#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.02707751f, 0.03981296f, -0.11023965f, -0.36606434f, -0.12878755f, 0.20125560f, -0.25802821f, -0.12298491f, 
    0.14513969f, 0.19940953f, 0.21706700f, -0.02297012f, -0.04128487f, 0.07596080f, -0.03534619f, -0.38195258f, 
    -0.09776829f, 0.21733214f, -0.23809436f, 0.06543413f, 0.09864359f, 0.33721051f, 0.00922435f, 0.32441399f, 
    0.24344355f, -0.30420035f, -0.58624184f, -0.72029871f, -0.57745546f, -0.58843464f, 0.48652110f, 0.58603340f, 
    0.18031664f, -0.54407436f, 0.10481719f, -0.29081780f, -0.20600058f, -0.44042489f, 0.02559687f, -0.08962326f, 
    0.11175577f, 0.13189507f, -0.01860491f, 0.21445094f, -0.17278080f, -0.22247998f, -0.13343623f, -0.10535385f, 
    -0.29259008f, -0.13170949f, -0.41253850f, -0.15846798f, 0.49959010f, -0.06645589f, -0.22539686f, 0.01013681f, 
    0.42591891f, 0.01767653f, 0.05530940f, 0.16985625f, -0.33856875f, -0.15612271f, 0.19275576f, 0.21864359f, 
    0.00828322f, -0.12706745f, 0.02670658f, -0.50765067f, 0.34587440f, -0.29943109f, -0.20432663f, 0.02812353f, 
    0.23453023f, 0.01129709f, 0.21070236f, -0.53110212f, -0.04746347f, 0.07381734f, 0.10866900f, 0.52912033f, 
    0.42465469f, 0.42781213f, 0.02449100f, 0.00358505f, -0.26434892f, 0.19495144f, 0.23149407f, 0.17799537f, 
    -0.20829682f, -0.11184414f, -0.39687675f, 0.13915867f, 0.30070895f, -0.16515702f, -0.16859460f, -0.08690679f, 
    -0.08416701f, 0.17037649f, 0.05433130f, 0.20232168f, -0.59446114f, -0.16264223f, -0.12747358f, 0.42389101f, 
    0.45410648f, -0.62358123f, -0.42114913f, 0.70844650f, -0.18055707f, -0.00804781f, 0.17293541f, -0.09597616f, 
    0.32679167f, -0.19366077f, -0.07115455f, 0.05439976f, -0.02952324f, 0.05442447f, -0.00349408f, -0.36496916f, 
    0.03793232f, -0.17924775f, 0.21964329f, 0.16876319f, 0.30786428f, 0.82208192f, 0.60210675f, -0.19354105f, 
    -0.65719295f, 0.31179613f, -0.25698453f, -0.43803132f, -0.08882944f, -0.63840419f, -0.75892764f, 0.18536228f, 
    -0.01499266f, 0.23490977f, 0.11306664f, -0.19978844f, 0.18612029f, 0.17960118f, 0.16397214f, -0.23199438f, 
    -0.06199636f, -0.18361245f, -0.05919952f, 0.30502579f, 0.01552103f, -0.01774684f, 0.50681490f, 0.66770989f, 
    0.10476816f, -0.11212017f, -0.12887768f, -0.57747877f, -0.02641595f, -0.10259750f, -0.07945170f, 0.49964657f, 
    -0.01743544f, 0.50294620f, -0.19451469f, -0.27749124f, -0.18206067f, -0.15512052f, -0.06698387f, -0.02930690f, 
    0.11986423f, -0.06601814f, 0.09832156f, 0.07517102f, -0.01001926f, 0.07247410f, -0.07725023f, -0.49654365f, 
    -0.42067039f, -0.37018958f, -0.43595740f, -0.29130277f, -0.22116540f, -0.36438653f, -0.08143543f, -0.29237062f, 
    -0.33022383f, 0.19108385f, -0.03487530f, 0.30710742f, 0.21444049f, 0.21787170f, -0.01979186f, -0.24479476f, 
    -0.02580772f, -0.05005690f, 0.12014130f, 0.21271634f, 0.17444809f, 0.24977548f, -0.01613943f, 0.33948466f, 
    0.62892562f, 0.48056343f, -0.01975022f, -0.51674861f, -0.29676190f, 0.10074212f, 0.04678187f, -0.02481108f, 
    -0.13973144f, -0.13631813f, 0.20074466f, -0.01283997f, 0.22890075f, -0.30888107f, -0.25055107f, 0.00401497f, 
    0.22559638f, -0.05758143f, -0.04136969f, -0.34390587f, -0.12857074f, -0.05299632f, -0.28197464f, -0.23184399f, 
    -0.49394971f, -0.15172391f, -0.85632855f, -0.77400529f, 0.26527208f, 0.15591380f, 0.47703257f, 0.14460720f, 
    0.06897379f, 0.33441529f, 0.44378278f, 0.28592139f, 0.20331158f, -0.10399305f, -0.17122734f, -0.00115925f, 
    -0.00219197f, 0.00412057f, 0.19257642f, -0.11708830f, -0.35501343f, -0.15260869f, 0.30082580f, -0.10841794f, 
    -0.20316447f, 0.14945891f, -0.68753517f, -0.24972360f, 0.29364339f, 0.51597106f, 0.08849564f, -0.29474854f, 
    -0.50633627f, -0.68542230f, -0.42412767f, 0.00796969f, -0.00616312f, 0.52614862f, 0.04768011f, 0.02702230f, 
    -0.04400354f, -0.23660569f, -0.18726479f, 0.17285401f, -0.31954500f, -0.38317910f, 0.00406551f, 0.04965263f, 
    -0.22582473f, -0.17997161f, -0.46585500f, -1.21360898f, -0.26813379f, 0.23774463f, 0.61250186f, 0.27356514f, 
    -0.16393580f, 0.02120084f, 0.18911646f, 0.43412378f, -0.10094902f, -0.25915697f, -0.25267383f, -0.23203814f, 
    0.40984631f, -0.05938929f, 0.34002978f, 0.00992734f, -0.05986443f, -0.27635193f, -0.01759238f, -0.30582199f, 
    -0.12326612f, 0.03536497f, -0.19661441f, -0.32278094f, -0.97433048f, 0.15094319f, -0.44227707f, -0.77260864f, 
    -0.83433276f, 0.39904067f, 0.34204233f, 0.11153673f, 0.32224616f, 0.57903343f, -0.08501182f, 0.06910954f, 
    -0.07367331f, 0.01064567f, 0.00898071f, -0.04194811f, -0.11349067f, -0.18923190f, 0.04977369f, -0.31237787f, 
    -0.15801993f, 0.13582438f, -0.02242729f, 0.05809548f, -0.05138375f, 0.55746049f, 0.60353488f, 0.23933174f, 
    0.15666017f, -0.22299844f, -0.29177389f, -0.34405300f, 0.17701845f, 0.14221512f, -0.26556683f, -0.05243969f, 
    -0.04570039f, 0.20014518f, -0.21827941f, -0.07956412f, -0.03922969f, 0.08967479f, -0.10259895f, -0.16331030f, 
    0.15596932f, 0.33479539f, -0.31167302f, -0.22094211f, 0.27088797f, -0.21589743f, -0.97742164f, 1.06650364f, 
    -0.24333256f, -0.90872455f, 0.56362319f, 0.12158070f, 0.27658033f, -0.05637941f, -0.03677520f, -0.28674316f, 
    -0.05144029f, 0.25397062f, 0.18711296f, -0.27396291f, -0.07156029f, 0.12889743f, 0.20777115f, -0.02194155f, 
    -0.04295564f, -0.05162973f, 0.19874772f, -0.00645667f, -0.33454230f, -0.25797275f, -0.06540916f, -0.70338470f, 
    -0.60799402f, -0.54601467f, 0.36928809f, 0.53561890f, -0.49225914f, -0.48976836f, -0.46315858f, -0.09784316f, 
    -0.20392604f, 0.07908513f, -0.62077540f, -0.14308175f, 0.28047463f, -0.33905619f, -0.17202614f, -0.09201904f, 
    -0.04052524f, -0.38411722f, -0.27279699f, -0.10276205f, -0.01614721f, -0.03351656f, 0.02477492f, -0.03525084f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.08913808f, -0.31515446f, 0.24819882f, -0.11916102f, 0.19272280f, 0.12228643f, 0.08802912f, -0.14625032f, 
    0.17120633f, 0.15770379f, -0.18335438f, 0.06445605f, 0.36631358f, 0.27581206f, 0.10294028f, 0.13077752f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.07774618f, 0.03889107f, 0.01303306f, -0.07626616f, -0.07833640f, -0.03652637f, 0.03170099f, 0.02358081f, 
    -0.01387479f, -0.02857817f, 0.05327102f, -0.00232233f, -0.00622236f, -0.00585119f, -0.06011323f, -0.07857154f, 
    0.02824263f, -0.08495707f, -0.01530941f, -0.08368039f, -0.07661039f, -0.06211821f, -0.04232377f, -0.05500323f, 
    -0.05146850f, 0.04914057f, -0.03193188f, 0.00683651f, -0.08146948f, 0.04126380f, 0.03685128f, 0.01077953f, 
    -0.06423963f, -0.02050888f, -0.02414320f, 0.03782990f, 0.04083392f, -0.00827651f, -0.05089208f, -0.07335974f, 
    0.04572800f, 0.00395234f, 0.02131232f, -0.05088927f, -0.07876710f, 0.03714573f, -0.06098412f, 0.02503929f, 
    -0.07339364f, 0.00885615f, -0.04285076f, 0.02725998f, 0.01968714f, -0.04638818f, 0.02135507f, 0.02146184f, 
    -0.03009865f, -0.00499781f, 0.04862577f, 0.05033909f, -0.01634885f, 0.04002371f, -0.03931731f, -0.08616824f, 
    -0.04213947f, -0.05202851f, 0.04575386f, -0.06304078f, -0.06742928f, 0.06053610f, -0.07189763f, 0.04154263f, 
    0.01059296f, -0.07496593f, -0.00245026f, 0.02464422f, -0.01088536f, 0.05025386f, -0.04926272f, -0.05570234f, 
    -0.00756456f, -0.02599809f, -0.04405746f, 0.00287814f, 0.00642078f, 0.03279640f, 0.01613320f, 0.04526519f, 
    0.02496946f, 0.04092765f, 0.02796317f, -0.01209789f, 0.00660115f, -0.03920731f, -0.03855725f, -0.05509654f, 
    -0.05578585f, -0.01246465f, -0.01052187f, 0.01410818f, 0.01119141f, -0.02185676f, -0.00936471f, -0.05762509f, 
    -0.02415391f, 0.01047144f, 0.05520163f, -0.02333447f, -0.03919811f, -0.08247743f, 0.00286474f, -0.04425101f, 
    -0.03156880f, 0.00429206f, -0.02723575f, 0.01340958f, 0.01740236f, 0.01436000f, -0.03435534f, -0.01140849f, 
    -0.06948406f, -0.01589172f, -0.02082730f, 0.01055581f, 0.05379109f, 0.04535433f, 0.03409871f, -0.04816123f, 
    0.03535492f, 0.01909173f, 0.04775443f, -0.01763339f, 0.03555433f, -0.04594446f, -0.04654127f, 0.03648803f, 
    0.01728068f, -0.00837164f, 0.01521912f, -0.07298746f, 0.05577635f, -0.08605894f, 0.01970227f, 0.00828180f, 
    0.05327008f, -0.06508804f, 0.00570182f, -0.03529470f, -0.07144146f, -0.00362669f, -0.05031026f, -0.04149378f, 
    -0.00400625f, -0.06940144f, 0.02208943f, -0.05992764f, 0.05169435f, -0.02214128f, -0.01099274f, 0.01882003f, 
    -0.00246620f, -0.05368982f, 0.01948138f, -0.04041703f, -0.00716212f, 0.01023362f, 0.03051553f, -0.08185644f, 
    0.04142852f, 0.03005126f, -0.00773138f, -0.01328467f, 0.01684118f, 0.04395808f, -0.01719536f, -0.04710082f, 
    -0.04537661f, -0.04715188f, -0.03344521f, -0.01605511f, 0.03990773f, 0.01686314f, -0.07782812f, -0.08455588f, 
    -0.02003351f, 0.02614895f, -0.01350814f, -0.01019673f, 0.02521939f, -0.04109996f, -0.06586150f, 0.01493076f, 
    0.13831732f, 0.06982232f, -0.05542855f, -0.02617808f, -0.12987204f, -0.14659306f, 0.12105776f, -0.04923688f, 
    -0.09782863f, -0.01986726f, -0.06370445f, 0.04389067f, -0.12460262f, 0.02848349f, -0.05216260f, 0.09552450f, 
    0.03124318f, -0.03894457f, -0.10969507f, -0.06428512f, -0.02431350f, 0.07412745f, 0.05397060f, -0.16333573f, 
    0.10522547f, 0.10435529f, 0.07527767f, -0.17867160f, -0.07762824f, -0.04182916f, 0.05377127f, -0.07436179f, 
    0.05157192f, 0.27003267f, 0.12596546f, 0.08317238f, -0.11075523f, 0.22674060f, 0.00008596f, -0.11376672f, 
    -0.07883329f, -0.01812270f, -0.10769541f, -0.04293761f, -0.01469351f, 0.28574568f, 0.03846693f, -0.02403687f, 
    -0.07729603f, -0.19173335f, 0.12878147f, 0.05893524f, 0.22322129f, 0.03231452f, -0.12968259f, 0.10080823f, 
    -0.05163565f, -0.00697921f, -0.01751497f, -0.09596878f, 0.15052542f, -0.11352193f, 0.25430274f, 0.09334276f, 
    -0.04871099f, 0.28085834f, -0.21734244f, 0.18790707f, -0.09083541f, -0.01111906f, -0.00510812f, 0.04901387f, 
    0.20184629f, 0.26799944f, 0.21770416f, 0.18230659f, -0.02064647f, 0.02455455f, -0.13249539f, -0.02760330f, 
    0.04901861f, -0.01256792f, -0.08074901f, -0.11226059f, -0.19290233f, -0.02963450f, 0.25754938f, 0.11020717f, 
    0.10542558f, 0.02213013f, 0.04388505f, 0.06380770f, -0.00731847f, 0.01898939f, -0.02719207f, -0.00766699f, 
    0.23677239f, 0.10894839f, 0.13780783f, -0.05974111f, -0.04698630f, -0.00496454f, 0.00993328f, 0.07904186f, 
    0.11946269f, -0.07413533f, 0.09825540f, -0.16107491f, -0.20872428f, -0.05948496f, -0.15515056f, -0.06548644f, 
    -0.00435878f, -0.09851853f, -0.03533907f, -0.01968501f, -0.06212835f, -0.04654501f, 0.19989152f, -0.10828314f, 
    -0.19676699f, -0.21884863f, -0.00629220f, 0.32258254f, 0.05328040f, 0.00986173f, 0.03617691f, -0.00296831f, 
    0.02758754f, 0.10328884f, 0.09596291f, -0.02717324f, -0.01587586f, 0.28441796f, -0.07106402f, 0.04675760f, 
    0.05046711f, -0.03693209f, -0.12792070f, -0.00231565f, -0.12357390f, -0.05486181f, -0.06576165f, -0.06938323f, 
    0.20496112f, 0.12265048f, 0.07895979f, -0.13826653f, -0.05805004f, -0.30624941f, 0.00986090f, 0.10007898f, 
    0.10251770f, 0.11668215f, -0.00097112f, -0.04880097f, 0.39894530f, 0.08619574f, 0.06207135f, -0.18395518f, 
    -0.07386974f, 0.00654995f, -0.02808580f, 0.06581920f, -0.01698591f, 0.08518435f, 0.02924471f, -0.01438418f, 
    0.07227588f, -0.15729623f, 0.46899340f, -0.28677443f, 0.08857770f, -0.11549050f, 0.17142871f, 0.06100493f, 
    0.10931802f, -0.10327885f, 0.02973359f, -0.15013200f, -0.22981375f, 0.10735970f, -0.05109206f, 0.36610508f, 
    -0.09242510f, 0.01942574f, 0.09910527f, -0.02176476f, 0.03837930f, 0.22007786f, 0.02011566f, -0.07228270f, 
    -0.02273631f, 0.05648793f, -0.07661366f, -0.06606625f, -0.00859340f, -0.01666276f, 0.02067195f, 0.03454003f, 
    -0.04362559f, 0.01588549f, 0.04945853f, -0.06533965f, -0.03973156f, -0.00703643f, 0.01710805f, 0.03986154f, 
    -0.02069777f, 0.06097569f, -0.02498939f, -0.04753802f, 0.04087164f, -0.02029935f, -0.03873358f, -0.04280280f, 
    -0.00278077f, -0.01710368f, 0.00530866f, -0.02814492f, 0.04003433f, 0.01949876f, -0.04266826f, -0.03559352f, 
    0.04482381f, -0.05429696f, 0.03231872f, -0.02041247f, 0.02244723f, -0.02208167f, 0.06148392f, 0.03660972f, 
    -0.03045388f, -0.01368325f, -0.03917238f, -0.01467773f, 0.06940632f, 0.01578676f, -0.04899018f, -0.00780819f, 
    -0.05692817f, -0.00117552f, -0.07370267f, 0.04898250f, 0.00823616f, -0.02298432f, -0.02681047f, 0.02449475f, 
    0.00315277f, -0.01132807f, -0.05364099f, -0.02764840f, -0.02328025f, -0.05480891f, -0.03938165f, -0.03597981f, 
    0.03431336f, -0.02824903f, -0.03224371f, 0.01998583f, 0.02312714f, -0.05881709f, -0.03744400f, 0.01684385f, 
    0.04162420f, 0.02758163f, -0.01017339f, 0.02411826f, -0.03306092f, 0.05599895f, -0.01969723f, 0.02949390f, 
    -0.05722337f, -0.06263188f, 0.01130791f, -0.07452822f, -0.04706803f, 0.03731289f, -0.01288065f, -0.00175062f, 
    -0.00612016f, -0.02562436f, 0.00811318f, 0.05956819f, -0.02312443f, 0.04931675f, 0.02591889f, 0.03181341f, 
    -0.01939233f, -0.03284639f, 0.05618249f, 0.01111203f, 0.03361326f, -0.03468499f, -0.02341071f, 0.01301636f, 
    0.04677955f, -0.00032866f, 0.01709980f, -0.06975117f, -0.04412686f, -0.04096865f, -0.02657593f, -0.02868479f, 
    -0.06576312f, 0.00859767f, -0.04232386f, -0.00399242f, -0.03478086f, 0.06467027f, -0.02076912f, -0.03209563f, 
    -0.03621248f, 0.01043438f, 0.03966524f, -0.03302879f, -0.02228417f, 0.00277172f, -0.06845742f, 0.04455282f, 
    -0.04397171f, -0.06494508f, -0.06578302f, 0.01881055f, 0.06323408f, 0.00564598f, -0.06983838f, -0.00627458f, 
    -0.05704996f, -0.01050282f, 0.02927787f, -0.04923073f, -0.07894281f, -0.00429693f, 0.05849122f, 0.05213224f, 
    -0.03180851f, 0.00176562f, -0.03198427f, -0.03510012f, -0.05909573f, 0.05587376f, 0.04004250f, -0.03131660f, 
    -0.02577841f, 0.00482950f, 0.00951622f, -0.04690366f, -0.05914374f, -0.04259963f, 0.01682426f, 0.03417983f, 
    -0.00310427f, -0.07449845f, -0.06529256f, 0.00014047f, 0.03530226f, 0.00357770f, -0.02685794f, -0.01572343f, 
    -0.02714250f, -0.07495228f, 0.03750259f, 0.04809218f, 0.05262671f, -0.04595950f, 0.01286128f, 0.02050773f, 
    -0.01327095f, 0.01983160f, 0.05706320f, -0.05099363f, -0.04267135f, 0.01421045f, 0.03386716f, 0.04737679f, 
    -0.02396103f, 0.06383770f, -0.03854815f, 0.00078842f, 0.04304270f, 0.01047255f, -0.03040593f, 0.04364370f, 
    -0.07252480f, 0.03328629f, 0.13467096f, -0.03941017f, 0.09227741f, -0.02511776f, -0.08830784f, 0.21735317f, 
    -0.29625279f, -0.24026580f, -0.28730354f, -0.37036574f, 0.23136769f, 0.16894887f, 0.29769447f, 0.34816316f, 
    0.28317419f, 0.25781447f, 0.02623127f, -0.01911332f, 0.08776985f, 0.08233912f, 0.06337389f, 0.22108334f, 
    0.05641366f, -0.03990093f, -0.01248634f, -0.01703010f, -0.02571445f, 0.19591868f, -0.13278170f, -0.23731257f, 
    -0.09729824f, -0.29712749f, 0.11059432f, -0.16511571f, -0.22522108f, -0.09257876f, -0.45450503f, -0.09829863f, 
    0.07834718f, -0.00378434f, 0.07137625f, -0.00782873f, -0.09682249f, 0.08724952f, -0.23852371f, -0.18644743f, 
    -0.06695236f, 0.08832138f, -0.13161407f, -0.03994517f, -0.14875109f, -0.04747875f, 0.17267494f, -0.22327553f, 
    -0.23797123f, -0.05891924f, 0.04320874f, -0.16216819f, 0.16115007f, 0.23453957f, 0.08982621f, 0.12712926f, 
    -0.08108274f, 0.01229494f, 0.07709736f, -0.03031669f, 0.00460028f, 0.10697775f, 0.03149067f, 0.03735295f, 
    -0.40180430f, -0.45915529f, -0.13697657f, -0.18445355f, 0.19315733f, 0.07674860f, -0.12095556f, 0.05379992f, 
    -0.34818900f, -0.02684597f, -0.14400485f, 0.10130857f, 0.22319645f, 0.28405198f, -0.00753101f, 0.13038865f, 
    0.01128079f, 0.06225438f, 0.17007987f, 0.02868570f, -0.07825664f, 0.00622009f, -0.00071608f, -0.16036320f, 
    -0.11285602f, -0.13244115f, -0.00002541f, 0.03144258f, -0.10061619f, -0.11024702f, -0.03367853f, -0.09377526f, 
    0.03814365f, 0.23071647f, 0.08926140f, 0.45949754f, 0.02575847f, 0.18944030f, -0.25432563f, 0.12550041f, 
    0.03703275f, -0.03069046f, 0.18932331f, -0.06599071f, 0.06049266f, -0.04732467f, -0.11070345f, -0.00299800f, 
    0.04143208f, 0.27764085f, -0.07202132f, 0.13647912f, 0.05326544f, -0.02849849f, -0.04041421f, 0.03148272f, 
    0.01258044f, 0.13890018f, 0.06860770f, 0.15647419f, -0.09514242f, -0.25833702f, 0.06874825f, -0.12789856f, 
    0.04347545f, 0.00396663f, 0.06411828f, -0.05034089f, 0.13902903f, 0.25271112f, 0.08769794f, 0.19166638f, 
    0.44624361f, 0.23098888f, 0.13670339f, 0.35004488f, 0.19979621f, 0.11785423f, -0.19989999f, -0.06973456f, 
    0.07455748f, -0.12225436f, 0.06474252f, 0.21814340f, -0.31283146f, -0.05914219f, 0.00259797f, -0.17546587f, 
    0.01145889f, -0.12663250f, -0.06486951f, -0.16942927f, -0.05695835f, 0.10856194f, -0.06870078f, 0.05749607f, 
    0.05637791f, -0.34324768f, -0.31035429f, 0.43772253f, 0.02393156f, -0.03365253f, -0.16194105f, -0.02199754f, 
    0.24449751f, 0.20218445f, 0.00826079f, 0.09804060f, 0.15730332f, -0.13706365f, 0.30191371f, -0.01182889f, 
    0.09769467f, -0.02255732f, -0.04754853f, -0.08101565f, -0.05315984f, -0.08362802f, -0.02777062f, -0.09770907f, 
    0.00002563f, -0.03989475f, -0.01991834f, -0.01766932f, 0.01265995f, 0.01977669f, -0.01459521f, -0.02900058f, 
    0.04891434f, -0.05873027f, 0.01820746f, -0.04867839f, -0.05397050f, 0.03119341f, -0.01506485f, 0.01403948f, 
    -0.06045398f, 0.00083719f, 0.04928969f, -0.03153731f, -0.00373284f, 0.06885368f, -0.01668347f, 0.00818293f, 
    0.01476899f, 0.01519026f, 0.03787002f, -0.06480278f, -0.00916123f, 0.05102903f, -0.02732456f, 0.03686243f, 
    0.00063982f, 0.03062421f, 0.06152680f, 0.03625590f, -0.02649941f, 0.06783239f, -0.06905328f, -0.01081530f, 
    0.00851115f, -0.05580196f, -0.06919108f, -0.02169976f, 0.02894701f, 0.06048883f, -0.01298963f, 0.00744426f, 
    -0.05957597f, -0.06781403f, 0.02092474f, 0.06247563f, -0.01525080f, 0.05581503f, 0.00979433f, -0.00559107f, 
    0.02724306f, -0.04739889f, 0.05555915f, 0.01899231f, -0.04260111f, -0.03673862f, -0.02180470f, -0.03849917f, 
    -0.02792279f, -0.03465278f, 0.02412528f, 0.05361988f, 0.01458196f, -0.00858108f, 0.05693635f, 0.04316162f, 
    0.06985535f, -0.04741998f, 0.02145894f, -0.01638067f, -0.01379885f, 0.04744513f, -0.00251784f, -0.04918497f, 
    -0.03206709f, -0.00802017f, 0.01324195f, -0.00493885f, 0.06626273f, 0.05702930f, -0.05851860f, 0.01988575f, 
    -0.06589519f, 0.03518876f, -0.01837313f, -0.00252459f, -0.06715931f, 0.03351409f, -0.02319896f, -0.02624742f, 
    0.01992344f, 0.06762975f, -0.07136106f, -0.03342520f, 0.05946922f, 0.04898508f, -0.06325082f, -0.04765192f, 
    0.05757235f, -0.01075321f, 0.04719459f, -0.05388561f, -0.00477665f, -0.06440365f, -0.06217969f, -0.03269216f, 
    0.02531107f, -0.04601309f, 0.05889254f, -0.01645117f, -0.06287216f, 0.06352694f, 0.05995557f, -0.03139456f, 
    -0.05467936f, 0.05129773f, -0.01229533f, -0.05428905f, 0.04138176f, 0.04969427f, 0.01091998f, -0.05950699f, 
    -0.06240604f, 0.00046609f, 0.03196367f, -0.02773237f, -0.05096225f, 0.05769323f, -0.04112943f, 0.05570172f, 
    0.06371537f, 0.02188884f, 0.02132825f, -0.04365789f, 0.01725666f, 0.04975261f, -0.04339997f, -0.05035086f, 
    -0.04310233f, -0.04028517f, -0.04104016f, -0.03939259f, 0.01037557f, -0.05600257f, -0.06799672f, -0.06708908f, 
    -0.01485449f, -0.05851267f, 0.03911459f, -0.03381206f, -0.04854259f, -0.02968334f, -0.03583479f, -0.06215736f, 
    -0.02346871f, -0.02564194f, -0.01637010f, -0.05238152f, -0.06224167f, 0.05208180f, -0.06280895f, -0.01683239f, 
    0.03769502f, -0.04160127f, 0.04471834f, -0.05468497f, -0.01988772f, -0.05307514f, -0.06804004f, -0.03208932f, 
    -0.04902158f, -0.00248927f, -0.04968134f, -0.03323650f, 0.05921842f, 0.03669022f, -0.02051128f, 0.06214226f, 
    0.06068861f, -0.03899567f, -0.05520708f, 0.00309232f, 0.01863631f, -0.00941546f, -0.00281235f, -0.06121204f, 
    0.12074947f, -0.02085571f, 0.02137938f, -0.04175387f, -0.18050526f, 0.07939848f, 0.03264342f, -0.08236101f, 
    0.13084123f, -0.09542124f, 0.05833280f, -0.05531806f, 0.14248008f, 0.11279653f, 0.04007273f, -0.27052259f, 
    0.05756506f, 0.02241816f, 0.03240483f, 0.16180755f, -0.06467275f, -0.01454707f, -0.11406090f, 0.03924932f, 
    0.07538106f, 0.10575815f, -0.07296862f, 0.16027056f, 0.01216236f, 0.06322215f, -0.01489009f, 0.00679670f, 
    -0.01421415f, 0.14116938f, -0.10075527f, 0.04807765f, 0.32711625f, 0.10670251f, 0.07961678f, 0.05165822f, 
    0.07997108f, -0.00100332f, -0.02961995f, -0.01094939f, 0.07916966f, -0.28299922f, -0.00348470f, -0.23131715f, 
    -0.03263780f, 0.13565628f, 0.22286651f, 0.05301774f, 0.08154580f, -0.14126584f, 0.00967421f, 0.01471554f, 
    0.01861451f, -0.14931253f, -0.03936476f, -0.06240625f, 0.00374027f, 0.37483069f, -0.29937723f, -0.10723327f, 
    0.11190785f, -0.03878768f, 0.13795145f, 0.09771460f, -0.03602404f, 0.03987999f, 0.06418143f, 0.01436663f, 
    -0.13089064f, -0.21030134f, -0.16276602f, -0.03604893f, 0.09310899f, 0.03560155f, -0.04697737f, -0.02180731f, 
    0.08342175f, 0.01347268f, 0.05232695f, 0.05666576f, 0.02965918f, 0.19810541f, -0.03117635f, -0.13395301f, 
    0.12474420f, -0.03764351f, 0.05015670f, 0.09133777f, 0.09781450f, 0.09032799f, 0.00414553f, 0.12006760f, 
    0.00162572f, 0.10700986f, -0.15640081f, 0.02413577f, 0.12283141f, 0.07827562f, 0.03365904f, -0.06055151f, 
    -0.01497285f, -0.08016819f, 0.03163342f, -0.00161086f, 0.60653400f, -0.12356056f, 0.14180656f, -0.24056375f, 
    -0.05744884f, 0.05651058f, 0.03238508f, 0.00564166f, 0.06511924f, -0.11200029f, -0.04775299f, -0.01787059f, 
    0.12788479f, 0.17860967f, 0.23059270f, -0.06562024f, -0.07305589f, 0.06490487f, 0.03842888f, -0.17595053f, 
    0.11349324f, -0.02232463f, -0.05527527f, -0.09410203f, 0.00164319f, -0.39294794f, 0.26101413f, 0.20095782f, 
    -0.00241820f, -0.11707507f, 0.01523523f, -0.01123807f, 0.09244809f, 0.02987284f, -0.03851368f, -0.06730642f, 
    -0.28166571f, -0.10767870f, -0.14802364f, -0.10160348f, 0.01559836f, 0.02819782f, -0.03051633f, -0.13422504f, 
    0.03776223f, -0.04985341f, -0.01187137f, 0.01659035f, -0.08030635f, 0.10477901f, -0.39692026f, 0.20492880f, 
    0.11024273f, 0.10281422f, -0.05346663f, -0.10980454f, 0.08680239f, -0.07993192f, 0.08008581f, 0.05646874f, 
    -0.20017880f, 0.38079926f, -0.33914778f, 0.13792749f, -0.06751326f, 0.06558054f, 0.02919232f, 0.01982665f, 
    0.07361462f, -0.01382983f, -0.14406858f, 0.05002713f, 0.30351445f, 0.14196053f, 0.24851319f, -0.04658965f, 
    0.09236243f, 0.09058588f, 0.14400537f, 0.08359601f, 0.01601172f, -0.02992891f, -0.23191029f, 0.11165301f, 
    -0.04630977f, 0.07067584f, 0.03593649f, 0.02686092f, 0.08848993f, -0.06100704f, -0.05625575f, 0.11038803f, 
    -0.11717309f, 0.08662392f, 0.06669176f, -0.00505995f, 0.14750369f, 0.21581079f, 0.25753570f, 0.02356617f, 
    0.04568907f, 0.03712164f, 0.00866321f, -0.18960136f, -0.05843330f, -0.06358902f, 0.07045560f, -0.13908622f, 
    0.09686874f, -0.16427913f, 0.09919823f, -0.01667747f, -0.01574710f, 0.07368206f, 0.16248788f, 0.05495404f, 
    0.17941754f, 0.13830371f, 0.05924034f, 0.19366421f, -0.08051021f, 0.00260498f, 0.08315033f, -0.00901886f, 
    -0.09841331f, 0.03841387f, -0.05922774f, -0.01108202f, 0.18207672f, 0.23109420f, -0.07871016f, -0.06992242f, 
    -0.27755690f, -0.01278324f, 0.05427811f, -0.02454114f, -0.02505855f, -0.06397490f, 0.01641708f, 0.05185718f, 
    -0.05333793f, 0.14822094f, 0.00707173f, 0.17305236f, 0.24700467f, -0.02967758f, 0.13147421f, -0.49299306f, 
    0.00504073f, 0.03653356f, 0.12007114f, -0.26194227f, -0.12013464f, 0.00182461f, 0.02559851f, 0.14688747f, 
    0.59428436f, -0.04169775f, -0.06790465f, 0.23866361f, 0.06633587f, -0.07876761f, -0.00671836f, 0.01154005f, 
    -0.08350435f, 0.02468264f, -0.01930221f, -0.03254639f, -0.20800488f, -0.02408931f, -0.06170226f, -0.13216373f, 
    0.04241676f, 0.02027752f, 0.12817842f, -0.15736413f, -0.14317107f, -0.03428637f, -0.04680275f, 0.00861210f, 
    0.25099126f, -0.20376837f, 0.02978401f, -0.23462792f, 0.02584925f, 0.01006829f, 0.02114381f, 0.09138469f, 
    -0.00104951f, 0.12550570f, -0.03451265f, 0.08734288f, -0.10626762f, 0.01570373f, -0.12558961f, -0.06493799f, 
    -0.11199505f, -0.01564597f, 0.03762642f, 0.01067449f, 0.13723330f, -0.00709749f, 0.11757190f, 0.06952036f, 
    -0.38924366f, -0.13663885f, -0.15076673f, 0.05227489f, -0.17031415f, 0.05157114f, 0.05978644f, 0.05484014f, 
    -0.01544876f, -0.01360603f, -0.06509917f, -0.00189941f, -0.25488967f, -0.26760709f, 0.06896240f, -0.24004607f, 
    0.09827982f, 0.09034281f, -0.05554573f, 0.01027968f, 0.01506380f, 0.01250311f, -0.01489108f, 0.06906807f, 
    -0.27752927f, 0.32135066f, 0.15461828f, -0.02785723f, 0.01672869f, -0.09337737f, -0.20032741f, 0.15322648f, 
    0.07950211f, 0.13705343f, 0.04668657f, -0.06449521f, 0.55458421f, 0.08388095f, 0.42724597f, 0.00422198f, 
    0.00855761f, -0.08495024f, 0.16181608f, -0.16083032f, -0.02477344f, 0.02092306f, -0.01360218f, 0.10114848f, 
    -0.20039049f, -0.17651841f, 0.15930033f, -0.16378191f, 0.05503781f, 0.05845334f, -0.01729756f, 0.29258019f, 
    -0.04083866f, 0.02570190f, -0.05250312f, -0.00945167f, -0.22482532f, -0.04653671f, 0.21900441f, 0.01152944f, 
    -0.04559017f, -0.09760904f, 0.21110170f, -0.14894718f, 0.07665465f, 0.01546333f, 0.01148838f, -0.04990607f, 
    0.02148267f, -0.01331010f, 0.01972259f, -0.05306520f, -0.07214604f, -0.03409114f, 0.02612341f, -0.00747073f, 
    -0.04003940f, -0.05440925f, 0.05755755f, -0.04327406f, -0.07207237f, 0.02646402f, -0.06860831f, -0.07579257f, 
    0.05823762f, -0.03696636f, -0.02913348f, -0.01275325f, 0.03409829f, 0.01730381f, -0.02406827f, -0.02500891f, 
    0.03438454f, -0.04973447f, -0.02932599f, -0.01178694f, -0.02511433f, 0.04222533f, -0.07127517f, -0.05955781f, 
    -0.06671908f, -0.03551896f, 0.01454417f, 0.05638163f, -0.04761575f, -0.04912040f, -0.07354988f, 0.03525592f, 
    0.03086011f, -0.06258085f, -0.02363199f, -0.06816964f, -0.06102733f, -0.05346151f, -0.03920759f, -0.07107617f, 
    0.01581605f, -0.06316984f, 0.00097782f, -0.04570656f, -0.04241263f, -0.00768198f, -0.05224512f, -0.04005147f, 
    -0.05047831f, 0.04877205f, 0.05115302f, -0.00741494f, -0.06965303f, 0.02160035f, 0.03542124f, 0.02655161f, 
    -0.02682668f, 0.03747355f, 0.05208425f, -0.06321827f, -0.04115318f, -0.04283534f, -0.00640151f, 0.00002679f, 
    -0.06971367f, -0.02360296f, 0.00324840f, -0.01888773f, 0.03837476f, 0.01028340f, 0.06188275f, -0.05202762f, 
    0.04249444f, 0.05898716f, 0.02235970f, -0.03667280f, -0.06652231f, 0.00426509f, -0.08213238f, -0.00196670f, 
    0.04392615f, 0.04478765f, -0.06436174f, 0.00403468f, 0.00089092f, 0.00367418f, -0.03038714f, -0.00345071f, 
    -0.02478100f, 0.02760550f, -0.03221126f, -0.06820233f, -0.06831312f, -0.06512770f, 0.03996114f, 0.04464119f, 
    -0.00487956f, 0.03129080f, -0.05390073f, -0.04671935f, 0.01494555f, 0.01050498f, 0.01632210f, -0.04225988f, 
    -0.05247061f, 0.04683484f, 0.00227291f, 0.03867748f, 0.03774844f, -0.02011264f, 0.06018835f, -0.07824332f, 
    -0.06063585f, -0.02454641f, -0.03028656f, -0.00306690f, -0.02128274f, -0.01794559f, 0.05044563f, 0.06007063f, 
    -0.02619346f, -0.01127547f, -0.06965750f, -0.03177864f, 0.02975601f, -0.02444660f, -0.06167673f, 0.03512389f, 
    -0.01999845f, 0.05897006f, -0.04625604f, -0.02536875f, 0.00265899f, 0.05976121f, 0.02766363f, -0.03871354f, 
    -0.07402780f, -0.05379806f, -0.06472456f, -0.03857788f, -0.04726377f, -0.07927816f, -0.00872218f, 0.00041248f, 
    0.05821444f, 0.03697149f, -0.02018626f, 0.00557639f, -0.07771112f, 0.00508659f, -0.06967221f, -0.06703422f, 
    -0.07465681f, -0.06402723f, 0.03272941f, -0.00643308f, -0.06418113f, -0.02848855f, -0.03581095f, 0.03444858f, 
    -0.05007147f, -0.03424817f, 0.04972441f, 0.03317230f, 0.01693798f, 0.02299801f, 0.02123663f, -0.08130060f, 
    -0.01719242f, -0.07578465f, 0.00509992f, -0.00525005f, 0.00027297f, 0.02746988f, -0.02838190f, -0.07732281f, 
    0.01615867f, -0.06835010f, -0.03751336f, -0.07798411f, 0.03648065f, 0.01235524f, 0.05257552f, -0.08000351f, 
    -0.06080828f, -0.06357133f, 0.02625227f, -0.03777975f, -0.00449662f, 0.03632175f, -0.00158272f, -0.01865936f, 
    -0.00903547f, 0.05410849f, 0.01997900f, 0.01439620f, -0.06450316f, -0.01146384f, -0.04811632f, -0.06292006f, 
    0.04289774f, -0.00973606f, -0.01632659f, -0.01149843f, -0.04095265f, 0.00513483f, 0.00834281f, 0.06187178f, 
    -0.02996807f, -0.05163058f, -0.02287815f, -0.07334795f, 0.03203118f, -0.00167896f, -0.04087207f, 0.02525084f, 
    -0.05618297f, -0.02937855f, 0.03152870f, 0.06233125f, -0.04322283f, -0.02851285f, -0.01925540f, -0.01629030f, 
    -0.07170576f, -0.00775915f, -0.07495125f, -0.02228295f, -0.01594961f, -0.07567267f, 0.01224117f, 0.02204168f, 
    -0.05664422f, -0.01308262f, 0.02825902f, 0.00600494f, -0.07886661f, 0.04828544f, -0.04642203f, 0.05586317f, 
    0.04406897f, -0.07753535f, -0.05633549f, 0.01029880f, -0.06824253f, -0.01973380f, -0.04366197f, -0.01659215f, 
    -0.03158534f, -0.07659444f, -0.04955031f, 0.00603004f, -0.05015266f, -0.04809279f, -0.04272426f, -0.02177190f, 
    -0.01966151f, -0.01381444f, 0.05982899f, 0.02035659f, -0.03070913f, -0.03952057f, 0.02662230f, 0.04314425f, 
    0.01438527f, 0.06080148f, 0.02618616f, 0.03950126f, -0.01191347f, 0.04810580f, -0.07183031f, 0.04515881f, 
    0.01562876f, -0.06001623f, 0.02395635f, -0.04018005f, -0.01245833f, -0.01727957f, 0.03632720f, -0.02689935f, 
    0.05418053f, 0.03009391f, 0.02757222f, -0.00792458f, -0.04852324f, 0.00136780f, 0.03865097f, -0.05304287f, 
    -0.05565894f, 0.03815287f, -0.02117648f, 0.04909298f, -0.06774963f, -0.02926158f, 0.03520769f, -0.04976404f, 
    -0.01152517f, 0.01189739f, -0.06381740f, -0.04458194f, -0.01073928f, -0.06403004f, 0.01169472f, -0.03867386f, 
    0.00400733f, 0.06153953f, -0.04345845f, -0.04747725f, -0.03673026f, -0.04312137f, -0.04030485f, -0.05276485f, 
    -0.04830701f, 0.06524576f, -0.03965743f, 0.01569711f, 0.00129533f, -0.00855154f, -0.03983764f, 0.03128730f, 
    0.06825333f, -0.05281694f, 0.06566619f, -0.04929333f, -0.05983625f, 0.04759312f, 0.05417987f, -0.05128260f, 
    0.00536788f, -0.04612525f, 0.00802876f, -0.03664421f, -0.06474207f, -0.06049529f, -0.06739645f, 0.03420132f, 
    -0.06797875f, -0.02648910f, 0.04525026f, -0.03993915f, 0.01408022f, 0.05267205f, -0.04370324f, -0.04017398f, 
    -0.05694920f, 0.04996324f, 0.03124630f, 0.00675177f, 0.00924340f, -0.03469307f, -0.04137032f, -0.02581346f, 
    0.03299853f, 0.04686162f, 0.01251368f, 0.00568733f, 0.02118997f, -0.05898603f, -0.06840727f, -0.06403090f, 
    -0.06072251f, 0.03072493f, 0.05592703f, 0.00616671f, -0.05597997f, 0.00696595f, 0.05952119f, -0.01229845f, 
    0.01624679f, -0.02137942f, -0.02316065f, 0.02651200f, 0.00709109f, -0.04275812f, -0.01281696f, 0.01453053f, 
    -0.17056002f, 0.00795173f, -0.05449956f, 0.05769639f, 0.10260239f, 0.06282023f, -0.03331423f, 0.10763548f, 
    -0.11498633f, -0.10646790f, -0.03638946f, -0.05725928f, -0.20813112f, 0.09396200f, 0.27861211f, -0.05115404f, 
    -0.15694340f, -0.03103735f, -0.08760327f, -0.18141717f, -0.04138034f, -0.03875813f, 0.02688104f, 0.03372475f, 
    -0.06055833f, -0.05636414f, -0.10027669f, 0.03698941f, -0.03385167f, 0.00049179f, 0.05257780f, -0.00407059f, 
    0.07263500f, -0.01086509f, -0.17259151f, -0.03797490f, -0.08225854f, 0.06565379f, 0.02979780f, -0.04660034f, 
    0.01302685f, -0.13752596f, 0.04472825f, 0.09681264f, 0.05507166f, 0.24041587f, -0.05411673f, 0.15424709f, 
    -0.00704120f, -0.27820966f, 0.07188025f, -0.03642235f, -0.02192504f, -0.06055650f, -0.08781568f, 0.00935908f, 
    0.03295353f, -0.02523378f, -0.00646844f, 0.02182804f, 0.02063699f, 0.22021849f, 0.17533195f, -0.26014251f, 
    0.00978773f, 0.03497402f, 0.04722648f, -0.24763270f, -0.07917599f, -0.02603953f, 0.02648504f, -0.08617020f, 
    0.56050628f, -0.11294272f, 0.07903127f, 0.22680165f, 0.05612318f, -0.00661182f, -0.00563053f, 0.14642462f, 
    -0.12385282f, -0.13005066f, -0.04819244f, -0.06478307f, 0.00119574f, -0.01032748f, -0.04830704f, 0.06749524f, 
    -0.12828492f, 0.00644823f, 0.00003811f, -0.11137433f, 0.08244260f, -0.02233720f, -0.12411409f, -0.08087863f, 
    0.14928414f, -0.20642200f, 0.05692491f, -0.09053476f, 0.03261093f, -0.09105173f, -0.11450106f, -0.23815943f, 
    -0.04113979f, -0.08557725f, 0.09065572f, 0.03554004f, -0.26945654f, -0.08712775f, -0.33046973f, 0.21815138f, 
    -0.18671401f, 0.00736859f, 0.04951682f, 0.04794891f, 0.10305340f, -0.06054894f, 0.06438463f, 0.04187883f, 
    -0.09517861f, -0.12167035f, 0.11310069f, -0.05177752f, 0.05377781f, -0.13669010f, 0.06456648f, 0.10922972f, 
    0.03762978f, 0.01893139f, 0.15354693f, 0.04241752f, 0.01578666f, -0.40695709f, -0.01360023f, -0.19415878f, 
    0.01794243f, 0.06424078f, -0.03813367f, 0.05911342f, 0.19399907f, 0.06456937f, -0.01240029f, 0.10573721f, 
    -0.22441347f, 0.36247763f, 0.12666301f, 0.07987297f, -0.07271299f, -0.04058518f, 0.00491012f, 0.12633875f, 
    -0.02065489f, 0.08133311f, -0.01934816f, -0.00266934f, 0.32302219f, 0.15791342f, 0.40701661f, -0.05709414f, 
    0.03122118f, 0.04066825f, 0.16005892f, 0.10899148f, -0.08228669f, -0.00548063f, -0.01703200f, -0.02480308f, 
    -0.04462404f, -0.20101489f, -0.04245355f, -0.00711696f, 0.05590566f, -0.08700052f, -0.06969468f, 0.16490045f, 
    -0.02612757f, 0.09276636f, -0.00841532f, -0.13408916f, -0.08265314f, -0.10025398f, 0.21038041f, -0.13164423f, 
    -0.09476722f, 0.01185093f, -0.10153376f, -0.16657658f, 0.04514090f, 0.04166332f, 0.10001943f, 0.04614705f, 
    -0.00838932f, -0.04469530f, -0.05760999f, -0.11712074f, 0.14918371f, 0.10905573f, -0.06819904f, 0.03286040f, 
    -0.01775154f, 0.11300897f, 0.08159295f, -0.04471364f, 0.41442713f, 0.03304799f, -0.19122657f, 0.23290390f, 
    0.13438992f, 0.18023096f, 0.17815809f, -0.12636192f, -0.09310921f, -0.03055482f, 0.02002325f, -0.02153329f, 
    0.01155823f, -0.00704583f, 0.04035944f, -0.07175551f, -0.08367191f, 0.08273184f, -0.07446796f, -0.05430440f, 
    0.09565394f, -0.14909050f, 0.17643510f, 0.03981325f, 0.15287404f, 0.09764033f, -0.03828366f, -0.11491396f, 
    -0.01169496f, 0.05733230f, 0.00545378f, -0.05574091f, 0.05465886f, 0.07450591f, -0.06887024f, -0.01145404f, 
    0.29206219f, 0.31459835f, -0.28791305f, -0.06190044f, -0.04936048f, 0.00409370f, 0.13278435f, -0.20255904f, 
    0.05211655f, 0.12529244f, -0.00717512f, 0.02654958f, 0.02704576f, -0.02928245f, 0.04121702f, 0.23046879f, 
    -0.13335557f, -0.19228336f, 0.02591708f, -0.00687767f, 0.01475146f, 0.09919930f, -0.11009140f, 0.04779486f, 
    -0.13489601f, 0.18701603f, 0.01924704f, -0.09909886f, -0.12160481f, -0.21849978f, -0.14350352f, 0.01195609f, 
    -0.06697484f, 0.03125520f, -0.07090592f, 0.10012784f, 0.18706754f, -0.06808743f, -0.16533436f, 0.07680343f, 
    0.14677733f, 0.18379627f, 0.04147967f, 0.04898935f, -0.19531754f, 0.01071727f, 0.05645297f, -0.02274353f, 
    -0.24510473f, 0.00620168f, 0.04268540f, 0.07897501f, -0.14627270f, -0.00133824f, -0.08606796f, 0.14551410f, 
    -0.05221996f, 0.09641998f, -0.10792193f, 0.02332331f, 0.10232892f, -0.04589240f, -0.26181075f, -0.19254032f, 
    -0.01431498f, -0.01714701f, -0.03187170f, -0.09103607f, -0.02127423f, 0.04778040f, 0.01607920f, 0.02105743f, 
    0.00847627f, 0.18811484f, -0.20328431f, 0.04137058f, -0.08256467f, -0.00795075f, -0.01407309f, 0.24506781f, 
    0.05392346f, 0.00145675f, -0.07805673f, 0.08243956f, 0.10311878f, 0.15551239f, 0.02375883f, -0.24622576f, 
    -0.00609086f, -0.10627818f, -0.01837924f, -0.09344243f, -0.12651350f, -0.11335568f, -0.04507469f, -0.16036859f, 
    0.15419795f, -0.34572449f, -0.21852405f, -0.02462250f, 0.05242319f, 0.27081478f, -0.01906308f, 0.00696765f, 
    -0.04094208f, 0.05010977f, 0.08407116f, 0.09440600f, 0.09154361f, 0.07749195f, 0.19223717f, 0.17438580f, 
    -0.07434312f, -0.17121488f, -0.08967429f, -0.17495853f, 0.05779251f, 0.05724174f, -0.06823660f, 0.07301195f, 
    -0.03909407f, -0.14557013f, -0.05872785f, 0.07956086f, 0.00701630f, 0.14463983f, 0.06380102f, -0.19701023f, 
    -0.17794403f, 0.01498309f, -0.17978953f, 0.24818517f, 0.13401860f, 0.05424655f, 0.07307050f, -0.06927765f, 
    0.17627655f, -0.02923875f, 0.08652084f, 0.00296378f, 0.06883509f, -0.09087944f, -0.00201605f, -0.01897888f, 
    0.09526839f, -0.04172981f, -0.04854837f, 0.06140122f, -0.05086799f, -0.18361215f, 0.04573513f, -0.11326399f, 
    0.07175013f, 0.10975543f, 0.06849482f, 0.06062911f, -0.21947925f, 0.01554871f, -0.01245553f, 0.13305290f, 
    0.04295578f, -0.09586579f, -0.11423446f, 0.06350879f, -0.00739822f, -0.04787070f, -0.01917315f, -0.02850809f, 
    -0.01262608f, 0.22679873f, -0.13339947f, 0.01689709f, -0.01472413f, -0.06125085f, -0.08357180f, -0.13467874f, 
    -0.01393449f, -0.01553293f, 0.07100745f, -0.01990361f, 0.22853082f, 0.18493579f, -0.07370058f, 0.04413597f, 
    -0.05721627f, 0.03766517f, -0.04749118f, -0.11706880f, 0.00032918f, -0.00352469f, 0.14068125f, -0.10437045f, 
    0.34287494f, -0.24415593f, 0.10827101f, 0.10952275f, 0.11481863f, -0.05699056f, -0.17144608f, -0.08065291f, 
    0.09233729f, -0.14247079f, 0.02482691f, -0.13138011f, 0.02525762f, 0.27236149f, 0.31063473f, 0.15023676f, 
    -0.05229720f, 0.11389868f, -0.08622438f, 0.10183881f, -0.07056246f, -0.14362963f, 0.07198289f, -0.01454116f, 
    0.08626760f, 0.25192094f, 0.12384544f, 0.17021814f, -0.07315183f, 0.00837376f, -0.04725251f, -0.13011515f, 
    0.05100964f, 0.00572856f, -0.07298378f, 0.00417651f, 0.05041036f, -0.10917645f, 0.15755986f, 0.02635969f, 
    0.05217420f, -0.07911717f, 0.01760136f, 0.10589915f, 0.09715255f, -0.04902117f, -0.02639214f, 0.06880056f, 
    -0.03486852f, 0.26327312f, 0.16417781f, -0.03097091f, -0.08711998f, 0.12416445f, 0.14790447f, -0.00848188f, 
    0.07669420f, -0.15690589f, 0.03346917f, -0.10425791f, 0.28238562f, -0.39517584f, -0.07376626f, -0.18292169f, 
    -0.02510392f, -0.07192169f, -0.08772860f, -0.07300163f, 0.02320485f, -0.01820025f, 0.09181610f, -0.09493078f, 
    -0.00011987f, -0.15695946f, 0.27574557f, 0.23949523f, 0.17575920f, -0.06001123f, -0.06265621f, -0.16731811f, 
    0.12136377f, -0.00762263f, 0.04270215f, -0.04307791f, -0.02471454f, 0.12201725f, -0.07846585f, 0.17336126f, 
    0.01706541f, -0.05020978f, -0.07291172f, -0.09177893f, -0.01814559f, -0.04580842f, 0.03130758f, 0.03909437f, 
    -0.00603181f, -0.10280994f, -0.14369000f, -0.09380831f, -0.16924272f, -0.23906001f, 0.09772154f, -0.03762707f, 
    0.11652457f, -0.09302238f, 0.03985233f, 0.00075756f, 0.27281642f, 0.16614111f, -0.17087431f, 0.22959304f, 
    0.08414083f, -0.03448365f, -0.03316396f, 0.12033936f, 0.06982012f, 0.09581699f, 0.03970927f, -0.04409696f, 
    -0.09968039f, 0.06655543f, 0.11960944f, -0.22541285f, 0.01689948f, -0.09291821f, -0.02889648f, -0.09115076f, 
    0.02182689f, -0.05589922f, 0.09035596f, -0.07937218f, -0.03889919f, -0.02131616f, 0.16599356f, 0.37385604f, 
    0.01136202f, -0.01800414f, -0.08184319f, 0.08001354f, 0.09719656f, 0.03554330f, -0.04385327f, 0.09495001f, 
    0.11728957f, 0.00554148f, -0.01407632f, -0.03997054f, -0.11602353f, 0.15406832f, -0.08684389f, -0.22197789f, 
    0.01267607f, -0.13615960f, -0.09261239f, -0.12328613f, 0.22495787f, 0.09706539f, -0.01701981f, -0.17154637f, 
    0.05037056f, 0.12619273f, 0.03367514f, 0.24038626f, 0.00628352f, 0.02995437f, -0.08669177f, 0.08612796f, 
    -0.12855926f, -0.15979290f, 0.06221851f, -0.00755081f, 0.02378383f, -0.10897844f, -0.06447329f, -0.08351979f, 
    -0.01019118f, 0.22027481f, -0.14336884f, 0.11884904f, -0.02799940f, -0.13881566f, 0.11715837f, 0.17061317f, 
    0.05011849f, -0.02165690f, -0.02624972f, -0.09729791f, -0.04871735f, -0.10400152f, -0.01032536f, -0.05354003f, 
    -0.26771909f, 0.16403857f, 0.46889922f, 0.02360160f, 0.15230444f, -0.00518779f, -0.11693478f, 0.11003765f, 
    -0.09294190f, -0.15012313f, -0.05775012f, 0.00117490f, 0.19891417f, -0.03823006f, -0.21431388f, -0.05899183f, 
    0.01952355f, 0.08075593f, 0.09214806f, 0.14202476f, -0.09365425f, 0.02027249f, -0.02043152f, -0.09392761f, 
    0.03132059f, -0.06047839f, -0.20451817f, 0.11528666f, -0.07138688f, 0.00152805f, -0.03504267f, 0.01071710f, 
    0.01675737f, -0.02076454f, 0.06525926f, 0.03674148f, 0.16600876f, 0.12851033f, 0.07792276f, -0.14947835f, 
    0.22059381f, 0.10401914f, 0.05394915f, 0.01317786f, -0.06201855f, -0.02956276f, -0.07217479f, -0.04574127f, 
    0.02753976f, -0.08906469f, -0.18706377f, -0.07085789f, -0.02391993f, -0.04742323f, -0.09123511f, -0.00373530f, 
    0.14054208f, 0.05109208f, 0.13769536f, 0.02556797f, -0.04871740f, 0.07497793f, -0.07059276f, -0.02532717f, 
    0.11604133f, -0.00507184f, -0.05559922f, -0.09706679f, -0.03853156f, 0.11622350f, 0.05633029f, 0.08695515f, 
    0.11749679f, 0.24673909f, 0.17702845f, -0.08682714f, -0.02867377f, 0.03208290f, -0.06412239f, -0.20975742f, 
    0.01577775f, -0.17227040f, -0.05520377f, 0.08962622f, -0.27621582f, 0.00672469f, 0.15989114f, 0.05062514f, 
    -0.02625201f, -0.13162291f, 0.00856139f, 0.08788922f, 0.04064104f, -0.06146394f, -0.07031191f, 0.06790587f, 
    0.02278900f, 0.00026483f, 0.07286285f, -0.22027507f, 0.00235901f, 0.07126472f, -0.02099169f, -0.09685114f, 
    0.04999742f, -0.01051657f, -0.08880727f, -0.10759046f, -0.00062959f, -0.28237879f, -0.39989433f, 0.13053741f, 
    0.05817986f, -0.03771413f, -0.12465682f, 0.06272605f, -0.04362381f, -0.05843426f, 0.01405617f, 0.00111312f, 
    -0.08907940f, 0.31594262f, -0.19839056f, -0.07645200f, -0.01743299f, 0.11103766f, -0.00439693f, 0.15476260f, 
    0.09659117f, -0.03291923f, 0.21047017f, -0.08356824f, 0.24928041f, 0.18558435f, 0.06333961f, 0.06727584f, 
    0.14805970f, 0.22432315f, 0.08456825f, 0.06805918f, 0.00824457f, 0.09609116f, -0.06317315f, 0.14773296f, 
    0.15279575f, -0.13531654f, -0.09286622f, -0.18207224f, -0.17469960f, 0.19204369f, -0.02090599f, -0.03545765f, 
    0.10395402f, -0.15496671f, -0.31709954f, -0.13218553f, 0.29765299f, 0.06775238f, -0.35823151f, -0.04140509f, 
    0.03122484f, 0.12186676f, 0.07653396f, 0.09315684f, 0.18103653f, 0.07480985f, 0.05855336f, 0.14143559f, 
    -0.12071959f, -0.02476279f, -0.11618232f, 0.10884570f, 0.03959099f, -0.04901934f, -0.17052472f, -0.17581949f, 
    0.01268047f, -0.25489008f, -0.12998870f, 0.02741905f, 0.21299025f, 0.22163303f, -0.18439524f, -0.03058522f, 
    0.02130297f, 0.04500509f, -0.02863271f, -0.11530910f, -0.11013522f, -0.14211127f, -0.02476983f, 0.02514022f, 
    0.02666111f, 0.22382328f, 0.24696955f, -0.01496774f, 0.21100867f, 0.05252977f, -0.09788772f, 0.06609366f, 
    -0.10383724f, -0.07194304f, -0.23118044f, -0.18413381f, 0.25476488f, 0.17488945f, -0.22926748f, 0.25246698f, 
    0.07144859f, 0.11510493f, 0.03684995f, 0.12783259f, -0.05394025f, 0.23307027f, -0.08473238f, -0.14066738f, 
    -0.18610241f, 0.19198543f, 0.30498099f, 0.15520224f, -0.05695985f, -0.04479353f, -0.07664412f, -0.14089517f, 
    -0.06911061f, -0.06050287f, -0.02106514f, 0.14149900f, 0.32621107f, 0.10358592f, -0.11282100f, -0.09240448f, 
    0.19707151f, 0.17616074f, 0.06190492f, 0.18566363f, 0.01080494f, -0.16207214f, -0.11792643f, -0.23714574f, 
    -0.41417518f, 0.07722325f, 0.01798846f, 0.17568627f, 0.01626947f, 0.03933006f, 0.00073487f, 0.13788490f, 
    -0.00836593f, 0.10509711f, 0.02020628f, 0.05405012f, 0.30472350f, -0.27808613f, 0.00602737f, -0.02965140f, 
    0.09820221f, -0.02009432f, -0.27070186f, -0.33765665f, 0.00571296f, 0.18365577f, 0.08263208f, -0.00720841f, 
    0.14930619f, 0.32356343f, -0.00392873f, -0.11067854f, -0.01725659f, 0.05967321f, 0.10708837f, 0.18192126f, 
    -0.01291765f, 0.05952543f, -0.09563064f, 0.02033720f, 0.13086145f, 0.23136713f, 0.13271970f, 0.37833732f, 
    -0.09105056f, -0.14330682f, 0.01325281f, -0.05683091f, 0.10895864f, -0.05581426f, 0.06068494f, 0.19483913f, 
    0.03417572f, -0.41599980f, -0.22655147f, -0.26803479f, -0.00162655f, 0.15796982f, -0.07669716f, -0.19001958f, 
    0.13197622f, 0.09475035f, -0.00032675f, 0.00435640f, -0.18146078f, 0.04106827f, -0.09444988f, 0.23338203f, 
    0.10477077f, -0.10221092f, 0.01710303f, 0.11823142f, -0.01735613f, -0.16040745f, -0.07703601f, 0.01473537f, 
    -0.31233263f, 0.49817407f, -0.32151306f, 0.08165081f, -0.01294333f, 0.19486719f, -0.11262368f, -0.22126921f, 
    -0.00329487f, -0.02487148f, -0.03011990f, 0.07767953f, 0.32899690f, 0.15718682f, 0.13380772f, -0.02126232f, 
    0.15730569f, 0.15099809f, 0.07752251f, 0.06603234f, -0.13311294f, 0.08616744f, 0.06663959f, 0.02150952f, 
    -0.01581727f, 0.02223149f, 0.04073122f, -0.05382696f, 0.04140444f, 0.05235780f, -0.04999073f, -0.07342663f, 
    -0.00658575f, 0.01401307f, -0.00365899f, 0.06232571f, -0.00104335f, -0.05161500f, -0.00339576f, -0.05675432f, 
    0.05889678f, 0.04777718f, 0.01738487f, 0.06652652f, -0.06181674f, -0.05619503f, -0.06529000f, 0.01276842f, 
    0.01747615f, -0.04613284f, 0.03754831f, -0.01419748f, 0.02680868f, 0.06174512f, -0.03498567f, -0.04061477f, 
    0.04066810f, -0.02707253f, -0.05391773f, 0.00438088f, 0.00658089f, 0.01413028f, -0.02298684f, -0.02457993f, 
    -0.01233650f, 0.05028749f, 0.01253570f, -0.07215630f, 0.04572136f, 0.01845196f, -0.03752987f, 0.01896989f, 
    0.01803439f, -0.00614767f, -0.04152421f, -0.07846721f, 0.05380680f, -0.04951764f, 0.01811342f, -0.06141910f, 
    0.00562023f, 0.05926155f, -0.07402937f, -0.00989744f, -0.03382852f, -0.06646060f, 0.00280622f, -0.04909275f, 
    -0.06131313f, 0.02654146f, -0.01345976f, -0.02117753f, -0.02644113f, -0.03061945f, -0.04186527f, 0.06724416f, 
    -0.06583191f, -0.08033032f, -0.04952485f, 0.06356042f, 0.00812182f, -0.04966023f, 0.01171510f, 0.00295432f, 
    -0.00101398f, 0.05237246f, -0.00305268f, -0.00511562f, 0.01178184f, -0.04863118f, 0.06010906f, 0.02328384f, 
    -0.01268947f, -0.04177525f, -0.05040816f, -0.08336329f, -0.05692770f, 0.03670684f, 0.04038610f, 0.05350943f, 
    -0.04925266f, -0.02830249f, -0.05409885f, -0.00013188f, 0.04624470f, -0.03913892f, 0.03290421f, -0.01532324f, 
    -0.03420177f, -0.05130408f, -0.00649707f, -0.04901681f, -0.04989717f, 0.02974945f, -0.00050937f, -0.05390980f, 
    -0.05000268f, 0.04848781f, 0.01319561f, 0.03448025f, 0.02424780f, -0.04043403f, -0.04218687f, 0.03662908f, 
    0.05136286f, 0.06499613f, 0.02799213f, 0.02889513f, -0.04799081f, 0.05239391f, 0.04023033f, -0.00115637f, 
    -0.06380078f, 0.05165957f, -0.01358559f, -0.03202341f, -0.00424702f, 0.06635781f, 0.01211272f, -0.06670462f, 
    -0.07955507f, -0.05579602f, -0.05691326f, -0.04226765f, -0.06061130f, 0.04229506f, -0.06413550f, -0.06579047f, 
    -0.05718635f, -0.07146931f, 0.01644047f, -0.06154171f, -0.06800132f, -0.07187794f, 0.06051433f, -0.06172280f, 
    0.06309177f, 0.01481276f, 0.03271092f, -0.02643779f, -0.04715835f, -0.01092767f, 0.00445466f, 0.02297348f, 
    -0.06404018f, -0.01329078f, 0.05708526f, -0.01417588f, -0.07844206f, 0.01975682f, -0.06484329f, -0.00895260f, 
    -0.03921001f, -0.01087654f, -0.04908927f, -0.02022696f, -0.00665894f, -0.03785424f, -0.05127051f, -0.02992119f, 
    -0.00757176f, -0.01489321f, -0.03460971f, -0.06366795f, 0.03855629f, 0.02467192f, -0.06270386f, 0.01899661f, 
    -0.01476644f, 0.04829076f, 0.03211929f, 0.02307399f, -0.03529192f, -0.01671218f, -0.03989336f, 0.03790741f, 
    -0.09704802f, 0.06813094f, 0.04112937f, 0.13253394f, -0.05635032f, 0.08770476f, -0.00895171f, -0.04421984f, 
    0.00160562f, -0.08547356f, 0.01801449f, -0.09981342f, -0.23446968f, 0.05367599f, 0.17002535f, -0.18739179f, 
    -0.06986002f, -0.08859150f, 0.00630613f, 0.18643746f, 0.09771955f, -0.04288626f, -0.03404049f, 0.05657161f, 
    0.01176206f, 0.00311534f, -0.25513920f, 0.05545347f, -0.13404459f, -0.13109115f, 0.07180949f, 0.05735484f, 
    0.11807790f, 0.24641640f, -0.04643522f, 0.25972265f, -0.19354486f, -0.04409070f, -0.12971011f, 0.01748564f, 
    -0.23758312f, -0.16266716f, -0.12043681f, -0.11728539f, 0.05913827f, 0.12180782f, 0.10563384f, 0.01039925f, 
    0.18950295f, -0.14805847f, 0.21676125f, 0.09915049f, 0.17594010f, -0.01631108f, 0.03175510f, 0.03770057f, 
    0.05427604f, -0.07607256f, 0.08867989f, -0.06803527f, -0.00434234f, 0.15450621f, 0.05260772f, -0.32668567f, 
    0.10126790f, 0.15330598f, -0.03662368f, -0.14723386f, -0.18390885f, -0.08677296f, 0.09379689f, -0.15403824f, 
    0.51764703f, -0.30871406f, -0.45576555f, 0.22951074f, 0.06498500f, 0.01968072f, 0.03703431f, 0.08274478f, 
    0.11825255f, -0.04586529f, 0.05993174f, -0.01864252f, 0.06272414f, 0.00475004f, 0.01350267f, 0.01991983f, 
    0.03204442f, -0.04942782f, 0.02616426f, -0.15094262f, 0.12951948f, 0.03448591f, -0.23174419f, 0.02712522f, 
    0.15722711f, -0.09725174f, -0.33544922f, -0.30638611f, 0.06480838f, 0.11840655f, -0.01816178f, -0.12433314f, 
    0.22834112f, -0.07090517f, 0.11879884f, -0.00640942f, 0.04645938f, -0.12259037f, -0.00618518f, 0.11075320f, 
    -0.12383255f, -0.01182727f, -0.05563731f, 0.14539973f, 0.14345489f, -0.00810637f, -0.04518541f, 0.01725526f, 
    -0.01298774f, -0.17636915f, 0.25610211f, -0.06654432f, 0.12462224f, -0.03811711f, -0.03372247f, -0.14226334f, 
    0.23168263f, -0.03505441f, 0.25650293f, -0.08584997f, -0.05632387f, -0.53636956f, 0.15736604f, 0.06862083f, 
    -0.17131296f, 0.14768746f, -0.02018041f, -0.08512689f, 0.26510757f, 0.14305744f, 0.12705663f, 0.17835981f, 
    -0.30893233f, 0.19161834f, 0.00920760f, -0.06297310f, -0.08085170f, -0.15590905f, 0.05838307f, 0.13720329f, 
    0.09392774f, 0.02005784f, 0.04820261f, 0.01162484f, 0.21778218f, -0.01490164f, -0.22157736f, -0.21727204f, 
    -0.15479322f, 0.09515910f, 0.04767597f, 0.24492256f, -0.09628540f, -0.01500643f, -0.02832226f, -0.06015232f, 
    -0.24989358f, 0.31359777f, -0.02522117f, -0.22952892f, 0.04619273f, -0.04178973f, -0.07452650f, 0.28921044f, 
    0.16086963f, 0.12979154f, 0.01166473f, -0.08161762f, 0.02710266f, -0.02712422f, 0.28316167f, 0.05360932f, 
    -0.07606643f, 0.12655304f, -0.04017553f, -0.07310167f, 0.06830308f, -0.07966433f, 0.02026232f, 0.18790260f, 
    -0.08581562f, -0.04625501f, -0.08884715f, -0.02683738f, 0.09911630f, 0.14435518f, -0.26763901f, -0.07537594f, 
    0.01375616f, 0.09237079f, 0.05325141f, 0.00234013f, 0.15658292f, 0.03361410f, 0.02218276f, 0.10236985f, 
    0.03752411f, 0.09219342f, -0.05418101f, -0.22974159f, 0.01692145f, -0.12536561f, -0.00326396f, 0.04433310f, 
    -0.05165280f, -0.24645565f, 0.19837692f, 0.06649585f, -0.07435091f, 0.00809637f, -0.14717798f, 0.02895427f, 
    0.11375662f, 0.05643797f, 0.00385298f, -0.02546065f, -0.11500669f, -0.09134509f, -0.08873129f, 0.01440406f, 
    -0.12420598f, -0.11744633f, 0.04315988f, -0.01209124f, -0.01766048f, 0.05817132f, 0.04769221f, 0.23942754f, 
    -0.08824248f, 0.25197119f, -0.20571622f, -0.03284833f, -0.09507951f, 0.05444452f, -0.01646036f, -0.08377519f, 
    -0.02866069f, 0.11111711f, 0.01344020f, 0.19931516f, -0.00897094f, -0.24899834f, 0.01505513f, -0.00841066f, 
    -0.05350638f, -0.15537967f, 0.03484369f, -0.17723572f, -0.09631889f, 0.11912960f, -0.07684996f, 0.05084085f, 
    -0.08296014f, -0.00725878f, -0.01371084f, -0.02248354f, -0.02256472f, -0.18808375f, -0.11274530f, 0.04782470f, 
    -0.03839584f, 0.00079009f, -0.00747846f, 0.05083070f, 0.02178456f, -0.14893456f, -0.13250110f, 0.13886060f, 
    0.06748009f, 0.14725530f, 0.09506080f, -0.10960131f, -0.01553189f, -0.03574800f, 0.03079526f, -0.09697929f, 
    -0.15827405f, -0.27257633f, -0.20465918f, 0.08168847f, -0.02895977f, -0.02891278f, -0.16537412f, -0.04638221f, 
    0.02687199f, 0.03222778f, -0.08414830f, -0.03512655f, -0.28870383f, -0.09554503f, -0.14342201f, -0.02346853f, 
    0.01021385f, -0.01797427f, 0.02896537f, 0.01926327f, -0.02193076f, 0.02609250f, 0.00464457f, 0.01911050f, 
    0.05609059f, 0.12704647f, -0.08864173f, -0.02888625f, -0.01933439f, -0.02426143f, 0.02208694f, 0.22644863f, 
    -0.04469938f, -0.12340755f, -0.15608838f, -0.04132128f, -0.12599252f, -0.02160000f, -0.08010636f, -0.20792463f, 
    0.09664060f, 0.03074768f, 0.00149587f, -0.00881882f, -0.17323983f, -0.14043033f, -0.10823686f, -0.07515036f, 
    0.07624428f, 0.05798702f, 0.13577221f, 0.15426157f, 0.05433246f, 0.19189626f, -0.01398741f, -0.04200851f, 
    0.04349561f, -0.04379420f, -0.12531641f, -0.08056618f, -0.00244706f, -0.07593213f, 0.33934361f, 0.07895703f, 
    -0.08256383f, -0.07396629f, -0.02756602f, -0.04920064f, 0.01835032f, -0.05676175f, -0.05378746f, 0.00143855f, 
    0.16035891f, -0.18135846f, -0.06101430f, -0.16189559f, 0.20799242f, 0.03108518f, -0.01847608f, 0.10050834f, 
    -0.21948327f, -0.05327599f, -0.10565954f, 0.01769555f, -0.01201442f, 0.02229334f, -0.06709914f, -0.17416221f, 
    0.13842167f, 0.08300026f, 0.04775399f, 0.03514827f, 0.07006041f, -0.06774018f, 0.01429733f, -0.06821389f, 
    -0.07524748f, -0.08458100f, -0.08699053f, -0.08450311f, -0.05580200f, -0.07033001f, 0.01116980f, -0.05681584f, 
    0.02983001f, 0.00538908f, -0.04258930f, -0.03018596f, 0.01414488f, 0.00480919f, 0.06924228f, 0.05816472f, 
    0.03190196f, 0.03564981f, -0.01315452f, -0.10275535f, -0.02312209f, -0.11320006f, -0.07501934f, -0.02655773f, 
    -0.00226652f, 0.01731968f, -0.10728829f, -0.06146717f, 0.01850539f, -0.05561233f, -0.01427643f, -0.01983504f, 
    0.02686285f, -0.01704045f, 0.00495581f, 0.01293905f, -0.02792030f, 0.02716770f, 0.01297983f, -0.04117859f, 
    -0.01345507f, -0.06429137f, -0.05726383f, -0.06930520f, 0.04455516f, 0.00946342f, -0.04614842f, -0.00458087f, 
    0.07150613f, -0.02467002f, -0.08478688f, -0.07866121f, -0.03969554f, -0.02418701f, -0.05733362f, -0.08095610f, 
    0.00447091f, -0.08375184f, 0.01950921f, -0.01267141f, -0.02005868f, -0.03441022f, 0.04100233f, -0.06043999f, 
    0.02726029f, -0.06006843f, -0.01484167f, -0.02344101f, 0.02386435f, 0.04870846f, -0.01471051f, 0.00414211f, 
    0.00106014f, -0.06327309f, -0.00344695f, -0.05059348f, 0.00780304f, 0.04047817f, -0.01310109f, -0.01265683f, 
    -0.01311677f, -0.03692245f, 0.03016691f, -0.01602066f, 0.02500274f, -0.03246513f, -0.07858629f, 0.04318589f, 
    0.00110842f, -0.08073001f, 0.01845019f, -0.04820433f, -0.02364496f, 0.05443439f, -0.05225492f, 0.05413528f, 
    -0.03637393f, -0.03303372f, -0.06282815f, -0.06213101f, 0.05093335f, -0.03433739f, 0.04180370f, -0.07032333f, 
    0.03431692f, 0.02030015f, 0.07314786f, -0.04129290f, -0.06216566f, -0.02710636f, -0.07328122f, -0.00580670f, 
    -0.01015498f, -0.06754890f, -0.07997126f, 0.00865442f, -0.00755038f, -0.03936895f, -0.06298505f, 0.02687321f, 
    0.05920190f, 0.01473801f, -0.03572484f, -0.01890995f, -0.01373161f, 0.06837282f, -0.00340496f, 0.03276929f, 
    0.05468636f, 0.01328430f, -0.02035665f, 0.03260684f, 0.00030292f, -0.09770297f, 0.03321790f, 0.01180965f, 
    0.03876125f, -0.06359709f, 0.03096433f, 0.02184935f, -0.04785204f, -0.00463400f, -0.05150323f, -0.01459697f, 
    -0.01627992f, -0.01114759f, 0.02561075f, -0.03399838f, 0.00939126f, -0.00641366f, 0.05346187f, -0.02317944f, 
    -0.06023749f, -0.10096736f, -0.09418981f, -0.05678396f, 0.03848273f, 0.03278387f, -0.03508041f, -0.05700972f, 
    -0.07096865f, 0.01423826f, -0.04577271f, 0.00584582f, -0.00874585f, -0.04235563f, -0.06139768f, -0.03025763f, 
    -0.01769689f, -0.06670293f, -0.03257209f, -0.05674082f, 0.04653182f, 0.02257492f, 0.00610304f, 0.03710483f, 
    -0.08775319f, -0.01667495f, -0.08464105f, 0.04303204f, -0.01592122f, 0.06377610f, -0.03777082f, 0.01531366f, 
    -0.00996275f, 0.06204724f, 0.01598358f, -0.03604361f, 0.04727782f, -0.04854858f, -0.07817387f, 0.03267474f, 
    -0.03207975f, -0.06543959f, -0.03756028f, 0.01242584f, 0.02690876f, -0.12683426f, 0.24348527f, 0.21836293f, 
    -0.08942257f, -0.12218457f, 0.00360345f, -0.02520310f, -0.20416775f, -0.03761545f, 0.30345592f, 0.01829778f, 
    -0.11676949f, -0.11659970f, -0.05962820f, 0.14474745f, 0.12969866f, 0.08375885f, 0.07350466f, -0.00427269f, 
    0.17422156f, 0.16945672f, -0.03999532f, 0.03004361f, 0.03705262f, 0.03986914f, -0.05112769f, -0.13676448f, 
    -0.03579674f, -0.11801670f, 0.00572077f, -0.13528167f, 0.02590329f, -0.01776966f, 0.04049332f, -0.04057054f, 
    0.14205433f, 0.05234605f, 0.00450767f, -0.03316323f, -0.03618403f, -0.10653551f, -0.02758297f, -0.14211741f, 
    0.03320319f, -0.25420141f, -0.24119864f, 0.31753522f, 0.04936572f, 0.13009880f, 0.03391530f, 0.00369314f, 
    -0.07413965f, -0.13762626f, -0.03821797f, -0.24234533f, -0.02038508f, 0.11885956f, -0.06049186f, -0.15758330f, 
    0.09625232f, 0.02466993f, 0.07293733f, -0.10696936f, 0.07726089f, 0.01040354f, 0.02571378f, -0.00315394f, 
    -0.06146199f, -0.25233868f, 0.01370489f, -0.18759735f, 0.07285704f, 0.13151178f, 0.10768040f, -0.05976639f, 
    0.09065520f, -0.01943035f, -0.11154497f, -0.14386131f, -0.12893967f, 0.05031949f, 0.06163842f, -0.09735782f, 
    -0.11278576f, -0.26470065f, -0.02202034f, -0.13418053f, 0.03473395f, -0.00381179f, 0.02972016f, -0.04770599f, 
    0.13020869f, 0.09408067f, 0.17594784f, -0.08181730f, -0.01633979f, -0.16257083f, 0.10583752f, -0.09603663f, 
    0.09060451f, 0.07793801f, 0.19410762f, 0.17702335f, 0.27851927f, 0.05106786f, 0.37855235f, 0.07571135f, 
    0.01569109f, 0.05607447f, -0.12065537f, 0.01529976f, 0.07154216f, -0.04855432f, -0.05817404f, 0.09865701f, 
    -0.11362296f, -0.13746046f, 0.01372380f, -0.00921220f, 0.12789959f, 0.11268040f, 0.06519777f, -0.07432943f, 
    0.10159524f, -0.02292472f, 0.13533999f, -0.01290300f, 0.23787589f, -0.01046368f, -0.08809753f, 0.18485354f, 
    -0.05051995f, 0.02990548f, -0.07419723f, -0.06944273f, 0.30721819f, 0.27434018f, 0.10837512f, 0.21639508f, 
    0.06569874f, 0.28377527f, 0.09139851f, 0.04618292f, -0.09486618f, -0.18048200f, -0.02822272f, 0.02857910f, 
    0.04990436f, 0.06210849f, 0.15903662f, 0.20131893f, -0.13996263f, 0.10364889f, -0.27852565f, -0.12916242f, 
    0.10215624f, 0.09609598f, 0.04710223f, 0.07829391f, 0.07694358f, -0.09967849f, -0.18691027f, -0.00060324f, 
    -0.16080254f, -0.06845624f, 0.02968626f, 0.28939554f, -0.08844125f, -0.12158769f, -0.06848343f, -0.07727827f, 
    0.26328725f, 0.18153425f, 0.10494528f, -0.04676294f, -0.03916178f, -0.13337514f, 0.05021674f, -0.07247432f, 
    -0.05607947f, 0.03609873f, -0.02068252f, -0.07214253f, -0.09669594f, -0.12617123f, -0.01691342f, -0.06743962f, 
    -0.03060867f, 0.02695271f, -0.02881520f, -0.10135544f, -0.06153394f, 0.01293419f, 0.16307877f, 0.07908168f, 
    -0.01780707f, -0.00408562f, -0.04495738f, -0.05675584f, 0.08040366f, 0.10927910f, 0.33200681f, -0.17688650f, 
    -0.03021415f, -0.09615971f, -0.21788849f, 0.00508366f, 0.08043547f, 0.08703278f, -0.03728697f, -0.18204777f, 
    0.04735787f, -0.05876971f, 0.02284865f, 0.13177055f, 0.06688526f, -0.06207850f, 0.15250255f, -0.02594413f, 
    -0.01490917f, 0.34336087f, -0.02707963f, 0.14875801f, -0.07115597f, -0.05420833f, 0.08483160f, 0.24383345f, 
    -0.13670224f, 0.04723712f, -0.09974209f, 0.01382793f, 0.16425262f, 0.05667066f, 0.07145861f, -0.07246510f, 
    -0.54880124f, -0.17465070f, 0.40347436f, 0.08221611f, 0.14265171f, 0.00703564f, -0.05640145f, 0.07866024f, 
    -0.01082043f, -0.10089695f, -0.00204376f, 0.07256024f, 0.25760782f, -0.08965170f, -0.20698307f, -0.28338489f, 
    0.00179739f, 0.04204466f, 0.08650617f, 0.02784671f, -0.09094891f, 0.03657192f, 0.03635453f, 0.01415728f, 
    0.30084980f, -0.05994201f, 0.23648131f, 0.09834901f, 0.00251765f, 0.10525008f, 0.06033829f, -0.07118940f, 
    -0.02888891f, -0.12246199f, 0.06191593f, -0.06606513f, -0.01343734f, 0.20827164f, 0.14030498f, -0.17035572f, 
    0.01220238f, -0.13610873f, 0.08164664f, 0.00781816f, -0.06970083f, -0.04461316f, -0.10017274f, -0.01951514f, 
    0.24030782f, -0.15371801f, 0.09575521f, -0.19904050f, 0.11231560f, -0.06505592f, -0.02197597f, 0.00597455f, 
    0.01238270f, -0.07892434f, 0.13601005f, 0.04761273f, 0.04803846f, 0.06039610f, -0.12223245f, 0.19002558f, 
    -0.19247314f, -0.06490629f, -0.15128426f, -0.03176740f, 0.04846383f, -0.07965320f, 0.18770781f, 0.14300282f, 
    -0.18364024f, -0.11643898f, 0.05911308f, -0.04281496f, -0.01990022f, -0.06816352f, -0.01039130f, -0.03422132f, 
    0.11108974f, -0.08087506f, 0.01343754f, -0.05812401f, -0.25399393f, -0.16821705f, 0.18589014f, 0.29513207f, 
    0.13295141f, 0.06226949f, -0.12067950f, 0.05214528f, 0.10064980f, 0.08342656f, -0.10652495f, 0.02480870f, 
    -0.20515144f, 0.29227525f, 0.08792738f, -0.25065550f, -0.10806258f, -0.15793936f, 0.01869018f, 0.04104911f, 
    0.02576257f, -0.03062180f, -0.00844419f, -0.07886931f, 0.27641541f, -0.03157378f, -0.03998518f, -0.02994779f, 
    0.00188769f, 0.02402416f, -0.04929803f, -0.02834544f, -0.04524765f, -0.14487754f, -0.01936514f, -0.07976288f, 
    -0.44122493f, 0.03580605f, 0.00213222f, -0.08383392f, -0.00556999f, 0.03071951f, -0.01793741f, 0.27439487f, 
    0.13334979f, -0.01712971f, 0.12693189f, -0.13794470f, -0.08425293f, 0.12860268f, 0.11546725f, 0.05134008f, 
    -0.06330307f, 0.00892223f, 0.07574075f, -0.11006379f, 0.13317870f, 0.11497246f, 0.09518948f, 0.07730342f, 
    -0.13203356f, 0.06084930f, 0.04594223f, -0.00397186f, -0.02450302f, -0.21164519f, 0.01593322f, 0.13319290f, 
    -0.14818105f, -0.14688817f, -0.11323497f, -0.18657362f, -0.10807679f, -0.08185089f, 0.32024136f, 0.08856602f, 
    -0.20847791f, -0.19203693f, 0.02697562f, 0.19598520f, 0.07862049f, 0.05451262f, 0.12882936f, 0.07217513f, 
    0.04434517f, -0.06361151f, 0.10829033f, 0.02648795f, 0.05370077f, -0.03418507f, -0.00376867f, -0.03575283f, 
    0.05443949f, -0.02673044f, -0.14252366f, 0.20275655f, -0.19172315f, -0.02524233f, 0.16008390f, 0.16287394f, 
    0.06180940f, 0.09924582f, 0.00892116f, 0.06525711f, -0.02415749f, 0.21366273f, -0.00207736f, 0.01210105f, 
    -0.23232536f, 0.00476245f, -0.32004544f, 0.04234184f, 0.09356869f, 0.02455666f, -0.03812705f, 0.12270118f, 
    -0.17948678f, 0.06058282f, -0.05323842f, -0.06046766f, 0.14078096f, -0.33003709f, 0.27029243f, -0.25711602f, 
    -0.00067169f, -0.07906979f, -0.01477100f, -0.21854341f, 0.03295950f, 0.07742364f, -0.05854257f, 0.04387040f, 
    0.34756333f, -0.21425067f, 0.23608032f, 0.12185135f, 0.02154423f, 0.10064156f, 0.07643830f, -0.04568845f, 
    0.03521571f, 0.02051007f, -0.06994659f, -0.04392588f, -0.35420269f, -0.04752493f, 0.00450752f, -0.25479138f, 
    -0.22373590f, -0.30082372f, -0.24318257f, -0.25504026f, -0.13895583f, -0.13606049f, -0.03560688f, -0.10983791f, 
    0.09348163f, -0.01277099f, 0.16043049f, -0.27740285f, -0.06269071f, 0.00205736f, 0.11594832f, 0.07060570f, 
    0.23738641f, 0.34986135f, 0.24442002f, 0.07623528f, 0.09251364f, 0.09160859f, 0.32643732f, 0.21380694f, 
    0.05305193f, -0.00538487f, -0.03885483f, 0.11929477f, 0.05521645f, 0.12681977f, 0.07490768f, 0.07948425f, 
    -0.43282974f, -0.48819157f, -0.32805863f, 0.04674421f, 0.02483427f, 0.12211543f, 0.10749126f, 0.04134438f, 
    -0.03759301f, 0.11564518f, 0.06097119f, -0.09772905f, 0.18376042f, -0.00392030f, -0.06208206f, 0.24882703f, 
    -0.06810912f, 0.08664318f, -0.06751278f, 0.01155336f, 0.09099206f, -0.00752909f, 0.27979937f, 0.22834221f, 
    -0.29572442f, 0.20983492f, 0.19839773f, -0.02860413f, -0.05236461f, -0.09601923f, -0.09436178f, 0.08647183f, 
    0.00864735f, 0.09178215f, 0.14433444f, 0.18387724f, 0.16512083f, 0.25135219f, 0.22380114f, -0.01215720f, 
    0.08777189f, -0.02075750f, 0.21984778f, -0.01507918f, 0.00720123f, 0.07159109f, 0.00465975f, 0.03078721f, 
    -0.30035469f, -0.01042328f, 0.17179090f, 0.00483487f, 0.08276507f, -0.04833038f, 0.10700830f, 0.07253060f, 
    0.39258265f, 0.02468349f, -0.00382738f, 0.00420619f, -0.09337280f, -0.27951071f, -0.24892457f, 0.00086164f, 
    0.07244788f, 0.08867642f, -0.08205245f, -0.12129371f, 0.03141252f, 0.04359952f, 0.11931738f, -0.17083651f, 
    0.03602385f, -0.05654334f, 0.02313244f, 0.05736636f, -0.01954124f, 0.03506148f, -0.07936483f, 0.03399590f, 
    -0.07321572f, 0.04863834f, -0.06186804f, 0.03851932f, -0.00078938f, -0.04507368f, -0.04655042f, -0.06941351f, 
    0.00054244f, 0.05741100f, -0.01217190f, 0.03888267f, 0.03442712f, 0.04987539f, -0.07072601f, -0.01635442f, 
    -0.02651877f, 0.04159411f, 0.05172439f, -0.05529150f, -0.03270392f, 0.03027051f, -0.06496738f, -0.07088839f, 
    0.01652521f, -0.02380684f, -0.04866325f, -0.07781868f, -0.06682675f, -0.06706992f, 0.00117562f, 0.00870472f, 
    0.00502194f, -0.06035019f, 0.04272205f, -0.06186535f, 0.00284928f, 0.01288349f, 0.01758966f, -0.03344910f, 
    -0.04608920f, 0.03705772f, -0.01811065f, -0.05588930f, 0.01708410f, 0.02924373f, -0.00151924f, -0.04277227f, 
    -0.06420760f, 0.04680880f, -0.05418917f, -0.01412688f, -0.06001901f, -0.06675921f, -0.01254697f, 0.01664121f, 
    0.02494047f, 0.00317162f, -0.02954129f, 0.02687875f, -0.03026920f, -0.05539107f, 0.01432335f, 0.04455718f, 
    0.03486758f, -0.01206708f, -0.05490621f, 0.02114251f, 0.02076697f, 0.04112393f, -0.05885990f, -0.05634874f, 
    0.01160791f, 0.04037707f, -0.04669480f, 0.05111282f, -0.04730133f, -0.04868073f, 0.02704950f, 0.00319433f, 
    -0.05963400f, 0.02305435f, -0.01652684f, 0.05060869f, -0.07116313f, 0.00686022f, -0.02466514f, -0.03898644f, 
    -0.04197108f, 0.00996102f, -0.02817124f, -0.07160852f, 0.04046888f, 0.02070026f, -0.08073067f, -0.01842731f, 
    -0.04434445f, -0.06357507f, 0.06412625f, 0.01361418f, 0.00817457f, 0.01847398f, 0.02589209f, 0.02292186f, 
    -0.01458065f, -0.06415570f, 0.04541614f, 0.06194827f, 0.03197291f, 0.00976230f, 0.00919145f, 0.05741823f, 
    0.01092021f, -0.07219236f, 0.01323524f, -0.00069254f, 0.05594699f, 0.00943030f, 0.01070069f, -0.00004702f, 
    0.01976516f, -0.01579730f, -0.05606313f, -0.05227732f, -0.04674227f, -0.01422543f, 0.00383682f, 0.04278099f, 
    0.02582557f, 0.06902331f, 0.01358650f, 0.03553757f, -0.07552319f, -0.00006555f, 0.02285331f, -0.01247013f, 
    0.01471245f, -0.03356970f, 0.00594839f, -0.03206759f, -0.06770515f, -0.02839311f, 0.05485478f, -0.01395576f, 
    0.04965930f, -0.06763154f, 0.02119134f, -0.07546069f, -0.06568081f, -0.00813208f, -0.01112889f, -0.00236428f, 
    0.00312922f, -0.02379874f, 0.06264712f, -0.06056029f, 0.05371054f, -0.04013737f, -0.03024212f, -0.02433833f, 
    -0.01816133f, -0.06491335f, -0.01524333f, 0.02903331f, -0.05038686f, -0.02023290f, 0.02397521f, -0.00636303f, 
    -0.06950012f, 0.02557730f, 0.03179629f, -0.01919695f, 0.02106776f, 0.04450845f, 0.00004321f, 0.04186671f, 
    0.05901819f, 0.03776566f, -0.01832988f, 0.05188918f, -0.06053454f, 0.04215783f, -0.06402077f, -0.04055716f, 
    -0.11282974f, -0.05421518f, -0.04494728f, -0.09648707f, -0.03472899f, 0.07039819f, 0.12511770f, -0.03373363f, 
    0.07758575f, 0.07990228f, 0.05723878f, 0.09003477f, 0.18847166f, -0.01144005f, 0.09831817f, -0.31016085f, 
    -0.01099768f, 0.01256625f, 0.07241733f, 0.19055353f, 0.00669724f, 0.02874355f, -0.14056256f, -0.13655822f, 
    -0.01851507f, -0.11303350f, 0.01084898f, 0.10616729f, -0.08054166f, 0.07003225f, 0.02820070f, 0.06597238f, 
    0.05426274f, 0.50513530f, -0.06550858f, 0.23781624f, -0.09596349f, 0.06785270f, -0.04890054f, 0.01869074f, 
    -0.19283596f, -0.04186721f, -0.06746487f, 0.03461524f, 0.19787006f, 0.01452141f, 0.04953304f, 0.07950741f, 
    -0.05475233f, 0.09707763f, 0.06204782f, 0.04134591f, -0.02925801f, 0.02213156f, -0.02332633f, 0.07996634f, 
    -0.02011329f, 0.26193148f, 0.02660663f, 0.16345523f, -0.14055866f, -0.08404365f, -0.19575329f, -0.18720180f, 
    0.10796241f, 0.01546698f, 0.22507855f, -0.04220014f, -0.00042844f, -0.07203083f, -0.05852186f, 0.11470984f, 
    -0.01532435f, -0.05499963f, 0.22411613f, -0.03879752f, 0.01406442f, 0.03894346f, -0.06410637f, -0.04301634f, 
    0.04329040f, -0.03096141f, 0.14433751f, -0.01878296f, -0.08357447f, -0.04794652f, -0.15313633f, -0.20452487f, 
    0.05161447f, 0.07554458f, 0.07188244f, -0.06768633f, -0.06221893f, -0.00424757f, -0.08584608f, 0.06188626f, 
    -0.06383481f, 0.03210454f, -0.15996252f, -0.00775725f, 0.04285159f, -0.05372406f, 0.04491399f, 0.08686177f, 
    0.04311713f, 0.00213718f, -0.12365698f, -0.20915183f, -0.07892720f, 0.00300121f, 0.21914625f, -0.16862814f, 
    -0.09935203f, -0.03664623f, 0.06454431f, -0.08724723f, 0.15297487f, -0.00605430f, 0.09972999f, 0.01009358f, 
    -0.05278441f, 0.02691160f, 0.10616175f, -0.13921897f, -0.18183212f, 0.10918025f, 0.12910907f, 0.17465831f, 
    0.05213680f, 0.02919290f, 0.01636975f, -0.21147943f, 0.16939326f, -0.37457860f, 0.13158000f, 0.01626202f, 
    0.00107694f, -0.05260599f, -0.02123733f, 0.04455614f, 0.08164883f, -0.08438165f, -0.03592842f, -0.13422747f, 
    -0.29282284f, 0.04411307f, 0.00746095f, -0.14886364f, 0.02403952f, 0.17187360f, 0.09997819f, -0.01131722f, 
    0.02409081f, 0.06706987f, 0.08302718f, -0.03795792f, 0.03250163f, 0.15986870f, -0.04860144f, 0.03430935f, 
    -0.00335715f, 0.06809659f, 0.02357144f, -0.16841199f, -0.09602051f, -0.03811802f, 0.11572903f, 0.03725120f, 
    -0.02844684f, 0.12676954f, -0.11599544f, -0.08640054f, 0.01462988f, 0.04184700f, 0.41451100f, 0.19958372f, 
    0.09556783f, -0.05535974f, -0.13179933f, 0.10018644f, 0.06340274f, 0.23924117f, 0.14631739f, 0.00232892f, 
    0.11536273f, 0.03467769f, 0.24916497f, -0.02139992f, 0.13525288f, 0.04598701f, -0.09154024f, 0.12642020f, 
    0.02857391f, 0.12829252f, 0.01386485f, 0.00628607f, 0.05456876f, -0.08731386f, 0.04050078f, 0.09279900f, 
    -0.13343452f, -0.10680693f, 0.06492864f, -0.01297058f, 0.27508605f, 0.04452569f, 0.40851283f, 0.01374911f, 
    -0.04754118f, 0.01778266f, -0.03009641f, 0.01346215f, 0.06383628f, 0.07425270f, -0.05798676f, -0.03491835f, 
    0.22396655f, 0.19101709f, 0.07342054f, 0.14193651f, -0.02612464f, -0.04300691f, 0.03064959f, 0.05297942f, 
    -0.02345136f, -0.02021404f, 0.09426086f, -0.07261842f, 0.12806638f, -0.13745333f, 0.05968099f, 0.21650153f, 
    0.06233818f, -0.02655020f, -0.01881162f, 0.01961953f, 0.08081306f, 0.01686659f, -0.06655999f, -0.10912146f, 
    -0.42795768f, -0.01869132f, 0.04689227f, 0.15823656f, -0.06319775f, 0.17515106f, 0.11100002f, -0.04069576f, 
    -0.07989941f, -0.07779207f, -0.12233401f, 0.01425625f, 0.06166599f, 0.16036625f, -0.39268878f, -0.23978876f, 
    -0.02146040f, -0.07634193f, 0.08245976f, -0.00074502f, -0.12742861f, 0.02709173f, -0.03422597f, 0.00452054f, 
    0.00629846f, -0.16317479f, -0.03685147f, -0.14184332f, 0.01579370f, -0.00894606f, 0.03431584f, 0.01606003f, 
    0.16121019f, -0.06946821f, 0.03018362f, 0.00428960f, -0.02642956f, 0.23784392f, 0.13410600f, 0.04303833f, 
    -0.24027301f, -0.12791646f, 0.11536428f, 0.11393283f, -0.08627042f, -0.04446163f, -0.00497756f, 0.04263949f, 
    0.05820803f, -0.02259264f, 0.04838365f, -0.14117244f, 0.05424621f, -0.07236597f, 0.09319201f, -0.05043591f, 
    0.03597084f, 0.07720933f, -0.01044181f, 0.31522989f, 0.38767877f, 0.09631050f, 0.15426975f, 0.10727783f, 
    -0.03805601f, 0.04419410f, -0.13914676f, 0.00213001f, -0.02628539f, -0.02349223f, -0.08006267f, 0.08138846f, 
    -0.04291047f, 0.04795286f, 0.02017956f, -0.08731952f, -0.05855281f, 0.00120779f, 0.00375309f, 0.00466422f, 
    0.03804696f, -0.05842533f, -0.04523513f, 0.06545073f, -0.12876183f, 0.01448149f, 0.05714490f, 0.25350028f, 
    -0.02959077f, 0.01333660f, 0.04099271f, 0.06232210f, 0.19924007f, 0.07983087f, -0.04354483f, 0.15960065f, 
    0.10412265f, 0.35395890f, 0.22159670f, 0.01433842f, -0.11678348f, -0.02137694f, -0.06348055f, -0.01239169f, 
    -0.09361124f, 0.08226687f, 0.01748591f, 0.02532720f, -0.07788558f, 0.17520814f, -0.10058545f, 0.04328711f, 
    -0.01225296f, 0.12602094f, 0.02035483f, -0.10083310f, 0.13387132f, -0.02173835f, -0.00422659f, 0.06104521f, 
    -0.14289719f, -0.06548737f, -0.15878087f, 0.14377749f, 0.00951140f, 0.05264549f, -0.15368499f, 0.03512916f, 
    0.02545962f, 0.20233995f, -0.02842304f, 0.01851006f, 0.01514687f, -0.00199399f, 0.17640731f, -0.06029298f, 
    0.09919500f, -0.09003290f, 0.06775209f, -0.09126532f, 0.01256513f, -0.08919517f, 0.03271336f, -0.08548321f, 
    0.00977156f, -0.18399632f, -0.04630645f, -0.20318075f, -0.12429999f, -0.22954410f, -0.09902701f, 0.09413889f, 
    -0.07928725f, -0.07556268f, -0.15980481f, -0.16131233f, -0.02128590f, 0.05306526f, 0.01601981f, -0.01834680f, 
    -0.04181883f, -0.07757335f, 0.24361572f, 0.20986517f, -0.15189800f, -0.02586403f, -0.03675320f, 0.10232878f, 
    0.11481623f, -0.09134942f, -0.00190339f, -0.07703538f, -0.02289491f, 0.00938392f, 0.03352601f, -0.04489176f, 
    0.25302914f, -0.10439216f, -0.08309737f, 0.06143158f, -0.05601170f, 0.01263082f, -0.10438711f, -0.20497391f, 
    -0.06987604f, 0.01828882f, -0.04551944f, 0.01203167f, 0.11051125f, 0.12965342f, 0.05799825f, -0.24645902f, 
    0.01020409f, 0.04076265f, -0.35715023f, -0.00279356f, 0.37158966f, -0.09572665f, -0.04973428f, -0.17563216f, 
    0.01983153f, 0.01214470f, 0.11542282f, -0.09090745f, 0.08225343f, -0.00939536f, 0.35447761f, 0.00320960f, 
    0.10659387f, 0.12084389f, -0.04579626f, 0.07208666f, 0.13817678f, 0.16698141f, 0.04819065f, -0.08870338f, 
    0.26556218f, 0.11640636f, 0.23828979f, 0.06550401f, -0.06180875f, 0.11454380f, -0.11739910f, 0.09934071f, 
    -0.11826345f, -0.02448155f, -0.10333343f, -0.09401323f, -0.23014763f, -0.18910231f, -0.13872741f, -0.33375213f, 
    -0.14434515f, -0.35205770f, -0.09704681f, -0.02799295f, -0.19907674f, -0.15018605f, -0.19614719f, -0.21723050f, 
    -0.13065262f, 0.06665029f, 0.23282601f, -0.00487281f, -0.09004891f, 0.02351464f, 0.03276304f, 0.06583464f, 
    0.41620269f, 0.30562299f, 0.23500873f, 0.20008256f, -0.03172311f, 0.01562979f, 0.08334696f, -0.08907338f, 
    -0.05324195f, -0.05877075f, -0.00715097f, 0.05698695f, 0.00081996f, 0.02659933f, 0.15507010f, -0.11248386f, 
    -0.17745015f, -0.30562025f, -0.18179716f, 0.02663562f, 0.02566379f, 0.02024095f, 0.03530512f, -0.12280972f, 
    -0.04517828f, 0.08570004f, 0.22878017f, 0.08715732f, 0.25914893f, 0.12626632f, 0.00247366f, 0.10938163f, 
    0.17795064f, -0.01899069f, -0.01300546f, -0.12840645f, 0.09784526f, 0.03474556f, 0.38689858f, 0.13742834f, 
    0.10620872f, -0.07453441f, -0.09204567f, -0.06782135f, -0.18266045f, -0.03748909f, 0.07533894f, 0.28745148f, 
    0.09433761f, 0.00612960f, 0.00848968f, 0.02723608f, 0.20162094f, 0.07821502f, 0.18397614f, -0.02203913f, 
    -0.06256077f, -0.11004429f, 0.09959152f, 0.00930707f, -0.08175928f, 0.13114132f, -0.08637971f, 0.08712780f, 
    -0.08171918f, 0.15080781f, 0.20214595f, 0.17090684f, 0.16333516f, 0.11471467f, 0.16395444f, 0.08564230f, 
    0.14777921f, 0.11290677f, -0.02524955f, -0.08803575f, -0.09638264f, -0.36748815f, -0.02568851f, 0.12667382f, 
    -0.05926984f, -0.08927734f, 0.03089360f, 0.07053936f, 0.11158911f, 0.03209504f, 0.15141389f, -0.12903008f, 
    0.18706965f, 0.12972434f, 0.05685976f, 0.03090531f, -0.12218171f, -0.23921983f, -0.09955180f, -0.09413537f, 
    -0.05577125f, -0.04344841f, 0.03021560f, 0.01835986f, 0.25182709f, 0.21336856f, 0.29673603f, 0.07279273f, 
    -0.03174493f, 0.11947818f, 0.39367348f, -0.15118125f, -0.19939594f, -0.06675456f, -0.10503140f, -0.05926007f, 
    0.22367562f, 0.32082582f, 0.07025158f, -0.05423548f, 0.11078027f, 0.12453537f, 0.09140502f, 0.00671519f, 
    -0.16806789f, 0.19679341f, 0.11991054f, -0.19743557f, 0.02775466f, -0.00203346f, 0.01127547f, -0.06893324f, 
    -0.01143457f, 0.08946870f, 0.03601056f, 0.03407153f, 0.01387907f, -0.13446961f, 0.11970016f, -0.15681644f, 
    0.12260006f, 0.35470074f, 0.11979257f, 0.11501515f, 0.04877637f, 0.05602691f, 0.01405139f, 0.02777755f, 
    0.17097783f, -0.09394154f, 0.04986062f, 0.23179030f, -0.01742000f, -0.12326160f, -0.32716781f, 0.01747855f, 
    -0.06244681f, 0.04188007f, 0.01074786f, -0.02374203f, 0.00118115f, 0.05262364f, 0.04584793f, 0.04189267f, 
    -0.19592832f, -0.08688789f, -0.10698282f, -0.14442094f, -0.09280720f, 0.01097101f, 0.05748593f, 0.07619236f, 
    0.11083202f, 0.02854514f, 0.18421023f, 0.13254957f, 0.09146725f, 0.27072784f, 0.08584284f, 0.22975735f, 
    0.14165018f, 0.02270605f, 0.15456364f, 0.11558991f, -0.02969035f, -0.01097902f, -0.05307072f, -0.04428104f, 
    -0.05469269f, -0.02032428f, -0.05670602f, -0.11550525f, 0.03213927f, 0.10956801f, 0.02888805f, 0.02745440f, 
    0.17518760f, 0.04853769f, 0.06623810f, -0.07054576f, 0.04548586f, 0.19006376f, -0.00739614f, 0.00278436f, 
    0.05977385f, 0.07060697f, 0.03269948f, 0.16614480f, -0.25833356f, -0.13651606f, -0.08421826f, -0.14100860f, 
    -0.40512174f, -0.08547479f, -0.18265015f, -0.19677149f, 0.08082312f, -0.02309780f, -0.15452442f, -0.22448505f, 
    -0.03872815f, -0.34309098f, -0.04792029f, -0.12082498f, -0.25679776f, -0.21450941f, 0.00451562f, -0.17563434f, 
    0.01987469f, 0.02895231f, 0.03461773f, 0.12455284f, -0.09262593f, 0.16766292f, -0.44981238f, -0.13213074f, 
    0.45756099f, 0.10381869f, -0.01977803f, -0.13344754f, 0.07890832f, -0.01260251f, 0.06464744f, 0.09176717f, 
    -0.12035678f, -0.14834835f, -0.24429278f, -0.13688859f, -0.07314496f, -0.15226054f, -0.08875626f, -0.12451658f, 
    -0.04703515f, -0.00399496f, -0.01452963f, 0.02203132f, 0.17150970f, 0.10158297f, 0.14986858f, 0.09270231f, 
    -0.11715865f, -0.00192605f, 0.02322131f, 0.06492644f, 0.06420927f, -0.09959717f, 0.01276943f, -0.19464387f, 
    -0.37976608f, -0.11126674f, 0.05930550f, 0.02116354f, -0.18744913f, -0.06589914f, -0.17171206f, -0.16164394f, 
    -0.02907494f, -0.13879123f, -0.15667848f, -0.16472124f, -0.12928231f, -0.19733374f, -0.11989911f, -0.26188540f, 
    -0.11483277f, -0.19478106f, 0.16901894f, -0.01793529f, 0.06241034f, -0.19330302f, -0.24777786f, 0.13339888f, 
    -0.36078173f, -0.04710603f, -0.38150355f, -0.29688904f, -0.17802268f, -0.04331197f, 0.00830999f, 0.14180018f, 
    0.01222207f, 0.02737254f, 0.28947419f, -0.09111159f, -0.12983929f, -0.13810508f, 0.11427517f, 0.08468356f, 
    0.02891063f, -0.00936531f, 0.16866933f, -0.01117888f, -0.06030302f, 0.07301781f, -0.34076005f, -0.19768651f, 
    0.07316066f, -0.12526430f, 0.14948530f, 0.14330496f, -0.01146588f, -0.03630222f, -0.05167290f, -0.28403494f, 
    0.16734669f, -0.16089518f, -0.19352747f, 0.05288353f, -0.17449154f, 0.01741098f, -0.03292210f, -0.11005543f, 
    0.10717298f, 0.12316457f, -0.34290549f, -0.10772125f, -0.02020247f, 0.09054870f, -0.01549110f, 0.07589453f, 
    -0.06168950f, -0.09719907f, -0.17518866f, -0.06213930f, -0.06724631f, -0.00549001f, 0.35810527f, 0.11306671f, 
    0.09104788f, 0.22758970f, 0.12520930f, -0.04481084f, -0.06169117f, -0.10480473f, -0.07347954f, -0.09278293f, 
    0.24716333f, 0.14520842f, 0.21407238f, 0.09815437f, 0.05961211f, 0.03112381f, -0.19408661f, -0.08337634f, 
    -0.10529602f, 0.11214896f, -0.28263801f, -0.10126910f, -0.20182896f, -0.16480879f, -0.12811767f, 0.05664722f, 
    -0.05982353f, -0.03805352f, 0.00175263f, -0.09211033f, -0.15910386f, -0.14782123f, -0.19747135f, -0.22137052f, 
    0.15056714f, 0.01191844f, 0.24747938f, -0.14119619f, -0.08340222f, 0.02907314f, 0.06405193f, 0.02727900f, 
    0.17949551f, 0.32197687f, 0.36481661f, 0.23507467f, -0.03406802f, 0.07037939f, 0.05129037f, -0.19770588f, 
    0.08964020f, -0.12076949f, -0.01652833f, 0.07273678f, 0.05327992f, 0.08550520f, 0.24097218f, 0.12568471f, 
    -0.17774695f, -0.16260259f, -0.10316402f, 0.20032530f, -0.15749702f, -0.01041816f, 0.05650006f, 0.08361169f, 
    0.01376234f, 0.12646836f, 0.03889226f, 0.06304945f, 0.18677439f, 0.41895333f, -0.03153985f, 0.10408847f, 
    -0.01781015f, 0.12662184f, 0.04506934f, 0.02697859f, 0.11065352f, 0.10870482f, 0.23078421f, 0.16515309f, 
    0.33926657f, -0.09419453f, 0.06835318f, 0.11236764f, 0.03483446f, -0.06286602f, 0.05078883f, -0.01016911f, 
    0.07526312f, -0.02587774f, 0.09838396f, 0.13655271f, 0.39649224f, 0.07462010f, 0.40719038f, -0.04453401f, 
    0.03172131f, -0.34781083f, -0.01399414f, -0.11324950f, -0.08948550f, 0.28465575f, -0.04777259f, 0.01702599f, 
    0.28163707f, -0.48592231f, 0.30123958f, 0.05006118f, 0.17017873f, 0.02484067f, 0.08212728f, 0.02179108f, 
    0.16304831f, 0.08542760f, -0.07562235f, -0.04977095f, -0.21218038f, -0.19399163f, -0.14825723f, 0.03553472f, 
    0.03075959f, -0.01907363f, -0.12802970f, 0.11637732f, -0.00132335f, -0.02173165f, 0.02068329f, -0.16768034f, 
    0.02549374f, 0.03499819f, -0.00882605f, -0.06762046f, -0.04541455f, 0.03445370f, -0.05600601f, 0.00464972f, 
    0.00616653f, 0.01644767f, 0.05171105f, -0.06334275f, -0.03545098f, 0.03540611f, 0.02963875f, -0.01847656f, 
    0.02867068f, -0.05226051f, -0.01527734f, -0.04746205f, -0.05508828f, 0.02697707f, -0.00200373f, 0.00805037f, 
    -0.04836822f, -0.06439439f, 0.03941977f, 0.00406814f, 0.01791271f, 0.02464681f, -0.05877842f, 0.03949416f, 
    0.05882745f, -0.00809794f, 0.04525063f, -0.02091241f, 0.05395228f, -0.04129731f, -0.04187928f, -0.06262197f, 
    -0.02118088f, -0.07010583f, 0.03397144f, -0.04433517f, 0.04209338f, -0.01297482f, 0.04115667f, -0.07164761f, 
    -0.02252650f, -0.03732836f, 0.03718394f, -0.07640617f, 0.00045179f, 0.00155095f, -0.04053776f, -0.01040708f, 
    -0.00212104f, 0.03171295f, -0.03557803f, 0.03969393f, -0.00752104f, -0.02684764f, -0.04219214f, 0.06039697f, 
    0.05735718f, -0.05797377f, -0.00126858f, -0.02383102f, -0.03074606f, -0.00525463f, -0.01642840f, 0.04557170f, 
    -0.00672278f, -0.02054109f, -0.02762047f, -0.01753021f, 0.02345987f, 0.02372828f, -0.05357447f, 0.05392652f, 
    -0.01877762f, 0.04131843f, -0.05029107f, -0.06694276f, -0.05407281f, -0.07003187f, -0.02349431f, -0.01719356f, 
    -0.00166702f, -0.03467024f, 0.02057767f, -0.04505229f, 0.01424735f, 0.02804309f, -0.00263746f, 0.05586597f, 
    -0.06404159f, -0.03789999f, 0.00229771f, -0.00114196f, 0.01019381f, -0.04197112f, 0.01271618f, -0.03377975f, 
    -0.05636452f, -0.06997116f, -0.08347005f, -0.05783946f, -0.04598751f, 0.05499764f, 0.05396355f, 0.06541964f, 
    -0.06586948f, 0.03439755f, -0.02687977f, -0.06285015f, -0.07904304f, -0.08630451f, -0.02884025f, -0.03346441f, 
    -0.04717953f, -0.03089565f, -0.04179152f, 0.07547490f, -0.05294618f, 0.05341282f, 0.03576961f, -0.02309590f, 
    -0.05621147f, -0.01746279f, -0.02346757f, -0.01225288f, 0.02542995f, -0.06145517f, 0.03496062f, -0.02048147f, 
    -0.01630409f, 0.06440803f, -0.00730686f, -0.03189616f, -0.00174128f, -0.00132052f, 0.05461586f, 0.01109838f, 
    0.04293171f, -0.06725170f, -0.03933170f, -0.01335729f, -0.07294381f, 0.02253516f, 0.05704195f, -0.02521503f, 
    -0.01401613f, 0.01789866f, -0.05801185f, -0.06341630f, -0.04504630f, 0.04610642f, 0.04394554f, 0.00656651f, 
    -0.04696804f, -0.08271107f, 0.03459819f, -0.01786528f, 0.00832155f, 0.05132287f, -0.02089020f, -0.04610555f, 
    0.06021933f, -0.05114219f, -0.04027227f, 0.01769772f, -0.01335638f, 0.03331881f, -0.06600717f, -0.07167751f, 
    0.02118572f, 0.01123312f, 0.01137685f, 0.01851596f, -0.01413658f, 0.04054533f, 0.02916479f, 0.04232784f, 
    0.06541446f, 0.03965833f, -0.06081709f, -0.07751189f, -0.01724434f, -0.01728674f, -0.01149028f, -0.01669668f, 
    -0.14637661f, -0.07468622f, -0.11941277f, -0.05816443f, 0.10727947f, -0.01253541f, 0.31782907f, 0.02872958f, 
    -0.03617511f, 0.01069712f, 0.04718427f, 0.00306126f, -0.02044767f, -0.17265815f, -0.55615520f, -0.06928161f, 
    0.04920365f, -0.03586649f, 0.06604529f, 0.11385144f, -0.18138567f, 0.03772777f, -0.04226153f, -0.09713988f, 
    0.05244147f, 0.07070185f, 0.04193707f, -0.07347565f, -0.10376304f, 0.06017701f, -0.00691688f, -0.00479225f, 
    0.18038952f, 0.04648415f, -0.00521547f, 0.19430293f, 0.11519848f, 0.18088581f, 0.07794330f, -0.18565115f, 
    -0.05009894f, -0.04071077f, -0.10479121f, -0.10661624f, 0.06899147f, 0.06946111f, 0.01073861f, 0.10269007f, 
    0.46764770f, 0.00460605f, 0.00099952f, -0.33245766f, -0.02301242f, -0.11289916f, -0.13754198f, 0.05354152f, 
    0.04151092f, -0.00103826f, -0.00053977f, 0.00235865f, -0.09986212f, 0.04048428f, 0.20037341f, -0.04073669f, 
    0.18965043f, 0.09922690f, 0.13803369f, 0.09098741f, 0.07847266f, -0.00674207f, -0.09958699f, 0.00813181f, 
    0.21810766f, 0.08241673f, -0.14257467f, 0.22182301f, -0.06861221f, 0.01653009f, 0.03266828f, -0.07618552f, 
    -0.02681977f, 0.08897711f, -0.09980281f, -0.03046926f, -0.35270581f, -0.39933047f, -0.35490322f, -0.40532127f, 
    -0.02138977f, -0.05248762f, -0.02238987f, 0.03632776f, -0.03443632f, -0.03144154f, -0.06745665f, 0.03390723f, 
    -0.11957303f, 0.01847001f, 0.02540766f, -0.02758345f, -0.06337286f, 0.02384269f, 0.07648619f, 0.05917526f, 
    -0.18497832f, 0.03676297f, -0.10628950f, -0.11987809f, -0.01693374f, 0.03239531f, -0.06129543f, -0.20466416f, 
    -0.11062102f, 0.02391301f, 0.09347770f, -0.01566212f, 0.19546388f, 0.06397990f, -0.07912860f, -0.18710631f, 
    -0.08499058f, -0.40186062f, -0.21370690f, -0.22179641f, -0.02545889f, 0.04916685f, 0.06139656f, 0.05612959f, 
    0.01798988f, 0.13921796f, 0.24423550f, 0.19064735f, 0.10955278f, -0.07289735f, 0.05969000f, -0.31678253f, 
    -0.07972728f, -0.00830585f, 0.02671546f, -0.11129998f, 0.06575867f, 0.16812094f, 0.15673207f, 0.00701277f, 
    -0.39593959f, -0.32737523f, -0.24741536f, 0.09572379f, 0.03549518f, -0.00870558f, -0.14154588f, 0.18228775f, 
    -0.00467633f, 0.18340413f, 0.12932399f, 0.02008344f, 0.08605215f, 0.09540865f, 0.13161762f, 0.15324357f, 
    0.06159161f, -0.04645391f, -0.02708125f, -0.04516439f, -0.14987619f, 0.00594659f, 0.05330269f, -0.12620789f, 
    -0.06569915f, 0.02858405f, -0.00659709f, -0.26612058f, -0.13875887f, 0.24274397f, 0.40107059f, 0.00238188f, 
    -0.05367702f, -0.11214916f, -0.17425637f, -0.02684450f, 0.13890448f, -0.32942614f, -0.27667832f, -0.22679210f, 
    -0.03904208f, -0.03654445f, 0.07687775f, -0.06647407f, 0.03879188f, -0.04838669f, -0.15670423f, 0.10808476f, 
    0.03821078f, -0.03780673f, -0.06894962f, 0.06030845f, -0.03112982f, -0.07235239f, -0.04197330f, -0.02963695f, 
    0.03439002f, -0.01455509f, 0.05539314f, -0.03643407f, 0.01867117f, -0.02798959f, 0.03262922f, -0.00395868f, 
    -0.03819902f, -0.01251244f, 0.03457885f, -0.04090007f, -0.05486219f, -0.02932144f, -0.05317350f, 0.00382271f, 
    0.03291623f, 0.00007614f, -0.06135714f, 0.05270508f, -0.00453139f, -0.01700611f, 0.05100901f, -0.06745303f, 
    -0.06971199f, 0.01454309f, -0.05856431f, -0.05357775f, 0.01254296f, -0.03225486f, -0.04820255f, 0.00122622f, 
    -0.02711299f, 0.01998518f, -0.04147583f, -0.04717522f, -0.00403294f, -0.03720200f, 0.03676400f, -0.06044851f, 
    -0.07384279f, 0.05975923f, -0.00693882f, 0.06182155f, -0.03399495f, 0.03372750f, 0.05050141f, 0.05531476f, 
    -0.02581619f, 0.04211378f, -0.07087097f, -0.05879238f, -0.04103588f, -0.00507052f, -0.03732635f, -0.03939714f, 
    -0.06511062f, -0.00702071f, -0.06287587f, -0.05947595f, 0.06178954f, -0.00375468f, -0.01126758f, 0.05661877f, 
    -0.05207827f, 0.03223102f, -0.01309784f, 0.05632150f, 0.04764478f, 0.03586964f, 0.03684711f, -0.04298234f, 
    -0.04732088f, -0.03821214f, 0.02288999f, -0.07019424f, 0.06610662f, 0.02557867f, -0.00823916f, -0.05594198f, 
    -0.05285567f, -0.05428538f, 0.05950487f, 0.02796538f, 0.04284630f, 0.03504488f, -0.07015278f, 0.00414140f, 
    0.03599543f, 0.04428676f, -0.04194392f, 0.05093119f, 0.06125301f, -0.03739947f, 0.05983568f, 0.03104202f, 
    -0.01715131f, -0.02991372f, -0.00303853f, 0.00402027f, -0.03974279f, -0.06163580f, -0.02944045f, -0.01851828f, 
    -0.02445216f, 0.06513430f, 0.01384571f, 0.01479737f, 0.00690509f, 0.03521931f, 0.01908213f, -0.03576678f, 
    0.00791126f, 0.02082250f, -0.05610146f, -0.05801714f, -0.03218715f, -0.06445158f, -0.05970376f, -0.00024020f, 
    0.01385058f, 0.01997875f, -0.03387328f, -0.01212958f, 0.02794066f, -0.03040931f, -0.06259779f, 0.02685477f, 
    0.03499801f, -0.05199879f, -0.00622311f, -0.05570835f, -0.04419636f, -0.01028703f, -0.05609838f, -0.06333438f, 
    0.01792886f, 0.00201533f, -0.06277904f, 0.02311185f, -0.03766407f, -0.00652970f, -0.07458884f, 0.04590536f, 
    -0.03356478f, -0.07409452f, -0.05824547f, -0.04114595f, 0.01117302f, 0.06240228f, -0.05243996f, 0.06035990f, 
    0.05233796f, -0.00128955f, -0.07380204f, 0.01917657f, 0.03806295f, -0.06455225f, -0.03229710f, 0.05207785f, 
    -0.02203218f, -0.02879601f, -0.05931742f, -0.04185898f, -0.04808080f, -0.00129373f, 0.02474522f, -0.02706153f, 
    -0.04159447f, -0.02766129f, -0.07626220f, -0.05918623f, -0.03186978f, -0.06606563f, -0.01519682f, -0.00555235f, 
    -0.00652250f, 0.01656693f, -0.01448157f, 0.04860070f, -0.01402582f, 0.06331653f, -0.02413082f, -0.04756500f, 
    0.07210382f, -0.16242142f, -0.19856624f, -0.17683995f, -0.10186750f, 0.19981010f, 0.07479186f, -0.15388767f, 
    0.25461036f, 0.09791432f, 0.08853001f, 0.15804178f, 0.23402584f, 0.09048229f, -0.03844618f, -0.10652107f, 
    0.08165298f, 0.02940764f, 0.08459738f, 0.17233165f, -0.02526269f, 0.06187343f, -0.16415247f, -0.12154136f, 
    0.04172438f, -0.19528738f, 0.04917969f, 0.03466067f, -0.16823782f, -0.13655345f, -0.09908091f, 0.00857963f, 
    0.17240827f, 0.25766429f, 0.06563202f, 0.25445783f, 0.15508941f, 0.00212132f, -0.16839392f, -0.04201400f, 
    -0.20917377f, -0.16593198f, 0.09694798f, -0.06860846f, 0.20508616f, -0.19477695f, 0.20255001f, 0.15147957f, 
    0.01613901f, 0.16641995f, 0.16942245f, 0.21927916f, 0.16341954f, 0.17476980f, 0.05996888f, -0.01086807f, 
    0.11738284f, 0.10542660f, 0.07821627f, 0.26639572f, -0.16316903f, -0.14156462f, -0.26756406f, 0.09633953f, 
    0.07717950f, -0.03883900f, 0.12287997f, 0.03842771f, -0.09707994f, 0.17739287f, -0.05897712f, 0.01748983f, 
    -0.11030407f, 0.27156112f, 0.38463718f, -0.00108051f, -0.18937980f, -0.06205361f, -0.21800838f, 0.12932388f, 
    0.07240943f, -0.13195223f, 0.04203148f, 0.12578344f, 0.01330677f, -0.09940387f, -0.15412883f, -0.12767649f, 
    0.22984198f, 0.08865102f, 0.12362462f, 0.10333979f, -0.16923589f, 0.01871552f, -0.03382398f, -0.04280918f, 
    -0.30776465f, -0.07128903f, -0.12292202f, 0.18104200f, 0.02250963f, -0.01775700f, -0.10532793f, 0.01394335f, 
    -0.08258949f, -0.21636051f, -0.22349662f, -0.31898707f, -0.10181087f, -0.16848059f, 0.09366084f, -0.08705138f, 
    -0.05781895f, -0.18261442f, -0.03143124f, -0.09580830f, 0.16573651f, 0.00316338f, 0.06310578f, -0.04254923f, 
    0.15568338f, 0.22806054f, 0.02479962f, -0.13182074f, 0.10893340f, 0.13125420f, -0.14937383f, 0.30417982f, 
    -0.09006764f, -0.28825665f, -0.00638828f, -0.18050855f, 0.24083287f, 0.20831007f, -0.06154567f, 0.27503720f, 
    -0.07225976f, -0.01809263f, -0.06689833f, -0.03380599f, -0.03781588f, -0.16303141f, -0.17929661f, -0.19521911f, 
    -0.05425826f, -0.14720866f, -0.02019193f, -0.09774688f, -0.06748474f, 0.21104142f, 0.00654037f, 0.02385502f, 
    0.09123315f, 0.09578444f, -0.07014073f, 0.00533660f, -0.22577299f, -0.00914478f, 0.02176430f, 0.31935391f, 
    -0.14857151f, 0.01786787f, -0.14571418f, 0.06316923f, -0.04362661f, -0.19092007f, 0.00200493f, -0.11603854f, 
    -0.09608919f, 0.35621384f, -0.08259849f, 0.06403601f, 0.16041155f, 0.10648745f, -0.00731871f, 0.00465014f, 
    -0.12456282f, -0.11647359f, -0.11373684f, 0.26223731f, 0.15991604f, 0.19512483f, 0.00743018f, -0.01635466f, 
    0.18600166f, 0.01996938f, 0.20891835f, 0.11494263f, 0.01168022f, 0.06402428f, 0.01529355f, -0.02338762f, 
    -0.07941268f, -0.01205188f, -0.04259481f, -0.14386530f, -0.04461340f, 0.05675293f, 0.06697339f, 0.02031465f, 
    -0.10771918f, 0.16693911f, 0.05158564f, 0.01184958f, -0.07890426f, 0.10546450f, 0.15321600f, 0.14294100f, 
    0.07143017f, -0.00199235f, -0.18924709f, -0.03543038f, -0.07866473f, -0.09706850f, -0.06897864f, -0.16619784f, 
    0.05162973f, -0.01115502f, 0.03309376f, -0.08724212f, 0.02900328f, -0.00290039f, 0.08247939f, -0.00192500f, 
    0.12524953f, 0.15149452f, 0.07894748f, 0.13564746f, 0.03374180f, 0.10132663f, -0.08814121f, -0.07880016f, 
    -0.13410579f, -0.07389639f, 0.02520662f, -0.07515106f, 0.27177301f, 0.26248112f, 0.04090021f, -0.17094843f, 
    0.06758408f, -0.23205701f, 0.06438520f, -0.10032428f, 0.03586176f, 0.00522509f, 0.05014956f, 0.02873022f, 
    0.07988652f, 0.04339189f, 0.21395321f, 0.08893207f, 0.05031132f, 0.18399549f, 0.19489484f, 0.01737867f, 
    0.06573069f, 0.12582998f, 0.01014198f, -0.01724990f, -0.08541165f, -0.06289150f, 0.11925771f, 0.02548748f, 
    0.35727173f, 0.25497141f, 0.24088222f, 0.29101565f, 0.09629447f, -0.10943738f, -0.10805647f, -0.03546832f, 
    -0.15036175f, -0.14845017f, -0.00462409f, 0.05425319f, 0.04389848f, -0.13750932f, 0.07474510f, 0.03482480f, 
    -0.05383975f, -0.02817378f, 0.18319465f, 0.10376844f, -0.02969377f, -0.01374972f, -0.07748356f, 0.03498298f, 
    0.10922758f, -0.17172667f, 0.16558850f, 0.15460369f, 0.00612890f, 0.05884830f, -0.04599236f, 0.00442775f, 
    -0.02385659f, -0.16972896f, -0.04209482f, 0.01341947f, -0.12869962f, -0.10644387f, -0.40826476f, -0.01436199f, 
    -0.15853693f, -0.07137892f, 0.02451584f, -0.01674620f, 0.05311832f, -0.11436628f, 0.03276918f, 0.13647027f, 
    -0.04145043f, -0.11865579f, 0.02133706f, 0.09598508f, -0.03034963f, -0.01562342f, 0.01614215f, 0.06844710f, 
    -0.00733861f, 0.00125293f, 0.05333538f, -0.04917724f, 0.02750252f, -0.25651902f, -0.00183070f, -0.21164890f, 
    0.04377193f, -0.06417280f, 0.04796325f, -0.03126799f, -0.07959827f, -0.06224908f, -0.10478723f, -0.05316658f, 
    -0.31480259f, 0.15093172f, -0.10325376f, 0.03645708f, -0.02434044f, -0.09123506f, -0.03475075f, 0.04297115f, 
    0.03429854f, 0.03040297f, -0.08975111f, -0.07636803f, 0.41703027f, 0.14822659f, 0.42681989f, 0.20908797f, 
    0.03792337f, -0.05164823f, -0.17017663f, -0.00872974f, -0.08073674f, -0.04289792f, -0.01161805f, 0.03305657f, 
    0.07527116f, -0.31219360f, 0.06851124f, -0.04053642f, 0.03289253f, -0.04885970f, 0.08612535f, 0.24576110f, 
    0.05145095f, -0.11275528f, 0.10143020f, 0.01186097f, -0.07307004f, 0.05624034f, 0.11175084f, 0.04848895f, 
    -0.03466949f, -0.02827924f, 0.12970847f, -0.00411232f, 0.13542393f, 0.05244133f, 0.00150111f, 0.05137867f, 
    0.03379629f, 0.04419293f, 0.13871671f, -0.05245562f, 0.06168682f, -0.11586763f, -0.02424890f, 0.04621286f, 
    -0.20869018f, -0.23196940f, -0.11553814f, -0.10688170f, 0.15759316f, 0.04725784f, 0.20892684f, 0.13885015f, 
    0.06646234f, 0.02313984f, -0.08131685f, -0.02898006f, 0.07473100f, 0.09981927f, -0.06166379f, 0.01177643f, 
    0.17432621f, 0.22992855f, 0.14673549f, -0.01132561f, 0.01339708f, -0.00344994f, -0.07852998f, -0.01746505f, 
    -0.06694631f, -0.23286575f, -0.05659449f, -0.14344856f, 0.05838498f, -0.10777992f, 0.18406886f, 0.04744949f, 
    0.13586751f, 0.07420822f, -0.02449362f, -0.04352869f, 0.02854522f, -0.06997775f, -0.08803459f, -0.14269507f, 
    -0.28756022f, -0.02805302f, 0.08127733f, 0.12168200f, -0.11962919f, 0.00994566f, 0.08779247f, -0.12181658f, 
    -0.13590783f, -0.12907587f, -0.08631963f, -0.23452620f, 0.10913812f, 0.23367415f, -0.27385184f, -0.02689120f, 
    -0.03971558f, -0.11882152f, 0.06358218f, -0.06727792f, -0.15396282f, -0.09472894f, -0.14616475f, -0.09652663f, 
    -0.18878648f, -0.24850798f, -0.17891499f, -0.21641973f, 0.03667380f, 0.09365354f, 0.04753572f, -0.03800985f, 
    -0.04667590f, -0.07217050f, -0.07706890f, -0.07049533f, 0.04512510f, 0.26167205f, 0.11080898f, -0.03649731f, 
    -0.21780387f, -0.17628327f, 0.01077791f, 0.05050849f, -0.12237291f, -0.07195089f, 0.07874746f, -0.10480905f, 
    0.16914691f, -0.04832541f, -0.03981555f, -0.01340037f, -0.00391608f, -0.08576258f, -0.01268809f, -0.06743929f, 
    -0.08236340f, 0.08932125f, -0.03438411f, 0.34336418f, 0.31460458f, 0.23818843f, 0.14613557f, 0.10198897f, 
    -0.14263003f, -0.00404734f, -0.07178547f, -0.03518081f, -0.01099971f, -0.01896744f, -0.07749177f, -0.01096333f, 
    -0.12257437f, 0.02234136f, -0.05912243f, 0.07305747f, -0.09414096f, 0.03030648f, 0.04791607f, -0.11979543f, 
    -0.04935217f, 0.17974532f, 0.02654801f, 0.08145083f, -0.02355229f, -0.16174702f, 0.09847652f, 0.08103184f, 
    -0.03214021f, 0.04976264f, 0.04186643f, -0.02552673f, 0.16309440f, 0.17725497f, 0.09065998f, 0.15503819f, 
    0.21876580f, 0.23560186f, 0.12425031f, 0.09175234f, -0.03478545f, -0.11290600f, -0.08874587f, -0.02773911f, 
    -0.08766077f, 0.00897111f, 0.05984405f, 0.17514260f, -0.25414038f, 0.03964072f, -0.23438831f, -0.11007483f, 
    0.07468775f, -0.02862343f, -0.00845164f, -0.11721569f, -0.07573865f, -0.14429511f, -0.02658176f, 0.10030015f, 
    -0.05076446f, -0.31521857f, -0.13784751f, 0.18149441f, -0.15032496f, -0.03258900f, -0.09287859f, -0.11263806f, 
    0.19341013f, 0.23644388f, 0.05700869f, -0.05219436f, -0.06192698f, -0.12716417f, 0.15982513f, -0.07279646f, 
    0.08897901f, -0.02828234f, -0.02649421f, -0.17052278f, -0.13671331f, -0.02274519f, -0.10383195f, -0.10273643f, 
    -0.06345452f, -0.15610942f, -0.11475894f, -0.01459180f, -0.02794348f, -0.08065213f, -0.00435576f, -0.06169313f, 
    0.21478499f, -0.05008506f, 0.11861245f, 0.13032469f, -0.40237811f, 0.02966320f, 0.09284928f, -0.13441780f, 
    -0.11713272f, -0.06890713f, 0.03161404f, 0.17695713f, -0.06588252f, -0.01895439f, -0.01992423f, 0.05875675f, 
    0.01277266f, 0.09417012f, -0.00650845f, 0.08188403f, -0.10417748f, -0.18656699f, -0.02342352f, -0.03037472f, 
    0.08519660f, 0.21644488f, -0.05332461f, 0.11205479f, -0.05348507f, 0.05049625f, -0.02565445f, 0.00048076f, 
    0.04421462f, -0.13729936f, -0.07737006f, 0.02722314f, -0.06150773f, -0.02446136f, 0.03542418f, 0.08404323f, 
    0.07121070f, -0.30717012f, 0.10622259f, -0.04390591f, -0.00256655f, -0.13137257f, -0.25045764f, 0.07240409f, 
    -0.06249899f, -0.00801751f, 0.09424204f, -0.00049307f, -0.12338983f, 0.10506255f, -0.03331408f, -0.07036354f, 
    0.20373316f, 0.18375896f, -0.03155043f, -0.00935993f, 0.04123615f, -0.06046931f, -0.03556386f, -0.00540952f, 
    0.19420093f, -0.01939859f, -0.29765418f, 0.08853639f, 0.00622931f, 0.04907440f, 0.04639311f, -0.01140547f, 
    0.03659696f, 0.04797584f, 0.05935735f, -0.09252438f, -0.07295807f, -0.11735644f, 0.02375029f, -0.00252318f, 
    -0.08410548f, 0.00344574f, -0.06591141f, -0.01136960f, 0.15051022f, 0.00362002f, -0.08253591f, 0.03614459f, 
    0.18201675f, 0.04060719f, -0.14794201f, -0.01582051f, -0.08062588f, -0.01106237f, 0.06730273f, -0.11017346f, 
    -0.00491704f, -0.09308302f, 0.03289172f, -0.26926911f, -0.13136914f, -0.04626830f, 0.10470360f, 0.01852243f, 
    0.01694576f, -0.05590080f, -0.05134327f, 0.07767861f, 0.13214068f, 0.03230236f, 0.02199618f, -0.02275556f, 
    0.15389389f, -0.11020807f, 0.23665325f, -0.00407453f, 0.06496119f, 0.12423790f, 0.00743627f, -0.03016032f, 
    -0.02846239f, -0.05405569f, 0.27128676f, -0.00195868f, 0.00572095f, -0.21718407f, -0.08188339f, -0.19054629f, 
    -0.07971504f, -0.09040421f, -0.02534512f, 0.01103933f, 0.19096799f, 0.14482188f, -0.06972959f, 0.04309058f, 
    -0.21814087f, 0.11941683f, 0.12053414f, 0.06811731f, 0.00371343f, -0.11449475f, 0.23201634f, 0.10476261f, 
    0.15079504f, 0.04585414f, 0.00889840f, 0.01163089f, -0.04124394f, -0.02987910f, -0.24965926f, 0.00913137f, 
    0.04021040f, 0.07106649f, -0.02523353f, 0.02956580f, -0.10105094f, -0.05092872f, -0.10194572f, -0.08831690f, 
    0.08233613f, 0.01526796f, -0.01419903f, -0.24413568f, 0.02269175f, -0.14640358f, 0.23436779f, 0.14830334f, 
    0.04759761f, 0.04530023f, 0.06090250f, -0.24427088f, -0.03732156f, -0.00570631f, -0.04080492f, -0.00561806f, 
    -0.03561281f, 0.06571241f, -0.07607482f, 0.03665504f, -0.09475551f, 0.08358710f, 0.02392449f, 0.24373639f, 
    -0.05662466f, 0.01250115f, -0.01601038f, 0.05514666f, 0.05270890f, 0.09194354f, -0.00690827f, 0.11057267f, 
    -0.21374218f, 0.06012246f, -0.01683076f, -0.16046257f, 0.26214993f, 0.28477883f, 0.35096803f, -0.03022230f, 
    0.15789822f, -0.08111253f, 0.03296281f, -0.20873472f, 0.06265844f, -0.08692534f, -0.07078375f, -0.16364445f, 
    0.08661511f, -0.07559803f, 0.19881479f, -0.05428530f, -0.02908815f, -0.01723516f, 0.11865053f, -0.01403868f, 
    0.13004400f, 0.22190575f, 0.01691271f, 0.15410715f, -0.05104661f, 0.06848761f, 0.12040767f, 0.13090867f, 
    -0.01847794f, -0.04451042f, 0.00833888f, 0.05361298f, 0.20551662f, 0.13456361f, -0.05034048f, 0.02352653f, 
    -0.42369041f, 0.04689036f, 0.17809993f, 0.05511869f, -0.03889958f, 0.00922518f, 0.04016927f, 0.09257675f, 
    -0.15544097f, 0.07575019f, 0.01828893f, 0.18019633f, 0.19831590f, -0.04074997f, -0.07900536f, -0.25928292f, 
    0.01192752f, -0.00268763f, 0.01525591f, -0.14492878f, -0.08658165f, 0.04047409f, 0.02127323f, 0.07263110f, 
    0.43410468f, -0.11512061f, 0.14976208f, 0.21767980f, 0.02841244f, -0.05133993f, 0.09894526f, 0.08315986f, 
    -0.07238585f, -0.02326470f, 0.07760502f, -0.11159324f, -0.05864418f, 0.00575961f, 0.03103312f, -0.10215577f, 
    0.02336280f, 0.04349527f, 0.04363747f, -0.19006279f, -0.12225327f, 0.03920384f, -0.07594071f, -0.11466040f, 
    0.24271095f, -0.30702704f, 0.05755377f, -0.18022436f, -0.00783618f, -0.06263318f, -0.13655770f, 0.01449790f, 
    0.03086797f, 0.04983771f, -0.00590456f, 0.08322931f, -0.14467186f, 0.19068398f, -0.07844400f, 0.07334010f, 
    -0.17508562f, 0.02661575f, 0.02894892f, 0.02838756f, 0.03102133f, -0.07695428f, 0.11659987f, 0.04359303f, 
    -0.32864743f, -0.07891645f, -0.14019918f, 0.00715572f, -0.09796775f, -0.00567342f, 0.02013184f, 0.05658144f, 
    0.00768920f, -0.03521252f, 0.00008022f, 0.04390418f, -0.00976977f, -0.28322163f, 0.04725651f, -0.26751223f, 
    0.05027802f, 0.08870764f, 0.01703842f, -0.04377793f, 0.04285606f, -0.03510769f, -0.01132706f, 0.04787716f, 
    -0.18244582f, 0.28537238f, 0.08438709f, -0.18366390f, -0.01432294f, -0.05849398f, -0.05597040f, 0.05462697f, 
    -0.00002482f, 0.05502464f, 0.01811751f, -0.03139745f, 0.37267065f, 0.01459185f, 0.43013477f, -0.21128325f, 
    -0.07649432f, -0.03466834f, 0.05274415f, -0.05418491f, 0.01254853f, 0.03235245f, -0.00507228f, 0.04146776f, 
    -0.14267682f, -0.27141738f, 0.00020536f, -0.09270645f, 0.11725700f, 0.02651006f, -0.00865129f, 0.36062238f, 
    0.12867974f, -0.07003325f, -0.06539883f, 0.08484460f, -0.05342770f, -0.05134551f, 0.22325402f, -0.09630258f, 
    -0.02854037f, 0.06671742f, 0.09299903f, -0.25855035f, -0.07636890f, -0.03035719f, 0.04777328f, -0.15285082f, 
    -0.24011661f, -0.13146868f, -0.07920123f, 0.19896823f, -0.05971628f, 0.05230583f, -0.05678357f, -0.38345212f, 
    -0.15224890f, -0.12798668f, -0.09142657f, -0.07672596f, -0.36688811f, -0.00933532f, -0.26405218f, 0.05081782f, 
    0.10873066f, 0.07161555f, 0.17186394f, 0.27319002f, 0.01325938f, -0.02103734f, 0.07506071f, 0.30136341f, 
    0.25943929f, 0.12224682f, -0.15680577f, -0.15392458f, -0.17672010f, -0.09547472f, -0.29342669f, -0.22327900f, 
    0.03811445f, 0.13013135f, -0.09401747f, -0.06605334f, 0.03606926f, 0.22745685f, 0.08573280f, -0.26235169f, 
    -0.07079572f, -0.00780364f, -0.05244091f, -0.23900259f, -0.05516934f, -0.04297838f, -0.09179439f, 0.04619591f, 
    0.19135222f, -0.08253696f, 0.37433147f, -0.12153833f, -0.02994551f, 0.03713435f, -0.19652709f, 0.02623419f, 
    -0.33856282f, -0.14080508f, -0.02055536f, -0.31030172f, 0.00863591f, 0.22267476f, 0.09319121f, 0.50495613f, 
    0.06696456f, 0.04898222f, 0.02110378f, 0.30766419f, -0.03324315f, 0.03760481f, -0.17574593f, -0.18783297f, 
    -0.10432293f, 0.08926571f, -0.10005104f, 0.19738805f, -0.03357310f, -0.08106010f, 0.24575618f, -0.15308236f, 
    -0.22766343f, -0.15784775f, -0.00639816f, -0.00119616f, 0.19322012f, 0.13359600f, 0.14415853f, 0.25162998f, 
    0.08788487f, 0.00714807f, -0.19189663f, 0.11115969f, 0.20039119f, 0.02707140f, -0.04485513f, 0.02485253f, 
    0.09533704f, 0.07484541f, -0.29381454f, 0.41791269f, -0.06466065f, -0.23772129f, 0.08766911f, 0.12978408f, 
    0.01124061f, 0.01286217f, -0.08275095f, 0.11784366f, 0.06112709f, 0.10879168f, 0.09588277f, -0.39119720f, 
    -0.09623860f, 0.00198177f, 0.01252369f, -0.02216919f, 0.10879132f, 0.12218520f, 0.02882804f, -0.17352846f, 
    0.19906813f, 0.05427465f, 0.29747742f, 0.32066637f, 0.13435961f, -0.07723312f, 0.05796821f, -0.17345570f, 
    0.10162739f, 0.23499916f, -0.02480258f, 0.18315461f, 0.29144976f, 0.19597414f, 0.10770369f, -0.39300767f, 
    -0.24248721f, -0.03101329f, 0.01578939f, -0.22125117f, 0.09105607f, 0.14315429f, -0.01425675f, 0.15560587f, 
    0.30915338f, -0.14677387f, -0.06392509f, 0.14984465f, -0.08766779f, -0.07984698f, 0.10493388f, 0.06286349f, 
    0.10147569f, 0.00255490f, 0.02338286f, 0.08721936f, -0.11468051f, 0.03447462f, -0.18720606f, -0.05327158f, 
    -0.06540687f, 0.02696423f, 0.15024418f, 0.02131200f, -0.10638648f, -0.26241720f, -0.22305466f, -0.18089668f, 
    0.72964650f, 0.00460203f, 0.12461254f, 0.07852051f, -0.11442283f, -0.08089320f, 0.11327592f, 0.21062562f, 
    0.08167909f, 0.01451533f, 0.06039536f, -0.06560341f, 0.15888393f, 0.08018605f, -0.07459828f, 0.26634374f, 
    0.10038909f, 0.13896790f, -0.19672231f, 0.04844312f, 0.07095123f, 0.08706284f, -0.18122159f, -0.02584212f, 
    0.06778061f, 0.02383379f, -0.04788170f, 0.01653359f, 0.05476432f, 0.04880908f, -0.02033116f, -0.00220915f, 
    -0.04836519f, -0.02281461f, -0.02054650f, -0.02049855f, 0.01643761f, 0.01696511f, -0.06493505f, -0.05311526f, 
    -0.04695825f, -0.06863315f, -0.04427858f, 0.00067165f, 0.02979802f, -0.02939226f, -0.02677865f, -0.01916188f, 
    0.02023228f, 0.03127486f, -0.04968948f, 0.04185653f, 0.02783676f, 0.01873756f, -0.05680020f, -0.01942658f, 
    0.03410498f, 0.02718997f, -0.04862559f, -0.06821828f, -0.01613479f, -0.03645862f, 0.00477357f, -0.04916717f, 
    0.01419779f, -0.07045027f, -0.07081393f, 0.06157216f, -0.05131221f, -0.05188470f, -0.02090614f, 0.05021865f, 
    -0.05489091f, 0.06458993f, 0.03429383f, 0.03502681f, 0.01390619f, -0.02129991f, -0.05836304f, -0.02397973f, 
    -0.05459414f, 0.01677628f, 0.04094601f, -0.05987690f, 0.01354396f, -0.07162565f, -0.07482108f, 0.05446946f, 
    -0.01530259f, -0.05998442f, -0.03398390f, 0.04022121f, 0.03583571f, 0.01526426f, 0.00705110f, 0.06440090f, 
    0.04460675f, 0.05233194f, 0.02765854f, 0.02376481f, 0.05095174f, 0.04445945f, 0.01174107f, 0.00188511f, 
    -0.06704520f, 0.01841350f, -0.06759284f, -0.02589499f, 0.00250527f, -0.02456304f, 0.06974109f, 0.06893513f, 
    0.01669826f, 0.02349568f, -0.06120589f, -0.03753522f, 0.04499620f, -0.01426701f, -0.06330002f, -0.01144062f, 
    -0.02828116f, 0.02844447f, -0.05470379f, 0.04886145f, 0.06525409f, 0.05458033f, 0.05083898f, 0.03263789f, 
    0.04255336f, 0.01365805f, 0.03279195f, -0.06467336f, -0.03713747f, 0.01255684f, -0.01931334f, 0.01208493f, 
    -0.01022419f, 0.00835940f, -0.04846844f, -0.06742714f, -0.07170848f, 0.01035638f, -0.07483522f, -0.06867169f, 
    0.00222522f, -0.07191528f, 0.05398207f, -0.02652946f, -0.05406042f, 0.03345684f, 0.03069094f, 0.01287848f, 
    -0.07534766f, 0.00445848f, -0.04357065f, -0.06603418f, 0.02408984f, 0.03833745f, 0.06549256f, 0.05336745f, 
    -0.00902243f, -0.03186118f, 0.04983303f, -0.05483330f, -0.00126477f, -0.03790108f, -0.05973545f, -0.01912285f, 
    -0.05770485f, 0.00217756f, -0.05132237f, -0.07188005f, -0.01479137f, 0.05672427f, -0.00169518f, -0.03704947f, 
    -0.02422342f, -0.02626891f, 0.04610800f, -0.06003914f, 0.05689185f, -0.07346516f, -0.02541430f, -0.06518874f, 
    -0.01467626f, -0.05037456f, -0.05876135f, -0.02513377f, -0.03562563f, -0.04442654f, -0.04280252f, -0.02646272f, 
    -0.03991801f, 0.01316008f, 0.00017040f, -0.01139972f, 0.06862386f, -0.03732445f, -0.02889009f, 0.02264550f, 
    -0.06778246f, 0.01262796f, -0.05673609f, -0.04811829f, 0.00141755f, 0.06296680f, -0.06004656f, -0.04504617f, 
    0.02852535f, -0.01188644f, -0.04033224f, 0.00123412f, 0.01748683f, 0.05094533f, 0.01746397f, -0.01045806f, 
    -0.04537920f, 0.15140213f, -0.11062686f, -0.00266727f, 0.10745335f, 0.18540184f, -0.16021998f, 0.03799538f, 
    -0.12675746f, 0.06271908f, 0.09115507f, -0.02583500f, -0.05951766f, 0.01744275f, 0.34917152f, 0.31238401f, 
    0.00550422f, 0.01602169f, -0.13125874f, -0.32543114f, -0.02427061f, -0.03930926f, -0.06254088f, -0.13832083f, 
    0.26820040f, 0.03807655f, 0.09964399f, -0.18091491f, -0.00517005f, 0.01524807f, 0.08946911f, -0.01120152f, 
    0.06995270f, -0.07517753f, 0.22963914f, -0.09941712f, 0.05472380f, 0.02373102f, -0.10023333f, 0.00605527f, 
    -0.02324080f, 0.04391571f, 0.03296424f, 0.08852079f, 0.16688755f, 0.23757622f, 0.01639058f, 0.05033251f, 
    -0.11393410f, -0.02193684f, -0.04205311f, 0.07717565f, -0.12354079f, 0.25536785f, 0.14315696f, -0.19505988f, 
    0.07814807f, -0.01307479f, 0.08917449f, 0.09527906f, -0.14578496f, -0.01854822f, 0.14766434f, 0.21282800f, 
    -0.09118038f, -0.05371892f, -0.06111558f, -0.11904801f, 0.02811264f, -0.04289662f, 0.04310537f, 0.07488588f, 
    -0.11871769f, 0.30888158f, 0.39942253f, -0.06261103f, -0.05127305f, -0.07240687f, -0.07834449f, 0.10774821f, 
    -0.06025813f, -0.03422523f, 0.05751168f, 0.01976102f, 0.12362197f, -0.00993188f, 0.11790952f, 0.34755200f, 
    -0.19107488f, -0.01371334f, 0.05645301f, 0.09155777f, -0.04404007f, 0.05534738f, 0.07811028f, -0.04807898f, 
    -0.09662326f, -0.16424374f, 0.01577692f, 0.03556620f, -0.12746128f, -0.08054411f, 0.02344003f, -0.02277087f, 
    -0.07666782f, -0.03914193f, -0.04786081f, 0.01323456f, -0.13638684f, 0.09892373f, -0.30213407f, 0.13540223f, 
    -0.07948644f, -0.01683175f, 0.05868344f, 0.10576823f, -0.03439127f, -0.06119604f, -0.03752824f, 0.17090495f, 
    0.06509690f, 0.14409587f, -0.15934534f, -0.03150358f, 0.18309425f, -0.02904723f, -0.01566458f, 0.13577056f, 
    -0.09087060f, -0.02477764f, 0.10133236f, 0.02848398f, 0.00635834f, 0.03647461f, -0.19989862f, -0.20132512f, 
    0.03113856f, 0.04325519f, -0.03260755f, -0.00779668f, -0.05313414f, 0.09135713f, -0.12723464f, -0.01006276f, 
    0.35587189f, 0.30121553f, 0.19149290f, 0.19231148f, 0.04988040f, 0.06472233f, 0.13983396f, 0.12475425f, 
    -0.02576234f, 0.02780330f, -0.19339214f, 0.01544664f, -0.13342564f, 0.10551295f, 0.46623427f, 0.09552685f, 
    -0.08795582f, -0.03518235f, 0.03166027f, 0.10015310f, 0.14202699f, -0.02286931f, 0.05381932f, -0.02523834f, 
    0.19035158f, -0.42316899f, -0.00889884f, 0.06826921f, 0.05057455f, -0.05177838f, -0.12589550f, 0.09701664f, 
    -0.21395853f, 0.01037768f, -0.04024499f, 0.03610350f, -0.12865695f, -0.00455654f, -0.08090452f, -0.08179883f, 
    0.03828745f, -0.01980973f, 0.06430954f, -0.01788733f, -0.00194502f, -0.02465463f, 0.14353220f, -0.08547132f, 
    0.05540552f, -0.00062026f, -0.01404330f, -0.01227670f, 0.09933621f, 0.03401226f, -0.02538938f, 0.01738933f, 
    -0.09532605f, 0.08607586f, 0.07828099f, 0.12829155f, 0.35378394f, -0.06712364f, -0.01729158f, 0.23579246f, 
    0.20328730f, 0.05500755f, 0.04920241f, -0.23761263f, 0.05622634f, 0.02918751f, 0.02504566f, -0.14331748f, 
    0.26994699f, 0.01628780f, 0.50367880f, -0.19961673f, -0.05377473f, 0.03020888f, -0.02152226f, -0.12568344f, 
    0.06083783f, 0.08950535f, 0.16003206f, -0.04379873f, 0.07697549f, -0.16117917f, 0.08245371f, -0.10627314f, 
    -0.14045557f, -0.08150329f, -0.09101100f, -0.18080795f, 0.23664320f, 0.01673613f, 0.01555310f, 0.05597433f, 
    -0.27926019f, 0.04475943f, -0.01752989f, 0.05377489f, -0.10042264f, 0.08841432f, 0.00554095f, -0.11952648f, 
    0.02679594f, 0.11521100f, 0.16599450f, 0.15279430f, -0.01775586f, -0.16555277f, -0.08912343f, 0.29318777f, 
    0.02073742f, -0.15144525f, -0.03172892f, 0.14181788f, -0.08259530f, -0.01614903f, -0.03873780f, 0.15838230f, 
    0.00239587f, 0.35829976f, 0.26861966f, -0.02224407f, -0.06872187f, -0.12826778f, -0.18300073f, -0.05447685f, 
    -0.21163766f, 0.06178548f, 0.10184164f, -0.05449092f, -0.06202326f, -0.09484384f, -0.04852535f, 0.07082844f, 
    -0.14650093f, 0.11800283f, 0.06557119f, 0.18364920f, -0.11314325f, 0.06005888f, 0.00929885f, 0.07534366f, 
    0.07523108f, -0.09398886f, 0.06503236f, 0.18607767f, -0.02245807f, -0.19847691f, 0.11817830f, 0.04097645f, 
    -0.10089698f, -0.02897622f, -0.09984128f, 0.09767342f, -0.21809424f, 0.34785864f, -0.36348927f, -0.13633396f, 
    -0.15204969f, -0.01354407f, -0.00132570f, -0.19770385f, 0.01785092f, 0.06607217f, 0.00433685f, 0.11365418f, 
    -0.06356642f, 0.12022164f, -0.23686923f, 0.13418344f, -0.17166825f, 0.19985306f, 0.04292680f, 0.29387912f, 
    -0.13147864f, 0.05037649f, -0.09548706f, 0.14740267f, -0.03006498f, 0.25968334f, 0.04780680f, -0.49289015f, 
    -0.03139211f, 0.01049161f, -0.11168265f, 0.03837695f, -0.18900535f, -0.11128698f, -0.05175456f, -0.02792192f, 
    0.27355003f, 0.09598343f, 0.21647881f, 0.05808664f, 0.03431314f, 0.14569205f, 0.06204324f, 0.15895505f, 
    -0.02899663f, 0.19519284f, 0.00004434f, 0.09886349f, 0.09834946f, 0.00984797f, 0.46939766f, -0.00206632f, 
    -0.03352233f, -0.03665016f, -0.22797839f, -0.21702047f, -0.05179458f, 0.03523767f, 0.01257026f, -0.02556206f, 
    0.42769584f, -0.58906478f, 0.05622970f, 0.02574539f, 0.03636603f, 0.02192961f, 0.24669959f, 0.09705876f, 
    -0.13196141f, -0.05868121f, 0.09275191f, 0.01904219f, -0.12660693f, 0.06804325f, -0.33573240f, 0.05714381f, 
    0.07300139f, -0.00178761f, 0.07188854f, -0.03689663f, -0.04524214f, 0.01598639f, 0.13786249f, 0.09677103f, 
    -0.02964912f, 0.03700164f, 0.02833160f, -0.01926887f, -0.02762668f, -0.07954832f, -0.07981597f, 0.02449097f, 
    -0.00783096f, -0.00871145f, -0.01987690f, -0.00368892f, 0.02673056f, 0.05757958f, -0.04269649f, -0.03181580f, 
    -0.00198349f, -0.00488762f, 0.01931137f, -0.04086795f, 0.01726537f, 0.05730588f, -0.07758331f, -0.07155079f, 
    0.02324441f, -0.06464348f, -0.03159541f, -0.00804140f, -0.05613427f, 0.03870224f, 0.00533287f, -0.00923355f, 
    0.01573634f, -0.00781893f, 0.03493642f, 0.00567822f, 0.03701727f, 0.03443925f, 0.05099455f, -0.05871521f, 
    0.04199833f, 0.03127002f, 0.02483728f, 0.00046991f, 0.01112347f, 0.04731494f, 0.01802598f, -0.00938826f, 
    -0.05998360f, -0.07370275f, -0.07148655f, 0.03259347f, -0.05468425f, 0.06438892f, -0.04643897f, 0.04216344f, 
    0.04797328f, 0.01466726f, -0.05345136f, -0.01334448f, -0.05121066f, -0.04717868f, 0.00966436f, -0.04559429f, 
    0.02677398f, -0.07467842f, -0.01370211f, 0.03906970f, -0.08156782f, 0.01922591f, -0.03916834f, -0.00945000f, 
    -0.00353956f, 0.00659902f, -0.02812923f, 0.05380609f, -0.05923650f, -0.00296268f, -0.07043037f, -0.05192933f, 
    0.01987236f, -0.06223790f, 0.00762882f, -0.05810553f, -0.05914076f, 0.04135568f, -0.01087626f, 0.05616076f, 
    -0.02457723f, -0.06178553f, -0.00969971f, -0.01117084f, 0.04502589f, -0.04718132f, -0.04158709f, 0.04678736f, 
    0.00426869f, -0.08148268f, 0.03748102f, -0.01030818f, -0.01262275f, -0.05618758f, -0.02950597f, -0.02279484f, 
    -0.03149598f, 0.01875733f, 0.03465927f, 0.02049624f, -0.02325296f, 0.02717558f, -0.02134968f, 0.03552560f, 
    -0.03729377f, -0.04284072f, 0.00656751f, -0.02307127f, 0.01325561f, -0.07130416f, -0.03798350f, -0.06549452f, 
    0.06598496f, -0.01273748f, 0.02293965f, 0.05526993f, -0.01923193f, -0.06344565f, -0.03871188f, -0.00570815f, 
    0.05760362f, -0.06378529f, -0.07202590f, 0.06457958f, 0.00822825f, -0.02022565f, -0.02304460f, -0.02100446f, 
    0.06203442f, 0.03513505f, 0.01427098f, -0.04249350f, -0.00425006f, -0.03879788f, -0.01181589f, -0.03059993f, 
    0.00313920f, -0.04554000f, 0.01233685f, 0.02720677f, -0.00500409f, -0.01777854f, -0.06422344f, -0.05427631f, 
    0.02117047f, -0.02974484f, -0.01769312f, 0.02087766f, -0.02336521f, -0.02463135f, -0.01186465f, 0.02024559f, 
    -0.07622261f, 0.01320926f, -0.01661946f, -0.06770151f, 0.00642186f, -0.04612946f, -0.02664142f, -0.00300227f, 
    0.03618608f, 0.05819390f, 0.02055801f, 0.00635282f, -0.02967238f, 0.05277968f, -0.07948081f, -0.04054784f, 
    -0.04823488f, 0.02357611f, -0.06311253f, 0.01065103f, 0.05665455f, -0.03889004f, -0.00769119f, -0.06660650f, 
    0.07380216f, -0.06973658f, -0.03630053f, 0.04619635f, 0.03954704f, -0.02416456f, -0.04858819f, 0.01202380f, 
    0.08583484f, 0.09696445f, 0.03552853f, 0.06548353f, -0.02726086f, 0.07941864f, -0.07376380f, -0.12877308f, 
    -0.03840269f, -0.14972740f, -0.04707559f, -0.01962938f, 0.27478081f, 0.10648049f, -0.03915510f, -0.02899317f, 
    0.09466768f, 0.19202806f, 0.05078485f, 0.06000204f, -0.07889929f, 0.05044105f, 0.06633706f, 0.00946154f, 
    0.01848860f, -0.11862256f, 0.06437317f, -0.02968930f, -0.01361225f, -0.10678725f, 0.00533839f, 0.01192724f, 
    -0.07989006f, 0.03097540f, 0.00756372f, 0.01413279f, -0.16863693f, -0.15113890f, 0.04590538f, 0.08611799f, 
    0.09220745f, -0.00999353f, 0.00166708f, -0.04725792f, -0.05559589f, 0.04617609f, 0.06906483f, -0.01575267f, 
    -0.15807445f, 0.18980074f, 0.31647667f, -0.20705795f, 0.01714645f, -0.07975540f, 0.07626531f, 0.13060457f, 
    0.06014901f, -0.13455915f, -0.06696353f, -0.04013924f, 0.25782049f, -0.10175197f, -0.30060485f, -0.07231160f, 
    0.00633690f, -0.06968483f, 0.06473934f, 0.13848840f, -0.08375951f, 0.08587854f, 0.02444718f, 0.09536880f, 
    -0.12524584f, -0.07466590f, -0.17733125f, -0.10091703f, -0.02782845f, -0.02004853f, -0.01062457f, 0.05924099f, 
    -0.10695890f, 0.05825705f, 0.00696217f, 0.05971215f, 0.20039931f, 0.24409634f, 0.09115212f, -0.06810734f, 
    0.01843701f, -0.01793139f, -0.06968866f, 0.01812706f, -0.11127907f, 0.00623943f, -0.07750214f, 0.00411577f, 
    -0.14794312f, -0.29608348f, -0.19982287f, 0.01481467f, 0.03795280f, -0.04689335f, -0.15004086f, 0.06139548f, 
    -0.15204769f, 0.10660134f, 0.05602657f, 0.22392254f, -0.16863942f, 0.31847954f, -0.01450729f, 0.13768856f, 
    0.07638694f, 0.07262665f, 0.02618544f, -0.06116823f, -0.02039171f, 0.18984430f, 0.04656475f, -0.11121473f, 
    0.02245733f, 0.19092099f, -0.03532375f, -0.14632516f, -0.16676638f, 0.00581465f, -0.08274027f, -0.08769685f, 
    -0.03342274f, -0.03336582f, -0.18436758f, 0.03181789f, -0.24345692f, 0.07323211f, 0.17185003f, -0.11339712f, 
    0.06995863f, -0.03505676f, 0.12184918f, 0.10929231f, 0.09196492f, 0.02417842f, -0.00875820f, 0.19589908f, 
    0.14303918f, 0.02484246f, 0.01673066f, -0.04044429f, 0.10448269f, 0.10584654f, -0.14875767f, -0.10506847f, 
    -0.05785520f, -0.05389057f, 0.04403217f, -0.08981171f, -0.38009480f, -0.26699910f, -0.13480441f, -0.12858202f, 
    0.08698293f, 0.02682257f, -0.07201415f, 0.00685473f, -0.02791140f, -0.02039444f, 0.00324939f, 0.00549382f, 
    -0.09738041f, 0.12094200f, -0.20339791f, 0.15044078f, -0.09721757f, 0.03154253f, -0.10531953f, 0.04031306f, 
    -0.09262554f, -0.13386948f, 0.17101976f, -0.25095600f, 0.24659315f, 0.07663311f, -0.02905427f, -0.12733893f, 
    0.06036827f, 0.04815567f, -0.05499050f, -0.10163928f, -0.04019427f, -0.11714521f, -0.09714881f, -0.23058313f, 
    0.02401189f, 0.00728412f, -0.03838838f, -0.19173370f, 0.03479061f, 0.03541015f, 0.05351888f, 0.20415841f, 
    -0.09535981f, -0.09287074f, 0.03031773f, -0.03169813f, 0.02702806f, 0.06913118f, 0.55238026f, -0.02471442f, 
    0.05121097f, -0.05561946f, 0.01165696f, -0.02499883f, 0.13748147f, 0.02643711f, -0.07721278f, -0.21020201f, 
    -0.06431688f, 0.04197605f, 0.09483116f, -0.05774419f, -0.01199570f, -0.01699293f, 0.01374816f, -0.09215636f, 
    0.04032740f, 0.24940896f, 0.01431222f, 0.01053659f, -0.16721061f, -0.25202546f, -0.02979693f, 0.00622265f, 
    -0.07229923f, -0.03652449f, -0.09473016f, -0.02673486f, 0.03862901f, 0.04917434f, 0.02027755f, -0.09203558f, 
    -0.33790532f, -0.18361130f, -0.23590915f, 0.17232864f, 0.11041408f, 0.07992759f, 0.01003232f, 0.02728815f, 
    0.04283666f, 0.05119130f, -0.08455986f, 0.04350930f, 0.00863044f, 0.14338948f, -0.19969703f, -0.29616463f, 
    -0.09493469f, 0.00562272f, 0.05886114f, -0.24403474f, -0.10716763f, 0.04202907f, 0.07227572f, 0.03410014f, 
    0.26790616f, -0.11570431f, 0.14484553f, -0.15177961f, 0.02292290f, 0.02526655f, -0.03033689f, 0.04025510f, 
    0.20219427f, -0.09478214f, -0.08180182f, -0.11780770f, -0.25277007f, 0.09681959f, 0.01707459f, 0.00134500f, 
    -0.12148181f, -0.05504906f, 0.16182138f, 0.04846688f, -0.06209652f, -0.04182008f, -0.03237573f, 0.05025131f, 
    0.20021555f, 0.04007931f, 0.25079513f, -0.31166279f, 0.04366330f, 0.06562061f, -0.08273167f, -0.16622314f, 
    0.20013320f, 0.02475518f, 0.10163806f, 0.00360489f, 0.20338531f, -0.11597105f, -0.07030489f, 0.02664328f, 
    -0.13515525f, -0.02408420f, -0.31429884f, -0.03252958f, 0.09643234f, -0.06880625f, 0.06289665f, 0.16616045f, 
    -0.22436558f, -0.16803071f, 0.10373178f, 0.14181851f, -0.10416418f, -0.09299673f, -0.18226831f, 0.03228716f, 
    -0.00111197f, -0.10059333f, 0.06473076f, -0.14617221f, -0.25709456f, -0.23948859f, -0.01232247f, 0.53457671f, 
    0.01254263f, -0.02001144f, -0.13599937f, -0.13354334f, 0.27361825f, 0.07453419f, -0.01929635f, 0.02770696f, 
    -0.16287065f, 0.43988618f, 0.13860415f, -0.00439184f, -0.12660532f, -0.06429861f, 0.00808928f, 0.04480837f, 
    -0.02020786f, 0.03278846f, 0.07470714f, -0.01197807f, 0.14978030f, 0.09863158f, 0.06087938f, -0.05651700f, 
    -0.14511885f, -0.07476040f, -0.10221615f, -0.15834890f, 0.07532185f, -0.03211453f, -0.04356932f, -0.03144126f, 
    -0.36682659f, -0.13014168f, 0.12601162f, -0.02502629f, 0.30061743f, -0.02698510f, -0.08016244f, 0.02326385f, 
    -0.08541524f, -0.05222177f, -0.04822977f, 0.22091520f, -0.32422346f, -0.01760558f, 0.25087905f, 0.12555248f, 
    0.08363880f, -0.10969956f, 0.22443193f, 0.05529254f, 0.10741235f, 0.08009723f, 0.12743923f, 0.07378712f, 
    -0.15224776f, -0.16296139f, -0.08684406f, 0.05845729f, 0.02914162f, -0.01442108f, -0.04367916f, 0.10834655f, 
    0.10447276f, -0.02461919f, 0.01426328f, -0.02696737f, -0.09101629f, 0.19514571f, -0.17915554f, 0.00364782f, 
    -0.00296061f, 0.00017788f, 0.19500755f, 0.12185656f, -0.03177962f, -0.15867727f, 0.13295199f, 0.14043482f, 
    -0.11479925f, -0.11709894f, -0.04448889f, -0.16206419f, -0.00246523f, -0.01833464f, 0.07894281f, 0.03561919f, 
    0.13667960f, 0.14480770f, -0.04719568f, 0.27682424f, -0.19464439f, 0.05499817f, -0.01711051f, -0.03609878f, 
    -0.06380533f, -0.03742684f, -0.06303395f, -0.07920516f, -0.10042142f, 0.10693452f, 0.01771583f, 0.02518971f, 
    0.23464176f, 0.12470736f, 0.05793865f, -0.29679215f, 0.18911134f, -0.10027951f, 0.10721279f, 0.22268948f, 
    -0.03981484f, 0.13148002f, 0.05273833f, 0.07228724f, 0.03108754f, -0.18132029f, 0.33065143f, -0.09014813f, 
    0.00058904f, 0.20082729f, 0.02583673f, 0.03485081f, 0.15645273f, -0.06799518f, -0.09868042f, 0.10785270f, 
    0.43275699f, 0.04630963f, -0.30298272f, 0.27544817f, -0.00981728f, -0.03051211f, 0.04332368f, -0.03157490f, 
    -0.11054277f, -0.09174700f, -0.16118892f, -0.08574907f, 0.01714787f, -0.13236155f, 0.05791074f, -0.00518361f, 
    0.23766761f, 0.17757630f, -0.02538595f, -0.10728556f, -0.06602141f, -0.05952581f, -0.16551039f, 0.01364572f, 
    0.09019804f, -0.03450382f, -0.06795105f, -0.02526646f, -0.08141813f, 0.14296035f, -0.03510398f, 0.08258519f, 
    0.11723061f, 0.05391524f, 0.06353730f, -0.05122835f, -0.40150577f, 0.03028172f, -0.15659520f, -0.14706439f, 
    0.03994495f, -0.05534123f, -0.00562288f, 0.16594745f, -0.03074612f, 0.01530143f, 0.06184062f, -0.02214955f, 
    -0.15630522f, -0.28328285f, -0.02059804f, 0.13424587f, -0.06774291f, -0.00299613f, 0.00943763f, -0.00272532f, 
    0.05294261f, -0.14985274f, 0.05729302f, 0.08226397f, 0.04631164f, -0.12194705f, 0.14825076f, -0.21150382f, 
    0.14812209f, 0.07027501f, -0.15013836f, -0.05462397f, -0.05960010f, 0.01312645f, 0.02605732f, 0.03431492f, 
    -0.34077457f, -0.04429220f, -0.06322542f, 0.03950728f, 0.00916905f, -0.07865900f, 0.04286259f, 0.16951500f, 
    0.03197280f, -0.01900759f, 0.11948141f, -0.08428881f, 0.55446684f, -0.15264729f, 0.19070487f, -0.09951659f, 
    -0.05638596f, -0.09062679f, 0.10235497f, -0.04055933f, -0.15538394f, 0.12418172f, -0.12922147f, -0.11569943f, 
    -0.07709267f, 0.07123422f, 0.20467079f, -0.04725739f, 0.09655659f, -0.07067697f, 0.28052059f, 0.15813027f, 
    0.22826688f, 0.11722558f, 0.18592194f, -0.08494309f, 0.05513659f, -0.15849464f, 0.12767041f, 0.09554028f, 
    -0.10616701f, 0.00217092f, -0.02149959f, 0.08154821f, -0.00154819f, -0.06490489f, -0.08320003f, 0.01996338f, 
    0.01174112f, 0.16100998f, 0.05215863f, -0.04719005f, -0.06254571f, -0.00924608f, 0.11471827f, 0.08449201f, 
    -0.09269714f, -0.00941938f, -0.14969876f, -0.18629172f, 0.36049333f, 0.21921834f, 0.15428957f, -0.01644566f, 
    -0.05335256f, 0.00008350f, 0.08326944f, 0.00982326f, 0.09701093f, 0.12769403f, -0.02794102f, -0.07137456f, 
    -0.07740186f, 0.05431260f, 0.08271687f, 0.06180644f, 0.03125782f, 0.05496201f, 0.18024273f, -0.04786112f, 
    0.02809264f, -0.00676529f, -0.05458290f, -0.03041172f, -0.00385227f, -0.05760088f, 0.09145249f, 0.09086020f, 
    -0.04322625f, 0.05620186f, -0.03424301f, -0.06610180f, 0.08687661f, 0.08571579f, -0.01195108f, -0.17979737f, 
    -0.28539941f, -0.06499015f, 0.38758281f, -0.08881815f, 0.10297339f, -0.00119574f, 0.07370088f, 0.16820534f, 
    -0.04380377f, -0.11979710f, -0.09379085f, -0.08725099f, 0.24752399f, 0.15872759f, -0.22382975f, -0.13163072f, 
    -0.10542345f, -0.03475443f, 0.09174911f, 0.10145894f, -0.03634933f, 0.15335000f, -0.05022527f, 0.01048752f, 
    0.12612092f, -0.19400159f, -0.13880527f, 0.03062097f, 0.03833838f, 0.09741317f, 0.02528297f, 0.01350503f, 
    -0.04441874f, -0.00484249f, 0.04616668f, -0.02150109f, 0.15223186f, 0.30840096f, 0.13068783f, -0.12598361f, 
    -0.10673699f, -0.22675034f, 0.00944566f, 0.04248008f, -0.00923274f, -0.02957601f, 0.04221610f, -0.05873677f, 
    0.03709712f, -0.07375360f, 0.07149262f, -0.14706013f, -0.00083489f, -0.01256499f, -0.17158526f, 0.03268347f, 
    -0.11193365f, 0.04920346f, 0.13828509f, 0.22467065f, 0.13580512f, 0.27960142f, -0.04316474f, 0.23037210f, 
    -0.08461786f, 0.11116920f, -0.02288293f, -0.00877168f, 0.04096030f, 0.04559431f, 0.02577918f, -0.10131156f, 
    -0.08837614f, 0.13803683f, -0.03544297f, -0.11272594f, -0.18976678f, -0.04195107f, 0.00300320f, -0.01367373f, 
    0.02832647f, 0.07879427f, -0.05521904f, 0.08474376f, -0.28378984f, -0.16006775f, 0.17130405f, 0.18652560f, 
    0.00771246f, -0.03014713f, -0.01892404f, 0.05861226f, 0.21576335f, 0.17151073f, -0.02550910f, 0.11965174f, 
    -0.21768878f, 0.11100008f, -0.05660913f, -0.10787954f, 0.04594242f, 0.02771080f, -0.15257028f, -0.06798812f, 
    -0.11712162f, 0.14013435f, -0.00997951f, -0.08503141f, -0.00140474f, 0.00808689f, 0.06252261f, -0.21692166f, 
    -0.00202542f, 0.02186423f, 0.00594555f, 0.00097648f, 0.00973011f, 0.02610696f, 0.02885825f, -0.02028079f, 
    -0.39573312f, 0.04820958f, -0.08772192f, 0.08800498f, -0.04180577f, 0.18652655f, -0.21143311f, 0.04537534f, 
    -0.02568031f, -0.05100230f, 0.06900764f, 0.07986475f, 0.23934066f, -0.01832973f, 0.10011756f, -0.07264617f, 
    0.08056417f, 0.02127479f, 0.13402569f, -0.11954398f, 0.17443341f, -0.09857069f, -0.10697457f, -0.19093107f, 
    0.01326812f, -0.00932790f, -0.02673128f, -0.03135060f, -0.04286584f, -0.01295596f, -0.06623071f, -0.04429335f, 
    0.03406425f, -0.00020371f, 0.01685013f, 0.00860896f, 0.03679161f, -0.01939188f, -0.05905311f, -0.08270717f, 
    0.02244555f, 0.04239929f, 0.02782241f, 0.00270577f, -0.06626239f, -0.05628631f, -0.08155607f, 0.05780866f, 
    0.03090759f, 0.01313701f, -0.04777845f, 0.01933604f, -0.02468685f, -0.01776333f, 0.01781452f, -0.05173885f, 
    -0.02947808f, 0.00621543f, 0.00340900f, -0.00652797f, -0.03876305f, -0.07603759f, -0.03748948f, 0.01056960f, 
    -0.02605795f, -0.01371252f, -0.03138807f, 0.03747006f, -0.01383122f, 0.04712596f, 0.04059656f, -0.00751418f, 
    -0.03310204f, -0.02997059f, 0.01650743f, 0.01366334f, 0.04221626f, -0.00190844f, 0.00501793f, -0.07040311f, 
    -0.01246046f, -0.03589313f, 0.03516051f, 0.05774014f, 0.05078438f, -0.06315241f, -0.00578273f, 0.01025633f, 
    0.02691746f, 0.03375802f, 0.03339988f, -0.00229930f, 0.01571222f, 0.04849139f, 0.02641286f, 0.02538201f, 
    0.02992349f, -0.04614335f, -0.02908363f, -0.03702435f, 0.03184385f, 0.06127884f, -0.00375019f, -0.01529522f, 
    0.00769366f, -0.05163510f, 0.04024091f, -0.00613955f, 0.05236976f, -0.07290451f, 0.04308973f, -0.07090898f, 
    -0.00693365f, 0.02105300f, -0.04187362f, -0.03380706f, -0.06378140f, 0.04393464f, -0.05960050f, -0.07687518f, 
    0.06090076f, 0.00434229f, -0.02748827f, -0.00013215f, -0.05927125f, -0.01028623f, -0.07006582f, 0.05943600f, 
    0.04508033f, -0.00436756f, 0.04421214f, -0.04823142f, -0.06313208f, -0.06499939f, -0.06267338f, -0.00381879f, 
    -0.05375516f, -0.04539691f, 0.04116832f, 0.00793463f, -0.00921550f, 0.01794284f, 0.01939662f, -0.07470655f, 
    0.04244899f, -0.01878846f, -0.08183035f, 0.05254393f, -0.05411278f, -0.04267357f, -0.00868311f, -0.01260275f, 
    -0.04476680f, -0.06548900f, 0.01085600f, -0.00755053f, -0.04479269f, 0.05382414f, 0.02822720f, 0.01419436f, 
    0.00967624f, -0.01160130f, -0.00515284f, 0.01030511f, 0.00005504f, -0.03385708f, -0.04254463f, -0.00478249f, 
    -0.01376294f, -0.08495415f, -0.08241800f, -0.04829558f, -0.05306441f, -0.03633016f, -0.04946999f, -0.08223998f, 
    0.04234836f, -0.05847760f, 0.02857352f, 0.05488146f, -0.00451543f, 0.01576093f, -0.04340208f, -0.05413113f, 
    0.02518628f, -0.06983181f, -0.05800110f, -0.06344271f, 0.05446107f, -0.00400942f, -0.07076103f, -0.02704143f, 
    0.00880262f, 0.03863648f, 0.02101062f, 0.02959754f, -0.04007051f, 0.01204402f, -0.05710514f, -0.06548158f, 
    -0.01271647f, -0.04171139f, -0.01076088f, -0.04040476f, 0.04768842f, 0.00464199f, 0.02616411f, 0.04163776f, 
    -0.02516242f, 0.03890482f, -0.04398369f, 0.01121501f, -0.04980093f, 0.05418587f, 0.01807990f, 0.01440377f, 
    0.00441679f, 0.00729844f, -0.01561180f, -0.07447547f, 0.11599377f, 0.13194120f, -0.09055997f, 0.06245714f, 
    -0.10005754f, 0.13730736f, 0.01838803f, -0.07974790f, 0.39374545f, 0.16937871f, -0.01319622f, 0.12582715f, 
    0.09997174f, 0.16895290f, 0.02040602f, -0.26026547f, -0.00755100f, -0.07730991f, -0.08344141f, -0.13549212f, 
    0.06245224f, -0.15302205f, 0.25038493f, 0.14123054f, 0.09576816f, 0.07494073f, 0.06176518f, 0.01566495f, 
    0.03256679f, -0.08222448f, -0.08307277f, -0.03668378f, -0.11749847f, -0.01535994f, -0.02649324f, 0.08082732f, 
    0.00608662f, 0.02976688f, 0.05432880f, 0.04265633f, 0.18264444f, 0.28013256f, 0.00972480f, 0.11332911f, 
    -0.20690972f, 0.22054410f, 0.11463386f, -0.05165643f, 0.03639698f, 0.14433683f, 0.01774584f, -0.00999398f, 
    0.02112802f, 0.12811926f, 0.10818898f, 0.12424190f, 0.08784986f, -0.12960693f, -0.03388848f, -0.07567189f, 
    0.04418791f, -0.01614171f, 0.01275399f, -0.00162946f, -0.11243127f, 0.18120213f, -0.04719322f, 0.03403431f, 
    0.01480223f, 0.10875858f, 0.45691198f, 0.18163110f, -0.07848013f, 0.05514007f, -0.11580910f, 0.00226189f, 
    -0.13575332f, -0.06256834f, 0.11764891f, 0.07612285f, 0.17105757f, -0.03823708f, -0.15284096f, -0.19351210f, 
    0.04198846f, 0.07086056f, -0.04670435f, 0.00477270f, -0.16049792f, -0.06031105f, -0.08905000f, -0.18205445f, 
    -0.33909661f, -0.21883261f, 0.02665666f, 0.04019492f, -0.01069910f, -0.11671955f, -0.10733038f, -0.07697430f, 
    -0.10867076f, 0.12710430f, -0.03097250f, 0.01950077f, -0.15568236f, 0.27203777f, -0.25079626f, 0.21963331f, 
    -0.07740124f, -0.04852382f, 0.16634649f, -0.05824418f, -0.01061023f, 0.09239142f, -0.06324840f, 0.09985211f, 
    0.11059080f, 0.20213772f, -0.15122817f, -0.09099542f, -0.06276703f, 0.00271134f, -0.15525821f, 0.20327212f, 
    -0.11148163f, 0.01533725f, -0.11926641f, -0.02784460f, 0.06302511f, 0.04521463f, 0.12972048f, -0.06938236f, 
    0.01198232f, -0.03265433f, 0.01655423f, 0.08036267f, -0.00390133f, -0.09440418f, -0.00410981f, -0.00240181f, 
    0.12484352f, 0.07093248f, 0.00272742f, 0.00498261f, 0.12123567f, 0.16988525f, -0.16658854f, 0.03369161f, 
    0.03755615f, 0.12981871f, -0.08998651f, 0.00908271f, -0.11840276f, 0.00256885f, 0.47137150f, 0.12949479f, 
    -0.08641028f, -0.07259191f, 0.01044129f, 0.04274758f, -0.08951083f, 0.03445515f, 0.01062985f, -0.00753511f, 
    -0.09735414f, -0.13384914f, -0.21664983f, 0.11787374f, -0.08851839f, 0.21579148f, 0.01937305f, 0.12287389f, 
    -0.17835602f, -0.05433704f, 0.11794895f, -0.03305254f, 0.12156368f, 0.03263242f, -0.05163875f, -0.17967752f, 
    0.16048171f, -0.01696517f, 0.07054389f, -0.08673497f, -0.06777821f, -0.06371367f, 0.02342595f, -0.10136349f, 
    -0.12218533f, 0.03000578f, -0.01514765f, 0.23586947f, 0.06955712f, -0.09154077f, 0.02305569f, 0.06671885f, 
    -0.15063848f, -0.02424990f, 0.02738963f, -0.08195995f, -0.42993537f, 0.01425654f, 0.22490725f, 0.07367924f, 
    -0.07234941f, -0.01536801f, -0.17080648f, -0.14293516f, -0.11517436f, -0.11907580f, 0.10164096f, 0.08119349f, 
    0.07119617f, 0.02204637f, -0.06040208f, -0.06490448f, -0.03045572f, 0.00822889f, 0.11661135f, 0.04485836f, 
    -0.07320674f, 0.16349803f, 0.19750537f, -0.02017003f, -0.30809525f, -0.05243358f, -0.09855297f, -0.00824062f, 
    0.16130035f, 0.00241087f, 0.09531061f, -0.06086812f, -0.11470161f, 0.37238753f, -0.02292644f, 0.10886239f, 
    0.30419138f, -0.09807256f, -0.12460717f, 0.03402546f, -0.05234842f, 0.00485939f, 0.03884087f, 0.15782054f, 
    -0.10180995f, -0.06363593f, 0.14091595f, -0.06297334f, -0.04772984f, -0.05363528f, 0.60042256f, -0.02089432f, 
    0.01457484f, 0.28267539f, -0.08984944f, -0.10217031f, 0.09118167f, -0.25881049f, 0.10968236f, -0.09881376f, 
    0.48049983f, -0.11512099f, -0.20735399f, 0.16535375f, 0.04566703f, 0.09976763f, -0.01942018f, -0.02297225f, 
    -0.08814854f, 0.01962177f, -0.10033452f, -0.07689384f, -0.03923616f, -0.03727759f, 0.05471835f, 0.20249012f, 
    -0.06325798f, -0.05632705f, -0.07988171f, -0.17742230f, -0.07232107f, -0.07556369f, -0.11204076f, -0.12224122f, 
    0.19637136f, -0.04721363f, -0.02559896f, -0.15882656f, -0.10233597f, 0.06848542f, -0.15371338f, -0.24800478f, 
    0.32399490f, 0.10082418f, 0.26811749f, 0.13349645f, -0.32559723f, 0.17555840f, -0.03150222f, 0.08305559f, 
    -0.05454760f, -0.04072025f, 0.09168983f, 0.20480253f, 0.04924065f, -0.04754330f, 0.02652976f, 0.04617752f, 
    -0.08920496f, -0.31205934f, -0.00853099f, 0.13511680f, 0.10955457f, -0.16845165f, -0.10067609f, -0.25455531f, 
    0.08439270f, 0.00576286f, 0.13706112f, 0.04342974f, -0.17571111f, -0.13818876f, 0.01217006f, -0.15935010f, 
    -0.00174623f, 0.03423298f, -0.07046485f, 0.02617593f, 0.03762623f, 0.19434285f, 0.08270558f, 0.20924361f, 
    0.13397810f, 0.38556114f, 0.34877899f, 0.28847346f, -0.01022931f, -0.15457891f, 0.04816365f, 0.21251462f, 
    0.02726555f, -0.04270208f, 0.05613117f, 0.08758942f, 0.29986212f, -0.02890407f, 0.40324306f, -0.20197845f, 
    0.06666671f, 0.03615964f, 0.09518176f, 0.07247820f, -0.10375674f, -0.00892130f, -0.01524010f, -0.10526820f, 
    0.30203557f, -0.39740589f, 0.25863838f, -0.07719838f, 0.04116812f, -0.15858391f, 0.01266170f, 0.15153348f, 
    0.18420295f, 0.12045207f, 0.14936781f, -0.03205134f, -0.24135463f, -0.14559220f, -0.09844138f, -0.02962551f, 
    -0.15856886f, -0.01012429f, -0.03386327f, -0.08037805f, 0.02985832f, -0.04918660f, -0.05534735f, 0.05040607f, 
    -0.02151341f, 0.09453225f, 0.14374325f, 0.18301025f, 0.03004225f, -0.03717156f, -0.05681903f, -0.16753866f, 
    0.03741403f, -0.15498123f, -0.01356575f, -0.04787280f, -0.50226736f, -0.31902853f, -0.03040908f, 0.05910739f, 
    -0.11290958f, -0.01385314f, 0.14468686f, 0.20565890f, -0.00242951f, -0.03346133f, 0.07899418f, 0.15558729f, 
    0.15641519f, 0.22021373f, 0.10260548f, 0.00948406f, -0.01497801f, -0.09414625f, -0.18905337f, 0.00792275f, 
    0.02305395f, 0.04583701f, 0.11182471f, 0.04334915f, 0.08042225f, 0.02731987f, 0.15384340f, -0.06067389f, 
    0.10443133f, -0.05778385f, -0.09676125f, 0.11156859f, -0.08643017f, -0.05161179f, -0.05738674f, 0.01641326f, 
    0.00717623f, 0.05342753f, -0.11169829f, 0.10023969f, 0.01185964f, 0.04460014f, -0.00161329f, 0.03356743f, 
    -0.19593495f, -0.05983040f, -0.13517693f, -0.18279855f, -0.23394312f, -0.06047148f, -0.09880406f, 0.24501076f, 
    0.14210361f, 0.00921447f, 0.02863407f, 0.11364546f, 0.03752407f, -0.10080057f, -0.09485188f, -0.09975705f, 
    -0.25535825f, -0.08988310f, -0.21329169f, -0.11106900f, -0.01000668f, -0.05309469f, 0.01644755f, -0.16132091f, 
    0.01642746f, -0.01264726f, -0.01902926f, -0.05935834f, -0.20218986f, 0.04275281f, 0.08312050f, 0.16538115f, 
    -0.09583567f, 0.06710954f, -0.02340542f, 0.04585402f, 0.02533923f, -0.02236965f, -0.02591236f, -0.08713945f, 
    0.09979164f, 0.28102210f, -0.16238467f, 0.04058509f, -0.08187827f, -0.04660993f, 0.14576288f, 0.07725415f, 
    0.18484059f, 0.25068128f, 0.15885538f, 0.05977912f, 0.13577349f, 0.10575139f, 0.54398835f, -0.15880854f, 
    0.02399937f, 0.03375417f, -0.08838470f, 0.12330826f, 0.02023839f, 0.09261250f, 0.04851046f, -0.00964468f, 
    -0.09959776f, -0.11413559f, 0.05940344f, 0.14576308f, 0.03873645f, 0.01133290f, 0.02098465f, -0.10091113f, 
    0.13036466f, 0.14216484f, 0.03811337f, 0.21422482f, -0.01526536f, 0.36907634f, -0.15027162f, 0.01741089f, 
    -0.09064843f, 0.05586490f, 0.04819429f, -0.02885561f, 0.15766437f, 0.06415615f, 0.02667557f, 0.02227781f, 
    0.49811593f, 0.11629621f, 0.33524761f, 0.30712897f, -0.16436510f, -0.01277079f, 0.04728530f, 0.10637133f, 
    0.05949221f, -0.06803960f, 0.06424712f, 0.19486515f, -0.18981706f, -0.01237478f, -0.29325470f, -0.10785151f, 
    -0.00508636f, -0.01596349f, 0.05088974f, -0.06781211f, 0.06767019f, -0.12868904f, 0.01582799f, 0.00971622f, 
    0.50101477f, -0.08481388f, 0.18326780f, -0.03268667f, -0.01750300f, -0.09103595f, 0.07829145f, 0.05216018f, 
    0.03936273f, 0.12738132f, -0.03943269f, 0.10823330f, -0.24369457f, -0.09832332f, -0.21895079f, 0.10026911f, 
    -0.06077232f, -0.04102275f, -0.10395372f, 0.15112780f, 0.00837261f, 0.12178966f, -0.12204815f, 0.01973701f, 
    -0.04544656f, 0.02300730f, -0.07209535f, 0.07558721f, -0.05616566f, -0.18907547f, -0.12748879f, 0.06318201f, 
    -0.08126863f, -0.02186279f, 0.03305237f, -0.05867938f, -0.14162102f, -0.36825991f, -0.40533835f, -0.12168407f, 
    0.09803195f, -0.37268442f, -0.06956811f, -0.00175925f, -0.06804525f, 0.02079310f, 0.08946446f, -0.07382405f, 
    0.19755001f, 0.05884494f, 0.12358356f, -0.08802459f, -0.03814197f, -0.06170018f, -0.01671932f, -0.12706691f, 
    0.14462268f, 0.15875824f, -0.11717951f, 0.10048352f, 0.17519191f, 0.08910618f, 0.09520895f, 0.01988457f, 
    -0.09007291f, -0.08725584f, -0.00739919f, -0.06932870f, 0.18448742f, -0.06588463f, -0.11961000f, 0.09734993f, 
    -0.10172684f, -0.11475019f, 0.01079876f, -0.16034907f, -0.00731055f, 0.12880296f, 0.00768968f, 0.00979618f, 
    -0.19272754f, 0.07189076f, 0.01168146f, 0.02220863f, 0.12816142f, -0.05652680f, 0.09493728f, 0.15749888f, 
    0.09357639f, -0.11137547f, 0.17131416f, 0.05495580f, -0.05130574f, 0.05676390f, -0.03396522f, -0.03546411f, 
    0.55274731f, 0.28150830f, 0.04457726f, 0.03670322f, 0.02112503f, -0.06080105f, 0.08260638f, -0.09339364f, 
    -0.02045238f, 0.05783766f, -0.02421161f, 0.01084327f, -0.36391801f, -0.42038810f, -0.26494032f, -0.10207333f, 
    -0.11999213f, -0.12174514f, -0.19525920f, -0.02645595f, -0.10953648f, 0.00977121f, 0.01986354f, -0.06520200f, 
    0.19231382f, -0.03704523f, 0.01311400f, 0.13533898f, -0.01387144f, 0.00766366f, 0.13496873f, 0.02500194f, 
    0.07576614f, 0.06038318f, -0.00722784f, 0.15620705f, 0.15673447f, 0.13998450f, -0.06939920f, -0.17275678f, 
    0.00132166f, -0.03109481f, 0.00535133f, -0.05551906f, 0.18687384f, -0.00936135f, -0.01888236f, -0.03456558f, 
    -0.36467326f, -0.34591022f, -0.19268006f, 0.05065615f, 0.08305026f, 0.18218635f, 0.15176874f, 0.13806191f, 
    0.06881218f, 0.16829266f, 0.25195026f, 0.10332499f, 0.29358557f, 0.12733971f, 0.09286577f, -0.32322624f, 
    -0.13895017f, 0.08421142f, -0.01466402f, 0.03594899f, -0.18039154f, 0.03559640f, 0.15498841f, 0.09216271f, 
    -0.45351097f, -0.51423633f, -0.12000974f, -0.08512652f, -0.02852409f, -0.08324608f, -0.04239609f, 0.02132818f, 
    0.22421782f, 0.01909795f, 0.11348896f, 0.06050577f, 0.41983312f, 0.17374001f, 0.31821966f, 0.03764847f, 
    -0.09240614f, -0.08643050f, 0.10779654f, -0.06133294f, -0.04094386f, 0.05516998f, -0.00989178f, 0.05340324f, 
    0.14347841f, -0.25637862f, 0.09371712f, 0.07663532f, 0.20342490f, 0.02588014f, 0.26446295f, 0.15591298f, 
    0.24682856f, -0.03529521f, -0.07105238f, 0.03009310f, -0.14185806f, -0.32588285f, -0.59974039f, -0.18706329f, 
    0.02772951f, 0.14212739f, -0.11944014f, -0.10245030f, -0.03759968f, 0.07307228f, 0.12165859f, 0.01327222f, 
    -0.10871650f, -0.01513736f, -0.16310306f, -0.01815418f, -0.08650705f, -0.00467261f, -0.03279943f, -0.12013850f, 
    0.03690055f, -0.02318339f, -0.04407001f, -0.01073703f, -0.10567285f, 0.09360181f, 0.12964514f, -0.12446603f, 
    -0.09533750f, -0.12729253f, -0.27824956f, -0.05757932f, -0.06119026f, 0.03261243f, -0.00009081f, -0.21555351f, 
    -0.08601339f, -0.01931067f, 0.15754962f, 0.08803713f, -0.04219688f, -0.18204273f, 0.00452216f, -0.08073282f, 
    0.06059912f, 0.44115263f, -0.08102800f, 0.20503348f, -0.11416192f, -0.07026234f, 0.02583246f, 0.11906084f, 
    -0.06871624f, -0.07210244f, -0.04653806f, -0.09327258f, 0.07597914f, 0.09637460f, 0.04417064f, 0.13025498f, 
    -0.32410082f, -0.21313424f, 0.23754029f, 0.04274081f, 0.09639760f, 0.01785623f, -0.16666389f, 0.08888049f, 
    -0.07327204f, 0.00014004f, -0.02949063f, 0.11125105f, 0.17819822f, -0.17104863f, -0.08873074f, -0.36906061f, 
    -0.02960321f, 0.16290568f, 0.04619880f, 0.07880694f, -0.06693245f, 0.00341725f, -0.07443864f, -0.03054929f, 
    0.35081658f, 0.08490535f, 0.04551253f, 0.14618249f, 0.04058156f, -0.00277258f, -0.07923489f, -0.13075048f, 
    -0.07543125f, -0.03225493f, -0.00030855f, -0.14950444f, -0.21953985f, -0.04622467f, 0.09158914f, -0.12289057f, 
    0.02616621f, 0.00353187f, -0.01703767f, -0.03222589f, -0.06864984f, -0.03357562f, -0.02584726f, -0.09408201f, 
    0.17858051f, -0.13569467f, -0.07821745f, -0.13288967f, -0.04254698f, -0.06260932f, -0.10309143f, -0.07495251f, 
    0.02604991f, -0.26203823f, -0.10920414f, -0.19692497f, -0.14997183f, -0.08642177f, -0.15812527f, 0.12726848f, 
    -0.06994335f, -0.06196419f, -0.12598240f, -0.00800230f, -0.06501017f, -0.09552959f, 0.07355218f, 0.00296218f, 
    -0.03320852f, -0.11741626f, 0.09908562f, -0.10417997f, -0.11402144f, -0.04830466f, 0.02268863f, -0.07764200f, 
    -0.08562999f, -0.15515929f, 0.07993963f, -0.05205989f, -0.25044504f, -0.10827389f, 0.04604010f, 0.00491411f, 
    0.06190085f, -0.01878172f, -0.11760555f, 0.02710543f, -0.03763327f, -0.14850481f, -0.16081211f, -0.02054423f, 
    -0.32555863f, 0.20698324f, 0.02601214f, -0.28317854f, -0.10868173f, -0.12262437f, -0.02003692f, 0.00961301f, 
    0.04397371f, 0.11610001f, -0.00880182f, -0.18301879f, 0.22517847f, -0.00085632f, 0.05695457f, 0.01821584f, 
    0.00430325f, 0.02793168f, -0.01342046f, -0.06580009f, -0.03063769f, -0.03015224f, -0.02005131f, -0.03317107f, 
    -0.25179523f, 0.06008267f, 0.08445545f, -0.29274619f, 0.01237633f, -0.02117818f, 0.00083729f, 0.25585952f, 
    -0.02207926f, -0.14048584f, 0.01485709f, -0.18146397f, -0.14533100f, 0.20792365f, 0.00537972f, 0.10362758f, 
    0.01210310f, 0.04806661f, 0.18527757f, 0.02793883f, 0.09804815f, 0.04023736f, 0.03808963f, 0.14578898f, 
    0.16781844f, 0.12828484f, -0.02867289f, -0.03070154f, -0.29574555f, -0.00513774f, -0.06137818f, 0.00732099f, 
    0.00282126f, -0.02935483f, 0.00977420f, -0.07347573f, -0.16189419f, 0.12656753f, 0.16343942f, 0.01699958f, 
    0.17755616f, -0.11014541f, 0.01516327f, -0.06458510f, -0.03659305f, 0.02049042f, -0.06831511f, -0.08785667f, 
    0.29774585f, 0.05573033f, -0.04803466f, -0.01275347f, 0.00986873f, 0.05286447f, 0.14100350f, -0.11612705f, 
    -0.08514252f, 0.03563568f, 0.04610123f, -0.07385553f, 0.29109353f, 0.17759085f, -0.03824136f, -0.01970731f, 
    0.05163637f, 0.00285114f, 0.01153074f, -0.07781123f, 0.08454913f, -0.09499288f, -0.03388016f, -0.07653486f, 
    -0.22733375f, -0.08329400f, 0.40236551f, 0.17996767f, 0.13254490f, 0.22347812f, 0.00961254f, 0.01969352f, 
    -0.08165035f, -0.15349285f, -0.08086593f, 0.11421716f, 0.19829017f, 0.26946005f, -0.02585661f, 0.22077782f, 
    -0.05088482f, 0.00970032f, -0.03824681f, 0.18668877f, -0.05059095f, 0.06712233f, 0.07868617f, -0.01343681f, 
    0.09967569f, 0.27863118f, 0.29473144f, 0.11464930f, 0.03277152f, -0.08699131f, -0.01438388f, 0.01678305f, 
    0.11209276f, -0.01276468f, 0.11324976f, 0.06799817f, 0.22336860f, 0.20399559f, 0.29398829f, 0.21707536f, 
    0.14598700f, 0.27287850f, 0.16537066f, 0.19917662f, -0.00417416f, 0.05702401f, -0.02054677f, 0.06873716f, 
    0.06099340f, 0.04596374f, 0.07578751f, 0.03338746f, 0.00767404f, 0.08211047f, -0.01025149f, -0.07566702f, 
    0.06532603f, -0.13505867f, 0.05151542f, 0.05999280f, 0.42939994f, -0.13825613f, -0.30168998f, -0.20137952f, 
    -0.01044247f, 0.06091955f, -0.11440699f, 0.02414609f, -0.12232205f, -0.10749450f, 0.04108205f, -0.07542926f, 
    -0.09388506f, 0.11849023f, 0.39532676f, 0.28038624f, 0.06381822f, -0.04164801f, -0.09282087f, -0.03308412f, 
    0.14805305f, 0.08368837f, 0.02120332f, -0.00457285f, -0.09346174f, -0.10274481f, 0.10802304f, 0.11851434f, 
    0.02584513f, 0.02698451f, -0.02552175f, -0.06323207f, -0.06614241f, 0.02671714f, -0.20804891f, -0.03021722f, 
    0.37541929f, -0.11669884f, -0.21857005f, -0.42531779f, -0.12029205f, -0.16341414f, 0.12743403f, -0.09492152f, 
    0.16011043f, -0.15793490f, -0.09145449f, -0.05727907f, 0.27617428f, 0.10035422f, -0.00989220f, 0.10064968f, 
    0.00349296f, -0.10623842f, -0.12204420f, -0.02535161f, 0.15357040f, 0.05636800f, 0.13000141f, 0.05597096f, 
    -0.02219030f, -0.05181301f, 0.05350728f, -0.01487044f, 0.12624797f, -0.00721268f, -0.10433946f, -0.02181019f, 
    -0.06636311f, -0.12423819f, 0.04153084f, 0.18715395f, -0.01643273f, 0.21352074f, 0.36248380f, 0.49433970f, 
    -0.02046411f, 0.06489647f, 0.03405413f, 0.10139830f, -0.03432724f, 0.02895449f, 0.09763645f, -0.04932451f, 
    0.19492260f, 0.08435280f, 0.05357338f, 0.18835647f, 0.01792548f, 0.07321969f, 0.23536974f, -0.00636113f, 
    0.21559606f, -0.01319034f, 0.06205408f, 0.03409997f, -0.32015517f, -0.26319683f, -0.36317852f, -0.16399200f, 
    -0.06347229f, -0.06824394f, -0.11423173f, 0.04530828f, -0.16152579f, -0.01550019f, -0.05647710f, -0.06828919f, 
    0.10125426f, 0.20215486f, -0.01707031f, -0.00622373f, -0.02627315f, -0.02267126f, -0.00851188f, -0.11491837f, 
    0.16441877f, 0.00084900f, 0.23343469f, 0.08588219f, 0.23627485f, 0.05645627f, 0.11552026f, -0.05112453f, 
    -0.04577611f, -0.01845662f, -0.00602757f, -0.07591190f, 0.08938368f, -0.16561070f, 0.07964115f, 0.14680769f, 
    0.26476511f, 0.07835837f, 0.12665670f, 0.04818146f, 0.15784743f, -0.02517658f, 0.03351973f, 0.03912647f, 
    -0.01972532f, -0.10917916f, -0.00831955f, -0.19759648f, 0.01439791f, 0.31296441f, 0.00506568f, 0.26713783f, 
    0.10460117f, 0.01620475f, -0.05581699f, 0.33083776f, 0.13198178f, -0.16620663f, -0.01204149f, -0.13712773f, 
    -0.19485551f, -0.00174096f, 0.00258325f, 0.01700902f, -0.05510379f, -0.05094266f, -0.06810541f, -0.10143054f, 
    0.17216484f, -0.06721802f, 0.00984170f, 0.06363437f, 0.12774348f, 0.13109694f, 0.17690913f, 0.11947068f, 
    -0.05216131f, -0.01501034f, 0.08188749f, 0.19887275f, -0.01269650f, -0.11661526f, -0.06974521f, 0.02116070f, 
    -0.12135336f, 0.22115922f, 0.20774755f, 0.13467646f, 0.01858552f, 0.06076143f, -0.12453458f, 0.04704243f, 
    0.30359399f, -0.03269595f, -0.01601200f, 0.04617208f, 0.29397434f, -0.16244595f, -0.03552362f, -0.09074905f, 
    -0.01242098f, -0.12846221f, -0.13386074f, -0.02260749f, 0.11537547f, -0.04180843f, 0.18259922f, 0.01716991f, 
    0.06985087f, 0.12763472f, 0.23457724f, 0.13548087f, 0.03701713f, -0.02779448f, -0.07014824f, -0.35857075f, 
    -0.02524249f, -0.04306215f, 0.01979669f, -0.13181123f, 0.02796327f, 0.13066621f, -0.30558139f, 0.20885567f, 
    -0.08902267f, -0.11526784f, -0.11292651f, -0.17992935f, 0.11964214f, 0.14430661f, 0.14726865f, -0.05821764f, 
    -0.01767975f, -0.09356073f, -0.11448009f, -0.10356864f, -0.25771534f, -0.26186627f, -0.07043456f, -0.28904298f, 
    -0.03424210f, 0.10813437f, 0.02187105f, 0.09546214f, -0.24119256f, 0.12136072f, -0.18316287f, 0.14352222f, 
    0.11365753f, -0.02593397f, 0.03435173f, 0.01558233f, 0.11434899f, -0.00716164f, 0.07249974f, -0.02944517f, 
    0.04192569f, 0.23775899f, -0.00847203f, -0.01418528f, -0.06523058f, 0.11336698f, -0.32472026f, 0.10846877f, 
    -0.01772301f, -0.07152062f, -0.13639106f, 0.10136145f, -0.04184867f, 0.12962280f, 0.01802801f, 0.13335364f, 
    -0.37973106f, -0.00538100f, 0.00242144f, 0.06580631f, -0.14550260f, -0.16830961f, -0.21306959f, -0.27958128f, 
    -0.01949232f, -0.13402449f, -0.15552072f, -0.15190256f, 0.05835097f, 0.27906495f, -0.01237108f, 0.16719624f, 
    0.05657497f, 0.02229677f, -0.03580184f, -0.06017661f, 0.37358633f, 0.15441102f, 0.05691116f, 0.00079400f, 
    0.05668025f, 0.07074000f, -0.08706119f, -0.13425317f, -0.00925707f, -0.05737412f, -0.09099647f, -0.00184925f, 
    -0.14462391f, -0.11987925f, -0.02233416f, 0.23352046f, -0.14282492f, 0.04796516f, 0.02493062f, 0.07633815f, 
    0.08341175f, -0.06924797f, 0.08595258f, -0.03087744f, -0.12981963f, -0.12603962f, -0.39329734f, -0.16364579f, 
    -0.14290239f, -0.18147662f, 0.05156317f, -0.11698443f, 0.04064759f, 0.05192854f, 0.06470750f, 0.10457926f, 
    0.16800077f, 0.27107316f, 0.06740439f, 0.09344234f, 0.06580393f, 0.06019100f, 0.19484448f, -0.02288632f, 
    0.18071897f, 0.08351161f, 0.20668711f, 0.29539046f, -0.01072012f, -0.18735561f, 0.26962194f, -0.00000119f, 
    -0.00392550f, 0.01791067f, 0.06714222f, -0.07093090f, 0.06907584f, 0.18246225f, 0.25341660f, -0.04768136f, 
    0.09854101f, 0.28753570f, 0.42145109f, 0.08699456f, -0.05724207f, -0.14570408f, -0.41762435f, -0.03707481f, 
    -0.10120142f, -0.13486816f, -0.10483573f, 0.14866914f, 0.21059564f, -0.08784206f, -0.31338334f, -0.00122468f, 
    0.31250745f, 0.19608584f, 0.00991021f, -0.06022803f, -0.15317994f, 0.05375287f, -0.10087564f, -0.14011790f, 
    -0.27082643f, -0.09166574f, 0.05813210f, 0.07200202f, 0.04138559f, 0.10646249f, -0.25011480f, -0.09798522f, 
    0.00400428f, -0.16127315f, 0.03872642f, -0.09959731f, -0.27368590f, -0.10211550f, -0.31840301f, 0.04753361f, 
    0.01560083f, -0.08338849f, -0.02222088f, -0.16753198f, 0.01130212f, -0.12200125f, 0.03605543f, 0.11848036f, 
    0.35108584f, 0.32446745f, 0.05931178f, -0.10555295f, 0.19111529f, -0.07557666f, -0.09308688f, 0.19883732f, 
    -0.05541919f, -0.07892630f, -0.11866628f, -0.07285117f, 0.08978866f, -0.16667031f, 0.11047492f, 0.13233991f, 
    0.03418632f, 0.04627204f, -0.01312665f, 0.00990755f, -0.02771485f, -0.05618510f, 0.03375556f, 0.04738582f, 
    -0.01585583f, -0.00319607f, 0.00689580f, 0.15560396f, 0.05094592f, 0.14805627f, 0.00420388f, -0.04842281f, 
    0.06526847f, 0.12624077f, -0.00287144f, 0.00169979f, 0.01483732f, 0.02054989f, 0.42351785f, 0.23350105f, 
    -0.08891959f, -0.04635792f, -0.17699538f, 0.03370942f, -0.08164687f, 0.02724323f, -0.03118179f, -0.06817583f, 
    0.00624524f, 0.04761428f, -0.18305990f, -0.00347333f, 0.29819962f, 0.16113240f, -0.22325215f, 0.06073532f, 
    -0.00458944f, -0.04573125f, 0.18964121f, 0.25146937f, 0.18084276f, 0.06329696f, 0.06944390f, -0.18772684f, 
    0.19542952f, 0.07303019f, 0.07087159f, 0.18014017f, -0.02125658f, -0.01182042f, 0.02299108f, -0.09575678f, 
    -0.14007629f, 0.00343256f, 0.00922659f, -0.06808888f, 0.00480227f, -0.14400969f, 0.06987158f, 0.19959919f, 
    -0.11584134f, -0.01548211f, -0.16726047f, -0.13621797f, -0.31903487f, 0.01878482f, 0.12978260f, 0.08493097f, 
    -0.05891444f, -0.08927015f, 0.08399041f, -0.02182740f, 0.08236419f, -0.00330628f, 0.12862739f, 0.03271988f, 
    -0.02768571f, 0.02802709f, -0.02325547f, -0.07600179f, 0.05410923f, 0.07701469f, -0.00975022f, -0.05581725f, 
    -0.11453201f, -0.18802141f, 0.00106239f, -0.01879634f, -0.18081838f, 0.06749397f, -0.07240804f, -0.11242143f, 
    0.10739589f, 0.08977406f, 0.00999729f, 0.09256044f, -0.18274432f, 0.17196104f, -0.05419365f, -0.05488783f, 
    0.03960922f, -0.09193556f, -0.33457786f, 0.06916328f, 0.09092687f, 0.04135167f, 0.08088175f, -0.01238506f, 
    -0.11808708f, 0.01293379f, -0.04027173f, -0.15301481f, -0.02240908f, -0.28477383f, 0.33227220f, -0.06815178f, 
    -0.09575966f, 0.12948975f, -0.19651379f, -0.08764822f, 0.11429283f, 0.05012983f, 0.01858489f, -0.04398442f, 
    0.14662382f, -0.15613762f, 0.18828119f, -0.04431826f, -0.00766932f, 0.14489509f, 0.07505390f, -0.02280699f, 
    -0.02196728f, -0.03667130f, -0.07203414f, 0.00240943f, -0.21368274f, -0.14784592f, -0.11710213f, -0.03188000f, 
    -0.09591778f, -0.10963586f, -0.21760428f, -0.13961926f, 0.05558873f, -0.06279137f, -0.07031301f, -0.11161238f, 
    0.06423409f, 0.05199718f, 0.26030883f, -0.08411517f, 0.03771652f, -0.00381476f, 0.01056872f, 0.01060141f, 
    0.15543143f, 0.18649016f, 0.27672040f, 0.18602914f, -0.20894830f, -0.00216420f, 0.21513547f, 0.16990273f, 
    0.02558997f, 0.03256980f, -0.07805372f, 0.07773925f, -0.05436476f, -0.03569182f, 0.01586386f, 0.16286255f, 
    -0.14783223f, -0.34868455f, -0.22899151f, 0.23044005f, 0.19667353f, -0.00157039f, -0.08064286f, 0.04157620f, 
    -0.08744176f, -0.00760112f, 0.13743857f, 0.05930019f, 0.30443794f, 0.22021021f, -0.12632218f, 0.04631180f, 
    0.03090743f, 0.06651884f, -0.00206398f, 0.00886839f, 0.15693292f, 0.07415190f, 0.16170245f, 0.21696863f, 
    0.24113730f, 0.13875414f, 0.07954673f, 0.19753231f, 0.02400854f, -0.11936589f, -0.05470514f, 0.00375010f, 
    0.01049329f, 0.11466851f, 0.03619853f, 0.20131268f, 0.06293391f, 0.04679634f, 0.10798685f, -0.29014686f, 
    -0.00412313f, -0.03422545f, 0.12129167f, 0.10106680f, 0.04473001f, 0.03760005f, -0.02154686f, -0.04402134f, 
    0.07395586f, -0.19313614f, 0.28441340f, 0.17731534f, 0.03053840f, -0.16267240f, -0.04644475f, -0.17679706f, 
    0.36794829f, 0.01127697f, 0.10598762f, 0.07910750f, -0.17702886f, -0.35230634f, -0.08335351f, 0.13679501f, 
    -0.04889701f, 0.08744839f, -0.17888078f, -0.07009257f, -0.06112450f, -0.00749925f, 0.03141950f, -0.27131534f, 
    0.00152148f, -0.08516800f, 0.10936422f, 0.01886768f, 0.04299184f, -0.13217618f, -0.10587185f, 0.11586007f, 
    -0.04943048f, 0.00832882f, -0.07362165f, 0.05511111f, -0.02730121f, -0.08892297f, -0.19369870f, 0.20823905f, 
    -0.03190609f, 0.07133629f, 0.06825525f, -0.07358655f, 0.00842596f, -0.02974347f, -0.02736019f, 0.02380831f, 
    -0.01741358f, 0.14359523f, 0.06430626f, -0.19992909f, 0.06060516f, 0.04867548f, 0.00366935f, -0.11144570f, 
    -0.04993458f, -0.13272831f, 0.18776102f, 0.05547500f, -0.24347797f, 0.00718952f, 0.04000013f, -0.12550507f, 
    0.09011626f, 0.05388887f, 0.03611008f, -0.06063750f, -0.19996910f, 0.19245961f, -0.06637961f, 0.09424465f, 
    0.11558685f, 0.05579579f, -0.11337159f, -0.15169479f, -0.06151858f, 0.05672469f, 0.02274602f, 0.04623066f, 
    0.02013718f, 0.06342456f, 0.07604265f, -0.08248523f, 0.08266805f, -0.21310320f, 0.19008543f, 0.18764897f, 
    0.01668316f, 0.03703559f, -0.18326497f, 0.08936845f, 0.06566273f, 0.02994246f, -0.02443266f, -0.05955923f, 
    -0.01492696f, 0.16310073f, -0.06043816f, -0.06971743f, -0.12078217f, 0.10594038f, -0.04079007f, -0.22021753f, 
    -0.25229451f, 0.07417319f, -0.08533028f, -0.06820541f, -0.01529404f, -0.07115660f, 0.07373006f, 0.09380427f, 
    -0.02299590f, -0.00921864f, -0.15039393f, 0.06340887f, -0.03561075f, -0.09797180f, -0.09805749f, -0.18160993f, 
    -0.10110201f, 0.01449977f, 0.08561624f, -0.11589246f, -0.12400713f, -0.15958633f, 0.07655399f, 0.12353003f, 
    -0.06472100f, 0.21798502f, 0.04427814f, 0.06649635f, -0.31395012f, 0.20388190f, -0.04090311f, 0.05090689f, 
    0.03353547f, -0.04275357f, -0.00439031f, -0.06260830f, -0.10052122f, 0.12498294f, 0.11341270f, 0.03779211f, 
    -0.12227727f, -0.13863832f, -0.23792610f, 0.05641609f, 0.08031388f, 0.03537529f, -0.04724373f, 0.04884226f, 
    0.03725660f, 0.20128264f, -0.03591451f, 0.11580811f, 0.16075839f, 0.37533724f, -0.19290322f, -0.15982442f, 
    0.03746834f, -0.04904009f, 0.01718405f, -0.00952314f, -0.00736706f, 0.12554091f, 0.13982776f, 0.13943262f, 
    0.39344662f, 0.08126616f, 0.09167372f, 0.12643495f, 0.03289988f, -0.08341407f, 0.02868548f, 0.16697185f, 
    -0.01388042f, 0.09517863f, -0.04475344f, 0.08682335f, 0.00024919f, 0.03527778f, 0.14386298f, -0.18181624f, 
    -0.05929121f, -0.10885241f, 0.02255674f, -0.00285621f, -0.04479064f, 0.04922370f, -0.03904410f, -0.00918777f, 
    0.10884507f, -0.22177383f, 0.23423743f, -0.01341022f, -0.02261792f, -0.12669799f, 0.07119522f, -0.04205472f, 
    0.05367921f, 0.10875026f, -0.00991818f, -0.11593536f, -0.20937037f, -0.15839285f, -0.37164760f, 0.02940879f, 
    0.03419277f, 0.06240221f, -0.17208096f, -0.08849820f, -0.03669800f, 0.08701734f, 0.04220935f, -0.11667777f, 
    -0.08480668f, 0.09248842f, 0.10019185f, 0.01170155f, 0.02540891f, -0.00193345f, 0.07053304f, 0.23629041f, 
    -0.27009171f, -0.05013541f, 0.00841072f, -0.04546861f, 0.11078341f, 0.09099972f, 0.45316407f, 0.32909414f, 
    0.12783638f, 0.20823292f, 0.03610097f, -0.05337165f, 0.13210173f, 0.10399161f, 0.01836457f, -0.12733582f, 
    0.32109776f, -0.03548349f, 0.17448068f, -0.03229307f, -0.09260648f, 0.11000430f, -0.02078958f, -0.09328501f, 
    -0.11906476f, -0.28661731f, 0.13244787f, -0.21796116f, -0.31474766f, -0.05655710f, -0.49023634f, -0.43006241f, 
    0.08064299f, -0.16956583f, -0.05950625f, 0.00131632f, 0.01868754f, 0.00991616f, -0.12249608f, -0.12932816f, 
    -0.19909087f, -0.00386455f, -0.20494379f, 0.12865984f, -0.14525485f, -0.00555429f, 0.06327567f, -0.15893905f, 
    -0.00621868f, 0.04987730f, 0.21068437f, -0.01016731f, -0.13907906f, 0.05939396f, -0.01994628f, 0.15168492f, 
    -0.00130448f, 0.18104571f, -0.04659037f, -0.15793236f, -0.08121105f, -0.03142060f, 0.00376186f, 0.02177585f, 
    -0.63396013f, -0.31598237f, 0.33420795f, -0.29065987f, 0.33930847f, -0.01218656f, -0.13259932f, -0.18562271f, 
    -0.31032029f, -0.06856252f, 0.15374087f, -0.08017837f, 0.11156504f, 0.16088556f, 0.16613598f, 0.16599296f, 
    -0.18220258f, 0.09100090f, 0.15577857f, 0.11169577f, -0.04976754f, 0.10886100f, 0.14905190f, -0.11490773f, 
    -0.03602055f, -0.00810723f, 0.02167667f, -0.09429976f, -0.02556172f, -0.18949974f, 0.08671278f, -0.13903657f, 
    -0.10190675f, -0.04947875f, -0.03483774f, 0.19253735f, -0.09867021f, 0.32191518f, -0.32647890f, 0.10346348f, 
    -0.34462994f, 0.00995641f, 0.05049281f, -0.12497275f, -0.01175549f, 0.11261287f, -0.08483581f, 0.06148096f, 
    0.02057557f, 0.12808074f, -0.07457355f, 0.16178918f, 0.02904126f, -0.04347092f, 0.02581925f, 0.15815528f, 
    0.10696203f, 0.13096391f, -0.18468857f, 0.13708995f, -0.12409232f, -0.14868215f, -0.05569840f, -0.15596116f, 
    -0.04530614f, -0.18654887f, -0.03373649f, -0.02979923f, 0.06861646f, 0.21895127f, -0.02394319f, 0.19604090f, 
    0.50690204f, 0.42461213f, 0.35348624f, 0.30289879f, 0.13484152f, 0.06917225f, -0.10884258f, -0.03882185f, 
    -0.00249293f, 0.05866678f, 0.04994766f, 0.06663054f, -0.51509541f, 0.01055782f, 0.16980059f, -0.18450747f, 
    -0.00403233f, -0.04062792f, -0.30922103f, -0.21349134f, -0.10732930f, -0.04362262f, 0.13141511f, 0.08378079f, 
    0.61983705f, -0.64755821f, -0.16579631f, 0.20429260f, -0.18416315f, -0.00652440f, -0.05680818f, 0.08304888f, 
    0.01620992f, 0.00678399f, 0.01524959f, 0.03579377f, 0.07139914f, -0.01033957f, 0.17773961f, 0.13382889f, 
    0.10892012f, -0.09273826f, 0.06322867f, -0.01606618f, -0.07306574f, -0.15288951f, -0.01745370f, -0.21550354f, 
    -0.02666200f, 0.02883828f, 0.21085055f, 0.03543114f, 0.19281469f, -0.18210687f, -0.15675855f, 0.05850232f, 
    -0.13017285f, 0.15354675f, -0.12298430f, -0.03020410f, -0.10464149f, -0.12560081f, -0.03010716f, 0.16907369f, 
    -0.08008894f, 0.08961320f, 0.10092664f, 0.06944958f, -0.16506343f, -0.23283608f, 0.03352423f, -0.03424434f, 
    0.04102146f, 0.17111970f, 0.15941478f, -0.03468433f, -0.10849518f, 0.13268356f, -0.28453016f, 0.04025853f, 
    0.07209177f, -0.16141225f, 0.11847310f, 0.06445754f, -0.12872159f, 0.02222646f, -0.05960374f, -0.26184696f, 
    0.01548917f, -0.14498916f, -0.17108122f, 0.12195293f, -0.13526700f, 0.03529873f, 0.06393009f, 0.00882798f, 
    0.44551599f, 0.18762510f, -0.53439760f, 0.17417490f, 0.04399740f, -0.08643801f, 0.02442783f, -0.01977669f, 
    0.08669711f, 0.14239159f, 0.05576561f, 0.03410173f, -0.22145157f, -0.08834432f, 0.41047868f, 0.09633819f, 
    0.01557585f, 0.05905992f, 0.05364426f, 0.04532576f, 0.11693214f, -0.05289159f, 0.01856362f, 0.04214367f, 
    -0.11178258f, 0.06178010f, -0.12716451f, -0.08972144f, -0.16070889f, 0.08055712f, -0.27144724f, -0.06262752f, 
    -0.15623941f, 0.07507309f, -0.13562740f, -0.04231109f, -0.17925774f, -0.09524055f, -0.04890797f, 0.03751732f, 
    -0.06325254f, 0.04631666f, 0.02284548f, 0.07004020f, -0.20803347f, -0.15658651f, -0.08535045f, -0.17997621f, 
    -0.17832938f, 0.28823471f, 0.15930258f, -0.11606064f, -0.17555977f, 0.19972734f, 0.00698516f, 0.07441933f, 
    0.20375316f, 0.38886288f, 0.11659475f, 0.04701309f, -0.20867626f, -0.01656153f, 0.23265798f, -0.06452094f, 
    0.08381419f, -0.03982900f, -0.01455567f, 0.15904780f, 0.07668716f, 0.03832743f, 0.06398049f, 0.03174737f, 
    -0.01336158f, -0.22688916f, -0.20725752f, 0.07046222f, -0.11548207f, -0.03060559f, 0.04252574f, 0.07503838f, 
    -0.01323420f, 0.12996463f, -0.02762049f, -0.03322473f, 0.00319428f, 0.38364410f, -0.37113023f, -0.09655242f, 
    0.06718951f, -0.04853164f, 0.10234836f, -0.09530376f, 0.12221313f, 0.04213532f, 0.16193800f, 0.10179418f, 
    0.28112513f, -0.01718583f, 0.16858378f, 0.35058656f, 0.03702183f, 0.04456866f, 0.07342394f, 0.05955480f, 
    -0.00048714f, -0.02994234f, 0.11701104f, 0.15909959f, -0.05308003f, 0.19261079f, 0.21521109f, 0.05080519f, 
    0.07912966f, -0.10972323f, -0.07270459f, -0.05886447f, 0.02981254f, 0.17017485f, -0.03099105f, 0.03885495f, 
    0.11840549f, -0.27849367f, 0.30909505f, 0.06323689f, 0.07471904f, -0.01383378f, 0.10782973f, -0.14885318f, 
    -0.04902035f, 0.16467801f, -0.13912205f, 0.07185204f, -0.15715912f, -0.17976837f, -0.24498756f, 0.08644514f, 
    0.03438785f, -0.04153418f, -0.02916363f, 0.15452649f, 0.05526672f, -0.01333654f, 0.00235413f, -0.03766809f, 
    0.05735518f, 0.07210633f, 0.01376405f, -0.02798468f, 0.28506246f, -0.15557241f, 0.06319147f, 0.04190476f, 
    0.05236793f, 0.08777609f, 0.11454043f, 0.07089002f, -0.13288786f, -0.15458238f, 0.16285636f, 0.25998041f, 
    -0.09873340f, -0.01515541f, -0.07750740f, -0.13357115f, 0.11350236f, 0.04474210f, 0.05378517f, -0.09580704f, 
    0.01095839f, 0.07763145f, 0.27120724f, 0.06513786f, -0.02113461f, -0.09009335f, -0.04712009f, -0.03503961f, 
    -0.02371379f, -0.06946337f, 0.17298394f, 0.00082651f, -0.21051098f, -0.28173405f, 0.05636258f, 0.24782616f, 
    0.07206416f, -0.15256691f, -0.16481954f, -0.00050751f, 0.05948441f, 0.05519139f, 0.09120737f, 0.17740105f, 
    -0.33388376f, -0.08491143f, -0.30914119f, 0.31122914f, -0.02450921f, 0.13317306f, 0.06139123f, 0.10185616f, 
    0.14363635f, 0.12025081f, 0.07997775f, 0.13674948f, 0.00495348f, -0.27682638f, -0.05964030f, -0.09502883f, 
    -0.02719121f, -0.04942621f, 0.12948626f, 0.04189123f, -0.05767962f, -0.05939786f, 0.04206840f, 0.09273212f, 
    -0.05145827f, -0.01456823f, -0.02754913f, -0.19577500f, -0.11414868f, 0.01650586f, 0.01247120f, -0.05969803f, 
    0.10167103f, -0.02949869f, 0.03769081f, -0.08587873f, -0.28956568f, 0.05433991f, 0.10775653f, 0.09749052f, 
    -0.18701448f, -0.04604008f, 0.20017512f, 0.01221150f, -0.00128972f, 0.06072718f, 0.04884465f, 0.00480029f, 
    0.12364887f, -0.00506505f, 0.00109479f, -0.28057352f, -0.01553255f, -0.00715289f, 0.11062516f, 0.03434857f, 
    -0.01412330f, 0.19988813f, -0.03865431f, 0.04324434f, 0.05207087f, 0.14247081f, 0.28237641f, 0.17090064f, 
    -0.02479511f, -0.04003396f, -0.19982170f, 0.02953383f, 0.02337571f, 0.09463316f, 0.11112010f, 0.16458164f, 
    -0.09143174f, -0.13829094f, -0.18162368f, 0.09453981f, 0.03897090f, 0.01189062f, 0.04252342f, 0.02300963f, 
    -0.09693855f, 0.03213862f, -0.10664256f, 0.07922695f, -0.13375100f, 0.40541553f, -0.20218834f, 0.31173915f, 
    0.01998002f, 0.05283046f, -0.06679750f, 0.06082623f, -0.16959871f, -0.03755784f, 0.02273456f, -0.08373698f, 
    0.33905953f, 0.44458142f, 0.41807789f, 0.19794737f, -0.06875265f, -0.09559324f, 0.01649351f, 0.03970536f, 
    -0.05349022f, 0.11176065f, 0.00982732f, 0.13478546f, -0.03887480f, -0.01237109f, 0.03135018f, 0.01824081f, 
    -0.00306781f, 0.00970904f, 0.12595449f, -0.14512937f, 0.08362558f, -0.09167721f, -0.00319988f, 0.01437935f, 
    0.03262958f, -0.25267607f, 0.21430176f, -0.06770859f, 0.17497908f, -0.19234194f, -0.21996482f, -0.03211535f, 
    0.03176494f, 0.20814914f, 0.03073929f, 0.15520363f, -0.32822052f, -0.00683211f, -0.26755303f, 0.09772351f, 
    0.05842441f, 0.01088947f, 0.06603166f, 0.16180159f, 0.05835494f, 0.07038314f, 0.19100837f, -0.12738435f, 
    0.06343793f, -0.00460149f, -0.02266109f, -0.20492086f, 0.10511459f, 0.11027228f, 0.05890908f, 0.00228680f, 
    0.21588184f, -0.01463014f, -0.04956213f, 0.12984678f, 0.31442326f, 0.17891574f, -0.00590643f, -0.00424416f, 
    -0.02874189f, 0.03888832f, -0.03887779f, -0.02822730f, 0.05108334f, -0.03545402f, -0.04781192f, -0.02259819f, 
    -0.02358919f, 0.18234488f, 0.08876909f, 0.12839150f, -0.01456481f, 0.03190013f, -0.16411069f, -0.03763633f, 
    0.06345785f, 0.05813629f, 0.11069552f, 0.11199839f, 0.10099647f, -0.15307792f, 0.17947724f, 0.24993579f, 
    -0.06898984f, -0.00770329f, -0.16956796f, -0.08321154f, 0.02887173f, -0.06559578f, 0.20713320f, 0.07088197f, 
    -0.42898783f, 0.11237773f, -0.06104423f, 0.20000488f, 0.14891297f, 0.03504569f, 0.09074882f, -0.02155166f, 
    0.15723087f, -0.06447087f, -0.09361890f, 0.04353522f, 0.14548363f, -0.11286579f, -0.28210095f, -0.11543442f, 
    -0.05420532f, -0.17492709f, 0.23046337f, -0.05847127f, -0.05378443f, -0.02623655f, -0.06832302f, 0.07176994f, 
    -0.08359621f, -0.06485232f, -0.09582254f, -0.02585625f, 0.00419802f, -0.02692318f, -0.05387770f, -0.14078780f, 
    0.22701830f, -0.13344890f, -0.12885758f, -0.02758127f, -0.18396464f, 0.12449272f, 0.14581271f, 0.03729170f, 
    0.17264213f, 0.16504942f, 0.30047354f, 0.10694156f, -0.15776454f, -0.05833343f, 0.01100571f, 0.02245874f, 
    0.07625890f, -0.04867230f, -0.01896969f, -0.18969591f, 0.01545965f, 0.17495754f, 0.03221447f, 0.02546891f, 
    0.04655361f, 0.02935172f, -0.03769223f, -0.12037296f, 0.32675764f, -0.05093015f, 0.11963874f, 0.06320139f, 
    -0.00444676f, -0.10287526f, -0.31997988f, 0.07147852f, -0.01341221f, -0.00126037f, 0.06899703f, 0.09736757f, 
    -0.01593728f, 0.11072885f, 0.04032580f, 0.01616197f, 0.00428930f, 0.06799761f, -0.04446114f, 0.10330015f, 
    -0.01222296f, -0.10668716f, -0.05473123f, -0.12040000f, -0.34507462f, 0.32023928f, -0.06340684f, 0.52005112f, 
    0.10836812f, -0.08758989f, -0.13197760f, -0.06382278f, -0.14520484f, -0.14416720f, -0.04675603f, -0.26510939f, 
    -0.14425977f, 0.10255915f, 0.03606524f, -0.11904498f, -0.01502859f, -0.04882370f, 0.08687259f, -0.10323836f, 
    0.07694247f, -0.00387283f, 0.00333411f, 0.07724145f, 0.09497888f, -0.09770971f, -0.20612292f, 0.17378102f, 
    0.06031388f, -0.04473371f, 0.02873155f, -0.13085140f, 0.09104136f, -0.09266707f, -0.01446453f, -0.00357585f, 
    -0.71478856f, 0.26109803f, 0.06450775f, -0.14042054f, 0.16220476f, 0.00022363f, -0.24586770f, -0.08868900f, 
    0.02480049f, 0.05610238f, -0.05453654f, 0.19636944f, -0.01433772f, 0.20853783f, 0.17176951f, 0.16150074f, 
    0.27928379f, -0.04894904f, 0.25849158f, 0.18560705f, 0.17357941f, 0.02763538f, -0.00504708f, -0.00861756f, 
    -0.27668267f, -0.04209083f, -0.09405712f, -0.08347498f, -0.02528244f, 0.29671946f, -0.03006486f, 0.21435605f, 
    -0.26340300f, -0.25528893f, -0.23913583f, -0.54139471f, -0.07312073f, -0.07833910f, 0.21644704f, -0.05481761f, 
    0.02811102f, 0.11592343f, 0.17063998f, 0.10249338f, 0.17997625f, -0.03836488f, -0.01266688f, 0.22577026f, 
    0.25567645f, 0.03612661f, -0.13926700f, 0.11713701f, -0.18691970f, 0.07138306f, -0.41898999f, -0.15920401f, 
    0.05503832f, -0.29365155f, 0.01946288f, -0.10665142f, 0.23051699f, 0.07338397f, -0.07950580f, -0.34654957f, 
    -0.02280216f, -0.09612852f, -0.07121839f, 0.08347344f, -0.15632324f, 0.02818692f, -0.10855678f, -0.25674152f, 
    -0.04677431f, 0.03034827f, 0.01362526f, 0.20007864f, -0.10226566f, 0.02463601f, 0.16526356f, -0.04020277f, 
    -0.33059588f, -0.24039905f, -0.07809377f, -0.38019681f, -0.32493734f, 0.31605440f, 0.01618529f, 0.19382024f, 
    0.04804592f, 0.15482190f, 0.08304775f, -0.06956857f, -0.04310417f, 0.07461414f, 0.07396303f, -0.24602725f, 
    -0.15395576f, -0.13156514f, 0.21551724f, 0.10687776f, 0.12870172f, 0.01015527f, -0.15691444f, -0.08892608f, 
    -0.11372652f, -0.17827179f, -0.06841920f, 0.14687845f, 0.21904112f, 0.08847465f, -0.26439023f, -0.10319941f, 
    -0.00560599f, 0.02834997f, 0.03442590f, 0.13385852f, -0.05160388f, -0.07857864f, -0.07366206f, -0.29836291f, 
    -0.20496608f, 0.09863728f, 0.10706253f, 0.18938775f, -0.08606111f, -0.21824273f, -0.05379590f, -0.16183610f, 
    0.22546069f, 0.17156780f, 0.27995548f, 0.32334465f, 0.39136514f, 0.01302449f, 0.23860157f, -0.18996094f, 
    -0.28184980f, 0.03202204f, -0.11786589f, -0.16253613f, 0.13647927f, -0.05751028f, 0.08826306f, 0.05154676f, 
    0.18889314f, 0.15226288f, 0.17482117f, 0.04818365f, 0.22536503f, -0.12341052f, 0.09108759f, 0.09487302f, 
    0.17286763f, 0.19590926f, 0.12246361f, 0.11751943f, 0.34036690f, 0.00309999f, 0.05082512f, 0.20616521f, 
    -0.20556967f, 0.03488213f, 0.07570922f, -0.12423510f, 0.22923693f, 0.15758623f, 0.02878406f, 0.29078782f, 
    0.37259406f, 0.00336628f, 0.11284284f, 0.23093963f, -0.05693394f, 0.08880475f, 0.06452968f, -0.11931694f, 
    0.16904871f, -0.03430738f, -0.04783193f, 0.26898444f, -0.38280511f, 0.33136845f, -0.07634696f, 0.15859441f, 
    -0.01852334f, -0.11008523f, -0.08684058f, 0.10548005f, -0.01797621f, -0.19742261f, -0.13550910f, 0.06967949f, 
    0.46713018f, -0.08257541f, -0.50058055f, 0.27929628f, -0.08039635f, -0.01418366f, -0.07535210f, -0.13229330f, 
    0.13372347f, 0.08593947f, -0.03644592f, 0.19718143f, 0.19519816f, -0.13405338f, 0.18735257f, -0.05850838f, 
    0.08081631f, 0.10866605f, -0.00552969f, 0.06730536f, -0.02312947f, -0.11372732f, -0.04310066f, -0.05147707f, 
    0.02109158f, -0.04496857f, -0.02410962f, 0.05216376f, -0.01361184f, 0.02983625f, -0.02393933f, -0.04379534f, 
    -0.04177816f, -0.00230868f, -0.02477270f, -0.03289231f, -0.02423241f, -0.02516102f, 0.01443998f, -0.02255603f, 
    -0.04493448f, -0.01903688f, -0.03695142f, -0.02125137f, -0.06220027f, 0.02068424f, -0.00236909f, -0.03113843f, 
    0.01386111f, -0.04989266f, 0.05312007f, -0.02236581f, -0.00339689f, -0.02490649f, -0.00729728f, -0.02134340f, 
    0.03203712f, -0.04911146f, 0.03148999f, 0.05766845f, 0.00042371f, 0.06501031f, 0.03900092f, -0.01645144f, 
    -0.06796895f, -0.06246362f, 0.02505738f, -0.03614445f, -0.02420028f, -0.05585251f, -0.04608249f, 0.03175844f, 
    -0.04924821f, 0.04788949f, -0.00164714f, -0.04690370f, -0.01545768f, -0.06988160f, 0.05798478f, 0.01299358f, 
    0.00494175f, 0.01359929f, -0.02243958f, -0.03182121f, 0.04602045f, 0.04998398f, -0.06369909f, -0.03436124f, 
    -0.07350993f, -0.06186303f, -0.02595107f, -0.06424366f, -0.01925709f, 0.02970231f, 0.05176570f, 0.02062066f, 
    0.00813260f, 0.00254236f, -0.07073407f, -0.03216781f, -0.03928942f, 0.00005653f, -0.02884859f, -0.00084686f, 
    -0.02990792f, -0.07809308f, 0.04251998f, -0.04442708f, 0.01189204f, -0.01072794f, 0.04613447f, -0.02156676f, 
    0.04109006f, -0.04029934f, -0.00952272f, 0.03667690f, 0.00173764f, 0.01088201f, -0.03437002f, -0.05890493f, 
    -0.04786352f, -0.04772681f, 0.06873231f, 0.00141278f, -0.02222228f, -0.01360045f, -0.01637381f, 0.03187094f, 
    0.05203175f, 0.06139523f, 0.03388649f, -0.02955929f, -0.06863032f, -0.00272022f, 0.05089581f, -0.07179114f, 
    -0.05171151f, 0.03772865f, 0.01966341f, 0.01302847f, 0.05533139f, -0.01514168f, -0.07780829f, -0.06486153f, 
    -0.05881741f, 0.03690632f, -0.06180548f, 0.01824793f, -0.06730252f, -0.07487653f, 0.00100438f, -0.06045946f, 
    -0.03874020f, 0.02002572f, -0.03794252f, -0.05137496f, -0.02714896f, -0.07530085f, 0.00229139f, -0.04793071f, 
    0.03049554f, -0.01164057f, 0.02625377f, 0.06251486f, 0.04171607f, 0.04924745f, -0.00778989f, -0.05492770f, 
    -0.05808248f, 0.06458504f, 0.04439252f, 0.04081243f, 0.03370871f, -0.06300638f, 0.02513980f, -0.02421491f, 
    -0.06705140f, -0.01165582f, -0.04998961f, 0.00021422f, 0.05751748f, -0.05328279f, -0.00054950f, 0.03062746f, 
    -0.03165337f, -0.01813785f, -0.01120578f, -0.04498030f, -0.07544846f, -0.01728807f, -0.00943812f, 0.01038648f, 
    -0.05887170f, -0.06534304f, -0.00534249f, 0.03051988f, 0.00250222f, -0.01824338f, -0.04809724f, 0.03115323f, 
    -0.00007096f, -0.03541013f, 0.00980717f, -0.03669046f, 0.04324560f, 0.03944574f, -0.02072746f, 0.01154614f, 
    -0.04516621f, 0.01202872f, 0.00214340f, -0.03032646f, -0.06487911f, -0.06215167f, 0.04654393f, -0.06407334f, 
    -0.02817435f, -0.20865308f, -0.05197083f, 0.09188309f, -0.10032684f, -0.03763596f, -0.13876744f, -0.23600437f, 
    0.09090252f, 0.07573272f, -0.05259846f, 0.05392085f, -0.24034141f, -0.05718212f, -0.19233339f, -0.04387236f, 
    0.04644509f, 0.00354533f, 0.11091610f, 0.25456208f, -0.18917409f, -0.11864143f, -0.00475253f, 0.17836639f, 
    -0.10009225f, 0.10400932f, -0.13765442f, -0.06007846f, -0.13818076f, -0.08190383f, -0.22162575f, 0.08486821f, 
    0.22039565f, 0.03608049f, 0.10462321f, 0.12786067f, -0.01069531f, 0.16694091f, -0.18109792f, -0.27711579f, 
    -0.15571970f, -0.06172199f, -0.01254582f, -0.03188815f, -0.06373844f, -0.08346172f, 0.02757568f, 0.00059994f, 
    0.66080296f, 0.14863920f, 0.05618951f, -0.04684269f, 0.10976013f, 0.01039649f, -0.00065619f, 0.03646390f, 
    -0.02206261f, -0.03156117f, -0.08646122f, 0.07697700f, -0.13528553f, 0.03442037f, 0.40471900f, 0.33046937f, 
    0.15301183f, 0.22356559f, -0.08754248f, 0.12069172f, 0.02880000f, 0.05547974f, 0.09312211f, -0.01516520f, 
    -0.04315214f, 0.12274110f, -0.32505059f, 0.05044234f, -0.10374922f, -0.03553951f, -0.00709524f, -0.02541802f, 
    -0.12799579f, 0.04491098f, -0.02486934f, 0.12401011f, 0.18444866f, -0.13335182f, 0.03803216f, 0.21859671f, 
    0.24543741f, 0.15753323f, -0.07785315f, 0.08663011f, 0.10649703f, -0.07531311f, -0.04152294f, 0.01323661f, 
    -0.31041506f, 0.14805025f, -0.08119460f, 0.09262959f, -0.08596176f, 0.15818112f, -0.04653735f, 0.13152353f, 
    0.16263637f, 0.12061515f, -0.07615271f, -0.35868481f, -0.25307068f, -0.32205179f, 0.13375509f, -0.26505107f, 
    0.10501518f, 0.03279312f, 0.11032433f, 0.06513487f, 0.06204357f, 0.13277715f, 0.13463917f, -0.16109060f, 
    0.21837300f, -0.11540686f, 0.17305085f, 0.13386446f, 0.25736427f, 0.02849861f, 0.11626960f, -0.05863714f, 
    0.06128992f, -0.04433711f, -0.01975247f, 0.04917647f, 0.10027786f, 0.06105549f, -0.19696882f, -0.23005936f, 
    -0.02829376f, 0.01166707f, 0.03663209f, 0.04319915f, -0.03463993f, -0.13977689f, 0.09280037f, -0.11537535f, 
    -0.09282918f, -0.37263814f, -0.18270540f, 0.14715217f, 0.05957317f, 0.07686606f, 0.19463642f, 0.09246896f, 
    0.08793440f, -0.00224418f, 0.12276386f, -0.00797481f, -0.05739256f, -0.12830594f, -0.14457186f, 0.25439721f, 
    -0.05658848f, -0.00658322f, -0.03540719f, 0.02039185f, -0.07293401f, -0.03793716f, -0.03628105f, -0.12033802f, 
    0.09862100f, 0.35926032f, 0.10519991f, -0.21132635f, -0.03144708f, 0.07096776f, 0.22819348f, -0.01146353f, 
    -0.05307902f, 0.09750950f, -0.01951840f, -0.00356965f, 0.05431860f, 0.06100848f, -0.05428600f, 0.14869246f, 
    -0.02576009f, -0.03833821f, -0.00251052f, 0.14752844f, 0.08476464f, -0.01606462f, -0.01061130f, 0.15300566f, 
    -0.15366019f, 0.04543750f, -0.04140654f, -0.09324779f, 0.19784662f, -0.26153785f, 0.08752560f, 0.20010735f, 
    -0.13078706f, 0.00190199f, -0.00588625f, 0.03395698f, -0.04167699f, -0.07083113f, 0.25853860f, 0.13173425f, 
    -0.14730187f, -0.06932731f, -0.01085405f, -0.12966134f, 0.18555725f, 0.02876456f, 0.13459270f, -0.04107331f, 
    -0.07395872f, 0.16434792f, 0.13768731f, -0.06304961f, -0.00794883f, -0.06648498f, -0.00183618f, -0.02174222f, 
    -0.03093028f, -0.09071070f, 0.15943840f, 0.00789055f, -0.29926255f, -0.20881891f, -0.07721817f, -0.04206379f, 
    -0.12215930f, -0.08183144f, -0.12975676f, -0.08525425f, -0.06259500f, 0.08163618f, 0.00658878f, -0.00395590f, 
    -0.03644203f, -0.10189911f, -0.55852628f, 0.16407348f, 0.00024823f, -0.02238756f, 0.07401597f, 0.01251075f, 
    0.12016364f, 0.14988583f, 0.00547484f, -0.11005793f, -0.11646265f, -0.11129034f, 0.18277068f, -0.18621227f, 
    0.02644226f, 0.01272695f, 0.11975356f, -0.08292529f, -0.01727675f, 0.03346776f, -0.06909255f, 0.07677198f, 
    0.08095132f, -0.29085848f, -0.08873208f, -0.28300568f, -0.08019622f, 0.02947609f, 0.01043450f, -0.01438458f, 
    -0.08670507f, -0.10198262f, -0.04930966f, -0.08205685f, -0.17233744f, -0.09459614f, -0.00171825f, -0.04571100f, 
    -0.14044903f, -0.15297194f, 0.00231172f, -0.03286847f, 0.00029455f, -0.06414046f, 0.06839523f, -0.03554032f, 
    0.16408551f, 0.04308086f, 0.20309402f, -0.13012101f, -0.06524549f, 0.06487872f, 0.02080080f, 0.00382720f, 
    0.04434402f, 0.23903534f, 0.12418952f, 0.19921264f, -0.07640669f, 0.08564965f, 0.17621659f, 0.08907425f, 
    -0.09148845f, -0.04918635f, -0.06049369f, 0.00010831f, 0.08171403f, 0.03827378f, -0.01074397f, 0.11633212f, 
    -0.22619723f, -0.30268005f, -0.24806373f, 0.00940388f, 0.08098714f, 0.00841967f, 0.25593311f, 0.17044148f, 
    -0.03979122f, 0.16959646f, 0.00172696f, -0.02619770f, -0.03060886f, 0.23737408f, -0.05723794f, 0.17762272f, 
    0.02697123f, 0.08277532f, 0.02743538f, -0.07223576f, 0.12434611f, 0.15803488f, 0.12967488f, 0.02851982f, 
    0.02842990f, 0.39911047f, 0.28739429f, 0.23077594f, 0.03054674f, -0.02313483f, 0.01829521f, 0.14611574f, 
    -0.01605829f, 0.17608047f, 0.13331366f, 0.24469426f, -0.06545053f, 0.13173342f, 0.09940712f, -0.06790955f, 
    0.07380462f, -0.05013820f, 0.04220176f, -0.13094655f, -0.02560982f, -0.02094362f, -0.05656338f, -0.07936364f, 
    -0.04726091f, -0.14146788f, 0.20491050f, -0.05995722f, 0.09157638f, -0.06634717f, -0.05677123f, -0.03615374f, 
    0.07851702f, 0.20348294f, 0.00056056f, 0.10234054f, -0.37910417f, -0.19390942f, -0.13504277f, -0.03427964f, 
    0.06418510f, -0.07093871f, 0.05268504f, -0.10669321f, 0.10404293f, 0.05138269f, 0.24977599f, -0.07769071f, 
    -0.08130117f, 0.02223830f, -0.02622002f, 0.00380494f, -0.00502895f, -0.04383556f, -0.05710961f, -0.11118565f, 
    -0.08921325f, 0.02407672f, -0.02099548f, -0.02351565f, -0.03465229f, -0.02157003f, -0.01325411f, -0.01674257f, 
    -0.06772606f, -0.01457578f, 0.00085488f, -0.08104522f, -0.01721144f, 0.01046511f, 0.03742321f, -0.01463960f, 
    -0.04351321f, -0.04642406f, -0.03225361f, -0.04236401f, 0.00762026f, 0.04160240f, 0.04183137f, 0.00482002f, 
    -0.05601828f, -0.06113856f, 0.02182979f, -0.09054419f, 0.03707132f, -0.07216679f, -0.01345210f, 0.01812288f, 
    -0.00805315f, -0.03933236f, -0.02008973f, 0.02443031f, 0.00861691f, -0.05334669f, -0.04383129f, -0.00428528f, 
    -0.06576404f, -0.05013143f, 0.04873287f, -0.09093268f, -0.03128277f, 0.01860584f, -0.05884694f, -0.07740369f, 
    -0.00986420f, -0.05916971f, 0.00516373f, -0.08200613f, -0.07250804f, 0.00252986f, 0.02289741f, -0.01599144f, 
    0.03990629f, -0.05718188f, -0.03956472f, -0.03732533f, 0.03621184f, -0.03206458f, 0.02558926f, -0.04439574f, 
    0.01759700f, 0.01608513f, 0.01140879f, -0.06622362f, -0.01288267f, -0.06057381f, -0.00870956f, -0.00992886f, 
    -0.10956609f, -0.10032947f, -0.00846099f, 0.01098260f, -0.05489119f, -0.06949893f, -0.05718218f, -0.03126634f, 
    -0.03933354f, -0.01067609f, -0.01057204f, -0.07904817f, -0.07189311f, -0.07490981f, 0.02515363f, 0.00887814f, 
    -0.04454461f, -0.03134325f, 0.00477120f, -0.02429099f, 0.05496602f, -0.01042529f, -0.03128709f, 0.01172164f, 
    -0.05482204f, -0.06519070f, 0.00965097f, -0.06234135f, -0.03938712f, -0.08199119f, 0.00567610f, -0.06203426f, 
    -0.07639270f, -0.09528825f, -0.03668209f, 0.03683762f, 0.01603580f, 0.00807692f, -0.06815727f, -0.01659181f, 
    -0.06685928f, -0.02049079f, -0.03825821f, 0.05830562f, 0.02901047f, 0.00542418f, 0.02107769f, 0.03857170f, 
    -0.00289759f, -0.05541132f, 0.00701554f, 0.00149399f, -0.04795302f, -0.06547372f, 0.01914145f, -0.01857920f, 
    -0.02888025f, -0.01448832f, -0.07297739f, -0.07396793f, 0.00781697f, -0.00339391f, -0.04168077f, -0.01551249f, 
    0.05503669f, 0.04174989f, -0.03009214f, 0.02363640f, -0.03697729f, -0.07526968f, -0.03598833f, -0.07867780f, 
    -0.06020168f, -0.01803271f, -0.03565147f, 0.02850759f, -0.05380474f, -0.00312852f, -0.09960309f, -0.05491656f, 
    0.02281683f, -0.10418682f, -0.00980535f, -0.07944651f, 0.02334006f, 0.00122976f, 0.02167618f, 0.02578130f, 
    0.00473037f, 0.04667921f, 0.00691120f, 0.02195545f, 0.00991176f, -0.02054503f, -0.00072902f, 0.00504094f, 
    -0.07098241f, -0.04051201f, -0.05995747f, -0.06360161f, 0.01433224f, -0.01570684f, 0.01992688f, -0.06523492f, 
    0.01697672f, 0.04648365f, 0.02061951f, -0.00647404f, 0.03669929f, 0.02376099f, -0.01670566f, -0.07134970f, 
    -0.00663455f, -0.06689553f, -0.00294613f, -0.00658267f, -0.06434499f, -0.03624368f, -0.05399192f, 0.03768072f, 
    -0.01926224f, -0.01883063f, 0.04577152f, -0.04497460f, 0.02054852f, -0.00566432f, -0.00840073f, 0.06148940f, 
    0.05574669f, 0.01356931f, -0.05935662f, -0.02879602f, -0.02195370f, -0.03399105f, -0.01697245f, 0.04719106f, 
    0.06477842f, -0.07066291f, -0.02269948f, -0.02358006f, -0.05956719f, -0.07169235f, -0.04051377f, -0.08010670f, 
    -0.01815101f, 0.01855352f, -0.02642027f, -0.06706056f, 0.02201374f, 0.01230537f, 0.01088435f, -0.00371410f, 
    0.06279790f, -0.03939328f, 0.02016647f, 0.04669754f, -0.01082386f, -0.00583482f, -0.07941388f, 0.01330534f, 
    -0.01123734f, -0.00477428f, 0.05942440f, -0.02702504f, 0.04245082f, 0.01229930f, 0.01947043f, -0.05197215f, 
    0.01706998f, -0.05440404f, -0.04726580f, -0.01474324f, -0.07048155f, -0.07810780f, 0.02077832f, 0.03446984f, 
    -0.00344628f, -0.05109913f, -0.02381870f, 0.03745465f, 0.02005382f, -0.06201806f, -0.04053602f, -0.01539651f, 
    -0.06428765f, -0.05568013f, -0.07197481f, -0.07391244f, -0.04989862f, -0.05369067f, -0.02663128f, -0.03333478f, 
    0.02262407f, -0.06018279f, 0.01645013f, 0.03010258f, -0.04894190f, 0.05461172f, -0.05620093f, -0.05338939f, 
    0.00775657f, -0.02576680f, -0.05133849f, 0.05924321f, 0.01980184f, 0.05246830f, 0.01685411f, -0.05386191f, 
    0.01517461f, -0.05792909f, 0.06365550f, 0.04010498f, 0.00895691f, -0.02409756f, -0.01479760f, -0.01662098f, 
    0.00127138f, -0.01156195f, -0.07585119f, 0.04384205f, 0.02610370f, 0.04791544f, -0.06347454f, 0.02299075f, 
    0.00359433f, 0.03856147f, 0.02364598f, -0.07511750f, -0.05257126f, -0.06693172f, -0.02411626f, 0.01973070f, 
    0.03716560f, 0.05132688f, 0.02977752f, -0.04750121f, 0.05871999f, -0.04319522f, 0.02920785f, -0.01268634f, 
    -0.04235426f, 0.01009653f, 0.02188097f, -0.07806807f, 0.00959011f, 0.01449148f, 0.03430934f, 0.04135332f, 
    0.05104892f, 0.05183585f, -0.04598608f, 0.01239528f, 0.04523076f, -0.04800942f, -0.07535841f, 0.01137950f, 
    0.05426221f, -0.04610385f, -0.03717117f, -0.06922027f, 0.00722010f, 0.01610950f, 0.00380208f, -0.01485332f, 
    0.05657940f, -0.07441526f, -0.01101221f, 0.01057920f, -0.01966068f, -0.01244278f, -0.00902882f, -0.03839337f, 
    0.04332263f, 0.02560837f, -0.03132514f, 0.06262916f, 0.01077227f, -0.05704918f, 0.01895835f, 0.02503148f, 
    -0.00379303f, -0.05291234f, -0.06370874f, -0.04005326f, -0.00565538f, -0.02950417f, -0.02443349f, -0.01015873f, 
    0.01048628f, -0.03030382f, -0.00829955f, -0.06983451f, 0.05441349f, -0.03298585f, -0.04489629f, 0.02253129f, 
    0.00161827f, -0.06008272f, 0.03996092f, -0.01213304f, 0.00238932f, -0.06861055f, -0.03628077f, -0.03788386f, 
    -0.03783286f, -0.01128342f, 0.04774575f, -0.02040412f, 0.02578572f, -0.01655165f, -0.05287409f, -0.00471289f, 
    0.00431376f, 0.03656251f, 0.05099692f, 0.01433231f, -0.07041726f, -0.04089523f, -0.03616776f, -0.05376367f, 
    0.06649159f, -0.04588984f, 0.00765911f, 0.04316132f, -0.05892520f, -0.00332213f, 0.02457428f, -0.05525760f, 
    -0.02388229f, 0.01629214f, 0.02692812f, 0.01863020f, -0.05813737f, 0.04642578f, 0.01673621f, 0.06069820f, 
    -0.04350662f, -0.01541431f, 0.06062547f, 0.03613884f, 0.05090360f, 0.03437022f, 0.03306677f, 0.03834095f, 
    -0.07782214f, -0.05922978f, -0.05629633f, -0.01713044f, 0.02764237f, -0.03380849f, -0.06487852f, 0.04750400f, 
    -0.03712815f, -0.08544973f, -0.06313717f, -0.06973539f, -0.01975360f, -0.00887304f, -0.00446626f, 0.03424513f, 
    -0.01105340f, -0.03693623f, 0.04486657f, 0.05876675f, -0.05384672f, -0.02811170f, 0.01928434f, -0.03798213f, 
    -0.04693496f, -0.05956709f, 0.01149351f, -0.02457800f, -0.06018671f, -0.02971499f, -0.05337347f, -0.04801781f, 
    -0.00609706f, -0.05753780f, -0.04103624f, -0.04523885f, 0.00543695f, -0.06864156f, -0.04624760f, -0.07252424f, 
    0.01903506f, 0.05012194f, -0.04005371f, -0.02744378f, -0.06915624f, 0.02638243f, 0.06849530f, -0.04930755f, 
    -0.06694560f, 0.00358240f, 0.03932351f, -0.04288086f, 0.05132896f, -0.02651663f, -0.05421807f, 0.03047083f, 
    0.00027658f, -0.03887368f, -0.06553881f, 0.00785689f, -0.06874781f, -0.02572497f, -0.02875701f, 0.05185007f, 
    -0.00129225f, 0.05851308f, 0.04830443f, -0.04922162f, -0.01105197f, -0.04737404f, 0.05923953f, -0.07077663f, 
    -0.02319965f, 0.06131737f, -0.04795624f, 0.04248769f, 0.01457291f, -0.00935875f, -0.00422409f, 0.06222836f, 
    -0.05764132f, -0.02179647f, -0.01902841f, 0.04701868f, -0.01864774f, -0.00016994f, 0.04682009f, -0.07104804f, 
    -0.00983948f, 0.02297885f, -0.04544352f, 0.02331424f, -0.07720743f, -0.01651568f, 0.03409171f, -0.04898467f, 
    0.05739826f, 0.06135650f, -0.03325288f, 0.02826805f, 0.03305498f, 0.02893021f, -0.07837325f, -0.00652961f, 
    -0.06515937f, 0.02264802f, 0.03331807f, -0.07107597f, -0.08151373f, -0.00915369f, -0.05069308f, 0.02110253f, 
    -0.04214810f, 0.00822527f, -0.02962317f, 0.03636443f, -0.02406014f, 0.00941147f, 0.03617413f, -0.02680698f, 
    -0.04131358f, -0.00184554f, -0.02977947f, 0.02768812f, -0.00775276f, -0.02062550f, -0.07030605f, 0.00489072f, 
    -0.07056312f, 0.02179882f, 0.06156383f, 0.00350986f, -0.01873566f, -0.00254679f, -0.06697542f, 0.04121573f, 
    0.04263201f, -0.06694581f, -0.01652139f, 0.01685788f, 0.00712002f, 0.05952670f, -0.02299867f, -0.02386527f, 
    -0.05777891f, 0.05436686f, -0.02602090f, 0.02121469f, -0.01381982f, -0.00960151f, 0.05458364f, -0.05630890f, 
    0.01556136f, -0.03062961f, -0.00089479f, -0.00572302f, -0.02381307f, 0.03886691f, -0.00050100f, -0.03145640f, 
    -0.01531438f, -0.02678747f, -0.01781789f, 0.06328096f, -0.06175364f, -0.01678102f, 0.04010275f, 0.05990917f, 
    -0.06954562f, -0.05092976f, -0.05482428f, -0.03490268f, -0.06488476f, -0.00395704f, 0.01149952f, -0.04793948f, 
    0.01221795f, 0.00909311f, 0.04580590f, -0.04079197f, -0.07372853f, -0.01759268f, 0.00601105f, 0.06287410f, 
    0.03143165f, 0.06301429f, -0.03843041f, -0.00886022f, -0.04224363f, 0.05123544f, 0.04137716f, 0.00422653f, 
    0.01071733f, -0.04695140f, -0.01891433f, -0.04928964f, -0.04781251f, -0.02037257f, -0.04052798f, 0.03386332f, 
    0.01615477f, 0.00500582f, 0.05485670f, -0.07487605f, -0.07552689f, -0.01861105f, 0.00602471f, 0.00460143f, 
    0.04563275f, -0.04115408f, -0.03827632f, -0.01274114f, 0.04450415f, -0.03976904f, -0.01287912f, -0.07083527f, 
    -0.06680690f, -0.00399907f, -0.01098671f, 0.04060999f, 0.05857678f, 0.01605827f, -0.01392848f, -0.06366614f, 
    0.05229331f, 0.06015225f, -0.02943714f, 0.01636444f, 0.05661003f, -0.00197913f, -0.03192106f, 0.00998991f, 
    -0.06380542f, 0.01747478f, -0.07430805f, -0.05196744f, -0.03544497f, 0.00408447f, -0.05688388f, 0.04201360f, 
    0.03478018f, -0.04695488f, 0.06245122f, -0.00279489f, -0.03744675f, -0.06626502f, 0.03759446f, 0.05179334f, 
    -0.03650978f, -0.02342786f, 0.05854466f, -0.02897692f, 0.03179963f, 0.02782217f, 0.00737696f, 0.02337159f, 
    0.04916562f, -0.03702671f, -0.03132570f, -0.06211057f, 0.01382344f, -0.03867701f, 0.03322845f, 0.00740857f, 
    0.01198177f, -0.03408637f, -0.00955787f, -0.06378634f, -0.05359920f, -0.05055720f, 0.06472251f, 0.04549821f, 
    0.00364806f, 0.01941305f, -0.01240638f, -0.01379557f, -0.04397666f, -0.07359875f, -0.03737542f, 0.02088926f, 
    -0.02272868f, 0.06250382f, -0.05484885f, -0.00590908f, 0.03661077f, -0.07151607f, -0.05969663f, -0.03203608f, 
    -0.05087850f, -0.00246273f, 0.02255826f, -0.06364065f, -0.06468169f, -0.04502508f, -0.05467520f, 0.06203821f, 
    -0.07075491f, 0.02625507f, 0.00171383f, 0.05914135f, -0.01104059f, 0.03815717f, -0.07634045f, -0.06992386f, 
    -0.00876355f, 0.06430998f, -0.04226010f, 0.03062427f, 0.00106918f, -0.06971265f, -0.07670705f, 0.04971766f, 
    -0.02559757f, 0.01805963f, 0.05911944f, -0.05338476f, -0.02601841f, 0.06258909f, 0.00606333f, -0.01399733f, 
    -0.03634326f, 0.01139773f, -0.06136212f, -0.06524397f, 0.01194199f, 0.01856132f, 0.01517015f, -0.00814209f, 
    0.07122503f, -0.07241342f, -0.03943286f, -0.02511039f, -0.07178941f, -0.07542314f, -0.01649125f, 0.01235328f, 
    0.03889825f, -0.02883363f, -0.06930771f, -0.03298298f, -0.07532313f, 0.05080378f, -0.04890493f, -0.00211639f, 
    0.03874525f, -0.07463717f, 0.02222803f, 0.05595233f, -0.06240480f, 0.04541434f, -0.03055897f, -0.07483871f, 
    0.01588786f, -0.01124699f, 0.00568106f, -0.04255281f, -0.05171812f, -0.03134286f, 0.03729273f, -0.01435082f, 
    -0.00804101f, 0.01514086f, 0.06023068f, -0.03913581f, -0.07889031f, 0.06283601f, -0.02684992f, -0.01288745f, 
    -0.00224163f, 0.03893081f, 0.05577739f, 0.00377262f, -0.04942984f, 0.05921311f, -0.07824881f, -0.04273714f, 
    0.00269310f, 0.03686551f, -0.01587391f, -0.00578286f, -0.03957476f, -0.00431099f, 0.00262669f, -0.07937080f, 
    -0.07939576f, 0.01016968f, -0.06910758f, -0.05696779f, 0.02440768f, 0.01261684f, -0.05190682f, 0.06615249f, 
    -0.03256974f, 0.01158647f, 0.02141315f, -0.05865511f, 0.03055573f, -0.02620222f, 0.04867904f, -0.08213227f, 
    0.00520839f, -0.06084953f, -0.01467546f, -0.01370666f, -0.00815411f, 0.01663970f, -0.03385566f, 0.05392366f, 
    0.04405824f, -0.00979527f, 0.05253050f, -0.08295821f, -0.05960138f, -0.07358862f, 0.01356687f, 0.04283514f, 
    -0.06140034f, -0.01957284f, 0.00356135f, 0.01255764f, 0.05294570f, -0.04248720f, 0.04841343f, 0.00606588f, 
    0.05122186f, 0.03947888f, -0.00526580f, -0.07749416f, -0.03297574f, -0.05467944f, 0.01441323f, -0.02750489f, 
    0.02018328f, 0.05507349f, 0.04963921f, 0.00743047f, -0.06971006f, -0.05373015f, 0.00107232f, -0.06937842f, 
    -0.07519958f, -0.03067137f, -0.00561997f, 0.05958522f, -0.06250609f, -0.03149983f, -0.05581770f, -0.04546935f, 
    0.02015428f, 0.05188749f, 0.01975436f, 0.01312800f, 0.00595341f, 0.02140212f, -0.07433840f, -0.02353716f, 
    0.00199186f, -0.07838497f, -0.01761694f, 0.01513525f, -0.03788580f, 0.03088386f, 0.04790059f, 0.00504577f, 
    0.00228553f, -0.08041310f, 0.04284714f, -0.00917868f, -0.06411678f, -0.01383676f, 0.04156535f, 0.02526310f, 
    0.02896545f, -0.06702626f, 0.03419552f, -0.00518192f, -0.06636350f, -0.06371934f, 0.04261747f, 0.02235443f, 
    0.02668365f, 0.03786314f, 0.05373001f, -0.05025506f, -0.03947143f, 0.00250111f, 0.01325410f, -0.05337521f, 
    0.01888142f, -0.00880750f, -0.07164707f, -0.07710055f, -0.07173317f, -0.01852878f, -0.03641883f, -0.04314794f, 
    -0.07157545f, 0.02150927f, -0.07356688f, 0.03158119f, 0.05117774f, 0.04465703f, 0.01210261f, -0.07658114f, 
    -0.06437097f, -0.02861284f, -0.07082442f, -0.03670102f, -0.06194638f, 0.05292144f, -0.06150417f, 0.05005388f, 
    -0.00391800f, 0.05540076f, 0.04543165f, -0.01028442f, 0.00484869f, 0.02930646f, 0.01384111f, -0.02659103f, 
    -0.00976143f, 0.05714411f, -0.03757637f, 0.00919781f, 0.03110934f, 0.01350627f, -0.07657679f, -0.01405899f, 
    -0.03388549f, -0.00630121f, -0.05543095f, -0.01219137f, -0.05667393f, 0.04284422f, 0.00371513f, -0.06459184f, 
    -0.03147018f, 0.04966871f, 0.06306498f, 0.05298293f, -0.03960628f, -0.00388200f, -0.01485288f, -0.00676109f, 
    -0.06809605f, 0.05447827f, -0.06961813f, -0.03139493f, -0.01903748f, 0.06759077f, -0.07225870f, 0.01523093f, 
    0.01019148f, 0.01391534f, 0.06604294f, -0.05836330f, -0.07219096f, 0.00122416f, -0.06909152f, -0.00972082f, 
    -0.01370881f, 0.00261252f, -0.04395043f, -0.04816234f, -0.07574033f, 0.04884459f, 0.04451178f, 0.05017950f, 
    -0.02263270f, -0.05066292f, -0.04314781f, 0.04019656f, -0.02306310f, 0.05400491f, -0.06700619f, -0.01725050f, 
    0.03761953f, 0.00837730f, 0.00749228f, -0.07261461f, 0.06937328f, 0.02630774f, -0.02509546f, 0.00006085f, 
    -0.07581463f, 0.00198284f, 0.02984183f, -0.02187871f, -0.02737913f, -0.07095464f, -0.07534153f, -0.06226375f, 
    0.00198777f, -0.06009438f, 0.03557604f, -0.06725788f, -0.00810836f, -0.06579485f, -0.05860602f, 0.03082658f, 
    -0.02555440f, -0.01454771f, -0.07642681f, -0.00276451f, -0.05477815f, -0.01794317f, 0.02874392f, -0.00753116f, 
    0.03847256f, -0.04495170f, 0.06094023f, 0.01269411f, -0.02233204f, 0.04204407f, -0.00458406f, 0.01418756f, 
    -0.00109542f, 0.01844690f, 0.06618571f, -0.03538156f, 0.03797099f, -0.00013330f, 0.04851300f, -0.01585285f, 
    0.01848350f, 0.01607456f, 0.06714540f, -0.03639180f, 0.02374864f, 0.02256607f, -0.05789321f, 0.01482659f, 
    0.01298258f, 0.04295206f, -0.01302805f, -0.02141122f, -0.03293914f, 0.00333340f, -0.01735552f, 0.05127057f, 
    0.01929829f, 0.02237557f, 0.03159045f, -0.05926689f, -0.06371217f, 0.04115605f, -0.06987372f, -0.05643779f, 
    -0.06809583f, 0.01739785f, 0.01158858f, 0.01356346f, -0.00036129f, 0.03528610f, -0.05347917f, 0.03822498f, 
    -0.03816998f, -0.07595997f, -0.06029226f, -0.04186459f, 0.00281006f, 0.06433354f, 0.05205509f, -0.07670745f, 
    -0.06230994f, -0.04012125f, 0.06710255f, 0.01374763f, 0.03879289f, 0.05603704f, 0.01891483f, -0.03146482f, 
    -0.02140102f, -0.03646506f, -0.02392126f, 0.04262417f, 0.04913944f, 0.05239946f, -0.06169984f, -0.06348210f, 
    0.01971970f, 0.06108911f, 0.02579840f, -0.05082677f, -0.02197017f, 0.06585802f, 0.01425184f, 0.01768450f, 
    0.01478741f, 0.00750064f, 0.01735978f, -0.01006710f, 0.04833021f, 0.03241020f, -0.06684669f, -0.02968117f, 
    -0.06239808f, -0.01852608f, -0.05214920f, -0.03469129f, -0.06345626f, -0.04487692f, -0.06613615f, -0.01507201f, 
    0.04030786f, 0.04226718f, 0.06152783f, 0.02214182f, -0.02619112f, -0.02095773f, -0.03353716f, -0.06472363f, 
    0.01713698f, -0.07144505f, -0.05562172f, 0.06511416f, -0.04402102f, -0.02150981f, -0.03799197f, 0.02507703f, 
    0.04538146f, 0.01586267f, -0.06199415f, 0.05670967f, -0.05772289f, 0.05803768f, -0.05399160f, 0.01370884f, 
    -0.12118854f, 0.02359465f, -0.00296651f, 0.04775720f, -0.08230256f, -0.03874248f, 0.10403454f, -0.20058805f, 
    0.10697156f, -0.01760318f, -0.00069921f, 0.11722939f, -0.02722272f, 0.01562630f, -0.24260019f, -0.18954833f, 
    -0.14001822f, 0.02786793f, -0.08314162f, 0.34600323f, -0.20111851f, -0.05070321f, -0.11788702f, 0.12013035f, 
    -0.22734024f, -0.03366666f, -0.19439362f, 0.06380989f, 0.00708892f, -0.22404228f, 0.12538011f, -0.00386707f, 
    0.07653389f, 0.31429580f, -0.10385516f, 0.30212834f, -0.31263885f, 0.04869457f, 0.02606526f, 0.04596345f, 
    -0.10393871f, -0.06796240f, 0.05028561f, -0.07859395f, 0.06843264f, 0.03711838f, 0.21454631f, 0.19695237f, 
    0.32015222f, -0.10262808f, 0.49182186f, -0.06850278f, 0.19218841f, -0.00483197f, -0.18122949f, 0.24613360f, 
    0.01174819f, -0.15909162f, 0.01384745f, -0.08955907f, 0.31869549f, -0.12649767f, 0.11096844f, -0.23081973f, 
    0.13942598f, 0.31805995f, -0.07011879f, 0.18115771f, 0.04972252f, -0.06940593f, 0.06229056f, 0.02731401f, 
    0.37471631f, 0.00244663f, -0.21804899f, 0.27815709f, -0.10492402f, 0.10681818f, 0.21750896f, -0.00397320f, 
    -0.10042584f, -0.03977976f, 0.07085582f, -0.04646174f, 0.03804649f, 0.01925007f, 0.17799352f, -0.08666655f, 
    0.00015980f, -0.09508490f, -0.16910090f, -0.00567546f, 0.11029180f, -0.13700847f, -0.27523005f, -0.05455985f, 
    -0.04735627f, -0.11251073f, -0.20286709f, -0.03406329f, 0.03802978f, 0.00309838f, 0.01053076f, 0.14959888f, 
    0.03023766f, -0.10895488f, 0.14062110f, -0.12480969f, -0.30626532f, 0.16563983f, 0.16159317f, 0.31116447f, 
    0.02356748f, 0.00428720f, 0.08524979f, 0.12333769f, 0.07221768f, 0.00296527f, 0.16416030f, 0.02555901f, 
    0.05677247f, -0.09679215f, 0.01662286f, -0.07097708f, 0.07112094f, 0.05008920f, -0.02283983f, -0.17235143f, 
    -0.02403629f, 0.04148822f, 0.09249035f, -0.03911313f, -0.14029910f, -0.19674578f, 0.06479434f, -0.15269962f, 
    -0.01559632f, 0.06795751f, 0.02154731f, 0.03820571f, 0.17552435f, -0.03241494f, 0.21552473f, 0.14753005f, 
    -0.36846939f, 0.12384696f, -0.00786659f, -0.20117556f, -0.00279986f, -0.16555960f, 0.01489909f, 0.20577627f, 
    0.11148252f, 0.14743289f, 0.09105960f, 0.00680001f, 0.26906684f, -0.19496639f, -0.21876925f, -0.18250252f, 
    0.06177626f, 0.20113766f, 0.14352858f, 0.27497879f, -0.19418347f, -0.16079395f, -0.05197948f, -0.23339780f, 
    -0.41689506f, 0.52336168f, 0.13788785f, -0.17747603f, 0.01012348f, 0.13684444f, 0.20910764f, 0.25157049f, 
    0.24346001f, 0.09610298f, 0.19813171f, -0.10654559f, 0.18356107f, 0.12444658f, -0.02083729f, 0.06199729f, 
    -0.00042234f, 0.10310314f, -0.04489627f, 0.00175885f, 0.02860435f, 0.10439639f, -0.04673860f, 0.17095619f, 
    0.08903629f, 0.11568433f, -0.04367153f, -0.03793371f, 0.13307106f, 0.21102993f, 0.06435475f, -0.03595340f, 
    -0.00378624f, 0.05289246f, 0.02378612f, 0.14285687f, 0.28646919f, -0.17484875f, -0.14367233f, 0.13372131f, 
    0.10950079f, 0.18732730f, -0.04122713f, 0.06193396f, 0.03772310f, 0.07842415f, -0.11344489f, 0.00034864f, 
    -0.07121298f, 0.04117006f, 0.18446325f, -0.06129952f, 0.05082966f, -0.07275592f, -0.12000266f, 0.01985447f, 
    0.07969562f, -0.04993611f, 0.09324428f, -0.02906759f, 0.03208647f, -0.34076083f, -0.04519675f, 0.05854630f, 
    -0.05578607f, -0.06622035f, -0.03738507f, -0.08359542f, -0.01641522f, -0.20516020f, 0.11157442f, 0.06191472f, 
    -0.07145604f, 0.08490153f, 0.33097726f, 0.05487330f, 0.11222535f, 0.25323164f, 0.08391955f, 0.11081370f, 
    0.08486314f, -0.12123006f, 0.08619197f, 0.12659700f, -0.01103106f, -0.26506132f, -0.54393750f, 0.12248186f, 
    0.06135240f, 0.02460038f, 0.02045922f, 0.22507024f, -0.08876047f, 0.00402764f, -0.03333649f, 0.01400089f, 
    -0.67212337f, 0.07336724f, -0.04497502f, -0.20977262f, -0.22031823f, -0.10816497f, 0.01138726f, 0.01516370f, 
    0.01028010f, -0.06287890f, 0.02780299f, -0.04604238f, 0.16074646f, 0.14147395f, 0.14093931f, 0.12372980f, 
    0.01911283f, 0.16563545f, 0.16372123f, 0.35827088f, -0.08442675f, 0.05159183f, 0.08186886f, -0.02200977f, 
    -0.24888393f, -0.21772279f, -0.15185417f, 0.08342879f, 0.04724025f, -0.12478667f, 0.12446836f, 0.14497121f, 
    -0.21785861f, -0.02544506f, -0.16150075f, -0.02980166f, 0.28386924f, 0.06674250f, -0.06371541f, -0.02008396f, 
    -0.02686142f, -0.08499957f, -0.11980830f, -0.20468828f, -0.05127549f, 0.08079288f, 0.02930558f, 0.09103775f, 
    0.25584882f, 0.38389894f, 0.04929886f, 0.04106474f, 0.03694386f, 0.03425081f, 0.03237315f, 0.06109848f, 
    -0.00116042f, 0.06344812f, -0.11818463f, 0.14929965f, -0.11237350f, 0.35180551f, 0.08663468f, 0.04875120f, 
    0.09892369f, 0.05540070f, -0.00341080f, -0.03249648f, 0.02205288f, -0.09882974f, -0.05868093f, -0.06974209f, 
    0.29147223f, -0.12547201f, 0.04991118f, 0.09674257f, -0.03825403f, 0.08640378f, 0.01510825f, -0.10828765f, 
    0.00815126f, 0.02015872f, 0.00871166f, 0.01901098f, -0.49995044f, -0.19141002f, -0.16786179f, 0.20960134f, 
    0.01226506f, 0.02276728f, -0.07726146f, 0.00334308f, -0.00796090f, -0.12721732f, 0.00871556f, -0.12175918f, 
    -0.08274861f, -0.04749056f, -0.14646919f, 0.13610795f, -0.12531069f, 0.04468769f, 0.00281411f, -0.00841763f, 
    0.01836173f, 0.11240555f, 0.02486919f, 0.06961558f, 0.03550396f, 0.21067460f, -0.14454526f, 0.00495334f, 
    0.20612997f, 0.03007493f, 0.15636741f, 0.25908750f, 0.02524384f, 0.06136465f, -0.01187555f, 0.10857588f, 
    0.03021942f, -0.08146720f, 0.02154478f, -0.05522123f, -0.04905573f, 0.00507904f, 0.06489047f, -0.03573016f, 
    0.02782691f, -0.01986295f, -0.04015514f, 0.02667189f, -0.02670197f, -0.04352752f, -0.06779776f, 0.00571461f, 
    0.00018468f, 0.02147192f, 0.02996227f, 0.02199191f, -0.02805557f, -0.04233797f, 0.02758227f, 0.06272977f, 
    -0.04012135f, 0.03899061f, 0.02622876f, -0.04941579f, 0.06859796f, -0.00141319f, 0.06467033f, -0.06342977f, 
    -0.06016698f, 0.03116647f, -0.07435369f, 0.06725831f, -0.02904958f, -0.02716623f, -0.01292703f, 0.01208737f, 
    -0.03574873f, 0.04380623f, 0.04886762f, -0.05380525f, -0.07555633f, 0.01088818f, -0.02460467f, 0.01158113f, 
    0.01096339f, -0.03886052f, -0.00872178f, -0.01245371f, 0.02086757f, -0.04294690f, 0.04617253f, 0.07139915f, 
    -0.04833062f, 0.05999223f, 0.02802183f, -0.01988992f, -0.05803896f, -0.02959897f, 0.03882907f, -0.05800315f, 
    -0.01417011f, -0.03948557f, -0.05022822f, -0.03888413f, 0.01419910f, -0.03520700f, -0.06043001f, 0.05492905f, 
    -0.04490028f, -0.02989889f, 0.04062030f, 0.00885995f, -0.02818891f, 0.04343007f, -0.05990015f, -0.07620309f, 
    -0.06416648f, -0.05996998f, 0.06082796f, 0.03243496f, -0.05359973f, -0.08274087f, 0.05507709f, -0.05598483f, 
    0.05095725f, -0.03490496f, 0.06656302f, -0.04324781f, -0.00335781f, 0.05080058f, -0.01111884f, -0.02567802f, 
    -0.03636197f, -0.02238298f, -0.04529079f, -0.05645386f, 0.04586633f, 0.03674391f, 0.05686969f, -0.03666316f, 
    0.01180830f, 0.00948733f, 0.04146018f, -0.05898872f, -0.01449153f, 0.00752215f, -0.06448247f, -0.07700426f, 
    -0.00915565f, 0.04293420f, -0.01087064f, -0.04694122f, 0.01763801f, -0.03626433f, -0.04132428f, -0.05123983f, 
    0.04684175f, 0.02153992f, -0.02338880f, -0.07476076f, 0.03825615f, -0.04576521f, 0.06655463f, -0.05728070f, 
    0.04382854f, 0.03969266f, 0.02723402f, -0.05015378f, 0.03606876f, -0.02955724f, -0.02115831f, -0.04457743f, 
    0.05182332f, -0.08153254f, 0.04138665f, -0.01180280f, -0.04178376f, -0.04218731f, -0.02139060f, 0.04474225f, 
    0.02035615f, -0.08587412f, 0.01759535f, 0.02183478f, -0.05435814f, 0.00093454f, -0.05916043f, 0.02510270f, 
    0.02689662f, -0.05384853f, 0.01726787f, -0.02460640f, -0.00230326f, -0.06195838f, -0.00761821f, -0.00133012f, 
    0.00665338f, -0.03141254f, 0.04717118f, -0.03091736f, 0.05008570f, -0.00500579f, -0.02791608f, -0.04999455f, 
    -0.03509677f, 0.07607202f, 0.03245118f, 0.04949874f, -0.05623898f, -0.06241952f, -0.04008232f, 0.02230020f, 
    -0.01737588f, 0.04819565f, -0.07081421f, 0.02133619f, -0.02864218f, -0.01024839f, -0.01299481f, 0.00398133f, 
    -0.02060816f, -0.00274757f, -0.05943624f, 0.06820767f, 0.03893073f, -0.02514521f, 0.04493957f, -0.07059944f, 
    -0.00961326f, -0.07709721f, 0.01778951f, 0.01570359f, 0.10493680f, 0.02110981f, 0.00023670f, 0.03486668f, 
    0.10350285f, 0.15972307f, 0.16328286f, 0.07498964f, 0.03001891f, 0.04287221f, -0.08603879f, -0.14086202f, 
    -0.00428926f, -0.15825020f, 0.04842336f, 0.10439634f, -0.04328732f, -0.13384129f, -0.17971349f, -0.09293516f, 
    0.08015801f, 0.05676086f, -0.06717418f, 0.13172147f, -0.07277970f, 0.05200059f, -0.17767306f, 0.11136865f, 
    0.13790882f, 0.04543050f, 0.00500286f, 0.08102169f, 0.38040635f, 0.13159539f, -0.00847872f, -0.03412733f, 
    -0.02214145f, 0.00864239f, 0.01886093f, 0.04588375f, 0.20017976f, -0.25362021f, 0.02513621f, 0.03194308f, 
    0.34619156f, 0.17761970f, -0.29299983f, 0.10952970f, 0.00755924f, 0.01723420f, 0.00702372f, -0.16491564f, 
    0.00798194f, -0.00668442f, 0.07259034f, 0.10205605f, -0.33859468f, 0.48243824f, -0.05515610f, 0.06275007f, 
    -0.02434271f, -0.09759992f, 0.25224200f, -0.06793080f, 0.02035255f, -0.02396926f, 0.05883107f, 0.01721166f, 
    -0.06741579f, 0.03847704f, -0.01016964f, -0.00466545f, 0.15503649f, -0.13887209f, -0.05577457f, 0.00737006f, 
    0.08983758f, -0.02430211f, 0.01341977f, 0.08936026f, -0.09492557f, -0.17420536f, -0.05791651f, -0.05936228f, 
    0.05898741f, 0.00248688f, 0.14006892f, -0.04179775f, 0.10810858f, 0.10809807f, 0.04196195f, 0.01020560f, 
    -0.02078596f, 0.19691892f, -0.16133767f, 0.02951402f, -0.08382188f, 0.13062829f, 0.09117761f, -0.01886461f, 
    0.11637794f, 0.04642630f, -0.16068991f, -0.13782021f, 0.40619594f, -0.33002934f, 0.13440095f, -0.37927163f, 
    -0.02169934f, 0.00519669f, 0.00236103f, 0.05852628f, 0.14046338f, -0.04839902f, -0.07873052f, -0.01005525f, 
    0.23084782f, 0.09318057f, 0.35837045f, -0.00312627f, 0.02768062f, 0.07297839f, 0.09973024f, -0.03344814f, 
    0.09178219f, 0.05437608f, 0.14277990f, -0.07780550f, 0.08707938f, -0.29306939f, -0.09700754f, 0.05751065f, 
    -0.06791122f, -0.00887354f, -0.02279677f, -0.05079161f, 0.03923497f, 0.02786122f, -0.17938364f, -0.24791685f, 
    -0.26851675f, -0.26160058f, -0.24016538f, 0.20673782f, -0.00108069f, 0.18030009f, 0.18798923f, -0.06706116f, 
    0.11954082f, -0.04428554f, 0.08969273f, -0.05381312f, 0.00023021f, 0.21608786f, -0.21648780f, 0.32645035f, 
    -0.05528126f, -0.06497381f, -0.13040699f, -0.22837706f, 0.03631189f, 0.03925173f, 0.02699139f, 0.09402286f, 
    -0.06570659f, 0.18987401f, -0.18092234f, -0.00817684f, -0.06086534f, 0.05647907f, 0.18099019f, 0.05939743f, 
    -0.14340858f, 0.01156676f, -0.28628868f, 0.27742240f, 0.24758740f, 0.03216765f, 0.40357500f, -0.05907623f, 
    0.08450382f, -0.07845400f, 0.02817312f, 0.14380512f, -0.00388573f, -0.02605983f, -0.02631313f, 0.26240334f, 
    -0.05349414f, 0.04320407f, 0.04446196f, -0.02082734f, 0.03230342f, -0.00062055f, -0.03678519f, -0.05878252f, 
    0.06336033f, -0.00048159f, 0.02469631f, -0.07341963f, -0.04371841f, -0.03209217f, 0.03716482f, -0.00859972f, 
    0.01610642f, 0.05351019f, 0.03808925f, -0.04760750f, -0.06146418f, 0.06335969f, -0.05000598f, -0.02183687f, 
    0.01905311f, -0.05119453f, -0.06312371f, 0.04205073f, -0.04924237f, -0.07941908f, -0.01896041f, 0.00794791f, 
    0.06281974f, 0.04363739f, 0.05581597f, -0.05787462f, -0.05386191f, -0.02628248f, -0.06476669f, 0.00586090f, 
    -0.05505773f, 0.03664758f, 0.03216098f, 0.03302603f, 0.05003719f, -0.04096070f, 0.05374194f, -0.01795193f, 
    -0.05323773f, 0.02442228f, -0.04477649f, 0.01849366f, -0.07697892f, -0.02256050f, 0.04659403f, 0.00102844f, 
    0.02095701f, 0.02685411f, -0.00351033f, -0.01250350f, 0.00610817f, -0.02655135f, 0.04286563f, 0.04983185f, 
    -0.05530176f, -0.06078960f, 0.02111314f, -0.06738342f, 0.02884349f, -0.01075546f, 0.05175001f, 0.02056538f, 
    -0.01266702f, 0.05573627f, -0.03603113f, 0.02872519f, 0.01305286f, 0.00688844f, 0.05063001f, -0.02807759f, 
    -0.03261164f, 0.03874836f, -0.04452877f, -0.02767400f, -0.02551880f, 0.01730395f, -0.04374649f, -0.05013850f, 
    -0.02848133f, -0.07405786f, 0.05829085f, -0.02042525f, -0.03670525f, 0.00129822f, -0.01808328f, -0.01977023f, 
    -0.06932246f, 0.02866273f, -0.02404071f, -0.02496770f, -0.04019684f, -0.06206474f, 0.00485900f, -0.04433491f, 
    0.02515347f, -0.06800548f, 0.05540780f, 0.03464941f, 0.01987450f, 0.02715974f, 0.04629705f, -0.01106446f, 
    0.01810402f, -0.06973972f, 0.06386385f, -0.06673966f, 0.01373599f, -0.06409747f, 0.02833257f, 0.00230195f, 
    0.02657525f, 0.00733639f, 0.05257599f, -0.07970923f, 0.01377769f, -0.00852544f, -0.06121833f, -0.07358302f, 
    -0.04724484f, -0.00890719f, -0.04964975f, -0.01707550f, -0.06358713f, -0.05219304f, 0.00981801f, 0.03330666f, 
    -0.04588662f, -0.01226791f, -0.04061881f, -0.04208122f, -0.03719399f, 0.00813782f, 0.03263354f, 0.01823798f, 
    -0.05722881f, -0.06523341f, -0.04844078f, 0.01458148f, -0.00185350f, -0.02398013f, 0.03315430f, -0.04914087f, 
    -0.07781715f, 0.01767279f, -0.05112105f, 0.03741055f, -0.04506428f, 0.02851180f, -0.04263293f, -0.03096435f, 
    0.01637777f, -0.05126407f, -0.07748441f, -0.02901418f, -0.05643720f, -0.05129696f, 0.06132225f, -0.00885918f, 
    -0.02669860f, 0.02311407f, -0.03025522f, -0.02442625f, -0.05057536f, -0.04546892f, 0.05027923f, -0.01596028f, 
    0.02856335f, -0.06151010f, -0.02366927f, -0.00618314f, -0.06908049f, -0.04831064f, -0.00771755f, -0.05502360f, 
    -0.05934670f, 0.00915460f, 0.06361658f, -0.02810028f, -0.02854711f, -0.03534181f, 0.02923342f, -0.06672116f, 
    0.03810332f, 0.09395678f, 0.00100845f, 0.04380832f, -0.00752100f, -0.12219411f, -0.08991876f, -0.00556966f, 
    -0.03407506f, -0.09688527f, -0.07590704f, -0.10137927f, 0.30026034f, 0.08889076f, -0.46413425f, 0.09238753f, 
    -0.06377734f, -0.14692545f, -0.18813780f, -0.10688630f, 0.01037323f, -0.00478293f, 0.04485036f, 0.02988285f, 
    -0.13933061f, 0.04394239f, 0.03396423f, 0.08825986f, -0.03754565f, -0.01492644f, 0.00852421f, -0.00803837f, 
    -0.01640812f, 0.01642549f, -0.10768143f, 0.04819866f, -0.00089795f, 0.05705201f, 0.15225761f, 0.07424153f, 
    0.08593715f, 0.03481998f, -0.09541727f, -0.00453441f, -0.01376510f, 0.09820756f, -0.03198877f, 0.07579438f, 
    -0.22214346f, -0.03662598f, 0.08467419f, -0.16872831f, 0.19296157f, 0.03670702f, -0.13290240f, -0.00744140f, 
    -0.02649328f, -0.06416307f, -0.13698912f, -0.03118367f, 0.55453134f, -0.08624906f, 0.27268267f, -0.13100931f, 
    0.01180942f, 0.05524645f, 0.13791512f, 0.02735586f, -0.05639949f, -0.01836295f, -0.09986523f, -0.03264372f, 
    0.39652821f, 0.05584662f, -0.09395400f, 0.27381414f, -0.01926664f, 0.04073020f, 0.13238637f, -0.12868640f, 
    -0.03784065f, -0.05694726f, -0.11856139f, -0.11208235f, 0.20302223f, 0.03952022f, 0.01819449f, -0.20028329f, 
    0.07915230f, -0.27222320f, -0.11189763f, -0.02614313f, -0.02029330f, -0.04810211f, -0.01315174f, -0.14266348f, 
    0.07394970f, -0.09302257f, 0.06640311f, -0.10210486f, -0.06826203f, 0.11152280f, 0.17596047f, 0.07685676f, 
    0.15743609f, 0.17720281f, 0.17719045f, 0.10619418f, 0.08322793f, 0.17827643f, 0.04007208f, 0.15528965f, 
    0.07341094f, -0.03371761f, -0.02073323f, -0.06495863f, -0.05935734f, 0.13239175f, 0.16062102f, 0.00452420f, 
    -0.24216400f, -0.27924192f, -0.14515543f, 0.01710064f, -0.06116100f, -0.08238219f, 0.03662362f, -0.09175527f, 
    0.07553048f, 0.13305071f, 0.02502746f, 0.13151915f, -0.01679238f, 0.10610957f, 0.13120072f, 0.05641557f, 
    0.06068618f, 0.11600742f, -0.05918826f, -0.01764505f, 0.00010271f, -0.05434733f, 0.21370047f, 0.06764312f, 
    -0.39752093f, -0.09937687f, -0.06957102f, -0.27187985f, -0.05406917f, -0.24760231f, -0.10122914f, 0.01552618f, 
    0.03509392f, 0.13681071f, 0.09368338f, -0.01294792f, 0.46315578f, 0.10861660f, 0.21387531f, 0.04720278f, 
    -0.06410261f, 0.08117073f, 0.13550991f, -0.04972834f, 0.04312672f, 0.03846996f, -0.08363938f, 0.00040337f, 
    -0.33028522f, 0.07042531f, 0.13470195f, -0.14365876f, 0.07927708f, 0.06322112f, -0.00484233f, -0.04248494f, 
    0.18564191f, 0.06899931f, 0.10963693f, 0.00024332f, -0.08580371f, -0.19159423f, -0.24515380f, 0.01737493f, 
    0.08628975f, 0.04502107f, -0.04514059f, -0.06693862f, 0.15010294f, 0.08778896f, 0.16515569f, -0.01754391f, 
    0.09863771f, 0.04350631f, 0.10613977f, -0.00710615f, -0.02154426f, -0.03675799f, 0.09540087f, 0.02177780f, 
    0.04853965f, 0.06283167f, -0.00548433f, 0.02329319f, 0.74829900f, 0.31949407f, -0.11968040f, 0.27451146f, 
    0.25629875f, 0.14617760f, 0.21293429f, 0.14266746f, -0.10397168f, -0.06773512f, -0.10441077f, -0.05672041f, 
    -0.31643200f, -0.11043672f, -0.15605499f, -0.17994814f, -0.00452417f, -0.05213803f, 0.06669067f, -0.04917303f, 
    -0.00707855f, 0.05111873f, 0.21576880f, 0.11560194f, -0.08511539f, -0.14733540f, -0.08362004f, -0.08302467f, 
    0.00255299f, -0.07166322f, -0.08853549f, -0.09819924f, 0.10841505f, 0.01393053f, 0.07535039f, -0.14427373f, 
    0.06243077f, 0.26397279f, 0.37984529f, -0.12778749f, -0.05194378f, -0.05381232f, 0.03530497f, 0.11885338f, 
    0.12339186f, -0.00193276f, -0.00592902f, 0.12548193f, 0.44627714f, 0.20143548f, -0.00650868f, -0.07975250f, 
    0.05005997f, -0.07283179f, 0.17264213f, 0.20509548f, -0.02672023f, -0.00406062f, 0.03919763f, -0.00228672f, 
    -0.29850009f, -0.10364537f, -0.38704678f, -0.20651028f, -0.08040011f, -0.10740510f, -0.10012841f, -0.02566856f, 
    -0.05948047f, 0.00384026f, 0.10306243f, 0.00924452f, 0.39897534f, 0.39625901f, 0.28105316f, 0.05351259f, 
    0.01549349f, 0.06863504f, 0.17029750f, 0.33615369f, -0.00958019f, 0.02820475f, 0.10632789f, 0.06775445f, 
    -0.21954942f, -0.08485712f, -0.16488323f, -0.06050853f, 0.01168904f, 0.01466051f, -0.13597770f, 0.11866587f, 
    -0.12210295f, 0.06989025f, -0.04419071f, 0.05351612f, 0.04653838f, 0.09464310f, -0.29236773f, -0.01440916f, 
    -0.10244399f, -0.01211355f, -0.00117780f, 0.01458426f, 0.08925071f, 0.12444649f, -0.05063676f, -0.15760355f, 
    0.19219512f, 0.45972994f, 0.07863321f, 0.14422338f, -0.18505408f, -0.09622619f, -0.04733675f, -0.06086158f, 
    0.05152058f, 0.15700708f, -0.04311382f, 0.03021220f, -0.41928867f, -0.11267710f, 0.10045420f, -0.04185941f, 
    0.10224276f, -0.07700204f, -0.05245933f, -0.05777321f, -0.11226553f, -0.05742274f, 0.05509841f, -0.11318281f, 
    0.07233421f, -0.21946503f, -0.05658893f, -0.02821132f, 0.05646335f, 0.01268738f, -0.07601116f, -0.07963548f, 
    0.04483239f, -0.01754789f, -0.02441319f, -0.26237717f, -0.15292448f, -0.37653917f, -0.24262552f, -0.10133830f, 
    -0.00926520f, -0.11153931f, -0.06125696f, -0.17438789f, 0.05812860f, 0.07026820f, 0.09437288f, 0.03380750f, 
    -0.12205520f, 0.11516926f, -0.16386287f, -0.05204700f, 0.01171187f, 0.07802532f, -0.00473969f, -0.01864332f, 
    -0.11015837f, -0.03422699f, 0.02779454f, 0.06745636f, 0.40622202f, 0.39548364f, 0.17190070f, 0.25184718f, 
    0.06739572f, 0.07607411f, 0.11287372f, 0.16915779f, 0.19124801f, -0.05175358f, -0.09557758f, 0.09548599f, 
    -0.11119376f, 0.08917037f, -0.03855992f, 0.01744496f, -0.09462243f, 0.04386852f, -0.21062832f, -0.03929127f, 
    -0.09925250f, 0.01421196f, -0.06936827f, -0.13802820f, -0.00617669f, -0.62050384f, -0.82304114f, -0.23234540f, 
    -0.06131140f, -0.15518580f, -0.28080824f, -0.13951476f, -0.17081383f, 0.04894131f, 0.02208938f, 0.00343935f, 
    0.02736852f, 0.18965699f, 0.33097541f, 0.15890576f, -0.01470485f, -0.06479570f, -0.04847960f, -0.02013993f, 
    0.14209685f, 0.18299218f, -0.02460392f, 0.10095695f, 0.05873691f, 0.03588393f, 0.11525594f, 0.21722715f, 
    -0.05740627f, -0.05981708f, 0.00381139f, -0.04707063f, 0.04738016f, 0.06992955f, -0.04011849f, -0.00647097f, 
    -0.27057427f, 0.06604525f, 0.20204739f, -0.13445278f, 0.11035705f, 0.18783860f, -0.11360000f, -0.01941860f, 
    -0.20907570f, 0.00884536f, -0.01821904f, 0.06283299f, 0.61391622f, -0.39058876f, 0.01490637f, 0.09401092f, 
    0.16482575f, 0.10356771f, 0.33173969f, -0.07394873f, -0.06188011f, 0.01708442f, 0.01589992f, -0.04175912f, 
    0.42590606f, 0.24026173f, 0.05306078f, 0.22059654f, 0.04216001f, -0.02252016f, 0.13108735f, -0.08601261f, 
    0.03281474f, -0.08213452f, 0.00749867f, 0.02861537f, -0.82047176f, -0.25037742f, -0.38418046f, -0.38522398f, 
    0.00462016f, 0.15572040f, 0.21472646f, 0.20061713f, -0.15095833f, -0.04958439f, -0.08731798f, -0.10712608f, 
    0.21307752f, -0.11048543f, -0.05992593f, 0.00145115f, -0.03100260f, 0.06266849f, 0.19635881f, -0.02715511f, 
    0.17990892f, 0.04842991f, 0.11416504f, 0.21703070f, 0.30559677f, 0.06033698f, 0.05571425f, 0.00917211f, 
    -0.03645518f, -0.02738897f, -0.04523731f, 0.05071992f, -0.01997233f, 0.03833375f, 0.07043187f, -0.07219305f, 
    -0.35505232f, -0.03333576f, -0.05447833f, -0.23212589f, -0.06476601f, 0.08583928f, 0.19367824f, 0.11746451f, 
    0.14879039f, 0.04016424f, 0.10928988f, 0.15727593f, -0.05144116f, 0.29802343f, 0.05939775f, -0.01769193f, 
    -0.09949232f, 0.02242793f, -0.04388503f, 0.05802521f, -0.06582782f, -0.13445149f, 0.07327382f, 0.02008447f, 
    -0.63935125f, -0.10380735f, 0.12603243f, -0.24570839f, -0.04432697f, -0.17742299f, 0.00524892f, 0.03995336f, 
    0.20272207f, -0.05689948f, 0.10444766f, -0.05296399f, 0.32152805f, 0.11144280f, 0.41294792f, 0.23537822f, 
    -0.04786736f, -0.03519044f, 0.11904054f, -0.11978876f, 0.00977702f, 0.02207145f, 0.01178692f, 0.05275834f, 
    -0.22480552f, -0.15683180f, 0.00597354f, -0.14598678f, 0.14136527f, 0.14206125f, -0.02665081f, 0.27919990f, 
    0.09707137f, -0.00057136f, 0.05187107f, 0.11510020f, -0.38075802f, -0.00195963f, -0.92827368f, -0.39771375f, 
    0.14799304f, 0.19457982f, 0.00710625f, -0.01937494f, -0.10255837f, -0.03343149f, 0.10059375f, -0.05153450f, 
    -0.06650177f, 0.04078971f, -0.02271794f, -0.09591369f, 0.01833282f, 0.05964210f, 0.03895612f, 0.15412946f, 
    -0.01730907f, -0.08306538f, -0.08588154f, -0.06488181f, 0.41304365f, 0.20275004f, 0.06572513f, 0.05687120f, 
    0.13517834f, -0.05479788f, -0.03082261f, 0.00617517f, 0.06957592f, 0.00255782f, -0.05542411f, 0.01180105f, 
    -0.14544149f, 0.02693081f, -0.13676013f, 0.17745100f, 0.04755267f, 0.03068755f, 0.02691690f, 0.00156175f, 
    0.06587745f, -0.04747948f, -0.15186629f, 0.04113097f, 0.07284134f, -0.01984688f, -0.14763334f, 0.09392294f, 
    -0.02266099f, 0.05857316f, -0.06904355f, -0.02315830f, -0.01298966f, 0.02736142f, 0.09503198f, -0.08641667f, 
    -0.20825599f, 0.05621110f, -0.02261201f, 0.09090458f, 0.16014563f, 0.06221381f, 0.03223615f, -0.07510789f, 
    0.02130896f, 0.00171347f, 0.01294750f, 0.04935928f, 0.35186863f, 0.30259627f, 0.11175386f, -0.11010496f, 
    -0.11175599f, -0.05729954f, 0.02910298f, -0.11642660f, -0.06312606f, 0.04179844f, 0.07147168f, -0.04381377f, 
    0.29914978f, 0.00262909f, 0.27574933f, 0.24616419f, -0.04217002f, -0.03216418f, -0.10175913f, 0.05578770f, 
    -0.07055277f, -0.08362685f, -0.05921386f, 0.06435469f, 0.21900731f, 0.06317902f, 0.00527150f, -0.08133855f, 
    0.10275283f, -0.04055292f, 0.07669286f, 0.00162473f, -0.13789921f, -0.14710788f, -0.03228364f, -0.12602754f, 
    -0.16461025f, -0.03089202f, 0.14963843f, -0.14585499f, -0.05829837f, 0.03304271f, -0.07425136f, -0.07298056f, 
    -0.01735435f, -0.17021081f, 0.16959532f, 0.13357250f, 0.24474093f, -0.19765954f, -0.26407591f, 0.14953990f, 
    -0.05568813f, -0.02039629f, -0.04860926f, -0.07253911f, 0.07514549f, -0.07043513f, 0.09896412f, -0.03089788f, 
    0.02800177f, 0.03732938f, 0.05196056f, -0.13665649f, 0.07250885f, -0.10738621f, 0.05388912f, 0.16743878f, 
    -0.02025349f, -0.06624456f, 0.12113535f, 0.04465220f, -0.10320137f, -0.11153052f, -0.03318537f, 0.43321013f, 
    0.14876381f, -0.03703680f, -0.04674991f, -0.08072000f, 0.01256219f, 0.04267333f, 0.06875716f, 0.05514051f, 
    -0.28128478f, -0.00187095f, -0.29481974f, -0.31766102f, -0.01259336f, 0.05232394f, -0.03845473f, -0.01555228f, 
    0.10556611f, 0.00217142f, 0.00976224f, 0.02168475f, 0.16075741f, 0.15720299f, 0.13199173f, 0.20603003f, 
    0.02487776f, -0.08105536f, 0.00442477f, 0.05990567f, -0.05858828f, 0.03934156f, 0.03390000f, 0.01494296f, 
    -0.58441633f, 0.20601349f, -0.12449837f, 0.01575786f, 0.08617330f, 0.11698012f, -0.22612071f, -0.09584668f, 
    0.04540955f, -0.00911162f, 0.08602750f, 0.09905583f, 0.24199279f, -0.04093133f, 0.50462282f, 0.05181314f, 
    0.16523898f, -0.00164149f, 0.08437423f, 0.03634566f, 0.06493423f, -0.03304651f, 0.14128715f, 0.01839906f, 
    -0.09120275f, -0.00465352f, -0.05395925f, 0.06392968f, 0.09674487f, 0.18837139f, -0.15169539f, 0.16599360f, 
    -0.08714604f, 0.04427589f, -0.02667137f, 0.02982559f, -0.05595428f, 0.13060522f, 0.21101949f, 0.13679059f, 
    -0.02821984f, -0.02845226f, -0.02950720f, -0.26572859f, 0.02755704f, 0.05405013f, -0.00726339f, -0.00493115f, 
    0.00572899f, -0.18020627f, -0.15338360f, -0.13431229f, 0.03013821f, -0.05308848f, -0.00765499f, -0.04732791f, 
    -0.06271721f, -0.11611971f, 0.02018980f, -0.09779269f, -0.13387692f, -0.13235782f, -0.29672405f, -0.21190096f, 
    0.02908437f, 0.00866105f, -0.05323844f, -0.05711094f, 0.03906303f, 0.09224682f, -0.03564683f, -0.08754480f, 
    -0.00191187f, 0.04264098f, -0.17051797f, 0.04743922f, -0.00757469f, -0.07824375f, -0.03692224f, -0.04822912f, 
    0.05097199f, 0.09579292f, 0.02360696f, 0.02350305f, -0.07267836f, 0.33851379f, 0.26619402f, 0.07569285f, 
    -0.19031087f, 0.01237317f, 0.04101202f, -0.19617637f, -0.01745470f, -0.06758551f, -0.01812346f, -0.04474984f, 
    -0.16654338f, -0.18537991f, -0.22313727f, -0.19533718f, 0.01850288f, -0.11619944f, -0.08976991f, 0.00148880f, 
    0.06088610f, 0.02014152f, 0.02012748f, 0.06505801f, 0.15521976f, 0.06466175f, 0.15922347f, 0.30247563f, 
    -0.02854016f, 0.11994321f, 0.07727437f, -0.07381966f, 0.09121211f, 0.04291075f, 0.09641980f, 0.09940165f, 
    -0.05291696f, -0.07436956f, -0.00041912f, -0.06496739f, -0.00117805f, 0.04331124f, -0.00165533f, -0.10253976f, 
    -0.02054287f, -0.07055563f, 0.12242735f, -0.06817795f, -0.14854382f, -0.15251146f, -0.24055064f, -0.08376271f, 
    -0.06021908f, -0.02108433f, -0.00013857f, 0.01356298f, 0.06259103f, -0.02870310f, 0.00921222f, -0.00032413f, 
    0.16519955f, 0.21851139f, 0.13561757f, 0.13382728f, -0.03194197f, -0.14257886f, 0.08367895f, 0.14805511f, 
    -0.04745533f, -0.03185625f, 0.02333500f, 0.00054716f, -0.17173848f, -0.32219920f, -0.10791817f, -0.07516541f, 
    0.01995414f, 0.06739680f, -0.07302012f, -0.01868648f, -0.03476392f, 0.04052666f, -0.11066376f, 0.00019009f, 
    0.18894632f, 0.20403457f, 0.18413240f, 0.38328359f, 0.04936023f, 0.04010393f, 0.07757751f, 0.07818373f, 
    0.03150138f, -0.01722810f, 0.04313696f, 0.02519664f, -0.09111502f, -0.17468221f, 0.04885575f, -0.19398999f, 
    0.00382346f, -0.14077774f, -0.11173499f, -0.12196087f, 0.08330526f, 0.00543282f, 0.00399018f, 0.06430990f, 
    0.24535611f, -0.21925542f, -0.00446492f, 0.11966669f, 0.11181654f, 0.04717383f, -0.16582552f, 0.13808653f, 
    -0.06183213f, 0.14792728f, -0.01093469f, 0.08685477f, -0.01326976f, 0.03246114f, 0.24258381f, 0.01414495f, 
    0.06245288f, -0.16474570f, 0.00344436f, 0.02056570f, 0.09500923f, -0.04396470f, 0.08640912f, -0.03833621f, 
    -0.03221827f, 0.02002520f, -0.04110927f, -0.05733201f, 0.05151421f, -0.01746467f, 0.01245849f, -0.05392594f, 
    0.02769072f, 0.03095556f, 0.02578391f, 0.04424327f, -0.05039151f, 0.04055629f, 0.04336813f, 0.00024855f, 
    -0.07155173f, 0.00865612f, -0.01674108f, 0.04305813f, 0.00573691f, -0.05854223f, -0.05160893f, -0.06638687f, 
    -0.03267385f, -0.00147545f, 0.01317843f, -0.02880541f, 0.01812021f, 0.01857667f, -0.01253899f, -0.06253731f, 
    -0.03153005f, -0.05480146f, -0.00374381f, -0.04035820f, 0.00790686f, -0.00807236f, -0.06851008f, 0.06140471f, 
    -0.04587042f, -0.06146370f, -0.00889369f, -0.00940150f, 0.04217281f, -0.02310310f, -0.05644322f, 0.02798873f, 
    0.03337526f, 0.05509457f, -0.00398551f, 0.05409628f, 0.02104999f, -0.00561643f, -0.05271588f, -0.02945643f, 
    0.04317471f, -0.05178453f, 0.07142010f, -0.04418176f, -0.07099614f, -0.00401629f, -0.03445935f, -0.04936631f, 
    0.06837534f, -0.03097337f, -0.02855039f, -0.01453509f, -0.03474380f, 0.03936691f, -0.05945141f, 0.04608084f, 
    0.06492928f, -0.00934083f, 0.03102584f, -0.04013421f, -0.00662511f, 0.01477760f, -0.06917326f, 0.02919596f, 
    -0.03000786f, -0.03235221f, 0.02060813f, -0.02987653f, 0.03701570f, -0.04724333f, 0.01813423f, -0.03545827f, 
    0.03502118f, -0.03172036f, -0.00373655f, -0.07109659f, -0.05539319f, -0.03187377f, -0.06310631f, 0.07167878f, 
    -0.02518693f, -0.01991758f, -0.04587671f, -0.00375349f, -0.01086733f, -0.03826534f, 0.03397987f, -0.06044669f, 
    0.04934708f, -0.04242301f, -0.02673920f, 0.00611305f, -0.03661964f, 0.05915334f, -0.01831655f, 0.04218540f, 
    -0.07066716f, -0.03317497f, 0.05973921f, -0.05336741f, -0.03606549f, -0.06316832f, 0.02588846f, -0.02639320f, 
    0.01570076f, 0.03377867f, -0.01011644f, 0.03333135f, 0.04457583f, -0.06765333f, 0.07013196f, -0.01826848f, 
    0.03117478f, 0.06162357f, -0.03608320f, 0.05028768f, -0.06652067f, -0.06397922f, 0.01926500f, -0.04580885f, 
    -0.02694540f, -0.05050986f, -0.02593435f, -0.06979292f, -0.01790571f, 0.05682187f, -0.05677401f, -0.04820035f, 
    0.01033832f, -0.07103731f, 0.01224761f, 0.03356487f, -0.07058644f, 0.01291380f, 0.05691127f, -0.01338857f, 
    0.06850953f, -0.03393281f, -0.03679793f, -0.00708252f, 0.05209479f, -0.02868056f, -0.01896916f, -0.01546611f, 
    -0.07205418f, 0.06179316f, -0.03795661f, 0.04710473f, -0.02136566f, 0.06447343f, 0.01444077f, 0.05922508f, 
    -0.06032478f, -0.07107418f, 0.01335874f, 0.04228758f, -0.06131272f, -0.01537778f, -0.06839941f, -0.00018499f, 
    -0.05702644f, 0.02074379f, 0.06462608f, 0.04401098f, -0.03586001f, -0.02869756f, -0.04064198f, -0.07116865f, 
    -0.05805396f, 0.03412389f, -0.05186985f, 0.06660377f, 0.01195982f, -0.06923391f, -0.00602963f, -0.03026263f, 
    -0.03637008f, 0.05255789f, -0.11734200f, -0.13162738f, -0.04573153f, 0.13205375f, 0.05011615f, -0.04996447f, 
    -0.03595945f, -0.01984266f, 0.08255219f, -0.04160004f, 0.34177008f, 0.19507882f, 0.03028691f, 0.00893500f, 
    0.05575741f, -0.02312444f, 0.07268013f, 0.10469387f, 0.05569457f, -0.02735637f, -0.18839878f, -0.05538863f, 
    -0.05446396f, -0.09697435f, -0.02665678f, 0.05672762f, 0.01387833f, 0.02820635f, 0.14219792f, -0.03497779f, 
    0.13169259f, 0.21680161f, -0.05383724f, 0.05146892f, 0.03107568f, -0.02582300f, -0.05822011f, -0.00630484f, 
    -0.20746388f, 0.00603090f, -0.03928588f, -0.01043792f, 0.23903576f, -0.00565174f, 0.10239684f, -0.00448546f, 
    -0.07647293f, 0.09567222f, 0.29688129f, 0.06950884f, 0.11650059f, 0.00831186f, 0.09177290f, -0.12844160f, 
    -0.00496630f, 0.03011885f, -0.04431845f, 0.09225494f, 0.15785752f, 0.07910335f, -0.25501698f, -0.13517289f, 
    0.07675340f, -0.12022068f, 0.12148843f, 0.04180782f, -0.13281313f, 0.06643341f, -0.07788654f, 0.06635651f, 
    0.01700045f, 0.06713563f, 0.30235836f, -0.01015141f, -0.02182184f, -0.02518264f, -0.06278218f, -0.04206862f, 
    -0.02216982f, -0.12273580f, 0.05704948f, 0.03693678f, 0.17894158f, -0.02427587f, -0.02019970f, -0.12521407f, 
    0.11961789f, 0.05378680f, 0.01090441f, 0.04714362f, -0.14888090f, 0.03845040f, -0.00923681f, -0.04331743f, 
    -0.20663674f, -0.16859367f, -0.04363262f, 0.02880754f, 0.01824108f, -0.07488843f, -0.05036347f, -0.00264231f, 
    -0.03208057f, -0.15354094f, -0.06452675f, -0.01040844f, 0.14104903f, -0.06425223f, -0.24908324f, -0.03669297f, 
    -0.14113206f, -0.02933864f, 0.02778964f, -0.08819692f, 0.08133233f, 0.02506294f, 0.01511879f, 0.05790812f, 
    0.02810428f, 0.12121144f, 0.05687054f, -0.08321445f, -0.03962651f, 0.01077247f, -0.03974367f, 0.07594472f, 
    0.09497537f, 0.05499160f, 0.01239302f, 0.00656577f, -0.02285558f, -0.32984683f, 0.07291944f, 0.02280170f, 
    0.03920011f, -0.05485520f, -0.04927883f, -0.05609917f, 0.09905320f, 0.07053646f, -0.01492476f, -0.05090855f, 
    -0.34195876f, -0.08703794f, -0.11060999f, -0.27786797f, 0.02340561f, 0.11642804f, -0.13760661f, -0.03762385f, 
    0.03043709f, 0.14884849f, -0.05695701f, -0.09760457f, 0.02562365f, -0.03827057f, 0.08716676f, 0.08649023f, 
    -0.09936611f, -0.06212922f, -0.11090595f, -0.05652991f, -0.02389279f, -0.11012270f, -0.00360483f, 0.04490979f, 
    -0.28098473f, 0.14876239f, -0.14396454f, 0.06296431f, -0.10178321f, 0.16938286f, 0.05932134f, 0.23151998f, 
    -0.09435556f, -0.01261516f, -0.00765944f, 0.02091684f, 0.22987105f, 0.10406236f, 0.21076195f, -0.03536798f, 
    0.23153721f, 0.04385269f, 0.23498093f, -0.00772229f, 0.19238077f, -0.07223010f, 0.03632728f, 0.05977989f, 
    0.00413812f, -0.05679471f, -0.07764938f, 0.04808436f, -0.01383402f, -0.00952193f, -0.05260326f, -0.00344821f, 
    -0.03551679f, 0.05288734f, -0.00992244f, 0.03908208f, -0.00186213f, 0.05482477f, 0.00033534f, 0.03308754f, 
    -0.04367754f, -0.05890216f, 0.03937959f, 0.02338352f, 0.03660040f, -0.01559641f, 0.03150600f, 0.01748862f, 
    0.04685792f, 0.05872148f, 0.02846497f, 0.04144128f, 0.00609689f, -0.04600419f, 0.00366522f, 0.03178576f, 
    -0.03273545f, -0.02093654f, 0.06128766f, -0.04346563f, -0.01719815f, -0.05239343f, -0.06015547f, -0.05730802f, 
    0.05037429f, -0.00550272f, 0.03514760f, -0.05314444f, 0.02880272f, 0.01576984f, 0.02057253f, -0.03235231f, 
    -0.01842730f, 0.02675967f, -0.04675858f, 0.03168388f, 0.05894966f, -0.04555773f, -0.04996691f, -0.02340765f, 
    0.05068163f, 0.02139324f, -0.04132097f, -0.00570767f, -0.01987307f, 0.05273598f, -0.02369413f, -0.03048053f, 
    -0.04338124f, 0.01819476f, -0.07375779f, 0.04052780f, 0.02618897f, -0.04439883f, -0.05443786f, 0.04285230f, 
    -0.01313578f, 0.02111141f, -0.02614799f, -0.00042237f, -0.04872151f, -0.04609032f, 0.04457115f, -0.00940241f, 
    -0.04828482f, -0.04868807f, 0.04653402f, -0.03968266f, 0.02035131f, -0.03615271f, 0.03440455f, 0.04277373f, 
    -0.06808449f, -0.06613647f, 0.04505334f, -0.06503359f, -0.02611175f, -0.02105168f, -0.04816512f, -0.03979260f, 
    -0.04246917f, 0.05052626f, -0.02041958f, -0.01837395f, 0.01445776f, 0.02204042f, 0.02573007f, -0.07672209f, 
    0.00833830f, -0.05014651f, -0.03140064f, 0.05664479f, -0.00479783f, -0.05934992f, -0.07647821f, 0.02289086f, 
    -0.02105366f, 0.03629990f, 0.05580665f, -0.05005447f, -0.03429560f, -0.06360878f, -0.00509423f, -0.01736741f, 
    -0.04802915f, 0.03369581f, -0.02961876f, -0.05714921f, 0.03268189f, -0.05571914f, -0.06929322f, -0.05215370f, 
    -0.03796484f, 0.01896662f, 0.02113744f, -0.01221632f, -0.02295928f, -0.03825282f, -0.07523244f, -0.02748568f, 
    -0.02471315f, -0.07287351f, 0.01057455f, -0.03596616f, -0.00279562f, -0.04749690f, -0.02941157f, 0.06445459f, 
    0.02982684f, 0.01331405f, -0.06825696f, -0.01581563f, -0.07524474f, -0.00247646f, 0.02442495f, 0.01528634f, 
    -0.04746503f, -0.04420152f, -0.02802731f, -0.01971941f, 0.00437185f, -0.03231908f, 0.01103176f, -0.00847573f, 
    0.04245016f, 0.00407309f, -0.05917485f, 0.00767094f, -0.05081722f, -0.01897296f, 0.03784224f, -0.01830998f, 
    -0.06926823f, 0.05739315f, 0.01457272f, -0.03865382f, -0.01715370f, -0.01362351f, -0.04471860f, -0.01869877f, 
    0.00853782f, 0.05645716f, -0.07274997f, -0.01089098f, 0.00930175f, -0.07908034f, 0.03750483f, -0.03988548f, 
    0.04174276f, 0.06030660f, 0.00968979f, 0.05641404f, -0.01466662f, 0.05720456f, 0.00284169f, -0.07470972f, 
    -0.06768456f, -0.04513672f, 0.03043344f, 0.04343719f, -0.03206917f, 0.03364314f, -0.06940611f, 0.02956151f, 
    0.05718595f, 0.00583362f, -0.05061495f, -0.00965508f, -0.04056900f, 0.04732275f, 0.04578126f, -0.02002792f, 
    -0.00104916f, 0.02634634f, 0.05982732f, 0.02504827f, 0.06581324f, 0.03944065f, -0.00644172f, -0.06219506f, 
    -0.02772229f, -0.01791538f, -0.04822181f, -0.03190657f, 0.01990759f, 0.05889264f, -0.02061103f, -0.00779883f, 
    -0.05621834f, -0.06202144f, 0.05282807f, 0.04656446f, 0.03820408f, 0.04960145f, -0.00703612f, 0.02056922f, 
    -0.01544150f, 0.01249725f, -0.06230873f, -0.02962103f, -0.02548089f, 0.03427498f, -0.02457107f, -0.00982070f, 
    -0.06515611f, 0.02307919f, 0.06315549f, 0.02096953f, -0.04248063f, 0.01995129f, -0.01409880f, -0.03824883f, 
    0.01329903f, 0.01706651f, -0.02553139f, -0.04458817f, -0.03581762f, -0.02917450f, -0.01461128f, -0.02337170f, 
    -0.00097629f, -0.06043914f, -0.06041945f, 0.02129763f, 0.04421737f, -0.06695274f, -0.05439543f, -0.03362507f, 
    0.03526759f, -0.07298253f, -0.06504451f, -0.05754725f, -0.01107417f, -0.05189975f, -0.02547042f, 0.02586358f, 
    -0.05091692f, -0.00011508f, 0.05954739f, -0.03728111f, -0.01175612f, -0.06985767f, -0.02746526f, -0.03263370f, 
    -0.06760205f, -0.07673841f, 0.03398075f, -0.03300076f, -0.06056990f, -0.07336673f, 0.06149564f, -0.02515653f, 
    -0.02889157f, 0.01621562f, 0.06521859f, -0.01900959f, -0.04424594f, -0.00327252f, -0.04167385f, -0.03117343f, 
    0.00489948f, -0.07338767f, 0.00172975f, 0.02242123f, -0.04583375f, 0.05059687f, -0.05357803f, -0.01460508f, 
    -0.00660001f, 0.06560165f, -0.04901518f, -0.04704769f, 0.01024569f, 0.05023910f, -0.03420022f, 0.03475082f, 
    -0.00522501f, 0.03788077f, -0.00531641f, 0.01268786f, -0.06531592f, -0.06073768f, -0.00749210f, 0.00609792f, 
    -0.05194335f, -0.06904007f, -0.04723753f, 0.05216176f, -0.00757394f, -0.02973722f, 0.02173586f, -0.00234293f, 
    0.00950116f, -0.06518119f, -0.03885662f, -0.05044203f, 0.03294942f, 0.00980920f, 0.06156889f, -0.05142924f, 
    -0.01869661f, -0.02562731f, 0.00062717f, -0.04459688f, 0.04343425f, 0.00019664f, -0.00430201f, -0.02670222f, 
    0.00478206f, -0.03436859f, -0.03745907f, 0.06381115f, 0.06041766f, 0.03040542f, 0.01806982f, -0.06210678f, 
    -0.04299467f, -0.07311431f, -0.04591781f, 0.06022696f, -0.00684335f, 0.03321731f, -0.03423610f, 0.04160924f, 
    0.06205132f, 0.01737330f, -0.04380390f, -0.05251549f, -0.03611463f, -0.05619701f, -0.06341533f, -0.06403132f, 
    0.06276038f, 0.00755247f, -0.03467460f, -0.03760318f, 0.02606534f, 0.01548940f, -0.05461654f, -0.02823968f, 
    0.05847751f, 0.01459426f, -0.05964174f, 0.02769676f, -0.00305659f, 0.05016195f, -0.01287176f, 0.05003779f, 
    -0.07747193f, 0.05746523f, -0.02021513f, 0.04238258f, -0.01611005f, 0.03010915f, -0.05997574f, -0.06702821f, 
    0.02114023f, -0.07100415f, -0.03309281f, -0.06808797f, -0.06541845f, 0.00057964f, 0.00817158f, -0.01952594f, 
    0.03203771f, 0.00473361f, -0.07156081f, 0.00456508f, -0.00952995f, 0.01868267f, -0.01976892f, 0.06289014f, 
    0.02005797f, -0.01204708f, 0.01545338f, 0.05842835f, -0.02254619f, 0.02738926f, -0.02107393f, 0.01967241f, 
    0.03742316f, -0.06004406f, -0.00878821f, -0.06572969f, 0.01883349f, -0.03153175f, 0.00421051f, -0.01886321f, 
    0.02087852f, 0.05018922f, 0.01809748f, -0.06687526f, -0.01261764f, -0.00064714f, 0.04210232f, -0.06250734f, 
    -0.00284148f, 0.05616114f, -0.02679398f, 0.03205198f, -0.04891550f, -0.07640428f, 0.02301979f, -0.03857788f, 
    0.00510087f, -0.06150087f, -0.02993805f, -0.05177767f, -0.02451510f, -0.00622153f, -0.04615877f, -0.07877915f, 
    -0.06502648f, 0.00163244f, -0.07039182f, 0.01421507f, -0.04047412f, 0.02513937f, -0.06716345f, 0.00582141f, 
    -0.01278153f, -0.07356766f, -0.05986585f, -0.02107210f, -0.03674050f, 0.02508597f, -0.00786202f, -0.00490969f, 
    0.04087203f, -0.07187603f, 0.02116135f, -0.05744277f, 0.04369197f, 0.04699208f, 0.03757467f, -0.07135271f, 
    0.03833263f, -0.04680149f, -0.06920420f, -0.03339693f, 0.01265042f, 0.05241289f, 0.01175852f, 0.01947618f, 
    -0.02227826f, -0.04784002f, -0.05561424f, 0.03635935f, 0.02878760f, 0.04272584f, 0.00783048f, 0.06120126f, 
    0.02305318f, -0.06438126f, -0.07051027f, 0.05638084f, 0.03436364f, -0.03843192f, -0.01589678f, -0.04131268f, 
    -0.03639031f, -0.00014216f, 0.03144423f, 0.06365944f, 0.00701277f, 0.04246823f, 0.01098265f, -0.04580096f, 
    -0.05529376f, 0.06225978f, 0.00839564f, -0.02848451f, 0.01880744f, -0.04146110f, 0.02630630f, -0.01161607f, 
    0.01989141f, -0.01213605f, -0.05140616f, 0.02213253f, 0.02232664f, 0.04207448f, 0.05787490f, -0.06154320f, 
    -0.03429320f, 0.00622477f, -0.07490331f, 0.04002234f, -0.06847894f, -0.02238751f, -0.01355339f, -0.06719788f, 
    -0.02539314f, 0.00013208f, -0.00132375f, 0.02338747f, 0.04653236f, 0.06086986f, -0.04909331f, -0.07461663f, 
    -0.00500815f, -0.05079317f, -0.04016787f, -0.01713614f, 0.05336110f, -0.03799041f, 0.03995031f, 0.05662625f, 
    -0.06315424f, -0.03882945f, 0.00548664f, -0.05902035f, -0.00585409f, 0.02120745f, -0.04104296f, -0.00393712f, 
    -0.04219716f, -0.03735304f, -0.04739326f, 0.06310400f, -0.03659431f, -0.04610929f, -0.06621427f, -0.04381197f, 
    0.03487383f, 0.00644807f, 0.05737890f, -0.00305826f, 0.04174083f, -0.05052545f, 0.02548558f, -0.03803214f, 
    0.04107258f, 0.03746016f, 0.00322235f, -0.06774579f, -0.07822683f, -0.04194104f, 0.05229338f, -0.02784711f, 
    -0.05968021f, -0.05528008f, -0.05746566f, 0.02710446f, -0.03467294f, -0.01658628f, -0.03212005f, -0.07364584f, 
    0.03785327f, -0.04432478f, -0.02590369f, -0.07847795f, -0.04110087f, -0.06074838f, 0.05518103f, 0.05681134f, 
    -0.05850584f, -0.01347583f, -0.04751258f, -0.06538319f, -0.00759732f, -0.07414243f, 0.03414848f, -0.04315588f, 
    0.02845890f, -0.06259924f, 0.01509799f, -0.07127801f, -0.03700243f, 0.04691310f, -0.04804968f, -0.00946632f, 
    -0.00985823f, -0.03718403f, -0.07556983f, -0.09231453f, -0.03632816f, -0.01618041f, -0.03257734f, -0.07016942f, 
    -0.01350925f, -0.03441855f, -0.05566630f, 0.00471151f, -0.01141270f, 0.01963738f, 0.01363763f, 0.03158557f, 
    0.04712733f, 0.01223673f, 0.02944851f, -0.00329722f, 0.04282798f, 0.05416670f, -0.03829825f, -0.07137178f, 
    0.02742108f, -0.03760976f, -0.01861205f, -0.02865171f, 0.02125982f, 0.00221268f, 0.03070025f, -0.08179200f, 
    0.01883090f, -0.06432779f, 0.01978553f, 0.04774017f, -0.00505088f, 0.00643577f, 0.01030263f, -0.06481884f, 
    0.00159096f, 0.03900949f, 0.05481184f, -0.08957367f, 0.01359809f, 0.00857693f, 0.04889352f, 0.02403709f, 
    0.03233763f, 0.02713235f, -0.02353587f, 0.03975179f, 0.03989927f, 0.05731348f, 0.02916495f, -0.02028301f, 
    -0.03966657f, -0.08604979f, -0.08066142f, 0.04095892f, 0.00898891f, 0.04160065f, 0.02105126f, -0.01596285f, 
    0.02258560f, 0.04308280f, 0.05723544f, 0.02784181f, -0.06878055f, -0.07623488f, 0.02880874f, 0.00814431f, 
    -0.07254584f, -0.05577490f, -0.05093930f, -0.04975863f, 0.03986704f, 0.00564087f, -0.05557177f, 0.01950159f, 
    0.02390553f, -0.00250923f, -0.01110207f, 0.05156974f, 0.03260180f, -0.06225421f, 0.03268817f, -0.03651723f, 
    -0.01277499f, 0.03625501f, -0.06471746f, 0.05403361f, -0.07449804f, -0.04364156f, -0.06163953f, 0.00875988f, 
    -0.02896441f, -0.07254909f, 0.03967750f, -0.01913649f, 0.05286150f, -0.02430143f, -0.03754047f, -0.02391829f, 
    -0.07406128f, 0.04703286f, -0.07197030f, -0.01802742f, -0.03401644f, -0.00655740f, -0.02183014f, -0.04394580f, 
    -0.04617425f, -0.04576086f, -0.04047559f, 0.00969517f, 0.03913838f, 0.01754236f, -0.02057623f, -0.04924579f, 
    0.05623407f, 0.02307150f, -0.01015092f, -0.04864531f, -0.01363128f, -0.01449154f, 0.00184042f, 0.03198319f, 
    0.03666524f, -0.02141596f, -0.08543403f, -0.08118323f, -0.08145120f, -0.00412940f, 0.01726256f, -0.05988014f, 
    -0.05512855f, 0.01050929f, 0.03010946f, 0.02478488f, -0.01413381f, -0.05965520f, -0.02649565f, 0.01460331f, 
    0.00867313f, 0.01482019f, 0.03123607f, -0.03166207f, -0.03008853f, -0.04185295f, 0.00876986f, -0.04765477f, 
    -0.05872046f, 0.02455719f, -0.05192946f, -0.01616306f, 0.05071677f, -0.00178293f, -0.00206385f, 0.01593252f, 
    -0.06012072f, -0.00181306f, -0.02224916f, 0.02820396f, -0.03443780f, 0.02532653f, -0.04786130f, 0.00475298f, 
    0.01479172f, -0.07517774f, -0.03041831f, 0.02827406f, 0.00513607f, -0.04389089f, -0.05420105f, -0.06747746f, 
    -0.04930653f, 0.02562806f, -0.06844965f, 0.05239122f, -0.00653889f, -0.04739084f, 0.03119987f, -0.01730557f, 
    0.00985831f, -0.05942538f, -0.00171716f, -0.06582437f, -0.01436903f, 0.01469093f, -0.07558358f, -0.00802269f, 
    0.01928683f, -0.05335984f, 0.01854961f, -0.06796493f, 0.05702407f, 0.04256013f, -0.03372692f, -0.06639798f, 
    0.03819243f, -0.04903265f, -0.03147879f, 0.03391409f, -0.07665829f, 0.05447354f, 0.02198590f, 0.01120155f, 
    -0.04631475f, -0.05094531f, 0.05573275f, 0.00265319f, 0.04430934f, -0.02014193f, 0.02190555f, -0.00749014f, 
    0.01605251f, -0.00885848f, -0.06691036f, -0.04792056f, 0.00627277f, 0.06637675f, 0.00208475f, 0.03644697f, 
    -0.07323898f, 0.05564575f, -0.02821818f, 0.02700229f, -0.00914115f, -0.06251749f, -0.07593287f, -0.07118139f, 
    0.06107986f, 0.03151596f, -0.04051232f, -0.05400334f, -0.00922399f, -0.06398948f, 0.05482136f, -0.05050346f, 
    -0.02942464f, -0.03080921f, -0.04501076f, -0.01346481f, 0.07141483f, -0.02839819f, -0.06155462f, -0.03246278f, 
    0.02278939f, -0.03778961f, -0.01087748f, -0.06199743f, -0.05971552f, -0.00432479f, -0.06161760f, -0.00145659f, 
    -0.01824373f, 0.04573940f, -0.05411423f, -0.06084538f, -0.01749233f, -0.01478217f, 0.03911197f, 0.03435154f, 
    0.03382757f, -0.03501551f, -0.07750762f, -0.06210504f, -0.02616877f, -0.06434215f, 0.04411402f, 0.00377859f, 
    -0.04222465f, 0.01504091f, -0.05608752f, -0.00990858f, -0.00344111f, -0.05814838f, -0.01986790f, -0.06859986f, 
    0.06543238f, 0.00781164f, -0.07330859f, 0.01877757f, 0.01661758f, 0.02793431f, 0.01725681f, -0.07018597f, 
    0.02654870f, -0.03067052f, 0.01161134f, -0.01029246f, -0.00166466f, -0.06720964f, -0.05109715f, 0.00452386f, 
    0.04847057f, -0.00446863f, -0.04039921f, 0.06647569f, -0.06804282f, -0.02296332f, 0.06028562f, -0.02274068f, 
    0.04784628f, 0.02582195f, -0.04935794f, -0.07343504f, -0.04039926f, -0.00499619f, -0.03259296f, 0.01132573f, 
    -0.01684218f, -0.03001817f, 0.05953681f, 0.05020956f, 0.01020073f, 0.04352732f, -0.04555028f, -0.01437907f, 
    -0.06424232f, 0.03390135f, 0.00991216f, -0.06514395f, -0.02314568f, -0.03727722f, 0.05105430f, 0.02917942f, 
    0.00524761f, 0.01585881f, 0.01245910f, 0.01671600f, 0.03965364f, 0.04402002f, 0.05629671f, -0.03279487f, 
    0.03425490f, 0.04008953f, 0.01636088f, -0.06792420f, -0.00455677f, 0.01027308f, -0.06486927f, -0.00259817f, 
    -0.00352763f, 0.05875752f, -0.04153507f, -0.04439694f, -0.06268805f, 0.01497488f, -0.03814252f, 0.06311625f, 
    0.00374402f, 0.07403863f, -0.06717457f, 0.09462120f, 0.07381008f, -0.01665064f, -0.02206885f, -0.16750287f, 
    -0.06371820f, 0.08217177f, 0.08649652f, 0.12971336f, -0.00442852f, -0.04622139f, 0.02012817f, 0.21437263f, 
    0.05424344f, 0.04239289f, -0.17871225f, -0.12331451f, 0.02952177f, 0.10135435f, -0.00838178f, -0.14701223f, 
    0.19210795f, 0.21708208f, 0.34815407f, 0.01151819f, 0.03116212f, -0.10692977f, -0.02031341f, 0.00961532f, 
    0.08829614f, 0.04982610f, 0.03281346f, -0.03761111f, 0.10079733f, -0.05706295f, 0.05658028f, 0.04404990f, 
    0.01533350f, -0.01380163f, -0.06664878f, 0.00533862f, 0.22396754f, -0.05283955f, -0.00843635f, -0.00348724f, 
    -0.30880186f, -0.22092110f, 0.18040803f, 0.03443362f, -0.06478272f, -0.00459264f, -0.14870557f, 0.07859046f, 
    -0.01567757f, -0.19478449f, -0.01999165f, 0.14877245f, 0.13192718f, 0.11521059f, -0.19875234f, 0.19528073f, 
    0.06152356f, 0.06218586f, -0.03595365f, 0.27783221f, -0.12398364f, -0.03585758f, -0.11827971f, 0.14359830f, 
    0.03664976f, 0.31497037f, 0.19365619f, -0.02386262f, -0.03615926f, -0.12561956f, -0.04296901f, -0.22487919f, 
    0.05848865f, 0.01469594f, 0.11095933f, -0.05780058f, -0.08899348f, 0.03933488f, 0.14449231f, 0.09135886f, 
    -0.15910538f, -0.00310673f, 0.14162304f, 0.28656644f, -0.10907754f, 0.00740561f, 0.05281338f, 0.06684601f, 
    0.06906550f, 0.07839592f, -0.00045452f, -0.01430489f, -0.02137911f, -0.08225785f, 0.17288634f, -0.03142533f, 
    -0.03589718f, -0.07706700f, -0.09568798f, 0.00522809f, 0.10181252f, -0.04508850f, -0.14746273f, -0.03517259f, 
    -0.07099838f, -0.02569155f, -0.08774662f, -0.15788807f, -0.04045259f, 0.03045216f, 0.06109560f, -0.05638873f, 
    -0.08465613f, 0.06335599f, -0.04049430f, 0.05997339f, -0.14262481f, 0.01211417f, 0.10162132f, 0.15544802f, 
    -0.03599638f, 0.07868182f, -0.08297998f, 0.17418799f, -0.22456461f, 0.29327098f, -0.15499738f, -0.05110138f, 
    -0.08707090f, -0.05500111f, -0.11785783f, 0.03801384f, -0.01939502f, 0.04422295f, -0.15769941f, -0.06470269f, 
    0.11116946f, 0.02343259f, 0.08916070f, -0.21221225f, -0.01450178f, -0.09460736f, 0.06573866f, -0.03410862f, 
    0.05793314f, 0.05450117f, -0.08363935f, 0.01546514f, 0.00215631f, 0.22274430f, 0.07107635f, 0.03753052f, 
    -0.08366165f, -0.04229945f, -0.13153389f, -0.17274131f, 0.09107790f, 0.04526498f, 0.02668543f, -0.03036214f, 
    0.10041623f, -0.39602712f, 0.14109315f, -0.15601026f, -0.10393596f, -0.04406531f, -0.01803960f, 0.09892378f, 
    -0.31203130f, -0.12878841f, 0.02519479f, -0.12617965f, -0.22530033f, 0.15770181f, -0.19771422f, 0.14784251f, 
    0.00503352f, -0.07288590f, 0.02961385f, 0.05697723f, -0.09538022f, 0.07318907f, 0.02893797f, 0.10963351f, 
    0.00507628f, -0.04239281f, -0.04834612f, -0.07223451f, 0.16463606f, -0.04132076f, 0.09036383f, 0.12751704f, 
    0.21399683f, 0.16535252f, 0.10485902f, 0.10152576f, -0.09674072f, -0.10939877f, -0.10868153f, -0.22577588f, 
    -0.21146069f, -0.11973337f, 0.07228695f, 0.19215591f, -0.01014816f, 0.03419465f, -0.00390705f, 0.05642107f, 
    -0.11115339f, -0.00442498f, -0.13752466f, 0.18818106f, 0.02202511f, -0.01373969f, -0.13033843f, 0.04607948f, 
    0.01323506f, 0.17295329f, 0.11053087f, 0.24598806f, -0.06144679f, 0.07129889f, -0.12804060f, 0.02024720f, 
    -0.05727649f, -0.08778328f, -0.03842827f, -0.02454971f, 0.07874853f, 0.05538983f, 0.15863656f, 0.15469052f, 
    0.40761366f, 0.11007843f, -0.30226550f, 0.10176575f, 0.22450630f, -0.19743419f, -0.12382508f, 0.04365924f, 
    0.08172222f, 0.11352924f, 0.05990047f, 0.02873642f, -0.20094329f, -0.02671963f, 0.10849388f, -0.07907095f, 
    -0.02046265f, 0.15791364f, 0.07637025f, 0.01908099f, 0.09118546f, -0.07908385f, -0.04669522f, -0.01262508f, 
    -0.06213888f, -0.15129173f, -0.12081014f, -0.05230360f, 0.04150624f, 0.14139777f, -0.07083586f, -0.00981839f, 
    -0.00065383f, 0.06888740f, -0.00727365f, -0.07765469f, -0.17754595f, -0.24408433f, -0.06870619f, -0.09292545f, 
    0.14890197f, 0.08881748f, -0.02925564f, -0.11937483f, 0.00986919f, -0.04943512f, -0.03162007f, 0.04294464f, 
    -0.05964781f, 0.30461532f, 0.02543235f, -0.10351518f, 0.00433043f, 0.14103211f, 0.14138533f, -0.04905565f, 
    0.09558681f, 0.23638196f, 0.04724986f, -0.24623206f, 0.04430338f, -0.27174768f, 0.28154778f, -0.14242674f, 
    0.01940014f, -0.09744209f, -0.05407996f, -0.00292548f, 0.11289028f, 0.12062072f, 0.17875545f, 0.12409790f, 
    -0.03271981f, -0.22595958f, 0.04585349f, 0.00626340f, -0.05850569f, 0.01162147f, 0.10630070f, 0.03402708f, 
    0.08670711f, 0.09150514f, -0.14014888f, -0.00703043f, 0.19482823f, 0.08407711f, -0.19006743f, 0.31375837f, 
    0.01400620f, -0.05920334f, -0.08165609f, -0.01486761f, 0.07428809f, -0.09620585f, 0.14363043f, -0.03266541f, 
    -0.20163611f, -0.18061571f, -0.06429619f, 0.05209606f, -0.12291909f, 0.04991643f, 0.11525775f, -0.00116775f, 
    0.06035642f, 0.07477624f, 0.12288860f, -0.00850888f, 0.04492364f, 0.12761094f, -0.23737440f, 0.15613575f, 
    0.09128742f, -0.04147163f, 0.06078841f, 0.00266095f, -0.07224834f, -0.01334240f, -0.00823086f, -0.01251632f, 
    -0.20382413f, 0.38050288f, 0.02184535f, -0.13061246f, -0.01196723f, 0.00408628f, 0.25542620f, -0.04855253f, 
    0.06960477f, 0.09496225f, -0.02803185f, -0.03011546f, -0.12034202f, -0.00816302f, 0.03614175f, 0.12115330f, 
    0.05532818f, -0.11176553f, 0.05008923f, 0.24421833f, 0.09591712f, 0.06590243f, 0.01093719f, 0.25705040f, 
    -0.06575077f, 0.02398293f, -0.06236890f, -0.08454566f, -0.05221907f, 0.04786743f, -0.02290555f, -0.05171227f, 
    -0.02508211f, -0.09374002f, -0.04013374f, -0.20129248f, 0.32302088f, -0.26088783f, -0.97607851f, -0.42914823f, 
    -0.00625428f, -0.21795779f, -0.21998212f, -0.06830524f, -0.07169107f, 0.13007991f, 0.02557902f, 0.07416505f, 
    0.01606394f, 0.05203440f, 0.13633196f, 0.07229764f, -0.08667906f, -0.10159834f, -0.06341477f, -0.05616039f, 
    0.19565490f, 0.02255616f, 0.09574476f, -0.08964556f, 0.21838176f, 0.08508504f, 0.12106849f, 0.19224282f, 
    -0.00881568f, 0.01268909f, -0.03672188f, -0.03607199f, 0.08614250f, -0.20780851f, -0.00983952f, 0.08137335f, 
    -0.35376373f, -0.17635363f, 0.18615803f, -0.02215505f, -0.00847541f, 0.20464049f, -0.04005107f, -0.26505584f, 
    -0.20830904f, -0.10145601f, -0.04540855f, 0.01056094f, 0.31495318f, 0.28964236f, -0.54270935f, 0.23348533f, 
    0.17323440f, -0.03349676f, 0.33453384f, 0.11117096f, -0.02884472f, 0.04191319f, 0.01774083f, -0.01594886f, 
    0.28037050f, 0.19803770f, 0.15601514f, 0.21481058f, 0.09421965f, -0.12477924f, -0.01217064f, -0.17000781f, 
    -0.00238002f, -0.14447060f, 0.01076594f, 0.10545606f, -0.46478343f, -0.25207701f, -0.42273679f, -0.36112899f, 
    0.12930882f, 0.23034798f, 0.39945102f, 0.36366653f, -0.01267623f, -0.07445475f, -0.00702162f, -0.08924497f, 
    0.28738233f, -0.03182302f, -0.03896355f, 0.15015319f, -0.05184809f, 0.03908278f, 0.17520274f, 0.09362575f, 
    0.02465408f, -0.07237563f, -0.00270757f, 0.10199906f, 0.45625156f, 0.04026691f, 0.02308290f, -0.13806982f, 
    -0.11353821f, -0.09097002f, -0.13674261f, -0.04864910f, 0.10900997f, 0.01071132f, -0.08157215f, 0.10226116f, 
    0.05226822f, 0.36779472f, 0.38301817f, -0.23506212f, -0.09480626f, 0.06050852f, 0.21599655f, 0.22777350f, 
    0.03616823f, -0.04363270f, -0.01450723f, 0.24167871f, -0.07445653f, 0.21245755f, 0.14093830f, 0.10248699f, 
    -0.17061386f, 0.03744882f, -0.06437142f, -0.07103828f, -0.10930540f, -0.00813600f, -0.01453923f, -0.07184285f, 
    -0.21845707f, -0.52538735f, -0.46795097f, -0.36794201f, -0.02917361f, -0.11907479f, -0.08052205f, -0.12139814f, 
    0.22209612f, 0.01753818f, -0.02810615f, -0.00765664f, 0.28955391f, 0.23878671f, 0.08735511f, 0.25672033f, 
    -0.01902606f, -0.02828292f, -0.01673890f, -0.11408382f, 0.00720023f, 0.01482852f, -0.10266737f, 0.01426420f, 
    -0.00243664f, 0.02790305f, -0.14461732f, -0.06816965f, 0.10042455f, 0.09044906f, -0.05857025f, 0.03612779f, 
    -0.15146077f, 0.08017683f, -0.08321235f, 0.18197508f, 0.04224210f, 0.26943934f, 0.17270719f, -0.26267916f, 
    0.12390867f, 0.17972212f, -0.01573997f, 0.09007342f, -0.05049273f, -0.01820651f, -0.00073335f, 0.15132989f, 
    -0.04116150f, -0.10664805f, -0.06471289f, -0.07482722f, -0.05400211f, -0.04459416f, 0.02974210f, -0.04068428f, 
    -0.06753818f, -0.00253979f, 0.04460645f, 0.00421700f, 0.00579040f, 0.01851591f, 0.06721734f, 0.06565904f, 
    -0.02757363f, -0.04278471f, -0.02304368f, -0.05694876f, 0.04251757f, -0.02199266f, -0.04630709f, 0.03598991f, 
    -0.09636288f, -0.03808137f, -0.05784840f, -0.01318332f, 0.02352530f, -0.03964771f, -0.01365381f, -0.03898916f, 
    0.04836513f, -0.00144467f, 0.02980686f, -0.05630803f, 0.04886499f, -0.07271196f, -0.13264465f, -0.03572064f, 
    -0.02727105f, 0.07710186f, -0.03051521f, -0.04391092f, 0.02373400f, -0.01202096f, -0.07192338f, 0.07922576f, 
    -0.09403206f, -0.11301164f, -0.02854868f, -0.01162437f, 0.05100045f, -0.05960821f, -0.03784231f, 0.02019679f, 
    0.02255304f, -0.09854659f, -0.00506626f, 0.03586962f, 0.00230642f, 0.02856622f, -0.03804814f, -0.03702948f, 
    -0.07227461f, 0.04324686f, 0.06219176f, -0.03936310f, 0.03397151f, -0.01910741f, 0.07302188f, -0.07254858f, 
    0.02870542f, 0.08580131f, -0.01952480f, 0.06185313f, 0.06892890f, -0.08210474f, -0.09490985f, -0.07256081f, 
    -0.00686401f, 0.04085933f, -0.01737140f, 0.04640014f, -0.02838548f, -0.02783077f, -0.03845757f, 0.01933092f, 
    0.01528299f, 0.00485675f, 0.08373776f, 0.04597125f, -0.06455901f, -0.06946966f, 0.01562473f, 0.02471511f, 
    -0.03856802f, 0.00082229f, 0.06513860f, -0.07218084f, 0.02278000f, -0.00812398f, 0.05688698f, 0.03300982f, 
    0.08279378f, 0.02215605f, -0.03504829f, 0.02209029f, -0.09024332f, 0.00293691f, -0.08396599f, -0.06890882f, 
    0.03791904f, 0.06014843f, -0.07035030f, -0.03003265f, -0.02665480f, 0.10306825f, 0.07906213f, -0.04637896f, 
    -0.07485303f, 0.06588461f, 0.01483057f, -0.01501613f, -0.08535132f, -0.04930319f, 0.02262644f, -0.00630467f, 
    -0.00716392f, -0.08202638f, -0.03160369f, 0.02506217f, -0.12321099f, 0.01884927f, 0.01883694f, 0.02460190f, 
    -0.02568286f, 0.02840558f, -0.02279188f, 0.04491714f, -0.04082868f, -0.11210336f, -0.08041690f, 0.10912875f, 
    -0.04584594f, -0.01737108f, -0.01724920f, 0.02802356f, -0.05330360f, -0.07207511f, 0.05442739f, 0.06374732f, 
    0.03528227f, -0.02200975f, 0.04094339f, -0.06285342f, -0.01244787f, 0.08676182f, 0.03367326f, 0.02582289f, 
    0.02168083f, 0.00184534f, -0.06862590f, -0.00640678f, 0.02656992f, 0.01122919f, -0.01104266f, -0.03019431f, 
    -0.05114938f, 0.04349757f, -0.00719153f, -0.01660934f, 0.05477682f, 0.04786568f, -0.08663646f, 0.11450174f, 
    0.01230947f, -0.07794241f, -0.01979600f, 0.03718217f, 0.01940498f, 0.12379140f, 0.03350198f, -0.02295116f, 
    -0.08595927f, -0.02201566f, -0.03921915f, -0.04447889f, -0.01114545f, -0.00165818f, -0.07460646f, 0.00798278f, 
    -0.09995575f, -0.01019517f, 0.07136401f, 0.04238886f, 0.05656725f, -0.18788588f, -0.01478530f, -0.01449389f, 
    0.02610878f, 0.02708441f, -0.13019282f, 0.07401011f, -0.23378582f, -0.11767732f, -0.12827261f, 0.03347243f, 
    -0.10119990f, 0.06914530f, -0.07737859f, 0.05255399f, 0.01715225f, -0.08197846f, 0.10727249f, 0.08243028f, 
    -0.16135000f, 0.26669869f, -0.04876261f, 0.05412951f, 0.08192809f, -0.03447261f, -0.04023768f, 0.03088767f, 
    0.04902072f, 0.09685299f, 0.06461247f, 0.15855686f, -0.24077921f, -0.13321166f, -0.04395346f, -0.07521679f, 
    -0.04487270f, -0.02225645f, -0.15727048f, -0.08947918f, -0.16935657f, -0.02464954f, 0.13552165f, 0.07388504f, 
    0.38832772f, 0.04160244f, -0.16363096f, 0.00862438f, -0.06004567f, -0.14827855f, -0.10425533f, 0.04295476f, 
    -0.03456411f, 0.06808443f, 0.06938498f, -0.08408608f, 0.06275051f, -0.01455998f, 0.27643344f, -0.04126662f, 
    0.08551703f, 0.12470287f, 0.08058354f, 0.07099985f, 0.04551138f, -0.04071949f, 0.01871806f, -0.13652210f, 
    0.04536999f, -0.05868639f, -0.32948890f, 0.00252059f, -0.12829819f, 0.06952524f, 0.03189217f, -0.02247482f, 
    -0.04425083f, 0.03381904f, -0.02705608f, -0.16754505f, 0.01625911f, -0.02745533f, -0.06459788f, -0.11420472f, 
    -0.23560968f, -0.11856386f, -0.04925162f, -0.05504331f, -0.02766427f, -0.14025339f, -0.08454255f, -0.10826559f, 
    -0.10279484f, 0.15113539f, -0.00476232f, -0.14647631f, -0.00854654f, 0.13459530f, 0.07507160f, 0.09181722f, 
    0.03974128f, 0.15856303f, 0.18852225f, -0.07301912f, -0.12224870f, -0.00058289f, 0.14757268f, 0.14899197f, 
    0.04734347f, -0.12705114f, -0.07334309f, -0.00925929f, -0.04577337f, 0.11387565f, 0.08262766f, 0.08182146f, 
    0.09904834f, -0.26691192f, -0.06506744f, -0.05018279f, 0.00038998f, -0.02216088f, 0.07830440f, -0.14140119f, 
    0.05478367f, 0.09794337f, 0.09906118f, -0.03860799f, -0.14050344f, 0.12801534f, -0.10448480f, -0.05204327f, 
    0.08932735f, 0.00440131f, -0.04779402f, -0.04533861f, 0.23340258f, 0.15541133f, 0.23119852f, 0.16444547f, 
    -0.18721780f, 0.12713082f, 0.21772976f, 0.36671999f, -0.02424470f, -0.07035702f, 0.04919838f, 0.06988207f, 
    -0.03754054f, 0.04478372f, 0.08927189f, 0.03771493f, -0.06459653f, 0.05730452f, -0.01618922f, 0.05160530f, 
    0.07274637f, 0.09295747f, 0.04843849f, 0.06463294f, -0.04455393f, -0.00058721f, -0.08158089f, -0.14154258f, 
    -0.24295370f, 0.03634219f, 0.03759104f, -0.09060315f, -0.13621157f, -0.06555296f, -0.00788771f, -0.02946162f, 
    0.24531017f, 0.14116186f, 0.09207992f, -0.10690759f, -0.09596575f, -0.19560419f, -0.22486229f, -0.07115948f, 
    -0.07289007f, -0.04619181f, -0.07167955f, 0.02676275f, -0.05009575f, 0.01252837f, -0.02222519f, 0.14286979f, 
    -0.27259484f, -0.06545582f, -0.11776987f, 0.12476689f, 0.17312534f, -0.02084141f, -0.06255375f, -0.07018290f, 
    -0.37806404f, -0.40194109f, -0.27710718f, -0.38335204f, -0.11392490f, -0.03679276f, 0.05444119f, 0.17416407f, 
    -0.02645506f, 0.08259249f, -0.02674924f, 0.15890171f, 0.19058482f, 0.04207251f, 0.04887300f, 0.27358848f, 
    -0.09379963f, 0.29072502f, -0.05222547f, 0.14481519f, -0.00039900f, -0.15685008f, -0.28881073f, -0.13765118f, 
    -0.09417406f, -0.25378910f, -0.16266800f, -0.21781337f, -0.22604433f, -0.14091259f, 0.09560947f, 0.15342695f, 
    0.10940590f, -0.05189549f, -0.52976906f, -0.26410791f, -0.23062000f, -0.18508993f, -0.08830101f, -0.11366387f, 
    -0.11728386f, -0.13135819f, -0.01633985f, 0.06554825f, 0.09115365f, -0.06306769f, -0.11319005f, -0.01552519f, 
    -0.33528179f, -0.31141141f, -0.18690018f, -0.26820955f, 0.27257347f, 0.21841128f, 0.14803395f, 0.30330715f, 
    0.01933062f, 0.09089611f, 0.08805817f, 0.11452183f, 0.09940988f, -0.03461770f, -0.10020775f, -0.31504211f, 
    -0.05250029f, -0.15323445f, -0.41602150f, -0.02453246f, -0.04208783f, 0.23896678f, 0.29972583f, -0.30854523f, 
    -0.25167122f, -0.16205923f, -0.17216335f, -0.23250623f, 0.07995507f, 0.18473706f, 0.09695781f, 0.09896257f, 
    -0.10886397f, -0.25116220f, -0.11326165f, 0.20065263f, -0.03902042f, -0.15517239f, -0.08146074f, -0.22093458f, 
    0.08043259f, 0.16694690f, -0.04118119f, -0.01606116f, 0.01251040f, -0.05911308f, 0.31677961f, -0.04515028f, 
    0.24141751f, 0.18276493f, 0.25178361f, 0.18500161f, 0.18276480f, 0.11848447f, 0.39225563f, 0.48077938f, 
    0.07062716f, -0.03627955f, -0.22612286f, -0.11117427f, -0.00470637f, 0.05593798f, -0.03793649f, -0.07056132f, 
    0.19217241f, 0.07406311f, 0.12662435f, 0.10355149f, -0.03402614f, -0.11070031f, 0.01206269f, -0.14000510f, 
    0.10985594f, 0.27372110f, 0.03535360f, 0.29072291f, -0.15807448f, 0.12458389f, 0.05114403f, 0.24653810f, 
    -0.09666935f, -0.01040254f, 0.05913445f, -0.06103557f, 0.05801237f, 0.19244838f, 0.11221451f, 0.34247863f, 
    0.13614091f, 0.22168481f, 0.31395194f, 0.31113565f, -0.05866384f, -0.12572135f, 0.05207263f, 0.06138448f, 
    0.09062042f, 0.03582305f, 0.12348300f, 0.18184485f, -0.18216257f, 0.08715175f, -0.29747176f, 0.05259864f, 
    0.07101339f, 0.21045822f, 0.20834942f, 0.01950422f, -0.13821658f, -0.36388758f, -0.24632709f, -0.24932548f, 
    -0.12382057f, 0.00810415f, -0.05528884f, -0.09464357f, -0.11293451f, -0.25254384f, 0.02168529f, -0.17634627f, 
    0.23837495f, 0.17365977f, 0.11248628f, -0.16430880f, 0.10097717f, 0.00065857f, 0.01157130f, 0.01199079f, 
    0.08732730f, 0.09302057f, -0.05817345f, 0.10185456f, -0.10847075f, 0.13188763f, 0.00370422f, 0.12745184f, 
    0.09583430f, 0.11717107f, 0.11168239f, 0.01494601f, 0.15066382f, 0.10178664f, 0.04844732f, 0.13440835f, 
    0.03754828f, -0.00593621f, -0.05704257f, -0.05542732f, 0.19736955f, 0.42693940f, 0.21223274f, 0.31825027f, 
    0.17059703f, -0.13300124f, -0.10546849f, -0.02437079f, 0.04679633f, -0.05507573f, -0.02289840f, 0.11137061f, 
    -0.31569523f, 0.00001135f, -0.17008542f, -0.07444749f, 0.18934129f, 0.08723627f, 0.06453405f, -0.07259975f, 
    -0.00704845f, -0.14041241f, 0.08997719f, -0.00775247f, -0.19839966f, -0.26745021f, -0.33873877f, -0.02675199f, 
    0.12998025f, 0.03267066f, -0.02958639f, -0.04584010f, 0.00302848f, 0.13445202f, 0.09920117f, 0.04500192f, 
    -0.15580940f, 0.13833334f, 0.17485265f, 0.18040897f, 0.17497650f, -0.04657404f, 0.09868112f, 0.04074918f, 
    -0.03901249f, 0.03360571f, 0.04689984f, -0.09601867f, 0.58192527f, 0.53534108f, 0.24303094f, -0.13475792f, 
    -0.09848548f, 0.08460153f, 0.08933503f, 0.10872915f, -0.07350843f, 0.02219395f, -0.06138771f, 0.01683988f, 
    -0.01043489f, -0.34672219f, -0.16807811f, -0.01857876f, 0.09625588f, -0.07447784f, -0.09430844f, 0.08946869f, 
    0.09882578f, 0.01790789f, -0.03868200f, -0.00233662f, 0.31502959f, 0.28933313f, 0.35560492f, 0.28302106f, 
    0.05559167f, 0.17173898f, 0.20743418f, 0.00370606f, 0.09074380f, -0.05270263f, -0.08328105f, -0.07981110f, 
    -0.02504736f, -0.04815243f, 0.00635879f, -0.19049220f, -0.07524993f, 0.05444713f, -0.13198960f, -0.05145079f, 
    0.04385111f, 0.02256656f, 0.09984244f, 0.22435251f, 0.01763852f, -0.15364197f, -0.27689660f, -0.01450455f, 
    0.06409310f, 0.06799638f, -0.07329607f, 0.00523628f, 0.04352646f, 0.04305145f, 0.08743751f, 0.12423849f, 
    0.30005929f, 0.21174978f, 0.09292913f, 0.24636832f, -0.10762211f, -0.12012611f, 0.05850820f, 0.05304779f, 
    -0.06337206f, -0.13607630f, -0.00469383f, 0.12568006f, -0.21403652f, -0.15822086f, -0.19622877f, 0.13987310f, 
    0.04175153f, 0.00570314f, -0.12647875f, -0.04154073f, -0.12241899f, 0.06095789f, -0.07421266f, -0.18433909f, 
    0.23989792f, 0.22279923f, 0.04634837f, 0.04528031f, 0.11736482f, -0.06475145f, 0.08914157f, -0.09117344f, 
    0.17449415f, -0.08124700f, -0.10464264f, 0.08594703f, 0.07659949f, -0.19449712f, -0.36392027f, -0.21667311f, 
    -0.04973019f, -0.12006362f, -0.07329484f, -0.18111606f, 0.01611734f, 0.02288641f, 0.01497664f, -0.00933435f, 
    -0.05270126f, 0.01011793f, -0.06288932f, 0.12902029f, 0.16680147f, -0.05211117f, -0.25166205f, 0.13880411f, 
    -0.09408725f, 0.15401605f, -0.01825536f, 0.23145652f, 0.03220168f, 0.03890562f, 0.46720189f, 0.28341323f, 
    -0.23709713f, 0.00584618f, -0.01348991f, -0.00655877f, 0.05794567f, 0.01284900f, -0.01297821f, -0.12515713f, 
    -0.03108009f, -0.12596726f, -0.10459720f, -0.07468752f, 0.14228591f, 0.07220777f, -0.03252003f, -0.08005143f, 
    0.05376577f, 0.19509587f, -0.03429079f, 0.17314155f, 0.35216859f, -0.01993606f, -0.28041324f, 0.17563741f, 
    0.11755633f, 0.13563353f, 0.18505535f, -0.12708424f, -0.05671711f, 0.02463198f, 0.01159447f, 0.04404168f, 
    0.06877098f, -0.17842755f, 0.27356142f, -0.04401342f, -0.22155714f, -0.00105734f, -0.08721326f, 0.01733909f, 
    0.10182416f, 0.07074785f, 0.08645757f, 0.15632655f, -0.05603056f, -0.02695228f, 0.07080043f, -0.09114803f, 
    -0.16539706f, -0.08542211f, -0.10887444f, -0.19990747f, 0.11282682f, -0.03181195f, -0.01128823f, 0.26348135f, 
    0.09333085f, 0.33971855f, 0.04355925f, -0.14357430f, -0.08127716f, -0.03106666f, -0.07407988f, -0.11501242f, 
    0.03077428f, 0.23709068f, 0.08392420f, 0.24912974f, 0.03227914f, -0.32354262f, -0.02309619f, 0.12304968f, 
    -0.02985550f, -0.05432762f, 0.18234441f, 0.06576398f, 0.01318882f, 0.07632484f, -0.11438377f, 0.11916976f, 
    -0.16848762f, 0.30522496f, -0.03581705f, -0.07663970f, -0.22626968f, -0.10318691f, -0.13384116f, -0.02764795f, 
    -0.20814094f, -0.04549425f, -0.05124495f, 0.06406973f, 0.10753932f, -0.08968473f, -0.14282143f, -0.08823097f, 
    0.10610483f, 0.17935082f, -0.05982285f, 0.08920445f, -0.25235260f, -0.09425802f, 0.00950327f, -0.01293221f, 
    -0.11877808f, -0.18733640f, -0.16507071f, 0.14747751f, -0.09564734f, -0.01517650f, 0.04591741f, 0.13617185f, 
    -0.15129940f, 0.09469125f, -0.09354261f, -0.06190858f, -0.40021768f, 0.16542129f, -0.10680967f, -0.15099508f, 
    0.01216057f, -0.13923219f, 0.18390276f, -0.20852628f, 0.07903855f, 0.15134709f, 0.10672982f, 0.17979088f, 
    0.02217900f, 0.16347671f, -0.21607713f, -0.02564014f, -0.04858563f, 0.17121604f, 0.02046782f, 0.24759915f, 
    -0.09425726f, 0.01493391f, -0.06941729f, 0.20571128f, 0.15075749f, 0.27731761f, 0.11213072f, -0.54699975f, 
    0.02021303f, -0.05033560f, -0.01656983f, 0.05408650f, -0.30069146f, -0.10934954f, -0.00556269f, -0.04895956f, 
    0.13994251f, -0.22490688f, 0.08560176f, 0.04062875f, 0.01381815f, 0.21668841f, -0.08410028f, 0.17814359f, 
    -0.02574582f, 0.17288132f, 0.05455735f, 0.07350904f, -0.05048769f, -0.18702418f, 0.36991885f, 0.14825761f, 
    -0.08880576f, -0.00546068f, -0.07272432f, -0.28282017f, -0.10938371f, -0.00240650f, 0.02627098f, -0.01899268f, 
    0.12491734f, -0.14438793f, -0.04378423f, 0.03492570f, 0.00381240f, 0.04498657f, 0.27252570f, 0.11091217f, 
    -0.11636627f, 0.00303375f, -0.03737443f, 0.15178706f, 0.16610320f, 0.02162043f, -0.17106692f, -0.11362839f, 
    0.09389542f, 0.07063860f, 0.11204934f, 0.02951178f, 0.03261531f, 0.09113359f, 0.01734748f, 0.09688555f, 
    -0.04855875f, -0.06936675f, -0.08331224f, -0.12318701f, -0.02515136f, 0.05631901f, 0.19071850f, 0.09440793f, 
    0.03188866f, 0.06177006f, 0.05334529f, -0.01619628f, -0.01278347f, 0.06957670f, 0.12045911f, -0.27192953f, 
    -0.03705858f, -0.12266796f, -0.05086276f, 0.18145734f, 0.00838755f, -0.05292968f, -0.10424981f, -0.16218981f, 
    -0.00814328f, 0.02703676f, -0.01232961f, 0.08563319f, -0.00254124f, -0.01281993f, 0.04348622f, 0.04078674f, 
    0.06444017f, 0.39258754f, -0.01299130f, 0.23379621f, -0.02741917f, 0.10305841f, -0.07181812f, -0.00071173f, 
    -0.09094148f, 0.01880653f, -0.06510770f, 0.03469555f, 0.18660696f, -0.01097141f, -0.00341460f, 0.06659264f, 
    -0.19135489f, -0.03637915f, -0.04312760f, 0.16719279f, 0.11904218f, 0.05680484f, -0.04924040f, 0.05872922f, 
    -0.04405432f, 0.26408115f, -0.03429034f, 0.14827624f, -0.10651829f, 0.03736569f, -0.14686517f, -0.31472862f, 
    0.02626029f, 0.00086549f, 0.15109949f, -0.01303555f, -0.09422609f, 0.02664267f, 0.04095812f, 0.00316530f, 
    0.11360457f, -0.12150344f, 0.28887922f, 0.03781400f, 0.09039339f, 0.06715015f, -0.05882832f, -0.00896388f, 
    0.03640468f, -0.04197502f, 0.10050310f, -0.02495069f, -0.23619117f, -0.21592794f, -0.04775596f, -0.05640081f, 
    0.12505436f, 0.05027880f, 0.12064865f, -0.03127541f, -0.06752799f, 0.04308117f, -0.03871109f, 0.01165909f, 
    0.10895706f, 0.10262274f, -0.07531237f, -0.09199172f, 0.01995638f, 0.08394033f, 0.01622242f, -0.02016168f, 
    0.15194595f, -0.09531263f, -0.06969405f, -0.15656884f, 0.08136963f, -0.23209539f, 0.27726790f, -0.10972405f, 
    -0.03677133f, -0.07085881f, 0.00152663f, -0.06094767f, 0.09811013f, -0.04902681f, 0.00015801f, 0.07515410f, 
    -0.15096493f, -0.14672844f, 0.06266080f, 0.03562989f, -0.16916548f, 0.11692804f, 0.07056919f, 0.13444741f, 
    0.14929207f, 0.09769809f, 0.04657643f, -0.19795062f, 0.09076407f, -0.34408772f, 0.02669331f, 0.21142097f, 
    -0.03085169f, -0.04207067f, -0.06980487f, -0.00543012f, 0.12715206f, -0.00343351f, -0.08744657f, -0.21180731f, 
    -0.41040719f, 0.01926013f, 0.04390371f, -0.21242218f, -0.01567933f, 0.09262052f, 0.13294673f, -0.00569898f, 
    0.15455933f, 0.13012910f, 0.06988480f, -0.13384223f, 0.27275005f, 0.22454694f, -0.11753146f, 0.16937773f, 
    -0.01873351f, 0.06682389f, 0.04355184f, -0.10293710f, 0.04064612f, -0.08448941f, 0.10020693f, 0.04688968f, 
    -0.06790770f, 0.16926621f, -0.07295292f, -0.13964950f, 0.04249002f, 0.05224755f, 0.37816021f, 0.22972205f, 
    0.07114933f, -0.11337671f, -0.24539062f, 0.11354364f, -0.02847205f, 0.13797408f, 0.19871166f, 0.09119477f, 
    0.04277104f, 0.00841278f, 0.27952397f, 0.12833631f, 0.09223226f, 0.01850739f, 0.01553492f, 0.20437899f, 
    -0.12160906f, -0.07589155f, -0.09584553f, 0.02859200f, -0.14727448f, 0.07637113f, 0.10986853f, -0.04671704f, 
    -0.03428676f, 0.02780309f, -0.07060372f, -0.09712797f, -0.28591835f, 0.04828157f, 0.06856854f, -0.08333731f, 
    -0.11423676f, -0.11385436f, -0.11187910f, 0.12065534f, -0.00196721f, -0.08860725f, 0.09937876f, 0.03927395f, 
    -0.28214380f, -0.02215185f, -0.34229362f, 0.01134950f, -0.00977143f, -0.10874409f, 0.05433271f, -0.03492225f, 
    0.05447739f, 0.16191977f, -0.03815996f, 0.18040532f, -0.14544722f, 0.03322083f, -0.34148109f, -0.11909614f, 
    -0.08785947f, -0.09561991f, 0.01023902f, 0.02294272f, 0.02119008f, 0.18218562f, 0.12879996f, 0.07646225f, 
    0.29092991f, -0.13491040f, 0.17299840f, 0.04915044f, 0.15671571f, -0.02515490f, -0.01879340f, 0.12721315f, 
    0.08112135f, -0.11273044f, 0.08321530f, 0.06821518f, -0.04490657f, 0.07729390f, 0.38912198f, -0.03300709f, 
    0.04615096f, 0.16757636f, -0.20707572f, -0.01319335f, -0.06429183f, -0.06759816f, 0.09799057f, -0.03547622f, 
    0.39292121f, 0.01324041f, 0.01353386f, 0.36404738f, -0.02781469f, -0.02341477f, -0.07283281f, -0.01800257f, 
    -0.09454813f, -0.10780995f, -0.13064173f, 0.00055101f, 0.07044355f, -0.04218591f, 0.09821379f, 0.04933286f, 
    0.01875707f, 0.01695176f, 0.00042105f, -0.00007731f, 0.07452696f, 0.02116466f, -0.13944766f, 0.06091339f, 
    -0.02355802f, -0.02321624f, 0.04809296f, -0.08061627f, -0.03122054f, 0.19781984f, -0.15406895f, -0.00003555f, 
    0.27966440f, -0.17039149f, 0.00213696f, -0.10269950f, -0.33112204f, -0.24679314f, -0.28377923f, 0.00074361f, 
    -0.06469931f, -0.07648508f, 0.04613214f, 0.10874324f, 0.07662624f, -0.07558705f, 0.07635882f, 0.10065584f, 
    0.09081790f, -0.14939944f, 0.25667340f, 0.05359172f, 0.13639970f, -0.12411734f, -0.05811873f, -0.13493130f, 
    0.03807355f, -0.05129414f, 0.17495723f, 0.05519693f, -0.01368635f, -0.19915397f, 0.04887224f, 0.11126719f, 
    0.09957529f, 0.03443131f, 0.02330177f, -0.04704370f, 0.00425456f, -0.04008048f, 0.00019110f, 0.05581064f, 
    -0.39580277f, 0.11808103f, -0.03251002f, -0.03012085f, -0.01518441f, -0.08094809f, 0.09557213f, 0.07592740f, 
    0.21378663f, 0.00955289f, 0.00951983f, -0.01342306f, 0.26195976f, -0.14247318f, 0.20890383f, 0.12014714f, 
    0.00016694f, 0.05821431f, -0.10873710f, 0.16578691f, -0.15960889f, -0.05908969f, -0.07053829f, -0.09417682f, 
    -0.18404832f, 0.21672320f, 0.11794779f, -0.27500772f, 0.18928409f, 0.00441690f, -0.02234704f, 0.24643706f, 
    0.22157940f, -0.00224118f, 0.24672107f, -0.09424067f, -0.00913044f, 0.05579894f, 0.19534688f, 0.06512903f, 
    -0.19504252f, -0.00327196f, -0.03608226f, 0.06409826f, 0.14421259f, 0.12255546f, 0.03980301f, 0.07624952f, 
    0.04839751f, -0.02198672f, -0.05981298f, 0.07248493f, 0.02635848f, -0.04227671f, 0.21742520f, -0.12530729f, 
    0.12223783f, -0.06275693f, 0.02600663f, 0.11369895f, -0.40574896f, -0.01934377f, 0.14516586f, -0.06718066f, 
    -0.16015512f, -0.16445681f, -0.11366148f, 0.22118771f, 0.02671929f, 0.07205022f, 0.02923601f, 0.02525072f, 
    0.09780011f, 0.33631670f, 0.06497463f, 0.03716950f, 0.06695094f, -0.09144683f, -0.03841803f, 0.03775473f, 
    0.02934246f, 0.11161311f, -0.02243553f, -0.03104999f, 0.14264673f, -0.03869378f, 0.12346372f, -0.00965193f, 
    0.11340525f, -0.04400227f, 0.02874820f, 0.02524963f, 0.02329464f, 0.02332090f, 0.06337358f, 0.08675624f, 
    0.00817103f, -0.43188021f, 0.25380245f, 0.22398536f, 0.03695847f, 0.06814880f, -0.15725656f, 0.12545827f, 
    -0.06361545f, -0.17132035f, 0.11548962f, -0.20820948f, 0.00166648f, 0.16379353f, 0.05037827f, -0.05234930f, 
    0.06932360f, 0.12780620f, -0.05061124f, 0.19136390f, 0.08613438f, -0.09490150f, -0.03287974f, -0.05629139f, 
    0.21872747f, -0.11715121f, 0.00786105f, 0.08703197f, 0.05415687f, 0.15255484f, 0.20306151f, -0.03362467f, 
    0.00838617f, -0.05541378f, 0.01714351f, -0.12642735f, -0.09928545f, -0.05396246f, 0.04870936f, -0.11194954f, 
    -0.21099128f, -0.23582564f, -0.05825966f, 0.06652362f, 0.10810440f, 0.05990285f, 0.03597132f, 0.07910954f, 
    0.25622538f, 0.16889399f, 0.09940684f, -0.09165024f, -0.03097900f, -0.09266233f, 0.23264162f, -0.01203229f, 
    0.04389674f, -0.13660404f, 0.07936916f, -0.05062539f, 0.18910560f, 0.02637761f, 0.26802456f, 0.11637317f, 
    -0.07756986f, 0.01816706f, -0.18030061f, 0.04807905f, 0.11902197f, -0.02131991f, -0.00754055f, 0.06498875f, 
    0.00781380f, -0.17152451f, 0.16313779f, 0.04374767f, 0.06952966f, 0.16289763f, 0.07964149f, -0.17080982f, 
    0.03869264f, -0.01089821f, 0.27273783f, 0.06095408f, -0.04819336f, 0.07802682f, 0.02375665f, 0.18021734f, 
    -0.05465557f, -0.04379769f, -0.03770985f, -0.02055541f, 0.28078747f, 0.15571611f, -0.02179949f, 0.10979629f, 
    0.04603045f, 0.25569537f, 0.16606575f, -0.11386826f, -0.19045013f, -0.28914315f, 0.16905600f, 0.13041535f, 
    0.05453344f, -0.00913716f, 0.07357977f, 0.09258082f, -0.06098907f, 0.09883901f, -0.36306477f, -0.04258647f, 
    0.07475327f, 0.11049799f, 0.09877857f, 0.24182385f, -0.00748014f, -0.06707332f, -0.02575148f, -0.06205000f, 
    -0.05124905f, 0.01974442f, 0.17394699f, -0.15904517f, -0.10514471f, -0.16660488f, 0.13066851f, 0.03946624f, 
    0.09129094f, 0.10953680f, 0.14433871f, -0.22404206f, -0.20600873f, -0.06655882f, -0.08227719f, 0.08837887f, 
    -0.12445444f, 0.02728523f, -0.04559299f, 0.01397481f, -0.16193095f, 0.09420938f, 0.00978992f, 0.25128207f, 
    0.00267731f, -0.02379555f, -0.03910555f, -0.07603978f, 0.11010442f, -0.02008178f, 0.40709966f, 0.10304650f, 
    0.00566499f, 0.06648910f, 0.01951094f, 0.08221085f, -0.15145883f, -0.58935004f, -0.58690166f, -0.14920330f, 
    -0.18524516f, -0.16655789f, 0.00997909f, 0.23424105f, -0.16303478f, 0.02797023f, -0.02014277f, -0.12017047f, 
    0.24683826f, 0.19514422f, 0.03014125f, 0.00293061f, -0.06994586f, 0.10139711f, 0.08149672f, 0.02797376f, 
    0.19174047f, -0.02581979f, 0.05812896f, 0.15191686f, 0.25294292f, 0.18556800f, 0.11855219f, -0.03579096f, 
    0.00230954f, -0.03586077f, -0.06621473f, -0.03874307f, 0.21896207f, -0.08470592f, 0.04231191f, -0.16013561f, 
    0.40575713f, 0.07273546f, -0.08116271f, -0.05358162f, -0.05584304f, 0.23675850f, -0.05158141f, -0.11431997f, 
    0.05510104f, 0.01176790f, -0.02276848f, -0.02571438f, -0.14830913f, 0.01470237f, 0.03285799f, 0.11604223f, 
    0.28887573f, 0.02056025f, 0.31168064f, 0.20646937f, 0.05842628f, 0.03413591f, 0.00017865f, 0.10931367f, 
    0.06769522f, 0.20256303f, 0.04604275f, 0.09459471f, 0.05708990f, 0.02443050f, -0.02540975f, -0.04285497f, 
    -0.01073120f, 0.13025224f, 0.00845105f, 0.07138118f, -0.42500746f, -0.40714520f, -0.34281105f, -0.33892560f, 
    0.03323206f, 0.05066416f, 0.21950348f, 0.13319333f, -0.03711864f, 0.01732666f, 0.01174467f, 0.02259726f, 
    0.03156939f, 0.05538114f, 0.06396458f, 0.06073078f, -0.02867143f, 0.09597095f, 0.25357771f, 0.21591280f, 
    -0.13132657f, 0.00369032f, -0.15713573f, 0.03690201f, 0.51176691f, -0.08642380f, 0.12043028f, -0.09794509f, 
    -0.12868293f, -0.03245948f, 0.00582073f, -0.11738620f, 0.23888291f, 0.17697930f, -0.03345676f, -0.20359467f, 
    -0.05551774f, -0.31683859f, -0.22043997f, -0.32382149f, -0.06576484f, 0.13413824f, 0.17636530f, 0.00618812f, 
    0.01862379f, 0.05841056f, 0.02968592f, -0.01839907f, 0.28441289f, -0.01508939f, -0.03302538f, 0.07375585f, 
    -0.04929299f, 0.05063916f, -0.01530456f, -0.09236412f, 0.11308007f, 0.02368232f, 0.16200304f, -0.09001765f, 
    -0.48928040f, -0.52938324f, -0.11664002f, -0.09977724f, -0.19619398f, -0.00036078f, -0.06589071f, 0.10001766f, 
    0.05631036f, -0.00039495f, 0.07835450f, -0.13622245f, 0.18828674f, 0.28909466f, 0.23292834f, 0.41408736f, 
    0.11101009f, -0.01015260f, 0.09619716f, -0.06787264f, -0.02197435f, -0.04041060f, 0.05104075f, 0.00697716f, 
    -0.19371687f, 0.01500790f, -0.11576276f, -0.11500803f, -0.16353661f, 0.27557737f, 0.16393395f, -0.07691696f, 
    -0.15471493f, -0.10475360f, -0.21156695f, 0.17671634f, 0.03969265f, -0.14593618f, -0.28807351f, -0.30032453f, 
    0.05174240f, -0.12107375f, 0.01515204f, -0.03486484f, 0.02938620f, -0.01075926f, -0.09968672f, 0.04313966f, 
    -0.06413763f, -0.03104481f, -0.07070331f, -0.17504165f, 0.00046863f, -0.03876646f, -0.03656661f, 0.10619106f, 
    -0.03131960f, 0.11311686f, -0.03321102f, 0.00496960f, 0.08300956f, 0.04549525f, -0.11312261f, 0.12225830f, 
    0.10082499f, 0.08729877f, 0.04610048f, -0.11362201f, -0.09106764f, -0.11578187f, -0.01116506f, -0.17147820f, 
    0.11972637f, 0.04287941f, -0.03478034f, -0.08820561f, -0.06774138f, 0.05662176f, 0.02511697f, -0.03154181f, 
    0.17282313f, 0.00673332f, 0.08551411f, 0.11003203f, -0.00774417f, 0.13801444f, -0.16925026f, -0.09453668f, 
    -0.05498916f, -0.05634941f, 0.04847204f, -0.04162305f, 0.16050372f, 0.23118877f, 0.09863670f, -0.07802425f, 
    0.22956353f, 0.06387880f, -0.40771636f, 0.05852683f, 0.09870221f, 0.02667791f, 0.04270067f, -0.06067524f, 
    0.16708018f, 0.07301477f, 0.00651137f, 0.04023629f, -0.05101074f, -0.17207040f, 0.35410354f, 0.22823738f, 
    -0.13507432f, -0.01410714f, -0.07225603f, 0.02694739f, 0.00825232f, 0.05834295f, -0.08233843f, 0.03791394f, 
    0.01546423f, 0.20105436f, 0.34516269f, 0.00218008f, -0.16902786f, -0.13007523f, -0.13752764f, -0.11150374f, 
    -0.03518315f, 0.02038987f, 0.00401574f, -0.00988347f, -0.06863828f, -0.21502650f, 0.00965425f, 0.08141102f, 
    0.15344740f, 0.15303878f, 0.09718724f, 0.04003220f, -0.13544437f, -0.01763703f, -0.06202415f, -0.03117861f, 
    -0.13772470f, 0.10072003f, 0.14061752f, -0.00117228f, -0.10558569f, 0.08503262f, -0.00598592f, 0.03702382f, 
    0.00899148f, 0.18696173f, -0.06505054f, -0.10801531f, -0.03550272f, -0.07526927f, -0.02412912f, -0.14688614f, 
    -0.01077147f, -0.12441327f, -0.01369474f, -0.04898448f, 0.01671037f, 0.03634450f, 0.09793951f, -0.02560697f, 
    -0.05384317f, -0.05635854f, -0.13102549f, 0.12655477f, -0.00374785f, 0.04283403f, 0.11233339f, 0.21255842f, 
    -0.01166744f, -0.01486085f, -0.02145403f, -0.09719512f, 0.16540833f, 0.30956116f, -0.12694383f, -0.07078885f, 
    0.01452972f, 0.03393197f, -0.13383092f, -0.10841514f, -0.06614678f, -0.07518541f, 0.05367879f, -0.05815876f, 
    0.06817249f, -0.11934616f, -0.07723128f, 0.10759313f, 0.02561867f, -0.00689948f, -0.09783998f, 0.12252540f, 
    -0.02542449f, 0.11859903f, -0.00723504f, -0.01396363f, 0.20901969f, 0.05329859f, 0.31282455f, 0.14792903f, 
    -0.08774139f, -0.21133478f, -0.06829764f, -0.07395038f, 0.00487727f, 0.04929318f, 0.04155968f, -0.02841241f, 
    0.02576888f, -0.14283490f, 0.29202333f, -0.01340248f, 0.11171709f, 0.04390831f, -0.03180569f, -0.13643217f, 
    -0.02521992f, -0.12173931f, -0.07210908f, 0.24632666f, -0.17465182f, -0.02309093f, 0.04753841f, 0.15967751f, 
    0.12559794f, -0.07931742f, 0.08285538f, 0.07903849f, 0.07802823f, -0.06180789f, 0.02960069f, -0.11728749f, 
    0.03243525f, 0.01897316f, -0.09763285f, -0.01863161f, -0.10657531f, 0.11818764f, -0.00172449f, 0.00705026f, 
    0.33157575f, -0.04116819f, -0.01120982f, 0.03217174f, -0.02762896f, 0.08273435f, -0.14443198f, -0.21146847f, 
    -0.14289255f, -0.06816174f, -0.05082164f, 0.15510274f, 0.00219425f, 0.01637446f, -0.20747989f, -0.14574802f, 
    -0.32789850f, 0.06866881f, -0.34028593f, -0.04495203f, -0.03599418f, -0.16526476f, 0.08700345f, 0.06526622f, 
    0.03606386f, 0.16244960f, 0.03284499f, 0.28559923f, 0.11451890f, 0.11880805f, -0.11049275f, 0.06762828f, 
    -0.17844288f, -0.13548854f, -0.01258766f, 0.06827389f, 0.01174690f, 0.00485534f, 0.07761626f, 0.12950954f, 
    0.29426453f, -0.03104126f, 0.11118463f, 0.13290243f, 0.13081324f, -0.01431325f, -0.02612507f, 0.14444239f, 
    -0.06025118f, 0.01638728f, 0.08229210f, -0.05949525f, 0.03641172f, -0.03301958f, 0.19072531f, -0.02557131f, 
    0.06036483f, -0.09669863f, -0.20168886f, 0.10759742f, 0.04479110f, -0.05528188f, -0.09008218f, -0.17816408f, 
    0.06104061f, 0.06096565f, -0.15660109f, 0.08659878f, 0.12609310f, -0.10267185f, -0.04369741f, 0.06477173f, 
    0.19010848f, -0.04918212f, -0.03218391f, -0.01686032f, 0.14596716f, 0.11954317f, 0.08060048f, 0.10941934f, 
    0.04002200f, 0.03681298f, -0.07286631f, -0.10503126f, 0.13381486f, -0.01215541f, -0.15072195f, 0.11929768f, 
    0.04581579f, 0.02385233f, -0.04354724f, -0.06216828f, 0.11453800f, -0.06945424f, -0.36922067f, 0.01083711f, 
    0.21134503f, -0.11230666f, -0.00390168f, -0.06624271f, 0.13757139f, -0.26074427f, 0.25101984f, -0.06587385f, 
    0.13237725f, -0.13433304f, -0.13847369f, 0.09898569f, 0.05952578f, -0.02636355f, 0.15501814f, -0.12952113f, 
    0.17390849f, -0.04072488f, 0.25109720f, 0.08035050f, -0.08302014f, -0.05220262f, -0.09389830f, -0.35404146f, 
    -0.00275965f, -0.22138052f, 0.03184286f, -0.28391454f, -0.25844067f, -0.00005061f, -0.06123675f, 0.06115004f, 
    -0.11116900f, 0.08015625f, 0.00744609f, -0.15108903f, -0.10349908f, -0.26502132f, 0.12443355f, -0.02894294f, 
    -0.27596316f, -0.01683653f, -0.09494328f, 0.05329980f, -0.05288367f, -0.11160383f, 0.03450736f, 0.02789108f, 
    0.07567319f, -0.03210895f, -0.03029343f, 0.04592278f, 0.20349468f, -0.05235598f, -0.34607080f, -0.08489417f, 
    -0.06029867f, 0.03814881f, 0.04630709f, 0.20573719f, -0.03240358f, -0.09568197f, -0.13008969f, -0.21920162f, 
    -0.10778012f, 0.53507686f, 0.03266931f, -0.06740695f, 0.14344253f, -0.00009818f, 0.12699035f, 0.00033381f, 
    0.23454300f, 0.10210575f, 0.27378613f, 0.15891176f, 0.12666550f, 0.19481489f, 0.21854843f, 0.09727904f, 
    -0.12833847f, 0.00621596f, -0.02871349f, 0.08478275f, -0.04454965f, 0.02299676f, -0.08711529f, 0.04813101f, 
    -0.01114227f, 0.06590076f, 0.03427972f, 0.06154086f, -0.01226084f, -0.06388255f, 0.04291812f, 0.05670250f, 
    -0.03852560f, 0.02440989f, 0.01627034f, -0.05022371f, 0.04477630f, -0.01112594f, 0.00258400f, -0.06641012f, 
    0.02880373f, 0.03145256f, -0.06734972f, -0.03105341f, 0.02671412f, -0.01013272f, -0.06006020f, -0.04800413f, 
    0.00307062f, -0.00686677f, 0.05202488f, -0.02732476f, 0.07146125f, -0.07159024f, -0.05880137f, 0.03906485f, 
    0.05358453f, -0.06788050f, -0.05663129f, -0.03345578f, -0.02333078f, -0.00978040f, 0.03545595f, 0.00097810f, 
    0.06840175f, -0.00994616f, -0.03773503f, -0.04747051f, -0.02434097f, -0.06461943f, 0.00564174f, -0.06672882f, 
    -0.00572196f, 0.00494564f, -0.00174572f, -0.05347460f, -0.00258249f, 0.02458208f, -0.00160317f, -0.04705568f, 
    -0.02374817f, -0.06853884f, -0.05273007f, -0.01728916f, -0.01671976f, -0.07008619f, -0.03017236f, 0.04402996f, 
    -0.06252844f, -0.07109802f, 0.01657141f, 0.05047445f, -0.06967112f, -0.03286606f, -0.03076851f, 0.04433332f, 
    0.01818451f, 0.06002704f, -0.04395640f, 0.03065446f, 0.00646046f, 0.03325982f, 0.05469887f, -0.01904966f, 
    -0.05620774f, -0.07126904f, -0.01313190f, -0.01043867f, 0.04346180f, -0.03768206f, 0.06408289f, 0.00784766f, 
    -0.02904714f, 0.06682904f, 0.02478483f, -0.03811891f, 0.04104110f, 0.01922603f, -0.01092753f, 0.02191987f, 
    0.04128354f, 0.00942765f, 0.01501088f, -0.07181816f, -0.03921476f, -0.04470072f, 0.01261481f, -0.06322737f, 
    0.01590837f, 0.06655272f, 0.01819113f, -0.04784334f, -0.01021339f, -0.07125431f, -0.03407650f, 0.06472190f, 
    0.06222231f, -0.06525894f, -0.05306305f, 0.03025270f, 0.03087647f, 0.00877249f, -0.03570748f, -0.04173454f, 
    0.01471329f, 0.00615364f, 0.02563244f, -0.00975511f, -0.05381650f, 0.06366194f, -0.05933808f, -0.05041010f, 
    -0.01308327f, -0.01605291f, 0.04527258f, -0.04148099f, 0.01351608f, -0.07107777f, -0.03042683f, -0.00446358f, 
    0.04018955f, -0.06783508f, 0.01507168f, 0.01456592f, -0.01495447f, -0.01422121f, -0.03554064f, 0.06129732f, 
    0.01940635f, -0.05110269f, -0.02472114f, -0.02259856f, -0.05691618f, -0.01825074f, 0.02662370f, -0.02183557f, 
    -0.02949402f, 0.03613292f, -0.01787911f, 0.03568413f, 0.02087856f, -0.05830705f, -0.05478168f, -0.02554924f, 
    -0.05182500f, 0.06304254f, -0.00161028f, -0.04817939f, -0.03628492f, -0.00623425f, -0.00941648f, 0.02951369f, 
    -0.04456899f, -0.03927972f, 0.05427480f, 0.05718354f, -0.06750211f, -0.01416402f, 0.01319196f, 0.02249294f, 
    0.03792129f, -0.03392401f, -0.03013648f, -0.00253142f, -0.01702372f, 0.04312477f, -0.06784689f, -0.05725922f, 
    -0.03126016f, -0.05469163f, 0.05886192f, 0.00337014f, 0.06564713f, 0.01603640f, -0.02998071f, -0.03579097f, 
    0.06433569f, 0.01217130f, 0.10556179f, 0.06698243f, 0.04392560f, 0.15651786f, 0.06853036f, -0.13993616f, 
    0.10791051f, 0.03041808f, 0.09846731f, -0.04622684f, 0.22186194f, 0.29154950f, -0.20325838f, 0.26752129f, 
    0.27588305f, 0.05433420f, -0.01599315f, -0.00946735f, -0.03942726f, -0.01861529f, 0.01340654f, -0.02137399f, 
    -0.02647693f, -0.08426843f, 0.04091188f, -0.21864162f, -0.07912741f, -0.02819022f, -0.02276372f, 0.01319806f, 
    0.23060583f, 0.22829498f, -0.01925178f, 0.03238930f, -0.05007923f, -0.17316727f, -0.08648719f, -0.15951730f, 
    -0.01008819f, -0.00367474f, -0.00955841f, -0.08072288f, 0.08270039f, 0.02578386f, -0.01615337f, 0.07405415f, 
    0.01337796f, 0.20162368f, 0.51572102f, -0.16561060f, -0.08166345f, -0.06692185f, -0.01026025f, 0.19143853f, 
    -0.03196704f, -0.08117315f, -0.00630276f, 0.00546822f, 0.32218516f, 0.33047593f, 0.22990005f, 0.26652798f, 
    0.08182141f, 0.16242477f, 0.00967047f, 0.31667703f, -0.01023549f, -0.08513656f, -0.08945256f, 0.03856768f, 
    -0.39719951f, -0.17786227f, -0.46778545f, -0.14009990f, -0.04014266f, -0.10473554f, -0.04904607f, -0.09728722f, 
    -0.05249767f, 0.02623191f, -0.03394292f, 0.00574833f, 0.36021936f, 0.24982280f, 0.23190621f, 0.40073627f, 
    0.27202830f, 0.28844163f, 0.06350634f, 0.16492040f, -0.03863895f, 0.01975297f, -0.05168942f, 0.08216526f, 
    -0.05231825f, -0.14791699f, -0.15593876f, -0.02167160f, -0.07540978f, 0.03320575f, -0.12229085f, -0.01130868f, 
    0.08246345f, -0.03156645f, -0.29948193f, -0.17300795f, -0.03428014f, -0.00586572f, -0.26909032f, -0.15952025f, 
    0.01929229f, 0.06340760f, -0.03151382f, -0.06001343f, -0.03076161f, 0.06934693f, 0.08431531f, -0.12037772f, 
    0.31372914f, 0.38782203f, 0.28240687f, 0.30252099f, -0.01542850f, 0.05798393f, 0.01311168f, -0.05631614f, 
    -0.01946511f, -0.12809147f, 0.07705291f, 0.12283528f, -0.32491523f, -0.06261801f, 0.04310885f, -0.30662915f, 
    -0.06201259f, -0.00860063f, -0.06275821f, 0.04530256f, -0.15501978f, -0.12952563f, -0.24061805f, -0.11885757f, 
    0.18264028f, -0.06078976f, 0.16013607f, 0.11193816f, 0.15226887f, 0.01395985f, 0.04400484f, -0.04997288f, 
    0.11279402f, -0.01891465f, 0.20949529f, 0.05399820f, -0.09648079f, -0.40666187f, -0.34085688f, -0.25179774f, 
    -0.14857818f, -0.15419252f, -0.20903905f, -0.14538302f, 0.06431674f, 0.05449966f, -0.00564261f, -0.00607617f, 
    0.05218533f, 0.06528538f, -0.02618409f, -0.06728768f, 0.13590132f, -0.00973093f, 0.12487361f, 0.04276237f, 
    -0.00810044f, -0.05095097f, -0.04523238f, -0.10060866f, 0.21383558f, 0.40083918f, 0.08024478f, 0.12099658f, 
    -0.14471854f, 0.18588878f, 0.15105057f, 0.07257574f, -0.11479568f, -0.02657091f, -0.14615940f, 0.10507048f, 
    -0.08082960f, -0.15624280f, 0.01187128f, 0.01770655f, 0.00327757f, -0.02234990f, 0.00430569f, -0.03175481f, 
    0.18880093f, 0.15948284f, -0.00010223f, 0.11087561f, -0.22231169f, -0.06819679f, -0.05926258f, -0.18193823f, 
    -0.05999468f, -0.08982709f, 0.02425218f, 0.05548144f, -0.02038009f, 0.02429299f, -0.02125374f, 0.08045548f, 
    -0.09755364f, -0.14276670f, -0.03865054f, -0.03448379f, -0.05540062f, 0.02344648f, -0.01009992f, 0.00155067f, 
    0.16573235f, 0.26356158f, 0.08029261f, 0.21558616f, -0.14669679f, 0.19770078f, -0.12252788f, -0.15231401f, 
    -0.11649881f, -0.13631484f, -0.06007317f, -0.03770991f, 0.02092351f, 0.13602893f, 0.04620115f, 0.12810075f, 
    0.44036260f, 0.16687311f, -0.07188929f, -0.07892475f, 0.09595772f, -0.11034679f, -0.02457951f, 0.10406628f, 
    0.08240636f, 0.14766699f, 0.15068495f, 0.14570625f, -0.21007103f, -0.11442938f, 0.43231279f, -0.02704048f, 
    0.08629176f, 0.14641578f, -0.08537309f, -0.10730214f, 0.06893893f, -0.08437832f, -0.04827222f, 0.02801116f, 
    0.29820833f, 0.09274122f, -0.19067653f, 0.16876918f, 0.06629987f, -0.10330700f, -0.04943250f, -0.00428349f, 
    -0.09288184f, 0.11015265f, -0.08285237f, 0.09450503f, -0.14300939f, -0.23022948f, -0.20311856f, -0.02936014f, 
    0.13750012f, 0.13170449f, -0.07637456f, -0.14475760f, 0.02920937f, -0.00345672f, -0.06751537f, 0.05103596f, 
    0.04915854f, 0.00953016f, -0.09078405f, -0.01297452f, -0.10728117f, 0.15441208f, -0.03073323f, -0.00908333f, 
    0.10398704f, -0.05845113f, -0.07265471f, -0.15709893f, -0.37503600f, -0.21057393f, -0.07539297f, -0.19542798f, 
    -0.05115774f, -0.00958306f, 0.08907591f, 0.15890503f, 0.13075942f, 0.00090310f, 0.13207592f, -0.00948391f, 
    0.01125103f, -0.17015396f, 0.09011642f, 0.12665924f, 0.04881243f, -0.02013341f, 0.03598463f, 0.05410528f, 
    0.12007917f, 0.06685245f, 0.11031587f, -0.04906365f, 0.13050458f, -0.05264397f, -0.04299977f, -0.20192687f, 
    0.06055163f, 0.01362962f, -0.00854868f, 0.05502029f, -0.06153120f, -0.00856561f, 0.16046266f, -0.04687437f, 
    -0.09821819f, -0.12329777f, -0.04835066f, 0.09968296f, 0.07887351f, 0.11146839f, 0.07478558f, 0.11078300f, 
    0.09277413f, -0.02136662f, 0.02184938f, 0.02380144f, 0.25268313f, -0.06056456f, 0.23959613f, 0.06907136f, 
    -0.02038933f, -0.10004134f, -0.04148099f, -0.09516031f, -0.04055696f, 0.04865506f, 0.00406846f, -0.07142869f, 
    0.07133473f, 0.09572363f, 0.08717557f, -0.11906162f, 0.08765139f, -0.06092580f, 0.24035908f, 0.10850595f, 
    0.13138035f, -0.01462030f, -0.04298221f, 0.02931848f, -0.08290400f, 0.00423918f, 0.06828354f, 0.07246700f, 
    0.02998585f, -0.02378421f, -0.03417347f, 0.09207733f, 0.15181059f, 0.10022674f, -0.02911193f, 0.22468407f, 
    0.02391452f, 0.01640962f, -0.01050045f, -0.06579428f, 0.01497478f, -0.01880437f, 0.02532564f, -0.06074578f, 
    -0.03376691f, -0.02345093f, -0.06536488f, -0.04413883f, -0.07737830f, -0.03301408f, -0.06109791f, 0.02051411f, 
    -0.02066695f, -0.09041926f, 0.02670634f, -0.08276542f, -0.02178904f, -0.05627172f, 0.02121045f, 0.03077045f, 
    0.02988487f, -0.02760972f, -0.05256663f, -0.06145005f, 0.04050980f, -0.09295083f, -0.00905417f, 0.00730636f, 
    -0.08151355f, -0.06871259f, -0.08522576f, -0.04442790f, -0.09041867f, 0.00980469f, -0.04376122f, 0.03593843f, 
    -0.02373582f, -0.04738690f, 0.03806261f, -0.05584514f, -0.00390933f, 0.01405263f, -0.04204071f, -0.04707791f, 
    -0.07007413f, 0.02238304f, -0.08854914f, 0.02393009f, -0.05052265f, -0.03957716f, 0.04356572f, 0.00507151f, 
    -0.00502971f, -0.03920682f, 0.04656617f, -0.02526551f, -0.09039458f, -0.03351627f, -0.00578381f, -0.05897678f, 
    -0.00305502f, -0.07401121f, 0.03061262f, -0.08910415f, -0.04699860f, -0.08623371f, -0.09863454f, -0.01522484f, 
    -0.01973157f, -0.03442337f, 0.04782519f, -0.05208024f, -0.05827588f, -0.08091593f, -0.05552109f, -0.06833028f, 
    -0.05593916f, -0.09068424f, -0.01169818f, 0.07272566f, -0.06706838f, -0.00426260f, -0.01952609f, 0.04386757f, 
    -0.05244777f, -0.07227340f, -0.09441993f, -0.06023371f, -0.05777798f, -0.06370946f, -0.02832451f, 0.03501581f, 
    -0.05506448f, -0.06823390f, -0.04639926f, -0.07368543f, -0.00362889f, -0.02889843f, -0.01632476f, -0.08773842f, 
    0.00446158f, -0.07822133f, 0.04532835f, -0.02104441f, 0.02696494f, -0.04428433f, -0.01052100f, -0.05626221f, 
    -0.07163986f, -0.07091091f, -0.02272499f, 0.00743372f, -0.00931556f, 0.04335131f, -0.00478804f, 0.01829030f, 
    -0.01171732f, 0.04210440f, 0.00763831f, -0.08233116f, -0.07996920f, 0.04702299f, -0.07298588f, 0.02401059f, 
    -0.03068877f, -0.08134133f, -0.08530819f, -0.06033675f, 0.03586607f, -0.09055378f, -0.05291428f, -0.07801022f, 
    0.02665741f, -0.04966826f, -0.09103760f, -0.08799977f, -0.01453358f, -0.03599682f, -0.07228763f, -0.03726526f, 
    -0.04746556f, 0.01976046f, 0.04168032f, -0.08375408f, 0.01813301f, 0.01945060f, -0.03522602f, 0.02116455f, 
    -0.05971285f, 0.01342922f, -0.06968059f, -0.07460628f, -0.07689269f, 0.03645962f, -0.08156762f, -0.07908511f, 
    0.03504999f, -0.09114026f, 0.01388438f, 0.02310588f, -0.07308560f, -0.01858939f, 0.00753186f, -0.01052347f, 
    0.00323737f, -0.07494398f, -0.09339096f, 0.01490007f, -0.02864030f, -0.08577960f, -0.02193291f, 0.04115884f, 
    0.01825830f, 0.02211838f, -0.00565257f, -0.03367222f, 0.03927979f, 0.00189988f, 0.00582833f, -0.04743358f, 
    -0.05557780f, -0.07847279f, 0.00643294f, -0.02192997f, -0.01271817f, -0.06528308f, 0.02852138f, -0.08261672f, 
    -0.06737061f, -0.07996344f, -0.03419659f, -0.14659993f, 0.19290806f, 0.09734026f, 0.19387950f, 0.13090809f, 
    -0.01504483f, 0.14363666f, 0.15988168f, 0.06054974f, 0.02892124f, -0.09993748f, 0.15405576f, 0.09394266f, 
    0.09857484f, -0.02887163f, 0.04696666f, -0.11098246f, -0.09641691f, -0.03770012f, -0.12343194f, -0.15957695f, 
    0.22414508f, -0.00696279f, 0.12748754f, -0.11336495f, -0.08294957f, 0.13161115f, 0.00599535f, 0.01736389f, 
    0.10902575f, -0.04632561f, 0.26982495f, 0.04072364f, 0.10286553f, -0.04746297f, -0.26953048f, -0.35643089f, 
    -0.28238368f, 0.00122936f, 0.01862335f, 0.01336776f, 0.31916565f, 0.04267517f, 0.15634808f, 0.03912244f, 
    0.31693915f, -0.06991334f, -0.39813542f, 0.12438355f, -0.04037790f, 0.09409998f, 0.10147082f, -0.16181345f, 
    0.22452082f, 0.20588636f, 0.10911524f, 0.09219702f, -0.30075341f, 0.02550430f, 0.16939881f, 0.26071900f, 
    0.03612651f, -0.14698070f, -0.06358445f, -0.02065864f, 0.02439756f, -0.00872342f, -0.02667962f, 0.12488995f, 
    -0.03492958f, 0.37562799f, 0.50027943f, -0.09535791f, 0.02189489f, -0.14702803f, -0.24300992f, 0.00974555f, 
    -0.05368230f, -0.00189586f, 0.06043632f, 0.01593851f, -0.13071650f, -0.23684791f, -0.08722877f, 0.13947839f, 
    -0.09327877f, 0.05004077f, 0.13351043f, 0.08983298f, -0.23952538f, 0.00407458f, 0.07111752f, -0.01121289f, 
    -0.14657384f, 0.01979521f, 0.12645258f, 0.12928706f, -0.07272276f, -0.10784768f, -0.06701282f, -0.02777632f, 
    -0.05756269f, -0.01710926f, -0.13422157f, -0.10592741f, -0.18954860f, -0.17603506f, -0.20375617f, -0.21251471f, 
    -0.10777886f, 0.00128944f, 0.03711760f, -0.01703441f, 0.14072482f, -0.00916979f, -0.00836368f, 0.14216852f, 
    -0.03569906f, -0.06491601f, -0.05391817f, 0.01656025f, 0.04834402f, 0.05672209f, -0.00604288f, 0.22239052f, 
    0.06701277f, 0.01432779f, -0.11594354f, 0.01627453f, 0.18529955f, 0.16842121f, -0.13528702f, -0.06205663f, 
    0.04148527f, -0.02711574f, 0.00567967f, -0.03723703f, -0.03605462f, 0.01905563f, -0.11007831f, -0.04126399f, 
    0.22867818f, -0.00597689f, 0.06483146f, 0.09391896f, 0.03908463f, 0.19172013f, 0.08907687f, 0.02224971f, 
    0.00918439f, 0.01912112f, 0.00151720f, 0.01591142f, -0.08032753f, 0.33023879f, 0.42947063f, 0.15776439f, 
    -0.07600903f, -0.22228202f, -0.18766548f, -0.12107490f, -0.01289277f, 0.07758297f, -0.02870746f, 0.01007432f, 
    0.36206371f, -0.45114845f, 0.08906256f, 0.12231085f, 0.12240719f, 0.05844474f, 0.11278018f, 0.03342422f, 
    -0.27210978f, -0.05928070f, -0.09562460f, 0.05989389f, -0.20861672f, 0.03735827f, -0.10641205f, 0.06512059f, 
    0.07347811f, -0.19719762f, 0.13213472f, 0.07428896f, 0.03680921f, 0.02444109f, 0.05969066f, -0.00378584f, 
    -0.02470278f, -0.08023593f, -0.01142967f, -0.00657668f, 0.04749179f, 0.09238464f, -0.00676215f, -0.04397557f, 
    0.03873676f, 0.21150483f, 0.06675184f, 0.11011322f, 0.01297590f, -0.04993102f, 0.01164912f, 0.06778730f, 
    -0.02185865f, -0.02291224f, -0.05485259f, -0.20176189f, -0.08537412f, -0.06081296f, -0.00354104f, -0.06088558f, 
    0.15055723f, -0.11854561f, 0.31461260f, -0.11642452f, -0.25243929f, 0.03027400f, -0.08660591f, 0.08262227f, 
    0.03630262f, 0.21789932f, 0.19005008f, 0.04630741f, -0.13369501f, -0.06139643f, -0.10298140f, -0.24493441f, 
    -0.25560412f, -0.14837030f, 0.07232532f, -0.12629433f, 0.04847457f, 0.04780211f, 0.10530572f, 0.16532189f, 
    0.18691325f, 0.08765873f, -0.21661194f, 0.07041544f, 0.04172869f, 0.15928085f, 0.17484158f, -0.00143783f, 
    0.06719510f, 0.18667567f, 0.14579876f, 0.28986284f, -0.24630953f, -0.43233594f, 0.27419263f, 0.10298963f, 
    -0.00724175f, 0.02193627f, -0.09202764f, -0.00956108f, 0.07494804f, 0.01855945f, 0.02512934f, 0.19264230f, 
    0.00675492f, 0.36821210f, 0.29325116f, -0.11544862f, -0.22415820f, -0.22516073f, -0.34554499f, 0.07416002f, 
    -0.09301359f, 0.09322424f, -0.03703588f, 0.04370932f, -0.14047122f, -0.25525287f, -0.06119287f, 0.07027859f, 
    0.05432624f, 0.16465513f, 0.01794531f, 0.01424420f, -0.20135963f, -0.01428100f, -0.03486301f, -0.11758098f, 
    -0.08474323f, 0.00106504f, 0.05713211f, 0.09843517f, -0.11538757f, -0.09153484f, -0.02219899f, 0.03974066f, 
    0.03149946f, -0.01551646f, -0.10865511f, -0.16820733f, -0.43056759f, 0.09627936f, -0.01474946f, -0.17264509f, 
    -0.09099542f, -0.18477198f, 0.03312766f, -0.03094107f, -0.00194647f, 0.03077197f, 0.10546782f, 0.18507025f, 
    -0.09399772f, -0.13584922f, -0.16640288f, 0.05763041f, 0.01526670f, 0.12404849f, -0.06713524f, 0.13630387f, 
    -0.02368296f, 0.01383748f, 0.01584357f, -0.08420533f, 0.11652786f, 0.33691159f, -0.04043570f, -0.36420837f, 
    -0.00202555f, 0.04413371f, -0.11625648f, -0.04056282f, -0.11720618f, -0.15400572f, -0.01197933f, -0.03269741f, 
    0.22994928f, 0.05253530f, 0.18920214f, 0.26544839f, 0.05992493f, 0.12253006f, 0.07145061f, 0.16845304f, 
    0.07361709f, 0.05623787f, 0.03255798f, 0.01023356f, 0.04568900f, 0.03013962f, 0.48688179f, -0.03567889f, 
    -0.08938555f, -0.18887305f, -0.14713177f, -0.09174643f, -0.07617620f, 0.03950311f, 0.06431323f, -0.00403824f, 
    0.35573885f, -0.25070733f, 0.32018709f, -0.06216303f, 0.24921304f, 0.07794094f, 0.06857579f, 0.14394867f, 
    -0.06113644f, -0.08225884f, 0.01782167f, 0.17629498f, -0.15173458f, -0.04594029f, -0.25899753f, -0.01422521f, 
    -0.02111139f, 0.07805400f, 0.04784287f, 0.06336141f, 0.14562561f, 0.05647554f, 0.10182116f, -0.08779918f, 
    0.23915800f, 0.12788899f, -0.00711773f, 0.09284560f, 0.33482444f, 0.15039556f, 0.18043418f, 0.05269417f, 
    -0.08316857f, 0.08249853f, 0.03650371f, 0.12399007f, 0.25974411f, -0.12020185f, -0.24075478f, 0.03977026f, 
    -0.08148514f, -0.40985054f, -0.12572499f, 0.00793726f, -0.21301652f, -0.14512047f, -0.05879017f, -0.23438379f, 
    0.07053398f, 0.17564262f, 0.04812336f, 0.08977698f, 0.00482144f, 0.04177456f, -0.04059803f, -0.00386548f, 
    0.11131262f, 0.07684806f, -0.01825617f, -0.01307369f, 0.17160672f, 0.06431156f, 0.19301447f, -0.07564107f, 
    0.15176150f, 0.08482312f, 0.08740068f, 0.07603193f, 0.30625764f, -0.01747795f, 0.20942651f, 0.00726582f, 
    -0.03692438f, 0.17664960f, -0.00556033f, -0.03612575f, 0.32327875f, 0.38280430f, 0.02578448f, -0.10891402f, 
    -0.01744618f, -0.10601092f, -0.14226097f, 0.10968909f, 0.01598662f, -0.01025504f, -0.01627512f, 0.10063497f, 
    -0.09972231f, -0.24785735f, -0.01283605f, -0.09038118f, -0.02916420f, 0.21051303f, -0.07026861f, -0.01295998f, 
    0.16839117f, 0.16289382f, 0.20328800f, -0.03648112f, -0.01334136f, 0.05370873f, -0.03226069f, -0.01453988f, 
    0.05593570f, 0.02083974f, -0.11355570f, 0.08212409f, 0.01792656f, -0.12139607f, -0.25586361f, -0.11541063f, 
    0.13340202f, 0.10141028f, -0.09790298f, -0.04537283f, -0.10064595f, -0.05090585f, 0.04862077f, -0.10340600f, 
    -0.33822045f, -0.06005903f, 0.29015821f, -0.06503026f, -0.07609712f, -0.15744133f, 0.09685853f, -0.05178475f, 
    0.23764949f, 0.20535655f, 0.14853491f, -0.03626602f, 0.27931359f, -0.06718640f, -0.00085404f, 0.06986745f, 
    0.14074756f, -0.02169523f, -0.07443071f, 0.06659371f, 0.32374933f, 0.21434858f, -0.00623644f, 0.15035021f, 
    0.03096957f, 0.02457672f, -0.10938166f, -0.29452518f, -0.13956779f, -0.28276733f, -0.26346561f, -0.01911112f, 
    -0.23554097f, -0.16882800f, -0.15015894f, -0.11307875f, 0.03616426f, 0.18118617f, -0.17740250f, 0.22818515f, 
    -0.07035244f, 0.08887779f, -0.09314994f, 0.04125567f, 0.09728738f, 0.00276729f, 0.01998864f, -0.08548550f, 
    0.22206025f, -0.02676998f, -0.22225979f, -0.51181507f, -0.28502086f, -0.14145799f, 0.28334773f, 0.21679837f, 
    -0.14139554f, -0.06082930f, -0.15596704f, 0.01413952f, 0.00607790f, 0.27206114f, 0.26275405f, 0.31718662f, 
    -0.01831926f, -0.03312367f, 0.04352472f, 0.06582647f, 0.12529087f, -0.01174596f, -0.00440035f, 0.05752592f, 
    -0.32680058f, -0.10278125f, 0.22104985f, 0.09353993f, -0.05660797f, 0.14066267f, -0.04926858f, -0.14580998f, 
    -0.28165603f, -0.04170528f, -0.17231660f, -0.00295990f, -0.04380996f, -0.04908595f, -0.30708879f, -0.21231039f, 
    -0.07412612f, -0.26153782f, -0.46591353f, -0.06054236f, -0.24331619f, -0.03531458f, -0.24399427f, -0.29726464f, 
    -0.14346623f, -0.15415630f, -0.01990177f, -0.11011276f, 0.04528745f, 0.09268437f, -0.05759015f, -0.05544393f, 
    0.14132261f, -0.06691904f, 0.04330376f, 0.02352079f, 0.27425379f, -0.03847069f, -0.15660632f, -0.18755382f, 
    0.03497047f, 0.04152907f, 0.25934309f, 0.21503611f, -0.03474750f, -0.12794712f, -0.02062863f, 0.12166294f, 
    0.08507890f, -0.01624430f, -0.01384996f, 0.04469984f, -0.15062937f, -0.07975381f, -0.28005487f, 0.08798835f, 
    0.09792054f, 0.04658266f, 0.01972068f, 0.24521442f, 0.09280016f, -0.02217015f, 0.25282708f, 0.18651699f, 
    -0.02091577f, -0.09444845f, -0.20005344f, -0.00353661f, -0.03333261f, -0.20296218f, 0.00121891f, 0.11129106f, 
    -0.02671111f, 0.32281896f, -0.13721316f, 0.06560386f, 0.06119457f, -0.00821658f, 0.05130217f, -0.03100868f, 
    -0.02831691f, 0.03170438f, -0.10108079f, 0.04789951f, 0.02030672f, -0.06062008f, -0.31067362f, -0.11181009f, 
    0.07801172f, -0.05184241f, 0.21775895f, -0.02401659f, 0.02094515f, 0.04096023f, -0.06746761f, 0.06195765f, 
    -0.04899273f, -0.31119585f, -0.43373135f, -0.06758563f, -0.04391065f, 0.07391061f, 0.10270995f, 0.00523282f, 
    0.12064353f, -0.05070212f, -0.06357818f, 0.03796238f, -0.01345720f, 0.08807879f, -0.18883270f, -0.16608588f, 
    0.15606081f, 0.07108778f, -0.08540313f, -0.10173220f, -0.01047440f, -0.11090127f, -0.04290894f, -0.02961252f, 
    -0.03996537f, 0.03946856f, -0.20709604f, -0.00782030f, 0.03045826f, 0.07544633f, 0.10393903f, 0.18215959f, 
    0.02367832f, 0.27827579f, -0.06169699f, 0.05937739f, 0.30827686f, -0.00788057f, 0.51067007f, -0.25134751f, 
    0.10911880f, -0.06114830f, -0.02733797f, -0.02157125f, 0.06022932f, 0.18867458f, -0.02690436f, 0.03735299f, 
    0.02371947f, 0.15441844f, 0.08530304f, -0.14477238f, -0.02703196f, 0.13347371f, 0.05924693f, 0.04501041f, 
    0.04741256f, -0.08973923f, -0.02995472f, -0.03799962f, 0.02454594f, 0.15468833f, 0.00172102f, 0.11228468f, 
    -0.01575252f, -0.04754554f, 0.03419066f, -0.05324547f, 0.03404813f, -0.08356670f, 0.08707952f, -0.03728704f, 
    -0.10636149f, -0.20177834f, -0.01607156f, -0.02200852f, -0.06715230f, 0.14293717f, 0.01223620f, 0.08538415f, 
    -0.00183892f, 0.06253386f, 0.16829392f, 0.06314985f, -0.12954076f, -0.09976840f, -0.31940320f, 0.11729205f, 
    0.03698399f, -0.03077074f, 0.14560816f, -0.20477633f, 0.00088456f, -0.04536870f, -0.01734167f, 0.02691949f, 
    -0.43928686f, 0.54472673f, -0.22166456f, 0.11839436f, -0.03429662f, 0.01391003f, 0.15825985f, -0.04117708f, 
    0.13584013f, 0.15794930f, -0.10886516f, 0.15272208f, 0.23864742f, 0.03214205f, 0.08073994f, -0.16859470f, 
    0.20599876f, -0.03891679f, 0.06892665f, 0.10490512f, 0.05964863f, -0.10483612f, -0.15014915f, 0.09035020f, 
    0.02249906f, -0.06784667f, 0.01095725f, -0.05270493f, -0.05559649f, 0.03095016f, 0.02371211f, 0.06456655f, 
    -0.01768655f, -0.06162295f, -0.03239520f, 0.04293269f, -0.05155994f, -0.06055027f, -0.03079420f, -0.02705260f, 
    0.03184009f, 0.05391311f, 0.01669540f, -0.00840518f, -0.03709717f, 0.04249147f, -0.03355410f, -0.00428126f, 
    -0.02951575f, -0.06736475f, -0.02084366f, 0.04751730f, -0.04726597f, 0.02909249f, -0.07943551f, 0.00943077f, 
    -0.06244009f, -0.06951419f, -0.06763940f, 0.04569501f, -0.04539860f, -0.06144992f, 0.00255022f, -0.02358845f, 
    0.00482248f, 0.03191954f, -0.07497774f, 0.04237260f, -0.00696345f, -0.00771131f, 0.05236039f, -0.01670611f, 
    0.01403258f, -0.07211942f, 0.05401558f, 0.00979421f, -0.02795036f, -0.05225806f, -0.01509253f, 0.02355707f, 
    -0.01932411f, -0.07212014f, 0.02468586f, 0.02841862f, 0.04681863f, -0.03608935f, -0.07467868f, 0.00376920f, 
    0.02586682f, 0.01772952f, -0.05240637f, -0.05450322f, -0.01800632f, -0.03190089f, -0.04827204f, 0.04108265f, 
    -0.07747781f, -0.06694314f, -0.04214223f, -0.01409257f, -0.06128020f, -0.00758110f, 0.00567996f, 0.00183667f, 
    -0.00425948f, 0.04940746f, -0.01310320f, -0.04352258f, 0.02820227f, -0.03961516f, -0.00182015f, -0.04148237f, 
    0.04761003f, 0.02265484f, 0.03052284f, -0.07523558f, -0.03507394f, -0.02129043f, -0.07011061f, 0.02715480f, 
    -0.03030853f, -0.03589895f, -0.01172517f, 0.04177664f, 0.05543604f, 0.02562728f, 0.04598339f, -0.03349224f, 
    0.00650383f, 0.01062125f, 0.03114271f, -0.07456212f, -0.06321385f, 0.00670543f, -0.06678013f, 0.03586588f, 
    -0.00781804f, 0.04018797f, -0.00740581f, -0.01618283f, -0.04433911f, -0.06734188f, -0.02052893f, 0.03985024f, 
    -0.01055586f, 0.00694387f, -0.01039064f, -0.02116175f, 0.05785901f, 0.04916171f, 0.02855138f, -0.05370552f, 
    0.03429236f, 0.04451431f, -0.02857742f, 0.04462259f, -0.04663694f, -0.00301974f, -0.05772719f, 0.02878632f, 
    0.02278156f, 0.03300286f, 0.01529795f, -0.03876030f, -0.05912261f, 0.02913083f, -0.03564022f, -0.04624968f, 
    -0.04489601f, 0.02260159f, 0.02523401f, -0.02780658f, -0.04796479f, 0.04207948f, -0.07790188f, -0.00262294f, 
    -0.07556579f, 0.05037928f, -0.06489780f, 0.02812058f, -0.03761337f, -0.00405994f, -0.02359748f, 0.01853783f, 
    0.00772908f, -0.03900675f, -0.01682893f, 0.00883374f, 0.05124909f, -0.06934626f, -0.05609000f, -0.04924309f, 
    -0.05415495f, -0.02017841f, -0.06911104f, -0.01720762f, 0.03462694f, 0.00297185f, -0.00831255f, -0.04598758f, 
    -0.00633350f, 0.03518016f, 0.04355324f, -0.01339776f, -0.03914674f, -0.02328511f, 0.00427643f, 0.00447394f, 
    -0.01470901f, 0.03012750f, 0.06741220f, -0.05958094f, -0.03555333f, -0.05396188f, 0.03294430f, 0.05695952f, 
    -0.11836852f, 0.05105691f, 0.00340708f, -0.00211517f, 0.29162514f, -0.01613241f, -0.16963777f, 0.01917337f, 
    0.11481887f, 0.00589595f, 0.04166762f, 0.03656161f, 0.50681764f, 0.13447940f, -0.24853568f, -0.04567634f, 
    -0.00156299f, 0.14503530f, -0.09170254f, -0.08255394f, 0.11054778f, -0.02007974f, 0.07176419f, 0.04815820f, 
    -0.20032722f, -0.15360261f, 0.10159400f, 0.10468784f, 0.03580592f, 0.01005096f, 0.10220996f, 0.11840674f, 
    0.06726562f, 0.03806664f, -0.09434818f, 0.20616905f, -0.16275933f, -0.14111412f, -0.00016694f, 0.17495677f, 
    0.01996996f, -0.09648050f, -0.07102560f, 0.01564642f, 0.01749617f, 0.25082478f, 0.05915324f, 0.29682291f, 
    -0.19101003f, 0.15815394f, -0.05054862f, -0.15210590f, -0.01671559f, -0.12915622f, -0.01110557f, 0.07101452f, 
    0.13432752f, 0.14507644f, 0.00929837f, 0.24363388f, 0.35424131f, -0.24567211f, 0.02238043f, -0.50551969f, 
    0.07546528f, -0.00218498f, 0.14972968f, -0.14190745f, -0.01135002f, 0.14837746f, -0.05707856f, 0.11031227f, 
    0.23565705f, -0.06808700f, -0.20979501f, 0.05707078f, -0.06779146f, -0.01489342f, 0.03351107f, -0.00930468f, 
    -0.08566669f, -0.01127104f, -0.06613668f, -0.02411167f, -0.01587757f, -0.06468578f, -0.12391266f, -0.19314584f, 
    0.12247557f, -0.06304931f, -0.04994840f, -0.11235448f, 0.00530083f, -0.03085712f, -0.03417763f, 0.07093163f, 
    0.01892187f, -0.11733196f, 0.01122608f, -0.12766838f, 0.13503239f, 0.06850179f, -0.15151526f, 0.11037554f, 
    -0.05652757f, 0.14087494f, 0.03344428f, -0.00847293f, -0.26641056f, 0.08466644f, -0.06372827f, 0.12807491f, 
    0.00294014f, -0.08087437f, 0.05366530f, 0.01002317f, 0.03195389f, 0.08774531f, 0.01608824f, -0.04294860f, 
    -0.02020188f, 0.08011061f, -0.36606213f, -0.23927937f, -0.27947181f, -0.14947289f, 0.19066843f, 0.15867804f, 
    -0.04589704f, 0.10804705f, -0.11698853f, 0.02548073f, -0.16544066f, 0.02486605f, 0.03245027f, 0.01905362f, 
    0.07080048f, 0.08943416f, 0.12138008f, 0.20698151f, -0.13135950f, -0.00628906f, 0.06257685f, 0.09997823f, 
    -0.33887967f, 0.20359558f, 0.11137227f, 0.12548667f, 0.03789827f, 0.21692275f, -0.12860921f, -0.01963945f, 
    0.01629810f, 0.09186158f, 0.00500492f, -0.03429591f, 0.06988989f, -0.03830495f, 0.27649143f, 0.04120624f, 
    0.08870448f, -0.04246600f, 0.07804544f, -0.05880327f, -0.09030403f, 0.05209625f, -0.03649372f, 0.04673808f, 
    -0.23584457f, -0.02408577f, -0.11094280f, -0.20193245f, 0.14531672f, 0.17366885f, -0.06195868f, 0.11656221f, 
    0.01645407f, 0.12060381f, 0.02383206f, -0.06064206f, 0.17742807f, -0.02044243f, -0.07731968f, -0.31787881f, 
    0.03906856f, 0.06460881f, 0.06124132f, 0.06181472f, 0.11031327f, 0.13241567f, 0.07804175f, -0.07752104f, 
    0.05144430f, 0.02405713f, -0.01299892f, -0.05802330f, -0.04216706f, -0.00064115f, -0.05781145f, 0.01942193f, 
    0.06176242f, -0.04381536f, 0.01624160f, -0.02197404f, 0.01841256f, -0.01378508f, 0.02870350f, -0.00072873f, 
    -0.01096182f, -0.06756981f, 0.05394866f, -0.00899906f, -0.01172900f, -0.07522256f, 0.01453778f, 0.01992954f, 
    -0.07264611f, -0.05460619f, 0.04075993f, -0.08041855f, -0.03797454f, -0.04773713f, -0.07217773f, -0.05215839f, 
    -0.02454210f, -0.00596257f, 0.03707409f, 0.00243764f, -0.02186343f, 0.03754885f, -0.01323115f, 0.04035566f, 
    -0.02912948f, -0.05590691f, 0.06268618f, -0.07176940f, -0.03705334f, -0.07434842f, 0.06422669f, -0.02158028f, 
    -0.01408280f, -0.03635218f, -0.05600996f, -0.05675679f, 0.05821622f, -0.01854987f, -0.06873175f, -0.03394735f, 
    0.04219228f, 0.04966535f, 0.03932082f, -0.01125605f, -0.01964838f, -0.03960007f, -0.05129447f, -0.06949341f, 
    -0.01706847f, 0.02910103f, 0.01360664f, -0.07484179f, 0.04082604f, 0.05225062f, -0.06729273f, -0.04205472f, 
    -0.00997929f, -0.05726334f, 0.04937698f, -0.07246666f, -0.06879149f, 0.02273480f, 0.00346350f, 0.05679296f, 
    0.01715935f, -0.04867594f, -0.06689017f, -0.07424147f, 0.05574450f, -0.04339002f, 0.06124608f, -0.01566432f, 
    0.06323340f, 0.03943961f, 0.03897927f, 0.01309669f, 0.03144351f, -0.00979383f, -0.05036838f, -0.03951428f, 
    -0.06242083f, -0.04199081f, 0.01446370f, -0.07094235f, -0.06262242f, 0.05432668f, 0.01088206f, -0.07709456f, 
    0.05813698f, -0.05952015f, 0.03234542f, -0.04577874f, 0.05383910f, -0.06203280f, 0.04600506f, -0.02967909f, 
    0.04112614f, 0.01067050f, 0.00773076f, -0.04800363f, 0.05383053f, 0.03117529f, 0.02402034f, -0.01874024f, 
    -0.00585755f, -0.03135728f, -0.04130600f, 0.05904106f, -0.04530381f, -0.06820406f, -0.05060761f, 0.01037806f, 
    0.03863730f, -0.05888218f, -0.03703063f, 0.02871221f, 0.06215542f, -0.00087038f, 0.03509321f, -0.04221844f, 
    0.05928210f, 0.05506995f, 0.00769415f, 0.05609306f, 0.01449172f, -0.07455601f, -0.06640479f, -0.06050822f, 
    -0.06917360f, -0.06586187f, -0.07215362f, -0.01512492f, 0.06315757f, 0.03664912f, -0.05427198f, -0.06429978f, 
    -0.07172984f, -0.07991702f, 0.04894303f, 0.01906593f, -0.04446751f, 0.02337287f, -0.03377625f, 0.03617693f, 
    0.06048480f, -0.00799578f, 0.03878084f, -0.07610801f, -0.03074015f, 0.03274314f, -0.01061831f, -0.04253871f, 
    0.00083870f, -0.06434049f, -0.03009481f, 0.05526713f, -0.07081923f, -0.02342186f, 0.00288312f, -0.02361801f, 
    0.06231230f, -0.01784100f, 0.04912861f, 0.01755865f, 0.00931624f, 0.04250383f, 0.02280481f, -0.06526384f, 
    -0.03484383f, -0.00912517f, -0.05144382f, 0.03941605f, -0.05728164f, -0.06236373f, 0.01641590f, 0.04287542f, 
    0.04371394f, -0.00857990f, -0.10960329f, 0.06235924f, 0.01269926f, -0.00976837f, 0.08030170f, -0.07271944f, 
    0.09885727f, -0.07430679f, -0.02096914f, -0.01184398f, -0.34199706f, -0.00313769f, 0.06281914f, 0.16702479f, 
    -0.04450585f, -0.06364384f, -0.10860135f, 0.00130316f, -0.08794719f, 0.09479567f, 0.01696651f, 0.13247791f, 
    0.23458369f, 0.19531302f, 0.02210299f, -0.18156098f, 0.00455984f, -0.01581369f, 0.05774764f, 0.02069567f, 
    0.10028520f, -0.11357490f, 0.05298807f, -0.12892042f, 0.03525097f, 0.06010219f, 0.06432050f, -0.10963423f, 
    0.06695871f, 0.07267182f, -0.06190846f, -0.01567951f, -0.07649147f, 0.06767648f, -0.04608531f, 0.08177293f, 
    0.37203166f, -0.29723051f, 0.18358959f, -0.17311390f, -0.08716542f, 0.00313786f, -0.13573326f, 0.13490544f, 
    -0.10373717f, -0.27839497f, -0.00458923f, -0.11954527f, -0.05948815f, 0.08055800f, 0.40511605f, 0.23911823f, 
    0.12730034f, 0.20832492f, -0.15264560f, 0.13450506f, 0.04588309f, 0.02396303f, -0.02774251f, -0.05450902f, 
    0.20276549f, 0.23240361f, -0.06892605f, 0.14065470f, -0.05720825f, -0.08275738f, 0.13333786f, -0.04030006f, 
    -0.04671862f, 0.08026938f, -0.06266768f, -0.00689380f, 0.11059968f, -0.06898970f, 0.00231727f, 0.09056734f, 
    -0.11854464f, -0.10486122f, -0.00949673f, 0.05685616f, 0.13627113f, 0.02605056f, -0.06596399f, 0.11379948f, 
    0.19288056f, 0.13353734f, 0.04812849f, 0.04904117f, -0.00648881f, -0.08421773f, 0.16943090f, -0.00872172f, 
    0.09601405f, -0.13639782f, 0.03283796f, -0.07945298f, -0.17734641f, 0.04027581f, -0.20706642f, 0.05486004f, 
    0.07044446f, 0.08411862f, -0.00909431f, 0.07005019f, -0.03595071f, -0.04831932f, -0.06325579f, -0.07512019f, 
    0.10920121f, -0.02903756f, 0.17710640f, 0.25411549f, 0.28229681f, 0.06997174f, -0.05671654f, -0.08409800f, 
    0.03574630f, -0.04408116f, 0.24481308f, 0.17232783f, 0.09291551f, 0.11973249f, -0.09844285f, -0.32288730f, 
    -0.08481267f, -0.07052790f, -0.04388493f, 0.00693530f, 0.03896336f, 0.13320225f, 0.09919887f, 0.11981996f, 
    0.25452626f, 0.07311916f, 0.05379912f, 0.24694103f, -0.01592634f, -0.26307607f, 0.16849399f, 0.21201247f, 
    -0.01988972f, -0.01518099f, 0.01276741f, 0.06091861f, 0.11783926f, -0.04082217f, 0.12566338f, -0.16089569f, 
    -0.02185780f, -0.00640237f, -0.04028008f, 0.11356148f, 0.04560092f, 0.06184737f, -0.08503617f, -0.00821993f, 
    0.34867141f, -0.13719416f, 0.32795879f, -0.11008690f, 0.01054122f, -0.11974449f, 0.12009764f, -0.05019578f, 
    -0.03448952f, 0.02805127f, 0.09723093f, -0.19648255f, -0.20303763f, -0.03171128f, -0.12335806f, 0.18076380f, 
    -0.26739401f, 0.04130375f, -0.18820637f, -0.15200007f, -0.17526112f, -0.02823564f, 0.12127935f, 0.23573261f, 
    0.08439179f, -0.07801925f, -0.13308141f, 0.02864957f, 0.04966719f, 0.23360226f, -0.07908516f, -0.01490322f, 
    0.08820255f, 0.16715309f, 0.20844676f, 0.02931608f, -0.17713048f, 0.03292690f, 0.12746002f, -0.08693205f, 
    -0.00589292f, 0.00950924f, -0.00274646f, 0.03208788f, -0.03984244f, -0.09700090f, -0.06884544f, 0.02292219f, 
    0.00581102f, 0.05158802f, -0.06127403f, 0.07859125f, -0.05663034f, -0.10574083f, -0.15936877f, 0.03667279f, 
    0.15889533f, 0.04165770f, 0.18138227f, 0.03587483f, 0.10673130f, -0.10496423f, -0.27211750f, -0.11687543f, 
    -0.06577900f, -0.19466634f, 0.03966847f, -0.00685413f, 0.03274723f, -0.06876748f, -0.01887489f, 0.10745263f, 
    0.07078634f, 0.01187787f, 0.13933113f, 0.11252488f, 0.04942419f, 0.18823703f, 0.00173908f, 0.05980280f, 
    0.00883769f, 0.02829616f, 0.16099253f, 0.19416134f, -0.20833237f, 0.19256593f, 0.17560437f, 0.33337891f, 
    0.01643486f, 0.02244092f, 0.01656286f, 0.00105274f, -0.01139705f, -0.08513486f, 0.11266620f, -0.09246045f, 
    -0.22740813f, 0.08980776f, 0.08317779f, 0.00594372f, -0.03354802f, -0.19084695f, -0.13855720f, -0.05573072f, 
    0.08742589f, -0.08796792f, -0.05175418f, 0.10267011f, 0.08601642f, -0.07938272f, 0.11068097f, 0.36095276f, 
    0.07873742f, 0.20233859f, 0.12901863f, 0.18804154f, 0.08232902f, 0.02268029f, -0.03733124f, -0.02247535f, 
    -0.17041592f, 0.00691445f, -0.07137345f, 0.05077622f, 0.06438596f, -0.00064486f, -0.08653607f, -0.11126432f, 
    0.25501648f, -0.15256839f, -0.07991603f, -0.23082153f, -0.07329118f, -0.32182521f, -0.17026740f, -0.18001375f, 
    -0.04182013f, 0.06348523f, -0.02432745f, 0.00017920f, 0.08108188f, -0.09777717f, 0.08813401f, -0.04439018f, 
    0.39241159f, 0.31203008f, 0.47091326f, 0.13202235f, 0.30762905f, 0.06574384f, -0.10291184f, 0.05787063f, 
    0.05020775f, -0.11725950f, -0.03274769f, -0.11695601f, -0.09576334f, 0.10783551f, -0.07022171f, 0.03171939f, 
    -0.01494866f, -0.02831738f, 0.02496276f, -0.01300267f, -0.02232914f, -0.13192767f, -0.18323582f, -0.05456971f, 
    0.25131947f, 0.06771833f, 0.10998154f, 0.33400425f, 0.00867131f, 0.03708669f, 0.34105137f, -0.03856959f, 
    0.03113584f, -0.11158570f, -0.00409601f, 0.03343809f, -0.29355502f, -0.12898348f, -0.06513940f, 0.28416455f, 
    -0.10440110f, -0.02555913f, -0.22025710f, 0.02991558f, 0.12244131f, -0.00824420f, 0.04005528f, -0.05025470f, 
    0.42949301f, 0.03577097f, -0.03445563f, -0.08536755f, 0.24719349f, -0.08804394f, -0.11403945f, 0.13890418f, 
    -0.15472153f, -0.07266374f, -0.02096097f, 0.13742326f, 0.01964824f, 0.30181041f, 0.11022771f, 0.06568497f, 
    0.03758092f, 0.09854186f, -0.06717452f, 0.18123272f, -0.04383685f, -0.00131740f, -0.05335056f, 0.06887298f, 
    0.01739668f, -0.05777503f, -0.05110251f, -0.05452465f, 0.00687081f, -0.03631465f, -0.05735304f, 0.01703575f, 
    0.03316514f, -0.05831657f, 0.00135295f, 0.02441855f, -0.01685654f, -0.01790787f, 0.00069831f, -0.05911285f, 
    0.02519648f, -0.00074683f, 0.09441277f, -0.04514795f, 0.00607990f, -0.00087065f, 0.03547176f, 0.05540477f, 
    -0.02886637f, 0.02003143f, -0.03619903f, 0.00113412f, -0.04360450f, -0.02438727f, -0.07228064f, -0.07269253f, 
    0.00889704f, -0.01478310f, -0.06634045f, -0.05567301f, -0.00409157f, 0.02650028f, -0.00262582f, 0.00292631f, 
    -0.03179728f, -0.01146793f, 0.00869557f, -0.00684031f, -0.09005743f, 0.01764925f, -0.07712647f, 0.00795592f, 
    -0.03161905f, -0.01456610f, 0.00058467f, -0.07307585f, -0.07616434f, -0.08898942f, -0.00077586f, 0.00565284f, 
    0.01912927f, 0.00853838f, 0.02448384f, 0.01328671f, -0.02673128f, -0.05732096f, -0.02655474f, -0.00012948f, 
    -0.00086364f, 0.01179638f, -0.03090857f, -0.00349809f, 0.03858582f, 0.04857825f, -0.04753370f, 0.03443318f, 
    -0.02034008f, -0.09473580f, -0.00777664f, -0.01125591f, -0.06232062f, -0.09981085f, -0.03073313f, 0.02054289f, 
    0.03246098f, -0.09426899f, -0.02973475f, 0.04679891f, -0.01433061f, -0.09095530f, -0.06506791f, 0.01336250f, 
    -0.04223926f, -0.00901014f, -0.04527174f, 0.05958733f, -0.01577322f, -0.05259540f, -0.05417930f, 0.02511597f, 
    -0.04923253f, -0.00376983f, -0.03736338f, -0.07134275f, 0.02870731f, 0.03766121f, -0.02466046f, -0.08558391f, 
    -0.03571178f, -0.01239779f, 0.01196788f, -0.07271286f, -0.07638799f, 0.01946723f, -0.03878083f, 0.02907377f, 
    0.02868026f, 0.00027524f, -0.02075845f, -0.05067887f, -0.04363528f, -0.08546998f, -0.04772350f, -0.00422377f, 
    -0.09624174f, -0.05277415f, -0.00426737f, 0.08979780f, 0.02049570f, -0.05046101f, -0.05178546f, -0.04031000f, 
    0.04580911f, -0.07309092f, 0.08646996f, 0.08267109f, -0.04990564f, -0.06545907f, -0.05190545f, -0.01302530f, 
    0.02105284f, -0.05475524f, 0.04681936f, -0.04313091f, -0.01277948f, 0.05901322f, -0.00710502f, -0.01496159f, 
    -0.06553429f, 0.01933744f, 0.05308013f, -0.01270810f, -0.02765380f, -0.06271356f, -0.02672560f, -0.03957324f, 
    0.00104392f, 0.02100883f, 0.06528080f, 0.07866049f, 0.03370681f, -0.04296498f, -0.05892710f, 0.01626229f, 
    -0.07387935f, -0.04809332f, -0.02545734f, -0.10380694f, -0.04958928f, -0.02864400f, -0.09028719f, 0.00091994f, 
    0.03016452f, -0.09583403f, -0.01098556f, -0.03558706f, 0.04322898f, -0.03087945f, 0.01531890f, -0.09702422f, 
    -0.04569933f, 0.02378062f, -0.04431131f, 0.00628139f, -0.00200676f, -0.06566992f, -0.03818051f, -0.06861686f, 
    -0.03921174f, 0.00933839f, -0.06623358f, 0.05677467f, -0.06405749f, 0.05401969f, 0.06340377f, 0.08437584f, 
    0.00792245f, -0.06707586f, 0.05800607f, -0.06134871f, 0.05279960f, -0.04989649f, 0.04678552f, 0.04350534f, 
    -0.04916728f, 0.02959404f, 0.05826933f, -0.04404096f, -0.04442749f, -0.06378274f, -0.03401217f, 0.06371734f, 
    0.03033648f, -0.01169144f, 0.03637348f, 0.05134268f, -0.04359571f, -0.02617173f, 0.01883537f, -0.00225880f, 
    -0.05467170f, 0.03966430f, 0.02071429f, -0.05437349f, -0.06394994f, -0.05578756f, 0.03069970f, -0.00367349f, 
    0.02945788f, -0.02690090f, -0.05975762f, -0.07611091f, 0.03707414f, 0.06192949f, -0.00590897f, -0.05992688f, 
    -0.07037339f, 0.06012825f, -0.01224014f, 0.02220156f, 0.03227539f, -0.07114655f, 0.02251312f, -0.02996448f, 
    -0.03331868f, 0.01016034f, -0.04756409f, -0.07121541f, -0.03235422f, 0.03938570f, -0.07469296f, -0.06035221f, 
    -0.05982007f, 0.02033246f, -0.05530363f, 0.00864013f, -0.03964756f, -0.00032601f, -0.05688459f, -0.01839113f, 
    0.04184947f, 0.04973508f, -0.07319262f, -0.05431865f, -0.06390230f, -0.04767000f, 0.03481586f, -0.00405582f, 
    0.01101248f, -0.07591429f, 0.00743334f, -0.02868321f, 0.01806638f, -0.03507163f, -0.04021682f, 0.01884918f, 
    -0.05615767f, 0.06679285f, -0.02098978f, -0.05775301f, 0.00565354f, -0.03955982f, 0.05245489f, -0.05932215f, 
    0.02911779f, 0.01265989f, -0.02948819f, 0.06259420f, -0.07029040f, 0.02104392f, -0.05796290f, -0.00426016f, 
    0.05919262f, 0.03781815f, 0.03591654f, 0.02566063f, -0.03576939f, -0.01028640f, 0.06343130f, -0.04802741f, 
    -0.03530588f, 0.04271641f, 0.04097032f, -0.06467038f, -0.01150192f, 0.02972253f, -0.07008098f, -0.03950649f, 
    0.05724941f, -0.05886508f, -0.07135479f, -0.00795935f, -0.00579735f, -0.05362293f, -0.04094293f, 0.05739082f, 
    -0.05148697f, 0.02115683f, -0.04701222f, -0.07076608f, -0.07355885f, 0.01554495f, 0.06401951f, -0.00748373f, 
    -0.02522740f, -0.05417311f, -0.05175966f, 0.05376999f, -0.04343858f, -0.02775590f, -0.05221421f, -0.01216935f, 
    0.03598988f, 0.03488332f, -0.06252401f, -0.07692993f, 0.04094448f, 0.04222028f, -0.05621659f, -0.04168993f, 
    0.05946458f, -0.04813384f, 0.04039735f, -0.01606935f, 0.00588829f, 0.01528655f, 0.04725595f, -0.01127037f, 
    0.00402883f, -0.06230948f, 0.02346446f, -0.06764249f, 0.02472298f, -0.04672146f, 0.03544764f, 0.04528145f, 
    0.04002599f, -0.02195946f, -0.06719470f, 0.03540604f, 0.05217693f, -0.01518621f, -0.07104909f, 0.03150748f, 
    0.04777579f, -0.01612988f, -0.02978444f, -0.05946256f, 0.04789408f, -0.04615545f, -0.04601312f, 0.05314719f, 
    -0.00939154f, -0.01835336f, 0.05803937f, -0.06465022f, -0.01065078f, -0.04653575f, 0.01670278f, -0.00161744f, 
    0.00717954f, 0.04178166f, -0.02263626f, 0.03208396f, -0.03864589f, -0.04827575f, -0.04660231f, -0.04834228f, 
    -0.22562724f, -0.10860728f, -0.11927562f, -0.00455225f, 0.00138359f, 0.09843767f, 0.07828355f, -0.01274757f, 
    0.08667479f, -0.10157831f, 0.03638674f, -0.11247817f, -0.36903900f, -0.09340459f, 0.15538499f, -0.27740249f, 
    -0.09239430f, -0.08110845f, 0.09236945f, 0.06159567f, -0.03678448f, -0.10468168f, 0.04339641f, 0.10259451f, 
    0.01799723f, -0.08320472f, -0.23460960f, 0.11527627f, -0.23025264f, -0.09483153f, -0.33739421f, 0.15233688f, 
    0.15641218f, 0.17352709f, 0.07543003f, 0.20532636f, 0.10294122f, -0.08538499f, -0.03933894f, 0.01766447f, 
    -0.17147742f, -0.13184039f, -0.12038601f, 0.05694457f, 0.01217920f, -0.03727810f, 0.11034955f, 0.11634182f, 
    0.23304591f, 0.17901154f, -0.14022358f, 0.15865386f, 0.08032777f, 0.03064490f, 0.05626168f, 0.13995543f, 
    -0.15418102f, -0.02332203f, -0.06163191f, 0.00717296f, -0.27718559f, 0.06822985f, 0.16837569f, -0.08471200f, 
    0.10856996f, 0.04930460f, 0.12042053f, -0.08134852f, 0.06302070f, -0.06427078f, 0.06878060f, -0.04472572f, 
    0.01961528f, -0.25691256f, -0.16542931f, 0.05710972f, 0.15536426f, -0.18216637f, -0.10830987f, 0.01627259f, 
    0.16919418f, -0.06820904f, -0.15024383f, 0.09892936f, -0.17384855f, -0.07276813f, -0.10407234f, 0.06700345f, 
    0.08941330f, 0.13273765f, 0.00856567f, -0.14557022f, 0.07731806f, 0.02412938f, -0.10482367f, 0.07527214f, 
    0.04161623f, 0.01225670f, -0.10564573f, 0.00168848f, -0.03357528f, 0.20321457f, -0.08361249f, -0.12579492f, 
    0.21744499f, 0.09476593f, 0.00302092f, -0.11316644f, 0.16035537f, -0.38683924f, 0.31679234f, -0.35867575f, 
    -0.08798113f, -0.10708900f, -0.08690870f, 0.11870778f, 0.06805205f, 0.00894826f, 0.08474280f, 0.02425263f, 
    0.09169333f, -0.06170787f, 0.41324508f, 0.09826031f, 0.26614180f, 0.09207648f, -0.05842249f, -0.09915313f, 
    0.11925321f, -0.14900789f, 0.13481547f, -0.07139839f, -0.00749580f, -0.16303641f, 0.03940558f, 0.01857508f, 
    -0.17972922f, 0.07772788f, -0.07496324f, -0.03156094f, 0.13308221f, -0.04664465f, 0.05331685f, -0.00620920f, 
    -0.03903560f, 0.03018913f, 0.04286141f, 0.25426084f, 0.01665444f, 0.07199547f, 0.08713222f, 0.06772472f, 
    0.11613426f, -0.09903743f, 0.11039212f, 0.05095626f, -0.11019409f, 0.09725069f, -0.19781587f, 0.07041299f, 
    -0.04435068f, -0.01931800f, 0.01990516f, 0.00756885f, 0.02284255f, -0.10408472f, -0.04523062f, -0.02543133f, 
    0.15015432f, 0.29442143f, 0.00683023f, -0.07028446f, 0.11375470f, -0.03351822f, 0.01388838f, 0.08697421f, 
    -0.02678699f, 0.06356272f, -0.05046273f, 0.25900534f, 0.02329748f, -0.06672508f, 0.26387599f, -0.07952639f, 
    0.03875989f, 0.00956354f, -0.00879963f, 0.09456309f, 0.08324981f, -0.08761989f, -0.14057654f, 0.11342709f, 
    0.11210714f, 0.12798023f, -0.04551229f, -0.02555505f, -0.12046363f, 0.16170140f, -0.03501575f, 0.03538778f, 
    0.01581493f, -0.23469126f, -0.27913278f, -0.16694057f, 0.05782549f, 0.22187395f, -0.07379562f, 0.05039563f, 
    0.04822461f, 0.13382074f, -0.12839963f, 0.05576470f, -0.01820665f, 0.03546530f, 0.08176348f, 0.18010609f, 
    -0.24581358f, -0.04669410f, -0.16496383f, 0.09052370f, 0.16537289f, -0.01399209f, 0.00927155f, -0.13563472f, 
    -0.03330883f, -0.07471918f, -0.13257612f, -0.01273091f, -0.12044330f, -0.08185185f, -0.09465083f, 0.02955167f, 
    0.04630569f, 0.02283539f, 0.01511346f, 0.01086018f, -0.10820195f, 0.15470633f, 0.03901010f, -0.11427388f, 
    -0.03723390f, -0.11932149f, 0.31744030f, -0.02892533f, 0.22106092f, -0.01189785f, 0.01674939f, -0.00415327f, 
    -0.03355534f, -0.20425023f, -0.11608713f, -0.19463104f, 0.50665462f, 0.15753540f, 0.29962724f, 0.07172318f, 
    0.02850465f, 0.17349210f, -0.04261599f, 0.07976184f, -0.04275309f, 0.04879508f, 0.07998843f, -0.05141148f, 
    0.08405187f, -0.00611999f, 0.05003600f, 0.12857674f, -0.03290873f, 0.00322578f, -0.05317078f, 0.06176214f, 
    -0.08924392f, -0.07866697f, -0.05943919f, -0.06462649f, 0.41876173f, 0.22467822f, 0.17465533f, 0.00740462f, 
    0.05272986f, 0.01204514f, -0.08121910f, 0.04805794f, 0.07593696f, -0.13928765f, -0.08588826f, -0.15746404f, 
    -0.12697017f, -0.06346585f, 0.11173403f, -0.05247485f, 0.02548561f, 0.05590960f, -0.05202997f, -0.06262252f, 
    0.20616260f, -0.09311646f, 0.20949751f, 0.13241731f, -0.12152615f, -0.02471219f, -0.13182583f, 0.19132192f, 
    0.09397652f, 0.00431689f, -0.03850116f, 0.02222190f, -0.10813142f, -0.08033028f, 0.03133548f, 0.05550760f, 
    0.26740080f, 0.17224623f, 0.16313596f, 0.03422516f, 0.14787808f, -0.08032017f, -0.04729893f, -0.17153394f, 
    0.11311956f, -0.01130615f, 0.05522727f, 0.07391623f, -0.19273649f, -0.03418227f, 0.01200673f, 0.18052632f, 
    0.05660462f, 0.00455871f, 0.00695956f, 0.00394186f, 0.05701567f, 0.10872783f, 0.05752749f, 0.24213594f, 
    -0.15139036f, 0.05391143f, -0.19150923f, -0.25777003f, 0.05810272f, -0.10588994f, -0.01237498f, -0.00906443f, 
    0.09531208f, -0.08088978f, -0.03862080f, 0.02064869f, 0.01617255f, -0.10531958f, -0.08046429f, -0.01128935f, 
    0.03097271f, 0.04549155f, 0.00188112f, 0.23387852f, -0.04768554f, 0.02093549f, 0.02178820f, -0.05358526f, 
    -0.35109311f, 0.24888182f, -0.01970682f, -0.03681983f, 0.05496920f, 0.10274610f, -0.15728419f, 0.00725911f, 
    0.07774973f, -0.03319889f, 0.25164193f, -0.05115978f, 0.33870971f, 0.05409144f, 0.18008924f, 0.08219320f, 
    0.02039389f, 0.22102517f, -0.08200382f, -0.03605314f, 0.02246922f, 0.02467296f, 0.11340445f, 0.09496750f, 
    -0.04640514f, -0.02016125f, -0.03952602f, -0.03298781f, -0.00479943f, -0.03482133f, -0.01802355f, 0.00500059f, 
    -0.03725115f, 0.04075824f, -0.06675445f, 0.00401700f, -0.03858525f, 0.04799809f, -0.01423445f, -0.00533884f, 
    -0.06077884f, -0.05918027f, -0.03397124f, 0.03902547f, -0.04331246f, 0.00120947f, 0.00778351f, 0.05750591f, 
    -0.04042717f, 0.02822497f, 0.03776095f, -0.01368790f, -0.05806614f, 0.01913810f, 0.01323142f, 0.04624559f, 
    0.03002585f, -0.03375338f, 0.00589421f, -0.04018408f, -0.00518511f, 0.00659561f, -0.07648269f, -0.08301704f, 
    0.04037165f, -0.02240280f, -0.08378743f, 0.01376902f, 0.01039693f, 0.02036208f, -0.06122416f, -0.03630881f, 
    -0.00975122f, -0.04049755f, -0.00046994f, 0.02754953f, 0.03469506f, -0.00834891f, -0.05991504f, -0.00813955f, 
    -0.07458577f, 0.02823798f, 0.02706581f, 0.01542394f, -0.06736942f, -0.03557087f, -0.00193696f, -0.02592572f, 
    -0.04641928f, 0.01935386f, 0.02681257f, 0.03483409f, 0.04274582f, 0.04500222f, 0.04466706f, -0.05458307f, 
    -0.00712762f, 0.03558163f, -0.02490148f, 0.06663392f, -0.02577095f, -0.01541874f, -0.02716288f, -0.01730014f, 
    -0.01517064f, 0.03869599f, 0.03042984f, -0.05370343f, -0.01030359f, 0.02662328f, 0.05114586f, -0.00946395f, 
    0.05677820f, 0.02930835f, 0.04136067f, 0.02595169f, -0.07738725f, -0.02217886f, 0.03024700f, -0.09545241f, 
    -0.02698307f, 0.00092067f, -0.03179592f, -0.00538882f, 0.03185695f, 0.03204801f, -0.01832819f, -0.05545311f, 
    -0.07857631f, -0.07722033f, -0.06683222f, 0.00627955f, 0.02229293f, 0.01258416f, -0.08048013f, -0.02176103f, 
    0.01436649f, -0.07707849f, 0.04506380f, -0.00023702f, -0.02159817f, 0.02336569f, 0.01410967f, 0.01130231f, 
    0.03916803f, -0.07309420f, -0.07713530f, -0.04175134f, 0.04374236f, -0.01924374f, -0.08100257f, -0.06480148f, 
    0.00576045f, 0.05164342f, -0.03411138f, 0.03324518f, -0.04571756f, 0.06103608f, 0.04061417f, 0.04773900f, 
    0.00117324f, -0.02121849f, -0.08315618f, -0.02774794f, -0.02394112f, 0.00664361f, 0.02089733f, -0.03728805f, 
    -0.07036214f, 0.04789134f, -0.07639080f, -0.00842636f, -0.07481453f, 0.03111153f, -0.06267554f, -0.08034073f, 
    -0.02295280f, -0.02963853f, 0.03424691f, 0.01691754f, 0.00438397f, -0.06172707f, -0.07579191f, -0.04015921f, 
    0.01527918f, 0.04070844f, 0.04871666f, -0.04307066f, -0.00420564f, -0.07174619f, -0.09257063f, -0.06685727f, 
    -0.00459010f, -0.01652020f, -0.05267724f, -0.06470279f, -0.01322748f, -0.03649078f, -0.02964363f, 0.02467192f, 
    -0.07399268f, -0.00664527f, -0.01326974f, 0.03793710f, -0.04219555f, -0.03989692f, 0.01490516f, 0.00599258f, 
    0.02745213f, -0.06059182f, 0.05372946f, 0.04902336f, -0.01388375f, -0.08040889f, -0.05712708f, -0.04242027f, 
    -0.04508481f, 0.08629417f, 0.13471404f, 0.00570563f, -0.04087335f, -0.15359057f, -0.04914356f, -0.04811770f, 
    -0.17311372f, -0.08655509f, -0.23651800f, -0.06366464f, -0.19165769f, -0.08372536f, 0.03377820f, 0.19344823f, 
    0.01323123f, -0.04560664f, -0.03652322f, 0.13946192f, 0.00552780f, 0.03456488f, -0.01183198f, -0.06327260f, 
    -0.02056480f, 0.20784266f, -0.04448182f, -0.07918836f, 0.03644140f, -0.04018261f, -0.18724413f, -0.19157989f, 
    0.01932921f, -0.20942286f, -0.01228276f, -0.13551375f, 0.17021489f, 0.05740625f, -0.08607538f, -0.22016264f, 
    -0.12380094f, -0.02743980f, -0.11217353f, -0.01777871f, -0.00036155f, 0.01086456f, 0.00795869f, -0.21688485f, 
    0.02189532f, -0.23608196f, -0.04490748f, 0.09292152f, 0.05045917f, -0.00223653f, -0.12996048f, -0.11576168f, 
    -0.09458825f, -0.09762002f, 0.04318621f, -0.30456427f, 0.03620768f, 0.28385049f, 0.22812296f, 0.24361376f, 
    0.05690596f, 0.01214015f, 0.04009779f, 0.32836473f, 0.01500162f, -0.09247254f, -0.06587248f, -0.11639287f, 
    -0.03866931f, 0.15837160f, 0.32385638f, -0.03746719f, 0.06627227f, 0.09056582f, -0.14894423f, -0.03260291f, 
    -0.15193062f, 0.01122687f, -0.05425574f, -0.08750733f, 0.00550465f, -0.04494532f, 0.10216172f, 0.18104082f, 
    -0.14857380f, -0.11478825f, 0.12322021f, 0.18960737f, -0.02678792f, 0.01639012f, -0.04104767f, 0.01798813f, 
    0.06426842f, 0.23057948f, 0.21066362f, 0.10847839f, -0.08790845f, -0.03116364f, 0.15060699f, 0.05206721f, 
    0.06084207f, 0.06172220f, 0.09453055f, 0.21726558f, 0.23362230f, -0.23992461f, -0.08287285f, -0.08248334f, 
    -0.11648277f, -0.13621104f, -0.15294425f, 0.02497887f, -0.02625090f, 0.00696119f, 0.03049485f, -0.14621159f, 
    -0.03714310f, -0.08812235f, 0.01540553f, 0.17193212f, 0.02272370f, -0.04655933f, 0.19817622f, 0.13806884f, 
    0.09964951f, 0.22154684f, 0.03942533f, -0.01719701f, 0.04742333f, 0.19417939f, -0.18852173f, 0.16362196f, 
    -0.14579749f, 0.15805608f, -0.02119304f, -0.07294215f, 0.10054673f, 0.08748164f, 0.14899248f, 0.02089727f, 
    0.13921945f, -0.11869857f, -0.09197771f, 0.06735493f, -0.12779437f, -0.14770103f, 0.07790266f, -0.09736646f, 
    0.01144718f, 0.02114885f, 0.03641574f, 0.15637425f, 0.04871261f, 0.18022822f, 0.07966345f, -0.02087181f, 
    -0.00100470f, -0.06650998f, -0.02710840f, 0.19404721f, -0.01389739f, 0.04368459f, -0.06289498f, 0.06363375f, 
    0.15153870f, -0.24289493f, 0.08429775f, -0.03456841f, 0.09962687f, -0.01341998f, -0.05375314f, -0.16883197f, 
    -0.01843041f, -0.04302783f, 0.05267283f, -0.05246522f, -0.19045071f, -0.07554502f, -0.02953405f, 0.25311202f, 
    0.05932913f, 0.11756113f, 0.00272542f, 0.16575949f, -0.00053944f, 0.03720644f, -0.00045276f, -0.02624062f, 
    -0.12966833f, -0.09054948f, -0.03439246f, 0.07037788f, -0.06048436f, 0.10897950f, -0.11405122f, -0.19662671f, 
    -0.24422236f, -0.35459211f, -0.34274179f, -0.39431384f, -0.17695172f, 0.07680986f, -0.03470480f, -0.00560212f, 
    0.17604642f, 0.16306606f, 0.09784646f, 0.29077914f, 0.00835516f, -0.00228974f, 0.08292090f, 0.34430090f, 
    -0.07892993f, -0.18218715f, -0.32267281f, 0.12479839f, -0.09069443f, -0.13817200f, -0.11227600f, -0.14692993f, 
    -0.05404734f, 0.02369928f, -0.08091941f, -0.09464668f, -0.03186866f, 0.33134329f, -0.34623140f, -0.29765591f, 
    0.07950998f, -0.02642738f, 0.02399492f, -0.16213451f, -0.21502912f, 0.10683998f, 0.05933055f, -0.11740820f, 
    0.35682729f, 0.13100658f, 0.27555472f, -0.05659389f, 0.14963019f, 0.05147740f, -0.04643890f, 0.13163261f, 
    -0.11339059f, -0.15217163f, -0.13052775f, -0.34340927f, 0.15455545f, 0.12040213f, 0.40884280f, 0.23946139f, 
    -0.04805044f, 0.14222769f, -0.16590165f, 0.12434069f, -0.00169961f, 0.12274946f, 0.27005574f, -0.13833611f, 
    0.12813960f, 0.16696668f, 0.13109006f, 0.39970571f, -0.13234614f, 0.01021857f, -0.07338688f, 0.00331378f, 
    -0.15374193f, -0.18087532f, -0.18698385f, 0.10967092f, 0.36010978f, 0.10935368f, -0.07635552f, -0.12195644f, 
    0.30349743f, 0.17704931f, -0.13568713f, 0.05049589f, 0.10595670f, -0.13682243f, -0.24560045f, -0.19409488f, 
    -0.29874444f, -0.04998972f, 0.01777085f, 0.20678237f, 0.02503908f, 0.07844055f, -0.15834400f, -0.08799799f, 
    0.13936591f, 0.02400800f, 0.30269310f, 0.14136718f, -0.26218510f, -0.24883977f, -0.05271805f, 0.01117433f, 
    0.15533236f, -0.07935052f, 0.05472620f, -0.20349269f, -0.02709987f, -0.03376373f, -0.01050255f, -0.06891228f, 
    0.22136024f, 0.11053576f, 0.31095496f, 0.00054419f, 0.20671883f, -0.15206820f, -0.04148091f, -0.04645613f, 
    0.16739550f, 0.08359527f, 0.04787152f, 0.21598980f, 0.12925844f, -0.25219017f, 0.02700831f, -0.05574057f, 
    0.06823364f, 0.02540205f, 0.03820562f, 0.00221036f, 0.17989688f, 0.01980706f, 0.12718269f, 0.38225403f, 
    0.01823628f, -0.14872508f, -0.23897053f, 0.06084035f, 0.07112728f, -0.07731214f, -0.01245717f, -0.10542019f, 
    -0.02114938f, -0.06665043f, -0.01454513f, 0.06176468f, 0.07056845f, 0.11200314f, 0.10084242f, 0.05097458f, 
    -0.01261926f, -0.05247525f, -0.02231202f, 0.16921003f, 0.05574061f, -0.06274886f, -0.11091738f, -0.07385906f, 
    -0.07795405f, 0.35629168f, -0.08730667f, 0.07914042f, 0.03712665f, 0.12378593f, -0.02314279f, 0.06694809f, 
    0.04467081f, 0.00864620f, 0.17795116f, -0.06495563f, 0.36606780f, 0.00177989f, 0.04814610f, 0.01230128f, 
    -0.06616842f, 0.10621949f, -0.12182465f, -0.03434016f, 0.12793279f, 0.03397301f, -0.05507094f, 0.05227774f, 
    -0.03523185f, -0.12930651f, -0.07052216f, -0.09544307f, 0.06827723f, 0.15150289f, -0.25147387f, -0.02011289f, 
    0.05494054f, -0.00881301f, -0.01577537f, 0.09886154f, -0.19746090f, -0.01899810f, 0.02752230f, 0.04119065f, 
    -0.12009771f, 0.00386311f, 0.00484389f, -0.04045836f, -0.04113015f, -0.10048694f, 0.01953966f, 0.03661865f, 
    -0.08570662f, -0.15303417f, -0.19496828f, 0.05819828f, -0.04450526f, 0.03316113f, -0.04762747f, -0.02449348f, 
    0.03157411f, -0.06738459f, 0.04508451f, -0.03181631f, 0.01291746f, 0.07092474f, -0.21956874f, -0.02243018f, 
    -0.12186533f, -0.01844570f, 0.08771411f, 0.06280825f, -0.02894153f, 0.08911929f, 0.04337527f, 0.13652888f, 
    0.36233199f, -0.03127283f, -0.31451648f, -0.06981198f, 0.03447516f, -0.00296755f, -0.03327624f, -0.10515253f, 
    0.08846766f, 0.04445626f, 0.16328444f, 0.13824736f, -0.25554577f, -0.09041785f, 0.41730914f, 0.22047579f, 
    0.03046390f, 0.15181024f, -0.05840742f, -0.08413123f, 0.11957856f, -0.03160408f, 0.07746138f, -0.09299649f, 
    0.02506084f, 0.23879130f, 0.24726535f, 0.13567758f, -0.03136582f, -0.03912042f, -0.01156645f, -0.00092191f, 
    -0.07390616f, 0.01511786f, -0.05262018f, 0.06857233f, -0.02024203f, -0.26142377f, -0.20476118f, 0.14671087f, 
    0.08179188f, 0.13091241f, 0.04352494f, -0.01072327f, -0.02717681f, -0.00435949f, -0.09524983f, -0.08208971f, 
    -0.19293500f, -0.10736860f, -0.03426754f, 0.15872614f, -0.00938054f, -0.00424830f, -0.09565198f, -0.16765349f, 
    0.18570690f, -0.02330549f, 0.00844422f, -0.06047185f, -0.36869577f, -0.10954959f, -0.18220778f, 0.01750193f, 
    -0.03284981f, -0.06091454f, 0.16579005f, 0.09539769f, 0.00712640f, -0.03372550f, 0.12025579f, 0.11640197f, 
    0.23741253f, 0.12635727f, 0.04509625f, 0.04964336f, 0.31284592f, -0.11553199f, -0.14344792f, 0.08696362f, 
    -0.07990312f, 0.00082880f, 0.04688927f, -0.03448818f, 0.07519907f, -0.02969805f, -0.11695448f, -0.09372853f, 
    0.03019183f, -0.01170342f, 0.01790815f, -0.00083136f, 0.00661246f, -0.05869960f, -0.01493989f, 0.07004929f, 
    0.20261319f, -0.05416952f, 0.09173774f, 0.26891822f, 0.08052596f, 0.07715651f, 0.21041906f, 0.07864681f, 
    0.03718479f, -0.04791148f, -0.10299708f, 0.02450526f, -0.08033237f, -0.03013442f, 0.35525051f, 0.17266239f, 
    0.04004325f, -0.07054039f, -0.06894898f, 0.15326060f, -0.10787415f, -0.02263357f, -0.08167935f, -0.04559008f, 
    0.19491968f, -0.12867934f, -0.00624616f, -0.02147851f, 0.03280020f, -0.01008584f, -0.08162134f, 0.13479090f, 
    0.01034324f, 0.05866845f, 0.09804732f, -0.08291968f, 0.05888654f, 0.00848859f, -0.11310756f, -0.03524139f, 
    -0.01711596f, 0.02331340f, -0.00624615f, 0.12744004f, 0.00881121f, 0.06515095f, 0.09271155f, 0.04499039f, 
    -0.19070973f, -0.01871575f, -0.01418803f, 0.10683879f, 0.00055873f, 0.01396134f, -0.07728729f, -0.22891495f, 
    -0.09064775f, -0.30016348f, -0.20497957f, -0.30056885f, -0.23165093f, -0.16858608f, 0.00078023f, -0.14140724f, 
    -0.05369011f, -0.01505031f, -0.02815450f, 0.08762340f, 0.02330096f, -0.08868028f, 0.06276566f, 0.28552470f, 
    0.10718724f, 0.17999320f, -0.08997003f, 0.16477919f, -0.07944269f, -0.09071917f, -0.36402619f, 0.15843840f, 
    -0.05375827f, 0.08923183f, -0.01260319f, -0.03950284f, -0.05002613f, -0.11312892f, 0.22910082f, 0.16991334f, 
    0.10028087f, -0.04708249f, -0.28471401f, -0.07489983f, -0.10149392f, -0.19254495f, -0.03247977f, 0.03604227f, 
    0.10854208f, 0.04170395f, -0.17750904f, 0.06090323f, 0.01623661f, 0.00367740f, 0.07359957f, 0.06342997f, 
    -0.24198201f, -0.10981207f, -0.15116306f, -0.26454106f, -0.22051612f, -0.00528416f, -0.15555319f, 0.14237884f, 
    0.12332746f, -0.11032298f, 0.06644209f, -0.08474297f, 0.02889522f, 0.00104404f, 0.05363862f, -0.13513312f, 
    -0.09906621f, -0.29081428f, -0.40239868f, 0.02325670f, 0.00757593f, -0.02287225f, 0.28409430f, -0.18580018f, 
    0.14747015f, -0.13942142f, -0.09891903f, -0.00888465f, -0.21993762f, 0.18206315f, -0.18848361f, -0.13074555f, 
    0.12237714f, 0.06294540f, -0.11135077f, -0.01158137f, -0.01823426f, -0.06318911f, -0.18518658f, -0.13726729f, 
    0.17257537f, 0.07825006f, -0.18228921f, -0.14780058f, -0.04320427f, 0.05624224f, 0.19143294f, 0.03386748f, 
    0.25544900f, 0.21690844f, 0.11731406f, 0.14945564f, 0.21768861f, 0.00449876f, 0.71104950f, -0.00034351f, 
    -0.03957921f, -0.14567657f, -0.19984272f, 0.02612038f, 0.10040894f, 0.10153733f, -0.09286658f, -0.07382337f, 
    0.12748212f, 0.13884103f, 0.34007335f, 0.00273956f, 0.05758403f, 0.00386878f, -0.03718778f, -0.08995555f, 
    0.15399481f, 0.14304005f, 0.16439281f, 0.11539000f, 0.01552963f, 0.21770535f, 0.03930093f, 0.15064394f, 
    -0.12329621f, 0.07423676f, -0.01740556f, -0.03835948f, 0.19124314f, 0.11021326f, 0.06857476f, 0.01625874f, 
    0.21137425f, 0.14280377f, 0.29350269f, 0.41821790f, -0.10963666f, -0.00762360f, 0.07315563f, 0.08677774f, 
    -0.02084730f, -0.08304267f, 0.06915835f, 0.24063018f, -0.15657413f, 0.00097385f, -0.27326912f, -0.00215465f, 
    0.05985997f, 0.02653740f, 0.27604562f, -0.07283656f, -0.06080221f, -0.13445622f, -0.05444561f, -0.13276365f, 
    -0.05601915f, 0.34436733f, -0.03632309f, 0.05869718f, -0.07778061f, -0.08934553f, 0.04074958f, -0.02394295f, 
    0.15644032f, 0.21148877f, -0.11229594f, 0.28274912f, 0.06877178f, -0.03568981f, 0.01865074f, -0.09882268f, 
    0.04222595f, 0.08380888f, 0.01265006f, 0.05280769f, 0.02677744f, 0.03146139f, -0.03226195f, 0.21479939f, 
    -0.02253081f, 0.02695622f, -0.07366059f, -0.07765955f, 0.00602066f, -0.08081994f, 0.05460588f, 0.02864260f, 
    0.03493663f, -0.03211175f, 0.03270356f, 0.03731538f, -0.05879152f, -0.07968245f, -0.03258161f, 0.02038115f, 
    0.00196169f, -0.01577649f, -0.01181014f, -0.03415700f, 0.00195677f, 0.05041876f, -0.05647067f, 0.05906141f, 
    0.01001891f, -0.06202773f, 0.03227022f, -0.07764075f, 0.05674251f, -0.00318852f, -0.06287663f, -0.05836178f, 
    -0.00401281f, -0.00704596f, -0.00250842f, -0.03784408f, -0.01105906f, -0.04182846f, 0.03334620f, -0.00884117f, 
    -0.07062926f, 0.02235142f, -0.01662657f, -0.07085633f, 0.02528929f, 0.01323373f, 0.04437812f, 0.04760909f, 
    -0.01156092f, -0.00051746f, 0.03320503f, -0.05718433f, -0.07397270f, -0.05300730f, 0.03409744f, 0.05416204f, 
    0.01956439f, 0.01503796f, 0.02307126f, 0.03751684f, -0.00740057f, -0.02792376f, -0.02972724f, -0.07379742f, 
    0.06358247f, 0.00184758f, -0.07707943f, -0.02723558f, -0.03817886f, -0.00495187f, -0.05933356f, -0.01907357f, 
    0.02823422f, -0.00910670f, 0.01882736f, 0.04168641f, -0.05592564f, -0.06929041f, -0.03795644f, 0.02181585f, 
    0.05852128f, -0.06914136f, -0.01749729f, -0.03987104f, 0.04210905f, -0.02885978f, 0.06114478f, -0.04849561f, 
    0.05479578f, -0.06543662f, -0.00808046f, -0.00017236f, 0.01987096f, -0.04437386f, -0.01451979f, 0.01513044f, 
    0.02062097f, -0.06970695f, -0.06897487f, -0.07564134f, -0.04448121f, -0.04536547f, 0.03466952f, 0.00966770f, 
    0.01501668f, -0.01678269f, 0.06315129f, 0.03126692f, 0.02113277f, -0.05358996f, -0.03770542f, 0.01255119f, 
    -0.07861985f, 0.05082694f, 0.02420905f, -0.07329720f, -0.04857741f, 0.05226576f, -0.05509609f, 0.04449281f, 
    -0.07067207f, -0.06888791f, 0.01801537f, 0.03308688f, 0.05530214f, -0.05265101f, 0.00680848f, 0.00516923f, 
    -0.05864953f, -0.05297254f, -0.05026015f, -0.04764387f, -0.03324147f, 0.05228210f, -0.05151793f, -0.02543301f, 
    -0.00757573f, 0.01594608f, -0.04591228f, -0.06628639f, -0.06409328f, -0.03691649f, -0.02011218f, 0.05098742f, 
    -0.01342622f, 0.03042513f, 0.01884846f, -0.03930296f, -0.07278328f, 0.01381365f, 0.04420787f, 0.01394496f, 
    0.05475689f, 0.03932196f, 0.05721275f, 0.01670820f, -0.00365632f, 0.00189707f, 0.03396235f, 0.03977969f, 
    0.02124711f, -0.00604748f, 0.05804978f, -0.04546497f, -0.04819771f, 0.04695647f, -0.07269782f, -0.01834222f, 
    0.06497841f, 0.00022770f, 0.00951336f, -0.05670401f, 0.01211175f, -0.04603824f, 0.00956662f, 0.00538953f, 
    -0.02183300f, -0.04278518f, -0.01066345f, -0.01347695f, -0.00322131f, 0.03560295f, -0.01033099f, -0.05088815f, 
    -0.03650724f, 0.04009529f, 0.04528535f, 0.01807274f, -0.03925362f, -0.07526021f, 0.04419428f, -0.04802151f, 
    -0.04507342f, 0.05404118f, 0.00392294f, 0.02537125f, -0.03071902f, -0.01934894f, 0.09244897f, 0.05818363f, 
    -0.01853790f, -0.09276830f, 0.10048600f, -0.05726300f, -0.30238083f, -0.15711232f, 0.36796373f, -0.02473143f, 
    -0.01687512f, -0.08598115f, -0.04247776f, -0.00641060f, 0.02363855f, -0.07018616f, -0.06712477f, -0.03933569f, 
    0.26274863f, 0.21392362f, 0.04006221f, -0.03314444f, -0.06145955f, -0.00422265f, 0.05660458f, -0.10660165f, 
    0.03882678f, 0.16224368f, 0.01794673f, 0.07401194f, -0.11861588f, -0.15359400f, 0.00673325f, 0.02215497f, 
    -0.09856268f, 0.00653097f, -0.04669806f, -0.00344937f, 0.04572015f, 0.08780865f, -0.01592918f, 0.02337768f, 
    -0.22415797f, -0.28138188f, -0.03127861f, 0.30566439f, 0.06968152f, 0.10821290f, -0.05537523f, 0.06357676f, 
    -0.14417233f, 0.03920048f, 0.00431276f, 0.02400953f, -0.11626463f, -0.04680369f, -0.01424818f, 0.02913602f, 
    0.05680820f, 0.16497828f, -0.04167046f, 0.08701088f, 0.03933108f, -0.09629194f, 0.02765656f, -0.01433320f, 
    0.12869877f, -0.12901764f, 0.24329361f, -0.26769423f, 0.03578546f, 0.01469445f, 0.05963166f, -0.01281235f, 
    0.07435418f, -0.01268739f, 0.02815564f, -0.14245035f, -0.37307817f, -0.03866328f, 0.07371932f, 0.02609987f, 
    -0.16691960f, -0.00017510f, -0.04441953f, -0.08676986f, 0.00194413f, -0.01119369f, -0.08148818f, -0.01607580f, 
    0.29365945f, 0.03220475f, 0.08409722f, -0.16287006f, 0.02289590f, -0.12056486f, 0.20642775f, -0.13295141f, 
    0.23038234f, 0.06973233f, 0.07088650f, -0.00592005f, 0.07950877f, -0.02736248f, 0.30043826f, 0.05676895f, 
    -0.13495353f, 0.00537195f, -0.17496243f, 0.01041122f, 0.00303756f, -0.08117449f, 0.03110152f, 0.14354777f, 
    -0.12180364f, -0.20098670f, 0.08934638f, 0.22294466f, 0.07678933f, 0.08859151f, 0.11533409f, 0.06229221f, 
    0.09318552f, -0.03206137f, 0.14854252f, -0.03257294f, 0.13558516f, 0.08324379f, -0.03376502f, 0.17038953f, 
    -0.18269576f, 0.02080351f, -0.11915091f, -0.03060291f, 0.12748910f, 0.09572762f, -0.06303990f, 0.03853894f, 
    0.24539363f, 0.40478155f, 0.37535828f, 0.02404340f, -0.08904713f, -0.24276312f, 0.17165758f, 0.11590026f, 
    0.05622450f, 0.03038457f, -0.04868961f, 0.10548715f, -0.02229541f, 0.06221644f, -0.24345146f, -0.27634537f, 
    -0.00785924f, 0.04393675f, 0.07685916f, 0.06865227f, 0.03691807f, -0.04848687f, 0.01750842f, -0.06281596f, 
    0.10833333f, -0.24280696f, 0.30956644f, -0.13547891f, 0.09128999f, -0.13358027f, 0.16326213f, 0.07266816f, 
    0.11346006f, 0.03344193f, 0.07581452f, -0.08899912f, -0.41938213f, -0.02305108f, -0.17204502f, 0.17538613f, 
    -0.03382754f, 0.03351189f, 0.01934263f, -0.05833126f, -0.02843981f, 0.04341827f, 0.00932382f, -0.01237918f, 
    0.05349519f, 0.10408682f, 0.07710668f, 0.04701309f, 0.13663164f, 0.00215588f, 0.05285134f, 0.14660811f, 
    0.00303156f, 0.17060386f, 0.04527194f, 0.10148788f, 0.13749617f, -0.08745554f, 0.06946211f, 0.06690236f, 
    0.01372256f, 0.07474084f, 0.08493453f, 0.00315710f, 0.11879796f, -0.11398649f, 0.08779643f, -0.07346518f, 
    0.21242343f, 0.19663772f, 0.24907029f, -0.11920212f, -0.10334323f, -0.00807414f, 0.02777439f, -0.09401190f, 
    -0.01239086f, 0.08057955f, 0.24160801f, -0.02260597f, -0.20479849f, -0.02079540f, -0.01295970f, -0.06016555f, 
    -0.05271915f, -0.04621647f, 0.00524393f, -0.03120930f, 0.15517122f, 0.23650907f, 0.22306342f, 0.13152133f, 
    -0.16557768f, 0.05378268f, -0.30378035f, 0.28070620f, 0.03801530f, 0.23437995f, 0.17412336f, 0.01395719f, 
    0.09736016f, 0.13719609f, 0.04308074f, 0.13719077f, -0.09479157f, -0.39042202f, -0.19773805f, -0.02103368f, 
    -0.07737011f, -0.11687006f, -0.03790452f, 0.16529672f, -0.00339963f, 0.06293820f, -0.09042539f, 0.09941484f, 
    -0.29556763f, 0.11789794f, 0.53625160f, -0.29972419f, -0.13404450f, -0.01162593f, 0.01011379f, 0.02486318f, 
    0.00642743f, -0.00433278f, 0.01860426f, -0.05997764f, -0.30007061f, -0.12755418f, 0.05880498f, 0.08573832f, 
    -0.11519841f, 0.05907855f, 0.02846912f, 0.03307623f, -0.13720670f, -0.03596902f, 0.06815002f, -0.01191486f, 
    0.00051196f, -0.01274716f, 0.20087212f, -0.05963479f, 0.00794771f, -0.21801259f, 0.12114667f, 0.11786503f, 
    -0.01420690f, 0.23617387f, 0.01209115f, 0.08923309f, -0.13600668f, 0.09754016f, 0.19572528f, 0.10575320f, 
    0.05601172f, -0.09448969f, -0.01035756f, 0.01789144f, -0.02762240f, 0.08301133f, 0.06171904f, 0.16123667f, 
    -0.16485764f, -0.04474129f, -0.33437696f, -0.00877543f, -0.01393094f, 0.13285884f, 0.04262498f, 0.14980191f, 
    -0.12849045f, -0.01100664f, -0.09477068f, 0.03785004f, 0.16466711f, 0.53680283f, -0.22774757f, 0.16334188f, 
    0.03773660f, 0.12509255f, -0.07954510f, -0.04269541f, -0.14904456f, -0.12927200f, 0.04017539f, -0.09062646f, 
    0.31925154f, 0.08477560f, 0.18536250f, 0.01856304f, -0.07276532f, 0.06289517f, 0.01697161f, 0.03983084f, 
    -0.03479483f, 0.12860724f, 0.05324446f, 0.10939167f, -0.18525013f, 0.23566142f, 0.06667327f, -0.20084475f, 
    -0.03030312f, 0.04398141f, 0.09286901f, -0.06428336f, 0.00665672f, -0.00796669f, 0.02930249f, -0.03370948f, 
    0.09115232f, -0.35757431f, 0.28074425f, 0.01319001f, 0.12600985f, -0.08977477f, 0.11132473f, 0.06579601f, 
    -0.07039053f, 0.05050803f, -0.03109618f, 0.13960186f, -0.34393004f, -0.00888161f, -0.31309566f, 0.05884152f, 
    0.05655889f, -0.05244945f, 0.11727644f, 0.12098417f, -0.06858181f, 0.00314402f, 0.03262617f, -0.17118101f, 
    0.01136103f, -0.04887038f, -0.14613432f, 0.04615585f, -0.05486456f, -0.02332966f, -0.11397094f, 0.00649074f, 
    0.08428423f, -0.02564999f, -0.04202317f, 0.07981391f, -0.34721738f, -0.05372311f, 0.09143002f, 0.11583440f, 
    0.12769105f, 0.06116233f, 0.03904784f, -0.10883269f, -0.10746705f, -0.00846219f, -0.00960586f, 0.11851011f, 
    0.26660979f, 0.00088908f, -0.06205971f, -0.06828155f, -0.06816207f, -0.07830144f, -0.02120816f, -0.10435233f, 
    0.01205102f, -0.22101051f, 0.06390814f, -0.10427963f, 0.04503153f, -0.03510615f, -0.07241625f, -0.10088354f, 
    0.08854219f, 0.00912208f, -0.06553996f, 0.01046890f, -0.17939091f, -0.07376558f, -0.16947702f, 0.07089686f, 
    0.17280856f, -0.04178822f, -0.20796739f, 0.01574142f, -0.15941553f, -0.06093075f, 0.01625362f, -0.06787699f, 
    -0.07013901f, -0.00454754f, 0.07273777f, -0.09505552f, -0.11199550f, -0.09405799f, 0.25465611f, 0.29377499f, 
    0.00010228f, 0.06117838f, -0.18631576f, -0.15750678f, 0.04655764f, 0.04415232f, -0.05457525f, -0.10155820f, 
    -0.12106067f, -0.05167624f, -0.05326471f, -0.21012330f, 0.02327112f, -0.06744772f, -0.05627074f, 0.02006990f, 
    0.00990845f, 0.00265238f, 0.00550399f, -0.09162521f, 0.06319407f, 0.03361050f, -0.08930191f, 0.18887182f, 
    0.06441281f, 0.05743979f, 0.00525790f, 0.05377153f, 0.05481081f, -0.01064202f, -0.02289803f, 0.01803767f, 
    0.02760809f, 0.10022922f, 0.02154313f, 0.05143965f, -0.00391792f, -0.02802009f, 0.03551792f, -0.08600932f, 
    0.11849277f, 0.19681431f, -0.07425170f, -0.16949469f, -0.05002135f, 0.03696513f, 0.03779944f, -0.01888918f, 
    0.11114102f, 0.07753491f, 0.05611313f, 0.09448559f, -0.16703679f, -0.12410129f, -0.13751361f, 0.07803261f, 
    0.07799661f, 0.16870932f, 0.02784304f, 0.19898124f, 0.35206890f, 0.13912760f, 0.04115972f, 0.02102025f, 
    -0.09006117f, -0.28671339f, 0.11972968f, 0.05543009f, 0.09428902f, 0.14179900f, -0.13136402f, -0.10631586f, 
    -0.11036161f, 0.03281508f, 0.01281578f, -0.03396942f, 0.00924390f, -0.09327399f, -0.00576508f, 0.06906906f, 
    0.37232980f, 0.13321027f, 0.25382584f, 0.39142910f, 0.09174783f, -0.01206868f, 0.14982560f, 0.14064945f, 
    -0.03502881f, -0.01795244f, 0.02622694f, 0.12755316f, 0.01657916f, 0.06568323f, -0.00751204f, -0.08186397f, 
    -0.08926668f, 0.03312976f, 0.03857869f, 0.03800403f, 0.01497804f, 0.03905407f, -0.12340236f, 0.01178540f, 
    0.16402839f, -0.04799199f, 0.16159542f, 0.05860585f, 0.07011222f, -0.10762423f, -0.04612039f, -0.09412301f, 
    -0.03309073f, 0.06775707f, 0.01474855f, -0.02049922f, -0.05820397f, -0.16787571f, -0.05354619f, 0.03861021f, 
    -0.07366382f, 0.12130492f, -0.15957049f, 0.08666998f, -0.22595054f, -0.11841244f, 0.03854903f, -0.04672816f, 
    0.00294434f, 0.01253154f, -0.04123920f, -0.05622692f, -0.09880465f, 0.23995030f, 0.16147381f, 0.10793953f, 
    -0.07237982f, -0.18025321f, -0.03313082f, -0.10028895f, 0.18233909f, 0.17122865f, 0.20796235f, -0.12870198f, 
    0.08047011f, -0.01707773f, -0.06238664f, -0.00530219f, 0.15176271f, 0.01550379f, -0.10027198f, -0.07003475f, 
    0.15755668f, 0.04287310f, 0.03516288f, 0.06429207f, 0.08205146f, -0.03605102f, 0.08338229f, -0.11761066f, 
    -0.05803440f, 0.13819999f, -0.02211479f, -0.07426015f, 0.07966498f, -0.03962880f, -0.10022996f, 0.04241674f, 
    -0.03960606f, 0.04562033f, -0.03180063f, -0.04243992f, 0.13030635f, 0.04554528f, -0.02709310f, -0.16007176f, 
    -0.37268770f, -0.13677289f, 0.38204741f, 0.09037288f, 0.13934180f, 0.10185775f, 0.07181295f, 0.01034130f, 
    -0.05581461f, -0.04175554f, -0.04582508f, 0.09757406f, 0.24940865f, 0.15348096f, -0.19646588f, -0.02919866f, 
    -0.00796545f, 0.05228432f, 0.01047399f, 0.02995796f, -0.13925275f, 0.01172162f, 0.04191108f, 0.04425570f, 
    0.05667083f, 0.07374010f, 0.44875666f, 0.09238012f, 0.06898527f, 0.01903335f, 0.00680716f, 0.04952988f, 
    -0.00937811f, -0.19157663f, -0.05005655f, -0.05501639f, 0.05452141f, 0.14641209f, 0.09494923f, -0.10331229f, 
    0.04312757f, 0.01861423f, 0.15032934f, 0.12662177f, -0.02783715f, -0.06626125f, 0.01689181f, 0.00108513f, 
    0.11477498f, -0.17014945f, 0.20221776f, 0.07189122f, 0.01877689f, -0.08302575f, -0.01099753f, -0.11165866f, 
    -0.01660327f, -0.24751878f, 0.08687690f, 0.08559884f, 0.32010683f, -0.00420229f, -0.17858255f, 0.10034259f, 
    -0.08916409f, -0.02589358f, -0.16583183f, 0.00646935f, -0.00526603f, -0.05470521f, 0.03694680f, 0.07149119f, 
    0.05176492f, 0.06659172f, 0.12074956f, 0.09316874f, 0.06693824f, 0.03065219f, -0.12391142f, 0.08401278f, 
    0.04509571f, -0.02044191f, -0.04658387f, -0.03816445f, -0.08863253f, -0.14653902f, 0.25382006f, 0.32307592f, 
    0.03284851f, -0.03444991f, -0.05327869f, -0.04404786f, 0.15890954f, 0.08059128f, -0.04328878f, 0.07249952f, 
    -0.00707238f, 0.13132048f, -0.06567162f, -0.30775589f, 0.00684695f, -0.22377464f, 0.10436195f, -0.08955349f, 
    0.03210192f, -0.03829098f, -0.12013508f, -0.01137726f, 0.02891305f, 0.06039483f, 0.04450592f, -0.03760348f, 
    -0.09838387f, -0.02205575f, -0.07770322f, 0.05067543f, 0.00802212f, -0.12563333f, -0.06885508f, -0.04356255f, 
    -0.10295030f, -0.03787182f, -0.05978714f, 0.04783754f, 0.09837192f, 0.11317683f, -0.19051738f, 0.22112423f, 
    0.05196310f, -0.08235731f, 0.09566401f, -0.00710164f, 0.07046546f, 0.18180345f, 0.16462249f, 0.09082898f, 
    0.16347820f, 0.17644185f, 0.02314976f, -0.08442603f, -0.01732707f, 0.06323338f, -0.02929381f, -0.07680628f, 
    0.13341288f, -0.01148892f, 0.06767964f, -0.09580725f, -0.01422694f, 0.00839916f, -0.01253149f, -0.06321409f, 
    -0.01137256f, 0.17827669f, -0.00053967f, 0.06043641f, -0.00903427f, -0.08359881f, -0.09290703f, 0.30513570f, 
    0.08882087f, -0.02501326f, 0.01564255f, -0.02427873f, -0.00531299f, -0.04450989f, 0.07410514f, -0.16730832f, 
    0.23892976f, 0.16591631f, 0.32165349f, -0.10737213f, -0.02587678f, 0.05047729f, -0.03050770f, -0.01657132f, 
    0.14037846f, 0.00046854f, 0.13982163f, -0.00882952f, 0.08439798f, -0.00960486f, 0.06534201f, 0.04002323f, 
    0.08534151f, -0.02059698f, -0.09099195f, -0.03669369f, -0.02074675f, 0.03913457f, 0.04852039f, -0.10197130f, 
    -0.27258250f, -0.09612278f, -0.06912595f, 0.13599059f, 0.02230627f, 0.19204132f, -0.03396919f, -0.00002553f, 
    0.01727610f, 0.02731087f, -0.00318103f, 0.22045164f, 0.00803386f, -0.20693503f, -0.03568773f, 0.21069609f, 
    -0.09992084f, -0.04649941f, 0.02091341f, 0.16911668f, -0.08025461f, 0.11355630f, -0.09346852f, 0.03623537f, 
    -0.41969353f, 0.32519850f, 0.25521550f, -0.17214370f, -0.26712945f, -0.07660510f, -0.05623002f, -0.08339453f, 
    0.00393273f, 0.00486965f, -0.05589720f, -0.06728154f, -0.11266585f, -0.02718365f, 0.15779437f, 0.13499193f, 
    0.09593170f, 0.14509994f, 0.01723215f, 0.19367675f, -0.13145585f, 0.02922135f, 0.07002846f, -0.10332788f, 
    0.01689833f, 0.10318295f, 0.15709864f, 0.04118645f, -0.23077157f, -0.03548918f, 0.13470368f, 0.15395311f, 
    0.13034384f, 0.16000485f, -0.02562079f, -0.07405747f, -0.06367497f, 0.07134952f, 0.11070316f, -0.04837168f, 
    0.12903652f, -0.10644166f, -0.12674022f, 0.00583683f, -0.11118656f, -0.03567090f, 0.07388878f, 0.03833227f, 
    -0.01569739f, -0.01381844f, -0.14045325f, 0.22477882f, -0.01902625f, 0.12946618f, -0.02295396f, 0.08191755f, 
    -0.06716204f, 0.03895609f, -0.13476506f, 0.01965106f, -0.08598329f, 0.58362037f, -0.10593126f, 0.14975460f, 
    0.08486390f, -0.02335640f, -0.06509174f, -0.03731054f, -0.14238755f, -0.20802374f, -0.13026197f, -0.13445070f, 
    0.45150274f, -0.04390531f, 0.11317197f, 0.01233098f, -0.10985096f, -0.09621965f, 0.08357710f, 0.02835240f, 
    -0.05625442f, -0.05892275f, -0.05419219f, -0.02793295f, -0.09404451f, -0.00354750f, 0.08123971f, 0.06757767f, 
    -0.09660349f, -0.21260776f, -0.02093245f, 0.00593947f, 0.20948300f, 0.06758113f, 0.07780658f, 0.03603070f, 
    0.08885390f, -0.28871408f, 0.36426485f, -0.01432335f, 0.10456499f, -0.09887467f, -0.03258525f, -0.10051599f, 
    -0.23057500f, -0.08163041f, -0.07432592f, 0.03528650f, -0.28240302f, 0.00654866f, -0.21623914f, 0.31086683f, 
    0.08777344f, 0.04106383f, -0.04034355f, 0.24164687f, -0.03678612f, 0.14541242f, 0.07261762f, -0.10937449f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.04971562f, 0.01828556f, -0.06025237f, -0.04007335f, -0.02648235f, -0.04404898f, 0.24322823f, -0.05341021f, 
    -0.05885528f, 0.14158311f, -0.02125438f, 0.00607881f, 0.05055783f, -0.07462474f, -0.06467535f, 0.15887141f, 
    0.12517460f, 0.04106993f, 0.01173007f, 0.14692776f, 0.15294060f, -0.06413861f, 0.16229787f, 0.12728167f, 
    0.12827009f, -0.12804811f, -0.08363243f, -0.02569316f, -0.07275301f, 0.02086360f, 0.07776454f, 0.12492994f, 
    -0.08660296f, 0.09526525f, 0.22359554f, -0.15095983f, -0.00918758f, 0.02300490f, 0.09569493f, -0.06366061f, 
    -0.02520726f, 0.27267712f, 0.09401576f, 0.07171337f, 0.02074887f, 0.06244452f, 0.14046282f, -0.05162223f, 
    0.11460888f, 0.16555080f, -0.08297309f, 0.06757864f, 0.13004345f, -0.03796541f, -0.01169587f, -0.10173842f, 
    0.09209613f, 0.10194506f, 0.15543249f, -0.09548458f, 0.06370477f, 0.06082622f, 0.17205742f, 0.03348279f, 
    -0.03767716f, -0.00184318f, 0.01249809f, -0.05737505f, 0.02229804f, 0.11206863f, -0.01306653f, 0.06204394f, 
    0.01507812f, 0.01443528f, 0.04213330f, -0.08781688f, 0.30504861f, 0.09996869f, -0.08188224f, -0.05993420f, 
    0.04826616f, 0.05421660f, -0.02278466f, -0.08109768f, -0.07331832f, -0.06086512f, 0.00465628f, 0.13932480f, 
    0.03972241f, -0.00741280f, 0.08283473f, -0.00740276f, 0.09243295f, -0.01297887f, 0.14953770f, 0.14045161f, 
    0.12155406f, 0.09998564f, 0.05630427f, 0.08001804f, -0.01560460f, -0.13381064f, 0.13260438f, 0.04334444f, 
    0.18037336f, 0.04498400f, 0.15441382f, 0.03696677f, 0.05247645f, 0.16949420f, -0.06900850f, -0.09207553f, 
    0.11624885f, -0.05870431f, -0.02549807f, 0.10857644f, -0.04905974f, -0.00575997f, 0.00704259f, -0.11445126f, 
    0.03830826f, -0.02715072f, -0.02501940f, 0.15307230f, 0.14594491f, -0.12379684f, 0.01972533f, 0.08721046f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.01306723f, -0.38055179f, -0.01790554f, 0.17290512f, 0.00103009f, 0.15882875f, -0.19616123f, 0.02078814f, 
    0.01889721f, -0.08608203f, 0.08842074f, -0.37957391f, 0.17657734f, 0.37438351f, -0.08801620f, -0.16031003f, 
    0.03619642f, 0.00633061f, -0.05677626f, -0.04793151f, -0.04012932f, 0.08087560f, -0.03626103f, 0.04335627f, 
    -0.29583511f, 0.17004167f, -0.60142362f, -0.07234161f, -0.17013560f, -0.00144830f, 0.12635751f, -0.24690437f, 
    0.09500741f, -0.13405034f, -0.03833687f, 0.08154169f, -0.04968486f, -0.02264772f, -0.07216500f, -0.09083685f, 
    0.23439744f, -0.35529524f, -0.16144672f, 0.17967054f, -0.05911499f, 0.16760819f, -0.56736475f, -0.11946515f, 
    0.03137036f, -0.07733290f, 0.00130165f, -0.43844092f, 0.07790203f, -0.16695382f, -0.11123580f, 0.07571311f, 
    -0.54634213f, -0.23258787f, -0.06100651f, 0.18124545f, -0.00796133f, -0.05354618f, -0.35888493f, 0.04665652f, 
    -0.07983121f, -0.02539712f, 0.06116382f, 0.01713422f, 0.01082141f, 0.05132199f, 0.13515688f, 0.04035361f, 
    -0.05734978f, 0.00080686f, -0.16186206f, 0.14296743f, -0.18464775f, 0.03431171f, 0.01847461f, 0.07219733f, 
    0.14028378f, -0.07862493f, -0.09140645f, 0.06465581f, 0.04623772f, -0.01029168f, -0.08022350f, -0.35324892f, 
    -0.26371038f, -0.16313967f, -0.05042828f, 0.09786953f, 0.01174915f, 0.22700152f, -0.17792845f, -0.23971994f, 
    -0.24557908f, -0.23663683f, -0.32626051f, -0.10489868f, 0.07266446f, 0.09535863f, -0.24097045f, 0.04196328f, 
    -0.37262273f, -0.31275776f, -0.23452662f, 0.19052483f, 0.05609037f, 0.05760989f, -0.05949208f, -0.20768639f, 
    0.01057845f, 0.03671414f, -0.06059361f, -0.08753142f, 0.09879728f, 0.02564141f, -0.40522254f, 0.20115560f, 
    -0.00334743f, 0.08163886f, 0.06851482f, -0.31885341f, -0.22472019f, 0.00503831f, 0.04072335f, -0.30687210f, 
    -0.07098912f, 0.00565467f, 0.04198495f, 0.21215981f, -0.03225815f, 0.01482641f, 0.23720804f, 0.01266044f, 
    -0.02165274f, 0.09331008f, 0.13285001f, -0.07865205f, -0.03644611f, -0.09501719f, -0.07196465f, -0.20121005f, 
    0.07220502f, 0.02197600f, -0.04693033f, 0.14844801f, 0.05762339f, 0.00486343f, 0.03975424f, 0.09730858f, 
    0.03096408f, 0.01272396f, 0.08008884f, 0.03371308f, -0.04166358f, -0.09158199f, 0.07242987f, 0.12044616f, 
    0.13511015f, -0.17368373f, 0.19562963f, -0.56195593f, 0.08021382f, 0.02896310f, 0.20681024f, -0.03123999f, 
    -0.01017796f, 0.29951990f, -0.07637117f, 0.10132968f, 0.04001332f, 0.09908191f, -0.25775787f, -0.35161304f, 
    0.31573370f, 0.06831926f, 0.10290790f, -0.10707186f, 0.10223281f, -0.08576342f, -0.13153742f, 0.37696585f, 
    -0.24417186f, 0.05761549f, 0.22209613f, -0.26487824f, 0.06278437f, -0.47078174f, -0.00215382f, -0.00230792f, 
    -0.07227151f, 0.00509450f, -0.09363585f, -0.03926450f, 0.07760563f, -0.41077590f, 0.01920199f, -0.01289592f, 
    -0.00136856f, 0.02351663f, 0.15810093f, 0.10223205f, 0.46032211f, 0.15310612f, 0.10975969f, -0.04390048f, 
    0.16390377f, 0.00196565f, -0.07656730f, -0.04416267f, -0.06917346f, 0.02121237f, 0.07095177f, -0.10438749f, 
    0.30246741f, 0.06810807f, -0.24719696f, -0.69309944f, 0.17719187f, 0.06899802f, 0.07317311f, -0.09510791f, 
    -0.16325757f, 0.05009091f, 0.06287859f, -0.36002088f, -0.06317865f, 0.03046221f, -0.06660848f, -0.02163517f, 
    0.15054612f, 0.05309217f, 0.08596335f, -0.07163563f, 0.05844402f, 0.09677418f, -0.02057706f, -0.26545981f, 
    -0.01441962f, 0.01839364f, 0.07689303f, -0.20025660f, -0.04482488f, 0.10777777f, 0.04712011f, -0.53676987f, 
    -0.01836472f, -0.34719890f, 0.08103240f, -0.05521924f, -0.01197683f, -0.06421320f, 0.11247000f, 0.03305434f, 
    0.01527005f, -0.10602212f, -0.05700270f, 0.09989493f, 0.01825052f, -0.07219630f, -0.07210111f, 0.03713468f, 
    -0.05145373f, 0.07894900f, -0.19523065f, -0.18940516f, -0.04950749f, -0.41834408f, -0.07851237f, 0.19168578f, 
    0.07857273f, 0.00120781f, 0.04813463f, 0.03397416f, 0.11986467f, 0.07140104f, 0.06134894f, 0.05990357f, 
    0.11474314f, 0.07007948f, 0.20851237f, 0.02025206f, -0.33537421f, -0.05788407f, 0.04013288f, -0.10451774f, 
    0.00851406f, -0.02048884f, 0.11339521f, -0.27609146f, 0.02683507f, 0.15607457f, -0.14716263f, 0.05377403f, 
    -0.00764989f, 0.28364968f, -0.27493474f, -0.04836988f, -0.08412531f, 0.17094254f, 0.38281214f, 0.10372132f, 
    -0.35792452f, -0.05766594f, -0.13328412f, -0.31766528f, 0.19553670f, 0.06534722f, -0.06035225f, 0.30659553f, 
    0.23620445f, 0.15126243f, -0.12656857f, 0.36365381f, 0.07168821f, -0.20984127f, 0.13410230f, -0.07263860f, 
    -0.03673960f, 0.00828699f, 0.05520456f, -0.06264421f, 0.02165153f, -0.41354233f, -0.07537767f, 0.01620798f, 
    -0.08373430f, -0.01632038f, -0.33399150f, -0.28647348f, -0.43502718f, -0.15029022f, 0.01342071f, 0.01475202f, 
    -0.15443775f, -0.04062637f, -0.04835714f, 0.00138260f, 0.00754197f, 0.06565009f, -0.22234897f, 0.03732262f, 
    -0.49413767f, 0.01457777f, -0.03388758f, -0.11565669f, -0.15116595f, -0.32417548f, 0.01880475f, 0.09893617f, 
    0.01058595f, -0.33182585f, -0.02598602f, -0.10106560f, 0.04851004f, -0.45381916f, -0.00617727f, 0.01027378f, 
    0.21561597f, 0.27057374f, -0.04420980f, -0.12151674f, 0.01068958f, 0.06554516f, 0.06883480f, -0.12917145f, 
    0.03974677f, 0.08557434f, -0.09345259f, 0.28561628f, -0.10591471f, 0.06653803f, -0.07836758f, 0.01547629f, 
    0.05227492f, 0.13865739f, 0.06056679f, 0.12465391f, 0.16160002f, 0.06097329f, -0.05697267f, -0.00080525f, 
    -0.08059204f, 0.02298874f, 0.01460444f, 0.15693919f, 0.08153459f, -0.24996276f, -0.43740827f, -0.07178177f, 
    -0.01242873f, -0.45610401f, 0.30142990f, 0.04559953f, -0.06029539f, 0.04628500f, -0.04897938f, -0.59167856f, 
    0.12264769f, -0.05679799f, -0.27497151f, -0.51630902f, -0.48729575f, 0.04209760f, -0.33216712f, -0.29186442f, 
    0.11971919f, 0.10410819f, 0.39363420f, -0.04623492f, -0.25154302f, 0.04407431f, -0.10173815f, -0.16032998f, 
    -0.05701605f, -0.22742763f, -0.32008797f, 0.10476242f, -0.02753335f, 0.05556724f, 0.07711052f, -0.05850194f, 
    -0.06183011f, -0.48648110f, 0.09343980f, -0.41602677f, -0.03623284f, -0.04770671f, 0.02816026f, 0.13770849f, 
    -0.15969409f, -0.16184451f, 0.08063121f, -0.40430972f, 0.06307159f, 0.00821283f, 0.26024032f, 0.12272789f, 
    0.31914166f, 0.07723720f, -0.02586245f, 0.02634361f, 0.05876293f, 0.24782707f, -0.12921968f, 0.06343274f, 
    0.05554834f, -0.06415314f, -0.05382831f, -0.07698575f, 0.02064772f, -0.43542275f, 0.06760828f, -0.06913696f, 
    -0.06854394f, -0.01190110f, 0.02282041f, 0.03111688f, -0.55223823f, -0.17822371f, 0.08722406f, 0.02458541f, 
    -0.36503783f, 0.07397459f, 0.04628586f, -0.09023503f, -0.00030379f, -0.07161251f, -0.00360642f, -0.01382906f, 
    0.34790641f, 0.00005413f, -0.03495375f, 0.04925147f, 0.05789480f, 0.21678166f, -0.38391304f, -0.10297508f, 
    -0.39242804f, -0.54056841f, 0.11769788f, -0.14136890f, -0.07380369f, 0.14078547f, 0.08845670f, 0.02189847f, 
    0.00431563f, 0.19445127f, 0.07280337f, -0.05500249f, 0.03274294f, -0.03002115f, -0.02943147f, 0.16734323f, 
    0.14149725f, 0.06096208f, 0.03679104f, 0.01722004f, -0.00841263f, -0.03882672f, 0.13461818f, 0.08468780f, 
    0.13651547f, 0.06701826f, 0.06580191f, -0.21201169f, 0.05253810f, 0.23266180f, -0.22825098f, 0.30275127f, 
    -0.01931234f, -0.06251395f, -0.00972115f, 0.15586983f, 0.03078263f, 0.05540925f, -0.01179665f, -0.04679960f, 
    -0.01280114f, 0.16405293f, -0.19779250f, 0.13445473f, -0.01316811f, -0.07460956f, -0.07585447f, 0.25117534f, 
    -0.05173154f, 0.01758860f, 0.07949977f, -0.00064937f, -0.37754744f, -0.08876821f, -0.15727849f, 0.05318899f, 
    -0.79483026f, 0.04592887f, -0.19426417f, -0.07932561f, 0.02263297f, -0.08213080f, -0.31012323f, 0.03073171f, 
    0.17348412f, 0.15509336f, -0.01930309f, 0.17221877f, -0.06862693f, 0.05859607f, -0.14871666f, -0.03516448f, 
    -0.06369857f, -0.04056692f, -0.09428437f, 0.00695424f, 0.05965736f, -0.19751941f, 0.24490836f, 0.06849856f, 
    -0.25045353f, -0.01795795f, 0.14861716f, 0.22486524f, -0.12170877f, -0.11627666f, -0.10744090f, 0.20294513f, 
    -0.32697162f, -0.08866838f, -0.13662209f, 0.18014692f, -0.02762589f, -0.03224064f, -0.14282992f, -0.08141816f, 
    0.00551834f, -0.04215355f, -0.08056770f, -0.06732895f, 0.01131726f, 0.00834066f, -0.03948199f, 0.05508615f, 
    0.01225181f, 0.02399902f, -0.08757253f, -0.03296010f, -0.05826412f, -0.05787505f, 0.07839659f, 0.07704130f, 
    -0.08498479f, -0.01541064f, 0.06098970f, 0.00274181f, 0.01408372f, -0.07341376f, 0.06102921f, -0.28007796f, 
    -0.23775087f, -0.03884815f, -0.02293777f, 0.25045002f, 0.12285571f, -0.35691154f, -0.14219409f, 0.10383064f, 
    0.20203854f, 0.11642520f, -0.33066812f, -0.05869099f, -0.03430716f, 0.11939725f, -0.09032275f, -0.03528356f, 
    -0.27332100f, -0.49674395f, 0.02822145f, -0.19479804f, 0.02550943f, -0.05133244f, -0.03454641f, 0.35604042f, 
    0.10285185f, -0.01405530f, -0.05003069f, 0.07943569f, 0.10250622f, 0.08198091f, 0.16968785f, 0.13065015f, 
    0.02028888f, 0.10383250f, -0.05221287f, 0.01475479f, -0.36772129f, 0.11174710f, 0.05666175f, -0.25890335f, 
    -0.05835988f, -0.01664819f, -0.02826343f, -0.21369015f, 0.08732639f, 0.18989190f, -0.01379677f, -0.01041453f, 
    -0.05533907f, 0.00072922f, -0.07306647f, 0.13413943f, 0.10537195f, 0.02858749f, -0.08828250f, 0.43392920f, 
    0.04407594f, 0.07722133f, -0.11884435f, 0.07420852f, -0.28937641f, -0.03859261f, 0.14112586f, -0.08485773f, 
    -0.35556802f, -0.08120449f, -0.79715872f, -0.07457747f, -0.01165130f, -0.02398797f, 0.29147172f, 0.02788430f, 
    -0.22192936f, 0.19109935f, -0.00743544f, -0.14809120f, 0.05997683f, -0.15706742f, -0.32830435f, 0.04694425f, 
    -0.11010171f, 0.07775240f, 0.27824718f, -0.04633152f, -0.01062241f, -0.16433041f, -0.22510958f, -0.20214827f, 
    -0.31174445f, 0.14953481f, 0.05716470f, 0.15573749f, 0.10602434f, -0.27195334f, -0.41911358f, -0.35997018f, 
    -0.37766162f, -0.10564409f, 0.25839391f, -0.28165805f, -0.00181123f, 0.15640146f, -0.16975124f, 0.06404483f, 
    -0.01649540f, 0.02637640f, 0.04880705f, -0.03323457f, -0.01577348f, 0.31607443f, -0.02976818f, 0.07311927f, 
    0.17452997f, -0.02231137f, -0.14530990f, 0.01666938f, 0.05089387f, 0.12330640f, 0.03660375f, -0.07680842f, 
    0.09713158f, -0.05443583f, 0.01609295f, -0.04332160f, -0.03552960f, 0.06107968f, -0.12363165f, 0.12153432f, 
    0.27201873f, 0.09237606f, -0.10869236f, -0.31800997f, 0.06667982f, -0.05437958f, 0.17135403f, 0.27896753f, 
    0.03999634f, 0.07824507f, -0.03371613f, 0.51379985f, 0.05443665f, 0.10110708f, 0.15302147f, 0.02215641f, 
    -0.18483642f, -0.00865600f, -0.63358527f, 0.20388527f, -0.00533139f, 0.06935865f, 0.00028695f, -0.18882641f, 
    0.13487078f, -0.10228390f, -0.02007626f, 0.28394169f, 0.03066660f, -0.00334169f, -0.42789432f, 0.02224526f, 
    -0.00217057f, -0.00321428f, -0.04747932f, -0.06182842f, -0.21088006f, -0.08069762f, 0.01723051f, -0.14391273f, 
    -0.03824388f, 0.05306015f, 0.03507122f, -0.02312223f, -0.00374292f, -0.06544127f, 0.20938717f, -0.06826422f, 
    0.03047237f, 0.03899824f, -0.21667494f, -0.24470647f, -0.06659391f, -0.82180297f, -0.09403108f, 0.32210660f, 
    -0.01564063f, 0.03364953f, 0.17112516f, 0.06045472f, 0.21964370f, -0.00046461f, 0.07833204f, 0.06955837f, 
    0.05021147f, -0.14086118f, 0.15297128f, 0.00752020f, 0.11828460f, -0.04641395f, -0.57461262f, -0.14032714f, 
    0.10490961f, 0.13685319f, 0.27042213f, 0.10779909f, 0.02649542f, -0.19833599f, -0.01744520f, -0.08517830f, 
    -0.00872260f, 0.01022809f, 0.32497931f, 0.07602298f, -0.01712187f, -0.23179527f, 0.40325040f, 0.12714855f, 
    0.10688934f, 0.07098518f, -0.39095697f, -0.28551307f, -0.69196832f, 0.12879597f, 0.13608558f, -0.61436832f, 
    0.15837781f, 0.13952500f, -0.19739246f, -0.36015254f, 0.02505599f, -0.08463770f, 0.19582167f, 0.04576570f, 
    0.04311815f, -0.02581129f, -0.01157849f, -0.01382547f, -0.07588412f, 0.32427847f, -0.37700555f, -0.02502321f, 
    -0.15756087f, -0.03283185f, 0.12186556f, -0.42989391f, 0.05866168f, -0.47029972f, -0.21363358f, -0.06446321f, 
    -0.26116517f, 0.06187426f, 0.00655744f, 0.03127776f, 0.06461544f, -0.06743979f, -0.06399952f, 0.05187215f, 
    -0.25510731f, -0.06833608f, 0.21821702f, 0.05756000f, -0.55084956f, 0.19489625f, 0.08107791f, -0.16494969f, 
    0.13769919f, 0.05919234f, -0.14003408f, -0.09466936f, 0.01384973f, -0.14556344f, 0.09930188f, 0.06546170f, 
    -0.33681178f, 0.08667615f, -0.35131881f, 0.17823856f, -0.07905527f, 0.12853448f, -0.02099616f, 0.08749927f, 
    -0.52392507f, 0.04071196f, -0.00699027f, -0.01971796f, -0.29339880f, -0.01476637f, -0.19589181f, -0.32523394f, 
    -0.25091586f, 0.16150725f, -0.03201578f, 0.13015653f, 0.09811121f, 0.04608466f, -0.42524853f, -0.22999588f, 
    -0.03746084f, -0.00618201f, -0.05601315f, -0.50533456f, -0.03804711f, 0.16768409f, -0.23675473f, 0.07439835f, 
    0.02952736f, -0.21695670f, 0.16398233f, 0.18621372f, -0.20372190f, 0.21873794f, -0.08317984f, 0.05133503f, 
    -0.24559991f, 0.09872974f, 0.16717254f, -0.21516873f, -0.08541082f, 0.00743402f, 0.05750455f, -0.02149308f, 
    0.15015303f, 0.11882658f, 0.14803785f, -0.06950168f, 0.07925787f, -0.04872966f, 0.02222604f, -0.04271550f, 
    -0.01801112f, -0.09947245f, -0.19708332f, 0.37218833f, -0.08225688f, -0.04480502f, -0.23930687f, -0.00901530f, 
    -0.25157505f, -0.18588226f, -0.07316475f, -0.03869632f, 0.01646904f, -0.30340734f, -0.48064873f, 0.11547530f, 
    0.11901046f, -0.29489782f, 0.21853322f, 0.21946973f, -0.40278167f, 0.06200650f, -0.09073285f, -0.31094635f, 
    0.04476279f, -0.48652947f, -0.33962953f, 0.37669232f, 0.02539963f, 0.24525386f, -0.19330585f, -0.00828537f, 
    -0.08788037f, 0.05366171f, 0.00659962f, -0.02690100f, 0.03301603f, -0.39547944f, -0.22356401f, -0.06927183f, 
    0.21158458f, 0.05939144f, -0.14549647f, -0.24656585f, -0.25380722f, -0.09785485f, -0.17132954f, 0.04901540f, 
    0.02188359f, 0.07869063f, 0.04691535f, 0.08014055f, 0.01261230f, -0.08080550f, -0.02316104f, 0.03171701f, 
    0.03757420f, 0.06320120f, -0.18291849f, -0.23434830f, -0.63226742f, -0.24493971f, 0.10222303f, -0.22894840f, 
    -0.01466833f, 0.20609564f, 0.12443918f, 0.05070367f, 0.08077496f, -0.10890803f, 0.03564525f, -0.03950700f, 
    0.20614588f, -0.03788323f, 0.01594951f, 0.10698738f, 0.01443216f, -0.59069717f, -0.07558514f, 0.01329327f, 
    -0.08067170f, -0.02936187f, -0.03127694f, 0.16849862f, -0.28730443f, 0.05505613f, 0.25396806f, 0.15836149f, 
    -0.13737406f, 0.01987785f, 0.05811157f, 0.00013705f, 0.00786558f, 0.07101168f, -0.06850158f, -0.01779656f, 
    -0.01451272f, -0.26695064f, 0.04772859f, -0.47346783f, -0.03933039f, -0.22774133f, -0.10488776f, 0.02153247f, 
    0.06949112f, 0.03805006f, 0.24613494f, -0.01355777f, -0.56873930f, -0.13040443f, -0.05371143f, -0.19502765f, 
    0.11823583f, -0.00260507f, -0.13519344f, -0.44007343f, -0.08356040f, 0.05753350f, 0.09450577f, -0.31077996f, 
    0.02472166f, -0.30782768f, -0.27020821f, -0.00542338f, 0.21330069f, 0.07006732f, 0.25214294f, 0.16082612f, 
    -0.30863094f, 0.04385876f, -0.28744656f, -0.49437049f, -0.06936558f, 0.13370261f, 0.16120209f, -0.00374840f, 
    -0.20469438f, -0.43937519f, -0.10887337f, -0.33478594f, 0.03198207f, 0.11045756f, -0.12120449f, -0.24137022f, 
    0.06662501f, -0.08101622f, -0.56903291f, 0.08312240f, 0.27739739f, -0.23714297f, -0.08337044f, -0.28036967f, 
    0.34549049f, -0.06845393f, -0.26824883f, -0.25695217f, 0.03844338f, 0.39421016f, 0.18131244f, -0.06963615f, 
    0.03686759f, -0.01841109f, 0.07307646f, 0.01429000f, 0.08116478f, -0.05695676f, 0.16786480f, 0.02966513f, 
    0.16737743f, 0.00764415f, -0.14602305f, 0.01788262f, -0.17986348f, 0.00528067f, 0.12994798f, 0.07572323f, 
    0.08934890f, -0.03729248f, -0.00769164f, 0.06861190f, -0.01307147f, -0.01927339f, 0.00343548f, 0.21063226f, 
    -0.12684050f, 0.03625857f, 0.18843120f, -0.13775355f, -0.52173859f, 0.36153397f, 0.01457970f, 0.06893272f, 
    -0.14386554f, 0.20096140f, 0.18325606f, 0.04451159f, -0.01115317f, -0.35192695f, 0.20473586f, -0.04573461f, 
    0.39760861f, 0.24439810f, 0.07097884f, 0.02222115f, -0.04011889f, 0.15176670f, 0.03737269f, -0.15857978f, 
    0.09914755f, 0.02754416f, 0.00029901f, 0.00483289f, -0.48234203f, 0.02218174f, -0.00825584f, -0.19729972f, 
    0.24733588f, -0.20818572f, -0.05239886f, -0.30036527f, 0.09540197f, -0.15719922f, -0.55544239f, -0.21787411f, 
    0.05495304f, -0.02878144f, 0.07423359f, -0.03065070f, 0.04178350f, 0.09646822f, -0.30048230f, -0.06999213f, 
    0.00590787f, -0.41109279f, -0.42907599f, 0.19018823f, 0.05306260f, 0.11468080f, -0.01159234f, -0.07224073f, 
    -0.29380566f, -0.08239213f, 0.22268637f, 0.14418839f, 0.12839729f, -0.04040226f, -0.14468539f, 0.18087801f, 
    0.04991242f, -0.25895900f, -0.02367156f, -0.09170753f, -0.18132260f, -0.07318129f, -0.23467998f, -0.43975452f, 
    0.22561039f, -0.09416325f, -0.39912146f, -0.20107986f, -0.06266518f, -0.30095071f, -0.55522859f, 0.01015120f, 
    0.01352080f, 0.23163599f, -0.46807575f, 0.14725745f, 0.01256297f, -0.34971476f, -0.24946544f, 0.16265377f, 
    -0.27416036f, -0.03322954f, -0.05527071f, 0.32762924f, -0.44660476f, 0.00882063f, 0.03178667f, -0.37672931f, 
    0.16015689f, 0.27723187f, 0.34685043f, -0.01431690f, 0.07644852f, -0.20271114f, 0.17724919f, 0.03686003f, 
    -0.01135497f, 0.06938235f, -0.08369359f, -0.05970928f, 0.07593100f, 0.03085447f, 0.17768921f, -0.02228255f, 
    -0.14015479f, -0.02243363f, 0.05544059f, 0.10214061f, 0.00513808f, 0.13473879f, -0.20656747f, -0.02463296f, 
    -0.17148903f, -0.03023589f, -0.06015222f, -0.05648969f, 0.02325574f, 0.08091584f, 0.04023515f, 0.12934566f, 
    -0.06917675f, -0.01946371f, 0.20245069f, 0.40427268f, 0.15003563f, -0.57287908f, -0.06132503f, -0.27615729f, 
    0.26355600f, 0.06762111f, -0.09940676f, 0.07254459f, 0.00635970f, -0.31378126f, -0.34606943f, 0.04910619f, 
    -0.29809320f, -0.43412161f, 0.39887139f, 0.20000271f, -0.03151567f, -0.02372950f, 0.00751847f, -0.21600647f, 
    -0.28205657f, -0.04123918f, 0.06757047f, -0.12758933f, 0.15811349f, -0.06327324f, 0.22124594f, -0.12758461f, 
    -0.41715434f, 0.20784481f, -0.05688970f, 0.10317400f, 0.16407171f, -0.14351563f, -0.01359743f, 0.19103891f, 
    0.00088975f, 0.35967252f, -0.07976191f, -0.53937954f, -0.06051959f, -0.37394488f, -0.18970588f, 0.07207403f, 
    0.07281002f, -0.26795021f, -0.18486020f, -0.02616559f, 0.06881092f, -0.15689847f, -0.00021118f, -0.48654056f, 
    0.04079665f, 0.00470107f, -0.21800731f, 0.09944921f, -0.19823153f, -0.02152117f, 0.08181246f, -0.15886426f, 
    -0.17259085f, 0.02722055f, -0.33022624f, -0.03444074f, -0.20920774f, 0.03622870f, 0.28816170f, 0.07683572f, 
    -0.14391589f, 0.14595078f, 0.04957463f, 0.25153843f, -0.00383812f, 0.20034748f, 0.46737400f, 0.01393281f, 
    -0.00768856f, -0.22283167f, -0.21155179f, -0.28235334f, -0.06192773f, 0.09361871f, -0.14991346f, 0.16904902f, 
    -0.03328036f, 0.16118948f, 0.16320625f, 0.07011803f, -0.10653374f, -0.18848008f, 0.14737280f, 0.04789215f, 
    -0.15998712f, 0.12614819f, -0.16607045f, -0.58044243f, -0.07794291f, 0.03035548f, -0.13198550f, -0.06975808f, 
    0.01305580f, 0.02002211f, 0.01396972f, -0.02471438f, -0.05602335f, 0.10521337f, 0.23652193f, -0.10578112f, 
    -0.41443121f, 0.01697176f, -0.31898278f, -0.02399241f, -0.34494072f, -0.65995520f, -0.14189467f, 0.01205406f, 
    -0.02114058f, -0.04165317f, -0.01598725f, -0.08906383f, 0.07158317f, 0.08187857f, 0.35861576f, -0.18896964f, 
    -0.39134768f, 0.03132204f, -0.23916277f, -0.31633934f, -0.27615163f, 0.27394450f, 0.02106276f, -0.07424317f, 
    0.20758311f, -0.36465961f, -0.03233930f, -0.25270167f, 0.02822939f, 0.09624975f, -0.03523514f, 0.08704588f, 
    0.21116751f, 0.34371728f, -0.15625499f, -0.40889195f, -0.06356423f, -0.14081904f, 0.02012689f, 0.28303272f, 
    0.12058356f, 0.07408423f, 0.06277756f, -0.33347788f, -0.17347611f, -0.08601689f, 0.11503635f, -0.44329315f, 
    -0.01652458f, -0.33253706f, 0.02129904f, 0.26392931f, 0.29045358f, -0.07485307f, 0.06376091f, 0.38832390f, 
    0.06599741f, 0.21316433f, 0.01057535f, -0.08745377f, 0.05567666f, -0.37208664f, 0.17168856f, 0.05874816f, 
    -0.01982688f, 0.24363098f, -0.22724648f, 0.13175754f, -0.03987547f, 0.06899165f, 0.07966664f, 0.24504793f, 
    -0.11081566f, 0.02467926f, -0.04229048f, 0.19084203f, 0.18021803f, 0.05845300f, -0.08304878f, -0.37645292f, 
    0.20574337f, -0.25985175f, 0.14068474f, 0.06660508f, 0.00470298f, -0.06143909f, -0.28177652f, 0.17336912f, 
    -0.23329873f, -0.09424059f, 0.21529268f, -0.24053794f, -0.04321449f, -0.06129875f, -0.18692704f, -0.09820618f, 
    0.01170048f, -0.03036013f, 0.28787610f, 0.14175142f, -0.02711108f, 0.20498681f, 0.31161505f, -0.43642211f, 
    0.03890013f, 0.12695274f, -0.02714775f, -0.35004878f, 0.19941087f, 0.19433226f, 0.17547385f, -0.30048263f, 
    -0.01770568f, -0.23388296f, -0.40028480f, -0.28964713f, -0.01187742f, -0.05254541f, 0.05771708f, 0.00069984f, 
    -0.08752661f, 0.02814587f, -0.01731850f, -0.05320297f, -0.02568088f, 0.36342773f, -0.63501400f, 0.04663144f, 
    -0.52005011f, -0.05575316f, 0.23298633f, -0.10866106f, -0.02790250f, 0.25026974f, -0.23662420f, 0.03034724f, 
    0.02440631f, 0.00947577f, -0.05856006f, -0.00308691f, 0.01768476f, -0.01388593f, -0.19801387f, -0.02220104f, 
    -0.26057920f, 0.04193843f, 0.07252119f, -0.20397551f, 0.16878505f, -0.14973702f, -0.04561229f, 0.36612248f, 
    -0.03703785f, -0.07099083f, 0.11687672f, 0.01538046f, -0.08048141f, -0.25369844f, 0.14588374f, 0.03489694f, 
    -0.08933446f, 0.06626605f, -0.14632441f, -0.48256695f, -0.08087692f, 0.11413307f, 0.03158683f, 0.09576830f, 
    -0.32486597f, -0.00336263f, -0.02227542f, -0.34700984f, 0.33594683f, 0.06681017f, 0.05287122f, 0.35541499f, 
    0.06680987f, -0.57667142f, 0.03255053f, -0.07893059f, -0.06182297f, -0.34839958f, 0.09456839f, -0.16546318f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.04654785f, 0.04089516f, 0.17296720f, -0.15561402f, 0.01442664f, 0.15850471f, -0.02034735f, -0.17071438f, 
    0.02726862f, 0.01420191f, 0.09590522f, -0.01825817f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
