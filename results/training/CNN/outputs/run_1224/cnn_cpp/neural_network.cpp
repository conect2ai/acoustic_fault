#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.19581844f, 0.13941222f, -0.47320014f, -1.19764221f, -0.89039284f, -0.66865528f, 0.15961635f, 0.17786172f, 
    1.05630577f, 0.42331141f, 0.89644378f, -1.17030132f, 0.11868563f, -0.44225401f, -0.31771189f, -0.47674161f, 
    -0.65775543f, -0.53268564f, 0.34649590f, -1.74795878f, 1.34252524f, -0.22708862f, -0.28544030f, -0.30311099f, 
    -0.33284941f, -0.32360977f, -0.18837938f, 0.83321035f, -0.16770852f, -0.24626273f, -0.65446907f, 0.44588342f, 
    0.68559575f, -0.10195767f, 0.09044591f, 0.12572978f, -1.30604291f, -0.95442140f, -0.88390827f, 1.44504488f, 
    0.47690532f, 0.07046271f, -0.18730451f, -0.24679178f, 0.41424587f, -0.78184664f, 0.47257537f, -0.20346153f, 
    -0.57176501f, -0.50262314f, -0.20185380f, -0.38895246f, -0.09132981f, -0.90126383f, 0.06065070f, 0.48584971f, 
    0.35253739f, 0.71661687f, 0.10551976f, 0.73675996f, 0.12819204f, 0.20031977f, -0.39480600f, -0.51150107f, 
    0.37503120f, 0.72411770f, -0.51146853f, 0.20452839f, 0.55574417f, 0.28724369f, -0.62194270f, -0.12366350f, 
    -0.02172022f, -0.52693892f, 0.03042469f, -0.72847897f, -0.91258049f, -0.62931973f, -0.02365628f, -0.62415421f, 
    -0.28256899f, 0.26026839f, 0.25214410f, 0.16392709f, 0.64686018f, 0.75738728f, 0.44970912f, -0.02767204f, 
    0.14996183f, 0.06385713f, -1.20471334f, -0.88400924f, 0.96565396f, 0.88053989f, -0.07459259f, 0.12808537f, 
    -0.43192470f, -0.54986173f, -0.36699247f, -1.11435974f, 0.78668743f, -0.37166801f, 0.10340511f, 0.36373511f, 
    0.59258235f, 0.34829399f, 0.47693551f, 0.43328044f, 1.03688514f, 0.88857955f, 0.25395256f, -0.23867875f, 
    -0.42516086f, 0.16914953f, 0.32886446f, -0.15114559f, -0.16296884f, 0.62402248f, -0.26405808f, -0.03619458f, 
    0.33801609f, 0.72712106f, 0.25813326f, 0.33910325f, 0.36010656f, 0.30502635f, 0.73048466f, 0.68253064f, 
    0.24050573f, 0.05662269f, 0.46719027f, -0.10061907f, -0.12293164f, 0.41468349f, 0.50703353f, -0.95364702f, 
    -0.83905411f, -0.29225791f, -0.20144670f, 0.05610304f, -1.20978689f, -0.16629867f, 0.68695295f, -0.07105958f, 
    -0.95838374f, -0.58116716f, -0.05407435f, -0.10278744f, -0.21235885f, -0.73360431f, -0.35140795f, -0.31432921f, 
    -0.53806764f, -0.54172122f, -0.70593417f, -0.09419636f, -0.83976066f, -0.21927485f, -0.76756620f, 0.52677679f, 
    0.11960121f, -0.14335376f, -0.28877768f, 0.22275694f, -0.40348649f, 0.01205739f, 0.15244465f, 0.43973172f, 
    -0.04969025f, 0.07680693f, 0.65367430f, 0.05673154f, 0.03605333f, 0.81986600f, 0.30893794f, -0.00459060f, 
    -0.03977060f, -0.54773957f, -0.32330716f, 0.69946814f, -0.22567143f, -0.66455239f, -0.10634170f, -0.35815606f, 
    0.25467157f, 0.49511015f, 0.44709826f, 0.32279265f, 0.29535511f, -0.95548946f, 0.28727427f, 0.14339891f, 
    -0.04728410f, 0.88906509f, 1.05253637f, -0.66542685f, -0.25797656f, 0.15678048f, -0.58922321f, -0.49224684f, 
    -1.10892022f, -0.31730217f, 0.50182736f, 0.56478149f, -0.36189690f, 0.81199211f, -0.24776927f, 0.17596407f, 
    -0.26748532f, 1.02550185f, 0.34241399f, 0.06235304f, 0.43317273f, -0.41020381f, -0.28097016f, 0.10138512f, 
    0.14928049f, 1.23697257f, -0.74342078f, 0.09301528f, 0.29681906f, 0.11030981f, -0.61790413f, -0.14735074f, 
    0.82889056f, -0.76758111f, -1.19804716f, -0.48916513f, 0.16428587f, 0.03725047f, 0.18749557f, 0.39442399f, 
    -0.64860475f, -0.91430479f, 0.42962784f, 1.79805171f, -1.25671566f, -0.77487290f, -0.29100177f, -0.37412640f, 
    -0.17555571f, 0.26125112f, -0.15049702f, -1.62968886f, 1.26062167f, -1.02326739f, -0.23517738f, 0.29335707f, 
    -0.07727405f, 0.28726423f, -0.46226239f, 0.27682242f, -0.22135061f, 0.51065892f, -0.52106994f, -0.35793391f, 
    -0.01963430f, -0.62969863f, 0.78513056f, 0.73773807f, 0.79225957f, 0.06216301f, 0.34443617f, 1.32083583f, 
    -1.20840001f, -0.99804926f, 0.46574795f, 0.01245692f, 0.29509118f, -0.25396687f, 0.85981858f, -0.93019211f, 
    -0.92287052f, -0.27041593f, -0.01768924f, 0.09305801f, 0.70256424f, 0.22924629f, 0.27029625f, 0.50977349f, 
    0.73059839f, 0.89484584f, -0.16807315f, 0.25233129f, 0.17823498f, 0.31749642f, -0.49117422f, -0.53177953f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.10614277f, 0.11534398f, 0.08879247f, 0.71404040f, 0.47983548f, -0.35352623f, 0.14144590f, 0.33325806f, 
    0.27739605f, -0.41284528f, -0.15939754f, 0.28274193f, 0.49234796f, -0.05372982f, 0.23379618f, -0.58447886f, 
    -0.65353596f, -0.07789356f, 0.36959320f, 0.71008229f, 0.42018184f, -0.11396224f, 0.53137922f, -0.08320639f, 
    0.30170035f, 0.40456763f, -0.26268980f, 0.31856808f, 0.40326858f, 0.05679762f, 0.37313130f, -0.22531097f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.04917971f, -0.03201156f, 0.04979861f, -0.05271584f, 0.03750006f, 0.04694803f, 0.04443054f, -0.06211599f, 
    -0.03069408f, -0.04286109f, -0.00518046f, -0.00733360f, 0.04240138f, 0.01575731f, -0.06239985f, -0.04573587f, 
    -0.02051987f, 0.00283784f, -0.02970158f, -0.00086763f, -0.03286646f, -0.05153961f, -0.00728152f, -0.04116477f, 
    -0.04969685f, -0.01398435f, -0.00653383f, 0.04628193f, -0.03504583f, -0.05435262f, 0.04792603f, -0.01417388f, 
    0.01283201f, 0.02534083f, -0.00102297f, 0.01557357f, -0.01343711f, 0.02190177f, -0.02454378f, 0.04870836f, 
    -0.06254671f, -0.00465237f, -0.04184192f, -0.05784418f, -0.01943719f, -0.01775494f, -0.02929566f, 0.01949723f, 
    0.04429994f, 0.02922606f, -0.06095343f, -0.05165620f, 0.01181503f, -0.01415542f, 0.03571720f, -0.01422591f, 
    -0.04285343f, -0.04379151f, 0.02265432f, 0.01251030f, -0.01211191f, -0.05738838f, -0.01667769f, -0.05347786f, 
    -0.03615056f, -0.04015796f, -0.04819971f, 0.04091366f, -0.00704416f, 0.01060879f, 0.02577378f, 0.03828285f, 
    -0.03161718f, -0.05567382f, -0.06075478f, -0.05839656f, -0.05167508f, 0.03108875f, -0.05839647f, -0.03244320f, 
    -0.02256529f, 0.03800609f, -0.06063690f, 0.03981465f, -0.01239046f, -0.02231751f, 0.04871030f, -0.05860958f, 
    0.01435052f, -0.00342145f, -0.02021025f, -0.05067975f, 0.00531430f, 0.00909946f, 0.00356305f, -0.04644076f, 
    0.04462311f, 0.04430423f, 0.03152807f, -0.03847105f, -0.03793947f, -0.04953536f, -0.03722069f, -0.05186069f, 
    -0.00023490f, 0.00260785f, -0.03648082f, -0.01539092f, 0.05162004f, -0.00263638f, -0.02471058f, -0.00922820f, 
    -0.04822056f, 0.01492375f, 0.02068360f, -0.06153659f, 0.02727662f, 0.03748235f, 0.00607730f, 0.02710261f, 
    -0.01494709f, 0.03087048f, -0.05504894f, -0.03180850f, 0.04611909f, -0.04522105f, -0.00083192f, 0.02631995f, 
    -0.06244167f, 0.01152674f, -0.06378122f, 0.00915941f, 0.00351742f, 0.01042503f, -0.06322056f, -0.05696600f, 
    0.01744924f, 0.02749611f, -0.02978000f, 0.03715648f, -0.05197243f, -0.01211476f, 0.01400387f, 0.04454049f, 
    -0.04136120f, 0.01392138f, 0.03576539f, 0.03178041f, -0.00067011f, -0.00129248f, -0.04091912f, -0.02839397f, 
    0.02011908f, -0.03997377f, 0.02608681f, 0.03265146f, 0.00198720f, 0.04931024f, 0.04951803f, 0.00433361f, 
    -0.00261568f, -0.04438800f, -0.06291953f, 0.01136531f, 0.04649123f, 0.01148604f, -0.01943924f, -0.00037097f, 
    0.04530156f, 0.02970043f, -0.01071076f, -0.02037394f, -0.00749613f, -0.04803677f, -0.05168932f, -0.01258233f, 
    -0.03903014f, 0.01552889f, 0.04333841f, -0.05751166f, 0.04630594f, -0.04775587f, -0.01492470f, -0.01410178f, 
    -0.01935754f, 0.03486772f, -0.06139785f, -0.04784666f, -0.02269133f, -0.00079127f, -0.02829391f, -0.02583337f, 
    -0.01454077f, 0.05069169f, -0.02141691f, -0.06329628f, 0.02271181f, -0.03307068f, -0.03949128f, -0.00952982f, 
    -0.02251322f, 0.04281089f, -0.01629841f, -0.06036059f, 0.03926995f, -0.01154102f, -0.01847821f, 0.04396007f, 
    0.01569197f, -0.00207438f, 0.04049446f, -0.04320325f, -0.02398338f, -0.01864571f, -0.01060557f, -0.05869473f, 
    -0.04817914f, 0.04843510f, -0.00592814f, -0.03666152f, 0.00645541f, -0.06091588f, 0.00245423f, -0.03892796f, 
    -0.02425278f, -0.02576957f, -0.02098086f, -0.03805048f, -0.00055835f, -0.05399545f, -0.03269602f, 0.04240404f, 
    -0.01478085f, 0.05130183f, 0.00917221f, -0.03406479f, -0.02993948f, -0.04449374f, 0.01773060f, 0.04720425f, 
    -0.00426873f, -0.03723720f, -0.04049829f, -0.03381991f, -0.04484884f, 0.00972648f, -0.06363468f, 0.02941223f, 
    -0.00477609f, 0.05198302f, -0.00536920f, 0.02207050f, -0.03617927f, -0.04317518f, 0.03396506f, -0.04729993f, 
    -0.03569442f, -0.02023163f, 0.03712108f, 0.02872745f, -0.01493772f, -0.00267573f, 0.04634630f, 0.03805356f, 
    0.00394661f, 0.01785920f, 0.01634760f, 0.04407863f, -0.01695812f, 0.00243062f, -0.02273826f, -0.03166678f, 
    -0.02596853f, -0.00520011f, -0.03504404f, 0.05220811f, -0.01140974f, 0.00083277f, -0.01206196f, -0.03660416f, 
    0.01550359f, -0.00739815f, 0.02777303f, 0.00284233f, -0.02219830f, 0.03918174f, -0.04287496f, -0.05117466f, 
    0.14838371f, 0.20829459f, 0.22152467f, 0.05771399f, 0.02552490f, -0.05755206f, -0.06589650f, 0.11098763f, 
    0.02259838f, 0.26134521f, -0.21095395f, -0.30501205f, 0.17372401f, 0.07484016f, -0.08145614f, 0.15674295f, 
    0.11582521f, 0.10446244f, 0.00244373f, -0.25172800f, -0.05558164f, -0.20144805f, 0.17009686f, -0.08531421f, 
    0.10693958f, 0.15955143f, -0.09828101f, 0.23227544f, 0.05146955f, -0.01049743f, 0.10662097f, 0.09031425f, 
    -0.01513548f, -0.05499545f, 0.12558250f, 0.35126257f, -0.10563427f, 0.10158920f, 0.50774068f, 0.07926066f, 
    0.00585771f, -0.00509841f, 0.21499099f, 0.04371498f, 0.21270584f, -0.18966261f, -0.22277422f, 0.12844604f, 
    -0.08379508f, 0.01716951f, -0.06432425f, 0.17839667f, 0.10551289f, -0.00094864f, -0.30658749f, -0.11204287f, 
    -0.05038712f, -0.10811290f, -0.05350420f, 0.07718490f, -0.04765694f, -0.10435892f, 0.01119688f, -0.22290236f, 
    -0.21651870f, -0.25901884f, -0.08206645f, 0.08135786f, -0.15822066f, 0.07944572f, 0.09400007f, -0.01346457f, 
    0.00628469f, 0.15734039f, 0.23875608f, 0.00869950f, 0.02595311f, 0.18288864f, 0.17356434f, 0.04511419f, 
    -0.04336046f, -0.35607034f, -0.13766271f, -0.05814610f, -0.16924281f, -0.14444134f, -0.08954534f, 0.23712933f, 
    -0.08522451f, -0.13003585f, -0.63448137f, -0.33817306f, 0.38384199f, -0.27276394f, -0.07028235f, -0.08397683f, 
    0.00453112f, -0.12424000f, -0.14871246f, 0.10718562f, -0.07832208f, -0.05722497f, 0.02729470f, -0.10145371f, 
    -0.13056956f, 0.08854321f, 0.20725745f, 0.23097214f, -0.16935267f, -0.52461046f, -0.06217746f, 0.11605448f, 
    0.04330325f, -0.02938445f, -0.08338936f, -0.09846721f, 0.24293938f, -0.06586437f, -0.01329658f, 0.00523017f, 
    -0.04427519f, -0.16368760f, -0.13423036f, 0.14082974f, -0.22495556f, 0.17538674f, -0.29630572f, -0.07116374f, 
    0.03055915f, -0.06436615f, -0.10004872f, 0.06025555f, -0.02247399f, -0.07013086f, 0.15569393f, -0.68632132f, 
    0.08547895f, 0.02967338f, -0.10394395f, -0.10483368f, -0.07862810f, 0.00053963f, -0.10901604f, 0.00117544f, 
    -0.73782939f, -0.06890563f, 0.09086449f, 0.02401967f, -0.08600271f, -0.03914766f, 0.12203808f, 0.00363830f, 
    -0.18207681f, -0.23931411f, -0.01720508f, 0.19581395f, 0.03742026f, -0.16790405f, 0.11885094f, -0.00450541f, 
    -0.02362629f, 0.04576230f, 0.00989952f, -0.00199640f, 0.08897218f, -0.11761784f, -0.09060585f, -0.01296816f, 
    0.22193612f, 0.10923331f, 0.12735128f, -0.25236663f, -0.12062316f, 0.05827702f, -0.16883007f, 0.07172293f, 
    0.10894007f, 0.16411519f, 0.18575923f, -0.02377433f, 0.06717580f, 0.04364780f, 0.32027307f, 0.12433033f, 
    0.05694045f, 0.11128424f, 0.21904287f, 0.04415665f, 0.11840534f, -0.12921759f, -0.05830712f, -0.15068503f, 
    -0.32312039f, -0.16560769f, -0.29688314f, -0.26714495f, 0.16909075f, -0.25716299f, 0.24183995f, 0.27469838f, 
    0.12728110f, -0.04041958f, 0.13350439f, -0.03530981f, -0.10339871f, 0.07896060f, 0.04563952f, -0.23607530f, 
    -0.22985987f, -0.05254152f, -0.23560824f, -0.08114227f, -0.10720200f, -0.02254518f, 0.03710074f, -0.42222768f, 
    -0.01749741f, -0.50842506f, -0.03816165f, -0.13803960f, 0.03471569f, -0.07401088f, 0.04387458f, 0.12851276f, 
    -0.02073790f, -0.13408740f, 0.20692414f, 0.30373698f, 0.06909402f, -0.04644779f, 0.16307788f, 0.21136452f, 
    0.06009614f, -0.17024767f, 0.50994319f, -0.47211817f, -0.45356962f, -0.10225543f, 0.01326585f, -0.49913180f, 
    -0.14891006f, 0.13059673f, -0.11789948f, 0.24677143f, 0.01137833f, -0.00788897f, 0.24058260f, -0.12391923f, 
    -0.30505303f, 0.03942271f, 0.08522561f, -0.08047955f, 0.15343006f, 0.07716787f, 0.01537009f, -0.12179615f, 
    0.02285982f, 0.14394994f, 0.00331118f, 0.18481298f, 0.20524587f, -0.40611377f, -1.05055308f, 0.05848435f, 
    -0.22077848f, 0.11082207f, -0.20645505f, -0.04123452f, 0.01162401f, 0.12983704f, -0.04911635f, 0.14642636f, 
    0.24632405f, 0.05324870f, 0.04421351f, 0.13611591f, -0.06427826f, -0.07890804f, 0.12300126f, -0.99274188f, 
    -0.57073992f, 0.02500271f, -0.06759943f, -0.00531688f, 0.07768252f, 0.00780256f, -0.02220738f, -0.02024168f, 
    0.09900504f, 0.20198977f, 0.27724189f, 0.03171103f, 0.03560210f, -0.01479510f, 0.01741469f, -0.04871530f, 
    -0.11255558f, 0.24685135f, -0.25688639f, -0.08594992f, -0.00144600f, 0.04570244f, 0.03365630f, 0.13606244f, 
    0.03236046f, 0.11333118f, -0.29862013f, 0.22337091f, 0.37847403f, -0.08499656f, -0.14032410f, 0.06914119f, 
    -0.03591083f, 0.36953151f, 0.08277003f, -0.20420961f, -0.42411518f, -0.09847561f, -0.04680168f, -0.05694298f, 
    -0.17347467f, 0.21043201f, 0.01918990f, 0.00830388f, -0.42721325f, -0.10885710f, 0.10735087f, 0.15747534f, 
    0.04302354f, -0.10766718f, -0.00628526f, -0.02156624f, 0.04474812f, 0.23989634f, -0.01747347f, 0.46017057f, 
    -0.02333883f, -0.02059184f, -0.01562298f, 0.06187951f, 0.08476815f, 0.04747368f, 0.00243397f, -0.07205563f, 
    0.07638714f, -0.08917217f, 0.09190035f, -0.13906495f, 0.21448795f, 0.27520439f, 0.05423085f, 0.12055445f, 
    -0.13743551f, -0.01169821f, -0.07543497f, -0.20899603f, -0.10488914f, -0.03019813f, 0.09958851f, -0.02787587f, 
    0.07894316f, 0.00824320f, 0.24454802f, 0.01037966f, -0.11597087f, -0.04985468f, 0.05888865f, -0.13887599f, 
    0.05558069f, 0.12561364f, 0.05646527f, 0.15069097f, -0.01797235f, -0.03078086f, -0.00551104f, 0.15953003f, 
    0.32311380f, 0.02161257f, -0.43619069f, 0.29020891f, -0.18811767f, 0.14917433f, 0.01077383f, -0.17430897f, 
    -0.29016855f, 0.00727677f, 0.09115037f, -0.01271580f, 0.10605326f, 0.13041978f, -0.02784793f, -0.10017934f, 
    0.08988991f, 0.09969723f, 0.06980740f, 0.01494516f, 0.00073255f, -0.10538869f, -0.12014908f, -0.09631214f, 
    -0.09575899f, -0.17485757f, 0.06724599f, 0.03558205f, 0.08213770f, 0.12219195f, -0.02552908f, 0.23379867f, 
    -0.21009906f, -0.15941301f, -0.06149675f, 0.06082111f, 0.16167773f, -0.02382692f, 0.04337186f, -0.05557238f, 
    -0.00382931f, -0.21289913f, -0.10580101f, -0.12259562f, 0.09066978f, 0.32318446f, -0.02491495f, -0.12323654f, 
    -0.02510026f, 0.44369563f, 0.18725365f, -0.08978262f, -0.08984133f, -0.09752922f, 0.12506174f, 0.25291041f, 
    -0.18785867f, 0.22320662f, 0.05010706f, -0.05579089f, -0.11661851f, -0.04803208f, -0.05228378f, 0.06685489f, 
    0.05853606f, 0.24782479f, -0.05187703f, 0.22200911f, 0.18959114f, -0.05313091f, -0.01485979f, -0.02538822f, 
    -0.01255048f, 0.16833408f, 0.08718842f, 0.05349016f, 0.19874294f, -0.09358591f, -0.07703109f, -0.01224036f, 
    0.03424859f, -0.03464738f, -0.10655329f, 0.03107172f, -0.16171467f, 0.00246019f, 0.04248658f, -0.04213133f, 
    0.03675438f, -0.10253631f, -0.12360498f, 0.03161607f, -0.09381619f, 0.02701568f, 0.25216761f, 0.03550297f, 
    -0.15365964f, 0.01241763f, 0.11860621f, 0.01005030f, -0.06548533f, 0.20951000f, 0.01804993f, 0.12411331f, 
    -0.08710611f, 0.10245894f, -0.04143562f, -0.11204151f, 0.00465313f, -0.17137551f, 0.01053274f, -0.11530377f, 
    0.43762010f, 0.14913322f, 0.01076872f, 0.05195018f, 0.01701546f, 0.02600191f, 0.03809434f, 0.13227656f, 
    0.10051087f, 0.03463025f, 0.08810657f, -0.00086400f, 0.08399164f, -0.15482408f, 0.06280666f, 0.04988137f, 
    0.23335250f, -0.00196302f, -0.09423529f, -0.22074470f, 0.03485537f, 0.02790868f, 0.05448124f, 0.29746580f, 
    0.17301522f, -0.41518599f, 0.03338140f, -0.08346713f, 0.08457860f, 0.00549718f, -0.20076373f, -0.10595609f, 
    0.05543005f, 0.22470436f, 0.52741992f, 0.43249705f, 0.69089764f, -0.10044707f, -0.00132945f, -0.03539739f, 
    0.02012377f, -0.03767795f, 0.15397848f, 0.22262426f, 0.19826195f, 0.40513268f, -0.10152201f, 0.01074654f, 
    0.23776203f, -0.01181163f, 0.12527055f, 0.13826323f, -0.12999158f, -0.01115129f, -0.04412058f, -0.24297707f, 
    0.08346105f, 0.05610178f, 0.08507019f, 0.06936694f, -0.19485460f, -0.05317857f, -0.21183069f, 0.06266440f, 
    -0.07400997f, -0.15594278f, -0.06572381f, 0.05898103f, -0.03473324f, -0.21849726f, -0.20398256f, -0.16363892f, 
    0.37658849f, 0.08965340f, 0.05968836f, 0.08654467f, 0.07987071f, -0.02616598f, -0.08545344f, 0.02580266f, 
    -0.06172130f, 0.08855363f, -0.01142888f, -0.06354727f, 0.02066499f, -0.06584949f, 0.22036013f, -0.02633244f, 
    0.05799511f, -0.10985820f, -0.19735749f, 0.00052216f, 0.01957751f, 0.30641297f, -0.20376198f, -0.04961447f, 
    -0.23443535f, 0.17552614f, -0.00632468f, 0.17027545f, 0.05301419f, 0.21172433f, 0.11102667f, 0.00126849f, 
    0.06267454f, 0.19836280f, -0.31108746f, 0.69225651f, -0.22167407f, -0.14884335f, -0.06989788f, -0.07677232f, 
    0.17125362f, 0.17372361f, -0.06121377f, -0.22163635f, 0.04246766f, 0.24267159f, 0.05853293f, 0.14200039f, 
    -0.13598029f, -0.00141323f, 0.04383649f, -0.21814784f, -0.51308793f, -0.03424494f, -0.27138489f, 0.11575025f, 
    0.02898216f, 0.13247795f, 0.22103913f, 0.26188785f, 0.14634816f, 0.38833088f, 0.24112931f, 0.05244936f, 
    -0.03015227f, 0.23532110f, 0.27783528f, -0.19648498f, -0.13460623f, 0.13607588f, 0.18827620f, -0.14214736f, 
    -0.11351412f, 0.15799046f, 0.16061607f, 0.00261592f, -0.06242546f, -0.05525752f, -0.16661490f, 0.22868641f, 
    -0.07332892f, 0.09945253f, 0.11116539f, 0.19192342f, -0.16921808f, 0.03044122f, -0.18262771f, -0.00555714f, 
    0.25163284f, 0.14673787f, 0.08014210f, 0.06512754f, 0.10513460f, -0.08967319f, -0.07361454f, 0.04578521f, 
    -0.06512215f, 0.21877924f, 0.09091675f, 0.11511981f, 0.08056800f, 0.11741266f, 0.10632855f, -0.18184873f, 
    -0.21225858f, -0.13898835f, -0.00563176f, 0.58830678f, 0.07663858f, 0.04152057f, -0.02073525f, 0.43137306f, 
    0.14012873f, 0.11179744f, 0.10809243f, 0.04302998f, 0.01138932f, 0.04379956f, 0.18984243f, 0.01713229f, 
    0.10059763f, -0.13469426f, -0.11777355f, -0.28445181f, -0.12999496f, -0.19737582f, -0.25075862f, 0.06376436f, 
    -0.01478042f, -0.12719168f, 0.03760418f, 0.11798536f, -0.00406305f, 0.02212690f, 0.03134312f, 0.25278997f, 
    0.03573107f, 0.03891461f, 0.04315900f, -0.20087074f, -0.28209093f, -0.36884612f, -0.00077596f, -0.08631262f, 
    0.03008689f, 0.05483414f, -0.03845880f, 0.02827995f, -0.05202200f, -0.08453353f, -0.17607617f, 0.13749395f, 
    0.21290311f, 0.00176672f, 0.32425237f, 0.13652933f, 0.19804314f, 0.10195987f, -0.06225568f, -0.01879210f, 
    0.39074609f, 0.35995138f, 0.15857036f, 0.00560393f, 0.04641172f, 0.08695623f, -0.04719246f, 0.01485540f, 
    0.03269058f, 0.31762061f, 0.12704830f, -0.03554275f, 0.33019903f, 0.16030642f, 0.04404892f, 0.06242459f, 
    0.07908492f, 0.03456483f, 0.07464115f, 0.06841244f, -0.06693938f, 0.10984603f, -0.03592545f, 0.05657547f, 
    -0.15072982f, -0.15743518f, -0.29451710f, 0.23392914f, -0.20680317f, -0.14963925f, 0.17613553f, 0.13405029f, 
    -0.02212740f, 0.16622916f, -0.10265726f, -0.22488226f, -0.08929752f, -0.14977852f, 0.03779154f, 0.08274511f, 
    0.21192552f, -0.05317359f, -0.36565721f, -0.32976139f, -0.14977038f, 0.29787517f, 0.00222061f, -0.00914641f, 
    0.11381847f, 0.02926092f, 0.21485732f, -0.13150787f, 0.00899487f, -0.03902350f, -0.04122046f, -0.20958674f, 
    0.07742754f, -0.10278557f, 0.17454939f, -0.03575429f, -0.07865287f, 0.20405558f, 0.15288043f, 0.27103573f, 
    -0.18749686f, -0.37348309f, 0.08719108f, 0.16309479f, -0.07012898f, 0.15971100f, -0.29855579f, -0.15371393f, 
    0.07052816f, 0.04992108f, -0.32340136f, 0.15633860f, 0.17210853f, 0.00332874f, 0.32242033f, 0.04628936f, 
    -0.14272927f, 0.04784104f, 0.28643230f, 0.08246575f, 0.14325975f, 0.26202226f, 0.45430005f, 0.07364158f, 
    0.24451099f, 0.16872989f, 0.04222587f, 0.04504389f, 0.00621051f, 0.10880090f, -0.01645365f, -0.02874700f, 
    0.12532046f, 0.07479782f, -0.06629584f, 0.15015382f, 0.07299758f, 0.23353480f, -0.00386923f, -0.09414465f, 
    -0.00632865f, 0.00453695f, 0.09556758f, 0.19796105f, -0.02985326f, -0.04909009f, -0.02591529f, 0.07193482f, 
    -0.06431877f, -0.07704695f, -0.44529492f, -0.14942913f, -0.36334535f, 0.15156621f, 0.09305034f, -0.01473239f, 
    -0.28083411f, -0.06980328f, -0.18371095f, 0.01762771f, 0.02083424f, 0.05734658f, -0.08683898f, 0.15002221f, 
    0.09866122f, 0.04033325f, 0.14337632f, -0.03718510f, -0.11457686f, 0.11750431f, -0.05922261f, 0.10055906f, 
    -0.20385508f, -0.14768831f, 0.07104846f, 0.12050339f, -0.01605543f, 0.09440356f, -0.13053900f, -0.01211369f, 
    0.15542112f, 0.38590369f, 0.34784508f, 0.19455679f, 0.12219864f, -0.11207592f, 0.02356045f, -0.06698907f, 
    0.13623446f, -0.16840816f, 0.21953848f, -0.32071260f, 0.06629994f, -0.15945570f, 0.03408730f, -0.12640858f, 
    -0.23037910f, -0.09124035f, 0.45701358f, -0.01780796f, -0.09402331f, -0.13480291f, -0.07188170f, 0.25995496f, 
    -0.12053505f, -0.03481092f, -0.33912268f, -0.40719959f, -0.41859603f, -0.14912313f, -0.21803154f, 0.01959440f, 
    -0.34239081f, 0.08235536f, -0.01477568f, 0.01750713f, 0.30719662f, 0.18710449f, -0.26856777f, -0.26006761f, 
    -0.17865075f, -0.04203874f, -0.05894035f, -0.00495866f, 0.11685424f, -0.07346319f, 0.43059319f, 0.18278387f, 
    0.05922524f, 0.11654703f, 0.04091021f, 0.21716441f, -0.07285971f, -0.13270852f, 0.00910377f, 0.05135851f, 
    0.09214403f, 0.12811641f, -0.07649659f, -0.13763562f, 0.05714066f, -0.13443944f, -0.01110084f, -0.05285186f, 
    -0.02266296f, 0.03251770f, -0.01774586f, -0.13912405f, 0.01002840f, -0.24588495f, -0.07352407f, -0.18012446f, 
    0.23825677f, 0.29987061f, 0.10348783f, -0.00815972f, 0.03936850f, -0.07350932f, -0.02789935f, -0.06399883f, 
    0.01627913f, 0.07952766f, 0.12687732f, 0.02844311f, -0.05374785f, -0.02749464f, -0.16033708f, 0.09808567f, 
    0.11255758f, -0.01841642f, -0.18628860f, -0.30352497f, -0.00354062f, -0.05741708f, 0.02229284f, 0.29978880f, 
    -0.25103307f, -0.16887859f, -0.08222499f, 0.09469468f, 0.10573232f, 0.11661775f, -0.20232014f, -0.03832191f, 
    0.05808377f, 0.02676010f, 0.06962392f, 0.06480129f, -0.03903555f, -0.08479395f, 0.03646382f, 0.08843982f, 
    0.02195515f, -0.07351273f, 0.02089611f, 0.09195065f, 0.10900012f, 0.01790204f, 0.04456300f, 0.08396472f, 
    0.03204488f, 0.01762176f, -0.15671767f, -0.06421412f, 0.02937198f, 0.08823233f, 0.01732784f, 0.03455378f, 
    0.11355635f, 0.05833580f, 0.10556359f, -0.13878597f, 0.17100807f, 0.04504324f, -0.06776305f, 0.61125433f, 
    0.54374886f, -0.03841484f, -0.03921549f, 0.18177091f, -0.01061696f, 0.10633081f, 0.11589587f, 0.12319962f, 
    0.27143991f, 0.30703250f, -0.04650368f, 0.06131455f, 0.09790514f, -0.04392763f, 0.25764859f, 0.07131332f, 
    -0.02536526f, 0.40282989f, 0.43188781f, -0.08669464f, 0.02229316f, 0.08921048f, -0.01485700f, -0.02786945f, 
    0.08095770f, 0.03664586f, 0.11764000f, 0.08994079f, -0.04177659f, -0.02577309f, 0.00485365f, -0.20730348f, 
    -0.02570322f, -0.02449102f, 0.01697301f, -0.15173067f, -0.21847479f, 0.03944424f, -0.04345296f, -0.15392867f, 
    -0.04621419f, -0.00553192f, -0.20437565f, -0.18526119f, 0.15802170f, 0.05302903f, 0.08244394f, -0.23733404f, 
    -0.13428602f, -0.15769698f, -0.04231717f, -0.00084420f, 0.03645564f, 0.16425204f, 0.09094018f, 0.17165101f, 
    0.01323128f, 0.20587932f, 0.28078985f, 0.01631774f, 0.06094123f, -0.05606624f, 0.27419388f, 0.02883209f, 
    0.15156257f, -0.12333566f, 0.19283295f, -0.21414447f, 0.05703886f, -0.01426376f, -0.07768139f, 0.02582191f, 
    0.04236689f, 0.05746629f, 0.13534535f, -0.09548036f, 0.20682099f, -0.00163555f, -0.13087258f, -0.21680266f, 
    0.01756246f, 0.02731950f, -0.05281004f, 0.09529122f, -0.09853730f, 0.05470180f, 0.11870166f, -0.18808311f, 
    -0.07636064f, 0.19810970f, -0.11166933f, -0.24723278f, 0.00975254f, 0.01351233f, -0.18174061f, -0.11035515f, 
    -0.06250388f, -0.08417881f, 0.20953003f, 0.20502439f, -0.31174695f, 0.12325235f, 0.09262700f, 0.18715531f, 
    -0.17377625f, 0.40621349f, 0.15416923f, 0.02031400f, 0.57332915f, 0.18587476f, -0.10166065f, -0.08451054f, 
    0.12333353f, -0.09322762f, 0.05426643f, -0.05585078f, 0.20023608f, 0.18597814f, -0.08656149f, 0.08266546f, 
    -0.01890479f, -0.12768562f, -0.00439033f, 0.12271977f, 0.02461090f, -0.78865427f, 0.14575318f, 0.26470205f, 
    0.00079843f, 0.15714139f, -0.09421545f, -0.02844531f, 0.02160973f, 0.19017737f, 0.25190961f, -0.02758835f, 
    -0.42136425f, -0.08893097f, -0.22630198f, -0.12183751f, 0.00021224f, 0.12731321f, -0.04011794f, -0.02255622f, 
    0.03303987f, 0.02416686f, 0.06909438f, 0.10404952f, 0.04479348f, 0.16121125f, -0.14298455f, -0.04078114f, 
    0.08171009f, 0.14608714f, 0.16500436f, -0.03223807f, -0.10000153f, 0.12332546f, -0.07699878f, -0.01318911f, 
    0.13745138f, -0.23225759f, 0.13801512f, 0.23394090f, 0.08578216f, -0.25471550f, 0.06800417f, 0.03294674f, 
    0.02415129f, -0.16070898f, 0.09578054f, -0.17728224f, -0.49140769f, 0.05428122f, 0.09867326f, 0.07668073f, 
    0.01444249f, 0.23212729f, -0.01774669f, 0.16172363f, -0.02180425f, 0.05869157f, -0.24595727f, -0.09996000f, 
    -0.03248146f, -0.03932720f, -0.26397085f, -0.12318819f, 0.27062801f, 0.37145939f, 0.45383015f, -0.03633519f, 
    0.04873765f, 0.25384992f, -0.02075868f, -0.03141166f, 0.24731162f, -0.22653884f, -0.01831500f, 0.00555829f, 
    0.16187914f, -0.09750422f, -0.18276370f, -0.19398841f, -0.07689894f, -0.02688798f, -0.05635995f, -0.24198186f, 
    -0.47589189f, -0.08882782f, 0.03290104f, 0.27032050f, -0.21068971f, 0.12190188f, 0.04543646f, -0.75494629f, 
    -0.44889030f, -0.30234483f, -0.02076441f, 0.21467510f, -0.18895589f, 0.07808080f, -0.12164205f, -0.14523989f, 
    0.11999034f, 0.29167822f, -0.07449935f, -0.04030287f, -0.02346078f, -0.21812965f, -0.04383292f, 0.02414079f, 
    0.05508479f, 0.10746501f, -0.19178411f, -0.38740310f, -0.06277190f, -0.04169206f, 0.07432268f, -0.19195336f, 
    0.00223847f, 0.03612971f, 0.58059841f, 0.08900066f, 0.10060674f, -0.13057829f, -0.16251314f, 0.13289383f, 
    -0.01845549f, 0.41039103f, -0.23597464f, -0.48894617f, -0.41427800f, -0.32845539f, 0.15696451f, -0.07161368f, 
    -0.05945635f, -0.13769354f, 0.17913952f, -0.10312448f, -0.72060740f, -0.34470564f, 0.38677675f, -0.06401880f, 
    0.02973065f, 0.01877262f, -0.08791415f, -0.04713775f, -0.02811454f, -0.22237414f, -0.10454178f, -0.00691161f, 
    -0.14940366f, 0.07860023f, 0.06851564f, 0.04403193f, 0.09540125f, 0.22213450f, -0.00431792f, -0.18719292f, 
    -0.25718176f, -0.00746878f, -0.01713538f, 0.03516917f, -0.12865093f, 0.05658633f, 0.06732079f, 0.49526230f, 
    0.20306578f, 0.29654920f, 0.07640868f, 0.12534234f, 0.19599271f, 0.13083325f, 0.02282820f, -0.01928389f, 
    0.47041836f, 0.29473901f, 0.30291393f, 0.18328531f, 0.04482753f, -0.26053408f, 0.00309308f, 0.11157172f, 
    -0.02256524f, 0.13478316f, 0.38616315f, -0.01356265f, -0.18091463f, -0.12664881f, 0.11125199f, -0.02322030f, 
    0.08006749f, -0.08752205f, -0.47077173f, -0.34739006f, -0.23066175f, 0.19985802f, -0.10769290f, -0.13370489f, 
    0.04778274f, -0.00528823f, 0.16145620f, -0.33260733f, -0.11729045f, -0.27380979f, 0.02766477f, 0.09840234f, 
    0.02191368f, -0.01429348f, 0.05783701f, -0.17431542f, -0.48064992f, -0.14708214f, -0.37123492f, -0.17601193f, 
    0.19351687f, -0.04992817f, 0.04523701f, 0.11494602f, 0.00183812f, -0.31280914f, -0.43176627f, 0.09051922f, 
    0.01676501f, 0.14721996f, 0.09765336f, 0.14622468f, -0.18836583f, 0.12772684f, -0.04733369f, -0.16041023f, 
    -0.00971340f, -0.11089591f, 0.14640349f, 0.17643318f, 0.21755756f, 0.05159787f, -0.20198750f, -0.35397792f, 
    -0.60670882f, -0.32746616f, 0.00747975f, 0.15180132f, 0.19733289f, 0.04665195f, 0.12007710f, 0.03111497f, 
    -0.48510140f, -0.82518917f, -0.27412841f, 0.02162047f, -0.44682172f, -0.18454872f, 0.06444623f, 0.00031009f, 
    -0.02852389f, 0.44277510f, 0.09727205f, 0.39886519f, 0.11284047f, -0.08540279f, -0.00788053f, 0.11342242f, 
    0.01981299f, -0.15706165f, -0.43233171f, -0.63817620f, -0.02708040f, 0.05303745f, -0.27649212f, -0.41719645f, 
    -0.15915023f, 0.14325887f, -0.10106254f, -0.55063444f, 0.01164156f, -0.03730298f, 0.24111941f, -0.08477531f, 
    -0.30522832f, 0.09852321f, 0.17706430f, 0.14343131f, 0.22862138f, -0.08564261f, 0.08668015f, 0.23789513f, 
    0.06757821f, -0.04828352f, -0.20661931f, 0.26552489f, 0.21693578f, -0.13999699f, 0.25688109f, -0.28480458f, 
    -0.30511558f, 0.03060024f, -0.21976815f, 0.21910556f, 0.03339124f, 0.22343081f, 0.17732933f, 0.11655191f, 
    0.00248749f, -0.05811979f, 0.02603451f, 0.14342530f, -0.08497113f, 0.07765074f, 0.08753802f, -0.40508920f, 
    -0.42965144f, -0.57057822f, 0.20268877f, 0.30400282f, 0.05230683f, 0.10944688f, -0.06257509f, -0.13586336f, 
    0.05590477f, -0.18313169f, -0.23081076f, 0.06356031f, 0.17856695f, 0.14311206f, 0.28289872f, 0.25818241f, 
    0.16304742f, 0.04534550f, -0.28409407f, 0.04389715f, -0.01988840f, 0.08257496f, 0.00630039f, 0.03918067f, 
    -0.02014624f, -0.13867332f, 0.02003724f, -0.19997656f, -0.27481303f, 0.12119844f, -0.04734894f, -0.06388436f, 
    0.21517222f, 0.22461952f, -0.44737637f, 0.16903734f, 0.09487457f, 0.16019519f, 0.29361689f, 0.26057082f, 
    0.12717144f, -0.02210231f, -0.11986664f, 0.44144410f, 0.12733406f, 0.12223116f, -0.03574384f, -0.12886049f, 
    0.02493857f, -0.00480829f, -0.12533872f, -0.07568813f, 0.06888654f, -0.31198618f, -0.39668617f, 0.14562048f, 
    0.05990541f, 0.13720132f, 0.06517179f, -0.20846950f, -0.01144380f, -0.01490057f, -0.05703053f, 0.00614082f, 
    0.00375073f, 0.02207230f, 0.13556612f, 0.14398827f, 0.08229173f, 0.01091753f, -0.10605220f, -0.01758388f, 
    -0.04252426f, 0.09952194f, -0.00794865f, 0.11736338f, -0.03339085f, -0.10966904f, -0.01991150f, -0.04321349f, 
    -0.01579913f, -0.24153033f, -0.26150703f, 0.10512888f, 0.13689569f, 0.18927060f, 0.04920277f, 0.26588380f, 
    -0.05801198f, -0.11159430f, -0.12274940f, -0.05412909f, 0.00045710f, 0.15115839f, 0.05142865f, 0.07577992f, 
    -0.11320698f, -0.06454118f, 0.00808392f, -0.05198516f, -0.16964109f, 0.04428864f, 0.04339819f, -0.21213709f, 
    0.07358675f, -0.21600103f, -0.38123983f, 0.02014267f, 0.03196279f, -0.01776121f, 0.18789424f, 0.07340493f, 
    -0.00928412f, 0.03272007f, 0.09530177f, 0.11886571f, -0.16906969f, 0.05306517f, 0.01647733f, 0.01373294f, 
    0.12926362f, 0.06575166f, -0.05136412f, 0.15730664f, 0.01257105f, -0.03225286f, -0.06514481f, -0.04426975f, 
    0.12398646f, 0.19970085f, 0.02175224f, -0.01845033f, -0.03597041f, 0.13520655f, -0.16358122f, -0.05096956f, 
    -0.02424269f, 0.15745577f, -0.08303744f, 0.02187984f, 0.13748780f, 0.06324200f, 0.18919720f, -0.15930508f, 
    -0.28447685f, -0.06738306f, -0.01659178f, -0.08935996f, 0.07079095f, -0.04976407f, 0.09459729f, 0.04853119f, 
    -0.37505788f, -0.56031084f, -0.04100496f, 0.10009314f, 0.05694515f, 0.00613231f, -0.29988980f, -0.01152301f, 
    -0.13987730f, -0.10285450f, 0.11349563f, -0.06434358f, -0.03262016f, -0.03062212f, 0.14845239f, 0.11086372f, 
    0.31147590f, 0.08171123f, 0.10773159f, 0.05513372f, 0.12127755f, 0.16879342f, 0.16437279f, -0.02262011f, 
    0.05388938f, 0.17735870f, 0.22323371f, 0.23391426f, 0.02714578f, 0.14266413f, -0.01938968f, -0.01315248f, 
    0.02344511f, 0.39155197f, 0.14326166f, 0.07759934f, -0.01176824f, -0.03511329f, -0.00930114f, 0.13380152f, 
    0.07282191f, 0.05721324f, -0.05561460f, -0.01145959f, 0.12799340f, -0.03492475f, -0.05969331f, -0.03661558f, 
    0.06930316f, -0.03229263f, 0.07512870f, 0.14423072f, -0.37399834f, -0.10764325f, 0.23762339f, -0.20559168f, 
    0.05590630f, 0.03729390f, 0.06875765f, 0.09094791f, -0.02659188f, -0.01210286f, 0.14461063f, -0.11735225f, 
    -0.01114490f, 0.03770154f, -0.21056572f, -0.12637734f, 0.02471440f, 0.30968344f, 0.07221144f, -0.24030766f, 
    0.13763231f, 0.00323077f, 0.11962208f, -0.14367504f, 0.07538777f, 0.02821000f, -0.03835352f, -0.04281532f, 
    0.14973606f, -0.07404254f, -0.07146045f, 0.09365580f, -0.11425988f, -0.02304092f, 0.11039133f, -0.23461795f, 
    0.10720181f, -0.27712345f, -0.47362301f, -0.32608593f, -0.22442003f, -0.15458982f, 0.09023558f, 0.02157028f, 
    0.02552687f, 0.06902479f, 0.19224314f, -0.17898630f, 0.29665110f, -0.04245012f, 0.05174753f, 0.08489493f, 
    0.05668472f, 0.00902268f, 0.09151374f, 0.09095659f, -0.18782164f, -0.00020619f, 0.02411951f, -0.07398073f, 
    0.12261887f, 0.08454294f, 0.30604693f, 0.37005541f, 0.23294380f, 0.00176094f, -0.14062750f, -0.01042601f, 
    0.18040319f, 0.01615122f, 0.06289535f, -0.06831396f, 0.26595816f, 0.07138877f, -0.12249120f, 0.05861952f, 
    0.11533590f, -0.00078457f, 0.07289310f, 0.10981122f, 0.01886494f, 0.20459294f, 0.06507485f, -0.09951576f, 
    -0.15162086f, 0.10406727f, -0.19469558f, 0.06037537f, -0.00146213f, -0.07782862f, 0.06529997f, -0.22963721f, 
    0.20389831f, 0.07346061f, 0.22619665f, 0.07022344f, 0.04442194f, -0.07129098f, -0.03643948f, -0.17000201f, 
    -0.05279922f, 0.21821599f, 0.06749623f, -0.40922940f, 0.04143853f, 0.15425855f, 0.32009485f, 0.13791457f, 
    -0.02358728f, -0.10095625f, -0.38480121f, -0.28001118f, -0.37230778f, 0.02599963f, 0.04331865f, 0.21069466f, 
    -0.17681496f, 0.22079054f, -0.24441960f, -0.38516772f, -0.14492890f, -0.21053652f, 0.13462727f, 0.08023375f, 
    -0.38543636f, 0.33452061f, 0.08273374f, 0.03107565f, 0.16647221f, -0.25062129f, -0.15892094f, -0.12645915f, 
    -0.17990768f, -0.20215705f, 0.09912504f, 0.12202122f, 0.05302018f, 0.06950086f, -0.01134595f, 0.15609491f, 
    -0.05133440f, 0.10549470f, 0.01833421f, 0.29438981f, 0.14746438f, 0.16694038f, 0.17482980f, 0.04856456f, 
    0.16577037f, -0.07928421f, -0.11955067f, -0.26548085f, 0.07164831f, 0.01198319f, -0.01222887f, -0.20756295f, 
    -0.27181736f, 0.20095772f, -0.10661350f, -0.10934819f, -0.13007005f, 0.17793344f, 0.27063879f, 0.03399190f, 
    0.27249220f, 0.39935544f, -0.00911231f, 0.03780502f, 0.03236881f, -0.07271218f, 0.03801136f, -0.01166926f, 
    0.19892733f, 0.02320115f, 0.07328513f, 0.16856681f, -0.23945840f, -0.19739525f, -0.25165963f, 0.19789660f, 
    0.05423067f, 0.05032370f, -0.42738193f, -0.38110548f, -0.10054589f, -0.24431297f, -0.05745494f, 0.25771022f, 
    0.02082072f, 0.13077968f, -0.04628620f, 0.11983123f, -0.11588884f, 0.11007369f, -0.25934461f, 0.04935775f, 
    0.06514826f, 0.11186291f, -0.01210769f, 0.08069671f, -0.09245688f, -0.46418136f, -0.03672055f, 0.14134873f, 
    -0.00158832f, -0.03343652f, -0.06850334f, 0.11948361f, -0.10850926f, -0.03231685f, 0.09138117f, 0.02430356f, 
    -0.26782963f, -0.09701268f, -0.32423297f, 0.08513441f, 0.03257873f, -0.07425123f, -0.00639688f, 0.04029922f, 
    -0.02536494f, -0.08487212f, 0.00061238f, -0.01989406f, 0.11222319f, -0.02234320f, 0.07679523f, -0.21119303f, 
    0.26412958f, 0.45785317f, -0.11510903f, -0.00162289f, -0.24775733f, -0.21173117f, 0.01750296f, 0.11352561f, 
    -0.05864120f, 0.00860961f, -0.01660565f, -0.02437842f, -0.01861437f, -0.06152410f, 0.08321026f, -0.06424148f, 
    0.23366211f, -0.15573907f, 0.16315095f, 0.11296124f, -0.07982218f, -0.13057172f, -0.06172804f, -0.02857529f, 
    -0.16124021f, -0.04221468f, 0.03542440f, -0.13796453f, 0.05309592f, -0.10223071f, 0.02519765f, -0.00177523f, 
    0.09120394f, -0.01852836f, -0.00495147f, -0.16204208f, -0.35195783f, 0.08634146f, 0.03845483f, -0.14060839f, 
    0.14365116f, 0.16501345f, 0.00577633f, 0.25465399f, 0.01603020f, 0.03808348f, 0.25270113f, 0.12902501f, 
    -0.08522167f, -0.11112640f, 0.08996250f, 0.09977402f, 0.04066028f, 0.08794392f, -0.09830880f, 0.31924540f, 
    -0.72142953f, -0.35606444f, 0.02754635f, 0.08811677f, 0.04539731f, 0.09002810f, -0.20185277f, -0.04782142f, 
    0.29585329f, 0.00520529f, 0.05932506f, -0.09275082f, 0.04308410f, 0.10796415f, 0.29071194f, -0.11394498f, 
    -0.12757774f, 0.06658547f, -0.10897921f, -0.26645073f, 0.03963209f, 0.00986614f, -0.01451647f, 0.02060932f, 
    0.15571649f, -0.13419355f, -0.18799756f, -0.08892378f, -0.04896489f, 0.16253886f, 0.09446959f, -0.00959554f, 
    0.27856758f, 0.02077786f, 0.05189455f, -0.12918913f, -0.02773253f, -0.01011165f, 0.14053175f, 0.05742419f, 
    0.06604058f, -0.05673211f, 0.46823019f, -0.06554618f, -0.80761254f, -0.03446172f, 0.09081092f, 0.24098699f, 
    0.00693811f, 0.08349264f, -0.14975519f, -0.31874928f, 0.17187199f, -0.05038637f, -0.02076045f, 0.04884780f, 
    0.21705636f, 0.05305742f, 0.07446367f, -0.03959118f, 0.25818869f, 0.19827554f, -0.03690597f, 0.06228261f, 
    0.08533949f, 0.12311964f, 0.04588325f, -0.07575075f, 0.08991403f, -0.23037024f, -1.25038815f, -0.00661345f, 
    0.03306294f, 0.01264823f, 0.00058662f, -0.07768068f, 0.18735637f, -0.15973823f, 0.06465007f, 0.35938784f, 
    -0.19241925f, 0.00898138f, 0.07801815f, -0.06944159f, 0.04855262f, -0.00709168f, -0.09159973f, -0.09777161f, 
    -0.23972438f, 0.01573701f, 0.19743106f, -0.01449366f, -0.11484607f, 0.00131963f, 0.25514671f, 0.06351303f, 
    0.33244473f, 0.16129580f, 0.11621502f, 0.08229887f, 0.25676984f, 0.05489925f, 0.14706543f, 0.14821610f, 
    0.05525530f, 0.08237439f, 0.11694574f, 0.17579925f, 0.19681858f, -0.05406730f, 0.01946756f, -0.04032539f, 
    0.04059763f, -0.12996189f, -0.39729583f, 0.51459694f, 0.37333620f, 0.06136527f, -0.02022721f, -0.02639944f, 
    -0.09872761f, 0.17564215f, -0.25856784f, 0.26366550f, -0.26800048f, 0.16499466f, 0.20535007f, 0.06435584f, 
    0.26612997f, -0.05264809f, 0.09260097f, 0.05259726f, -0.05100026f, -0.01618975f, 0.07360642f, 0.06810860f, 
    0.03673880f, -0.02588614f, -0.03391057f, -0.22779417f, 0.01802508f, -0.11073261f, 0.00118701f, 0.06656507f, 
    0.18242900f, 0.11799360f, 0.05947666f, 0.17353986f, -0.32228792f, 0.14299032f, -0.09157567f, -0.05110327f, 
    -0.12222055f, 0.04891334f, 0.16664895f, 0.06407110f, -0.09281518f, 0.02216216f, -0.12790409f, 0.01375124f, 
    -0.12883183f, 0.04315455f, -0.11376966f, -0.08115131f, 0.01875062f, -0.01562418f, -0.12784101f, -0.24972464f, 
    -0.15116079f, -0.23059788f, 0.09835545f, 0.09100591f, 0.06170838f, 0.06839349f, -0.04623213f, -0.03645855f, 
    -0.08690628f, -0.07167037f, -0.05811640f, -0.12980424f, 0.09920292f, 0.07129744f, 0.08827433f, 0.03489741f, 
    0.17025827f, -0.08767725f, 0.02501333f, 0.50635701f, -0.10342100f, 0.07517109f, -0.13765591f, 0.12381604f, 
    -0.21312588f, -0.26263788f, -0.18826565f, 0.05520269f, 0.16599908f, 0.23264563f, 0.17948727f, -0.00028648f, 
    -0.19679864f, 0.11110885f, 0.24311873f, 0.26996392f, -0.38350725f, -0.34144285f, -0.13132247f, 0.07126937f, 
    0.07796163f, 0.04389246f, 0.14134654f, 0.09756541f, 0.01077048f, 0.03978995f, 0.00876268f, 0.06144715f, 
    0.08347657f, 0.10675866f, 0.03280051f, -0.02581615f, 0.10705002f, 0.12838838f, -0.03694542f, -0.11665064f, 
    0.01528656f, 0.10792240f, -0.00207103f, -0.03007341f, 0.20522067f, 0.13101864f, 0.12559706f, -0.09636128f, 
    -0.61396569f, -0.08456169f, 0.01179537f, 0.20540674f, 0.01135754f, 0.05511230f, 0.00931329f, 0.11403393f, 
    -0.43709609f, -0.26131704f, 0.04397498f, 0.12859882f, -0.01949487f, -0.03107745f, 0.06568614f, 0.05597072f, 
    -0.09809621f, 0.26870862f, 0.09412505f, 0.01700642f, 0.02623304f, 0.03013573f, 0.17947310f, -0.05728738f, 
    0.08707600f, 0.08438918f, 0.11565757f, 0.11041457f, 0.23830022f, 0.13372812f, 0.12666163f, -0.25606453f, 
    0.15851177f, 0.12044097f, 0.26576105f, -0.14986309f, -0.03877939f, 0.16628881f, 0.02202150f, -0.01361972f, 
    0.07126983f, -0.05981908f, -0.15570922f, 0.01092134f, 0.16295181f, 0.04873845f, 0.07244454f, 0.13237184f, 
    -0.02296703f, 0.03789150f, 0.19065619f, 0.14441748f, 0.09019075f, 0.27084270f, -0.09200533f, 0.01430279f, 
    0.14215368f, 0.05694811f, 0.01861611f, -0.09429707f, -0.09592997f, -0.12409764f, 0.37650537f, -0.10133611f, 
    0.31063244f, 0.11578211f, 0.04898093f, 0.02461627f, 0.18371269f, -0.14997557f, 0.13779823f, -0.06264532f, 
    0.21016006f, 0.07138658f, -0.07363705f, -0.02705180f, 0.06282469f, -0.12249517f, -0.19767307f, -0.22631243f, 
    0.09858068f, -0.07685822f, 0.35978529f, 0.04501519f, -0.02910341f, -0.11987381f, 0.09253316f, 0.07633301f, 
    -0.03181471f, 0.00814610f, 0.02154771f, 0.20464359f, -0.07956774f, 0.00968611f, 0.11225887f, -0.10929975f, 
    -0.22497551f, -0.18035215f, -0.35757425f, 0.20271002f, 0.56537998f, 0.11722680f, 0.07187767f, -0.02152041f, 
    0.14284217f, 0.17839640f, -0.17904919f, 0.33031228f, 0.29777128f, 1.02224445f, -0.12893790f, 0.07936464f, 
    -0.23208360f, -0.02846136f, 0.14522824f, 0.19435605f, 0.08304852f, 0.14971606f, 0.10207648f, 0.07331234f, 
    0.13472788f, -0.18952928f, 0.25540471f, 0.27844387f, 0.15795235f, -0.36333707f, -0.04979685f, -0.15740962f, 
    0.22316837f, 0.08780324f, 0.05010292f, 0.08476822f, 0.09549571f, 0.00292056f, 0.11419092f, -0.03448297f, 
    0.64844388f, -0.26160821f, -0.03765744f, 0.15120213f, 0.08639216f, 0.14695270f, 0.11718952f, -0.21214963f, 
    -0.20475195f, 0.01282284f, -0.04688966f, 0.06271354f, 0.06845074f, 0.01655629f, -0.10236875f, -0.20172790f, 
    -0.04329227f, 0.01134235f, 0.02665588f, -0.00798690f, 0.04651071f, 0.02992004f, 0.03662096f, 0.01372390f, 
    -0.06646223f, -0.01041369f, 0.04690782f, -0.05550947f, -0.00803728f, -0.03221817f, 0.05431274f, 0.03447622f, 
    0.00779714f, 0.00839503f, 0.03365557f, 0.04894501f, -0.06916399f, -0.06112609f, 0.02040953f, -0.00630285f, 
    0.02087216f, 0.00704080f, -0.05938322f, 0.02496853f, -0.02018330f, 0.01948581f, -0.05166678f, 0.05062595f, 
    0.01736362f, -0.02397959f, -0.02637586f, -0.00681590f, 0.04552579f, 0.00699537f, -0.00074481f, 0.04692665f, 
    -0.02203592f, -0.04057508f, -0.02188003f, -0.05451981f, -0.03090923f, 0.02008034f, 0.00566634f, -0.06555571f, 
    -0.04731020f, -0.04769361f, 0.00637335f, -0.03605407f, -0.00825224f, -0.05394340f, -0.01691569f, 0.04135762f, 
    -0.04603850f, -0.06346727f, -0.05664865f, -0.02826708f, 0.00452885f, -0.00608349f, 0.00053031f, -0.03100539f, 
    0.01651249f, -0.02020555f, -0.00939762f, 0.01241988f, -0.03049652f, 0.04632568f, 0.04376123f, -0.00560408f, 
    -0.03316457f, -0.03481197f, -0.05608327f, 0.03104198f, -0.05766971f, -0.01647148f, 0.00224006f, -0.06035924f, 
    -0.07347449f, 0.03210088f, -0.05507546f, 0.04387021f, -0.01326556f, -0.00050903f, 0.00674163f, 0.05260893f, 
    0.00362563f, -0.02901161f, -0.02018938f, -0.01932835f, -0.02291002f, -0.03871001f, 0.02539941f, 0.01143213f, 
    -0.06223483f, -0.06327290f, 0.01510287f, -0.00571250f, 0.04531733f, -0.04472370f, 0.02497262f, 0.01100774f, 
    0.00417389f, 0.01520458f, -0.02920073f, -0.05252760f, 0.03723902f, -0.04672145f, 0.00433273f, -0.04417290f, 
    0.00708789f, -0.03913212f, -0.03318486f, -0.04988088f, -0.04752631f, 0.03976690f, 0.04027760f, 0.03019030f, 
    0.04360719f, -0.02763491f, 0.00360201f, 0.00439880f, -0.03292264f, 0.00149520f, -0.04442517f, 0.02819720f, 
    0.00281861f, -0.01927597f, -0.03382277f, -0.05561350f, -0.00997668f, -0.01045790f, -0.02235167f, -0.01954247f, 
    0.01010651f, -0.03036728f, 0.03774530f, -0.03252538f, -0.04325931f, 0.04796946f, 0.01612307f, 0.04762733f, 
    -0.03309286f, -0.02044195f, 0.02656043f, -0.03192734f, -0.00613624f, -0.01564275f, 0.03473121f, 0.00987441f, 
    0.04436080f, -0.03361859f, -0.04105367f, 0.02046848f, -0.00112432f, -0.06874115f, -0.02652263f, 0.03103945f, 
    0.04356574f, -0.06835938f, 0.04759345f, 0.05318158f, 0.02255031f, -0.03959262f, -0.04147954f, -0.01182788f, 
    -0.01021255f, -0.01908089f, -0.04508797f, 0.03904849f, 0.01078083f, -0.02043339f, 0.03416380f, 0.04026002f, 
    0.01014493f, 0.03448652f, 0.04606191f, 0.02501842f, -0.06036103f, -0.00218911f, -0.01371545f, 0.03088277f, 
    -0.05290223f, 0.00712744f, -0.02538253f, -0.01162163f, -0.04018531f, 0.03284720f, -0.02259574f, -0.05213964f, 
    -0.03352645f, -0.00187062f, -0.03057644f, -0.04706983f, -0.05258027f, 0.01676142f, -0.04666453f, -0.04499526f, 
    0.03050553f, 0.01234327f, -0.05601638f, -0.02532281f, 0.04764368f, -0.03966488f, -0.00652386f, -0.01128756f, 
    -0.00731269f, 0.01326296f, 0.04739382f, 0.01708363f, -0.05473065f, -0.05188406f, -0.01435676f, 0.00192913f, 
    0.00425913f, 0.00399348f, -0.02091270f, 0.04380680f, 0.03170263f, 0.00373215f, 0.00862257f, 0.00510580f, 
    0.04181832f, 0.01065448f, 0.01453921f, 0.04712475f, -0.05265127f, 0.00179374f, 0.04403362f, -0.06892629f, 
    -0.05841183f, -0.00585889f, 0.02733327f, -0.02443461f, 0.03900536f, 0.00298417f, -0.02924042f, 0.05249614f, 
    0.03259648f, 0.00422431f, 0.02317326f, 0.00454540f, -0.03831442f, -0.05982473f, 0.00810403f, -0.00772023f, 
    0.04099410f, -0.05776205f, 0.01696965f, 0.00231230f, 0.01055048f, -0.05452072f, -0.06517325f, 0.03825448f, 
    -0.00557409f, 0.03728072f, -0.04205209f, -0.04145472f, -0.02319430f, -0.02428607f, 0.05162959f, -0.06436324f, 
    -0.06054758f, -0.02428867f, 0.00099660f, -0.04228537f, -0.00428792f, 0.02762941f, -0.01446950f, 0.01481675f, 
    0.04127350f, -0.05174538f, -0.05285487f, 0.03452744f, -0.01866157f, 0.00862927f, -0.04316021f, -0.03255372f, 
    -0.00472519f, -0.02949326f, 0.02894677f, 0.01197259f, -0.05180265f, 0.03794235f, 0.00531566f, -0.04494565f, 
    -0.49632451f, -0.85769635f, -0.13102584f, -0.09322692f, -0.13671730f, -0.10994142f, -0.16487290f, -0.09658043f, 
    0.13251020f, -0.47798306f, -0.10239145f, 0.16944087f, 0.02799808f, -0.22800344f, 0.11952698f, 0.03335355f, 
    0.11553686f, 0.16351143f, 0.90193236f, -0.31406480f, -0.07172910f, 0.10956680f, -0.08134943f, -0.09741259f, 
    0.15585665f, 0.31177750f, -0.24557850f, -0.17743716f, 0.15135866f, -0.20124939f, 0.11711472f, 0.01231371f, 
    0.20193423f, 0.14572296f, 0.13134597f, 0.02278996f, 0.93918461f, -0.19592904f, -0.96659017f, -0.09466456f, 
    0.27737695f, 0.06033869f, 0.18326581f, -0.07410711f, -0.06848894f, 0.45391715f, 0.17903841f, 0.01694611f, 
    0.01149068f, -0.04702119f, 0.06052691f, 0.10909311f, 0.01508006f, 0.10932387f, -0.07930961f, 0.07328420f, 
    0.18427126f, 0.01311712f, 0.05049316f, -0.04148220f, 0.13474226f, -0.01786159f, -0.03731436f, 0.07718965f, 
    0.13534229f, 0.17058215f, -0.09010545f, 0.10292255f, -0.01340857f, 0.03541425f, 0.10409787f, 0.10014763f, 
    0.00813167f, -0.39764220f, -0.08456033f, 0.07368039f, -0.06226726f, -0.03713667f, -0.02155865f, 0.08390427f, 
    0.03487164f, -0.14689620f, 0.23440187f, -0.00392582f, -0.11731237f, -0.04145964f, -0.00291299f, 0.05354204f, 
    -0.06091762f, -0.08300544f, 0.51287097f, -0.20226096f, -0.39318216f, -0.03690008f, -0.12347906f, -0.11501230f, 
    0.07338098f, 0.06204742f, -0.07414703f, 0.42842081f, 0.02032273f, -0.29991505f, -0.00421771f, -0.00949665f, 
    0.11434704f, 0.24881512f, 0.05394662f, -0.02915079f, -0.20866594f, 0.14820209f, 0.06460574f, -0.04987049f, 
    0.10731972f, -0.05913532f, 0.06252556f, 0.01226536f, -0.00706516f, -0.09927980f, 0.09408096f, -0.08866050f, 
    -0.05354982f, -0.04834618f, 0.00754271f, 0.16305467f, 0.03673722f, -0.16707207f, -0.18470070f, 0.25766733f, 
    -0.02313663f, 0.03756839f, -0.00145925f, 0.04033966f, 0.19385885f, -0.02239308f, -0.00150750f, 0.33825287f, 
    0.23558605f, -0.06040501f, -0.05798300f, 0.06128365f, -0.06484761f, -0.11687162f, -0.18415430f, -0.05688728f, 
    0.52491069f, 0.20183967f, 0.02341709f, -0.02571170f, -0.25949040f, -0.19558686f, -0.00730809f, 0.00968412f, 
    -0.12805015f, 0.01149704f, -0.24123737f, -0.44167656f, -0.05418698f, 0.11928115f, -0.17982392f, -0.00991480f, 
    -0.07268885f, 0.12866282f, 0.25918487f, 0.02778806f, -0.36468717f, -0.01026634f, 0.05104069f, 0.21012373f, 
    0.07751295f, -0.11114471f, -0.00236730f, 0.03388672f, 0.01286824f, -0.00444613f, 0.10528423f, 0.16277152f, 
    -0.01586381f, 0.01887037f, 0.05646779f, 0.07443382f, 0.17154305f, -0.00942294f, -0.42034748f, 0.07246763f, 
    -0.12113336f, 0.12972595f, 0.42876264f, -0.01349912f, 0.09528478f, 0.24612349f, 0.18654875f, -0.55778503f, 
    0.02660880f, 0.07987427f, 0.14028893f, -0.06324000f, -0.05064932f, -0.13412528f, 0.42851713f, -0.24333102f, 
    -0.83948022f, 0.09813513f, 0.05913267f, 0.11155026f, 0.34467983f, -0.04597782f, 0.07190160f, -0.07226392f, 
    0.00484492f, -0.20748290f, 0.00378655f, -0.03829763f, -0.05091654f, -0.03403837f, -0.00405210f, -0.11614882f, 
    -0.15954414f, 0.01915514f, -0.26387474f, -0.03950971f, 0.07811967f, 0.29542902f, 0.12219325f, -0.03011957f, 
    0.08889811f, 0.38631257f, -0.12056837f, -0.70718992f, 0.05537678f, 0.19633299f, 0.34495008f, 0.03073668f, 
    0.06115570f, 0.01391272f, -0.71429741f, -0.50883687f, -0.23028098f, -0.25069460f, -0.30483654f, 0.28346106f, 
    0.02613628f, 0.02010865f, 0.00056623f, 1.11283195f, -0.44326341f, -0.84347618f, 0.07484267f, 0.23301980f, 
    0.07544608f, 0.00587850f, 0.07537282f, 0.05949964f, 0.08963081f, -0.17472754f, -0.05452110f, 0.01745259f, 
    0.01636873f, 0.09136597f, -0.03622068f, -0.13121521f, 0.14859140f, -0.24508283f, -0.14479253f, -0.18068324f, 
    -0.07838908f, -0.01072441f, 0.00921635f, 0.13664725f, 0.14413561f, 0.09398261f, 0.02097679f, -0.41847202f, 
    -0.60478354f, -0.01024312f, -0.16802494f, 0.09952449f, -0.00039571f, 0.10329305f, -0.00629199f, -0.21105003f, 
    -0.01267186f, 0.15716687f, -0.11300450f, -0.00626954f, -0.10740926f, -0.05429321f, -0.05674331f, 0.11216538f, 
    0.07926688f, 0.37220579f, 0.36544710f, 0.02734655f, -0.04760454f, -0.36773968f, 0.04451595f, -0.00872540f, 
    0.08373333f, 0.06133375f, 0.74347413f, 0.07186377f, -0.17621678f, -0.05675668f, -0.13585763f, 0.05693614f, 
    -0.12523791f, -0.05277093f, 0.07293341f, 0.05482429f, -0.20737396f, -0.02955567f, 0.06660853f, 0.15480199f, 
    -0.02827047f, -0.10380814f, -0.09149897f, -0.49344853f, 0.10049570f, -0.25853178f, 0.03056442f, -0.08130112f, 
    -0.08373302f, 0.07456861f, -0.15796983f, -0.20491251f, 0.21182959f, 0.00722432f, 0.53427905f, -0.00068382f, 
    0.20369376f, 0.07743071f, -0.03264652f, -0.12684567f, -0.09273567f, -0.05164072f, 0.22479892f, 0.41318691f, 
    -0.10281499f, 0.12453758f, 0.02783873f, 0.05682841f, -0.06702150f, -0.08570229f, 0.15982693f, -0.03781459f, 
    -0.07896852f, 0.01756222f, -0.05987482f, -0.00416575f, -0.09742811f, -0.10631616f, 0.07075061f, -0.21095449f, 
    -0.32238877f, -0.10920441f, 0.07975706f, -0.18737751f, -0.01721873f, 0.04262906f, -0.15193199f, 0.06462089f, 
    0.08349088f, 0.38288713f, 0.13213721f, 0.04195002f, 0.05831207f, -0.12868799f, -0.04213764f, -0.03971539f, 
    -0.02384272f, 0.11552816f, 0.06689215f, -0.05951749f, 0.12036952f, 0.03092008f, -0.07336013f, -0.21127568f, 
    -0.11879906f, -0.04970921f, 0.19463754f, 0.01349354f, 0.33242556f, -0.19101164f, 0.19335623f, 0.09411981f, 
    0.07985869f, -0.06269929f, -0.20408255f, -0.17256331f, -0.01071410f, -0.11492413f, -0.18076780f, 0.05808046f, 
    0.13908127f, -0.11759653f, 0.18828765f, 0.04716830f, -0.32017791f, -0.31030750f, -0.25267947f, -0.01204213f, 
    -0.10541697f, 0.01647359f, -0.02189529f, 0.04967977f, -0.01328018f, -0.01414167f, 0.08621039f, -0.10132881f, 
    -0.02527296f, 0.04348029f, 0.09261464f, -0.08373290f, -0.15676884f, 0.08393252f, -0.01433247f, 0.01034001f, 
    -0.12004994f, -0.03190883f, 0.11334858f, 0.00287716f, -0.03932292f, 0.04363578f, 0.00894736f, 0.40339395f, 
    0.44863671f, 0.56100434f, -0.15276872f, 0.04715377f, -0.23470698f, 0.02917641f, 0.11646365f, 0.10101684f, 
    0.30668193f, 0.09613484f, 0.30411124f, 0.10876868f, 0.06188069f, 0.01225420f, 0.10221729f, -0.06563298f, 
    -0.00602026f, 0.11288836f, 0.23781395f, 0.19731127f, -0.07868073f, -0.19353659f, -0.36566684f, 0.00968465f, 
    0.09790935f, 0.05213264f, -0.20087022f, 0.13297094f, -0.12288726f, 0.01255796f, -0.07495288f, 0.07321113f, 
    -0.13200575f, 0.05926973f, 0.07333846f, -0.19571820f, -0.37158981f, -0.20636415f, 0.03795780f, 0.07906071f, 
    0.01327404f, 0.12291057f, 0.24225089f, -0.13514608f, -0.04316100f, 0.04270060f, -0.02236893f, -0.08507561f, 
    0.03116986f, -0.08283633f, 0.19909510f, 0.01133595f, -0.08784962f, 0.29787692f, -0.07220606f, 0.14274421f, 
    0.11126889f, -0.06528316f, 0.17041974f, -0.18911985f, 0.03268517f, -0.01889269f, -0.13362378f, 0.13013032f, 
    0.30042586f, -0.00536246f, 0.04291866f, 0.13251285f, 0.02857363f, 0.04733304f, -0.01864010f, 0.09127796f, 
    -0.20994689f, -0.37040609f, 0.10468027f, 0.13897645f, 0.11700911f, 0.09993841f, 0.01276570f, -0.10529126f, 
    -0.25656882f, 0.12030956f, -0.22159448f, -0.02490216f, 0.13792315f, 0.11319213f, -0.01764902f, 0.00272802f, 
    -0.08709151f, 0.22341593f, -0.08444592f, -0.00615166f, 0.11734422f, 0.03900955f, 0.13437626f, -0.09396362f, 
    -0.19748040f, -0.23885004f, -0.06437740f, 0.36324432f, -0.36924991f, -0.16290715f, 0.23823339f, 0.08893535f, 
    -0.02752106f, 0.06671165f, -0.20089591f, -0.10706925f, 0.06371456f, 0.27699575f, -0.34006438f, 0.02747412f, 
    0.42022264f, 0.00565631f, 0.01918322f, -0.01852609f, 0.13795292f, 0.11582263f, 0.09774161f, 0.04452122f, 
    0.07420048f, -0.28088403f, -0.09297188f, 0.13447767f, 0.09822633f, -0.49928948f, -0.28650963f, 0.07352093f, 
    -0.18525378f, -0.08702321f, -0.29614472f, 0.01886238f, 0.01129721f, -0.05061620f, 0.07524614f, 0.31535044f, 
    -0.20599093f, -0.03632820f, 0.12213942f, -0.15503789f, 0.14695683f, -0.03352661f, 0.13900110f, -0.11548813f, 
    -0.39770058f, -0.32378963f, 0.16242245f, -0.07970653f, -0.04693051f, 0.13381192f, 0.00636720f, 0.02374772f, 
    -0.03259365f, -0.01477833f, -0.01123324f, 0.04443575f, 0.00838901f, -0.02155650f, 0.04826312f, 0.03510917f, 
    -0.02017745f, 0.03610662f, -0.07033908f, -0.03318924f, -0.06025832f, -0.02668911f, -0.01024089f, -0.03779447f, 
    -0.01442819f, 0.04361054f, 0.03842520f, -0.04975428f, -0.06195450f, 0.01063394f, -0.02586052f, -0.05790043f, 
    -0.03016195f, -0.06113750f, -0.01458124f, -0.05871248f, 0.03740886f, 0.03837627f, -0.00034756f, -0.01070024f, 
    -0.01478562f, 0.02335102f, -0.04360410f, -0.02087685f, 0.03480162f, 0.05139131f, 0.00143166f, 0.03772124f, 
    -0.04726860f, 0.03172575f, 0.00665488f, 0.00524091f, 0.00303738f, -0.03968012f, 0.03261226f, -0.05443671f, 
    0.03672734f, 0.04734742f, -0.04940172f, 0.03697203f, 0.02688791f, 0.02210147f, 0.03147894f, -0.01703003f, 
    -0.04688546f, -0.01242742f, 0.03333365f, -0.03846436f, -0.04435237f, 0.01795268f, -0.01745237f, 0.00659773f, 
    -0.04015948f, -0.01097001f, -0.03788076f, 0.03668993f, 0.04906196f, -0.00805508f, 0.01926977f, 0.04922124f, 
    -0.00036093f, -0.03214506f, 0.03621329f, 0.04494371f, 0.00974107f, 0.03843375f, -0.05480294f, 0.02859027f, 
    -0.01858668f, -0.04667548f, 0.04215781f, -0.05034698f, 0.04097241f, -0.05519460f, -0.00588346f, 0.00718964f, 
    0.02710003f, -0.05069051f, -0.05747278f, -0.05328681f, -0.04274586f, -0.05587827f, 0.04577183f, 0.00410737f, 
    -0.05294123f, 0.04221509f, 0.00485674f, -0.03417442f, -0.01659179f, -0.00962676f, -0.02215996f, 0.02087695f, 
    -0.02117721f, -0.05340838f, -0.02232701f, 0.02475360f, 0.01551296f, -0.06447780f, 0.04156264f, -0.06003814f, 
    0.01292842f, 0.02584826f, 0.02529885f, -0.00276257f, -0.04876301f, -0.00982546f, 0.03511593f, 0.00191813f, 
    -0.01741447f, -0.05984718f, -0.05083280f, -0.03896749f, -0.02666836f, -0.05630808f, -0.01430260f, -0.05188804f, 
    -0.03928233f, -0.00058514f, -0.02891835f, 0.00381247f, -0.02564762f, -0.02471782f, 0.00562743f, -0.00482115f, 
    -0.04136677f, -0.03340408f, -0.01011984f, -0.06174158f, -0.00288569f, 0.01327530f, -0.06684445f, -0.00725976f, 
    -0.03140093f, -0.00040643f, -0.03054400f, -0.01399461f, -0.04907492f, -0.01628180f, -0.03910292f, -0.07031988f, 
    0.02943917f, 0.02962437f, -0.00235634f, -0.03897392f, -0.01550525f, -0.04013541f, -0.02904996f, -0.05923339f, 
    0.03585693f, 0.04986217f, -0.00531633f, 0.01776812f, 0.01622756f, -0.00458717f, -0.03628539f, -0.02606511f, 
    0.05181850f, -0.02054170f, 0.04403098f, 0.02704799f, -0.04705274f, 0.02353830f, 0.00717729f, -0.01677935f, 
    0.00634981f, 0.01686058f, 0.05688752f, 0.04491811f, 0.01867236f, 0.04500381f, 0.05003999f, -0.04882141f, 
    0.00498423f, -0.05540799f, -0.01428884f, 0.04459199f, -0.04883931f, 0.02806776f, -0.00447788f, -0.02111601f, 
    0.00757346f, -0.01437478f, -0.03104436f, -0.01184068f, -0.02387848f, -0.04406971f, -0.01924446f, 0.03347687f, 
    0.00455228f, -0.06094733f, 0.04050618f, -0.00538548f, -0.00996003f, 0.01412593f, -0.05651911f, -0.01100528f, 
    -0.05084435f, -0.00207350f, 0.02286791f, 0.00700630f, -0.02519735f, -0.03961739f, -0.03093305f, -0.05548156f, 
    0.02025674f, 0.01952295f, 0.02374199f, 0.02712548f, -0.04300389f, 0.00921609f, -0.06062510f, -0.02683621f, 
    -0.04003521f, -0.01700028f, 0.02085354f, -0.00646732f, -0.01144046f, -0.05455567f, -0.06218616f, -0.01048580f, 
    -0.02118584f, -0.04165109f, -0.04658917f, -0.01352705f, 0.00342009f, -0.01157254f, -0.00363087f, 0.02503831f, 
    0.01126982f, -0.01752684f, 0.01350522f, -0.04352701f, -0.00155728f, 0.01192962f, -0.05339440f, -0.01913540f, 
    0.02130051f, -0.02686564f, 0.01671748f, 0.01451397f, -0.00820777f, 0.05056164f, -0.03410506f, -0.00383580f, 
    0.03006820f, -0.03575289f, 0.00735495f, 0.05220337f, 0.02697536f, 0.03227581f, -0.04558459f, -0.01785039f, 
    -0.00417916f, 0.00387370f, -0.00409132f, 0.01033577f, 0.00699207f, -0.03189941f, 0.04447846f, 0.02170506f, 
    0.01936199f, -0.01831277f, 0.00206894f, -0.00625220f, 0.05167805f, 0.01369438f, -0.06508461f, 0.02759186f, 
    -0.04201671f, 0.02267846f, -0.00446666f, -0.05064067f, 0.04320249f, -0.00262149f, 0.03177797f, 0.03823045f, 
    -0.04107525f, -0.01716573f, 0.01273901f, -0.10314009f, 0.12040598f, -0.05604577f, -0.06143535f, -0.10273874f, 
    -0.07483421f, 0.13875362f, 0.15263753f, 0.06022784f, 0.09558085f, 0.13804643f, 0.01482011f, 0.02470820f, 
    0.05423191f, -0.28849468f, 0.34525913f, 0.23924403f, -0.13391078f, 0.04183368f, 0.23998880f, -0.12876664f, 
    0.30832398f, -0.12796348f, -0.30106390f, 0.65735555f, -0.07893571f, 0.30720699f, -0.08432122f, -0.02318413f, 
    0.18716395f, -0.01956389f, -0.06858140f, 0.04556400f, 0.12252412f, 0.44544235f, 0.32416943f, 0.01726852f, 
    0.05194514f, -0.05011772f, 0.11418184f, 0.06345057f, 0.12403507f, -0.33588251f, 0.21050501f, 0.06951771f, 
    0.17277130f, -0.00962127f, 0.02812103f, 0.23589875f, -0.01673452f, 0.17002928f, -0.39298305f, -0.24256925f, 
    0.17805652f, -0.22167829f, -0.17144942f, -0.04494296f, -0.14970763f, 0.07228150f, -0.01230657f, -0.15862851f, 
    -0.54152060f, -0.06734890f, 0.18870877f, -0.02578229f, -0.23679003f, 0.04257077f, -0.16236794f, -0.07606453f, 
    -0.01614180f, -0.00505122f, -0.14207698f, 0.02327543f, 0.16914643f, 0.07984751f, 0.11743037f, 0.12466224f, 
    -0.16161028f, -0.51856375f, -0.58843118f, -0.08919113f, -0.10655246f, -0.24887884f, -0.25193682f, 0.04820183f, 
    -0.20739640f, -0.11009282f, 0.58538252f, 0.64685905f, 0.15599078f, 0.19828776f, -0.00363649f, -0.27405936f, 
    0.07886641f, -0.15756378f, -0.17244238f, -0.33384913f, -0.42150703f, -0.20812984f, -0.01590715f, 0.01196398f, 
    0.38653031f, -0.06256028f, 0.13763100f, -0.01457085f, -0.59122378f, -0.40471947f, 0.09084474f, -0.16985005f, 
    -0.29176766f, 0.27941838f, 0.03780268f, 0.22641326f, 0.16923112f, -0.16301014f, -0.29063267f, -0.18302023f, 
    -0.21419741f, 0.03660311f, 0.15637094f, -0.03661287f, 0.12405695f, 0.04598205f, -0.51000184f, -0.57619393f, 
    -0.12906031f, -0.21557011f, 0.08189604f, -0.03194672f, 0.08651023f, 0.05550175f, 0.20186977f, -0.10269943f, 
    0.13454930f, -0.08531391f, -0.10722537f, -0.06374947f, 0.41590881f, 0.23044384f, -0.09152223f, 0.25049210f, 
    0.16785295f, 0.19316897f, 0.02120483f, 0.16503754f, -0.03205664f, 0.05081479f, 0.08589869f, -0.23491617f, 
    0.00258503f, -0.10181057f, -0.02692219f, -0.09863955f, -0.07675289f, 0.02909554f, 0.31238306f, -0.10708097f, 
    0.00567784f, -0.06800398f, -0.23191752f, -0.24684112f, -0.08716802f, 0.01355290f, 0.20149399f, 0.26762137f, 
    0.31569687f, 0.10166827f, 0.00946651f, 0.20329547f, 0.07452484f, -0.10724845f, -0.10150336f, 0.20030993f, 
    0.12963690f, 0.38297907f, 0.28913063f, 0.04529459f, -0.23011664f, -0.32291651f, -0.14798087f, -0.05837984f, 
    0.14511038f, 0.09862286f, 0.01954048f, 0.31079164f, -0.28236181f, -0.59190959f, -0.40718320f, -0.18137319f, 
    -0.02231527f, -0.37403369f, -0.23626751f, 0.27808133f, -0.07951139f, -0.12266481f, -0.02407420f, 0.04648522f, 
    0.05172100f, 0.10340433f, -0.02723008f, 0.01295159f, 0.30606735f, -0.01574820f, 0.01710056f, -0.43421790f, 
    -0.48446542f, -0.39385766f, -0.08515227f, 0.03191864f, -0.49969178f, 0.10109282f, 0.10766070f, -0.17059791f, 
    0.17004591f, -0.40688607f, -0.09641761f, -0.23498473f, 0.33769074f, 0.24691474f, 0.40156728f, 0.11679203f, 
    0.04708280f, 0.07137888f, 0.19614995f, -0.09243271f, 0.05271258f, 0.19385445f, 0.03852515f, 0.07235694f, 
    0.09433712f, -0.29855108f, -0.52516681f, -0.19081651f, -0.10664527f, -0.15584879f, -0.35131273f, -0.05631941f, 
    0.06533159f, -0.03667266f, 0.04584900f, -0.02977295f, 0.06046250f, 0.14821701f, 0.00034213f, 0.18164510f, 
    0.32058957f, 0.21910007f, 0.18121773f, 0.05835980f, -0.48710337f, -0.16084316f, 0.13592592f, -0.02798731f, 
    0.02991106f, 0.23273058f, -0.11116079f, 0.05745688f, 0.10076707f, -0.52923328f, -0.41528851f, 0.09648920f, 
    -0.24612544f, -0.17253883f, -0.02893472f, 0.09908837f, 0.18043453f, 0.19870488f, 0.13902055f, -0.02114780f, 
    -0.15283807f, -0.07531377f, 0.14531896f, 0.12112570f, -0.03222248f, 0.29907012f, -0.02016476f, -0.40518951f, 
    -0.55626369f, -0.16682871f, 0.01609642f, 0.00213619f, 0.23875095f, -0.04980725f, -0.14521196f, -0.12244408f, 
    0.42576671f, 0.26990405f, 0.31879121f, 0.00028736f, 0.02120205f, -0.12164256f, 0.14571704f, -0.12649682f, 
    -0.10774708f, 0.43058285f, 0.29619604f, -0.08271911f, 0.01720413f, -0.14854772f, -0.07632560f, -0.01715479f, 
    -0.03423755f, 0.01599770f, 1.07713199f, -0.39693618f, -0.20829739f, 0.14135766f, -0.03019816f, 0.07291093f, 
    0.01123642f, 0.00635204f, -0.02685600f, 0.02265384f, -0.20014444f, -0.44254729f, 0.08659526f, -0.21879420f, 
    0.06941803f, -0.03580402f, 0.17711499f, 0.17137757f, -0.05073091f, -0.23619363f, -0.49699679f, 0.07524507f, 
    -0.04314837f, 0.09103220f, 0.05382914f, 0.06172749f, 0.05899001f, -0.47216722f, 0.16078530f, 0.07525174f, 
    -0.09948805f, 0.01929686f, 0.06299390f, 0.06380534f, -0.03179966f, -0.05951032f, 0.08868065f, -0.03826417f, 
    -0.44218135f, -0.05081474f, -0.00525673f, 0.01718224f, -0.02641762f, -0.20619969f, 0.06164544f, -0.20171407f, 
    -0.16690366f, 0.15507671f, 0.22176354f, -0.15069079f, -0.10775649f, -0.02467579f, 0.03296863f, 0.01765741f, 
    0.34647942f, 0.20491228f, 0.34386319f, 0.03617363f, 0.17515862f, -0.04583521f, 0.05065966f, -0.03934957f, 
    -0.02175614f, -0.02164034f, -0.16115636f, -0.17083451f, -0.00851313f, 0.06595404f, 0.16811560f, 0.08274365f, 
    -0.02426040f, 0.13509561f, 0.09154987f, -0.31088889f, -0.18401165f, -0.03401241f, -0.18101628f, 0.20327318f, 
    0.13365613f, -0.00016468f, -0.16997820f, -0.14154640f, -0.13793314f, -0.28916556f, 0.03268836f, -0.19907032f, 
    -0.02572496f, 0.15006152f, 0.00591933f, 0.07668129f, 0.52273887f, -0.10290938f, -0.07356243f, 0.21376806f, 
    -0.11761266f, 0.04558938f, 0.06076219f, 0.07869425f, 0.17321132f, 0.06571282f, -0.09722421f, -0.25466555f, 
    0.06341115f, 0.01276898f, 0.09697162f, 0.21815759f, 0.23099464f, 0.27161443f, 0.23757492f, -0.04040071f, 
    -0.17159517f, -0.01570501f, 0.09666356f, 0.09016391f, 0.15645841f, 0.04134607f, 0.04151810f, 0.08433652f, 
    0.12414189f, 0.53842896f, 0.21646674f, -0.13639975f, 0.03876801f, -0.10251665f, -0.11552420f, 0.03314034f, 
    0.14820942f, 0.16333830f, 0.37108019f, 0.12598905f, -0.07927567f, 0.04347851f, 0.06421702f, 0.01961064f, 
    -0.01475443f, 0.31900519f, 0.16834611f, 0.41877347f, 0.14195025f, -0.12532806f, -0.03455802f, 0.08960821f, 
    -0.04699305f, -0.14974958f, -0.11989295f, -0.17904584f, -0.27613318f, 0.03268602f, -0.11531564f, -0.01891796f, 
    -0.01409064f, 0.00897754f, -0.22790353f, 0.03954895f, -0.46461099f, -0.26551065f, -0.04974147f, 0.09349500f, 
    -0.01121095f, 0.06922483f, 0.07488746f, -0.11375737f, 0.10533234f, -0.17260927f, -0.03443692f, 0.08332342f, 
    0.02818309f, 0.07613255f, 0.09608676f, 0.19287978f, -0.09377734f, 0.02366650f, -0.53649479f, -0.58715272f, 
    0.18495418f, -0.12232298f, -0.08086327f, 0.03543385f, 0.16731055f, 0.24678212f, -0.07133832f, -0.15229982f, 
    -0.38060310f, 0.06822292f, 0.07475783f, 0.26921451f, -0.02251876f, -0.17913900f, 0.11511194f, 0.24249172f, 
    -0.35438293f, -0.22054668f, 0.13912973f, -0.01309053f, 0.00035882f, 0.02816093f, -0.00236471f, -0.08265097f, 
    0.33321384f, -0.35820657f, -0.64288521f, 0.02880928f, -0.00882711f, 0.06369931f, 0.09237158f, -0.15711893f, 
    -0.23570186f, 0.35182783f, -0.04981718f, -0.07037123f, 0.04845568f, 0.08236760f, 0.07900609f, 0.19729970f, 
    -0.07662738f, 0.04788769f, 0.49032059f, 0.12585779f, -0.89744169f, -0.09944665f, -0.27769047f, 0.06386551f, 
    0.13230300f, -0.11958563f, -0.02377732f, -0.19999358f, 0.23076467f, -0.20585696f, -0.24135716f, -0.55092680f, 
    -0.22010857f, 0.21580084f, -0.15043987f, 0.05300041f, 0.26897725f, 0.12621033f, 0.05465169f, 0.04961573f, 
    -0.18290009f, 0.11498817f, 0.18533203f, 0.00908332f, -0.11473653f, 0.04417318f, -0.33829662f, -0.06918745f, 
    0.15912311f, -0.24421912f, -0.31614190f, 0.00630597f, 0.20881487f, 0.05154264f, 0.21372652f, 0.20701802f, 
    -0.07855604f, 0.17517744f, 0.00215619f, -0.13545874f, 0.05694467f, 0.05480233f, -0.00263074f, 0.30604050f, 
    0.18305168f, 0.21050347f, 0.20597196f, -0.10685191f, -0.01896792f, -0.00465586f, 0.09149741f, 0.12689559f, 
    -0.00113225f, 0.15080459f, 0.44315767f, 0.02714717f, -0.16639066f, -0.06334468f, 0.05259109f, 0.05392480f, 
    0.24118450f, 0.14004190f, 0.20032422f, -0.39054325f, -0.02813791f, -0.16023599f, 0.09847546f, 0.01443987f, 
    -0.08634021f, 0.02355136f, -0.10180087f, -0.34307298f, -0.91810900f, 0.01588398f, 0.11348441f, 0.46856993f, 
    -0.11949125f, 0.04433083f, -0.15513782f, 0.08817635f, -0.04341380f, 0.28487346f, 0.02800974f, -0.03903150f, 
    0.00409709f, -0.17702587f, -0.02642366f, -0.03799487f, 0.09590628f, -0.15084946f, -0.00347610f, -0.12777914f, 
    0.03430410f, 0.05506746f, 0.03610353f, -0.08910683f, -0.04366961f, -0.11154638f, 0.15390673f, -0.11374074f, 
    -0.07312988f, -0.22104481f, 0.00900172f, -0.02040470f, -0.07422810f, -0.04816960f, 0.02200619f, -0.11620830f, 
    0.16875900f, -0.05854826f, -0.07149425f, -0.05493059f, 0.06367248f, -0.19718744f, 0.04783259f, -0.23104087f, 
    -0.08035585f, 0.22627816f, -0.06635637f, 0.00759081f, 0.00016293f, 0.09416148f, 0.02086654f, 0.07722010f, 
    0.16205338f, 0.02211323f, -0.10020142f, -0.03235468f, -0.08124954f, -0.02521513f, -0.02334812f, 0.09053620f, 
    0.05515099f, 0.07467171f, 0.00635930f, 0.03838315f, -0.08560901f, -0.15066165f, -0.14827311f, 0.06484519f, 
    -0.14182130f, 0.02375072f, -0.26457492f, -0.56157237f, -0.08092264f, -0.19014296f, 0.16719304f, 0.11156304f, 
    0.16981329f, -0.00997325f, -0.12028292f, -0.22289208f, -0.12695925f, -0.13958661f, 0.07272252f, 0.08756501f, 
    0.17400640f, -0.09189259f, 0.00033735f, 0.00500508f, 0.42973289f, 0.00857108f, 0.13844556f, -0.07220695f, 
    -0.15504298f, -0.00937938f, -0.06645551f, 0.07454696f, 0.05134782f, 0.01255740f, -0.00931868f, -0.00000682f, 
    -0.03621087f, 0.03662574f, 0.05796344f, 0.05575680f, -0.14493792f, 0.04641639f, 0.30108055f, 0.10576000f, 
    -0.01004167f, -0.13153073f, 0.00673876f, -0.13462095f, 0.08115900f, 0.08993234f, -0.03260158f, 0.52258003f, 
    0.54460329f, 0.37880176f, -0.06851582f, 0.05033131f, -0.20317163f, -0.02301669f, -0.00526816f, 0.16130479f, 
    0.30200616f, 0.28715044f, -0.00530757f, -0.14248461f, 0.10336843f, 0.05904283f, 0.11040008f, 0.08355923f, 
    -0.00683409f, 0.08686303f, 0.25008270f, -0.02933211f, -0.14676408f, 0.05890920f, -0.10548597f, 0.04351366f, 
    0.02609987f, 0.09011181f, -0.15220277f, -0.04178974f, -0.00600488f, 0.05101441f, 0.08054473f, -0.06932004f, 
    -0.05282245f, 0.01631668f, 0.09040529f, 0.03656885f, 0.02762670f, 0.18779334f, -0.00754083f, 0.13077420f, 
    -0.07874206f, 0.09803907f, 0.25984427f, 0.00065597f, -0.15009247f, -0.21434632f, -0.18624216f, -0.01533993f, 
    0.15197986f, -0.05061278f, 0.18779334f, 0.07580770f, 0.06806362f, -0.35744789f, -0.10377395f, 0.20790477f, 
    -0.04175016f, 0.11678763f, -0.26847601f, -0.03251870f, -0.06166726f, -0.16713995f, -0.04466330f, -0.02400532f, 
    -0.01494453f, 0.03433627f, 0.09692521f, -0.31855166f, 0.08190670f, -0.03139245f, -0.17713462f, 0.06819945f, 
    -0.06710340f, 0.06546448f, -0.07521179f, 0.06367052f, 0.02470924f, 0.16594082f, 0.00211447f, -0.03171583f, 
    0.15186822f, -0.11173256f, 0.14556795f, -0.05850432f, 0.06871179f, 0.00273007f, 0.05066849f, -0.00574303f, 
    -0.08739802f, 0.24186687f, -0.03735173f, -0.25507152f, -0.03971114f, 0.06908695f, -0.00326396f, -0.01116410f, 
    0.00348913f, -0.17498560f, 0.36457464f, -0.69934517f, -0.55976093f, -0.14973255f, -0.18975838f, 0.01367674f, 
    -0.04785338f, 0.05676849f, 0.03922991f, -0.22662842f, -0.22130190f, 0.00447849f, -0.07995062f, -0.05200007f, 
    0.05434348f, 0.10276979f, 0.13261020f, -0.13457537f, -0.05075442f, -0.11947326f, -0.04355700f, 0.06152583f, 
    0.23132123f, 0.09809250f, 0.14225738f, 0.10735930f, 0.19860421f, -0.13195893f, 0.24176565f, 0.37227163f, 
    -0.35017303f, -0.24704915f, 0.13076685f, -0.04894925f, 0.05539868f, 0.22804385f, 0.04217923f, -0.40574855f, 
    -0.28379455f, 0.03599552f, 0.17458209f, 0.17651850f, 0.20767291f, -0.13090263f, 0.11954107f, 0.39308774f, 
    -0.07676382f, 0.30812109f, -0.09281261f, -0.15457976f, -0.11978886f, 0.03323679f, 0.06548312f, 0.14412870f, 
    -0.10708293f, 0.06270315f, 0.36567560f, 0.14088742f, 0.06817179f, 0.05831075f, -0.09040916f, -0.07311707f, 
    -0.07093240f, -0.16055097f, 0.12021857f, 0.03549997f, 0.00768151f, 0.00695446f, -0.00366770f, -0.26210320f, 
    0.11444235f, 0.36220130f, -0.23448008f, 0.11833127f, -0.09135798f, 0.09906399f, 0.19690023f, 0.08614774f, 
    0.15501599f, 0.44826117f, 0.05786039f, -0.06011078f, 0.02068680f, 0.00881760f, -0.33046216f, -0.17066346f, 
    0.03708619f, -0.01517479f, 0.13159680f, -0.18530230f, -0.13724478f, -0.16145928f, 0.35437477f, 0.04031058f, 
    0.06358317f, 0.08488235f, 0.06309266f, 0.06244894f, 0.02239165f, 0.29768997f, -0.10929710f, -0.00149962f, 
    -0.02494522f, -0.05977913f, -0.13286531f, 0.00493520f, -0.08276515f, 0.31938422f, 0.07796531f, 0.08241352f, 
    0.05024979f, 0.01858716f, 0.03446477f, 0.07779901f, 0.22312059f, 0.24571383f, -0.03257445f, 0.16710347f, 
    0.07728067f, -0.03155232f, 0.00142125f, 0.04608015f, -0.01730486f, 0.02915183f, 0.06646430f, -0.16427650f, 
    -0.15872057f, -0.12869695f, 0.29722747f, 0.01433947f, -0.07109821f, -0.00174058f, -0.02442296f, 0.07538937f, 
    -0.04105817f, -0.01099479f, 0.07398053f, 0.12162597f, -0.17787190f, 0.01503874f, 0.08412345f, 0.11108176f, 
    0.00848322f, -0.04281781f, 0.23170036f, -0.10900716f, -0.29492509f, -0.09055638f, 0.03750953f, -0.03932210f, 
    0.05218630f, 0.31334487f, 0.16914181f, 0.09221033f, 0.03416960f, 0.04640376f, -0.03224202f, -0.01245321f, 
    0.19164029f, 0.07167447f, 0.04982812f, -0.08808684f, -0.08566421f, 0.10799007f, -0.04914495f, -0.00947932f, 
    -0.18506603f, 0.08790259f, -0.00831800f, 0.05737510f, -0.04621066f, 0.02111077f, -0.00556869f, 0.11548084f, 
    -0.23450243f, -0.16453598f, 0.02724685f, 0.11553746f, -0.06710376f, 0.02782506f, 0.00957637f, 0.01567107f, 
    -0.01394892f, -0.03601117f, -0.13658747f, -0.11400212f, -0.03396294f, -0.04672382f, 0.01705529f, -0.08366292f, 
    -0.42054370f, 0.21159351f, 0.05554732f, -0.01754763f, 0.02081883f, 0.04127746f, -0.09714679f, -0.28007191f, 
    0.05394050f, -0.22039509f, -0.01937338f, 0.04956202f, -0.08685300f, -0.15307562f, 0.01213752f, -0.05602995f, 
    -0.37111172f, -0.05761920f, -0.40999159f, 0.16712393f, 0.09273516f, 0.03739042f, -0.11392735f, 0.02566544f, 
    -0.04769015f, -0.12203511f, 0.04437099f, 0.01706784f, 0.19021757f, 0.04930551f, 0.05499861f, 0.13697842f, 
    0.02660795f, 0.06819940f, -0.06407756f, 0.17055047f, 0.09442853f, -0.03321147f, -0.24514246f, -0.08262666f, 
    0.02352198f, -0.08122842f, 0.13991405f, 0.02534154f, 0.11716247f, -0.05119205f, 0.12369940f, 0.08876754f, 
    0.11648810f, 0.03592116f, 0.04697834f, -0.12343471f, 0.10146902f, 0.10468002f, 0.02018527f, 0.15125485f, 
    -0.38989189f, -0.09122878f, 0.00657040f, 0.17727308f, 0.14892372f, -0.08202406f, -0.13651226f, -0.06567425f, 
    0.22324893f, 0.09600728f, -0.01532181f, -0.13798465f, 0.03666524f, -0.09847657f, 0.00559353f, 0.04480073f, 
    -0.02080099f, 0.11551187f, -0.20921205f, 0.08777001f, 0.04088460f, 0.30601558f, 0.38242927f, 0.14522038f, 
    -0.05994504f, 0.00149156f, 0.19664025f, -0.15904196f, -0.07020494f, -0.01636112f, 0.05154437f, 0.15642735f, 
    -0.02538805f, -0.12717104f, -0.00637981f, 0.18463723f, -0.01658078f, 0.01033007f, -0.04893737f, 0.05345339f, 
    0.00481620f, -0.03935466f, 0.07980853f, 0.19227006f, 0.35419783f, -0.08001123f, 0.09266273f, 0.11599285f, 
    -0.07123372f, -0.20299289f, 0.04207441f, 0.08824178f, -0.14458583f, -0.05079837f, 0.05571479f, 0.06813180f, 
    -0.12121435f, -0.06621851f, -0.16487056f, 0.04872650f, 0.07278369f, -0.15195231f, 0.01921879f, 0.16871427f, 
    0.15129714f, 0.02207058f, -0.06844810f, 0.07954715f, -0.05313879f, 0.10988143f, 0.41988909f, 0.14234975f, 
    -0.01740391f, 0.08411451f, 0.22073482f, 0.06691020f, 0.01796640f, -0.54424506f, -0.11309300f, -0.00571035f, 
    0.62132025f, -0.10523261f, 0.31280354f, 0.04438835f, 0.23963287f, -0.05797199f, 0.05075720f, -0.04256603f, 
    0.04528483f, 0.01980581f, 0.04475874f, -0.01766143f, 0.08014473f, 0.03106773f, 0.14489180f, -0.03787937f, 
    0.03200098f, -0.01266966f, 0.00685186f, -0.04908891f, 0.04486486f, -0.00142187f, 0.01751082f, -0.00993784f, 
    -0.03091357f, -0.05703291f, -0.03371279f, -0.00088824f, 0.01955576f, 0.00230454f, -0.00468356f, 0.04231839f, 
    -0.00822659f, 0.00466731f, -0.04362653f, 0.02844705f, -0.04614545f, -0.04368964f, -0.02660388f, 0.01216778f, 
    -0.06782624f, -0.04736070f, -0.01326500f, -0.00755278f, 0.01750730f, 0.04706337f, -0.02579147f, 0.03284985f, 
    -0.04956191f, -0.04511666f, -0.04329697f, 0.00752986f, -0.00086285f, -0.03605677f, -0.03964883f, 0.03506003f, 
    -0.00643897f, -0.03726184f, 0.00773666f, -0.00194667f, 0.01401485f, 0.04254079f, -0.07312762f, 0.02501681f, 
    -0.03385090f, -0.05804456f, 0.02468690f, -0.04301888f, -0.04530384f, 0.05120653f, -0.02609818f, -0.02138397f, 
    0.03527325f, 0.06125565f, 0.05698365f, -0.01025052f, -0.03665683f, -0.00810779f, -0.02642138f, -0.04628798f, 
    -0.00438869f, -0.00096302f, 0.04696125f, 0.04547591f, -0.01677446f, 0.01429710f, -0.05761119f, 0.00349410f, 
    0.03463823f, 0.03211848f, 0.01324346f, 0.02195334f, 0.03511042f, -0.06511500f, 0.00619589f, -0.05374523f, 
    -0.00712808f, -0.03824838f, 0.04667625f, 0.02899034f, -0.02917645f, -0.05864399f, -0.02867840f, -0.00415472f, 
    -0.02793612f, -0.03257025f, 0.00991278f, -0.00414239f, -0.06825076f, 0.04743047f, 0.02133735f, 0.02918589f, 
    0.04641024f, -0.05468526f, -0.02513658f, -0.03216602f, -0.05061888f, -0.00127667f, 0.04759860f, 0.02902555f, 
    -0.04208873f, -0.04840755f, -0.05834841f, -0.03218821f, -0.04046853f, -0.04885890f, 0.03082412f, 0.03320674f, 
    0.02085765f, -0.02195156f, 0.01843069f, 0.03965539f, -0.00159305f, 0.04281257f, 0.00844901f, 0.03457304f, 
    -0.02661630f, -0.03926222f, 0.05300569f, 0.01629834f, -0.03948855f, 0.01066930f, -0.01941220f, -0.03611079f, 
    -0.00046770f, -0.01036150f, 0.05184123f, -0.02468585f, 0.00462154f, 0.03918419f, -0.04876295f, 0.00657458f, 
    0.00390897f, 0.00042086f, -0.05297656f, -0.03515951f, 0.04193149f, 0.03248525f, -0.06214222f, 0.00737873f, 
    -0.03150103f, 0.01032093f, -0.03877124f, -0.01422001f, 0.03541104f, -0.02628412f, 0.00188512f, 0.02568301f, 
    -0.00111912f, 0.01880726f, -0.05033204f, 0.04326675f, -0.04347570f, -0.03813066f, 0.03327733f, 0.02261801f, 
    -0.02073187f, -0.03032240f, -0.04276201f, 0.02623361f, 0.05271148f, 0.02274730f, 0.04137520f, 0.02402477f, 
    0.04793456f, 0.04053945f, 0.02984590f, 0.04319922f, 0.00860753f, 0.05102496f, -0.04187175f, -0.06022727f, 
    0.02143099f, -0.03528244f, 0.01160004f, -0.01079047f, 0.01361717f, -0.00064674f, -0.02835416f, -0.00253806f, 
    -0.06417473f, -0.00767144f, -0.00639284f, -0.00780321f, -0.00990356f, 0.01024017f, 0.00991003f, 0.01388867f, 
    -0.02754865f, -0.05666019f, -0.04059164f, 0.05116542f, 0.00260381f, -0.01399546f, -0.04920088f, 0.01974773f, 
    0.03652691f, -0.01582932f, -0.00685159f, -0.02815034f, -0.05079144f, -0.05075201f, -0.00154654f, 0.01896420f, 
    0.02079658f, 0.02957181f, -0.00188488f, -0.05944354f, 0.01742881f, 0.04402801f, 0.04859154f, -0.00244622f, 
    0.06007958f, 0.00025977f, -0.02837895f, -0.02497757f, -0.05601892f, 0.01749779f, -0.01076939f, -0.03479850f, 
    0.02950686f, -0.03051129f, 0.01174403f, -0.00751306f, 0.03719277f, -0.05333215f, -0.04486081f, 0.04414196f, 
    0.01717491f, 0.03916815f, 0.04335207f, 0.02765129f, 0.02373280f, -0.00744927f, -0.05984341f, 0.03039916f, 
    -0.02952541f, -0.02276877f, -0.06501446f, -0.01931882f, -0.07020541f, -0.05234222f, 0.00419474f, 0.03740636f, 
    -0.04391915f, -0.02384759f, -0.04770585f, -0.03209839f, -0.02076229f, -0.02018364f, 0.01032977f, 0.01603161f, 
    0.02625774f, -0.02218423f, 0.03447198f, -0.05243463f, 0.02540371f, -0.06094930f, -0.03561129f, 0.05411270f, 
    -0.03792137f, -0.01438976f, -0.03441594f, -0.03568175f, -0.01023472f, -0.05042490f, -0.03211665f, 0.01805429f, 
    -0.01129971f, -0.01501674f, -0.02692669f, -0.04084067f, 0.03728448f, 0.05067913f, -0.02438636f, -0.05761041f, 
    0.01693449f, -0.01462233f, -0.03707697f, -0.05958317f, -0.04309275f, -0.03951475f, 0.04355682f, 0.04332760f, 
    0.04562463f, 0.03098585f, 0.00479030f, 0.03898700f, -0.00055197f, -0.04790143f, 0.03472774f, -0.05423545f, 
    0.01183238f, -0.06026836f, 0.05108004f, 0.02025782f, -0.04768720f, 0.02357344f, -0.00685071f, 0.00083020f, 
    0.05399940f, 0.01167354f, 0.00898191f, -0.01406753f, 0.03118392f, 0.00818149f, 0.02018766f, -0.05287901f, 
    -0.04278535f, 0.01525620f, 0.03792202f, -0.00377644f, -0.05225781f, 0.01899459f, -0.02664611f, -0.02003427f, 
    0.01230784f, 0.04315738f, -0.00977776f, -0.05136907f, -0.03106286f, 0.03372047f, -0.07082243f, -0.00214723f, 
    0.02035136f, 0.02342422f, -0.06694376f, 0.03591261f, 0.03651787f, -0.00428376f, -0.00466756f, 0.01116875f, 
    -0.03103429f, 0.04946450f, -0.00255109f, -0.03698120f, -0.05702385f, 0.00906410f, 0.00894064f, 0.04075817f, 
    -0.00560962f, 0.00801225f, 0.05366113f, 0.01737393f, -0.04481425f, -0.02263383f, -0.05928171f, 0.01410365f, 
    -0.02630472f, -0.06308813f, -0.04446581f, 0.01416014f, -0.03519082f, -0.05705746f, 0.01244201f, -0.03394896f, 
    -0.02387966f, -0.07176382f, 0.02947089f, -0.06244323f, -0.00488955f, -0.05719221f, -0.03170632f, 0.03158961f, 
    -0.01972588f, -0.05512521f, 0.01257710f, 0.01839465f, -0.03371538f, -0.00436363f, -0.02088976f, 0.03194314f, 
    -0.00324292f, -0.04243031f, 0.01326563f, 0.03536658f, -0.04713022f, 0.00881287f, -0.03518877f, 0.01748336f, 
    0.03361428f, 0.00621379f, -0.05111073f, -0.01574048f, -0.03842166f, 0.00160440f, -0.00757347f, -0.04344417f, 
    -0.04810826f, 0.00327499f, 0.03629177f, 0.01157686f, -0.04183210f, 0.04005225f, -0.05969805f, 0.03716947f, 
    -0.04402226f, -0.05163890f, -0.00074358f, -0.03618945f, -0.00027088f, -0.00277653f, -0.06176516f, 0.03497271f, 
    -0.03596332f, 0.04024855f, 0.06253894f, -0.03400550f, 0.04434621f, -0.04895876f, 0.00709732f, -0.03746843f, 
    -0.03244168f, 0.03946190f, 0.03672697f, -0.00524153f, 0.01625605f, -0.03042937f, 0.00782527f, -0.02176588f, 
    -0.02558716f, 0.01962458f, -0.03955039f, 0.03844882f, 0.00011567f, -0.04686086f, 0.04500649f, 0.02684903f, 
    0.02263650f, -0.01368886f, -0.05869566f, -0.03044154f, -0.01905898f, 0.01336414f, 0.01726385f, 0.04278305f, 
    -0.00571007f, -0.05737618f, -0.05270838f, -0.02078322f, 0.00043761f, -0.04646700f, 0.02784060f, 0.00107559f, 
    0.01517178f, 0.05469167f, -0.01785755f, 0.04016721f, -0.06057512f, -0.03889012f, 0.05134359f, -0.02676398f, 
    0.04736656f, 0.00405001f, -0.01899679f, 0.02910985f, 0.01489435f, 0.04449270f, -0.01518148f, -0.05222031f, 
    -0.00402422f, -0.02170984f, 0.00246842f, -0.07255489f, -0.00854229f, 0.00848240f, -0.07006344f, 0.00069729f, 
    0.05864232f, -0.05347929f, -0.02196844f, 0.00289648f, -0.02323031f, -0.01408897f, 0.01367752f, 0.03059931f, 
    -0.00547486f, 0.01367802f, 0.05140059f, 0.01439073f, 0.02880351f, -0.00956850f, -0.05263636f, 0.02075133f, 
    -0.01542758f, -0.02964991f, -0.00824261f, -0.05350435f, -0.04999320f, -0.04964139f, -0.03900219f, 0.00667636f, 
    -0.01978203f, 0.01237505f, -0.05348452f, 0.00510212f, 0.01780069f, -0.02108328f, -0.04004056f, -0.05360616f, 
    -0.01279715f, -0.00105098f, 0.02671163f, -0.02953899f, -0.02696617f, -0.02440749f, 0.02798066f, -0.04141305f, 
    -0.02850408f, -0.03784868f, 0.00469586f, -0.05815045f, -0.00860573f, 0.03848042f, 0.02974188f, -0.01686337f, 
    0.00081016f, 0.05707254f, -0.05657961f, -0.06489877f, -0.00290601f, 0.04582531f, 0.03677294f, -0.03031711f, 
    -0.02930770f, 0.04261349f, -0.05994697f, 0.04736580f, -0.02484686f, 0.01255696f, 0.02176385f, 0.03526621f, 
    0.04536271f, -0.02915435f, 0.00153562f, 0.04731580f, -0.06176591f, -0.05302033f, -0.06357107f, -0.03998990f, 
    -0.03051695f, -0.04010486f, -0.00601949f, 0.05167522f, 0.00346402f, -0.01090490f, 0.04413071f, -0.01856473f, 
    -0.01951957f, 0.02785848f, -0.04076372f, -0.04940361f, -0.05595791f, 0.03989408f, -0.04477334f, -0.06488593f, 
    -0.00826034f, -0.02880406f, 0.02351170f, -0.04683187f, 0.01065587f, 0.05270372f, 0.02388589f, 0.01327846f, 
    -0.04288058f, 0.03795921f, -0.07066908f, -0.03806357f, -0.00764154f, 0.00684491f, -0.05811680f, -0.01251207f, 
    -0.08697031f, 0.00524287f, 0.12640949f, 0.13386157f, -0.06572967f, 0.01242780f, 0.08231333f, 0.09230994f, 
    0.02815614f, 0.56559324f, -0.08015274f, -0.15253060f, -0.05381484f, 0.06412864f, 0.22254886f, -0.04500040f, 
    0.08763063f, -0.22988106f, 0.84455913f, -0.07759254f, -0.17242135f, -0.03071552f, 0.18580468f, -0.05402700f, 
    -0.00752724f, -0.03471859f, -0.15528712f, 0.10292661f, -0.06568567f, -0.19333345f, 0.11534828f, -0.13985451f, 
    0.08253343f, 0.15861961f, 0.08882684f, 0.05357454f, -0.33777344f, 0.27637169f, -0.17311667f, -0.09986107f, 
    -0.12050168f, 0.11390501f, 0.05933654f, 0.03913303f, -0.01105138f, -0.21295409f, 0.04009071f, 0.32809308f, 
    -0.02941619f, 0.04175882f, 0.07737507f, 0.13974997f, 0.04799701f, -0.07800731f, 0.12537810f, -0.07192392f, 
    -0.08574963f, 0.21434924f, 0.06546065f, -0.20409440f, -0.29096830f, -0.24238078f, -0.13113207f, 0.09551623f, 
    -0.15982300f, -0.01979315f, 0.15508299f, -0.12371089f, 0.07936288f, -0.18321571f, -0.17601109f, -0.22420703f, 
    0.24099322f, 0.06484096f, 0.07819634f, 0.01302652f, 0.04159191f, -0.00714449f, 0.01043371f, 0.02300179f, 
    0.00538318f, 0.10823635f, 0.05234927f, -0.00540859f, 0.16645528f, 0.02678647f, -0.06753015f, -0.18146408f, 
    -0.06039604f, 0.01248830f, -0.44743913f, -0.12787819f, -0.11900134f, -0.25698236f, 0.04442430f, 0.05333766f, 
    -0.34329307f, -0.28180060f, -0.25469637f, -0.17914015f, -0.05556767f, -0.07497760f, 0.20310435f, -0.12329994f, 
    0.00346189f, 0.18669647f, 0.10136995f, 0.06244257f, 0.18662690f, 0.04122506f, -0.13448472f, 0.07607991f, 
    -0.01778509f, 0.12046560f, -0.00141426f, 0.04164136f, 0.17575787f, 0.02663115f, -0.03234343f, -0.04467687f, 
    0.23655841f, 0.11130597f, -0.08650133f, -0.07608592f, 0.12936634f, 0.13154441f, 0.14427157f, 0.05960048f, 
    -0.04456661f, 0.02604656f, 0.12225845f, -0.04296881f, -0.06454972f, 0.04876406f, 0.00371876f, 0.05846576f, 
    -0.09644805f, 0.08434703f, 0.03344196f, -0.09643107f, 0.09921763f, 0.05381775f, -0.01178129f, 0.14876457f, 
    -0.38170606f, -0.00640458f, 0.04962717f, -0.05024081f, -0.02086761f, 0.00141633f, -0.10168666f, 0.01972346f, 
    -0.02482131f, 0.16761732f, 0.04900756f, 0.06501413f, 0.06570485f, 0.03435775f, 0.22423951f, -0.04488858f, 
    0.06842763f, 0.13692841f, -0.05716612f, 0.01201616f, -0.09308987f, 0.07433690f, 0.04474418f, -0.13779928f, 
    0.15627535f, 0.06138609f, 0.07565127f, -0.01425000f, -0.23102464f, -0.10066848f, 0.20199051f, -0.02603456f, 
    0.02250205f, 0.06632400f, -0.17844853f, -0.15618363f, -0.00130263f, -0.12154204f, -0.13072447f, 0.04737994f, 
    0.02320294f, 0.01204136f, 0.04070192f, 0.18953308f, 0.06119207f, -0.02498664f, 0.04041964f, -0.23466510f, 
    0.33362907f, 0.02554427f, 0.19179170f, -0.01917282f, -0.07281606f, -0.06711288f, 0.00525828f, -0.04394092f, 
    -0.20891486f, 0.16466603f, 0.13133861f, -0.03275281f, -0.04579727f, 0.01571465f, 0.08011135f, 0.13685289f, 
    -0.00451297f, 0.00787717f, 0.17678337f, -0.04320749f, 0.05075615f, -0.21951503f, -0.28131348f, -0.41817608f, 
    0.20012093f, 0.09936685f, -0.17184964f, -0.11068948f, 0.23215236f, 0.07831372f, -0.04683185f, -0.32362702f, 
    0.20434298f, -0.02103974f, 0.07611480f, -0.26774141f, -0.00395548f, 0.03808516f, -0.15269952f, -0.18249604f, 
    0.03928894f, -0.10869870f, 0.58425361f, 0.37467435f, -0.00400357f, -0.18373084f, 0.17989488f, 0.13689627f, 
    0.02054090f, 0.06290205f, 0.21888039f, -0.57374614f, 0.30461687f, 0.12679484f, 0.31066394f, -0.10935397f, 
    -0.01706735f, 0.02903470f, -0.02803587f, 0.03742582f, -0.17779683f, 0.18852173f, 0.13931914f, -0.11627082f, 
    -0.18625791f, -0.07911920f, 0.18097495f, 0.12568764f, 0.20271881f, -0.12338253f, -0.49279678f, -0.17531550f, 
    -0.12268884f, 0.07994295f, -0.06718509f, 0.04609872f, 0.04153175f, -0.05373706f, 0.01257853f, -0.23695035f, 
    -0.22115767f, 0.12775706f, -0.14782377f, 0.03439956f, 0.00919602f, 0.11471551f, 0.04140551f, 0.06792066f, 
    -0.03690910f, -0.10296091f, 0.17738025f, -0.00122573f, 0.03631753f, -0.16395988f, -0.23078912f, -0.20815739f, 
    -0.27660963f, 0.07017368f, -0.05787203f, 0.01456089f, -0.11759568f, -0.06285917f, 0.03714621f, -0.19147789f, 
    0.06392622f, 0.10434151f, 0.19781169f, 0.48310402f, 0.07103033f, 0.06334966f, 0.02836156f, 0.12151133f, 
    0.19819622f, 0.04361835f, 0.41239050f, 0.07917528f, 0.41782495f, 0.34284902f, 0.09131520f, 0.06206392f, 
    0.10090615f, -0.05010073f, 0.01248961f, 0.12932636f, 0.31880659f, 0.14130016f, 0.10007711f, 0.21930788f, 
    0.10037480f, 0.23048994f, 0.00370811f, -0.16281298f, 0.08729491f, -0.36711684f, -0.06791514f, -0.02355176f, 
    -0.07048690f, 0.25312242f, 0.02980659f, 0.09005173f, 0.10629951f, 0.16047531f, 0.04724581f, 0.08461973f, 
    0.01820074f, -0.14634082f, 0.26549155f, 0.07410555f, 0.04891248f, 0.26142377f, 0.12284164f, 0.20148991f, 
    -0.04471551f, 0.00139341f, 0.06315311f, 0.02864276f, 0.14230673f, 0.10283160f, -0.26372570f, 0.19947816f, 
    0.36651307f, -0.22035842f, 0.06757649f, 0.12358437f, 0.07870890f, -0.03976192f, -0.12259023f, -0.22940646f, 
    -0.06677485f, -0.05818534f, 0.32822746f, 0.22505111f, -0.07999850f, 0.23230053f, 0.09535370f, 0.01990287f, 
    0.19719709f, -0.06778220f, -0.06360130f, -0.20073053f, 0.03431737f, 0.07066968f, 0.03220367f, 0.04438437f, 
    -0.14850399f, -0.28679082f, -0.22923361f, -0.12578875f, -0.23537052f, 0.19633642f, -0.05212110f, 0.09169377f, 
    0.09953894f, 0.06291144f, 0.01906881f, -0.06260882f, -0.05628834f, -0.14730310f, 0.02909086f, 0.08603449f, 
    0.00376983f, -0.05647224f, -0.33078232f, -0.13600998f, 0.28632596f, 0.54532415f, 0.16667889f, -0.04249590f, 
    -0.06868318f, -0.01774763f, 0.02070171f, -0.07660993f, 0.04911602f, -0.05921464f, -0.17871222f, -0.24487761f, 
    -0.02447675f, 0.04280372f, 0.06965371f, -0.07165741f, -0.04299739f, -0.37078762f, 0.11063403f, 0.02964284f, 
    -0.04396217f, -0.03278841f, 0.04037627f, 0.04177693f, 0.07284132f, 0.11347614f, -0.28084528f, -0.02395437f, 
    -0.25806984f, -0.02199441f, 0.16033958f, 0.34631410f, -0.05299618f, -0.04078731f, 0.09845378f, 0.13113372f, 
    0.05039341f, 0.13441029f, 0.24645005f, -0.00747482f, 0.07444564f, 0.34534791f, 0.01807425f, -0.00670812f, 
    0.21355711f, -0.04043270f, -0.15129599f, -0.01981453f, 0.13843286f, -0.03257594f, 0.07255969f, 0.00202919f, 
    0.04704514f, 0.13029359f, -0.16838893f, -0.19174378f, -0.10302189f, -0.02887741f, -0.05694742f, -0.06203569f, 
    -0.25995451f, -0.12430817f, -0.28756848f, 0.29631019f, 0.18782704f, -0.01651459f, -0.11153428f, -0.08620360f, 
    -0.09071301f, 0.00204585f, 0.04315258f, -0.04862867f, -0.01380191f, -0.26443604f, -0.01123543f, 0.00918784f, 
    0.04115362f, 0.05167548f, -0.14686170f, -0.21343426f, -0.08343832f, -0.41334519f, -0.44194362f, -0.25863016f, 
    0.10535489f, 0.03600345f, -0.02206597f, -0.25546071f, -0.24131861f, -0.64569688f, 0.14201085f, -0.39809597f, 
    0.08615945f, -0.08580542f, 0.01365652f, 0.23174271f, -0.12685435f, 0.05808118f, 0.07623730f, 0.04043920f, 
    -0.20959905f, -0.08475524f, 0.03359672f, -0.07897722f, 0.04131515f, -0.13232355f, 0.03514089f, -0.35201618f, 
    -0.12512688f, -0.01572467f, -0.01215496f, 0.05760767f, -0.04388168f, -0.12217069f, 0.11056189f, -0.10076740f, 
    -0.20997135f, -0.00846027f, -0.12962268f, 0.07695242f, -0.15645215f, -0.16880260f, 0.14793412f, 0.06850338f, 
    -0.03003982f, 0.19076322f, -0.15202793f, 0.47326919f, 0.24120209f, 0.06710252f, 0.04077707f, 0.02357915f, 
    0.12985648f, 0.02208026f, 0.08990949f, 0.52856171f, -0.14255241f, -0.08033208f, 0.17259288f, -0.00186849f, 
    -0.00718766f, -0.15250723f, 0.03060738f, 0.15310501f, -0.07715658f, -0.00192809f, -0.12282504f, 0.06469282f, 
    0.01525955f, 0.01162031f, -0.13079454f, -0.05460922f, -0.03578534f, 0.58321130f, 0.46643946f, -0.36772129f, 
    -0.01384680f, 0.00741874f, 0.06185294f, 0.01080380f, -0.25679001f, -0.10396355f, -0.13428645f, -0.07313938f, 
    0.16778681f, -0.10478218f, 0.11285338f, -0.02075198f, -0.19630735f, -0.33958650f, 0.17608598f, 0.26521450f, 
    0.34072933f, -0.05469472f, -0.04056828f, -0.09925602f, 0.04068997f, 0.06548728f, -0.09918018f, -0.04702104f, 
    0.02930245f, -0.01310951f, -0.05005000f, -0.05158908f, -0.05232573f, 0.00263474f, 0.00751464f, 0.03635932f, 
    -0.01935055f, 0.04817103f, -0.03154676f, -0.01369765f, -0.05695886f, -0.02443753f, -0.01683572f, -0.05082468f, 
    -0.03081215f, -0.01649347f, 0.00888408f, 0.04756415f, -0.04702334f, -0.00507253f, -0.05207817f, 0.01976477f, 
    0.04696447f, 0.00456848f, 0.00636492f, -0.05165550f, -0.03483810f, -0.01574570f, -0.01564586f, -0.03226793f, 
    -0.04905174f, -0.02285487f, -0.05757648f, 0.03888640f, -0.00494243f, -0.02461576f, 0.03129643f, 0.04208801f, 
    -0.01081582f, -0.01358867f, -0.03885733f, -0.04856863f, 0.02517052f, -0.02318438f, 0.01837057f, -0.03983826f, 
    0.01416544f, -0.03813554f, -0.02121155f, 0.02361535f, -0.00313674f, -0.05554720f, -0.03144445f, -0.06853314f, 
    0.03108356f, 0.02469998f, -0.06061386f, -0.01749625f, -0.03653968f, -0.04832247f, -0.01676889f, -0.01870115f, 
    -0.01445561f, -0.00423443f, 0.02930131f, -0.02749805f, 0.04077046f, 0.05064655f, -0.00475181f, -0.06187231f, 
    -0.04366186f, -0.00640070f, 0.04606899f, 0.02836346f, -0.03123285f, -0.04109182f, -0.04485819f, -0.04611548f, 
    -0.00883165f, -0.06111113f, -0.00774176f, 0.00137812f, 0.03170469f, 0.04487821f, 0.02266872f, -0.00351454f, 
    -0.01339277f, 0.03588904f, 0.03153179f, -0.00442325f, 0.02461288f, 0.02720557f, -0.05991789f, -0.02921754f, 
    0.01555521f, 0.05971333f, 0.00005252f, -0.00990567f, -0.01619844f, 0.03314402f, 0.03700006f, 0.04460602f, 
    -0.02066498f, -0.06409482f, -0.00376546f, -0.05026338f, -0.03666152f, -0.03174032f, -0.01572407f, -0.00783843f, 
    0.01546703f, 0.04015741f, -0.04916898f, 0.00369727f, -0.00158380f, 0.00572079f, 0.04013441f, 0.02915278f, 
    -0.02866372f, 0.01786120f, 0.03269060f, -0.01754471f, 0.02278725f, 0.02497550f, 0.02290411f, 0.00078444f, 
    0.03426303f, -0.03952191f, 0.02937702f, -0.03233970f, 0.02317964f, 0.02501825f, 0.00201626f, 0.00848248f, 
    -0.03436995f, 0.00346053f, -0.00053518f, -0.05911645f, -0.03541488f, -0.01276299f, 0.01170921f, 0.02462186f, 
    0.04330231f, -0.01154318f, 0.05097869f, -0.03183213f, 0.01354621f, -0.04815052f, -0.05549810f, 0.02734353f, 
    0.00712527f, -0.00354651f, 0.01962739f, -0.00616562f, 0.00832894f, 0.03266311f, 0.04811200f, 0.02329355f, 
    0.02631028f, 0.01377805f, -0.05652884f, -0.04578921f, 0.01900814f, -0.01087323f, 0.01417249f, -0.04853778f, 
    -0.01043632f, 0.03196853f, -0.01929588f, 0.00482487f, -0.01869788f, 0.01604365f, -0.01711511f, 0.02173228f, 
    -0.04426979f, -0.04731602f, 0.01574245f, -0.04720470f, -0.03427274f, 0.03399577f, 0.05254211f, -0.00432353f, 
    0.02758049f, 0.00761651f, 0.05363509f, 0.01243537f, -0.04529578f, 0.01111247f, -0.00210283f, 0.04622691f, 
    0.01294540f, -0.02288847f, 0.01977845f, -0.02838525f, 0.00268065f, -0.02403379f, -0.01770551f, 0.04048845f, 
    -0.00047238f, -0.00042426f, -0.05565559f, -0.05988719f, -0.03190544f, -0.01626245f, -0.03314118f, -0.02325903f, 
    0.00761554f, -0.04524926f, -0.05645017f, -0.04235767f, 0.04840875f, -0.04703247f, 0.01345755f, 0.01978607f, 
    -0.00636217f, 0.03123272f, -0.00313514f, -0.02132078f, 0.02593318f, -0.02298510f, 0.04451945f, 0.03709326f, 
    -0.01892926f, 0.03897040f, -0.00050844f, 0.01546162f, 0.04490471f, 0.05082443f, -0.02020941f, -0.03555727f, 
    0.02092814f, -0.00566024f, -0.04444435f, -0.05472762f, 0.03478157f, -0.02405313f, 0.00386199f, 0.04396586f, 
    0.05550602f, 0.04681435f, -0.05535155f, 0.01203380f, 0.01844751f, 0.01866784f, -0.04079676f, 0.02754596f, 
    0.01146282f, 0.03619381f, -0.05181357f, 0.02663836f, -0.02441260f, -0.06156654f, 0.00791568f, 0.04010677f, 
    0.01135513f, -0.05569497f, -0.02736623f, 0.01944002f, 0.00867726f, 0.05046197f, 0.03608707f, -0.01376817f, 
    0.01687499f, 0.00995258f, 0.05204163f, -0.04989167f, -0.03072829f, -0.04654713f, -0.04758250f, -0.02958670f, 
    -0.01695816f, -0.03789797f, -0.04620385f, -0.03741885f, -0.01989285f, -0.03194695f, -0.02716137f, -0.01955350f, 
    -0.06015861f, -0.01809354f, 0.04875205f, -0.05123327f, 0.00820788f, -0.00692070f, -0.00429965f, 0.00670772f, 
    -0.16569109f, -0.06087755f, -0.08894823f, 0.30000812f, 0.28792909f, 0.03432486f, -0.18481202f, -0.30660728f, 
    -0.26210359f, -0.21432775f, 0.27234739f, 0.47863543f, -0.12016284f, 0.01358302f, 0.21254416f, 0.00564518f, 
    0.07992392f, 0.03933860f, 0.12996481f, 0.32658985f, -0.27833256f, -0.13383298f, 0.01376431f, -0.21115001f, 
    -0.04171621f, 0.09208801f, 0.24419907f, -0.37951207f, 0.31796309f, 0.03064747f, -0.02516636f, -0.01516800f, 
    -0.17538600f, 0.13031156f, -0.22639365f, -0.08847359f, 0.09687369f, -0.19135977f, 0.20133008f, 0.08908517f, 
    -0.03637864f, 0.14596841f, 0.23130032f, 0.27629659f, 0.20833723f, 0.32060161f, -0.09267388f, 0.04110844f, 
    -0.03904147f, 0.12341648f, 0.08537947f, 0.02528156f, -0.02968739f, 0.09483539f, 0.09997221f, 0.05541021f, 
    -0.01660837f, 0.14198378f, 0.05117861f, 0.12639196f, 0.13465890f, 0.12145993f, -0.20039913f, 0.51681101f, 
    0.21206430f, -0.42193443f, 0.07602997f, 0.17828421f, 0.16150890f, 0.25190583f, -0.05988198f, -0.10820037f, 
    0.07938050f, 0.04746817f, 0.07285623f, 0.10388526f, 0.16957870f, 0.08672503f, -0.01980726f, 0.07543138f, 
    -0.01061195f, -0.14650601f, -0.10968765f, 0.19751033f, 0.22426735f, 0.12464308f, 0.13862738f, -0.28823185f, 
    -0.32646924f, 0.01716940f, 0.11296063f, -0.17733289f, -0.47882146f, 0.09166128f, 0.14236271f, -0.07497916f, 
    0.01592555f, 0.10666779f, 0.16101138f, 0.01085272f, 0.04435944f, 0.05478168f, 0.08100732f, 0.02473329f, 
    -0.00435330f, 0.07525642f, -0.35272026f, -0.21112841f, -0.06748086f, 0.25518814f, -0.13846476f, 0.07193328f, 
    0.01311644f, 0.01588256f, 0.20439635f, 0.02375962f, -0.01716916f, -0.17366806f, -0.07625555f, 0.06132216f, 
    0.11050835f, 0.00681798f, 0.08588449f, -0.41121191f, -0.50316811f, -0.16769594f, -0.04621128f, -0.01978032f, 
    -0.02330189f, 0.04084905f, 0.01959579f, 0.10698650f, 0.11799484f, -0.05648611f, 0.02421961f, 0.24757241f, 
    -0.10289440f, -0.25950959f, -0.26545936f, 0.10361771f, -0.01974940f, 0.04335854f, -0.00646965f, -0.19445209f, 
    0.03243136f, -0.04750162f, -0.25282785f, -0.14620565f, 0.21500820f, 0.13926364f, -0.08946829f, -0.10184094f, 
    0.04601916f, 0.09365997f, -0.15274425f, -0.28086853f, 0.26947448f, 0.23483279f, 0.12377241f, -0.02049858f, 
    0.12329165f, -0.15554589f, -0.03301382f, 0.06758008f, 0.03811012f, 0.00890646f, 0.07096593f, -0.06732403f, 
    -0.00872576f, -0.39078033f, -0.07708652f, -0.02217755f, -0.19960558f, -0.08838803f, 0.10854899f, 0.00478347f, 
    0.00239047f, 0.00447684f, -0.01093695f, -0.04669778f, 0.02219658f, 0.07696246f, 0.13559517f, 0.11949315f, 
    0.02333034f, -0.06591608f, -0.02166745f, -0.36491078f, -0.08758370f, -0.04866625f, -0.04697051f, 0.02485071f, 
    0.18906580f, 0.16396981f, 0.12101231f, -0.11549191f, -0.15065446f, -0.22538966f, 0.00556169f, -0.14333825f, 
    0.12114315f, -0.10520373f, 0.15112549f, -0.03477228f, 0.30041298f, -0.01223123f, -0.02368517f, 0.14047831f, 
    -0.34917277f, -0.26998997f, 0.12701344f, 0.07314540f, 0.08619430f, 0.04570098f, 0.08745410f, 0.04486284f, 
    -0.30982310f, -0.10825477f, -0.09697852f, 0.10316368f, 0.08171196f, 0.00266422f, 0.14136688f, -0.04973594f, 
    -0.06700740f, 0.07466308f, -0.00435987f, -0.05236520f, -0.00955847f, -0.06489975f, -0.05124481f, 0.12098686f, 
    0.05770501f, 0.18372431f, 0.18753788f, 0.33925381f, 0.15014842f, 0.03345988f, -0.01327673f, -0.06627618f, 
    0.14285222f, -0.03020029f, -0.09715784f, 0.21783961f, -0.25040114f, -0.44700447f, 0.25208002f, 0.00748194f, 
    -0.20990743f, 0.16060035f, -0.01383483f, -0.05468226f, 0.07671047f, 0.00063586f, -0.06828509f, 0.24852909f, 
    0.03353597f, -0.18522160f, -0.45256352f, -0.77652901f, -0.32539794f, 0.54628640f, 0.38381502f, -0.59898198f, 
    -0.37785041f, 0.10298747f, 0.15594028f, 0.15213509f, -0.12117446f, 0.00575181f, -0.08399325f, 0.10569362f, 
    0.02595201f, 0.24080172f, 0.15296067f, -0.31320766f, 0.01071996f, -0.18374451f, -0.17983466f, 0.14490280f, 
    0.05996459f, -0.43260321f, 0.04779908f, 0.12271936f, 0.12553972f, 0.33977547f, 0.06067311f, 0.01238202f, 
    -0.01774727f, 0.01054466f, -0.08964929f, -0.02617558f, -0.06030177f, -0.08883020f, 0.04237130f, -0.01989519f, 
    -0.06200252f, -0.36322188f, 0.13592468f, -0.34643680f, 0.12492633f, 0.04061668f, -0.01626596f, 0.10498220f, 
    -0.03803657f, 0.11904764f, 1.05943286f, 0.15402970f, -0.21451613f, -0.01871106f, 0.14241514f, -0.03587803f, 
    0.09698354f, 0.15435588f, 0.02019932f, 0.03140623f, -0.09150115f, 0.20020327f, 0.02808993f, 0.13305487f, 
    -0.01222936f, 0.24237569f, 0.10225797f, -0.13549414f, -0.22474225f, -0.11739411f, -0.52367014f, 0.09453207f, 
    -0.09166152f, -0.01879630f, 0.12560163f, -0.01477388f, -0.11144613f, -0.36372501f, 0.22603932f, 0.03008372f, 
    -0.05755858f, 0.01219429f, 0.02215987f, 0.23436056f, 0.31824756f, 0.02519665f, 0.07198095f, 0.19378391f, 
    0.15280366f, -0.05146769f, -0.29512501f, -0.21588936f, 0.02286024f, -0.05184947f, 0.07885000f, 0.08976539f, 
    0.13551839f, 0.26526693f, -0.06669772f, -0.04076480f, 0.06945529f, 0.06480832f, -0.01381187f, 0.04896059f, 
    0.14054960f, 0.25062782f, 0.27998081f, -0.07444389f, 0.07719997f, -0.04399098f, 0.10806555f, -0.04241833f, 
    -0.00595546f, -0.04316368f, 0.16817482f, 0.10633244f, -0.11220005f, -0.18684170f, -0.14234425f, 0.07137543f, 
    0.09500625f, 0.17573906f, -0.18691078f, -0.11945608f, -0.38216904f, -0.00472292f, 0.15525059f, 0.13503872f, 
    -0.01967117f, 0.01192719f, -0.19793595f, 0.20271844f, -0.07814939f, -0.03088580f, -0.14519671f, -0.05932315f, 
    0.11732386f, 0.11603997f, 0.15205988f, 0.06116664f, -0.01299084f, 0.13369906f, 0.11957511f, 0.07775607f, 
    -0.16180196f, -0.04151951f, 0.01937585f, -0.03148263f, -0.02518110f, -0.08710493f, 0.04008090f, 0.02332469f, 
    0.02635281f, -0.17327411f, -0.15129289f, 0.14677390f, 0.13886167f, 0.15354434f, -0.09950931f, 0.04312597f, 
    0.06307536f, 0.00145963f, -0.26789314f, 0.03873410f, 0.16744234f, 0.06973189f, 0.04335649f, -0.17268406f, 
    0.31795692f, -0.29944560f, -0.30097526f, 0.00383727f, -0.04726682f, 0.02767191f, 0.07647093f, 0.11310919f, 
    -0.13114755f, 0.14513180f, -0.20786531f, -0.21114156f, -0.08105708f, 0.07087465f, 0.25025141f, 0.14223681f, 
    0.09224457f, 0.04664274f, 0.02791106f, 0.15811165f, -0.24339826f, -0.00179012f, -0.01485792f, 0.04703815f, 
    0.04310884f, 0.20566963f, 0.07299336f, -0.18861590f, -0.03013694f, -0.06652047f, -0.05800037f, -0.12216254f, 
    0.03666532f, 0.10588199f, 0.02437130f, -0.07582250f, 0.04283387f, 0.22060780f, -0.04942205f, -0.14211796f, 
    -0.09884325f, -0.00918172f, -0.02770067f, -0.17057572f, 0.17954500f, -0.25625554f, 0.04453004f, -0.02619106f, 
    -0.00578809f, -0.06687777f, 0.05044945f, 0.03741989f, -0.01536542f, 0.09519760f, -0.13189922f, 0.34105617f, 
    0.08044749f, -0.02630762f, -0.09780449f, 0.13988861f, 0.03476080f, 0.08800814f, 0.15158272f, -0.25646517f, 
    -0.37588578f, -0.26619041f, 0.34048733f, -0.10893168f, 0.19503273f, -0.00170886f, -0.03095190f, 0.04719928f, 
    0.01894189f, 0.09018804f, 0.06538599f, -0.15562266f, -0.09498634f, -0.08110324f, -0.12041886f, -0.01462116f, 
    -0.08296518f, 0.14126849f, 0.18868326f, 0.16729549f, 0.17712510f, 0.03504539f, -0.17174502f, -0.10601470f, 
    -0.01330504f, 0.19771045f, 0.08039667f, -0.24055451f, -0.22835723f, 0.07424979f, -0.08204944f, 0.00693468f, 
    -0.14332236f, 0.14737761f, -0.09854862f, -0.13545366f, -0.10156956f, 0.08388402f, 0.19548330f, -0.22565815f, 
    0.10937354f, 0.11763784f, -0.10389289f, 0.07307148f, 0.31307262f, -0.46087435f, -0.13391516f, 0.00364462f, 
    0.13145363f, 0.16587909f, -0.04684508f, -0.07192103f, 0.01801583f, -0.11540404f, -0.15648702f, -0.01968141f, 
    -0.18849437f, -0.05963656f, 0.11869620f, 0.13086458f, 0.06768788f, -0.00112933f, -0.13779867f, 0.51775604f, 
    -0.06796095f, -0.07689587f, -0.22065140f, -0.02985053f, 0.19180644f, 0.22392616f, -0.05753823f, -0.38056931f, 
    -0.30841616f, 0.02750669f, 0.14129901f, -0.28780162f, -0.08957318f, 0.19794539f, 0.02303834f, 0.05405943f, 
    0.30369571f, 0.08868217f, 0.01741607f, -0.03198441f, -0.02371611f, 0.03553765f, -0.28786859f, 0.14702275f, 
    0.11611597f, -0.24418741f, -0.06606452f, 0.00825628f, -0.01223818f, -0.01441496f, 0.13496350f, -0.10016724f, 
    0.15254202f, -0.05380960f, -0.06569719f, -0.00071656f, -0.17171125f, 0.03413709f, 0.10095999f, 0.05675388f, 
    0.06119347f, 0.04710938f, 0.41011485f, -0.37249175f, 0.16494831f, 0.01933969f, -0.05381722f, 0.22217126f, 
    0.25526851f, -0.07831720f, 0.11172184f, 0.50068402f, 0.33342287f, 0.18525022f, 0.18158330f, 0.37543404f, 
    -0.04451456f, 0.00246710f, -0.02820175f, 0.05388587f, -0.63131070f, -0.50597703f, -0.02826926f, -0.18013617f, 
    0.18199886f, 0.00109857f, 0.05859558f, -0.07667307f, 0.05559240f, -0.15432070f, -0.43602338f, -0.20000194f, 
    -0.10390932f, -0.08901065f, -0.07240238f, 0.14458428f, -0.06207856f, -0.00053190f, -0.15253328f, 0.11952877f, 
    -0.08498510f, 0.04047368f, -0.12342399f, -0.02752524f, -0.01190536f, -0.07955392f, 0.11027975f, 0.21901108f, 
    -0.20201491f, 0.14657103f, 0.15347816f, 0.08394580f, 0.20666556f, -0.19421124f, 0.23811220f, -0.01942238f, 
    -0.02761560f, -0.15845761f, 0.08024324f, -0.14969163f, 0.14490876f, 0.12541050f, 0.07758504f, 0.11792166f, 
    0.21433669f, -0.32378310f, -0.00076831f, -0.25222144f, -0.27029970f, -0.23837376f, -0.33096695f, -0.09865726f, 
    -0.11868849f, 0.05325407f, -0.09301192f, -0.61803806f, 0.39568204f, -0.03647653f, -0.01170464f, 0.01437858f, 
    0.09405717f, 0.04840685f, 0.13359609f, -0.11225117f, -0.39179644f, -0.40277222f, 0.26726276f, -0.17826515f, 
    -0.02250923f, 0.03522480f, 0.14918438f, -0.17713273f, 0.46503299f, 0.35181499f, 0.03913220f, -0.00994120f, 
    -0.00594983f, -0.19973692f, -0.08028198f, -0.06207833f, -0.03776415f, -0.37903669f, 0.02158187f, -0.21173929f, 
    -0.14363949f, 0.18503419f, -0.09428467f, -0.02056303f, 0.09963651f, 0.08202360f, 0.33588907f, 0.21786855f, 
    0.11666199f, 0.16319451f, 0.07871678f, -0.13226044f, -0.02948120f, 0.00286294f, -0.19364189f, -0.49498647f, 
    -0.28780046f, -0.17792666f, -0.21619347f, -0.00353758f, -0.14224838f, -0.11972914f, -0.16454607f, -0.19885194f, 
    -0.22909610f, -0.45296606f, 0.08884834f, -0.01780694f, -0.12787837f, -0.08266273f, 0.01004825f, -0.05335475f, 
    -0.03345735f, -0.01426582f, -0.21032651f, -0.02807680f, -0.15511198f, 0.25626692f, -0.05338278f, -0.00809113f, 
    0.11809950f, 0.03811317f, 0.02958451f, -0.02868231f, -0.13353972f, 0.17932241f, 0.03778892f, 0.18161324f, 
    0.09129313f, -0.01880562f, 0.05961778f, 0.29376289f, -0.03257246f, 0.32418644f, 0.25649381f, 0.01648846f, 
    0.09069432f, 0.07993063f, 0.00049523f, 0.02449305f, 0.20472650f, -0.27468607f, -0.09921241f, 0.04765829f, 
    0.08980279f, 0.05311142f, 0.18434653f, 0.06271594f, -0.06548075f, -0.31772447f, -0.44918719f, -0.28917256f, 
    -0.03420271f, 0.19878718f, -0.10753920f, -0.29925022f, -0.10362310f, 0.21067393f, 0.05144283f, -0.15684105f, 
    0.27834243f, 0.08998976f, -0.03948329f, 0.09827596f, 0.15253611f, -0.05458626f, 0.02608592f, 0.09297874f, 
    -0.31280744f, -0.02991986f, 0.05782175f, -0.09260835f, -0.07340999f, -0.02658667f, -0.17447469f, 0.12102047f, 
    0.06253656f, -0.18626302f, 0.06157296f, -0.07864276f, -0.20094264f, 0.16779737f, 0.30991846f, -0.04727496f, 
    -0.11203916f, 0.37077764f, 0.06040503f, 0.39391348f, 0.03330569f, 0.12953490f, 0.13047773f, -0.05690765f, 
    0.09731875f, 0.29937905f, 0.27184084f, -0.95811749f, -0.37551504f, -0.27325800f, -0.30860195f, -0.19723944f, 
    -0.11670305f, -0.16770899f, -0.12627195f, -0.11899532f, -0.30899787f, -0.58846843f, 0.24053049f, -0.12115112f, 
    -0.03023234f, 0.11541044f, -0.09679775f, -0.04028639f, 0.20932487f, -0.23926398f, -0.20881486f, 0.06370077f, 
    0.10187985f, -0.01572013f, 0.06491750f, -0.05367669f, -0.12296075f, 0.78385377f, -0.23973496f, 0.20826323f, 
    0.08140006f, 0.16633323f, 0.01842953f, -0.07175747f, -0.06906361f, 0.12753396f, -0.27717870f, -0.09566270f, 
    0.01144305f, 0.06341034f, 0.16637465f, 0.19749336f, -0.11893103f, 0.01741075f, -0.13513717f, 0.16871639f, 
    0.11221281f, 0.09636966f, -0.19373724f, -0.10708743f, -0.02116502f, -0.19996090f, 0.23722309f, -0.00596403f, 
    -0.01655136f, 0.02210660f, 0.02269864f, 0.00512872f, -0.05123201f, -0.01021102f, 0.01682655f, -0.02590376f, 
    -0.06373730f, -0.03075322f, 0.01993788f, -0.05537949f, -0.01481900f, -0.00224146f, -0.02325737f, -0.03089467f, 
    0.03372531f, -0.05631924f, -0.07293020f, -0.01515073f, -0.02692734f, 0.00929407f, -0.02581581f, -0.04881967f, 
    -0.02366669f, 0.01393763f, -0.01545348f, -0.00246533f, 0.01083486f, 0.02117725f, -0.06607912f, -0.02156165f, 
    -0.06157772f, -0.05901430f, -0.00002902f, 0.01979032f, -0.08825526f, -0.07637543f, 0.01576754f, -0.05794362f, 
    -0.06791080f, 0.01311143f, -0.04495729f, 0.02583204f, 0.02387830f, -0.00663683f, -0.00522295f, 0.03937130f, 
    -0.07683271f, -0.04212428f, -0.05339312f, 0.00531757f, -0.05634186f, 0.03324694f, 0.01583475f, 0.03598594f, 
    -0.03655850f, -0.00029433f, 0.03613934f, -0.01088548f, -0.00002164f, -0.02940968f, 0.00765946f, -0.01617129f, 
    0.01336107f, 0.05073885f, -0.05084553f, -0.04931930f, 0.02026792f, -0.05802848f, -0.05020422f, 0.04014640f, 
    0.04089714f, 0.03181775f, 0.03125418f, 0.02501164f, -0.06950019f, 0.03341412f, 0.01504594f, -0.00502342f, 
    -0.01246525f, -0.02250004f, 0.00476160f, -0.00587043f, 0.05270624f, -0.01825566f, -0.02161068f, 0.02075499f, 
    0.03705449f, -0.04658581f, 0.02557523f, 0.00589751f, -0.02125418f, -0.02053007f, 0.02103011f, -0.07956048f, 
    0.02226558f, 0.02067802f, -0.04824902f, -0.03014227f, 0.00794114f, -0.01014111f, -0.02625025f, 0.02005390f, 
    0.01098984f, -0.01948952f, 0.01852037f, 0.01230032f, 0.00667741f, -0.03796509f, 0.01478440f, -0.01766427f, 
    0.04287864f, -0.02353055f, 0.03648531f, -0.05845717f, -0.02823964f, 0.02793078f, 0.01650331f, 0.03605057f, 
    0.06879659f, 0.04781874f, 0.00259964f, -0.02224566f, 0.01340356f, -0.00883764f, 0.04288760f, -0.00691857f, 
    -0.05720821f, 0.01512392f, 0.00894078f, -0.04877830f, -0.05372502f, -0.06594914f, -0.03666450f, -0.06366300f, 
    -0.05610290f, 0.02933418f, -0.04207107f, 0.01345094f, -0.01083579f, -0.01485264f, -0.05406134f, 0.02414241f, 
    -0.06401080f, -0.04422819f, -0.04691733f, -0.06217523f, -0.01589238f, -0.00204302f, -0.00772311f, -0.01617644f, 
    -0.02683231f, -0.01119895f, -0.01244967f, -0.03923601f, -0.02023489f, -0.01338814f, -0.02250389f, 0.02915973f, 
    -0.00091685f, 0.02082454f, 0.04277943f, 0.02493078f, -0.06745428f, -0.00100430f, 0.01243391f, 0.00080752f, 
    0.00189416f, -0.07674322f, 0.04080130f, -0.02578134f, -0.00135661f, -0.04433088f, -0.00475384f, 0.00455470f, 
    -0.03822102f, 0.02406667f, -0.05843151f, -0.00458015f, -0.03512033f, 0.04001115f, -0.00757060f, 0.00122764f, 
    0.02731760f, -0.05368673f, 0.02163570f, 0.03007855f, -0.04154332f, 0.01162765f, -0.05248565f, 0.01433225f, 
    -0.02524810f, -0.00094180f, 0.02909639f, -0.05198252f, -0.03794401f, -0.00423816f, -0.07673411f, -0.02587084f, 
    -0.07388127f, -0.01230575f, 0.02991605f, -0.04514513f, -0.05499727f, -0.00458999f, -0.01718227f, 0.03642084f, 
    0.01036655f, -0.02572575f, -0.01496616f, -0.04394231f, 0.04716251f, -0.05941413f, -0.08098713f, 0.04249075f, 
    -0.04042352f, 0.00292084f, -0.04177141f, -0.01927898f, 0.04212400f, 0.00787962f, -0.02554255f, 0.01376808f, 
    -0.03246501f, 0.02196677f, 0.00054992f, -0.04706118f, -0.05462204f, -0.05717369f, -0.01873429f, -0.00105348f, 
    -0.01852076f, -0.01220279f, 0.03714515f, -0.04127867f, -0.07914881f, -0.07288749f, -0.00777811f, -0.00699740f, 
    0.00934996f, 0.03061406f, -0.02793909f, -0.04416585f, -0.04064169f, -0.07949284f, -0.04894190f, 0.01399421f, 
    -0.06938380f, 0.02181642f, 0.03791637f, 0.02787055f, -0.04064592f, 0.00346593f, 0.01824124f, 0.02601351f, 
    0.01165767f, 0.01682054f, 0.02022960f, -0.01440448f, -0.01776406f, 0.03729580f, -0.01746426f, -0.00254020f, 
    -0.05108976f, -0.02480116f, 0.00889534f, -0.04286284f, -0.04724255f, 0.04438575f, -0.00674722f, -0.02910132f, 
    0.00894685f, -0.08705264f, -0.00336031f, 0.02866914f, -0.06969724f, -0.06562173f, -0.06993002f, 0.05662886f, 
    0.03300948f, 0.00758286f, 0.00826702f, -0.02100205f, -0.05915054f, -0.03631881f, -0.00618507f, -0.05608662f, 
    0.27727830f, -0.02338651f, 0.11833862f, -0.09359445f, 0.10655468f, 0.07365959f, 0.01973236f, 0.00465384f, 
    0.07207919f, -0.08698181f, -0.32991910f, 0.06456579f, -0.01680841f, 0.15363519f, -0.01085781f, -0.32582614f, 
    -0.12814747f, -0.36386093f, -0.24084724f, 0.09004898f, -0.60955781f, -0.05220328f, -0.06456421f, -0.20124125f, 
    -0.16303754f, 0.11840725f, -0.24149489f, -0.08215481f, -0.09824986f, -0.02854806f, 0.02163432f, -0.04303379f, 
    -0.27819601f, -0.02390022f, 0.00159177f, 0.06540588f, 0.66406173f, -0.08062506f, -0.05855207f, -0.13934994f, 
    -0.17753440f, -0.06605861f, 0.00445766f, 0.10577713f, 0.05110443f, 0.36398214f, -0.25181481f, -0.21914822f, 
    0.06792340f, -0.12865856f, -0.07408635f, -0.07073854f, -0.06188570f, 0.08558788f, 0.18518677f, 0.06102477f, 
    0.14873824f, 0.03852516f, 0.13482557f, -0.10373673f, 0.03728132f, -0.14446165f, 0.02851140f, -0.16247942f, 
    0.12523052f, 0.05332710f, 0.26042813f, 0.15726227f, 0.03924052f, 0.10379449f, 0.13526775f, 0.10851783f, 
    0.16124921f, 0.07462450f, 0.13642222f, -0.06614804f, -0.01001247f, 0.03385735f, 0.01009748f, 0.13664734f, 
    0.10561150f, 0.25666600f, 0.20285885f, 0.29663971f, -0.07718349f, -0.28768665f, -0.21846102f, 0.05256047f, 
    -0.13662891f, 0.02536433f, 0.66955280f, 0.13772818f, -0.17884399f, -0.16854441f, -0.07532024f, 0.12545478f, 
    0.04358337f, -0.03963662f, -0.16165233f, 0.23756935f, -0.04554998f, -0.05487369f, 0.04599286f, -0.19224826f, 
    -0.07678689f, 0.01306491f, -0.09762584f, 0.05676553f, -0.22080517f, -0.04893148f, 0.18484561f, 0.05669238f, 
    0.12752509f, -0.03830159f, 0.14359164f, -0.12161957f, 0.11762935f, 0.10673226f, 0.04203882f, 0.08347004f, 
    -0.00585751f, -0.23482436f, -0.31978464f, 0.17368460f, -0.01764234f, 0.05768945f, 0.11695663f, -0.08736967f, 
    0.08370364f, -0.06918618f, -0.12637343f, -0.06111706f, 0.25324428f, -0.02693607f, 0.05156146f, 0.33995953f, 
    -0.14555900f, -0.16246736f, -0.02655473f, -0.10868297f, 0.20024557f, 0.13120015f, -0.09147546f, -0.06971413f, 
    0.66651452f, -0.08527087f, -0.10264031f, 0.01151966f, -0.01807615f, -0.00202651f, -0.01585180f, 0.13955621f, 
    0.17779326f, 0.43266022f, -0.07080175f, 0.05826642f, 0.02175885f, -0.07986868f, 0.08676203f, -0.00146749f, 
    0.11664995f, -0.17163475f, 0.14841925f, -0.03651041f, -0.05242534f, -0.07205611f, 0.12112294f, -0.09683008f, 
    0.04925007f, -0.02038873f, -0.02102995f, -0.01298862f, 0.10126697f, 0.07604696f, 0.10602970f, -0.01811130f, 
    -0.07081097f, -0.18745975f, 0.21334139f, -0.15235201f, -0.06704921f, 0.04774148f, 0.04967991f, 0.02066183f, 
    0.01819381f, -0.01559505f, -0.02803493f, 0.02603177f, -0.05151208f, 0.15852864f, -0.00782022f, 0.34083235f, 
    -0.28392807f, -0.43679452f, -0.32389650f, -0.11926016f, 0.00490995f, 0.00440708f, -0.08516593f, -0.21402466f, 
    -0.39871246f, -0.19273412f, -0.09201726f, -0.05505481f, -0.04572708f, 0.03393101f, 0.07477273f, -0.05806354f, 
    -0.07172757f, 0.04327482f, -0.06453978f, 0.05810876f, -0.28523961f, -0.10160596f, 0.10007861f, -0.02098195f, 
    0.13646302f, -0.05597354f, -0.01102897f, 0.11104456f, 0.18105118f, -0.05866826f, -0.05673706f, -0.16625977f, 
    -0.12608470f, 0.33157134f, -0.01246402f, 0.25913876f, -0.02785457f, -0.04433481f, 0.11480255f, 0.04569747f, 
    0.03717502f, -0.09927849f, -0.53057301f, 0.34322402f, 0.32809752f, -0.19373870f, -0.01486479f, -0.18026462f, 
    -0.17881003f, -0.16322085f, 0.01505892f, 0.44073939f, -0.41778311f, -0.55773443f, 0.10092359f, -0.01051209f, 
    -0.10732353f, -0.04292510f, 0.03986218f, -0.16137862f, 0.18292236f, 0.23528227f, -0.26262879f, 0.12640731f, 
    0.00477559f, 0.15120831f, 0.15307748f, -0.01466140f, 0.11856081f, -0.35725045f, 0.01261261f, 0.62933195f, 
    -0.09027406f, 0.05597020f, 0.07732326f, 0.15659781f, 0.03324120f, 0.02565275f, -0.14923480f, 0.28885421f, 
    -0.05926724f, 0.06154331f, 0.23411572f, 0.16431326f, 0.04475840f, 0.09912550f, -0.06684323f, -0.05144195f, 
    0.04406342f, 0.07708829f, 0.18726130f, 0.18594281f, 0.04486190f, 0.06958605f, -0.14142781f, 0.04018424f, 
    -0.03068674f, -0.02267054f, -0.04469472f, -0.05177175f, 0.04153796f, 0.01487025f, -0.00716161f, 0.04925370f, 
    -0.04347143f, -0.04635635f, 0.03846566f, 0.01043061f, 0.01488951f, -0.03577339f, 0.01652477f, -0.05550758f, 
    0.00615014f, 0.04088915f, 0.01533039f, 0.05372343f, 0.03142751f, 0.02798904f, -0.00464871f, -0.03562988f, 
    -0.04501199f, 0.04215281f, 0.01202619f, 0.04702222f, -0.06178378f, -0.00723649f, 0.02903488f, -0.04924339f, 
    -0.05269372f, -0.02797731f, 0.00230641f, 0.03143586f, -0.03010706f, -0.05712215f, -0.05624314f, -0.05693322f, 
    0.00154187f, -0.01960713f, 0.03981866f, -0.02896791f, -0.01388319f, -0.01390268f, -0.06161199f, -0.02891545f, 
    -0.02025653f, -0.04995695f, -0.06206952f, 0.03255400f, 0.01978749f, 0.04195357f, 0.02038615f, -0.02679711f, 
    -0.00248658f, -0.04848417f, 0.00962793f, -0.03087481f, -0.03866223f, -0.01661523f, -0.04920888f, -0.00595626f, 
    -0.01991982f, -0.00416525f, -0.05116863f, 0.05898139f, 0.04251017f, -0.06260183f, 0.00159724f, 0.03249045f, 
    -0.04023439f, -0.02105147f, -0.03119498f, -0.04104415f, 0.02145883f, 0.01475484f, -0.03176060f, -0.04876274f, 
    0.01389346f, 0.04705309f, -0.04256080f, 0.02635329f, 0.04475068f, -0.04889811f, -0.03945236f, 0.04234632f, 
    0.03948071f, -0.06043209f, 0.01200578f, -0.04826472f, 0.00963822f, -0.02543788f, -0.02823776f, -0.04489926f, 
    0.02185476f, 0.03158141f, 0.01374511f, -0.02725078f, -0.04257384f, -0.02882332f, 0.05169962f, -0.01814180f, 
    -0.05328190f, -0.05858287f, 0.00193811f, -0.04315891f, -0.05081134f, -0.03204360f, 0.00599801f, -0.06361452f, 
    -0.00596314f, -0.04520825f, -0.02451285f, 0.04191168f, -0.01421285f, 0.01289741f, -0.06308313f, -0.02232014f, 
    -0.03028854f, 0.00411788f, 0.03269803f, -0.05278905f, -0.00603602f, -0.03553547f, 0.04586378f, -0.04718745f, 
    -0.01581813f, 0.02921775f, 0.00622255f, -0.00448003f, 0.02067998f, -0.05817788f, -0.06144719f, 0.04498509f, 
    0.02253490f, -0.05430308f, -0.03146474f, 0.05104219f, 0.03246944f, -0.02922936f, 0.02068927f, 0.00388698f, 
    0.02581464f, -0.01389881f, -0.04386049f, -0.05828210f, 0.03709871f, 0.00981926f, -0.02718901f, 0.03056060f, 
    0.03249947f, -0.06045719f, -0.04572883f, -0.04878487f, 0.04451958f, -0.06122445f, -0.05080980f, 0.05156631f, 
    -0.03594815f, 0.04587926f, 0.02785701f, 0.03260534f, 0.00011669f, 0.00413514f, 0.00800863f, -0.02886314f, 
    -0.04443053f, 0.02977927f, -0.01023492f, 0.00961316f, 0.04957804f, 0.02797534f, -0.06328637f, -0.05778459f, 
    0.00112934f, 0.00261532f, 0.02129008f, -0.05160509f, -0.01273905f, -0.00126529f, -0.00694828f, -0.04437982f, 
    -0.06339195f, -0.04252920f, 0.03846615f, 0.05128666f, -0.05745011f, 0.01247634f, -0.01326379f, 0.01549037f, 
    0.00610193f, 0.02872638f, -0.01573227f, -0.05172858f, 0.01668599f, 0.03034419f, 0.01822290f, -0.02455100f, 
    -0.03963859f, -0.06148814f, -0.04969986f, 0.00158952f, -0.01129975f, -0.03373813f, -0.00257947f, -0.05649922f, 
    0.03728978f, -0.00052260f, -0.02855817f, 0.01023384f, 0.01306735f, -0.01165631f, -0.02123616f, -0.01026524f, 
    -0.05992820f, -0.03725166f, 0.03428710f, -0.00553823f, -0.00436416f, -0.02781347f, 0.02202911f, 0.05177799f, 
    0.05196287f, 0.00990241f, 0.05237745f, -0.00078862f, 0.00401839f, -0.06229200f, 0.03166103f, 0.02188339f, 
    -0.05908879f, 0.01031070f, 0.00035983f, 0.01359105f, -0.04159034f, -0.02253958f, 0.03143061f, -0.00161225f, 
    -0.04838962f, -0.00228574f, -0.03465629f, 0.00034231f, -0.06160397f, -0.02467975f, 0.04201324f, -0.00368371f, 
    0.01005223f, -0.03520119f, -0.00598346f, -0.01506290f, 0.00246698f, 0.05261699f, -0.00440645f, -0.04799614f, 
    -0.06260037f, 0.01737700f, -0.05725604f, 0.00832330f, -0.01461241f, -0.01011070f, 0.00674574f, 0.01513421f, 
    0.00028502f, -0.02150122f, 0.04007814f, -0.06576803f, -0.00584607f, 0.02791336f, -0.02447578f, -0.00087120f, 
    0.03335761f, -0.00174478f, 0.03785018f, 0.01483237f, -0.05561854f, -0.02859933f, 0.02769559f, -0.05644385f, 
    0.03182087f, -0.02797074f, 0.02319708f, 0.04807612f, 0.01737002f, -0.05184548f, 0.05216348f, -0.02530118f, 
    -0.24446930f, -0.70837188f, 0.15347002f, 0.09103950f, 0.11790410f, 0.03770868f, -0.05433924f, -0.09554555f, 
    0.04719521f, 0.11076330f, -0.32657585f, -0.04122705f, 0.07730324f, -0.02904917f, 0.08411968f, -0.01225614f, 
    -0.15005332f, 0.00276555f, -0.06534909f, -0.37525979f, -0.10305340f, 0.08735628f, 0.03615249f, 0.20456761f, 
    -0.15796942f, 0.02587618f, -0.05322585f, 0.08562697f, 0.07567314f, 0.11635661f, 0.30371684f, -0.01613099f, 
    0.38579452f, -0.25244468f, -0.03624098f, 0.02552983f, 0.34780592f, -0.36930224f, -0.34895301f, -0.17349654f, 
    0.06537717f, -0.13419208f, 0.01339112f, -0.11426195f, -0.02072501f, -0.76465559f, -0.41521585f, -0.03933429f, 
    0.08771334f, -0.04377314f, -0.00932159f, -0.05286519f, 0.15079176f, -0.24226512f, 0.09748322f, 0.15211439f, 
    0.19039233f, -0.24374436f, -0.05454578f, 0.08675545f, -0.02424849f, -0.13956633f, -0.09686093f, 0.03659236f, 
    0.18448214f, 0.19801547f, 0.05513012f, 0.17946240f, 0.11592379f, 0.24826176f, 0.13560703f, 0.17635994f, 
    -0.09405623f, -0.08236177f, 0.54828846f, 0.06301634f, 0.05312784f, 0.03976717f, -0.02748582f, 0.09506951f, 
    0.16426788f, 0.13408899f, 0.09457560f, 0.17135705f, -0.21991432f, -0.26172200f, -0.13356522f, -0.01952194f, 
    -0.20550060f, -0.05524351f, -0.02055193f, -0.12258554f, -0.20892318f, 0.06293851f, 0.07418074f, 0.08300897f, 
    -0.02215149f, -0.27518815f, -0.24344338f, 0.17601135f, 0.05388857f, -0.01329367f, -0.03390002f, -0.20686428f, 
    -0.15343851f, -0.05870766f, -0.01829628f, 0.00650465f, 0.27430379f, 0.04652631f, 0.16429713f, -0.02532956f, 
    -0.00318760f, 0.06643773f, 0.14999907f, -0.20014133f, -0.04810158f, 0.17047749f, 0.07462402f, 0.15160236f, 
    -0.03275668f, -0.16229533f, -0.08497983f, -0.12567297f, -0.01104288f, 0.03094720f, 0.13334511f, 0.18007989f, 
    0.11215399f, -0.08750780f, -0.18913405f, -0.04586736f, 0.04410318f, -0.02681257f, -0.07498559f, 0.72516692f, 
    0.05817009f, -0.03096570f, -0.01711736f, 0.06119232f, 0.07420240f, 0.10054740f, -0.02931037f, 0.02193235f, 
    0.26172298f, -0.14512987f, -0.31129020f, -0.05159357f, -0.04219473f, -0.02921111f, 0.06067617f, 0.13116018f, 
    0.23823482f, -0.01185182f, 0.31639218f, -0.17759494f, 0.11245249f, 0.00082180f, 0.02650716f, 0.07051528f, 
    -0.00194881f, -0.06722349f, 0.10753205f, 0.09092124f, 0.11312255f, 0.01054694f, -0.10095835f, -0.09950875f, 
    -0.12777627f, -0.05110706f, -0.09974483f, 0.14666003f, 0.04209110f, 0.20095727f, 0.10186332f, 0.19069813f, 
    0.07326414f, 0.21529494f, -0.02799891f, 0.01573162f, -0.04021110f, -0.18961139f, -0.05513103f, 0.37595490f, 
    -0.22271504f, 0.02038233f, -0.02102350f, -0.06917094f, -0.17190300f, 0.12419335f, 0.19117032f, 0.06247846f, 
    -0.08512076f, -0.30594695f, -0.24125163f, -0.09819103f, -0.20256254f, -0.05955430f, -0.00922548f, -0.50658840f, 
    -0.37332153f, 0.04528518f, -0.06538303f, -0.13402608f, -0.05066275f, -0.07355859f, -0.04655400f, 0.06142553f, 
    0.09640005f, 0.10634265f, -0.07452545f, 0.04103039f, 0.21209586f, -0.04631343f, -0.06568026f, -0.11980169f, 
    0.22172487f, 0.14977598f, 0.16361591f, -0.01989627f, -0.04171298f, -0.08989014f, 0.16731273f, -0.26391336f, 
    -0.18777663f, -0.34502631f, -0.91195279f, -0.38591680f, -0.06193083f, -0.02459912f, -0.05921614f, -0.00405301f, 
    -0.16149990f, -0.03923314f, 0.26281166f, 0.03850659f, 0.04028462f, -0.04368319f, 0.02874730f, 0.22121739f, 
    0.10802861f, -0.22546524f, -0.08958867f, 0.34219751f, -0.17000194f, -0.90372986f, -0.10388921f, 0.09268132f, 
    0.03235414f, 0.08760750f, -0.04324741f, 0.00262346f, -0.14601262f, -0.10659183f, 0.02653077f, 0.19742009f, 
    -0.12861882f, 0.01555512f, -0.07154892f, -0.09295831f, -0.01290962f, -0.37458909f, 0.11679304f, 0.31817418f, 
    0.06015518f, 0.07105028f, 0.06309459f, 0.04206887f, 0.00593508f, 0.03082184f, -0.39863464f, -0.37156376f, 
    -0.23476070f, 0.50601149f, 0.14812592f, 0.17773169f, 0.07725187f, 0.00718854f, -0.10071342f, 0.09533581f, 
    0.06191459f, 0.24108741f, 0.05764484f, 0.07955860f, 0.16210595f, 0.05154854f, -0.03695964f, 0.05379763f, 
    -0.76062357f, -1.00804460f, -0.38967833f, -0.06973357f, -0.09004839f, -0.06870734f, 0.03891511f, 0.00739716f, 
    0.25593963f, -0.06344958f, -0.32743964f, 0.16766642f, -0.09785200f, 0.03059458f, 0.01771844f, 0.28211281f, 
    0.18888463f, 0.13948396f, 0.41550142f, 0.09314409f, -0.73491228f, 0.01214589f, -0.05939033f, -0.03509422f, 
    -0.05906372f, -0.07312320f, 0.05285282f, 0.25814274f, 0.19576678f, 0.17667165f, -0.25049955f, 0.20919935f, 
    -0.01928912f, 0.24476837f, 0.13313945f, 0.06679530f, -0.34468862f, 0.45582899f, 0.77871829f, -0.04395719f, 
    0.09746161f, 0.11237852f, 0.08835290f, 0.06306802f, 0.18876222f, -0.59777451f, -0.48894706f, -0.26917520f, 
    -0.09371114f, 0.03266487f, 0.00801609f, -0.08388390f, -0.02596560f, -0.00238722f, 0.01341165f, -0.00687308f, 
    -0.07314485f, 0.01988829f, -0.30675632f, -0.26015273f, 0.00074323f, -0.03381525f, 0.03703520f, 0.16591543f, 
    -0.00511047f, -0.17993535f, 0.02346203f, -0.19956881f, -0.06991709f, 0.09744269f, 0.14478043f, 0.19813608f, 
    -0.77188528f, -0.59261680f, -0.59519327f, 0.07085574f, 0.00816587f, -0.03237997f, 0.07295685f, 0.10434049f, 
    0.08857386f, -0.12330670f, -0.21666935f, -0.08402586f, -0.15182795f, -0.03712116f, -0.39448041f, 0.05009058f, 
    -0.10330730f, 0.01259346f, -0.07384986f, 0.33145717f, 0.09475394f, -0.03772799f, -0.14205970f, -0.12396880f, 
    -0.01569068f, -0.04670157f, 0.10551091f, -0.07365409f, 0.03376161f, -0.02174114f, -0.18574834f, 0.04954353f, 
    0.03210593f, 0.07129793f, 0.03405028f, 0.00198203f, 0.18024750f, 0.11333847f, 0.03897947f, 0.00879043f, 
    -0.01968740f, -0.01634816f, -0.04529707f, 0.18201147f, -0.19058034f, 0.01376987f, 0.10729899f, -0.01430215f, 
    -0.69619566f, -0.05981284f, -0.28958899f, -0.06566612f, 0.04821750f, 0.06357723f, 0.08124179f, 0.01974981f, 
    0.04046841f, -0.09151746f, -0.11840693f, -0.10882364f, -0.14643942f, -0.14252102f, -0.03461906f, 0.26330587f, 
    -0.24262124f, 0.46968040f, -0.09911077f, 0.03685523f, -0.18294968f, -0.06539138f, -0.10687983f, 0.01527547f, 
    -0.17368312f, -0.11554926f, 0.23321176f, -0.19464692f, -0.01044809f, -0.18009773f, -0.35887089f, -0.05588857f, 
    -0.00494700f, -0.80919343f, -0.35929921f, -0.53540337f, -0.00240910f, 0.03439336f, -0.10087465f, 0.05146785f, 
    0.08597009f, 0.09964128f, 0.01865096f, 0.05826716f, -0.00993065f, 0.00689326f, 0.35403112f, 0.28981462f, 
    -0.03947790f, 0.10146905f, 0.06435005f, 0.15886800f, 0.21333736f, 0.04187129f, 0.12695260f, 0.04457198f, 
    0.11549740f, 0.29287022f, 0.30010429f, 0.21513693f, 0.05651145f, 0.43327796f, 0.07414002f, -0.45174709f, 
    0.20828967f, 0.16381150f, 0.10478713f, 0.05117780f, -0.06224413f, -0.27327806f, -0.28012648f, -0.44206041f, 
    -0.15430570f, 0.06190237f, -0.07141661f, 0.01344415f, 0.16978675f, 0.09469053f, 0.07871758f, 0.60784900f, 
    0.82122648f, -0.14209728f, 0.19320220f, -0.03375277f, 0.18867517f, 0.04645391f, -0.02612534f, 0.06044382f, 
    0.06769234f, -0.11867202f, -0.01526688f, -0.23816183f, 0.05653238f, 0.09751964f, -0.17296045f, 0.07475295f, 
    0.09109998f, -0.22278397f, 0.00663885f, 0.08578163f, -0.11332276f, -0.12670451f, 0.05078658f, 0.09232247f, 
    0.00106304f, -0.35083070f, -0.05990979f, 0.43242490f, -0.04697538f, 0.03227462f, 0.02483292f, -0.06059436f, 
    0.09587515f, 0.11331554f, 0.11686613f, -1.39901483f, -0.08569344f, -0.05786591f, 0.09454914f, -0.00324631f, 
    -0.08250342f, -0.13183260f, 0.05706591f, 0.11407445f, -0.04133017f, -0.06767368f, 0.07059794f, -0.14637463f, 
    0.10815597f, -0.08528773f, 0.05626336f, 0.11790296f, -0.04754597f, -0.31328556f, -0.15874930f, 0.06974540f, 
    0.06477784f, -0.16841726f, 0.02518836f, -0.02708607f, 0.02889644f, -0.23822929f, -0.36438367f, -0.36589301f, 
    -0.08769240f, 0.10458395f, -0.08876121f, 0.07656296f, 0.00130697f, 0.03169046f, 0.00034024f, 0.45016673f, 
    -0.25745383f, 0.22634840f, 0.16894619f, -0.22505102f, 0.06754775f, 0.01139294f, 0.03334896f, 0.11437887f, 
    -0.01442498f, -0.09215941f, -0.12811129f, -0.20139077f, -0.14422473f, 0.02463779f, 0.04558157f, -0.16632700f, 
    -0.40803635f, -0.28466707f, -0.50832075f, 0.02178754f, 0.04690107f, 0.08924133f, 0.08543476f, -0.13131817f, 
    0.01025405f, 0.12945452f, -0.01409983f, -0.40535831f, -0.02280363f, 0.06638175f, 0.12586483f, -0.04087993f, 
    -0.06944343f, 0.00862535f, -0.23815034f, 0.50361168f, -0.18307920f, 0.11952751f, 0.23105088f, 0.01140463f, 
    0.05235751f, -0.02778709f, -0.10597404f, 0.53939843f, 0.05266907f, 0.13373202f, -0.01646758f, -0.06111095f, 
    0.44957507f, 0.17471999f, 0.14155205f, 0.04856796f, -0.06977376f, 0.04627876f, -0.24784316f, -0.11352812f, 
    0.00126575f, -0.18595637f, 0.10118783f, -0.08895620f, -0.00302469f, -0.27287409f, -0.42417660f, -0.18923198f, 
    -0.02014789f, -0.07154915f, -0.03730610f, 0.05983836f, 0.38373989f, -0.13741174f, 0.05214389f, 0.02571077f, 
    0.06303486f, -0.01065399f, -0.06157790f, -0.15012112f, 0.09332344f, -0.04862968f, 0.01489581f, 0.18835124f, 
    0.17308778f, -0.03245692f, -0.14676285f, -0.11854257f, -0.06790924f, -0.17314491f, 0.17849796f, 0.18918757f, 
    -0.43816683f, -0.09879041f, -0.80695486f, -0.05793395f, 0.01850065f, -0.13791935f, 0.03081840f, 0.08874076f, 
    -0.17640789f, 0.05275237f, -0.07347735f, -0.08873855f, -0.01850549f, -0.06707913f, -0.13508028f, 0.01696116f, 
    -0.16107558f, -0.10099403f, 0.03180706f, 0.11039746f, -0.05383196f, -0.05803681f, 0.06154514f, -0.19963209f, 
    0.00700583f, -0.04718680f, -0.25981173f, 0.03032966f, 0.14734533f, -0.01280217f, 0.09206176f, 0.06660512f, 
    0.18133266f, 0.14625922f, 0.03926542f, 0.07010541f, 0.22916608f, 0.00798089f, -0.02247479f, 0.04129269f, 
    0.02855049f, 0.06610046f, 0.13184513f, 0.11000399f, 0.16677883f, 0.16993155f, -0.05115169f, -0.06830724f, 
    0.12232659f, -0.03687385f, 0.04901963f, -0.09975908f, -0.06674612f, 0.02484943f, 0.12163070f, -0.01229010f, 
    0.03407702f, -0.09009663f, 0.08854038f, 0.07478958f, 0.00813322f, 0.08205500f, 0.09044955f, 0.14754839f, 
    0.24925420f, 0.32416505f, 0.07941200f, -0.08246497f, -0.11885846f, 0.02122346f, -0.04203198f, -0.16212077f, 
    -0.23379374f, 0.22559877f, -0.34394878f, -0.15133004f, -0.11068328f, -0.19180495f, -0.06233662f, 0.23100008f, 
    -0.02145616f, -0.34426156f, 0.18717420f, -0.23322535f, -0.07845531f, -0.01477381f, -0.07240352f, 0.06296282f, 
    0.01926749f, -0.17001645f, 0.05456132f, 0.08193719f, -0.08233383f, -0.00054738f, 0.24026483f, 0.15317121f, 
    0.11169373f, 0.03629754f, -0.02285153f, 0.08975919f, 0.16788982f, 0.07441433f, 0.06620494f, 0.27081424f, 
    0.02266293f, 0.28870726f, 0.38524038f, 0.16104166f, 0.06016095f, 0.04187990f, -0.15522198f, -0.10688218f, 
    0.03490224f, 0.00102456f, 0.16801725f, 0.07381822f, 0.05875456f, -0.06761035f, -0.03557054f, -0.08219579f, 
    0.14707133f, -0.01043458f, -0.04508751f, 0.01871996f, -0.13523799f, -0.13656554f, -0.24930875f, -0.02730649f, 
    0.05333273f, 0.14284447f, 0.03228415f, -0.08811849f, 0.14072534f, -0.03304908f, 0.17872995f, -0.03232721f, 
    0.09790614f, -0.13893792f, 0.01629372f, 0.05911524f, -0.20171356f, 0.28956577f, 0.03307384f, -0.09990361f, 
    0.09378085f, 0.10023635f, 0.18155438f, -0.14422858f, 0.20118986f, 0.28736252f, 0.04812517f, -0.05464536f, 
    -0.12874530f, -0.30559561f, -0.19373131f, -0.77426630f, -0.09740488f, -0.00163604f, -0.15128583f, 0.07043838f, 
    -0.06060913f, -0.05534105f, 0.12105147f, -0.27611461f, -0.09718465f, 0.01002203f, 0.25941539f, 0.32120550f, 
    0.06364826f, -0.13973294f, -0.11018117f, -0.39080349f, 0.27078667f, 0.10120834f, 0.05074126f, -0.04863253f, 
    0.09842430f, 0.17204586f, 0.06655480f, 0.13825051f, -0.12650429f, 0.09677500f, 0.08062311f, 0.11840574f, 
    0.14229789f, 0.13103567f, 0.10034797f, 0.04635862f, 0.17268305f, -0.27798244f, -0.27742815f, 0.27076781f, 
    0.01603467f, 0.08152773f, 0.07776485f, -0.07652383f, -0.01071144f, 0.22329530f, 0.28671664f, -0.09180097f, 
    -0.16185792f, -0.08314206f, 0.14244829f, 0.02259277f, 0.02491286f, 0.05997432f, 0.02557698f, 0.05730815f, 
    0.05204756f, -0.04229218f, -0.19354297f, -0.10180416f, -0.21899493f, 0.07650179f, 0.02197484f, 0.13602677f, 
    -0.14692393f, 0.35366982f, -0.31332761f, -0.18694909f, -0.28917310f, -0.29203981f, -0.24837697f, -0.23303255f, 
    -0.10932716f, -0.12036173f, -0.14325102f, -0.24286233f, -0.15889035f, -0.17459556f, 0.06335060f, 0.01497466f, 
    0.09678747f, 0.04946735f, -0.33391818f, -0.19640763f, -0.17779450f, 0.32549673f, -0.06848854f, 0.03678474f, 
    0.08662587f, -0.05318153f, 0.13107231f, -0.03705022f, 0.31152794f, 0.16190942f, 0.14652444f, -0.07049381f, 
    0.13679992f, 0.20210700f, 0.21595207f, 0.05966844f, -0.27766687f, 0.31982401f, 0.39586657f, -0.18760613f, 
    -0.05873194f, -0.28865010f, 0.08099729f, -0.06718109f, 0.04697647f, -0.27726468f, -0.24693868f, -0.38578317f, 
    0.04008347f, -0.25162011f, -0.00690932f, -0.00286023f, 0.09030562f, 0.20358880f, 0.16851456f, 0.14330493f, 
    0.08800565f, 0.05894852f, 0.03192848f, 0.00488631f, 0.20586938f, 0.02864255f, -0.03910431f, -0.03908122f, 
    0.15797141f, 0.11964060f, 0.02855772f, 0.11200698f, 0.11161941f, 0.14711533f, 0.09905731f, 0.08871822f, 
    -0.10014418f, 0.19085133f, -0.08480405f, -0.01507104f, -0.01787316f, 0.05923749f, -0.01997074f, -0.00531573f, 
    0.04615844f, 0.06277564f, -0.04461847f, 0.18003112f, 0.07713000f, -0.03725869f, 0.02975207f, 0.15883872f, 
    0.03823698f, 0.00294877f, -0.58554083f, 0.07833666f, 0.19350530f, -0.44299057f, 0.22543164f, -0.34521815f, 
    0.01296736f, -0.16888803f, 0.27224612f, -0.17176370f, 0.15826602f, 0.21980147f, 0.02986357f, -0.08262731f, 
    -0.12904245f, 0.25333780f, -0.07060608f, -0.23221944f, 0.37137628f, 0.18706840f, -0.08597151f, 0.19348425f, 
    0.04796299f, 0.17878442f, 0.06688660f, 0.00961105f, -0.12798658f, 0.14808807f, 0.04775944f, 0.16018087f, 
    0.08880565f, -0.10709195f, -0.08398245f, 0.18866201f, 0.01159015f, -0.10010105f, 0.20311610f, 0.02778215f, 
    0.02968258f, 0.20798980f, 0.08761549f, 0.08478466f, 0.22558491f, -0.03779842f, 0.04266349f, -0.65649843f, 
    -0.14470640f, -0.01905824f, -0.19352749f, 0.05258386f, -0.28581870f, -0.15490091f, -0.09098685f, -0.12556355f, 
    -0.39174834f, 0.16839202f, -0.21600689f, 0.02401571f, 0.22236979f, 0.10592053f, -0.02113298f, -0.03163229f, 
    0.22366682f, -0.38252127f, 0.00931915f, 0.23712015f, 0.17885073f, -0.18859516f, -0.17807433f, -0.08383461f, 
    -0.07047353f, -0.15772399f, -0.05197158f, 0.17244586f, 0.18392842f, 0.08672294f, -0.11790911f, -0.03564592f, 
    0.05881828f, 0.01458761f, -0.07364029f, 0.07878074f, -0.01542967f, 0.18444303f, 0.17618442f, 0.06818856f, 
    0.03796660f, 0.18859775f, 0.12910734f, 0.09175193f, -0.07052290f, 0.29639190f, 0.38371435f, 0.05903677f, 
    -0.09986112f, -0.02540863f, 0.00397604f, -0.03817601f, -0.25562498f, -0.38755706f, 0.11517174f, 0.31201413f, 
    -0.02197617f, -0.09715151f, -0.24094157f, -0.07745459f, 0.10695077f, -0.13575572f, -0.07425517f, 0.26174748f, 
    0.45628515f, 0.10792329f, -0.09777161f, -0.29869863f, 0.02966817f, -0.00479635f, 0.11023054f, -0.01228624f, 
    0.06786373f, 0.27720034f, 0.01516463f, 0.02681896f, -0.01143322f, 0.04327854f, -0.08608939f, -0.00362035f, 
    -0.09734038f, -0.04343493f, 0.10666430f, 0.11351603f, -0.24878043f, 0.14229736f, 0.18248835f, 0.14078863f, 
    -0.14733484f, -0.07213868f, 0.06612679f, 0.48591539f, 0.18657325f, 0.37946379f, -0.10654132f, -0.00773843f, 
    0.10171742f, 0.39738190f, -0.35520193f, -0.31962615f, -0.30126798f, -0.20490398f, -0.41515806f, -0.11956535f, 
    0.05327959f, -0.13231808f, -0.02853896f, -0.66788512f, -0.45630789f, -0.12986349f, 0.46162206f, 0.13490976f, 
    -0.18498047f, 0.15980706f, 0.12064752f, -0.09410056f, 0.15048857f, 0.14807241f, 0.04156843f, 0.11322337f, 
    -0.11483092f, -0.09933748f, -0.08114517f, -0.37481225f, -0.34066617f, 0.33298647f, -0.04882392f, -0.50193942f, 
    -0.03971356f, 0.01625203f, 0.28478232f, 0.06062494f, -0.17605177f, -0.06857771f, 0.17936866f, 0.37140480f, 
    0.23225865f, 0.17564176f, -0.16634206f, -0.02210159f, -0.04730275f, -0.16476321f, -0.20162638f, 0.11109901f, 
    0.11254992f, -0.06124743f, 0.05091392f, 0.08967787f, 0.17124863f, 0.18024842f, -0.01433479f, -0.15910225f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.01457779f, 0.34718591f, 0.00260661f, -0.09319060f, -0.24350420f, -0.12073383f, 0.27987099f, 0.23802944f, 
    0.05783190f, -0.01293676f, 0.23385477f, -0.11055394f, 0.03507238f, 0.12130281f, -0.01881273f, 0.12830913f, 
    -0.08794846f, 0.01200339f, -0.02352621f, 0.08128130f, 0.17407911f, -0.00964850f, -0.02511327f, 0.01597417f, 
    0.31705990f, -0.04152554f, 0.03953135f, -0.05057520f, 0.22324388f, 0.27602226f, 0.21787523f, 0.35822105f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.16603185f, -1.20453346f, -0.32971519f, 0.22138514f, 0.45621294f, 0.48370191f, -0.23392993f, 0.19674481f, 
    -0.36533099f, 0.00868006f, -0.10095383f, 0.35130605f, -0.09983067f, 0.10548489f, 0.39949924f, 0.30986258f, 
    -0.19401075f, -0.14123654f, -0.11281115f, -0.26346579f, -0.49963540f, -0.01935440f, 0.14108106f, 0.03744756f, 
    0.05668146f, 0.05347273f, 0.33160055f, -0.10928066f, 0.14452171f, 0.15057057f, -0.12608191f, -0.14199245f, 
    -0.17559278f, 0.08239463f, -0.35035947f, -0.13638043f, -0.25142178f, 0.66070771f, 0.17364709f, -0.09077848f, 
    -0.12983403f, 0.09989008f, -0.18131569f, 0.01728316f, -0.05936906f, 0.50155431f, 0.00016887f, 0.39551929f, 
    -0.17918140f, -0.05355706f, -0.12033855f, 0.04792285f, -0.05562372f, -0.15876086f, -0.21581690f, -0.06050159f, 
    0.12132594f, 0.07313558f, 0.16345297f, -0.09125438f, 0.30903789f, 0.02190380f, 0.24837181f, -0.04880232f, 
    0.04791937f, 0.60519224f, -0.06141617f, 0.13633493f, -0.24818851f, -0.73273599f, 0.11323394f, -0.60842085f, 
    -0.10939374f, -0.16603076f, -0.44657823f, -0.12200799f, 0.05246544f, 0.49053648f, -0.41263634f, -0.42620003f, 
    0.19453575f, -0.08672915f, -0.13793845f, -0.31921557f, -0.32726780f, -0.14352725f, 0.23559380f, -0.16950464f, 
    0.15485145f, -0.01142525f, 0.07369232f, 0.14755265f, 0.12946129f, 0.80954963f, -0.20481989f, 0.05532944f, 
    0.03844778f, -0.41807580f, 0.47359666f, 0.39829087f, -0.14473455f, 0.04144845f, 0.13438696f, -0.40085810f, 
    -0.06582513f, 0.15675160f, 0.35387573f, -0.12530448f, 0.05844051f, 0.11499621f, -0.05703960f, -0.79231101f, 
    0.40563935f, -0.01196280f, 0.06679969f, -0.29629117f, -0.08452387f, -0.15848352f, 0.19875784f, -0.74305212f, 
    -0.85042232f, 0.12516904f, 0.62045038f, -0.11720878f, -0.47639510f, -0.69116509f, -0.62698764f, -0.22251286f, 
    -0.12348455f, 0.53990918f, 0.09471583f, -0.16505323f, 0.16167130f, 0.12331237f, -0.43141279f, 0.35476911f, 
    -0.12915479f, -0.02897586f, -0.18851791f, 0.33830771f, -0.00884155f, -0.38935602f, 0.12543520f, 0.16589355f, 
    0.07980917f, -0.04113480f, -0.04164233f, 0.06465304f, 0.27838966f, -0.15452784f, 0.29458687f, -0.07159437f, 
    -0.98085928f, -0.12580277f, -0.02923174f, 0.02686791f, 0.08202254f, -0.33610791f, -0.12588850f, 0.23537521f, 
    0.06615913f, 0.33911249f, 0.25053400f, 0.01309100f, 0.13191286f, -0.50677109f, 0.08426692f, 0.16194966f, 
    0.07242509f, -0.14129084f, -0.34402677f, -0.12439560f, 0.16874991f, 0.16257165f, 0.56318885f, -0.07316540f, 
    -0.38326669f, -0.02939409f, -0.00728490f, 0.45140612f, -0.33083743f, -0.01947815f, -0.36197901f, 0.41670480f, 
    -0.15847848f, -0.03766689f, -0.02736271f, 0.07372601f, 0.12985328f, -0.09081218f, -0.24242027f, -0.24677290f, 
    -0.04849737f, -0.70835185f, 0.11559723f, 0.29189003f, -0.20191175f, -0.37881246f, -0.05364826f, -0.06648732f, 
    -0.27406287f, 0.07985826f, -0.06450392f, -0.67542070f, -0.13437596f, -0.84359998f, -0.56609416f, -0.41986373f, 
    -0.00665284f, 0.16023557f, -0.04519336f, 0.15480693f, 0.26179159f, 0.05865469f, 0.36500698f, -0.15582661f, 
    -0.29406089f, -0.15479678f, -0.49037433f, -0.00979747f, -0.41936821f, 0.79439169f, 0.37667802f, 0.32097030f, 
    -0.00167148f, -0.81540638f, -0.17505001f, 0.15359783f, -0.17524597f, -0.21838866f, -0.15293190f, 0.01502954f, 
    -0.22665505f, 0.03752278f, 0.78432405f, 0.60802227f, -0.02754673f, -0.49738055f, -0.38144884f, -0.09778720f, 
    0.11999090f, -0.00742086f, -0.01068978f, -0.14775325f, -0.00887844f, -0.12098440f, 0.07100099f, 0.19391367f, 
    0.04246331f, -0.01768300f, 0.26117679f, -0.02641041f, 0.08196864f, -0.53541791f, 0.04719076f, -0.28552377f, 
    0.00064865f, 0.05267492f, -0.23146400f, -0.61028188f, 0.15433879f, -0.10279301f, 0.26364034f, -0.66136825f, 
    0.23552486f, 0.01076164f, 0.58124268f, -0.22207542f, 0.03140707f, 0.04602547f, -0.29446870f, -0.21024880f, 
    -0.24235165f, -0.05392223f, 0.07180280f, 0.30485189f, 0.05326769f, -0.14500268f, 0.00881271f, 0.34894609f, 
    0.50546068f, -0.10529485f, -0.19135037f, 0.04846439f, -0.13466656f, -0.03888407f, -0.13415882f, -0.23448837f, 
    0.08074850f, 0.59801394f, -0.45036548f, 0.03277559f, -0.55364579f, -0.17882861f, 0.20809749f, 0.62796253f, 
    -0.18007977f, 0.17694807f, -0.54000026f, -0.27473539f, 0.09587981f, -0.31052804f, 0.06367397f, -0.65913045f, 
    0.17544673f, 0.00179409f, -0.11416923f, -0.63307506f, 0.56858760f, -0.11784820f, 0.28466144f, -0.10447939f, 
    0.00050311f, 0.12778348f, 0.18984777f, 0.06757019f, -0.07465156f, -0.43820730f, -0.29912424f, 0.47719926f, 
    0.12694305f, -0.09421956f, 0.44253555f, -0.15630852f, 0.33131889f, -0.92730063f, 0.20184201f, 0.61889714f, 
    0.33961219f, 0.16399437f, -0.33045870f, 0.14530586f, 0.13614304f, 0.27120692f, -1.12613332f, -0.08859462f, 
    0.06271891f, 0.13924848f, -0.01734974f, -0.17218129f, -0.13270776f, -0.02797153f, -0.49293879f, -0.17336199f, 
    -1.00052750f, -0.13938455f, -0.33616009f, 0.03980357f, -0.44023505f, -0.03114951f, 0.11261766f, -0.51132631f, 
    -0.08591180f, -0.15629636f, 0.25931337f, 0.34174034f, -0.24582598f, -0.16223650f, 0.01318619f, -1.22287738f, 
    0.32011729f, 0.02094980f, -0.49608004f, -0.72938699f, 0.10541404f, -0.48878875f, -0.13317077f, 0.44393042f, 
    0.18908904f, 0.03744861f, 0.14032724f, -0.57295734f, 0.02562231f, 0.14795780f, -0.12373776f, -0.53081334f, 
    0.71920067f, 0.02709817f, -0.62726808f, -0.11645364f, 0.01277338f, -0.27421337f, 0.02015392f, -0.01319368f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.25039515f, 0.12640011f, -0.11788427f, 0.15003876f, -0.19331901f, -0.07455160f, 0.02977567f, -0.44929558f, 
    0.02447235f, 0.16900665f, 0.09457289f, 0.15626279f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
