#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.30337676f, -0.75786555f, -0.05435347f, 0.50742435f, 0.52203947f, 0.67177087f, -0.11960912f, -0.36139908f, 
    -0.24371697f, 0.18997826f, -0.30858639f, 0.06135476f, -0.16955569f, -0.01839311f, 0.38116112f, -0.31011391f, 
    -0.08386295f, 0.16089550f, 0.10380992f, -0.13286929f, 0.19142956f, -0.11526594f, -0.27380186f, -0.10314108f, 
    0.14258835f, -0.05281654f, 0.61465681f, 0.84317261f, -0.61222315f, -0.44861338f, -0.06676858f, -0.08354848f, 
    0.24822733f, 0.17372075f, -0.15517920f, -0.25542048f, -0.57469487f, 0.11406007f, 0.03505826f, -0.02905670f, 
    -0.09491280f, -0.12569954f, 0.04495442f, -0.07223992f, -0.19258820f, -0.49602908f, -0.41876304f, -0.65089530f, 
    -0.78863174f, -0.95993507f, -0.98221719f, 0.06795385f, 0.14773311f, 0.57533795f, 0.49984574f, 0.36869091f, 
    -0.02155278f, -0.34643778f, -0.13615696f, 0.38414028f, 0.25963125f, 0.08360748f, -0.21723704f, -0.25541002f, 
    0.03966454f, 0.00489328f, -0.16464099f, 0.11974118f, 0.02804335f, 0.16636091f, -0.05485322f, -0.37791693f, 
    0.13986625f, 0.07874376f, -0.41851336f, -0.23336728f, -0.80313760f, -0.53276247f, -0.60403895f, -0.57939339f, 
    0.37903970f, 0.39718378f, 0.04125170f, 0.08941604f, -0.20726764f, -0.33602658f, -0.32962033f, -0.53837419f, 
    0.31153247f, 0.22431856f, -0.12628156f, -0.31514782f, -0.24726315f, -0.32397056f, -0.64674485f, -0.22259559f, 
    -0.32824484f, -0.13379569f, -0.44745451f, -0.44547871f, 0.26353922f, -0.05549103f, -0.05249155f, 0.18396676f, 
    -0.36095291f, 0.00600684f, -0.12663317f, 0.10706162f, 0.05659277f, -0.18843013f, 0.06480359f, 0.52271169f, 
    -0.31864044f, -0.04155577f, -0.10969800f, -0.22209249f, -0.00574628f, 0.01578347f, 0.18793705f, -0.04189651f, 
    0.24573243f, 0.05174115f, -0.08645763f, 0.35554555f, 0.35732630f, -0.99621272f, -0.68069661f, -0.59843069f, 
    -0.09812514f, -0.58603603f, 0.75896472f, 0.23697175f, -0.12955290f, 0.33436164f, 0.76184648f, 0.25589833f, 
    0.18049161f, 0.04044146f, 0.06743305f, -0.23079421f, -0.17994350f, 0.02576767f, -0.25658190f, -0.10772561f, 
    -0.09289011f, -0.36611831f, -0.07682998f, -0.11679231f, -0.15465294f, -0.20545137f, -0.47378924f, -0.02639361f, 
    -0.30428126f, -0.44280991f, -0.20484360f, 0.36311215f, 0.33558497f, -0.03504347f, 0.45825189f, 0.10498163f, 
    -0.02721662f, 0.70788801f, -0.32413664f, 0.07379963f, -0.56491095f, -0.41406909f, -0.32020134f, -0.11294650f, 
    0.06028038f, -0.22662646f, 0.22154839f, 0.54286885f, 0.18116830f, 0.23389398f, 0.22311611f, -0.01624515f, 
    -0.97773045f, -0.65401036f, -0.67533541f, -0.08755607f, -0.28793329f, -0.21518260f, 0.69074148f, -0.55996937f, 
    -0.75449610f, -0.25330338f, 0.08614621f, -0.35396698f, -0.04177357f, -0.24732034f, 0.14393708f, -0.49496633f, 
    -0.05368453f, 0.23705286f, -0.07151140f, -0.37606245f, 0.25313371f, 0.10174145f, -0.27787846f, 0.06508341f, 
    0.76148379f, 0.40677786f, -0.01303478f, -0.11950649f, -0.82592827f, -0.22808616f, -0.64971757f, 0.30760682f, 
    0.73368007f, 0.12694864f, -0.39031434f, -0.59968632f, -0.21847269f, 0.06803843f, -0.08110523f, 0.02645751f, 
    0.05285385f, -0.14315872f, 0.27282751f, 0.08766798f, -0.39804786f, 0.11387197f, -0.04004528f, -0.13715059f, 
    0.17745645f, 0.95781088f, -0.18086195f, -1.01349223f, -1.09460557f, -0.96432853f, 0.75734025f, 0.27026138f, 
    0.69883150f, -0.03446275f, -0.25376227f, -0.17178768f, -0.28177992f, -0.11325958f, -0.01819818f, -0.33037904f, 
    -0.54212785f, -0.21333310f, 0.54979479f, -0.41553563f, -0.40316790f, -0.07760864f, 0.03284318f, 0.17494176f, 
    0.25329006f, 0.02165052f, -0.56811583f, -1.07699144f, -0.84402066f, -0.24791153f, -0.51716101f, -0.02454476f, 
    0.39480299f, 0.18890557f, -0.51346809f, -0.72517735f, 0.64518756f, 0.39513975f, 0.28843737f, 0.19128676f, 
    0.37914768f, -0.07870366f, -0.40794116f, -0.05847585f, -0.12519683f, -0.28956184f, 0.01566120f, -0.23578209f, 
    0.23240764f, 0.13870892f, -0.12837911f, -0.48839569f, 0.12617321f, -0.04357142f, -0.50252384f, -0.26667917f, 
    0.59690267f, 0.32015088f, -0.29678193f, -0.46471241f, -0.34191692f, 0.37376451f, 0.86297733f, -0.31102914f, 
    -0.39243707f, -0.36184624f, -0.71059769f, -0.37677789f, 0.00648622f, -0.37367862f, -0.39293712f, -0.02997695f, 
    -0.09064986f, 0.26954356f, -0.11220431f, -0.19871897f, 0.63817418f, 0.08790344f, 0.02157354f, 0.04911213f, 
    -0.57068634f, 0.24647160f, -0.11300992f, -0.27448094f, 0.03561351f, 0.46295342f, 0.27894038f, -0.08193891f, 
    -0.24185057f, -0.26687825f, 0.04604939f, -0.32135957f, 0.02739437f, 0.20604746f, 0.19326946f, -0.20417769f, 
    -0.34238127f, 0.08814136f, 0.25413048f, 0.07345643f, -0.06391703f, 0.60695893f, 0.35150433f, 0.65230370f, 
    -0.75515962f, -0.66655058f, -0.19258885f, 0.23622118f, -0.34651726f, -0.72370249f, 0.70067644f, 0.02370811f, 
    -0.08414945f, 0.48845720f, -0.23975369f, -0.26545367f, 0.05083610f, 0.11047918f, 0.30160144f, 0.28894481f, 
    -0.50067049f, -0.05356370f, 0.45973647f, -0.08781673f, 0.01157185f, -0.06583625f, 0.28238463f, 0.21393754f, 
    0.03858170f, 0.00351543f, -0.31224510f, -0.24541731f, 0.20901847f, 0.51421231f, -0.30015010f, -0.10147980f, 
    0.55332190f, -0.17665429f, -0.05380995f, 0.04323442f, -0.22620091f, 0.58955669f, -0.14756946f, -0.34396106f, 
    -0.19994761f, -0.13366178f, 0.08716215f, 0.24433659f, -0.32060131f, 0.10338505f, 0.38774201f, -0.76409853f, 
    -0.58894974f, -0.09112200f, 0.68803000f, 0.58390266f, -0.29213929f, -0.34565133f, -0.75801927f, -0.55915344f, 
    -0.00662596f, -0.16657455f, -0.31537971f, -0.22611387f, -0.27006665f, 0.34473962f, 0.10945211f, -0.02881543f, 
    0.27826694f, 0.45265937f, 0.47750741f, -0.06008116f, -0.29059634f, -0.26906535f, -0.27806464f, -0.39958605f, 
    0.03812462f, 0.34357250f, 0.31336123f, 0.10096396f, -0.02938238f, 0.50639683f, 0.60097718f, 0.29359666f, 
    0.16245596f, 0.19536920f, 0.02919352f, -0.12468252f, -0.03321401f, -0.17321555f, -0.33704326f, 0.02555541f, 
    -0.14451602f, -0.02766808f, -0.10200232f, -0.07447860f, 0.25610429f, -0.07718250f, -0.05424133f, 0.12404045f, 
    0.41496187f, -1.14323771f, -0.21023425f, -0.75095016f, -0.67839009f, -0.61956650f, -0.06057986f, 0.25989330f, 
    -0.87300807f, -0.65713751f, 1.19611025f, -0.21193737f, 0.08043645f, -0.47490001f, -0.62055635f, 0.16867717f, 
    0.05297277f, 0.48245552f, -0.12022293f, -0.21949387f, -0.23067559f, -0.11404931f, -0.28915522f, -0.12397739f, 
    0.11809079f, 0.16572884f, -1.16743004f, -0.39985874f, -0.24329558f, 0.73138517f, 0.83107704f, 0.28850281f, 
    -0.05463328f, -0.02131880f, 0.31583837f, -0.06628212f, -0.56344342f, -0.43066612f, -0.32287091f, 0.53604627f, 
    -0.74907368f, 0.10959430f, -0.35479495f, 0.21172523f, -0.36092502f, -0.30201772f, 0.14531675f, 0.18991071f, 
    -0.14101383f, -0.03526033f, 0.10778442f, 0.24488981f, 0.28076062f, 0.02392869f, -0.07873978f, 0.18296845f, 
    -0.48480630f, 0.21351819f, 0.06383302f, 0.21916470f, 0.23287480f, 0.13177474f, -0.34560493f, 0.09084261f, 
    0.40844449f, 0.15992677f, 0.24049550f, -0.20220785f, -0.22617829f, 0.30094013f, -0.47462523f, -0.03377671f, 
    0.32044241f, 0.11345845f, 0.28977308f, -0.56393510f, -1.08325672f, -0.17419295f, -0.43421471f, -0.37932026f, 
    0.33248392f, -0.14731736f, -0.36716056f, 0.26805207f, 0.82357073f, 0.50590557f, -0.09506048f, -0.21133852f, 
    -0.42633820f, 0.14999861f, 0.60406679f, -0.22995184f, -0.20425734f, 0.22874747f, 0.11178088f, -0.27170336f, 
    0.03083399f, 0.32091275f, 0.40576547f, 0.09398076f, -0.19092427f, 0.49257562f, 0.19924226f, -0.15578485f, 
    -0.27500895f, 0.35242489f, -0.18974191f, -0.12940691f, -0.15775155f, 0.05431008f, 0.17646289f, -0.04097660f, 
    -0.07828242f, 0.10426789f, 0.13852392f, 0.14664912f, 0.31061167f, 0.00798107f, -0.16734266f, 0.10206232f, 
    0.07878859f, 0.03171278f, 0.28615919f, 0.16335985f, 0.03818740f, -0.12809838f, -0.43790656f, 0.71017879f, 
    0.27793208f, 0.04884109f, -0.65868556f, -0.85276735f, -0.35000172f, 0.26528585f, 0.45741606f, -0.65652233f, 
    -0.07062132f, -0.23375969f, 0.32289186f, 0.24932274f, -0.64738309f, 0.38224572f, -0.23704492f, -0.13872132f, 
    -0.26321930f, 0.12542087f, 0.05133668f, 0.13053386f, -0.37672305f, 0.32339880f, 0.13562112f, -0.59818518f, 
    -0.77001894f, -0.29729459f, 0.22911943f, -0.12554225f, 0.60634667f, 0.26402715f, -0.01969847f, 0.47888580f, 
    0.64553857f, 0.40698209f, -0.26434642f, -0.10319518f, -0.20008187f, -0.10183495f, -0.25600663f, 0.06562336f, 
    0.12930021f, 0.04701871f, -0.16495815f, -0.23941934f, -0.01004349f, 0.01148463f, 0.00628116f, 0.26673979f, 
    -0.54925758f, -0.60595274f, -0.70117098f, -0.66877478f, -0.43218046f, -0.53802419f, -0.78250134f, -0.80770230f, 
    -1.02145898f, -0.63697499f, -0.21784160f, 0.19696566f, 0.17248790f, 0.08743905f, -0.19791220f, -0.08518808f, 
    0.07406806f, -0.20105194f, -0.29764384f, -0.10003860f, -0.08118831f, 0.09534908f, 0.42555144f, 0.09499683f, 
    0.22793315f, 0.40563983f, -0.29126292f, -0.20032920f, 0.63694155f, 0.27608851f, -0.36606494f, -0.25714305f, 
    -0.48775309f, -0.58601463f, -0.10391885f, 0.18777899f, -0.02747046f, 0.09397341f, 0.30828166f, 0.05454171f, 
    -0.01693641f, 0.30523723f, -0.09513535f, -0.19683102f, 0.11301873f, 0.13736367f, -0.11284035f, 0.35378480f, 
    0.26991868f, 0.02066962f, 0.51754814f, 0.41748467f, 0.08462396f, -0.22068284f, -0.14217357f, -0.38383147f, 
    -0.80544227f, -0.36132741f, -0.83060604f, -1.23855197f, 0.40045494f, -0.07570431f, -0.19689484f, 0.22385961f, 
    -0.30145887f, -0.17650905f, -0.56215668f, -0.44356862f, -0.39736572f, -0.07083975f, -0.44448218f, -0.31205538f, 
    -0.11956514f, -0.33381093f, -0.21468386f, 0.98737139f, -0.26209071f, -0.16710232f, -0.10609689f, 0.58619362f, 
    0.27326274f, 0.69911999f, -0.48086762f, -0.79945821f, -0.80279362f, -0.35623109f, -0.34314349f, 0.18543844f, 
    -0.27338114f, 0.23925346f, -0.35644755f, 0.08739015f, 0.22952528f, -0.25462884f, 0.16594416f, -0.00299554f, 
    -0.01952673f, 0.13894670f, -0.04579613f, -0.08960839f, 0.71161968f, 0.80336237f, 0.09322606f, -0.24251057f, 
    -0.35698143f, -0.23016937f, 0.11248149f, -0.00563400f, -0.12653677f, -0.27449614f, 0.07857974f, -0.02670559f, 
    -0.68396991f, -0.53414863f, 0.49598983f, 0.24804132f, 0.32228574f, -0.08393770f, 0.19106971f, -0.32965624f, 
    0.02035914f, -0.33107263f, -0.08706798f, -0.01411574f, -0.22444442f, 1.04021859f, -0.42876095f, -0.11042777f, 
    0.19983487f, 0.20908463f, -0.03848630f, 0.13293464f, 0.33759421f, 0.11305428f, -0.19647342f, -0.35804382f, 
    0.53263760f, -0.07882104f, -0.48208606f, -0.08033597f, -0.25375932f, 0.13825059f, -0.08041625f, -0.28705314f, 
    -0.40935075f, 0.05117343f, 0.29378766f, 0.03138472f, -0.10403794f, -0.00984676f, 0.65585512f, -0.67474061f, 
    -0.87794334f, -0.58267200f, -0.62040192f, 0.63160479f, 0.54409337f, 0.36173448f, 0.10186175f, 0.29037726f, 
    -0.05234121f, -0.21357891f, -0.09961206f, 0.35986370f, 0.04097632f, -0.32514891f, 0.07795800f, -0.08022440f, 
    0.32117122f, -0.23938876f, 0.18206993f, -0.23525149f, 0.15092750f, 0.07143819f, -0.02411102f, -1.25513983f, 
    0.16274536f, -0.36148879f, -1.10957742f, -0.73367459f, 0.05687133f, -0.08877099f, 0.06732288f, -0.03508771f, 
    0.20679423f, -0.14192063f, -0.04992648f, -0.39516750f, -0.55236107f, -0.34751242f, 0.25715744f, -0.22766423f, 
    -0.17011893f, 0.04456494f, -0.00963802f, -0.01589612f, -0.14367504f, -0.38209978f, -0.26196110f, -0.58081108f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.48974982f, 0.04638939f, 0.34858882f, -0.03901776f, -0.21333313f, 0.08349486f, -0.01254826f, 0.19525115f, 
    0.38773397f, 0.05061873f, 0.34635407f, 0.09110146f, 0.43694171f, 0.36263773f, 0.15893835f, 0.07765998f, 
    -0.13620180f, -0.16513525f, -0.05856595f, 0.21689036f, 0.56871837f, 0.14225633f, 0.36954656f, 0.26449752f, 
    -0.44702157f, 0.16084121f, -0.06467435f, 0.22547734f, 0.25606227f, 0.55477148f, 0.39450067f, -0.34308299f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.48409164f, -0.16311735f, -0.20553754f, -0.04328175f, -0.05915894f, -0.15953495f, 0.10280472f, 0.01562059f, 
    0.05158193f, -0.00343250f, 0.01890506f, 0.01729658f, -0.55100852f, -0.30870393f, 0.13163224f, 0.07602959f, 
    0.03355191f, 0.00667151f, -0.10756458f, -0.00793552f, -0.02707061f, -0.04352633f, 0.01323540f, 0.17409128f, 
    -0.04102739f, 0.03296003f, 0.12923141f, 0.03966671f, 0.00358860f, -0.02248613f, 0.04420386f, 0.05410784f, 
    -0.09974941f, -0.14761937f, -0.08103970f, 0.07642375f, 0.24847563f, -0.02091827f, -0.09136853f, -0.08349685f, 
    0.17257003f, 0.07055181f, -0.15168899f, -0.14295940f, -0.09732923f, -0.14970671f, 0.08219686f, 0.21232486f, 
    0.00471751f, 0.02658165f, 0.01200779f, 0.11382910f, -0.17393127f, 0.00284163f, -0.11495386f, -0.08762050f, 
    -0.01933790f, 0.07108299f, -0.02400096f, -0.05405425f, 0.28096658f, 0.15951636f, -0.06122213f, 0.02453804f, 
    0.15104465f, 0.10201152f, 0.08573221f, -0.03700994f, 0.12570089f, 0.17590320f, 0.00670775f, 0.02828759f, 
    -0.04408324f, -0.05591762f, -0.13870296f, -0.05262257f, 0.13875499f, 0.22985949f, -0.00066253f, 0.05483491f, 
    0.00905623f, -0.17958854f, -0.12911625f, -0.06739858f, 0.38573304f, 0.07804127f, -0.13772610f, -0.04949132f, 
    0.14313844f, 0.10287148f, 0.20356345f, 0.11266559f, -0.07023542f, -0.02509844f, -0.09914753f, 0.00300381f, 
    -0.86414123f, 0.06038286f, 0.23836756f, -0.31138575f, 0.02756751f, 0.08032486f, -0.07626660f, -0.00368711f, 
    0.02149973f, -0.09889188f, -0.13364488f, -0.07860317f, 0.11996258f, -0.35143393f, -0.60593402f, 0.13820294f, 
    0.07375465f, 0.12126280f, -0.34691897f, -0.14360745f, 0.04158600f, -0.03142496f, -0.26005924f, -0.01118819f, 
    0.39677501f, 0.18441647f, -0.31181696f, -0.12341938f, 0.08498224f, 0.10508215f, 0.01075734f, -0.23283146f, 
    -0.21197180f, -0.13254039f, -0.11957303f, -0.01863620f, 0.24083138f, -0.08512849f, -0.25450164f, -0.06373212f, 
    0.02904648f, 0.10599449f, -0.06575556f, -0.07208037f, -0.19705220f, -0.11283486f, -0.25995901f, 0.00889434f, 
    -0.13918118f, -0.44479620f, -0.40646797f, -0.03089152f, -0.09712794f, -0.03937756f, -0.00551551f, -0.01215975f, 
    -0.28186306f, -0.19379424f, -0.12962075f, -0.00015653f, 0.02541454f, -0.15591095f, -0.31744537f, 0.03343333f, 
    -0.04917960f, -0.20132214f, -0.10566583f, -0.18496928f, -0.08489845f, -0.08505940f, -0.06553712f, 0.07930527f, 
    -0.17357396f, -0.08702855f, -0.06122939f, 0.18417259f, -0.08078803f, 0.04858211f, 0.01929002f, 0.01662130f, 
    -0.14765045f, -0.00865859f, -0.23499221f, -0.21829674f, 0.61479145f, 0.33255410f, 0.12085707f, -0.27476838f, 
    0.12763010f, 0.10450790f, 0.08818258f, 0.17859556f, -0.01979909f, 0.02897426f, 0.00313500f, -0.00335814f, 
    0.09519345f, 0.00152074f, -0.11964609f, -0.14667489f, 0.04950752f, 0.10061997f, 0.03534865f, 0.13179000f, 
    -0.00359606f, 0.09305053f, 0.06710280f, 0.12718451f, 0.24068148f, 0.37354973f, 0.10356213f, -0.11780433f, 
    0.08551954f, 0.19676219f, -0.09479615f, 0.05787821f, -0.08060049f, -0.02170545f, 0.00858321f, -0.05476388f, 
    0.50428563f, 0.06615028f, 0.29156962f, -0.04900567f, -0.00878237f, -0.03403251f, 0.16428752f, 0.13369498f, 
    0.02014793f, 0.01536182f, -0.18107924f, -0.20477448f, -0.15852804f, -0.10888990f, 0.03087449f, 0.12615249f, 
    0.03093700f, -0.03804472f, 0.05147404f, -0.09159701f, -0.10182864f, -0.11541951f, -0.40642154f, -0.20218699f, 
    0.05497849f, 0.03781494f, 0.16502319f, -0.26324806f, -0.06259857f, 0.09253696f, -0.01003140f, -0.13093042f, 
    -0.02522875f, -0.02827644f, -0.06436962f, -0.12600994f, -0.01460172f, 0.04789577f, -0.00242300f, 0.01174248f, 
    -0.23749413f, -0.26126271f, -0.05324133f, -0.02653755f, -0.09072877f, -0.09701674f, -0.12391819f, 0.00799548f, 
    -0.07352990f, 0.01337037f, 0.28937489f, -0.16190442f, -0.14106561f, -0.01192165f, -0.02178858f, -0.11405047f, 
    0.01737893f, -0.09209776f, -0.03752792f, -0.17360912f, -0.02451607f, 0.01041257f, 0.02561728f, 0.01185402f, 
    0.09754385f, 0.06900723f, 0.10321210f, -0.07633170f, 0.12315857f, 0.00520241f, -0.10302014f, -0.19159518f, 
    0.42043921f, 0.32055101f, -0.15662865f, -0.30080539f, 0.11433871f, 0.09638128f, 0.06140402f, 0.09120912f, 
    -0.10612460f, -0.08526380f, 0.05638499f, -0.06164999f, 0.06788088f, 0.12102170f, 0.01233398f, -0.08126393f, 
    0.00585967f, -0.09086009f, -0.07219044f, -0.06019730f, -0.01286511f, 0.08246360f, -0.01691487f, -0.00617324f, 
    0.31670013f, 0.11603085f, -0.15440352f, -0.04197498f, -0.35105383f, -0.32082587f, -0.15887682f, 0.14856225f, 
    -0.07332403f, 0.03833120f, -0.00572176f, -0.00538114f, 0.38875061f, -0.50589484f, -0.49364054f, 0.12897496f, 
    -0.07552720f, -0.43269229f, 0.11355193f, -0.09686703f, -0.04219115f, 0.07311563f, 0.04349168f, 0.06224563f, 
    -0.55055583f, -0.04908679f, -0.14093035f, 0.03050054f, -0.04057657f, 0.00395318f, -0.10416597f, -0.12408055f, 
    -0.03184074f, -0.01815969f, 0.05713753f, -0.00769480f, -0.66264272f, -0.83022714f, -0.41081506f, 0.16198705f, 
    -0.03945699f, 0.02742993f, 0.04687737f, 0.05240679f, 0.01087029f, 0.01643839f, 0.02126492f, -0.10005306f, 
    0.15280052f, -0.28312707f, -0.38288650f, 0.12885119f, 0.16428311f, 0.09392774f, -0.22914483f, -0.19602385f, 
    0.03050634f, -0.06314370f, -0.15271585f, -0.12064212f, 0.10311122f, 0.39975914f, 0.08889408f, -0.05982937f, 
    0.10038193f, 0.44301936f, 0.03523988f, 0.21483122f, -0.08753230f, -0.00355805f, 0.04039889f, 0.02817829f, 
    0.28305230f, 0.18962808f, -0.14525582f, 0.22719768f, -0.04288767f, 0.05266313f, -0.04595578f, -0.04468815f, 
    0.12543966f, 0.09962695f, 0.01341652f, 0.00869167f, -0.00727279f, -0.00668019f, 0.11966939f, -0.12654287f, 
    0.03275963f, 0.01239988f, -0.13095051f, -0.02248738f, -0.40652546f, -0.18324828f, -0.13082676f, -0.34718320f, 
    0.10584830f, 0.12015183f, -0.00903619f, 0.09884931f, -0.02939985f, -0.00938602f, -0.00556939f, 0.09166255f, 
    -0.03288804f, -0.04779161f, 0.02307804f, 0.12441093f, 0.07614973f, -0.06522939f, 0.10984805f, 0.06614671f, 
    0.10368328f, 0.10002030f, 0.02836284f, -0.08380067f, -0.00979758f, 0.18342112f, -0.08782030f, -0.32731968f, 
    0.07883684f, -0.01133061f, 0.03269918f, -0.03120164f, 0.25028154f, 0.05920191f, -0.16491731f, -0.01599766f, 
    -0.16907454f, -0.06701457f, -0.05344920f, -0.04156042f, 0.27118903f, 0.03711471f, -0.43437481f, -0.15272169f, 
    -0.03448837f, 0.06925574f, -0.00089556f, -0.09763423f, -0.14288579f, -0.19868326f, -0.00098091f, -0.16998930f, 
    -0.06128225f, 0.07632865f, -0.17481932f, -0.06829552f, 0.00304416f, -0.16056991f, 0.01170063f, 0.09798076f, 
    -0.22170855f, 0.14796099f, -0.11246964f, -0.03870304f, -0.07705887f, 0.18435258f, -0.16177888f, 0.13189629f, 
    -0.20441617f, 0.16216703f, 0.09849031f, -0.30293128f, -0.01159256f, 0.06564089f, -0.05183697f, -0.01841105f, 
    0.17293951f, 0.17612500f, 0.28496677f, -0.17685319f, 0.01615844f, -0.03822717f, -0.01600315f, -0.08205909f, 
    -0.00454314f, 0.02166274f, 0.01491952f, 0.00307262f, 0.68232220f, 0.09562819f, 0.06639531f, -0.59185266f, 
    -0.06206286f, 0.02850282f, 0.15779364f, 0.05772076f, -0.08207903f, 0.12866697f, -0.06428250f, -0.18210337f, 
    -0.41939473f, -0.32441637f, 0.16100571f, -0.16004635f, 0.08912465f, 0.27331182f, 0.22363885f, -0.08607253f, 
    0.23804617f, 0.12690198f, 0.05086385f, 0.03623068f, -0.24660617f, -0.55080843f, -0.45769352f, -0.23297423f, 
    0.04759967f, 0.03369539f, -0.06900148f, 0.32087612f, 0.03571948f, -0.36220568f, -0.40954670f, 0.16852777f, 
    0.26271707f, 0.28739679f, 0.25116247f, -0.11761495f, -0.02647866f, -0.01605615f, 0.04282480f, 0.05151206f, 
    0.14294463f, 0.00738964f, 0.06743404f, -0.01844937f, 0.40291509f, -0.28896093f, 0.15250365f, -0.23881647f, 
    0.08905721f, 0.16653411f, -0.11258343f, 0.03829349f, -0.10173695f, -0.13467859f, 0.14103904f, 0.03570978f, 
    0.15984052f, -0.05070805f, 0.07441707f, 0.03153191f, -0.06997505f, 0.16934051f, -0.05288620f, 0.00981229f, 
    -0.05098802f, -0.05906871f, -0.02074565f, 0.14290416f, -0.02568053f, 0.05662657f, -0.12697418f, -0.27033177f, 
    0.01408194f, -0.18407120f, -0.02554986f, 0.09002646f, 0.13316554f, -0.11525954f, 0.07101437f, -0.13461076f, 
    0.07027023f, 0.09062593f, 0.08909035f, 0.22277683f, -0.10466455f, 0.03927257f, -0.00439496f, -0.00029126f, 
    0.08917204f, -0.03080512f, 0.01647778f, 0.00874930f, 0.55518591f, -0.01697911f, 0.17208727f, -0.05859205f, 
    0.11482336f, 0.21051094f, -0.24430074f, -0.32044005f, 0.14351499f, 0.00995099f, -0.10223152f, -0.08743710f, 
    -0.89101285f, -0.27512744f, -0.25554460f, 0.05073920f, -0.04232715f, -0.01183168f, -0.01009613f, 0.02008020f, 
    0.16799523f, 0.09618766f, -0.30168989f, -0.07178190f, 0.08904175f, 0.13079415f, 0.18656319f, 0.03484591f, 
    -0.09183741f, -0.07433157f, -0.01393464f, 0.09529185f, 0.09396433f, -0.08568814f, 0.01682978f, -0.10438965f, 
    -0.71433353f, 0.29237199f, 0.13568699f, -0.26296806f, 0.04891319f, 0.08214673f, 0.04171855f, 0.14395151f, 
    -0.26953614f, 0.07149456f, 0.00720995f, -0.13641135f, 0.04879972f, -0.04648477f, 0.04648555f, 0.03275327f, 
    0.09547446f, -0.03744943f, -0.03243357f, 0.02936335f, -0.08438422f, -0.03994767f, 0.10375419f, 0.02701770f, 
    -0.24915442f, -0.30555466f, 0.18976843f, -0.36447534f, 0.08860966f, -0.09619741f, 0.12156457f, -0.08734202f, 
    -0.01116868f, -0.07937295f, -0.05160825f, -0.04482831f, 0.21855232f, 0.26026636f, -0.24566455f, -0.06239064f, 
    -0.06510685f, 0.01937287f, -0.03761267f, -0.05232229f, 0.10787988f, 0.06509075f, 0.03742023f, 0.06826431f, 
    0.11492036f, 0.24125238f, 0.17817552f, 0.42177469f, -0.14158957f, 0.16055988f, 0.10935748f, -0.04800611f, 
    -0.06393118f, -0.00638308f, -0.00257991f, 0.02075014f, -0.10274634f, 0.12953107f, -0.11148971f, -0.03837074f, 
    -0.08171548f, -0.05942440f, 0.21772608f, -0.14744005f, -0.14888015f, -0.02367853f, 0.10312854f, 0.07860512f, 
    0.10720417f, -0.30590346f, -0.34546158f, -0.39491221f, -0.02490674f, -0.03348178f, 0.23511779f, 0.45992976f, 
    -0.01947070f, 0.00489152f, -0.09952835f, 0.05091292f, 0.74052060f, -0.40279749f, 0.06499855f, 0.17182180f, 
    -0.21151040f, -0.11603009f, 0.07486510f, -0.13075134f, -0.08691468f, 0.05897099f, -0.01160958f, 0.11817955f, 
    0.39028049f, -0.19492230f, 0.35186961f, -0.23410136f, -0.02240547f, -0.10248624f, 0.16896681f, -0.32214290f, 
    0.00287548f, 0.08530199f, -0.21311602f, -0.00701914f, 0.69785416f, 0.47107515f, 0.09862180f, 0.15393555f, 
    -0.05136449f, 0.05185971f, 0.00657327f, 0.01680721f, -0.06633558f, 0.10400626f, -0.17400782f, -0.02329564f, 
    0.54297757f, -0.24992181f, -0.13742851f, -0.19122642f, -0.02108374f, 0.00596785f, -0.02046098f, -0.06673012f, 
    0.04004876f, -0.23084952f, 0.19842786f, -0.18868838f, 0.07181735f, 0.19434164f, 0.07173391f, 0.22074719f, 
    -0.10965092f, 0.02968645f, -0.32919243f, -0.12342466f, -0.02795211f, -0.01572305f, -0.04521954f, -0.00654724f, 
    0.12507746f, 0.28603297f, -0.25280714f, -0.00287238f, -0.03191263f, 0.01832262f, -0.02933317f, 0.20361285f, 
    0.00155288f, 0.06401929f, 0.02443434f, -0.14422405f, 0.04366240f, 0.03324372f, -0.03765275f, 0.00820861f, 
    0.03318340f, -0.04996920f, -0.04362459f, -0.03424334f, 0.11188957f, 0.27548328f, 0.21656030f, 0.02059563f, 
    0.11681474f, -0.04864522f, -0.02346331f, -0.00001591f, 0.05019813f, -0.00892064f, 0.02066636f, 0.05064255f, 
    0.01990375f, 0.05787695f, -0.07426712f, 0.08062033f, -0.26508501f, 0.02807979f, 0.52061081f, 0.07691804f, 
    -0.06333255f, -0.01750416f, 0.15912335f, 0.18755293f, 0.11766601f, -0.04511028f, 0.10575747f, 0.08578134f, 
    -0.12790814f, -0.00679222f, -0.00052822f, -0.07178466f, -0.26626509f, -0.08668321f, -0.11639348f, 0.10565273f, 
    -0.04993694f, -0.10536750f, 0.03803146f, 0.02811445f, 0.18857428f, 0.21080075f, 0.34553668f, 0.30397531f, 
    -0.03480191f, -0.08062047f, 0.07958988f, 0.02757886f, 0.04435354f, -0.09854435f, 0.11467840f, 0.09382132f, 
    -0.09802096f, 0.08860210f, -0.02375696f, -0.06843783f, 0.18975556f, 0.07061812f, -0.15343980f, 0.05874888f, 
    0.05329671f, -0.35948962f, -0.24136327f, 0.03661499f, -0.32932544f, 0.39458373f, 0.27704829f, -0.08687599f, 
    0.06374845f, -0.07811537f, 0.12071478f, 0.10048196f, 0.05922766f, -0.00732460f, 0.07364997f, -0.01116870f, 
    -0.50715446f, 0.39685720f, 0.06594778f, -0.08496369f, -0.00771743f, 0.06463882f, -0.03404789f, 0.07609574f, 
    -0.03555840f, 0.10026814f, -0.12607870f, -0.02749028f, -0.54652089f, 0.82761186f, 0.75957662f, -0.31865329f, 
    -0.18538705f, -0.06370014f, -0.01252925f, -0.21663670f, -0.05017450f, -0.02919431f, 0.09606675f, -0.30638805f, 
    -0.19026788f, -0.28572178f, 0.52969420f, -0.41466746f, -0.18098249f, -0.20041332f, 0.06699876f, 0.01683395f, 
    -0.10781050f, 0.03457041f, -0.06393693f, -0.03477342f, 0.30040127f, -0.05825545f, 0.03592047f, -0.61535639f, 
    0.10863913f, -0.17563546f, 0.06183081f, 0.08274808f, 0.00919212f, 0.01245062f, -0.09180359f, -0.05723270f, 
    -0.44934663f, 0.24592638f, 0.31674939f, -0.25929898f, 0.04386105f, 0.00451328f, -0.01661049f, 0.00178024f, 
    0.08240776f, 0.01496297f, 0.06031351f, 0.02406088f, -0.05050416f, -0.28339505f, 0.36064193f, -0.14383025f, 
    0.04190812f, 0.03143927f, -0.23535143f, 0.24075918f, 0.11948922f, -0.01831483f, 0.16450292f, 0.03287734f, 
    -0.02973511f, -0.27863848f, -0.23808299f, 0.01852400f, -0.08468553f, 0.00066473f, -0.03828089f, 0.08520637f, 
    0.09642860f, -0.09315244f, -0.00202293f, 0.24582404f, -0.36995867f, -0.23398840f, -0.29749823f, -0.02839719f, 
    0.05402085f, -0.11107744f, -0.17320165f, 0.16064067f, -0.02641862f, 0.06914788f, 0.00926915f, -0.00778389f, 
    -0.09684631f, -0.14493211f, -0.27798873f, -0.35982856f, 0.01390331f, 0.02133071f, -0.01676559f, 0.05849448f, 
    -0.00978723f, -0.05978256f, -0.01294261f, -0.10507309f, 0.40031776f, -0.31599414f, 0.37043157f, 0.33404660f, 
    -0.07691940f, 0.03170639f, -0.12457688f, -0.07869395f, -0.07820299f, 0.08792418f, -0.10525310f, 0.20051490f, 
    -0.05877341f, -0.01803379f, -0.31842777f, 0.16449800f, 0.06568395f, 0.05513403f, -0.04902728f, 0.03008021f, 
    0.02243657f, -0.08651615f, 0.13642615f, -0.27769518f, -0.08243845f, -0.12629946f, -0.00535451f, 0.15125482f, 
    -0.00734415f, 0.05589712f, 0.00770143f, -0.03821755f, -0.02690055f, -0.21561940f, 0.05803074f, 0.25525260f, 
    -0.16606814f, 0.09792572f, 0.01543112f, 0.24826968f, 0.06059782f, 0.09094900f, 0.04455384f, -0.01595678f, 
    -0.04768212f, 0.07869596f, 0.02482865f, 0.07011921f, -0.04651999f, -0.05285966f, 0.09696587f, 0.06061927f, 
    -0.15003841f, -0.10904156f, -0.00008605f, -0.00381728f, -0.03405917f, 0.03271851f, -0.10047276f, 0.02546934f, 
    -0.05256729f, -0.10589374f, -0.14060111f, -0.27214563f, 0.25393695f, -0.01110019f, 0.06708419f, 0.08297609f, 
    0.00066819f, -0.05023814f, -0.00913729f, 0.02061962f, -0.34417024f, 0.16780174f, 0.16035005f, -0.03074193f, 
    0.03078749f, 0.01398198f, -0.01014393f, 0.08464317f, -0.03765686f, -0.07850385f, 0.12237532f, 0.02269631f, 
    -0.68668151f, -0.83955872f, -0.57468516f, -0.33609462f, -0.08567667f, 0.00605971f, 0.14123814f, -0.17934549f, 
    -0.02588177f, -0.05001270f, -0.05029685f, -0.03814251f, -0.18472719f, -0.07413116f, -0.02134954f, 0.01798881f, 
    -0.23688507f, -0.17304081f, -0.04972174f, -0.17293909f, 0.01133285f, -0.02541082f, -0.06453250f, 0.02237860f, 
    -0.84453279f, -0.09541487f, -0.01922703f, -0.48516089f, 0.07899111f, 0.02900711f, -0.16372226f, -0.47497162f, 
    -0.02074180f, -0.04032527f, 0.09516323f, -0.01250639f, -0.12775987f, 0.04552744f, -0.43551072f, -0.27682492f, 
    0.01326603f, -0.09449341f, 0.11077747f, -0.04498637f, 0.04405812f, 0.03747689f, -0.05604830f, -0.11264905f, 
    -0.11859836f, -0.36317620f, 0.56274801f, -0.34482521f, 0.05412272f, 0.02493148f, 0.01465516f, -0.07387456f, 
    0.15405007f, -0.07478777f, -0.23388872f, 0.13286267f, 0.08045494f, 0.16747212f, -0.18316543f, 0.30881032f, 
    -0.04159901f, 0.01847928f, 0.07098234f, -0.02914802f, 0.06533326f, 0.00671596f, -0.07302788f, 0.03546312f, 
    -0.38749796f, 0.68528938f, 0.46260291f, -0.00430726f, -0.04707923f, 0.01304131f, 0.16310154f, -0.19276786f, 
    0.11287513f, -0.07723802f, 0.03269401f, -0.05387957f, 0.16927147f, 0.40059781f, 0.17597984f, 0.49828550f, 
    -0.05341913f, -0.22281320f, 0.05433507f, -0.12179252f, 0.03280549f, -0.00575574f, -0.35675669f, -0.00911628f, 
    -0.53487492f, 0.79099059f, -0.26896295f, -0.17479824f, 0.18145688f, -0.27711749f, -0.09855907f, -0.33406878f, 
    -0.21349497f, 0.04776167f, -0.12211654f, 0.01847575f, 0.41923437f, -0.07205468f, 0.36049441f, 0.05682991f, 
    -0.24924807f, 0.08467107f, -0.10331318f, 0.10335469f, 0.10162046f, -0.00362438f, 0.08401780f, -0.06210300f, 
    -0.19303592f, 0.76291782f, -0.09064627f, -0.58224565f, 0.11228623f, 0.08334985f, 0.10920762f, -0.19542688f, 
    -0.08819191f, 0.02144333f, -0.07088365f, 0.10038113f, -0.01220308f, -0.00144667f, -0.06055352f, 0.32431316f, 
    0.02901741f, 0.09871333f, -0.11107230f, -0.03185268f, -0.11777694f, 0.10047480f, 0.00054925f, 0.05163371f, 
    -0.16124725f, 0.11049937f, 0.15148667f, 0.16562411f, 0.06615362f, -0.37227237f, -0.09050981f, -0.06011695f, 
    -0.08606060f, 0.29131469f, -0.11608011f, -0.36162838f, -0.15494631f, -0.35349938f, 0.02335198f, 0.08683816f, 
    0.25515434f, 0.20166878f, 0.00059918f, 0.15935495f, -0.12065610f, -0.11816444f, 0.02060569f, -0.08063801f, 
    0.49958530f, -0.02041214f, -0.11412103f, 0.30899021f, 0.12760614f, -0.02257565f, -0.03351196f, -0.02046064f, 
    0.09795876f, 0.10160033f, 0.03982934f, 0.00134713f, -0.14076658f, -0.05689865f, -0.18663007f, 0.19291840f, 
    0.05938523f, 0.04807741f, -0.05716206f, -0.10895723f, 0.01035652f, -0.19606611f, 0.15652613f, -0.00662543f, 
    -0.25775048f, -0.35594171f, 0.21261342f, -0.19491453f, -0.30203894f, 0.05725066f, -0.30335927f, 0.02375246f, 
    -0.16541927f, -0.12084123f, 0.01660210f, -0.09581249f, 0.06284233f, -0.10267293f, 0.21711302f, 0.52951503f, 
    0.09496745f, -0.03141725f, 0.07953867f, 0.01604475f, 0.12327272f, 0.06113023f, 0.16273890f, 0.21297221f, 
    -0.19996594f, -0.11759044f, -0.11418066f, 0.20548458f, 0.21444574f, 0.07369103f, 0.15956455f, 0.04344762f, 
    -0.16375242f, -0.14799218f, 0.24112616f, -0.10943737f, -0.13313289f, -0.03951773f, -0.14857748f, 0.20540833f, 
    0.09441238f, 0.02095053f, 0.07036363f, -0.16046076f, -0.05869370f, 0.03057078f, -0.01330051f, 0.08675036f, 
    -1.13263738f, -0.34843889f, 0.12699778f, 0.03693150f, -0.18670119f, -0.07427813f, -0.12767881f, -0.20692542f, 
    -0.09297545f, -0.03780384f, -0.08647014f, 0.00653720f, -0.17273517f, 0.06077706f, -0.17762071f, 0.23643240f, 
    -0.07824187f, 0.03533089f, -0.13483506f, -0.08943509f, 0.08185574f, -0.32253259f, 0.05367715f, -0.04191815f, 
    -0.09335547f, 0.25162783f, -0.08842246f, 0.20065941f, 0.20437148f, -0.17514980f, 0.28193048f, -0.11375474f, 
    0.02614272f, 0.02645353f, 0.15770675f, -0.07663757f, -0.21060525f, 0.16625571f, -0.16075262f, 0.21270363f, 
    -0.02856214f, 0.04512700f, -0.02301912f, -0.08248647f, 0.02241596f, -0.00685810f, -0.03805196f, 0.11444531f, 
    -0.26707679f, -0.18206653f, -0.17673221f, 0.15605727f, 0.51188737f, 0.12450290f, 0.20627433f, 0.16699673f, 
    -0.30787277f, 0.23029281f, 0.12073377f, -0.21598525f, 0.11336530f, -0.33806208f, -0.11963008f, 0.18273138f, 
    0.04479396f, -0.20021009f, 0.05864251f, -0.36677206f, -0.08631888f, 0.05308776f, -0.15682386f, 0.19644877f, 
    0.12131850f, 0.52462912f, -0.53105408f, -0.58634049f, 0.06240391f, 0.15735286f, -0.09981760f, 0.16266003f, 
    -0.49456450f, 0.06502048f, 0.06232106f, 0.02012125f, -0.20924182f, -0.14795116f, -0.34750515f, -0.26221898f, 
    -0.45456997f, -0.05509790f, -0.13949278f, -0.07060106f, -0.16007122f, -0.36408582f, 0.34642860f, -0.09300434f, 
    0.85654128f, -0.12058225f, -0.14916663f, 0.00720202f, 0.05079478f, -0.07421829f, 0.00086194f, -0.12699758f, 
    0.09289835f, -0.13930142f, 0.01927431f, 0.10191105f, -0.28865051f, 0.01841955f, -0.04823682f, 0.00300256f, 
    0.00658987f, -0.07371060f, -0.33643439f, -0.06408999f, -0.15547913f, -0.26016116f, 0.06848772f, -0.21515000f, 
    0.41743684f, -0.13311696f, 0.15120293f, -0.05350024f, -0.08900031f, -0.17390260f, 0.02187687f, 0.02487820f, 
    0.08119435f, 0.23236276f, 0.15601675f, 0.00639736f, -0.14670543f, -0.23365499f, -0.20141681f, -0.32126674f, 
    0.34603509f, 0.07833245f, 0.00767424f, 0.06795562f, -0.16837756f, 0.05029088f, 0.13382223f, -0.16866112f, 
    -0.06932720f, -0.12999426f, -0.11058034f, 0.15533888f, -0.05047046f, 0.05698757f, 0.10688386f, 0.07832742f, 
    -0.03066789f, -0.01858732f, -0.28487077f, -0.09534921f, 0.23232418f, 0.01155196f, -0.30825886f, 0.49670759f, 
    -0.00078660f, -0.20275137f, -0.00343196f, -0.09370749f, 0.03405234f, 0.01648903f, -0.10832838f, 0.01300447f, 
    -0.17315909f, -0.22400536f, 0.27417007f, 0.14602634f, 0.11038888f, 0.05558607f, -0.00524466f, 0.03409228f, 
    -0.03776038f, -0.04332542f, 0.02779450f, 0.07803246f, -0.44960466f, 0.56093413f, 0.01857135f, 0.63128662f, 
    0.03106453f, -0.15722680f, -0.14569768f, -0.16117965f, -0.02662062f, -0.07393733f, -0.00313693f, -0.15265642f, 
    -0.06628242f, -0.58189863f, 0.23532571f, 0.04627344f, -0.23375061f, -0.12575611f, -0.14622784f, 0.06615054f, 
    -0.06813800f, 0.22679976f, -0.14755379f, 0.10640572f, -0.34359974f, 0.45309311f, 0.09679088f, -0.00455813f, 
    -0.01128243f, -0.13800947f, -0.11549592f, -0.16480863f, -0.28257909f, 0.13436267f, -0.16256046f, 0.02938868f, 
    -0.09273753f, -0.03008034f, 0.13283034f, 0.26178229f, -0.00674993f, 0.12539174f, 0.19041786f, -0.12124706f, 
    0.03872714f, -0.12999403f, -0.05932793f, 0.11667792f, 0.41371667f, -0.29801449f, -0.03498003f, 0.18793647f, 
    0.11159422f, -0.08549646f, 0.13974211f, -0.14764710f, 0.06804101f, 0.01880394f, 0.06914125f, 0.14661251f, 
    0.13763131f, -0.54216099f, 0.03445839f, -0.13333075f, 0.07074241f, 0.03882162f, -0.01803460f, -0.02338387f, 
    -0.05686679f, -0.08237333f, -0.05550420f, 0.00231867f, 0.06607697f, 0.18064603f, -0.18999895f, 0.04604502f, 
    0.00092723f, -0.13338161f, 0.12367304f, -0.15550014f, 0.04510867f, 0.01919074f, 0.21696626f, 0.46358290f, 
    -0.03541274f, -0.10073408f, -0.10837355f, 0.08553443f, 0.03474563f, -0.15938921f, -0.07060532f, -0.09034015f, 
    -0.30435288f, 0.07043317f, -0.02349257f, 0.05363899f, -0.18621118f, 0.05514564f, 0.01650488f, 0.05078787f, 
    -0.15750144f, -0.09399336f, 0.03884220f, -0.02044238f, 0.22928847f, 0.00279032f, 0.10103089f, 0.20864199f, 
    0.10628395f, 0.05767007f, 0.06446411f, 0.00148838f, -0.05238939f, 0.06560917f, 0.03431437f, -0.02363440f, 
    0.05583215f, -0.00017705f, -0.15992247f, -0.05366907f, 0.21593836f, 0.11761763f, 0.01630554f, 0.18833157f, 
    0.00502034f, 0.01784972f, 0.11536290f, 0.10223045f, 0.03683169f, 0.02067105f, -0.08511606f, 0.11567219f, 
    0.28955865f, 0.12903860f, -0.09158134f, -0.00468001f, -0.04707593f, -0.05472836f, -0.03482559f, -0.01769225f, 
    0.07491816f, -0.34577751f, -0.15824553f, -0.07788949f, -0.15726256f, -0.04727783f, 0.09944237f, 0.01937886f, 
    -0.16591819f, -0.13627912f, -0.26041362f, -0.14285906f, -0.05231154f, -0.06397980f, -0.01131587f, 0.00158345f, 
    -0.25991991f, -0.17087702f, -0.54526371f, 0.00097333f, -0.04423639f, -0.00041910f, 0.02197451f, 0.05732903f, 
    0.01016462f, 0.07350069f, 0.01521444f, -0.01729798f, -0.39964077f, -0.03599698f, 0.22585328f, 0.12448874f, 
    -0.03190687f, -0.17513512f, -0.00357096f, -0.01245442f, -0.17288131f, -0.15673116f, -0.12464163f, -0.00455058f, 
    0.39341739f, 0.14651671f, 0.25476795f, 0.23794897f, -0.01214376f, -0.17231312f, -0.04500592f, 0.06065412f, 
    0.04663549f, 0.02693264f, -0.06297608f, 0.01263710f, 0.15109788f, 0.03644989f, -0.02375557f, 0.15532742f, 
    0.05511481f, -0.15370919f, -0.02101557f, -0.16403042f, -0.05534953f, -0.25498661f, 0.14046386f, -0.10585323f, 
    0.11371315f, -0.07404387f, -0.33046153f, -0.20447926f, 0.06696652f, 0.00891927f, -0.01253794f, -0.03207071f, 
    0.02098442f, 0.07032230f, 0.00657355f, -0.14255713f, -0.05562031f, -0.02056150f, -0.20307328f, 0.02184098f, 
    -0.00411326f, -0.01276825f, 0.02304910f, -0.46077636f, 0.12842891f, 0.05886687f, -0.20912094f, -0.05778189f, 
    0.07303314f, 0.02618578f, 0.18995334f, -0.06973001f, 0.11432245f, 0.01174823f, -0.12522443f, 0.11879687f, 
    -0.00838979f, -0.04642111f, -0.19219832f, -0.33070135f, 0.02254262f, -0.04996631f, 0.31885514f, 0.31775162f, 
    -0.08204366f, 0.12199567f, -0.27872151f, -0.06612525f, -0.09999804f, 0.02699014f, -0.05621915f, 0.06667800f, 
    0.22130199f, 0.07663867f, 0.05605962f, -0.02399816f, 0.13397114f, 0.05724813f, 0.04899447f, 0.09273142f, 
    0.09692816f, 0.03957382f, -0.02329517f, -0.08405841f, -0.03667532f, 0.05367475f, -0.10723200f, 0.24299912f, 
    -0.05421680f, -0.02384536f, -0.05424418f, -0.15943077f, -0.08577406f, -0.03174631f, 0.08083118f, -0.00887712f, 
    -0.42885980f, -0.58965200f, 0.46757907f, -0.04288738f, 0.07199918f, 0.07553080f, 0.04703861f, -0.00777339f, 
    -0.05718898f, -0.09034109f, 0.02925588f, 0.04080924f, -0.01003453f, -0.03198184f, 0.03202365f, -0.04726722f, 
    0.03289646f, 0.06146323f, -0.00177675f, 0.05793683f, 0.08105273f, -0.05662610f, -0.24553612f, -0.02822392f, 
    -0.18915914f, -0.04747298f, -0.18160358f, -0.06162025f, -0.09329418f, 0.02585606f, -0.07177988f, -0.05959983f, 
    0.02615821f, -0.10113779f, -0.16017222f, 0.07880456f, 0.10025088f, 0.04118700f, 0.03071875f, 0.09396084f, 
    0.00217709f, 0.19738546f, -0.04526833f, -0.03961500f, 0.04384651f, -0.02494606f, -0.09627891f, -0.10499565f, 
    -0.02968136f, -0.00136115f, -0.12116405f, 0.24901332f, -0.00779481f, 0.04320936f, -0.37525481f, -0.07399011f, 
    0.07097268f, -0.07501199f, -0.08890798f, -0.21578428f, 0.13603468f, 0.09899171f, -0.16961512f, -0.04521513f, 
    -0.04027272f, -0.01843517f, 0.04275078f, 0.03145878f, -0.13510256f, 0.00160403f, -0.22258469f, -0.08951198f, 
    0.10339682f, 0.14445163f, 0.22244821f, 0.17313530f, -0.05240982f, -0.00813294f, -0.02815527f, 0.18664496f, 
    0.08412073f, -0.01738821f, 0.07764995f, -0.01177869f, 0.15070221f, 0.00414681f, 0.25010392f, 0.15251832f, 
    -0.17625144f, 0.05701930f, -0.08171310f, 0.35107416f, -0.06057258f, -0.05804839f, -0.04551689f, -0.14945924f, 
    0.14381276f, 0.44410953f, 0.16592649f, 0.24779415f, 0.06613012f, -0.03700140f, -0.04160185f, -0.03596706f, 
    0.05258042f, -0.03208257f, 0.08520404f, -0.08365572f, 0.11419597f, 0.04395315f, 0.30355215f, -0.22752164f, 
    0.06290628f, 0.07264162f, 0.03016388f, 0.14338113f, 0.08016103f, -0.01867001f, -0.00421083f, -0.11408583f, 
    0.10048511f, 0.84725940f, -0.88504624f, 0.12184197f, 0.07414545f, 0.09474047f, 0.04957179f, 0.06189801f, 
    0.08502994f, -0.02245137f, 0.03428886f, 0.00733784f, 0.05642022f, -0.74485976f, 0.14052233f, -0.62121820f, 
    0.03820428f, -0.00813244f, 0.10019112f, -0.01344100f, 0.01434645f, -0.08265042f, 0.03867365f, -0.08916125f, 
    -0.26759309f, 0.15394408f, -0.00282478f, -0.11634864f, -0.06851532f, -0.08246405f, 0.05161997f, -0.09434869f, 
    -0.10532163f, 0.00379571f, -0.13802469f, 0.18651368f, -0.13027062f, -0.17688139f, -0.01356930f, 0.09684960f, 
    0.10243426f, -0.08919682f, -0.12405870f, 0.07514033f, 0.07038470f, -0.09064553f, 0.08751179f, 0.09642360f, 
    -0.14526130f, -0.25682983f, 0.51008976f, -0.02836098f, -0.03282101f, -0.12450969f, -0.05877697f, 0.00574644f, 
    -0.00284227f, 0.08615618f, 0.01058808f, -0.03582002f, -0.15338928f, 0.00530341f, -0.21816401f, 0.07110000f, 
    0.07054024f, 0.14216004f, 0.09335534f, 0.06345703f, -0.02240502f, -0.26847872f, -0.56407416f, -0.71277118f, 
    -0.12918518f, -0.02642556f, 0.16015318f, -0.00053041f, -0.00727782f, -0.09651720f, -0.07208101f, 0.07535501f, 
    0.24425346f, -0.05085728f, -0.04096115f, -0.18717153f, 0.17499249f, 0.12216513f, -0.04287116f, -0.25709227f, 
    0.01436616f, 0.04892766f, -0.03047809f, -0.03018453f, 0.04221960f, -0.17967127f, -0.12852333f, -0.27600768f, 
    -0.03418663f, -0.07961007f, -0.09070877f, -0.04224037f, -0.19444183f, 0.27463651f, 0.15506203f, -0.10792507f, 
    0.10148916f, -0.01546932f, -0.00255420f, 0.13243131f, -0.75153971f, -0.51150835f, -0.06129999f, -0.21581492f, 
    -0.00585890f, 0.04615326f, 0.04669793f, 0.14204738f, 0.06355745f, 0.02688276f, 0.01140023f, 0.10197914f, 
    -0.37668815f, -0.13397187f, 0.09382036f, -0.12105288f, -0.20209615f, 0.07205775f, -0.01315602f, -0.29548880f, 
    0.26969725f, 0.05321188f, 0.20158088f, 0.02677183f, 0.36533535f, 0.16565460f, 0.09388731f, -0.12293119f, 
    0.28407770f, 0.05214267f, 0.10627495f, 0.12069394f, 0.05995632f, 0.00292390f, 0.01368143f, 0.09483208f, 
    0.65742803f, -0.15300107f, -0.17449564f, 0.20387490f, 0.11642451f, 0.09862197f, -0.02002773f, 0.11112244f, 
    0.10645160f, -0.01407319f, -0.01057170f, 0.00714565f, 0.00196041f, 0.05336610f, -0.52440518f, -0.51915503f, 
    0.04033570f, 0.22785817f, -0.19620654f, 0.03599853f, 0.12610583f, -0.21482719f, 0.11566203f, 0.00197590f, 
    0.19521162f, 0.27705631f, -0.13406344f, -0.06409506f, 0.12009193f, 0.07719287f, 0.01266672f, -0.03035755f, 
    0.06575125f, -0.09322146f, -0.17986433f, -0.07297087f, -0.10111002f, 0.37937927f, -0.09291128f, -0.17193599f, 
    -0.08901264f, 0.08426555f, 0.09759774f, -0.19359985f, 0.10604440f, 0.05235310f, 0.42389700f, 0.04902272f, 
    0.39627439f, -0.24327439f, -0.39959040f, -0.02512726f, 0.17322899f, 0.00302928f, -0.05131915f, -0.01246664f, 
    0.10221462f, 0.04227810f, -0.04177168f, 0.02608797f, -0.10644231f, 0.26915574f, -0.33608878f, -0.09574115f, 
    0.05037342f, -0.26565772f, 0.01914059f, 0.18576601f, -0.11883707f, 0.02303323f, 0.00609233f, 0.01424818f, 
    -0.07360101f, 0.02908156f, -0.24153164f, 0.08679789f, 0.14821388f, -0.21027878f, -0.12041675f, -0.09171703f, 
    0.11651505f, -0.03215088f, 0.09008767f, 0.21171428f, -0.17351587f, -0.00328155f, 0.34322929f, -0.07901622f, 
    -0.00369994f, -0.13025630f, 0.04513147f, 0.15746841f, -0.19651321f, 0.07947140f, 0.03274422f, -0.06959173f, 
    -0.06340956f, -0.00556504f, -0.06076954f, 0.21829446f, 0.03451769f, -0.15723701f, -0.08466510f, -0.14475195f, 
    0.00754861f, -0.14641337f, -0.13970771f, 0.24035504f, -0.43185866f, 0.18572530f, 0.06165631f, -0.13998316f, 
    -0.02295825f, -0.09965244f, 0.00627777f, 0.44796062f, 0.08817320f, -0.13599558f, 0.02904920f, 0.01897835f, 
    0.05608983f, 0.13777669f, 0.49910346f, -0.02098743f, -0.02955072f, -0.05136808f, 0.01312583f, 0.05804706f, 
    0.03176358f, -0.16000298f, 0.17508531f, -0.03416038f, -0.27432159f, -0.16668928f, -0.03512013f, 0.04405152f, 
    0.09984142f, -0.03672158f, 0.09457752f, 0.02604523f, -0.02648335f, 0.42360005f, 0.07500044f, -0.02318490f, 
    -0.30836087f, -0.20014568f, 0.17091955f, 0.20480740f, -0.18362461f, -0.21037386f, -0.02155455f, -0.11467694f, 
    0.16044335f, 0.09716620f, 0.04648179f, -0.04341281f, -0.13037317f, -0.01321171f, 0.00870930f, -0.08287348f, 
    -0.00360599f, -0.03821295f, 0.11329272f, -0.09828097f, 0.06159935f, 0.03381114f, -0.07494673f, 0.00495397f, 
    -0.01015047f, 0.20100984f, -0.32660317f, 0.35799530f, 0.13260423f, 0.17285168f, 0.09119708f, 0.09894276f, 
    0.07492019f, -0.05744930f, 0.07126639f, 0.20131980f, -0.41623005f, -0.74234128f, 0.06133409f, -0.03272914f, 
    -0.02106208f, -0.01243114f, -0.07006522f, 0.05678934f, -0.03788348f, -0.18882774f, -0.08631653f, 0.12087290f, 
    0.03876463f, 0.07765356f, 0.15295897f, -0.17878187f, 0.27196947f, 0.14430708f, 0.05197734f, -0.07098772f, 
    0.14708695f, 0.01520543f, 0.01904759f, 0.03832138f, 0.09097651f, -0.15548779f, 0.11965414f, -0.14849964f, 
    0.27274132f, 0.25359973f, 0.03117794f, 0.25186566f, 0.07535888f, 0.01246029f, 0.05906953f, 0.00363959f, 
    0.14494106f, 0.19155867f, -0.07653158f, 0.07408867f, -0.03753912f, 0.04488579f, -0.01155106f, -0.16243865f, 
    0.04081603f, -0.07352570f, -0.06127495f, 0.06195432f, -0.15396766f, 0.11787189f, -0.52514249f, -0.43916398f, 
    0.00655161f, 0.13780354f, -0.04938165f, 0.24937838f, -0.01567832f, -0.00911103f, 0.02296016f, -0.10935289f, 
    0.13051762f, 0.04385027f, -0.16231087f, -0.05875627f, 0.17228557f, 0.10377941f, -0.06310319f, 0.31618840f, 
    0.09925434f, 0.04599754f, 0.15370825f, -0.03093594f, -0.18422750f, -0.54710138f, -0.12494714f, 0.12349687f, 
    0.04544070f, 0.07516901f, -0.03631180f, -0.05625955f, 0.10121620f, -0.05495970f, 0.24502043f, -0.01364282f, 
    -0.27714300f, -0.26093575f, -0.11501296f, -0.20511362f, 0.02698099f, 0.01166662f, -0.19680518f, 0.03173665f, 
    0.07954738f, 0.19632003f, -0.06748354f, -0.17880642f, -0.30097029f, 0.20254211f, 0.04853427f, -0.25801584f, 
    -0.10141747f, -0.15766038f, 0.12047541f, 0.09207773f, -0.04901915f, -0.19181538f, -0.07585260f, -0.21784450f, 
    -0.16665412f, -0.15745895f, 0.05043408f, 0.28729850f, 0.11478874f, 0.08637787f, 0.15843278f, 0.05322553f, 
    0.05037848f, -0.14299318f, -0.01443298f, 0.16777219f, 0.20605777f, -0.01978654f, 0.01190651f, 0.02038056f, 
    -0.05802315f, 0.02003469f, 0.08267678f, 0.08315683f, -0.02021212f, 0.17315640f, 0.07208688f, 0.26678395f, 
    -0.08046312f, -0.11298762f, 0.02928960f, 0.13255344f, 0.07475384f, 0.05035966f, 0.04909323f, 0.04235279f, 
    0.23673591f, 0.15800622f, 0.17005898f, -0.10814419f, -0.19129038f, 0.06829350f, 0.17811634f, -0.26412690f, 
    -0.10998959f, -0.00696503f, 0.02847872f, -0.12496608f, 0.02215951f, 0.11196117f, 0.08814038f, 0.15045023f, 
    -0.00691035f, -0.05267053f, -0.02114170f, -0.04061279f, 0.15695807f, -0.42077699f, 0.31625348f, -0.12123456f, 
    0.00492777f, -0.03690751f, -0.10232534f, -0.07665016f, -0.51756072f, 0.34102005f, 0.45200229f, 0.10944915f, 
    -0.08324500f, 0.02438843f, -0.07091399f, 0.06602541f, 0.01183487f, 0.17495926f, -0.06729136f, 0.00314266f, 
    -0.32612813f, -0.06479662f, 0.41265056f, 0.47398353f, 0.01721425f, -0.20247217f, -0.08131088f, -0.01909769f, 
    -0.15557513f, 0.06854198f, -0.29776841f, -0.02684013f, -0.51461357f, -0.44327444f, -0.14663556f, -0.28724092f, 
    -0.15158446f, 0.01098298f, -0.06654442f, -0.29120278f, 0.02629966f, 0.01967842f, 0.03070261f, -0.01395146f, 
    0.39055872f, 0.18467045f, -0.00985688f, 0.13954647f, -0.09205440f, 0.10936159f, 0.13169484f, -0.00057492f, 
    0.01120855f, -0.06502595f, 0.09087645f, 0.07160796f, -0.30359948f, 0.16524675f, -0.02705160f, 0.10126711f, 
    -0.02105636f, -0.14315997f, 0.05111152f, 0.04894009f, 0.13228385f, 0.08817674f, -0.01676841f, 0.09982086f, 
    -0.95918292f, 0.90154606f, 0.52468944f, -0.61392659f, -0.36885667f, -0.18281600f, -0.35959780f, -0.16853006f, 
    -0.13573386f, 0.02538230f, 0.05628610f, -0.00886554f, -0.53548610f, -0.03791969f, 0.63992232f, -0.15837763f, 
    0.07041352f, 0.08021490f, -0.03576605f, -0.20129730f, 0.14138921f, 0.07460986f, 0.17139050f, 0.03516539f, 
    0.27647683f, 0.00973450f, 0.04269278f, 0.11553203f, 0.06391697f, 0.02421173f, 0.06255717f, 0.12633219f, 
    -0.03981200f, 0.11304197f, -0.06075077f, -0.11219385f, 0.60502315f, -0.16378355f, -0.38214791f, -0.36786526f, 
    0.08537870f, -0.02773197f, 0.11061078f, 0.22854686f, 0.11984428f, 0.33692151f, -0.17509621f, -0.03674125f, 
    0.25314295f, 0.11658968f, 0.03444637f, -0.24686344f, 0.11461511f, -0.15166607f, 0.15120558f, -0.00177391f, 
    0.02748349f, 0.01894783f, 0.19062874f, -0.37183094f, -0.42431682f, -0.50456047f, -0.47425494f, 0.55211955f, 
    -0.01890440f, 0.23484549f, 0.25719789f, -0.11641473f, 0.08624073f, 0.00806923f, 0.10387503f, 0.07066462f, 
    0.00913622f, 0.07052535f, -0.09858013f, -0.28423762f, 0.02301082f, -0.09455023f, -0.02929022f, -0.11382831f, 
    -0.10055248f, -0.00599874f, -0.20975639f, -0.11067948f, -0.81134588f, -0.34478465f, -0.27798727f, 0.24886216f, 
    -0.19708544f, 0.07211488f, 0.11267065f, 0.32000455f, 0.03672610f, -0.00816474f, 0.18408544f, -0.11074026f, 
    0.09055997f, -0.16431610f, 0.16440950f, -0.29203790f, -0.00931858f, -0.02090132f, -0.02728646f, -0.05485478f, 
    -0.05152333f, 0.09503928f, 0.03173975f, 0.20696735f, 0.22537407f, 0.04454131f, -0.17823660f, -0.10913284f, 
    0.04952544f, -0.01147794f, 0.01264001f, 0.12835774f, -0.11336388f, 0.09655085f, 0.03864006f, -0.29236183f, 
    -0.30428812f, -0.22987887f, -0.19101638f, 0.11700849f, -0.02355821f, 0.05401103f, -0.35011277f, 0.15126336f, 
    0.06810777f, 0.04354778f, 0.13133000f, -0.00987512f, 0.11163002f, 0.01175779f, -0.14603925f, 0.02117345f, 
    -0.11610325f, -0.10075743f, 0.04265567f, 0.05573099f, -0.03908482f, -0.14309041f, 0.04786787f, -0.08859381f, 
    -0.00041342f, -0.15546192f, -0.15954030f, -0.64505744f, -0.00685160f, -0.02831554f, 0.24014671f, -0.05355938f, 
    -0.11044601f, 0.03339057f, 0.06788482f, -0.05295714f, -0.25797340f, 0.07990614f, 0.35953227f, 0.11599132f, 
    -0.07951212f, -0.13094757f, -0.06385652f, 0.04813738f, -0.04699765f, 0.17174059f, 0.10803668f, 0.05662367f, 
    -0.67838067f, -0.76755226f, -0.81123674f, -0.51719946f, 0.07864587f, -0.31284904f, -0.63144261f, -0.39114136f, 
    -0.05221336f, -0.06047432f, -0.10739590f, -0.00464567f, -0.15942740f, -0.17906477f, -0.01072489f, 0.04453918f, 
    0.10261459f, 0.07865685f, -0.22015482f, -0.18178806f, 0.04243015f, -0.08569764f, -0.06607375f, -0.03391068f, 
    -0.75963998f, -0.67300892f, -0.19914423f, -0.52217799f, 0.07206834f, -0.09217249f, -0.12009460f, -0.26417750f, 
    -0.08327399f, 0.03494981f, 0.05155518f, 0.04874910f, -1.27149653f, -0.61961287f, -0.01874975f, 0.37763798f, 
    0.22667496f, 0.18133791f, 0.04387002f, -0.05635031f, 0.09758616f, 0.00027846f, 0.03337272f, 0.18578550f, 
    0.45518997f, -0.44045016f, -0.15408733f, -0.09834844f, 0.02924767f, 0.06269947f, 0.07915892f, -0.21523367f, 
    -0.07653205f, -0.07391588f, 0.17386547f, -0.09727573f, -0.28486222f, -0.00460424f, -0.05399387f, -0.28774956f, 
    0.05813804f, 0.02584863f, -0.06274804f, -0.03867039f, -0.06215943f, 0.06711308f, 0.01248673f, 0.01261915f, 
    -0.02213698f, 0.50324172f, 0.00104717f, 0.22275463f, 0.00753425f, -0.04243183f, -0.06400046f, 0.12169505f, 
    0.03028102f, 0.04605660f, 0.02874182f, 0.07500783f, -0.30207488f, -0.84598494f, -0.18242097f, -0.00796736f, 
    -0.06504529f, 0.19559303f, 0.05573920f, 0.07716639f, -0.02288592f, 0.09164996f, 0.02299529f, -0.14887622f, 
    0.07086287f, -0.20145276f, 0.11043635f, -0.30288720f, 0.03603914f, -0.05598005f, -0.05163286f, -0.05763821f, 
    0.01722101f, 0.00138695f, 0.03086004f, -0.09621020f, 0.05623682f, 0.11063208f, -0.11137688f, 0.16965257f, 
    -0.09867521f, -0.01000798f, -0.04578885f, -0.00069327f, 0.05978722f, 0.06374324f, -0.05062970f, 0.14078274f, 
    0.22374736f, 0.05763607f, 0.08271889f, -0.21047081f, -0.06237981f, 0.04885264f, -0.02279824f, -0.08095779f, 
    -0.21914473f, -0.13054989f, -0.03287499f, -0.23934084f, -0.10561329f, -0.32348180f, -0.49810559f, -0.27812168f, 
    -0.10798174f, -0.24356411f, -0.00563438f, 0.03933665f, 0.03790969f, 0.04381616f, -0.06325556f, 0.09832013f, 
    0.05194046f, 0.02232180f, -0.04046502f, -0.00095842f, -0.11944216f, -0.10634113f, 0.12645799f, -0.02116467f, 
    0.03897196f, 0.00466102f, 0.03935160f, 0.03381926f, 0.74216580f, -0.76963943f, -0.25624081f, -0.42677882f, 
    -0.13764890f, -0.05319075f, -0.07304886f, 0.03062640f, 0.33369812f, 0.02034325f, -0.06132630f, -0.03467851f, 
    0.19514573f, -0.01359616f, -0.02246079f, -0.12700585f, -0.03613994f, 0.12832385f, 0.17305575f, 0.08573563f, 
    0.05587121f, -0.08494237f, 0.18317036f, 0.01826299f, -0.69603753f, 0.48978120f, -0.37101772f, -0.06886070f, 
    0.05988460f, -0.19464923f, 0.17824540f, 0.03155114f, -0.03361777f, 0.00745729f, -0.09917498f, -0.01723825f, 
    -0.19497147f, 0.38002741f, 0.12947595f, 0.04582864f, 0.07274252f, 0.09226412f, 0.07676355f, -0.11473066f, 
    -0.14496113f, -0.00240660f, 0.06720822f, 0.02931372f, -0.37201825f, 0.51333475f, -0.23411278f, 0.13729621f, 
    0.03412452f, 0.01876760f, 0.27148288f, -0.03453171f, -0.03789316f, 0.02278420f, 0.14844018f, -0.12342466f, 
    0.02270970f, -0.48455563f, -0.78326881f, -0.32721955f, 0.16883251f, -0.21678393f, 0.14829914f, 0.12433205f, 
    0.12321543f, 0.07631920f, -0.00070297f, 0.09991007f, 0.28523612f, 0.21487276f, 0.01801892f, 0.21295479f, 
    -0.08576567f, -0.01102791f, 0.01040497f, 0.07501531f, -0.05111779f, -0.01577225f, 0.02575018f, -0.35160154f, 
    -0.14664233f, 0.02344242f, 0.22099191f, -0.08204399f, -0.04578265f, 0.16454667f, -0.07991847f, 0.00760279f, 
    0.05726515f, -0.13136552f, 0.10846072f, 0.01612372f, -0.43043986f, -0.06911405f, 0.10073201f, 0.21763076f, 
    -0.00170440f, 0.20627704f, -0.19282088f, 0.01338795f, 0.02960172f, -0.14644872f, -0.01540698f, 0.08733007f, 
    -0.04183596f, 0.09954510f, -0.01129320f, 0.12619938f, -0.03921571f, 0.02234903f, 0.06377339f, -0.05182222f, 
    -0.08308987f, -0.05724216f, -0.19576479f, -0.01912740f, 0.20419975f, -0.54957891f, -0.05217684f, -0.25459883f, 
    -0.04197472f, 0.02403594f, -0.10155174f, -0.03992137f, -0.06937201f, -0.02556363f, 0.00136565f, 0.04656793f, 
    0.06771994f, 0.12125360f, -0.04015970f, -0.13081647f, 0.00836891f, 0.13148865f, 0.05139282f, 0.06712726f, 
    0.03247190f, -0.00420500f, -0.05986662f, -0.02715685f, -0.08605769f, -0.64100116f, -0.08748724f, -0.09409007f, 
    -0.05714182f, -0.16832982f, -0.08088882f, 0.07429401f, 0.04524156f, 0.04941259f, -0.01529122f, -0.08832910f, 
    0.64502966f, -0.16478634f, 0.04907304f, -0.29958642f, 0.10040306f, -0.07071710f, 0.02950869f, 0.09058254f, 
    -0.02458918f, 0.08858906f, -0.07884948f, -0.15316035f, 0.01394241f, 0.08781917f, 0.02393140f, 0.00461182f, 
    -0.06878577f, 0.02929564f, -0.00553155f, -0.04832368f, 0.04851004f, -0.06552713f, -0.05923129f, -0.11535414f, 
    0.68473566f, -0.33305278f, -0.20749499f, -0.40000933f, 0.05640560f, -0.23362172f, -0.26942810f, -0.02447169f, 
    0.03748176f, -0.00214957f, 0.07131791f, -0.04774320f, -0.10978135f, 0.03580409f, -0.00295854f, -0.00313041f, 
    -0.09143023f, -0.16385187f, -0.02640155f, -0.05073841f, -0.01116666f, 0.04712699f, 0.01850791f, 0.01374691f, 
    -0.86692202f, 0.46251917f, -0.50045359f, 0.44795161f, -0.24308370f, 0.06656293f, -0.04595371f, -0.13214245f, 
    -0.03334234f, 0.01468076f, -0.02203047f, 0.03517084f, 0.30098799f, -0.16891780f, 0.07239503f, -0.44595918f, 
    -0.00562838f, 0.10696144f, -0.00553253f, -0.04196843f, 0.01090383f, -0.11036348f, -0.08218572f, -0.19345242f, 
    -0.45125178f, -0.58916765f, 0.05904301f, 0.26893371f, 0.17610677f, 0.12482221f, -0.02599936f, 0.11867455f, 
    0.04616895f, -0.00176975f, -0.04173420f, -0.04749268f, -0.06951981f, 0.03245542f, 0.15674365f, -0.08440232f, 
    -0.13193691f, -0.01715689f, -0.01491911f, -0.10903411f, -0.00328775f, 0.04299661f, 0.01430466f, -0.07721297f, 
    -0.48291805f, 0.34539425f, -0.10587247f, 0.27766109f, -0.07465534f, -0.24902821f, -0.11987709f, 0.20272608f, 
    -0.01208043f, -0.03431271f, 0.04878603f, -0.05551387f, 0.08938841f, 0.18473831f, 0.37091941f, -0.15810253f, 
    0.12221129f, -0.24985804f, -0.00603871f, 0.04561516f, 0.06978677f, -0.06265330f, 0.07449987f, -0.07492016f, 
    -0.22042182f, 0.23363680f, 0.11369558f, 0.09086376f, -0.05781342f, 0.01798827f, 0.00665969f, 0.04645601f, 
    0.00410642f, 0.02151568f, 0.11141367f, 0.05076380f, 0.02959859f, -0.08239455f, -0.06109193f, -0.14999640f, 
    0.06626374f, -0.05028810f, -0.01067147f, -0.07082431f, 0.05666755f, 0.02012144f, -0.00911326f, -0.08332689f, 
    -0.01133939f, -0.58670217f, -0.55607319f, -0.10325955f, -0.00533650f, -0.11515106f, -0.00554491f, 0.05573879f, 
    -0.09685325f, 0.08619618f, -0.10673770f, 0.02835469f, -0.14636722f, -0.41102710f, -0.30758864f, -0.28266519f, 
    0.13445440f, -0.00323665f, 0.02991282f, 0.19164611f, 0.01061678f, -0.12379755f, -0.04153336f, 0.11785609f, 
    0.22727814f, 0.08764995f, 0.03367070f, -0.25542587f, -0.12251502f, -0.06463520f, 0.00322631f, -0.00915381f, 
    -0.03775658f, -0.18654251f, 0.04331288f, 0.20093805f, -0.19495299f, -0.01044136f, 0.09405849f, 0.11724328f, 
    0.05910128f, -0.02347752f, -0.14618415f, 0.08333164f, -0.06602872f, 0.10239068f, -0.15498556f, -0.32248676f, 
    0.19074674f, -0.03634562f, -0.13659857f, -0.24971563f, -0.05660566f, -0.05143052f, 0.03442100f, -0.11235704f, 
    -0.06027904f, -0.00662719f, -0.10506314f, -0.05876800f, 0.12264834f, -0.36181971f, -0.07175876f, -0.07762947f, 
    0.09335707f, 0.13521640f, 0.07895754f, 0.14364573f, -0.29007021f, -0.17692311f, -0.10872661f, -0.54633331f, 
    -0.16106850f, -0.00634868f, -0.03719402f, -0.04399425f, -0.03439552f, 0.02572281f, -0.01744187f, -0.02939785f, 
    0.05721622f, -0.01113290f, 0.14497732f, 0.10327276f, -0.34134415f, -0.25162241f, -0.10959899f, 0.05847669f, 
    0.02450201f, 0.06234799f, 0.04572851f, -0.00462321f, -0.12119251f, 0.02222763f, -0.10330872f, -0.18227324f, 
    -0.17642415f, -0.16703343f, -0.15030433f, 0.24700294f, -0.14849682f, 0.00196093f, 0.01381918f, -0.02164283f, 
    -0.04450243f, 0.13322350f, 0.13920195f, 0.17750359f, 0.46358183f, -0.54692233f, -0.36103290f, 0.11267576f, 
    -0.00077545f, 0.24160601f, 0.12343661f, -0.10081051f, -0.02621673f, 0.06507564f, 0.07324517f, 0.02042636f, 
    -0.55977792f, 0.14135942f, 0.17501955f, 0.17544240f, 0.13805369f, -0.13420790f, -0.05267876f, -0.16717982f, 
    0.00022640f, -0.03274341f, 0.02769749f, 0.09268129f, -0.92010111f, -0.79502910f, 0.18607025f, 0.54331964f, 
    0.08359477f, 0.05953737f, -0.01492513f, 0.01279361f, 0.01382696f, 0.06549003f, 0.10546865f, 0.39033487f, 
    -0.35135275f, -0.95926595f, -0.61075467f, -0.26592952f, -0.23070741f, 0.09004715f, -0.05223718f, 0.03934831f, 
    0.20300803f, -0.06748580f, -0.03846409f, -0.00070210f, -0.06149530f, -0.01727015f, -0.07665450f, 0.19574772f, 
    -0.08616751f, 0.12371040f, 0.15290973f, 0.18176259f, 0.15233220f, 0.28162175f, 0.03399259f, -0.07794859f, 
    -0.20398378f, -0.03041061f, 0.08410680f, 0.25765476f, 0.03041952f, -0.04607736f, -0.04425604f, 0.08771103f, 
    -0.05865443f, 0.08538966f, 0.03954130f, 0.13699439f, -0.36713469f, -0.08672759f, 0.14583063f, 0.36595145f, 
    0.13545017f, 0.06884854f, -0.20436616f, 0.12436953f, -0.14653550f, 0.18644854f, -0.07878446f, 0.12125997f, 
    -0.42971212f, 0.12521867f, 0.00774435f, -0.00435533f, 0.02261538f, 0.06797041f, -0.15170996f, -0.05719835f, 
    -0.02713487f, 0.05642259f, 0.12296258f, 0.19953054f, 0.45758846f, 0.10117493f, -0.07564985f, -0.06119337f, 
    0.15865979f, 0.17145674f, 0.12518057f, -0.11805853f, -0.06352230f, -0.03243262f, -0.15723893f, 0.01444244f, 
    -0.28459409f, 0.08028676f, 0.04406526f, 0.00769556f, -0.26725674f, -0.12080383f, -0.12518683f, -0.09608895f, 
    -0.03474770f, 0.03461334f, 0.12485041f, 0.05682027f, -0.34229076f, -0.42780975f, -0.27243176f, -0.08332893f, 
    0.29813957f, 0.36162689f, 0.27285910f, -0.00069242f, 0.06614745f, -0.08226048f, -0.07534696f, -0.06091014f, 
    0.53286409f, -0.02688572f, -0.25087780f, -0.54538995f, -0.02196660f, -0.11872778f, -0.09036259f, -0.04301376f, 
    0.04820546f, 0.15988289f, -0.13956076f, 0.25041354f, -0.15074168f, 0.19416019f, -0.11202075f, -0.27179039f, 
    0.08666433f, 0.08384531f, 0.01678760f, 0.02146501f, -0.03603824f, 0.03145008f, 0.05159079f, 0.16352403f, 
    0.14771441f, -0.24374762f, -0.25633487f, -0.28928900f, 0.30487129f, 0.18908915f, 0.17758906f, 0.25150666f, 
    0.09935359f, -0.03677406f, 0.01471878f, 0.14741927f, -0.16942281f, -0.02598159f, 0.03325393f, -0.08833131f, 
    0.07803661f, 0.02985789f, 0.04818528f, -0.03492641f, 0.01784753f, 0.13728404f, 0.07807082f, 0.13695699f, 
    0.24842671f, 0.07088320f, 0.27943933f, 0.35128823f, 0.09582060f, 0.13188276f, -0.08516774f, 0.28256556f, 
    0.03391016f, 0.06841771f, 0.17349534f, 0.12194815f, -0.16812620f, -0.16276552f, -0.28522286f, -0.02862571f, 
    -0.03729172f, -0.04166055f, 0.10635422f, 0.12358522f, 0.21980062f, 0.03289490f, 0.06272031f, 0.05181927f, 
    -0.51765519f, -0.85888720f, -0.53276348f, 0.01520521f, 0.06806763f, -0.10163753f, -0.09604543f, -0.24669082f, 
    0.01406590f, 0.01657304f, 0.03847000f, 0.05199543f, -0.02699596f, -0.04590690f, 0.03842956f, 0.00147190f, 
    -0.12276656f, -0.14079888f, -0.10806430f, -0.23467958f, 0.12985183f, 0.12421919f, 0.10429652f, 0.09614861f, 
    -0.43728670f, -0.20469639f, -0.23224808f, -0.34254637f, 0.08856513f, 0.00022077f, 0.05128049f, 0.02790139f, 
    0.01981664f, 0.06446961f, 0.06179111f, 0.03386725f, -0.41923201f, -0.13748404f, 0.11843801f, 0.17895350f, 
    0.01055080f, 0.14005797f, -0.14176072f, -0.15164556f, -0.01509472f, 0.01749619f, -0.04282720f, 0.04959455f, 
    -1.01435721f, -0.20988263f, 0.35160792f, 0.15768722f, -0.02627354f, 0.06989479f, -0.18728919f, -0.16905884f, 
    -0.16840388f, -0.27019772f, -0.04749416f, -0.21552216f, -0.22761603f, 0.18037453f, 0.13622832f, -0.13929741f, 
    -0.03187177f, 0.07432611f, -0.03764694f, -0.14589962f, 0.02687054f, 0.09370906f, -0.10692342f, 0.16103327f, 
    -0.39415708f, -0.42939413f, 0.50460947f, 0.06063345f, 0.00658257f, 0.07527413f, 0.07654786f, 0.22771192f, 
    -0.08696529f, 0.07619025f, -0.00983187f, 0.07871476f, 0.00231389f, -0.21418406f, -0.36116183f, 0.06607282f, 
    0.05602379f, -0.09218436f, 0.01393659f, -0.01345607f, -0.15394086f, 0.02406789f, -0.26322791f, -0.34034824f, 
    0.19809037f, -0.64221650f, 0.33773804f, -0.23164709f, 0.01140315f, 0.07902084f, -0.16467494f, -0.22798656f, 
    -0.25996923f, 0.12619394f, 0.15019864f, -0.02371920f, 0.01605038f, 0.21347660f, -0.24811877f, 0.06125498f, 
    -0.01107902f, 0.07333869f, 0.10105267f, 0.01669458f, 0.13279320f, 0.05305312f, 0.25518587f, 0.37340653f, 
    -0.11928380f, -0.52898967f, 0.16586119f, 0.23842518f, -0.01413185f, 0.17799942f, -0.22595695f, -0.13210954f, 
    0.03773868f, -0.00588770f, 0.16222654f, -0.06631177f, 0.20764494f, 0.10242881f, -0.17444232f, 0.30792710f, 
    -0.11030225f, 0.01775425f, -0.07054412f, 0.00444794f, -0.06837674f, -0.00779744f, 0.15255362f, 0.10364074f, 
    0.00373223f, 0.01575561f, -0.07352325f, 0.00056816f, 0.10585736f, 0.01598805f, 0.13528071f, 0.03002183f, 
    0.02293422f, -0.02270203f, -0.12181052f, -0.07084618f, 0.34284747f, 0.04933565f, 0.30020040f, 0.18155396f, 
    -0.13936351f, -0.10301045f, -0.17457139f, -0.31432575f, 0.01538867f, -0.01169064f, 0.07225891f, 0.15106307f, 
    0.24780552f, 0.03341031f, 0.28828904f, -0.20152059f, 0.15338610f, -0.00554656f, 0.06050576f, -0.06319307f, 
    -0.05854374f, 0.09445459f, -0.23119403f, 0.05694949f, -0.51766276f, -0.17223413f, 0.14304642f, 0.05670207f, 
    -0.08178028f, -0.14832532f, -0.03175784f, 0.23134230f, -0.09488609f, 0.05057448f, 0.08132841f, -0.01406077f, 
    -0.25263196f, -0.21759917f, -0.76271969f, -0.27317002f, 0.00627160f, -0.17490198f, 0.24819197f, 0.01076031f, 
    -0.04163946f, 0.00709836f, -0.00868124f, 0.10222277f, 0.19320093f, -0.39648557f, -0.00201291f, -1.21391046f, 
    0.10937335f, -0.15350758f, 0.22195010f, 0.05954493f, -0.11604432f, -0.10690638f, -0.11836541f, -0.04951992f, 
    -0.06068206f, 0.02010921f, 0.23481809f, 0.24683172f, 0.10138398f, -0.19662623f, -0.22715792f, 0.12622999f, 
    -0.11281089f, -0.04906886f, 0.01536248f, 0.05399877f, -0.18019602f, 0.02776259f, 0.14148211f, 0.04119178f, 
    0.05175520f, 0.08757797f, -0.15214057f, -0.09114935f, 0.05820733f, 0.27647561f, -0.07167313f, -0.02535987f, 
    0.11020342f, -0.22222090f, -0.21971822f, -0.25828308f, -0.16704275f, 0.16341564f, 0.08887103f, -0.20959240f, 
    0.00097533f, -0.05723625f, 0.04999900f, 0.12650044f, -0.22737150f, 0.31880495f, -0.39656147f, -0.42390606f, 
    -0.24428721f, 0.04254220f, 0.14438336f, -0.10013139f, 0.19321644f, -0.09533138f, -0.31447798f, 0.18455879f, 
    -0.31119511f, 0.02521213f, -0.05927119f, -0.06708913f, 0.01238914f, 0.13125668f, -0.00918665f, 0.03148869f, 
    -0.06429520f, 0.11202282f, -0.08049285f, -0.41813239f, -0.10146273f, -0.58472437f, 0.24918576f, -0.32111016f, 
    -0.16437644f, 0.02191590f, -0.11766280f, 0.08820350f, 0.16017783f, 0.05673099f, -0.00123859f, -0.00271905f, 
    -0.01533787f, -0.09707971f, 0.12471443f, 0.29614303f, 0.04263254f, 0.11196571f, 0.17267817f, -0.02403177f, 
    -0.12808113f, 0.15331088f, -0.08177514f, 0.04482898f, -0.14763524f, -0.06807147f, 0.19112404f, -0.46146253f, 
    -0.03973012f, -0.17214572f, -0.01272088f, -0.15910347f, 0.11307307f, 0.02787020f, 0.06732862f, -0.00148798f, 
    -0.15797478f, 0.07625706f, 0.07631003f, 0.61694610f, 0.12570584f, 0.10428227f, -0.07410187f, 0.04317291f, 
    -0.11341904f, -0.09980235f, 0.01365325f, -0.07750067f, -0.07026528f, 0.24988979f, -0.15517330f, -0.06678494f, 
    0.17585558f, -0.09080247f, 0.07702325f, -0.20018131f, 0.29258165f, -0.07678474f, -0.02159004f, -0.07008529f, 
    0.15720031f, 0.04795500f, 0.38016692f, 0.51365739f, 0.14728287f, -0.26918742f, 0.07318696f, -0.16553974f, 
    0.06650191f, -0.12946177f, 0.03031247f, 0.10888470f, 0.11020168f, 0.08758052f, -0.05891425f, -0.14967246f, 
    0.25796461f, -0.03465942f, 0.16161215f, 0.12265042f, 0.18477219f, -0.07126833f, -0.03980975f, -0.14744116f, 
    -0.91945016f, 0.30957299f, -0.87039453f, 0.11358571f, -0.19063748f, -0.27631322f, -0.09677797f, -0.09536549f, 
    0.16703126f, -0.09241015f, -0.26649013f, -0.14071327f, 0.44733670f, 0.09274363f, 0.39328760f, 0.27185053f, 
    -0.01312928f, -0.04833023f, -0.28569743f, -0.18611878f, 0.04995105f, -0.00696689f, -0.04186404f, -0.03705110f, 
    -0.81169641f, 0.14319426f, 0.34191608f, -0.44401219f, -0.41980699f, -0.08207490f, 0.07504761f, 0.39834008f, 
    0.04509651f, 0.04070863f, 0.04589406f, -0.03456273f, 0.41751873f, -0.31975278f, -0.03940319f, -0.12948085f, 
    0.19026610f, 0.13564914f, -0.00384778f, 0.09185883f, -0.07609116f, -0.16096629f, -0.11823831f, -0.22187066f, 
    0.30065665f, -0.07329636f, -0.29283398f, 0.21412526f, -0.12630045f, 0.11001101f, 0.17086661f, 0.15699174f, 
    0.18452311f, 0.06552211f, 0.07864784f, -0.22682145f, 0.32329226f, -0.73064703f, 0.35944930f, -0.54902506f, 
    0.11533518f, 0.09011492f, 0.00921890f, -0.02646722f, 0.11498320f, -0.09799155f, -0.09028489f, 0.05533883f, 
    -0.23605086f, -0.13049169f, -0.40970126f, -0.21492548f, 0.02767445f, 0.05431057f, 0.14854021f, 0.25306585f, 
    -0.02775467f, -0.11747782f, -0.05636906f, 0.01329535f, -0.08670530f, -0.25885254f, 0.15281817f, 0.02759057f, 
    0.15976308f, 0.00076533f, 0.02799453f, -0.00096635f, 0.08293366f, -0.08389262f, 0.02403828f, -0.13855700f, 
    0.42657837f, -0.07608079f, 0.23274170f, -0.22126552f, -0.00589952f, -0.21546346f, -0.08210961f, -0.04897046f, 
    -0.05453768f, -0.07760680f, 0.18985616f, 0.07681123f, -0.45576558f, 0.03154263f, 0.38286427f, -0.41541362f, 
    -0.03252478f, -0.01166313f, -0.02882144f, -0.08871727f, 0.12504940f, 0.09587304f, 0.16883135f, 0.11029113f, 
    -0.50883830f, 0.37257740f, -0.38718975f, 0.25879571f, -0.16680838f, 0.04000888f, -0.06089773f, 0.04572059f, 
    0.04028594f, -0.00235865f, 0.05267445f, 0.04988999f, 0.24314453f, -0.12224526f, 0.11106534f, 0.08838859f, 
    -0.10795809f, -0.24995916f, -0.03391968f, -0.07341430f, -0.17030753f, -0.16504017f, -0.50003082f, -0.39152542f, 
    -0.51308131f, -0.09807832f, -0.14519285f, -0.01986248f, 0.06961582f, 0.13124780f, 0.04206220f, -0.00434120f, 
    -0.07613046f, -0.08611669f, -0.06306650f, -0.02590510f, -0.01094275f, 0.11753669f, -0.10610510f, -0.10448162f, 
    0.10486739f, -0.06532980f, 0.02391013f, 0.06510574f, 0.04044839f, 0.06225149f, -0.27382770f, -0.65795237f, 
    -0.12834132f, 0.00960964f, 0.29743353f, -0.02931808f, -0.13167988f, 0.02560608f, -0.23728095f, -0.05470298f, 
    0.15107977f, -0.08446572f, 0.48549640f, -0.06086664f, -0.19001950f, 0.19866182f, -0.30095515f, -0.19529903f, 
    0.14242476f, -0.01891270f, -0.12000962f, -0.07924097f, -0.29061636f, -0.09858657f, -0.24710973f, -0.32367983f, 
    0.19070181f, 0.32576635f, 0.43289119f, -0.16097990f, -0.20649804f, -0.00455948f, -0.04579704f, 0.01155727f, 
    -0.08663421f, 0.15211959f, 0.30506274f, 0.10097621f, -0.07999834f, -0.40868774f, -0.04082527f, 0.19353727f, 
    -0.10809902f, 0.03579546f, -0.18364856f, 0.11494264f, 0.06872194f, 0.10126605f, -0.01320879f, -0.05998513f, 
    0.04996048f, 0.19083585f, -0.43854678f, 0.12121107f, -0.23566306f, -0.04167522f, -0.03951847f, -0.04024700f, 
    0.02319569f, 0.14789464f, 0.02533339f, -0.01104541f, 0.17462897f, -0.43866634f, -0.12703305f, 0.51166952f, 
    0.04513310f, 0.11139497f, -0.04837380f, 0.04739280f, 0.13181759f, 0.09253711f, -0.08718235f, 0.03275346f, 
    -0.06462302f, 0.12100253f, -0.19257857f, 0.31747752f, 0.01719586f, 0.18471956f, -0.36500019f, 0.05169094f, 
    0.13884927f, 0.12323652f, 0.05985666f, 0.05329952f, 0.53573942f, -0.25882176f, 0.38913703f, 0.03129184f, 
    0.01769001f, 0.03163403f, 0.04925686f, 0.18854044f, -0.13109602f, -0.11952091f, -0.17965522f, -0.24519728f, 
    -0.02339280f, 0.25668472f, -0.26371229f, 0.14389537f, -0.00957258f, 0.09425349f, -0.00489277f, -0.05992748f, 
    -0.09018192f, 0.05826756f, 0.06750825f, 0.00573070f, 0.17945123f, 0.29201025f, 0.19048373f, 0.20402466f, 
    -0.14217223f, -0.27679718f, 0.23480673f, 0.24542084f, -0.07065862f, -0.08337312f, -0.09484304f, 0.15533918f, 
    0.09261315f, -0.28441069f, 0.11469000f, -0.16768394f, -0.29533315f, -0.03014380f, 0.05392059f, 0.07206132f, 
    0.03441736f, -0.05671449f, 0.10452079f, 0.13285393f, -0.54357755f, -0.01570528f, -0.22374471f, -0.17359039f, 
    0.00182549f, 0.05203205f, -0.34404925f, -0.29275540f, -0.15283293f, -0.12693462f, -0.02531787f, -0.13591543f, 
    -0.05005589f, -0.50300920f, -0.04373316f, -0.38029802f, -0.09336980f, -0.24401863f, -0.10129452f, -0.14008369f, 
    0.25671783f, -0.26306036f, 0.08450697f, 0.19420534f, -0.37019563f, 0.21823984f, 0.05674722f, -0.10710765f, 
    -0.05072238f, -0.06816620f, 0.37707061f, 0.04186755f, -0.01624943f, 0.02422880f, 0.13962425f, -0.15307470f, 
    -0.34177893f, 0.75701386f, -0.53286546f, 0.18154709f, -0.11907039f, 0.16706270f, 0.09833761f, -0.10377437f, 
    0.06900606f, 0.00916332f, 0.18502294f, 0.14202207f, -0.31987596f, -0.20650947f, 0.06352277f, -0.10676052f, 
    -0.30328315f, 0.03433108f, -0.06287347f, 0.01024147f, -0.23742145f, 0.16101091f, -0.39756024f, 0.17047372f, 
    -0.03130106f, 0.34251398f, -0.23366377f, -0.16019344f, -0.20934260f, -0.10920326f, 0.17705135f, 0.08970038f, 
    0.05136079f, 0.10453965f, -0.22218795f, 0.09713138f, -0.11741927f, 0.08766732f, -0.21013913f, -0.08863617f, 
    -0.08257125f, 0.03648465f, -0.01269205f, 0.07682119f, -0.02879292f, 0.12466424f, -0.00235661f, 0.06308202f, 
    0.21262543f, 0.25320402f, 0.25275385f, 0.07318467f, -0.35110682f, 0.19761035f, 0.29476163f, 0.21051840f, 
    -0.00258912f, 0.16528209f, 0.15326950f, 0.24891061f, -0.23130952f, 0.27191141f, 0.08630432f, 0.17917819f, 
    0.04514809f, -0.01491178f, 0.05788282f, -0.10634162f, -0.10872568f, 0.03463214f, -0.09030388f, 0.15195172f, 
    -0.33911228f, -0.14088573f, -0.12510857f, 0.05318585f, -0.11672391f, -0.04229318f, -0.09201767f, 0.05087790f, 
    0.05066334f, 0.14243872f, 0.13306989f, 0.05399122f, -0.41192105f, -0.08044671f, -0.24621831f, 0.12208444f, 
    -0.02778496f, 0.07765701f, -0.09305156f, -0.03541445f, 0.00857251f, 0.14236853f, 0.17453869f, 0.10732412f, 
    -0.11177334f, -0.22164874f, -0.17570932f, 0.00510552f, -0.00841655f, -0.01681665f, 0.07000244f, -0.01641757f, 
    0.17192668f, 0.04590503f, -0.09338850f, -0.15234067f, -0.45753914f, 0.47530001f, 0.14061414f, 0.17796876f, 
    -0.14946242f, 0.02243937f, -0.19194435f, 0.37973189f, 0.03850351f, -0.01143197f, 0.19995299f, 0.18881309f, 
    -0.04952276f, 0.02700113f, 0.22634186f, -0.10828197f, -0.02750360f, -0.24476936f, 0.00066053f, 0.05399321f, 
    -0.16975456f, -0.05858795f, -0.11242624f, 0.02472010f, -0.60771757f, 0.18960866f, 0.10471957f, 0.10948756f, 
    -0.16241634f, -0.16453184f, -0.09767410f, 0.10760043f, -0.17470744f, -0.10164626f, 0.24573189f, 0.16070767f, 
    0.07245465f, 0.25073901f, -0.04762608f, -0.02458536f, -0.06168639f, -0.14919539f, 0.05699204f, 0.20608002f, 
    0.11880542f, 0.18417189f, -0.09189436f, -0.10623906f, 0.31777859f, -0.47479430f, 0.09781064f, -0.20746842f, 
    0.06025352f, -0.02086961f, -0.14143547f, -0.02192216f, -0.03626730f, 0.07766203f, -0.22456922f, -0.35042423f, 
    -0.42722261f, 0.38773844f, -0.46545357f, 0.23933998f, 0.14485016f, 0.00070155f, 0.08142009f, 0.04438637f, 
    0.02907695f, 0.08257113f, -0.11727968f, -0.06090166f, 0.23758616f, -0.09075721f, 0.23042323f, -0.30731151f, 
    0.05007975f, 0.00077938f, 0.12566812f, 0.05590257f, 0.30496237f, 0.15444708f, 0.09315240f, 0.11060484f, 
    -0.48352739f, 0.09554425f, -0.50582755f, -0.04616730f, -0.06158696f, -0.01612789f, 0.07344090f, -0.13589720f, 
    0.13348924f, -0.01569697f, 0.19326320f, 0.06917734f, -0.42228508f, -0.02209224f, 0.04432408f, -0.24441688f, 
    -0.06141984f, -0.10257766f, -0.11171437f, 0.07353817f, -0.06804261f, -0.04863339f, 0.04210584f, 0.19585004f, 
    0.03922387f, -0.03154583f, -0.05776583f, 0.24770457f, -0.02918716f, -0.05526296f, 0.11088587f, 0.22489031f, 
    -0.27761891f, 0.01237283f, -0.44342232f, -0.14485155f, -0.18306947f, 0.17444634f, -0.63815159f, 0.01520395f, 
    -0.01769839f, -0.17241865f, -0.08154581f, -0.01702881f, -0.06464053f, 0.06314592f, -0.00024383f, -0.05283655f, 
    0.02622568f, -0.30220807f, -0.14218742f, -0.15024258f, 0.06434301f, 0.24387655f, -0.09231311f, 0.21031070f, 
    -0.14590949f, -0.17346734f, -0.04044154f, -0.35113361f, 0.03616876f, -0.21412155f, 0.60730231f, -0.20109719f, 
    0.09863748f, -0.11300319f, -0.27211273f, 0.09698371f, 0.02894020f, 0.00941456f, -0.02196507f, -0.07572260f, 
    0.65120274f, -0.90722483f, 0.44765022f, 0.25912255f, 0.13344961f, -0.04328276f, 0.06159112f, 0.07400393f, 
    -0.11995293f, -0.05966808f, -0.08074611f, -0.05949780f, -0.41663241f, 0.16488013f, 0.04096209f, -0.44722855f, 
    -0.17334862f, 0.02857145f, -0.02526217f, 0.13792737f, -0.20282733f, 0.08925308f, 0.11922710f, -0.03754636f, 
    -0.50576192f, -0.49529210f, -0.11325090f, 0.17142479f, -0.21994798f, -0.14940111f, -0.06783686f, 0.11981602f, 
    -0.21175402f, -0.08794573f, -0.03631258f, -0.07777894f, -0.37569657f, -0.01878521f, -0.38011435f, 0.19528584f, 
    -0.10564724f, -0.00537166f, -0.02005570f, -0.15028182f, -0.18875742f, 0.30918726f, 0.09728891f, 0.08641247f, 
    -0.12494447f, 0.06719013f, 0.10522018f, 0.41661927f, -0.10215621f, -0.05427335f, 0.16829284f, -0.20492345f, 
    -0.16047458f, -0.01439869f, 0.06385048f, -0.02813141f, -0.32516611f, 0.50695050f, 0.74956244f, 0.19526455f, 
    0.05720430f, 0.09995566f, 0.31440952f, -0.16872448f, -0.13966650f, 0.02383732f, 0.25780323f, -0.28509924f, 
    0.06515247f, -0.00147835f, 0.10685923f, -0.11007810f, -0.11244092f, -0.12786515f, 0.05724169f, 0.09508453f, 
    -0.02582666f, -0.05924815f, 0.18314581f, -0.13390841f, 0.02421472f, -0.02776670f, -0.39742836f, -0.09653969f, 
    -0.22924092f, -0.22330333f, 0.25371993f, -0.17639923f, 0.06252095f, 0.10592695f, 0.07272039f, 0.04705710f, 
    -0.33417025f, -0.15588705f, -0.09764227f, -0.20402186f, 0.07334955f, 0.00003033f, -0.10536128f, -0.01796455f, 
    -0.34209836f, 0.06467374f, -0.13941053f, -0.15738668f, -0.20640641f, 0.58447373f, -0.38203618f, -0.38866132f, 
    -0.06275114f, -0.17214416f, 0.11621318f, 0.04275044f, 0.04411658f, 0.22063175f, -0.01528248f, -0.05227385f, 
    -0.35788456f, -0.56576121f, -0.35297588f, 0.39050877f, 0.15643348f, 0.02892668f, -0.03926583f, -0.02851383f, 
    -0.02354293f, -0.13700297f, 0.32654166f, 0.20068128f, 0.48900387f, 0.02919914f, -0.03473471f, 0.14515983f, 
    0.02697919f, 0.15106501f, -0.04181624f, 0.16799152f, -0.09392358f, 0.03584081f, -0.00172975f, 0.13949864f, 
    0.15259840f, -0.19124129f, -0.05952485f, 0.06188315f, 0.03454161f, 0.15374468f, 0.10012929f, -0.02893674f, 
    -0.09465840f, 0.11425617f, -0.01627336f, -0.21941003f, 0.35108805f, 0.06091743f, 0.16056578f, 0.05253793f, 
    -0.06850088f, 0.32234880f, -0.21519756f, 0.09084462f, -0.17372984f, -0.03364539f, -0.04502484f, 0.01919267f, 
    0.43307233f, -0.46307072f, 0.38135543f, -0.15939164f, 0.24674715f, -0.28398800f, -0.17438099f, 0.12009259f, 
    -0.10871984f, 0.15233849f, -0.03496112f, 0.09896088f, -0.38897246f, 0.08238191f, -0.36679870f, 0.29128978f, 
    0.10920344f, -0.00012054f, 0.00716981f, -0.06675883f, -0.07888955f, 0.00246131f, 0.24271296f, -0.08301803f, 
    -0.15620348f, -0.17861135f, 0.05360195f, -0.08353835f, -0.07883622f, -0.30522090f, -0.16597311f, -0.35469028f, 
    0.02281392f, -0.01886456f, -0.17097020f, -0.12357814f, 0.34824026f, 0.22269557f, 0.01268834f, 0.05292245f, 
    0.02011146f, 0.02577841f, 0.22750486f, 0.14088839f, -0.05059973f, -0.07931193f, -0.09839126f, -0.14580730f, 
    0.00032979f, -0.49693900f, 0.64208317f, -0.14272201f, -0.14160110f, 0.14354482f, -0.16560762f, -0.30892506f, 
    0.06871482f, 0.14182451f, 0.14032678f, 0.25133345f, 0.10178103f, 0.55075687f, -0.12045254f, -0.06863239f, 
    -0.13425407f, 0.12079226f, -0.09884205f, -0.20917368f, -0.02391475f, 0.16461113f, 0.00667402f, 0.07868793f, 
    0.33387008f, 0.39660579f, -0.10317647f, 0.37208909f, -0.12490711f, 0.08809787f, -0.13711490f, 0.21579097f, 
    -0.08060432f, -0.06268502f, 0.11365868f, 0.01221155f, 0.25923881f, 0.22222053f, -0.08186581f, 0.35647607f, 
    -0.04933880f, 0.09711943f, -0.04270541f, 0.25056344f, -0.19747294f, -0.00911209f, 0.13166821f, -0.15894434f, 
    -0.32499033f, -0.03171999f, -0.17107888f, 0.04286176f, 0.02564531f, 0.06680130f, 0.09338749f, 0.12258124f, 
    -0.13556041f, -0.08487566f, -0.05511860f, 0.06135998f, -0.02736109f, 0.17480019f, -0.03402914f, -0.50806028f, 
    0.01638926f, -0.10789285f, 0.10167758f, -0.23065719f, 0.06015176f, 0.11955152f, 0.13375416f, 0.02958422f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.14887804f, 0.11320269f, 0.15865652f, -0.08239803f, -0.07275913f, 0.05023183f, 0.05462397f, -0.19730555f, 
    0.08650929f, -0.01522936f, 0.01347311f, 0.00417568f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
