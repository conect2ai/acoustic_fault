#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.07426503f, 0.62483436f, 1.06303966f, -1.17021286f, 0.53358114f, -0.43475536f, 0.05879338f, 0.51459628f, 
    -0.22457659f, -0.94876778f, 0.67578721f, 0.62047565f, 0.72103083f, 0.69910657f, 0.53868085f, 0.41716713f, 
    -0.32798553f, -0.11528139f, 1.13172734f, 0.70165402f, -1.23641133f, 0.66853833f, 0.04803210f, -0.29106990f, 
    0.24130888f, 0.40078837f, 0.11119710f, -0.17666280f, -0.35227504f, -0.64161050f, 1.11119926f, -0.69166559f, 
    0.42574707f, 0.24186189f, 0.11710430f, -0.02765223f, 0.62583178f, 0.52602059f, 0.74381131f, 0.61233985f, 
    -0.30394769f, 0.72666299f, -0.29462859f, -0.34336674f, -0.53703225f, -0.53100276f, -0.98599178f, 0.82774508f, 
    0.09643369f, -0.38354892f, -0.51718122f, 0.29790959f, 0.06965274f, -0.35158318f, -1.40245092f, 1.12921083f, 
    0.95917177f, 0.13014765f, 0.54575557f, 0.34718817f, -0.19585006f, 0.28920510f, 0.09306806f, -0.07688116f, 
    -0.91581625f, -0.70265687f, -0.34634602f, -0.35525447f, 0.87031448f, -0.09309903f, 0.14583150f, 0.03445827f, 
    0.50290453f, -0.62549186f, -0.75254053f, 1.10559595f, 0.66214305f, -0.48200175f, -0.36090100f, -0.40838617f, 
    0.21538268f, 0.88456357f, 0.71052790f, 0.11614819f, 0.36555597f, 0.67516392f, 0.62391448f, 0.23548232f, 
    -0.38264912f, 0.23352934f, 0.57165146f, 0.54884297f, 0.22837503f, -0.04158721f, -0.95528579f, -0.59973860f, 
    -0.18640170f, 0.89647067f, 0.56590217f, 0.99964648f, -1.22270977f, 0.99607587f, 0.81833678f, 0.35029727f, 
    -0.11837369f, 0.18454619f, -0.30408728f, 0.04871444f, 1.05414307f, -0.81706822f, -0.74971306f, -0.28500327f, 
    -0.42084849f, -0.61513853f, -0.21390125f, -0.07905365f, -0.20833007f, -0.26052049f, -0.14637877f, -0.87978184f, 
    -0.41895723f, -0.48928824f, 0.36879277f, -0.60707980f, 0.11170084f, 0.19362171f, -0.61798280f, -0.32810456f, 
    -0.71258634f, 0.30016026f, 0.74395901f, -0.27459675f, -0.12110545f, -0.16761473f, -0.71382111f, -1.20901179f, 
    0.61049068f, -1.04728198f, -0.00720599f, 0.28345636f, -0.87788880f, 0.30110505f, -0.17975485f, 0.40016344f, 
    1.13649178f, 0.86522061f, -0.92079651f, -0.49991688f, -0.29461300f, -0.46275970f, -0.13655663f, -0.17978358f, 
    0.44834155f, 0.45354849f, 1.16270530f, 0.54837227f, -0.37455419f, 0.82161790f, -0.07675700f, -0.06827444f, 
    0.13708796f, -0.34336835f, 0.93669266f, 1.00113273f, 0.60717696f, -0.81483853f, -0.47798252f, -0.11245788f, 
    0.21564700f, -0.38427100f, -0.45415944f, 0.94349343f, -0.98627156f, 0.52883315f, -1.10300481f, 0.67588657f, 
    -0.55196255f, 0.20497604f, 0.19965346f, -0.15671308f, 0.51957893f, -0.73647112f, 1.06216943f, 0.17278184f, 
    0.40088627f, 0.59848702f, -0.53305930f, -0.43859518f, 0.10926112f, 0.03100544f, -0.42065924f, -0.29112563f, 
    -0.68984842f, -1.14817083f, -0.87824219f, 0.39475739f, 0.24662575f, -0.22166327f, -1.03898287f, 0.89163148f, 
    -0.53308856f, 0.28357229f, 1.04709601f, 0.47168800f, -0.37403351f, -0.20845555f, 0.50955385f, -0.32344127f, 
    -1.05338717f, -0.66116083f, -0.56582326f, 1.12003183f, 0.39320371f, 0.28343388f, 0.41552463f, 0.30128124f, 
    0.76238751f, 0.52388543f, 0.77340043f, -0.86314595f, 0.26533744f, -0.43977943f, 0.48017725f, 0.15627313f, 
    0.34556198f, -0.87095535f, -0.77184236f, -0.08747572f, 0.75991648f, -0.05517539f, -0.80853730f, -0.35304353f, 
    0.51293921f, -0.05727775f, 0.68773705f, 0.84513557f, 0.74968106f, 0.05508588f, -0.75248164f, -0.14353350f, 
    -0.64560539f, 0.03864379f, 0.16450873f, -0.75789112f, -0.58139056f, -0.11971836f, 0.58377558f, -0.30785668f, 
    -0.18892716f, -0.46846503f, -0.65036660f, -0.51474172f, 0.83074611f, -0.87661225f, 0.24437064f, -0.56524742f, 
    -0.69206065f, -0.19402239f, -0.16081183f, -0.47188270f, 0.00729167f, -0.12133376f, -0.46480027f, -0.67701602f, 
    -0.51982319f, -0.56741190f, -0.14773354f, -0.51842970f, 0.28731719f, 0.28193510f, -0.93243468f, -0.87631303f, 
    -0.47192496f, -0.08796506f, 0.06693722f, 0.74423647f, 0.53523839f, 0.15302549f, 0.47806895f, -0.56499106f, 
    -1.51762652f, -0.48566693f, 0.68320090f, 1.06846488f, 0.79151368f, -0.39373001f, -0.03108438f, -0.42202216f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.16332942f, 0.27525875f, 0.28911009f, 0.12733507f, -0.02386438f, 0.17075028f, 0.11493466f, 0.11205821f, 
    0.18282415f, 0.24540564f, -0.15169151f, -0.06698211f, 0.06446668f, 0.30540916f, 0.06890344f, 0.15032455f, 
    0.15274411f, 0.13435850f, -0.09775190f, 0.17621943f, 0.19157767f, 0.05992386f, 0.18598005f, 0.29273462f, 
    0.09760068f, 0.24339104f, 0.20713231f, -0.05733013f, 0.29171073f, 0.22482643f, 0.35372791f, 0.28269032f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.00490895f, -0.03814200f, -0.00249993f, -0.00220416f, 0.00968149f, 0.00720027f, -0.00593185f, -0.03160721f, 
    -0.03632634f, 0.03311549f, 0.00007971f, 0.00468592f, 0.00987743f, -0.00069509f, -0.02577729f, 0.02824454f, 
    0.02145557f, -0.02651919f, -0.03668622f, 0.01479316f, 0.02454699f, 0.00102339f, -0.00392320f, -0.01922284f, 
    -0.02726025f, 0.03156942f, 0.00515148f, 0.01546122f, 0.00816762f, 0.02219734f, 0.00826989f, 0.00823802f, 
    0.01676502f, 0.03512016f, 0.00953374f, 0.01077701f, -0.01166281f, -0.04318615f, -0.02230553f, -0.00130723f, 
    0.02513936f, 0.02682621f, 0.01733772f, 0.03002188f, -0.02409361f, -0.01509036f, -0.03009732f, 0.00487322f, 
    -0.01071938f, -0.02979923f, -0.02279711f, 0.02360501f, -0.00852175f, -0.02507898f, 0.00652272f, -0.00753634f, 
    0.03814530f, 0.02624799f, -0.02330974f, -0.00522894f, 0.03025653f, 0.01827212f, -0.00990788f, -0.03284739f, 
    -0.02005811f, 0.03191752f, 0.00978825f, 0.02931929f, -0.02474263f, 0.01337563f, -0.00374677f, -0.00236882f, 
    0.01242805f, 0.03074762f, -0.03105798f, -0.01253452f, 0.03860522f, -0.03297951f, -0.02947322f, 0.00776820f, 
    -0.04176628f, 0.01172118f, -0.00944930f, -0.04290147f, -0.01109705f, -0.02075412f, -0.01894521f, -0.03142496f, 
    -0.01544184f, -0.01323666f, -0.00159658f, 0.00128716f, -0.02487915f, -0.01581366f, 0.01272711f, -0.03171138f, 
    0.00636688f, -0.00343504f, -0.03423922f, 0.03535172f, 0.00554527f, -0.03038039f, 0.01285892f, 0.00397828f, 
    -0.03526789f, 0.00555206f, 0.01387848f, -0.04460888f, -0.01870592f, 0.03011409f, 0.01993871f, 0.00158704f, 
    0.01526278f, -0.01554388f, -0.01066525f, -0.01647801f, -0.04232281f, -0.00506953f, -0.02737594f, -0.04022170f, 
    0.04482106f, -0.00771363f, 0.01432569f, -0.03261508f, -0.01756678f, -0.03493753f, 0.02188713f, 0.00198688f, 
    0.02316671f, 0.02485688f, -0.01928519f, 0.01949245f, -0.01304817f, -0.03520816f, -0.02190969f, 0.00816905f, 
    0.02415578f, 0.00283070f, 0.02142540f, -0.03908881f, -0.00499162f, -0.02436333f, -0.01381524f, 0.01973777f, 
    -0.00403138f, -0.00795803f, 0.01552912f, -0.00813367f, 0.03040068f, -0.00918577f, -0.00022189f, -0.01937181f, 
    0.00763892f, -0.00438659f, -0.02040041f, -0.02810591f, -0.00189481f, -0.03171084f, -0.03950178f, 0.00690628f, 
    -0.00400294f, 0.00023282f, 0.02608567f, 0.00430944f, -0.01093087f, 0.02316437f, 0.01606649f, 0.00747942f, 
    -0.02379053f, 0.02322467f, -0.04447524f, -0.03789015f, -0.04375849f, -0.04026930f, 0.03185218f, -0.00697630f, 
    -0.01813841f, 0.01863343f, -0.01731356f, 0.01811195f, -0.04192666f, -0.01508438f, 0.02684570f, -0.03993820f, 
    -0.01351419f, -0.00252521f, 0.00046373f, 0.01634020f, -0.00980285f, 0.03622450f, -0.00528822f, 0.03414500f, 
    -0.02013909f, 0.02705794f, 0.01318476f, -0.04033267f, -0.00968020f, 0.00186985f, -0.00205341f, 0.00472215f, 
    -0.02372865f, -0.00101552f, -0.02005401f, 0.00369134f, -0.03734561f, 0.03230932f, 0.03193079f, -0.01103127f, 
    -0.01219036f, -0.00441020f, 0.00127953f, 0.00242954f, 0.01373679f, 0.02202367f, -0.02705913f, -0.02735313f, 
    -0.02331102f, 0.01120269f, 0.00859362f, -0.01255675f, 0.00257174f, -0.01165128f, 0.02570587f, 0.02240258f, 
    0.02933027f, 0.03993105f, 0.01687083f, -0.01573765f, 0.01199929f, -0.00822421f, -0.00136557f, -0.04218364f, 
    0.03445734f, -0.00635329f, -0.02750573f, -0.00469259f, 0.04776124f, -0.00175880f, 0.02426870f, 0.00010834f, 
    0.02259487f, 0.02125125f, -0.00872670f, 0.03063490f, -0.00350919f, -0.01404605f, 0.01850984f, -0.03101249f, 
    -0.00753253f, -0.03462558f, -0.01285891f, 0.02056199f, 0.03151121f, -0.02594988f, 0.02072152f, 0.02241772f, 
    0.02229561f, 0.00918545f, 0.02040114f, 0.01017075f, -0.03167548f, 0.00368010f, -0.00452850f, -0.04431800f, 
    -0.04330145f, -0.02903960f, 0.02083897f, -0.04370729f, -0.02073168f, -0.01036166f, -0.02942762f, -0.03377325f, 
    -0.01867131f, -0.02731390f, 0.03069092f, -0.02190724f, -0.01963401f, -0.01795745f, -0.03961914f, 0.01002270f, 
    -0.03209101f, -0.01735787f, 0.01772722f, -0.03141386f, 0.01601789f, -0.01494075f, -0.00589663f, -0.02888324f, 
    -0.03855966f, -0.00724408f, 0.02502496f, 0.02692653f, 0.01002035f, -0.00811703f, -0.03128396f, 0.02101880f, 
    0.00921226f, 0.02078700f, 0.01226905f, -0.00071825f, -0.01163081f, 0.00321908f, 0.01529476f, -0.03322993f, 
    -0.01859017f, 0.02818671f, -0.01078363f, -0.04233837f, -0.00652744f, 0.00195672f, -0.00673344f, -0.02123215f, 
    0.00817295f, -0.03445965f, 0.01266359f, -0.01121956f, 0.02058508f, -0.00696833f, 0.02245079f, -0.01267165f, 
    -0.04303336f, 0.00392161f, 0.03080310f, -0.04225347f, -0.02351020f, 0.01117548f, -0.00685500f, 0.01638628f, 
    0.01309999f, -0.03706780f, 0.00703410f, -0.02020223f, -0.02223803f, 0.01534104f, -0.01942727f, -0.02264644f, 
    0.01499205f, 0.01461822f, -0.02668011f, 0.00682181f, 0.01849342f, 0.01720272f, 0.01989528f, 0.00628189f, 
    0.03519446f, 0.01764621f, -0.04213644f, -0.03040985f, -0.02714041f, -0.04233654f, -0.00333202f, -0.03362130f, 
    -0.03028396f, -0.03706333f, -0.03676173f, 0.01828670f, -0.00488173f, -0.01511261f, 0.01553220f, -0.00911402f, 
    -0.00393867f, -0.03312575f, -0.01227222f, 0.02902700f, -0.00426067f, -0.02404508f, -0.03553863f, -0.02416534f, 
    -0.01009354f, -0.03400314f, 0.02393430f, -0.03872203f, -0.03475253f, -0.03211427f, 0.02256698f, 0.01901686f, 
    0.02405858f, 0.03669769f, 0.03401646f, 0.00660774f, 0.00675559f, -0.03577923f, -0.02574646f, 0.01490449f, 
    0.03250378f, -0.03297526f, -0.03830407f, 0.02546692f, 0.00442367f, -0.00778468f, -0.04036515f, 0.00493260f, 
    0.02173107f, -0.03903127f, -0.02932184f, 0.01382691f, 0.02292774f, -0.01423338f, 0.00557302f, 0.00915981f, 
    -0.00582279f, -0.02813506f, 0.00604233f, 0.02099369f, -0.01800317f, -0.01875100f, -0.02683697f, 0.02342592f, 
    -0.01700657f, 0.00485450f, -0.03570408f, -0.03011734f, 0.01947079f, -0.04224250f, -0.03698194f, 0.00278854f, 
    0.01413813f, 0.02994698f, -0.01864151f, -0.03106598f, -0.01597191f, -0.03492486f, -0.01319195f, -0.01782815f, 
    -0.02775929f, -0.00067722f, 0.01854631f, 0.01076985f, -0.03542400f, -0.02710940f, -0.03499422f, -0.03746570f, 
    0.01358307f, -0.00114576f, 0.02788044f, 0.01023908f, 0.00351719f, 0.01683532f, -0.03756100f, 0.02803302f, 
    -0.01422199f, 0.00478868f, 0.02541740f, 0.01386030f, -0.00470035f, 0.01337521f, -0.02381944f, -0.03901555f, 
    0.00425751f, -0.03239804f, -0.03957561f, 0.02131007f, 0.02419073f, 0.01591570f, 0.03476404f, -0.00332648f, 
    0.00566934f, 0.00868169f, -0.02520677f, 0.00659993f, -0.01073800f, -0.03089581f, 0.03351446f, 0.00574689f, 
    0.01146725f, 0.01320089f, -0.00660776f, -0.01122360f, -0.01598087f, 0.02511769f, -0.00872331f, -0.01569891f, 
    -0.03523530f, 0.01465509f, -0.03088620f, 0.01335393f, -0.03440316f, -0.02340950f, 0.01945179f, 0.00779799f, 
    -0.03881442f, 0.01099044f, 0.02921546f, 0.00681651f, 0.02925339f, -0.04158944f, 0.01205752f, -0.01189733f, 
    0.01657573f, -0.02387994f, 0.02637133f, 0.01372886f, 0.00100320f, 0.01723959f, -0.03131366f, -0.01791843f, 
    -0.03526103f, -0.00728553f, -0.00737704f, 0.01266961f, -0.04399573f, 0.02555152f, 0.02447143f, -0.00690137f, 
    -0.02926875f, 0.00503516f, 0.03123415f, -0.03120315f, -0.01261200f, 0.01111020f, 0.02883008f, -0.03389046f, 
    -0.02053769f, -0.01256808f, 0.02772841f, -0.04474614f, -0.00515941f, 0.03010773f, 0.01682756f, -0.02898435f, 
    0.00243715f, 0.01776126f, -0.00166933f, -0.03202685f, -0.00622225f, -0.03917260f, -0.02731638f, -0.00019051f, 
    0.02160961f, -0.01569548f, -0.03879759f, -0.03004499f, 0.01003166f, 0.00147279f, -0.02908374f, -0.04325895f, 
    0.01360115f, 0.01758950f, -0.00033065f, 0.00989974f, -0.03057443f, -0.03039940f, -0.00830642f, 0.00350377f, 
    0.00079254f, 0.02287681f, 0.02683333f, 0.02048648f, -0.02925147f, 0.03412510f, -0.02416524f, -0.03762729f, 
    0.00296077f, 0.02934808f, 0.01515601f, -0.00787663f, -0.00850779f, -0.04646903f, 0.00286856f, -0.03172977f, 
    -0.00015461f, 0.01405036f, 0.01714750f, 0.00131960f, -0.01602399f, -0.01282612f, 0.02216173f, 0.02026485f, 
    0.03254377f, 0.01818141f, 0.02302898f, 0.00095055f, 0.03303798f, 0.00815566f, 0.02883762f, -0.03278634f, 
    -0.01382159f, -0.02510009f, -0.03548851f, -0.02779488f, -0.02625460f, -0.02771933f, -0.02298364f, -0.00983155f, 
    -0.02951122f, -0.03341474f, -0.03843247f, 0.00791929f, 0.02105235f, 0.00817655f, 0.00131510f, -0.00265756f, 
    -0.03417453f, 0.02470401f, 0.00871814f, -0.04111224f, -0.03023176f, 0.02848235f, -0.03504781f, -0.02193826f, 
    -0.02726826f, -0.00438852f, 0.02065177f, -0.03653887f, 0.02081299f, -0.03321591f, 0.01969312f, -0.01690327f, 
    -0.00540896f, 0.01827429f, -0.04068626f, 0.01039668f, -0.02419109f, 0.02573529f, -0.04019307f, -0.03886345f, 
    0.02379031f, 0.01938606f, 0.00235419f, 0.02430724f, 0.00289821f, -0.02074561f, 0.02950084f, -0.00915727f, 
    -0.01363826f, -0.00445345f, -0.02521758f, -0.02747422f, -0.00336255f, 0.03047967f, 0.00559378f, -0.03009694f, 
    0.00591413f, -0.02273458f, 0.02891407f, -0.00601467f, 0.00667764f, -0.03139276f, -0.04482879f, -0.00999540f, 
    0.22837611f, -0.15922821f, -0.20964234f, -0.01010368f, 0.01775229f, -0.10079815f, 0.00115281f, -0.01165241f, 
    0.05864377f, 0.00349985f, 0.03945471f, 0.07918900f, -0.00470062f, 0.17391917f, 0.14078003f, 0.05918401f, 
    -0.00948646f, 0.08140055f, 0.02069909f, 0.08344191f, -0.25098360f, 0.20003542f, 0.06324388f, -0.04295823f, 
    -0.07196675f, 0.09435073f, -0.04501100f, -0.10324910f, 0.02710173f, -0.02952794f, 0.00729122f, 0.11419050f, 
    -0.05945389f, 0.00928457f, -0.15149958f, -0.01578837f, 0.00578914f, 0.20829570f, 0.03334337f, 0.10594618f, 
    -0.18800752f, 0.22921678f, 0.01053251f, -0.14763728f, 0.01211238f, 0.06561953f, -0.05656331f, -0.01693349f, 
    -0.07726239f, 0.05950803f, 0.12714523f, 0.05870629f, -0.03124143f, 0.10304542f, -0.02610146f, 0.05111334f, 
    0.07759292f, -0.15934043f, 0.21758336f, -0.01317076f, -0.14665212f, 0.07289121f, 0.33423099f, 0.01517793f, 
    -0.00844102f, 0.15682794f, -0.07821627f, -0.02321690f, 0.02968050f, 0.01690291f, 0.17457172f, 0.07548817f, 
    0.02858560f, -0.00869650f, -0.13684504f, 0.19185469f, 0.04437592f, -0.06427641f, 0.01106811f, -0.07335743f, 
    0.27390072f, -0.03488874f, 0.02214555f, -0.12168153f, -0.18884739f, 0.06260469f, 0.00437856f, -0.06829736f, 
    -0.11737837f, -0.01679605f, 0.05179246f, 0.03133907f, 0.06466127f, 0.04122048f, -0.09160971f, -0.16150324f, 
    -0.02206803f, 0.31730640f, -0.02559249f, -0.05284185f, -0.20370923f, 0.23779656f, 0.17598654f, 0.20048118f, 
    0.18128218f, 0.05776784f, -0.01635557f, -0.13780355f, 0.01853855f, 0.05302842f, -0.03117633f, -0.01147844f, 
    0.09181905f, 0.12206285f, 0.18321918f, 0.02035218f, 0.04991543f, -0.12529297f, -0.12941000f, -0.08242135f, 
    -0.55558312f, -0.02678672f, 0.07489669f, 0.03473552f, -0.15300220f, 0.11474379f, 0.11073714f, -0.24596868f, 
    0.06986520f, -0.06766327f, 0.01473569f, -0.01657878f, 0.02990187f, -0.04205663f, 0.01796523f, 0.05051326f, 
    0.15576625f, 0.14041069f, 0.04716949f, 0.09454081f, -0.40880471f, 0.10353298f, 0.04616661f, -0.03545402f, 
    0.09405225f, 0.01967165f, 0.07850294f, -0.07024412f, 0.03583378f, 0.01899880f, 0.01756383f, 0.09746040f, 
    -0.05154900f, 0.03154247f, -0.04121209f, 0.00461142f, 0.09972733f, -0.04476587f, -0.17047594f, 0.14845300f, 
    0.20562638f, 0.32534853f, 0.04541560f, -0.13829465f, -0.19976972f, -0.00856979f, 0.15854301f, 0.05489291f, 
    -0.01406789f, -0.01713894f, 0.16734463f, -0.06611790f, 0.01767611f, -0.11693783f, 0.07553396f, -0.04704939f, 
    0.14011700f, -0.20092636f, 0.23216617f, -0.15140691f, 0.43447188f, 0.14992906f, 0.02179966f, -0.06898592f, 
    0.00155372f, 0.16977699f, 0.09140085f, 0.05807500f, -0.12602419f, -0.00770612f, 0.07047348f, 0.07978673f, 
    -0.04521963f, -0.00852609f, 0.02537065f, 0.04061172f, 0.01641001f, 0.20802981f, 0.13202113f, 0.05865676f, 
    0.21604516f, -0.10559309f, -0.25961021f, 0.09560984f, 0.13413158f, -0.03003298f, -0.11383111f, -0.03827763f, 
    -0.04665617f, 0.01417967f, 0.02591537f, 0.05727170f, 0.06607288f, 0.17675567f, 0.01534501f, 0.09874708f, 
    0.10458687f, -0.00950233f, 0.04682539f, 0.03254709f, -0.34545112f, 0.28055966f, 0.15983883f, 0.19628954f, 
    -0.10836239f, 0.04583901f, 0.02046099f, -0.08359464f, -0.06635815f, 0.05269086f, 0.10198156f, 0.07605897f, 
    -0.11231323f, 0.04306925f, -0.02968093f, 0.02091368f, 0.11262808f, -0.10696348f, 0.12710309f, -0.13880624f, 
    -0.08663589f, 0.12677883f, 0.10818138f, 0.21430735f, 0.10015359f, 0.03793970f, -0.14174022f, 0.01582093f, 
    -0.02548416f, 0.01364910f, 0.07299536f, 0.08537516f, 0.02254089f, -0.01131349f, 0.03466339f, -0.17908615f, 
    -0.00156435f, -0.19903585f, -0.10723372f, -0.11579065f, -0.05384997f, 0.13829164f, 0.14054039f, 0.04800846f, 
    0.01311003f, 0.11271496f, 0.27871367f, -0.03764991f, -0.01592963f, 0.00872792f, -0.00647155f, 0.05824202f, 
    0.00403968f, -0.01497313f, 0.03924372f, -0.05571004f, 0.04647816f, 0.00464096f, -0.01283616f, 0.05216854f, 
    -0.00544728f, 0.25272533f, 0.08091585f, -0.07708790f, 0.07489615f, 0.14842741f, -0.06866677f, 0.17670631f, 
    -0.05967986f, -0.10971878f, 0.00658512f, -0.00338679f, -0.15048034f, -0.10855299f, -0.12428091f, -0.08669139f, 
    0.00277763f, -0.18754055f, -0.06078747f, 0.05626693f, -0.37486443f, -0.10688049f, 0.03367422f, 0.03953265f, 
    -0.20105365f, -0.03091696f, -0.05367276f, 0.04644553f, -0.00568630f, 0.16053921f, 0.04608062f, 0.02167460f, 
    0.28970817f, -0.04960153f, -0.09492101f, -0.09029258f, 0.13137482f, -0.27217487f, -0.04263650f, -0.03506653f, 
    -0.06477054f, -0.03899594f, 0.02884303f, 0.10800087f, 0.31603208f, -0.03859940f, -0.06793490f, -0.06424605f, 
    -0.06608754f, -0.09630003f, 0.00904770f, -0.10123677f, 0.01577552f, 0.05335563f, 0.13320640f, -0.02780750f, 
    0.04746323f, -0.23840833f, 0.04025505f, -0.02646115f, 0.24535704f, -0.34422657f, -0.23254074f, 0.14662223f, 
    -0.05085522f, -0.05665347f, 0.08806164f, -0.13644205f, -0.15845889f, 0.05640577f, 0.10978804f, 0.05252871f, 
    0.00579670f, -0.02887186f, 0.16055094f, 0.05577514f, -0.04557234f, 0.06868765f, 0.09538250f, -0.01170482f, 
    0.08659720f, -0.15563563f, 0.00493463f, 0.07814173f, 0.20214909f, -0.00865256f, 0.13839270f, -0.15185572f, 
    -0.09141991f, -0.06571781f, 0.00953197f, -0.10880964f, 0.12718225f, 0.26327196f, 0.15705591f, -0.15350828f, 
    0.01959928f, 0.05514811f, -0.06348602f, -0.09708792f, -0.30490357f, -0.09385947f, -0.14100568f, -0.02824589f, 
    0.16117039f, 0.06172823f, 0.06907446f, 0.07472486f, 0.00571065f, 0.04089601f, 0.10905609f, -0.01156443f, 
    -0.10266612f, -0.08039137f, 0.00161412f, -0.13817887f, 0.03108615f, -0.03919397f, -0.12058125f, -0.04534014f, 
    -0.05158434f, 0.19862518f, 0.05864886f, -0.07237776f, 0.02547071f, -0.09565572f, 0.02311200f, -0.15277915f, 
    -0.08448247f, -0.05826862f, 0.02541365f, 0.02557386f, -0.06581867f, 0.04375477f, -0.07173181f, 0.01421624f, 
    -0.11872834f, 0.10716712f, -0.01474157f, 0.17040448f, 0.18223004f, 0.18720835f, 0.15661965f, -0.02309035f, 
    0.21666853f, -0.03112437f, -0.26815379f, -0.09653964f, 0.11124042f, -0.03323817f, 0.05989071f, 0.04254571f, 
    0.24407098f, 0.13230333f, 0.01554117f, 0.03482854f, 0.08538110f, -0.22586486f, -0.24333988f, -0.02551180f, 
    -0.27999148f, 0.07714067f, 0.01475621f, 0.03638254f, 0.05158718f, -0.07130993f, 0.11085663f, -0.10562368f, 
    -0.02331159f, 0.05724011f, 0.05758749f, 0.01792671f, 0.00751410f, -0.02869687f, 0.02433425f, 0.06318249f, 
    0.01015787f, 0.02458562f, 0.12313579f, -0.00484576f, -0.27137539f, 0.17271399f, -0.07852717f, -0.04754445f, 
    0.02986777f, -0.00431318f, -0.07336840f, 0.03789466f, 0.09941804f, -0.09258214f, -0.01890479f, 0.06384078f, 
    -0.01578597f, -0.00825205f, -0.06075699f, 0.05798061f, 0.07362816f, -0.06234497f, 0.08052103f, 0.03503429f, 
    0.10828523f, -0.21087471f, -0.17678764f, -0.04618807f, 0.14440674f, 0.01139694f, 0.03568879f, 0.09020206f, 
    -0.05780454f, 0.08390678f, -0.01113532f, -0.04915771f, 0.04568149f, 0.06571884f, 0.03202122f, 0.09882399f, 
    0.20712247f, 0.01984498f, 0.02022372f, 0.17163631f, -0.30475044f, 0.17615677f, 0.01694487f, 0.12210690f, 
    -0.13510841f, 0.06523644f, 0.01053823f, 0.06784040f, -0.06075209f, -0.02941773f, -0.09129006f, 0.12751867f, 
    0.03029543f, -0.07384115f, 0.07649253f, 0.01368529f, 0.09913798f, -0.04580096f, 0.06238034f, -0.11204617f, 
    0.13430305f, -0.09714315f, 0.09144964f, 0.04680416f, 0.15431319f, 0.08708760f, -0.09066871f, -0.15477036f, 
    -0.10090044f, -0.06234393f, -0.05220205f, -0.02066315f, 0.07845458f, 0.12022886f, 0.11923740f, -0.02110999f, 
    -0.01696530f, 0.14162038f, 0.00184692f, -0.00474645f, -0.02178723f, 0.30235684f, 0.21006876f, 0.24803779f, 
    -0.06702580f, 0.14529952f, -0.01519605f, 0.04722482f, -0.12456851f, -0.01212159f, 0.09663007f, 0.08565070f, 
    0.07779881f, -0.06982838f, 0.03709433f, -0.08590930f, -0.11398229f, 0.02646242f, 0.05449386f, 0.02713866f, 
    -0.17048618f, -0.05623053f, 0.01432185f, 0.06695232f, 0.11488798f, -0.02446378f, -0.11074971f, -0.09627610f, 
    0.03443013f, -0.03918396f, 0.11980398f, 0.09645493f, 0.05122647f, 0.08692293f, -0.02022391f, -0.05908756f, 
    -0.04275744f, -0.03789134f, -0.24919032f, -0.07299392f, 0.04450695f, 0.10297024f, 0.05343057f, 0.03681932f, 
    0.04859502f, 0.02895524f, 0.03878567f, -0.00216070f, -0.00087295f, 0.04540113f, 0.08288436f, 0.09885687f, 
    0.06591459f, 0.00989822f, 0.01794813f, -0.03918093f, 0.06715565f, -0.03889570f, -0.14036427f, 0.02124161f, 
    -0.23866227f, 0.00339382f, 0.06808762f, -0.00617877f, 0.05837982f, 0.06263506f, -0.00208420f, 0.15228394f, 
    0.04424806f, -0.06857615f, 0.01730405f, 0.05471144f, 0.08673286f, 0.10418586f, -0.02697886f, 0.07884895f, 
    0.03894113f, 0.03829326f, -0.09981697f, 0.18216644f, -0.13312700f, 0.40478560f, 0.00995479f, 0.06828947f, 
    0.06465498f, -0.07458575f, 0.05000100f, 0.11943144f, -0.05916886f, -0.10674831f, -0.02210977f, -0.01946826f, 
    -0.19007050f, -0.09869891f, 0.01867727f, -0.01338563f, -0.03236959f, 0.12509865f, 0.09710253f, -0.12213345f, 
    -0.05193044f, -0.14184663f, 0.14694515f, -0.14974596f, -0.14091717f, -0.00217649f, -0.07989207f, -0.10644372f, 
    0.06760523f, 0.07008360f, 0.09516868f, 0.03148526f, 0.10290473f, -0.00017607f, 0.01064942f, 0.02461800f, 
    -0.05016205f, 0.13187461f, -0.03532794f, 0.10237814f, -0.03222105f, -0.05660348f, 0.07691242f, 0.03670206f, 
    0.16431051f, 0.00775956f, 0.13579340f, 0.00951163f, -0.03138579f, 0.06466481f, 0.00900572f, 0.04865676f, 
    0.10353719f, 0.02366713f, 0.16780448f, 0.10968968f, 0.03633518f, -0.01578461f, 0.03327392f, -0.02493878f, 
    0.01530718f, -0.12279304f, 0.23806605f, -0.09022668f, 0.23091625f, 0.04141030f, 0.08559144f, -0.01133299f, 
    0.00531493f, 0.06057749f, 0.02248017f, 0.05381881f, 0.00742940f, 0.03818445f, 0.02398652f, 0.01899512f, 
    0.02710968f, 0.04467878f, -0.04398041f, 0.09926032f, 0.13572748f, -0.21097600f, 0.09412182f, -0.18038133f, 
    -0.14631392f, 0.00164784f, 0.10751654f, 0.02007578f, -0.08151136f, 0.05963208f, 0.01708112f, 0.08059569f, 
    0.05695986f, 0.13012882f, 0.06549881f, -0.05685431f, 0.05435641f, -0.06105297f, -0.01174307f, 0.00123584f, 
    0.27767166f, 0.22582871f, 0.21360283f, 0.19504400f, 0.13981326f, -0.02570465f, 0.07106781f, -0.03626705f, 
    0.01235116f, 0.04417519f, -0.05911818f, 0.06861090f, -0.03186372f, 0.02562587f, 0.09888223f, 0.14778154f, 
    0.11077365f, 0.00036783f, 0.10472888f, -0.00273732f, -0.20220496f, 0.03063920f, -0.18899766f, 0.02087625f, 
    -0.21927305f, 0.05160695f, -0.12999363f, 0.05321217f, 0.01501681f, 0.00622474f, 0.02236865f, 0.05957526f, 
    0.04732565f, 0.06572587f, -0.02799799f, 0.03889874f, 0.03817859f, 0.08284575f, -0.07577767f, 0.11787412f, 
    -0.22013359f, -0.13780683f, 0.09433728f, 0.04906111f, 0.27885076f, 0.14895752f, -0.02825432f, -0.04520026f, 
    -0.05289827f, 0.00606584f, 0.07803732f, 0.00248363f, 0.09498709f, 0.01739995f, 0.08655354f, 0.02710092f, 
    -0.12183979f, 0.05703627f, -0.04921579f, -0.01990729f, -0.22907220f, -0.11481696f, -0.09337297f, -0.09158028f, 
    -0.03712052f, 0.01818098f, -0.01754582f, 0.04289000f, 0.08867122f, 0.01841718f, 0.12622546f, -0.00695443f, 
    0.08936245f, 0.02768611f, 0.05450584f, 0.01515787f, 0.05565399f, -0.02914122f, -0.06151286f, 0.04751487f, 
    0.03924308f, -0.03238233f, -0.11876899f, 0.00097605f, -0.01786971f, 0.09186780f, 0.09140500f, -0.03699952f, 
    0.05204666f, -0.00627504f, 0.01088741f, 0.09638744f, 0.09298599f, -0.05506231f, 0.04867085f, 0.13028446f, 
    0.09929145f, -0.05673662f, -0.00853927f, -0.03442190f, 0.01105279f, 0.12194178f, -0.01678945f, 0.15611993f, 
    0.20733878f, -0.01156955f, 0.06643824f, -0.04271954f, -0.02790094f, -0.04823431f, 0.01912352f, 0.08820558f, 
    0.02447809f, 0.05104519f, 0.10301339f, 0.00243069f, 0.13373604f, -0.00757637f, -0.02479400f, 0.04672839f, 
    0.13990448f, 0.14985247f, 0.12010608f, -0.29455239f, -0.00158576f, -0.10095862f, -0.05794979f, 0.04573251f, 
    -0.10805414f, 0.02905955f, 0.02355914f, -0.07091032f, 0.02153634f, -0.00664044f, -0.02066122f, -0.09279261f, 
    -0.02954618f, -0.15001182f, 0.08262447f, -0.00700026f, 0.57138216f, -0.25760871f, 0.07348397f, 0.03364316f, 
    -0.18150018f, 0.00527692f, 0.04285691f, 0.08437406f, -0.09022904f, 0.08257158f, 0.03455217f, 0.05697331f, 
    0.14301601f, 0.03208222f, 0.02097771f, -0.04530197f, 0.08600137f, -0.01287409f, 0.03234899f, -0.00743542f, 
    0.05681092f, -0.30964872f, 0.04865801f, -0.13843952f, 0.03208917f, 0.03893345f, -0.02039888f, 0.01603264f, 
    -0.01720977f, -0.01709262f, -0.05046599f, 0.03282124f, 0.05683029f, 0.04507366f, 0.10132152f, -0.05943999f, 
    -0.00540672f, -0.03604347f, -0.06021804f, 0.02048787f, -0.21675289f, -0.14202170f, 0.06140184f, -0.14531460f, 
    0.03280768f, 0.08075779f, -0.12718959f, 0.02216264f, 0.02946339f, 0.01358040f, 0.07903468f, -0.02933931f, 
    0.05521085f, 0.03840244f, -0.03579992f, 0.06663660f, 0.09357395f, -0.02190233f, 0.03914278f, 0.11191066f, 
    -0.00406090f, -0.11036143f, -0.21257983f, -0.02227554f, -0.16134946f, 0.15183984f, 0.11297800f, -0.03827546f, 
    -0.04083081f, 0.10529996f, 0.04182419f, 0.12390196f, -0.12774184f, -0.04956824f, 0.11545334f, 0.07629052f, 
    0.03844213f, -0.01609548f, -0.13901947f, 0.01144955f, 0.00021203f, -0.18870257f, -0.09847378f, 0.14548643f, 
    0.30641112f, -0.07218836f, 0.03421211f, 0.09042505f, -0.02255768f, 0.04791988f, -0.01362607f, 0.03235289f, 
    -0.06235434f, 0.01353655f, 0.12759092f, 0.08205302f, 0.06400368f, 0.04750777f, 0.02052097f, 0.00769587f, 
    -0.03578674f, -0.11562911f, 0.17703202f, 0.00673291f, 0.01747705f, -0.07636388f, -0.05740258f, -0.01129260f, 
    0.09493571f, 0.01518886f, -0.00617895f, 0.01172767f, 0.03857953f, 0.09933252f, 0.03914399f, 0.00178055f, 
    -0.03359885f, 0.02275719f, 0.04015158f, -0.09060746f, 0.07845955f, 0.18328115f, 0.15710296f, 0.06734786f, 
    0.27327359f, 0.07434569f, -0.00109240f, -0.02185983f, 0.05809290f, 0.06436284f, -0.05627793f, 0.00274505f, 
    -0.00635017f, 0.08009451f, -0.03097056f, 0.06472791f, 0.06287068f, 0.07447379f, 0.08083225f, -0.03648327f, 
    0.09934874f, 0.30049902f, 0.29669470f, 0.00211990f, -0.28069773f, -0.02498137f, -0.11333487f, -0.07041678f, 
    0.03702638f, 0.00986319f, -0.03086500f, 0.03669255f, 0.03482537f, 0.01069097f, -0.09057930f, 0.11019598f, 
    -0.01181465f, -0.01315051f, -0.04563976f, -0.05298096f, 0.24178709f, -0.30172831f, 0.03361258f, 0.14923202f, 
    -0.26973563f, 0.01590123f, -0.00455334f, 0.00323402f, -0.05318617f, -0.03622744f, 0.00430251f, 0.12887441f, 
    0.00012886f, 0.11518259f, 0.03970316f, -0.00699033f, -0.02372032f, 0.03302888f, 0.03102719f, 0.05977210f, 
    0.48171821f, 0.03119965f, 0.06095667f, 0.21858215f, -0.02535796f, 0.09134734f, 0.04684468f, -0.02168975f, 
    0.01586949f, 0.03579860f, 0.11107586f, 0.04163273f, -0.02596374f, -0.00203369f, -0.09072883f, 0.04182397f, 
    0.08082601f, -0.03136369f, -0.01273644f, -0.02134688f, 0.01442384f, -0.10308474f, 0.07248347f, -0.08228790f, 
    -0.10836867f, 0.02603455f, 0.02384758f, 0.12760970f, 0.13711329f, -0.02578283f, -0.11275177f, 0.01083171f, 
    -0.02944360f, 0.12276959f, 0.04205219f, 0.09098928f, 0.10658762f, -0.16506977f, 0.04996894f, -0.00736357f, 
    0.32738268f, -0.08594683f, -0.07114784f, -0.07980795f, 0.11430719f, 0.06898517f, 0.13982865f, -0.04715953f, 
    0.05176983f, -0.07494454f, 0.06367977f, 0.08277942f, 0.09035905f, -0.03643826f, 0.14601104f, 0.04795563f, 
    0.09663377f, 0.08647092f, 0.05355938f, -0.00256135f, -0.07286005f, -0.11561368f, -0.20411561f, 0.03776341f, 
    -0.02390670f, -0.00612549f, 0.06643745f, 0.04647921f, 0.04026931f, 0.08874825f, 0.06795011f, 0.04287886f, 
    -0.00022237f, 0.01965892f, 0.08994571f, 0.08873523f, -0.07731271f, -0.00895264f, -0.05368891f, 0.11571389f, 
    0.11880838f, 0.05956990f, 0.12964523f, -0.09940784f, -0.22274968f, 0.04543205f, -0.10798591f, -0.08450997f, 
    0.04884376f, 0.02179337f, 0.08082941f, 0.12546673f, 0.04600893f, 0.12569483f, 0.02061925f, -0.00789361f, 
    -0.08447362f, 0.03518610f, -0.03171853f, -0.01742122f, -0.15704569f, -0.04682514f, -0.11940669f, 0.10733253f, 
    -0.09600431f, 0.06756155f, -0.10494190f, 0.08579981f, -0.13536218f, 0.09408589f, 0.04846673f, 0.00853362f, 
    0.09960381f, 0.06936094f, -0.06691390f, 0.06535495f, 0.03295315f, 0.07712556f, -0.03568632f, 0.02488252f, 
    0.08461969f, 0.17963164f, 0.22689365f, -0.06037441f, -0.08788848f, -0.02473239f, -0.03189879f, -0.06099972f, 
    0.01797852f, 0.05782744f, 0.06893803f, -0.15627475f, -0.00420190f, 0.04565898f, 0.09528038f, 0.00728702f, 
    -0.01927724f, -0.09385765f, 0.00889217f, -0.06269193f, -0.01399754f, -0.00855955f, 0.00491043f, -0.18402869f, 
    -0.26850051f, 0.19109286f, -0.05339055f, 0.00801759f, -0.03574852f, 0.16967449f, 0.03510044f, 0.11606652f, 
    -0.03316081f, -0.03124656f, 0.05328218f, 0.14586256f, -0.00460655f, 0.08903623f, 0.03607691f, -0.13037306f, 
    0.04563555f, -0.20245691f, 0.08632573f, -0.02250587f, -0.21646398f, 0.00495039f, 0.08369353f, 0.07103916f, 
    -0.00929899f, 0.03562658f, 0.00925366f, 0.01868688f, 0.04704039f, 0.02234667f, 0.03535115f, 0.09570778f, 
    -0.01922357f, -0.07491297f, 0.03693413f, 0.05080792f, -0.36060444f, -0.19311377f, 0.05200349f, -0.08687299f, 
    0.05125497f, 0.07827578f, -0.02869898f, 0.10067680f, -0.00501278f, 0.03970925f, -0.03489448f, -0.14921418f, 
    -0.00212059f, 0.07071637f, 0.04981969f, 0.06304003f, 0.01116521f, 0.01162269f, 0.06535196f, 0.14312890f, 
    -0.07230356f, 0.02969855f, -0.21398151f, 0.02862058f, -0.06023254f, 0.03173396f, 0.00219275f, 0.07440957f, 
    0.12752233f, 0.07729664f, -0.00116789f, 0.03431968f, -0.03009736f, 0.03650414f, 0.04591079f, 0.08606082f, 
    0.14824426f, 0.00049571f, 0.10853080f, 0.08491856f, 0.32348621f, 0.03768041f, -0.17313877f, -0.08552679f, 
    -0.24810670f, 0.11943427f, 0.14237404f, 0.00578157f, 0.03662510f, 0.02912582f, 0.01267441f, 0.03971905f, 
    -0.00565181f, 0.12834297f, -0.02109231f, 0.08831501f, 0.02141602f, -0.08757170f, -0.07908302f, -0.00927105f, 
    -0.20921554f, 0.48380482f, -0.11936860f, 0.18599965f, 0.16793105f, 0.21642350f, 0.09807021f, 0.03374930f, 
    -0.01645641f, -0.03836396f, 0.02360562f, 0.04566607f, -0.07405013f, 0.07599526f, -0.11858457f, 0.04087774f, 
    0.01475097f, -0.06525694f, -0.05554702f, 0.05010894f, 0.21621513f, 0.16603367f, -0.04486823f, 0.09951256f, 
    0.10860159f, -0.08682724f, 0.00829415f, 0.00242675f, 0.02057723f, 0.06722038f, -0.00571206f, 0.01462731f, 
    0.05297720f, 0.00724176f, 0.11620373f, 0.05507849f, -0.01721197f, 0.04112239f, 0.02509528f, 0.01808716f, 
    0.48998758f, -0.44861045f, -0.19435118f, -0.01243734f, -0.12034936f, -0.15451214f, -0.09369741f, 0.05480674f, 
    0.02344833f, 0.12306646f, -0.01389802f, -0.08410681f, -0.04824017f, -0.00062578f, 0.05763389f, -0.05369750f, 
    0.02528207f, 0.02598281f, -0.01159292f, 0.03162575f, -0.08076651f, 0.19263235f, -0.12791701f, -0.04046205f, 
    -0.03391557f, -0.05180386f, -0.09083129f, 0.02167808f, -0.08538213f, 0.09605347f, 0.12229153f, -0.03244085f, 
    -0.02125969f, 0.05409025f, 0.10793782f, -0.04859982f, 0.13059427f, -0.06549348f, 0.01727224f, 0.14029202f, 
    -0.22852714f, 0.29993263f, 0.17355937f, 0.24941593f, 0.26408696f, -0.01103976f, 0.00575347f, -0.01075958f, 
    0.02644338f, 0.05375812f, -0.07218618f, 0.03473864f, 0.07138265f, 0.03234562f, 0.08754031f, -0.02581167f, 
    0.08656751f, 0.04611197f, 0.06410830f, -0.02883761f, -0.09680126f, -0.09552883f, 0.05973100f, -0.14174329f, 
    -0.43145809f, -0.01820648f, -0.00266788f, -0.06477877f, 0.02994594f, -0.02569157f, 0.02289594f, 0.02306531f, 
    0.06435174f, -0.00942820f, 0.00748038f, -0.03608453f, 0.00456676f, 0.05642745f, -0.00252245f, 0.02157385f, 
    0.17097510f, 0.39203042f, -0.25665438f, -0.10089590f, 0.07566062f, -0.18214847f, 0.14087313f, 0.03610570f, 
    -0.01094053f, 0.08051196f, 0.00936872f, 0.16627330f, 0.00107720f, -0.06334262f, -0.01792146f, -0.05298729f, 
    -0.12655571f, 0.07129060f, -0.00912122f, 0.03400841f, -0.08559570f, -0.14560616f, 0.09886230f, -0.09697171f, 
    -0.07059725f, -0.00250383f, -0.03678467f, 0.10024758f, 0.08855429f, 0.05021718f, 0.08578569f, -0.01765024f, 
    0.03708994f, 0.09981352f, -0.04315171f, -0.00085114f, -0.01683322f, -0.02984398f, 0.18346331f, -0.04771173f, 
    0.22773059f, -0.38277110f, -0.07922266f, -0.13709392f, -0.06218671f, -0.10580410f, -0.10099714f, -0.00008642f, 
    0.13195018f, -0.11310435f, 0.09089000f, -0.01713788f, 0.03292721f, 0.00670556f, -0.01311535f, 0.04752994f, 
    -0.09699813f, 0.02247108f, -0.00995200f, 0.02647392f, 0.20462415f, 0.14420749f, 0.00247641f, 0.10645069f, 
    0.20984611f, -0.01488955f, 0.00178889f, -0.03626375f, 0.12313762f, -0.04306693f, -0.07082722f, -0.00770241f, 
    0.10101697f, 0.04839551f, 0.01646134f, -0.04622078f, 0.13231803f, 0.03839450f, 0.07065166f, 0.02237026f, 
    -0.15991665f, -0.10070327f, 0.18195157f, 0.11442991f, 0.19554956f, 0.13720278f, 0.11872335f, 0.16365229f, 
    -0.09616679f, -0.06222695f, 0.08923471f, -0.08750933f, 0.03532695f, -0.06906916f, 0.05786597f, 0.07601830f, 
    0.04897649f, 0.08237258f, -0.14815232f, -0.03222411f, -0.09852292f, -0.04391441f, 0.13174598f, -0.03783429f, 
    0.06733710f, -0.03858845f, 0.01528877f, 0.00445268f, 0.02582651f, 0.04280309f, 0.09998412f, -0.12156090f, 
    0.14185910f, -0.16118152f, 0.13174231f, 0.06841430f, 0.07912442f, 0.07218187f, 0.14072262f, 0.04759908f, 
    0.05250559f, -0.18586093f, 0.02130145f, -0.24906643f, 0.06871422f, -0.04987038f, 0.09601301f, 0.02952836f, 
    0.02246280f, 0.02170160f, 0.14848776f, -0.13516612f, -0.00166221f, 0.04948813f, -0.05536974f, -0.03421079f, 
    -0.02509130f, 0.05357415f, 0.06054126f, 0.14796984f, -0.13666858f, -0.15730897f, -0.00306097f, -0.10369499f, 
    -0.03834271f, 0.02168576f, -0.12769890f, 0.06880004f, 0.05585299f, -0.00402658f, 0.02334386f, -0.10065427f, 
    0.04615224f, 0.03373678f, -0.06373835f, 0.07601462f, 0.07945493f, -0.04498556f, 0.06562924f, -0.06496973f, 
    0.30465078f, -0.18649919f, -0.25715393f, -0.21544597f, -0.01724919f, -0.05656003f, -0.09972995f, -0.13650188f, 
    0.01994755f, 0.16960381f, 0.15444443f, 0.08768355f, -0.09484459f, 0.03216321f, 0.27804530f, 0.01827501f, 
    0.06819585f, 0.12073797f, -0.08567452f, 0.04179390f, 0.03209083f, 0.42143601f, -0.14099395f, -0.16308281f, 
    0.06281513f, 0.19166858f, 0.02554329f, -0.04387173f, -0.04053226f, 0.02865558f, 0.07915170f, -0.08751084f, 
    -0.04613772f, 0.01060164f, 0.18149945f, 0.05767591f, -0.00774849f, -0.08546446f, 0.05976733f, 0.02174468f, 
    0.26981044f, -0.19381712f, -0.19660896f, -0.05033202f, -0.13762069f, 0.05245913f, -0.03333207f, 0.06707356f, 
    -0.03206148f, 0.06255720f, 0.08227935f, 0.01969432f, 0.04257798f, 0.05012025f, 0.10023952f, -0.00124889f, 
    -0.02216666f, 0.00252577f, 0.01676180f, 0.01380537f, -0.23413365f, 0.53097498f, -0.01340877f, 0.12644087f, 
    0.32946551f, 0.09988527f, 0.04768066f, 0.17112505f, -0.00976763f, -0.00035990f, -0.07246561f, -0.07319549f, 
    0.11193001f, 0.13303016f, -0.06879181f, 0.00634903f, 0.09409054f, -0.00088482f, -0.03510202f, -0.00200400f, 
    -0.14209075f, 0.23055115f, -0.08062097f, 0.26147208f, 0.14400761f, 0.12682182f, 0.03163737f, 0.15143587f, 
    0.00432666f, -0.05514606f, 0.04792120f, 0.10802341f, -0.06752610f, 0.04457991f, -0.08721993f, 0.19985978f, 
    -0.00730026f, 0.02984749f, 0.01150312f, -0.05428172f, 0.27730134f, 0.14863227f, 0.11444895f, 0.01488909f, 
    0.12213782f, 0.06248721f, 0.09483276f, -0.00942369f, -0.05415017f, -0.02926557f, 0.04021896f, 0.04352255f, 
    0.11335078f, -0.05817003f, -0.03880163f, 0.13483110f, 0.00365079f, -0.01149598f, 0.04716214f, 0.06799376f, 
    -0.17770308f, 0.10322380f, 0.03324135f, 0.09294175f, 0.07144792f, -0.05054905f, 0.01477187f, 0.03838240f, 
    -0.01558808f, 0.07049915f, 0.01627625f, 0.02841599f, 0.06482141f, 0.00984080f, 0.21364520f, 0.01026166f, 
    0.09317252f, 0.03852763f, 0.07639834f, -0.05260619f, -0.14689541f, -0.01556560f, 0.06311720f, -0.02777351f, 
    -0.19251835f, 0.22391632f, 0.17547092f, 0.05266117f, 0.02965088f, 0.01291538f, -0.07620179f, -0.04829536f, 
    -0.00311386f, 0.11383615f, 0.04097502f, 0.00489180f, 0.11696367f, 0.14500679f, 0.06518288f, 0.05213905f, 
    -0.09344014f, 0.40077788f, -0.06902608f, 0.04753952f, 0.15996975f, 0.00236944f, 0.05642982f, -0.05029868f, 
    -0.06048118f, 0.07822146f, 0.00550611f, -0.11440168f, 0.02001633f, -0.02591916f, 0.11691276f, 0.04364465f, 
    -0.00384699f, 0.02434789f, 0.07721208f, -0.02489618f, 0.40460336f, 0.02624172f, 0.04713376f, 0.03442496f, 
    0.10302164f, -0.08878563f, 0.04223010f, 0.06077398f, 0.03405700f, 0.01102399f, 0.10461181f, -0.11234142f, 
    0.09384955f, 0.07840436f, 0.07075350f, 0.21198173f, 0.03488620f, 0.00899081f, -0.05948375f, 0.03137928f, 
    0.01815271f, 0.25589585f, -0.01904078f, 0.21904825f, 0.03972514f, 0.10310940f, 0.07925870f, 0.12912488f, 
    0.00413267f, -0.06674656f, 0.06837311f, 0.10407867f, -0.02306011f, -0.00341846f, 0.03965726f, 0.09710647f, 
    0.03781938f, 0.00361198f, -0.06349431f, -0.14883924f, 0.30279329f, -0.10381618f, 0.02365391f, -0.22266595f, 
    -0.11551305f, -0.03109136f, 0.01936678f, 0.02279822f, -0.05103893f, -0.04728336f, 0.05743424f, -0.05411105f, 
    0.07255877f, 0.05849994f, 0.11798234f, -0.04496562f, 0.02929633f, 0.10479388f, -0.05469771f, 0.19167338f, 
    -0.11391566f, 0.15768123f, -0.02917649f, 0.29349190f, 0.21676050f, 0.01318311f, 0.05176894f, 0.12394191f, 
    -0.01438755f, 0.02375807f, 0.11172882f, 0.01732804f, 0.11057687f, 0.05056523f, 0.10120967f, 0.06929114f, 
    -0.00523210f, 0.03564834f, -0.07251403f, -0.05049330f, -0.09229057f, -0.13518195f, -0.06706864f, -0.29415154f, 
    -0.08550557f, -0.01350445f, -0.03697596f, -0.03586071f, 0.02106727f, -0.03095140f, 0.04879092f, 0.14379205f, 
    -0.00055584f, -0.02944119f, 0.08403327f, -0.05641045f, 0.13736238f, 0.02022465f, -0.06602651f, 0.03213948f, 
    -0.03856647f, -0.01149046f, 0.05371553f, -0.07622296f, -0.04838036f, 0.08239468f, 0.20816706f, 0.13109893f, 
    -0.01064562f, 0.08122999f, 0.06363186f, 0.02018403f, 0.06919700f, -0.01985917f, 0.01463159f, 0.01476463f, 
    -0.03287575f, 0.00717834f, 0.17390206f, -0.07336514f, -0.05068233f, -0.14779374f, 0.01529280f, -0.20792380f, 
    -0.09071697f, 0.04499841f, 0.00223776f, 0.04884587f, 0.08829294f, -0.06713429f, -0.10132802f, -0.13695526f, 
    0.04494480f, 0.13142695f, 0.04800950f, -0.01930854f, 0.04965027f, 0.05272054f, 0.03962692f, 0.00454294f, 
    0.23202440f, 0.11902066f, 0.07430267f, -0.06903421f, -0.08704941f, -0.08615732f, 0.03987900f, -0.00859526f, 
    0.05645663f, 0.07530617f, 0.01889676f, -0.01042002f, 0.04972348f, 0.04221787f, -0.01613004f, 0.08217589f, 
    0.10225550f, 0.08482778f, 0.00850413f, 0.11022720f, 0.16387920f, -0.21333478f, -0.03177698f, -0.10364066f, 
    -0.01385916f, -0.14176004f, -0.10619622f, -0.04949565f, 0.09632223f, 0.07809100f, 0.09947918f, 0.06031352f, 
    0.06391258f, 0.04555934f, 0.08403277f, 0.12493863f, 0.12795739f, -0.01385123f, 0.00755117f, 0.11428819f, 
    0.00715297f, 0.02499319f, 0.01131018f, 0.02162303f, -0.04098028f, -0.04136134f, 0.02572377f, 0.02714480f, 
    0.02739737f, -0.01732475f, -0.00478138f, 0.03053530f, -0.02787755f, -0.00186765f, -0.03960099f, 0.00978864f, 
    -0.00581068f, -0.00393329f, 0.01579695f, -0.02056273f, 0.02186608f, -0.03660765f, -0.00229905f, -0.01511582f, 
    0.03252470f, -0.01276887f, 0.00414350f, -0.04118765f, -0.00601413f, 0.02792175f, -0.00137610f, -0.02238166f, 
    0.03123155f, 0.03119132f, 0.02168066f, -0.01128366f, -0.02525678f, -0.00887449f, -0.00829700f, 0.02759180f, 
    -0.04481033f, 0.01185012f, 0.02911063f, -0.00069962f, -0.02882855f, -0.01330539f, -0.00009239f, -0.02042684f, 
    -0.02382735f, 0.02289912f, 0.00624100f, -0.04251354f, 0.01441232f, 0.01605407f, 0.00781312f, 0.00283720f, 
    -0.00809022f, 0.02077176f, 0.02262108f, 0.03378670f, -0.00217063f, -0.00976156f, -0.00229332f, 0.02062364f, 
    0.02428084f, 0.00002058f, -0.03880335f, -0.03479108f, -0.03818645f, -0.02839527f, 0.00096587f, -0.03294545f, 
    -0.01062985f, -0.01785096f, 0.03343352f, -0.03848203f, 0.03249477f, -0.04504285f, -0.04056323f, -0.00912953f, 
    0.01259776f, -0.02479694f, 0.00230867f, 0.03149614f, 0.02654563f, 0.01512195f, 0.02656176f, 0.02878848f, 
    0.00904985f, 0.02380751f, -0.02391596f, 0.01464132f, -0.01369326f, -0.02975714f, -0.00295544f, -0.03705818f, 
    0.00043637f, 0.01606123f, -0.00195742f, 0.01808864f, -0.00355048f, -0.04272959f, -0.01972971f, -0.01496197f, 
    0.02120459f, -0.01037811f, 0.01247616f, 0.00974336f, -0.03698191f, 0.00711611f, -0.03524028f, -0.01412346f, 
    0.03038067f, -0.00314657f, -0.02674298f, -0.01680683f, -0.03702594f, 0.02749759f, -0.02054167f, -0.02338886f, 
    -0.02846032f, -0.02476916f, 0.03047777f, 0.03029825f, -0.04197989f, 0.02886246f, -0.04239906f, -0.02723730f, 
    0.01572553f, 0.02193657f, 0.02076409f, 0.02629649f, -0.04105657f, 0.02511348f, -0.02688435f, -0.01871058f, 
    0.02104022f, 0.01364598f, 0.02003512f, -0.01470180f, 0.01370389f, 0.00836885f, -0.02330625f, 0.01968856f, 
    -0.03969330f, -0.03262314f, 0.02794537f, -0.01775048f, -0.01823480f, 0.01693273f, -0.02868285f, 0.00322369f, 
    -0.01900933f, -0.03632350f, 0.03090492f, -0.00023152f, 0.03173349f, -0.01833440f, 0.00820148f, -0.00394225f, 
    -0.00869336f, -0.02828541f, -0.02596728f, -0.00271509f, 0.01875981f, 0.01405956f, 0.00329565f, 0.00801331f, 
    0.00020619f, 0.00687297f, -0.02662150f, -0.03122580f, -0.01942700f, 0.00313253f, 0.03073108f, -0.00055073f, 
    -0.00380241f, 0.00906803f, -0.02072892f, -0.01678643f, -0.03051783f, 0.03141412f, -0.03977854f, -0.03612518f, 
    -0.00070353f, -0.03983974f, 0.02555571f, -0.03873338f, -0.01148868f, 0.02619762f, -0.03505023f, 0.02464807f, 
    -0.03683899f, 0.03326474f, -0.03908185f, 0.00980591f, 0.01318138f, 0.00166705f, 0.01877518f, -0.00575072f, 
    -0.01826412f, 0.02674414f, 0.00815539f, -0.00693199f, 0.00715334f, 0.01481530f, -0.02789934f, -0.00027760f, 
    0.01275548f, -0.04536676f, -0.01143115f, 0.02750909f, 0.00457743f, -0.03458044f, -0.00609474f, -0.00977977f, 
    -0.03946122f, -0.02959752f, 0.01635482f, 0.00311350f, -0.02753729f, 0.01404614f, -0.02546822f, -0.02611040f, 
    0.01377740f, 0.02131939f, 0.00099781f, 0.01598282f, -0.04462932f, 0.00453286f, -0.02218504f, -0.03353167f, 
    -0.03215668f, -0.04166032f, -0.01354614f, -0.02764384f, -0.01465337f, -0.03273181f, -0.03202460f, 0.00893511f, 
    -0.02000113f, -0.00737529f, -0.03760022f, 0.03021394f, -0.02581393f, 0.03130992f, -0.03687770f, -0.02025397f, 
    -0.03626449f, 0.02385506f, -0.03304357f, -0.03628229f, -0.00456906f, 0.02847214f, 0.01257955f, -0.03999657f, 
    -0.03569237f, 0.00209415f, 0.01072272f, -0.03344783f, -0.02327408f, -0.02161649f, 0.02945422f, 0.01369494f, 
    0.00512503f, 0.02336377f, -0.03307291f, 0.01239360f, -0.03743524f, -0.00977168f, 0.01507941f, 0.00511008f, 
    0.01618424f, -0.00071325f, -0.02874664f, -0.03511128f, 0.01394057f, -0.03683035f, 0.02992055f, -0.02730485f, 
    -0.00524819f, -0.04202906f, 0.02118528f, -0.00165359f, 0.01835304f, 0.00877177f, -0.03375991f, -0.00757273f, 
    0.02408016f, -0.04245957f, 0.00980705f, -0.01579432f, 0.02705951f, -0.03254098f, -0.00011157f, -0.01484323f, 
    0.00750660f, -0.01583530f, -0.02417718f, 0.00958901f, 0.02841534f, -0.02530892f, 0.02359271f, -0.01081078f, 
    -0.03156531f, 0.02017760f, -0.03321525f, 0.00689338f, -0.00450865f, -0.00930104f, -0.01668986f, 0.00472694f, 
    -0.03036894f, 0.01978293f, 0.00711360f, -0.02541801f, -0.00204610f, 0.00159310f, -0.00352133f, 0.01968363f, 
    0.02468928f, 0.02048920f, 0.00961332f, -0.00966353f, 0.01571693f, -0.00000342f, 0.00636896f, -0.01315106f, 
    -0.03911751f, -0.01707868f, -0.04365700f, -0.03096343f, -0.01063367f, -0.03679188f, -0.01442559f, 0.03326442f, 
    0.02895740f, 0.03131716f, 0.03076073f, -0.03378533f, 0.00649581f, -0.02495580f, 0.02949106f, -0.04057510f, 
    -0.03912220f, -0.04487191f, 0.01771824f, -0.02806101f, -0.01048692f, 0.03098538f, 0.00020834f, -0.03068038f, 
    -0.03206196f, -0.03838477f, 0.01211512f, -0.03536716f, -0.03670352f, -0.01170730f, 0.01210275f, -0.02912406f, 
    0.01702785f, -0.02891043f, -0.02201980f, -0.00016015f, -0.02928618f, 0.02434469f, -0.03281946f, -0.00459486f, 
    -0.04057599f, -0.03292353f, -0.02662700f, 0.01841769f, -0.02078852f, 0.01846537f, 0.03186089f, 0.02690189f, 
    -0.02910667f, -0.03331494f, 0.00196804f, -0.01948679f, 0.03051382f, -0.00264491f, -0.00446790f, 0.00886265f, 
    0.01013852f, -0.02476827f, -0.04090237f, 0.01291538f, 0.03245893f, -0.02403240f, -0.00897684f, 0.01014317f, 
    -0.02451598f, -0.03685501f, -0.01825172f, -0.04045469f, -0.00244154f, 0.03295207f, -0.03774667f, -0.03964257f, 
    -0.03559024f, -0.04149934f, 0.02788148f, 0.01935543f, -0.01957298f, -0.00669654f, 0.01549161f, -0.03805618f, 
    0.02471896f, -0.00228434f, -0.04440821f, -0.03568237f, 0.02434788f, 0.01351356f, 0.02745182f, 0.02974742f, 
    0.02162374f, 0.01323209f, -0.01746469f, -0.02874835f, 0.00475403f, -0.03374758f, -0.04114619f, -0.00431606f, 
    0.00165109f, -0.02982469f, 0.03122888f, -0.04495720f, 0.03265655f, -0.02132052f, 0.00110981f, 0.00951242f, 
    0.02283377f, -0.01427032f, -0.01551451f, 0.00148506f, -0.02847471f, 0.00208562f, -0.04549974f, 0.00314807f, 
    -0.03335281f, -0.03685231f, -0.03546689f, -0.02685896f, -0.00678043f, -0.00321858f, 0.02015032f, 0.00147578f, 
    0.02440221f, 0.02383482f, 0.02454530f, -0.03068683f, 0.02511542f, 0.00420765f, 0.00268513f, -0.00009650f, 
    -0.02276917f, -0.04350102f, -0.00683000f, -0.02719966f, 0.02014908f, -0.04537448f, -0.00686274f, 0.02903837f, 
    -0.04297692f, -0.04259250f, 0.00088334f, -0.00141557f, -0.03118581f, 0.00674658f, -0.03406455f, 0.02081186f, 
    0.03148391f, -0.00029495f, -0.02869780f, 0.00554111f, -0.00553591f, 0.00915949f, -0.02708219f, -0.00329189f, 
    -0.02307827f, -0.01847979f, -0.03582632f, -0.00445353f, 0.01518122f, -0.04500297f, -0.01088335f, 0.02029513f, 
    -0.04234984f, -0.02077780f, -0.01767064f, -0.01174052f, -0.03868149f, -0.03952279f, -0.04531408f, 0.02262036f, 
    0.03130344f, -0.00565268f, -0.03002241f, -0.02249007f, 0.02910609f, -0.00963253f, -0.01179561f, -0.01374215f, 
    0.00262990f, -0.03367248f, 0.01063235f, -0.02617064f, -0.01840449f, 0.00816214f, -0.00840663f, -0.04366490f, 
    -0.03714170f, -0.00587733f, -0.01517785f, 0.02885073f, -0.02563396f, -0.04074346f, -0.00239230f, -0.01906455f, 
    -0.00405969f, -0.01880148f, 0.00832255f, -0.01507894f, -0.03247605f, 0.01364594f, 0.01220267f, 0.02036038f, 
    0.03334878f, 0.00636288f, 0.02432476f, -0.01651332f, -0.02099296f, -0.04354968f, 0.01872193f, 0.00167867f, 
    -0.00421065f, 0.02445331f, -0.01530392f, -0.03485042f, -0.03873765f, -0.00954444f, -0.01499992f, -0.00091116f, 
    0.01866039f, 0.02524306f, -0.04190323f, -0.01689613f, -0.01987862f, -0.00649714f, 0.00178493f, 0.02754636f, 
    0.02207084f, -0.04420192f, -0.00532941f, -0.02299038f, -0.03459782f, -0.03207439f, -0.01344737f, -0.04338060f, 
    -0.00165568f, 0.01146515f, 0.00273147f, 0.02247211f, -0.01556937f, -0.04452533f, 0.03096236f, 0.02984932f, 
    0.01166959f, -0.03383723f, 0.00005311f, -0.02923837f, 0.01752448f, -0.00646611f, -0.00262297f, -0.01487878f, 
    0.01700481f, -0.03104625f, -0.00771233f, 0.02939941f, -0.03955413f, -0.01356259f, 0.00924047f, -0.04514696f, 
    -0.03226687f, -0.03136144f, 0.00033598f, 0.00503080f, -0.01553471f, -0.02392734f, -0.01643374f, 0.03478621f, 
    -0.01894544f, 0.00720206f, -0.01724377f, -0.02254119f, -0.01656845f, 0.00144714f, 0.00733532f, 0.02119470f, 
    -0.02188762f, 0.01766041f, -0.00486743f, 0.01354580f, -0.01696888f, 0.02670781f, 0.02708942f, 0.02323802f, 
    -0.03575658f, -0.04161889f, 0.01200403f, 0.00828170f, -0.03003821f, -0.04504886f, -0.01682258f, -0.02343807f, 
    0.01778395f, -0.00652333f, -0.01698365f, -0.02766057f, -0.01222359f, -0.03281085f, -0.00129928f, -0.01724960f, 
    0.01273431f, 0.00873658f, 0.00407723f, -0.01598250f, -0.02421821f, -0.03014146f, 0.00287197f, -0.03672411f, 
    0.02128425f, -0.04243429f, -0.00068787f, 0.00619261f, -0.04378750f, -0.00683654f, -0.00479600f, 0.00138714f, 
    -0.11512027f, -0.02995759f, 0.00914406f, 0.03996569f, 0.07730455f, -0.01649913f, 0.08963776f, -0.15696755f, 
    -0.12544884f, 0.00861398f, -0.02687909f, 0.03762194f, -0.02668510f, -0.08273947f, -0.04745729f, 0.06815685f, 
    0.02735728f, -0.11398295f, 0.17211409f, -0.16813155f, 0.39170226f, -0.06500190f, 0.06920151f, -0.06658762f, 
    0.00831038f, -0.01722511f, -0.01729311f, 0.11883242f, 0.01907182f, 0.10144351f, -0.08811265f, -0.07403526f, 
    0.08231731f, 0.10179621f, 0.00156000f, 0.02290297f, 0.00119453f, -0.28887737f, -0.09550802f, -0.06445105f, 
    0.06058299f, 0.20253119f, 0.04758470f, 0.06075514f, 0.27905759f, -0.11765447f, -0.00191477f, -0.04873348f, 
    0.02406441f, -0.09548623f, -0.09082232f, 0.03724654f, -0.03738200f, -0.06114201f, -0.00796897f, 0.06777149f, 
    -0.03141372f, 0.10453894f, -0.01860411f, 0.00536541f, 0.31445089f, 0.03583498f, -0.16471493f, -0.11283702f, 
    -0.17429040f, 0.03487711f, 0.06810060f, 0.15524282f, 0.13864912f, 0.01238665f, -0.07655807f, -0.00985128f, 
    0.06951825f, 0.08431021f, -0.02605822f, 0.07877126f, -0.04509813f, 0.05001061f, -0.18083237f, -0.15456818f, 
    0.02935410f, -0.08586161f, -0.22510278f, -0.23548377f, -0.01065667f, -0.06543372f, -0.01574222f, -0.02888642f, 
    -0.08379083f, -0.14463346f, -0.08137412f, 0.06046556f, 0.12370137f, 0.11727307f, 0.11384434f, 0.20116544f, 
    0.05156488f, -0.34044254f, -0.21233344f, 0.02230556f, 0.03759311f, -0.24554677f, 0.20115735f, -0.00702605f, 
    0.18445861f, -0.04601679f, 0.00251521f, -0.12283882f, -0.06847500f, 0.02582718f, -0.06510190f, 0.15562376f, 
    -0.04669102f, -0.03165293f, -0.05797575f, -0.02628653f, 0.02037523f, -0.00367618f, 0.04669598f, 0.05510448f, 
    0.43354300f, 0.03124980f, 0.31799534f, 0.22577515f, 0.13657294f, 0.00885526f, -0.06485102f, 0.08127810f, 
    0.02679398f, -0.07410830f, -0.04383015f, 0.00030972f, -0.02143700f, 0.12101837f, 0.02674627f, 0.18145576f, 
    -0.00358230f, -0.24237825f, -0.04698584f, 0.03938811f, 0.44367453f, 0.16316126f, -0.22275731f, 0.15760379f, 
    -0.12912768f, -0.02195106f, 0.11046552f, -0.03569411f, -0.05604603f, -0.03121606f, -0.06390282f, 0.03013954f, 
    0.01583016f, -0.07224794f, 0.05604940f, 0.01744098f, 0.02222000f, 0.12820643f, 0.06890507f, 0.00997028f, 
    -0.15610069f, 0.36225954f, 0.06847571f, -0.07928619f, 0.32128659f, -0.07305817f, -0.09028942f, 0.09306692f, 
    -0.01713459f, 0.00141440f, -0.01159381f, 0.06131816f, 0.01640686f, 0.12321088f, 0.02866622f, 0.07697973f, 
    0.09931822f, 0.15111211f, -0.31081158f, 0.08795044f, -0.09248027f, -0.12508029f, -0.21499127f, -0.41715908f, 
    0.03796575f, -0.08953200f, -0.00712016f, -0.00264638f, -0.00408123f, -0.01103941f, -0.03476387f, 0.02842643f, 
    0.06507707f, -0.04314758f, 0.06177815f, 0.03249540f, 0.06102342f, -0.17167269f, -0.22291809f, -0.02184523f, 
    0.06956211f, -0.05721184f, 0.05260213f, -0.02650030f, -0.03996526f, -0.11870629f, -0.01013537f, -0.07452544f, 
    -0.00238258f, -0.10268151f, -0.13446191f, -0.06486633f, -0.27611735f, 0.03938615f, -0.00017762f, -0.02296163f, 
    0.12338104f, 0.11161198f, -0.03721499f, -0.08376285f, 0.12165450f, 0.17118801f, -0.05893023f, -0.04833832f, 
    -0.10681415f, -0.06404876f, -0.04251018f, -0.06849519f, 0.01299894f, -0.15292391f, -0.02719458f, 0.07251701f, 
    -0.12920912f, 0.06313127f, -0.04056164f, -0.04242697f, -0.01338766f, -0.01839143f, -0.27507934f, -0.04224156f, 
    0.15130539f, 0.12913552f, 0.19878109f, 0.42214465f, 0.10063311f, 0.08213086f, 0.03819554f, 0.00320566f, 
    0.01106207f, -0.08137633f, -0.06922784f, -0.05086500f, 0.05615432f, -0.02460453f, 0.05035260f, 0.12330277f, 
    0.13426892f, 0.17594160f, 0.09229848f, 0.11459059f, 0.20860608f, 0.11410814f, -0.11969660f, 0.18124038f, 
    0.00244442f, -0.03190223f, 0.00209410f, -0.00029187f, -0.02275935f, -0.00399894f, -0.03025664f, 0.05854531f, 
    0.06559698f, 0.01051546f, 0.03854311f, -0.06562629f, -0.00036649f, 0.00948974f, -0.01625948f, 0.05659945f, 
    0.02852635f, 0.22322859f, 0.40391445f, -0.24288510f, -0.09849961f, -0.06376462f, 0.05012314f, 0.00445532f, 
    0.14232613f, -0.04483411f, -0.03939052f, -0.10336288f, 0.13827169f, 0.11153801f, 0.02864602f, 0.08928502f, 
    0.14975521f, 0.12279217f, 0.21545734f, -0.13972719f, 0.68560326f, 0.04875090f, 0.16951740f, -0.23703945f, 
    -0.08107596f, 0.07435523f, -0.07158179f, -0.18921465f, 0.05486458f, -0.05570483f, 0.00972638f, 0.13853453f, 
    -0.11925852f, 0.11821042f, 0.03196407f, 0.06992269f, -0.13763367f, 0.25275463f, -0.00675054f, -0.00112193f, 
    0.13118102f, 0.11827886f, 0.15916745f, -0.06635490f, 0.09367077f, 0.04406381f, 0.06665834f, -0.04397220f, 
    -0.06836676f, 0.05083564f, -0.03227754f, 0.04703837f, 0.02746427f, 0.02906663f, -0.03258396f, 0.07314036f, 
    -0.02883260f, 0.05532411f, 0.03962881f, -0.12948596f, -0.00427921f, 0.09153541f, 0.04727025f, -0.25013584f, 
    0.27038631f, -0.08917281f, 0.00165201f, -0.16258901f, -0.06584758f, -0.03009942f, -0.10654025f, 0.09464008f, 
    0.10637064f, -0.02845378f, 0.09615485f, 0.08149348f, 0.09499647f, -0.24109784f, 0.03468465f, -0.09449878f, 
    0.18236572f, 0.04344935f, 0.01096892f, -0.03940845f, 0.31709746f, -0.07577952f, -0.05412492f, -0.22607343f, 
    -0.17732257f, 0.06319167f, -0.08826819f, 0.07402480f, 0.07862702f, -0.15129101f, 0.03479613f, 0.10649497f, 
    0.14952876f, -0.07501011f, 0.00050653f, -0.04733237f, 0.19542156f, 0.09434883f, 0.01244697f, 0.19306214f, 
    -0.24119486f, -0.08722019f, -0.01122526f, -0.11131025f, -0.03056350f, -0.02447349f, -0.11804884f, 0.00354539f, 
    -0.01609590f, -0.03502512f, 0.05309468f, 0.00521663f, -0.03094138f, -0.11657636f, -0.01899468f, -0.01132774f, 
    0.19249168f, -0.04832585f, -0.21350522f, 0.01354721f, -0.14307918f, 0.02584576f, 0.02649159f, 0.01316607f, 
    -0.05378925f, -0.04774061f, -0.06719356f, -0.03678346f, 0.06042069f, 0.02230164f, 0.11682612f, 0.04296121f, 
    0.14372003f, -0.22760743f, -0.15528974f, 0.02701427f, -0.07482025f, -0.23178622f, 0.04878988f, 0.27594069f, 
    0.07723183f, -0.05422051f, 0.09082536f, -0.05676095f, -0.23048021f, 0.08641117f, -0.00085077f, -0.00770243f, 
    -0.10032848f, -0.13010219f, 0.08475789f, 0.06222177f, 0.03353110f, 0.16434105f, 0.18969159f, 0.06729329f, 
    0.50874662f, 0.08761230f, -0.04344069f, -0.28784540f, -0.06079899f, 0.14478073f, -0.03058517f, 0.14506428f, 
    0.11918846f, 0.00892687f, 0.06556848f, -0.03314019f, -0.03207367f, 0.10143110f, 0.00117267f, 0.00582521f, 
    0.01349417f, -0.12805703f, 0.02150835f, 0.08475518f, -0.26557013f, 0.27299351f, -0.05491754f, -0.13481544f, 
    -0.10944235f, -0.00713221f, -0.03520957f, 0.01914499f, -0.06842503f, -0.00203321f, 0.05910031f, 0.08239313f, 
    -0.00987861f, -0.01395873f, 0.15852076f, -0.10898439f, 0.08302534f, -0.08106390f, 0.04127171f, -0.09032065f, 
    -0.03247321f, 0.07234465f, 0.02664415f, -0.02426607f, 0.00118810f, -0.19306824f, -0.02950474f, -0.09616601f, 
    -0.07389718f, -0.04534848f, -0.06352838f, -0.08960010f, -0.05883184f, -0.17297278f, -0.04988869f, -0.06844682f, 
    0.00344655f, -0.00876990f, 0.01270548f, -0.12243688f, -0.08848707f, 0.00388357f, 0.21383487f, -0.13295963f, 
    0.12766705f, -0.03462631f, -0.12920238f, -0.06040083f, 0.12785849f, -0.00247179f, -0.10847905f, -0.05388374f, 
    0.00684493f, -0.00759646f, 0.09463822f, 0.04026519f, 0.03736476f, 0.05306534f, 0.02855089f, -0.12197610f, 
    0.04447891f, 0.04921513f, -0.03601713f, -0.00264050f, 0.00346190f, -0.01309358f, -0.04418117f, -0.09917660f, 
    0.00889992f, -0.06514769f, -0.05858790f, 0.02226724f, -0.11209718f, -0.01365375f, -0.10356237f, 0.13446200f, 
    0.10070883f, -0.12690686f, -0.10033942f, -0.00404282f, 0.05654287f, -0.12848833f, 0.05948672f, 0.12525107f, 
    0.08486680f, 0.02379804f, -0.01717745f, 0.04848475f, 0.06302735f, 0.09446269f, 0.04243024f, -0.21708143f, 
    -0.06945907f, 0.15982740f, 0.04206363f, 0.14982922f, 0.08289225f, 0.07689147f, 0.05457104f, 0.11271654f, 
    0.37912536f, -0.01157022f, 0.09965396f, 0.23343632f, -0.04087156f, -0.00288752f, 0.08281974f, -0.05001164f, 
    -0.00093048f, 0.00995784f, -0.06785058f, -0.09210688f, -0.03507353f, 0.02209335f, 0.01683125f, 0.01368133f, 
    0.09649070f, 0.03136045f, 0.09527216f, 0.04225373f, 0.21199900f, -0.01612046f, 0.02636010f, 0.26243964f, 
    0.00825796f, -0.00087945f, -0.03198454f, -0.06181757f, 0.03237968f, 0.06492152f, 0.06486403f, 0.02503578f, 
    -0.03647400f, -0.06698986f, 0.03940352f, -0.04038377f, 0.05710204f, 0.09187459f, 0.06984180f, 0.03612386f, 
    -0.05738263f, -0.02271239f, -0.11316478f, -0.13133478f, -0.05017244f, -0.00861003f, 0.02891269f, -0.10853789f, 
    0.02030250f, -0.00692849f, 0.04266273f, 0.06910386f, -0.03199741f, -0.10297687f, 0.06430461f, -0.03013342f, 
    -0.03944951f, -0.01993255f, -0.00510847f, -0.09776349f, -0.10433777f, 0.19549569f, 0.12547490f, -0.30373111f, 
    -0.18498942f, 0.13048184f, 0.08006839f, 0.11894564f, 0.16740891f, 0.03817816f, 0.08154488f, -0.02527549f, 
    0.20535468f, 0.14842944f, -0.05829644f, 0.14583860f, 0.16101941f, -0.08714566f, 0.02071044f, 0.00776124f, 
    -0.04504804f, -0.01271392f, -0.03046233f, 0.00123619f, -0.04813953f, 0.01448218f, 0.00068921f, 0.01656610f, 
    -0.02501318f, -0.02209656f, -0.01218208f, -0.04977323f, -0.04772825f, -0.00373486f, -0.00617923f, 0.01119155f, 
    0.02352018f, -0.00217695f, -0.03407235f, -0.00001510f, -0.04290157f, 0.02263813f, 0.00333388f, 0.02018130f, 
    0.02613239f, 0.02960842f, -0.00452949f, 0.02046761f, 0.00208167f, -0.00648295f, -0.02600310f, -0.03780746f, 
    -0.02481435f, 0.01373674f, -0.00995161f, 0.01080243f, 0.02767758f, 0.00687609f, -0.00474503f, -0.00495962f, 
    -0.03011386f, -0.02950677f, -0.01236815f, -0.02720836f, -0.04836988f, -0.04400989f, 0.03823411f, -0.00817803f, 
    0.01176795f, -0.00670376f, -0.03401133f, 0.03141927f, 0.01516741f, -0.02016965f, 0.01225860f, -0.00381656f, 
    -0.01180204f, -0.04124474f, -0.04243616f, -0.02602549f, -0.03765738f, -0.02942673f, -0.00803312f, 0.01677601f, 
    0.02636336f, -0.03323713f, 0.01154412f, 0.01031015f, 0.00562053f, -0.04580440f, -0.03650231f, 0.01789397f, 
    -0.01761777f, -0.00781292f, 0.01976162f, -0.04083584f, -0.02598133f, -0.02350685f, 0.01000615f, 0.00138252f, 
    0.02785883f, 0.00775846f, 0.00449536f, 0.00952131f, 0.01975494f, -0.00995458f, 0.00743173f, -0.04737200f, 
    -0.00084633f, -0.03529153f, -0.03118908f, 0.01159313f, -0.00049289f, 0.00619707f, -0.04348456f, 0.00007056f, 
    0.00580631f, 0.00598294f, -0.00708104f, -0.02544793f, 0.01206926f, 0.02288580f, 0.02614476f, -0.01144259f, 
    -0.02526761f, -0.01213074f, 0.00819800f, 0.00666577f, -0.02268527f, 0.01603790f, -0.00081128f, -0.03261345f, 
    -0.03762868f, 0.01753287f, 0.01633356f, -0.03828751f, 0.02702221f, -0.03223336f, -0.04639952f, -0.01921146f, 
    0.00435439f, 0.00876651f, 0.01470820f, -0.01025584f, -0.01792139f, -0.00653389f, 0.00476753f, -0.00978505f, 
    -0.00896388f, -0.02438943f, -0.01967506f, -0.03657158f, -0.02588934f, -0.04626616f, -0.00666308f, -0.03888199f, 
    -0.02331086f, 0.00995384f, -0.02430999f, 0.03737212f, -0.02486407f, -0.04316878f, -0.01327906f, -0.03777339f, 
    -0.02102891f, -0.01628493f, 0.01121788f, -0.03556413f, 0.02661810f, -0.04829144f, -0.03595833f, -0.02428746f, 
    0.00227839f, 0.01769613f, -0.02450809f, -0.04867559f, -0.02982014f, -0.03066668f, -0.00042233f, -0.04474023f, 
    0.01977483f, -0.03354815f, -0.03746172f, 0.03074408f, -0.04709365f, -0.03952948f, -0.03539852f, 0.01953693f, 
    0.00707648f, 0.01376970f, -0.04277016f, -0.03554393f, -0.02829770f, -0.00491245f, -0.01895925f, 0.01707926f, 
    -0.01004600f, -0.03714435f, -0.03839723f, 0.02363939f, -0.01597485f, -0.02162055f, 0.02005576f, -0.03488448f, 
    0.01372273f, -0.03871306f, 0.01387696f, -0.04498343f, 0.02744857f, -0.01328736f, -0.00327006f, -0.03615255f, 
    -0.01633785f, -0.04299891f, 0.00448919f, -0.01632301f, -0.02395623f, -0.00890975f, -0.01254232f, -0.04082952f, 
    0.02123631f, -0.04345217f, -0.01857549f, -0.01369750f, -0.00068558f, 0.03321910f, -0.04996170f, -0.00634289f, 
    -0.00388062f, 0.02350492f, 0.02146969f, -0.01587369f, -0.00975651f, 0.02222162f, -0.02011286f, 0.02441100f, 
    -0.01231941f, 0.00056416f, -0.04689839f, -0.03342722f, -0.02289874f, -0.03148846f, -0.01524353f, 0.01271912f, 
    -0.02128026f, -0.04720316f, -0.02822291f, -0.01192877f, -0.03003285f, -0.03560285f, 0.02490135f, -0.03405399f, 
    0.00119770f, -0.00890588f, -0.00191213f, -0.03131419f, -0.02329045f, 0.00862510f, -0.03076050f, 0.02466045f, 
    -0.03266691f, -0.00306087f, 0.01635360f, 0.03517689f, -0.02737653f, -0.03371639f, -0.03578503f, 0.01807366f, 
    -0.00906410f, -0.02813263f, -0.00856194f, -0.04358364f, -0.00875662f, -0.02137261f, -0.04625170f, -0.01230962f, 
    -0.00701654f, -0.02825524f, 0.00140972f, 0.02703837f, 0.02649688f, -0.02150430f, -0.01796112f, -0.04770989f, 
    -0.02774164f, -0.04655875f, 0.00363637f, 0.00904532f, 0.02381158f, -0.04325673f, -0.03276708f, 0.02376392f, 
    -0.02159312f, 0.00343086f, 0.02530992f, 0.00220876f, 0.01770879f, 0.00993975f, -0.04374013f, -0.00338760f, 
    -0.02117689f, -0.03444634f, 0.00444810f, -0.02441949f, -0.03780816f, 0.02362516f, -0.02044885f, -0.00093949f, 
    0.01237419f, -0.03507585f, -0.00994848f, 0.00514592f, 0.03579682f, -0.02627292f, -0.01638550f, -0.02335392f, 
    -0.04129433f, -0.02887185f, -0.01657892f, 0.01350228f, 0.02187867f, -0.01029575f, 0.03044640f, -0.01541565f, 
    -0.04048787f, 0.00506999f, 0.02577289f, -0.00987866f, -0.00781871f, -0.04702244f, -0.00249609f, 0.01561766f, 
    -0.02825439f, 0.01372099f, 0.00218583f, -0.01961049f, -0.03538743f, 0.00442410f, -0.02263331f, -0.00444336f, 
    0.01945049f, -0.02952482f, -0.01735072f, -0.04484625f, 0.01408846f, -0.01013530f, -0.04800443f, 0.01225232f, 
    -0.03470545f, -0.03651511f, -0.00422594f, 0.00618569f, -0.00258555f, 0.01963266f, -0.02029904f, -0.04588911f, 
    -0.02824648f, -0.02565369f, -0.02348622f, 0.00216504f, 0.02072978f, 0.01292370f, 0.00860477f, -0.01741442f, 
    0.00063103f, -0.04443431f, 0.01482954f, -0.00359301f, 0.03861788f, -0.02238971f, 0.02155423f, -0.03588540f, 
    -0.02444790f, -0.02628657f, -0.03814415f, 0.00939899f, -0.03239509f, -0.04364659f, -0.04380168f, -0.02091655f, 
    -0.02324789f, 0.02363322f, 0.01680507f, 0.01735973f, 0.00579619f, -0.04202805f, -0.01858924f, 0.01917918f, 
    -0.00952896f, 0.03873269f, -0.02887070f, -0.00908623f, 0.00760790f, -0.03097442f, -0.02556050f, -0.01421895f, 
    -0.04098400f, -0.04189874f, 0.01804718f, -0.03239609f, -0.03324674f, -0.02444684f, -0.01551071f, -0.01331264f, 
    0.01240173f, 0.02451236f, -0.04423334f, -0.04383433f, 0.00315129f, 0.00976371f, 0.00925949f, -0.00416392f, 
    0.00652126f, -0.01372604f, -0.02119558f, -0.03199714f, -0.04992610f, 0.00373319f, -0.01711246f, -0.01697774f, 
    0.00159842f, -0.01054300f, -0.03361314f, 0.02356792f, 0.01835740f, -0.03478503f, 0.02673865f, -0.04335437f, 
    -0.00302501f, 0.02024590f, 0.01348512f, 0.02753891f, -0.03526541f, -0.01493548f, -0.00451845f, -0.05011825f, 
    -0.02639096f, 0.02170345f, 0.00632898f, -0.00386075f, -0.04136869f, -0.03316087f, -0.02393000f, 0.03592009f, 
    0.01695474f, 0.01060076f, -0.00759088f, -0.02504139f, 0.02617436f, 0.02326188f, -0.01051898f, -0.03340949f, 
    0.01050945f, -0.04303174f, -0.02201978f, 0.00905496f, 0.00349921f, 0.00923477f, -0.02256001f, -0.03275887f, 
    -0.04286129f, -0.04905539f, -0.03198029f, -0.04449413f, -0.02117868f, 0.02446483f, -0.00769137f, -0.02271579f, 
    -0.03408220f, -0.03604243f, -0.04654265f, 0.01185774f, 0.02665325f, -0.03812591f, -0.01631933f, -0.01037250f, 
    -0.00200594f, -0.01490883f, -0.04676170f, 0.02513209f, 0.01618342f, -0.03100989f, -0.03713190f, -0.02854610f, 
    -0.02777813f, -0.01439960f, -0.01124087f, -0.00326544f, 0.00474240f, 0.02409073f, -0.02208526f, -0.02855680f, 
    -0.04029382f, 0.01506723f, -0.03655332f, -0.04969702f, -0.02439971f, -0.03084987f, -0.00874300f, -0.02820776f, 
    -0.00339547f, -0.03083039f, -0.02914286f, 0.00703851f, -0.02192423f, 0.00130422f, 0.01955724f, -0.01302250f, 
    -0.03968227f, -0.01327231f, -0.01045095f, -0.01741295f, -0.02743702f, -0.02078625f, -0.01935754f, -0.02737049f, 
    0.01679827f, -0.03703167f, -0.02704924f, -0.02057417f, 0.02616408f, -0.03926107f, -0.03794268f, 0.01655519f, 
    -0.03919212f, -0.00616619f, -0.04518960f, 0.01234205f, -0.04740871f, 0.01092362f, -0.01210141f, -0.01626334f, 
    0.00345345f, 0.00663254f, -0.02360465f, 0.01403103f, -0.01145846f, -0.00805831f, -0.03539152f, -0.04323739f, 
    0.01549814f, -0.04788062f, 0.02836339f, -0.04395780f, 0.00366390f, -0.03402987f, 0.00399228f, -0.00562933f, 
    0.02077951f, -0.03075173f, -0.04472062f, -0.03188030f, -0.00097188f, -0.04671567f, -0.02770061f, -0.00332731f, 
    -0.00099337f, 0.02764020f, 0.01767085f, 0.01640492f, -0.03450470f, -0.00626376f, -0.00546684f, -0.01401573f, 
    -0.00255160f, 0.01587066f, -0.04219571f, -0.01312888f, 0.02419992f, -0.03461888f, -0.04451312f, -0.01213897f, 
    -0.00640402f, 0.02546531f, -0.02869879f, -0.03317628f, -0.00734414f, 0.00788251f, 0.00228240f, 0.01002126f, 
    -0.04782077f, -0.00215896f, -0.03514869f, -0.04509423f, -0.00296027f, -0.02894530f, 0.01784045f, -0.03280709f, 
    0.00697446f, -0.03787650f, -0.01330077f, -0.02796025f, -0.03243262f, -0.01188728f, -0.04869080f, -0.01572281f, 
    -0.04611285f, 0.00606006f, -0.00253037f, 0.02114031f, -0.04672756f, -0.02699874f, -0.03107968f, -0.00579109f, 
    -0.00179324f, 0.01902092f, 0.00346968f, 0.01917220f, -0.01198725f, 0.01125904f, -0.02165972f, -0.02122922f, 
    -0.00294532f, -0.01058581f, -0.00060223f, -0.04127136f, -0.01274876f, 0.02608368f, -0.00155009f, -0.02359574f, 
    -0.03408573f, -0.03882980f, -0.04911257f, 0.01275015f, -0.01454787f, 0.00623116f, -0.01873117f, 0.00187841f, 
    -0.00489861f, 0.01588332f, -0.00326426f, -0.03325320f, -0.02003839f, -0.03257145f, 0.00395443f, -0.04464142f, 
    -0.04075915f, -0.00753799f, -0.00846770f, 0.03657768f, -0.03725674f, 0.02356917f, 0.01898915f, -0.01834020f, 
    0.00918769f, 0.00580963f, -0.00131243f, -0.03979657f, -0.04015823f, 0.01994329f, -0.00643336f, -0.03676972f, 
    -0.02489416f, -0.02163070f, -0.00229827f, -0.01699062f, 0.00208322f, -0.00739816f, -0.02913922f, -0.04376363f, 
    0.00993422f, 0.03062413f, -0.00164563f, -0.03115446f, -0.00570125f, -0.02465297f, -0.02880281f, -0.02364409f, 
    -0.01614599f, -0.00837417f, -0.02472017f, -0.02635005f, -0.03126794f, -0.01816346f, 0.01543084f, 0.01567781f, 
    0.00047602f, -0.03867925f, 0.00746681f, 0.00703606f, -0.01901512f, -0.00303017f, 0.02150355f, -0.03512918f, 
    0.02097211f, 0.02914307f, -0.03605585f, -0.01983863f, -0.00257565f, 0.02167555f, -0.00191789f, 0.03195969f, 
    -0.03440542f, 0.02087627f, 0.02659428f, 0.02543609f, 0.01957875f, -0.03002483f, 0.00668660f, -0.04095309f, 
    -0.00805046f, 0.02500010f, -0.00887689f, 0.00115836f, -0.01052254f, 0.02988841f, -0.00323606f, -0.03118707f, 
    0.00735805f, 0.02200090f, 0.00510610f, 0.00748226f, 0.00049722f, 0.02949381f, 0.02198964f, -0.00307118f, 
    -0.03865726f, -0.02439357f, -0.02065269f, 0.00527723f, -0.02687851f, -0.03958584f, -0.00660998f, -0.04278032f, 
    -0.04413718f, 0.02097769f, -0.02361356f, 0.01690760f, -0.04278613f, -0.00535442f, 0.02293466f, -0.02461549f, 
    0.00433481f, -0.01105579f, -0.02773385f, 0.02127958f, -0.03502898f, -0.00772347f, -0.03724192f, -0.03050637f, 
    -0.03572804f, -0.02427448f, 0.00011918f, -0.02237761f, 0.01375692f, -0.01983483f, 0.01477928f, -0.00381285f, 
    -0.00839444f, -0.03412133f, -0.00616064f, -0.04104580f, -0.00824806f, -0.04103728f, 0.01033808f, -0.01753297f, 
    0.00836368f, 0.00029032f, 0.01653505f, 0.01283940f, 0.03081079f, 0.00957136f, 0.02783477f, 0.03200157f, 
    -0.00679148f, 0.03069172f, 0.02417842f, 0.02063024f, 0.00011082f, 0.01529729f, -0.02883342f, -0.01431449f, 
    -0.00169304f, 0.02001806f, -0.01264805f, -0.00333646f, 0.00456254f, -0.00870110f, 0.02603202f, -0.03805897f, 
    -0.00809405f, -0.03832599f, 0.02050630f, -0.03946548f, -0.03138415f, -0.00324624f, 0.01032828f, 0.03046864f, 
    -0.03356522f, 0.01711858f, 0.03714748f, -0.00571246f, 0.03091040f, -0.03787840f, 0.02905883f, -0.02667841f, 
    -0.00429253f, 0.00229315f, 0.03331647f, -0.03501580f, -0.00755293f, 0.01653408f, 0.02420711f, -0.00869973f, 
    -0.02857330f, -0.01654861f, -0.02878063f, -0.01233029f, -0.02292672f, -0.03852372f, -0.04550497f, 0.02413474f, 
    0.00537926f, -0.04480399f, -0.04065374f, 0.02058288f, -0.03104245f, -0.02382845f, 0.00276685f, 0.02445514f, 
    -0.00331407f, 0.02796428f, 0.03335241f, -0.00956061f, -0.02495141f, -0.01124348f, -0.00093598f, -0.00911455f, 
    -0.01301945f, 0.02750274f, -0.01954963f, -0.04425572f, -0.03583921f, -0.01976402f, 0.02957403f, -0.02076622f, 
    0.02264566f, -0.02948481f, -0.01297054f, -0.03271480f, 0.01158998f, -0.03323545f, -0.01896205f, -0.01752306f, 
    -0.04504621f, -0.01334830f, -0.02404713f, -0.04200957f, 0.02050401f, -0.00028543f, -0.02131999f, 0.00861961f, 
    -0.03231879f, 0.01391044f, -0.04460413f, 0.00293687f, 0.01703055f, -0.02578175f, 0.03297541f, -0.04270297f, 
    0.00000717f, -0.04490423f, 0.01319157f, -0.00468188f, -0.03599288f, -0.04061440f, -0.03412831f, -0.03108639f, 
    0.03342791f, -0.00081713f, -0.02856355f, 0.02751820f, -0.01921829f, -0.04158498f, -0.04183590f, -0.03052155f, 
    -0.00932456f, -0.02697653f, 0.01041960f, 0.02925299f, -0.00929205f, 0.02198337f, 0.00782605f, -0.04228009f, 
    -0.04453865f, -0.00292172f, -0.00398724f, -0.04185741f, -0.03677242f, -0.02039055f, 0.00109672f, -0.02303563f, 
    -0.03473912f, 0.01703860f, 0.01878564f, 0.00882148f, -0.03218179f, -0.01762816f, 0.01530771f, -0.01394783f, 
    0.00306225f, 0.01289488f, 0.03228539f, -0.02978959f, -0.00292909f, -0.02835828f, -0.02834973f, 0.02103885f, 
    -0.01875930f, -0.02244480f, -0.01668854f, 0.03214004f, 0.00992518f, -0.02688451f, -0.02541230f, -0.02548427f, 
    -0.01472896f, -0.03471130f, 0.01036216f, -0.00935669f, -0.04096576f, -0.03513359f, -0.02154060f, -0.01111557f, 
    0.01062904f, -0.02756110f, -0.03697862f, -0.03756453f, 0.02306322f, -0.03653325f, -0.03358115f, -0.04005438f, 
    -0.04153444f, -0.01261600f, 0.00741934f, -0.01746196f, -0.02356897f, 0.00460569f, -0.04283439f, -0.00939185f, 
    -0.01041593f, 0.02995079f, -0.02197955f, 0.03078570f, 0.00999650f, 0.02556390f, -0.02785842f, -0.02492002f, 
    -0.02063402f, -0.02101068f, 0.00885344f, -0.00552749f, -0.00172650f, -0.02640914f, 0.03308931f, 0.02974516f, 
    -0.00740887f, -0.00010438f, 0.00655961f, -0.03765418f, 0.00765345f, -0.00382920f, -0.03786887f, 0.00038946f, 
    -0.01297564f, -0.01134888f, 0.01178131f, 0.02553286f, -0.00525265f, -0.03226893f, 0.02230952f, -0.02602016f, 
    0.02993980f, 0.02406727f, -0.00075012f, 0.00698088f, -0.01202089f, 0.00782729f, 0.00618280f, 0.02249329f, 
    -0.02934781f, -0.03395468f, -0.03335298f, 0.01493177f, 0.02396722f, -0.04266115f, -0.00428822f, 0.02099135f, 
    -0.03964834f, -0.03909707f, 0.02695832f, 0.02676436f, -0.01737289f, 0.00701707f, -0.04360738f, 0.02050186f, 
    0.02403562f, 0.00049179f, -0.00198574f, -0.01593850f, 0.02509491f, -0.03117645f, -0.01993136f, -0.03247190f, 
    -0.00996444f, -0.00472637f, -0.03500158f, -0.03376520f, 0.00893712f, 0.02009278f, -0.01597953f, -0.02368429f, 
    0.01152675f, 0.03315150f, -0.00391273f, -0.01035285f, -0.00579143f, 0.02417419f, 0.00360607f, 0.01505842f, 
    0.02756656f, 0.02410273f, 0.03720649f, -0.03406348f, -0.03881732f, 0.00174135f, -0.02143622f, -0.03558438f, 
    0.01262593f, 0.03544443f, -0.01314184f, -0.01096661f, -0.01657771f, -0.02180367f, 0.01975459f, -0.03225367f, 
    -0.01515126f, 0.00031437f, 0.02509901f, 0.01398419f, 0.01697518f, 0.01240002f, -0.04283791f, -0.02944943f, 
    0.03254273f, -0.03433986f, -0.01767723f, 0.01333607f, -0.02316035f, -0.01597864f, 0.00782095f, -0.01870743f, 
    0.02956021f, -0.02050649f, -0.03240490f, 0.03133354f, 0.02859378f, 0.02545887f, 0.03182890f, 0.01801145f, 
    -0.04023577f, -0.01756659f, -0.03139165f, 0.00061246f, -0.03914494f, -0.00025489f, 0.03067826f, 0.00052336f, 
    -0.00132029f, -0.00708092f, 0.00762982f, 0.00110527f, 0.01240297f, 0.02553999f, 0.01477024f, 0.02328595f, 
    0.02542923f, -0.01461412f, -0.01562629f, -0.01819498f, 0.00399306f, -0.03338699f, 0.02748462f, 0.00536523f, 
    -0.01335487f, 0.00160989f, 0.01995650f, -0.01458827f, -0.00127159f, 0.00353621f, 0.00234711f, -0.01629734f, 
    0.02064798f, -0.02475763f, -0.03436004f, -0.04039123f, 0.00444657f, 0.02236050f, 0.00764321f, -0.02089811f, 
    -0.01986961f, 0.01241312f, 0.00368956f, 0.01753781f, -0.03333976f, 0.01978354f, -0.00753072f, -0.01099396f, 
    -0.01318367f, -0.04539274f, 0.00870125f, -0.00485744f, 0.02811449f, -0.00783568f, 0.00188132f, 0.01615112f, 
    0.01031760f, -0.02835647f, 0.00881583f, -0.03864150f, -0.03634023f, -0.02288626f, -0.01770978f, 0.01130834f, 
    0.03203261f, 0.01745008f, -0.01382190f, -0.01559072f, 0.03082593f, 0.02130743f, -0.03436628f, -0.04073303f, 
    -0.03338854f, 0.03007624f, -0.02133064f, -0.03337394f, -0.03960073f, 0.02225905f, -0.01836976f, 0.00149780f, 
    -0.02874478f, -0.01581335f, -0.00888497f, -0.03454953f, -0.04264433f, -0.03730694f, 0.02040788f, 0.00106548f, 
    -0.03715571f, -0.01673536f, -0.01346206f, -0.03056318f, -0.04311023f, 0.02705894f, -0.02866332f, -0.01619678f, 
    -0.00695183f, -0.04520353f, -0.00422790f, -0.02252028f, 0.01688099f, 0.01527258f, -0.02035193f, -0.02216885f, 
    0.01553873f, 0.00379615f, -0.01552022f, 0.01285868f, -0.02442838f, 0.00027860f, 0.00186660f, -0.01684852f, 
    -0.02160233f, -0.03390229f, 0.00017030f, 0.01675127f, -0.01720497f, -0.03576743f, -0.01232488f, -0.03748222f, 
    -0.01906776f, -0.02161366f, 0.01513985f, -0.03275094f, 0.00723203f, 0.02939533f, 0.01710410f, 0.02462722f, 
    -0.01948621f, 0.00425297f, -0.01555621f, -0.00092346f, 0.01380064f, -0.03062632f, -0.01560806f, 0.02816727f, 
    0.00593853f, 0.02358520f, -0.01481600f, -0.04544741f, 0.01738863f, -0.02563488f, 0.01254098f, 0.01517586f, 
    -0.04315891f, -0.03976659f, -0.03296436f, -0.01574355f, 0.00924070f, 0.01325674f, 0.00222667f, -0.00774904f, 
    0.02497121f, -0.01709338f, -0.01849531f, -0.01638633f, 0.01716397f, -0.00275970f, 0.01854471f, -0.02732544f, 
    -0.02190385f, 0.00598794f, 0.00287759f, 0.02982912f, -0.03145278f, -0.04424951f, 0.02071137f, -0.04323531f, 
    -0.01573929f, -0.03879421f, 0.00378581f, 0.02575120f, 0.02942581f, 0.01702909f, -0.01957430f, -0.00508293f, 
    -0.02254617f, -0.03110973f, -0.02841150f, -0.00569225f, -0.03033387f, -0.02199435f, 0.01967874f, 0.01957302f, 
    -0.00696508f, 0.01569361f, 0.00927245f, -0.01824041f, -0.04028735f, -0.01459464f, -0.03364997f, -0.03982962f, 
    -0.00882222f, 0.00434433f, -0.03934146f, -0.02016208f, -0.01845057f, -0.01016505f, -0.00262944f, -0.00482317f, 
    -0.00408878f, 0.02451519f, -0.01533442f, 0.02636864f, -0.02718185f, -0.02256621f, -0.03395874f, -0.00543522f, 
    -0.01518345f, -0.00892655f, -0.03945313f, 0.01042541f, -0.00383795f, 0.01318934f, 0.00373687f, -0.01718617f, 
    -0.04284987f, -0.03831694f, 0.03199120f, -0.01198314f, 0.00097116f, 0.02342398f, 0.03126166f, 0.00048450f, 
    0.01348553f, -0.02603554f, 0.00343959f, -0.01127047f, -0.03489062f, -0.03076429f, -0.00696203f, -0.04205389f, 
    0.01326124f, 0.00396646f, 0.01593939f, 0.02860921f, -0.02954834f, -0.04009417f, 0.00983800f, -0.02702042f, 
    0.48993883f, -0.05423498f, -0.04728423f, -0.07668222f, -0.14445187f, -0.01051122f, 0.03651184f, 0.01331486f, 
    0.05245674f, -0.00134988f, -0.06034491f, -0.04698002f, 0.03214412f, 0.03574913f, 0.04269841f, -0.02632929f, 
    0.11084635f, 0.02905008f, -0.00175924f, 0.02644187f, -0.13554783f, -0.02533120f, 0.18783163f, 0.03950304f, 
    -0.20695089f, -0.05188246f, 0.03582621f, 0.05839856f, -0.06706288f, 0.07423850f, 0.02158030f, -0.01538895f, 
    -0.01199985f, -0.04701349f, 0.05576208f, 0.09874650f, -0.07100066f, 0.14978056f, -0.04187666f, -0.01024130f, 
    0.12328729f, -0.11853363f, 0.32587513f, -0.17450169f, -0.04956350f, 0.05687176f, -0.09902073f, 0.08247172f, 
    -0.02672979f, 0.05147978f, -0.04156549f, 0.06269359f, 0.05733277f, 0.02172342f, -0.10623892f, 0.01662662f, 
    -0.06385293f, -0.00001590f, -0.02304595f, -0.09416688f, -0.03533476f, 0.02336705f, 0.11512531f, -0.02964377f, 
    -0.02765507f, 0.04019511f, 0.03068332f, -0.09210405f, 0.13692373f, 0.06896891f, 0.04647559f, 0.01397404f, 
    0.05686260f, 0.02432108f, -0.07855286f, 0.04476986f, -0.02575159f, -0.02665923f, 0.00841236f, -0.10093798f, 
    0.03571882f, 0.08067165f, 0.09146342f, -0.04714595f, -0.10224693f, 0.01882138f, -0.04750986f, 0.19858976f, 
    0.06873794f, 0.09399445f, -0.05335130f, -0.01093064f, 0.04323801f, 0.04246813f, 0.00389213f, 0.08483031f, 
    -0.06631554f, 0.06676481f, -0.04498004f, 0.03982779f, 0.10782284f, 0.11922527f, -0.10911118f, 0.21225280f, 
    0.21626200f, 0.03075487f, 0.13759562f, 0.07296261f, 0.02403928f, -0.07131607f, 0.02191055f, -0.01600940f, 
    0.06746370f, -0.03502433f, 0.15285707f, 0.02605651f, 0.05103961f, 0.00953029f, -0.00207729f, 0.00378127f, 
    -0.05408229f, -0.20139775f, 0.06770799f, 0.10845046f, -0.27808633f, 0.01998114f, 0.08903275f, 0.06862857f, 
    -0.11263698f, 0.02247691f, -0.03128766f, 0.01564951f, 0.06341628f, 0.06010539f, -0.06321949f, 0.00763689f, 
    -0.02029568f, 0.12448481f, 0.04243077f, -0.03149446f, 0.19262415f, -0.02639288f, 0.10264947f, 0.03843430f, 
    0.00772983f, -0.00298146f, 0.03856271f, 0.05558695f, 0.04664120f, 0.04546106f, 0.01189272f, 0.01055723f, 
    0.01277564f, -0.11280052f, -0.07250454f, 0.01787832f, -0.02343098f, 0.01347415f, 0.03985137f, -0.04779301f, 
    0.14807686f, -0.21434505f, 0.13627489f, -0.21242577f, 0.11483398f, -0.02647858f, 0.06425506f, -0.12440713f, 
    0.14740033f, 0.04973629f, 0.08068461f, 0.02814838f, -0.03826887f, -0.04140764f, -0.01755801f, 0.03067583f, 
    0.12668946f, -0.14709592f, 0.00191957f, -0.02029877f, -0.04634799f, 0.15195875f, 0.27582529f, 0.04422107f, 
    -0.03507214f, -0.04036514f, -0.07818307f, 0.15143436f, -0.01868330f, 0.03071315f, 0.04265403f, 0.02797114f, 
    -0.09080648f, 0.01242920f, -0.00582821f, 0.07787833f, -0.05785126f, 0.04948805f, -0.04826638f, 0.01595174f, 
    -0.01849721f, 0.31770894f, 0.03629645f, -0.07714725f, -0.01347747f, 0.01419625f, -0.07452762f, 0.13058606f, 
    0.09063283f, 0.04030294f, -0.02652871f, 0.09219596f, 0.03493956f, 0.06148231f, -0.01880462f, 0.03114411f, 
    -0.00110715f, -0.02161897f, 0.05116385f, -0.01952338f, 0.11736377f, -0.10940129f, 0.13097422f, 0.13991094f, 
    0.19248576f, -0.10518287f, 0.03684540f, 0.02257804f, 0.07067609f, 0.09350429f, 0.03839931f, 0.03681036f, 
    0.06961172f, 0.01831318f, 0.05102907f, 0.14688642f, -0.02434274f, -0.04018595f, 0.02692092f, -0.02430843f, 
    0.10733576f, -0.26208770f, -0.13973702f, -0.12091113f, 0.25055006f, 0.05609218f, 0.02679549f, -0.00750524f, 
    0.00791622f, 0.13299647f, -0.04534757f, 0.07070120f, -0.03167010f, -0.00135231f, -0.02564595f, 0.00075707f, 
    -0.06116850f, 0.03539961f, -0.10032088f, -0.09063347f, 0.05457347f, 0.06995358f, 0.03117142f, 0.00201102f, 
    0.07656105f, 0.07700711f, 0.10407075f, -0.09420060f, -0.03334754f, 0.06555163f, -0.00431940f, 0.01461390f, 
    -0.00253113f, 0.00303581f, -0.07782786f, -0.01973565f, 0.09715588f, 0.09658060f, -0.02328808f, -0.02721604f, 
    0.01241148f, 0.17609961f, 0.05099784f, -0.03764009f, 0.12650643f, 0.19960152f, 0.10898972f, 0.09311775f, 
    0.05108484f, -0.00120106f, 0.01084482f, 0.03743964f, -0.03220436f, -0.07716247f, -0.13362269f, 0.05760750f, 
    -0.03174328f, -0.07862888f, -0.08624830f, 0.07081363f, -0.30853882f, -0.15656929f, 0.01824351f, 0.14335185f, 
    0.15130658f, 0.00896316f, -0.16043103f, 0.06607243f, 0.07213528f, 0.07734028f, -0.07224147f, 0.03538366f, 
    0.07346921f, -0.06330050f, -0.07552217f, 0.02434965f, -0.06669435f, -0.02640407f, 0.04023905f, 0.03062167f, 
    0.11436983f, 0.26376882f, 0.02213321f, -0.06161709f, 0.14840640f, 0.12193965f, -0.09420055f, 0.07439379f, 
    0.02372598f, -0.00630501f, -0.17353752f, -0.13268884f, -0.00994072f, 0.01529160f, -0.00482023f, 0.04422398f, 
    -0.06685011f, -0.02850445f, -0.04776609f, 0.02102166f, 0.37022486f, -0.00162687f, 0.03983111f, -0.03731473f, 
    -0.18242386f, 0.01386544f, 0.04198486f, 0.14348006f, -0.00677532f, -0.01554700f, -0.07185980f, 0.04410323f, 
    -0.01664344f, 0.09224461f, -0.06173193f, -0.02737662f, 0.00875343f, 0.08910651f, -0.02806634f, -0.04868294f, 
    0.21404174f, 0.16054401f, -0.14756139f, 0.02464641f, -0.01033383f, -0.04748255f, 0.02759157f, 0.07390578f, 
    0.10681218f, -0.06100852f, -0.13057590f, -0.05117935f, 0.00353682f, 0.12671752f, -0.05280292f, -0.03061235f, 
    -0.00475130f, -0.00021217f, -0.02038723f, 0.03061518f, 0.26669320f, -0.10447867f, -0.06401533f, 0.05459891f, 
    0.29663086f, 0.07070528f, -0.01338166f, 0.10961896f, 0.08141342f, -0.00726586f, 0.01229361f, -0.08090909f, 
    -0.04885369f, 0.05711308f, -0.04508705f, 0.02117548f, -0.05306080f, -0.01551314f, -0.03898531f, -0.09425560f, 
    -0.01478975f, 0.04618675f, 0.05599045f, 0.05956677f, 0.07226086f, -0.06109979f, -0.03441791f, 0.06495393f, 
    0.00259225f, 0.08831016f, 0.00396658f, 0.05225318f, -0.03517717f, 0.03778213f, -0.01878101f, 0.01090999f, 
    -0.11982530f, 0.03635409f, -0.01443750f, 0.05484848f, -0.05681103f, -0.14906554f, -0.24210486f, -0.00567880f, 
    0.24457669f, 0.05354808f, -0.11577564f, -0.10014107f, 0.04522731f, 0.08291693f, -0.02527912f, 0.02372307f, 
    0.13362090f, 0.09616740f, -0.01272385f, 0.10372411f, 0.02363282f, -0.02971209f, 0.01069954f, -0.09366392f, 
    -0.31458798f, 0.05439509f, 0.14343964f, -0.03914353f, -0.08927971f, -0.03645558f, -0.01481854f, 0.02732398f, 
    -0.00999526f, -0.00864657f, 0.10409853f, 0.08240058f, 0.02321548f, 0.09521402f, -0.04353387f, 0.00323817f, 
    -0.05529447f, 0.03211199f, -0.13980043f, 0.03109071f, 0.28992593f, -0.14450811f, 0.05636306f, -0.05412244f, 
    -0.03758093f, -0.05361371f, 0.02967784f, 0.03518665f, 0.04198458f, -0.03791464f, 0.02264813f, 0.03201940f, 
    0.04010972f, -0.04299938f, -0.00748119f, 0.00088467f, -0.07998608f, -0.02675286f, -0.00239349f, 0.09793643f, 
    0.36938748f, 0.20607373f, 0.10819945f, -0.02583394f, -0.02141312f, -0.01337183f, -0.02556156f, 0.06099982f, 
    -0.00555207f, 0.03633498f, -0.04295203f, -0.06716077f, 0.01726497f, 0.04673202f, 0.06345519f, 0.04315461f, 
    0.03114641f, 0.01751574f, -0.09967405f, 0.06751779f, -0.01416694f, 0.04258442f, 0.02606685f, 0.18278466f, 
    0.10504390f, 0.10004325f, 0.12495296f, -0.01860600f, 0.06079850f, 0.03982291f, -0.04061907f, 0.02701368f, 
    0.08895724f, -0.05744725f, 0.06978486f, 0.04743255f, 0.06030007f, 0.02542982f, 0.02616598f, -0.06562696f, 
    0.25188127f, 0.27364990f, -0.08704359f, 0.01723485f, -0.07836799f, -0.03756433f, -0.03557434f, 0.10741181f, 
    -0.01647215f, -0.02772210f, -0.09423953f, -0.05353717f, 0.09948909f, -0.01261104f, 0.07599912f, 0.04670840f, 
    -0.02147610f, -0.02839359f, 0.01222043f, 0.02113373f, -0.01669611f, 0.23948734f, 0.07460033f, 0.16726416f, 
    0.02361712f, 0.14875606f, 0.09744597f, 0.09476685f, 0.00119762f, 0.05323687f, -0.01874913f, 0.08530891f, 
    0.07878841f, -0.04454782f, -0.05719973f, 0.02103992f, 0.02215145f, -0.03729079f, 0.02825206f, 0.08249756f, 
    0.17928991f, 0.01702970f, -0.18606757f, -0.00745028f, 0.28405023f, -0.02671198f, -0.04417575f, 0.00539920f, 
    0.01582006f, -0.00294167f, -0.02505432f, -0.05368315f, 0.07845148f, 0.00771842f, -0.04503161f, 0.03661405f, 
    -0.13474499f, -0.04690250f, -0.08756521f, -0.05332804f, 0.06239676f, -0.06939171f, 0.01628973f, -0.06468431f, 
    0.15052560f, 0.03146989f, 0.04469804f, -0.07570314f, -0.05217977f, 0.08974401f, 0.03652046f, -0.02651736f, 
    0.00609250f, -0.02653106f, -0.01151995f, -0.07741475f, 0.01736102f, 0.07282661f, -0.00184266f, -0.13175586f, 
    0.10063806f, -0.14959535f, -0.02149961f, 0.06857096f, -0.06083481f, 0.01930281f, 0.03563604f, 0.04189862f, 
    -0.01199865f, 0.00352489f, 0.02017111f, -0.05829667f, -0.09242811f, -0.03340355f, 0.03551839f, -0.04358555f, 
    -0.00941337f, 0.00391842f, 0.09246250f, -0.00659131f, 0.16744754f, 0.06924918f, 0.03790792f, -0.00964407f, 
    -0.03930486f, -0.00847325f, 0.10595036f, -0.05194578f, 0.01576948f, -0.12975353f, 0.03020748f, 0.07992143f, 
    -0.00721805f, 0.01545517f, -0.01542844f, 0.00555301f, -0.04804289f, -0.00072035f, -0.04463570f, 0.01109864f, 
    0.09428269f, -0.03486958f, 0.01698070f, 0.08314724f, 0.03437663f, 0.21978368f, 0.04120141f, 0.03657754f, 
    0.03074211f, 0.05054839f, -0.01453870f, 0.09281007f, -0.04840093f, 0.11626549f, -0.11567419f, 0.19124825f, 
    0.06507168f, 0.06845658f, -0.11202765f, 0.08724133f, -0.06834807f, -0.29662204f, -0.16726123f, -0.02813745f, 
    -0.09145039f, -0.07496328f, 0.15730084f, -0.09051919f, 0.08127755f, 0.04567260f, -0.04562576f, 0.05682656f, 
    0.06782497f, -0.00387781f, 0.15126973f, -0.01728356f, -0.05294755f, 0.07889835f, -0.14295264f, 0.03167682f, 
    -0.16514184f, -0.23330617f, -0.34500200f, 0.30629474f, -0.02795031f, 0.11453979f, 0.14704297f, -0.09574479f, 
    0.03237778f, -0.01811613f, 0.18208845f, 0.04076304f, -0.03310934f, 0.00628964f, 0.02078924f, -0.11905392f, 
    0.04409190f, 0.03345296f, -0.10339974f, 0.00565885f, 0.26064631f, 0.01371738f, -0.15248556f, -0.00806625f, 
    0.06717437f, -0.11827016f, -0.08118836f, 0.12488300f, -0.03142095f, -0.09546378f, -0.13301565f, -0.03424802f, 
    -0.05603565f, -0.00795135f, 0.10098546f, -0.12005244f, -0.02040477f, 0.09156912f, 0.03440850f, 0.02571526f, 
    -0.44723940f, -0.13989694f, -0.11601769f, -0.09950363f, -0.18624929f, 0.10232116f, 0.09780896f, -0.01580481f, 
    -0.00255924f, 0.08822993f, -0.07875419f, -0.02051349f, -0.11781010f, 0.05084048f, 0.04427598f, -0.02893257f, 
    -0.04525206f, 0.00702558f, -0.05200578f, 0.06493799f, 0.01577591f, 0.30376562f, 0.20228936f, 0.15787135f, 
    0.13883796f, 0.05424887f, 0.11193862f, -0.07688800f, 0.01032571f, 0.09292518f, -0.08324131f, 0.01232906f, 
    -0.01855499f, 0.00576846f, -0.03120418f, 0.11364952f, 0.01401879f, -0.00873173f, -0.01842314f, 0.08328144f, 
    -0.26899934f, 0.07183603f, -0.18298274f, -0.11474544f, 0.15160456f, 0.01038641f, 0.02523011f, -0.06755252f, 
    -0.01627618f, 0.18485805f, 0.05733244f, 0.08761189f, 0.03119450f, -0.10674429f, -0.03857514f, 0.05114144f, 
    0.11316464f, 0.07445193f, -0.19520862f, -0.00651455f, 0.03787325f, 0.09342854f, 0.23046008f, -0.15551373f, 
    0.25290358f, 0.16237953f, -0.07928494f, 0.14599809f, -0.05735423f, -0.01753103f, 0.05413755f, 0.02899918f, 
    0.05787792f, 0.04045482f, -0.00800408f, -0.07693275f, -0.02280820f, -0.14904797f, 0.15428320f, 0.00050402f, 
    0.22363719f, -0.31215796f, -0.08043693f, -0.01235896f, -0.00508991f, -0.17453350f, 0.02436738f, 0.11637200f, 
    -0.09047531f, -0.09327330f, -0.04211077f, 0.01487910f, 0.03985555f, 0.06367937f, -0.08516725f, -0.00796593f, 
    0.00443868f, 0.07971472f, 0.05732497f, -0.05969723f, -0.52491558f, -0.17833054f, -0.07602067f, -0.00701500f, 
    -0.22014868f, -0.00720997f, 0.09639453f, -0.04897763f, 0.02088466f, -0.00477026f, -0.04584043f, -0.07364924f, 
    0.04233115f, 0.02222711f, 0.01816286f, -0.10619485f, 0.09528841f, 0.02323912f, 0.00958122f, -0.02765864f, 
    -0.04225676f, -0.07560532f, -0.15890911f, 0.13194610f, 0.00791067f, 0.26335427f, -0.00974381f, -0.05839911f, 
    0.02195921f, -0.00363183f, 0.06758805f, 0.06014490f, 0.11285010f, -0.07742013f, 0.00851142f, 0.06904566f, 
    0.00878192f, 0.13365121f, -0.07487262f, 0.12158119f, -0.12622438f, -0.10655955f, -0.13504606f, 0.13894701f, 
    0.45251974f, 0.04638143f, -0.20178628f, -0.02166680f, -0.09251620f, 0.12033596f, -0.04168512f, 0.06038855f, 
    0.10183104f, -0.07270909f, 0.12428884f, 0.06350677f, -0.08519137f, 0.07440880f, -0.00642119f, 0.03466162f, 
    -0.04621429f, 0.05307974f, -0.10304438f, -0.12649240f, 0.28807914f, -0.08870028f, 0.02820479f, -0.01540138f, 
    -0.09018284f, -0.04904572f, 0.08778095f, -0.04542051f, -0.14132954f, -0.04171091f, -0.03931595f, 0.12060726f, 
    0.06759737f, 0.02739353f, 0.05863468f, 0.10435329f, 0.08954979f, 0.31448078f, 0.13856526f, -0.14504036f, 
    0.27873260f, 0.00039681f, -0.13075157f, 0.06692632f, 0.03095870f, -0.07386892f, 0.09842755f, -0.02360946f, 
    0.04087341f, -0.03278473f, -0.04077301f, 0.02525867f, 0.10453446f, -0.08541561f, 0.07783211f, 0.01451257f, 
    0.30329990f, -0.01104912f, 0.16237313f, 0.19919822f, -0.01041648f, -0.13696541f, -0.06546958f, -0.14721738f, 
    0.06819634f, -0.10262105f, -0.02667827f, 0.09638703f, -0.00106447f, 0.06348369f, -0.04592551f, -0.00441841f, 
    -0.08019596f, -0.02541502f, -0.03006368f, -0.07361849f, 0.01104092f, 0.36567017f, 0.01011492f, 0.09768026f, 
    0.14314468f, -0.02214434f, -0.02391114f, 0.02237734f, 0.03906629f, 0.03017375f, -0.07120307f, -0.00034089f, 
    0.02270372f, 0.00920658f, 0.08554649f, 0.13144244f, -0.02623532f, 0.04148011f, 0.17212248f, -0.04103104f, 
    -0.12131106f, 0.16365716f, -0.20782445f, 0.22834405f, -0.18795733f, 0.24455015f, 0.29640862f, -0.12593257f, 
    0.01432243f, -0.04310337f, 0.09856571f, 0.16051030f, 0.00005229f, 0.13005166f, 0.01431413f, -0.02974859f, 
    0.10297550f, -0.05374906f, -0.04882359f, -0.03192601f, -0.37431762f, -0.01328914f, -0.14229862f, 0.02348585f, 
    -0.66741246f, 0.12616853f, -0.02133851f, -0.01608479f, 0.01244201f, 0.02212671f, 0.02555096f, -0.08218317f, 
    -0.03407864f, 0.19647048f, -0.11963528f, 0.09291103f, 0.05518899f, 0.01088624f, -0.09549273f, -0.04927713f, 
    -0.16781157f, 0.10737482f, -0.12250343f, -0.18313996f, -0.41382238f, 0.24498039f, -0.03241620f, -0.01829685f, 
    -0.09249370f, -0.11546446f, 0.10979432f, 0.07514127f, -0.17265177f, 0.10902899f, -0.11194061f, 0.13008095f, 
    -0.04328320f, -0.11500531f, -0.01291032f, 0.07598614f, 0.11801039f, 0.11680640f, -0.03024197f, 0.10322878f, 
    0.37940127f, 0.11049423f, 0.05584378f, 0.00981555f, -0.04345272f, 0.02486713f, -0.00855262f, 0.09355949f, 
    0.11300736f, 0.03476097f, -0.00265991f, 0.13217480f, 0.09255681f, 0.07556862f, 0.00363056f, 0.06528237f, 
    -0.35119012f, -0.31372091f, -0.03957363f, -0.12429009f, 0.27865037f, -0.02096125f, -0.03495235f, -0.07317621f, 
    0.06970204f, 0.09978411f, 0.05865190f, -0.03999840f, 0.13525172f, -0.05658327f, 0.25418395f, -0.03027297f, 
    -0.03365361f, -0.06959150f, -0.03206133f, -0.08963695f, 0.23804392f, 0.32025123f, -0.14828365f, -0.13247970f, 
    0.08929651f, 0.19318917f, -0.04613565f, 0.04015424f, 0.00444355f, -0.05816103f, -0.03939614f, -0.06520268f, 
    -0.11128284f, 0.04823272f, -0.16466375f, -0.06933654f, -0.03252967f, 0.10531704f, 0.11124203f, 0.15199451f, 
    -0.26165578f, -0.08998217f, -0.04022077f, 0.09201045f, -0.02925543f, -0.13756396f, -0.03654318f, -0.07979291f, 
    0.04792013f, 0.01846647f, -0.19177277f, 0.03313097f, -0.03778499f, 0.03930518f, 0.02878944f, -0.02268877f, 
    0.03873901f, 0.04944349f, -0.17345117f, -0.03754815f, 0.38394094f, -0.12916873f, 0.00538789f, -0.02972491f, 
    0.02770993f, -0.07088881f, 0.15106620f, 0.10627127f, -0.03036745f, 0.05149858f, 0.03498080f, -0.17673588f, 
    0.04468526f, 0.02518710f, 0.01326451f, -0.00088409f, 0.12534235f, 0.11077341f, -0.01636521f, 0.08207681f, 
    -0.01296435f, -0.03444421f, 0.10049770f, -0.03099411f, 0.07220659f, 0.13815452f, 0.04959032f, -0.07003070f, 
    -0.01013849f, 0.01061385f, 0.09657881f, 0.15316945f, 0.02180847f, 0.15896560f, -0.01148325f, 0.17639503f, 
    0.00645553f, 0.06359497f, -0.02307181f, -0.12503582f, 0.43986470f, 0.16202094f, 0.08241352f, 0.09817535f, 
    0.09756611f, -0.06517604f, 0.13062397f, 0.09405484f, -0.03993293f, -0.14052656f, 0.05004580f, -0.09951111f, 
    -0.06938853f, 0.04124788f, -0.02390726f, 0.06349695f, -0.00587928f, 0.11006111f, -0.07807539f, 0.18085942f, 
    -0.19295563f, 0.09100819f, -0.07741985f, -0.07016530f, -0.24336633f, 0.06620365f, 0.02375663f, -0.01058788f, 
    -0.05942826f, 0.07206543f, 0.08126263f, 0.03107616f, 0.00799332f, -0.03053763f, 0.00762811f, 0.03312184f, 
    -0.10121417f, -0.07850266f, 0.03810692f, -0.00765822f, 0.09969002f, 0.04091314f, 0.02488184f, -0.08339020f, 
    0.10110521f, -0.19648556f, -0.03631093f, -0.09732434f, 0.10236354f, -0.11727116f, -0.09514141f, 0.07769661f, 
    -0.03618532f, -0.00374141f, -0.10338014f, 0.01168969f, -0.08069194f, -0.09735462f, -0.08516169f, 0.08499212f, 
    -0.05938921f, 0.21392289f, 0.09377792f, -0.01607948f, 0.23932201f, 0.12486184f, -0.04394522f, 0.14149043f, 
    -0.03029308f, 0.10636397f, -0.03494198f, 0.03485306f, 0.01074113f, -0.01669754f, 0.13744590f, 0.13627236f, 
    0.06577879f, -0.07243039f, 0.02590428f, -0.01745215f, 0.29397711f, 0.37564644f, 0.08141744f, -0.18460050f, 
    0.25081328f, 0.04877781f, 0.00150511f, 0.06087694f, -0.02550563f, -0.05501119f, 0.06717271f, -0.04049377f, 
    0.00700504f, -0.01894278f, 0.00404361f, 0.07086379f, 0.04796449f, -0.06031969f, 0.04390822f, 0.02302591f, 
    0.07097291f, 0.08893462f, 0.14566359f, -0.11694974f, -0.04773675f, -0.04402972f, 0.04443802f, 0.13713795f, 
    -0.06364088f, 0.09711060f, 0.04757548f, -0.07042978f, -0.00533530f, 0.06102718f, 0.05555345f, -0.08813436f, 
    0.08298004f, -0.02163509f, -0.01956215f, -0.05030559f, 0.28058356f, -0.37914485f, 0.14359832f, -0.07304173f, 
    0.07327928f, -0.18045132f, -0.00365778f, -0.07754705f, 0.11025595f, -0.06851325f, -0.06205812f, 0.07137293f, 
    0.05737448f, 0.02848678f, -0.04660485f, -0.05252003f, 0.00920094f, 0.01094470f, -0.09082451f, 0.07526021f, 
    0.01895809f, 0.02538350f, 0.03214342f, 0.00938967f, -0.00556920f, 0.01008869f, -0.03609830f, -0.00099680f, 
    0.02018769f, -0.01211531f, -0.01635381f, -0.04430007f, -0.03864300f, 0.03076958f, 0.01205038f, 0.03059147f, 
    0.00279761f, -0.01578755f, -0.01490536f, 0.02787449f, -0.02589095f, -0.03072786f, -0.02996359f, -0.01727260f, 
    0.01032810f, -0.02936839f, -0.01281098f, -0.00988891f, -0.03573270f, 0.01091738f, -0.04093876f, -0.01710108f, 
    0.02514432f, -0.00881100f, 0.02040231f, 0.01989246f, -0.01331084f, -0.04502950f, -0.03584997f, -0.02937904f, 
    0.00892057f, 0.00464286f, 0.00301083f, 0.01978967f, -0.01969845f, 0.01888710f, 0.02125806f, -0.02728200f, 
    -0.03148963f, -0.04354985f, -0.00379761f, -0.00548222f, -0.02276996f, -0.00380707f, 0.02374792f, 0.02483620f, 
    0.03290936f, -0.02057682f, 0.03226409f, -0.00056057f, -0.00285062f, -0.04537264f, -0.04525123f, -0.02667194f, 
    -0.04097946f, -0.01282051f, -0.02825387f, -0.04463911f, -0.00786882f, 0.03026701f, 0.01159743f, -0.01906336f, 
    -0.00839546f, -0.02774681f, -0.00347558f, -0.01773576f, -0.01529363f, 0.03048966f, 0.00644994f, -0.02044511f, 
    -0.03702664f, 0.00356177f, 0.00225986f, -0.02898966f, 0.02009489f, -0.03882487f, 0.00018050f, -0.03677398f, 
    -0.02968178f, -0.03683583f, -0.03865549f, -0.03993450f, -0.01822961f, -0.00405830f, -0.01041554f, -0.01049199f, 
    -0.01086481f, 0.01499585f, -0.00978134f, -0.00813364f, -0.03719907f, -0.03647818f, -0.03159378f, 0.00121897f, 
    0.01188760f, -0.02642462f, -0.00995692f, -0.00275396f, -0.03457591f, 0.00911092f, 0.00362119f, -0.03967618f, 
    0.03183740f, 0.01482535f, -0.02195247f, 0.02732860f, 0.02497576f, -0.03939379f, -0.01424768f, -0.02140983f, 
    -0.02342317f, -0.02670000f, -0.01085743f, 0.02142621f, 0.02349440f, 0.02762516f, 0.03147675f, -0.02965935f, 
    -0.00957275f, -0.04020338f, -0.02581090f, -0.00752704f, 0.02840878f, 0.02210177f, -0.00029315f, 0.00834181f, 
    -0.03158499f, 0.00502485f, 0.01704620f, -0.03729539f, -0.02064409f, 0.01380364f, -0.01437386f, 0.01444984f, 
    0.00104237f, 0.01636400f, -0.02127900f, 0.01690359f, 0.01119632f, 0.03064503f, 0.02899375f, 0.00591880f, 
    -0.03855121f, -0.04439614f, -0.02143640f, -0.04371033f, -0.04301303f, 0.02007094f, 0.00848776f, 0.00960025f, 
    -0.01059511f, -0.01684242f, -0.04302780f, 0.00777308f, 0.01184113f, -0.03592639f, 0.01678441f, -0.03749269f, 
    0.03068200f, -0.03013557f, 0.00476548f, 0.00230014f, -0.03862194f, -0.04169755f, -0.01386484f, -0.00256920f, 
    -0.02473631f, 0.01709048f, -0.03873270f, -0.03815190f, -0.03853063f, -0.01923046f, -0.00634236f, 0.02822892f, 
    0.01076688f, -0.01265100f, 0.02073835f, -0.02396675f, 0.02103274f, 0.01514336f, -0.04319710f, -0.02797275f, 
    -0.03339211f, -0.01422514f, 0.00089311f, 0.02424385f, 0.01048198f, 0.03214366f, 0.00590944f, -0.00456849f, 
    0.01897130f, -0.00410627f, 0.00417267f, 0.02404452f, -0.01031880f, -0.03673568f, -0.01019356f, -0.01718591f, 
    -0.02524181f, -0.02223656f, -0.03750156f, -0.01890318f, 0.02811493f, 0.02630933f, 0.01689345f, 0.02891039f, 
    0.00390862f, -0.00943842f, 0.01963263f, 0.02056959f, -0.01486390f, -0.02126476f, -0.01297327f, -0.01818607f, 
    0.01174442f, -0.01158835f, 0.00361906f, -0.03201302f, 0.01783047f, -0.03466640f, -0.00288800f, 0.02420351f, 
    -0.03403071f, 0.00896745f, -0.01218613f, 0.02639720f, -0.01613201f, -0.03576896f, -0.03450817f, -0.02406632f, 
    -0.00440649f, -0.03168055f, -0.03710518f, 0.02848508f, 0.02928897f, -0.02400354f, -0.00482376f, 0.00629957f, 
    -0.03334976f, 0.00909415f, 0.00735465f, 0.00279808f, -0.04081684f, -0.00655248f, 0.01057278f, 0.01083510f, 
    0.01631601f, 0.02162822f, -0.02409681f, -0.01165604f, 0.00927364f, -0.03669942f, 0.02531445f, -0.03342746f, 
    0.00286079f, -0.01273185f, 0.02442768f, -0.00077176f, -0.01682086f, 0.01101335f, -0.04270217f, -0.01064004f, 
    -0.03774881f, 0.03039123f, -0.00203457f, -0.03456432f, -0.02713688f, -0.04295786f, -0.04510336f, -0.03208091f, 
    -0.02304625f, 0.02453040f, 0.00412343f, -0.01658018f, 0.01571395f, -0.01304870f, 0.00735636f, 0.00987722f, 
    0.00213379f, -0.01610459f, -0.01193934f, 0.02202086f, -0.04066997f, -0.04089094f, -0.04360076f, -0.01205231f, 
    0.02034158f, 0.01641066f, -0.02911366f, -0.01375461f, -0.02979069f, 0.01091630f, -0.01042963f, -0.02335914f, 
    0.02077083f, -0.00008613f, 0.00855401f, -0.01514492f, -0.03109700f, -0.03577647f, 0.02600823f, -0.04060795f, 
    0.02517044f, 0.00626482f, 0.01087213f, 0.01981046f, 0.00306067f, -0.01973655f, 0.02463004f, 0.01579629f, 
    0.02138145f, 0.02045608f, -0.02496064f, -0.01038668f, 0.00857818f, -0.02411340f, 0.02238055f, 0.00125617f, 
    0.00363603f, 0.01764306f, 0.02906287f, 0.00548831f, 0.02986826f, 0.02762917f, -0.03722654f, 0.00004622f, 
    0.01885282f, 0.02696116f, -0.03124002f, 0.02127668f, 0.02601780f, -0.01224646f, -0.00993720f, 0.01749926f, 
    -0.02525727f, -0.04064523f, 0.01735571f, -0.02234197f, -0.04354917f, -0.00002278f, 0.02588532f, -0.02673784f, 
    -0.03657806f, -0.03359558f, 0.00695984f, -0.03371083f, 0.00845242f, 0.03120675f, -0.03566067f, -0.02045532f, 
    -0.00421732f, 0.01243137f, -0.02949353f, -0.03741521f, 0.01054692f, -0.02118480f, -0.00554002f, -0.03810709f, 
    -0.01654561f, 0.00226956f, -0.04053690f, -0.00536109f, 0.00731313f, 0.00597981f, 0.01292319f, -0.02135241f, 
    -0.03511786f, -0.03596237f, -0.02458187f, -0.00573854f, -0.04353744f, 0.03348218f, -0.03762334f, 0.02971662f, 
    -0.03482054f, 0.00156342f, -0.00066454f, 0.02130240f, -0.00795880f, 0.00016981f, -0.01341065f, 0.00497186f, 
    -0.02036010f, -0.01018611f, 0.03039392f, -0.00939923f, 0.01644762f, -0.02388765f, -0.04236116f, -0.00919317f, 
    -0.01261640f, -0.00823219f, 0.01902129f, -0.00369390f, 0.01862908f, -0.01948365f, -0.01332627f, -0.01556112f, 
    -0.02287300f, -0.02822147f, 0.00226426f, 0.03262645f, -0.02958702f, 0.00549031f, 0.01502468f, -0.00037121f, 
    -0.03164433f, 0.01483911f, -0.00392517f, 0.00433074f, 0.02177141f, 0.02559069f, -0.04163220f, -0.00668869f, 
    0.00960050f, -0.00020045f, 0.01276705f, 0.00032672f, -0.01602848f, -0.03817659f, -0.03080338f, 0.01137031f, 
    0.00365689f, 0.03115925f, -0.02766417f, -0.04432982f, -0.02300455f, 0.02328344f, -0.01658594f, 0.01131018f, 
    0.01146626f, -0.02196633f, 0.03122382f, -0.03269909f, 0.01844827f, 0.01110580f, -0.04264526f, 0.02721639f, 
    -0.01142181f, -0.01963967f, -0.01933239f, -0.01508791f, -0.02992451f, -0.04469416f, -0.00967489f, -0.03623137f, 
    -0.03189084f, 0.00583340f, 0.02979498f, -0.02160242f, -0.04197045f, -0.03211286f, -0.02177574f, -0.02001337f, 
    -0.03998581f, 0.00252071f, -0.01398843f, 0.02070431f, -0.03538464f, 0.00060583f, -0.01106217f, 0.00066863f, 
    0.01454359f, -0.00100076f, -0.02893738f, -0.03148334f, 0.01774139f, -0.02151158f, -0.03647760f, -0.00064411f, 
    -0.01956717f, -0.01673092f, 0.02558473f, 0.00828221f, 0.01613239f, 0.01111211f, -0.01675582f, -0.02299700f, 
    0.02713044f, -0.02895294f, -0.02666604f, 0.00646652f, -0.04234904f, 0.01802669f, 0.03129204f, -0.00742664f, 
    -0.01346071f, 0.00361553f, -0.02577020f, 0.02536766f, -0.01938933f, -0.00972878f, -0.03246187f, -0.03620997f, 
    -0.03163657f, -0.02612434f, -0.03411151f, -0.03385410f, 0.01098656f, -0.02196784f, -0.02268026f, 0.00950206f, 
    0.00212923f, -0.00241769f, 0.00179600f, -0.00196435f, -0.01032425f, -0.04443990f, -0.02786002f, 0.00782632f, 
    0.00160361f, -0.00783708f, -0.04269185f, -0.03261044f, 0.01943237f, 0.00042643f, 0.00783254f, -0.02560494f, 
    0.01443453f, 0.00125319f, -0.00488948f, -0.03606148f, -0.03611744f, 0.01910248f, 0.00356096f, 0.01994210f, 
    -0.03632991f, 0.01043790f, 0.02538065f, -0.04129522f, -0.01099663f, -0.04483297f, 0.03017598f, 0.00452714f, 
    -0.00048195f, -0.04390072f, 0.01824187f, 0.02987181f, -0.00456488f, -0.03694749f, -0.01949264f, -0.02070771f, 
    -0.03005440f, 0.00636503f, -0.02656080f, 0.03219547f, 0.02317410f, -0.02420788f, -0.03127388f, -0.02205733f, 
    -0.02114463f, -0.00192358f, -0.04364822f, -0.02973982f, 0.02552703f, -0.02170042f, -0.01995580f, -0.04354521f, 
    -0.01829510f, 0.00456072f, -0.02364140f, 0.02858024f, 0.03240213f, 0.00559713f, 0.00470748f, 0.01561536f, 
    -0.03144563f, -0.00130154f, 0.02735380f, -0.04293344f, -0.01431693f, -0.01182985f, 0.01859448f, -0.04327762f, 
    -0.01313700f, 0.01721412f, -0.02392050f, -0.04549127f, 0.00317180f, 0.00431613f, -0.03267341f, 0.00795961f, 
    -0.00768196f, -0.02764348f, -0.00759119f, 0.01718996f, 0.01483585f, -0.01050302f, -0.00097227f, 0.00628479f, 
    0.01459800f, 0.01434712f, 0.03220539f, 0.02172713f, 0.01608843f, -0.03624301f, 0.01466605f, -0.00579770f, 
    -0.00687927f, 0.02771287f, -0.01100936f, -0.01352146f, -0.04045096f, 0.00845079f, -0.02466338f, -0.03612267f, 
    0.01628410f, -0.00770719f, -0.02484405f, 0.00966604f, -0.01894504f, 0.03139197f, -0.01099449f, -0.01801693f, 
    0.02943812f, -0.00050353f, 0.01687691f, 0.02347417f, -0.00263606f, -0.02093645f, 0.03239936f, -0.04208909f, 
    -0.01466859f, 0.01761932f, 0.02571542f, 0.02884874f, 0.03145899f, 0.02630650f, 0.01459355f, -0.00056571f, 
    -0.35434839f, -0.10896056f, 0.13716297f, 0.06709425f, 0.04548837f, -0.08145528f, 0.01809387f, -0.01606876f, 
    0.11264433f, 0.10891403f, -0.03020081f, -0.02934935f, -0.01645429f, -0.00969324f, -0.15860125f, -0.04868204f, 
    0.06680542f, -0.03209883f, 0.00766097f, 0.05383948f, -0.18630575f, 0.00394147f, 0.00583387f, -0.06767810f, 
    -0.05267189f, 0.10399004f, 0.00958150f, -0.02964990f, 0.01402844f, -0.05696131f, -0.02151265f, -0.04908196f, 
    0.01714022f, 0.00397038f, -0.01855300f, -0.06885971f, -0.01284991f, -0.01953954f, 0.06728747f, 0.04407086f, 
    -0.02155679f, 0.10680830f, -0.06054712f, 0.09676357f, 0.29196605f, -0.00512310f, -0.03942344f, -0.03521770f, 
    0.18325254f, -0.04329917f, -0.05150477f, 0.00920052f, -0.04020064f, 0.02962692f, 0.04578286f, -0.07047418f, 
    0.15515845f, 0.03192538f, 0.04515566f, -0.01074454f, 0.21457389f, 0.19058642f, -0.13088207f, 0.10685496f, 
    0.05328879f, 0.04917165f, -0.02496574f, 0.05424280f, -0.00137191f, 0.09064670f, -0.08546559f, -0.07001858f, 
    0.02874750f, 0.06829372f, 0.00445842f, 0.05474570f, -0.04807838f, 0.08664431f, -0.04097350f, 0.01292683f, 
    0.06532512f, -0.24609853f, -0.09103840f, -0.01510408f, -0.07379325f, -0.09486515f, -0.00159425f, 0.05874934f, 
    -0.01050190f, -0.06825917f, -0.00440754f, -0.06062673f, 0.06360856f, -0.05024710f, -0.10732848f, 0.07420877f, 
    -0.01062366f, 0.00056478f, 0.05033536f, 0.06634232f, 0.09838507f, 0.16736855f, 0.19145501f, -0.01646932f, 
    0.10217179f, 0.02531984f, 0.09877297f, 0.00525581f, 0.00758102f, 0.04782932f, 0.01740883f, -0.04268915f, 
    0.02068408f, -0.03200843f, -0.00077839f, -0.04606490f, 0.12955654f, -0.00408931f, 0.02326601f, 0.05827400f, 
    -0.20601043f, -0.06948868f, 0.10376793f, -0.10555846f, 0.04787406f, 0.12295471f, 0.01036292f, 0.00948173f, 
    0.06689664f, -0.05132950f, -0.02041331f, 0.03367047f, 0.04674868f, 0.01887789f, 0.00961080f, -0.00353172f, 
    0.04114223f, -0.01476705f, -0.05176779f, 0.01988479f, 0.26098430f, 0.00442930f, 0.11036564f, 0.15676285f, 
    0.02489730f, -0.00350805f, 0.07099640f, -0.00910972f, -0.02913598f, 0.05558686f, -0.04548424f, 0.00183952f, 
    0.01622664f, -0.05045387f, -0.03747033f, -0.07795054f, -0.08758236f, -0.07114154f, -0.13564989f, 0.04091826f, 
    -0.05905630f, 0.28515884f, -0.24984315f, 0.19248137f, -0.06133572f, 0.05131661f, 0.05333312f, 0.02803121f, 
    0.05175852f, -0.11910556f, -0.00000785f, 0.01027695f, 0.00325290f, -0.01617599f, 0.02436698f, 0.08669014f, 
    0.00281455f, 0.01976069f, -0.02575243f, -0.03002201f, -0.08937801f, -0.27734065f, -0.01453273f, -0.09024579f, 
    -0.01697550f, -0.05869658f, 0.01230933f, -0.01832665f, -0.04338220f, -0.09021678f, 0.00745204f, -0.04758153f, 
    0.01328058f, 0.04671714f, 0.07064161f, 0.00773343f, 0.04024230f, -0.01261681f, -0.05584503f, -0.00253742f, 
    -0.01571587f, -0.31045613f, -0.02849548f, 0.11833116f, 0.00786834f, -0.07212102f, 0.02712648f, -0.08965609f, 
    0.05789596f, 0.04666587f, 0.00620020f, -0.03855859f, -0.14372283f, -0.06944419f, -0.06368706f, -0.14235391f, 
    0.00365553f, -0.11066672f, 0.05632698f, -0.07541188f, -0.02024681f, -0.18599504f, -0.12969147f, 0.07103000f, 
    -0.20810480f, -0.02874883f, 0.01260194f, -0.03228556f, -0.00759769f, 0.00409441f, 0.01916942f, 0.01925830f, 
    -0.02885434f, 0.09887161f, 0.01864232f, -0.05322877f, 0.08241301f, 0.08457556f, 0.06399515f, -0.04783150f, 
    0.19055538f, 0.17070594f, 0.32433957f, 0.27337334f, 0.08741540f, 0.02699811f, 0.06100154f, -0.03405317f, 
    -0.01107930f, 0.07300793f, -0.05924188f, 0.00444686f, -0.04793039f, 0.00673726f, 0.07431384f, 0.03776029f, 
    0.02460559f, -0.05930642f, -0.03214834f, -0.00245791f, 0.15407197f, -0.02939826f, 0.17822266f, 0.15029474f, 
    0.09001925f, -0.04990445f, 0.02458458f, 0.02304615f, -0.03623737f, -0.00871643f, -0.04283880f, 0.00722548f, 
    -0.01767885f, 0.04172421f, 0.09110320f, -0.03341858f, -0.00809765f, 0.06470827f, 0.01200405f, 0.09121501f, 
    -0.10647079f, 0.29514840f, 0.03210009f, 0.20077701f, -0.03932719f, 0.05369583f, 0.00139542f, 0.08058452f, 
    0.08546127f, 0.08553708f, -0.08411038f, 0.04468095f, 0.04529468f, -0.01473278f, -0.07044370f, -0.09323089f, 
    0.00774846f, 0.02469788f, 0.14655171f, -0.05642568f, 0.37595290f, 0.23972693f, 0.04673886f, 0.09524222f, 
    0.12096202f, 0.05359324f, -0.02406133f, 0.19628014f, 0.17490174f, -0.00344615f, 0.00275705f, -0.00908956f, 
    0.00754555f, -0.03954959f, 0.07531738f, -0.00326649f, -0.08161926f, 0.21390642f, -0.02241415f, 0.01070105f, 
    0.01515542f, -0.18452688f, 0.20573318f, -0.09611459f, 0.15609930f, -0.05434192f, 0.03998824f, -0.04241829f, 
    0.10994303f, -0.02400155f, 0.06131453f, 0.04810784f, -0.03292206f, -0.00837099f, 0.06836917f, 0.04959071f, 
    0.00803991f, 0.08315562f, 0.00001676f, 0.04514920f, -0.11265402f, -0.16849865f, -0.03716755f, -0.18723714f, 
    0.07414696f, -0.06256523f, -0.06257923f, -0.03030699f, 0.07058492f, 0.03469244f, 0.07359545f, -0.04083672f, 
    -0.02618308f, -0.00492543f, 0.02048601f, 0.00062869f, 0.03852935f, -0.00123540f, -0.06392902f, 0.07633455f, 
    -0.06252269f, -0.26947623f, -0.10229812f, -0.04877460f, -0.06078760f, -0.08879012f, -0.09066652f, -0.00065396f, 
    0.01015112f, 0.08960880f, -0.02045096f, -0.03360014f, -0.02399054f, -0.00420087f, -0.06179056f, 0.08612942f, 
    0.03802036f, -0.03099390f, -0.03999745f, 0.02071397f, -0.12283067f, -0.04416628f, -0.00396075f, 0.18589267f, 
    -0.15897457f, -0.07966945f, 0.01890397f, -0.04744661f, 0.07397899f, 0.02199216f, -0.03819131f, 0.03088225f, 
    -0.00110592f, -0.03172433f, 0.05683092f, 0.00454764f, -0.06957142f, 0.07386597f, 0.08161878f, 0.07510900f, 
    0.23447235f, -0.19896390f, -0.09529867f, 0.00314685f, -0.14267443f, -0.02809265f, 0.00189081f, 0.03470102f, 
    -0.00500402f, -0.10754121f, 0.00335643f, 0.07755571f, -0.04791954f, -0.03004947f, -0.13115557f, 0.00355981f, 
    -0.01928220f, 0.04622444f, 0.04123351f, 0.08208332f, 0.18994096f, 0.10614540f, 0.10973350f, 0.25504959f, 
    0.06802134f, 0.04415993f, 0.03708246f, 0.08489236f, -0.11848169f, -0.01182211f, -0.11215694f, 0.03225546f, 
    -0.06112292f, -0.03848107f, -0.04834502f, -0.01753727f, 0.00011741f, -0.02114543f, 0.06612547f, 0.03292616f, 
    0.00241362f, 0.02386159f, 0.00389020f, -0.00454725f, -0.15464236f, 0.07097612f, 0.05478761f, 0.06531673f, 
    0.08724207f, -0.08298845f, 0.03588010f, 0.07528155f, -0.05439803f, 0.00207799f, 0.03295596f, -0.00515409f, 
    -0.02207782f, -0.01627885f, 0.06835863f, 0.02491610f, 0.08829329f, 0.00138803f, -0.01369615f, 0.08379500f, 
    -0.09957175f, -0.01222911f, -0.04871292f, -0.04152840f, 0.02003188f, 0.00395607f, -0.07220864f, 0.13655807f, 
    -0.09992476f, -0.00299382f, 0.03267103f, 0.01873806f, 0.02651499f, -0.00113523f, -0.07029466f, -0.08229903f, 
    -0.26194596f, -0.35592160f, -0.11408862f, -0.08412302f, -0.15722668f, -0.09301304f, -0.00883723f, -0.05807463f, 
    0.03701762f, 0.05959484f, -0.00187419f, -0.01837809f, -0.05893127f, -0.05705277f, -0.03352867f, -0.06123749f, 
    0.09870075f, 0.00939207f, 0.02183775f, 0.06811845f, 0.06748581f, 0.28839669f, -0.10758120f, 0.18189922f, 
    0.12926695f, 0.09855392f, -0.02531331f, 0.00733992f, 0.03323282f, 0.07362976f, -0.13229415f, -0.00156227f, 
    0.03766430f, 0.02825349f, -0.08273792f, -0.00389988f, 0.01836443f, 0.04146519f, -0.00132540f, 0.00885662f, 
    0.01871970f, -0.37339357f, -0.13090874f, 0.00402548f, -0.05986104f, -0.03045981f, -0.07901833f, 0.00070222f, 
    -0.03177012f, -0.02772994f, 0.04360239f, -0.06066662f, -0.11783901f, 0.05438748f, -0.10540228f, 0.03998800f, 
    0.02226502f, -0.01327319f, 0.04879251f, -0.07044055f, 0.10043832f, 0.20374271f, -0.07526021f, 0.25284877f, 
    0.00089343f, 0.08097729f, -0.04419569f, 0.01894577f, 0.01930751f, -0.00405935f, -0.11448709f, -0.08322516f, 
    -0.08225691f, -0.01939057f, 0.04311712f, 0.12127434f, -0.11181347f, 0.03401276f, 0.07915626f, -0.05130889f, 
    0.14633612f, 0.06210000f, 0.15179580f, 0.16582863f, -0.04726216f, -0.06919686f, 0.08834516f, 0.04541358f, 
    -0.08623492f, 0.08319203f, -0.05653240f, 0.08948251f, -0.08122574f, 0.01776275f, -0.00643688f, 0.09521930f, 
    0.00888964f, -0.02743782f, 0.05294317f, 0.04631880f, 0.21441405f, 0.06408002f, 0.15243775f, 0.19234221f, 
    0.21316436f, 0.01323958f, 0.08920088f, 0.04999735f, -0.06826526f, -0.04240298f, -0.11297470f, -0.01617808f, 
    -0.04678968f, -0.05412855f, 0.02200543f, 0.05294907f, -0.00895271f, 0.09351166f, 0.09376512f, 0.06958972f, 
    0.27128929f, 0.16435105f, 0.00121129f, 0.03699077f, 0.01653469f, 0.05230109f, -0.00241109f, -0.06070269f, 
    0.02125287f, 0.05427246f, -0.06248847f, 0.02499804f, 0.06025764f, -0.06047892f, 0.04088164f, 0.03088261f, 
    0.07609051f, -0.01133113f, 0.02740290f, -0.05044509f, 0.26679647f, 0.04585553f, 0.06477394f, 0.05613232f, 
    -0.19569463f, 0.02636564f, 0.07726107f, -0.01710469f, -0.05042350f, 0.06564479f, -0.09085611f, 0.09509537f, 
    0.09575393f, -0.03720342f, -0.09957111f, -0.08084070f, -0.06016764f, 0.02951366f, -0.05365222f, -0.01315254f, 
    -0.03557200f, -0.02802779f, -0.02105189f, -0.02652523f, 0.00875584f, -0.03814001f, -0.04062156f, -0.00637393f, 
    -0.01772597f, 0.02978789f, 0.02146349f, -0.01458718f, -0.01019946f, -0.01133872f, 0.01653703f, 0.00615091f, 
    -0.01026385f, 0.03001068f, -0.03952955f, 0.01344747f, 0.02084686f, -0.03072643f, 0.01815103f, -0.02744759f, 
    0.00804392f, 0.00105268f, -0.03690668f, -0.02595395f, 0.00200035f, 0.00112902f, -0.03624629f, 0.01653234f, 
    -0.04031734f, -0.00607499f, -0.01160502f, -0.03063780f, -0.01489005f, -0.04305163f, -0.01640832f, -0.01686109f, 
    -0.02506250f, -0.02934241f, 0.00371367f, -0.01176208f, -0.00784110f, 0.00247267f, -0.02257002f, -0.01334786f, 
    0.00752342f, 0.01828180f, -0.00465062f, 0.03537520f, 0.00913858f, 0.02366100f, 0.00090120f, 0.01632433f, 
    -0.01985299f, -0.01259817f, -0.00640376f, -0.04515097f, -0.01644549f, 0.02856497f, -0.01600081f, -0.03402533f, 
    -0.03117438f, 0.01809314f, 0.01848384f, 0.02334318f, 0.00487749f, -0.02839153f, -0.02524410f, -0.02947292f, 
    -0.03686911f, -0.02797908f, -0.03939793f, -0.03551235f, 0.02646517f, 0.02240258f, -0.01431540f, 0.00341832f, 
    0.02544647f, -0.03430653f, -0.03849269f, 0.00127706f, 0.02106692f, 0.00531065f, -0.00738540f, 0.02438992f, 
    0.00145833f, -0.00728098f, -0.00185066f, -0.03035942f, 0.02417239f, -0.01225242f, -0.00271077f, -0.04267927f, 
    -0.02572746f, 0.00325425f, -0.01023827f, 0.02054657f, -0.02064983f, -0.03071298f, -0.02690634f, 0.01327306f, 
    -0.01091123f, 0.00872666f, -0.01756578f, 0.01720564f, -0.04432584f, -0.03467446f, -0.00631960f, -0.00826591f, 
    -0.03713954f, -0.01694828f, -0.02974291f, -0.02208052f, -0.00814631f, -0.02867275f, -0.00237313f, 0.02243367f, 
    -0.00492419f, -0.03202186f, 0.03050740f, -0.02020517f, 0.00252749f, -0.00298637f, 0.02944204f, -0.01735033f, 
    0.00048093f, -0.01603342f, 0.01254139f, -0.01385255f, -0.02990539f, -0.04631500f, -0.00780220f, -0.02325791f, 
    0.00234274f, -0.00088799f, -0.01172995f, -0.04093971f, -0.03392446f, 0.02284656f, -0.03099921f, 0.01499134f, 
    -0.00086467f, -0.01288440f, 0.00766599f, -0.00355480f, -0.02082190f, -0.03609521f, -0.04305988f, 0.00451108f, 
    -0.00985127f, 0.00324738f, 0.00027345f, -0.04215713f, -0.00641695f, 0.00474567f, 0.03037993f, 0.00533976f, 
    0.01397775f, -0.04541297f, -0.00583159f, 0.01076925f, -0.01070739f, 0.00460935f, 0.02002745f, -0.02972565f, 
    -0.04147050f, -0.03949018f, 0.01113593f, -0.02927236f, -0.04374211f, 0.00083433f, 0.00878728f, 0.00308464f, 
    -0.00617602f, -0.02187300f, -0.03819616f, 0.02351605f, -0.02221277f, -0.01841317f, -0.00381952f, -0.02269474f, 
    0.00455079f, -0.01343579f, -0.04330419f, 0.00788124f, 0.01615520f, 0.00398669f, -0.03434214f, 0.00759112f, 
    0.00978268f, 0.01394647f, 0.02021577f, -0.00456254f, 0.01761856f, -0.00732324f, 0.01198298f, 0.01798204f, 
    0.00714862f, 0.01552084f, -0.01417505f, -0.04347046f, -0.02450299f, 0.00556829f, 0.02090834f, -0.03830024f, 
    -0.03716938f, 0.02041651f, -0.02311271f, -0.02089972f, 0.02487935f, 0.02272941f, -0.03526893f, -0.01774699f, 
    -0.04133075f, -0.04637512f, -0.04104654f, -0.01025880f, -0.02743665f, -0.02081849f, -0.01998121f, -0.02142451f, 
    0.03101716f, -0.04620446f, -0.01485441f, -0.00451072f, -0.01073493f, 0.01274246f, -0.00072531f, -0.00420582f, 
    -0.01969286f, -0.01604936f, 0.00835567f, -0.02681101f, 0.00471840f, 0.00844816f, -0.03148871f, 0.01057294f, 
    0.02717024f, -0.03702870f, -0.01938931f, -0.02267087f, 0.00630922f, 0.03065947f, -0.03549134f, -0.02448050f, 
    -0.03515561f, -0.02691270f, -0.04453252f, 0.00889425f, -0.03134294f, 0.02556321f, 0.01736072f, -0.04037333f, 
    -0.01728767f, -0.02955466f, -0.04268259f, 0.01984524f, -0.04660657f, -0.03861256f, 0.02453391f, -0.04569001f, 
    -0.03938178f, 0.02765924f, -0.04584584f, -0.01040656f, 0.02267685f, 0.02857126f, -0.04203252f, -0.01174224f, 
    -0.00518600f, -0.04334068f, -0.04673319f, -0.00308209f, -0.01100112f, 0.01407987f, 0.01497378f, -0.03704388f, 
    -0.01668266f, 0.01039326f, 0.02588123f, -0.03503506f, 0.00269248f, -0.04345179f, 0.03794764f, -0.02564537f, 
    -0.01338885f, 0.03049138f, 0.01000652f, 0.03282471f, -0.00086090f, 0.03154492f, 0.01200553f, -0.03298309f, 
    -0.01934710f, -0.00474515f, -0.01928960f, -0.04575641f, -0.00199099f, -0.03010995f, -0.03709053f, -0.03375629f, 
    0.00116286f, -0.02277735f, -0.02939751f, -0.02999443f, 0.00894689f, -0.01276868f, -0.02498818f, -0.03947914f, 
    0.01933348f, 0.02747127f, 0.03089484f, -0.00554045f, 0.01437078f, 0.01436370f, -0.03513330f, 0.01059316f, 
    -0.01327507f, 0.00950783f, 0.01210713f, 0.00074052f, -0.03234175f, 0.00822604f, 0.00432214f, -0.04033273f, 
    -0.01211501f, 0.02040967f, -0.04178021f, 0.03130909f, 0.00093117f, -0.02032632f, -0.01331217f, -0.04636887f, 
    0.03660915f, -0.04377223f, 0.00734749f, -0.04183508f, -0.03229109f, -0.02075983f, -0.01787441f, -0.01604270f, 
    -0.02842635f, -0.04419567f, -0.03064536f, 0.02369288f, -0.02508159f, -0.04424248f, -0.00207448f, 0.01533540f, 
    0.03041553f, -0.01372458f, 0.00968091f, -0.01139528f, 0.02564297f, 0.02721580f, 0.02513005f, -0.03765569f, 
    -0.03054829f, -0.03935015f, 0.00133557f, 0.00476765f, -0.00497718f, -0.02325795f, 0.01934192f, 0.02332363f, 
    0.01574780f, 0.02470073f, -0.04199215f, 0.00952255f, -0.00811047f, 0.00999421f, -0.03541159f, 0.01434546f, 
    -0.00203543f, -0.02901944f, -0.02913760f, 0.03107243f, -0.00409532f, -0.03293573f, -0.04366422f, 0.00951730f, 
    -0.04601629f, 0.00931999f, -0.00121658f, 0.01537296f, 0.00256336f, -0.02947336f, -0.01808242f, 0.02534225f, 
    0.01265953f, -0.02004242f, 0.03147986f, 0.01515260f, 0.03162774f, 0.02757789f, 0.02362698f, -0.03023527f, 
    0.01510921f, 0.01308198f, 0.01538830f, 0.02671842f, 0.01404943f, -0.02254763f, -0.01157140f, -0.03756932f, 
    0.01698085f, 0.00963641f, -0.00557828f, 0.00961786f, 0.02728156f, -0.04667994f, 0.00235706f, 0.01652050f, 
    -0.00094225f, -0.02411111f, -0.04638803f, 0.00361571f, -0.04454648f, 0.00557161f, -0.02569149f, -0.00647856f, 
    -0.01775724f, 0.01343616f, -0.00861711f, 0.01506989f, -0.01814871f, 0.02211909f, 0.03095269f, 0.00710640f, 
    0.01804113f, 0.03168167f, 0.00327538f, -0.01592032f, -0.04691416f, -0.02428770f, -0.03726925f, -0.03661009f, 
    0.02813662f, -0.03491054f, 0.02931687f, -0.00953660f, -0.03484662f, -0.03967839f, -0.02718261f, 0.02504448f, 
    -0.04043285f, 0.02281380f, 0.00742985f, 0.02356326f, 0.03201650f, 0.02956458f, -0.02540957f, -0.02672284f, 
    -0.04136411f, 0.02891874f, -0.03181217f, -0.00657736f, -0.02262539f, -0.04113211f, -0.03606642f, 0.01613065f, 
    0.02388802f, -0.02890368f, -0.02697384f, 0.02640008f, 0.02810168f, 0.02528174f, -0.01531416f, -0.03885798f, 
    0.00854373f, -0.00773589f, 0.00941223f, 0.03082209f, -0.04006880f, -0.02708661f, 0.02190290f, -0.03229698f, 
    -0.00833989f, -0.03136298f, 0.01826309f, -0.00877929f, -0.03863516f, -0.02070195f, -0.01387083f, -0.00761708f, 
    -0.02022411f, -0.03629955f, -0.02403468f, -0.04454799f, -0.02252329f, -0.01534173f, -0.03049735f, -0.00917435f, 
    -0.00685207f, -0.04040416f, 0.01264198f, 0.02508752f, -0.02735865f, -0.01976026f, -0.02519287f, -0.01537878f, 
    -0.03761162f, 0.02785780f, -0.03928769f, 0.00424901f, -0.04284808f, 0.02276583f, -0.03150973f, -0.04494924f, 
    0.00033881f, -0.01661296f, -0.00916677f, 0.01671923f, -0.03030686f, -0.02901373f, -0.04387327f, -0.02400205f, 
    -0.03918339f, -0.04640016f, -0.03036370f, -0.02606958f, -0.03448129f, -0.01696727f, -0.02185417f, -0.04665922f, 
    -0.04148065f, 0.01401160f, -0.02564252f, 0.00711814f, 0.00486828f, -0.04040235f, -0.01829669f, 0.02316550f, 
    0.01700934f, 0.03162361f, -0.01923369f, 0.03050458f, 0.00636848f, -0.02348908f, 0.01690141f, -0.04326740f, 
    0.00203473f, -0.01686964f, 0.02578588f, 0.00216794f, 0.00444688f, -0.02998165f, 0.01295967f, 0.03055924f, 
    0.02825795f, 0.01098749f, -0.01756173f, -0.00947623f, -0.03143617f, -0.01863882f, 0.01896906f, -0.01141725f, 
    0.00335217f, -0.00746168f, -0.01883018f, 0.02290841f, 0.00606303f, 0.02731369f, 0.01139046f, -0.02397059f, 
    0.02662135f, 0.02002149f, -0.04271257f, -0.02530063f, -0.04142047f, -0.01027477f, -0.01784209f, -0.04178457f, 
    0.02326529f, 0.00341677f, -0.00042597f, 0.00279490f, -0.04062904f, -0.02368844f, 0.00175140f, -0.00617280f, 
    0.01388396f, -0.01515246f, -0.03282876f, 0.00004371f, -0.02074629f, -0.03190602f, -0.04579390f, -0.02596291f, 
    -0.03575315f, 0.00942563f, -0.01010498f, 0.00856294f, -0.03559030f, 0.00636741f, -0.01000315f, -0.02706196f, 
    -0.00348868f, -0.04266500f, -0.03802933f, 0.00253043f, -0.03937491f, 0.02420406f, -0.02297647f, 0.02179090f, 
    -0.00693279f, 0.03377318f, 0.00011882f, -0.02731147f, -0.03077287f, -0.04651115f, -0.00794199f, 0.02353483f, 
    -0.00535977f, -0.03849033f, 0.02991596f, -0.04487721f, -0.00798318f, 0.01684203f, 0.00604812f, 0.00421899f, 
    -0.04371264f, -0.02388181f, -0.04301521f, 0.01593158f, -0.03154837f, -0.00123604f, 0.00325097f, -0.03653094f, 
    -0.02824851f, -0.01915579f, 0.02398076f, 0.00778805f, 0.00449995f, -0.01724966f, 0.01847959f, 0.02216181f, 
    -0.03122670f, 0.02128236f, -0.03592086f, -0.01560996f, 0.02989814f, 0.01252548f, 0.02092396f, 0.03017539f, 
    -0.00949374f, -0.02283204f, 0.00570585f, 0.00413834f, -0.00356976f, 0.01471542f, 0.00849245f, -0.01653692f, 
    0.00402960f, 0.00632406f, 0.00536585f, -0.03868718f, 0.01734880f, 0.01777406f, -0.01997914f, -0.01621710f, 
    -0.00942054f, -0.01403345f, -0.03374223f, -0.03223352f, -0.02393701f, 0.02973346f, 0.01930959f, 0.02368172f, 
    -0.01833928f, -0.02257252f, 0.03288941f, 0.02313988f, -0.01009674f, 0.00077178f, 0.01506725f, -0.02025908f, 
    -0.02925038f, -0.02602063f, 0.02996710f, -0.02792599f, -0.03672567f, -0.00467846f, -0.01852574f, 0.00623637f, 
    0.01696416f, -0.01579528f, 0.02445483f, -0.01194417f, 0.00633230f, -0.02552067f, 0.01169906f, -0.03990873f, 
    0.02192836f, -0.00653810f, 0.00319625f, 0.00016073f, -0.02969419f, -0.03968932f, -0.01468896f, -0.03638898f, 
    -0.02061110f, 0.02050568f, -0.00686490f, -0.02589938f, 0.02159200f, 0.04118744f, 0.01345318f, -0.01539422f, 
    -0.01850167f, -0.02576718f, -0.04032240f, -0.02902735f, 0.03194967f, -0.01861406f, -0.01010858f, 0.02652739f, 
    -0.03074655f, -0.02383200f, 0.02893265f, 0.02360704f, 0.02525688f, -0.00209101f, -0.02172623f, -0.00712440f, 
    0.02977000f, -0.02251932f, -0.02886458f, 0.03204564f, 0.00267255f, -0.01185253f, -0.00611446f, -0.01849761f, 
    0.03155773f, 0.00950199f, -0.02024481f, 0.02406887f, -0.00912976f, -0.00748256f, 0.01101774f, 0.01646251f, 
    0.00170830f, -0.03390004f, -0.02106907f, 0.00570168f, -0.01788880f, -0.02153463f, -0.02740115f, -0.00420244f, 
    0.02626246f, 0.01003248f, 0.01902599f, 0.02745072f, -0.04058143f, 0.00232580f, -0.01554534f, -0.02627908f, 
    -0.01962717f, 0.02006633f, -0.02834844f, -0.02720161f, 0.01370731f, -0.02120623f, -0.02024890f, 0.00962527f, 
    -0.04061526f, 0.01662608f, 0.02632005f, -0.03997113f, 0.01189551f, -0.00784093f, -0.02135109f, -0.01860696f, 
    -0.00599852f, -0.02528765f, 0.03341620f, -0.01214174f, 0.01533683f, -0.02479877f, -0.00235943f, 0.00634773f, 
    0.00611035f, 0.02156995f, -0.01743393f, -0.02206191f, -0.02894351f, 0.01585927f, 0.02988500f, -0.01128100f, 
    0.01135211f, -0.02160051f, 0.02698736f, -0.01541015f, -0.01943530f, -0.01851798f, 0.02786685f, 0.00280622f, 
    0.00195994f, -0.02756855f, -0.00813714f, 0.03145330f, -0.01361443f, 0.03541102f, -0.02483183f, 0.00626205f, 
    -0.00473625f, 0.01583544f, -0.02257670f, 0.03456477f, 0.00574935f, -0.03135380f, -0.03427649f, -0.01073722f, 
    -0.02699962f, 0.01170345f, 0.02328736f, -0.03151106f, -0.01634233f, 0.03148182f, -0.00891306f, -0.00556111f, 
    -0.02085618f, -0.00442798f, -0.03007947f, -0.02380111f, -0.03530135f, -0.02469123f, 0.01534053f, -0.03183861f, 
    -0.00904058f, -0.00377462f, -0.02060653f, 0.04102685f, 0.02438134f, -0.01483884f, -0.02975250f, -0.02503125f, 
    -0.00506708f, -0.03121391f, 0.00922980f, 0.01716267f, -0.03710706f, -0.02247945f, 0.02401791f, -0.02922310f, 
    -0.00335641f, -0.00249371f, 0.04710741f, 0.01928769f, -0.02273259f, 0.00739590f, 0.01424039f, 0.03678754f, 
    0.02679624f, -0.03606255f, 0.03380797f, -0.01858328f, -0.04385900f, 0.03104793f, 0.00542786f, -0.03742002f, 
    -0.04146305f, 0.02935449f, 0.01347409f, -0.04017960f, -0.04364273f, -0.01090997f, 0.00360953f, 0.03036253f, 
    -0.02706625f, 0.03231813f, -0.03496986f, 0.02935779f, -0.00242298f, -0.03850916f, 0.02955539f, 0.02698969f, 
    0.00624763f, 0.02002730f, 0.03002587f, -0.04339474f, 0.01069208f, -0.01634900f, 0.03194769f, 0.02196988f, 
    0.01387444f, -0.01005731f, 0.00168275f, -0.03165755f, 0.02102584f, 0.03089182f, -0.01608174f, -0.00029292f, 
    -0.01136885f, 0.00355701f, 0.00221266f, 0.00875935f, -0.01034093f, -0.02024649f, -0.02153111f, -0.03525247f, 
    -0.02765272f, 0.01276774f, -0.04134997f, -0.01708409f, -0.00577936f, -0.04429279f, -0.02206403f, 0.01226998f, 
    -0.02655373f, -0.03460431f, 0.00955996f, -0.01346010f, 0.00334907f, 0.01683402f, 0.02879909f, 0.02808882f, 
    -0.04271640f, 0.00085992f, -0.03261723f, 0.00377957f, 0.00076295f, 0.01647546f, -0.01117842f, -0.00113601f, 
    -0.01354747f, 0.01366897f, 0.00698482f, -0.01095934f, 0.01862721f, 0.00824514f, -0.03798388f, -0.01650241f, 
    0.00176218f, -0.03646095f, 0.00267745f, -0.03440469f, 0.01043483f, -0.01576345f, 0.00393758f, 0.03007161f, 
    -0.00152462f, -0.03226970f, 0.00597507f, 0.02894638f, -0.00571796f, 0.01280457f, 0.01511467f, -0.00533644f, 
    -0.00947489f, -0.00475549f, -0.03921852f, 0.01292676f, 0.01460847f, 0.02287394f, -0.01074020f, -0.04126188f, 
    -0.02056776f, 0.03234519f, -0.02280707f, -0.04004426f, 0.02603081f, 0.00139029f, -0.03010079f, -0.00557706f, 
    0.00136320f, 0.01144357f, 0.02721477f, -0.00255322f, 0.00027208f, -0.02758118f, 0.01488642f, -0.02639410f, 
    0.02503054f, 0.01242728f, 0.02763598f, 0.02794968f, 0.03440854f, 0.00853478f, -0.01335838f, 0.03530627f, 
    0.02198697f, -0.02142078f, 0.02875553f, -0.01599066f, 0.00591928f, 0.01730319f, 0.01980579f, -0.03359335f, 
    -0.02146428f, -0.04402958f, -0.00433460f, -0.02821595f, 0.00423767f, 0.03368930f, -0.00330467f, 0.00484190f, 
    0.02270896f, 0.03848796f, -0.01470883f, 0.02751196f, -0.00888968f, 0.00143782f, -0.00698568f, 0.02767357f, 
    -0.03711445f, -0.01548621f, -0.02410879f, 0.00444281f, 0.01824236f, -0.03128543f, 0.02856988f, -0.00996920f, 
    -0.03185887f, -0.00400529f, -0.02022139f, 0.03546112f, 0.01040469f, 0.00001945f, -0.01092712f, -0.01457077f, 
    0.02488093f, -0.02339226f, -0.00115989f, -0.02913098f, -0.03247909f, -0.03713747f, 0.02159998f, 0.00735550f, 
    0.01839498f, 0.02187461f, -0.00211695f, 0.03453959f, -0.04130211f, -0.00187335f, -0.04599512f, -0.03382424f, 
    0.02592243f, 0.00881743f, -0.01830604f, -0.00208643f, -0.03776594f, -0.04024823f, -0.02479669f, -0.04132433f, 
    0.00085418f, -0.04266610f, 0.00642376f, 0.00138386f, -0.03865700f, -0.04058845f, -0.02629209f, -0.00127550f, 
    0.02998228f, 0.00810482f, 0.00225957f, -0.04074657f, 0.01012730f, 0.01130555f, 0.00744353f, 0.03095250f, 
    0.01421841f, -0.03875246f, 0.02030031f, -0.02023783f, -0.03228404f, 0.00185724f, 0.01652403f, 0.03520481f, 
    -0.03752137f, 0.00933170f, -0.02664262f, -0.02668737f, -0.02213637f, -0.03203334f, -0.02714780f, 0.01861300f, 
    0.00014914f, -0.00516343f, 0.02518851f, -0.00924983f, -0.02271669f, -0.00564589f, -0.00747270f, 0.02508780f, 
    0.00750315f, 0.02462503f, 0.00997388f, -0.01895609f, 0.01021031f, -0.02110223f, 0.03387747f, -0.00094867f, 
    -0.01446231f, -0.01231576f, 0.01601007f, -0.01744078f, -0.03385086f, -0.01205513f, -0.04456454f, 0.01907083f, 
    0.00436808f, 0.01167352f, 0.01956261f, 0.01676862f, 0.02753904f, 0.03040367f, -0.03836123f, 0.03183349f, 
    0.01731825f, -0.01625071f, 0.00053117f, 0.00313984f, -0.03277437f, 0.02178101f, 0.03202324f, 0.00388047f, 
    -0.03512139f, -0.01095704f, -0.02988665f, 0.01088005f, 0.01568110f, -0.03826124f, -0.01667292f, 0.02367484f, 
    -0.03416024f, 0.03321778f, 0.01637957f, 0.01288407f, -0.02731736f, 0.00089572f, -0.00709173f, 0.02807094f, 
    -0.02261408f, -0.01553780f, 0.01950146f, -0.01143299f, -0.00934826f, -0.00117811f, -0.03501371f, -0.03596281f, 
    -0.00499607f, -0.00976778f, 0.01813383f, -0.00195717f, 0.00556725f, -0.01209793f, -0.03186521f, 0.01213876f, 
    -0.00240561f, 0.02307303f, 0.01689893f, -0.01242538f, 0.01106121f, 0.00529602f, -0.01901548f, 0.01373451f, 
    -0.03190005f, 0.00304173f, 0.01895945f, 0.02394937f, 0.00300814f, 0.03060106f, -0.02654882f, 0.02616864f, 
    -0.00107525f, 0.01488104f, -0.02318416f, -0.04050356f, -0.02178440f, -0.03332000f, 0.02494265f, -0.02585026f, 
    0.01017494f, 0.00821853f, -0.03566446f, -0.01382950f, 0.00083890f, -0.01995790f, -0.01258513f, 0.02076857f, 
    0.03014610f, 0.00448454f, 0.01814889f, -0.02674498f, -0.02778379f, -0.00618080f, -0.03928029f, -0.00564067f, 
    -0.02234523f, 0.00090017f, -0.02869541f, -0.02383258f, -0.02128904f, -0.00355682f, 0.02462750f, 0.00617620f, 
    -0.04393485f, 0.02558372f, 0.01291731f, -0.03005837f, 0.01649488f, -0.01231748f, 0.03191506f, 0.01712852f, 
    -0.04074223f, -0.03001040f, 0.02385585f, 0.01380974f, -0.01492961f, -0.01769481f, -0.00231270f, -0.00559737f, 
    0.03533504f, -0.01518357f, 0.02314646f, -0.00043149f, -0.02067987f, -0.03443803f, 0.00919763f, 0.03139612f, 
    0.03080079f, 0.02024008f, 0.00931173f, -0.04001628f, -0.01572662f, -0.04177540f, 0.01293909f, 0.01369785f, 
    0.02178882f, -0.02288008f, -0.02768376f, -0.01091936f, -0.03953803f, 0.01464508f, 0.00818114f, -0.03734674f, 
    -0.03698039f, -0.00723885f, -0.03445527f, -0.03760685f, -0.01999371f, -0.03746039f, -0.03004880f, 0.00894515f, 
    -0.02583895f, 0.02055256f, -0.00037817f, 0.01403749f, 0.00807225f, -0.03929156f, 0.00530544f, 0.00181360f, 
    -0.00516391f, -0.02958342f, -0.03804850f, -0.02140972f, -0.02252819f, 0.02965943f, -0.00618477f, 0.01482844f, 
    0.00567645f, 0.00561643f, 0.01594635f, 0.00265605f, 0.00097667f, -0.00429503f, -0.02155495f, 0.01310729f, 
    -0.02372706f, 0.03363091f, -0.03576224f, 0.01237354f, -0.03363294f, 0.00434720f, -0.02961709f, -0.00437400f, 
    0.25259614f, -0.08906557f, 0.17354317f, -0.07655561f, -0.10789251f, -0.22037904f, -0.05161922f, -0.02767828f, 
    -0.06457225f, 0.05116846f, 0.06506982f, 0.07590823f, 0.10190973f, -0.07988802f, 0.07654669f, 0.15937082f, 
    -0.05133948f, 0.02529142f, 0.05002582f, 0.04193041f, 0.27514693f, -0.07053407f, -0.10377926f, -0.09221437f, 
    0.06360245f, 0.09517767f, 0.10765427f, 0.12326292f, -0.01556883f, 0.13758320f, -0.02775392f, 0.07264294f, 
    -0.05560636f, 0.06308360f, 0.01989695f, -0.04392563f, 0.02214371f, -0.02251747f, -0.04980779f, 0.00467026f, 
    -0.23973064f, -0.12297885f, 0.06766920f, -0.11045346f, 0.09764680f, 0.29308969f, 0.06231919f, 0.14238712f, 
    -0.00173562f, -0.00116360f, 0.11310256f, -0.00213642f, 0.09683647f, -0.02777827f, 0.01263946f, 0.16379447f, 
    -0.04178807f, 0.10774283f, 0.04723601f, 0.07129234f, 0.25382173f, -0.41419819f, 0.18137495f, 0.01623635f, 
    0.10135482f, 0.14404072f, 0.01175735f, 0.10371897f, 0.02810962f, -0.01612422f, -0.05998396f, 0.01798258f, 
    0.00443748f, -0.04084792f, -0.03853391f, 0.18085113f, -0.06828386f, 0.16226304f, 0.00127131f, 0.04654079f, 
    0.00193022f, -0.24982740f, 0.06823979f, -0.17589164f, -0.15008441f, 0.19683394f, -0.04831080f, -0.05940331f, 
    0.05355853f, 0.07782052f, -0.02204174f, 0.04406454f, 0.01170335f, 0.01193638f, 0.03980368f, -0.01567333f, 
    0.03678521f, -0.10486619f, -0.04156454f, 0.04057966f, 0.19627495f, -0.03527086f, -0.24032666f, 0.02173833f, 
    0.04667674f, -0.06000105f, -0.14090613f, 0.08382113f, 0.14477654f, 0.00319362f, 0.05078305f, -0.01489598f, 
    -0.05499532f, 0.00511975f, -0.05095971f, 0.14158311f, 0.06966701f, 0.06883568f, 0.03142849f, 0.07528309f, 
    0.00755907f, 0.08202703f, -0.11100329f, 0.12158296f, 0.17063761f, 0.02214623f, 0.00721072f, 0.09459634f, 
    0.08160031f, 0.02772631f, -0.00443697f, -0.01490874f, 0.09018851f, 0.08856594f, 0.09126730f, 0.04659025f, 
    -0.04669175f, -0.05832724f, -0.06768491f, 0.02506893f, 0.12652084f, 0.13714533f, -0.32879806f, 0.05053955f, 
    0.01770696f, 0.04029068f, -0.00643916f, -0.11092924f, 0.04492760f, 0.02889472f, 0.04709485f, -0.00895062f, 
    0.03967441f, -0.02159347f, 0.07032526f, 0.02414684f, -0.00476473f, -0.01373560f, -0.07648809f, 0.05465586f, 
    -0.09167334f, 0.08586050f, 0.17556167f, 0.32269424f, 0.07770531f, 0.08861768f, -0.14802933f, 0.20976463f, 
    -0.05659690f, 0.05604295f, 0.05220225f, 0.01775967f, 0.12810130f, 0.07026221f, 0.01397380f, -0.07094727f, 
    -0.02993898f, 0.17057905f, -0.08528135f, 0.03157283f, -0.01870076f, -0.21269627f, -0.12258870f, -0.19013098f, 
    -0.05872878f, 0.14480917f, 0.10633530f, 0.13911086f, 0.01613554f, 0.12568644f, 0.04866294f, 0.00665841f, 
    0.01747595f, 0.04180811f, 0.10395726f, -0.04486705f, -0.06520633f, -0.06997517f, -0.06026201f, 0.00208381f, 
    0.04283188f, 0.08298114f, 0.18319760f, -0.19542152f, -0.07084131f, -0.01323054f, 0.11223179f, -0.11905661f, 
    -0.04447072f, 0.05752203f, -0.02582623f, 0.04234840f, 0.02304597f, 0.02641714f, 0.01318981f, -0.03708001f, 
    0.07450081f, -0.07905366f, 0.02851527f, -0.00322997f, -0.08799225f, 0.06602792f, 0.15560244f, -0.12046485f, 
    -0.24524611f, 0.14170754f, -0.10302828f, 0.08876058f, 0.03051587f, 0.06478434f, -0.12955424f, 0.05836055f, 
    -0.02678506f, 0.00547620f, -0.04144898f, -0.01438725f, -0.14273651f, 0.12322487f, -0.17349453f, 0.02420074f, 
    -0.30171150f, -0.25397962f, -0.10983590f, 0.26313257f, -0.28771439f, 0.10959807f, -0.12724401f, 0.16852494f, 
    0.07251907f, -0.10593694f, 0.04661355f, 0.09946179f, 0.04872146f, -0.02426838f, 0.15843734f, 0.04677761f, 
    0.07032517f, 0.04980930f, 0.05275508f, -0.02158448f, 0.11817297f, 0.03257349f, -0.27151868f, 0.20892282f, 
    -0.02750688f, -0.01214523f, 0.05770965f, 0.01490436f, 0.08009662f, 0.00340479f, 0.06634876f, 0.10287956f, 
    0.01284994f, -0.01744607f, 0.10056307f, 0.00405850f, -0.04654065f, -0.04485802f, -0.06047306f, 0.03908830f, 
    0.29897696f, -0.19183028f, 0.13179587f, 0.15351847f, -0.11028283f, -0.10567734f, 0.00186590f, -0.05776332f, 
    -0.02568577f, -0.13644628f, -0.03434568f, -0.04184154f, 0.02552278f, 0.02944710f, -0.07062356f, -0.08868045f, 
    -0.04484449f, -0.03572401f, -0.03851430f, -0.06715316f, 0.30983061f, -0.40326586f, 0.02339631f, 0.04963371f, 
    -0.08920898f, -0.15466624f, 0.11327349f, -0.07275373f, -0.11882068f, -0.06281618f, 0.12079751f, 0.06717081f, 
    0.01405318f, 0.05276355f, 0.05161852f, 0.01641705f, 0.03241972f, 0.18563649f, -0.05521424f, -0.08199422f, 
    -0.23320936f, 0.04931712f, 0.10589129f, 0.11771822f, -0.03393938f, 0.02517992f, 0.08748365f, 0.15184280f, 
    -0.05882588f, -0.06783456f, 0.02425977f, 0.13975693f, 0.04669254f, 0.01095509f, -0.00464558f, -0.02696215f, 
    0.19348109f, 0.13122819f, 0.05730285f, -0.09677363f, 0.00030048f, -0.13032146f, 0.07924558f, -0.29530740f, 
    -0.14412579f, 0.01155367f, -0.01072873f, -0.02377014f, 0.02226675f, 0.07837932f, 0.03831804f, 0.02542068f, 
    -0.05251541f, -0.12948647f, 0.18794018f, 0.07703031f, -0.00431771f, -0.00734225f, -0.06704431f, 0.06232283f, 
    0.20141751f, 0.21164054f, 0.31558424f, -0.24526289f, -0.17860538f, -0.04070641f, -0.02999709f, -0.02034323f, 
    -0.01111486f, 0.07147332f, 0.04166349f, 0.01439082f, 0.00352175f, -0.09851968f, 0.12789403f, 0.00133364f, 
    0.08618277f, 0.06128564f, -0.02077782f, 0.12051753f, -0.15274587f, -0.01613178f, 0.19849958f, -0.01221811f, 
    -0.27716959f, -0.01909138f, -0.10614947f, 0.00550199f, 0.03396636f, 0.09377369f, -0.05334728f, -0.00093754f, 
    0.05951844f, -0.06789348f, 0.11643391f, 0.00770631f, 0.04756972f, 0.11270245f, 0.04209977f, 0.05722363f, 
    -0.23211250f, 0.03587856f, -0.01658408f, -0.02567134f, -0.12634476f, 0.08565746f, 0.01948843f, 0.02517353f, 
    0.08288076f, 0.01113137f, 0.05211812f, 0.01780288f, -0.00011535f, -0.04813613f, 0.01659375f, -0.06566757f, 
    0.00085736f, -0.03878113f, -0.05857135f, 0.03219436f, 0.18329115f, -0.20501943f, 0.19069019f, 0.06274595f, 
    -0.13376352f, -0.03738791f, 0.05603789f, 0.09007536f, -0.00575889f, -0.09447842f, 0.21140970f, 0.07681321f, 
    -0.06123470f, -0.05667839f, 0.05210079f, 0.03170975f, -0.10823283f, -0.04248925f, 0.14087914f, 0.05594389f, 
    0.38471773f, -0.19996001f, 0.03853922f, 0.02919419f, 0.10690305f, 0.13962726f, 0.05967801f, 0.08544037f, 
    0.11620683f, -0.00026114f, 0.02249600f, -0.02188244f, 0.01462721f, 0.05114846f, 0.18094566f, -0.04831550f, 
    -0.01307854f, -0.02242135f, -0.11205139f, 0.01431432f, -0.23707505f, 0.27845407f, -0.11512939f, 0.00766235f, 
    -0.02548901f, 0.16888814f, -0.00520157f, -0.00813769f, 0.10802054f, 0.13245863f, 0.00453169f, 0.00960818f, 
    0.02754121f, -0.06560416f, -0.00229851f, -0.03572532f, 0.09650316f, 0.07836235f, -0.01797145f, 0.02679652f, 
    0.07550415f, 0.05234307f, 0.14219043f, -0.07456778f, -0.05568239f, -0.02668316f, 0.01032865f, -0.14406992f, 
    0.03927159f, 0.15709558f, 0.06617542f, 0.02178658f, -0.05647719f, 0.01595511f, 0.05237853f, -0.08579508f, 
    -0.09626203f, 0.05989305f, 0.08441310f, 0.09694790f, -0.01232410f, 0.01081106f, 0.08812860f, 0.04967029f, 
    0.10261907f, -0.05994727f, -0.10905544f, 0.01447193f, 0.03876156f, 0.02471881f, 0.01474180f, 0.01029416f, 
    -0.01725159f, 0.01835425f, 0.01756239f, -0.02237659f, 0.01783064f, 0.01741359f, 0.05321118f, -0.06706784f, 
    -0.04801665f, 0.15857996f, 0.31351939f, -0.19644715f, -0.20859501f, 0.06462084f, 0.05823445f, -0.07014766f, 
    0.01983313f, 0.07878771f, 0.08029976f, 0.03453889f, -0.10427961f, 0.02518069f, -0.06683503f, 0.04087432f, 
    0.05763015f, -0.03160491f, 0.03131995f, 0.09956730f, 0.05929025f, -0.30447623f, -0.12802415f, 0.04641618f, 
    0.11690570f, -0.10645395f, -0.03365361f, -0.00383299f, -0.08781913f, -0.03501325f, 0.06221059f, -0.16134860f, 
    -0.12482990f, 0.12153369f, -0.03198919f, -0.03295491f, -0.04691973f, -0.09423821f, 0.01283022f, 0.05757570f, 
    -0.07274379f, -0.14617103f, 0.01314971f, 0.14951873f, -0.22451428f, 0.08256139f, -0.10554676f, -0.07161745f, 
    0.03077997f, -0.03498502f, -0.02420674f, 0.00592128f, 0.01198811f, -0.03241695f, 0.13424149f, 0.00052827f, 
    0.04507343f, 0.04185272f, 0.02666793f, 0.03807837f, 0.09556443f, -0.07854753f, -0.27651671f, 0.16084489f, 
    -0.05622756f, 0.00899390f, 0.04464489f, 0.08262662f, 0.08935090f, -0.00409283f, 0.15828919f, 0.19121942f, 
    -0.09467679f, -0.02400088f, 0.00157567f, 0.00244707f, 0.03578533f, -0.07853366f, 0.04768161f, 0.04449943f, 
    -0.15069357f, 0.22380485f, -0.11529900f, -0.03787705f, 0.13692300f, 0.06193609f, 0.08479924f, -0.01349541f, 
    0.13461429f, -0.00931882f, 0.04123489f, 0.04060955f, -0.04448203f, -0.03536539f, 0.00602404f, -0.04475430f, 
    0.01605442f, 0.07284404f, 0.03939608f, -0.04189358f, -0.20961416f, 0.30521092f, 0.01768267f, 0.06955497f, 
    0.16244403f, 0.09260522f, -0.01156881f, 0.01423598f, 0.12650090f, 0.04183972f, 0.03979864f, -0.08499048f, 
    0.02225629f, 0.02253468f, -0.10300345f, -0.02109510f, -0.01803803f, 0.02135149f, 0.00948162f, -0.00545231f, 
    0.14082754f, -0.15107808f, 0.22548476f, 0.03520010f, -0.09456729f, 0.03075109f, -0.08222479f, 0.06122366f, 
    -0.03984123f, 0.02179754f, -0.08472862f, 0.05997400f, 0.02564158f, 0.05230519f, 0.16445082f, 0.07113713f, 
    -0.02952161f, -0.02604840f, 0.06857423f, -0.06086852f, 0.02621852f, -0.20502836f, -0.10632229f, 0.13518190f, 
    -0.18958201f, -0.00291713f, 0.00695428f, 0.00200366f, -0.00198168f, 0.04568005f, 0.03090488f, 0.06381453f, 
    -0.02247137f, 0.00728135f, -0.06713118f, -0.02215297f, 0.02971853f, 0.05871100f, -0.05415702f, -0.00427907f, 
    -0.18175155f, 0.52280855f, -0.16051568f, 0.26897401f, -0.19973417f, 0.12056224f, 0.21526639f, -0.08548362f, 
    -0.10103454f, -0.03045331f, 0.07350307f, -0.01994652f, 0.04431414f, 0.02253629f, 0.00607174f, -0.03848354f, 
    0.08991122f, 0.03244517f, -0.17057343f, -0.00436290f, -0.04151828f, -0.16485704f, -0.19832736f, 0.01330914f, 
    -0.01669776f, -0.01867520f, -0.00918011f, 0.09135140f, 0.06281080f, -0.09828006f, -0.07481290f, 0.01440625f, 
    -0.03020888f, -0.06466589f, -0.08194734f, -0.06685848f, -0.04024457f, 0.07971754f, 0.02722930f, -0.05367746f, 
    -0.05156967f, 0.07155699f, -0.04172985f, -0.13176872f, -0.18332697f, 0.03543717f, 0.01114095f, -0.00066765f, 
    0.04818358f, -0.03972878f, 0.07540339f, -0.03204042f, -0.03925172f, 0.11817259f, 0.04270994f, -0.00182162f, 
    -0.05690635f, -0.08569230f, -0.05466670f, -0.07063821f, 0.09538026f, 0.12657787f, 0.04895698f, -0.00168908f, 
    0.39305893f, 0.13586210f, -0.05803113f, 0.05032436f, -0.07713605f, 0.08110545f, -0.01007454f, 0.08980173f, 
    -0.06941873f, 0.07289743f, 0.00203752f, 0.07812193f, -0.03479014f, -0.01991239f, 0.04365362f, -0.00113074f, 
    0.16922560f, -0.12420595f, 0.12784539f, 0.15192090f, -0.11726294f, 0.04031928f, -0.07990649f, -0.03170256f, 
    0.10366549f, 0.06489679f, 0.00060475f, -0.00707414f, -0.08919343f, 0.02156168f, 0.02477420f, 0.00641678f, 
    0.17601794f, -0.08252735f, -0.07647004f, -0.13892210f, -0.18665873f, 0.14113180f, -0.06618415f, -0.11536305f, 
    0.26215079f, 0.13005541f, 0.01908106f, 0.05836312f, -0.10023376f, -0.03554996f, -0.00126223f, 0.05338839f, 
    0.02602953f, 0.01897720f, 0.05239034f, 0.00859995f, 0.09119953f, -0.00327771f, 0.04189901f, 0.03283357f, 
    -0.09458307f, -0.06064475f, -0.06904877f, -0.06462298f, 0.14930902f, -0.00325478f, 0.07610626f, -0.07247825f, 
    -0.04879799f, 0.02267802f, 0.01617282f, -0.02986292f, -0.00185979f, 0.10833809f, 0.02576076f, 0.01783493f, 
    0.03361066f, 0.15951407f, -0.00617056f, -0.01617815f, -0.12347057f, 0.11581694f, -0.10469022f, 0.06035519f, 
    -0.25292844f, 0.06856010f, 0.16108657f, -0.01685481f, 0.03338450f, 0.06640276f, 0.10200598f, 0.05236886f, 
    0.04670393f, -0.08267070f, 0.01039572f, 0.11628668f, 0.00656949f, -0.05807667f, 0.10723967f, -0.07856313f, 
    0.08074962f, 0.17603597f, -0.15760151f, 0.21479584f, -0.22491778f, -0.04791352f, 0.04956667f, -0.01698777f, 
    0.02746543f, 0.00327061f, 0.03447750f, -0.00771003f, -0.04419495f, -0.01221840f, 0.01483572f, 0.03019097f, 
    -0.06929373f, 0.11169952f, -0.03230419f, 0.05893553f, 0.12082735f, 0.22616558f, -0.24497251f, -0.01742412f, 
    0.29838654f, 0.10355312f, 0.03585944f, -0.01127475f, 0.04795757f, 0.02329139f, -0.10978364f, -0.02306390f, 
    0.04098057f, 0.09384455f, -0.01188392f, -0.00616352f, -0.00632984f, -0.02501291f, -0.17213243f, 0.01267454f, 
    -0.06316600f, 0.38694572f, -0.36114308f, 0.01473751f, 0.09204001f, -0.04037258f, -0.07553068f, 0.00997699f, 
    -0.03236236f, -0.08081902f, -0.00307650f, -0.00655210f, -0.03592012f, 0.04793712f, 0.01719712f, 0.13195150f, 
    0.10942893f, 0.10569659f, 0.03157400f, 0.07658731f, 0.09081704f, 0.17843208f, 0.04476294f, -0.00619165f, 
    0.12845531f, -0.01012557f, 0.04322691f, -0.02953080f, -0.00522278f, 0.06444189f, 0.09149549f, 0.06438420f, 
    0.04885526f, -0.01227421f, 0.03880434f, 0.08195455f, -0.04799625f, 0.05994860f, 0.05520548f, 0.10592255f, 
    -0.29684412f, -0.03062292f, 0.11701136f, 0.04525544f, 0.08785749f, -0.00289397f, 0.08445469f, 0.09433054f, 
    0.01405246f, -0.09898493f, -0.10228005f, -0.05205060f, 0.19130251f, 0.15334010f, 0.00870712f, 0.04595923f, 
    -0.00644824f, 0.04328899f, 0.01511120f, 0.11347661f, -0.28921527f, -0.00789633f, 0.26638243f, 0.07606108f, 
    -0.02474582f, -0.10144337f, 0.11058977f, 0.04584916f, -0.00988702f, -0.05647077f, -0.04704224f, 0.10780463f, 
    0.01614947f, 0.09042799f, -0.15538752f, -0.06432671f, 0.13480639f, 0.05292629f, 0.05688623f, 0.19882381f, 
    -0.17720483f, 0.26411593f, -0.11946505f, 0.35415259f, -0.27040917f, 0.04341781f, 0.15964209f, -0.01031555f, 
    -0.02720183f, -0.01356226f, -0.02605721f, -0.06379900f, -0.00859803f, 0.03278864f, -0.02198477f, 0.01156652f, 
    0.14416806f, -0.00796836f, 0.00347339f, 0.09073716f, -0.06738798f, -0.08452347f, 0.16442326f, 0.28654477f, 
    -0.55368567f, 0.06705117f, 0.02933578f, 0.00662029f, 0.02263362f, 0.01952538f, 0.07971928f, 0.10204805f, 
    0.01980307f, 0.02198440f, 0.02223806f, 0.04437784f, -0.03065792f, -0.07579903f, 0.02523150f, 0.02675353f, 
    -0.05239820f, -0.08000899f, 0.17263705f, 0.07464983f, -0.20247760f, 0.09573787f, 0.12311160f, -0.04646375f, 
    -0.08803241f, 0.00666569f, 0.13243231f, 0.02701643f, 0.02802553f, -0.09496193f, 0.05440409f, -0.05025915f, 
    -0.10599448f, -0.06386045f, 0.05145427f, 0.07661982f, -0.19357389f, 0.19553894f, 0.01483124f, -0.04473777f, 
    0.14915361f, 0.10434644f, -0.05399624f, 0.01584229f, -0.10709553f, 0.01574659f, -0.00236488f, -0.07022233f, 
    0.06195825f, 0.09166899f, 0.10889967f, 0.04884780f, 0.12056235f, 0.01766874f, -0.02370291f, 0.01247901f, 
    -0.04028382f, -0.11149462f, 0.05410096f, -0.14271222f, 0.21368591f, 0.06106053f, 0.04333634f, -0.08459616f, 
    0.04904537f, 0.01446336f, -0.05669708f, -0.03581997f, 0.04770759f, 0.14748436f, 0.14657271f, 0.12514648f, 
    -0.01269455f, -0.11280379f, -0.00517864f, -0.08792275f, -0.06959806f, 0.20894836f, -0.29148313f, -0.03679660f, 
    0.18639879f, -0.04554220f, -0.06105611f, -0.00883703f, -0.03789866f, 0.05108970f, 0.10695920f, -0.04809721f, 
    -0.08563967f, 0.01948228f, 0.05598447f, -0.07058604f, -0.10512174f, 0.12335432f, 0.02543255f, 0.14592586f, 
    -0.27565622f, -0.25079313f, 0.02460375f, 0.18599060f, -0.11396181f, -0.11750156f, -0.06035779f, 0.04504857f, 
    0.00900602f, 0.00702695f, -0.05896672f, 0.02148486f, 0.00322836f, 0.02227944f, -0.08729126f, 0.00598661f, 
    0.03654771f, -0.05279477f, -0.02770504f, 0.07083138f, -0.38188806f, 0.05005759f, 0.03412993f, -0.05220101f, 
    0.11839737f, 0.11538304f, -0.00184463f, 0.06311671f, 0.01293930f, -0.03180642f, -0.01432845f, -0.04519018f, 
    0.04643442f, 0.01685016f, -0.03869284f, -0.06930146f, 0.07263241f, -0.00947923f, 0.07490440f, -0.01131824f, 
    -0.10359856f, -0.03944402f, 0.24642143f, 0.08948908f, 0.04463687f, 0.05800042f, 0.07146562f, 0.01177150f, 
    -0.03930540f, 0.07522622f, 0.01874858f, -0.02519693f, 0.02057953f, 0.06150140f, 0.00148469f, -0.00525318f, 
    -0.09162340f, -0.06651948f, 0.00734215f, -0.00889483f, -0.10723630f, 0.07188140f, 0.01724829f, -0.07125673f, 
    0.09488095f, 0.00395269f, 0.10790584f, 0.03781904f, -0.01244638f, -0.08985662f, 0.06981329f, 0.06640942f, 
    -0.02641212f, -0.00814158f, 0.00243151f, 0.11924764f, -0.06686374f, -0.03746657f, 0.03897605f, -0.06563765f, 
    0.01357128f, 0.08478288f, 0.08541900f, -0.01346492f, -0.17014554f, -0.00330002f, 0.07381095f, 0.04616946f, 
    0.07940198f, 0.00442058f, -0.00671168f, 0.11169063f, 0.03637776f, -0.10771650f, -0.00306233f, -0.07405438f, 
    0.05546620f, 0.02148881f, 0.04732278f, -0.01463476f, 0.14544715f, 0.01678024f, 0.02347824f, -0.08431610f, 
    0.25849959f, -0.19304967f, 0.04347449f, 0.07005098f, 0.01872218f, -0.01257991f, 0.06642737f, -0.07254171f, 
    0.10229082f, 0.06824511f, -0.03494463f, 0.03218535f, 0.03467621f, 0.10725012f, 0.04352775f, 0.13584824f, 
    0.02855459f, 0.17280160f, -0.06338545f, -0.07706269f, 0.22687644f, -0.02733097f, -0.11278217f, 0.02616881f, 
    0.03551621f, -0.00597888f, 0.00670429f, -0.06412813f, -0.01093464f, -0.00356617f, 0.08648904f, 0.10038839f, 
    0.10708493f, 0.13506006f, 0.01184709f, 0.11423977f, 0.06717414f, 0.28366792f, -0.02264561f, 0.05437978f, 
    0.17764063f, -0.08407993f, -0.01467931f, 0.01351686f, -0.05363527f, 0.03317355f, 0.14774865f, 0.06428172f, 
    0.01690917f, -0.01709400f, 0.03268781f, 0.00181866f, -0.03440641f, -0.00822191f, 0.12561835f, 0.07295231f, 
    -0.33920425f, -0.10149588f, -0.00738209f, -0.07009977f, 0.17763802f, 0.05947687f, 0.04854948f, 0.08480576f, 
    -0.13061379f, 0.00592266f, -0.00425563f, 0.01395743f, -0.00117842f, 0.06844854f, 0.03196408f, -0.13244867f, 
    -0.05261247f, -0.06066626f, -0.04989699f, -0.04217445f, -0.37482601f, -0.15519324f, -0.09441063f, -0.04262714f, 
    0.26962778f, 0.12998587f, -0.01494040f, 0.01311264f, -0.04454948f, -0.07289362f, -0.07217219f, -0.00203894f, 
    0.00710053f, 0.05895560f, 0.06997836f, 0.01972860f, -0.01147263f, 0.00483466f, 0.00047187f, -0.01549474f, 
    0.00091033f, 0.02944232f, -0.03348329f, 0.01150131f, -0.00348337f, -0.03733254f, -0.00768185f, -0.04188534f, 
    0.00751551f, -0.02883693f, -0.00101850f, -0.01708713f, -0.02931165f, 0.01107090f, -0.01593842f, 0.00533468f, 
    -0.00142308f, -0.01389672f, -0.03656194f, 0.01022217f, -0.01197621f, -0.04408842f, -0.00041680f, -0.01788666f, 
    0.00895387f, -0.03612608f, -0.01658773f, 0.02254732f, 0.01749801f, -0.02465643f, 0.03991514f, -0.00620902f, 
    0.02030480f, 0.00985817f, 0.02844113f, -0.01697845f, 0.02649969f, -0.01219441f, 0.03673106f, 0.00929822f, 
    0.01253845f, -0.00011394f, 0.01735473f, 0.02282212f, -0.03771415f, 0.00866416f, -0.00339031f, -0.03138427f, 
    0.03191026f, -0.02330472f, 0.00033363f, 0.02164335f, -0.02967446f, 0.01841994f, -0.03625434f, 0.01609784f, 
    0.01300765f, -0.00297083f, -0.02886616f, 0.01499785f, 0.01362359f, -0.01712151f, 0.00355935f, -0.02446820f, 
    0.01707254f, -0.02099071f, 0.01760496f, 0.02523781f, -0.02876625f, -0.03607702f, 0.04555339f, 0.00482588f, 
    -0.02249928f, -0.03043062f, -0.02884235f, -0.03362455f, -0.01460334f, 0.01486752f, 0.00785176f, -0.01842693f, 
    -0.03200394f, -0.00635105f, -0.01576506f, -0.01238639f, 0.01576626f, 0.02147247f, 0.02854734f, 0.03645557f, 
    0.03434325f, 0.01144742f, -0.02014374f, -0.03066007f, 0.01814534f, -0.01770547f, 0.02274748f, -0.00644031f, 
    0.02411847f, -0.00332329f, -0.02782607f, 0.02107559f, 0.02107188f, -0.00466886f, 0.00872861f, 0.00014546f, 
    0.03431628f, -0.03538805f, 0.01909216f, 0.00608363f, 0.01243474f, -0.04140494f, 0.00702617f, -0.01732666f, 
    0.01105275f, -0.02552456f, 0.02249672f, 0.01914870f, 0.00143262f, -0.01809073f, 0.00645654f, -0.02697209f, 
    0.03194425f, -0.01510515f, 0.01722094f, -0.02792587f, 0.00112922f, 0.00235011f, -0.03488689f, -0.00632126f, 
    0.01330559f, -0.02525478f, 0.02907709f, 0.01572121f, -0.03537719f, 0.00692230f, 0.00495411f, -0.03164390f, 
    0.02184663f, 0.02738497f, 0.01723493f, -0.01406098f, -0.03319883f, -0.01793773f, -0.02320616f, -0.01378704f, 
    -0.00221415f, -0.00210164f, -0.02612071f, -0.01090723f, 0.00770618f, 0.00112077f, 0.02435954f, -0.00876729f, 
    -0.01539644f, 0.02832154f, -0.02189420f, 0.01214871f, 0.02650934f, -0.00513879f, -0.00239204f, 0.01227474f, 
    -0.02797446f, -0.02302193f, -0.02725993f, -0.01100939f, -0.01817826f, -0.03998930f, -0.03195125f, 0.01242332f, 
    -0.02783474f, 0.02447369f, -0.00669014f, 0.02640070f, 0.00679624f, 0.03670976f, -0.00554236f, -0.03575619f, 
    -0.02765597f, 0.03488798f, 0.03326405f, -0.02414204f, -0.00085292f, -0.02008703f, 0.00998792f, 0.04847217f, 
    -0.01870775f, 0.03133713f, 0.03130713f, -0.00765290f, -0.00094276f, 0.02891819f, -0.00365256f, 0.02008213f, 
    0.00242715f, -0.01794907f, 0.01861026f, -0.00025561f, -0.01738773f, 0.03585773f, -0.02115898f, -0.00442645f, 
    0.02847802f, -0.00563597f, 0.02615830f, 0.02373521f, -0.02090310f, 0.02441425f, -0.00994008f, 0.01989353f, 
    0.01426052f, -0.00617668f, 0.00794078f, -0.02451988f, 0.00650728f, -0.01103855f, -0.03166258f, -0.01692411f, 
    0.01676257f, 0.00682769f, -0.02353288f, -0.03806813f, -0.01034518f, -0.02936646f, -0.00664249f, 0.00097356f, 
    -0.02715710f, -0.02545736f, -0.03712425f, -0.01847729f, 0.04574486f, -0.00417118f, -0.02675326f, -0.00879051f, 
    -0.02822942f, 0.00996089f, -0.02644273f, -0.01464503f, -0.01566853f, 0.02357858f, 0.01742883f, -0.02963749f, 
    0.01640895f, -0.01992038f, -0.00173847f, -0.01203349f, -0.00090064f, 0.01488150f, 0.00171736f, -0.02150807f, 
    -0.00527795f, 0.00483347f, -0.01429838f, -0.03400716f, -0.00662084f, 0.01977989f, -0.02445541f, -0.01558394f, 
    -0.01527487f, 0.02102204f, -0.01762856f, 0.00383285f, -0.01064075f, -0.03897379f, 0.02781378f, 0.01614286f, 
    -0.02739073f, 0.03353167f, -0.02119142f, -0.01450632f, -0.00994538f, 0.02474517f, 0.01080388f, -0.03722225f, 
    -0.02842472f, 0.00506995f, -0.02728836f, 0.01430527f, -0.00935062f, -0.02513595f, -0.00285041f, 0.03312936f, 
    -0.01788499f, -0.00359869f, -0.00961558f, -0.02865122f, 0.00974715f, -0.03056957f, -0.02710354f, -0.02536386f, 
    -0.00683332f, -0.00823628f, -0.01282717f, -0.03486152f, 0.02728495f, -0.03844415f, 0.02521306f, 0.03085954f, 
    -0.00895641f, -0.01106678f, -0.03839782f, 0.00147451f, -0.01902725f, 0.02594176f, -0.01639542f, -0.01445428f, 
    0.02615372f, -0.01815349f, 0.03092209f, 0.00915816f, -0.02741742f, -0.01664728f, 0.03363578f, -0.01461324f, 
    0.03545840f, -0.00533836f, -0.03453639f, -0.02158396f, 0.00850753f, 0.03578243f, -0.02426271f, 0.02416342f, 
    -0.00460212f, -0.00353052f, -0.00117974f, -0.02793216f, -0.02626318f, 0.02208230f, -0.02488488f, 0.03200319f, 
    0.00775156f, -0.01386355f, -0.03156234f, 0.02204167f, -0.03414166f, 0.02953938f, -0.03670207f, 0.01310187f, 
    0.01757518f, 0.00274021f, 0.02818827f, -0.02775990f, 0.02473924f, -0.03447494f, 0.01734707f, -0.00867165f, 
    -0.01696648f, 0.00402255f, -0.01250653f, 0.01681662f, -0.01137773f, 0.00891488f, -0.00742940f, 0.01752336f, 
    -0.02325095f, -0.02775932f, 0.00010055f, -0.01476985f, -0.01113849f, 0.00851388f, 0.03152660f, 0.01313695f, 
    -0.00991623f, 0.03492286f, 0.01312855f, -0.01050371f, 0.02572236f, -0.00987113f, 0.03492821f, -0.02663058f, 
    0.03513116f, 0.01674575f, 0.00977066f, -0.02188270f, 0.00518527f, -0.02595275f, 0.02475883f, -0.02586504f, 
    -0.04002675f, 0.01217007f, -0.01927016f, -0.00644375f, -0.01402530f, -0.03307073f, 0.02135262f, 0.02918123f, 
    -0.04186157f, 0.01597483f, 0.02938861f, -0.03215940f, -0.03233726f, -0.01258915f, 0.03399725f, 0.03836863f, 
    -0.03925665f, 0.03036108f, 0.03431474f, -0.00607566f, -0.00700835f, -0.01420893f, -0.03957752f, -0.03089761f, 
    0.02799041f, 0.00588455f, -0.03116246f, 0.03400807f, -0.01935166f, 0.01104188f, -0.01725866f, 0.02989959f, 
    0.03257027f, -0.00681311f, -0.03598516f, -0.01077314f, 0.03417240f, 0.02541355f, -0.01967543f, -0.02168353f, 
    -0.03793820f, 0.03617993f, 0.00160187f, -0.01731992f, -0.00718126f, -0.00379817f, -0.03750368f, -0.01018856f, 
    0.00925350f, -0.03126061f, -0.02750070f, 0.01012416f, -0.00207148f, -0.03195599f, -0.02642993f, -0.02107836f, 
    -0.02354527f, -0.01006737f, 0.03274279f, -0.00412406f, -0.03901973f, 0.00083025f, -0.03127815f, -0.00678215f, 
    0.02946197f, 0.01223060f, -0.02749834f, 0.00137378f, 0.00035458f, -0.00034668f, -0.03149124f, -0.00138758f, 
    -0.03253661f, 0.00163136f, -0.03435416f, 0.02182533f, 0.00775487f, -0.00421236f, -0.02547404f, 0.00190357f, 
    -0.02248264f, 0.02424769f, -0.02700911f, 0.03566941f, 0.02942211f, 0.02059473f, 0.03312822f, -0.01446737f, 
    0.01897542f, 0.00368897f, -0.03483829f, 0.01045276f, -0.00474671f, 0.02327475f, 0.02659352f, 0.01538936f, 
    -0.03774648f, -0.00841946f, -0.02290082f, -0.03193757f, 0.01105520f, 0.02085729f, 0.00698449f, -0.01268993f, 
    0.00897321f, 0.00628675f, -0.03120875f, 0.03827988f, -0.01654842f, -0.03342235f, -0.01174965f, -0.02300414f, 
    0.02441430f, 0.01890337f, 0.04089689f, -0.02092895f, -0.03515824f, 0.03785431f, 0.01596091f, -0.00675163f, 
    0.00419128f, -0.01107870f, -0.04012981f, -0.00820084f, 0.02624962f, -0.01211548f, 0.02693160f, 0.02042283f, 
    -0.04367781f, -0.00870280f, 0.02780599f, 0.02990129f, -0.01881587f, -0.03694613f, -0.01804436f, -0.03883134f, 
    -0.00430373f, -0.00277947f, -0.03950218f, -0.00981340f, -0.00168091f, 0.02142140f, 0.00171546f, -0.00893512f, 
    -0.01712550f, -0.00218930f, -0.03493094f, 0.02710800f, -0.02649592f, 0.03415882f, -0.01283394f, 0.01054385f, 
    -0.00720961f, -0.00424850f, 0.02408101f, -0.03992668f, 0.01814157f, -0.04044101f, 0.00039237f, 0.00127311f, 
    -0.04312309f, -0.02162709f, -0.03064758f, 0.00386080f, 0.00938554f, 0.00904665f, -0.02827947f, 0.02064104f, 
    -0.01631585f, 0.02010404f, -0.01358355f, -0.01788326f, -0.01996231f, 0.02311767f, -0.00647244f, 0.01190293f, 
    -0.00820439f, -0.00676433f, -0.00196118f, -0.01183219f, -0.03715516f, 0.01187437f, -0.01484371f, -0.02819156f, 
    -0.00107441f, 0.02735374f, -0.00751692f, -0.02749002f, -0.01471444f, -0.00161522f, 0.00131959f, 0.02960765f, 
    -0.02874688f, 0.00347534f, -0.00362523f, -0.01506180f, -0.03377155f, 0.02199201f, -0.00274011f, -0.00927248f, 
    0.02929479f, 0.02029739f, 0.00758616f, 0.00384946f, -0.00677514f, 0.01278675f, 0.02931656f, -0.00149298f, 
    -0.01096405f, -0.00629273f, -0.00313455f, 0.02283638f, -0.01411577f, -0.00664693f, 0.02140133f, 0.02132835f, 
    -0.00205129f, -0.00419707f, 0.01082706f, -0.01134901f, -0.00366694f, 0.00342111f, 0.00472334f, 0.00058469f, 
    0.02293356f, -0.01224304f, -0.02835467f, 0.00631348f, -0.03101508f, -0.01408193f, -0.00396151f, 0.00650005f, 
    -0.02999063f, 0.01347258f, 0.02548868f, -0.02173733f, 0.01301644f, -0.02622422f, 0.01510700f, 0.00639192f, 
    -0.03681076f, 0.02097205f, -0.03543055f, -0.03076194f, 0.02357050f, 0.03318271f, -0.03173658f, -0.02838319f, 
    -0.02733235f, -0.04325229f, -0.02616934f, -0.00441714f, -0.03334906f, -0.02966220f, 0.01061052f, -0.02111172f, 
    0.03607461f, 0.00679104f, 0.02834575f, -0.01129226f, -0.00257419f, -0.04147333f, -0.00792538f, -0.02725338f, 
    -0.00488759f, 0.01813870f, -0.02746664f, 0.00744688f, 0.02779581f, 0.01407804f, 0.00940070f, -0.02671731f, 
    -0.02850296f, -0.04463013f, -0.00427741f, 0.03069113f, -0.00630395f, -0.00702397f, -0.03103464f, 0.00573329f, 
    -0.01143463f, 0.01141373f, -0.03924260f, 0.03222976f, -0.02269164f, 0.00799873f, -0.02225272f, 0.02125929f, 
    -0.02900067f, 0.01873869f, -0.00630182f, 0.02772115f, 0.00605428f, 0.03347162f, -0.04147828f, 0.02449262f, 
    0.03284042f, -0.02485792f, 0.03013367f, -0.03595543f, -0.04186716f, -0.04074714f, 0.02329941f, 0.02316223f, 
    0.02499180f, -0.00088080f, 0.01719593f, -0.03341221f, -0.02298731f, -0.00087950f, 0.02141451f, 0.03357158f, 
    -0.03557536f, 0.02878070f, 0.03051637f, 0.03263077f, -0.01647896f, 0.02310233f, -0.03610468f, -0.02479968f, 
    0.00498241f, -0.00327982f, -0.00921386f, 0.02307647f, 0.02721814f, 0.00491460f, 0.01222452f, -0.02422313f, 
    -0.00433218f, 0.03107343f, -0.01721786f, -0.00927898f, -0.02833563f, -0.01568810f, 0.02849181f, -0.04099853f, 
    0.03454565f, 0.03088369f, 0.03160524f, 0.01825948f, 0.01153395f, 0.03007792f, -0.02240262f, 0.02598151f, 
    0.02303201f, -0.03345700f, -0.03578853f, -0.00880126f, -0.01996113f, -0.03049800f, -0.04304289f, -0.04118481f, 
    0.03380985f, -0.04458674f, -0.03187672f, -0.03965506f, 0.02135742f, 0.01988218f, -0.03711928f, -0.02022234f, 
    0.02917774f, -0.03272211f, -0.04703014f, -0.04475838f, -0.03538193f, -0.03165875f, 0.02054417f, 0.01937330f, 
    0.02752427f, -0.04081241f, 0.00528188f, 0.02048341f, -0.01796495f, 0.02232588f, -0.01999414f, -0.00883072f, 
    -0.00376026f, -0.04056233f, 0.03101994f, 0.00204051f, 0.02629967f, -0.03917212f, -0.01131881f, 0.01527181f, 
    -0.00650735f, 0.01967490f, -0.00709554f, -0.01885620f, 0.01865791f, -0.00776853f, -0.02468140f, -0.01378875f, 
    0.01748473f, 0.03413948f, -0.01005077f, 0.00497060f, 0.00784605f, -0.02569794f, -0.02888645f, -0.00299336f, 
    -0.01833066f, 0.01119918f, 0.01357594f, -0.00431887f, 0.02950164f, -0.00966886f, -0.03121728f, -0.02005445f, 
    -0.00508767f, 0.03072175f, -0.02250635f, -0.00734587f, 0.00019825f, -0.03141882f, -0.02831213f, 0.02817477f, 
    -0.00697341f, -0.03068376f, 0.01674136f, 0.03007332f, -0.02499880f, 0.02398024f, 0.00281876f, 0.02742594f, 
    0.00080998f, 0.00947281f, -0.01100239f, -0.02940844f, -0.03550849f, -0.04845529f, -0.00009538f, 0.00159612f, 
    0.00990644f, -0.02845428f, 0.00178838f, -0.03932090f, 0.02323211f, -0.02740258f, 0.00984433f, -0.01134207f, 
    0.00959687f, 0.02016064f, 0.01240150f, -0.00952854f, -0.04359715f, -0.01210912f, -0.03244803f, -0.02875979f, 
    0.01915883f, -0.02845003f, -0.02429721f, -0.00846203f, 0.03149552f, -0.00147890f, -0.04249360f, 0.00714132f, 
    -0.00372670f, 0.03140172f, 0.03487092f, -0.00321171f, -0.01111858f, 0.00645818f, 0.01056209f, -0.04363573f, 
    0.02180797f, -0.03840821f, -0.01142939f, -0.00745607f, 0.00742457f, -0.00874112f, -0.02654228f, 0.02081642f, 
    -0.03716046f, 0.01731861f, 0.02073559f, -0.03872874f, -0.01379145f, -0.04056328f, -0.01486461f, -0.03684171f, 
    -0.01393028f, -0.03319613f, 0.00462930f, -0.02531660f, 0.02680920f, -0.02003988f, -0.04191943f, -0.03019580f, 
    -0.01816138f, -0.04195893f, 0.02904527f, -0.01805910f, 0.02543210f, -0.03851748f, -0.03180777f, 0.01811074f, 
    -0.03500192f, -0.02567873f, -0.03247238f, -0.02194943f, -0.02398523f, -0.04410712f, 0.02112683f, 0.00490884f, 
    0.03299941f, -0.00766255f, 0.02368786f, -0.00817566f, 0.03016443f, -0.00865281f, -0.03940325f, -0.01826521f, 
    0.01817074f, 0.02870545f, -0.03069870f, 0.02624747f, 0.02940229f, -0.01785833f, 0.00131760f, 0.01680703f, 
    0.01180314f, 0.01554315f, -0.00851537f, 0.02042478f, -0.00208793f, -0.04089700f, -0.01507879f, 0.02782751f, 
    -0.00337221f, -0.02613153f, -0.00247052f, -0.01961633f, -0.04045367f, 0.03007909f, 0.01381015f, 0.00831503f, 
    -0.02985585f, -0.04370355f, -0.02874210f, 0.02721850f, -0.03687281f, -0.03096979f, -0.04516898f, 0.03101093f, 
    -0.00874185f, -0.00958756f, 0.01529100f, -0.00791782f, -0.00894938f, 0.03139381f, -0.03023297f, -0.02724167f, 
    0.01394751f, 0.00947077f, -0.03657337f, 0.01581871f, -0.01114284f, 0.01364078f, -0.02659954f, -0.02817962f, 
    -0.00064956f, 0.02384275f, -0.02264361f, -0.00974777f, 0.01273932f, -0.03036818f, 0.00195989f, -0.02213513f, 
    0.01010894f, -0.00649786f, 0.00891799f, 0.00453919f, -0.00815179f, 0.02859833f, -0.00830925f, -0.00576526f, 
    0.01472765f, -0.01897274f, 0.02212881f, -0.02150451f, -0.04023075f, -0.03567690f, 0.00385596f, -0.03584216f, 
    -0.04147082f, -0.03332464f, -0.01227424f, -0.01058056f, 0.03540589f, -0.01936881f, 0.01584238f, -0.01786366f, 
    -0.03765853f, -0.02606324f, 0.02795939f, 0.02949540f, -0.03239063f, 0.00497284f, 0.00181348f, -0.03783719f, 
    -0.02451144f, -0.02218091f, 0.02744122f, -0.01636993f, -0.04735489f, -0.04163673f, 0.02500708f, 0.03147250f, 
    -0.00411767f, -0.02417635f, 0.01716283f, -0.01806089f, -0.01644778f, -0.03495300f, -0.01463203f, -0.02093011f, 
    -0.03592905f, -0.03104021f, -0.02055010f, 0.00211059f, 0.02287929f, 0.00993848f, 0.00482310f, -0.02031797f, 
    -0.02682773f, -0.03859488f, -0.01374715f, -0.02979753f, -0.03611396f, -0.04030567f, 0.02229113f, 0.01570553f, 
    0.02249079f, 0.00896577f, -0.03253256f, -0.03029045f, 0.00228149f, 0.00875609f, -0.01326287f, -0.03804087f, 
    0.00995370f, -0.02821218f, -0.01584068f, 0.01105562f, 0.02139969f, -0.00673698f, -0.02997337f, 0.02963554f, 
    0.02429758f, -0.03534843f, -0.03952491f, -0.03977979f, 0.02848577f, -0.03814316f, -0.02617951f, 0.00597568f, 
    -0.03718114f, -0.00986198f, -0.02564371f, -0.03948804f, -0.02714020f, -0.00275318f, -0.02759555f, -0.03275640f, 
    0.02321657f, 0.02407029f, -0.03372858f, -0.03504080f, -0.02484508f, -0.03076118f, -0.04156453f, 0.02989314f, 
    -0.01915103f, 0.00170848f, -0.01588506f, -0.03179350f, -0.03031502f, 0.01157537f, -0.03222429f, -0.00557132f, 
    -0.03625956f, -0.04564149f, -0.03660723f, -0.03163147f, -0.02657692f, -0.01775493f, 0.02901390f, -0.00027621f, 
    0.00189943f, -0.03400541f, -0.03232053f, -0.01029010f, 0.01355306f, 0.00278486f, -0.03857721f, 0.01899688f, 
    0.00180831f, -0.04403636f, -0.04512351f, -0.04279129f, -0.01711114f, -0.04168346f, -0.00181845f, -0.00939933f, 
    -0.04640591f, -0.00732510f, 0.02025461f, 0.01812166f, 0.01604761f, -0.04246197f, -0.00187976f, 0.00149025f, 
    0.03098309f, 0.02382350f, -0.03766815f, 0.01863744f, 0.02481884f, 0.01843085f, 0.02193564f, 0.03248572f, 
    -0.01675083f, 0.02074686f, -0.03570439f, -0.04091866f, -0.04551390f, 0.03032753f, 0.00176108f, -0.03755417f, 
    -0.04165129f, 0.01838307f, 0.01240764f, -0.01547817f, -0.00139208f, -0.01756489f, 0.01048350f, 0.00249261f, 
    -0.03197457f, -0.02795738f, -0.04510498f, 0.01831135f, -0.01877259f, 0.01024900f, 0.02192017f, 0.02182930f, 
    -0.00522498f, 0.00487739f, 0.01123153f, -0.00238648f, -0.02576443f, 0.02354216f, -0.02852516f, -0.04519268f, 
    -0.00412707f, -0.02732464f, -0.03065529f, 0.03041318f, -0.03389711f, 0.01925239f, 0.00909877f, 0.03307739f, 
    -0.02216022f, 0.01996619f, 0.00709893f, 0.02782936f, -0.01535185f, 0.00716079f, -0.03647054f, -0.01717720f, 
    0.01309703f, -0.01156174f, -0.03988575f, -0.03996527f, -0.00571562f, -0.01388173f, -0.03558704f, 0.00901338f, 
    0.00811308f, 0.01050924f, 0.03076720f, -0.03550451f, -0.00848702f, 0.01889909f, -0.03517914f, -0.02121995f, 
    -0.00823908f, -0.01981079f, 0.02072622f, 0.01478625f, -0.02953289f, 0.02672992f, 0.02651165f, -0.02767919f, 
    0.00005379f, 0.01762625f, -0.00670247f, -0.02582546f, 0.01853980f, -0.00277029f, 0.00177521f, 0.00095205f, 
    0.02150058f, 0.00734639f, 0.01510256f, 0.01518962f, -0.03585220f, -0.01826452f, 0.00373712f, 0.02113613f, 
    -0.00284820f, -0.01700387f, 0.02486096f, -0.01544735f, -0.02984826f, 0.03245959f, -0.00387957f, 0.01432974f, 
    -0.00820064f, 0.01656168f, 0.00665527f, -0.00308269f, -0.03664485f, -0.00059083f, 0.00518715f, -0.02117486f, 
    0.03201380f, 0.01782003f, -0.03019995f, -0.00078431f, -0.00111491f, 0.02443981f, -0.03438225f, -0.01681994f, 
    -0.02441533f, -0.03055009f, -0.03912492f, 0.00047488f, -0.04448919f, -0.02056842f, -0.00187937f, -0.04521457f, 
    0.03026216f, -0.04629643f, -0.03134830f, 0.01914408f, -0.02041946f, 0.01747456f, -0.03178656f, 0.00403209f, 
    -0.03138129f, -0.01385178f, -0.03249966f, 0.01912824f, 0.01618916f, 0.01966995f, -0.02039574f, -0.01272129f, 
    0.01714814f, -0.00726313f, 0.02008345f, 0.03171529f, -0.01006764f, -0.01264592f, -0.00237819f, -0.03284450f, 
    -0.02971625f, 0.03219282f, 0.00853541f, -0.01627699f, -0.02176950f, 0.03186803f, -0.03173482f, 0.02416169f, 
    0.00216476f, -0.02564771f, 0.00996920f, 0.03476428f, -0.00270849f, -0.01640756f, -0.02739433f, 0.03193964f, 
    -0.01913036f, 0.00638325f, 0.00524057f, 0.01560998f, -0.00288933f, -0.02908862f, -0.02859857f, 0.00798119f, 
    0.01767089f, -0.01896516f, -0.03562213f, -0.00185239f, 0.00819741f, 0.02886462f, -0.00742531f, 0.02993378f, 
    -0.04009451f, 0.01774218f, -0.01571953f, 0.00401909f, 0.00424808f, 0.01671852f, -0.02030696f, 0.01909815f, 
    0.01551622f, -0.00719397f, -0.02922921f, -0.03965229f, -0.04022040f, -0.02405479f, 0.00846446f, -0.01941531f, 
    -0.04161152f, -0.02615976f, -0.03837647f, 0.03608727f, 0.00330998f, 0.02395788f, 0.01900443f, 0.00209578f, 
    -0.01588728f, 0.02654085f, -0.02277066f, -0.00455813f, 0.00149087f, -0.02573921f, 0.01328926f, 0.02711481f, 
    -0.01931683f, -0.01091088f, -0.03462306f, 0.03046290f, 0.01658929f, -0.03570842f, -0.01320189f, 0.00620904f, 
    -0.03526486f, -0.02039599f, 0.02008580f, -0.01553165f, -0.03245188f, -0.01143009f, -0.01272461f, 0.00173273f, 
    0.02969461f, -0.01892743f, -0.00178687f, -0.01866777f, -0.03051522f, -0.03092773f, -0.01821747f, 0.01972519f, 
    -0.01508243f, -0.01290330f, -0.01545877f, -0.00178757f, -0.02261360f, 0.02451312f, 0.03539132f, 0.02664675f, 
    -0.03978196f, -0.03129115f, 0.01428511f, 0.01880590f, -0.00622795f, -0.04470878f, -0.04109402f, -0.03370580f, 
    -0.01002489f, -0.00046445f, 0.01965947f, 0.01880470f, 0.02779617f, -0.03705336f, 0.00383366f, 0.01684179f, 
    0.02463030f, -0.02838278f, -0.01126562f, -0.01936486f, 0.00853934f, -0.00918051f, -0.00974375f, -0.02997961f, 
    0.00260739f, -0.00292365f, 0.03096176f, -0.03474632f, -0.00137836f, -0.01061456f, -0.01025806f, 0.01593003f, 
    -0.01576684f, -0.01426040f, -0.04378989f, 0.00360754f, -0.01544037f, -0.03684002f, -0.04577214f, 0.00237475f, 
    0.00470761f, -0.00397351f, -0.01922819f, 0.02962245f, 0.03540820f, -0.03910152f, -0.02894202f, 0.00966811f, 
    0.00519713f, -0.01808774f, 0.00218229f, 0.02069800f, -0.01109450f, 0.00182304f, 0.01012248f, -0.01027640f, 
    -0.00141777f, -0.00679709f, -0.01414118f, -0.02407145f, 0.01556082f, -0.01814923f, -0.00049746f, 0.02084718f, 
    -0.01496004f, -0.04507972f, -0.03651915f, -0.03175839f, 0.01094109f, -0.00597970f, -0.01290381f, -0.03596643f, 
    -0.01791846f, 0.03203023f, 0.02205259f, 0.02961431f, -0.03255788f, 0.01594422f, -0.00286347f, -0.04528227f, 
    0.00131883f, -0.00260315f, 0.03607208f, 0.03347665f, -0.03514484f, 0.01372240f, 0.01724283f, 0.03124175f, 
    -0.01276145f, 0.02601609f, 0.00154918f, -0.03902650f, -0.01775247f, -0.03466707f, -0.01264328f, 0.02976878f, 
    0.01807933f, 0.00596460f, -0.02945434f, -0.01517370f, 0.02669954f, 0.01837648f, 0.02262090f, 0.01895619f, 
    0.01028693f, 0.02336961f, -0.02934333f, -0.03502062f, 0.03199622f, 0.00531493f, -0.03580105f, 0.00838119f, 
    0.01278341f, -0.02559620f, 0.01159695f, -0.03366190f, 0.01701317f, -0.01651431f, 0.00038370f, 0.03133877f, 
    -0.00059616f, 0.00860100f, -0.03835071f, 0.03697169f, -0.04409781f, -0.02038887f, 0.03458496f, 0.01336629f, 
    -0.02276926f, -0.02581112f, 0.00971624f, -0.04247429f, -0.00845520f, 0.03056893f, -0.00946108f, -0.04307437f, 
    -0.00006726f, 0.04082184f, -0.00776727f, -0.00469542f, -0.02663963f, -0.00128370f, -0.02701928f, -0.02114297f, 
    0.02226089f, 0.03052527f, 0.02723481f, -0.03568503f, -0.00922244f, 0.00249713f, -0.01446506f, 0.02050650f, 
    0.00263664f, 0.01295306f, -0.00838641f, -0.03649458f, 0.00825265f, 0.03750209f, 0.01049300f, -0.01233518f, 
    -0.00535710f, 0.01151174f, -0.00513635f, 0.01733553f, 0.03266783f, -0.03228477f, -0.02488383f, 0.04259432f, 
    0.01080490f, -0.02613139f, 0.01474458f, -0.01894208f, -0.00752929f, -0.01128947f, -0.03973374f, 0.03505925f, 
    -0.00183988f, 0.02292321f, 0.02809682f, 0.02667817f, -0.00220330f, -0.00139512f, -0.04460276f, 0.01181586f, 
    -0.02946674f, 0.00586334f, -0.04569563f, 0.00404887f, -0.02441738f, 0.03960515f, -0.00398190f, -0.00333759f, 
    0.00735723f, 0.01322487f, 0.01006734f, -0.01561492f, -0.01533401f, 0.01819342f, -0.03520935f, -0.03862959f, 
    -0.00827891f, -0.00394564f, -0.00581135f, -0.03935686f, 0.02618955f, -0.00030661f, 0.01525941f, -0.00038617f, 
    -0.02493093f, 0.00237275f, -0.00206447f, -0.00096345f, -0.02344446f, -0.02726651f, 0.02631483f, 0.02373838f, 
    0.02042631f, -0.01608589f, 0.02334141f, -0.00032104f, -0.01877531f, 0.01679845f, 0.02452558f, 0.01488763f, 
    -0.04379511f, 0.00703146f, -0.02730161f, -0.03280604f, -0.02724820f, -0.03730160f, -0.00858113f, 0.01564169f, 
    0.02529913f, 0.01979139f, -0.00544641f, -0.03978576f, -0.00170483f, -0.04072320f, -0.01162697f, 0.01608451f, 
    0.02890376f, 0.00860116f, -0.02864203f, -0.00078964f, 0.00161540f, -0.02412776f, 0.00598104f, -0.00772201f, 
    -0.01317304f, 0.01882156f, -0.01452808f, -0.00914143f, -0.01917058f, 0.01420261f, 0.02006722f, -0.01383536f, 
    -0.01007180f, 0.01358172f, 0.00365690f, -0.03528319f, -0.02414607f, -0.03707463f, -0.03344509f, -0.02321401f, 
    -0.04138061f, -0.01434693f, -0.00443231f, -0.02693887f, 0.02111433f, 0.00595527f, 0.02705551f, -0.01851960f, 
    -0.01025679f, 0.01849275f, -0.03550689f, 0.01977987f, 0.00343227f, 0.00380385f, 0.02840061f, 0.00350751f, 
    0.01143558f, -0.04211518f, -0.00757269f, -0.01487019f, -0.00671864f, -0.00429842f, -0.02761161f, 0.02345791f, 
    -0.02760523f, -0.04015170f, 0.01753166f, 0.00861298f, 0.01954136f, 0.02294831f, -0.00875798f, -0.03781531f, 
    -0.01278121f, 0.01369718f, 0.00711195f, -0.03481670f, 0.00588003f, 0.02854445f, 0.00156220f, 0.02390847f, 
    -0.00452498f, 0.03269713f, 0.00238741f, 0.01078286f, -0.01539270f, -0.00851121f, 0.00304098f, -0.00254762f, 
    -0.00595016f, -0.01972233f, -0.00498803f, -0.02913967f, -0.01306028f, 0.01015854f, -0.00433069f, 0.02776639f, 
    0.02182500f, 0.01001147f, 0.04152077f, -0.02303297f, -0.02827718f, -0.04004012f, -0.00479668f, 0.02469550f, 
    -0.03710159f, -0.00239484f, -0.01378080f, 0.00654903f, -0.01909483f, 0.00357980f, 0.01950776f, -0.02712571f, 
    -0.02374437f, -0.02220593f, -0.02344201f, 0.03467254f, -0.02872810f, 0.02689074f, 0.00024177f, -0.03262445f, 
    0.01169536f, -0.04041161f, 0.02896427f, 0.02010089f, 0.02126669f, -0.04035876f, -0.01550307f, -0.03085695f, 
    -0.02091438f, 0.01192102f, 0.01659882f, -0.01475286f, 0.00742815f, -0.03713487f, 0.02274263f, 0.03165236f, 
    0.01946361f, 0.03678787f, -0.01010343f, -0.02184808f, -0.02023627f, 0.00551301f, -0.03182881f, -0.01425416f, 
    0.02303163f, -0.01684972f, -0.04570504f, -0.03654210f, 0.02935322f, 0.02857400f, 0.03742745f, -0.02603818f, 
    -0.00273868f, -0.00482702f, -0.00020345f, -0.03076497f, -0.02354247f, 0.00009465f, 0.01073683f, 0.02043708f, 
    0.00138541f, 0.00720585f, -0.02138712f, -0.02851805f, -0.01377115f, -0.04589660f, 0.01316329f, 0.01758832f, 
    -0.03967075f, -0.00729304f, 0.02542092f, -0.00701905f, 0.00326558f, 0.00063607f, -0.04187770f, -0.03683553f, 
    -0.01462133f, 0.01668249f, -0.03398617f, 0.02269657f, 0.00315408f, -0.02346566f, 0.01368924f, -0.03646669f, 
    0.01952079f, 0.03080244f, 0.01118549f, 0.03031796f, -0.03881598f, -0.01448150f, -0.03558681f, -0.02212989f, 
    -0.00500220f, -0.00233827f, -0.01378321f, -0.03212108f, 0.00054705f, 0.00175489f, 0.00566845f, -0.02462764f, 
    0.00611048f, -0.00843570f, -0.04617373f, 0.02079831f, -0.01705553f, -0.03483138f, 0.03272931f, -0.02044790f, 
    -0.02950259f, -0.03600178f, -0.01925015f, -0.01603767f, -0.03672590f, -0.00595269f, 0.00391763f, 0.00259770f, 
    -0.02183278f, -0.02916068f, -0.03482376f, 0.00812967f, -0.00175696f, 0.01296939f, 0.01641439f, -0.04413399f, 
    -0.01053905f, -0.02295318f, -0.02011155f, -0.01563302f, -0.03194054f, -0.02924004f, -0.00761240f, 0.03138857f, 
    -0.02002296f, -0.00042677f, -0.01328138f, 0.01008293f, -0.03874653f, -0.01768224f, -0.00493678f, 0.02152460f, 
    -0.03911856f, -0.01044554f, -0.03510784f, -0.00026254f, -0.03959887f, 0.03030396f, -0.00404975f, -0.03541042f, 
    0.00315769f, -0.02005002f, 0.00985382f, 0.02963321f, 0.01505109f, 0.01483752f, 0.02410290f, -0.03048589f, 
    0.02871712f, -0.02735554f, -0.00560653f, -0.02949653f, 0.02945950f, 0.02961569f, -0.03335045f, -0.03027341f, 
    0.02550580f, 0.00633928f, -0.03035738f, -0.00675303f, -0.00648491f, -0.01639660f, -0.00354970f, 0.01589314f, 
    -0.00677631f, -0.00464449f, -0.03175826f, 0.01650662f, -0.01727595f, 0.01201043f, -0.01845064f, 0.02540333f, 
    -0.00569779f, 0.01131391f, -0.02058968f, 0.02438173f, 0.02738792f, -0.04147008f, -0.03366765f, -0.03245983f, 
    -0.03879295f, 0.01244804f, -0.01640654f, -0.03959956f, -0.04260230f, 0.01631715f, -0.02795031f, 0.02110698f, 
    -0.01792549f, 0.00613780f, 0.00658654f, 0.03437336f, 0.02937961f, -0.00362851f, 0.03518251f, -0.02677682f, 
    0.00391257f, -0.01663746f, -0.02809682f, 0.01112757f, 0.02188245f, 0.00994852f, 0.00830255f, 0.03024198f, 
    -0.03760327f, 0.00421559f, -0.00262082f, 0.02642622f, -0.02792638f, -0.02192167f, -0.03609334f, -0.03491767f, 
    0.00159123f, 0.02609493f, -0.00359356f, 0.00009281f, -0.02065877f, 0.00943487f, -0.00849897f, 0.03559312f, 
    0.03239542f, -0.03506733f, 0.02348315f, 0.01791876f, -0.02550522f, -0.03660398f, -0.01255442f, 0.01035843f, 
    -0.02245283f, -0.02359047f, -0.01580671f, 0.02915816f, -0.00929790f, 0.01470561f, -0.01088195f, -0.00964190f, 
    -0.00054096f, -0.03729253f, -0.00332558f, -0.03178526f, 0.02940617f, -0.02172621f, -0.03917250f, 0.01490992f, 
    -0.01621228f, -0.01354214f, -0.02262581f, -0.03353395f, -0.02926185f, 0.00107242f, -0.00904690f, 0.03349845f, 
    -0.63374597f, 0.00193180f, 0.27336073f, 0.12472384f, 0.04765830f, -0.07103133f, -0.06080145f, 0.07737029f, 
    0.03194740f, 0.07898859f, -0.03191797f, 0.01010492f, -0.07510089f, -0.00862707f, 0.07847360f, -0.07335924f, 
    -0.04156087f, 0.05967091f, 0.02947216f, -0.04057319f, -0.08128641f, 0.18140927f, -0.01830816f, 0.01067637f, 
    -0.17611243f, 0.07428460f, -0.06697533f, 0.13013814f, -0.03575998f, -0.02791570f, 0.08490012f, -0.02635729f, 
    0.00080945f, -0.01019948f, -0.11424169f, 0.01730023f, 0.07453985f, 0.00728326f, 0.09755848f, 0.02647942f, 
    -0.09807942f, 0.23511051f, -0.09276817f, 0.08548848f, 0.04848406f, -0.05540962f, 0.09150817f, -0.05635908f, 
    0.09059978f, 0.00363064f, -0.05708798f, -0.03713321f, -0.08001669f, 0.08363195f, 0.10501460f, -0.03922101f, 
    0.21424334f, -0.07562210f, 0.02778420f, 0.02877142f, -0.08103605f, 0.00955289f, -0.36965117f, 0.03884156f, 
    -0.06269749f, 0.13663869f, -0.04303299f, 0.17328954f, 0.01707886f, -0.00996144f, 0.01068656f, 0.03863131f, 
    -0.01369060f, -0.05107289f, -0.02858525f, 0.08576719f, 0.02970124f, 0.04796879f, 0.04833386f, 0.08156876f, 
    0.13179111f, -0.10667525f, -0.04470097f, 0.02904639f, 0.02523435f, -0.08962436f, -0.00008241f, 0.02546652f, 
    0.04629549f, -0.07273668f, 0.13382632f, 0.03250083f, 0.05305253f, 0.07766825f, -0.08347024f, 0.02946214f, 
    -0.01056492f, 0.09350016f, 0.14161837f, 0.04658036f, -0.12300069f, 0.16320162f, 0.10416754f, -0.07511743f, 
    0.07900729f, 0.11486272f, -0.01226202f, -0.08550020f, 0.01058849f, 0.12029156f, 0.05970497f, 0.09616110f, 
    -0.01550229f, -0.00360844f, -0.03536470f, -0.06043521f, 0.06617465f, -0.03717923f, -0.04540796f, -0.06335627f, 
    -0.18672846f, 0.06019368f, 0.11157012f, -0.05721108f, -0.14134036f, 0.10967098f, 0.00631791f, 0.08586441f, 
    0.09234447f, 0.02526117f, 0.04437931f, -0.02880288f, -0.12646279f, -0.02799027f, 0.01462720f, 0.03343611f, 
    0.12837441f, 0.05361929f, 0.04213613f, -0.04199422f, -0.11432151f, 0.01549655f, -0.12601897f, -0.00156405f, 
    0.15639287f, 0.08012806f, 0.08123533f, -0.11478643f, 0.04703148f, 0.08857622f, -0.06872853f, 0.02562904f, 
    -0.06800347f, -0.05696772f, -0.01896789f, -0.03410389f, 0.03310400f, 0.01026454f, -0.02784333f, 0.01326087f, 
    -0.18197195f, 0.38499144f, -0.28052759f, 0.06959530f, -0.01431925f, 0.08003487f, -0.01033763f, 0.01910537f, 
    -0.02614026f, -0.18415383f, 0.02971767f, 0.06040116f, 0.10323898f, -0.01192656f, 0.14089978f, 0.06604116f, 
    0.10109899f, 0.15277933f, 0.05786568f, 0.05331463f, 0.14311248f, -0.02643398f, 0.01712462f, -0.12741135f, 
    0.00336125f, -0.07140317f, 0.10720591f, -0.00717149f, -0.01878003f, 0.04396099f, -0.00725665f, 0.03188844f, 
    0.07087393f, -0.03981169f, 0.00290858f, 0.11771089f, 0.03671444f, 0.04822394f, 0.09756947f, 0.07663806f, 
    0.03931068f, -0.33619335f, 0.04073742f, 0.30634707f, 0.06249680f, -0.26944491f, 0.04174387f, -0.09223099f, 
    0.01141892f, -0.00585995f, -0.15133618f, -0.16062818f, -0.04693002f, 0.07494096f, -0.02031035f, -0.16714676f, 
    0.09655011f, -0.02227870f, 0.07758845f, -0.05884303f, -0.20951444f, 0.32467818f, -0.09622894f, -0.07866443f, 
    -0.19391538f, -0.05186226f, 0.09681035f, -0.07126976f, 0.11331817f, -0.06193697f, -0.00748413f, -0.04454760f, 
    -0.11009659f, 0.06617343f, 0.01759972f, -0.06443285f, 0.05019221f, -0.03348177f, 0.01518826f, 0.00590471f, 
    0.12817806f, 0.13370207f, 0.11917183f, 0.42775738f, 0.08040377f, -0.00042706f, -0.02268352f, -0.02755894f, 
    0.05508104f, 0.02879284f, 0.00405000f, -0.00513887f, 0.12128679f, 0.03969260f, 0.03819397f, -0.03612498f, 
    0.01141155f, -0.06332918f, -0.07034800f, -0.05577505f, 0.15309054f, -0.14152612f, 0.01997771f, 0.07277950f, 
    0.12264422f, -0.00761096f, 0.15069418f, 0.00456808f, 0.02051377f, 0.08959843f, -0.03905132f, 0.01436106f, 
    0.09481902f, -0.01861727f, 0.05996342f, -0.06938682f, -0.11867528f, 0.09498939f, 0.02996101f, 0.03980303f, 
    -0.27606571f, 0.23104012f, 0.00246341f, -0.04890991f, 0.06292725f, 0.09683510f, 0.04109395f, 0.17833182f, 
    0.08803300f, -0.05544341f, 0.00675876f, 0.00376912f, 0.08659655f, 0.06573486f, 0.02156775f, -0.06630348f, 
    0.19447269f, 0.07273690f, 0.15279019f, 0.01622085f, 0.03490888f, 0.23189212f, 0.19356166f, 0.00814291f, 
    -0.00900819f, 0.00403599f, 0.10005333f, 0.09531006f, 0.03182936f, 0.04475901f, 0.04236049f, 0.01392610f, 
    0.09683803f, 0.10425351f, 0.00041344f, -0.13085684f, 0.07323484f, -0.04739679f, -0.07336599f, 0.14628361f, 
    0.11499951f, -0.28225181f, 0.29955918f, 0.11683647f, 0.07479110f, -0.11008665f, -0.05511748f, 0.02719143f, 
    -0.04265629f, 0.02343018f, 0.03800968f, -0.07250233f, 0.02252017f, 0.04664353f, -0.08244283f, -0.00629021f, 
    0.03777770f, -0.09830679f, 0.03519713f, 0.04428462f, -0.37102878f, 0.00531236f, 0.28289041f, -0.00945348f, 
    0.11437315f, -0.14765210f, -0.01867576f, 0.00079924f, 0.02327954f, 0.02766334f, 0.09384027f, 0.07959847f, 
    0.08090527f, -0.02211704f, 0.08329052f, 0.03953734f, 0.03029831f, -0.05787089f, 0.08276098f, 0.08072808f, 
    -0.15280603f, -0.31285194f, 0.09903625f, 0.21940432f, 0.05813305f, -0.12902953f, -0.04950043f, 0.02185790f, 
    -0.03527489f, 0.13303378f, 0.00411651f, -0.02566875f, 0.09491079f, 0.06970073f, 0.07863045f, -0.07305236f, 
    -0.04134248f, 0.03972549f, 0.07056665f, 0.04689960f, -0.50060773f, -0.09262802f, 0.12443464f, 0.17892049f, 
    -0.13975482f, -0.11742512f, 0.05493813f, -0.05742573f, 0.01301404f, 0.09696819f, 0.06425596f, -0.03298262f, 
    -0.04295443f, -0.12696943f, 0.10636833f, -0.05687691f, -0.07816663f, -0.00645459f, -0.07565083f, 0.02301912f, 
    0.09441514f, 0.09066537f, -0.05632083f, -0.04254593f, -0.14017214f, 0.01961994f, 0.06226183f, -0.05292923f, 
    0.05276967f, -0.02398358f, -0.07835250f, 0.01264394f, 0.03908141f, 0.04502895f, -0.03709479f, 0.11162914f, 
    -0.00715920f, 0.02310859f, 0.00799618f, 0.15455510f, 0.02569127f, 0.07073276f, 0.11610176f, 0.44150594f, 
    0.19642320f, -0.01006226f, 0.03596734f, 0.01258719f, -0.06880014f, 0.10156968f, 0.01107736f, 0.01072067f, 
    0.05078853f, 0.03444295f, 0.11909906f, -0.06357912f, 0.07893408f, 0.02129734f, -0.11854985f, 0.06834392f, 
    -0.21790752f, 0.04514484f, -0.02698618f, -0.05290662f, -0.10807497f, 0.04854890f, 0.05245247f, 0.15570961f, 
    -0.04444785f, -0.05504048f, 0.15524431f, 0.04118406f, -0.06981841f, -0.03875883f, -0.04381178f, 0.10213641f, 
    -0.00770987f, -0.02899760f, 0.21576227f, 0.07518759f, -0.50890559f, 0.15470576f, -0.05341917f, -0.03242161f, 
    -0.04885076f, 0.07031447f, -0.11035549f, -0.03212259f, 0.01728240f, -0.00985602f, -0.03963368f, 0.08743115f, 
    -0.07012964f, 0.09658412f, 0.06478968f, 0.00379925f, 0.08851640f, -0.00903246f, 0.04816060f, -0.12865075f, 
    -0.43491042f, -0.30360174f, 0.10408347f, 0.08255929f, -0.01249378f, -0.10516129f, 0.02644319f, 0.03432740f, 
    0.06364267f, 0.08783458f, -0.00170939f, -0.11056901f, 0.02219866f, -0.00139982f, 0.07170820f, -0.10547738f, 
    -0.01819339f, -0.12502739f, 0.06305315f, 0.11949920f, -0.27169088f, 0.25096428f, -0.18660718f, -0.06398576f, 
    -0.01606651f, 0.08655395f, 0.00987864f, -0.05827336f, 0.06687684f, -0.01389213f, 0.02461449f, 0.08361660f, 
    0.02089674f, -0.02668844f, 0.06893455f, 0.06376483f, 0.08604940f, -0.01157671f, 0.06635626f, -0.04945252f, 
    0.01153571f, -0.21999407f, 0.09663472f, 0.12480339f, 0.00606069f, -0.00344043f, -0.07052157f, 0.04612530f, 
    -0.01954996f, 0.00490128f, -0.11481208f, 0.00912192f, -0.00325602f, 0.03615979f, -0.05728383f, -0.06427936f, 
    0.01002669f, 0.10698289f, 0.09167271f, 0.01440339f, 0.12793304f, 0.18071975f, -0.13043374f, 0.26997778f, 
    0.14820652f, 0.10041502f, 0.02147854f, 0.07384481f, 0.06093137f, 0.07180544f, 0.10019028f, -0.00485230f, 
    0.04621212f, -0.04315018f, -0.00688971f, 0.03756224f, 0.05396901f, 0.12304524f, 0.11304835f, 0.07717122f, 
    0.05480709f, -0.05151701f, 0.14012758f, 0.27934635f, -0.02863467f, -0.00565622f, -0.01671145f, -0.01353982f, 
    -0.00731721f, 0.04813584f, 0.05144125f, 0.02553435f, -0.01969071f, 0.02699474f, 0.06313930f, 0.00716894f, 
    -0.02830538f, 0.08769403f, -0.01304614f, 0.03355187f, 0.07479405f, -0.02013844f, 0.04901456f, 0.29422626f, 
    0.18702708f, 0.00787409f, 0.14280222f, -0.00151453f, 0.08770373f, 0.11862396f, 0.02893720f, 0.04525619f, 
    0.07672520f, -0.01112366f, 0.07399942f, -0.02334373f, 0.02427048f, 0.05842670f, 0.02047266f, 0.07239601f, 
    -0.16546637f, 0.12135619f, -0.18309017f, -0.02616066f, 0.04836741f, 0.20386396f, 0.03516226f, -0.00679738f, 
    0.05057465f, 0.04429363f, -0.03882957f, 0.08507651f, 0.08509289f, 0.13442603f, -0.03372318f, 0.05924875f, 
    0.04089532f, -0.03613943f, -0.02840655f, 0.02398380f, -0.42133683f, 0.10488959f, -0.20916343f, 0.01474360f, 
    -0.10290290f, 0.18208572f, 0.08724804f, 0.10100915f, -0.04489457f, -0.01847933f, -0.02225268f, 0.03007268f, 
    0.03251714f, -0.00669013f, 0.06388360f, 0.10728326f, 0.12326181f, 0.06904881f, 0.10377152f, -0.03322249f, 
    0.00539314f, -0.03906019f, -0.03329442f, 0.02895916f, -0.01151469f, -0.04232528f, 0.02319646f, 0.03175158f, 
    -0.02401455f, 0.03332975f, 0.01686990f, -0.03284057f, -0.03005849f, 0.02582430f, -0.01095586f, 0.02055250f, 
    0.03181801f, 0.00111001f, 0.01982116f, 0.03511811f, -0.00624727f, 0.00543811f, -0.02469299f, -0.00499886f, 
    -0.01147023f, 0.00082699f, 0.00335021f, -0.01194913f, 0.03513069f, 0.02515975f, -0.03165331f, 0.01676941f, 
    -0.01629543f, -0.02161917f, 0.02024855f, -0.00238994f, 0.01419293f, -0.01534186f, 0.02001429f, 0.03415836f, 
    -0.03519691f, -0.03578248f, 0.00697885f, -0.01102223f, -0.00341267f, 0.03025016f, -0.00401879f, -0.04271992f, 
    0.03031596f, -0.01208737f, -0.00569948f, -0.03160197f, 0.01157568f, -0.01639987f, -0.03435284f, -0.02583407f, 
    -0.00473651f, 0.01259809f, -0.00240711f, 0.01086561f, 0.00514126f, -0.04354399f, -0.03095739f, -0.04103393f, 
    0.00755879f, -0.01748203f, 0.02294525f, -0.01520047f, -0.01648683f, -0.00633879f, -0.02167124f, 0.00516947f, 
    0.03207920f, -0.02349387f, -0.01973318f, -0.01875405f, 0.01798455f, 0.03097500f, -0.02861575f, -0.03949001f, 
    -0.03939943f, -0.03343539f, -0.01343689f, 0.00782973f, 0.02818943f, -0.00922029f, 0.00167898f, 0.01707621f, 
    -0.01387912f, -0.01541266f, -0.03593839f, -0.03014450f, -0.03622053f, -0.01940793f, -0.00634832f, 0.02696838f, 
    0.03162440f, -0.02626559f, 0.02900701f, 0.02500429f, 0.03363885f, 0.01328749f, 0.00144683f, 0.00706186f, 
    -0.01377267f, 0.02727687f, -0.00888163f, -0.02132822f, -0.01887743f, -0.01593775f, -0.04076616f, -0.00087842f, 
    -0.02115475f, 0.00311158f, -0.03215100f, -0.02855116f, -0.01464661f, 0.01945263f, 0.03206508f, 0.03619211f, 
    -0.00183423f, -0.03671443f, 0.02148950f, -0.04494260f, 0.00725683f, -0.02984898f, 0.01908839f, 0.00799604f, 
    0.01544289f, 0.00404996f, -0.01472637f, -0.04031423f, -0.03023446f, 0.02355891f, -0.01837027f, -0.00920376f, 
    -0.00103687f, 0.02969566f, -0.00410571f, -0.02047366f, 0.01558507f, 0.01331100f, -0.04182476f, 0.00667290f, 
    0.00518018f, -0.01403369f, -0.01510100f, -0.01252017f, -0.00148628f, -0.03929725f, -0.01217487f, -0.00404376f, 
    0.02739580f, 0.01077842f, 0.00836483f, 0.01142565f, -0.03366868f, 0.00293303f, 0.02171892f, -0.01177584f, 
    0.02019581f, 0.01281890f, -0.00379989f, -0.01734458f, -0.03043088f, 0.00172563f, 0.00140461f, 0.01811420f, 
    -0.04434803f, 0.02567826f, 0.02467285f, -0.04109133f, -0.01168932f, -0.00968249f, 0.00004865f, -0.00490833f, 
    0.02232264f, -0.01990593f, 0.01687086f, -0.01385151f, 0.02856044f, -0.03484930f, -0.03883350f, -0.04314574f, 
    0.02869855f, -0.04171642f, 0.02358461f, 0.00608827f, 0.00030195f, 0.01777408f, -0.01679984f, -0.03888479f, 
    0.02918485f, 0.03170928f, -0.02466123f, -0.00938416f, -0.02518482f, 0.00868777f, 0.02423560f, 0.00959465f, 
    -0.04510837f, 0.01831599f, -0.01200018f, 0.00234163f, -0.03592032f, -0.04106686f, 0.03050631f, -0.00048838f, 
    -0.04436191f, 0.00172162f, 0.01894774f, 0.00048782f, -0.00075675f, 0.02986382f, -0.03552426f, 0.00194028f, 
    -0.02250072f, 0.02721061f, -0.00497954f, 0.00401791f, -0.02131373f, 0.02593664f, 0.02020442f, -0.00106094f, 
    -0.03291564f, 0.00525359f, 0.00366345f, -0.03549966f, 0.01212748f, 0.02510853f, 0.01171190f, 0.01904570f, 
    -0.01314130f, -0.02633175f, -0.04099915f, -0.00810959f, -0.01506848f, 0.03173334f, -0.02030446f, -0.01684988f, 
    -0.00036718f, 0.03108892f, 0.02729607f, 0.01898621f, 0.03958233f, -0.00513695f, -0.03536035f, 0.00128790f, 
    0.03190227f, -0.02527433f, -0.02031136f, -0.00157498f, 0.02729619f, -0.04031840f, 0.02109302f, 0.02240323f, 
    0.02962479f, -0.02612618f, -0.03842650f, 0.02389116f, 0.02734064f, 0.00711930f, 0.01379767f, -0.02660671f, 
    -0.00493564f, 0.01448946f, -0.00690972f, -0.02379290f, 0.03530038f, -0.01302643f, -0.01969143f, -0.04120512f, 
    0.01263428f, 0.01519242f, -0.01622118f, -0.03253794f, 0.01496542f, 0.01008544f, -0.01549977f, -0.02678582f, 
    -0.03630156f, -0.02111817f, 0.03569179f, -0.00687423f, -0.01652880f, 0.00374678f, -0.00530803f, 0.01144238f, 
    0.03019732f, -0.01745848f, -0.03246333f, -0.02620272f, -0.01679065f, 0.02723675f, -0.00592355f, -0.00589559f, 
    -0.01379768f, -0.01222520f, -0.00590696f, -0.02469683f, -0.02350114f, 0.03288332f, 0.00785399f, 0.01727513f, 
    0.00855769f, -0.04014711f, -0.00425119f, -0.00232493f, -0.01655322f, 0.00984137f, -0.01341567f, 0.03138719f, 
    -0.03963198f, -0.01215391f, -0.02559261f, 0.00862473f, -0.03505090f, 0.00274775f, 0.02594303f, 0.03080563f, 
    -0.00708776f, -0.03915539f, -0.04351744f, 0.03169687f, -0.00064624f, 0.03166384f, -0.02743533f, -0.00637072f, 
    0.00443483f, 0.00277832f, 0.01147060f, -0.01615134f, 0.03214668f, 0.01509004f, 0.00001893f, -0.03770915f, 
    -0.00585084f, 0.02854696f, -0.01192172f, -0.01086361f, 0.03568309f, -0.01569683f, 0.00049908f, 0.02108201f, 
    -0.00195964f, 0.03046985f, -0.00670775f, 0.04119363f, -0.03479630f, 0.01981701f, -0.03730745f, 0.01417677f, 
    -0.03912440f, -0.03420287f, -0.01301744f, -0.03550543f, -0.02855074f, -0.01305870f, 0.03562257f, -0.00806717f, 
    -0.01011345f, 0.02768968f, 0.01619572f, -0.02641206f, 0.00763506f, -0.04308418f, -0.03799193f, -0.02818616f, 
    -0.03137922f, -0.04167917f, 0.01825532f, 0.04300629f, 0.01606781f, 0.04445609f, 0.02220970f, -0.01904914f, 
    0.01765138f, 0.01885253f, -0.02824606f, -0.02943010f, -0.03605973f, 0.00343933f, -0.03687883f, -0.02444180f, 
    -0.00549944f, 0.02241271f, 0.00634521f, -0.04261180f, 0.00231340f, -0.00102391f, 0.00244922f, -0.03408713f, 
    0.01667105f, 0.00767091f, -0.00662809f, 0.03464178f, 0.00898800f, -0.00233814f, 0.01062844f, 0.02927716f, 
    0.03036712f, 0.02082058f, -0.03446118f, -0.02240750f, -0.01081239f, 0.00298106f, 0.00918148f, -0.03483592f, 
    -0.04193619f, 0.02871097f, -0.01363511f, -0.03167899f, -0.02064430f, 0.00347289f, 0.01671839f, -0.01125025f, 
    0.00890592f, -0.03757331f, -0.01478199f, 0.02978894f, 0.00609519f, 0.00802070f, 0.00075346f, 0.01208366f, 
    0.02217317f, 0.03498543f, -0.04279964f, 0.00680438f, -0.03654977f, -0.03960612f, -0.03857907f, -0.02258714f, 
    0.00539507f, 0.01449551f, -0.00589425f, -0.00552955f, 0.02885580f, 0.00196767f, 0.02148535f, 0.02919274f, 
    -0.00329712f, -0.00715787f, 0.00725845f, -0.01579944f, 0.01824996f, -0.02705532f, -0.03564981f, -0.03009184f, 
    -0.03757891f, 0.00346505f, 0.00874299f, -0.00975417f, 0.03060540f, -0.00223280f, 0.02995400f, -0.00066983f, 
    0.00573293f, -0.00609826f, -0.00309581f, -0.00975360f, 0.00096396f, 0.03325035f, -0.04183802f, 0.01835871f, 
    -0.02872194f, 0.03064782f, -0.02170495f, 0.00567999f, 0.02163473f, 0.00417381f, 0.00965029f, -0.01138994f, 
    -0.04226432f, -0.02126934f, -0.03636761f, 0.02288256f, -0.02833432f, -0.02391733f, -0.02943983f, -0.00244479f, 
    -0.04357042f, 0.02808883f, 0.01652895f, 0.02225389f, 0.02231082f, -0.00837820f, -0.00961376f, 0.03358440f, 
    0.00159137f, -0.01016660f, 0.02851561f, 0.01230675f, -0.01629679f, 0.03383211f, 0.02002086f, -0.03204019f, 
    0.01036604f, 0.03574096f, -0.04483227f, -0.02377887f, -0.00948986f, 0.02044770f, 0.01156899f, -0.03096341f, 
    0.01551732f, -0.00988044f, 0.01659507f, 0.00369782f, -0.03641612f, -0.01914012f, 0.01642085f, 0.00866509f, 
    -0.04473102f, 0.00325302f, -0.02267032f, -0.03327423f, -0.02120338f, 0.01065422f, 0.01709788f, -0.01976347f, 
    0.03694570f, -0.04159394f, -0.00995547f, 0.01200334f, -0.00338604f, -0.01528756f, -0.00191618f, -0.01305155f, 
    -0.02705557f, -0.01565682f, 0.00686154f, -0.01086876f, -0.01785067f, -0.00232018f, -0.00870763f, 0.03483092f, 
    -0.04455172f, -0.01111592f, -0.00656976f, 0.01527525f, -0.01651105f, 0.00330625f, 0.03483945f, -0.00019907f, 
    0.01954366f, 0.03014249f, -0.03963105f, -0.00446205f, -0.01536563f, 0.01690792f, -0.00241369f, -0.02376958f, 
    -0.04292192f, 0.02705300f, -0.04412248f, 0.01202636f, -0.02680837f, 0.00617313f, -0.01550314f, -0.02272684f, 
    0.02876316f, 0.00831088f, -0.02656033f, 0.02262192f, 0.03107216f, -0.03052598f, -0.01289262f, 0.03274555f, 
    -0.04222997f, 0.00930858f, -0.02776994f, -0.01848151f, 0.02612747f, -0.03021224f, -0.03968912f, 0.01371707f, 
    -0.00637211f, -0.00540672f, 0.01346183f, 0.02478636f, -0.01687494f, -0.01822196f, -0.02039921f, -0.03548099f, 
    -0.03554223f, -0.04057509f, 0.00496547f, 0.01274798f, -0.02014001f, -0.03251394f, -0.01596836f, 0.04207448f, 
    0.00408450f, -0.01518664f, -0.00256494f, 0.02782068f, -0.04132774f, -0.00413393f, -0.01944669f, -0.00157059f, 
    0.00068642f, -0.04431938f, 0.00892657f, -0.02402897f, -0.00993473f, 0.02594048f, -0.03278359f, 0.01522751f, 
    -0.01806846f, -0.03960000f, -0.00445322f, -0.02277158f, 0.00123581f, 0.00659560f, 0.00947692f, -0.03747665f, 
    0.03504083f, 0.01401684f, 0.01305678f, -0.01360379f, -0.00679634f, 0.00932535f, -0.01314624f, -0.04012034f, 
    -0.00356889f, -0.01146580f, 0.03551975f, -0.03532721f, 0.02274491f, -0.00258624f, 0.00138915f, -0.03220278f, 
    0.02558086f, -0.02289269f, -0.03698651f, -0.03632222f, -0.00145425f, -0.03954049f, -0.02622464f, -0.02944248f, 
    -0.04924574f, 0.13832213f, -0.30795330f, 0.06714684f, 0.06490052f, -0.00135343f, 0.08720344f, -0.01394290f, 
    0.06934505f, 0.00481807f, 0.08147907f, 0.04504257f, -0.04683457f, 0.10935842f, -0.04782338f, 0.03424725f, 
    0.00699149f, 0.11688028f, -0.02401106f, 0.02968280f, -0.11062313f, 0.17582394f, 0.14097142f, 0.01899022f, 
    0.10910589f, 0.04518964f, 0.06141771f, 0.01646607f, -0.02212848f, -0.02348300f, 0.01421010f, 0.02413554f, 
    0.04612101f, -0.03114516f, 0.03848247f, 0.05006311f, -0.04012361f, 0.13753223f, 0.05469717f, 0.01615785f, 
    0.14744778f, -0.42482239f, -0.05675526f, -0.17250469f, 0.34080508f, -0.09335622f, -0.12532552f, 0.00938588f, 
    0.02017012f, 0.05968996f, 0.05920174f, 0.00910641f, -0.05083467f, 0.00582247f, 0.00461572f, 0.06683443f, 
    0.01934217f, -0.07493331f, 0.27205095f, 0.04512570f, 0.18392655f, 0.02147602f, 0.18864296f, -0.10861129f, 
    -0.08384307f, 0.02990726f, 0.03439598f, 0.09900595f, -0.02191668f, 0.03744222f, 0.10906268f, 0.09521228f, 
    -0.03262459f, 0.06670419f, 0.04331708f, 0.12890045f, 0.06870948f, -0.05635741f, 0.00502876f, 0.00051635f, 
    0.01903220f, -0.07199317f, 0.16124508f, 0.19160402f, 0.11084614f, -0.08046053f, -0.03599816f, -0.00423410f, 
    -0.12014896f, 0.08920320f, -0.09344199f, 0.11397999f, 0.12405492f, -0.07773490f, -0.00246706f, -0.08340609f, 
    0.00950080f, 0.15334488f, 0.06362001f, 0.00515827f, -0.33026680f, 0.05417300f, 0.14391476f, 0.14055553f, 
    -0.31162831f, -0.07846061f, 0.01177350f, -0.01870712f, 0.07065223f, -0.04365725f, 0.00724886f, 0.03371066f, 
    0.07972238f, -0.04483849f, 0.05724192f, -0.03729885f, 0.02381915f, -0.02759405f, -0.15827899f, -0.02634627f, 
    -0.70653379f, 0.18311852f, -0.05287230f, 0.06466079f, 0.16662404f, 0.06692703f, 0.05601178f, -0.10381915f, 
    -0.02985078f, 0.02139173f, 0.08551859f, 0.05478756f, 0.03682762f, -0.10993159f, 0.02803070f, -0.06316907f, 
    -0.05793477f, 0.17175961f, 0.04994908f, 0.07751341f, -0.19955276f, -0.05661983f, 0.08393201f, -0.10911353f, 
    -0.14600550f, 0.07735000f, 0.05561567f, 0.03589368f, 0.11418214f, 0.06412394f, -0.03088197f, -0.00789841f, 
    -0.02963745f, 0.04179538f, -0.02966421f, 0.00753293f, 0.00965132f, -0.10002326f, -0.02957530f, 0.08203597f, 
    0.25456133f, 0.07661685f, -0.03272203f, -0.05414490f, -0.04403653f, -0.10425686f, 0.01455555f, 0.09976833f, 
    0.05014972f, -0.22827758f, 0.15442447f, 0.00099994f, 0.03925798f, -0.16727909f, 0.06903429f, -0.00664887f, 
    0.06078873f, -0.15547259f, 0.14099613f, -0.02283440f, 0.21809435f, 0.05074583f, 0.02031936f, -0.08855247f, 
    0.31058496f, -0.01686216f, -0.00773674f, 0.03258845f, -0.05434048f, -0.00715129f, -0.12146746f, -0.03499583f, 
    -0.02962935f, 0.04173493f, 0.07651183f, -0.10073724f, 0.15317422f, 0.12807469f, 0.00399297f, 0.13573499f, 
    0.13711883f, -0.21340235f, 0.14981262f, -0.05220331f, 0.26762730f, 0.08266754f, -0.07705505f, -0.03529511f, 
    -0.00583349f, 0.05342618f, 0.01182775f, -0.00626604f, 0.08038417f, 0.13523448f, -0.04940217f, 0.08541118f, 
    0.15348735f, 0.00146556f, 0.00916970f, 0.02302022f, -0.21975176f, -0.07176767f, 0.36602598f, 0.24935998f, 
    -0.08676597f, -0.05821012f, -0.03307476f, 0.04560838f, -0.06559509f, 0.07477137f, 0.09638979f, 0.03283062f, 
    -0.05071662f, -0.09390216f, 0.12703869f, -0.03601582f, -0.01784800f, 0.07560915f, 0.21058062f, -0.03726917f, 
    0.00203024f, -0.43128470f, 0.28874296f, 0.09621003f, 0.15495625f, -0.00193443f, 0.01926607f, 0.05473434f, 
    0.04318283f, 0.12038973f, 0.12253892f, -0.02029814f, 0.05016613f, -0.02121193f, -0.03051491f, -0.20038143f, 
    -0.10313642f, -0.26405072f, -0.06599566f, -0.06580596f, -0.10597217f, -0.03944853f, 0.07588793f, -0.11433483f, 
    0.01676424f, 0.12011002f, 0.09521146f, -0.01072092f, -0.01812033f, -0.01217827f, -0.03881631f, -0.03025832f, 
    0.00920148f, -0.02451107f, -0.02218239f, -0.09270605f, 0.04732976f, -0.09090661f, -0.04273560f, -0.03841246f, 
    0.42528188f, 0.16432388f, 0.00689781f, -0.08910703f, -0.12686165f, 0.01698137f, -0.03450246f, -0.05225175f, 
    0.01340597f, 0.02623624f, 0.14162292f, 0.01770316f, -0.22249393f, -0.09281717f, 0.08474868f, -0.03512516f, 
    0.02973557f, -0.12750854f, -0.14103951f, 0.05691890f, 0.30444214f, 0.22590002f, -0.14319086f, -0.02155843f, 
    -0.01984033f, 0.01593122f, -0.11199414f, 0.04848709f, -0.00105857f, 0.12847953f, 0.12730034f, -0.05430689f, 
    0.12353765f, -0.01100522f, 0.17797837f, 0.06547440f, 0.00461747f, -0.20399748f, -0.10068752f, -0.16267049f, 
    0.16297749f, -0.22887737f, 0.07906227f, -0.06351554f, 0.36185610f, -0.01097094f, -0.11805607f, -0.00146183f, 
    0.08545639f, 0.04324754f, 0.08723548f, -0.04292808f, 0.03965233f, 0.02164750f, 0.01826650f, 0.01631876f, 
    -0.13103357f, -0.21112107f, 0.03430336f, -0.04164043f, -0.06728388f, 0.04170548f, -0.27532741f, -0.01126436f, 
    0.35794172f, -0.06006066f, 0.01040866f, -0.04609712f, -0.01486517f, 0.05010497f, -0.07523004f, -0.03239831f, 
    -0.02751337f, 0.00630732f, 0.08007095f, -0.03649564f, 0.00428912f, 0.09116359f, 0.07026450f, -0.01279354f, 
    -0.01883616f, 0.18624473f, -0.07386367f, 0.00733702f, 0.22733776f, -0.02970205f, -0.08780830f, -0.08203530f, 
    0.07701305f, -0.00122454f, -0.02537315f, -0.01736719f, 0.00649690f, 0.19741532f, 0.06116557f, 0.03206015f, 
    0.03274492f, 0.00093910f, 0.01936725f, -0.06318598f, 0.12919474f, -0.17714150f, -0.01614304f, 0.18587351f, 
    -0.05583202f, 0.00954602f, 0.00038643f, -0.00030661f, 0.03197823f, -0.02282839f, 0.05132500f, 0.12648551f, 
    -0.03529422f, -0.12874417f, -0.03246569f, -0.04086600f, -0.10920835f, -0.01222938f, -0.06311459f, 0.00007934f, 
    -0.03303744f, 0.18819422f, -0.00334539f, 0.21731459f, -0.06928116f, -0.04572713f, 0.04537927f, -0.00380089f, 
    -0.06487130f, -0.04415097f, 0.02807863f, 0.01475497f, -0.09386899f, -0.19689327f, 0.10250959f, -0.05888391f, 
    -0.00172461f, 0.11972315f, 0.01937976f, 0.15955310f, 0.16251405f, 0.01803543f, 0.31323567f, 0.03460299f, 
    0.02769344f, 0.08641148f, -0.05222628f, 0.01482538f, 0.13559957f, -0.07374772f, -0.07116278f, 0.00136032f, 
    0.09757934f, 0.13011386f, -0.00381480f, 0.11078967f, 0.12506650f, -0.19958353f, -0.09771127f, -0.04096406f, 
    0.08764189f, 0.33517501f, 0.00897319f, -0.08484121f, 0.12840824f, 0.04048868f, 0.12321229f, -0.11941269f, 
    -0.08300989f, 0.00254053f, 0.06653722f, -0.02282841f, 0.00135489f, -0.02830617f, 0.19207856f, 0.01716847f, 
    0.06172344f, 0.04407584f, 0.05048206f, -0.07276411f, 0.03539958f, 0.04943600f, -0.08538266f, -0.03344760f, 
    -0.09726775f, -0.09623998f, -0.02947666f, 0.12028139f, 0.04663038f, -0.00559090f, 0.04614793f, 0.03590748f, 
    0.02234434f, 0.04066451f, 0.04577813f, 0.14042497f, 0.04604032f, 0.01421397f, -0.03081434f, 0.03114480f, 
    0.10842493f, -0.00776275f, -0.16343641f, -0.05435574f, 0.03491472f, 0.00066061f, -0.05031811f, -0.01998983f, 
    0.07745253f, 0.01637310f, 0.01810443f, 0.05736369f, 0.01359953f, 0.05754939f, 0.07384017f, 0.09074748f, 
    0.15534398f, 0.11716028f, 0.01653746f, 0.11169308f, -0.02060582f, 0.07399373f, -0.00378946f, -0.01003985f, 
    -0.17120302f, 0.05933404f, -0.05381813f, 0.10566730f, -0.08479726f, 0.03174350f, -0.06622431f, 0.05247446f, 
    0.07866511f, -0.01498783f, 0.09078162f, -0.03770103f, 0.09875713f, 0.04675929f, -0.05118747f, 0.02788475f, 
    -0.03427734f, 0.06373516f, 0.06918325f, 0.06155406f, 0.14979573f, 0.08386741f, -0.18525523f, -0.06320833f, 
    -0.06187104f, 0.05794636f, 0.06364953f, -0.08075586f, 0.03595319f, 0.18350002f, 0.15193480f, 0.08003275f, 
    -0.03822083f, 0.04079330f, 0.02556139f, -0.02689895f, -0.08207050f, 0.08485813f, 0.16946727f, 0.05994245f, 
    -0.36856344f, 0.20427194f, -0.09994046f, 0.01222840f, 0.00879808f, -0.02494711f, 0.10510410f, 0.12463593f, 
    -0.09116389f, -0.14138542f, 0.01869097f, -0.07310630f, -0.10394104f, -0.05467273f, -0.04437043f, -0.02983637f, 
    -0.02510003f, -0.17398366f, 0.11570589f, 0.12904131f, -0.04338510f, 0.04312857f, -0.00537348f, -0.03302694f, 
    0.00838304f, 0.03680672f, 0.05771901f, 0.08563351f, 0.09446821f, 0.00389236f, 0.01220349f, 0.00895752f, 
    -0.09197405f, -0.11074744f, -0.03249512f, -0.12873137f, -0.04580744f, -0.23298921f, 0.05200835f, -0.08687935f, 
    -0.11616860f, 0.08416983f, -0.02925574f, 0.08731546f, 0.01270810f, 0.01474079f, -0.10363521f, -0.10826412f, 
    0.06928326f, 0.06886476f, 0.04264664f, -0.05808103f, 0.05213395f, -0.10181031f, -0.23700199f, -0.04415266f, 
    -0.04525916f, 0.04812917f, 0.00421417f, 0.00975746f, -0.12140163f, 0.00256416f, 0.00417861f, 0.09418426f, 
    0.13352688f, -0.01405964f, -0.00683198f, -0.01172198f, 0.08003549f, 0.12459754f, 0.00299874f, 0.12686518f, 
    0.17429791f, 0.13050230f, -0.01474964f, 0.10120825f, 0.20049474f, 0.26948845f, 0.02363792f, -0.02085839f, 
    -0.16315903f, -0.16566224f, 0.11544229f, 0.04741532f, -0.00973057f, -0.14678878f, -0.00454440f, 0.07992283f, 
    -0.07952994f, -0.09753736f, -0.02815235f, 0.03473390f, 0.03760083f, 0.05154030f, 0.05114704f, 0.01275040f, 
    0.15976940f, -0.49542692f, 0.15809476f, -0.30803367f, -0.16692904f, 0.05262764f, -0.02276692f, -0.01534252f, 
    -0.05706392f, 0.07874845f, 0.07251270f, 0.01619857f, 0.09905332f, -0.00944872f, -0.01827225f, -0.03349588f, 
    0.04773119f, 0.07067619f, -0.06416252f, 0.07350297f, 0.15398481f, 0.00054291f, -0.04087515f, 0.02769154f, 
    0.16847083f, 0.06798659f, 0.12266864f, -0.02568675f, -0.03103919f, -0.03361815f, -0.02922567f, 0.03200943f, 
    0.06305431f, 0.02405211f, 0.07483812f, 0.04846330f, 0.07948685f, -0.01920087f, 0.04485140f, 0.00050264f, 
    -0.17723528f, 0.29695141f, 0.28510624f, -0.15408844f, 0.06958758f, 0.03723062f, 0.15413447f, 0.00041296f, 
    -0.01574850f, -0.00076442f, 0.05325585f, 0.04889163f, 0.03350599f, 0.01193348f, 0.02408873f, 0.06830080f, 
    -0.00581946f, 0.10126887f, -0.01608493f, -0.01356225f, -0.05414661f, 0.02449671f, 0.37992358f, 0.04478171f, 
    -0.01191146f, -0.04171553f, -0.00704226f, -0.03768491f, 0.03159823f, 0.02949578f, 0.04411949f, 0.05055876f, 
    0.03319057f, 0.05473123f, 0.14741710f, -0.14657322f, 0.04366901f, 0.01239062f, 0.03289892f, -0.03788403f, 
    0.26129553f, 0.42060819f, 0.05920570f, 0.07650319f, 0.16370566f, 0.02499079f, 0.07333565f, -0.09240684f, 
    -0.01349332f, -0.12234703f, 0.06124359f, -0.02767249f, -0.01758878f, 0.01121511f, -0.03118831f, 0.07343911f, 
    0.02749966f, -0.03863337f, 0.07174607f, -0.07579669f, 0.12898099f, -0.13793716f, -0.09299061f, -0.07213648f, 
    0.04250183f, 0.09869215f, -0.00806172f, 0.01740780f, -0.09669694f, 0.00846842f, -0.05815165f, -0.03160281f, 
    0.06638776f, 0.04205184f, -0.01120110f, 0.09412669f, 0.02650318f, 0.05237911f, -0.00134618f, 0.10793672f, 
    0.33509070f, -0.25520125f, 0.08799882f, -0.04937793f, 0.04473859f, 0.14798246f, -0.02079975f, -0.05921611f, 
    -0.13735430f, 0.01936496f, -0.09579845f, 0.00484317f, -0.00125480f, 0.02760108f, 0.07960325f, 0.09257233f, 
    -0.03672797f, -0.02122376f, -0.12574784f, 0.03243250f, -0.00381307f, -0.00727623f, 0.14935179f, 0.02316472f, 
    0.14145595f, -0.09269006f, 0.09078471f, -0.00177899f, 0.10297487f, 0.00715527f, 0.14357384f, -0.00749015f, 
    0.04633189f, 0.01038426f, 0.10495082f, 0.02026860f, 0.03752521f, 0.03521964f, -0.06492029f, 0.02076770f, 
    -0.15390509f, 0.19895105f, 0.18198872f, 0.01881058f, 0.01430571f, 0.11532461f, 0.01597925f, -0.07713207f, 
    0.13111106f, 0.20925619f, -0.08413661f, 0.03750649f, -0.05900007f, -0.05009512f, 0.03668845f, 0.06556495f, 
    0.06419683f, -0.03430048f, 0.08504637f, -0.07495742f, -0.05176785f, 0.29124647f, 0.08882146f, 0.17692135f, 
    0.16754782f, 0.03899431f, 0.07697099f, 0.02538593f, -0.08615871f, -0.12539899f, 0.09114706f, 0.03864365f, 
    -0.04964221f, -0.04070758f, -0.00769632f, -0.07488008f, 0.05535547f, -0.02547967f, -0.07504592f, -0.10060146f, 
    0.03533162f, 0.23746821f, -0.08056714f, -0.37818027f, -0.09413803f, -0.17156665f, -0.04869590f, 0.05892659f, 
    -0.08281359f, 0.01639184f, 0.05099059f, -0.00289618f, 0.15443532f, -0.04944244f, 0.01459975f, -0.08949666f, 
    0.03197906f, -0.14591949f, 0.12987302f, 0.10744573f, 0.62731916f, 0.02268451f, -0.05844154f, -0.16544177f, 
    -0.06411707f, 0.06709681f, 0.03900203f, 0.09123034f, -0.09610245f, 0.03967319f, 0.05766060f, 0.00218644f, 
    0.07799711f, 0.06223875f, -0.03961413f, 0.05773345f, 0.02027928f, -0.10084339f, -0.07138210f, -0.08704422f, 
    0.03718841f, 0.11848625f, -0.13836510f, -0.20549604f, -0.30450290f, -0.03177151f, 0.04093464f, -0.07734418f, 
    -0.01943249f, -0.11343722f, -0.17695726f, 0.02711153f, 0.09148739f, 0.04885359f, 0.04006194f, 0.12271606f, 
    -0.00706914f, -0.00082711f, -0.05201382f, 0.03876498f, -0.19184773f, -0.06894580f, 0.22729090f, -0.05515331f, 
    -0.03389639f, 0.02692447f, -0.06038706f, -0.08025705f, 0.08480653f, 0.02106506f, 0.05364097f, -0.01308528f, 
    -0.02002330f, 0.01226900f, 0.07415234f, 0.10438260f, 0.06479465f, 0.01240330f, 0.04244620f, 0.08792747f, 
    -0.22990207f, -0.08147692f, 0.03008459f, 0.19041410f, 0.10478874f, 0.19156070f, 0.12698546f, -0.04142543f, 
    -0.02042261f, 0.18603498f, -0.00547320f, 0.02339771f, -0.01459459f, 0.02349613f, 0.02992723f, 0.10374581f, 
    -0.00007270f, -0.03193852f, -0.01673917f, 0.02023575f, -0.39318246f, -0.42308593f, -0.01305198f, 0.17663954f, 
    0.29333779f, 0.03708075f, -0.03245119f, 0.02451374f, 0.09623360f, 0.08704808f, -0.09177428f, 0.07228339f, 
    -0.00596099f, -0.09949569f, -0.08818240f, 0.08161183f, 0.06259753f, 0.05458627f, 0.12221870f, 0.08797611f, 
    -0.32765481f, -0.07905277f, -0.05471409f, -0.05241426f, -0.12708515f, -0.03185537f, 0.02794719f, -0.07350431f, 
    0.10914731f, -0.12939796f, -0.05762653f, 0.03107541f, -0.01438465f, 0.01439827f, 0.01090224f, 0.03005278f, 
    0.00439970f, 0.01150701f, 0.06019218f, -0.06113284f, 0.22287677f, -0.14760584f, 0.12342058f, 0.13878590f, 
    0.15010428f, 0.25034818f, 0.04766391f, -0.02025845f, -0.06373030f, -0.00784867f, -0.05210945f, -0.00477330f, 
    -0.08011828f, -0.00832887f, -0.07117900f, 0.03231123f, 0.01795901f, 0.10677111f, -0.03840690f, -0.07943141f, 
    -0.17437860f, -0.12283162f, 0.28972220f, 0.02988094f, -0.29614756f, 0.02902164f, -0.03262805f, -0.02187687f, 
    0.00631029f, 0.01044977f, -0.15374538f, -0.08240166f, 0.00680131f, -0.02491521f, -0.09851359f, -0.00582775f, 
    -0.01060923f, -0.04180433f, -0.08752778f, -0.13455655f, 0.30292010f, -0.29595459f, -0.20588364f, -0.10654540f, 
    -0.30358881f, 0.02343947f, -0.06072095f, -0.01011730f, -0.10489042f, -0.05632295f, -0.01729433f, 0.02591412f, 
    -0.03748269f, 0.25921780f, -0.01476613f, 0.03269261f, 0.00348393f, 0.03036026f, 0.01289789f, -0.02455963f, 
    0.56436354f, 0.04142558f, 0.03061459f, -0.02112904f, 0.16200809f, 0.00236677f, 0.02608380f, -0.08422532f, 
    -0.04960378f, -0.03433673f, 0.11845216f, -0.03566083f, -0.00866096f, 0.12240981f, -0.16656038f, -0.01098210f, 
    0.06787369f, -0.06310339f, 0.00876474f, -0.05006083f, -0.07665358f, -0.05419308f, -0.09427392f, -0.34014258f, 
    -0.20531173f, -0.05078839f, -0.01270705f, 0.02909665f, 0.11170910f, -0.02318788f, -0.00881576f, 0.08490347f, 
    -0.05479154f, 0.00431802f, -0.11182921f, 0.02999174f, 0.01006523f, -0.12803364f, 0.00497698f, 0.05058469f, 
    0.40306294f, -0.30630684f, 0.02396083f, 0.08381832f, 0.17869131f, 0.04054895f, -0.02825402f, -0.03729423f, 
    -0.00338759f, 0.02353286f, -0.03320065f, 0.08502634f, 0.10193608f, -0.01187672f, -0.00543849f, 0.10043560f, 
    0.10884270f, 0.06461417f, -0.01815859f, -0.02564891f, 0.29135466f, -0.20605092f, 0.05593997f, 0.07251886f, 
    0.14305490f, -0.09475277f, 0.19771975f, -0.05239506f, 0.04571774f, 0.10115616f, -0.01895407f, 0.06779467f, 
    -0.12533654f, -0.02783434f, -0.08775447f, -0.05717062f, -0.13807881f, -0.03976082f, 0.03320166f, 0.08127297f, 
    0.11255708f, -0.14888754f, 0.00688786f, -0.19472395f, -0.26935178f, 0.10698380f, 0.00843609f, -0.02375713f, 
    -0.02863498f, -0.08464994f, 0.01658134f, 0.06838568f, 0.06824579f, 0.07298494f, -0.06675084f, 0.00248209f, 
    -0.02965542f, 0.07443572f, 0.03487400f, 0.01064004f, -0.16476199f, -0.07189691f, 0.03203250f, 0.12891130f, 
    -0.06554332f, 0.06189393f, -0.03417392f, 0.07472488f, -0.04142021f, 0.12808326f, 0.11006279f, 0.03362181f, 
    0.06647863f, 0.04260586f, -0.10666137f, 0.05581199f, 0.02855277f, -0.03360235f, 0.05200594f, 0.01219588f, 
    -0.09413722f, 0.01486505f, 0.17761348f, -0.13205928f, -0.02853840f, -0.09635142f, 0.11204997f, -0.08626484f, 
    -0.05484111f, 0.03225181f, -0.04389203f, -0.07907323f, 0.13613816f, 0.01230101f, 0.01637720f, 0.01550429f, 
    0.07026040f, -0.13393487f, -0.03190134f, -0.06128207f, 0.01729717f, 0.06319562f, 0.07344337f, -0.04412728f, 
    -0.08905381f, 0.10168935f, -0.01600565f, -0.12880887f, -0.02495561f, 0.20534252f, -0.09540340f, 0.07964969f, 
    0.08712319f, 0.04466479f, -0.00819804f, 0.22324389f, 0.01588324f, 0.01605148f, 0.06088726f, -0.16289720f, 
    0.03049095f, -0.14249361f, -0.18248568f, -0.07211752f, -0.30371007f, -0.06843799f, -0.01902848f, 0.06046946f, 
    -0.03386293f, -0.08747852f, -0.06075199f, -0.09885181f, 0.05352509f, 0.03761921f, -0.05012307f, 0.03369671f, 
    0.02889231f, -0.03179312f, -0.05949345f, 0.11054820f, -0.29459161f, -0.03774464f, 0.17586644f, -0.06336936f, 
    0.03293050f, 0.01646287f, 0.06650610f, -0.04762755f, 0.00847486f, 0.01160452f, -0.00957349f, -0.10194274f, 
    -0.08539415f, 0.03648965f, 0.01137322f, 0.03449008f, -0.00638565f, -0.02717511f, 0.10327346f, 0.11074658f, 
    0.29947808f, -0.06027623f, 0.03729144f, 0.20889075f, 0.12867619f, -0.02630188f, 0.00924517f, -0.01711972f, 
    0.16814177f, 0.08246271f, 0.00920377f, 0.04484525f, -0.04186856f, -0.03977796f, 0.02541638f, 0.04600302f, 
    0.08223686f, -0.04858922f, 0.13344228f, 0.07763778f, 0.46172285f, 0.03037319f, 0.04741133f, 0.10408538f, 
    0.15657336f, 0.05463910f, 0.05020553f, -0.01636594f, 0.00808367f, 0.09084022f, 0.08686505f, -0.05153630f, 
    -0.11235274f, 0.09350944f, -0.00680225f, 0.05517006f, 0.01871954f, -0.01719906f, 0.00639734f, -0.06016877f, 
    -0.00865093f, -0.01901763f, 0.01274209f, -0.00643463f, 0.00921913f, 0.02213174f, 0.00486210f, -0.01199691f, 
    0.02498638f, -0.02016412f, 0.01847119f, -0.00072125f, -0.02656570f, 0.01267218f, -0.00383267f, -0.02580959f, 
    0.02635564f, -0.01051288f, 0.03070708f, 0.01775574f, -0.01738791f, 0.01968281f, 0.01022027f, -0.01007564f, 
    -0.02673877f, 0.00688858f, -0.03476656f, 0.00093286f, -0.01699437f, 0.00310831f, 0.01809048f, -0.03230749f, 
    -0.00929693f, -0.00098968f, -0.00333142f, -0.00852047f, 0.00878397f, 0.03105702f, 0.03315503f, 0.01036108f, 
    0.02590648f, 0.02988328f, -0.03937186f, 0.02571294f, 0.02034258f, -0.02757135f, 0.01534098f, 0.01535477f, 
    -0.01269557f, -0.02121852f, 0.02753057f, 0.01829392f, -0.02375013f, -0.01637393f, 0.02733698f, -0.04203545f, 
    -0.00196245f, 0.03009246f, -0.01586436f, -0.01500294f, 0.01885173f, -0.02994530f, -0.01339330f, -0.04214123f, 
    -0.01074957f, 0.00265251f, 0.03327227f, -0.04160238f, -0.01852130f, -0.02626546f, 0.01462578f, 0.03150084f, 
    0.00621851f, 0.03201124f, -0.00986520f, 0.00832206f, -0.00153463f, -0.00251905f, 0.01987505f, 0.03081273f, 
    -0.00493301f, 0.00039173f, 0.02621224f, -0.03704984f, 0.03138503f, -0.02654721f, -0.04117965f, 0.01748215f, 
    -0.02232070f, 0.00238641f, 0.03182660f, -0.02676351f, -0.00774018f, 0.02718432f, -0.04114364f, -0.03600142f, 
    -0.01891522f, 0.01681731f, 0.03274363f, 0.01369388f, -0.03681684f, -0.00226691f, 0.02020441f, 0.01291500f, 
    -0.02294031f, -0.02209992f, 0.01163701f, 0.01880280f, 0.03242350f, 0.00716401f, -0.02451488f, -0.03284110f, 
    0.00234747f, -0.00141795f, -0.02656562f, -0.02739800f, -0.00905910f, -0.01247093f, 0.01604582f, 0.02440128f, 
    0.00256754f, 0.03332395f, -0.03924186f, -0.03699578f, 0.01314845f, -0.02142843f, 0.02839838f, -0.01028091f, 
    0.02941281f, 0.01850568f, -0.03337407f, -0.04124025f, 0.00053970f, -0.02040917f, 0.00675535f, 0.00047747f, 
    -0.04359313f, -0.02131077f, 0.01357405f, -0.00329777f, 0.01197465f, -0.00975225f, 0.00912952f, -0.01326679f, 
    0.03458201f, 0.03040817f, 0.00277077f, -0.00895513f, -0.03076220f, 0.00366847f, 0.00644228f, 0.00589257f, 
    -0.03200092f, -0.03942990f, 0.02611453f, 0.00307850f, 0.03439185f, 0.03294648f, -0.01473300f, -0.01163246f, 
    0.02071027f, -0.01264337f, -0.00934049f, 0.02078201f, -0.03026565f, -0.04268536f, 0.00663493f, -0.04540502f, 
    0.02310323f, 0.03380407f, -0.02658716f, 0.01388453f, 0.00875432f, -0.00528141f, -0.03806061f, -0.03576942f, 
    0.03052714f, -0.02420274f, -0.01644104f, 0.00088229f, 0.02208837f, 0.00841792f, 0.00092465f, -0.00311360f, 
    -0.01874129f, -0.02046736f, 0.00577795f, -0.02822763f, -0.04489416f, -0.03337782f, 0.03181911f, 0.03363531f, 
    -0.04510278f, -0.03460389f, -0.03592801f, -0.02705129f, -0.01324721f, -0.03027484f, -0.02326157f, 0.00575736f, 
    -0.00036135f, 0.02546397f, 0.02671732f, -0.00013833f, -0.01266469f, 0.03369651f, 0.00390411f, 0.01910942f, 
    0.01781117f, 0.01967994f, 0.02463235f, -0.03560626f, 0.00046778f, -0.03752866f, -0.02377493f, -0.00229120f, 
    -0.01825148f, 0.02146617f, -0.03542535f, 0.03228899f, 0.03041193f, 0.02994128f, -0.01600395f, -0.01485427f, 
    0.02672810f, -0.02089088f, 0.01033839f, 0.00960529f, -0.02294134f, -0.04265239f, -0.00678652f, 0.00428058f, 
    0.02995152f, -0.00180127f, -0.00605335f, -0.04056218f, -0.01617049f, -0.01586973f, -0.00149992f, -0.02848629f, 
    -0.01203538f, 0.02418492f, 0.00191895f, -0.01293854f, 0.03256257f, -0.03378820f, 0.01600529f, 0.02027604f, 
    -0.04433168f, 0.02910794f, 0.00613596f, 0.00882852f, -0.02239297f, -0.03897435f, 0.04481237f, -0.04253916f, 
    0.03948585f, -0.01362898f, 0.03056368f, 0.04415137f, -0.01297945f, 0.01371427f, -0.02038980f, 0.02828492f, 
    0.03608327f, 0.01476674f, -0.04195770f, -0.02251287f, 0.00574306f, -0.03224554f, 0.02118431f, 0.02969838f, 
    0.01679695f, -0.00554126f, -0.02408580f, -0.02389160f, 0.01979142f, 0.03222656f, -0.00687576f, -0.02697496f, 
    0.00783731f, -0.02718287f, -0.01508174f, -0.03064397f, 0.01886539f, 0.00239717f, -0.03217425f, -0.02848761f, 
    0.00408832f, -0.04187085f, -0.03692858f, -0.02623760f, -0.02664246f, 0.00310411f, 0.00851596f, -0.01216410f, 
    -0.00902847f, 0.01593954f, -0.04346696f, 0.04528253f, 0.02551190f, 0.02655857f, -0.01818556f, -0.01177423f, 
    0.00119100f, 0.00382505f, -0.01084194f, -0.03239869f, -0.01918786f, -0.01805486f, 0.00173618f, -0.03248908f, 
    -0.01692894f, 0.01285033f, -0.02326814f, -0.02913908f, 0.01578810f, 0.01048427f, 0.00302352f, -0.04529258f, 
    -0.01317624f, 0.02176250f, 0.01156149f, 0.01921318f, 0.03258248f, -0.02866020f, 0.02065626f, 0.02808880f, 
    0.02652737f, -0.03587437f, -0.01910207f, -0.00793411f, -0.02341385f, 0.02938039f, -0.04425357f, 0.02946862f, 
    -0.01468492f, -0.01646308f, -0.00138153f, -0.00352353f, 0.04028555f, 0.00985289f, 0.02150628f, 0.01061368f, 
    -0.04411583f, -0.02960481f, -0.00376296f, 0.00995565f, -0.03482096f, 0.02889032f, -0.01978668f, 0.02745388f, 
    -0.00973996f, -0.02016253f, -0.02222805f, 0.00775947f, -0.01380733f, 0.01104415f, 0.01117324f, 0.00155266f, 
    -0.04502970f, 0.01327665f, -0.03099820f, -0.03187039f, 0.01820485f, -0.00669211f, -0.01851384f, 0.02777346f, 
    0.01312781f, -0.00663929f, 0.03260757f, -0.02323331f, 0.02920821f, 0.02497408f, -0.03278057f, 0.02264423f, 
    0.01787745f, 0.01828184f, 0.04311077f, -0.00086104f, 0.02427099f, -0.04012899f, -0.02655299f, 0.03048360f, 
    0.00626983f, 0.01948854f, -0.03102451f, 0.00057159f, -0.00757131f, 0.03822670f, -0.04075415f, -0.03396524f, 
    -0.04410229f, -0.01821447f, -0.02274456f, -0.00198865f, -0.01815839f, -0.02993293f, -0.00862278f, 0.00772940f, 
    0.00719793f, 0.00784653f, -0.02040874f, 0.00398314f, -0.00084786f, -0.00270395f, 0.00913567f, 0.02260714f, 
    0.03326743f, -0.00834494f, 0.00497369f, 0.01324562f, 0.00667422f, -0.01963015f, -0.01621481f, -0.03338655f, 
    0.02687677f, -0.04091333f, -0.01839200f, -0.00430492f, -0.00013747f, -0.00114761f, 0.02068862f, -0.00642468f, 
    0.00141845f, -0.00203304f, 0.01195609f, 0.00984218f, -0.01784055f, -0.02891554f, -0.03115590f, -0.01018777f, 
    0.00267551f, -0.00901795f, 0.00033977f, -0.03266923f, 0.04259447f, 0.01989515f, 0.00900521f, -0.02814971f, 
    -0.01867567f, 0.02971180f, -0.00921567f, -0.02534426f, -0.01332643f, 0.03695257f, -0.01655873f, 0.01727910f, 
    -0.03556500f, 0.00236672f, 0.01322144f, -0.04408512f, -0.02081172f, -0.01205335f, -0.00180410f, 0.00776922f, 
    -0.00846865f, -0.01159584f, 0.01700420f, 0.00311413f, 0.02727735f, -0.03332829f, -0.00135829f, -0.02419858f, 
    -0.02759621f, 0.01712309f, 0.00516413f, -0.00660715f, 0.01960737f, 0.01889521f, -0.01420803f, -0.02005069f, 
    0.01648289f, 0.01613693f, -0.04215005f, -0.03011373f, 0.02505816f, 0.03308735f, -0.03683903f, 0.00933458f, 
    -0.04202683f, 0.02219705f, -0.03045538f, -0.03808584f, -0.00274327f, -0.02197980f, 0.01378357f, -0.00473939f, 
    0.00158604f, -0.03830341f, 0.02129198f, -0.01689053f, -0.02648058f, -0.01910689f, 0.01034916f, -0.03893937f, 
    0.02594616f, -0.01681331f, 0.01674032f, 0.03095759f, -0.01903517f, -0.01563651f, -0.00479858f, -0.03695321f, 
    -0.02013285f, -0.03838834f, 0.04341214f, -0.01975666f, 0.02545859f, -0.02808487f, -0.00497936f, -0.03714361f, 
    -0.01856461f, -0.04413680f, -0.01769980f, -0.03341080f, -0.04514790f, -0.04208068f, -0.03313305f, 0.01270843f, 
    -0.02194634f, -0.00114091f, -0.02882512f, 0.03248413f, -0.00900971f, 0.02945865f, 0.01145557f, -0.02014157f, 
    0.00400093f, -0.02945386f, -0.02664559f, -0.01497866f, -0.01607389f, -0.02535025f, -0.01864627f, -0.01568170f, 
    -0.04183558f, -0.00806280f, -0.01747465f, -0.04351953f, 0.04083458f, 0.00921582f, 0.01307194f, 0.02457268f, 
    -0.01015002f, -0.04206114f, 0.03548522f, 0.01968018f, -0.02761900f, -0.02404093f, -0.00630097f, -0.02972632f, 
    -0.04233070f, -0.03601557f, 0.00643716f, -0.02677097f, -0.03339575f, -0.01137172f, -0.03259952f, -0.01857508f, 
    0.02824132f, 0.01072964f, -0.02212429f, -0.02162970f, -0.02595193f, -0.00975900f, 0.00665194f, 0.02525482f, 
    0.03280498f, 0.01007800f, 0.01870119f, -0.04035458f, 0.03047586f, 0.02463565f, -0.01229466f, -0.00145364f, 
    -0.01952743f, -0.03223861f, 0.01613646f, -0.02562522f, -0.02878559f, 0.01730363f, -0.01546729f, -0.01900005f, 
    -0.01245086f, -0.03151402f, 0.02510285f, 0.00924302f, 0.03208598f, -0.00547573f, -0.01440229f, -0.00503569f, 
    0.00079765f, -0.02662860f, -0.02766407f, 0.01631968f, -0.03234024f, 0.00058149f, 0.02022417f, -0.01778724f, 
    0.01574113f, 0.00699627f, -0.00977069f, -0.02893495f, -0.00308283f, 0.02629464f, 0.03489720f, -0.01131591f, 
    0.01490812f, -0.01491506f, -0.00296549f, -0.00507574f, 0.03163766f, -0.01139157f, 0.00147437f, 0.00197924f, 
    -0.01236211f, -0.03625592f, 0.00529257f, -0.00534232f, 0.02782529f, -0.02216351f, -0.03687753f, 0.02752968f, 
    0.02977425f, 0.03867325f, -0.00547869f, 0.03109230f, 0.00703108f, -0.03857917f, -0.00928346f, 0.01420820f, 
    -0.03101171f, -0.04459845f, -0.03172274f, 0.00516843f, -0.00751718f, -0.01662193f, -0.03871355f, -0.02516549f, 
    0.02329242f, -0.00691118f, -0.01712253f, -0.02733532f, 0.02445963f, -0.04250496f, -0.03627268f, -0.01545362f, 
    -0.00614506f, 0.03245699f, 0.02393807f, 0.01941252f, -0.02559040f, -0.03319392f, 0.00334192f, -0.01091157f, 
    0.02061931f, 0.00592652f, -0.03775452f, -0.03943659f, -0.01181165f, -0.00378936f, -0.03199811f, 0.03629684f, 
    0.02608777f, -0.00338531f, 0.01734603f, 0.00946796f, -0.02864936f, 0.01720270f, 0.00186089f, -0.03727134f, 
    -0.01068247f, 0.01238368f, 0.01562038f, -0.01257694f, -0.00031689f, -0.01179122f, 0.01722065f, 0.02963687f, 
    -0.00110297f, -0.02993397f, 0.02259312f, 0.01010195f, -0.00179421f, 0.03305118f, -0.02501088f, -0.01476914f, 
    0.00288158f, 0.00920798f, 0.02462555f, 0.02086435f, 0.00627552f, -0.03501721f, 0.00823816f, -0.02753242f, 
    -0.00179781f, -0.04229904f, -0.03006517f, 0.01128132f, 0.02013157f, -0.04233960f, 0.01226744f, -0.03128708f, 
    -0.00188717f, 0.02917119f, 0.01345490f, -0.03753427f, -0.04395443f, 0.02635329f, 0.02589783f, 0.02954260f, 
    -0.01103524f, -0.01276933f, -0.00833181f, -0.00209222f, -0.02679822f, 0.02876908f, 0.02726240f, 0.02928029f, 
    -0.04205887f, 0.00075489f, 0.02266661f, 0.00752005f, 0.02505469f, 0.00982490f, 0.00255334f, -0.03956739f, 
    0.00456007f, 0.01787682f, -0.02746389f, 0.02943214f, 0.01848988f, -0.02232722f, 0.01796606f, -0.04197353f, 
    0.02565765f, 0.00128414f, 0.03206607f, -0.02817846f, 0.01608168f, -0.03667040f, 0.00360534f, -0.02019653f, 
    -0.00671485f, 0.02339669f, 0.01558586f, -0.04001452f, 0.02645662f, -0.01647434f, -0.02250686f, 0.01620353f, 
    0.02784225f, -0.04096454f, -0.00960230f, 0.01591786f, -0.03979209f, 0.02116017f, -0.02429999f, -0.00655376f, 
    0.00435084f, 0.01177344f, 0.00298730f, 0.01336584f, -0.03579565f, -0.04537669f, -0.03536209f, -0.04001114f, 
    0.00121583f, 0.02039959f, 0.00267811f, -0.04219000f, 0.02611615f, -0.00184300f, -0.02370278f, 0.00417515f, 
    -0.02510187f, 0.00903595f, -0.02935035f, -0.02010224f, -0.03861337f, -0.04089389f, 0.02593559f, -0.02349383f, 
    -0.00898579f, 0.02182555f, -0.00506351f, 0.02892631f, -0.01957357f, -0.03923277f, -0.04453694f, -0.00972660f, 
    -0.01329882f, -0.01164988f, 0.00437505f, -0.03203684f, -0.00474106f, 0.01874719f, 0.00769913f, 0.01070455f, 
    -0.04267536f, 0.01385522f, 0.03088753f, -0.01149277f, 0.00146736f, -0.00978669f, -0.02493932f, 0.02336056f, 
    -0.00299696f, 0.03028901f, 0.01879756f, 0.02193749f, -0.04299203f, -0.01104326f, -0.00220934f, 0.01160613f, 
    -0.01976561f, 0.02323230f, -0.01805521f, 0.00391555f, -0.00907140f, -0.04075377f, -0.02544869f, -0.02508769f, 
    0.02526838f, 0.00501161f, -0.02853903f, -0.00951052f, -0.01247950f, -0.03742843f, -0.03469368f, 0.02870346f, 
    -0.00507061f, -0.03499012f, -0.02867457f, 0.03301074f, 0.02802974f, 0.03002728f, 0.01143744f, -0.00127308f, 
    0.01487113f, -0.04224711f, 0.01316344f, 0.01945676f, 0.00161469f, 0.02910708f, 0.00574005f, -0.03455461f, 
    0.02957671f, -0.01613249f, 0.01941587f, 0.00699984f, -0.02951699f, -0.03000223f, 0.01230936f, -0.02866645f, 
    0.01373048f, 0.02711739f, -0.01889171f, -0.00487121f, -0.03538769f, 0.01586833f, -0.02838620f, 0.00814695f, 
    0.03030599f, -0.02394170f, 0.00642271f, 0.00778557f, -0.01563083f, 0.02897351f, 0.00000496f, -0.02441129f, 
    -0.03995492f, 0.00746623f, -0.00176249f, -0.01539517f, -0.03233851f, 0.02837871f, -0.01564322f, -0.03028446f, 
    -0.00129542f, 0.00191621f, -0.01173954f, -0.00903355f, -0.01468999f, 0.01459947f, 0.01084876f, 0.00337435f, 
    -0.02597237f, -0.00601633f, -0.04029070f, -0.02917069f, -0.01810635f, -0.02307799f, -0.02471525f, -0.01577437f, 
    -0.04270821f, 0.00706022f, 0.02113862f, 0.02743158f, -0.03136196f, -0.02579437f, -0.02777427f, -0.01671267f, 
    -0.03250431f, -0.03971298f, -0.02527507f, 0.02624090f, 0.01490254f, -0.01046366f, -0.03618832f, -0.00877114f, 
    -0.02008860f, 0.02415586f, 0.00693592f, 0.00350359f, -0.01882820f, 0.03048857f, -0.01846688f, 0.00896139f, 
    -0.01861145f, -0.01001213f, 0.00908297f, 0.01737286f, 0.00863257f, 0.03149661f, -0.01576578f, -0.00288367f, 
    0.01543636f, 0.01980894f, 0.00950674f, 0.01454762f, -0.00660933f, -0.00578103f, 0.02357522f, -0.03137392f, 
    -0.01729697f, -0.03908972f, -0.00711740f, -0.01066679f, -0.02685137f, 0.02535199f, 0.00671793f, 0.00540894f, 
    -0.02558551f, -0.00039220f, -0.01020698f, -0.01317836f, -0.03112588f, -0.02401488f, 0.00588162f, 0.00805233f, 
    -0.03891421f, -0.00844893f, 0.01150960f, -0.03617387f, 0.00626512f, 0.03162203f, 0.00433024f, 0.01876976f, 
    0.03012969f, -0.03684733f, -0.02821968f, -0.01030300f, -0.00445719f, -0.01934712f, 0.02552937f, -0.04456575f, 
    -0.03410602f, -0.02132393f, 0.02305788f, -0.01623991f, 0.00895622f, -0.00520216f, -0.03719026f, 0.02301219f, 
    -0.00611374f, 0.03024450f, 0.01829915f, 0.00199908f, -0.02048311f, -0.01459013f, 0.00299556f, 0.00366016f, 
    0.02851554f, 0.03180260f, 0.02677240f, -0.04467534f, -0.02233990f, -0.00403352f, -0.00194688f, 0.02393295f, 
    0.00286241f, 0.01395013f, -0.02855258f, -0.03008303f, 0.02499876f, 0.01057153f, -0.04327345f, -0.02567069f, 
    0.02931752f, -0.00903787f, -0.03491697f, -0.01516322f, 0.01337394f, 0.02801643f, 0.02633247f, 0.01257511f, 
    0.01867431f, -0.01408321f, -0.02466667f, -0.04201014f, -0.00171247f, 0.00623518f, 0.01820529f, -0.02244394f, 
    -0.01598323f, 0.01580195f, -0.01239627f, 0.01169586f, -0.01307948f, 0.00882182f, -0.03605413f, -0.02684249f, 
    -0.02497836f, 0.02083033f, -0.03583170f, 0.00881269f, 0.00115569f, -0.02497252f, 0.00271634f, -0.02299584f, 
    -0.03313244f, 0.00317287f, -0.02530023f, -0.00427891f, -0.04077343f, -0.04037812f, -0.00527241f, -0.00692446f, 
    0.03254000f, 0.02524288f, 0.02390878f, -0.02430426f, -0.04018797f, -0.00173679f, -0.04117149f, 0.00149850f, 
    0.02405983f, -0.03234106f, -0.01328185f, -0.00442938f, -0.01326585f, 0.01864040f, 0.02586574f, -0.04074154f, 
    0.00823027f, -0.03943760f, 0.01959635f, -0.03653709f, -0.00626561f, -0.01026538f, -0.00228821f, 0.00644197f, 
    -0.03252462f, 0.01567638f, 0.00162243f, -0.02282993f, -0.02620510f, -0.04303043f, -0.03675877f, -0.03918739f, 
    0.03312603f, 0.01783804f, -0.01595495f, 0.01986700f, 0.00391020f, -0.00441760f, -0.00020736f, -0.03611466f, 
    -0.03133376f, 0.00150739f, -0.03466741f, -0.02555485f, 0.02738126f, 0.01543825f, -0.01993747f, -0.01775873f, 
    -0.02840554f, -0.00693886f, 0.01345953f, 0.02347656f, -0.03230392f, -0.03728585f, 0.02173812f, -0.03129586f, 
    -0.01337910f, 0.00991851f, 0.00859723f, 0.02997054f, 0.02539780f, -0.00361158f, 0.02975627f, 0.03292583f, 
    -0.03863559f, 0.02319094f, -0.04450319f, 0.02976516f, 0.00525010f, -0.03597216f, -0.01913646f, -0.00747249f, 
    -0.03138803f, 0.02231949f, -0.02701547f, 0.01699096f, -0.00780119f, -0.01395080f, -0.04133622f, -0.01248354f, 
    -0.01612933f, -0.00972348f, -0.04029424f, 0.02728874f, 0.01323467f, -0.02190397f, -0.03019897f, -0.03862713f, 
    -0.03093250f, -0.03513798f, 0.01084307f, 0.02308712f, 0.02605479f, -0.02514551f, 0.02796490f, -0.03861794f, 
    -0.02991094f, -0.00534508f, 0.00891028f, 0.01813417f, -0.01174198f, -0.03582126f, -0.01945166f, 0.02678017f, 
    0.01722137f, 0.00608580f, 0.00042916f, -0.04221013f, -0.02956058f, -0.02943779f, 0.01988271f, -0.02948161f, 
    -0.00524641f, -0.00274339f, -0.01381602f, -0.03530118f, -0.01065878f, 0.00015076f, -0.02836003f, 0.02912736f, 
    0.02005986f, -0.02482071f, -0.01470562f, 0.00613783f, 0.02201001f, 0.00922650f, -0.01967310f, -0.03377325f, 
    -0.00050832f, -0.03875647f, -0.02263203f, -0.02999958f, -0.03119802f, 0.00512969f, -0.01972197f, -0.02377205f, 
    0.00820260f, -0.00306285f, 0.01830223f, 0.03117167f, -0.01553796f, -0.02078633f, -0.03868179f, -0.01703852f, 
    -0.02328541f, 0.01241038f, 0.02274580f, -0.03371794f, 0.02707051f, 0.01839466f, -0.01941718f, 0.00418676f, 
    0.03157898f, -0.00475790f, 0.02012876f, -0.00460352f, 0.02068351f, -0.04479463f, 0.02366986f, 0.00570441f, 
    0.00850500f, -0.02291939f, 0.01807599f, 0.00932813f, 0.02773523f, -0.00871111f, -0.02337120f, -0.01512987f, 
    -0.01985441f, -0.01937831f, 0.00535814f, -0.03944724f, 0.02123934f, -0.01539252f, -0.02434159f, -0.04039330f, 
    -0.00996824f, -0.03857717f, -0.01806356f, -0.03003910f, -0.00673335f, -0.02718783f, -0.00629520f, 0.00372859f, 
    -0.01822143f, 0.01681980f, 0.00870411f, 0.00649013f, -0.00187415f, -0.02540447f, -0.02158449f, 0.01264097f, 
    0.01303870f, 0.02511582f, 0.02772830f, -0.02246120f, 0.02529656f, 0.02874413f, 0.00502696f, -0.04258217f, 
    -0.01832086f, 0.03193774f, -0.01574560f, -0.03060654f, 0.01235423f, 0.02698618f, 0.00190196f, 0.00368961f, 
    -0.02472583f, 0.01905215f, 0.00397736f, -0.04245833f, -0.04189748f, -0.00326417f, -0.03894233f, 0.01814215f, 
    0.00859372f, -0.01559260f, 0.00706637f, 0.00564208f, -0.04456851f, -0.02638365f, -0.03236969f, -0.03873881f, 
    0.00517922f, 0.03074174f, -0.03223335f, 0.00294220f, -0.00119183f, -0.03008511f, -0.02611710f, 0.03186309f, 
    -0.01660590f, -0.03151372f, -0.02072390f, 0.00267583f, -0.02723614f, -0.03709316f, 0.00065748f, 0.02601379f, 
    0.06231441f, 0.01827815f, -0.23443224f, 0.19692685f, 0.25348037f, 0.01981467f, -0.02952977f, 0.03273873f, 
    -0.00843280f, -0.08254967f, 0.12255947f, 0.01844954f, 0.03124466f, 0.00654925f, -0.11314463f, 0.04819089f, 
    0.02177465f, -0.15721874f, 0.00542293f, -0.03208288f, 0.04595243f, 0.17152779f, 0.00476005f, -0.03694825f, 
    0.20119563f, -0.03237961f, -0.02903412f, -0.01742443f, 0.10911518f, -0.02033327f, -0.16576537f, 0.10277729f, 
    0.09496965f, 0.03344069f, 0.02053227f, 0.04245080f, -0.04787199f, -0.15981559f, -0.08257247f, -0.01834469f, 
    0.49164805f, -0.01688348f, -0.21647473f, -0.00265707f, -0.37056011f, -0.02280157f, -0.11191271f, 0.08027310f, 
    -0.05855038f, -0.06863253f, -0.09737666f, 0.03036215f, -0.01177505f, -0.05525835f, 0.04556515f, -0.10678870f, 
    0.00679893f, -0.03645116f, -0.13346221f, -0.12157483f, 0.02628190f, 0.15940075f, -0.07605509f, 0.29448760f, 
    0.11684062f, -0.02866900f, -0.03144420f, -0.01386079f, -0.13325645f, 0.03475271f, -0.02528329f, -0.07835484f, 
    0.01928652f, -0.04642863f, -0.04244968f, 0.05488609f, -0.05814214f, -0.00360250f, -0.02860791f, 0.00083360f, 
    0.15739135f, -0.14703007f, -0.01775938f, -0.19911565f, 0.16387258f, 0.04601430f, 0.00023561f, -0.03135373f, 
    0.06321400f, 0.06585409f, 0.02344755f, 0.03389884f, 0.05258994f, 0.01310256f, -0.13646391f, -0.05270761f, 
    -0.00423350f, -0.08383097f, -0.02259509f, 0.07235248f, -0.20865013f, -0.01594025f, 0.21874531f, -0.07621764f, 
    -0.08221774f, -0.05848084f, 0.03078801f, -0.04891780f, 0.05255101f, -0.05897589f, -0.05843379f, -0.17689197f, 
    -0.14070615f, 0.07278715f, -0.06303854f, -0.00807892f, -0.05585793f, 0.02220181f, 0.14831851f, 0.00156652f, 
    0.24564859f, 0.50580037f, -0.12122851f, -0.12768897f, 0.10543133f, -0.18546036f, 0.10298219f, 0.16598198f, 
    0.03248489f, -0.01024296f, -0.03338785f, 0.05140072f, 0.05124773f, 0.05286292f, -0.06462525f, 0.07943544f, 
    0.07449861f, -0.12882118f, 0.09861200f, 0.02579715f, 0.16758324f, 0.20017157f, 0.20427936f, 0.29455891f, 
    -0.02521424f, -0.03904410f, -0.03060366f, 0.00471492f, 0.00257251f, 0.10681253f, -0.00236954f, 0.03635037f, 
    0.07666697f, 0.08571056f, -0.07870990f, 0.05055819f, 0.00731554f, 0.00662734f, 0.11575522f, -0.16011356f, 
    0.21372929f, -0.25835219f, 0.22789989f, 0.18914087f, -0.19866262f, -0.01513591f, -0.01717537f, 0.05696069f, 
    -0.09366897f, -0.04037423f, -0.13711219f, -0.06137889f, -0.02477351f, 0.05143917f, -0.03512630f, -0.17748781f, 
    -0.09847411f, 0.00818875f, -0.04238275f, -0.06264255f, 0.27027079f, -0.14835975f, 0.05812805f, 0.01844992f, 
    -0.08295485f, 0.01715031f, 0.06763913f, 0.00049752f, 0.12899938f, 0.11279526f, -0.02775286f, -0.03900853f, 
    0.09794784f, -0.03913502f, 0.01157094f, -0.12364827f, -0.08998645f, -0.12605655f, -0.02102613f, -0.06258555f, 
    -0.14946274f, -0.12355326f, -0.05196674f, 0.18629138f, 0.12296198f, 0.16298375f, -0.01257293f, -0.04926899f, 
    0.10153980f, -0.06373875f, 0.20235942f, 0.15867867f, 0.04994609f, -0.01918782f, 0.21338093f, -0.01262349f, 
    -0.04056560f, 0.10943235f, -0.03487884f, 0.07614531f, -0.20270750f, 0.10241549f, -0.07795319f, -0.27987605f, 
    -0.02128842f, 0.16710874f, -0.14678890f, -0.03198114f, 0.01867246f, -0.04731159f, 0.07941939f, 0.05102174f, 
    -0.10268546f, 0.01418131f, -0.00556208f, -0.01889782f, 0.07713736f, -0.03858368f, -0.03539492f, -0.01088926f, 
    0.14333521f, 0.43163615f, 0.06859328f, 0.06665839f, -0.00924880f, -0.04953304f, -0.02433474f, -0.01736866f, 
    -0.05364779f, -0.08214706f, 0.04194449f, 0.02562371f, -0.04161754f, 0.00011537f, -0.04376044f, 0.04043165f, 
    0.09920035f, 0.09302104f, 0.14983234f, 0.04899987f, 0.08819892f, 0.20189412f, 0.00349390f, 0.06385556f, 
    0.00226056f, -0.05728225f, -0.10725536f, 0.06630328f, 0.02991943f, -0.04173975f, 0.06941259f, -0.00859052f, 
    -0.03914050f, 0.05923279f, -0.00578398f, 0.04411323f, 0.00001831f, 0.03685927f, 0.08882149f, -0.10928331f, 
    0.03191966f, 0.02228347f, 0.16393586f, 0.04374387f, -0.08975229f, -0.13315225f, -0.11098945f, -0.07798777f, 
    -0.02753844f, 0.02592666f, -0.15288310f, 0.03466595f, 0.16946173f, 0.13091369f, 0.02049707f, -0.01311241f, 
    -0.00913420f, 0.22770682f, 0.15164721f, -0.07903682f, 0.10131541f, 0.26126495f, -0.01440719f, -0.24249662f, 
    -0.23415098f, 0.25073537f, 0.10735580f, -0.07822891f, 0.02843374f, 0.01411402f, 0.06346904f, -0.16067304f, 
    0.06266038f, 0.00182803f, -0.02765973f, 0.17350452f, -0.08633868f, 0.03763073f, 0.00669876f, -0.19712590f, 
    0.50271016f, 0.20178619f, -0.23609616f, -0.15977396f, -0.14306298f, -0.05160538f, 0.00080132f, -0.08098680f, 
    -0.04611555f, -0.04732938f, -0.00780146f, 0.10670599f, 0.01397658f, -0.13242406f, 0.16394709f, -0.09329428f, 
    0.11879243f, 0.09594930f, -0.03355993f, 0.03256956f, 0.41746458f, 0.25119868f, -0.12821101f, -0.09089968f, 
    0.18527271f, 0.01057588f, -0.06389138f, 0.16267584f, 0.07555756f, -0.01622049f, 0.11268318f, -0.04774546f, 
    0.06104264f, 0.01640639f, 0.03979801f, 0.01457947f, 0.10148262f, -0.06412868f, -0.13889143f, 0.01505361f, 
    0.43775964f, -0.08249629f, -0.30330694f, -0.10229542f, 0.27473283f, 0.04084983f, 0.00109338f, 0.04917253f, 
    0.08545319f, -0.01797145f, 0.29562998f, 0.08686305f, -0.10559978f, -0.03806959f, -0.00360266f, 0.17162350f, 
    0.07705347f, 0.03670290f, 0.06659266f, 0.15882446f, 0.04609950f, 0.05765495f, -0.08712004f, -0.02588225f, 
    0.35922316f, 0.11721357f, -0.00108645f, -0.05455770f, -0.00957998f, -0.02678469f, -0.01005684f, 0.02046730f, 
    -0.04392157f, 0.01693193f, -0.09420352f, -0.01562544f, -0.00773201f, -0.02459636f, -0.04984673f, -0.01288847f, 
    -0.38628241f, -0.02109641f, -0.14083827f, -0.23566560f, -0.03874120f, 0.02446463f, -0.07380687f, -0.01297981f, 
    0.05253385f, 0.07062346f, 0.17076364f, 0.04934425f, 0.05086302f, 0.03272479f, 0.00319472f, 0.01349715f, 
    0.01073831f, 0.02440447f, 0.00346074f, -0.09588579f, -0.22138046f, -0.14027901f, -0.07473519f, 0.10288682f, 
    -0.06113704f, 0.04758261f, 0.05574026f, -0.03405495f, -0.01704479f, -0.09104951f, 0.08109690f, 0.01752935f, 
    0.01571317f, -0.02343702f, -0.02506482f, -0.02276115f, -0.23306680f, 0.13328761f, 0.08991393f, 0.04022995f, 
    -0.28026015f, 0.10555161f, 0.03494587f, 0.07306699f, -0.00074425f, 0.16530700f, 0.03115464f, -0.03650507f, 
    0.06871232f, 0.08642210f, -0.09056902f, -0.12458839f, -0.02213275f, 0.02233944f, -0.05905672f, -0.05329682f, 
    -0.03345457f, -0.06525660f, 0.06193986f, -0.04690918f, 0.09113874f, 0.23678648f, 0.20738222f, 0.10827191f, 
    0.06969020f, 0.07884014f, 0.04329423f, -0.00617258f, -0.08579052f, 0.13630149f, 0.03846798f, -0.08144537f, 
    0.07672182f, 0.04939188f, 0.02025585f, 0.12688157f, 0.00824571f, 0.07337228f, -0.06548753f, -0.17281300f, 
    0.22696136f, -0.07177453f, -0.24925078f, 0.08789442f, 0.30833480f, 0.01497895f, -0.02101818f, -0.02052942f, 
    -0.05838868f, -0.05790011f, 0.16285741f, 0.11049723f, -0.00575844f, -0.08056977f, 0.01612371f, -0.07640816f, 
    0.14070812f, -0.06984875f, -0.00188693f, -0.08486101f, 0.23261866f, -0.05485153f, 0.21755329f, -0.04895046f, 
    0.01146048f, -0.12470836f, 0.04557817f, -0.00080091f, 0.13123465f, -0.04479595f, -0.02370857f, -0.14659634f, 
    -0.14838384f, 0.09665477f, 0.01627431f, -0.06078440f, -0.04216081f, 0.03379423f, 0.01165355f, 0.08360826f, 
    0.27079391f, -0.10167738f, -0.23510408f, -0.05396356f, 0.35947824f, -0.11662778f, 0.05858778f, 0.00352416f, 
    0.06380615f, -0.05912240f, 0.19696076f, 0.04947410f, 0.03575530f, -0.01654062f, -0.02974409f, 0.08701383f, 
    0.02880081f, 0.04558236f, 0.03744156f, 0.18183844f, -0.01587806f, -0.05709595f, 0.02660879f, 0.05520631f, 
    0.13533019f, -0.09960895f, 0.07700826f, -0.03274507f, 0.09289130f, -0.23457238f, -0.06555659f, 0.01886750f, 
    0.09317536f, 0.11378240f, 0.02538955f, -0.09284629f, -0.00100011f, -0.07513396f, -0.00684308f, 0.10152414f, 
    -0.03843821f, 0.17334014f, -0.05142059f, -0.04702832f, 0.18362020f, 0.03500762f, -0.00522483f, 0.03996595f, 
    -0.07442662f, -0.02072620f, 0.01881876f, 0.10857056f, -0.03426915f, -0.05024341f, -0.05797322f, -0.05925799f, 
    0.13885581f, 0.09671503f, 0.08625156f, -0.00234563f, 0.04154935f, 0.23993120f, 0.06732263f, 0.08264657f, 
    -0.00014979f, -0.09265804f, -0.04042979f, -0.01018406f, 0.09449055f, -0.07794131f, 0.06010494f, 0.12087856f, 
    0.01428713f, 0.04330526f, 0.03914205f, 0.09391979f, 0.07020495f, 0.00072838f, 0.05023771f, -0.07648917f, 
    0.12536892f, 0.31514850f, 0.20808671f, 0.04752375f, 0.05375122f, -0.04272459f, 0.06743164f, -0.00457627f, 
    -0.11213518f, 0.00078380f, 0.06417856f, -0.04783536f, 0.02762644f, -0.01385826f, -0.06608751f, 0.04975747f, 
    -0.11408657f, -0.04584280f, 0.00445769f, -0.09460549f, -0.32612577f, -0.07759416f, 0.33793044f, 0.20933785f, 
    0.09855424f, 0.00676124f, -0.05471366f, -0.06360255f, 0.01735644f, 0.15315443f, -0.01157494f, 0.06879922f, 
    0.03778210f, 0.07868359f, 0.06994336f, 0.05666983f, 0.04793330f, 0.06359263f, 0.03022240f, 0.06803846f, 
    -0.17637815f, -0.13465826f, 0.11497527f, -0.00247596f, 0.05325048f, 0.09217533f, 0.05667349f, 0.01523659f, 
    -0.06306256f, -0.05387273f, -0.01968142f, 0.00905303f, 0.03764478f, -0.00565937f, 0.01302792f, 0.06498998f, 
    -0.02065379f, -0.05789067f, 0.11708573f, -0.01842411f, 0.37048149f, 0.04250018f, -0.12978211f, 0.03910010f, 
    0.01929710f, 0.08668076f, -0.05310957f, 0.02472842f, -0.01237782f, -0.00673518f, -0.02306092f, -0.06085385f, 
    -0.02895052f, 0.02515092f, -0.05717131f, -0.11484291f, 0.02938438f, -0.04765671f, 0.07239141f, 0.03969732f, 
    -0.26511660f, 0.50268137f, -0.16542953f, 0.09795912f, -0.09217537f, -0.02840360f, 0.11259168f, -0.04213436f, 
    0.10045557f, -0.06457496f, 0.09141897f, -0.05228527f, 0.06075829f, 0.01701402f, 0.03658675f, 0.15300609f, 
    0.05815945f, 0.12718974f, 0.11409509f, 0.09109703f, -0.24267791f, 0.18993436f, 0.13608298f, 0.19757476f, 
    0.17361033f, -0.02726471f, -0.03609492f, 0.07697785f, 0.10325459f, -0.05530875f, -0.05300777f, 0.03091616f, 
    -0.07624489f, -0.01396042f, 0.15282291f, -0.04438905f, -0.00900467f, 0.05247102f, 0.07446434f, 0.08432569f, 
    -0.06241863f, 0.14955130f, -0.19233333f, -0.06834140f, 0.01376546f, 0.06724378f, 0.03221449f, -0.11161610f, 
    0.03890521f, -0.16146955f, 0.13599278f, 0.03627926f, -0.03754906f, -0.01779655f, 0.00434394f, -0.07838573f, 
    -0.07551293f, -0.06028948f, -0.05156602f, -0.01835275f, 0.37140599f, -0.24569543f, 0.16486852f, -0.20121518f, 
    0.12639780f, 0.03067787f, 0.00578846f, -0.01336091f, -0.13683413f, 0.08742343f, 0.06938079f, 0.05745366f, 
    0.00558783f, -0.02303208f, -0.13350508f, 0.01178049f, -0.06737778f, 0.04140683f, 0.02977255f, 0.03370871f, 
    0.71136904f, 0.05320068f, -0.04080620f, 0.00174130f, -0.03015869f, 0.09459656f, -0.01478231f, 0.07779323f, 
    0.10908923f, -0.00589485f, 0.00963899f, -0.03895384f, -0.10760203f, 0.03502272f, 0.05042730f, 0.01575903f, 
    0.04705820f, -0.09316929f, 0.00180586f, 0.05107447f, 0.18684085f, 0.11249443f, 0.13806008f, 0.11897760f, 
    0.10525361f, -0.01104763f, 0.08320331f, -0.10523876f, -0.04743905f, -0.09127227f, -0.02359994f, 0.01858260f, 
    -0.03190529f, 0.08468500f, 0.11233050f, -0.06528807f, 0.06537765f, 0.09756482f, -0.04922472f, 0.06342665f, 
    -0.34521157f, 0.40203536f, 0.21153286f, 0.16512939f, 0.12420113f, 0.00179175f, -0.09080914f, 0.03903091f, 
    0.00293453f, 0.12013465f, -0.08023826f, -0.04652200f, -0.00004052f, 0.07153194f, 0.03090346f, 0.11597063f, 
    -0.15245911f, 0.18721315f, 0.02170413f, 0.01815097f, -0.15370457f, 0.01681333f, -0.16753034f, -0.05852883f, 
    -0.11794489f, 0.05527902f, 0.06415034f, -0.04047260f, -0.02071488f, -0.06943992f, 0.03732055f, -0.09261350f, 
    0.03491897f, -0.02105734f, -0.03761965f, 0.01727526f, -0.07685359f, -0.05286200f, 0.03524349f, -0.03926582f, 
    -0.14226374f, -0.09264427f, -0.05083854f, 0.05339917f, -0.07652692f, 0.03817572f, 0.16318838f, -0.04748293f, 
    0.06737154f, 0.00939470f, -0.07493784f, 0.04602612f, 0.05410722f, -0.01095163f, -0.02710340f, -0.03685308f, 
    0.01997680f, 0.08340342f, 0.10973377f, 0.02852594f, -0.18975577f, 0.45686391f, -0.20218997f, -0.06568482f, 
    0.04835928f, 0.04160521f, 0.07371079f, -0.06683175f, -0.01045952f, -0.15820044f, -0.08370324f, -0.05866903f, 
    -0.06575677f, 0.10737033f, -0.04190907f, 0.00739163f, -0.05161855f, 0.00642624f, -0.08376313f, 0.03952396f, 
    -0.19675228f, 0.46847752f, 0.01625309f, 0.04272788f, -0.28604797f, -0.02551218f, 0.08887337f, -0.01113973f, 
    0.08035313f, -0.10412138f, 0.07440878f, -0.05060977f, 0.02706856f, -0.05042568f, 0.00245146f, 0.16837513f, 
    0.07296127f, 0.08955459f, 0.07035705f, 0.09448159f, 0.17177817f, -0.04537303f, 0.06297893f, 0.18330269f, 
    -0.05723007f, -0.05456756f, 0.01485873f, -0.02146681f, 0.03913770f, -0.03766086f, -0.07928184f, 0.06203204f, 
    -0.03961441f, -0.01982576f, 0.07519428f, 0.05844075f, -0.06471744f, 0.04725820f, -0.00856544f, 0.06679703f, 
    -0.06434347f, -0.08304794f, 0.31571206f, 0.25891998f, 0.21569456f, -0.04318629f, 0.01659829f, -0.07351316f, 
    0.00826416f, 0.03079937f, 0.04260331f, -0.06401315f, 0.06884369f, 0.15208904f, 0.01624703f, -0.01315669f, 
    -0.00126208f, 0.01801310f, 0.15516196f, -0.06134995f, -0.10269336f, -0.00964412f, 0.17858212f, -0.05971095f, 
    -0.10636006f, 0.08072656f, 0.06915957f, -0.07321898f, 0.01247178f, -0.03601608f, 0.03303915f, 0.13549383f, 
    -0.02374092f, 0.10599168f, 0.00884393f, -0.02187268f, 0.00161210f, 0.12926264f, 0.03460921f, 0.15910569f, 
    -0.34489441f, -0.05932776f, 0.00904759f, 0.02356264f, -0.21831675f, 0.02186959f, 0.15178095f, 0.01667996f, 
    0.02260497f, 0.03017802f, 0.07440493f, 0.11062864f, 0.02876767f, -0.06788671f, -0.07228505f, 0.01914098f, 
    0.01197218f, 0.09262119f, 0.14225222f, 0.00545451f, -0.32321572f, -0.19378760f, 0.06804906f, -0.00679245f, 
    -0.06443750f, 0.21623136f, 0.10298730f, -0.07267822f, -0.05221889f, -0.04786924f, -0.03810683f, 0.01582299f, 
    -0.01906900f, -0.05277885f, 0.00695707f, 0.12481460f, -0.03868068f, -0.06394544f, 0.07184885f, -0.00490118f, 
    -0.41758239f, -0.33722809f, 0.08276820f, -0.05591014f, 0.04240904f, 0.14764525f, 0.05491536f, 0.01421789f, 
    -0.10434072f, -0.02766298f, 0.02633183f, 0.06994020f, -0.00914648f, -0.19686507f, 0.08484445f, -0.12796815f, 
    0.05975660f, 0.05227382f, 0.03736285f, -0.02505582f, -0.15033627f, 0.22307798f, 0.01192605f, -0.22911470f, 
    -0.18689665f, -0.14978209f, 0.08215874f, -0.04242093f, -0.01130770f, 0.00740505f, -0.01231406f, -0.05704959f, 
    0.05100069f, 0.03365894f, 0.05278013f, 0.02474610f, 0.08803543f, 0.05539986f, 0.11744889f, 0.07452374f, 
    0.14325260f, -0.04878351f, -0.00087329f, -0.17963693f, 0.00362821f, 0.04714001f, 0.06040158f, -0.01225199f, 
    0.02406040f, -0.17676570f, -0.01462588f, -0.10146452f, 0.08249795f, 0.04719418f, 0.09475229f, -0.04865533f, 
    0.08218644f, -0.03481415f, 0.02172568f, -0.04601918f, 0.06498748f, 0.17135251f, 0.06656963f, -0.11185613f, 
    -0.12417196f, -0.04607996f, 0.14767289f, -0.01182100f, -0.10714352f, -0.01678937f, 0.12906609f, 0.04632115f, 
    -0.09502403f, -0.16633271f, -0.04748477f, -0.10105415f, -0.06714144f, 0.14703299f, 0.02332163f, 0.18282239f, 
    0.33498833f, -0.12944776f, 0.01901505f, 0.15902987f, 0.08481175f, -0.01868635f, -0.17813176f, 0.10506660f, 
    0.01473822f, 0.12283380f, -0.11488686f, 0.00728983f, 0.04890670f, -0.01171608f, -0.05849215f, 0.04277662f, 
    0.00286408f, -0.00844383f, 0.13243924f, 0.03144043f, 0.11352856f, 0.04697943f, 0.21477878f, 0.04997321f, 
    0.11673126f, 0.04778860f, 0.12335724f, -0.07030783f, 0.00018616f, 0.03282594f, -0.00712294f, 0.01860726f, 
    0.00713173f, 0.10486413f, -0.03720131f, -0.15067832f, 0.03290286f, 0.00974024f, 0.13498463f, 0.00453564f, 
    -0.40099865f, -0.16905187f, 0.02504000f, -0.01292927f, -0.06547333f, -0.02262844f, 0.21396701f, 0.04511393f, 
    -0.04737025f, -0.05017042f, -0.01981977f, -0.02704699f, -0.05387010f, -0.03484307f, -0.07283801f, -0.02983725f, 
    -0.02273420f, -0.01081441f, 0.08713119f, 0.04268507f, 0.06021734f, -0.12235371f, 0.14898093f, -0.06934092f, 
    0.08034681f, 0.04523459f, -0.06792994f, -0.00378754f, 0.11174392f, 0.02623086f, 0.06773137f, 0.02155789f, 
    -0.02854986f, 0.05575689f, -0.01113977f, -0.00473553f, -0.10252179f, -0.10196655f, 0.04115954f, 0.01062042f, 
    -0.41200501f, -0.23405917f, -0.01300445f, -0.03639574f, -0.00461141f, 0.13826105f, 0.10980203f, -0.03453951f, 
    0.00131374f, -0.02850437f, -0.03561019f, 0.14912809f, 0.04173600f, -0.02327552f, -0.12626170f, -0.06647267f, 
    0.05446521f, 0.01409809f, 0.01276621f, 0.00309870f, 0.11663179f, -0.07858206f, 0.07143334f, 0.06633044f, 
    0.28934735f, -0.08908639f, 0.03637654f, -0.08641151f, -0.00752249f, 0.09338912f, -0.04176670f, -0.06992444f, 
    0.03719022f, 0.06231483f, -0.07429294f, -0.06714785f, 0.09568734f, 0.01564188f, -0.01767972f, -0.04318474f, 
    -0.01962824f, 0.18173537f, 0.00581320f, -0.00945534f, -0.17976888f, -0.01003947f, 0.07481869f, -0.07176786f, 
    -0.00895334f, -0.07260627f, -0.00012452f, -0.02801187f, -0.10144130f, -0.08642296f, 0.03244808f, -0.04880442f, 
    0.19090138f, 0.04951264f, 0.02089969f, 0.06695835f, 0.18472511f, 0.16832890f, 0.07516656f, 0.18168254f, 
    -0.12464058f, -0.03210437f, 0.12808706f, -0.06796104f, 0.02266945f, -0.00802732f, 0.00622077f, 0.11133184f, 
    -0.06403083f, -0.09867951f, 0.04914419f, 0.02709766f, 0.00065909f, -0.02219475f, 0.03924328f, 0.04783307f, 
    0.15863600f, -0.09431626f, 0.23716807f, 0.07230438f, 0.19877721f, -0.02885170f, 0.05748421f, -0.10625771f, 
    -0.05982010f, -0.01318901f, 0.00599233f, 0.08191517f, 0.06815930f, 0.04933580f, 0.03857410f, -0.06515970f, 
    -0.09294598f, 0.01836001f, -0.02355182f, -0.03562238f, -0.14807962f, -0.02360723f, 0.23521230f, 0.11809058f, 
    0.41416174f, -0.03666961f, -0.08576903f, 0.04501920f, 0.06541948f, 0.09554381f, 0.02660292f, -0.08439181f, 
    -0.02899878f, -0.03575891f, 0.13389090f, -0.01875536f, -0.01603606f, 0.03069139f, 0.12591048f, -0.01331513f, 
    -0.01393962f, -0.00433274f, -0.03647352f, -0.00652467f, 0.01986121f, -0.00514131f, -0.00945322f, -0.03552853f, 
    0.03062547f, 0.03222495f, -0.03614496f, -0.04409380f, 0.02921506f, 0.01453184f, 0.02885736f, 0.03403410f, 
    0.00649083f, 0.02895855f, 0.03397202f, -0.02709262f, -0.00804310f, -0.01657169f, 0.03971499f, -0.00682889f, 
    0.01429107f, -0.01784697f, 0.00935916f, -0.02085513f, -0.02912428f, -0.00464117f, -0.03696698f, -0.00016545f, 
    0.02407435f, -0.00332994f, 0.01069679f, -0.03550837f, -0.04124343f, -0.03995189f, -0.03747482f, -0.00989096f, 
    -0.00655601f, 0.03095265f, 0.02201002f, 0.00719216f, 0.01561306f, -0.02770360f, -0.04127689f, -0.00345609f, 
    0.01370198f, 0.01085562f, -0.00735741f, 0.02950616f, 0.01938208f, 0.01054800f, 0.01290475f, -0.00902664f, 
    -0.02741313f, -0.00347824f, 0.00627857f, -0.00615154f, 0.02077379f, -0.02674891f, -0.00428412f, -0.00215680f, 
    0.01752007f, -0.00342733f, 0.01373587f, 0.01825037f, -0.03397956f, 0.01707366f, 0.00347637f, 0.01698552f, 
    0.00964951f, 0.03054163f, 0.02184376f, 0.03325860f, 0.01406866f, 0.01874004f, -0.02697785f, 0.01708179f, 
    0.02079309f, -0.02615406f, 0.01521909f, -0.00630010f, -0.00666537f, -0.00068393f, 0.02007939f, 0.01939343f, 
    0.00120444f, -0.03330929f, 0.01731350f, -0.00547338f, 0.01596931f, -0.00603599f, -0.04013937f, -0.00475623f, 
    -0.03961614f, -0.03634701f, -0.00302341f, 0.03490760f, 0.02592347f, 0.00772586f, -0.00087461f, 0.03181650f, 
    -0.03593716f, -0.03882372f, 0.00639786f, 0.02788967f, -0.02036913f, -0.00104028f, -0.03206925f, 0.00328687f, 
    -0.02472080f, 0.01351709f, 0.02644370f, -0.01019143f, -0.02376500f, 0.00879712f, 0.00264039f, 0.01907483f, 
    0.01629924f, 0.02928801f, -0.03335313f, -0.03818014f, 0.03243405f, -0.00382346f, -0.02898519f, -0.02109695f, 
    -0.02288948f, 0.01586695f, 0.01281338f, -0.02955505f, -0.03102602f, -0.02140918f, -0.01374858f, -0.02764040f, 
    -0.02789702f, 0.01344970f, 0.00258400f, -0.01889631f, 0.00408792f, -0.03107866f, 0.02668139f, 0.00222085f, 
    0.02356122f, 0.00828406f, -0.02978701f, -0.01256812f, 0.00764400f, -0.00217776f, 0.00902821f, -0.02267770f, 
    -0.01274907f, -0.03475587f, 0.02349950f, -0.04638084f, 0.04046628f, -0.03609598f, -0.00567754f, 0.01529180f, 
    -0.03496935f, -0.02331503f, 0.03653604f, -0.00106545f, -0.01271968f, 0.03136177f, -0.04153888f, 0.03959943f, 
    0.04415993f, -0.02922352f, -0.03158487f, -0.01902567f, 0.01955931f, 0.01029673f, 0.01548422f, -0.02118205f, 
    -0.01963458f, -0.02028560f, -0.00680031f, -0.03008575f, -0.02112404f, 0.04307984f, -0.01240045f, -0.01475136f, 
    0.01383012f, 0.01774902f, 0.01722418f, -0.00166736f, -0.02094189f, 0.02156193f, -0.01278973f, -0.02751255f, 
    -0.03164983f, 0.03133326f, 0.04237119f, -0.01710405f, 0.03270953f, 0.00130980f, -0.03835486f, 0.02615563f, 
    -0.00246478f, 0.02447986f, 0.00591614f, -0.01956790f, -0.03967983f, 0.01628291f, 0.02715405f, -0.02234568f, 
    -0.00098805f, 0.01402766f, -0.02915070f, -0.01363287f, -0.02567960f, -0.01780631f, -0.01994388f, 0.00470502f, 
    -0.00308709f, -0.00012142f, 0.01300029f, -0.00307733f, 0.00186739f, 0.00942244f, -0.01302146f, 0.00323799f, 
    -0.00316081f, 0.04013791f, -0.02287679f, -0.02860877f, 0.03113599f, 0.01989025f, 0.00501188f, 0.01916118f, 
    -0.00634702f, 0.02647997f, -0.01391771f, 0.00973050f, 0.01369729f, -0.01209001f, -0.01656271f, -0.02539589f, 
    0.01016538f, -0.03066331f, 0.00271322f, -0.01571765f, 0.03323289f, -0.01900383f, 0.01465270f, -0.04415530f, 
    -0.01762249f, 0.03755698f, -0.00553434f, -0.02698439f, 0.01608855f, -0.03263674f, 0.01487897f, -0.02352746f, 
    -0.00274954f, -0.00611742f, -0.03432250f, 0.00293900f, -0.01494119f, -0.02569605f, 0.02071070f, -0.02562972f, 
    0.02472347f, -0.00005357f, 0.03194232f, -0.02478271f, -0.00736856f, 0.03298306f, 0.03640801f, -0.00273917f, 
    0.00005689f, 0.00576881f, -0.03428030f, 0.02569688f, -0.00925285f, -0.01231461f, 0.00936471f, 0.02136323f, 
    0.02593523f, -0.01503554f, -0.04041047f, -0.01121448f, 0.03828428f, 0.00449726f, 0.03238660f, -0.00001702f, 
    -0.00995487f, 0.02204919f, 0.02539632f, 0.03338266f, 0.03381335f, -0.03079485f, -0.04014850f, -0.01014346f, 
    -0.03755742f, 0.03327874f, 0.02438644f, -0.00993374f, -0.01740054f, 0.01829353f, -0.04173296f, -0.01473869f, 
    0.01901535f, -0.01842066f, 0.00365052f, 0.01537780f, -0.03060587f, 0.02960170f, 0.01001438f, -0.02263407f, 
    -0.02744245f, -0.00116676f, -0.01681465f, 0.01953001f, 0.01737689f, -0.01244568f, 0.02613423f, 0.02727213f, 
    -0.00677765f, -0.03220854f, 0.01387508f, 0.00460613f, -0.02369511f, 0.01077202f, 0.00117178f, 0.04222440f, 
    0.02263384f, -0.02008763f, -0.03015716f, 0.02823395f, 0.00219266f, -0.04053016f, 0.00241214f, 0.02956514f, 
    -0.01442634f, -0.00017432f, -0.02095330f, -0.01488746f, 0.01500681f, 0.02152696f, -0.02304070f, 0.00155048f, 
    0.00367976f, -0.04154625f, -0.01535262f, 0.01213160f, 0.02122707f, -0.01055598f, -0.00158277f, 0.04073467f, 
    -0.01118379f, -0.00271202f, 0.04310120f, -0.04407026f, -0.01517712f, -0.00297141f, 0.04047288f, -0.01558538f, 
    -0.01839168f, -0.03160108f, -0.00743780f, -0.02605540f, 0.02341859f, -0.04490489f, 0.01917626f, -0.00065240f, 
    0.02167939f, -0.00741206f, -0.01687772f, 0.02702379f, 0.00129332f, -0.01210881f, -0.01617146f, 0.00393590f, 
    -0.00583582f, -0.02252396f, -0.00224725f, -0.01010321f, 0.02666043f, -0.00590668f, -0.01775069f, -0.00190031f, 
    -0.00271997f, 0.02354188f, 0.04240632f, 0.01374631f, -0.03419902f, -0.01146724f, -0.04698518f, 0.01087117f, 
    -0.02959095f, -0.00653765f, -0.02277104f, 0.02011737f, 0.02411931f, -0.02089763f, -0.01299543f, 0.03006963f, 
    -0.03985909f, -0.03297105f, -0.04024500f, -0.03933050f, -0.01034156f, -0.00207539f, 0.01956541f, 0.03319221f, 
    -0.03664877f, -0.02274721f, 0.01411117f, -0.01877223f, -0.01534311f, 0.02680309f, -0.01082936f, 0.01779780f, 
    -0.01357974f, 0.00821361f, 0.00840366f, -0.03612570f, -0.01145335f, -0.01414619f, -0.00961530f, -0.00531925f, 
    -0.03034362f, -0.03999751f, -0.02308244f, 0.02083387f, 0.01732080f, 0.04499132f, 0.00679427f, -0.00192255f, 
    -0.01673533f, -0.01550362f, -0.03775201f, 0.02131010f, -0.00372711f, -0.03569415f, -0.03201476f, -0.03325434f, 
    -0.03299049f, -0.02108933f, -0.02075417f, 0.00588293f, -0.01185679f, -0.02568791f, -0.00703448f, 0.00264408f, 
    -0.02906093f, -0.01408472f, 0.00333224f, -0.00313608f, -0.02927613f, -0.04017278f, 0.03477855f, -0.02657036f, 
    -0.01776111f, -0.01492095f, 0.02562963f, 0.01360276f, 0.00533762f, 0.01999746f, -0.00196774f, -0.00743609f, 
    0.02708274f, -0.01825689f, 0.01942031f, 0.00262892f, 0.02481752f, -0.00353368f, 0.02800498f, -0.02759010f, 
    -0.01025588f, 0.02319366f, -0.02427015f, -0.02817225f, -0.01113117f, -0.00696597f, -0.04018195f, -0.00390512f, 
    -0.03055524f, -0.00770751f, 0.02830857f, 0.02609627f, -0.03672868f, 0.00414608f, -0.02452858f, -0.01061648f, 
    -0.02207038f, 0.03015110f, -0.01509383f, -0.00028540f, 0.03943168f, -0.00922882f, 0.03020286f, 0.00906010f, 
    0.03077720f, -0.01822487f, 0.02049200f, -0.00972331f, -0.03889108f, -0.04670971f, -0.02797697f, 0.00217100f, 
    0.01098368f, -0.00780697f, 0.02675013f, 0.02952196f, 0.02986934f, 0.00882601f, -0.04425569f, -0.03513050f, 
    0.00292332f, -0.02427334f, 0.02701187f, 0.00815990f, -0.02289122f, 0.02460456f, 0.02181126f, 0.01969432f, 
    -0.04210282f, -0.03202102f, -0.04361704f, -0.00104167f, 0.02821186f, 0.01829834f, -0.00252338f, 0.00896811f, 
    0.00194023f, -0.01817728f, 0.02428271f, -0.03323304f, -0.04129124f, 0.03391281f, 0.00841716f, 0.03095285f, 
    0.01225847f, 0.02258723f, -0.00332123f, -0.01810218f, -0.03961859f, -0.00342527f, -0.00022803f, -0.02806390f, 
    -0.00708504f, 0.01932138f, -0.04301345f, -0.03707874f, -0.01602217f, -0.01332650f, 0.02732806f, -0.01922932f, 
    -0.03440141f, -0.04158824f, 0.01228422f, -0.00995927f, -0.02257674f, -0.03576914f, -0.02169513f, -0.02578976f, 
    -0.03029298f, -0.01926387f, -0.01548481f, 0.00463486f, -0.03420484f, -0.00352101f, -0.03173135f, 0.03350949f, 
    -0.03626169f, 0.00235631f, 0.01679801f, -0.00701784f, 0.03016367f, 0.02067880f, 0.02301487f, 0.02266011f, 
    0.02644587f, -0.02700646f, 0.03320482f, 0.01545752f, -0.01201866f, -0.02503964f, 0.02396637f, -0.01791926f, 
    -0.03996742f, -0.00101212f, 0.01589309f, 0.00033333f, -0.00543494f, 0.01055202f, 0.01904202f, 0.02211483f, 
    0.04505758f, -0.01780578f, -0.04373730f, 0.00565004f, 0.01883840f, 0.02257620f, -0.02142947f, -0.02913019f, 
    -0.03517873f, -0.00974635f, -0.03416084f, -0.03130050f, -0.01992381f, 0.02430696f, -0.03260668f, 0.01310242f, 
    0.00033021f, 0.00350842f, -0.04215112f, -0.03385262f, -0.01061670f, -0.03768104f, -0.02569138f, 0.02465529f, 
    -0.01895451f, 0.01067683f, -0.03556069f, -0.01231525f, -0.01728016f, 0.00818091f, -0.04337610f, -0.01033740f, 
    0.01906162f, 0.02899187f, 0.02350648f, 0.00897645f, 0.00245146f, -0.03188964f, 0.00064198f, 0.01319829f, 
    -0.04763903f, 0.01798575f, -0.03873055f, 0.03433599f, -0.03978240f, 0.02463531f, -0.02145541f, 0.01929708f, 
    0.23630257f, 0.15640348f, 0.14251502f, 0.06573411f, -0.04698933f, 0.05449831f, 0.01946802f, 0.06835501f, 
    0.01218458f, -0.01227402f, -0.11632105f, -0.00903627f, 0.03561991f, 0.04711742f, 0.17512168f, -0.02755954f, 
    -0.01601595f, 0.03088515f, 0.04689222f, -0.02218696f, -0.02984740f, -0.11385584f, 0.09576051f, 0.09886100f, 
    -0.28301498f, -0.04515562f, 0.00971234f, 0.03570844f, -0.00464483f, 0.05541191f, 0.07950596f, 0.06310400f, 
    -0.00816088f, 0.05734686f, -0.06901431f, 0.02031776f, 0.00863242f, 0.05528294f, -0.10013276f, -0.03759905f, 
    0.09998738f, 0.32838660f, 0.00647016f, 0.19640003f, -0.20397207f, 0.13214602f, 0.07028501f, 0.00709206f, 
    -0.07971612f, 0.04533043f, -0.00937510f, -0.03078890f, 0.05023113f, 0.00266445f, -0.04035737f, 0.04308621f, 
    -0.03162704f, -0.02730558f, -0.12408537f, -0.01345554f, -0.18465292f, -0.06640986f, -0.14351965f, -0.08564923f, 
    -0.00681969f, 0.11137891f, 0.12599532f, -0.02074709f, 0.08652424f, 0.02449409f, -0.00987346f, 0.03296498f, 
    0.05322826f, -0.01660382f, -0.09988191f, 0.04008322f, 0.01527391f, -0.05805098f, 0.03949957f, -0.07052129f, 
    0.06213831f, 0.04208619f, 0.02793863f, 0.03270727f, -0.12004702f, 0.05894937f, -0.05448469f, 0.14847471f, 
    0.06728559f, 0.06415762f, 0.03150563f, -0.02665314f, 0.02065162f, 0.08196093f, 0.12239332f, 0.04377643f, 
    0.05386559f, -0.04153591f, -0.06414788f, -0.04900750f, 0.07930221f, 0.06941761f, -0.19201510f, 0.02919883f, 
    0.34192196f, 0.10216755f, -0.01104306f, 0.06450881f, -0.00686182f, -0.02915471f, 0.04764788f, 0.07638357f, 
    0.05083808f, 0.05433125f, 0.11114357f, 0.09388562f, 0.02769639f, 0.07112510f, 0.11870318f, -0.03436781f, 
    0.14815432f, -0.22629102f, 0.20259447f, 0.21609373f, -0.23847415f, -0.04159129f, -0.02889472f, 0.00059436f, 
    0.08683819f, 0.00988389f, -0.06172083f, 0.00963972f, -0.00971589f, 0.11661383f, 0.02099022f, -0.04952756f, 
    0.10289027f, -0.01941200f, 0.07759153f, -0.05837420f, -0.09397963f, -0.02725427f, -0.17244390f, -0.05608576f, 
    0.11817037f, 0.06160475f, -0.05173511f, 0.04699391f, -0.00904079f, 0.00168651f, 0.00461118f, 0.05647973f, 
    0.01916802f, 0.01645016f, 0.00656418f, 0.07256179f, 0.02154576f, 0.04762449f, 0.07618610f, 0.06535869f, 
    0.00507618f, -0.12400954f, -0.05976563f, -0.12212696f, 0.18481328f, 0.06631389f, 0.03659083f, -0.09873727f, 
    0.07309261f, 0.09051896f, 0.09923756f, 0.02968426f, 0.01851170f, 0.10389471f, 0.02240718f, 0.04110412f, 
    0.08389907f, 0.02636676f, -0.02903762f, 0.09489816f, 0.06201610f, 0.12752649f, 0.06530902f, 0.09715080f, 
    -0.14407396f, 0.10868698f, 0.07103718f, 0.06608552f, 0.03341053f, 0.14933854f, 0.06203471f, 0.05697981f, 
    0.06367672f, -0.01362274f, -0.01480094f, 0.15950896f, 0.00373077f, 0.02383986f, 0.09556279f, 0.00396320f, 
    0.17698909f, 0.25198221f, -0.11410733f, 0.22400683f, -0.15474857f, -0.04958938f, 0.08190446f, 0.14724837f, 
    0.08620676f, 0.06749237f, 0.07349557f, 0.01492384f, -0.12216270f, 0.08432945f, 0.03496800f, 0.05235478f, 
    -0.12699285f, 0.14822216f, -0.04086362f, -0.07909562f, 0.17355746f, 0.05089639f, -0.10352962f, 0.14677745f, 
    0.20606419f, 0.03852392f, 0.12593152f, 0.01086379f, 0.16011107f, 0.06139569f, -0.03755721f, 0.00844108f, 
    0.13433659f, 0.11526944f, -0.00818314f, 0.07967796f, 0.05396213f, -0.04444110f, -0.04013308f, 0.09640612f, 
    0.00159388f, 0.03319367f, -0.29657906f, -0.06157799f, 0.12817672f, 0.03858253f, -0.04275501f, 0.06783020f, 
    0.01010126f, 0.09386665f, 0.02513647f, -0.01915841f, 0.05678027f, 0.02262777f, 0.07257135f, 0.05547283f, 
    0.03855443f, 0.23985741f, 0.01705902f, 0.03013225f, 0.05188164f, 0.05460130f, -0.07694763f, 0.06300940f, 
    0.06385553f, -0.02534699f, 0.09026804f, -0.01376189f, -0.04518833f, 0.09527664f, 0.02109081f, 0.06705430f, 
    0.05723606f, -0.01010355f, 0.02675928f, 0.05472235f, 0.00937320f, 0.11230540f, 0.00843506f, 0.07858931f, 
    -0.19318013f, -0.07342748f, -0.15976951f, -0.10803875f, 0.13773158f, 0.04574601f, 0.11570466f, 0.19548737f, 
    0.01588986f, -0.07203131f, -0.04142844f, -0.00419203f, 0.16724969f, 0.00453362f, 0.04136480f, 0.13630362f, 
    0.10521804f, 0.06762031f, 0.02104318f, 0.18190742f, -0.31604949f, -0.07672670f, 0.18155201f, 0.04743383f, 
    -0.04741758f, -0.08896545f, 0.08406550f, -0.02566254f, -0.03495019f, -0.02271791f, -0.01435520f, 0.11325708f, 
    -0.04876235f, 0.10037246f, -0.16954030f, -0.04757711f, 0.12823303f, 0.01777421f, 0.00808538f, 0.24113493f, 
    0.09539624f, 0.24273646f, -0.02552964f, 0.22699451f, -0.07002278f, 0.05137129f, 0.03051111f, 0.14321728f, 
    -0.05401215f, 0.10536543f, -0.02819547f, -0.08805297f, 0.04980774f, 0.00760437f, -0.00182170f, 0.03163766f, 
    0.09022958f, 0.03124322f, 0.01539975f, 0.10952877f, 0.18640400f, 0.03900306f, 0.19958676f, 0.28512111f, 
    -0.33450437f, -0.03311418f, 0.09005416f, 0.05947363f, -0.00382836f, -0.01637078f, 0.08489341f, 0.15866105f, 
    0.13226175f, 0.07987311f, 0.06203056f, -0.04094189f, -0.06466412f, 0.03241612f, 0.09529813f, 0.01262383f, 
    0.19021791f, 0.03846477f, 0.03129819f, 0.16684765f, 0.09594744f, -0.04755029f, 0.15304720f, -0.00399528f, 
    0.03170764f, 0.03601580f, 0.05777999f, -0.04567532f, 0.10071671f, -0.06350347f, 0.07798785f, -0.04875517f, 
    0.00999204f, -0.00832844f, 0.08205967f, 0.01769797f, -0.17659624f, 0.25334027f, 0.10656365f, -0.00441541f, 
    0.20778562f, 0.13060623f, -0.02199659f, 0.02837513f, 0.01666413f, 0.05133770f, 0.05719518f, -0.10909013f, 
    0.07286008f, 0.05799160f, 0.11241099f, -0.02337958f, 0.08324842f, -0.02782651f, 0.03452064f, -0.05927994f, 
    -0.07945635f, -0.00025759f, 0.16502908f, 0.00356023f, 0.10974723f, 0.06371408f, 0.09425799f, 0.00867993f, 
    0.03176027f, 0.09192710f, -0.08732608f, -0.01081315f, 0.07802355f, 0.12085050f, 0.08803279f, 0.07314886f, 
    -0.04343957f, -0.05475413f, 0.02083155f, -0.01783728f, -0.11819196f, 0.01177584f, -0.21951604f, -0.01880878f, 
    0.20286551f, -0.06981651f, -0.02722831f, -0.03352016f, -0.05758465f, 0.09059034f, 0.13051137f, -0.04027565f, 
    0.01422801f, 0.06216577f, 0.14163509f, 0.05027981f, -0.01354528f, 0.14791223f, 0.05909741f, 0.03005708f, 
    -0.33336398f, -0.01486988f, 0.05403408f, 0.07361151f, -0.14600730f, -0.09165635f, 0.04276546f, 0.10730083f, 
    0.03640341f, 0.05001912f, 0.05249944f, 0.03649642f, 0.05329802f, 0.07964188f, -0.06637954f, -0.07905067f, 
    0.02820827f, -0.07361728f, -0.02700179f, 0.10312440f, -0.31926420f, 0.08473995f, -0.01086622f, 0.00660303f, 
    0.05941096f, 0.16642392f, -0.08223069f, 0.01274557f, -0.01919745f, -0.09325927f, -0.00003390f, 0.00759844f, 
    0.13224605f, -0.01754926f, 0.00794010f, -0.00121025f, 0.04920678f, -0.03523877f, 0.08136574f, 0.11003665f, 
    0.14821823f, 0.22998470f, 0.14962541f, 0.11932842f, 0.07261632f, 0.03157758f, 0.01248439f, 0.10535393f, 
    0.01740038f, 0.07126673f, -0.03640270f, -0.10657737f, 0.00892516f, -0.04075759f, 0.06477812f, 0.02557367f, 
    -0.05019381f, -0.06896006f, -0.02931395f, -0.02085002f, -0.10813814f, 0.01041663f, -0.03282742f, -0.06938902f, 
    0.10284390f, 0.00221434f, 0.07802031f, -0.02321029f, 0.03356895f, 0.00551993f, 0.04217901f, 0.09065991f, 
    0.06698940f, -0.04649680f, 0.12944549f, 0.16847222f, -0.00633244f, 0.02620745f, 0.06138992f, -0.06061765f, 
    0.23656212f, 0.16564733f, 0.04754215f, 0.16031271f, -0.10340872f, 0.03277717f, 0.09329046f, 0.16159348f, 
    0.10600520f, -0.01513524f, -0.01902950f, 0.10640234f, 0.03261890f, -0.06039428f, 0.11411081f, -0.00218247f, 
    0.02962108f, 0.09304877f, 0.02883340f, -0.00281101f, 0.04877557f, -0.04810204f, -0.09827149f, -0.13227426f, 
    0.16368601f, -0.04996862f, 0.08849176f, 0.14434384f, 0.00684441f, 0.09618621f, 0.12062611f, -0.07659629f, 
    0.07669502f, 0.03765338f, 0.10796101f, 0.01411678f, 0.16780367f, 0.13649392f, 0.07951098f, 0.16078568f, 
    0.02956235f, 0.12665287f, -0.11504431f, -0.02145872f, 0.23157673f, -0.00594747f, -0.04219858f, 0.04172891f, 
    0.11089732f, 0.02803858f, 0.11788273f, -0.04577023f, 0.02826851f, 0.05602961f, 0.04272924f, 0.08476149f, 
    0.06336145f, 0.17361444f, 0.01372764f, 0.05313075f, -0.04609723f, 0.03789739f, -0.16500074f, -0.00171826f, 
    0.05872833f, -0.04629792f, -0.03565195f, -0.00651448f, -0.06746967f, 0.08849318f, 0.10938837f, 0.04253826f, 
    0.03867352f, 0.01906680f, -0.01960874f, -0.01389899f, -0.03511561f, 0.15434600f, 0.06353775f, 0.02419669f, 
    -0.28373170f, -0.14481786f, -0.11491434f, -0.13161069f, 0.06322530f, 0.06389849f, -0.00337038f, 0.05891799f, 
    -0.10092089f, -0.01440763f, 0.07103380f, 0.05975179f, -0.01339301f, -0.04408743f, -0.02297014f, -0.03018671f, 
    -0.08355883f, -0.03070015f, -0.05628127f, -0.00907402f, -0.35684773f, -0.03150902f, -0.23299830f, -0.13523351f, 
    0.06217846f, 0.13488825f, -0.03812927f, 0.04755056f, 0.03262879f, -0.03586394f, -0.05690091f, 0.00559694f, 
    0.07007377f, 0.00069121f, 0.14475161f, 0.01158506f, -0.02075060f, 0.02431273f, 0.03868706f, 0.03635939f, 
    -0.00071326f, -0.02684074f, 0.00205583f, -0.03530529f, -0.03454366f, -0.01088211f, -0.04750269f, 0.01064934f, 
    0.03102275f, -0.03695833f, -0.04434490f, 0.00413659f, -0.02116949f, -0.02858203f, -0.01048392f, -0.01851214f, 
    -0.03345225f, 0.01397604f, 0.02868369f, -0.01474565f, -0.01309571f, -0.04876908f, 0.04519687f, 0.00104188f, 
    -0.01439005f, 0.02374425f, 0.02313244f, -0.01061170f, 0.02378118f, 0.01746668f, -0.03803848f, -0.00408956f, 
    -0.00462379f, 0.03331338f, -0.01080966f, -0.02582964f, 0.00334897f, -0.01084773f, 0.00553431f, 0.03747746f, 
    0.02841829f, -0.03134011f, -0.01919391f, -0.03216159f, -0.04008392f, -0.02377884f, -0.00545184f, -0.00364119f, 
    -0.02800167f, -0.02451536f, 0.00098312f, 0.02488844f, -0.00327350f, -0.00696885f, 0.03182832f, 0.01414782f, 
    0.02892320f, -0.02429351f, 0.03167121f, -0.00829574f, -0.01229779f, -0.01132572f, 0.02941777f, 0.01833526f, 
    0.01812564f, 0.03207696f, -0.00582565f, -0.02565964f, -0.00390115f, -0.02395470f, 0.04135926f, 0.02684356f, 
    0.02321556f, 0.02468421f, -0.03421869f, 0.03921214f, -0.04450739f, -0.04508942f, 0.00470342f, -0.00759224f, 
    -0.00499030f, -0.00154305f, -0.01546505f, -0.01166484f, -0.03441813f, -0.02719392f, -0.02618849f, -0.01337515f, 
    -0.00187398f, -0.03412233f, -0.02415992f, 0.00289733f, 0.00965630f, -0.00448456f, -0.01905236f, 0.01562452f, 
    0.01088036f, 0.00419309f, -0.00500214f, -0.00363151f, -0.00163198f, -0.01718284f, -0.04489867f, 0.00642072f, 
    0.02038041f, -0.02130867f, -0.03765685f, -0.01302026f, 0.01083303f, 0.02519825f, -0.01545099f, 0.00659728f, 
    0.01779534f, 0.01192513f, -0.01985413f, -0.01926897f, -0.00704899f, -0.03952118f, -0.00901106f, -0.03014767f, 
    -0.01710362f, 0.01610687f, -0.00048346f, -0.00277929f, 0.01175203f, -0.00323303f, -0.00906732f, 0.02852248f, 
    0.00033806f, -0.03846211f, -0.00954615f, -0.03411064f, 0.00576510f, -0.01629307f, 0.02114334f, 0.00498772f, 
    -0.00436157f, -0.02917801f, 0.02244433f, -0.01074877f, -0.01400362f, -0.02953207f, -0.03120619f, 0.00512961f, 
    0.00351905f, -0.03095816f, 0.02392008f, 0.00625898f, -0.00324386f, -0.00073873f, 0.03092052f, -0.02208978f, 
    -0.00223472f, -0.01931003f, -0.00324306f, 0.00640745f, -0.02036612f, 0.00409621f, -0.04375686f, 0.03047564f, 
    0.01756886f, 0.02618170f, -0.00905466f, -0.02231750f, 0.01557839f, -0.00452447f, -0.01211414f, -0.03984182f, 
    -0.01965180f, -0.02525380f, 0.00575739f, 0.02233824f, -0.03098040f, 0.01774701f, -0.01503334f, 0.00142137f, 
    -0.00265424f, 0.00724610f, -0.00278224f, 0.02430625f, -0.02673831f, 0.01496228f, 0.01687343f, -0.00856245f, 
    0.01027890f, 0.02734602f, 0.01434481f, -0.01271235f, 0.00005214f, 0.03600224f, 0.03253704f, -0.00584361f, 
    0.00068449f, -0.03892778f, -0.00528069f, -0.00670558f, -0.04152006f, 0.03459104f, -0.00006698f, -0.01073692f, 
    0.01453223f, 0.04045119f, 0.00621428f, 0.03750280f, 0.01804624f, -0.01671046f, -0.04157389f, -0.01092872f, 
    0.00717610f, 0.01163945f, 0.03250797f, -0.03785129f, 0.04075513f, -0.03435816f, 0.03170433f, -0.03267577f, 
    0.02987801f, -0.03814767f, -0.01157385f, 0.00156244f, -0.03610397f, -0.02908298f, -0.02405248f, -0.01438687f, 
    -0.01545878f, 0.04147504f, -0.00879765f, 0.01300273f, -0.03882234f, -0.01894265f, -0.02954362f, 0.03168844f, 
    -0.03351951f, 0.02371404f, 0.01798376f, -0.00321716f, -0.00428727f, -0.02747906f, 0.04219533f, -0.02475931f, 
    -0.01364215f, 0.01449270f, -0.04534307f, 0.01218903f, 0.00229428f, 0.04376452f, -0.03919932f, 0.02550380f, 
    0.00361849f, -0.00105573f, 0.02011294f, 0.02474234f, 0.02605611f, -0.04019377f, -0.03474921f, 0.00907929f, 
    -0.00293697f, -0.03169800f, -0.01972548f, 0.00706229f, -0.02118081f, -0.04218535f, 0.01201484f, 0.02185586f, 
    -0.02796292f, 0.00623402f, -0.01582842f, 0.01167834f, 0.02080997f, -0.00693154f, 0.01693112f, -0.03727788f, 
    0.02918325f, -0.01501410f, -0.00572471f, -0.01328754f, -0.01512911f, -0.03195485f, -0.02136534f, -0.01834611f, 
    -0.02915953f, 0.01359830f, 0.01187265f, -0.02256723f, 0.01820772f, -0.02380116f, 0.01631066f, -0.01338314f, 
    -0.01622062f, -0.01663799f, -0.02915288f, 0.00447859f, 0.00472651f, -0.04367553f, 0.01072405f, -0.04049373f, 
    -0.02438680f, -0.00859183f, -0.01675391f, -0.02294325f, 0.00787188f, -0.01468689f, -0.02275199f, 0.00821026f, 
    -0.00908670f, 0.00808578f, -0.02021916f, 0.02607029f, 0.00502144f, 0.01779030f, 0.03279882f, 0.01761711f, 
    0.01828936f, -0.02249039f, -0.01162085f, -0.00908964f, 0.01235791f, -0.02266361f, -0.02226790f, -0.00716472f, 
    0.00415162f, -0.01009841f, -0.01751248f, -0.03261991f, 0.00200854f, -0.01440063f, -0.02415903f, -0.00587985f, 
    -0.01892190f, 0.02180666f, 0.03544136f, -0.01586671f, 0.00924333f, -0.02422656f, -0.02216964f, 0.02442965f, 
    -0.01851020f, -0.00780855f, -0.03751628f, -0.02391029f, -0.01326375f, 0.02247819f, 0.00734386f, 0.01720456f, 
    -0.01078969f, 0.01713852f, 0.02065577f, -0.02245463f, 0.03707615f, 0.01308131f, 0.00470389f, 0.03040739f, 
    -0.03921327f, -0.03467379f, -0.01582734f, -0.02678259f, -0.04415431f, -0.01535170f, 0.02649220f, 0.03183302f, 
    -0.01538616f, 0.01845336f, -0.00287544f, 0.02512230f, -0.01196501f, -0.03149347f, -0.01150031f, 0.02133112f, 
    0.02627308f, -0.00503045f, -0.02766737f, -0.04044618f, -0.02066774f, 0.01903962f, -0.03904857f, -0.02849718f, 
    -0.01186042f, 0.03979165f, -0.00330968f, -0.02584388f, -0.02877381f, -0.02534339f, -0.01088291f, 0.02334305f, 
    0.01793230f, 0.00724491f, -0.03145228f, -0.00581911f, -0.02182395f, 0.03026482f, -0.03671881f, -0.00190481f, 
    -0.03658753f, -0.01323523f, -0.04257842f, 0.01752922f, 0.02814085f, 0.01874352f, 0.01721753f, 0.00188198f, 
    -0.04067632f, 0.02720666f, 0.02847842f, -0.00692320f, -0.00329945f, 0.00260935f, 0.03347393f, 0.03782020f, 
    0.01242228f, 0.00591508f, -0.00891247f, -0.02957068f, -0.02213157f, -0.04693950f, -0.01448760f, -0.04176887f, 
    -0.00166851f, -0.03289709f, -0.00240829f, 0.01932118f, 0.00289117f, -0.00595354f, 0.00094121f, 0.00799914f, 
    -0.02917170f, 0.03818744f, 0.01057975f, -0.03779515f, -0.01455051f, 0.03453108f, 0.01507847f, -0.02410501f, 
    -0.00800644f, -0.00805135f, 0.04081630f, -0.04037662f, -0.00364801f, 0.00428385f, 0.00984231f, 0.03232644f, 
    -0.02306128f, 0.03290796f, 0.03372527f, 0.03052197f, 0.01013753f, 0.00809992f, 0.00966666f, 0.00468014f, 
    0.02459821f, -0.04389883f, 0.01125375f, -0.04620931f, -0.00787966f, -0.00625010f, -0.04641579f, 0.00287517f, 
    0.00625886f, 0.00480292f, 0.03264887f, -0.03292914f, 0.01121525f, 0.03835002f, 0.01723789f, -0.03549023f, 
    0.00145314f, -0.01084074f, -0.04550808f, 0.02744678f, -0.02142278f, -0.01381456f, -0.01934459f, -0.04735787f, 
    -0.01199074f, 0.00098605f, -0.01586499f, -0.04183015f, -0.04299783f, 0.03268762f, -0.01135325f, -0.03594545f, 
    -0.03907476f, 0.00004284f, 0.01291569f, -0.04063359f, 0.02378544f, -0.01989138f, -0.00932418f, 0.02108722f, 
    0.02494422f, 0.00834031f, 0.00834350f, -0.00933909f, 0.02501530f, -0.01360228f, -0.03189901f, -0.03916365f, 
    -0.02243235f, 0.00727866f, 0.02686595f, -0.02867212f, -0.03084324f, -0.00522263f, 0.02791339f, -0.04441179f, 
    -0.02349246f, -0.03237731f, 0.02954208f, -0.02747774f, -0.04538598f, -0.03335884f, 0.00259675f, 0.03565463f, 
    0.01714980f, -0.03043754f, -0.01062089f, -0.03667056f, -0.04538129f, 0.02342968f, 0.01087675f, -0.00043763f, 
    0.01129927f, -0.00017534f, 0.02310002f, -0.02241928f, -0.02080702f, -0.00695710f, 0.03489508f, 0.01809559f, 
    -0.02836558f, -0.04081768f, -0.01053108f, -0.03499451f, 0.00293023f, 0.02315458f, -0.02156897f, -0.00018826f, 
    -0.04599876f, 0.01734470f, 0.03002454f, -0.03921836f, -0.02292428f, -0.00235901f, 0.01249608f, -0.01585330f, 
    0.02986576f, -0.00136070f, 0.01934377f, -0.03521128f, -0.02545301f, 0.03406695f, -0.01811679f, 0.02739207f, 
    0.02123250f, -0.04047405f, 0.01823671f, 0.02057107f, 0.01982981f, 0.03597246f, -0.00794920f, 0.01256070f, 
    -0.01737814f, -0.02879110f, -0.00611756f, 0.01675977f, 0.03127074f, -0.00545169f, 0.01974004f, 0.00817319f, 
    0.01016521f, -0.01659593f, -0.01573821f, -0.03318027f, -0.03996591f, 0.00426211f, 0.03279424f, -0.03998985f, 
    -0.02926033f, 0.03034566f, 0.03166779f, 0.00245522f, 0.03118217f, 0.00486156f, 0.02220412f, 0.00291504f, 
    -0.01817249f, 0.02423474f, 0.02566412f, 0.01506044f, -0.03829094f, -0.04792405f, -0.03480238f, -0.00719114f, 
    -0.02774660f, -0.04424131f, 0.02522739f, 0.01946076f, -0.03755407f, 0.01792166f, -0.02799715f, -0.02728476f, 
    -0.03614523f, -0.03194271f, 0.02257188f, 0.01142027f, -0.02913064f, -0.02934967f, -0.04566794f, 0.01389602f, 
    0.01080149f, 0.00858443f, -0.02100929f, -0.00278391f, 0.03220751f, 0.02893756f, -0.02153878f, -0.02170494f, 
    -0.00179820f, -0.03082311f, -0.01345903f, -0.01565652f, -0.04124396f, -0.00903302f, -0.00687895f, 0.02828032f, 
    0.01864927f, 0.01013151f, 0.00140822f, -0.01967995f, -0.02321274f, 0.01714509f, 0.03076912f, 0.01383900f, 
    0.02125226f, -0.04711260f, 0.01841613f, -0.02037409f, -0.01188906f, -0.03649206f, 0.00420494f, -0.02406669f, 
    0.35934114f, 0.16628473f, -0.09359889f, -0.19224058f, 0.13459386f, 0.07052667f, 0.07120447f, 0.07705557f, 
    0.16230464f, 0.09685526f, 0.07294046f, -0.01780702f, 0.04787202f, -0.01768206f, 0.02280231f, -0.01597068f, 
    0.16990136f, 0.07111584f, 0.02513331f, 0.07822819f, -0.40253875f, -0.16764097f, -0.03974936f, -0.21630117f, 
    -0.07688110f, 0.08341906f, -0.01522990f, -0.15539989f, 0.03305053f, -0.03189982f, 0.06721105f, 0.05523693f, 
    -0.07199879f, 0.04153778f, 0.08073463f, -0.01488684f, -0.04099141f, 0.02269227f, -0.03598768f, -0.03373251f, 
    -0.08650727f, 0.10614771f, 0.24317558f, 0.04047832f, 0.16220546f, 0.15872748f, -0.01608175f, -0.02638862f, 
    0.00929826f, -0.05433136f, 0.10069348f, 0.05157389f, 0.07250877f, 0.02559724f, 0.02647158f, 0.04151765f, 
    0.01160329f, 0.05216696f, -0.00708312f, 0.17668387f, 0.20356472f, 0.34931222f, 0.19309956f, -0.02992710f, 
    0.06255068f, 0.00577159f, -0.11076470f, -0.09408067f, 0.09652437f, -0.03321677f, -0.05990833f, -0.03675737f, 
    0.05318246f, 0.08084705f, 0.06464248f, -0.05449530f, 0.06586191f, 0.00239970f, -0.09776758f, -0.09885296f, 
    -0.17696086f, -0.36872116f, -0.23525287f, -0.26080102f, -0.11175180f, 0.12678428f, 0.12606697f, 0.03554216f, 
    0.00341208f, -0.06996098f, -0.01639440f, -0.06434146f, -0.05431742f, -0.07647941f, -0.01705598f, -0.02378952f, 
    -0.00366029f, 0.09563467f, -0.01780293f, 0.04256824f, 0.31548595f, 0.01063149f, 0.01829070f, 0.17908788f, 
    0.35405478f, -0.06172432f, 0.14396510f, 0.05393304f, 0.00113719f, 0.01206208f, 0.03856104f, -0.05088040f, 
    0.00216348f, 0.03701760f, 0.04257246f, 0.07035670f, 0.15642838f, 0.00778053f, 0.13473734f, 0.03357847f, 
    -0.02252399f, -0.27289012f, -0.03546514f, -0.15769422f, 0.03407114f, 0.02396298f, 0.02118612f, -0.20035112f, 
    0.00296285f, -0.03579603f, 0.07520968f, 0.03300169f, 0.08797456f, 0.07444853f, 0.08300848f, 0.02139606f, 
    0.07673214f, -0.08985502f, 0.01748122f, 0.16054535f, 0.36738667f, 0.05195959f, 0.10174017f, 0.13235240f, 
    -0.11416873f, -0.18057042f, -0.03803375f, 0.04789692f, -0.08009680f, -0.08790004f, 0.01134966f, -0.08202957f, 
    0.05374961f, 0.01018672f, 0.11187672f, 0.01943589f, -0.04097801f, -0.00132728f, -0.08621950f, 0.00618591f, 
    0.09932029f, -0.00771161f, 0.05900479f, 0.00219873f, -0.14494680f, 0.10636781f, 0.05815816f, 0.07744010f, 
    0.05501818f, 0.18547525f, -0.01405186f, -0.04052200f, -0.15708309f, -0.02959858f, -0.04455769f, 0.00229164f, 
    0.03853296f, -0.07358795f, 0.02026169f, 0.02821541f, -0.31138110f, -0.18410899f, 0.04724520f, -0.08925915f, 
    -0.22070383f, 0.09614642f, -0.00523337f, 0.03733955f, -0.02522233f, -0.07784579f, 0.03881801f, 0.06395232f, 
    -0.07491573f, -0.01607927f, 0.07679743f, -0.03588940f, -0.03592117f, 0.06107694f, -0.06785849f, 0.07584500f, 
    0.15409486f, 0.19902135f, -0.29455891f, -0.09234094f, -0.02899223f, 0.34319001f, 0.06114968f, 0.10741835f, 
    -0.00693065f, 0.10997625f, 0.14795288f, 0.11675370f, -0.07468569f, -0.10816332f, -0.03935738f, 0.22607423f, 
    -0.02431972f, -0.05521527f, -0.01515991f, 0.02647152f, 0.06892945f, -0.33420828f, -0.17483257f, 0.25551650f, 
    0.02277300f, 0.02720328f, 0.03240191f, 0.06018345f, 0.00907480f, 0.03937927f, 0.01730370f, 0.03933718f, 
    -0.01833892f, 0.07793286f, -0.12472688f, -0.01150553f, 0.20152068f, -0.02687403f, 0.00124065f, 0.03057936f, 
    -0.10809080f, -0.00714889f, 0.22726826f, -0.03218124f, -0.06577542f, -0.00254315f, 0.04039263f, 0.01208828f, 
    -0.04740346f, 0.13853633f, 0.08857194f, 0.01884454f, 0.01219712f, -0.01642813f, 0.04481937f, -0.01079255f, 
    0.09485743f, -0.09254465f, -0.04479796f, 0.02158510f, 0.01631853f, 0.05736894f, -0.00336682f, 0.08699920f, 
    -0.08050176f, -0.08438037f, 0.02223296f, -0.00735591f, 0.00879835f, -0.10511047f, 0.04476266f, 0.04745583f, 
    -0.00376031f, 0.04589704f, 0.03455778f, 0.05814685f, 0.05330280f, 0.02523861f, 0.06599010f, 0.07019628f, 
    -0.08247835f, 0.04410570f, -0.11163018f, 0.16279142f, -0.02436842f, -0.14079410f, -0.15344836f, 0.02216256f, 
    -0.09052975f, 0.09442114f, -0.00121158f, -0.04157153f, -0.06732406f, -0.10271424f, -0.09373976f, 0.07256301f, 
    -0.03921561f, -0.08148001f, 0.00202190f, -0.04858399f, 0.14638296f, -0.00225564f, -0.20603256f, 0.07794672f, 
    0.04940838f, -0.16856389f, -0.06497521f, 0.04235538f, 0.17126124f, -0.06063499f, -0.19059387f, 0.08828091f, 
    -0.09603511f, -0.01939336f, 0.04565364f, 0.11388492f, 0.04374345f, 0.12947440f, 0.03067660f, 0.04237031f, 
    -0.19358869f, 0.05141734f, 0.07618126f, -0.16167684f, 0.23362495f, 0.18355756f, 0.09642838f, 0.04626753f, 
    0.03943035f, -0.05054872f, 0.06800187f, 0.03337898f, -0.02836110f, 0.06762054f, 0.11322349f, 0.12078813f, 
    0.05837787f, 0.12076887f, -0.09052221f, 0.04135360f, 0.17632775f, -0.38439527f, -0.38139546f, -0.22087780f, 
    -0.24297635f, 0.05074027f, 0.12873296f, -0.02399698f, -0.06601086f, 0.00036661f, 0.01200596f, 0.02462124f, 
    -0.00162038f, 0.13516304f, -0.00271340f, -0.07289481f, -0.11567037f, 0.05746663f, -0.02109330f, 0.06318898f, 
    -0.09228195f, -0.21965542f, -0.26655501f, -0.32520729f, -0.08160029f, 0.12104888f, 0.24564397f, -0.01248563f, 
    -0.00925976f, -0.05439626f, -0.05993846f, 0.03196223f, 0.11717246f, 0.01292999f, -0.01423890f, -0.10340691f, 
    -0.01312838f, 0.03056717f, -0.08619453f, -0.09898518f, -0.17194189f, 0.25032553f, -0.13484432f, -0.02928729f, 
    0.12704891f, 0.11752348f, 0.11281382f, 0.08598759f, 0.08933403f, 0.08670478f, 0.06628472f, -0.00242454f, 
    -0.00135572f, 0.07116121f, 0.06088239f, -0.01061272f, 0.06329676f, 0.08183452f, 0.07405613f, -0.00322645f, 
    0.08557605f, -0.29483280f, -0.02630451f, -0.06022575f, 0.10384578f, -0.00230587f, 0.03323291f, 0.08779453f, 
    -0.03332670f, -0.00315938f, -0.03752691f, 0.00270939f, -0.02537119f, 0.04247626f, -0.19167110f, -0.09829804f, 
    -0.10778926f, -0.02173684f, -0.00929974f, 0.04231368f, 0.28267944f, 0.31303322f, 0.03949863f, -0.20358317f, 
    -0.01135718f, -0.04072016f, 0.03675602f, 0.00646199f, 0.01787979f, 0.03653061f, 0.02078690f, 0.03935958f, 
    0.03984057f, -0.06493306f, -0.08231220f, 0.02368277f, 0.11513112f, 0.03648033f, 0.03531194f, -0.03435404f, 
    0.02009706f, -0.04361896f, 0.05860366f, -0.05120512f, -0.11094254f, -0.12837784f, 0.01542230f, -0.11563667f, 
    0.10650504f, -0.03089304f, 0.05664982f, 0.08494043f, 0.02724301f, 0.11378781f, -0.04651530f, -0.02783390f, 
    -0.00451793f, 0.06567235f, -0.14100266f, 0.05198869f, 0.49991015f, -0.09067354f, -0.03039117f, 0.06965011f, 
    -0.16222158f, -0.05990309f, -0.01852877f, -0.04203094f, -0.01545724f, 0.01700077f, 0.00699338f, 0.05524181f, 
    -0.04410933f, -0.07488544f, -0.03225026f, -0.05894923f, 0.06933701f, -0.01777879f, 0.00591879f, 0.00580571f, 
    -0.00633231f, 0.08265299f, -0.08638567f, -0.31841931f, 0.01976047f, 0.12051298f, 0.14014256f, 0.03360986f, 
    0.04178625f, 0.02729623f, -0.04726841f, 0.10533764f, -0.05742887f, -0.01415277f, -0.00337113f, 0.07090199f, 
    0.06450018f, 0.14034158f, 0.01294618f, 0.12277514f, 0.23713554f, 0.10119006f, 0.02176000f, 0.19672434f, 
    0.11371417f, 0.00212451f, -0.11544264f, -0.01296963f, 0.08471323f, 0.19451827f, 0.01130459f, 0.01459917f, 
    0.02431315f, 0.04384722f, -0.07329308f, -0.00289333f, 0.02841131f, 0.12343327f, 0.03916494f, 0.00957897f, 
    0.01510435f, -0.31742400f, -0.21038178f, -0.20931789f, -0.11373256f, 0.22410156f, 0.20261970f, -0.04332492f, 
    -0.05799147f, -0.02359951f, 0.08304782f, -0.03547826f, -0.07429866f, 0.03800364f, 0.11591474f, 0.03970733f, 
    0.01901757f, -0.04109431f, -0.08908100f, -0.07034346f, -0.08349910f, 0.02127757f, 0.10775208f, 0.01792359f, 
    -0.00219921f, -0.09431307f, -0.08371378f, 0.05571065f, 0.03294420f, 0.07672039f, -0.07664514f, -0.15068059f, 
    -0.05633223f, -0.02401504f, 0.00189251f, -0.01309534f, -0.05388039f, -0.02223297f, 0.07280980f, -0.09734454f, 
    -0.09727863f, 0.07154626f, 0.02982361f, -0.11142527f, 0.10422749f, 0.05281452f, -0.00411593f, 0.03710985f, 
    0.02638325f, 0.03574444f, 0.06794557f, -0.02075208f, 0.03489916f, 0.02110951f, 0.00916668f, -0.02073742f, 
    0.14588958f, -0.02815264f, -0.07621907f, 0.14562094f, 0.14911358f, 0.13039285f, -0.08516456f, -0.05204176f, 
    -0.01504233f, -0.03701228f, -0.09550586f, -0.04927561f, -0.12611528f, -0.09534661f, 0.12273093f, -0.03298630f, 
    -0.00266317f, -0.04458382f, -0.01137618f, 0.18146157f, 0.05478590f, 0.09161403f, 0.01659052f, 0.05113317f, 
    0.40615281f, 0.04382863f, 0.15708700f, 0.01184850f, -0.10957918f, -0.20083350f, -0.09534944f, -0.00622734f, 
    -0.09305155f, 0.03180827f, 0.02799848f, -0.03881548f, 0.01029861f, -0.07672255f, 0.07489408f, 0.04019531f, 
    -0.00024725f, 0.02468873f, 0.06827001f, -0.01649483f, 0.69685847f, -0.09099547f, 0.03167249f, 0.03422203f, 
    -0.10491985f, -0.15866421f, -0.06888741f, -0.05178307f, -0.03173086f, 0.02305982f, -0.05739937f, -0.09182286f, 
    0.01437373f, -0.05772286f, -0.01173958f, -0.12926234f, -0.14286470f, -0.05377996f, -0.07291928f, 0.04615272f, 
    -0.35111919f, 0.28198457f, 0.11355355f, 0.00209147f, 0.03547298f, -0.20325714f, -0.00852528f, 0.07746971f, 
    -0.01410661f, 0.05046084f, 0.01437361f, -0.08730411f, -0.00500984f, -0.08724047f, -0.07100664f, 0.03767290f, 
    0.07046114f, -0.10247663f, -0.07825819f, 0.08961555f, -0.14560609f, 0.39723235f, -0.10692306f, -0.16662896f, 
    0.15944724f, 0.03685600f, 0.02987087f, -0.01926436f, 0.02142349f, 0.01070722f, 0.07178761f, 0.05663331f, 
    -0.05249509f, 0.03489993f, -0.05614740f, 0.01398124f, 0.03729048f, -0.05262755f, 0.00403551f, 0.08506107f, 
    0.07332662f, -0.26408362f, 0.11545843f, -0.15458170f, -0.05999165f, 0.07179188f, -0.16763315f, 0.07919730f, 
    0.00350470f, 0.01421606f, -0.05454634f, -0.07455005f, 0.04406148f, 0.01430926f, 0.04528839f, 0.04063877f, 
    0.11078668f, -0.00654233f, 0.00033932f, -0.01898937f, -0.17654584f, 0.20332375f, -0.00681357f, 0.09214260f, 
    0.20594078f, 0.15282689f, -0.18456103f, -0.04628362f, -0.04608154f, 0.08480937f, 0.06318481f, -0.08072700f, 
    -0.04377048f, -0.01967745f, -0.00120383f, 0.07890578f, 0.10297054f, -0.06174606f, -0.02882496f, 0.11086628f, 
    0.07156172f, -0.06724722f, -0.02258921f, -0.06851087f, 0.16356221f, 0.10442856f, 0.00926984f, -0.08970781f, 
    0.02129330f, 0.00608798f, 0.01589418f, -0.03415557f, 0.07004154f, 0.00662550f, -0.15073372f, -0.00563718f, 
    -0.03562425f, 0.05771694f, 0.00204460f, 0.03450090f, 0.15399875f, 0.05522641f, -0.11476522f, -0.06777868f, 
    -0.21830794f, -0.04720547f, 0.07414161f, -0.08356491f, 0.09049828f, 0.02688438f, 0.06618451f, -0.13008973f, 
    0.04799370f, 0.02571966f, -0.03166337f, 0.01064675f, 0.08908639f, -0.09830965f, 0.09532327f, -0.03426627f, 
    0.11605111f, 0.38308200f, -0.35154170f, -0.33406538f, -0.06448041f, -0.15855314f, 0.17705280f, -0.00320954f, 
    -0.05224682f, 0.06180542f, -0.01573406f, 0.07398934f, 0.12248838f, 0.05058902f, 0.06662146f, -0.00452831f, 
    -0.00828916f, -0.08730864f, -0.04192936f, -0.00651718f, 0.20351076f, -0.06918696f, -0.17390952f, 0.29261571f, 
    -0.11378612f, -0.08907696f, -0.02550352f, -0.09708297f, 0.05803269f, 0.16425650f, 0.01103474f, -0.09420251f, 
    0.03399494f, -0.01295872f, 0.03427384f, 0.06475501f, 0.02225668f, -0.02818735f, -0.02891864f, 0.02324598f, 
    -0.16549253f, 0.04224785f, -0.02127775f, 0.21193647f, -0.25481290f, 0.21648894f, -0.13411658f, 0.08589908f, 
    0.09458056f, 0.04623212f, -0.08596713f, -0.05614014f, 0.00288537f, 0.03784829f, 0.02369582f, 0.04006879f, 
    -0.05836672f, 0.03715433f, 0.02275302f, -0.05217202f, 0.27328122f, -0.09997506f, 0.15452029f, -0.01150693f, 
    -0.03950863f, -0.00424605f, -0.01865722f, 0.02752270f, 0.00092955f, -0.01215291f, -0.01941430f, -0.03089719f, 
    0.02545787f, 0.06112192f, 0.06602943f, 0.03100271f, -0.00230555f, 0.06093655f, -0.00448087f, -0.01568092f, 
    -0.21222179f, -0.21418127f, 0.14422724f, -0.04874372f, 0.13841550f, -0.07016870f, 0.14374480f, 0.03191459f, 
    -0.06021586f, 0.05151635f, 0.01470372f, -0.02677256f, 0.04689679f, -0.02934805f, 0.03418596f, -0.13923685f, 
    0.08153223f, -0.20132303f, -0.17305551f, -0.01930539f, -0.33435637f, -0.05926004f, -0.04795131f, -0.31198412f, 
    -0.34542161f, 0.16263276f, -0.00074639f, 0.02329958f, 0.12038615f, -0.08172949f, 0.08826568f, -0.10432548f, 
    -0.05790735f, -0.03678959f, -0.07631277f, 0.03075931f, 0.10510799f, -0.06173434f, 0.04034502f, 0.03220270f, 
    -0.00010152f, -0.03886349f, 0.08961397f, 0.06919872f, -0.24897709f, 0.06577540f, 0.08610139f, 0.09644517f, 
    -0.00194574f, -0.02062766f, 0.01802748f, 0.03410298f, 0.07094117f, 0.03844289f, 0.00115836f, 0.01843258f, 
    -0.03135701f, -0.04882515f, -0.03945651f, -0.04421394f, 0.14291228f, -0.26067522f, -0.15831649f, 0.14246364f, 
    -0.03103990f, -0.01628520f, 0.04208220f, 0.05455261f, 0.02729145f, 0.00863431f, 0.06062825f, 0.09789383f, 
    0.01621871f, 0.06346172f, 0.14224851f, 0.08081002f, 0.02404120f, 0.07837361f, 0.10235280f, -0.03724609f, 
    -0.02601056f, -0.16834447f, -0.35682175f, 0.11876274f, 0.08733578f, -0.09189955f, -0.17240354f, 0.00249914f, 
    -0.00712528f, 0.12567861f, 0.05748786f, 0.02714396f, 0.00973119f, 0.08276554f, -0.00946418f, -0.07386976f, 
    0.00509359f, 0.12984043f, 0.04678275f, -0.08807815f, 0.05331398f, -0.04269610f, -0.20333263f, -0.17181973f, 
    -0.06914040f, 0.07371434f, 0.12328494f, 0.03172090f, -0.01699568f, -0.01964021f, 0.04837756f, -0.03169495f, 
    0.03605027f, -0.09666557f, -0.01184944f, -0.03574872f, 0.03062371f, -0.01978021f, -0.01940686f, -0.02997612f, 
    0.10614240f, -0.41989213f, 0.10948347f, -0.17588574f, 0.03506241f, -0.01031115f, 0.00884549f, 0.18284807f, 
    -0.06777503f, -0.05408933f, 0.00549780f, 0.06437185f, -0.01768645f, -0.03957526f, 0.13104846f, -0.03045891f, 
    0.11411338f, 0.14236119f, -0.14532121f, 0.05160859f, -0.01423780f, -0.01545637f, 0.05029679f, -0.15105382f, 
    0.26553407f, -0.03253684f, 0.02013500f, 0.06421416f, 0.02329116f, 0.03552269f, 0.01491901f, -0.01624084f, 
    -0.00767083f, -0.01237701f, 0.04869636f, 0.05442773f, 0.01468077f, 0.00419380f, -0.11076730f, 0.07300920f, 
    -0.06472000f, -0.22607394f, -0.00944154f, 0.07716487f, 0.00497025f, 0.01468437f, 0.02765205f, 0.18128836f, 
    -0.05659379f, 0.13251285f, -0.02128695f, -0.02620389f, 0.02968236f, 0.13712616f, 0.03405849f, -0.02028275f, 
    0.03104054f, 0.05603354f, -0.16586529f, -0.06579402f, -0.26021338f, -0.03022836f, 0.03169070f, -0.09909381f, 
    -0.06450835f, 0.00386931f, 0.10274525f, 0.00117373f, 0.02824664f, 0.03450803f, 0.04171758f, 0.00463734f, 
    -0.01045202f, -0.01116177f, -0.00988434f, -0.01097199f, 0.07452549f, 0.04549840f, 0.02649232f, 0.07129174f, 
    -0.07905228f, 0.09945482f, -0.03464663f, -0.08497979f, -0.20311712f, -0.01907191f, 0.00901516f, 0.00560626f, 
    0.03083627f, -0.01754409f, 0.04681691f, 0.12900519f, 0.01516499f, 0.05574932f, -0.17902412f, -0.03416884f, 
    -0.01982453f, 0.02172504f, 0.06624085f, 0.04330180f, 0.17850731f, 0.06098406f, 0.27450895f, 0.09536553f, 
    -0.17124887f, 0.13506763f, 0.14984870f, 0.08880374f, 0.10362678f, -0.01594282f, 0.02414764f, 0.05211342f, 
    0.12723210f, -0.01398806f, -0.02871699f, -0.02138313f, -0.01897767f, -0.10871968f, -0.04444864f, -0.03095793f, 
    0.08020219f, 0.08737237f, -0.03937668f, -0.04196213f, 0.02450750f, 0.08733645f, 0.10247807f, 0.00423595f, 
    -0.01105722f, 0.01673608f, 0.04063006f, -0.02794979f, 0.08591173f, -0.06704775f, 0.04939920f, 0.03928047f, 
    0.04275254f, 0.07189705f, 0.05421277f, -0.06603078f, 0.25611907f, 0.06408803f, -0.06159864f, 0.10759322f, 
    -0.04934077f, 0.00761969f, -0.00202004f, -0.02514273f, 0.02551329f, 0.11373468f, 0.00342897f, -0.04867911f, 
    -0.11011645f, -0.01597006f, 0.03936667f, 0.02960262f, 0.06268388f, 0.10750055f, -0.06502403f, -0.09424108f, 
    -0.27704141f, -0.11480970f, 0.01138667f, -0.04045008f, 0.00991639f, -0.01768013f, 0.07176691f, 0.04697245f, 
    -0.13605340f, -0.05626227f, 0.02483078f, -0.01766626f, -0.10474204f, -0.04382560f, 0.05207168f, 0.00436870f, 
    0.09101360f, -0.03449245f, 0.01780590f, 0.01155508f, 0.21179438f, 0.09512001f, -0.23221724f, 0.02756346f, 
    0.06702723f, 0.01812075f, -0.11084778f, -0.04482896f, 0.07167000f, 0.11083749f, -0.00649033f, -0.00162087f, 
    0.03939696f, 0.15148027f, -0.06335339f, -0.02398683f, 0.10604861f, 0.11535661f, 0.08632264f, 0.09336492f, 
    -0.05387715f, -0.28297991f, 0.02040528f, 0.08293155f, 0.11416757f, 0.07556521f, 0.21515751f, 0.00399498f, 
    -0.07979742f, -0.01804134f, 0.02686731f, -0.05378137f, 0.02969208f, 0.12308978f, -0.08080343f, -0.00522693f, 
    0.05619461f, 0.00978201f, -0.14528368f, 0.02256817f, 0.02927823f, -0.05806234f, -0.25627452f, 0.08234758f, 
    0.03809357f, 0.01684793f, -0.02939364f, 0.00345898f, -0.01215644f, -0.05407805f, -0.04865653f, 0.00995299f, 
    0.01752783f, 0.09361058f, 0.15432374f, -0.05088132f, -0.04691773f, 0.00573797f, -0.01759464f, 0.01159812f, 
    -0.12408544f, -0.01364113f, 0.00374700f, 0.06126387f, -0.10433719f, 0.01136998f, 0.05848674f, 0.08504093f, 
    -0.14637730f, -0.00324012f, 0.03040452f, 0.13749626f, 0.05942860f, 0.02440831f, -0.05214008f, -0.09233296f, 
    0.06770141f, 0.00855030f, -0.05392046f, 0.03855412f, 0.08158958f, -0.05395705f, -0.06852829f, 0.19483097f, 
    -0.04185911f, 0.01184592f, 0.13751747f, 0.00097838f, 0.09442334f, 0.04224083f, 0.00958947f, 0.14075220f, 
    0.02172841f, 0.04673501f, 0.06248079f, 0.13748035f, 0.08457673f, 0.00933942f, 0.02587720f, 0.04258905f, 
    0.43371782f, 0.31060162f, -0.09143120f, 0.06359193f, 0.07767151f, 0.01946124f, -0.01829689f, -0.02683155f, 
    0.11216120f, 0.08850294f, -0.07945184f, 0.01460961f, 0.01954459f, -0.14801991f, 0.00148472f, 0.09311787f, 
    0.04331765f, 0.01818823f, 0.09211339f, 0.05666516f, 0.18485022f, 0.06643127f, -0.08121523f, 0.28302500f, 
    0.04661848f, -0.02508665f, -0.11238822f, -0.05567280f, -0.02448037f, 0.22570896f, 0.10710319f, -0.03991020f, 
    0.03017707f, 0.00755666f, 0.04274930f, 0.04111089f, -0.00560341f, 0.00378375f, 0.05493852f, 0.03038477f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.03825370f, 0.05067195f, 0.07772315f, 0.07726523f, -0.03455237f, -0.07096516f, -0.03747371f, 0.00533802f, 
    0.02875393f, 0.08378168f, -0.01148293f, 0.02006097f, 0.02053412f, -0.03575021f, 0.01327464f, 0.03619282f, 
    -0.01733896f, 0.01530973f, 0.01091921f, 0.02664448f, -0.03631516f, 0.07408749f, 0.00528733f, 0.02013001f, 
    0.01788513f, -0.02241287f, -0.04783445f, 0.01890125f, 0.00064371f, 0.02884449f, 0.05728981f, 0.03894250f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.00821733f, -0.22403091f, 0.28101295f, -0.00139527f, 0.07812276f, 0.67964256f, 0.05000455f, 0.05119914f, 
    -0.12076399f, -0.45473579f, 0.11064272f, 0.16446018f, 0.09236532f, 0.14343369f, 0.32432491f, -0.48910964f, 
    -0.12221799f, -0.04676321f, -0.06627326f, 0.08394550f, 0.15426902f, 0.33336425f, -0.11869097f, 0.11174024f, 
    -0.02918394f, -0.11523250f, -0.18740624f, 0.04488209f, -0.19701582f, -0.09812658f, -0.50943661f, -0.26231000f, 
    -0.13472946f, -0.04247971f, 0.29850048f, 0.26270622f, -0.02365525f, -0.55158669f, -0.09300603f, 0.06685763f, 
    0.13923280f, -0.13678466f, -0.01613719f, 0.10984539f, -0.18140598f, -0.10052551f, -0.28387237f, -0.49178374f, 
    0.08950140f, -0.02183235f, 0.09466545f, -0.07741655f, 0.02240361f, 0.21506146f, 0.13187532f, -0.14520039f, 
    0.08297303f, 0.05944246f, -0.63744962f, 0.00262083f, -0.13431628f, 0.00146186f, -0.11893781f, 0.29994932f, 
    0.06319523f, -0.40470076f, -0.27320001f, 0.23092964f, 0.07802987f, 0.05295248f, -0.02202230f, 0.01799805f, 
    0.16777381f, -0.25092819f, -0.04165608f, -0.62309408f, -0.04762708f, -0.14939451f, 0.20584506f, -0.39169818f, 
    -0.07336006f, -0.03336456f, -0.12273167f, -0.61994439f, 0.04088048f, -0.15725259f, -0.07912481f, -0.05667877f, 
    0.11129522f, 0.17734203f, 0.30898193f, -0.04100546f, -0.00228391f, 0.00767954f, 0.14939143f, 0.37346110f, 
    -0.04151230f, -0.23870355f, -0.31382665f, 0.12440134f, 0.04967218f, 0.33317587f, -0.06036716f, 0.08046382f, 
    -0.31234226f, 0.00668157f, -0.00692408f, 0.37505388f, -0.17634571f, -0.07523560f, -0.38824633f, -0.10972943f, 
    -0.04447920f, -0.02827400f, 0.04375319f, 0.30879009f, -0.17204551f, -0.07338552f, -0.84760165f, -0.13777679f, 
    -0.09242152f, 0.14090186f, 0.15831929f, -0.09135965f, -0.04566929f, -0.00424295f, 0.30926275f, 0.24614783f, 
    -0.03305106f, -0.10026716f, -0.13904777f, -0.01433577f, 0.16420475f, 0.16845287f, 0.06943794f, 0.08424692f, 
    -0.34803265f, -0.13621415f, 0.13048604f, -0.05274482f, -0.00625253f, 0.07244442f, 0.25167173f, 0.17231499f, 
    -0.07130168f, -0.13239351f, -0.05871339f, 0.38216606f, 0.14679328f, -0.31253889f, -0.19284029f, 0.16558941f, 
    -0.11935540f, 0.22242038f, 0.31248492f, -0.05574031f, -0.00605691f, -0.16089267f, -0.90456516f, 0.34577432f, 
    0.12066618f, 0.46903643f, 0.00271834f, -0.13412468f, -0.18147722f, -0.18842727f, -0.10329379f, 0.09835555f, 
    0.24994522f, -0.44478202f, -0.05067005f, -0.21931200f, 0.12703276f, 0.11819876f, -0.05126008f, 0.15608865f, 
    0.01968270f, -0.04321761f, -0.08739568f, 0.27871686f, 0.14890489f, 0.08534396f, -0.22985801f, -0.00270405f, 
    0.01408891f, -0.47096375f, -0.31388304f, -0.08672692f, 0.28805640f, -0.03507923f, -0.12655087f, -0.29394683f, 
    -0.16595475f, -0.74448925f, 0.15798552f, 0.23499388f, -0.07451389f, -0.01029570f, -0.08077618f, 0.10577819f, 
    0.01139597f, 0.47387999f, 0.14943793f, -0.38578951f, 0.02247033f, -0.06251505f, -0.05964893f, 0.34288380f, 
    0.08990791f, 0.13731784f, 0.11503549f, -0.15280634f, 0.01485555f, -0.30985680f, 0.03455439f, 0.02257807f, 
    -0.00194336f, -0.29059279f, 0.06534247f, -0.15555643f, 0.18912083f, -0.00762092f, -0.35178629f, -0.69846767f, 
    -0.15047529f, 0.10847018f, -0.42087290f, -0.44755542f, -0.15817273f, 0.25500092f, 0.01143207f, -0.13124166f, 
    0.28750691f, 0.25261605f, 0.03269765f, 0.21697497f, 0.00164671f, -0.16952063f, -0.34195894f, 0.11987171f, 
    -0.02504611f, 0.11805835f, -0.05461324f, 0.07255536f, 0.04177479f, -0.28622925f, 0.14704075f, 0.05523418f, 
    -0.16051933f, 0.16085701f, 0.28454047f, -0.00000938f, -0.15347962f, -0.17906702f, 0.17239209f, -0.36137232f, 
    0.04707843f, 0.39314410f, 0.07881124f, 0.18417895f, -0.17387107f, -0.51724839f, -0.01696972f, -0.14900787f, 
    -0.41022852f, -0.14410418f, -0.06502371f, -0.50227141f, 0.04144745f, -0.01847356f, -0.33498716f, -0.02681015f, 
    0.13224083f, -0.01777744f, -0.05000379f, -0.24920130f, -0.06719024f, 0.22690421f, 0.34632552f, -0.15896149f, 
    0.16241066f, 0.11460630f, 0.45502087f, -0.05590306f, -0.21078005f, 0.12291133f, -0.12923752f, -0.30559331f, 
    0.14735346f, -0.27687296f, 0.28701350f, -0.36745963f, 0.01756836f, 0.12814580f, -0.04513359f, 0.01800024f, 
    -0.11853123f, -0.41570157f, -0.05693636f, 0.08412508f, -0.06557603f, 0.09807181f, 0.22832975f, 0.11723228f, 
    0.06370362f, 0.07757038f, -0.17178328f, 0.00543765f, -0.09156083f, -0.57447445f, 0.50416493f, -0.12220297f, 
    -0.13795044f, -0.46145931f, 0.25034130f, 0.14968565f, 0.04079842f, 0.08164465f, 0.37525216f, 0.16108283f, 
    -0.08106817f, 0.21692404f, 0.02025918f, -0.03389833f, -0.06913155f, -0.34744179f, -0.15404224f, 0.13070498f, 
    -0.26941052f, 0.37282604f, 0.05675973f, 0.22609852f, -0.09086799f, 0.13726145f, 0.21975955f, -0.24081194f, 
    -0.16765928f, 0.14343756f, 0.12036247f, 0.05808539f, -0.04658833f, 0.33670613f, -0.16166599f, 0.17753319f, 
    0.10001703f, -0.50915182f, 0.05254505f, 0.04851662f, -0.36760941f, -0.15191217f, 0.33268940f, 0.34122512f, 
    0.08379290f, 0.12531464f, -0.20359237f, -0.21993296f, 0.03725770f, -0.08160388f, -0.05457750f, -0.07655705f, 
    0.11568157f, 0.33945981f, 0.13501854f, -0.28346902f, -0.00018004f, -0.01101570f, 0.29932347f, 0.26161075f, 
    -0.02165932f, -0.03553151f, 0.07872942f, -0.34608254f, 0.12378611f, -0.19868283f, -0.54042333f, 0.09263585f, 
    -0.11938141f, 0.45972154f, -0.45749623f, -0.04207997f, 0.21671267f, -0.04367091f, 0.24568306f, -0.25457025f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.07421373f, 0.02465945f, 0.08042645f, -0.15890419f, -0.16475697f, 0.19734232f, 0.00184597f, -0.06911850f, 
    0.06585626f, 0.10812739f, -0.10083112f, -0.04191486f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
