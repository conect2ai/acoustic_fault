#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    1.44805503f, 0.71723908f, -0.31518441f, 2.01701736f, 0.47162762f, 0.67970037f, 0.50662082f, -0.96677363f, 
    0.42706546f, -0.09510372f, -0.21585698f, -0.43575943f, -0.24144889f, 0.25415707f, -0.39070165f, -0.19199760f, 
    -0.03961648f, 0.22962400f, -0.24394153f, -0.25101668f, 0.07812412f, 0.00474275f, -0.07971476f, 0.00082848f, 
    0.19433370f, 0.82942659f, -0.84931147f, 1.05690575f, 1.37961769f, 0.50830948f, -0.16764084f, 0.02857067f, 
    0.56962436f, 0.05097983f, 0.14101064f, 0.64728761f, -0.11366474f, -0.10055184f, 0.19752052f, 0.39498019f, 
    -0.64958835f, -0.14266065f, 0.21726963f, 0.00317477f, 0.53870636f, -0.29833636f, 0.16772009f, 0.16479145f, 
    0.06420410f, 0.12672637f, 0.53656954f, -0.92298174f, -1.22277188f, -0.96759760f, -0.53512239f, 0.48825923f, 
    -0.51697952f, -0.54072994f, -0.90058684f, -0.49411565f, -0.54784399f, 0.14847133f, 0.40516883f, 0.72946304f, 
    0.32710072f, -0.17414248f, -0.21850656f, -0.19276588f, 0.39970165f, 0.14689493f, 0.32895443f, 0.11114871f, 
    0.09827251f, -0.20134430f, -0.05223705f, 1.27724671f, 1.00955510f, 1.01594853f, 0.45674267f, -1.61620533f, 
    -0.08746294f, -0.58778477f, 0.40103698f, -0.41110966f, 0.68259573f, 0.39394596f, 0.18649611f, 0.11736639f, 
    -0.10354230f, -0.46034560f, -0.18198405f, -0.10933329f, 0.28538248f, -0.02398336f, -0.17197958f, 0.09210286f, 
    0.19415002f, -0.13230520f, 0.06422406f, -0.10015978f, -0.50592357f, -1.08586955f, -1.21620929f, -0.54822582f, 
    -0.83927578f, 0.05144225f, -0.55699056f, 0.17574316f, 0.18633893f, -0.12720639f, -0.24216376f, -0.20636065f, 
    -0.14678821f, -0.04887890f, -0.36388731f, 0.15273656f, 0.14009814f, 0.11123320f, -0.38614124f, 0.48645115f, 
    0.27319756f, 0.79001373f, 0.28908545f, 0.02644511f, -0.25640932f, -0.05425073f, 0.23917115f, -0.04345971f, 
    -0.07627103f, 0.62623602f, -0.40403587f, -1.21421456f, -1.21068013f, -0.66745782f, -1.06175494f, -0.33463958f, 
    0.49445254f, 0.29360414f, 0.02780614f, -0.08847974f, -0.12973174f, -0.40027460f, -0.79173547f, -0.74214882f, 
    0.12886733f, -0.43562824f, 0.22898442f, 0.00823845f, 0.31575325f, -0.08537227f, -0.43281713f, 0.58262670f, 
    0.72463757f, 0.53924656f, 1.05544174f, 1.12718284f, -0.66166794f, -1.39723969f, -0.84923929f, -0.54330385f, 
    0.50941145f, 0.27878925f, -0.10800114f, 0.34282643f, -0.48661715f, 0.34204143f, 0.08986440f, -0.04183396f, 
    0.13376303f, 0.38223413f, 0.17912461f, 0.29777750f, 0.40995914f, -0.04292078f, -0.26681319f, -1.06565857f, 
    -0.48582855f, 1.39083695f, 0.75199616f, 0.41473433f, 0.87427944f, 1.31855750f, 0.42547551f, 0.15638959f, 
    0.45962590f, -0.14255123f, 0.00064810f, 0.58119094f, -0.37041828f, -0.36896053f, -0.29018387f, -0.26599774f, 
    -0.03774126f, -0.66142273f, -0.48056147f, 0.06752542f, 0.25700542f, -0.20834480f, 0.10024941f, -0.48850000f, 
    1.37360120f, 0.71946937f, -0.73874700f, 1.05292618f, 1.16494048f, -0.66994357f, -0.96367973f, 0.57632428f, 
    -0.07443363f, 0.24310429f, -0.21869944f, -0.06424164f, 0.10658488f, -0.12333786f, 0.01925816f, 0.14381379f, 
    -0.16555142f, 0.31736529f, 0.13167082f, 0.43815491f, 0.40310544f, 0.10523706f, 0.06545714f, 0.29100963f, 
    0.00599492f, -0.20353934f, -1.33344507f, 1.56536281f, 0.04909153f, -0.79779541f, 0.14581583f, 0.22998309f, 
    1.16658616f, 0.10245961f, -0.66697371f, -0.06294730f, -0.54003102f, -0.34463835f, 0.26351252f, -0.24732313f, 
    0.17841665f, -0.05261540f, -0.03654052f, 0.00464592f, -0.10731506f, -0.22419405f, 0.10429139f, -0.11309590f, 
    -0.49289662f, -0.27296978f, 0.96202821f, 0.97641712f, 0.40604916f, 0.96334690f, 1.35266125f, 0.77774024f, 
    0.16725571f, 0.61517930f, 0.12140415f, 0.67133015f, -0.91306013f, 0.32366017f, 0.00650688f, -0.04965831f, 
    0.20535764f, 0.01066748f, -0.24354629f, -0.00592250f, 0.00580440f, 0.04027211f, 0.06694535f, 0.15446767f, 
    -0.04015381f, -0.23229063f, 0.14787835f, 0.30722523f, -1.24176717f, -1.31675398f, -0.73459828f, -0.74616343f, 
    -0.29587889f, 1.28602064f, 0.95653182f, 0.69468260f, 0.47161061f, -0.50656039f, -0.19115219f, -0.45204601f, 
    -0.34112886f, -0.49017185f, -0.11768075f, 0.25286487f, 0.04914356f, 0.00706539f, -0.16489181f, 0.06886923f, 
    -0.00354523f, 0.05443345f, -0.56291997f, 0.17498277f, -0.75737321f, 1.29533041f, -0.43339860f, -1.22818708f, 
    -1.25459969f, 1.30867696f, 0.57768101f, -0.74462402f, 0.45011771f, 0.63705254f, 0.42190710f, -0.24507391f, 
    -0.40909988f, 0.06906538f, -0.06373585f, 0.04266756f, 0.09990143f, 0.20771015f, 0.10690039f, -0.06701782f, 
    -0.22399448f, -0.24244897f, 0.04557620f, 0.17252980f, 0.16425453f, 0.25950447f, 1.28269553f, 0.39742795f, 
    0.20734195f, 0.33004636f, 0.37538803f, -0.10425270f, -0.64493674f, 0.24335608f, -0.50564492f, 0.71863014f, 
    -0.25548536f, 0.49984172f, 0.49247429f, 0.39395031f, 0.07035001f, 0.72443104f, 0.39616695f, -0.24514075f, 
    0.49026009f, -0.28736380f, 0.00453000f, -0.10760629f, -0.23214495f, 0.66714650f, 1.64939749f, 0.88343447f, 
    -0.96276999f, -0.54692376f, -0.92395538f, -0.35270736f, 0.54461396f, 0.67304498f, 0.41418400f, 0.71187752f, 
    0.30187446f, 0.08875062f, 0.46839717f, -0.23927777f, 0.44280136f, -0.21575555f, 0.13727202f, -0.23752615f, 
    0.32346851f, 0.34821656f, 0.02621778f, -0.30621928f, -0.18723710f, 0.07799789f, -0.25024405f, 0.08927067f, 
    0.54630196f, 0.86331052f, 0.50530440f, 0.87733942f, -1.24193692f, -0.03344591f, 0.01954469f, -1.07982814f, 
    0.20877089f, 0.70294207f, 0.37344453f, 0.38791013f, 0.62266457f, 0.01186651f, 0.28583938f, 0.37742305f, 
    -0.00997536f, 0.59259909f, -0.20928401f, -0.00904986f, 0.13221668f, -0.43231010f, 0.36502832f, 0.31714016f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.36330512f, 0.26353115f, 0.37838441f, 0.17866629f, 0.37157783f, 0.32495263f, 0.36847043f, 0.17547968f, 
    0.08414090f, 0.15947866f, 0.20352450f, 0.07250952f, 0.38928059f, 0.27879950f, 0.55428553f, 0.23846003f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.09371242f, 0.21784587f, -0.20814563f, 0.52393609f, -0.16982871f, 0.02688620f, -0.03660638f, 0.08441202f, 
    -0.12147211f, 0.08234276f, -0.11977851f, -0.04559818f, 0.43028650f, -0.17161311f, -0.53022432f, 0.40865746f, 
    -0.26189920f, 0.00071839f, 0.06897658f, -0.02586849f, -0.18187110f, -0.09054559f, -0.27447417f, 0.07914879f, 
    -0.34181967f, -0.50753045f, 0.28894222f, -0.07282414f, -0.02605828f, -0.12346943f, 0.09048132f, -0.12102404f, 
    -0.22003557f, 0.07333239f, -0.25793448f, -0.02066832f, -0.28372538f, 0.37093467f, -0.24125697f, 0.07703593f, 
    -0.28104150f, -0.25005320f, -0.11827164f, -0.13934720f, -0.18021567f, 0.03555116f, -0.15646030f, 0.02383781f, 
    0.10148701f, -0.31664518f, 0.12009169f, -0.23662858f, 0.00763928f, -0.04180670f, 0.14696956f, -0.03606242f, 
    -0.27145353f, -0.16788167f, 0.11172767f, 0.00287783f, -0.08113575f, -0.14923096f, 0.33627376f, -0.09357017f, 
    0.24637190f, -0.12287968f, -0.07348343f, 0.05316067f, -0.17908636f, -0.25545135f, -0.18272811f, -0.17703356f, 
    -0.19705944f, -0.04564100f, 0.03442117f, -0.20525861f, -0.11556695f, -0.09720934f, -0.03705471f, -0.21828236f, 
    0.05184939f, 0.00611905f, -0.05005364f, -0.10570345f, -0.32424495f, 0.29848045f, 0.08320212f, 0.27140445f, 
    -0.12015446f, 0.14277253f, 0.19603911f, -0.09978481f, -0.11243229f, 0.02457085f, 0.08124726f, 0.01054295f, 
    0.63785428f, 0.14170939f, 0.37501630f, 0.26162526f, -0.20343649f, 0.18388200f, -0.14756256f, 0.10795216f, 
    -0.09503018f, -0.11521598f, 0.08338233f, 0.05817934f, -0.17445761f, 0.08154996f, 0.10417305f, 0.59467185f, 
    -0.24281137f, -0.12474857f, 0.31088981f, -0.10276867f, 0.22301076f, -0.12325782f, -0.12178971f, -0.22417742f, 
    0.37917909f, -0.19922964f, -0.09576496f, 0.10618930f, -0.10966087f, -0.03016442f, 0.06099299f, 0.13974765f, 
    0.16912797f, 0.08537602f, -0.12645487f, 0.04598674f, 0.00529034f, 0.26065126f, -0.11588207f, -0.51848042f, 
    -0.05266032f, -0.02156613f, 0.15746705f, -0.02128618f, 0.01804557f, -0.02634254f, 0.05144025f, 0.16953211f, 
    0.96557522f, -0.15400818f, 0.09709941f, -0.49981445f, -0.21224359f, 0.01839953f, 0.10798644f, -0.24855521f, 
    0.07002755f, 0.09555902f, -0.00846926f, -0.01691810f, -0.00160648f, -0.07267859f, 0.08472792f, -0.27376685f, 
    -0.44249761f, -0.24527298f, 0.04803258f, 0.06956432f, 0.11028737f, 0.08482680f, -0.11368746f, 0.21091807f, 
    -0.47499323f, -0.29136738f, 0.00601903f, -0.39330053f, 0.03689475f, -0.21356235f, 0.00410982f, 0.15855543f, 
    0.09968659f, -0.11009912f, 0.14917670f, 0.36634904f, 0.05808445f, 0.18097712f, -0.21784537f, 0.11105455f, 
    0.02117352f, 0.02616208f, -0.06894332f, -0.18056433f, 0.06843361f, 0.09359997f, 0.14201404f, -0.10445967f, 
    0.41631538f, -0.37637219f, 0.09889466f, 0.20238732f, -0.03378196f, -0.01723221f, -0.06705855f, 0.21049632f, 
    -0.03461732f, -0.03650090f, -0.02580313f, -0.17184412f, -0.36091068f, 0.29025969f, 0.30130082f, 0.47466338f, 
    -0.17459363f, -0.08342148f, 0.01566025f, -0.03179913f, -0.01424590f, 0.11746000f, 0.11462880f, -0.10226578f, 
    0.24131544f, -0.15330617f, 0.12772270f, -0.12858386f, -0.02472473f, -0.04911674f, 0.13903971f, 0.12546720f, 
    -0.23568405f, 0.10981400f, 0.07427265f, -0.03538924f, -0.02528513f, 0.13314204f, -0.01775562f, 0.20295063f, 
    -0.20071237f, -0.13066755f, 0.12336559f, 0.06118119f, 0.00765296f, -0.02627363f, -0.00315139f, -0.00048092f, 
    -0.13896100f, -0.06388570f, 0.15634331f, -0.21986748f, -0.07648121f, -0.09640677f, 0.05858536f, 0.28806379f, 
    0.30462176f, 0.11732563f, -0.08361519f, 0.15874465f, -0.06452169f, -0.49073863f, -0.03227755f, -0.65127337f, 
    0.05458984f, 0.06982008f, 0.24780208f, -0.09963846f, 0.00887495f, 0.01359246f, -0.18456469f, -0.12929386f, 
    0.16475472f, -0.07508714f, -0.02353081f, -0.03939999f, -0.07528011f, 0.04744801f, -0.08603105f, -0.07577583f, 
    -0.15323836f, 0.00447013f, -0.05774758f, 0.11207801f, -0.16362928f, 0.30747643f, -0.06990142f, 0.15935276f, 
    -0.16047899f, 0.25926402f, -0.05542754f, -0.06583810f, -0.10776641f, -0.09587607f, 0.05179097f, -0.11359832f, 
    0.07941133f, -0.21926077f, 0.00251108f, 0.40737632f, -0.02045754f, -0.14039265f, -0.12394638f, 0.10813142f, 
    0.14513689f, -0.00548838f, -0.22721913f, 0.27315861f, -0.77835655f, 0.25107360f, -0.28156427f, 0.00510210f, 
    0.03345776f, -0.13321637f, -0.15644254f, -0.25877991f, -0.01917218f, 0.18151999f, -0.02801450f, -0.08727828f, 
    0.75988424f, 0.12723574f, -0.03720144f, 0.31910717f, -0.01884622f, 0.06573230f, 0.04999189f, -0.03461447f, 
    0.15819331f, -0.02488994f, 0.13362171f, -0.04701591f, 0.48443016f, -0.54757303f, 0.05544990f, -0.27061036f, 
    0.12780397f, -0.11104164f, -0.22240996f, 0.27377385f, 0.07549772f, -0.11114114f, 0.00137958f, -0.18559423f, 
    -1.02250612f, -0.46946442f, -0.06771046f, -0.49445397f, -0.06573134f, -0.11193869f, -0.05900145f, -0.04501833f, 
    0.00899100f, 0.01222895f, -0.06007716f, -0.04106249f, 0.20112036f, 0.29498342f, -0.03426526f, -0.18887441f, 
    0.00100695f, -0.04503070f, -0.08244807f, -0.11199799f, 0.03003302f, 0.20633282f, 0.13289143f, 0.01388722f, 
    0.79701930f, -0.27832523f, 0.21069252f, -0.24751377f, 0.01700989f, -0.15248744f, -0.14366686f, -0.01382980f, 
    -0.23741598f, 0.14959961f, -0.11125711f, 0.07014965f, -0.33223575f, 0.04605889f, 0.01116718f, -0.05040404f, 
    -0.09787223f, -0.08658770f, -0.06419609f, 0.13262899f, 0.05111118f, 0.13389713f, -0.08164699f, 0.00354827f, 
    0.21333568f, -0.39723307f, -0.09215700f, -0.09937093f, 0.29025117f, 0.01635617f, 0.04190474f, -0.01498589f, 
    -0.09049192f, 0.31677637f, -0.11274691f, 0.02087963f, -0.05579067f, 0.33645713f, -0.21589181f, 0.08163393f, 
    0.08058799f, 0.14219271f, -0.17955953f, 0.18873742f, -0.11794461f, -0.02649732f, -0.04470555f, -0.10703573f, 
    -1.20017660f, -0.17903988f, -0.19895680f, -0.66961569f, -0.23268488f, -0.29541516f, -0.01899929f, -0.09037988f, 
    0.04883398f, -0.00004007f, -0.30854791f, 0.08021925f, -0.67078620f, -0.10183673f, 0.07150068f, -0.16951172f, 
    -0.11020608f, 0.28048551f, -0.05345886f, 0.06088810f, -0.10495827f, 0.08337647f, -0.14212725f, 0.02446262f, 
    -0.37337166f, -0.02523701f, 0.13846439f, 0.19228247f, -0.26836357f, -0.28682357f, -0.10298502f, -0.18450008f, 
    0.00099621f, -0.03006963f, -0.01040172f, -0.17186703f, -0.39788958f, -0.06212394f, -0.49800032f, -0.40796170f, 
    0.36092389f, 0.15989159f, 0.05015638f, -0.06723444f, -0.15890934f, 0.30010417f, 0.08565304f, -0.30722547f, 
    0.34228060f, 0.03025350f, -0.06305463f, 0.10907596f, 0.24243645f, 0.09594557f, 0.00931035f, -0.10548607f, 
    0.04740281f, -0.20024996f, -0.07002994f, -0.25664163f, 0.71247756f, -0.23689319f, 0.19328648f, -0.00450042f, 
    -0.22145903f, -0.04733843f, 0.08137067f, -0.07243197f, 0.02342156f, 0.03383885f, -0.03583739f, -0.20998630f, 
    0.13779679f, -0.01846249f, -0.24413037f, -0.17999518f, 0.18808995f, -0.09826240f, 0.17614466f, 0.07611924f, 
    -0.06244073f, -0.05700655f, 0.06664144f, -0.01984751f, -0.40087676f, 0.08587018f, -0.44131771f, -0.34707630f, 
    -0.26690811f, 0.02112651f, 0.02483451f, 0.20327015f, 0.19169660f, 0.11290973f, -0.03022443f, -0.12143245f, 
    -0.14171956f, -0.23926146f, 0.14324041f, 0.07212780f, -0.01262016f, 0.09538453f, -0.03464760f, -0.05108725f, 
    0.06739158f, 0.21626765f, 0.05786207f, 0.15501595f, 0.71686560f, 0.28651604f, 0.18482552f, 0.59535110f, 
    -0.15712543f, -0.48974669f, 0.25301155f, 0.19431145f, -0.10109107f, 0.07771933f, -0.12360115f, 0.08790497f, 
    0.44118854f, 0.08617648f, 0.11132078f, 0.10014760f, 0.13682990f, -0.10334273f, 0.04325118f, -0.09582788f, 
    -0.12756126f, 0.07491274f, -0.01395461f, -0.11836325f, 0.01949281f, 0.04696282f, -0.16407347f, 0.02274043f, 
    0.24140435f, -0.14606763f, 0.22189078f, -0.04162609f, -0.12778093f, -0.08789118f, -0.27780589f, 0.08757669f, 
    -0.03039500f, 0.17585006f, -0.06061558f, -0.12261465f, -0.24560131f, -0.31723619f, 0.21739000f, -0.06336784f, 
    -0.25109518f, -0.16593412f, 0.06190849f, -0.14037731f, 0.69612479f, 0.06774225f, -0.45851821f, 0.09894616f, 
    0.06862253f, 0.11343643f, 0.08688112f, -0.07873034f, -0.25335306f, 0.03175151f, -0.09118848f, -0.11500811f, 
    0.08376261f, -0.49972534f, -0.46274820f, -0.02677147f, 0.01235298f, -0.07757424f, 0.01803271f, -0.14157584f, 
    -0.07005109f, -0.25999650f, 0.20441251f, -0.04502866f, -0.14877751f, -0.07703445f, 0.11578306f, -0.04792821f, 
    -0.22937465f, 0.22793351f, 0.07836001f, 0.22865808f, -0.00130344f, 0.04241898f, 0.02416935f, -0.29509905f, 
    0.31117415f, -0.07171658f, 0.03011580f, 0.01291835f, -0.10161883f, 0.07389492f, -0.13172108f, 0.15647794f, 
    -0.22384845f, 0.08017065f, 0.10198727f, -0.02225535f, -0.00608518f, -1.21022642f, -0.37577099f, 0.41515249f, 
    -0.04829344f, 0.15430443f, 0.08580582f, -0.10488389f, -0.19754404f, -0.02417806f, -0.17214449f, 0.17220888f, 
    0.24482818f, -0.10315375f, -0.27450275f, -0.20347251f, -0.41854119f, 0.09831236f, 0.08019599f, 0.15371335f, 
    -0.19567807f, -0.05117726f, -0.12404463f, 0.05040962f, 0.38688570f, 0.12855239f, 0.13990234f, 0.29788655f, 
    0.12939130f, 0.02020180f, -0.18268692f, 0.20474556f, 0.16448236f, 0.01496885f, 0.07458122f, -0.27830628f, 
    0.72095597f, -0.24714728f, 0.00505799f, 0.54272908f, 0.10781176f, 0.18175247f, -0.08013663f, 0.06709757f, 
    -0.16042748f, -0.00694923f, 0.03964723f, -0.31752914f, -0.17697443f, -0.05525691f, -0.24092804f, -0.14820936f, 
    0.02667818f, -0.10685177f, 0.03552559f, 0.00776284f, 0.29518741f, 0.11553442f, 0.05218819f, -0.07911490f, 
    0.46161637f, -0.21909675f, -0.02588035f, 0.15435044f, 0.09956285f, 0.27622446f, 0.08598486f, -0.07635137f, 
    0.05896225f, -0.15680717f, 0.05860925f, -0.13392682f, 0.36272418f, 0.14292774f, 0.32264370f, -0.11659036f, 
    -0.06736302f, 0.09967431f, 0.04152280f, 0.07312774f, 0.14919502f, 0.04923713f, 0.03576319f, 0.01246894f, 
    -1.35906672f, -0.79057723f, -0.32938075f, 0.08253837f, -0.12061568f, -0.11846584f, -0.15379219f, -0.21068895f, 
    0.05456372f, -0.23082985f, -0.03574630f, 0.10319466f, 0.01821034f, -0.28218454f, -0.00171319f, 0.01713145f, 
    -0.28503466f, 0.08075567f, -0.00577723f, -0.16477686f, -0.25283101f, 0.24628030f, -0.03543880f, 0.21502599f, 
    0.04741222f, 0.52540278f, 0.17235254f, -0.29509944f, -0.13042113f, 0.11685494f, -0.06339122f, 0.08993845f, 
    -0.05857299f, -0.14970013f, -0.08591605f, 0.06721440f, 0.31802052f, 0.09974470f, 0.03378718f, 0.02369596f, 
    0.08457858f, -0.07467442f, 0.04631651f, 0.16727169f, -0.05571736f, -0.01320661f, 0.03255561f, -0.18355717f, 
    -0.14680627f, -0.49996608f, -0.17998405f, 0.28010190f, -0.30567333f, 0.01126281f, -0.14054006f, 0.15738709f, 
    -0.02887917f, -0.08711758f, 0.07225780f, 0.02813231f, -1.05460107f, -0.33235815f, 0.31858963f, 0.27027819f, 
    0.16640751f, 0.03061801f, 0.39591235f, -0.23495986f, -0.12659304f, -0.07317051f, -0.09997004f, -0.07466091f, 
    0.45347044f, 0.50198346f, 0.06171543f, -0.07630189f, -0.12807263f, 0.18440174f, -0.06214768f, 0.04551558f, 
    -0.10931870f, -0.09658976f, 0.11871979f, 0.09839592f, -0.27271190f, -0.00599152f, 0.16795024f, -0.13565226f, 
    0.15981206f, 0.03167274f, -0.06466328f, -0.02183912f, 0.10859556f, -0.20149931f, 0.01106106f, -0.04891267f, 
    -0.12845936f, 0.47616574f, -0.00422911f, 0.15911146f, 0.03755831f, -0.02121765f, 0.09091521f, 0.24480183f, 
    0.02644644f, -0.14038979f, -0.08809385f, 0.08016011f, -0.59770286f, -0.54865581f, 0.11150254f, -0.34442225f, 
    -0.19813193f, 0.00115736f, -0.04192412f, 0.01911009f, 0.15671732f, -0.06259134f, -0.08773622f, -0.01594453f, 
    0.04304402f, -0.07287858f, -0.12705590f, 0.10356490f, 0.02448563f, 0.17166005f, -0.18240876f, 0.18679778f, 
    0.04803856f, 0.14030372f, 0.01468691f, -0.15181756f, -0.14473668f, -0.13838212f, 0.37042257f, 0.14261469f, 
    -0.21118101f, -0.06279731f, -0.11302501f, 0.09311129f, -0.18299532f, -0.10449313f, 0.28989011f, 0.21964569f, 
    -0.37326744f, 0.24181463f, 0.30848032f, -0.28181791f, -0.12072238f, 0.07494471f, -0.22472160f, 0.05888683f, 
    0.08149515f, -0.18826844f, -0.12631342f, 0.04379568f, -0.42297807f, 0.57226765f, -0.14909834f, -0.19788608f, 
    0.14384371f, -0.19799843f, 0.20205344f, 0.23804460f, -0.01321609f, -0.00518345f, -0.09891731f, -0.01541464f, 
    0.30260956f, -0.31182867f, -0.08843298f, 0.15055723f, -0.40790933f, -0.03135863f, 0.07819869f, -0.24159153f, 
    0.21661183f, 0.20333649f, -0.07855219f, -0.31754988f, -0.02784632f, -0.07735454f, -0.00897312f, -0.39899862f, 
    0.01359411f, 0.13994600f, 0.07736867f, 0.14899188f, -0.00968796f, 0.13798887f, -0.13390972f, 0.19951829f, 
    0.17474768f, -0.14991468f, -0.26322463f, 0.25823393f, -0.02673861f, -0.06493231f, 0.13788599f, 0.19449045f, 
    -0.05282304f, -0.01444850f, 0.05851826f, 0.17159647f, -1.02513826f, 0.08229763f, 0.26337463f, 0.26282647f, 
    -0.03514656f, -0.06368457f, 0.14109018f, -0.13194585f, -0.08829544f, 0.03841195f, 0.22733778f, 0.12179761f, 
    0.13517332f, -0.18540421f, 0.21097197f, 0.23382977f, 0.10498659f, -0.11212382f, -0.04324479f, 0.12656726f, 
    0.10858548f, 0.06832574f, 0.03526075f, 0.03736629f, -0.27992219f, 0.02003865f, 0.07806344f, 0.12655292f, 
    -0.02022182f, 0.19308503f, 0.12243435f, -0.06473741f, -0.09417287f, -0.04412907f, 0.02474628f, -0.11684145f, 
    -0.02677543f, -0.34622666f, -0.12307214f, -0.06297930f, 0.02570633f, 0.19669455f, -0.00838978f, -0.38063371f, 
    0.07100882f, -0.10959132f, 0.06010639f, -0.10535112f, -0.50845963f, -0.42628431f, 0.23487371f, 0.13166237f, 
    -0.25751725f, -0.29514515f, -0.06795585f, 0.02852385f, 0.09237286f, 0.02302125f, -0.18920046f, -0.17977637f, 
    -0.23697381f, -0.00527150f, 0.23167747f, -0.16706038f, -0.24249208f, -0.03826245f, -0.02900429f, -0.06486991f, 
    0.24229898f, -0.20478198f, -0.03428608f, -0.01466571f, -0.11585046f, 0.11734066f, 0.10976448f, -0.13795172f, 
    -0.06332210f, 0.25309676f, -0.04445072f, -0.04981454f, -0.07057385f, -0.04738680f, 0.27431861f, 0.03346589f, 
    -0.27151650f, -0.21439566f, -0.05470174f, 0.28258479f, 0.14553426f, -0.13520965f, -0.16582057f, 0.13337898f, 
    0.25994685f, 0.20842409f, 0.64812756f, -0.08304382f, 0.40423846f, 0.27666938f, -0.06367725f, -0.00467177f, 
    -0.03104984f, 0.10074064f, -0.05627888f, 0.16297039f, 0.17903934f, -0.14763772f, 0.22265875f, -0.22276375f, 
    -0.24565355f, -0.39176780f, -0.41730905f, 0.14488162f, 0.44599992f, 0.20570880f, 0.19487458f, 0.10902426f, 
    0.03094921f, 0.15020540f, -0.27577314f, -0.14362931f, -0.01040924f, 0.17280954f, 0.11575674f, 0.34736368f, 
    -0.27400637f, -0.26043242f, 0.06235279f, -0.04943883f, -0.35187820f, -0.07237615f, 0.00314075f, 0.17965239f, 
    -0.19717874f, -0.16586286f, 0.19762634f, 0.28730777f, -0.11468204f, 0.13728602f, 0.24364151f, 0.01081425f, 
    -0.00757701f, 0.30149344f, 0.02282224f, 0.17778830f, -0.58052438f, -0.10463215f, 0.27783433f, -0.11276226f, 
    0.19289324f, -0.29601827f, -0.03773127f, -0.02909079f, 0.09030645f, -0.10122681f, -0.11011142f, -0.25855026f, 
    -0.19141361f, 0.00840501f, -0.02643173f, -0.64353895f, -0.17358375f, -0.09392475f, -0.09947344f, 0.09849959f, 
    -0.11928973f, 0.16982880f, 0.22314249f, 0.14503931f, -0.46489906f, -0.09848125f, -0.06955901f, 0.23561479f, 
    0.16147782f, -0.09135661f, -0.06042522f, -0.17933464f, -0.05247106f, -0.12491565f, 0.04550060f, -0.08931489f, 
    -0.09047898f, 0.29277444f, 0.48796293f, -0.35842615f, -0.06355088f, 0.10801049f, -0.04219455f, -0.00790921f, 
    -0.09874493f, 0.08814891f, -0.06169787f, 0.00707472f, -0.09328980f, -0.03088304f, -0.61401093f, -0.20199916f, 
    0.20719585f, 0.19660610f, -0.24003267f, -0.11559837f, 0.07123670f, -0.21246617f, -0.16856562f, -0.09061641f, 
    0.00181479f, -0.09823261f, -0.23918705f, 0.01956648f, 0.13574056f, -0.01079651f, 0.08681709f, -0.10856485f, 
    0.05200303f, -0.13398944f, 0.06991217f, -0.10119189f, 0.07030410f, -0.16131267f, 0.32887641f, 0.02676374f, 
    -0.22976236f, 0.15214965f, 0.15122552f, -0.24772577f, -0.22403410f, -0.01354548f, 0.05638840f, 0.29599723f, 
    0.16552705f, 0.30560884f, -0.08567229f, -0.12646492f, -0.23146120f, -0.19771980f, -0.06015245f, -0.26330304f, 
    -0.19869342f, 0.02291774f, 0.07330123f, -0.07591823f, 0.16500190f, 0.04717952f, 0.30613998f, -0.12315623f, 
    -0.19659719f, 0.09024214f, -0.04813398f, -0.08747649f, -0.14846937f, -0.16696133f, 0.22037484f, 0.28352353f, 
    -0.31373808f, 0.18128909f, 0.01658768f, -0.19443597f, -0.22127753f, 0.09505001f, -0.04009172f, 0.07934328f, 
    0.05867479f, 0.15276583f, -0.04248552f, -0.01000146f, 0.66444212f, -0.17007466f, 0.18377128f, -0.25976092f, 
    -0.06631197f, -0.13195096f, 0.09344295f, 0.16196206f, 0.19495620f, -0.12525830f, -0.10942058f, 0.05789697f, 
    -0.00487985f, -0.09226101f, -0.18602332f, -0.08509187f, -0.03189591f, 0.13669497f, 0.19360323f, -0.24053602f, 
    0.08941940f, -0.19875763f, -0.31607175f, 0.07914184f, -0.33489344f, 0.09225017f, 0.27066964f, 0.11708599f, 
    -0.07919850f, 0.05448372f, -0.11145912f, 0.08239720f, -0.21969727f, 0.00452005f, -0.14604673f, 0.10032725f, 
    -0.29959252f, 0.18906523f, -0.37799710f, -0.24502683f, -0.19710377f, -0.17164208f, -0.16788992f, -0.19236502f, 
    -0.04278404f, -0.07873968f, 0.18037882f, 0.11757308f, -0.07084535f, 0.06237777f, -0.27473131f, -0.07490689f, 
    -0.04183668f, 0.20478971f, 0.04816170f, -0.06801042f, 0.28453884f, -0.06736158f, 0.11977978f, 0.11192068f, 
    0.27123570f, -0.09361022f, -0.08872482f, -0.52651584f, 0.06388091f, 0.09970393f, -0.00015575f, 0.14220946f, 
    0.06203727f, -0.11233193f, -0.02633168f, -0.17446426f, 0.91398805f, -0.94535905f, -0.03122265f, 0.17241955f, 
    -0.15364444f, -0.04239978f, -0.02433897f, 0.06110386f, 0.08593840f, -0.00263905f, 0.13944450f, 0.25762853f, 
    0.13221939f, 0.22122376f, 0.33147639f, -0.50701821f, -0.10955412f, 0.22350350f, 0.00776663f, -0.25328925f, 
    -0.15741707f, -0.11357833f, -0.03446244f, -0.14594345f, -0.20348601f, -0.61392683f, -0.13985731f, 0.14082240f, 
    -0.05982235f, 0.33763459f, 0.07067371f, -0.05542679f, -0.24466017f, -0.06067081f, 0.14843760f, 0.02272491f, 
    -0.38688686f, 0.16262546f, 0.26455721f, -0.27523115f, -0.36605564f, 0.06824375f, -0.11574931f, 0.18125427f, 
    -0.06491078f, -0.12930350f, 0.14041542f, 0.00148943f, -0.17165993f, -0.51130408f, 0.00294488f, -0.17864560f, 
    0.03948909f, -0.09702696f, 0.03596148f, -0.21297194f, -0.07771349f, 0.04031389f, 0.26730207f, 0.37957683f, 
    0.06629987f, -0.12044137f, -0.36605448f, 0.58533585f, -0.18647139f, 0.28043348f, 0.02082590f, 0.09418629f, 
    -0.07009470f, 0.25137925f, -0.13849188f, 0.04880250f, 0.09770377f, 0.23967540f, -0.18387756f, 0.16339646f, 
    -0.17444405f, -0.11888332f, -0.03808349f, 0.14637241f, 0.25123066f, -0.12480839f, -0.18493576f, -0.51343977f, 
    -0.47119054f, -0.06359734f, -0.12810853f, 0.42046264f, 0.24921748f, 0.22094728f, 0.03720718f, 0.14371663f, 
    0.00119351f, -0.08591711f, -0.04295637f, -0.29290670f, 0.14363623f, 0.27391088f, 0.09576808f, -0.17771256f, 
    -0.04823073f, 0.03013548f, 0.10679730f, -0.06703227f, 0.00208266f, -0.12693122f, -0.14466101f, 0.07781872f, 
    -0.86303663f, 0.58882540f, 0.09940959f, -0.10761517f, -0.17525494f, -0.07239665f, -0.00694646f, -0.13574487f, 
    -0.12439390f, -0.04744123f, -0.10456444f, -0.08762755f, 0.65773904f, 0.01510618f, -0.27094135f, -0.39389658f, 
    -0.12062391f, 0.04470660f, 0.03629520f, -0.15080941f, 0.10623615f, -0.00631208f, -0.05623682f, 0.00856142f, 
    0.14518644f, 0.38747257f, 0.14365770f, 0.25931436f, -0.14693271f, 0.01448315f, -0.12889741f, -0.09813239f, 
    -0.12317173f, -0.16970816f, -0.17409414f, -0.10164398f, -0.27503997f, -0.22068559f, -0.35275775f, -0.39089045f, 
    -0.00493506f, 0.06797187f, 0.12507311f, -0.07268360f, -0.14559697f, -0.15017691f, 0.01216776f, -0.11715421f, 
    0.23658378f, 0.45251715f, 0.08646984f, 0.50676697f, 0.33730075f, 0.29003152f, -0.04032946f, -0.09709932f, 
    -0.08953834f, 0.06923641f, 0.08882196f, -0.20257765f, -0.01400178f, 0.04771303f, -0.06496722f, 0.30775338f, 
    -0.11291473f, -0.28985542f, -0.16615340f, -0.11672669f, -0.29340506f, 0.04033015f, -0.00226298f, -0.03111831f, 
    -0.91575015f, 0.28778887f, -0.38040134f, 0.11115581f, -0.19319524f, -0.08179960f, 0.05763833f, 0.00582811f, 
    0.03266055f, 0.02135982f, 0.30076021f, -0.10166273f, -0.14872620f, -0.11568850f, 0.02272030f, -0.12951814f, 
    0.17937022f, 0.09258435f, -0.12616353f, -0.16385506f, -0.07897006f, -0.21219720f, -0.01696368f, -0.07408558f, 
    -0.33098498f, 0.31858015f, -0.06856423f, -0.36424196f, 0.15714860f, 0.10304815f, -0.14962666f, -0.15965748f, 
    -0.29548112f, -0.10749698f, -0.01125901f, -0.21471536f, 0.33721071f, -0.14986439f, 0.05225389f, 0.18035193f, 
    -0.06677561f, 0.04252233f, -0.10310740f, 0.07423611f, 0.00869090f, -0.08746532f, -0.10971145f, 0.04022224f, 
    -0.14610866f, 0.18540813f, -0.07485171f, -0.07828864f, -0.04721548f, 0.12012840f, -0.04603657f, -0.10834567f, 
    -0.16429999f, 0.02084899f, -0.04763142f, 0.06396674f, 0.45830905f, 0.25935605f, 0.32162833f, 0.18090102f, 
    0.08974318f, 0.23430625f, 0.19315861f, -0.16238283f, -0.02365193f, 0.20787327f, -0.08295189f, -0.20087212f, 
    -0.15561819f, 0.56591141f, -0.23439215f, 0.49173537f, 0.48066896f, -0.24394915f, 0.06989525f, 0.11646995f, 
    -0.04445055f, 0.03464227f, -0.02036882f, -0.03339302f, -0.79368168f, -0.05731062f, 0.00928694f, 0.16346760f, 
    -0.07557023f, 0.11017609f, -0.00100986f, 0.07872058f, -0.01142772f, -0.03409277f, 0.09212253f, -0.06051642f, 
    -0.45914501f, 0.13227089f, -0.28958753f, -0.08503717f, -0.11989073f, -0.07710984f, -0.01614804f, -0.09203088f, 
    0.06180298f, 0.01767371f, -0.07795823f, -0.17626335f, 0.12324679f, -0.41696724f, -0.02813812f, 0.02559548f, 
    0.01157381f, -0.11206713f, 0.01052660f, 0.04157651f, 0.04889810f, -0.19179690f, -0.01455085f, -0.09354737f, 
    0.28418407f, -0.50547218f, 0.18355578f, 0.46129495f, 0.09209696f, -0.09875565f, -0.13154580f, -0.12712027f, 
    0.14192946f, -0.23944750f, 0.27804032f, -0.23767044f, 0.15451470f, -0.41449103f, 0.14521682f, 0.18973082f, 
    0.22908786f, -0.20889409f, 0.03764062f, -0.26148728f, -0.14569847f, 0.21877599f, -0.06948616f, 0.00461935f, 
    -0.25561863f, 0.21190092f, -0.21739854f, -0.67202252f, 0.00544344f, 0.00341334f, -0.23353672f, 0.00025006f, 
    0.09417568f, -0.01751622f, 0.12083779f, -0.26347765f, 0.42480052f, -0.21555163f, -0.20650171f, 0.12294889f, 
    0.22892888f, -0.04129489f, -0.06391090f, 0.02372256f, 0.04470974f, 0.09861398f, 0.10987139f, 0.04665718f, 
    -0.47670695f, 0.18452413f, 0.53513944f, -0.22967179f, -0.09223736f, -0.13943268f, 0.06399648f, 0.21355456f, 
    0.08286691f, -0.07663996f, -0.04918180f, 0.01439541f, -0.47174871f, -0.26045224f, -0.59705311f, -0.74529022f, 
    -0.12630177f, 0.04808402f, -0.24490568f, -0.00563220f, 0.03274499f, 0.16864756f, 0.03355707f, -0.37739253f, 
    -0.56646502f, -0.21849456f, -0.17414565f, 0.19680507f, 0.12351403f, -0.22224896f, 0.03014128f, 0.17208205f, 
    0.18910182f, 0.11356644f, -0.11958963f, 0.15572226f, 0.38748020f, -0.46394098f, 0.18731138f, 0.12522615f, 
    -0.11720905f, -0.17101634f, -0.15986787f, -0.04981874f, -0.07107252f, -0.31456152f, -0.19775966f, -0.36097631f, 
    -0.38726345f, -0.52131373f, -0.40495905f, 0.08289039f, 0.05751821f, -0.09324867f, -0.04195458f, 0.11310505f, 
    0.14067227f, 0.11959995f, 0.05212032f, 0.10977101f, -0.09902503f, 0.00031105f, 0.19871801f, -0.25408545f, 
    -0.12993173f, -0.31829971f, -0.21342941f, -0.29972783f, -0.17556685f, -0.20419955f, 0.19628817f, 0.02124674f, 
    0.37609798f, 0.04343407f, 0.14549707f, 0.37427044f, 0.35328326f, -0.14800374f, -0.20033744f, -0.12459888f, 
    -0.14750694f, 0.00119058f, -0.17172401f, -0.44223475f, -0.20661132f, 0.43374735f, -0.02619522f, 0.06373145f, 
    -0.10792465f, 0.10265391f, -0.25176144f, 0.30958092f, 0.22410308f, 0.01237770f, -0.30840561f, -0.18631214f, 
    0.11882001f, 0.60440105f, -0.34739479f, 0.07314018f, 0.03409335f, -0.06878543f, -0.17159563f, 0.03537877f, 
    -0.02230401f, -0.15054864f, -0.02258333f, 0.27691540f, 0.17006280f, -0.20749579f, -0.18354623f, 0.15472926f, 
    0.11936178f, 0.15482281f, -0.29436031f, 0.04369487f, 0.10182016f, 0.15095581f, 0.20432472f, 0.27059928f, 
    0.06745348f, 0.52715045f, -0.28816473f, 0.13384333f, -0.06274610f, 0.12756701f, -0.17282128f, -0.26615864f, 
    -0.00232454f, 0.10038734f, -0.02474115f, 0.05704959f, 0.21980101f, -0.02005323f, -0.19645442f, 0.03513230f, 
    0.03760419f, 0.04067801f, 0.02488548f, -0.01637840f, 0.07827970f, -0.01227637f, 0.20079200f, 0.12408613f, 
    -1.04086804f, 0.26514596f, 0.07313497f, -0.32395208f, 0.20401302f, 0.04169478f, -0.00861840f, -0.01563744f, 
    0.00434543f, 0.06015168f, -0.10028838f, 0.05851044f, 0.05193261f, 0.09820645f, -0.23444188f, -0.54725468f, 
    0.10073624f, -0.10425229f, 0.16759047f, 0.08915551f, 0.05133516f, 0.02096571f, -0.14551044f, 0.14588334f, 
    -0.55181879f, 0.27719113f, 0.09423479f, 0.24482483f, 0.26617488f, 0.23092547f, 0.00570405f, -0.26898101f, 
    -0.13913260f, -0.03305352f, -0.23663005f, 0.10439682f, 0.29239407f, 0.37197220f, -0.06192578f, -0.03129840f, 
    0.05408845f, 0.06732665f, 0.31359929f, -0.04767995f, -0.06588119f, -0.00183318f, -0.08462512f, -0.01597295f, 
    -0.35533679f, 0.07181837f, 0.09611740f, 0.06769839f, -0.02869114f, 0.05857304f, -0.06690490f, -0.12802757f, 
    -0.28104654f, -0.08629256f, 0.01506519f, 0.07059593f, -0.32975152f, -0.06777427f, -0.28679752f, 0.02496010f, 
    -0.06809253f, 0.11224190f, -0.30228227f, -0.04270219f, 0.13944957f, -0.09371862f, 0.07028234f, -0.03063212f, 
    -0.35707825f, 0.53919333f, -0.37393057f, -0.66328496f, -0.02267838f, -0.22616592f, 0.05497729f, -0.03016816f, 
    -0.09932726f, -0.07393908f, -0.09260943f, -0.13438128f, 0.14467719f, 0.11188623f, 0.27245337f, -0.09139668f, 
    0.11733343f, 0.11811505f, -0.15196967f, -0.27738965f, -0.03154217f, 0.14489131f, 0.12147512f, 0.22111592f, 
    -0.58854115f, -0.12319046f, -0.01810069f, -0.09034917f, -0.13221017f, -0.10503498f, 0.03518242f, -0.15254526f, 
    -0.16622815f, -0.05548627f, 0.08187442f, 0.13749482f, 1.24593222f, 0.24977933f, -0.07923642f, -0.07529354f, 
    0.21147752f, -0.21245182f, 0.20468484f, 0.05845222f, -0.01875473f, 0.11573945f, 0.02062457f, 0.32080659f, 
    -0.15162612f, 0.30935311f, -0.28159472f, 0.17833589f, 0.13160147f, 0.02208033f, 0.00296678f, -0.16558893f, 
    -0.01380660f, -0.12446078f, -0.03799437f, -0.10473753f, -0.30080724f, -0.00566619f, 0.00566560f, 0.09659256f, 
    0.04405399f, 0.12763922f, -0.00456412f, 0.29684052f, -0.19223282f, 0.11551426f, -0.04255870f, 0.09493956f, 
    -0.80287868f, -0.43061820f, 0.49743080f, -0.41741028f, -0.09212793f, 0.13795094f, -0.00355724f, 0.17202362f, 
    0.06036641f, -0.19176024f, 0.03370157f, 0.02881650f, 0.03664086f, 0.05947759f, 0.13191724f, -0.48811418f, 
    -0.00692432f, 0.16552016f, -0.09320460f, -0.04191517f, -0.00080286f, -0.23674153f, -0.19965018f, -0.29197738f, 
    -0.16915929f, -0.02540247f, 0.44214773f, 0.34161288f, 0.05268406f, -0.08235466f, 0.08845475f, 0.22720867f, 
    0.19856197f, 0.08015147f, -0.09330020f, 0.03214508f, 0.01911563f, 0.01043715f, 0.03335085f, -0.48977557f, 
    -0.04027547f, -0.07668710f, -0.05551330f, -0.01734657f, 0.07761567f, 0.09669150f, 0.13341717f, -0.12621872f, 
    -1.03140414f, -0.87255812f, -0.01884445f, -0.28016695f, -0.01049075f, -0.11980569f, 0.04852854f, 0.09770677f, 
    0.26441520f, -0.03914366f, 0.06266966f, 0.05473267f, -0.53413588f, 0.03109368f, -0.19212395f, 0.14870487f, 
    0.09354546f, -0.14813444f, -0.01649443f, -0.17359115f, 0.13877165f, 0.34208471f, 0.05062015f, 0.05942212f, 
    0.30744433f, -0.32856026f, 0.00609573f, 0.00623009f, -0.11666093f, 0.16467926f, -0.04853854f, 0.04009309f, 
    0.02050314f, 0.30930719f, 0.14382982f, -0.02515080f, -1.62573969f, -0.24377331f, 0.08790984f, 0.32261077f, 
    0.36253709f, -0.11840843f, -0.07840474f, -0.12446503f, -0.26555315f, -0.15574096f, 0.08153258f, 0.17385611f, 
    0.09438273f, 0.03366632f, 0.13486466f, -0.02677672f, -0.29746753f, -0.04103411f, 0.03292486f, -0.32085362f, 
    0.13703485f, 0.09756490f, 0.35075897f, 0.03252273f, 0.77268809f, 0.21425414f, -0.06237015f, -0.08990508f, 
    0.16709666f, 0.05286423f, 0.12196933f, 0.00937560f, 0.12625074f, -0.01179310f, -0.32718191f, -0.06728303f, 
    0.01744896f, 0.23738478f, -0.20627674f, -0.23501432f, 0.11555727f, -0.24752219f, 0.18896936f, 0.09542169f, 
    0.05337260f, 0.06555050f, 0.19916032f, 0.30777866f, 0.31573087f, 0.25086904f, -0.24950793f, 0.05677465f, 
    -0.06522103f, -0.07071178f, -0.23511131f, 0.05881850f, -0.06236648f, -0.12379535f, 0.01389551f, 0.02511092f, 
    -0.47209913f, -0.35284147f, 0.00397434f, -0.11122649f, 0.26001522f, -0.05032904f, 0.01406978f, 0.12303089f, 
    -0.15878098f, 0.09811854f, 0.11697282f, 0.07030211f, 0.02070381f, -0.07450462f, 0.20105369f, -0.04874208f, 
    -0.03293226f, 0.11295708f, -0.23745467f, -0.03803779f, 0.04093780f, 0.07421025f, -0.07909082f, -0.00099645f, 
    -0.82797784f, -0.26531166f, -0.22029370f, -0.58672726f, 0.15423709f, 0.06118629f, -0.20747361f, -0.06561662f, 
    -0.15760317f, -0.09037971f, -0.00180939f, -0.03322758f, 0.32158935f, -0.29363343f, 0.09868393f, -0.29252958f, 
    -0.44888946f, -0.05757426f, 0.08230546f, 0.00427827f, 0.10020415f, -0.27170953f, -0.14685448f, -0.36544809f, 
    -0.27750427f, -0.05980914f, -0.26183680f, 0.13836388f, -0.05092384f, -0.10699055f, 0.11893733f, 0.00472833f, 
    0.04794757f, -0.04053959f, 0.06242629f, 0.03475590f, -0.49980536f, -0.22470982f, -0.34774303f, 0.01570018f, 
    0.18095507f, -0.08901759f, -0.17539668f, 0.08144085f, 0.20805353f, 0.45403269f, 0.11686609f, 0.14719003f, 
    -0.19141656f, 0.12669146f, 0.22368622f, -0.00767376f, 0.24415098f, 0.15001276f, 0.15611298f, -0.04015024f, 
    0.09935853f, 0.17274702f, 0.04675694f, -0.01450945f, 0.03707911f, 0.38530886f, -0.25179765f, -0.16767769f, 
    0.10429081f, 0.16921026f, -0.15177199f, 0.15584639f, -0.01286325f, 0.13087356f, 0.18095246f, 0.18988064f, 
    0.27129123f, -0.41349620f, 0.22213529f, -0.46405110f, 0.28517547f, 0.05284329f, 0.08586386f, -0.07753321f, 
    -0.08862507f, 0.20398219f, -0.12315070f, 0.14897278f, -0.21058767f, -0.09523252f, -0.11260063f, -0.37855431f, 
    0.23565473f, -0.10130706f, -0.00351841f, 0.17116739f, -0.01384496f, -0.00741946f, -0.02581791f, 0.04556828f, 
    0.26042730f, -0.13375233f, -0.19827798f, 0.03112470f, -0.16823672f, 0.06908352f, 0.06720418f, 0.06880041f, 
    0.03369095f, -0.20824248f, -0.09117884f, 0.11808526f, 1.00872028f, 0.06911718f, 0.11989699f, -0.11247625f, 
    0.08860794f, -0.24782507f, -0.35419133f, -0.00352926f, 0.27943918f, 0.24793379f, 0.09128077f, 0.02231217f, 
    0.43808472f, 0.12471934f, 0.08419069f, 0.04117567f, -0.02930353f, -0.34845963f, -0.30472955f, -0.42639676f, 
    0.01922154f, -0.24370502f, 0.05564916f, -0.05408466f, -0.06335843f, -0.01327474f, -0.27687797f, 0.15845835f, 
    0.24260490f, 0.03325975f, 0.17334853f, 0.16460747f, 0.21264094f, 0.24511759f, 0.04328873f, 0.18323922f, 
    0.27155840f, -0.59981960f, 0.17081523f, 0.41573510f, -0.04268670f, -0.15615748f, 0.10638236f, -0.07499575f, 
    -0.13267066f, -0.19526392f, -0.03483717f, -0.18976511f, -0.79434162f, -0.26261318f, -0.18274827f, -0.20628797f, 
    -0.05640686f, 0.11863744f, 0.15635401f, 0.09785835f, -0.12783101f, 0.11551283f, -0.03299847f, 0.26924813f, 
    -0.37808707f, 0.81648344f, -0.13947529f, 0.29456997f, 0.46025416f, 0.06713694f, -0.05107109f, -0.05406500f, 
    0.02963658f, 0.00352434f, -0.26305228f, -0.22904213f, -0.76871800f, 0.02748200f, 0.26412597f, -0.08388629f, 
    0.07971063f, 0.08452324f, -0.23996429f, 0.11999133f, 0.05582335f, -0.09574518f, 0.09837100f, -0.02283270f, 
    -0.24749662f, -0.18646942f, -0.39124510f, -0.43222883f, 0.00324137f, -0.10216993f, 0.14899638f, 0.10197122f, 
    -0.03499186f, -0.08525513f, -0.11529926f, -0.04627499f, -0.39692321f, 0.38989919f, -0.19395927f, 0.05128876f, 
    -0.03690867f, -0.19212545f, 0.04515733f, -0.04502306f, 0.04723440f, 0.13621727f, -0.00673049f, -0.26938370f, 
    0.06463566f, -0.65326244f, -0.26548240f, 0.22793946f, -0.18073133f, 0.13949092f, -0.19365439f, -0.11067204f, 
    -0.06761837f, 0.05342425f, -0.09670658f, -0.03821450f, 0.25801933f, -0.54264861f, 0.09261863f, 0.17786846f, 
    0.12746911f, -0.05476777f, 0.09826735f, 0.16344476f, -0.06369682f, -0.08595695f, -0.08306719f, 0.11094363f, 
    -0.31424707f, 0.23188189f, -0.08261208f, 0.02483087f, 0.23083684f, 0.10820695f, -0.06139749f, 0.07373250f, 
    0.07413068f, -0.07274303f, -0.11245453f, 0.11179054f, -0.06896792f, 0.00872667f, -0.32888418f, 0.06693807f, 
    -0.02751262f, 0.02690556f, 0.04902442f, 0.23710449f, -0.10020462f, 0.10416888f, -0.13093974f, -0.06406879f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.22211508f, 0.09129328f, -0.17775472f, -0.04100683f, 0.02930076f, -0.03027696f, -0.09092984f, -0.13657950f, 
    -0.05127945f, 0.00338432f, 0.35171539f, -0.03274618f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
