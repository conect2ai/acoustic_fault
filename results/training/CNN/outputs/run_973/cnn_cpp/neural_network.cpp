#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -1.36733639f, 1.09195328f, 0.41526678f, -1.35527790f, 0.07864837f, 1.26678216f, -0.38218051f, 0.44473252f, 
    0.23378971f, -1.93661225f, 1.10951912f, -0.87994808f, 0.03070955f, -0.53177953f, 0.24328887f, 0.60017735f, 
    -0.53491557f, 0.48195145f, 0.09109654f, -0.79288262f, 0.84907621f, -0.12612353f, -0.75730044f, -1.50694680f, 
    -0.76352531f, -0.55363286f, -0.99615371f, 0.68574309f, -1.82227635f, 0.50166059f, 0.52612025f, 0.63733602f, 
    -0.23606110f, -0.05852562f, -0.51956421f, 0.24333110f, -0.86167085f, -0.44841060f, 1.16202462f, 0.70724910f, 
    0.65292114f, -0.92643768f, -0.26464805f, 0.28523579f, 0.24766526f, 0.52732837f, 0.55259651f, 0.62171984f, 
    0.18279192f, 0.16817100f, 0.22030836f, 0.29313552f, 0.45263520f, -0.53840327f, -0.73597598f, 0.52778631f, 
    0.43770283f, 0.19396527f, 0.10976113f, 0.88475919f, -0.19017346f, -0.52821493f, -0.43122935f, 1.62406194f, 
    -0.76649475f, -1.14871025f, 0.15954427f, 0.18611695f, 0.43079150f, -0.95016736f, -0.63720381f, -0.22680908f, 
    -0.35947552f, 0.77534372f, -0.67428070f, 0.13098487f, 0.12782924f, -0.23385181f, 0.03159074f, 0.79671794f, 
    0.42250437f, 0.49740338f, 0.74479723f, 0.40816203f, 0.41130570f, -0.29219288f, 0.30035952f, 0.30281737f, 
    -0.48384970f, 0.12294728f, -0.44322020f, 1.10596502f, 0.60183346f, -0.61175829f, -0.17732641f, 0.63742113f, 
    -0.31137416f, -0.23128147f, -0.42324483f, -0.77771962f, -1.42232907f, -0.07578349f, -1.48142076f, -1.84801888f, 
    -1.13510811f, 0.08719366f, 0.65381831f, 0.47864664f, -0.33466199f, -1.28922749f, -0.75628418f, 0.82813919f, 
    -0.00214992f, 0.03256974f, 0.71075380f, -0.07707578f, 0.78013307f, -1.66110694f, -1.32022285f, 0.39424348f, 
    0.70688522f, 0.90890133f, -0.16371289f, 0.10583191f, 0.07345769f, 0.00600849f, -0.09382473f, -0.66036719f, 
    -0.92883867f, -1.34279954f, -0.69657874f, -0.11242004f, -0.55415410f, -0.80543697f, -0.84300399f, -1.21216547f, 
    -0.28543794f, -0.43499938f, 0.91547084f, 1.07033634f, -0.10829091f, -0.24683145f, -0.57115740f, -0.66829520f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.53794730f, 0.30865636f, -0.00974763f, 0.37947685f, 0.26220772f, -0.13586010f, 0.69690114f, 0.06000344f, 
    0.36442250f, -0.25222692f, 0.76527512f, 0.09027253f, 0.43736389f, 0.09339718f, 0.45870966f, -0.03011822f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.34612945f, -0.18072452f, 0.43684435f, 0.13681163f, -0.19174765f, -0.24762298f, -0.34221449f, 0.15717962f, 
    0.04477793f, -0.06193182f, -0.00914120f, -0.03587385f, -0.19195306f, -0.19006546f, -0.02489735f, -0.22974068f, 
    -0.21481043f, -0.09916644f, -0.23255379f, -0.21332712f, 0.31019372f, 0.26129368f, 0.30829030f, -0.62017727f, 
    0.21796085f, -0.03682266f, 0.13389063f, -0.02565573f, 0.02539982f, -0.21201886f, 0.20068334f, -0.05825655f, 
    -0.01329544f, -0.07341786f, 0.08283788f, -0.17822433f, -0.04749014f, -0.04935212f, -0.15481098f, -0.01907245f, 
    0.49178624f, 0.29533240f, -0.18180311f, -0.69665641f, 0.15932265f, 0.13679233f, -0.13952087f, 0.08116382f, 
    -0.10253344f, 0.20523597f, -0.03155942f, -0.08661755f, -0.06718901f, 0.07077358f, -0.00666130f, 0.11559498f, 
    -0.10713057f, 0.10906470f, -0.15009990f, 0.17512482f, 0.03610113f, -0.44722086f, -0.68552095f, -0.06353750f, 
    0.02901079f, 0.00146896f, -0.15347779f, 0.12573567f, -0.24924003f, 0.16471447f, -0.18010876f, 0.05848526f, 
    -0.20088480f, 0.03208691f, -0.01910245f, -0.09637089f, 0.13830359f, -0.04220732f, -0.18508522f, -0.08802737f, 
    0.29133707f, -0.14183298f, -0.43028760f, -0.35233584f, 0.08500315f, -0.15518340f, -0.00006201f, 0.09906390f, 
    0.00999172f, -0.11671973f, -0.15972987f, -0.29882875f, -0.30880061f, -0.24073638f, -0.15610415f, -0.19640943f, 
    0.05692268f, -0.03528264f, 0.08441968f, 0.04721344f, -0.11906806f, -0.09909981f, -0.07724092f, 0.10620502f, 
    0.09995921f, 0.02411484f, 0.03762867f, 0.03979307f, 0.02990918f, 0.05875792f, -0.11059742f, 0.09408145f, 
    0.03130123f, 0.06340703f, 0.08237375f, -0.01002463f, -0.47261953f, 0.00422486f, -0.10346857f, 0.02055710f, 
    -0.42644882f, -0.46574360f, 0.04907543f, -0.30478385f, -0.25551069f, 0.03681925f, -0.04675369f, 0.04235467f, 
    0.14558266f, 0.02745337f, 0.01435602f, -0.05058406f, -0.06586984f, -0.09442314f, 0.01187976f, -0.05128202f, 
    -0.16184814f, 0.01247400f, -0.07720244f, 0.08115242f, 0.08914618f, 0.04563710f, 0.37676314f, 0.26864851f, 
    -0.19860350f, 0.00214380f, 0.06455017f, 0.03423716f, -0.13471724f, 0.10322671f, 0.03367799f, -0.02063772f, 
    -0.07515676f, -0.16141456f, 0.00357097f, -0.10928266f, 0.18103296f, 0.01372395f, 0.14267309f, 0.24236310f, 
    0.08999020f, -0.08294418f, -0.06539658f, 0.09847043f, 0.01809471f, 0.01407221f, -0.02052877f, 0.07927593f, 
    0.00246809f, 0.10906406f, -0.21392174f, 0.14212118f, -0.14063571f, -0.05635072f, 0.02543860f, -0.14157540f, 
    -0.08193558f, -0.10465518f, -0.11806792f, -0.06244529f, -0.18791200f, -0.17233939f, -0.14004263f, 0.01232506f, 
    0.11142747f, 0.10388830f, 0.05290454f, 0.05544743f, 0.04762712f, 0.02801869f, 0.03968272f, 0.06186841f, 
    0.00024787f, 0.08381108f, 0.12498617f, -0.24369682f, -0.04600033f, -0.06122994f, 0.01914178f, 0.04669556f, 
    -0.95802242f, -0.15581374f, 0.13658859f, 0.05437517f, -0.15579805f, -0.03611205f, -0.07378370f, -0.02158475f, 
    0.09197678f, 0.00307277f, 0.00658516f, -0.04782864f, -0.02672742f, -0.00570558f, -0.03152867f, -0.06348970f, 
    0.15975446f, -0.15344328f, -0.29133800f, -0.16103987f, 0.58213544f, 0.56999683f, 0.01898238f, -0.65133804f, 
    -0.19784179f, 0.11496129f, 0.12933576f, 0.09726712f, -0.11849294f, -0.02528218f, 0.09869313f, -0.02388282f, 
    0.06726161f, 0.06872879f, 0.00239726f, 0.01816996f, -0.09192148f, -0.01713742f, 0.14377646f, -0.10165066f, 
    0.22800994f, 0.28181088f, -0.21292709f, -0.10285234f, 0.14617386f, 0.14431876f, 0.07820483f, 0.12774892f, 
    -0.12231947f, -0.32601854f, -0.10887700f, 0.01348765f, -0.16433375f, -0.01567402f, 0.09027523f, -0.00546176f, 
    0.00849371f, -0.00686441f, 0.06823719f, 0.00160950f, 0.54715127f, 0.06537922f, -0.42762828f, -0.23651943f, 
    0.00207859f, 0.16791493f, 0.17418304f, 0.22860490f, -0.05437670f, -0.04551838f, -0.04147549f, -0.13209097f, 
    -0.15922229f, 0.18324524f, -0.02709004f, 0.00609232f, 0.05438337f, 0.08323191f, -0.00606257f, 0.00178347f, 
    0.32458839f, 0.32644373f, 0.39858869f, -0.29228863f, -0.26113760f, 0.09452564f, 0.15286678f, 0.07729465f, 
    -0.04947562f, 0.09949868f, 0.00187074f, -0.10346060f, -0.02096258f, -0.24952064f, -0.23345691f, -0.05910913f, 
    -0.10527536f, -0.15210819f, -0.00279872f, 0.07505785f, 0.61255616f, 0.22992413f, -0.44800061f, -0.22460286f, 
    -0.29884005f, -0.07709611f, -0.00990451f, 0.01495571f, 0.11158089f, 0.00043217f, -0.09715459f, 0.05020734f, 
    0.05371394f, 0.15443914f, 0.09563626f, -0.06527421f, 0.04857470f, 0.07545384f, -0.06064063f, 0.02091183f, 
    -0.25181973f, -0.36103722f, 0.19899552f, -0.13455845f, 0.00085989f, -0.05467111f, 0.05858442f, 0.02997175f, 
    0.04811284f, 0.08305827f, 0.14755905f, 0.05172731f, 0.10108234f, 0.14417730f, -0.03265750f, -0.12278933f, 
    0.17708899f, 0.00367148f, 0.18387897f, 0.17974640f, -1.35640001f, -0.07800025f, -0.06557965f, 0.04954616f, 
    0.04985868f, 0.00240049f, -0.00866360f, -0.29594895f, -0.26846841f, -0.00783028f, -0.40793520f, 0.18523668f, 
    -0.01558727f, 0.02629471f, 0.04792302f, 0.00804208f, 0.07674803f, -0.03791951f, -0.17141619f, 0.08313077f, 
    -0.14604014f, -0.15121895f, -0.45176262f, -0.27952999f, -0.18777841f, 0.06345856f, -0.27306521f, -0.19719140f, 
    0.02114683f, -0.02653868f, 0.04694932f, 0.09939161f, 0.09923705f, -0.05040586f, 0.05489167f, -0.15517069f, 
    -0.30947664f, -0.48787144f, -0.38281906f, -0.44773608f, 0.45494285f, -0.29837891f, 0.24125753f, 0.05051415f, 
    0.12393986f, -0.04767023f, 0.09584345f, 0.02110547f, -0.07133253f, -0.03710506f, 0.00380029f, -0.02699891f, 
    0.31599525f, -0.07703010f, -0.19700992f, 0.04349403f, 0.02454851f, 0.04437029f, -0.14524268f, -0.11464529f, 
    0.08089209f, -0.01709871f, 0.05163120f, 0.12034065f, 0.35016149f, 0.04908227f, -0.05535142f, 0.07052366f, 
    0.05573681f, -0.05729266f, -0.01525371f, -0.06960968f, 0.15536252f, 0.11213362f, -0.11823271f, 0.10631265f, 
    -0.05539557f, 0.11276364f, 0.01435244f, -0.11419418f, 0.28421023f, 0.05493984f, 0.07235126f, 0.20359084f, 
    0.16612507f, -0.00952120f, -0.09264225f, -0.07006970f, -0.02752962f, -0.11872360f, 0.05397440f, -0.10303753f, 
    -0.02424377f, 0.03815715f, 0.03782481f, -0.11332171f, 0.04572325f, -0.12002166f, 0.03709101f, -0.16103853f, 
    -0.33383906f, -0.28410807f, 0.11654278f, 0.07853206f, 0.24436414f, -0.03958139f, -0.04725759f, 0.06145570f, 
    -0.02062034f, -0.00559034f, 0.15209194f, 0.02175298f, 0.04565773f, -0.01447636f, 0.13236912f, 0.37596869f, 
    -0.23588182f, 0.16523984f, 0.14455545f, -0.09644038f, 1.22011364f, 0.34920323f, 0.04006806f, 0.35464036f, 
    -0.87959063f, 0.05936629f, -0.02403102f, -0.00459960f, -0.13589162f, -0.04814929f, 0.04233212f, -0.08672731f, 
    -0.04264384f, -0.09209468f, -0.05715692f, 0.01659309f, -0.21221162f, -0.32297999f, -0.17916508f, -0.08292012f, 
    -0.18240608f, -0.14801481f, -0.11115005f, 0.03170260f, -0.09043667f, 0.03638074f, -0.04669786f, 0.00898828f, 
    0.08599652f, 0.02054656f, 0.05420654f, 0.15421925f, -0.07775580f, 0.13852096f, -0.04201870f, -0.10037769f, 
    0.05191966f, -0.10018415f, 0.10923082f, 0.09515403f, 0.33837155f, 0.11695711f, 0.10324186f, 0.11911844f, 
    0.17005445f, -0.12519269f, -0.08477324f, -0.11416088f, -0.10970478f, -0.12902281f, -0.05608288f, -0.02784732f, 
    -0.00853478f, 0.00274235f, -0.01143225f, 0.02180868f, -0.11649938f, -0.11738972f, -0.00688991f, 0.01360226f, 
    -0.02668920f, -0.18747258f, 0.18847997f, -0.08405115f, 0.23710772f, -0.03134520f, -0.09946664f, -0.01418247f, 
    -0.04895576f, -0.04980235f, 0.05795867f, 0.08254077f, -0.03231002f, -0.02593281f, 0.02112504f, 0.18924445f, 
    -0.05412358f, 0.09490652f, 0.32092351f, 0.09846701f, -0.45885351f, 0.21277210f, -0.35337156f, 0.33693767f, 
    0.18726870f, -0.24428917f, 0.16227393f, 0.02139454f, 0.19422866f, -0.10172901f, -0.04551670f, 0.03613321f, 
    0.00659948f, 0.00032035f, 0.02829415f, -0.01739349f, 0.00763329f, 0.07724614f, -0.26930976f, 0.26617238f, 
    -0.06122731f, -0.09427451f, -0.35843602f, -0.12581404f, -0.19562459f, -0.05588611f, 0.05861155f, 0.25426474f, 
    0.02220178f, -0.28331921f, -0.10573239f, 0.03219716f, 0.07562204f, 0.05267190f, -0.02551044f, -0.07893431f, 
    -0.01163655f, 0.11776478f, -0.02847334f, -0.00874754f, 0.24371600f, -0.14571431f, -0.03855072f, 0.00211823f, 
    0.15412760f, -0.01445805f, -0.01902883f, 0.15259477f, 0.05602723f, -0.01363686f, 0.16463454f, -0.05199770f, 
    -0.06693783f, -0.02216555f, -0.20706719f, 0.03947621f, -0.00497904f, -0.05165550f, -0.00308125f, -0.12608847f, 
    -0.12915613f, 0.50314003f, 0.22527514f, 0.21587192f, 0.04853312f, 0.16082965f, -0.10564810f, 0.04562036f, 
    -0.12653233f, 0.19295663f, -0.08285388f, -0.01217093f, -0.02967397f, -0.05530703f, 0.20727921f, -0.03036885f, 
    -0.06797048f, 0.20936088f, -0.18951693f, -0.10961600f, 0.40829739f, -0.25270113f, 0.19593348f, -0.18839456f, 
    -0.12980442f, 0.01243436f, -0.06707849f, -0.01661698f, 0.06554919f, -0.06538247f, 0.23766933f, -0.08802719f, 
    -0.11545616f, -0.30691695f, 0.14619312f, 0.16336608f, -0.14779238f, -0.28882697f, 0.09182846f, -0.02912967f, 
    0.16360673f, 0.04922228f, -0.25458628f, -0.07334433f, 0.28417689f, -0.22016267f, 0.12677692f, -0.09437624f, 
    -0.09416532f, -0.05978370f, -0.09253465f, 0.00331038f, -0.16097616f, -0.04728597f, 0.04002375f, 0.11001449f, 
    -0.16383493f, 0.08283358f, 0.01976141f, 0.06890637f, 0.57544023f, -0.13564956f, -0.60983306f, 0.51909745f, 
    0.04006957f, 0.16277707f, -0.00614892f, -0.25682780f, -0.15878044f, -0.17076759f, -0.13954774f, 0.06554041f, 
    0.07614388f, 0.04051928f, 0.02834867f, -0.00801165f, 0.07315750f, -0.11762432f, 0.13589872f, 0.09728707f, 
    -0.57741779f, 0.31817624f, 0.06024120f, 0.18441980f, -0.30576882f, -0.05335773f, -0.10753161f, -0.17470616f, 
    0.15924989f, -0.10091485f, -0.03137859f, -0.00855311f, 0.01750283f, -0.12211008f, -0.09042656f, -0.14988627f, 
    0.11383195f, 0.11070796f, 0.11161978f, 0.09070290f, 0.16073117f, 0.31500256f, 0.57487804f, -0.06010133f, 
    0.15676521f, -0.00390407f, -0.02260835f, -0.02355899f, 0.05647161f, -0.04008872f, 0.14690830f, -0.04522533f, 
    0.14262359f, -0.09603053f, 0.09311625f, -0.05941762f, 0.01424183f, 0.01241123f, 0.07196587f, -0.19731688f, 
    0.54344279f, 0.32775298f, -0.05252220f, 0.03854156f, 0.13451415f, 0.14166807f, -0.25232315f, -0.02504778f, 
    0.08786363f, 0.25002676f, -0.30861387f, 0.08457910f, 0.27844134f, -0.09849234f, -0.09378555f, 0.02267601f, 
    -0.15815420f, -0.03781841f, 0.05512513f, -0.19310586f, -0.07858069f, -0.27975866f, -0.00372094f, -0.25676757f, 
    0.02957977f, -0.04546997f, -0.13927598f, 0.00069196f, 0.08786432f, 0.14163566f, 0.00360633f, -0.14188735f, 
    -0.10828239f, 0.11493434f, -0.11264042f, 0.14404760f, -0.01446214f, -0.02783868f, -0.02589447f, -0.09296624f, 
    0.09302801f, -0.14183328f, -0.41919756f, -0.35367146f, 0.34504876f, 0.07455283f, 0.02031397f, 0.01295633f, 
    0.04078959f, 0.08027335f, 0.07786879f, -0.04854643f, 0.02550125f, 0.01570027f, -0.06440990f, 0.00059552f, 
    0.12000078f, 0.09050854f, 0.08272153f, 0.01464797f, -0.55830628f, 0.35028589f, 0.43542263f, 0.43259987f, 
    -0.12929223f, -0.04991091f, -0.13149086f, -0.05818201f, -0.16903216f, 0.18131308f, 0.00825045f, -0.01956434f, 
    0.01455800f, -0.11135073f, -0.09100380f, 0.17765924f, 0.09271165f, -0.06781463f, 0.22460707f, -0.17076690f, 
    0.20373614f, -0.00254971f, -0.00517964f, 0.01422492f, 0.06581800f, 0.04546112f, -0.11067069f, 0.02781775f, 
    0.01189922f, -0.06913786f, -0.06153350f, -0.18531632f, -0.01093424f, 0.04692334f, 0.10876227f, 0.06459241f, 
    -0.10138441f, -0.18930328f, 0.12203937f, -0.13420065f, -0.45345655f, -0.43165982f, -0.05100363f, -0.40853679f, 
    0.04187165f, -0.00443689f, -0.09024100f, 0.01842882f, 0.07302728f, -0.01877037f, 0.03249512f, -0.06333381f, 
    -0.07818922f, 0.05710240f, -0.08481168f, -0.13282295f, -0.08033200f, -0.01743953f, 0.06259263f, -0.03523771f, 
    0.17834444f, -0.30308610f, -0.40119919f, -0.25250962f, -0.16460353f, 0.07026556f, 0.07270669f, -0.04674268f, 
    -0.00493387f, 0.07350840f, 0.08115757f, 0.00158752f, 0.00257775f, 0.09815168f, 0.02193430f, -0.09674026f, 
    0.07639897f, -0.06699470f, 0.00995655f, -0.26845011f, -0.70992863f, -0.80978811f, -1.06029367f, 0.29024255f, 
    -0.68097758f, -0.05483580f, -0.07598381f, -0.12735690f, -0.03879516f, -0.18155840f, 0.01160396f, 0.06013856f, 
    0.02877110f, -0.00036230f, -0.03834753f, -0.05649634f, -0.01370182f, 0.01719449f, -0.42377925f, -0.00706209f, 
    -0.01244510f, -0.04470607f, 0.20889321f, 0.22036181f, 0.13637200f, -0.03564641f, -0.15692140f, 0.05647516f, 
    0.19589031f, -0.25706109f, 0.03693318f, 0.05708882f, 0.05749178f, -0.00515671f, 0.00625775f, -0.02707706f, 
    -0.06993040f, 0.03663090f, -0.00184365f, -0.07436576f, 0.22343257f, -0.40694940f, 1.04326391f, 0.31729385f, 
    0.37950122f, -0.06756668f, -0.06681891f, -0.05940919f, 0.17674747f, 0.01600160f, -0.02233455f, 0.05474397f, 
    0.05339278f, -0.02101821f, 0.00113404f, 0.03243573f, -0.02157713f, -0.03504175f, -0.00704964f, 0.01272579f, 
    -0.06286811f, -0.05556377f, -0.08409524f, 0.53564280f, -0.10655439f, 0.19644350f, 0.25075987f, -0.00653027f, 
    -0.08053590f, 0.11715996f, -0.05618110f, -0.00507993f, 0.02912150f, 0.04124611f, -0.00012013f, 0.02077043f, 
    0.07110955f, -0.13552597f, 0.03463744f, 0.18023705f, -0.72896075f, -0.45199215f, 0.93285215f, 0.40176228f, 
    0.43190536f, 0.04295577f, -0.14823417f, -0.25062308f, -0.14863817f, -0.25039315f, 0.03866734f, -0.03824086f, 
    -0.04120199f, -0.19211319f, -0.01446371f, 0.10432079f, 0.08088654f, -0.07640798f, -0.03673950f, -0.08306985f, 
    0.80253333f, 1.03197479f, -0.20910268f, -0.56888050f, -0.24736369f, -0.15807281f, -0.29397458f, 0.15060607f, 
    -0.18524732f, -0.25879931f, -0.09395932f, -0.02452755f, -0.06826311f, -0.14847511f, 0.20100205f, 0.07916794f, 
    0.08559820f, -0.22262944f, -0.11398818f, 0.02033700f, 0.53724426f, -0.35138705f, -0.45463413f, -0.05592347f, 
    0.39160183f, 0.02371088f, 0.13067375f, -0.01366558f, -0.20459096f, -0.23846903f, -0.09317978f, -0.05558124f, 
    0.23420788f, 0.12381550f, -0.24455686f, -0.16076753f, -0.20353164f, 0.07078370f, 0.37744704f, -0.08641858f, 
    -0.23258546f, 0.12878856f, 0.09471305f, 0.22775516f, 0.23189875f, -0.19149813f, 0.10203762f, 0.06161986f, 
    -0.08241613f, 0.19805142f, -0.00360798f, 0.04009864f, -0.10541906f, -0.04095254f, 0.02300408f, 0.13495877f, 
    -0.12400442f, 0.19354281f, -0.16238730f, 0.02072121f, -2.25957847f, 1.33462298f, -0.15994863f, -0.31298241f, 
    0.17989521f, 0.23302776f, 0.00251524f, 0.09927806f, -0.42766064f, -0.02296801f, -0.31762677f, -0.22024326f, 
    -0.01444506f, -0.19685481f, -0.13147485f, 0.19869478f, 0.17993093f, 0.06743852f, -0.25774753f, -0.28262302f, 
    -0.68041641f, 1.47021604f, -0.13791831f, -0.36752260f, -0.26042846f, -0.01521097f, -0.01175498f, -0.15156579f, 
    0.00411212f, -0.12570217f, -0.13674626f, -0.12617855f, -0.07799872f, -0.27450314f, 0.03849363f, -0.25590357f, 
    -0.13006417f, -0.17678149f, -0.15934561f, -0.18399873f, -0.32726035f, -0.19385979f, -0.09409636f, 0.03822209f, 
    -0.21311563f, -0.05147742f, -0.33047161f, -0.18919206f, -0.05978693f, -0.07460777f, -0.10081244f, 0.12341690f, 
    0.00296423f, 0.13159211f, -0.05763856f, 0.07906000f, 0.00554880f, -0.13050644f, -0.22991005f, -0.11159238f, 
    0.68425971f, 0.33059293f, 0.02191985f, -0.45140818f, -0.76794791f, 0.15627444f, 0.20243926f, 0.18806472f, 
    0.25779924f, 0.17511557f, 0.00591342f, -0.19774041f, 0.23027553f, -0.10286179f, -0.05271996f, -0.11382945f, 
    -0.06967502f, -0.08008260f, -0.13525952f, -0.09425426f, -0.16803409f, 0.06737914f, -0.38715857f, 0.44210291f, 
    0.22745453f, 0.00111250f, -0.01964744f, -0.01041178f, 0.17070660f, 0.09236421f, -0.02346842f, 0.16555765f, 
    -0.11777607f, -0.11207854f, -0.06094361f, -0.04071228f, 0.06153386f, 0.01482359f, 0.10709550f, 0.05879981f, 
    -0.53358024f, -0.22787593f, -0.15087472f, 0.14573240f, -0.04408085f, 0.15156999f, 0.05932664f, -0.12943749f, 
    -0.09076229f, 0.03923766f, -0.08528328f, 0.00730978f, -0.03517448f, -0.03406066f, -0.14802012f, 0.14236860f, 
    -0.07359836f, 0.06491749f, -0.22746561f, -0.13105291f, -0.69118911f, -0.47626466f, -0.08270603f, 0.05056329f, 
    -0.25424162f, -0.13203898f, 0.00607786f, -0.03986811f, 0.33934584f, 0.22177941f, 0.10115858f, 0.14788127f, 
    0.39513984f, -0.09314065f, 0.02492381f, -0.01890531f, 0.06695280f, 0.39125514f, -0.51041728f, -0.28471598f, 
    0.41940314f, 0.05058182f, 0.49080211f, -0.67666018f, -0.24955840f, -0.13263825f, -0.01592027f, 0.05407397f, 
    0.13670005f, -0.04830966f, 0.03539353f, -0.11990344f, 0.02247463f, -0.01738518f, 0.03506330f, -0.18606758f, 
    -0.15327133f, -0.07081752f, 0.03456653f, 0.01133379f, 0.14318781f, -0.16314439f, -0.40439320f, 0.05146322f, 
    0.34769073f, 0.15619099f, -0.05074602f, 0.11561771f, 0.19752355f, 0.16344064f, 0.04105906f, 0.04152982f, 
    -0.14478795f, 0.05029718f, -0.00897443f, -0.11247515f, -0.13591579f, 0.16691209f, -0.41158968f, 0.12988165f, 
    -0.41801140f, -0.10943867f, -0.17259015f, -0.15608987f, 0.63406736f, 0.14290363f, 0.07291096f, -0.01396881f, 
    -0.11312786f, -0.01556314f, -0.13505168f, -0.00884870f, -0.00205205f, 0.10842383f, 0.04090500f, 0.02433726f, 
    0.15170181f, 0.23275056f, 0.07815026f, -0.01217230f, -0.31083483f, 0.59291267f, 0.05791296f, -0.20307916f, 
    0.42797452f, 0.34794697f, 0.10287073f, -0.10042113f, -0.17727940f, -0.16442575f, -0.24868771f, 0.11847915f, 
    -0.04404032f, -0.00264363f, 0.15106404f, -0.05258994f, 0.04072081f, -0.18752676f, 0.08277306f, 0.12817594f, 
    0.08296467f, -0.24195045f, -0.23966299f, -0.04106096f, 0.31635034f, -0.16714804f, 0.00860834f, -0.11427166f, 
    0.06768869f, -0.06169274f, -0.02586602f, -0.00368567f, -0.03278710f, -0.17259285f, -0.02220438f, -0.10107149f, 
    0.10002800f, -0.02932961f, 0.01331483f, 0.02260141f, 0.53535146f, 0.24589969f, -0.30744451f, -0.05048043f, 
    0.25089234f, 0.37884977f, 0.25453344f, 0.07285593f, 0.01151181f, 0.20753276f, -0.16398756f, -0.03365012f, 
    0.14685717f, 0.02911248f, 0.26988766f, -0.14841929f, 0.02345811f, -0.07303450f, 0.26400256f, 0.14243609f, 
    -0.03452513f, -0.12505886f, -0.13345842f, -0.11725447f, 0.05980998f, 0.11008248f, 0.07681599f, -0.06745382f, 
    -0.00017042f, -0.01906206f, -0.02387331f, -0.27836984f, -0.02240025f, -0.08859975f, 0.02488320f, -0.26842186f, 
    -0.38562429f, -0.13126764f, -0.27324030f, -0.22545752f, 0.24026066f, 0.22778383f, 0.19439591f, 0.34278241f, 
    -0.15471169f, 0.03078823f, -0.04039999f, -0.18413387f, 0.03287482f, -0.01342730f, 0.12975220f, -0.04588171f, 
    -0.06944815f, 0.09910943f, 0.02101789f, 0.07716788f, 0.04462794f, -0.18963023f, -0.12761055f, -0.13483347f, 
    0.03774679f, -0.08809558f, 0.17705876f, 0.06952540f, 0.20912527f, 0.01600312f, 0.19839785f, 0.18776192f, 
    -0.01267725f, 0.08166566f, -0.04639904f, -0.06948335f, 0.00690558f, 0.07205075f, -0.06204399f, 0.02235103f, 
    0.15645084f, 0.04240223f, 0.23847295f, 0.48303479f, -0.10933255f, -0.67884034f, 0.04147888f, -0.09922156f, 
    -0.05067793f, -0.05182036f, -0.15412021f, -0.07842580f, 0.07968233f, -0.18309861f, -0.04778795f, 0.02905328f, 
    -0.10588928f, 0.02207294f, -0.16601466f, -0.04841401f, -0.10778004f, -0.05510661f, -0.00836279f, -0.17235875f, 
    0.38597333f, -0.41696268f, -0.00340618f, 0.01008888f, -0.14134455f, 0.04568753f, -0.18534552f, 0.08243684f, 
    -0.16335812f, 0.04994864f, -0.12950434f, -0.05669552f, -0.11038716f, -0.04740560f, -0.03982016f, -0.13320266f, 
    -0.15993248f, 0.07229823f, -0.24916275f, -0.05702558f, 0.06583750f, -0.00836293f, -0.03156747f, -0.00922784f, 
    0.08776923f, 0.18521376f, 0.01870166f, 0.05380805f, 0.00016989f, 0.05260374f, 0.08297871f, 0.17797133f, 
    0.09371808f, -0.10442986f, 0.17178035f, 0.13278513f, -0.11585850f, -0.14208917f, -0.02196197f, 0.05574038f, 
    0.37362587f, -0.21524818f, -0.26796576f, -0.41106668f, -0.43918499f, 0.05041522f, -0.01385950f, -0.06430450f, 
    0.00903942f, 0.13032015f, 0.06877252f, 0.01455749f, -0.05535953f, 0.09057319f, -0.10599996f, -0.14199772f, 
    0.07822300f, -0.06883962f, -0.01865868f, 0.24580872f, -0.39599189f, -0.11579559f, -0.16105643f, -0.64554578f, 
    -0.14325920f, -0.01244788f, 0.09010360f, -0.09393194f, 0.05549029f, -0.03300287f, -0.02333008f, -0.08001041f, 
    -0.00973164f, 0.31271720f, 0.05453358f, -0.10396825f, 0.16172299f, -0.05461141f, -0.03501667f, -0.05206322f, 
    0.07214954f, 0.11727213f, 0.01664948f, -0.04096026f, -0.09043404f, 0.04937484f, 0.08410987f, -0.02728573f, 
    -0.05659589f, 0.06885033f, 0.12383727f, -0.23147681f, 0.19607760f, -0.16606365f, -0.00104821f, 0.08446953f, 
    -0.05958597f, -0.12528922f, -0.13321632f, -0.08436778f, 0.09597123f, 0.10239744f, -0.03541227f, -0.01636312f, 
    0.06928477f, 0.17686884f, 0.06601862f, -0.01853732f, 0.08517265f, 0.02563982f, 0.15373859f, 0.07143104f, 
    0.02315758f, -0.03499131f, 0.15631546f, 0.08447519f, -0.10671061f, 0.01020655f, 0.04526060f, -0.00443756f, 
    0.62767363f, 0.09506267f, -0.51466238f, 0.23425652f, 0.07934444f, 0.13324280f, -0.00574103f, -0.04485862f, 
    -0.01101687f, 0.02891429f, 0.13884690f, -0.04727839f, -0.01882453f, 0.00441603f, 0.07973517f, 0.04878182f, 
    0.14471634f, 0.13104512f, -0.32932428f, 0.05621523f, 0.10059560f, 0.28406501f, 0.58156753f, 0.36129814f, 
    0.23229827f, -0.20379831f, -0.04178182f, -0.02933264f, 0.01031198f, 0.31838530f, 0.01529640f, 0.01507544f, 
    0.02493587f, 0.05049442f, 0.04698098f, 0.00461533f, -0.06210934f, -0.19169091f, -0.00384864f, -0.33453026f, 
    0.23007780f, -0.10164990f, 0.08828945f, 0.15920869f, -0.05014021f, -0.00803203f, -0.13942701f, -0.15590215f, 
    -0.07124737f, -0.03666365f, 0.18743242f, -0.14523576f, -0.11652561f, 0.03639571f, 0.04049072f, 0.07279369f, 
    0.01531616f, -0.11109439f, -0.02397626f, -0.14399761f, 0.07217170f, -0.50616020f, 0.12519133f, 0.10730885f, 
    0.09273520f, -0.36539534f, -0.23676990f, 0.00925464f, -0.18573219f, 0.12816960f, -0.04560504f, 0.01720858f, 
    -0.01684596f, -0.04188123f, 0.03161807f, -0.00229663f, 0.05217221f, 0.10039771f, -0.10930690f, -0.03827222f, 
    -0.28015774f, -0.06091942f, 0.01934776f, -0.08084724f, 0.04593604f, -0.22072065f, 0.16705963f, -0.14472064f, 
    -0.07695896f, -0.09329262f, 0.01505308f, -0.02295055f, -0.02630692f, 0.15486273f, -0.03633569f, 0.09288461f, 
    0.11249901f, -0.06170103f, -0.07104132f, 0.07497535f, -0.34532452f, -0.52297229f, 0.09355574f, 0.04824142f, 
    0.19838105f, 0.02289185f, 0.14258942f, 0.07571080f, -0.05743181f, 0.22273917f, 0.02392633f, 0.11026239f, 
    0.00125166f, -0.12118348f, -0.08686358f, -0.13822550f, 0.10021198f, 0.01872217f, -0.05473358f, 0.11354951f, 
    -0.34965068f, -0.17838906f, -0.29129201f, 0.42146578f, -0.12583935f, 0.19779932f, -0.37029192f, -0.26377326f, 
    -0.00065516f, 0.22975801f, 0.02242765f, 0.09296969f, 0.02987801f, -0.02999552f, -0.15544380f, 0.25746769f, 
    0.19700927f, 0.26806629f, -0.08021335f, 0.06593268f, -0.35096490f, 0.42619368f, 0.16234301f, -0.00781706f, 
    -0.23452829f, 0.01291822f, -0.04501088f, 0.23593681f, 0.30501711f, 0.13904527f, 0.19622970f, -0.26574707f, 
    0.02796419f, 0.00695739f, -0.14984660f, -0.05272767f, -0.03538476f, 0.04297489f, 0.15208299f, 0.13690585f, 
    0.07355692f, 0.16302159f, 0.51640856f, -0.07460792f, -0.17468221f, -0.03633141f, -0.01386835f, -0.14883563f, 
    0.06569897f, -0.04589598f, -0.00282703f, 0.05791136f, -0.00866424f, -0.07028577f, -0.03546095f, -0.17957900f, 
    0.19380359f, -0.23585859f, -0.27054068f, -0.44721299f, 0.47757536f, 0.08581608f, -0.32520348f, -0.35134771f, 
    -0.12745829f, 0.02225051f, -0.03776370f, -0.04838574f, -0.09074378f, 0.24994756f, 0.00978477f, 0.25688484f, 
    -0.29003242f, 0.02105796f, 0.11248276f, -0.00660429f, -0.21186996f, 0.02916126f, 0.22970265f, 0.23417266f, 
    -0.35219717f, -0.33230445f, -0.02737672f, 0.06304093f, -0.22898185f, -0.00881736f, -0.04368863f, -0.28768259f, 
    0.03844857f, 0.01922658f, 0.34973571f, 0.12011310f, -0.01633669f, 0.03259401f, 0.11488512f, 0.04591671f, 
    0.06513575f, -0.12698533f, 0.10782256f, 0.28911954f, -0.26476946f, -0.14023881f, -0.17655762f, 0.01294333f, 
    0.02548778f, 0.18595083f, 0.00749087f, -0.10581357f, -0.02189369f, 0.02598623f, 0.10654805f, -0.03889354f, 
    0.03916902f, 0.07140929f, -0.01660699f, -0.13868047f, -0.01959416f, 0.14826979f, 0.01214241f, -0.02416874f, 
    -0.03140168f, 0.40266985f, -0.14249095f, 0.16767353f, 0.23795970f, 0.04113521f, -0.04628415f, -0.12353807f, 
    -0.05222457f, 0.01161377f, -0.06232831f, 0.03130242f, -0.18473832f, 0.04187918f, 0.10192157f, -0.17130396f, 
    0.13893348f, -0.00204763f, -0.07244431f, -0.03961127f, -0.11511505f, 0.13693219f, 0.17730874f, -0.41345727f, 
    0.12732589f, -0.00766247f, -0.06194076f, -0.05698330f, 0.00180622f, 0.05437575f, 0.01727321f, 0.04682490f, 
    0.04942824f, -0.14385997f, 0.08958847f, -0.14932559f, -0.10972951f, -0.11078107f, 0.01014639f, 0.02514216f, 
    0.02852149f, 0.19987127f, 0.00576136f, -0.07597650f, 0.11410140f, -0.07699269f, -0.01792134f, 0.01178964f, 
    -0.02239093f, -0.11400811f, 0.06583042f, -0.17589858f, 0.04013596f, 0.03274338f, -0.07889546f, 0.06612699f, 
    0.06150501f, 0.10502632f, -0.06808466f, 0.01874247f, -0.24741481f, -0.18217555f, -0.11000381f, -0.03602557f, 
    0.14926201f, 0.24380806f, 0.06205266f, -0.09755134f, -0.02705788f, 0.13550875f, 0.06942587f, -0.15064581f, 
    -0.03018105f, 0.09827267f, 0.02534899f, 0.01736251f, 0.10750087f, 0.04474424f, -0.00059574f, -0.05402382f, 
    -0.29593247f, 0.15505120f, -0.08131102f, 0.28826037f, -0.07672064f, 0.12510026f, -0.06138020f, -0.09229670f, 
    0.08728992f, 0.21039927f, -0.14165345f, 0.05016912f, -0.09854734f, -0.00242525f, 0.05008985f, -0.19635913f, 
    -0.20189950f, 0.26760310f, -0.02879669f, -0.13275628f, 0.18889780f, -0.17023054f, 0.51301628f, -0.02851993f, 
    -0.43207714f, 0.33755314f, 0.14988297f, 0.02158093f, -0.15749229f, -0.19367701f, 0.08859575f, -0.02421921f, 
    0.00301988f, 0.02952299f, 0.02289160f, -0.00818416f, 0.07203536f, -0.07215973f, 0.15541682f, 0.23817499f, 
    -0.06542515f, -0.02565561f, -0.05497955f, -0.20386963f, -0.23765653f, 0.00494367f, 0.03757329f, -0.20479278f, 
    0.06638427f, 0.30535093f, 0.03829888f, 0.10574178f, -0.08650710f, 0.00537040f, -0.07005513f, -0.04331848f, 
    0.00681341f, -0.03189385f, -0.00939553f, 0.13463049f, -0.76362389f, -0.16990606f, -0.32018071f, -0.41850236f, 
    -0.61698008f, 0.16966759f, 0.00008755f, -0.11989157f, 0.04077757f, -0.12578881f, 0.10825775f, 0.03945414f, 
    0.03027489f, -0.09784122f, 0.04970810f, -0.03022420f, -0.02785209f, 0.00819263f, 0.05972432f, 0.11457233f, 
    0.24139337f, -0.01776712f, 0.20523612f, 0.07530764f, -0.14144786f, 0.02498214f, -0.07588190f, 0.09766620f, 
    0.16332966f, 0.13560040f, 0.10636898f, 0.10629550f, 0.03169451f, 0.03874451f, -0.11290234f, -0.03436276f, 
    -0.11715763f, -0.21672833f, -0.11637773f, -0.15548342f, -0.76693445f, 0.56611931f, -0.49093089f, -0.35065281f, 
    -0.22476272f, -0.13600799f, -0.18118070f, 0.10125986f, -0.13671672f, -0.22037213f, -0.13677230f, -0.06142957f, 
    -0.16745907f, 0.03863503f, -0.06968823f, -0.23218401f, -0.24271414f, 0.21751776f, -0.10611878f, -0.26801547f, 
    -0.15644883f, 0.01975729f, -0.18799669f, -0.29472986f, 0.41118518f, -0.08001287f, 0.14363219f, 0.13305493f, 
    0.02262381f, 0.27030042f, 0.14192405f, 0.17218389f, 0.02855376f, 0.09247230f, 0.02952120f, -0.17853212f, 
    0.10612201f, -0.26171070f, 0.17128246f, -0.15458426f, -1.19396734f, -0.30653602f, 0.72731322f, 0.24517314f, 
    -0.42904088f, -0.09242338f, -0.09704898f, 0.03047434f, -0.00221145f, 0.05913495f, 0.03650046f, 0.00542202f, 
    0.00307629f, -0.00722170f, 0.14275526f, -0.05893748f, -0.05151120f, 0.01735387f, -0.00136003f, -0.07385383f, 
    -0.15795530f, -0.62830883f, -0.72976863f, 0.09662573f, -0.03104889f, -0.03048863f, 0.16298768f, 0.01781114f, 
    -0.17663421f, -0.24888818f, -0.04456924f, -0.05024269f, 0.03125479f, 0.10702801f, 0.04336144f, 0.03103602f, 
    0.13871141f, 0.26080298f, 0.36103845f, 0.04039686f, -0.24153088f, 0.39492562f, 0.13805592f, 0.05208134f, 
    0.30818757f, 0.10325403f, 0.08818138f, -0.06794877f, 0.18390349f, 0.17791440f, 0.18751797f, -0.11448766f, 
    0.05434947f, 0.04680637f, 0.08687023f, 0.09864809f, -0.00416521f, -0.09099930f, -0.01863526f, 0.06959656f, 
    -0.15333164f, -0.30629399f, 0.14965351f, 0.01959476f, -0.20557597f, 0.02008106f, 0.15903836f, -0.02743285f, 
    0.00449587f, 0.00760313f, 0.20562054f, 0.13310517f, -0.09798145f, 0.23086160f, -0.33059174f, -0.01796429f, 
    0.06859618f, -0.01144276f, 0.07485000f, 0.13536854f, 0.14307590f, -0.14367996f, -0.27747342f, -0.18110803f, 
    -0.10769563f, 0.05250482f, 0.03341742f, 0.01520441f, -0.04859875f, 0.02333155f, -0.02083783f, -0.19829941f, 
    -0.05487058f, -0.20126352f, -0.18258403f, -0.11344639f, -0.08592883f, -0.15335478f, 0.00782697f, 0.03320035f, 
    0.01275061f, 0.27267307f, 0.01239576f, 0.11304077f, -0.00038837f, -0.01656137f, 0.05925467f, -0.06010817f, 
    -0.00232310f, 0.14737733f, -0.05201771f, 0.05697782f, 0.20573375f, 0.07075865f, -0.15941285f, 0.04420355f, 
    0.24523789f, -0.25675356f, -0.03269491f, 0.00194980f, -0.68080324f, -0.19753566f, 0.44303915f, -0.46740615f, 
    0.46875840f, -0.10560849f, -0.02231546f, 0.06669401f, 0.08241805f, -0.20146467f, 0.12515344f, -0.01443717f, 
    -0.04803326f, 0.07342747f, 0.00413426f, 0.01583373f, 0.19064651f, 0.29152036f, -0.11715481f, -0.02252229f, 
    -0.05608561f, 0.21370791f, 0.25593272f, -0.03315636f, -0.07989160f, -0.02761053f, -0.03232045f, -0.04665353f, 
    0.04113465f, 0.03132725f, 0.05164373f, 0.15022360f, 0.01190010f, 0.08667262f, 0.12451719f, -0.00494172f, 
    -0.05875722f, -0.07311754f, -0.24075449f, -0.06900184f, -0.01101974f, -0.00307801f, -0.09354034f, -0.10199209f, 
    0.03143346f, 0.00438156f, 0.02728113f, -0.11803702f, -0.07806544f, 0.06910191f, -0.13129157f, -0.12702976f, 
    -0.07084424f, -0.15255311f, -0.07332097f, -0.03935082f, -0.21257477f, -0.08210661f, 0.00788135f, 0.08186994f, 
    -0.12892345f, 0.04935995f, -0.36815125f, -0.27163440f, -0.04077999f, -0.06558928f, 0.13410021f, 0.03001696f, 
    0.00442752f, 0.02815716f, -0.03676257f, 0.04760296f, 0.04406201f, -0.03851677f, -0.05641929f, 0.16646177f, 
    -0.03990528f, -0.21137369f, 0.29448020f, 0.11220651f, -1.83859932f, -1.13733304f, -0.90049094f, -0.34001020f, 
    0.47936991f, -0.16678452f, -0.08729881f, -0.30544534f, -0.25783035f, -0.55967826f, -0.00226661f, -0.09088523f, 
    -0.11946505f, -0.01905508f, -0.00566219f, -0.06708510f, -0.01601667f, 0.15399861f, 0.27266747f, -0.10031718f, 
    -0.63979799f, 0.77713460f, 0.52269346f, -0.11083391f, 0.11774426f, 0.00840250f, -0.14428250f, -0.16010547f, 
    -0.05351422f, 0.14958993f, 0.04327180f, 0.02424606f, -0.00063024f, 0.11092192f, 0.22466213f, 0.01557395f, 
    0.01504216f, -0.12988125f, -0.05333710f, -0.03612779f, -0.68094397f, 0.03673309f, 0.77111590f, -0.03380149f, 
    0.21353737f, -0.18225101f, -0.12915431f, -0.02080247f, -0.29460651f, 0.15275489f, -0.19016063f, 0.12222973f, 
    0.18129969f, 0.09661079f, 0.03091232f, 0.02209497f, 0.04254274f, -0.04294770f, 0.02333192f, -0.00959655f, 
    -0.76128793f, -0.74327672f, -1.50131583f, -0.40400901f, 0.03970950f, -0.40590525f, 0.02278198f, 0.02535145f, 
    -0.09197795f, -0.32332084f, 0.08073178f, -0.08201347f, -0.04359745f, -0.07180678f, -0.03523209f, -0.03610300f, 
    -0.04182375f, 0.00464372f, 0.25820923f, 0.12191635f, -0.03691879f, -0.32513240f, 0.32800451f, -0.04532006f, 
    0.27749199f, -0.01184847f, -0.09541252f, -0.08352419f, 0.04485898f, 0.17572008f, -0.00813601f, 0.01798301f, 
    0.27758223f, 0.19245964f, -0.11184199f, -0.04045526f, 0.14315218f, 0.15384205f, 0.08557138f, 0.02623601f, 
    0.45512095f, 0.35113522f, -0.42111349f, 0.09991390f, -0.44697419f, 0.09317040f, -0.03252073f, 0.12187643f, 
    -0.12885423f, -0.12461676f, -0.26742539f, 0.03091047f, 0.05760099f, 0.06061313f, -0.06672069f, -0.04865668f, 
    -0.28238663f, 0.10469922f, -0.05549273f, -0.04327537f, 1.56474447f, -1.47558892f, -1.15457106f, -0.54673231f, 
    -0.76942021f, 0.15467559f, -0.13418376f, -0.26705936f, -0.19991784f, -0.36305273f, -0.06268067f, -0.07569576f, 
    0.10708527f, 0.01656148f, 0.01897448f, -0.03084873f, -0.00655704f, 0.00327428f, -0.06112288f, -0.08837564f, 
    0.14051200f, -0.66379631f, 0.73233783f, 0.25966457f, 0.10780924f, -0.04105453f, -0.04708136f, -0.24863285f, 
    0.08229921f, 0.19465478f, -0.02655567f, -0.03028126f, -0.01023088f, 0.00149629f, -0.06833173f, 0.19144364f, 
    0.07703622f, 0.03985697f, 0.04935434f, -0.11095861f, -0.10620882f, 0.04837290f, 0.06623736f, -0.20838757f, 
    0.04654031f, 0.01232515f, 0.06503453f, -0.05938607f, -0.01867899f, -0.12616757f, -0.00894981f, -0.00927215f, 
    -0.16925339f, -0.03127337f, 0.06139743f, -0.01825967f, 0.06282838f, -0.10809336f, -0.01801247f, 0.02594850f, 
    0.11787423f, 0.22626764f, -0.06107133f, -0.21802822f, 0.01044477f, -0.04567461f, 0.19720928f, -0.05961049f, 
    0.03421499f, -0.07035316f, -0.11982572f, 0.02781485f, 0.09638740f, -0.34568974f, -0.12089221f, -0.08513022f, 
    0.04561782f, 0.04663543f, -0.11154311f, 0.05371327f, 0.08678047f, 0.14578782f, 0.17180187f, -0.04629492f, 
    -0.11779679f, 0.00294875f, 0.01498816f, -0.02722477f, -0.01405150f, -0.09833050f, 0.07683828f, -0.04740288f, 
    0.06009188f, -0.09018799f, 0.02891261f, 0.02958416f, -0.05061264f, 0.14230664f, 0.10499541f, 0.04137883f, 
    0.01349568f, 0.10761438f, 0.01382817f, 0.21294452f, -0.23233838f, 0.01597336f, 0.14350764f, -0.01001742f, 
    0.00593983f, -0.07642265f, -0.09299569f, 0.05412999f, -0.02128623f, -0.09771915f, -0.03429892f, -0.11228500f, 
    -0.01488902f, -0.02214734f, -0.10160871f, -0.05167319f, -0.64947397f, -0.17066821f, 0.31307638f, 0.41234779f, 
    0.41506910f, 0.03602970f, 0.00033747f, 0.33159745f, -0.19592284f, 0.04486292f, -0.10934274f, 0.03122126f, 
    0.01195657f, 0.12957385f, -0.01340567f, 0.03388902f, 0.01863164f, 0.08499680f, -0.13092712f, -0.04611210f, 
    0.16841838f, 0.05826817f, -0.10090139f, -0.10298787f, -0.00396822f, 0.00331679f, 0.06273969f, 0.04580727f, 
    -0.09637705f, 0.00594969f, -0.19273946f, -0.43725938f, 0.16222011f, -0.01333903f, -0.00192514f, 0.01032690f, 
    -0.03912498f, 0.05294164f, -0.09597918f, -0.08388759f, 0.01668978f, 0.16298366f, 0.17338553f, -0.06788312f, 
    -0.13008009f, -0.01404091f, -0.00798376f, -0.05166985f, 0.05281415f, 0.02965509f, 0.04843332f, -0.01458393f, 
    0.01104282f, -0.09379726f, -0.01461318f, -0.09279615f, -0.03394369f, 0.08278291f, 0.16908695f, 0.03536832f, 
    -0.13284713f, 0.10542660f, -0.04567604f, 0.16472191f, -0.41606745f, 0.01431393f, 0.11426383f, -0.01510746f, 
    -0.10513689f, -0.08227843f, 0.03325275f, 0.08756384f, -0.00486613f, -0.07094461f, 0.01129999f, -0.26702258f, 
    -0.09242715f, -0.03283202f, -0.27978298f, -0.02491146f, 0.03342062f, -0.90325606f, 0.35549682f, 0.56804252f, 
    0.11896070f, -0.00787124f, 0.17090978f, -0.01739541f, 0.16738321f, 0.13608156f, 0.02626377f, -0.02374163f, 
    0.02464203f, -0.09578011f, -0.04161040f, 0.03152064f, -0.02952885f, -0.10055412f, 0.13450900f, -0.09257242f, 
    0.23343445f, -0.43515202f, -0.09580211f, -0.37684631f, -0.03010399f, 0.02462692f, 0.02883521f, 0.04142313f, 
    0.06873529f, -0.10089959f, -0.04717226f, 0.09420160f, 0.01884335f, 0.10015812f, 0.03874020f, 0.01631700f, 
    -0.03012711f, -0.01530210f, 0.06798515f, 0.02661704f, 0.74174404f, 0.13388735f, -0.41838390f, -0.15512699f, 
    -0.39085823f, -0.03227049f, -0.09207743f, -0.52854937f, 0.10045631f, -0.13844070f, 0.03698162f, 0.05620334f, 
    -0.01187898f, 0.05696113f, 0.02006602f, -0.02460476f, 0.05860893f, -0.04245164f, 0.07983525f, 0.07464839f, 
    -0.58714747f, -0.63234746f, -0.73194337f, 0.29848886f, -0.09692127f, 0.30288571f, -0.00732140f, -0.05662584f, 
    -0.06756645f, 0.00514151f, 0.00356711f, -0.01980870f, -0.05311552f, -0.11193174f, -0.04352607f, 0.09460662f, 
    0.15108532f, 0.07268728f, 0.05591913f, -0.19936103f, 0.44457948f, -0.85644239f, -0.57624799f, -0.22843681f, 
    -0.15860651f, 0.01199402f, -0.06608429f, -0.03631199f, 0.29543558f, 0.04251138f, -0.07909733f, -0.02975145f, 
    -0.06636360f, 0.08813697f, -0.02977278f, -0.14328453f, -0.02247300f, -0.26103675f, 0.14601500f, 0.20574205f, 
    0.75984907f, 0.10818493f, -0.04297149f, -0.09553120f, -0.12345859f, -0.01362869f, 0.23146200f, -0.06181692f, 
    0.08278809f, -0.20492136f, 0.10208174f, -0.06405318f, 0.10118816f, 0.09998195f, 0.10322035f, 0.12113982f, 
    0.23981287f, -0.05250880f, 0.22585699f, 0.03804826f, 0.58678108f, -0.59394467f, -1.22422302f, -0.79309815f, 
    0.40122065f, 0.13368052f, 0.10150274f, 0.24564140f, 0.01350987f, 0.02676891f, 0.00740338f, 0.20217234f, 
    -0.05842420f, -0.12748109f, -0.05565776f, 0.04696579f, -0.03754931f, 0.04015411f, -0.16783126f, 0.06148867f, 
    0.74106926f, 0.25636956f, 0.32542390f, -0.25725824f, -0.09861401f, 0.06194844f, -0.15839049f, 0.06950048f, 
    0.13158822f, 0.00073455f, 0.02899083f, 0.03146972f, -0.00423813f, -0.03218251f, 0.00389583f, 0.05308576f, 
    0.11342686f, -0.19163294f, -0.13923885f, -0.78157848f, 0.28765288f, -0.41992620f, -0.09505215f, 0.22526696f, 
    0.07852361f, -0.07489163f, 0.03768863f, 0.03518108f, 0.03802267f, 0.12927787f, 0.20826787f, -0.16549189f, 
    -0.02757385f, -0.01571593f, 0.14916638f, -0.02170797f, 0.10260787f, 0.06819087f, 0.04749958f, 0.11312665f, 
    -0.07335106f, -0.04371393f, -0.20664856f, -0.01678661f, -0.34066224f, -0.12158159f, -0.01079175f, 0.05959899f, 
    0.23349188f, 0.05715010f, 0.17349955f, 0.10001919f, -0.01961627f, 0.19717135f, 0.23084757f, 0.18517682f, 
    0.18599308f, 0.02460910f, 0.08492977f, 0.18855174f, -0.41027749f, 0.16340287f, 0.14843775f, -0.14345483f, 
    -0.27228463f, -0.11701421f, -0.04923502f, -0.06248838f, -0.00128015f, -0.08549648f, -0.18642753f, -0.09099683f, 
    -0.05761787f, -0.04540081f, -0.04100244f, 0.00102046f, 0.16173868f, 0.02709980f, 0.09790419f, 0.07042363f, 
    -0.04046525f, 0.14771527f, 0.25368878f, 0.04745952f, -0.21900430f, -0.03477598f, -0.08381817f, -0.02290899f, 
    0.02210269f, -0.10331921f, -0.15491283f, 0.01131327f, 0.04038559f, 0.00728180f, 0.05029042f, -0.09522668f, 
    -0.05056576f, -0.13930897f, -0.03238294f, -0.04588687f, -0.09429180f, -1.03821111f, 0.37822235f, 0.20594873f, 
    0.90289748f, -0.04952851f, 0.14394309f, -0.07081183f, -0.11123693f, 0.06634410f, 0.01868390f, -0.01266981f, 
    0.09042219f, -0.01774161f, 0.01655044f, -0.20561813f, -0.35930398f, -0.08002330f, -0.17905320f, -0.17395298f, 
    -0.01095932f, -0.15677558f, -0.06705357f, 0.06343087f, -0.02627975f, -0.15283936f, -0.01465626f, -0.03084504f, 
    0.07108198f, 0.04099424f, 0.05079394f, 0.18430860f, -0.01430231f, 0.07723009f, 0.04094730f, -0.07759334f, 
    0.25440955f, 0.13318758f, 0.18834209f, 0.13993886f, -0.46516985f, 0.05055034f, 0.08657955f, -0.06283350f, 
    -0.20181207f, -0.04140153f, -0.14353034f, 0.00674032f, 0.03344278f, -0.17502923f, -0.16044784f, -0.12277031f, 
    0.01108617f, -0.07802524f, -0.03213475f, 0.04033989f, 0.11919171f, -0.05483352f, -0.07983036f, 0.09893037f, 
    0.17162581f, 0.31936368f, 0.36282727f, 0.05272165f, -0.10574736f, -0.00764198f, 0.02426279f, -0.11684663f, 
    0.03670238f, -0.10681602f, -0.08847332f, -0.03774578f, 0.04994084f, -0.14116023f, -0.01865912f, -0.15938337f, 
    -0.21925168f, -0.13523075f, -0.08781033f, -0.16312291f, 0.24398237f, -1.05035794f, -0.94219482f, -0.38403669f, 
    -0.32113481f, -0.11172617f, -0.14212286f, -0.06025084f, -0.03488649f, -0.31149900f, -0.15583892f, -0.03007087f, 
    0.03907124f, 0.02077556f, 0.03170808f, -0.00851430f, 0.07659424f, 0.05607233f, 0.10168670f, 0.27513251f, 
    -0.00036342f, -0.48018706f, -0.44197300f, -0.15365517f, 0.26156807f, 0.15030549f, 0.05065277f, 0.08185817f, 
    0.09781589f, 0.19673377f, -0.00716092f, -0.13625641f, -0.20799792f, -0.15542339f, -0.12356347f, 0.01418172f, 
    0.05095451f, 0.12560126f, 0.00290269f, 0.03551303f, -0.18275125f, -0.29491270f, -1.32175732f, -0.20140566f, 
    0.02875636f, -0.18302463f, 0.10708059f, 0.28855601f, 0.32200712f, 0.07429775f, 0.27484357f, 0.01196404f, 
    0.11623706f, 0.05523311f, 0.00149367f, -0.08654938f, -0.00296598f, 0.00419198f, 0.00669605f, 0.00101340f, 
    0.46058199f, -0.43199459f, -0.54549921f, -0.15162876f, 0.17411181f, -0.09825952f, -0.04875452f, -0.10903875f, 
    -0.21206273f, -0.36500189f, 0.08909439f, -0.10259817f, 0.02891250f, 0.18605798f, 0.08331984f, 0.10812158f, 
    -0.00290685f, 0.10332686f, -0.29063556f, -0.32542115f, 0.21920392f, 0.00692983f, -0.36770919f, 0.01730596f, 
    0.06004279f, -0.16886929f, -0.07020164f, 0.16962335f, 0.05280009f, -0.17616022f, -0.05349224f, 0.01676788f, 
    -0.02480210f, 0.31254625f, -0.02667507f, 0.03807611f, -0.17995270f, -0.00000285f, -0.23537472f, -0.29673713f, 
    -0.92568201f, 0.46272209f, -0.66208386f, 0.33492231f, -0.20016581f, 0.05243706f, -0.12930012f, -0.04660076f, 
    -0.24372388f, -0.24525778f, 0.06097102f, -0.13071875f, -0.01263468f, -0.27486423f, -0.10482091f, 0.01601318f, 
    -0.13050699f, -0.31313381f, 0.05985586f, -0.07912745f, -1.11356711f, -0.24085800f, 0.11123154f, 0.18892898f, 
    -0.77405983f, 0.08065205f, -0.05829422f, -0.25708953f, -0.51743180f, 0.02182005f, 0.12571013f, -0.19586387f, 
    -0.05510592f, -0.03460197f, 0.01224659f, 0.00641928f, -0.13404557f, -0.07353151f, -0.09296311f, -0.30624887f, 
    -0.09403118f, -1.10431564f, -0.63930267f, 0.21315287f, -0.07715926f, -0.09662772f, 0.22546330f, 0.01152460f, 
    0.19217665f, 0.12995224f, -0.04072428f, -0.00318269f, 0.05029997f, 0.07113945f, -0.07208280f, 0.06308170f, 
    0.18916431f, 0.03584982f, 0.27039856f, 0.33716637f, -0.07296649f, -0.39987189f, 0.10037734f, 0.11256929f, 
    -0.22367296f, -0.03157741f, 0.20523214f, -0.33489767f, -0.09568289f, -0.36636648f, 0.22331305f, -0.00950112f, 
    0.11994215f, 0.08468778f, 0.11301259f, 0.05032346f, 0.23789224f, -0.11633073f, -0.07024392f, 0.12295510f, 
    -0.62776399f, -0.23654342f, 0.09821451f, 0.22610939f, 0.40008077f, -0.37452057f, 0.37722030f, -0.58387613f, 
    0.12012803f, -0.19331269f, -0.11151144f, 0.08337462f, -0.16118304f, -0.05202818f, -0.00329771f, 0.21354182f, 
    0.03763945f, -0.10750168f, -0.19735409f, 0.03353165f, -0.21714495f, -0.16329165f, -0.30988503f, -0.06612599f, 
    0.33953950f, -0.12778114f, 0.26204750f, 0.20349474f, 0.13063614f, -0.10571622f, 0.12823734f, 0.19559836f, 
    0.07554460f, -0.11135070f, 0.00991334f, 0.17200333f, 0.08051515f, -0.04796593f, -0.00483298f, -0.01259599f, 
    -0.16540821f, 0.17429343f, -0.14195432f, 0.39712292f, 0.25922871f, -0.04932724f, 0.04428746f, 0.11195400f, 
    -0.05252760f, -0.09976728f, 0.06153536f, -0.03303193f, 0.08168353f, -0.06811178f, -0.09717762f, -0.04393293f, 
    0.00973166f, 0.06684741f, 0.05656763f, 0.26610503f, 0.25472441f, -0.80086124f, -0.79751050f, -0.70237917f, 
    -0.52347732f, 0.14541581f, -0.23035587f, 0.16595827f, 0.13453041f, 0.04062565f, -0.16651459f, 0.11612529f, 
    0.03760393f, -0.08395499f, 0.05235174f, 0.18761136f, 0.11556613f, 0.11645618f, -0.01980682f, 0.19285639f, 
    -0.04227221f, 0.31379661f, 0.45029140f, -0.06992184f, 0.12968658f, 0.01489910f, 0.02536256f, -0.05978848f, 
    -0.09295776f, 0.05524248f, 0.03080058f, 0.12990631f, -0.00436049f, 0.04115414f, 0.09865402f, 0.00038153f, 
    -0.17393370f, -0.16498020f, -0.07917635f, -0.10415704f, -0.21506810f, -0.10573684f, -0.43021637f, -0.19816998f, 
    -0.03796513f, 0.05775152f, 0.19078115f, 0.39625579f, -0.05745578f, 0.01404978f, 0.05519149f, 0.10493873f, 
    -0.03832889f, 0.01957236f, -0.04356601f, 0.04165091f, 0.15319233f, -0.08827819f, -0.11765237f, 0.04687086f, 
    -0.32691082f, 0.11818375f, -0.72318357f, 0.40247223f, 0.15907362f, 0.03231015f, 0.07599364f, 0.29071397f, 
    -0.04592769f, -0.02929217f, -0.02917390f, -0.13493730f, 0.05160638f, 0.10727375f, -0.14654504f, -0.02895437f, 
    0.16693647f, -0.03717464f, 0.08921333f, 0.21627972f, -0.51877201f, -0.39233646f, 0.45182836f, 0.05616533f, 
    -0.48849818f, -0.19379021f, -0.31316069f, 0.34470010f, 0.12795149f, 0.31331030f, -0.06761723f, 0.04092420f, 
    0.04562010f, -0.08325843f, -0.16987540f, 0.06335142f, -0.01177326f, 0.06651981f, 0.07416843f, -0.26601562f, 
    0.51028460f, -0.09414077f, 0.49026397f, 0.31856310f, -0.42711842f, -0.01261499f, -0.03658189f, -0.41944808f, 
    -0.03658423f, -0.10887025f, 0.08036508f, 0.02967825f, 0.08982518f, -0.04839344f, 0.01996308f, -0.00466479f, 
    -0.08286437f, -0.07515095f, -0.04895507f, -0.02499967f, -0.31721652f, 0.30634215f, -0.00153618f, 0.72773451f, 
    -0.41702667f, -0.14462309f, 0.17378771f, -0.66760463f, 0.04442473f, -0.24046983f, 0.06067031f, -0.10261330f, 
    0.06200032f, 0.11362807f, 0.08808720f, 0.09609605f, 0.07945567f, -0.03074651f, 0.00025279f, -0.10551503f, 
    -0.02550784f, -0.05850357f, 0.06566865f, 0.14054082f, -0.18907030f, 0.08955128f, -0.39361864f, -0.03938125f, 
    0.21010256f, 0.09738296f, 0.00776229f, 0.07391322f, -0.01414578f, 0.09351151f, 0.10388889f, -0.08221871f, 
    0.17390887f, 0.17929533f, 0.20426515f, 0.17778566f, -0.09566867f, 0.16832936f, 0.14406121f, 0.58427787f, 
    -0.29139981f, -0.01189833f, 0.19893090f, -0.34749028f, -0.07661826f, 0.03606043f, 0.04774799f, 0.00812790f, 
    0.15186051f, -0.08051404f, 0.02305815f, 0.20900406f, 0.11570425f, -0.00015710f, 0.05423079f, 0.11611681f, 
    0.31559679f, -0.71686810f, 0.48044214f, -0.26583150f, -0.28112063f, -0.07624875f, 0.07315978f, 0.07876757f, 
    0.31652597f, -0.05120088f, -0.10553864f, 0.00574956f, -0.04694663f, -0.03649536f, 0.02621338f, 0.13466661f, 
    0.04768504f, 0.20380385f, 0.25078416f, -0.29868805f, 0.29661423f, -0.31092602f, 0.34480336f, 0.09866892f, 
    0.40134156f, -0.14077485f, 0.17682420f, 0.59833777f, 0.08747714f, 0.12937409f, -0.12050283f, -0.00396232f, 
    0.01085943f, 0.11194088f, 0.16658805f, 0.10279585f, 0.04112047f, 0.29452813f, 0.05387893f, 0.22789606f, 
    -0.26963231f, 0.07915998f, -0.46671778f, 0.38061938f, 0.17266524f, 0.14071724f, -0.03128964f, 0.31142819f, 
    -0.19683820f, -0.11436865f, -0.04620043f, 0.03113674f, -0.02576941f, -0.03332674f, 0.10629489f, -0.04237521f, 
    -0.21027546f, -0.41348523f, -0.36475796f, -0.26332545f, -0.63323790f, 0.64699447f, 0.10415940f, 0.21542923f, 
    0.02830079f, 0.05184817f, -0.04841881f, 0.01605488f, 0.40078089f, 0.12379966f, -0.14105849f, -0.07700165f, 
    -0.00691680f, 0.05954009f, 0.04843441f, -0.33571729f, -0.03949302f, -0.16240536f, 0.23872849f, 0.17100729f, 
    0.35122353f, -0.23953766f, 0.42854673f, -0.05036100f, -0.19103669f, 0.09381188f, -0.15667607f, 0.08825111f, 
    -0.23910734f, 0.09850919f, -0.07382786f, 0.10603665f, 0.14313251f, 0.32479626f, 0.26221266f, -0.09596449f, 
    0.02508861f, 0.08056000f, -0.12325656f, 0.08190627f, -0.07308239f, -0.73005402f, -0.04146843f, -0.43749598f, 
    -0.28568840f, -0.25091895f, -0.39166155f, 0.10338033f, -0.07324348f, -0.10377048f, -0.16182272f, 0.18753487f, 
    0.06346779f, -0.15887856f, 0.11233740f, 0.03710661f, 0.07996832f, 0.19348009f, 0.03310735f, 0.06185582f, 
    0.26464140f, -0.39851809f, 0.44689965f, 0.24555054f, -0.15440798f, -0.06424516f, -0.08825689f, 0.00620658f, 
    -0.13461192f, -0.14857955f, 0.05395510f, -0.02162381f, -0.12292279f, 0.02178112f, -0.10865749f, 0.02695022f, 
    -0.13633396f, 0.05699059f, -0.02837582f, -0.21685755f, -0.60443830f, 0.21854472f, -0.66074497f, 0.26557469f, 
    -0.17590052f, -0.18641061f, 0.10756085f, 0.03708998f, 0.09425135f, -0.06994339f, 0.15354218f, 0.15752649f, 
    -0.12351851f, 0.12062341f, -0.04846302f, 0.04683684f, -0.15303901f, -0.19302596f, -0.23554988f, -0.24764392f, 
    -0.03510067f, -0.43255660f, 0.39443696f, -0.33309856f, -0.19295302f, -0.18658230f, 0.22833289f, 0.22859210f, 
    0.25369239f, 0.06931298f, -0.05166887f, -0.12583260f, 0.01845035f, -0.11732984f, -0.10372551f, -0.00781132f, 
    0.21285880f, 0.46998402f, 0.20801322f, 0.33509934f, 0.05162506f, -0.53445023f, -0.44054991f, 0.40053719f, 
    -0.40024209f, -0.28542066f, -0.26088423f, -0.03987798f, -0.33484471f, -0.03303253f, -0.13616996f, 0.08146112f, 
    -0.29596716f, 0.04775588f, 0.10183751f, 0.14814027f, -0.05694347f, 0.02074954f, 0.12293642f, 0.04237348f, 
    0.06430933f, -0.33617416f, 0.28306609f, -0.11158657f, 0.09356648f, -0.19944966f, -0.09531818f, 0.06060295f, 
    -0.13410021f, -0.17538127f, -0.04754796f, 0.00497871f, -0.13503510f, 0.07732873f, 0.02534300f, 0.20818511f, 
    -0.09389710f, -0.02085804f, -0.11959840f, -0.18555894f, -0.78342420f, 0.03939370f, -0.55883670f, -0.05473370f, 
    0.16906248f, -0.10948860f, -0.07402531f, -0.15316783f, 0.12020234f, -0.10097411f, -0.10090575f, 0.08875467f, 
    0.04016390f, 0.10230545f, -0.05242063f, 0.05287981f, 0.08335669f, -0.22472695f, 0.22411984f, 0.03418026f, 
    -0.34233591f, 0.17232890f, -0.24467081f, 0.26877907f, 0.23352095f, -0.02799463f, -0.00655279f, -0.05098251f, 
    -0.15528652f, 0.13023765f, -0.15394713f, -0.03767231f, 0.09745213f, -0.02432633f, -0.09169493f, 0.13523504f, 
    -0.03322132f, -0.22161290f, 0.11952815f, 0.22549237f, 0.41327506f, 0.27539331f, 0.06577766f, -0.32144129f, 
    -0.06276410f, 0.13946117f, -0.15869929f, 0.06036219f, -0.10236972f, -0.00314616f, -0.13968158f, 0.16367695f, 
    -0.07547333f, -0.11075667f, -0.09237421f, -0.08657929f, -0.15641068f, -0.03280448f, -0.00831461f, -0.06406737f, 
    -0.28789979f, 0.02777301f, -0.45873681f, 0.07868679f, 0.02115049f, -0.04709860f, -0.01267431f, -0.01476870f, 
    -0.07379421f, 0.01845024f, -0.07431063f, 0.09034110f, -0.03716401f, 0.04486836f, -0.02097480f, 0.05324747f, 
    -0.09899400f, -0.06210577f, -0.25283870f, -0.21964569f, 0.23628105f, -0.22968464f, 0.35879084f, -0.00138152f, 
    0.09372560f, 0.13161857f, -0.11362444f, -0.01656811f, -0.14015491f, -0.12090443f, -0.09252463f, 0.00166287f, 
    -0.20915082f, -0.08669896f, -0.33404240f, -0.08302273f, -0.09422844f, 0.19850905f, -0.06989379f, -0.32963768f, 
    0.21963550f, -0.21176776f, 0.48031706f, -0.37996101f, 0.52206618f, 0.33049226f, 0.42985052f, 0.02963312f, 
    0.28001994f, -0.03930298f, -0.12173791f, 0.23846710f, 0.22821771f, 0.07999121f, 0.19863422f, 0.12472710f, 
    0.16628653f, 0.00249360f, -0.39363566f, 0.13131559f, -0.19227074f, -0.36374363f, 0.09564860f, -0.33326361f, 
    0.33162948f, 0.10688703f, -0.38549262f, -0.48717836f, 0.47134963f, 0.26927921f, 0.12035357f, 0.28299940f, 
    -0.12251602f, -0.17366968f, -0.26333433f, -0.06832431f, -0.03580946f, -0.08527564f, 0.27498856f, -0.03859479f, 
    -0.02934293f, -0.15460908f, -0.09560651f, 0.42739588f, -0.19684361f, 0.18810880f, -0.23774235f, 0.24320200f, 
    -0.31466657f, -0.07245284f, -0.02012466f, 0.21463510f, 0.00198129f, 0.06840385f, 0.17990625f, 0.00669643f, 
    -0.06232065f, 0.30581552f, 0.03318635f, 0.19306563f, -1.07405818f, 0.24066338f, -0.54761118f, 0.72615236f, 
    -0.67476600f, 0.16463503f, 0.12723593f, 0.26025182f, 0.05198935f, -0.12933972f, -0.06703642f, -0.00744287f, 
    -0.05273993f, 0.09079378f, -0.08786369f, 0.35404289f, -0.02456302f, 0.06394593f, -0.06336385f, 0.06228660f, 
    -0.97395778f, -0.05441395f, -0.38366973f, 0.33560905f, -0.08467835f, 0.15905491f, 0.13936307f, 0.45756903f, 
    -0.20663300f, 0.10268061f, -0.04801554f, 0.07441577f, -0.19420567f, 0.17371936f, 0.22785535f, 0.00756072f, 
    -0.01985442f, 0.03726431f, 0.20765728f, -0.33808142f, 0.26578471f, 0.21823943f, 0.23938280f, 0.20969696f, 
    -0.22290052f, -0.19474433f, 0.11174673f, -0.04936035f, 0.07401225f, 0.07697988f, -0.26295444f, 0.06790125f, 
    -0.02824451f, 0.02650407f, -0.09379499f, 0.07132220f, 0.09322483f, 0.09290404f, -0.25721833f, 0.01340773f, 
    -0.02997095f, -0.35283071f, 0.05663349f, -0.12636322f, 0.13534698f, 0.10586720f, 0.05893848f, 0.09559456f, 
    0.06504603f, -0.09043451f, 0.06618918f, -0.14269039f, -0.04538419f, -0.00799154f, 0.04131366f, 0.00615832f, 
    0.02475565f, -0.04065263f, 0.00330673f, -0.08401661f, -0.58966911f, -0.47164592f, -0.28342849f, 0.41380411f, 
    0.07859583f, -0.09097683f, 0.22438206f, -0.06596346f, 0.19003333f, -0.04443115f, -0.37802228f, 0.09732008f, 
    0.14799696f, 0.00916295f, 0.12822759f, 0.30926332f, -0.21199855f, 0.11479750f, -0.04853022f, -0.03362959f, 
    -0.24064663f, -0.16207300f, -0.13948572f, 0.15697427f, 0.31772757f, -0.02935697f, 0.26249483f, -0.10289834f, 
    0.14675805f, 0.12695999f, 0.05205988f, 0.19330980f, -0.20140395f, -0.04629801f, 0.14911579f, -0.08155318f, 
    -0.28111652f, -0.01025702f, -0.18672110f, -0.25738278f, 0.61131406f, -0.22508800f, 0.22966354f, -0.08239330f, 
    -0.62533522f, -0.10315564f, 0.05360018f, -0.17600425f, 0.24118166f, 0.01682751f, -0.03413259f, 0.03891810f, 
    0.08863273f, -0.03805480f, -0.27345705f, 0.09160333f, 0.14627853f, -0.05607754f, 0.04535771f, 0.01729383f, 
    0.53183210f, -0.21643484f, 0.42903662f, -0.15271720f, 0.31052816f, 0.01766284f, 0.00337926f, -0.10971458f, 
    0.04380036f, -0.06271590f, -0.11029962f, -0.05156214f, -0.09430420f, -0.12623145f, -0.16005670f, 0.03536253f, 
    0.09917814f, 0.05482936f, -0.06331678f, 0.12497779f, 0.10998914f, -0.60035175f, -0.23658468f, -0.07636184f, 
    -0.15461898f, -0.04666997f, -0.49408743f, -0.13480237f, -0.53428817f, -0.16758202f, 0.02876006f, 0.05180049f, 
    -0.07821956f, 0.00295615f, 0.00422226f, 0.05073450f, -0.05541045f, 0.12153351f, -0.12928864f, -0.22917907f, 
    -0.24741164f, -0.35246071f, -0.18537946f, 0.42626807f, -0.47029224f, -0.10910766f, -0.10900452f, 0.05571241f, 
    -0.11792734f, 0.28243372f, -0.04435280f, -0.06677108f, 0.04610699f, -0.31711054f, -0.19206858f, 0.03403414f, 
    -0.22932869f, -0.11076043f, -0.19018629f, -0.24738370f, -0.70278066f, -0.02071654f, -0.57945490f, 0.48870024f, 
    -0.48246023f, 0.23308530f, 0.16189893f, 0.16037886f, -0.27837071f, 0.22587112f, -0.18885101f, -0.14778072f, 
    -0.06264225f, 0.04918639f, -0.02282002f, -0.03036044f, -0.07597303f, -0.01343401f, 0.02813300f, 0.08211716f, 
    0.21510196f, -0.52365386f, 0.14462742f, -0.37804216f, 0.23191456f, -0.14588004f, -0.34419194f, 0.02923085f, 
    0.01634742f, -0.16267462f, -0.07340086f, 0.00850677f, 0.08160379f, -0.06552630f, 0.00427343f, 0.20202565f, 
    0.01640694f, 0.07296516f, 0.19125637f, 0.02151707f, -0.51496327f, 0.52356875f, -0.59602290f, 0.21942757f, 
    -0.12116338f, 0.06340659f, 0.25210491f, 0.09031141f, -0.28238934f, 0.20396438f, -0.15026245f, -0.11618793f, 
    0.11870494f, 0.14614105f, 0.17416273f, 0.05081465f, 0.01435275f, -0.01838660f, 0.12864648f, 0.25310299f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.25802490f, 0.28489107f, 0.03298862f, -0.21138164f, -0.15513834f, 0.07831516f, -0.01859183f, -0.14879178f, 
    0.13655671f, 0.05987184f, 0.04026975f, 0.01683932f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
