#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.61039495f, -0.21767798f, 0.34080425f, 0.27735525f, -0.11484913f, -0.23765714f, -0.48070121f, -0.58560956f, 
    -0.51084185f, -0.09829612f, -0.11804454f, -0.29989034f, -0.31373027f, -0.33415908f, 0.04951235f, -0.04726545f, 
    -0.12169624f, 0.11590973f, -0.15175276f, -0.14291205f, 0.21301119f, 0.15697950f, -0.12228497f, -0.21293305f, 
    -0.28703585f, 0.73955905f, 0.69971758f, 0.21372095f, -0.20540692f, 0.06789462f, -0.36977458f, -0.38912377f, 
    0.14153297f, -0.21083947f, -0.38126677f, 0.00634172f, -0.02009577f, -0.14213856f, -0.14399779f, 0.15838592f, 
    -0.13617784f, -0.03979962f, 0.38507012f, 0.05033119f, -0.23403712f, 0.00795697f, -0.01371578f, -0.17487669f, 
    0.10089672f, -0.29420137f, -1.04246247f, -0.21918236f, 0.28286546f, 0.74282944f, -0.52041972f, 0.23061056f, 
    -0.33378410f, 0.09391152f, 0.21917418f, 0.30711961f, -0.34054637f, 0.10511081f, -0.24917212f, 0.40829462f, 
    0.01640891f, 0.25950113f, -0.00073039f, -0.02344589f, -0.10733804f, 0.19205953f, 0.15315142f, -0.22133289f, 
    0.07124150f, -0.09352648f, -0.10030986f, 0.05356588f, -0.38799900f, -0.42359304f, -0.22003442f, -0.54525954f, 
    0.05931779f, -0.27340978f, -0.42878792f, -0.49102166f, -0.44236913f, -0.16299997f, -0.09752481f, -0.11329176f, 
    -0.33190504f, -0.19576509f, -0.18079425f, 0.14075463f, -0.32196730f, -0.39329466f, -0.12473255f, -0.27749601f, 
    -0.01169004f, 0.09000763f, -0.23759159f, -0.15948634f, 1.03850424f, -0.76900214f, -0.56877530f, 0.09166887f, 
    -0.25819001f, 0.35161710f, 0.15338959f, 0.36695454f, 0.09333843f, -0.26925188f, -0.10308368f, -0.10450921f, 
    0.18321308f, -0.32741272f, 0.07743409f, -0.07926058f, -0.17901392f, 0.31223491f, 0.01011691f, -0.02137333f, 
    0.08350101f, -0.14666468f, -0.13838805f, 0.03384040f, 0.27579290f, 0.33021286f, 0.38275915f, 0.05412504f, 
    -0.02745840f, -0.05603902f, -0.18090576f, -0.11520122f, -0.26214367f, 0.14922614f, -0.15885475f, -0.11915658f, 
    -0.00056575f, -0.08974685f, -0.14749415f, 0.20946760f, 0.21556072f, -0.17052478f, -0.11668834f, -0.06305896f, 
    -0.27207464f, -0.18783256f, 0.18722962f, 0.08170236f, 0.28404352f, 0.18479325f, -0.17552361f, -0.56159925f, 
    -0.52441025f, 0.00183603f, 0.40351745f, 0.34161931f, 0.41868737f, 0.47674185f, 0.17836563f, 0.24809587f, 
    -0.11749216f, -0.21418983f, -0.21918352f, -0.18846455f, 0.04726771f, 0.10525962f, 0.03881751f, 0.17462912f, 
    -0.19206780f, 0.01866586f, 0.03376258f, -0.09540085f, -0.12306605f, 0.14249016f, -0.13811222f, -0.00660724f, 
    -1.02338481f, 0.36243671f, 0.77332175f, 0.61234033f, -0.33402205f, -0.88290745f, -0.68303412f, -0.07546453f, 
    0.53423005f, 0.05627744f, 0.32806510f, 0.06841398f, 0.33188465f, 0.00093040f, -0.08097862f, 0.24621402f, 
    -0.17668399f, -0.08432508f, -0.12293793f, 0.10574827f, 0.02580841f, -0.11297911f, 0.09546943f, -0.02270188f, 
    0.13050593f, 0.06047902f, -0.16315944f, -0.03478739f, -0.15537778f, -0.00369868f, 0.27541789f, -0.29790786f, 
    -0.39494911f, 0.43034813f, -0.22381903f, 0.31577924f, -0.11096021f, -0.36869821f, 0.37929890f, -0.17228393f, 
    -0.15818051f, -0.12131992f, 0.10950452f, 0.29997584f, -0.19886938f, 0.16534907f, -0.24980631f, 0.06169202f, 
    0.31685403f, -0.26230574f, 0.19434784f, 0.38340345f, 0.43553364f, 0.22762111f, 0.09661476f, -0.51606572f, 
    -0.55641431f, -0.29736894f, 0.23656672f, -0.28303450f, 0.04218475f, -0.05057648f, -0.29723594f, -0.36423162f, 
    0.14629358f, -0.01162722f, 0.28643972f, 0.25405246f, -0.22739427f, -0.19121890f, 0.08394543f, -0.20285094f, 
    0.01988503f, -0.26078787f, 0.77636451f, 0.09059139f, -0.54945326f, 0.31903103f, -0.39498907f, -0.25843486f, 
    -0.01477729f, 0.06137569f, 0.04849529f, 0.49956998f, -0.00851370f, 0.37614942f, -0.20889318f, -0.23697497f, 
    0.02718511f, 0.00272219f, -0.24441622f, 0.26701117f, -0.17106453f, -0.43962473f, -0.08232770f, -0.06312756f, 
    -0.03359128f, -0.21524629f, -0.23354398f, 0.34646809f, 0.48222017f, 0.05576318f, -0.05723469f, -0.33855343f, 
    -0.37821719f, 0.10088801f, -0.10068779f, 0.27844304f, -0.14549178f, 0.33833459f, 0.11756285f, -0.21773809f, 
    0.07611592f, -0.22694895f, 0.05220487f, -0.26213145f, 0.12446781f, -0.09993852f, 0.10576003f, 0.05521647f, 
    0.24940099f, -0.33019796f, -0.07567142f, -0.32639530f, 0.77164823f, 0.69230306f, -0.07614932f, 0.38328877f, 
    -0.37622485f, -0.20531024f, -0.49588922f, -0.35994941f, -0.19784549f, -0.20491436f, 0.25028959f, -0.17402656f, 
    0.11508936f, 0.03409310f, -0.43561304f, -0.26420945f, 0.06848787f, 0.06264010f, 0.19549763f, -0.17348200f, 
    0.07551779f, -0.15936454f, 0.12411644f, -0.00464521f, 0.10312026f, 0.00538241f, 0.17038839f, -0.34243253f, 
    0.22866191f, -0.07699372f, 0.02581044f, -0.24551998f, 0.14201811f, 0.00513882f, 0.10047898f, 0.30699253f, 
    -0.19398184f, 0.19217663f, -0.17843185f, 0.00592234f, 0.08464485f, -0.12764145f, 0.11153162f, -0.00084162f, 
    -0.37021911f, -0.28686187f, 0.17184286f, 0.26751772f, 0.20120344f, 0.16267827f, -0.16192199f, 0.89165336f, 
    0.29926121f, -0.46682122f, 0.04579776f, -0.29424295f, 0.12911874f, -0.15316387f, -0.47769600f, -0.05065795f, 
    -0.35016251f, 0.39298761f, 0.29670498f, 0.21463238f, -0.18792979f, -0.08207704f, 0.07597600f, -0.09504253f, 
    0.31155834f, 0.01251218f, 0.16155423f, 0.29468042f, -0.25617623f, -0.10860134f, -0.15652266f, 0.04114908f, 
    -0.41714475f, -0.37741745f, -0.52134824f, -0.45067751f, 0.54766494f, 0.17558996f, 0.16600689f, -0.27271727f, 
    0.00057704f, -0.26697475f, 0.17816094f, -0.10243174f, 0.11195376f, -0.09140389f, 0.18362847f, -0.06041099f, 
    -0.18669775f, -0.03771994f, -0.04961694f, -0.05161434f, 0.06723241f, -0.23211913f, -0.18491553f, 0.03493071f, 
    0.37390861f, -0.41766399f, -0.11000111f, 0.55117947f, -0.21508661f, 0.44343227f, 0.04132232f, -0.09045655f, 
    -0.30207887f, -0.13341410f, 0.38768852f, 0.05913963f, 0.13359641f, -0.47170195f, -0.26122019f, -0.13853267f, 
    -0.16907857f, 0.26233673f, 0.13980944f, -0.04681704f, -0.40073493f, 0.15224674f, 0.19319707f, 0.13132021f, 
    -0.25416312f, 0.55654114f, -0.26996768f, -0.45349801f, -0.60898596f, -0.49827695f, 0.21874119f, -0.40489945f, 
    -0.38814181f, -0.27981415f, -0.62724602f, 0.46612430f, -0.04817257f, 0.13008586f, -0.11219823f, -0.24426027f, 
    -0.21911915f, -0.41085112f, -0.37359604f, -0.06050474f, 0.08366866f, -0.02546220f, 0.14418864f, 0.16081686f, 
    -0.24541363f, -0.23265669f, -0.81302708f, 0.16860342f, -0.56895083f, -0.82198977f, 0.40591526f, 0.25642529f, 
    0.27567148f, 0.55727756f, 0.27417383f, -0.14488730f, -0.15506014f, -0.18170798f, -0.40957904f, -0.47175196f, 
    0.13207029f, -0.05638178f, 0.11087477f, 0.00553369f, 0.29053000f, -0.61913729f, 0.04162256f, -0.09023896f, 
    -0.30517673f, 0.17310056f, 0.34311110f, -0.05384102f, -0.19958557f, 0.00790137f, -0.64225930f, -0.53820944f, 
    0.18927269f, 0.29617792f, 0.01591841f, 0.03108624f, -0.02095901f, -0.10706573f, -0.30118340f, 0.37396911f, 
    0.21169193f, -0.16148746f, -0.08405605f, -0.21925144f, -0.36632004f, -0.31183904f, 0.13132870f, -0.34566149f, 
    0.35893509f, 0.39044014f, -0.07512765f, 0.21751302f, -0.63880026f, -0.46695596f, -0.03763561f, -0.12956880f, 
    0.28029919f, -0.08381546f, 0.00663148f, -0.70945567f, -0.54020637f, -0.01364088f, -0.22486107f, 0.25701490f, 
    -0.40164351f, -0.27377704f, -0.05117308f, -0.10191902f, -0.01806909f, 0.09829539f, 0.35331342f, -0.05651706f, 
    0.18160793f, -0.24311170f, -0.20453426f, 0.16759640f, -0.03256955f, -0.66197765f, -0.53037906f, -0.57162827f, 
    -0.25166094f, -0.12732568f, 0.14538164f, -0.02984469f, 0.06546328f, -0.04745620f, -0.13284151f, -0.10871739f, 
    0.00571355f, 0.13951463f, 0.03750499f, 0.10691460f, 0.12649569f, -0.38242543f, -0.40858424f, -0.30603716f, 
    -0.26414785f, -0.24304730f, 0.20655908f, -0.18032785f, 0.06925618f, 0.02160043f, 0.62341201f, 0.57575053f, 
    0.35659453f, -0.08258571f, -0.50908881f, -0.51157880f, -0.44041380f, 0.09196074f, 0.15606055f, 0.13983418f, 
    -0.03192688f, -0.13281068f, 0.04777337f, 0.03180932f, -0.07878866f, -0.13302080f, 0.08719262f, 0.03071625f, 
    -0.23309977f, 0.13912858f, 0.12442032f, -0.12671681f, -0.04896265f, 0.13868213f, 0.12108199f, 0.10588013f, 
    -0.10135204f, -0.03123833f, 0.28197429f, 0.33100331f, -0.02738743f, 0.17360227f, 0.09136637f, 0.12603773f, 
    0.03748635f, 0.11383791f, 0.09256691f, -0.01944292f, 0.08622701f, 0.06183517f, 0.24007218f, -0.31036001f, 
    0.00377532f, 0.03939062f, -0.19480032f, -0.01650402f, -0.15492430f, 0.05191895f, 0.16956642f, 0.27545992f, 
    0.39084390f, -0.43383241f, -0.36836517f, -0.39068419f, -0.25723317f, 0.17830957f, 0.18424003f, 0.23679575f, 
    -0.18649416f, 0.02966710f, 0.05063551f, 0.26617062f, 0.10471882f, -0.33283630f, 0.22856034f, -0.09044057f, 
    -0.32348514f, -0.29525009f, -0.01057262f, 0.05878816f, 0.18176238f, -0.16679391f, 0.30859628f, 0.39359349f, 
    0.22683072f, -0.11090437f, -0.25844646f, -0.36371887f, -0.28003997f, -0.17094781f, -0.19491534f, -0.46911702f, 
    -0.41019094f, -0.39793047f, -0.57856387f, 0.25958660f, 0.42447948f, 0.12309699f, -0.21037816f, -0.01090271f, 
    -0.23377627f, -0.04781168f, 0.10478354f, -0.23895918f, -0.21027039f, -0.22226176f, -0.08918793f, -0.01355544f, 
    -0.15091023f, -0.09045831f, -0.54709011f, 0.25743672f, -0.01227777f, -0.05575645f, 0.15364227f, -0.14637776f, 
    -0.09033416f, -0.25025308f, -0.00203261f, 0.64275032f, 0.15173310f, 0.03085186f, -0.32651305f, 0.19585194f, 
    0.26385137f, -0.14184368f, 0.03485853f, -0.12879036f, -0.15792207f, -0.51080656f, 0.14463165f, 0.05258389f, 
    0.32999137f, 0.14425331f, 0.01552822f, 0.07067871f, -0.18625103f, -0.04739528f, 0.25345623f, 0.40697563f, 
    -0.46667996f, -0.48649269f, -0.36044163f, -0.44585574f, -0.61962402f, 0.10919865f, -0.02139000f, 0.18346420f, 
    0.48489064f, -0.29557383f, -0.01741593f, 0.16536385f, -0.03009950f, -0.05016638f, 0.12321386f, -0.33686528f, 
    0.21613543f, -0.25013334f, -0.22629903f, 0.38994658f, 0.07098977f, -0.06675956f, -0.21505390f, -0.45205638f, 
    -0.24194841f, -0.06434381f, -0.30030149f, -0.18457088f, 0.33257467f, -0.02000380f, 0.17965686f, 0.30219525f, 
    0.11724850f, 0.28518957f, 0.23211910f, -0.13323718f, 0.11030919f, 0.23303378f, 0.25569049f, -0.11731683f, 
    0.18827295f, -0.14129962f, 0.15828058f, -0.15988462f, -0.29883260f, -0.51281410f, -0.10330726f, 0.26702228f, 
    0.23404829f, 0.30335891f, 0.34104288f, 0.12018309f, -0.10294592f, 0.30352628f, -0.18527633f, -0.05255023f, 
    -0.01510500f, 0.08751221f, 0.38368422f, -0.23113674f, -0.07591607f, 0.02955104f, -0.27630532f, -0.23937608f, 
    0.09385192f, -0.36086908f, 0.12477055f, 0.28401059f, -0.11846395f, -0.08199043f, -0.45373598f, -0.70680857f, 
    0.16945356f, 0.00529949f, -0.70728540f, 0.59059858f, -0.47263470f, 0.01953569f, 0.62535590f, -0.29711688f, 
    0.05585790f, -0.27808467f, -0.11293337f, 0.39038697f, -0.49163377f, 0.21222006f, -0.18274285f, 0.05388847f, 
    -0.08982430f, 0.14869216f, -0.08370377f, 0.16192418f, 0.16490227f, -0.19375576f, -0.12158421f, -0.52164477f, 
    -0.51187748f, 0.09401064f, -0.14225066f, -0.27904627f, 0.61473823f, 0.09431784f, -0.05850048f, -0.04082732f, 
    -0.13149641f, -0.25788200f, 0.07258616f, -0.23282994f, 0.38906819f, -0.33348304f, -0.34507212f, -0.17848948f, 
    0.13876317f, 0.19835790f, 0.11829092f, 0.08410081f, -0.27460083f, -0.22608618f, 0.18890497f, 0.23524442f, 
    -0.11418916f, -0.74925995f, -0.14957727f, 0.22594334f, 0.59343070f, -0.71056497f, -0.29178658f, -0.09868094f, 
    0.61318856f, 0.43420082f, 0.29289961f, -0.26116639f, -0.36859822f, 0.10352829f, 0.43697137f, -0.25174287f, 
    0.07944407f, 0.23598249f, -0.13800064f, -0.35640389f, 0.00059669f, 0.13998395f, 0.01570035f, 0.01240386f, 
    0.35392597f, -0.15769848f, 0.49529943f, 0.84146321f, -0.53613150f, -0.36335766f, -0.30445299f, -0.05996468f, 
    0.20545535f, 0.03373316f, -0.45931533f, -0.17127715f, 0.09494133f, 0.39747259f, 0.00487789f, 0.18628484f, 
    0.11817671f, 0.00899413f, -0.23012045f, -0.11528354f, -0.04408168f, -0.05090905f, -0.07567109f, -0.28355679f, 
    0.18195489f, 0.28559503f, 0.25988334f, -0.03818606f, 0.17723587f, 0.24729638f, 0.34985155f, 0.25379071f, 
    -0.17403553f, 0.29964855f, 0.13370341f, -0.16908042f, -0.13228792f, 0.16394822f, 0.21572007f, -0.01815541f, 
    0.24756283f, -0.09894643f, -0.17113087f, -0.12017516f, -0.00942086f, 0.10838848f, -0.11424354f, 0.13853005f, 
    -0.10666094f, 0.05874797f, 0.04098612f, -0.43088290f, -0.13970381f, 0.43147326f, 0.11998149f, -0.04865628f, 
    0.32425407f, 0.80172861f, -0.60065323f, -0.52491915f, -0.25579822f, 0.23067446f, 0.23279205f, -0.02566287f, 
    -0.21508749f, -0.09291434f, -0.14489226f, -0.05957568f, 0.29175615f, -0.22033733f, 0.12148153f, -0.20707709f, 
    0.05495190f, 0.26306835f, -0.09874593f, -0.37722218f, -0.11179783f, -0.56223530f, 0.04177725f, 0.58311248f, 
    -0.24904001f, 0.57908177f, 0.16622688f, -0.34681770f, -0.37718374f, -0.13111724f, 0.31771246f, -0.22449018f, 
    -0.29483250f, -0.24124327f, -0.27559534f, -0.16028525f, -0.05232178f, 0.29364485f, 0.30157593f, 0.10237311f, 
    0.08996481f, -0.32117361f, -0.22876105f, -0.08591090f, -0.41324636f, -0.47816721f, -0.52071333f, -0.41822273f, 
    -0.18075395f, 0.30284804f, -0.16389659f, 0.05357550f, -0.07439370f, 0.22599550f, -0.10108230f, -0.07045500f, 
    0.16055526f, -0.10785180f, 0.21423846f, -0.41840902f, -0.09309131f, 0.24094580f, -0.47880527f, -0.04070435f, 
    0.15366203f, -0.06640738f, 0.03010929f, 0.34911302f, 0.05755040f, -0.05583239f, 0.25520235f, -0.25807840f, 
    0.31441531f, 0.04622681f, -0.30265296f, -0.36907861f, -0.02991940f, -0.04221521f, 0.13080804f, 0.33519560f, 
    0.10048417f, -0.44333923f, -0.33753139f, -0.19071002f, 0.29056731f, -0.25229341f, -0.01814728f, 0.19544965f, 
    0.18623891f, -0.23234770f, -0.13850026f, -0.00834385f, -0.29502499f, -0.48729041f, -0.61291456f, -0.71901768f, 
    -0.50556916f, -0.13379553f, 0.06271033f, 0.12957452f, -0.69069630f, -0.61073565f, 0.15702254f, -0.13578704f, 
    -0.16978416f, -0.11205849f, -0.31247598f, -0.37590483f, 0.21378653f, -0.13611157f, -0.22252327f, -0.10078048f, 
    -0.41469562f, -0.15508169f, -0.52847141f, -0.14265205f, -0.02332786f, 0.03419770f, -0.35528025f, -0.35596859f, 
    -0.48315850f, 0.18278781f, 0.39255136f, 0.61691421f, 0.06188643f, 0.11891849f, -0.43561620f, -0.41615617f, 
    -0.05598673f, -0.34398136f, -0.00622983f, -0.23855555f, -0.02782753f, 0.12770902f, -0.21430641f, 0.25153220f, 
    0.23245186f, 0.20147255f, -0.32930708f, -0.01498013f, -0.24487448f, -0.25108373f, -0.19145276f, -0.11857289f, 
    -0.06065239f, -0.77602583f, -0.37452847f, -0.24243455f, -0.55985653f, -0.51846784f, 0.22362585f, -0.00708251f, 
    -0.19324790f, -0.20025393f, 0.06207801f, -0.20935172f, -0.16190214f, -0.32124004f, -0.20127089f, 0.13562837f, 
    0.02432378f, -0.03688329f, 0.14712377f, 0.29022357f, 0.00494789f, -0.03102491f, 0.33246869f, 0.28890252f, 
    0.15749423f, -0.08439310f, -0.68857789f, -0.22249329f, -0.13556206f, -0.49766830f, -0.26724997f, -0.29491428f, 
    0.25599506f, 0.29193366f, 0.34753388f, 0.32904997f, -0.30974597f, -0.38408226f, -0.17586020f, 0.10695724f, 
    0.30307671f, -0.04301353f, 0.30268148f, 0.09822216f, 0.25692731f, 0.20861325f, -0.27164662f, 0.08784364f, 
    -0.25222880f, -0.16335003f, -0.43206602f, -0.83970761f, -0.26716504f, -0.14490992f, -0.56569880f, -0.58225703f, 
    0.36416107f, 0.35875654f, 0.39615321f, 0.29786620f, 0.26602623f, 0.04555619f, 0.04021632f, 0.26238203f, 
    0.14386180f, -0.01023466f, -0.13512544f, 0.16598153f, 0.00046693f, -0.05809848f, -0.04158001f, 0.06424713f, 
    -0.05673839f, 0.27118632f, -0.05998456f, -0.29211113f, -0.28804466f, -0.71878892f, -0.65674120f, -0.12327626f, 
    -0.57078445f, 0.49748662f, 0.28855827f, 0.11736473f, 0.22748758f, 0.45230862f, 0.36949041f, -0.03262908f, 
    0.28775430f, -0.08937577f, -0.07732268f, -0.03601975f, -0.17061596f, 0.06813970f, -0.09770175f, -0.08326139f, 
    -0.12991060f, -0.05709931f, 0.05717776f, -0.16547512f, 0.26071274f, -0.69623947f, -0.23153931f, -0.12389627f, 
    0.56748998f, -0.12500326f, 0.49421635f, -0.27908430f, -0.63549906f, 0.58375490f, -0.44064143f, -0.48539275f, 
    0.30401635f, 0.03156547f, -0.12572551f, -0.16750644f, 0.16650209f, 0.32486758f, -0.00358647f, -0.46111950f, 
    0.35094947f, 0.20969243f, -0.08533726f, -0.20459007f, 0.03396141f, 0.00286461f, -0.04659155f, -0.08107934f, 
    -0.10274001f, -0.07862364f, -0.25202659f, -0.15277387f, 0.14891957f, 0.20305993f, 0.15147141f, 0.22629863f, 
    -0.19565453f, -0.16955714f, -0.25127599f, 0.02243839f, 0.22389564f, 0.20458227f, -0.06974613f, -0.12504543f, 
    -0.20303462f, 0.19551082f, -0.20836309f, 0.04006208f, 0.24356593f, 0.02979437f, 0.14356282f, -0.65673709f, 
    0.06655387f, -0.12597597f, 0.47116002f, 0.47062501f, -0.20617662f, 0.25906742f, -0.02849079f, 0.32727748f, 
    0.32106695f, 0.07131641f, 0.24610297f, 0.05028558f, -0.04546134f, -0.33829981f, -0.01839553f, 0.10662013f, 
    -0.19024278f, -0.26105809f, 0.14495152f, -0.06283683f, -0.24012384f, 0.08761618f, -0.14240541f, 0.31675705f, 
    0.16406946f, -0.00186922f, -0.60866773f, -0.54206985f, -0.11894444f, 0.00693207f, 0.02611628f, -0.28386658f, 
    -0.42875466f, 0.37404424f, -0.17764993f, 0.03014537f, 0.03509564f, -0.29049417f, -0.28404325f, 0.22379674f, 
    -0.09665793f, -0.35755643f, -0.30164278f, -0.52583236f, -0.49334091f, -0.00800643f, -0.18619291f, -0.29184914f, 
    -0.48444602f, 0.15190037f, -0.72517729f, -0.07677728f, 0.38639966f, 0.79876918f, -0.17964122f, 0.13075978f, 
    -0.38803381f, -0.20647553f, 0.11746769f, -0.24121842f, -0.20263948f, 0.24270818f, -0.23702420f, -0.19648238f, 
    -0.12148835f, -0.00652705f, 0.01985744f, 0.18384132f, -0.04171721f, 0.20983636f, -0.09167776f, 0.02102029f, 
    -0.08602361f, 0.09072556f, -0.63558269f, -0.26661634f, -0.95214474f, -0.50381917f, 0.39951771f, 0.65006208f, 
    0.05205879f, -0.23652966f, -0.22927646f, 0.47240376f, -0.08610515f, -0.24420846f, -0.05263218f, 0.15450348f, 
    0.40700257f, -0.06150972f, -0.12440644f, -0.01427983f, 0.14298259f, -0.56368452f, 0.00375151f, -0.19315626f, 
    0.19977216f, 0.06758770f, -0.01951426f, 0.14388576f, 0.31968567f, -0.02091593f, -0.38722056f, -0.34101027f, 
    0.15580101f, 0.34601292f, -0.28878653f, -0.04964415f, 0.00865376f, -0.36749133f, 0.75836778f, -0.44493642f, 
    -0.05047943f, 0.00563582f, 0.14660381f, 0.26464495f, -0.05148882f, -0.21808159f, -0.16279526f, -0.21316941f, 
    0.27925295f, 0.17542820f, -0.32264033f, 0.08609126f, -0.48953390f, -0.47558293f, -0.47348377f, -0.44654027f, 
    -0.01075032f, -0.15151197f, 0.02484494f, 0.16591851f, 0.37521303f, 0.04672885f, 0.28943071f, -0.01250295f, 
    -0.18007852f, -0.12552729f, 0.08927783f, -0.00922183f, -0.11460199f, -0.19020385f, -0.25053555f, -0.33850169f, 
    -0.27693918f, -0.23734954f, -0.14905185f, -0.24353695f, -0.47408891f, 0.20520060f, 0.59202957f, 0.20525382f, 
    -0.40285662f, 0.05960631f, -0.27734876f, -0.23747766f, -0.05547480f, -0.49575344f, -0.46900997f, 0.09434755f, 
    0.16549131f, 0.24208924f, -0.04063262f, 0.10694873f, 0.00957220f, 0.15435468f, 0.04605503f, 0.04850415f, 
    0.25088713f, 0.00906993f, 0.25742003f, -0.09619615f, -0.39677086f, -0.28148329f, 0.33833694f, 0.12809557f, 
    0.21715876f, 0.07984713f, -0.22397509f, 0.03191359f, 0.27097794f, 0.21489789f, 0.13840495f, -0.02807377f, 
    0.04585027f, -0.11236887f, 0.07572174f, 0.08241707f, -0.16088457f, 0.00998785f, -0.18027882f, -0.11447892f, 
    -0.24005117f, 0.13194001f, 0.25527370f, 0.17903946f, 0.26782459f, -0.23341003f, -0.19556637f, 0.26082322f, 
    0.19504070f, 0.46993643f, -0.54714853f, -0.60046095f, -0.05539284f, 0.13016833f, -0.06071104f, -0.21334709f, 
    0.16896096f, 0.22296007f, 0.05927830f, -0.11046463f, 0.13196602f, -0.15430981f, 0.18754676f, -0.21698105f, 
    -0.17575552f, 0.04153804f, -0.11826784f, -0.07414255f, 0.12865858f, 0.02143404f, 0.10277675f, 0.35262081f, 
    -0.52337670f, -0.45610166f, -0.35131162f, -0.16019720f, 0.10026906f, -0.38508397f, -0.28762227f, -0.31425309f, 
    -0.45481068f, -0.41785359f, 0.10206949f, -0.06096203f, 0.50152647f, 0.25838265f, -0.18674307f, 0.02499867f, 
    -0.23932984f, -0.11040497f, -0.20259510f, -0.04770636f, -0.06020391f, 0.11053711f, 0.19897386f, 0.14200914f, 
    0.34039891f, 0.29514346f, -0.19705923f, -0.37351924f, -0.04964998f, 0.20400029f, -0.34490591f, 0.07031351f, 
    0.25290751f, 0.23607333f, 0.11470351f, 0.12471105f, 0.40977439f, -0.24406043f, -0.39826182f, -0.04876614f, 
    -0.01703599f, 0.04527678f, 0.17888246f, -0.37909102f, 0.08811904f, 0.05012755f, 0.28892285f, -0.09522264f, 
    0.17726846f, 0.14542061f, -0.23973660f, -0.41381240f, -0.04674463f, 0.34939957f, 0.57088125f, -0.25115544f, 
    0.58875167f, 0.18091290f, -0.29089221f, -0.31665605f, -0.35869610f, 0.07833312f, 0.52722377f, -0.48167431f, 
    0.00022831f, -0.10998272f, -0.07950972f, 0.08013480f, 0.32007045f, 0.06909997f, -0.00152615f, -0.08345369f, 
    -0.22174270f, -0.22842202f, 0.32402778f, 0.15874177f, 0.01010840f, 0.23455770f, 0.08056878f, 0.06188013f, 
    0.11626290f, 0.03744228f, -0.05729420f, 0.07238580f, 0.18031082f, 0.04652373f, -0.03500574f, 0.10262778f, 
    0.04270503f, -0.35437986f, 0.09164107f, -0.06672577f, 0.20981638f, -0.08921287f, -0.28116009f, -0.02338664f, 
    0.33329797f, -0.33541644f, -0.14046395f, -0.08516220f, 0.49395877f, 0.15915841f, -0.14510955f, -0.29058722f, 
    0.10442241f, -0.01720173f, 0.23585093f, 0.05479178f, -0.13085662f, -0.18142085f, -0.31665611f, 0.04056073f, 
    0.11413940f, -0.34675470f, 0.07401479f, -0.11824124f, -0.25821629f, -0.04415199f, 0.00086228f, 0.00449251f, 
    -0.28449607f, -0.22947755f, -0.37081006f, -0.29639977f, -0.32946789f, 0.49795142f, 0.41674751f, 0.14082494f, 
    0.22439970f, 0.07565892f, 0.16186638f, 0.39499012f, -0.07976067f, -0.10800404f, -0.11796833f, -0.01205861f, 
    0.13121843f, -0.02422717f, -0.07223219f, -0.10794703f, -0.18438360f, 0.13818698f, -0.14867860f, -0.07623156f, 
    -0.18130289f, 0.04751332f, 0.08484122f, 0.17101307f, -0.14868551f, -0.20612910f, 0.68670684f, -0.47237474f, 
    -0.58264822f, -0.69452894f, -0.55627882f, 0.28676245f, -0.10075443f, 0.11134335f, 0.11175942f, -0.20992139f, 
    -0.01790111f, 0.33558577f, 0.10494131f, 0.13292675f, 0.10945792f, 0.26654103f, -0.28162226f, -0.00312633f, 
    -0.00965853f, 0.08382123f, -0.01342959f, -0.31990957f, -0.16758083f, 0.14935908f, -0.32662094f, 0.08778562f, 
    -0.47368848f, -0.25592765f, 0.04763104f, -0.44790015f, -0.52111512f, -0.56389821f, -0.25540724f, -0.60898781f, 
    -0.72533059f, 0.31034088f, 0.34493124f, 0.15316734f, 0.58960438f, -0.18219647f, 0.07702117f, 0.17773306f, 
    0.13861559f, -0.12864842f, -0.35280004f, 0.02789896f, 0.32656509f, 0.16322480f, -0.21163641f, -0.06516726f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.12753452f, 0.11611500f, 0.07673005f, -0.12035704f, 0.18135463f, 0.06638109f, 0.25504994f, 0.20171902f, 
    0.26982686f, -0.13323173f, 0.06124749f, 0.13011745f, 0.19724058f, 0.11850289f, -0.00754491f, 0.07341272f, 
    0.26831520f, 0.01520939f, -0.07206521f, -0.07620756f, -0.01196908f, 0.20269234f, 0.30857477f, -0.00242524f, 
    0.00197601f, 0.09509527f, 0.17469572f, -0.03157461f, -0.07683172f, 0.21793497f, -0.04243093f, 0.26367110f, 
    0.33665648f, 0.21922646f, -0.08550073f, 0.29435050f, 0.06676438f, 0.09898762f, 0.06023981f, 0.11750439f, 
    -0.12549897f, 0.11390541f, -0.04080989f, 0.13796759f, 0.08522230f, 0.16961955f, 0.13846698f, 0.11267848f, 
    -0.05226283f, 0.17837456f, 0.22091496f, 0.40618598f, -0.18443316f, 0.04268456f, -0.07584070f, 0.08922278f, 
    0.05098004f, 0.03950190f, 0.16297884f, -0.02962165f, -0.05097408f, -0.06304590f, 0.13555324f, -0.08022648f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.03899036f, -0.00222088f, 0.02556020f, -0.00764409f, 0.00269397f, 0.00197724f, 0.01478457f, 0.00829388f, 
    -0.02582933f, -0.03890003f, -0.00099436f, -0.02831747f, 0.02470466f, 0.01213340f, 0.01490635f, -0.04006336f, 
    -0.03061848f, 0.01486171f, -0.00275982f, -0.03981878f, 0.01496352f, 0.01246013f, -0.03932526f, -0.01716981f, 
    -0.00751978f, -0.02530358f, 0.02834996f, -0.01229386f, -0.03175767f, 0.00182889f, 0.00068601f, -0.00146156f, 
    -0.02739458f, -0.01675771f, 0.01386216f, 0.00411146f, 0.02806527f, 0.01448277f, 0.02377255f, 0.02341440f, 
    -0.04005466f, -0.02517918f, -0.01907949f, -0.00442760f, 0.02910927f, 0.02163934f, 0.01936502f, -0.00462253f, 
    -0.03465817f, -0.00821702f, -0.01659554f, 0.00798685f, 0.00641444f, -0.01231942f, -0.02050430f, 0.02294867f, 
    -0.03063692f, 0.00934166f, -0.02472675f, -0.03740739f, 0.00648159f, -0.03752460f, 0.00687606f, -0.01694947f, 
    -0.02718383f, 0.01392203f, 0.02119751f, -0.04048750f, 0.02328789f, 0.02617025f, -0.00015973f, 0.00722440f, 
    -0.01893019f, -0.03064851f, -0.04074877f, -0.00582405f, 0.02218075f, -0.01752361f, -0.00377364f, 0.02470995f, 
    -0.03071239f, -0.01842512f, -0.00803569f, -0.01976148f, 0.02015173f, -0.04067285f, -0.01914383f, -0.02517653f, 
    -0.02378584f, 0.02498288f, -0.00360335f, -0.01294347f, -0.02743363f, 0.02640696f, 0.01906894f, -0.02663672f, 
    0.01291958f, -0.02852978f, 0.02916819f, -0.00520522f, -0.01763061f, 0.01952966f, -0.00904281f, -0.03797818f, 
    -0.01614628f, 0.01929427f, 0.01102504f, -0.01164361f, 0.00616795f, -0.03891972f, 0.00196725f, -0.02107850f, 
    0.02897488f, 0.01314311f, -0.01551257f, -0.00026884f, -0.00689463f, -0.02043344f, -0.01885353f, -0.02560562f, 
    0.02347156f, -0.02959044f, -0.00110144f, -0.03009677f, 0.02269358f, -0.03635850f, 0.01924861f, -0.03043827f, 
    -0.00647946f, -0.02997940f, -0.03257596f, -0.01114357f, -0.02805082f, -0.04206351f, 0.01691443f, 0.02862755f, 
    -0.00625243f, -0.00504501f, -0.00817898f, -0.01052885f, -0.00567553f, 0.01738992f, -0.00277424f, -0.00675954f, 
    0.00178087f, 0.02300701f, 0.02674388f, -0.00845399f, -0.02159034f, -0.00836911f, 0.01103531f, -0.01852658f, 
    0.01715804f, -0.04109978f, -0.00243586f, -0.00613754f, -0.01506210f, 0.00294472f, -0.04017021f, -0.00084941f, 
    0.00636500f, -0.04132441f, 0.01921250f, -0.03715321f, 0.02509219f, -0.03201146f, 0.00862320f, 0.02959484f, 
    -0.01111077f, 0.01082658f, -0.00870681f, -0.03016376f, -0.02830168f, -0.02528883f, 0.02237328f, -0.04141145f, 
    0.00580029f, -0.02742135f, -0.02680677f, -0.03770724f, -0.04006482f, 0.01498620f, 0.02399560f, -0.00711576f, 
    -0.00850195f, 0.01836809f, 0.01913077f, -0.01011328f, -0.00086883f, 0.00967085f, -0.04193274f, -0.01025863f, 
    -0.02723268f, 0.01343448f, 0.00059038f, -0.03126917f, -0.03222837f, -0.01033878f, 0.00503408f, 0.00683700f, 
    -0.00118932f, -0.02259970f, -0.00592022f, -0.00831451f, 0.02029366f, -0.03016803f, -0.01159799f, 0.00189260f, 
    -0.02693518f, 0.00943000f, 0.02914760f, -0.03489627f, -0.00895006f, -0.02572038f, -0.03590311f, 0.00566901f, 
    -0.03390043f, 0.01387514f, -0.02084155f, -0.03966596f, -0.02981553f, -0.01877676f, 0.02637935f, 0.00317568f, 
    -0.01282005f, 0.02210664f, 0.01811644f, 0.00779422f, 0.00313978f, -0.03045396f, 0.01517723f, -0.03324699f, 
    0.02330043f, -0.02205216f, -0.00037816f, -0.00895971f, -0.01224701f, 0.00733627f, -0.03371826f, -0.04189985f, 
    0.00846452f, -0.01043980f, 0.01157661f, 0.00275072f, -0.00655276f, 0.00354328f, 0.01135222f, -0.04105497f, 
    -0.04153448f, -0.03155321f, -0.03972439f, -0.01679914f, -0.03088557f, -0.03096567f, 0.02375806f, 0.01809126f, 
    -0.01229960f, -0.04112699f, -0.03644782f, 0.01630792f, -0.01366289f, -0.02890477f, 0.01536868f, 0.02251928f, 
    -0.01300991f, -0.02386328f, -0.02726961f, -0.01153216f, -0.00548470f, -0.00524498f, 0.01006680f, -0.03095871f, 
    0.02244708f, -0.02453742f, -0.02731118f, -0.01337562f, -0.01361453f, -0.01062155f, -0.01980594f, -0.01785877f, 
    0.00641229f, 0.01748393f, 0.00424536f, -0.02210643f, -0.03791372f, -0.02801693f, 0.02085226f, 0.01204411f, 
    0.02612917f, 0.01331239f, 0.00643353f, -0.01407514f, -0.02963523f, -0.02118753f, -0.00340646f, -0.02603716f, 
    0.00078629f, 0.00988752f, 0.01384984f, 0.00500953f, -0.03832610f, 0.01277034f, -0.02072214f, 0.00332131f, 
    -0.01053484f, 0.01719507f, -0.03044141f, -0.03141781f, -0.03203310f, -0.02569463f, 0.00249542f, 0.01289379f, 
    0.02537983f, -0.02769303f, 0.01938635f, -0.00273393f, -0.00547566f, -0.00542740f, 0.02584592f, -0.00020587f, 
    0.01738233f, -0.04022504f, 0.02634517f, 0.02400273f, -0.02888602f, 0.02149456f, -0.02263162f, 0.02457565f, 
    -0.00441908f, 0.01754744f, -0.00636978f, -0.02021616f, 0.02814588f, -0.03856914f, 0.01700284f, 0.00896383f, 
    -0.03604877f, 0.02653972f, -0.02049362f, 0.00542061f, -0.01382618f, -0.01098547f, -0.01670626f, -0.02564695f, 
    0.02146082f, -0.01661759f, -0.01485248f, 0.01571445f, -0.00615416f, 0.00066325f, -0.02210554f, -0.02090579f, 
    -0.03030473f, -0.02921479f, -0.03983702f, -0.03066946f, -0.01564993f, 0.02423245f, -0.00023086f, -0.02677391f, 
    -0.01685635f, -0.00850214f, 0.01414359f, -0.02706153f, -0.01901636f, -0.00997037f, 0.00769473f, 0.02996997f, 
    -0.00573684f, -0.00991629f, -0.03706178f, -0.03162348f, -0.03673492f, -0.01306528f, 0.01794738f, 0.02302994f, 
    0.00997732f, -0.00882292f, 0.01464618f, 0.02658477f, 0.01125030f, 0.02726340f, -0.00210442f, 0.01003682f, 
    0.01642569f, -0.01917487f, 0.01414728f, 0.02123783f, -0.00217499f, -0.00365559f, -0.00654077f, -0.00906054f, 
    -0.02893339f, -0.00325213f, 0.02465141f, 0.00849093f, 0.02241608f, -0.00460587f, -0.00492339f, -0.03908374f, 
    -0.01378855f, 0.02742271f, -0.02250490f, 0.00785874f, 0.02948882f, -0.03303278f, -0.04119306f, -0.00165109f, 
    0.02872176f, -0.02304882f, -0.03974879f, -0.01630303f, 0.02210721f, 0.01575240f, -0.03551270f, 0.02752347f, 
    0.00290395f, -0.02731229f, -0.02923569f, -0.01284235f, -0.04051818f, -0.02594051f, -0.02489824f, 0.02378120f, 
    -0.00346341f, -0.03056295f, 0.01674729f, -0.01080940f, 0.01811014f, -0.03351865f, -0.01138402f, -0.03829935f, 
    -0.03669325f, 0.00391953f, 0.01612671f, -0.02452878f, -0.03401330f, -0.03527657f, -0.01526388f, -0.02434438f, 
    -0.00515602f, -0.02192776f, -0.03673674f, -0.01114949f, 0.01568427f, -0.00007624f, -0.00026186f, 0.02268600f, 
    -0.02986791f, 0.00214427f, 0.00921522f, 0.01477694f, -0.04009192f, -0.03511133f, 0.01647752f, 0.00368784f, 
    -0.01267975f, -0.01866549f, 0.01070958f, 0.01325412f, 0.00324127f, 0.00261160f, -0.03147709f, -0.00951674f, 
    0.00114146f, 0.01751417f, -0.00444150f, -0.03780977f, -0.01066443f, -0.03098278f, 0.01578177f, 0.00242353f, 
    -0.01632178f, 0.02803154f, 0.02732732f, -0.02612337f, -0.03092678f, 0.00488734f, -0.04079244f, -0.02447707f, 
    0.00094606f, -0.03712413f, -0.02304527f, 0.01814950f, -0.02469759f, -0.00032525f, -0.03964504f, -0.01335677f, 
    0.02660696f, -0.00297997f, -0.01497081f, 0.00949411f, -0.03115402f, -0.02601705f, 0.00248460f, -0.03815089f, 
    -0.01004803f, -0.03865611f, 0.00367792f, 0.02364335f, -0.02094858f, 0.00178719f, -0.02211823f, 0.00695575f, 
    -0.02012825f, -0.01042625f, -0.01983948f, -0.03843957f, -0.01780999f, 0.01048348f, -0.01714367f, -0.03377851f, 
    -0.01976808f, 0.01426939f, -0.01255321f, 0.00183902f, 0.01726774f, 0.02122000f, 0.02251750f, -0.03607306f, 
    -0.00996928f, -0.04132598f, 0.01513113f, -0.00632943f, -0.02777367f, -0.00035713f, -0.04014724f, -0.00516814f, 
    0.00677965f, -0.02074030f, -0.00882050f, 0.00092476f, 0.01066954f, 0.02539830f, 0.01003911f, 0.00308588f, 
    0.00392444f, 0.00952554f, -0.02171918f, 0.00521188f, -0.01890578f, 0.02281503f, 0.02799516f, -0.02047829f, 
    0.02001970f, -0.02510967f, -0.01543191f, -0.02485172f, 0.01734239f, 0.00307152f, -0.00915377f, 0.00906694f, 
    -0.01020514f, 0.02795359f, 0.02283589f, -0.00491806f, 0.00995753f, -0.01997977f, 0.00086344f, 0.01878032f, 
    0.00392672f, -0.03110429f, -0.00654490f, -0.03734971f, 0.02345910f, -0.00380255f, 0.02065998f, 0.00253366f, 
    -0.03046916f, 0.01174702f, -0.00721013f, -0.00959631f, -0.03800982f, -0.01883854f, 0.01704748f, 0.01305499f, 
    0.02974504f, -0.02725419f, -0.03371240f, -0.01489988f, -0.03398600f, -0.04116753f, 0.00454025f, 0.00916769f, 
    -0.00516262f, -0.02365866f, -0.01920303f, -0.04134707f, -0.02280575f, -0.01771139f, -0.02583790f, -0.00297174f, 
    0.02561482f, -0.01787461f, 0.02342786f, -0.03494530f, -0.01916197f, -0.00355437f, 0.02262335f, -0.03477406f, 
    0.00644888f, 0.01793923f, 0.02625231f, -0.01775535f, -0.00346675f, -0.02973511f, -0.01774834f, 0.00827749f, 
    0.00993487f, 0.01794583f, -0.00199273f, 0.00625985f, 0.02213940f, -0.01320211f, -0.01133575f, 0.00781650f, 
    -0.02901636f, 0.00960560f, 0.01420408f, 0.01229843f, -0.01612134f, 0.00916685f, 0.02356099f, 0.00517495f, 
    -0.03792467f, 0.01562810f, -0.01283210f, -0.02889081f, 0.01225756f, -0.03986155f, -0.02303560f, -0.00484949f, 
    0.01154466f, 0.02305900f, -0.00283067f, 0.00307681f, -0.00563537f, 0.02282764f, 0.01141237f, -0.01837633f, 
    0.02496173f, -0.03497430f, 0.02151924f, -0.01741964f, 0.02459805f, 0.00198101f, -0.03443993f, 0.00729139f, 
    0.01406401f, 0.01928459f, -0.01596331f, 0.00143281f, -0.02712159f, 0.00244896f, -0.03864498f, 0.01654032f, 
    -0.01071334f, -0.02291060f, -0.03348236f, -0.01803922f, -0.02465910f, -0.01973553f, -0.04110555f, 0.02292106f, 
    0.02833446f, 0.01620595f, 0.02498313f, -0.01703434f, -0.02543624f, 0.00767159f, 0.02025078f, -0.02398893f, 
    -0.01259157f, 0.01061861f, -0.01584745f, -0.01445213f, 0.01696464f, 0.00406464f, -0.02288895f, -0.00990979f, 
    -0.02195370f, 0.01335617f, 0.01776464f, 0.00832076f, -0.00964843f, 0.02710534f, 0.00807431f, 0.00537851f, 
    -0.03813015f, 0.02847235f, 0.00547275f, -0.02966655f, 0.02980367f, -0.01674016f, -0.00415429f, -0.02866802f, 
    -0.01428769f, 0.01640753f, -0.02699367f, 0.02116534f, 0.01888219f, 0.00708165f, 0.01650843f, -0.02932145f, 
    -0.02588127f, 0.01575936f, -0.01509360f, 0.01054633f, -0.00614973f, -0.01653628f, -0.00899727f, -0.01161408f, 
    -0.03163466f, -0.04185230f, -0.02066251f, -0.02926458f, -0.01371787f, 0.00208544f, -0.03867013f, 0.02248698f, 
    0.02224900f, 0.02878631f, -0.03334416f, 0.02492219f, 0.00202872f, -0.00023911f, -0.00947774f, -0.03367704f, 
    -0.02312704f, 0.00147722f, -0.03395658f, -0.00555953f, -0.00489010f, 0.00600200f, -0.04172178f, -0.02354703f, 
    -0.03412943f, 0.00023190f, 0.00109964f, -0.01215787f, 0.02782704f, -0.01262566f, 0.00195449f, 0.00184483f, 
    0.00805613f, -0.00756231f, -0.02291753f, 0.00464374f, -0.02695988f, 0.00840353f, -0.01153778f, 0.02489844f, 
    0.00658248f, 0.00636681f, -0.03678281f, 0.01017488f, 0.01021984f, -0.00741524f, -0.01799858f, -0.00056278f, 
    -0.00676141f, -0.04072857f, -0.01510313f, -0.00338272f, -0.02421065f, 0.00536076f, -0.00791805f, -0.00820665f, 
    -0.00387769f, -0.02325646f, -0.02566564f, -0.03432214f, -0.00832892f, 0.00046670f, 0.02763117f, 0.00364871f, 
    -0.01755537f, -0.02962877f, -0.03588758f, 0.02347583f, -0.03735734f, -0.00330971f, 0.00621018f, -0.00805611f, 
    0.00298585f, -0.01071491f, -0.01696878f, -0.02225375f, -0.02612114f, -0.01408863f, 0.02231248f, -0.01710481f, 
    0.01528496f, 0.02990507f, -0.02913159f, 0.03267640f, 0.01223521f, 0.00249110f, 0.02870092f, -0.02220871f, 
    0.01741150f, 0.01638081f, -0.02271557f, -0.00521244f, -0.01720561f, -0.01395413f, -0.03507988f, -0.03387180f, 
    -0.00850635f, 0.01257475f, 0.02596005f, -0.00916440f, 0.02341012f, 0.01221852f, 0.01271279f, -0.02408716f, 
    -0.02499171f, 0.01669468f, -0.02106160f, -0.01870069f, 0.02515967f, 0.00268696f, -0.02275702f, -0.03705478f, 
    0.01997225f, -0.03985697f, -0.00369970f, -0.00628849f, -0.02728854f, 0.00019189f, -0.03712008f, -0.00475300f, 
    -0.02885134f, -0.00657912f, 0.03183357f, -0.00364879f, 0.01742537f, -0.01565969f, -0.02216350f, -0.01810424f, 
    0.00477309f, -0.00843115f, -0.02966751f, -0.00981230f, -0.00225432f, -0.02703818f, 0.00335510f, 0.01598408f, 
    -0.03876729f, 0.01493438f, -0.00314139f, -0.00859509f, 0.00058271f, -0.02443661f, 0.02130643f, -0.02564391f, 
    -0.01502042f, 0.00306687f, 0.02890228f, -0.03019912f, 0.02271204f, -0.00934962f, 0.02186588f, 0.01084391f, 
    0.01762298f, -0.03963575f, 0.00198035f, 0.00899890f, -0.01213205f, 0.00245792f, 0.03086060f, -0.03289606f, 
    -0.00125596f, 0.02673307f, 0.02853621f, 0.00172577f, 0.02023581f, -0.01223269f, -0.03846050f, -0.00386570f, 
    0.01394233f, -0.01983230f, -0.02750492f, -0.03391768f, -0.00383232f, 0.00508847f, -0.03456901f, -0.01465430f, 
    -0.03401337f, -0.02129134f, 0.01665881f, -0.03965178f, -0.03548215f, -0.02690537f, -0.02814320f, -0.02590120f, 
    0.02782100f, -0.00830853f, -0.03605639f, -0.02069907f, -0.02800645f, -0.00507015f, 0.01533394f, -0.03296579f, 
    -0.02285051f, 0.00292759f, 0.00009721f, -0.00773240f, 0.02925011f, 0.01709864f, 0.01050645f, 0.00376695f, 
    0.01478369f, -0.02644882f, -0.02307399f, 0.02222716f, 0.01068345f, 0.02574515f, -0.00369607f, 0.01992757f, 
    -0.03489561f, -0.02945554f, -0.00101976f, -0.02381051f, -0.00004583f, 0.01337316f, 0.00595121f, -0.01168534f, 
    -0.02866797f, -0.01351479f, 0.02486847f, 0.02834829f, 0.03171963f, -0.00686821f, -0.01298803f, 0.01466885f, 
    -0.02791596f, 0.00989976f, 0.03043879f, -0.01291599f, 0.01070786f, 0.02580026f, 0.03134739f, 0.01563459f, 
    0.02849985f, -0.03835467f, 0.02122593f, -0.03160416f, -0.02926126f, -0.03487142f, -0.00009774f, 0.01189396f, 
    -0.01158061f, 0.02909972f, 0.00016088f, -0.00591431f, 0.01944329f, -0.02648548f, -0.03546152f, 0.01443463f, 
    -0.01980813f, 0.00569607f, 0.02547257f, 0.02599854f, 0.01926844f, -0.01218534f, -0.02176989f, -0.03459528f, 
    -0.01711588f, -0.00494203f, -0.03131443f, -0.00004160f, 0.00571715f, -0.02681021f, 0.00312967f, -0.02719094f, 
    -0.03600963f, -0.02238044f, -0.02171297f, -0.01615160f, -0.01706230f, 0.01281278f, -0.02102420f, 0.00149695f, 
    0.02854060f, 0.02256955f, 0.01608289f, -0.01972453f, 0.01988589f, -0.04001424f, -0.01368862f, 0.02210699f, 
    0.02865782f, 0.03075812f, -0.04068866f, -0.02802341f, -0.01314194f, 0.00167574f, 0.00435905f, -0.00708227f, 
    0.01518212f, -0.03159650f, 0.01697474f, 0.02556534f, 0.01671718f, 0.02372507f, 0.01871401f, -0.01865388f, 
    -0.02079330f, -0.01153613f, -0.02207475f, -0.02642860f, -0.02573421f, -0.01817450f, -0.03865254f, 0.00160833f, 
    0.00573764f, 0.01551727f, -0.00253462f, -0.02207835f, -0.00888050f, 0.02663890f, 0.02513093f, 0.00469648f, 
    -0.03547737f, -0.02532821f, -0.01948254f, -0.00913650f, 0.00207882f, 0.02273892f, 0.02002853f, -0.03505698f, 
    -0.02924604f, 0.01939863f, -0.03057322f, -0.02816002f, 0.02795238f, 0.01629918f, 0.01886594f, -0.03567494f, 
    -0.02614209f, -0.02741985f, -0.02341757f, 0.00613709f, 0.00405965f, -0.00570421f, -0.01260450f, -0.03591663f, 
    -0.01263256f, -0.03763922f, -0.00933636f, -0.01922364f, 0.01894511f, 0.01053268f, 0.02322359f, -0.02258582f, 
    -0.01892648f, -0.00553579f, 0.01625521f, 0.01738618f, -0.03595006f, -0.01977388f, -0.02578138f, -0.00094945f, 
    0.00002878f, 0.02698270f, -0.01508774f, 0.02750132f, -0.00662879f, -0.03444986f, -0.01181054f, -0.00304576f, 
    0.02571148f, -0.00409832f, 0.00845717f, -0.00618277f, -0.01009616f, -0.02913557f, -0.02883377f, -0.02772170f, 
    0.00536988f, 0.00753850f, 0.00173499f, -0.03697979f, 0.00777326f, 0.00472230f, 0.01587444f, -0.01949495f, 
    -0.00794532f, -0.01673978f, -0.02338762f, -0.02510457f, 0.01287030f, 0.02183054f, -0.00227156f, 0.03194312f, 
    -0.02106686f, 0.02730983f, 0.02672813f, -0.00104482f, 0.03112542f, 0.03173251f, -0.00247682f, 0.01111530f, 
    0.01533596f, 0.02579694f, -0.01193250f, -0.00251537f, -0.00904801f, -0.02278754f, 0.01900327f, -0.00170201f, 
    -0.01215285f, -0.01089890f, 0.02629342f, -0.01325105f, -0.00461333f, 0.00204441f, 0.02633109f, -0.02761286f, 
    -0.01095876f, 0.00138669f, 0.01725177f, 0.00352713f, -0.01485114f, 0.00045189f, 0.02668341f, 0.02114375f, 
    0.02500012f, -0.00093494f, 0.03045735f, -0.00348478f, -0.01402224f, 0.01709081f, -0.01433996f, -0.00097666f, 
    0.02035260f, -0.02301107f, -0.02604596f, -0.03286907f, -0.02205260f, -0.03428255f, -0.00104442f, 0.00119418f, 
    -0.03863231f, -0.02491322f, 0.03336775f, 0.02809098f, -0.03152262f, 0.01732015f, -0.00184820f, -0.00568178f, 
    -0.01045184f, -0.01059489f, 0.02795491f, -0.02510022f, 0.00573662f, 0.00307246f, -0.03887976f, 0.00062175f, 
    0.00667286f, 0.03209589f, 0.00147698f, -0.03327286f, -0.02726161f, -0.01189878f, -0.02494524f, -0.02091809f, 
    0.01310201f, 0.02206130f, -0.02913091f, 0.01488754f, -0.03692999f, -0.02496092f, -0.03439922f, 0.00652873f, 
    -0.02784905f, 0.01847334f, -0.01868816f, -0.01806694f, -0.01198356f, -0.02997838f, -0.03177563f, 0.01665406f, 
    0.00480533f, -0.00234201f, -0.00799339f, -0.02355384f, 0.01421992f, 0.02528217f, -0.00440578f, -0.00221162f, 
    -0.01970839f, -0.01325496f, -0.01581317f, -0.02878520f, 0.00353930f, 0.00983859f, -0.01399951f, -0.03374610f, 
    0.00098118f, -0.00505608f, 0.00790931f, 0.02594748f, 0.02309079f, -0.01915431f, -0.03008962f, -0.02695221f, 
    -0.03998022f, -0.03948838f, 0.01709431f, -0.02217187f, -0.01721563f, 0.00980931f, 0.02334179f, -0.01674756f, 
    0.00282933f, 0.00544936f, -0.03395792f, -0.00587338f, 0.02582920f, -0.00769458f, 0.00028941f, -0.02116271f, 
    0.01639307f, -0.03888868f, 0.01037076f, 0.03229506f, 0.02494040f, -0.01161195f, 0.01275034f, -0.01221761f, 
    -0.02338271f, 0.02427346f, -0.00319892f, -0.02888395f, -0.03438353f, 0.00852186f, -0.01050202f, 0.00268687f, 
    -0.02154950f, -0.00560166f, -0.00537293f, -0.02955050f, 0.01468660f, 0.01743376f, -0.02565842f, 0.02306159f, 
    -0.00988920f, -0.01864387f, -0.03022845f, 0.00542611f, -0.01623293f, -0.03226186f, -0.02597018f, 0.00135435f, 
    0.03198693f, -0.01488101f, 0.00473830f, 0.02794170f, -0.02982008f, -0.02585522f, -0.03974268f, -0.02703582f, 
    0.02616642f, -0.00177856f, 0.03099055f, -0.00889015f, -0.03708601f, 0.02833098f, 0.02036471f, -0.02422629f, 
    0.00447213f, -0.03314670f, -0.03176602f, -0.01763840f, -0.01415990f, -0.01924601f, -0.00617755f, -0.03522653f, 
    -0.03654692f, 0.02369243f, -0.03149656f, 0.02117786f, -0.00125096f, -0.00065103f, -0.02170401f, -0.03977285f, 
    -0.01307914f, -0.03568332f, -0.02656243f, -0.01162075f, 0.02089405f, 0.02739822f, -0.00831595f, 0.01336202f, 
    0.01223143f, 0.01119658f, -0.01738922f, -0.01227378f, -0.03660195f, -0.02012615f, -0.00647783f, -0.02626739f, 
    0.00969334f, -0.01335053f, -0.02816353f, -0.02274762f, -0.03010360f, -0.01379338f, -0.02171486f, -0.01611272f, 
    0.00636450f, -0.01968976f, -0.01425535f, -0.02725516f, -0.02415550f, 0.00822876f, 0.03170801f, -0.00226757f, 
    -0.01802241f, -0.01849747f, -0.01411350f, 0.01621340f, -0.00576591f, 0.00983692f, -0.00758379f, 0.00319468f, 
    0.00275694f, 0.00867341f, -0.02145940f, -0.01984599f, 0.01212407f, -0.01766596f, 0.00067291f, 0.00655697f, 
    -0.00275766f, -0.03201635f, 0.01479619f, -0.02926111f, -0.04038687f, 0.00445564f, 0.02711063f, -0.02710699f, 
    -0.02384993f, -0.02941261f, 0.00963888f, 0.00289959f, -0.02085966f, -0.01778138f, 0.01180807f, 0.01126903f, 
    0.02031874f, -0.01894745f, -0.02185371f, 0.00088718f, 0.00004047f, -0.00624630f, 0.00832834f, -0.01388909f, 
    -0.03081642f, -0.02442440f, -0.03157395f, -0.01407814f, 0.01684415f, 0.02956876f, -0.03072203f, -0.01986672f, 
    -0.01627347f, -0.01535847f, -0.03764684f, 0.01207929f, -0.02302504f, 0.02612397f, 0.03005711f, -0.00184011f, 
    0.02232557f, -0.02412713f, 0.02157294f, -0.01008335f, -0.03895347f, 0.01655250f, -0.02382162f, -0.04008676f, 
    0.00955738f, 0.00906420f, 0.00009209f, -0.01947399f, -0.02467542f, 0.00180562f, -0.03435400f, -0.02885388f, 
    -0.02883830f, -0.01633424f, 0.00386375f, 0.00963856f, -0.01357290f, 0.00845925f, -0.00749974f, 0.01735776f, 
    0.01142741f, 0.00032086f, 0.00565660f, 0.02664411f, -0.00482855f, -0.03008597f, 0.00809205f, -0.01530286f, 
    -0.01557312f, 0.01524795f, -0.01645636f, -0.03792513f, 0.02994874f, 0.02770839f, 0.01833434f, -0.03636048f, 
    0.03051597f, -0.03351424f, 0.00962283f, -0.01404393f, -0.01453338f, -0.03091725f, -0.02839646f, 0.01318472f, 
    0.01482505f, -0.03730833f, -0.01000478f, -0.03969364f, 0.03009957f, -0.02019061f, -0.03480548f, 0.01514182f, 
    0.01780167f, 0.00768488f, -0.01177350f, -0.03134391f, 0.01311449f, 0.02944498f, -0.01183076f, -0.03593171f, 
    0.03097331f, -0.00754463f, -0.01168185f, -0.03666812f, -0.03387554f, 0.02366562f, 0.02933774f, -0.01659695f, 
    0.01895555f, -0.01510343f, -0.02602930f, -0.02061349f, 0.01827798f, 0.03159419f, 0.01237558f, 0.02804218f, 
    -0.01207218f, -0.00873707f, -0.03628745f, -0.02002216f, -0.02550918f, -0.00189490f, 0.00209672f, -0.00264824f, 
    0.00290089f, 0.01170575f, 0.02080681f, 0.02875723f, 0.01310164f, -0.02578782f, -0.02953224f, -0.03345092f, 
    -0.02630958f, 0.00404399f, 0.02600951f, -0.00170393f, -0.02063334f, -0.02078709f, 0.01658122f, -0.01253113f, 
    0.00902714f, -0.01021984f, -0.03421308f, 0.01748912f, -0.00124649f, -0.01074845f, 0.01057276f, -0.00504410f, 
    -0.01160569f, -0.00379222f, -0.02816187f, -0.02607630f, 0.00968586f, 0.00848100f, -0.03954999f, -0.01195007f, 
    0.02442268f, 0.01032775f, -0.00086694f, -0.00163250f, -0.01040770f, -0.03279249f, 0.01929719f, -0.01297841f, 
    0.01197305f, -0.00837380f, -0.03319027f, -0.02386398f, -0.00403668f, -0.02580100f, 0.03120315f, -0.02575237f, 
    -0.01211394f, 0.01653958f, 0.01116463f, -0.01828663f, -0.02728261f, 0.01755414f, 0.01401906f, -0.03659214f, 
    0.01293185f, -0.03740523f, 0.02888043f, 0.00194578f, 0.02443474f, -0.02530895f, -0.01257490f, 0.02143031f, 
    -0.01768303f, 0.00343999f, 0.01696472f, -0.01629631f, 0.00614442f, 0.02253457f, 0.00065532f, 0.00473823f, 
    0.24172814f, 0.16450033f, -0.07220020f, -0.19556183f, 0.14055018f, 0.08817615f, 0.05948766f, 0.03704303f, 
    -0.05462974f, 0.01487202f, -0.00081029f, 0.12311524f, -0.36228451f, -0.01026497f, -0.06504115f, 0.05712543f, 
    0.12389204f, 0.07261503f, -0.00226044f, -0.07208744f, -0.03558977f, -0.04816344f, 0.02113471f, -0.00544854f, 
    0.02411427f, -0.03797385f, 0.18662558f, -0.07599030f, -0.14396024f, 0.08759787f, 0.11180320f, 0.11701365f, 
    -0.18820776f, 0.19326414f, -0.08147839f, -0.02524527f, 0.22745533f, 0.09215013f, -0.01233456f, -0.04614641f, 
    0.18413725f, 0.08153410f, -0.02789487f, 0.10261357f, -0.07481232f, -0.04507931f, 0.05001841f, 0.12646455f, 
    -0.15228793f, 0.02002491f, 0.04153673f, -0.01318670f, -0.20855686f, 0.08634318f, -0.07342793f, -0.07197627f, 
    0.01336681f, 0.12118053f, -0.05093668f, 0.13082974f, -0.01004879f, -0.02876537f, 0.03451619f, -0.02773529f, 
    0.00089582f, 0.04242384f, 0.08150469f, 0.02987145f, 0.02978561f, 0.02407347f, 0.00246954f, 0.07042157f, 
    -0.03081932f, -0.15619011f, 0.07325725f, 0.09825440f, -0.11942962f, 0.01465616f, -0.03066754f, -0.03051734f, 
    0.22472908f, 0.12939605f, 0.04031180f, -0.05972818f, 0.07336785f, 0.30117363f, -0.02432104f, -0.21147513f, 
    -0.24470034f, 0.10888026f, -0.04626872f, -0.01914218f, -0.05124901f, -0.00904939f, 0.03915608f, 0.01734374f, 
    -0.03097651f, 0.03117768f, 0.00702698f, -0.00729758f, -0.06664096f, 0.02792248f, 0.00819340f, -0.00910406f, 
    -0.00705209f, -0.00274477f, 0.09805474f, -0.01511181f, 0.11404254f, 0.11964162f, 0.00532024f, 0.09753551f, 
    -0.03518022f, -0.05621103f, 0.08344583f, 0.01957674f, -0.02009852f, -0.04123566f, 0.00805183f, 0.04606928f, 
    -0.14986558f, 0.11175349f, -0.06631929f, -0.03309542f, 0.09890884f, 0.01418239f, 0.06548303f, 0.02855527f, 
    -0.09429482f, 0.05066033f, 0.01805507f, 0.26422814f, -0.10677630f, -0.04176373f, -0.06545722f, 0.02247936f, 
    0.09493023f, -0.00728181f, 0.06471480f, 0.00444099f, -0.10118493f, -0.10734203f, 0.09671609f, -0.09336072f, 
    -0.16867836f, 0.04504678f, -0.30979601f, -0.01134419f, 0.05062590f, 0.02155629f, 0.04237869f, 0.06457369f, 
    -0.01479805f, 0.02764570f, 0.00032411f, 0.03761652f, -0.05290517f, -0.04042444f, -0.05454561f, 0.05426078f, 
    -0.13732500f, -0.02069450f, 0.05550728f, 0.01627237f, 0.03431274f, -0.12430051f, -0.02751914f, 0.05976952f, 
    -0.02489965f, -0.20063552f, -0.16878724f, 0.09600185f, 0.05198393f, 0.19852196f, 0.11104421f, -0.12829211f, 
    0.05560574f, 0.07991736f, -0.02181237f, -0.12193752f, 0.28192601f, -0.03151814f, 0.12020194f, 0.00066014f, 
    0.00017515f, 0.06444451f, 0.06639107f, -0.01480146f, -0.08854269f, 0.02295539f, 0.07385802f, 0.02751233f, 
    0.18422134f, -0.26733106f, 0.05906197f, 0.03402305f, -0.00690405f, -0.05692734f, 0.05298007f, -0.19008957f, 
    -0.10336199f, -0.03801655f, -0.03085935f, 0.06015221f, 0.20616892f, 0.04428273f, -0.13520947f, 0.02497452f, 
    0.11553738f, 0.05893749f, 0.06378486f, 0.16125877f, -0.00209227f, -0.05297519f, 0.02102792f, -0.02012886f, 
    -0.06178561f, 0.09700501f, 0.10856353f, 0.15783536f, -0.25430557f, 0.12001244f, 0.04060333f, 0.06198744f, 
    0.11832301f, 0.05633900f, 0.07322936f, -0.13020104f, 0.13149747f, 0.16629583f, 0.05600577f, 0.14154963f, 
    0.10262205f, -0.04272153f, -0.01678935f, -0.03248268f, -0.06416419f, -0.03791630f, -0.02043479f, -0.00314410f, 
    0.23995116f, 0.11802737f, 0.03682331f, 0.06972104f, 0.14212596f, 0.14051311f, 0.11475298f, 0.08017575f, 
    0.03823534f, 0.05217295f, 0.09046933f, 0.01687068f, 0.22180052f, 0.18851839f, 0.00493989f, 0.01013640f, 
    -0.06697097f, 0.07592615f, 0.00251802f, -0.00032317f, -0.12216139f, -0.14000458f, -0.13789584f, -0.03313809f, 
    -0.14257790f, 0.18143593f, -0.04075813f, -0.07363251f, -0.00626094f, 0.03515181f, -0.09550644f, 0.08916621f, 
    -0.05506338f, 0.02065144f, 0.04187290f, 0.03868565f, -0.12268304f, -0.11242788f, -0.05636544f, -0.04253319f, 
    -0.06155524f, -0.01812398f, -0.04311246f, 0.00111250f, -0.02864877f, -0.04091223f, 0.01617416f, -0.00510418f, 
    0.03267413f, 0.02820182f, 0.00744261f, 0.05038498f, 0.06518338f, 0.04192219f, -0.23433921f, -0.08215006f, 
    0.02752362f, -0.10856517f, -0.02753439f, 0.01888685f, 0.25061840f, 0.13621199f, 0.07508004f, -0.07327060f, 
    0.02659103f, 0.05129347f, 0.05440757f, 0.10979283f, -0.02265178f, -0.09311344f, 0.11433756f, 0.12005662f, 
    -0.32831165f, 0.05324294f, -0.15812792f, -0.05060879f, -0.08861243f, 0.00868637f, 0.08515648f, 0.02429777f, 
    0.09474195f, 0.02648347f, 0.02416303f, -0.03461064f, 0.21768428f, 0.17527813f, 0.00593236f, 0.02892461f, 
    0.08210322f, 0.11619607f, 0.15869340f, 0.11720020f, -0.03587893f, -0.02539532f, -0.00312454f, 0.04463040f, 
    0.09002089f, 0.02346241f, -0.00987814f, 0.05428378f, 0.00622299f, -0.03525636f, 0.08548078f, 0.07939376f, 
    0.04870001f, -0.00087862f, -0.02413671f, 0.03999739f, -0.00000289f, -0.03383699f, -0.00690245f, -0.02735275f, 
    0.00254732f, -0.04422645f, 0.05339452f, 0.00418050f, 0.01739023f, 0.15587406f, -0.07884501f, 0.10606170f, 
    0.22563241f, 0.28185880f, -0.05912258f, -0.10528848f, 0.01835890f, 0.05039080f, 0.13252158f, 0.04464117f, 
    -0.05240936f, 0.05458081f, -0.00559262f, 0.02171340f, 0.29107907f, 0.12274766f, 0.14682090f, 0.12255178f, 
    -0.04021105f, -0.10257383f, 0.09892967f, 0.13312550f, -0.01767823f, 0.05241134f, 0.06272589f, -0.09509702f, 
    -0.21374989f, 0.32093573f, -0.06971444f, -0.25202480f, -0.25045478f, 0.02203787f, 0.11373334f, -0.04618881f, 
    -0.08205742f, -0.08720343f, -0.23474427f, 0.04149469f, 0.01973089f, -0.19475068f, 0.03495873f, -0.04964902f, 
    -0.06344155f, -0.10151938f, -0.07283176f, -0.02836258f, 0.03941854f, 0.09836867f, 0.03937522f, -0.16540624f, 
    -0.20108293f, -0.17449272f, -0.04970668f, 0.04026946f, -0.04108492f, 0.00387948f, -0.02874472f, 0.03762487f, 
    -0.04545843f, 0.05389316f, 0.03691606f, -0.02505917f, 0.26019242f, -0.18581942f, 0.33705539f, -0.17913067f, 
    0.02619636f, -0.11917507f, 0.07247794f, -0.20711002f, -0.12230138f, 0.02346551f, 0.02591573f, 0.07513284f, 
    0.28176361f, 0.01553158f, -0.13127448f, -0.04014863f, 0.13299955f, -0.11157061f, 0.05466561f, 0.03016195f, 
    -0.03286230f, 0.00619015f, -0.21654357f, -0.01296315f, 0.15777571f, 0.18736807f, 0.11354056f, -0.00050707f, 
    0.04544832f, 0.14107196f, 0.05050383f, 0.02123176f, -0.03347435f, 0.03989791f, -0.04839768f, 0.01069215f, 
    -0.19178726f, 0.23236455f, 0.01426425f, -0.08202031f, 0.05924560f, -0.01317146f, 0.14300652f, 0.11496044f, 
    0.06359931f, 0.04098365f, 0.02572627f, 0.24149583f, 0.18078488f, 0.12143566f, 0.06820083f, -0.08543854f, 
    -0.02696238f, 0.09839443f, 0.06984939f, 0.13710269f, -0.14453238f, -0.06862526f, -0.19193020f, 0.16131775f, 
    0.09870863f, 0.01440550f, -0.14944218f, -0.09359827f, 0.01356107f, 0.07924241f, -0.12106103f, 0.18012109f, 
    -0.01134291f, -0.03530910f, -0.06451325f, 0.01797391f, 0.04360572f, 0.11125930f, -0.05346016f, 0.00320372f, 
    0.05445767f, 0.12986077f, 0.10285261f, 0.07836005f, -0.05526102f, 0.01294624f, 0.03674991f, 0.10007425f, 
    -0.19206239f, 0.11493313f, 0.14069074f, 0.04875319f, 0.06603621f, 0.10780260f, 0.08464637f, 0.07933197f, 
    0.01574868f, 0.09706745f, 0.01121365f, -0.01000538f, -0.14029483f, 0.12013553f, 0.14719684f, 0.08494352f, 
    -0.01015574f, 0.03479257f, 0.03558801f, 0.08949522f, 0.04958155f, 0.04270985f, -0.05601773f, -0.05551111f, 
    0.08572788f, 0.28342286f, 0.10387445f, 0.17741224f, 0.02470186f, 0.07443244f, 0.05699539f, 0.01897470f, 
    0.04435325f, 0.03122308f, -0.06217609f, 0.06437393f, 0.16966090f, 0.15109532f, -0.07431182f, 0.06715642f, 
    0.00932808f, 0.10116389f, 0.07762551f, -0.00386759f, -0.01010354f, -0.00528178f, 0.18915342f, -0.03638060f, 
    -0.01583090f, 0.07515404f, 0.06785351f, 0.01429354f, -0.03396520f, -0.05406015f, -0.01053873f, 0.03586754f, 
    -0.01461235f, 0.01374256f, -0.02204279f, 0.09147137f, -0.22103944f, -0.03878349f, -0.00924664f, -0.06501218f, 
    -0.08888261f, -0.07682874f, 0.04172389f, 0.06442582f, -0.11415995f, -0.11958514f, 0.13033660f, 0.08309569f, 
    0.19879305f, 0.14418897f, 0.01081658f, 0.07981221f, -0.01953456f, -0.09358051f, 0.01215980f, 0.03098249f, 
    -0.10562244f, 0.00815644f, -0.03913045f, 0.12866804f, 0.21203791f, -0.16693254f, 0.22324598f, 0.08483901f, 
    -0.14396636f, -0.04269324f, 0.10076927f, 0.08344654f, -0.00605660f, 0.00892530f, 0.03540204f, 0.10768323f, 
    -0.03093187f, 0.32559660f, -0.01698754f, 0.16405284f, -0.00697284f, 0.20540547f, 0.09653831f, 0.04828769f, 
    0.01306418f, -0.02543835f, -0.08719383f, -0.05456141f, 0.18172641f, -0.17899969f, 0.21810570f, -0.06474154f, 
    0.08122426f, -0.09637973f, 0.08235850f, -0.14074075f, 0.02416240f, -0.00611836f, 0.15301295f, -0.11610568f, 
    0.16162595f, 0.12554610f, -0.13673095f, -0.00718255f, 0.05573110f, 0.14625110f, 0.11884367f, 0.09222414f, 
    0.13609871f, 0.08186962f, 0.06722529f, 0.13519247f, 0.05865133f, -0.07596470f, -0.03751586f, 0.09422603f, 
    0.08406314f, 0.03794539f, 0.18572213f, -0.07869802f, 0.04541242f, -0.01613382f, 0.05517458f, -0.09028088f, 
    -0.08956956f, 0.02100078f, -0.07892056f, -0.17863023f, -0.00237378f, -0.06640850f, -0.05591973f, 0.02633264f, 
    0.02666154f, 0.05396610f, -0.00891596f, -0.01572371f, 0.04401909f, -0.08502266f, -0.00247690f, 0.00848714f, 
    0.01835390f, -0.07519702f, -0.06955241f, 0.05369888f, -0.01215782f, -0.04596566f, 0.01194940f, -0.06203759f, 
    0.12589788f, 0.14053176f, 0.03751680f, -0.07503729f, 0.02765952f, 0.01430968f, 0.14580956f, 0.10908468f, 
    -0.00789211f, 0.04591189f, 0.01658462f, 0.10077485f, -0.06462435f, 0.08011031f, -0.03493350f, -0.12884665f, 
    -0.21449044f, -0.00566602f, 0.00323720f, -0.03939642f, 0.08139496f, -0.11538284f, 0.06039905f, -0.05962342f, 
    0.07010628f, -0.36455822f, 0.23660047f, -0.12622595f, -0.16200097f, -0.01735311f, 0.03356167f, -0.01537833f, 
    -0.05913475f, -0.01688092f, 0.04987762f, -0.03919316f, -0.08729665f, -0.10866790f, -0.05737207f, 0.00407883f, 
    -0.02326396f, -0.03014982f, 0.04609347f, 0.01743273f, 0.04658064f, -0.08302466f, -0.08829240f, -0.10260392f, 
    -0.24890926f, -0.17463069f, -0.03613444f, 0.00790478f, 0.04116381f, 0.03361452f, 0.03064310f, 0.08227815f, 
    0.00464031f, -0.01716550f, 0.18823004f, 0.25793618f, -0.28409615f, -0.20758861f, -0.08011062f, -0.07905426f, 
    0.00706458f, -0.03365913f, 0.05740024f, -0.05832792f, -0.00525785f, 0.04907428f, 0.06393640f, 0.02699139f, 
    0.23659137f, 0.02588885f, 0.03911161f, 0.15751033f, 0.13748062f, 0.05993616f, -0.11999317f, 0.02193755f, 
    0.07371254f, 0.01731966f, -0.05907915f, 0.10391424f, 0.27143389f, 0.19563229f, -0.00970791f, -0.14414366f, 
    -0.02062704f, -0.08141534f, 0.16861269f, 0.14731328f, -0.01749250f, 0.12639479f, 0.06283478f, 0.05755953f, 
    0.00757086f, -0.00155302f, -0.03042311f, -0.02388818f, 0.01077047f, 0.02678224f, 0.01188816f, -0.04072069f, 
    0.00085560f, -0.04055148f, 0.01574279f, -0.00751983f, -0.03124565f, -0.03859368f, -0.01537885f, -0.02266539f, 
    -0.01350689f, -0.02144748f, -0.02607617f, 0.02482243f, -0.03868655f, -0.01162410f, -0.03035076f, -0.00208635f, 
    -0.03875484f, 0.03057872f, 0.02006967f, 0.01427519f, 0.00951791f, 0.00018074f, -0.01738596f, -0.00098951f, 
    0.02782966f, -0.00059965f, -0.01842169f, 0.00721315f, -0.02370583f, 0.00278147f, 0.02271214f, 0.02813131f, 
    0.00714285f, 0.00162035f, 0.01424386f, -0.01321521f, 0.00002602f, -0.01958833f, 0.01106111f, -0.04065866f, 
    0.02322736f, -0.03024962f, -0.03333484f, 0.01143317f, 0.03050256f, -0.02955084f, -0.03393352f, -0.00120869f, 
    -0.04079120f, 0.02070730f, 0.01863799f, -0.01108899f, -0.00955850f, 0.01993212f, -0.01062746f, 0.00749299f, 
    0.02769644f, -0.01206973f, -0.01015220f, -0.01576014f, -0.00751018f, -0.01393349f, 0.01313959f, -0.01073542f, 
    0.02869305f, -0.01660192f, -0.04155082f, -0.00184498f, 0.02388392f, -0.02936853f, 0.01984310f, -0.03225624f, 
    0.01827458f, 0.01359493f, 0.00732340f, -0.02896353f, 0.01085854f, -0.02309333f, -0.00442688f, -0.01042534f, 
    -0.03489763f, -0.00549301f, -0.00228096f, 0.00438620f, -0.03692678f, 0.01479059f, -0.03024984f, 0.00628543f, 
    -0.01255674f, -0.00742099f, -0.00077898f, -0.01177042f, -0.02301178f, 0.01278412f, -0.04151978f, -0.01535465f, 
    -0.02274265f, 0.00184753f, -0.00796663f, 0.02608013f, 0.02073886f, -0.03226753f, 0.03006842f, 0.01980894f, 
    -0.02201784f, -0.02999034f, 0.02365937f, -0.01501500f, -0.00174672f, 0.00852810f, -0.02361496f, 0.01453745f, 
    -0.00692895f, -0.00543898f, 0.02439505f, 0.00640188f, 0.00376038f, 0.00593722f, -0.03749716f, 0.01426410f, 
    0.02904705f, -0.03428908f, 0.00226366f, 0.02915029f, 0.02589150f, -0.02744479f, 0.01261710f, -0.01866174f, 
    0.00551619f, -0.00286591f, -0.00979051f, -0.02305492f, -0.00409443f, 0.01575438f, 0.01611009f, -0.03058059f, 
    -0.01589208f, -0.01604939f, -0.01499347f, 0.00055664f, -0.00956584f, -0.01930779f, 0.01585197f, -0.03800489f, 
    0.00199140f, -0.04076593f, 0.00432990f, -0.02985395f, -0.01860526f, 0.01733233f, -0.03668157f, 0.01196386f, 
    -0.01120330f, 0.01321526f, -0.01912397f, -0.01195799f, -0.03107551f, 0.00439286f, -0.00313439f, -0.02118934f, 
    -0.01331371f, -0.01029913f, -0.04048843f, 0.00306415f, 0.00580200f, 0.01329335f, 0.02865959f, -0.00036930f, 
    -0.01929787f, 0.00503645f, 0.02147916f, 0.02395543f, -0.00879473f, 0.00615193f, -0.01527673f, -0.02143333f, 
    0.00674026f, -0.00164527f, 0.02607713f, 0.02625753f, 0.00591990f, 0.01804741f, -0.01350550f, 0.01531781f, 
    -0.00353278f, -0.00734052f, -0.03965025f, -0.04097717f, 0.00940123f, 0.02938232f, -0.01722823f, -0.00231996f, 
    -0.03712224f, -0.03823336f, 0.02593408f, -0.02481108f, 0.00419951f, 0.02737285f, -0.02789201f, 0.03033353f, 
    0.02121450f, -0.00741725f, 0.00058571f, 0.02894511f, -0.01946852f, -0.01328369f, -0.02295642f, -0.03367935f, 
    -0.02350544f, 0.02290232f, 0.01020506f, -0.00512387f, 0.01368801f, 0.00442710f, 0.00527976f, -0.00432921f, 
    0.02729689f, -0.01374137f, -0.00920546f, -0.02191148f, -0.01153413f, 0.00664921f, 0.02002154f, 0.01902477f, 
    -0.03466851f, -0.00422867f, -0.02568495f, 0.02933926f, -0.01757285f, -0.00590186f, -0.01913031f, -0.03018279f, 
    -0.02007215f, 0.02462529f, 0.00668116f, -0.03239205f, 0.01254915f, -0.03187943f, -0.03391808f, 0.01401863f, 
    -0.01320087f, -0.02560196f, -0.03148535f, 0.00135122f, -0.01986951f, -0.02197829f, -0.00303791f, -0.00967021f, 
    -0.03042787f, 0.02298971f, 0.02446020f, -0.03967628f, -0.01056486f, -0.02128487f, 0.02145239f, 0.03042170f, 
    -0.01192183f, -0.03795629f, 0.00651454f, -0.03067119f, -0.00622417f, -0.01733837f, -0.02502719f, -0.02459973f, 
    0.00762665f, -0.03199685f, -0.00522842f, -0.02590672f, -0.01869974f, 0.01455079f, 0.01815267f, 0.03012481f, 
    0.02812699f, -0.03112711f, 0.00482620f, -0.00884049f, 0.01178179f, 0.01799999f, -0.00597851f, -0.00063239f, 
    0.00735135f, -0.02069385f, 0.01693535f, -0.00074208f, -0.03739632f, -0.03676279f, 0.02466005f, -0.02832329f, 
    0.00538630f, -0.02365434f, 0.01902590f, -0.03591169f, -0.01087510f, 0.00889242f, -0.01137762f, 0.00336551f, 
    0.02380881f, -0.03070884f, -0.02028313f, 0.01176699f, 0.01520811f, -0.03942709f, 0.01933858f, 0.00451664f, 
    0.01065503f, 0.02528147f, 0.01455269f, 0.01868556f, 0.00942966f, -0.04087375f, 0.01787612f, -0.03441406f, 
    0.00075797f, -0.03501776f, 0.02558238f, -0.00801471f, -0.03080805f, -0.03073796f, 0.00709280f, -0.02737666f, 
    -0.03399268f, -0.04155480f, -0.02774670f, -0.03348643f, -0.03356266f, -0.02905132f, 0.01868142f, 0.00464809f, 
    0.02446634f, -0.02168002f, -0.03437234f, -0.01090390f, 0.02506918f, 0.02949055f, -0.03493619f, -0.02897095f, 
    0.01943820f, 0.01622853f, 0.01886124f, -0.04057226f, -0.00917472f, 0.00733191f, 0.02921018f, -0.03879139f, 
    -0.00556237f, 0.02582846f, -0.03420684f, -0.03805783f, 0.02061303f, -0.00595213f, -0.02036720f, 0.01643036f, 
    -0.01862732f, -0.02507483f, 0.01607284f, 0.03034981f, 0.01715493f, 0.01445166f, 0.01260445f, 0.00386391f, 
    0.01152633f, -0.02641178f, 0.01149075f, -0.04039061f, -0.01600238f, -0.03005798f, -0.03040725f, -0.00508974f, 
    -0.03179094f, -0.01276875f, -0.03259871f, 0.02566197f, -0.04126783f, 0.00581705f, 0.01865809f, 0.02339205f, 
    -0.03375342f, -0.01494269f, -0.02043515f, -0.02314980f, -0.02034576f, -0.03819495f, -0.01438474f, -0.03812816f, 
    -0.03304742f, -0.03812876f, -0.00941340f, -0.00545565f, -0.00408481f, -0.02230937f, 0.02306562f, -0.00675338f, 
    -0.00638053f, -0.03404415f, -0.03635592f, -0.01483646f, 0.01876548f, 0.02269048f, 0.01549810f, -0.03245375f, 
    -0.03903474f, -0.02219054f, -0.00849244f, 0.01715760f, -0.00663539f, -0.01978051f, -0.02957250f, -0.02565492f, 
    -0.00608551f, -0.02621847f, -0.03518061f, -0.03494599f, 0.02591365f, -0.03544389f, -0.02584804f, 0.01207713f, 
    -0.01585557f, -0.03102872f, 0.03029454f, -0.00330507f, -0.00133720f, -0.01903071f, -0.00437878f, 0.00202435f, 
    -0.00134300f, 0.02059836f, -0.00657143f, 0.00555079f, 0.01706695f, -0.02376271f, 0.02097394f, -0.01000554f, 
    -0.03591679f, 0.00054034f, 0.02706258f, -0.01096526f, -0.01609379f, -0.01732668f, -0.00882662f, -0.01961375f, 
    0.01780824f, -0.01195903f, -0.02192923f, 0.00572045f, -0.03465367f, 0.00271239f, 0.02901066f, 0.02940706f, 
    -0.01454192f, 0.02902555f, 0.00919533f, -0.01237480f, -0.02946605f, -0.03407428f, -0.03195935f, -0.02218504f, 
    -0.01406645f, -0.01130597f, -0.01160677f, -0.03132201f, -0.01610632f, 0.00951692f, 0.00210182f, 0.01154942f, 
    -0.02320633f, 0.01018124f, 0.00305810f, -0.00351374f, -0.03144414f, 0.01861020f, -0.02847650f, -0.02813000f, 
    -0.03380645f, 0.02706420f, 0.00001741f, -0.01255760f, -0.02831814f, -0.00491242f, -0.02135988f, -0.04128755f, 
    0.01935363f, -0.00908273f, -0.03052627f, 0.01797276f, -0.02997721f, -0.03110511f, -0.03657836f, -0.01999335f, 
    -0.00810473f, 0.02319897f, -0.02957353f, -0.02349496f, -0.01050477f, -0.00119632f, -0.01837004f, 0.02575070f, 
    -0.02064929f, 0.01392893f, 0.02982838f, 0.01018145f, -0.03926073f, 0.02631067f, 0.00539030f, 0.01889161f, 
    0.02069658f, -0.01135089f, -0.01062865f, -0.00700503f, 0.00431319f, -0.02956270f, 0.01659669f, 0.00063128f, 
    -0.02250296f, 0.00167501f, 0.00804247f, 0.01696056f, 0.00430338f, -0.00907009f, -0.01091465f, 0.02885578f, 
    0.02427008f, -0.02162424f, 0.02000894f, -0.01514151f, -0.02416255f, -0.01096214f, 0.00249964f, -0.00286995f, 
    -0.01302021f, -0.03566488f, -0.02732117f, 0.02319933f, 0.01683878f, 0.01819265f, 0.00753095f, 0.00795745f, 
    -0.00307088f, 0.00304412f, 0.01561656f, -0.02350802f, 0.01155083f, 0.00471211f, -0.02625969f, -0.02371590f, 
    0.01603414f, 0.00066899f, -0.03929776f, -0.03126086f, -0.01526296f, -0.03936739f, 0.01976324f, -0.02794953f, 
    -0.00687945f, -0.00202046f, -0.02103131f, 0.02827248f, -0.03136309f, -0.02086241f, -0.03504531f, 0.02544167f, 
    0.02935959f, -0.02801277f, 0.00947864f, 0.00362716f, -0.01583059f, 0.00007911f, -0.01476549f, 0.02081328f, 
    0.00434201f, -0.00184807f, 0.01024867f, -0.02071001f, -0.03447599f, -0.02770033f, 0.00888689f, -0.01283268f, 
    0.03477816f, -0.01964710f, -0.01950984f, -0.00536111f, -0.02954885f, -0.00421112f, 0.00990932f, 0.00466857f, 
    0.02388126f, -0.01148439f, -0.04004675f, -0.00128826f, -0.02515073f, -0.00196084f, -0.01121875f, 0.01241265f, 
    -0.03622362f, -0.01272591f, -0.03024356f, -0.03510078f, -0.00434732f, 0.03394373f, -0.00691338f, -0.03960838f, 
    0.02697096f, -0.01464558f, -0.02641052f, -0.02827678f, 0.00823479f, 0.01456745f, 0.00623886f, -0.03701234f, 
    0.01419097f, -0.03858605f, -0.00598729f, -0.02503623f, 0.02257347f, -0.02878393f, -0.01586145f, 0.02231117f, 
    -0.00919418f, 0.01683973f, -0.03005053f, 0.00123038f, -0.02700228f, -0.02396179f, 0.02456478f, -0.00258744f, 
    0.03408456f, 0.01557262f, 0.00417343f, -0.02151385f, -0.00673464f, 0.00629243f, -0.02879327f, 0.00819113f, 
    0.00173985f, -0.02769330f, 0.02003788f, 0.00993201f, -0.03048803f, 0.01826884f, 0.01230363f, -0.00437431f, 
    -0.04085032f, 0.02290401f, -0.01424703f, 0.00736267f, -0.03706228f, -0.01106366f, -0.01211599f, 0.02781283f, 
    -0.00599480f, -0.03023730f, -0.02878134f, 0.02699311f, 0.02408100f, 0.02972128f, 0.00264857f, -0.03238270f, 
    -0.03623341f, 0.01225156f, 0.00224147f, -0.00504099f, 0.01090632f, -0.02068232f, 0.00625880f, -0.03111318f, 
    -0.01799206f, 0.00602521f, 0.00353541f, -0.03951856f, -0.00139912f, 0.01913470f, 0.03598834f, 0.00479826f, 
    -0.02201964f, 0.02157079f, -0.01160390f, 0.02779332f, 0.02724340f, 0.00945616f, -0.01146138f, 0.02616635f, 
    -0.01105725f, -0.02876596f, -0.01056772f, -0.00601575f, -0.00263580f, -0.02023477f, -0.03451598f, 0.02148068f, 
    0.00401144f, 0.00389895f, -0.03324118f, -0.03802444f, 0.00602904f, -0.01699448f, -0.02080493f, 0.02450741f, 
    -0.02588842f, 0.00491169f, 0.02533422f, -0.02590464f, -0.03673529f, -0.00115867f, -0.00203712f, -0.02961295f, 
    -0.00512608f, 0.00513741f, -0.00097638f, -0.03244008f, 0.00782069f, -0.02586882f, -0.01571248f, 0.02301818f, 
    -0.02120386f, -0.03003554f, -0.02228594f, 0.01789391f, -0.00243275f, 0.00343640f, -0.03574238f, 0.01305020f, 
    0.02877234f, 0.01505006f, -0.00400456f, -0.02349637f, -0.01971667f, -0.01538154f, -0.03659026f, -0.00975975f, 
    -0.00580286f, -0.00414598f, 0.02263387f, -0.01026231f, -0.00369631f, -0.03610508f, -0.00276725f, 0.01741798f, 
    0.01473217f, -0.02918690f, -0.02241692f, 0.00578731f, 0.02021582f, -0.03230925f, -0.02688782f, -0.00229460f, 
    -0.01739967f, 0.00664754f, -0.03059554f, 0.02893962f, -0.02452259f, -0.01873302f, -0.00523712f, -0.00096593f, 
    -0.03324442f, -0.00506566f, -0.00045828f, 0.01261514f, -0.03335773f, -0.00113873f, 0.01579402f, 0.00261592f, 
    0.08197893f, 0.35419124f, 0.34305316f, 0.05746672f, 0.03268387f, -0.01046810f, 0.12427296f, 0.03782513f, 
    -0.06736990f, 0.08184821f, -0.02232914f, -0.07862280f, -0.09538730f, 0.12638241f, 0.40584186f, 0.07407749f, 
    0.01046918f, -0.03928963f, -0.21255752f, 0.00789364f, 0.01438892f, 0.10519571f, 0.11338684f, 0.00211724f, 
    0.16577435f, -0.17144851f, 0.06914571f, -0.05432277f, 0.24692316f, -0.31637248f, 0.05397921f, -0.09393655f, 
    -0.16392849f, 0.02031426f, -0.05428106f, 0.02838269f, 0.12354464f, 0.02923195f, 0.18624698f, 0.03481375f, 
    0.03738640f, 0.01811857f, 0.01380128f, -0.04308382f, -0.06698562f, -0.07878415f, 0.07740843f, 0.11495156f, 
    0.14943235f, -0.15857686f, -0.10887403f, 0.11231105f, -0.00668113f, 0.14799160f, 0.15191269f, -0.12084527f, 
    0.05760899f, 0.01870337f, 0.05325304f, -0.07759865f, 0.01750963f, 0.16990963f, 0.15863088f, 0.06361587f, 
    0.06666868f, -0.00092542f, -0.16157113f, -0.01424335f, 0.05090718f, 0.08187337f, 0.05936308f, 0.08860578f, 
    0.00737303f, -0.09015527f, -0.20813003f, -0.12338158f, -0.02542496f, 0.03314351f, 0.02915244f, 0.09300531f, 
    -0.01854852f, -0.02709776f, -0.06470022f, -0.00758672f, 0.44746742f, 0.06072297f, 0.17080793f, -0.22916593f, 
    -0.03553084f, -0.11439823f, 0.02331959f, 0.10341065f, 0.13046439f, 0.07364795f, 0.04389604f, 0.07413809f, 
    -0.05698049f, -0.05359003f, -0.19575153f, 0.25313726f, 0.02416597f, -0.03579072f, -0.03889068f, 0.04503202f, 
    -0.00770755f, -0.02673265f, -0.02321123f, -0.03604193f, 0.03472675f, 0.33922535f, 0.19781183f, -0.03108586f, 
    -0.00504767f, -0.14981675f, -0.06752285f, 0.13533431f, -0.04361811f, 0.12391662f, -0.00210688f, 0.03602096f, 
    0.01698538f, -0.18369417f, -0.16506912f, 0.11503402f, 0.10560270f, -0.09393825f, 0.02347364f, 0.02440540f, 
    0.08689407f, 0.06476612f, -0.13457941f, -0.02078686f, 0.00254718f, -0.17264862f, 0.00293868f, -0.00754581f, 
    -0.00074217f, -0.05166867f, -0.21259633f, -0.01753389f, -0.01389531f, 0.06081307f, 0.13540030f, 0.08615535f, 
    -0.01417923f, 0.06705089f, 0.37887117f, 0.02758272f, 0.02722278f, -0.14201429f, -0.24185881f, -0.04713516f, 
    0.03407537f, -0.04292845f, 0.08610736f, 0.05279669f, 0.00273145f, 0.04997762f, -0.02153596f, -0.02190960f, 
    0.05855443f, 0.00352053f, -0.07902492f, -0.01134293f, 0.04383429f, -0.02327027f, 0.06523614f, -0.08244084f, 
    0.11922272f, 0.03868346f, 0.05378973f, 0.21031202f, -0.03046754f, -0.05236455f, -0.09330835f, 0.00450054f, 
    -0.05757117f, 0.11570859f, -0.00635857f, 0.09430134f, -0.10069758f, 0.03056896f, -0.05699591f, 0.07563839f, 
    0.06437623f, 0.17028499f, -0.01498702f, -0.00637068f, -0.08854264f, -0.01719301f, 0.03249276f, 0.08584003f, 
    -0.13556145f, 0.35086066f, -0.00157676f, -0.09292370f, 0.00765610f, -0.18970844f, 0.15829152f, -0.05494021f, 
    0.07926533f, 0.09983153f, 0.03212708f, -0.01741604f, -0.07202245f, 0.11733683f, 0.13038377f, 0.05675925f, 
    0.13688168f, 0.13890500f, -0.09670149f, -0.17900115f, -0.08570279f, -0.11318441f, 0.22197895f, -0.00954197f, 
    -0.09741043f, 0.22881128f, -0.29057118f, -0.11887822f, -0.13199511f, 0.05728802f, -0.00506117f, 0.17238733f, 
    -0.16154398f, -0.05269972f, 0.09913396f, 0.13943568f, 0.01871163f, -0.13998395f, -0.01191330f, 0.38262922f, 
    0.10170212f, 0.25256005f, 0.03220558f, -0.16856138f, 0.02322001f, 0.08493341f, 0.04491278f, 0.07064109f, 
    0.26100484f, 0.33394200f, -0.20484687f, 0.02597400f, 0.04489128f, 0.09886491f, 0.11552632f, -0.03049878f, 
    -0.01624679f, -0.07239658f, -0.08649530f, 0.09869767f, -0.04441179f, -0.00905589f, -0.13813326f, -0.05091742f, 
    0.08748873f, 0.12148737f, -0.01565863f, -0.01440331f, 0.03490144f, -0.02066777f, -0.03894825f, 0.02358057f, 
    0.11335880f, -0.04249400f, 0.30463219f, 0.04325677f, 0.14035308f, -0.09035009f, -0.18614382f, -0.01278188f, 
    0.00301596f, 0.00865299f, -0.00826688f, -0.00987657f, 0.12348802f, 0.11195930f, -0.02958314f, 0.00520215f, 
    0.04306958f, -0.03943756f, 0.09519703f, 0.04676474f, 0.06953731f, 0.06224510f, 0.11330884f, 0.10078332f, 
    -0.06856918f, -0.13694710f, -0.07056402f, 0.24486873f, 0.09786877f, 0.12645407f, 0.15662411f, -0.09840729f, 
    0.15141065f, 0.06016357f, -0.01914451f, 0.00515648f, 0.17349878f, 0.04695129f, 0.07345255f, 0.13087678f, 
    0.17156690f, 0.15770827f, -0.05755646f, -0.17863664f, -0.01268787f, -0.06668450f, 0.04638312f, 0.02196963f, 
    0.10700002f, -0.13939655f, -0.00260144f, -0.11176223f, 0.01644761f, 0.00685010f, -0.04072598f, 0.12885773f, 
    0.14130151f, -0.01201104f, 0.08377696f, 0.08913966f, 0.38341740f, 0.10571911f, 0.32516044f, 0.03676002f, 
    -0.03445435f, -0.00552166f, -0.08165093f, 0.01338058f, 0.04820995f, -0.05448463f, 0.04293588f, 0.11197279f, 
    0.04730849f, -0.12935138f, -0.04327170f, 0.07231028f, 0.12201346f, 0.17633335f, 0.15446010f, -0.02274166f, 
    -0.04005413f, -0.06152821f, -0.02776883f, -0.01411702f, 0.19530229f, -0.25735906f, -0.02090945f, -0.27423838f, 
    -0.04947623f, 0.04090744f, -0.01327747f, 0.07823716f, -0.08908668f, -0.04497466f, 0.00941813f, -0.02893670f, 
    0.14202185f, -0.50635302f, 0.32587224f, -0.00291055f, 0.15000920f, 0.12743747f, 0.04897894f, 0.00672897f, 
    -0.02071614f, 0.03001733f, 0.04293719f, 0.00453761f, -0.02320186f, -0.04839350f, -0.05785864f, -0.02796805f, 
    0.04883681f, 0.00079307f, 0.05073943f, -0.03576134f, -0.01525583f, 0.02750583f, 0.00684715f, 0.05093975f, 
    0.33964899f, -0.14143330f, 0.06231248f, -0.15844476f, -0.05129269f, 0.01433749f, 0.02653524f, 0.10936055f, 
    -0.02138409f, 0.03054285f, -0.00012882f, 0.12487247f, -0.01522486f, 0.06842462f, 0.00301597f, 0.12221919f, 
    0.28418654f, -0.01857715f, -0.26521948f, -0.01198514f, -0.03808774f, -0.01149895f, 0.00273708f, 0.04306243f, 
    0.19768146f, 0.02281664f, 0.01152494f, -0.00541266f, -0.04522998f, 0.00540088f, -0.06662079f, 0.04153192f, 
    -0.02827685f, 0.03512523f, 0.00968017f, 0.17948589f, -0.12930544f, 0.45903423f, -0.25519899f, 0.14271280f, 
    -0.02951230f, 0.01280520f, 0.07991488f, -0.00266810f, 0.12216533f, 0.03556491f, 0.03801723f, 0.08389589f, 
    -0.09595004f, 0.33165470f, -0.06349520f, -0.04191976f, -0.00340605f, -0.20649873f, 0.15139431f, 0.04917665f, 
    -0.12455893f, 0.03427802f, 0.01729603f, -0.00046934f, 0.20892523f, -0.29057071f, -0.13212636f, -0.15780698f, 
    -0.00782229f, 0.13380235f, 0.15606178f, -0.12001120f, 0.01406517f, -0.00287239f, -0.09679426f, 0.05475415f, 
    -0.14113106f, -0.07487409f, 0.12216520f, 0.01303907f, 0.08089519f, 0.02043323f, -0.19292411f, -0.01333578f, 
    0.01779882f, 0.05504066f, -0.03021609f, -0.09809782f, 0.13511285f, -0.05393859f, 0.14910166f, -0.13236466f, 
    0.00737965f, -0.00051520f, 0.06776728f, -0.05112396f, 0.00765271f, -0.03402892f, 0.03840031f, 0.03380387f, 
    0.01908923f, 0.07721188f, 0.28636357f, 0.07066043f, -0.08885627f, -0.25677377f, -0.15052320f, -0.13422494f, 
    0.10297646f, 0.13565160f, 0.22158460f, 0.03951604f, 0.14326584f, 0.12195019f, 0.05353471f, 0.01136404f, 
    0.11922947f, 0.09046222f, 0.01210694f, -0.13056459f, -0.02834091f, 0.01595035f, -0.01826732f, -0.00583669f, 
    0.14859778f, -0.07229696f, 0.02272874f, -0.00827161f, 0.09195089f, 0.22892755f, 0.01024484f, 0.05572509f, 
    -0.14904743f, -0.04637564f, -0.05034177f, 0.08008178f, -0.13208340f, -0.26819748f, -0.09680774f, 0.03324500f, 
    0.07593956f, 0.20058569f, 0.11737952f, 0.08417167f, 0.06124552f, 0.03031038f, -0.10008848f, -0.05406115f, 
    -0.29486099f, -0.26757023f, -0.30485696f, -0.03598057f, 0.11415568f, 0.11669915f, 0.12762165f, 0.11965206f, 
    0.12445948f, 0.07653998f, 0.00779232f, -0.06728043f, 0.07676784f, 0.04721059f, 0.23244607f, -0.08051551f, 
    0.17167631f, -0.07473276f, 0.08085774f, -0.01661020f, -0.06626378f, 0.03596085f, -0.06476112f, 0.11148834f, 
    0.04396750f, -0.03434898f, -0.01621911f, 0.10902192f, 0.01595202f, 0.02175721f, -0.00789653f, -0.01453238f, 
    -0.09021967f, -0.05739077f, -0.10716417f, 0.12047026f, 0.24493624f, 0.00606675f, -0.08913160f, -0.09791354f, 
    -0.01688361f, -0.03984468f, 0.07721945f, 0.04450556f, -0.05136541f, -0.05448321f, -0.02474120f, 0.00000110f, 
    0.04677505f, -0.09863408f, -0.16812530f, 0.16963798f, -0.11140332f, -0.00074387f, -0.00524443f, 0.06479815f, 
    0.03572693f, -0.05132562f, 0.06518529f, -0.01100044f, 0.37044078f, 0.51263970f, 0.00264834f, -0.05410733f, 
    -0.11505145f, -0.17153592f, -0.00089585f, -0.05388155f, 0.04115504f, 0.02950653f, -0.02612714f, -0.01400930f, 
    -0.10458124f, -0.15110908f, -0.09999087f, -0.27006316f, 0.01916749f, 0.08866215f, 0.02322606f, 0.03541191f, 
    0.16408953f, -0.11973327f, 0.02618333f, 0.01824195f, -0.05813137f, 0.06926573f, -0.26282761f, 0.11390692f, 
    -0.15948093f, 0.04356488f, -0.07065777f, 0.01728941f, 0.05777410f, -0.06312742f, 0.01667885f, -0.04863007f, 
    0.01532521f, -0.14843407f, -0.11739310f, -0.12922701f, 0.04167461f, 0.04645116f, 0.04961563f, -0.00372094f, 
    0.01633468f, 0.00613230f, 0.00190702f, 0.04216224f, 0.02714289f, 0.09513698f, 0.05926427f, 0.24103422f, 
    -0.00782789f, 0.04671692f, -0.14633001f, 0.01697358f, 0.03507864f, 0.10202182f, 0.08406708f, 0.05964634f, 
    0.02076814f, 0.15631156f, 0.18190178f, 0.04628775f, 0.04259450f, 0.11714427f, 0.00706452f, -0.00930194f, 
    -0.09741611f, 0.10152258f, 0.10208847f, 0.00162292f, -0.11454079f, -0.04288016f, -0.06310184f, 0.36602297f, 
    0.20702006f, 0.10281927f, -0.22932678f, -0.16150476f, 0.02233611f, 0.03135420f, 0.01959132f, 0.02137338f, 
    0.18700886f, -0.01402147f, 0.01169565f, 0.07683010f, 0.24766278f, 0.18805374f, 0.07932346f, -0.10664120f, 
    0.04009429f, -0.03346845f, -0.06429673f, -0.02791618f, 0.07765721f, 0.03722703f, -0.07792488f, -0.00342656f, 
    0.01351317f, 0.10871716f, -0.00915331f, -0.02126705f, 0.07608809f, 0.06224688f, -0.14764121f, 0.07760723f, 
    0.42886299f, 0.41861990f, -0.36580363f, 0.02687993f, -0.14469010f, -0.13125736f, 0.10273316f, -0.15731993f, 
    -0.17880325f, 0.15960591f, -0.11247493f, 0.02706382f, 0.12348352f, 0.01285189f, 0.12906016f, -0.10648082f, 
    0.06697462f, 0.00846729f, -0.08357878f, 0.02143094f, -0.00776675f, -0.07205970f, -0.01510103f, -0.00371010f, 
    -0.02895365f, -0.03679794f, -0.16772531f, 0.14800613f, 0.02312431f, 0.06905364f, -0.08791792f, -0.07302830f, 
    0.01270411f, 0.11425193f, -0.10484152f, -0.19682790f, -0.02853043f, 0.31270644f, 0.14412452f, 0.12863383f, 
    0.03286688f, 0.04269274f, -0.05022556f, 0.03918326f, 0.03126476f, 0.02822761f, 0.05299590f, 0.04655921f, 
    0.00085706f, -0.14291558f, -0.21513729f, 0.13899194f, 0.09718663f, 0.16012226f, 0.16384129f, 0.04714974f, 
    0.02987448f, -0.05845213f, 0.06702826f, -0.02465564f, 0.36606267f, -0.14012551f, 0.16976357f, 0.05639251f, 
    0.13559422f, 0.13304277f, 0.00517575f, 0.03970171f, -0.03308764f, 0.00724025f, 0.02372067f, 0.00601849f, 
    -0.03681741f, 0.02759922f, -0.00684467f, -0.00340075f, 0.01715225f, 0.00947271f, -0.01530585f, 0.00033534f, 
    0.02219370f, 0.01631627f, -0.01149078f, 0.03157064f, -0.00541039f, -0.02639729f, 0.02406220f, -0.01580208f, 
    -0.02921706f, 0.00672133f, -0.02699169f, 0.02673400f, -0.01228895f, -0.03282326f, -0.03206627f, 0.02152510f, 
    -0.01093155f, 0.03293714f, 0.02895843f, -0.03629179f, -0.00708683f, -0.03142815f, -0.00914957f, 0.00871170f, 
    -0.01058513f, -0.02883665f, 0.02239486f, -0.01774682f, -0.03117075f, -0.00773390f, 0.00781683f, -0.00618279f, 
    -0.01936971f, 0.03092184f, 0.02057440f, 0.00323766f, 0.00237877f, 0.01016859f, 0.00373287f, 0.02179621f, 
    -0.01932471f, -0.03424823f, 0.03209930f, 0.02558414f, -0.03166674f, -0.03651729f, -0.02402266f, -0.01797128f, 
    -0.02662149f, -0.02802247f, 0.02639929f, 0.02071426f, 0.00307153f, -0.02350040f, -0.02406276f, 0.00691760f, 
    -0.02063501f, 0.02141835f, 0.01687305f, 0.00244102f, 0.00002108f, -0.02883569f, -0.01825383f, -0.02211306f, 
    -0.02150329f, 0.01532328f, 0.02119961f, -0.02470427f, -0.03142833f, -0.00014770f, 0.01945402f, 0.00909373f, 
    -0.01758647f, -0.01951693f, 0.03077402f, -0.02242534f, -0.00253595f, -0.02808191f, 0.01157505f, 0.00311033f, 
    -0.02756864f, 0.00775115f, -0.01816920f, 0.02041135f, 0.01281856f, 0.00099822f, -0.03424719f, -0.02813927f, 
    0.00392831f, 0.01209677f, -0.02948176f, -0.03015056f, 0.01970564f, -0.00103717f, -0.02800639f, 0.02454513f, 
    -0.03047607f, 0.00036684f, 0.00412427f, 0.02474064f, -0.02916794f, -0.01708841f, -0.00470579f, -0.01907121f, 
    0.00877666f, -0.03731367f, 0.02234758f, 0.02730198f, -0.01244673f, -0.03445509f, -0.02943621f, -0.00340766f, 
    0.01168229f, -0.00452850f, -0.03296718f, -0.03997994f, 0.00202221f, -0.02608129f, 0.02819119f, -0.03064790f, 
    -0.04074739f, 0.01212452f, 0.01642174f, -0.01885141f, 0.02320152f, 0.01772777f, -0.03512091f, -0.03150065f, 
    0.01409944f, -0.00737641f, 0.02291976f, -0.02798149f, -0.00287520f, 0.03086352f, -0.00201534f, -0.02140282f, 
    0.00968067f, -0.04086057f, -0.02036688f, 0.01709029f, 0.00778085f, 0.02676376f, -0.02839478f, 0.02531602f, 
    -0.02032741f, -0.01980824f, 0.01254291f, 0.02692907f, 0.02933454f, -0.02482552f, 0.02143509f, 0.02412956f, 
    -0.01948376f, -0.01608268f, -0.02438031f, -0.00028682f, -0.04010147f, -0.03291855f, -0.02290127f, 0.00529015f, 
    -0.03596457f, -0.00689283f, 0.00558094f, 0.01758919f, -0.01771586f, -0.00392352f, -0.01938743f, 0.02984428f, 
    0.00032680f, 0.02663337f, 0.00731415f, -0.01061850f, -0.02106749f, -0.03645461f, -0.03078265f, 0.01327440f, 
    -0.00413506f, 0.00287457f, -0.00808856f, -0.00550648f, -0.03851261f, 0.00021504f, -0.02556705f, 0.02514436f, 
    0.01395301f, 0.02349732f, -0.02542615f, -0.00627386f, -0.01010207f, -0.02053456f, -0.00696240f, -0.01115172f, 
    -0.04040119f, -0.03108144f, 0.01912554f, -0.03001446f, -0.03616101f, -0.03903586f, -0.00354946f, 0.00592896f, 
    -0.03886045f, -0.03880553f, -0.01089281f, -0.03855860f, -0.01796731f, 0.01610131f, 0.01758378f, -0.01242052f, 
    -0.00227319f, 0.01921287f, -0.03339812f, 0.01181821f, -0.02595931f, -0.01102334f, 0.01047361f, -0.03422704f, 
    -0.00321065f, 0.02465190f, -0.03662946f, 0.02595814f, 0.01293285f, 0.00782849f, -0.02337810f, -0.04053265f, 
    -0.00243499f, -0.00312706f, 0.00182879f, -0.03095828f, 0.01880282f, 0.00044719f, -0.01973769f, 0.01990785f, 
    -0.00349449f, 0.00031213f, -0.03558938f, -0.01623893f, 0.01683851f, -0.02773069f, -0.00851501f, 0.02549872f, 
    0.01389000f, 0.01742336f, -0.03214725f, 0.01105108f, -0.02584586f, 0.01365237f, 0.01508640f, 0.00769024f, 
    -0.00199117f, 0.02775890f, 0.00191338f, -0.01634577f, -0.01343963f, 0.02454326f, 0.02897524f, 0.01433625f, 
    -0.00476674f, 0.00528341f, 0.02195291f, 0.02756460f, 0.00941384f, -0.02205537f, -0.01436476f, -0.01451190f, 
    0.02864577f, -0.00502128f, 0.02919430f, -0.02105426f, -0.00590355f, -0.00413820f, 0.02276732f, 0.01555648f, 
    -0.02849360f, -0.01506268f, 0.00151899f, -0.00131279f, -0.00901324f, -0.00784170f, -0.02125571f, 0.00471405f, 
    -0.00536563f, 0.03435665f, -0.01154869f, -0.03067112f, -0.02789846f, -0.01440101f, -0.03636289f, 0.02040472f, 
    -0.03188403f, 0.01686359f, -0.01324903f, -0.00271696f, 0.02561685f, -0.03205144f, 0.02977531f, -0.01682542f, 
    0.02263367f, 0.01942146f, 0.01750546f, 0.01014482f, 0.02245827f, 0.02241406f, 0.02326152f, 0.01417105f, 
    -0.01967658f, -0.00294840f, -0.03861673f, -0.01679938f, 0.03413259f, 0.01900673f, -0.00027452f, -0.02628533f, 
    -0.02673838f, 0.00736362f, -0.00189602f, 0.03089952f, 0.01730394f, 0.00028525f, -0.03204332f, -0.00244945f, 
    -0.03533759f, -0.01272780f, 0.01650111f, -0.00447164f, -0.02624511f, -0.01991517f, -0.02133661f, -0.00427956f, 
    -0.02098569f, -0.03332751f, -0.03673124f, -0.04022329f, -0.04098319f, -0.01336367f, -0.00778959f, 0.00988424f, 
    0.02169332f, 0.00121427f, 0.01203842f, 0.00331734f, -0.01905508f, 0.02434221f, 0.03405062f, -0.03351770f, 
    0.02673720f, -0.01553759f, 0.02411705f, -0.02303996f, -0.02868091f, 0.01744799f, -0.03184361f, -0.02341065f, 
    0.03496120f, -0.02279127f, 0.01819475f, 0.02355157f, -0.00702028f, -0.00761791f, -0.01224971f, -0.03158059f, 
    0.00758312f, 0.02293264f, 0.01737398f, -0.02485592f, 0.01806242f, -0.03083916f, -0.01001906f, 0.00485751f, 
    -0.00876739f, 0.00654764f, -0.01407631f, 0.01380430f, -0.00231574f, -0.03354866f, 0.01859155f, 0.00025026f, 
    -0.02811113f, 0.00493467f, -0.02710028f, -0.01308163f, 0.00170763f, -0.01851643f, -0.00810729f, -0.00001113f, 
    -0.03832082f, -0.00686953f, -0.00504329f, -0.02819403f, -0.00765100f, 0.02776375f, 0.01499481f, -0.03116400f, 
    0.00364309f, -0.03695931f, -0.01914123f, -0.00592750f, 0.01047780f, -0.01497082f, 0.00282047f, -0.03045233f, 
    -0.00173036f, 0.00569364f, 0.02673313f, -0.01498973f, 0.00410286f, 0.02661590f, -0.01368379f, -0.01876426f, 
    -0.01198981f, 0.03909147f, 0.00032082f, 0.02423096f, 0.01634003f, 0.00547445f, -0.01040365f, -0.01188708f, 
    0.02486467f, -0.02686992f, -0.02751544f, -0.02349032f, 0.01405125f, 0.02203043f, 0.01478436f, -0.00261802f, 
    -0.02186763f, -0.03285468f, 0.01003294f, 0.02229265f, -0.02278702f, -0.03256898f, 0.02930568f, 0.02951141f, 
    0.01310671f, -0.00321360f, -0.01047225f, 0.02433911f, -0.01386235f, 0.00232689f, -0.02145822f, 0.02877593f, 
    -0.02356238f, -0.00228788f, 0.01892876f, 0.02928645f, -0.02574643f, 0.00929995f, 0.03006644f, -0.02884207f, 
    -0.00571326f, 0.02206455f, -0.03354672f, -0.03927675f, 0.02137441f, -0.02736831f, -0.03814939f, -0.01569447f, 
    -0.02299139f, -0.01121616f, -0.03000774f, -0.01760371f, -0.03773474f, -0.00735850f, -0.01184069f, 0.00349239f, 
    -0.04003010f, -0.03507924f, -0.00058688f, -0.01729568f, 0.01566796f, 0.03265862f, 0.01431829f, 0.01148726f, 
    0.03149393f, 0.02010076f, -0.00205343f, -0.02147477f, 0.00482658f, 0.01806420f, -0.01287989f, -0.01695392f, 
    0.01980963f, -0.03789349f, -0.00874033f, 0.02948495f, -0.02119673f, 0.02861019f, 0.00461691f, -0.00012429f, 
    -0.01332537f, -0.00372679f, -0.00565465f, -0.00671720f, 0.01250352f, -0.03181386f, -0.02287951f, 0.02518637f, 
    -0.02641529f, -0.03690181f, 0.03012248f, -0.03209279f, 0.02770868f, -0.00637051f, -0.02934412f, 0.01220284f, 
    -0.00633629f, -0.01805823f, -0.01408982f, -0.02698806f, -0.03162602f, -0.00667889f, 0.01064593f, 0.01724884f, 
    0.00310167f, -0.00913832f, -0.02355089f, 0.01917236f, 0.03165332f, -0.00873068f, 0.02972298f, 0.00761907f, 
    0.01877839f, 0.02723838f, 0.03008963f, -0.01805148f, -0.01659975f, 0.01277330f, -0.03710517f, 0.03065390f, 
    -0.01385565f, 0.02447693f, -0.03064874f, 0.00467990f, 0.02957398f, -0.00212286f, -0.01719726f, 0.00332631f, 
    -0.03854162f, -0.01865821f, 0.02463842f, -0.02788930f, -0.00319502f, 0.02049309f, -0.03110286f, 0.01731882f, 
    -0.03739331f, -0.01840409f, 0.01471522f, 0.02007209f, 0.00213757f, 0.00578609f, 0.00405385f, 0.00257503f, 
    -0.01693963f, 0.02652972f, -0.02512011f, 0.00709438f, 0.01600442f, 0.02407490f, -0.02403102f, 0.00585318f, 
    -0.03775982f, -0.03413418f, 0.01708024f, 0.02806735f, 0.02190069f, -0.00475193f, -0.03333814f, -0.00955470f, 
    0.02630915f, 0.02067635f, -0.03904439f, -0.01235795f, 0.02103445f, -0.03472961f, 0.01617301f, 0.03055891f, 
    0.01714799f, 0.02290944f, -0.01831767f, 0.01422612f, -0.00203785f, 0.01787383f, 0.01311946f, 0.00443765f, 
    0.00695794f, 0.01040155f, -0.03114446f, 0.02854530f, -0.00157357f, -0.03128242f, 0.00790708f, -0.02608147f, 
    -0.02721832f, -0.01358168f, -0.00761350f, 0.00174984f, -0.02932987f, -0.02132708f, -0.00918071f, 0.00361308f, 
    0.02824494f, -0.00503090f, -0.02368539f, -0.03999975f, 0.00168434f, -0.01711095f, -0.03135689f, -0.00864087f, 
    -0.02955343f, -0.03324400f, 0.00087024f, -0.02684541f, -0.00455444f, 0.01816117f, 0.01552821f, 0.01401204f, 
    0.01887199f, -0.02424294f, -0.00417324f, 0.02753608f, -0.00580508f, -0.03596473f, 0.02981585f, 0.02408548f, 
    -0.03075236f, 0.01950676f, -0.03684011f, -0.02936834f, 0.02419762f, -0.00504501f, -0.01166332f, -0.01653397f, 
    -0.02855818f, 0.02601267f, -0.03548086f, -0.01678204f, 0.01065248f, -0.01686791f, -0.00255606f, 0.03078256f, 
    0.00240043f, -0.00270573f, -0.00614226f, -0.00324623f, 0.02784803f, 0.03041417f, -0.03057667f, 0.02853676f, 
    -0.00430668f, 0.00571264f, -0.02488196f, -0.00101631f, 0.00024482f, 0.01964293f, -0.02985954f, -0.02082508f, 
    -0.01388618f, -0.01785410f, -0.01793685f, 0.02793865f, -0.03899776f, -0.03066852f, 0.02274689f, 0.02756614f, 
    -0.02325176f, -0.03604594f, 0.03394358f, 0.00623644f, -0.01548029f, -0.03295088f, -0.03433689f, 0.00001827f, 
    -0.03446910f, 0.00753307f, 0.02534027f, 0.00601342f, -0.01981626f, 0.02564838f, -0.01412509f, -0.03135706f, 
    0.00922851f, 0.03079352f, 0.01315954f, -0.03354560f, 0.01715474f, -0.01326494f, -0.00253377f, -0.01953982f, 
    -0.02123078f, 0.00038466f, 0.00310216f, 0.01438833f, -0.02774672f, -0.02763382f, 0.02777409f, 0.03030561f, 
    -0.01887897f, -0.01903931f, -0.02746108f, -0.00474420f, 0.03138612f, -0.00178815f, 0.03024624f, -0.01816311f, 
    -0.01788640f, -0.02765679f, 0.01521714f, -0.03006102f, 0.02776305f, -0.02932220f, 0.01310101f, -0.01834479f, 
    -0.00635116f, 0.03350910f, -0.00391323f, -0.00000627f, -0.01490187f, -0.01202936f, 0.00229295f, 0.00704706f, 
    0.00676877f, 0.00246165f, 0.01448507f, -0.00586703f, 0.00522528f, 0.01316562f, -0.00440807f, -0.03397285f, 
    0.00777494f, 0.01217243f, -0.01713461f, -0.00415767f, -0.01936367f, -0.01959484f, -0.01941866f, 0.00504837f, 
    0.02257703f, -0.01624659f, 0.02674452f, -0.01197735f, 0.03187058f, -0.01276049f, 0.00147073f, 0.01108739f, 
    -0.03251771f, -0.02681377f, -0.01772702f, 0.02571024f, 0.00688282f, -0.04035428f, -0.02097758f, 0.00200694f, 
    -0.02547192f, -0.02695169f, -0.01044781f, -0.00780508f, 0.01998213f, 0.03391174f, 0.00308164f, 0.00283775f, 
    -0.03958337f, -0.09255041f, 0.14583509f, 0.13522011f, -0.00975581f, -0.00755053f, -0.07514176f, 0.06503573f, 
    -0.00440928f, 0.00797295f, -0.01602714f, -0.02666629f, 0.32185888f, 0.12301982f, -0.28197721f, -0.19270118f, 
    -0.11572598f, -0.03027889f, -0.02497547f, 0.05800799f, -0.03970179f, -0.01280920f, 0.02122089f, -0.04646189f, 
    -0.39255506f, 0.07228193f, -0.10375549f, -0.12910914f, -0.14739349f, 0.14121278f, 0.00037929f, 0.03426473f, 
    0.03240750f, -0.05957201f, -0.03005817f, 0.01227475f, 0.06878477f, 0.15587763f, 0.12290879f, 0.25962776f, 
    0.08192174f, 0.04812422f, -0.02492315f, 0.17764619f, 0.01679940f, -0.00329498f, 0.00079911f, 0.04384213f, 
    0.35524011f, -0.08086021f, 0.01909273f, 0.06085727f, -0.07934986f, 0.02300980f, -0.06910724f, 0.05915251f, 
    0.08449078f, 0.01708585f, 0.16211341f, 0.10414894f, 0.10804948f, -0.00441351f, -0.07298522f, -0.08019356f, 
    -0.05166517f, -0.06059483f, 0.02375247f, -0.03643497f, 0.00971640f, 0.08032339f, 0.04360288f, 0.00477361f, 
    -0.08980344f, 0.04903154f, -0.04324118f, -0.12055162f, 0.00391962f, 0.04446312f, -0.02990114f, 0.02713760f, 
    0.05189721f, -0.04287180f, -0.08451569f, 0.07831781f, -0.29450920f, 0.10688401f, -0.04658090f, -0.04578202f, 
    -0.04564141f, 0.05650102f, 0.14681976f, 0.07252105f, -0.06037708f, 0.03105525f, 0.03167307f, 0.17929533f, 
    -0.02126455f, 0.10354576f, -0.06769586f, 0.10209176f, -0.02713407f, 0.03039560f, 0.09709383f, -0.00734131f, 
    0.08971309f, 0.07998789f, 0.05991500f, 0.08522009f, 0.02638714f, 0.00838724f, 0.04005455f, 0.07107244f, 
    -0.09455846f, 0.02446979f, 0.08093307f, -0.03346425f, 0.03833770f, 0.00723667f, -0.02252049f, -0.04243353f, 
    0.09106425f, -0.11879317f, 0.05918206f, -0.06732991f, -0.03148862f, -0.07013372f, -0.05093377f, -0.03690563f, 
    0.01854391f, -0.26221421f, -0.08844288f, -0.24029359f, -0.02060167f, -0.04678167f, -0.03718674f, -0.01435804f, 
    -0.01459493f, -0.13455552f, 0.06721117f, -0.04128323f, -0.02980794f, -0.03787415f, 0.08161255f, -0.00812889f, 
    0.42511952f, 0.22457735f, -0.31295496f, 0.07032744f, -0.20463151f, -0.12196025f, -0.01153339f, 0.04192095f, 
    0.04478008f, 0.02453656f, -0.03269342f, -0.00456137f, -0.04941100f, -0.03598205f, -0.00632536f, -0.02275058f, 
    0.01690361f, 0.02995696f, 0.04925522f, -0.03526003f, 0.02692319f, 0.18011934f, 0.15121661f, 0.12092902f, 
    0.10618231f, 0.11460833f, -0.09609237f, 0.03979721f, -0.07777146f, -0.09496949f, 0.10864004f, 0.08252051f, 
    0.15864477f, -0.02216935f, 0.08714120f, -0.01944861f, 0.14204234f, 0.03130029f, 0.01499811f, 0.11771095f, 
    0.05522827f, 0.00067808f, -0.04898487f, 0.04152395f, -0.00463947f, -0.01906789f, -0.00925107f, -0.05468618f, 
    0.22195683f, -0.14943111f, -0.18250242f, 0.10574924f, 0.02416847f, 0.08385146f, -0.01387946f, 0.06106432f, 
    -0.11065022f, -0.05457113f, 0.00342850f, 0.11862994f, 0.22637233f, -0.04601533f, 0.24682024f, 0.34115055f, 
    0.05987171f, -0.00293871f, 0.01710838f, 0.21544096f, -0.03924889f, -0.09228899f, -0.07798548f, 0.08166119f, 
    0.13328400f, 0.18365888f, 0.06967864f, -0.00537634f, 0.12260854f, 0.13770649f, -0.03874936f, 0.02298412f, 
    0.04917224f, -0.04438697f, 0.01178562f, -0.10041643f, 0.32088727f, 0.09794330f, 0.19489418f, 0.17466432f, 
    0.13136473f, 0.10221194f, 0.17181234f, 0.16002785f, 0.02169108f, 0.13014700f, 0.06212076f, -0.02545339f, 
    -0.06319527f, 0.08380454f, 0.33912417f, 0.22247483f, -0.00540100f, -0.02856287f, -0.10908268f, 0.04988781f, 
    0.00040925f, 0.01310188f, 0.07675716f, 0.02638219f, 0.01060586f, 0.03579715f, 0.00826268f, 0.14180158f, 
    0.06339561f, 0.08966826f, 0.04636044f, 0.11986323f, 0.06940271f, -0.01193791f, 0.02436112f, -0.04364533f, 
    0.20531499f, -0.10452690f, -0.09144213f, 0.04034420f, -0.14485656f, -0.08892310f, -0.08368512f, -0.01550037f, 
    0.01185600f, 0.01007429f, 0.02275582f, -0.00733352f, -0.16629012f, -0.15615185f, -0.06367181f, -0.12603599f, 
    -0.03545623f, 0.00773454f, -0.03292077f, -0.04524473f, 0.14018989f, 0.02229093f, 0.11263251f, 0.18218537f, 
    0.14340842f, 0.03455645f, 0.10558884f, 0.11757149f, 0.13840282f, 0.18756302f, 0.03557381f, 0.13933432f, 
    0.14864781f, 0.16778752f, 0.11493903f, 0.09109218f, 0.15867299f, 0.21678293f, 0.26486108f, 0.23948224f, 
    0.01990127f, 0.04827216f, -0.00140958f, 0.14425857f, -0.05765339f, -0.02718288f, -0.04839292f, 0.02527782f, 
    -0.35930127f, 0.28766850f, -0.01765182f, -0.02823360f, -0.03967405f, -0.06663467f, 0.03616400f, 0.05795556f, 
    -0.03134287f, -0.02304498f, 0.01256531f, 0.03289948f, 0.33067521f, 0.32966909f, 0.20673078f, -0.00193197f, 
    -0.15203474f, 0.09652748f, 0.08649780f, 0.08354999f, 0.00377046f, 0.04469151f, -0.00655833f, 0.02314445f, 
    -0.08305857f, -0.02396830f, 0.01744395f, 0.00695681f, 0.02798181f, 0.03781262f, 0.03902381f, 0.12799507f, 
    -0.00555527f, -0.00492225f, -0.01272038f, -0.06179901f, -0.23651594f, -0.10060664f, 0.09112559f, -0.04113109f, 
    -0.05947615f, -0.04052389f, 0.01532437f, -0.00686456f, -0.00839887f, 0.02952826f, -0.08788150f, 0.02595731f, 
    0.15465505f, 0.38065863f, -0.01581088f, 0.10596523f, -0.10336947f, -0.06485021f, 0.08875962f, 0.04147572f, 
    -0.07622247f, 0.04496560f, -0.01740290f, -0.03651758f, 0.01571159f, 0.10227475f, -0.00152255f, 0.14096278f, 
    0.05038894f, 0.12019464f, 0.01335604f, -0.07683112f, 0.06138450f, 0.05034328f, 0.07906205f, -0.04930840f, 
    -0.17117827f, 0.09608895f, 0.12251552f, 0.19871826f, -0.07825249f, 0.01731639f, -0.00361960f, 0.09822265f, 
    -0.07865366f, -0.05418879f, -0.05910321f, 0.02577748f, 0.10425077f, 0.02301737f, 0.02336019f, 0.08912823f, 
    0.04373489f, 0.14432834f, 0.15577033f, -0.00302156f, -0.01119920f, 0.06831679f, 0.03509733f, 0.00545474f, 
    -0.14948833f, -0.19868098f, -0.14266485f, -0.17178285f, 0.00553376f, 0.00456772f, -0.02871584f, -0.08834289f, 
    0.04251483f, 0.03699026f, 0.08342151f, 0.06376336f, 0.06429708f, -0.03621171f, 0.13954984f, 0.13028733f, 
    0.10455536f, -0.05077357f, 0.07304975f, 0.01404942f, -0.06016754f, 0.01864883f, 0.06413375f, 0.04050781f, 
    0.04042190f, 0.01592102f, -0.04703867f, 0.18229707f, -0.07060694f, -0.03038244f, 0.01523836f, 0.06178093f, 
    -0.18886162f, -0.10918894f, -0.14477523f, -0.04086114f, -0.00701102f, 0.22569738f, 0.08079654f, 0.13895102f, 
    -0.01807973f, 0.00666425f, -0.01173226f, 0.01799246f, -0.06734240f, 0.10069560f, -0.00666591f, 0.09107578f, 
    0.00206961f, 0.08414377f, -0.09585798f, -0.03353084f, -0.03991440f, -0.06201682f, -0.03748596f, -0.03044193f, 
    -0.14901508f, -0.16607952f, -0.11759571f, -0.19117802f, -0.08452491f, 0.12676276f, 0.19985314f, 0.20032537f, 
    0.02742836f, -0.06161267f, 0.01407081f, 0.18797609f, 0.02163986f, 0.03688536f, -0.03178660f, -0.01868682f, 
    0.07017282f, 0.00947521f, 0.01718812f, 0.04170955f, -0.06392803f, 0.03703550f, 0.03153695f, -0.01509423f, 
    -0.02547286f, -0.12912235f, -0.12022290f, -0.04958798f, 0.16116489f, 0.28492078f, 0.18182184f, 0.18165998f, 
    -0.00354251f, -0.09824258f, 0.10850441f, 0.04913238f, -0.05658291f, 0.03822955f, 0.00380339f, -0.05494338f, 
    -0.04909535f, 0.10775263f, 0.00701229f, -0.03044138f, 0.05301530f, -0.09660563f, -0.04296286f, -0.05014798f, 
    -0.01778102f, 0.01125915f, -0.08139607f, -0.16062431f, -0.03309622f, -0.15596063f, -0.11876334f, -0.18591352f, 
    0.07053542f, -0.05470733f, 0.00164443f, 0.06215314f, 0.04408999f, 0.08538290f, 0.13755023f, -0.09421314f, 
    0.14541335f, -0.13274309f, -0.29101110f, -0.12368605f, -0.02298542f, 0.11575382f, 0.02630907f, 0.01780044f, 
    0.06210613f, 0.00721716f, 0.12106938f, 0.06549747f, -0.03174648f, -0.03031797f, 0.29533049f, 0.13992980f, 
    0.01099004f, -0.00829302f, 0.04307952f, -0.05803308f, -0.12461746f, -0.09558515f, -0.03934241f, -0.01246265f, 
    -0.02062391f, 0.00103019f, -0.00884245f, -0.07024048f, 0.08556519f, -0.00428486f, 0.04292245f, -0.00840515f, 
    0.10116647f, 0.07263083f, -0.03277804f, 0.06579004f, -0.32050437f, -0.16282415f, -0.08070736f, -0.10996904f, 
    -0.00368587f, -0.04701664f, -0.03471528f, -0.08249872f, -0.07675320f, -0.08764074f, -0.06921872f, 0.13154520f, 
    0.00868218f, 0.17530002f, 0.19876049f, 0.23493190f, 0.08964374f, -0.05969183f, 0.01478667f, 0.14858662f, 
    0.02401538f, -0.27000609f, -0.18679084f, -0.16976073f, -0.28049186f, -0.27488321f, 0.06701139f, -0.18996133f, 
    -0.10409805f, 0.01940563f, -0.01875764f, -0.00395365f, -0.02326182f, -0.01913040f, -0.05634516f, -0.03643882f, 
    -0.02045109f, 0.31087857f, -0.10781849f, 0.16714692f, 0.04504675f, 0.00712113f, 0.04068075f, 0.14884371f, 
    0.16139059f, 0.02025569f, 0.07874440f, -0.03467792f, 0.04871618f, 0.16472286f, 0.03833972f, 0.10294451f, 
    0.04418086f, -0.14539666f, 0.18885624f, -0.02225252f, 0.08018488f, -0.08989091f, 0.10137742f, 0.05427655f, 
    0.01950575f, -0.01546435f, -0.07934068f, 0.04297444f, -0.01437484f, -0.04990859f, -0.01832312f, 0.07992706f, 
    0.03623825f, -0.16230017f, -0.23626181f, -0.19786626f, 0.08266202f, 0.04134456f, 0.00357521f, -0.06069320f, 
    -0.05867999f, -0.09078135f, 0.08333911f, 0.10793544f, -0.04487909f, 0.00406076f, 0.06106868f, -0.01119878f, 
    -0.00214832f, -0.16606095f, -0.15298741f, -0.08673730f, -0.06239245f, -0.05051240f, -0.07515064f, -0.02633193f, 
    -0.04907982f, -0.00043663f, 0.04912923f, 0.09623113f, 0.11739346f, 0.00047578f, 0.04648698f, -0.04182339f, 
    -0.05780972f, 0.03007335f, 0.09708440f, 0.10996472f, 0.14164408f, 0.13882555f, 0.07992933f, 0.04417391f, 
    0.08283184f, 0.30842617f, 0.38848564f, 0.37650901f, 0.00780998f, 0.12198991f, 0.08497869f, 0.16227037f, 
    0.03667324f, 0.00152705f, 0.00807206f, 0.03946965f, -0.00029462f, -0.04343262f, 0.03953827f, -0.04001005f, 
    0.10801224f, 0.04308674f, -0.03181563f, 0.00510302f, 0.05390675f, 0.02630593f, 0.08908004f, 0.09329144f, 
    -0.17858279f, -0.19382443f, 0.16865140f, -0.03803531f, -0.00772910f, -0.04929040f, -0.08671249f, 0.05727205f, 
    0.14885585f, -0.09498587f, 0.00178379f, 0.05736471f, -0.17214172f, -0.16318837f, -0.13029416f, -0.06142355f, 
    -0.09467407f, -0.09669239f, 0.01049711f, -0.06686012f, -0.06117470f, -0.07140274f, -0.00659771f, 0.08198016f, 
    0.04671508f, -0.05450309f, -0.03295190f, -0.07911289f, -0.01241122f, -0.03999545f, -0.04968524f, -0.03628043f, 
    -0.13608466f, -0.26926228f, -0.18396237f, -0.12270405f, 0.01530499f, -0.25364685f, -0.32427931f, -0.12216397f, 
    -0.06503878f, -0.07908254f, -0.04525692f, -0.05334024f, 0.00344773f, -0.00640191f, 0.00998855f, -0.04399990f, 
    0.02396574f, -0.16382249f, 0.01449688f, -0.01668837f, 0.02738915f, 0.00955716f, -0.04466671f, 0.08009811f, 
    0.00067861f, -0.03627785f, -0.11606932f, -0.13915686f, 0.22723635f, 0.47696173f, 0.47024992f, 0.38436675f, 
    -0.01335427f, 0.04073136f, 0.05360292f, 0.18945001f, -0.08929229f, 0.00378918f, 0.01335279f, 0.02096400f, 
    -0.04107353f, -0.08919580f, 0.04354758f, 0.27961367f, 0.02185687f, 0.11272918f, 0.08061907f, 0.03462891f, 
    0.03436742f, -0.02989991f, -0.02804975f, 0.02464384f, 0.19248851f, -0.07942546f, 0.08846269f, -0.02379576f, 
    -0.05210496f, -0.02523992f, 0.13404220f, 0.06078515f, 0.05901248f, -0.00023514f, -0.06209385f, 0.06644750f, 
    -0.13517198f, 0.49412569f, -0.08446566f, 0.03481580f, 0.15241975f, -0.00697541f, -0.05592840f, -0.14556986f, 
    -0.02521946f, 0.07975600f, 0.04543131f, 0.02377468f, -0.09668340f, -0.12659317f, 0.05371766f, 0.15215017f, 
    0.02060240f, 0.02831361f, 0.06343903f, 0.01891526f, 0.00568202f, -0.01935129f, -0.02392644f, -0.02924767f, 
    -0.17102423f, 0.33590239f, -0.03821294f, -0.02125237f, 0.01615184f, -0.18089654f, -0.03240129f, -0.04284808f, 
    -0.04791809f, -0.05473541f, 0.02185151f, -0.05645467f, 0.17307553f, 0.12022331f, -0.12157175f, -0.08847001f, 
    -0.05793832f, 0.03974766f, -0.00815924f, -0.02443510f, -0.02412687f, -0.05124215f, -0.14687212f, -0.13302386f, 
    0.06139541f, 0.31776056f, -0.08839558f, -0.14288206f, 0.07962270f, -0.02399294f, -0.02095785f, -0.00997888f, 
    -0.10240975f, 0.03399901f, 0.07237928f, 0.02021701f, -0.12108015f, -0.35846010f, -0.09250096f, 0.20195976f, 
    -0.06007815f, 0.04580658f, 0.09382912f, 0.12671155f, 0.08272334f, -0.00059801f, -0.07422159f, -0.06633439f, 
    -0.03917646f, -0.09614892f, 0.04351207f, 0.08154447f, 0.07624227f, -0.10355670f, -0.06359348f, 0.00138637f, 
    0.06937283f, -0.19649798f, -0.09685208f, 0.14118683f, -0.03771120f, -0.02769561f, -0.07227813f, 0.15547103f, 
    0.02248423f, 0.15949640f, 0.06027957f, 0.14566891f, 0.10511868f, -0.02873556f, -0.07934540f, 0.09059942f, 
    0.16405660f, -0.05289432f, -0.09269610f, 0.04578045f, -0.03648142f, -0.04882126f, -0.04435026f, 0.07519975f, 
    0.01456372f, 0.14630154f, 0.10180981f, -0.09041409f, 0.13823469f, -0.04953161f, 0.02355043f, -0.12432095f, 
    -0.07102976f, -0.14669190f, 0.13836208f, 0.04006279f, 0.02659219f, 0.11083118f, -0.03106143f, -0.07199915f, 
    0.21869121f, -0.14834227f, -0.05955156f, 0.03376063f, -0.00556177f, 0.05410831f, 0.14225286f, -0.00522455f, 
    0.03365896f, -0.06120220f, -0.10859659f, 0.02752726f, 0.00163251f, -0.01453624f, 0.01068985f, -0.01418539f, 
    -0.14286239f, -0.03266967f, -0.12589218f, -0.08612397f, -0.08666321f, 0.00656101f, -0.06114222f, -0.15452862f, 
    -0.19112562f, 0.04783401f, 0.13346130f, -0.07039420f, -0.06300191f, 0.13085863f, 0.07491391f, -0.06569388f, 
    -0.11000509f, -0.08811335f, 0.02976406f, 0.15471198f, -0.25808147f, 0.10139374f, -0.12637919f, 0.04425648f, 
    0.12946631f, -0.05201950f, 0.11111559f, 0.03877229f, -0.01223919f, 0.01916302f, 0.02470867f, 0.01032268f, 
    -0.35913521f, 0.18199234f, 0.08248457f, 0.04547250f, -0.02106330f, 0.10330380f, 0.04174431f, -0.02292477f, 
    0.01529602f, 0.00012985f, -0.03672181f, 0.02882408f, -0.12340745f, 0.00616950f, 0.15943001f, 0.06670492f, 
    0.03793451f, -0.00054171f, 0.07574581f, -0.05229944f, -0.01434269f, -0.10168631f, 0.08785931f, 0.00603094f, 
    0.41643965f, -0.06220987f, -0.17443228f, 0.02703467f, 0.14850833f, -0.13085455f, 0.07333987f, -0.02177167f, 
    -0.01046556f, 0.01245097f, 0.10184491f, 0.14763008f, -0.01112647f, -0.06295357f, 0.02706905f, 0.16561049f, 
    0.02138118f, 0.03495191f, -0.11809058f, -0.02701036f, 0.03576561f, 0.09448179f, 0.00494418f, -0.03523295f, 
    -0.21538289f, -0.02555870f, -0.09402281f, 0.09532797f, 0.05126546f, 0.00499098f, 0.06902701f, -0.08052779f, 
    -0.04229970f, -0.05318078f, 0.00268040f, 0.03681612f, -0.13645083f, 0.03190634f, -0.03476083f, 0.04697443f, 
    0.01324139f, -0.07300421f, -0.01296383f, 0.08285967f, -0.06978326f, 0.06538888f, 0.03793015f, 0.02540653f, 
    0.22319594f, 0.03396733f, -0.13245821f, -0.20235315f, -0.01639511f, -0.02606966f, 0.18470481f, 0.01707243f, 
    0.00437130f, 0.02315273f, -0.12834464f, -0.10282420f, -0.04858117f, -0.01364690f, 0.01877164f, -0.10996775f, 
    0.01006325f, -0.08015124f, 0.00702964f, -0.06551807f, -0.05129261f, -0.05199547f, -0.06345144f, -0.14650197f, 
    -0.24233744f, 0.15880162f, 0.00869835f, 0.05612057f, 0.02712114f, -0.14100069f, 0.07356216f, -0.10673231f, 
    -0.07519276f, 0.03959348f, 0.09206703f, 0.00895892f, -0.10517780f, -0.11474077f, -0.01127263f, 0.10101587f, 
    0.05844012f, 0.02355763f, 0.06995857f, 0.03396219f, -0.01356440f, -0.10139878f, -0.05849713f, 0.01883179f, 
    0.22482590f, -0.16645657f, -0.05995101f, 0.05084085f, -0.05429250f, -0.09765866f, 0.04293440f, -0.08637186f, 
    0.12224815f, 0.04149912f, 0.02911262f, -0.03605444f, -0.00977213f, -0.24003179f, -0.02656437f, 0.17486151f, 
    0.13348961f, 0.07276271f, 0.09858636f, 0.14132893f, 0.05647224f, -0.06587945f, 0.03150677f, 0.01764452f, 
    0.14994709f, 0.03876877f, -0.03597979f, 0.08036642f, 0.04021339f, 0.08431460f, 0.01988800f, -0.10812776f, 
    -0.03549605f, -0.01545508f, -0.04104090f, 0.01507587f, -0.01206115f, 0.16812827f, 0.06926993f, -0.21416932f, 
    -0.05691069f, 0.09529973f, -0.19797540f, 0.08864640f, -0.09631488f, -0.04970786f, 0.07439570f, -0.03740633f, 
    -0.16368614f, -0.25918198f, 0.08040511f, -0.02043511f, 0.07709941f, 0.04539615f, -0.00819194f, 0.01155921f, 
    0.07825555f, 0.08531532f, 0.01147553f, 0.10442662f, -0.26915938f, -0.06055547f, -0.05626771f, -0.03479202f, 
    0.05804538f, 0.00980592f, -0.04834040f, -0.15981440f, -0.08148823f, 0.06343527f, -0.07762604f, 0.09120017f, 
    0.16129699f, -0.05423885f, 0.03154738f, 0.00098228f, -0.05641025f, -0.12379376f, -0.02548682f, 0.07965994f, 
    0.05673489f, 0.01740987f, -0.02373118f, -0.05786943f, 0.08944369f, 0.13611959f, 0.05095205f, -0.11115146f, 
    -0.04874322f, 0.07686687f, 0.00987575f, -0.02975311f, -0.01092475f, -0.05676672f, -0.01566217f, 0.09107134f, 
    -0.02390817f, -0.01369290f, 0.00912473f, -0.06502192f, 0.03158843f, -0.05909406f, -0.01069704f, -0.00932131f, 
    -0.02952116f, -0.17953603f, -0.05050018f, -0.04513173f, -0.29177222f, 0.07813513f, -0.03225059f, 0.14858006f, 
    0.04110091f, 0.21815278f, -0.06204277f, -0.02491626f, 0.07421279f, -0.02507691f, 0.05085140f, 0.00303134f, 
    -0.33674911f, -0.00030972f, 0.12904097f, 0.18313891f, -0.03613575f, 0.18939835f, 0.02275048f, -0.08127885f, 
    0.10153898f, 0.04364339f, 0.12380821f, 0.05444552f, -0.12482501f, -0.18537201f, -0.03859144f, -0.03210749f, 
    0.00483459f, 0.02971087f, -0.09201869f, 0.10658354f, -0.05913671f, -0.00825353f, -0.02426530f, -0.07164013f, 
    0.07208147f, -0.17829829f, 0.06237638f, 0.11061976f, -0.05838086f, 0.10700680f, 0.02700652f, -0.03747746f, 
    0.06379177f, 0.08060884f, 0.10589059f, 0.02403518f, -0.06061124f, -0.04029112f, -0.06694869f, 0.10096762f, 
    -0.05771911f, 0.05832536f, 0.00630308f, 0.06877175f, -0.07553538f, -0.05504123f, 0.03613576f, -0.02533208f, 
    -0.05376782f, 0.13563024f, 0.10295270f, 0.11573619f, -0.14741884f, 0.08447091f, 0.19468157f, 0.10826106f, 
    0.05329936f, 0.08368687f, 0.08119396f, 0.13067037f, 0.08040053f, -0.16501288f, -0.13594058f, 0.00173723f, 
    0.05756753f, -0.03594245f, -0.03860586f, -0.07749454f, 0.05855320f, -0.03977723f, -0.01629825f, -0.01525725f, 
    0.37313262f, -0.09169058f, -0.09576654f, 0.02475911f, 0.10243895f, 0.13466981f, 0.11774465f, -0.04733487f, 
    -0.00053975f, -0.07165076f, 0.00345405f, 0.12915154f, 0.23397614f, 0.02872058f, 0.03279147f, 0.05092798f, 
    0.11340921f, -0.04203536f, -0.03239232f, -0.07333430f, -0.05679740f, 0.03822886f, -0.03140302f, 0.06998968f, 
    -0.13656224f, -0.05389108f, 0.06632110f, -0.03571030f, 0.09318929f, -0.05958604f, -0.07123515f, 0.00272401f, 
    0.04478297f, 0.09748818f, 0.01134766f, -0.03553713f, -0.15657449f, -0.02378979f, 0.04044725f, -0.09913895f, 
    -0.00383790f, 0.05967464f, 0.05191121f, 0.05217135f, -0.01871176f, 0.08935069f, -0.09061296f, 0.15346323f, 
    0.06572067f, -0.01780348f, -0.04746854f, 0.07423169f, 0.01114197f, 0.00722719f, -0.02407257f, -0.00069052f, 
    -0.02734445f, -0.06837118f, 0.09258474f, 0.03405466f, 0.09028549f, 0.03298037f, 0.06763047f, -0.21793327f, 
    0.02684804f, 0.01489982f, -0.09412733f, -0.04892045f, 0.02631025f, 0.07413966f, 0.06035591f, -0.01692654f, 
    -0.03961175f, -0.07879742f, -0.03376463f, 0.10106377f, -0.02011172f, 0.03442086f, -0.05896376f, 0.10950930f, 
    0.04976364f, 0.10393243f, 0.17472838f, 0.05408791f, -0.19300881f, 0.23909098f, -0.31176358f, 0.07533950f, 
    0.08351797f, -0.05395519f, 0.04671619f, 0.03348150f, 0.07773424f, -0.06733569f, 0.01097540f, 0.02854089f, 
    0.23035291f, -0.16295855f, -0.11454208f, -0.11154781f, 0.04946800f, -0.17174707f, 0.03527542f, -0.06848616f, 
    0.03697185f, 0.08431009f, 0.02560625f, 0.08266112f, -0.07336338f, 0.17525157f, -0.10014884f, 0.07658149f, 
    -0.08322980f, 0.00943996f, -0.06065693f, 0.05302507f, -0.05084705f, -0.09886827f, 0.06479784f, -0.03305050f, 
    0.02878701f, -0.10897410f, -0.02144551f, 0.06098809f, 0.03320784f, 0.06638494f, -0.04405949f, 0.04080761f, 
    -0.01742546f, 0.03671191f, 0.11565246f, 0.04151638f, -0.05763875f, -0.10707623f, 0.19515279f, -0.03003814f, 
    -0.05917931f, 0.09359992f, 0.11333022f, 0.10705294f, 0.06425332f, -0.01677558f, -0.02219350f, 0.10152261f, 
    -0.03414810f, -0.02481264f, -0.01016783f, -0.04107487f, -0.03596422f, -0.00940815f, 0.00596424f, -0.08909187f, 
    -0.09319045f, -0.01398781f, 0.03190385f, -0.12121239f, 0.08836480f, 0.12898450f, -0.05365226f, 0.21407132f, 
    0.01749777f, -0.03874043f, -0.12305366f, -0.15977460f, 0.00172421f, -0.00960943f, 0.01629852f, -0.15485147f, 
    -0.05486948f, -0.14624350f, -0.09831295f, 0.03255292f, 0.04530021f, -0.03198048f, -0.17698239f, 0.00636030f, 
    -0.07571609f, -0.03792507f, -0.11870605f, -0.02256835f, -0.01882008f, -0.10566290f, -0.08546386f, -0.10455509f, 
    0.02714503f, -0.11637712f, 0.01047241f, 0.03569141f, -0.05080850f, 0.15352349f, -0.08944961f, -0.09122735f, 
    -0.28175130f, 0.41469112f, -0.07448136f, 0.01700744f, 0.17187233f, -0.07714523f, -0.00865162f, -0.07993104f, 
    0.00117155f, 0.00148078f, 0.00004337f, 0.07606596f, 0.12010141f, -0.01515687f, -0.01198549f, -0.18076319f, 
    0.04764522f, 0.00904017f, -0.05093868f, -0.07671546f, -0.00878938f, 0.17504577f, 0.04463467f, 0.01335012f, 
    0.01366390f, 0.13126992f, 0.03023709f, 0.03936348f, 0.00433839f, -0.03065890f, 0.05616094f, 0.02156289f, 
    0.01956058f, 0.05512582f, -0.00068921f, 0.00175238f, 0.03910206f, -0.06029339f, 0.00852144f, -0.07451425f, 
    0.02377372f, 0.06218497f, 0.05379356f, 0.04558693f, -0.04151037f, -0.03968185f, -0.06533282f, -0.04654461f, 
    -0.11341426f, 0.15158489f, -0.06358844f, 0.09397307f, 0.00346740f, -0.00317629f, 0.08569629f, 0.00668905f, 
    -0.03923903f, -0.03629968f, 0.13202520f, 0.02308746f, -0.01650197f, -0.13460998f, 0.08095266f, 0.28134191f, 
    0.02859463f, 0.07977657f, -0.04829589f, 0.05458817f, 0.03470442f, -0.02847057f, 0.01697802f, -0.02392382f, 
    0.15634018f, 0.17341417f, 0.03011915f, 0.09181990f, 0.07816843f, 0.07273690f, 0.00116814f, -0.04417011f, 
    0.05394894f, -0.04024222f, -0.00065129f, 0.03461636f, 0.23323175f, 0.44509017f, -0.03792198f, 0.03353764f, 
    -0.06842113f, -0.04828342f, 0.07679277f, 0.05572512f, -0.01923268f, -0.01550283f, -0.05378123f, 0.09082010f, 
    0.14330257f, 0.08040631f, 0.11456060f, -0.37941176f, 0.05887222f, -0.08657116f, 0.27469501f, -0.02698211f, 
    0.10100579f, 0.13311641f, -0.10909737f, 0.07740133f, 0.16621439f, 0.11276276f, 0.19168626f, 0.11589960f, 
    0.09287816f, -0.00427640f, 0.06998624f, 0.18739480f, 0.05842846f, -0.02085693f, 0.06506570f, 0.00120300f, 
    0.24298942f, -0.17491110f, -0.02561735f, -0.15799095f, 0.02225258f, -0.10356103f, 0.07434943f, -0.02945806f, 
    -0.16004105f, -0.01256170f, -0.10965489f, -0.12310223f, -0.02330599f, 0.14818878f, -0.07916091f, 0.18752649f, 
    0.09713125f, 0.03741026f, -0.09046305f, -0.04544638f, -0.35014239f, -0.21261398f, -0.24136566f, -0.32308754f, 
    0.08035150f, -0.13712826f, -0.12512679f, 0.03395928f, 0.08487652f, 0.00874514f, 0.15420865f, -0.03074955f, 
    0.05003700f, 0.18071890f, 0.10377339f, 0.08816670f, -0.29972166f, 0.15553421f, 0.20205151f, 0.00541652f, 
    -0.04818802f, 0.03255981f, 0.04497214f, -0.12283330f, -0.06733169f, -0.11080558f, -0.04179066f, -0.03020724f, 
    0.07693429f, 0.03188354f, -0.01245732f, -0.13706374f, 0.00262300f, -0.02950186f, -0.15447819f, -0.07952968f, 
    -0.14638075f, -0.15759961f, -0.01325501f, -0.34292620f, 0.26040453f, 0.18832962f, -0.01823485f, 0.12627973f, 
    0.16114675f, -0.04606307f, 0.08743972f, 0.03854511f, 0.01015075f, 0.07740102f, 0.03474141f, 0.18790448f, 
    -0.24194077f, -0.29547840f, 0.17572226f, -0.00945730f, -0.18970104f, 0.00436908f, -0.13629529f, -0.02869870f, 
    -0.11723960f, 0.12741582f, 0.09987428f, 0.20602942f, -0.19120367f, -0.19992548f, -0.01299577f, -0.10353421f, 
    -0.11686227f, -0.07689801f, -0.03402067f, 0.06469332f, 0.20621443f, 0.03573220f, 0.05425032f, 0.13527624f, 
    -0.13384949f, 0.04328292f, 0.25425372f, 0.07371379f, 0.02493026f, -0.05572494f, -0.13233539f, 0.09404226f, 
    -0.18309385f, -0.04750623f, -0.10921664f, -0.07542441f, -0.15722296f, 0.02655010f, -0.02962343f, -0.19693260f, 
    0.04606768f, 0.02139316f, -0.11152370f, -0.13381012f, -0.19731697f, -0.04778584f, -0.10003190f, -0.26387677f, 
    0.08514330f, 0.26179704f, 0.00854570f, 0.17897257f, 0.14279863f, 0.04807906f, -0.10907910f, -0.14678764f, 
    0.11722940f, -0.05147407f, -0.07876812f, 0.09411585f, -0.01548145f, 0.04564328f, 0.00197547f, 0.06858767f, 
    -0.08689529f, 0.15115808f, 0.00681983f, 0.02282838f, 0.02158681f, 0.04403657f, 0.05219935f, 0.15895987f, 
    -0.13106580f, 0.05905768f, 0.14433143f, -0.22839294f, -0.13742542f, -0.14364444f, 0.11039180f, 0.14985335f, 
    -0.05892477f, 0.06398299f, 0.02070339f, -0.06183187f, 0.14879444f, 0.16337831f, 0.14974862f, -0.00749381f, 
    -0.01145355f, -0.05110233f, 0.09209583f, 0.16052507f, 0.10565229f, 0.05722602f, 0.02914354f, 0.02670128f, 
    0.19704033f, -0.01415023f, 0.03939162f, 0.10669063f, 0.13493802f, -0.04462418f, 0.07280237f, -0.01914841f, 
    0.01544818f, 0.22226599f, 0.01890992f, -0.27243191f, 0.14083061f, 0.22397090f, 0.16920795f, 0.15476136f, 
    -0.03133966f, 0.06822432f, -0.09865381f, 0.09664068f, -0.04750873f, -0.19178428f, 0.08586623f, 0.01486506f, 
    0.25558054f, 0.05387270f, -0.02986444f, 0.18765852f, 0.02254893f, -0.02444661f, -0.04591847f, -0.07947614f, 
    0.03206671f, -0.17458487f, -0.13730881f, -0.03918016f, 0.21952432f, 0.07905429f, 0.07704601f, 0.15675014f, 
    -0.03727978f, 0.00205465f, -0.00491459f, -0.01830935f, 0.09483212f, 0.10693564f, 0.12886226f, 0.09031518f, 
    -0.04801398f, -0.15275569f, 0.09458591f, -0.13991751f, -0.03817220f, 0.09877106f, -0.05339078f, -0.00165635f, 
    -0.11317202f, -0.10468960f, -0.18313482f, -0.09502055f, -0.00287105f, -0.01138812f, -0.18974583f, -0.10976961f, 
    -0.05489048f, 0.06268650f, 0.06322367f, -0.12221899f, -0.23948449f, -0.09462088f, -0.14531247f, -0.15995643f, 
    0.10980781f, 0.11890853f, -0.10944740f, 0.16566488f, 0.08315089f, -0.03013418f, 0.14213468f, -0.09893270f, 
    -0.29541171f, -0.10066533f, -0.13763946f, -0.09361395f, 0.20138954f, 0.05491080f, 0.03891771f, 0.12196494f, 
    0.03592012f, 0.04789295f, 0.06085403f, 0.18418013f, 0.11785995f, 0.13285272f, -0.00853487f, -0.02061038f, 
    0.12022226f, -0.10571820f, -0.11345317f, 0.06861155f, 0.11808477f, 0.00750640f, -0.07584015f, -0.34865636f, 
    -0.08592664f, -0.11319125f, -0.03249453f, 0.01494036f, 0.22610426f, 0.03818402f, 0.22588135f, 0.07451993f, 
    0.04747411f, 0.02466706f, 0.02077746f, 0.00420794f, -0.05088739f, -0.11239310f, -0.03152950f, -0.10472990f, 
    0.23163590f, -0.09957604f, 0.12592462f, 0.14728379f, 0.02575261f, 0.10733325f, -0.05273865f, -0.03382837f, 
    0.02611894f, 0.05535651f, -0.06730483f, 0.05220454f, 0.04327998f, -0.11374994f, 0.08068646f, -0.12050410f, 
    -0.06572033f, -0.00192691f, -0.16691044f, -0.05582247f, -0.07913588f, -0.07945511f, 0.01684101f, -0.08528554f, 
    0.15820360f, -0.14437075f, 0.27446702f, -0.00248330f, -0.01648868f, -0.00781374f, -0.00071619f, 0.19414787f, 
    0.06313281f, 0.07440524f, -0.07557163f, -0.01426582f, 0.07375427f, -0.12309679f, 0.05512708f, -0.11827634f, 
    -0.05133412f, 0.10114576f, 0.03656300f, 0.15708490f, -0.05916736f, -0.11081833f, -0.11669885f, -0.00886374f, 
    -0.06094288f, 0.17474972f, 0.22811273f, -0.05354489f, 0.00001314f, -0.01578868f, -0.01487293f, -0.27972668f, 
    -0.04584875f, -0.06859952f, -0.02973756f, -0.02807826f, -0.07935946f, 0.28502798f, -0.03756637f, -0.07471656f, 
    0.00082874f, 0.07469055f, -0.04126098f, -0.04347379f, 0.12131058f, 0.07600312f, -0.08026753f, -0.03302257f, 
    0.15781389f, 0.05077800f, -0.19564036f, -0.16718924f, 0.07602295f, -0.01346419f, -0.09825047f, -0.05439184f, 
    -0.16570163f, -0.01611868f, -0.04032797f, 0.04573448f, 0.03372255f, 0.00911012f, -0.18430661f, 0.09394348f, 
    -0.09404426f, -0.02175179f, -0.12183841f, -0.13635433f, -0.06355055f, -0.02490689f, 0.06332335f, 0.10123417f, 
    0.15456705f, -0.10082955f, 0.01069582f, 0.03027490f, -0.00829743f, 0.02465186f, 0.18579094f, 0.16525729f, 
    0.02981572f, 0.02004606f, 0.13729291f, 0.24859565f, 0.28049758f, -0.00980675f, -0.00781789f, -0.00167532f, 
    -0.04269287f, -0.03463696f, -0.03404223f, 0.03588350f, -0.09922780f, -0.05670501f, -0.05153666f, -0.13983972f, 
    -0.10271617f, 0.06298453f, 0.04451279f, -0.02900381f, -0.04449832f, 0.13218968f, 0.03770341f, -0.07836848f, 
    0.23377319f, 0.15488939f, 0.20474336f, 0.42440054f, 0.10891102f, 0.05970297f, 0.07940635f, 0.11718816f, 
    0.10190179f, 0.06358024f, -0.03915618f, 0.03260825f, -0.00960693f, -0.05755896f, 0.02060104f, 0.15934250f, 
    0.26400635f, 0.09137751f, 0.05907774f, 0.01329290f, 0.10889301f, -0.05435826f, 0.13416164f, 0.16426650f, 
    0.08039228f, 0.23421855f, 0.07412951f, 0.14385645f, 0.25238350f, 0.11857377f, 0.12055147f, 0.09943528f, 
    -0.00722147f, 0.08843625f, -0.07265770f, 0.01998251f, -0.03888526f, -0.13936323f, -0.06333242f, 0.00612521f, 
    0.15763293f, 0.10475232f, 0.13316301f, -0.01268319f, 0.18630663f, 0.16924106f, 0.04839825f, -0.01882575f, 
    0.00397146f, -0.02588676f, -0.03724007f, 0.34667543f, 0.34357095f, 0.11584545f, 0.09876678f, -0.00710035f, 
    -0.02551115f, 0.08242577f, -0.06268347f, -0.13741213f, -0.04760517f, -0.06702652f, -0.09143902f, 0.20414637f, 
    0.44218209f, 0.24359217f, -0.12432009f, -0.02382633f, -0.02345543f, -0.07142464f, 0.00209845f, -0.09489056f, 
    0.02741659f, 0.01838927f, -0.03138813f, 0.03174445f, 0.09441753f, -0.09538519f, 0.12010249f, -0.10016052f, 
    -0.24002936f, 0.01757442f, 0.11329938f, 0.19375785f, 0.12763672f, 0.11722622f, -0.19615714f, -0.05826767f, 
    -0.17449392f, 0.04107253f, -0.08876646f, -0.18588425f, 0.08263457f, -0.07494260f, 0.00006664f, -0.03728899f, 
    -0.12362012f, -0.02381109f, 0.02265508f, -0.06273120f, 0.15939227f, 0.06656922f, -0.19748650f, -0.19487868f, 
    -0.15965997f, 0.08468028f, -0.03156013f, -0.15652063f, 0.12942764f, 0.18425658f, -0.06903192f, -0.02073925f, 
    0.04014623f, 0.06135520f, 0.03530913f, 0.26499963f, 0.04338967f, 0.08493552f, -0.06082713f, -0.00480370f, 
    0.08143104f, 0.12956119f, 0.25246084f, 0.24413885f, -0.03654603f, -0.10157617f, -0.01711625f, -0.15961415f, 
    0.17174138f, 0.01537660f, -0.02737947f, -0.26197812f, -0.06341631f, -0.16478908f, -0.01191212f, -0.15656969f, 
    0.51915962f, 0.03017098f, 0.00254413f, 0.07300486f, 0.05177708f, 0.03154152f, -0.06441445f, -0.12966125f, 
    0.04271295f, -0.07648908f, 0.03066609f, -0.04607463f, 0.04825188f, -0.06404375f, -0.19635864f, -0.12961549f, 
    -0.10241980f, -0.00758038f, -0.15282531f, -0.04278643f, -0.06334405f, 0.01980485f, -0.25200620f, -0.21428375f, 
    0.21814011f, -0.05152975f, 0.07505544f, 0.17589754f, 0.11720146f, 0.06762850f, 0.01936592f, -0.08921438f, 
    0.18578155f, 0.21061082f, 0.25905967f, 0.40785870f, 0.18351683f, 0.29977959f, -0.01137256f, 0.19477661f, 
    0.10139239f, 0.04828814f, -0.06531467f, 0.01225225f, 0.10545569f, -0.00803096f, 0.10250236f, 0.21208143f, 
    0.11044511f, -0.12360740f, 0.02062424f, -0.03023594f, 0.04404008f, 0.19757265f, 0.01069740f, 0.00831978f, 
    -0.06197003f, -0.10768288f, -0.06825648f, -0.11007419f, -0.06355935f, -0.18320848f, -0.01599327f, 0.15852082f, 
    -0.00934694f, 0.22100411f, -0.05600369f, -0.02870934f, -0.29348326f, -0.14620087f, -0.08416526f, -0.19025670f, 
    0.27134699f, 0.21750382f, 0.09017761f, 0.17682426f, -0.01838644f, -0.02056577f, 0.06245767f, 0.08473308f, 
    -0.07768593f, -0.01381339f, -0.09185305f, -0.18686901f, 0.00061454f, -0.12127198f, 0.04213294f, -0.24624465f, 
    0.06962149f, -0.09640422f, -0.05972655f, 0.00239923f, -0.16358817f, 0.09092115f, -0.20359161f, -0.28810543f, 
    -0.02291015f, 0.01882360f, -0.10741220f, -0.06106432f, 0.09097721f, -0.01195117f, 0.03260382f, -0.10284902f, 
    0.18695258f, -0.05485610f, -0.09462517f, -0.09752807f, 0.04999372f, -0.06042643f, 0.04034781f, -0.03897527f, 
    0.00538793f, 0.16594154f, -0.07838219f, -0.14604358f, -0.02252121f, 0.01560558f, 0.01057856f, 0.04855571f, 
    0.15392873f, 0.15093766f, -0.01686376f, 0.17085882f, 0.01846668f, -0.13614368f, -0.01122020f, -0.02095181f, 
    0.03227067f, 0.20621671f, 0.15744315f, 0.32881230f, 0.19225943f, 0.01225700f, -0.07697906f, 0.10079962f, 
    0.00156161f, -0.08894134f, -0.06109884f, -0.01223151f, -0.02535547f, -0.03158119f, -0.08949590f, 0.16712138f, 
    -0.08060605f, -0.18674369f, 0.14612883f, 0.10141125f, -0.01782843f, -0.04317256f, 0.13284805f, -0.03945485f, 
    0.05122015f, 0.01854518f, -0.02554475f, 0.16290461f, 0.23630592f, 0.08742929f, 0.26294291f, 0.14909004f, 
    -0.03265290f, 0.10743942f, 0.06226221f, 0.27896833f, 0.07657176f, 0.06756071f, -0.02768582f, -0.05700129f, 
    -0.16905586f, -0.20522964f, -0.21956684f, 0.06528889f, 0.00657774f, -0.06277372f, -0.05280441f, -0.00839108f, 
    0.04495636f, 0.01417924f, -0.02911306f, 0.04028441f, 0.10917570f, -0.00316462f, 0.58809453f, 0.04314855f, 
    -0.19748716f, -0.20235738f, -0.05772841f, -0.13146360f, 0.00765403f, 0.01796403f, -0.06111751f, 0.06898685f, 
    -0.18641816f, 0.55152065f, -0.03396855f, -0.02028521f, 0.03685991f, -0.02208126f, -0.00917463f, 0.01980400f, 
    -0.21373512f, -0.03122767f, 0.06844586f, 0.01552237f, -0.14110343f, -0.16859518f, -0.04374105f, 0.15843780f, 
    -0.02488165f, -0.00126226f, -0.03161985f, -0.04223455f, 0.08589667f, 0.03351837f, -0.11363778f, -0.02167387f, 
    0.37748307f, 0.58361536f, 0.06058092f, 0.08920345f, 0.09034996f, 0.01898098f, 0.01902148f, -0.04474596f, 
    0.17628698f, 0.07995114f, 0.11913901f, -0.00267771f, 0.04704843f, -0.01151670f, 0.09776700f, -0.00499699f, 
    -0.06435568f, -0.15611963f, -0.05986622f, -0.16803773f, -0.08201671f, 0.02018520f, 0.00044473f, -0.00801565f, 
    0.09814140f, 0.17267795f, 0.25549740f, 0.05359226f, 0.06947415f, 0.00002297f, 0.00978314f, 0.02419119f, 
    0.12336060f, 0.05679309f, -0.08174586f, 0.03711728f, -0.46524689f, 0.22730696f, -0.62961537f, 0.31485853f, 
    -0.10721323f, -0.16265737f, 0.04033989f, 0.08935273f, -0.13959204f, 0.07292233f, -0.04009081f, 0.03614886f, 
    0.12883990f, -0.15818064f, 0.08479301f, 0.07846243f, 0.03236805f, 0.13249819f, -0.09333123f, 0.15855981f, 
    0.08808312f, 0.05240753f, 0.04432177f, 0.01835512f, -0.21965379f, 0.08654238f, -0.18811758f, 0.09243513f, 
    -0.03394889f, -0.01105789f, -0.05671824f, 0.00947172f, 0.03821513f, -0.00894672f, -0.03236599f, -0.01276334f, 
    -0.08634450f, 0.18421210f, 0.18186939f, -0.09359304f, -0.12742150f, 0.03164629f, -0.13655004f, -0.13231029f, 
    -0.05240795f, 0.02331678f, 0.06382888f, -0.07407816f, -0.01310859f, 0.00995100f, 0.23711243f, -0.19077457f, 
    -0.05118750f, -0.15245667f, 0.06774729f, 0.07030031f, 0.19022048f, -0.04650583f, 0.03858256f, -0.01200560f, 
    -0.43844923f, 0.08524207f, 0.38154539f, -0.05251790f, -0.09274860f, -0.19432278f, -0.11522713f, -0.19679344f, 
    -0.02387472f, -0.01373296f, -0.00673025f, 0.03881605f, -0.12159163f, 0.04242035f, -0.01290799f, -0.12529384f, 
    0.02016762f, -0.01733696f, -0.08131260f, -0.14993727f, 0.00457933f, 0.25071529f, 0.12982492f, 0.12166509f, 
    0.21011658f, -0.11668631f, 0.29962417f, -0.19303016f, 0.01007235f, -0.15509042f, -0.00665578f, 0.01889793f, 
    -0.00484174f, -0.15869291f, 0.07633934f, 0.16617322f, 0.08136041f, -0.04124954f, 0.01459882f, 0.33723316f, 
    0.07115040f, 0.07863152f, 0.04772495f, -0.07204314f, -0.06124029f, 0.01625845f, 0.02904707f, 0.01287652f, 
    -0.33115807f, 0.35592565f, 0.09004133f, 0.10886224f, -0.11285331f, -0.01662423f, 0.02784695f, 0.11492081f, 
    -0.06643000f, 0.01081597f, 0.01618916f, 0.14205346f, -0.17882271f, -0.08573583f, -0.04977753f, 0.09417591f, 
    0.08176143f, -0.02125800f, -0.03106358f, 0.13928166f, 0.10737874f, -0.03244960f, -0.02501395f, 0.06359954f, 
    0.45828450f, 0.12646842f, 0.07151692f, 0.13408789f, 0.30383319f, -0.01651521f, 0.17088029f, -0.08135580f, 
    0.06352295f, 0.04619516f, -0.08084085f, -0.21182837f, 0.08272117f, 0.01095159f, 0.29187125f, 0.18591143f, 
    -0.05898530f, 0.09772037f, 0.01586269f, 0.19829826f, -0.02786294f, 0.02788206f, 0.05783087f, -0.01320858f, 
    -0.05921476f, -0.13997871f, -0.11954727f, 0.15360200f, -0.14344487f, -0.08126129f, -0.05320290f, -0.08631867f, 
    0.05204064f, -0.17324515f, -0.01430582f, 0.03779370f, -0.11319988f, -0.01353939f, 0.02894988f, 0.20459694f, 
    0.09220141f, 0.11863848f, 0.09185205f, 0.12741528f, -0.05233482f, 0.15569083f, 0.19556186f, 0.05802963f, 
    -0.02818481f, 0.10214175f, 0.31766027f, -0.28565606f, -0.00782023f, -0.02110196f, -0.01623255f, -0.05943444f, 
    0.02112717f, -0.02277321f, 0.03192643f, 0.02249856f, -0.00232231f, 0.10108704f, -0.10147443f, -0.04770849f, 
    -0.10831542f, -0.00285985f, -0.06080533f, -0.09112275f, -0.06205712f, 0.07099714f, 0.02021174f, -0.04423970f, 
    -0.09262883f, 0.10960367f, -0.03800010f, 0.06828517f, -0.03439169f, 0.09933794f, 0.19517022f, 0.00218532f, 
    0.03465154f, 0.06807722f, 0.13838366f, 0.09486223f, -0.23088534f, -0.20447408f, -0.08135948f, 0.11075784f, 
    -0.01887266f, 0.12145342f, -0.02033982f, 0.06231456f, 0.01677442f, -0.00473619f, -0.03349973f, 0.05595532f, 
    0.35768172f, -0.28160080f, -0.05021033f, -0.21023963f, 0.03260123f, -0.06452021f, 0.05876620f, -0.00945308f, 
    -0.06195077f, -0.11173753f, 0.14440940f, 0.12951346f, -0.19408016f, -0.10990342f, -0.23121443f, 0.08621355f, 
    -0.10602637f, -0.07592228f, -0.03071415f, -0.19372961f, -0.03845765f, 0.04262722f, -0.03149681f, -0.00665355f, 
    -0.19226664f, -0.13312390f, -0.02649383f, 0.00261289f, 0.01230122f, 0.07939092f, 0.02771153f, 0.00357769f, 
    -0.07976551f, -0.10600953f, -0.07109613f, 0.00026186f, 0.05363429f, 0.39913169f, -0.00091583f, -0.22764806f, 
    -0.02771709f, -0.02920957f, -0.00812248f, 0.05251529f, -0.15665248f, 0.07866223f, 0.02783082f, -0.05457472f, 
    -0.21381094f, 0.21345036f, 0.04246756f, -0.03326480f, -0.05373195f, 0.02936755f, -0.05665278f, 0.22160040f, 
    -0.09973312f, 0.11153378f, 0.01780475f, -0.09660906f, -0.08212169f, 0.01330154f, 0.08223116f, 0.09899445f, 
    0.10954198f, -0.00961222f, 0.03371950f, 0.13563372f, -0.02889156f, -0.04795810f, 0.10633691f, -0.02203587f, 
    -0.21049996f, 0.33874515f, -0.20322363f, -0.20567419f, -0.02921741f, 0.09391028f, -0.06033394f, 0.10447852f, 
    0.06348217f, 0.10500650f, 0.00775999f, 0.13407150f, 0.39474881f, -0.13799325f, 0.21103927f, -0.27527750f, 
    0.01459047f, -0.11895560f, 0.04517604f, -0.11256180f, 0.11278006f, 0.16210142f, 0.07001828f, -0.01520680f, 
    -0.00735295f, 0.05908203f, 0.00851297f, -0.01558893f, -0.08775453f, -0.17449208f, -0.05581679f, -0.04517185f, 
    -0.02118494f, 0.03465767f, -0.11020963f, -0.00017933f, 0.05954267f, -0.07285363f, 0.06107407f, 0.02218968f, 
    0.05257090f, 0.14755216f, 0.00446189f, 0.08360703f, -0.14461862f, 0.09161112f, 0.03067194f, 0.04887565f, 
    -0.06979769f, 0.04648310f, 0.10880820f, 0.06426726f, 0.04892393f, 0.04297609f, -0.05148961f, -0.04044139f, 
    0.03841252f, -0.05777482f, 0.10595392f, 0.01455621f, -0.04395221f, 0.02445395f, -0.04071544f, 0.13831685f, 
    -0.02932880f, -0.02265641f, 0.07285415f, 0.14269300f, -0.04180022f, -0.06388316f, 0.03823876f, -0.01834407f, 
    -0.02333297f, 0.06890430f, 0.07397803f, 0.04442407f, -0.13206522f, 0.05430442f, -0.08308124f, -0.10617107f, 
    -0.07851055f, -0.00386108f, 0.11068289f, -0.06870621f, -0.16433530f, -0.10203264f, -0.22871943f, -0.03420262f, 
    0.04085432f, 0.11720946f, 0.05521214f, 0.14574453f, -0.05280290f, 0.01697049f, 0.18445176f, 0.01110044f, 
    -0.18788433f, 0.26820716f, -0.10877507f, -0.14350553f, -0.02839877f, -0.10632813f, 0.11648998f, 0.00210262f, 
    -0.02224182f, 0.19554061f, -0.11929165f, 0.00240815f, 0.07908788f, -0.00754464f, 0.16192986f, 0.20675097f, 
    0.05314569f, -0.03487062f, -0.05538183f, 0.07981139f, -0.07821276f, -0.03427411f, 0.03806568f, 0.00507091f, 
    0.14986679f, 0.02490901f, 0.06687099f, 0.12961684f, 0.15074299f, 0.10459290f, -0.08711383f, -0.08674277f, 
    0.00517083f, 0.03275159f, -0.01999249f, -0.11255823f, 0.26052073f, -0.00741800f, 0.18425888f, 0.06032956f, 
    0.05415319f, 0.08946444f, 0.11682091f, -0.01942955f, -0.07649733f, 0.11192206f, -0.00982682f, 0.03022096f, 
    -0.04171088f, 0.26735198f, 0.07323278f, 0.12443068f, 0.03736949f, 0.01700884f, 0.03585394f, -0.18762727f, 
    0.07480179f, 0.08021737f, 0.09666898f, 0.01250659f, -0.13583921f, 0.12271538f, -0.24675643f, -0.05708947f, 
    -0.04893202f, 0.00713248f, 0.04585530f, 0.11776005f, -0.01053945f, 0.10998654f, -0.26630616f, 0.06365134f, 
    0.00628457f, 0.15343396f, 0.12320812f, -0.00070157f, 0.00509966f, 0.09892309f, 0.05900075f, -0.02611276f, 
    -0.02559198f, 0.09815742f, 0.07506108f, 0.09251547f, 0.11761208f, 0.04098922f, -0.20304053f, -0.16554521f, 
    -0.06712667f, -0.00679345f, -0.03848005f, -0.16822693f, 0.10518634f, 0.06315871f, -0.16458316f, 0.20434105f, 
    0.01170952f, -0.11946573f, 0.01136551f, 0.19666880f, 0.02968605f, 0.01566047f, -0.00575999f, 0.14296339f, 
    -0.01057857f, 0.08545069f, -0.06058878f, -0.07085188f, -0.24724692f, 0.30516139f, -0.40456143f, 0.22606319f, 
    -0.08112341f, -0.02881058f, -0.00752200f, -0.09695156f, -0.02833033f, -0.08265124f, 0.07737839f, -0.10425001f, 
    0.17923883f, -0.12704675f, 0.09732693f, 0.21680865f, 0.21046679f, 0.04167768f, 0.09936294f, 0.03500471f, 
    -0.07123289f, 0.08417673f, 0.17095627f, -0.05360926f, 0.15230455f, -0.11405587f, 0.14518918f, 0.07850747f, 
    -0.06970283f, 0.13815400f, -0.12717649f, 0.06845482f, -0.05186683f, 0.22562845f, -0.11405355f, 0.22487827f, 
    -0.05018860f, 0.02534760f, -0.04361607f, 0.01930051f, 0.01296776f, 0.00367422f, 0.02411571f, 0.06257882f, 
    -0.18047751f, 0.08343659f, -0.06569543f, -0.04978755f, -0.02313045f, -0.18115088f, 0.08618892f, -0.07597730f, 
    0.01200483f, -0.16197884f, -0.04679136f, -0.01184083f, -0.04421776f, 0.01258230f, -0.11391406f, 0.16474165f, 
    0.15150803f, 0.16447775f, 0.06272477f, -0.13739234f, -0.09775262f, -0.05157521f, -0.07094508f, -0.04594101f, 
    -0.10157599f, -0.09374940f, 0.10706948f, -0.01683255f, 0.25389013f, -0.19310141f, 0.13779201f, 0.00122474f, 
    -0.02240169f, 0.08549687f, -0.11177233f, 0.13886891f, 0.06787148f, 0.04761324f, 0.17503351f, -0.01406136f, 
    -0.13267171f, -0.18182410f, -0.09429055f, 0.15647757f, -0.02532245f, 0.00112660f, 0.01911591f, -0.02740848f, 
    -0.10415725f, 0.04489261f, 0.03415195f, -0.00254710f, -0.02368956f, 0.10018451f, 0.07295205f, -0.07643568f, 
    0.09358551f, -0.00216919f, 0.06775530f, -0.06879819f, -0.01116481f, 0.23974410f, -0.07513733f, 0.16263705f, 
    0.01429791f, 0.22672327f, -0.19639148f, 0.06392866f, -0.02325686f, 0.02616170f, 0.06069999f, -0.01865297f, 
    0.28471982f, -0.07835478f, 0.07656207f, -0.15019752f, 0.05816042f, 0.18244751f, -0.02978730f, -0.00768465f, 
    -0.06809486f, 0.02189492f, -0.13347247f, -0.05248831f, -0.19732548f, 0.19247086f, 0.11692739f, 0.07703660f, 
    0.28517190f, 0.17910071f, 0.23791911f, -0.04560498f, -0.04419106f, -0.06592927f, -0.08756451f, -0.08217160f, 
    -0.15076180f, -0.00242136f, -0.01452497f, -0.10152388f, 0.04501494f, 0.24817002f, 0.33969742f, -0.05975787f, 
    -0.15097323f, -0.09293699f, -0.11229560f, -0.08850745f, -0.07068992f, -0.07410120f, -0.12655739f, 0.01843851f, 
    -0.10610126f, 0.09847100f, 0.04615144f, 0.12383771f, 0.01965747f, 0.10862273f, 0.04680227f, -0.11398428f, 
    0.06719845f, -0.02107931f, -0.01131690f, 0.03022555f, -0.33802491f, -0.20118342f, -0.16464029f, 0.07378513f, 
    -0.06588294f, -0.04557934f, -0.11841283f, 0.01684264f, -0.04841736f, -0.01153881f, -0.04674757f, 0.08166482f, 
    0.02059370f, -0.01476048f, 0.01145447f, 0.03203677f, -0.01493080f, 0.00233353f, 0.02936575f, 0.01164638f, 
    0.00018088f, 0.04009770f, -0.00241426f, 0.02524767f, 0.01893559f, 0.03599985f, -0.00027086f, -0.00600502f, 
    0.00458162f, 0.02256647f, -0.00524924f, -0.02505154f, 0.01459341f, 0.02561503f, 0.01201544f, 0.00465936f, 
    -0.03199905f, 0.01970491f, -0.02935649f, -0.00874720f, -0.01695463f, 0.00914811f, -0.00065143f, -0.03973316f, 
    -0.00752400f, -0.01602858f, -0.00696580f, -0.03323260f, -0.03602682f, -0.01049751f, -0.01461300f, -0.01193942f, 
    -0.01728205f, -0.02322797f, 0.00303160f, -0.02420447f, 0.00764252f, -0.03214844f, -0.00633302f, -0.03324050f, 
    -0.03161196f, 0.00113658f, 0.02354474f, 0.00040879f, -0.02749682f, -0.01608886f, -0.03607528f, -0.02643355f, 
    -0.02989002f, 0.02189526f, -0.03363992f, 0.02995330f, 0.02655727f, 0.00745256f, -0.02474032f, -0.01534237f, 
    -0.03777202f, -0.01302961f, 0.00168096f, -0.02905592f, 0.00727520f, 0.01214985f, -0.00383239f, 0.03254357f, 
    -0.00367430f, -0.04075787f, -0.03167063f, -0.02755792f, 0.00684950f, -0.03860385f, -0.03330877f, 0.03185750f, 
    -0.02474503f, -0.01964274f, 0.00722474f, 0.01289186f, 0.01768942f, -0.01676459f, -0.02156047f, 0.01222811f, 
    0.01219021f, 0.02217036f, 0.00600739f, -0.00248282f, 0.01850742f, -0.01513244f, -0.03593749f, -0.02752002f, 
    0.02595136f, 0.02650567f, 0.00434410f, -0.03970037f, 0.01528300f, 0.02261853f, 0.02370725f, -0.02838285f, 
    -0.02340198f, -0.02806820f, 0.00681309f, 0.01108665f, 0.00617675f, -0.01406020f, -0.01659200f, 0.00384966f, 
    0.03945057f, -0.01772674f, -0.02990018f, -0.00454625f, 0.01596467f, 0.01109259f, -0.00726629f, 0.03306949f, 
    0.00408466f, -0.00828545f, -0.01423073f, -0.01470897f, 0.03281931f, -0.00299916f, -0.02217688f, 0.00247266f, 
    0.00183422f, -0.02940239f, -0.02010749f, -0.02051800f, 0.00522584f, -0.03284816f, -0.03059438f, -0.03358744f, 
    0.03237253f, 0.03053564f, 0.00331848f, 0.01534950f, -0.03694754f, -0.02314419f, -0.03629781f, 0.01605210f, 
    -0.02635351f, -0.03102588f, 0.01071653f, 0.00448105f, 0.02729912f, -0.03724161f, -0.00988732f, -0.01472501f, 
    -0.02188311f, 0.00314544f, 0.00958941f, 0.02202221f, 0.00733394f, -0.01945118f, 0.02980025f, -0.00472661f, 
    -0.00909248f, -0.02716402f, 0.03011802f, 0.02435904f, -0.02699682f, 0.01911298f, -0.02096796f, 0.02133158f, 
    0.01369611f, -0.03948939f, -0.01096515f, -0.01153307f, 0.02337535f, -0.03684793f, -0.02337601f, -0.00541398f, 
    0.00592700f, -0.03699842f, -0.02769146f, 0.01167786f, -0.01097074f, -0.03173778f, -0.04190676f, -0.00281662f, 
    -0.00615396f, 0.01837216f, 0.01108797f, -0.02128605f, -0.01026674f, -0.04137383f, -0.03973533f, -0.00074268f, 
    0.02161990f, -0.02778887f, 0.03440837f, -0.03482075f, -0.01254984f, -0.01255232f, -0.00054926f, -0.02732248f, 
    -0.02349079f, 0.00253854f, 0.03139150f, -0.01562922f, -0.04541994f, -0.03057038f, -0.01810242f, 0.03489868f, 
    0.02360215f, 0.01704316f, 0.01833424f, -0.00685971f, -0.00979126f, 0.01546919f, -0.02842075f, -0.01738038f, 
    -0.00641058f, -0.03416495f, -0.03275030f, -0.00632422f, -0.00253183f, 0.01381855f, -0.02949246f, -0.01741437f, 
    0.02863788f, -0.02774749f, -0.03004486f, -0.02074135f, 0.02917876f, -0.03494760f, -0.01534780f, -0.00651778f, 
    -0.04108146f, -0.02270664f, 0.01633862f, 0.02389326f, 0.01065418f, 0.02207129f, -0.01416357f, -0.02308792f, 
    -0.03206540f, -0.01365329f, -0.00920648f, 0.01578863f, 0.00529517f, 0.03279710f, -0.03535081f, -0.02503582f, 
    -0.03120988f, 0.02638566f, -0.03038319f, 0.02463717f, -0.00179319f, -0.04484758f, -0.01036398f, -0.01235481f, 
    -0.01688298f, -0.03538806f, -0.02710625f, 0.00482753f, -0.00937468f, 0.01380019f, 0.01083551f, 0.01606352f, 
    -0.00849266f, 0.00911970f, 0.00395952f, -0.02569397f, 0.02719687f, 0.02208432f, 0.01935556f, -0.04464441f, 
    -0.02854266f, -0.01127591f, 0.02762077f, -0.00769428f, 0.02556184f, 0.02942233f, -0.01523844f, 0.00392833f, 
    -0.03597507f, 0.01861601f, 0.01666773f, -0.00744522f, 0.02618654f, -0.02939441f, -0.00773848f, 0.00062085f, 
    0.01138149f, -0.01899402f, -0.03230309f, -0.01213850f, -0.02197869f, -0.04135522f, 0.02804977f, -0.03161881f, 
    0.02755101f, 0.00748939f, -0.00716158f, 0.00428807f, 0.00202551f, 0.00558417f, -0.04130050f, -0.01999380f, 
    0.00014931f, -0.02485153f, 0.02108461f, 0.03341901f, 0.02695440f, -0.03056778f, 0.03137011f, 0.00124361f, 
    -0.01323825f, 0.02305462f, -0.00005952f, -0.04289350f, -0.02773202f, 0.00246754f, -0.01893663f, 0.01120435f, 
    -0.03217092f, -0.01348398f, -0.00837552f, -0.01354117f, -0.00802668f, 0.01670958f, -0.03181632f, 0.01585208f, 
    0.03133591f, -0.00877888f, -0.00229961f, 0.01545436f, -0.01667394f, -0.02074382f, -0.00457070f, -0.02725594f, 
    0.01253968f, -0.02996902f, -0.03744142f, -0.00823760f, 0.01286713f, -0.01353865f, 0.00443843f, 0.02965278f, 
    -0.00352681f, 0.00537611f, 0.00220547f, 0.01636597f, 0.03194712f, -0.00398907f, 0.00240493f, -0.00682849f, 
    -0.03393997f, 0.01534495f, 0.01816940f, 0.00066679f, -0.00686477f, 0.01206232f, 0.01122857f, -0.03386669f, 
    -0.01466351f, 0.02266819f, -0.01964309f, 0.00851023f, 0.01762008f, 0.01596894f, -0.00625743f, 0.02562857f, 
    0.00551789f, 0.02762067f, -0.02329833f, 0.02096310f, -0.01878818f, -0.02650886f, 0.01306629f, -0.01473056f, 
    -0.02376113f, 0.01334611f, 0.02503631f, -0.03236613f, -0.00232878f, 0.01525338f, -0.02421511f, 0.01841674f, 
    -0.01491073f, -0.02204353f, 0.00389526f, -0.04091525f, 0.02204865f, 0.01825383f, 0.02425429f, -0.02017285f, 
    -0.03766274f, -0.04096570f, -0.01943479f, -0.00539627f, -0.00930914f, 0.00932772f, 0.01432831f, -0.02706544f, 
    0.00427047f, 0.01244616f, 0.02959186f, -0.03864178f, -0.03234446f, 0.01811078f, -0.00272860f, 0.00574108f, 
    -0.01808855f, 0.00030556f, -0.03686421f, -0.02118795f, -0.03377091f, -0.01703342f, 0.00426101f, 0.02530528f, 
    -0.03197268f, 0.02341804f, -0.00169602f, 0.00663502f, 0.01943347f, 0.02464494f, -0.00512945f, -0.03615691f, 
    0.01008912f, -0.00915831f, 0.01898613f, -0.00237350f, 0.00001528f, -0.02161385f, 0.02423449f, -0.03315086f, 
    -0.01153363f, 0.02625079f, 0.02756095f, 0.03055344f, -0.01468210f, 0.02735720f, -0.03922084f, -0.01265936f, 
    -0.00122740f, 0.01593497f, -0.01688975f, -0.00128196f, -0.03397384f, 0.00462145f, 0.01188768f, -0.00730041f, 
    0.01033836f, 0.01297989f, -0.00006505f, 0.01580660f, 0.02336911f, 0.02697824f, 0.01350082f, -0.02138824f, 
    -0.01885036f, -0.03150006f, 0.03577946f, -0.03997717f, 0.03415802f, -0.02649716f, -0.03635847f, 0.01067275f, 
    0.01147567f, 0.00377841f, 0.00120693f, 0.01851398f, 0.00398780f, -0.04366996f, -0.01890203f, 0.02040040f, 
    0.00873145f, -0.00645813f, 0.02510124f, 0.00847895f, 0.00027329f, -0.00491559f, 0.01960793f, 0.02133579f, 
    0.03435309f, 0.01422043f, -0.01016147f, -0.01905951f, -0.00347637f, 0.01306921f, -0.03335339f, 0.03220098f, 
    0.02232345f, 0.01832368f, -0.04001183f, 0.01687958f, -0.01296431f, -0.01950129f, 0.00117989f, 0.00250937f, 
    -0.02571346f, -0.03969033f, -0.02866219f, 0.00266950f, -0.00099630f, 0.01685879f, 0.02692477f, -0.00133838f, 
    0.01727127f, 0.02350729f, -0.02122507f, -0.04279390f, 0.02789021f, 0.01139522f, -0.00520191f, -0.01490398f, 
    -0.01596637f, -0.02727512f, -0.01290144f, -0.00257429f, 0.02595227f, -0.00986832f, -0.01636835f, -0.02079543f, 
    -0.02992421f, 0.00524003f, 0.02927988f, -0.02486378f, 0.00716263f, 0.01295945f, -0.01971395f, -0.00006336f, 
    0.00823868f, -0.03302552f, 0.02902807f, -0.03629474f, -0.04171843f, -0.00168141f, -0.00920599f, 0.02808609f, 
    0.02111176f, 0.02699686f, 0.01438972f, -0.00549971f, 0.00816003f, -0.02715822f, -0.02583575f, 0.00627588f, 
    -0.00918146f, 0.02104020f, -0.04214751f, 0.03008879f, -0.01329995f, -0.03283888f, -0.00649543f, -0.03802688f, 
    0.01559096f, -0.01348501f, 0.02362868f, -0.03384442f, -0.03788107f, -0.02999320f, 0.00897209f, -0.03461608f, 
    0.03208704f, -0.01511968f, -0.02085442f, -0.03046924f, 0.01471363f, 0.00856467f, 0.00526298f, -0.04348636f, 
    -0.02478944f, 0.00958659f, 0.00193778f, -0.02122737f, -0.01002918f, -0.02980940f, 0.01214599f, -0.01323641f, 
    0.01039042f, 0.01957049f, -0.00673064f, -0.03965947f, -0.01443641f, -0.01291323f, 0.03711134f, -0.02907457f, 
    -0.02496333f, -0.00077649f, -0.01134960f, -0.01178245f, -0.02343832f, -0.01924331f, 0.00674905f, 0.02375702f, 
    -0.01298037f, -0.00463066f, -0.00828303f, -0.00376703f, 0.01806010f, -0.01878222f, -0.00169098f, 0.02541705f, 
    -0.02890075f, 0.02245475f, 0.02548777f, 0.02181565f, -0.00518174f, 0.00906426f, 0.00414717f, -0.04104222f, 
    -0.00134786f, -0.01725750f, -0.03315049f, -0.03072881f, -0.03175987f, -0.03751228f, -0.00831907f, 0.00527031f, 
    -0.02852524f, -0.02048636f, -0.04058893f, -0.01981633f, -0.02394602f, 0.00410260f, -0.00125403f, 0.00188167f, 
    0.01400342f, -0.03501137f, -0.01102594f, -0.02926670f, -0.02633909f, -0.00990787f, -0.02930713f, 0.03645480f, 
    -0.00284363f, -0.03878366f, -0.03808448f, 0.02670443f, -0.03566406f, -0.03915705f, 0.00253385f, 0.01805660f, 
    0.03245222f, -0.02367903f, -0.03089484f, -0.00089908f, -0.01357459f, -0.04363248f, 0.02505351f, -0.00655378f, 
    0.00938207f, -0.00241470f, -0.02843217f, 0.03003033f, -0.02434463f, 0.01817625f, -0.01690276f, 0.02811640f, 
    0.03069711f, 0.02198382f, -0.01106937f, 0.00498492f, -0.02997074f, 0.01753153f, 0.02931398f, -0.01657650f, 
    -0.03759097f, -0.02845970f, 0.02300249f, 0.01203464f, -0.02506241f, 0.02189633f, 0.01607198f, 0.03783383f, 
    -0.03638381f, 0.02130497f, -0.00601247f, -0.01472706f, 0.00109511f, 0.00985715f, -0.03657738f, -0.03309675f, 
    -0.00008004f, 0.03232671f, 0.00692665f, 0.01748726f, -0.00987340f, -0.02614515f, -0.03005263f, -0.00585805f, 
    -0.00411017f, -0.03466897f, 0.02356962f, -0.02100562f, -0.03797011f, -0.03929741f, 0.00583986f, -0.00483998f, 
    0.01935217f, 0.02840802f, 0.00949561f, 0.02365481f, -0.00930212f, -0.00452232f, 0.02975564f, 0.00581019f, 
    -0.01957804f, 0.00192428f, 0.02098077f, 0.02773708f, 0.00989093f, 0.03723976f, -0.00857840f, 0.03075656f, 
    0.00715221f, 0.00646013f, -0.00582110f, -0.00030634f, -0.03282944f, -0.00170145f, 0.01425698f, -0.01512175f, 
    0.01626425f, 0.01899373f, 0.00521110f, 0.00119741f, -0.02835523f, 0.02583195f, 0.00707638f, -0.03239152f, 
    0.00636719f, -0.00924558f, 0.01167628f, 0.00915920f, -0.00415245f, 0.01083499f, 0.01207226f, 0.02230485f, 
    -0.02135797f, -0.01581081f, -0.03048138f, -0.02871433f, 0.03395140f, 0.01690335f, -0.01381789f, 0.01479161f, 
    -0.02370012f, -0.01825763f, -0.04437059f, -0.00243768f, -0.01929311f, -0.03432617f, 0.00891687f, 0.01325435f, 
    -0.00892478f, -0.01017379f, -0.04160615f, 0.00348367f, -0.00839407f, -0.02975408f, -0.03567175f, 0.01190119f, 
    0.02629856f, 0.02710331f, -0.00315597f, 0.00654949f, -0.02379460f, -0.00325545f, -0.01767541f, 0.01796838f, 
    -0.03285762f, -0.00140116f, -0.01632620f, 0.01451184f, 0.01532116f, 0.00978492f, -0.01911823f, 0.00669103f, 
    -0.01581859f, 0.01169141f, 0.03033364f, 0.01827714f, -0.02908341f, -0.03769404f, -0.02741188f, -0.02296328f, 
    0.02550541f, -0.01452520f, -0.01673292f, -0.02846115f, 0.02419713f, 0.03101335f, -0.03944247f, 0.01010062f, 
    0.01539290f, 0.02493789f, -0.01726727f, 0.00703039f, 0.01793923f, -0.00599503f, -0.02242212f, 0.02378089f, 
    0.01821647f, -0.04293741f, -0.01680416f, -0.01947893f, 0.02672418f, -0.02622985f, -0.03227172f, -0.03484014f, 
    0.02489572f, -0.01447870f, -0.02739386f, -0.02145615f, -0.00631302f, 0.01998602f, -0.00165790f, 0.00017054f, 
    0.02903462f, 0.02394569f, -0.02540384f, -0.03199640f, -0.01809268f, 0.02384268f, 0.02215794f, 0.00270309f, 
    -0.02243130f, -0.02817324f, 0.01445080f, 0.02874971f, -0.04035905f, 0.02258985f, -0.00205184f, -0.02575497f, 
    -0.01077859f, 0.01079702f, 0.01372056f, -0.02283424f, 0.01599638f, 0.03263054f, -0.01592546f, 0.02401441f, 
    -0.03709309f, 0.02366526f, -0.00999525f, -0.01373625f, 0.02730544f, -0.01793247f, -0.01655701f, 0.01696617f, 
    -0.01253467f, -0.00175330f, -0.00159595f, -0.03435841f, -0.04322629f, 0.00722619f, 0.00806348f, 0.01894751f, 
    -0.01831682f, 0.00987051f, 0.02275953f, 0.02451815f, -0.00107171f, -0.03724354f, 0.02274040f, -0.01104083f, 
    0.02515367f, -0.03038891f, 0.01689325f, -0.02394040f, 0.00556338f, 0.02322029f, 0.01503649f, 0.00551037f, 
    0.00259927f, -0.02152741f, -0.02710515f, 0.01379624f, -0.03578607f, 0.00585906f, -0.00025638f, -0.00598887f, 
    -0.02929321f, 0.02176591f, 0.00563266f, -0.01200216f, -0.03597890f, -0.03468699f, 0.01996696f, 0.03134226f, 
    0.01517927f, -0.02653397f, -0.02295771f, 0.02942269f, -0.02407526f, 0.02485890f, -0.02364990f, -0.00831729f, 
    -0.01013339f, -0.00168304f, 0.00310771f, 0.00447594f, -0.03621927f, 0.00366666f, 0.01588247f, 0.00868159f, 
    -0.01250417f, -0.01252810f, -0.03574465f, 0.01064012f, 0.02093289f, 0.01002634f, 0.01608008f, 0.00784514f, 
    0.02439719f, 0.02656141f, -0.01445211f, 0.00761804f, 0.00234942f, -0.00817121f, 0.00408220f, 0.00121862f, 
    -0.01747761f, 0.01190857f, -0.02992737f, -0.03712539f, 0.00353559f, -0.03970687f, 0.00689669f, -0.00195450f, 
    -0.03843507f, -0.00883645f, -0.04000538f, -0.00505744f, -0.03632664f, -0.03619729f, 0.01246525f, 0.00955448f, 
    0.02297768f, 0.02094898f, 0.01620298f, 0.00982911f, -0.03866496f, 0.01033183f, 0.00061348f, -0.01699864f, 
    0.01525112f, -0.01623257f, -0.03460355f, -0.01430679f, 0.02496084f, -0.00524184f, 0.02899834f, 0.02215457f, 
    0.02219901f, -0.00480927f, -0.02536065f, -0.00517455f, -0.02225027f, 0.00084614f, 0.01586953f, -0.00080870f, 
    -0.00493428f, 0.02679238f, -0.00810843f, 0.00047715f, -0.02763613f, -0.00405828f, -0.02458021f, -0.01706720f, 
    -0.04267965f, 0.00872574f, -0.00968089f, -0.01541139f, 0.01235532f, -0.01895127f, -0.03846467f, -0.02496612f, 
    0.03029232f, -0.04157717f, -0.00453424f, 0.02895960f, 0.00949298f, -0.00602929f, -0.03791444f, -0.02951729f, 
    -0.01607241f, -0.00066668f, -0.01444583f, -0.01069068f, -0.00284715f, -0.03925582f, -0.00531807f, -0.04227905f, 
    0.01718978f, 0.02294785f, -0.02302576f, 0.02051709f, -0.01858125f, 0.02631605f, -0.03442864f, 0.02887734f, 
    -0.01608670f, 0.02512666f, -0.03899092f, 0.02618424f, -0.01847951f, 0.02551243f, 0.00993210f, -0.01311390f, 
    -0.00000603f, -0.02182544f, -0.02500895f, -0.00311992f, -0.01919081f, 0.02873186f, -0.02607554f, -0.03621566f, 
    0.02357375f, -0.03032982f, 0.02838349f, 0.00702770f, -0.01654403f, 0.01776621f, -0.01160781f, 0.00894140f, 
    -0.03276188f, 0.01407687f, -0.03370804f, -0.03332668f, 0.01811704f, -0.03541070f, 0.00203639f, -0.00012477f, 
    0.02041274f, -0.00773505f, -0.01530672f, 0.02565720f, -0.02424276f, 0.00289108f, -0.02945354f, -0.00619661f, 
    -0.03135593f, 0.02229849f, 0.01624752f, -0.00058597f, -0.03127893f, -0.03877232f, 0.02441739f, 0.00932923f, 
    0.00046266f, 0.01149637f, -0.00278545f, -0.00261741f, -0.02617293f, -0.03119372f, 0.01124569f, -0.00968861f, 
    0.01526038f, -0.01758702f, -0.01831981f, -0.02946180f, -0.01140547f, 0.02209982f, 0.00877296f, -0.01805015f, 
    -0.02741751f, -0.00918123f, 0.00713377f, 0.00374829f, -0.03966408f, 0.02515297f, -0.02888431f, -0.03930677f, 
    0.02760399f, 0.01740118f, -0.00049393f, -0.02044435f, -0.00255854f, -0.00091438f, 0.02034953f, -0.02002486f, 
    -0.00644265f, 0.01717006f, 0.02443592f, 0.00548471f, -0.01110718f, 0.02596316f, 0.02758383f, -0.03026916f, 
    -0.03337590f, -0.02260056f, -0.01602634f, 0.01955124f, -0.03573946f, 0.02829671f, -0.03619683f, -0.00431355f, 
    -0.04016924f, 0.00147463f, 0.01989098f, 0.02158816f, 0.02965585f, -0.03329901f, 0.02710953f, -0.02622521f, 
    -0.00557718f, -0.03395510f, -0.00994216f, 0.00306540f, 0.01938302f, 0.01941672f, -0.02647222f, 0.02162377f, 
    -0.00413655f, 0.02725792f, 0.02207846f, -0.02062972f, 0.01521640f, -0.02342228f, -0.00359815f, -0.01398343f, 
    -0.03653434f, 0.02513685f, -0.02703498f, 0.02621554f, 0.02830888f, -0.01713350f, -0.00110281f, 0.01030101f, 
    0.02500634f, -0.00033871f, -0.03823570f, -0.02238746f, 0.00025449f, -0.01077451f, 0.01797749f, 0.01740947f, 
    0.01094496f, 0.00712537f, -0.00576698f, -0.02541512f, 0.02957313f, 0.00597066f, 0.02613023f, 0.03006119f, 
    -0.00140706f, 0.00049060f, -0.01827567f, 0.01831531f, -0.00641777f, -0.01642247f, 0.00859102f, -0.01444229f, 
    -0.04161696f, -0.02164218f, -0.02672387f, 0.02074442f, -0.01857963f, -0.03392920f, 0.00273818f, -0.01775644f, 
    -0.02584818f, -0.03321746f, 0.01033689f, 0.01210776f, -0.01382462f, 0.02259002f, 0.01916888f, -0.01680363f, 
    0.01529538f, 0.01580362f, 0.00778362f, 0.00880896f, 0.02163252f, -0.03211103f, 0.01893154f, 0.00673469f, 
    -0.03284440f, 0.01265676f, 0.01669111f, 0.02369633f, -0.03008163f, -0.00410056f, 0.01524681f, 0.01355054f, 
    0.00504993f, 0.00443732f, -0.02025558f, -0.01780978f, 0.02405189f, -0.03462213f, -0.00771255f, 0.01402014f, 
    -0.00851838f, -0.02333498f, 0.00489860f, -0.00630713f, -0.01943629f, -0.01613937f, -0.01505356f, 0.00663655f, 
    -0.03069307f, -0.02949724f, 0.03213813f, 0.02647074f, 0.02691426f, 0.00160631f, -0.02424569f, 0.02690860f, 
    -0.01169298f, -0.00143259f, -0.03970436f, -0.01539804f, -0.00025976f, 0.03633390f, 0.00204665f, 0.00088766f, 
    -0.03268434f, 0.02514295f, -0.03053501f, -0.03832654f, 0.00305925f, 0.01534438f, -0.00867768f, 0.03129480f, 
    -0.02993995f, 0.00994579f, 0.00606965f, -0.01787485f, 0.00351512f, -0.01413166f, -0.02949447f, -0.01090123f, 
    0.01318345f, -0.03082091f, 0.00635739f, 0.02495067f, -0.02107520f, -0.01157490f, -0.01993782f, 0.01020409f, 
    0.02268334f, 0.01155883f, 0.01952172f, -0.01489092f, 0.02025038f, 0.02559478f, 0.00992588f, -0.02409663f, 
    -0.03523521f, -0.01280678f, -0.00226395f, -0.03571042f, -0.00371508f, 0.02843696f, -0.00098409f, 0.02933778f, 
    0.01866299f, 0.01539007f, 0.02648983f, -0.03815833f, -0.00924997f, 0.00066879f, 0.01375605f, -0.03724704f, 
    -0.02057002f, 0.00085705f, -0.02825949f, 0.01279036f, -0.02766704f, 0.00305524f, -0.01689498f, 0.03022210f, 
    -0.01853593f, 0.00147472f, -0.01267354f, 0.03330956f, -0.03505427f, 0.03024280f, 0.02781055f, 0.01825851f, 
    0.01122981f, 0.01223201f, 0.02177355f, 0.01463324f, 0.02831674f, -0.01965938f, -0.01678582f, -0.01313594f, 
    0.02153454f, 0.01012630f, -0.03044542f, -0.02894181f, -0.02097465f, -0.01706291f, -0.00709901f, -0.03875780f, 
    -0.02151331f, 0.00835421f, 0.00948660f, 0.02399565f, -0.02529816f, 0.02970163f, -0.02130720f, -0.02891420f, 
    -0.03181273f, 0.02710662f, -0.04304498f, 0.00468188f, -0.01845378f, 0.02728625f, -0.02599126f, -0.00007206f, 
    -0.00283617f, -0.04034005f, 0.01974548f, 0.02725684f, -0.01429826f, 0.02080375f, -0.03176487f, -0.03143324f, 
    -0.02786443f, -0.01000625f, 0.00445778f, 0.00031174f, -0.02569861f, -0.03584854f, 0.02263713f, 0.00685503f, 
    0.02306699f, -0.01807432f, 0.00130090f, 0.00634185f, -0.01667626f, 0.01995747f, 0.02755339f, 0.01212980f, 
    0.00123772f, -0.01523719f, -0.01312050f, -0.01713069f, 0.01661635f, 0.02521439f, 0.02204485f, -0.02681211f, 
    0.03219597f, -0.02877134f, -0.00379185f, -0.03546734f, 0.02413759f, -0.03701229f, 0.02363158f, 0.01320994f, 
    0.00651720f, 0.00470867f, 0.00940302f, -0.02110644f, 0.01493199f, 0.01114575f, 0.01110778f, 0.00541443f, 
    -0.02896018f, 0.02177454f, 0.01872851f, -0.03873686f, 0.01674495f, -0.02121592f, -0.03270166f, -0.00986427f, 
    0.01917529f, 0.02994584f, 0.00351461f, -0.00560303f, 0.01398028f, -0.03199360f, -0.02547363f, -0.03124622f, 
    0.00891667f, 0.01814334f, -0.01245167f, 0.00317780f, 0.02068366f, 0.01608636f, -0.01358467f, -0.03174785f, 
    0.02255223f, -0.01541419f, 0.02081508f, 0.00703724f, 0.00805198f, -0.00785317f, 0.01917531f, -0.03154792f, 
    -0.02213156f, 0.02361310f, -0.00083268f, -0.01568405f, -0.01910064f, -0.02055076f, -0.00726878f, 0.00474095f, 
    0.02811883f, -0.01833039f, -0.00882298f, 0.02107502f, -0.03192968f, 0.00236629f, 0.00126175f, -0.00100818f, 
    0.02184819f, -0.00437840f, 0.01481906f, -0.00204439f, -0.00528809f, -0.01404263f, 0.01425880f, -0.00117152f, 
    0.00133366f, 0.00383752f, 0.01412804f, 0.00397442f, -0.02163800f, -0.03733420f, -0.02271369f, -0.01120516f, 
    -0.01664273f, -0.04242735f, -0.01389914f, 0.00756707f, 0.02015561f, 0.02903043f, 0.02169811f, 0.02290573f, 
    -0.03620567f, -0.01862800f, -0.00987772f, -0.03356948f, -0.01822899f, -0.02532491f, 0.00372075f, 0.02603819f, 
    0.02543515f, -0.02786344f, 0.00168144f, -0.00291175f, 0.01299644f, -0.00546990f, -0.02004274f, 0.01955204f, 
    0.00051577f, -0.00921709f, 0.00980862f, 0.00993618f, -0.03063493f, 0.01586156f, 0.01773427f, -0.01809747f, 
    -0.01201406f, -0.04044831f, 0.00325804f, 0.00182773f, 0.02438487f, -0.02748768f, -0.03201357f, 0.00212260f, 
    0.00880251f, -0.02832107f, 0.02844450f, -0.01902217f, -0.01031058f, -0.00003844f, -0.01864746f, -0.02551877f, 
    -0.00512327f, -0.02128180f, 0.02378271f, -0.03621259f, -0.01186172f, -0.00363049f, -0.03781764f, 0.01732999f, 
    0.01737938f, -0.02140971f, 0.00150966f, -0.00074355f, 0.01398969f, -0.03007565f, 0.00239472f, 0.02576321f, 
    0.00890193f, -0.02403124f, 0.01226611f, 0.00798019f, -0.01656030f, -0.02458264f, -0.01563526f, -0.02155961f, 
    0.01839925f, -0.02210497f, -0.02155647f, 0.00784641f, -0.00316774f, -0.02036007f, -0.03619292f, 0.00723392f, 
    0.01066647f, 0.02554384f, 0.02106052f, -0.03804631f, 0.00544744f, -0.01516667f, -0.01520958f, -0.03875299f, 
    0.03410820f, -0.02719507f, -0.00944168f, -0.00783787f, -0.02614044f, -0.03035401f, -0.02442713f, 0.00347532f, 
    -0.01352733f, -0.01661441f, 0.02882228f, 0.00475674f, 0.00596689f, -0.03286985f, -0.03824485f, -0.00068821f, 
    -0.03937398f, -0.03609538f, 0.01732362f, -0.01435040f, 0.00902853f, 0.00100796f, -0.00915829f, -0.02141486f, 
    0.02314989f, -0.16776483f, -0.06759851f, -0.03485299f, -0.00266735f, 0.06037341f, 0.02625544f, 0.08543482f, 
    0.00884909f, 0.00033956f, 0.07689284f, -0.04453130f, 0.24240525f, 0.05477329f, -0.06820895f, 0.24593040f, 
    0.04740150f, 0.10956180f, 0.28110871f, 0.09194241f, -0.00074428f, -0.00169533f, -0.02781296f, 0.03865892f, 
    -0.10984020f, 0.08395635f, -0.05911990f, -0.14404050f, -0.08378962f, 0.11527302f, 0.02058524f, -0.01594413f, 
    0.17908928f, -0.19682956f, -0.03309959f, -0.08883662f, 0.14536180f, 0.04330619f, -0.08753082f, -0.18514833f, 
    0.02816666f, -0.01954615f, 0.07147633f, 0.11193967f, -0.02139838f, 0.01093471f, 0.14234352f, 0.05119722f, 
    0.47313589f, -0.21536371f, 0.00286274f, -0.10273919f, 0.14374001f, -0.07694466f, -0.00780218f, -0.06297603f, 
    0.11145384f, -0.01751995f, 0.01807389f, 0.07678668f, 0.04112577f, 0.06610501f, -0.12074139f, 0.07413577f, 
    0.07167371f, -0.01112037f, -0.00030885f, -0.07000963f, -0.06774072f, -0.05814064f, -0.01610100f, -0.04419335f, 
    0.23111047f, 0.09845861f, 0.11749060f, 0.14332296f, -0.04208316f, -0.01414878f, 0.02298487f, 0.00043494f, 
    -0.02723977f, -0.06736983f, 0.08540250f, 0.08775844f, -0.03771741f, -0.09092166f, 0.19027422f, -0.00955316f, 
    0.15533444f, 0.19671270f, 0.03890093f, -0.06547479f, -0.07226640f, -0.07007773f, -0.06615366f, -0.00788859f, 
    0.05896322f, -0.07072114f, -0.01617857f, -0.04489917f, -0.06846292f, -0.00593539f, 0.07508880f, 0.07071852f, 
    0.11666477f, -0.07234479f, -0.07998794f, 0.16129053f, 0.04226081f, -0.20199050f, 0.04629983f, 0.16438444f, 
    0.04236682f, 0.17926395f, 0.07735171f, -0.01692071f, 0.05239439f, 0.09636296f, 0.05418334f, 0.02481528f, 
    0.26651406f, -0.03439207f, 0.25682169f, -0.08523871f, -0.00752947f, 0.02326453f, 0.02680068f, 0.03335052f, 
    0.03970841f, -0.00543236f, -0.02057697f, -0.14398463f, -0.03500916f, 0.04804748f, -0.02496389f, 0.05520951f, 
    -0.05043714f, 0.08246460f, 0.17316081f, 0.04292361f, 0.07300818f, 0.09915838f, 0.02224129f, 0.13736495f, 
    0.47133943f, 0.06196696f, -0.21880911f, 0.23841596f, 0.09677020f, 0.11971081f, 0.06530767f, 0.00027867f, 
    -0.05710409f, -0.02826627f, -0.03815768f, -0.00144348f, 0.05946558f, 0.04850575f, 0.02105640f, 0.02029922f, 
    0.06590746f, 0.01286310f, -0.08742490f, -0.02138020f, -0.03734354f, 0.00114271f, -0.06715603f, -0.13602982f, 
    -0.21971625f, 0.08791091f, -0.10931841f, 0.09646400f, 0.08698966f, 0.09831975f, 0.13703671f, -0.10433360f, 
    -0.01052433f, -0.05374055f, -0.01647726f, 0.04523974f, -0.09269860f, -0.11552992f, -0.26891506f, -0.19200605f, 
    -0.09419049f, -0.06201565f, 0.03509809f, 0.10399745f, -0.01480830f, 0.13310163f, 0.04312814f, 0.08936221f, 
    0.39805603f, -0.04830006f, 0.21915437f, 0.06378234f, 0.04520553f, 0.12489375f, -0.09659614f, 0.08403821f, 
    0.10151666f, 0.05230855f, 0.04957621f, 0.12415134f, 0.35709608f, -0.00694257f, -0.07906520f, -0.23483901f, 
    -0.22591229f, -0.12898444f, 0.09060498f, 0.10931976f, 0.00094081f, 0.00925408f, -0.00573272f, 0.02942976f, 
    -0.16918515f, -0.18342428f, -0.05569289f, -0.07234613f, 0.21509102f, -0.06676019f, 0.18195114f, -0.10742694f, 
    -0.04451463f, -0.09215700f, 0.08549424f, 0.03861766f, -0.05307951f, -0.09965682f, -0.23048657f, -0.39272109f, 
    -0.06469265f, -0.00041600f, -0.08634493f, 0.03008781f, 0.05192430f, 0.10962702f, 0.07692194f, -0.13912201f, 
    0.11436252f, -0.07129209f, -0.00781812f, -0.26960006f, -0.09764566f, -0.07417239f, -0.13564025f, 0.07832519f, 
    -0.00609505f, -0.02369295f, 0.03417620f, -0.01236315f, -0.19336440f, -0.01960131f, -0.09864023f, -0.12085255f, 
    -0.04608824f, -0.03145473f, 0.05775789f, -0.08198297f, 0.08009813f, 0.02770764f, 0.00375596f, 0.01626595f, 
    0.24047732f, 0.19417547f, -0.19355352f, 0.15139706f, -0.01990657f, 0.02101131f, 0.12419966f, -0.00760333f, 
    0.00958308f, -0.04704868f, -0.07747248f, -0.01572395f, 0.12081650f, 0.03551241f, 0.15466173f, 0.10890736f, 
    0.04101017f, 0.00295766f, -0.04322727f, -0.09119930f, -0.03311965f, -0.00499600f, -0.03762029f, -0.03986106f, 
    0.17000940f, 0.05183943f, 0.06045158f, -0.12023886f, -0.01202232f, -0.10230533f, -0.03165286f, -0.06530412f, 
    0.00318612f, 0.05296127f, -0.00641437f, -0.03284173f, 0.06388012f, 0.06896129f, 0.04159966f, -0.08924153f, 
    -0.04673068f, -0.06390962f, 0.05477021f, 0.08029006f, -0.01859326f, 0.00751541f, -0.00632183f, -0.01684958f, 
    0.08848471f, 0.13841681f, 0.16805296f, 0.07448038f, -0.07861161f, 0.01058155f, -0.07054351f, -0.07689925f, 
    -0.00401548f, -0.01153796f, 0.15320100f, -0.15751842f, 0.02872948f, -0.15711457f, -0.25430399f, 0.00006634f, 
    0.11407670f, -0.10043025f, 0.29196915f, 0.08956813f, -0.05999167f, -0.03872193f, -0.05656438f, -0.09245696f, 
    -0.03523806f, -0.00654010f, 0.04887245f, -0.12178208f, -0.06266320f, -0.06160611f, -0.05721113f, 0.03340196f, 
    -0.00951658f, -0.00510192f, -0.08528080f, -0.09179647f, 0.15446615f, 0.15516874f, 0.17873257f, 0.21360214f, 
    -0.00670174f, -0.00579262f, -0.03623357f, -0.04163800f, 0.06236541f, 0.04509558f, 0.15239742f, -0.00612887f, 
    -0.15814106f, -0.13283430f, -0.43947887f, -0.28643811f, -0.17706151f, 0.06659298f, -0.00574865f, -0.01942536f, 
    -0.01697711f, -0.08496623f, 0.07260972f, 0.07097186f, -0.07081108f, -0.21973985f, -0.31680617f, -0.32897210f, 
    -0.03877464f, -0.02879698f, -0.04854957f, 0.00621339f, -0.00388253f, -0.08334111f, -0.00368719f, 0.16581282f, 
    0.08263093f, 0.08189414f, 0.29745439f, 0.00369582f, 0.01386688f, -0.17984962f, 0.07719906f, -0.10226466f, 
    0.02882363f, 0.00911801f, 0.10229866f, -0.02269453f, -0.15256758f, 0.07740464f, -0.15421873f, -0.03964778f, 
    -0.04764204f, 0.07204217f, 0.16767327f, 0.02446332f, -0.02858295f, -0.05964091f, 0.00815461f, 0.05500652f, 
    0.06110991f, 0.06478543f, 0.15766639f, 0.08714318f, 0.05201805f, -0.00415977f, -0.03017347f, -0.04977476f, 
    -0.02006202f, -0.04904190f, 0.03247903f, -0.02577418f, 0.06218628f, -0.15593421f, 0.09255876f, -0.00080184f, 
    -0.02801144f, 0.23333605f, -0.14795375f, 0.07187595f, 0.10203509f, -0.09675740f, 0.03626234f, 0.02670743f, 
    0.15507340f, -0.19158921f, 0.06917319f, 0.05816606f, -0.15094979f, 0.11129321f, -0.03981761f, 0.02252222f, 
    0.12178983f, -0.00562045f, 0.14965875f, 0.12030260f, -0.10306939f, -0.15566349f, -0.11430029f, -0.08605054f, 
    0.06974534f, -0.05741726f, -0.07747627f, 0.02651509f, -0.11758850f, -0.12291396f, 0.04072687f, 0.00455061f, 
    0.11108048f, -0.05707471f, 0.09329320f, 0.07363486f, -0.12995094f, 0.02896839f, 0.23828833f, -0.05922472f, 
    -0.02904589f, -0.09556101f, 0.07343206f, -0.10640930f, -0.01005187f, -0.10699110f, -0.20066655f, 0.03547882f, 
    0.10520624f, 0.02332408f, 0.01411198f, 0.09610967f, 0.12563181f, 0.03433343f, 0.02336329f, 0.06768073f, 
    0.09082379f, -0.16893953f, 0.06840383f, 0.20963416f, 0.13929099f, 0.10655376f, 0.20702815f, 0.13556337f, 
    0.10058929f, 0.08882762f, 0.01864107f, 0.02283069f, -0.03658880f, -0.08955418f, -0.22593693f, -0.20077416f, 
    -0.03775865f, -0.08410147f, -0.08026615f, 0.02679421f, -0.06160387f, -0.08447991f, -0.02598647f, 0.02107263f, 
    -0.10550639f, -0.07871042f, -0.04227887f, 0.01758366f, -0.06947988f, -0.03781033f, 0.08330393f, -0.15377687f, 
    0.00066989f, -0.13943559f, 0.02100804f, 0.09096222f, -0.15500347f, -0.04485361f, -0.19768393f, -0.03620882f, 
    -0.04653583f, -0.03447824f, -0.11074262f, -0.03241336f, -0.04617581f, 0.02789262f, 0.03632187f, 0.06981397f, 
    0.27875847f, -0.10811692f, 0.06881414f, -0.19659132f, -0.07088095f, -0.09793378f, -0.12466341f, -0.07408099f, 
    -0.00474287f, 0.11918014f, 0.19347174f, 0.00802867f, -0.09970212f, 0.00115730f, -0.29506981f, -0.26830566f, 
    0.00383612f, -0.08343861f, -0.10970296f, -0.00197104f, 0.08083496f, -0.04407262f, 0.04500910f, 0.03703293f, 
    -0.09962989f, 0.02156551f, 0.06022945f, 0.01478497f, 0.04806808f, -0.01495365f, -0.05941965f, -0.03695625f, 
    -0.12195086f, -0.09354150f, 0.08803043f, -0.07326697f, 0.05807421f, 0.12680891f, 0.19220556f, 0.16880928f, 
    0.04005916f, 0.03595495f, -0.04480271f, -0.04793086f, -0.00353636f, 0.11552274f, 0.06812493f, 0.06772527f, 
    -0.02960694f, -0.03313424f, 0.03956884f, -0.14480962f, 0.00351744f, 0.05503356f, 0.06904273f, 0.17834155f, 
    0.02772000f, 0.04576280f, 0.12085809f, 0.03452963f, 0.03358806f, -0.13126652f, 0.14936143f, -0.02550405f, 
    0.05292194f, -0.06078747f, -0.00527109f, 0.01884904f, 0.02753513f, 0.03409446f, 0.03156530f, -0.05155019f, 
    0.16182226f, -0.16258882f, -0.16864537f, -0.17806454f, -0.06565026f, -0.06964566f, -0.09553979f, -0.02543242f, 
    -0.03074612f, -0.03507755f, -0.00590293f, 0.01434808f, 0.01707994f, 0.02994985f, 0.00896944f, -0.09737042f, 
    0.02910187f, 0.14244096f, -0.01279663f, 0.16159350f, 0.05810248f, 0.08645172f, -0.03510251f, -0.03403346f, 
    -0.06168360f, -0.08327940f, 0.15376519f, 0.09384461f, 0.00519436f, 0.01859352f, -0.02425953f, 0.00793845f, 
    0.07743804f, -0.04118655f, 0.10681864f, 0.03681720f, -0.07723626f, 0.06949620f, -0.09804010f, 0.00639792f, 
    0.10603856f, 0.05720149f, 0.14136674f, 0.05271026f, 0.08339200f, 0.02763041f, 0.01155734f, -0.00323044f, 
    0.10157127f, 0.05730936f, 0.13609299f, 0.18082365f, 0.01487861f, 0.05567861f, -0.02092226f, -0.00232911f, 
    -0.03081365f, -0.06761879f, -0.05733031f, 0.00556475f, 0.08248391f, -0.03484443f, -0.04407515f, -0.08111268f, 
    -0.06065153f, -0.00655800f, 0.05482892f, -0.02168152f, 0.00421559f, -0.01987937f, -0.06980581f, -0.15912938f, 
    -0.07711517f, 0.14262567f, -0.00721429f, -0.30251962f, -0.07646663f, -0.08329616f, -0.01129997f, -0.01528850f, 
    -0.02819231f, -0.02978873f, -0.04460090f, -0.06304938f, -0.01922820f, -0.01323680f, 0.07637490f, -0.04083539f, 
    0.11258461f, -0.03046017f, -0.05452980f, -0.06828161f, -0.03754779f, 0.01848033f, -0.12303244f, -0.03187540f, 
    -0.13031502f, 0.00656189f, 0.16058835f, 0.08776704f, -0.00437918f, -0.01220903f, 0.00978934f, -0.00560993f, 
    0.28712183f, 0.00719139f, 0.05603432f, 0.00504750f, 0.07882021f, 0.03849109f, 0.07141732f, 0.14582242f, 
    -0.00674650f, 0.03138255f, 0.02761918f, -0.03528397f, 0.07497351f, 0.12880565f, -0.05924140f, 0.07476967f, 
    0.08632816f, -0.00746077f, 0.09248471f, -0.00610756f, -0.04825116f, 0.01510520f, 0.07379963f, 0.06482722f, 
    -0.07874428f, -0.11400814f, 0.13823232f, 0.08782794f, 0.17047048f, 0.07154946f, 0.24328823f, 0.35742494f, 
    0.01358763f, 0.09991558f, 0.01885518f, 0.02778468f, -0.02944284f, 0.04376259f, 0.01943057f, 0.05031888f, 
    0.06985742f, -0.04434089f, 0.09544227f, -0.29345298f, -0.02444175f, -0.04780460f, 0.03255975f, -0.00372501f, 
    0.13884352f, 0.05077996f, 0.04190080f, 0.01919268f, 0.34108213f, 0.39285249f, 0.04315990f, 0.01213627f, 
    -0.04606308f, -0.10916682f, -0.04151516f, 0.00666968f, -0.09471891f, -0.06154387f, -0.08584023f, -0.08815227f, 
    0.00999267f, -0.01513358f, 0.01598865f, 0.03074803f, 0.01807106f, -0.01272930f, -0.01161564f, 0.00290017f, 
    -0.00466331f, 0.02245848f, 0.01234890f, 0.01800401f, -0.02177652f, 0.00463496f, 0.01423552f, 0.02186134f, 
    -0.01648470f, -0.02624851f, 0.03292805f, -0.00399759f, 0.02864430f, 0.00792809f, -0.03547442f, -0.00669267f, 
    -0.00299567f, -0.02414681f, -0.02885259f, -0.03308401f, 0.02932459f, 0.01548287f, -0.00820251f, -0.03265831f, 
    0.00629211f, -0.01865982f, -0.02180594f, 0.03571778f, -0.01409624f, -0.00597538f, -0.02816259f, 0.01462697f, 
    -0.03676251f, -0.01702295f, 0.00678911f, -0.02526504f, 0.02348581f, -0.01387387f, 0.01359413f, 0.00463939f, 
    -0.00568109f, -0.00433074f, -0.02436493f, 0.02563469f, 0.01323283f, 0.03393877f, -0.01344420f, -0.01677795f, 
    0.02935388f, 0.01213118f, -0.02381896f, -0.03290508f, -0.00130563f, 0.02977253f, -0.03938351f, -0.01436648f, 
    0.00488792f, 0.01941547f, -0.03509375f, 0.02861420f, -0.01920817f, -0.03941640f, -0.01785854f, -0.00212593f, 
    -0.00251889f, -0.01973631f, -0.00122395f, -0.03414863f, 0.00217306f, -0.01052859f, -0.03390350f, 0.00266040f, 
    0.01603181f, -0.01037180f, 0.00023686f, -0.01496006f, 0.01852822f, 0.02025632f, -0.01032252f, -0.02796462f, 
    -0.00525823f, 0.02016283f, -0.01394532f, -0.01868973f, -0.02967225f, 0.02381347f, -0.01697253f, -0.01509385f, 
    0.02552927f, 0.01819753f, 0.00583469f, -0.03342712f, -0.00633706f, 0.01917136f, 0.00844613f, 0.02666645f, 
    -0.02608759f, 0.01001981f, 0.00519848f, -0.00380665f, 0.02886698f, -0.00059963f, -0.02895025f, 0.01709272f, 
    0.02780900f, 0.00326651f, -0.00078595f, -0.02532369f, -0.00622061f, -0.02638597f, -0.02878637f, 0.00154600f, 
    -0.01798089f, 0.00437347f, 0.01866428f, -0.03273458f, 0.01919720f, 0.00273175f, 0.02658721f, -0.02719893f, 
    -0.00147373f, 0.00884503f, -0.02608457f, -0.00691494f, -0.00678681f, -0.00642694f, -0.02851672f, 0.00213829f, 
    0.02788827f, 0.00941574f, -0.00437944f, -0.00149624f, 0.02789493f, -0.00828631f, 0.01035927f, 0.02712768f, 
    0.02428155f, 0.01232126f, -0.01424055f, 0.02736879f, -0.03162376f, -0.01953445f, 0.00089903f, -0.00969112f, 
    -0.00045492f, 0.00950395f, -0.00452865f, 0.00282331f, -0.02869899f, -0.01347419f, -0.02382100f, 0.02821051f, 
    -0.00131079f, -0.02693871f, 0.02561717f, 0.01532290f, 0.00182516f, -0.01186189f, 0.02275341f, -0.00596372f, 
    0.01436482f, 0.03753886f, 0.00241691f, 0.03793993f, -0.02716460f, -0.04219079f, -0.02192484f, -0.02168280f, 
    -0.01755529f, 0.02540049f, 0.03070558f, 0.00629493f, -0.00664279f, 0.01173720f, -0.04077420f, -0.03840432f, 
    0.01974905f, 0.00382685f, -0.03270609f, 0.02256138f, -0.01832142f, -0.00968446f, -0.03369623f, -0.03476303f, 
    -0.01634092f, -0.00951627f, 0.02198456f, -0.02656117f, -0.02126663f, -0.02683165f, 0.00878251f, 0.00119010f, 
    -0.00449356f, 0.00094565f, 0.01428397f, 0.01805001f, 0.02688237f, -0.00728113f, -0.01189585f, 0.02770262f, 
    -0.00399210f, -0.00432047f, 0.02564213f, -0.01687984f, -0.01767970f, -0.00386187f, -0.00598780f, 0.02150763f, 
    -0.02583248f, -0.01487852f, -0.04342791f, 0.03709293f, 0.02473278f, 0.00747536f, 0.02008415f, -0.02652479f, 
    0.02881375f, -0.00255100f, -0.02471519f, 0.02094932f, -0.00367409f, -0.04242820f, 0.02807770f, -0.03020618f, 
    -0.02761828f, -0.03851486f, 0.01818205f, 0.02557348f, -0.00270462f, -0.02931519f, -0.03431396f, -0.00277674f, 
    0.01540466f, -0.00342437f, -0.01750733f, -0.03750261f, -0.02491372f, 0.03227174f, -0.02636838f, -0.00945470f, 
    -0.01440915f, 0.02979207f, -0.03069370f, -0.02108078f, 0.02757479f, -0.01515400f, -0.02163173f, -0.02332656f, 
    0.00633891f, 0.00985444f, -0.02088869f, 0.02897545f, -0.01163722f, -0.02700087f, -0.02148702f, 0.00143954f, 
    -0.03475159f, 0.01774947f, 0.00142793f, -0.02557241f, -0.01471442f, -0.01809783f, -0.00068656f, 0.00014881f, 
    0.00521563f, -0.02171950f, -0.00642897f, 0.00306610f, -0.00545632f, 0.00306901f, -0.00454969f, -0.00796509f, 
    0.01908203f, 0.01230080f, -0.01320253f, -0.03046698f, -0.01050174f, 0.01141637f, 0.02565945f, -0.02503798f, 
    -0.03691510f, -0.03683937f, -0.03192043f, -0.01711352f, -0.01385359f, -0.02743728f, -0.00799691f, -0.03093282f, 
    0.01055683f, 0.00064390f, -0.01397872f, 0.02507070f, -0.00478915f, -0.00188593f, -0.02164704f, -0.01951499f, 
    -0.00327335f, -0.04016431f, -0.03290840f, -0.02938969f, -0.02350731f, 0.01020302f, 0.02618255f, 0.02972532f, 
    -0.00282976f, 0.02397515f, -0.01056061f, -0.00679915f, -0.01889623f, -0.01949606f, 0.01858010f, -0.01236875f, 
    -0.00311699f, -0.01409906f, 0.00573375f, 0.02482468f, -0.01669884f, -0.01532543f, -0.01598559f, -0.00542978f, 
    -0.00447673f, -0.03346958f, 0.03128031f, 0.00861812f, -0.01892978f, -0.01366542f, 0.01060053f, -0.00648904f, 
    -0.00359352f, 0.00548795f, 0.00806437f, -0.02413168f, 0.01359550f, -0.03259051f, -0.01622971f, -0.01082927f, 
    -0.01071385f, 0.01948109f, 0.01392615f, 0.02502834f, -0.01557273f, 0.03248007f, 0.00722086f, 0.01745491f, 
    0.00924344f, -0.01683371f, -0.01640823f, 0.02259585f, 0.02627722f, 0.02632715f, -0.03950653f, 0.01689985f, 
    -0.01138277f, 0.00000634f, 0.00391627f, -0.04262118f, 0.01528019f, -0.01231909f, -0.02718995f, 0.01797369f, 
    -0.02189714f, -0.00041613f, 0.01908342f, -0.03791333f, -0.00294489f, 0.01626988f, 0.02158126f, -0.01179438f, 
    -0.02926010f, 0.01477121f, -0.00235489f, 0.02231611f, 0.01068065f, 0.00891158f, 0.00470565f, 0.00655305f, 
    -0.01121296f, 0.02493735f, -0.03918972f, -0.01838918f, 0.01174925f, 0.00191812f, -0.02656216f, -0.02961225f, 
    -0.04322711f, -0.02694183f, -0.00423033f, 0.00001704f, 0.00151505f, 0.01933537f, -0.01025173f, -0.02631441f, 
    -0.01571250f, -0.02670144f, 0.00947539f, 0.01238939f, -0.02455229f, -0.00491381f, -0.00510521f, 0.01403982f, 
    -0.00252374f, -0.01791172f, -0.01764976f, 0.01530908f, -0.03510719f, 0.02132235f, 0.01061700f, 0.02856451f, 
    -0.02190569f, 0.03612261f, 0.03308554f, 0.03203354f, 0.00762437f, 0.02219866f, 0.01526111f, -0.01196777f, 
    -0.00972216f, -0.04147791f, -0.02170275f, 0.02251231f, -0.00909832f, 0.02471747f, -0.02677732f, -0.03644953f, 
    0.01901399f, 0.01465491f, -0.01493577f, 0.00647544f, -0.03256288f, -0.01367246f, 0.02618258f, 0.01851105f, 
    0.02273306f, -0.01358041f, 0.01166174f, 0.00189021f, 0.00527314f, 0.00909349f, -0.00406089f, -0.00324931f, 
    -0.00349102f, -0.03422626f, -0.02076841f, 0.01343433f, -0.01639436f, -0.03648887f, -0.00936238f, -0.01769318f, 
    0.01975382f, -0.00250432f, -0.00876413f, 0.02928118f, 0.00555966f, 0.01135725f, -0.02248095f, -0.02510492f, 
    0.02718279f, 0.00772352f, -0.00827111f, -0.01662574f, -0.01522135f, 0.00468830f, -0.00008331f, 0.01242332f, 
    0.01251238f, -0.00111349f, -0.00730426f, -0.02573310f, 0.03094789f, -0.01901766f, 0.01271568f, 0.02394896f, 
    0.03042166f, -0.01234644f, 0.01286280f, 0.01853352f, -0.03865566f, 0.00111788f, 0.01903587f, -0.00364383f, 
    -0.03864455f, 0.03251188f, -0.03769981f, 0.02932168f, -0.00013877f, -0.02534503f, -0.01585216f, -0.03075018f, 
    -0.00534477f, 0.01823876f, -0.02500005f, -0.00996924f, -0.03118057f, -0.02057064f, -0.01335258f, 0.01836863f, 
    -0.02983878f, -0.03226044f, -0.00773054f, -0.02916620f, 0.01775716f, 0.00128587f, -0.03515849f, -0.00175289f, 
    -0.00832417f, -0.01801294f, 0.01048527f, 0.01461256f, -0.04017612f, -0.02726748f, -0.01480697f, -0.01242972f, 
    0.02859783f, -0.04221288f, 0.02600815f, -0.01669573f, 0.02965297f, -0.00702741f, -0.01263244f, 0.02613410f, 
    -0.01526639f, 0.01741129f, -0.00189810f, -0.02595085f, 0.00680754f, -0.04166048f, -0.01550246f, -0.02539288f, 
    -0.00815504f, 0.03184044f, -0.02215550f, -0.00373262f, 0.00380441f, -0.02395704f, -0.00497328f, -0.03019720f, 
    -0.02007875f, 0.00607146f, 0.01070862f, 0.02090792f, 0.01368055f, -0.02651904f, -0.01865690f, -0.01804590f, 
    -0.02065805f, -0.03304415f, 0.01514133f, -0.00664289f, -0.03494464f, -0.01172186f, 0.01660903f, 0.01199962f, 
    -0.01686312f, -0.03480893f, -0.01116594f, 0.01821395f, 0.01729804f, 0.01590962f, 0.04225442f, 0.02253193f, 
    0.03013828f, -0.01915456f, -0.02640679f, 0.01173135f, -0.02134999f, -0.03684778f, -0.02563417f, 0.03082970f, 
    0.00125821f, 0.02796516f, 0.00337244f, 0.02056489f, -0.02235105f, -0.03094677f, 0.00860012f, 0.00078919f, 
    0.01188280f, -0.00085992f, 0.03320182f, -0.01488588f, -0.00408878f, 0.00076321f, 0.02043764f, 0.00119081f, 
    -0.01575340f, -0.02520471f, -0.01677735f, 0.00027419f, -0.00175709f, -0.03304972f, 0.00952859f, -0.03758525f, 
    -0.01528082f, -0.02843273f, -0.01195944f, -0.03599954f, -0.03774394f, 0.01798818f, 0.00848886f, 0.03837524f, 
    -0.01563103f, 0.00441312f, 0.01149502f, 0.00139807f, 0.03023919f, -0.00804923f, -0.02597044f, 0.00617579f, 
    -0.02281021f, 0.02593913f, -0.00418110f, 0.00479118f, -0.03727433f, 0.02970082f, -0.03864587f, 0.00536148f, 
    0.00951059f, -0.03317682f, -0.00082149f, 0.01343241f, -0.02897864f, -0.03422186f, -0.03332024f, -0.02851644f, 
    -0.01949595f, 0.02568727f, 0.00626456f, -0.00837940f, -0.02253356f, 0.00076722f, -0.00404058f, -0.00657593f, 
    -0.00956763f, -0.02930502f, -0.00637419f, 0.02822482f, -0.00129755f, 0.02890225f, 0.02130760f, 0.02130634f, 
    -0.00037289f, 0.02550996f, 0.01509682f, -0.00289084f, 0.02909276f, 0.00747097f, -0.01473233f, -0.00447685f, 
    -0.03547508f, 0.00678515f, 0.00284191f, 0.01162748f, -0.02635468f, -0.00301864f, -0.03194430f, -0.02003186f, 
    -0.03387351f, -0.01811993f, 0.03759545f, -0.02408234f, 0.00907557f, -0.03438077f, 0.01750365f, -0.00644022f, 
    0.01777813f, -0.03454356f, -0.00508232f, -0.00190160f, -0.03036260f, -0.03857588f, 0.00976313f, 0.02632219f, 
    -0.01594308f, 0.01439197f, -0.02037975f, -0.00357098f, 0.01078125f, 0.00944841f, 0.01120484f, -0.00036092f, 
    0.02724182f, 0.02171403f, 0.02879281f, -0.01913312f, 0.03044765f, 0.01387038f, -0.03806625f, -0.04173388f, 
    0.00537194f, 0.00520082f, 0.00571797f, -0.00138072f, 0.00799842f, 0.00166865f, -0.03892286f, 0.00836879f, 
    -0.03166157f, 0.00916964f, 0.00606019f, -0.00011409f, 0.01022900f, 0.00429093f, 0.00862180f, -0.01119989f, 
    -0.03243037f, -0.02487748f, -0.00447905f, -0.01685661f, -0.00265395f, -0.02651346f, -0.03825686f, -0.02649027f, 
    -0.03299973f, 0.01945184f, 0.00347423f, 0.00452271f, -0.02228009f, 0.01708591f, 0.01502537f, -0.02228836f, 
    0.02433910f, 0.00977274f, -0.00261698f, 0.01382455f, 0.03212874f, -0.02038770f, -0.00247954f, 0.00066206f, 
    0.02259332f, -0.01110707f, -0.02805441f, -0.00319238f, 0.00581159f, -0.00181963f, -0.01978101f, 0.00347418f, 
    -0.02357106f, -0.00428515f, 0.01687817f, 0.01943069f, -0.04047135f, 0.01035938f, 0.00923814f, 0.01262359f, 
    0.02577780f, -0.02729591f, 0.00195173f, 0.00928626f, 0.02508849f, -0.02423394f, -0.00657036f, -0.03119891f, 
    0.01599916f, 0.01816194f, 0.00543231f, -0.00156443f, -0.02615238f, -0.01888641f, -0.00500899f, 0.01951414f, 
    0.27726382f, 0.36576062f, 0.29747620f, -0.01375632f, 0.02266777f, 0.06853031f, 0.08966539f, 0.16364145f, 
    -0.04459693f, -0.05362204f, -0.00584463f, -0.02621997f, -0.33423057f, -0.17748991f, -0.11450656f, 0.13526249f, 
    0.02081795f, 0.12994471f, -0.05415619f, 0.22359012f, 0.05888661f, 0.06895629f, -0.03429744f, -0.16437198f, 
    0.15071151f, 0.01548624f, 0.23757476f, -0.21233742f, 0.16052005f, -0.01531297f, -0.14152367f, 0.01511123f, 
    0.07315367f, 0.10015780f, -0.11722669f, 0.06000922f, 0.21388929f, 0.13654912f, 0.00503329f, 0.05524625f, 
    0.07665567f, 0.08557084f, 0.08576311f, 0.11500229f, -0.09377386f, 0.04418841f, -0.04857819f, -0.03277978f, 
    -0.38600057f, -0.25859544f, -0.31264627f, -0.04421962f, 0.11930815f, -0.00708622f, -0.08851653f, 0.02582742f, 
    0.00106123f, 0.07597579f, 0.02842195f, -0.09626073f, -0.06032759f, 0.08433422f, -0.05241546f, 0.02267845f, 
    0.07412158f, 0.10261827f, -0.05155294f, 0.09031188f, 0.00694402f, -0.14043167f, -0.04098840f, 0.00398890f, 
    0.05203810f, 0.15426567f, -0.23331746f, -0.07961337f, 0.10612016f, 0.02501557f, 0.07854128f, -0.21769637f, 
    -0.13596918f, -0.03405994f, 0.04143096f, 0.06508929f, 0.38364086f, 0.24079682f, 0.52633226f, -0.42104158f, 
    0.05123707f, -0.01653051f, 0.06218450f, -0.10478231f, 0.13963366f, -0.05313611f, -0.09876643f, 0.01673596f, 
    -0.13476126f, 0.04525282f, -0.04154700f, -0.19838448f, -0.03754036f, -0.14793061f, 0.03575099f, -0.08032943f, 
    0.04430354f, -0.09198665f, -0.09268065f, 0.11259806f, -0.01463640f, 0.32266197f, 0.32512733f, -0.00444007f, 
    0.03274481f, 0.05340935f, 0.04883440f, 0.17096271f, -0.03517248f, -0.07290135f, 0.00846804f, -0.05734802f, 
    -0.01867681f, 0.04073911f, 0.08700753f, 0.19044802f, 0.05555808f, -0.01929258f, 0.00519186f, 0.00058111f, 
    0.01237544f, -0.03301431f, -0.08692033f, -0.06713877f, -0.24597554f, -0.16991131f, -0.10288937f, 0.04498860f, 
    -0.09764063f, 0.10836592f, -0.10027084f, -0.09815238f, -0.20838614f, -0.04674960f, -0.05945778f, 0.04086006f, 
    -0.02238689f, -0.09381295f, -0.23091406f, 0.19635463f, 0.01876841f, 0.22652464f, -0.03802427f, 0.09566530f, 
    -0.01426044f, -0.02247348f, -0.10262004f, -0.12862079f, -0.02996662f, -0.12341171f, -0.07957512f, 0.03911232f, 
    0.13202423f, 0.06666501f, -0.04702405f, -0.21725956f, 0.03954483f, -0.18118198f, 0.04368200f, 0.08742395f, 
    -0.34556636f, 0.28167629f, -0.02489441f, 0.05921453f, -0.05042357f, 0.08958981f, -0.03821176f, 0.01190341f, 
    0.06833423f, 0.13369726f, -0.05783847f, -0.05798548f, -0.00424107f, -0.00906414f, -0.12877192f, -0.05868434f, 
    0.07760153f, 0.03728717f, -0.03505503f, 0.10995612f, -0.02296802f, 0.08325045f, 0.00312356f, -0.05007463f, 
    0.07233498f, -0.00055648f, -0.15644898f, 0.03004523f, 0.08159560f, 0.05942781f, -0.06938984f, 0.03078600f, 
    0.11686793f, -0.01189792f, -0.11182830f, 0.11026672f, 0.12314101f, 0.10635017f, -0.16273862f, 0.12763368f, 
    -0.01339647f, 0.07541218f, 0.07220107f, 0.00079798f, -0.13800238f, 0.11003343f, 0.10368584f, -0.17231075f, 
    0.17058729f, 0.12258287f, -0.11426205f, -0.00813966f, -0.09378616f, 0.08920255f, 0.06078232f, 0.08247621f, 
    -0.00146902f, -0.12667039f, 0.16848968f, 0.40315369f, 0.06050525f, -0.04620347f, -0.22115681f, 0.00059538f, 
    0.09305613f, 0.08958070f, -0.04365651f, 0.07364912f, 0.15644045f, 0.15979983f, 0.04395826f, 0.07767178f, 
    0.22241782f, 0.33808860f, 0.03293579f, -0.10991423f, 0.20539226f, 0.16501792f, 0.10254718f, 0.12405534f, 
    -0.06554079f, 0.01572655f, 0.00439081f, 0.01267877f, 0.20569655f, 0.06769147f, -0.03874065f, -0.06564396f, 
    0.07855342f, 0.04911382f, 0.02670548f, -0.00856279f, 0.01000657f, -0.09828750f, -0.12376324f, 0.00497057f, 
    -0.10806766f, -0.03186942f, -0.15021756f, 0.21146773f, 0.02714631f, -0.03303913f, -0.07100693f, -0.03712868f, 
    -0.02970002f, -0.05588704f, -0.12100631f, -0.00030847f, -0.10043158f, -0.00104329f, 0.09521414f, 0.05193002f, 
    0.06174177f, -0.15620676f, -0.05760537f, -0.10705864f, 0.02580453f, 0.02993398f, 0.02032057f, 0.09841532f, 
    -0.07212025f, -0.03650338f, -0.08642585f, 0.03423524f, 0.11008095f, -0.04089302f, -0.10162774f, -0.11330166f, 
    0.10547116f, 0.02533683f, -0.01342528f, -0.09405484f, 0.24018964f, 0.16238952f, -0.00256705f, 0.03337197f, 
    0.21107174f, 0.04043749f, 0.09824290f, 0.02904783f, -0.03596477f, 0.06148516f, 0.07924466f, -0.02266787f, 
    0.00337100f, 0.10994183f, 0.34436706f, 0.12185194f, -0.05344179f, 0.07039448f, -0.14306659f, -0.19867907f, 
    -0.03747732f, 0.15016744f, -0.12122785f, 0.04345164f, 0.18033426f, 0.13756002f, 0.13349831f, 0.07335122f, 
    0.03034394f, 0.08358476f, 0.14962041f, 0.27146786f, 0.07218575f, 0.08204959f, 0.12820233f, -0.10757703f, 
    0.06494538f, -0.08688246f, -0.21622169f, 0.03123908f, 0.06094287f, -0.04559270f, 0.08507776f, 0.02860944f, 
    -0.00198097f, 0.04646030f, 0.21217678f, 0.05956183f, 0.08011992f, -0.06060706f, -0.13143526f, 0.10076558f, 
    -0.04761122f, 0.01819327f, -0.00416222f, -0.05458134f, -0.01588789f, -0.04485831f, 0.02887987f, -0.11572763f, 
    0.24310827f, -0.06304808f, 0.02117486f, -0.09705596f, 0.06708106f, 0.18116532f, 0.12914766f, 0.10174003f, 
    -0.01079536f, 0.02781134f, 0.04817585f, 0.09362532f, 0.06693287f, 0.10805705f, -0.15630211f, -0.10601611f, 
    0.14111018f, 0.12569343f, -0.04717623f, -0.03473115f, -0.02054891f, 0.05906817f, 0.03094519f, -0.02810992f, 
    0.29207829f, -0.09243277f, 0.37532082f, 0.05410776f, 0.00740071f, -0.04624393f, 0.00482496f, -0.14163578f, 
    -0.01690601f, -0.04646479f, 0.11529795f, -0.02907981f, -0.08722077f, 0.06929541f, 0.04014368f, 0.20278408f, 
    -0.00286666f, 0.05798422f, -0.00055425f, 0.26682121f, -0.03372452f, -0.13184127f, 0.04409676f, -0.02510206f, 
    0.08703214f, -0.08268031f, 0.01992832f, 0.04140433f, -0.04991996f, 0.05677377f, -0.16075350f, -0.06100140f, 
    -0.07196830f, -0.02001812f, 0.11200147f, -0.09688490f, 0.04931729f, 0.28784916f, -0.21135028f, -0.08343524f, 
    0.10910591f, -0.06039921f, 0.14488606f, 0.17710505f, 0.21158631f, -0.02362673f, -0.03513787f, -0.00005251f, 
    0.06877290f, 0.21147892f, -0.11342680f, -0.05194432f, -0.10459810f, -0.01015693f, 0.08652527f, 0.03972669f, 
    0.02197742f, 0.08056821f, -0.00175888f, 0.08528449f, 0.17761146f, 0.04341257f, -0.09792025f, -0.05039128f, 
    0.23397331f, 0.07934344f, 0.13173527f, -0.13186440f, -0.01574208f, 0.03408610f, 0.03336982f, 0.15238325f, 
    0.09365203f, -0.11709420f, 0.28736255f, 0.09960964f, 0.02270274f, -0.08552143f, 0.00084940f, 0.16584651f, 
    -0.04845927f, -0.03165690f, -0.03514825f, -0.03058214f, 0.29854038f, 0.23851249f, 0.25215667f, 0.03996155f, 
    0.10078144f, 0.02721517f, 0.08860195f, 0.03076538f, 0.03543467f, -0.08506771f, -0.11963163f, -0.04963828f, 
    0.08939211f, 0.09826621f, 0.27368864f, 0.12836230f, -0.02452760f, 0.06862719f, 0.01491208f, 0.03546851f, 
    -0.05917254f, -0.11785586f, 0.11185794f, -0.08138929f, 0.17070408f, 0.10314098f, -0.04528287f, -0.01037974f, 
    0.09114254f, 0.07736240f, 0.10639484f, 0.06868978f, 0.04975722f, -0.03037679f, 0.02567417f, 0.09478739f, 
    0.30737087f, 0.04400948f, 0.11626308f, -0.08698866f, 0.08187012f, 0.04494852f, 0.11975254f, 0.06642123f, 
    0.02380052f, 0.06412148f, 0.07936317f, 0.05101151f, 0.10085724f, -0.29780605f, -0.28866923f, 0.02046798f, 
    0.18294449f, 0.04230575f, -0.10537268f, -0.01522054f, 0.04621410f, 0.05939342f, 0.01872226f, -0.02781664f, 
    -0.14586103f, -0.43560103f, -0.18441601f, -0.09661128f, 0.13970728f, 0.08575341f, -0.10314301f, 0.02390298f, 
    -0.00914940f, 0.04466539f, 0.06447343f, 0.05126102f, 0.24127898f, 0.26557598f, 0.13725123f, -0.01558818f, 
    0.03660318f, 0.07820637f, 0.02553429f, 0.00840111f, -0.15520801f, -0.01265581f, 0.15512469f, -0.01646410f, 
    -0.00031765f, -0.22338626f, -0.06380596f, -0.09354809f, 0.04834479f, -0.04451637f, -0.11254875f, -0.06256717f, 
    0.06197858f, 0.01882298f, 0.00875534f, 0.00497436f, 0.03195690f, 0.10157216f, 0.04244747f, 0.04366610f, 
    -0.01506394f, -0.19310062f, 0.00894572f, -0.00122704f, -0.10827200f, -0.07671003f, 0.07211419f, -0.17742616f, 
    0.11080154f, 0.18174312f, -0.01989780f, 0.05014111f, -0.02567768f, 0.02468481f, 0.10748816f, -0.09160844f, 
    0.03813750f, -0.08284832f, -0.09058163f, 0.07439155f, 0.05802898f, 0.36958951f, 0.20119222f, -0.05299617f, 
    -0.05062276f, -0.05522887f, 0.11050968f, 0.03158338f, 0.03594619f, 0.00630707f, -0.09929395f, 0.01383420f, 
    0.14506893f, 0.14011107f, -0.16889426f, -0.17322735f, 0.01600911f, 0.01174254f, 0.09572197f, -0.21895370f, 
    0.09138840f, -0.09427869f, -0.10075414f, 0.06967562f, -0.02867150f, 0.06546310f, -0.08841015f, 0.03047212f, 
    -0.05117412f, -0.05100190f, 0.01628932f, 0.05189540f, -0.02857174f, -0.12249345f, 0.02333056f, -0.01500835f, 
    0.24758868f, 0.02051090f, 0.06468756f, 0.05904070f, 0.09728002f, 0.04814627f, 0.03353767f, -0.10799777f, 
    0.01822969f, 0.01312554f, -0.03768058f, 0.05696396f, -0.25600374f, 0.06372221f, -0.07909881f, 0.14148861f, 
    0.08821082f, 0.12525511f, -0.01375275f, 0.16916402f, 0.18419890f, 0.17723092f, 0.09928986f, -0.08096451f, 
    -0.06025531f, -0.20563769f, 0.01151840f, 0.17623821f, 0.08223752f, 0.04917095f, 0.00856512f, -0.05213027f, 
    0.05574086f, 0.09106374f, 0.03631343f, 0.05248556f, -0.32734913f, 0.10635635f, -0.15165137f, 0.14058082f, 
    -0.09813212f, -0.04729540f, -0.00490937f, -0.14517960f, 0.13468492f, -0.00831368f, -0.02564341f, 0.15727139f, 
    0.27908298f, 0.29257771f, 0.01606736f, -0.08917329f, 0.25278735f, 0.29027882f, 0.11340677f, 0.13119818f, 
    0.06757544f, -0.09106512f, -0.03132955f, -0.03863799f, -0.10290802f, -0.25251395f, -0.09060082f, -0.02402318f, 
    0.06445793f, -0.03836333f, -0.03047680f, -0.11663312f, 0.00360032f, -0.06168878f, 0.17800200f, 0.01220175f, 
    0.09775147f, 0.27704430f, -0.03060129f, 0.08805354f, 0.12304501f, -0.11066313f, -0.04362498f, -0.03341554f, 
    -0.22118302f, 0.06491566f, 0.02459233f, 0.12323992f, -0.05113310f, -0.08529320f, 0.06870695f, 0.15786771f, 
    -0.09057396f, -0.08001485f, 0.06913037f, -0.13031696f, 0.04476982f, -0.06758402f, 0.06109421f, -0.11304049f, 
    -0.19407760f, -0.07577451f, -0.14817998f, 0.15166934f, -0.04326275f, 0.06041475f, -0.01142039f, -0.04103117f, 
    0.20053041f, -0.03366796f, -0.15689890f, -0.09817258f, -0.06816751f, -0.05096456f, -0.06108323f, 0.21890888f, 
    -0.00780501f, -0.01835921f, -0.05618602f, 0.10606633f, 0.04544793f, 0.02143392f, 0.02549895f, -0.06191151f, 
    -0.16807418f, -0.33864969f, -0.14522676f, 0.00794666f, 0.04621870f, -0.04803738f, 0.01071818f, 0.06098478f, 
    -0.04217063f, 0.04151532f, 0.17680517f, -0.03484768f, 0.42125574f, 0.17859136f, -0.02082856f, 0.04925003f, 
    0.26868698f, 0.15106289f, 0.12996119f, 0.16884220f, -0.10388212f, 0.05349946f, -0.00788178f, -0.11705112f, 
    -0.30908489f, -0.16733010f, -0.15212134f, 0.15931243f, -0.06270150f, 0.03048193f, 0.01731855f, -0.19791012f, 
    0.06316083f, 0.00661977f, 0.04702600f, -0.06890208f, 0.64183366f, 0.24318032f, 0.05508543f, -0.09459104f, 
    -0.09772135f, -0.03415876f, -0.02745801f, 0.03947214f, -0.02349854f, 0.07723159f, 0.06440029f, 0.01832128f, 
    -0.13138355f, -0.13552119f, 0.01676377f, -0.01864742f, 0.15554355f, 0.12790602f, 0.10573424f, -0.03972180f, 
    -0.00663635f, 0.02932623f, 0.10986792f, 0.06217654f, -0.05084081f, -0.18983264f, -0.05667790f, 0.09340695f, 
    0.03877689f, -0.02242339f, -0.03176245f, -0.14044543f, -0.02624416f, 0.02958702f, -0.03963166f, -0.01711043f, 
    0.03073173f, 0.07895505f, -0.11630500f, 0.20963880f, 0.01546932f, 0.06112673f, 0.02080244f, 0.17213991f, 
    -0.08280236f, 0.06283312f, 0.04922370f, -0.04534197f, 0.33236474f, 0.11830305f, 0.01142491f, 0.05084607f, 
    -0.10301901f, 0.07330918f, 0.07101049f, 0.01273005f, -0.09154448f, -0.03298460f, -0.05074405f, -0.12163190f, 
    -0.10346084f, -0.07411611f, -0.16573757f, -0.05100230f, 0.01937779f, -0.01370022f, -0.03508399f, 0.10492333f, 
    -0.06616528f, -0.03654175f, 0.11687523f, 0.11266053f, -0.36854622f, 0.05579221f, -0.13776442f, 0.22391716f, 
    0.16101402f, 0.15554750f, 0.10173058f, 0.13465631f, -0.02878217f, -0.04803982f, -0.05498296f, -0.00788420f, 
    -0.05426225f, 0.24571346f, -0.12646456f, 0.19093546f, 0.07304153f, 0.05202531f, 0.07978967f, 0.00090736f, 
    0.02854636f, 0.03228142f, -0.07818612f, -0.05636438f, 0.18403737f, -0.11749638f, -0.26052883f, 0.07742843f, 
    0.01387986f, 0.00629441f, -0.01556042f, 0.03443817f, 0.00385157f, 0.06528880f, -0.01116096f, 0.06901752f, 
    0.15975937f, 0.10265696f, -0.17425275f, 0.15731452f, 0.00018788f, -0.01617580f, 0.08256080f, 0.12260955f, 
    -0.10488132f, 0.03633039f, 0.13417214f, 0.06731398f, 0.28250587f, -0.06796128f, 0.12592852f, 0.03313677f, 
    0.02196370f, 0.07027956f, 0.10903835f, 0.08893593f, 0.01369545f, 0.14513512f, 0.11533844f, -0.01699731f, 
    0.60384047f, 0.06380716f, 0.18355736f, 0.01737139f, -0.05733432f, -0.11327223f, 0.09097970f, -0.00924545f, 
    -0.05486761f, -0.00313383f, 0.00086298f, -0.00708920f, 0.04213296f, -0.00007871f, 0.05353866f, 0.05010135f, 
    -0.07880927f, -0.00212279f, 0.07108969f, 0.05848139f, -0.11171709f, -0.09753948f, -0.07537421f, -0.15550798f, 
    0.04020561f, -0.05484877f, 0.03594410f, 0.10162390f, 0.02743679f, 0.07652219f, 0.11077055f, -0.04670518f, 
    -0.04302897f, -0.01194996f, 0.05415095f, -0.02447705f, -0.21360973f, 0.02931322f, 0.02975125f, -0.05697696f, 
    0.01056299f, -0.09653179f, 0.07459130f, -0.07056886f, -0.06814884f, 0.03271766f, 0.03671085f, -0.09488109f, 
    -0.02954866f, 0.17826878f, 0.10964230f, 0.08580773f, -0.01503129f, 0.11939456f, 0.09847852f, 0.08036789f, 
    -0.09324093f, 0.07368167f, 0.09994736f, 0.07135321f, -0.04122693f, -0.41953266f, 0.06091560f, -0.00997672f, 
    0.01988288f, 0.00753566f, -0.00948855f, -0.06042862f, -0.00737576f, -0.04167521f, -0.09498625f, 0.14771493f, 
    -0.34428898f, -0.33820498f, -0.09633499f, -0.29573649f, 0.03650469f, 0.06521922f, 0.01183418f, 0.04952774f, 
    -0.02503423f, 0.02251934f, 0.07159035f, 0.10188304f, -0.08292530f, -0.03814176f, 0.00975663f, -0.12037997f, 
    -0.04293573f, -0.11513904f, 0.13891715f, -0.02041291f, -0.04992537f, -0.07685356f, -0.04554340f, -0.00779597f, 
    -0.05529324f, -0.11259487f, -0.07721710f, 0.18370751f, -0.17063218f, -0.14301185f, 0.07428025f, -0.09752317f, 
    -0.01822242f, 0.04809327f, -0.08169916f, -0.08086116f, -0.34185559f, -0.21912460f, 0.00408143f, -0.33330762f, 
    -0.04303180f, -0.13445604f, -0.04437923f, 0.01470720f, 0.04109038f, 0.09963655f, 0.06499942f, 0.03438030f, 
    0.54955798f, -0.14916198f, 0.18720450f, -0.15710106f, -0.06579681f, 0.04451790f, 0.08055074f, -0.03613561f, 
    -0.06361244f, 0.05273164f, 0.00283514f, -0.02674099f, 0.14838386f, 0.05469537f, -0.01508650f, 0.04099891f, 
    0.06298225f, 0.01764832f, 0.02435975f, -0.02790490f, -0.04589739f, -0.05306390f, -0.13279919f, -0.09277900f, 
    0.06601394f, 0.07491632f, -0.12969890f, 0.13173606f, -0.00884049f, -0.12994815f, 0.18988577f, 0.19408172f, 
    -0.10807944f, 0.00039744f, -0.09507176f, -0.03271909f, -0.19890755f, -0.13875164f, 0.05819757f, 0.05601771f, 
    -0.13211337f, -0.01182693f, -0.10877684f, -0.09897715f, 0.01565064f, -0.01141485f, -0.08742967f, -0.03460623f, 
    -0.07226197f, 0.19283865f, 0.01633360f, 0.07470492f, 0.00515781f, 0.01981012f, 0.00031717f, 0.07458586f, 
    0.06948775f, -0.12632000f, -0.15157761f, -0.13114648f, 0.01815421f, -0.08631023f, 0.23294310f, 0.06854908f, 
    0.00784120f, -0.03373856f, -0.17938119f, 0.06269189f, -0.02896680f, -0.00853049f, 0.04008238f, 0.02513296f, 
    0.05612807f, 0.00275124f, -0.02598617f, -0.00048724f, 0.01401966f, 0.09714675f, -0.18079050f, -0.08546513f, 
    0.04427624f, 0.05440186f, -0.03445014f, 0.04295645f, 0.09537882f, -0.01862562f, 0.14857705f, 0.10207558f, 
    0.08487161f, 0.07629589f, -0.02260580f, -0.05084560f, -0.05835203f, 0.15309079f, 0.05526397f, 0.03618521f, 
    0.23837841f, -0.10718980f, 0.24331196f, 0.05880757f, 0.12988332f, -0.04174814f, -0.09406783f, -0.09978366f, 
    0.02581234f, -0.02310104f, 0.03188193f, -0.08693575f, -0.03427371f, -0.07739687f, 0.09022880f, 0.01223250f, 
    0.03108635f, -0.11819819f, -0.03609765f, -0.02015230f, -0.11990996f, -0.01545902f, -0.08237918f, 0.04688503f, 
    -0.05053146f, 0.12419775f, -0.05055625f, -0.01044214f, -0.03379196f, 0.13317716f, -0.10250262f, 0.08025960f, 
    -0.06262372f, -0.01152524f, 0.07687092f, -0.33162606f, 0.10255420f, -0.04139618f, 0.31019422f, -0.08669746f, 
    0.10278080f, 0.19928174f, 0.21832259f, -0.15169156f, -0.03055076f, 0.11010497f, 0.11181990f, 0.20782426f, 
    0.10649978f, 0.11734612f, 0.00431329f, 0.06785832f, 0.05538399f, 0.03543746f, 0.00764852f, 0.02763533f, 
    -0.01082916f, -0.03881864f, -0.02435056f, -0.12672055f, -0.10643151f, -0.05036028f, -0.13836241f, 0.22192988f, 
    -0.09798891f, 0.16429764f, 0.21875410f, -0.02954319f, -0.11479251f, 0.00006884f, 0.08997840f, -0.02535946f, 
    -0.08519199f, -0.08475407f, -0.06416575f, 0.13190979f, 0.02417543f, 0.21819481f, 0.13520141f, 0.03687925f, 
    -0.00588550f, 0.01200317f, 0.23873855f, 0.13328429f, -0.17755976f, -0.20785186f, 0.10393517f, -0.12817308f, 
    -0.02472929f, 0.01300113f, -0.13113883f, 0.08271130f, -0.08716114f, 0.04862633f, -0.03270996f, -0.13881445f, 
    0.07879156f, 0.09938786f, -0.10261750f, 0.04072727f, -0.01053131f, 0.01858494f, 0.06911337f, 0.08360495f, 
    -0.02406323f, 0.04907281f, 0.22320665f, 0.19535239f, -0.13862807f, -0.21482933f, -0.02346100f, -0.23741230f, 
    -0.01824047f, 0.17714897f, -0.08145158f, -0.07585213f, -0.06570255f, -0.02212422f, 0.14610355f, 0.13309804f, 
    0.07290345f, -0.10962117f, 0.00038427f, 0.00337667f, -0.03559970f, 0.02299188f, -0.03264980f, 0.14307329f, 
    0.00971118f, 0.03879316f, 0.10676906f, 0.12260220f, 0.05173704f, -0.01265809f, -0.03142900f, -0.25102836f, 
    -0.11146012f, -0.06119451f, -0.07325108f, -0.16405052f, 0.01494453f, 0.02416630f, -0.02309204f, -0.11009819f, 
    -0.02598939f, 0.05543558f, -0.11996830f, -0.10651291f, -0.12653455f, 0.01050322f, 0.05609622f, 0.00681426f, 
    0.04293482f, 0.07942711f, 0.03304121f, 0.04305753f, -0.16460809f, -0.13027616f, 0.03935168f, -0.17841800f, 
    0.00940577f, 0.00675752f, -0.05422395f, 0.01752793f, -0.15927598f, 0.09573282f, 0.08400386f, 0.07229282f, 
    -0.25241777f, 0.03828802f, -0.05498301f, 0.00832254f, 0.00455248f, -0.09858934f, -0.04326944f, -0.00184293f, 
    -0.01346840f, 0.02616289f, 0.08212956f, -0.03080268f, -0.09062413f, -0.30952305f, 0.48202980f, 0.16508165f, 
    -0.02111020f, -0.03266416f, 0.07621395f, -0.07476619f, -0.05142980f, -0.04121074f, 0.12197999f, -0.01155164f, 
    0.05803377f, 0.00320904f, -0.05120369f, -0.00299323f, -0.04475892f, 0.02842359f, 0.01864293f, 0.02604221f, 
    0.08013881f, -0.01092249f, -0.01635511f, -0.14559542f, -0.03629405f, 0.12855023f, 0.04725287f, 0.02409886f, 
    -0.00374364f, 0.04253733f, 0.00400438f, -0.04198566f, -0.05826937f, 0.02389386f, 0.10297225f, 0.03026962f, 
    -0.19088131f, 0.15472968f, -0.14360027f, 0.03066570f, -0.00171560f, -0.01639233f, -0.17170072f, 0.08694343f, 
    0.08102805f, 0.13195483f, 0.20836236f, 0.02441781f, -0.06348124f, 0.06217134f, -0.05545933f, 0.23777959f, 
    0.08154220f, 0.05431314f, -0.04721713f, 0.07300595f, 0.02262551f, -0.01618560f, 0.01695421f, 0.04883681f, 
    -0.22434303f, 0.27503926f, -0.31688267f, -0.04556283f, 0.02333494f, -0.07430469f, -0.11590882f, 0.10575610f, 
    -0.03328951f, 0.22515541f, 0.08014660f, -0.03287245f, 0.09398229f, 0.17322513f, 0.08168274f, 0.14584261f, 
    -0.03430704f, 0.09673037f, -0.02214761f, -0.04668957f, 0.05630435f, -0.05745711f, 0.10017926f, -0.15800969f, 
    -0.15061207f, -0.15295725f, -0.18091038f, -0.29852086f, -0.06630658f, -0.02248561f, -0.10391553f, -0.00735384f, 
    0.01391139f, 0.03334848f, 0.16588666f, 0.07101293f, 0.06133773f, 0.00034726f, 0.01860041f, -0.06927179f, 
    -0.11066662f, -0.01244187f, 0.03011058f, -0.05846138f, -0.03493329f, -0.00565601f, 0.12634733f, 0.07660650f, 
    0.19778828f, 0.03937254f, 0.11901160f, 0.00869132f, 0.04794127f, -0.02448264f, -0.02852998f, -0.02894701f, 
    0.08706849f, -0.00620897f, -0.07766716f, -0.25549898f, 0.12043053f, -0.01282830f, 0.11823653f, 0.00667147f, 
    -0.02221926f, 0.03397035f, 0.31911981f, -0.12511055f, -0.08456913f, 0.02429224f, -0.10760231f, -0.08046036f, 
    -0.11862961f, -0.11731659f, 0.09716813f, 0.13023229f, -0.14959660f, -0.23626770f, -0.29462218f, -0.11187343f, 
    -0.05504179f, -0.02980880f, -0.04624172f, -0.05025842f, 0.04817044f, 0.00088947f, -0.09359019f, 0.08838727f, 
    -0.10410012f, 0.07769879f, -0.04290015f, 0.16623744f, -0.07176516f, -0.04204125f, -0.05547639f, -0.11357392f, 
    -0.11352474f, -0.01848056f, 0.22054800f, 0.07776923f, 0.09571566f, 0.10836872f, -0.02468647f, -0.15432294f, 
    0.03577663f, 0.05070366f, -0.01835977f, 0.11975569f, 0.14514767f, 0.08434106f, 0.05481809f, 0.00660721f, 
    -0.03614122f, 0.04871792f, 0.01566335f, -0.01160346f, 0.10064171f, 0.01157978f, 0.03370797f, 0.05047180f, 
    0.05722271f, 0.12616363f, 0.11054018f, 0.03150780f, -0.02153468f, -0.00088515f, 0.01546847f, 0.02109999f, 
    0.06632748f, 0.05901521f, 0.07266530f, 0.14991432f, 0.41121107f, 0.24274160f, 0.07667252f, 0.17334284f, 
    -0.02785573f, 0.03292247f, -0.00289338f, -0.01753682f, 0.06065203f, 0.04072905f, -0.01622177f, -0.03946080f, 
    -0.01434715f, 0.01829082f, 0.03761845f, -0.05451436f, -0.03624941f, -0.01295000f, 0.02694524f, 0.00594249f, 
    0.10091914f, 0.01612032f, 0.04704325f, 0.07863716f, -0.09508543f, 0.03072966f, 0.50067723f, -0.03997551f, 
    -0.02082786f, 0.03094655f, -0.09891886f, -0.10048249f, 0.01703602f, -0.01856989f, -0.01815988f, -0.05787504f, 
    -0.12752147f, -0.20625648f, -0.01276770f, 0.25248846f, 0.07480739f, 0.09605634f, 0.12674809f, -0.15119533f, 
    -0.01809120f, -0.05134223f, 0.04088300f, 0.06488107f, 0.32754463f, 0.12539406f, 0.03255774f, 0.13266483f, 
    0.00806081f, 0.14599897f, 0.19725820f, 0.11733135f, -0.03140420f, -0.00609343f, -0.05052831f, -0.01284353f, 
    0.04579446f, -0.04385958f, -0.19984061f, 0.19460741f, -0.03750283f, -0.07597413f, 0.05086436f, -0.14931551f, 
    0.09296034f, 0.04389553f, 0.10039024f, 0.11182461f, -0.33994099f, -0.14095795f, -0.03056201f, 0.03987385f, 
    -0.08758675f, -0.01429942f, 0.03442490f, 0.04249518f, -0.00764191f, 0.03822146f, 0.04829630f, 0.09445296f, 
    -0.69854027f, 0.05338371f, 0.21113196f, -0.03980341f, 0.02362207f, -0.05978267f, -0.06567001f, 0.15305920f, 
    -0.10863768f, 0.03843953f, 0.08909900f, 0.13939361f, 0.05461149f, -0.07911623f, -0.01460335f, 0.14011653f, 
    0.08397848f, 0.10642412f, -0.00621259f, 0.03091802f, 0.03202191f, -0.02944282f, -0.04434823f, -0.08078086f, 
    -0.15801343f, 0.22304240f, -0.00376200f, -0.04717945f, 0.07977062f, -0.01092193f, 0.00546747f, 0.05595338f, 
    -0.03192868f, 0.11955655f, 0.17805193f, 0.17729433f, 0.33593744f, -0.29083520f, -0.03591087f, 0.32091528f, 
    0.14085126f, 0.02602501f, -0.13318735f, 0.03621927f, -0.04811191f, 0.05398219f, 0.06946936f, -0.04820580f, 
    -0.10408541f, -0.04640428f, 0.04686958f, -0.08211519f, 0.09094124f, -0.05647364f, -0.04553951f, 0.06045870f, 
    -0.03623506f, -0.05751343f, -0.01233249f, -0.03980349f, 0.27980614f, -0.29479721f, 0.10313694f, 0.15103023f, 
    -0.00233012f, 0.07409818f, 0.21626729f, 0.07673667f, 0.01158610f, -0.00821274f, -0.03863548f, 0.01060759f, 
    0.09652409f, 0.06867637f, -0.08381341f, 0.22955897f, -0.02763975f, -0.07546989f, 0.03946442f, -0.04850835f, 
    0.08433735f, 0.24711457f, 0.17879085f, 0.21606478f, 0.08361929f, 0.13839498f, 0.02489386f, 0.05471782f, 
    -0.02565209f, 0.07329661f, 0.12949431f, -0.07720771f, 0.06609629f, 0.22236064f, 0.15895937f, 0.10822594f, 
    0.30599195f, -0.05222576f, 0.30227518f, 0.31943670f, 0.09322943f, 0.19161549f, 0.17607044f, 0.11770995f, 
    0.02731627f, 0.00048362f, -0.10488222f, -0.06850460f, 0.08826064f, -0.03834906f, -0.00396173f, 0.04219686f, 
    0.09889307f, 0.01772513f, -0.02219814f, 0.04505007f, 0.09100462f, -0.01505812f, 0.01545228f, -0.09154984f, 
    0.06478141f, -0.02955754f, 0.14515139f, -0.13340384f, 0.11010929f, 0.17388272f, 0.12017431f, -0.02661519f, 
    0.11956584f, 0.05129620f, -0.09272236f, -0.07125573f, -0.33950466f, 0.12348043f, 0.18838833f, 0.03553516f, 
    -0.04716664f, -0.15758619f, 0.04554350f, 0.04945245f, 0.11709386f, 0.09611983f, 0.10187822f, 0.12469232f, 
    -0.09511890f, -0.12509109f, 0.21644801f, 0.11313102f, 0.04462640f, 0.15808466f, 0.04125959f, -0.01071534f, 
    0.09526902f, 0.00339208f, 0.09854450f, -0.19190852f, -0.23542571f, -0.02504496f, 0.28227693f, -0.05077333f, 
    -0.06548927f, 0.12669438f, 0.00587484f, -0.10124464f, 0.08140365f, 0.12088918f, 0.14501186f, 0.01249765f, 
    0.09191945f, -0.26288050f, -0.07607911f, 0.10351355f, 0.23689306f, -0.09823153f, -0.21237326f, 0.13200058f, 
    -0.14094037f, 0.01974141f, 0.14643474f, 0.21952306f, -0.13541648f, 0.05481204f, 0.02518520f, -0.01626984f, 
    -0.12376177f, -0.12746620f, -0.03097372f, -0.05723880f, 0.04679444f, 0.00218500f, -0.06623828f, 0.15581855f, 
    -0.32156599f, -0.19288355f, -0.07029179f, 0.08231991f, -0.02581664f, -0.01699699f, 0.02817324f, -0.11038239f, 
    -0.05216292f, 0.00813351f, -0.06215633f, -0.02765038f, -0.17884347f, -0.12552023f, 0.04060668f, -0.00516765f, 
    -0.05449601f, -0.07185598f, -0.05565517f, 0.13691814f, -0.01407148f, 0.01032722f, 0.12241810f, 0.13507277f, 
    0.16983292f, -0.00446982f, 0.03102538f, 0.18136898f, -0.00899846f, 0.04136967f, 0.05748516f, 0.08565325f, 
    -0.00682334f, -0.01044268f, -0.04421368f, -0.05666657f, 0.08455336f, 0.03033103f, 0.03279072f, 0.02570988f, 
    0.08738504f, -0.00079519f, -0.04093061f, 0.01463286f, -0.01745203f, 0.01607337f, 0.02487415f, -0.03584278f, 
    -0.25789094f, -0.09216358f, 0.11304399f, -0.07585029f, 0.05036901f, -0.07532341f, -0.16301456f, 0.13273773f, 
    -0.04932388f, 0.00278599f, 0.07496372f, 0.01940741f, -0.13011533f, -0.05222484f, 0.06150001f, -0.01255603f, 
    0.01027429f, -0.04027164f, 0.06605486f, -0.02969280f, -0.01904628f, 0.09458880f, 0.09911149f, -0.01630450f, 
    0.15036881f, 0.21026686f, -0.15727489f, 0.25101233f, 0.06900647f, -0.04961905f, 0.00901493f, -0.12191685f, 
    0.01777198f, 0.09766738f, -0.15177937f, 0.26105505f, -0.01364565f, -0.20523523f, 0.19852123f, 0.23329723f, 
    0.17450041f, 0.14509806f, -0.19875795f, 0.14551170f, 0.05088187f, -0.02811195f, 0.00339165f, -0.00482143f, 
    0.02038668f, 0.12105063f, -0.02679379f, 0.06025115f, 0.00014750f, -0.08706487f, 0.02123365f, -0.19307213f, 
    0.26746157f, 0.09120122f, 0.02277026f, 0.01296797f, -0.04944798f, -0.00032950f, 0.13506535f, 0.08907713f, 
    0.07566183f, 0.02553806f, -0.02616656f, -0.03423197f, 0.23431943f, -0.16861074f, 0.04474915f, 0.06553382f, 
    -0.08424690f, -0.20621029f, 0.14924604f, 0.33819357f, 0.14075696f, -0.11893049f, 0.00986512f, -0.15680143f, 
    0.10668418f, 0.01753971f, 0.01486610f, 0.11262137f, -0.16863179f, 0.00244449f, 0.16983730f, 0.23046206f, 
    0.08556712f, 0.01733275f, -0.00910056f, -0.15376538f, -0.03364698f, 0.03709292f, -0.01671460f, 0.04791357f, 
    0.30746892f, -0.25228456f, -0.05201586f, 0.29415599f, 0.10123172f, -0.06257417f, -0.04293572f, -0.04247678f, 
    -0.06622908f, 0.02509524f, -0.05042636f, 0.11899972f, 0.00436742f, 0.24680349f, 0.03004816f, -0.01978784f, 
    0.10218921f, 0.09219685f, 0.06973316f, 0.15930788f, 0.00426185f, 0.00535099f, 0.04443292f, -0.06892884f, 
    -0.00779945f, 0.03134304f, -0.05860252f, 0.01343760f, 0.09324200f, 0.06590489f, 0.03320232f, 0.05871185f, 
    0.07957339f, -0.07352171f, -0.03508477f, -0.01768344f, -0.28345585f, 0.02171754f, -0.07599490f, 0.34471744f, 
    0.11169796f, 0.14364561f, -0.09339795f, -0.11788671f, 0.06438279f, 0.11038071f, 0.01709112f, -0.08268572f, 
    -0.35135865f, -0.05165101f, 0.12358033f, 0.26063195f, 0.00468679f, 0.21847622f, 0.14187130f, 0.03847980f, 
    -0.02304378f, 0.23767681f, 0.05622278f, 0.20325445f, -0.15571496f, -0.10560979f, 0.18171246f, 0.05729916f, 
    -0.03042841f, -0.01649560f, -0.17406446f, 0.01290569f, 0.02624959f, 0.02470500f, 0.03098680f, 0.04647686f, 
    0.20854878f, -0.03281080f, -0.21431518f, 0.15545315f, -0.00064431f, -0.08268375f, 0.11096872f, 0.00106667f, 
    0.20814553f, 0.24858962f, 0.08059549f, 0.29359710f, -0.14864132f, -0.12895659f, -0.08304004f, 0.03650660f, 
    0.10951205f, 0.10708664f, 0.06024934f, -0.09922321f, -0.07664985f, -0.03680221f, 0.08939324f, 0.19565517f, 
    0.02768700f, -0.01572557f, 0.11195575f, 0.23318599f, -0.06282388f, 0.05750978f, 0.19879673f, 0.13418524f, 
    -0.00172189f, -0.01662978f, 0.14676525f, -0.00331800f, -0.13818769f, -0.20588213f, -0.04669321f, 0.10425445f, 
    -0.05180919f, -0.08617307f, -0.02872998f, -0.18215856f, 0.08621044f, -0.01684669f, -0.02908784f, -0.02595359f, 
    -0.00373033f, -0.12960052f, -0.15897331f, -0.03748917f, -0.15036412f, -0.12623255f, 0.29914573f, 0.20719586f, 
    0.09055290f, -0.05393948f, 0.00854938f, 0.15522201f, 0.00483598f, 0.36922869f, 0.11573821f, 0.07062934f, 
    -0.05724400f, -0.12380585f, 0.00024980f, -0.11684788f, 0.17508230f, 0.02315098f, 0.12620442f, 0.13452521f, 
    -0.06529215f, 0.17122862f, 0.39838615f, 0.12046514f, -0.05440557f, -0.11549696f, -0.08462383f, 0.15528940f, 
    -0.09686863f, 0.00705335f, -0.03345458f, 0.13557683f, -0.08258455f, -0.25102779f, 0.18626165f, 0.20782754f, 
    0.13484100f, 0.11552782f, 0.06289098f, -0.06065655f, 0.00567070f, 0.02485206f, -0.02836172f, 0.10581598f, 
    0.06748724f, -0.07935318f, -0.18720818f, 0.00409962f, 0.04629316f, 0.02416719f, -0.03243745f, 0.02980213f, 
    0.09121656f, -0.07088790f, -0.02186852f, 0.09196933f, 0.05177242f, 0.01431537f, -0.00501054f, 0.08541200f, 
    0.04995431f, -0.02968710f, -0.00915302f, 0.01311764f, -0.01309014f, 0.00818473f, 0.09191579f, -0.07959849f, 
    -0.15151693f, -0.07666086f, 0.03728175f, -0.13617963f, -0.04607920f, -0.02664693f, -0.00870289f, 0.04187294f, 
    0.13623013f, 0.12523569f, 0.20287043f, 0.17234296f, -0.00644113f, 0.00154583f, 0.11405872f, 0.06594913f, 
    0.10470107f, 0.10870183f, 0.02875795f, 0.02457708f, -0.04544684f, -0.01316951f, 0.00773927f, -0.05376158f, 
    -0.17872092f, -0.07231315f, 0.05130143f, 0.13978113f, -0.06431080f, -0.13766144f, -0.12015439f, 0.01228934f, 
    0.00569414f, 0.00192697f, -0.08153022f, 0.24034318f, -0.03911437f, 0.24604325f, -0.10590017f, -0.00264304f, 
    0.11709827f, 0.06914484f, 0.09464835f, -0.02755230f, 0.04802729f, -0.04154789f, 0.25310060f, -0.16766196f, 
    -0.06968425f, -0.00072184f, 0.20815349f, 0.18490411f, -0.11636918f, -0.11759204f, 0.01442522f, -0.05949353f, 
    0.14767428f, 0.10573376f, 0.14917280f, 0.17149131f, 0.02536121f, 0.00993120f, 0.10672484f, -0.01378901f, 
    -0.02927387f, 0.26114622f, 0.05623137f, 0.01422421f, 0.15763791f, 0.07124548f, 0.04743522f, 0.02230395f, 
    -0.01790850f, 0.11076994f, 0.03257573f, 0.07982516f, 0.07568252f, 0.01530710f, -0.01397763f, -0.06887803f, 
    0.07661328f, -0.00742644f, -0.02740357f, -0.03576289f, -0.12289245f, 0.13413708f, -0.09032440f, -0.06021222f, 
    0.19364108f, 0.03885518f, 0.09840212f, 0.01285668f, 0.03335241f, 0.05411352f, 0.14225841f, -0.02526080f, 
    -0.10254774f, -0.13489012f, -0.01497652f, -0.00095230f, -0.05342006f, -0.10117657f, -0.18693313f, 0.02679099f, 
    -0.03913635f, -0.03532647f, -0.05421301f, -0.05813688f, -0.01496356f, 0.01314154f, -0.02988615f, 0.08113675f, 
    0.00886733f, 0.00962147f, 0.07977587f, 0.01448733f, 0.04435842f, 0.05164283f, 0.05682547f, -0.11062577f, 
    -0.08788677f, -0.01086805f, 0.12907022f, -0.09205673f, 0.24217746f, 0.07691117f, -0.19218211f, 0.22022079f, 
    -0.21085569f, -0.05765617f, -0.01953534f, 0.00360109f, 0.13984829f, 0.07567732f, 0.09226329f, -0.02518835f, 
    0.02798924f, -0.00144908f, 0.08212487f, -0.03354286f, 0.01496770f, 0.06397578f, -0.01501617f, -0.03061301f, 
    0.01227731f, 0.10407545f, 0.16051817f, -0.05490943f, -0.00880731f, -0.02525859f, 0.03233323f, -0.02431113f, 
    0.16731162f, 0.28435481f, 0.03385864f, 0.22104281f, 0.09659791f, 0.09663428f, -0.01263941f, -0.02132463f, 
    0.02244114f, 0.08020081f, 0.02604449f, 0.00693592f, 0.04315287f, 0.00274263f, -0.02066278f, -0.04431738f, 
    -0.18714675f, 0.09930914f, 0.16184273f, -0.02462646f, -0.08399317f, -0.15951264f, -0.01294769f, 0.09290341f, 
    -0.03646008f, 0.08637552f, 0.14182994f, 0.06250546f, -0.06081863f, -0.19229513f, 0.19248179f, 0.06918170f, 
    0.10106380f, 0.02198253f, 0.00215537f, -0.09900232f, 0.10226741f, 0.01537074f, 0.03675796f, -0.12291144f, 
    -0.13896105f, -0.13211639f, 0.12390637f, 0.07112286f, 0.08450866f, 0.03161336f, -0.04164262f, 0.24352923f, 
    0.07093749f, -0.05628560f, 0.03128025f, -0.01658218f, -0.18420704f, -0.19170080f, -0.23375605f, -0.01623855f, 
    -0.00375099f, -0.04591685f, 0.13087031f, -0.02684578f, 0.09967824f, -0.03256380f, 0.01252025f, 0.03985554f, 
    0.11544775f, 0.05379613f, -0.01676024f, 0.15138066f, -0.22616968f, -0.02042511f, -0.14966284f, 0.01470707f, 
    0.20729083f, -0.06370364f, -0.03071922f, -0.00428932f, 0.07999312f, 0.26293278f, 0.31667033f, -0.12304265f, 
    0.00217131f, -0.00367904f, 0.10777806f, 0.17560066f, -0.00425979f, 0.04367150f, -0.03002656f, -0.11860737f, 
    0.59702653f, 0.06281465f, -0.03843435f, -0.38461009f, -0.05802071f, -0.09570254f, 0.01636791f, -0.03706115f, 
    0.14975211f, -0.00276690f, 0.09572425f, 0.03025826f, -0.15151058f, -0.08467799f, -0.06391691f, 0.03317291f, 
    -0.03212162f, 0.04651443f, 0.09010302f, 0.00662656f, 0.07410480f, -0.00753176f, 0.01606194f, 0.04115775f, 
    0.29896292f, 0.09730821f, 0.29217145f, 0.17016803f, 0.02591346f, -0.09314250f, 0.01201417f, -0.03463339f, 
    0.08803291f, -0.09580254f, -0.11089528f, -0.10831349f, -0.35471728f, -0.32466120f, 0.15160124f, 0.10322915f, 
    -0.01562494f, -0.01977688f, 0.05597132f, 0.05114616f, 0.05710519f, -0.04260991f, -0.03293804f, 0.02126678f, 
    0.19675416f, -0.13858016f, 0.12306195f, -0.16451377f, 0.06983420f, 0.09896953f, -0.06203686f, 0.14635456f, 
    0.08080191f, 0.10914470f, 0.05662148f, 0.14991875f, -0.36664376f, -0.22728981f, -0.02277306f, 0.06228643f, 
    0.00457331f, 0.11481125f, -0.14780822f, 0.06195320f, 0.11375192f, 0.03563817f, 0.10463461f, -0.02937820f, 
    0.20714925f, -0.11181302f, 0.33831456f, -0.27603105f, -0.05419072f, 0.02831990f, -0.08094731f, -0.07677941f, 
    0.18780141f, -0.02244163f, 0.01628041f, -0.13269779f, -0.04446061f, 0.08351994f, -0.15955050f, -0.06967529f, 
    0.01611249f, 0.01678609f, 0.07677732f, -0.01442270f, 0.30065888f, -0.03797251f, -0.11557771f, 0.12706572f, 
    -0.14738040f, -0.00612683f, -0.22213462f, -0.23908001f, 0.07642996f, 0.12688923f, -0.04861053f, 0.02775265f, 
    0.07110804f, -0.01939341f, 0.01835490f, 0.01855581f, -0.05878493f, 0.02123034f, 0.03266137f, -0.03300208f, 
    -0.02502529f, 0.00341537f, 0.01698707f, -0.02755186f, -0.02506297f, -0.01021113f, -0.01105939f, 0.00505078f, 
    -0.13899991f, 0.10584272f, -0.14258619f, -0.03992928f, 0.16703935f, -0.11280733f, -0.14761318f, 0.16093311f, 
    0.06912560f, -0.12634929f, 0.07466318f, 0.04197506f, 0.14023146f, 0.11741728f, 0.15210989f, -0.23263672f, 
    -0.03143306f, -0.00371344f, -0.03496382f, 0.04051638f, 0.15940230f, -0.00322311f, -0.05342576f, 0.07298405f, 
    0.28168574f, -0.05129266f, -0.00575235f, -0.21999876f, -0.01791701f, 0.06332367f, -0.14599434f, 0.08376604f, 
    0.12270194f, -0.03369867f, 0.02094508f, 0.00744324f, 0.22710136f, 0.42451563f, 0.21804999f, -0.23869187f, 
    0.04413402f, -0.05464213f, 0.05754289f, 0.08330913f, 0.03663405f, 0.01275420f, -0.03792556f, -0.00851613f, 
    -0.21957798f, 0.26428810f, 0.36574146f, 0.20591702f, 0.05562007f, -0.01685480f, 0.15980096f, -0.13529643f, 
    0.07107104f, 0.04694428f, -0.32965887f, 0.00341464f, 0.04152520f, 0.25853175f, -0.10792840f, -0.19904347f, 
    0.00675031f, -0.00652669f, 0.04580724f, 0.11965859f, 0.12009162f, -0.09737273f, 0.08658523f, -0.11534794f, 
    -0.15673050f, -0.31730700f, 0.47325060f, -0.25674188f, 0.17070875f, 0.05125346f, -0.07137793f, 0.27767178f, 
    0.07695828f, 0.07909781f, 0.01171205f, 0.01910931f, 0.08062726f, 0.29527286f, 0.21158047f, 0.34952798f, 
    0.01967179f, 0.00288015f, 0.09656358f, -0.12355150f, 0.05675657f, 0.03902359f, -0.01747389f, 0.00534993f, 
    -0.23260383f, 0.08296969f, -0.29447928f, 0.00857313f, -0.05698668f, 0.06593464f, 0.09804998f, -0.00239934f, 
    0.11574637f, -0.03120786f, -0.00260160f, 0.04613141f, -0.05231217f, -0.10293599f, 0.07984439f, 0.10717580f, 
    -0.06038166f, 0.02850496f, 0.03698933f, 0.00025720f, 0.00432847f, -0.02372192f, -0.03261088f, -0.06524663f, 
    0.27090085f, 0.18877931f, 0.15761735f, -0.26156664f, -0.14455542f, -0.01599507f, -0.03794539f, -0.12565337f, 
    0.12338160f, 0.09121864f, -0.05512547f, 0.02502828f, -0.02875675f, 0.17154105f, 0.20298359f, -0.00196801f, 
    0.02501030f, 0.07885689f, 0.08700945f, 0.10967292f, 0.01738215f, 0.04394544f, 0.01655865f, 0.03568576f, 
    0.05880482f, -0.22369020f, 0.29663378f, 0.18090294f, 0.03311373f, 0.00688450f, -0.05710534f, 0.05602658f, 
    0.00882124f, -0.08092348f, 0.02954700f, -0.16031070f, -0.55416375f, -0.18192865f, -0.31497008f, -0.04741237f, 
    0.06806797f, 0.02179306f, 0.30063850f, -0.02790602f, -0.04805954f, 0.07208318f, -0.01333476f, -0.00863707f, 
    0.00879029f, 0.09495513f, 0.06000264f, -0.00001910f, -0.00244833f, -0.00469173f, 0.02733125f, 0.05851730f, 
    -0.06066396f, 0.11385601f, 0.17050879f, 0.03206225f, 0.01260695f, -0.00145063f, -0.09427648f, 0.24576117f, 
    -0.02834032f, -0.05865196f, -0.02850203f, 0.00980656f, 0.03413204f, -0.03004894f, 0.01698137f, -0.14102150f, 
    -0.41237465f, 0.32047108f, -0.30777264f, -0.08732309f, -0.23020947f, 0.00128868f, -0.06047428f, 0.06934974f, 
    0.08211458f, -0.11158174f, 0.01255199f, -0.05415385f, 0.03415548f, -0.00280751f, 0.07946467f, -0.27853826f, 
    -0.05127468f, 0.25469285f, -0.04332840f, 0.04347958f, 0.13007055f, 0.03732463f, 0.09511136f, 0.06659836f, 
    -0.16565090f, -0.17966568f, 0.33475411f, 0.26062509f, 0.07079996f, -0.00043107f, -0.04670128f, 0.03266223f, 
    0.08701755f, 0.08184260f, 0.07345031f, 0.09161803f, -0.24895114f, 0.30156627f, -0.40558809f, 0.19197904f, 
    -0.05081081f, 0.03487573f, -0.09140950f, -0.01461940f, -0.01187575f, -0.04534271f, -0.09988535f, 0.02882024f, 
    -0.01710964f, -0.06384581f, 0.01879424f, 0.07183890f, -0.01691533f, -0.05585948f, 0.05278416f, -0.03990806f, 
    -0.03287461f, 0.05845456f, 0.06008165f, -0.01691338f, 0.29775769f, -0.06460690f, 0.08403400f, -0.35413080f, 
    0.12165650f, -0.01884493f, -0.08465471f, 0.30966288f, 0.18133689f, 0.00316523f, 0.07943451f, -0.03180900f, 
    0.10744011f, -0.08065532f, 0.21611644f, -0.25090012f, -0.07609285f, 0.02141540f, -0.16905969f, 0.11859220f, 
    0.19951116f, -0.08549718f, -0.07196042f, -0.08107710f, -0.03112759f, 0.20271178f, 0.20893006f, 0.28376278f, 
    -0.01076649f, -0.09384437f, 0.07858585f, 0.07867244f, 0.02633665f, -0.02903581f, -0.00942421f, 0.00035035f, 
    0.06233994f, -0.15514427f, 0.01745339f, -0.04120405f, 0.00972623f, 0.03644267f, -0.02542135f, -0.04125542f, 
    0.03301583f, -0.09718787f, -0.06027625f, -0.02480517f, -0.12935165f, 0.11918571f, 0.04467370f, 0.40891129f, 
    -0.03761597f, -0.16077323f, 0.01459960f, 0.07565142f, 0.06509921f, -0.00440459f, -0.05277130f, -0.14730385f, 
    -0.24273492f, -0.17603137f, -0.11718494f, -0.00251997f, 0.15416633f, 0.12777793f, -0.00231057f, -0.05032481f, 
    0.05522833f, -0.00221000f, -0.00909360f, -0.06126096f, -0.25023645f, 0.17404157f, 0.25319937f, 0.14848581f, 
    0.07746635f, 0.06992663f, 0.09036242f, 0.22289398f, 0.04528182f, 0.01213316f, 0.08701994f, -0.00586222f, 
    -0.22626671f, 0.02045251f, 0.13754070f, 0.24150032f, -0.05662230f, -0.29295066f, -0.12827715f, -0.14688271f, 
    0.02083266f, -0.02694290f, 0.04889828f, 0.02380726f, 0.13685521f, 0.22532155f, 0.00732646f, 0.09628603f, 
    -0.07014281f, -0.09140571f, -0.04991581f, -0.09418547f, 0.00415342f, -0.11137506f, 0.11879446f, 0.12664670f, 
    0.55585146f, 0.08553082f, 0.22368193f, -0.17206526f, -0.12229114f, -0.06911216f, -0.10766991f, -0.07398297f, 
    -0.07560842f, 0.00030737f, 0.10332682f, 0.06878933f, -0.10487340f, -0.02330721f, -0.34243208f, 0.00117696f, 
    0.00937745f, -0.00337234f, -0.05042507f, 0.10920765f, 0.13545153f, -0.00102927f, -0.00407047f, 0.05081099f, 
    0.07243435f, -0.00118493f, 0.03600711f, 0.01663200f, 0.00398058f, 0.05898776f, 0.04994175f, 0.06424659f, 
    0.02658148f, 0.04887953f, 0.12967169f, -0.05240978f, 0.07349665f, -0.11054716f, 0.03581970f, 0.20939039f, 
    0.04234900f, 0.03931423f, -0.09179686f, -0.00105474f, 0.02434808f, 0.07166877f, -0.14238466f, 0.07120661f, 
    0.25500888f, -0.04575066f, 0.29492506f, -0.07443826f, 0.09547547f, 0.12207415f, 0.09164506f, -0.15492791f, 
    0.00681436f, -0.05630269f, -0.01806664f, 0.03426964f, -0.01523117f, -0.41053894f, 0.16381581f, -0.10377034f, 
    0.09722884f, 0.06573565f, 0.03807988f, 0.07486305f, 0.02262127f, 0.09720167f, 0.05268041f, 0.03596535f, 
    0.28711054f, -0.32113793f, 0.64043778f, 0.11187113f, -0.02945693f, -0.04745428f, 0.02955567f, -0.01579594f, 
    0.15359809f, -0.02647706f, 0.02766337f, -0.12057943f, 0.21697092f, -0.02910454f, -0.09624821f, -0.37051660f, 
    0.17323098f, -0.02830363f, 0.15048172f, 0.13060133f, 0.19781668f, 0.06743571f, -0.19439349f, 0.19365889f, 
    0.01152934f, 0.15675718f, 0.29658270f, 0.19905651f, -0.08340300f, -0.05750816f, 0.00296575f, -0.00005718f, 
    0.09510262f, -0.00603614f, -0.03101121f, 0.08555112f, 0.01211482f, 0.10392363f, -0.07987949f, -0.09320580f, 
    0.16050395f, -0.12745079f, 0.07856762f, 0.12968732f, 0.02743996f, -0.05212532f, 0.01100084f, 0.07473420f, 
    0.09237111f, -0.08397526f, -0.12406478f, 0.06087368f, -0.03097410f, -0.03966093f, -0.01017753f, 0.06636665f, 
    -0.00985734f, -0.02748198f, -0.03965201f, 0.08010209f, 0.15418862f, 0.05959051f, -0.05816082f, -0.18804885f, 
    -0.12550062f, -0.06430312f, -0.09706810f, 0.17170183f, 0.12685628f, -0.03854807f, -0.14183593f, 0.12257520f, 
    -0.18664032f, 0.05249440f, 0.18531509f, 0.12291308f, 0.07884874f, 0.15313168f, 0.24222693f, 0.07211427f, 
    0.05643471f, 0.04308404f, 0.05889021f, 0.01110873f, 0.07066187f, -0.02067181f, 0.14877965f, -0.07768886f, 
    0.16019918f, 0.01417062f, -0.00223908f, -0.04798046f, 0.01526241f, 0.00321539f, -0.06863168f, 0.10119786f, 
    -0.11954971f, -0.05072579f, -0.04743524f, 0.16575857f, 0.08200633f, 0.08547102f, -0.00183776f, 0.15957771f, 
    0.23048024f, 0.12682831f, 0.01411037f, 0.05329970f, -0.01132909f, -0.06685719f, 0.01964931f, 0.07165692f, 
    0.01666213f, 0.01418935f, -0.06658857f, 0.00371759f, 0.10906363f, -0.16580905f, 0.04648284f, 0.00658781f, 
    0.13770556f, 0.02133383f, -0.06939700f, -0.03920163f, 0.04764005f, -0.04266698f, 0.05295410f, -0.00263901f, 
    -0.08136586f, -0.06584401f, 0.16484220f, -0.00347201f, 0.01438050f, -0.28263786f, -0.01524070f, 0.00807635f, 
    0.03148394f, -0.05975793f, 0.03834095f, 0.02553747f, 0.09973287f, 0.02392644f, 0.02628038f, 0.03597875f, 
    0.14075002f, 0.21595681f, 0.12401021f, -0.20914753f, -0.00455350f, -0.06801996f, 0.11510109f, -0.12690289f, 
    0.07416692f, 0.10512133f, 0.01973635f, -0.00195802f, -0.23868974f, 0.21149060f, -0.15502013f, -0.05613042f, 
    0.12889798f, -0.03567193f, 0.14011817f, -0.00385317f, 0.07260391f, 0.02387057f, 0.02028757f, 0.01558137f, 
    0.00923028f, 0.00203628f, 0.01246255f, 0.01019588f, -0.02036838f, -0.03156651f, 0.01113280f, -0.04080610f, 
    -0.01625111f, -0.00776912f, 0.00265711f, -0.02123631f, -0.02193371f, -0.04067585f, -0.00415023f, -0.02575732f, 
    -0.00447126f, -0.03432272f, 0.01229427f, 0.01148684f, 0.02906266f, -0.00858661f, 0.03713378f, 0.00206136f, 
    -0.02636417f, 0.00211624f, -0.01029879f, 0.02233567f, -0.00571385f, 0.00540890f, -0.00501658f, 0.01275256f, 
    0.00819638f, 0.01979553f, -0.00043593f, 0.02142657f, -0.02769702f, -0.01983324f, 0.01655959f, -0.02419518f, 
    -0.04098767f, 0.00120870f, -0.01367624f, 0.02420399f, 0.02703160f, -0.00532549f, 0.01211341f, -0.02020818f, 
    0.01637145f, 0.01823976f, 0.01529134f, 0.00047834f, -0.00894087f, -0.00267052f, 0.02641891f, -0.00175762f, 
    -0.00099512f, -0.03570188f, 0.00449926f, -0.02275631f, -0.03944850f, 0.02803991f, -0.03367212f, 0.00697261f, 
    -0.03069279f, -0.03269748f, -0.01812465f, -0.01851231f, -0.02286877f, -0.02617365f, -0.00685785f, -0.03714472f, 
    0.01730954f, -0.00473596f, 0.01619961f, -0.02539160f, -0.01466443f, 0.02015411f, -0.01185361f, -0.01941600f, 
    -0.01512580f, 0.00776639f, 0.01834708f, 0.00804450f, -0.01696883f, -0.02687885f, -0.03358566f, 0.02838764f, 
    0.02409429f, -0.03754181f, -0.03925750f, -0.00556462f, -0.02620365f, -0.04036995f, -0.00674312f, 0.01176464f, 
    0.01390342f, 0.01188373f, -0.02460234f, -0.03707721f, -0.04079130f, -0.02660779f, 0.01537009f, -0.04028164f, 
    -0.01288110f, -0.03510428f, -0.04111247f, -0.00259442f, -0.02401069f, 0.02293996f, 0.02172261f, -0.00844110f, 
    0.02043196f, -0.00578309f, -0.03721477f, -0.03698529f, -0.02841785f, 0.00134117f, 0.00998904f, -0.03066046f, 
    -0.01118214f, -0.01468353f, -0.01129401f, 0.01494971f, -0.00640889f, -0.00026916f, 0.01778799f, -0.01573002f, 
    0.02371240f, -0.01388161f, -0.01759234f, -0.00488313f, -0.01932932f, -0.02176300f, -0.00282259f, 0.00310922f, 
    0.00385531f, -0.00682859f, -0.02503230f, -0.00904892f, 0.01983584f, 0.02286076f, -0.02572667f, -0.02764337f, 
    0.00307570f, 0.01487857f, 0.02847306f, 0.00948959f, 0.02292670f, -0.01526288f, 0.02551791f, 0.00481577f, 
    -0.02533941f, -0.02675914f, -0.02087041f, -0.01990436f, 0.02911818f, -0.01305581f, -0.02210619f, 0.00236976f, 
    -0.00152890f, 0.01685366f, -0.00698139f, 0.02988079f, -0.03701083f, -0.00806173f, -0.01927119f, 0.02644304f, 
    -0.02444133f, 0.02239901f, -0.04204794f, -0.04006543f, -0.00942695f, -0.01447316f, -0.03461280f, 0.00698243f, 
    -0.01038265f, 0.01083290f, 0.00769192f, 0.01694782f, -0.02962463f, 0.00336066f, -0.03709749f, 0.04168457f, 
    0.02440644f, -0.02010787f, 0.00240896f, -0.00325336f, -0.03534233f, -0.00225275f, -0.03881397f, 0.02017671f, 
    -0.00885649f, 0.01213533f, -0.03529951f, 0.00272133f, -0.01332553f, 0.00736027f, 0.02638411f, 0.01853419f, 
    0.00160777f, 0.00154933f, 0.02263258f, 0.02480606f, -0.01714649f, -0.03314934f, 0.01157997f, -0.02102664f, 
    0.01559569f, -0.00969218f, 0.01670619f, 0.00163815f, 0.01054649f, 0.01717793f, 0.02966662f, 0.00124495f, 
    -0.02382927f, -0.01630021f, -0.01867319f, 0.00825964f, 0.02220876f, 0.02220622f, -0.01178029f, -0.02880240f, 
    -0.02721936f, -0.00249469f, -0.02986400f, -0.02927241f, 0.02410766f, -0.02219547f, 0.03747954f, -0.00655338f, 
    -0.01857375f, -0.03572728f, -0.02570688f, -0.00825410f, -0.04090739f, -0.01739807f, 0.03933208f, 0.00971513f, 
    0.02702094f, 0.03917806f, 0.00029851f, -0.01921383f, 0.01985061f, 0.01144659f, 0.00906276f, -0.00112850f, 
    -0.02881930f, -0.01421214f, 0.02197726f, 0.02119555f, -0.01119289f, 0.00792741f, 0.04109788f, 0.03569188f, 
    0.02156270f, -0.02941384f, 0.00623001f, -0.02042946f, -0.02131999f, -0.01803904f, -0.01195362f, 0.00324174f, 
    -0.00092816f, 0.01577643f, -0.00528891f, -0.01358799f, -0.00994044f, -0.00016697f, 0.02793005f, -0.00256283f, 
    -0.03921406f, -0.04176911f, -0.02609537f, -0.03971562f, -0.00795385f, 0.02425478f, -0.04034367f, -0.01046739f, 
    0.01853469f, 0.00880539f, -0.03037011f, 0.00100267f, 0.02192401f, -0.02000517f, 0.00928295f, 0.00448113f, 
    -0.03204668f, 0.03322087f, -0.00229222f, -0.01903432f, -0.04050353f, -0.00189742f, -0.03087766f, 0.02308181f, 
    0.02376285f, -0.00192527f, -0.00146553f, -0.03253786f, -0.01470622f, 0.00358483f, -0.00726552f, -0.02995242f, 
    0.02187888f, -0.02087300f, 0.00690557f, -0.03873769f, 0.00152612f, 0.02935389f, 0.01549958f, 0.02386417f, 
    -0.02546307f, 0.00825748f, 0.01471321f, -0.00257199f, -0.04202024f, -0.01882613f, -0.00430608f, -0.01935965f, 
    -0.01987124f, -0.03781438f, -0.03419494f, -0.03986721f, 0.02025874f, 0.01593294f, 0.01456335f, 0.00690378f, 
    0.00228479f, -0.00602461f, -0.04196906f, -0.01291115f, 0.02320459f, -0.02547015f, -0.02958369f, -0.00349379f, 
    0.01191592f, 0.01868123f, -0.01028202f, -0.01926062f, 0.01987662f, -0.00657090f, 0.01101355f, 0.01090259f, 
    0.01639668f, -0.04186023f, 0.00704499f, 0.02167837f, -0.02231678f, 0.01670025f, 0.02000079f, -0.00188908f, 
    -0.00499407f, -0.00244197f, -0.00718835f, 0.02306383f, -0.03771348f, 0.00651474f, 0.02206357f, -0.02844407f, 
    -0.01620067f, -0.02111242f, 0.02729874f, 0.00120839f, 0.02994031f, 0.01716912f, -0.01037296f, -0.00660179f, 
    -0.02919302f, -0.00468810f, -0.01053342f, 0.01648073f, 0.02604850f, -0.01580221f, -0.03676629f, -0.03739817f, 
    -0.03914973f, 0.01781721f, -0.00447671f, 0.00604139f, 0.00069897f, -0.01925573f, 0.02586366f, -0.03340879f, 
    -0.00937830f, -0.03229345f, -0.03016151f, -0.01254908f, 0.02281580f, -0.00076151f, 0.00264538f, -0.02422784f, 
    0.02897947f, -0.00949777f, 0.00873003f, -0.03754405f, 0.01508995f, -0.00947478f, -0.00824547f, -0.00279403f, 
    -0.04079653f, -0.03014887f, -0.03711272f, -0.00981758f, -0.01721818f, 0.02693641f, -0.02135886f, 0.01075496f, 
    0.01851869f, -0.03410903f, -0.02123890f, -0.03446540f, 0.01756049f, 0.00651572f, -0.01969212f, 0.02099400f, 
    -0.00814136f, -0.02434690f, 0.01819972f, -0.03376770f, -0.03881152f, -0.01608112f, -0.02036687f, -0.03689715f, 
    0.02691144f, -0.01532115f, 0.02055698f, 0.01253147f, -0.00059060f, 0.01168664f, -0.00389313f, -0.02920482f, 
    0.00700531f, -0.00713957f, -0.00299781f, -0.02460474f, -0.02922762f, -0.00692978f, 0.00732520f, -0.02122093f, 
    -0.00653840f, 0.02339288f, -0.02496201f, -0.01547308f, -0.04082175f, 0.02676554f, 0.00551332f, -0.00473257f, 
    -0.01365187f, 0.02939052f, -0.02869099f, -0.00935088f, -0.01748130f, -0.01516767f, -0.00128662f, 0.00192691f, 
    -0.02959735f, 0.02304531f, 0.00875645f, -0.01462210f, 0.00795172f, -0.01822506f, -0.02922189f, -0.03508128f, 
    -0.02138261f, 0.01209518f, 0.02980057f, 0.00657000f, -0.01476648f, 0.03323545f, 0.03326574f, -0.04066366f, 
    0.02727388f, 0.02418509f, 0.01519082f, -0.04044089f, -0.00088405f, -0.00268369f, 0.02889089f, 0.01457445f, 
    -0.01813029f, -0.01621259f, 0.02224552f, -0.03664955f, -0.03882802f, 0.00862837f, -0.03700728f, 0.02245561f, 
    -0.03919822f, 0.02160471f, -0.03949221f, -0.00529801f, 0.00575629f, 0.00057781f, -0.02119480f, -0.02767475f, 
    -0.00450677f, -0.02964852f, -0.02452113f, 0.00764351f, 0.00108340f, -0.00176982f, -0.00962451f, 0.02356627f, 
    -0.00076764f, -0.02771610f, -0.00580375f, 0.00721909f, -0.01376695f, 0.00244064f, -0.01799019f, -0.00562472f, 
    -0.02022248f, 0.01756999f, 0.00867118f, -0.00878415f, 0.02229099f, 0.01740040f, -0.00926850f, 0.00193910f, 
    0.00778316f, 0.00278094f, -0.00370621f, 0.02841128f, -0.03905125f, -0.00398300f, 0.00638158f, 0.01396488f, 
    0.01414288f, 0.03002540f, 0.00089556f, -0.01500806f, 0.02125976f, -0.01491077f, -0.03178087f, 0.02956774f, 
    -0.02979517f, -0.02336262f, -0.03116370f, 0.00423219f, -0.00664793f, 0.00235207f, -0.00077392f, 0.01263352f, 
    -0.04120076f, 0.00147784f, -0.03282074f, -0.02141458f, 0.01069892f, -0.01700292f, 0.01604792f, 0.02105507f, 
    0.02037838f, 0.00891507f, 0.00297800f, 0.01029605f, -0.01014511f, -0.02240231f, -0.01244546f, -0.02265903f, 
    0.02840921f, -0.00433990f, -0.03923906f, 0.01332953f, -0.03837454f, -0.02308600f, 0.02327813f, -0.02361541f, 
    -0.00638060f, 0.00289341f, 0.02275157f, -0.02315599f, 0.02955223f, 0.01846505f, 0.02574608f, -0.01531777f, 
    0.00385601f, -0.02435749f, 0.01457884f, -0.00742781f, 0.01623367f, -0.02447725f, 0.00593135f, 0.02454208f, 
    -0.01919193f, 0.02614290f, 0.00875650f, 0.01542964f, 0.02785426f, -0.01545317f, 0.00052784f, -0.03141411f, 
    -0.04019317f, -0.00452710f, 0.00024599f, -0.02653652f, 0.01932036f, 0.01430798f, 0.02746726f, -0.00605344f, 
    0.02078188f, 0.01070753f, 0.00714259f, 0.02515311f, 0.02863962f, 0.01706484f, -0.01748841f, -0.01010576f, 
    0.00487145f, 0.00078145f, 0.01823060f, -0.02558231f, 0.01586586f, -0.02790194f, -0.01188320f, -0.03939448f, 
    -0.02255659f, -0.03251239f, -0.00475814f, -0.02991497f, -0.02068991f, 0.01945011f, -0.03525661f, -0.01790131f, 
    0.00826825f, 0.00558996f, 0.00353501f, -0.02893570f, -0.02739916f, -0.02328390f, 0.00668375f, 0.02569364f, 
    -0.02230889f, -0.03333446f, 0.00087218f, -0.01716729f, 0.00583719f, 0.00032042f, -0.00752444f, -0.02432483f, 
    -0.00039440f, 0.02704060f, -0.02003594f, -0.03335831f, -0.00945723f, -0.03194563f, -0.01581150f, 0.01207830f, 
    -0.02370743f, 0.02554364f, -0.03108515f, 0.02125823f, 0.02867150f, 0.02866546f, -0.01467243f, 0.01532992f, 
    0.02286479f, 0.00036158f, -0.00016946f, 0.00533642f, -0.01463287f, -0.03441945f, 0.02950402f, -0.01443377f, 
    -0.01044568f, 0.00371284f, 0.01283736f, 0.02649970f, 0.00706662f, -0.02838811f, -0.00248984f, 0.00247985f, 
    0.02169771f, -0.02436498f, -0.02195645f, 0.03788172f, 0.00562966f, -0.02736040f, -0.03097132f, 0.02579046f, 
    0.01729462f, -0.03377302f, -0.00709750f, -0.01895523f, -0.01178097f, 0.01003797f, 0.01438185f, 0.01274467f, 
    -0.00944343f, 0.02520986f, 0.02693192f, 0.01309165f, 0.01868928f, -0.00854125f, -0.02679501f, -0.02029652f, 
    -0.00688724f, 0.02089355f, 0.00231534f, 0.01933732f, 0.01837572f, -0.02306192f, -0.02045068f, -0.03426257f, 
    -0.04082532f, 0.00496675f, 0.01910660f, 0.00954796f, -0.02017702f, -0.03603444f, -0.02209924f, -0.00037774f, 
    0.01612148f, -0.02422576f, -0.02543435f, 0.00542932f, -0.01901508f, -0.03037849f, -0.02100352f, 0.02571710f, 
    0.02662424f, 0.01229967f, -0.03252269f, 0.02570353f, 0.00853539f, -0.00513552f, 0.00037986f, -0.02089228f, 
    -0.00730786f, -0.00741249f, 0.00133987f, -0.02813426f, -0.00460361f, -0.02862141f, -0.03105752f, 0.01425357f, 
    0.01733676f, 0.02744009f, -0.00695539f, -0.03655041f, -0.04010589f, -0.02956067f, -0.01874848f, -0.01908160f, 
    0.00695016f, -0.02629630f, -0.04104408f, -0.00006874f, -0.03297651f, -0.02092535f, -0.01004348f, 0.01546218f, 
    -0.02034528f, -0.01698092f, -0.03595268f, -0.02955726f, -0.02681245f, 0.02382663f, -0.02093452f, -0.02872988f, 
    0.00052042f, 0.02589470f, -0.00842569f, -0.02955490f, -0.01042276f, -0.02905559f, 0.01457581f, -0.00783488f, 
    0.04065262f, -0.10313386f, -0.35052329f, -0.22143519f, -0.02073670f, -0.00400668f, -0.06453425f, -0.04193604f, 
    0.02626527f, -0.03745135f, -0.03445064f, 0.02726565f, 0.09483278f, -0.05909124f, 0.30633450f, 0.11515878f, 
    -0.00702194f, -0.06098349f, 0.15526505f, -0.14771613f, 0.03452503f, 0.00849294f, -0.04745666f, 0.05645204f, 
    -0.27465951f, 0.46329966f, 0.01920627f, -0.07080817f, -0.00195129f, -0.03857597f, 0.19666004f, 0.12510879f, 
    0.11350232f, 0.01625572f, 0.03874885f, 0.15667304f, -0.03736466f, -0.11866888f, -0.17522514f, 0.06127331f, 
    0.04421693f, 0.05445822f, -0.06340496f, 0.02200222f, -0.00387430f, 0.01329722f, -0.08157444f, -0.00992939f, 
    -0.05209545f, 0.37568659f, 0.19710933f, 0.00431766f, 0.14018989f, -0.06301176f, -0.14484522f, 0.06367444f, 
    -0.02373830f, 0.09611321f, -0.00281197f, -0.01287405f, 0.02667082f, -0.21628185f, -0.06147922f, 0.07824676f, 
    -0.05477991f, -0.05749209f, 0.04110909f, -0.02734121f, -0.07712776f, -0.02213264f, 0.00779271f, 0.00592212f, 
    -0.00689803f, 0.17347828f, 0.18077581f, 0.12079301f, 0.10308264f, 0.06385829f, 0.04369169f, 0.00642382f, 
    0.12856933f, 0.14128245f, 0.06499065f, 0.06509175f, -0.19974557f, 0.59766048f, -0.37998253f, 0.18900581f, 
    0.03170313f, -0.12442433f, -0.06291696f, -0.06101941f, -0.11868663f, -0.01472355f, 0.00520133f, 0.04897624f, 
    0.16476195f, 0.05155286f, -0.05172125f, -0.02898475f, -0.04743397f, 0.05442393f, -0.08998457f, 0.09909506f, 
    -0.07409015f, -0.02165928f, 0.04038526f, -0.01273296f, 0.10148495f, 0.07645517f, -0.22251156f, 0.12928520f, 
    -0.03398179f, 0.06764293f, 0.20685792f, -0.00935378f, 0.01490043f, -0.09293897f, 0.06305520f, -0.04054626f, 
    -0.28981662f, 0.22079267f, 0.10674232f, 0.01926365f, -0.08522382f, 0.06573559f, -0.00325700f, -0.10548148f, 
    -0.12926464f, 0.27765366f, 0.21057241f, 0.28038457f, -0.17672029f, -0.05395756f, 0.11457306f, 0.02881535f, 
    -0.08965512f, 0.08107515f, -0.02498448f, -0.00317705f, 0.20347422f, 0.00494322f, -0.09137494f, 0.01566371f, 
    -0.48221335f, 0.04598349f, 0.23802131f, 0.09533832f, -0.06911521f, -0.04297568f, 0.08611494f, 0.01692355f, 
    -0.03994872f, 0.00427150f, -0.02406136f, 0.00670077f, -0.08175301f, 0.00622122f, -0.00605622f, 0.04151798f, 
    0.09006443f, 0.01882893f, 0.06284843f, 0.02358299f, -0.04956786f, 0.07712848f, 0.01150155f, 0.02370169f, 
    0.06926201f, 0.06299908f, 0.14925079f, -0.16869940f, 0.10803613f, 0.08255409f, -0.09805205f, -0.19153361f, 
    0.20824319f, -0.13890018f, 0.00462033f, 0.03614346f, 0.18812610f, -0.01961323f, 0.09083284f, 0.26890114f, 
    -0.01126635f, -0.00236455f, 0.04109672f, -0.10867626f, 0.00365239f, 0.05027183f, 0.09617369f, 0.12405945f, 
    -0.14765821f, -0.23501660f, -0.04543927f, 0.13100162f, -0.08445379f, 0.09400696f, -0.03521740f, 0.08702274f, 
    -0.16682076f, 0.06110017f, 0.04323484f, 0.02227989f, -0.01327709f, -0.03010188f, -0.17096642f, -0.13807045f, 
    -0.03304709f, -0.04432367f, 0.08897670f, 0.24438997f, 0.02039646f, 0.12704258f, -0.06376263f, -0.02516836f, 
    0.43568760f, 0.00284688f, 0.23999090f, 0.26570454f, 0.20032200f, -0.03611188f, -0.07854175f, -0.20388247f, 
    -0.11104892f, 0.04914342f, -0.02286370f, -0.21120359f, 0.05657160f, 0.11681922f, 0.19397101f, 0.09177119f, 
    -0.06424604f, -0.15256216f, -0.23003395f, 0.06402550f, -0.05251483f, -0.20829371f, -0.08195406f, -0.02712280f, 
    0.02113733f, -0.06187201f, -0.18904090f, 0.11884201f, -0.10485326f, -0.06938745f, -0.06338223f, -0.14343368f, 
    -0.05830200f, -0.04958021f, -0.02935772f, -0.07831407f, 0.04715370f, 0.02451840f, 0.04489883f, 0.24093330f, 
    0.00419083f, 0.00591476f, 0.04680739f, 0.07234246f, -0.16248341f, -0.03453739f, 0.14687048f, 0.06588635f, 
    -0.10879079f, 0.17143744f, 0.24919108f, -0.17281303f, -0.03891380f, 0.00113726f, 0.05297538f, 0.05651839f, 
    -0.03080016f, -0.02872261f, -0.07453961f, 0.01971349f, -0.04972878f, -0.02878889f, -0.00804766f, 0.09554750f, 
    0.00492076f, 0.06539006f, -0.00928038f, 0.03717050f, -0.04707604f, 0.08042324f, 0.08243075f, 0.11089282f, 
    0.09005356f, 0.14935602f, -0.00388185f, 0.07201345f, 0.07254337f, -0.02339571f, -0.04450199f, -0.06190498f, 
    -0.22753523f, -0.12880722f, -0.07324040f, -0.06429779f, -0.05744522f, -0.16065162f, -0.09117185f, -0.06617311f, 
    -0.03136519f, -0.04398225f, 0.09219799f, 0.19944963f, -0.00496617f, 0.07280955f, -0.02146171f, -0.03918066f, 
    -0.04582658f, -0.06311002f, -0.21603172f, 0.08047488f, 0.11430750f, 0.14373557f, 0.04428490f, -0.07725044f, 
    -0.13016303f, -0.06087208f, -0.00512923f, 0.24549361f, -0.06183753f, -0.00773715f, -0.17390868f, -0.07539915f, 
    -0.01911428f, -0.10312080f, 0.05065366f, 0.01920671f, -0.01652870f, 0.02613916f, -0.04941104f, -0.03934569f, 
    0.02164058f, -0.00450676f, 0.10009088f, 0.16338134f, 0.04006083f, 0.04800024f, -0.01928630f, 0.02403667f, 
    0.00826726f, 0.11948285f, -0.07367422f, 0.09043022f, -0.12844384f, 0.20650911f, 0.02926818f, 0.19392109f, 
    0.06920852f, -0.01840123f, 0.03687970f, 0.05121354f, -0.09681179f, 0.01934758f, 0.02351998f, 0.01928888f, 
    0.02486650f, 0.19566229f, 0.12534723f, -0.02922615f, -0.11951564f, -0.07756569f, 0.05118763f, 0.17126372f, 
    -0.01518191f, 0.01024685f, -0.02135779f, -0.03641070f, 0.10145111f, 0.05561503f, 0.08751318f, 0.10159021f, 
    0.08803622f, -0.04677311f, 0.11855154f, 0.08605337f, 0.00959139f, -0.09098554f, 0.03633913f, 0.01069278f, 
    -0.26192102f, 0.61979151f, -0.09495091f, -0.13913897f, 0.04773670f, 0.17601283f, -0.04068949f, -0.09795125f, 
    0.02309876f, -0.03263683f, -0.01161130f, 0.06565866f, 0.25908691f, -0.16122414f, 0.23547128f, -0.34148851f, 
    -0.09009719f, -0.08553010f, 0.08552080f, -0.00898151f, 0.19335490f, 0.10838535f, 0.00971014f, -0.14419742f, 
    -0.08140428f, 0.09548613f, 0.05542800f, 0.06575715f, 0.02620367f, -0.02069832f, 0.01596849f, 0.08548520f, 
    0.05913674f, 0.09227222f, 0.03837503f, 0.12112845f, 0.11377753f, -0.21235211f, -0.03172281f, -0.04740315f, 
    -0.05205005f, -0.00561130f, -0.15446144f, -0.24441732f, -0.19943200f, 0.13298570f, -0.06104451f, -0.02709184f, 
    0.09077313f, -0.17743883f, -0.10962307f, 0.11105157f, 0.01801451f, 0.17039810f, 0.02266411f, -0.04099435f, 
    0.20951550f, 0.07055969f, 0.06571378f, 0.18960251f, 0.10224140f, 0.16499987f, -0.06117470f, 0.05494111f, 
    -0.00105932f, -0.07491437f, 0.00428233f, 0.10531349f, -0.07842363f, -0.18599388f, 0.03082286f, -0.01764607f, 
    -0.04534313f, 0.28517368f, -0.08234233f, 0.02474084f, -0.10610881f, -0.09347840f, 0.06043281f, -0.13161741f, 
    0.11276340f, 0.19856429f, 0.26733243f, 0.35010898f, 0.03076728f, -0.02439047f, -0.13204345f, -0.12672298f, 
    0.17948253f, 0.11466132f, -0.01436136f, 0.11022125f, -0.03789233f, -0.00921346f, 0.14873143f, 0.14976719f, 
    0.01018397f, 0.22101492f, -0.17815652f, -0.16591632f, 0.04256449f, 0.02127370f, 0.18831089f, 0.23206168f, 
    0.02554884f, 0.09572263f, -0.07355430f, -0.03048240f, 0.25459796f, 0.04935815f, 0.06656766f, 0.17076620f, 
    -0.07760400f, 0.00858709f, -0.04956214f, 0.03004473f, -0.05916690f, -0.06312197f, -0.04836738f, 0.02352309f, 
    0.09978028f, 0.16435868f, 0.13058035f, 0.13132289f, 0.04924044f, 0.06392210f, -0.08491357f, -0.01557331f, 
    0.12666540f, 0.08700366f, 0.13578105f, 0.10070798f, 0.21435300f, 0.34604874f, 0.29049167f, 0.16793987f, 
    -0.04095867f, -0.06058723f, 0.07499427f, -0.03086097f, -0.01977977f, 0.11409639f, -0.01428793f, 0.17628422f, 
    0.23373443f, 0.58290648f, 0.23540018f, 0.28356946f, 0.08907253f, -0.01846555f, 0.05237411f, -0.11833619f, 
    -0.10693186f, 0.08088418f, -0.03425971f, 0.07862690f, -0.04271096f, 0.01867448f, -0.24427500f, -0.03558001f, 
    -0.08057570f, -0.03540462f, 0.11664159f, 0.10447292f, 0.05732117f, 0.05912964f, -0.03942871f, 0.00237980f, 
    -0.01530496f, 0.09749745f, 0.14464940f, 0.00363121f, 0.14186494f, -0.16719940f, 0.01035513f, 0.04423361f, 
    0.00595484f, -0.06668834f, 0.03378086f, 0.03187136f, -0.17761971f, 0.03468813f, -0.01964222f, 0.12063570f, 
    0.00979953f, 0.08177234f, 0.02548610f, 0.01653997f, 0.17829934f, 0.15038906f, -0.01298396f, 0.28956929f, 
    0.05754116f, -0.01278213f, 0.02591180f, 0.16210562f, 0.01191106f, -0.05650604f, -0.02130111f, -0.00412051f, 
    -0.02500042f, 0.26324224f, 0.11129250f, 0.21267729f, -0.26202941f, 0.02966172f, -0.17140926f, 0.26587731f, 
    0.02417818f, 0.11938171f, 0.02481741f, -0.00367050f, -0.09579404f, -0.05125650f, 0.05976274f, -0.01619230f, 
    0.16394849f, 0.07361965f, 0.05552441f, 0.44545552f, 0.16854422f, 0.08545472f, -0.02346369f, -0.07987587f, 
    -0.22378282f, -0.00957399f, 0.00607475f, -0.01004876f, 0.15525702f, -0.26231265f, -0.01187286f, -0.10523162f, 
    -0.08439812f, 0.10367244f, -0.16751887f, -0.09825590f, -0.12541442f, 0.18924803f, -0.17539039f, 0.01534281f, 
    0.08727876f, 0.11524762f, 0.12850939f, 0.14520897f, 0.00306840f, -0.00616337f, -0.01501157f, -0.15049298f, 
    -0.09336144f, 0.19318253f, 0.20826471f, 0.31377146f, 0.05286683f, -0.03673470f, 0.13785216f, -0.05011417f, 
    -0.00015516f, 0.00273049f, -0.12458044f, -0.12200197f, 0.19994032f, 0.05305154f, -0.05304011f, 0.06710834f, 
    0.01381154f, 0.00256403f, 0.02907242f, 0.00030221f, 0.03300341f, -0.01585263f, 0.05423747f, 0.07623528f, 
    -0.01791923f, -0.08380403f, -0.03940433f, 0.01130685f, 0.13200398f, -0.09969935f, 0.12109112f, -0.00474188f, 
    0.04380142f, 0.08338901f, -0.01571937f, 0.08109287f, -0.06783481f, -0.03530886f, -0.02754288f, -0.08914056f, 
    -0.00582278f, -0.05652755f, -0.13333695f, -0.04140089f, -0.13704614f, -0.11821405f, 0.03528064f, 0.10615981f, 
    -0.09072028f, -0.08962264f, -0.04689286f, -0.06225409f, 0.01903673f, 0.16554445f, 0.08796300f, 0.00346065f, 
    -0.00931660f, 0.02052242f, 0.04907916f, 0.02618685f, -0.11854890f, 0.08998337f, -0.03915968f, -0.12024225f, 
    -0.14554983f, -0.08427178f, 0.02020206f, -0.01047863f, 0.15143590f, 0.18852805f, -0.02261159f, 0.11061709f, 
    0.30239457f, -0.10712861f, 0.07438448f, -0.11840075f, -0.17084984f, 0.01363354f, -0.01399823f, 0.15662844f, 
    -0.03081215f, 0.05191441f, 0.07646016f, 0.02979476f, -0.01321430f, 0.23814154f, 0.26596946f, 0.05472121f, 
    -0.01293730f, -0.07694174f, 0.25653970f, -0.06046212f, -0.01032409f, -0.08844430f, -0.08565105f, -0.05374997f, 
    -0.02514048f, 0.18271290f, 0.12459850f, 0.37621745f, -0.04216734f, -0.07280269f, 0.00493965f, -0.02778029f, 
    -0.04892612f, -0.01818478f, 0.06317759f, -0.01857939f, -0.07843308f, 0.04706658f, 0.00208800f, 0.15028322f, 
    -0.04889314f, -0.02332531f, 0.26332581f, 0.18197966f, 0.00778319f, -0.04786180f, -0.09775164f, -0.24306166f, 
    0.05010774f, 0.21055219f, 0.02985668f, 0.09126388f, -0.09666704f, -0.11926326f, -0.26504675f, -0.04781997f, 
    -0.21807037f, -0.08669897f, -0.01525551f, 0.09329021f, 0.00790223f, 0.00734230f, -0.05012124f, -0.03102351f, 
    0.01693875f, 0.01576942f, -0.02824744f, -0.00898930f, -0.00220405f, -0.00970677f, 0.01225742f, 0.02371511f, 
    0.01555650f, -0.01099859f, -0.00057779f, -0.04318222f, -0.01809594f, -0.01562202f, 0.02776337f, 0.00881034f, 
    -0.00399275f, -0.00560708f, 0.03205139f, -0.01970796f, 0.01626378f, -0.00072813f, -0.03452464f, 0.00023327f, 
    -0.01499627f, -0.03959503f, 0.01406938f, -0.00896370f, 0.02318339f, -0.02609000f, 0.01312312f, 0.02299578f, 
    0.00593583f, 0.00423711f, 0.02080986f, 0.02515979f, -0.03474336f, -0.01734305f, 0.03351476f, -0.00727470f, 
    -0.02637016f, -0.03351798f, 0.02198376f, 0.00531046f, -0.00330175f, -0.00421032f, 0.01791662f, 0.01270239f, 
    -0.03444254f, 0.00461076f, 0.00718914f, -0.00379938f, -0.01987538f, 0.02717269f, -0.02057708f, 0.02546852f, 
    0.02527530f, 0.00699298f, -0.04083358f, -0.03263320f, -0.01733232f, -0.00052133f, -0.03086848f, -0.01940017f, 
    0.02359031f, -0.02583327f, 0.02750180f, -0.00775930f, -0.03188194f, 0.01526131f, -0.01106794f, -0.01713122f, 
    -0.03427651f, -0.01002764f, 0.00409615f, -0.02958484f, -0.03162764f, 0.00113560f, -0.00346252f, -0.03385716f, 
    0.00221802f, 0.02689345f, -0.01246293f, -0.02275051f, 0.01564176f, -0.04050031f, -0.02105497f, -0.03992931f, 
    -0.03946468f, -0.01493025f, 0.00803333f, 0.01609154f, -0.02267822f, 0.01089961f, -0.02468578f, -0.03292610f, 
    -0.00833328f, 0.01134458f, 0.02156875f, 0.02748820f, -0.04276632f, 0.01741781f, -0.01818455f, -0.01546292f, 
    0.01333266f, -0.00644885f, -0.03699194f, -0.03531413f, -0.00795865f, 0.01146113f, -0.03654223f, -0.00774569f, 
    -0.01995399f, -0.04194874f, -0.01969739f, 0.01188927f, 0.01448916f, -0.04095310f, -0.01483895f, 0.01037467f, 
    0.01576998f, -0.01063286f, -0.04227335f, 0.01571133f, -0.02580879f, 0.00388957f, 0.00084339f, 0.02198838f, 
    -0.00231828f, -0.00742929f, -0.00021283f, 0.01407471f, 0.00130398f, 0.00152084f, -0.03419271f, -0.02020526f, 
    -0.04000397f, -0.01430338f, -0.03109449f, -0.00119683f, -0.00193929f, -0.03713717f, 0.02007488f, 0.00781098f, 
    0.01394890f, -0.02263242f, 0.03835552f, -0.02975225f, -0.00320265f, 0.00887526f, 0.02347791f, -0.01765586f, 
    0.00585386f, -0.01829353f, 0.01534999f, -0.01812066f, -0.01715260f, -0.01389800f, 0.00713005f, -0.02160024f, 
    0.00344528f, 0.01164816f, -0.03727172f, -0.00798865f, -0.01593087f, -0.00426189f, 0.00347381f, -0.01706110f, 
    0.01488731f, 0.02729142f, -0.00838993f, -0.03980885f, 0.02214699f, 0.00985393f, -0.00174963f, 0.02263326f, 
    -0.02367319f, -0.04003157f, 0.02444565f, -0.02421212f, -0.01816682f, -0.01499738f, 0.02110969f, 0.00681923f, 
    -0.03154190f, 0.00037334f, 0.00451041f, 0.01932938f, 0.00280114f, 0.03280586f, 0.00390758f, 0.01969775f, 
    -0.02997107f, -0.03595464f, -0.04280060f, 0.01467350f, 0.03172212f, 0.02112145f, -0.02337689f, -0.00430094f, 
    -0.02063613f, 0.02569856f, 0.01554773f, -0.03568426f, 0.02302041f, -0.01958175f, 0.01274539f, -0.00102948f, 
    -0.00905539f, 0.02078373f, 0.01203886f, 0.02674178f, -0.00459697f, -0.02032550f, -0.01853187f, 0.00342417f, 
    -0.00713749f, 0.00895201f, 0.01065454f, -0.02606354f, -0.03425989f, 0.01898745f, 0.00815612f, 0.02036275f, 
    0.01375074f, 0.00866731f, 0.00055048f, -0.03113646f, 0.01142200f, -0.02544327f, 0.02548067f, -0.01846813f, 
    -0.00818782f, 0.01032056f, 0.01141012f, 0.01442356f, -0.02548301f, -0.00152472f, 0.00425555f, -0.04200252f, 
    -0.03293479f, -0.03980750f, 0.00252134f, 0.03064643f, 0.01998155f, -0.00864816f, -0.01688145f, -0.02472879f, 
    -0.00335343f, -0.00654948f, -0.00792158f, 0.02228860f, 0.00856985f, 0.03025077f, -0.02764615f, 0.02196045f, 
    0.02084552f, 0.02985389f, 0.00682493f, -0.02135484f, 0.01980405f, 0.00864904f, -0.03903105f, -0.00410996f, 
    0.02634803f, -0.03171246f, -0.03190783f, -0.03326146f, -0.02395525f, 0.01604534f, 0.02124445f, -0.02271897f, 
    -0.03860164f, 0.00504661f, 0.00048100f, 0.01889035f, -0.03422829f, 0.01475753f, -0.00153958f, 0.00796287f, 
    0.00989802f, -0.00266163f, 0.00084219f, 0.01694458f, -0.00041867f, -0.00920054f, -0.03014586f, -0.00567860f, 
    -0.03333701f, 0.02791321f, -0.00463287f, 0.00290115f, -0.02522369f, -0.02601349f, 0.00987674f, -0.00855861f, 
    0.02442413f, 0.01866504f, -0.03064029f, -0.00938973f, -0.03813903f, -0.02410400f, -0.03431426f, 0.00297402f, 
    -0.03669780f, 0.00064354f, -0.03147447f, -0.00027530f, -0.03245987f, 0.00252347f, -0.00474995f, 0.01870626f, 
    0.00460358f, -0.02213142f, 0.01618111f, 0.00360817f, -0.02335595f, -0.03702169f, -0.01083639f, -0.00741517f, 
    0.02465852f, -0.00119105f, -0.02669152f, -0.01766994f, -0.00029145f, 0.00946662f, -0.02332714f, -0.02313625f, 
    0.02784768f, -0.03698249f, -0.03220944f, -0.01764403f, -0.00555077f, -0.03647736f, -0.02703240f, -0.03469320f, 
    -0.01572725f, -0.02996508f, -0.01752008f, 0.01411330f, -0.03658086f, -0.03928126f, 0.01332064f, -0.02211919f, 
    0.00295280f, 0.00017068f, -0.03745378f, -0.03807119f, 0.00992652f, -0.02509570f, -0.04364865f, -0.03456145f, 
    -0.00524958f, 0.00154069f, -0.00191925f, -0.01784652f, -0.00989014f, 0.00272468f, 0.02837273f, -0.03536740f, 
    0.01138342f, -0.03200033f, 0.01114666f, 0.01512062f, -0.00578605f, 0.00963581f, 0.02383238f, -0.00065829f, 
    0.02132714f, -0.01900733f, -0.00258609f, -0.02258914f, 0.02095485f, -0.04305582f, -0.01040762f, -0.04195252f, 
    -0.02859022f, 0.00948866f, -0.02672579f, 0.00704386f, -0.00012474f, -0.01808772f, 0.01770311f, 0.02221827f, 
    -0.03000205f, 0.02570217f, -0.01307886f, -0.04066806f, -0.04339912f, -0.03161759f, 0.00312377f, -0.02488475f, 
    0.00223519f, -0.03594404f, 0.00066550f, -0.00613954f, -0.01181560f, -0.01188462f, -0.01759351f, -0.00076071f, 
    -0.03474852f, -0.02232428f, -0.04319070f, -0.03218168f, 0.01243180f, -0.03811431f, 0.02312432f, 0.01573425f, 
    -0.01774113f, -0.02256523f, -0.04075305f, 0.01937298f, 0.01501344f, 0.01790375f, 0.02619237f, 0.02477838f, 
    -0.03150684f, -0.02870441f, -0.00316005f, 0.01160301f, 0.00128357f, 0.00814502f, -0.03650849f, 0.00898562f, 
    0.01812144f, 0.00038606f, -0.02174730f, -0.01844425f, 0.03114348f, 0.03390497f, -0.01238369f, -0.01310733f, 
    -0.02268811f, -0.03109227f, -0.00492770f, -0.02600233f, -0.00321784f, -0.02486757f, 0.02882251f, -0.02109320f, 
    0.01837385f, -0.02676220f, -0.03834512f, -0.01726754f, 0.00892720f, -0.03457828f, -0.02268095f, 0.02247378f, 
    0.01031264f, 0.00878406f, 0.01044953f, -0.01961025f, -0.02681078f, -0.01286472f, -0.00254233f, -0.03265300f, 
    0.03510333f, -0.03283256f, -0.03643141f, -0.03453460f, -0.02539233f, 0.02379573f, 0.00920238f, -0.01065092f, 
    -0.04253564f, 0.02021028f, -0.01606503f, -0.03454303f, -0.00884431f, -0.00594143f, -0.03514377f, -0.03342534f, 
    -0.01983010f, -0.00790085f, -0.01554587f, 0.01246499f, 0.01284102f, -0.03249911f, 0.00711298f, -0.00107581f, 
    0.01341222f, 0.00998792f, -0.03355679f, 0.00833086f, -0.01629166f, -0.03836038f, 0.02873755f, -0.01341424f, 
    -0.00936230f, -0.02409020f, 0.01311547f, -0.03266647f, -0.01577668f, 0.00779106f, 0.00712059f, -0.03091605f, 
    -0.04017149f, -0.00623094f, 0.01581019f, -0.04038421f, 0.01621105f, 0.02682351f, -0.01901231f, -0.00170987f, 
    -0.03552905f, -0.02773865f, 0.01605375f, -0.01754784f, -0.02675376f, -0.00680540f, 0.02705709f, -0.01145198f, 
    -0.01998181f, 0.01986942f, 0.01523653f, -0.01891294f, -0.00870837f, 0.02249899f, 0.02092985f, -0.03386895f, 
    -0.00452835f, 0.00571344f, -0.00034128f, -0.00379446f, -0.02942498f, 0.01515929f, 0.00308148f, 0.00070173f, 
    -0.01494561f, 0.01278039f, -0.03242843f, -0.02937105f, -0.02723091f, 0.02628241f, -0.00427699f, -0.00676021f, 
    -0.02492182f, 0.03090657f, 0.00887373f, -0.03364582f, -0.02123529f, -0.02562359f, -0.03709296f, -0.00410087f, 
    -0.01387141f, 0.00443829f, 0.01461311f, 0.00045231f, -0.03711973f, -0.00341814f, -0.03602203f, -0.02639977f, 
    0.01289501f, 0.00800214f, -0.00070878f, -0.00504641f, 0.02628956f, 0.02759344f, -0.03494754f, 0.02028808f, 
    -0.03585259f, -0.01322012f, 0.00796648f, -0.01757128f, -0.02789438f, 0.00403187f, 0.02122768f, -0.02193031f, 
    0.00533323f, -0.03773959f, -0.03878615f, -0.03245362f, 0.02750152f, -0.03564712f, -0.01908942f, -0.03327595f, 
    0.02856294f, 0.02575525f, -0.03715363f, 0.01807437f, -0.01227204f, 0.00605878f, -0.00801004f, 0.00376028f, 
    0.02660357f, -0.01544776f, 0.01593646f, -0.02199744f, -0.00840962f, 0.01955388f, -0.00510730f, 0.01503551f, 
    0.00348007f, 0.02696897f, -0.00016236f, -0.02484746f, -0.01224386f, 0.00417951f, -0.02823412f, 0.02020310f, 
    -0.03549162f, -0.03869723f, 0.01256102f, 0.00928751f, -0.03378594f, -0.02338393f, 0.00360974f, -0.01861703f, 
    0.02943642f, -0.01479859f, 0.01883636f, 0.01791223f, -0.02954296f, -0.01546316f, -0.02145977f, -0.00347145f, 
    0.01069590f, -0.04247256f, -0.00925685f, -0.03864131f, -0.03689877f, -0.01654010f, 0.00894698f, -0.03955112f, 
    0.00719446f, 0.03463440f, -0.02980711f, -0.01787886f, 0.00984546f, 0.01807210f, -0.02020325f, -0.02564090f, 
    -0.00046378f, 0.01734207f, -0.02699348f, 0.01471613f, 0.01556872f, 0.02574136f, 0.02632215f, 0.02818570f, 
    0.01642076f, -0.03880114f, -0.03421873f, 0.02009759f, -0.00946343f, -0.04243107f, -0.01077296f, 0.00853739f, 
    0.02428089f, -0.00625114f, 0.00488136f, 0.00112339f, -0.02246819f, -0.00944591f, 0.01998986f, 0.02929881f, 
    0.01346647f, 0.02279725f, -0.00455868f, -0.00938446f, -0.01510917f, 0.01491185f, 0.02316928f, -0.02148919f, 
    -0.03971645f, -0.00704403f, -0.02971704f, -0.03121899f, -0.00764272f, -0.04059798f, -0.01777713f, -0.02204043f, 
    0.02392602f, -0.02535469f, 0.01886597f, -0.04232077f, -0.03189443f, -0.01098672f, -0.00525744f, -0.02640024f, 
    -0.00350666f, -0.02656338f, -0.02484903f, 0.02574303f, -0.01622177f, -0.02557417f, 0.02374404f, 0.00048595f, 
    0.00709207f, -0.01989226f, 0.00506139f, -0.03823245f, 0.00194089f, -0.01323278f, 0.01168902f, -0.02302591f, 
    -0.02697883f, -0.02437364f, -0.03412701f, 0.01280847f, -0.02187042f, -0.01635606f, 0.02335669f, 0.00685861f, 
    0.02825570f, -0.02036360f, 0.02806577f, -0.02612374f, -0.00524169f, 0.02794232f, -0.03667594f, 0.01766911f, 
    0.01742142f, -0.03024151f, 0.00076285f, 0.01140794f, 0.00749760f, -0.02822800f, -0.02341072f, -0.03810536f, 
    -0.00963211f, 0.02807013f, 0.00219895f, -0.02073059f, -0.03928875f, -0.03635263f, 0.00226067f, -0.00173881f, 
    -0.03827047f, -0.00721933f, -0.03365996f, -0.00454092f, -0.01066962f, -0.02497651f, 0.00423663f, -0.02364448f, 
    -0.03409303f, -0.01000648f, -0.02206343f, 0.01099802f, -0.02602486f, -0.01209291f, -0.00808366f, 0.02176404f, 
    0.02365530f, 0.00002463f, -0.02897152f, 0.00859255f, -0.00246406f, -0.01210862f, -0.02617020f, -0.01916570f, 
    -0.03653930f, -0.01433684f, -0.01293493f, 0.00172472f, -0.01821364f, 0.01499377f, -0.01358191f, 0.02243107f, 
    -0.01025215f, 0.03004468f, -0.00233491f, 0.01016665f, -0.03701410f, -0.00336641f, -0.02928969f, -0.03896478f, 
    -0.03638146f, -0.00246118f, 0.15473184f, 0.13313444f, 0.08421016f, 0.04240761f, 0.03465014f, -0.06256046f, 
    -0.10465462f, 0.02372116f, 0.00364943f, 0.08030774f, -0.12599973f, 0.06767579f, -0.25722617f, -0.10249333f, 
    0.11363668f, 0.09465420f, 0.13728546f, 0.09433496f, -0.01264871f, -0.04400625f, -0.04353078f, -0.03749472f, 
    0.31911352f, -0.30818480f, -0.07112938f, 0.14891262f, -0.08306013f, 0.00465218f, -0.01814014f, 0.02593000f, 
    0.05727072f, 0.04442776f, 0.13558748f, -0.06339095f, -0.05955481f, -0.04918538f, 0.00223822f, -0.21720436f, 
    0.04905275f, 0.00784217f, 0.05422814f, -0.08133655f, 0.00992530f, -0.03361250f, 0.08077347f, -0.02932845f, 
    -0.00206502f, -0.02430654f, -0.03437893f, 0.04143867f, -0.04846773f, -0.08163827f, 0.15564317f, -0.14131705f, 
    0.14245673f, 0.01700082f, 0.05464453f, 0.26490411f, -0.17783803f, 0.01218873f, -0.04113871f, -0.02434302f, 
    0.18534438f, 0.10383104f, 0.01401859f, 0.01455239f, 0.05334145f, 0.03313267f, 0.06105070f, 0.00294261f, 
    0.10575194f, -0.06174303f, 0.04469954f, 0.14318603f, -0.11939008f, -0.08178911f, -0.00139801f, -0.05415704f, 
    0.07673376f, 0.02601682f, 0.10032178f, -0.04430148f, 0.49707326f, -0.49938282f, 0.20809783f, 0.08420590f, 
    -0.00206155f, 0.10075545f, 0.03016278f, 0.06144326f, 0.13524212f, 0.12204456f, 0.08794043f, -0.08755302f, 
    0.13879263f, -0.14951824f, 0.21878457f, 0.03154203f, 0.12945151f, -0.03696267f, 0.19278362f, 0.05707631f, 
    0.10941242f, -0.05647700f, 0.07014308f, 0.03591256f, 0.13568014f, -0.06066028f, -0.06101298f, -0.12559016f, 
    0.09497099f, 0.11090519f, -0.19328108f, 0.02493529f, -0.03858794f, 0.12181504f, -0.02211435f, -0.00350327f, 
    0.22411115f, 0.12168911f, 0.11462081f, -0.02562794f, -0.04531503f, -0.00372469f, -0.01509236f, -0.01207964f, 
    0.07608356f, 0.07518189f, -0.06545544f, -0.04479045f, 0.02524113f, 0.08185076f, -0.03842965f, -0.08143786f, 
    0.02406354f, -0.08069187f, -0.04059626f, 0.02417108f, -0.11402415f, 0.08454450f, 0.02050632f, -0.02701456f, 
    0.07392595f, -0.14172985f, -0.28068024f, -0.05490059f, 0.20722143f, 0.09288717f, 0.08440612f, -0.04344621f, 
    0.02032906f, 0.04109526f, -0.00099635f, -0.00325552f, 0.00774909f, -0.04969748f, -0.01449899f, -0.01989786f, 
    -0.00083150f, -0.03298355f, -0.04157426f, 0.09762934f, 0.03479239f, 0.01911207f, 0.02522543f, 0.00331695f, 
    -0.12526329f, -0.10272633f, -0.16661525f, 0.16266884f, -0.03188010f, 0.04623276f, 0.14932552f, 0.20438880f, 
    -0.03920583f, 0.03127962f, -0.07686888f, 0.02938740f, -0.14592505f, -0.13487482f, -0.06464773f, -0.03878881f, 
    0.13053833f, 0.08666556f, 0.07672700f, 0.09628657f, 0.10863593f, 0.09878957f, 0.04990644f, 0.06976908f, 
    0.17333469f, 0.12700044f, 0.25206116f, 0.12109463f, 0.05135731f, -0.02130820f, -0.02215220f, -0.04747899f, 
    0.23960599f, 0.08623925f, 0.00263858f, -0.02641458f, -0.01705875f, 0.02334602f, 0.04293591f, -0.00696369f, 
    0.11523141f, 0.07752547f, 0.05187379f, -0.24351482f, -0.04039205f, 0.01458506f, 0.08731525f, 0.00646595f, 
    -0.28765485f, -0.14221112f, -0.17821997f, -0.09337186f, -0.15575658f, -0.11569563f, 0.09092834f, 0.03912970f, 
    0.07591732f, -0.05320603f, 0.24532279f, 0.11655956f, -0.16539076f, -0.10224631f, -0.11887535f, -0.06660044f, 
    0.18006176f, 0.15460558f, 0.06159770f, -0.03222170f, -0.00829456f, 0.12723024f, -0.00747546f, 0.23738936f, 
    0.06305959f, -0.09909266f, 0.00188645f, -0.10676932f, 0.08976959f, 0.04575579f, 0.10296400f, -0.00486718f, 
    -0.00742834f, -0.02726211f, 0.02534867f, -0.00846275f, -0.19749893f, -0.06367742f, -0.06738082f, -0.24701531f, 
    0.16526870f, 0.16943529f, 0.08569875f, -0.05629745f, 0.16672044f, 0.10894755f, 0.01778006f, 0.09001786f, 
    -0.01036388f, 0.02444744f, -0.18180057f, 0.13409720f, 0.12098607f, 0.04811191f, 0.03190583f, 0.03043585f, 
    -0.01177794f, -0.01115973f, 0.07544168f, 0.00949274f, 0.04702728f, -0.02031664f, 0.01734560f, -0.12418953f, 
    0.01624380f, -0.07751332f, -0.01263549f, -0.02369834f, 0.03300752f, -0.01707258f, 0.01393457f, -0.01852778f, 
    -0.08829572f, -0.11081509f, -0.04036582f, -0.03356947f, -0.01680776f, 0.06914505f, 0.13166545f, 0.09286850f, 
    0.09244595f, -0.01763528f, 0.12702537f, 0.03335854f, -0.07652827f, -0.01393256f, -0.05827632f, -0.06334177f, 
    0.01640046f, 0.06297266f, 0.01047238f, -0.06643252f, 0.03446063f, -0.07011159f, -0.00498485f, -0.01216298f, 
    0.20233265f, -0.15419416f, 0.06844691f, -0.10273965f, 0.00971986f, -0.04801896f, -0.09223077f, -0.01476169f, 
    0.01078541f, 0.11540402f, 0.24157672f, -0.10455118f, 0.01827914f, -0.05416132f, -0.13809049f, 0.04826743f, 
    0.10943019f, 0.10388866f, 0.06919757f, -0.12876439f, 0.07287973f, 0.04509117f, -0.01620112f, 0.02761324f, 
    0.05149984f, 0.01939012f, -0.06458759f, -0.10685906f, -0.02002292f, -0.11117831f, -0.12343380f, 0.03251361f, 
    0.02726302f, -0.00821523f, -0.02258888f, -0.03377578f, 0.11064993f, 0.07298926f, -0.01275922f, -0.14412607f, 
    -0.05207348f, 0.01746973f, -0.05536803f, 0.00504735f, 0.13857093f, 0.04181508f, 0.03826981f, 0.21993189f, 
    -0.24231188f, -0.29821256f, -0.27303639f, -0.09085502f, 0.10867997f, 0.01895547f, 0.04499920f, -0.18773517f, 
    -0.05341119f, 0.02929642f, -0.11143255f, 0.07223947f, -0.01330442f, -0.07754473f, 0.09608182f, -0.02285958f, 
    0.03481385f, -0.05841748f, 0.06883845f, 0.03478752f, -0.04970276f, 0.02433711f, -0.01894567f, 0.03312986f, 
    0.33411658f, -0.26222160f, 0.07435004f, 0.05171992f, 0.14047045f, -0.09103479f, 0.16887119f, 0.13689193f, 
    0.08163207f, 0.08110633f, 0.09460817f, 0.13960978f, -0.13011689f, 0.21941163f, -0.06497485f, 0.35866189f, 
    -0.04813262f, 0.06566662f, 0.00687035f, 0.17662345f, -0.01172657f, -0.05166535f, 0.01453265f, 0.10529802f, 
    0.00722140f, -0.03860607f, 0.04616179f, -0.04748717f, 0.01239107f, -0.01907024f, 0.00263695f, -0.02202883f, 
    -0.04139673f, -0.10589487f, -0.01476857f, 0.06088426f, 0.04288416f, -0.09959004f, 0.14538287f, 0.15326685f, 
    -0.02446161f, 0.11819473f, 0.03843122f, 0.24621214f, 0.15825020f, -0.04983286f, 0.09605891f, 0.06893043f, 
    0.05019975f, -0.13802440f, 0.07648101f, -0.05853571f, 0.04130243f, 0.06504877f, 0.12124097f, -0.02336933f, 
    -0.14347866f, 0.15144171f, 0.14237042f, -0.02672965f, -0.07876399f, -0.23066469f, 0.07143091f, -0.05668625f, 
    0.01467825f, 0.06239777f, 0.03095142f, 0.03916083f, 0.02636829f, 0.05027915f, -0.01953979f, -0.00273898f, 
    0.10926919f, -0.05569157f, 0.12821777f, 0.01158022f, -0.00018985f, 0.01712437f, 0.01404342f, 0.03439101f, 
    -0.03661693f, -0.08522223f, -0.02289059f, -0.11171797f, -0.06317274f, -0.06925461f, -0.23038109f, -0.05300914f, 
    0.01107427f, 0.05364324f, 0.15932290f, 0.00912863f, 0.00694364f, 0.02399572f, -0.03414898f, 0.03869475f, 
    0.04747648f, -0.09688799f, -0.16682792f, 0.00052494f, -0.00493019f, 0.09438144f, -0.04686387f, -0.01855293f, 
    -0.03933066f, -0.00408435f, 0.02394034f, 0.02970193f, -0.39025152f, -0.22755405f, -0.16116436f, -0.17890123f, 
    0.18895365f, 0.05517983f, -0.10556965f, -0.03622572f, -0.04197577f, -0.02860465f, 0.01221430f, -0.02867576f, 
    -0.19510698f, -0.24359505f, -0.06608489f, -0.03774055f, 0.11468085f, 0.11847724f, 0.12654266f, 0.08941999f, 
    0.03685763f, -0.12906656f, -0.04438639f, 0.01969365f, -0.08312473f, -0.01697432f, -0.00503034f, 0.03385301f, 
    -0.02000508f, 0.09135012f, -0.09807233f, -0.00494674f, 0.04120132f, 0.03755862f, 0.10626670f, 0.10736676f, 
    -0.21517608f, -0.12785804f, 0.20756951f, 0.04377491f, -0.06022255f, 0.03574393f, -0.00426220f, 0.00448989f, 
    0.07567233f, 0.09537954f, 0.03457854f, 0.16290082f, 0.12888661f, 0.05560261f, -0.09252183f, -0.01781500f, 
    -0.01163631f, 0.07634301f, 0.01169704f, -0.04139561f, 0.02450623f, 0.02908249f, -0.04225533f, -0.01175213f, 
    0.03503354f, -0.02227597f, -0.03127244f, 0.09100622f, -0.06925043f, 0.10380225f, -0.04304730f, 0.03825605f, 
    0.02562436f, -0.04643276f, 0.01036352f, 0.06361737f, 0.26664564f, 0.02346359f, 0.14748789f, -0.01141794f, 
    0.00021355f, -0.09424434f, 0.03100222f, -0.01025134f, 0.16867733f, 0.01414358f, 0.13086380f, -0.08344818f, 
    -0.05238424f, -0.11535114f, -0.04783897f, -0.27318704f, -0.05021709f, 0.05374155f, 0.04236231f, 0.06740151f, 
    0.01859729f, -0.02426322f, 0.00340554f, -0.15402944f, 0.32568184f, -0.11033155f, 0.07704542f, -0.00846593f, 
    0.11444707f, -0.08967558f, -0.02936265f, -0.03655531f, 0.05095606f, 0.04528945f, -0.01519699f, 0.01808743f, 
    -0.11400837f, -0.33078662f, -0.03197977f, -0.44454682f, 0.01760676f, 0.04867644f, 0.06224424f, 0.08097196f, 
    0.11980300f, 0.07523359f, 0.05146893f, 0.13492613f, -0.06437320f, 0.07047962f, 0.23710382f, 0.22568004f, 
    0.17382592f, -0.00519614f, 0.08062933f, 0.13165392f, 0.05420954f, 0.01006102f, 0.14827278f, -0.04073382f, 
    -0.19786648f, -0.13637649f, -0.10526028f, -0.08436591f, 0.01460102f, 0.04431956f, 0.04171056f, 0.05108183f, 
    0.07319688f, -0.06551129f, -0.05102532f, -0.31333241f, -0.04340049f, -0.02613117f, -0.15767050f, -0.04742645f, 
    0.04572451f, 0.05587907f, 0.17616133f, 0.08564192f, -0.03056918f, 0.02063625f, 0.01048892f, 0.01209950f, 
    -0.06707930f, 0.12047363f, -0.07443646f, -0.03094429f, -0.07611240f, -0.00811989f, -0.06696928f, -0.04086249f, 
    -0.00666243f, 0.00421332f, 0.02339779f, 0.14310232f, -0.08510900f, -0.08206002f, -0.08053509f, 0.02439230f, 
    0.06286187f, 0.00396498f, 0.09307781f, 0.08100814f, 0.04793924f, 0.08319518f, 0.09786786f, 0.02558100f, 
    -0.14449224f, -0.23334596f, -0.09818394f, -0.03216521f, 0.00663617f, -0.01467019f, -0.04774890f, -0.13159110f, 
    -0.02329772f, 0.10609562f, -0.00922646f, 0.03904424f, -0.06654131f, -0.06172036f, -0.04260866f, -0.04034378f, 
    0.01095608f, -0.07219921f, 0.06837292f, -0.05993056f, 0.12481180f, -0.02519814f, 0.05256533f, 0.07344770f, 
    0.24015786f, 0.04809959f, -0.05686130f, 0.08762411f, 0.01025589f, -0.16700052f, 0.21717991f, -0.09262487f, 
    -0.07188473f, 0.06419887f, -0.01103258f, 0.08324707f, 0.17705344f, 0.06584879f, 0.02250033f, -0.09836991f, 
    0.02490574f, -0.09482203f, -0.01608188f, -0.06460866f, -0.12950210f, -0.00250221f, -0.18681125f, -0.03756578f, 
    -0.01884609f, 0.07104395f, 0.00317073f, 0.09071136f, -0.03539204f, -0.10575834f, 0.05413928f, 0.01503693f, 
    -0.05099497f, -0.03903219f, -0.01259772f, -0.11461867f, -0.14741233f, 0.02910947f, 0.02717396f, 0.03937909f, 
    -0.00442067f, 0.01691673f, -0.03498220f, -0.02552374f, -0.02198105f, -0.08997844f, -0.06599724f, -0.12517902f, 
    0.05414618f, 0.13455983f, -0.12764877f, -0.13387330f, -0.00887349f, 0.03980402f, 0.02322747f, 0.14574717f, 
    0.02173281f, 0.00055322f, 0.01293009f, -0.01731464f, -0.13429263f, -0.04886992f, -0.05095549f, -0.05823035f, 
    0.07359054f, 0.02410146f, -0.10052101f, -0.17339127f, -0.02058341f, 0.02457081f, -0.02866574f, -0.00768548f, 
    -0.26461506f, -0.06375672f, 0.00621826f, 0.02570588f, 0.00885784f, 0.04014792f, 0.08716968f, 0.03048087f, 
    -0.00956690f, -0.00227858f, 0.04546428f, 0.02664318f, 0.48915234f, -0.22947213f, 0.09523428f, -0.09103059f, 
    0.15719409f, 0.20291784f, 0.01737250f, -0.03240155f, -0.13373213f, -0.02602788f, 0.03601157f, -0.02122865f, 
    -0.45839289f, -0.27352184f, 0.00469348f, 0.23169094f, 0.01850408f, 0.18338478f, -0.02808147f, 0.04672301f, 
    -0.08967670f, -0.16186807f, 0.00343279f, 0.04454666f, 0.01010324f, 0.05576389f, -0.01645507f, 0.10446930f, 
    0.07199111f, 0.10616298f, 0.02111015f, -0.11327810f, 0.04543374f, 0.02673072f, 0.06054084f, 0.13052151f, 
    0.18340464f, 0.29086590f, -0.00141878f, 0.11075065f, -0.09877014f, 0.01270261f, -0.11311661f, 0.09366824f, 
    0.14423151f, 0.04749081f, 0.08891414f, -0.00669321f, 0.28553540f, -0.10422563f, -0.04097452f, -0.12898205f, 
    0.07668260f, 0.02416821f, 0.10394723f, -0.05920444f, -0.08797602f, 0.03778638f, -0.04913746f, -0.03598620f, 
    -0.07886171f, 0.09948780f, 0.02354407f, 0.04269903f, -0.08609115f, -0.03007137f, -0.08513093f, 0.00573989f, 
    -0.04014234f, -0.15696289f, 0.00126409f, 0.09283080f, -0.42966372f, 0.11533240f, -0.17798650f, 0.21243495f, 
    0.11543891f, 0.09972156f, 0.12190792f, 0.24920906f, 0.01649715f, -0.09429015f, -0.08335032f, 0.06406619f, 
    0.04414897f, 0.05598589f, -0.02489085f, 0.18442956f, 0.15826109f, 0.07940749f, 0.18761849f, 0.20499633f, 
    0.27102351f, 0.02973598f, -0.07461658f, 0.19110750f, -0.21453275f, -0.19343866f, -0.11537039f, 0.00647611f, 
    -0.03491411f, 0.15975055f, 0.00619361f, 0.00173340f, 0.03410857f, 0.03871217f, -0.01801999f, -0.05822582f, 
    0.51661229f, 0.22911038f, -0.27222276f, 0.13101016f, -0.01047239f, 0.05189818f, 0.07004406f, 0.07721946f, 
    0.15215397f, -0.03596473f, 0.00711680f, -0.04437356f, 0.29139560f, -0.04934601f, 0.03968224f, 0.08316538f, 
    0.09492128f, 0.02826217f, 0.05772056f, 0.01904843f, 0.08299322f, 0.08400260f, 0.02175168f, 0.02404251f, 
    0.77062345f, -0.11889002f, -0.07995436f, -0.11475417f, 0.11628874f, 0.12631175f, 0.15088372f, -0.03927194f, 
    -0.03472191f, -0.06796020f, -0.07703063f, -0.02896419f, 0.02808868f, -0.02406983f, 0.00661967f, 0.11119697f, 
    -0.10185490f, -0.02631798f, -0.01200111f, 0.05792405f, -0.00514976f, 0.00894488f, -0.05008030f, -0.08216309f, 
    -0.00493734f, -0.27818373f, -0.09932949f, 0.05268342f, 0.12714730f, 0.05477478f, 0.07407064f, 0.10653636f, 
    -0.07877738f, 0.00082445f, -0.00679412f, -0.05052229f, 0.05731305f, 0.19438529f, 0.15500164f, -0.08636329f, 
    0.16083710f, -0.07005483f, 0.03347860f, 0.02283676f, 0.11909837f, 0.03673602f, -0.03937873f, -0.00078303f, 
    0.19323577f, 0.10277607f, -0.05482324f, 0.28352928f, 0.03623056f, 0.07932585f, -0.05820107f, -0.03027724f, 
    0.08873537f, 0.10235590f, -0.01287649f, 0.04630458f, 0.00153364f, -0.04406772f, 0.11855707f, 0.16465443f, 
    0.03371779f, 0.14958411f, -0.09851033f, -0.10199933f, 0.06427795f, -0.01614993f, -0.04026661f, 0.13932511f, 
    -0.37439635f, 0.10138992f, 0.12106096f, -0.17848691f, -0.07852895f, 0.01969186f, 0.03353126f, -0.00927677f, 
    -0.00921710f, -0.09898704f, 0.11885809f, 0.24337356f, 0.08772444f, 0.17752311f, 0.01972782f, -0.08732747f, 
    0.15270576f, -0.17685945f, 0.08248182f, 0.04056114f, 0.09095019f, 0.01461484f, -0.05774624f, 0.03446361f, 
    -0.25103322f, 0.01478434f, 0.20620689f, 0.10218768f, 0.10422039f, 0.10278977f, 0.18146282f, 0.00125001f, 
    -0.04788259f, 0.06381016f, -0.02431791f, 0.00234928f, -0.21830593f, 0.24770103f, 0.24282411f, -0.07748751f, 
    0.05316682f, -0.03244832f, -0.02051254f, 0.05401618f, 0.04849399f, 0.02647155f, 0.06670613f, 0.07279852f, 
    0.55048245f, -0.11846591f, 0.00497235f, -0.12701681f, 0.02121841f, 0.04725732f, 0.10418139f, -0.01605410f, 
    -0.06805780f, -0.03064089f, -0.10141916f, -0.04445485f, 0.01186531f, -0.00114634f, 0.06895610f, 0.11753707f, 
    -0.00933458f, -0.01775374f, -0.02190239f, 0.01749331f, -0.03096620f, 0.02388340f, -0.02703963f, -0.00502282f, 
    0.02518176f, 0.17170407f, 0.05251725f, -0.06805476f, -0.05035005f, -0.04396674f, -0.11002252f, 0.09932162f, 
    0.10251214f, -0.01158778f, -0.10777026f, -0.10875387f, -0.05878575f, 0.02642707f, 0.14043312f, 0.04974930f, 
    -0.03986041f, 0.07962856f, -0.07160655f, -0.26849744f, 0.01745962f, -0.01966260f, 0.03831330f, 0.04770938f, 
    -0.19440223f, 0.23957732f, 0.06261310f, 0.06591259f, -0.09305606f, -0.08625848f, 0.04352769f, 0.12310793f, 
    0.04091304f, 0.10656236f, 0.03312273f, 0.01401536f, -0.10469054f, -0.03421376f, -0.03832332f, 0.07657696f, 
    0.00041893f, 0.17785944f, 0.00172480f, -0.13926426f, -0.04624657f, -0.02473299f, -0.04702231f, 0.03046348f, 
    -0.00522114f, -0.05869399f, -0.10784837f, -0.09348191f, -0.12380242f, 0.00415190f, -0.09961384f, -0.01051364f, 
    0.20153922f, -0.07113475f, -0.07672551f, -0.06129679f, -0.00041322f, 0.00527512f, 0.24283631f, 0.21607740f, 
    -0.02942480f, -0.02971883f, -0.00948751f, -0.03493620f, 0.07515429f, -0.01883972f, 0.07782424f, 0.17121148f, 
    -0.09735686f, 0.23063622f, 0.05975937f, 0.19876419f, 0.04751348f, 0.05786650f, -0.04563211f, -0.26278335f, 
    -0.00451908f, -0.05333611f, 0.06223558f, 0.01455872f, -0.15406117f, 0.11362813f, 0.17233916f, 0.15610184f, 
    0.11791856f, -0.03267901f, 0.00991468f, -0.12727787f, -0.04835167f, 0.06230247f, -0.06754456f, 0.00121608f, 
    -0.23870504f, 0.00015088f, -0.19919346f, 0.25129408f, -0.09327246f, 0.00493645f, 0.07126446f, 0.19696197f, 
    0.07576445f, 0.00216780f, 0.11298378f, 0.09623169f, 0.25173864f, -0.34526944f, 0.19076709f, -0.10056999f, 
    0.16146716f, 0.14715527f, 0.18355000f, -0.01963672f, -0.12004746f, 0.01869236f, -0.01420441f, 0.17663094f, 
    -0.00330393f, 0.01971150f, 0.03041357f, 0.18206662f, 0.01885862f, -0.03293394f, -0.06785881f, 0.00608505f, 
    -0.05175005f, -0.10196745f, -0.01299448f, 0.01471155f, 0.01839415f, -0.06833107f, 0.13422292f, 0.04862135f, 
    0.19478372f, 0.16651851f, 0.25741211f, -0.00487567f, 0.21141386f, 0.05252932f, 0.12993434f, 0.01134226f, 
    -0.04940895f, 0.15886486f, 0.00373901f, 0.06845263f, 0.06301372f, 0.05844271f, 0.01230396f, -0.05047740f, 
    0.03885723f, 0.17536023f, -0.02307556f, -0.03786807f, -0.33890331f, 0.15095545f, 0.35850665f, 0.10926538f, 
    0.02422018f, 0.14078596f, 0.02942261f, -0.01122092f, -0.03620834f, 0.07687442f, -0.00568425f, -0.06291600f, 
    0.17057554f, 0.05282919f, -0.15053023f, 0.06483597f, -0.01252239f, 0.04933454f, 0.09192305f, 0.11045276f, 
    -0.00873396f, -0.04919225f, -0.02248312f, -0.13817103f, -0.16775744f, -0.01540479f, 0.21443470f, -0.14279622f, 
    -0.04100763f, 0.08713472f, 0.10154626f, 0.04396697f, 0.00399921f, 0.09978618f, 0.04516976f, 0.08942441f, 
    -0.26764545f, -0.16065541f, 0.06560788f, 0.14504902f, 0.00451142f, 0.14015955f, -0.13425688f, -0.00991569f, 
    0.12078150f, -0.04224354f, 0.04214563f, 0.03091346f, -0.19892947f, 0.11830443f, 0.07871867f, -0.06360052f, 
    0.02494499f, 0.04683010f, 0.08534209f, -0.05841916f, -0.05862573f, -0.01536534f, -0.03453302f, -0.09267279f, 
    -0.27109128f, -0.00434007f, -0.08396017f, -0.05339453f, -0.14331475f, 0.02620762f, 0.00643061f, 0.03707520f, 
    0.09418385f, 0.05562376f, -0.04809425f, -0.10682137f, -0.48997250f, 0.08461024f, 0.02073579f, -0.10619289f, 
    0.02543557f, -0.00360016f, -0.03642766f, -0.04281759f, -0.03301758f, 0.04867835f, 0.02289316f, -0.06328353f, 
    -0.42789045f, 0.18230473f, 0.13537507f, -0.02575281f, -0.08688463f, -0.03703891f, -0.09877004f, -0.07373714f, 
    -0.01472454f, 0.00029393f, 0.07407754f, 0.09393033f, -0.17563157f, -0.06235274f, 0.11904071f, 0.31212214f, 
    0.24654226f, 0.02437488f, 0.05102991f, -0.04301871f, -0.00274074f, -0.02268705f, 0.13288125f, 0.04799908f, 
    0.03658776f, 0.00056554f, -0.03449513f, 0.07797793f, -0.03796807f, 0.00671696f, -0.06977922f, 0.05266822f, 
    0.06466148f, -0.11934083f, -0.09300614f, 0.04062682f, -0.22880216f, 0.03178869f, 0.15085779f, 0.16394040f, 
    0.01724558f, -0.05889769f, -0.03565982f, 0.04544252f, 0.02895829f, -0.09650236f, 0.18342528f, 0.13374417f, 
    0.05215164f, 0.16043822f, -0.04007795f, -0.04020900f, 0.00754693f, 0.06707534f, 0.08834400f, 0.15008719f, 
    0.06203451f, 0.02799929f, -0.02577269f, -0.00792334f, -0.11484650f, 0.01109915f, -0.02024098f, 0.30180141f, 
    -0.07599737f, 0.06840019f, -0.05529844f, 0.17612334f, -0.00395054f, -0.01255138f, -0.03578104f, 0.04798750f, 
    -0.54360664f, 0.42269802f, 0.17950010f, -0.04856266f, 0.06112770f, -0.05521555f, 0.11515258f, 0.28217024f, 
    0.12069253f, 0.07299048f, 0.02698315f, 0.08742711f, 0.27201575f, 0.13062318f, 0.13126755f, 0.08171900f, 
    0.29235607f, 0.06728324f, 0.07551449f, 0.09833518f, 0.12555256f, -0.08525149f, 0.15656343f, 0.23844226f, 
    -0.26342803f, 0.12420741f, -0.08476866f, -0.16782860f, -0.09984560f, -0.00437612f, -0.05953224f, 0.12774435f, 
    -0.00642036f, -0.12100672f, -0.06886091f, -0.10149729f, 0.05547198f, -0.20810783f, 0.03995639f, -0.11625808f, 
    0.06479977f, -0.00500869f, 0.17723782f, -0.00379029f, -0.01352918f, -0.01047926f, 0.05876722f, -0.02811361f, 
    0.17545290f, -0.05049201f, -0.00724876f, 0.05288245f, -0.01116962f, -0.02053681f, -0.05060699f, -0.02997517f, 
    -0.11318520f, -0.05915251f, 0.06324228f, -0.00303384f, 0.25380558f, -0.00525814f, 0.02025698f, -0.13414127f, 
    0.06820712f, -0.15232225f, 0.07458074f, -0.00501346f, 0.01388692f, -0.00346131f, -0.05317257f, -0.05160397f, 
    -0.17898829f, 0.06370682f, 0.21372646f, 0.03583325f, 0.06004162f, 0.00227393f, -0.12221206f, -0.21939212f, 
    -0.04566818f, -0.03304588f, -0.06638831f, 0.03845011f, 0.01069846f, 0.00716361f, -0.03864046f, 0.08869943f, 
    0.01077499f, 0.03197830f, -0.10769582f, -0.01533592f, -0.00861821f, -0.06566372f, 0.00000766f, -0.04252627f, 
    -0.20984425f, -0.02909275f, 0.12533437f, 0.13059087f, -0.05020935f, -0.10529506f, -0.02277724f, 0.16821299f, 
    0.07071630f, 0.07819181f, 0.00396202f, 0.18216018f, 0.10152390f, -0.01768251f, 0.01286005f, 0.06769542f, 
    -0.08355419f, -0.04372925f, 0.01093170f, 0.05014535f, 0.05609754f, 0.06990521f, 0.11239889f, 0.02801860f, 
    0.12846349f, 0.00030080f, 0.04275551f, -0.05671624f, -0.08760192f, 0.00076804f, 0.05015935f, 0.04163630f, 
    -0.08697477f, -0.04948904f, -0.05691131f, -0.19985329f, 0.31250826f, -0.03061648f, 0.05977257f, 0.09037419f, 
    -0.02439294f, 0.02298309f, -0.00721619f, -0.05817536f, -0.09333517f, -0.09277498f, -0.00263966f, -0.10474101f, 
    0.19272614f, 0.12965235f, -0.18471327f, -0.10077531f, -0.01692615f, 0.00315712f, -0.04285772f, 0.12119190f, 
    0.23921522f, 0.05216494f, 0.02473002f, -0.02682409f, -0.18818280f, 0.02170887f, 0.19420837f, -0.03555221f, 
    0.00086021f, -0.01129046f, -0.01979835f, -0.32937437f, -0.05993716f, -0.06653683f, 0.00122685f, 0.00257817f, 
    0.01001336f, -0.03170817f, 0.00947333f, -0.00216250f, 0.00347132f, -0.03716261f, 0.02008225f, -0.02156844f, 
    -0.02271391f, -0.01062354f, -0.00524694f, 0.03945803f, 0.00585794f, -0.00816434f, 0.00996032f, 0.00892466f, 
    -0.01850880f, 0.01810938f, -0.03802321f, -0.00940533f, -0.02846757f, 0.02576227f, -0.00992257f, -0.02427842f, 
    -0.01230580f, 0.01502156f, 0.01031737f, -0.00053906f, -0.01793841f, 0.01282969f, -0.02438582f, -0.03190390f, 
    -0.01173694f, -0.01682409f, 0.00521672f, -0.02608626f, -0.00503652f, -0.00739014f, -0.02586227f, 0.00876388f, 
    0.02610308f, -0.03338056f, -0.00714761f, -0.01656550f, 0.01223687f, 0.00687828f, -0.02884927f, 0.00123173f, 
    0.03037336f, 0.00528817f, 0.02488912f, -0.02242242f, 0.02308914f, -0.03124452f, -0.00223704f, 0.02694833f, 
    0.01287409f, -0.03075877f, 0.00698072f, 0.00926004f, 0.02469358f, -0.01514035f, 0.00780522f, -0.01916291f, 
    -0.01424081f, -0.02092007f, -0.00841206f, -0.04127788f, 0.03332432f, -0.02841810f, -0.02113860f, -0.00870055f, 
    -0.00870935f, 0.00435938f, -0.03568152f, -0.02070803f, -0.01939057f, -0.01557216f, 0.01661120f, 0.01825305f, 
    -0.02528547f, -0.03324147f, -0.02894289f, -0.03038014f, 0.00484759f, 0.03472205f, -0.00826329f, -0.00470462f, 
    0.00042850f, 0.00060757f, -0.01179741f, 0.00313863f, -0.03670683f, -0.01154704f, -0.01002276f, 0.00707003f, 
    -0.00449525f, 0.01699465f, -0.00347127f, 0.03628069f, -0.00943287f, 0.02553980f, 0.00916211f, 0.00207561f, 
    0.01038277f, -0.04017415f, 0.02523748f, -0.01959317f, -0.01232860f, -0.01341348f, -0.04125028f, 0.00402272f, 
    -0.03612516f, -0.03978289f, -0.02399050f, -0.01441960f, -0.02420574f, 0.02790759f, 0.01233966f, -0.01994849f, 
    -0.02267436f, -0.02717116f, 0.00006213f, 0.01983759f, -0.01559950f, -0.03713815f, -0.00010813f, -0.02842582f, 
    0.03204354f, 0.00252895f, 0.02199176f, 0.01529490f, -0.02816728f, -0.02983043f, 0.03030327f, 0.01292353f, 
    -0.02546643f, 0.02378965f, -0.01244222f, 0.02400150f, -0.00828727f, -0.04196043f, 0.02196758f, -0.02703239f, 
    0.01527295f, -0.00889368f, 0.00776345f, -0.01610731f, 0.00357317f, -0.02937141f, -0.04113153f, -0.01849885f, 
    -0.00507808f, -0.03127735f, 0.00822217f, 0.00506133f, -0.01337815f, -0.01225604f, -0.02987226f, -0.02334721f, 
    0.01714573f, 0.01229400f, -0.00860447f, -0.01140394f, 0.02890060f, -0.01408328f, -0.03945931f, 0.01880258f, 
    0.01028495f, -0.00424210f, -0.02930277f, -0.00317549f, 0.00510023f, -0.01470346f, -0.01081071f, 0.01057776f, 
    0.01630765f, 0.02383046f, 0.00296814f, -0.03184293f, -0.02839470f, -0.03304227f, -0.02373222f, -0.03754268f, 
    -0.00236700f, -0.02921274f, 0.02421672f, 0.03894129f, -0.01933998f, 0.00926868f, -0.02854196f, -0.00958936f, 
    0.00822681f, 0.02284254f, -0.00026030f, 0.01816361f, 0.01609623f, -0.00112011f, 0.00999932f, -0.03170735f, 
    -0.01967712f, -0.00697955f, -0.00597718f, 0.02527350f, 0.00185030f, -0.04037467f, -0.01937310f, 0.02643853f, 
    -0.03994923f, 0.01534889f, -0.00779387f, -0.04018918f, 0.00691833f, 0.03003597f, -0.03765018f, -0.02890593f, 
    -0.01771710f, -0.02621147f, -0.03321192f, -0.00276738f, 0.02609337f, -0.00766282f, -0.00063237f, 0.03281293f, 
    0.03515185f, 0.02393398f, -0.02179801f, 0.02161163f, -0.01961973f, 0.00478620f, 0.01797786f, -0.01573528f, 
    -0.02555374f, 0.00577779f, -0.02293662f, -0.03363413f, 0.01748883f, 0.03473637f, -0.02633723f, 0.01616715f, 
    0.00558234f, 0.02433786f, -0.01775216f, -0.01546324f, -0.03491788f, 0.01683506f, -0.02683033f, -0.03039766f, 
    0.04046983f, 0.02815546f, -0.02654796f, 0.02176781f, 0.00107339f, 0.01580462f, -0.03814431f, -0.02887593f, 
    0.02840032f, 0.03228402f, -0.03187834f, 0.02701069f, 0.01617294f, -0.02380631f, -0.01266054f, -0.02021088f, 
    0.00535986f, 0.03315309f, 0.01412934f, 0.01648363f, -0.01313427f, 0.00393028f, 0.01659445f, -0.02611171f, 
    0.00099303f, 0.02295843f, -0.02016435f, 0.03919873f, -0.02680028f, 0.01921466f, -0.01189476f, 0.00208584f, 
    0.00520528f, -0.01963666f, -0.00879993f, 0.02886484f, 0.02954991f, -0.03539916f, -0.02354135f, -0.03865794f, 
    0.00851279f, -0.00465180f, 0.04463355f, 0.01577827f, -0.00658617f, -0.01734569f, 0.02925525f, -0.01133044f, 
    -0.01514928f, -0.00721139f, 0.01420528f, -0.01230266f, -0.03087983f, -0.02492449f, -0.00472831f, -0.02166492f, 
    0.02400018f, 0.01550441f, 0.01611566f, -0.02704717f, -0.02517982f, 0.01617059f, -0.01730440f, -0.02052100f, 
    -0.02500308f, -0.02949741f, 0.00528234f, 0.01448516f, -0.00360772f, 0.00036890f, 0.01059384f, -0.00753926f, 
    0.00143986f, 0.02845456f, 0.03519120f, 0.01700628f, 0.01613447f, 0.00490792f, 0.00102866f, 0.01263949f, 
    -0.02684378f, 0.00379807f, 0.00271347f, 0.02545185f, -0.04245664f, 0.03248360f, -0.01338328f, 0.03562552f, 
    -0.02489419f, -0.03101971f, 0.00527547f, -0.02793626f, 0.03156464f, -0.00176645f, 0.01201932f, -0.00239426f, 
    -0.02982844f, 0.01550754f, 0.00353629f, 0.00587077f, -0.00178259f, 0.02122257f, -0.00074060f, -0.03021757f, 
    0.02794075f, 0.02055150f, 0.00054327f, -0.01392200f, 0.01804148f, -0.01690547f, 0.01231850f, 0.01068981f, 
    -0.00709575f, -0.03961881f, 0.00580547f, 0.01572302f, 0.02323225f, -0.00121672f, -0.02099051f, -0.03290008f, 
    -0.02270767f, 0.02829348f, -0.01198528f, -0.00368572f, 0.02555638f, -0.03264624f, 0.02731615f, 0.02239126f, 
    -0.03930878f, -0.01056359f, 0.02210406f, -0.03255639f, -0.02390929f, -0.02365010f, -0.00723938f, -0.01748365f, 
    -0.02905007f, -0.03705550f, 0.00389972f, -0.00631451f, -0.02168530f, -0.01785080f, -0.03166189f, 0.00697286f, 
    0.00880716f, 0.03355505f, -0.02664924f, -0.01934755f, -0.00609464f, 0.01727401f, -0.00477512f, 0.02701714f, 
    0.01486350f, 0.02112426f, -0.00571185f, -0.02453134f, -0.01136010f, -0.03465709f, -0.03282795f, 0.01768096f, 
    0.02602350f, -0.04023603f, -0.01544894f, 0.00924965f, -0.00838166f, 0.01442992f, -0.00505712f, 0.03549751f, 
    -0.02251339f, -0.02369577f, -0.03142238f, 0.01223580f, -0.00924332f, -0.03486052f, -0.01378760f, 0.02386510f, 
    0.00972278f, 0.00195452f, 0.00535740f, -0.00072904f, 0.01861742f, 0.00181098f, -0.01398547f, 0.01176650f, 
    -0.01667367f, -0.02330263f, -0.00796204f, -0.01517178f, -0.01893626f, -0.00144890f, 0.01484333f, 0.01362092f, 
    -0.00918479f, 0.01193054f, 0.00992751f, 0.00622184f, -0.03454834f, -0.03327981f, -0.01723978f, 0.03426060f, 
    0.00844412f, 0.01770851f, -0.00958809f, -0.03920766f, 0.01203230f, -0.00481023f, 0.01089022f, -0.00180385f, 
    0.01217741f, -0.02150423f, -0.00266585f, 0.02289039f, 0.00789007f, -0.02444034f, -0.01402014f, -0.03764242f, 
    0.00135010f, -0.01098316f, 0.00317547f, 0.01444333f, 0.01940375f, -0.03037589f, -0.04114712f, -0.00952471f, 
    -0.01194653f, -0.03424570f, -0.00301124f, 0.01718098f, -0.00874628f, 0.00436493f, -0.02365717f, 0.00550893f, 
    -0.00172311f, 0.01464850f, 0.01082950f, -0.02643645f, 0.02369643f, -0.03806984f, -0.02888635f, 0.00493962f, 
    -0.02638533f, -0.00603818f, 0.01024776f, 0.02424850f, -0.03678315f, -0.02049776f, -0.00178367f, 0.03695837f, 
    0.01924033f, 0.01094196f, -0.00676600f, -0.02841207f, -0.03337305f, 0.02417662f, -0.03407042f, -0.00373750f, 
    -0.03683464f, -0.01716981f, 0.00711150f, -0.00752422f, -0.03274213f, -0.02780281f, 0.01554289f, 0.01376511f, 
    -0.01066156f, -0.02676289f, -0.02187334f, -0.03620335f, 0.02158194f, -0.02633296f, 0.01739413f, 0.00864487f, 
    -0.01212059f, -0.01044687f, 0.01439430f, 0.02985410f, -0.00248281f, 0.02066313f, 0.00301984f, -0.01210117f, 
    0.00728776f, 0.02455147f, 0.00290400f, 0.01465239f, -0.03581902f, -0.01136558f, 0.01425085f, 0.01811335f, 
    -0.01290352f, -0.03705297f, -0.03178814f, -0.03178902f, -0.03081894f, -0.01837948f, -0.03157520f, -0.00767036f, 
    -0.01794061f, -0.00163903f, 0.00696485f, -0.01153440f, -0.01183512f, 0.01927198f, -0.03773236f, -0.01000237f, 
    -0.02107499f, 0.01798941f, -0.01481919f, 0.01432327f, -0.02904084f, 0.00927234f, 0.01202759f, 0.02873824f, 
    0.00542550f, 0.01384538f, -0.01433646f, -0.00268705f, 0.02847113f, -0.02715063f, -0.03037667f, -0.02840618f, 
    0.02346156f, 0.00253568f, 0.03936080f, 0.01815973f, 0.01864829f, 0.02616577f, -0.00675107f, 0.03308094f, 
    0.02467230f, -0.03650434f, -0.01261332f, -0.04212094f, -0.02357248f, 0.01212790f, -0.02221211f, 0.00032509f, 
    0.01718505f, 0.02823607f, 0.03155267f, 0.02780996f, -0.03265582f, -0.02376124f, 0.00581170f, 0.01246323f, 
    -0.00834363f, 0.02636590f, -0.03251950f, -0.02946207f, 0.00562708f, 0.02797244f, 0.00369813f, -0.02408042f, 
    -0.04015834f, -0.03065567f, -0.03523082f, -0.00909999f, 0.00400336f, -0.02222400f, 0.02731361f, -0.02168356f, 
    -0.01550309f, -0.02293026f, 0.02542552f, -0.00702885f, -0.01024312f, -0.02437816f, 0.03021021f, 0.00163365f, 
    -0.01029112f, -0.01088121f, -0.03255821f, 0.00923901f, 0.01759895f, 0.03749448f, -0.02110963f, -0.00295164f, 
    -0.00551134f, -0.03368722f, -0.03289516f, 0.01310934f, 0.03433639f, -0.02233060f, -0.00778780f, -0.01215971f, 
    -0.02506437f, -0.02806011f, -0.02749728f, 0.01987592f, -0.02680767f, -0.00341078f, -0.03795069f, 0.02522617f, 
    -0.03569856f, 0.02828629f, 0.01862554f, -0.01565875f, 0.00310445f, -0.02478826f, -0.02873150f, 0.01258223f, 
    -0.00271709f, 0.02282603f, -0.02580488f, -0.01817842f, 0.01528999f, -0.00479112f, -0.04089609f, -0.00301064f, 
    0.00295270f, 0.02630926f, -0.00785923f, -0.02476897f, 0.02952462f, 0.01407013f, -0.00835749f, -0.00435100f, 
    -0.02773795f, -0.00406069f, -0.02326883f, 0.00038608f, -0.03840978f, 0.01913349f, -0.00240201f, 0.00515333f, 
    0.02533555f, -0.00587515f, -0.00323672f, -0.02225385f, -0.00043606f, -0.03799956f, -0.00277543f, 0.02781158f, 
    -0.02025800f, -0.00101822f, 0.01978889f, -0.02353430f, 0.02869580f, 0.01179339f, 0.02078504f, 0.03005676f, 
    -0.02614106f, -0.01510807f, -0.00547333f, -0.01902466f, -0.01117596f, -0.01810777f, 0.02893586f, -0.00248317f, 
    0.01747934f, 0.01752206f, 0.01656133f, -0.02032974f, -0.00003661f, 0.00998397f, -0.03926092f, 0.01965511f, 
    0.00323392f, -0.02038611f, 0.02670552f, -0.02549449f, -0.03416302f, -0.00944565f, -0.03788800f, 0.01553592f, 
    -0.00432288f, -0.02691768f, -0.03246883f, -0.00505708f, 0.02195214f, 0.02416678f, -0.03406164f, -0.00223039f, 
    -0.00540646f, -0.01181195f, 0.00569056f, -0.01816510f, 0.03261890f, 0.02811206f, 0.02083170f, -0.02196684f, 
    -0.03935755f, -0.04128259f, 0.00631693f, 0.01263946f, -0.00158182f, 0.00517384f, -0.04098135f, -0.00517133f, 
    0.02667630f, -0.03302594f, 0.02380009f, -0.01889111f, 0.00588050f, 0.00532797f, -0.00734792f, 0.02728230f, 
    0.02650310f, -0.00779709f, -0.03665721f, -0.00694808f, -0.02090175f, -0.00012901f, 0.02948371f, -0.02354455f, 
    -0.01110319f, 0.01243031f, 0.00723675f, 0.02359116f, -0.03537246f, 0.00328772f, -0.01682381f, 0.03627012f, 
    -0.02953432f, -0.02885720f, -0.01551620f, -0.02822343f, 0.00672166f, 0.00207719f, 0.00283349f, 0.03076309f, 
    0.11013090f, -0.13959649f, 0.04340675f, 0.12100502f, 0.01701557f, 0.11304826f, -0.00801545f, -0.09693255f, 
    -0.02224268f, 0.03966894f, -0.00422415f, 0.06256822f, -0.21954916f, -0.19489720f, -0.11079703f, 0.13834669f, 
    -0.01412151f, 0.05660816f, 0.08373565f, 0.01884496f, -0.05712909f, -0.03991886f, -0.09991314f, -0.06143621f, 
    -0.12526996f, 0.30121106f, -0.12798332f, -0.05770065f, -0.11863612f, 0.21113597f, -0.02609662f, -0.02386241f, 
    0.01544406f, -0.05840834f, 0.08442017f, -0.12334847f, -0.14697005f, -0.14217468f, -0.24019341f, 0.12723173f, 
    0.05108624f, 0.02756798f, 0.03314180f, 0.04752329f, 0.04796824f, -0.01433183f, 0.01314625f, 0.08096594f, 
    -0.36572275f, 0.08752570f, 0.07963593f, 0.15177868f, 0.11037661f, -0.07401354f, -0.07800172f, -0.04964025f, 
    0.15293166f, 0.04532651f, 0.11766166f, 0.24604422f, -0.03507776f, -0.04632112f, -0.10185124f, -0.04602993f, 
    0.06941467f, -0.10747857f, 0.01441967f, -0.03022802f, 0.06288966f, 0.03714684f, 0.03962112f, 0.00164569f, 
    0.02057119f, 0.30858320f, -0.01526922f, -0.02398721f, -0.05934441f, -0.00922608f, -0.06384982f, -0.02022634f, 
    -0.03832842f, 0.03312445f, 0.10046605f, 0.05539624f, 0.38860345f, -0.29411283f, -0.00997336f, -0.04655219f, 
    0.07855704f, 0.10863811f, -0.01419715f, -0.12525041f, 0.02823850f, 0.09587091f, 0.00893419f, -0.01273192f, 
    -0.03557192f, -0.10615962f, 0.10592914f, -0.00438584f, -0.02023907f, -0.10472655f, 0.22595143f, -0.08805095f, 
    0.20474835f, -0.12196078f, 0.03947341f, 0.04296539f, 0.14307027f, -0.05147038f, 0.04922150f, 0.14434554f, 
    -0.00497901f, 0.16105463f, 0.02257642f, -0.07349137f, -0.00917343f, 0.06094642f, -0.09205716f, 0.03048772f, 
    0.05011341f, 0.18986580f, -0.06494883f, -0.03638498f, 0.01360601f, -0.05286726f, 0.00465679f, 0.01076637f, 
    0.13166161f, 0.02940395f, -0.05494748f, -0.13178383f, -0.07241585f, 0.09172764f, -0.02811221f, 0.00071612f, 
    0.05365488f, 0.02025029f, 0.06756186f, 0.01671419f, -0.14491805f, 0.11274426f, 0.02629618f, -0.10665841f, 
    0.17339173f, -0.10926982f, -0.43485248f, 0.37223467f, -0.02247458f, 0.15565118f, 0.16460505f, -0.11299255f, 
    -0.01011810f, 0.09064399f, -0.06323419f, 0.00485516f, 0.05749228f, -0.03444664f, -0.04119421f, 0.06011684f, 
    0.00548717f, -0.03254018f, -0.05330124f, 0.03413560f, 0.10660603f, 0.08106348f, 0.10677635f, 0.07174844f, 
    -0.19457440f, -0.08177770f, -0.09941735f, 0.01525149f, -0.10168016f, 0.18038262f, 0.19012171f, 0.07179059f, 
    -0.05320448f, -0.00995620f, -0.07541572f, 0.01562209f, -0.08617778f, -0.06446020f, -0.11619063f, 0.10819022f, 
    0.11337455f, 0.05026210f, 0.01457047f, 0.07714019f, -0.11449650f, 0.05742462f, -0.05108554f, -0.06708079f, 
    0.15159178f, -0.17791201f, 0.12420022f, 0.32117489f, -0.00007089f, 0.10543565f, -0.12361019f, -0.09037191f, 
    0.07840241f, 0.03468445f, -0.07954849f, 0.12243579f, 0.07501288f, -0.13689896f, -0.05027715f, 0.19026119f, 
    0.05944040f, 0.02637542f, 0.04027854f, -0.02486424f, -0.04973129f, 0.05090521f, 0.05633683f, -0.03607489f, 
    0.48258790f, -0.13569391f, -0.22814113f, 0.16532643f, 0.11410336f, -0.19081435f, 0.10071963f, 0.08460604f, 
    0.03784249f, -0.02644573f, 0.17321531f, 0.21505052f, 0.08900134f, -0.05070075f, -0.07132505f, 0.01396290f, 
    -0.01752353f, -0.08464611f, 0.00197083f, 0.09508919f, -0.00720281f, 0.37588266f, 0.00573737f, 0.08532673f, 
    -0.15916455f, 0.03308599f, -0.00540101f, 0.09585372f, -0.04188277f, -0.01788723f, 0.04446302f, -0.16208833f, 
    -0.01083698f, 0.01189565f, 0.09286933f, -0.03076543f, -0.17207225f, -0.01516173f, -0.14201440f, -0.14258723f, 
    0.09513739f, 0.10984642f, 0.02378446f, 0.12892465f, 0.01790105f, 0.10040990f, -0.03138177f, 0.00843353f, 
    -0.01785305f, 0.13800550f, -0.34056067f, 0.25794607f, -0.04129293f, -0.11322294f, 0.01110056f, -0.03449009f, 
    -0.01704690f, 0.02218205f, 0.00940026f, 0.00376336f, -0.10610202f, -0.05344904f, 0.03982587f, -0.16365308f, 
    0.03258947f, -0.05348742f, -0.07910834f, -0.05093949f, 0.10397424f, 0.00505733f, 0.06644231f, 0.00340490f, 
    -0.08505601f, 0.05280687f, 0.07084044f, 0.04993993f, 0.00255988f, -0.08103883f, -0.05515797f, 0.02091016f, 
    0.13270332f, 0.11129747f, 0.24161965f, 0.05620392f, -0.06853616f, -0.00842758f, -0.02327153f, 0.00174438f, 
    0.05139004f, 0.01949538f, 0.13439517f, 0.12151982f, -0.03242194f, -0.06231245f, -0.01574316f, -0.00606719f, 
    0.17105113f, 0.17596060f, -0.01384955f, -0.13191281f, -0.05193440f, -0.06260446f, 0.03904528f, -0.10767459f, 
    -0.00058082f, 0.14942271f, 0.18282615f, 0.06054008f, 0.07061656f, -0.05384200f, -0.17443641f, 0.26492852f, 
    0.12845534f, 0.07301325f, 0.05393996f, 0.07682023f, 0.01262278f, 0.05754502f, -0.00954898f, -0.00872760f, 
    -0.07637732f, 0.02536024f, -0.05955566f, -0.11308587f, 0.00664902f, -0.04615469f, 0.03704850f, 0.15751296f, 
    -0.10950369f, -0.11606675f, -0.07453268f, -0.05601839f, -0.07457307f, 0.31445000f, 0.07185162f, -0.22176497f, 
    -0.05052186f, 0.02465772f, -0.07733810f, 0.01682389f, 0.16957666f, 0.14095527f, 0.00479926f, 0.25740513f, 
    -0.01123404f, 0.12930435f, -0.31761974f, 0.00209988f, 0.14532261f, 0.02903422f, 0.17992251f, -0.09026332f, 
    -0.09039403f, 0.01834981f, -0.06539044f, 0.11645915f, -0.04121893f, 0.08719502f, -0.05522305f, 0.21506728f, 
    0.10828918f, -0.10463812f, 0.00070490f, -0.06443225f, -0.09933356f, 0.06799417f, 0.06032673f, -0.02192022f, 
    0.24165726f, -0.01640756f, -0.06043012f, -0.05235771f, 0.05530190f, -0.24698763f, 0.16713248f, 0.10266393f, 
    0.04175892f, -0.07559207f, 0.01992314f, 0.08005378f, 0.03720800f, -0.13695250f, 0.12780316f, 0.14479543f, 
    -0.10173471f, 0.05517855f, 0.14784217f, 0.13070284f, 0.01292574f, -0.09676699f, 0.05137212f, 0.01395129f, 
    -0.18716580f, -0.14653334f, 0.07195611f, -0.09049989f, -0.01503316f, -0.00422095f, -0.02990128f, -0.11943037f, 
    0.07499515f, -0.06284679f, 0.02781107f, -0.00542349f, -0.15334499f, -0.18791476f, 0.24743827f, 0.22362019f, 
    0.04416006f, 0.21137440f, -0.13376077f, 0.17490324f, 0.03792843f, 0.02182997f, -0.01126655f, 0.15033154f, 
    -0.09389667f, -0.05294709f, 0.03396173f, 0.24605231f, 0.03913410f, 0.07010577f, -0.04600471f, -0.06509158f, 
    -0.04003908f, 0.03401904f, -0.03042115f, -0.08948964f, -0.20965588f, 0.05967465f, -0.04023712f, 0.01838919f, 
    0.06703206f, 0.03574067f, -0.07770392f, 0.02487877f, -0.01374554f, 0.05386411f, 0.04095474f, 0.13840854f, 
    0.09732811f, -0.02940571f, 0.02332388f, 0.03154120f, -0.08418596f, -0.04935282f, 0.08469183f, 0.08130559f, 
    -0.07857008f, 0.04517468f, -0.07208196f, -0.16367735f, -0.02109879f, 0.05947172f, -0.24738340f, -0.03523919f, 
    0.11345069f, 0.06432265f, 0.13838013f, 0.04631986f, -0.00935950f, 0.09408592f, 0.06108792f, 0.03117155f, 
    0.01377259f, 0.07277979f, -0.08146754f, 0.30752355f, -0.04313063f, 0.16503522f, 0.05613630f, 0.02686973f, 
    -0.05601747f, -0.05180695f, -0.06141739f, -0.02205142f, 0.00206313f, -0.31620371f, -0.28143904f, 0.07046747f, 
    0.01687819f, -0.04748121f, -0.01003940f, 0.00469308f, -0.04314500f, -0.02011516f, 0.06096742f, 0.06057407f, 
    0.10756432f, -0.11312071f, -0.19024405f, -0.10561004f, 0.13091464f, 0.04614113f, 0.19760576f, 0.10387477f, 
    -0.05862511f, -0.06114044f, -0.01985830f, -0.05126544f, 0.01636027f, -0.02646225f, -0.03925141f, -0.02404314f, 
    0.03833651f, -0.03419492f, -0.12940513f, 0.11141396f, 0.01197871f, 0.11588457f, -0.01567338f, 0.00683217f, 
    -0.18741156f, -0.12675655f, 0.20061553f, 0.03546844f, 0.07444163f, 0.01343397f, -0.09907410f, -0.01932637f, 
    0.04900332f, 0.13644038f, 0.08678924f, 0.04344757f, 0.04967351f, 0.25539377f, -0.15196243f, 0.00222765f, 
    0.04688491f, 0.24396363f, 0.02579902f, -0.10058784f, -0.07932146f, -0.01867931f, -0.02134435f, 0.07138500f, 
    0.00563533f, 0.01690617f, -0.07072193f, 0.02975040f, 0.01755419f, 0.01412696f, -0.06902272f, 0.02208420f, 
    0.09122230f, -0.01235756f, 0.03447877f, 0.02702361f, -0.06908023f, 0.00423250f, 0.11954512f, -0.14297016f, 
    0.05247283f, -0.11759821f, -0.04051091f, -0.06268918f, 0.11457766f, -0.02540632f, 0.11241239f, -0.03103553f, 
    -0.12652862f, -0.00998900f, -0.03688251f, -0.16954711f, 0.01548725f, 0.01244248f, 0.04275708f, 0.17314458f, 
    -0.03167122f, -0.02133513f, -0.14521678f, -0.17619880f, -0.01424103f, 0.01550429f, 0.10108168f, 0.04663663f, 
    0.01723411f, -0.04792314f, 0.00173776f, -0.01932463f, 0.03679603f, 0.00210760f, 0.01031849f, 0.10383708f, 
    -0.02191726f, 0.14473994f, -0.32301009f, -0.07259504f, 0.01907444f, 0.00865370f, 0.07201599f, -0.06554341f, 
    -0.05026130f, 0.02712265f, -0.04518520f, 0.23022462f, -0.12011046f, 0.12089379f, 0.26230505f, 0.37332657f, 
    0.03232064f, -0.04194007f, -0.00494243f, 0.06159254f, 0.02631658f, -0.01331474f, 0.17277046f, 0.18210335f, 
    -0.06745247f, 0.04726401f, -0.06231215f, 0.05107737f, 0.12891959f, 0.02198218f, -0.01388791f, 0.02450185f, 
    -0.19053897f, -0.11776312f, -0.08932905f, -0.38673440f, -0.14610291f, -0.13128857f, -0.02277208f, 0.09796481f, 
    0.09857892f, 0.14679287f, 0.17245506f, 0.08025309f, 0.00455022f, -0.05283043f, -0.10191647f, -0.05599770f, 
    -0.18647504f, 0.12469764f, 0.00467932f, -0.01057427f, -0.11298519f, -0.04156767f, -0.07729419f, -0.07429705f, 
    0.04525349f, 0.03598231f, 0.03382554f, 0.20168649f, 0.03734658f, 0.07453717f, -0.08457897f, 0.11081170f, 
    0.03807249f, -0.08806659f, 0.06224780f, -0.02976206f, 0.10860433f, 0.09757576f, 0.17981522f, -0.05324170f, 
    -0.11126204f, -0.08698702f, -0.08313700f, 0.03516261f, -0.00698513f, 0.01182107f, -0.06419020f, 0.07910499f, 
    0.00734200f, 0.06568426f, -0.03602351f, 0.08257358f, -0.08212762f, 0.00664548f, 0.04034287f, -0.01755419f, 
    -0.02269769f, -0.12349150f, 0.03506101f, -0.05157127f, 0.11462831f, 0.02972771f, 0.05500134f, 0.05947317f, 
    -0.15481655f, 0.06103256f, 0.28534335f, -0.06929648f, 0.06759713f, -0.03259952f, 0.06148841f, -0.00755560f, 
    -0.05842593f, -0.05712192f, -0.05620780f, 0.12355780f, 0.03721207f, 0.03933963f, -0.08300888f, -0.00725103f, 
    -0.04057885f, -0.11841407f, 0.03970763f, -0.10711588f, -0.02398109f, 0.17947827f, -0.13517419f, 0.00820658f, 
    -0.19295652f, -0.01981970f, 0.10179861f, -0.04857492f, -0.00337449f, -0.04664887f, 0.06792440f, 0.01867147f, 
    0.09141733f, -0.11895812f, -0.09675273f, -0.03050821f, -0.30927655f, -0.11295329f, 0.00190752f, 0.02697600f, 
    -0.07310791f, -0.00171324f, -0.06182856f, -0.02172871f, -0.04264898f, 0.04285552f, -0.08768873f, -0.01949705f, 
    -0.00977973f, 0.01769340f, -0.00694124f, -0.06876156f, 0.06582882f, 0.03107262f, -0.05295376f, 0.16297896f, 
    -0.09488609f, -0.08508080f, 0.03631781f, -0.04175143f, -0.05744350f, 0.05666260f, -0.12846653f, 0.17914566f, 
    0.08180478f, 0.08410916f, -0.07131845f, 0.11045930f, -0.12270895f, 0.06598731f, -0.00532138f, 0.03626166f, 
    -0.00877885f, -0.00334117f, -0.01213895f, 0.02966426f, -0.00113625f, 0.02565825f, -0.02113037f, 0.02807637f, 
    -0.03399720f, 0.01184353f, 0.00359603f, -0.03518791f, 0.01917497f, 0.01390083f, 0.00834992f, 0.02589780f, 
    0.02000400f, 0.00850698f, -0.02707515f, -0.01416435f, -0.01128684f, -0.04149140f, 0.00496782f, -0.04171061f, 
    0.02592231f, 0.02691616f, -0.02932411f, 0.00453849f, 0.02378326f, 0.01609475f, 0.02425076f, 0.01198518f, 
    0.00963742f, 0.00960870f, 0.00721661f, 0.00991277f, -0.02070515f, 0.00414453f, 0.02785051f, -0.00624380f, 
    -0.00505891f, 0.02693306f, 0.00204832f, 0.02660554f, 0.00482797f, -0.03136627f, 0.01632692f, 0.01543183f, 
    -0.01284361f, 0.02995900f, 0.02485284f, 0.00037384f, -0.03369506f, -0.00363472f, -0.00531715f, -0.02758324f, 
    -0.02705723f, -0.03680448f, -0.03515807f, -0.02547652f, -0.00701588f, -0.01561803f, -0.04073966f, -0.03998492f, 
    0.01619667f, -0.01292140f, 0.00761802f, 0.01388865f, 0.02076845f, -0.03685814f, -0.01713472f, 0.02581856f, 
    -0.02358519f, -0.00827290f, -0.03310458f, 0.01941341f, -0.03777340f, -0.03765086f, -0.01787077f, 0.01432673f, 
    0.00285832f, -0.01951123f, -0.01486219f, -0.02679731f, 0.02788681f, 0.02672357f, 0.01700265f, -0.03833725f, 
    0.01775537f, -0.01719170f, 0.02171100f, 0.00350906f, -0.03254440f, 0.00167981f, -0.03255708f, 0.00089687f, 
    0.01774436f, 0.02995824f, -0.01355356f, -0.02321834f, -0.00210665f, 0.02296447f, 0.02535282f, -0.01115443f, 
    -0.02809474f, -0.02456726f, -0.00784411f, 0.00810322f, -0.03343641f, 0.02818826f, 0.02226456f, 0.02692400f, 
    0.01396397f, -0.02063858f, -0.01183578f, -0.03208808f, -0.01330257f, -0.03050757f, 0.00638777f, -0.00966480f, 
    0.03715844f, 0.01924388f, -0.03443011f, -0.01192735f, -0.02526485f, -0.03552774f, -0.01044982f, -0.04081767f, 
    -0.02564934f, -0.03096266f, 0.02803658f, 0.02793902f, 0.01045859f, -0.00196590f, -0.02331017f, -0.02549838f, 
    -0.03503755f, -0.01693544f, 0.00568874f, 0.02322972f, -0.01927357f, -0.02936820f, -0.03090754f, -0.03608695f, 
    -0.02808568f, -0.01205230f, -0.01086019f, -0.01100628f, -0.02940076f, -0.02933719f, -0.02065050f, -0.01605907f, 
    -0.02506344f, 0.01534493f, 0.02214997f, 0.01054899f, -0.00169780f, -0.00966145f, 0.01324993f, -0.02532999f, 
    0.02277173f, -0.01903380f, 0.02406050f, -0.01077087f, 0.00440669f, -0.01181204f, -0.00053650f, 0.01610677f, 
    -0.01640722f, -0.03718931f, -0.00516343f, 0.00251904f, -0.00188435f, 0.00300000f, 0.01561445f, -0.02206769f, 
    -0.01284735f, 0.01925110f, 0.03104552f, -0.04068624f, -0.02378164f, 0.00785067f, 0.00138108f, -0.01566133f, 
    -0.00815082f, -0.03390603f, -0.02019442f, -0.01528140f, -0.02628306f, 0.00408600f, 0.01433710f, 0.02969980f, 
    -0.02445052f, 0.01907816f, -0.00611490f, -0.01361776f, 0.01480727f, -0.04067989f, -0.03502330f, -0.00979426f, 
    0.02923967f, 0.01927781f, -0.01873566f, -0.00187249f, 0.02062564f, 0.02210926f, -0.00983490f, 0.00899521f, 
    -0.01027066f, 0.01076577f, -0.00511226f, -0.03712049f, -0.03620519f, 0.01239056f, -0.01994307f, -0.02527861f, 
    0.00597463f, 0.01232991f, 0.02094627f, -0.01450380f, -0.01436001f, 0.03020462f, -0.01980002f, 0.01408971f, 
    -0.02757273f, -0.03549052f, 0.02220404f, -0.04036510f, 0.00705253f, 0.02923311f, 0.00739172f, -0.03460922f, 
    -0.01832602f, -0.03239220f, -0.04094264f, 0.01165022f, -0.02168103f, 0.00663237f, -0.02225859f, -0.02476966f, 
    -0.03110376f, -0.03703967f, -0.03764586f, 0.01576632f, -0.01832972f, 0.01220307f, -0.03105518f, -0.00410884f, 
    0.01184857f, 0.02995195f, 0.01304202f, -0.00966806f, -0.03291696f, 0.02064697f, 0.02267033f, 0.00453341f, 
    0.00963284f, 0.00403185f, -0.03909230f, -0.03461974f, 0.01850219f, -0.01567088f, -0.00408328f, 0.01582823f, 
    0.02885105f, -0.01135624f, -0.00463948f, -0.00056910f, -0.02259507f, 0.01274097f, 0.02564359f, -0.03401899f, 
    -0.03508371f, 0.02589200f, 0.00768022f, -0.01515274f, 0.01973126f, 0.00196126f, 0.02985089f, 0.00354784f, 
    -0.02228247f, -0.00457513f, 0.02507922f, -0.01677571f, -0.00158636f, 0.00000304f, -0.03272838f, 0.01144150f, 
    -0.00667167f, -0.01857198f, -0.00358299f, 0.01987609f, -0.01807795f, 0.01019859f, -0.02933924f, 0.01657098f, 
    -0.03232229f, -0.02241337f, -0.01128697f, 0.00608753f, 0.00743006f, -0.03682839f, -0.01098340f, -0.02765642f, 
    0.01730904f, 0.01480630f, 0.01917296f, -0.03511670f, 0.02906288f, 0.02084315f, -0.00728368f, -0.03826091f, 
    -0.00991111f, -0.03577633f, -0.02205800f, -0.01898245f, -0.00064200f, -0.03190159f, 0.02850401f, -0.03257849f, 
    -0.03061200f, -0.03572534f, -0.02366061f, -0.00620138f, 0.01538276f, 0.00458776f, 0.03712672f, -0.03572018f, 
    0.01563177f, 0.01342282f, -0.03899159f, -0.00863982f, -0.02671717f, 0.00369314f, -0.01673043f, -0.02081103f, 
    -0.00946232f, -0.02078380f, -0.02694641f, -0.04207010f, 0.02936990f, 0.00604630f, 0.02756652f, 0.00392753f, 
    0.00994290f, -0.02036275f, -0.02812200f, -0.02311081f, -0.00476335f, -0.02468904f, -0.01398921f, -0.00646576f, 
    -0.01687212f, 0.01806867f, -0.00233410f, 0.02836386f, -0.02796031f, -0.00993482f, 0.01685244f, -0.03204396f, 
    0.02357696f, -0.00483854f, 0.01667219f, 0.02977705f, -0.00472140f, -0.01119329f, 0.01132451f, 0.01472539f, 
    0.01571536f, 0.02733298f, 0.00342963f, 0.02652058f, -0.01873733f, 0.02020568f, 0.00338585f, -0.01568005f, 
    0.01830470f, 0.00943679f, 0.01075807f, 0.00263451f, 0.01103265f, -0.03131787f, 0.02918812f, -0.02686296f, 
    -0.03488237f, -0.01786020f, 0.02120925f, 0.00018111f, 0.01949915f, 0.01703804f, -0.02839032f, -0.04181363f, 
    -0.01272383f, -0.03126317f, -0.03794764f, -0.01936504f, 0.01008981f, 0.01092390f, -0.03059645f, 0.02835912f, 
    -0.00671331f, -0.00574588f, -0.01452351f, -0.02438995f, 0.02614137f, 0.00743951f, 0.01046335f, 0.01027629f, 
    -0.03815012f, -0.01311346f, -0.03808703f, 0.01956690f, 0.01213641f, -0.02589228f, 0.00359500f, -0.00359173f, 
    -0.00925241f, -0.03211923f, -0.02420605f, 0.03789929f, 0.02845987f, 0.01366545f, -0.00430893f, -0.03092250f, 
    0.02324644f, -0.01338574f, 0.02640665f, -0.03928688f, 0.01027513f, -0.03999608f, 0.02888977f, 0.02341180f, 
    -0.02141345f, -0.03677696f, -0.00253330f, -0.00002626f, -0.02005570f, -0.03927067f, 0.02264719f, -0.03675938f, 
    -0.01506911f, 0.01156470f, 0.00356093f, 0.02716268f, 0.02881246f, 0.00266147f, -0.03197217f, -0.01913825f, 
    -0.00718183f, -0.03740994f, -0.02847373f, -0.00252191f, 0.00171613f, -0.01751049f, -0.00438767f, -0.03375909f, 
    0.03044556f, -0.00597138f, 0.02064112f, 0.02881818f, -0.02063250f, -0.02007827f, -0.00814348f, -0.01044307f, 
    -0.03424144f, 0.00043264f, -0.01472720f, 0.02725847f, 0.04126228f, 0.02374428f, -0.02112966f, -0.03534276f, 
    0.02715096f, 0.01846517f, 0.00362223f, -0.00827952f, 0.02731918f, 0.02909223f, -0.01512502f, -0.01585681f, 
    -0.02699116f, -0.03009258f, 0.00594619f, 0.00134134f, -0.00898307f, -0.03298716f, -0.02207373f, 0.00564298f, 
    -0.03570599f, -0.00963045f, -0.02082863f, -0.01666908f, 0.00448284f, 0.01421494f, 0.00346883f, 0.00235157f, 
    0.01395463f, 0.02688722f, -0.03695843f, -0.02504474f, 0.02670963f, -0.01542979f, -0.03438971f, 0.02668670f, 
    -0.02157900f, 0.00989796f, 0.02694585f, 0.01189913f, -0.03068830f, 0.00304510f, 0.01358690f, -0.02930531f, 
    0.02790916f, -0.01821790f, 0.04195766f, -0.02403537f, -0.02348118f, -0.01970360f, -0.02549797f, -0.00508897f, 
    -0.03729166f, -0.00910751f, 0.00358189f, -0.00103252f, -0.00112869f, -0.03283716f, -0.00695238f, 0.02978153f, 
    -0.04031684f, -0.02156150f, 0.02181608f, -0.03420055f, 0.02188301f, -0.00347721f, -0.03746812f, -0.01419461f, 
    0.01208147f, -0.01014126f, -0.03569138f, -0.00460325f, 0.02954069f, 0.02732597f, -0.00774854f, -0.01190484f, 
    -0.02509722f, 0.02540255f, -0.02056460f, 0.00748524f, -0.03134790f, 0.00675931f, 0.02478573f, 0.03002684f, 
    0.01446129f, 0.00202998f, -0.03792785f, 0.02461342f, -0.01406881f, -0.02690484f, -0.01324025f, -0.00414626f, 
    0.02828859f, 0.01333450f, 0.00906852f, 0.02069175f, 0.01439677f, -0.02194941f, 0.00759628f, 0.01471572f, 
    -0.01938163f, -0.00710643f, -0.02355008f, -0.04078891f, -0.02584274f, -0.01536077f, 0.00200152f, 0.02157666f, 
    -0.01434661f, -0.00094382f, -0.03507309f, -0.01349841f, -0.00493018f, -0.03383981f, -0.00599902f, 0.01717338f, 
    0.02020438f, -0.01463460f, -0.02363637f, 0.01577511f, -0.02429714f, -0.03849599f, -0.01861149f, -0.01095003f, 
    0.02047905f, -0.02672905f, -0.03771472f, -0.03248607f, -0.02210665f, 0.00573323f, -0.03781143f, 0.02004789f, 
    0.00180465f, -0.02530316f, 0.02387872f, -0.02275044f, -0.02469639f, -0.00181820f, -0.02479835f, -0.00693464f, 
    0.02291857f, -0.03300171f, -0.01325142f, 0.02866301f, 0.00226434f, -0.03360853f, 0.00760549f, 0.01672143f, 
    -0.02564374f, -0.00970524f, -0.02098405f, -0.01778834f, -0.01088394f, 0.00376468f, 0.01859430f, 0.02252357f, 
    0.03188801f, 0.02208427f, 0.00064159f, 0.03182129f, -0.00290662f, -0.02153369f, -0.02262301f, 0.00570779f, 
    0.02080117f, -0.01014121f, -0.02356968f, -0.03001505f, -0.00100637f, -0.03653313f, 0.00995867f, 0.00696368f, 
    0.02835069f, -0.02813832f, -0.00560881f, 0.02113944f, -0.01577430f, -0.02487773f, -0.02801973f, -0.00588805f, 
    0.01136027f, 0.01162989f, -0.03477178f, 0.02466397f, -0.02398729f, -0.00553631f, 0.00372471f, -0.00402010f, 
    -0.01611066f, 0.01936201f, -0.01612256f, -0.00200117f, -0.00683213f, 0.00492208f, -0.01456680f, -0.03654339f, 
    0.01780590f, 0.01237006f, 0.02037161f, 0.03527893f, 0.01579306f, 0.02642474f, -0.04056642f, 0.02201995f, 
    -0.04194354f, 0.02821410f, 0.00705466f, 0.01653407f, -0.01488300f, -0.00657700f, -0.03249248f, 0.02796615f, 
    -0.01587614f, -0.02021746f, 0.02970695f, -0.00323673f, -0.02999444f, -0.02712198f, -0.02587566f, 0.00068575f, 
    0.02301844f, -0.03494479f, -0.03348172f, 0.03750650f, 0.00966933f, -0.00671732f, -0.02919488f, -0.00432178f, 
    0.00215323f, 0.00608905f, -0.04136701f, -0.03527834f, -0.00610859f, -0.01878933f, 0.01936243f, 0.02284002f, 
    -0.01984807f, -0.01573537f, 0.00979950f, -0.02758048f, -0.02670921f, 0.02823791f, -0.00200166f, 0.01787085f, 
    0.00173817f, 0.02339032f, -0.00196287f, -0.02955399f, -0.01164395f, 0.02220171f, -0.03843340f, -0.02955145f, 
    0.03289367f, -0.00932373f, -0.00386372f, -0.00144313f, 0.02828468f, 0.00716649f, -0.02019328f, 0.00321590f, 
    -0.00194744f, 0.02111744f, -0.02800245f, 0.00244076f, -0.02925006f, 0.00851433f, -0.03673659f, -0.03101928f, 
    0.00351308f, -0.03294307f, 0.00343403f, 0.02364157f, -0.04098656f, -0.03867985f, -0.03342346f, 0.02525851f, 
    -0.02110262f, 0.02355108f, -0.02269450f, -0.02941077f, 0.01405218f, 0.02025583f, -0.04002027f, -0.01838022f, 
    -0.02347647f, -0.03609046f, 0.01724699f, -0.01116293f, 0.03360218f, -0.00702598f, 0.02836399f, 0.00911602f, 
    0.01996949f, 0.00629869f, -0.03706954f, -0.00665725f, -0.02159823f, -0.01566246f, -0.04023936f, 0.00412706f, 
    -0.15261708f, -0.17314452f, 0.06357834f, 0.24066795f, 0.13349886f, 0.00222916f, 0.04539303f, -0.03525046f, 
    0.10585275f, 0.04711401f, -0.03962492f, 0.05314492f, 0.03267870f, 0.31345612f, 0.07481246f, 0.15587994f, 
    -0.00969874f, 0.05136481f, 0.04150667f, 0.05113980f, 0.01304663f, -0.02693759f, -0.05083849f, -0.05971004f, 
    0.28160298f, -0.05373348f, -0.13439801f, 0.25209811f, -0.17822394f, 0.08910771f, 0.03231785f, -0.08794124f, 
    0.06428726f, 0.06573784f, -0.00305523f, 0.19240656f, -0.31949639f, -0.08256101f, 0.00488674f, -0.01557914f, 
    -0.06745472f, -0.07733210f, 0.04528903f, 0.14957812f, 0.06010247f, 0.03093414f, 0.03613522f, 0.08891274f, 
    -0.53674638f, -0.04736962f, 0.29305536f, -0.17005295f, -0.03687654f, -0.01096836f, 0.02691180f, 0.16186593f, 
    -0.21799774f, 0.04362572f, 0.20417501f, -0.03210607f, -0.15235423f, 0.10544597f, 0.17212929f, 0.10201892f, 
    0.11390689f, 0.04192870f, -0.15861429f, 0.06747030f, -0.09621602f, -0.16666394f, -0.02426463f, -0.14952031f, 
    -0.17643866f, 0.00511812f, 0.00515068f, -0.03698853f, -0.03569585f, -0.07452270f, 0.02582446f, -0.00290760f, 
    -0.00192446f, 0.11083901f, 0.12786403f, 0.04017882f, 0.47653750f, -0.34924692f, 0.30422378f, 0.21700287f, 
    0.03950204f, -0.02660610f, -0.06768081f, -0.08031804f, -0.07514907f, 0.04394665f, -0.04847082f, -0.01232505f, 
    -0.09762519f, 0.09087458f, 0.07660478f, -0.13920590f, 0.03851363f, -0.05170099f, -0.02891484f, -0.02598357f, 
    -0.10220307f, 0.05664566f, -0.04223727f, -0.08109888f, 0.18073012f, -0.18307491f, 0.29644763f, 0.10383671f, 
    0.02890252f, -0.05933676f, 0.12610729f, 0.04077153f, -0.01686205f, -0.02517466f, 0.03618658f, 0.01488004f, 
    -0.21281742f, -0.09244778f, 0.01073141f, 0.03502497f, 0.01499446f, -0.06224906f, 0.01234826f, -0.08969298f, 
    0.06168854f, 0.08705620f, 0.14417467f, 0.08710600f, -0.02195379f, 0.18302488f, -0.17097412f, -0.01900888f, 
    0.00626662f, 0.11126062f, 0.02628536f, -0.11197911f, 0.13663346f, 0.12361950f, 0.08655127f, 0.10167786f, 
    0.10629809f, 0.13319787f, 0.37298152f, 0.30908123f, 0.07707766f, 0.23082171f, 0.04570574f, 0.14152679f, 
    0.00278905f, -0.08231127f, -0.07225338f, -0.19042252f, 0.11320884f, -0.12506041f, 0.02779536f, -0.09823125f, 
    -0.00630708f, 0.02414003f, -0.05054307f, -0.02970425f, 0.00054268f, -0.13261017f, 0.00194784f, -0.13133153f, 
    0.16505972f, 0.38995555f, 0.18375485f, -0.20573574f, 0.15919715f, 0.04515139f, 0.04011003f, 0.05325546f, 
    0.04254694f, -0.08766658f, -0.12208021f, -0.25517654f, -0.31137827f, 0.03309980f, 0.21669319f, 0.03129255f, 
    -0.01557179f, -0.08381596f, 0.02298158f, 0.12964053f, 0.10504972f, -0.09050895f, -0.01031725f, 0.05118528f, 
    -0.11652641f, -0.00074092f, 0.14127944f, -0.12310719f, 0.00716657f, 0.21491535f, 0.02583951f, -0.05845768f, 
    -0.00480584f, -0.02877746f, 0.05384568f, -0.06685746f, -0.20225510f, 0.05382183f, 0.28251973f, 0.06882156f, 
    -0.04643224f, 0.12606965f, 0.04639374f, -0.02502212f, 0.13188608f, 0.06684165f, 0.11861840f, -0.04103575f, 
    0.04708029f, -0.24783362f, -0.03520853f, 0.19510667f, 0.07850997f, -0.18226585f, -0.21442299f, 0.13258918f, 
    -0.14009610f, 0.00076805f, -0.03836069f, 0.09969255f, -0.13770716f, 0.00849964f, 0.03686249f, 0.04815214f, 
    -0.05088892f, 0.06201242f, -0.06953989f, -0.08005144f, 0.04271168f, -0.10704612f, -0.15365887f, -0.02510294f, 
    -0.30632868f, -0.18681075f, 0.11817521f, 0.05126883f, -0.01425404f, -0.03467395f, -0.06902025f, 0.01605311f, 
    -0.13968821f, 0.06835364f, -0.05375392f, 0.00039984f, -0.02920188f, -0.12074688f, 0.04129832f, 0.04507792f, 
    -0.06647436f, -0.07331337f, 0.00684283f, 0.16551478f, 0.15051121f, 0.00430023f, -0.07652212f, 0.02567468f, 
    -0.20499717f, 0.10490792f, 0.01662642f, 0.25681669f, 0.07223102f, 0.04913529f, -0.12504415f, 0.01879798f, 
    -0.05644474f, -0.05940251f, -0.04362885f, -0.17902012f, -0.09157418f, -0.15869859f, -0.19372471f, -0.09338587f, 
    0.02458644f, -0.09317344f, 0.02111355f, 0.06921491f, -0.04861925f, 0.00693993f, 0.03711205f, -0.02926926f, 
    -0.17053311f, -0.04014083f, 0.21345361f, 0.01142432f, 0.05064513f, -0.07128505f, -0.06771785f, -0.08766244f, 
    -0.09590340f, 0.04952302f, -0.12550262f, -0.12766273f, -0.11652467f, 0.02647566f, 0.13337895f, 0.05763667f, 
    -0.02893773f, -0.11668523f, 0.04846594f, 0.05436449f, 0.08898289f, 0.07150857f, 0.04285905f, -0.07056123f, 
    0.11805201f, 0.10489578f, -0.05219505f, 0.18919787f, 0.04915516f, -0.06353571f, -0.01371781f, -0.09342099f, 
    0.00854748f, -0.00276620f, -0.14203644f, 0.07924580f, -0.02046523f, 0.04769341f, 0.32155100f, 0.23630486f, 
    0.04341931f, 0.09933271f, -0.17619812f, 0.12420414f, 0.04776937f, -0.05080328f, 0.01937597f, -0.06592321f, 
    -0.12692986f, 0.25654376f, 0.16883007f, 0.22089224f, 0.11423954f, -0.02826349f, 0.03402375f, -0.04356901f, 
    0.01113978f, -0.00097454f, -0.04259469f, -0.06336317f, -0.01998917f, -0.06276437f, -0.18394086f, 0.03675279f, 
    -0.00446744f, -0.00078996f, -0.08229379f, -0.07195209f, 0.11020356f, 0.01046844f, 0.03364506f, 0.05230263f, 
    -0.09027754f, -0.09658532f, 0.04572065f, 0.29676223f, 0.01453871f, -0.13923791f, 0.02459705f, -0.00454631f, 
    0.03237272f, -0.05678985f, 0.03792094f, 0.01858103f, -0.12948398f, -0.00015334f, 0.10667881f, 0.18171410f, 
    0.00671357f, 0.00894629f, -0.09208784f, 0.01198440f, -0.12356176f, 0.01526404f, 0.00144762f, 0.02158447f, 
    0.24487358f, -0.35556328f, 0.17776173f, 0.29491538f, 0.09243510f, -0.03032190f, -0.03812733f, -0.00513644f, 
    -0.05588053f, 0.08225866f, 0.01621380f, -0.06604107f, -0.13554150f, 0.45283899f, -0.06411521f, 0.18896984f, 
    0.09012853f, 0.12826873f, -0.06357928f, 0.00437542f, -0.09948149f, -0.08030567f, 0.03433621f, -0.01725060f, 
    -0.15823506f, -0.12600924f, -0.30243078f, -0.19294250f, -0.00491584f, -0.01860708f, 0.05386564f, 0.10171954f, 
    0.02833646f, -0.02673921f, 0.04403586f, 0.10658890f, -0.18623063f, 0.17578831f, -0.03465790f, 0.18236111f, 
    0.13959199f, -0.00073259f, -0.04460240f, 0.02564307f, -0.02547757f, 0.18347506f, 0.02806385f, -0.04803111f, 
    -0.26180953f, 0.02981141f, 0.16216578f, 0.21049881f, -0.11687460f, 0.14167100f, 0.09895314f, 0.08923158f, 
    0.05793238f, 0.11455958f, -0.10289309f, 0.18121602f, -0.06043207f, -0.02408811f, 0.08563394f, 0.02321061f, 
    -0.10200164f, -0.06147037f, -0.08900067f, 0.01699384f, 0.06547507f, 0.07851461f, -0.05177461f, -0.00674500f, 
    0.08769758f, -0.11815843f, -0.06552681f, 0.08100832f, 0.07515015f, 0.04874840f, 0.07170880f, 0.07333385f, 
    0.19568111f, 0.17647593f, -0.06507771f, 0.29121879f, -0.16729043f, -0.06698373f, -0.10043382f, 0.20072107f, 
    0.04039995f, 0.00094717f, 0.04414537f, -0.08848514f, 0.01466708f, 0.01098100f, 0.12197282f, 0.15485032f, 
    0.14694263f, 0.00463717f, 0.10835651f, 0.18047605f, -0.03093291f, -0.02323806f, 0.05127406f, 0.00796412f, 
    -0.00789466f, 0.09307089f, 0.05067784f, -0.00538568f, -0.18723509f, -0.16462541f, 0.03683739f, 0.10680081f, 
    -0.02309026f, -0.12167279f, 0.03983307f, -0.03454253f, 0.06125284f, -0.01628196f, -0.05715229f, 0.04973399f, 
    -0.02698338f, -0.03437138f, -0.02350535f, 0.01423069f, -0.03739084f, -0.12612379f, 0.20022804f, 0.20928675f, 
    -0.01729950f, -0.09550674f, 0.10355814f, 0.17829111f, 0.24518673f, 0.27797017f, 0.16297084f, 0.24692470f, 
    -0.00578908f, -0.19214162f, 0.12825637f, 0.08145811f, 0.16162655f, -0.00236329f, -0.01502829f, 0.00274033f, 
    0.21804780f, 0.07975437f, 0.24727447f, 0.12028616f, -0.10294817f, -0.07707641f, -0.01908479f, 0.22621921f, 
    -0.00624804f, 0.02593414f, 0.01698327f, -0.00212727f, 0.00439761f, -0.24420623f, 0.14813954f, 0.12900069f, 
    0.04079548f, 0.11661410f, -0.05683708f, -0.00338755f, -0.03041935f, 0.06688543f, -0.14376780f, 0.11076626f, 
    -0.03570751f, 0.00238069f, -0.19280285f, -0.06128893f, -0.01478734f, -0.08337104f, -0.04191698f, -0.06619974f, 
    -0.04323696f, -0.06653777f, -0.07017424f, 0.06047949f, 0.12854026f, -0.15021290f, -0.20833457f, -0.14744897f, 
    0.00947738f, -0.00819207f, -0.04316672f, 0.11330437f, 0.08567583f, 0.11101694f, 0.03753138f, -0.05697072f, 
    -0.12554859f, -0.06566679f, 0.17778261f, -0.01841518f, 0.01655173f, 0.04021887f, 0.09751158f, 0.00481764f, 
    0.14048442f, -0.05380958f, 0.09032569f, 0.14138627f, 0.11630767f, -0.06691217f, 0.26019308f, -0.08965442f, 
    0.05012061f, 0.12003414f, 0.01687415f, 0.09557024f, 0.00295071f, 0.02276128f, -0.11115523f, -0.02365964f, 
    0.03695747f, -0.17766818f, 0.11275670f, 0.15418255f, -0.09986171f, -0.04662053f, -0.02739183f, 0.04432168f, 
    0.09047323f, -0.07176582f, -0.08573373f, 0.10452601f, -0.07492748f, 0.14347228f, -0.04293438f, -0.02041728f, 
    0.09502457f, -0.09343929f, 0.12116937f, -0.04147159f, 0.13625699f, -0.17048283f, 0.17508768f, -0.03793620f, 
    0.01168869f, -0.01174643f, 0.19129054f, 0.20690861f, -0.02144572f, -0.10733307f, 0.02146015f, -0.05728585f, 
    0.18807408f, 0.07976804f, -0.03814937f, 0.14773010f, -0.02503706f, 0.21884690f, 0.15260848f, 0.08824926f, 
    0.01765822f, 0.16369681f, -0.02482272f, 0.03286256f, 0.15350790f, -0.08082218f, 0.05666897f, -0.01236288f, 
    -0.20723227f, -0.08512459f, -0.04621515f, -0.07404052f, 0.07837662f, 0.07291288f, -0.04764456f, -0.06470215f, 
    0.08771424f, -0.01191502f, -0.10447714f, -0.03672615f, -0.33517361f, 0.35461366f, -0.10975663f, 0.02044623f, 
    0.08671563f, 0.10540645f, -0.12166761f, -0.12086451f, 0.05614563f, -0.04562535f, -0.00446146f, 0.01259740f, 
    -0.09531654f, -0.12139235f, -0.00812781f, 0.10876942f, -0.07376959f, 0.04976861f, -0.01551925f, 0.09111926f, 
    0.01780387f, -0.03364994f, -0.08672579f, -0.12922946f, 0.01753189f, -0.15680164f, -0.02926176f, -0.09677668f, 
    -0.03387850f, -0.00599716f, 0.12839249f, 0.07350553f, -0.09008250f, 0.00269107f, -0.03517722f, -0.27484947f, 
    -0.07591596f, -0.02634358f, 0.02138634f, -0.12273026f, 0.12089208f, 0.08334385f, -0.11875921f, 0.16170478f, 
    -0.08063708f, 0.00549362f, -0.06076403f, -0.04237638f, -0.07060517f, -0.12265955f, -0.01109161f, -0.14100091f, 
    -0.01660699f, -0.03093912f, 0.01924222f, 0.01194726f, 0.11634807f, -0.09655698f, 0.06750506f, 0.03689958f, 
    -0.03210640f, 0.11597071f, 0.02276334f, -0.06510908f, 0.02137617f, -0.00032046f, 0.01224408f, -0.00006588f, 
    0.23732659f, 0.24190572f, 0.06619768f, 0.16477171f, -0.10022565f, -0.05971183f, -0.10944045f, -0.18620287f, 
    -0.01516131f, -0.00578750f, -0.02554024f, 0.01759342f, 0.10812569f, -0.02332331f, 0.02830492f, 0.00861351f, 
    -0.34621376f, 0.16856320f, 0.24760434f, 0.08166577f, 0.05015213f, -0.09209374f, 0.09598681f, 0.10576104f, 
    -0.04455527f, 0.05487774f, -0.01244610f, 0.02529191f, -0.01907748f, -0.04433419f, 0.20337892f, 0.22877969f, 
    0.19374628f, -0.03748756f, 0.00525607f, 0.06472626f, 0.09958254f, -0.15742786f, 0.02768658f, -0.17665760f, 
    0.09995004f, 0.18855761f, 0.14779766f, -0.19255197f, -0.11879313f, -0.18568063f, -0.02049447f, 0.15283163f, 
    0.08323161f, 0.08402274f, 0.07367161f, 0.01699254f, 0.03823814f, 0.12615710f, 0.21763818f, 0.05167752f, 
    0.01170334f, 0.04131636f, -0.16798650f, 0.12794115f, -0.08722605f, -0.03486624f, 0.03140663f, -0.04590555f, 
    0.08042756f, -0.15999809f, -0.06047060f, -0.29692325f, 0.12817042f, 0.00094292f, -0.13568042f, 0.10120138f, 
    0.12821905f, -0.01452546f, 0.10718521f, -0.07362908f, 0.19525318f, 0.11966422f, -0.05225846f, -0.06886008f, 
    -0.03920309f, -0.04861329f, -0.07367916f, -0.06058218f, 0.01317919f, 0.03619538f, 0.05523393f, 0.07046337f, 
    0.16717255f, -0.29224455f, 0.02372788f, 0.17800795f, -0.04661655f, 0.02059553f, -0.02523930f, 0.09562272f, 
    -0.01603011f, 0.06620324f, 0.10871186f, -0.03131570f, 0.04726380f, 0.06828552f, 0.05716785f, 0.00639790f, 
    -0.00519684f, 0.00983855f, -0.07552271f, -0.01866306f, 0.03952441f, 0.03311330f, 0.04498136f, 0.13077042f, 
    -0.03140184f, -0.15556855f, -0.13669151f, -0.09547916f, -0.06876599f, -0.03967379f, -0.03648737f, -0.15269032f, 
    0.02200314f, 0.02138946f, -0.04187478f, 0.01914264f, 0.32828408f, 0.33920836f, 0.05318769f, -0.19639052f, 
    0.11325394f, -0.14969634f, 0.02251446f, -0.11334226f, 0.05035970f, 0.02442064f, 0.05437671f, 0.03776210f, 
    0.02924933f, 0.23949702f, -0.00796974f, -0.09760915f, -0.05190186f, 0.10908674f, 0.00986825f, -0.01815994f, 
    0.05958413f, 0.09471025f, -0.00660853f, 0.07671377f, -0.10921067f, 0.29399785f, 0.16688065f, -0.26299074f, 
    0.06997056f, -0.00487629f, 0.06279237f, 0.04080264f, -0.03298850f, -0.05810320f, -0.06298062f, -0.08001918f, 
    -0.08129893f, 0.12697366f, 0.13380639f, 0.21110649f, 0.06057028f, 0.08545650f, 0.03388297f, 0.03370287f, 
    -0.07106996f, -0.20793302f, -0.01490409f, -0.04978292f, -0.11339790f, -0.04517557f, 0.13825423f, 0.06012948f, 
    -0.04333106f, 0.02903628f, -0.10953303f, 0.02785460f, -0.32619563f, -0.08775599f, -0.00365258f, 0.00305375f, 
    0.09230402f, 0.32533035f, 0.19930372f, -0.03570831f, -0.07994349f, -0.14843005f, -0.08475979f, -0.00078670f, 
    -0.03316200f, -0.05355298f, 0.08691731f, -0.02008393f, -0.06668172f, 0.01415032f, -0.05570437f, -0.01143945f, 
    0.00163195f, 0.07002532f, 0.01618260f, -0.11689350f, -0.00654561f, 0.08309670f, 0.03350250f, 0.21364743f, 
    -0.08676238f, 0.07185964f, 0.18833946f, -0.05509004f, -0.08880821f, -0.05362856f, -0.02228833f, 0.13516468f, 
    -0.14787917f, 0.05207255f, 0.07457916f, 0.02907901f, 0.18265045f, -0.05734728f, -0.12254033f, -0.03482293f, 
    -0.01189409f, 0.05967106f, 0.00503941f, 0.14133725f, -0.03258666f, 0.02598586f, -0.00128734f, -0.07946820f, 
    0.14794648f, 0.18316346f, -0.06814671f, 0.23957324f, 0.01275310f, 0.03191019f, 0.16031055f, 0.06845558f, 
    0.03065549f, -0.05045044f, 0.00423334f, 0.17344764f, 0.03190684f, -0.15508045f, -0.22433186f, 0.04759667f, 
    -0.06238032f, -0.02575071f, 0.03958216f, 0.05975638f, -0.08044839f, 0.14089456f, 0.03192869f, 0.02050470f, 
    -0.15909529f, 0.17769714f, 0.12504484f, -0.14835502f, -0.11694417f, 0.12558600f, -0.08799996f, -0.04737435f, 
    0.13873740f, 0.01476593f, 0.10600634f, 0.13816617f, -0.08411291f, -0.19971871f, -0.01431215f, -0.14847484f, 
    -0.01092854f, 0.15379097f, 0.18883146f, 0.07807510f, 0.05546812f, 0.13154063f, -0.08500846f, 0.07693321f, 
    0.35011587f, 0.22916825f, 0.05078370f, -0.15455832f, 0.03297804f, 0.02239031f, 0.04393820f, 0.17516749f, 
    0.09853906f, 0.03562864f, 0.04882574f, 0.05365591f, 0.06181877f, -0.15988167f, -0.00887508f, -0.08746801f, 
    0.07955439f, 0.03151112f, 0.07380357f, 0.13078247f, 0.10326225f, 0.01547657f, 0.01293186f, 0.02039908f, 
    0.12246918f, 0.06546114f, 0.24677502f, 0.11156293f, 0.15532458f, -0.08439971f, -0.06618223f, 0.02312606f, 
    -0.02949148f, -0.02237272f, 0.06767343f, 0.00276380f, 0.08010825f, 0.06063085f, -0.02328794f, -0.01866842f, 
    -0.08171919f, 0.02137730f, -0.06409520f, -0.12506847f, 0.08384705f, 0.06217548f, 0.05721955f, 0.12078775f, 
    -0.17584345f, -0.29807773f, -0.10226110f, -0.13512112f, -0.05358354f, 0.09781665f, 0.05259032f, 0.07041406f, 
    0.03896163f, 0.00079994f, -0.03704100f, -0.00015367f, 0.10490081f, 0.01064458f, -0.01882592f, -0.00096049f, 
    0.02834427f, -0.00577097f, -0.03933037f, 0.00486059f, -0.01351945f, 0.05985228f, -0.01581647f, 0.03310088f, 
    -0.07770196f, 0.12738821f, 0.09355426f, -0.18022132f, -0.04311521f, 0.03473776f, -0.07762981f, -0.02768088f, 
    0.01672190f, 0.21677990f, 0.02163933f, 0.02780536f, 0.19548880f, 0.26756254f, 0.08640756f, -0.17074424f, 
    -0.18499012f, -0.06896409f, 0.02459071f, 0.00330506f, -0.01421519f, 0.04486249f, -0.02350925f, -0.00836326f, 
    -0.16262896f, -0.21792647f, -0.10684489f, -0.06542792f, -0.05064573f, -0.08617707f, 0.07690703f, 0.06883000f, 
    -0.15479510f, -0.05678627f, 0.00329404f, -0.08227096f, 0.12024724f, 0.03276611f, -0.08398991f, 0.02979325f, 
    -0.05499613f, -0.03652345f, 0.04383009f, -0.08152422f, 0.02736305f, 0.06468717f, 0.05302800f, 0.05221197f, 
    0.18797441f, 0.12971103f, 0.01448482f, 0.05477617f, 0.11316054f, 0.08784617f, 0.03689034f, 0.18668260f, 
    -0.04865245f, -0.03162119f, 0.03673511f, 0.09450932f, 0.16231839f, 0.07794357f, -0.20010766f, -0.07218281f, 
    0.04911500f, 0.09340871f, 0.04984898f, 0.13476305f, 0.16166224f, -0.00779638f, 0.10481868f, -0.03665470f, 
    0.19091803f, 0.07207441f, -0.07920486f, 0.02431095f, 0.11973660f, 0.16976966f, 0.00082453f, 0.01022925f, 
    0.14918749f, 0.07827932f, 0.03549124f, 0.02998050f, 0.11004874f, -0.09667200f, 0.22726265f, 0.07768732f, 
    0.15681091f, 0.03460515f, 0.18432972f, 0.14436965f, 0.06531312f, 0.00386885f, 0.08022948f, 0.08628105f, 
    0.19173500f, 0.12138889f, 0.05489756f, -0.05118585f, -0.09796917f, -0.01855449f, -0.10451598f, -0.06633708f, 
    -0.07154085f, 0.04373533f, -0.00777288f, -0.07217684f, 0.01590672f, 0.25007010f, -0.05025681f, -0.06280582f, 
    0.00086103f, -0.05089375f, 0.25729829f, 0.21541429f, 0.07725854f, 0.05264223f, -0.04132414f, 0.01295924f, 
    0.14875528f, 0.14823839f, -0.14861505f, -0.06043169f, -0.00070098f, -0.00835851f, 0.03119079f, 0.07475348f, 
    -0.02100372f, -0.06833205f, 0.09967796f, -0.00181366f, 0.14637777f, -0.05387204f, -0.16749145f, 0.00360674f, 
    0.16835135f, 0.01129292f, 0.27630121f, -0.06632444f, 0.04933012f, -0.00412225f, 0.04004237f, 0.06361103f, 
    0.01512333f, 0.07225350f, 0.15908007f, 0.13401306f, 0.11459234f, -0.00094920f, 0.02475450f, 0.11810273f, 
    -0.05573417f, -0.06502338f, -0.02892375f, -0.23417796f, 0.20371270f, 0.06438241f, 0.16752963f, 0.01029223f, 
    0.20305698f, -0.04558245f, -0.04501664f, 0.02780401f, 0.23467402f, 0.13229491f, -0.01750934f, 0.02789871f, 
    -0.02735941f, 0.05443824f, 0.11115655f, -0.12890545f, 0.15410151f, -0.02500256f, 0.09908827f, -0.06648163f, 
    -0.04583169f, -0.07760432f, -0.03622734f, -0.07698994f, 0.03532698f, 0.12629032f, -0.02316983f, -0.09565373f, 
    0.09799571f, 0.04816717f, 0.13570279f, 0.15920128f, -0.01076979f, 0.04234879f, -0.04940048f, -0.01051451f, 
    0.15935428f, -0.07738215f, -0.03160907f, -0.17264719f, 0.07318018f, 0.05167308f, -0.05923001f, 0.00850590f, 
    0.04078422f, 0.05323326f, -0.05813049f, -0.16481975f, -0.16315643f, -0.35087368f, -0.32986432f, -0.24576873f, 
    -0.09110823f, 0.03978599f, -0.00153674f, 0.10748162f, 0.04586501f, 0.02363938f, -0.06097434f, -0.21772508f, 
    -0.24215414f, -0.40179372f, -0.39673707f, -0.17427102f, -0.08720715f, 0.01844344f, 0.04143000f, 0.00678302f, 
    0.03492661f, -0.04510009f, 0.01718135f, -0.07965099f, 0.02000939f, 0.22956820f, 0.12146291f, 0.03253350f, 
    0.15285245f, 0.01842357f, 0.02215236f, -0.00483550f, -0.02356188f, -0.07728544f, 0.12863716f, -0.05997938f, 
    -0.08400404f, -0.06673798f, 0.05740152f, 0.00227076f, -0.07587565f, -0.06635635f, -0.06696700f, -0.15612832f, 
    0.07903130f, 0.13427344f, -0.03801630f, 0.04289650f, 0.08230147f, 0.09400449f, -0.10400879f, -0.06816129f, 
    -0.07963295f, -0.02185366f, 0.00746191f, -0.09857988f, 0.08127338f, -0.03953547f, -0.03207809f, -0.02721570f, 
    -0.03013224f, 0.18846086f, 0.03358618f, -0.05478142f, 0.05988843f, 0.00585027f, 0.10519757f, 0.12240729f, 
    0.06184227f, 0.03809395f, -0.08392093f, -0.13266386f, 0.10477169f, 0.28497157f, -0.02228720f, 0.01933735f, 
    -0.01529173f, 0.04118654f, 0.01426773f, -0.12832762f, 0.01821264f, -0.02165161f, 0.02430429f, -0.02258174f, 
    -0.05201946f, 0.07421869f, -0.11809654f, -0.08306734f, -0.04854383f, 0.00928090f, 0.05514442f, -0.03530661f, 
    -0.02065273f, 0.03623422f, 0.01555878f, -0.00344859f, -0.17203085f, 0.11263241f, 0.17569703f, 0.22871496f, 
    -0.07831956f, 0.04804422f, 0.05149598f, 0.11647690f, -0.11557373f, 0.10753149f, -0.00154214f, 0.21526667f, 
    0.01261145f, -0.06611225f, -0.02937662f, -0.10920449f, 0.07459652f, -0.00642743f, 0.03669288f, 0.13508381f, 
    -0.09748458f, -0.02119802f, -0.12823266f, -0.17704959f, -0.16262318f, -0.05056899f, -0.00958248f, -0.02188968f, 
    -0.04166017f, -0.05013287f, -0.07427768f, 0.05810203f, -0.20851167f, 0.07148773f, -0.03464921f, -0.07812636f, 
    -0.06264781f, 0.04710456f, 0.13536297f, 0.08521666f, -0.13977838f, -0.11912319f, -0.03513696f, -0.02032732f, 
    -0.10778488f, 0.05249108f, 0.10327044f, 0.15946907f, -0.35418907f, -0.11687452f, 0.09144006f, -0.08813738f, 
    -0.19182780f, 0.09631479f, 0.13868031f, 0.02147880f, 0.03348633f, 0.03723304f, 0.03805715f, 0.17664279f, 
    0.01364865f, -0.01581743f, 0.07159225f, -0.12952414f, 0.06620666f, 0.06709177f, 0.15126690f, 0.03946909f, 
    0.06650725f, -0.05450660f, 0.07542439f, 0.00292502f, -0.05121532f, -0.02749905f, 0.03140824f, 0.07957999f, 
    -0.09169521f, 0.02168714f, -0.12851907f, -0.11644985f, -0.05954878f, -0.03517778f, 0.12031882f, 0.13742241f, 
    0.29500499f, 0.09407627f, -0.00148989f, 0.05909178f, -0.00352299f, 0.04943618f, 0.05134964f, -0.04516227f, 
    0.07238851f, 0.09711572f, 0.12773068f, -0.02759855f, -0.10487607f, 0.16149442f, 0.05132878f, 0.13011503f, 
    -0.05673655f, -0.04439755f, -0.02975065f, 0.00860312f, -0.09952772f, -0.06599167f, 0.06419852f, -0.04174274f, 
    0.07300465f, -0.01903913f, 0.07227577f, 0.09728301f, 0.02017518f, 0.10472634f, -0.05655215f, -0.01755749f, 
    0.06528044f, 0.00825617f, -0.07818913f, -0.17726706f, 0.09977514f, 0.34316763f, 0.14565691f, 0.12033758f, 
    -0.08575323f, -0.09414731f, -0.00995630f, 0.02413695f, -0.09960991f, 0.01798612f, 0.03237085f, -0.02837933f, 
    -0.12327511f, -0.31897381f, -0.10780130f, -0.04412545f, -0.10036863f, 0.01093821f, 0.03553256f, 0.14269002f, 
    -0.10556080f, -0.03331121f, -0.01507404f, -0.09988450f, -0.02995505f, 0.07810632f, -0.13515754f, -0.13699056f, 
    -0.05762806f, 0.02905173f, 0.03365514f, 0.02343353f, -0.11219519f, -0.00995873f, 0.04481358f, 0.02982454f, 
    -0.18532287f, 0.00364757f, 0.12924185f, -0.05774860f, -0.10230075f, -0.23989429f, 0.04624006f, 0.07573425f, 
    0.02560841f, 0.11500593f, 0.07833159f, -0.07276928f, 0.27594265f, -0.01469139f, 0.33265683f, -0.08393627f, 
    0.00092760f, 0.02235009f, -0.13785492f, -0.03795800f, -0.13421036f, -0.02267171f, -0.01576028f, -0.03632335f, 
    -0.17033689f, -0.30628365f, -0.09743036f, 0.16506341f, 0.08695193f, -0.01966070f, 0.03964237f, 0.01234251f, 
    0.20269017f, -0.26635218f, 0.08418034f, 0.07972001f, 0.01766022f, 0.01694596f, 0.13528043f, -0.09687275f, 
    -0.13371885f, 0.00781570f, 0.03843705f, -0.18291712f, 0.05402328f, 0.04750461f, 0.01964053f, 0.06551968f, 
    0.48729134f, -0.16900724f, 0.14885138f, -0.00091274f, -0.06280233f, -0.00486723f, 0.03781779f, 0.01270813f, 
    0.01897538f, 0.11522549f, 0.14466758f, 0.03688746f, 0.14762196f, 0.01327924f, 0.03665338f, -0.03751509f, 
    0.04869174f, -0.09237809f, -0.08717839f, -0.05582615f, -0.01834323f, 0.03090355f, 0.04087113f, 0.05873976f, 
    -0.16328663f, -0.17965120f, 0.06217098f, 0.06222346f, -0.11994039f, -0.07708514f, -0.07542955f, -0.05781634f, 
    0.17473774f, -0.04311468f, 0.05393502f, 0.18667585f, 0.38870052f, 0.14083675f, -0.05626922f, 0.11924810f, 
    0.09997151f, -0.16725600f, 0.02434858f, 0.01576259f, 0.03378736f, -0.08320995f, 0.01835166f, -0.00853352f, 
    0.20602582f, 0.06791938f, -0.03378760f, 0.09987707f, 0.09680640f, 0.18966873f, -0.03605657f, 0.22637184f, 
    0.18675222f, 0.13558936f, -0.06624821f, 0.10311525f, -0.23645109f, -0.14560673f, -0.00707666f, -0.28425720f, 
    0.04654374f, -0.01965490f, -0.03328066f, 0.08703606f, -0.07284287f, -0.06369605f, -0.01322026f, -0.08505603f, 
    0.36264709f, 0.09969798f, 0.16773503f, 0.14828993f, -0.01471910f, 0.01500408f, -0.03476976f, 0.04344740f, 
    0.13236842f, -0.08216754f, 0.03418729f, -0.02937789f, -0.01531842f, -0.02721403f, 0.04347482f, -0.01280039f, 
    0.02528981f, 0.02781213f, -0.11314433f, 0.04218721f, -0.09313350f, 0.05755116f, -0.07563729f, 0.09525576f, 
    0.35167086f, 0.26977283f, 0.38994771f, -0.24486730f, 0.07609549f, -0.13828342f, -0.14608797f, -0.04329784f, 
    -0.10341100f, -0.11827889f, 0.04153427f, 0.01518936f, 0.04896108f, 0.02977412f, -0.03940664f, -0.03946016f, 
    0.05269578f, 0.03760942f, -0.04422074f, 0.01668961f, 0.02935715f, 0.08006357f, 0.07274702f, 0.12675038f, 
    -0.04802186f, -0.02864469f, 0.07297114f, -0.07039821f, 0.13927008f, -0.12450756f, -0.16575384f, 0.21117923f, 
    -0.17222634f, 0.02523519f, 0.02750626f, -0.01748578f, 0.07710622f, 0.07409196f, 0.10989556f, -0.12784071f, 
    -0.02039571f, 0.04206804f, 0.01265532f, 0.09613962f, 0.06426266f, -0.01552560f, 0.01235799f, 0.03171426f, 
    0.29665697f, 0.20579691f, -0.06909040f, 0.13693778f, -0.06078079f, -0.02505259f, 0.04029436f, 0.03949415f, 
    0.11231538f, 0.05046630f, 0.12838067f, 0.05727270f, -0.07777120f, -0.09555840f, 0.04904363f, -0.14079739f, 
    -0.05892991f, 0.04302778f, -0.01361769f, -0.01867937f, -0.04032320f, 0.10509441f, 0.03093131f, 0.15902369f, 
    -0.48759082f, 0.19008593f, 0.35388559f, -0.17436902f, -0.07085335f, -0.00786497f, -0.06573580f, -0.13155967f, 
    0.02788276f, -0.07260531f, 0.03006011f, 0.18422940f, -0.12683658f, -0.05048072f, 0.03368561f, -0.21050496f, 
    -0.06041646f, 0.08426034f, 0.15790170f, -0.01063358f, -0.01861764f, 0.05058447f, -0.05493980f, 0.04745053f, 
    0.11699457f, -0.08192983f, 0.04616768f, -0.12377332f, -0.05745272f, 0.02583884f, 0.05770177f, 0.18110633f, 
    0.05938911f, -0.02348854f, 0.00228163f, 0.10592604f, -0.12114937f, -0.08828847f, 0.10702473f, -0.01195134f, 
    0.07937235f, 0.04818517f, 0.03404993f, 0.06374908f, 0.04012206f, -0.06338166f, 0.06490852f, 0.01042534f, 
    0.31939712f, 0.15534379f, 0.29016411f, 0.04881274f, 0.21036795f, -0.06216199f, -0.03232480f, 0.01732090f, 
    -0.00014799f, 0.01814998f, 0.03330192f, 0.00773825f, 0.08278684f, 0.08156814f, -0.03870998f, 0.02897747f, 
    -0.06187403f, -0.03474728f, 0.03147930f, 0.00417007f, 0.13521218f, 0.10990933f, 0.09294765f, 0.16473031f, 
    0.01325248f, -0.27983454f, 0.01432074f, -0.21595514f, -0.08295629f, 0.13979039f, 0.14380565f, 0.07190860f, 
    -0.00442210f, -0.02586771f, -0.09409060f, -0.06452178f, -0.11893362f, -0.04190341f, -0.00350498f, -0.02728508f, 
    -0.07208087f, 0.05894732f, -0.03551057f, -0.14425157f, -0.05045306f, -0.02089812f, 0.00839552f, 0.06590030f, 
    -0.07064509f, -0.02303894f, 0.02639573f, -0.08334473f, -0.04185669f, -0.00510127f, -0.11748621f, 0.07787543f, 
    0.10190167f, 0.16090453f, 0.18721335f, 0.05429097f, 0.00356872f, 0.00795323f, -0.01819675f, -0.13378009f, 
    -0.19196717f, -0.13647230f, -0.00796070f, -0.19681202f, -0.03063961f, -0.02989328f, -0.03340241f, 0.03982330f, 
    -0.10518812f, -0.07696550f, 0.01947986f, -0.06880887f, -0.05964015f, 0.04985466f, -0.00230856f, 0.02783880f, 
    0.06456827f, 0.02534998f, -0.02106192f, -0.07328614f, -0.10095061f, -0.29833317f, -0.09441604f, 0.26671344f, 
    -0.00449300f, -0.04091762f, 0.04255635f, -0.00327092f, 0.13202132f, 0.05898828f, 0.19758260f, 0.22833443f, 
    -0.06781514f, -0.05483970f, 0.01869723f, 0.23524816f, 0.11167511f, 0.03921191f, 0.06393680f, -0.02947012f, 
    -0.06304530f, -0.14693779f, 0.15368553f, 0.12215742f, 0.02206692f, 0.01629521f, 0.02185241f, -0.03592595f, 
    0.10893799f, 0.11407644f, 0.08385431f, 0.09742720f, 0.11167430f, -0.09658911f, 0.15650456f, 0.15346599f, 
    0.23309244f, -0.07354939f, -0.08837764f, 0.24583234f, 0.12461854f, 0.13015398f, 0.02580337f, 0.20624039f, 
    0.28538465f, 0.09792360f, 0.20398359f, 0.14625563f, 0.00352161f, 0.05489321f, 0.03902566f, -0.01090595f, 
    0.24445790f, -0.05052580f, 0.04748384f, 0.09349404f, -0.01263183f, 0.00390829f, 0.07814100f, 0.18276308f, 
    0.14029424f, 0.11053562f, -0.00062368f, -0.04286547f, -0.04514035f, -0.07037803f, -0.00338987f, -0.03090546f, 
    0.01626974f, 0.06568302f, -0.00062524f, 0.12382358f, 0.02941667f, 0.17991853f, -0.07929073f, -0.06115043f, 
    0.03513452f, 0.15814535f, 0.13737740f, 0.15949795f, 0.20563623f, 0.13138224f, 0.04816830f, -0.01972558f, 
    -0.01677777f, 0.10718239f, -0.02346353f, -0.12582736f, -0.03865908f, -0.01331198f, 0.08467797f, 0.10882083f, 
    0.05513525f, -0.02292054f, 0.11162663f, -0.01714974f, -0.06874888f, -0.09664652f, -0.00273902f, 0.13850588f, 
    0.06546734f, 0.02788072f, 0.22171047f, -0.00776105f, 0.07766265f, -0.09500124f, 0.00929428f, 0.08127625f, 
    0.10238457f, 0.04039684f, 0.07308668f, 0.14699219f, 0.03672460f, -0.00731130f, 0.00446315f, 0.06660280f, 
    -0.05444190f, -0.03022904f, -0.02586394f, -0.35176447f, -0.05636660f, -0.10682202f, 0.15622696f, 0.06823286f, 
    0.09372561f, -0.13920391f, 0.02935453f, 0.00772053f, 0.16677341f, 0.10392413f, 0.04176055f, -0.00129515f, 
    -0.33818045f, -0.15248094f, 0.00041078f, -0.20300940f, 0.16487546f, -0.06683574f, 0.00135417f, -0.12301193f, 
    0.00282708f, -0.14087830f, 0.01462120f, -0.11161273f, -0.09438012f, 0.15993914f, 0.13699482f, -0.03876668f, 
    0.06931386f, 0.08827638f, 0.12075441f, 0.09716430f, -0.05219669f, -0.01775518f, -0.02728028f, -0.09093826f, 
    -0.07516331f, -0.01164524f, -0.07987093f, 0.03244488f, 0.01702101f, -0.03171363f, -0.08340087f, 0.02283295f, 
    0.01797299f, -0.03651617f, -0.05075658f, -0.15943396f, -0.41849080f, -0.01652466f, -0.16818748f, -0.07539533f, 
    -0.07671224f, 0.03246792f, 0.05547855f, 0.01662252f, 0.04970396f, 0.03932622f, 0.06354842f, -0.12151890f, 
    -0.19982579f, -0.18385658f, -0.13405497f, -0.12114556f, -0.14588733f, 0.01489264f, 0.05807734f, -0.02960009f, 
    0.04216921f, 0.00488429f, 0.07530680f, -0.04249768f, -0.19362935f, 0.01382450f, 0.07659113f, 0.16674335f, 
    0.31598398f, -0.06502125f, 0.04761250f, 0.04919596f, 0.14492564f, -0.05738114f, 0.05930482f, 0.04905071f, 
    -0.05321962f, -0.03321419f, 0.03587219f, 0.11946005f, -0.06122132f, 0.01398227f, -0.03977484f, -0.06122661f, 
    0.01918520f, -0.01352797f, -0.01196570f, 0.16287945f, 0.02991278f, -0.02904955f, -0.12034484f, 0.15221074f, 
    0.00529312f, 0.00317520f, -0.03118007f, -0.05400781f, 0.35273796f, 0.08703802f, 0.09710775f, 0.28053957f, 
    0.00860247f, 0.01579062f, 0.08523068f, -0.11283865f, 0.00573031f, 0.08045627f, 0.07409595f, 0.09846023f, 
    0.02192497f, 0.11018988f, 0.00695514f, -0.19984379f, 0.18075965f, 0.09824114f, -0.05740425f, -0.00541588f, 
    -0.09129576f, -0.03847937f, 0.00222925f, -0.02145541f, -0.06707767f, 0.03194276f, -0.03071605f, -0.04391357f, 
    -0.31573030f, -0.14955047f, 0.34473640f, -0.05117783f, -0.00927052f, 0.04274056f, -0.02223804f, 0.21512797f, 
    0.00967746f, -0.00855489f, 0.05915033f, 0.00033764f, -0.05259750f, 0.15400745f, 0.05852799f, 0.00795193f, 
    0.12966633f, 0.14921898f, 0.02684655f, 0.21318217f, 0.12507445f, 0.19682950f, -0.15963361f, 0.28895611f, 
    -0.19013560f, -0.01408318f, 0.04653856f, -0.16723447f, -0.01233576f, -0.06423185f, 0.05680394f, 0.06401787f, 
    -0.09796708f, -0.11611621f, -0.09679827f, -0.20186205f, -0.07108833f, -0.01813899f, -0.02326939f, -0.15932918f, 
    -0.04821642f, 0.00942801f, -0.11208526f, 0.00406956f, -0.22017525f, 0.04502406f, -0.09423817f, -0.07670180f, 
    0.00336548f, 0.04903651f, 0.10171500f, 0.01571283f, -0.06552024f, -0.04292055f, -0.02004893f, -0.07244085f, 
    -0.11156628f, 0.10354123f, 0.11911609f, 0.14062747f, -0.07018267f, -0.03189892f, 0.09009605f, -0.14508787f, 
    0.09324799f, 0.10417026f, -0.00505249f, 0.10982372f, 0.11593381f, 0.08146436f, -0.00035941f, 0.08838262f, 
    -0.08984772f, -0.16172232f, 0.09342948f, -0.03241065f, 0.03182796f, 0.01278014f, 0.13198192f, -0.07152197f, 
    -0.00963619f, -0.08010050f, -0.05337034f, -0.02996479f, -0.00941424f, -0.00273347f, -0.01403160f, 0.13570739f, 
    0.11381352f, 0.10060306f, -0.03212738f, -0.04236660f, -0.03329514f, -0.00746958f, -0.00260874f, 0.09888586f, 
    0.17653516f, 0.00379014f, -0.24023175f, 0.12332100f, -0.15693948f, 0.02559694f, 0.08200467f, 0.12637298f, 
    0.18370086f, 0.21356867f, 0.08264024f, 0.04064129f, -0.02587270f, 0.08687225f, 0.04761553f, 0.06433929f, 
    -0.06532101f, -0.01152797f, -0.05048094f, 0.08571423f, -0.04007283f, 0.04806456f, 0.09968870f, -0.03504582f, 
    0.18502235f, -0.16345309f, 0.06571736f, 0.01612834f, -0.05008054f, 0.06907281f, -0.04642747f, 0.01927990f, 
    -0.15954025f, 0.05987622f, -0.01447670f, -0.24460463f, 0.17298789f, 0.27013427f, 0.14911354f, -0.00060133f, 
    -0.02650349f, 0.02021793f, -0.08546463f, 0.01491004f, -0.02403042f, 0.01332752f, -0.01889162f, -0.01834797f, 
    -0.02911321f, -0.08406164f, -0.06302388f, -0.17531417f, -0.06865148f, 0.04977391f, 0.05731893f, 0.05789810f, 
    -0.03100864f, 0.03718106f, 0.04954717f, -0.06123686f, -0.21664461f, -0.02264311f, -0.01006465f, -0.12273011f, 
    -0.04399634f, 0.01933942f, 0.00113807f, -0.26274160f, -0.08335892f, -0.12793140f, -0.04750332f, 0.01306697f, 
    -0.01656167f, 0.03007111f, -0.01053755f, 0.02214765f, -0.00335996f, -0.05151942f, -0.00213932f, 0.03789591f, 
    0.01017088f, -0.06383581f, -0.04656218f, 0.07102088f, -0.13151456f, -0.13463697f, 0.46492386f, 0.01924583f, 
    -0.05100136f, -0.03210349f, -0.22852512f, 0.03205381f, 0.03767933f, 0.08749492f, 0.01701133f, 0.01897969f, 
    0.18510343f, 0.37565243f, 0.22450444f, -0.06263317f, 0.29260808f, 0.16233808f, -0.14462650f, 0.10879759f, 
    -0.23127244f, 0.02343462f, 0.09082700f, 0.04955030f, -0.08940044f, -0.15050022f, -0.12490319f, -0.02011610f, 
    -0.02959381f, 0.05410518f, -0.00283291f, -0.11870754f, -0.00879975f, -0.02522128f, -0.19432908f, -0.08325171f, 
    -0.29208905f, 0.48516801f, -0.07907274f, 0.30376500f, 0.06074873f, 0.09137641f, 0.00411227f, 0.11942336f, 
    0.07765847f, 0.06833608f, 0.15230681f, -0.12571724f, 0.04377402f, 0.06744858f, 0.14622572f, -0.10660581f, 
    -0.04481884f, -0.03700780f, -0.13696279f, -0.14653656f, -0.08155023f, 0.01489229f, 0.04050947f, 0.14341110f, 
    -0.05064821f, 0.09255255f, -0.08058282f, -0.16693968f, 0.08587849f, -0.01572974f, -0.02501496f, -0.01379909f, 
    -0.06565943f, -0.03645044f, 0.00277424f, -0.03214845f, -0.02239466f, 0.28656852f, -0.23384598f, 0.05625086f, 
    0.00379445f, -0.08097519f, 0.04147196f, 0.04415448f, -0.02282210f, -0.06371930f, -0.04014996f, -0.03347489f, 
    -0.00372288f, 0.08306888f, 0.13360101f, 0.08583143f, 0.04638974f, -0.01083287f, -0.02806734f, 0.06547145f, 
    0.01286115f, 0.06753888f, 0.05805241f, -0.01127847f, -0.17056371f, 0.30010083f, 0.03132167f, -0.10853557f, 
    -0.03875379f, -0.03881146f, -0.08332711f, 0.07481360f, -0.09868522f, -0.10092203f, -0.03930399f, -0.02079240f, 
    -0.14875019f, 0.26011428f, -0.04699104f, 0.26543429f, -0.01980514f, 0.16161016f, -0.04492167f, 0.08394164f, 
    -0.11453675f, 0.04622610f, 0.01403688f, 0.07413480f, 0.01369567f, -0.05036692f, 0.21597575f, -0.03883531f, 
    -0.15409769f, 0.01377637f, -0.09877970f, 0.10573439f, -0.01530241f, -0.06439716f, -0.02389692f, 0.02541736f, 
    -0.32427847f, -0.01008502f, 0.30436757f, -0.11523657f, -0.01137744f, -0.04661755f, -0.06158202f, -0.06719475f, 
    0.04796514f, -0.01842679f, 0.01720159f, 0.08519544f, -0.00919548f, -0.06672662f, -0.07757480f, -0.03609075f, 
    -0.09158774f, -0.00696643f, -0.08497640f, -0.16138500f, -0.01400263f, -0.01045518f, 0.14303978f, 0.11903084f, 
    0.16150384f, -0.16350937f, 0.44943157f, -0.14852823f, -0.05705368f, -0.01235904f, 0.05701331f, 0.07061336f, 
    -0.15972495f, -0.06477379f, 0.08333740f, 0.15687269f, 0.00908964f, -0.05467372f, -0.03890753f, 0.12273285f, 
    0.08814175f, 0.04096200f, -0.00368002f, 0.05066139f, -0.02782051f, -0.04486828f, -0.09139936f, -0.06612261f, 
    -0.38679090f, 0.46756849f, 0.00932307f, 0.20247197f, -0.02139091f, 0.01659757f, 0.12936470f, 0.02299268f, 
    0.08026602f, 0.01785698f, -0.00273085f, 0.07438047f, -0.25976670f, -0.11432878f, -0.20453790f, 0.06723396f, 
    0.08072730f, 0.12349357f, 0.00177927f, 0.03336145f, 0.02947827f, 0.03962318f, -0.00121804f, -0.04941843f, 
    0.27991825f, 0.10045537f, -0.03348535f, -0.03448146f, -0.01257883f, -0.03182816f, 0.01461495f, 0.01272644f, 
    0.00029651f, -0.08661745f, 0.12786098f, 0.25014848f, 0.05241520f, -0.15247867f, 0.04410163f, 0.11186730f, 
    -0.01132522f, 0.16834514f, -0.02535386f, -0.01667027f, 0.08467449f, 0.14622226f, -0.17704530f, 0.00676136f, 
    -0.02560731f, 0.12205967f, -0.13473926f, -0.02736091f, 0.05084417f, 0.04284514f, 0.08190017f, 0.00442521f, 
    -0.13427696f, -0.04603127f, 0.01928995f, -0.01274425f, 0.02561954f, -0.12711693f, -0.00149141f, -0.02816983f, 
    0.04278065f, 0.01034307f, 0.03679740f, 0.10404496f, -0.08765082f, 0.02839608f, -0.08416677f, -0.01936216f, 
    0.00368779f, -0.00471926f, 0.31140754f, -0.15453821f, 0.04209901f, -0.03050147f, -0.01924467f, -0.04605645f, 
    -0.03672620f, 0.02328317f, -0.03082843f, 0.02377636f, -0.05797311f, 0.04274415f, -0.22969274f, -0.12653661f, 
    -0.12032692f, -0.12187071f, -0.12828115f, -0.10322507f, -0.07496790f, 0.02127930f, 0.02237495f, -0.01216329f, 
    -0.28448886f, 0.02594831f, -0.09680119f, 0.05362410f, -0.01593589f, 0.00060220f, 0.05262014f, -0.01180890f, 
    0.06870463f, 0.04551522f, 0.00781799f, -0.02716811f, -0.15125211f, -0.12877934f, -0.16097896f, 0.02691416f, 
    0.15735258f, 0.15100475f, -0.01951785f, -0.01138107f, -0.01129453f, -0.03554102f, -0.04951463f, -0.06113572f, 
    0.35206819f, -0.07713640f, 0.16715486f, -0.11781750f, -0.11171197f, -0.01803709f, 0.05655392f, -0.00805258f, 
    0.01651455f, 0.04893304f, 0.03626306f, 0.15459357f, -0.12867087f, -0.00272620f, -0.00595186f, 0.09634636f, 
    -0.08019070f, 0.05512426f, -0.07574449f, -0.03256012f, 0.00229815f, 0.09511306f, 0.05157536f, 0.02409868f, 
    -0.13058704f, -0.17844437f, -0.23451737f, 0.02339789f, 0.06626507f, 0.02262581f, 0.10691489f, -0.06654556f, 
    -0.07456280f, -0.11471517f, 0.05997670f, -0.04870279f, 0.22911480f, 0.32159856f, -0.14692892f, -0.29688740f, 
    -0.04544036f, 0.03590205f, 0.05769294f, 0.14617185f, -0.13333313f, 0.02561187f, 0.05099660f, -0.05703986f, 
    0.00941989f, 0.05572340f, 0.20843177f, 0.04309886f, 0.03516343f, 0.15827979f, -0.00160090f, 0.18557756f, 
    -0.10285091f, 0.14643712f, -0.02401783f, 0.08727989f, -0.02443974f, 0.15696947f, 0.05433995f, 0.09398825f, 
    0.14140379f, 0.00886592f, -0.05780604f, 0.11164697f, -0.06519287f, 0.08490022f, 0.06793774f, -0.09969563f, 
    0.04784132f, 0.10610217f, -0.17207073f, -0.13667905f, 0.01876551f, 0.16592032f, 0.02317354f, 0.06237655f, 
    0.06878352f, 0.04922357f, 0.10726921f, 0.02327859f, 0.32790178f, -0.07036293f, 0.30179375f, -0.11359662f, 
    0.06783628f, -0.03695443f, 0.12277596f, 0.09164460f, 0.08737979f, 0.03945503f, 0.09452851f, -0.01072778f, 
    0.04588351f, 0.11833028f, -0.04441620f, -0.13006306f, -0.24755810f, -0.20701005f, -0.06997152f, -0.02634277f, 
    -0.09132022f, -0.02776067f, -0.13908221f, -0.20786670f, -0.01910271f, 0.25582826f, -0.00491419f, 0.05769609f, 
    0.11901054f, -0.03956959f, 0.22794154f, 0.14113408f, -0.03153371f, 0.11625694f, 0.03556005f, 0.01481245f, 
    -0.16124646f, 0.24594891f, -0.00479729f, 0.00388761f, -0.01650523f, 0.09212041f, 0.04332193f, 0.03623191f, 
    -0.03708303f, 0.09589081f, 0.07984835f, -0.03575282f, 0.11429304f, 0.02324047f, -0.13874093f, 0.01571681f, 
    0.03743796f, 0.08862197f, 0.18303698f, 0.08562390f, 0.04350416f, 0.01059595f, 0.02514346f, -0.02103436f, 
    -0.01318056f, -0.03655405f, 0.24054471f, 0.11805455f, -0.01317579f, 0.00773336f, -0.05796869f, 0.03945562f, 
    -0.10001343f, 0.02779333f, -0.04097077f, -0.05958199f, 0.05000205f, -0.04011597f, -0.06748565f, -0.06997342f, 
    0.01091682f, 0.03512644f, 0.05383774f, 0.01049502f, -0.09252042f, -0.04244325f, -0.04328822f, -0.10690636f, 
    -0.10861824f, 0.22304355f, -0.02778851f, -0.09125180f, -0.13843074f, -0.06391612f, -0.03358917f, -0.00599536f, 
    -0.05108796f, 0.05239798f, 0.08190797f, 0.01078815f, 0.08561741f, -0.06253161f, 0.04217654f, 0.06078724f, 
    0.08021109f, -0.02067009f, 0.03556831f, 0.07197575f, -0.00746219f, 0.00442068f, -0.00389403f, -0.01969038f, 
    0.43245816f, 0.04156753f, 0.11142413f, -0.01816097f, 0.12017659f, 0.11914916f, 0.10742947f, 0.07931132f, 
    -0.10163815f, 0.09723297f, 0.00868831f, -0.09528197f, 0.34524584f, -0.15278816f, 0.09722956f, 0.09378728f, 
    0.08912955f, 0.09802092f, 0.10223275f, 0.15066579f, -0.07807589f, 0.09401228f, -0.03246039f, -0.05464735f, 
    -0.37414914f, -0.08536751f, -0.02791049f, 0.14474058f, 0.05720709f, 0.07684954f, 0.09847665f, 0.01933379f, 
    0.07607204f, 0.03185799f, 0.01321374f, -0.08761296f, 0.07013699f, 0.21490696f, 0.02994777f, 0.02748148f, 
    0.02468095f, 0.07521011f, 0.00509547f, 0.02053459f, -0.17543046f, 0.11717129f, 0.00159071f, 0.07577804f, 
    0.11015489f, -0.01859809f, 0.10894960f, 0.02540996f, -0.09559638f, 0.04838600f, -0.03719783f, -0.08574096f, 
    0.02971723f, 0.05835349f, -0.06408390f, 0.11777893f, 0.22184715f, 0.14033632f, -0.14477991f, -0.35171270f, 
    -0.10040762f, -0.03998552f, 0.13346735f, -0.05155948f, 0.06362593f, -0.08567643f, -0.02631416f, -0.09186297f, 
    -0.05702100f, -0.03909963f, -0.05811992f, 0.07671908f, -0.02366130f, -0.01748659f, 0.00912392f, -0.00274174f, 
    -0.02412782f, 0.00576425f, -0.08242854f, -0.02477125f, -0.07702357f, 0.66298681f, -0.20423612f, 0.18907502f, 
    -0.10899255f, -0.03162091f, 0.04050745f, -0.02822907f, 0.00045276f, -0.03330566f, 0.10544305f, -0.00307958f, 
    0.09246691f, -0.05332437f, -0.07376157f, 0.02522138f, 0.07462979f, 0.05325003f, 0.16607502f, -0.03553981f, 
    0.00434061f, 0.05555255f, -0.02091420f, 0.01787316f, 0.02170448f, -0.00613770f, 0.19771676f, 0.24922797f, 
    -0.01867699f, 0.04192562f, -0.06185975f, 0.08569269f, -0.07463799f, 0.02621573f, 0.07827773f, 0.25001124f, 
    0.05609237f, -0.02217735f, -0.09252685f, -0.13649179f, 0.01612516f, 0.00077250f, 0.06960777f, 0.04114956f, 
    -0.15278986f, 0.02127317f, -0.07549702f, -0.04223097f, -0.21434370f, -0.39075980f, 0.11522998f, -0.04659287f, 
    0.06547934f, -0.02695652f, -0.02353204f, 0.02016107f, 0.00596903f, 0.11802626f, 0.00271212f, 0.06522544f, 
    0.01841186f, 0.06880249f, 0.06683450f, 0.01096869f, -0.06468167f, -0.14114580f, -0.04568227f, -0.02498494f, 
    -0.05652644f, -0.03112665f, 0.05947475f, 0.02508813f, -0.03951306f, -0.08879667f, 0.04794378f, 0.08459638f, 
    -0.09448913f, -0.01229008f, -0.12679636f, -0.06742658f, 0.11162577f, 0.02321745f, 0.10785893f, 0.10006521f, 
    -0.04314011f, -0.13584667f, -0.13079061f, 0.00295263f, 0.16089040f, 0.07485574f, -0.04325166f, -0.03929903f, 
    -0.02607343f, 0.02349763f, -0.02388005f, -0.04101515f, -0.06839418f, -0.02940725f, -0.15025140f, 0.14107232f, 
    -0.15989450f, -0.07545018f, -0.04400112f, -0.10564482f, -0.10434224f, 0.09400915f, 0.12293416f, 0.16189161f, 
    0.20327750f, 0.40912870f, -0.20020078f, 0.14197755f, -0.03503143f, -0.08978093f, 0.06491047f, 0.01850234f, 
    -0.09949733f, 0.03408653f, 0.15743382f, -0.10727730f, 0.03779761f, 0.08868821f, 0.10303280f, -0.04478250f, 
    -0.07114977f, -0.08117767f, -0.04661867f, 0.02506088f, -0.09416550f, 0.03675814f, 0.16169000f, -0.01539776f, 
    -0.03243196f, 0.11611626f, 0.02301211f, 0.16923302f, -0.06312438f, -0.00833139f, -0.06593605f, -0.05948808f, 
    0.16219597f, 0.08264218f, -0.10280745f, -0.24051237f, 0.01210127f, 0.26223531f, 0.13347313f, -0.04971579f, 
    -0.12582010f, -0.15242451f, -0.10721393f, 0.02476552f, -0.12242835f, -0.04670884f, -0.05990538f, -0.03823887f, 
    -0.27073050f, -0.06526667f, -0.18362267f, 0.20915502f, -0.04855280f, 0.11018334f, 0.12141123f, 0.08092885f, 
    0.01568589f, -0.03203674f, 0.01271369f, 0.01874071f, -0.14554994f, -0.26948267f, -0.25914279f, 0.04052911f, 
    0.14656669f, 0.07267401f, -0.07555567f, -0.03070089f, 0.01198586f, -0.02853344f, -0.02737162f, -0.00244608f, 
    0.00095474f, -0.13197239f, -0.09021891f, -0.14401428f, 0.13798533f, 0.03439289f, -0.03330990f, 0.10820279f, 
    -0.06758807f, -0.04252531f, 0.05530918f, -0.06273599f, 0.06636206f, 0.31275180f, 0.14401071f, 0.17788032f, 
    -0.16375256f, -0.13565357f, 0.03667469f, 0.09690505f, 0.04766158f, 0.00974377f, 0.05233999f, 0.01771510f, 
    0.23922373f, 0.32000458f, 0.05218678f, -0.19145919f, -0.17143708f, 0.12701878f, -0.07401630f, 0.04150796f, 
    0.00554491f, -0.10643419f, -0.16167775f, -0.09840499f, 0.07010486f, -0.08087238f, -0.07897548f, -0.05233744f, 
    0.07685158f, -0.05056275f, 0.05894968f, 0.18723828f, -0.00231195f, 0.05490950f, 0.06759219f, -0.00787434f, 
    0.54429483f, -0.16698830f, 0.13864207f, -0.12258410f, 0.06090371f, -0.05685139f, -0.01100387f, -0.02790811f, 
    0.09603921f, 0.17725468f, 0.16868912f, -0.02208416f, 0.08458652f, 0.16904575f, 0.05143935f, 0.13644363f, 
    -0.02552450f, -0.06700440f, -0.03424840f, -0.05012653f, -0.10820433f, -0.09265885f, -0.05299137f, -0.06996296f, 
    0.22941507f, 0.04148108f, 0.17850484f, 0.01204085f, -0.05779595f, 0.03067991f, -0.02698038f, -0.00348607f, 
    0.10799649f, -0.09035375f, -0.06907807f, -0.01192287f, -0.21060829f, 0.02952622f, 0.17890731f, -0.06537514f, 
    0.04128040f, 0.12693036f, 0.08060744f, -0.02699827f, -0.08778536f, -0.00773445f, -0.06896112f, 0.11959571f, 
    -0.06668199f, -0.05557099f, 0.00815944f, -0.02099233f, -0.15931100f, -0.04160538f, 0.04037030f, 0.06130803f, 
    0.02691552f, 0.08585665f, -0.00223189f, 0.12048548f, 0.16029784f, -0.00659685f, 0.17612912f, 0.11125015f, 
    -0.03630604f, 0.04023630f, -0.01206971f, 0.04668445f, -0.02166038f, 0.01110385f, -0.00508163f, 0.01821144f, 
    -0.08480949f, -0.14847733f, 0.40025243f, -0.13102026f, -0.00729035f, 0.02645468f, -0.05754773f, -0.06401519f, 
    0.04454632f, -0.07230466f, 0.00836577f, -0.08467089f, -0.06999781f, 0.06910130f, 0.05390190f, -0.00803911f, 
    0.02871954f, 0.01982791f, 0.04915401f, 0.04332915f, 0.20027141f, 0.04142977f, 0.12818918f, 0.20018588f, 
    0.18712023f, 0.36257708f, 0.06325231f, 0.19657673f, -0.12800072f, -0.03467036f, -0.12287923f, -0.01449087f, 
    -0.02749333f, -0.00925279f, -0.01544714f, -0.05115391f, 0.04301848f, 0.04390073f, 0.07030904f, -0.02083025f, 
    0.09608909f, 0.06214057f, -0.01851222f, -0.05013977f, -0.07646392f, -0.03897182f, 0.04134155f, 0.00020087f, 
    -0.07426935f, 0.18853283f, 0.09470998f, -0.01607818f, 0.08987056f, -0.11725484f, -0.01600244f, 0.01839259f, 
    0.02528316f, -0.14003183f, 0.01623043f, -0.01942212f, -0.06893136f, -0.31669089f, -0.17555720f, -0.22770721f, 
    -0.12357448f, -0.09154265f, -0.03035716f, 0.01007846f, 0.00185418f, 0.12301688f, 0.02941750f, -0.01651983f, 
    0.26568767f, -0.06872429f, 0.15625085f, -0.02454432f, 0.01332348f, 0.14952494f, -0.09367097f, 0.19323465f, 
    0.11862633f, 0.01971615f, 0.04573811f, 0.06554652f, 0.19442420f, -0.11171695f, -0.15019357f, -0.12568395f, 
    -0.10447998f, -0.07681467f, 0.08933998f, 0.20381260f, -0.00721216f, 0.03576451f, 0.07619834f, -0.03661706f, 
    -0.13358764f, -0.18767285f, -0.12153931f, -0.07165430f, 0.16446055f, 0.01401846f, 0.03368455f, -0.11810929f, 
    0.05663471f, -0.05807015f, -0.09633698f, -0.08482471f, -0.12093133f, -0.25692233f, -0.30728918f, -0.29568139f, 
    -0.14369279f, 0.05126305f, 0.06966293f, 0.14003080f, 0.09914409f, 0.10975161f, 0.03825185f, -0.07755192f, 
    -0.04115181f, -0.29914877f, -0.13403727f, -0.32934400f, 0.07506691f, -0.04332335f, -0.18180221f, 0.19746289f, 
    -0.06000180f, -0.05621085f, -0.01472786f, 0.05193584f, -0.01131329f, -0.28768736f, -0.21199252f, 0.20559700f, 
    0.01768847f, 0.07064991f, 0.03616052f, 0.02691053f, 0.04329447f, 0.09401628f, -0.02027733f, 0.02015908f, 
    0.10172931f, 0.24542117f, 0.02317044f, 0.16056156f, -0.15652101f, -0.00666450f, -0.01308588f, -0.00438906f, 
    0.01042078f, -0.02205177f, -0.03224374f, 0.00657085f, 0.13110270f, 0.07699391f, 0.11618634f, 0.07720657f, 
    -0.00470864f, 0.01369454f, -0.04033748f, -0.09671611f, -0.01147331f, 0.00744400f, -0.00528897f, 0.01100941f, 
    0.11540701f, -0.01688230f, -0.03018798f, -0.03462860f, 0.01128069f, -0.04469297f, 0.11070809f, -0.10690451f, 
    0.08795186f, 0.17596161f, -0.02376613f, -0.00029185f, -0.07366889f, -0.09984919f, 0.16898732f, 0.08715713f, 
    0.08594906f, -0.06915661f, 0.11217286f, 0.18379128f, 0.04002998f, 0.09235674f, 0.02384203f, 0.00537143f, 
    0.16216671f, 0.13644341f, 0.14710137f, 0.10642115f, -0.01750049f, 0.07402425f, -0.03179735f, -0.02163741f, 
    -0.07281630f, -0.25513464f, 0.10287512f, 0.00849365f, -0.19318771f, 0.15562417f, -0.06520370f, -0.11240488f, 
    0.00873587f, -0.04631364f, 0.26111838f, 0.12313746f, -0.06676351f, -0.00508902f, -0.03157650f, -0.03992410f, 
    -0.08336493f, -0.01571786f, -0.02127515f, -0.11420794f, 0.09340089f, 0.01209402f, 0.02972066f, 0.12844330f, 
    -0.07873990f, -0.02466575f, -0.01110777f, -0.03970595f, 0.23161434f, 0.17466974f, 0.10543524f, 0.17436041f, 
    -0.07300811f, -0.03046725f, -0.00414882f, -0.03973101f, -0.02144784f, 0.13967067f, 0.01856127f, -0.04992985f, 
    -0.29147363f, -0.02422035f, -0.58406872f, -0.38058105f, -0.26085803f, -0.06031097f, -0.15787432f, 0.15061834f, 
    -0.10832408f, -0.03153922f, -0.02380362f, -0.07811639f, -0.14142746f, -0.34781545f, -0.48354968f, -0.39930066f, 
    -0.16317825f, -0.03122956f, -0.13086486f, 0.09253712f, -0.00161498f, 0.00720482f, 0.07904529f, 0.00697570f, 
    -0.03400742f, 0.12437253f, 0.33216104f, -0.10550252f, -0.01598578f, 0.08753810f, -0.03628423f, -0.13812777f, 
    -0.11160671f, -0.00188466f, 0.07068717f, 0.10288696f, -0.17284000f, 0.31437466f, -0.16576417f, 0.20463853f, 
    -0.05721206f, 0.03147835f, 0.14754732f, -0.01281376f, -0.03706709f, 0.01542557f, 0.05678697f, -0.01357774f, 
    0.09804250f, 0.07032706f, 0.14266412f, 0.04467797f, -0.03208968f, -0.03702715f, -0.00534888f, -0.05959627f, 
    0.03732608f, 0.06272656f, 0.03462460f, -0.00580167f, 0.31359491f, -0.06937395f, 0.04656834f, -0.13505031f, 
    0.00582755f, 0.12606607f, -0.06788005f, 0.19488956f, 0.05402160f, 0.03035646f, 0.12015137f, -0.07666975f, 
    0.23068717f, -0.16448404f, -0.00839602f, 0.04785722f, -0.13953781f, 0.10388730f, -0.08889282f, 0.20047046f, 
    0.04193405f, -0.09411070f, 0.10654671f, 0.01897609f, -0.00091676f, -0.24313848f, -0.51683515f, -0.17845887f, 
    0.02570015f, -0.00781160f, -0.04356391f, -0.10084322f, -0.07264142f, -0.06742949f, -0.07974859f, 0.02595183f, 
    0.04254380f, -0.05547922f, 0.16145360f, 0.01436820f, -0.08863093f, 0.01174480f, 0.08727694f, -0.03994360f, 
    -0.14014433f, -0.11230493f, -0.07100876f, -0.05447532f, -0.07665749f, 0.07880071f, -0.20083772f, 0.21525067f, 
    0.12114348f, 0.02258796f, 0.01787709f, 0.08338973f, -0.00662633f, 0.07605649f, -0.02894532f, -0.02257344f, 
    0.18981431f, -0.01125331f, 0.07633614f, 0.08891021f, 0.01197512f, 0.00464031f, 0.23415284f, 0.09506961f, 
    0.03566419f, 0.19466433f, -0.04766348f, 0.00921772f, 0.02962079f, -0.11480562f, -0.41927120f, -0.20925927f, 
    0.04466652f, -0.11411554f, -0.02732128f, 0.14731555f, -0.12161997f, -0.06410848f, -0.01276621f, -0.01143663f, 
    -0.12595040f, -0.02359934f, -0.09505712f, -0.02070159f, -0.04109932f, -0.23823892f, -0.11839506f, -0.16320257f, 
    -0.10929562f, -0.03358233f, -0.08048691f, 0.08703824f, 0.22082174f, -0.15362018f, -0.20609725f, -0.19111930f, 
    -0.07338478f, -0.10017040f, -0.07759973f, -0.01774507f, 0.03943679f, -0.00487944f, 0.02405920f, 0.03236606f, 
    0.40091208f, -0.29110634f, -0.21854401f, -0.38749504f, -0.07628164f, -0.12231316f, -0.07893201f, -0.03791255f, 
    0.07143247f, 0.01926985f, 0.13954608f, 0.01472664f, -0.14357725f, 0.00294958f, -0.25712693f, -0.44186914f, 
    -0.06882840f, 0.04197440f, -0.11058642f, -0.01564620f, -0.12148582f, -0.14274499f, -0.08855238f, -0.00996707f, 
    -0.07759314f, 0.05150914f, 0.07727110f, -0.06035444f, -0.00129723f, -0.02985097f, -0.01271288f, -0.00773985f, 
    -0.05019088f, -0.00064589f, -0.02372278f, 0.02453460f, 0.20297915f, 0.12992348f, 0.11112097f, 0.04322864f, 
    0.00773729f, 0.07642134f, -0.06421924f, -0.05886978f, -0.02787588f, 0.05999882f, 0.01278777f, 0.11935244f, 
    0.00193561f, -0.17138018f, 0.17338359f, 0.03922873f, -0.03821159f, 0.08696976f, 0.08528608f, 0.02301019f, 
    0.01635170f, -0.15432951f, 0.02253406f, -0.03805194f, 0.18734926f, 0.05045199f, 0.18476842f, -0.07493351f, 
    -0.02639617f, 0.00070303f, 0.05968597f, 0.00030923f, -0.00936964f, -0.05886099f, -0.01270422f, -0.03918118f, 
    0.38451692f, -0.30017436f, -0.20469552f, -0.14688444f, -0.07482402f, -0.07896014f, -0.13939284f, -0.08254123f, 
    -0.02492384f, -0.03526901f, 0.04925385f, -0.13750646f, -0.03476036f, 0.00758269f, 0.04454439f, -0.07738459f, 
    0.03494699f, -0.05577664f, 0.10395179f, 0.14025304f, 0.15051422f, 0.05867570f, -0.02937588f, -0.03750084f, 
    0.09699292f, -0.33876404f, 0.05965471f, 0.21376641f, -0.02698470f, -0.05790619f, 0.01435350f, -0.03871972f, 
    0.02375628f, -0.09295338f, -0.14373124f, 0.06084133f, -0.08415610f, 0.06604721f, -0.03962520f, 0.00810347f, 
    0.10798641f, -0.10920085f, 0.01198194f, 0.17041001f, 0.04122538f, 0.01304284f, 0.06260787f, -0.00442408f, 
    0.20866133f, 0.09840238f, 0.14760308f, 0.13582991f, -0.02541758f, -0.03234272f, 0.00457928f, 0.00996748f, 
    0.00073910f, -0.02351375f, -0.07465739f, 0.03706191f, 0.07975423f, 0.07332022f, 0.02320181f, 0.05999138f, 
    -0.10669980f, 0.09547562f, 0.00237738f, 0.03207116f, 0.06240855f, -0.00321099f, -0.06563675f, -0.04608405f, 
    -0.11713008f, -0.09531550f, -0.11508285f, -0.07720438f, 0.13946852f, 0.16581492f, 0.05995814f, 0.11804353f, 
    -0.08091942f, -0.01605147f, 0.01587407f, -0.04995359f, 0.04707936f, 0.05431182f, 0.06868266f, -0.06059429f, 
    0.12140340f, 0.06348301f, -0.02086787f, -0.05656645f, -0.02898566f, -0.00723485f, -0.10761445f, -0.02012802f, 
    -0.04944918f, -0.00690961f, 0.22777164f, 0.03702002f, -0.01117004f, 0.19209918f, -0.04733702f, 0.04095324f, 
    0.22165240f, 0.03894788f, 0.02293428f, -0.04099895f, 0.05624976f, 0.06823231f, 0.08743997f, 0.16428161f, 
    -0.01835862f, 0.02693712f, 0.01737814f, -0.03825506f, 0.21120813f, 0.03283693f, 0.08760110f, 0.19324639f, 
    0.06792916f, 0.06210209f, 0.08816992f, 0.07508413f, -0.03561294f, -0.03462937f, -0.00134406f, 0.02275205f, 
    0.06575713f, -0.10500574f, 0.08152795f, -0.00872862f, 0.26041347f, 0.17755155f, 0.24233213f, 0.21360031f, 
    -0.04094741f, -0.03058034f, -0.01729313f, -0.00406621f, 0.08935785f, 0.07543261f, 0.06531469f, 0.09476217f, 
    -0.11380250f, -0.12175626f, 0.12078132f, -0.20173869f, -0.00086713f, -0.01621873f, 0.00452914f, 0.01321813f, 
    0.06165396f, 0.06089753f, 0.00796400f, 0.01165093f, 0.08058041f, 0.23302698f, -0.12594537f, 0.00426314f, 
    0.26396617f, -0.01339794f, 0.05760331f, 0.25035262f, -0.04814610f, -0.02047799f, -0.03559269f, -0.03930477f, 
    0.00245272f, 0.00351024f, -0.01534425f, 0.01772637f, 0.00974338f, 0.01687999f, -0.00692337f, 0.01500494f, 
    -0.03909862f, 0.01244781f, -0.02828448f, -0.01096951f, 0.00894500f, -0.03768235f, -0.03249488f, -0.02958352f, 
    0.02549241f, 0.00281342f, -0.02237737f, 0.02263100f, 0.00056423f, -0.00310231f, -0.01518444f, -0.02741710f, 
    -0.04107593f, 0.02744115f, -0.02876654f, -0.03624688f, 0.02991261f, -0.00905545f, 0.00521442f, -0.00495040f, 
    -0.01719628f, -0.03310195f, -0.04126771f, 0.01371326f, 0.00932711f, 0.02348201f, 0.02034803f, -0.03118627f, 
    -0.02327227f, -0.04350761f, 0.00055723f, -0.01560780f, 0.02590540f, -0.01219840f, -0.03526651f, -0.03891241f, 
    -0.00268704f, 0.00865752f, -0.02113131f, 0.02477418f, 0.01118143f, 0.00419699f, -0.02241700f, 0.01110812f, 
    0.01592353f, -0.03253888f, -0.01959436f, 0.02282774f, 0.00643581f, -0.00708325f, -0.03309900f, -0.04015837f, 
    0.00401327f, -0.04303011f, -0.00329894f, 0.01864794f, 0.00000227f, 0.01473887f, -0.01875164f, 0.02631511f, 
    0.00382619f, 0.00699716f, 0.00533564f, -0.01706449f, -0.02380390f, 0.01522248f, -0.03683008f, 0.00476253f, 
    -0.03999868f, -0.03094109f, 0.01855225f, 0.01225377f, 0.01494550f, 0.00140593f, 0.01059267f, -0.01503998f, 
    0.01142444f, 0.02473716f, -0.03741946f, -0.04231049f, -0.02915566f, 0.00642165f, -0.03432937f, 0.02156088f, 
    0.00417841f, 0.01746998f, -0.01623615f, -0.01497410f, -0.03461036f, -0.01569300f, 0.00363235f, 0.00538350f, 
    0.01607494f, -0.03582332f, -0.02766738f, -0.01001871f, 0.01649187f, 0.02977371f, 0.00158625f, 0.00075228f, 
    0.02074133f, -0.02408409f, 0.00525743f, 0.01285356f, -0.02404669f, -0.00115814f, -0.00771783f, -0.04322529f, 
    0.01679383f, -0.01107817f, -0.02443608f, -0.00032554f, -0.00868221f, -0.03988793f, 0.00592041f, -0.00033464f, 
    -0.02306595f, 0.02411659f, 0.00195011f, -0.01762450f, 0.01122367f, -0.03549197f, -0.03569524f, 0.00392029f, 
    -0.04430053f, -0.00312265f, 0.00055032f, -0.02305736f, 0.02213720f, 0.00024846f, 0.00728679f, 0.02604444f, 
    0.01336500f, 0.01302158f, -0.00517853f, 0.01314767f, -0.01484124f, -0.01893616f, -0.02425693f, -0.02910978f, 
    0.02295120f, 0.03085547f, -0.01891256f, 0.01737058f, -0.03590067f, -0.03204547f, 0.02319156f, -0.03795426f, 
    -0.03110089f, 0.01377642f, -0.00612703f, -0.00301934f, -0.00882516f, -0.01372597f, -0.00292371f, 0.02123800f, 
    0.02222091f, -0.00778150f, -0.02292206f, -0.01993904f, 0.02411059f, 0.00234418f, -0.03690875f, -0.00154759f, 
    0.00469842f, -0.02177946f, 0.02142062f, 0.03151264f, 0.02202761f, -0.00633276f, -0.01065221f, -0.01099236f, 
    -0.01272985f, -0.04055422f, -0.01580683f, -0.03241352f, -0.01406015f, -0.00238059f, 0.02929499f, 0.00925113f, 
    0.02074202f, 0.00711628f, 0.00717790f, -0.03311039f, 0.00113400f, -0.01105663f, -0.00429171f, -0.01802378f, 
    0.00622058f, 0.00433064f, 0.02226406f, -0.04286661f, -0.01910952f, -0.03037074f, 0.01222940f, 0.00293700f, 
    0.01271227f, -0.01306756f, -0.00179290f, -0.02621501f, -0.03092246f, -0.03720225f, -0.03750783f, -0.00330526f, 
    0.00898404f, -0.02301554f, 0.01943130f, -0.00438693f, 0.02415347f, -0.01245247f, 0.00583465f, 0.01563002f, 
    0.02010252f, 0.02967292f, -0.01382571f, 0.01124659f, -0.00225339f, -0.03229837f, -0.02651560f, 0.00256374f, 
    -0.04336245f, -0.03137024f, -0.01424275f, 0.01385466f, 0.02003667f, -0.01615858f, -0.02771894f, -0.00445723f, 
    -0.01872963f, -0.02177380f, -0.01634846f, -0.01867956f, -0.01098178f, -0.03944676f, 0.01374607f, -0.01200210f, 
    -0.00987878f, -0.03182329f, -0.03620008f, 0.02474326f, 0.01772613f, 0.01062739f, 0.01097788f, -0.01319943f, 
    0.01555074f, -0.02398020f, -0.03480018f, -0.02533529f, 0.00590007f, 0.00247340f, 0.00031389f, -0.01365179f, 
    0.01670995f, 0.01335128f, -0.03331953f, 0.02730286f, 0.02771036f, -0.02285678f, 0.01016513f, -0.03147529f, 
    -0.02582641f, -0.02504729f, 0.00314528f, 0.02136277f, 0.02720421f, 0.02551736f, -0.01060998f, -0.00355711f, 
    -0.01422102f, -0.03316905f, -0.01310357f, 0.02657968f, -0.02643881f, 0.02011264f, -0.00185020f, 0.01793090f, 
    0.00495865f, 0.00415657f, 0.02665313f, 0.02638317f, -0.02632429f, 0.00081800f, 0.00184760f, -0.00374239f, 
    0.00992038f, 0.00615296f, -0.00243734f, 0.01644182f, 0.01430938f, -0.02095624f, -0.02805434f, -0.00940754f, 
    -0.00071824f, 0.00223173f, 0.00178867f, 0.01434871f, -0.01716063f, -0.00037213f, 0.01346470f, -0.02695698f, 
    -0.03669177f, -0.00384442f, -0.03223709f, 0.00822565f, 0.03863064f, -0.01950886f, 0.00261634f, 0.02700041f, 
    -0.03503344f, -0.03807168f, -0.02204121f, -0.03524492f, 0.01286064f, 0.00069944f, -0.02329305f, -0.03004094f, 
    -0.03149206f, -0.01669852f, 0.01504098f, 0.00797626f, -0.01893778f, -0.00518888f, 0.02332520f, -0.04163294f, 
    0.02743898f, -0.02910083f, 0.01919816f, 0.00929375f, 0.01771172f, -0.03172648f, 0.00747738f, -0.01972451f, 
    0.02147460f, -0.01017920f, 0.02697226f, 0.00995559f, -0.03394561f, 0.01944817f, 0.00080863f, -0.00519072f, 
    0.00382265f, 0.02380981f, -0.01318443f, -0.01022833f, -0.00787799f, 0.02703955f, -0.01511839f, -0.01001810f, 
    0.00278667f, 0.01909461f, 0.01288133f, -0.00584818f, -0.02412124f, 0.00739143f, 0.01953313f, 0.00543942f, 
    -0.03495083f, 0.01442783f, -0.03063225f, -0.01524906f, 0.01629429f, -0.03918437f, -0.02300741f, 0.00454846f, 
    -0.00758082f, -0.00698555f, -0.02281898f, 0.00887320f, 0.02032436f, -0.03660087f, -0.02293109f, -0.02240973f, 
    -0.03962085f, -0.00190995f, -0.00091368f, 0.01576801f, -0.01043907f, -0.00519575f, -0.03232319f, -0.00732719f, 
    -0.03669811f, 0.01352476f, -0.00562687f, -0.04092909f, 0.00015632f, -0.01860093f, 0.01506237f, -0.00585837f, 
    -0.03412594f, -0.00965919f, 0.01093097f, -0.00990116f, 0.00207435f, 0.01770814f, -0.02046338f, 0.01658650f, 
    -0.00235150f, 0.01206483f, 0.01264967f, -0.00893280f, 0.02817963f, -0.03127884f, -0.00691657f, -0.01647977f, 
    -0.02847779f, -0.00985956f, 0.00563196f, 0.01622728f, 0.00169366f, -0.04407810f, 0.00844079f, 0.02545805f, 
    -0.01039267f, 0.00318232f, -0.03380210f, -0.02061403f, -0.02534564f, -0.03394644f, 0.00230224f, -0.01280207f, 
    0.01267571f, -0.02470522f, 0.01073018f, -0.00840081f, -0.03825974f, 0.00531427f, 0.00100724f, 0.01258055f, 
    0.02575879f, -0.03341911f, -0.00697003f, -0.00500905f, -0.01109420f, 0.00144547f, 0.00834874f, -0.03396847f, 
    -0.02099532f, -0.01024582f, 0.01280236f, -0.01865421f, -0.03470872f, 0.02481071f, -0.03110884f, 0.03001489f, 
    -0.03636981f, 0.02397923f, -0.03022871f, 0.00539143f, -0.03496675f, -0.03268392f, 0.00976046f, 0.01563338f, 
    -0.03420912f, -0.00921565f, 0.01322144f, 0.00238829f, -0.00904414f, -0.02130401f, 0.03276198f, 0.00203458f, 
    -0.00872432f, 0.02153049f, -0.00453777f, 0.00526265f, -0.03038151f, 0.01947543f, -0.02244205f, -0.02096338f, 
    0.00581310f, -0.01855808f, -0.04206494f, -0.04156830f, -0.04073981f, -0.00476519f, -0.01996820f, 0.01387547f, 
    -0.00256359f, -0.02834128f, -0.03541106f, -0.02224746f, 0.00469890f, -0.03838173f, 0.00935240f, 0.00403171f, 
    -0.01713922f, 0.01677300f, 0.01626838f, 0.02725480f, -0.01885642f, -0.01417653f, -0.01753800f, -0.00447332f, 
    0.02166041f, 0.00358876f, 0.02407919f, 0.02020292f, 0.03234204f, -0.02446559f, 0.00954167f, -0.03159037f, 
    -0.02169146f, 0.00052064f, -0.04249174f, -0.02224090f, -0.04173700f, -0.02727945f, 0.01828807f, -0.01199488f, 
    -0.02078177f, 0.01132722f, 0.02272765f, 0.00161828f, -0.02848274f, -0.03489893f, -0.03349715f, 0.01823025f, 
    0.02864774f, 0.01049646f, 0.01154584f, 0.01003242f, -0.00694096f, -0.00784970f, 0.00025746f, 0.00565946f, 
    0.01570265f, -0.00462113f, 0.02376773f, -0.00907138f, -0.03267074f, -0.02215329f, 0.01158124f, 0.02205035f, 
    -0.00517252f, -0.03689182f, 0.00764444f, -0.02555348f, -0.02599389f, 0.01015492f, 0.02813813f, 0.01517045f, 
    -0.00037487f, -0.04221678f, -0.02918457f, -0.00295161f, 0.02012710f, -0.02238467f, -0.02506725f, -0.03284057f, 
    -0.02063770f, -0.00834083f, -0.00060918f, -0.00400196f, -0.00159602f, -0.02083464f, -0.00998431f, 0.02366411f, 
    -0.00813694f, 0.02105951f, 0.02198784f, 0.01106084f, -0.01403127f, 0.01802848f, 0.01702558f, -0.00303141f, 
    -0.01193470f, -0.02057966f, -0.02962104f, -0.03914265f, 0.00543629f, 0.02541421f, 0.00826745f, 0.01756137f, 
    -0.03245695f, 0.01572226f, -0.01933990f, 0.00768265f, -0.03683499f, 0.00870989f, -0.00110898f, 0.01032306f, 
    -0.01449033f, 0.02532139f, 0.02678547f, 0.02057477f, 0.01720530f, 0.02388278f, -0.00392264f, -0.02103056f, 
    -0.03513198f, 0.03289326f, 0.00542975f, 0.02717164f, -0.02732008f, -0.00782186f, -0.01066040f, -0.00419841f, 
    -0.01668397f, -0.03307360f, 0.02558015f, -0.01641352f, -0.01604431f, -0.01199065f, 0.00155314f, 0.01307552f, 
    -0.03614721f, 0.00625816f, -0.03446576f, 0.02252600f, -0.01593967f, 0.02838962f, 0.02701504f, -0.02654963f, 
    -0.02510272f, -0.01665772f, -0.02550311f, -0.02868668f, 0.02214387f, -0.01501958f, 0.00846515f, -0.03536282f, 
    0.00110331f, -0.03949773f, -0.03663214f, 0.00243741f, 0.00130471f, -0.03827480f, 0.01486836f, -0.01239479f, 
    -0.01716442f, 0.01642610f, -0.01298237f, -0.03947072f, -0.00032651f, -0.04055774f, -0.03098103f, 0.00120416f, 
    0.01661809f, -0.01255580f, -0.00880042f, -0.03075509f, 0.02770318f, -0.02017284f, 0.01677579f, -0.04539044f, 
    0.02598700f, -0.00163617f, -0.03117063f, 0.00760242f, -0.00441422f, -0.03129537f, -0.02645770f, 0.02672109f, 
    -0.03940788f, -0.00201033f, -0.02782116f, -0.02991712f, -0.02996582f, -0.03260545f, 0.02307194f, -0.00212518f, 
    0.01740678f, -0.01471980f, -0.04396865f, -0.01223903f, -0.00002862f, -0.01037191f, -0.00665934f, 0.02287532f, 
    0.02391818f, 0.02641433f, 0.01526410f, 0.00032854f, 0.02709372f, -0.00916047f, 0.01277513f, -0.03570512f, 
    -0.01126417f, -0.03399941f, -0.02430579f, 0.02115976f, 0.03422549f, -0.00019680f, -0.01943917f, -0.00852761f, 
    0.02151587f, 0.01139641f, -0.00902324f, -0.03750587f, 0.00861726f, -0.01916688f, -0.02922366f, -0.01004324f, 
    0.02709559f, -0.03467013f, 0.00655194f, -0.01562408f, 0.01595742f, -0.01144850f, -0.01511039f, -0.03512012f, 
    -0.02495814f, 0.01290399f, 0.01869305f, -0.02172230f, 0.01474574f, -0.03880275f, -0.01766703f, 0.00814824f, 
    0.00168314f, -0.02383440f, -0.03581979f, 0.01500009f, 0.02418103f, 0.00983238f, 0.01378996f, 0.02418281f, 
    0.01959895f, -0.03618689f, 0.01750924f, -0.03161225f, -0.02546759f, 0.02821921f, 0.00136971f, -0.02346674f, 
    -0.03900212f, -0.01019791f, -0.00220976f, -0.01453629f, 0.00791342f, 0.01335532f, 0.01324949f, 0.02513470f, 
    0.00530123f, 0.02532271f, -0.01587153f, 0.00076604f, 0.00657258f, -0.02849019f, -0.04149846f, 0.01192332f, 
    0.01121444f, -0.01297343f, 0.02442611f, -0.01886420f, -0.00043849f, -0.01222014f, 0.01601850f, -0.00255495f, 
    -0.02461899f, 0.01159977f, -0.01089677f, -0.04021127f, 0.02103485f, 0.02487898f, -0.00297588f, 0.02589652f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.03679729f, -0.01563935f, 0.00639630f, 0.02020814f, -0.03778708f, -0.00845299f, 0.05341000f, -0.05309207f, 
    -0.13808101f, 0.09748101f, 0.02072282f, 0.02657380f, 0.10724356f, -0.02348382f, -0.01795405f, 0.01696356f, 
    0.03889233f, 0.07333721f, -0.01377524f, 0.01284904f, -0.01598195f, 0.07950344f, 0.12738238f, -0.02883657f, 
    0.07198672f, -0.01666650f, -0.00693834f, 0.05924047f, 0.14028570f, 0.05209921f, 0.10735308f, -0.04274857f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.04791108f, -0.03119048f, 0.28677833f, 0.12809758f, 0.17435181f, 0.11064827f, -0.07953028f, -0.45595336f, 
    0.30501890f, -0.49532524f, -0.06729180f, -0.11754269f, 0.20233330f, 0.13302110f, 0.37084556f, -0.00630772f, 
    -0.34801602f, -0.12888610f, 0.03132980f, 0.21407719f, 0.11139430f, -0.25378779f, -0.22693940f, 0.16325007f, 
    -0.25466147f, 0.01269227f, -0.51856238f, 0.11217436f, -0.32704368f, -0.09027869f, -0.32231912f, 0.11857978f, 
    -0.06567867f, 0.09945782f, 0.06550688f, -0.18198396f, 0.10533056f, 0.15144530f, 0.24007197f, -0.17189619f, 
    -0.01947703f, 0.47667342f, -0.04885885f, 0.01429933f, 0.28807065f, 0.16182724f, -0.18795440f, 0.06877333f, 
    -0.39519310f, 0.17863095f, 0.08264975f, 0.11102171f, 0.08439153f, -0.10083598f, 0.11588357f, -0.09337937f, 
    -0.25389370f, 0.15146819f, -0.81337368f, 0.15206592f, 0.20678343f, -0.16332647f, 0.37240550f, 0.04343363f, 
    -0.04853756f, 0.11236438f, 0.04464461f, 0.03922843f, -0.10275301f, 0.12692471f, -0.45296419f, -0.28917173f, 
    -0.09377258f, 0.38409445f, -0.12363321f, 0.08660909f, -0.57662988f, -0.11674279f, -0.22118059f, -0.32033136f, 
    0.08492544f, 0.22958024f, 0.08891719f, 0.28878033f, 0.16953407f, -0.09664022f, -0.01448160f, -0.04687709f, 
    -0.26071128f, 0.15596578f, 0.36423689f, -0.08745072f, 0.17024888f, 0.39444610f, -0.14451139f, 0.09416246f, 
    0.10293112f, -0.05824337f, -0.07847027f, 0.11199610f, 0.26735270f, -0.13449989f, 0.01100346f, 0.54448307f, 
    0.13958752f, 0.39794859f, -0.09775184f, -0.09189401f, -0.43731555f, -0.01655830f, 0.20030458f, -0.43632123f, 
    0.00545794f, -0.20190053f, 0.16637711f, 0.11313377f, 0.10497464f, -0.35050017f, -0.23419128f, 0.04680262f, 
    0.15088075f, -0.02915089f, 0.04035748f, -0.21157077f, -0.43234181f, 0.32305741f, -0.09345918f, -0.02925681f, 
    0.14839071f, -0.00060525f, 0.14749701f, 0.08917415f, 0.15205333f, 0.14640467f, 0.19673491f, -0.42074990f, 
    0.26497334f, -0.41943213f, 0.07047944f, -0.07035194f, -0.49265078f, -0.03138338f, -0.04383703f, 0.09396292f, 
    0.13913551f, -0.03856750f, -0.09825513f, 0.04710856f, 0.03030172f, -0.16177018f, -0.09795602f, -0.04934551f, 
    -0.06245690f, 0.08140547f, 0.42072174f, -0.31702977f, -0.31829247f, -0.67013603f, 0.06191881f, -0.17399426f, 
    -0.02300538f, -0.00597658f, 0.06731758f, 0.08700366f, 0.22223228f, 0.15662272f, 0.21710086f, -0.27161995f, 
    -0.33633292f, -0.77073568f, -0.05966827f, -0.01621062f, 0.01175272f, -0.07189810f, 0.31555313f, -0.21873818f, 
    -0.06970215f, 0.09368823f, -0.02254744f, -0.38357130f, 0.15571564f, 0.12876081f, 0.24586110f, 0.03983429f, 
    0.07582910f, 0.01148412f, -0.11726726f, 0.14342645f, 0.17219496f, -0.19349512f, -0.23944832f, -0.10790588f, 
    -0.12495670f, 0.03297634f, 0.05365127f, -0.06446537f, -0.10426981f, 0.16375911f, -0.68468851f, 0.31018880f, 
    -0.15891397f, 0.20066895f, 0.03373032f, 0.16062106f, -0.00845333f, 0.08824304f, -0.65178961f, 0.22942305f, 
    0.17264111f, 0.01361720f, 0.00303549f, 0.04053285f, 0.09809081f, 0.25915015f, 0.34663162f, 0.03622626f, 
    0.20801473f, -0.08499679f, -0.08529878f, -0.49128190f, -0.01032922f, -0.10196649f, -0.55061042f, -0.00651882f, 
    -0.10909121f, 0.06490245f, -0.35421315f, 0.13725948f, 0.19277869f, 0.09338634f, -0.31002015f, 0.17732581f, 
    0.40483883f, -0.04331434f, 0.03435226f, -0.13468288f, -0.11028453f, 0.02043227f, 0.08124118f, 0.12433547f, 
    -0.04895562f, 0.10920065f, -0.05267422f, -0.40587658f, 0.01161318f, 0.22384559f, -0.40315238f, -0.02177558f, 
    -0.15795952f, 0.01934887f, 0.27628183f, 0.01764151f, -0.09339504f, 0.21530673f, 0.20813105f, -0.13461462f, 
    -0.05932498f, 0.16091956f, 0.06854099f, 0.09816464f, 0.27637109f, -0.12649666f, -0.19239387f, -0.38559696f, 
    -0.60631943f, 0.14131050f, 0.13617557f, -0.09010822f, -0.13597277f, -0.12749672f, -0.07159335f, -0.40529266f, 
    -0.06412233f, -0.33635801f, -0.09031785f, -0.01818829f, -0.15559795f, 0.33025393f, -0.43876731f, 0.08446725f, 
    0.34951991f, -0.13002330f, -0.00428304f, 0.39235407f, 0.25262234f, 0.25458777f, -0.10874341f, -0.06717152f, 
    -0.03850713f, -0.08918137f, -0.03178172f, -0.13238731f, -0.55595016f, -0.13908067f, -0.08386159f, 0.04432365f, 
    0.13158813f, -0.09220866f, -0.08201770f, 0.03462256f, 0.22478807f, 0.07381686f, -0.07715094f, -0.20234212f, 
    0.13389848f, 0.36129534f, -0.04949529f, 0.21149901f, -0.16488175f, 0.00497570f, -0.21204588f, -0.01456616f, 
    0.19535400f, -0.16085169f, 0.22278479f, -0.24543869f, -0.04210391f, -0.76085883f, 0.11770702f, -0.15519203f, 
    -0.10292248f, -0.03272559f, 0.18551193f, 0.08982353f, -0.48331296f, 0.15241167f, 0.31991372f, -0.17791051f, 
    -0.63585335f, 0.34277940f, 0.00792671f, 0.02022879f, -0.52135283f, 0.09521040f, -0.02763106f, 0.08681390f, 
    -0.16510443f, -0.14970975f, 0.13306603f, 0.16269879f, 0.08073059f, -0.07895806f, 0.18866980f, -0.01046909f, 
    0.49099487f, 0.00534322f, -0.26431456f, 0.18283626f, -0.26044306f, 0.38571224f, -0.26231164f, -0.04574624f, 
    0.15986404f, -0.07494690f, -0.30591235f, -0.04612450f, 0.05534503f, 0.11923081f, -0.07788394f, -0.06583375f, 
    0.09813834f, -0.10589878f, -0.15697370f, -0.08461542f, -0.21660757f, 0.15381469f, -0.06033511f, 0.41593787f, 
    0.20889689f, -0.50817388f, 0.10253510f, 0.10863297f, -0.05914877f, -0.16217968f, 0.13086116f, 0.09495796f, 
    -0.28433523f, 0.05317683f, 0.15133876f, 0.24654138f, 0.25514436f, 0.19308719f, -0.45869485f, 0.01948186f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.28585792f, 0.13459003f, -0.09615821f, -0.04132044f, -0.00288270f, 0.10962594f, 0.20116173f, -0.11841401f, 
    0.11989842f, 0.05896157f, 0.00815429f, 0.13737582f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
