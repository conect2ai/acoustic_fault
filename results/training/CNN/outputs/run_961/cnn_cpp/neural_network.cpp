#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.74863189f, 0.33797118f, 0.04835450f, -0.26325774f, 0.30309138f, -0.42493945f, -0.31937650f, -0.69740075f, 
    -0.96756077f, -0.48785174f, -0.11399952f, 0.45137075f, 0.42899057f, 0.04535508f, -0.08323160f, -0.15571861f, 
    -0.22832109f, 0.22813405f, 0.23440990f, 0.12190236f, 0.33440050f, 0.05084402f, -0.06134558f, 0.22239198f, 
    0.09394990f, -0.15278800f, -0.90557772f, 0.76390046f, 0.18137409f, -0.26423281f, 0.31306744f, -0.34798875f, 
    0.93053120f, 0.27351144f, 0.19437701f, 0.22842652f, -0.66546178f, 0.24151506f, 0.42690504f, -0.10188977f, 
    -0.01829746f, -0.16497593f, -0.09807358f, -0.13280240f, 0.09914012f, -0.45417112f, 0.06435602f, 0.07194000f, 
    -0.12142750f, 0.11021779f, -0.19422016f, 0.55499625f, -0.20125423f, -0.51304632f, -0.59334552f, 0.54776454f, 
    -0.27302080f, -0.80324680f, -0.66323745f, -0.45171618f, -0.17623167f, -0.11160956f, 0.16659459f, 0.29863271f, 
    0.24422145f, 0.16228391f, -0.30349463f, 0.13555847f, 0.00538421f, -0.17553714f, 0.02790474f, -0.18056946f, 
    -0.21169119f, -0.22395445f, 0.08762445f, 0.31983721f, 0.40145224f, 0.62785512f, 0.80282789f, 0.41216812f, 
    -0.85204142f, -0.22337802f, -0.08464368f, -0.56031156f, 0.31218296f, 0.39680541f, 0.05290773f, 0.11723308f, 
    0.47710818f, -0.28617913f, 0.27091068f, -0.02227844f, 0.11004575f, 0.29787859f, -0.15293428f, 0.27982387f, 
    0.17246389f, 0.22932285f, -0.07415023f, -0.15597631f, 0.28652251f, 0.60905474f, 0.44981670f, 0.57171857f, 
    -0.15533435f, -0.63867635f, -0.02255363f, 0.03390845f, 0.56450886f, -0.31224635f, -0.08976467f, -0.23494919f, 
    -0.24293050f, -0.08399130f, 0.18265834f, -0.04812006f, 0.09053019f, 0.05123406f, 0.15691173f, 0.26710600f, 
    0.06168441f, -0.00329976f, 0.01559258f, -0.35884759f, 0.06116064f, 1.04433489f, 0.62439615f, 0.62502170f, 
    -0.27730703f, 0.07031356f, -0.28856844f, -0.41748992f, 0.01051633f, 0.11875015f, 0.10184854f, 0.15383188f, 
    0.09891606f, -0.18261501f, -0.03190500f, 0.05933966f, 0.09904385f, -0.20280491f, 0.30672950f, 0.12007483f, 
    -0.18262094f, 0.12980206f, 0.10447156f, -0.09356038f, 0.16102760f, 0.05037545f, -0.54662192f, -0.70855826f, 
    0.08385293f, 0.81878275f, 0.38447523f, 0.19441576f, 0.23526478f, 0.03845704f, -0.07068046f, 0.21078287f, 
    0.25910127f, -0.19677892f, -0.15142661f, 0.38251728f, 0.06093334f, 0.29043308f, -0.01753735f, -0.38927564f, 
    0.08951396f, -0.00954989f, -0.25077790f, 0.13600756f, 0.28881148f, -0.43757415f, 0.12070588f, 0.80456859f, 
    0.11135327f, 0.01164963f, 0.69516164f, -0.25132245f, 0.02702339f, 0.60930437f, -0.57181662f, -0.48260438f, 
    0.38578287f, -0.01029333f, 0.18207794f, 0.11079890f, 0.11039215f, -0.13829856f, -0.51538312f, 0.12382410f, 
    -0.06008266f, -0.42539343f, -0.02937054f, 0.15651700f, -0.04154234f, 0.02791100f, 0.28519747f, 0.03468807f, 
    0.32617554f, 0.61263990f, 0.54603761f, -0.81909513f, -0.14112723f, 0.13606764f, -0.83859289f, -0.06609395f, 
    -0.05052631f, 0.11932225f, 0.21898904f, -0.28478870f, 0.35622281f, 0.31034806f, -0.06658489f, -0.05123333f, 
    0.07820562f, 0.25624013f, 0.13612273f, -0.45831823f, 0.14431264f, 0.33113122f, -0.14158686f, 0.08449411f, 
    -0.06679714f, 0.63899118f, -0.07928701f, -0.78684449f, -0.92787236f, -0.87282181f, 0.11524531f, 0.82490849f, 
    0.39459318f, 0.50761980f, 0.47045651f, -0.14361069f, -0.14502956f, -0.26945511f, -0.44214877f, -0.28376111f, 
    -0.10561223f, 0.05791410f, 0.01275803f, 0.12620203f, -0.04899288f, -0.01589995f, -0.05732938f, -0.06877980f, 
    -0.22339812f, -0.24678950f, 0.03881034f, -0.12668172f, -0.61496061f, 0.71757555f, 0.70863467f, 0.06185472f, 
    -0.43499821f, -0.90549910f, 0.24340589f, 0.17909871f, -0.40765381f, -0.13402601f, 0.18622632f, 0.31289136f, 
    -0.12341656f, -0.06717347f, 0.22367683f, 0.43650520f, -0.01417316f, -0.11406942f, 0.31596914f, -0.03354810f, 
    -0.02205782f, -0.13753168f, 0.27810135f, -0.78611982f, -1.20351374f, -0.67723209f, 0.06709012f, 0.51226753f, 
    0.21573836f, 0.99099529f, 0.40683571f, 0.25321308f, -0.31236434f, -0.34423465f, -0.19574228f, -0.13192365f, 
    0.23547681f, 0.24441466f, -0.01158412f, -0.13085295f, -0.19421943f, -0.16410135f, 0.09390555f, -0.03432527f, 
    0.09940578f, 0.09635713f, 0.14875296f, -0.02602622f, 0.25371957f, -0.62644958f, -0.61012638f, -0.23731120f, 
    -0.35996816f, -0.42183390f, 0.84247905f, -0.17872147f, -0.63880450f, 0.49948168f, 0.01440017f, 0.18556687f, 
    0.14348124f, 0.22425611f, -0.01027642f, -0.06971242f, -0.11679053f, 0.14623775f, 0.02852738f, -0.24383748f, 
    -0.25403965f, -0.08978206f, -0.09786160f, -0.35227072f, -0.14360344f, 0.80415893f, 0.50014472f, 0.44778827f, 
    0.06951320f, 0.28033993f, 0.16265482f, -0.41791323f, 0.54115611f, 0.47369298f, -0.15552013f, -0.39678529f, 
    0.11034141f, 0.05796859f, -0.06987087f, -0.31698278f, 0.04208945f, 0.11779480f, -0.14613467f, -0.37576231f, 
    0.14948261f, -0.48306963f, 0.02608024f, 0.24242668f, 0.38163778f, -0.27019763f, -0.58019984f, -0.29807225f, 
    -0.68228805f, -0.20621178f, -0.07625721f, -0.44322389f, -0.57147110f, -0.31729373f, 0.04247063f, 0.10999220f, 
    -0.03781878f, -0.04897755f, -0.06643628f, 0.07353590f, -0.43805131f, 0.09822423f, -0.24279650f, 0.33840746f, 
    0.36267170f, -0.12323177f, 0.32017690f, 0.20915809f, -0.29865626f, -0.00898027f, 0.47794873f, 0.79533112f, 
    0.25107333f, 0.76444787f, -0.23036729f, -0.38809311f, 0.28080088f, -0.02686905f, -0.10117773f, -0.12970969f, 
    0.31854433f, 0.20918630f, 0.06867816f, -0.13011463f, 0.39199886f, 0.24315302f, 0.24830613f, -0.39507732f, 
    -0.11085372f, 0.12718225f, -0.26698521f, 0.20634551f, 0.30183539f, 0.16810507f, 0.13793521f, 0.24660228f, 
    0.15826558f, -0.53307992f, 0.26892307f, 0.18550618f, -0.28557363f, -0.96245456f, 0.07713614f, -0.60258186f, 
    -0.16691078f, 0.53815538f, 0.10304135f, 0.27653748f, -0.45013705f, -0.10079718f, -0.33269641f, -0.33297586f, 
    -0.43355554f, 0.14844149f, 0.15940347f, 0.28703466f, 0.38344640f, -0.18279180f, -0.08323899f, -0.26322702f, 
    -0.14424077f, -0.46409890f, 0.44471264f, -0.63254613f, 0.48363060f, -0.73179346f, 0.38254425f, -0.11223698f, 
    -0.54439205f, -0.26915780f, -0.04319390f, -0.39273563f, 0.27872664f, -0.34008443f, 0.29180533f, -0.04450315f, 
    0.18731508f, 0.38879979f, 0.11589658f, 0.38383088f, 0.13673383f, -0.09962884f, -0.00289548f, -0.00318702f, 
    -0.05351235f, 0.01479195f, 0.92550582f, 0.36491513f, 0.39235812f, 0.35402176f, -0.08781352f, 0.49936673f, 
    0.29670417f, -0.56971449f, 0.40264297f, -0.12333252f, -0.00153934f, -0.17908794f, -0.37114447f, 0.19332252f, 
    -0.34073293f, 0.05069123f, 0.15371215f, -0.13427116f, 0.19922307f, 0.40660635f, 0.27290872f, 0.28555751f, 
    0.35385138f, -0.10622961f, 0.19953075f, 0.62849426f, 0.23950407f, 0.38751289f, 0.54642552f, 0.67277163f, 
    0.29385731f, 0.14733593f, 0.16985440f, -0.65631199f, -0.50476658f, 0.32882774f, -0.34464663f, -0.65930551f, 
    0.00560305f, -0.05094708f, 0.17921522f, -0.33696067f, -0.16013420f, 0.15985464f, -0.07015719f, 0.21317440f, 
    -0.10158475f, 0.21915622f, 0.21848825f, 0.09541166f, 0.72863215f, 0.41947412f, -0.18973306f, 0.60789478f, 
    0.44298416f, -0.01256314f, 0.02963425f, 0.45453501f, 0.50884140f, 0.14505191f, -0.34731090f, -0.26503578f, 
    -0.26563683f, -0.56620306f, -0.09083311f, -0.56988072f, -0.29534814f, -0.21076821f, -0.18600282f, 0.06994643f, 
    0.47065195f, 0.18028218f, 0.24552438f, 0.09486754f, 0.05849298f, 0.12446691f, 0.64811051f, 0.74035132f, 
    -0.91795850f, -0.04052626f, 0.20836470f, -0.06598809f, -0.42381507f, -0.19636519f, -0.48083627f, 0.26599404f, 
    0.44435784f, 0.24755594f, 0.18551978f, -0.32470065f, -0.32368806f, -0.27897856f, -0.17709571f, -0.35392475f, 
    -0.42184711f, 0.24265519f, -0.16734281f, 0.34700167f, 0.15703291f, -0.00421915f, 0.15206087f, 0.61029112f, 
    0.68826598f, -0.65294248f, -0.82470846f, -0.12273866f, 0.31562483f, -0.06738020f, -0.47637886f, 0.38025475f, 
    0.43755984f, 0.31952560f, -0.17145123f, 0.17369124f, -0.15892662f, -0.15581347f, 0.07242540f, -0.00836683f, 
    0.11703096f, -0.15658426f, -0.04362129f, 0.01932218f, 0.04958762f, -0.27531239f, 0.33871353f, 0.56264991f, 
    0.59155482f, -0.07387595f, -0.48345727f, -0.01069356f, 0.38990298f, 0.00042610f, -0.29870102f, 0.13512404f, 
    0.04661098f, 0.43047571f, 0.38088110f, 0.14784159f, 0.13224930f, 0.12675144f, -0.17072855f, 0.17151901f, 
    0.29617083f, 0.24575771f, 0.56149858f, -0.46710849f, 0.09806057f, -0.03493761f, 0.10180099f, 0.42120034f, 
    0.21829052f, -0.01265472f, 0.84054291f, 0.12619142f, -0.87510222f, -0.67941689f, -0.08795002f, -0.25225192f, 
    -0.16271348f, -0.60864580f, 0.18157737f, 0.27433863f, -0.35083678f, -0.18546391f, -0.08577932f, -0.26693785f, 
    -0.21110402f, -0.22221856f, -0.09004642f, 0.09368297f, -0.07725069f, 0.30513400f, 0.14925949f, 0.11526468f, 
    0.21661639f, 0.51183093f, 0.20498240f, 0.19989170f, 0.24717940f, 0.55773473f, 0.48130411f, -0.02256878f, 
    0.37681159f, 0.40514839f, 0.44265479f, -0.23857090f, 0.13435967f, 0.18309055f, 0.22484377f, 0.30194908f, 
    -0.00472436f, -0.13561723f, -0.13973500f, -0.07530260f, 0.23516479f, 0.07544935f, 0.06383675f, 0.08638606f, 
    0.41361576f, 0.23143083f, -0.21608828f, 0.53762341f, -0.26463389f, -0.61685640f, -0.21594040f, -0.23376796f, 
    0.43867368f, -0.36309752f, -0.63959712f, -0.57881808f, 0.03827222f, 0.09397478f, -0.23485881f, 0.06589134f, 
    0.32881707f, -0.05885424f, 0.19054350f, 0.42507041f, -0.11192708f, -0.15193179f, 0.01680161f, 0.22368695f, 
    -0.45420823f, 0.16587448f, 0.46841580f, 0.49210587f, -0.11274657f, 0.43554270f, 0.45332673f, 0.51965493f, 
    0.13827664f, -0.41717553f, 0.53701925f, 0.32281399f, 0.29093370f, -0.03256343f, -0.13387771f, -0.17698354f, 
    -0.08573017f, -0.01123802f, 0.00719724f, 0.41579568f, 0.09142563f, -0.36064115f, -0.44053531f, 0.01139344f, 
    0.10648945f, -0.10360904f, -0.12642828f, -0.16217405f, -0.02203998f, -0.23870569f, -0.15514080f, -0.30011344f, 
    0.64259738f, 0.14129859f, -0.61108637f, -0.14551373f, -0.54496580f, 0.54296970f, -0.38367018f, -0.28912333f, 
    0.27883479f, 0.05252190f, -0.21872041f, -0.48397854f, -0.35993320f, -0.52414137f, 0.37042853f, -0.41921973f, 
    -0.12140594f, 0.06886555f, 0.02950347f, 0.04199916f, 0.10786414f, 0.34177384f, -0.00008479f, 0.49988341f, 
    0.60894221f, -0.78905147f, 0.38853958f, -0.96184522f, -0.38162538f, -0.25353229f, 0.37334162f, 0.34893966f, 
    0.29660118f, 0.48454717f, 0.28594530f, -0.13032983f, -0.33945462f, 0.10864194f, 0.37890193f, -0.04114867f, 
    -0.01855471f, -0.38127577f, -0.13359493f, 0.06940072f, 0.14426100f, -0.09392118f, 0.46631178f, 0.03419795f, 
    -0.86122817f, -0.74785268f, -0.29418969f, 0.09138297f, -0.37182382f, -0.38225380f, -0.21603879f, -0.06938551f, 
    0.41812301f, -0.08650752f, 0.36782956f, 0.33569521f, 0.13760404f, 0.19106901f, 0.21445276f, 0.27785814f, 
    -0.27475917f, 0.14679107f, 0.11989139f, -0.24505402f, 0.26832315f, 0.32586935f, 0.34421134f, -0.41563731f, 
    -0.44121280f, -0.62074220f, -0.42131209f, 0.27623707f, -0.09604559f, 0.75130785f, -0.04410173f, -0.36670771f, 
    0.59823173f, 0.27345851f, -0.13077208f, 0.34983793f, -0.23581676f, 0.31353813f, -0.11783159f, 0.24774054f, 
    0.24078740f, 0.27238721f, -0.20901960f, 0.35323036f, -0.06893369f, 0.03694867f, 0.25699610f, -0.00060832f, 
    -0.70029896f, -0.43472821f, -0.57334155f, 0.37785256f, -0.35019684f, 0.24220952f, 0.48466799f, 0.00036629f, 
    0.51090783f, -0.36777282f, 0.12229503f, 0.03636600f, 0.16630231f, -0.28973129f, -0.50902289f, -0.01508946f, 
    0.00289641f, -0.02282840f, -0.41875532f, -0.25287923f, 0.30577484f, 0.18592831f, 0.28724575f, -0.04067532f, 
    0.19045059f, 0.27756211f, 0.51190740f, 0.39499420f, 0.35701966f, -0.19471827f, -0.39634824f, 0.04327324f, 
    -0.04707481f, 0.37394965f, 0.38230118f, 0.11726087f, 0.24133648f, -0.36547622f, -0.14515312f, 0.29009110f, 
    0.04600617f, -0.16568319f, -0.32035762f, -0.30797675f, 0.18379951f, -0.42629769f, 0.31729829f, 0.32423595f, 
    -0.52862036f, -0.36675465f, -0.54879194f, 0.45055655f, -0.34787205f, -0.84003741f, -0.62167883f, 1.01247489f, 
    -0.05209243f, -0.54248828f, 0.31292224f, 0.03724606f, 0.14505562f, -0.20926076f, 0.45623145f, 0.29160228f, 
    -0.15276051f, 0.20449583f, 0.04543786f, -0.01322423f, -0.11072416f, -0.05145817f, -0.13125119f, -0.03533649f, 
    0.16347696f, 0.09473435f, 0.02022794f, 0.53244460f, -0.26471445f, 0.11585918f, 0.32676560f, -0.30754417f, 
    0.45498940f, 0.52370465f, 0.08734949f, 0.36551565f, 0.53809988f, -0.12608175f, 0.03764750f, -0.12520410f, 
    -0.26578107f, 0.06427874f, -0.23037787f, 0.35469443f, -0.21758671f, -0.41840130f, 0.19594346f, 0.11679883f, 
    0.11841863f, 0.49752650f, 0.07695245f, -0.28612530f, -0.44428053f, -0.48018155f, -0.52297300f, -0.20769882f, 
    -0.34273753f, 0.72087461f, 1.06247675f, -0.51143932f, 0.26543099f, 0.14936930f, -0.37120682f, 0.11756850f, 
    -0.09178349f, -0.08089316f, 0.43808413f, -0.18937175f, -0.14891320f, 0.02853960f, 0.07020830f, 0.10266553f, 
    0.24252863f, -0.03913545f, -0.01854137f, 0.11972523f, 0.14810283f, 0.70607489f, -0.58502305f, -0.08948924f, 
    0.23359293f, 0.69323409f, 0.76324743f, 0.17892212f, 0.36026227f, -0.13806629f, -0.34559983f, -0.39069563f, 
    -0.23237136f, -0.31280458f, 0.30922922f, 0.37862375f, 0.19333099f, 0.14103238f, 0.45701486f, 0.35769582f, 
    0.25133666f, 0.23993088f, -0.25727519f, 0.17266142f, -0.12296533f, -0.17069705f, 0.09269045f, -0.49846983f, 
    -0.30074549f, 0.88645560f, 0.02215887f, -1.07897449f, -0.19161329f, 0.45807651f, -0.92838091f, -0.10556780f, 
    0.32375717f, 0.30826077f, 0.14380319f, -0.04481489f, 0.31443501f, 0.13342963f, 0.19223683f, -0.01400043f, 
    0.10274234f, -0.09600250f, -0.02719929f, 0.02496895f, -0.27926013f, 0.15467796f, 0.15672997f, 0.02451139f, 
    -0.23996329f, -0.14183430f, -0.32111543f, -0.37938851f, -0.65120113f, -0.58805329f, -0.15372592f, 0.05153103f, 
    -0.54248619f, -0.42455810f, -0.15846567f, -0.07280376f, -0.25210130f, -0.30337101f, -0.47722882f, -0.03139352f, 
    -0.36253685f, -0.46147564f, -0.35094157f, 0.35317680f, 0.23536259f, 0.12806007f, -0.37321734f, -0.23668671f, 
    0.76972771f, 0.43018246f, 0.42970130f, 0.72372627f, 0.82171315f, -0.41848236f, 0.23431946f, -0.29037848f, 
    0.60142738f, -0.26313189f, -0.16039035f, 0.35246810f, -0.21344756f, -0.33999720f, -0.31303075f, -0.01069295f, 
    0.11105268f, -0.22031774f, -0.28801581f, 0.05065044f, -0.09783279f, -0.02345053f, -0.12141468f, 0.24529678f, 
    0.11489002f, -0.15615992f, -1.13747370f, -0.53427851f, 0.70079988f, 0.05695930f, -0.69869304f, 0.66212529f, 
    0.57931930f, 0.12169529f, -0.05608288f, 0.06644607f, 0.15309812f, -0.12619865f, -0.17508414f, 0.14044774f, 
    -0.01290890f, 0.17234193f, -0.52689052f, -0.28210992f, 0.06014040f, -0.19913566f, -0.12497948f, 0.46549514f, 
    0.02661598f, 0.40269104f, 0.58578199f, -0.03716621f, 0.36471334f, 0.70266163f, 0.63633734f, -0.78094846f, 
    -0.25804079f, 0.15251933f, -0.08858012f, -0.02809785f, 0.29236361f, 0.22071575f, 0.13787583f, 0.34756947f, 
    -0.02674457f, -0.33308804f, 0.15086998f, 0.30017117f, -0.07420517f, -0.39433417f, -0.34083897f, 0.33233094f, 
    0.12095061f, -0.02265587f, 0.06219279f, 0.11465899f, 0.20201801f, -0.72947079f, 0.42908654f, 0.42123824f, 
    -0.67407167f, 0.41706520f, -0.32783112f, 0.34806928f, -0.31530261f, 0.08317647f, 0.02618443f, -0.07338263f, 
    0.18040515f, 0.40568146f, -0.22834376f, 0.00624024f, -0.16180655f, 0.12543561f, 0.04599726f, 0.03957392f, 
    0.05947072f, -0.28971195f, 0.51476616f, 0.25889963f, -0.74108380f, 0.19181229f, 0.60986680f, 0.53458238f, 
    0.40558794f, -0.47798517f, 0.62232840f, -0.03350709f, -0.65740931f, -0.55582225f, 0.25682572f, -0.19483173f, 
    -0.04835071f, 0.03948710f, -0.08589916f, 0.24232955f, 0.38749102f, 0.18152395f, -0.23854545f, -0.10106491f, 
    -0.04871137f, -0.14702615f, -0.19782789f, 0.06078056f, -0.05124957f, -0.97621602f, 0.90157461f, 0.65431523f, 
    -0.67463273f, 1.07273960f, 0.81664842f, 0.08771427f, -1.03150558f, 0.47712430f, -0.62724733f, -0.23904648f, 
    0.07797209f, -0.47119308f, 0.03150828f, -0.31958377f, -0.15357012f, 0.33570319f, -0.09951741f, -0.31626776f, 
    -0.23598376f, 0.20317994f, 0.05281707f, -0.15597729f, 0.28398553f, -0.04209520f, 0.88755399f, 0.53218925f, 
    0.39828429f, -0.07502704f, 0.41406816f, -0.57808936f, -0.37989140f, 0.25221893f, 0.12369821f, -0.38462865f, 
    -0.21632813f, -0.53409576f, 0.02342500f, 0.06428141f, 0.44563386f, 0.12671921f, 0.15717585f, -0.32552496f, 
    -0.19466180f, -0.25650951f, -0.04277343f, 0.29043141f, 0.24509266f, 0.22621517f, 0.03184975f, -0.45704690f, 
    -0.51953042f, 0.11412058f, -0.40261492f, -0.58119714f, 0.14519462f, -0.04720584f, 0.02180571f, 0.21617933f, 
    -0.48470449f, -0.23225866f, 0.54793233f, -0.03478300f, 0.15085579f, -0.11275447f, 0.20591600f, 0.03060238f, 
    0.33268675f, 0.36648795f, -0.48141885f, 0.12742580f, -0.25842845f, 0.20631860f, -0.32988089f, 0.22004493f, 
    0.38564995f, 0.53764260f, 0.58061546f, -0.32077453f, -0.14593635f, -0.03353105f, 0.59001791f, 0.27240843f, 
    -0.22218795f, 0.43429872f, 0.05073550f, 0.61707652f, 0.13604282f, 0.19990063f, 0.11848285f, 0.50543016f, 
    -0.21627079f, -0.44888753f, 0.19339707f, -0.36686239f, -0.07043073f, -0.20815139f, 0.09867637f, 0.18469171f, 
    -0.14034098f, -0.21161835f, -1.17352307f, 0.72391337f, 0.77343827f, -0.43382776f, 0.17961344f, -0.29863513f, 
    0.50460815f, 0.15157993f, 0.04429464f, -0.18690343f, -0.47166508f, -0.33861738f, 0.33866227f, 0.12064406f, 
    0.31827483f, 0.23728828f, -0.05437816f, 0.00848068f, -0.11034292f, 0.13212967f, 0.09932297f, 0.28946289f, 
    -0.04932011f, 0.10847688f, 0.15962632f, 0.53707075f, -0.35319996f, 0.86745715f, 0.45190838f, 0.78867781f, 
    0.63200420f, 0.23816910f, 0.03504438f, 0.55785984f, -0.22807312f, -0.31999239f, -0.03271163f, -0.35241196f, 
    -0.33194920f, -0.09439787f, 0.09952952f, 0.09696957f, -0.14664166f, -0.31232777f, 0.04960643f, -0.21966161f, 
    -0.07157137f, -0.19684352f, -0.01200050f, -0.42973682f, -0.95511377f, -0.07076184f, 0.00241556f, -0.47450426f, 
    -0.56235707f, 0.20246784f, 0.54059178f, -0.69240075f, 0.11840650f, 0.16032867f, -0.12907645f, 0.39065033f, 
    -0.21546914f, 0.26872069f, -0.28053662f, 0.07857374f, 0.13854240f, -0.19757746f, 0.25517026f, 0.31880090f, 
    0.08381691f, 0.00954071f, 0.40479395f, -0.16642073f, 0.39166081f, -0.63697624f, -0.75183219f, -0.03738701f, 
    -0.07024547f, 0.79383522f, 0.66472942f, -0.22251663f, 0.47944722f, 0.47996551f, -0.10379359f, 0.05357091f, 
    -0.33418086f, 0.41645271f, -0.34140369f, -0.08541975f, 0.03232529f, 0.26157272f, 0.19908769f, -0.22196287f, 
    -0.13001072f, -0.03825712f, -0.38670599f, -0.20823099f, 0.06902437f, -0.59548193f, -0.90265298f, -0.21563108f, 
    0.10489634f, -0.17439885f, 0.65124381f, 0.09573672f, 0.50987291f, 0.03881800f, -0.04716130f, -0.39194053f, 
    -0.10337553f, 0.31897610f, 0.50598383f, 0.00060770f, -0.22016646f, 0.13797158f, -0.02285858f, -0.28263193f, 
    0.11448547f, -0.02123482f, 0.09025072f, -0.10492210f, -0.16609110f, 0.02498511f, 0.74592435f, 0.59603584f, 
    0.49968398f, 0.66341871f, 0.08248329f, 0.05464734f, 0.30574611f, 0.04338891f, -0.22272697f, -0.29833558f, 
    -0.31833500f, 0.04171536f, 0.16450755f, 0.38599095f, -0.10711776f, 0.37690890f, -0.34584460f, 0.18480407f, 
    0.12131941f, 0.08345027f, -0.14450192f, -0.34729794f, -0.38897857f, -0.10247391f, -0.14398709f, -0.52439719f, 
    -0.53656346f, -0.05614894f, -0.21157236f, -0.58291996f, 0.05654415f, 0.74190480f, 0.32857025f, 0.29649201f, 
    0.15564913f, 0.34555149f, 0.09344045f, -0.16376998f, -0.11590537f, -0.21541810f, 0.20719279f, -0.00912906f, 
    -0.06952951f, 0.14244208f, 0.28209302f, -0.08670782f, -0.12831260f, 0.01391847f, -0.27189976f, 0.60357213f, 
    0.14074813f, 0.22209126f, -0.31914172f, 0.27631921f, -0.22930560f, -0.63207906f, -0.67287832f, -0.12015806f, 
    0.15876096f, -0.17137001f, -0.10401143f, 0.17406631f, 0.43634689f, -0.43131137f, -0.57938868f, 0.02833977f, 
    -0.36406478f, -0.48343197f, -0.00361449f, -0.18206751f, -0.29084474f, -0.33630949f, -0.05672917f, -0.45618024f, 
    -0.34556526f, -0.90943933f, -0.07556760f, 0.26591748f, -0.44436982f, -0.70662236f, 0.59148157f, 0.37166530f, 
    -0.06121106f, -0.02538050f, 0.51039058f, -0.04587420f, -0.13012983f, -0.28055078f, -0.37181371f, -0.21425703f, 
    -0.05044915f, 0.21343285f, 0.04668612f, 0.00197250f, -0.36108443f, -0.06237648f, 0.03417417f, 0.26906097f, 
    -0.02424616f, 0.17584398f, 0.85971493f, 0.43827593f, 0.55923164f, 0.49391270f, 0.95299500f, -0.11069395f, 
    -0.15352203f, -0.43549073f, 0.02676727f, 0.06563409f, -0.12331444f, 0.29247838f, 0.19840240f, -0.07991118f, 
    0.07398728f, 0.21878912f, 0.21255316f, 0.21472426f, 0.10515393f, 0.39057875f, 0.41214925f, 0.01570807f, 
    0.19314478f, -0.23687495f, 0.32263103f, -0.29534656f, 0.08770951f, 0.73879379f, 0.07036904f, -0.51158851f, 
    -0.77845848f, 0.44479510f, -0.45361111f, -0.59131628f, -0.36005422f, -0.09000198f, 0.37576091f, -0.50537014f, 
    0.04231472f, -0.07403015f, -0.22500362f, -0.18330379f, 0.07888989f, -0.00452905f, 0.04014584f, 0.22850552f, 
    -0.13838023f, -0.22851017f, 0.22727299f, -0.12539847f, 0.93791115f, 0.76326203f, 0.38528910f, -0.13420436f, 
    -0.41450760f, -0.33854523f, -0.06280489f, -0.58786398f, 0.26209432f, 0.30052689f, 0.21702529f, -0.06282196f, 
    0.38147983f, 0.18864943f, -0.03146803f, 0.28302649f, -0.03316168f, -0.08912610f, 0.21333240f, -0.26687270f, 
    -0.03761487f, -0.24813491f, 0.17218482f, -0.25022885f, 0.31049642f, 0.70697647f, 0.45541206f, 0.67982942f, 
    0.69204348f, 0.74950641f, 0.47520009f, -0.31631127f, -0.59776068f, -0.18717411f, -0.44054249f, 0.07015022f, 
    0.15773654f, 0.10178303f, 0.13023645f, -0.14774336f, -0.10440013f, 0.21736971f, -0.12834612f, -0.24335717f, 
    0.20454052f, -0.12289301f, -0.06330327f, -0.13251846f, -0.27269882f, 0.31386760f, 0.60274446f, -0.35738367f, 
    -0.23360638f, -0.33114517f, 0.75000674f, -0.12487702f, -0.61626387f, -0.48203421f, -0.37072840f, 0.09042626f, 
    -0.07130501f, 0.48227572f, -0.06515640f, 0.01459703f, -0.03889038f, 0.22318558f, -0.09882356f, -0.07125961f, 
    0.39296889f, 0.37043157f, 0.28597170f, 0.00499621f, -0.45591092f, -0.38990176f, 0.28101346f, -1.08852184f, 
    -0.24362645f, 0.51872194f, 0.40211889f, -0.41563639f, 0.45630515f, 0.47988534f, 0.64228064f, 0.10892654f, 
    -0.56208694f, 0.11268751f, 0.04916533f, -0.11034068f, 0.25319430f, 0.03518121f, -0.21310000f, 0.07980277f, 
    0.08365277f, -0.24902886f, 0.03176846f, 0.15699318f, 0.23671313f, -0.07093553f, 0.22208172f, -0.35340354f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.22564891f, -0.03286833f, 0.15408169f, 0.07693282f, 0.13650404f, 0.07339329f, 0.30757725f, 0.21075383f, 
    0.26768991f, -0.00308291f, 0.33078536f, 0.15269749f, 0.18067162f, 0.27987814f, 0.09711485f, 0.14793330f, 
    0.17353615f, 0.05927427f, 0.14933676f, 0.10940177f, 0.21285737f, 0.28003952f, -0.08133958f, -0.01998825f, 
    0.23063374f, 0.26542342f, 0.16509107f, 0.00480427f, 0.31249431f, 0.15395398f, 0.08333581f, 0.20500989f, 
    0.16964708f, 0.08700553f, 0.31567472f, 0.01829229f, 0.27972913f, 0.27727240f, 0.01214176f, -0.06146305f, 
    0.05686112f, 0.25186571f, 0.05869853f, 0.20557356f, -0.16958827f, -0.01586775f, 0.27406693f, 0.27022967f, 
    0.12496825f, -0.02079574f, -0.03043900f, 0.15364303f, -0.10004041f, 0.18007684f, 0.15902090f, 0.09430050f, 
    -0.03933721f, -0.05901586f, 0.13315950f, -0.00585642f, 0.16504014f, 0.11755313f, 0.39523757f, 0.29294518f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.02761221f, -0.03148283f, 0.00464939f, 0.01222699f, 0.02575409f, -0.02538952f, 0.01322536f, -0.04079403f, 
    -0.02104679f, -0.00213508f, 0.01326872f, 0.01665523f, 0.02558789f, -0.01266580f, -0.00067752f, -0.00957661f, 
    0.02238890f, -0.02352376f, 0.02245488f, -0.02315865f, 0.00083154f, 0.02983725f, -0.01057219f, 0.02276503f, 
    -0.00664462f, -0.01027462f, -0.03273101f, 0.00141070f, -0.02508776f, 0.00263762f, 0.00491793f, 0.00027604f, 
    0.02664366f, -0.03229356f, -0.00580265f, -0.00812695f, 0.02393622f, 0.00890150f, -0.01305020f, 0.01930603f, 
    -0.00393396f, 0.00967355f, 0.02033195f, 0.02220399f, -0.02269346f, -0.03384253f, -0.01155313f, -0.01920053f, 
    -0.02684595f, 0.02700810f, 0.00253788f, -0.04155126f, -0.03067164f, -0.03095681f, 0.00538136f, -0.03515278f, 
    -0.00556611f, 0.01391277f, -0.02099527f, 0.00116186f, -0.03853964f, -0.03749321f, -0.02331897f, -0.01305298f, 
    -0.02559976f, 0.00085663f, 0.00496859f, -0.00191474f, -0.00058669f, 0.02366754f, 0.01778399f, -0.02594056f, 
    -0.03979599f, 0.01153158f, -0.03144471f, -0.03592839f, -0.01893662f, 0.01968959f, -0.01102770f, -0.00681129f, 
    0.00757963f, -0.03167769f, -0.03972368f, -0.02160255f, -0.02502993f, 0.02617247f, -0.00268324f, 0.03324104f, 
    -0.02750749f, -0.04093950f, 0.00451159f, -0.00986601f, -0.02728743f, -0.01079610f, -0.00046488f, -0.02860816f, 
    -0.02208314f, -0.02163662f, -0.03604307f, -0.03225608f, 0.00891352f, 0.01233917f, -0.00674608f, -0.01552763f, 
    -0.01177018f, -0.02991406f, -0.02419121f, -0.03764712f, -0.02742364f, 0.00369650f, -0.01573204f, 0.00883950f, 
    -0.04166379f, -0.01586477f, 0.00665032f, -0.01278501f, -0.00261289f, -0.03036333f, -0.02395753f, -0.02127132f, 
    0.01268471f, -0.03541761f, -0.00331825f, 0.01685211f, -0.00795600f, -0.01868814f, 0.02491976f, 0.00069928f, 
    0.00869390f, -0.02709045f, 0.01741064f, -0.01805753f, 0.01045862f, 0.00936261f, 0.00088995f, 0.00053462f, 
    -0.01502220f, -0.03930120f, -0.02153985f, 0.00446677f, -0.02422815f, -0.04069427f, 0.01377855f, -0.00195569f, 
    -0.00459708f, 0.00206666f, -0.02056465f, -0.02096648f, 0.02905974f, 0.02650422f, -0.03255863f, -0.00189168f, 
    0.02732822f, -0.02464231f, -0.01587904f, -0.02477874f, 0.00276949f, 0.02704145f, 0.00682940f, -0.03107397f, 
    -0.00719148f, 0.01469461f, -0.03066499f, -0.03884159f, -0.03342068f, 0.01835164f, 0.00162752f, 0.00372363f, 
    -0.02263038f, -0.00821962f, 0.00552320f, -0.03028004f, -0.03487889f, -0.01361722f, 0.01216964f, -0.03587704f, 
    -0.03623755f, 0.02282108f, -0.01325736f, -0.00789257f, -0.00691662f, 0.02023740f, -0.01333089f, -0.03049543f, 
    -0.00849892f, -0.02555976f, 0.01247796f, -0.02510985f, 0.02923037f, 0.00274782f, -0.03781639f, 0.02017692f, 
    -0.00200447f, -0.02529724f, 0.02316900f, -0.03312611f, -0.02152374f, 0.01042661f, -0.01104792f, 0.01924466f, 
    -0.00544290f, -0.02192520f, 0.00341796f, -0.00373819f, -0.00676866f, -0.00593036f, -0.00038354f, -0.03003090f, 
    0.00272454f, 0.00411431f, 0.00299025f, 0.00728849f, -0.04090402f, -0.02287465f, 0.00310674f, -0.02477389f, 
    -0.00402831f, -0.01099860f, 0.00659667f, 0.02700317f, -0.00962544f, 0.00511970f, 0.00903609f, 0.01644914f, 
    0.02762312f, 0.02699145f, -0.00524705f, 0.02462654f, -0.02365450f, 0.02859218f, -0.01999567f, -0.00783285f, 
    -0.01401179f, -0.00583277f, -0.02549979f, -0.03856708f, 0.01459243f, 0.00680010f, -0.04198647f, -0.01591174f, 
    -0.00932382f, -0.00836485f, -0.01756591f, -0.00027472f, 0.00269053f, 0.00909268f, 0.02155448f, -0.02841374f, 
    0.00574587f, -0.02828885f, -0.00994463f, 0.02964116f, 0.02782942f, -0.03357988f, -0.02826201f, -0.02571816f, 
    -0.02646664f, -0.01649247f, -0.03204726f, -0.03027091f, -0.03810158f, 0.00853626f, -0.01178931f, 0.00189978f, 
    -0.01078823f, -0.03186900f, 0.01427372f, -0.01293990f, 0.00945456f, -0.00028029f, 0.01106060f, 0.00920905f, 
    -0.04166221f, -0.00878023f, 0.01755084f, -0.00949752f, 0.02605685f, -0.02905614f, 0.00495925f, -0.00625275f, 
    -0.02976148f, 0.01502277f, -0.03790015f, -0.02597080f, -0.02921807f, -0.02831710f, -0.00548943f, 0.01854432f, 
    0.01070233f, 0.01571788f, 0.02939750f, -0.01177934f, 0.00465406f, 0.01687526f, 0.00776276f, -0.00520293f, 
    -0.04151963f, 0.02845177f, 0.00032100f, 0.00653597f, 0.02411833f, -0.01499254f, -0.02413961f, -0.01559950f, 
    0.02117367f, 0.00491179f, 0.02786610f, -0.00415006f, 0.01325953f, 0.00632625f, -0.01930496f, 0.02508650f, 
    -0.01912895f, 0.00915307f, -0.03009272f, -0.00560260f, -0.03208231f, 0.00645272f, 0.00309330f, 0.00439459f, 
    -0.00801508f, -0.03282733f, 0.00064448f, -0.02529854f, 0.02139755f, -0.01327347f, -0.00152931f, -0.04098438f, 
    -0.03677401f, 0.00856053f, -0.03399204f, -0.01173738f, -0.00503192f, 0.02289619f, -0.03754459f, 0.00055215f, 
    -0.03282939f, -0.03296097f, -0.02576727f, 0.00910458f, -0.02636601f, 0.01485388f, 0.01052485f, -0.02637228f, 
    -0.01700476f, -0.02467330f, -0.01878477f, 0.02758411f, 0.01441680f, -0.01007679f, -0.01057376f, -0.03671287f, 
    0.02606061f, 0.02733004f, -0.00681600f, -0.01965403f, 0.00173945f, -0.03982589f, 0.02434941f, -0.03574246f, 
    -0.00153401f, 0.00837112f, 0.01959792f, -0.02276419f, -0.02931517f, -0.01689347f, -0.00592413f, 0.01858712f, 
    0.01449342f, -0.03678205f, 0.02242835f, 0.00658482f, -0.01156241f, -0.02602139f, -0.02909228f, 0.02751347f, 
    -0.00001746f, -0.00657776f, 0.00686581f, -0.01540688f, 0.01612019f, 0.02507772f, -0.00850323f, -0.01492094f, 
    0.02398071f, 0.01912228f, 0.01548116f, -0.00883118f, 0.01554198f, -0.03289076f, 0.02791066f, -0.03119813f, 
    0.01534579f, -0.01889639f, -0.00230275f, 0.02502858f, -0.00728544f, 0.01221698f, -0.02019190f, 0.01172602f, 
    -0.01182969f, -0.03981891f, 0.02485749f, -0.02237068f, -0.03387603f, 0.01212320f, 0.02467970f, -0.03967372f, 
    -0.02632283f, -0.00968518f, 0.01383150f, -0.03460639f, -0.00844113f, -0.00326662f, 0.02721545f, 0.00769033f, 
    -0.00237342f, -0.03569295f, -0.00411001f, 0.02998853f, 0.02839428f, 0.01218088f, -0.00648829f, 0.01566353f, 
    0.02068367f, 0.01568603f, 0.02425904f, -0.00399606f, -0.00905752f, 0.02741762f, 0.02796027f, 0.00837336f, 
    -0.01874995f, -0.03944131f, -0.02696594f, -0.03477545f, -0.04045958f, -0.03144001f, -0.03290261f, 0.01628141f, 
    -0.00234898f, -0.00745361f, -0.03019223f, -0.02745771f, 0.01550144f, 0.00022673f, -0.03075578f, -0.02945774f, 
    -0.02818061f, -0.00135539f, -0.03997309f, -0.03748407f, 0.00534351f, -0.02243813f, -0.00061621f, -0.01635542f, 
    -0.01729267f, 0.00171505f, 0.01874080f, 0.02730985f, -0.01874622f, 0.00837523f, 0.01983501f, -0.01805242f, 
    -0.00182833f, 0.00125808f, -0.02758594f, -0.01546136f, -0.00966405f, -0.03104608f, -0.00252102f, 0.01534506f, 
    0.00498042f, -0.00463698f, -0.01821363f, 0.02973431f, 0.01641633f, -0.01989560f, 0.02807119f, 0.02830525f, 
    0.02944996f, -0.00444156f, -0.02781322f, 0.01285435f, -0.04151077f, 0.02827340f, 0.02425421f, -0.01052078f, 
    -0.02740396f, -0.01496048f, 0.02162770f, -0.02035604f, -0.02103010f, -0.00374148f, -0.00535459f, -0.03255932f, 
    -0.02127103f, -0.03280281f, -0.00702602f, -0.00007684f, 0.02361270f, 0.00479518f, -0.02612362f, -0.03435467f, 
    -0.00797167f, 0.01496872f, -0.01948260f, -0.00939219f, -0.03664177f, 0.02860145f, 0.01052966f, 0.02982213f, 
    -0.00164070f, -0.01197054f, -0.03754149f, 0.01167393f, 0.01484331f, -0.02644520f, -0.03291577f, -0.01384236f, 
    -0.02332704f, -0.01616557f, -0.00619427f, 0.01159579f, 0.02035047f, 0.02649279f, 0.01008937f, 0.01663241f, 
    0.04182476f, 0.04180795f, -0.02102183f, -0.03084787f, 0.03406217f, 0.01107374f, 0.00364714f, -0.02964978f, 
    0.02546834f, -0.02065221f, -0.02179223f, 0.02223464f, -0.01018760f, 0.01510738f, 0.00664654f, 0.02618731f, 
    -0.02338064f, 0.01453139f, 0.00554865f, -0.02870615f, -0.03138800f, 0.02044368f, -0.03686972f, 0.02326296f, 
    -0.00965323f, 0.01999411f, -0.02648033f, -0.02741265f, 0.02060890f, -0.03773098f, -0.00002844f, -0.04120957f, 
    -0.03438127f, -0.02676443f, -0.02513591f, 0.02952470f, 0.01641827f, 0.00361727f, -0.02463961f, 0.01530452f, 
    0.02140359f, -0.03500503f, -0.00314158f, 0.00166131f, -0.02521271f, 0.02003130f, -0.00354760f, 0.00715309f, 
    0.00375839f, -0.01009475f, 0.02319526f, -0.02640923f, -0.03533525f, 0.00663126f, 0.01676893f, -0.00712472f, 
    0.00396126f, 0.02595819f, -0.00696852f, 0.01235050f, 0.00348757f, 0.02531451f, 0.00473976f, -0.00979538f, 
    0.00653725f, -0.03088263f, 0.01249812f, 0.00763976f, 0.00787880f, -0.02337022f, 0.00792285f, -0.00782323f, 
    -0.00620028f, 0.01038196f, -0.03553663f, 0.00059092f, -0.02831724f, 0.00512670f, 0.02050508f, 0.00038226f, 
    -0.00165700f, 0.00616461f, -0.03105868f, 0.02936156f, 0.01502010f, -0.00311089f, 0.00049038f, -0.00139871f, 
    -0.02240892f, -0.02118125f, -0.03406795f, -0.02929768f, 0.02165180f, -0.02000698f, -0.00523217f, -0.03264074f, 
    0.01315057f, 0.02401036f, -0.03790378f, -0.01842142f, -0.03046354f, -0.02938595f, 0.01028459f, -0.02840233f, 
    0.02328937f, 0.01039072f, -0.02589131f, -0.01309277f, 0.01619480f, -0.01348753f, -0.02662820f, 0.02855417f, 
    0.00406419f, -0.00528450f, -0.04088606f, -0.00690416f, 0.00067620f, -0.00384843f, -0.02462859f, 0.01286165f, 
    -0.01964943f, 0.02880931f, 0.02754615f, 0.00394639f, 0.02373286f, -0.03066533f, 0.00504822f, 0.01994824f, 
    -0.00728488f, -0.01220591f, -0.02908494f, 0.02776705f, 0.00044291f, -0.00915783f, -0.02241707f, 0.02085679f, 
    0.00256836f, -0.02520573f, 0.02259181f, 0.02798743f, 0.01398625f, -0.01098926f, -0.01455592f, 0.03342430f, 
    -0.03046105f, 0.01649093f, 0.01338786f, -0.01770674f, 0.01667421f, -0.00480111f, -0.03144825f, -0.02898613f, 
    -0.04070426f, 0.00939771f, 0.02982433f, -0.03359362f, -0.02875868f, 0.02406329f, 0.00498717f, 0.00364203f, 
    -0.00935533f, -0.01193271f, 0.02238256f, -0.00286629f, 0.01823049f, 0.00199098f, 0.00318308f, -0.01226119f, 
    -0.01107553f, 0.00994757f, -0.03530398f, 0.01728770f, -0.01191910f, -0.00992288f, -0.01626111f, 0.03887078f, 
    0.02655228f, 0.00386716f, -0.02637465f, -0.02561988f, 0.02196196f, 0.03375473f, -0.00615187f, 0.01797089f, 
    -0.03889023f, -0.00675798f, 0.00435740f, 0.01501444f, 0.02248971f, -0.01274759f, -0.02572793f, -0.02377632f, 
    -0.02817488f, -0.02763539f, -0.03036406f, -0.02396728f, -0.00829450f, -0.03265633f, -0.00240174f, -0.00107902f, 
    -0.01345721f, -0.02315924f, -0.02514813f, 0.02885667f, -0.03176192f, -0.02639537f, 0.01261542f, 0.01595746f, 
    -0.03090310f, 0.02230380f, -0.03682169f, -0.02250568f, -0.04168579f, 0.02306908f, -0.03349837f, -0.02475879f, 
    -0.02968475f, -0.03300996f, 0.01896494f, -0.01947118f, -0.01149241f, -0.03236113f, -0.00049935f, 0.00573205f, 
    0.01527714f, 0.00504212f, -0.01546643f, 0.02148005f, 0.01826923f, -0.01186931f, 0.01949873f, 0.00567696f, 
    0.00926567f, 0.01165211f, -0.00472240f, -0.01928341f, -0.01954604f, -0.04206389f, 0.00998483f, -0.00556576f, 
    0.00861792f, 0.02539822f, -0.00894543f, 0.01505700f, -0.01839711f, -0.03746982f, -0.00418814f, -0.01971364f, 
    -0.00884410f, 0.02086318f, 0.02557255f, -0.03663254f, 0.02408434f, 0.02098775f, 0.02326883f, -0.01432106f, 
    -0.01374178f, -0.02222234f, -0.01628418f, -0.03238061f, -0.01905336f, -0.00141167f, -0.00219494f, 0.01868562f, 
    -0.01088364f, -0.00003310f, -0.02781904f, 0.01103512f, -0.00731620f, 0.01292118f, -0.03742285f, -0.03279159f, 
    -0.03727465f, -0.00892511f, 0.01937354f, -0.02014917f, 0.00154391f, -0.01527142f, 0.02369527f, -0.03271157f, 
    -0.03745463f, -0.01346100f, -0.00146195f, -0.03753655f, -0.00473604f, 0.00373912f, -0.03429925f, -0.00152664f, 
    -0.00345009f, -0.02883592f, 0.01470095f, -0.01154324f, -0.03153837f, -0.03162738f, -0.00113700f, 0.00498414f, 
    -0.01528373f, -0.00008947f, 0.02829141f, 0.00937649f, -0.00319496f, -0.03466751f, -0.00058421f, 0.01003055f, 
    -0.01869031f, -0.00777540f, -0.00243477f, -0.03613042f, 0.02878367f, -0.02637580f, 0.00664045f, -0.02681927f, 
    -0.02865035f, -0.01058526f, 0.01458606f, -0.01386526f, -0.03105667f, -0.03005012f, 0.00585083f, 0.02129879f, 
    0.00273745f, -0.00251374f, -0.00234471f, -0.01441749f, 0.01709231f, -0.03451392f, 0.01559599f, -0.03060737f, 
    0.00283035f, -0.00662540f, 0.01450750f, 0.01338215f, 0.00806373f, 0.02748294f, -0.00971038f, 0.02588777f, 
    -0.01087831f, 0.01044691f, 0.02079439f, 0.00019742f, -0.04017391f, -0.02530991f, -0.03378920f, -0.00184914f, 
    -0.00346642f, 0.02471886f, -0.03556896f, 0.02133844f, -0.01745152f, 0.00963115f, -0.02887939f, 0.02002497f, 
    0.02609524f, -0.01069755f, 0.02060724f, -0.03750382f, -0.00386147f, 0.02313551f, -0.03682872f, 0.00035509f, 
    0.01331090f, 0.03118972f, 0.01132618f, 0.03165079f, -0.00736791f, 0.01433030f, -0.00859560f, -0.00465984f, 
    0.00795633f, -0.00489909f, -0.02218430f, -0.03574046f, 0.01906970f, -0.02711672f, 0.00644976f, -0.02744057f, 
    -0.02742195f, -0.03264219f, -0.02068142f, -0.01751790f, -0.00986340f, -0.01907386f, 0.00992339f, -0.00827397f, 
    0.01138468f, 0.01570330f, -0.02839142f, -0.01998448f, -0.00185655f, 0.01912693f, 0.00956507f, 0.03459328f, 
    -0.01890384f, -0.02310986f, 0.01365177f, -0.00994372f, 0.02450570f, -0.00150072f, 0.00535349f, -0.03466893f, 
    -0.01272946f, -0.04021232f, -0.00862684f, -0.04156791f, -0.00728901f, -0.00324780f, -0.00184541f, -0.00717634f, 
    0.01194631f, -0.04179751f, 0.02947270f, -0.01226163f, -0.03211466f, 0.00003064f, -0.00881408f, -0.03880871f, 
    0.01887370f, -0.00020982f, -0.03858904f, -0.00315221f, 0.01500244f, -0.00952512f, -0.00786680f, -0.04190063f, 
    -0.00535401f, -0.02068420f, 0.00245710f, 0.01878043f, -0.01125896f, -0.01796814f, -0.01458781f, -0.01350574f, 
    0.00411367f, 0.02322660f, -0.00439628f, 0.00221139f, 0.01890654f, -0.00023543f, 0.01053187f, -0.03862634f, 
    -0.01349159f, -0.01319468f, -0.02050051f, -0.01750561f, -0.00093203f, 0.02042660f, 0.03213884f, 0.01199690f, 
    0.01972444f, -0.03423033f, -0.01829092f, 0.02617383f, -0.03693338f, 0.02960816f, -0.03966945f, -0.02905987f, 
    -0.01090466f, 0.00462196f, 0.02113300f, 0.01002371f, -0.02632950f, -0.01439399f, -0.02648097f, 0.02165878f, 
    -0.03015528f, -0.02334869f, -0.03895130f, -0.01501266f, 0.01271177f, -0.02488861f, 0.02203782f, 0.02570582f, 
    -0.02798416f, 0.01067066f, -0.01735478f, -0.04214130f, 0.02692582f, -0.03861789f, 0.01435198f, -0.00539998f, 
    0.00955063f, -0.02621295f, 0.02634611f, -0.01741458f, -0.02583860f, 0.02132788f, -0.02019251f, -0.03693794f, 
    -0.00324283f, 0.00948202f, 0.02968311f, -0.01702326f, 0.03043708f, 0.00440690f, -0.03092410f, -0.02164197f, 
    0.00009284f, -0.01060097f, 0.00088785f, 0.01385354f, 0.00584375f, -0.00341884f, -0.00640821f, -0.01562531f, 
    -0.02685983f, 0.03054463f, -0.00875313f, -0.03371703f, -0.01476107f, 0.00274627f, -0.02393986f, 0.01019439f, 
    0.01202197f, -0.01069630f, 0.00159213f, 0.00459325f, 0.02134117f, 0.02801708f, -0.01797961f, 0.00488891f, 
    0.00512705f, 0.02981773f, -0.03040285f, -0.03400246f, -0.02512836f, -0.00525045f, 0.02281681f, -0.00556098f, 
    -0.01121516f, -0.00909426f, -0.02607961f, 0.01451523f, -0.02390456f, 0.00714583f, -0.03381892f, 0.01889763f, 
    -0.03258795f, 0.01054620f, 0.01917958f, -0.02633288f, -0.02166324f, -0.00178586f, -0.04163071f, 0.01230806f, 
    0.01073537f, -0.01927673f, -0.02969462f, 0.00660043f, 0.01110815f, -0.04105387f, 0.00027834f, -0.00408069f, 
    -0.00944726f, 0.02843262f, 0.00183331f, -0.02947054f, -0.00240977f, 0.02687746f, -0.03025357f, 0.02552280f, 
    0.01370251f, 0.02448624f, -0.02082940f, -0.03573355f, 0.02035577f, 0.00582732f, -0.03617640f, 0.02736864f, 
    -0.02277898f, 0.00653430f, 0.02709263f, -0.03494076f, 0.02356976f, 0.00853165f, 0.00852488f, -0.02373422f, 
    0.00565015f, 0.00303540f, -0.02868190f, -0.01895825f, 0.00545093f, -0.00817239f, -0.01577218f, -0.01288336f, 
    0.00909782f, 0.00780781f, 0.00345057f, -0.03069827f, -0.00861677f, -0.00892539f, 0.02175480f, 0.02999833f, 
    0.00050338f, 0.02893522f, 0.02391370f, -0.03649420f, -0.01008896f, -0.02621300f, 0.02377742f, -0.01907138f, 
    -0.02465884f, -0.03908810f, -0.01935686f, 0.01335689f, -0.00989546f, 0.00263404f, 0.02859932f, -0.02785654f, 
    0.00760141f, -0.03630047f, -0.03422838f, -0.01044433f, 0.01819703f, -0.01244834f, -0.01721116f, 0.01036465f, 
    -0.02648031f, -0.00535539f, -0.00346688f, -0.02708881f, -0.03703134f, -0.03042960f, -0.03075927f, 0.00690459f, 
    -0.01287371f, -0.01526204f, 0.03232438f, -0.02480654f, -0.00298333f, 0.03447817f, -0.00308145f, -0.01050624f, 
    -0.02845649f, 0.01626574f, 0.00434561f, 0.00152941f, -0.02729523f, -0.00575998f, -0.00095313f, -0.00640010f, 
    -0.03412271f, 0.02810257f, 0.02518889f, 0.00878996f, -0.01934071f, -0.00004324f, -0.03308123f, 0.01965862f, 
    0.02761638f, 0.01615575f, 0.01171425f, 0.01644077f, 0.02975687f, -0.01302652f, 0.00301478f, -0.00789203f, 
    0.02030883f, 0.02966310f, -0.04214621f, -0.00910812f, 0.00122835f, 0.03173194f, -0.02473423f, 0.00646496f, 
    0.01749020f, -0.00063919f, -0.00417747f, 0.02410402f, -0.02356523f, 0.00703958f, -0.01081715f, 0.01123307f, 
    -0.00805976f, 0.02082618f, -0.02166912f, 0.02466469f, 0.00012345f, -0.03828988f, -0.02428534f, -0.03465839f, 
    0.00573004f, -0.00496286f, 0.00361412f, 0.01839003f, -0.03386746f, 0.03059044f, -0.02469655f, 0.02818314f, 
    0.02853223f, 0.00867527f, -0.00095548f, 0.02761582f, 0.02513023f, -0.01834984f, 0.02589319f, 0.02413085f, 
    -0.01946450f, 0.02574926f, -0.03284696f, 0.00239448f, -0.02291862f, -0.00275771f, 0.00652251f, -0.00197933f, 
    0.02069165f, -0.01512590f, -0.01463389f, -0.00082327f, -0.03291382f, 0.02262437f, 0.00528666f, -0.01318547f, 
    0.03003536f, -0.00928878f, 0.00209341f, -0.03795004f, 0.00579999f, -0.01582931f, -0.02521727f, -0.02774924f, 
    0.02966796f, 0.02529752f, -0.02981103f, 0.01214690f, 0.01967922f, 0.02928074f, -0.00868931f, -0.02726432f, 
    0.00215755f, -0.01991071f, -0.02866791f, 0.00865538f, -0.01380198f, -0.04297949f, -0.01435153f, -0.02771514f, 
    -0.01051166f, -0.03729283f, -0.00962263f, -0.02339758f, 0.00638487f, -0.03512101f, 0.01669082f, -0.03492223f, 
    -0.02650901f, -0.00561959f, 0.02646628f, -0.02122114f, -0.02417423f, -0.02148136f, 0.02213586f, -0.00591679f, 
    -0.00002495f, 0.00455341f, -0.01291903f, -0.01905799f, -0.01586849f, -0.01545957f, 0.03166861f, -0.03626841f, 
    0.00820752f, -0.03962231f, 0.02250200f, 0.00278461f, -0.00277833f, -0.00526311f, 0.00877673f, -0.03282622f, 
    0.01278919f, -0.01208215f, -0.01003477f, 0.00030811f, 0.02519798f, -0.02375121f, -0.03316101f, -0.02852741f, 
    -0.02100054f, -0.01756703f, 0.01855845f, -0.02061415f, -0.01074861f, 0.01163127f, 0.02695561f, 0.01803906f, 
    -0.02640813f, 0.00740077f, -0.00000226f, -0.02712998f, -0.01569994f, -0.02299307f, -0.01536331f, 0.01292842f, 
    -0.00135151f, -0.03288382f, -0.01299248f, -0.01813162f, 0.02653416f, -0.03998681f, 0.02046132f, -0.03170441f, 
    -0.02728430f, 0.01172311f, -0.02592794f, -0.00356241f, 0.00870446f, -0.00387005f, -0.02573203f, 0.01201670f, 
    0.01979699f, 0.01946460f, -0.02870962f, -0.01517278f, -0.00598514f, -0.01861959f, -0.00206622f, 0.03131105f, 
    0.02084589f, -0.02441462f, -0.01082488f, 0.01213315f, -0.02001476f, -0.04172550f, -0.00566005f, -0.02302960f, 
    0.02658403f, 0.02590571f, -0.01948367f, -0.00694553f, -0.00579384f, 0.01482440f, 0.02395965f, 0.01561724f, 
    -0.02379325f, -0.04063474f, -0.03939188f, 0.00131591f, -0.01036811f, -0.04091243f, -0.01073762f, 0.01113500f, 
    0.00289973f, 0.01614701f, -0.01249297f, -0.03399464f, 0.02367486f, 0.02767720f, -0.03254848f, 0.01618722f, 
    0.01364890f, -0.01860568f, -0.02717443f, 0.00509314f, 0.01214763f, -0.01572170f, -0.03675260f, 0.00681815f, 
    -0.00465524f, -0.02376246f, 0.02941496f, -0.00141792f, -0.00646827f, 0.01458647f, 0.01091114f, -0.02001624f, 
    -0.00066921f, -0.01624376f, -0.03227401f, -0.01108539f, 0.01210893f, -0.00683461f, 0.01946497f, -0.02964958f, 
    -0.02564820f, 0.02200644f, -0.02993888f, -0.01268109f, -0.00366027f, 0.02896304f, -0.03672063f, -0.02319861f, 
    0.00729427f, 0.00287418f, 0.00901461f, -0.00182727f, -0.01433537f, -0.00423930f, 0.02801871f, -0.03150261f, 
    -0.02965439f, -0.00867386f, 0.00857464f, -0.03335761f, -0.02939492f, -0.03722135f, -0.00663657f, 0.00435448f, 
    0.01224919f, 0.00567668f, -0.00944276f, 0.01669532f, 0.00917560f, 0.00706293f, -0.00524655f, 0.01391268f, 
    0.01445605f, 0.00827696f, -0.00925805f, 0.02725262f, -0.01902741f, -0.03060447f, -0.02753047f, -0.04180494f, 
    -0.00862237f, 0.01529482f, 0.02712612f, 0.01585934f, -0.01800059f, 0.01013976f, -0.01013096f, 0.00681313f, 
    -0.00432312f, -0.00136426f, 0.00070360f, -0.03216996f, 0.00246586f, 0.00388732f, 0.00493024f, -0.01161159f, 
    -0.01085332f, -0.01845489f, -0.00911077f, 0.01772045f, 0.01600611f, 0.00686947f, -0.02226915f, 0.00016111f, 
    -0.00570647f, -0.00780441f, -0.01391448f, 0.00249742f, -0.03592262f, 0.02060213f, 0.01873314f, -0.03301545f, 
    -0.01249188f, 0.01680708f, -0.03952285f, 0.02093032f, 0.03791974f, -0.03940735f, -0.02735377f, -0.02914202f, 
    0.02929846f, -0.00056544f, 0.02089456f, -0.01378497f, -0.03719362f, -0.02306103f, -0.00049366f, 0.00496777f, 
    0.02146648f, 0.02740256f, -0.01290937f, -0.01175904f, -0.03166901f, 0.00625002f, 0.00970340f, -0.01972092f, 
    -0.02062297f, 0.01486517f, -0.02541295f, -0.03306883f, 0.00602054f, -0.03478247f, 0.02146383f, 0.01837547f, 
    -0.02443137f, 0.01792892f, 0.01328940f, 0.00920259f, 0.00604232f, -0.01874096f, -0.02005368f, -0.00503983f, 
    0.02188999f, 0.00360653f, -0.03513674f, 0.02106305f, -0.02850933f, 0.00475081f, 0.02205803f, 0.02549761f, 
    -0.00859255f, -0.00076155f, -0.02022601f, 0.02732503f, -0.00790324f, -0.00504598f, -0.03987138f, -0.00852228f, 
    0.00714151f, -0.01004424f, 0.02139120f, 0.00170569f, -0.01389835f, 0.01969392f, 0.01622747f, -0.00903224f, 
    -0.02272875f, -0.01478556f, -0.00965501f, 0.02873862f, 0.02648023f, -0.01765998f, -0.00753331f, 0.00972632f, 
    -0.01200872f, 0.00143904f, -0.03110966f, -0.00100425f, -0.00814388f, -0.02032540f, 0.02481112f, -0.02823403f, 
    -0.03229453f, 0.02499890f, -0.01867260f, 0.01935769f, 0.01843048f, 0.01969646f, -0.03621241f, -0.03799035f, 
    0.01710296f, -0.03361178f, 0.00659871f, -0.01234611f, -0.03017300f, -0.02329926f, -0.00215648f, -0.01887346f, 
    -0.01237846f, -0.02428201f, 0.01865991f, -0.02803839f, 0.00830856f, -0.03606755f, -0.03767159f, -0.01097301f, 
    -0.02285131f, -0.02022791f, -0.02297482f, -0.00544126f, -0.00883407f, 0.01633143f, 0.00766681f, -0.01426686f, 
    -0.03092360f, -0.00077933f, 0.00877339f, -0.02383447f, -0.03184502f, 0.01896188f, -0.02339248f, -0.03479382f, 
    0.00820557f, -0.00536041f, -0.02852852f, 0.00366745f, -0.03031855f, -0.03096013f, 0.02110036f, -0.00097192f, 
    0.00949417f, -0.00450295f, -0.03867747f, -0.03697499f, -0.01249607f, -0.03189874f, -0.03550908f, -0.00391655f, 
    0.00683089f, -0.02990517f, -0.00407792f, -0.01998240f, -0.00119232f, 0.00235353f, -0.00839603f, 0.00513648f, 
    -0.03337126f, 0.00725617f, -0.02258324f, -0.01155603f, -0.02603403f, -0.01804305f, -0.02170782f, -0.01670604f, 
    -0.00414211f, 0.02728321f, 0.00283376f, 0.02479345f, -0.02057025f, 0.01449643f, -0.02974223f, -0.00572914f, 
    -0.01450580f, -0.04206568f, -0.00581992f, -0.03547903f, -0.00592983f, 0.00268228f, -0.00084974f, -0.00792245f, 
    -0.02619573f, 0.02360188f, 0.02417804f, -0.02210066f, 0.01820435f, -0.02588539f, 0.02662183f, 0.02081652f, 
    -0.02847986f, 0.02126727f, -0.00899713f, -0.01404437f, 0.02961909f, -0.01273435f, 0.00757304f, -0.04123962f, 
    0.00492291f, 0.00018336f, 0.00060648f, -0.03373185f, -0.02640392f, 0.02642467f, 0.00592069f, 0.00094712f, 
    -0.01816302f, -0.04099591f, -0.03884272f, -0.00378770f, 0.01217845f, 0.02310495f, -0.01792354f, 0.01710988f, 
    -0.03495566f, -0.03351244f, -0.01235734f, 0.02782207f, 0.00915891f, 0.02881732f, 0.00601335f, -0.03222937f, 
    -0.01949561f, 0.02644899f, 0.01763933f, 0.01882622f, -0.01338682f, -0.02972935f, 0.01342168f, -0.01857704f, 
    0.00804321f, 0.00412233f, -0.00369570f, -0.00135332f, -0.03046006f, -0.00953879f, -0.03960035f, -0.00891436f, 
    0.00021223f, -0.02147691f, -0.03194051f, -0.00999254f, 0.00655177f, 0.00104840f, 0.01107179f, 0.00412147f, 
    0.01888825f, -0.02419514f, -0.02952601f, 0.00906636f, 0.00088885f, -0.00046433f, -0.03750700f, -0.02840448f, 
    -0.03466882f, -0.01301577f, 0.01214457f, -0.01150989f, 0.00455778f, 0.01842848f, -0.02851531f, 0.00635775f, 
    -0.00180293f, 0.01810298f, 0.02284234f, 0.00114158f, 0.01806854f, -0.00275320f, -0.00677236f, -0.01747393f, 
    0.01938533f, -0.04129079f, 0.02744781f, 0.00739149f, 0.01551011f, -0.04037717f, 0.02769955f, -0.01249096f, 
    -0.01720535f, -0.00664076f, 0.00672475f, -0.00739884f, 0.01284996f, -0.03876851f, 0.00032023f, -0.02608184f, 
    0.00756416f, -0.01441101f, -0.00926118f, -0.01852043f, -0.00810648f, 0.00196913f, -0.01166387f, -0.03343949f, 
    -0.02358028f, 0.01508402f, -0.01936139f, -0.01354767f, 0.02803872f, -0.03272886f, -0.02461175f, -0.02244263f, 
    -0.02732173f, 0.01512817f, -0.00980318f, 0.00393897f, 0.00432887f, 0.02064483f, -0.00667723f, -0.02237859f, 
    -0.00278528f, -0.02017182f, 0.01446593f, 0.02574222f, -0.01347522f, 0.00512311f, -0.03745757f, 0.01896495f, 
    -0.03717932f, -0.03412858f, 0.00167150f, 0.02602217f, -0.02435362f, -0.00435661f, -0.02521378f, -0.00093217f, 
    -0.00597718f, -0.01407285f, -0.02013683f, -0.00364499f, -0.02951671f, -0.01943874f, -0.00834798f, 0.00719196f, 
    0.01367754f, 0.02749564f, -0.02567274f, -0.00864011f, 0.02546799f, 0.01694822f, -0.03381921f, -0.00600837f, 
    -0.02914133f, 0.01702143f, 0.01108123f, -0.02262412f, -0.02201904f, -0.01159279f, -0.03395341f, -0.02832258f, 
    0.00740252f, 0.00841096f, 0.00284717f, -0.01745357f, -0.03658026f, 0.02811256f, 0.00217690f, 0.02971437f, 
    0.02727177f, -0.02433773f, 0.00359762f, -0.02167769f, -0.00661658f, 0.01169943f, -0.03200905f, 0.00202383f, 
    0.02319200f, -0.02861186f, -0.00918765f, 0.00838682f, -0.00116469f, 0.01238856f, 0.01278192f, -0.02961702f, 
    0.01625837f, 0.02822986f, 0.01098247f, -0.01874683f, 0.02869126f, -0.02667602f, -0.00063345f, 0.01644409f, 
    0.00495745f, -0.01225653f, -0.00343913f, -0.00109789f, -0.04142299f, -0.00109451f, -0.04207192f, -0.03634737f, 
    0.00617711f, -0.00129729f, -0.02700253f, 0.00216065f, -0.01471062f, -0.02260675f, -0.01126496f, -0.02132132f, 
    -0.02155888f, -0.01527291f, -0.03930095f, 0.00817184f, -0.00254534f, -0.03852319f, 0.02799094f, -0.02346940f, 
    -0.03767165f, 0.00599321f, -0.02806932f, -0.03572275f, 0.00308242f, 0.02318696f, -0.03936502f, -0.02380826f, 
    -0.01282837f, -0.04184392f, 0.01482954f, 0.01142942f, -0.03584504f, 0.01847744f, 0.01113919f, -0.01697368f, 
    0.00408735f, 0.00216486f, -0.02539045f, 0.01254938f, -0.00420091f, 0.02948358f, 0.00869185f, 0.02716559f, 
    -0.02239128f, 0.01360437f, 0.01031283f, -0.00909381f, 0.01418258f, -0.01857040f, -0.03790296f, 0.00954592f, 
    0.00470035f, 0.01961349f, 0.02734496f, -0.00279794f, -0.03406289f, -0.01912311f, -0.03545536f, 0.02154794f, 
    -0.02784692f, -0.00871573f, -0.02659615f, -0.02311368f, 0.00201979f, -0.02441079f, -0.01398707f, -0.00522895f, 
    -0.01315606f, -0.03615708f, -0.00572929f, -0.03998829f, 0.00558847f, 0.01795715f, -0.03930443f, -0.02173714f, 
    0.02800041f, 0.01364992f, -0.03904521f, -0.03058677f, 0.00001253f, -0.01174502f, -0.01743351f, -0.03284661f, 
    -0.01996938f, -0.00206345f, -0.02062846f, -0.00389607f, -0.03947294f, -0.00203347f, -0.01297462f, -0.00393249f, 
    -0.02967666f, 0.00864290f, -0.02550184f, 0.00631893f, 0.02725094f, -0.03648704f, -0.03393764f, -0.00643065f, 
    0.00678302f, 0.02510591f, 0.00950102f, 0.02653530f, 0.00194112f, 0.00643450f, -0.02258538f, -0.00709129f, 
    -0.02363608f, -0.01543477f, -0.02610277f, -0.01233771f, -0.01666337f, -0.01297702f, -0.03546115f, -0.00962068f, 
    0.01592583f, 0.02035893f, 0.03475464f, -0.03800568f, -0.01171408f, 0.01784878f, -0.02614356f, -0.03312453f, 
    -0.01185500f, -0.02779075f, 0.02957575f, 0.01237000f, 0.00302292f, -0.02142418f, -0.03954869f, -0.02740195f, 
    0.01343694f, -0.02584777f, 0.00945403f, 0.00356127f, 0.01371924f, -0.00952106f, 0.00118788f, 0.02512700f, 
    0.02464954f, 0.00812055f, 0.00362528f, 0.01011054f, -0.03513020f, -0.01508884f, -0.02847807f, -0.00216599f, 
    -0.03512761f, 0.02512844f, -0.01151719f, -0.01782970f, 0.02398633f, -0.00896397f, -0.01034547f, 0.02994840f, 
    0.01152312f, 0.02470960f, -0.01761405f, -0.03105146f, -0.01163071f, 0.00069196f, -0.02903602f, -0.01318177f, 
    0.01102186f, -0.02362050f, -0.00782918f, -0.02551771f, 0.00182036f, 0.02027827f, -0.04020511f, -0.02581305f, 
    0.02100528f, -0.03216752f, -0.02196433f, 0.02974773f, -0.02864897f, 0.01800483f, 0.01014933f, -0.02087371f, 
    -0.02371917f, -0.00022002f, 0.01784917f, -0.03933856f, 0.01353066f, 0.00888486f, -0.02643150f, -0.00226639f, 
    0.01217661f, -0.00233144f, 0.01253478f, -0.03818070f, -0.02423002f, 0.00013508f, 0.00815332f, -0.01253497f, 
    -0.03193626f, 0.00650574f, -0.01554134f, -0.01508628f, -0.00358487f, 0.00122359f, -0.00820459f, 0.00698479f, 
    -0.03600859f, 0.01473794f, -0.00840000f, -0.00826810f, -0.02467561f, 0.00315655f, 0.00628831f, -0.00712587f, 
    0.00753771f, 0.00159449f, 0.00480823f, -0.01942439f, -0.01143033f, -0.02402874f, -0.01038821f, -0.02009731f, 
    0.00881209f, -0.02758494f, 0.00140621f, 0.02223411f, -0.01798806f, -0.01815528f, 0.00032417f, 0.02726880f, 
    -0.00258361f, 0.00524270f, -0.01486286f, 0.01855450f, 0.01127611f, -0.01215117f, 0.02223760f, -0.00825932f, 
    0.01193717f, -0.02955503f, 0.00868753f, 0.01489624f, -0.01734695f, 0.00119758f, -0.02417547f, -0.00462860f, 
    -0.01663812f, 0.02545507f, 0.00190463f, -0.03532197f, -0.00434550f, -0.00718939f, -0.01456380f, -0.02049884f, 
    0.00772943f, 0.02796279f, -0.01405646f, 0.00485886f, -0.04200556f, 0.00042557f, 0.00459051f, 0.01395337f, 
    0.02462739f, -0.01340141f, -0.00431021f, -0.00874441f, -0.00197452f, 0.00035326f, -0.00984284f, 0.00242139f, 
    -0.00289239f, -0.01241100f, 0.02106032f, 0.01431714f, 0.00784991f, -0.00151829f, -0.03101564f, -0.00373599f, 
    -0.03267438f, -0.00125373f, 0.00238265f, -0.00451264f, -0.02699703f, -0.00737091f, 0.00987486f, -0.00972143f, 
    -0.01775915f, -0.03408829f, 0.00457506f, 0.01500532f, 0.01885067f, 0.02932137f, -0.02530437f, -0.00286827f, 
    -0.00201745f, 0.02266590f, -0.00816289f, -0.02251408f, 0.01846326f, 0.00580750f, -0.01193484f, 0.02570357f, 
    -0.03842457f, 0.00498698f, 0.00814879f, -0.03757543f, 0.00660789f, -0.01832211f, -0.02521998f, 0.01512585f, 
    -0.03368103f, -0.01411622f, -0.03512524f, -0.01802780f, -0.01429263f, 0.01087118f, -0.01095442f, 0.01933093f, 
    -0.00524480f, -0.03434890f, 0.02234267f, 0.01920237f, 0.02506308f, 0.02775541f, -0.02210326f, -0.03088433f, 
    -0.00923657f, 0.00692343f, -0.03136489f, 0.00064688f, -0.02791055f, -0.04086662f, -0.00852516f, 0.02054772f, 
    -0.00348334f, 0.02368045f, -0.02288781f, -0.03599349f, -0.00390211f, 0.00566629f, 0.00934731f, -0.02508308f, 
    -0.03559478f, -0.03424111f, -0.03745754f, 0.00437993f, 0.01120056f, -0.01709143f, -0.00582863f, -0.02676001f, 
    0.00571381f, -0.00645900f, 0.02987994f, 0.00297743f, -0.03200335f, -0.03267204f, -0.01033965f, 0.00845450f, 
    -0.01458083f, -0.02237990f, 0.02786370f, -0.03740709f, -0.02882131f, -0.02782951f, -0.01103789f, -0.01773302f, 
    0.00202325f, -0.01968988f, -0.03801839f, 0.02223796f, -0.02618453f, 0.00699280f, -0.00007298f, -0.00056149f, 
    -0.04206400f, 0.01925078f, 0.02100965f, 0.02673858f, -0.00510933f, 0.02991181f, -0.00529448f, -0.02108063f, 
    0.02429527f, -0.01073218f, 0.00389029f, -0.03256095f, -0.02200743f, -0.01171260f, 0.00921942f, -0.00137141f, 
    0.01201390f, 0.00943689f, 0.00894997f, -0.00987646f, 0.00904561f, 0.02626203f, -0.01128853f, -0.03523717f, 
    -0.00876549f, -0.00585724f, -0.00851534f, -0.00073502f, -0.03189896f, -0.03752498f, -0.02726123f, 0.01223900f, 
    0.02247312f, -0.03617835f, -0.01117533f, -0.01757020f, -0.00653485f, 0.02458870f, -0.03233562f, 0.00231164f, 
    0.01188492f, 0.01298602f, 0.00688624f, -0.03427736f, -0.00152119f, -0.02852244f, 0.00498358f, -0.01466055f, 
    -0.04139043f, 0.00597034f, 0.02917169f, 0.00522466f, 0.00615845f, -0.01601505f, 0.01644437f, -0.01018098f, 
    -0.03665194f, -0.01546289f, 0.02593552f, 0.02365161f, -0.00401448f, -0.02873033f, 0.02295928f, 0.00158655f, 
    -0.02132260f, -0.02118967f, 0.02489489f, -0.02106008f, -0.01897524f, -0.03254710f, -0.03540167f, -0.03233384f, 
    0.00136315f, -0.04173769f, -0.01462717f, -0.02521162f, -0.00796600f, -0.02713239f, -0.00946231f, 0.01521359f, 
    -0.01552149f, 0.00713587f, -0.03852633f, -0.01957875f, 0.02927403f, -0.01938486f, -0.02693025f, -0.00993902f, 
    0.10723270f, -0.10177415f, 0.01806786f, 0.27237794f, 0.00210628f, -0.11708530f, -0.04704107f, 0.07168918f, 
    -0.12642668f, -0.01686894f, -0.02559409f, 0.00810196f, 0.14718072f, 0.08225608f, -0.08498900f, -0.04086123f, 
    -0.03349246f, -0.00874424f, -0.15386513f, 0.03165145f, 0.05193501f, 0.03940314f, 0.12566970f, -0.02285230f, 
    -0.07735721f, -0.04400110f, 0.01211581f, 0.08187632f, 0.05480583f, -0.04916058f, 0.02885363f, 0.03745735f, 
    0.03460456f, 0.03512837f, -0.00602600f, 0.05568440f, -0.04376172f, -0.07623978f, 0.00704266f, 0.03492820f, 
    -0.02792668f, 0.00570311f, 0.06312615f, -0.03318439f, -0.00840310f, -0.11701174f, -0.09679869f, 0.15806414f, 
    0.20299798f, 0.08875767f, -0.07089591f, -0.23515733f, 0.01247672f, 0.15163249f, -0.00013419f, 0.08111539f, 
    -0.08576201f, 0.00973884f, 0.16225347f, -0.02777185f, 0.20874807f, 0.09086839f, -0.12892449f, 0.09022909f, 
    -0.00329906f, 0.01825009f, 0.04992006f, 0.09018780f, -0.13836868f, -0.07650459f, 0.10807519f, -0.08492311f, 
    0.05048825f, -0.08183718f, 0.05308119f, -0.24213886f, 0.07522605f, -0.07031871f, 0.06376588f, -0.11525016f, 
    0.00196401f, -0.02011101f, 0.13250917f, 0.05635856f, -0.10621497f, -0.01821817f, -0.10022966f, -0.26673388f, 
    0.21789652f, -0.00384577f, 0.04786232f, 0.04779100f, -0.11115310f, 0.03446862f, -0.05140853f, 0.03332704f, 
    0.24293639f, -0.24082914f, -0.11650060f, 0.11580051f, 0.00709789f, 0.06412721f, 0.06688351f, 0.05623204f, 
    0.09506645f, -0.07387076f, -0.11964881f, 0.08394331f, 0.07854398f, 0.06322523f, 0.05358998f, 0.43302503f, 
    -0.08406430f, -0.02733139f, 0.01624506f, 0.14066871f, -0.06861311f, 0.06177692f, -0.06366824f, 0.12202951f, 
    -0.10161863f, 0.15296207f, 0.01438967f, -0.23165269f, 0.10945611f, -0.02438923f, 0.01241955f, -0.01156812f, 
    -0.02258400f, -0.02556159f, -0.16683614f, -0.05389590f, -0.02709366f, 0.00538113f, 0.10536624f, 0.16655123f, 
    -0.00850029f, -0.14499108f, 0.01360001f, 0.07796977f, -0.02363485f, -0.02334351f, 0.09481619f, 0.12359634f, 
    0.14169228f, 0.00907422f, 0.00109430f, 0.09030880f, 0.14483695f, -0.00898457f, -0.03221445f, 0.06759743f, 
    -0.12591240f, 0.02293239f, -0.00962280f, -0.02052673f, 0.02281692f, 0.05422061f, -0.08596060f, 0.09279334f, 
    0.05987808f, 0.08069154f, -0.00276553f, 0.04762237f, -0.07005682f, -0.05430056f, 0.04525950f, -0.04896518f, 
    0.09621375f, 0.07455593f, 0.01854664f, 0.06001914f, 0.00058389f, -0.00967887f, 0.01548519f, -0.15145448f, 
    -0.05158349f, 0.02087809f, -0.12170512f, 0.10116635f, 0.44545007f, -0.01270123f, 0.01542476f, -0.03389385f, 
    -0.12229909f, 0.05182667f, 0.06073790f, 0.03576927f, -0.04653237f, -0.06742401f, 0.00454181f, -0.03162395f, 
    -0.08994889f, 0.18786106f, 0.03981285f, -0.10423110f, 0.06782252f, 0.10463583f, 0.15828566f, 0.09193937f, 
    0.03461210f, -0.03872896f, 0.01000822f, 0.04635346f, 0.02877991f, -0.09130038f, 0.10152277f, -0.13235040f, 
    -0.08416131f, 0.02634107f, 0.15309353f, 0.03675884f, -0.07610926f, -0.06672724f, -0.06723290f, -0.07676829f, 
    0.19272970f, 0.01069774f, -0.03298233f, -0.08189194f, -0.05072849f, 0.09053674f, 0.02194374f, -0.03872640f, 
    -0.08366650f, -0.10632765f, 0.10780087f, -0.06297504f, -0.20425664f, -0.20703116f, -0.02929743f, 0.01584728f, 
    0.14812577f, 0.09612539f, -0.00734368f, -0.06644626f, 0.12924336f, 0.00026154f, 0.07845751f, 0.03011764f, 
    -0.03820245f, 0.13584065f, -0.07307184f, -0.27991986f, 0.13349067f, -0.00806834f, -0.03371693f, -0.00859566f, 
    0.01359409f, -0.03404870f, 0.12571532f, -0.03132999f, 0.25194108f, -0.12630896f, -0.05260918f, 0.29633838f, 
    0.01134830f, 0.03965636f, -0.03038873f, -0.02097548f, -0.08492371f, 0.08973017f, 0.03009965f, 0.00904014f, 
    0.38717946f, -0.18661736f, 0.22047554f, 0.01717044f, -0.03360076f, -0.02788329f, 0.04092323f, 0.09332792f, 
    0.06467073f, 0.12860610f, 0.02437406f, -0.01940960f, 0.14831497f, 0.01217773f, 0.07488628f, 0.09150044f, 
    0.07205100f, -0.13066022f, 0.09154734f, 0.01260482f, -0.20904815f, -0.11375733f, -0.04559095f, -0.15216203f, 
    0.29269624f, -0.07069663f, -0.10865504f, -0.04303718f, -0.11535572f, 0.04414745f, -0.04327387f, 0.08405500f, 
    0.01542245f, -0.09814110f, 0.06429667f, -0.03518395f, -0.07623737f, 0.36102527f, 0.03111973f, -0.11528432f, 
    0.07095934f, 0.05965501f, -0.03361152f, -0.05714842f, -0.02568396f, -0.06097482f, -0.00982432f, -0.14467484f, 
    0.18462987f, -0.04775622f, 0.13867725f, 0.07377495f, 0.12969694f, -0.07525478f, 0.04555673f, -0.05388048f, 
    -0.02357893f, 0.03741914f, 0.06051316f, -0.06623664f, 0.01281071f, 0.24239327f, -0.06836305f, -0.15341520f, 
    0.06462330f, 0.04042168f, 0.02131429f, 0.03169683f, -0.00802609f, -0.08820421f, 0.03365302f, -0.03685497f, 
    -0.20533580f, -0.03328953f, -0.19763063f, 0.13002919f, 0.00255000f, 0.07984340f, 0.03845291f, -0.01384581f, 
    0.04514504f, 0.05894963f, 0.22542895f, 0.13614570f, 0.13769723f, 0.03866351f, -0.12667795f, -0.18616682f, 
    0.07732215f, 0.21236715f, -0.06185201f, 0.12115361f, 0.06919501f, -0.01328091f, -0.04717522f, -0.07796332f, 
    0.00876713f, 0.09549805f, 0.05163828f, 0.14646126f, 0.00865988f, -0.13500978f, -0.09628829f, 0.03380439f, 
    -0.02876811f, 0.06252842f, -0.07772946f, -0.06329857f, 0.00406751f, -0.11443726f, 0.10487101f, 0.19866426f, 
    -0.06940465f, -0.00586009f, 0.06855619f, 0.02216350f, -0.08972021f, -0.11822423f, -0.03016401f, -0.09976798f, 
    -0.21623372f, -0.06151661f, 0.16538233f, 0.18866245f, 0.03554016f, 0.03743349f, 0.04602050f, -0.08050819f, 
    0.05009592f, 0.15359427f, 0.04603011f, -0.00484987f, 0.29030195f, 0.11167359f, 0.05704590f, -0.12900423f, 
    0.03052807f, 0.28054190f, 0.00615965f, 0.05120919f, 0.02884637f, -0.05107527f, 0.07564623f, -0.15531997f, 
    -0.20806640f, 0.14083147f, 0.11464069f, 0.18848848f, 0.09333489f, 0.02874373f, -0.07955004f, 0.00254290f, 
    0.07996061f, -0.05757327f, -0.07410566f, -0.07953377f, -0.04134448f, -0.00510312f, 0.09140150f, -0.19158851f, 
    0.06827663f, -0.01980357f, 0.06911079f, 0.09181913f, -0.05105891f, 0.04186298f, -0.05141008f, -0.22294961f, 
    -0.28015432f, -0.10552953f, 0.07305101f, 0.21554315f, 0.11551245f, 0.08781392f, -0.05970453f, -0.02258996f, 
    -0.12466390f, -0.13018003f, 0.02524088f, -0.01062923f, -0.25230986f, 0.10429072f, -0.01593650f, -0.03403456f, 
    0.06215908f, 0.00108402f, 0.00936149f, -0.03352788f, -0.01796894f, -0.17700015f, -0.09197690f, 0.00246661f, 
    0.11415538f, 0.11008263f, 0.03800677f, -0.27945089f, 0.03152592f, -0.02510491f, 0.08972002f, 0.10401300f, 
    -0.08784972f, -0.09516689f, -0.02115181f, -0.13049109f, 0.26559967f, 0.26258305f, -0.05258303f, 0.03720807f, 
    -0.08177376f, -0.02095340f, 0.04566720f, -0.03652676f, 0.10447008f, 0.10168604f, -0.01268895f, 0.09920129f, 
    -0.09774163f, 0.01128185f, -0.11091365f, -0.17551100f, 0.00629416f, -0.01938592f, 0.06593034f, -0.01195384f, 
    -0.02845519f, 0.17347234f, 0.11041009f, 0.00652698f, 0.07684018f, 0.12891173f, 0.05875601f, -0.14289761f, 
    0.07772274f, -0.07535557f, -0.05652285f, 0.11333533f, 0.00105552f, 0.04479919f, -0.01363857f, 0.01313698f, 
    -0.18836786f, 0.13452284f, -0.08567113f, -0.20697150f, 0.03088321f, 0.05645637f, -0.01366037f, 0.00634053f, 
    0.09583454f, -0.03944388f, 0.00464723f, 0.06470866f, -0.01529761f, -0.13621807f, 0.04925599f, -0.25685248f, 
    0.08407515f, -0.12766148f, 0.07720804f, -0.08259512f, -0.07349050f, -0.06357607f, 0.10944009f, 0.00361261f, 
    0.46529081f, -0.13838919f, 0.14454517f, 0.04653496f, 0.01853864f, 0.07276275f, 0.03027494f, 0.04304649f, 
    0.05448993f, 0.02657203f, 0.03409327f, 0.02775555f, 0.56702948f, -0.08878751f, 0.09872364f, 0.47078946f, 
    -0.14946127f, -0.02138803f, -0.00972478f, -0.03292851f, 0.03065304f, -0.05355705f, 0.13381116f, -0.06839853f, 
    0.08000048f, 0.04514573f, -0.20065238f, 0.05438985f, 0.06406604f, 0.12484936f, -0.03273721f, 0.01606472f, 
    0.04132442f, -0.06953076f, 0.10017613f, -0.04905636f, -0.02745305f, 0.10586985f, 0.06980483f, 0.23227361f, 
    0.05586472f, -0.11148483f, -0.13894357f, -0.05936202f, 0.00427702f, -0.03865250f, 0.00392050f, 0.13523661f, 
    0.34560552f, 0.03978195f, 0.13887270f, -0.00073128f, -0.05405805f, -0.06644365f, 0.04171481f, 0.05039565f, 
    -0.06046218f, -0.02161479f, -0.08176485f, -0.01034230f, 0.28899571f, 0.10626854f, 0.06591214f, -0.35606524f, 
    0.00164725f, -0.05313919f, -0.05827846f, 0.05433761f, -0.12480803f, -0.00830302f, 0.03851528f, 0.01487516f, 
    -0.16709606f, -0.08100879f, 0.12250440f, -0.25565627f, -0.00763700f, 0.00831133f, 0.08705778f, 0.03658944f, 
    0.10145488f, 0.15074751f, 0.11313907f, -0.01061600f, 0.34122419f, 0.11508188f, 0.15396148f, 0.03787579f, 
    -0.10541568f, -0.05238519f, 0.06254486f, 0.10393447f, -0.08780036f, 0.11428067f, -0.04569104f, -0.24160963f, 
    -0.10808487f, -0.05199002f, 0.07687221f, -0.07637748f, 0.00179749f, -0.04305129f, -0.00925892f, -0.02721501f, 
    0.01977884f, 0.03767786f, 0.00370116f, 0.04833779f, -0.01687864f, -0.05388553f, 0.02360747f, 0.16046627f, 
    0.03519099f, -0.04483673f, -0.01904181f, -0.07419325f, -0.04142871f, 0.08242487f, 0.02281635f, 0.05077726f, 
    0.04554798f, 0.05815348f, -0.01945461f, 0.03154735f, 0.06967968f, 0.03108732f, 0.14157413f, -0.00810529f, 
    -0.00883685f, 0.06425847f, -0.10593300f, 0.03017162f, -0.13476992f, 0.07121249f, 0.01440764f, 0.25277206f, 
    0.04779626f, 0.01286809f, -0.02957574f, -0.03172742f, -0.03077045f, -0.08008499f, 0.02231666f, -0.12971461f, 
    0.10648924f, 0.10916474f, -0.04458722f, 0.02845574f, -0.00691374f, 0.03633860f, 0.13564025f, -0.00856549f, 
    0.03426268f, 0.01557181f, 0.03265903f, -0.06780761f, -0.12728766f, -0.13789105f, 0.09295559f, 0.09075026f, 
    0.11175603f, 0.08606455f, -0.00965354f, 0.00658607f, 0.01373646f, -0.09995437f, 0.05049670f, 0.02768939f, 
    -0.14021917f, 0.24726863f, -0.06805233f, 0.17225093f, 0.17680022f, 0.05047286f, 0.00852908f, -0.09315886f, 
    -0.07871884f, -0.01873263f, -0.09502265f, 0.00599396f, 0.35888249f, 0.06549713f, -0.09881648f, -0.02878698f, 
    0.02524120f, -0.04365715f, 0.08330199f, -0.00766591f, 0.02615073f, -0.03442429f, -0.10600700f, 0.04792332f, 
    0.20168246f, 0.13270140f, -0.07819030f, -0.01900681f, -0.08465227f, 0.06463738f, 0.04764230f, -0.02742046f, 
    -0.07054434f, 0.06368982f, -0.07471800f, -0.11751699f, -0.00723068f, 0.04571017f, -0.02957142f, 0.17988019f, 
    0.09071814f, 0.01658149f, 0.07830235f, -0.05795035f, -0.08439258f, -0.02801790f, -0.04897435f, 0.13420466f, 
    -0.12185338f, 0.17640035f, -0.15313911f, 0.32258523f, -0.02237255f, -0.16542864f, 0.00848383f, -0.17589900f, 
    -0.09560556f, 0.03567233f, -0.06186841f, -0.16998099f, -0.05861259f, 0.06718913f, 0.07103803f, -0.07959606f, 
    0.11898136f, 0.00987010f, -0.07477601f, 0.02555618f, 0.12112448f, 0.07872299f, -0.09967915f, -0.02319512f, 
    -0.03917966f, 0.00886657f, 0.01455051f, -0.02710442f, 0.00300762f, -0.04215135f, 0.02769858f, 0.02806438f, 
    -0.00091899f, 0.02925483f, -0.03426625f, -0.01210773f, -0.01209012f, 0.01827440f, -0.03650904f, -0.02013860f, 
    0.00849839f, 0.02957079f, -0.00668618f, -0.00062109f, -0.00371860f, 0.00657750f, -0.00929920f, -0.02104963f, 
    0.01031358f, 0.02680192f, 0.01330598f, -0.03319455f, 0.00243450f, 0.02472577f, -0.03657207f, -0.01549998f, 
    -0.03288255f, 0.00421323f, -0.00409165f, 0.00123319f, -0.03491883f, 0.01048053f, -0.04130347f, -0.02526087f, 
    -0.03896899f, 0.00880438f, 0.02676787f, -0.01847379f, 0.02625557f, -0.02699937f, -0.03288443f, 0.00216677f, 
    0.02114246f, 0.00208494f, 0.02322775f, 0.02500049f, -0.03728693f, -0.04057764f, -0.03804621f, -0.02567173f, 
    0.01517987f, 0.02414634f, -0.02898877f, -0.01124663f, -0.03728193f, -0.02579430f, -0.02731581f, -0.01635604f, 
    0.00990831f, 0.03487435f, -0.00888132f, 0.03043058f, 0.01807426f, 0.01969798f, -0.00847875f, -0.00775125f, 
    -0.03246937f, -0.02713054f, -0.01651609f, 0.02695206f, -0.02223645f, -0.00037328f, -0.00233381f, 0.00006246f, 
    0.00462459f, -0.04121638f, -0.02344126f, -0.00760521f, 0.01774677f, -0.02269927f, 0.00203719f, -0.02754249f, 
    0.01134137f, -0.01919791f, 0.00876200f, -0.01327327f, -0.02209390f, -0.00775209f, 0.00955372f, -0.00850173f, 
    -0.00829772f, 0.01644535f, 0.00020762f, -0.01170671f, -0.02756175f, 0.01292671f, -0.02292514f, -0.03960519f, 
    0.01804445f, -0.04237249f, 0.01020276f, 0.00742811f, -0.02218234f, -0.01805949f, -0.00584057f, -0.03101610f, 
    0.02838972f, -0.03744181f, -0.02618678f, -0.01841556f, -0.02077281f, -0.01761002f, -0.04095839f, 0.03227469f, 
    -0.03333905f, -0.03558886f, 0.01054184f, 0.02413496f, -0.02149593f, 0.02812296f, 0.02506264f, -0.03650161f, 
    -0.00796819f, 0.02526941f, 0.02679467f, -0.03304743f, 0.01186549f, -0.04119675f, 0.03021389f, -0.04026167f, 
    -0.01076343f, 0.01288546f, -0.01770479f, -0.01932796f, -0.03992421f, -0.02060923f, 0.02471582f, -0.00759491f, 
    -0.04400313f, 0.00496235f, 0.02372051f, -0.03007758f, -0.02986139f, 0.00991299f, -0.01942774f, 0.01175502f, 
    -0.01856283f, -0.03755893f, 0.00825086f, 0.02873559f, -0.03371529f, -0.00932063f, -0.03948396f, 0.02569267f, 
    -0.02360332f, 0.02465180f, -0.00482830f, 0.00880694f, 0.01364755f, -0.03262929f, -0.03097780f, -0.01011775f, 
    0.02498232f, -0.03894302f, -0.02530481f, -0.01199247f, -0.00555501f, -0.00233078f, -0.03801215f, -0.04092085f, 
    -0.02994255f, 0.00260521f, -0.00083590f, -0.03993627f, -0.00743600f, -0.01329331f, 0.01144136f, -0.01448229f, 
    -0.01205260f, -0.00435378f, -0.03982865f, 0.01769326f, -0.00307517f, -0.02172287f, -0.00599731f, -0.03981534f, 
    0.01146540f, 0.00886947f, 0.01951065f, 0.01412978f, 0.02409873f, -0.02413022f, -0.00493609f, 0.00572133f, 
    -0.00550729f, -0.01593687f, -0.00873584f, -0.03199691f, 0.02145283f, -0.00153302f, -0.02913903f, 0.03612863f, 
    0.01547462f, 0.00195954f, 0.01421890f, -0.01579170f, 0.01747472f, 0.01552628f, -0.02568769f, 0.00342183f, 
    -0.03955077f, -0.01795009f, 0.01043816f, -0.00944780f, 0.01919528f, -0.03510119f, -0.03491093f, -0.02068764f, 
    -0.04273262f, 0.03453979f, 0.01124247f, -0.04237617f, -0.03378567f, -0.01836566f, 0.01290524f, -0.01590581f, 
    0.00396336f, -0.01412305f, 0.00414898f, -0.00665051f, -0.02578108f, -0.00853380f, 0.00185093f, -0.01118862f, 
    -0.00055008f, 0.01356821f, -0.00359296f, 0.01369218f, 0.01421521f, -0.01390231f, 0.03061821f, 0.02232627f, 
    0.01129642f, 0.02608492f, 0.02633382f, -0.03696448f, 0.01779586f, -0.01569348f, 0.01209667f, 0.02489615f, 
    -0.03870500f, 0.01373754f, -0.02929595f, -0.01696285f, -0.01662649f, 0.02426645f, 0.02148115f, -0.02783461f, 
    -0.03924921f, -0.02615957f, -0.00277209f, 0.00539190f, -0.00614293f, -0.00493933f, 0.01428914f, 0.01761996f, 
    0.00781336f, -0.04049620f, -0.02057116f, -0.02088527f, 0.02116759f, -0.03783257f, 0.02109081f, -0.01025052f, 
    -0.01893535f, 0.01839967f, -0.02954062f, -0.02434266f, -0.04117922f, -0.01333739f, -0.02707460f, 0.01107350f, 
    -0.00777192f, 0.01419661f, -0.02518793f, 0.00069332f, -0.02319860f, 0.00903667f, -0.03131419f, -0.00067316f, 
    -0.02456909f, 0.01102487f, 0.01818451f, 0.01772153f, 0.00425933f, -0.02219958f, -0.00669260f, -0.03414625f, 
    0.03437090f, 0.00268443f, 0.02438891f, -0.01278790f, -0.04036633f, -0.01736431f, -0.01866611f, -0.01733281f, 
    -0.01655631f, 0.00264166f, 0.01413921f, -0.01378359f, 0.01505305f, -0.02109055f, 0.00770123f, -0.02997314f, 
    -0.01067049f, 0.02102903f, 0.03256677f, 0.03697652f, -0.01077688f, -0.01275888f, -0.02832502f, -0.03819624f, 
    -0.00266582f, -0.03993674f, -0.02627245f, -0.00360284f, 0.01257327f, 0.02420474f, -0.03925427f, -0.04171285f, 
    -0.00347470f, 0.02940936f, -0.01719663f, 0.01992348f, 0.02987990f, 0.02718294f, 0.00071889f, 0.00295189f, 
    0.01496415f, 0.02361504f, 0.02796737f, 0.02222412f, 0.00257350f, 0.01549703f, 0.02994123f, -0.02086901f, 
    0.01281967f, -0.00946846f, 0.02565848f, -0.02077132f, 0.01004312f, 0.02804574f, -0.02699965f, -0.04111776f, 
    -0.00862379f, 0.00857797f, 0.02050776f, 0.00648891f, -0.04015418f, 0.01547114f, -0.02352478f, -0.02110884f, 
    0.01004488f, 0.01986325f, 0.02544643f, -0.02227954f, 0.00437681f, 0.01153842f, -0.03109282f, -0.04126684f, 
    0.01199422f, -0.00084809f, 0.02410555f, -0.00582745f, 0.01444533f, -0.02811389f, 0.01830460f, -0.00513030f, 
    -0.02425027f, -0.01119910f, -0.02823939f, 0.00462015f, -0.02089727f, -0.03506377f, 0.02890860f, -0.01324524f, 
    0.00088272f, -0.02114479f, 0.01288725f, 0.02812362f, 0.00682117f, -0.00096782f, -0.02609528f, 0.00083808f, 
    0.01971855f, -0.01756652f, -0.01721036f, -0.02296534f, -0.02797226f, 0.01053656f, -0.00067143f, -0.01916353f, 
    -0.01898914f, -0.00328595f, 0.00474600f, -0.03786780f, -0.02753723f, -0.02554770f, -0.00129246f, 0.01235947f, 
    0.00992118f, -0.01073795f, -0.00863069f, -0.02893637f, -0.03665050f, -0.04125295f, -0.04296595f, -0.01674741f, 
    -0.02725325f, -0.00479459f, -0.01035260f, 0.00610741f, 0.01624816f, -0.03088177f, 0.00244195f, 0.01074756f, 
    -0.03870197f, 0.00343590f, -0.03709573f, -0.02185326f, -0.02368301f, -0.03763317f, -0.00558929f, 0.01577204f, 
    0.02719678f, 0.00135270f, -0.00570947f, 0.00081309f, -0.04129117f, 0.02912467f, -0.02321863f, 0.01580972f, 
    -0.01235852f, -0.02710660f, -0.00683642f, -0.00224179f, -0.00373338f, 0.00145675f, -0.01944260f, -0.04056095f, 
    0.01903784f, -0.01112668f, -0.03253290f, 0.01590771f, -0.01660635f, -0.03826840f, 0.01807363f, 0.00634069f, 
    -0.01946911f, -0.00313065f, -0.03280896f, 0.01744284f, 0.00900341f, 0.02772074f, -0.03873940f, -0.01935556f, 
    -0.02651932f, -0.00289416f, -0.00540106f, 0.00167214f, -0.01726488f, 0.00530733f, -0.04236623f, 0.02156074f, 
    -0.01267100f, 0.02364876f, -0.02733935f, -0.01743116f, 0.03238024f, 0.00405326f, -0.01815742f, 0.02611855f, 
    -0.02126225f, 0.01113671f, -0.01103762f, 0.02334467f, 0.02111473f, -0.00008007f, -0.00797908f, 0.00854153f, 
    0.01883289f, -0.00867181f, -0.02079568f, -0.03577854f, 0.01240031f, -0.00621666f, -0.00762567f, -0.00946326f, 
    0.01660918f, -0.01742088f, 0.01391745f, -0.00262050f, 0.00357143f, 0.01954965f, 0.01691249f, 0.02493070f, 
    -0.03931826f, -0.00616379f, 0.00289968f, -0.01451539f, -0.02995889f, 0.00359038f, 0.02179552f, -0.04022705f, 
    -0.00571682f, 0.02454268f, 0.01130631f, -0.01600807f, 0.02663348f, -0.02999424f, -0.01003206f, -0.03650403f, 
    0.02218606f, -0.00136497f, -0.03814979f, 0.01866063f, 0.00697209f, 0.00371570f, 0.02479499f, -0.01375087f, 
    -0.00042611f, 0.02784742f, -0.04014898f, 0.02880265f, -0.00071383f, 0.00180894f, 0.00925230f, 0.01828586f, 
    0.01814747f, -0.00477715f, -0.03359235f, -0.01307531f, 0.01255244f, 0.00409352f, -0.03287545f, 0.02081675f, 
    0.00426280f, 0.00663106f, 0.01758098f, -0.04115262f, -0.03835985f, 0.01221440f, -0.03642868f, 0.00079010f, 
    -0.03150397f, -0.04066937f, 0.00399676f, -0.03380065f, -0.02503670f, 0.02047040f, 0.02296649f, -0.02452518f, 
    -0.00022822f, -0.01030920f, -0.00692035f, -0.03339323f, -0.00632762f, -0.00259675f, -0.01403885f, 0.00661874f, 
    -0.03471770f, -0.00951423f, -0.01694163f, -0.04006616f, 0.00157744f, -0.02863381f, 0.01738013f, -0.02787729f, 
    0.02144720f, -0.02691389f, 0.00996147f, -0.03735535f, -0.01792612f, 0.02917469f, -0.02306698f, 0.02322759f, 
    -0.01146678f, -0.03229069f, -0.01333598f, -0.03756947f, 0.01572547f, 0.03123643f, -0.01117277f, 0.01639811f, 
    -0.02792090f, -0.03202369f, -0.03652777f, 0.01829755f, -0.04218404f, -0.03886596f, 0.00528457f, -0.00079258f, 
    -0.00997478f, 0.00600416f, 0.02591910f, -0.02436106f, 0.01600020f, -0.02493147f, -0.00320639f, 0.00940389f, 
    0.01298395f, 0.00600496f, 0.01364318f, -0.00677025f, -0.02533913f, -0.02955824f, -0.01680338f, 0.03004052f, 
    -0.01878511f, -0.00021175f, -0.01249387f, 0.01758103f, 0.01745414f, -0.01800506f, -0.00195054f, -0.00988135f, 
    0.01596431f, 0.02815147f, -0.03330949f, 0.02758320f, -0.00550795f, 0.00719862f, -0.03437356f, -0.00734932f, 
    -0.03766579f, -0.04023845f, 0.00794728f, 0.01051066f, 0.00926632f, 0.01844325f, 0.02339929f, -0.01465987f, 
    -0.00477636f, -0.03244312f, -0.00243315f, 0.00646982f, -0.01309720f, 0.00481071f, -0.02597465f, -0.01054319f, 
    0.01411414f, -0.01845876f, 0.01903436f, -0.03180377f, 0.01830353f, 0.01886589f, 0.00738788f, 0.00248445f, 
    -0.00387881f, -0.02995712f, -0.02290885f, 0.00137971f, -0.00037310f, -0.01304583f, -0.03938230f, 0.02013125f, 
    -0.00786335f, 0.01237481f, -0.03292280f, -0.02563992f, -0.01419855f, 0.01129335f, 0.00816677f, -0.03109105f, 
    0.01503293f, -0.03535971f, 0.02200129f, -0.01054304f, 0.01758877f, -0.01700525f, -0.01401770f, -0.00184904f, 
    -0.00794666f, 0.00031851f, 0.02299461f, 0.01525958f, -0.00352656f, -0.03067091f, 0.01639446f, 0.01335237f, 
    -0.00516906f, -0.03556010f, -0.00173333f, 0.00145091f, 0.00877038f, -0.02416741f, 0.02739296f, -0.02886103f, 
    -0.02798684f, 0.02322865f, -0.04217753f, -0.04352538f, -0.02445111f, -0.03085052f, 0.00061810f, 0.01611946f, 
    -0.00604316f, 0.02786613f, 0.01726061f, -0.01715787f, -0.02192595f, 0.02533536f, -0.00260005f, 0.02081420f, 
    0.02280367f, 0.02005873f, 0.00656366f, 0.00372979f, -0.03219293f, 0.00096152f, -0.03325359f, 0.02292623f, 
    0.01726359f, -0.03419441f, -0.02490222f, 0.02225763f, 0.02222839f, -0.02755518f, -0.01918227f, 0.02600604f, 
    -0.01514339f, -0.03184950f, -0.00237991f, 0.02566041f, -0.04054849f, 0.00133627f, -0.02839028f, 0.02655691f, 
    -0.03474401f, -0.03425169f, -0.02584695f, 0.01505831f, -0.01270865f, 0.00275787f, -0.01092942f, -0.03639382f, 
    -0.01621246f, 0.02783197f, -0.02004403f, -0.02377576f, -0.00038476f, -0.03116142f, -0.00209503f, -0.02485999f, 
    0.02190603f, -0.00710495f, -0.04192762f, -0.02249201f, 0.00535118f, -0.00784581f, -0.01027582f, 0.00463622f, 
    -0.02354774f, -0.03402823f, 0.00757957f, -0.03368199f, -0.01340100f, -0.02671061f, -0.01698411f, -0.03542956f, 
    -0.01251520f, 0.02713998f, -0.02084408f, -0.02596670f, -0.03434129f, 0.00836068f, -0.03857557f, 0.00089451f, 
    -0.02195452f, -0.01011488f, -0.00202736f, 0.01639126f, -0.01013138f, 0.02479261f, -0.01934263f, 0.00877443f, 
    0.02200075f, -0.02170672f, -0.02474829f, -0.00745336f, -0.03230129f, -0.03731755f, -0.01612636f, -0.03902174f, 
    -0.01964373f, 0.02474699f, 0.01739968f, -0.03569608f, -0.00320864f, 0.02331431f, -0.00027366f, 0.01709565f, 
    -0.00124419f, 0.01550219f, -0.00831512f, -0.01371746f, -0.02752629f, 0.01073105f, 0.00419801f, 0.02150434f, 
    0.00877610f, -0.01049326f, -0.01761264f, 0.00833457f, -0.00227114f, 0.02111893f, 0.01061267f, -0.03462105f, 
    -0.00794430f, -0.01064232f, -0.00998923f, -0.03777856f, -0.01812036f, -0.01598543f, -0.00014016f, 0.01800932f, 
    0.01440322f, 0.00586326f, -0.03273204f, -0.02331756f, 0.00626291f, 0.01927593f, -0.00851093f, -0.01918632f, 
    -0.01270988f, 0.01602687f, -0.00068490f, 0.00428915f, -0.03426799f, 0.01953798f, -0.03508788f, -0.03972856f, 
    -0.02646943f, -0.00410694f, 0.01566139f, -0.01700938f, 0.02300713f, 0.00545794f, -0.01887484f, 0.01044967f, 
    0.02246471f, 0.02691984f, -0.01063068f, 0.02115546f, 0.01251035f, -0.03255006f, -0.03733366f, -0.00524524f, 
    0.02945698f, -0.00903127f, -0.00258460f, 0.00858594f, -0.03753682f, -0.01022209f, 0.00810306f, 0.01692376f, 
    0.02163509f, -0.03355886f, -0.03551358f, -0.00858244f, -0.00311448f, -0.02705682f, 0.01559043f, -0.00202390f, 
    0.01182547f, 0.02438607f, 0.00602529f, -0.00555900f, -0.00660341f, -0.02751721f, 0.03468141f, 0.02518764f, 
    -0.00224187f, 0.00984114f, 0.01388671f, 0.01061824f, -0.02837803f, -0.01148477f, -0.03304026f, -0.00906406f, 
    0.01993503f, -0.03268624f, -0.01614221f, -0.01663007f, -0.03349735f, -0.00434941f, -0.00345022f, 0.01825002f, 
    -0.02529182f, -0.03808776f, -0.02132689f, -0.00071753f, -0.00616527f, 0.00248269f, -0.02048399f, -0.02891457f, 
    -0.00024558f, 0.00210731f, -0.02920651f, -0.02866603f, 0.01380746f, 0.01151604f, -0.00404381f, -0.00655426f, 
    0.00556636f, 0.00761061f, -0.02231446f, -0.03023508f, -0.00118280f, -0.02233999f, -0.00637064f, -0.03051873f, 
    0.01307107f, -0.01841592f, -0.03617791f, -0.01885841f, 0.00040652f, 0.01674346f, 0.02261711f, -0.01487240f, 
    -0.02420431f, -0.03956685f, -0.01819512f, -0.01696486f, -0.02507506f, -0.03449114f, -0.00048965f, -0.00257016f, 
    -0.01138561f, -0.01996449f, 0.02493255f, 0.01460492f, 0.02425635f, -0.00768109f, 0.02135389f, -0.03191278f, 
    0.01861240f, -0.03085599f, -0.02707250f, -0.04074506f, -0.00523906f, 0.01983073f, -0.03713196f, 0.02585981f, 
    -0.03687512f, -0.01520751f, -0.01891736f, -0.00310972f, 0.00846287f, 0.00403199f, 0.02405687f, -0.03655293f, 
    0.00609061f, -0.00056858f, 0.00375886f, -0.03685199f, -0.00944562f, -0.03409783f, -0.03503133f, -0.02965672f, 
    0.01433026f, 0.02484437f, -0.03929913f, -0.02007703f, 0.00567863f, -0.01399976f, 0.01249129f, -0.01178348f, 
    -0.03701662f, -0.03491529f, 0.01508632f, -0.01241621f, -0.02690112f, 0.02895798f, 0.02199679f, -0.02020801f, 
    -0.01338644f, -0.02293270f, 0.00997230f, 0.00805956f, -0.02549094f, 0.00821209f, -0.01507393f, 0.01078620f, 
    -0.00755463f, -0.01235397f, -0.02748243f, 0.02412208f, 0.01177443f, -0.03227920f, 0.01586390f, -0.01861647f, 
    -0.03302796f, -0.00384546f, 0.02166510f, 0.02849675f, -0.00558581f, -0.03231067f, -0.01222215f, 0.02493262f, 
    -0.01945536f, -0.01978537f, -0.02045869f, 0.01264077f, -0.01701469f, -0.01828464f, 0.00265455f, -0.00324253f, 
    -0.01155124f, -0.02081906f, -0.00819600f, -0.01006056f, -0.00232799f, -0.03660442f, 0.02799002f, -0.03099045f, 
    -0.03342322f, 0.01064554f, 0.02180836f, -0.02940727f, 0.00824799f, 0.01836582f, -0.02528054f, 0.00726844f, 
    -0.01433179f, -0.01301610f, 0.00699944f, -0.01917745f, 0.00565501f, -0.03649994f, -0.01970105f, -0.00846503f, 
    -0.01667200f, -0.00302048f, -0.01027592f, 0.00171057f, 0.01854175f, -0.03246840f, -0.00054206f, 0.01580393f, 
    0.00336314f, 0.02658627f, 0.00414776f, -0.02614747f, -0.01862823f, -0.03256286f, -0.02759756f, -0.00055924f, 
    0.00911847f, -0.03539283f, -0.03002837f, -0.02704364f, -0.01002245f, -0.01497967f, 0.00451122f, -0.00816120f, 
    -0.02838804f, -0.00019829f, -0.00744385f, -0.00251771f, 0.01452818f, -0.01079499f, 0.01267374f, -0.01176121f, 
    0.03463956f, -0.03251028f, -0.00949587f, 0.00801970f, -0.03438890f, -0.01428456f, -0.02015858f, 0.02111667f, 
    0.00393778f, 0.02169615f, 0.02927350f, 0.00099902f, 0.02552316f, 0.01050991f, -0.02766082f, -0.01192928f, 
    -0.00125290f, 0.01790247f, 0.01194358f, 0.01673689f, -0.03554599f, -0.02372443f, 0.01301387f, 0.00339616f, 
    -0.03611563f, 0.00499428f, -0.03137654f, 0.01261708f, -0.02896462f, -0.00138077f, 0.02200705f, 0.00827552f, 
    -0.03991996f, 0.01808659f, -0.02940726f, -0.03597857f, 0.02516840f, 0.00362025f, -0.00168220f, 0.02812366f, 
    0.02053209f, -0.02531830f, -0.03047481f, 0.01024661f, 0.01424392f, 0.00521395f, 0.01463712f, 0.01772267f, 
    -0.03127569f, 0.00440165f, 0.03021648f, 0.01137025f, -0.01665100f, -0.03854958f, -0.00269162f, 0.01886477f, 
    0.02126737f, -0.03419200f, -0.00866542f, 0.01855677f, 0.03041198f, 0.02225199f, -0.03972895f, -0.01218011f, 
    -0.01428224f, -0.00687678f, 0.01544008f, 0.01275967f, -0.04053340f, -0.00332025f, -0.02635127f, 0.00924737f, 
    -0.01512753f, 0.01190217f, 0.00165712f, 0.00553801f, -0.02380965f, 0.02981257f, -0.01928842f, -0.00401317f, 
    0.02263182f, 0.02502839f, 0.00252230f, 0.01910933f, 0.02268336f, -0.00177750f, -0.03980335f, -0.00095450f, 
    0.01299800f, -0.00870297f, 0.01030440f, 0.00649560f, 0.00565150f, -0.02375773f, -0.03170672f, -0.01277243f, 
    -0.02695938f, 0.01445876f, -0.03060575f, 0.03187378f, 0.01742875f, 0.01908306f, -0.02396920f, 0.01961781f, 
    -0.02313261f, 0.00249676f, -0.03229011f, 0.01844074f, -0.02450956f, 0.02953265f, -0.02453961f, -0.00303887f, 
    -0.00638768f, 0.02218033f, -0.00098125f, -0.02145728f, 0.00268647f, -0.01006190f, -0.02030752f, -0.03620267f, 
    0.01223727f, -0.03789759f, -0.03013828f, 0.02217533f, 0.01295978f, 0.00998572f, -0.02391038f, 0.02918223f, 
    0.01969428f, -0.00258039f, -0.02740685f, 0.02844424f, 0.00934269f, 0.01075814f, -0.00553160f, -0.03730905f, 
    -0.00812664f, 0.02438670f, 0.01593219f, -0.00554587f, -0.02867030f, 0.01396628f, 0.02100543f, 0.01181624f, 
    -0.00079646f, 0.00844562f, -0.00745649f, 0.02813426f, -0.02726125f, -0.02975588f, -0.01422438f, -0.02695645f, 
    0.02765730f, 0.00982244f, 0.00837270f, 0.01340054f, -0.00772591f, 0.00818097f, 0.00023729f, -0.03508389f, 
    0.02913829f, -0.01351164f, -0.00394578f, -0.02441598f, -0.01774137f, 0.01591423f, -0.00801298f, -0.04124895f, 
    0.01263699f, 0.00572654f, -0.02167748f, -0.02117241f, -0.01730065f, -0.01223131f, -0.00572703f, -0.01028391f, 
    -0.04041441f, -0.00672362f, -0.02434692f, 0.02743518f, -0.00563055f, -0.02140415f, 0.02894440f, -0.02490483f, 
    0.01611096f, -0.03109604f, -0.02837988f, -0.02602028f, -0.01499146f, -0.01009640f, -0.02469424f, 0.01850471f, 
    -0.00652797f, 0.00797577f, -0.03130499f, 0.02952772f, -0.01524219f, -0.04131273f, 0.00855567f, 0.01828350f, 
    0.03024616f, 0.00826031f, -0.01567665f, -0.01762140f, -0.02485405f, 0.01467231f, -0.00037394f, -0.01518417f, 
    -0.01845695f, -0.04001502f, -0.01424554f, -0.02220324f, -0.03328342f, 0.01819270f, -0.01879740f, 0.00419981f, 
    -0.02862921f, -0.01119909f, -0.03844426f, -0.03300090f, 0.00148050f, -0.00493739f, -0.02824993f, -0.03193633f, 
    -0.01675260f, -0.03093383f, -0.03693479f, 0.00012323f, -0.00228448f, 0.02296420f, -0.01044594f, 0.00795246f, 
    0.01788458f, 0.00452780f, 0.01846972f, -0.00343807f, 0.01023792f, 0.00870392f, 0.02781280f, -0.03033298f, 
    -0.02461396f, -0.02485704f, 0.02919017f, -0.02165820f, 0.03063685f, 0.01123028f, 0.01667073f, -0.03873553f, 
    -0.02425267f, -0.01210664f, -0.02026769f, 0.02459634f, 0.02661027f, 0.02480444f, -0.03487204f, 0.01839349f, 
    -0.04042548f, -0.02645688f, 0.01788248f, -0.01786883f, 0.01878518f, 0.00886820f, -0.00937265f, -0.01597924f, 
    -0.02434024f, -0.00252450f, 0.02868724f, -0.00180414f, -0.02971939f, 0.02876461f, -0.01795107f, -0.00165124f, 
    -0.02306400f, 0.00803771f, -0.04008088f, 0.02055739f, -0.01923529f, 0.01136320f, -0.03409636f, -0.03713830f, 
    -0.04098712f, 0.01222526f, -0.00208743f, 0.02939383f, -0.02540163f, -0.03648930f, -0.03200180f, -0.02950014f, 
    0.02325154f, -0.03005889f, -0.00948195f, -0.00708182f, -0.02713767f, 0.03301907f, 0.02559096f, -0.03588896f, 
    -0.03447403f, -0.00338224f, 0.02260600f, -0.03607754f, 0.00762948f, -0.02982299f, -0.01651477f, -0.03598996f, 
    0.02678427f, 0.00695125f, -0.02683420f, 0.02639896f, 0.02309782f, -0.01580464f, 0.02560232f, -0.00371826f, 
    0.01218705f, -0.00771451f, -0.02681204f, -0.00182387f, 0.01753047f, -0.00324157f, -0.02657262f, -0.01249913f, 
    0.02647832f, 0.02883097f, 0.02126629f, 0.03002329f, -0.03156110f, 0.00014046f, -0.00986557f, -0.02572772f, 
    -0.01865366f, 0.00527415f, 0.02332171f, 0.02394122f, -0.03483443f, -0.02717624f, -0.00757055f, -0.03468024f, 
    -0.03307277f, -0.03900518f, -0.02690930f, 0.02167230f, -0.02283803f, -0.02215295f, -0.01901176f, -0.00310836f, 
    -0.01242649f, -0.02599823f, 0.01693766f, -0.03785138f, 0.01817274f, 0.00376200f, 0.02862218f, -0.00074642f, 
    0.00209518f, 0.02297003f, -0.01695942f, 0.02312618f, -0.02795404f, 0.01140935f, 0.01057919f, -0.04038998f, 
    -0.01767913f, -0.00353223f, -0.03912628f, -0.01365665f, 0.01701164f, 0.01414309f, -0.02263854f, -0.03371779f, 
    0.01824131f, 0.02460731f, 0.02916908f, 0.00528863f, -0.01230192f, -0.02164890f, 0.00266341f, -0.00894499f, 
    -0.02941533f, 0.01088165f, -0.02842963f, -0.00080680f, -0.01589244f, 0.01679351f, -0.03327853f, -0.00865045f, 
    -0.00626453f, -0.01128418f, -0.02428934f, -0.00313632f, -0.04121658f, -0.03415821f, 0.00424675f, 0.00912960f, 
    0.01518653f, -0.02800404f, 0.02519564f, -0.03522980f, -0.02869026f, -0.00981939f, -0.03170290f, -0.02045646f, 
    0.00254944f, -0.02530858f, -0.02092028f, -0.00333715f, 0.00915685f, 0.03015383f, -0.00768815f, 0.01038551f, 
    -0.03751770f, 0.02783582f, -0.01601813f, 0.00554843f, 0.00824934f, 0.01269108f, -0.03610677f, -0.00127911f, 
    -0.00426475f, -0.01565113f, 0.01011295f, 0.01368399f, -0.01844304f, -0.00872132f, -0.01533660f, -0.03620022f, 
    0.01481478f, -0.00003146f, -0.02887963f, -0.02576921f, 0.00564761f, -0.02931465f, -0.03209862f, 0.02516023f, 
    0.02219725f, 0.02876094f, 0.00009736f, -0.00280723f, -0.02629323f, -0.01526176f, -0.03965665f, -0.01820816f, 
    0.01595899f, -0.00648961f, 0.01882927f, -0.00218169f, 0.01883609f, 0.02619379f, -0.02218571f, -0.02162793f, 
    -0.02646839f, 0.01628505f, -0.00156180f, -0.01753278f, -0.01131397f, -0.02430463f, 0.01427613f, -0.00565302f, 
    0.02448949f, 0.32681686f, 0.07753693f, -0.26861283f, 0.05803325f, 0.02243743f, 0.00967172f, 0.07421690f, 
    0.06374071f, 0.11410855f, -0.12090072f, -0.14905839f, 0.05606462f, 0.30182537f, 0.08654677f, -0.03410751f, 
    -0.01670347f, 0.01656558f, -0.10545805f, 0.10889585f, -0.06705175f, 0.14104712f, 0.05919568f, -0.12170225f, 
    0.33589101f, 0.11536597f, -0.18110517f, -0.27516887f, 0.09938255f, -0.04737344f, 0.08773541f, 0.02929775f, 
    0.00170476f, 0.11025558f, -0.15677145f, 0.07950257f, -0.26021823f, -0.13135768f, -0.24596405f, 0.39129990f, 
    0.12959619f, 0.22720860f, 0.02090564f, -0.13146360f, -0.16525245f, 0.05613095f, 0.05248918f, -0.05784714f, 
    -0.13935204f, 0.00202971f, -0.28588539f, -0.01478034f, 0.00983906f, -0.06794528f, 0.00368994f, 0.06586206f, 
    -0.00637388f, 0.02713964f, -0.00877205f, 0.10827187f, -0.39977235f, -0.04349078f, -0.22419548f, -0.07122900f, 
    0.04453260f, 0.08989046f, 0.13613465f, 0.01233780f, 0.02886104f, 0.03769150f, 0.00437880f, -0.02298043f, 
    0.07959086f, -0.18346728f, 0.13179341f, 0.16812505f, -0.02605004f, 0.06780855f, -0.00042345f, 0.05098911f, 
    0.01319621f, -0.05325095f, -0.03768880f, -0.11793213f, 0.00922154f, -0.17282844f, -0.12791319f, 0.03325864f, 
    -0.07407100f, 0.02981241f, 0.01273507f, -0.01553359f, 0.10255712f, 0.09526870f, -0.10702381f, 0.06468400f, 
    -0.14589612f, 0.01899196f, -0.10240526f, -0.07027215f, 0.03680855f, 0.12267704f, 0.00017370f, -0.04628400f, 
    -0.02152889f, 0.12463357f, 0.03594185f, -0.02848353f, -0.03798371f, 0.16844800f, 0.21529807f, 0.01946493f, 
    -0.21155331f, -0.03842695f, 0.06823904f, 0.00678926f, -0.05953910f, -0.01612426f, 0.04373988f, 0.09229044f, 
    0.39704093f, -0.14627536f, 0.08786144f, 0.20402816f, 0.09719715f, 0.07374541f, -0.08134887f, -0.06586421f, 
    -0.07885158f, -0.01043059f, -0.01419846f, -0.01920829f, 0.24645357f, -0.04558300f, 0.12952983f, 0.20453340f, 
    -0.15301120f, -0.11949069f, 0.03119360f, -0.06061204f, 0.05031621f, -0.07242386f, 0.00707398f, 0.00645256f, 
    0.23143688f, 0.12847573f, 0.09871957f, -0.05205707f, -0.06259499f, 0.04087894f, 0.04817712f, 0.02195009f, 
    -0.00094211f, 0.06908085f, -0.06608456f, 0.08742304f, -0.09833669f, -0.03571481f, -0.12986436f, 0.01880876f, 
    0.06495136f, -0.06830413f, -0.01924700f, 0.10693644f, -0.04745286f, 0.08446149f, -0.04339224f, 0.07476185f, 
    -0.01388072f, 0.07376179f, 0.00304065f, -0.13016501f, 0.04010866f, -0.16550788f, 0.09717234f, 0.15529092f, 
    0.06746047f, 0.06051204f, 0.01759746f, -0.01478285f, -0.34544498f, -0.11566400f, -0.09460581f, -0.14770812f, 
    -0.07026375f, 0.04954269f, 0.05860566f, -0.05189730f, -0.02444580f, -0.00254875f, 0.05254546f, -0.06409381f, 
    -0.10203330f, 0.23971547f, 0.08805039f, 0.01678209f, 0.09620008f, 0.12001219f, -0.11727433f, -0.05701933f, 
    -0.04405926f, 0.04031102f, 0.06141505f, 0.06069737f, 0.29306000f, -0.06147660f, -0.14833137f, 0.09414987f, 
    0.12263297f, -0.12088080f, -0.11828143f, 0.04023063f, -0.03838242f, 0.00591568f, 0.02983291f, 0.04023023f, 
    0.04510440f, -0.21691968f, -0.12473428f, 0.10315509f, 0.02402127f, -0.06169622f, 0.02725512f, -0.00292143f, 
    0.04889288f, 0.09557435f, 0.05995081f, -0.00142055f, -0.23673552f, -0.09941175f, 0.06634139f, 0.15960029f, 
    0.05009058f, -0.05724931f, -0.00539450f, 0.03321288f, -0.06465833f, -0.04689565f, 0.16584328f, -0.09453157f, 
    0.11320113f, -0.16837312f, -0.08973877f, 0.15085009f, 0.08786996f, -0.00147884f, 0.15435459f, -0.06805450f, 
    -0.00288079f, 0.10606881f, 0.06442139f, 0.15564102f, 0.09101579f, 0.11627746f, -0.11538157f, -0.21821602f, 
    0.12216005f, 0.02024785f, 0.14632182f, 0.02108460f, 0.16290922f, 0.15233909f, -0.08986906f, -0.09403257f, 
    -0.17955071f, 0.21107282f, 0.08999212f, -0.08447208f, -0.03564349f, 0.16650674f, 0.10187074f, -0.00716339f, 
    -0.00575187f, -0.19819936f, 0.02512871f, -0.04820498f, -0.13826847f, 0.01269508f, 0.05169716f, -0.11152387f, 
    0.00434490f, 0.06576902f, 0.00270585f, 0.16853127f, 0.07677806f, 0.11672900f, 0.12212273f, 0.04936327f, 
    -0.30503815f, 0.22161327f, -0.10797818f, -0.14983289f, 0.10141118f, 0.07392394f, -0.00865672f, 0.00617527f, 
    0.05276798f, 0.05854393f, -0.10395034f, -0.01337554f, -0.11782125f, -0.11618767f, -0.11658475f, 0.02989796f, 
    0.05956401f, -0.09095194f, -0.00120400f, 0.02964760f, -0.00852337f, -0.00217760f, 0.05231810f, 0.03965774f, 
    -0.04318085f, 0.15952088f, -0.08868206f, -0.36805809f, 0.00894335f, -0.03170029f, 0.08496273f, 0.09385096f, 
    -0.09063027f, 0.05324842f, 0.06144596f, 0.10846310f, -0.23806155f, -0.02995518f, -0.05775922f, 0.25417379f, 
    0.00976400f, 0.10429619f, 0.01491721f, 0.00056376f, 0.02596172f, 0.08939631f, -0.15379886f, -0.07269798f, 
    0.19396868f, 0.09901267f, 0.08561471f, 0.17446949f, -0.02435481f, 0.04927251f, -0.19282863f, -0.02360935f, 
    0.04445893f, 0.06537949f, 0.00870219f, -0.00111969f, -0.10517878f, -0.06960060f, -0.08042812f, 0.25340384f, 
    -0.04528185f, 0.01004748f, 0.05865740f, 0.13562690f, -0.09901421f, 0.22074789f, 0.05008930f, 0.09952703f, 
    -0.11777407f, 0.03450744f, -0.02500555f, -0.08465818f, -0.06826939f, -0.01436321f, 0.13335909f, -0.10496042f, 
    -0.00142994f, 0.15262046f, 0.03526758f, -0.04896282f, 0.34727335f, 0.16304567f, 0.12321502f, 0.06701773f, 
    -0.15225868f, -0.11039435f, -0.06441953f, -0.02881474f, -0.05891822f, 0.06543767f, -0.00675534f, 0.12346112f, 
    0.31348875f, -0.00654428f, 0.03922690f, -0.08193618f, -0.03342788f, -0.13389426f, -0.04157658f, -0.01180054f, 
    0.02700739f, 0.08666394f, -0.00223787f, 0.05706307f, -0.15865895f, -0.12330139f, -0.19868353f, 0.09679951f, 
    0.01515010f, 0.03395882f, 0.04006957f, 0.05053378f, 0.02970180f, -0.01350040f, 0.05799539f, 0.01355043f, 
    0.43555191f, 0.33764473f, -0.02390073f, -0.09880234f, 0.02930989f, -0.07443113f, -0.02832603f, 0.04352671f, 
    0.02345338f, -0.00623541f, 0.01482049f, 0.11463057f, -0.04906281f, -0.07275778f, 0.06302774f, 0.02989898f, 
    -0.06027144f, -0.00411363f, 0.07661369f, -0.00378240f, 0.04364663f, 0.04749778f, 0.02586042f, 0.02006023f, 
    0.48458534f, 0.08200838f, 0.10668018f, -0.03114716f, -0.15358640f, -0.07533531f, -0.01665631f, 0.04778459f, 
    -0.04550235f, -0.08870073f, 0.05604871f, 0.08157665f, -0.30918047f, -0.17267326f, 0.24219126f, 0.01974763f, 
    -0.10238741f, 0.16237500f, 0.00781940f, 0.00405942f, -0.10860957f, -0.11600996f, 0.05717039f, -0.03120441f, 
    0.55997711f, -0.07183316f, 0.09946823f, -0.04268185f, 0.10849857f, 0.04249095f, 0.22487551f, -0.09353934f, 
    -0.00536131f, 0.06404508f, -0.03505699f, -0.02904030f, -0.00210236f, 0.14863712f, 0.05122202f, -0.08796466f, 
    -0.07511331f, -0.09508923f, 0.03162539f, -0.04663339f, -0.02882897f, 0.19391873f, 0.05545919f, 0.07966760f, 
    0.18265483f, -0.11089233f, -0.17564330f, 0.21978095f, 0.04440502f, -0.00453119f, 0.03251662f, -0.00651447f, 
    -0.05529042f, 0.04926013f, -0.00169269f, 0.05289861f, 0.47342658f, -0.20148996f, 0.03785513f, 0.12018139f, 
    -0.10103392f, -0.02855057f, -0.00091070f, -0.12653317f, -0.02518532f, -0.00082637f, 0.07097284f, 0.04575063f, 
    0.01843037f, -0.05976978f, -0.04001508f, 0.27259433f, 0.08911926f, 0.09454624f, -0.03536858f, -0.02330473f, 
    -0.01510597f, 0.00498919f, -0.11759413f, -0.11340027f, 0.23598835f, 0.06007360f, -0.13139032f, -0.07122985f, 
    0.07346168f, -0.00967221f, 0.03534177f, 0.04341866f, 0.00288632f, 0.00925820f, -0.02091400f, 0.05911379f, 
    -0.25252318f, 0.19135697f, 0.10819437f, 0.25805998f, 0.12406659f, -0.00605403f, -0.03397776f, -0.06464106f, 
    -0.02142875f, -0.04435358f, -0.13857281f, 0.04730929f, 0.71177292f, -0.13819239f, -0.16790569f, -0.04716839f, 
    0.02672982f, 0.04095409f, 0.03260829f, -0.10652311f, 0.05494103f, 0.11938161f, -0.02751439f, 0.08772541f, 
    -0.32493734f, -0.12531736f, -0.15120634f, -0.18342429f, 0.06109557f, -0.07172185f, 0.01521415f, -0.07110655f, 
    0.02509023f, 0.02360952f, -0.08169690f, -0.04891938f, 0.05981236f, 0.06662421f, 0.06453188f, -0.26967165f, 
    -0.13089761f, 0.06816141f, -0.00165700f, 0.05965940f, 0.03557834f, -0.00747889f, -0.00091452f, -0.14868796f, 
    -0.19643423f, 0.10780995f, -0.18722464f, -0.01508640f, -0.10115983f, 0.00894924f, 0.14437154f, 0.06278422f, 
    -0.09697652f, 0.05409574f, 0.04574853f, -0.03447426f, -0.15378144f, -0.14640075f, 0.09776462f, 0.13044280f, 
    -0.13348638f, 0.14595434f, -0.08564945f, 0.04014898f, 0.09972009f, 0.02757589f, 0.08363027f, -0.05989861f, 
    0.30808401f, -0.32876265f, -0.07764736f, 0.24846390f, 0.05053623f, -0.06222666f, -0.12487606f, 0.02677854f, 
    0.01414044f, -0.02421598f, 0.04273194f, 0.07677376f, 0.64104444f, -0.01862450f, 0.16536538f, -0.18227103f, 
    -0.14289339f, -0.03585440f, -0.09178023f, 0.03972821f, 0.08845185f, 0.00010676f, 0.04125253f, 0.07950549f, 
    0.23633401f, 0.00292561f, 0.33351797f, 0.16081272f, -0.21545526f, 0.03865157f, 0.02289572f, 0.06577119f, 
    0.02604314f, -0.04742667f, -0.01287191f, -0.05609273f, 0.30631769f, 0.17577288f, 0.10895824f, -0.01172876f, 
    -0.13839628f, -0.08300245f, -0.07301810f, 0.20579301f, 0.06310638f, -0.03105518f, -0.00726117f, -0.12249944f, 
    -0.16366455f, -0.25351331f, -0.11731888f, 0.17921673f, -0.04330868f, -0.02158111f, 0.00943047f, 0.03003597f, 
    0.03836925f, 0.05539039f, -0.00121184f, 0.03733636f, 0.18912756f, 0.10044789f, 0.27345806f, -0.15321167f, 
    -0.23178120f, -0.08355980f, -0.04942063f, 0.06492482f, -0.01478229f, 0.00731743f, -0.00558821f, -0.05629903f, 
    0.28592461f, 0.14667274f, -0.09065437f, -0.07255076f, 0.12699780f, 0.11745778f, -0.06919165f, 0.04086004f, 
    0.01662489f, 0.03508838f, 0.03696451f, -0.07407279f, 0.27746078f, 0.14918187f, 0.31522813f, -0.29327342f, 
    -0.15472372f, -0.00883954f, 0.05460545f, 0.21339256f, 0.03390231f, 0.01318557f, 0.00058828f, -0.08253877f, 
    -0.05085451f, -0.29698178f, -0.09299265f, 0.34620816f, 0.10400724f, 0.05891399f, 0.00168943f, -0.07427684f, 
    0.04759728f, -0.01531740f, -0.07987113f, 0.05155678f, -0.04664254f, 0.47693771f, 0.02307338f, 0.13345677f, 
    0.01837050f, 0.06728548f, 0.00809596f, -0.02163894f, -0.01862820f, -0.08312380f, 0.00060925f, 0.05978760f, 
    -0.18679750f, -0.19533415f, -0.23459110f, -0.00518864f, -0.04142804f, 0.09856471f, 0.08634479f, 0.02329983f, 
    -0.00704863f, 0.06015453f, 0.08235642f, -0.11781838f, 0.10552939f, -0.26073170f, 0.05132744f, 0.36000043f, 
    0.06678368f, 0.06962547f, -0.00989193f, -0.06374033f, 0.13864936f, 0.09324013f, -0.07025631f, -0.09700044f, 
    -0.17148460f, -0.08770853f, 0.08350838f, 0.01898803f, 0.12056095f, 0.09168249f, 0.10906183f, -0.05637122f, 
    0.09121941f, -0.11098265f, 0.01695525f, -0.06937837f, 0.10878259f, 0.10465502f, 0.15703747f, -0.11110567f, 
    -0.22621673f, 0.00642400f, -0.06842511f, -0.02503021f, 0.04519808f, -0.07716462f, 0.05179911f, 0.00245379f, 
    -0.00494761f, 0.00449661f, -0.03194685f, -0.01677522f, -0.04257740f, -0.00883188f, -0.02800162f, -0.00607638f, 
    0.00599198f, 0.00178355f, 0.02007749f, 0.02126201f, -0.02569078f, -0.03414678f, -0.00987785f, -0.00291617f, 
    -0.02373497f, -0.01795018f, -0.03751986f, -0.02476235f, -0.00363590f, 0.01676271f, 0.00163138f, -0.02852777f, 
    -0.00850241f, -0.04018336f, -0.03906189f, -0.00990101f, -0.00648351f, -0.02706026f, -0.03349861f, 0.03353046f, 
    -0.00066491f, 0.00603042f, 0.02583473f, 0.00796689f, -0.01401745f, -0.03598237f, 0.02699174f, 0.02462903f, 
    -0.01617604f, 0.01530890f, -0.03541236f, -0.03516324f, 0.01104327f, -0.01088121f, -0.00869856f, 0.02765604f, 
    0.01329813f, -0.02981211f, 0.02116429f, -0.01738022f, 0.00013573f, -0.00895967f, -0.01219816f, 0.00085830f, 
    0.01755917f, -0.02894112f, 0.01546281f, -0.03558028f, -0.00005441f, -0.00978761f, -0.02136119f, -0.00123408f, 
    0.02323670f, -0.02409871f, 0.02029521f, -0.02253573f, -0.00808518f, -0.02062996f, 0.02207076f, 0.02772245f, 
    0.01427530f, 0.01052578f, -0.02714481f, -0.02308324f, -0.01534375f, -0.02730628f, 0.01757004f, -0.01147507f, 
    -0.02676633f, -0.00725089f, -0.02355139f, -0.01893890f, -0.03323723f, -0.03764138f, 0.00431130f, 0.02004975f, 
    -0.02988118f, -0.01251409f, -0.02305128f, -0.00549747f, 0.01813311f, 0.02845779f, -0.03719744f, -0.01618358f, 
    0.00251592f, -0.02523185f, 0.02319289f, 0.00759655f, 0.01189902f, 0.00157693f, -0.01888861f, 0.03099003f, 
    -0.03178569f, -0.02201248f, -0.02616240f, -0.02522924f, -0.02420396f, 0.02581724f, 0.01098596f, 0.01936010f, 
    -0.00871296f, -0.03344696f, -0.03753704f, -0.02600032f, -0.00809644f, -0.03648531f, 0.00612936f, 0.03061672f, 
    0.00837640f, -0.03237431f, -0.00735258f, 0.01401069f, -0.01870267f, -0.04224900f, 0.02238994f, -0.01598464f, 
    0.01010896f, -0.03946928f, 0.03102805f, 0.01753132f, 0.03116614f, -0.00269194f, 0.02635450f, -0.02834176f, 
    0.02339274f, -0.03043217f, -0.04082259f, -0.02835308f, -0.00816236f, -0.04201152f, 0.01776687f, 0.00313866f, 
    -0.01931481f, 0.00570697f, -0.04064041f, -0.01078060f, 0.02518562f, -0.01609660f, 0.02604282f, -0.00479651f, 
    0.01241679f, -0.02948230f, 0.00734050f, -0.01299049f, 0.01111314f, 0.02022778f, -0.02886381f, 0.02258703f, 
    -0.02234258f, -0.02172810f, -0.01960581f, 0.01279136f, 0.00882048f, -0.03472106f, -0.02168688f, 0.01018633f, 
    -0.03809515f, -0.00801092f, -0.00758168f, -0.01809628f, -0.00211334f, -0.02447105f, -0.00651316f, 0.02219641f, 
    -0.04370053f, -0.01316501f, 0.01281037f, -0.04298848f, 0.03439316f, 0.02670828f, 0.02349395f, 0.02026865f, 
    0.01738178f, 0.02512052f, 0.03251278f, 0.02187396f, 0.01569859f, -0.02055343f, -0.04336394f, -0.02563348f, 
    -0.02931827f, 0.01900592f, 0.02649539f, 0.03454183f, 0.02017941f, -0.02145485f, 0.02225380f, -0.03985975f, 
    0.00702626f, 0.02044236f, -0.01070108f, 0.00954791f, -0.04039043f, -0.00604742f, -0.00223592f, 0.01757444f, 
    0.00718857f, -0.00625626f, 0.01790948f, -0.00102414f, -0.00002196f, -0.02503407f, -0.00993037f, -0.01306820f, 
    -0.03463988f, -0.03767306f, -0.00590168f, 0.02578550f, -0.02700159f, 0.00501278f, 0.02370760f, 0.03111855f, 
    -0.01359650f, 0.02131638f, -0.02127484f, 0.02158714f, -0.01350281f, 0.00262023f, 0.00913091f, -0.02364104f, 
    0.00229086f, -0.00227481f, 0.02045891f, -0.04028412f, 0.02597830f, -0.02971035f, 0.02674675f, -0.04060306f, 
    -0.03944899f, 0.02641643f, 0.01869704f, 0.01577708f, -0.03226148f, -0.00420014f, -0.03729564f, -0.00352422f, 
    0.00248462f, -0.01098808f, -0.03069208f, 0.03138145f, 0.00251955f, 0.00934301f, 0.01863295f, 0.01550891f, 
    0.02172441f, 0.00090816f, 0.00210952f, -0.01555421f, 0.00793502f, -0.02616842f, 0.00133529f, -0.00895902f, 
    -0.00532376f, -0.03058403f, -0.02736776f, 0.00514360f, 0.00861255f, -0.01824889f, -0.03129469f, -0.01032537f, 
    -0.02492931f, -0.03198997f, 0.03173346f, -0.03090851f, 0.02489327f, -0.03956897f, 0.01002607f, -0.01810113f, 
    0.01378715f, 0.00956103f, 0.00026799f, 0.00756270f, 0.01824140f, 0.02209099f, 0.02760755f, 0.01028391f, 
    -0.03127403f, -0.00759619f, 0.03021637f, -0.00262891f, 0.02086752f, 0.00503536f, -0.01609604f, 0.00008249f, 
    0.01345814f, 0.00570518f, 0.02640833f, 0.00906082f, -0.01954311f, -0.03324849f, -0.04324498f, -0.00920232f, 
    0.01085873f, -0.02453741f, 0.02649157f, 0.01722293f, 0.02343554f, -0.03157647f, -0.02117434f, 0.01565032f, 
    -0.00545932f, -0.03025355f, 0.00652860f, -0.00249520f, -0.02774386f, 0.02635927f, 0.02826567f, -0.00185084f, 
    0.00112482f, -0.03085053f, -0.01915062f, 0.00637421f, -0.02314290f, -0.01701184f, -0.03258650f, -0.02483022f, 
    0.01407260f, -0.03152222f, -0.00982017f, -0.02165929f, -0.03683490f, -0.01364550f, -0.00232421f, -0.02036125f, 
    0.00059896f, 0.01417970f, -0.00928410f, -0.03334291f, -0.00112746f, -0.01504209f, -0.03798658f, 0.00951672f, 
    -0.03842680f, -0.00710938f, -0.02225351f, 0.02290987f, 0.01723559f, 0.01906307f, -0.00930240f, -0.01730329f, 
    0.00646650f, -0.01275603f, -0.04150028f, -0.03098504f, 0.00570082f, 0.01370051f, -0.03599019f, -0.00510313f, 
    0.01457109f, -0.01005251f, 0.00853722f, -0.03564918f, -0.01004242f, 0.00372058f, 0.01886954f, -0.02619994f, 
    -0.00803643f, 0.02269373f, -0.01135038f, -0.03652392f, 0.00919558f, 0.00876468f, -0.03476315f, 0.01905971f, 
    -0.03806607f, 0.01224920f, -0.04149709f, -0.01768149f, -0.02844934f, 0.03214031f, 0.01255122f, -0.02789913f, 
    -0.00311964f, -0.01659950f, -0.01149169f, -0.01282465f, 0.02556916f, -0.00331960f, -0.01729859f, -0.00240613f, 
    0.02417601f, -0.01515168f, -0.00773084f, -0.00371108f, -0.00055114f, 0.02585144f, -0.03471256f, -0.00991251f, 
    -0.00159171f, -0.03449645f, 0.01464907f, -0.00474134f, 0.02053561f, -0.02628513f, -0.02453078f, -0.03106674f, 
    0.00296166f, 0.01573858f, 0.00200966f, 0.02345565f, -0.00824413f, 0.02751788f, 0.00378179f, 0.01918827f, 
    0.00161558f, -0.01191267f, 0.00608912f, 0.01016235f, -0.01305277f, 0.00762472f, 0.02270669f, 0.03034915f, 
    0.00895715f, 0.02016255f, 0.01137967f, 0.00987319f, -0.01180765f, -0.00858129f, -0.02751251f, 0.01388690f, 
    0.01814837f, -0.02885079f, 0.00635366f, 0.01350271f, 0.01163470f, -0.00891085f, 0.02500766f, -0.00129177f, 
    -0.00464057f, 0.01628019f, 0.01470050f, -0.01306033f, -0.02489266f, 0.02767899f, 0.00615343f, 0.02845250f, 
    -0.01885835f, -0.00697787f, 0.02239496f, 0.00253211f, -0.03349154f, -0.01768632f, 0.01756208f, -0.00419288f, 
    0.01662333f, -0.00187832f, -0.02134934f, -0.00850966f, -0.04235953f, 0.02266427f, 0.01229890f, -0.02491534f, 
    0.02210630f, 0.00750958f, -0.01250383f, -0.03270688f, 0.02708423f, 0.00394701f, 0.00037193f, 0.00978322f, 
    -0.02321329f, -0.03422876f, -0.03018312f, -0.02352425f, -0.01030127f, -0.00586165f, 0.01032022f, 0.00607700f, 
    -0.02231501f, -0.00374741f, 0.02307645f, -0.02248182f, 0.01308551f, 0.00383901f, 0.02424617f, 0.02774045f, 
    0.02975802f, 0.03158858f, -0.00601772f, -0.03640503f, 0.01543167f, -0.03593726f, -0.00409505f, -0.03202116f, 
    0.01091126f, 0.00795431f, -0.03953085f, 0.02193596f, -0.02609577f, -0.01293697f, -0.02551968f, -0.01967423f, 
    0.01873267f, 0.02566052f, -0.02634220f, -0.02775120f, -0.02891679f, 0.00752851f, -0.02660958f, -0.02320737f, 
    -0.00838003f, -0.02486164f, 0.00765947f, -0.01574978f, -0.00391069f, -0.03734244f, -0.02575574f, 0.02456812f, 
    0.01091557f, -0.03172588f, -0.03041259f, -0.01527717f, 0.00996094f, -0.00322792f, -0.01806520f, -0.01810799f, 
    0.01664340f, -0.02731112f, 0.03150605f, 0.01092090f, -0.03951783f, 0.02004522f, 0.01270666f, -0.02743862f, 
    -0.04202320f, 0.00387365f, -0.02844859f, -0.00095472f, 0.00814519f, 0.02082261f, -0.00619181f, 0.00482627f, 
    -0.04084608f, 0.00080116f, -0.04252423f, -0.02209318f, 0.02065402f, -0.01558127f, -0.00155574f, -0.00180148f, 
    -0.00392381f, -0.01802118f, -0.02327750f, -0.04170860f, -0.00679314f, -0.00770841f, -0.00909206f, -0.02938959f, 
    -0.03400505f, 0.00018477f, -0.04198748f, -0.01079799f, 0.01292237f, 0.00106511f, 0.00077847f, -0.02493662f, 
    -0.01675562f, -0.01454865f, 0.01338577f, 0.01260945f, -0.00966550f, -0.00947946f, -0.01404205f, -0.01675323f, 
    -0.00244574f, -0.01232678f, 0.00927933f, -0.01213494f, -0.00958464f, 0.01888806f, -0.00974228f, -0.00772382f, 
    0.01176111f, 0.00647743f, 0.01020839f, -0.00710601f, -0.03933000f, 0.02611287f, -0.01808081f, 0.00532531f, 
    0.02433795f, 0.00492480f, 0.01567657f, 0.00316162f, 0.01116765f, -0.03058380f, -0.02534793f, 0.00508685f, 
    -0.00117581f, 0.02730694f, -0.00371967f, 0.00662457f, -0.00968386f, -0.03660388f, 0.01482669f, 0.01087659f, 
    -0.00660188f, -0.03723519f, -0.03874907f, -0.03917168f, 0.00050298f, -0.00756539f, -0.02892787f, -0.03382545f, 
    0.02835140f, -0.03914792f, 0.02108393f, 0.02290636f, -0.02290632f, 0.01112181f, -0.02503418f, 0.02062379f, 
    0.01818067f, -0.02361556f, -0.00785919f, -0.00531372f, 0.02379659f, 0.03278827f, 0.01597614f, 0.03210600f, 
    0.00940168f, 0.00733778f, -0.04241593f, 0.00898715f, 0.00960588f, 0.00710067f, -0.02970461f, 0.01684366f, 
    -0.02126435f, -0.01022938f, 0.01715671f, 0.00990285f, -0.03973369f, -0.03515628f, 0.01136759f, -0.03587079f, 
    -0.01970344f, 0.00805955f, 0.01027312f, -0.03438118f, -0.03015799f, -0.03075908f, -0.02627648f, -0.00429756f, 
    0.00265168f, 0.00468238f, 0.00437018f, 0.00531347f, 0.00750621f, 0.02264035f, 0.01338369f, 0.01986744f, 
    -0.01935776f, -0.02012259f, -0.04241902f, 0.02987675f, 0.01246294f, -0.03105672f, -0.01209482f, -0.00321359f, 
    -0.02671110f, -0.01094502f, -0.02298963f, -0.01222084f, -0.02520500f, 0.03029790f, -0.03581657f, -0.00349091f, 
    0.00823385f, -0.03748884f, 0.00276619f, 0.00620544f, 0.01224407f, 0.02542648f, -0.02382046f, 0.02720305f, 
    0.02544203f, -0.00658473f, 0.01045547f, -0.00291573f, 0.00012664f, 0.00223117f, 0.01584638f, -0.00938653f, 
    0.01456839f, -0.00874191f, -0.01022911f, 0.00301356f, -0.00952998f, 0.02617447f, -0.01703773f, 0.00202224f, 
    0.01149484f, 0.00474858f, 0.00509146f, 0.01478169f, 0.01520974f, -0.03825616f, 0.02721494f, 0.01227459f, 
    0.02628702f, -0.00603381f, -0.04016733f, -0.01996611f, -0.02496726f, 0.02245372f, -0.02391009f, -0.00482357f, 
    0.02516653f, -0.02897593f, -0.03621899f, -0.01323199f, 0.00496935f, -0.00175665f, 0.01059036f, 0.03031130f, 
    0.00398682f, -0.02091307f, -0.03698351f, -0.01750262f, 0.02122429f, 0.01772524f, 0.00962986f, -0.03468310f, 
    -0.01341013f, -0.04004855f, -0.02093985f, 0.02814161f, 0.02708768f, 0.01663412f, 0.01096490f, 0.02359447f, 
    0.00335257f, -0.01837428f, -0.01320303f, -0.00605107f, -0.03283311f, -0.03751226f, -0.02852212f, -0.02268465f, 
    -0.04225629f, -0.03735926f, -0.02679325f, 0.03026408f, -0.01315769f, -0.02999067f, 0.01998734f, -0.01059390f, 
    -0.02825289f, -0.02262432f, 0.01256259f, -0.01073770f, 0.00347442f, 0.01650740f, -0.03408497f, -0.02384341f, 
    0.02703079f, 0.00115664f, -0.02257193f, -0.02893494f, 0.01135095f, 0.02651141f, -0.00912267f, -0.00728337f, 
    -0.01244546f, 0.02873836f, -0.00322549f, -0.01280917f, -0.03307407f, -0.01785893f, -0.02441094f, -0.03136907f, 
    0.02911811f, -0.00502149f, 0.01348010f, 0.01067308f, -0.01538805f, -0.03213881f, 0.02899589f, -0.00051000f, 
    0.01498755f, 0.00056925f, 0.01496647f, 0.02589554f, -0.02956678f, 0.02238785f, 0.01322385f, 0.02194276f, 
    0.02840389f, -0.03267549f, -0.03451168f, -0.00862446f, -0.00406247f, -0.01485070f, -0.00524644f, -0.01655024f, 
    -0.00962709f, -0.01970146f, -0.04094613f, 0.00814681f, 0.00171568f, 0.02046962f, 0.01129556f, -0.00872665f, 
    -0.02014813f, -0.00638350f, 0.01433343f, -0.01623864f, -0.04195453f, 0.02270355f, 0.02873838f, -0.00297580f, 
    -0.02343837f, -0.01741752f, -0.01382950f, -0.01191067f, -0.00852008f, 0.01008824f, -0.01521121f, -0.02824599f, 
    0.01758342f, 0.00330441f, -0.02387078f, 0.01432197f, 0.01380108f, 0.01957991f, 0.00369494f, -0.02520592f, 
    -0.01670741f, -0.03923784f, -0.01966073f, -0.03033299f, 0.02908125f, -0.00076780f, 0.02574305f, -0.01435618f, 
    0.01747798f, -0.01902064f, 0.02629242f, 0.01883110f, -0.00889966f, -0.04114296f, 0.01110041f, -0.02894113f, 
    -0.00732412f, 0.02581089f, 0.02059158f, 0.01369512f, -0.03324261f, -0.01118037f, -0.01211418f, -0.00969065f, 
    0.01796899f, -0.00592651f, -0.02394712f, -0.02244584f, 0.00594243f, -0.02800377f, -0.02139332f, -0.01134033f, 
    0.01402209f, -0.01462854f, 0.02587306f, -0.01669091f, -0.01080017f, 0.01627019f, 0.02148623f, 0.00048243f, 
    -0.02425458f, -0.03530034f, 0.02037498f, -0.03021534f, -0.00287172f, 0.01479550f, -0.00564088f, -0.00990724f, 
    -0.03275596f, -0.02548094f, -0.01252505f, -0.00427568f, 0.02734406f, 0.02917271f, -0.03122218f, -0.02912342f, 
    -0.01482091f, 0.00368555f, -0.03393263f, -0.00682795f, -0.03824570f, 0.01516882f, -0.04248648f, -0.03482786f, 
    0.01498444f, 0.01666702f, -0.02879373f, -0.01958247f, -0.02870866f, -0.03216319f, -0.03633056f, 0.01670026f, 
    -0.03789426f, 0.00840920f, -0.01356195f, -0.02819881f, 0.00528910f, -0.03585277f, -0.02473626f, -0.01050106f, 
    -0.03562629f, -0.01609823f, 0.02472136f, -0.00476747f, 0.01001120f, 0.00864643f, -0.03198293f, -0.02197479f, 
    0.00981795f, -0.00976274f, -0.03674593f, 0.02121935f, -0.01564394f, -0.00863201f, -0.00115797f, 0.02486278f, 
    -0.01323980f, -0.02070600f, -0.00053189f, 0.00773135f, 0.01310332f, -0.03767300f, 0.03049215f, -0.01598295f, 
    -0.04167796f, -0.01605893f, 0.01748937f, -0.00848364f, 0.01567531f, 0.02479267f, 0.00794399f, 0.00141533f, 
    0.00932686f, -0.03832505f, 0.00102028f, -0.04382768f, -0.01640732f, -0.00241934f, 0.00190107f, -0.04162626f, 
    -0.02646635f, -0.01350317f, 0.03009192f, 0.02939127f, 0.02286939f, 0.00448619f, 0.01009004f, -0.01964491f, 
    -0.04220131f, -0.02096455f, 0.00751410f, -0.03742946f, 0.02239602f, -0.02164073f, 0.00134810f, -0.04336046f, 
    0.00569700f, -0.04203759f, -0.01282788f, 0.00040381f, -0.01922419f, -0.01941743f, -0.03324495f, -0.02176646f, 
    0.00850612f, -0.01932904f, 0.01031367f, -0.02155726f, 0.00641741f, -0.00856742f, 0.02720978f, 0.02125371f, 
    -0.03758074f, -0.02238612f, 0.01544254f, 0.02707296f, -0.03045232f, 0.01808800f, 0.02998078f, -0.02545553f, 
    -0.01485493f, 0.03262752f, -0.01108351f, 0.01444979f, 0.00754084f, 0.01694116f, -0.03952820f, -0.00541520f, 
    -0.02042475f, 0.00594920f, -0.00787568f, -0.03003837f, 0.01009634f, -0.00818406f, -0.02093820f, -0.02644069f, 
    0.00937737f, -0.02603473f, -0.03792463f, -0.03526937f, 0.00648419f, -0.02021438f, 0.02165245f, 0.03372518f, 
    0.01680589f, -0.02705810f, -0.02848956f, 0.01405857f, -0.01104761f, -0.04269247f, -0.03138623f, -0.02704939f, 
    0.00837681f, 0.01278154f, 0.02853673f, 0.02832160f, -0.03567002f, 0.02750455f, -0.01197172f, -0.04298678f, 
    -0.00954607f, 0.01484114f, -0.01912756f, 0.00614260f, 0.00282985f, 0.00498128f, -0.02071572f, -0.02333956f, 
    0.00508748f, 0.02701419f, 0.03984855f, 0.00691206f, -0.00315756f, 0.00109404f, 0.00789211f, 0.01630951f, 
    0.00123378f, -0.02259653f, -0.01182254f, -0.03209319f, -0.01510592f, 0.02380709f, 0.00537879f, -0.00348535f, 
    0.00763419f, 0.02410899f, -0.00270976f, -0.03749198f, 0.00730365f, 0.02967770f, 0.02392778f, -0.01238962f, 
    -0.03737552f, -0.03653201f, -0.03527264f, -0.04086768f, -0.01626545f, 0.00440890f, 0.02514366f, 0.01442033f, 
    -0.01488454f, -0.00780302f, 0.02230959f, 0.01070546f, 0.00505642f, 0.03010283f, -0.01233104f, 0.00303419f, 
    0.00147958f, 0.01031226f, 0.01469574f, -0.02916193f, -0.00725418f, -0.02170536f, -0.02336034f, -0.03307753f, 
    -0.02615569f, 0.00073011f, 0.02400161f, -0.01920885f, -0.03965254f, -0.01389043f, -0.02320211f, -0.00790770f, 
    0.01160505f, -0.00835930f, -0.00315320f, 0.01339207f, -0.00719694f, -0.01844657f, 0.00807928f, 0.00717684f, 
    -0.02888482f, 0.02539153f, 0.03236791f, 0.01694188f, -0.01890003f, -0.02794200f, 0.00838810f, -0.00646165f, 
    0.01414745f, -0.01736081f, -0.00543738f, -0.03016905f, -0.01205923f, 0.00383697f, -0.01962971f, 0.02044448f, 
    0.02355498f, 0.01651109f, 0.00436605f, 0.01955344f, -0.01942154f, -0.01083677f, -0.03445221f, -0.01306697f, 
    0.00527058f, 0.03624500f, 0.01223503f, -0.02304069f, -0.02860572f, 0.02255674f, -0.02772013f, 0.02266145f, 
    -0.02196886f, -0.01869176f, 0.02049776f, 0.03095853f, -0.02256500f, 0.03006504f, -0.00389778f, -0.03218960f, 
    0.02601971f, -0.03075892f, 0.01324860f, -0.03535068f, -0.00158280f, -0.02235539f, 0.00090085f, -0.00477770f, 
    0.01981234f, -0.01999380f, -0.03791791f, -0.01908359f, -0.00352037f, 0.02151262f, 0.03006811f, 0.01881577f, 
    -0.00453735f, 0.00980456f, -0.03404833f, -0.03268080f, -0.00581336f, -0.01700711f, -0.00174651f, 0.01044037f, 
    -0.03525405f, -0.04068710f, -0.00283064f, -0.04076464f, 0.01004265f, -0.02528981f, -0.02810244f, 0.01466577f, 
    0.03140039f, -0.00133735f, 0.02021242f, -0.00786129f, -0.02197082f, 0.01285000f, 0.01615684f, 0.01239797f, 
    0.02568173f, 0.00405258f, -0.02282525f, 0.01669487f, -0.03356878f, -0.03956336f, -0.01415145f, 0.00724982f, 
    0.00517511f, -0.01853680f, -0.02959200f, 0.00757227f, 0.02146380f, -0.02645161f, -0.03384393f, -0.02275316f, 
    0.01326933f, -0.02479905f, -0.03455631f, -0.01996426f, 0.00514804f, -0.03796876f, -0.01800473f, 0.00982915f, 
    -0.02312171f, 0.01892137f, 0.01205291f, -0.01279628f, -0.04066446f, 0.01460291f, 0.02902320f, 0.02199906f, 
    -0.02348476f, 0.02749935f, 0.02292255f, -0.00157357f, 0.01743056f, -0.01533146f, -0.03391616f, -0.01327618f, 
    -0.01001601f, 0.02647565f, -0.03569062f, -0.01283530f, 0.02714248f, 0.00493084f, -0.03434114f, -0.02489410f, 
    -0.02474999f, 0.03128798f, 0.01953733f, 0.01175939f, 0.03554983f, 0.01170041f, -0.03090485f, -0.00280933f, 
    -0.03570745f, -0.02187356f, 0.01089229f, -0.00887115f, -0.01676707f, -0.00811372f, -0.03883748f, -0.00048219f, 
    0.01219175f, 0.01343944f, 0.00119942f, -0.02793332f, 0.01225949f, 0.01291399f, 0.02914320f, 0.00299817f, 
    0.03284339f, 0.00058277f, 0.00822265f, 0.00977317f, -0.02356424f, -0.03274256f, 0.01432421f, -0.04089928f, 
    0.01309953f, 0.01849426f, 0.00750278f, 0.00974045f, 0.02418779f, -0.00390839f, 0.01037298f, 0.01604406f, 
    -0.00838096f, 0.02634816f, -0.02348809f, 0.01060929f, 0.02387237f, 0.02123444f, -0.01052698f, -0.00628261f, 
    0.01766916f, -0.00372508f, -0.03475760f, 0.02329259f, 0.01889703f, 0.01176931f, -0.00504682f, -0.01493215f, 
    -0.01447059f, 0.00546911f, 0.00110362f, 0.00757733f, 0.01185713f, 0.01966168f, -0.02716435f, -0.01309022f, 
    -0.03563996f, 0.01839916f, -0.01738682f, -0.00953531f, -0.00837720f, -0.02112986f, -0.02634026f, -0.02046128f, 
    0.01854148f, 0.03190243f, 0.00895505f, 0.02508262f, -0.03788688f, -0.00511863f, -0.00692199f, 0.01044353f, 
    -0.01641525f, 0.02357228f, 0.01612359f, 0.01292575f, 0.02084930f, 0.00760477f, -0.02566127f, 0.02600457f, 
    -0.01958677f, -0.03392912f, -0.00296913f, -0.03248732f, -0.02041329f, 0.00290194f, -0.03939249f, 0.01064644f, 
    0.00158577f, -0.01193898f, 0.01684428f, 0.01170316f, -0.00810502f, 0.02899823f, 0.00279147f, 0.03031237f, 
    -0.01008098f, -0.02244962f, -0.01707620f, -0.02281183f, -0.00407726f, 0.03136591f, -0.00981240f, 0.01359731f, 
    0.01640739f, -0.02432389f, -0.00228775f, -0.02305362f, -0.00703316f, 0.01762398f, -0.00178864f, 0.03260419f, 
    -0.00493418f, 0.02106221f, -0.01596406f, 0.02980804f, -0.00436271f, -0.02987071f, 0.01530733f, 0.02143043f, 
    -0.01550570f, -0.00903604f, -0.02900859f, 0.00615842f, 0.02333060f, -0.00964964f, -0.03213423f, -0.01151534f, 
    0.01988150f, -0.00291117f, -0.03425914f, 0.00728877f, -0.00187875f, 0.01929146f, 0.01912758f, -0.04186431f, 
    0.01321312f, 0.02861977f, -0.03142674f, -0.01272887f, 0.03119860f, 0.03448846f, -0.01238184f, -0.00969790f, 
    0.02335570f, 0.00201893f, -0.00528088f, 0.00449677f, 0.00068386f, 0.01900807f, -0.02292731f, -0.01338188f, 
    0.01683705f, 0.00333027f, -0.02702919f, -0.00259843f, -0.02822031f, -0.02863755f, 0.00819298f, 0.00333883f, 
    0.02912801f, -0.03316301f, -0.02692152f, 0.00181107f, 0.01642212f, 0.01182099f, 0.01738187f, -0.00490327f, 
    -0.02449716f, 0.01329973f, -0.02275372f, -0.02347691f, -0.03619289f, -0.00568182f, -0.03688258f, -0.03686089f, 
    -0.03175984f, -0.02158180f, 0.00387662f, -0.03270146f, -0.00741885f, -0.02715129f, -0.01955558f, -0.00011389f, 
    -0.01923963f, -0.00406461f, 0.01896730f, -0.01015233f, 0.02233627f, -0.02039631f, -0.01841155f, -0.03626532f, 
    0.02868915f, 0.00435706f, -0.02459275f, -0.00118072f, 0.02519743f, 0.02474884f, 0.03718739f, -0.01187978f, 
    -0.01152656f, -0.01461391f, 0.00813521f, -0.00559440f, -0.02809548f, 0.00656242f, 0.00855651f, -0.03628413f, 
    -0.03197192f, -0.02479205f, 0.02783877f, 0.00721734f, 0.01597192f, 0.00320875f, 0.00143277f, 0.00163729f, 
    0.01423438f, -0.00215010f, -0.00390339f, -0.03659444f, -0.00360857f, -0.01594573f, 0.03035366f, -0.03255686f, 
    0.00681041f, -0.00537995f, -0.01602939f, -0.01630940f, -0.03678349f, -0.02559137f, -0.02513868f, 0.01052192f, 
    0.01080157f, 0.00937371f, 0.03102378f, -0.01605096f, 0.00558391f, -0.01143980f, -0.03000281f, -0.00266952f, 
    -0.04100151f, 0.01394263f, 0.00376084f, -0.00651609f, 0.00908746f, 0.00129825f, 0.01629464f, 0.02029411f, 
    -0.02104694f, -0.02755828f, -0.00500246f, -0.02974914f, -0.00272356f, -0.00199953f, -0.02661400f, -0.03358847f, 
    -0.01556414f, 0.01198594f, -0.02633012f, 0.00459801f, 0.00161675f, -0.02383247f, -0.01996419f, -0.01708073f, 
    -0.03527506f, -0.03342546f, -0.01406272f, -0.04197707f, -0.00184697f, -0.04418863f, -0.00886686f, -0.02079994f, 
    -0.01552906f, -0.02601752f, 0.02326193f, -0.03989526f, -0.03699698f, -0.03438413f, -0.02453278f, -0.03689700f, 
    -0.01005773f, 0.01700049f, 0.00248218f, -0.03701095f, 0.01982526f, -0.01710066f, -0.01501320f, -0.00018233f, 
    0.15160303f, 0.13848568f, -0.14443828f, -0.07004797f, 0.02424106f, 0.06734079f, 0.03399469f, 0.00627851f, 
    -0.14476798f, 0.14465229f, 0.20505215f, 0.08380455f, -0.20897393f, 0.14057489f, 0.08328166f, 0.06788007f, 
    -0.02738786f, 0.01455936f, 0.07730724f, -0.10095558f, -0.08821119f, -0.00150973f, 0.15159713f, -0.07786669f, 
    -0.22839496f, -0.03267876f, 0.02972232f, -0.14303930f, 0.01021175f, 0.10347080f, -0.04135684f, 0.05848585f, 
    0.00933723f, -0.06993523f, 0.14056337f, -0.02986044f, 0.14512922f, 0.08557661f, 0.14612383f, -0.00722978f, 
    0.07578377f, -0.07116253f, -0.00877471f, 0.02423894f, 0.18029639f, -0.01523704f, 0.04738929f, 0.21624333f, 
    0.09604853f, -0.04737383f, -0.12150928f, 0.16760820f, 0.02117057f, -0.00151116f, -0.14282866f, 0.08119594f, 
    -0.13264126f, 0.19498362f, 0.10657514f, 0.08828642f, 0.11230046f, 0.04021530f, 0.07527748f, 0.18810210f, 
    0.11115946f, 0.12607785f, -0.01031045f, -0.02305254f, 0.02269593f, -0.11854692f, 0.11583689f, 0.17393018f, 
    0.05315945f, 0.10426275f, -0.05677226f, 0.11003660f, 0.04614730f, -0.00985514f, 0.12365510f, -0.10232319f, 
    0.01929811f, 0.10524927f, 0.03773341f, 0.22828142f, 0.07687927f, -0.06535754f, 0.03849088f, 0.08768874f, 
    0.22094612f, 0.06641233f, 0.24855492f, 0.02029036f, 0.02855740f, -0.04928956f, 0.21164821f, -0.06956571f, 
    -0.07440086f, 0.10167973f, 0.06662451f, 0.06785503f, 0.09649789f, -0.02799783f, 0.12203497f, 0.12048368f, 
    0.17857949f, -0.10206700f, 0.01459836f, 0.12374163f, 0.47248852f, -0.16509993f, -0.25828201f, -0.19692124f, 
    0.01136097f, -0.03149466f, -0.07470248f, 0.11105876f, 0.09038054f, -0.13041669f, -0.18187824f, 0.05691958f, 
    0.03825663f, -0.14589912f, -0.17702568f, -0.11014181f, 0.00930692f, -0.12992959f, 0.15398954f, 0.06812638f, 
    0.11436585f, 0.02284191f, 0.16446435f, 0.07859333f, 0.22795083f, 0.09295203f, -0.13129272f, -0.03136117f, 
    -0.03842655f, 0.11160766f, 0.05316570f, -0.00158958f, 0.03075904f, 0.16639532f, -0.11436487f, -0.09297668f, 
    0.18042742f, 0.04199108f, -0.22862917f, -0.03661662f, -0.04834216f, -0.04563362f, 0.04921842f, 0.01782599f, 
    0.02422799f, -0.05278756f, 0.10192571f, -0.10875149f, -0.02217235f, 0.04407689f, 0.03611097f, 0.13640317f, 
    0.20494588f, 0.01177440f, 0.08964543f, -0.16811483f, -0.01025112f, -0.05207886f, 0.10721727f, 0.03004031f, 
    -0.07101279f, -0.09825334f, -0.05148403f, -0.00459026f, 0.05756666f, 0.22962491f, -0.01438518f, 0.01169269f, 
    0.02609658f, 0.05064926f, 0.06765275f, 0.02733489f, 0.19554485f, 0.07933255f, 0.04852151f, 0.13128813f, 
    -0.07599297f, 0.11119876f, 0.10938333f, 0.09026575f, -0.01235068f, 0.00974796f, 0.06426540f, 0.05720596f, 
    -0.17516263f, -0.04553780f, -0.03226544f, 0.06352749f, -0.00216630f, 0.03185117f, 0.16853151f, 0.16582876f, 
    0.03146957f, 0.01170363f, -0.00997645f, -0.00498105f, -0.38129824f, -0.03298663f, -0.17937484f, -0.24287196f, 
    0.11904859f, 0.02081067f, 0.05372322f, -0.04810599f, 0.01140300f, -0.03981755f, 0.00097879f, 0.04887075f, 
    0.10693769f, -0.17748663f, 0.06015841f, 0.16362339f, 0.05177038f, 0.04021270f, 0.11902492f, -0.03398604f, 
    -0.09505994f, 0.13293703f, 0.00911264f, 0.09011896f, -0.11605492f, 0.06421819f, 0.03964857f, 0.14472608f, 
    0.04483318f, 0.13340665f, -0.03212432f, -0.01509530f, 0.12414025f, 0.07447072f, -0.22720978f, 0.19563228f, 
    0.07461856f, -0.00548695f, -0.04967538f, 0.09323850f, -0.11430085f, -0.06200542f, 0.00080285f, 0.07826206f, 
    0.10883716f, 0.06460933f, -0.05508589f, -0.07540807f, -0.08176572f, 0.17625372f, 0.02818087f, 0.04369796f, 
    0.06044196f, 0.07094120f, 0.02304146f, 0.06387781f, 0.03078889f, -0.09606374f, -0.02276299f, -0.04967197f, 
    -0.17375225f, 0.07729185f, -0.25861120f, -0.07490105f, -0.13314104f, -0.00410624f, -0.07207143f, 0.05408327f, 
    0.09073169f, 0.00338322f, 0.19341390f, 0.04737218f, 0.28124246f, 0.07235363f, 0.09184668f, -0.15039422f, 
    -0.04363647f, -0.00373654f, 0.00590310f, -0.18148261f, -0.15850388f, -0.01039054f, 0.19540545f, 0.16040367f, 
    -0.24582446f, 0.28388661f, -0.11815426f, -0.02253154f, 0.00059120f, 0.05923510f, 0.04962358f, 0.12951358f, 
    0.09345752f, 0.14442436f, -0.08868238f, 0.07940207f, 0.18169764f, 0.18772726f, 0.12747274f, -0.02845233f, 
    0.00925237f, 0.10743789f, 0.06892902f, -0.01890109f, 0.09563934f, 0.10750227f, 0.08557709f, 0.18329690f, 
    0.00522231f, -0.08259118f, -0.10008775f, -0.04068322f, -0.01873169f, 0.08439334f, -0.10871308f, -0.03144715f, 
    0.05390321f, 0.13328606f, 0.10346973f, 0.07776551f, -0.07858717f, 0.03575507f, 0.04525871f, 0.15535223f, 
    0.12301340f, -0.14338250f, -0.15402320f, -0.02941396f, 0.07564296f, -0.16662399f, 0.06841258f, 0.02264947f, 
    0.07852752f, 0.03223178f, 0.05575639f, 0.10680923f, 0.00204068f, -0.01880545f, 0.24331675f, 0.08005507f, 
    0.06209472f, -0.05315726f, -0.02448883f, -0.13339910f, -0.09213037f, 0.14580519f, -0.08176292f, 0.11450207f, 
    0.10100526f, 0.07495046f, 0.07502180f, -0.03611992f, 0.12272281f, -0.10840593f, 0.22309016f, 0.02762288f, 
    0.13714723f, -0.12161095f, 0.06745163f, -0.15023784f, 0.08199037f, 0.05996623f, -0.01126547f, 0.02205017f, 
    0.08427330f, 0.01857034f, 0.06736392f, 0.11296886f, 0.14551876f, -0.04021953f, -0.09200414f, -0.01535325f, 
    -0.01287333f, 0.03326374f, 0.05357850f, 0.08790079f, 0.09419050f, 0.03905087f, 0.02404372f, 0.07874761f, 
    -0.12041541f, -0.13632171f, -0.20438504f, 0.11479707f, 0.08674221f, 0.16215381f, 0.04505942f, 0.00845400f, 
    0.09081344f, -0.09399784f, -0.15936998f, -0.00856377f, 0.22105077f, 0.00102066f, 0.06322929f, 0.16879219f, 
    0.06676503f, -0.17516930f, 0.05220296f, -0.06853198f, 0.01501964f, 0.06700469f, -0.22968195f, 0.06486280f, 
    -0.41958722f, -0.06538072f, 0.08517434f, -0.24456976f, -0.00122698f, 0.04198200f, 0.00435310f, -0.02613381f, 
    0.06228773f, -0.07843425f, 0.14655147f, -0.06126714f, 0.42577764f, 0.11569022f, -0.00404567f, -0.00313516f, 
    0.10417458f, 0.02511677f, 0.22597940f, -0.08112253f, 0.12406636f, 0.08360209f, -0.03670334f, 0.06648607f, 
    0.09668805f, -0.04028774f, -0.19928527f, -0.11849166f, 0.01495860f, 0.01405938f, 0.01191142f, 0.09069169f, 
    0.00371049f, 0.10177608f, 0.04820195f, -0.02768848f, 0.06395149f, 0.04003979f, 0.09053577f, 0.11227728f, 
    0.03187058f, -0.01502218f, -0.07327563f, 0.05452777f, 0.20700040f, 0.12112441f, 0.10288855f, 0.16979592f, 
    -0.02051882f, -0.06905904f, 0.00137638f, -0.09054579f, 0.04826189f, 0.05161450f, -0.16735311f, 0.14104480f, 
    -0.13562168f, -0.00924855f, 0.03404343f, 0.10780764f, -0.15371804f, -0.06040959f, 0.07575594f, -0.10466436f, 
    0.19063321f, 0.03087596f, 0.10521615f, 0.14714183f, 0.07818384f, -0.02953600f, -0.14210105f, -0.19568999f, 
    -0.01952488f, -0.11006017f, -0.00307240f, 0.18747917f, 0.06790589f, 0.06151221f, 0.00029554f, -0.01351566f, 
    0.09981152f, -0.04570005f, -0.05266583f, 0.04011541f, 0.03955056f, -0.04527080f, -0.09289438f, 0.11884529f, 
    -0.01533893f, 0.06737144f, 0.08628958f, -0.01465108f, 0.08188006f, 0.07284708f, -0.10877953f, 0.12183366f, 
    -0.14263006f, 0.05318728f, 0.03815313f, 0.05997607f, 0.07773793f, -0.03632860f, 0.00335446f, 0.10603518f, 
    0.09060107f, -0.06394733f, 0.07559140f, 0.02511157f, 0.08610655f, -0.20717344f, -0.04258167f, -0.06759261f, 
    0.09758446f, 0.03940343f, 0.00833383f, 0.03798586f, 0.07738057f, 0.09402051f, 0.06939984f, 0.06185979f, 
    -0.09948292f, 0.01357695f, -0.09004758f, -0.06172615f, 0.02305720f, 0.02399622f, -0.07577769f, -0.02158646f, 
    0.07666991f, -0.09472530f, 0.00976461f, 0.06034603f, -0.05913935f, -0.26048261f, 0.16963121f, 0.20141573f, 
    -0.02294249f, -0.04341831f, -0.01691439f, 0.02137528f, 0.07613435f, -0.07803942f, -0.12181050f, -0.10466310f, 
    -0.00225012f, 0.13468042f, -0.00097017f, 0.02966249f, 0.13326168f, -0.01487383f, 0.10601621f, 0.09964074f, 
    0.06527942f, -0.04000244f, -0.08604909f, 0.25812152f, -0.17030457f, -0.03870416f, -0.12076756f, 0.00428809f, 
    0.08050875f, -0.04648326f, -0.01522698f, 0.06580613f, 0.01615850f, -0.01881175f, 0.17854141f, 0.22089514f, 
    0.35141033f, 0.20145759f, 0.01570763f, -0.02867040f, -0.06273439f, 0.06190705f, -0.06877228f, 0.01009923f, 
    -0.04117417f, -0.08906981f, -0.06469080f, 0.13508806f, 0.08075008f, 0.22505036f, -0.11368088f, 0.10417899f, 
    -0.00944019f, -0.20506009f, 0.07876629f, -0.00066430f, 0.20448972f, 0.16259333f, 0.06309883f, 0.03889226f, 
    0.22860165f, 0.16755335f, 0.09999725f, 0.01573400f, 0.13238186f, -0.03853524f, -0.13046761f, -0.03146145f, 
    0.09394950f, 0.02743252f, 0.04180979f, -0.14960314f, -0.02830480f, -0.13021280f, -0.07704977f, 0.11585280f, 
    0.03554432f, -0.04372114f, 0.09246991f, 0.02399040f, 0.04797781f, 0.04688527f, 0.14161880f, 0.10438166f, 
    0.38089949f, -0.21555270f, -0.21245421f, -0.08626869f, 0.15341094f, 0.01138064f, -0.12836049f, 0.03390456f, 
    -0.02016330f, -0.10984404f, -0.03567523f, -0.06074865f, -0.03967373f, 0.06667905f, -0.02043913f, -0.02601633f, 
    -0.00971371f, -0.01898990f, 0.04359456f, -0.01026397f, 0.02532463f, -0.01722453f, 0.12315641f, -0.09768635f, 
    0.10021894f, -0.05243500f, 0.07736681f, 0.15554281f, 0.15934637f, 0.12325649f, -0.11292534f, -0.05060599f, 
    -0.00041707f, -0.01292651f, 0.13655646f, 0.09695580f, -0.00385094f, -0.17902806f, -0.28966242f, -0.09671134f, 
    -0.03096754f, -0.12141617f, -0.02418115f, 0.01278082f, 0.07818903f, 0.03741331f, -0.05790594f, 0.20829979f, 
    0.04538982f, -0.03446173f, 0.06819941f, 0.00971690f, 0.03258505f, -0.13008240f, 0.09616360f, -0.05453822f, 
    -0.10889298f, -0.17034499f, -0.08451723f, -0.09903516f, -0.33948299f, -0.18077748f, -0.18132910f, -0.12089190f, 
    0.03140135f, -0.10698979f, 0.00690205f, -0.04548497f, 0.16158691f, -0.16483288f, -0.05392001f, -0.05243296f, 
    0.11473411f, -0.09804180f, 0.07032757f, 0.12970529f, 0.11353000f, 0.04767816f, 0.01980439f, -0.04636439f, 
    0.04176750f, 0.17399909f, 0.13781850f, 0.24544755f, -0.26258376f, 0.19334441f, -0.29493654f, -0.04744226f, 
    -0.06867771f, -0.00488938f, -0.05565200f, 0.10306597f, -0.05327598f, 0.07318177f, 0.08335330f, 0.09713307f, 
    0.29203022f, 0.09929202f, 0.04914417f, -0.00805555f, 0.08624577f, -0.03499292f, 0.04992345f, 0.03314866f, 
    -0.01969478f, 0.03932636f, -0.03718922f, 0.11923541f, 0.12601271f, -0.20865144f, -0.03376048f, 0.14509654f, 
    0.11447625f, 0.13006039f, 0.00589582f, -0.14235809f, -0.07553599f, 0.11464950f, 0.06257663f, 0.09862363f, 
    0.06979248f, 0.02248764f, 0.09267572f, -0.15297495f, 0.05329515f, 0.08808758f, -0.04391139f, 0.12467145f, 
    -0.00674303f, 0.17460352f, 0.03454535f, 0.10392316f, -0.25355121f, 0.02739330f, -0.03943991f, 0.06881913f, 
    -0.03434275f, 0.01439509f, -0.03496923f, 0.14387214f, 0.02060706f, 0.07113198f, -0.03639480f, -0.05366637f, 
    0.02482228f, 0.01517410f, 0.01292288f, -0.02549566f, -0.02803010f, -0.03100193f, 0.03307927f, 0.02722245f, 
    -0.00212626f, -0.03914304f, 0.01733956f, -0.01262939f, -0.00763081f, -0.01126143f, 0.01045735f, -0.03885318f, 
    0.01155323f, 0.02597897f, 0.01388658f, 0.01101369f, 0.00279367f, -0.03011335f, 0.02530094f, -0.01815232f, 
    -0.00112554f, -0.02368963f, -0.03917193f, -0.02616806f, -0.01029325f, -0.03392560f, -0.03562582f, -0.01614835f, 
    -0.00995074f, -0.00063447f, 0.00734385f, 0.00083569f, -0.03766051f, 0.02032490f, -0.00685642f, -0.03137796f, 
    -0.03556026f, 0.03123293f, 0.02920171f, -0.01867573f, -0.01828209f, -0.02045511f, -0.03345273f, -0.03122466f, 
    0.02620152f, 0.03235648f, -0.00576924f, 0.02208032f, -0.03202611f, -0.02302724f, -0.00299565f, -0.00802966f, 
    0.01039983f, 0.01894073f, 0.03034339f, 0.02267367f, -0.01226169f, 0.01384541f, -0.01652280f, -0.00206747f, 
    -0.01079560f, -0.00921189f, 0.00979872f, 0.00882060f, 0.03261282f, 0.02875170f, -0.03436848f, 0.02767855f, 
    -0.01936264f, 0.02068223f, -0.01688837f, -0.03506554f, 0.03251790f, -0.00223200f, 0.01113950f, -0.02518184f, 
    0.02985103f, -0.01825888f, -0.01940772f, 0.00364975f, 0.00619392f, 0.01755366f, 0.00620067f, 0.01803412f, 
    -0.03346151f, -0.02577908f, 0.02114207f, -0.01686357f, 0.01300259f, 0.00758756f, -0.01412268f, 0.01106061f, 
    -0.01784379f, -0.00091156f, -0.00170161f, -0.00055985f, -0.02892270f, 0.00384751f, -0.01770064f, 0.00203343f, 
    0.02421277f, -0.01467295f, -0.00364683f, 0.01735573f, -0.02024168f, -0.02761966f, 0.02444912f, 0.01426792f, 
    -0.03374657f, -0.01327155f, 0.01424108f, -0.01981352f, 0.01255510f, 0.00895322f, -0.01531513f, 0.00845197f, 
    0.02615824f, 0.00705359f, -0.00445491f, -0.02956737f, 0.03064995f, -0.04027142f, 0.01535966f, -0.01035765f, 
    0.00713349f, 0.01800347f, 0.02544972f, 0.00338338f, 0.02425173f, 0.02572190f, -0.03824214f, -0.02308999f, 
    0.01239810f, -0.00675504f, 0.01156533f, -0.01168038f, 0.01345153f, -0.00209815f, -0.03536686f, 0.02661522f, 
    0.00376900f, -0.02059077f, 0.01129521f, -0.01899289f, -0.00995421f, 0.02625470f, 0.00774784f, -0.01404904f, 
    -0.01434617f, 0.01582659f, 0.00941662f, 0.00494509f, -0.00067329f, 0.00200006f, -0.01333586f, 0.00352639f, 
    0.03794120f, 0.02112093f, 0.01259302f, 0.01506404f, -0.02572745f, -0.00180254f, 0.00737029f, -0.01573879f, 
    -0.02879253f, -0.01275628f, -0.02384273f, -0.03496130f, -0.02445517f, -0.01447387f, 0.01363543f, -0.00312361f, 
    -0.03225973f, -0.03090254f, 0.00094404f, -0.00046376f, -0.00331842f, 0.01083605f, -0.01561246f, 0.00115890f, 
    0.01216397f, 0.00152312f, -0.02608206f, -0.02733490f, -0.00589069f, 0.01475297f, 0.01969445f, 0.01528158f, 
    -0.00218844f, -0.00794263f, -0.01961340f, -0.03268257f, 0.00027433f, -0.02209548f, -0.02955901f, -0.00671412f, 
    -0.00091311f, 0.03305689f, 0.00080537f, -0.03279933f, -0.02478125f, -0.02625296f, -0.02765228f, -0.01623299f, 
    -0.01349873f, 0.02915278f, -0.03932021f, -0.03554317f, -0.01114793f, -0.00621629f, -0.00241268f, 0.00044333f, 
    0.00331503f, -0.00456882f, 0.02495551f, -0.01372493f, -0.02765857f, 0.01443989f, -0.04006686f, -0.00637669f, 
    0.01183822f, -0.00369737f, -0.03595448f, 0.03051848f, 0.00466364f, 0.02782889f, -0.01133380f, -0.01369387f, 
    0.02493439f, -0.03653792f, -0.01942220f, 0.01037223f, -0.03848899f, 0.01225509f, -0.00327361f, 0.02652508f, 
    -0.03675196f, -0.00404359f, -0.03214489f, -0.03426609f, -0.03630020f, -0.00070115f, -0.02509584f, 0.02795646f, 
    -0.00050652f, 0.00505855f, -0.01662239f, -0.03831598f, -0.02840404f, 0.02576734f, 0.02214673f, -0.00300800f, 
    -0.02666428f, -0.01292817f, 0.02390221f, -0.00153852f, -0.01729502f, 0.02615408f, -0.03523079f, -0.02613001f, 
    0.00218391f, -0.01853016f, 0.00589082f, 0.02332118f, -0.01958920f, 0.00055391f, -0.02832037f, 0.00476700f, 
    0.01392257f, -0.02722315f, -0.03269773f, -0.00571611f, -0.01247845f, -0.01198891f, -0.00365247f, 0.01348039f, 
    0.01995471f, 0.00204156f, -0.03103306f, 0.00435813f, 0.01791171f, 0.01605196f, 0.00824825f, -0.03229924f, 
    -0.03810061f, 0.00312698f, -0.02474239f, -0.01082286f, 0.01298509f, 0.00309981f, -0.02137374f, 0.00782341f, 
    0.02832042f, 0.00611671f, -0.02250698f, 0.03097659f, -0.03642539f, -0.00762972f, -0.01770403f, 0.01106983f, 
    -0.00273656f, -0.01233473f, -0.01735367f, 0.01299852f, -0.00730415f, 0.02639570f, -0.02200064f, 0.02280650f, 
    0.03060782f, -0.01897771f, 0.01099333f, 0.01174559f, 0.00895407f, 0.00317139f, 0.02654276f, -0.02359844f, 
    -0.00468709f, 0.00840636f, -0.03599552f, 0.01510296f, 0.01839464f, -0.00313026f, 0.01595279f, 0.00998303f, 
    -0.00439775f, 0.00896072f, -0.03107402f, -0.03627476f, -0.02689185f, -0.03350843f, 0.00254173f, -0.00862954f, 
    -0.01327518f, 0.01854523f, -0.02007861f, 0.00141590f, 0.03429195f, -0.02680187f, -0.00030749f, 0.00642923f, 
    -0.02380303f, 0.03047299f, -0.00703000f, -0.01908389f, -0.03819608f, 0.02499289f, -0.03643560f, 0.02830884f, 
    -0.00244650f, -0.00740059f, -0.00299791f, -0.01558930f, 0.00649598f, -0.03782362f, -0.00564084f, -0.00636827f, 
    -0.02857875f, -0.02510929f, 0.01530402f, 0.01474119f, 0.02367853f, 0.01797953f, -0.02085049f, 0.01937427f, 
    0.00004560f, 0.02281716f, 0.00918368f, 0.01562965f, 0.03699790f, -0.03877680f, -0.03351520f, -0.00867878f, 
    0.01824920f, 0.02796639f, 0.00691786f, -0.00666034f, -0.02833720f, 0.03171517f, -0.01575824f, -0.02743494f, 
    0.03824422f, 0.03320256f, -0.01855492f, 0.02174522f, -0.02506115f, -0.03800251f, 0.00237482f, -0.01977247f, 
    -0.00755208f, -0.02217285f, 0.02746574f, 0.03096285f, 0.00037308f, -0.03380004f, 0.00309078f, 0.02019248f, 
    -0.00783960f, -0.00620548f, -0.02595571f, -0.03738729f, 0.00175145f, -0.03368166f, -0.02055207f, -0.02811605f, 
    0.00861014f, -0.01188462f, -0.03558911f, 0.00673279f, -0.02099748f, 0.02400996f, -0.01470870f, -0.01408610f, 
    0.02260643f, 0.00760125f, 0.01186311f, -0.02825237f, -0.03472963f, 0.00743600f, -0.04186031f, -0.00833091f, 
    0.02632934f, -0.02394061f, -0.03499228f, 0.00104802f, -0.02214849f, 0.00341703f, 0.00328602f, 0.03091268f, 
    -0.00918995f, -0.00717025f, 0.00064944f, 0.00417356f, -0.02444856f, -0.02757736f, 0.01609974f, -0.01765167f, 
    -0.00497381f, -0.03121752f, -0.00118991f, -0.02646378f, -0.03105127f, -0.02721260f, -0.02258915f, -0.00167250f, 
    -0.00399128f, 0.00669399f, -0.02354483f, 0.01303118f, 0.01300391f, -0.01058578f, 0.01657526f, -0.01453452f, 
    0.02316620f, -0.00781331f, -0.01593892f, -0.03079486f, -0.03442806f, -0.00890397f, 0.02805683f, -0.00296795f, 
    -0.01534556f, 0.02615562f, -0.01863593f, -0.02289184f, 0.02190158f, 0.04227832f, 0.02662921f, 0.02889702f, 
    0.00755758f, 0.01360403f, -0.03575787f, 0.00920741f, -0.03095349f, -0.02428592f, -0.00585128f, 0.02916668f, 
    -0.01926951f, -0.01752131f, -0.04276851f, -0.02050648f, -0.03176793f, 0.00794594f, -0.02057813f, 0.00461731f, 
    -0.01208014f, -0.00872955f, 0.02276737f, -0.02070057f, 0.01898279f, 0.03229168f, -0.01264639f, 0.00353837f, 
    -0.02838592f, -0.01012759f, 0.03296253f, 0.02307722f, 0.01163840f, -0.02446277f, -0.02312804f, -0.02662186f, 
    0.02300865f, -0.01715576f, 0.00942215f, 0.01747686f, 0.02978000f, -0.03434328f, -0.01977593f, 0.02237719f, 
    -0.02438770f, -0.02386981f, -0.03982964f, 0.01226306f, -0.02930219f, -0.01064106f, 0.01027713f, 0.01397117f, 
    0.02141083f, 0.00572797f, -0.04223298f, -0.00644463f, 0.03156348f, -0.03162399f, -0.00096143f, 0.01655625f, 
    -0.02919231f, -0.00605688f, 0.01348956f, 0.01021513f, -0.03446208f, 0.02447301f, -0.01804907f, 0.02937901f, 
    -0.02713289f, -0.02044535f, 0.01613429f, 0.03031337f, -0.02769396f, -0.00629811f, -0.03131263f, -0.03038706f, 
    0.01502890f, 0.01911842f, -0.03771076f, 0.01820599f, 0.00112026f, -0.01482805f, -0.00067296f, -0.01567344f, 
    0.00206310f, -0.00573695f, -0.01250435f, 0.01470073f, -0.02616450f, -0.02142801f, 0.02546509f, -0.02333063f, 
    0.02117226f, -0.00688094f, -0.04067783f, 0.00730214f, 0.00934004f, 0.03378348f, 0.00758431f, 0.01475345f, 
    0.01400613f, -0.00964692f, -0.00151309f, -0.02431841f, 0.02472287f, -0.02720383f, 0.02764612f, -0.01404727f, 
    0.02059243f, 0.01197490f, -0.02191016f, 0.02346457f, -0.03019137f, -0.00407597f, -0.00403539f, 0.02657783f, 
    0.03030455f, -0.02235761f, 0.02965567f, 0.03062039f, -0.02094343f, -0.01854176f, -0.01241697f, -0.00421777f, 
    0.01298116f, 0.02301381f, 0.02842640f, -0.03384411f, -0.02379148f, 0.01106924f, -0.01231442f, -0.02175622f, 
    -0.00247159f, -0.03558121f, 0.02852473f, 0.00971975f, 0.00737448f, -0.02121654f, 0.02575639f, -0.03233696f, 
    -0.00746573f, 0.01540879f, -0.00334066f, -0.02571657f, 0.03622144f, -0.03435287f, 0.03310101f, -0.01489785f, 
    0.01192475f, 0.02847377f, 0.00591158f, -0.00390455f, -0.00092505f, -0.02546771f, 0.01988637f, -0.02943228f, 
    0.01770297f, -0.00711662f, -0.00142629f, 0.02848701f, -0.02389961f, -0.02861455f, 0.02977929f, -0.01284495f, 
    -0.03306103f, 0.00877253f, -0.00946190f, -0.02997270f, -0.01543161f, 0.03813245f, 0.00021331f, 0.00603983f, 
    -0.01060096f, -0.02401794f, 0.00455835f, 0.03193036f, -0.02641552f, 0.01077416f, -0.02683080f, -0.01316416f, 
    0.00018267f, 0.02464655f, -0.01463137f, 0.00219396f, 0.01166229f, 0.02253073f, -0.01134227f, -0.02294385f, 
    0.02709202f, 0.00936386f, -0.00351435f, 0.00519757f, -0.00721998f, 0.00340157f, -0.02333873f, -0.03474148f, 
    0.00263970f, -0.02397105f, 0.00986954f, 0.01072847f, -0.02649735f, 0.01905050f, 0.00730353f, -0.02342218f, 
    -0.00852968f, -0.02026264f, 0.02167226f, 0.01087123f, -0.04466813f, 0.01971019f, 0.00375883f, 0.01446337f, 
    -0.01659198f, 0.01864930f, -0.03598315f, 0.00584508f, 0.03985735f, -0.02036666f, -0.02831083f, 0.02435116f, 
    -0.00021761f, 0.01302014f, -0.01151359f, 0.00680017f, -0.01930343f, 0.01008634f, -0.03719273f, -0.00391952f, 
    0.01333026f, 0.01190723f, 0.02357152f, 0.01723438f, 0.03285589f, -0.00820780f, 0.00260951f, -0.01239628f, 
    -0.00566906f, -0.00289237f, -0.00593937f, 0.02871445f, 0.00888317f, 0.03335090f, -0.01539649f, -0.02842912f, 
    0.01576456f, 0.03076408f, -0.02372345f, -0.03231753f, -0.01060108f, -0.00188789f, 0.02101097f, 0.03176865f, 
    -0.01725656f, 0.02743704f, -0.03155765f, 0.01923543f, 0.00574841f, -0.00900451f, -0.01054263f, -0.01095801f, 
    -0.03550473f, -0.00791002f, 0.00426345f, 0.02155629f, -0.01999038f, -0.02423936f, -0.03227725f, -0.00203098f, 
    -0.00787815f, 0.00418153f, 0.02634453f, 0.00064166f, 0.02515063f, -0.00478296f, -0.03720930f, -0.01943237f, 
    0.01323898f, 0.01080509f, -0.02328271f, 0.01031705f, 0.02822401f, -0.02818158f, -0.01579332f, 0.00578968f, 
    0.02142445f, -0.01129799f, -0.01680611f, 0.02502636f, -0.00776180f, -0.01127195f, 0.02532852f, 0.00392539f, 
    -0.00390888f, -0.01660394f, -0.00532725f, 0.01841265f, -0.03737509f, 0.00215009f, -0.00330088f, 0.00848361f, 
    -0.02857417f, -0.01750384f, -0.03369724f, -0.03272509f, 0.01684410f, 0.01441066f, -0.03932489f, -0.01302593f, 
    -0.00993511f, -0.02680475f, -0.01187694f, 0.04063202f, -0.00563886f, -0.01139335f, 0.00560428f, 0.01068180f, 
    -0.00374805f, -0.00221838f, -0.00881951f, -0.01584833f, 0.02842188f, 0.02517592f, -0.03482264f, -0.04338480f, 
    -0.01349776f, 0.01451154f, 0.02159052f, 0.00243686f, 0.02130788f, 0.00470830f, -0.00759165f, 0.02306869f, 
    -0.02133095f, -0.01842184f, 0.00093922f, 0.00669919f, -0.02773141f, 0.01336016f, -0.02551335f, 0.03126427f, 
    -0.00036605f, -0.02276611f, 0.01319761f, -0.02527870f, 0.01387057f, 0.01809582f, 0.01151335f, 0.01730701f, 
    -0.00946363f, 0.01341015f, -0.00754987f, 0.02682768f, -0.02356902f, -0.02411896f, 0.01980485f, 0.00191119f, 
    -0.02803769f, -0.01058262f, -0.01561442f, -0.02348343f, -0.02336967f, 0.02069053f, -0.03186069f, -0.04019303f, 
    -0.01852271f, 0.02353986f, 0.00375659f, 0.01056875f, -0.03198913f, 0.02816403f, 0.03163355f, 0.01451378f, 
    -0.00911789f, -0.02646748f, -0.00358952f, -0.02906587f, -0.00098989f, -0.02987839f, -0.02971695f, -0.01261286f, 
    0.01175983f, 0.02567861f, -0.01274240f, -0.02887638f, 0.02943385f, -0.02280212f, 0.00658958f, -0.04193827f, 
    -0.02454047f, 0.01649939f, 0.00058224f, -0.00557033f, -0.01042873f, 0.03913320f, -0.03139343f, -0.00933772f, 
    -0.00172564f, -0.01619016f, 0.02838936f, -0.03952534f, 0.00468810f, -0.00127986f, -0.02928143f, -0.00140677f, 
    0.02347613f, 0.02095515f, -0.03564888f, 0.00669133f, -0.00804836f, 0.03074723f, -0.01840511f, -0.02331113f, 
    0.01194172f, -0.01212010f, 0.01105959f, -0.03765548f, 0.02026061f, -0.02298403f, -0.01284570f, -0.02259216f, 
    -0.03851509f, -0.02992948f, 0.01094593f, -0.01535164f, -0.03985801f, 0.00824360f, -0.03265903f, 0.00075587f, 
    0.01896149f, 0.02640097f, 0.00417682f, -0.03652652f, 0.01773321f, 0.00530322f, -0.01334965f, 0.02401141f, 
    0.00661815f, 0.01872617f, 0.00923027f, 0.01947248f, 0.02765771f, 0.02007239f, 0.01866230f, 0.00733470f, 
    0.02203978f, -0.02634850f, -0.00922374f, 0.01466625f, -0.00318209f, -0.01411920f, 0.02088716f, 0.01766883f, 
    -0.01697656f, -0.02865527f, -0.00889301f, -0.00665621f, 0.00167284f, -0.01350996f, -0.01624911f, -0.03778543f, 
    0.00218926f, 0.01966817f, -0.01370026f, 0.02874957f, -0.01886858f, 0.00985236f, 0.00648427f, -0.02963771f, 
    0.02384875f, 0.00934999f, -0.02980344f, 0.00591679f, -0.00302042f, -0.03484740f, -0.02795083f, -0.01179664f, 
    -0.02477369f, -0.01997394f, 0.00743251f, -0.02902260f, 0.00591597f, -0.00675732f, -0.04476514f, -0.01580878f, 
    0.02557831f, -0.01641200f, -0.02345354f, 0.01753625f, -0.01076023f, 0.01383445f, 0.03090581f, 0.04343884f, 
    -0.00821588f, -0.03097642f, -0.00585668f, -0.02528961f, 0.02554574f, 0.01133222f, 0.00839967f, -0.00370747f, 
    -0.03047536f, -0.01995371f, -0.00209922f, 0.02068440f, -0.02930171f, 0.01183834f, -0.00565716f, 0.00033278f, 
    0.01096002f, -0.03361119f, -0.03072621f, 0.02903200f, -0.01513588f, -0.02418640f, -0.02084032f, -0.02389726f, 
    0.01675089f, -0.02148248f, 0.02845729f, 0.01675073f, -0.00744105f, 0.01537223f, 0.01705573f, 0.00600905f, 
    0.02668326f, -0.03667242f, -0.01423649f, 0.03243402f, -0.00860753f, 0.01290908f, 0.01590403f, -0.01631912f, 
    -0.02107203f, 0.01989056f, -0.01786057f, -0.02653782f, -0.02148152f, 0.03201719f, -0.01771744f, 0.02449809f, 
    -0.03536643f, -0.02104426f, -0.02870163f, 0.00726294f, -0.01256703f, 0.01171858f, -0.00011531f, -0.03376278f, 
    -0.01296048f, -0.01255608f, -0.01284503f, 0.02000796f, 0.02609912f, 0.02804104f, 0.02066806f, 0.00982855f, 
    -0.01034912f, 0.01898848f, 0.01586176f, 0.00285800f, 0.00616835f, 0.02611643f, 0.02836856f, 0.00383475f, 
    0.00951677f, 0.00438177f, -0.03041272f, -0.00629915f, -0.00454717f, 0.03467032f, 0.02058889f, 0.04442616f, 
    0.01980222f, 0.02908778f, 0.02508218f, -0.00395178f, -0.00441269f, 0.00882110f, 0.02097671f, -0.00905928f, 
    0.02877184f, -0.02255691f, 0.00764785f, -0.01724372f, -0.01332641f, -0.00399296f, 0.00455283f, 0.01382103f, 
    0.01816172f, -0.00421931f, 0.02423634f, -0.00549151f, -0.01440429f, -0.02157260f, -0.01925350f, -0.00656410f, 
    0.00697071f, 0.00683026f, 0.00986248f, -0.00169136f, -0.00221417f, -0.02017514f, -0.01028014f, -0.00086135f, 
    0.02112146f, 0.01250616f, -0.00486883f, 0.01678494f, -0.01762466f, 0.01608669f, -0.02224829f, 0.00045692f, 
    -0.02381483f, 0.03979103f, -0.02223814f, -0.01809816f, 0.01331820f, -0.03136509f, -0.03594718f, 0.01962111f, 
    0.02927368f, -0.03438754f, -0.02290198f, -0.01440606f, -0.02904942f, -0.01322289f, -0.04208228f, 0.01402934f, 
    0.02048268f, 0.02050441f, -0.03904683f, 0.03489333f, 0.02082422f, 0.02009886f, 0.01331213f, -0.01055982f, 
    -0.02153324f, -0.04239703f, -0.02459413f, -0.00949770f, 0.00582181f, -0.00846532f, -0.02169172f, 0.00552711f, 
    0.00576557f, -0.03845435f, -0.01052832f, -0.01286361f, 0.04092648f, 0.00932422f, 0.02330298f, 0.00154088f, 
    -0.03883113f, 0.01736802f, -0.00240775f, -0.00232532f, 0.02519935f, -0.02299925f, 0.00762740f, -0.02033427f, 
    0.01810443f, -0.00748794f, -0.02499319f, -0.00220526f, 0.00609747f, -0.02825461f, -0.01025171f, -0.01893107f, 
    -0.00378432f, 0.00564072f, 0.02943878f, -0.00810336f, -0.01882690f, -0.01337099f, 0.00702660f, 0.00769729f, 
    0.00958241f, -0.02558241f, -0.01995869f, 0.02962686f, -0.03495824f, -0.03585564f, 0.01512002f, 0.02734884f, 
    -0.03898342f, 0.00529561f, -0.03493582f, 0.01188700f, -0.02235557f, -0.03798845f, 0.02455752f, -0.01908950f, 
    0.00577793f, 0.02214288f, 0.00341150f, 0.02253628f, -0.03796881f, -0.00687307f, -0.03697728f, 0.01033299f, 
    0.02918303f, -0.01537170f, -0.01634075f, -0.01833964f, -0.00497581f, -0.03524474f, -0.03016192f, -0.01437033f, 
    0.02249651f, -0.02540444f, 0.02402128f, 0.01409604f, 0.01032643f, -0.02119312f, -0.01252650f, -0.01085207f, 
    0.00641151f, 0.02931536f, 0.01240877f, 0.01593892f, 0.01035242f, -0.00896717f, -0.00236490f, -0.02628952f, 
    -0.02267398f, 0.02759377f, 0.02960946f, -0.01130935f, 0.00790702f, -0.01479813f, -0.01176720f, -0.02491389f, 
    0.02056409f, 0.03054742f, -0.00936495f, -0.03806020f, -0.01468524f, -0.02687565f, 0.03558337f, -0.02233048f, 
    -0.02116930f, -0.01647221f, 0.02641934f, -0.03468880f, 0.01347185f, -0.00585959f, -0.03553154f, -0.01095629f, 
    -0.03540634f, -0.01413414f, -0.00027687f, -0.00939891f, 0.00868931f, -0.01753281f, 0.00729481f, 0.01372227f, 
    0.03360936f, -0.03117503f, 0.01696174f, 0.02789294f, -0.01251927f, -0.03833691f, -0.01222852f, 0.00706809f, 
    0.00832010f, -0.00913992f, -0.00686418f, -0.03499318f, 0.01876776f, -0.01172208f, 0.03233726f, 0.02150007f, 
    -0.00060515f, -0.00935037f, -0.02678326f, 0.01957023f, 0.01737658f, -0.02200568f, -0.02932015f, -0.02665673f, 
    -0.02899065f, -0.01340009f, -0.02593614f, -0.01082014f, -0.02880444f, 0.02306902f, -0.02798314f, -0.03036385f, 
    -0.01110476f, 0.02961802f, -0.02724042f, -0.03076158f, 0.01473462f, -0.04038433f, -0.01412117f, -0.03744910f, 
    0.01231327f, 0.01837322f, 0.02015571f, -0.01412723f, 0.01820274f, 0.01545880f, 0.01892434f, 0.01086637f, 
    0.02649260f, 0.00976682f, -0.00028907f, 0.02609434f, -0.02264461f, 0.00933774f, 0.00964063f, 0.02708354f, 
    -0.00379144f, 0.02842730f, 0.02803556f, -0.01830662f, -0.03726666f, -0.02582065f, -0.01334611f, 0.01459939f, 
    -0.00304256f, -0.00363352f, -0.01166626f, -0.03045742f, 0.02069948f, 0.00652737f, 0.02994769f, 0.00072234f, 
    -0.01537701f, -0.02708557f, -0.01683439f, -0.03776100f, -0.02822925f, 0.01564734f, 0.02827974f, 0.02750944f, 
    0.01984632f, 0.03771584f, 0.00970234f, 0.01689883f, 0.00634630f, -0.02937862f, -0.02524007f, 0.00068963f, 
    -0.01593292f, -0.01305832f, 0.00521553f, -0.02597742f, -0.01754677f, 0.02420014f, 0.01437797f, -0.03217310f, 
    0.01380308f, -0.00151611f, -0.00706867f, 0.01120192f, 0.02889058f, 0.01901207f, 0.00319328f, 0.02175716f, 
    -0.01206243f, -0.03116130f, 0.01420833f, 0.02889950f, 0.00314951f, 0.03706617f, 0.00899793f, -0.00448529f, 
    -0.03620439f, 0.02859836f, -0.03598079f, -0.00624756f, -0.01749131f, -0.02428184f, -0.04475820f, -0.01848649f, 
    -0.02460082f, -0.01601009f, 0.02713328f, 0.02364754f, 0.01439376f, 0.00082083f, -0.03362529f, -0.02345209f, 
    0.01989750f, -0.01745792f, 0.00714079f, -0.03578317f, -0.01678377f, 0.01973638f, -0.02915766f, -0.02875745f, 
    -0.01713492f, -0.02782795f, -0.01655633f, -0.00913551f, -0.01950356f, -0.01680477f, 0.01376153f, -0.02330814f, 
    -0.00718780f, -0.02843146f, -0.03902608f, -0.03209671f, 0.01471964f, -0.02280785f, 0.02165811f, -0.03182350f, 
    0.00424135f, -0.02445777f, -0.00377379f, -0.03905957f, 0.01554215f, -0.03076553f, 0.01993971f, 0.00165692f, 
    0.02349375f, -0.00592683f, -0.02323321f, 0.01915366f, -0.00797069f, 0.01077986f, -0.03850183f, -0.01981036f, 
    -0.03459121f, 0.00673447f, -0.00133864f, -0.00266984f, -0.02533300f, 0.04301516f, -0.02386188f, 0.03144806f, 
    -0.02441593f, -0.01025547f, 0.00829521f, -0.04294235f, -0.00125881f, -0.02382307f, -0.02107005f, -0.02730044f, 
    -0.03347644f, -0.01174248f, 0.00515364f, 0.03705923f, 0.00892154f, -0.01799763f, 0.01828365f, -0.00339354f, 
    0.00573801f, -0.01791878f, -0.01994789f, -0.02726004f, 0.02527278f, 0.01431169f, -0.00522543f, -0.02485571f, 
    -0.00695215f, 0.03988250f, 0.02632915f, -0.01028726f, 0.01663468f, 0.02257749f, 0.02373686f, 0.01722272f, 
    -0.00635399f, 0.00326640f, -0.02296678f, 0.02455993f, 0.01645662f, -0.01929360f, -0.01964088f, -0.01214688f, 
    -0.02641104f, 0.02773130f, -0.01904376f, -0.03926182f, 0.01232376f, -0.01405109f, 0.03175520f, -0.01806268f, 
    -0.03918693f, 0.01998316f, 0.00187654f, 0.00656604f, 0.01732297f, 0.00864633f, -0.02871460f, -0.03036028f, 
    0.01021736f, -0.00527819f, 0.01556618f, 0.00467227f, 0.00715776f, 0.03711904f, -0.01394974f, -0.02487664f, 
    0.01596097f, -0.01812138f, -0.00961907f, -0.01872645f, 0.03240164f, -0.00661650f, -0.03670699f, -0.01737812f, 
    0.01706256f, 0.00230550f, 0.01452651f, -0.03088973f, 0.00975001f, 0.02621007f, -0.02340264f, -0.02381353f, 
    0.02712881f, 0.02474356f, -0.04160527f, 0.02623252f, -0.02717907f, -0.03193630f, -0.03882165f, 0.02352792f, 
    -0.02589297f, -0.01658269f, -0.01840719f, -0.03418272f, -0.02410912f, -0.02619771f, -0.01387454f, 0.01113118f, 
    0.02279827f, -0.01214946f, 0.01853182f, 0.00042150f, -0.01658550f, -0.00147464f, 0.01822457f, 0.01644124f, 
    0.01356683f, 0.01178396f, 0.01716860f, 0.02253926f, 0.00189753f, -0.00195871f, 0.02313425f, -0.02176208f, 
    -0.03149340f, -0.01067290f, 0.03754384f, 0.02555772f, -0.03146964f, 0.02102970f, 0.02187523f, -0.00980793f, 
    0.01136016f, -0.03710317f, 0.00483076f, -0.02628469f, 0.02608220f, 0.01527368f, 0.02079980f, 0.00475042f, 
    0.01686057f, 0.00057471f, 0.01040784f, 0.01156063f, 0.01975089f, 0.02163283f, -0.00918344f, -0.01642208f, 
    0.03737811f, -0.05003723f, 0.11206163f, 0.29985869f, -0.04204371f, 0.06637082f, -0.06375199f, -0.01038149f, 
    0.00186958f, -0.05649250f, 0.02819319f, 0.23793055f, -0.08465500f, -0.52471417f, -0.05586711f, 0.13252962f, 
    -0.02925633f, 0.20709768f, 0.04252944f, -0.03050143f, 0.00348296f, -0.02702083f, 0.01745318f, 0.09763287f, 
    0.23980497f, 0.02618997f, 0.03597887f, 0.30006817f, 0.00579371f, -0.03959691f, -0.01803701f, 0.17033216f, 
    -0.15558232f, 0.02314191f, 0.07633674f, 0.05885493f, 0.19685410f, 0.07135469f, 0.10000947f, -0.23707853f, 
    -0.01676099f, 0.06556420f, 0.03338672f, 0.01000012f, -0.01830624f, 0.00249997f, -0.00490955f, 0.06113572f, 
    -0.00763288f, 0.20425750f, 0.16611330f, -0.13571203f, -0.04184557f, 0.12595163f, 0.04694593f, -0.01866200f, 
    -0.02767646f, 0.14833601f, 0.07723626f, -0.04199384f, -0.29487669f, 0.04544554f, -0.08733243f, 0.19504923f, 
    -0.01291352f, 0.11917045f, 0.00140660f, 0.08520912f, -0.04142810f, -0.02307391f, -0.00596366f, -0.02206194f, 
    -0.10022516f, 0.04143872f, 0.15834670f, -0.04285217f, 0.05351756f, 0.00375944f, 0.10034715f, -0.03117315f, 
    0.04254100f, -0.01162577f, 0.12126363f, -0.11611222f, -0.05514061f, -0.12738858f, 0.17671192f, -0.13406445f, 
    -0.09991799f, -0.08134647f, -0.08246431f, -0.01161432f, -0.13244687f, 0.16360410f, 0.01688793f, -0.02766982f, 
    -0.12764545f, -0.08189050f, -0.00985186f, 0.32280809f, 0.01054658f, 0.01696942f, -0.01973713f, 0.02142682f, 
    0.05114054f, -0.00366706f, 0.02751819f, -0.04490232f, -0.11969531f, -0.06616103f, -0.41062775f, -0.03181628f, 
    -0.06007325f, -0.02197361f, -0.04164587f, -0.13490538f, -0.02280413f, 0.01122276f, 0.06984825f, 0.00612133f, 
    0.19771138f, 0.13713637f, 0.07623032f, -0.09092751f, 0.09463852f, 0.06358129f, 0.04307354f, 0.00807376f, 
    0.12856306f, 0.10390447f, 0.08912113f, 0.12436970f, -0.33798200f, 0.10184176f, 0.07347284f, -0.12647930f, 
    0.06397836f, 0.04423076f, 0.03718554f, -0.02647339f, 0.01831403f, -0.00042301f, 0.02159438f, -0.03134388f, 
    -0.37200180f, -0.21650614f, -0.07995053f, -0.08733131f, 0.00664714f, -0.04893097f, -0.19636405f, 0.04957225f, 
    0.12104259f, 0.01753824f, 0.07323677f, 0.15154050f, -0.24872854f, 0.07253176f, 0.19159837f, -0.01363167f, 
    -0.04663263f, 0.01188429f, 0.08358929f, -0.07639298f, -0.00804717f, 0.08920377f, -0.11588853f, 0.02427283f, 
    -0.11228478f, 0.06178355f, -0.08523922f, -0.03618123f, 0.10446136f, -0.01868273f, -0.01357172f, -0.16779868f, 
    -0.06533219f, -0.08833365f, 0.03471437f, -0.01083556f, -0.16709115f, 0.07906641f, -0.07305423f, 0.16969089f, 
    -0.09108438f, -0.01758057f, 0.04191428f, 0.06733149f, 0.03591826f, 0.01290887f, 0.00326776f, -0.03617268f, 
    0.13722464f, 0.29613176f, 0.01635604f, 0.08744334f, -0.06058459f, -0.13293159f, -0.07897414f, -0.09698814f, 
    -0.04896010f, -0.03380340f, -0.11516684f, -0.13678201f, 0.36834118f, 0.14804891f, 0.35479367f, 0.21928720f, 
    -0.06569117f, 0.01187035f, 0.03437976f, 0.14553738f, -0.01846818f, 0.04222080f, 0.26492745f, 0.05425303f, 
    -0.40255770f, -0.04168814f, -0.11982613f, 0.12562564f, -0.00324550f, -0.09403495f, -0.00069068f, 0.01477257f, 
    0.24176359f, 0.05996077f, 0.03146464f, 0.02646249f, -0.12110227f, -0.05140172f, 0.18312570f, -0.18602483f, 
    -0.06465426f, 0.10177535f, -0.09021192f, 0.01112814f, 0.01815538f, -0.03287447f, 0.02853807f, 0.01441154f, 
    -0.16003329f, 0.01215256f, -0.00740952f, -0.37030146f, -0.06677281f, -0.10411907f, -0.08018244f, 0.03973629f, 
    -0.14697109f, 0.00632891f, 0.00926274f, -0.17534071f, -0.05977190f, -0.17849165f, 0.00914249f, 0.34091187f, 
    -0.12754248f, -0.04157844f, -0.06907719f, 0.04698263f, -0.12875769f, 0.04707205f, -0.05799427f, -0.02061198f, 
    -0.22755754f, 0.10564580f, -0.06216335f, 0.28203690f, 0.11579723f, 0.06940983f, -0.16365096f, 0.04654710f, 
    -0.02249771f, 0.06432007f, -0.16817270f, 0.06434920f, -0.13315509f, 0.09176370f, -0.17602286f, 0.12051756f, 
    -0.10168074f, -0.05864182f, 0.12396280f, 0.11696956f, 0.10890966f, -0.04881624f, -0.12636422f, -0.02761021f, 
    -0.12528905f, 0.03836462f, 0.04752563f, 0.23695180f, 0.11840654f, 0.02487715f, 0.05651467f, -0.03341035f, 
    -0.07730982f, -0.07178379f, 0.06850732f, -0.10113902f, -0.21660827f, 0.06818160f, 0.11698622f, -0.13265929f, 
    -0.04824739f, 0.02309456f, 0.04883508f, -0.03749372f, -0.01600873f, 0.05732606f, 0.00058982f, -0.06880433f, 
    -0.10240278f, -0.06626526f, 0.00926903f, 0.26630318f, 0.15516782f, -0.14123909f, 0.00495470f, 0.09667110f, 
    0.01740129f, 0.08312327f, -0.12365157f, -0.01812988f, 0.10405465f, 0.09265140f, 0.09444940f, 0.09878156f, 
    0.03194014f, 0.07072034f, 0.08316459f, -0.11503530f, -0.12896550f, 0.00861260f, 0.03634245f, 0.00026608f, 
    0.01671461f, -0.05665502f, 0.09505107f, -0.02035531f, 0.01766562f, 0.16644190f, -0.10550680f, -0.15209027f, 
    -0.01891141f, -0.08060690f, 0.26785842f, -0.10580391f, 0.31440198f, -0.09630933f, 0.00356664f, 0.24367757f, 
    0.09464081f, 0.03833869f, 0.02021803f, 0.08817807f, -0.04406657f, -0.10490368f, -0.08979706f, -0.00844923f, 
    -0.01100066f, 0.07087661f, -0.10415967f, 0.18583135f, -0.15711375f, -0.00668082f, -0.13527115f, 0.03118719f, 
    0.26085877f, 0.01545900f, -0.09594144f, 0.00345115f, -0.63700485f, 0.08322292f, 0.08087733f, -0.20217033f, 
    0.10036629f, 0.02848720f, 0.04098125f, 0.01723570f, -0.02729538f, 0.06905817f, -0.02355593f, 0.07014826f, 
    0.20519204f, 0.25949210f, 0.23285596f, -0.18633388f, -0.09887847f, 0.04394595f, 0.06774592f, -0.07584184f, 
    -0.12868111f, -0.02329376f, 0.07299896f, -0.00629279f, -0.04962520f, 0.12416680f, -0.12579279f, 0.03167728f, 
    0.07460745f, 0.06179397f, -0.12878253f, 0.19186166f, -0.03554571f, 0.04230405f, 0.02566624f, -0.02934622f, 
    0.36986306f, 0.07019073f, -0.24117732f, 0.16908149f, -0.19128284f, 0.10867136f, -0.07525162f, -0.02126134f, 
    -0.05210531f, 0.03659827f, -0.04909321f, 0.15052000f, -0.01242186f, -0.01767999f, -0.04712876f, -0.01878939f, 
    -0.07803512f, -0.02617671f, 0.04903756f, 0.09672900f, -0.07376383f, -0.14658548f, 0.02336317f, 0.02613539f, 
    0.01086283f, 0.05467680f, -0.06111924f, -0.13290870f, -0.08378659f, 0.18969403f, 0.07693478f, 0.06304302f, 
    0.04176842f, -0.02432198f, 0.08958636f, -0.01714792f, -0.21607119f, 0.01648654f, 0.20289254f, 0.00029740f, 
    -0.08163591f, -0.03643712f, -0.07577439f, 0.01232563f, 0.14962004f, -0.03995077f, 0.11641558f, 0.06310120f, 
    0.27359179f, 0.12962659f, 0.27105418f, -0.17598805f, -0.01311681f, 0.04178935f, 0.07154685f, -0.02395401f, 
    0.12534460f, -0.07383130f, 0.02686559f, 0.01334060f, 0.06884885f, 0.24221146f, -0.06952508f, 0.32664657f, 
    0.12793772f, 0.10393706f, -0.00206674f, 0.01482373f, -0.05396293f, 0.07125580f, 0.06693803f, 0.01100054f, 
    -0.28376749f, 0.06808973f, 0.13633056f, -0.36172679f, 0.09575815f, -0.00197304f, 0.01560000f, -0.02507171f, 
    0.04718794f, 0.15667549f, 0.04089132f, 0.22858766f, 0.00705559f, 0.09397865f, 0.12841867f, -0.25495178f, 
    -0.00113035f, 0.02011529f, 0.14699066f, -0.14060669f, 0.13489661f, -0.02923515f, -0.08872064f, 0.05145639f, 
    0.27740267f, 0.14472221f, 0.01857364f, -0.19440000f, -0.04349023f, 0.09435787f, 0.05139949f, -0.01099398f, 
    -0.04845615f, -0.10286135f, 0.05857172f, 0.09168463f, -0.13329382f, 0.19139722f, 0.11531743f, -0.00156238f, 
    0.04545091f, 0.00050757f, 0.16563241f, -0.08458532f, -0.05902460f, -0.06421027f, 0.16844220f, -0.08890191f, 
    0.04295107f, -0.14378215f, 0.38130832f, 0.01547808f, 0.01134649f, -0.04363908f, 0.19328922f, 0.09738654f, 
    0.17254519f, 0.04421693f, -0.06838883f, -0.01035485f, 0.27437770f, -0.22938813f, 0.44935313f, 0.34735709f, 
    0.22290930f, 0.02917340f, -0.00589622f, 0.01216718f, -0.01686702f, 0.21636654f, -0.15322255f, 0.14416960f, 
    -0.06135274f, 0.05121285f, -0.06709474f, 0.06993376f, 0.06965845f, 0.05372018f, -0.02513677f, 0.00284955f, 
    -0.03016947f, -0.00131520f, 0.06119957f, -0.12006439f, -0.15105821f, -0.14274441f, -0.08974244f, -0.03022505f, 
    -0.03129577f, -0.08799514f, -0.04100911f, 0.04284970f, -0.04288271f, 0.08540340f, 0.06650037f, 0.07410256f, 
    -0.10239429f, -0.06052216f, 0.07332084f, 0.03677410f, -0.03272995f, 0.07694311f, 0.00836725f, 0.13017955f, 
    -0.01537332f, -0.02204207f, -0.01731423f, 0.10764357f, -0.22984634f, -0.05704648f, 0.07461777f, 0.08993817f, 
    0.22065862f, -0.00693488f, 0.04978056f, 0.07011025f, -0.07848787f, 0.11576531f, -0.14887679f, -0.04617572f, 
    -0.20160367f, 0.20796730f, 0.31857139f, -0.11381158f, -0.25324747f, -0.00156309f, 0.11039381f, 0.03454558f, 
    0.12427429f, -0.11527128f, -0.03312084f, 0.03273865f, -0.26750910f, -0.10303202f, -0.08883288f, -0.16048424f, 
    0.16333032f, -0.06621867f, 0.12694474f, 0.04540306f, -0.03695132f, 0.04404514f, -0.00074506f, -0.02408797f, 
    -0.29370832f, 0.07347841f, -0.22208534f, -0.23480043f, -0.12057105f, 0.03851311f, -0.01375533f, -0.27368787f, 
    0.13326654f, 0.05212787f, 0.08888035f, 0.13611323f, -0.30065039f, -0.25047567f, 0.01482726f, -0.01233792f, 
    0.02482785f, 0.12267831f, 0.04082994f, -0.10191965f, -0.12271076f, 0.14163321f, -0.01248944f, -0.03160715f, 
    -0.10338013f, 0.11816001f, 0.11558167f, -0.04147300f, -0.04811423f, -0.04332186f, 0.12354939f, -0.00692427f, 
    -0.11195368f, 0.04719796f, 0.09443602f, 0.02690019f, 0.06083968f, 0.01415243f, -0.13177416f, -0.03837316f, 
    0.06795586f, 0.10615075f, -0.05188784f, -0.18881088f, 0.08245791f, -0.13750766f, 0.02164813f, 0.05324293f, 
    0.28892449f, 0.07848097f, 0.28512520f, 0.15849493f, 0.05540267f, 0.06432556f, 0.17316771f, 0.00952126f, 
    0.00373102f, 0.00162598f, 0.01488616f, 0.06405916f, 0.40161806f, 0.11732783f, -0.14338468f, 0.07897972f, 
    0.18532731f, 0.17954409f, 0.01838071f, 0.00999648f, 0.01134466f, -0.22301979f, -0.08542646f, 0.10996939f, 
    -0.13578305f, 0.07756459f, 0.19989865f, -0.37929448f, 0.04791613f, -0.01930127f, -0.05519482f, 0.01312744f, 
    -0.02462643f, 0.03080458f, 0.08621251f, 0.09187167f, 0.08996110f, 0.16059914f, 0.11785793f, -0.03806584f, 
    0.12650707f, 0.01097771f, 0.15453479f, 0.10904392f, -0.01311306f, 0.05768066f, 0.08677796f, 0.00439474f, 
    -0.32818156f, 0.11011547f, -0.08246858f, 0.12188550f, -0.01419873f, 0.13070951f, 0.04265346f, -0.04898878f, 
    0.05601772f, -0.06089620f, 0.06119990f, 0.01058584f, -0.00480504f, 0.06608091f, 0.01539852f, 0.04532598f, 
    -0.12982267f, -0.05901377f, 0.08730122f, 0.03944596f, -0.01567798f, -0.07639684f, -0.02944311f, 0.14734656f, 
    0.10169528f, 0.06406631f, 0.02163859f, -0.02770878f, -0.09110884f, 0.08318767f, 0.04783460f, 0.08557933f, 
    -0.01647113f, -0.07101572f, 0.01866234f, 0.06591525f, 0.09822836f, -0.32392710f, 0.17777023f, -0.05811875f, 
    0.09287462f, -0.05498497f, 0.08247179f, 0.00687987f, 0.15706696f, 0.06492914f, -0.02593958f, -0.02699657f, 
    0.02248510f, 0.01614276f, 0.02506401f, -0.02322703f, -0.01937236f, -0.01995277f, 0.02677428f, 0.01848475f, 
    0.01681058f, -0.01616019f, -0.00049740f, -0.02599565f, 0.02524921f, -0.03172772f, 0.02465433f, 0.02081533f, 
    0.01216281f, 0.01290494f, -0.03688102f, -0.01121029f, 0.02499439f, -0.02472694f, -0.01114977f, -0.00090469f, 
    -0.03141279f, -0.03001109f, -0.02416346f, 0.00097428f, 0.01673502f, 0.00157320f, 0.01234077f, 0.00409447f, 
    -0.03449024f, -0.02655464f, -0.00403419f, 0.02280943f, 0.01410333f, 0.01856863f, -0.02730154f, 0.02597909f, 
    -0.02956858f, 0.00662273f, -0.02238376f, 0.01657872f, -0.03835129f, -0.02070678f, 0.00522548f, -0.03510037f, 
    -0.01716124f, 0.02014459f, -0.02202990f, 0.00860278f, 0.02651195f, 0.00917676f, -0.02478098f, -0.00438679f, 
    -0.01345698f, -0.00676321f, 0.00160090f, 0.02851787f, -0.01383840f, 0.02607288f, -0.03759797f, 0.00542497f, 
    0.02018369f, -0.02698582f, -0.02051595f, 0.01435090f, 0.01059549f, -0.02629742f, -0.04093907f, 0.00597923f, 
    0.02012822f, -0.03879191f, 0.01250485f, 0.01928959f, -0.01433558f, 0.00039219f, -0.00202242f, 0.01887853f, 
    -0.00863130f, 0.02648221f, -0.00415165f, -0.02576970f, 0.03886274f, 0.02815553f, 0.00696992f, -0.01526455f, 
    0.02740283f, -0.02714597f, -0.00708771f, -0.02397140f, 0.00566679f, 0.02620130f, 0.00029731f, -0.00515985f, 
    0.02440051f, -0.00723816f, 0.02982542f, -0.02034095f, 0.00346328f, 0.03103960f, -0.02128042f, -0.02785296f, 
    -0.04117039f, 0.02477528f, -0.02840893f, -0.01088577f, -0.02663399f, 0.00385999f, -0.01873343f, -0.01691833f, 
    0.00562645f, -0.02664352f, 0.02528540f, 0.00117127f, -0.00523225f, -0.02689575f, -0.00993194f, -0.01767250f, 
    -0.02238188f, -0.03865444f, -0.01647721f, -0.00030305f, -0.03755654f, -0.00255442f, -0.02716187f, 0.01221092f, 
    0.00403079f, -0.02642407f, -0.03336772f, 0.00446017f, -0.00705406f, 0.00206049f, -0.00011500f, 0.02867361f, 
    0.02189338f, -0.00593930f, -0.00708887f, -0.01142004f, -0.02660866f, -0.03358094f, -0.01941499f, -0.00076298f, 
    0.02179178f, -0.02454517f, -0.01752336f, -0.00990151f, 0.01778485f, 0.01120991f, -0.02455307f, -0.03956008f, 
    -0.02754916f, 0.02452688f, -0.03775831f, -0.04294014f, -0.00421487f, -0.00535834f, -0.03762699f, 0.01596726f, 
    -0.03461324f, 0.01318223f, -0.00982145f, -0.03428320f, -0.04245330f, 0.01087115f, 0.00809516f, -0.02988045f, 
    -0.00121466f, -0.00239828f, 0.01545731f, 0.02410853f, 0.02235687f, 0.02268152f, -0.01226055f, 0.01763466f, 
    -0.01412430f, -0.01575445f, 0.00772135f, -0.03674559f, -0.00669216f, -0.01406291f, -0.02122749f, -0.01172853f, 
    -0.04176986f, 0.02783507f, -0.03989340f, 0.00402468f, -0.02071953f, -0.03602303f, 0.01490345f, -0.02503192f, 
    0.02510448f, -0.01221698f, -0.03046647f, -0.03606268f, -0.00666747f, -0.02529505f, -0.03542526f, -0.00974753f, 
    -0.00393089f, 0.00614884f, 0.02654744f, -0.04092539f, -0.01489809f, 0.01440056f, 0.00680785f, 0.00003042f, 
    0.02501093f, 0.02410853f, -0.03343252f, -0.00839753f, -0.02868766f, -0.02702091f, -0.03670466f, -0.02226502f, 
    0.00633930f, 0.01752654f, -0.01201953f, -0.01791258f, 0.03259347f, -0.01382427f, -0.03446108f, -0.02919947f, 
    0.01383457f, -0.03258354f, 0.00706646f, -0.00322666f, -0.04078334f, -0.00108720f, -0.00514917f, -0.04048487f, 
    -0.00882110f, -0.00033872f, 0.00254861f, -0.02188428f, 0.01276080f, 0.00206864f, -0.01413514f, 0.01793290f, 
    -0.00414279f, -0.04244941f, -0.02764264f, 0.02728185f, 0.02165938f, -0.03398575f, -0.03485906f, -0.00480380f, 
    -0.02287656f, -0.02028326f, 0.01527752f, -0.00756392f, 0.00271219f, 0.00194160f, -0.02421478f, -0.03392851f, 
    0.01063631f, 0.01566028f, 0.02188084f, 0.01277067f, -0.03474683f, -0.03543621f, 0.02733118f, 0.01468133f, 
    -0.03138908f, -0.04155144f, 0.02668710f, -0.00982353f, -0.00432465f, -0.00970987f, 0.01258513f, -0.01801595f, 
    -0.01305989f, -0.01405217f, -0.03358032f, 0.00531012f, 0.02230798f, 0.01625212f, -0.02121484f, -0.04257736f, 
    0.01367711f, 0.03124788f, 0.00053298f, 0.01742866f, -0.00709387f, -0.00911639f, -0.02467709f, -0.02200725f, 
    -0.02868430f, 0.01260943f, -0.01500203f, 0.00962080f, 0.01809146f, 0.02799296f, -0.01024053f, 0.01264881f, 
    0.00921288f, -0.02883604f, -0.03157939f, -0.02359770f, 0.00323055f, 0.02238157f, -0.00573042f, -0.01969632f, 
    -0.03541484f, -0.00868152f, 0.02472553f, 0.00920510f, -0.01745745f, -0.02515433f, -0.02605410f, 0.01547825f, 
    0.02555081f, 0.01438195f, 0.02986681f, 0.01468930f, 0.00021222f, 0.02640348f, 0.01999711f, -0.03498218f, 
    0.02368451f, -0.01914418f, 0.02871499f, 0.00107713f, -0.01512034f, 0.01908766f, 0.02717110f, -0.00764890f, 
    -0.03101766f, -0.04094322f, -0.03724547f, -0.00364309f, 0.00984634f, 0.00465747f, -0.03487779f, -0.00840689f, 
    -0.01712522f, -0.01496597f, -0.00238908f, -0.00855688f, -0.01929516f, 0.00531736f, 0.01668417f, 0.01866998f, 
    0.02139198f, -0.00838118f, -0.01376215f, 0.01873065f, 0.02178263f, 0.00437153f, -0.01339949f, -0.00593730f, 
    -0.00036024f, -0.02856994f, 0.01024683f, 0.01315516f, -0.01113748f, -0.01088115f, -0.03620987f, 0.01400654f, 
    0.00893890f, -0.01061085f, 0.00324745f, -0.00544706f, -0.03343047f, 0.03024511f, 0.00488490f, -0.02554191f, 
    -0.04184372f, 0.02543116f, -0.03703506f, 0.02041133f, -0.03399435f, -0.00240516f, 0.00702734f, 0.01188879f, 
    -0.02691596f, -0.00734609f, 0.02747905f, -0.03523589f, -0.00168196f, -0.02835712f, -0.02903332f, 0.00879814f, 
    -0.01491500f, 0.00029100f, -0.00289191f, -0.00363070f, 0.00260985f, -0.04416284f, 0.02708653f, -0.03374984f, 
    0.03092459f, -0.01683483f, -0.01271642f, 0.01188804f, -0.03564393f, 0.02242806f, -0.01780542f, 0.02374097f, 
    0.02147714f, 0.02743003f, 0.02751101f, -0.00563262f, 0.02820381f, -0.00795429f, 0.01529117f, -0.01801476f, 
    -0.02416004f, -0.01613381f, -0.02072346f, 0.00900312f, -0.00942304f, 0.00335261f, -0.01817231f, 0.01865660f, 
    0.00954016f, -0.00218197f, -0.00508761f, -0.01864152f, 0.03199309f, -0.01383357f, 0.02816361f, -0.00305517f, 
    -0.02623679f, -0.00259172f, -0.03714280f, 0.01905019f, 0.02136271f, 0.01085046f, -0.00358035f, 0.01414369f, 
    0.02515694f, -0.01771522f, -0.02175546f, 0.01579592f, 0.01141621f, 0.01438540f, -0.03728595f, -0.03005354f, 
    0.00051862f, 0.02070101f, 0.00529113f, -0.01277077f, -0.01830762f, -0.03471714f, 0.00978481f, -0.01075870f, 
    0.01604803f, 0.02787976f, -0.00880348f, -0.02527668f, -0.00309803f, 0.01575537f, -0.03144163f, -0.01781695f, 
    0.04244984f, -0.01036270f, -0.00511335f, -0.02578283f, 0.00642199f, 0.01719819f, -0.02427017f, 0.02303077f, 
    -0.03480119f, 0.02435257f, -0.01239274f, -0.03383224f, -0.02860991f, 0.03166549f, -0.02723604f, 0.00144848f, 
    -0.03451091f, -0.02245358f, 0.02941168f, -0.02560892f, 0.03577306f, 0.02397895f, -0.00826937f, -0.00982547f, 
    0.01985234f, -0.01243001f, -0.03899896f, -0.02159705f, -0.02795301f, 0.00871582f, 0.02556517f, -0.01049250f, 
    0.02091181f, -0.02636309f, -0.00640286f, 0.00730054f, -0.01788010f, -0.00856586f, 0.02236869f, 0.02354620f, 
    -0.00817988f, 0.01594130f, -0.01038790f, -0.03936975f, 0.00008913f, -0.01421888f, 0.01750096f, -0.02500868f, 
    -0.02443597f, 0.00050158f, -0.02301410f, -0.03666069f, -0.04247456f, -0.01337856f, -0.00760529f, 0.01301596f, 
    0.01543965f, -0.03377740f, -0.03578705f, -0.03151973f, 0.01861876f, 0.00349278f, -0.02647019f, -0.02704560f, 
    -0.03665932f, -0.01087757f, 0.00670801f, 0.01292246f, -0.01609432f, 0.00170493f, 0.01125155f, 0.00440288f, 
    0.00584717f, -0.01895840f, -0.01421958f, 0.00684519f, -0.04403136f, -0.02981430f, 0.00921345f, 0.00943410f, 
    -0.00076466f, -0.01845072f, -0.02487076f, -0.00414986f, -0.00676962f, -0.00381988f, -0.02228508f, 0.00319499f, 
    0.02220533f, -0.04109900f, 0.01612643f, 0.02804363f, 0.02590488f, 0.01505161f, 0.03542596f, 0.02339559f, 
    -0.02488639f, 0.00081028f, -0.00101408f, -0.02806568f, 0.01346891f, 0.00841209f, -0.02129956f, -0.02009830f, 
    0.03172169f, -0.02649329f, -0.03519012f, 0.01275941f, 0.02595906f, 0.03213987f, -0.01099120f, 0.02213784f, 
    0.00248582f, -0.00544953f, -0.01433467f, 0.01160318f, 0.02825519f, 0.02585710f, -0.00413832f, 0.00478158f, 
    -0.03999602f, -0.03454290f, -0.02739336f, -0.02367750f, -0.00920317f, -0.02734556f, 0.00998230f, 0.00030478f, 
    -0.02818012f, -0.03448194f, 0.03270291f, 0.02887768f, 0.00318330f, 0.02059734f, 0.01363051f, -0.00265422f, 
    -0.03071537f, 0.01030196f, 0.00981092f, -0.04019890f, 0.01282488f, -0.00250255f, 0.02030635f, 0.00438049f, 
    -0.02820583f, 0.02771712f, 0.01357971f, 0.01401684f, 0.00725175f, -0.03580663f, 0.01483258f, -0.02370469f, 
    -0.01556458f, -0.03867731f, 0.00632427f, 0.02456323f, -0.00435782f, -0.01958208f, -0.01974215f, 0.02791568f, 
    0.02049338f, 0.02987577f, 0.02189734f, -0.00809347f, -0.02317276f, -0.00291279f, 0.01930170f, -0.00547560f, 
    -0.00061369f, -0.01250185f, 0.00814603f, -0.03206153f, -0.02219065f, 0.02154607f, -0.00677840f, 0.02301152f, 
    -0.01832800f, 0.02566675f, 0.01882506f, 0.00735608f, -0.03547907f, 0.01185848f, -0.01131007f, 0.00482498f, 
    -0.02591789f, -0.04166532f, -0.01873614f, -0.01825566f, -0.03698149f, 0.03153318f, -0.02353401f, 0.02807462f, 
    -0.01305489f, -0.00888781f, 0.02526786f, 0.00156783f, 0.02366420f, -0.01370811f, 0.01258631f, -0.02177326f, 
    0.00752682f, -0.02474793f, -0.00571812f, 0.03292590f, 0.04221952f, -0.03280843f, -0.03395113f, 0.02874410f, 
    -0.00860898f, -0.01179471f, 0.02558934f, 0.02738107f, -0.03064346f, 0.00159303f, -0.02003885f, -0.00731924f, 
    0.03690350f, -0.01571592f, -0.03903783f, -0.01191387f, 0.02229655f, -0.00791454f, -0.01803113f, 0.00067192f, 
    -0.00139292f, 0.00872352f, 0.01208424f, 0.00107907f, 0.01769474f, 0.00075413f, 0.01216535f, -0.00363587f, 
    -0.04232801f, -0.01442554f, -0.01553277f, -0.03360533f, -0.02981920f, -0.03818054f, 0.01337859f, 0.03601428f, 
    0.02233084f, 0.01623426f, -0.01311128f, 0.00229963f, -0.03365542f, 0.01286574f, -0.00237159f, -0.02897355f, 
    -0.01273784f, -0.02529196f, -0.04201530f, -0.00794329f, -0.01630976f, 0.00553008f, 0.00885133f, 0.02764158f, 
    0.00532847f, -0.02511927f, 0.00276256f, -0.03592263f, 0.02341537f, -0.01737292f, -0.00517761f, 0.02691337f, 
    -0.00992660f, -0.00573986f, 0.00025661f, 0.02194060f, -0.02218037f, -0.01133181f, 0.02429062f, -0.01027645f, 
    -0.01589036f, 0.03045421f, -0.01127673f, -0.02797690f, -0.03136193f, -0.00747944f, 0.01408308f, -0.03059921f, 
    0.01600809f, -0.02030741f, -0.03489577f, 0.02045692f, -0.02828942f, 0.01310343f, -0.02907464f, 0.01940715f, 
    -0.02267192f, -0.01369527f, -0.00712464f, 0.01212938f, -0.01702957f, -0.01870035f, 0.00688693f, -0.00808469f, 
    -0.00116579f, 0.02710742f, 0.02473222f, 0.02701953f, -0.01668325f, 0.03148067f, 0.00186874f, 0.03193050f, 
    -0.00305086f, 0.03455757f, -0.02074569f, 0.01070934f, -0.04300317f, -0.03356726f, 0.01330730f, -0.03248286f, 
    -0.01728279f, -0.03661663f, -0.01325304f, 0.01668013f, -0.03624000f, 0.01343514f, 0.02186074f, -0.01830738f, 
    -0.04147434f, -0.03750064f, 0.02776235f, 0.00561249f, -0.02205014f, 0.02602747f, 0.00071222f, -0.00818578f, 
    -0.03426965f, 0.01380713f, -0.03221340f, -0.01730789f, -0.00683290f, 0.04041322f, 0.00939529f, -0.00456476f, 
    0.03654228f, -0.03759804f, -0.02930025f, 0.02857739f, -0.03191039f, 0.02810764f, -0.00248360f, 0.02767944f, 
    -0.01799452f, 0.02885276f, 0.02217425f, -0.01708628f, 0.00504193f, 0.03209173f, 0.01826223f, -0.02701627f, 
    -0.00458465f, -0.02936034f, 0.00591795f, 0.00964908f, 0.00113982f, 0.00522413f, -0.00297422f, 0.02965853f, 
    -0.02257467f, -0.00545208f, 0.00022770f, -0.02274942f, -0.00875153f, -0.01391951f, 0.02048476f, -0.01236962f, 
    -0.03725237f, -0.00076524f, -0.01420600f, 0.02935682f, 0.01825353f, 0.01247159f, 0.02457918f, 0.00714878f, 
    -0.02591957f, 0.01615530f, 0.01054759f, -0.02933244f, -0.00403580f, -0.03612048f, -0.01448859f, 0.01900946f, 
    0.00986239f, -0.03184956f, -0.02037697f, -0.00801212f, -0.00386804f, 0.01999913f, -0.03135759f, 0.00945874f, 
    -0.00849206f, -0.03231755f, -0.01115451f, -0.03446697f, 0.00186324f, -0.00704644f, 0.02002295f, 0.00845827f, 
    0.00836870f, -0.00299048f, -0.03981649f, 0.00978798f, -0.00803434f, -0.02772992f, -0.01507275f, 0.00802877f, 
    0.02340652f, -0.03972553f, -0.01836792f, 0.00995199f, 0.00550485f, -0.00531216f, -0.03952257f, -0.01427568f, 
    -0.02035833f, -0.00245542f, 0.01783022f, 0.02080579f, 0.02434657f, 0.01065874f, 0.01544215f, -0.01460504f, 
    -0.01887228f, 0.02579116f, -0.01432367f, -0.03396454f, -0.02123179f, -0.02494848f, -0.02477724f, 0.01703562f, 
    0.02071832f, -0.02316756f, -0.00791324f, -0.03824645f, 0.03270714f, 0.00933996f, -0.00170573f, 0.02922491f, 
    -0.00312521f, -0.03813035f, -0.01942699f, 0.02462407f, 0.01081157f, -0.03231240f, -0.03798959f, -0.01858869f, 
    -0.00297554f, -0.02292520f, -0.03113434f, 0.03610384f, 0.00366315f, -0.00659356f, -0.00057041f, -0.03132864f, 
    0.00607379f, 0.00412047f, 0.00018406f, -0.02573197f, -0.02460966f, 0.02557167f, -0.02406904f, -0.02313617f, 
    0.01479895f, -0.03933471f, 0.01431945f, 0.00029496f, 0.01124131f, 0.02620634f, 0.00033476f, -0.00544291f, 
    -0.00809242f, 0.02174984f, -0.03982906f, 0.01489697f, -0.00046836f, -0.02624907f, -0.01670052f, 0.02020200f, 
    -0.00590344f, -0.01882282f, 0.01193746f, -0.00407277f, 0.01930438f, 0.00559498f, -0.02228703f, -0.03500045f, 
    0.00079052f, 0.00321852f, -0.03001629f, 0.02553261f, -0.01710609f, -0.00864718f, -0.03101454f, 0.02373235f, 
    0.00131480f, 0.03071483f, 0.00458025f, -0.03639248f, -0.00974993f, -0.01740321f, -0.02236484f, 0.00803450f, 
    -0.03656945f, 0.01119996f, -0.03088276f, 0.01975710f, -0.02838903f, -0.02122748f, -0.03880328f, 0.02548861f, 
    0.00986747f, 0.00605910f, -0.03388797f, -0.00452167f, -0.03810375f, 0.00094511f, 0.00234274f, -0.01448111f, 
    -0.02936294f, -0.03792590f, -0.00968302f, -0.00219175f, -0.01314611f, -0.02909285f, 0.00114100f, 0.02488392f, 
    -0.00498906f, -0.01760215f, -0.01358615f, -0.01058477f, 0.02309947f, 0.03721858f, 0.00199704f, -0.02008428f, 
    0.02273564f, -0.03647689f, -0.02094181f, -0.00087462f, -0.01455909f, -0.00013099f, -0.04157426f, 0.00858470f, 
    0.02483423f, -0.00546173f, 0.01472926f, -0.03625781f, 0.00114279f, -0.01407530f, 0.01284727f, -0.02543774f, 
    -0.02216190f, -0.02981264f, 0.00165326f, -0.00854552f, 0.02938725f, 0.00608772f, 0.01342356f, -0.03119480f, 
    0.01029219f, -0.02759145f, 0.00887327f, -0.01764500f, 0.02786948f, 0.00990053f, -0.02432696f, 0.01355731f, 
    0.01922743f, -0.03110323f, 0.01366400f, -0.02076342f, 0.00619888f, -0.02801942f, 0.00105563f, -0.00132417f, 
    0.02615790f, 0.04104144f, 0.01752341f, -0.02133021f, 0.02418978f, -0.01447161f, 0.01465393f, 0.02784764f, 
    -0.01543203f, 0.02976944f, 0.01387677f, -0.01897725f, -0.03472308f, -0.00757330f, -0.00690642f, 0.00818235f, 
    0.01925556f, 0.00382698f, 0.01329133f, 0.00297095f, 0.03574323f, 0.00700408f, -0.00694009f, 0.00395713f, 
    0.03682466f, 0.02310992f, 0.03373174f, -0.02344165f, 0.02809484f, -0.01803334f, -0.03247796f, -0.01598594f, 
    -0.00607207f, 0.02295857f, 0.00928556f, 0.02224374f, -0.00941118f, -0.02817830f, 0.02191863f, 0.02389264f, 
    -0.01281296f, -0.00961714f, -0.01134738f, 0.00916507f, -0.02822462f, 0.02328807f, 0.01362894f, -0.01728523f, 
    0.01003212f, 0.01301479f, 0.01904867f, 0.01619703f, 0.00687203f, 0.01873338f, 0.00591935f, -0.02297670f, 
    -0.02312334f, -0.01235653f, 0.01315555f, 0.01485385f, -0.00741292f, -0.01561073f, -0.02209022f, 0.01910836f, 
    0.01116800f, -0.01534532f, 0.03932408f, -0.01370118f, 0.00959701f, -0.03565306f, -0.02463843f, 0.02709184f, 
    0.00985723f, -0.03384718f, -0.02376538f, 0.02875232f, -0.01926503f, 0.02793601f, -0.00946476f, 0.02553826f, 
    0.02372628f, 0.00966014f, 0.02598270f, -0.01625433f, 0.02193260f, 0.00537110f, 0.00580253f, -0.01360981f, 
    -0.03730433f, 0.02777684f, -0.01899942f, -0.00548719f, -0.00218416f, -0.02390345f, 0.01560455f, -0.00949551f, 
    0.01702742f, 0.02504085f, -0.01279047f, 0.02659016f, 0.03149458f, -0.01276130f, 0.03447523f, -0.02561483f, 
    0.00922129f, -0.01737518f, -0.02438230f, 0.00800708f, -0.00073273f, -0.01828937f, 0.02337567f, -0.00199110f, 
    -0.00732055f, -0.02461795f, -0.01576487f, -0.03706815f, 0.01994425f, -0.01609694f, -0.01942721f, -0.02037955f, 
    -0.00241005f, -0.00311543f, -0.02067785f, -0.01462550f, -0.00998452f, 0.00851292f, -0.00323598f, -0.00038443f, 
    0.01028861f, 0.00493209f, -0.01443606f, -0.03524456f, -0.03559895f, 0.01519897f, -0.00439060f, 0.02604194f, 
    0.00839289f, -0.00415098f, 0.02258739f, -0.02714434f, -0.01029926f, -0.03366975f, -0.00633122f, 0.02019594f, 
    0.03146758f, -0.00058118f, 0.01462409f, 0.03249939f, -0.03819109f, -0.00136152f, 0.01763321f, 0.04174412f, 
    -0.00562504f, 0.02132840f, -0.02606020f, -0.00769045f, 0.02923057f, -0.00859119f, 0.01272532f, 0.00325095f, 
    0.01698926f, 0.01908424f, -0.03033620f, -0.00952646f, -0.02701450f, 0.01315698f, 0.02414471f, 0.01302726f, 
    -0.02286345f, -0.03868718f, -0.00744059f, 0.01514977f, 0.00195783f, 0.01518927f, -0.00487068f, -0.01441315f, 
    -0.02986512f, -0.02942530f, -0.02942488f, -0.02957269f, 0.01367699f, -0.00515722f, -0.03962154f, -0.02990885f, 
    -0.01251251f, -0.01303848f, -0.02650682f, -0.00567119f, -0.03254719f, 0.02909163f, -0.03044303f, -0.01899249f, 
    0.01085422f, 0.00766904f, -0.00816793f, -0.02924737f, -0.00339648f, -0.03327026f, 0.01071616f, 0.02593024f, 
    0.01159166f, -0.00602991f, 0.00900788f, -0.03417514f, -0.03102149f, -0.00071035f, 0.01523986f, 0.01259327f, 
    -0.01710225f, 0.02278153f, 0.01139315f, -0.03041331f, 0.01053787f, 0.02071912f, -0.04066417f, -0.04077044f, 
    -0.02808110f, 0.00296474f, -0.02326503f, 0.01575521f, 0.02423603f, -0.01451654f, -0.02936027f, 0.00060382f, 
    0.00246103f, -0.02850200f, -0.02891498f, 0.01801495f, -0.01430800f, -0.03561316f, 0.02189151f, 0.00960505f, 
    0.01598438f, 0.02992329f, 0.01569757f, 0.03271246f, -0.01011734f, -0.02486816f, 0.03915308f, -0.02806416f, 
    0.01807185f, -0.01531950f, -0.02720387f, 0.00478325f, -0.02055973f, -0.03683401f, -0.04027779f, -0.01918342f, 
    -0.01309012f, 0.03769827f, 0.02686141f, -0.01220516f, -0.00184708f, 0.00055894f, 0.00445031f, -0.00572800f, 
    0.03413381f, -0.02358365f, 0.02434569f, 0.02719319f, -0.02084807f, -0.01961257f, 0.00707539f, 0.01899416f, 
    0.00270188f, 0.03794263f, 0.02312851f, 0.01787585f, 0.03547374f, 0.01439941f, 0.02455398f, -0.04050590f, 
    -0.01614211f, -0.01956317f, -0.03915714f, -0.02537520f, -0.02999294f, -0.00187289f, -0.01250762f, 0.02978036f, 
    -0.00537027f, -0.01693937f, -0.00522276f, -0.02614659f, 0.01359065f, -0.01061935f, -0.01171915f, 0.00929513f, 
    -0.02477536f, 0.03845532f, 0.03464732f, 0.00649667f, -0.04098206f, -0.03276014f, 0.01746225f, -0.01207689f, 
    0.02267206f, -0.02254187f, -0.03657465f, 0.02881395f, -0.01218099f, -0.01311001f, -0.01719834f, -0.00057347f, 
    0.00200341f, 0.00895879f, 0.00463921f, -0.00799731f, 0.00226082f, 0.00622349f, 0.00047101f, 0.00090321f, 
    -0.01891000f, -0.02804388f, -0.02475744f, 0.01518993f, 0.02512549f, -0.00061408f, -0.02175533f, -0.00239940f, 
    0.01103688f, -0.00647699f, -0.00254946f, 0.01072105f, 0.03266083f, -0.00815672f, 0.03327931f, -0.00957465f, 
    0.03299244f, -0.00612286f, 0.02400382f, -0.01660253f, 0.01866559f, 0.00282065f, -0.04150629f, -0.02964457f, 
    0.01348255f, -0.00611044f, -0.03406440f, 0.01096650f, -0.00811856f, 0.00275847f, -0.03033574f, 0.01175043f, 
    0.01831049f, -0.01693048f, 0.00396454f, -0.00045292f, -0.02076440f, -0.04070556f, 0.02052538f, -0.01413206f, 
    -0.01420137f, 0.01034121f, 0.01893726f, -0.02758599f, -0.03366903f, 0.00573976f, 0.01150105f, -0.00808477f, 
    -0.00352873f, 0.00190703f, -0.03910189f, -0.03679867f, -0.04150528f, -0.00050122f, -0.00080835f, 0.02263270f, 
    0.02576064f, -0.00522401f, -0.01877964f, 0.00433044f, -0.00936288f, 0.02512339f, 0.00656570f, -0.03712845f, 
    0.00806188f, -0.00337073f, 0.01474108f, 0.02157797f, 0.00709418f, -0.02305453f, 0.02988773f, -0.03666892f, 
    -0.00266429f, -0.01139646f, -0.02363338f, -0.00663565f, 0.02781279f, -0.03389479f, 0.01507735f, 0.00530933f, 
    -0.02918628f, -0.03068734f, -0.01221140f, -0.02611349f, -0.00553893f, -0.03898944f, 0.02587354f, -0.03266054f, 
    0.00321768f, 0.01527925f, -0.01391321f, 0.03089820f, -0.00023292f, 0.00563798f, -0.03678531f, 0.01465518f, 
    0.02891405f, -0.01566972f, 0.00151347f, -0.02908026f, -0.01302629f, 0.01764920f, 0.02612184f, -0.00054851f, 
    0.01768930f, -0.01004087f, 0.02359247f, -0.01935575f, 0.01599732f, -0.00830860f, 0.00838206f, -0.02526777f, 
    0.01368767f, -0.03790723f, -0.00911568f, 0.00591005f, 0.01169722f, 0.02193681f, 0.01902990f, -0.03588623f, 
    -0.00917561f, 0.02474860f, 0.02684223f, 0.01039292f, -0.01616943f, -0.02967359f, -0.02477782f, 0.00273166f, 
    0.01851256f, -0.03187713f, -0.02690226f, -0.00254033f, -0.01244398f, -0.02822503f, 0.01547060f, -0.02631225f, 
    -0.00254772f, 0.01182994f, -0.01010405f, -0.01223999f, -0.04050025f, 0.01320349f, -0.00452101f, 0.01165039f, 
    0.01050548f, -0.02044732f, -0.01592190f, -0.03458700f, 0.02016194f, -0.00912558f, -0.02127878f, 0.02515603f, 
    0.00448746f, 0.00926497f, -0.03918481f, -0.00687095f, 0.00399069f, -0.03480798f, 0.03983218f, -0.03084303f, 
    0.01404959f, 0.02174792f, -0.02225033f, 0.01903052f, 0.02934188f, -0.00133993f, -0.01014017f, -0.00457739f, 
    0.00747090f, 0.00442274f, 0.00365739f, 0.02368313f, -0.01283311f, -0.04153135f, 0.03662430f, -0.01806672f, 
    -0.02041693f, -0.00934386f, -0.00115728f, -0.03499096f, -0.03788293f, 0.01127488f, -0.00170184f, 0.00104900f, 
    -0.01609359f, -0.02083581f, -0.01391337f, -0.03292069f, 0.01173457f, -0.00488250f, -0.03373528f, -0.02787667f, 
    -0.09723978f, 0.14241268f, 0.27215660f, 0.12068307f, -0.05143593f, -0.04733014f, 0.04197113f, 0.06045003f, 
    -0.03447938f, 0.19664645f, 0.04917782f, 0.05769788f, -0.11174351f, 0.17648360f, -0.13415636f, -0.06161839f, 
    -0.07515718f, -0.00860279f, -0.06950088f, -0.15696567f, 0.03102438f, 0.01411505f, -0.00573790f, 0.06917673f, 
    -0.16399194f, 0.18549652f, 0.39462510f, -0.14097612f, -0.09564355f, 0.12222220f, 0.14701591f, -0.06190919f, 
    -0.02133650f, 0.13473420f, 0.12890407f, 0.02990604f, -0.30791694f, -0.15139122f, 0.14741749f, 0.29453725f, 
    -0.02537788f, -0.02393417f, 0.02503373f, -0.03561627f, 0.09966046f, -0.08626568f, 0.02633997f, 0.02691881f, 
    0.07788552f, -0.08338974f, -0.11913442f, 0.19161470f, -0.09066055f, 0.06211886f, -0.03300507f, 0.05661406f, 
    0.06465545f, 0.01427643f, 0.03469239f, 0.13274004f, 0.01753534f, -0.30360460f, 0.11106171f, 0.03038725f, 
    -0.10747969f, 0.00967645f, 0.02105567f, 0.01465836f, 0.00592435f, -0.09152567f, 0.02244573f, -0.04068155f, 
    -0.27311987f, 0.20720512f, -0.11720875f, 0.04186644f, -0.00263954f, 0.19115245f, 0.03764247f, -0.09462429f, 
    -0.01933061f, 0.05898900f, 0.01428258f, 0.11471096f, -0.11760831f, 0.03997049f, 0.10545711f, 0.03075633f, 
    -0.15148014f, 0.01762111f, 0.01519937f, 0.06021313f, -0.07728375f, -0.15992753f, 0.01854254f, -0.08158906f, 
    -0.12295131f, -0.08872949f, 0.21853609f, -0.20647611f, -0.03836112f, -0.05134345f, 0.17503169f, -0.08218409f, 
    0.09058023f, -0.07781784f, -0.03650624f, 0.01853015f, 0.32220817f, -0.22757766f, 0.22812757f, -0.17696966f, 
    0.03730654f, 0.12609378f, -0.05349331f, 0.01633082f, 0.07012307f, 0.04249470f, -0.03857012f, 0.07402728f, 
    0.11941490f, 0.03252555f, 0.01296781f, 0.08140589f, -0.05006165f, -0.04591856f, 0.01477595f, -0.07090248f, 
    -0.00034359f, 0.01038966f, 0.03755325f, 0.07892750f, -0.19292261f, 0.45342353f, -0.29949802f, -0.00787720f, 
    0.09071618f, 0.13239489f, 0.03761080f, 0.00760667f, -0.05010403f, 0.01899811f, -0.00534394f, -0.00441988f, 
    -0.11299402f, -0.02257359f, 0.21247335f, 0.15522371f, -0.02284609f, -0.02048813f, 0.02480474f, 0.07997183f, 
    -0.00794263f, 0.08881513f, -0.05400677f, 0.01675241f, 0.21918376f, -0.13114519f, 0.04262755f, 0.13271764f, 
    -0.15453792f, 0.00519253f, -0.00467475f, -0.05370500f, 0.01890483f, -0.16080520f, -0.02690961f, 0.02487784f, 
    0.30378565f, 0.06200187f, -0.00391362f, 0.28399348f, 0.13852492f, 0.13398163f, 0.01081877f, 0.21774864f, 
    0.15516318f, 0.03100473f, 0.04437163f, 0.15317415f, -0.18050174f, -0.10447561f, 0.16273075f, -0.22229399f, 
    0.06186619f, 0.01641640f, 0.08137076f, 0.13753231f, 0.07114179f, -0.03829047f, 0.01972062f, 0.04748844f, 
    -0.21986102f, -0.05495847f, 0.05571610f, 0.32116455f, 0.01262777f, 0.04962090f, 0.09075969f, 0.09162749f, 
    0.06104729f, 0.02340156f, 0.10530149f, -0.06107406f, -0.02895390f, 0.20162350f, -0.13463993f, -0.10104474f, 
    0.20145357f, 0.08386461f, 0.02270664f, 0.11334366f, -0.04812767f, 0.09373814f, -0.05596597f, 0.21126951f, 
    -0.07871465f, 0.08406096f, 0.05397420f, 0.09747241f, -0.10416635f, -0.12767677f, 0.05946372f, 0.05169740f, 
    -0.03581166f, 0.09776448f, -0.01430698f, 0.09849320f, -0.01454077f, 0.18484096f, 0.26595786f, 0.24025728f, 
    -0.16705257f, 0.06841650f, -0.02099289f, -0.00330242f, 0.05286941f, 0.00371613f, -0.00842288f, -0.06837919f, 
    0.34629267f, -0.10816519f, 0.13659906f, 0.20578358f, -0.13442434f, 0.16649999f, -0.02003245f, 0.00239961f, 
    0.03774846f, -0.03785750f, -0.01704380f, -0.00931512f, -0.32507086f, 0.11593933f, 0.26368085f, -0.13616894f, 
    -0.15030339f, 0.04056179f, 0.08728863f, -0.09017310f, -0.02252318f, -0.17806128f, -0.12012085f, -0.12606205f, 
    -0.31551370f, -0.05393846f, 0.10535234f, -0.28585494f, -0.03964458f, -0.04201015f, 0.04288756f, 0.04940204f, 
    0.01755076f, -0.00249536f, 0.02735247f, -0.05064612f, -0.05597234f, -0.08725985f, 0.14900085f, -0.25144589f, 
    0.00116993f, -0.05363565f, 0.07367095f, 0.01494847f, -0.08537012f, -0.11948689f, 0.05403614f, 0.06776416f, 
    -0.18333904f, 0.03285020f, 0.02384700f, 0.18580140f, -0.14005555f, 0.09019540f, 0.04520839f, 0.03782491f, 
    0.04435400f, 0.10161120f, -0.00565184f, 0.04036079f, 0.12287237f, -0.03183458f, -0.16294181f, -0.03274769f, 
    0.01058318f, 0.03242736f, -0.05965063f, -0.04475023f, 0.05858912f, 0.05701603f, 0.07504768f, 0.10266156f, 
    -0.09265950f, 0.05760368f, 0.42626682f, -0.08552865f, 0.03607509f, 0.10741080f, -0.03133909f, -0.06146741f, 
    0.12786689f, 0.02088700f, 0.04545598f, 0.07677758f, 0.13734132f, -0.18728331f, -0.01769223f, 0.13757178f, 
    -0.04416570f, 0.00240665f, 0.09205853f, 0.02940145f, 0.06482957f, 0.00179833f, 0.01151964f, 0.06961015f, 
    0.17767417f, -0.03502912f, -0.10184559f, 0.00869627f, 0.02665799f, -0.06789057f, -0.01576494f, 0.07662403f, 
    -0.02846485f, -0.04275176f, -0.09139679f, -0.04346994f, -0.20644955f, 0.01491316f, -0.16013865f, 0.02848172f, 
    -0.12518515f, 0.06602556f, 0.02576892f, -0.05363221f, 0.04220051f, -0.13414408f, 0.14381659f, 0.06604484f, 
    0.13238467f, -0.07171313f, 0.21024819f, 0.21241863f, -0.09107724f, 0.06304684f, 0.22357862f, 0.12425446f, 
    0.02514146f, 0.01092100f, 0.02627409f, -0.03076172f, -0.03819975f, 0.06121007f, 0.04797812f, -0.08640439f, 
    0.11187543f, -0.03447407f, 0.01605500f, 0.03244853f, 0.16342591f, 0.02584000f, 0.03911545f, -0.02256925f, 
    -0.16402601f, 0.29160812f, -0.43535343f, 0.02335512f, 0.23926331f, 0.25826952f, 0.02220158f, 0.06010484f, 
    0.02417986f, 0.03386761f, 0.02415162f, -0.03113627f, -0.07110786f, 0.00401363f, -0.00065663f, 0.06416541f, 
    -0.04829950f, -0.01899387f, 0.02552203f, 0.01177960f, 0.04913573f, -0.02311167f, -0.04807870f, 0.07011537f, 
    -0.17544588f, -0.16433398f, 0.16518165f, -0.08983692f, 0.05460463f, -0.09362098f, 0.08078067f, 0.02922860f, 
    0.09417064f, -0.01687836f, 0.02296175f, -0.04914593f, -0.11058076f, 0.20007585f, -0.07685518f, 0.02461373f, 
    0.02845700f, 0.04101333f, -0.01573656f, -0.08951964f, -0.01673138f, 0.11343168f, -0.01935177f, 0.03846695f, 
    -0.46547845f, 0.15211056f, 0.02110801f, -0.10270219f, 0.08679079f, -0.10588543f, 0.04858220f, -0.01432085f, 
    0.06945321f, 0.08060650f, 0.00771921f, -0.00635088f, 0.30474997f, 0.16241807f, -0.11255255f, 0.04860168f, 
    0.03254387f, 0.04353353f, 0.00421614f, -0.10207268f, 0.17819194f, 0.10648320f, 0.02422285f, 0.08803048f, 
    -0.24327229f, -0.21847382f, 0.14878297f, 0.18954387f, 0.00986070f, -0.02769707f, -0.31359461f, 0.00554837f, 
    -0.03189446f, 0.01586129f, -0.00649136f, 0.11248054f, 0.35130414f, -0.11549775f, 0.13185024f, 0.30089858f, 
    0.13318489f, 0.07714850f, 0.07539783f, 0.05219967f, -0.05709554f, -0.08309598f, -0.05148499f, -0.04481453f, 
    0.23589687f, 0.02553222f, -0.00176943f, 0.25066081f, -0.06656849f, 0.02069779f, 0.07670671f, 0.01427950f, 
    -0.01644546f, -0.00650980f, -0.09382945f, -0.02342307f, -0.42706850f, 0.23771726f, -0.19532308f, -0.02767119f, 
    -0.00220215f, 0.22540276f, -0.03357041f, 0.11657226f, -0.10394180f, 0.02836996f, -0.08549891f, 0.10353302f, 
    -0.14877549f, -0.13709249f, 0.09212149f, 0.30686381f, -0.08146568f, -0.06436367f, 0.00921500f, -0.01216418f, 
    0.04196776f, -0.09971619f, 0.06936260f, 0.04875601f, 0.20623466f, -0.06009544f, 0.08592126f, -0.17747031f, 
    -0.03565275f, -0.03719455f, -0.09766188f, -0.07366879f, -0.06629786f, 0.01593597f, -0.00698740f, -0.00955018f, 
    -0.37951010f, 0.09497697f, 0.13972485f, -0.01024148f, -0.03361311f, 0.04261148f, -0.07444805f, -0.06024381f, 
    0.05916360f, -0.01131857f, 0.09559432f, 0.03737954f, 0.03198144f, 0.27060235f, 0.08107736f, -0.31926262f, 
    -0.09469761f, -0.01868553f, 0.02844110f, -0.06012050f, -0.02619931f, -0.00057601f, 0.00836038f, -0.12141427f, 
    0.33706731f, -0.13079511f, 0.11672577f, 0.15649346f, -0.10615948f, 0.00058888f, 0.10555516f, -0.01737626f, 
    -0.07383814f, 0.07072745f, 0.02572355f, 0.08076587f, 0.13995177f, 0.17297961f, 0.08179422f, 0.13372023f, 
    0.07576028f, -0.00690263f, -0.14670140f, 0.07933635f, 0.19177726f, -0.04417496f, -0.03918004f, 0.11871524f, 
    -0.21909636f, -0.06386223f, 0.12651950f, -0.24786644f, -0.14224999f, 0.05764480f, -0.08798870f, 0.04661869f, 
    0.03898184f, -0.00028849f, -0.04460765f, -0.00264092f, -0.10761764f, 0.30072325f, -0.19874182f, 0.27317464f, 
    0.10054579f, 0.07511359f, 0.06768806f, -0.06946215f, 0.17971265f, 0.13387823f, -0.02380766f, -0.04345563f, 
    -0.05385285f, 0.16525981f, 0.13834119f, 0.20650756f, 0.01844157f, 0.06544894f, 0.02647115f, -0.00562371f, 
    0.00925092f, 0.07095218f, -0.00933870f, -0.08702172f, -0.00300185f, -0.08894689f, -0.09870975f, 0.17800713f, 
    0.04939323f, -0.00490348f, -0.07295953f, 0.14375573f, 0.03051153f, 0.00359973f, 0.02353352f, 0.05089503f, 
    0.07468399f, 0.20586865f, -0.24297184f, 0.10906523f, 0.14303806f, -0.05053811f, -0.08372188f, -0.14911488f, 
    -0.09860478f, -0.07435448f, -0.00573719f, -0.01779326f, -0.12828910f, 0.22142850f, -0.16948333f, 0.05347959f, 
    0.15592195f, -0.01479848f, -0.02346069f, 0.09445151f, -0.00736231f, 0.00322438f, -0.02180667f, -0.00720564f, 
    0.18173602f, 0.06331103f, 0.11864717f, 0.09857121f, -0.04886586f, 0.09161048f, 0.05466655f, 0.07340892f, 
    0.07297552f, 0.03632850f, 0.07442528f, 0.12654983f, -0.12994660f, 0.17582107f, 0.03956868f, -0.07760382f, 
    0.13540828f, 0.06814982f, 0.00427518f, 0.06792118f, 0.01035384f, 0.03731734f, -0.03566049f, 0.08869693f, 
    0.28210646f, -0.21710671f, 0.08397622f, 0.20850739f, -0.19890545f, 0.07051420f, 0.03587041f, -0.10653952f, 
    -0.07603161f, -0.10339020f, -0.09321149f, -0.00061320f, -0.06831270f, 0.22702487f, 0.05133247f, 0.12873034f, 
    0.29693168f, -0.02046618f, 0.06258906f, 0.07808956f, 0.13821946f, -0.00437837f, -0.04752601f, 0.01776274f, 
    0.09171406f, -0.22469285f, 0.03366853f, 0.10785743f, -0.04438847f, -0.01530351f, 0.12513989f, 0.07283138f, 
    -0.01793175f, -0.05018426f, -0.03763844f, 0.14692569f, -0.26491469f, 0.15250890f, 0.11775752f, 0.17901437f, 
    -0.00620829f, 0.08017448f, -0.04290006f, -0.00476173f, -0.02687428f, 0.04631601f, -0.05762770f, 0.05614444f, 
    -0.11095911f, -0.22247772f, 0.04539560f, -0.08091616f, -0.12139721f, -0.07109712f, 0.09741956f, 0.00598889f, 
    -0.09826647f, -0.12328863f, 0.04083504f, -0.01570040f, -0.02419711f, -0.05837556f, 0.13104640f, 0.21634777f, 
    0.05461971f, 0.04965948f, 0.04479718f, 0.12058895f, -0.19840810f, -0.03487895f, -0.02299815f, 0.07762023f, 
    0.13551266f, -0.24388428f, 0.21472155f, 0.12544332f, 0.01403042f, -0.02020844f, -0.01849321f, 0.00497049f, 
    0.10367367f, 0.12156811f, 0.04791597f, 0.08689445f, -0.35643229f, 0.31490704f, -0.12526652f, -0.00993400f, 
    0.00160778f, 0.03862527f, -0.00128524f, 0.10741768f, -0.05554529f, 0.00525686f, -0.01741331f, -0.03616139f, 
    -0.01501019f, -0.02022369f, -0.03912598f, 0.01262463f, 0.00018221f, 0.02946810f, 0.02621051f, 0.02305203f, 
    0.00824929f, -0.01374181f, -0.03340821f, 0.00769538f, 0.00404920f, 0.00534076f, 0.03213578f, 0.01445372f, 
    -0.02501004f, 0.02549382f, -0.01555715f, 0.00261449f, -0.02633679f, 0.01875156f, 0.00979265f, -0.03756359f, 
    -0.02917524f, 0.00980390f, -0.03970632f, 0.02622322f, 0.02435120f, -0.00750747f, -0.01972769f, -0.03549965f, 
    -0.00842589f, 0.01224463f, -0.00919322f, -0.00454026f, 0.03058422f, -0.00672815f, -0.01647740f, 0.02164577f, 
    0.00675859f, 0.00931355f, 0.03886491f, -0.01415720f, -0.01436063f, 0.01032022f, 0.00439391f, 0.02067124f, 
    0.02440365f, 0.00834533f, -0.03968395f, -0.01374851f, 0.00534948f, 0.00781480f, 0.00055836f, -0.00165593f, 
    0.01880512f, -0.04111813f, -0.02072540f, -0.03012173f, 0.01667601f, -0.02342612f, -0.03302455f, -0.03125468f, 
    0.02931111f, -0.00169379f, 0.00091430f, -0.02556021f, 0.02922597f, 0.00052194f, 0.03215915f, -0.03248965f, 
    0.00018196f, 0.02523326f, 0.02571055f, 0.00351774f, 0.01713332f, 0.01268373f, 0.00443293f, -0.03800367f, 
    -0.01837359f, 0.00253236f, 0.02021354f, -0.02033866f, -0.01156528f, 0.03203055f, -0.00324074f, 0.00055635f, 
    0.00489556f, -0.01923647f, 0.02165029f, 0.00034623f, 0.00428044f, 0.01952408f, 0.01099926f, -0.01633357f, 
    0.01525986f, -0.02790330f, -0.01072652f, 0.00722645f, 0.00111520f, -0.01366279f, 0.03054942f, -0.00871253f, 
    0.00229121f, -0.03542764f, -0.02848864f, 0.02941786f, -0.01316658f, -0.04497485f, -0.01459672f, -0.02988646f, 
    -0.00741439f, 0.00875688f, -0.00585312f, 0.02653609f, -0.03212332f, 0.02530722f, 0.01525147f, -0.01280515f, 
    0.01851805f, 0.02097718f, 0.00425805f, -0.01738445f, -0.02186959f, -0.02802058f, -0.01071192f, 0.00606530f, 
    0.01808877f, -0.00503202f, -0.02996298f, 0.02902054f, -0.02144397f, 0.02344872f, 0.00169531f, 0.01977821f, 
    0.00494083f, 0.01379454f, -0.03185937f, -0.03955377f, -0.02956461f, 0.01438225f, 0.01767808f, 0.01313490f, 
    -0.02270857f, -0.03551494f, 0.01009208f, -0.01571502f, -0.03610073f, -0.01910529f, -0.02924241f, 0.00894355f, 
    0.01941749f, -0.00526049f, 0.01789416f, 0.00030382f, 0.02145199f, 0.00325645f, 0.02685590f, 0.02346942f, 
    -0.01290085f, -0.00690950f, -0.02829196f, 0.00054776f, -0.01975690f, -0.03227635f, -0.01482613f, 0.01584482f, 
    -0.02389916f, -0.00639372f, 0.02278550f, 0.01987647f, -0.01911028f, 0.01150894f, -0.02395679f, 0.02970292f, 
    -0.04348959f, -0.03146380f, 0.01314210f, -0.03455826f, 0.01698126f, 0.03575475f, 0.00086990f, -0.01497115f, 
    -0.02404127f, 0.01895463f, -0.01387730f, 0.02653838f, 0.00062765f, 0.02352132f, 0.01457726f, 0.01502254f, 
    0.00018695f, 0.00038509f, -0.02142178f, 0.01698241f, 0.00214628f, 0.01984220f, -0.02129373f, -0.01459631f, 
    -0.04190772f, -0.03401027f, -0.01922872f, -0.01908696f, -0.01972473f, 0.00689520f, 0.02020222f, -0.03991323f, 
    -0.02185238f, 0.00343521f, -0.03126749f, -0.00198043f, 0.00261250f, 0.02676390f, 0.02955516f, 0.00012610f, 
    -0.00336694f, -0.03293927f, -0.00417537f, -0.02719193f, 0.00399314f, 0.00444109f, 0.00734717f, -0.00298078f, 
    0.01441748f, -0.00883678f, 0.00421739f, -0.02982996f, 0.02017168f, 0.02197587f, 0.02424179f, 0.03201614f, 
    0.01630444f, -0.03026876f, 0.02622666f, -0.03841428f, -0.03686338f, -0.02613911f, -0.02850974f, 0.02162222f, 
    -0.02951453f, 0.01411216f, -0.01984577f, 0.01091180f, -0.00866117f, -0.03921201f, -0.00116923f, 0.03591903f, 
    -0.03496902f, -0.01682807f, 0.02703315f, 0.02684879f, -0.02286482f, -0.01896921f, 0.00667638f, -0.01669165f, 
    0.00332978f, 0.00505688f, -0.01033952f, 0.00586979f, 0.02330254f, -0.03776555f, -0.03448554f, 0.01511220f, 
    -0.04155538f, 0.00712900f, 0.01686068f, 0.02580176f, -0.04094151f, -0.01394752f, -0.02810110f, -0.03554756f, 
    0.01256728f, -0.02762716f, 0.02614306f, -0.01556984f, 0.01536567f, 0.02778532f, -0.01672562f, 0.04156456f, 
    0.02003546f, -0.03758737f, -0.02250892f, -0.02679597f, -0.01887673f, -0.03118847f, 0.03326588f, -0.00674417f, 
    0.00908591f, 0.00923757f, 0.02559426f, 0.02718916f, -0.00193050f, -0.00117125f, 0.02327432f, -0.02404930f, 
    -0.00477033f, -0.03503896f, -0.02949496f, 0.02827861f, 0.02294010f, -0.03230550f, -0.01629257f, -0.01549315f, 
    0.02430224f, 0.02144386f, -0.02076067f, 0.03467390f, -0.01974810f, -0.00598924f, -0.00574927f, 0.02783016f, 
    0.00666714f, -0.02492261f, -0.01496652f, 0.00504804f, 0.00738279f, 0.02161721f, -0.00249465f, -0.02343393f, 
    0.01339127f, -0.03984316f, 0.03022449f, -0.03097737f, -0.02133630f, 0.00174646f, 0.01638428f, -0.01311446f, 
    -0.02974501f, 0.02299321f, 0.01251680f, -0.01488844f, 0.02030527f, -0.01852169f, -0.02334431f, -0.01181571f, 
    -0.01091554f, -0.02448638f, 0.00851633f, -0.02838195f, 0.02250683f, 0.03206888f, -0.02459599f, 0.01720104f, 
    -0.03214785f, 0.00882611f, 0.02931775f, -0.03460543f, -0.04244772f, 0.01447545f, -0.00697837f, -0.00289539f, 
    -0.01678976f, -0.00293119f, -0.02393928f, 0.00748658f, 0.01532950f, 0.02829471f, 0.02402805f, -0.00607334f, 
    -0.00638755f, 0.01974662f, -0.03811161f, -0.03489522f, -0.03450966f, 0.00133781f, 0.00492034f, 0.01046143f, 
    0.00348072f, 0.00120179f, -0.03597524f, -0.03312423f, -0.00448140f, -0.03372164f, 0.01334179f, -0.01158393f, 
    0.02730876f, 0.01668925f, -0.01756557f, -0.03652548f, -0.02857080f, -0.03217280f, 0.00196052f, 0.02075748f, 
    -0.04276074f, -0.04110191f, 0.02244833f, -0.00299760f, -0.00172865f, 0.02116304f, 0.00736524f, -0.03389636f, 
    0.02792890f, -0.03781457f, 0.02628467f, -0.02185526f, -0.03612470f, -0.00339629f, 0.01221452f, 0.00620384f, 
    0.02842232f, 0.01024826f, 0.01675803f, 0.01579327f, -0.01011992f, -0.02475044f, -0.03394741f, 0.01504255f, 
    -0.02292011f, 0.00812962f, -0.03726397f, 0.01558741f, 0.02195510f, -0.02792573f, -0.00237947f, -0.00888908f, 
    0.02282090f, 0.02947304f, 0.01910423f, 0.00482215f, 0.02048791f, -0.03494070f, -0.01664468f, -0.01413898f, 
    -0.03993895f, 0.02262831f, 0.00007888f, -0.01321291f, -0.01747704f, -0.01579902f, 0.01150156f, 0.01041221f, 
    -0.00489731f, -0.02034312f, 0.02110967f, 0.00567746f, -0.03649772f, -0.02785339f, -0.03654839f, 0.00587471f, 
    0.02560151f, 0.01652360f, -0.00366216f, 0.03043365f, 0.02210372f, 0.00832306f, 0.03510876f, 0.00085103f, 
    0.02213950f, -0.02647238f, -0.02277153f, -0.01240219f, 0.02644180f, -0.03394881f, -0.03103914f, -0.01891193f, 
    0.00069675f, -0.01635057f, -0.02638917f, 0.02477974f, -0.03752911f, -0.00025194f, 0.02439873f, -0.01481398f, 
    -0.01454018f, 0.02207135f, 0.00936895f, -0.01674917f, -0.01685043f, 0.02688245f, 0.01303537f, -0.02156888f, 
    -0.01356874f, -0.01432819f, -0.04277769f, 0.01553468f, -0.02605817f, -0.01893650f, -0.01719746f, 0.02638851f, 
    -0.02593032f, 0.01200257f, -0.02068674f, -0.02642924f, -0.01703667f, -0.00750397f, 0.01375884f, 0.02304947f, 
    0.02742569f, 0.01694992f, 0.02444060f, 0.01264195f, 0.01839562f, 0.00860625f, 0.00740633f, 0.02243061f, 
    -0.02912250f, 0.00629649f, 0.00186462f, -0.03924901f, 0.00646523f, 0.00333300f, -0.00988448f, -0.02997925f, 
    -0.01503580f, 0.02315567f, 0.02338121f, -0.01844290f, -0.00802743f, 0.01420612f, 0.01861557f, 0.01876172f, 
    0.02958664f, 0.01620585f, 0.03070112f, 0.01515562f, 0.01779258f, -0.02995943f, 0.03185853f, -0.00912916f, 
    0.00311767f, 0.02935828f, 0.03038146f, -0.01543733f, -0.02020334f, -0.02058406f, 0.00702036f, -0.03613298f, 
    -0.00303508f, 0.02226201f, 0.01231298f, 0.01343474f, -0.03646968f, 0.01509979f, 0.01617368f, 0.02947829f, 
    0.01935536f, -0.00335380f, 0.01956458f, -0.03783631f, -0.01487349f, 0.01197894f, 0.00731506f, 0.01748542f, 
    0.02679441f, 0.02143159f, 0.03238083f, 0.01074395f, -0.03729498f, 0.00407045f, -0.01800307f, 0.03216695f, 
    0.03336730f, -0.02630155f, -0.01961364f, -0.00729560f, 0.01563392f, -0.00909256f, 0.00081969f, 0.00625146f, 
    -0.02701673f, -0.03990326f, 0.00418763f, -0.02211717f, -0.04106214f, 0.01590471f, 0.02338327f, -0.00602800f, 
    -0.03161938f, -0.02736417f, -0.03944131f, 0.00503718f, 0.00588801f, -0.01732643f, 0.03159004f, -0.03544847f, 
    0.01685613f, 0.00357720f, 0.00500920f, 0.00830329f, 0.01022426f, 0.00776139f, -0.03382081f, 0.02021533f, 
    -0.03863783f, 0.01567676f, 0.00161221f, 0.00513532f, -0.01524783f, -0.02115742f, 0.02664121f, 0.02381084f, 
    -0.03720269f, 0.03651144f, -0.00461236f, -0.02477023f, 0.00622525f, -0.02741637f, 0.00178564f, 0.03083658f, 
    0.02285214f, 0.00015117f, 0.03373652f, 0.00276067f, 0.01927834f, 0.02394981f, -0.00099731f, -0.01448081f, 
    0.01871725f, -0.03774302f, 0.02862384f, 0.02057819f, -0.00430543f, 0.01399650f, 0.00992189f, 0.01404040f, 
    -0.02251546f, 0.00405923f, -0.03183149f, 0.02166764f, -0.03419397f, 0.01036577f, -0.00734201f, 0.00379274f, 
    -0.02129526f, -0.00967805f, -0.02251554f, 0.02166908f, -0.01499720f, -0.03190682f, 0.00024428f, 0.02398041f, 
    -0.02745552f, -0.00582669f, 0.00914412f, 0.02351112f, -0.00127014f, -0.01733843f, -0.03621767f, -0.02633635f, 
    0.02841248f, 0.02088749f, -0.00401309f, -0.02418152f, -0.03622676f, -0.03677162f, 0.02843830f, 0.02241527f, 
    0.02545413f, 0.00818260f, 0.04234383f, 0.03710085f, 0.00604990f, 0.00192532f, 0.03028959f, -0.00424621f, 
    -0.00489125f, 0.00262077f, 0.00601651f, -0.02047261f, -0.02360630f, 0.02835503f, -0.01987219f, 0.01297736f, 
    -0.02655347f, -0.01888078f, -0.00715333f, -0.02447902f, 0.02389725f, 0.00550595f, 0.00273850f, -0.02283069f, 
    -0.01143669f, -0.01436691f, 0.01432054f, -0.03081489f, 0.00854085f, -0.02063785f, 0.00636115f, -0.03809585f, 
    -0.00420955f, 0.02292750f, -0.04321302f, -0.02318439f, 0.02554621f, 0.00539044f, -0.04407407f, 0.01255715f, 
    0.01551625f, 0.01116371f, -0.03847465f, 0.02544486f, -0.00765448f, -0.03906593f, -0.00477853f, -0.03093230f, 
    -0.00221012f, -0.02680486f, -0.00779204f, 0.00586089f, -0.02897307f, 0.00865217f, -0.02473626f, 0.02463213f, 
    0.00537664f, -0.02788407f, -0.01627665f, -0.01680169f, 0.00751572f, 0.02307512f, -0.02947013f, -0.02714252f, 
    -0.03123643f, 0.00763340f, -0.02697087f, -0.01703206f, 0.01645347f, -0.03441770f, -0.03653762f, -0.00929190f, 
    0.00608561f, -0.01088095f, -0.00762225f, 0.01634301f, 0.02535273f, -0.01483413f, -0.01041696f, 0.02414369f, 
    0.01338749f, 0.02842717f, 0.01352860f, -0.00781644f, -0.03535360f, -0.02792606f, -0.01372668f, -0.02901240f, 
    0.01199149f, 0.00972746f, -0.03817448f, -0.03376424f, 0.02158193f, 0.02572009f, 0.02104601f, 0.02629713f, 
    -0.03087687f, 0.03150000f, -0.00859423f, -0.02863196f, -0.00568659f, -0.01897386f, 0.01939338f, -0.00529692f, 
    0.01464878f, 0.01529395f, 0.02925478f, -0.02644773f, 0.01044174f, -0.00903581f, 0.00400387f, -0.02700651f, 
    0.02595619f, 0.01869003f, -0.03284057f, 0.02485770f, -0.02950860f, -0.01121664f, -0.00151859f, -0.03377454f, 
    -0.00131966f, -0.04154573f, -0.01274351f, -0.02831104f, 0.00644064f, 0.02208233f, -0.00725555f, 0.02235702f, 
    -0.00950016f, 0.00204616f, 0.01099549f, -0.02904152f, -0.02020808f, -0.01391215f, -0.01215633f, -0.02200813f, 
    -0.03629994f, 0.03297083f, -0.03161267f, -0.03615289f, -0.02827362f, -0.00024066f, -0.03487065f, -0.03512766f, 
    -0.02170414f, -0.03182132f, -0.01158541f, -0.01990759f, 0.01083829f, -0.02601725f, -0.03662214f, 0.02724342f, 
    0.01535509f, -0.00415555f, 0.02690901f, 0.01563304f, 0.03035077f, -0.01242779f, 0.02344710f, 0.03767053f, 
    -0.00183680f, 0.00298698f, -0.01934269f, -0.02912015f, -0.00912836f, -0.02373359f, 0.01993938f, -0.01106989f, 
    -0.01357457f, -0.03682630f, 0.01730023f, 0.02074684f, -0.00165135f, -0.03075716f, -0.03146914f, 0.03173331f, 
    -0.00932758f, 0.01456335f, -0.00155131f, 0.01554265f, 0.00584763f, -0.01135874f, 0.03293184f, 0.00399353f, 
    0.02294658f, -0.03940871f, 0.01053962f, -0.04036507f, -0.01748990f, -0.01847096f, -0.03832193f, 0.00641576f, 
    -0.00886124f, -0.01639103f, -0.00132436f, 0.00558268f, -0.00143255f, 0.00604121f, -0.02924290f, -0.02267642f, 
    0.01893793f, 0.02399534f, 0.02428984f, 0.02960853f, -0.01136028f, -0.00034815f, -0.01936610f, -0.03069389f, 
    0.02337229f, -0.02041470f, 0.02537697f, 0.00674870f, -0.03547773f, 0.02023331f, 0.03007552f, 0.01549718f, 
    0.01595767f, -0.01702864f, -0.00196928f, -0.00607629f, 0.03027108f, 0.01392340f, 0.02026012f, 0.00149323f, 
    0.01633844f, -0.02144598f, 0.00080585f, -0.01194319f, 0.02685762f, 0.01257478f, -0.02751813f, -0.01262156f, 
    0.02113680f, 0.00785621f, -0.01074777f, -0.02191716f, 0.02754678f, -0.02678051f, -0.03121149f, -0.03415477f, 
    0.01629813f, 0.01773615f, -0.02059551f, 0.01945408f, -0.02994374f, -0.00612531f, -0.00996751f, 0.00042451f, 
    -0.01034754f, -0.03307214f, -0.00134406f, -0.03720532f, -0.01437279f, -0.01472492f, 0.02761053f, -0.01363797f, 
    0.01041860f, -0.01439601f, 0.01223720f, -0.03835383f, 0.02953087f, 0.02520489f, -0.03451309f, 0.00571770f, 
    -0.00860413f, 0.01593615f, 0.01582086f, 0.02842602f, -0.00300370f, -0.03042949f, 0.02009029f, -0.02866060f, 
    0.02239563f, 0.01147959f, 0.02440983f, -0.01512610f, -0.03694915f, 0.03700551f, -0.02828176f, -0.00257914f, 
    0.00853765f, 0.02129289f, -0.01330724f, -0.02554670f, -0.03632816f, 0.02732292f, -0.03812926f, 0.01890261f, 
    0.02681123f, -0.02525094f, 0.02392808f, 0.01875747f, 0.03245088f, -0.04026923f, -0.00933804f, -0.00152251f, 
    0.01372280f, -0.03584307f, -0.02380929f, -0.01460528f, 0.01366037f, -0.03407688f, -0.02216895f, -0.03092928f, 
    0.01425742f, 0.02446976f, 0.03168856f, -0.00328785f, 0.02978970f, 0.02300338f, -0.00684540f, 0.01884363f, 
    -0.02118293f, -0.03579728f, -0.01334925f, 0.00656565f, -0.02127282f, 0.00282339f, -0.00107528f, 0.01831931f, 
    -0.02672645f, 0.02016690f, 0.01184281f, 0.01655264f, 0.03000623f, -0.00053757f, -0.03880277f, -0.00242405f, 
    0.04083604f, -0.00411890f, 0.00510352f, -0.02541660f, 0.00038037f, 0.01776739f, -0.03956148f, -0.02265603f, 
    -0.02272239f, -0.02816363f, -0.02014610f, 0.01340175f, -0.01095300f, 0.02679809f, -0.00199758f, 0.01566693f, 
    -0.02885245f, -0.03402295f, -0.02594751f, 0.01507071f, 0.02321467f, -0.00563470f, -0.00913262f, 0.01009783f, 
    0.01168062f, -0.00657384f, -0.03450784f, 0.01285561f, 0.00741031f, 0.01646987f, -0.00922449f, 0.00383391f, 
    0.02752154f, 0.00150912f, -0.00589144f, -0.03997863f, -0.03520128f, -0.01302491f, -0.01198928f, -0.02018542f, 
    -0.02255738f, -0.01510055f, 0.02993883f, -0.03913216f, -0.04102384f, 0.01263653f, -0.02097343f, 0.00368359f, 
    -0.01611605f, 0.02186038f, 0.01834354f, -0.02587740f, -0.00971381f, 0.01948911f, -0.03091306f, 0.00740402f, 
    0.01619921f, -0.02635241f, -0.01866788f, -0.01022594f, 0.00995621f, -0.01804326f, -0.03835855f, -0.00137202f, 
    -0.02210396f, 0.00367553f, -0.03859520f, -0.04172591f, -0.02223131f, -0.00234386f, -0.00941533f, 0.03608115f, 
    0.03527802f, -0.03950575f, -0.01518175f, -0.02902001f, -0.00338825f, -0.03720245f, -0.00234796f, -0.03335075f, 
    0.03134220f, 0.01965672f, -0.01009970f, 0.00173734f, -0.03551324f, 0.00485887f, -0.01640417f, 0.00065465f, 
    -0.02193310f, 0.01206842f, -0.03703685f, 0.02947785f, -0.03088903f, 0.02228426f, 0.02769855f, -0.03192342f, 
    -0.00041054f, -0.02847278f, 0.01194024f, -0.01587682f, 0.01617886f, -0.01294587f, -0.00880375f, -0.00652652f, 
    -0.00471695f, -0.00137901f, 0.00189430f, 0.00433750f, -0.03311206f, -0.03343944f, 0.02599121f, 0.00362370f, 
    -0.00276967f, 0.02049053f, -0.03482744f, 0.01279991f, -0.02310837f, 0.02536559f, -0.02052397f, -0.02284772f, 
    0.00273714f, -0.00060910f, -0.02652467f, -0.00912030f, -0.01707609f, -0.00924812f, -0.03029767f, -0.00263588f, 
    -0.02114008f, -0.00046652f, 0.00189763f, -0.02528721f, -0.00432124f, 0.00287105f, 0.02701528f, 0.03012911f, 
    0.02791219f, -0.03547471f, -0.00112039f, -0.00370439f, -0.02418843f, -0.03747734f, -0.02447579f, -0.01935215f, 
    0.03063442f, -0.00898167f, 0.00579188f, 0.02952783f, 0.00998502f, 0.02373571f, -0.01061110f, 0.01933296f, 
    0.02904593f, -0.00585343f, 0.01566814f, -0.00075315f, 0.00185799f, -0.01218439f, -0.03825760f, 0.02477578f, 
    -0.00979219f, -0.03638344f, -0.01317468f, -0.02532882f, -0.02124889f, -0.02364383f, 0.02499312f, 0.00696910f, 
    0.01855494f, 0.02954330f, -0.01669551f, 0.00997360f, 0.02009608f, -0.01118701f, 0.01343088f, -0.03223113f, 
    0.02550419f, -0.02320604f, 0.00463386f, 0.01172050f, 0.02907479f, -0.01156850f, -0.00754663f, 0.02288886f, 
    -0.00019420f, -0.01257707f, -0.00930142f, -0.01610649f, -0.00408695f, 0.01702054f, 0.00909549f, 0.01980545f, 
    -0.01770469f, -0.00229153f, 0.01972247f, -0.02569381f, -0.00349428f, -0.02606062f, -0.01088285f, -0.00976186f, 
    -0.00701064f, -0.01452493f, 0.02607437f, -0.03864827f, -0.00738344f, 0.00512932f, -0.02047902f, -0.01719756f, 
    0.02561322f, 0.00746434f, -0.01415625f, 0.02540007f, 0.04186995f, 0.01348117f, -0.00744664f, 0.01566656f, 
    0.02353729f, -0.00943294f, 0.01047233f, -0.00425460f, 0.02054491f, -0.00695424f, -0.02316190f, -0.00773784f, 
    0.01896267f, 0.01605541f, -0.00196374f, 0.00656007f, -0.03374933f, -0.00671178f, 0.03333200f, -0.01628384f, 
    -0.02012948f, -0.03534674f, -0.01981643f, -0.01842870f, 0.01910755f, -0.02460707f, 0.00976264f, 0.03080638f, 
    -0.00143666f, 0.02139322f, 0.01556529f, 0.00017554f, -0.03200500f, -0.00266942f, 0.01597986f, 0.00005655f, 
    -0.02158625f, 0.02881731f, 0.00036854f, -0.00144451f, -0.02396155f, 0.00958532f, 0.01595323f, -0.02448122f, 
    0.02979984f, -0.00731106f, 0.03025842f, -0.01911264f, -0.03081249f, 0.01575566f, 0.00593559f, 0.00115921f, 
    -0.03770775f, 0.03898800f, 0.01657089f, -0.01750155f, -0.02764023f, -0.01342613f, -0.00542937f, -0.00304316f, 
    0.03245894f, -0.02003336f, 0.00530496f, 0.01216808f, -0.02180926f, -0.00754961f, -0.01538296f, 0.01605094f, 
    0.02690164f, 0.01778724f, -0.02938293f, -0.01310280f, 0.03313884f, 0.00619792f, -0.01950294f, -0.02238587f, 
    -0.00304613f, -0.03012383f, -0.02060893f, -0.03277473f, -0.01981714f, 0.00433067f, 0.00166519f, 0.01090186f, 
    -0.03897818f, -0.02694208f, -0.02678747f, -0.02675404f, -0.00247411f, 0.03234052f, 0.01424587f, -0.00149295f, 
    0.02019569f, -0.00591805f, 0.02698484f, 0.02333862f, 0.01838075f, -0.02316757f, 0.01979691f, 0.02509257f, 
    0.02249098f, -0.03107414f, -0.03987235f, 0.02053305f, 0.01933761f, -0.00700235f, 0.00283593f, -0.03071007f, 
    -0.03368276f, -0.00335004f, 0.00140389f, -0.03689430f, -0.03192627f, -0.00594990f, 0.01165596f, 0.00530644f, 
    -0.02649704f, 0.02003372f, 0.00938429f, -0.01749918f, 0.01485175f, 0.01181229f, 0.02212800f, -0.00586635f, 
    0.02682156f, -0.03992865f, -0.03011588f, 0.00984723f, 0.01785165f, -0.01520540f, -0.03399179f, 0.01849314f, 
    -0.02816733f, 0.00429738f, -0.02250592f, -0.03012459f, -0.02372817f, -0.00018219f, 0.02322977f, -0.00412697f, 
    0.00850945f, -0.01369309f, -0.01240362f, -0.00295092f, -0.04130084f, -0.03183996f, 0.01517660f, 0.03180665f, 
    0.01839415f, 0.02283453f, 0.02494455f, 0.01123759f, 0.01102864f, 0.02739941f, 0.02545709f, -0.01878029f, 
    0.00244477f, 0.01984477f, -0.03922553f, -0.01730311f, 0.00829698f, 0.01241385f, -0.03466669f, -0.03679566f, 
    0.00240439f, 0.02169108f, 0.02297983f, -0.00851228f, -0.00067351f, -0.02779692f, 0.02161074f, -0.01134666f, 
    -0.00554325f, -0.00069671f, -0.03935029f, -0.00622390f, 0.00625006f, 0.01426854f, 0.02137489f, -0.00430407f, 
    0.01799536f, 0.00301619f, -0.03362896f, -0.01115563f, 0.00233170f, -0.02286115f, 0.02401223f, -0.03442013f, 
    0.02323030f, 0.00303827f, -0.00391114f, -0.00037054f, -0.00298432f, 0.00149026f, -0.01647206f, -0.01286787f, 
    0.02032064f, 0.01882890f, -0.03073137f, 0.02793171f, 0.01797025f, 0.00998066f, -0.02096955f, 0.00334958f, 
    -0.03049576f, 0.01538004f, -0.00036545f, 0.01531772f, 0.02721720f, -0.02259166f, -0.00408976f, -0.00972813f, 
    -0.03920238f, -0.00253869f, -0.02477763f, 0.00322067f, 0.01192645f, -0.01038986f, -0.01034202f, 0.01052189f, 
    0.00631726f, -0.02117991f, 0.01458078f, -0.03216870f, -0.02653779f, -0.00500592f, 0.00844130f, 0.02781226f, 
    0.02965420f, 0.01034745f, -0.02835723f, -0.03296169f, 0.00235920f, 0.00370965f, -0.01522484f, -0.01276807f, 
    -0.02330402f, 0.02567081f, -0.00508333f, 0.02924530f, -0.00457634f, 0.02889358f, -0.01366561f, -0.00873901f, 
    -0.02986408f, 0.00851991f, -0.00047178f, 0.00067305f, -0.02243850f, 0.00691490f, -0.03144842f, -0.02697020f, 
    -0.01014093f, -0.01578193f, -0.01417814f, -0.02833500f, -0.02919375f, 0.02802846f, 0.02242887f, -0.01876565f, 
    -0.01894458f, -0.01892525f, 0.01541668f, -0.03596740f, -0.00254528f, -0.01800821f, -0.01610062f, 0.01324830f, 
    -0.01532430f, -0.02574026f, 0.01405651f, -0.02350126f, -0.00424292f, -0.00830686f, 0.02115964f, 0.00225740f, 
    0.00695977f, -0.00110019f, -0.03913447f, 0.02376979f, 0.01335704f, -0.02723953f, 0.02609249f, 0.02350592f, 
    0.02635805f, 0.01174136f, -0.03155571f, 0.02327508f, 0.00041168f, -0.03811970f, -0.00064926f, 0.00135100f, 
    0.00577477f, -0.00999786f, 0.02369275f, -0.03333214f, -0.03306574f, -0.02052815f, -0.01628891f, 0.01269059f, 
    -0.00969629f, -0.01356937f, -0.02556623f, -0.01406668f, 0.01337833f, -0.01186652f, 0.02021337f, -0.00006145f, 
    0.03050484f, 0.01138074f, -0.00057028f, 0.00160970f, -0.01125469f, -0.00386299f, -0.01608415f, 0.00706139f, 
    -0.03387622f, -0.01671370f, -0.01389296f, -0.00224865f, 0.01188322f, -0.01931327f, 0.00311158f, 0.01950748f, 
    -0.01874866f, 0.02539932f, -0.00729633f, -0.02164854f, 0.01595940f, 0.00211578f, 0.02005968f, -0.00695062f, 
    -0.03273071f, 0.00200409f, -0.01434878f, -0.00682143f, -0.03114525f, -0.00190431f, 0.02574063f, 0.01626136f, 
    -0.03708836f, 0.03129340f, -0.03122128f, 0.00132799f, 0.00131439f, -0.03679024f, -0.02360517f, 0.01676598f, 
    0.02524949f, 0.00865258f, -0.01096145f, -0.00357792f, -0.02142100f, -0.02134788f, 0.01296864f, -0.02630085f, 
    0.02715518f, 0.01793712f, -0.03169152f, 0.02735036f, 0.00442778f, 0.00164943f, 0.01113491f, -0.00363699f, 
    -0.03090083f, -0.04378167f, -0.02854750f, -0.03346239f, 0.00944453f, 0.01786969f, -0.03348953f, -0.00322517f, 
    0.01184600f, 0.02066142f, 0.01785248f, -0.00236938f, 0.00740796f, -0.02123122f, -0.02629209f, -0.04026527f, 
    -0.04383651f, -0.00076926f, 0.01487970f, -0.01640361f, -0.00706611f, -0.03971529f, 0.02729807f, 0.00949342f, 
    -0.03643476f, -0.01688278f, -0.00455804f, 0.01206306f, -0.02600123f, 0.01027319f, -0.03843457f, -0.02511811f, 
    -0.01497794f, 0.00807453f, -0.03428657f, 0.01042509f, -0.00041945f, 0.00123686f, -0.02898731f, -0.02509092f, 
    0.02553910f, 0.00333834f, -0.03035492f, -0.03857360f, 0.01419271f, 0.01968739f, 0.02647139f, -0.01363301f, 
    0.00545605f, -0.02170216f, -0.02969163f, -0.02928518f, 0.01119517f, -0.01222163f, -0.03167266f, 0.01343805f, 
    -0.00659957f, 0.02105838f, -0.02232203f, 0.00998604f, -0.02270120f, 0.01051500f, -0.03253551f, 0.00541472f, 
    -0.03287622f, -0.03359078f, 0.00274940f, -0.01910842f, 0.01382461f, 0.02145841f, -0.02612990f, -0.03768361f, 
    -0.04097264f, 0.01332026f, -0.01556529f, 0.00577080f, -0.03201281f, 0.00807188f, 0.01188957f, -0.01145009f, 
    0.01274366f, -0.03619178f, -0.01316946f, 0.00645497f, 0.01717784f, -0.00923952f, -0.00373505f, -0.01434743f, 
    0.01784352f, -0.01065637f, 0.01456640f, -0.03606694f, 0.00742282f, 0.01660202f, 0.02318408f, 0.01075061f, 
    0.01360126f, -0.00302110f, 0.02162086f, 0.01715565f, 0.00710555f, -0.01097533f, 0.00507017f, 0.00857438f, 
    -0.03103285f, -0.02874080f, 0.01058582f, 0.00985932f, -0.02651459f, 0.00605858f, 0.00573917f, 0.01896977f, 
    0.02399942f, -0.01968376f, -0.01042289f, -0.00641882f, 0.00599522f, 0.00192506f, -0.01458604f, -0.03364164f, 
    -0.00959960f, -0.04270153f, 0.00949728f, -0.03872734f, -0.02473662f, 0.02359449f, 0.00281384f, -0.02093830f, 
    0.01526144f, 0.01903953f, -0.00690312f, -0.03161879f, -0.02168938f, -0.01526674f, -0.00967314f, 0.01903523f, 
    0.01882975f, 0.02523862f, 0.02039682f, -0.01484767f, -0.03532804f, -0.00046541f, 0.01275428f, 0.00485820f, 
    0.00207204f, 0.00571347f, 0.01290728f, -0.01632481f, 0.02851934f, 0.02047036f, -0.02683520f, 0.01868707f, 
    -0.00802247f, 0.02193761f, -0.02195023f, -0.00751837f, -0.03712136f, 0.02379773f, -0.04234513f, 0.00928001f, 
    -0.03704115f, 0.00900720f, -0.01664551f, 0.01681855f, -0.03508457f, -0.02211811f, -0.01914834f, -0.00910934f, 
    -0.02320771f, 0.02348026f, 0.02000774f, -0.00512255f, -0.02934426f, -0.01642663f, -0.04323614f, 0.01917848f, 
    -0.00146014f, -0.02500849f, -0.02341378f, -0.02546532f, 0.00314197f, 0.02302827f, -0.00205674f, -0.03609798f, 
    -0.03009179f, -0.02303911f, 0.00485202f, 0.02384850f, -0.03431769f, -0.02931388f, -0.00498399f, -0.02911231f, 
    -0.03384214f, -0.02904610f, -0.01206396f, 0.03583533f, -0.02076917f, 0.01166446f, -0.01794337f, 0.01672180f, 
    -0.04188779f, 0.02131682f, 0.02368326f, 0.01495021f, -0.03537460f, -0.01783475f, -0.04347505f, -0.00805465f, 
    -0.01730197f, -0.01241582f, 0.00752285f, -0.01023036f, -0.02619573f, -0.00465314f, -0.02532935f, -0.00565769f, 
    0.01116321f, -0.01515391f, -0.03692202f, -0.03457046f, -0.02056571f, -0.03737491f, -0.01016238f, -0.01213784f, 
    -0.03524064f, 0.01731633f, -0.00802881f, -0.01613954f, -0.04266999f, -0.01119997f, -0.03053609f, -0.01908250f, 
    -0.04016061f, -0.04271283f, 0.02306108f, 0.00023530f, 0.02295705f, 0.02708354f, -0.01442044f, 0.02367628f, 
    0.00609509f, -0.03234533f, -0.03301849f, 0.00544502f, -0.01865045f, -0.00033673f, 0.02339903f, -0.01875231f, 
    -0.00420050f, 0.02678732f, -0.04162925f, 0.00504733f, 0.00720048f, -0.02758952f, -0.00434092f, 0.00702597f, 
    -0.01895933f, -0.02237419f, -0.04342246f, -0.02447388f, 0.01508711f, 0.01930284f, -0.00186062f, -0.03868853f, 
    -0.01343106f, 0.00286606f, -0.03476093f, -0.01487943f, 0.02641860f, 0.02348221f, 0.00697833f, -0.03417708f, 
    -0.02467591f, -0.03253082f, 0.02567766f, -0.02986781f, -0.02186804f, -0.02484577f, -0.01657562f, -0.02216305f, 
    -0.02617332f, 0.00431782f, 0.02403482f, 0.00011317f, -0.02020361f, -0.04023340f, -0.03682443f, 0.00644317f, 
    0.02099102f, -0.02689221f, 0.00179344f, -0.00834964f, -0.00193890f, -0.01019758f, 0.00213905f, 0.00807607f, 
    -0.00244758f, -0.03140447f, 0.02013923f, 0.01353850f, 0.02194363f, 0.02452593f, 0.02156802f, -0.01170284f, 
    0.01199611f, -0.01146298f, 0.00697314f, -0.00991437f, -0.03148820f, -0.03267395f, -0.03752641f, -0.03144101f, 
    0.02246596f, -0.01686712f, 0.01661788f, 0.00749825f, -0.03932345f, -0.01360668f, -0.03269696f, -0.03163271f, 
    -0.02704412f, -0.03439402f, -0.00640952f, -0.03839683f, 0.00485194f, 0.02427806f, -0.03905868f, -0.02738599f, 
    -0.01679415f, -0.03511988f, -0.00348624f, 0.00908390f, -0.02349878f, -0.01754714f, -0.03388318f, -0.00072716f, 
    0.01905500f, -0.02496923f, 0.01843174f, 0.00795408f, 0.01571653f, 0.01722379f, -0.04322422f, -0.01319933f, 
    0.01479178f, -0.01408502f, -0.03438641f, -0.03406452f, 0.02189202f, 0.01935668f, 0.02790624f, 0.02950706f, 
    0.02316612f, 0.02128042f, -0.00599238f, 0.02756896f, -0.01370563f, 0.01328135f, -0.00936581f, -0.02869394f, 
    -0.02396957f, 0.00459433f, 0.01087544f, 0.02379069f, -0.00938983f, -0.01300041f, 0.00608938f, -0.01869186f, 
    -0.00979443f, -0.01877863f, 0.00526651f, -0.03877988f, -0.02711708f, 0.02500054f, -0.00045619f, -0.01110395f, 
    0.00434849f, -0.03368504f, 0.00676311f, -0.03832402f, -0.02476363f, 0.00538022f, -0.01070612f, -0.02613703f, 
    -0.03448905f, -0.03340153f, -0.04262167f, 0.02042430f, -0.00020270f, -0.00640553f, -0.02436778f, -0.00049032f, 
    -0.04443247f, 0.02297534f, 0.01979694f, -0.03182016f, 0.02801225f, 0.00088605f, -0.00533500f, -0.01350825f, 
    -0.02058506f, -0.02023601f, 0.01469379f, -0.01097236f, 0.03939867f, 0.02640504f, 0.01188329f, 0.00417951f, 
    -0.01165993f, -0.03773119f, -0.02680365f, 0.02360966f, -0.03057043f, 0.02275470f, -0.02765864f, -0.02410307f, 
    0.00375467f, 0.02669539f, -0.02437830f, 0.01440065f, 0.01600928f, -0.04028225f, 0.01282766f, -0.00714411f, 
    0.02251711f, -0.00979750f, 0.02697285f, -0.04384191f, -0.00743196f, -0.03931160f, -0.01593239f, -0.01948403f, 
    0.02295349f, 0.02451487f, 0.00810583f, -0.02906289f, 0.00361000f, 0.01484765f, -0.04319072f, -0.00432155f, 
    0.00191718f, -0.03067647f, -0.01774704f, -0.02743917f, -0.02412691f, -0.03538881f, -0.02364006f, 0.01917286f, 
    -0.00842164f, 0.02009002f, 0.01483258f, 0.00217224f, 0.02467557f, 0.01825968f, -0.04035558f, -0.00636067f, 
    0.01049805f, -0.02131930f, -0.01525548f, 0.01079803f, 0.00831576f, -0.01432380f, 0.00548058f, -0.03131289f, 
    -0.01601066f, 0.01762393f, -0.04356598f, 0.00279761f, -0.01617070f, -0.01700091f, -0.01665261f, -0.02958954f, 
    -0.02814629f, 0.01961052f, -0.01676632f, 0.01920890f, 0.02102527f, -0.02847060f, -0.04091448f, -0.01196432f, 
    -0.04160569f, 0.00649849f, 0.00546951f, 0.00977204f, -0.02809263f, -0.04056422f, -0.00537269f, -0.03793246f, 
    -0.01781937f, -0.00850965f, -0.01346056f, -0.00448477f, -0.02399728f, -0.03046764f, -0.00379818f, -0.01119874f, 
    -0.03578022f, 0.00715148f, -0.04170149f, 0.02165451f, -0.02722898f, 0.01492327f, 0.02757794f, -0.00072951f, 
    0.02589946f, 0.02032368f, -0.03335929f, 0.01167819f, -0.01669870f, 0.00623897f, 0.01400188f, -0.01965496f, 
    0.02694550f, -0.03264399f, 0.00667223f, -0.03209835f, 0.01229503f, 0.02389329f, -0.00824501f, -0.00403270f, 
    -0.01428383f, -0.00113874f, -0.01907734f, 0.01235161f, -0.03996092f, -0.01389670f, 0.02740345f, -0.00284303f, 
    -0.02555261f, -0.00805996f, -0.02474538f, -0.02127691f, 0.02390931f, -0.00115093f, 0.01258453f, -0.01505779f, 
    0.01795956f, -0.04171964f, 0.01997972f, -0.02504601f, 0.01698592f, -0.02551535f, -0.00098726f, -0.02801922f, 
    0.00109064f, -0.03498386f, -0.02229914f, -0.00188429f, -0.02124901f, -0.00824079f, 0.00968433f, -0.00103968f, 
    0.01125745f, -0.03842303f, -0.02917772f, -0.02193522f, 0.00838684f, -0.02734295f, 0.01574968f, 0.01719254f, 
    0.00921231f, 0.02149550f, -0.00284070f, -0.02764381f, -0.00568847f, 0.01237123f, -0.02688861f, -0.03493151f, 
    0.00110351f, 0.00410803f, -0.02121550f, -0.01846055f, 0.02522379f, -0.01260121f, -0.00161532f, -0.03671782f, 
    -0.02074184f, -0.03128983f, -0.00427562f, -0.02036977f, -0.00966655f, -0.01092883f, -0.03126612f, 0.02896977f, 
    0.02070400f, -0.01189444f, -0.03735157f, -0.00407562f, -0.01409248f, -0.01805745f, -0.03492860f, -0.00508461f, 
    0.00078063f, 0.00315101f, 0.00495888f, 0.00507083f, -0.00198073f, -0.03518523f, -0.02847835f, 0.02618180f, 
    -0.01300955f, -0.00565715f, 0.02252202f, -0.02599677f, -0.04155333f, -0.04256084f, 0.01216910f, -0.00263257f, 
    -0.03586020f, -0.00657365f, 0.01380954f, -0.00281654f, -0.03587186f, 0.02808549f, -0.00825927f, -0.03610837f, 
    0.02375160f, -0.02773567f, -0.03665026f, -0.03960922f, -0.00617369f, 0.00488123f, -0.01557035f, -0.03360378f, 
    -0.00543485f, -0.01580287f, 0.02782458f, 0.02638006f, 0.01903734f, -0.03178361f, 0.00600849f, -0.04324670f, 
    0.00528830f, 0.01792876f, 0.00896620f, -0.02209814f, -0.02969370f, -0.00488100f, -0.02862064f, -0.02752401f, 
    -0.03381140f, -0.03040203f, -0.04022135f, -0.00967394f, 0.00704781f, 0.00165411f, -0.04394137f, 0.01813797f, 
    0.00348050f, -0.02844617f, -0.03220025f, -0.00174062f, -0.02785482f, 0.01075533f, 0.00153882f, -0.01791584f, 
    0.01678055f, 0.00200363f, -0.04124783f, -0.01263369f, 0.01054815f, -0.00476304f, 0.01959217f, 0.01648114f, 
    -0.02459765f, 0.01435617f, 0.01858896f, -0.01198866f, -0.01179556f, -0.02377926f, 0.01278708f, -0.01827344f, 
    -0.01858751f, 0.01875247f, 0.01572293f, 0.01009784f, 0.00317239f, 0.02398574f, 0.01531119f, 0.02086370f, 
    0.02314132f, 0.01192511f, 0.00595252f, -0.01132830f, -0.01386104f, -0.03032031f, 0.01866168f, -0.00538266f, 
    -0.03720815f, -0.04359349f, -0.01463454f, -0.01930723f, -0.04253888f, -0.04147581f, 0.01079992f, -0.01377600f, 
    -0.01960024f, -0.00620850f, -0.00662244f, 0.00612706f, -0.02303362f, 0.01912962f, -0.00333610f, -0.02626693f, 
    -0.00657495f, -0.00827513f, -0.01132278f, 0.01337832f, -0.01475264f, -0.00222100f, -0.01232826f, 0.02138728f, 
    0.01746850f, -0.01803803f, 0.00604775f, 0.00849108f, -0.02139449f, -0.00293609f, -0.02891421f, -0.03031820f, 
    0.01751886f, -0.03024430f, 0.01036583f, -0.01826132f, 0.02351322f, -0.03178109f, -0.00450824f, 0.01421628f, 
    -0.00687589f, 0.02693825f, -0.02862280f, 0.01641921f, 0.02435832f, -0.00873178f, -0.04292099f, -0.00537509f, 
    0.02407052f, -0.00796030f, -0.04282055f, -0.02238779f, -0.03547662f, -0.00507846f, -0.02802629f, 0.01011292f, 
    -0.04251821f, 0.00462870f, -0.02805710f, 0.00671015f, -0.01586446f, -0.02467228f, 0.02134255f, -0.04315373f, 
    -0.01737774f, 0.01830488f, 0.00024470f, 0.00730898f, -0.00388095f, -0.04127699f, 0.01724422f, -0.04129053f, 
    -0.04201280f, -0.03852494f, 0.01776071f, 0.02200823f, 0.00717880f, -0.00203824f, -0.02659795f, -0.00782519f, 
    -0.00716491f, -0.00474394f, 0.01642247f, -0.03287976f, 0.02697235f, -0.04186682f, -0.03373127f, -0.04437393f, 
    -0.02016493f, -0.02820616f, 0.01439596f, -0.00914409f, -0.02921548f, 0.01671632f, 0.02355906f, 0.02606588f, 
    0.02332997f, -0.00173369f, 0.01889263f, -0.01791998f, -0.00482139f, -0.03521077f, 0.00357654f, -0.00978363f, 
    -0.02880905f, -0.01910828f, -0.04217070f, -0.03214173f, -0.00913826f, -0.01051250f, -0.03053668f, 0.00768820f, 
    -0.01547852f, -0.01075766f, -0.04239468f, 0.01677337f, -0.04194172f, 0.02536430f, -0.03257726f, -0.02795217f, 
    -0.04039473f, -0.00376230f, -0.01842763f, -0.03666120f, -0.03829398f, -0.01618064f, -0.02762608f, -0.03313222f, 
    0.00846999f, 0.00375858f, 0.01741536f, -0.03377555f, -0.03845700f, -0.02142173f, 0.01565674f, 0.02208793f, 
    -0.02289191f, 0.02445418f, 0.01044883f, 0.01238380f, -0.01760796f, 0.01044631f, -0.02024976f, -0.03867055f, 
    -0.03245571f, -0.04281355f, -0.02766963f, -0.02878533f, 0.00280615f, 0.00807150f, -0.01041103f, 0.01837111f, 
    -0.01411155f, 0.01105913f, -0.03946406f, -0.04110130f, 0.02714288f, 0.00737948f, -0.00129717f, 0.02133016f, 
    -0.01647184f, -0.02686547f, -0.02427912f, -0.02851179f, 0.00239889f, 0.02733739f, -0.04002516f, -0.01552885f, 
    0.00231676f, -0.02006101f, -0.00581046f, -0.01802475f, -0.02368914f, -0.03442824f, 0.02637200f, -0.00854183f, 
    -0.00616124f, -0.01308567f, -0.00721572f, -0.01613149f, -0.01121685f, -0.01956823f, 0.02359314f, 0.02750479f, 
    0.00370911f, 0.00056844f, -0.00167023f, -0.03051096f, 0.02764530f, 0.00860504f, 0.00038625f, 0.00248055f, 
    0.02379099f, -0.02337776f, 0.01591997f, -0.00514743f, -0.02959948f, -0.01137086f, -0.01507775f, 0.01816471f, 
    0.00250315f, 0.00553073f, -0.00666110f, 0.02468010f, -0.03987976f, 0.01505950f, -0.01191204f, -0.00892800f, 
    -0.03973750f, 0.01252095f, -0.03236957f, -0.04191213f, -0.03396208f, 0.01292616f, 0.01873074f, 0.00529154f, 
    0.01612258f, 0.00790991f, 0.02111654f, -0.03069686f, 0.01561372f, -0.02790512f, -0.03928584f, -0.00385141f, 
    0.01648968f, -0.02587385f, -0.00527432f, -0.00514911f, 0.01395981f, -0.02759800f, -0.00066198f, -0.00461607f, 
    -0.00691995f, 0.00051389f, -0.03975389f, -0.00678331f, 0.01639526f, -0.04113429f, -0.00063967f, -0.02505560f, 
    -0.01793065f, 0.00546444f, 0.00339171f, -0.02771571f, -0.02758673f, -0.04246864f, -0.03788707f, 0.01262444f, 
    0.00437793f, 0.02602229f, 0.02736345f, 0.01624320f, -0.01656270f, -0.02933137f, -0.01016585f, -0.04408662f, 
    -0.04412398f, 0.01733706f, -0.00030111f, -0.01438763f, 0.01427212f, 0.01890338f, -0.00961597f, -0.01085900f, 
    -0.01290700f, -0.00205683f, -0.02286152f, -0.01592898f, -0.01767847f, 0.00735569f, 0.01064917f, -0.00481116f, 
    0.01578597f, -0.01119078f, -0.00643505f, -0.03712368f, 0.02214538f, -0.01904921f, -0.02938554f, -0.02293864f, 
    -0.02748467f, 0.02758980f, -0.00001040f, -0.00005200f, -0.01619259f, -0.00659887f, -0.01336101f, -0.00608121f, 
    -0.00242505f, 0.01981202f, -0.01530969f, 0.00858460f, -0.02193673f, -0.00705331f, -0.01299751f, -0.03966742f, 
    -0.02215723f, -0.03765582f, -0.01231787f, -0.01820033f, -0.00724311f, -0.04297671f, -0.00097720f, 0.01037293f, 
    -0.02776145f, 0.00847740f, -0.03147222f, -0.02799282f, 0.01226642f, 0.00105586f, -0.02104836f, 0.01913894f, 
    -0.01252694f, 0.01171519f, 0.02055549f, -0.02939488f, -0.00427007f, -0.02670578f, 0.01509503f, 0.01703597f, 
    0.01262728f, -0.01767106f, -0.02640596f, -0.03409511f, -0.03689104f, 0.00675453f, 0.02009159f, -0.00958532f, 
    -0.00480740f, 0.02180690f, 0.00265736f, 0.01537970f, -0.03410622f, 0.02487564f, 0.01019057f, -0.02580727f, 
    0.01041682f, 0.01064447f, -0.01272181f, -0.03502167f, -0.02379156f, 0.00926080f, 0.00606518f, -0.02041783f, 
    0.01662093f, 0.00937821f, -0.01377895f, 0.01379119f, -0.00584850f, 0.00373805f, -0.02945673f, -0.01750984f, 
    -0.02110577f, 0.00041860f, -0.00967832f, -0.01735714f, -0.03366235f, 0.00754559f, 0.00069970f, -0.03406690f, 
    -0.01653576f, -0.00998039f, -0.02232951f, -0.04336496f, 0.02695808f, -0.03200770f, 0.00866338f, -0.01597916f, 
    -0.02086368f, 0.01596741f, -0.03353326f, -0.02107867f, -0.02847432f, 0.02258641f, 0.00641765f, 0.02489018f, 
    -0.03168902f, -0.03072142f, -0.03606132f, -0.03503380f, 0.02240110f, -0.01610311f, -0.02392677f, 0.00057597f, 
    0.01353145f, 0.00343575f, -0.00629585f, 0.01132551f, 0.00713467f, -0.04009310f, -0.02920082f, 0.01457390f, 
    0.00415489f, -0.00336590f, -0.00024325f, 0.00776868f, -0.04167430f, -0.04287702f, -0.00886889f, 0.01360664f, 
    -0.02970296f, -0.02073847f, -0.00451144f, -0.02629342f, 0.01402469f, -0.01821271f, -0.01884131f, 0.02271848f, 
    0.02029628f, -0.00405706f, -0.01949708f, -0.04219241f, -0.01285657f, -0.01980286f, 0.01160380f, 0.00746733f, 
    0.01280692f, -0.02389014f, 0.00257359f, -0.00286564f, -0.02820008f, -0.04071898f, -0.00800672f, -0.03337148f, 
    0.00492030f, -0.03839381f, 0.00031782f, -0.00556195f, -0.02972365f, 0.01249226f, -0.00864629f, 0.00314983f, 
    -0.03701624f, 0.00826775f, 0.02205686f, -0.00912023f, 0.01071716f, 0.02064706f, -0.03719629f, -0.02088200f, 
    -0.00724813f, 0.00758318f, -0.03323683f, -0.03203090f, 0.00682735f, -0.01426207f, 0.00760412f, -0.02061852f, 
    0.00720377f, -0.02632000f, -0.02930973f, -0.02823140f, -0.00061201f, 0.02047201f, 0.01572375f, -0.01374633f, 
    -0.03524815f, 0.02098310f, 0.00829994f, 0.00292267f, 0.01073463f, -0.00452029f, -0.00311165f, -0.01288564f, 
    0.00985069f, -0.01050732f, 0.00327839f, 0.02139992f, -0.02718398f, -0.00354899f, -0.00222549f, -0.03422101f, 
    0.00852321f, 0.02254950f, 0.00985332f, -0.02369198f, -0.00435245f, 0.01453293f, 0.01210209f, -0.01515262f, 
    0.01420370f, -0.02490121f, 0.01298506f, -0.01989603f, 0.02132695f, 0.01304948f, -0.03208706f, 0.01145388f, 
    0.00906847f, 0.00952852f, 0.02046022f, 0.02285221f, -0.03178911f, -0.01328071f, 0.01787370f, -0.01908662f, 
    0.01714090f, 0.00619019f, 0.00220609f, 0.00385697f, 0.02052145f, -0.03669239f, 0.01987360f, -0.03627255f, 
    -0.00615013f, 0.00665895f, -0.02213085f, -0.03669486f, -0.03352161f, -0.01335256f, 0.02745769f, -0.02592547f, 
    -0.02529173f, 0.00167273f, 0.01827807f, -0.02499865f, 0.00109026f, 0.01288880f, -0.01319743f, 0.02678132f, 
    -0.01849291f, 0.02326458f, -0.02190456f, 0.01337409f, -0.01957353f, 0.00819068f, 0.02351018f, 0.00531879f, 
    -0.02085869f, -0.02045272f, 0.00449000f, -0.00215570f, -0.03758012f, 0.00395840f, -0.01044570f, -0.02194729f, 
    0.00213745f, 0.02400755f, -0.02005496f, -0.00133551f, -0.03199944f, -0.00073362f, 0.01756355f, 0.00937240f, 
    0.00197717f, -0.01312684f, 0.01188119f, -0.02231663f, 0.01678307f, 0.00841373f, -0.03101640f, 0.00395082f, 
    -0.03452719f, 0.01299076f, 0.00958021f, -0.03029181f, 0.00896882f, -0.02809521f, -0.03186309f, 0.02511301f, 
    -0.03713646f, -0.00179982f, -0.00919997f, 0.01185723f, 0.02665364f, 0.01284114f, 0.01872816f, 0.02413874f, 
    -0.04361000f, 0.02774410f, -0.01092316f, -0.01202566f, 0.02373224f, -0.03634768f, -0.03679939f, 0.01540568f, 
    0.01219263f, 0.00506207f, -0.03663385f, -0.00964753f, -0.01978069f, -0.04173012f, -0.00444626f, -0.04076878f, 
    0.00241955f, 0.00100976f, -0.00800587f, -0.02660482f, -0.03947219f, -0.00086754f, 0.02302941f, 0.02578138f, 
    -0.01799921f, -0.04082916f, 0.00612151f, 0.01506868f, -0.02674815f, 0.01903455f, 0.01637934f, -0.00007464f, 
    0.01654373f, -0.02124950f, 0.00908859f, 0.01801919f, -0.01987894f, 0.00880428f, -0.01863143f, -0.02117386f, 
    -0.01433005f, 0.01187474f, 0.01464968f, -0.00153190f, -0.02456840f, 0.00542067f, 0.02131690f, -0.00078270f, 
    -0.01957839f, -0.04397522f, -0.01239082f, 0.01144390f, 0.02667793f, -0.01942517f, -0.03069126f, -0.01696407f, 
    0.02534931f, -0.01010051f, -0.03836083f, -0.00949730f, -0.01797669f, 0.02196231f, -0.03008892f, -0.00164653f, 
    -0.03817546f, 0.02223977f, 0.01433137f, 0.01098014f, -0.04284733f, 0.02602880f, 0.01583531f, 0.01058848f, 
    0.00899355f, -0.02661687f, 0.00164735f, -0.03889441f, 0.00574084f, -0.00181851f, -0.00699910f, -0.00762462f, 
    -0.00898120f, 0.02341735f, 0.01009415f, -0.02489437f, -0.02802244f, -0.02095993f, 0.02455485f, 0.00280687f, 
    -0.02675728f, 0.00755794f, -0.02185657f, -0.02129517f, 0.00428523f, 0.02760792f, -0.04018885f, -0.03242979f, 
    -0.00329116f, -0.03890801f, -0.02441559f, -0.02966357f, 0.01740496f, -0.01781772f, -0.02353774f, 0.00574210f, 
    -0.01765074f, 0.00458658f, -0.03799162f, 0.01783630f, -0.03286092f, -0.00367917f, -0.01557397f, -0.01052826f, 
    0.02650502f, -0.03013250f, 0.00940586f, -0.03088951f, -0.00991705f, 0.01585373f, -0.02625525f, -0.01142365f, 
    0.02749179f, 0.00976012f, -0.01004758f, 0.02445129f, -0.02377629f, -0.03665608f, -0.03446491f, 0.02012841f, 
    -0.03204376f, -0.00683368f, -0.00781254f, 0.02666998f, -0.00592489f, -0.02652705f, -0.01960262f, -0.02842517f, 
    0.00690038f, 0.02154474f, -0.04373086f, 0.02013959f, -0.01192955f, -0.01023061f, -0.02173848f, -0.01644382f, 
    -0.00833475f, -0.00571185f, -0.00885122f, 0.02310152f, -0.02160685f, 0.00386176f, -0.02008392f, 0.00510017f, 
    -0.03764377f, -0.04402710f, 0.00919066f, 0.00204958f, -0.02363890f, -0.03088964f, -0.00705739f, -0.03525138f, 
    0.01636859f, -0.03613048f, 0.00611223f, 0.02710685f, -0.00551049f, -0.00667946f, -0.01356116f, -0.02361157f, 
    0.00294678f, -0.03622537f, 0.00895444f, -0.02821590f, -0.04298759f, -0.02849225f, -0.02825404f, 0.01056673f, 
    -0.03598507f, 0.02894674f, 0.00444438f, 0.02122092f, 0.01580029f, -0.03061462f, -0.03593645f, -0.00958980f, 
    -0.03315233f, 0.01138778f, -0.01604156f, -0.02361756f, -0.00934024f, -0.00717624f, -0.03727752f, 0.02315899f, 
    0.00699443f, 0.01054984f, 0.01194459f, -0.00130007f, -0.02555399f, -0.00294081f, 0.02091018f, -0.01799962f, 
    -0.01641007f, -0.03876892f, 0.02556529f, -0.00171226f, 0.01804636f, -0.01603182f, -0.00286959f, -0.00792736f, 
    0.02424514f, -0.02124105f, -0.02303449f, -0.03374738f, 0.01404473f, 0.02148458f, -0.01220952f, 0.01896971f, 
    0.00952706f, -0.01980875f, -0.03327503f, -0.02093724f, 0.02129714f, -0.04095326f, 0.02830390f, 0.02299911f, 
    -0.01602057f, -0.00990319f, -0.01082178f, 0.02261704f, 0.00542714f, -0.03375041f, -0.00378882f, -0.01768731f, 
    -0.04243747f, 0.02273368f, -0.01402576f, 0.02763623f, 0.00141018f, -0.02431735f, -0.01586824f, 0.02560177f, 
    -0.00660648f, -0.00760076f, 0.02179620f, -0.04202831f, -0.02331879f, 0.00304549f, -0.01263724f, -0.00645986f, 
    0.01543415f, -0.01020024f, 0.01985816f, -0.04425482f, 0.01319065f, -0.01702305f, 0.02066396f, -0.00533743f, 
    -0.02005951f, -0.00096870f, 0.02477371f, -0.00359434f, -0.02323344f, -0.02559570f, 0.01890096f, -0.01558020f, 
    0.00882823f, -0.01103940f, -0.01879804f, 0.00879521f, 0.02408547f, -0.01621229f, -0.00884902f, -0.01658052f, 
    -0.04012850f, 0.00233106f, -0.00872442f, 0.02578590f, 0.00898605f, 0.00801679f, 0.02922099f, 0.00408693f, 
    -0.01611422f, 0.00055151f, -0.00447816f, 0.01736864f, -0.04040563f, 0.01511544f, -0.02106423f, -0.00227937f, 
    -0.00950413f, 0.02126765f, 0.02591134f, -0.02283642f, 0.02317385f, -0.02567802f, 0.01730289f, -0.01891714f, 
    0.00127180f, -0.02776096f, -0.00581689f, -0.02069377f, 0.00188540f, -0.04119714f, -0.03494161f, 0.01932094f, 
    0.00339357f, 0.03616402f, 0.02606656f, -0.02965515f, -0.03449676f, 0.01902872f, -0.03984071f, 0.03048924f, 
    -0.03238199f, -0.02383550f, -0.02039170f, -0.02394787f, -0.01037051f, -0.02378270f, 0.01344191f, -0.03661386f, 
    0.02360367f, -0.01353786f, 0.01143280f, -0.01433887f, -0.01068962f, -0.04105157f, -0.01693814f, -0.01044686f, 
    0.02824331f, 0.02975773f, -0.01509006f, 0.02899432f, 0.01615882f, -0.01367447f, 0.02383213f, -0.04027529f, 
    0.01651286f, 0.01122744f, -0.00939020f, -0.02236022f, -0.00818541f, 0.00182324f, -0.03575297f, 0.00721533f, 
    -0.00515264f, -0.04092615f, -0.02564012f, -0.01223989f, -0.03593320f, -0.03111226f, -0.01771216f, 0.02861935f, 
    -0.01539562f, 0.02925283f, -0.02326907f, 0.01147592f, -0.01916869f, 0.00678298f, -0.00725678f, -0.00406204f, 
    -0.02663811f, -0.00347060f, 0.02570903f, 0.01701277f, -0.00541163f, -0.03246247f, 0.01644678f, -0.01192669f, 
    0.01058799f, -0.03928089f, -0.01570470f, 0.02432224f, -0.01988420f, -0.00128307f, -0.04168773f, 0.03270058f, 
    -0.03186188f, 0.01236723f, 0.01011892f, -0.02718962f, 0.01442055f, -0.03508993f, 0.01385127f, -0.03680624f, 
    0.02323726f, -0.00409187f, -0.00301701f, -0.02009821f, 0.00311747f, -0.01087082f, 0.02256243f, 0.00058768f, 
    -0.02163132f, 0.01176072f, -0.02415513f, -0.01733311f, -0.00611102f, -0.01703846f, -0.01704362f, -0.02323696f, 
    0.00526771f, -0.01538046f, 0.02185377f, 0.02045851f, -0.01046794f, 0.01948063f, -0.03874880f, -0.02268828f, 
    0.01808004f, 0.02203057f, 0.02752853f, -0.03486149f, -0.00240492f, 0.03009284f, 0.00114942f, 0.00411210f, 
    -0.01532501f, -0.02365988f, 0.02721565f, 0.00115304f, 0.00253217f, -0.02360523f, -0.02541445f, -0.00651839f, 
    -0.01731560f, -0.03713368f, -0.01478074f, 0.01378345f, 0.01022206f, -0.01598575f, -0.02955477f, -0.02787264f, 
    0.01227219f, 0.01144301f, 0.03446319f, -0.00655917f, -0.04253874f, 0.01159169f, 0.01270379f, 0.03060080f, 
    0.00533092f, 0.01696741f, 0.01663677f, -0.02391620f, -0.01978215f, -0.02741139f, 0.00791835f, 0.01709368f, 
    0.01338078f, -0.02682128f, -0.01746045f, 0.00301338f, 0.00467098f, -0.02092503f, 0.00910991f, -0.03543941f, 
    -0.00770265f, 0.02076739f, -0.02279781f, -0.02068080f, 0.01796828f, 0.03030217f, 0.01085958f, -0.00786490f, 
    0.02650489f, -0.03728056f, -0.01154043f, -0.02444045f, -0.01814677f, 0.00972572f, 0.02694835f, -0.00878047f, 
    -0.02195443f, -0.01818352f, -0.02714204f, -0.01992570f, 0.00703721f, 0.01388177f, -0.01463126f, -0.03297501f, 
    -0.00195084f, -0.02356497f, -0.03991638f, -0.02406955f, -0.01224782f, 0.01940751f, -0.01931371f, -0.02019468f, 
    0.01653533f, -0.03033767f, -0.04238771f, 0.02260854f, 0.02332018f, -0.01832056f, -0.01198817f, -0.02314472f, 
    0.02907437f, -0.03946738f, 0.00389386f, 0.00568419f, -0.03223573f, 0.00710580f, -0.01542649f, 0.01508910f, 
    -0.03760814f, -0.03739495f, -0.00030324f, 0.01954105f, 0.01556034f, -0.02175341f, -0.03559030f, -0.03544522f, 
    0.01283816f, -0.01736811f, 0.00389724f, 0.02996607f, -0.02772741f, 0.02072476f, 0.01079293f, -0.00548300f, 
    0.00830162f, 0.02042476f, 0.00109603f, -0.02341454f, -0.02809180f, 0.01628077f, 0.02007139f, 0.02962063f, 
    0.01242896f, 0.03689970f, -0.00263521f, -0.00899975f, 0.00856503f, -0.02556695f, 0.03000853f, -0.02521622f, 
    -0.00181420f, 0.00787406f, 0.02214072f, -0.00456593f, -0.03817471f, -0.01115814f, -0.02701276f, -0.04322952f, 
    0.03551262f, 0.01377769f, 0.02130694f, 0.00254957f, -0.02585779f, 0.02305257f, -0.03050571f, -0.01365474f, 
    -0.02335360f, -0.03109913f, -0.02208124f, -0.03313448f, 0.02169817f, 0.01431180f, -0.03795619f, -0.01387993f, 
    0.01316622f, -0.02883878f, -0.03441809f, 0.02473888f, 0.02793601f, -0.01282669f, -0.02883687f, -0.02502090f, 
    0.02894132f, -0.02356465f, 0.01605604f, 0.02652518f, -0.01246506f, 0.01624111f, -0.00425246f, -0.03284399f, 
    0.03000722f, -0.00043990f, 0.00643596f, 0.00793906f, 0.01669909f, 0.01944098f, -0.01073531f, -0.02442399f, 
    0.00858729f, -0.04073463f, 0.01515303f, -0.02948956f, 0.00626796f, -0.04089174f, -0.02631408f, 0.01284970f, 
    0.01411868f, -0.02787200f, -0.02695720f, 0.01407817f, -0.02448402f, 0.02356498f, 0.00175719f, 0.01090315f, 
    -0.01934989f, -0.01473724f, 0.02961308f, 0.01839820f, -0.03979219f, 0.00265865f, 0.02377176f, -0.03008064f, 
    0.00950929f, -0.00499744f, -0.01995105f, -0.01613547f, 0.00736777f, -0.00859301f, 0.02109527f, -0.01517232f, 
    -0.02708599f, -0.00496309f, -0.01037466f, 0.01047492f, 0.02193749f, -0.03276366f, -0.03302640f, -0.04079121f, 
    -0.01235291f, -0.01688727f, -0.01172723f, -0.01662538f, -0.03560323f, 0.02766695f, -0.02461218f, -0.03461869f, 
    -0.00795586f, -0.03326146f, 0.01550603f, 0.00519799f, 0.03902930f, 0.03684715f, 0.00266876f, 0.00018349f, 
    -0.00037025f, 0.01944369f, -0.03748321f, -0.03664057f, 0.00034064f, -0.00386272f, -0.02308811f, 0.01818103f, 
    -0.00453980f, -0.01872129f, -0.04126897f, -0.03074870f, 0.00939467f, -0.02045937f, 0.00776986f, -0.00909173f, 
    -0.04122876f, -0.03195972f, -0.03245482f, 0.00800194f, 0.00563507f, 0.01982132f, -0.01923724f, 0.01097192f, 
    -0.00178618f, 0.00450510f, -0.03387507f, 0.00132164f, -0.03964044f, 0.01553457f, 0.00776103f, -0.00616831f, 
    -0.01738617f, -0.01268127f, -0.00828054f, -0.02767342f, 0.00899294f, 0.02872436f, -0.03833333f, 0.02227928f, 
    -0.00593499f, -0.03505692f, -0.00144879f, 0.01720538f, 0.00966747f, -0.02723354f, -0.00717184f, -0.00575221f, 
    0.02238304f, 0.00887549f, -0.03543403f, 0.01560235f, 0.01057084f, 0.00274343f, -0.02865821f, 0.01077354f, 
    -0.01424556f, -0.01015421f, -0.03450768f, -0.03916876f, 0.01223738f, 0.02491013f, -0.00937926f, -0.01971541f, 
    -0.02744677f, 0.00456015f, -0.01733374f, 0.00196940f, -0.03404950f, 0.00526841f, -0.01827896f, 0.00466903f, 
    -0.01782279f, -0.01171184f, -0.00572486f, 0.00796110f, 0.01916746f, 0.02208575f, -0.00157259f, -0.03208780f, 
    0.02019048f, -0.03336773f, -0.00574849f, -0.03253749f, 0.02727336f, -0.03693835f, -0.00371560f, -0.01380505f, 
    -0.01691498f, 0.00666430f, -0.02682850f, 0.02725641f, -0.02089905f, 0.01618234f, 0.01105570f, -0.01652505f, 
    -0.02803385f, -0.01391243f, 0.02506509f, -0.01175329f, 0.01802418f, 0.01112961f, 0.02736456f, -0.01323021f, 
    0.03412725f, 0.00323976f, 0.00126470f, -0.02197556f, 0.00147499f, 0.00520558f, -0.03722272f, -0.02684017f, 
    0.01017247f, 0.02953660f, -0.00204858f, 0.02094480f, -0.01517358f, -0.02560242f, 0.02777363f, 0.00886553f, 
    -0.00180160f, -0.02788725f, 0.02390104f, 0.00677881f, 0.01429971f, 0.01560971f, -0.03350437f, -0.01587266f, 
    0.00883573f, -0.03012095f, -0.03517627f, 0.00666480f, -0.02518439f, -0.03529000f, 0.02661684f, 0.02032483f, 
    -0.03474712f, -0.01603091f, 0.01467710f, -0.00994162f, 0.00009473f, -0.02582557f, -0.00697733f, 0.02590625f, 
    0.01013318f, 0.01986481f, -0.01248382f, -0.01786320f, -0.00106167f, -0.03286486f, 0.00473575f, -0.02744380f, 
    -0.01026301f, 0.01408045f, -0.03960443f, 0.02962999f, 0.02565956f, -0.02027084f, -0.02804613f, -0.01679164f, 
    0.01587726f, -0.01793218f, -0.03130907f, 0.01184104f, -0.03103390f, 0.00223912f, 0.00578551f, 0.02369802f, 
    0.02768027f, 0.00771776f, 0.01865920f, -0.01291665f, -0.01788263f, -0.02846653f, 0.01370716f, 0.01973355f, 
    0.02588064f, -0.03997179f, 0.01482124f, -0.02662486f, -0.02598315f, -0.02939167f, -0.00616432f, -0.01149077f, 
    -0.03020931f, 0.02013504f, -0.01166763f, 0.00296712f, 0.01842825f, 0.01586561f, 0.01419673f, 0.00605005f, 
    0.00521629f, 0.02700461f, -0.02651952f, -0.00755008f, -0.00606506f, 0.01429301f, -0.03522093f, -0.00925084f, 
    -0.02556452f, 0.01679853f, -0.00244877f, -0.00057247f, -0.02368763f, 0.00182363f, -0.04310598f, -0.00827634f, 
    -0.01071614f, -0.01539894f, -0.04128368f, -0.01701895f, 0.02312181f, 0.01518163f, -0.01296941f, -0.02586260f, 
    -0.00790231f, -0.00463029f, -0.00436254f, -0.01321051f, -0.00772588f, -0.00395353f, 0.00434327f, -0.02354436f, 
    -0.03907887f, 0.00315803f, 0.02583491f, -0.03209326f, -0.02871435f, 0.00853794f, -0.03282208f, -0.01132317f, 
    -0.02675369f, -0.02476455f, -0.01045139f, -0.00535554f, 0.03663398f, -0.03411511f, -0.03369192f, -0.02945224f, 
    0.01272716f, 0.02336917f, -0.03120717f, -0.00053545f, -0.00933735f, -0.01866590f, -0.02708124f, 0.02649568f, 
    0.00834768f, 0.01526171f, 0.02761775f, -0.02773925f, -0.00092811f, -0.02131872f, -0.02296387f, 0.01566812f, 
    -0.00693848f, -0.03051338f, 0.01251893f, 0.01699801f, -0.03259013f, -0.00411422f, 0.00696986f, -0.01132746f, 
    -0.03718222f, 0.01339692f, -0.03076415f, 0.00521883f, 0.00854319f, 0.01797886f, -0.03792560f, 0.01376197f, 
    0.00044818f, -0.01989554f, 0.00458598f, -0.01406060f, -0.00836559f, -0.01535133f, 0.02492870f, -0.00949769f, 
    0.02133426f, -0.01608130f, 0.01324051f, 0.01637614f, -0.02418409f, 0.01879053f, -0.00763279f, -0.00296070f, 
    0.00500154f, 0.01443936f, 0.01469802f, -0.02027058f, 0.00893114f, 0.01242438f, 0.01838686f, -0.02219794f, 
    -0.00680036f, -0.02531927f, -0.01352661f, -0.00751731f, 0.02921497f, -0.00182528f, 0.00388209f, -0.02881005f, 
    -0.02875119f, -0.00431251f, 0.00836075f, 0.01390692f, 0.01874753f, 0.00337983f, 0.01232429f, 0.00473986f, 
    -0.00168103f, 0.00361553f, 0.03145647f, 0.00056759f, 0.00240199f, 0.02261364f, 0.02432492f, 0.01640819f, 
    0.02623993f, 0.00814864f, -0.04230684f, -0.00487944f, 0.00646331f, -0.04257013f, 0.02020051f, 0.02054057f, 
    -0.01136147f, -0.02266752f, 0.02364465f, 0.02231768f, -0.00447849f, 0.02980188f, -0.01486755f, -0.03829744f, 
    -0.03892601f, 0.00406520f, -0.01971914f, -0.03989168f, -0.00333740f, 0.01021565f, -0.01710298f, -0.01340334f, 
    -0.00825462f, -0.04119219f, -0.02722313f, -0.00711395f, -0.02234581f, -0.00874207f, 0.02660019f, -0.03168172f, 
    -0.02134779f, 0.02762469f, -0.03669320f, -0.01869165f, -0.00149516f, 0.02100282f, -0.03000548f, 0.02884319f, 
    0.01502188f, -0.03365255f, -0.04230084f, 0.02092005f, -0.00596662f, -0.04367561f, 0.02307141f, 0.02825041f, 
    0.02316469f, -0.00614258f, -0.02135959f, -0.03202075f, -0.01663152f, 0.00060777f, -0.02914831f, 0.02066485f, 
    0.01669818f, 0.01523970f, 0.02776168f, 0.01714769f, 0.01045191f, 0.00613336f, -0.00962626f, -0.01910301f, 
    -0.02843719f, 0.02249762f, -0.01407569f, -0.03463700f, -0.01695158f, 0.00787691f, -0.03487866f, 0.02108093f, 
    -0.36020976f, -0.25036767f, -0.01000578f, -0.11249764f, 0.00214147f, 0.04056531f, 0.06510913f, 0.04263630f, 
    0.17643376f, -0.10383732f, -0.03759019f, 0.06730738f, 0.09630477f, -0.06723527f, 0.03651625f, 0.13991305f, 
    0.14347154f, 0.02691722f, 0.06532021f, 0.12994038f, 0.12832810f, 0.04595728f, 0.02546987f, 0.09565301f, 
    -0.17762220f, 0.11205295f, 0.08656098f, -0.02211893f, -0.02441152f, 0.06253530f, 0.06766416f, -0.00212378f, 
    0.15681505f, 0.06582479f, 0.04450124f, 0.07188567f, 0.19654603f, 0.08429998f, -0.01313729f, 0.09147894f, 
    -0.03974827f, -0.06538805f, 0.01516834f, 0.04876474f, 0.00027133f, 0.02271073f, 0.00234749f, -0.11307225f, 
    0.10824522f, 0.07095045f, 0.18185599f, 0.13108326f, 0.10094912f, 0.02290596f, 0.08557890f, -0.11899276f, 
    0.14712146f, -0.04775540f, -0.09167500f, -0.07235686f, 0.28825673f, 0.16516624f, 0.20602933f, -0.13601977f, 
    0.02817642f, -0.05529260f, -0.00694890f, 0.00425693f, 0.03216358f, 0.05550318f, -0.02039358f, -0.09367212f, 
    -0.05837063f, -0.00164710f, 0.00045937f, 0.06294589f, 0.05394362f, 0.04808038f, -0.03057860f, 0.11101431f, 
    0.01867737f, 0.02088021f, 0.10491044f, -0.02173782f, 0.29020849f, 0.39863542f, 0.04358423f, 0.08565800f, 
    -0.10620755f, -0.00939413f, -0.00558779f, -0.00395291f, -0.01141376f, 0.06430341f, -0.06561288f, 0.07584526f, 
    0.10165521f, 0.13452153f, 0.03980976f, -0.16446650f, -0.03137878f, -0.00315240f, -0.03076480f, -0.00074871f, 
    -0.02382855f, 0.10938517f, 0.05408340f, -0.04143441f, -0.21933742f, 0.24939339f, 0.20486613f, 0.18473567f, 
    0.13121618f, 0.10064191f, 0.07879022f, 0.04174265f, 0.09936881f, 0.09156062f, 0.26361120f, 0.04296325f, 
    -0.31189951f, -0.02037759f, 0.20644754f, 0.10136579f, -0.00244946f, 0.11784691f, -0.05794227f, 0.09107076f, 
    0.00303832f, 0.00833987f, -0.02003440f, 0.09095344f, -0.45785725f, 0.01417522f, 0.08132151f, -0.14247060f, 
    0.23420155f, 0.09649442f, 0.01037268f, 0.03590203f, 0.15428056f, -0.07537429f, 0.13293701f, 0.17726365f, 
    -0.16821921f, 0.04091242f, 0.13324174f, 0.09335767f, 0.07455513f, 0.05616312f, 0.04382199f, 0.04182133f, 
    0.14552914f, 0.08924390f, 0.06613727f, 0.10585377f, 0.36073110f, 0.26623651f, 0.11603224f, 0.03998836f, 
    -0.04571603f, 0.09455458f, -0.04734214f, 0.14956240f, 0.11611728f, 0.06655911f, 0.04618185f, 0.06015512f, 
    -0.17672659f, -0.25229040f, 0.07373899f, 0.08252110f, -0.00115959f, -0.02548139f, -0.00294686f, 0.10740658f, 
    0.04555101f, -0.05809948f, 0.08337641f, 0.07497267f, 0.15764165f, 0.18111737f, 0.00819149f, -0.11564017f, 
    0.13191418f, -0.00318840f, -0.09650483f, -0.04371271f, 0.11517690f, 0.06306280f, 0.02011283f, 0.02680490f, 
    0.07721610f, -0.34886184f, 0.00472204f, -0.00778644f, -0.08210308f, 0.00950922f, 0.11427096f, -0.03321826f, 
    0.11660505f, 0.09395687f, 0.12064292f, 0.09249269f, -0.10352587f, 0.02334749f, 0.11048573f, -0.15201810f, 
    0.02744136f, 0.02567881f, -0.11944401f, 0.04361193f, 0.12760246f, 0.08548078f, 0.08482994f, 0.06502908f, 
    0.23731378f, 0.42009026f, 0.22955863f, 0.06035053f, 0.05008930f, 0.06574842f, -0.01423596f, 0.03746702f, 
    0.01656031f, -0.05433580f, 0.02625437f, -0.06134729f, 0.37711057f, 0.23973513f, 0.02482165f, 0.01685358f, 
    0.11073830f, -0.06115817f, 0.02854516f, 0.06708800f, -0.00168988f, 0.04776916f, 0.22300991f, 0.01151989f, 
    0.21396695f, 0.17542620f, 0.19939031f, 0.24463093f, 0.11558288f, 0.04568251f, 0.10143451f, 0.04647041f, 
    -0.05419110f, -0.03405432f, 0.07391287f, 0.08565626f, 0.15672930f, 0.12999299f, -0.04506965f, -0.08463416f, 
    -0.00282748f, 0.09805679f, 0.02032897f, -0.04641343f, 0.07216429f, -0.00279563f, 0.12069412f, 0.14903896f, 
    0.41810796f, 0.06707226f, 0.10926248f, -0.09011009f, 0.12116019f, 0.12641734f, 0.07213148f, -0.03348727f, 
    -0.04542286f, 0.07029834f, 0.02876606f, 0.06683892f, 0.14688009f, 0.16281302f, 0.04734493f, 0.06489160f, 
    0.06103266f, 0.11087693f, 0.04182390f, 0.03168090f, 0.05925094f, 0.02395965f, 0.01078103f, 0.01813279f, 
    0.17366415f, -0.31301412f, 0.07281937f, -0.07845123f, -0.05722256f, 0.04732574f, -0.01557141f, -0.09644663f, 
    -0.03583741f, 0.04533462f, 0.16488381f, 0.03549226f, 0.31462029f, -0.03447672f, 0.08299478f, 0.21028748f, 
    0.03720499f, -0.00848485f, -0.01141276f, 0.11375404f, 0.00878291f, 0.05236883f, 0.01078207f, -0.04938575f, 
    -0.11331881f, 0.08421092f, -0.00399489f, 0.04006348f, 0.12057601f, 0.03760708f, 0.17794856f, 0.02855965f, 
    0.00290572f, -0.12083170f, 0.00971418f, 0.02742740f, 0.26030451f, 0.11976418f, 0.21345749f, 0.01493688f, 
    0.00348701f, 0.05639254f, 0.09678205f, 0.06463646f, 0.16842972f, 0.21690796f, 0.05628487f, 0.09540456f, 
    -0.16428979f, -0.07468587f, 0.02667554f, -0.15926477f, 0.14532422f, 0.00002244f, -0.06946829f, 0.02880047f, 
    -0.06512659f, 0.05592614f, 0.05975872f, 0.06016486f, -0.00042494f, 0.18200436f, 0.18811162f, -0.27103320f, 
    -0.12038910f, -0.05698367f, -0.08220244f, 0.02425692f, -0.00036237f, 0.07005692f, -0.08223771f, 0.01161142f, 
    -0.18691722f, 0.17807971f, 0.04989758f, 0.05749151f, 0.00346895f, 0.03325220f, 0.16766943f, 0.06580465f, 
    -0.08814807f, -0.05719225f, 0.12334828f, 0.05466726f, -0.22374158f, 0.00822703f, 0.10939699f, 0.03918436f, 
    0.13945885f, 0.06956748f, 0.00526121f, -0.00231746f, 0.02472455f, -0.04726433f, -0.00278226f, 0.01893898f, 
    -0.15428597f, -0.00833145f, 0.11569986f, -0.06193460f, 0.08890828f, -0.01043327f, -0.09532393f, 0.16531180f, 
    -0.03815452f, 0.02774370f, -0.02683111f, 0.08762896f, 0.06588549f, 0.05933234f, 0.13553074f, 0.01266566f, 
    0.10048556f, 0.06362554f, -0.01282832f, 0.12744689f, 0.06635103f, 0.07360138f, 0.14347957f, 0.01798099f, 
    0.24860336f, 0.02446578f, 0.08747904f, 0.17518656f, 0.01706852f, 0.06716952f, 0.08198917f, 0.02344961f, 
    0.02678111f, 0.12355771f, 0.05276146f, 0.07868963f, 0.16020423f, 0.13762441f, 0.17575426f, 0.14346831f, 
    -0.03268594f, -0.01672560f, -0.05615987f, 0.08935221f, -0.04891190f, 0.00730595f, 0.00606452f, 0.09261875f, 
    -0.13557284f, 0.02386926f, 0.25578260f, 0.01008844f, 0.08536442f, 0.07057454f, 0.09035578f, 0.00170718f, 
    0.10353987f, 0.05306196f, -0.02302062f, 0.08561566f, 0.33450794f, 0.22233360f, -0.12966825f, -0.04001004f, 
    0.10862548f, -0.05457195f, 0.14377783f, -0.00998111f, 0.05381813f, 0.03645122f, 0.00971450f, 0.00707376f, 
    -0.11850476f, -0.02324793f, -0.19276805f, 0.15309326f, -0.01593958f, -0.08089329f, 0.08669969f, 0.00960505f, 
    0.15617292f, 0.17282589f, 0.07723603f, 0.03336499f, -0.13043648f, -0.19922276f, -0.12582640f, -0.03258817f, 
    -0.02253414f, 0.10307605f, -0.00919072f, 0.03500663f, 0.06231090f, 0.00793255f, 0.08621242f, 0.13666764f, 
    0.28132528f, 0.21016170f, 0.25995836f, 0.16107824f, 0.11192230f, 0.02700857f, -0.03820432f, 0.00992279f, 
    0.05852373f, 0.03444169f, 0.08404683f, 0.04554738f, -0.17311075f, 0.15601097f, 0.05713013f, 0.07377134f, 
    0.07678292f, 0.04224543f, 0.04974374f, 0.07508196f, 0.03420953f, 0.04516704f, 0.08756902f, -0.01381608f, 
    0.32006130f, 0.03504302f, 0.07043858f, 0.05377290f, 0.01223888f, -0.01768449f, -0.04478141f, -0.05644374f, 
    -0.00272769f, 0.11113656f, 0.00677329f, 0.11974882f, 0.02165799f, 0.17667900f, -0.00205680f, 0.05749416f, 
    -0.03073389f, 0.01343047f, 0.00893072f, -0.02134837f, 0.00925387f, -0.07429531f, -0.00123576f, 0.03288721f, 
    0.24790308f, 0.04458718f, -0.08975098f, 0.04382788f, 0.05293560f, -0.04934850f, 0.05500138f, 0.02062902f, 
    -0.03317714f, 0.16321415f, 0.12137872f, 0.17492324f, -0.31463897f, 0.19940986f, -0.08666162f, -0.32104316f, 
    0.05079505f, 0.03291984f, -0.00469408f, -0.01092802f, 0.03902460f, 0.07747806f, 0.11503042f, 0.21096355f, 
    0.24078482f, 0.03272657f, 0.09235287f, 0.04613352f, -0.04170834f, 0.03959103f, -0.03001893f, 0.00743925f, 
    0.06355923f, 0.05666673f, 0.05590704f, -0.00823441f, 0.16436836f, 0.03526222f, 0.15842141f, 0.06198489f, 
    -0.00861532f, 0.13836220f, 0.12605572f, 0.00167469f, 0.06445013f, 0.06058424f, -0.06904102f, -0.08534355f, 
    0.12289637f, 0.04509016f, -0.05468336f, 0.02161189f, 0.18642601f, 0.08305956f, 0.07728555f, 0.02601997f, 
    0.08007795f, 0.20213813f, 0.08465484f, -0.11096768f, 0.00565622f, -0.08999676f, 0.11774731f, -0.05253432f, 
    0.08194809f, 0.22633281f, 0.02680929f, 0.11258567f, 0.02265225f, -0.08688267f, -0.04686059f, 0.10591511f, 
    0.31336567f, 0.02879536f, 0.07377118f, 0.19841656f, -0.05571293f, 0.04573722f, 0.12559192f, 0.08331921f, 
    -0.04755988f, 0.19395950f, 0.00634158f, 0.15324657f, -0.25722167f, 0.04161489f, -0.01962065f, -0.01615933f, 
    0.05392344f, 0.07232858f, -0.00124389f, 0.06333365f, 0.00524228f, -0.05607742f, -0.01946372f, 0.01597783f, 
    -0.08459993f, 0.22008525f, 0.39106384f, 0.28471005f, 0.01968758f, 0.04478769f, 0.11457712f, 0.08109203f, 
    0.15735772f, 0.20331813f, 0.09271673f, 0.10202875f, -0.20026426f, -0.07928301f, 0.15748650f, 0.00778480f, 
    0.12961249f, 0.09137440f, -0.03936896f, 0.13824543f, 0.05094207f, 0.08694215f, 0.00565128f, 0.19087455f, 
    0.29433513f, 0.34173509f, 0.05388651f, 0.06200712f, 0.06860059f, 0.01633766f, 0.06333146f, 0.16164047f, 
    -0.02954292f, 0.12141822f, -0.03154953f, -0.05115817f, 0.02318259f, -0.00910140f, 0.17178670f, 0.24708404f, 
    0.11378682f, 0.15595874f, 0.06659907f, 0.04307232f, 0.03902576f, 0.00245444f, 0.08045346f, -0.02488542f, 
    -0.36163196f, 0.02305530f, 0.00832311f, -0.06542626f, 0.01724479f, 0.07363351f, -0.01097581f, 0.06298517f, 
    0.18481173f, 0.22046340f, 0.07260721f, 0.11265855f, 0.34642562f, -0.03739552f, 0.16865237f, 0.07576696f, 
    0.09695851f, 0.11122578f, 0.04647676f, -0.00171088f, -0.04624946f, 0.15727547f, 0.07809838f, 0.17139418f, 
    0.23554195f, 0.24879064f, 0.15286870f, 0.04637634f, -0.03890668f, -0.05023007f, 0.04302160f, 0.00677324f, 
    0.02310426f, -0.02059576f, -0.01566076f, -0.07945909f, 0.06931698f, -0.45541242f, 0.01134823f, -0.07142366f, 
    0.05996018f, 0.11027650f, 0.02459015f, -0.03612041f, 0.15692900f, 0.08351026f, 0.04673263f, 0.03857158f, 
    0.10438339f, 0.17402856f, 0.06854069f, -0.03484885f, -0.03372943f, 0.03856609f, 0.00813318f, 0.04487256f, 
    0.04018638f, -0.00754967f, 0.10460392f, -0.05988825f, 0.03673785f, 0.35329440f, 0.22423567f, -0.01937866f, 
    -0.01355444f, -0.04605104f, 0.04338507f, 0.11280119f, 0.04459586f, 0.03193529f, 0.04873915f, 0.05788956f, 
    0.02370634f, -0.05715256f, 0.07060269f, -0.12104920f, -0.09832302f, -0.01833369f, 0.11849139f, 0.00245754f, 
    0.12729760f, -0.06358252f, 0.11459407f, 0.08588074f, 0.16969427f, 0.02871647f, 0.03429072f, -0.00497663f, 
    0.03449952f, 0.07707473f, 0.09363876f, 0.05139933f, 0.01100551f, 0.03281145f, 0.07969760f, 0.12241635f, 
    0.19173335f, -0.06355748f, -0.20684522f, 0.00767340f, 0.05416565f, 0.00350072f, 0.05239402f, 0.03431089f, 
    -0.00567089f, 0.02393935f, -0.02862313f, -0.16237533f, 0.34629858f, 0.20873998f, -0.09300473f, 0.01829384f, 
    -0.03720656f, -0.00576075f, 0.10026892f, 0.07776773f, 0.06444000f, 0.08949631f, -0.09476983f, 0.09201922f, 
    -0.00937600f, -0.09814744f, -0.02552224f, -0.00693926f, 0.03504134f, -0.06590006f, 0.03991019f, 0.04052112f, 
    -0.00642369f, -0.05092530f, -0.21538714f, 0.01622869f, 0.37758267f, 0.30093816f, -0.26829499f, -0.30856737f, 
    0.01633485f, 0.06717864f, -0.03516828f, -0.01940876f, -0.06156059f, 0.03577702f, -0.14608823f, -0.00650649f, 
    -0.07680018f, 0.07693169f, -0.08776082f, 0.02863360f, -0.08733171f, -0.10804626f, -0.04191304f, -0.00006001f, 
    -0.01306743f, -0.08150268f, -0.07436578f, -0.04910547f, 0.11009714f, 0.24091847f, 0.08333179f, -0.21861158f, 
    0.00113781f, -0.02836689f, -0.01422964f, -0.04139173f, -0.13988692f, 0.07633007f, -0.01146495f, -0.01318064f, 
    0.32401049f, 0.01341051f, 0.01855901f, 0.11229011f, -0.05702414f, 0.03496345f, -0.10201031f, -0.00726966f, 
    0.10557992f, 0.00029188f, -0.06837423f, -0.06734722f, -0.15265365f, 0.10599546f, -0.09753834f, 0.04105677f, 
    -0.07421063f, -0.03342256f, -0.04162236f, 0.07769670f, 0.04092595f, 0.16837977f, -0.01933007f, 0.08679029f, 
    -0.17672119f, 0.15308474f, 0.21592310f, -0.11805500f, 0.04651596f, 0.05070451f, -0.01872222f, -0.03406977f, 
    -0.04521742f, 0.01035925f, 0.00989766f, 0.05276096f, 0.07171226f, 0.10726988f, -0.07271458f, -0.20915772f, 
    0.16499114f, -0.03636228f, 0.14377214f, 0.05368174f, -0.10759731f, -0.04829532f, 0.02969847f, -0.01346284f, 
    -0.18784453f, 0.03352063f, 0.12000208f, 0.01038460f, 0.03286924f, 0.00650623f, 0.07013624f, -0.00728586f, 
    -0.06266094f, 0.06227076f, -0.04201952f, 0.07906040f, 0.33788687f, 0.01571978f, 0.08797564f, 0.04480077f, 
    -0.03987034f, 0.02137579f, -0.04702922f, 0.02296944f, 0.05198834f, 0.04729455f, -0.02214210f, 0.05370773f, 
    0.12788004f, -0.00856363f, -0.03265468f, -0.16879688f, -0.11353350f, -0.03924999f, 0.07066260f, 0.03510373f, 
    -0.08641834f, -0.00178786f, -0.13216531f, -0.06109648f, 0.10045740f, 0.05481555f, -0.10603138f, -0.07216440f, 
    0.05101048f, 0.00944553f, -0.03638089f, 0.07475797f, -0.02751564f, -0.06631403f, -0.00051521f, -0.07062114f, 
    -0.11271161f, -0.07698552f, 0.05865397f, 0.01624122f, 0.06735057f, 0.00959510f, 0.08859996f, -0.12685807f, 
    -0.03485140f, 0.10226468f, -0.13860883f, -0.01460766f, 0.27349377f, -0.11865533f, 0.01015413f, -0.02885288f, 
    -0.10433979f, 0.06966840f, 0.02767849f, -0.00889991f, -0.04714217f, -0.00223643f, -0.04765233f, 0.11813863f, 
    0.28189617f, -0.16083869f, 0.05396501f, 0.06043256f, 0.04064015f, -0.07123113f, 0.18817982f, 0.03534389f, 
    0.09013578f, 0.03082010f, -0.28635120f, -0.02077423f, -0.21592027f, 0.04757844f, 0.07326719f, 0.28439867f, 
    -0.02318964f, 0.03027182f, 0.00232599f, -0.01769655f, 0.10230399f, 0.02605638f, -0.13435546f, -0.05301555f, 
    -0.03515599f, -0.13009845f, -0.07334727f, -0.09509102f, 0.06720164f, 0.13752170f, -0.00504080f, -0.01943586f, 
    0.06139205f, 0.05975593f, -0.10658655f, 0.09035389f, 0.02314696f, -0.05465681f, -0.18103643f, -0.32397148f, 
    0.04650168f, -0.06711265f, 0.05166350f, 0.03951134f, -0.05743246f, 0.00592179f, 0.01608360f, -0.12076551f, 
    -0.25938085f, 0.16632771f, -0.19121100f, -0.01935557f, -0.05928867f, 0.03123604f, -0.06462928f, -0.13911477f, 
    0.00932375f, 0.09078722f, 0.12512715f, 0.10731527f, -0.11840265f, -0.19211181f, 0.06922084f, -0.19630001f, 
    -0.01369402f, 0.02216895f, -0.07366055f, -0.00805611f, -0.03859707f, 0.05242734f, 0.18460628f, 0.04838318f, 
    -0.12915663f, 0.07700793f, 0.32083583f, 0.09872100f, 0.16839300f, -0.01162321f, 0.17517221f, 0.00152144f, 
    -0.05672816f, 0.04229765f, -0.01539735f, 0.02297173f, 0.03327419f, -0.08953681f, 0.29732367f, -0.07247189f, 
    0.06291598f, 0.02770769f, 0.01269393f, 0.07234575f, 0.14607133f, 0.10406445f, -0.05340727f, -0.11275809f, 
    0.25143695f, 0.32008383f, 0.09549156f, 0.26253551f, 0.02108617f, -0.03406957f, -0.16499400f, -0.01279355f, 
    0.05901772f, -0.00278437f, -0.05141048f, 0.08757529f, -0.09642877f, 0.09352117f, 0.00627000f, -0.08635864f, 
    0.07825669f, 0.00898755f, 0.03170443f, -0.00731543f, 0.04054278f, -0.08996175f, 0.01733887f, 0.01596270f, 
    0.09508432f, 0.00816387f, -0.09333459f, 0.12933181f, -0.07212532f, 0.00983836f, 0.02593492f, -0.08172171f, 
    -0.16253719f, -0.05379503f, -0.00115626f, -0.11363570f, -0.09106538f, 0.18110490f, -0.10618237f, -0.03092776f, 
    -0.06427312f, 0.08143983f, -0.02983362f, -0.03156319f, -0.13038436f, -0.00911702f, 0.08789356f, -0.06213557f, 
    -0.01624095f, 0.11869680f, 0.16280541f, 0.02423961f, -0.00894791f, 0.04084222f, 0.10034136f, 0.01996349f, 
    0.02938850f, 0.08546025f, -0.01559347f, 0.14748926f, -0.09210024f, 0.25092956f, -0.03894375f, 0.07872885f, 
    0.06487180f, 0.03379293f, -0.00771016f, 0.04986813f, -0.12400275f, 0.21893735f, -0.12623639f, -0.06827158f, 
    -0.24196035f, -0.15839924f, 0.25707909f, -0.16522513f, -0.01418995f, 0.04151440f, -0.11539674f, -0.07790884f, 
    -0.07038789f, -0.01664935f, 0.02371646f, -0.00522365f, 0.28725985f, -0.14515290f, 0.07547054f, -0.03664447f, 
    0.03765466f, 0.12266359f, -0.10077313f, 0.05554588f, -0.04064795f, 0.04773040f, -0.04598610f, 0.00238866f, 
    0.22676584f, 0.09793282f, 0.06180756f, 0.24026272f, -0.06532923f, -0.04561472f, 0.03005896f, 0.03088331f, 
    -0.03732281f, 0.08039159f, -0.04148779f, -0.00976891f, -0.00844935f, -0.04854913f, -0.03537066f, -0.08119203f, 
    0.02234463f, 0.03952708f, 0.01081390f, -0.08850254f, -0.00338347f, -0.08589163f, 0.16913983f, -0.01711864f, 
    0.07023884f, -0.18093632f, 0.04371784f, -0.10253336f, -0.03152826f, 0.05241339f, -0.09641699f, 0.03824401f, 
    -0.00265664f, 0.01340903f, -0.02718113f, -0.08233807f, -0.13348246f, -0.05455406f, -0.09308098f, 0.03878447f, 
    0.00522261f, 0.19626510f, -0.07788184f, 0.00349770f, 0.04172108f, 0.20459203f, 0.21229781f, 0.07430328f, 
    0.46709359f, 0.04905789f, 0.15709853f, -0.03083606f, 0.01610961f, 0.05024994f, 0.05609872f, 0.04085672f, 
    0.15286952f, -0.03746812f, 0.10821566f, 0.10007414f, -0.01726358f, 0.02921208f, -0.01936713f, 0.12782124f, 
    -0.00425993f, 0.01382905f, -0.06758649f, 0.02962157f, -0.10956509f, -0.06664836f, -0.03014621f, 0.02699016f, 
    0.37681919f, 0.31423399f, -0.10925468f, 0.00411699f, 0.07565135f, 0.08387710f, 0.08996200f, -0.01285009f, 
    0.05193020f, 0.03442129f, 0.01564931f, -0.07242524f, 0.00200509f, 0.07092728f, -0.05701007f, 0.06951303f, 
    0.03201386f, 0.08798865f, 0.05849922f, -0.10825510f, -0.00311240f, 0.08219190f, -0.01338056f, 0.10802200f, 
    -0.27536142f, -0.07084993f, -0.17081127f, -0.15205404f, -0.00294986f, -0.03992332f, -0.00730550f, -0.00793170f, 
    0.03798708f, -0.15913002f, 0.02663836f, -0.12487990f, 0.28808165f, 0.00658492f, -0.01821285f, 0.10567497f, 
    -0.14606652f, 0.04161467f, -0.05087609f, -0.03284292f, 0.09627552f, 0.17318845f, 0.20513174f, -0.08437232f, 
    0.22319828f, 0.27209169f, -0.28293762f, -0.20373370f, -0.03008682f, -0.02206850f, 0.00682813f, 0.05850121f, 
    -0.13516147f, 0.16489252f, 0.06448960f, 0.02084219f, -0.10548972f, -0.15534723f, 0.02057931f, 0.00452983f, 
    -0.02622231f, -0.10843758f, 0.12036271f, -0.03652257f, 0.10510686f, -0.02126216f, 0.02286561f, 0.07728715f, 
    0.45223165f, -0.05309550f, -0.15683688f, 0.04813123f, -0.14847860f, 0.03107625f, 0.00508541f, 0.02684449f, 
    0.02249479f, -0.07230300f, 0.06547228f, -0.13023208f, -0.69829136f, -0.17301977f, 0.19370425f, -0.02231371f, 
    0.05979144f, 0.11651213f, 0.13831680f, 0.00195122f, -0.09674771f, -0.10391926f, 0.17546961f, 0.04724580f, 
    -0.11023566f, 0.15265697f, -0.10873061f, -0.16350281f, 0.11648113f, 0.01138983f, -0.01527809f, 0.03822237f, 
    -0.10875463f, -0.06439359f, 0.05184545f, -0.12837160f, -0.06038170f, 0.01590074f, 0.02230435f, 0.09907281f, 
    0.05258684f, 0.06739283f, 0.07724730f, 0.01864734f, -0.00488159f, 0.09351353f, 0.01920833f, -0.11724032f, 
    0.10850743f, -0.16491881f, 0.12184533f, 0.05250731f, -0.01798930f, -0.03328355f, -0.03237669f, -0.02384779f, 
    0.01805004f, -0.12450022f, -0.05191366f, -0.21581960f, 0.52452832f, 0.07386124f, -0.11446261f, 0.26015797f, 
    -0.10026525f, 0.04230253f, 0.02775973f, -0.05643248f, 0.00602308f, -0.04968637f, 0.17674538f, -0.02371326f, 
    -0.09307463f, 0.08160529f, -0.00114282f, -0.15467522f, 0.05321562f, -0.04228705f, 0.04537326f, 0.00196961f, 
    0.02317054f, 0.04956274f, -0.05073198f, 0.11092011f, 0.19355942f, 0.24900593f, -0.09976786f, 0.22736511f, 
    -0.04482570f, 0.14750105f, -0.15294585f, -0.07889465f, 0.07347768f, 0.03741314f, -0.07779416f, 0.05589589f, 
    0.11877923f, -0.03640024f, -0.05913973f, -0.16050884f, 0.11665165f, 0.12105358f, 0.12026715f, 0.16454236f, 
    -0.03565417f, 0.16361530f, -0.01644424f, 0.01097844f, 0.46611470f, 0.18998660f, 0.05959082f, 0.06774577f, 
    0.08178726f, 0.03283175f, 0.00130787f, 0.05901644f, 0.02368722f, -0.08577961f, -0.06018774f, 0.11192327f, 
    -0.33075124f, -0.08098547f, -0.11703958f, -0.22259913f, -0.01859923f, 0.04164170f, -0.03520505f, -0.01290449f, 
    0.08457526f, -0.03085296f, -0.04097374f, -0.00711677f, 0.32005930f, 0.10185721f, -0.02898943f, -0.07954434f, 
    -0.00844820f, -0.00191181f, 0.18169266f, 0.19864103f, 0.11814164f, 0.20592563f, -0.04356456f, -0.09741943f, 
    -0.08299776f, 0.24781208f, -0.02811146f, 0.00998635f, -0.05081677f, 0.07348511f, 0.02781934f, 0.13794324f, 
    0.08533989f, -0.04996091f, 0.09227756f, -0.16970859f, 0.30259362f, 0.18616669f, 0.10492832f, 0.10080227f, 
    0.10851792f, -0.02586677f, -0.06224243f, -0.00516743f, 0.00871362f, 0.20096990f, 0.15725909f, -0.00221026f, 
    -0.11052679f, 0.17361683f, -0.12721406f, -0.24986535f, 0.02518910f, -0.03023051f, -0.07648049f, -0.00048385f, 
    -0.01889463f, 0.06249942f, -0.00325885f, -0.06604789f, 0.18120328f, 0.01411380f, 0.07751335f, 0.33785173f, 
    -0.02024403f, 0.05305436f, 0.07669387f, 0.07681236f, -0.00429983f, -0.04893413f, 0.00741384f, -0.07696430f, 
    0.03119280f, 0.06865446f, 0.23400223f, -0.08026832f, 0.01961716f, -0.03107067f, -0.14296468f, 0.07022887f, 
    0.00198695f, -0.00433959f, 0.03066796f, -0.03643253f, -0.08821924f, 0.07742161f, -0.18956561f, -0.29465994f, 
    -0.00963231f, -0.07468856f, 0.02281403f, 0.05906375f, -0.00686399f, 0.02913681f, -0.01426707f, 0.02366172f, 
    0.16699438f, -0.00906367f, 0.07896800f, -0.17607360f, 0.17506592f, 0.08977050f, 0.15476406f, -0.09539801f, 
    -0.09487380f, 0.08739459f, 0.01142684f, 0.03658720f, 0.24452877f, 0.04423131f, 0.13740498f, 0.34346020f, 
    -0.00121206f, 0.03368706f, 0.03443240f, -0.02808830f, 0.03250147f, -0.07135429f, 0.07633190f, -0.06579477f, 
    0.02270716f, -0.01485429f, -0.01004741f, -0.00875776f, -0.03616283f, 0.01411876f, 0.00376702f, -0.02918476f, 
    -0.02710688f, -0.03329720f, 0.01330088f, -0.02332392f, -0.00723183f, -0.00654655f, -0.02309681f, 0.01206070f, 
    -0.01194473f, -0.02217934f, 0.01816485f, -0.00064773f, 0.01092510f, -0.00946514f, -0.04113769f, -0.02442651f, 
    0.02764129f, -0.00393080f, -0.01621147f, -0.04158926f, 0.00766264f, 0.02961768f, -0.00130479f, -0.02068016f, 
    0.01998906f, -0.00696060f, -0.02833566f, -0.00356261f, 0.00341041f, 0.01437315f, 0.00281766f, -0.00389197f, 
    -0.02380091f, 0.00867339f, -0.00244792f, -0.01326478f, 0.00695680f, -0.02220332f, 0.01975856f, 0.02912332f, 
    -0.02581717f, 0.00574883f, -0.02543793f, -0.00544738f, -0.02099662f, -0.03319000f, 0.02816289f, -0.03917519f, 
    -0.00606765f, -0.03205708f, 0.02061289f, -0.03877949f, 0.01138824f, 0.02955638f, 0.00898669f, -0.00992100f, 
    0.02202878f, 0.01642075f, -0.03634799f, 0.00114333f, 0.01179278f, 0.00590096f, 0.02996264f, -0.02705205f, 
    0.01859347f, -0.02483492f, -0.01985587f, -0.04100826f, 0.00985350f, -0.03036822f, 0.01877863f, 0.01387663f, 
    0.02319413f, 0.01619258f, -0.02126187f, 0.01733935f, -0.03242978f, -0.03030535f, -0.01896828f, 0.00045727f, 
    -0.03166333f, 0.00827919f, 0.00265394f, -0.00461417f, 0.00095537f, -0.02972602f, 0.02816722f, 0.01069484f, 
    -0.00965770f, 0.02532830f, -0.02967362f, -0.01921430f, -0.01918866f, -0.01803996f, -0.03582068f, -0.00405435f, 
    -0.03862333f, 0.00520152f, 0.02081754f, 0.01169238f, -0.00536243f, -0.00426742f, -0.01777495f, -0.01738428f, 
    -0.02546787f, 0.01006769f, -0.02585813f, -0.03330922f, -0.02815305f, 0.01285788f, -0.01256305f, -0.00848145f, 
    -0.00187181f, -0.03171983f, -0.02066470f, -0.03394365f, 0.02886749f, -0.00232807f, -0.01307052f, 0.00666715f, 
    -0.01499117f, 0.02296806f, 0.02481189f, -0.01882587f, -0.01801228f, -0.03078336f, 0.00105293f, 0.00118124f, 
    -0.01349841f, -0.02638234f, -0.04008476f, -0.02526197f, 0.01983714f, 0.02490041f, 0.01524791f, -0.02002807f, 
    -0.02176478f, 0.01951160f, -0.01992509f, 0.01730988f, 0.01538756f, -0.01867706f, -0.01217464f, -0.00283666f, 
    -0.01422001f, -0.03182105f, -0.00518496f, -0.02428375f, 0.02678347f, -0.00372862f, -0.04123652f, -0.01167451f, 
    0.02380271f, 0.02279092f, -0.01430399f, 0.00275004f, -0.02078965f, -0.01426779f, -0.01263518f, -0.03577414f, 
    -0.03780946f, 0.01685531f, 0.02781337f, -0.00111347f, -0.02075585f, 0.01554230f, 0.01817944f, 0.02361845f, 
    -0.00348377f, -0.01939630f, 0.01136338f, -0.00352259f, -0.03415623f, -0.03104032f, -0.01980180f, -0.03083037f, 
    0.02468412f, -0.00362503f, 0.02139045f, 0.01005674f, -0.01603715f, -0.01479126f, 0.01794381f, 0.00252263f, 
    0.00792346f, -0.02276688f, -0.02569382f, 0.02833795f, -0.03359399f, -0.01097980f, 0.00541128f, -0.03806588f, 
    0.01764406f, 0.00080264f, -0.03241380f, -0.01174506f, 0.02590008f, -0.00653103f, -0.03245828f, -0.01530647f, 
    -0.00567851f, 0.02843311f, -0.02162119f, -0.04044000f, 0.02299771f, -0.00735116f, 0.02210893f, -0.02913774f, 
    0.00872167f, 0.01285852f, -0.04097801f, -0.03595579f, -0.00088706f, -0.03769214f, -0.01931113f, 0.02512295f, 
    0.02917494f, -0.02081086f, -0.03104973f, -0.00743748f, -0.02843594f, -0.03891528f, -0.02425823f, -0.03463037f, 
    0.02531296f, 0.00325327f, -0.01611116f, 0.00441755f, 0.01457857f, -0.00031529f, 0.01624485f, -0.04043896f, 
    -0.00734831f, -0.01824325f, -0.02076382f, -0.01587824f, 0.01193224f, -0.01909269f, -0.00030406f, -0.00762855f, 
    -0.03812619f, -0.04156109f, -0.01059619f, -0.03608133f, -0.00567409f, -0.00033477f, -0.00620604f, 0.01433520f, 
    0.02592831f, 0.02598691f, 0.00918131f, -0.02755265f, -0.03853568f, -0.02113061f, 0.00054305f, -0.02716902f, 
    0.01688945f, 0.01746744f, -0.02806270f, -0.03279893f, -0.00594027f, 0.02275174f, 0.02303437f, -0.03415856f, 
    0.02560040f, 0.01218458f, -0.03295252f, 0.00027865f, 0.02168428f, 0.00729886f, 0.00153703f, -0.02043986f, 
    -0.02349576f, -0.03652544f, 0.02212279f, -0.01621327f, 0.02958345f, 0.01293184f, 0.01622781f, -0.00170216f, 
    -0.00928556f, -0.01039622f, 0.02512521f, 0.00585078f, 0.01478146f, 0.00143074f, -0.01502988f, 0.02693755f, 
    -0.00186466f, 0.00894380f, -0.03194596f, -0.01299066f, -0.00233130f, -0.02874577f, -0.02874767f, -0.02783425f, 
    0.01201876f, 0.00188365f, -0.00891095f, 0.01339569f, 0.01695449f, 0.00472300f, -0.00375359f, 0.00576847f, 
    0.00289381f, -0.04124357f, 0.00185463f, 0.00302357f, 0.00012887f, 0.00618539f, 0.00309907f, -0.01606094f, 
    0.01782474f, -0.00182936f, -0.01377197f, -0.03641827f, 0.02447519f, 0.01026091f, 0.00136628f, 0.00609913f, 
    0.02382170f, -0.02803664f, -0.02462173f, -0.02433657f, -0.01614131f, -0.03319287f, 0.01416905f, 0.01009776f, 
    -0.02569489f, -0.04059910f, -0.00553236f, 0.00452892f, -0.03869645f, -0.01269113f, 0.02576934f, -0.01888224f, 
    0.01226157f, -0.01624090f, -0.02868221f, -0.01678124f, -0.03306538f, -0.03743160f, -0.01285585f, -0.02550319f, 
    0.00567840f, -0.00033681f, -0.01505489f, 0.02302662f, 0.01789187f, -0.00309667f, -0.02260593f, -0.03043004f, 
    0.01054639f, 0.02909320f, -0.02584776f, -0.00412964f, -0.01237750f, 0.00187613f, -0.03598628f, 0.00825624f, 
    -0.02063403f, -0.03201222f, -0.03699940f, 0.02402092f, 0.00998463f, 0.00857698f, -0.03132908f, 0.01674910f, 
    -0.01168579f, 0.00408076f, -0.04152139f, -0.03573300f, -0.00080979f, -0.03991563f, 0.01257456f, -0.00757414f, 
    -0.03259569f, 0.00321842f, 0.02935430f, -0.02313618f, -0.03413295f, -0.00592655f, -0.04012733f, 0.01990927f, 
    0.00771245f, -0.00582606f, -0.02282362f, -0.00207395f, 0.00956909f, -0.02728687f, 0.00001808f, 0.01902588f, 
    -0.02355553f, -0.03619277f, 0.01081023f, 0.00238505f, -0.04090485f, 0.01642960f, 0.02771167f, -0.01081247f, 
    0.00073841f, 0.02932542f, 0.00358438f, -0.02173354f, -0.01941203f, -0.03747474f, 0.00328258f, -0.01773264f, 
    0.00970720f, 0.01793640f, -0.03391986f, -0.00997880f, -0.03159205f, -0.02823374f, 0.00327451f, 0.02305381f, 
    -0.00803916f, -0.03693952f, -0.00304272f, -0.00164530f, -0.00277260f, -0.00125476f, -0.00103366f, 0.00366571f, 
    0.01088513f, 0.02170935f, -0.02732636f, -0.01539373f, -0.00949948f, -0.00819594f, -0.04189907f, -0.03837419f, 
    0.00724868f, -0.02506000f, -0.04186155f, -0.01438341f, -0.00563278f, 0.01875803f, 0.02163570f, -0.03333629f, 
    0.02521897f, 0.01783921f, 0.01713045f, 0.00824288f, 0.02656433f, -0.03937055f, 0.00595710f, 0.01855999f, 
    -0.02156301f, 0.00897166f, -0.03958766f, -0.00477449f, 0.02218588f, -0.03827361f, 0.00949578f, -0.04181745f, 
    0.02491337f, -0.02095136f, 0.01957910f, 0.02944258f, 0.00812779f, -0.00238861f, -0.00620642f, 0.01671607f, 
    0.01296284f, -0.02689534f, -0.04049195f, -0.00278036f, -0.02444355f, -0.00596233f, 0.01161623f, -0.04130495f, 
    -0.02173427f, 0.01205220f, 0.01945672f, -0.00825745f, -0.00704843f, -0.02083581f, -0.02344778f, -0.01185324f, 
    0.00118521f, 0.00510766f, -0.01947705f, 0.01482239f, -0.01717395f, -0.02336912f, 0.02380441f, -0.01353509f, 
    0.00245955f, -0.00906470f, -0.00910773f, 0.02704304f, -0.03531659f, -0.01736697f, 0.02117518f, -0.03962554f, 
    -0.03816428f, -0.02822842f, -0.02134560f, 0.00279459f, 0.01887497f, -0.00555083f, -0.03723849f, -0.01855214f, 
    -0.01420296f, -0.00238493f, -0.00959417f, 0.01889491f, -0.00826253f, 0.01814336f, 0.02021538f, 0.00041379f, 
    0.02627475f, 0.00590632f, -0.00256681f, -0.03798111f, 0.02885360f, 0.01274349f, -0.00363294f, -0.03046193f, 
    -0.04152310f, -0.01128928f, 0.02341579f, 0.02798189f, 0.00158368f, 0.00843557f, -0.03874278f, -0.00164330f, 
    0.02093579f, 0.01854610f, -0.03992676f, 0.01273744f, 0.02374385f, -0.01205307f, -0.03353878f, -0.00586264f, 
    -0.03074643f, 0.01428674f, -0.01544976f, 0.02125006f, 0.00404573f, -0.00468396f, -0.01902572f, -0.01996949f, 
    -0.02839054f, -0.02434711f, 0.02085003f, 0.01827456f, 0.02403848f, -0.00086793f, 0.02529518f, 0.00306874f, 
    -0.01472478f, -0.02520232f, -0.01856720f, -0.02465041f, -0.01864554f, 0.01860877f, -0.01211847f, 0.01114569f, 
    -0.02966254f, -0.00700619f, -0.03813098f, -0.02941733f, 0.01215802f, -0.02572875f, -0.04049578f, -0.01999913f, 
    -0.00716360f, -0.00950153f, -0.03564305f, -0.02397696f, -0.03105838f, -0.01350384f, -0.04021507f, -0.02382674f, 
    0.00421551f, -0.00862398f, -0.03142032f, 0.00665060f, 0.02423236f, 0.00825748f, 0.01670169f, -0.02435589f, 
    0.02582825f, -0.01599606f, 0.02296010f, 0.01813479f, -0.00626632f, -0.01720187f, -0.00744899f, 0.02610500f, 
    0.01813409f, -0.03328663f, 0.01102460f, -0.00285920f, -0.01085428f, -0.04149115f, 0.00933408f, 0.01010564f, 
    -0.01435783f, 0.02297195f, 0.02735633f, -0.00922148f, -0.00707847f, 0.00228380f, 0.02885534f, -0.02675502f, 
    -0.00654196f, -0.03367525f, 0.02023123f, -0.00273777f, -0.00012841f, 0.02386146f, -0.02313520f, -0.01457949f, 
    -0.00775870f, 0.02445618f, 0.00760989f, -0.01120905f, 0.02582791f, -0.02785835f, -0.01597598f, -0.02552193f, 
    0.02044878f, -0.02370701f, 0.02233464f, 0.00558594f, -0.04109431f, 0.00676633f, -0.02223918f, -0.03353110f, 
    -0.03745287f, 0.02177740f, -0.01601867f, -0.02151288f, -0.00191902f, -0.02837161f, 0.01303581f, -0.00927162f, 
    0.00010470f, -0.02928304f, 0.00547358f, -0.03071973f, 0.02368146f, -0.01883471f, 0.00568110f, -0.00421011f, 
    -0.01297997f, -0.02218772f, -0.01216314f, -0.02305509f, -0.04037777f, 0.02950973f, -0.00800013f, 0.00474439f, 
    0.00469365f, -0.01748020f, -0.01341163f, 0.00569422f, -0.02000441f, -0.01639547f, -0.01783710f, -0.04012213f, 
    0.00659835f, 0.00076267f, -0.00999356f, 0.01417060f, 0.02922386f, 0.00986535f, -0.00953106f, -0.03982802f, 
    0.01769040f, -0.03155714f, -0.00826774f, -0.01754991f, -0.01896636f, -0.01995178f, -0.00255769f, 0.00242084f, 
    0.01116022f, -0.01544887f, -0.00199164f, -0.02586712f, -0.01539812f, -0.01334640f, 0.02295639f, -0.02770858f, 
    -0.01782452f, -0.00906722f, 0.01578895f, -0.02632211f, -0.02079423f, 0.01873632f, -0.02022449f, -0.00575700f, 
    -0.04020069f, 0.01698089f, -0.00740973f, 0.00028999f, -0.02337394f, 0.00900892f, -0.00310694f, -0.03438891f, 
    -0.02025902f, 0.01651274f, 0.01085093f, -0.01933356f, 0.01861818f, 0.02216170f, -0.00169235f, -0.01938771f, 
    0.00437061f, -0.02772247f, -0.03714415f, 0.02480195f, -0.01533413f, 0.01103189f, -0.02849499f, 0.01983993f, 
    0.00897657f, 0.00189803f, 0.02405179f, -0.00997440f, 0.02091519f, -0.02072604f, -0.01210432f, -0.00072577f, 
    0.00359322f, 0.02741583f, -0.00370124f, -0.01737160f, -0.02640926f, -0.00177984f, -0.01291542f, -0.01390039f, 
    -0.03029528f, -0.00721895f, 0.02701646f, 0.01135264f, 0.00548441f, 0.00313223f, -0.03885213f, 0.00068614f, 
    -0.03481265f, 0.01382552f, 0.01997753f, -0.01448989f, -0.03641066f, -0.00909863f, -0.03047659f, 0.02037949f, 
    -0.03655596f, 0.00125016f, -0.01483179f, 0.02701465f, -0.03400682f, -0.03542774f, 0.00918570f, -0.04177563f, 
    0.22814570f, 0.11180498f, -0.08043924f, -0.04197828f, 0.05982038f, 0.10803433f, 0.01890127f, -0.03733825f, 
    -0.05938750f, 0.04117593f, 0.14334002f, -0.06213853f, -0.58929151f, 0.14733712f, 0.03511488f, 0.02764226f, 
    0.04226084f, 0.03794972f, 0.11578725f, -0.04206623f, -0.03481089f, -0.03578908f, -0.05503162f, -0.03724213f, 
    0.05766468f, -0.12256694f, -0.18659261f, 0.25073782f, 0.02769218f, 0.01618464f, 0.05822230f, 0.11534661f, 
    0.01170158f, -0.04900554f, 0.01636427f, 0.00808339f, 0.11326393f, 0.21470793f, 0.05310883f, -0.19037126f, 
    0.02449998f, -0.02412671f, 0.01435354f, 0.06945249f, 0.06415781f, 0.08577109f, 0.01587205f, 0.05868250f, 
    0.01875850f, 0.03475296f, 0.05618859f, -0.06378597f, 0.07060704f, -0.02656819f, 0.05379970f, 0.07047367f, 
    -0.11237480f, -0.03303811f, -0.07910170f, 0.07844087f, -0.02179535f, 0.13189729f, 0.10979010f, 0.19478802f, 
    0.09056170f, -0.08584733f, 0.02184266f, -0.00919695f, 0.11030731f, 0.00777002f, -0.06705684f, 0.26137534f, 
    0.24855757f, 0.08953309f, -0.07965393f, 0.00242495f, -0.06278706f, -0.02493388f, 0.06590337f, 0.06607467f, 
    -0.09760126f, 0.07964570f, 0.01222676f, 0.09459713f, 0.25721794f, 0.01999968f, 0.12571329f, 0.05032126f, 
    0.15765573f, 0.10407646f, 0.06440474f, -0.01052812f, 0.17566110f, -0.11500451f, 0.17521296f, 0.01752890f, 
    -0.04409568f, 0.14486861f, -0.02592796f, 0.24207197f, 0.04933885f, -0.09902829f, -0.00762976f, 0.11048210f, 
    -0.06559364f, -0.04747988f, 0.00764679f, 0.02644563f, 0.19484566f, -0.23244502f, -0.04098788f, -0.12581348f, 
    0.07759599f, -0.21233435f, 0.05128271f, -0.08761577f, 0.07429658f, -0.11213203f, -0.13372955f, -0.11248924f, 
    0.16631752f, -0.07285188f, -0.21953706f, -0.06359181f, 0.00032294f, -0.00151065f, 0.00979584f, 0.02558902f, 
    -0.02082961f, -0.05513972f, 0.09053412f, -0.12964959f, 0.56490296f, -0.25370815f, 0.02948621f, -0.04445254f, 
    0.01890818f, 0.02879206f, 0.00000371f, -0.01685624f, -0.00417436f, 0.08811555f, -0.06679089f, 0.01356618f, 
    0.32554427f, 0.07474862f, -0.10349222f, 0.02196943f, 0.00042242f, -0.00800469f, 0.09381134f, -0.01506259f, 
    -0.03318212f, -0.16231443f, -0.01391506f, -0.09563386f, -0.31700513f, 0.14953828f, 0.05095559f, 0.03511478f, 
    0.13222636f, 0.03175488f, 0.15183599f, -0.01958454f, 0.07775276f, 0.16310635f, 0.08335583f, -0.01342494f, 
    0.14206780f, 0.05219755f, -0.07050189f, -0.11375514f, 0.00354189f, 0.14177898f, -0.00685278f, -0.01780512f, 
    0.01170005f, 0.03824759f, 0.03894870f, -0.07261512f, -0.18345794f, 0.05444736f, -0.04191329f, 0.21961845f, 
    -0.10004587f, -0.03119935f, -0.02380281f, 0.11943414f, -0.05837340f, 0.05853749f, -0.01313486f, -0.07506046f, 
    0.08983516f, 0.06547647f, -0.12866859f, -0.10373471f, 0.12296725f, -0.00426353f, -0.04383710f, 0.09960509f, 
    -0.04169420f, -0.01415154f, 0.08907028f, 0.06433482f, -0.09388734f, 0.01843022f, -0.12448339f, 0.14182267f, 
    0.02331660f, 0.10683796f, 0.02051548f, -0.01891796f, 0.01157995f, 0.05226675f, 0.02993827f, -0.13554923f, 
    0.10478827f, -0.12926470f, 0.12186297f, -0.06641264f, -0.03333526f, 0.03935220f, 0.01532115f, 0.06226091f, 
    -0.08738095f, 0.02308361f, -0.00215939f, -0.02711996f, 0.10680325f, -0.01979402f, 0.06566633f, -0.05854276f, 
    -0.00223701f, 0.07614113f, 0.14340469f, 0.06639998f, 0.05423190f, 0.13770023f, -0.16981381f, 0.15179047f, 
    -0.13106324f, 0.04172647f, -0.01809613f, 0.06683239f, -0.10341762f, 0.00239504f, 0.12428464f, 0.08518992f, 
    0.11775567f, -0.01070178f, -0.09015128f, 0.12011200f, -0.11754332f, 0.00095736f, -0.10555563f, 0.21567704f, 
    0.05665562f, 0.01017690f, 0.00766974f, 0.17798817f, 0.04351015f, 0.01715393f, 0.01591620f, 0.00220729f, 
    -0.27543321f, -0.00706160f, -0.36614960f, 0.21525699f, -0.16955365f, 0.00253677f, -0.03603683f, -0.08886096f, 
    0.11330383f, -0.03677830f, 0.00450257f, -0.13257030f, -0.01234751f, -0.23295623f, -0.02873397f, 0.10831894f, 
    -0.05726523f, 0.00592400f, -0.03514724f, -0.20605032f, 0.04999687f, 0.04280293f, 0.04704712f, 0.00402448f, 
    -0.25065663f, 0.00784643f, -0.01426123f, -0.08503062f, 0.11918443f, -0.03618854f, 0.07078995f, 0.08700816f, 
    0.05401453f, 0.05859004f, -0.03783565f, -0.02838936f, -0.04624199f, -0.02785181f, 0.16444851f, 0.07492547f, 
    -0.11256574f, 0.02345786f, 0.11232784f, 0.14220543f, -0.00391785f, 0.05203047f, -0.06589855f, 0.11780125f, 
    0.12894079f, -0.05537331f, -0.32925120f, 0.06130793f, -0.07532834f, 0.04968045f, -0.00862528f, 0.07911142f, 
    0.12074954f, 0.06862798f, 0.08183103f, 0.01567034f, -0.22306402f, -0.00707918f, 0.08275293f, -0.10144868f, 
    0.03404843f, -0.03753331f, -0.05580212f, 0.11641291f, 0.01642487f, -0.10457596f, 0.04080271f, 0.00429675f, 
    0.19101037f, 0.07441628f, 0.11769224f, 0.01121278f, 0.04779023f, -0.03163701f, 0.18816777f, 0.18023051f, 
    0.05176775f, 0.03258805f, -0.19677658f, 0.01804672f, -0.21336453f, -0.02004835f, 0.19628020f, 0.08521196f, 
    0.16245008f, -0.04357900f, 0.02550744f, -0.06865286f, 0.19631207f, 0.06801313f, 0.01339745f, 0.04150325f, 
    0.37453979f, -0.19436423f, -0.15198252f, -0.15710056f, 0.24657993f, 0.07953040f, -0.06651680f, -0.07640756f, 
    -0.01617399f, 0.04166866f, 0.00136032f, 0.00302421f, 0.36213627f, 0.01218233f, -0.17084874f, 0.01446988f, 
    -0.02110431f, 0.04109502f, 0.01167458f, 0.04968264f, 0.07941101f, 0.03462378f, 0.07886755f, 0.02276473f, 
    0.05201491f, -0.20675623f, -0.06260000f, 0.00592159f, 0.01103204f, -0.00771158f, 0.00090163f, -0.07304200f, 
    0.09083769f, -0.11096081f, -0.01396447f, 0.05740194f, 0.09917162f, 0.14229240f, 0.12548731f, 0.00355571f, 
    -0.07141957f, -0.17304537f, 0.21458036f, -0.08743305f, -0.09060423f, -0.01339065f, -0.02771883f, 0.06818517f, 
    -0.22140311f, -0.15027386f, -0.02673837f, 0.03691604f, 0.09816165f, 0.11458686f, 0.12466934f, 0.02671392f, 
    -0.12121499f, 0.06355770f, -0.01330524f, 0.01079720f, 0.25797868f, -0.10788297f, 0.16869962f, 0.00049770f, 
    0.09004155f, 0.04836324f, 0.13045929f, -0.05158903f, 0.11647796f, -0.09414814f, 0.12620156f, -0.00338325f, 
    0.36314198f, -0.12509586f, -0.17422931f, 0.04577652f, -0.03863782f, -0.04642307f, -0.01628757f, -0.03555132f, 
    -0.00429658f, 0.10972536f, -0.01615288f, -0.03425094f, 0.01852035f, -0.34035853f, 0.14740819f, -0.01991383f, 
    -0.02169836f, 0.05157869f, -0.04033928f, 0.14714390f, -0.02514361f, 0.15075867f, -0.07484464f, -0.01836218f, 
    -0.07615755f, -0.00973495f, -0.00927610f, 0.09400854f, -0.01651579f, 0.13442910f, -0.02843927f, 0.05894743f, 
    -0.11940006f, 0.05683402f, -0.08592366f, 0.02206939f, -0.26733974f, 0.00013055f, 0.05262632f, -0.34726489f, 
    0.04855282f, -0.10128579f, 0.02701999f, 0.05159845f, 0.01409451f, -0.07215630f, 0.04507988f, -0.06725265f, 
    0.06425871f, 0.18399499f, 0.02217359f, 0.06907675f, -0.11610232f, 0.12442368f, 0.07317689f, 0.02183715f, 
    -0.01869445f, -0.04913644f, 0.02094195f, -0.05369789f, 0.37709478f, -0.27926251f, 0.05197794f, 0.05725649f, 
    -0.01304882f, 0.00804509f, -0.04140657f, -0.00996368f, 0.08515777f, -0.04896189f, 0.14864689f, 0.06083639f, 
    -0.10132798f, 0.10046981f, 0.08275516f, 0.04433735f, 0.07286777f, 0.00867616f, 0.03878773f, 0.16115329f, 
    0.01502819f, 0.09830210f, 0.01354369f, 0.06504931f, 0.10232380f, -0.03008966f, -0.08416544f, 0.20128846f, 
    0.07381804f, 0.21877965f, -0.01548815f, 0.13113113f, 0.04064400f, 0.18969220f, -0.01750285f, -0.02350148f, 
    0.02191790f, 0.10707421f, -0.20013608f, -0.18149072f, 0.00996261f, 0.15221182f, 0.00757758f, -0.07828386f, 
    -0.12007206f, 0.03079837f, 0.01133145f, -0.16615845f, -0.22479762f, -0.05432193f, -0.11998545f, 0.28509203f, 
    -0.03047467f, 0.05273594f, 0.06092068f, 0.14486066f, 0.07897826f, 0.04086760f, -0.12512669f, -0.03951528f, 
    -0.17513320f, 0.30924737f, 0.18907185f, 0.06389062f, 0.09112886f, -0.08304735f, 0.18476920f, 0.07506655f, 
    0.09982079f, 0.08162030f, -0.08616262f, 0.17811151f, -0.20434724f, 0.06303632f, -0.14925469f, -0.00386444f, 
    0.00865164f, -0.00210694f, 0.09577245f, 0.01059590f, -0.05682015f, 0.01920261f, 0.11520650f, 0.04509769f, 
    -0.06944175f, 0.25598776f, -0.00274734f, 0.08357123f, 0.05621783f, 0.00623778f, -0.03246115f, -0.05030264f, 
    0.04378330f, -0.05960494f, -0.07035893f, 0.04179956f, -0.23406562f, 0.04563755f, 0.02036764f, -0.04705921f, 
    -0.11136120f, -0.09877893f, 0.01573549f, -0.05322903f, 0.05180382f, -0.02921926f, 0.02887586f, 0.02107888f, 
    0.00866678f, -0.05490149f, -0.15198614f, -0.02970531f, 0.11898830f, 0.08720242f, -0.13033685f, 0.04948824f, 
    -0.02829136f, -0.06791519f, 0.10801305f, 0.01857121f, -0.03766556f, 0.04694171f, 0.04885830f, 0.20763923f, 
    0.01815423f, 0.04257637f, 0.06740107f, -0.04970848f, 0.11607742f, -0.00135522f, 0.08222947f, 0.05516003f, 
    0.29295582f, -0.38305315f, -0.13598898f, -0.15329576f, 0.07425482f, -0.03367427f, 0.01127127f, 0.14365679f, 
    -0.11467583f, -0.06038330f, 0.00918084f, -0.10665613f, 0.12588598f, 0.03626831f, -0.05558259f, 0.03085655f, 
    -0.22742942f, 0.08151254f, 0.12921351f, -0.06921106f, 0.14747731f, 0.00438678f, 0.10000350f, 0.01924288f, 
    -0.07281397f, -0.10652373f, 0.14717908f, -0.07163325f, -0.04491150f, -0.01089147f, -0.09524826f, -0.07794162f, 
    0.10171275f, -0.12396257f, -0.01449320f, 0.00610922f, -0.06474346f, -0.10766687f, -0.21861278f, 0.02637084f, 
    -0.11195064f, -0.24762073f, 0.04505264f, 0.05473283f, 0.00715536f, 0.04943969f, 0.04281406f, 0.14118950f, 
    -0.07384824f, 0.04713242f, 0.11981568f, -0.07023963f, 0.13711619f, -0.17718746f, -0.11902864f, -0.03053343f, 
    -0.07440413f, -0.07770138f, -0.03124735f, 0.03806627f, -0.27970243f, -0.14101869f, -0.21007735f, 0.14457977f, 
    -0.25163746f, -0.12127294f, -0.03784189f, -0.08277122f, 0.04041540f, 0.04730428f, -0.03840544f, -0.06764176f, 
    0.10494437f, 0.14081392f, 0.05099595f, 0.08202732f, -0.07804430f, 0.07352768f, 0.02088214f, -0.00157215f, 
    0.04262510f, 0.06307649f, 0.12491751f, -0.03725375f, -0.10002933f, 0.02473614f, -0.15962312f, -0.04429923f, 
    0.06254193f, 0.00278006f, -0.05505709f, 0.01269606f, 0.00111273f, 0.01832304f, 0.12304620f, 0.06423843f, 
    0.22160271f, 0.12124837f, 0.14765106f, 0.18189466f, 0.21684460f, -0.08957813f, 0.04732870f, 0.04994958f, 
    0.00057346f, 0.19450089f, -0.09808119f, 0.15758333f, 0.13243443f, -0.02246782f, 0.04966152f, -0.09639447f, 
    -0.11830333f, 0.04817056f, -0.02278339f, -0.04380020f, 0.12075740f, 0.09405848f, 0.15473309f, -0.09500925f, 
    0.22653916f, -0.07892470f, 0.01583134f, -0.08063647f, 0.15157129f, 0.03623532f, -0.11686056f, 0.17023198f, 
    -0.10479987f, -0.03248982f, -0.08851044f, -0.00545961f, -0.15291394f, -0.11880950f, -0.03346956f, 0.03220138f, 
    0.03519349f, 0.00913015f, -0.00853302f, -0.02701174f, -0.05843873f, 0.05321230f, -0.06499248f, -0.02914432f, 
    -0.00077925f, 0.02665780f, 0.02925318f, -0.00211629f, 0.01500029f, 0.02319601f, -0.02114915f, -0.01140348f, 
    0.02966824f, -0.02383790f, -0.01449900f, -0.02584117f, -0.03618697f, 0.01885726f, -0.03245084f, -0.02819444f, 
    -0.01542844f, -0.00867917f, -0.00664767f, -0.00802041f, 0.02240054f, -0.02446690f, -0.00210846f, 0.00098259f, 
    -0.04002377f, -0.02493924f, -0.02465357f, -0.03410028f, -0.02146288f, -0.03641173f, -0.00120747f, 0.00371395f, 
    -0.03534772f, -0.03457761f, -0.00371301f, 0.02298425f, -0.00195037f, -0.00303712f, -0.03795694f, 0.02620996f, 
    -0.00761893f, 0.01363698f, -0.02258588f, -0.03515163f, -0.02351698f, -0.02099193f, 0.02316822f, 0.00039145f, 
    -0.00007273f, -0.03816290f, -0.03912454f, -0.03238309f, -0.03858035f, 0.01311399f, 0.01140008f, -0.02093454f, 
    0.02413000f, -0.01511369f, -0.04095589f, 0.02631254f, -0.03910770f, -0.00557553f, 0.02017837f, -0.02830691f, 
    0.00283330f, -0.02698097f, 0.01538599f, -0.02492626f, 0.00620507f, -0.02189813f, -0.01292665f, -0.01806372f, 
    -0.00522181f, -0.03852619f, -0.02641894f, -0.01262315f, 0.01625421f, -0.01031588f, 0.01850369f, -0.01009846f, 
    0.02581592f, -0.03179416f, -0.00739905f, -0.02528612f, 0.02027443f, 0.01939182f, -0.02028348f, -0.00082654f, 
    -0.02468638f, -0.03723961f, -0.02811260f, -0.01416396f, 0.02041595f, -0.02556682f, -0.03595887f, -0.01436854f, 
    0.00007161f, -0.01463520f, -0.02804166f, 0.00094456f, -0.01786821f, 0.00098822f, 0.02703951f, -0.00772168f, 
    -0.02196513f, -0.03597653f, -0.03323363f, -0.01990440f, -0.01969270f, 0.02813538f, -0.00729986f, -0.01069087f, 
    -0.03321907f, -0.02092626f, 0.00237560f, 0.01185236f, -0.04113600f, 0.01326602f, -0.02877266f, 0.02752321f, 
    0.00558858f, -0.02361146f, 0.02783368f, -0.00605105f, -0.00846187f, 0.02676596f, 0.02783730f, -0.01005512f, 
    0.00863126f, -0.02029835f, -0.01998597f, 0.03194510f, -0.01570061f, -0.02905119f, -0.00673675f, 0.02378535f, 
    0.00060354f, 0.00585424f, 0.01717755f, -0.03171302f, 0.01544508f, 0.02836809f, 0.01846049f, -0.02267849f, 
    0.00743090f, -0.03516771f, 0.00980307f, 0.00818499f, 0.00048909f, 0.02037187f, 0.02737281f, 0.02523516f, 
    -0.02583048f, 0.00458623f, 0.00308202f, -0.01087825f, 0.02158293f, 0.01124454f, -0.00236646f, -0.00477548f, 
    -0.00094158f, 0.01052480f, -0.01553786f, -0.03584662f, -0.03476753f, 0.01706068f, -0.00755214f, 0.02000512f, 
    -0.03219004f, 0.00180610f, -0.03781875f, -0.00155096f, -0.03897296f, -0.03675732f, -0.00504780f, 0.02414543f, 
    0.02675003f, -0.00636712f, 0.02088337f, -0.01763554f, -0.01591264f, -0.00941806f, -0.03451307f, -0.02582211f, 
    0.00011146f, -0.00025787f, -0.02721152f, -0.03589552f, 0.01502338f, -0.03649515f, -0.00463104f, 0.02511449f, 
    0.00685698f, -0.03312518f, -0.01301891f, 0.02154534f, 0.00238227f, -0.01877999f, -0.01909514f, 0.00922842f, 
    -0.02317909f, -0.01553163f, 0.01996228f, 0.00717376f, 0.00994507f, -0.03660610f, -0.01639391f, 0.01011715f, 
    -0.02491205f, -0.00854334f, -0.00418725f, -0.02843938f, 0.00421201f, -0.03834698f, 0.00215210f, 0.01717591f, 
    -0.03890415f, -0.00672978f, 0.02054571f, 0.02948312f, 0.01223747f, -0.03437644f, 0.01972382f, -0.01339747f, 
    0.04180141f, 0.00227955f, 0.01543227f, 0.00886234f, -0.03280729f, 0.00408727f, -0.03491084f, 0.01498890f, 
    0.01080235f, -0.03790176f, -0.03198661f, 0.00388034f, 0.02385441f, -0.03540617f, -0.03791142f, -0.03599422f, 
    0.01763185f, -0.02681097f, 0.01309831f, 0.02111227f, 0.02655302f, -0.00283698f, 0.01667420f, -0.02657003f, 
    -0.00632285f, -0.02497097f, -0.03304180f, 0.01658195f, -0.00706911f, -0.01284050f, 0.02524480f, -0.00274067f, 
    0.00395399f, -0.03363915f, -0.00068817f, -0.02915795f, -0.01588872f, -0.02954214f, 0.02548840f, -0.00015646f, 
    -0.00676045f, -0.00370685f, -0.00281377f, 0.00732534f, 0.00218466f, -0.03837492f, 0.00049490f, 0.01621849f, 
    -0.03899922f, -0.03026881f, -0.02241802f, 0.04108104f, -0.02461710f, -0.02114882f, -0.01300005f, -0.03206621f, 
    -0.02337036f, -0.00695913f, 0.00956693f, -0.03599102f, 0.00640894f, 0.00686265f, -0.02855368f, 0.02534807f, 
    -0.02957503f, -0.04084467f, -0.02890524f, -0.00111689f, -0.00242696f, 0.02959834f, 0.02684699f, -0.00609864f, 
    -0.02732123f, -0.01616447f, 0.01135685f, 0.02264501f, 0.02667063f, -0.03986254f, -0.02738155f, 0.01438216f, 
    -0.02788955f, -0.02029810f, 0.02890639f, -0.01487150f, 0.00020037f, 0.00464237f, -0.01303191f, 0.01993924f, 
    -0.00913117f, 0.01630555f, 0.01720714f, -0.02126284f, -0.03698127f, 0.01890212f, 0.02637779f, 0.01141410f, 
    0.01957442f, 0.00558827f, -0.00351346f, -0.01073131f, 0.01132451f, 0.01431554f, -0.02218059f, -0.01087308f, 
    0.02016718f, -0.03552337f, -0.03938003f, 0.01776198f, 0.02172303f, 0.00248901f, -0.03706693f, -0.03860151f, 
    -0.00337310f, 0.02388233f, -0.01404798f, -0.02640291f, -0.00390165f, -0.02417745f, 0.00016402f, -0.02270054f, 
    0.00063237f, 0.01392809f, 0.03004763f, -0.01146712f, 0.01433451f, 0.00243628f, 0.02653151f, -0.01024248f, 
    -0.02927512f, -0.03079635f, -0.00303489f, 0.02187891f, 0.02369146f, 0.01852354f, -0.00810883f, -0.01128825f, 
    0.00725066f, -0.00943655f, 0.02985722f, 0.01991988f, -0.00491441f, -0.03674804f, -0.00891830f, -0.00164082f, 
    -0.00352069f, -0.01867259f, -0.02339340f, -0.02079094f, 0.02603109f, -0.02366247f, -0.00958563f, -0.02134178f, 
    -0.02448851f, 0.00006244f, -0.04026042f, 0.02810615f, 0.00329944f, 0.02345755f, -0.03662752f, -0.02819425f, 
    -0.00734952f, -0.03037239f, -0.02566232f, 0.01075955f, -0.02382226f, 0.00866218f, -0.00904370f, 0.01755652f, 
    -0.00687245f, -0.01277716f, -0.03679884f, -0.04141990f, -0.02967330f, -0.02209393f, -0.03035934f, -0.00830840f, 
    0.00419942f, -0.03471344f, -0.01452421f, 0.01370987f, -0.02410023f, 0.02948718f, -0.01185952f, -0.03457474f, 
    -0.03090822f, -0.01540578f, -0.03992914f, 0.02197501f, -0.01307375f, 0.02583782f, 0.00490650f, -0.03586572f, 
    0.00306329f, -0.00433541f, -0.01093082f, -0.01598183f, -0.01271330f, 0.00239956f, 0.02141749f, -0.00219263f, 
    -0.03055898f, 0.00975068f, -0.01330261f, -0.03231410f, -0.03139137f, 0.01391049f, -0.01896873f, 0.00009732f, 
    0.02562176f, -0.01411359f, 0.00645821f, -0.03173877f, -0.01692731f, 0.00298479f, 0.02348188f, 0.00165124f, 
    0.01705788f, 0.02774755f, 0.00102310f, -0.02481392f, 0.00971757f, 0.00598767f, -0.01098129f, 0.01185941f, 
    0.00411616f, 0.01663782f, 0.00015005f, -0.02309545f, 0.01705569f, -0.00275101f, -0.03514371f, -0.00451599f, 
    -0.02921232f, -0.04058363f, -0.01897630f, 0.02104731f, -0.00567425f, -0.00542509f, 0.02681775f, -0.02736426f, 
    -0.03631869f, -0.01782248f, 0.01709756f, -0.00841400f, -0.02393426f, -0.00475463f, -0.00160030f, -0.00087833f, 
    0.01828505f, -0.00345164f, -0.01681151f, -0.01553451f, 0.00944902f, -0.00535039f, -0.02108569f, -0.04055320f, 
    0.00462984f, 0.02198119f, -0.01953762f, -0.00518592f, 0.01407355f, -0.02270141f, 0.00595364f, 0.00753168f, 
    -0.03064570f, 0.04012117f, -0.03899165f, -0.03255305f, -0.00066271f, -0.03871443f, -0.03884939f, 0.02792281f, 
    0.00941614f, -0.01362379f, -0.03854012f, -0.02920603f, 0.01130498f, 0.00656876f, -0.00295984f, -0.01465827f, 
    -0.00517952f, -0.03727205f, -0.00777067f, -0.03169597f, -0.04091608f, 0.01873168f, 0.01860669f, -0.02632974f, 
    0.00415233f, -0.00061442f, -0.02607798f, 0.02096531f, -0.02116421f, -0.01743186f, 0.01209950f, 0.02835131f, 
    0.02278834f, -0.00349222f, 0.02428775f, -0.02346889f, -0.02685068f, -0.02090905f, 0.01866681f, -0.03200610f, 
    -0.02962664f, 0.01714119f, -0.03287844f, -0.01759428f, -0.02270093f, -0.04063158f, -0.00835785f, 0.00509220f, 
    0.00273355f, -0.03770914f, -0.02218865f, 0.01361781f, 0.00828715f, 0.01400331f, 0.01852538f, -0.03865466f, 
    -0.01278420f, -0.00534480f, 0.02325003f, 0.02958736f, 0.00489640f, -0.02813789f, 0.01920041f, -0.02473320f, 
    -0.03178012f, -0.00539919f, 0.02075525f, -0.00831013f, 0.02810957f, -0.00292344f, -0.00052119f, -0.01259187f, 
    -0.01236107f, 0.02053525f, 0.00430979f, 0.00308665f, -0.03627861f, 0.01558313f, 0.01768578f, -0.01895240f, 
    0.01502663f, -0.02175476f, -0.03772934f, 0.01613950f, 0.00876511f, 0.02450838f, 0.02701140f, -0.01689457f, 
    0.00128956f, -0.04139783f, -0.01527839f, 0.00587335f, 0.01531893f, -0.00976531f, 0.01101908f, -0.01101911f, 
    -0.03143372f, -0.00951668f, -0.02896259f, -0.02188855f, -0.02324964f, -0.03270635f, 0.02467488f, -0.02888206f, 
    -0.01821708f, -0.02922421f, -0.02811219f, -0.01233374f, -0.04000096f, -0.02591753f, -0.02739353f, -0.03158740f, 
    -0.01304387f, -0.00612740f, -0.00785450f, 0.00034950f, 0.02954940f, -0.01388840f, -0.01910340f, 0.01296138f, 
    -0.01297020f, -0.02323016f, -0.00072964f, -0.01944570f, -0.03809509f, -0.01991446f, 0.02112636f, 0.00063822f, 
    -0.04140886f, 0.02065543f, -0.02810295f, -0.02530513f, 0.02310896f, 0.00467817f, -0.02856392f, 0.02572850f, 
    -0.03730589f, -0.01375641f, -0.01862364f, -0.02592467f, -0.02186771f, -0.01429674f, -0.03957475f, 0.00313641f, 
    0.00620051f, -0.01218081f, 0.02246709f, 0.01852213f, -0.02365668f, -0.00427038f, 0.00536360f, -0.01640867f, 
    0.02887280f, 0.02922062f, 0.02936965f, -0.01966342f, -0.00748021f, 0.01257820f, -0.02630237f, 0.00764827f, 
    0.02888020f, 0.02232358f, -0.00236220f, 0.00867201f, -0.02730933f, 0.00813007f, 0.00413960f, 0.01785943f, 
    -0.00186813f, -0.02323023f, 0.00137468f, -0.01998329f, 0.02855571f, 0.00226665f, 0.02079529f, 0.01285476f, 
    -0.03871961f, 0.00766852f, 0.03030681f, -0.03645642f, 0.00073516f, 0.02660752f, -0.04138077f, 0.01017480f, 
    -0.01451819f, -0.00788223f, -0.01428715f, -0.00129214f, -0.00181433f, -0.02409828f, 0.01448097f, 0.02001113f, 
    -0.02746308f, -0.02416017f, -0.03986048f, 0.02098878f, -0.02245966f, -0.01882306f, -0.01548539f, 0.02167703f, 
    0.01510909f, -0.03191025f, 0.00780328f, -0.00476521f, -0.03315897f, -0.04048118f, -0.01137755f, 0.02671100f, 
    -0.01945635f, -0.01508834f, -0.00372372f, -0.00543831f, -0.02892292f, 0.00736407f, -0.02606399f, 0.00934661f, 
    -0.00198619f, -0.02591578f, -0.00017491f, 0.02320323f, -0.02805931f, -0.01890781f, 0.02096911f, 0.02327159f, 
    -0.00409956f, -0.03809661f, 0.02594483f, 0.02332014f, -0.02502492f, -0.01773769f, 0.01349668f, -0.02772619f, 
    -0.01350489f, 0.01968637f, 0.00510865f, -0.01514001f, -0.01755345f, 0.02791902f, -0.00331266f, -0.01657307f, 
    0.01221121f, 0.00398998f, -0.01680688f, -0.00458682f, 0.02955302f, -0.01934197f, 0.00332495f, 0.02998870f, 
    -0.03616546f, -0.02420526f, 0.00190354f, -0.02574516f, -0.00504756f, -0.02010973f, -0.03169272f, 0.02237010f, 
    -0.01592817f, -0.02980706f, 0.01484775f, -0.03691324f, 0.00216279f, 0.00666756f, 0.02107763f, -0.02924983f, 
    -0.03256535f, 0.00751811f, -0.02300025f, 0.00984326f, -0.03821099f, -0.03741606f, 0.00016656f, 0.01651934f, 
    0.01980840f, 0.02917456f, 0.01505629f, -0.03603049f, -0.04089738f, 0.01265157f, 0.00485875f, 0.02950600f, 
    0.06746536f, 0.11146126f, 0.05225384f, 0.21335123f, -0.15254822f, -0.07330409f, -0.01862048f, 0.05791711f, 
    0.02966117f, -0.03209177f, 0.04695408f, 0.00583126f, -0.25457120f, 0.00882078f, -0.00458976f, -0.03353301f, 
    -0.02926836f, -0.08765720f, -0.08687456f, 0.07421402f, -0.03921803f, -0.05387717f, -0.01623597f, -0.11367676f, 
    0.08197843f, -0.10192548f, -0.35259882f, 0.28142452f, -0.00246975f, -0.00660522f, -0.02190886f, -0.07210226f, 
    0.09901244f, 0.06297871f, 0.18176807f, -0.13751815f, 0.06497584f, -0.14575140f, -0.29820213f, -0.10842081f, 
    -0.02002424f, -0.06193057f, 0.00859987f, 0.13178492f, 0.02902221f, -0.04652822f, 0.14260399f, 0.06086965f, 
    0.04472411f, -0.12676440f, -0.00336176f, -0.12141576f, 0.02774053f, -0.00560336f, -0.01248616f, 0.05289521f, 
    -0.01802394f, 0.12121158f, -0.01146416f, 0.05721481f, 0.18684608f, -0.09001733f, -0.19432294f, -0.12622814f, 
    0.03327822f, -0.01174124f, -0.04207965f, -0.05209702f, 0.11926793f, 0.01432949f, -0.03063753f, 0.17513601f, 
    -0.18897271f, 0.06654615f, 0.12375507f, -0.05100652f, 0.09215376f, -0.10108972f, 0.00729636f, -0.02928738f, 
    -0.06239563f, 0.01476572f, -0.11440482f, 0.21178249f, 0.30162403f, -0.23108344f, -0.17320278f, 0.11636133f, 
    0.05575999f, -0.02181778f, -0.00973213f, -0.01703241f, 0.06646731f, -0.11841188f, -0.00746081f, -0.01125159f, 
    0.23000485f, -0.05396756f, -0.05934278f, -0.04755493f, 0.09194811f, 0.02437871f, -0.05022872f, 0.08078384f, 
    0.11645751f, 0.04683984f, -0.00487531f, 0.08489503f, 0.02726791f, 0.21397933f, -0.03917605f, -0.09029087f, 
    -0.05179978f, -0.02078464f, -0.06561978f, -0.12287581f, 0.04712865f, 0.03039238f, -0.10755607f, -0.04278721f, 
    0.30953199f, 0.09779788f, -0.09999948f, 0.12061588f, -0.02150170f, -0.00821299f, 0.06193116f, 0.10655908f, 
    0.09374060f, 0.02161481f, 0.15011270f, -0.04049295f, -0.18333456f, 0.19427432f, 0.23487252f, -0.14728002f, 
    0.07377232f, -0.04067403f, 0.10928841f, 0.00456165f, -0.09396101f, 0.06472813f, 0.03485220f, -0.07779821f, 
    0.12468881f, 0.22898665f, 0.03578817f, 0.07905494f, 0.16347709f, 0.11169275f, -0.03179108f, -0.02806468f, 
    -0.00440382f, -0.13441536f, 0.03292823f, -0.06559830f, 0.11115551f, -0.14800338f, -0.05950193f, -0.17400929f, 
    0.08662484f, 0.05438942f, -0.11344456f, -0.04195815f, -0.05080817f, -0.09759624f, 0.10171705f, -0.01424091f, 
    0.31740066f, 0.29228848f, -0.01150773f, 0.04450931f, -0.05979517f, 0.07199998f, -0.05184615f, -0.07287002f, 
    0.14789921f, -0.10521025f, 0.02756106f, -0.09658133f, 0.21861458f, -0.20796372f, -0.05058160f, 0.03006903f, 
    0.00687810f, -0.03952406f, 0.09018110f, 0.05990260f, 0.16051047f, 0.05373937f, 0.13808627f, 0.19136633f, 
    0.33480683f, 0.11927117f, 0.04884258f, 0.07794171f, 0.11463951f, -0.01212011f, -0.18147065f, 0.10831464f, 
    0.04413774f, -0.00082611f, 0.02051580f, -0.03989939f, 0.20914820f, 0.01367565f, -0.05494375f, 0.12400361f, 
    0.08153678f, -0.00699329f, -0.03915297f, -0.06753027f, -0.05992703f, 0.03515874f, 0.07776017f, 0.02520303f, 
    0.21692885f, -0.24884075f, -0.09683671f, -0.02373333f, 0.01955957f, -0.04907187f, 0.06525548f, -0.05480351f, 
    0.11249167f, 0.04003502f, -0.11975986f, 0.04439121f, 0.13030483f, -0.20695624f, 0.04616531f, 0.17416166f, 
    -0.07896119f, 0.07282671f, 0.03383160f, -0.09675489f, 0.07353222f, -0.01720272f, -0.11140030f, -0.00947183f, 
    -0.02137380f, -0.23667553f, -0.13951510f, -0.16250572f, 0.08881807f, 0.13964261f, -0.02634989f, -0.00338001f, 
    0.18326019f, -0.01133919f, 0.04219648f, -0.07473204f, 0.10583448f, -0.07618179f, 0.04757430f, 0.17799003f, 
    0.02467112f, -0.07775541f, 0.15678723f, 0.06755055f, 0.08927541f, 0.00695241f, -0.02337288f, -0.07340021f, 
    0.33704773f, 0.01928633f, -0.02906059f, -0.03396733f, -0.00117730f, -0.07389160f, 0.00190860f, 0.12104816f, 
    0.08838122f, 0.02697914f, 0.03910820f, 0.10328540f, -0.04990531f, -0.08522933f, -0.08669573f, 0.24081831f, 
    0.21677114f, -0.01624373f, -0.10414311f, 0.08913410f, 0.05914750f, 0.11683751f, 0.03409898f, 0.18324716f, 
    0.37091526f, -0.09566505f, 0.23468326f, 0.36922616f, 0.07834350f, -0.05528134f, -0.05986087f, 0.07467464f, 
    0.08649606f, 0.05068748f, -0.04111646f, -0.02935094f, -0.00583966f, -0.23088934f, -0.08918747f, -0.09569240f, 
    0.04729460f, 0.01835702f, -0.00538163f, 0.01063852f, -0.01595404f, 0.06048544f, -0.01289799f, 0.10759069f, 
    0.14868808f, 0.08298651f, 0.20799567f, 0.07923891f, -0.12120622f, -0.05183396f, -0.13759728f, -0.09994485f, 
    0.01572608f, 0.03585897f, 0.10732583f, 0.05302894f, 0.02644346f, -0.20726644f, -0.21488807f, -0.15882155f, 
    -0.00216257f, -0.01742429f, -0.08762451f, -0.01957106f, -0.10297529f, -0.06626721f, 0.04604636f, -0.07902311f, 
    0.14113531f, -0.10868295f, -0.04003801f, 0.30848140f, -0.01180760f, -0.14399213f, -0.01401174f, 0.15799016f, 
    0.13052484f, 0.00992673f, -0.05871816f, -0.11567931f, 0.20937176f, -0.33140793f, -0.00197892f, 0.20511870f, 
    0.04914004f, -0.14684279f, 0.01216572f, 0.01868035f, -0.02154524f, 0.05977173f, 0.11904862f, 0.11562199f, 
    0.21712951f, 0.05651845f, -0.01656774f, 0.00836285f, 0.08951426f, -0.04559917f, -0.02592024f, -0.07983032f, 
    0.10983523f, 0.10633191f, -0.12971257f, 0.14397770f, 0.11133305f, 0.17918256f, 0.10261063f, 0.17119837f, 
    0.07648524f, 0.08453700f, 0.15619013f, -0.02917318f, -0.00787630f, 0.05847678f, 0.11329090f, -0.07547309f, 
    -0.01759734f, 0.04581006f, 0.17738684f, -0.09125499f, 0.01932256f, 0.07140815f, 0.16301586f, -0.02244530f, 
    0.09516889f, -0.12711541f, 0.10649049f, -0.09860873f, 0.23277287f, -0.09282416f, -0.13407618f, -0.04658814f, 
    0.01119669f, -0.04518326f, 0.00549849f, -0.01548450f, -0.00336474f, 0.01919319f, 0.00203698f, 0.05699197f, 
    0.09181622f, 0.09090436f, -0.18509789f, 0.05760569f, 0.01856751f, -0.03533461f, 0.02529374f, 0.00901318f, 
    -0.00033247f, -0.09123867f, 0.06864971f, 0.09121744f, -0.16920206f, -0.19226357f, -0.08529191f, -0.12533395f, 
    0.06995983f, -0.02648908f, 0.12075737f, 0.02168125f, 0.05259149f, 0.01816849f, -0.19125770f, 0.03914256f, 
    0.09242162f, 0.16688271f, -0.04019591f, 0.08960116f, -0.05416930f, 0.08115173f, 0.06034458f, 0.05874160f, 
    0.03187855f, 0.06000138f, 0.09024946f, -0.01043757f, -0.09116852f, -0.10329218f, 0.21418108f, 0.11766526f, 
    -0.02137896f, -0.05203643f, 0.05880983f, -0.14714880f, -0.01298661f, 0.12666221f, 0.12932482f, -0.01656858f, 
    -0.30647677f, 0.15944341f, 0.00500379f, -0.02226443f, 0.13722587f, 0.04330198f, -0.04196446f, -0.11868314f, 
    -0.04715862f, -0.07353834f, -0.07451442f, 0.19198178f, 0.07260828f, 0.20881616f, 0.23908408f, 0.19871528f, 
    -0.03686121f, 0.07132204f, -0.04836571f, 0.02597229f, -0.05849108f, -0.16689065f, 0.07046248f, -0.04581779f, 
    0.04584197f, -0.20887078f, -0.12843226f, -0.09203504f, -0.04443890f, -0.02517145f, -0.02464871f, 0.10263828f, 
    0.06612910f, 0.14128298f, -0.17547427f, -0.08042397f, -0.32393217f, 0.24824041f, 0.00924566f, -0.08091893f, 
    0.13478547f, -0.11042731f, 0.00388159f, 0.18759489f, 0.08325468f, 0.09859649f, -0.23255709f, -0.02892649f, 
    -0.08524050f, -0.09964035f, -0.23094298f, 0.04556432f, 0.05194072f, -0.06203560f, 0.00990178f, 0.00293585f, 
    0.04704511f, -0.07764273f, -0.04861878f, -0.08843354f, -0.11379906f, 0.07885480f, 0.09996900f, 0.12768017f, 
    0.04187738f, -0.11103494f, -0.07707945f, 0.05354015f, 0.02826902f, 0.07258159f, -0.02918485f, 0.02893234f, 
    -0.34221035f, 0.03138350f, 0.18085156f, -0.01158662f, -0.11627270f, -0.04617756f, -0.06024092f, -0.08833204f, 
    -0.10266687f, 0.04084744f, 0.08344349f, 0.19191423f, -0.21355344f, 0.23190741f, 0.11915106f, 0.37312263f, 
    -0.04377164f, -0.06446753f, 0.05773665f, 0.14728639f, 0.14681225f, -0.12140130f, -0.04985500f, -0.01518573f, 
    0.28821996f, 0.05962351f, 0.04798906f, 0.04221513f, -0.04090492f, 0.02812283f, 0.00702034f, 0.11344949f, 
    0.08700816f, -0.04243953f, -0.08325074f, 0.12425178f, 0.12235025f, 0.11305816f, 0.05461246f, 0.04095023f, 
    -0.05134493f, 0.14942375f, -0.04861620f, -0.00923023f, 0.14822133f, -0.12520489f, 0.03051239f, -0.04981360f, 
    -0.02888348f, -0.09754545f, -0.02872905f, -0.02997720f, 0.08530731f, -0.01240509f, 0.06651661f, 0.03784328f, 
    0.08020863f, -0.00774329f, 0.01217777f, 0.12761024f, -0.32265425f, -0.04428549f, 0.12800673f, 0.11666074f, 
    -0.03764889f, -0.14094158f, 0.00468067f, 0.08271267f, -0.01180732f, 0.05676677f, -0.00409088f, 0.08480526f, 
    -0.20997976f, -0.00472714f, -0.04741641f, -0.17582428f, 0.02314428f, -0.08085633f, -0.04418992f, -0.08538823f, 
    -0.04517214f, -0.17138098f, 0.02825390f, -0.11864648f, -0.27827471f, 0.24161521f, 0.14227822f, 0.06588060f, 
    -0.02184618f, 0.02915654f, 0.10600624f, 0.02668224f, 0.11018968f, 0.04755029f, 0.01185846f, -0.07394777f, 
    0.01605573f, 0.12043913f, -0.05605932f, 0.03264114f, -0.07596285f, -0.02832306f, 0.09536213f, -0.12324085f, 
    0.00555285f, -0.12317063f, -0.01207478f, -0.14840659f, 0.00050995f, 0.02340334f, 0.12001738f, 0.08130658f, 
    0.03227573f, 0.06039661f, 0.00263410f, 0.06172189f, 0.07012592f, -0.05050727f, 0.13397203f, -0.01604648f, 
    -0.04868834f, -0.21954688f, -0.04857248f, -0.07173411f, -0.03169557f, 0.01666969f, -0.09345749f, -0.13328989f, 
    -0.07711995f, -0.05937105f, 0.17042427f, 0.00384846f, 0.03855890f, 0.36134458f, 0.27634186f, -0.01262699f, 
    0.02544955f, 0.10016864f, -0.09284940f, -0.03321614f, 0.01318954f, -0.00112497f, -0.06694456f, 0.00447919f, 
    0.24284543f, 0.05480856f, -0.04611931f, -0.04756463f, 0.05564208f, -0.08241060f, -0.10150136f, -0.05202452f, 
    0.03185723f, -0.01614532f, 0.11085971f, 0.07831575f, -0.12816902f, 0.18572798f, 0.10014669f, 0.20631626f, 
    -0.03243266f, 0.16312410f, 0.00299361f, 0.02998762f, -0.01871286f, -0.09524002f, -0.09061957f, -0.18349215f, 
    0.12778242f, -0.14254890f, -0.26016796f, 0.12041629f, -0.02013662f, -0.02843175f, 0.06212799f, 0.03598421f, 
    0.06252231f, 0.08141378f, 0.06439883f, 0.03160084f, 0.19682547f, 0.10590114f, 0.16705994f, 0.19992557f, 
    -0.05855170f, -0.02418536f, -0.13102409f, -0.01591887f, 0.03498625f, 0.04546305f, -0.05337045f, 0.03325014f, 
    0.26508704f, -0.07044384f, -0.15188292f, -0.11988296f, 0.09668912f, -0.07365971f, -0.04980137f, -0.03161233f, 
    0.08062755f, 0.03181333f, -0.00462227f, 0.20902213f, 0.01461456f, -0.15318190f, -0.05833836f, 0.21728012f, 
    0.06803607f, -0.00784240f, 0.00427793f, -0.07045540f, 0.03785206f, 0.09950724f, 0.05453904f, 0.01049398f, 
    0.02257090f, -0.01615820f, -0.11217919f, 0.37400177f, -0.07570996f, -0.19356543f, -0.14919503f, 0.09761092f, 
    0.07161567f, 0.00750192f, -0.00459546f, -0.02976068f, -0.33792973f, -0.02275999f, 0.12387760f, -0.12926427f, 
    -0.04253416f, -0.00849672f, 0.08081484f, -0.01600371f, -0.11596981f, 0.05947935f, 0.09114252f, -0.01020675f, 
    0.00647253f, -0.00090468f, -0.03172371f, 0.00489193f, -0.03895768f, -0.01434477f, 0.02153986f, 0.01678854f, 
    -0.01443612f, 0.02942893f, -0.02802751f, -0.00584487f, -0.03836591f, 0.02695054f, -0.02278770f, -0.01530000f, 
    0.01669547f, -0.01346403f, -0.03897301f, 0.01424883f, 0.01292668f, 0.00913758f, -0.00908280f, 0.01621540f, 
    -0.00831007f, -0.01567879f, -0.03273510f, -0.03417163f, -0.01132414f, 0.00699864f, 0.01044109f, -0.02317422f, 
    -0.02052801f, -0.00057906f, 0.02757067f, -0.01953445f, 0.01619085f, 0.01385208f, -0.00852642f, -0.01436906f, 
    -0.01165706f, -0.00810072f, 0.02482932f, 0.02407513f, -0.02430613f, -0.02263055f, -0.00366217f, -0.01414992f, 
    0.00419670f, 0.02096984f, 0.00802250f, -0.03954749f, 0.01690707f, 0.00728419f, -0.02118973f, -0.02972073f, 
    -0.02514894f, -0.03708952f, 0.02477072f, -0.02963759f, 0.00925136f, -0.00127217f, 0.00419831f, -0.01348769f, 
    -0.03177490f, 0.01522593f, -0.01865324f, 0.02205756f, -0.03775166f, 0.03301639f, 0.00114375f, -0.03210539f, 
    0.02321883f, -0.01281342f, -0.02674973f, -0.04177280f, -0.03893805f, -0.02955376f, -0.03872179f, 0.01040949f, 
    -0.03994162f, 0.02672612f, 0.00065937f, -0.02583406f, 0.00307677f, 0.02877614f, -0.04102606f, 0.01515768f, 
    0.00789421f, -0.00008910f, 0.00537847f, -0.00181774f, -0.03061822f, -0.00123712f, 0.02351672f, 0.00906553f, 
    0.01806614f, -0.00742363f, -0.02363225f, 0.01728991f, -0.00887404f, 0.01270478f, -0.03614081f, -0.00599170f, 
    0.02110303f, 0.01508034f, 0.01408895f, -0.03399642f, -0.00341984f, -0.00579600f, 0.01350260f, 0.01095211f, 
    0.00017816f, -0.00022449f, 0.01278693f, -0.00441611f, 0.01714026f, 0.00863333f, 0.01126104f, 0.00926472f, 
    -0.00129162f, -0.04127347f, 0.01034424f, 0.02979448f, -0.01880012f, 0.00822534f, 0.00862353f, -0.02344764f, 
    0.00156556f, -0.01265248f, -0.02901050f, -0.00288463f, 0.02320815f, -0.01303306f, -0.02979148f, -0.02735934f, 
    0.00343400f, 0.02920720f, 0.01072693f, -0.01914681f, -0.01384224f, 0.00513084f, -0.02701224f, 0.00713653f, 
    0.00205984f, -0.01354362f, -0.03750862f, 0.02646017f, 0.02775850f, -0.00119020f, 0.02375449f, -0.02987305f, 
    0.00628463f, 0.02145397f, 0.02173663f, 0.00031434f, -0.00685917f, -0.02811561f, -0.03044060f, 0.03005090f, 
    -0.03769750f, -0.01552916f, 0.00824055f, -0.03788452f, -0.02553191f, -0.01364441f, -0.03300843f, -0.03388442f, 
    -0.00002555f, -0.03733335f, 0.01106421f, 0.02689672f, -0.04172693f, -0.00167486f, -0.00931933f, 0.02414793f, 
    -0.01100821f, 0.02927418f, -0.01311076f, 0.02522910f, -0.03018858f, 0.00029456f, -0.01147544f, -0.02519407f, 
    0.01582910f, -0.01434310f, 0.02275173f, -0.00304549f, 0.00930791f, 0.02301695f, 0.01048077f, 0.03451577f, 
    -0.03421957f, -0.00485421f, -0.01579181f, -0.01074800f, 0.00854748f, -0.03852344f, -0.01784087f, -0.04205516f, 
    -0.00574488f, -0.04193054f, 0.00872670f, 0.02254526f, -0.04004407f, 0.00405622f, -0.03954249f, 0.01045577f, 
    0.02282569f, 0.01540007f, 0.00013441f, 0.02110714f, -0.01005283f, -0.02153552f, -0.00322536f, -0.02586881f, 
    -0.00937715f, 0.01655061f, 0.02039976f, -0.02087914f, -0.02244543f, -0.03411400f, -0.02167439f, 0.02685547f, 
    -0.03778428f, 0.01868334f, -0.03665216f, -0.03882839f, -0.02301423f, -0.02866711f, -0.03786414f, 0.02635918f, 
    0.01891672f, -0.03271694f, 0.02770914f, 0.01041948f, -0.00541186f, 0.01982531f, 0.03169831f, 0.01485961f, 
    0.01465874f, -0.04013442f, 0.00394415f, -0.04037586f, -0.00201289f, 0.00301949f, 0.00963228f, -0.04032516f, 
    -0.00356700f, -0.03558125f, 0.02065068f, -0.03622830f, 0.00766776f, -0.02832086f, 0.01185070f, 0.00717231f, 
    -0.03567886f, 0.01207274f, -0.00057693f, -0.01301457f, 0.01462977f, 0.02849584f, -0.04074675f, 0.02018384f, 
    -0.00438077f, 0.00607937f, -0.03174343f, 0.02632507f, -0.00832161f, -0.03866676f, 0.00586582f, -0.03978563f, 
    0.00955726f, -0.04188156f, 0.00794535f, -0.03806406f, 0.03480777f, 0.00998329f, 0.02376746f, -0.03585527f, 
    0.02002057f, -0.02081125f, 0.01803640f, -0.03780264f, 0.03438872f, -0.01767264f, -0.03236071f, -0.01906073f, 
    -0.02545448f, 0.02931043f, 0.03344358f, -0.01815610f, -0.02832575f, 0.02980137f, 0.01686585f, 0.02699392f, 
    -0.03696998f, -0.03742490f, -0.00832798f, -0.01324426f, 0.02949898f, -0.00019305f, -0.00017961f, -0.02807664f, 
    0.00982624f, -0.01430428f, 0.01402295f, 0.02553630f, 0.01133006f, 0.00192994f, -0.03210694f, -0.02701510f, 
    0.01277063f, 0.00588518f, -0.01742031f, -0.00023185f, -0.02848652f, 0.00062327f, 0.01628380f, 0.02185407f, 
    -0.01329860f, 0.01355215f, -0.03681738f, -0.01434184f, -0.00762326f, 0.00982328f, 0.02772056f, -0.01533720f, 
    -0.04075184f, -0.01904528f, -0.02098801f, -0.02507817f, -0.01999143f, 0.00520084f, -0.00072421f, 0.02533161f, 
    0.01316313f, 0.00650121f, 0.02983125f, -0.01487067f, -0.02861030f, 0.02661079f, 0.01437247f, -0.03511579f, 
    -0.00071692f, -0.01928140f, -0.02289515f, -0.01751159f, -0.02778692f, 0.02664358f, 0.02569387f, -0.01474779f, 
    0.01546730f, -0.00265404f, 0.01691658f, 0.02885111f, -0.01588906f, -0.03661364f, 0.00492875f, -0.00261714f, 
    -0.02596412f, 0.02256585f, -0.02603441f, 0.00452319f, 0.03858356f, -0.02465826f, 0.02132084f, -0.04019769f, 
    -0.03338204f, -0.00984761f, -0.03422157f, 0.00287065f, -0.02019261f, -0.00868491f, -0.02883072f, 0.01950947f, 
    0.00932942f, -0.03304502f, 0.00723450f, -0.02483239f, 0.03215233f, 0.00819604f, 0.02906511f, -0.01287494f, 
    0.02355466f, -0.00679376f, -0.01127907f, -0.01519238f, -0.02373823f, 0.00695960f, -0.01197798f, 0.00355838f, 
    -0.00846633f, -0.03341053f, -0.01792195f, -0.01325418f, -0.03928906f, -0.03255085f, -0.04088634f, 0.01997530f, 
    -0.01584034f, -0.02876770f, 0.02335910f, 0.01199220f, -0.02890177f, -0.03035542f, -0.03919782f, 0.02429773f, 
    0.03438529f, -0.01561885f, 0.02916986f, -0.02440402f, -0.00941393f, 0.00739691f, -0.01005971f, -0.02613637f, 
    0.00344793f, -0.02325132f, 0.02395913f, 0.00414727f, 0.00536847f, -0.00986867f, 0.01212432f, 0.01389492f, 
    -0.01309715f, -0.00176560f, -0.02379420f, -0.03734103f, 0.00181185f, 0.00435952f, -0.01754303f, -0.00803466f, 
    0.02821329f, 0.01789569f, -0.03991449f, 0.02477597f, 0.02002803f, 0.00148388f, 0.02430507f, -0.03955269f, 
    0.00674694f, -0.00433337f, -0.00488483f, -0.01409693f, 0.00167221f, -0.03521863f, 0.01688007f, -0.04188780f, 
    -0.01952806f, 0.03395021f, -0.02425249f, -0.00620924f, -0.00878874f, 0.02105151f, 0.02738797f, 0.01519166f, 
    -0.00329440f, -0.02900960f, -0.00071891f, -0.02380816f, 0.01671793f, 0.00132365f, 0.02614423f, 0.00043827f, 
    -0.03186200f, -0.02652534f, 0.02540814f, 0.02550916f, 0.01957272f, -0.03619325f, 0.02247795f, 0.01307998f, 
    -0.00312247f, -0.03099790f, 0.01496147f, 0.02361319f, -0.01861765f, -0.03471079f, -0.04019058f, -0.01470360f, 
    -0.01438048f, -0.01468224f, -0.02611317f, 0.01418177f, -0.02985187f, -0.01070258f, 0.01893027f, 0.02539676f, 
    -0.02733787f, -0.01601538f, 0.00001289f, 0.01537017f, -0.01285808f, -0.01933300f, -0.00660142f, -0.00010942f, 
    0.01413005f, -0.01753961f, -0.01725435f, -0.00742983f, -0.02101963f, -0.01995754f, 0.02670771f, 0.01297490f, 
    0.00406608f, -0.01187677f, -0.00989487f, 0.02975225f, 0.00851866f, -0.02427518f, -0.02629948f, -0.03342132f, 
    -0.02764079f, -0.04127297f, -0.04099554f, 0.02503753f, -0.01694250f, -0.00354366f, 0.02054712f, -0.00801451f, 
    -0.02557094f, -0.03780866f, -0.02452135f, 0.00576289f, 0.00925110f, -0.03937583f, 0.00498649f, 0.02751140f, 
    -0.03740010f, -0.00998236f, 0.02037674f, 0.00098943f, -0.01076941f, -0.01398653f, -0.01717027f, 0.02871077f, 
    -0.00601558f, 0.03131070f, 0.01657231f, -0.00336830f, 0.00183571f, 0.01033390f, 0.01910995f, 0.02457728f, 
    -0.01146667f, -0.00260692f, 0.01269867f, -0.00580063f, -0.01480154f, -0.01126630f, -0.01881554f, 0.00394784f, 
    0.02421711f, 0.00767894f, 0.03985618f, 0.01188029f, -0.00427870f, 0.00694356f, -0.00093135f, -0.01533568f, 
    0.01045350f, -0.02333547f, -0.03816537f, -0.01954678f, -0.00667060f, -0.03104803f, -0.01007254f, -0.01751335f, 
    -0.02951284f, 0.00158032f, -0.03296829f, 0.00485778f, -0.00340675f, -0.02512063f, -0.02557147f, -0.01368810f, 
    0.02122971f, 0.00557374f, 0.02677692f, -0.04022916f, -0.03960016f, 0.01148161f, -0.01084327f, -0.04196832f, 
    0.02717014f, 0.00061284f, -0.01235108f, -0.03602915f, -0.00373645f, 0.02869156f, -0.01387565f, -0.03587613f, 
    -0.01144554f, 0.02387465f, -0.02450795f, -0.00906834f, -0.03319348f, -0.02577041f, -0.01675620f, 0.03767317f, 
    0.00897433f, 0.02778430f, 0.01235214f, -0.01930582f, -0.03806243f, 0.02868637f, 0.02137733f, -0.03916847f, 
    0.01878263f, 0.01100759f, 0.00620758f, -0.01849692f, 0.03544566f, -0.01220451f, -0.00977047f, -0.00015397f, 
    -0.00365445f, 0.02650755f, 0.01620503f, -0.03848795f, 0.02716378f, -0.01830143f, -0.03784222f, -0.02997135f, 
    0.01249066f, -0.00712374f, -0.03037364f, 0.02013869f, 0.01728924f, 0.00792269f, -0.02441990f, -0.00346493f, 
    0.02927884f, 0.00916703f, -0.03755512f, -0.01622425f, -0.04138430f, -0.01693587f, 0.01625757f, 0.02182014f, 
    -0.02513679f, -0.04186244f, -0.03235304f, -0.04079556f, 0.00698605f, 0.00116678f, 0.01051089f, 0.00735246f, 
    0.00664011f, -0.03076724f, 0.02031445f, -0.04073746f, 0.03911471f, 0.03463363f, 0.02222869f, -0.01491486f, 
    -0.03222972f, 0.01946916f, -0.03738517f, -0.02837948f, -0.02916638f, 0.01747966f, 0.00905540f, -0.00228968f, 
    0.00116409f, -0.01762238f, -0.01828880f, 0.00398657f, -0.02394844f, -0.03260894f, -0.01751482f, 0.02044578f, 
    0.00917194f, -0.00017332f, 0.01978181f, -0.02122570f, 0.00302688f, 0.01084067f, -0.02356925f, 0.04138736f, 
    -0.02498878f, 0.03919521f, 0.01584034f, -0.03101024f, 0.02180757f, 0.00389852f, 0.04114022f, -0.00729484f, 
    -0.01761794f, 0.00234642f, -0.01992646f, 0.02748540f, -0.03989695f, 0.00325232f, -0.01647535f, -0.02052003f, 
    -0.03532075f, 0.00186146f, 0.02558779f, -0.00613793f, 0.02706888f, 0.01019839f, 0.02889729f, 0.02449314f, 
    0.00034942f, -0.01633705f, 0.02781497f, 0.00768384f, -0.00960131f, 0.01420815f, 0.01912959f, -0.02502723f, 
    0.00287542f, -0.03773752f, -0.01121117f, 0.03785044f, -0.00218507f, -0.04194157f, -0.00090645f, 0.00112034f, 
    0.02812009f, -0.03125332f, -0.03674857f, -0.03249317f, -0.02965576f, 0.00569495f, 0.00287862f, -0.00010488f, 
    -0.00643018f, 0.02376482f, -0.00665037f, 0.01363641f, 0.02304357f, -0.00108430f, -0.02418828f, -0.01564563f, 
    0.02402971f, -0.01491203f, -0.01647071f, 0.00980605f, 0.02833197f, 0.00830174f, 0.02098106f, 0.02690681f, 
    0.01783991f, -0.03340057f, -0.01516288f, -0.02689595f, -0.00197337f, 0.01909969f, 0.02954232f, -0.01221909f, 
    0.02431267f, 0.01406897f, 0.01090526f, -0.02719741f, -0.01895368f, -0.02022719f, -0.00928243f, -0.03202445f, 
    0.02409035f, -0.02132699f, 0.00358695f, -0.02074809f, 0.00735453f, -0.00755489f, 0.00769303f, -0.03188556f, 
    0.48901227f, 0.05292582f, -0.12126741f, -0.05324038f, 0.09591849f, -0.00349761f, 0.04611081f, 0.05190609f, 
    0.09734434f, 0.08400434f, 0.03993583f, 0.12104516f, 0.67948031f, 0.05374012f, 0.05954649f, -0.08400019f, 
    -0.03827983f, -0.04821694f, 0.08739617f, 0.03214406f, 0.00364780f, 0.08904129f, -0.01034586f, 0.05965567f, 
    0.12630191f, -0.08684065f, 0.12129536f, 0.10986353f, 0.14974257f, -0.01671832f, -0.19211885f, -0.02027837f, 
    -0.02496335f, -0.08255579f, -0.02137049f, -0.07777308f, -0.33834839f, -0.07010482f, 0.15279402f, -0.22935583f, 
    0.06051546f, 0.00683169f, 0.01947924f, -0.03232863f, 0.05972711f, 0.02366350f, 0.02894653f, -0.01223992f, 
    -0.20025076f, -0.06423856f, 0.22929579f, -0.00553219f, 0.04903264f, 0.03442839f, 0.03143707f, -0.05080316f, 
    0.08821536f, 0.01432307f, 0.00000558f, -0.04051457f, -0.41591996f, -0.26060960f, 0.03699007f, 0.14900123f, 
    0.07312699f, 0.11188325f, -0.03807834f, -0.11951257f, -0.07837051f, 0.07011520f, 0.05200958f, 0.00070358f, 
    0.19298796f, -0.08844358f, 0.05927077f, -0.16534892f, 0.09652563f, -0.14728497f, 0.01735063f, 0.08719951f, 
    0.16697297f, -0.01573559f, 0.09210432f, 0.09089430f, -0.59012610f, -0.17487687f, -0.01485845f, -0.00567751f, 
    0.10111158f, 0.11920939f, 0.12415545f, 0.05694557f, 0.13293874f, 0.03448372f, -0.00547461f, 0.06130400f, 
    0.01422574f, -0.05659150f, 0.10197721f, 0.02334916f, 0.11929788f, 0.03552477f, -0.01682361f, 0.03068606f, 
    -0.02752387f, 0.09077057f, 0.08353739f, 0.05310477f, -0.24339485f, 0.05498898f, 0.13077331f, 0.35936186f, 
    -0.13982509f, 0.18338284f, 0.07705985f, 0.14994834f, 0.05750725f, -0.06131455f, -0.00605030f, -0.01487786f, 
    -0.04279345f, 0.27365798f, -0.03888411f, -0.05753792f, 0.00779712f, -0.05717759f, 0.00833307f, 0.02574586f, 
    0.10173316f, 0.03118904f, -0.05717465f, 0.07267571f, 0.32258600f, -0.29395929f, -0.02634953f, 0.34170485f, 
    -0.09029286f, -0.07236192f, -0.06140060f, -0.07560727f, -0.04830974f, 0.03244434f, -0.00708447f, 0.04399456f, 
    -0.01708966f, 0.02287845f, -0.01597204f, -0.01316389f, -0.00708180f, 0.13547562f, 0.05882447f, 0.07266025f, 
    0.00520459f, 0.08096087f, 0.02272805f, 0.01707957f, -0.08740926f, -0.24634898f, -0.03238440f, -0.14674085f, 
    0.01624713f, 0.15812841f, -0.03555995f, 0.01015565f, 0.05152283f, 0.05834732f, 0.07065507f, 0.07937876f, 
    0.06818549f, 0.16251408f, 0.15828659f, 0.02227752f, 0.05516241f, -0.00816060f, -0.03302399f, -0.02827469f, 
    -0.06461735f, 0.15453200f, 0.02447053f, 0.00300760f, -0.11776630f, 0.01005702f, 0.27243015f, 0.10779569f, 
    0.14229056f, 0.02247242f, 0.07863457f, -0.13103627f, -0.01680333f, -0.03903938f, 0.09944262f, 0.08019515f, 
    -0.00491209f, 0.10119350f, 0.22165735f, -0.17033789f, 0.01334384f, 0.12231794f, 0.02554628f, 0.02800602f, 
    0.04628148f, 0.15757594f, 0.02029243f, 0.05848750f, -0.16635525f, -0.10571438f, 0.01707822f, 0.17009851f, 
    -0.04652691f, -0.04217179f, 0.19998235f, -0.05586213f, -0.09146369f, -0.02556917f, -0.03230644f, 0.02431211f, 
    -0.44264650f, 0.10920639f, 0.02029691f, -0.18533520f, 0.07234332f, 0.21692097f, 0.10340034f, -0.03856431f, 
    0.11957689f, -0.04087019f, 0.05150835f, 0.06681432f, -0.16524774f, 0.08285247f, -0.19516534f, -0.14589465f, 
    0.18258382f, -0.07906364f, -0.03195572f, -0.06299442f, -0.00505463f, 0.00088233f, 0.02730134f, 0.06424876f, 
    -0.20033433f, -0.04605647f, -0.17014647f, -0.19502524f, 0.16154127f, -0.00374820f, -0.00213466f, -0.11916568f, 
    -0.01405607f, 0.08980838f, -0.08158118f, 0.05488979f, 0.09532638f, -0.11785016f, 0.11512692f, -0.19212300f, 
    0.22985095f, -0.01367042f, -0.08561239f, -0.01978491f, -0.04156693f, 0.08549238f, 0.16975193f, 0.05445942f, 
    0.09930991f, -0.17352481f, 0.15940247f, 0.19998108f, 0.16871934f, -0.12211166f, -0.02958938f, 0.13164537f, 
    -0.05466938f, 0.16914627f, 0.00774670f, 0.03283671f, -0.13105468f, 0.07062598f, 0.05186880f, -0.05141747f, 
    -0.02522141f, 0.00617655f, -0.02415445f, 0.12056568f, 0.08330249f, 0.06829236f, 0.00164731f, 0.07202726f, 
    0.17224564f, 0.10637964f, 0.14728193f, -0.17181684f, 0.03748503f, -0.02159442f, 0.16152842f, -0.07171156f, 
    -0.12594727f, 0.08121595f, 0.10412981f, 0.24605674f, -0.20258160f, 0.13675067f, -0.06994458f, -0.12937981f, 
    0.04648022f, 0.07127663f, 0.03144004f, -0.05941471f, 0.11162723f, -0.03202239f, 0.01781772f, -0.03307878f, 
    0.16338693f, -0.19649839f, 0.14454474f, 0.13927795f, 0.07037131f, 0.08688994f, -0.12269290f, -0.01707027f, 
    -0.03454413f, 0.01856066f, -0.03495147f, 0.01845210f, -0.04031810f, 0.11041671f, -0.18423994f, -0.12189227f, 
    0.16867912f, 0.00425478f, -0.04435191f, -0.15870264f, -0.06688801f, -0.09269179f, -0.00138214f, -0.01591950f, 
    -0.00217994f, 0.19989282f, -0.11733808f, 0.17458971f, 0.01092096f, 0.10325013f, 0.08806623f, -0.01287211f, 
    0.15386838f, 0.06318187f, 0.11503556f, 0.13854346f, 0.05403007f, 0.13816676f, 0.06211780f, -0.10483526f, 
    0.02295958f, 0.04426640f, 0.01073352f, 0.04465894f, 0.02413659f, -0.01518774f, 0.04601840f, -0.02918730f, 
    -0.14414257f, 0.22022004f, 0.12408395f, 0.05123308f, 0.05166677f, 0.03903337f, -0.09173022f, -0.03585437f, 
    0.10617045f, -0.04645356f, 0.11826145f, -0.06732494f, 0.03583007f, -0.08338227f, -0.04501834f, 0.19237521f, 
    -0.15556175f, 0.01295313f, 0.00618667f, -0.01367254f, -0.06335405f, 0.16128176f, 0.04832904f, -0.01516105f, 
    0.04707496f, 0.04819517f, 0.19083928f, 0.29156923f, -0.09031484f, -0.17105435f, 0.00456394f, 0.06803869f, 
    0.03253073f, 0.09530427f, 0.08700247f, 0.04460634f, -0.22007267f, -0.04316146f, 0.16629285f, -0.07532002f, 
    0.06885710f, 0.10170038f, 0.01067362f, -0.16176911f, 0.05763862f, -0.00125718f, 0.02682502f, 0.07328517f, 
    -0.26468238f, 0.23715204f, 0.09680541f, 0.11314305f, 0.10764789f, -0.07181495f, 0.03884154f, 0.04605591f, 
    0.11885359f, -0.05734259f, 0.16308118f, 0.00968126f, -0.20860894f, 0.02201900f, -0.13737835f, -0.09105542f, 
    0.09766405f, 0.07752486f, -0.10950792f, -0.07111735f, 0.20536149f, -0.02854966f, -0.02332521f, 0.06541804f, 
    -0.18965805f, 0.17760624f, -0.06821403f, 0.27487099f, 0.09506133f, -0.02993441f, 0.00958240f, -0.03947844f, 
    0.04356382f, -0.01792485f, 0.01033747f, -0.10976121f, -0.17809732f, 0.08378950f, -0.18495683f, 0.02037735f, 
    0.05241385f, -0.03421399f, 0.17089717f, -0.03159243f, -0.11535444f, 0.09332269f, 0.08437233f, -0.04038018f, 
    -0.04909872f, 0.11961377f, 0.00192053f, -0.16013375f, -0.00884703f, 0.00676987f, 0.09777942f, 0.11300731f, 
    0.12683108f, -0.03438416f, 0.05928591f, 0.01903737f, 0.23969346f, 0.09174721f, 0.14770363f, 0.21944050f, 
    -0.07080176f, 0.04281915f, 0.04814203f, 0.06327618f, 0.03867257f, 0.03318116f, -0.06830452f, 0.09917585f, 
    -0.42657053f, -0.14467610f, 0.07860585f, -0.21268640f, 0.04720810f, 0.08023097f, -0.07556400f, -0.00847662f, 
    -0.05838319f, -0.05510377f, 0.07183736f, 0.19251481f, 0.07463756f, -0.06564261f, 0.01867931f, 0.00711768f, 
    0.11320189f, 0.00974334f, 0.00258661f, 0.10101711f, 0.02526279f, 0.00646085f, -0.03228940f, 0.03239648f, 
    -0.24136452f, -0.11500393f, 0.06953029f, -0.21673232f, 0.05201698f, 0.07362636f, 0.03006183f, -0.07682417f, 
    0.06118650f, 0.05688711f, 0.01716392f, 0.02494861f, -0.22412668f, -0.11710002f, -0.00600037f, 0.14664257f, 
    0.00712828f, 0.01815579f, -0.02896275f, 0.08456157f, 0.14456034f, 0.01305574f, 0.02467452f, 0.13188943f, 
    0.10692642f, -0.05924569f, -0.07638771f, 0.01217010f, -0.02956096f, -0.05250045f, -0.07589909f, 0.18937241f, 
    0.10966399f, -0.05262475f, -0.04806397f, -0.01012027f, -0.01445988f, 0.24322584f, -0.24596033f, -0.27095023f, 
    0.19177885f, -0.00046953f, -0.09908962f, 0.12799887f, -0.00534101f, -0.08389013f, 0.16221847f, -0.11683070f, 
    -0.27769092f, -0.31052542f, 0.10415518f, 0.06792937f, 0.09753840f, 0.17398030f, -0.04479972f, 0.00049583f, 
    0.03515899f, -0.00381908f, 0.07562393f, 0.15948506f, 0.29152089f, -0.09384140f, 0.01368724f, 0.00495722f, 
    0.13307816f, -0.01341881f, 0.07777698f, 0.06455079f, -0.03780388f, -0.00233418f, 0.08827305f, 0.09084119f, 
    0.12682858f, -0.22095826f, 0.19792095f, 0.19697896f, 0.08095060f, 0.03388828f, -0.01921682f, -0.17063919f, 
    -0.05931773f, -0.01165665f, 0.09210382f, 0.10992995f, 0.53964621f, -0.07181749f, 0.08490904f, -0.19545846f, 
    -0.04202718f, -0.11232541f, -0.03678513f, -0.05780990f, -0.16825201f, 0.00368539f, 0.09880912f, 0.06879337f, 
    -0.22517683f, 0.12378486f, -0.23124775f, -0.17835182f, 0.12488231f, -0.14713955f, -0.04385364f, -0.06792144f, 
    -0.01047974f, -0.13379927f, 0.04771379f, 0.09621372f, 0.32151404f, -0.03342726f, 0.07015878f, -0.09071207f, 
    -0.02081488f, 0.08521520f, 0.06917267f, 0.01311307f, -0.12191052f, 0.16439480f, -0.00880968f, 0.07128592f, 
    -0.37737063f, 0.34910065f, 0.17668320f, 0.05096604f, 0.04792651f, 0.04179871f, -0.07474794f, 0.11811559f, 
    0.02271507f, 0.02977525f, 0.03360344f, 0.12722513f, 0.26085615f, 0.07156674f, -0.07554007f, 0.12346827f, 
    0.05266225f, -0.08229271f, 0.14084113f, -0.00090397f, -0.07644464f, 0.11631040f, -0.00846204f, -0.00912898f, 
    -0.35860598f, -0.16925581f, 0.05010464f, -0.15535469f, 0.10064429f, -0.03562236f, 0.04204938f, -0.06829623f, 
    0.02164108f, 0.03165192f, -0.00079985f, -0.01570236f, 0.13577050f, -0.05975341f, 0.08542705f, 0.12454882f, 
    0.16828759f, -0.01423343f, -0.00628861f, 0.00479958f, 0.01485139f, 0.06919410f, 0.03544649f, 0.04129639f, 
    0.03762186f, -0.04267672f, 0.00298074f, 0.04223413f, 0.08897774f, 0.06847104f, 0.03897207f, 0.05132153f, 
    -0.01990161f, -0.02488523f, -0.10100704f, 0.05404679f, -0.21930426f, 0.05438023f, -0.02185728f, 0.12315667f, 
    0.07506169f, -0.16965637f, 0.05474626f, -0.02591814f, -0.01445467f, -0.00187306f, 0.09695783f, 0.13443941f, 
    -0.41011432f, -0.02670049f, 0.01369152f, -0.27158821f, 0.11669867f, 0.04179213f, -0.05173722f, -0.02109403f, 
    0.03026467f, 0.05237982f, 0.07452251f, -0.07324161f, 0.08323275f, 0.02965174f, 0.29561716f, -0.08734742f, 
    -0.00984583f, -0.04583882f, 0.01416147f, 0.07934892f, 0.01962228f, -0.02637793f, -0.01477040f, 0.02085918f, 
    -0.38813314f, -0.13664348f, 0.20572257f, 0.03116393f, 0.08224684f, 0.13679884f, 0.00187885f, -0.02486867f, 
    0.11040403f, 0.03696425f, -0.00569921f, 0.06097252f, -0.27379024f, 0.07365353f, -0.10014282f, -0.33770910f, 
    0.14505935f, 0.03190666f, -0.02511255f, 0.02642488f, 0.10685907f, -0.07577362f, -0.01830836f, -0.05479784f, 
    -0.17406359f, 0.38834676f, -0.12385739f, 0.13119531f, 0.06486949f, -0.02570579f, 0.04216162f, -0.11682478f, 
    -0.00870852f, 0.07003073f, 0.10508796f, 0.02712317f, 0.55076563f, 0.12632170f, -0.14569062f, 0.07973398f, 
    0.12047026f, 0.00543453f, 0.00945831f, 0.04178264f, -0.07197060f, 0.11492383f, -0.05460626f, 0.11349861f, 
    -0.02814185f, -0.01201058f, 0.00465706f, -0.01036649f, -0.03756645f, -0.02897291f, -0.01706294f, -0.02485601f, 
    -0.01879236f, -0.01686427f, -0.04036479f, 0.00924130f, 0.02093015f, -0.00332011f, 0.01281974f, -0.03173518f, 
    -0.01120279f, 0.02013350f, -0.02979078f, 0.02499693f, -0.02100912f, -0.01474673f, -0.03041548f, 0.02064450f, 
    -0.01452107f, 0.01644173f, -0.02059573f, -0.01501576f, -0.00930059f, -0.01001873f, 0.00129325f, 0.02222403f, 
    -0.03935810f, -0.02102868f, -0.00836414f, -0.01813838f, 0.00786981f, -0.00927782f, 0.00995673f, -0.03982304f, 
    0.01157503f, -0.02111098f, -0.01655655f, -0.02081391f, -0.01003902f, -0.00646694f, 0.00346499f, 0.02479398f, 
    0.00987991f, -0.03452409f, -0.01902384f, -0.03150214f, -0.03526161f, -0.03587497f, -0.03341033f, -0.03359973f, 
    0.00220716f, 0.01483618f, -0.00370041f, -0.03046958f, -0.03294719f, -0.04176335f, 0.02134249f, -0.03869774f, 
    -0.01150529f, 0.02545115f, -0.03061791f, 0.00224166f, 0.00549455f, -0.03017343f, 0.01116729f, 0.00151729f, 
    0.02678264f, -0.03577668f, -0.04206049f, -0.03914687f, -0.02935847f, 0.02277811f, 0.02388038f, 0.00665135f, 
    -0.02540787f, -0.03620582f, 0.00602234f, 0.01936827f, 0.01667505f, 0.01249144f, -0.00404818f, 0.00963797f, 
    0.02891809f, 0.01083628f, -0.01340634f, -0.01388472f, 0.02669590f, -0.01660407f, -0.00324633f, -0.00037090f, 
    -0.02218545f, 0.01120023f, -0.01512456f, 0.00079807f, 0.02327814f, 0.01831671f, -0.03268711f, 0.03087341f, 
    -0.00094033f, -0.00763025f, 0.01663479f, -0.03797106f, 0.02058661f, -0.03699268f, 0.02284695f, 0.01046741f, 
    0.00022397f, -0.03314918f, 0.01070416f, -0.02240964f, -0.03387087f, 0.02405306f, -0.03629274f, 0.01790793f, 
    0.01627053f, -0.02989927f, 0.00595714f, -0.02163128f, 0.01211497f, -0.02310396f, -0.02227764f, -0.01534647f, 
    -0.04191204f, -0.01272156f, -0.03807246f, -0.03446474f, -0.00182259f, 0.00046785f, 0.01399504f, -0.02583609f, 
    -0.03180575f, 0.02959150f, 0.02309632f, -0.00209732f, -0.00510777f, -0.00204731f, -0.03358745f, 0.02718113f, 
    0.03424278f, -0.01768496f, -0.00450682f, -0.03606445f, -0.02314420f, -0.01893464f, -0.00360358f, 0.00954332f, 
    -0.02510789f, -0.00095032f, 0.02913360f, -0.02853335f, -0.00358407f, -0.02578602f, -0.00709270f, -0.00774772f, 
    -0.01529462f, 0.01354818f, -0.01743686f, -0.02647895f, 0.02447360f, -0.01864195f, 0.02359619f, -0.00428610f, 
    0.02909281f, -0.00875581f, -0.01354243f, 0.00359022f, -0.01655648f, -0.03778124f, -0.02729323f, -0.01454011f, 
    -0.01770089f, -0.02315819f, 0.01138509f, 0.02776274f, -0.00263765f, 0.00236855f, -0.03761216f, -0.02898610f, 
    -0.00836193f, -0.03657300f, -0.01569439f, 0.00380896f, -0.03509965f, -0.02922046f, -0.02749251f, 0.03461809f, 
    -0.02937055f, -0.02287326f, 0.02398861f, -0.02482903f, 0.01655671f, 0.02197621f, 0.02067591f, 0.00515996f, 
    0.00839882f, 0.01777948f, -0.02124340f, -0.00499642f, 0.01770351f, -0.00737431f, 0.02328822f, -0.00402131f, 
    0.00641861f, 0.02565483f, 0.01491833f, 0.01683673f, -0.02168048f, -0.01739265f, 0.02905410f, 0.00869902f, 
    0.01665550f, 0.00815916f, -0.01408848f, -0.03221729f, -0.00274679f, -0.00893438f, -0.02750420f, -0.03456261f, 
    0.02424565f, 0.01897667f, -0.01546692f, -0.01380270f, -0.00023341f, -0.01778622f, 0.01512149f, -0.00961498f, 
    0.00836481f, -0.03924318f, 0.01527820f, 0.00688276f, -0.00099276f, 0.02511364f, 0.02475185f, 0.02303851f, 
    -0.01015072f, -0.02614002f, 0.01729587f, -0.00729916f, -0.02738383f, 0.02714584f, -0.02412246f, -0.03968624f, 
    0.02035409f, -0.03409697f, -0.01028849f, -0.02132152f, -0.02939879f, -0.00879714f, 0.02283826f, -0.01214049f, 
    -0.03982411f, -0.01651778f, 0.02312044f, -0.03147526f, 0.02051316f, -0.02641179f, -0.03241122f, -0.03336827f, 
    -0.02869576f, 0.00494493f, 0.02078144f, -0.03277737f, -0.00456532f, 0.01243837f, 0.01120443f, -0.02224652f, 
    -0.00975267f, -0.00371992f, -0.01320270f, -0.03480327f, -0.02428992f, -0.01392766f, 0.02699738f, -0.01126859f, 
    -0.03553068f, -0.03064309f, -0.00893234f, -0.01749425f, -0.02951265f, -0.01868980f, -0.01206648f, -0.00897808f, 
    0.02342735f, 0.00364703f, 0.00380840f, -0.01947506f, -0.01470678f, -0.03761683f, -0.01502719f, 0.01608400f, 
    0.02910029f, 0.01574267f, -0.04086991f, 0.00520085f, -0.03749720f, 0.01108536f, -0.01233637f, 0.00702141f, 
    -0.02310413f, 0.02133401f, 0.00032350f, -0.03106128f, 0.02689781f, 0.01392693f, -0.01782309f, 0.00248795f, 
    -0.02236156f, 0.02675143f, 0.02243509f, -0.02889314f, 0.01502849f, 0.02614073f, -0.04021421f, 0.02197667f, 
    -0.02508340f, -0.00600708f, -0.01310312f, -0.02755314f, 0.00183853f, -0.04082348f, -0.01742647f, -0.01601315f, 
    -0.01125653f, 0.00244940f, 0.03248189f, -0.00802110f, 0.01887952f, -0.00293987f, -0.03098164f, 0.01930877f, 
    -0.00525003f, -0.01459947f, -0.03535495f, -0.03217335f, 0.00262855f, -0.02797852f, -0.03554500f, 0.02383235f, 
    -0.00078068f, 0.01631205f, -0.02970303f, 0.00486286f, -0.01755358f, -0.01298052f, -0.01769062f, 0.01013627f, 
    0.01511721f, -0.00596072f, -0.00599916f, 0.02868547f, 0.01101682f, 0.01847628f, -0.03568232f, -0.00224676f, 
    0.02377631f, 0.00332667f, -0.01774830f, -0.01848405f, -0.02915808f, -0.04061969f, 0.01238371f, 0.00439725f, 
    0.00113034f, -0.01871933f, 0.02908172f, -0.00232875f, 0.00350451f, -0.03295999f, -0.01445882f, 0.02259855f, 
    -0.02127300f, 0.02312328f, -0.01711698f, 0.00376586f, 0.02620097f, 0.02916219f, -0.00664343f, 0.02655087f, 
    0.01793955f, -0.00219050f, 0.00060886f, 0.01879363f, -0.03614372f, 0.00849806f, -0.02342441f, 0.02768587f, 
    -0.03949459f, 0.02929816f, 0.02175869f, -0.02132517f, -0.02718222f, 0.00492439f, 0.00345839f, -0.02224947f, 
    -0.03979666f, -0.04040646f, 0.02462346f, -0.00668389f, -0.03233739f, 0.00177938f, 0.02042736f, 0.02754827f, 
    0.00852607f, -0.03083195f, 0.00303518f, -0.01681877f, -0.02137437f, -0.02951328f, 0.00280686f, 0.01916601f, 
    0.02080229f, 0.00461583f, 0.00687558f, -0.03988795f, -0.00928911f, 0.01491833f, 0.00869457f, 0.01481919f, 
    0.01883947f, 0.01176773f, -0.03068542f, 0.00814817f, -0.00653526f, -0.00005937f, -0.00608061f, -0.01810554f, 
    0.01270453f, -0.00534042f, -0.01619381f, 0.01913733f, -0.03650944f, -0.00412284f, 0.02274090f, -0.03289765f, 
    -0.03754718f, -0.03341558f, 0.02177367f, -0.01302339f, 0.02546655f, 0.00213586f, 0.01557207f, -0.03331566f, 
    -0.03175661f, 0.02663649f, -0.01463124f, 0.00477306f, 0.02807332f, -0.00110040f, 0.01085052f, -0.00674286f, 
    -0.02558865f, -0.03288066f, 0.02551155f, -0.02850110f, 0.01152198f, -0.01571396f, -0.04143307f, -0.02505841f, 
    -0.02694653f, -0.00139362f, 0.01514168f, 0.01017510f, 0.00384057f, 0.02594062f, 0.01137837f, -0.00028443f, 
    0.00827887f, -0.03288590f, -0.01302494f, -0.01462678f, 0.02789279f, -0.01841954f, 0.00615875f, -0.00106414f, 
    -0.03711138f, -0.03072472f, -0.02223694f, -0.00184189f, -0.02212662f, -0.01307444f, -0.00536785f, -0.00000819f, 
    0.01674904f, -0.01422293f, 0.01033582f, -0.00865332f, 0.01244719f, 0.00336595f, -0.02091055f, 0.01310140f, 
    0.01859473f, 0.00454685f, 0.00911465f, -0.02941351f, 0.02315690f, -0.03986904f, -0.00811316f, -0.03081542f, 
    0.01420737f, 0.02328591f, -0.03115883f, -0.04175179f, -0.01970966f, -0.01027838f, 0.00605815f, -0.04058917f, 
    -0.02560650f, -0.01029663f, 0.00584364f, -0.04171938f, 0.02285874f, 0.01725540f, 0.01051746f, -0.02827139f, 
    -0.02405847f, 0.02047431f, -0.02092625f, -0.02581464f, 0.02804757f, -0.02509337f, 0.00931081f, 0.00271024f, 
    -0.01307746f, -0.02766074f, 0.00619386f, -0.04200007f, -0.01071308f, 0.01270944f, -0.03245004f, 0.01495336f, 
    -0.01611081f, -0.00270417f, -0.02201444f, -0.00576797f, 0.02905509f, -0.00267180f, -0.04189775f, -0.03373972f, 
    0.02507094f, -0.02386638f, -0.03748031f, -0.02442351f, -0.00329593f, -0.02023675f, 0.01315669f, 0.00090675f, 
    -0.01723382f, -0.03402348f, -0.02736242f, -0.00220782f, 0.01417266f, 0.02087289f, 0.00763017f, -0.00636232f, 
    -0.00741352f, -0.03660275f, 0.02628324f, 0.02490027f, 0.00942646f, 0.01410127f, 0.01699206f, -0.02113342f, 
    -0.01882112f, -0.01112191f, -0.03938322f, -0.02586859f, -0.02510896f, 0.02659988f, -0.02561761f, -0.02529294f, 
    0.01637126f, -0.03319701f, -0.02122506f, 0.01576756f, 0.00885937f, 0.00465331f, 0.01211983f, 0.01296883f, 
    -0.00155920f, 0.00335396f, 0.01463475f, -0.02136011f, -0.02308190f, -0.00125486f, 0.01710964f, -0.03723941f, 
    -0.03039890f, -0.02698115f, 0.01235104f, -0.00339058f, -0.02224284f, -0.03538606f, 0.02855288f, 0.03001856f, 
    0.02917874f, 0.02280752f, -0.03079386f, 0.02571519f, -0.03237540f, -0.03009989f, 0.02603073f, -0.02339080f, 
    -0.00237354f, 0.00621987f, -0.02088226f, 0.01572659f, -0.01471967f, -0.04095381f, 0.01406285f, -0.01101405f, 
    0.02216146f, -0.01652513f, -0.01782835f, -0.03501626f, -0.01891554f, -0.01228197f, 0.01244446f, -0.03407561f, 
    -0.01123690f, -0.03783189f, -0.03136043f, -0.03328589f, -0.01222091f, 0.00700597f, 0.02904046f, 0.02204973f, 
    -0.03872987f, -0.00746981f, 0.01106802f, -0.03880515f, 0.00224181f, -0.03229044f, 0.00887462f, 0.01615765f, 
    0.00619703f, 0.00882696f, -0.01825414f, -0.01632273f, -0.01964368f, 0.02802612f, 0.00253611f, -0.02405875f, 
    0.02504478f, -0.01730135f, -0.02988643f, 0.01490040f, 0.00208016f, 0.02684953f, -0.03010020f, -0.02720007f, 
    0.01347779f, -0.00784594f, 0.02372350f, 0.00595295f, 0.00750095f, 0.00190271f, 0.02366337f, 0.00207602f, 
    -0.01394104f, -0.03100767f, -0.00773342f, -0.03473664f, -0.01618986f, 0.00815426f, -0.02742340f, -0.01547097f, 
    -0.02414209f, -0.01001798f, -0.00946998f, 0.02865192f, -0.00376102f, 0.02046661f, -0.02361959f, 0.00169575f, 
    0.03357485f, 0.00904355f, -0.02113571f, -0.00286380f, -0.01677801f, -0.02442156f, 0.00766914f, -0.00255497f, 
    -0.02458453f, -0.02765431f, -0.00310827f, 0.00024683f, 0.00249345f, -0.01566060f, -0.03806237f, -0.03990904f, 
    -0.02316404f, 0.01815030f, 0.03450059f, -0.02976519f, -0.03203405f, -0.01013800f, -0.02035937f, -0.01751013f, 
    -0.03611375f, 0.02798814f, -0.01838670f, -0.00367589f, -0.00355881f, -0.00704035f, -0.02392871f, 0.01743125f, 
    -0.03160577f, -0.03458861f, -0.00956024f, 0.01513702f, 0.00610668f, 0.00925497f, -0.00465881f, 0.01158430f, 
    -0.02334570f, 0.00539872f, -0.02785734f, -0.00346908f, -0.02198899f, -0.02711487f, 0.00752703f, 0.00271643f, 
    -0.03001687f, 0.00651280f, -0.01540379f, -0.03570110f, -0.02836153f, 0.02466954f, 0.00474966f, -0.01151599f, 
    0.00379323f, -0.03190754f, -0.02594325f, -0.01290947f, 0.00160701f, -0.00632982f, -0.03037906f, -0.04169134f, 
    0.02814664f, 0.02383561f, -0.02190568f, 0.01657012f, -0.01072692f, -0.02337210f, -0.03503295f, -0.00994794f, 
    -0.02519855f, 0.02468104f, 0.02016703f, -0.01150791f, -0.01194147f, 0.00634045f, -0.03763341f, 0.02563035f, 
    -0.04004975f, 0.01335816f, -0.03765913f, -0.02488361f, -0.02910171f, -0.02333669f, 0.01509150f, -0.03897712f, 
    -0.00314922f, -0.03289326f, 0.02797040f, 0.02271800f, 0.02267092f, -0.03355729f, -0.01786831f, 0.03708408f, 
    0.01139418f, 0.01831118f, 0.01314013f, 0.00493694f, -0.00735730f, 0.00248740f, 0.02266609f, 0.01053872f, 
    -0.00022391f, 0.00506345f, -0.02915511f, -0.03410098f, -0.02608992f, -0.02042558f, 0.02415349f, -0.00547844f, 
    0.02560910f, 0.02046617f, 0.03643206f, -0.03580526f, -0.01776432f, -0.00502260f, 0.01305109f, -0.02316266f, 
    0.02166136f, -0.03896780f, 0.01963065f, -0.03900678f, -0.00906254f, -0.02684418f, -0.03642910f, -0.02964724f, 
    0.01474692f, 0.02263018f, -0.00697622f, 0.01599640f, 0.01429920f, 0.00077660f, -0.03246782f, 0.02920198f, 
    -0.00651050f, -0.01939016f, -0.03936587f, -0.01706593f, 0.01004921f, -0.01390665f, -0.01918355f, 0.00466015f, 
    -0.02930426f, -0.02624384f, -0.03499139f, -0.00333957f, -0.02260555f, 0.01592149f, 0.01637986f, -0.01023640f, 
    -0.02604064f, -0.00668784f, -0.01500618f, 0.01525174f, 0.01957892f, -0.04098785f, 0.01742041f, -0.01812555f, 
    0.00348474f, -0.02520145f, -0.02159127f, -0.02509571f, 0.01662166f, 0.01844216f, -0.02412766f, 0.01374612f, 
    -0.01293030f, -0.03162933f, 0.00994010f, 0.00395935f, -0.01985748f, -0.00257531f, 0.01866970f, 0.02443313f, 
    -0.03023484f, -0.01913207f, -0.01282848f, 0.01132684f, -0.03446215f, 0.01333906f, 0.00053659f, 0.01467704f, 
    -0.01970569f, 0.00019183f, -0.00755604f, 0.02287497f, 0.01281423f, -0.04066469f, 0.00097011f, 0.02139425f, 
    -0.00746418f, 0.00261724f, -0.04064164f, -0.04201686f, -0.02803507f, 0.00798903f, -0.03577475f, -0.01440191f, 
    0.00966903f, 0.02667970f, -0.03930891f, -0.03310976f, -0.02525152f, 0.01851672f, 0.00184318f, -0.02703113f, 
    0.00726063f, -0.02283153f, -0.00776523f, -0.00788851f, -0.01689267f, -0.00666517f, -0.01436638f, -0.01563743f, 
    -0.00633571f, -0.02013876f, -0.02239072f, -0.03536384f, 0.04077245f, -0.01566467f, 0.01879210f, -0.01939477f, 
    0.01399773f, -0.01561129f, -0.00031415f, 0.02179844f, -0.03417581f, -0.00779560f, -0.01409630f, -0.00854594f, 
    -0.00832655f, -0.03936537f, -0.02863249f, 0.00776810f, 0.02386419f, -0.01099351f, -0.01182398f, 0.02698933f, 
    -0.03145300f, -0.01958285f, 0.02233914f, -0.01636695f, -0.02388600f, 0.01955507f, 0.02649488f, -0.00403059f, 
    0.00872542f, -0.02416886f, -0.01113645f, -0.03050933f, -0.02679284f, 0.02661795f, 0.01780386f, -0.03986275f, 
    -0.01471176f, -0.00678178f, -0.03877001f, -0.00918912f, -0.01910431f, 0.02121266f, -0.01876528f, 0.02332532f, 
    -0.01314060f, 0.01074074f, -0.01417628f, -0.03168631f, -0.00612537f, -0.00501350f, 0.02886810f, 0.00792682f, 
    0.00643369f, -0.00701264f, -0.02585730f, -0.02397451f, 0.00482178f, -0.01984586f, -0.03948566f, 0.01832045f, 
    0.01032872f, -0.03419686f, 0.01706992f, 0.01270700f, -0.00775441f, 0.01052105f, -0.03444618f, 0.00723444f, 
    -0.00120635f, -0.00330277f, 0.01748615f, -0.00192204f, 0.02448202f, -0.01521768f, 0.00572166f, 0.00694617f, 
    0.02225712f, -0.02308980f, -0.01145760f, 0.02183411f, -0.02213059f, -0.04176477f, 0.02953645f, -0.02580004f, 
    0.00571470f, -0.00634156f, -0.00111786f, -0.00666947f, 0.01006008f, -0.04188339f, 0.01007261f, 0.02534201f, 
    -0.01077815f, -0.03563519f, 0.01845225f, 0.00246728f, 0.02128669f, -0.01397629f, -0.02371793f, -0.00020632f, 
    0.01827659f, 0.01482235f, -0.01945532f, -0.02289627f, -0.01406841f, -0.01844189f, -0.01641644f, -0.02694790f, 
    0.00833866f, -0.01160300f, 0.00903719f, -0.01532087f, -0.02454695f, 0.01802567f, -0.03904896f, -0.01165975f, 
    -0.03652991f, -0.01057749f, 0.00575843f, 0.02288363f, 0.00256439f, 0.01124989f, -0.02164295f, -0.03702334f, 
    -0.02411669f, 0.01975868f, 0.02677850f, 0.01007293f, -0.00193619f, 0.01722763f, -0.02607571f, -0.02507687f, 
    0.00344139f, -0.01215955f, 0.02092514f, 0.02921601f, -0.03206342f, -0.02236663f, -0.03092078f, -0.02394114f, 
    0.02385121f, -0.03358813f, -0.00338010f, -0.01263081f, -0.03432515f, 0.00561885f, -0.03298131f, 0.00249508f, 
    -0.03381517f, 0.02130701f, 0.03736976f, -0.01267976f, -0.01225204f, -0.02459203f, -0.02296398f, -0.01765864f, 
    -0.00731598f, -0.00402329f, -0.00272591f, 0.00030893f, 0.00160965f, 0.02827720f, -0.02923964f, -0.01188102f, 
    -0.02144091f, 0.01462493f, -0.03678551f, 0.02852016f, 0.01292318f, -0.00630515f, 0.02546118f, 0.01623023f, 
    -0.02471389f, 0.02714736f, -0.02169050f, -0.01842797f, -0.00526522f, -0.00343024f, 0.02537282f, -0.04305533f, 
    -0.02368917f, -0.00279610f, 0.02491331f, -0.02625035f, -0.02295051f, 0.02707067f, 0.00409407f, 0.01117949f, 
    0.03464137f, -0.00662511f, -0.01989267f, -0.01790642f, 0.03581582f, 0.01192578f, 0.02348797f, 0.03753852f, 
    -0.01823570f, 0.02287959f, -0.02078974f, -0.02894033f, 0.00069035f, 0.02704936f, -0.01622287f, -0.02768602f, 
    0.00463365f, -0.02487801f, -0.00859146f, 0.02631220f, 0.02422398f, 0.01140651f, -0.00016257f, -0.02043495f, 
    0.00010711f, 0.01713308f, -0.01906113f, 0.01318172f, 0.02993632f, -0.03221036f, -0.03538783f, 0.01084565f, 
    -0.01707910f, -0.02941686f, 0.02517330f, -0.02826576f, 0.02520745f, -0.00104382f, -0.02412887f, -0.00198215f, 
    0.01856328f, -0.02962962f, 0.01908221f, -0.04160084f, -0.04033613f, -0.01671264f, 0.02673556f, 0.00478533f, 
    -0.02068744f, -0.00635213f, -0.01719897f, 0.02226351f, -0.00335330f, 0.00511466f, 0.00114947f, 0.00978477f, 
    -0.02376368f, 0.02107995f, -0.01205037f, -0.02785191f, 0.02738191f, -0.02568775f, 0.00200230f, -0.01378825f, 
    -0.01208692f, 0.01795542f, -0.00399869f, 0.03075806f, 0.00354236f, -0.04330659f, 0.01733331f, -0.01568481f, 
    -0.03849904f, -0.01083192f, 0.01780004f, 0.01048244f, -0.00761486f, -0.00072251f, -0.03595123f, -0.02946042f, 
    0.01035276f, -0.01568336f, 0.00961995f, 0.01271613f, 0.01024057f, -0.00494771f, 0.02790732f, -0.00032615f, 
    0.02311485f, 0.02781074f, 0.02333690f, -0.03830421f, -0.00726743f, -0.02942742f, 0.03892672f, -0.01792260f, 
    0.01594099f, -0.03830153f, -0.02473672f, 0.03102093f, -0.00399204f, 0.02548483f, 0.02174754f, 0.03813842f, 
    -0.02580443f, -0.01743531f, -0.03579860f, 0.02599709f, 0.02287651f, -0.00578559f, -0.01638577f, -0.01152867f, 
    -0.01268225f, 0.01872710f, -0.01871512f, 0.02535779f, 0.02210834f, -0.00077982f, 0.01621379f, -0.01445104f, 
    0.00929356f, 0.00453379f, -0.02020709f, 0.02017100f, 0.02784429f, -0.03172339f, -0.01022156f, 0.02380761f, 
    -0.00762354f, 0.00891399f, -0.00637326f, 0.02239915f, 0.01215457f, -0.03241759f, -0.02169069f, -0.03490951f, 
    -0.01575098f, -0.00720920f, -0.03353740f, -0.00535861f, -0.01165786f, 0.00322998f, -0.02943040f, -0.01827280f, 
    0.01740125f, -0.02169985f, -0.00107914f, -0.01241366f, -0.04158837f, -0.00536194f, 0.00501936f, -0.01605767f, 
    -0.01693049f, -0.03296689f, 0.01486913f, -0.02190971f, -0.01786455f, 0.03195703f, -0.02005444f, -0.00993245f, 
    -0.00506428f, -0.03609674f, 0.01074357f, -0.01042899f, 0.01515271f, -0.00695931f, -0.00477093f, -0.04247294f, 
    0.02067327f, -0.00230390f, -0.01583990f, -0.02740208f, -0.03693748f, -0.02068488f, 0.02725547f, 0.01454204f, 
    -0.04175676f, 0.01586085f, -0.03322662f, 0.02375668f, 0.00768553f, -0.02333212f, 0.01120281f, -0.00039845f, 
    0.02980842f, 0.01723038f, -0.04100102f, 0.00948140f, 0.03429752f, -0.00278298f, -0.01214606f, 0.01283576f, 
    -0.01534082f, 0.01484086f, -0.04075858f, 0.01597131f, -0.01461797f, -0.03460599f, -0.01218258f, -0.00008395f, 
    -0.00217016f, -0.00529296f, -0.03052189f, -0.04100658f, 0.02708158f, 0.01660983f, -0.01886987f, -0.00168657f, 
    -0.02946148f, 0.01841821f, -0.02870365f, 0.00202359f, 0.00916134f, -0.02836580f, -0.03068310f, -0.01668434f, 
    -0.00810376f, -0.03424209f, -0.04049932f, -0.02113559f, 0.01975076f, 0.04072747f, -0.03142784f, 0.02687554f, 
    -0.03161840f, 0.00284296f, -0.01652052f, 0.00044976f, -0.01509602f, -0.03922613f, 0.02707884f, -0.03234901f, 
    0.02862463f, -0.03255253f, -0.03229257f, 0.00978511f, -0.02899885f, 0.00296376f, 0.01665222f, -0.01595728f, 
    0.01449722f, 0.01939565f, -0.01154015f, -0.02871720f, -0.01198099f, -0.02703226f, -0.00214610f, 0.00022705f, 
    -0.00679550f, 0.02396663f, -0.01577035f, 0.02142398f, -0.02392677f, 0.02327403f, -0.04132589f, -0.03129310f, 
    0.02449154f, 0.02342705f, 0.02719784f, 0.02632807f, 0.03213518f, -0.02960972f, 0.00768152f, -0.02533490f, 
    0.01799196f, -0.04335425f, -0.00157012f, 0.02057536f, -0.01404676f, -0.00644160f, -0.01290250f, 0.00630681f, 
    -0.02873696f, -0.01514750f, 0.02718818f, -0.01147303f, 0.00768670f, -0.00082638f, -0.01233364f, -0.03350919f, 
    -0.01467955f, 0.02632971f, -0.01892944f, 0.04138231f, 0.00445337f, 0.02296816f, 0.00400942f, 0.02584158f, 
    0.02636572f, -0.04085861f, 0.02467547f, -0.01772230f, -0.01470915f, -0.02278674f, 0.02780744f, -0.00220962f, 
    0.03470594f, -0.03993678f, -0.03766382f, 0.02463827f, -0.00535682f, 0.00709293f, -0.00318262f, -0.00006744f, 
    0.03934218f, -0.01600112f, 0.02175804f, -0.00148887f, -0.03537563f, -0.03421411f, 0.00084928f, 0.03720865f, 
    0.00800168f, 0.02902630f, 0.00165916f, -0.01560674f, 0.02819555f, -0.00247650f, -0.03961526f, 0.01495495f, 
    0.02342334f, -0.03849699f, -0.01036679f, 0.03743399f, -0.02071625f, -0.01807630f, -0.03991431f, 0.00049683f, 
    0.02311478f, 0.01105107f, -0.02221947f, -0.04107775f, -0.04156499f, -0.01766744f, -0.03836470f, -0.03209252f, 
    0.02145406f, -0.02926052f, 0.01994670f, -0.00920229f, -0.01795734f, -0.02714546f, 0.00388507f, -0.02606439f, 
    0.00702958f, -0.01000975f, -0.01900302f, 0.02437383f, -0.01506477f, -0.03060208f, 0.01435739f, -0.00495478f, 
    0.00335203f, 0.02741299f, 0.00790254f, 0.00043652f, -0.02640663f, -0.03403324f, -0.02114553f, -0.00387945f, 
    0.02128619f, 0.02978954f, -0.00350399f, 0.02058605f, -0.03528320f, 0.02535833f, 0.00709299f, -0.01473602f, 
    0.02749847f, -0.04307844f, 0.02650950f, 0.00507951f, -0.00806194f, -0.03739211f, 0.00989964f, 0.01869629f, 
    -0.01598971f, -0.03241344f, 0.00987436f, -0.03609117f, 0.01966293f, 0.02502831f, -0.01723291f, 0.01465742f, 
    -0.01988292f, -0.03461604f, -0.01551896f, 0.00442710f, 0.01942423f, 0.02135662f, 0.00904061f, -0.03776820f, 
    0.02944728f, 0.01909425f, 0.03155936f, 0.00215250f, -0.02125973f, 0.01489605f, -0.03828938f, 0.00734080f, 
    -0.00288411f, -0.03541156f, 0.00892513f, -0.04097878f, -0.01936162f, -0.03784163f, -0.01189440f, -0.00517542f, 
    0.01410283f, -0.02378319f, -0.02700298f, 0.01325628f, -0.01559912f, -0.02014248f, -0.02553310f, 0.02379739f, 
    -0.02518513f, 0.00906352f, 0.01617512f, -0.01255591f, 0.00642744f, -0.03018360f, 0.02693156f, -0.02910108f, 
    -0.01682305f, 0.00947523f, 0.00866993f, 0.02554709f, -0.03413957f, 0.02477581f, -0.02778027f, -0.01797753f, 
    0.01442000f, -0.01933382f, -0.02357534f, -0.01053580f, 0.01576414f, 0.00459648f, -0.02265021f, -0.00845558f, 
    0.03031306f, -0.01435978f, -0.03078539f, -0.02915537f, 0.02361599f, -0.01621909f, 0.02393452f, -0.02450985f, 
    -0.22681172f, 0.08255274f, 0.22527131f, 0.04201778f, 0.00349543f, 0.14651288f, 0.07659248f, 0.10687457f, 
    0.15037841f, -0.16762696f, -0.14602342f, 0.06565695f, 0.19063857f, -0.20392373f, 0.02145003f, -0.11981393f, 
    0.17117412f, 0.10456783f, -0.00500067f, 0.17542410f, 0.07415374f, 0.00123550f, -0.08108085f, 0.15282941f, 
    0.32240182f, -0.06902852f, 0.14490500f, 0.05105919f, 0.00574624f, 0.09947269f, 0.12823138f, 0.06182814f, 
    0.04310336f, -0.02289528f, -0.11917482f, 0.21343231f, -0.32035235f, -0.10156272f, 0.04624233f, 0.19295388f, 
    0.00596301f, 0.12939593f, -0.01719826f, 0.01354976f, -0.04542447f, 0.03310019f, -0.01817354f, -0.11516899f, 
    -0.06726402f, 0.20200761f, 0.13825150f, -0.19518076f, 0.00010413f, 0.06728577f, 0.17670128f, -0.02033280f, 
    0.16601504f, -0.19077343f, -0.00025415f, -0.04332566f, -0.00005956f, -0.03406829f, 0.02847482f, 0.04378192f, 
    -0.05886709f, 0.05557761f, 0.06923736f, 0.03766922f, 0.09496024f, 0.13963056f, -0.09158812f, -0.08855087f, 
    0.02453082f, 0.11589111f, 0.11961320f, 0.05295027f, 0.06783772f, 0.01796183f, 0.01158408f, 0.17233606f, 
    0.06782793f, -0.03479987f, 0.09522150f, -0.18410122f, -0.12362575f, 0.05368241f, 0.12832710f, -0.04270961f, 
    0.06873484f, 0.00372202f, -0.10868496f, 0.04833162f, 0.04213252f, 0.06400780f, -0.14298630f, 0.16204157f, 
    0.29084650f, -0.13123643f, -0.00233781f, 0.08141211f, -0.13827796f, 0.16689810f, -0.00110908f, -0.01386525f, 
    -0.05249861f, 0.07453796f, -0.00314953f, -0.01195366f, -0.50589490f, -0.31661990f, 0.18410523f, 0.11869825f, 
    0.03778261f, 0.12297261f, 0.09214563f, 0.03623710f, -0.08757472f, 0.10003214f, 0.22292747f, 0.04129122f, 
    0.33238339f, 0.07182080f, 0.07640899f, 0.26995409f, 0.08036538f, 0.13560960f, -0.05029897f, -0.01966779f, 
    -0.02222541f, -0.05600257f, -0.21000393f, -0.04147148f, -0.14057048f, -0.11386690f, -0.18413815f, 0.15881196f, 
    0.02981170f, -0.15740128f, 0.05190260f, 0.04130839f, -0.02526250f, -0.16490719f, 0.16515887f, 0.11308569f, 
    -0.38159814f, -0.21995737f, 0.02291065f, 0.14333029f, 0.11153241f, 0.02485852f, -0.00069279f, 0.08689007f, 
    0.01791516f, 0.10816365f, -0.03094416f, 0.12269823f, -0.25444436f, 0.00065358f, -0.07623580f, -0.08275942f, 
    -0.13809289f, 0.05953676f, 0.00686244f, 0.21312198f, 0.12639067f, 0.09934372f, -0.04066001f, 0.11409266f, 
    0.19432047f, 0.08678298f, -0.08858196f, -0.11337403f, -0.16910072f, -0.28666484f, 0.10711453f, 0.07703897f, 
    -0.00305022f, -0.01236010f, -0.14883278f, 0.04559921f, -0.21356526f, -0.02850299f, 0.07800228f, 0.00688896f, 
    0.10795283f, -0.04910809f, -0.12949942f, 0.00195035f, -0.01092523f, -0.03016495f, -0.05058279f, -0.07102302f, 
    -0.15367255f, 0.24940895f, 0.11608130f, -0.01385436f, 0.10460225f, 0.09853665f, -0.14713679f, -0.04357677f, 
    -0.05500304f, 0.04604376f, 0.14301203f, 0.10768050f, 0.52764577f, 0.06539705f, 0.13811277f, 0.15009999f, 
    -0.16853279f, 0.21080135f, 0.06966546f, 0.10885893f, -0.01081231f, 0.03813205f, 0.05347772f, 0.05623491f, 
    0.04595629f, 0.20681295f, -0.00714398f, -0.12950914f, 0.10025153f, -0.04312838f, -0.17494220f, 0.06827601f, 
    0.05781556f, -0.11705921f, 0.11526219f, -0.04860468f, 0.10430294f, -0.13047755f, 0.05756262f, -0.20406741f, 
    0.12522556f, -0.03288501f, 0.01142271f, 0.06920452f, -0.05830860f, -0.06569627f, 0.23871282f, -0.06148736f, 
    -0.12849854f, 0.00359812f, 0.04386540f, -0.02396004f, 0.14468192f, 0.00875360f, 0.07687793f, -0.08705445f, 
    -0.08259109f, -0.03862080f, 0.09839427f, 0.17376938f, 0.20941857f, -0.01787641f, 0.03753325f, 0.01189015f, 
    0.02644796f, 0.12163008f, 0.00121872f, -0.04641309f, 0.13102084f, 0.15460950f, -0.01010051f, 0.11150662f, 
    -0.02580903f, -0.11653704f, 0.19785750f, 0.07885041f, 0.01508927f, 0.02892938f, -0.04416682f, 0.03300149f, 
    0.05350751f, 0.11859543f, -0.05887612f, -0.00057981f, -0.07143729f, -0.10928987f, -0.02804786f, 0.07423006f, 
    0.03310021f, 0.04350666f, 0.06453857f, 0.26358229f, 0.15332399f, -0.00696385f, -0.16537204f, -0.13964202f, 
    0.00340188f, 0.10526939f, 0.03973853f, -0.12278918f, 0.09356539f, 0.09687927f, 0.00258354f, -0.01695986f, 
    0.00188400f, 0.01708729f, 0.22489341f, -0.08572226f, -0.31062940f, -0.22392890f, -0.16289032f, -0.03299806f, 
    -0.01362554f, -0.07043701f, 0.01579709f, 0.08569057f, 0.00122902f, -0.06223743f, -0.01794408f, -0.04653740f, 
    -0.10691325f, -0.00219061f, 0.10258701f, -0.04517964f, -0.03717270f, -0.01619545f, 0.18658262f, 0.10411131f, 
    0.02986454f, -0.06332703f, -0.07743993f, 0.03101203f, 0.01656677f, -0.07064950f, 0.02052259f, -0.04089336f, 
    -0.08548814f, 0.14795995f, 0.16025554f, 0.04515548f, 0.02110064f, 0.21511124f, 0.03129357f, 0.06811267f, 
    0.04043330f, 0.05639936f, -0.00508639f, -0.02475676f, 0.10631482f, 0.06073461f, -0.12408427f, -0.00599684f, 
    0.12103754f, 0.06836835f, 0.07592881f, 0.22748807f, 0.24237415f, -0.11806544f, 0.10020299f, -0.04601871f, 
    0.01744623f, 0.02436599f, 0.08176626f, 0.08943094f, 0.06265478f, 0.04076426f, -0.20933077f, 0.14404732f, 
    0.29886582f, -0.12306660f, 0.00235600f, 0.20238867f, -0.01195489f, -0.08842972f, 0.06730191f, 0.09198575f, 
    -0.11157216f, -0.00419693f, -0.06653228f, -0.14204180f, -0.07819983f, -0.07230996f, -0.08342590f, -0.05310695f, 
    0.02038687f, -0.10811074f, -0.01874970f, 0.01171993f, -0.02093654f, -0.05629639f, -0.07141788f, 0.00320136f, 
    0.18605830f, 0.16413695f, -0.09166583f, -0.17181759f, -0.12438384f, -0.17129689f, -0.04516523f, -0.01397933f, 
    0.03077140f, 0.05970252f, 0.13818146f, 0.14319208f, -0.10954174f, 0.17891084f, 0.03344319f, 0.02886601f, 
    -0.02649495f, 0.15650243f, 0.04526545f, 0.18076429f, 0.12976681f, -0.00839536f, 0.21968070f, -0.00882121f, 
    0.44214264f, -0.21750939f, -0.02480708f, 0.07873321f, -0.03585326f, 0.14302607f, 0.06421588f, 0.08974312f, 
    -0.05909796f, 0.08984721f, -0.19377789f, 0.13205153f, -0.32205129f, -0.05907154f, 0.02862305f, -0.02024398f, 
    0.05224850f, -0.06225690f, -0.09213149f, 0.09464242f, -0.12937669f, -0.13117893f, 0.16690157f, -0.04516655f, 
    -0.16494183f, -0.18928656f, 0.01944606f, 0.09377811f, 0.03057388f, -0.00841605f, -0.03760302f, -0.05972168f, 
    -0.11297249f, -0.08238854f, -0.01615663f, 0.02823787f, 0.09304617f, -0.10237040f, 0.01005697f, 0.02687122f, 
    0.16113056f, 0.13913512f, 0.10410345f, 0.10096913f, -0.09995286f, -0.06438506f, -0.06774502f, -0.05358820f, 
    -0.46219945f, -0.10478443f, 0.06545788f, 0.20230643f, 0.13953675f, -0.03850494f, 0.16487536f, 0.00231584f, 
    0.09587593f, -0.08675034f, -0.08518127f, -0.17908148f, -0.09618334f, 0.12932388f, -0.07266612f, -0.07182373f, 
    -0.14485289f, -0.04566628f, -0.15247168f, -0.10480212f, 0.02795695f, 0.26859996f, 0.15588452f, 0.19665098f, 
    0.16989429f, 0.26618710f, -0.09584703f, -0.08588433f, -0.00258049f, 0.00891591f, 0.01497818f, 0.07885242f, 
    -0.09350400f, 0.11354261f, 0.08603159f, 0.02847851f, -0.10331501f, 0.12075658f, 0.06484815f, 0.14989497f, 
    0.11790785f, -0.10023088f, -0.06732380f, 0.09459518f, -0.05285141f, -0.10970563f, 0.23073547f, -0.14122055f, 
    -0.11885042f, 0.00548581f, 0.08227405f, 0.02790003f, -0.03085771f, 0.07434207f, 0.03697025f, -0.07791868f, 
    0.02855493f, 0.15536802f, -0.13169749f, 0.08094320f, -0.01702275f, 0.29997367f, 0.04678749f, 0.13903730f, 
    -0.06398364f, 0.08694732f, 0.17357786f, 0.03842307f, -0.09207920f, 0.02730937f, -0.00010398f, -0.08566511f, 
    -0.24591050f, 0.25470248f, 0.11734828f, -0.06943081f, 0.16799982f, 0.05886050f, 0.08944302f, 0.04888674f, 
    -0.05252439f, 0.06479717f, -0.02566678f, -0.02005168f, 0.58898592f, 0.10768612f, -0.14929597f, -0.05988724f, 
    -0.03261610f, 0.03543713f, 0.08155859f, 0.06513436f, -0.06893373f, 0.22468854f, 0.12938809f, 0.06713114f, 
    -0.02233744f, 0.07376548f, 0.05997784f, 0.07375143f, -0.02389802f, 0.08916574f, -0.03178803f, -0.06170516f, 
    0.11371172f, 0.09240002f, 0.09223637f, -0.13669901f, -0.02297754f, -0.02133729f, 0.04161774f, -0.22611116f, 
    -0.11732011f, 0.03800031f, -0.06530008f, -0.00380243f, 0.06685165f, 0.14033110f, -0.16597664f, -0.07655637f, 
    -0.41089100f, -0.03326665f, -0.00228459f, 0.14236051f, 0.06136568f, -0.07535108f, 0.02133718f, -0.00469485f, 
    0.04598188f, 0.20441304f, 0.03348504f, -0.01542666f, -0.11621591f, -0.13764113f, 0.03956737f, -0.25132453f, 
    0.14492066f, 0.16887344f, -0.07330007f, 0.09651923f, -0.12819876f, -0.18250309f, 0.03119418f, -0.02408060f, 
    -0.31018952f, -0.38491529f, -0.22447172f, 0.03038519f, -0.04869773f, 0.07214978f, 0.13710143f, 0.15420543f, 
    -0.01451177f, 0.11796593f, 0.04652368f, 0.15583315f, -0.24292438f, 0.04201090f, -0.05374485f, -0.21908951f, 
    -0.08113877f, 0.01436440f, -0.02723770f, 0.02646530f, -0.09272478f, -0.11135016f, -0.06439546f, -0.06529159f, 
    -0.24026471f, -0.15484706f, -0.01252366f, 0.01092687f, 0.00838255f, -0.14351848f, 0.17805167f, 0.04570440f, 
    0.07491549f, 0.12370855f, -0.00127769f, 0.10644220f, 0.10051731f, -0.12839946f, -0.23610941f, -0.11136192f, 
    -0.04485390f, 0.01873250f, 0.00682269f, 0.05175907f, 0.06805956f, -0.00428215f, 0.01522532f, 0.16241704f, 
    0.01829442f, 0.08497538f, -0.07691803f, -0.06478842f, -0.04313925f, -0.10789030f, 0.02737672f, 0.11175606f, 
    0.16867490f, 0.03318514f, -0.12800683f, 0.06249508f, -0.25892141f, -0.05856200f, -0.08037723f, -0.05854784f, 
    0.00698080f, 0.00719377f, -0.05275061f, 0.07573133f, -0.11712027f, -0.02059563f, 0.13857351f, -0.23653573f, 
    0.00041341f, -0.01790284f, 0.05275805f, 0.08330043f, 0.04550934f, 0.17299503f, 0.05854112f, 0.09461410f, 
    0.19314384f, 0.28694531f, 0.00151634f, 0.23010835f, 0.11130362f, -0.19415790f, -0.02858613f, -0.27698222f, 
    -0.33568886f, 0.07473099f, -0.13977189f, 0.11126509f, -0.07440646f, 0.16755700f, 0.00251395f, 0.17543399f, 
    0.10772678f, 0.05424143f, 0.01534434f, 0.04676951f, -0.05099128f, -0.02723453f, 0.00114690f, 0.01484653f, 
    0.05988766f, -0.13868020f, -0.16805232f, -0.07676048f, -0.11180055f, 0.22773233f, 0.20743133f, -0.06575326f, 
    0.00309351f, 0.10771241f, -0.03326124f, -0.03360958f, 0.05459633f, -0.04217174f, -0.01914905f, 0.05453169f, 
    -0.04770171f, -0.15318276f, 0.07114070f, 0.09074691f, -0.02454269f, 0.12287290f, 0.02744833f, -0.05386746f, 
    0.07575731f, 0.05934025f, -0.02776125f, -0.00911316f, 0.23821385f, -0.01416995f, -0.01318888f, -0.10186833f, 
    -0.01435409f, -0.06708875f, -0.00735822f, 0.13202202f, 0.18790945f, -0.08182817f, -0.01355223f, -0.01329885f, 
    0.11607716f, 0.05479503f, 0.03093711f, 0.22591811f, 0.10841868f, 0.05232833f, 0.12729031f, -0.03307390f, 
    0.08168556f, -0.04091923f, 0.00547319f, -0.13256080f, 0.12088437f, 0.02986896f, -0.06265704f, -0.13382906f, 
    0.00972977f, 0.16421591f, 0.00553843f, -0.09324882f, 0.06718918f, -0.02196894f, 0.03196641f, 0.12441934f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.02706385f, 0.03051570f, -0.01100356f, -0.05672059f, 0.01042760f, 0.01623001f, -0.05574762f, 0.00694986f, 
    -0.01802948f, 0.07753185f, -0.02411230f, -0.02884284f, -0.01466975f, 0.00798048f, -0.00512264f, -0.00051114f, 
    0.00886573f, 0.01721733f, -0.04421007f, 0.02147147f, -0.03373756f, -0.01010058f, -0.01738674f, 0.00733388f, 
    0.06368929f, -0.03664000f, 0.04017226f, -0.02876280f, 0.04957130f, 0.00744153f, -0.03721395f, 0.04966427f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.08514933f, 0.06421971f, -0.16032453f, -0.75178862f, -0.06315613f, 0.05667991f, 0.05592704f, -0.00316472f, 
    0.06140291f, -0.11750849f, -0.08916801f, 0.05642961f, 0.05399374f, 0.06763747f, -0.01288596f, 0.26959997f, 
    -0.07118542f, 0.01659790f, 0.02040552f, 0.06567460f, -0.11813679f, 0.17144345f, 0.37789083f, 0.05301719f, 
    -0.35676134f, -0.12906280f, -0.06732415f, 0.13564520f, -0.78966320f, 0.03906322f, 0.05958682f, 0.02237478f, 
    -0.00038868f, -0.15328042f, -0.02642163f, -0.20773223f, -0.00510947f, -0.13397039f, -0.08994033f, 0.03067360f, 
    0.02235838f, 0.33361769f, 0.09476553f, 0.02532460f, -0.54949135f, -0.01357809f, 0.08621540f, 0.28061005f, 
    0.08726519f, -0.08140170f, 0.01875682f, -0.04829046f, -0.13076547f, -0.09550847f, -0.10053881f, -0.11473110f, 
    0.46255916f, -0.02014850f, -0.14083347f, -0.16625574f, -0.39786065f, -0.00554723f, -0.13346045f, -0.25457108f, 
    -0.14059608f, -0.03524570f, -0.03007611f, 0.27440718f, 0.07804760f, 0.03714895f, 0.44438538f, -0.07395304f, 
    -0.16725674f, 0.08892853f, 0.10870320f, 0.16365029f, -0.28732756f, 0.13558368f, 0.02302211f, -0.28812391f, 
    -0.05351558f, -0.00470006f, 0.12448613f, 0.16748384f, -0.04318196f, -0.06515007f, 0.31935996f, 0.12221599f, 
    -0.00369891f, 0.03681651f, -0.68086863f, 0.12312689f, -0.20580070f, 0.16556375f, -0.08567960f, -0.15338859f, 
    -0.06180662f, -0.05889164f, -0.13937619f, 0.11056257f, 0.04926943f, -0.16317229f, 0.48640534f, -0.00465519f, 
    -0.02955996f, -0.10607158f, 0.12172546f, 0.03495361f, 0.21936935f, 0.10568680f, -0.15560612f, 0.05675587f, 
    -0.16830900f, -0.10219623f, -0.06225576f, -0.11161677f, 0.00674019f, -0.38726196f, -0.24069087f, 0.08810897f, 
    -0.33229390f, 0.06916957f, 0.00634709f, 0.05669318f, 0.10997263f, 0.07915999f, -0.02503331f, 0.34990829f, 
    -0.06500208f, -0.04955250f, 0.10499366f, -0.10346974f, 0.12576489f, 0.15805414f, -0.15597545f, 0.02584262f, 
    -0.08142903f, -0.34648851f, -0.15739039f, -0.00263841f, -0.12601617f, 0.12262925f, 0.15315232f, 0.32929590f, 
    -0.03944479f, -0.05151761f, -0.11545070f, -0.07376770f, 0.15998036f, 0.15053137f, -0.55598444f, 0.02244117f, 
    -0.35989949f, -0.00408661f, -0.13650723f, 0.03003927f, 0.01395833f, -0.04275926f, 0.05114799f, 0.38089582f, 
    0.15287760f, 0.11119530f, 0.10621850f, 0.14659664f, -0.11463066f, -0.09889730f, -0.65242976f, -0.14753753f, 
    -0.09886415f, 0.34413826f, -0.07896511f, -0.15228225f, 0.42130131f, -0.14321823f, 0.05717535f, 0.22413053f, 
    0.12106747f, -0.16730052f, -0.05263819f, -0.11172543f, -0.10969625f, -0.11367662f, -0.15500461f, -0.16541106f, 
    -0.08050364f, 0.03001987f, -0.03588838f, -0.08517090f, -0.22370934f, 0.09833094f, -0.08769307f, -0.31244680f, 
    0.02870950f, -0.02458705f, -0.01548427f, -0.12558593f, -0.13935097f, -0.10724223f, -0.24767898f, -0.04683891f, 
    0.13518104f, -0.22418725f, -0.15306142f, -0.00222706f, 0.47501934f, 0.06043541f, 0.03271333f, -0.59114593f, 
    0.00973263f, 0.17513652f, -0.09055229f, -0.05721246f, -0.12369500f, 0.07409053f, 0.06403155f, -0.16587603f, 
    0.27904251f, -0.09421678f, -0.50233412f, 0.08986322f, -0.09133168f, 0.04837760f, -0.15724105f, 0.30271798f, 
    -0.07483838f, 0.05430309f, 0.08423642f, 0.26503265f, -0.12967210f, 0.12671657f, -0.00839026f, 0.11095803f, 
    -0.07018719f, -0.47265652f, -0.00940545f, 0.01253201f, 0.12483724f, -0.05807052f, -0.16852050f, -0.02410151f, 
    -0.09902332f, -0.04706134f, 0.12254692f, 0.10584132f, -0.02546073f, -0.09445649f, 0.33429804f, -0.04112706f, 
    -0.38712284f, 0.13804245f, 0.20681971f, -0.16916823f, 0.21579960f, 0.04119179f, 0.13084018f, -0.50250882f, 
    -0.12101229f, 0.07250492f, -0.18172482f, -0.21948726f, 0.14590518f, 0.09096599f, 0.25567344f, -0.10141842f, 
    0.09233904f, 0.16351883f, -0.11653718f, 0.16383079f, -0.26524371f, -0.08872067f, -0.02188039f, -0.47733980f, 
    0.01542794f, -0.14266121f, 0.12553139f, -0.05539661f, -0.16296086f, 0.19705296f, -0.59504527f, 0.12111392f, 
    -0.14286675f, 0.03904285f, 0.21288095f, 0.11629176f, -0.00043412f, 0.16570346f, -0.10885911f, -0.60118270f, 
    -0.13619527f, 0.02636792f, -0.05872186f, 0.13691352f, -0.04204305f, 0.13483188f, -0.53841156f, -0.15124367f, 
    0.04144229f, -0.06858499f, 0.03783880f, -0.01048237f, -0.27520007f, -0.02349156f, -0.08377200f, -0.08809625f, 
    -0.15561159f, -0.15086389f, -0.08818634f, 0.13085939f, -0.06667263f, 0.02855661f, 0.36975810f, 0.13101709f, 
    -0.36989173f, -0.01195466f, -0.45563918f, -0.11040939f, 0.41202962f, 0.05009070f, 0.15199165f, 0.04342898f, 
    -0.12464483f, -0.16317043f, 0.05828324f, -0.60031140f, 0.15153858f, -0.11796587f, 0.09372390f, 0.17993906f, 
    -0.03226297f, 0.06780688f, 0.14054006f, 0.17180616f, -0.11531688f, 0.05852922f, 0.13179320f, -0.15847477f, 
    -0.05808675f, -0.11027141f, -0.16270205f, -0.03086513f, 0.01391453f, -0.35620889f, 0.30128306f, -0.07547791f, 
    0.33639276f, 0.02486606f, 0.18292554f, -0.11998288f, 0.43867737f, 0.00688874f, 0.14778993f, -0.13771713f, 
    0.13329989f, -0.00329340f, -0.02812370f, 0.34118032f, 0.01654862f, 0.16454978f, -0.21447891f, 0.13600950f, 
    -0.11006844f, -0.11814623f, 0.01325680f, 0.14242409f, -0.25325045f, -0.10567063f, 0.04849263f, -0.39840838f, 
    0.01957683f, 0.01820674f, -0.14777142f, -0.02792657f, -0.02391307f, -0.08117252f, 0.11571303f, 0.12351597f, 
    0.19087565f, -0.16069317f, 0.47787935f, 0.15561004f, -0.38578543f, 0.09734803f, -0.11800686f, 0.26912662f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.17707586f, 0.09707367f, 0.03744229f, -0.06041117f, -0.10513043f, 0.00437166f, -0.00920044f, -0.00470412f, 
    -0.08743495f, 0.12570228f, 0.13795492f, -0.15503249f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
