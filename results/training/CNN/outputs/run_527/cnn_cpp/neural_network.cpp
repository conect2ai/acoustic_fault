#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.33198938f, -0.33413625f, -0.62110293f, -0.85268819f, 0.39700389f, 0.18515079f, -0.58564514f, 0.61463112f, 
    0.20308776f, 0.41790685f, -0.09618592f, -0.06933839f, -0.13776611f, -0.11294425f, -0.40518287f, -0.07356497f, 
    0.12797388f, -0.10617306f, 0.34318376f, 0.04725474f, -0.14172027f, 0.21944815f, -0.34869963f, -0.09673992f, 
    0.08880235f, 0.10366265f, 0.40987340f, 0.55827630f, -0.24764504f, 0.47717693f, -0.88821495f, -0.37151888f, 
    -0.34213829f, -0.56615120f, -0.67148882f, 0.23220113f, 0.09093962f, 0.15327178f, -0.18347929f, 0.27496743f, 
    0.25350755f, 0.05793292f, -0.17352866f, -0.02025632f, 0.24861905f, 0.04592789f, -0.00893448f, -0.24940646f, 
    -0.04593373f, -0.03914146f, 0.83915383f, 0.33928242f, 0.47685310f, 0.69506556f, 0.65697849f, 0.59412509f, 
    -0.43918502f, -0.30516180f, 0.29460037f, -0.10288662f, 0.12771751f, 0.21697244f, -0.45549420f, -0.05159518f, 
    -0.21706979f, 0.35714740f, -0.12461373f, -0.12747175f, -0.03061695f, -0.23897983f, 0.20533454f, 0.22483321f, 
    0.11565146f, -0.23478895f, 0.48427528f, 0.69250071f, -0.30608377f, -0.79213965f, -0.45823565f, -0.48154542f, 
    0.34932104f, 0.50408304f, 0.35419527f, 0.54784334f, 0.36294600f, 0.11271592f, 0.21659832f, -0.21879376f, 
    0.24140507f, 0.25705120f, 0.09338452f, 0.16519006f, 0.03384862f, 0.00531637f, -0.04124409f, 0.06474985f, 
    0.16384728f, 0.04779193f, 0.01642184f, 0.07686322f, 0.23780958f, -0.29149660f, 0.69095629f, -0.50278986f, 
    -0.57195175f, 0.62461221f, -0.32505569f, 0.20816213f, -0.46480021f, -0.26119506f, 0.32307798f, -0.14228445f, 
    -0.35297135f, 0.27991900f, 0.03234977f, 0.30099198f, 0.08041111f, -0.34164962f, 0.06020585f, -0.25808197f, 
    0.22401936f, 0.37921017f, 0.22994122f, 0.22203171f, -0.25454146f, 0.22111113f, -0.11376211f, -0.73612440f, 
    -0.65612000f, 0.25302577f, -0.34706283f, -0.49103764f, 0.48573086f, 0.06498334f, -0.52709657f, -0.44909674f, 
    -0.39823854f, 0.25281009f, -0.21020629f, -0.65786535f, -0.04351123f, 0.33623099f, 0.29073101f, 0.43257067f, 
    -0.01147802f, 0.07575087f, -0.18233484f, 0.10881910f, 0.16610786f, 0.04568419f, 0.24992420f, -0.72024864f, 
    -0.80807555f, -0.64482868f, 0.07447672f, 0.59193039f, -0.12269201f, 0.26068088f, -0.16451389f, 0.33835399f, 
    -0.24624601f, 0.15127067f, 0.09914725f, 0.24584693f, 0.11426928f, -0.05175848f, -0.07401323f, -0.07309563f, 
    0.04635115f, 0.10104188f, 0.03560149f, 0.01977614f, 0.07479811f, -0.09339274f, 0.01592401f, 0.36697596f, 
    0.45409444f, -0.84087867f, -0.35329860f, -1.07145166f, 0.52619964f, 0.07229478f, -0.14274544f, 0.57972288f, 
    0.05388703f, -0.28850216f, 0.18847540f, 0.13287795f, 0.07771975f, -0.09251653f, 0.29184765f, -0.05573450f, 
    -0.06308424f, 0.34295005f, -0.02207508f, -0.10742611f, -0.17042674f, 0.17320316f, -0.23039001f, 0.35907921f, 
    -0.51041889f, 0.24460830f, -0.16470149f, -0.81240362f, -0.53361082f, -0.04984042f, -0.24514998f, -0.17066897f, 
    -0.69317144f, 0.02211334f, 0.10187941f, 0.15689687f, -0.21374691f, 0.42941120f, 0.23663126f, 0.32771769f, 
    -0.18715259f, -0.12479740f, -0.04112739f, 0.15208983f, 0.00529726f, 0.27156290f, -0.00355376f, 0.04326865f, 
    0.44873515f, 0.89158547f, 0.19070576f, -0.17819197f, -0.63030112f, -0.49102992f, 0.19080637f, 0.66693133f, 
    -0.17679973f, -0.62066495f, -0.57879150f, -0.06869078f, 0.23368892f, -0.29645804f, 0.11734957f, 0.43206981f, 
    0.12444417f, -0.14534894f, 0.21687259f, 0.21552344f, 0.31872341f, -0.20038174f, -0.08646546f, 0.04397057f, 
    0.06353458f, 0.03446009f, 0.13418764f, -0.39531666f, -0.44190398f, -0.68852258f, 0.14949812f, -0.02946363f, 
    -0.55942106f, -0.64092553f, -0.23532023f, -0.02294515f, -0.41953346f, -0.14554754f, 0.41502777f, -0.03540794f, 
    -0.08887334f, -0.16963701f, 0.34419349f, 0.16710995f, 0.20897768f, -0.30335927f, -0.08644458f, -0.02136521f, 
    -0.05602567f, -0.10891620f, 0.12784672f, -0.84216523f, 0.17422093f, 0.09225718f, -0.63080859f, -0.67414534f, 
    0.59545988f, 0.10712533f, -0.22903106f, 0.60350281f, 0.68108821f, 0.30012229f, -0.42693713f, -0.36457047f, 
    -0.20272562f, -0.38685551f, 0.09247530f, 0.27213424f, -0.01545851f, 0.00434727f, 0.03725308f, 0.30231574f, 
    -0.01089574f, -0.01900460f, -0.07561789f, 0.15385179f, -0.90719849f, 0.78448671f, -0.27885050f, -0.83759230f, 
    -0.45829809f, 0.59859729f, -0.16260952f, -0.49783647f, 0.36195031f, 0.13842423f, -0.08639990f, -0.21831416f, 
    0.19354928f, 0.14393993f, 0.08107097f, -0.00169891f, 0.12296681f, -0.14788525f, -0.00902654f, 0.05259931f, 
    -0.27327284f, 0.01869489f, 0.35823497f, -0.05248671f, 0.27172989f, 0.27710953f, -0.28029361f, 0.38457987f, 
    0.85427558f, 0.73064852f, 0.48489010f, 0.25879496f, 0.65909564f, -0.37679851f, -0.14546379f, -0.12130878f, 
    -0.30073231f, 0.20995760f, 0.03418231f, 0.00584662f, -0.29106089f, -0.24756268f, 0.17622916f, -0.09312572f, 
    -0.02756272f, 0.38109183f, 0.32031161f, -0.17255862f, 0.02879116f, -0.14248605f, 0.17232630f, -0.73785228f, 
    -0.04685666f, 0.59127760f, 0.11768334f, 0.47675815f, -0.53707427f, -0.42445698f, -0.35034338f, -0.61172402f, 
    -0.30995083f, -0.19810510f, 0.21633989f, 0.32830843f, 0.18741180f, 0.11198696f, -0.00854100f, -0.18216424f, 
    0.15571524f, 0.23201701f, -0.17134725f, -0.14844126f, -0.02436557f, 0.37990570f, 0.10735940f, 0.43855658f, 
    0.19330993f, 0.04822179f, 0.72626054f, -0.62564743f, 0.18694064f, -0.66500992f, 0.08673218f, -0.03180890f, 
    0.46129826f, -0.13996817f, 0.24393715f, 0.06339034f, -0.03901542f, 0.15755019f, -0.47535294f, 0.19470052f, 
    -0.38519996f, -0.36137420f, 0.01943018f, -0.36248156f, -0.27487510f, -0.01734837f, -0.43316197f, -0.20815548f, 
    -0.94881636f, 0.96022516f, -0.32832363f, -0.12196002f, 0.50177681f, -0.35925788f, 0.68220031f, -0.23498444f, 
    -0.57416731f, -0.42140961f, -0.53087902f, 0.40946925f, 0.34198201f, -0.34466293f, -0.07755457f, 0.17498158f, 
    -0.13922416f, 0.11460629f, -0.07460899f, -0.15558311f, -0.00388464f, -0.02305482f, -0.14073175f, 0.03230702f, 
    0.09925412f, -0.80209452f, -1.10869622f, -0.53724897f, -0.02254632f, 0.45620310f, -0.20366155f, 0.73633623f, 
    0.48225015f, 0.08608725f, 0.08736573f, 0.17449057f, -0.14969891f, 0.07679495f, 0.02592097f, 0.36477026f, 
    0.14261648f, 0.14594288f, -0.05789509f, 0.26696554f, -0.09033456f, 0.02377871f, -0.08799023f, -0.28496212f, 
    -0.25377741f, 0.04591554f, -0.20502502f, -0.30440855f, 0.56021053f, 0.55297905f, -0.04447223f, 0.10222542f, 
    0.02057545f, 0.42680866f, -0.12696220f, 0.47260994f, -0.10990109f, -0.04231225f, 0.17084895f, 0.00124013f, 
    0.36126044f, 0.24499846f, -0.36521307f, 0.09047125f, 0.26080957f, 0.18324697f, 0.32801372f, 0.25111711f, 
    -0.29908797f, -0.25840816f, 0.14916991f, 0.76273620f, 0.08497201f, 0.75572753f, -0.17975652f, 0.19780999f, 
    -0.43260169f, -0.07997897f, -0.10065255f, -0.29831219f, 0.36979637f, -0.14979821f, 0.34554803f, 0.44790620f, 
    0.26019871f, -0.32641166f, -0.28011054f, -0.08733195f, 0.22313285f, -0.09651835f, 0.05527323f, -0.19478296f, 
    0.15369558f, -0.21178789f, 0.24171796f, -0.11568204f, 0.76044255f, -0.63288951f, 0.03769848f, 0.82153100f, 
    0.86962128f, -0.70721775f, -0.06945568f, 0.16032213f, 0.38156286f, -0.24125917f, 0.31301457f, 0.15198466f, 
    0.02755570f, -0.39542934f, -0.14980391f, -0.20451006f, -0.09710959f, -0.10991324f, 0.26685512f, 0.03479480f, 
    0.01228156f, 0.07972489f, 0.07519323f, 0.02563834f, 0.11523378f, -1.32484424f, 0.97746456f, 0.15144147f, 
    -0.54673129f, -0.01628483f, 0.82098407f, 0.20262399f, -0.52543503f, 0.65088832f, -0.22368032f, 0.11956662f, 
    -0.20749703f, -0.11791319f, 0.39359590f, 0.20189713f, -0.15566732f, -0.18102342f, -0.11656430f, -0.00614282f, 
    -0.05851794f, -0.14440779f, -0.03244892f, 0.21203427f, 0.30556944f, -0.19905066f, -0.06284213f, 0.58368313f, 
    0.68382317f, 0.15828863f, 0.06895880f, -0.89533544f, 0.55874324f, -0.01034703f, -0.47447294f, 0.49829638f, 
    0.15426317f, 0.34179249f, 0.19760947f, 0.34728706f, -0.14256158f, 0.24197730f, -0.03844117f, 0.27974394f, 
    -0.06785485f, -0.08197539f, 0.03421412f, -0.32156026f, -0.07956670f, 0.02789506f, -0.22077177f, 0.79136318f, 
    -1.38621271f, -0.24411000f, 0.46119583f, 0.45396659f, -0.72392666f, 0.70209837f, 0.27621162f, -0.59999049f, 
    0.31249380f, 0.22934031f, 0.39189407f, -0.44263023f, -0.05812941f, 0.16409299f, -0.13496085f, -0.12717240f, 
    -0.18523097f, 0.17206454f, -0.16458546f, 0.10138629f, -0.07169285f, 0.13322967f, 0.22240891f, 0.05294321f, 
    0.54809093f, 0.65881622f, 0.43206152f, 0.63162243f, 0.42644826f, -0.02357986f, -0.42468131f, -0.02475114f, 
    -0.40289509f, 0.49324846f, 0.33248746f, 0.15051073f, -0.08904321f, 0.26148006f, -0.05997588f, 0.24956818f, 
    0.00218086f, 0.45246941f, 0.02805109f, 0.01879938f, 0.31051520f, -0.22733723f, 0.10101077f, 0.18585235f, 
    0.09429993f, 0.79317427f, 0.62275457f, 0.57467240f, 0.73732054f, 0.62937719f, -0.21607651f, 0.20670412f, 
    0.12066832f, -0.39813834f, -0.06669800f, -0.13655859f, -0.15162084f, -0.23377056f, 0.52393085f, -0.05585628f, 
    -0.14828914f, -0.25716311f, 0.18499358f, 0.05346318f, -0.33697593f, -0.11254766f, 0.26564848f, -0.17244411f, 
    -0.16612756f, 0.17534244f, -0.67528158f, -0.91667074f, -0.67349553f, -0.48091155f, -0.06348038f, -0.43554330f, 
    0.03310128f, 0.27351573f, -0.28916270f, 0.21607682f, -0.13242665f, -0.17454824f, -0.09368579f, -0.03608386f, 
    0.13576226f, 0.15489818f, -0.14184377f, -0.14479381f, 0.01904753f, 0.07150797f, 0.15987766f, 0.29516208f, 
    0.24064799f, 0.13501452f, 0.12668197f, 0.25556141f, 0.03028470f, -0.36789152f, 0.65753758f, 0.99190032f, 
    0.16902529f, 0.44595227f, 0.70764935f, 0.51070803f, 0.31184971f, 0.10485277f, -0.30968136f, -0.05908591f, 
    -0.35959581f, -0.15273283f, -0.09227649f, -0.20459405f, -0.09778560f, -0.26981869f, 0.03529088f, 0.28479216f, 
    0.01213088f, -0.12194026f, 0.13811150f, 0.04714701f, 0.12876442f, -0.47145551f, 0.47920978f, -0.16888751f, 
    -0.27681366f, 0.41280597f, 0.21980433f, -0.14900303f, 0.18876593f, 0.46574205f, 0.15356898f, 0.01764936f, 
    -0.12110433f, 0.14491215f, 0.08641405f, 0.27554435f, 0.08055986f, -0.44707668f, 0.16625336f, -0.39062515f, 
    0.35136494f, 0.35080194f, 0.09274255f, 0.58918899f, 0.06404694f, 0.10011046f, -0.87547433f, 0.04829027f, 
    0.12462748f, -0.54005998f, 0.68140858f, 0.57602972f, 0.34516808f, 0.49345818f, -0.08500835f, -0.20474304f, 
    -0.39484671f, -0.34288195f, -0.29941627f, -0.04571987f, -0.12312511f, 0.14492829f, -0.09481749f, 0.05677249f, 
    -0.09761669f, -0.23343797f, -0.24000420f, -0.06101578f, -0.31555545f, -0.28739378f, -0.50054097f, -0.58730882f, 
    -0.69848210f, -0.18636359f, -0.47948670f, 0.35739210f, -0.07511531f, -0.19895886f, 0.33488247f, -0.07940882f, 
    -0.32913688f, 0.00140669f, 0.23121007f, 0.24738644f, 0.26075628f, -0.16145648f, 0.02525122f, 0.10827809f, 
    -0.16949549f, -0.19042145f, 0.17223237f, 0.24281874f, -0.59241199f, 0.00415055f, 0.09857275f, 0.88890254f, 
    0.37614930f, -0.31603274f, 0.71007442f, 0.55047446f, 0.13683328f, -0.32356355f, -0.32239422f, -0.08918568f, 
    0.22996862f, -0.23411624f, 0.03864774f, 0.24306461f, -0.22104757f, 0.16525598f, 0.39297026f, 0.29198009f, 
    0.20757776f, 0.00040595f, 0.35364524f, -0.07170089f, -0.06929159f, -0.10001409f, -0.24973686f, 0.35431427f, 
    0.96615195f, 0.37207413f, 0.67056835f, -0.66508967f, -0.38537145f, -0.38087839f, -0.59908712f, -0.06629121f, 
    0.36389008f, 0.40035278f, -0.23999007f, -0.21512789f, -0.19318359f, 0.00772389f, 0.11679085f, 0.05860950f, 
    -0.05450736f, 0.27740616f, 0.02615974f, 0.04192864f, 0.39426348f, 0.22595668f, -0.16245162f, 0.01670977f, 
    0.39338911f, 0.78162247f, 0.86525881f, 0.92542863f, 0.06453512f, -0.54040408f, -0.71806133f, 0.47609371f, 
    -0.70220393f, -0.19986179f, -0.07237415f, 0.35657507f, 0.15508705f, -0.22003843f, -0.18780938f, -0.27417558f, 
    -0.35820836f, -0.52939618f, 0.25373265f, -0.03472789f, -0.43427420f, -0.09997918f, -0.00095985f, -0.11091567f, 
    0.11912313f, -0.11404844f, 0.86837184f, 0.70626736f, -0.32059181f, -0.43179831f, -0.37139136f, 0.71101105f, 
    0.00248078f, 0.43144509f, 0.12881336f, 0.35412863f, -0.04814731f, 0.28950313f, -0.42114004f, -0.12225143f, 
    -0.10798771f, -0.21098070f, -0.24408673f, -0.26886293f, 0.11128604f, -0.01738620f, 0.03878357f, -0.12978107f, 
    -0.18478887f, 0.00133780f, 0.09053314f, -0.95562327f, 0.58068341f, -0.23315901f, 0.64889956f, -0.42004067f, 
    -0.11042791f, 0.17571421f, -0.07545934f, 0.58414179f, -0.30140534f, -0.16382615f, -0.44844612f, -0.30506778f, 
    -0.35292479f, -0.10470873f, -0.21989937f, 0.07922483f, -0.33085525f, -0.26523349f, -0.35184076f, -0.11159057f, 
    0.03772430f, -0.07092056f, -0.29193267f, -0.33028582f, 0.62860328f, 0.25946057f, 0.36909127f, 0.86435175f, 
    0.80964202f, 0.65253115f, 0.24662793f, -0.65175200f, 0.43137690f, 0.15625085f, -0.36313868f, -0.03964641f, 
    -0.28754890f, 0.26877555f, -0.41294548f, -0.24487390f, 0.02705298f, -0.05684987f, -0.04652760f, -0.25291649f, 
    0.28888160f, 0.20718051f, 0.03789670f, -0.16512147f, 0.20223993f, -0.70847118f, -0.15667701f, 0.43450886f, 
    0.52302164f, 0.24409087f, -0.34377068f, -0.05946904f, -0.14443660f, 0.32417330f, -0.34207752f, 0.39897165f, 
    -0.34504509f, 0.03000228f, 0.25583330f, 0.30130318f, 0.26314044f, 0.45483446f, 0.16247013f, 0.49378678f, 
    -0.14525136f, -0.16646016f, -0.20975511f, -0.00905733f, -0.14106840f, 0.48211199f, -0.54079664f, -0.82926822f, 
    -0.53766006f, -0.32378379f, -0.23582348f, -0.62040544f, 0.80658400f, 0.77305931f, 0.28055304f, 0.03381390f, 
    0.06237618f, -0.12869787f, 0.13434254f, -0.14198993f, -0.19635062f, -0.24745427f, -0.15701640f, -0.00303825f, 
    -0.31191000f, -0.00396726f, -0.14247824f, -0.10841791f, 0.06358783f, 0.06218712f, -0.02597485f, 0.08656206f, 
    0.42846331f, -0.13020839f, -0.30462325f, 0.69027114f, -0.27337748f, -0.33570993f, 0.38418576f, 0.18102482f, 
    -0.71436322f, 0.26804093f, 0.32788932f, -0.08241153f, 0.13209532f, -0.06487982f, 0.30777746f, 0.20043670f, 
    -0.09659819f, 0.11528294f, 0.38188505f, -0.36398160f, 0.22140834f, -0.15300176f, 0.15989928f, 0.42479298f, 
    -0.17429471f, -0.21851273f, -0.64939600f, -0.31434771f, -0.27285397f, 0.20259303f, 0.22944756f, -0.21536320f, 
    0.83379221f, -0.35994077f, 0.18437710f, -0.20596412f, 0.06240847f, 0.46301413f, 0.10902907f, 0.27460530f, 
    -0.51045853f, -0.01102073f, -0.36057019f, -0.38252288f, 0.32011044f, -0.05358801f, -0.05669160f, -0.13486174f, 
    0.03754365f, 0.49677002f, 0.58975935f, 0.00890723f, 0.49132195f, 0.68714738f, 0.26205397f, 0.44241503f, 
    0.77379370f, 0.26174819f, 0.24937667f, 0.16772261f, -0.22071114f, -0.06532837f, 0.31032783f, -0.25617132f, 
    0.28820688f, -0.14910693f, -0.22639842f, 0.29496717f, -0.34178373f, -0.18914476f, -0.42688259f, -0.14202128f, 
    -0.01425855f, -0.14022131f, 0.68278253f, -0.18010481f, -0.38572058f, -0.24005838f, 0.80820215f, 0.55360496f, 
    -0.11896247f, -0.64275891f, 0.23613974f, 0.26396734f, -0.05746556f, 0.57713443f, -0.36382312f, 0.14952497f, 
    0.36233690f, -0.20830862f, -0.40017098f, -0.01690018f, 0.14531291f, 0.11526148f, 0.27813393f, -0.05040320f, 
    -0.13124214f, -0.31061977f, 0.18408763f, 0.36767972f, -0.50292200f, -0.46570274f, -0.79314590f, -0.49225628f, 
    -0.44409305f, 0.80519843f, 0.67689025f, -0.08007801f, 0.46514073f, 0.11153685f, -0.05020612f, -0.33824366f, 
    -0.54382795f, -0.35338208f, -0.22136630f, 0.21220917f, 0.04692047f, -0.02834857f, -0.08067816f, -0.14020999f, 
    0.06027506f, 0.07967787f, -0.37265566f, 0.00682504f, 0.22416341f, 0.69333684f, -0.12922756f, 0.55400109f, 
    0.71139503f, 0.55077833f, 0.42146522f, 0.04988550f, -0.27814740f, -0.10774475f, -0.18311977f, -0.09479070f, 
    0.18745421f, -0.09887683f, 0.08988588f, -0.21058334f, 0.25855547f, 0.20779850f, 0.10501917f, 0.30400041f, 
    -0.07477763f, -0.10245036f, 0.08543075f, -0.42819548f, -0.04318037f, -0.79462367f, -0.82183421f, 0.06177766f, 
    0.53644788f, -0.19038677f, -0.07156215f, 0.82946342f, 0.26286587f, -0.70273018f, 0.00096321f, -0.27549437f, 
    0.18326235f, 0.13571332f, -0.31314695f, -0.18622164f, -0.29671690f, 0.04527144f, -0.02130353f, -0.14789575f, 
    -0.47961146f, 0.38604736f, 0.06631787f, -0.00344127f, -0.11183015f, 0.04410287f, -0.26612788f, -0.28560346f, 
    0.31097376f, 0.48226568f, 0.55022383f, 0.04522074f, 0.33282256f, -0.30213520f, 0.11463235f, -0.39054525f, 
    -0.26641396f, -0.42071605f, 0.07565598f, -0.24239035f, 0.11923885f, 0.39575469f, 0.17231737f, 0.07969641f, 
    0.51410520f, 0.38485557f, -0.27573451f, -0.29282555f, -0.21395855f, -0.36940661f, -0.09301503f, 0.60721320f, 
    0.10331074f, 0.03777019f, -0.31355417f, -0.64010811f, -0.46212605f, -0.15741600f, -0.52068567f, -0.33212930f, 
    0.19803828f, 0.24835218f, -0.24780956f, 0.26601419f, -0.31559357f, -0.57503539f, -0.04275506f, 0.24074280f, 
    -0.44165179f, 0.14592265f, -0.31259677f, -0.35799220f, 0.14461707f, -0.13180290f, -0.17910253f, -0.13665713f, 
    -0.23332627f, -0.19460499f, -0.52575910f, 0.08726130f, -0.39435667f, -0.02398533f, -0.50111061f, -0.48336580f, 
    -0.16669810f, -0.27571538f, -0.48284894f, 0.03211188f, 0.36202928f, 0.30102092f, -0.34679213f, -0.41858199f, 
    -0.34364459f, 0.23367751f, 0.23312265f, 0.05911585f, 0.27663824f, 0.19887298f, 0.02156818f, 0.25045890f, 
    0.23261599f, 0.92654717f, 0.23698474f, -0.42468402f, -0.55478460f, 0.18807235f, 0.42664629f, 0.39744648f, 
    -0.56038082f, 0.15770601f, 0.41519472f, -0.24392045f, -0.19501309f, -0.18651597f, -0.07286678f, -0.37319931f, 
    0.00266177f, -0.24275769f, 0.08067638f, 0.27495381f, -0.14260818f, -0.04449939f, 0.38829875f, 0.13112934f, 
    -0.01409099f, -0.04110681f, 0.45648649f, -0.05717932f, -0.36509144f, 0.57772213f, -0.23117000f, -0.78844428f, 
    -0.35898659f, -0.59949106f, -0.37382987f, -0.54386085f, -0.22243050f, 0.05030458f, 0.34827307f, 0.12079404f, 
    0.01121715f, 0.20414867f, -0.17510056f, -0.14579016f, -0.06439915f, -0.20113073f, 0.02200893f, -0.18806186f, 
    -0.00006187f, 0.45584667f, 0.18816672f, 0.82061732f, 0.83109117f, 0.24158221f, 0.24225660f, 0.10444807f, 
    -0.12854204f, 0.22684014f, -0.30308658f, 0.42243096f, 0.48448047f, -0.04801054f, 0.19499823f, -0.14433235f, 
    -0.41088754f, -0.07699127f, -0.17421854f, -0.11320093f, -0.11756719f, -0.05335040f, 0.14889824f, -0.09292348f, 
    0.50525522f, 0.23003392f, -0.19204819f, -0.09919716f, 0.95153552f, -0.06400207f, 0.62211788f, 0.60755712f, 
    -0.45166415f, 0.58336991f, -0.46124542f, -0.34863782f, 0.41460049f, -0.05540640f, -0.32640693f, -0.01170334f, 
    -0.05949675f, -0.07775211f, -0.03213580f, 0.08823846f, 0.04910645f, -0.07237761f, -0.24483748f, 0.12508717f, 
    0.26051760f, -0.39851338f, 0.25973770f, 0.12580487f, 0.00964127f, 0.45690048f, -0.56186122f, -0.39105844f, 
    -0.67113948f, 0.67326516f, 0.12937088f, -0.39644322f, -0.31353441f, 0.11422913f, 0.27963716f, -0.10449504f, 
    -0.48659933f, -0.30737603f, 0.06670506f, -0.22392565f, 0.10442837f, 0.42085445f, -0.04954181f, -0.25829250f, 
    -0.17688018f, 0.15651768f, -0.32841665f, 0.30947924f, 0.50681424f, -0.18926781f, 0.80317634f, 0.47411227f, 
    0.17086352f, 0.32790437f, -0.57934517f, -0.05624504f, -0.04087126f, 0.58515835f, 0.45873162f, 0.32099649f, 
    -0.14837918f, -0.04899303f, 0.43549845f, -0.51471823f, -0.22977601f, -0.16654912f, -0.15834987f, 0.04011504f, 
    0.09064753f, -0.15271090f, 0.02410064f, -0.16530707f, 0.05239860f, 0.14074412f, -0.03186924f, 0.47721788f, 
    0.11328364f, 0.85570711f, 0.32208142f, -0.18778752f, 0.35194597f, 0.12932043f, -0.69227523f, -0.53757572f, 
    0.27725780f, 0.15824018f, 0.63629210f, 0.26472667f, -0.08911775f, -0.04301210f, -0.17599849f, -0.13118839f, 
    0.21024117f, -0.10080598f, 0.20899007f, 0.01071940f, 0.19822077f, 0.09814028f, 0.22015047f, 0.27198595f, 
    -0.05826856f, 0.34423932f, 0.74647135f, 0.73640829f, 0.17499611f, -0.79820669f, -0.48780516f, -0.44024277f, 
    -0.23800574f, -0.04471036f, 0.30186656f, 0.23375417f, -0.14075410f, 0.19333279f, 0.01739980f, 0.18029143f, 
    0.00760765f, 0.09639370f, -0.19653773f, 0.45398816f, -0.01950908f, 0.17872165f, 0.30845341f, -0.34058836f, 
    0.02784163f, 0.48771805f, 0.39401761f, 0.27612832f, 0.75828886f, 0.17249835f, 0.44216126f, 0.05336589f, 
    0.15444404f, 0.23138879f, 0.47465417f, 0.26676631f, 0.05918424f, -0.01396481f, 0.26573750f, 0.13676712f, 
    -0.06222481f, 0.19426376f, 0.35473248f, 0.04903916f, 0.38880327f, -0.18528335f, 0.08170771f, 0.35378626f, 
    -0.05465424f, 0.00995113f, -0.32144541f, -0.19933006f, 0.04531314f, -0.57504719f, -0.61674178f, 0.33162802f, 
    0.19199049f, 0.59798473f, 0.51107341f, 0.56457436f, -0.11851580f, -0.19472119f, -0.22306006f, -0.39052978f, 
    0.26744097f, 0.16559842f, 0.37671787f, -0.23290971f, 0.11686543f, 0.20238516f, -0.31963718f, -0.16109857f, 
    -0.01355642f, -0.05634951f, 0.13173699f, 0.21370892f, 0.23105596f, -0.40725043f, -0.61519098f, 0.34550786f, 
    0.19622223f, -0.62806463f, 0.70057935f, 0.54074734f, -0.39414504f, -0.50134695f, -0.00274190f, -0.12652987f, 
    -0.15093248f, -0.11012133f, -0.16182050f, -0.07126301f, -0.36244953f, -0.59109825f, -0.00488805f, -0.35692245f, 
    -0.01451995f, -0.33249149f, 0.47430101f, 0.12587242f, 1.10565639f, 0.42440087f, -0.06776536f, 0.65615916f, 
    0.65705788f, 0.21280862f, 0.39630070f, 0.04569199f, -0.03719306f, -0.50693375f, -0.57530123f, -0.17133619f, 
    -0.32869107f, 0.16074289f, -0.30223477f, 0.26308134f, 0.32105568f, 0.01276070f, -0.09091318f, -0.03749198f, 
    0.30991045f, 0.05576494f, 0.21356422f, -0.08673360f, -0.12989755f, -0.20113429f, -0.91113561f, 0.85166579f, 
    0.69934857f, -0.70010138f, -0.24876396f, 0.20500812f, 0.65267229f, -0.71817905f, -0.39943290f, -0.19572830f, 
    0.01643941f, 0.22910702f, 0.36088532f, 0.26174149f, 0.03442043f, 0.36235908f, 0.10217148f, -0.22558852f, 
    -0.25843337f, 0.04844185f, 0.09449606f, -0.20413201f, 0.39407337f, -0.01882627f, -0.85951430f, -0.31066284f, 
    0.02186956f, -0.41714540f, 0.18325977f, -0.88251024f, -0.31976560f, -0.49001431f, -0.54306531f, -0.28753257f, 
    0.03147301f, 0.20867896f, 0.29595166f, 0.21125050f, -0.27984011f, 0.07387546f, -0.38481003f, 0.24486825f, 
    0.29530218f, -0.15398228f, -0.22186373f, 0.09209631f, 0.00591562f, 0.06887060f, 0.35058102f, 0.34286663f, 
    0.55017406f, -0.28961757f, 0.14027098f, 0.58127534f, -0.32535505f, -0.40078992f, 0.56505764f, 0.34122798f, 
    0.13502698f, -0.69133502f, 0.40159404f, 0.20846525f, -0.06231275f, -0.20281856f, 0.39632535f, -0.18840277f, 
    -0.42274311f, 0.10859758f, 0.45336306f, -0.34023121f, -0.04634045f, -0.13490434f, -0.37925392f, -0.38902879f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.09228770f, 0.15948197f, 0.22014131f, 0.29510176f, 0.11711195f, 0.16356930f, 0.31854439f, 0.11666112f, 
    0.29769477f, 0.21483147f, 0.34998858f, 0.05547334f, 0.12637109f, 0.18351214f, -0.00164669f, 0.14464992f, 
    0.16889420f, 0.25408557f, 0.15296964f, -0.07428061f, 0.00086468f, 0.03156750f, 0.30314165f, 0.13217571f, 
    0.26288909f, 0.03251804f, 0.10234468f, 0.17561638f, 0.19198701f, -0.02745509f, 0.13651863f, -0.06032233f, 
    0.24614227f, 0.14976987f, 0.03401420f, 0.16417168f, 0.06098686f, 0.07307024f, -0.02135868f, 0.11445913f, 
    -0.05870083f, -0.02742614f, 0.08091618f, 0.18362118f, 0.02490985f, 0.37989414f, 0.12160701f, 0.17879395f, 
    0.29790545f, -0.08594628f, 0.03838285f, 0.11315385f, 0.16804269f, 0.33591023f, 0.33528450f, -0.04321310f, 
    0.21908598f, 0.19845568f, -0.02971632f, 0.02437546f, 0.03933326f, -0.09640706f, 0.24610029f, 0.00320319f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.21207608f, -0.01634347f, 0.02727719f, -0.45242533f, 0.09410554f, 0.05401871f, 0.04608005f, -0.10923146f, 
    -0.12840383f, 0.08947825f, 0.06071422f, -0.04650722f, 0.14051315f, 0.21494353f, 0.05035888f, -0.10377767f, 
    -0.05928797f, -0.09739402f, -0.00558487f, 0.11632946f, 0.01525594f, -0.07876956f, -0.08313946f, 0.01946259f, 
    0.12273295f, -0.11045939f, 0.00170871f, 0.15908277f, -0.08172076f, 0.01450145f, -0.04767808f, 0.02744210f, 
    0.00510369f, 0.00952738f, 0.00553696f, -0.14727367f, 0.15249448f, -0.07044943f, -0.03223518f, -0.17450342f, 
    0.03238897f, -0.08265245f, 0.05267428f, -0.10560455f, -0.02798980f, 0.02552356f, 0.04431688f, 0.00058249f, 
    -0.30093470f, -0.09618346f, -0.01001064f, -0.13372469f, -0.06820314f, 0.09125176f, -0.05342492f, -0.13140897f, 
    -0.04726104f, 0.07650038f, 0.01140835f, 0.01186365f, -0.10858723f, 0.02147279f, 0.10021544f, 0.05488950f, 
    -0.02977837f, 0.07584137f, -0.00605876f, -0.00204474f, -0.07703850f, 0.12991977f, 0.07039168f, 0.05106114f, 
    0.22835320f, -0.19306488f, 0.02593403f, -0.22030134f, 0.02298170f, -0.09326883f, 0.00395181f, -0.02645712f, 
    -0.09412975f, -0.06034852f, -0.05724563f, 0.01565262f, 0.15275809f, 0.00859805f, -0.11638995f, -0.31488431f, 
    -0.00131906f, -0.00754997f, 0.02159795f, -0.04963547f, -0.04091277f, -0.03508791f, 0.00378728f, 0.04132304f, 
    -0.22119500f, -0.00602342f, 0.04506970f, -0.28926232f, -0.04452556f, 0.09385440f, 0.11186830f, 0.01928836f, 
    -0.01391837f, -0.01634904f, -0.08343253f, 0.08097975f, -0.31425193f, 0.24055757f, 0.13168493f, -0.34836555f, 
    -0.19672140f, -0.04330836f, -0.12511376f, 0.04957284f, -0.00883005f, -0.02074704f, 0.07900303f, -0.06031324f, 
    -0.14997612f, -0.17578506f, 0.22561578f, -0.08830548f, -0.00548793f, -0.00911185f, 0.02789101f, -0.01815460f, 
    -0.04625675f, -0.04428148f, 0.01354250f, 0.01192516f, 0.38132194f, -0.02610790f, -0.09926623f, -0.08243047f, 
    0.08510211f, 0.02597901f, -0.01647809f, -0.04895370f, 0.03849799f, 0.04140760f, -0.00761940f, -0.00832925f, 
    0.44297132f, -0.20069991f, -0.03127534f, -0.21171665f, -0.07390509f, -0.02376697f, -0.08607712f, 0.01305412f, 
    -0.04904424f, -0.09342466f, -0.06286156f, -0.00071631f, 0.01980188f, 0.05593668f, -0.07500031f, 0.04383716f, 
    -0.16101733f, 0.09497883f, 0.00523500f, -0.00406722f, -0.05701967f, -0.05335096f, -0.07491652f, -0.02252247f, 
    0.06791877f, -0.14295307f, -0.04962679f, 0.26500303f, 0.07329497f, -0.08405998f, -0.04497388f, -0.08905082f, 
    0.04285024f, -0.09297289f, -0.03189415f, -0.03747112f, 0.13949552f, -0.02580422f, -0.13142346f, 0.11364685f, 
    -0.12264101f, -0.06307477f, -0.01704977f, 0.12371748f, -0.09124225f, 0.01405804f, 0.02680492f, 0.03660593f, 
    -0.05987794f, -0.03323904f, 0.08607989f, -0.04989763f, -0.04093042f, -0.18789127f, 0.07792521f, -0.07828477f, 
    0.12721175f, -0.02270243f, -0.10382521f, 0.00434209f, -0.21489412f, 0.18659392f, 0.00830574f, -0.12471223f, 
    0.07503760f, 0.09437685f, -0.00076361f, 0.00867059f, 0.04639836f, -0.02019090f, -0.12218960f, 0.03610884f, 
    -0.14100233f, 0.08748545f, -0.18270491f, 0.15806152f, -0.02229842f, 0.06951475f, 0.05609097f, -0.00722793f, 
    0.04519808f, -0.07855856f, 0.01034168f, -0.06121238f, 0.12808912f, 0.02536107f, -0.06143223f, -0.13597178f, 
    -0.08119312f, -0.13281168f, 0.01517750f, 0.07691377f, -0.02333587f, 0.00896658f, 0.00083470f, 0.12516834f, 
    0.28820506f, 0.04692998f, -0.13294940f, 0.27357060f, -0.10710061f, 0.04104229f, -0.03033342f, 0.04778003f, 
    0.01917735f, -0.03918789f, -0.05652240f, -0.06689144f, 0.35207602f, -0.03739190f, 0.02362449f, -0.03611928f, 
    -0.10857139f, 0.02003230f, 0.08605713f, -0.03155049f, 0.05202195f, -0.00204300f, 0.03928902f, 0.08644265f, 
    -0.14334641f, -0.06392416f, -0.06006293f, 0.02297756f, -0.04090673f, -0.07967546f, -0.06018697f, -0.05631303f, 
    0.03225699f, 0.03657409f, 0.01881597f, -0.06559328f, 0.02917688f, -0.26721299f, 0.00838904f, 0.19688791f, 
    -0.17648911f, 0.00504224f, -0.03486843f, -0.04831134f, -0.05270305f, 0.15508570f, 0.03260247f, -0.11093674f, 
    0.11790022f, -0.00242490f, 0.01021384f, -0.03441506f, -0.16081625f, -0.08243192f, 0.03752843f, -0.00319517f, 
    0.05601626f, 0.02347264f, -0.07253881f, -0.16195413f, 0.20577034f, 0.11088554f, -0.12856458f, 0.01913541f, 
    -0.23021908f, -0.01439107f, 0.01881515f, 0.04957921f, -0.07413599f, 0.03761758f, -0.07549185f, -0.11353416f, 
    -0.25156483f, -0.07241866f, -0.14754638f, -0.15265612f, 0.01366784f, -0.06400333f, 0.03442802f, 0.05542720f, 
    -0.01344985f, -0.01315365f, 0.03372099f, -0.01956941f, -0.13496111f, 0.20073880f, 0.09236851f, 0.22077954f, 
    -0.01885993f, 0.08581530f, -0.00450235f, -0.01941596f, -0.12182122f, 0.04047463f, -0.02422195f, 0.02030887f, 
    -0.09969158f, -0.03281407f, 0.01988152f, -0.02234723f, 0.01253291f, 0.03499539f, -0.05319225f, -0.04082743f, 
    -0.01821124f, 0.12351078f, 0.01837175f, -0.05022289f, 0.19875418f, 0.11205216f, 0.00571187f, 0.15091980f, 
    0.02238648f, 0.09681305f, 0.05176240f, 0.06685364f, 0.02892160f, -0.04274349f, 0.04035950f, 0.03979833f, 
    0.11103060f, -0.15725517f, -0.02348700f, -0.04834589f, -0.00537980f, -0.04435183f, 0.03297696f, 0.01900403f, 
    0.05365071f, -0.15498397f, -0.02583594f, 0.09247907f, 0.24028447f, -0.11303312f, 0.03451251f, 0.17834750f, 
    -0.13471419f, 0.00443584f, -0.00409829f, 0.12655954f, 0.01154436f, 0.12001557f, 0.00691992f, 0.15231815f, 
    0.12343123f, -0.01680235f, -0.07712170f, -0.16082801f, 0.04249566f, -0.06444123f, -0.11058357f, -0.07500940f, 
    0.06633868f, 0.05319665f, -0.11585475f, 0.06933325f, -0.02397496f, 0.09313748f, -0.00550884f, 0.02302054f, 
    -0.08066821f, -0.01045869f, -0.01952521f, -0.04672435f, -0.04806297f, 0.08955667f, -0.04283442f, -0.11870432f, 
    0.10248916f, -0.16257596f, -0.03097253f, -0.16558737f, -0.04139840f, 0.00778681f, 0.03873074f, 0.04308771f, 
    -0.09699995f, -0.02975133f, 0.00751637f, 0.07650126f, 0.34596556f, 0.05344671f, -0.13045388f, 0.06243489f, 
    -0.04943328f, 0.00294848f, 0.04238657f, -0.03785250f, -0.02978402f, 0.04958506f, -0.00759502f, -0.00735318f, 
    0.05836792f, -0.03347309f, 0.06601113f, 0.34556508f, -0.02714132f, -0.10095772f, -0.02174756f, -0.05474744f, 
    -0.07544221f, 0.12883875f, -0.11812895f, 0.00500109f, -0.16376625f, 0.08836371f, -0.28678754f, 0.15292832f, 
    -0.11714440f, -0.00898856f, 0.06144045f, 0.02565268f, -0.01457739f, 0.04522680f, 0.00347087f, -0.01979381f, 
    -0.25983521f, 0.29018572f, -0.08438434f, -0.19802701f, -0.01423831f, 0.04801603f, 0.02309271f, 0.01160139f, 
    0.08064695f, 0.02721565f, -0.05172134f, 0.08252542f, 0.00621594f, 0.04635532f, 0.11000516f, -0.13767916f, 
    -0.11783087f, -0.03126652f, -0.06952156f, 0.08851763f, 0.10762008f, 0.03326198f, 0.03929149f, -0.13673598f, 
    0.02617254f, 0.17677259f, -0.06842462f, -0.18978895f, -0.04007038f, 0.00034261f, -0.04255121f, -0.03043792f, 
    0.14031854f, -0.00486077f, -0.05948888f, 0.05557096f, 0.07045826f, 0.01277694f, 0.05192749f, -0.00875146f, 
    -0.07688390f, 0.09190553f, 0.01839179f, 0.02164198f, -0.03373231f, 0.06951976f, 0.03708727f, -0.10129399f, 
    0.13551822f, -0.24650845f, 0.17474732f, -0.12620465f, -0.10603993f, -0.01394561f, 0.05508718f, -0.05109344f, 
    -0.01890549f, 0.05312321f, 0.13326474f, 0.00105218f, -0.32843435f, 0.05902468f, 0.04984915f, -0.28079280f, 
    -0.03203074f, 0.02207235f, 0.01787238f, -0.06488135f, -0.00273507f, 0.00191376f, 0.00537932f, -0.00592062f, 
    0.05845843f, -0.13371988f, 0.02190607f, -0.02084250f, -0.24108407f, 0.01019478f, 0.09902156f, 0.03858442f, 
    0.05102748f, 0.08720955f, -0.08761178f, 0.09748192f, -0.19230057f, 0.16180883f, 0.10459087f, 0.05086515f, 
    -0.06810975f, -0.01826951f, -0.02598931f, -0.00122959f, 0.01663867f, -0.00792227f, -0.09874146f, -0.04053805f, 
    0.03727606f, -0.13187388f, 0.02554948f, 0.12651224f, -0.10810030f, 0.02305197f, 0.03478515f, 0.07879940f, 
    0.07008696f, -0.04423842f, -0.04901803f, 0.02459459f, -0.13168903f, 0.12081023f, 0.10072205f, 0.03949409f, 
    -0.02552994f, -0.02572908f, -0.06495263f, 0.07328239f, -0.08970108f, -0.01407714f, 0.06822029f, -0.16817188f, 
    -0.21351641f, -0.18296228f, 0.01390261f, -0.01074641f, 0.00936064f, 0.00937675f, 0.07559003f, 0.03111345f, 
    -0.09404752f, -0.08173189f, -0.10590618f, 0.04098661f, 0.00827186f, 0.00897024f, 0.23019323f, -0.09402855f, 
    0.02938696f, 0.01841027f, 0.10115547f, 0.05929618f, -0.03656678f, 0.09506230f, 0.00746551f, -0.01618463f, 
    -0.07988926f, -0.05680984f, 0.11395109f, 0.27193940f, -0.01690277f, -0.05396112f, 0.00857415f, 0.01740677f, 
    0.01970772f, -0.03090961f, -0.01369583f, -0.01116493f, 0.10175766f, -0.11329576f, -0.01779619f, 0.02104586f, 
    -0.05177058f, -0.14840925f, -0.06045903f, 0.04350720f, 0.01865789f, 0.09146198f, 0.08749165f, 0.07912800f, 
    0.22350261f, -0.07863413f, -0.21821193f, 0.28091633f, 0.03887380f, -0.18769066f, -0.03302415f, 0.02400025f, 
    -0.07648716f, -0.03300506f, -0.08153062f, 0.00236573f, -0.04556485f, -0.07109394f, 0.25144103f, -0.07962909f, 
    0.02285124f, -0.00521337f, 0.03392665f, 0.06172805f, -0.07491238f, 0.01187833f, 0.08177138f, -0.10983735f, 
    -0.11223713f, 0.02787450f, -0.14290643f, 0.09142543f, -0.03249486f, -0.04390161f, -0.10332965f, -0.06718931f, 
    -0.05251930f, -0.02595448f, 0.05308492f, -0.00677697f, -0.07483800f, 0.19525899f, 0.10193071f, 0.00396612f, 
    -0.15798829f, -0.10372135f, 0.01456512f, -0.04296133f, 0.00313735f, 0.05725871f, -0.04080005f, 0.11076744f, 
    0.08383009f, 0.03836817f, -0.19646527f, 0.11850362f, -0.02256685f, -0.00683086f, -0.04146354f, -0.01554269f, 
    -0.00206913f, 0.02137064f, -0.04829778f, -0.00066766f, 0.06212526f, -0.05600563f, -0.19617687f, 0.16711882f, 
    -0.15140143f, 0.07971446f, -0.01207251f, -0.01073733f, 0.05126889f, 0.03782337f, -0.09784395f, 0.03248764f, 
    0.16417240f, 0.08225527f, 0.07841038f, -0.06616379f, 0.02792986f, 0.09167259f, -0.06926888f, -0.03214389f, 
    -0.01717320f, -0.05276993f, -0.08431201f, 0.09480432f, 0.25707480f, 0.01263650f, 0.21572989f, -0.22269179f, 
    0.02283043f, -0.04846241f, -0.06233306f, -0.16143343f, -0.01288740f, 0.00598948f, -0.01030932f, -0.03190921f, 
    0.13795263f, 0.13269788f, -0.00272044f, 0.08524342f, -0.04135419f, 0.00036421f, -0.05911804f, 0.03885411f, 
    -0.03423693f, -0.01439265f, 0.03421412f, -0.15643217f, -0.04017005f, 0.14570281f, -0.10021987f, 0.33138946f, 
    0.11384551f, 0.00633590f, 0.09597707f, -0.07802653f, -0.01283860f, 0.04728892f, 0.03732874f, -0.11874933f, 
    -0.40967256f, -0.33671370f, -0.05314738f, -0.01542464f, -0.08420628f, -0.00465948f, -0.05552760f, 0.06960080f, 
    -0.02836721f, 0.05802439f, -0.16002570f, -0.09776628f, 0.11081450f, -0.04677315f, -0.01079946f, -0.22900605f, 
    -0.04634552f, 0.11418500f, -0.12089275f, 0.09329240f, 0.06150312f, -0.06883291f, -0.00820414f, 0.03701440f, 
    0.08946453f, -0.15386246f, 0.11904056f, -0.28397763f, -0.04700814f, -0.02172760f, -0.03302413f, 0.12238014f, 
    -0.00171514f, -0.02350370f, 0.13212283f, 0.05647030f, -0.24963102f, -0.01400797f, -0.17158954f, -0.10292672f, 
    0.00870310f, 0.06063927f, -0.05648557f, -0.11528230f, 0.03812713f, 0.11513413f, 0.01082974f, 0.11614515f, 
    0.16594979f, -0.05668313f, 0.22715057f, 0.11612548f, -0.10133436f, -0.00231676f, -0.04022079f, 0.01887371f, 
    -0.04522215f, -0.04134231f, -0.01081500f, 0.03047402f, 0.22923300f, -0.35889733f, 0.01301994f, -0.13564861f, 
    0.08479647f, 0.06678569f, -0.07294106f, -0.00155369f, 0.00163147f, 0.01871759f, 0.06242239f, 0.02036268f, 
    -0.03020581f, 0.14521217f, -0.11379278f, -0.00625644f, 0.02009850f, -0.05013657f, 0.01242839f, -0.07065684f, 
    0.00552082f, -0.01348108f, -0.07242788f, 0.03255721f, 0.01818221f, -0.22803368f, 0.11613919f, -0.40443304f, 
    -0.04439699f, -0.02208708f, 0.05343672f, 0.05109543f, 0.02798672f, -0.15314141f, -0.08911157f, 0.11013378f, 
    0.13476659f, -0.14486492f, 0.09305061f, -0.23988166f, -0.06120629f, 0.07469554f, 0.09194640f, 0.11851204f, 
    -0.07140728f, 0.04702965f, 0.05344120f, -0.01682400f, -0.01857635f, -0.34513032f, 0.13780910f, -0.24466830f, 
    0.04963366f, -0.08918450f, -0.01674101f, 0.28616425f, -0.02407716f, 0.07306682f, 0.09891663f, -0.04348248f, 
    0.02003205f, 0.00704806f, -0.15478384f, -0.08117224f, -0.01490823f, 0.01069189f, -0.04209036f, 0.07042074f, 
    0.02360036f, 0.12456635f, -0.02448802f, -0.04798966f, 0.25425717f, -0.07739820f, -0.03363326f, -0.09878190f, 
    0.06719173f, -0.00338923f, 0.01752341f, -0.01527603f, -0.18672085f, 0.08681496f, -0.04717490f, 0.13090451f, 
    0.05439785f, -0.03688801f, 0.04802444f, -0.00945954f, -0.04123604f, -0.02944615f, 0.10274515f, 0.03984399f, 
    -0.04709249f, -0.04805656f, 0.08682761f, -0.02068490f, -0.57876354f, 0.01822915f, 0.00636263f, -0.02052381f, 
    -0.02666626f, -0.19131365f, -0.02189648f, 0.09570990f, 0.15274127f, 0.02539604f, -0.07255857f, -0.06861573f, 
    -0.55389148f, -0.09110808f, 0.03105376f, -0.14224902f, 0.03029457f, -0.07391997f, 0.04955246f, 0.01708145f, 
    0.07309223f, 0.17674936f, 0.06877953f, 0.02327465f, 0.04974347f, 0.04991239f, -0.07258338f, 0.27197996f, 
    -0.06264763f, 0.04804292f, 0.03888844f, 0.03775364f, 0.06201299f, 0.08034198f, 0.06608457f, 0.02244243f, 
    -0.30887157f, -0.06607264f, -0.11891329f, -0.14313756f, -0.07154597f, 0.15694979f, 0.10401878f, 0.02304781f, 
    0.00206022f, 0.08273319f, -0.05234004f, 0.09812268f, -0.11080352f, 0.08514418f, 0.05629935f, 0.14251824f, 
    -0.04806910f, -0.06377362f, -0.03917568f, -0.14171267f, 0.01558817f, -0.13429050f, -0.00184822f, -0.12597910f, 
    -0.17145686f, 0.16224642f, -0.34784794f, -0.53338212f, -0.03861766f, 0.17569411f, 0.00078499f, 0.00014179f, 
    -0.00901823f, -0.09575094f, 0.06734079f, -0.04413929f, 0.35045773f, -0.01145560f, -0.05354833f, 0.00199070f, 
    0.07329939f, 0.01174676f, 0.01431965f, 0.04924520f, -0.01506915f, 0.08574326f, -0.05288558f, 0.02410132f, 
    0.00977291f, 0.10222883f, -0.05576343f, 0.17323011f, -0.02458681f, -0.05314504f, 0.03825842f, -0.01703358f, 
    -0.07604198f, 0.03715510f, 0.07165862f, -0.00339854f, 0.11341205f, 0.10086894f, 0.07290121f, -0.01446269f, 
    0.06227678f, -0.11715198f, -0.01609407f, 0.03287549f, 0.09081592f, -0.05471897f, 0.08249716f, -0.15724102f, 
    -0.02794940f, -0.20688392f, 0.03995656f, 0.30440629f, -0.04688863f, 0.00570525f, -0.05816903f, 0.07951947f, 
    -0.03790725f, -0.00289932f, -0.06604175f, -0.03915241f, -0.49483442f, 0.04350819f, 0.00140877f, -0.11495345f, 
    -0.04872902f, -0.01235557f, -0.04174086f, -0.11912361f, -0.05690510f, 0.12642668f, -0.04121953f, -0.02541062f, 
    -0.02408313f, 0.16238676f, -0.02063295f, -0.08261638f, -0.02242416f, 0.03359320f, -0.09875561f, -0.03248566f, 
    0.03695510f, -0.01175614f, 0.01221371f, 0.08383981f, 0.20509391f, -0.22671136f, 0.13194056f, 0.05363765f, 
    -0.09331545f, 0.05680098f, -0.01894296f, 0.08911614f, 0.01638520f, -0.10001545f, -0.14439514f, 0.01192918f, 
    0.08051225f, 0.02102271f, 0.08545849f, 0.20181656f, -0.02675642f, -0.01445842f, -0.02473688f, -0.00949123f, 
    0.01647231f, 0.07872505f, 0.06284394f, 0.09700748f, 0.15212299f, 0.02799434f, 0.15169632f, 0.22653541f, 
    -0.06115557f, 0.02194683f, 0.06123845f, 0.06036219f, 0.11008245f, -0.04850111f, -0.06924827f, 0.07080424f, 
    0.32290015f, 0.00329838f, 0.07757320f, 0.03672675f, -0.00231496f, -0.03417030f, 0.00259740f, 0.00027093f, 
    0.07703183f, 0.03334963f, -0.06880127f, 0.05752014f, 0.22097255f, -0.02515608f, -0.05795316f, 0.13877507f, 
    0.04503151f, 0.03027614f, -0.09068589f, 0.03112939f, 0.17946364f, 0.06650069f, -0.05210762f, 0.02632934f, 
    0.00640108f, -0.04502299f, -0.04527011f, 0.05383448f, 0.01627963f, -0.03963172f, -0.03029389f, -0.02615491f, 
    0.09322321f, -0.06463651f, -0.02054661f, 0.07564779f, 0.02205084f, -0.09397469f, -0.02984240f, 0.05209850f, 
    0.10718977f, 0.04737997f, -0.07497171f, -0.10755925f, 0.05312850f, 0.06452736f, -0.06385294f, -0.06393659f, 
    -0.06976232f, 0.08084735f, -0.01331750f, -0.01460545f, -0.05064372f, 0.00296344f, -0.00600317f, 0.08366460f, 
    -0.11802222f, -0.04456355f, 0.03182492f, -0.10592236f, 0.16594738f, -0.09298382f, 0.02033604f, 0.09577456f, 
    -0.01021708f, -0.01424345f, -0.02811988f, 0.01871307f, -0.00574160f, -0.07742424f, 0.01970416f, -0.11966541f, 
    0.11325802f, -0.07163475f, -0.17819491f, -0.05832092f, -0.01468898f, -0.08721900f, 0.05694584f, 0.13052058f, 
    -0.03885787f, -0.07256166f, -0.00507193f, -0.04511366f, 0.10507429f, 0.05122474f, -0.09007555f, -0.06764843f, 
    -0.13999215f, -0.03050321f, 0.02661894f, 0.03408039f, 0.06936091f, -0.14245880f, 0.03748213f, 0.09629271f, 
    0.12415905f, 0.01774266f, 0.15230416f, -0.10556014f, -0.07018110f, -0.08838370f, 0.03386861f, -0.06563249f, 
    -0.04745496f, 0.02022989f, -0.04203013f, -0.01488205f, -0.20006059f, -0.07834029f, -0.19480985f, -0.00096098f, 
    0.08541740f, 0.05066527f, -0.02986565f, 0.03540673f, -0.00250455f, -0.12578684f, -0.18658872f, -0.13598534f, 
    0.28136224f, -0.04754858f, 0.12317882f, 0.06397330f, -0.14602412f, 0.01863443f, 0.05513447f, 0.05184644f, 
    -0.04302384f, -0.04581138f, 0.10350861f, -0.07960207f, 0.05209833f, 0.10197727f, -0.19980240f, -0.00228204f, 
    0.14019831f, 0.07218646f, -0.06112714f, 0.05580767f, 0.05481186f, 0.07733713f, -0.03453479f, 0.10461478f, 
    0.25962868f, -0.12948081f, -0.06945493f, -0.03872688f, -0.03181339f, -0.00233058f, -0.11145665f, -0.04750130f, 
    -0.05430877f, -0.18297793f, -0.04063454f, -0.03191783f, 0.03725232f, -0.01559215f, -0.05775538f, 0.02513236f, 
    0.03042878f, 0.13387349f, -0.03833712f, 0.01905565f, 0.00388330f, 0.14517589f, 0.01546673f, 0.11441309f, 
    0.00861736f, -0.04958316f, -0.06738867f, 0.14517240f, 0.08237302f, 0.09517929f, -0.03299114f, 0.13178760f, 
    -0.10669536f, 0.01705408f, -0.04527730f, -0.07141659f, 0.15282939f, 0.06661533f, 0.05070582f, 0.13747379f, 
    0.06650861f, -0.01316957f, -0.03769507f, 0.03720490f, -0.08161902f, -0.01827803f, -0.02314912f, 0.02847720f, 
    0.26485196f, -0.08402572f, 0.07586211f, -0.06017491f, 0.02960408f, -0.13984293f, -0.16206892f, 0.04347196f, 
    -0.12715389f, 0.00651622f, -0.16188887f, -0.04342402f, 0.31755161f, -0.09549152f, -0.05824374f, -0.13683483f, 
    0.03052380f, -0.07201137f, 0.01342352f, 0.06407041f, -0.00686852f, -0.08293033f, -0.10400914f, -0.14782688f, 
    0.15016045f, 0.11908925f, -0.00353008f, 0.06241538f, -0.02643440f, -0.03865316f, -0.06802833f, 0.01668619f, 
    -0.09011156f, -0.00579995f, 0.05184182f, -0.07202413f, -0.09175944f, 0.11243387f, -0.33468324f, 0.11082255f, 
    -0.04370987f, 0.01982683f, -0.04796530f, -0.05602668f, -0.00461306f, -0.08620042f, 0.00880077f, -0.04304885f, 
    0.07123550f, 0.03057285f, -0.17568392f, -0.01313633f, 0.10064633f, 0.12535107f, -0.08613668f, -0.00823327f, 
    -0.01741884f, 0.03274247f, -0.07298208f, -0.01510529f, 0.08060205f, -0.04378619f, -0.09977031f, -0.12093402f, 
    -0.00160983f, -0.16512719f, 0.09581934f, -0.04331077f, -0.02812477f, -0.01985713f, -0.12182332f, 0.01479728f, 
    -0.15758914f, -0.21906991f, -0.08903775f, -0.10280879f, -0.04404939f, -0.04789412f, -0.05148819f, 0.10130141f, 
    0.07033057f, 0.04794832f, 0.05085501f, -0.12656140f, 0.26070982f, -0.12386128f, 0.07111999f, -0.15577129f, 
    0.05629252f, -0.13332884f, -0.16826183f, -0.02180706f, -0.17876485f, -0.17760931f, -0.08152917f, -0.07833394f, 
    0.04879010f, -0.23666793f, -0.16787942f, -0.09853769f, -0.06173047f, 0.06820069f, -0.03382749f, 0.16696964f, 
    -0.03483360f, 0.07746256f, 0.00451955f, 0.01853957f, 0.25490281f, 0.05104976f, 0.10346346f, 0.13409980f, 
    0.01964242f, -0.02942488f, 0.11157898f, -0.05305606f, -0.12399802f, -0.08480824f, -0.12821059f, -0.04887474f, 
    0.13649121f, -0.01022583f, -0.00486162f, 0.00361358f, -0.16909614f, -0.00394867f, 0.02673705f, 0.03278084f, 
    0.03368399f, -0.05714928f, 0.14477868f, -0.03799967f, 0.17180713f, -0.10138674f, 0.02965061f, -0.29568842f, 
    0.02819503f, -0.02476990f, -0.07405236f, -0.04555546f, 0.08175809f, -0.06976760f, -0.06754701f, 0.14637272f, 
    0.18658236f, 0.03367858f, 0.06931569f, 0.12150673f, -0.02236246f, -0.06922402f, 0.03389886f, 0.03839983f, 
    0.04033428f, -0.07986648f, -0.09679468f, 0.03089067f, -0.04320241f, 0.01230695f, 0.11569146f, -0.05699855f, 
    -0.11332363f, 0.03409507f, -0.02753147f, -0.05469747f, 0.07996847f, 0.04078043f, 0.10887639f, -0.18195175f, 
    -0.16425356f, -0.05335188f, 0.03804003f, 0.00044289f, 0.00750206f, -0.06107822f, 0.02908750f, -0.07258122f, 
    0.00049635f, 0.00807782f, 0.06140845f, 0.10709565f, 0.17846946f, 0.04439813f, 0.18247029f, 0.11621389f, 
    -0.06200608f, -0.16331133f, 0.00422080f, 0.00082284f, -0.02278977f, -0.02958284f, 0.09768222f, 0.07084316f, 
    -0.18807454f, -0.08560478f, -0.07528280f, -0.06687909f, 0.02784470f, -0.08979787f, 0.04220769f, 0.03435134f, 
    0.07972393f, 0.03199853f, -0.00550838f, -0.04080537f, -0.23325719f, -0.16447879f, -0.01780643f, -0.11005538f, 
    0.02615306f, -0.06895817f, 0.03800721f, 0.02958946f, 0.00046900f, -0.10433477f, -0.04098510f, 0.00045554f, 
    0.19830263f, -0.02150533f, 0.09672963f, 0.08649906f, -0.14935002f, 0.02605103f, -0.04389848f, 0.03720447f, 
    0.04579003f, 0.03439483f, -0.12050701f, 0.07629342f, -0.60939908f, 0.01513195f, -0.11437026f, 0.12639233f, 
    -0.24865550f, 0.03089808f, -0.08600838f, -0.12230158f, 0.16569746f, 0.00460457f, -0.00145981f, 0.07921660f, 
    -0.06307219f, 0.03579276f, 0.10546298f, -0.12925297f, 0.03203056f, 0.04101939f, 0.05920395f, 0.06361502f, 
    -0.01543499f, 0.08836752f, 0.04720243f, -0.02149486f, 0.14025772f, -0.01804833f, 0.01696786f, -0.01995270f, 
    0.14343216f, -0.07960418f, -0.00291895f, -0.03590253f, -0.10042651f, -0.08902946f, -0.05338744f, -0.01148908f, 
    -0.27435625f, 0.11224854f, 0.04000160f, 0.13553981f, 0.01614302f, -0.06259970f, 0.10148604f, 0.01310357f, 
    -0.00192531f, -0.02323495f, -0.08559719f, 0.05029549f, 0.19713241f, 0.07361443f, -0.24375640f, -0.01931681f, 
    0.15598765f, 0.08536626f, 0.04674596f, -0.06487478f, -0.04683365f, -0.06881512f, -0.05520887f, -0.17838915f, 
    0.07756381f, -0.02388343f, -0.06349650f, -0.00704988f, 0.04260432f, -0.03341326f, 0.01624133f, 0.02275286f, 
    0.04246391f, 0.07375202f, 0.04907341f, -0.09406932f, 0.07778060f, 0.04805006f, 0.12821715f, 0.17537488f, 
    -0.05882350f, -0.16564333f, 0.08240609f, 0.00015059f, -0.01927440f, -0.05327882f, -0.00375601f, -0.02400330f, 
    -0.25562426f, 0.05455956f, -0.08607561f, -0.17584281f, -0.09829178f, 0.06634891f, -0.01737223f, -0.03554939f, 
    0.07160096f, -0.16499665f, -0.04914046f, -0.04797427f, -0.35955057f, -0.08312303f, -0.11562210f, -0.03897196f, 
    0.07132368f, -0.01220035f, -0.01447843f, -0.00873000f, -0.03875533f, -0.00916653f, -0.02604614f, -0.00260997f, 
    -0.09558626f, 0.13920392f, 0.11167753f, 0.08094826f, -0.14203073f, -0.09773872f, 0.00922034f, -0.00926434f, 
    -0.04216930f, -0.05470547f, -0.11480871f, 0.03405169f, 0.02086053f, 0.05131414f, 0.00612135f, 0.08205020f, 
    0.02411378f, -0.08416197f, 0.08321565f, 0.02491993f, -0.05839396f, 0.07179637f, 0.04405382f, -0.02679103f, 
    -0.19942020f, -0.01117017f, 0.02100463f, -0.18356593f, 0.04427655f, -0.08048717f, -0.06444816f, -0.01338351f, 
    0.01576874f, -0.08441947f, -0.04129592f, 0.02814589f, -0.22583076f, -0.01454630f, 0.01430479f, -0.27559695f, 
    -0.05564256f, -0.10797600f, 0.03258754f, 0.00446797f, -0.03252637f, -0.01035569f, -0.00258884f, -0.07383946f, 
    -0.38444778f, -0.28143454f, 0.01510724f, -0.13365315f, 0.06704021f, -0.06467816f, 0.00631379f, -0.06603847f, 
    -0.02708958f, 0.01519109f, -0.03284266f, 0.02346089f, 0.19654900f, 0.01769064f, 0.23743293f, 0.06590862f, 
    -0.03515710f, 0.05995421f, 0.08370459f, -0.01670606f, -0.06633598f, 0.05566468f, 0.02871008f, -0.01817729f, 
    0.06043691f, 0.22107506f, -0.09654520f, -0.08847065f, 0.13078603f, 0.02536072f, -0.03255780f, 0.01341339f, 
    -0.11067525f, 0.04887127f, 0.00003086f, -0.01804697f, -0.30765539f, -0.00666829f, 0.11485174f, 0.00592275f, 
    0.00890428f, -0.00912275f, -0.12008827f, -0.00360053f, 0.08895289f, -0.03645063f, 0.02290904f, 0.00708472f, 
    -0.27495405f, -0.17859943f, 0.07932469f, -0.18278345f, 0.02709347f, -0.01109875f, -0.23580417f, 0.04840281f, 
    -0.06292749f, -0.03884779f, -0.04795102f, -0.12077054f, -0.09789637f, -0.00559179f, -0.08816607f, -0.13543926f, 
    -0.05720604f, 0.04135435f, -0.04351941f, 0.08669792f, -0.00603252f, 0.05134021f, 0.02659649f, -0.07488005f, 
    0.08899599f, -0.04422141f, -0.19344470f, -0.08918921f, 0.02157104f, 0.02155578f, -0.04192281f, -0.11943424f, 
    -0.00394622f, 0.01738680f, -0.03426093f, -0.08206029f, 0.25608152f, -0.01325359f, 0.04708005f, 0.05546829f, 
    -0.08707827f, -0.00758796f, -0.02969358f, 0.03663233f, -0.00386909f, -0.04552503f, -0.02418578f, 0.01000301f, 
    0.03355407f, 0.00736652f, 0.02883831f, -0.02325903f, -0.07848868f, 0.06128280f, 0.03443772f, -0.05138357f, 
    0.00366138f, -0.00630783f, -0.08836252f, -0.00771523f, -0.11949305f, 0.12181894f, -0.02928568f, -0.02090901f, 
    0.02285667f, 0.11252192f, 0.01576215f, 0.01666340f, -0.02738366f, 0.12195089f, -0.05284039f, 0.06915189f, 
    -0.00030496f, 0.13431309f, -0.13238081f, -0.07280830f, 0.07864762f, 0.06273415f, 0.01642648f, -0.03093230f, 
    0.04730447f, 0.05101857f, -0.06538730f, -0.10395740f, 0.35186026f, 0.18766829f, -0.10421453f, 0.02368526f, 
    0.04542277f, 0.04659576f, -0.01121531f, -0.05737129f, -0.17315529f, 0.00547617f, -0.01940914f, 0.02379543f, 
    0.20798481f, 0.13049129f, -0.12800701f, -0.02204643f, 0.04350682f, 0.07560664f, 0.03697919f, -0.02066236f, 
    -0.07401867f, 0.01295966f, -0.07177933f, -0.10206377f, 0.49464312f, -0.14697106f, 0.01545627f, -0.19490118f, 
    0.04580335f, -0.08378521f, 0.04188747f, 0.02276655f, -0.01663839f, -0.05277353f, 0.14641926f, -0.10625734f, 
    0.05049279f, 0.08863359f, -0.03058252f, 0.06282187f, 0.00653611f, 0.02804103f, 0.01642978f, 0.00145018f, 
    -0.11876810f, -0.04750563f, -0.02527844f, -0.06413167f, -0.13534112f, 0.00925925f, -0.04214377f, -0.05839468f, 
    0.18550223f, -0.01660683f, 0.01663468f, -0.03805157f, 0.03203539f, 0.09152143f, -0.04947462f, 0.06188273f, 
    0.26829845f, -0.12541911f, -0.04601145f, 0.16805482f, -0.17345297f, 0.00156897f, -0.08854064f, -0.09808917f, 
    0.01148792f, -0.00539341f, 0.10514348f, 0.04219245f, 0.00218717f, -0.08526438f, -0.05441763f, 0.00510493f, 
    -0.00142403f, 0.00361659f, 0.09344970f, -0.06618222f, 0.04930062f, 0.01438002f, 0.09790239f, 0.00929882f, 
    0.09660811f, 0.01772831f, 0.12756637f, 0.03020127f, -0.17359063f, 0.04337945f, 0.01868612f, 0.00692850f, 
    0.00538251f, -0.06738367f, -0.07694948f, -0.04543473f, 0.02180920f, 0.09884718f, 0.02704099f, -0.10479964f, 
    -0.04172910f, 0.06720281f, 0.04880526f, 0.13428533f, 0.06523569f, -0.04141816f, 0.05540564f, -0.00870022f, 
    0.03554663f, 0.09916948f, -0.05031002f, 0.01049299f, -0.10191070f, -0.14789051f, 0.02906498f, -0.02103481f, 
    -0.02026596f, -0.00530325f, -0.11059141f, 0.00185394f, -0.05816725f, -0.17470245f, 0.12503988f, -0.09791051f, 
    0.05083264f, -0.02159925f, -0.00690853f, -0.02812007f, 0.02013994f, 0.01390285f, -0.02657132f, -0.02044215f, 
    -0.43206277f, 0.08447538f, 0.06255992f, -0.08166448f, 0.00324571f, 0.03731748f, 0.05519069f, -0.04593854f, 
    0.02502507f, -0.05366232f, 0.02705853f, -0.01473696f, -0.04640837f, 0.17751092f, -0.04741317f, -0.17543077f, 
    -0.00019741f, 0.02246155f, -0.00680059f, -0.00040379f, 0.04584160f, 0.07399529f, 0.01691834f, -0.09514794f, 
    0.14398682f, 0.03345498f, 0.07228576f, -0.10902080f, -0.01430102f, -0.11792917f, 0.06835096f, 0.00181858f, 
    -0.10438561f, 0.00626701f, 0.16812927f, -0.04080270f, -0.05544063f, -0.08662715f, -0.32832557f, -0.15251631f, 
    -0.00530078f, 0.09775589f, 0.00729078f, -0.03687623f, -0.03636543f, 0.01688904f, 0.12011232f, 0.02843339f, 
    0.05195159f, -0.19305268f, 0.04076269f, 0.00193436f, 0.06093712f, 0.05602704f, -0.05083435f, -0.09622942f, 
    0.02117816f, 0.10146583f, -0.01717430f, 0.04269344f, 0.21273629f, -0.11828097f, -0.25346676f, 0.09204262f, 
    -0.03122104f, -0.08653168f, -0.12832886f, -0.03277951f, -0.12300108f, -0.06113152f, -0.06815103f, -0.10348379f, 
    0.37102145f, 0.11738002f, -0.10962479f, 0.15445817f, -0.21194109f, -0.04496957f, 0.07369231f, 0.11661613f, 
    -0.04331986f, 0.13264038f, 0.05502247f, 0.03474257f, -0.10514244f, -0.00692072f, -0.18940641f, -0.00884986f, 
    0.00987610f, 0.00851676f, 0.02278404f, -0.13069040f, -0.04943050f, -0.12087633f, 0.08741131f, -0.08479075f, 
    0.12375395f, 0.11142171f, -0.11693140f, 0.08450744f, -0.13669884f, -0.09079105f, -0.00361010f, 0.04539528f, 
    0.01449480f, 0.11672799f, -0.10396233f, -0.08239619f, 0.13998659f, -0.07031243f, 0.05408834f, -0.07223184f, 
    0.03668741f, -0.02533932f, 0.01564661f, 0.06507626f, -0.10033637f, -0.03118108f, -0.00932026f, 0.00134718f, 
    -0.09408001f, -0.15526727f, 0.15335898f, -0.12846653f, 0.05097258f, 0.05431961f, 0.01784134f, -0.00261266f, 
    0.04722673f, -0.06064551f, 0.12794985f, 0.01226600f, 0.11907031f, 0.10064988f, 0.08310347f, 0.17482026f, 
    -0.02529252f, -0.10095002f, 0.08349165f, 0.04096313f, -0.11023701f, 0.03093029f, -0.01261604f, 0.08196931f, 
    0.07816580f, -0.15066700f, 0.08396327f, -0.05672383f, 0.06695345f, 0.04558987f, -0.03521276f, -0.11547790f, 
    -0.00621479f, -0.04899207f, -0.08655964f, 0.10993461f, 0.35162848f, -0.22590363f, -0.04136028f, -0.01534309f, 
    -0.13393822f, 0.02281580f, 0.01194502f, 0.02890611f, 0.13147011f, 0.01171059f, -0.04903946f, -0.04405217f, 
    0.00810891f, -0.07570586f, -0.03866735f, -0.00264362f, -0.02666284f, 0.02854349f, -0.06507704f, -0.01399848f, 
    -0.05064303f, -0.16617644f, -0.09757093f, 0.00503775f, -0.24275418f, 0.00475189f, 0.06222009f, -0.22501323f, 
    -0.01987944f, 0.00757255f, 0.06608464f, -0.06636723f, -0.01326998f, 0.06936855f, 0.00978692f, -0.08567365f, 
    -0.42978036f, -0.09599639f, -0.10876072f, -0.28768110f, -0.07431520f, -0.02092046f, -0.06792571f, 0.03230740f, 
    -0.02020270f, 0.05846613f, -0.12748580f, 0.03002163f, 0.15554217f, -0.04818584f, 0.05467096f, -0.07450398f, 
    0.03580130f, 0.00611896f, -0.01898589f, 0.03260732f, -0.10578957f, 0.06547142f, 0.09294582f, 0.11513700f, 
    0.06732815f, 0.03404026f, -0.24244364f, -0.25531688f, -0.01064215f, 0.06259561f, -0.03480090f, 0.00954199f, 
    0.02513362f, 0.07484445f, -0.10014822f, -0.11768150f, 0.21255191f, 0.04370577f, 0.06224534f, -0.07179175f, 
    0.08101974f, -0.02578405f, 0.06738829f, -0.00162499f, -0.00851229f, 0.03049357f, 0.02714660f, 0.01963281f, 
    -0.15595761f, -0.05572946f, 0.00898233f, -0.12468726f, 0.10420261f, 0.10502642f, -0.05748485f, 0.02398008f, 
    -0.03702537f, -0.00892971f, -0.05121935f, -0.11615257f, -0.44037235f, -0.12954392f, 0.04979328f, -0.07330123f, 
    0.02989193f, 0.10300764f, 0.03543924f, -0.08055988f, -0.03871302f, -0.02872987f, 0.05433030f, -0.07241689f, 
    -0.01314435f, 0.06987020f, -0.03453115f, -0.00951676f, -0.05160184f, 0.01410074f, 0.06417605f, 0.07425106f, 
    -0.08637719f, 0.07402091f, 0.04139519f, -0.02374392f, -0.12062567f, 0.02873069f, 0.10195718f, -0.09842356f, 
    -0.09501989f, 0.12143719f, -0.00042201f, 0.07166903f, 0.03147640f, 0.07941018f, -0.12743650f, -0.01131262f, 
    0.05594334f, 0.07967030f, -0.18637072f, 0.11452346f, 0.01534847f, 0.10115425f, -0.06580821f, 0.00341039f, 
    -0.11766957f, -0.08946340f, -0.02373715f, -0.05614926f, 0.09427258f, 0.02247473f, -0.01628530f, -0.00826392f, 
    0.02892588f, 0.07022592f, 0.02278858f, 0.07628150f, -0.09799502f, -0.03899807f, 0.01306428f, -0.01735141f, 
    0.17038150f, 0.21883874f, 0.17070110f, 0.13643740f, -0.14010747f, -0.03864560f, 0.06795343f, 0.16386040f, 
    -0.07124767f, 0.00336921f, 0.02457407f, -0.11897727f, -0.32375732f, 0.09020904f, -0.14045189f, -0.00735807f, 
    0.03647993f, 0.00242210f, 0.05606796f, -0.05358338f, 0.00810224f, 0.05866630f, 0.04288013f, 0.01269466f, 
    -0.04999610f, -0.05705319f, 0.02000482f, -0.07415150f, 0.12520039f, -0.11143488f, 0.05396703f, 0.01988739f, 
    0.02688850f, 0.01317497f, -0.01486678f, -0.00137290f, 0.35815617f, -0.03669300f, -0.26673329f, -0.17449285f, 
    -0.17382582f, 0.03797805f, 0.00474438f, 0.08920379f, 0.13327672f, 0.01828059f, -0.02342911f, -0.12618642f, 
    0.17143352f, -0.08693697f, -0.21653458f, -0.10756278f, 0.14081003f, -0.05722164f, 0.04161063f, -0.06399103f, 
    -0.05225217f, -0.02562083f, -0.04153297f, -0.05787683f, -0.01794523f, 0.08944827f, -0.07247829f, 0.02671670f, 
    0.07362102f, 0.14001526f, 0.05795765f, 0.01980319f, -0.01805828f, 0.06055158f, -0.01571834f, -0.08028945f, 
    -0.11256499f, 0.10207055f, -0.19331206f, -0.00187712f, -0.09217712f, -0.04200767f, -0.01867962f, -0.11020461f, 
    -0.05279690f, 0.05262996f, -0.06067447f, 0.04771293f, -0.02515225f, 0.07894590f, 0.10849496f, 0.18265212f, 
    0.11662754f, 0.07423334f, 0.03727209f, 0.04115479f, -0.06715351f, 0.00612965f, 0.06817312f, -0.25229123f, 
    0.03390803f, -0.26143390f, -0.33088660f, 0.15157448f, -0.06845121f, -0.01681788f, -0.02458373f, -0.05397572f, 
    -0.01172814f, -0.03849314f, -0.05755843f, 0.01943679f, 0.10254465f, -0.17164157f, -0.02485735f, 0.01511784f, 
    -0.06564787f, -0.00340284f, -0.04823012f, -0.01677779f, -0.11679753f, -0.00329008f, -0.03725505f, 0.05845379f, 
    0.16587445f, -0.10796185f, 0.02930018f, -0.00809624f, -0.03134089f, 0.07271969f, -0.02145489f, 0.04121272f, 
    0.00950178f, 0.05219117f, -0.02435525f, -0.05937356f, 0.03805936f, -0.02653085f, 0.11556716f, 0.00928407f, 
    -0.06419389f, 0.01926299f, 0.03401940f, -0.01574423f, 0.00153094f, 0.05888781f, -0.09778584f, 0.12840211f, 
    0.05267119f, -0.01875751f, -0.19078560f, 0.03348274f, -0.07588403f, 0.00871697f, 0.03511329f, 0.04715362f, 
    -0.09872281f, -0.05847081f, 0.09021349f, -0.04957690f, 0.03068950f, -0.21032919f, -0.03041549f, 0.05064305f, 
    -0.10225425f, 0.12854998f, 0.06328005f, 0.01014757f, -0.10130938f, 0.02682539f, -0.04717403f, 0.03328847f, 
    0.11063949f, 0.03103484f, 0.11654427f, -0.15579273f, 0.00115527f, -0.12874182f, 0.00787203f, 0.07322879f, 
    0.01762054f, 0.00394231f, 0.01215706f, -0.00631071f, -0.07682678f, -0.02643112f, -0.02352546f, 0.01167616f, 
    -0.01190794f, -0.03947600f, -0.01269104f, 0.10841744f, -0.02859245f, 0.01731414f, 0.08176386f, 0.06802016f, 
    0.08666416f, 0.06258509f, 0.09497450f, 0.02074650f, -0.10784301f, -0.07870549f, 0.03361364f, -0.04777599f, 
    0.08009917f, 0.09326252f, -0.05469477f, 0.03247544f, -0.30674428f, 0.15916738f, -0.00796415f, -0.16880846f, 
    -0.00455939f, 0.10795372f, -0.06360798f, 0.10661950f, 0.04880672f, -0.06923735f, -0.01136482f, -0.01280483f, 
    0.25091016f, 0.21013880f, 0.03446267f, -0.10780593f, -0.08136758f, 0.06644342f, 0.06646194f, 0.11363672f, 
    0.09981018f, -0.12143764f, -0.03293574f, -0.00946081f, -0.30095205f, -0.27090591f, 0.08338027f, 0.06264368f, 
    -0.14304766f, 0.10898092f, 0.04433168f, -0.10428751f, 0.02587416f, -0.00090996f, 0.02146843f, -0.01782353f, 
    0.22391987f, -0.03074268f, 0.04599733f, 0.25380930f, 0.11490814f, 0.03513677f, 0.03907951f, -0.02388847f, 
    -0.01251711f, -0.12525266f, -0.10007395f, -0.07741189f, 0.29340562f, -0.15331079f, -0.15001468f, 0.14115700f, 
    -0.03092059f, 0.01827466f, 0.09771635f, 0.04390180f, 0.06368647f, 0.07435915f, 0.03597317f, 0.10904545f, 
    0.05778087f, 0.15000278f, 0.13290645f, 0.02587075f, 0.04338105f, 0.02819544f, -0.00958453f, 0.16559684f, 
    0.01010171f, 0.09344814f, -0.12424193f, -0.00170740f, 0.00810252f, -0.01560872f, -0.03601775f, 0.11195067f, 
    -0.11197784f, -0.10012504f, 0.02675555f, -0.05627543f, -0.02237747f, -0.00939638f, -0.07934640f, -0.06213577f, 
    -0.06912467f, 0.01382969f, 0.09637676f, -0.01982816f, -0.03547569f, -0.00256943f, 0.00583342f, 0.01061695f, 
    -0.00450084f, 0.02991699f, -0.00292592f, 0.03769701f, -0.30267456f, 0.00646889f, 0.02030017f, 0.13613071f, 
    -0.01838982f, 0.03816814f, 0.04505394f, -0.01812953f, -0.09627482f, -0.04903793f, -0.09042934f, 0.03513407f, 
    0.00754582f, 0.08083569f, 0.17940004f, 0.12105185f, -0.07060681f, 0.08441509f, 0.09347584f, 0.00711163f, 
    -0.03995181f, 0.14364162f, 0.02224895f, 0.04522910f, 0.54396915f, 0.38958061f, 0.04748758f, -0.11958757f, 
    0.07665849f, -0.05160994f, -0.04970001f, 0.05148816f, -0.02266447f, -0.14713831f, 0.02413944f, -0.00115646f, 
    -0.68936706f, 0.11193165f, 0.15492859f, 0.15782902f, -0.03242575f, 0.07594225f, 0.09854620f, -0.02948572f, 
    0.03151433f, -0.00515861f, -0.05572108f, 0.02031885f, -0.12021004f, 0.07568375f, 0.20824553f, 0.17531472f, 
    0.07877906f, 0.13325444f, 0.03343475f, -0.05501803f, -0.05736515f, 0.06216159f, 0.07733161f, -0.05306732f, 
    -0.26623553f, -0.30202767f, -0.13781390f, 0.28451741f, -0.05356558f, 0.04704830f, 0.00332838f, -0.09605026f, 
    0.00098622f, -0.07168081f, 0.01374614f, -0.03421883f, -0.52983034f, -0.62452042f, 0.01381684f, 0.02179074f, 
    -0.06109958f, 0.00395957f, 0.01208216f, -0.03176198f, 0.00429536f, -0.19581534f, 0.10467146f, 0.01173614f, 
    0.19000073f, 0.05605454f, -0.00389382f, -0.00099512f, -0.17870578f, -0.21394895f, 0.06251095f, 0.07691126f, 
    -0.03457232f, -0.08108985f, -0.01202119f, -0.05910467f, -0.29486096f, 0.05209021f, -0.12596171f, -0.11565091f, 
    -0.09049743f, 0.00536393f, 0.02330258f, -0.13473094f, -0.04041411f, 0.10144932f, 0.03751210f, -0.06125502f, 
    0.04243108f, -0.10145232f, -0.00183135f, -0.08257523f, -0.12708369f, 0.05777194f, 0.03243388f, -0.01112055f, 
    0.01298319f, -0.00476329f, 0.03163387f, -0.10981870f, -0.14217186f, -0.32165012f, -0.00141011f, -0.04544313f, 
    0.03230643f, 0.05574713f, -0.09499148f, -0.06534332f, 0.04413797f, 0.09582599f, 0.06206859f, -0.01898784f, 
    0.07244206f, 0.00925741f, -0.03953781f, -0.03419270f, -0.07880463f, -0.15088071f, 0.03316594f, 0.02486710f, 
    -0.01596704f, -0.00527944f, -0.06060034f, 0.02086155f, 0.25082943f, -0.19935761f, -0.14880964f, 0.11693904f, 
    -0.03495503f, 0.02911292f, 0.03898692f, -0.04882252f, 0.03323798f, -0.10436863f, -0.08746226f, 0.08337149f, 
    -0.01578801f, -0.13356727f, -0.06489287f, -0.03368003f, -0.01043802f, 0.05277391f, 0.03339335f, -0.05430738f, 
    0.02703932f, 0.11138117f, 0.00533837f, 0.06858943f, -0.43099260f, 0.22141971f, -0.26396203f, 0.12403832f, 
    -0.00812744f, 0.02743209f, 0.01981117f, 0.00213250f, 0.02464790f, 0.09675165f, 0.04410075f, -0.07879132f, 
    -0.13971849f, -0.22559844f, -0.04705670f, 0.05485056f, -0.05585729f, 0.02909278f, 0.03847498f, 0.02946537f, 
    -0.11671208f, 0.03231429f, 0.01900598f, 0.02676269f, -0.07136624f, 0.32037294f, -0.04500317f, 0.06964613f, 
    0.01895275f, 0.12053884f, 0.06049258f, 0.07064351f, -0.02264899f, 0.04531565f, 0.09317379f, -0.03242259f, 
    0.12518577f, -0.27903777f, -0.18163653f, 0.05830397f, -0.03830477f, -0.01072204f, -0.07813541f, -0.10677380f, 
    0.03833256f, -0.03670932f, -0.01081600f, 0.08900830f, -0.36118954f, 0.21028891f, 0.02729153f, 0.09708190f, 
    0.03625901f, 0.01877540f, 0.10939831f, 0.01667369f, 0.00909306f, -0.11156075f, -0.04991091f, -0.15028088f, 
    -0.01088655f, -0.05398401f, -0.00315400f, 0.04638399f, -0.07976256f, -0.12070692f, 0.02490589f, 0.01950973f, 
    -0.10963005f, 0.00674684f, -0.01142522f, 0.05095746f, 0.00409713f, 0.02244196f, 0.06961042f, 0.00676622f, 
    -0.09277398f, -0.05109972f, 0.03685130f, 0.00000746f, 0.04701460f, -0.00043647f, -0.06766137f, -0.10416938f, 
    0.23067860f, 0.11941363f, 0.02457724f, -0.02081610f, -0.01699863f, 0.05893441f, 0.03193710f, -0.07475603f, 
    -0.01995998f, 0.05375348f, 0.06311770f, 0.01438506f, -0.33418208f, -0.19920568f, -0.04816145f, -0.23010395f, 
    -0.13692230f, 0.01468640f, -0.01121969f, 0.00803933f, 0.02198402f, -0.02273430f, 0.06178375f, -0.02986088f, 
    0.03518534f, -0.01128828f, 0.03320117f, 0.06711403f, -0.06815340f, 0.09415738f, -0.04013638f, -0.16766737f, 
    -0.03658754f, 0.02625188f, 0.03646765f, -0.05047676f, -0.10648833f, -0.09579955f, -0.01510213f, -0.04948870f, 
    0.04734842f, 0.08071198f, -0.04295302f, 0.03219730f, -0.03887089f, 0.05484542f, -0.04823184f, 0.05860846f, 
    -0.00553259f, -0.29341158f, 0.02722533f, 0.05602936f, -0.07271048f, 0.02897996f, -0.10809550f, -0.01408125f, 
    0.04949647f, -0.07833174f, -0.01162086f, 0.00693382f, 0.01011714f, 0.09543584f, 0.11614955f, 0.00020696f, 
    0.06726950f, -0.03990555f, -0.02975039f, 0.11731029f, -0.04316372f, 0.11723020f, -0.04976353f, 0.04901241f, 
    -0.07365847f, -0.02962202f, 0.03433787f, 0.20306028f, 0.04221729f, -0.02908548f, 0.08328064f, 0.02726604f, 
    0.00032712f, 0.01359059f, 0.04897092f, -0.03413911f, 0.01318943f, 0.05445461f, -0.03590843f, 0.12019548f, 
    -0.00178745f, 0.12736234f, 0.01395072f, -0.00031925f, 0.05450954f, 0.02173751f, 0.03171258f, -0.02093827f, 
    0.18329462f, 0.10351849f, 0.04275043f, 0.06177604f, -0.05160904f, -0.01600775f, 0.01060194f, 0.10490691f, 
    -0.01190118f, -0.04231822f, -0.05235339f, 0.07932299f, -0.13348651f, -0.00437031f, 0.03151601f, -0.07260866f, 
    -0.00212507f, -0.05143657f, -0.09249137f, -0.03859480f, -0.10225742f, -0.02795730f, -0.01250266f, 0.07933418f, 
    0.20041379f, -0.05516408f, 0.13514382f, -0.08621992f, 0.08926124f, -0.01549978f, 0.04568584f, -0.03220439f, 
    0.07259567f, 0.00295336f, 0.01682308f, -0.03113962f, -0.18437041f, -0.23333716f, -0.22192274f, -0.07966370f, 
    -0.00168447f, 0.09068638f, -0.05001905f, -0.00064358f, 0.02467325f, -0.01958274f, -0.05100084f, 0.01721475f, 
    0.06554126f, -0.51967835f, -0.23515271f, 0.05766848f, 0.01006407f, -0.10389695f, -0.01351109f, 0.07630745f, 
    0.03693644f, 0.05182913f, -0.08442836f, 0.01448683f, 0.07756794f, 0.12863395f, -0.00112128f, 0.08898349f, 
    -0.02448783f, 0.05668697f, -0.07469386f, -0.06325578f, -0.04132043f, 0.08181892f, -0.03400148f, -0.03349139f, 
    0.13257702f, -0.36903363f, -0.16050756f, -0.06966055f, -0.03672757f, 0.03566089f, 0.00557950f, 0.01498202f, 
    -0.05707815f, 0.04327948f, -0.02229475f, 0.05498176f, -0.19895013f, -0.26828387f, 0.00345548f, 0.19036521f, 
    0.07439378f, -0.00875284f, -0.05180212f, 0.04532648f, -0.00678614f, -0.03172556f, -0.17299999f, -0.03128039f, 
    -0.22561495f, -0.08744528f, -0.02555067f, 0.17944930f, 0.00686497f, 0.06004938f, 0.10018036f, 0.01308026f, 
    -0.06668910f, -0.01457377f, -0.05818222f, -0.14899181f, -0.40251252f, -0.04423462f, -0.25222600f, -0.04751626f, 
    -0.05766107f, -0.08615807f, 0.01067474f, -0.04807732f, -0.02527044f, -0.02900116f, 0.02139828f, -0.02086204f, 
    -0.04352868f, -0.13753055f, -0.05318080f, -0.31245837f, -0.00871115f, 0.06966066f, -0.08976157f, -0.04593072f, 
    0.03939327f, -0.00199179f, 0.01987389f, 0.01913392f, -0.10301986f, -0.04880046f, 0.01310382f, 0.08344157f, 
    -0.08453278f, -0.11396140f, 0.11208259f, -0.08064537f, -0.06995743f, 0.08575425f, 0.00426739f, 0.00994422f, 
    -0.16741702f, -0.39473227f, -0.02931926f, 0.02485376f, -0.04269642f, -0.03519737f, 0.00966622f, -0.04203300f, 
    -0.00543137f, -0.12448555f, 0.13350125f, 0.02037069f, 0.11933912f, -0.08574019f, 0.23835440f, -0.20218813f, 
    0.06573680f, -0.10640958f, 0.02840161f, 0.01991427f, -0.13179736f, 0.00253329f, -0.10899046f, 0.06503563f, 
    -0.16214627f, 0.21508634f, 0.12095681f, 0.03500407f, -0.03150363f, -0.04955352f, 0.01435234f, -0.04030609f, 
    0.00460236f, 0.00357014f, 0.10714261f, 0.02697005f, 0.10919696f, 0.06092934f, -0.12571146f, 0.09408543f, 
    -0.12656094f, -0.05914113f, 0.00003564f, -0.01344333f, 0.01213919f, -0.01508881f, -0.05500739f, 0.06466027f, 
    -0.14070916f, -0.28498861f, -0.15104821f, 0.11916943f, 0.05279807f, -0.06633345f, -0.01583207f, -0.08168411f, 
    -0.03642130f, 0.01320613f, -0.05345254f, -0.03972206f, -0.20628104f, -0.10045563f, 0.08055473f, 0.16776265f, 
    -0.07199200f, -0.03266250f, -0.00294027f, -0.10702576f, 0.02489707f, 0.01967537f, 0.00605432f, -0.06173134f, 
    0.06133750f, 0.09157652f, 0.12019864f, 0.03250626f, -0.13146776f, -0.03094419f, -0.01523371f, 0.01999541f, 
    0.11758696f, -0.05536683f, -0.09144459f, 0.06042663f, -0.18509555f, 0.19082624f, 0.05345583f, 0.08988824f, 
    -0.03880671f, 0.05491199f, 0.04010214f, -0.06140736f, 0.00844819f, 0.07577664f, 0.02389096f, 0.01305664f, 
    0.00207187f, 0.07471910f, 0.17750256f, -0.23545216f, 0.09156031f, 0.00109553f, -0.11770780f, 0.03209058f, 
    0.01698430f, -0.01304691f, -0.08299918f, -0.10057298f, 0.12835787f, -0.02038671f, -0.10319767f, 0.08180138f, 
    0.00677462f, -0.12332104f, 0.01539996f, 0.03424523f, -0.04605413f, 0.02496778f, 0.11121601f, 0.04074053f, 
    -0.19370928f, -0.03870254f, -0.11967079f, 0.20825480f, 0.10231938f, -0.01836393f, 0.03129381f, -0.03060050f, 
    -0.03557839f, 0.03848400f, -0.07384321f, -0.05302776f, -0.07800100f, 0.03794817f, -0.09717774f, 0.15213618f, 
    -0.07320442f, 0.05581609f, 0.07022776f, -0.03295828f, 0.03245072f, 0.10608725f, 0.01178932f, -0.02958906f, 
    0.27519441f, -0.02621868f, -0.00417865f, 0.05216353f, 0.09269957f, -0.07628566f, 0.03442229f, 0.12063053f, 
    0.00324353f, -0.17023574f, 0.00915867f, 0.01399855f, -0.11103386f, 0.07560547f, 0.28802919f, -0.16863871f, 
    0.12483678f, 0.08659072f, -0.00299276f, -0.17024891f, 0.04776810f, 0.00310160f, 0.03664422f, -0.02730242f, 
    0.00207208f, -0.04639938f, 0.04487237f, 0.13725179f, -0.09536652f, 0.03127686f, 0.05371605f, 0.05125831f, 
    -0.00640203f, 0.04129979f, -0.03663488f, 0.06693637f, 0.19446483f, 0.14651588f, 0.08898469f, 0.21205539f, 
    -0.01625640f, -0.08411507f, 0.04490770f, 0.14220588f, -0.08344439f, 0.03801890f, 0.11956448f, 0.01095119f, 
    0.21033712f, -0.03666851f, -0.01761349f, 0.03036729f, 0.01890338f, -0.00130424f, 0.06829597f, 0.05781388f, 
    -0.00582127f, 0.04004943f, 0.01155021f, 0.02824390f, 0.14426528f, 0.15437873f, -0.07746407f, -0.04038897f, 
    0.10208286f, -0.02442946f, 0.12335312f, 0.04231462f, -0.09797480f, 0.04587268f, -0.01469499f, -0.01927531f, 
    -0.15563242f, 0.40799403f, 0.14503425f, -0.12958942f, 0.02331003f, 0.04439342f, -0.07963959f, 0.04312192f, 
    0.05544190f, -0.08093178f, 0.03713133f, 0.06287212f, -0.08601892f, -0.25983697f, -0.03895038f, -0.12251609f, 
    -0.00965856f, 0.09488021f, 0.01828667f, -0.07638438f, 0.03634755f, -0.04378584f, -0.02555072f, -0.04022187f, 
    -0.07109708f, 0.11811097f, 0.19424884f, -0.04800917f, -0.04376688f, -0.03888778f, 0.03209269f, -0.01129813f, 
    -0.08672551f, 0.01122227f, -0.04988434f, -0.06255978f, -0.42025337f, 0.02647503f, -0.06621582f, 0.06240446f, 
    -0.09139346f, -0.09408966f, 0.09847984f, 0.04677347f, 0.04498668f, 0.01855022f, 0.02763323f, -0.02511336f, 
    0.01016087f, -0.09910797f, 0.04625389f, -0.09300655f, -0.00491568f, -0.06991063f, 0.06020124f, 0.10316171f, 
    0.13575681f, -0.02611045f, -0.02645501f, -0.04902592f, -0.16523586f, -0.20004839f, 0.13292764f, -0.07157815f, 
    -0.06766046f, -0.01643379f, -0.09402306f, 0.03807729f, 0.08963694f, -0.05127818f, -0.00970103f, -0.12060592f, 
    -0.05243009f, 0.02490443f, 0.01519842f, -0.04353030f, -0.04732602f, -0.04271210f, 0.05829414f, 0.00036059f, 
    0.03109559f, -0.06593502f, -0.02986842f, -0.08466764f, 0.30817747f, 0.27050859f, -0.18279493f, -0.27371547f, 
    -0.00807155f, 0.02784240f, 0.04358860f, -0.02842142f, 0.08164333f, -0.15751658f, -0.09346065f, -0.02253685f, 
    -0.30907583f, -0.16873592f, -0.00988197f, 0.12379899f, -0.01742884f, -0.07192338f, 0.06900655f, 0.02192957f, 
    -0.01334596f, 0.06559855f, -0.08473176f, 0.05852869f, -0.58891547f, 0.20308341f, -0.07023137f, -0.06894331f, 
    0.08151110f, -0.13476649f, 0.03687467f, -0.10921736f, -0.06354976f, 0.00687305f, 0.04231431f, -0.05170005f, 
    -0.17178349f, -0.13728821f, -0.02694870f, 0.11712573f, -0.16535078f, -0.04849817f, -0.03666939f, 0.04133596f, 
    0.01885638f, 0.08285537f, -0.06198889f, -0.09740677f, 0.08781191f, 0.13517852f, 0.06852600f, 0.19053283f, 
    -0.00852407f, 0.02872498f, 0.03789657f, 0.01933213f, 0.01626190f, 0.06892271f, 0.02209216f, 0.09429801f, 
    -0.17559707f, -0.01830779f, -0.05570221f, 0.11673772f, 0.06481637f, 0.02927184f, 0.00600883f, 0.19864446f, 
    -0.02025540f, -0.09435438f, 0.06582013f, -0.01805221f, 0.25210547f, -0.17971812f, -0.07758455f, 0.04698032f, 
    -0.02808266f, -0.00846824f, 0.15015160f, -0.01815846f, -0.02516713f, -0.08852729f, 0.08791939f, -0.02164850f, 
    -0.18751429f, 0.04428408f, -0.07752123f, -0.08443971f, 0.09871352f, 0.02495095f, -0.06892888f, -0.02787686f, 
    -0.02139144f, -0.03802049f, -0.17776898f, -0.13470796f, -0.51758033f, 0.11680286f, 0.01764818f, 0.10172852f, 
    -0.13873716f, 0.02450192f, 0.05051468f, 0.03300096f, 0.01861358f, 0.05414769f, 0.02260225f, 0.08373614f, 
    -0.10107868f, -0.02926028f, 0.03655113f, 0.04116039f, 0.10159166f, 0.08585121f, 0.10900561f, 0.08720143f, 
    -0.00689581f, -0.04682811f, 0.00296883f, 0.04916604f, 0.06203385f, 0.02314808f, 0.04535316f, 0.12606455f, 
    -0.06956077f, 0.07326494f, 0.03966423f, 0.02281755f, -0.06246328f, -0.05793265f, 0.01766078f, -0.07018433f, 
    -0.06003301f, -0.33101949f, 0.04601383f, -0.04951461f, -0.05661055f, 0.05642954f, 0.01952687f, -0.14630176f, 
    0.04073254f, 0.08507576f, -0.03079601f, -0.02104781f, -0.34695700f, -0.25118756f, 0.22210653f, -0.04061320f, 
    -0.06415687f, 0.04738210f, 0.00789729f, -0.02244828f, 0.16078319f, -0.08849778f, -0.01619457f, -0.03652514f, 
    -0.35846710f, -0.20445535f, -0.04389881f, 0.09965126f, 0.13416749f, 0.08411478f, 0.00632510f, -0.11262333f, 
    0.06325522f, -0.12273818f, 0.00100759f, -0.04590115f, 0.07578528f, -0.04150962f, 0.04528604f, -0.10238457f, 
    0.09308955f, 0.10562505f, 0.13076454f, 0.00264082f, 0.05815662f, -0.02371667f, 0.02675073f, 0.10529451f, 
    0.13686962f, 0.13710542f, -0.10396985f, 0.04496112f, -0.06455458f, -0.00211100f, 0.02264636f, 0.02431769f, 
    -0.03604083f, -0.03486388f, 0.05026525f, 0.10818680f, 0.04453773f, -0.03580064f, 0.17937987f, 0.01734048f, 
    -0.03230213f, 0.06209712f, -0.02553364f, -0.05088086f, 0.03077880f, 0.15441650f, 0.00963203f, -0.05617632f, 
    -0.39599109f, -0.01563399f, 0.10075787f, 0.10509419f, 0.04458242f, 0.08058120f, 0.04243265f, -0.00012563f, 
    -0.03981296f, -0.01939149f, 0.01979590f, 0.09047297f, 0.05915717f, -0.01727821f, -0.11453599f, -0.07756752f, 
    -0.07449491f, -0.15933013f, -0.03944400f, -0.15571113f, -0.01037382f, -0.08734046f, -0.02702949f, -0.14904563f, 
    -0.03178236f, 0.04613669f, 0.00696490f, -0.11722831f, -0.01762531f, -0.04175478f, 0.10726042f, -0.03707111f, 
    0.00075890f, -0.06229361f, 0.08855883f, -0.08620704f, 0.16579953f, -0.11686065f, -0.18482140f, 0.04862377f, 
    -0.04079271f, -0.12387991f, -0.02628156f, 0.10749255f, 0.07340683f, 0.05885757f, 0.00209163f, 0.00704624f, 
    -0.16220781f, -0.09774829f, -0.14342274f, 0.05298035f, -0.01707072f, -0.11101100f, 0.07230693f, 0.00282806f, 
    -0.03549900f, -0.10706398f, -0.00991677f, -0.01251029f, -0.37444532f, -0.04563771f, 0.29190797f, 0.07778806f, 
    -0.05372486f, 0.11296568f, -0.00274123f, 0.00894480f, -0.00174523f, 0.15338859f, 0.10692076f, 0.02911787f, 
    0.14783001f, -0.04035531f, -0.18363246f, 0.00163644f, 0.07408619f, 0.02983588f, 0.18557109f, -0.04448206f, 
    -0.10710831f, -0.06646180f, 0.06446113f, -0.08938012f, -0.36836702f, 0.06518781f, 0.10679819f, -0.27322173f, 
    0.01980318f, 0.00108578f, -0.10183629f, 0.01132018f, -0.01776340f, 0.06395611f, -0.02818228f, 0.09604487f, 
    -0.07526473f, 0.10662376f, -0.16443413f, -0.26774022f, 0.01171367f, -0.02081976f, 0.06297111f, 0.10082327f, 
    0.03213245f, -0.01297419f, 0.07367971f, 0.03581537f, -0.09884617f, -0.25774574f, 0.07096495f, -0.09368297f, 
    -0.07643146f, 0.12616774f, 0.10472137f, -0.04029339f, -0.03199688f, -0.01839516f, 0.08404721f, -0.08555608f, 
    0.06324732f, 0.04326046f, 0.08117253f, -0.03497692f, -0.00068877f, -0.00367669f, -0.08660999f, 0.08783959f, 
    0.03464266f, -0.02761726f, 0.05868931f, 0.03968293f, -0.14668179f, 0.01135446f, -0.07231969f, 0.04093210f, 
    -0.04757836f, 0.03052752f, 0.07924881f, 0.09163786f, 0.02513008f, -0.12317558f, -0.07428807f, 0.05955782f, 
    -0.00287001f, -0.02938196f, 0.10224005f, 0.15065594f, -0.01951840f, -0.02485728f, -0.01598711f, -0.19568324f, 
    -0.02860476f, -0.06148317f, 0.00166314f, -0.04747225f, -0.12055314f, 0.00460105f, 0.06634577f, 0.08647321f, 
    -0.14730059f, -0.07594447f, 0.04097005f, 0.04638809f, 0.03085717f, -0.02552389f, -0.00718194f, -0.03513353f, 
    -0.05353944f, 0.27459595f, 0.08908881f, -0.11807550f, -0.15445291f, 0.08213777f, 0.00728654f, -0.03903739f, 
    -0.03478305f, -0.06307751f, 0.03807239f, 0.17488949f, -0.01622490f, -0.12801717f, -0.10426915f, 0.13063535f, 
    0.14739047f, -0.06280553f, -0.01215038f, 0.09572281f, 0.01692056f, 0.10792852f, -0.04570666f, -0.01692582f, 
    -0.09323243f, -0.06690615f, 0.14014626f, -0.08836891f, -0.05853374f, -0.04871959f, 0.03420315f, -0.01865288f, 
    -0.01369049f, 0.02119365f, 0.07311644f, 0.02571980f, -0.46239662f, -0.10641108f, 0.13219152f, -0.14677921f, 
    -0.02649393f, 0.06600649f, -0.21856733f, 0.00986265f, 0.05349059f, -0.13724118f, -0.09744590f, 0.06588649f, 
    -0.32065061f, -0.19240184f, 0.17433706f, 0.16954875f, -0.09588828f, -0.01780702f, -0.10929603f, -0.07932898f, 
    0.00754873f, -0.07581151f, -0.08575481f, -0.07356817f, -0.09033148f, -0.08219883f, -0.11613559f, -0.02989895f, 
    -0.02859404f, 0.01663403f, -0.06590776f, 0.08086565f, -0.03228124f, -0.14179805f, -0.05236759f, -0.03534139f, 
    -0.06736744f, -0.19419268f, 0.08000550f, 0.20245585f, -0.03255199f, -0.01217415f, -0.20414764f, 0.12495402f, 
    0.06361335f, 0.06752460f, 0.15003049f, 0.11554211f, 0.25014541f, -0.20584214f, -0.18620433f, 0.03586312f, 
    -0.00053629f, 0.08741687f, 0.06457274f, 0.00179184f, -0.09444661f, -0.04200066f, 0.08258513f, 0.04959104f, 
    0.44020244f, 0.08394823f, -0.00860163f, -0.00417572f, -0.04844907f, 0.04157609f, 0.11361453f, 0.03047554f, 
    -0.01524463f, 0.10947970f, 0.01924714f, 0.08416874f, -0.33952212f, -0.06406229f, 0.05261745f, -0.38318053f, 
    -0.07810159f, 0.03418262f, -0.11229330f, 0.04741807f, -0.08115728f, 0.01009270f, -0.01144402f, 0.12517698f, 
    -0.01924859f, 0.11733141f, 0.23051627f, 0.02550951f, 0.09629420f, -0.04628679f, 0.04896646f, 0.04570140f, 
    0.13708848f, -0.12581153f, 0.02764818f, 0.06282357f, 0.13012816f, -0.15958010f, -0.08148992f, 0.18437088f, 
    -0.19516791f, 0.11898762f, 0.13054499f, -0.02592064f, 0.05420547f, 0.06177658f, 0.02084232f, -0.09907571f, 
    0.03407212f, -0.02932424f, 0.06923217f, -0.11296669f, -0.04948394f, 0.03572818f, -0.23019943f, -0.01629545f, 
    -0.01613949f, -0.12142615f, -0.00806571f, -0.04162138f, 0.04228713f, -0.05016335f, 0.06001831f, 0.13612372f, 
    0.01808880f, -0.02556280f, 0.03675395f, 0.05166927f, -0.08289359f, 0.01770891f, 0.05894495f, 0.19379410f, 
    -0.02985970f, 0.00720847f, -0.04900188f, 0.01267089f, 0.04107226f, 0.00877069f, 0.09459228f, -0.01713338f, 
    0.03397599f, 0.01441589f, -0.10066020f, 0.15758476f, -0.00205617f, 0.02136146f, -0.22617865f, -0.00545288f, 
    -0.00615151f, -0.05336386f, 0.02243660f, 0.02651145f, 0.01346003f, 0.01975708f, -0.05428204f, 0.02460025f, 
    -0.19104300f, -0.08481144f, 0.10920134f, 0.16718623f, -0.01903454f, 0.05539251f, 0.16364968f, 0.24728782f, 
    0.11558743f, 0.03687133f, -0.06140967f, -0.04100914f, 0.12641935f, -0.14652339f, 0.09498265f, 0.03666288f, 
    0.05956779f, 0.02881004f, -0.01666237f, -0.00406940f, 0.03725018f, -0.02757927f, 0.05216378f, -0.05349494f, 
    -0.28447896f, -0.06935558f, -0.08424930f, -0.00876024f, 0.02273993f, -0.01624122f, -0.10696574f, -0.01695033f, 
    0.16515358f, 0.06813177f, 0.12295097f, -0.07781088f, 0.18566036f, 0.10477035f, -0.22830801f, -0.04991116f, 
    0.06674742f, 0.06003641f, -0.03050576f, -0.17050688f, -0.11744489f, -0.06707737f, 0.02115037f, 0.08596338f, 
    -0.40133885f, -0.09321091f, 0.12432582f, 0.18995284f, -0.02994600f, 0.05602518f, -0.05481176f, -0.00165031f, 
    0.07972442f, 0.13330536f, 0.12356645f, 0.07379966f, -0.07146411f, -0.05038395f, -0.01387183f, 0.25878754f, 
    -0.08305560f, -0.01809544f, 0.10721443f, 0.00790369f, 0.00868152f, 0.13348147f, 0.02053072f, 0.01072862f, 
    -0.00363123f, -0.02873380f, -0.09285641f, 0.01551516f, 0.11054169f, -0.08975970f, -0.05073621f, 0.01018066f, 
    0.08026440f, -0.08007959f, 0.13412899f, -0.07536365f, 0.19769950f, -0.14184651f, -0.18639296f, 0.09981529f, 
    0.10278353f, 0.07815156f, -0.14375243f, -0.19363280f, 0.13805480f, -0.06115543f, -0.07772896f, -0.00435148f, 
    -0.15504085f, -0.14619337f, 0.09148876f, 0.12519003f, -0.06562449f, -0.06893506f, 0.02551356f, -0.22521770f, 
    -0.16480395f, -0.15568857f, 0.05972770f, -0.01303552f, -0.07939515f, 0.11525179f, 0.19459626f, -0.17069232f, 
    0.08862107f, 0.03504895f, -0.11998848f, 0.06431060f, 0.03381662f, -0.00147890f, 0.01965904f, -0.09420261f, 
    0.07360531f, 0.03416364f, -0.08098236f, -0.01673941f, -0.04914803f, -0.05194366f, -0.02600544f, -0.10442077f, 
    -0.02572522f, 0.20149653f, 0.18244006f, 0.09042960f, 0.21509776f, -0.03240260f, -0.01799687f, -0.11376634f, 
    0.05587006f, -0.04161095f, -0.01524987f, 0.06019601f, -0.22757873f, -0.04489806f, -0.12256145f, -0.12659143f, 
    -0.00062382f, -0.22400168f, 0.11228154f, 0.23389581f, 0.06201848f, 0.12093897f, 0.01473380f, -0.06478884f, 
    -0.01947382f, -0.00847874f, 0.15262027f, 0.11055460f, -0.44061449f, 0.00196721f, -0.16183841f, -0.22129495f, 
    0.14339484f, 0.15816131f, -0.05467728f, -0.14606048f, 0.00819021f, -0.01304614f, 0.00065490f, 0.02404961f, 
    0.02004087f, -0.00034268f, 0.03745177f, -0.09109636f, -0.00265957f, -0.07856443f, -0.13012795f, 0.00231271f, 
    -0.01983480f, 0.08998208f, -0.03848959f, 0.02421037f, 0.11323702f, -0.06162149f, 0.10297963f, 0.13952056f, 
    0.07774869f, 0.00220455f, 0.03504162f, -0.03768995f, -0.00162231f, -0.02564413f, 0.02515211f, 0.02397488f, 
    -0.24924441f, -0.06773954f, 0.02765573f, -0.43586752f, 0.00834801f, -0.04766768f, 0.02456330f, -0.04138457f, 
    0.18503970f, -0.03132718f, 0.03010251f, -0.01975165f, -0.24013449f, -0.32279661f, 0.25233376f, -0.01164732f, 
    -0.11304324f, -0.09124631f, 0.14052151f, -0.02527127f, -0.03014216f, 0.11114398f, 0.06354100f, -0.07719044f, 
    0.22064681f, -0.08123120f, -0.02727994f, -0.05939972f, -0.03926080f, -0.03348111f, 0.02987945f, 0.06241634f, 
    0.04742939f, -0.06382098f, 0.05184559f, 0.01932489f, -0.38679427f, 0.09667975f, 0.09561736f, -0.22128181f, 
    -0.03678914f, 0.07097902f, -0.03298604f, -0.00480923f, 0.07166080f, -0.15967883f, -0.04598013f, -0.00306748f, 
    0.07761844f, -0.01025489f, 0.00753837f, -0.07212804f, -0.10190720f, 0.11249793f, 0.04069079f, 0.08532301f, 
    0.07508886f, -0.08344457f, 0.05753598f, 0.09644226f, -0.00229929f, 0.03884830f, 0.10512020f, 0.07905596f, 
    -0.11521134f, 0.04326732f, -0.04567117f, -0.06258096f, -0.07933253f, -0.12486374f, 0.18433677f, 0.08518074f, 
    -0.34456456f, -0.07045637f, -0.15952970f, -0.05452213f, 0.14780053f, 0.15426038f, 0.12189493f, 0.00458106f, 
    -0.13378914f, 0.04687195f, -0.10098751f, -0.04585131f, -0.05406565f, 0.19280253f, 0.12718669f, -0.39115533f, 
    -0.08454917f, -0.03873337f, -0.14268146f, 0.06349333f, -0.02121738f, 0.00883477f, -0.17340475f, -0.08938029f, 
    -0.10301527f, 0.04260607f, -0.12023026f, 0.05126101f, -0.15047447f, -0.10168228f, 0.05321522f, 0.10286160f, 
    0.04945999f, 0.06896025f, -0.18203171f, -0.00001852f, -0.04228167f, 0.20791714f, -0.25939789f, 0.00684815f, 
    0.04506501f, -0.12617394f, -0.13641736f, -0.20507039f, -0.19047819f, -0.04662168f, -0.07382344f, -0.20317356f, 
    -0.44052273f, -0.17246377f, -0.20191883f, 0.03453507f, 0.04381303f, 0.16724235f, -0.12464170f, 0.00602834f, 
    0.08192330f, 0.09938018f, 0.12448964f, 0.06110238f, -0.05494486f, 0.09755743f, 0.04095856f, -0.18598583f, 
    -0.01666653f, -0.05627225f, 0.04146872f, -0.08207646f, -0.07606413f, 0.07945573f, -0.06154817f, 0.23749301f, 
    0.08683123f, 0.01299203f, 0.14623886f, 0.04796500f, -0.02873582f, -0.06830812f, -0.00277635f, 0.01216224f, 
    0.11603151f, -0.03107301f, 0.18457548f, 0.07040501f, -0.13777889f, -0.00222312f, -0.10479647f, 0.23372246f, 
    -0.04373210f, -0.06003891f, 0.03307524f, -0.00454920f, -0.10850441f, -0.11233545f, -0.01956632f, -0.03599249f, 
    0.26608506f, -0.01079743f, -0.04248226f, -0.02981205f, -0.07214538f, 0.00174142f, -0.20553890f, -0.05171522f, 
    -0.00759061f, 0.01896263f, -0.00818803f, -0.04652998f, -0.16133885f, 0.09736080f, 0.25123614f, 0.04108988f, 
    -0.03528416f, -0.00894386f, -0.12315413f, 0.04908743f, -0.04453669f, 0.05686421f, -0.19938102f, -0.07733494f, 
    -0.07955551f, -0.03661234f, 0.08742908f, -0.14590390f, 0.09109783f, 0.02433443f, 0.03719377f, 0.05209532f, 
    0.17427292f, -0.04489966f, -0.04126379f, -0.06315017f, 0.00257927f, -0.06001516f, 0.08598286f, -0.19014969f, 
    0.18603121f, 0.03159392f, 0.00095203f, -0.00846636f, -0.01808893f, -0.01125733f, 0.11381540f, 0.10943181f, 
    -0.32479087f, -0.11521256f, -0.27843052f, -0.01239617f, 0.13414727f, 0.00008571f, 0.04169535f, -0.03438098f, 
    0.10005711f, 0.02506044f, -0.08489080f, -0.01611005f, 0.01075880f, 0.13611141f, 0.15597215f, -0.00566816f, 
    0.01499432f, -0.09752599f, 0.11154024f, -0.07980386f, -0.13410737f, -0.08417228f, -0.06877986f, 0.28992295f, 
    -0.31590098f, -0.08740096f, -0.22341970f, -0.09463678f, 0.03207834f, 0.04931643f, 0.07453715f, 0.02316065f, 
    0.19115421f, 0.02534984f, 0.00660228f, 0.13708374f, -0.05213770f, 0.22289941f, 0.19004996f, -0.04263708f, 
    0.00084609f, -0.02663434f, -0.06172542f, -0.22486623f, -0.01528631f, -0.25798169f, -0.08246484f, 0.17681853f, 
    -0.11856443f, -0.08664002f, -0.12173704f, -0.15711169f, 0.02331049f, 0.01918922f, -0.03078856f, 0.05878513f, 
    -0.02211906f, 0.05391650f, -0.05469478f, -0.02979670f, -0.02739163f, -0.11945495f, -0.18652199f, -0.07199904f, 
    -0.02881033f, 0.05117927f, -0.03004803f, -0.03105674f, 0.09154092f, -0.09675983f, -0.06287648f, 0.08790021f, 
    -0.16463569f, 0.11214315f, 0.25590000f, -0.02718152f, 0.00972416f, 0.03521156f, -0.00096265f, -0.04116482f, 
    0.02284313f, 0.17376290f, 0.10343541f, -0.01040195f, -0.31306127f, 0.07531226f, -0.11928428f, -0.05616566f, 
    0.05695535f, 0.00883907f, -0.01090906f, 0.10850535f, -0.02523559f, -0.07110394f, 0.11664611f, -0.19953099f, 
    -0.03994484f, 0.13227211f, -0.04056412f, -0.01588556f, 0.05188150f, -0.05892673f, -0.06955693f, -0.12400573f, 
    -0.02713902f, 0.14386970f, 0.09193165f, 0.14111513f, 0.01486459f, 0.02916581f, -0.01377203f, 0.13416733f, 
    -0.02843093f, -0.16630705f, -0.08080946f, 0.12716314f, 0.07006057f, -0.08643504f, -0.06576771f, 0.11324754f, 
    0.04832546f, -0.07652606f, -0.08892720f, 0.25106224f, 0.03749431f, 0.00274195f, 0.09785292f, 0.00339105f, 
    -0.02218642f, 0.05130266f, 0.18891075f, -0.05384989f, 0.10699686f, -0.32762432f, -0.08593661f, -0.10490540f, 
    -0.14441246f, -0.05377460f, 0.01971546f, 0.04987066f, 0.14059289f, -0.02194990f, 0.02207214f, -0.03557582f, 
    0.05728178f, 0.05261449f, 0.25782868f, -0.02911806f, 0.00834961f, -0.05099164f, 0.03919220f, -0.05962870f, 
    -0.07752492f, -0.17435588f, 0.08011490f, 0.12002368f, 0.03699149f, -0.04984400f, -0.01477083f, 0.01218836f, 
    -0.01410004f, -0.17751877f, 0.00103772f, 0.01671443f, 0.09131935f, 0.01985568f, -0.03142593f, -0.01606896f, 
    0.00169684f, -0.00057559f, 0.07010722f, 0.13556500f, -0.01078438f, -0.16523789f, -0.00621944f, 0.01525542f, 
    -0.01711365f, 0.04520288f, -0.17143358f, -0.04906376f, 0.11013727f, -0.08107378f, -0.11368294f, -0.07612325f, 
    -0.04125775f, 0.04301456f, 0.08010555f, -0.04639096f, 0.13722920f, -0.13884613f, -0.01996504f, -0.07927456f, 
    0.34335932f, 0.03572632f, 0.05954742f, -0.07414217f, -0.14526382f, -0.00389897f, 0.02589815f, 0.00904041f, 
    -0.00637440f, -0.07616042f, 0.02910063f, -0.00240250f, -0.01718005f, -0.07035586f, -0.01052205f, 0.25535133f, 
    0.01770088f, 0.02150010f, 0.14051948f, 0.07469627f, -0.08770483f, -0.00041309f, 0.11179514f, 0.03170302f, 
    0.17510608f, 0.01270479f, 0.00026541f, 0.00310406f, -0.06681439f, 0.02391249f, 0.06340423f, 0.03357297f, 
    0.07762759f, 0.02260813f, 0.03580477f, 0.15583949f, 0.02453027f, 0.06508242f, -0.01254322f, -0.10845838f, 
    0.18923728f, 0.12035009f, 0.03573247f, -0.04207624f, 0.06573039f, 0.03437468f, 0.11807612f, 0.02877573f, 
    0.07590181f, 0.02408563f, -0.20081981f, -0.10193429f, 0.05317770f, 0.05806864f, 0.00965420f, -0.27282819f, 
    -0.10450910f, 0.03195897f, -0.13216875f, 0.04684780f, 0.10409044f, 0.13651742f, 0.07478082f, 0.14585128f, 
    -0.11381415f, 0.04503896f, 0.01467231f, -0.16691729f, -0.10544871f, -0.05915265f, -0.15272588f, -0.07945331f, 
    -0.07898159f, 0.02653828f, 0.11589597f, 0.07061443f, -0.03915664f, -0.13581398f, 0.08241767f, -0.07695243f, 
    0.09296059f, -0.05719526f, -0.00443302f, 0.07533300f, 0.04071477f, 0.10088839f, 0.05014621f, -0.01657515f, 
    0.04487282f, -0.01592244f, 0.00881639f, 0.13848132f, -0.14263090f, -0.00331120f, 0.05603760f, -0.08771015f, 
    0.16277616f, -0.01026476f, -0.07664749f, 0.16190670f, -0.00911136f, -0.00622926f, -0.11392925f, -0.01016345f, 
    -0.03683890f, 0.02767995f, 0.19811799f, 0.13949206f, 0.18203567f, 0.17091955f, 0.16984409f, -0.07303011f, 
    -0.02112484f, -0.01905087f, -0.01839361f, -0.22810696f, -0.12409514f, 0.05559400f, 0.02280074f, -0.01848847f, 
    -0.29764500f, -0.07164781f, -0.02524397f, -0.09324412f, 0.04364458f, 0.08203644f, 0.10588004f, -0.01371742f, 
    0.02860334f, 0.01998207f, 0.02052069f, 0.08309440f, 0.09630778f, 0.12030932f, 0.11266586f, -0.13581160f, 
    0.01940288f, 0.08768718f, 0.04049682f, 0.03993440f, -0.01999306f, -0.16785158f, -0.08190950f, -0.05390565f, 
    -0.13757004f, 0.17202885f, 0.04051697f, -0.23068309f, -0.09768885f, 0.01720352f, 0.01181534f, 0.09690391f, 
    0.02165586f, 0.01518210f, 0.07338461f, -0.03102479f, -0.35326323f, -0.08279329f, -0.07868294f, 0.03321530f, 
    0.03557847f, -0.00961272f, -0.04451199f, -0.06580529f, 0.03005259f, -0.09090500f, 0.05550664f, -0.12641771f, 
    -0.11087244f, -0.01327185f, -0.15037443f, 0.17860951f, 0.08271439f, -0.01354532f, -0.20450637f, -0.19617455f, 
    -0.09343410f, -0.06227130f, 0.00323027f, 0.03739236f, -0.00641516f, 0.02570999f, -0.10051648f, -0.04317018f, 
    0.01832048f, -0.10765273f, 0.10148007f, 0.00258856f, 0.02327070f, -0.00513152f, -0.05896428f, -0.04723753f, 
    -0.14938845f, -0.04723073f, -0.12942453f, -0.21162190f, 0.04064400f, 0.01445880f, 0.02247908f, -0.10601111f, 
    0.01009642f, -0.08062727f, -0.01707274f, 0.07866952f, 0.04398765f, -0.00019346f, 0.00497479f, 0.36361229f, 
    0.00070909f, 0.06094937f, -0.02964541f, 0.00195973f, 0.06762198f, 0.02222394f, -0.06002932f, 0.03014589f, 
    -0.03748135f, 0.00527228f, -0.13958198f, 0.06604011f, -0.03885793f, -0.06520347f, 0.00395772f, -0.03066546f, 
    -0.14824729f, -0.15602335f, 0.08600321f, -0.09371504f, 0.12575132f, -0.16451699f, -0.22498836f, 0.08657362f, 
    0.07421940f, -0.08078062f, -0.03805726f, 0.02935649f, 0.03313095f, -0.17973404f, 0.00053421f, -0.11060496f, 
    0.03412837f, -0.07169580f, -0.19652501f, -0.12576471f, -0.03275120f, 0.00292926f, -0.11584291f, -0.07338805f, 
    -0.07275690f, 0.01698937f, -0.07796532f, -0.02852760f, -0.01964731f, -0.11266026f, -0.14137568f, -0.00742325f, 
    -0.20456548f, -0.01275651f, -0.06773931f, -0.06046382f, -0.16425709f, -0.01058299f, 0.08097208f, -0.04850540f, 
    0.13591711f, 0.05022056f, -0.08764316f, 0.18557395f, -0.14906769f, 0.03818270f, 0.02446750f, 0.07375416f, 
    -0.16358401f, 0.03456212f, -0.06229641f, -0.03138709f, 0.22861236f, -0.26274723f, 0.10163914f, -0.08581427f, 
    0.01813271f, 0.01981489f, 0.04255592f, 0.01064113f, 0.01570981f, 0.00453468f, -0.03866221f, 0.08734027f, 
    -0.00512700f, -0.14633933f, -0.05834507f, -0.22614589f, 0.02627132f, 0.01838315f, -0.02975522f, -0.08522118f, 
    0.05828959f, -0.21267788f, -0.00741245f, -0.15332371f, 0.01040827f, 0.23093653f, 0.16859309f, 0.07522595f, 
    0.01537571f, 0.01875304f, -0.08191577f, 0.00562251f, 0.03011311f, 0.04329877f, 0.00455509f, 0.04248424f, 
    -0.07118329f, -0.04055654f, -0.08412454f, 0.13399470f, 0.03803356f, -0.03141575f, -0.05420297f, -0.03860354f, 
    0.02163256f, -0.05258728f, -0.06866430f, 0.07363240f, -0.06071293f, -0.35976160f, -0.00380099f, 0.01292628f, 
    -0.05004004f, 0.08387576f, 0.03447838f, 0.13224562f, 0.09578348f, -0.05470230f, 0.07659537f, 0.00930275f, 
    0.22466226f, -0.05374237f, 0.08249694f, -0.07268969f, 0.01805128f, 0.07283476f, -0.02806964f, 0.04306395f, 
    -0.01678417f, -0.02242471f, 0.01756895f, -0.05832167f, 0.00590981f, 0.09279982f, 0.05963124f, 0.18117468f, 
    -0.01217463f, -0.00091406f, -0.03936853f, -0.10274918f, -0.08732755f, -0.05247596f, -0.00007848f, 0.14921351f, 
    0.43012255f, 0.12620100f, 0.16311374f, -0.20140930f, 0.03410477f, 0.07830141f, 0.10360369f, -0.01565203f, 
    -0.07373621f, -0.02689803f, -0.00065135f, -0.02072237f, 0.18148181f, -0.20742881f, 0.01728399f, 0.16357234f, 
    -0.02542416f, 0.13716897f, -0.08213659f, 0.01264498f, -0.09920208f, 0.09732407f, -0.04563418f, 0.04396034f, 
    -0.06565838f, 0.07203545f, 0.12644833f, 0.05750549f, 0.03457584f, -0.05304919f, 0.09356405f, 0.05333860f, 
    -0.00306633f, 0.09119378f, -0.05461457f, 0.00008642f, 0.67410392f, 0.02905546f, 0.08352602f, -0.16140062f, 
    -0.03014262f, -0.03997479f, -0.16672364f, 0.04298180f, 0.06580988f, 0.01035235f, 0.02046459f, 0.06255993f, 
    0.12880988f, 0.17398964f, 0.15330435f, -0.22805807f, -0.03548134f, 0.05016037f, -0.01707613f, 0.02784532f, 
    0.02456384f, 0.03736001f, -0.02312546f, 0.04942211f, 0.05336157f, 0.18299137f, 0.10595581f, -0.36988258f, 
    0.06380200f, -0.06035420f, -0.02682142f, 0.12893339f, -0.07380059f, 0.14800881f, -0.08065303f, 0.05478791f, 
    -0.10851327f, 0.01691104f, -0.04060379f, -0.40442708f, -0.07995220f, -0.05552059f, -0.07211516f, -0.14095737f, 
    -0.00288441f, -0.04791358f, 0.02800969f, 0.02528141f, -0.06245223f, -0.13875343f, 0.14336909f, -0.00651277f, 
    -0.00810334f, -0.08572180f, 0.06849204f, 0.11522654f, -0.01454023f, -0.04958817f, 0.06483328f, 0.05839508f, 
    0.12833789f, 0.06062923f, 0.01297517f, 0.07324507f, 0.00006820f, -0.01159851f, -0.05178294f, -0.15645611f, 
    -0.11451003f, -0.07888827f, 0.14263685f, -0.01459177f, -0.07411391f, -0.34176472f, 0.00200102f, -0.12887405f, 
    -0.10325658f, 0.00652970f, 0.04665446f, 0.11904869f, 0.09917457f, 0.02014216f, 0.00660516f, 0.11475199f, 
    0.03546497f, 0.02915953f, -0.01175619f, -0.12509266f, -0.10687987f, -0.03350595f, -0.02805666f, -0.08994546f, 
    -0.01260834f, 0.08750869f, -0.05103961f, 0.04404828f, 0.01581901f, 0.24769476f, -0.00341052f, -0.22560595f, 
    -0.08975012f, 0.08086425f, -0.03891145f, 0.06813762f, 0.17429028f, -0.10322326f, -0.01631959f, -0.24056990f, 
    -0.33580250f, 0.15151186f, 0.03092405f, 0.31560078f, 0.04358494f, 0.00805478f, 0.11278138f, 0.06595953f, 
    -0.09954380f, -0.17702085f, 0.01276322f, -0.24040504f, -0.05025753f, 0.11286255f, 0.11478449f, -0.02823024f, 
    0.19559191f, -0.14173742f, 0.08574067f, 0.06139613f, 0.02290692f, 0.11175079f, -0.06404793f, 0.12649953f, 
    -0.12484055f, 0.25345179f, -0.27566475f, 0.21620195f, -0.11794632f, -0.06461966f, 0.05498563f, 0.08361986f, 
    0.05243326f, 0.02824201f, -0.04146089f, -0.00824277f, 0.22039944f, 0.00408468f, 0.26461005f, 0.07504991f, 
    0.08670610f, -0.03658560f, 0.00534775f, -0.05196789f, -0.05348022f, -0.01962571f, 0.12590080f, 0.07786232f, 
    -0.01230315f, 0.03264895f, 0.08306316f, -0.28934410f, -0.09354120f, -0.10452884f, -0.00606936f, 0.04497172f, 
    -0.02034299f, -0.03240273f, 0.12422656f, -0.03006385f, 0.11349725f, -0.00177841f, 0.11830261f, -0.12340017f, 
    -0.16933148f, -0.06990921f, 0.03289583f, -0.11978545f, 0.07427849f, 0.03041392f, -0.16700894f, -0.16196194f, 
    -0.05948554f, -0.31102836f, -0.12185930f, -0.23305501f, 0.05832553f, 0.04566781f, -0.01635959f, -0.09875684f, 
    0.01377847f, -0.05670156f, 0.08317853f, 0.15632831f, -0.18609542f, 0.08609974f, 0.08794428f, 0.08129267f, 
    0.06478367f, -0.02854225f, -0.02400576f, -0.07599156f, 0.09319212f, 0.02235732f, -0.01249518f, -0.11654776f, 
    -0.16928770f, -0.18370190f, 0.10281080f, -0.01499247f, 0.06205434f, 0.01625159f, -0.18496804f, -0.11188310f, 
    -0.19790721f, 0.07999043f, -0.02644905f, 0.04652308f, -0.28739011f, 0.00978852f, 0.13330685f, -0.12525964f, 
    -0.07492165f, -0.08411995f, 0.05167920f, 0.15114225f, 0.01273676f, 0.20509471f, 0.11730792f, 0.06463561f, 
    -0.03836417f, 0.00041661f, 0.12016848f, -0.12454790f, -0.05239228f, -0.02697562f, 0.01277687f, 0.09116405f, 
    0.12928559f, -0.11889241f, -0.04127581f, 0.12920141f, -0.04712014f, -0.20920134f, -0.01494838f, 0.02386041f, 
    0.11544026f, -0.03160837f, -0.06749588f, -0.07882349f, 0.01812050f, -0.05301216f, 0.09850245f, 0.08537117f, 
    -0.19493437f, 0.00143676f, -0.05401186f, 0.01088211f, -0.08821090f, -0.02395944f, -0.03668283f, 0.07087354f, 
    0.04027748f, -0.11320774f, -0.08517583f, -0.01777191f, 0.29287472f, -0.40798941f, 0.03182475f, -0.04640003f, 
    0.09307160f, 0.00354958f, 0.02386190f, -0.00542821f, 0.07043456f, 0.07250008f, 0.08530623f, 0.13844354f, 
    0.02771293f, 0.03785079f, -0.00156498f, -0.10755038f, -0.12953334f, 0.04532978f, -0.01161887f, 0.08170210f, 
    0.03667399f, -0.05780732f, -0.09508888f, -0.20316048f, -0.06185326f, -0.07210520f, -0.04634413f, 0.04898256f, 
    -0.00976952f, 0.13836062f, -0.06806207f, -0.05380496f, 0.06507093f, 0.05412450f, 0.00803661f, 0.08102580f, 
    -0.06683704f, 0.15651725f, 0.07036462f, 0.02823293f, -0.00772349f, -0.00139217f, 0.03180788f, -0.09002940f, 
    -0.01662787f, 0.00826669f, -0.05427752f, 0.09363914f, -0.09939906f, 0.12002620f, -0.11238141f, 0.07978089f, 
    0.04554019f, 0.18814754f, -0.06997107f, -0.04785226f, -0.00054716f, 0.09393293f, 0.08981486f, 0.06103889f, 
    -0.12741187f, 0.05803012f, -0.19196682f, 0.05362169f, 0.03274595f, 0.00955693f, 0.00457459f, 0.03011977f, 
    -0.00583696f, -0.01643425f, 0.07909375f, -0.07915628f, -0.38904998f, 0.24501744f, 0.01594137f, -0.06095295f, 
    -0.07793808f, 0.11959208f, -0.03076323f, 0.05105090f, -0.08514250f, 0.00204305f, 0.04518709f, 0.07434650f, 
    -0.32003707f, 0.14134152f, 0.10979243f, -0.04401877f, -0.04479560f, 0.18144740f, 0.10244580f, 0.01391149f, 
    0.01433231f, 0.01137282f, -0.01081766f, 0.01167894f, -0.14263223f, 0.15254889f, 0.08832990f, -0.21365967f, 
    -0.06299058f, -0.03680057f, -0.04249621f, 0.05017595f, -0.07473790f, 0.09934531f, -0.03507281f, 0.07798611f, 
    -0.38313612f, 0.11152937f, 0.10070567f, 0.13726249f, 0.05544238f, -0.06410063f, 0.09566514f, 0.12528469f, 
    0.02241863f, 0.18136832f, -0.09845918f, 0.04560807f, -0.02957828f, 0.01071330f, -0.08412654f, 0.00803101f, 
    0.01723146f, -0.14965422f, -0.12314299f, -0.08181959f, -0.07757308f, -0.05903903f, -0.02772593f, -0.26457277f, 
    0.04365744f, 0.12139446f, 0.04382730f, -0.38804519f, -0.00676205f, 0.07029329f, 0.11746556f, 0.02274530f, 
    -0.03510537f, -0.00246952f, 0.02332463f, -0.13883181f, 0.00515721f, 0.15015547f, 0.05189413f, -0.08350908f, 
    -0.12488703f, -0.02198167f, 0.02350621f, -0.02221962f, 0.13318042f, -0.02114605f, -0.12146371f, -0.12190723f, 
    -0.13726142f, -0.07548305f, -0.16579707f, 0.10741988f, 0.04884562f, -0.01454703f, -0.00569677f, 0.09412010f, 
    0.00373828f, -0.04919869f, 0.07441618f, -0.04550160f, -0.33080581f, 0.05690055f, -0.07708035f, 0.03655424f, 
    -0.11506129f, -0.02448986f, 0.06665353f, 0.00915181f, 0.12478208f, 0.18477146f, -0.01720969f, 0.00712538f, 
    -0.18438168f, -0.04056028f, -0.01168786f, -0.08072656f, 0.06226686f, 0.09039846f, -0.02796167f, 0.00907582f, 
    -0.16088723f, 0.03125585f, -0.01967294f, -0.05246485f, 0.06247706f, -0.32185900f, 0.21902594f, -0.07727609f, 
    0.12528148f, -0.03489729f, 0.12201209f, -0.04870919f, 0.01966682f, -0.03129959f, 0.00055817f, -0.05314929f, 
    -0.05312698f, -0.07883231f, -0.10316356f, -0.11346222f, -0.07558619f, 0.09797737f, -0.00497272f, -0.08360825f, 
    -0.00139207f, -0.13670436f, -0.20919240f, -0.02727051f, -0.32618198f, 0.16044666f, 0.15659304f, -0.21553549f, 
    0.04401020f, 0.02808604f, 0.07789605f, 0.15851562f, 0.08181382f, -0.13550816f, 0.06985883f, 0.00333574f, 
    0.07405584f, 0.06952425f, 0.06445531f, 0.13347343f, -0.03878938f, -0.02949627f, 0.05541371f, 0.06092785f, 
    0.02427296f, 0.01810329f, -0.06601567f, -0.01669036f, 0.03399572f, -0.27878404f, 0.00678722f, 0.14840952f, 
    -0.07735256f, -0.10265664f, -0.04467959f, 0.02559799f, -0.02567414f, 0.01674312f, 0.01443291f, -0.12250123f, 
    -0.21677382f, 0.06272195f, -0.08679012f, -0.09072513f, -0.04479611f, -0.02855622f, -0.03519030f, -0.09331866f, 
    -0.06244226f, 0.02923600f, 0.03645445f, -0.01633439f, -0.13855898f, 0.16061498f, -0.03863138f, -0.00961718f, 
    -0.01614666f, 0.02042585f, 0.00124249f, -0.02550643f, 0.03990163f, 0.03984075f, -0.00027120f, -0.02709104f, 
    -0.04684056f, 0.00843501f, -0.00106558f, 0.17624977f, -0.00293056f, -0.05023498f, 0.00857422f, -0.02542681f, 
    0.00853913f, -0.02891641f, -0.02659043f, -0.05354907f, 0.14250295f, 0.16424222f, 0.10746479f, 0.17665720f, 
    0.07115038f, -0.04788404f, -0.01790853f, 0.05968538f, -0.08295775f, 0.00817717f, -0.01415834f, -0.03478839f, 
    -0.01762419f, 0.08059257f, 0.11637973f, 0.14131334f, -0.08335452f, 0.09665630f, -0.01337272f, -0.01243712f, 
    -0.02328373f, -0.04559721f, -0.07117023f, -0.02023704f, 0.00664762f, 0.13991705f, -0.14929859f, 0.09286528f, 
    -0.08641291f, -0.01392284f, 0.09188951f, 0.02985753f, 0.12255517f, 0.00108794f, -0.04642876f, -0.01508305f, 
    0.16954823f, 0.12950252f, 0.10546649f, 0.21782550f, 0.07448269f, 0.00917436f, 0.00961311f, -0.06228688f, 
    -0.06569406f, -0.08999032f, 0.01193324f, -0.11743747f, -0.04951617f, -0.01717364f, -0.14885858f, 0.06869800f, 
    -0.10012557f, 0.02219884f, 0.01540142f, -0.01563247f, 0.04519074f, -0.03840177f, -0.03060602f, -0.03361724f, 
    0.08429057f, 0.06401618f, 0.04399823f, 0.08034588f, 0.00466640f, -0.02136608f, -0.00826897f, -0.03012756f, 
    -0.07027758f, -0.01833404f, -0.02862622f, -0.09421983f, -0.11637454f, 0.18800063f, 0.06967999f, 0.12673852f, 
    0.09890058f, 0.09343725f, 0.03967789f, 0.00677628f, 0.06246541f, 0.03054692f, 0.02320781f, 0.01979756f, 
    0.02153156f, 0.19236505f, 0.03051149f, 0.25037542f, 0.08506161f, -0.13783771f, -0.03721104f, 0.02439741f, 
    -0.00672316f, 0.00745554f, 0.00089730f, -0.01947314f, -0.04823026f, -0.08884273f, -0.14809507f, -0.12806487f, 
    -0.02389059f, -0.00376361f, -0.01502607f, -0.05615065f, -0.04803677f, 0.02397416f, -0.03373511f, -0.00570602f, 
    0.01895109f, 0.09795434f, 0.13229175f, 0.08913112f, -0.04033476f, -0.05440955f, 0.00296193f, -0.01914708f, 
    -0.05335168f, -0.01788448f, -0.10354074f, -0.09113027f, -0.04944370f, 0.09971613f, -0.14533944f, -0.09083433f, 
    -0.06505302f, 0.02169337f, -0.05412273f, 0.03190253f, 0.00787881f, 0.01523445f, -0.02473324f, -0.07389548f, 
    0.02106037f, -0.07174104f, 0.19468115f, 0.12168187f, -0.01611643f, -0.14210667f, 0.01300038f, -0.03087114f, 
    -0.00264591f, 0.02273827f, -0.02503278f, -0.08775681f, -0.05877869f, -0.07692657f, 0.13688633f, -0.02867987f, 
    -0.00562171f, 0.02358213f, -0.00489054f, -0.02931679f, -0.04003917f, 0.03445619f, -0.02890773f, -0.04185535f, 
    0.03255357f, -0.06385922f, -0.11780057f, -0.16207862f, 0.04311812f, 0.01883200f, -0.03026786f, -0.03876809f, 
    -0.00401513f, -0.00474274f, -0.03302266f, 0.00678273f, -0.01363776f, -0.17220120f, -0.08633635f, -0.06177437f, 
    -0.08961492f, 0.02213941f, 0.05464954f, -0.00006511f, -0.07085582f, -0.01647934f, 0.09288640f, -0.04064705f, 
    0.14854188f, 0.01336858f, -0.12670301f, -0.04537849f, -0.04014602f, 0.02256492f, -0.03073580f, -0.12633121f, 
    -0.03078101f, -0.03975599f, -0.00826424f, -0.01571283f, -0.21923037f, 0.13297945f, -0.00251218f, 0.05765213f, 
    0.04550941f, -0.01128271f, 0.02731081f, 0.00226626f, -0.01237855f, 0.01008460f, 0.05401287f, -0.03123085f, 
    0.09465326f, -0.21143702f, 0.02808508f, -0.09774788f, 0.03238196f, 0.05419752f, -0.04022092f, 0.04988069f, 
    -0.07772467f, -0.13324447f, 0.00959539f, -0.00207879f, 0.15783320f, 0.06980272f, 0.08511641f, -0.03543818f, 
    -0.11645409f, -0.02787698f, -0.02847078f, 0.00943798f, 0.01362209f, 0.01098345f, -0.09157375f, -0.03488063f, 
    -0.28709644f, -0.00852508f, -0.11013028f, -0.26490033f, 0.07911378f, -0.03651071f, 0.01576765f, -0.04489271f, 
    -0.04451839f, 0.00824728f, -0.04448916f, -0.04317301f, -0.01754886f, -0.08358315f, -0.07831173f, -0.06338730f, 
    -0.05365844f, -0.01888941f, 0.01005787f, -0.06757095f, -0.00338124f, 0.01847154f, -0.04578679f, 0.02326812f, 
    0.04009019f, 0.13351791f, 0.20745254f, 0.13647023f, 0.12992167f, 0.10009260f, 0.02624175f, -0.04499303f, 
    -0.03931481f, 0.01330629f, -0.00424109f, 0.01815339f, -0.06599680f, -0.01521748f, -0.04672452f, -0.10549597f, 
    -0.03790817f, -0.06153950f, -0.06860734f, -0.07046773f, -0.00454131f, -0.00404575f, 0.04593782f, -0.05603164f, 
    -0.11160963f, 0.04945532f, -0.05567660f, -0.09214374f, 0.01104269f, 0.05053526f, 0.03288656f, 0.01460744f, 
    -0.03823429f, -0.06858063f, -0.03227284f, -0.01344168f, 0.17056872f, 0.18557698f, 0.10676699f, 0.12608959f, 
    -0.02811288f, 0.03126022f, 0.05846339f, 0.02933482f, -0.04609412f, 0.01034804f, -0.05155079f, 0.01373063f, 
    0.06831475f, 0.13853054f, 0.06748891f, 0.13368675f, 0.01296878f, 0.07654306f, 0.04587657f, -0.00181488f, 
    -0.05318173f, 0.01228978f, 0.01034026f, -0.01341480f, -0.43667543f, 0.20048563f, 0.06516477f, -0.10773901f, 
    -0.05591833f, 0.00896730f, -0.04018299f, -0.01619811f, -0.06962215f, 0.01666183f, 0.00913615f, 0.00819900f, 
    0.01304255f, 0.02533595f, -0.25031862f, -0.02331226f, 0.00444242f, -0.07551252f, -0.06554624f, -0.04072335f, 
    -0.06198471f, -0.02940552f, 0.04410851f, 0.04906335f, 0.02541970f, -0.35498226f, -0.13571781f, 0.02188925f, 
    -0.04211293f, -0.01495713f, 0.03489637f, -0.02515936f, -0.09025061f, -0.09844307f, 0.00254337f, -0.01868006f, 
    -0.01610259f, 0.01272079f, -0.08902469f, -0.10142186f, -0.05259144f, -0.03086306f, -0.01235102f, 0.01923749f, 
    0.06683229f, 0.04966616f, 0.01624712f, 0.01951941f, -0.00145959f, -0.04607206f, 0.06916653f, -0.02560481f, 
    0.08978105f, -0.02754069f, -0.04234408f, -0.04914626f, -0.05375341f, 0.01281725f, 0.09449712f, -0.02645304f, 
    -0.31163809f, 0.16787925f, -0.17416753f, -0.12092359f, -0.06998964f, 0.02041624f, -0.00696934f, -0.10927279f, 
    -0.06677616f, 0.02596088f, -0.02949710f, -0.03176124f, 0.01824932f, -0.17234744f, 0.04959194f, -0.10748245f, 
    0.01168362f, -0.08514652f, -0.03651758f, -0.12255216f, -0.04217160f, 0.01073790f, 0.07827661f, -0.07811520f, 
    0.20952119f, 0.06028979f, 0.18246199f, 0.08810470f, 0.05451972f, 0.10631212f, -0.01213911f, -0.01386200f, 
    -0.06388680f, 0.10346407f, -0.00671756f, 0.02391038f, -0.01230433f, -0.20315731f, -0.07426772f, 0.08575576f, 
    0.10317475f, -0.02440904f, -0.03893823f, -0.03299423f, 0.03052944f, -0.01799881f, 0.00948194f, -0.03601430f, 
    -0.09104173f, 0.18523948f, -0.00654816f, 0.05724064f, -0.04207563f, 0.06389608f, 0.09519913f, -0.05088650f, 
    0.06776287f, -0.02283221f, 0.08087759f, -0.04654189f, -0.13955911f, 0.10466217f, 0.01799820f, -0.04739447f, 
    -0.10628411f, 0.00565279f, -0.00475130f, -0.05136660f, -0.02886081f, -0.07125361f, -0.07844312f, -0.10000884f, 
    -0.17929210f, -0.02247455f, -0.33515164f, 0.03229227f, -0.00721546f, -0.02361821f, -0.03101831f, -0.07407510f, 
    -0.04116976f, -0.03019406f, 0.01273972f, -0.07959636f, 0.14521694f, 0.12161345f, 0.16409351f, 0.08874331f, 
    0.01617433f, -0.03579320f, 0.00180783f, -0.08070850f, -0.02999225f, 0.03347164f, -0.04641284f, -0.02978403f, 
    -0.24206856f, 0.19103166f, 0.05733213f, -0.03866979f, -0.10877270f, 0.01615748f, 0.02576217f, -0.04172748f, 
    -0.03126299f, -0.04090973f, -0.01035982f, -0.09033803f, 0.17939724f, -0.07902357f, 0.20799431f, -0.01544883f, 
    0.07244544f, -0.05231711f, -0.02085112f, -0.01296938f, -0.05136432f, 0.07245627f, -0.07011424f, -0.03280280f, 
    -0.10262688f, 0.03928908f, 0.07721058f, -0.03065780f, -0.02865714f, -0.02034069f, 0.06228323f, -0.02202622f, 
    -0.01904641f, 0.04890126f, 0.05504957f, -0.01196713f, -0.01731736f, -0.04910976f, 0.02563443f, 0.08841842f, 
    -0.11038043f, -0.08890121f, -0.02936034f, -0.01165014f, -0.06133832f, 0.02466227f, -0.10986135f, -0.04616342f, 
    0.07901795f, 0.11699541f, 0.04629049f, 0.13558029f, -0.08387206f, -0.03269022f, -0.03498081f, -0.07925130f, 
    -0.08827922f, 0.01405328f, -0.08320288f, 0.02114638f, -0.15148215f, 0.14022890f, -0.26471990f, -0.00577682f, 
    -0.00629100f, 0.04716730f, -0.00506297f, -0.05523639f, 0.09457568f, 0.08444893f, 0.03101478f, 0.00491762f, 
    0.10117576f, 0.17596678f, -0.01714985f, 0.03087631f, -0.14432664f, -0.01911531f, -0.01213240f, -0.09647315f, 
    -0.00870483f, 0.00839075f, -0.05197944f, -0.03689763f, -0.32651997f, 0.03950266f, -0.06720730f, -0.12543778f, 
    0.07323094f, -0.00004296f, -0.09733012f, -0.05050816f, -0.04589515f, -0.03483837f, -0.03137705f, -0.07576194f, 
    -0.11542206f, 0.14077641f, -0.09204974f, 0.05191901f, -0.05840752f, -0.03343150f, -0.01378487f, -0.04860645f, 
    0.02147214f, 0.00801892f, -0.05316743f, -0.06621856f, -0.08238857f, 0.05237205f, -0.06558672f, 0.04631559f, 
    -0.07132295f, -0.03397816f, 0.00409793f, -0.02731393f, -0.11056139f, -0.02983697f, 0.00241013f, -0.01042730f, 
    -0.10687172f, 0.05939750f, -0.10034607f, -0.15518646f, -0.01949061f, -0.01645714f, -0.03779250f, -0.03338089f, 
    -0.00703578f, -0.05844549f, -0.05009393f, -0.05711810f, 0.08023499f, -0.06791465f, -0.06721250f, 0.00444883f, 
    0.03496058f, -0.01805305f, -0.09380269f, -0.00267597f, -0.11313567f, 0.04362606f, -0.13699248f, 0.04617698f, 
    0.05576349f, -0.19863944f, -0.08498351f, -0.09667627f, -0.05995834f, -0.03978512f, -0.07100005f, -0.08639219f, 
    -0.10900527f, 0.00123378f, 0.05270828f, -0.03110868f, -0.06602187f, 0.14849265f, 0.07203796f, -0.09424760f, 
    -0.06059368f, 0.04536866f, -0.03097260f, -0.08621985f, -0.00270507f, -0.05083227f, 0.02235645f, -0.07730687f, 
    0.06009592f, 0.19284320f, -0.01851679f, 0.14830302f, 0.08403486f, 0.02060886f, 0.11167487f, 0.05992424f, 
    0.00497489f, -0.05028301f, 0.01541630f, -0.02742155f, 0.32678074f, 0.07207534f, -0.14047332f, 0.02934272f, 
    0.07953139f, -0.02969159f, -0.06224603f, 0.06450993f, 0.00539611f, -0.03515141f, 0.03727858f, -0.01475915f, 
    -0.09495822f, 0.07739371f, 0.05241217f, -0.10869280f, -0.11780722f, 0.09015527f, 0.03919466f, -0.10243256f, 
    0.02524294f, -0.03531326f, -0.04449808f, 0.02982706f, 0.33390859f, -0.05255980f, 0.10674226f, -0.04347800f, 
    -0.03149271f, 0.01007842f, 0.06103857f, -0.00369853f, 0.08074309f, 0.06834880f, 0.03417939f, 0.00909011f, 
    0.09704211f, -0.15445440f, 0.06653155f, 0.08534141f, -0.05274615f, -0.02664233f, -0.08850383f, -0.06213854f, 
    -0.07187501f, -0.02794892f, -0.12925994f, -0.05504967f, 0.10389630f, 0.00402054f, 0.01167929f, -0.01747847f, 
    -0.07741194f, 0.05809208f, -0.02155554f, -0.00669929f, -0.04731055f, 0.02377809f, 0.01445668f, -0.03400993f, 
    -0.24624540f, 0.14954053f, -0.01303724f, 0.07872933f, -0.13531888f, -0.02537452f, -0.23146640f, 0.04783886f, 
    0.06701145f, -0.09387039f, 0.04969554f, -0.05487918f, -0.11838963f, -0.23433927f, -0.00735847f, -0.18219493f, 
    -0.03205094f, -0.07816602f, -0.07774311f, 0.03665866f, 0.06271843f, 0.11201140f, 0.00188993f, 0.01876129f, 
    -0.11065933f, 0.01191136f, 0.10702235f, 0.15230621f, 0.06661725f, 0.01559066f, -0.01686280f, -0.02590292f, 
    -0.00053071f, -0.06001419f, 0.01041867f, -0.05188865f, 0.00201753f, 0.20866516f, 0.14158420f, 0.13512655f, 
    -0.10676133f, 0.03793149f, -0.07021418f, 0.06758998f, 0.05466439f, 0.01247277f, 0.00148674f, -0.01416861f, 
    0.13586578f, 0.13155869f, -0.04318615f, -0.18767220f, -0.05938791f, 0.00061686f, 0.09751970f, 0.00601748f, 
    0.10688327f, 0.02555139f, -0.02893753f, 0.09156077f, -0.38950840f, 0.02047467f, -0.09256653f, -0.19519903f, 
    -0.08559948f, 0.00792229f, -0.01518131f, 0.01174958f, 0.13198924f, -0.01234536f, 0.10665184f, -0.00274535f, 
    -0.21956810f, 0.19853604f, 0.05743248f, -0.05195733f, -0.06222254f, 0.01314924f, -0.16531542f, -0.00083254f, 
    0.02913458f, -0.00487410f, -0.00200855f, -0.05838387f, 0.08863859f, 0.22083156f, -0.05181519f, 0.04151830f, 
    0.04243333f, -0.02877875f, -0.21506281f, -0.00454885f, 0.02292694f, -0.20974343f, 0.11829640f, -0.04915468f, 
    0.00551003f, 0.08836358f, -0.00893571f, -0.16872035f, 0.05616012f, -0.00993840f, -0.05988041f, -0.08461730f, 
    -0.01595090f, 0.04141930f, -0.00484850f, 0.05342758f, 0.13397032f, 0.12535776f, -0.32114679f, -0.17318641f, 
    -0.05886860f, 0.00105890f, 0.01603769f, -0.11938282f, 0.04966702f, 0.00306808f, -0.02024081f, 0.01468034f, 
    -0.28855023f, 0.01484545f, -0.10348591f, -0.25551420f, 0.00255828f, -0.02643269f, -0.16582891f, -0.04134582f, 
    0.01914342f, -0.08867913f, 0.05249869f, -0.05497711f, 0.08116896f, -0.04782126f, 0.07970890f, 0.00575804f, 
    0.00190200f, 0.01152390f, 0.07629829f, 0.03034195f, 0.04756629f, -0.08864515f, -0.06707657f, 0.05190730f, 
    -0.10645507f, 0.15817574f, -0.08749844f, -0.17862616f, 0.08123194f, -0.05962728f, -0.06847772f, 0.00601144f, 
    0.12021723f, 0.02596759f, 0.06688272f, 0.00235745f, 0.14970304f, 0.13659094f, 0.05649655f, 0.12924875f, 
    -0.00701179f, -0.09463689f, -0.04538909f, 0.03385364f, 0.09368391f, -0.05399698f, -0.06877508f, -0.16065891f, 
    -0.10958963f, -0.05106227f, -0.02900486f, -0.10963012f, -0.14030866f, -0.06606562f, 0.13215594f, -0.08463829f, 
    0.01260892f, 0.06470451f, 0.06070825f, -0.02305856f, -0.01112271f, -0.07428996f, 0.05991380f, -0.12978910f, 
    0.02367133f, -0.16269977f, -0.10719576f, -0.06052756f, 0.03481720f, 0.07197088f, -0.06271107f, 0.04899255f, 
    -0.03099835f, 0.00808790f, -0.14782229f, 0.07405777f, -0.07254858f, -0.07262824f, -0.06505802f, -0.21229991f, 
    0.00100460f, -0.02948094f, -0.01436660f, 0.01216783f, -0.22692680f, -0.08484209f, 0.14551549f, 0.06937286f, 
    -0.08923063f, -0.01666437f, -0.12176889f, -0.10267278f, 0.05192567f, -0.05985880f, 0.11143358f, -0.01610981f, 
    0.20745113f, -0.18546580f, 0.00081979f, 0.07392769f, 0.08686142f, -0.07454143f, -0.05820897f, -0.01161883f, 
    -0.02866440f, -0.00069965f, -0.02344505f, -0.04003980f, 0.12547655f, -0.05086495f, -0.15417676f, -0.04591367f, 
    0.10006721f, 0.00554252f, -0.06091246f, -0.08736505f, 0.04865737f, -0.02547533f, 0.11533952f, 0.00004022f, 
    -0.27263939f, -0.24291827f, 0.08281144f, 0.01074099f, -0.00653726f, -0.05032611f, -0.01088558f, -0.03010803f, 
    -0.05889120f, 0.06723907f, 0.11801264f, 0.08541232f, 0.04090473f, -0.05126042f, -0.04693871f, 0.09250650f, 
    0.07373730f, -0.11270989f, -0.04942622f, 0.00649940f, 0.15982233f, 0.04872380f, 0.03358252f, 0.01675247f, 
    0.17353521f, 0.07514665f, -0.19552797f, 0.09600124f, -0.00709517f, -0.00565146f, 0.00728598f, -0.00584487f, 
    0.01714518f, 0.01702106f, 0.06816390f, -0.04842957f, -0.10821984f, 0.17013207f, -0.23430552f, -0.16844082f, 
    -0.00705383f, -0.06710904f, 0.05884958f, -0.09128243f, 0.04106978f, -0.01167630f, 0.07105387f, 0.08323157f, 
    -0.05402526f, -0.09710241f, 0.00759710f, 0.10704361f, 0.11730047f, 0.03706286f, -0.06055818f, 0.01021592f, 
    -0.05860777f, -0.01876462f, 0.12017988f, -0.05495835f, 0.05069955f, -0.12865719f, -0.00543512f, 0.23307425f, 
    0.10868369f, 0.01237966f, -0.03140589f, -0.05603202f, 0.02469579f, 0.00297644f, 0.09001658f, -0.06174004f, 
    -0.23814423f, -0.00700569f, 0.21003681f, -0.05531767f, 0.01715531f, -0.04329626f, 0.05049126f, -0.04356973f, 
    -0.00761841f, -0.06303260f, -0.06267671f, -0.13078342f, 0.13926040f, -0.08965553f, 0.05674434f, 0.09360759f, 
    -0.04905813f, -0.05976035f, 0.00610365f, -0.05582177f, 0.04096886f, 0.00067028f, -0.11198169f, -0.06321330f, 
    0.08344864f, -0.05117947f, 0.03923272f, 0.06024580f, -0.02794557f, -0.01754755f, 0.05770918f, 0.03682333f, 
    -0.00107690f, -0.07167143f, 0.02968024f, 0.04531742f, 0.06473600f, -0.00988673f, 0.15950388f, -0.05713618f, 
    -0.04094556f, -0.14222693f, -0.02586507f, -0.03941054f, 0.00662473f, 0.05424362f, -0.00384097f, -0.04267000f, 
    -0.02981742f, 0.06504059f, 0.18494162f, -0.13476920f, -0.00864393f, 0.05798027f, -0.08150806f, 0.02592209f, 
    -0.02470467f, 0.04935391f, 0.01704348f, -0.15378198f, -0.04451689f, 0.00815215f, -0.01403334f, 0.14641307f, 
    0.09376755f, 0.02546623f, -0.01974863f, -0.10849917f, 0.05467816f, 0.09346723f, 0.03233114f, 0.06964809f, 
    -0.11428845f, -0.02416548f, -0.18077454f, -0.10411912f, 0.00393688f, 0.05339376f, -0.13428050f, 0.00354806f, 
    0.03167871f, 0.05193373f, 0.12470131f, -0.07558013f, 0.21044295f, -0.14393003f, -0.25436452f, 0.01185600f, 
    0.12888576f, 0.01041366f, 0.02215935f, -0.07558479f, -0.03072506f, 0.02337315f, 0.10855967f, 0.00920772f, 
    0.15532027f, 0.23400748f, -0.20312090f, 0.05151533f, -0.00212836f, -0.00206491f, -0.15139475f, 0.02200155f, 
    -0.05666386f, -0.00999441f, -0.10020667f, -0.01525293f, 0.01035315f, -0.13773081f, 0.01088603f, -0.06048840f, 
    0.00059375f, -0.16933501f, -0.17713921f, -0.05406097f, 0.06256209f, -0.10730834f, -0.16234297f, -0.05548814f, 
    0.03935900f, -0.16718628f, 0.14565001f, 0.18796177f, 0.05694906f, 0.02786895f, -0.02347270f, 0.01616113f, 
    0.11596376f, -0.05122161f, 0.06231451f, -0.11524596f, -0.22690378f, -0.21807729f, 0.05450788f, 0.02115163f, 
    -0.05458235f, -0.06699703f, -0.03395890f, -0.10956553f, -0.01401421f, -0.00578911f, -0.02219166f, 0.10165901f, 
    -0.07040349f, -0.12899950f, 0.19344990f, -0.04071565f, -0.01429025f, -0.09608672f, 0.06756524f, -0.14662555f, 
    -0.00692138f, -0.04562523f, -0.03205367f, 0.02179176f, -0.05496986f, -0.06811473f, -0.14545198f, -0.08247559f, 
    -0.03234322f, 0.04058542f, -0.06436154f, 0.02131722f, -0.08923501f, 0.02626484f, 0.03335846f, 0.13803993f, 
    -0.04016317f, 0.01351526f, 0.16105288f, -0.04508653f, 0.04040032f, -0.00178141f, -0.07651991f, 0.07745976f, 
    -0.13759384f, 0.01603844f, 0.11506601f, -0.02760509f, 0.23377997f, 0.08318330f, -0.01966640f, 0.16258273f, 
    0.05859532f, 0.01812180f, -0.00831152f, -0.05646086f, -0.15562566f, -0.12163311f, 0.07960402f, -0.06737121f, 
    0.08225569f, 0.15015127f, -0.05314554f, 0.08395119f, -0.02026094f, 0.04189653f, -0.03850726f, -0.01003942f, 
    -0.03634675f, -0.03304476f, 0.05350956f, 0.05095631f, 0.03332155f, 0.15066524f, -0.11499623f, 0.05318428f, 
    0.01437055f, 0.01355473f, 0.00535036f, 0.02383887f, 0.09957152f, 0.05331231f, -0.15064549f, -0.03352796f, 
    0.13092789f, 0.05041483f, -0.02045485f, 0.15978310f, 0.11779552f, -0.02517295f, -0.05789578f, -0.03945011f, 
    0.05942767f, 0.03127233f, 0.04081936f, -0.00581383f, -0.01075656f, -0.24289908f, -0.01377062f, -0.07384264f, 
    -0.08085823f, -0.00880715f, -0.02007353f, -0.01050893f, 0.03462794f, -0.14765078f, -0.13637207f, 0.00303478f, 
    -0.07580681f, -0.20775579f, 0.04016857f, 0.03339455f, 0.05651388f, -0.05869615f, 0.02308806f, -0.14411236f, 
    -0.09330713f, -0.00331096f, 0.07594721f, 0.03805376f, -0.02255211f, 0.04880405f, -0.29927036f, -0.20279630f, 
    0.03285395f, 0.03148619f, 0.00417351f, -0.04533401f, 0.03594551f, -0.09715903f, -0.03675782f, 0.06180658f, 
    -0.03621226f, -0.07507532f, 0.02822266f, -0.19062345f, 0.02051004f, -0.03998138f, 0.07192499f, 0.04781842f, 
    0.00384891f, -0.03436378f, 0.08447713f, -0.19405510f, 0.17121089f, 0.08825168f, -0.14116330f, 0.06938220f, 
    -0.06572051f, 0.05992116f, 0.02319342f, -0.01384629f, 0.05471951f, 0.05439410f, -0.04031638f, -0.01049444f, 
    -0.00987147f, -0.09833532f, -0.16822349f, -0.12346601f, -0.06724862f, -0.04346599f, 0.10352273f, -0.01502282f, 
    0.04419867f, -0.03582311f, 0.10704073f, -0.03251072f, 0.09688182f, -0.00990667f, -0.04734103f, 0.15804662f, 
    0.06949752f, 0.01446226f, -0.03349955f, -0.03992540f, -0.02281607f, 0.07166858f, -0.11481351f, 0.01057189f, 
    0.05208747f, -0.10790122f, 0.14491425f, 0.06388441f, 0.02528501f, -0.04873148f, -0.00812756f, -0.09766039f, 
    0.02060242f, 0.06460217f, -0.04025665f, 0.03667288f, -0.22975941f, 0.01234121f, 0.13489038f, -0.03563204f, 
    -0.11094274f, -0.05525775f, 0.06398911f, 0.01116576f, 0.03578462f, -0.00283261f, -0.02334521f, -0.06444459f, 
    0.14242442f, 0.01613327f, -0.04527036f, 0.03745260f, 0.07869198f, -0.01513236f, -0.03796635f, -0.06817704f, 
    -0.10614654f, -0.02939716f, 0.10497909f, 0.04917563f, 0.23479082f, 0.02297487f, -0.29961428f, -0.00527553f, 
    0.03077149f, 0.04734126f, 0.05945119f, -0.06479653f, -0.00402908f, -0.05964456f, 0.08558943f, 0.07653095f, 
    -0.00660947f, -0.22328998f, -0.06919938f, -0.03510227f, 0.01819139f, -0.03442999f, -0.00372616f, 0.03764338f, 
    0.09699588f, 0.11679552f, -0.05043728f, -0.01048938f, 0.10312188f, 0.03438328f, 0.03990747f, 0.12834428f, 
    0.02490678f, 0.01180443f, -0.04794575f, -0.03130027f, -0.07801288f, 0.03582666f, -0.00232936f, 0.03862393f, 
    0.10804500f, 0.06615197f, 0.02778452f, 0.09898316f, -0.08304655f, -0.00416535f, -0.00526558f, -0.05093905f, 
    -0.01525830f, -0.01328125f, -0.09249043f, 0.04201329f, -0.05114158f, 0.08217312f, -0.08524512f, -0.13797906f, 
    0.01490480f, 0.04611474f, -0.00289841f, -0.04203621f, -0.01300041f, 0.03249619f, -0.10506424f, 0.06199411f, 
    0.13636364f, -0.07413927f, 0.12605126f, 0.09744472f, -0.03736531f, -0.05691451f, -0.00991061f, 0.02134860f, 
    0.06099872f, -0.08792390f, 0.05797676f, 0.01470185f, 0.12033918f, -0.11150304f, -0.02852877f, -0.11909698f, 
    0.08499605f, -0.12885077f, 0.07751947f, 0.00167036f, 0.01024791f, 0.07369533f, 0.00088520f, 0.06113090f, 
    -0.07852641f, -0.12910949f, -0.05794103f, -0.20191751f, -0.09513207f, -0.01192716f, 0.00202954f, -0.08577002f, 
    -0.00493850f, -0.00219359f, 0.05924930f, -0.01410254f, 0.02246466f, -0.02673329f, -0.04315443f, 0.09631203f, 
    0.05689144f, -0.17916012f, -0.09400707f, -0.01618334f, -0.11965925f, 0.08779126f, -0.11293685f, -0.03261152f, 
    0.12475815f, 0.08757834f, -0.02571627f, 0.17820056f, -0.14879245f, 0.06693976f, 0.02626704f, 0.10694988f, 
    0.00083302f, 0.06892064f, 0.05197908f, 0.05169560f, 0.01001419f, -0.10658229f, -0.08702314f, -0.29401529f, 
    -0.10093285f, 0.01486475f, 0.00516088f, -0.06474026f, 0.02114061f, 0.04963632f, 0.07797641f, -0.08095609f, 
    -0.07787917f, 0.19081233f, -0.05734182f, -0.28017429f, 0.08014207f, -0.01932888f, 0.03776500f, -0.05802261f, 
    -0.21757405f, -0.02259620f, 0.06696816f, -0.13659786f, -0.07669766f, 0.09462638f, 0.11410278f, 0.07341843f, 
    0.08721884f, -0.00966937f, 0.03778346f, 0.15479124f, 0.00060906f, -0.00269625f, -0.00723889f, -0.03615808f, 
    0.36212006f, 0.04577009f, -0.01640138f, -0.05824437f, 0.01638293f, -0.01474937f, 0.04370479f, -0.05937038f, 
    -0.05982217f, -0.00603415f, 0.04307164f, 0.09344421f, 0.01718456f, -0.08586449f, -0.19638456f, 0.13912416f, 
    -0.08001968f, 0.04419316f, -0.09741957f, 0.06348752f, -0.08538888f, 0.05935422f, -0.08672779f, -0.01702413f, 
    0.02783792f, 0.15758932f, 0.08640969f, 0.16424070f, 0.06173352f, -0.02150184f, -0.03302741f, 0.05568999f, 
    0.08725416f, 0.01135735f, -0.00709169f, 0.01857651f, -0.43833694f, 0.07875298f, 0.43043453f, -0.18163021f, 
    0.02525305f, -0.12680104f, 0.06891883f, 0.10932902f, 0.09931368f, -0.06819679f, -0.09522492f, 0.01501346f, 
    -0.09034062f, -0.11585667f, 0.07559215f, -0.00397994f, 0.02520008f, 0.02885856f, -0.01604777f, -0.00277718f, 
    0.01823893f, -0.11749671f, -0.09673341f, -0.06889579f, -0.28183445f, 0.21373507f, -0.08788806f, 0.22505945f, 
    0.08288310f, 0.04034974f, -0.10778461f, 0.04898344f, 0.07603040f, -0.10755031f, -0.06111267f, 0.08969396f, 
    -0.13133927f, 0.09114819f, 0.02293793f, -0.03637943f, 0.05166534f, 0.12240488f, 0.04282247f, 0.06394664f, 
    0.04817114f, 0.04193549f, -0.14286129f, 0.03801363f, -0.11595612f, -0.17125019f, -0.01691468f, -0.21651268f, 
    0.07464905f, -0.02084148f, 0.12278390f, -0.02565855f, -0.02278464f, 0.03042965f, 0.09576403f, 0.01331729f, 
    -0.31855851f, -0.32295099f, 0.17822446f, -0.17670991f, -0.01046836f, 0.02468263f, -0.00717384f, 0.05482464f, 
    0.02148299f, -0.18859902f, 0.04015318f, -0.08049347f, 0.00838633f, 0.19267228f, -0.32499573f, -0.17375952f, 
    0.05314168f, -0.03364968f, -0.08754556f, -0.00240827f, -0.05812471f, 0.00610712f, -0.09272495f, 0.15326072f, 
    0.04844591f, 0.07005027f, -0.17515035f, 0.00225156f, 0.00443789f, -0.01844175f, -0.00291909f, 0.14873199f, 
    -0.12753841f, -0.01951381f, -0.08698672f, -0.02153183f, -0.21693252f, 0.13242823f, -0.01288762f, -0.06211068f, 
    -0.01831476f, -0.07197345f, 0.13381915f, -0.05823570f, 0.06520177f, 0.09694147f, 0.09768064f, 0.04536326f, 
    0.46430820f, -0.23243354f, -0.11536908f, -0.04334646f, -0.06398024f, -0.04679231f, 0.17740960f, 0.19174960f, 
    0.01555093f, 0.03077520f, -0.04702196f, -0.02760680f, 0.22538833f, -0.16905282f, -0.10356487f, 0.11001654f, 
    0.05395742f, -0.08874033f, 0.04184831f, -0.08107465f, -0.00606977f, -0.06602806f, 0.04840669f, -0.01925227f, 
    0.03223417f, 0.09367876f, -0.05300022f, -0.13683563f, 0.06713583f, 0.03691437f, 0.06935985f, -0.26540953f, 
    -0.04700927f, -0.08665622f, 0.00780920f, 0.09594569f, 0.01872124f, -0.04407482f, -0.06257389f, -0.13889976f, 
    -0.07035550f, 0.15409246f, 0.12213201f, 0.01045795f, -0.13846646f, -0.04916348f, -0.20862615f, 0.00704797f, 
    -0.21265259f, 0.04619926f, -0.14550021f, 0.04731779f, 0.04783374f, -0.05466267f, -0.01722430f, -0.11153543f, 
    -0.00234953f, 0.02429725f, 0.00127907f, 0.16358121f, -0.34649849f, -0.23226328f, -0.01660764f, -0.03384767f, 
    -0.01095035f, -0.04907105f, 0.00323907f, 0.02468596f, -0.08171369f, -0.22940248f, 0.01616748f, -0.06810560f, 
    0.15928818f, -0.15864706f, 0.20186855f, -0.12628932f, 0.01372871f, -0.01042870f, -0.04163573f, -0.00383819f, 
    -0.03496153f, -0.10771898f, 0.01053662f, -0.09784305f, -0.31085074f, -0.05179728f, -0.19220793f, 0.18652016f, 
    0.05167541f, -0.02557317f, -0.00929266f, 0.01020292f, -0.08106631f, 0.07390332f, 0.07921319f, 0.06209163f, 
    -0.19039713f, 0.14880270f, 0.05069538f, -0.18436287f, 0.12223346f, -0.02160283f, -0.14517225f, -0.05382638f, 
    -0.13386509f, -0.04101951f, -0.06718706f, -0.07651650f, -0.22649916f, 0.00044670f, -0.10412092f, -0.19923240f, 
    0.02635563f, -0.00021983f, 0.04632368f, -0.09489259f, -0.07756428f, -0.00702832f, -0.08676913f, -0.06456447f, 
    -0.06873047f, -0.24186154f, -0.22180329f, 0.09234235f, -0.04717179f, -0.04190769f, -0.10100233f, -0.05217208f, 
    -0.02223445f, 0.01281527f, 0.05638072f, -0.00880626f, -0.15796889f, 0.10086410f, -0.12394046f, -0.02147516f, 
    0.16137967f, 0.02072048f, -0.07091121f, -0.06153546f, -0.11910444f, -0.04568456f, 0.10890274f, 0.00761406f, 
    0.15071705f, -0.03824457f, 0.06535935f, -0.12055777f, 0.05777758f, -0.00970433f, 0.06684982f, -0.07538200f, 
    0.06290545f, -0.04643143f, 0.07507616f, -0.00142575f, 0.21836911f, -0.00922292f, -0.10043546f, 0.01517000f, 
    0.17227653f, 0.03253871f, 0.05626573f, 0.05812709f, 0.04414588f, 0.00792512f, 0.06116444f, 0.08992645f, 
    -0.28555951f, -0.13449122f, 0.15714334f, 0.06482467f, 0.03211287f, -0.09072674f, 0.05203454f, -0.13800652f, 
    0.03399520f, -0.09333429f, -0.19624855f, 0.05303279f, -0.23463333f, 0.13553080f, -0.13502179f, -0.24354494f, 
    0.00395671f, -0.02366477f, 0.09303723f, 0.03604972f, -0.05006329f, 0.06072918f, 0.00685640f, 0.01145700f, 
    0.38326052f, -0.03722862f, 0.12274697f, 0.01234554f, -0.08425284f, 0.11234210f, 0.05512031f, -0.15115936f, 
    -0.04354948f, -0.01166065f, -0.12424421f, 0.03556039f, 0.03933598f, -0.05149575f, 0.18366285f, -0.18414390f, 
    -0.10466938f, 0.01636791f, -0.09176779f, 0.07280249f, -0.01838094f, 0.09315815f, 0.04645541f, 0.03683791f, 
    0.03575105f, 0.15723158f, 0.22045788f, 0.05359207f, 0.01188627f, 0.00917220f, 0.07982549f, 0.06313094f, 
    0.03894939f, 0.15121888f, 0.07154400f, 0.06570526f, 0.02569971f, -0.01173616f, -0.06050570f, 0.18594339f, 
    -0.13471209f, -0.07509187f, 0.01718936f, 0.01074873f, 0.09143967f, 0.04494014f, 0.05928231f, 0.05828321f, 
    -0.52248186f, 0.42662913f, -0.11031450f, -0.31791317f, 0.07815347f, 0.00724565f, -0.06144527f, -0.07635215f, 
    -0.13080016f, -0.02030477f, -0.09204663f, 0.05175464f, 0.11148388f, -0.03183741f, -0.10763820f, 0.07098474f, 
    0.08383222f, -0.06541169f, 0.03635221f, 0.07187531f, -0.06762236f, -0.10869440f, 0.04988791f, -0.17705010f, 
    0.02526891f, -0.08296882f, 0.02315011f, 0.19837844f, 0.00349209f, 0.04411598f, -0.10337544f, 0.09764555f, 
    -0.02123979f, 0.07152501f, -0.04718154f, -0.07721143f, 0.10172923f, -0.08941467f, -0.14890891f, -0.00035756f, 
    -0.13772403f, 0.02178283f, 0.10423182f, 0.11768056f, 0.01556364f, 0.02373712f, 0.01563597f, -0.13260451f, 
    -0.20418017f, -0.02298293f, 0.15077008f, 0.23910728f, -0.02201826f, -0.06015625f, -0.02995848f, 0.01930862f, 
    0.10785095f, -0.00748947f, -0.09898101f, -0.03333678f, -0.05687149f, 0.02839311f, -0.09825174f, 0.02908223f, 
    0.04501268f, 0.01065574f, 0.05872540f, -0.04000424f, 0.14223906f, 0.08215901f, 0.08024308f, -0.04161802f, 
    -0.18623666f, 0.50218940f, -0.10552475f, -0.01813478f, -0.00447604f, 0.03774566f, 0.00387304f, -0.05443727f, 
    -0.05437190f, 0.14545721f, 0.14966637f, -0.03234521f, -0.03025458f, -0.07534861f, -0.18686101f, 0.10160231f, 
    0.03126746f, 0.07125662f, 0.01653187f, 0.12635837f, -0.12511882f, -0.00282550f, 0.00291624f, -0.01722133f, 
    0.07620830f, 0.10160851f, -0.27030915f, -0.09128691f, 0.06734980f, 0.01681832f, -0.02168624f, 0.10507711f, 
    -0.03361626f, 0.03724282f, -0.11612821f, 0.00798859f, 0.14443147f, -0.04845672f, -0.07096018f, 0.09815304f, 
    -0.02533633f, 0.02581584f, 0.10050030f, -0.06497443f, -0.10689261f, 0.04911346f, -0.02180423f, 0.07632302f, 
    0.18323722f, 0.01219667f, 0.07298834f, 0.14407799f, 0.04201146f, -0.02637036f, 0.07176831f, -0.02144186f, 
    0.04749933f, -0.00724381f, -0.05423347f, 0.00038425f, 0.01715595f, 0.17192130f, 0.02258062f, -0.04279744f, 
    -0.05015105f, 0.00484790f, -0.03314302f, 0.05033236f, -0.04651949f, 0.06183466f, 0.00599717f, -0.04637844f, 
    -0.19199891f, -0.07079262f, 0.07738558f, 0.03761325f, 0.09112846f, 0.02817469f, 0.00955550f, -0.19632347f, 
    0.01389737f, -0.08435826f, -0.16701005f, 0.08334109f, -0.25185165f, 0.37775841f, 0.13490318f, 0.07192136f, 
    -0.00043048f, 0.03748706f, -0.05113503f, -0.00479779f, -0.02298475f, 0.11397563f, -0.06515428f, -0.02832547f, 
    -0.29356107f, 0.05775286f, -0.04324977f, -0.07123154f, -0.00552489f, 0.01752093f, -0.01033701f, 0.03380309f, 
    -0.06778815f, -0.00052271f, -0.04756550f, -0.00735093f, -0.04044038f, 0.06034305f, 0.09924052f, -0.09285564f, 
    0.04411445f, 0.06543054f, -0.01409005f, -0.12456852f, 0.07307800f, 0.00707125f, -0.00307951f, 0.02286648f, 
    0.10876248f, 0.12706302f, -0.02050473f, -0.18753114f, 0.00603016f, 0.10512024f, -0.08735789f, 0.04873936f, 
    0.00039732f, -0.07522215f, 0.17116761f, -0.06391868f, 0.03027824f, 0.11333767f, -0.16721576f, 0.14251894f, 
    -0.03869821f, 0.12450627f, -0.02895940f, -0.07275252f, -0.03553073f, -0.02484801f, 0.14577493f, 0.03209658f, 
    0.05537854f, 0.09637012f, -0.06179662f, 0.05028212f, 0.03943320f, 0.03776021f, -0.00572640f, 0.01522343f, 
    0.07062840f, -0.00499889f, -0.01366860f, -0.10403647f, -0.02017186f, 0.21520998f, -0.14322773f, -0.43108034f, 
    -0.02756918f, 0.03862434f, -0.03063867f, 0.01511270f, -0.02684952f, 0.03683075f, 0.03759203f, 0.06074806f, 
    -0.11731293f, 0.02235676f, 0.14885892f, -0.19181463f, 0.05675348f, 0.00255874f, -0.06370424f, -0.02732171f, 
    0.00487741f, -0.00540471f, -0.02573264f, -0.11597841f, -0.09460833f, 0.13143949f, 0.02651880f, -0.09548477f, 
    0.01496068f, 0.06686395f, -0.01339639f, -0.03736846f, -0.02043287f, 0.04427457f, -0.21090937f, -0.00103162f, 
    0.04097430f, -0.12334676f, 0.01162729f, -0.08348763f, 0.01847257f, -0.02976047f, 0.14631498f, 0.06893294f, 
    0.05874666f, -0.04605608f, 0.05440601f, -0.02527589f, -0.02932334f, 0.10189808f, 0.08340576f, 0.07270104f, 
    -0.06592884f, -0.08485567f, -0.12206541f, 0.23720233f, 0.07250612f, -0.05196490f, 0.12793876f, 0.11362916f, 
    -0.34607765f, 0.24811749f, -0.24172835f, -0.05077539f, 0.05510653f, 0.11377490f, -0.01696064f, -0.00637376f, 
    -0.07857040f, -0.05199395f, 0.04253807f, -0.11918985f, 0.44160062f, 0.17205679f, -0.26586998f, 0.01015406f, 
    0.04281738f, -0.01551410f, -0.05548745f, 0.01127577f, -0.11166680f, -0.00752445f, -0.13354670f, -0.00543596f, 
    -0.09814250f, -0.15854511f, -0.13527441f, -0.00538750f, -0.00277154f, 0.04179364f, -0.00289628f, -0.03596054f, 
    -0.02492750f, 0.04752568f, -0.05593599f, -0.03975235f, -0.09688555f, -0.13212259f, -0.13379282f, 0.11167365f, 
    -0.01874635f, 0.04155127f, -0.00907743f, 0.03358709f, 0.11381906f, 0.06992166f, 0.09577145f, 0.10819574f, 
    0.03898381f, 0.06908348f, 0.09525372f, 0.10969669f, 0.10512253f, -0.01388682f, 0.04426263f, 0.10354935f, 
    0.13060744f, -0.05703489f, -0.09897450f, -0.08049366f, -0.00009102f, 0.18139650f, -0.00055181f, -0.17554560f, 
    0.00662981f, 0.02461199f, 0.02104693f, 0.09441172f, 0.03218502f, -0.04007909f, -0.02755257f, 0.25222868f, 
    -0.27687436f, -0.26914015f, 0.00194291f, -0.18248710f, 0.06032390f, 0.01806572f, 0.05248078f, 0.02808337f, 
    0.06771447f, 0.02565525f, -0.02209304f, 0.11183073f, 0.00571332f, -0.03472908f, 0.05787144f, -0.02086954f, 
    -0.06396775f, 0.03541435f, 0.00967850f, 0.03410389f, 0.08450712f, -0.02659669f, 0.05840509f, -0.04109620f, 
    -0.14092480f, 0.01957849f, 0.08821149f, 0.20028812f, 0.12985462f, -0.00207341f, 0.02959827f, 0.05091034f, 
    -0.04607534f, 0.11123657f, 0.12269870f, 0.05092818f, -0.11763013f, -0.07670102f, 0.11942341f, -0.02792540f, 
    0.06761972f, 0.07285932f, 0.00303672f, 0.07715232f, 0.05107094f, -0.05196469f, 0.02683214f, -0.06187158f, 
    0.14653383f, 0.02886446f, 0.02663282f, -0.01141466f, -0.12373710f, -0.00035617f, 0.10682192f, -0.00032235f, 
    -0.02951947f, 0.02291275f, 0.02751729f, 0.00688181f, -0.24254447f, 0.01632253f, -0.04491153f, 0.01790783f, 
    0.01943661f, -0.00582560f, -0.02314890f, -0.03306649f, 0.09813845f, -0.09597625f, 0.09703100f, 0.04667546f, 
    0.02584476f, 0.01132553f, -0.05597363f, -0.05197117f, 0.02733852f, 0.15188856f, 0.00852216f, -0.05128213f, 
    0.02523339f, 0.12342206f, -0.00262571f, 0.04182344f, -0.04216909f, -0.20261165f, 0.09553815f, -0.00902892f, 
    -0.08120568f, 0.02524318f, -0.05702218f, -0.01667452f, 0.09573998f, 0.03129601f, 0.04717514f, -0.03355824f, 
    0.10362820f, 0.07386502f, -0.08211751f, -0.00590701f, 0.10546482f, 0.15863709f, -0.01390203f, -0.03062331f, 
    -0.06418331f, -0.05250335f, 0.04267434f, -0.04893040f, 0.02620861f, -0.02747707f, 0.02541815f, 0.08788776f, 
    -0.07313805f, -0.06182915f, 0.05100334f, -0.07184406f, 0.00895525f, 0.01399466f, -0.06876157f, 0.00214674f, 
    -0.11033846f, 0.07589151f, -0.14138292f, 0.07092074f, 0.06559980f, 0.00257855f, -0.03206876f, -0.11046303f, 
    -0.03350255f, 0.12710583f, 0.01390216f, -0.02884199f, 0.03448927f, 0.01070351f, -0.08247984f, -0.11252543f, 
    0.03319909f, -0.11470120f, 0.00879389f, 0.07749432f, -0.05335205f, 0.05475594f, -0.00858469f, -0.01636000f, 
    0.19944136f, -0.08278028f, -0.05174879f, 0.01294561f, 0.01175431f, -0.10006930f, 0.12789036f, -0.04032765f, 
    0.00785464f, 0.14782739f, 0.01003216f, 0.04587993f, -0.28464070f, -0.13273008f, 0.05533941f, 0.10716313f, 
    0.11974435f, -0.00412742f, 0.04711441f, -0.18739459f, 0.06627391f, -0.10249343f, -0.12447329f, 0.01323182f, 
    -0.01251198f, -0.01569048f, -0.10852758f, 0.06147356f, 0.01245319f, -0.01089745f, -0.04897462f, -0.00430416f, 
    0.00001027f, -0.00836601f, 0.09412588f, -0.03194267f, 0.26125926f, 0.04983258f, -0.00594241f, -0.02531935f, 
    0.00906913f, -0.07150366f, -0.03228097f, 0.04232701f, -0.04615541f, 0.05135199f, -0.02979874f, 0.04681423f, 
    -0.14987583f, -0.00229789f, -0.04919554f, 0.06326561f, 0.04416300f, -0.02436802f, -0.03132451f, 0.09082096f, 
    0.02372146f, 0.08977564f, 0.00883502f, 0.06999961f, -0.27357978f, -0.21914917f, 0.05687820f, 0.03769781f, 
    0.04585124f, -0.00521614f, 0.03110646f, -0.01589708f, 0.23309298f, 0.05765062f, 0.09465563f, 0.00607555f, 
    -0.06861332f, -0.14917320f, -0.06208975f, 0.02136996f, 0.07456988f, -0.02396462f, -0.04950520f, 0.09583828f, 
    -0.05001485f, -0.00815211f, -0.07301444f, 0.01151987f, -0.37453803f, 0.00400893f, -0.22767168f, 0.02998203f, 
    0.08216272f, -0.03805598f, -0.04932307f, -0.01168775f, 0.00189827f, 0.12172942f, 0.02174776f, -0.06721292f, 
    -0.12486022f, 0.02791195f, -0.12397818f, -0.01221076f, 0.09505171f, 0.04947848f, -0.12125331f, -0.05246215f, 
    -0.01748111f, 0.02494042f, 0.03298315f, 0.07544315f, 0.06005244f, -0.19263078f, -0.08700529f, 0.03924362f, 
    -0.01345361f, 0.05180002f, 0.00196967f, 0.04942114f, 0.03361902f, -0.04797938f, -0.08703197f, 0.05129376f, 
    -0.22395189f, -0.01532862f, -0.00068468f, -0.12895204f, 0.10348887f, 0.01525927f, 0.03111461f, 0.05153849f, 
    0.00411432f, 0.13261974f, 0.10833801f, 0.12457585f, -0.50576407f, -0.21753664f, -0.16055122f, -0.22043732f, 
    0.02822424f, -0.00741016f, -0.10264371f, -0.00378739f, 0.00609725f, 0.05201280f, -0.02529350f, -0.09499721f, 
    0.13359395f, -0.00847237f, -0.01290493f, -0.04780493f, -0.05729540f, 0.04176590f, -0.01831421f, -0.14689574f, 
    0.08249764f, 0.06139631f, -0.02767493f, 0.05836232f, 0.19169937f, -0.05664453f, -0.20664631f, 0.02440156f, 
    0.05794181f, -0.06393430f, 0.01467269f, 0.06370088f, -0.02446834f, -0.09609716f, -0.03243407f, 0.08544877f, 
    0.02231725f, 0.00627037f, -0.01566353f, 0.19314177f, 0.11536509f, 0.02237315f, 0.03877266f, -0.01498538f, 
    0.09118947f, 0.15280361f, 0.10371368f, 0.16330932f, 0.14955081f, 0.05218130f, 0.07941622f, -0.07677952f, 
    -0.09228474f, 0.01322986f, -0.02045383f, -0.08431329f, 0.08068722f, -0.08974073f, -0.16974476f, -0.06414665f, 
    0.20875086f, -0.03360161f, 0.00066886f, -0.05529489f, -0.04605806f, 0.00794058f, -0.00197627f, 0.09432384f, 
    0.00225294f, -0.00634566f, 0.06995600f, -0.09715695f, -0.23339045f, -0.35135323f, -0.15373665f, -0.01096883f, 
    0.10572887f, -0.06178648f, -0.02344808f, 0.01305966f, -0.01150185f, 0.06478798f, 0.09426593f, -0.04049389f, 
    -0.53456366f, -0.07050794f, 0.22996812f, 0.16920514f, 0.12179031f, 0.04306224f, -0.07320856f, 0.00196157f, 
    -0.00004231f, 0.08480099f, -0.06729192f, 0.10196491f, -0.34095466f, -0.06427434f, 0.11986559f, -0.09877521f, 
    0.07334280f, 0.05982420f, -0.03664614f, 0.01970706f, -0.08901335f, -0.02190431f, -0.09472024f, 0.02032011f, 
    -0.34753329f, -0.21264134f, -0.08131693f, -0.01758684f, -0.00775092f, 0.10195723f, -0.00929171f, -0.07690194f, 
    0.00361430f, -0.05854766f, -0.11888029f, -0.07817885f, 0.12003394f, -0.13655923f, 0.05270476f, 0.02763272f, 
    0.01187933f, -0.13950843f, -0.12526914f, 0.05633311f, 0.05638905f, -0.12236156f, -0.18079020f, -0.06429572f, 
    -0.27670449f, -0.26047134f, -0.09535766f, -0.24959384f, 0.01677461f, -0.02574694f, 0.04339746f, 0.03838455f, 
    0.08383663f, -0.04765886f, 0.09791217f, -0.00790055f, -0.08350939f, -0.00804188f, -0.04478396f, 0.03832789f, 
    -0.03161210f, 0.08741774f, 0.00789240f, 0.09235891f, 0.01190273f, 0.03388314f, -0.00057091f, 0.11757133f, 
    0.26795676f, -0.01143438f, 0.04716440f, -0.12448233f, -0.00326448f, 0.00436661f, 0.03442333f, -0.08125401f, 
    -0.04262974f, -0.05722759f, -0.10803173f, -0.06939657f, 0.21000673f, -0.07798199f, -0.02205949f, -0.09790666f, 
    0.08126020f, 0.06786852f, 0.03265342f, 0.09817366f, 0.05476729f, 0.12753122f, 0.08279897f, 0.15075676f, 
    0.12707418f, -0.23667140f, 0.08727883f, -0.15959631f, -0.12996536f, 0.03221205f, -0.06292789f, 0.13045336f, 
    -0.11659572f, -0.16561247f, -0.05563052f, 0.00055022f, 0.00199196f, -0.05343344f, -0.19327602f, -0.06224211f, 
    0.13527496f, 0.02218582f, -0.13024129f, -0.08225343f, -0.05296322f, -0.08222374f, -0.09733948f, -0.05081574f, 
    -0.07205561f, -0.27846143f, -0.00597631f, 0.02028205f, 0.11637898f, 0.09535936f, 0.06045293f, 0.08278718f, 
    0.06311360f, 0.11996219f, 0.04498894f, 0.11201337f, 0.19197682f, 0.03913793f, -0.04622219f, -0.07903018f, 
    -0.12391717f, -0.06279074f, 0.10081729f, -0.01234264f, 0.09220608f, -0.05631418f, -0.02406281f, -0.13205859f, 
    -0.24781568f, -0.06879177f, -0.19744870f, -0.10391066f, -0.01008521f, -0.07075602f, -0.04721247f, 0.07674860f, 
    -0.02164682f, 0.06309971f, 0.03508132f, -0.08607069f, 0.24624987f, 0.05427698f, -0.06332745f, 0.09884456f, 
    -0.04834884f, 0.03210288f, 0.00648942f, -0.00937684f, 0.06649292f, -0.09569263f, 0.02193455f, -0.07715737f, 
    -0.16953428f, 0.03499172f, -0.08107476f, -0.01304290f, 0.01161797f, -0.01157422f, -0.10082501f, 0.04277911f, 
    -0.05692723f, -0.05251513f, -0.03686858f, 0.07925513f, -0.08453237f, 0.04407910f, 0.17143174f, 0.01911654f, 
    0.18330950f, -0.06548739f, 0.04673659f, 0.00386009f, -0.07355982f, -0.12597273f, -0.00258252f, 0.03348282f, 
    0.22438678f, 0.06609662f, 0.01712943f, -0.06237724f, -0.00753441f, 0.12449062f, 0.05059851f, 0.00493345f, 
    0.03695876f, 0.07836274f, 0.11087669f, -0.05433954f, -0.26632372f, -0.31728116f, -0.10670312f, 0.20729201f, 
    -0.01853066f, -0.03158576f, 0.20090920f, -0.14271599f, 0.16275516f, -0.01300623f, -0.06952920f, -0.05784708f, 
    0.06893092f, -0.07486892f, 0.09228662f, 0.10145583f, 0.11801505f, 0.03774457f, 0.05995356f, 0.06555222f, 
    0.04453589f, 0.05299923f, -0.00595554f, 0.08053981f, -0.48590213f, -0.33991534f, -0.18647501f, -0.07825772f, 
    0.02739001f, -0.02729193f, -0.01339366f, -0.08481813f, 0.05432681f, 0.06617215f, 0.03134812f, 0.04845788f, 
    -0.52392763f, -0.25980738f, 0.12008476f, 0.01782113f, 0.13616836f, 0.01747796f, 0.02309137f, -0.11350844f, 
    0.05811835f, 0.03119906f, 0.02821995f, 0.06869788f, -0.03261896f, -0.07212964f, 0.03642344f, 0.17792165f, 
    -0.01065746f, -0.00595600f, 0.04925789f, 0.02941521f, 0.12089595f, -0.06993626f, -0.02319793f, -0.00762812f, 
    -0.37930638f, -0.24145232f, 0.02170618f, -0.03862447f, 0.06316040f, 0.03217211f, -0.01585534f, -0.03720114f, 
    0.05751389f, -0.07295863f, -0.02466291f, 0.10983814f, -0.12274231f, -0.04784621f, -0.04751216f, -0.02660098f, 
    0.08016516f, -0.00245328f, -0.01798177f, 0.03541290f, 0.02897680f, 0.13420011f, 0.08102720f, 0.01324199f, 
    0.08729175f, 0.29322940f, -0.02604520f, -0.10110800f, 0.11226718f, -0.18539044f, 0.07166484f, 0.02083132f, 
    0.01420248f, 0.07854249f, 0.05992071f, 0.12779632f, -0.30573192f, -0.21656092f, -0.05956003f, -0.04541718f, 
    0.06974627f, -0.06393208f, -0.00422208f, -0.00419513f, 0.00179027f, 0.07468692f, 0.07781561f, 0.08662010f, 
    0.11910967f, 0.03814307f, 0.04656017f, -0.03344403f, -0.11512591f, -0.01364412f, 0.03968992f, -0.14069919f, 
    0.06708452f, -0.04275313f, -0.12486133f, -0.01046667f, -0.00458848f, -0.16016854f, 0.11260224f, -0.09200152f, 
    -0.00205473f, 0.12840007f, -0.12061659f, 0.03273764f, 0.16590640f, -0.03480528f, -0.10018201f, -0.12786408f, 
    -0.39025059f, -0.25199187f, -0.01515451f, -0.18398888f, -0.00211902f, -0.04813523f, -0.00190408f, 0.04422090f, 
    -0.02053087f, 0.00560845f, -0.06248745f, 0.02940327f, -0.30458525f, -0.04874170f, -0.16264120f, 0.20529151f, 
    0.03054902f, 0.02052414f, 0.02264673f, -0.08334554f, 0.04472036f, -0.03094022f, 0.03539177f, -0.01534960f, 
    0.32919517f, 0.18175830f, -0.07444125f, -0.15053284f, 0.09609436f, 0.09994480f, 0.11529255f, 0.05648464f, 
    -0.03729230f, 0.07204935f, 0.08183524f, 0.00112986f, -0.17764693f, -0.24550301f, -0.06637480f, -0.07392624f, 
    0.02777743f, -0.08765011f, -0.02061051f, -0.08277535f, 0.00125899f, -0.01830313f, 0.02166501f, 0.02162484f, 
    0.00211174f, 0.06826181f, -0.17300817f, 0.10239951f, 0.07291751f, -0.08595195f, 0.07186199f, -0.05940625f, 
    -0.05139931f, 0.06086794f, -0.06600607f, -0.03422023f, 0.10747101f, -0.03016944f, -0.11208200f, 0.20344710f, 
    -0.07569291f, -0.03224146f, 0.05855669f, 0.07427909f, 0.02343631f, 0.00545940f, -0.07820305f, -0.16041483f, 
    0.19690655f, -0.12060076f, -0.08239848f, -0.16709250f, 0.02210150f, -0.06336284f, -0.01181216f, 0.02494191f, 
    -0.02558429f, 0.04614271f, 0.05985209f, -0.04449330f, -0.06495588f, 0.01797588f, 0.00300853f, 0.02312021f, 
    0.08036497f, -0.05432414f, 0.08847629f, 0.01594109f, -0.05758715f, 0.00739254f, -0.02282160f, -0.02167781f, 
    0.01079638f, -0.15419972f, -0.04378711f, 0.03175507f, -0.09607755f, 0.00814999f, 0.02316259f, 0.03469238f, 
    0.04360289f, -0.05745450f, 0.09024180f, -0.04655416f, 0.01131724f, 0.21479857f, -0.06985965f, 0.18750349f, 
    -0.02112432f, -0.05457014f, -0.02687300f, -0.25886559f, -0.05823578f, -0.04432242f, 0.01152270f, -0.07113544f, 
    0.14573045f, -0.07659720f, -0.07206018f, -0.02780964f, 0.02294076f, -0.03660412f, -0.03800296f, -0.05559921f, 
    -0.00795475f, -0.03175831f, 0.00476916f, 0.03335145f, 0.00804868f, 0.01753243f, -0.14254543f, 0.06130974f, 
    -0.01544795f, 0.01905968f, -0.17620254f, -0.10693923f, 0.00932200f, 0.02385398f, -0.10293450f, -0.12723184f, 
    0.11260670f, -0.02135422f, -0.09750987f, 0.02897881f, -0.16636923f, 0.01004023f, -0.01788240f, -0.00738678f, 
    0.04368056f, -0.01100339f, 0.11591194f, -0.04592879f, 0.07576825f, -0.23306914f, -0.13272509f, 0.13434146f, 
    0.05775229f, -0.00146825f, 0.09203240f, -0.00424311f, -0.06495717f, 0.00822073f, -0.06290986f, -0.06579778f, 
    0.13311400f, 0.03893554f, -0.25289884f, 0.08888033f, -0.05808811f, -0.02619089f, -0.00101937f, 0.05575674f, 
    0.02801653f, 0.09129848f, -0.04407337f, -0.03192511f, 0.08896722f, -0.16298103f, 0.02321769f, -0.11638323f, 
    -0.10794736f, 0.09333362f, 0.02786652f, 0.01510640f, -0.12344552f, -0.00478429f, -0.07272391f, -0.10787547f, 
    0.06633256f, -0.08537966f, -0.04896597f, 0.11452603f, -0.05383867f, 0.16306752f, -0.07850725f, -0.11284848f, 
    0.02220179f, -0.06073257f, -0.10175599f, 0.07140583f, -0.18486995f, -0.23965123f, 0.04903471f, -0.11988656f, 
    0.02102851f, -0.05240481f, -0.01153906f, -0.06339056f, -0.00966665f, -0.05872897f, 0.01723740f, 0.10888441f, 
    0.01361807f, -0.23799063f, 0.19854853f, 0.02897309f, -0.04523820f, -0.01904377f, -0.04220346f, 0.15178031f, 
    0.02123443f, -0.04460964f, 0.00173909f, 0.02223251f, 0.09019053f, 0.05435694f, 0.06345100f, -0.19249307f, 
    0.06164823f, -0.05276324f, -0.05218641f, -0.01134919f, 0.12227281f, 0.05205510f, 0.14577579f, 0.10644516f, 
    -0.24502917f, 0.08229308f, -0.00311518f, 0.05268323f, -0.01214224f, -0.06231007f, -0.04018316f, 0.05154423f, 
    -0.15687844f, 0.01412654f, 0.12343806f, 0.05852153f, -0.08798666f, 0.19455594f, 0.04565727f, -0.01349170f, 
    -0.02587109f, -0.00796538f, -0.01168459f, -0.06374677f, -0.06189941f, -0.02955792f, 0.03697151f, -0.04886954f, 
    -0.25687242f, 0.01193552f, 0.08348449f, -0.04204385f, -0.09290945f, 0.09384019f, 0.03692357f, 0.00769384f, 
    -0.02166802f, -0.05061744f, -0.00142415f, 0.04906752f, 0.00477322f, 0.16499276f, -0.24353597f, -0.08672918f, 
    0.01568818f, -0.10763275f, -0.09780476f, 0.06229893f, 0.02692225f, 0.06648555f, -0.07726553f, 0.00738834f, 
    -0.28485364f, 0.07377766f, -0.10815172f, -0.14624922f, 0.18984224f, -0.04272621f, -0.04391152f, 0.08728498f, 
    0.02787523f, 0.06617360f, 0.00464454f, -0.00003523f, -0.12465553f, -0.14420693f, -0.01064183f, 0.20341262f, 
    -0.01235873f, 0.04596940f, -0.07241794f, 0.11205117f, 0.02885537f, -0.08475522f, 0.07650735f, 0.13826431f, 
    0.10579861f, 0.08453473f, -0.08165151f, -0.03978592f, -0.09431689f, 0.02714119f, -0.04530061f, 0.06196881f, 
    -0.02809893f, 0.02025764f, -0.02431875f, -0.00739917f, -0.27852803f, 0.14490400f, -0.13143899f, 0.08218563f, 
    0.14534669f, -0.03627095f, 0.12348758f, -0.00233106f, -0.01788849f, -0.00540546f, -0.01154049f, 0.02056046f, 
    0.25648212f, -0.07612747f, -0.16374160f, -0.06544089f, 0.07170197f, -0.02669606f, 0.03252836f, 0.05084555f, 
    -0.01365038f, -0.00679772f, -0.03856600f, 0.02307952f, 0.16988227f, -0.07975543f, -0.19437788f, -0.19474955f, 
    -0.01713572f, -0.13458569f, 0.03892551f, -0.00312230f, 0.10266814f, -0.04237569f, -0.02976875f, -0.02753323f, 
    -0.03044780f, 0.18996681f, -0.01260666f, 0.00138429f, -0.05364345f, -0.04207185f, -0.11872007f, -0.04288632f, 
    0.04806947f, 0.02872945f, 0.06005841f, 0.00459411f, -0.25934067f, -0.21413963f, 0.01717152f, -0.09276613f, 
    -0.00548581f, 0.01785979f, 0.09718268f, 0.03458305f, 0.02991358f, 0.02304758f, -0.00530108f, -0.04111496f, 
    -0.06451231f, -0.11733317f, 0.03203778f, -0.03941565f, 0.08639020f, -0.01730202f, 0.07353218f, 0.05688000f, 
    -0.09188513f, 0.00204788f, 0.06782632f, -0.03333279f, -0.12345786f, -0.25725764f, 0.04506544f, -0.18945265f, 
    0.09781649f, -0.09021614f, 0.04595551f, 0.12181418f, -0.08569019f, 0.07288149f, 0.09401911f, -0.04602064f, 
    0.17530470f, -0.01255890f, -0.06316096f, 0.02387179f, -0.01076653f, 0.00055879f, -0.02652662f, -0.07595228f, 
    0.06543988f, -0.06072870f, 0.07804114f, -0.03700063f, -0.09031525f, 0.04466502f, 0.01401263f, 0.10668352f, 
    0.14938579f, -0.06428321f, 0.01420472f, 0.00304682f, -0.03346149f, -0.02395849f, -0.02743543f, -0.05047112f, 
    0.30764073f, 0.30808592f, -0.05280348f, -0.13772430f, -0.06094051f, -0.03410544f, -0.03370626f, 0.05902761f, 
    0.02321955f, -0.01805072f, -0.00391987f, 0.10433677f, 0.65339500f, 0.12796244f, -0.11755130f, -0.02284267f, 
    -0.04500803f, -0.11299293f, -0.09501742f, -0.04987501f, 0.07054381f, 0.07721331f, 0.11826681f, 0.07652922f, 
    -0.20948826f, -0.11086693f, 0.02569696f, -0.02801353f, 0.12351980f, -0.03902951f, -0.00889086f, -0.01568916f, 
    0.09761953f, 0.02086733f, 0.04885195f, 0.03120618f, -0.28428414f, -0.15090144f, 0.01197010f, -0.37151980f, 
    -0.06556975f, -0.02025874f, 0.07299659f, -0.01538165f, -0.00186618f, 0.05546808f, 0.09838790f, 0.10590903f, 
    0.16732891f, -0.20671016f, 0.01814729f, -0.13536085f, -0.04920853f, 0.07165661f, 0.04147571f, 0.00362850f, 
    -0.01553969f, 0.03217545f, -0.01612726f, -0.09942192f, -0.11806514f, -0.00113044f, 0.09705547f, -0.12195382f, 
    -0.14706074f, -0.01806033f, 0.04795274f, 0.01745722f, -0.05805154f, -0.04215109f, -0.02554993f, 0.06489124f, 
    -0.35379997f, 0.16998035f, 0.04521084f, -0.05957352f, -0.09938555f, -0.05584195f, -0.00577775f, -0.02303392f, 
    0.07788713f, 0.03563455f, 0.03629767f, -0.20938867f, -0.05656405f, -0.06769982f, 0.08421748f, 0.14323619f, 
    0.06153753f, 0.01908460f, -0.03828420f, 0.11075977f, -0.01389877f, -0.03857109f, -0.02158267f, -0.10973159f, 
    0.10611696f, -0.19227853f, -0.00165906f, 0.01077379f, 0.03570496f, -0.08679409f, 0.05579113f, -0.14367954f, 
    -0.06532267f, 0.00236617f, -0.02746318f, 0.15709908f, -0.25165489f, -0.25731429f, -0.14460067f, -0.04982902f, 
    -0.05916926f, 0.01477279f, 0.08248077f, 0.04028742f, 0.05940885f, 0.06808430f, 0.01237527f, -0.09879061f, 
    0.17453377f, 0.10064875f, -0.07090102f, 0.29565033f, 0.01896943f, 0.10024022f, -0.01735143f, -0.00363197f, 
    0.05489045f, -0.03181686f, -0.11374556f, -0.06645272f, -0.16585489f, 0.22888377f, -0.09887575f, 0.01405358f, 
    0.04818516f, 0.01762493f, 0.00581033f, -0.02896835f, -0.07172363f, 0.02014706f, 0.05466646f, -0.03025930f, 
    -0.02774891f, -0.08219910f, 0.05449452f, 0.00299572f, 0.08083334f, 0.12949000f, 0.07963486f, -0.08848985f, 
    -0.08580704f, 0.01778907f, 0.04573848f, 0.03423857f, -0.20757909f, 0.07399051f, 0.03771757f, 0.10067195f, 
    -0.03182221f, 0.03019067f, -0.03858829f, -0.14722884f, 0.08087332f, -0.02271906f, 0.09718380f, 0.05443202f, 
    -0.01971018f, -0.08356705f, 0.13882607f, -0.01341244f, -0.04297652f, -0.07002187f, -0.01829322f, -0.05758472f, 
    0.02051037f, -0.10222511f, 0.01029133f, -0.11482229f, 0.23078349f, 0.04790488f, -0.05271178f, 0.02980257f, 
    0.00812299f, 0.00341110f, -0.05875336f, -0.05305924f, 0.06024253f, 0.14190918f, 0.06798849f, 0.05479809f, 
    0.06359472f, 0.01055749f, -0.05563344f, -0.00880620f, -0.04409130f, 0.00596001f, -0.11879756f, -0.09735885f, 
    0.09579434f, -0.03805592f, -0.06161693f, -0.04084811f, 0.07816289f, 0.07519852f, -0.16420394f, 0.05039947f, 
    0.03242387f, -0.03327179f, -0.05477433f, -0.05492067f, -0.06595871f, 0.03397704f, 0.04160660f, -0.00275044f, 
    -0.10580588f, 0.09084678f, -0.12346081f, -0.06699160f, 0.14064389f, -0.00015355f, -0.05534790f, 0.07124682f, 
    -0.02073388f, 0.10473265f, -0.02232645f, 0.02308736f, 0.27290961f, 0.06354318f, -0.04174533f, -0.10602734f, 
    0.07987437f, 0.06804565f, -0.03438992f, 0.00274662f, 0.00527570f, -0.03484983f, 0.16694742f, -0.00858724f, 
    0.12840992f, -0.11995683f, -0.11265761f, -0.24056944f, 0.10913090f, 0.03239512f, -0.08742028f, 0.09128485f, 
    -0.03777942f, -0.02302749f, 0.02292277f, 0.04429160f, 0.23028387f, 0.00546341f, -0.14624247f, 0.15682214f, 
    -0.06108531f, -0.09545182f, 0.05707910f, 0.05013670f, -0.16467376f, 0.01796000f, 0.07215708f, 0.04982054f, 
    -0.21520747f, 0.14456718f, -0.07158961f, -0.11718959f, 0.08984260f, -0.00363399f, -0.08555862f, 0.08815223f, 
    0.01649608f, -0.00613533f, 0.00989902f, -0.08915150f, 0.47962859f, -0.21343590f, -0.08730000f, 0.13358124f, 
    0.13296287f, -0.07032703f, -0.03569881f, 0.00167217f, 0.07638928f, -0.08537114f, -0.02501928f, 0.04284516f, 
    0.23686056f, -0.05779485f, -0.11434723f, 0.05798458f, -0.06427334f, -0.00111398f, -0.03303892f, 0.08345988f, 
    0.06835248f, -0.13758418f, 0.07244038f, -0.04038193f, 0.09704858f, -0.29317218f, -0.00692828f, -0.17635545f, 
    0.09626956f, -0.01686433f, 0.02667836f, 0.09285606f, -0.05529325f, -0.03831394f, -0.00800370f, -0.02192486f, 
    -0.23132820f, 0.05046145f, 0.04519764f, 0.02091705f, -0.05569144f, -0.00637429f, 0.05046696f, 0.08373085f, 
    -0.11900709f, 0.00973955f, 0.01973636f, -0.18340506f, -0.09358132f, 0.11417747f, -0.03006635f, 0.07853058f, 
    0.18410556f, -0.00365320f, -0.03385056f, 0.13210945f, -0.01376888f, 0.05962798f, 0.06901985f, 0.01878792f, 
    -0.09221796f, -0.08611183f, 0.05847583f, -0.10347995f, 0.07247703f, 0.00434706f, 0.03787635f, -0.08764783f, 
    0.04664019f, -0.01227328f, 0.00181650f, -0.08900071f, -0.43096069f, 0.09806922f, 0.13009597f, 0.12020472f, 
    -0.06179021f, -0.00957453f, -0.02950601f, -0.02084095f, 0.00600155f, -0.04782273f, 0.05714794f, -0.05648471f, 
    -0.20040935f, 0.06364933f, -0.03446758f, 0.04749063f, -0.07358171f, -0.06031657f, 0.10032765f, 0.03700302f, 
    0.10774954f, -0.10413914f, -0.00225827f, -0.03031355f, -0.33805627f, 0.21256377f, -0.09078314f, -0.01928055f, 
    -0.00043283f, -0.02998349f, -0.04206173f, 0.04497477f, 0.11493597f, 0.04951000f, 0.06030822f, 0.00621474f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.07759678f, 0.04129748f, -0.03668158f, -0.02215231f, -0.00584003f, -0.01924029f, -0.01481048f, -0.06184478f, 
    0.00528020f, 0.03468034f, 0.04133441f, -0.01101057f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
