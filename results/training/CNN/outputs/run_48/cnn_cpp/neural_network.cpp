#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.82130039f, 0.43220183f, 0.09888016f, 0.41854179f, 0.43698794f, 0.39865488f, -0.33395353f, -0.10560290f, 
    -0.12564470f, 0.87508482f, 0.97234035f, -0.10522793f, -0.41156992f, -0.69684857f, -0.49330711f, 0.18974932f, 
    -0.09889075f, -0.16133662f, 0.63807774f, 0.55121297f, 0.59527671f, -0.10434577f, 0.23129030f, -0.08767147f, 
    -0.48904511f, -0.07734669f, 0.12943134f, -0.32394812f, -0.62014198f, -0.75115442f, 0.68926150f, 0.63477170f, 
    -0.64342469f, 0.15373422f, -0.45552963f, -0.22835910f, 0.79340923f, -0.50766993f, -0.75937480f, 0.59939712f, 
    -0.06258259f, 0.43788978f, 0.09714749f, 0.02849071f, 0.21833444f, -0.67221677f, 0.47240660f, 0.70964193f, 
    0.75714052f, -0.17036594f, -0.88951993f, -0.18478788f, 0.30978230f, 0.00450549f, -0.76189142f, -0.35168311f, 
    -0.45466155f, -0.77859324f, -0.55608279f, -0.68582487f, 0.40055835f, -0.20743355f, 0.09176502f, 0.77364933f, 
    -0.37287536f, -1.00171506f, -0.55358881f, 0.61695880f, -0.40801695f, -0.00944133f, 0.00382006f, -0.00905819f, 
    -0.12256942f, -1.00621104f, 0.05802210f, 0.63120300f, -0.17571907f, 0.74176264f, 0.21547613f, -0.33772996f, 
    -0.03112843f, -0.29897258f, -0.80176228f, -0.17057143f, -0.40474209f, -0.69435859f, -0.35817415f, 0.10025523f, 
    0.35045668f, -0.39482260f, -0.21496767f, -0.19930086f, 0.39200631f, 0.33820322f, 0.69246638f, -0.59519047f, 
    0.78851634f, 0.02538265f, -0.37585393f, 0.97228587f, -1.34204328f, 0.41951913f, -0.68917489f, 0.44781381f, 
    -0.04680043f, 0.11813261f, 0.00021349f, -0.14377494f, -0.57035631f, -0.90736496f, -0.04822158f, -0.57447511f, 
    0.27021819f, 0.45238596f, -0.14525445f, -0.28512359f, -0.35240519f, 0.67255116f, 0.47878921f, 0.71399903f, 
    -0.75490922f, -0.03189375f, -0.36918548f, -0.02561997f, 0.21169074f, -0.30060822f, 0.69308764f, 0.43460444f, 
    0.46787903f, -0.56196678f, 0.22811861f, 0.55470568f, 0.18280043f, -0.42160192f, -0.32761896f, 0.10755376f, 
    -0.75914931f, 0.86494362f, -0.32393086f, -0.68775654f, 0.03803835f, 0.23772988f, -0.34749937f, -0.30272192f, 
    0.00034719f, -0.28609505f, 0.83586562f, -0.81611729f, -0.50965321f, -0.27789921f, 0.13263302f, 0.29270315f, 
    0.18426785f, -0.25547138f, -0.47493058f, -0.47447032f, -0.39696714f, -0.53354490f, -0.35008436f, -0.31158704f, 
    -0.20376036f, 0.40503931f, -0.39053854f, 0.36409318f, 0.64817536f, 0.37639052f, 0.44179100f, 0.63282323f, 
    -0.59285766f, -0.14165132f, -0.19823265f, 0.21397188f, 0.54247946f, 0.42003593f, -0.07860942f, -0.91391957f, 
    0.60023415f, -0.01854929f, 0.03980732f, -0.01635880f, 0.15617062f, -0.38432002f, -0.83263403f, -0.21028024f, 
    -0.58986449f, 0.40295646f, -0.31192029f, 0.10081800f, -0.24087460f, -0.36104006f, 1.12373519f, -0.22943261f, 
    0.53721774f, 0.49326575f, 0.43477872f, -0.03377427f, -0.43863308f, -0.09628695f, 0.82135481f, 0.05371580f, 
    0.57816452f, 0.07035284f, -0.07075464f, -0.48150560f, 0.12207463f, -0.05432070f, 0.53915018f, 0.60242659f, 
    -0.56661659f, -0.62746543f, -0.64323908f, -0.30638430f, 0.20596351f, -0.13983959f, -0.02563186f, 0.65615946f, 
    -0.23493451f, -0.67453337f, -0.45933878f, 0.41016555f, 0.99752402f, 0.65045863f, -0.32199752f, 0.01920091f, 
    -0.43070522f, -1.44118428f, 1.10455227f, -0.13046758f, -0.16439240f, 0.81969720f, -0.44500601f, -0.21299876f, 
    -0.09410545f, 0.00243015f, 0.60588729f, 0.21994230f, -0.01681330f, -0.62914217f, -0.16445538f, -0.59514630f, 
    0.32819617f, 0.71538812f, 0.35333490f, -0.56022489f, -0.99708062f, 0.11955774f, -0.73731780f, 0.52237725f, 
    0.07787988f, 0.14025545f, 0.29620969f, 0.40970993f, 0.37657213f, 0.81827992f, 0.62806660f, 0.13172530f, 
    -0.24402957f, 0.15718660f, -0.37561890f, 0.05582461f, 0.10422822f, -0.87359804f, -0.08092315f, -0.52328444f, 
    0.53691143f, 0.54496050f, -0.79618490f, -0.07916220f, 0.42528725f, 0.45723584f, -0.45504484f, -0.67786807f, 
    -0.28740662f, 0.41065520f, 0.98500121f, 0.05339824f, 0.05112065f, 0.50331193f, -0.03355454f, 0.49689502f, 
    0.34708536f, 0.44937822f, 0.23780937f, -0.26382816f, 0.47913459f, 0.26527944f, 0.06695908f, 0.39389530f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.36681014f, -0.19110703f, 0.37581918f, 0.13948621f, -0.08668616f, 0.02764936f, 0.06860836f, 0.14796458f, 
    0.00658243f, 0.11166422f, -0.17636222f, -0.01063461f, 0.04461332f, -0.16600122f, 0.19882853f, 0.04321103f, 
    -0.08621413f, -0.11421528f, 0.00268151f, 0.02626490f, 0.19181661f, 0.01193218f, -0.10182257f, 0.08629522f, 
    -0.07545073f, 0.04365979f, -0.07146059f, -0.11314690f, 0.38582203f, -0.03940122f, 0.23524553f, 0.35279515f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.01367383f, -0.00296746f, 0.03179473f, -0.00288653f, -0.02629466f, 0.01449034f, -0.00415218f, 0.00975795f, 
    -0.01802209f, 0.01151628f, 0.02239493f, 0.00105453f, -0.01831613f, -0.01168491f, -0.02345791f, -0.00114184f, 
    0.01930467f, 0.00168246f, 0.03257516f, 0.00384789f, -0.00627910f, 0.03266834f, -0.03098508f, -0.00996149f, 
    0.00444627f, -0.03845352f, 0.02972909f, -0.04301321f, 0.01341874f, -0.03756417f, 0.02202886f, -0.03162002f, 
    0.00850309f, -0.01744170f, 0.01564187f, -0.04393475f, -0.01168972f, -0.02510778f, -0.03672851f, 0.02097015f, 
    0.02069525f, 0.02031862f, -0.03851287f, -0.03185174f, -0.01948575f, -0.01437386f, -0.00417148f, 0.02534907f, 
    0.02300154f, -0.00660261f, 0.02878232f, 0.00936617f, 0.00745585f, -0.02973904f, -0.01527898f, -0.00043647f, 
    0.00529948f, 0.00657066f, 0.01590488f, 0.00583793f, 0.03120956f, 0.01574771f, -0.03200730f, 0.02017550f, 
    -0.04035541f, -0.01343232f, -0.00554495f, -0.03219526f, -0.02610726f, 0.00419171f, -0.03358342f, 0.03038500f, 
    -0.02950356f, -0.03660054f, 0.02684833f, -0.04184894f, 0.01852955f, 0.01511005f, 0.00143811f, -0.04074460f, 
    -0.02374808f, -0.00479951f, -0.00879162f, -0.03986284f, 0.02353215f, -0.02521694f, -0.01611851f, 0.01559809f, 
    -0.01479357f, 0.02399848f, 0.00605201f, -0.04240574f, -0.03473802f, 0.00242600f, -0.03371986f, 0.01308177f, 
    -0.03394350f, -0.03170865f, 0.02871062f, -0.00533133f, 0.00691415f, -0.04049605f, -0.02757353f, -0.01473067f, 
    -0.04352419f, -0.00079255f, -0.00332335f, -0.02796778f, -0.00860696f, 0.01381668f, 0.01717267f, 0.02662469f, 
    0.00385915f, 0.02358316f, -0.00757352f, 0.00855416f, -0.03715095f, -0.04132793f, -0.01516630f, -0.04181575f, 
    0.03269785f, 0.01760917f, -0.00593339f, 0.01942579f, -0.04041753f, -0.03482988f, -0.02677888f, 0.00471337f, 
    0.01831608f, -0.02580461f, 0.00761083f, 0.03680696f, 0.00900420f, -0.03337502f, -0.03591892f, 0.01037518f, 
    -0.01637811f, 0.03120887f, -0.00690840f, 0.01343103f, -0.03347173f, -0.03600552f, -0.00005691f, -0.01420909f, 
    0.01816501f, 0.00356072f, -0.04127799f, -0.01478049f, 0.01375763f, 0.00574780f, -0.01371200f, -0.03492784f, 
    -0.00092681f, -0.00188547f, -0.00815502f, -0.02481589f, -0.01882056f, -0.03297277f, 0.00858474f, -0.04066061f, 
    0.01994643f, -0.00402791f, 0.00513901f, 0.03220996f, -0.00781820f, -0.02284571f, 0.01220718f, -0.02255651f, 
    0.00826908f, -0.03606721f, 0.01514401f, -0.02271641f, -0.01147846f, -0.04246855f, 0.01413923f, -0.02382207f, 
    -0.02991056f, 0.01118055f, 0.02285401f, -0.00354257f, -0.00407084f, -0.00887264f, -0.02270955f, 0.01310473f, 
    -0.03440548f, 0.01609171f, -0.03570932f, -0.01981820f, -0.00966466f, -0.01998754f, 0.00187094f, -0.04444144f, 
    0.02658850f, -0.01552554f, -0.03197310f, -0.00013362f, -0.03743028f, 0.03106943f, -0.00646982f, 0.02404657f, 
    0.01644824f, 0.00811839f, 0.01294570f, 0.02105293f, -0.02790808f, -0.01742200f, 0.01383271f, -0.03913204f, 
    0.02701013f, 0.00471274f, -0.02839491f, -0.04498876f, 0.01829075f, 0.00235183f, -0.04434284f, 0.02330888f, 
    -0.01956957f, -0.02147949f, -0.03152274f, 0.00946877f, -0.03541926f, -0.03403096f, -0.02944713f, -0.01158771f, 
    -0.00855481f, -0.03385408f, 0.01487698f, 0.01842977f, 0.00288046f, -0.03631203f, 0.00025496f, 0.03259397f, 
    -0.01658491f, -0.01195937f, -0.02079080f, -0.02871439f, -0.00338088f, -0.00324367f, -0.02532572f, -0.00542652f, 
    -0.02794023f, 0.00678355f, -0.02437159f, 0.03279513f, -0.01800001f, -0.02763750f, 0.01055792f, -0.02129750f, 
    -0.01418723f, 0.01956813f, 0.03226221f, -0.00462501f, 0.03261859f, 0.02283898f, -0.00476397f, -0.00660798f, 
    -0.01171806f, 0.02450149f, -0.04266162f, -0.00055487f, -0.01044346f, -0.04299385f, -0.03920529f, -0.01424361f, 
    -0.03612768f, -0.02210792f, -0.03518590f, 0.02966094f, -0.03081186f, -0.03093958f, -0.04149617f, 0.01496870f, 
    0.00857371f, -0.00098496f, 0.03049726f, -0.03926151f, 0.01616164f, -0.04333767f, -0.03485082f, -0.02111170f, 
    0.00621993f, -0.02877957f, 0.02643275f, -0.01603134f, -0.00164766f, -0.03455983f, -0.03832224f, -0.00301739f, 
    -0.00106683f, -0.01976078f, -0.02745369f, 0.03085311f, -0.02346100f, 0.01686091f, -0.04324899f, 0.02138474f, 
    0.00283731f, -0.03101712f, 0.02277554f, -0.04366041f, -0.00060164f, -0.03654962f, 0.01556280f, 0.02593135f, 
    0.02535899f, 0.03738872f, 0.00959534f, 0.01894693f, 0.02101204f, -0.01665779f, -0.03074980f, 0.02056335f, 
    0.03151676f, -0.03892538f, -0.01719005f, -0.00840330f, -0.01663079f, -0.00291434f, -0.02063873f, 0.00430401f, 
    -0.03941796f, -0.03743904f, -0.00769813f, 0.01278293f, -0.03919312f, -0.00048656f, 0.01902574f, -0.00445209f, 
    0.02443151f, 0.00774515f, 0.00850144f, -0.02401732f, 0.00072465f, 0.00754643f, -0.00333019f, -0.00198780f, 
    0.00047580f, 0.03630487f, 0.02910594f, 0.02536106f, -0.03820136f, 0.02241859f, -0.03620233f, 0.00629890f, 
    -0.02607706f, -0.02123418f, -0.02034617f, 0.02220157f, -0.01880588f, -0.03911721f, -0.00914308f, 0.02029996f, 
    -0.00580529f, -0.02400899f, 0.01580772f, 0.00799670f, 0.01808160f, -0.02237178f, 0.00614942f, -0.00403163f, 
    -0.02722099f, -0.02861901f, 0.01779364f, 0.02926813f, 0.02838913f, 0.00368206f, 0.00918404f, -0.01542211f, 
    -0.02360021f, 0.01902679f, -0.01753544f, -0.02774335f, -0.02674575f, -0.02564150f, -0.00969203f, -0.00296749f, 
    -0.02059078f, 0.02497048f, 0.01374141f, 0.00596078f, 0.02310761f, -0.03807115f, -0.01101680f, 0.01612612f, 
    0.02731818f, -0.00937050f, 0.01065553f, -0.03568953f, -0.00817938f, 0.02160022f, -0.01647981f, -0.03724409f, 
    -0.04004801f, -0.03721834f, 0.03167614f, -0.00169630f, 0.00951245f, 0.02748953f, -0.04214284f, 0.01172689f, 
    -0.03455674f, 0.02045983f, 0.01420434f, -0.01278184f, -0.01484400f, 0.03189612f, -0.01294114f, 0.00831469f, 
    -0.04381456f, 0.01392368f, -0.03880068f, -0.04219761f, 0.01892688f, -0.00827042f, 0.00804215f, 0.01156947f, 
    0.03132959f, 0.00255865f, -0.01333455f, -0.00474895f, 0.01321904f, -0.03960814f, -0.03840904f, 0.01353327f, 
    0.01356394f, -0.02548318f, 0.00018881f, 0.01348450f, -0.04265140f, -0.01061710f, -0.00662380f, -0.01709318f, 
    0.02913530f, -0.03414657f, -0.04122088f, -0.02879871f, 0.03103326f, -0.03195303f, 0.00686642f, -0.02254225f, 
    0.01259717f, -0.02821602f, 0.00287321f, -0.01346498f, 0.00252133f, 0.01225202f, 0.01759790f, -0.03519363f, 
    0.01269508f, 0.02306312f, -0.01700258f, 0.01007125f, -0.02128272f, 0.00218819f, -0.02351306f, 0.01384607f, 
    -0.00234717f, 0.02399667f, 0.00204571f, 0.02303364f, -0.01634156f, 0.02543823f, -0.00133311f, -0.00852020f, 
    -0.01975226f, -0.00196238f, 0.02955930f, -0.01939072f, -0.02715969f, -0.02265655f, -0.01606401f, -0.03130430f, 
    -0.01882249f, 0.01654100f, -0.02147756f, -0.02969302f, -0.04435738f, 0.00053692f, 0.02063344f, -0.03979411f, 
    0.01928701f, -0.02071182f, 0.03016782f, -0.00489780f, -0.02106606f, -0.03782590f, -0.04058011f, -0.04089534f, 
    -0.03877345f, -0.04449961f, 0.00208963f, -0.03569240f, -0.01355223f, 0.02516428f, -0.00756542f, -0.00966328f, 
    0.01251192f, 0.03127949f, -0.00678330f, 0.01883851f, -0.03792301f, 0.01007998f, 0.03224389f, -0.02332696f, 
    -0.02476121f, -0.03427153f, -0.02936061f, 0.01482341f, -0.00578716f, -0.03107296f, -0.00767670f, -0.02655042f, 
    -0.03776348f, 0.01437082f, -0.00411065f, 0.03012272f, -0.02017712f, 0.00421223f, 0.01378256f, -0.01918003f, 
    0.00534399f, -0.04513534f, -0.03625843f, 0.00371178f, -0.01483075f, 0.01850555f, 0.02691852f, 0.00218090f, 
    -0.00344030f, -0.04086736f, -0.03578108f, 0.01692685f, 0.02112966f, -0.01319995f, 0.01294868f, -0.03069990f, 
    0.01320804f, 0.01517128f, 0.02558588f, 0.01663768f, 0.02668383f, 0.02830613f, 0.02526907f, -0.03946384f, 
    -0.03470568f, -0.00205879f, 0.01986640f, 0.00887534f, -0.02474085f, 0.00494694f, -0.04300373f, -0.00417847f, 
    0.02098803f, 0.01124979f, -0.04430836f, -0.02989053f, -0.03837929f, 0.02707610f, 0.00799828f, 0.01835412f, 
    0.00146771f, 0.00829465f, 0.02975532f, 0.01673670f, -0.04364062f, -0.03348804f, -0.00212940f, 0.00346336f, 
    -0.03469725f, -0.03712955f, 0.00726887f, -0.03388120f, 0.00337612f, -0.02933477f, -0.00615369f, -0.00401169f, 
    0.00356229f, -0.00610273f, 0.01080224f, -0.04261447f, 0.00543168f, 0.00019696f, 0.02907409f, 0.00348109f, 
    0.02231764f, -0.03856170f, -0.01306051f, -0.03695560f, -0.03087380f, 0.00906224f, 0.00961636f, 0.02683466f, 
    -0.04026445f, -0.03054939f, -0.03398297f, -0.00891929f, 0.01782363f, 0.02825084f, -0.04120402f, -0.01234147f, 
    0.00760547f, -0.03274029f, -0.04224824f, 0.02888372f, -0.02732038f, 0.02137070f, 0.01767484f, 0.01904780f, 
    -0.03440703f, -0.00578152f, -0.00562580f, 0.02252248f, 0.01666338f, 0.02861432f, -0.00165337f, 0.01328263f, 
    0.01132308f, -0.04177941f, -0.01366424f, -0.00334098f, 0.01853689f, -0.03441324f, -0.01965678f, -0.02237383f, 
    -0.02688567f, 0.01441406f, -0.00691914f, -0.03156941f, -0.00550607f, 0.03099572f, -0.00712900f, 0.00470318f, 
    -0.01774185f, -0.00062514f, 0.03224054f, -0.01571205f, 0.00895416f, 0.01441489f, -0.01503806f, -0.00886784f, 
    -0.07203931f, 0.09786364f, -0.01607597f, 0.03206772f, -0.08176738f, 0.00702671f, 0.06153756f, 0.00106428f, 
    -0.04975571f, 0.10825868f, 0.02225161f, -0.00035421f, 0.00744661f, 0.02162123f, 0.03718686f, -0.09457201f, 
    0.08647558f, -0.01145126f, 0.06986739f, -0.11873546f, -0.27209133f, 0.10098790f, -0.29144767f, 0.25338042f, 
    -0.23063661f, 0.12385463f, 0.05197946f, -0.07750690f, -0.01695641f, -0.01312756f, 0.11208491f, 0.06510834f, 
    -0.00612013f, 0.17921355f, 0.01156513f, -0.01902714f, -0.04128874f, -0.10133862f, -0.02158030f, 0.08584825f, 
    -0.13397457f, 0.03334824f, 0.12389340f, 0.08639498f, -0.02743869f, 0.01908760f, 0.08977608f, 0.07482538f, 
    -0.07517246f, 0.06878664f, 0.06932233f, -0.00412810f, -0.01628798f, -0.01122706f, 0.11321094f, 0.00102434f, 
    -0.04045917f, 0.03598879f, 0.06632799f, -0.00646739f, -0.13756743f, 0.25685120f, 0.18022211f, 0.03455450f, 
    0.07071936f, -0.12743555f, 0.03824371f, 0.01871362f, -0.01047042f, -0.04675780f, -0.03843203f, 0.00147635f, 
    -0.00710293f, 0.04111203f, -0.06188217f, -0.07621502f, -0.05945665f, -0.01272025f, 0.04691102f, 0.08699840f, 
    -0.25838685f, 0.06647149f, 0.09654586f, -0.08650666f, 0.15715095f, -0.11577423f, -0.00607833f, -0.08016927f, 
    -0.04224432f, 0.09732646f, 0.08224694f, 0.01401645f, 0.00663184f, 0.03002815f, -0.06677829f, -0.06446808f, 
    0.05592775f, 0.05243830f, 0.18436939f, -0.00915279f, 0.17932867f, -0.00987391f, -0.27904212f, 0.06318597f, 
    0.02432658f, -0.03462693f, 0.13369060f, 0.02588798f, 0.11464673f, -0.01481642f, 0.10092580f, -0.05766135f, 
    0.02233034f, -0.08333001f, 0.05516107f, 0.14191306f, 0.10266598f, 0.02146477f, 0.03981492f, 0.12514268f, 
    0.03026537f, 0.19156361f, 0.09256442f, -0.33569854f, 0.03857935f, 0.05368087f, 0.01679250f, -0.00775904f, 
    -0.10631243f, -0.06559739f, -0.03776571f, -0.03464289f, 0.01403303f, 0.10611246f, -0.00171438f, -0.03164862f, 
    -0.04101497f, -0.03524202f, 0.02043277f, 0.14201142f, 0.05112342f, 0.26694864f, 0.01938497f, -0.07485815f, 
    0.01097979f, 0.05506808f, 0.13892646f, -0.01669796f, 0.01108598f, -0.08859619f, 0.00549405f, -0.10354562f, 
    0.03093342f, -0.06829718f, 0.01364656f, -0.02400762f, 0.07858306f, -0.06489249f, 0.04120890f, 0.10957108f, 
    -0.39517003f, -0.10394335f, 0.12307909f, 0.04702793f, 0.40922937f, -0.14958286f, -0.14880325f, 0.04928570f, 
    0.01266599f, -0.14152619f, -0.02396287f, -0.00987095f, 0.05382213f, 0.00662258f, -0.02036219f, -0.15202788f, 
    -0.07740895f, 0.03988891f, -0.02020103f, -0.01567621f, 0.07405104f, 0.29708132f, 0.01347983f, -0.30316120f, 
    0.15331157f, 0.10957075f, -0.04457178f, -0.02730458f, 0.00178342f, 0.02206220f, 0.02860528f, 0.08137648f, 
    -0.01836693f, 0.01635179f, 0.02514025f, -0.00123582f, -0.10305736f, 0.11888957f, -0.09315272f, -0.03325435f, 
    0.44309101f, 0.26644874f, -0.10851579f, 0.00905473f, 0.03368540f, 0.04878126f, 0.02907587f, -0.07311321f, 
    0.03802487f, 0.11004978f, -0.02790878f, 0.00652183f, -0.13315272f, 0.00486529f, 0.18683036f, 0.06343015f, 
    -0.02426578f, 0.07363738f, 0.12894647f, 0.04160640f, -0.09677120f, 0.35507017f, -0.03956375f, -0.18400297f, 
    0.55894387f, -0.04428735f, -0.02723292f, 0.03664266f, -0.03401490f, -0.03995748f, -0.00358625f, -0.03197156f, 
    0.01365051f, -0.02592749f, 0.07017549f, -0.00892224f, 0.13344519f, 0.10261589f, -0.06667192f, -0.03279949f, 
    0.04022544f, -0.13960047f, 0.19626513f, -0.25321484f, 0.24469197f, 0.09556614f, -0.04727884f, 0.01001756f, 
    -0.05327435f, -0.02367891f, -0.11265860f, -0.00412722f, 0.03288418f, -0.00422783f, 0.04516512f, -0.03674624f, 
    0.03265521f, 0.06506029f, -0.04944959f, -0.01064634f, -0.16645336f, -0.17039360f, 0.02581561f, 0.12294424f, 
    -0.01327411f, 0.09869448f, 0.08003879f, 0.11771880f, -0.12377656f, 0.00034338f, -0.01658214f, -0.01892164f, 
    -0.04677297f, 0.12998606f, 0.00623560f, 0.09872640f, -0.08293600f, -0.01122350f, -0.09121913f, -0.02061800f, 
    0.01303595f, -0.06856210f, 0.05572906f, -0.01492397f, -0.05340442f, 0.14876786f, 0.07639898f, 0.06409536f, 
    -0.05371055f, -0.03607168f, 0.02400618f, 0.01300345f, -0.07994854f, 0.18188623f, 0.03228097f, 0.02553719f, 
    0.02436734f, 0.12702088f, 0.01227067f, -0.02718696f, -0.11960435f, 0.14388955f, 0.14969973f, -0.11874610f, 
    0.45165017f, 0.09774547f, -0.02880906f, -0.07235091f, -0.01829308f, -0.07998631f, -0.01926418f, -0.06842065f, 
    -0.01217047f, -0.03513653f, 0.04782963f, -0.01023503f, 0.01702317f, -0.06549179f, -0.10993779f, -0.03639611f, 
    0.07377008f, -0.09000476f, -0.00006348f, -0.04965076f, 0.29087266f, 0.04043947f, -0.12788643f, -0.06879620f, 
    -0.01274270f, -0.01744271f, 0.03083231f, 0.00310039f, -0.02547282f, 0.12123287f, 0.04679171f, 0.06889857f, 
    -0.02914641f, 0.04941551f, -0.02676351f, 0.01678178f, -0.02178702f, 0.21559559f, -0.05004923f, -0.22157443f, 
    0.02171200f, -0.02530255f, 0.06831405f, -0.06044875f, -0.05211116f, 0.03092837f, 0.16718031f, 0.01657381f, 
    0.06569491f, 0.06001980f, 0.00683051f, -0.04367635f, 0.08323156f, -0.00606708f, 0.01605137f, -0.02719399f, 
    0.28432950f, 0.02783994f, -0.12106965f, -0.12112671f, -0.06596714f, -0.07568155f, 0.08523872f, -0.03550729f, 
    -0.00174921f, -0.00807579f, -0.08093051f, -0.03065418f, -0.04434330f, -0.05685914f, 0.03635786f, -0.05671028f, 
    0.03509641f, 0.14628008f, -0.04102584f, -0.01840223f, -0.17226690f, 0.05893940f, -0.12372326f, -0.07181334f, 
    -0.03409007f, 0.06206330f, 0.08675405f, -0.01774578f, 0.04657150f, 0.02788566f, 0.07646298f, -0.02796461f, 
    -0.00661186f, -0.00865856f, 0.01836066f, -0.06470194f, -0.06662965f, 0.13781418f, 0.07540129f, 0.02456473f, 
    -0.18667294f, 0.25083148f, -0.03812693f, -0.12646520f, 0.15137775f, 0.16025755f, 0.03712429f, 0.10736724f, 
    0.10579021f, 0.03439909f, 0.05135068f, 0.04414601f, -0.00066855f, -0.01073290f, -0.00831448f, -0.02286442f, 
    0.03691617f, -0.03986851f, 0.14505948f, 0.03307351f, -0.17961447f, 0.10839653f, -0.13482001f, 0.24921522f, 
    -0.21131387f, 0.07482681f, -0.05528723f, -0.15418866f, -0.04662351f, 0.01753496f, -0.06423289f, -0.03819036f, 
    0.08609017f, 0.03154567f, -0.05645585f, 0.01495216f, -0.05878667f, 0.00012644f, -0.02735783f, -0.02022643f, 
    -0.21001612f, 0.17519842f, -0.03945481f, 0.21776412f, 0.16007426f, 0.05564476f, 0.02391981f, -0.01665576f, 
    -0.16717111f, 0.06113800f, 0.11270722f, 0.04481939f, 0.12564680f, -0.01707746f, 0.05654443f, 0.07976376f, 
    0.10738587f, -0.03364288f, 0.07983696f, -0.00449972f, 0.09584650f, 0.31668928f, 0.10139571f, -0.15289603f, 
    0.07729997f, -0.03541994f, 0.04838690f, 0.00059832f, -0.00258197f, -0.08821336f, 0.05127664f, 0.06261002f, 
    0.03477196f, 0.04803797f, -0.02122218f, -0.00881592f, 0.18237062f, 0.02929968f, 0.01017579f, 0.02682563f, 
    0.16261898f, -0.16738544f, 0.06668105f, 0.13794915f, 0.33258823f, -0.21955346f, -0.06759841f, 0.02984275f, 
    0.04427482f, -0.06419241f, 0.00079926f, 0.03825293f, -0.07572740f, 0.04163395f, 0.03525476f, -0.00786538f, 
    0.03670410f, 0.04257301f, 0.07580394f, -0.10364738f, -0.49463919f, -0.04937327f, -0.21001782f, 0.37561542f, 
    -0.19811554f, 0.09187862f, -0.08498545f, 0.01221846f, -0.00355641f, 0.10136462f, -0.09448320f, 0.03205546f, 
    0.04162222f, 0.05884577f, 0.01812309f, 0.02026197f, 0.02221677f, -0.03090642f, -0.00129806f, 0.06674556f, 
    0.05429973f, 0.03809430f, -0.18453777f, 0.05488779f, -0.04390716f, 0.09092762f, -0.07185522f, -0.07164631f, 
    0.00618024f, -0.01954299f, 0.04586840f, -0.04800651f, 0.03360308f, 0.10872376f, 0.01009636f, 0.01458027f, 
    0.10443112f, 0.09513416f, -0.14303061f, 0.14511418f, -0.00915039f, -0.01283410f, 0.21361981f, -0.09645534f, 
    0.15114400f, 0.04326417f, 0.17393921f, 0.12242971f, -0.11157476f, 0.07700108f, -0.02812945f, 0.07999647f, 
    0.03639392f, 0.08755635f, -0.00412137f, 0.06307304f, 0.00627200f, -0.04090775f, 0.02202328f, -0.04555750f, 
    -0.02405482f, 0.13937885f, 0.03317923f, -0.00371468f, -0.07711330f, 0.09924009f, 0.03830002f, -0.02191740f, 
    -0.02384486f, 0.13188383f, 0.08945380f, 0.03580528f, 0.04162880f, -0.04066012f, 0.07721626f, -0.01327541f, 
    -0.00939649f, 0.03898967f, 0.12076818f, -0.04625673f, -0.23711604f, 0.01888395f, -0.04324399f, 0.00221728f, 
    -0.08643268f, -0.03779820f, 0.05211025f, 0.11862811f, 0.06915995f, -0.08912917f, -0.10162042f, 0.02181054f, 
    -0.02731702f, 0.04132738f, 0.02181565f, -0.02849813f, 0.16166434f, -0.03726521f, 0.04134179f, -0.01231566f, 
    0.19609936f, -0.12808564f, 0.09336051f, 0.12952320f, 0.21200307f, -0.08000934f, 0.07999630f, 0.10645813f, 
    -0.00315514f, -0.09794068f, -0.02486302f, -0.07079445f, -0.01602087f, 0.03733138f, -0.00520744f, 0.04008285f, 
    -0.00556808f, 0.04038363f, 0.01969841f, -0.02520361f, -0.19142352f, 0.14361544f, 0.03064100f, 0.10588172f, 
    0.10839842f, 0.13074107f, 0.03819577f, -0.03744387f, 0.00558656f, 0.13852006f, -0.05527349f, 0.02919859f, 
    0.06969518f, -0.01196880f, -0.03695273f, 0.01609132f, -0.00945670f, 0.11441260f, 0.06813327f, -0.04989932f, 
    0.02994210f, -0.02370397f, -0.03379897f, -0.01524631f, -0.02606195f, 0.01020948f, -0.04434083f, -0.00697171f, 
    0.00790731f, 0.02260831f, -0.03808901f, 0.01143577f, 0.02200174f, -0.04705146f, -0.00410205f, 0.00983516f, 
    -0.00890955f, -0.00965861f, -0.03796846f, 0.00718308f, -0.03738170f, -0.02417054f, -0.00125715f, 0.03924241f, 
    -0.01405137f, -0.02674123f, -0.00749808f, -0.04005153f, -0.03110434f, -0.02784389f, -0.01427390f, 0.00816865f, 
    0.02805752f, -0.03608989f, 0.02427959f, 0.02917907f, -0.02979198f, -0.01486675f, -0.02553264f, 0.03194120f, 
    0.00402133f, 0.01525217f, 0.02426500f, -0.02926041f, -0.01724180f, -0.04956293f, -0.04234410f, 0.01451170f, 
    -0.02558575f, 0.02311464f, -0.00958992f, -0.02848990f, -0.03459392f, 0.00288827f, -0.03574513f, -0.02421054f, 
    -0.00954641f, -0.03181613f, -0.02326131f, -0.02539132f, 0.02266146f, -0.03556908f, -0.03277710f, 0.01505025f, 
    0.02791516f, -0.00304786f, -0.02801253f, 0.01416672f, -0.00934015f, 0.01844802f, 0.00961404f, 0.01205931f, 
    -0.02253492f, 0.03852678f, -0.02459620f, -0.01730018f, 0.03356563f, 0.02419040f, 0.03056815f, 0.03001095f, 
    -0.04883856f, -0.04582327f, 0.02634547f, -0.03349378f, 0.03953869f, -0.00447910f, 0.03206735f, 0.01201140f, 
    0.00741986f, -0.01659499f, -0.03792674f, 0.00751942f, 0.02605818f, -0.02850879f, -0.03134842f, 0.00322733f, 
    -0.04782100f, 0.02535202f, -0.03842339f, -0.03628178f, 0.02291838f, 0.00461230f, -0.01446724f, -0.01432320f, 
    -0.02621566f, -0.03427430f, -0.01348149f, -0.02901384f, 0.01797037f, -0.01593758f, 0.00365608f, 0.00372449f, 
    -0.04686800f, -0.02761546f, 0.00743821f, -0.03102093f, 0.00220556f, -0.04805105f, -0.00473742f, 0.00642579f, 
    -0.00334101f, 0.00359208f, 0.02592285f, -0.01875285f, 0.00930060f, -0.01268432f, -0.02465121f, -0.03672739f, 
    0.01151888f, -0.03622346f, 0.02855141f, 0.02260017f, -0.04626996f, -0.03217300f, -0.02733297f, 0.02100109f, 
    0.01460771f, -0.00668313f, -0.01966702f, -0.04059515f, 0.01946450f, -0.02445482f, -0.00345451f, -0.04264243f, 
    0.01020894f, -0.04161339f, -0.03811608f, -0.03230009f, 0.02076285f, -0.03818262f, -0.00036309f, -0.00917652f, 
    0.01846201f, 0.01298679f, -0.01648964f, -0.01337470f, 0.01633608f, -0.02316815f, -0.02859082f, -0.03733651f, 
    -0.05005254f, -0.03805080f, -0.01174719f, -0.04766969f, 0.02637777f, -0.00668511f, 0.00789936f, -0.00830788f, 
    -0.03038099f, -0.01620581f, -0.03611954f, 0.00695394f, -0.01617865f, 0.00541210f, -0.02196626f, -0.02391206f, 
    0.00444354f, -0.00550895f, -0.04312873f, -0.03657693f, 0.02169464f, -0.01736363f, -0.03128821f, 0.01833862f, 
    0.02702895f, -0.01540147f, -0.03382545f, 0.02383729f, -0.00854803f, 0.02986335f, -0.04113370f, -0.01806011f, 
    -0.04741034f, -0.02133435f, 0.03014614f, 0.00761171f, -0.01649565f, 0.01912209f, -0.02300665f, -0.04328508f, 
    -0.04111315f, -0.04665391f, -0.00691737f, -0.01197644f, -0.00154639f, 0.00645596f, -0.01612450f, 0.01661931f, 
    -0.02241323f, -0.03854404f, -0.00531017f, -0.01449819f, -0.04063047f, 0.02759644f, 0.01404503f, -0.03249006f, 
    -0.01234565f, 0.01959564f, 0.01374091f, -0.01503094f, 0.02715609f, 0.02342580f, -0.01328831f, 0.02421598f, 
    0.01209441f, -0.00277785f, 0.00860266f, -0.02781611f, -0.00263606f, -0.02647875f, -0.01310367f, -0.01919488f, 
    -0.02520662f, -0.00037329f, 0.01067854f, -0.02467877f, 0.02177541f, -0.00556208f, 0.01040248f, 0.01238497f, 
    0.00514384f, -0.03944934f, -0.00062553f, 0.02170921f, -0.04024346f, -0.00437408f, 0.01979682f, 0.02496162f, 
    -0.00259074f, -0.00171030f, 0.00887113f, 0.01238238f, -0.00837991f, 0.02394805f, -0.01464284f, 0.00401505f, 
    -0.04530068f, 0.01833029f, 0.01379268f, -0.00110269f, -0.01939785f, 0.01333172f, -0.01909343f, -0.01927187f, 
    -0.03226147f, -0.00013324f, 0.02473347f, -0.02954927f, 0.03307940f, -0.01851681f, 0.02920458f, -0.03001071f, 
    -0.03899160f, 0.01061577f, -0.03153892f, -0.04306689f, -0.03657503f, -0.01825531f, -0.03591686f, -0.02486135f, 
    -0.02052600f, 0.01801959f, 0.02097791f, 0.02887121f, -0.03384067f, 0.02354720f, 0.02506189f, -0.01194239f, 
    0.02826916f, -0.02234880f, 0.00527038f, -0.04503745f, 0.03258790f, 0.01425512f, 0.01848105f, -0.01741178f, 
    -0.01979367f, 0.03403181f, 0.00010291f, 0.02263853f, -0.02943267f, 0.02310904f, 0.01700228f, -0.04441059f, 
    0.00231487f, -0.04294898f, -0.00229706f, -0.01282312f, 0.02245297f, -0.01133077f, -0.00890733f, 0.03551643f, 
    -0.01037028f, 0.00437633f, -0.00570717f, 0.01720213f, 0.02064425f, -0.02400886f, 0.02217016f, -0.03117472f, 
    -0.04242365f, -0.01527218f, 0.01587868f, -0.02220261f, -0.02341084f, 0.02989725f, 0.02436333f, 0.03572850f, 
    0.02709590f, 0.02685759f, 0.02370295f, -0.00174266f, 0.01164781f, -0.03068874f, -0.00152653f, 0.00039940f, 
    0.00036872f, 0.00831487f, -0.02029404f, -0.03375154f, 0.01996113f, -0.03497623f, 0.01692372f, -0.01716628f, 
    -0.02050002f, -0.00713983f, -0.03792753f, -0.00457506f, -0.02563188f, -0.03586209f, -0.01110360f, -0.00233328f, 
    0.02282594f, -0.01698695f, 0.00931015f, -0.00572553f, 0.00670551f, 0.03444606f, 0.02189805f, -0.03734487f, 
    0.02822385f, -0.02064727f, -0.03026021f, 0.00582331f, 0.01847512f, -0.02198696f, -0.03985226f, -0.02755459f, 
    -0.02021445f, 0.03865027f, -0.03336186f, 0.00753764f, 0.01187624f, -0.03137615f, -0.04573283f, 0.02086393f, 
    -0.01049471f, -0.00360089f, -0.01676172f, 0.01590156f, 0.02072630f, 0.01219501f, 0.02108543f, 0.03047865f, 
    -0.02991526f, -0.00486767f, -0.00564520f, 0.00019671f, 0.01187992f, -0.01812996f, -0.04453066f, -0.04410568f, 
    0.01755027f, -0.04651430f, -0.03586574f, -0.01162263f, 0.00987394f, -0.02383898f, 0.00390231f, -0.01934838f, 
    -0.00589453f, 0.01389059f, -0.01581012f, -0.01836943f, -0.02931283f, 0.00895434f, -0.01677768f, -0.02096519f, 
    0.01123669f, 0.02531131f, 0.02523301f, 0.02101333f, -0.01108892f, -0.01663449f, 0.01871510f, -0.04563096f, 
    0.00354217f, 0.03254601f, -0.03615600f, 0.00539019f, 0.01168067f, 0.01412794f, 0.01428373f, 0.02630762f, 
    -0.02739610f, -0.04843048f, -0.04686708f, 0.00109509f, 0.02663100f, -0.03527395f, 0.02969182f, -0.04377526f, 
    -0.00150235f, -0.04662046f, 0.02421629f, 0.00946866f, -0.00692602f, -0.01588501f, 0.02359738f, -0.02682693f, 
    -0.02518935f, -0.02583070f, 0.03154524f, -0.03315601f, -0.01731043f, -0.00678130f, -0.04017126f, -0.01599830f, 
    -0.03038360f, -0.04513482f, -0.02716691f, 0.02704267f, 0.02077608f, 0.01985347f, 0.02224023f, -0.00989863f, 
    0.02373164f, -0.04349419f, -0.04231929f, 0.02046693f, -0.00622700f, -0.02479333f, -0.01335202f, 0.02504934f, 
    0.00878688f, 0.01341272f, 0.02027895f, 0.01699646f, 0.01656337f, -0.02566538f, 0.02300225f, 0.00605833f, 
    0.02336738f, -0.03924932f, 0.03495856f, -0.03026566f, -0.04493800f, -0.01026652f, 0.00482396f, 0.00561984f, 
    -0.03895712f, 0.02032174f, -0.03736718f, 0.00837112f, -0.01707552f, -0.01221200f, 0.00826972f, 0.03231017f, 
    0.02533970f, 0.00354178f, -0.02902831f, -0.00678123f, 0.02113668f, -0.03878746f, 0.02187315f, -0.00593184f, 
    0.02579290f, -0.04519459f, -0.02219889f, -0.03215716f, -0.00090581f, -0.01669667f, -0.00193277f, 0.02430335f, 
    -0.00577390f, 0.01318455f, -0.01651250f, 0.02020761f, 0.02861825f, 0.02271763f, -0.02078224f, 0.00213260f, 
    -0.01736693f, 0.02391401f, -0.03281877f, -0.02477830f, -0.00071718f, 0.03458657f, 0.01349262f, 0.02523532f, 
    -0.00608064f, 0.01489441f, 0.00661716f, 0.01432834f, 0.02161321f, -0.02776331f, -0.03752146f, 0.01117401f, 
    -0.01908552f, -0.03548685f, -0.00312955f, -0.03769144f, 0.02905762f, 0.03333195f, 0.02408267f, 0.01396654f, 
    0.00742612f, -0.01039561f, -0.00088288f, 0.01809702f, -0.00838778f, 0.01667313f, -0.00198564f, 0.00163128f, 
    -0.01404355f, -0.01047763f, -0.02112358f, 0.00667510f, 0.02750991f, -0.01146248f, -0.02468385f, 0.03080484f, 
    0.02766902f, -0.03160584f, -0.03878377f, -0.04025019f, -0.00469452f, -0.02592799f, -0.00858933f, -0.03611330f, 
    -0.03070772f, -0.02528849f, -0.00821924f, 0.00423082f, 0.00609825f, -0.02187534f, 0.01633650f, -0.01229815f, 
    -0.00517405f, 0.00845688f, -0.00137455f, -0.00573771f, 0.02420271f, -0.01034361f, -0.02728227f, 0.01036376f, 
    -0.03005285f, 0.03547643f, -0.03233138f, -0.00808029f, 0.01798369f, 0.00191116f, 0.01379103f, -0.02643539f, 
    0.00257045f, 0.01161818f, 0.01034419f, -0.03846968f, -0.04251344f, -0.03183967f, -0.03894976f, -0.02795529f, 
    0.00841609f, 0.01979992f, 0.00257853f, -0.03345562f, 0.02480363f, 0.00836030f, -0.02782341f, -0.04906503f, 
    0.01363130f, -0.01850228f, -0.02373413f, -0.02912740f, -0.02840629f, -0.01753892f, -0.01341594f, 0.02453764f, 
    -0.02311615f, -0.01516712f, 0.02796726f, -0.04009985f, 0.01978592f, 0.00314142f, -0.04015521f, -0.01756139f, 
    -0.02536476f, -0.04774058f, 0.01558585f, 0.00439825f, -0.01408724f, -0.01920049f, 0.00234580f, 0.01221646f, 
    0.01031826f, 0.00642968f, -0.03860748f, 0.02340369f, -0.01121166f, 0.02453309f, 0.01388952f, 0.02513493f, 
    0.01401007f, -0.02726873f, -0.03371990f, 0.02140208f, 0.01238242f, -0.04842782f, -0.00730086f, -0.00138540f, 
    0.20332488f, 0.07148566f, -0.08152192f, 0.03754199f, 0.00500980f, 0.07926767f, 0.05938417f, -0.01802013f, 
    0.05376256f, -0.08798391f, 0.06186221f, 0.00610669f, 0.00489578f, -0.01397245f, -0.02221116f, -0.04674409f, 
    0.06488393f, 0.12090471f, 0.12662035f, 0.11377385f, 0.08296312f, -0.04456475f, 0.13361643f, -0.18689479f, 
    0.15075287f, 0.05103561f, -0.12829086f, 0.03876756f, -0.01088322f, -0.04797779f, 0.09858514f, 0.06446157f, 
    0.20569094f, 0.04601185f, -0.06648941f, -0.04298782f, 0.02081209f, -0.05191526f, -0.03476343f, -0.16110954f, 
    0.09911728f, -0.12511182f, -0.03486402f, 0.07838035f, 0.18360534f, 0.00755595f, 0.05356618f, -0.05736158f, 
    0.02234477f, -0.02126256f, 0.03117506f, -0.04478553f, -0.01734762f, 0.05802839f, -0.01606169f, 0.00240641f, 
    0.04822673f, 0.11139006f, 0.05216948f, 0.03838610f, 0.18353954f, -0.03752489f, 0.16825001f, 0.09627160f, 
    -0.14893387f, 0.10838668f, -0.06996388f, 0.04045632f, 0.05852127f, 0.12718941f, 0.04745021f, 0.03378210f, 
    -0.09336906f, 0.05503600f, 0.07061523f, 0.03579796f, -0.00035421f, -0.05397476f, 0.07954264f, -0.17062482f, 
    0.01808523f, 0.12163503f, 0.22262463f, 0.14618237f, 0.05713742f, 0.05496562f, 0.07275055f, 0.06676714f, 
    0.00438438f, 0.00325125f, 0.04355318f, 0.04471066f, 0.01719499f, 0.03321254f, 0.09164678f, -0.03542146f, 
    0.08727152f, -0.07180751f, 0.06603420f, 0.09255739f, -0.13244984f, -0.09372763f, -0.04111016f, -0.03059726f, 
    0.21655500f, 0.08023994f, -0.05967088f, -0.01827190f, -0.11953325f, 0.15530436f, 0.08926375f, -0.02606617f, 
    0.13215843f, -0.03021776f, 0.06745155f, 0.03591497f, -0.13073193f, 0.07915398f, 0.05771664f, 0.04477279f, 
    0.12810487f, -0.09706487f, 0.16379607f, -0.01233063f, -0.15277939f, 0.14387536f, 0.06257255f, 0.06604028f, 
    0.09998421f, 0.04516114f, 0.02665169f, 0.03745814f, 0.04276438f, 0.03080803f, -0.05807407f, 0.07105374f, 
    -0.00964108f, -0.03938879f, -0.08590300f, -0.13750698f, 0.18729863f, 0.27821764f, -0.08299850f, -0.07239105f, 
    -0.25974095f, 0.00250121f, -0.02051383f, 0.01188495f, 0.02446483f, 0.05399359f, 0.02809326f, 0.07090434f, 
    0.02138612f, 0.05615061f, 0.11835244f, -0.08130672f, 0.01014128f, -0.00378839f, -0.01035807f, 0.03808644f, 
    0.36120969f, 0.39819971f, 0.20776041f, 0.13303439f, 0.06436421f, 0.01892842f, -0.06434437f, -0.02594700f, 
    -0.04858440f, 0.13567954f, 0.06395124f, -0.00556319f, -0.00722111f, 0.06692722f, 0.08834440f, -0.01896790f, 
    0.14541219f, 0.06771414f, 0.00467336f, 0.07986146f, 0.07790235f, 0.05304841f, 0.36067995f, -0.08133589f, 
    -0.22031309f, 0.02872354f, 0.10610905f, 0.10013860f, 0.02821141f, -0.04667871f, -0.07343204f, -0.01973146f, 
    0.08188401f, 0.13282245f, -0.11782365f, 0.04047075f, 0.12147661f, -0.10709336f, -0.09512249f, 0.10509966f, 
    -0.04344868f, -0.18789919f, -0.01846841f, 0.00104778f, 0.02187289f, 0.10760391f, 0.13065632f, 0.05682812f, 
    0.02939531f, 0.08116691f, 0.07236591f, -0.05253225f, 0.01316795f, 0.14052482f, -0.03365938f, 0.16612075f, 
    0.05054636f, -0.03849319f, 0.18283489f, -0.06127263f, 0.21482168f, -0.14406753f, 0.01334889f, 0.04797113f, 
    -0.15980618f, 0.16262445f, 0.04275151f, 0.06287681f, -0.02417911f, 0.04747878f, 0.02571834f, 0.08254516f, 
    -0.01621242f, 0.11196890f, -0.09878362f, -0.01855296f, 0.04158743f, -0.05647239f, 0.09279028f, 0.05821994f, 
    0.16524412f, -0.10605111f, 0.19528641f, 0.13609421f, -0.08364626f, -0.00218471f, -0.03459744f, 0.04239168f, 
    -0.06525843f, 0.04252215f, 0.13351507f, 0.10696609f, 0.00187055f, 0.02912310f, 0.01238558f, -0.00497055f, 
    -0.16425619f, 0.07876072f, -0.13151871f, 0.06692513f, 0.11315608f, -0.13683201f, -0.10558441f, -0.07463691f, 
    0.12025242f, 0.01688780f, -0.03590930f, -0.08336366f, -0.02529403f, 0.05008048f, 0.08312037f, 0.07469632f, 
    -0.09417612f, 0.17534705f, -0.00659923f, -0.01669017f, 0.14310271f, 0.07198526f, 0.00447338f, -0.01826116f, 
    -0.01780774f, 0.02477517f, -0.19796291f, 0.12838431f, 0.02591731f, 0.08294316f, 0.02022363f, -0.00215496f, 
    0.03984723f, -0.03359076f, 0.03240930f, -0.00442617f, 0.00638461f, 0.03647339f, -0.00037206f, -0.02138802f, 
    -0.05116855f, 0.15723488f, 0.00450630f, 0.01483703f, -0.10712501f, 0.18225628f, 0.02666007f, -0.09602048f, 
    -0.40674031f, 0.02267400f, -0.04477930f, -0.02520368f, 0.02329737f, 0.01129996f, -0.03760110f, 0.14569643f, 
    0.11314462f, 0.04802328f, -0.03469847f, 0.06406864f, 0.03143794f, 0.02306631f, -0.11107364f, -0.00931871f, 
    -0.11421295f, 0.00505606f, -0.03479380f, -0.25825417f, -0.28801122f, -0.01710388f, 0.05336545f, -0.07776427f, 
    0.13709576f, -0.04830198f, -0.00441463f, 0.14294966f, 0.08412506f, -0.05061577f, -0.04950307f, -0.00979903f, 
    0.08714758f, -0.03338115f, -0.05305830f, 0.03579508f, -0.04764242f, 0.03517776f, -0.02331392f, -0.00148912f, 
    -0.08388607f, 0.01279859f, -0.04726790f, 0.16506380f, 0.02983100f, 0.02695387f, -0.04400113f, -0.07572398f, 
    0.05225820f, 0.00406259f, -0.01872764f, 0.05116635f, 0.01437341f, 0.07080603f, -0.09521890f, -0.01998823f, 
    0.13694464f, -0.01042356f, 0.01878168f, 0.00932022f, 0.26098052f, 0.07762830f, 0.03293500f, -0.16838735f, 
    -0.06072421f, 0.03071774f, 0.05794066f, 0.07970173f, 0.03105167f, -0.01027025f, 0.06247774f, 0.00917885f, 
    0.00428866f, 0.09223083f, 0.16407987f, 0.04228481f, 0.05276339f, 0.04276315f, 0.11869512f, -0.00128136f, 
    0.18713708f, 0.12318221f, -0.01866664f, -0.00281132f, 0.07522263f, -0.01598989f, 0.08098381f, 0.03240826f, 
    0.01189259f, 0.10756183f, 0.04885380f, 0.01254909f, 0.09175842f, 0.04298433f, 0.02385155f, 0.00655359f, 
    -0.15299265f, 0.06378491f, 0.28306216f, 0.02257439f, -0.09236159f, -0.05845806f, 0.03795813f, -0.08335557f, 
    -0.01635648f, -0.03627121f, 0.05774771f, 0.05566582f, 0.00406045f, 0.15752725f, 0.03420771f, 0.06817869f, 
    -0.03098772f, -0.09676109f, -0.04807351f, -0.02271959f, 0.03841395f, 0.05875852f, -0.08975802f, -0.18600978f, 
    0.34631860f, -0.00856464f, 0.03851112f, -0.17642215f, 0.02110193f, 0.00568502f, 0.00537680f, 0.08819454f, 
    0.02783138f, -0.00343670f, 0.14668624f, -0.07221737f, 0.10739799f, 0.06641550f, 0.07235521f, 0.05574201f, 
    -0.02462613f, -0.29658869f, -0.07882838f, -0.06629770f, 0.01161810f, 0.10371387f, 0.00459730f, -0.03132179f, 
    -0.10682704f, -0.02153228f, 0.08885186f, 0.11786412f, 0.01665061f, -0.04515844f, 0.03129619f, 0.00976135f, 
    0.03675714f, 0.00022932f, 0.00233725f, -0.02123896f, -0.28611904f, -0.01380268f, 0.00476566f, 0.00716556f, 
    -0.06085991f, 0.05679839f, 0.03628885f, 0.10009821f, 0.10266197f, 0.01715294f, -0.00256940f, -0.01983231f, 
    -0.01161873f, 0.07560715f, 0.12103180f, 0.03942720f, -0.03566676f, -0.00030109f, 0.03903029f, -0.01853993f, 
    0.49465394f, 0.22977909f, -0.03258966f, 0.07841127f, -0.03627859f, -0.05182637f, -0.02673160f, -0.07885943f, 
    0.07471332f, 0.13193597f, 0.03737195f, -0.06141333f, -0.02218815f, -0.01105778f, 0.09514214f, 0.02197102f, 
    -0.04079786f, 0.04026989f, 0.01570120f, 0.08040886f, -0.01682642f, -0.08356749f, -0.29788160f, -0.03013199f, 
    0.28440011f, 0.03224153f, 0.03691012f, -0.08841800f, 0.01366864f, 0.07392664f, 0.01773466f, 0.00996528f, 
    0.07141603f, -0.04060571f, 0.10405603f, 0.08603217f, 0.04661317f, -0.05034484f, -0.03333111f, -0.14865573f, 
    0.17949146f, 0.07137099f, -0.12539768f, -0.22694902f, -0.05191368f, 0.01272877f, 0.04760402f, -0.02341590f, 
    0.01207322f, 0.00105768f, -0.00869949f, 0.16944592f, 0.02478719f, 0.03691763f, 0.06249949f, 0.13608623f, 
    0.10565978f, 0.03260446f, 0.04095381f, 0.05107145f, 0.15409562f, -0.18592654f, 0.21940376f, -0.01842246f, 
    -0.05810698f, 0.05328181f, 0.05149359f, 0.06295563f, 0.04178741f, 0.05714127f, 0.03533374f, 0.06083763f, 
    -0.02317200f, 0.05558181f, 0.01599325f, 0.05600223f, -0.01220834f, -0.06439925f, 0.03883786f, 0.12972978f, 
    0.12336837f, -0.11315077f, -0.06869125f, 0.05596821f, 0.26034477f, 0.03769428f, 0.00290169f, -0.09894723f, 
    -0.05740136f, 0.01846197f, 0.05901925f, 0.01558456f, -0.03755010f, 0.09326965f, 0.05274599f, 0.02803037f, 
    0.07035668f, 0.08803825f, -0.02880724f, 0.04438950f, 0.13380662f, 0.10475960f, -0.05696095f, 0.19389132f, 
    0.00206131f, 0.03467758f, -0.08913971f, 0.02767930f, 0.04118470f, 0.01634666f, 0.01699267f, -0.07559708f, 
    0.06686810f, 0.04245688f, -0.06804833f, 0.05615427f, -0.00618810f, -0.02664725f, 0.09447780f, 0.05623614f, 
    0.42124310f, 0.06327376f, -0.03045334f, 0.17357944f, 0.00081347f, -0.06550254f, -0.01507116f, 0.06144532f, 
    0.00774819f, 0.13940872f, -0.01759326f, -0.00116977f, -0.02164413f, 0.08390883f, 0.01697364f, 0.07990948f, 
    0.05974505f, -0.02169297f, -0.01733954f, 0.04647405f, 0.12261090f, 0.07968953f, -0.02305774f, 0.01963633f, 
    0.11416582f, 0.07244416f, -0.03062730f, -0.00412735f, 0.00501327f, -0.01361495f, 0.05907173f, -0.00928730f, 
    0.05875797f, 0.08756660f, 0.05638168f, 0.09137914f, 0.06341828f, 0.10285053f, 0.01305519f, 0.07269201f, 
    0.18063822f, -0.02341265f, -0.01750888f, 0.01494669f, 0.02029347f, -0.01968117f, -0.03858333f, 0.03609681f, 
    0.08933493f, 0.00490571f, 0.03724580f, 0.06436950f, -0.00494736f, 0.06745842f, -0.02921922f, -0.03528098f, 
    0.01809778f, 0.06755311f, -0.05283051f, -0.11412778f, 0.06758593f, 0.00719824f, -0.26926067f, -0.17999560f, 
    -0.14223740f, 0.07978939f, -0.00004745f, 0.00626882f, 0.01556921f, 0.01724378f, -0.09997720f, -0.02752132f, 
    -0.11705609f, 0.14688522f, -0.00907469f, 0.08727235f, 0.00241387f, -0.05915066f, 0.00755924f, -0.04091559f, 
    0.25132844f, -0.07891893f, -0.00993234f, -0.07378521f, -0.08502877f, -0.00760110f, 0.02664621f, 0.00533639f, 
    0.02783813f, 0.02359655f, 0.03707610f, -0.05570242f, -0.03842107f, -0.02010042f, -0.00091072f, 0.00523467f, 
    -0.06560264f, -0.05865626f, -0.06648436f, -0.07752377f, -0.10916050f, 0.25437850f, 0.32014903f, 0.02850395f, 
    0.00279147f, 0.00169854f, 0.12054916f, -0.07093921f, -0.14004719f, 0.01753155f, -0.05698175f, 0.07181484f, 
    0.06882996f, -0.02081041f, 0.05297423f, -0.00234277f, 0.13023323f, 0.01917021f, -0.01582845f, -0.07185566f, 
    0.21075246f, -0.08675202f, 0.15178843f, 0.00921575f, 0.02388475f, -0.09893351f, 0.01299764f, -0.18650557f, 
    -0.03729225f, -0.22519854f, -0.05234182f, 0.13252492f, -0.02990291f, -0.01423689f, 0.06171080f, 0.02180463f, 
    0.09210095f, 0.08814468f, -0.12350394f, -0.04448990f, -0.32997712f, -0.11870524f, -0.09736329f, -0.05278032f, 
    -0.04229368f, -0.17196329f, 0.00280565f, -0.00561392f, 0.07080343f, -0.03178195f, -0.12990336f, -0.01019934f, 
    0.03447789f, -0.00414331f, -0.05553007f, 0.02681357f, -0.00304118f, 0.08629943f, 0.06183111f, -0.02519371f, 
    0.11756621f, 0.03055168f, 0.16901818f, 0.05676672f, 0.09175023f, 0.01885463f, -0.06572353f, 0.02654388f, 
    0.05442791f, 0.13076527f, -0.06132994f, -0.05534976f, 0.03620977f, 0.06305714f, -0.04028874f, 0.04475479f, 
    -0.14479798f, -0.17298448f, -0.09180049f, -0.08134256f, 0.35293162f, 0.03461074f, 0.00488105f, 0.05419259f, 
    -0.02106787f, -0.00881350f, -0.03760744f, -0.00638067f, 0.03543470f, 0.00928032f, -0.14542630f, -0.01735560f, 
    0.02546294f, 0.12521301f, 0.05941220f, -0.00099797f, -0.01781968f, -0.07867463f, -0.03385345f, 0.02679257f, 
    0.13531202f, 0.04278302f, 0.03234937f, 0.07506163f, 0.00740551f, -0.13656078f, -0.04349785f, -0.02955005f, 
    0.00029943f, -0.16229838f, 0.09066438f, 0.09886705f, -0.02672827f, -0.01238562f, 0.06626067f, 0.13338646f, 
    -0.02687563f, -0.06122202f, 0.00038619f, -0.04923748f, 0.21868944f, 0.08000799f, 0.01458328f, 0.16888283f, 
    0.08861791f, 0.05933566f, -0.00322132f, -0.01249574f, 0.08539806f, 0.11319482f, -0.11432086f, -0.06409547f, 
    -0.05374458f, 0.05230633f, 0.01428655f, 0.01336722f, -0.21428694f, -0.11637335f, -0.16753626f, -0.06815060f, 
    0.17664459f, 0.27879336f, -0.07021839f, -0.01241343f, -0.00677650f, -0.15080638f, 0.05099614f, 0.05557118f, 
    0.03426434f, -0.00615617f, -0.21215925f, 0.11059397f, 0.12010492f, -0.07459054f, -0.13580588f, -0.07026624f, 
    -0.01422297f, -0.03294499f, 0.08000866f, -0.15558685f, 0.40448061f, -0.02402379f, -0.08919027f, 0.14568764f, 
    0.00276416f, -0.01818924f, -0.03682754f, 0.00233737f, -0.02716135f, -0.12721477f, -0.16323687f, -0.05224755f, 
    -0.02440141f, 0.08464666f, 0.02837948f, -0.00635273f, 0.00858724f, -0.02716723f, -0.14768527f, 0.00081003f, 
    0.17088181f, 0.14025804f, 0.11228999f, 0.16321190f, -0.00198332f, -0.02857243f, 0.06678145f, -0.01401921f, 
    -0.01128360f, -0.00875446f, -0.06013551f, 0.05640431f, 0.00126675f, -0.02996444f, -0.02352150f, 0.06621189f, 
    -0.02880592f, -0.07627904f, -0.04965449f, -0.07522791f, 0.24080694f, -0.35181373f, -0.13027485f, -0.21528091f, 
    -0.28599083f, 0.05701243f, -0.01754757f, 0.05245885f, 0.06019725f, 0.05428465f, -0.07934324f, -0.03451226f, 
    -0.14279440f, 0.09858958f, -0.10235032f, 0.06885805f, 0.13503459f, -0.03769894f, -0.00189182f, -0.02916859f, 
    0.26071170f, -0.22327590f, -0.01801092f, -0.15879340f, -0.05966974f, -0.06123807f, -0.07005253f, 0.06161110f, 
    0.03514516f, 0.02730324f, -0.04951999f, 0.01844519f, -0.05086955f, -0.00387637f, -0.06872322f, -0.04293579f, 
    -0.04131535f, -0.00649673f, -0.11753738f, -0.05887359f, -0.00789140f, 0.09013932f, -0.23468761f, 0.01293659f, 
    0.09245096f, -0.04198613f, -0.09841590f, 0.00665848f, -0.06933775f, 0.01395407f, -0.00543531f, -0.04059951f, 
    0.02359645f, 0.01597380f, 0.04411968f, -0.01165815f, -0.22849023f, -0.08646062f, 0.03260236f, 0.14417744f, 
    -0.18637228f, -0.27687424f, -0.24137859f, -0.17936401f, -0.16358410f, 0.07198891f, -0.09050883f, -0.03161026f, 
    -0.02492797f, 0.04906211f, 0.03056022f, 0.00075884f, -0.00194973f, 0.00941070f, -0.04956510f, -0.03895715f, 
    0.08603349f, -0.21025130f, 0.05616023f, 0.05956139f, 0.12193021f, 0.17001866f, 0.16235989f, 0.10797440f, 
    0.24712889f, 0.01346525f, 0.08456519f, 0.10259089f, 0.02731527f, 0.11421094f, -0.00560830f, -0.08810360f, 
    -0.10725448f, 0.03566117f, 0.02998521f, -0.11156264f, -0.03526836f, -0.08418839f, -0.13147616f, -0.11360385f, 
    0.17210957f, -0.17694171f, -0.05929030f, 0.00556658f, 0.01825501f, -0.00917407f, -0.02430900f, 0.10902869f, 
    -0.05082409f, -0.00188489f, 0.09125405f, 0.06227597f, -0.05159909f, 0.04897527f, -0.14122145f, 0.04494041f, 
    -0.02055068f, -0.01221066f, -0.10763469f, -0.15134133f, -0.08968454f, -0.01359645f, -0.10405633f, -0.34825987f, 
    -0.24690437f, -0.07224606f, 0.00372248f, 0.00793804f, 0.04109706f, -0.01573966f, -0.01228390f, -0.04944411f, 
    -0.10704543f, -0.00119243f, -0.05878833f, 0.13355003f, 0.00422868f, -0.02023856f, -0.05782977f, -0.05865756f, 
    0.22720736f, 0.21325575f, 0.18121168f, 0.16547956f, 0.07963706f, -0.06708088f, 0.08519690f, -0.00606866f, 
    0.03114814f, 0.08993619f, -0.05810048f, 0.00622376f, 0.00959428f, 0.06522001f, 0.03638013f, -0.04562490f, 
    -0.05892669f, 0.06883825f, -0.07842265f, -0.03827374f, -0.21044306f, -0.16727097f, 0.01857332f, 0.09033261f, 
    0.04371831f, 0.10346591f, -0.08224978f, 0.09904519f, -0.06350709f, -0.03287103f, 0.10316128f, 0.02409977f, 
    0.02436560f, 0.08638773f, -0.05419607f, 0.04018049f, 0.05031410f, -0.03179250f, -0.05755563f, -0.03701058f, 
    0.30618525f, 0.00892738f, -0.17434821f, -0.19670898f, -0.02700029f, 0.00924672f, -0.04392929f, -0.00141055f, 
    0.02353070f, -0.04441256f, -0.07152969f, -0.03254393f, 0.01448706f, 0.06235443f, 0.00690915f, 0.01685918f, 
    -0.04214305f, -0.19236812f, -0.06125329f, 0.00045274f, 0.35382339f, 0.22223264f, 0.07283428f, 0.04848825f, 
    0.12166253f, -0.01514194f, 0.10539250f, 0.09848859f, 0.07401671f, 0.02835953f, -0.17614464f, -0.03956442f, 
    -0.08807409f, 0.01640983f, 0.01375618f, -0.07401932f, 0.03835503f, 0.03471051f, -0.05001616f, -0.05373780f, 
    0.04949015f, 0.10490181f, 0.10972057f, 0.10251500f, 0.03255835f, 0.10418259f, 0.10997454f, 0.01678407f, 
    -0.04141407f, -0.10392462f, 0.11771066f, 0.11552612f, -0.00960738f, 0.11472664f, -0.03090762f, 0.05834809f, 
    0.16642044f, 0.04733221f, -0.03431343f, -0.05322218f, -0.11260945f, -0.35622293f, 0.14082298f, 0.04375211f, 
    -0.02638727f, 0.09926643f, -0.09141452f, 0.03778475f, -0.02704375f, 0.00575018f, -0.03619003f, -0.04220092f, 
    0.00873520f, 0.16073006f, -0.10456470f, 0.17776521f, -0.01049313f, 0.00778091f, -0.09673591f, -0.03406826f, 
    0.16414845f, -0.15186949f, -0.07146445f, -0.00154082f, -0.17929727f, -0.00004247f, -0.04653346f, 0.04495630f, 
    -0.00558523f, 0.03373621f, -0.13117774f, -0.01425671f, -0.00346564f, 0.03572461f, -0.07470275f, -0.02775213f, 
    0.07023460f, -0.05037865f, -0.07025754f, -0.01219069f, 0.21926290f, 0.06092963f, 0.19298348f, 0.15660621f, 
    0.13192526f, -0.00779785f, 0.08614863f, -0.06354699f, 0.00372646f, -0.15274687f, 0.02590207f, -0.00982699f, 
    -0.03443865f, 0.00107520f, 0.05889703f, -0.06280179f, -0.00122286f, -0.12418319f, -0.15139145f, 0.07448690f, 
    0.06112222f, 0.04018645f, -0.06653540f, -0.13122433f, -0.09767337f, -0.07057130f, 0.05549924f, 0.08452383f, 
    0.04690764f, -0.05325986f, 0.00974628f, -0.02888342f, -0.03118799f, 0.02496299f, -0.00792685f, 0.02755625f, 
    -0.06837890f, -0.07323571f, -0.03855690f, -0.06724568f, -0.02198912f, -0.03071931f, 0.19335073f, 0.11249509f, 
    0.19976056f, 0.08064441f, -0.11795261f, -0.01078157f, 0.00369720f, 0.05632608f, -0.02900336f, 0.07921205f, 
    -0.01559666f, -0.04855739f, -0.01255319f, 0.01014305f, 0.07329769f, -0.01280700f, -0.00800443f, -0.17263128f, 
    0.16964778f, 0.13824637f, 0.13185592f, 0.13980828f, 0.09656304f, 0.05571667f, 0.08461648f, -0.02359940f, 
    -0.19057642f, -0.09689129f, 0.01727585f, 0.04460917f, -0.07831084f, 0.00562794f, 0.00279830f, -0.04647887f, 
    0.10918276f, 0.02862535f, -0.05584682f, 0.01096410f, -0.04081299f, 0.09904882f, -0.02344367f, -0.04344280f, 
    -0.02471780f, -0.01840296f, -0.07102532f, 0.03685185f, 0.04453945f, -0.02409747f, -0.08832573f, -0.03582869f, 
    -0.03472319f, -0.00978954f, -0.08419889f, 0.03849901f, 0.04891661f, 0.00396577f, -0.07003105f, -0.01301031f, 
    0.39659220f, 0.27637976f, 0.11367898f, 0.09119329f, 0.22383603f, 0.06373154f, 0.13204083f, -0.06040102f, 
    -0.01742917f, 0.06527008f, 0.05804183f, 0.09591637f, -0.04112114f, 0.03744010f, 0.08741096f, 0.03388557f, 
    0.10086574f, 0.10623967f, 0.01549931f, -0.06047128f, -0.10032142f, -0.12821639f, 0.32417661f, 0.27098307f, 
    -0.07395025f, -0.09924975f, 0.00119610f, -0.10455992f, -0.03244280f, 0.08967562f, -0.00849960f, -0.17352800f, 
    0.03170732f, 0.15629780f, 0.12634403f, 0.07993878f, 0.04826336f, -0.08383515f, 0.06324840f, 0.03071863f, 
    0.26239565f, 0.06964847f, 0.31899682f, 0.09920672f, 0.17428905f, 0.01296135f, 0.07566258f, -0.10685871f, 
    0.02195142f, 0.07994427f, -0.00152670f, 0.04033051f, 0.06561568f, -0.02565898f, -0.02364380f, -0.07673460f, 
    0.04911246f, -0.00559302f, 0.08658610f, -0.02881791f, -0.41784009f, -0.00043183f, -0.11919089f, -0.02320820f, 
    -0.13390797f, 0.06862970f, 0.12385913f, 0.00752793f, -0.00800275f, -0.06446677f, 0.01259752f, -0.00458708f, 
    0.02467584f, -0.01885025f, -0.02424725f, 0.00122915f, 0.12976547f, -0.03031301f, 0.05375837f, 0.05072603f, 
    -0.04220431f, 0.06069716f, -0.17350969f, -0.05118654f, -0.12177378f, 0.03689210f, -0.03255330f, -0.03250043f, 
    -0.09711964f, 0.00128280f, 0.05886396f, 0.08752435f, 0.06020715f, 0.00674810f, -0.07272983f, 0.01287864f, 
    0.01929997f, 0.02471439f, 0.05800381f, 0.00275994f, -0.21329068f, 0.16340499f, 0.08549793f, -0.36857423f, 
    -0.18719842f, -0.05129020f, -0.05600310f, -0.07277635f, -0.00003215f, -0.03587589f, 0.03315403f, 0.04130664f, 
    -0.02808989f, 0.02264301f, 0.18694220f, -0.03030177f, 0.08078093f, -0.00392696f, 0.04015579f, -0.15654404f, 
    -0.09371085f, -0.06878506f, 0.02753329f, 0.15320180f, 0.05904922f, 0.07891767f, 0.05319945f, 0.01539781f, 
    0.04198078f, -0.01857683f, 0.10802203f, 0.11228103f, 0.04907545f, 0.15472686f, 0.02031676f, -0.08046994f, 
    0.04519499f, -0.06846235f, -0.18560880f, 0.14226195f, -0.25651738f, 0.14286491f, -0.05848064f, 0.07196914f, 
    -0.07436354f, 0.00487183f, -0.11089264f, -0.09258154f, -0.00398592f, -0.02641515f, 0.13062806f, -0.04597165f, 
    -0.04168076f, 0.04191108f, 0.00338301f, -0.13203993f, -0.04868739f, -0.12451721f, -0.00073324f, -0.05036297f, 
    -0.21275304f, -0.04001784f, -0.25816390f, 0.01521091f, 0.01921599f, 0.11528724f, 0.06121462f, 0.09393156f, 
    0.13124402f, -0.10091660f, -0.02172992f, 0.03266450f, -0.03659869f, 0.08056475f, -0.13492170f, 0.07772656f, 
    0.00673526f, -0.00067962f, -0.05374146f, -0.07437929f, -0.11442731f, -0.14746454f, -0.08068704f, 0.18524952f, 
    0.10464229f, 0.05333410f, -0.08180098f, -0.05012091f, 0.10659420f, 0.00118018f, 0.04194074f, 0.03464027f, 
    -0.01732172f, 0.06963276f, 0.06328499f, -0.02360728f, 0.06879489f, 0.00897042f, -0.14583144f, -0.00844075f, 
    -0.45513079f, -0.16263479f, -0.15748446f, -0.15668587f, -0.00474105f, -0.03130978f, 0.00713183f, 0.01164396f, 
    -0.02982336f, -0.10455325f, -0.07503726f, -0.02207775f, -0.09626082f, -0.06425849f, -0.03018980f, 0.04784623f, 
    0.11355203f, 0.08441153f, -0.07327854f, -0.01734075f, -0.50556833f, 0.01242960f, -0.03088028f, 0.02245853f, 
    -0.26508281f, 0.00504019f, -0.07780878f, -0.08256586f, -0.10592107f, -0.01481373f, 0.13006648f, -0.09087104f, 
    0.09811565f, -0.01336487f, 0.02104369f, -0.06941958f, 0.04774631f, 0.03051423f, -0.02158314f, -0.09935531f, 
    -0.40520895f, 0.20816110f, -0.20857622f, -0.02518534f, -0.04935246f, 0.07145980f, 0.10085378f, -0.00246504f, 
    0.05526076f, 0.08682524f, 0.01999258f, -0.03770216f, -0.14293677f, -0.02361011f, -0.01842820f, 0.01823845f, 
    0.16813727f, 0.14421016f, 0.03799281f, -0.06635319f, -0.01939871f, -0.17479520f, 0.35427245f, 0.20379589f, 
    0.04398693f, -0.07145578f, -0.00274194f, -0.02721735f, -0.00690563f, 0.07630832f, 0.03029788f, -0.06596999f, 
    0.13524665f, 0.01104175f, 0.07461088f, -0.08111212f, -0.10017627f, 0.10651969f, -0.01224260f, -0.09060058f, 
    0.25990495f, -0.02649089f, 0.23015663f, 0.05193255f, 0.03646061f, -0.00650795f, 0.07517745f, -0.12518586f, 
    -0.04634217f, 0.11025646f, 0.10125899f, 0.08201190f, 0.10577251f, -0.03201613f, 0.01054334f, 0.02268912f, 
    -0.04255476f, 0.12711811f, 0.02947551f, 0.04951579f, 0.06695379f, -0.11735666f, 0.07213467f, -0.03676177f, 
    -0.15253897f, 0.03966373f, 0.00502939f, -0.03193572f, 0.02277476f, 0.00755304f, 0.17685673f, -0.01529910f, 
    0.08621826f, 0.02613563f, 0.03856895f, 0.03571155f, 0.00812301f, 0.09922744f, -0.18832782f, 0.08406101f, 
    -0.10905476f, -0.18880685f, 0.14055251f, 0.00406857f, -0.07158244f, -0.19987573f, -0.14801362f, -0.08660270f, 
    -0.12514375f, -0.02187274f, 0.02355381f, -0.04819346f, 0.00116517f, 0.06967904f, 0.17883800f, -0.04063817f, 
    -0.08451264f, 0.02646660f, -0.11445136f, -0.09468783f, -0.12858164f, -0.15306047f, -0.04817830f, 0.08031236f, 
    0.02955928f, 0.09764489f, 0.05286216f, -0.01100131f, 0.08726483f, 0.01331043f, 0.02111212f, -0.03335625f, 
    0.15188432f, 0.07168833f, 0.05410901f, 0.02518318f, 0.06327757f, -0.04342342f, -0.02475530f, 0.04781403f, 
    0.23469029f, 0.36533076f, 0.15777074f, 0.09599763f, 0.20835213f, 0.08886115f, 0.01844927f, -0.02262323f, 
    -0.02946327f, 0.03553894f, -0.00522860f, 0.03287564f, 0.05214984f, 0.05944365f, 0.01052403f, 0.01905150f, 
    0.08000503f, 0.07580961f, 0.12020423f, -0.03271218f, 0.16580074f, -0.06177571f, 0.18769817f, 0.15173434f, 
    0.07305344f, -0.07798603f, 0.00971873f, -0.11508653f, -0.06825979f, 0.00857222f, 0.09502136f, 0.09233829f, 
    0.04552754f, 0.07319674f, -0.00676086f, -0.02568904f, -0.03033646f, 0.14203085f, 0.04713779f, -0.02521647f, 
    -0.22489272f, -0.11539569f, -0.14060076f, -0.09144344f, -0.15888564f, 0.06903031f, 0.02229766f, 0.00201323f, 
    0.00997491f, 0.06851410f, 0.01241074f, 0.05627529f, 0.06061625f, -0.03317263f, -0.00019497f, -0.07294209f, 
    0.01788885f, 0.02565129f, -0.00889393f, 0.09738494f, 0.27068958f, 0.23424752f, 0.16072512f, 0.13155648f, 
    0.15729269f, 0.07646314f, -0.05074670f, 0.00398855f, -0.09388970f, 0.01496856f, 0.10317697f, 0.09954142f, 
    0.03107834f, -0.03122982f, 0.05638069f, 0.01683299f, 0.04760477f, -0.06562418f, 0.17951509f, -0.05931060f, 
    0.11915677f, 0.11321158f, 0.24258333f, 0.09632533f, 0.12863357f, -0.06841222f, 0.04555138f, 0.05058685f, 
    -0.03156869f, 0.05779091f, -0.04104096f, -0.15648928f, 0.01318037f, 0.04012704f, 0.09005875f, -0.15402676f, 
    0.10834107f, -0.08736827f, 0.11935063f, 0.12987325f, -0.35430753f, -0.02520862f, -0.07708210f, 0.08523802f, 
    0.02324041f, -0.06878288f, -0.06057468f, -0.05934419f, 0.06940413f, -0.12462465f, 0.00534448f, -0.04887814f, 
    0.03189661f, 0.07096784f, 0.03078555f, 0.05764231f, -0.03011939f, -0.08869787f, 0.06029219f, 0.03827256f, 
    -0.37146777f, 0.23932308f, -0.14007759f, 0.00272688f, 0.18747441f, 0.17050132f, 0.11448986f, 0.07297254f, 
    -0.02914322f, -0.04657578f, 0.00201315f, 0.00281582f, -0.04217306f, -0.01469219f, 0.10900395f, 0.16675058f, 
    0.09192465f, 0.02171178f, 0.14513494f, -0.07535623f, -0.13572381f, 0.06682447f, 0.24898849f, 0.03692971f, 
    -0.11647642f, 0.01163700f, -0.02277381f, 0.09876672f, -0.01904942f, 0.00889317f, 0.11971493f, -0.00409679f, 
    0.05754768f, 0.02098269f, 0.02062497f, -0.05130979f, 0.02859077f, -0.04730519f, 0.05817161f, 0.05216513f, 
    -0.01662460f, -0.12273679f, 0.03769660f, 0.04966905f, 0.01493222f, -0.26152864f, -0.24974313f, 0.14808477f, 
    -0.07596434f, -0.06165481f, 0.06240740f, -0.15501598f, 0.00181272f, 0.12722740f, 0.08207419f, -0.06879369f, 
    -0.01682290f, -0.10911092f, -0.04116333f, 0.12773564f, -0.64210129f, -0.06838176f, -0.05058786f, -0.00886374f, 
    -0.04546220f, 0.24284253f, -0.10615999f, -0.03450647f, 0.10956576f, -0.01482804f, -0.03431203f, 0.06108045f, 
    0.06143716f, 0.00255315f, 0.02316995f, 0.07542941f, -0.06054666f, 0.02007669f, -0.02876991f, 0.12285136f, 
    0.13692476f, 0.10833780f, 0.34232908f, 0.11139172f, 0.18590721f, 0.03549916f, 0.00616697f, -0.07770495f, 
    0.03209044f, 0.04000640f, -0.06626400f, 0.06567453f, 0.10455824f, -0.04851234f, 0.05566850f, -0.01421963f, 
    -0.01178135f, 0.05308352f, 0.06913757f, -0.02947207f, -0.53348273f, -0.16241005f, -0.17029552f, -0.12862307f, 
    -0.11385079f, 0.03552721f, 0.14473240f, 0.04048751f, -0.06911092f, 0.08430216f, 0.10518919f, -0.01430439f, 
    0.05135768f, 0.04079981f, -0.00636075f, -0.01121541f, 0.03308605f, -0.14767358f, 0.01239359f, 0.00573637f, 
    -0.56867290f, 0.00075768f, -0.19481558f, 0.08513662f, 0.10701519f, 0.19868125f, 0.03932520f, 0.05520267f, 
    0.06075454f, 0.05357989f, 0.00769262f, 0.01017249f, -0.00127667f, -0.00601460f, 0.01124498f, 0.16101590f, 
    0.08159525f, -0.04058020f, 0.07016856f, -0.00458894f, 0.20486031f, 0.16822779f, 0.15988551f, 0.08987622f, 
    0.10595480f, 0.01556493f, 0.07274053f, -0.04979439f, 0.04095905f, 0.05154128f, 0.01463618f, -0.00319617f, 
    -0.05809374f, 0.04111893f, -0.04887132f, -0.03270588f, 0.01908322f, -0.00736197f, 0.06823552f, 0.06206738f, 
    0.25113127f, 0.03064242f, -0.01743323f, -0.08557441f, -0.11151262f, 0.12895000f, 0.00229653f, 0.10485261f, 
    -0.02476353f, -0.00319298f, -0.00940528f, 0.04845154f, -0.02935682f, -0.00362561f, -0.00129580f, -0.07467849f, 
    0.04503147f, 0.04017505f, 0.08787972f, 0.03491633f, 0.10517758f, -0.25680494f, 0.05733148f, -0.02839744f, 
    0.30709580f, 0.03438394f, -0.06548894f, 0.13391729f, -0.08572721f, -0.03482204f, 0.02266490f, 0.02592126f, 
    0.11653565f, -0.00867905f, 0.02807226f, -0.08870800f, 0.14219958f, 0.00598463f, -0.01076465f, -0.12099320f, 
    0.00316894f, -0.18515523f, -0.14540476f, -0.05225655f, 0.10107464f, 0.05788407f, 0.04970495f, 0.00944964f, 
    -0.05652572f, 0.01852263f, -0.06595349f, 0.00797300f, 0.01141537f, 0.01869928f, 0.02922226f, 0.02628058f, 
    -0.03793064f, 0.10210089f, -0.00616047f, 0.02495994f, 0.10304355f, -0.16296233f, 0.15516987f, 0.15020420f, 
    -0.02605337f, 0.04020566f, -0.17531791f, 0.04463485f, 0.04236602f, 0.13055250f, 0.02830242f, -0.09144336f, 
    -0.06142686f, 0.03296851f, 0.00194084f, -0.08283924f, -0.05172641f, -0.03691943f, 0.04342182f, -0.09734260f, 
    -0.04227974f, 0.41107613f, 0.18452452f, 0.27467540f, -0.20306230f, -0.06589785f, -0.11886632f, 0.02861914f, 
    0.01568824f, -0.03279253f, 0.04598918f, 0.00764310f, 0.02327239f, 0.04563418f, 0.05899786f, -0.04767919f, 
    0.16008593f, -0.08840897f, 0.09258229f, 0.08724732f, 0.26955006f, -0.12846296f, 0.01050996f, -0.00168155f, 
    -0.12502064f, 0.10480155f, 0.03477795f, -0.05004050f, 0.00378679f, 0.06074189f, 0.08266144f, -0.02896861f, 
    -0.07254608f, -0.03351140f, 0.18276356f, -0.11029864f, -0.05690781f, 0.06029062f, 0.03029246f, -0.04934399f, 
    0.14320175f, 0.04947922f, 0.03481307f, -0.04854414f, -0.25719696f, 0.01616426f, 0.04250014f, -0.06884874f, 
    0.05886607f, 0.01670846f, 0.02632960f, 0.00752006f, 0.07935414f, 0.06594393f, -0.07136466f, -0.06658139f, 
    -0.06907728f, 0.07464506f, -0.12222862f, -0.00692205f, 0.17015092f, 0.18025914f, 0.14999147f, -0.02455926f, 
    -0.20712578f, -0.11633474f, -0.03263827f, 0.07635508f, -0.00219046f, 0.07108818f, 0.05244940f, 0.01760860f, 
    -0.06815297f, -0.03143974f, 0.09457183f, -0.09116985f, -0.07339684f, -0.07572009f, 0.02116889f, 0.00971638f, 
    -0.04601559f, 0.28185529f, 0.19731905f, 0.20007516f, 0.11164979f, -0.08189598f, -0.12116348f, -0.03446850f, 
    0.03273163f, -0.04574492f, 0.07504384f, -0.07545845f, -0.00159451f, -0.03747511f, 0.01321529f, -0.03321972f, 
    0.07787921f, -0.01741452f, -0.03823686f, 0.01179761f, -0.08194003f, -0.06949655f, 0.29825595f, -0.07717646f, 
    -0.15377843f, -0.11361372f, 0.04948867f, -0.15533072f, 0.11639133f, 0.02337791f, 0.03864567f, 0.01215140f, 
    0.13574579f, 0.05853445f, 0.01321281f, 0.02736569f, 0.09248678f, -0.01329826f, -0.05315722f, -0.07363999f, 
    0.06807564f, -0.34750190f, 0.10636231f, 0.03142143f, 0.03606548f, 0.14484780f, 0.04404127f, 0.07517011f, 
    -0.02232355f, -0.00149974f, 0.02705801f, -0.06915127f, -0.01692207f, 0.20647162f, 0.04615754f, 0.13699782f, 
    0.01887782f, -0.06513774f, 0.18101241f, -0.07637643f, -0.40290594f, 0.12752688f, -0.03328570f, -0.13614587f, 
    -0.11682623f, 0.21049067f, 0.08048424f, -0.00592181f, 0.07747502f, 0.00570031f, 0.04389570f, -0.01037556f, 
    -0.08888500f, -0.05498660f, -0.07029157f, -0.09037481f, 0.08493858f, -0.08344503f, 0.09723154f, -0.01834543f, 
    0.01864471f, 0.13356298f, 0.01875992f, 0.11812107f, -0.03254705f, -0.04439005f, 0.06375147f, -0.01894315f, 
    0.01003581f, 0.02075358f, 0.14124437f, 0.02865874f, -0.07718278f, 0.01968302f, 0.03256034f, -0.16361642f, 
    -0.07433666f, 0.01722299f, -0.01088116f, -0.08564640f, -0.14455105f, -0.09406526f, -0.32775053f, -0.09596852f, 
    0.36375067f, 0.00460067f, 0.12746873f, 0.01373476f, 0.03022747f, -0.09013221f, 0.10390977f, 0.03039677f, 
    0.02162862f, 0.01488701f, 0.08192655f, -0.01842276f, 0.07716402f, 0.03200037f, -0.10155760f, -0.06173981f, 
    -0.17610103f, -0.06235709f, -0.24626650f, -0.08445767f, 0.03423078f, 0.01448894f, 0.07560637f, 0.03203245f, 
    0.04729754f, 0.05123243f, -0.03280231f, 0.07046384f, 0.02348382f, 0.07129453f, 0.00515860f, -0.11448942f, 
    -0.02811465f, 0.14118104f, -0.01452460f, -0.02801110f, -0.17789482f, 0.07472610f, -0.04872306f, 0.03954809f, 
    -0.09769662f, -0.05978043f, 0.10645943f, -0.08502530f, 0.05827669f, -0.01845079f, 0.01134583f, 0.07564932f, 
    0.21909814f, 0.01893238f, 0.02354399f, -0.02278247f, 0.06161128f, -0.02522295f, -0.20290767f, -0.16185027f, 
    -0.01014843f, 0.19822608f, -0.00906226f, -0.07310031f, -0.01629245f, -0.04126955f, 0.11903220f, -0.04532905f, 
    0.12402716f, -0.13456352f, 0.07073887f, 0.02984910f, 0.07514521f, -0.06097536f, -0.03824154f, 0.04533346f, 
    0.17914112f, 0.06032149f, -0.11695963f, -0.06784456f, 0.03246516f, 0.00024817f, -0.05588201f, -0.08855361f, 
    -0.23393415f, -0.05164176f, -0.04642187f, -0.03073113f, -0.01602884f, -0.01875123f, -0.00024692f, -0.03891100f, 
    0.10183109f, 0.01028807f, -0.00371875f, -0.01096583f, 0.05286901f, -0.04355064f, 0.01721279f, 0.03014983f, 
    0.04508471f, 0.11853577f, 0.09877140f, -0.19511308f, 0.12458491f, -0.00327933f, -0.06035778f, -0.14027059f, 
    0.00903768f, -0.00877044f, 0.03471727f, -0.03913790f, 0.06704962f, -0.06145163f, -0.02738300f, -0.08292666f, 
    0.03353847f, 0.08240423f, 0.14932522f, 0.09362123f, 0.01492510f, -0.03413117f, -0.10992857f, 0.02436789f, 
    0.15678953f, 0.04071629f, 0.08594061f, -0.02681860f, 0.01901342f, -0.03746355f, 0.06317164f, -0.00699639f, 
    -0.02710892f, 0.13731834f, 0.06017390f, -0.13880691f, 0.02053455f, 0.16104540f, -0.07747152f, 0.00351582f, 
    -0.25609279f, 0.00392851f, 0.10379338f, 0.21539231f, -0.19528586f, 0.02400340f, -0.02200737f, -0.03413928f, 
    0.01303920f, 0.01579859f, -0.01343681f, 0.11999850f, -0.08538809f, 0.04971682f, 0.04611743f, 0.00154145f, 
    0.00221799f, -0.07765079f, -0.10702764f, 0.02361090f, 0.02558000f, 0.26440647f, -0.00960598f, -0.08617472f, 
    0.17786157f, 0.05800864f, -0.01947631f, -0.09982617f, 0.07044721f, 0.11727612f, 0.04883117f, -0.05302695f, 
    0.02270747f, 0.00595744f, -0.04744917f, 0.01534040f, 0.05893664f, -0.00396544f, 0.04426478f, 0.07289368f, 
    -0.08268940f, -0.12104246f, -0.05251032f, -0.00566590f, -0.02737687f, 0.10198297f, 0.03485730f, 0.11748369f, 
    -0.05169750f, -0.01424472f, -0.00002060f, 0.05217283f, -0.15793154f, -0.04362265f, -0.04660100f, 0.04223683f, 
    0.11081198f, 0.05073996f, -0.01855695f, -0.01580005f, 0.14979436f, 0.11543801f, -0.11493825f, 0.11213332f, 
    -0.23000506f, 0.01900372f, -0.01808283f, 0.08575162f, -0.04357160f, -0.03100711f, 0.07840049f, -0.03188160f, 
    0.01417750f, 0.12370043f, 0.12530297f, -0.02914850f, 0.04922663f, 0.04245980f, 0.00973338f, 0.06694493f, 
    0.15301530f, 0.39982551f, 0.08316971f, 0.17011230f, 0.17395489f, -0.10600347f, -0.11097099f, 0.04466800f, 
    0.04341024f, 0.09428766f, 0.02351415f, -0.07770913f, -0.16552979f, -0.13040522f, 0.07335028f, -0.01620213f, 
    -0.06026238f, 0.10803311f, 0.08189850f, 0.08686531f, -0.04287508f, 0.24926183f, -0.31899059f, 0.00024072f, 
    -0.13620555f, -0.04287223f, -0.11575488f, -0.08819654f, -0.04743757f, 0.05778115f, 0.05760050f, 0.02064879f, 
    0.05767271f, 0.11244726f, 0.10283197f, 0.00577587f, -0.09039155f, -0.16239133f, -0.04107559f, -0.09798929f, 
    0.10719300f, 0.08438806f, -0.01511410f, -0.21971574f, 0.09784751f, 0.02467222f, 0.03640262f, 0.07817408f, 
    -0.07488486f, -0.01838951f, 0.09453210f, 0.05874906f, 0.01519985f, -0.08344196f, 0.08821926f, 0.11900576f, 
    0.12347256f, -0.01105699f, -0.04254410f, 0.05103835f, 0.21338102f, -0.00740951f, 0.18249491f, -0.06903587f, 
    0.03104660f, -0.06914545f, 0.00113462f, -0.04271097f, 0.02387182f, -0.00415280f, 0.01741257f, 0.08387221f, 
    0.01214825f, -0.00595848f, 0.02773346f, 0.15984140f, 0.07172526f, -0.00854119f, 0.05714734f, 0.09146202f, 
    0.07302943f, -0.22388522f, -0.15379545f, -0.08921988f, 0.13841747f, 0.05833313f, 0.07098289f, -0.05825448f, 
    -0.08397382f, -0.04834128f, 0.04070120f, 0.04168252f, 0.03311528f, 0.05553335f, 0.00046529f, 0.06540688f, 
    -0.00250358f, 0.11197013f, 0.02078614f, 0.10308605f, 0.25920749f, 0.02632560f, -0.06274421f, -0.00349953f, 
    -0.08720123f, 0.01341677f, -0.09715477f, 0.02292897f, 0.13344096f, 0.03016027f, -0.01618430f, -0.03504558f, 
    0.06385528f, 0.11902296f, -0.01425765f, -0.01015646f, -0.06267928f, -0.05808562f, 0.13920943f, 0.04499101f, 
    0.17190962f, 0.05270142f, 0.10925304f, 0.08994298f, 0.25155506f, -0.14334182f, -0.08751575f, 0.03266756f, 
    0.05056838f, 0.05413435f, 0.09319977f, -0.03557447f, -0.00457778f, -0.01395175f, 0.03447784f, 0.06150552f, 
    0.03588921f, -0.01603821f, 0.06105599f, 0.04200093f, 0.15058510f, 0.05916500f, -0.03649073f, -0.05533498f, 
    0.08692022f, 0.04696770f, 0.04895436f, 0.04028612f, 0.02186436f, -0.05866597f, 0.01361641f, -0.06369839f, 
    0.00772231f, 0.06634439f, 0.02720534f, -0.01710270f, -0.02705702f, 0.05344458f, 0.05269593f, 0.13852572f, 
    -0.02181195f, -0.02996447f, 0.01250168f, -0.03399558f, 0.01007400f, 0.00541785f, 0.00786525f, 0.02612179f, 
    -0.02297789f, 0.01856470f, -0.00137731f, -0.01361829f, 0.02469764f, 0.00756334f, -0.01620821f, 0.00993296f, 
    -0.01183965f, -0.03079497f, -0.04469819f, 0.02366256f, 0.02751607f, 0.02157587f, -0.01829579f, -0.00019474f, 
    -0.01204542f, 0.03259664f, -0.01713710f, -0.00532979f, 0.00922060f, 0.00876129f, 0.01522146f, -0.02147257f, 
    0.00003186f, 0.02413652f, 0.01417158f, 0.01439527f, 0.00062496f, -0.02293674f, -0.01895636f, -0.02225459f, 
    0.00858914f, -0.01905159f, -0.01724667f, 0.00867153f, 0.00081518f, -0.03156834f, -0.01958502f, -0.02884829f, 
    0.00249603f, 0.00408571f, -0.03671787f, -0.02604204f, -0.03681368f, -0.01307382f, -0.02408055f, -0.00322031f, 
    -0.00772924f, 0.01815568f, -0.03796001f, 0.01992218f, -0.04261725f, 0.02782997f, -0.04168148f, -0.03743832f, 
    -0.01075786f, 0.02245968f, -0.04391391f, -0.00274799f, -0.00924003f, 0.00732600f, 0.00433338f, -0.03228366f, 
    0.03182469f, 0.02390152f, -0.00124404f, 0.02076656f, 0.00701907f, 0.01691511f, 0.03161955f, -0.01688924f, 
    0.03559249f, -0.00377034f, -0.00838929f, 0.02902922f, 0.03085975f, -0.01486726f, 0.02580304f, 0.02845941f, 
    -0.00309216f, -0.01467329f, -0.03581996f, 0.00169404f, -0.01032268f, 0.02980082f, 0.01487211f, 0.01764609f, 
    -0.04202354f, -0.01012965f, -0.00992633f, 0.00167244f, -0.04140557f, -0.00261960f, 0.00968533f, -0.01122138f, 
    0.02948220f, -0.02418447f, 0.00014877f, 0.00880225f, -0.04351543f, 0.00073168f, -0.03412459f, -0.00502873f, 
    -0.03513298f, -0.00907810f, -0.01254299f, -0.00283704f, 0.02015986f, 0.02608915f, -0.02328428f, -0.04428650f, 
    0.00096559f, -0.03712757f, -0.02705749f, 0.02461188f, 0.00072121f, 0.03026385f, -0.00099046f, -0.02608091f, 
    0.01596192f, -0.02583493f, -0.00142515f, -0.01437913f, -0.01169867f, -0.01879146f, -0.00540751f, -0.03050139f, 
    -0.02679352f, -0.03234500f, -0.00387344f, 0.01838363f, -0.01875003f, 0.02941936f, -0.02010407f, -0.02691480f, 
    -0.02955775f, 0.00453247f, -0.03808122f, 0.02804680f, 0.01344978f, 0.02786237f, -0.00065252f, -0.00938226f, 
    0.02947330f, -0.02074957f, -0.03559905f, 0.01475227f, -0.03502785f, 0.01796530f, -0.04343394f, 0.02362413f, 
    0.02026589f, -0.00739380f, 0.01982584f, -0.01358202f, 0.03108634f, 0.00081386f, 0.02301325f, -0.02366394f, 
    -0.04099713f, -0.00202370f, -0.02804154f, -0.02005428f, 0.00563947f, -0.04104376f, 0.01250710f, -0.00044095f, 
    -0.01666768f, -0.03055365f, -0.01045023f, 0.02694716f, 0.00963991f, -0.03725975f, 0.01993291f, 0.02780732f, 
    -0.02971462f, -0.02899731f, 0.02316136f, 0.01836847f, 0.00045780f, -0.03523739f, 0.02071723f, -0.01471471f, 
    -0.02832276f, 0.00627817f, 0.02516749f, 0.02777112f, -0.00098033f, -0.01477650f, -0.01083635f, 0.02855973f, 
    -0.00622284f, -0.02819637f, 0.00678754f, 0.02781960f, -0.00345240f, -0.02875453f, 0.03013728f, 0.02879378f, 
    0.00411074f, -0.00158320f, 0.01927655f, 0.02016853f, 0.01076655f, -0.01875615f, -0.02350516f, -0.01303136f, 
    0.01559691f, -0.01704654f, 0.02228007f, -0.01682289f, 0.00927846f, 0.03025361f, -0.00913297f, 0.03222345f, 
    0.00463126f, 0.00274098f, -0.03771988f, -0.00760294f, -0.04693042f, 0.02534920f, -0.01186017f, -0.02746681f, 
    0.02173939f, 0.03068951f, -0.01645438f, -0.00118859f, 0.00940896f, -0.03652409f, -0.00476644f, 0.01086638f, 
    0.01741567f, 0.00946824f, -0.02175601f, 0.01303998f, -0.00623469f, -0.00869249f, 0.00263693f, -0.00962112f, 
    -0.01909069f, -0.04474193f, -0.04084247f, 0.02681417f, -0.00464400f, -0.00026578f, -0.02409190f, 0.02606270f, 
    -0.00822412f, -0.01970029f, -0.00409666f, -0.00459236f, 0.00419547f, -0.02246936f, -0.02898146f, -0.00820800f, 
    -0.02672173f, 0.03234085f, -0.03092235f, -0.02054865f, -0.03283399f, -0.00261932f, -0.03871110f, -0.00542942f, 
    0.03005587f, -0.00191420f, 0.03221468f, -0.03161635f, 0.02061314f, -0.02471469f, -0.03801527f, -0.00430066f, 
    -0.02641428f, -0.04031227f, 0.00038210f, 0.00022793f, -0.00185138f, -0.03050972f, -0.03997200f, 0.03340991f, 
    -0.03156846f, 0.00242245f, 0.03088199f, 0.00420498f, -0.01301898f, -0.01619264f, -0.03299202f, -0.00254970f, 
    0.00774200f, -0.00657863f, -0.02144557f, -0.04119598f, -0.01103383f, -0.02721194f, -0.00209406f, -0.00732821f, 
    -0.00142865f, 0.01409807f, -0.00566170f, -0.00935936f, 0.00323839f, -0.01052247f, -0.02962031f, -0.04100096f, 
    -0.02268826f, -0.00093621f, -0.00965622f, 0.00818969f, -0.01530584f, 0.00567363f, -0.01214625f, -0.03623605f, 
    -0.00280950f, 0.00229922f, 0.02598115f, -0.02957350f, -0.02320720f, -0.03188808f, -0.03699181f, 0.00614751f, 
    -0.04149731f, -0.00449840f, -0.00707182f, -0.04140454f, 0.01245062f, 0.02473517f, -0.01267377f, -0.00188794f, 
    -0.01115594f, 0.02975461f, 0.01999992f, -0.01425525f, 0.01031342f, 0.01251821f, 0.00414598f, 0.01282030f, 
    0.02032772f, -0.03482832f, 0.02188849f, -0.03704794f, 0.00793601f, 0.02843560f, -0.00950694f, 0.01218730f, 
    0.02586988f, -0.02038074f, -0.03005021f, -0.01389627f, 0.03063306f, -0.01355092f, 0.02548444f, 0.01106523f, 
    0.03258710f, -0.04352547f, 0.03026463f, -0.02742938f, -0.00944878f, -0.02299433f, 0.01732502f, -0.01849162f, 
    0.02821456f, -0.00699940f, -0.00441767f, -0.01386610f, 0.01856064f, -0.04158501f, -0.03605137f, 0.00538487f, 
    -0.00614287f, 0.01596868f, 0.00579661f, 0.02965435f, -0.04545424f, -0.01227217f, 0.00267381f, 0.01781602f, 
    -0.02335121f, -0.04332253f, 0.00647117f, 0.01524650f, -0.00053288f, -0.01482673f, -0.01195041f, -0.01054036f, 
    -0.04078574f, 0.02969048f, -0.03543991f, 0.01616067f, 0.02821078f, -0.02346925f, -0.00384930f, -0.00793112f, 
    -0.03698369f, -0.02012513f, -0.01598759f, 0.01748447f, 0.01441785f, -0.01851728f, 0.02867290f, -0.01094014f, 
    0.01115450f, 0.02620770f, 0.02542508f, 0.02231597f, -0.04248866f, -0.04024818f, 0.02546446f, -0.04357667f, 
    -0.01829338f, 0.02801825f, -0.02126488f, -0.04123597f, -0.03455097f, -0.01991539f, -0.00009210f, 0.00209498f, 
    -0.02576997f, -0.01176496f, -0.04226028f, -0.03134513f, 0.00423180f, 0.02632884f, -0.03148974f, -0.01786237f, 
    -0.03767848f, 0.03097517f, 0.00175376f, -0.03811767f, 0.01829658f, 0.03242157f, -0.01387600f, 0.02904106f, 
    0.01496371f, -0.01047984f, -0.02470183f, -0.00112693f, -0.02083611f, -0.01715336f, 0.01888152f, 0.01002003f, 
    -0.02871703f, -0.03643133f, 0.00044449f, -0.00315116f, -0.02902359f, 0.02607854f, -0.00851704f, -0.02260485f, 
    -0.02391458f, -0.00309167f, -0.02700744f, 0.02860578f, -0.00773891f, -0.01437989f, -0.03504410f, -0.03128386f, 
    -0.03568912f, -0.01686933f, -0.04028704f, -0.02274371f, 0.01313405f, 0.01963749f, 0.01482876f, -0.01655775f, 
    -0.02367470f, -0.01915253f, -0.04078750f, 0.01703027f, -0.03976404f, -0.03030745f, -0.03675184f, -0.02518761f, 
    0.00851628f, 0.01764887f, 0.01546660f, 0.01505021f, -0.02361520f, -0.01179153f, -0.00198203f, 0.03092111f, 
    -0.01545150f, 0.01838426f, -0.01771107f, -0.01060005f, -0.02822223f, 0.01351171f, -0.01450020f, -0.03214085f, 
    0.00744596f, -0.03680209f, -0.03093919f, -0.00229536f, -0.02050018f, -0.01048724f, 0.01006912f, -0.03004500f, 
    -0.00296266f, -0.00387419f, 0.00256015f, -0.01969406f, -0.00118113f, -0.03454545f, -0.01570334f, -0.03962743f, 
    -0.04370189f, -0.02759955f, -0.02240119f, -0.03239284f, 0.02107600f, 0.01297650f, -0.00675033f, -0.02955015f, 
    -0.04511456f, -0.01986418f, -0.02944797f, -0.01048476f, -0.03857685f, -0.03268098f, -0.02064515f, -0.02397297f, 
    0.00353731f, -0.00496055f, 0.03277650f, 0.01882806f, 0.02190877f, -0.01746696f, -0.04475240f, -0.03244912f, 
    -0.04343743f, 0.01611899f, 0.02021263f, -0.00844764f, -0.03942169f, 0.01962101f, 0.01019862f, 0.00916309f, 
    -0.03916538f, 0.00138387f, -0.00560310f, -0.00243795f, -0.01692988f, 0.01020810f, 0.00810380f, -0.00849200f, 
    0.02674660f, 0.01953302f, 0.01815577f, -0.04337186f, -0.02998588f, -0.03839307f, -0.04446733f, -0.02180283f, 
    0.02326041f, 0.00783928f, 0.00619637f, -0.00687586f, -0.04501422f, -0.03357233f, -0.04254444f, -0.02016474f, 
    -0.00145818f, -0.03654023f, 0.02927403f, 0.01009405f, -0.02249592f, -0.04352388f, -0.00502905f, 0.00930497f, 
    -0.03609710f, -0.02202000f, -0.01843834f, -0.03790335f, 0.02961438f, -0.01738470f, 0.02285896f, 0.02088190f, 
    0.03134244f, 0.00158480f, -0.02871766f, 0.01492008f, -0.03235160f, -0.00488752f, -0.01180825f, -0.00493365f, 
    -0.03443037f, 0.02592677f, -0.03350943f, -0.03322096f, 0.02288882f, -0.01489132f, -0.03810759f, -0.02254096f, 
    -0.01149589f, -0.03879419f, -0.04498297f, -0.01783892f, -0.00332434f, -0.04593349f, -0.01648063f, 0.00344337f, 
    0.02889057f, -0.00529682f, 0.00693168f, 0.01486704f, -0.04161447f, -0.02938161f, -0.00060656f, -0.02155914f, 
    -0.04402915f, -0.02100239f, -0.03829424f, 0.02368279f, -0.01265664f, -0.00201197f, -0.03970352f, -0.02275418f, 
    -0.04223514f, -0.01859384f, -0.01459200f, -0.00592807f, -0.03319104f, -0.00080171f, -0.01705064f, 0.01713358f, 
    0.01153871f, 0.00538763f, 0.00974672f, 0.02340276f, 0.03104899f, 0.01730160f, 0.03095681f, 0.01736343f, 
    0.02317086f, 0.03765706f, -0.03137593f, 0.02334752f, -0.00700651f, 0.01207646f, 0.01233614f, 0.00267870f, 
    0.01561180f, 0.02690971f, -0.04136482f, -0.00181753f, -0.04015157f, 0.01657858f, -0.00147996f, 0.00349371f, 
    0.02529749f, -0.00429813f, -0.01537602f, -0.04362157f, 0.00787633f, 0.01441820f, -0.02761688f, -0.00651922f, 
    -0.01626642f, 0.02638480f, 0.02528928f, 0.00919063f, -0.02181379f, 0.00174771f, -0.01005304f, -0.03354925f, 
    -0.00397616f, 0.01223302f, -0.04247302f, -0.00468173f, -0.03339063f, -0.03535672f, -0.03401309f, -0.01178916f, 
    0.00571292f, -0.00870761f, -0.02202740f, 0.00161943f, 0.03034958f, -0.04364857f, 0.02180362f, -0.00641540f, 
    -0.00102913f, -0.03209743f, -0.03689674f, -0.00147001f, -0.00378756f, 0.02733259f, -0.03952924f, -0.00514268f, 
    -0.04756154f, -0.03547776f, 0.01812636f, -0.04187224f, 0.00308191f, 0.02526170f, -0.02444082f, -0.01541131f, 
    -0.03145623f, -0.01507326f, 0.02856083f, 0.00635706f, -0.02719325f, 0.01362717f, 0.01042905f, 0.01943413f, 
    -0.01325961f, -0.04320582f, 0.03753893f, -0.01612584f, 0.03258944f, -0.01695587f, -0.01228943f, 0.03032348f, 
    0.02174219f, -0.01424831f, -0.03270786f, -0.00224554f, 0.01397428f, -0.00042240f, 0.01114307f, -0.03255969f, 
    -0.04632188f, -0.03276395f, 0.02415834f, -0.02381220f, -0.04722223f, -0.02857030f, 0.00169164f, 0.02836577f, 
    0.00016101f, 0.00065961f, 0.00952742f, -0.02965511f, 0.02351443f, -0.00801621f, -0.02202500f, -0.03741775f, 
    -0.01550614f, -0.01687879f, -0.02582822f, -0.01834366f, 0.00332294f, -0.03289906f, -0.02656899f, -0.02317836f, 
    0.01216342f, 0.00561216f, -0.04342828f, 0.00702411f, -0.02645507f, 0.00231416f, -0.03831635f, -0.03684399f, 
    0.02405156f, 0.01863546f, -0.03365128f, 0.02977773f, -0.03910294f, -0.02880561f, 0.01199665f, -0.03796928f, 
    -0.00557113f, 0.00339626f, -0.02177036f, 0.02016796f, -0.04658705f, -0.00703113f, -0.00152401f, -0.04328606f, 
    -0.00391102f, -0.00440498f, -0.02794708f, -0.03183045f, -0.00906477f, 0.02548542f, -0.04634767f, -0.04331330f, 
    -0.03539523f, -0.03659309f, -0.04034343f, -0.04725000f, 0.00020737f, -0.02187869f, -0.01502843f, -0.03188765f, 
    -0.02400838f, -0.01010712f, -0.02329821f, -0.04223149f, -0.02632251f, -0.01982624f, -0.03036785f, -0.03023106f, 
    0.00980027f, 0.03090134f, -0.00879616f, 0.00897689f, -0.00073934f, -0.03593031f, 0.00253085f, -0.01767909f, 
    0.00344621f, -0.00446923f, 0.02570629f, -0.00927436f, 0.00797238f, -0.02977536f, -0.00915390f, 0.00732590f, 
    -0.02154527f, 0.00134866f, -0.03785924f, -0.02147585f, 0.01221292f, -0.00399257f, 0.00736416f, -0.02222583f, 
    0.01655980f, -0.01700878f, 0.00686672f, 0.00266609f, 0.01556770f, 0.00116517f, -0.03037765f, -0.02592983f, 
    -0.00242272f, -0.00783175f, 0.01606010f, -0.00218833f, -0.01998826f, 0.02931754f, -0.00453746f, -0.01606974f, 
    -0.01378952f, -0.03788478f, -0.03703057f, 0.00597016f, -0.03891011f, 0.02861612f, -0.03636045f, 0.00244596f, 
    -0.00985735f, -0.01180081f, -0.02324180f, -0.00649550f, -0.03665029f, -0.00131611f, -0.02896355f, 0.00931659f, 
    -0.00517394f, -0.00890920f, -0.01136159f, -0.00294973f, 0.03040400f, -0.01220017f, -0.01641610f, 0.03135379f, 
    -0.02044641f, -0.00752683f, 0.02036712f, -0.01717144f, 0.01787608f, -0.01588627f, -0.02099571f, 0.00665202f, 
    0.01803697f, 0.01518525f, -0.02470028f, -0.03652662f, -0.00750965f, -0.00111538f, 0.00736201f, -0.00903406f, 
    -0.03766459f, 0.01958308f, -0.00883710f, -0.04180635f, -0.00359011f, 0.02497867f, 0.00079006f, 0.01076973f, 
    -0.02720871f, 0.01044447f, -0.01421936f, -0.01763723f, -0.02356274f, 0.02045479f, 0.00263691f, -0.01377883f, 
    -0.00564859f, -0.03625635f, -0.02662161f, -0.02156191f, 0.00185881f, -0.03041425f, 0.02970247f, -0.00708640f, 
    -0.02804813f, -0.00760715f, 0.01918992f, -0.02341518f, 0.00510503f, -0.02279961f, 0.02144029f, -0.01616923f, 
    -0.04172182f, 0.02976849f, -0.00833647f, -0.02455042f, -0.00527693f, -0.00078550f, -0.01822343f, -0.02420028f, 
    0.02826633f, 0.02127708f, 0.01300287f, 0.02996576f, 0.00389269f, 0.03073404f, -0.02566670f, 0.01851898f, 
    -0.00065051f, 0.01414168f, -0.01650891f, 0.01786552f, 0.02201944f, 0.02610431f, 0.00040205f, 0.01245101f, 
    0.02342206f, -0.01685471f, -0.01245980f, 0.02592791f, 0.01356277f, 0.00108234f, 0.02323345f, -0.03327857f, 
    -0.03714184f, -0.00072495f, -0.01811583f, -0.01280990f, 0.03038164f, -0.04202748f, -0.02353984f, 0.01694641f, 
    -0.01115508f, -0.01207102f, 0.02843726f, -0.02856835f, -0.00272287f, 0.03291405f, -0.00581164f, -0.03960163f, 
    -0.04089212f, 0.01285487f, -0.01111719f, -0.00360835f, 0.02781746f, 0.03207881f, 0.03336414f, 0.00443790f, 
    -0.01525245f, -0.02123381f, 0.02074157f, 0.00834986f, -0.01035978f, 0.00478226f, 0.02794713f, 0.03119703f, 
    0.00588484f, 0.03660394f, 0.03202311f, 0.01624886f, -0.01695751f, 0.02077630f, 0.01437580f, -0.00703098f, 
    -0.01537169f, -0.00768762f, -0.00966924f, -0.03152589f, -0.03896806f, -0.02242281f, -0.01600900f, -0.03307622f, 
    0.03406299f, -0.01920797f, 0.03223720f, -0.00673041f, -0.01286685f, 0.01140078f, 0.00437421f, -0.02049022f, 
    -0.03144424f, -0.02975971f, 0.02557318f, -0.01345652f, -0.02298223f, 0.02391036f, -0.03186312f, 0.01124553f, 
    0.00220223f, -0.03749833f, -0.04464299f, 0.00122442f, 0.01201268f, 0.00213075f, 0.02469831f, 0.03891055f, 
    -0.02840356f, -0.03462577f, -0.02437246f, 0.02198221f, -0.03564028f, -0.01670225f, 0.01638275f, -0.02009322f, 
    0.00069199f, -0.01237644f, -0.01143565f, -0.04227815f, -0.00192762f, 0.00846950f, -0.00022847f, 0.02117428f, 
    -0.03536787f, -0.00742888f, 0.02016539f, 0.00077816f, -0.03839932f, 0.00017444f, -0.03686631f, -0.01649540f, 
    -0.01768680f, -0.03464787f, -0.01024631f, 0.01225801f, -0.04409454f, 0.02253919f, 0.02686627f, 0.01294620f, 
    0.01263806f, -0.04332900f, 0.01266376f, -0.03331421f, 0.02327021f, -0.01658433f, 0.01749866f, -0.00848695f, 
    0.02112954f, 0.01074336f, -0.04686376f, 0.01515632f, -0.01654320f, 0.00013983f, 0.01166510f, -0.02738146f, 
    -0.00881414f, -0.02562982f, 0.02183081f, 0.02007560f, 0.02505798f, 0.00585438f, -0.04390529f, 0.03158440f, 
    0.01638102f, -0.04314981f, 0.01190439f, -0.04283323f, 0.00446695f, 0.02086688f, 0.00261264f, -0.03239967f, 
    -0.03280783f, -0.02338777f, -0.02751461f, 0.01115202f, -0.03068642f, -0.00883340f, -0.01697076f, 0.00692809f, 
    0.02291782f, -0.03104019f, -0.00507432f, -0.04069202f, -0.00132263f, 0.00434120f, -0.02867687f, -0.02955541f, 
    -0.00571143f, 0.03124347f, -0.03826168f, -0.03154005f, -0.02908624f, 0.02439151f, -0.02268998f, -0.04383866f, 
    -0.00168805f, 0.01277536f, -0.01937466f, -0.01954040f, -0.02346803f, 0.00417649f, 0.00065947f, -0.00051711f, 
    0.00863301f, -0.02753380f, -0.04093722f, 0.01779334f, -0.04188652f, 0.00922393f, -0.01412379f, 0.02857840f, 
    -0.02280742f, 0.01387067f, 0.00869888f, -0.02630955f, -0.03058526f, -0.01617249f, 0.02219001f, -0.02554068f, 
    0.01853108f, -0.04171655f, 0.01681614f, -0.02571102f, 0.02478615f, -0.01531281f, -0.03720715f, -0.00843792f, 
    -0.04832542f, 0.00282815f, -0.04273197f, 0.00117868f, -0.04271516f, -0.01045220f, -0.03300906f, 0.00198866f, 
    0.02863787f, 0.01482727f, 0.02571727f, 0.03147886f, -0.02127176f, -0.01479726f, -0.02468277f, -0.00589291f, 
    0.02532351f, -0.02204256f, 0.03094028f, -0.02783824f, 0.00385824f, -0.03178853f, 0.01208714f, -0.01869781f, 
    0.02482862f, 0.00926208f, -0.02685927f, 0.01836354f, -0.01815627f, 0.00618448f, -0.03472565f, -0.00215830f, 
    -0.04027021f, 0.02903860f, -0.04335533f, 0.00921599f, 0.02654536f, -0.01234690f, -0.01548413f, -0.02462847f, 
    0.00907017f, -0.02934565f, 0.01016627f, -0.02239880f, 0.01184608f, -0.00467188f, 0.00419848f, -0.03078641f, 
    -0.00247713f, -0.00742873f, 0.00804373f, 0.01151184f, 0.00332260f, 0.00939169f, -0.02745567f, 0.02185076f, 
    -0.03515019f, 0.02077919f, -0.03040707f, 0.02624751f, -0.02313853f, 0.01978580f, 0.00670465f, 0.02921597f, 
    -0.00730187f, -0.02763200f, -0.01416722f, 0.01138763f, -0.02488535f, 0.01961895f, -0.01923501f, -0.00266827f, 
    0.00068771f, 0.01261634f, -0.03290553f, -0.03921357f, -0.00710573f, 0.02642004f, -0.04845000f, 0.00562189f, 
    -0.01940942f, 0.02442133f, -0.04545576f, -0.01631185f, 0.02072274f, 0.02581633f, -0.03151792f, 0.03567995f, 
    0.00087271f, 0.00832685f, -0.02447958f, 0.00383626f, 0.01721311f, -0.03347671f, -0.00397063f, -0.00426003f, 
    -0.01527501f, -0.03475741f, -0.01090777f, -0.03184650f, -0.02656966f, 0.01291707f, -0.01594916f, -0.03750007f, 
    0.02546065f, 0.01906382f, 0.00590923f, -0.02737215f, -0.01182538f, 0.00474971f, -0.00901909f, -0.00161842f, 
    0.02103732f, -0.01452723f, -0.00667178f, 0.02636592f, -0.04323818f, 0.01107622f, -0.01708332f, -0.02003518f, 
    0.00251151f, -0.02458283f, 0.01184949f, -0.03908951f, 0.02197488f, 0.02238260f, -0.03652673f, 0.03039330f, 
    -0.02821928f, 0.00840062f, -0.02472513f, -0.04654686f, -0.03474249f, 0.01728088f, -0.04577566f, 0.02978375f, 
    0.02721172f, 0.00708891f, -0.03789492f, -0.03489929f, 0.02074918f, -0.03015789f, -0.04477433f, -0.03231364f, 
    0.01901225f, 0.01726899f, 0.00808504f, 0.01330137f, -0.03541394f, 0.03584166f, 0.00435042f, -0.02133541f, 
    -0.02001124f, -0.03618735f, 0.02006334f, -0.02658650f, -0.03459139f, -0.03948736f, 0.00352863f, -0.00131036f, 
    -0.02991188f, 0.01648355f, 0.02665642f, 0.02844944f, -0.02792087f, -0.03076280f, -0.03339624f, -0.01105090f, 
    -0.03899975f, 0.01062043f, -0.01376703f, -0.00685408f, -0.00481887f, 0.02017171f, -0.04625110f, -0.01552456f, 
    -0.02250955f, -0.00243135f, -0.01667522f, -0.00520753f, -0.04644063f, -0.00482620f, 0.01648109f, 0.00757372f, 
    -0.04144372f, -0.01536451f, 0.01393863f, -0.01809444f, -0.00852487f, 0.00578226f, 0.02387395f, -0.03060725f, 
    -0.04003881f, -0.02506622f, 0.02420203f, 0.01248725f, -0.00300829f, -0.04207738f, 0.02625782f, -0.02493980f, 
    -0.02009800f, -0.02647727f, 0.00230359f, -0.02461091f, 0.02891856f, 0.01838143f, -0.03086686f, -0.01036428f, 
    -0.00605468f, -0.00513703f, 0.00156497f, -0.01700483f, -0.02294893f, 0.02337368f, 0.01007121f, 0.03173499f, 
    0.01511854f, -0.03477778f, -0.00930508f, -0.04011605f, -0.00773180f, -0.00299705f, -0.01443910f, 0.01177303f, 
    0.02386132f, -0.00778940f, 0.01165941f, -0.02422225f, 0.03068477f, 0.02679985f, -0.03832724f, -0.03202710f, 
    0.02753141f, -0.00071535f, -0.03186631f, 0.00182114f, -0.00708528f, 0.02599633f, -0.00262687f, -0.03849787f, 
    0.00511936f, 0.02006175f, -0.03269408f, 0.02731998f, 0.03310975f, -0.01962481f, -0.02520533f, -0.02100308f, 
    0.01506394f, -0.03440183f, -0.00549178f, 0.03132506f, -0.04016369f, -0.00500947f, 0.01420431f, 0.02172270f, 
    0.01114685f, 0.01868718f, 0.03739536f, -0.03450971f, -0.02046800f, 0.03198298f, -0.01069607f, -0.02110488f, 
    -0.01507831f, -0.01479455f, 0.02183551f, 0.03006439f, -0.01904174f, 0.00439975f, -0.01250671f, 0.02456981f, 
    0.02332842f, -0.02441026f, 0.02441510f, -0.03477604f, -0.02385465f, 0.00525526f, 0.00723246f, 0.03384851f, 
    0.02533480f, -0.00934213f, -0.01202948f, -0.02667834f, -0.00425737f, 0.00351645f, 0.02512879f, 0.02896446f, 
    0.03151298f, -0.00551527f, 0.01242779f, -0.03887351f, 0.02000052f, -0.02394987f, 0.00372667f, 0.02259307f, 
    -0.01700818f, -0.02119260f, -0.02660887f, -0.01841035f, 0.01498676f, 0.02144187f, -0.01978550f, 0.03462653f, 
    -0.00205770f, 0.03480393f, -0.03079252f, 0.02547488f, 0.03426808f, -0.02338165f, -0.02548628f, -0.02719748f, 
    -0.04363625f, 0.01307681f, -0.02620015f, -0.02912701f, -0.02251526f, 0.00360687f, -0.00272951f, 0.02748282f, 
    -0.03047745f, 0.00237698f, 0.02554433f, 0.03263535f, -0.01059328f, 0.01073447f, 0.03595424f, -0.00967454f, 
    0.01790302f, 0.01342413f, 0.03731684f, -0.00635343f, -0.01042424f, -0.00937039f, -0.00295811f, -0.00019759f, 
    -0.02448333f, 0.01618228f, 0.01006636f, 0.03648673f, -0.02694906f, 0.00421192f, 0.00628370f, 0.02411755f, 
    0.01444730f, -0.03865171f, -0.00816976f, -0.00792157f, 0.01051366f, 0.02617315f, -0.01794910f, -0.02992527f, 
    -0.00318252f, 0.03188244f, 0.02784394f, -0.00082790f, -0.00501412f, -0.01508680f, -0.00876829f, -0.00607347f, 
    0.02654371f, 0.02527344f, -0.01698867f, -0.00320574f, -0.01403006f, -0.04496226f, -0.00372854f, 0.01907839f, 
    -0.00431059f, -0.02967449f, -0.00242570f, -0.03454806f, 0.00750883f, 0.03256796f, -0.00280502f, -0.02271740f, 
    -0.01023807f, 0.02350802f, -0.00130303f, -0.01251756f, 0.00329893f, 0.01493401f, 0.02996124f, -0.01757177f, 
    -0.00126392f, 0.01468162f, 0.02651400f, -0.02114243f, -0.02796728f, -0.03396168f, 0.00286946f, 0.02166658f, 
    -0.00838226f, 0.00599979f, -0.02274055f, 0.01873912f, 0.03787849f, -0.02862809f, -0.04146872f, -0.02499015f, 
    -0.04674213f, -0.03755236f, 0.00739220f, 0.01207031f, -0.04064713f, 0.00371978f, 0.02004618f, -0.03145582f, 
    0.00266862f, -0.01177052f, 0.01253027f, -0.02401339f, 0.01431134f, 0.01312512f, -0.00175617f, 0.00683003f, 
    -0.00487093f, -0.02330298f, 0.01460960f, -0.02034703f, -0.04184923f, -0.02206301f, 0.00517638f, 0.00812758f, 
    -0.01805578f, -0.04657457f, 0.01331081f, 0.03426908f, -0.02750683f, 0.02605510f, 0.02171675f, 0.00889113f, 
    0.02676887f, 0.00297031f, 0.02380865f, 0.00183734f, -0.01074317f, 0.00920906f, 0.00806594f, -0.00998857f, 
    0.02590019f, -0.01951959f, -0.03664839f, 0.01363819f, -0.00264937f, -0.00523297f, -0.02106385f, -0.01976374f, 
    -0.01256347f, -0.00512623f, 0.02834083f, -0.01632658f, 0.04041357f, -0.01039505f, -0.01792548f, 0.00112367f, 
    -0.02361826f, 0.03108608f, 0.02206841f, 0.04009261f, -0.04101703f, -0.01703462f, 0.03447344f, -0.02242668f, 
    0.00623855f, 0.03393818f, 0.01960575f, -0.00061276f, -0.02140828f, -0.00357690f, -0.03869603f, -0.03206882f, 
    -0.04054408f, -0.01642651f, 0.03284086f, -0.00950391f, 0.03471534f, -0.01375861f, 0.00632596f, -0.03240833f, 
    -0.01539786f, -0.03010406f, -0.02020052f, -0.03585310f, -0.03110415f, -0.02956189f, -0.03513589f, 0.03896006f, 
    0.01783812f, 0.03701146f, -0.03746617f, 0.03144653f, 0.00179418f, 0.02502298f, 0.00824825f, 0.01796095f, 
    -0.03210995f, 0.03808555f, -0.02288404f, 0.02893702f, 0.02805303f, 0.00834376f, 0.03256210f, -0.01120388f, 
    -0.03612668f, 0.02860914f, -0.02664884f, 0.03516657f, -0.01543319f, 0.03073781f, -0.03994925f, 0.02476939f, 
    0.03624145f, 0.02162452f, -0.00691814f, -0.00582441f, 0.00211851f, -0.02142807f, -0.02286927f, -0.02746049f, 
    0.00728639f, -0.00142405f, -0.02022280f, 0.01886654f, -0.02495814f, 0.01795130f, 0.03031458f, 0.03133601f, 
    0.01956267f, 0.03673721f, -0.03166535f, 0.00566477f, 0.03987614f, 0.00706870f, -0.02020418f, -0.03924926f, 
    0.01302715f, -0.00440397f, -0.02762259f, -0.02830113f, -0.04807054f, -0.00635330f, 0.01200573f, -0.02972062f, 
    0.03787295f, -0.04191767f, -0.03089776f, 0.01544709f, -0.00872442f, 0.02301029f, 0.01291480f, -0.03385210f, 
    -0.03557889f, 0.02765368f, -0.02097137f, 0.02002730f, 0.01308362f, -0.00555658f, -0.00193465f, 0.00480839f, 
    0.04047157f, -0.04450241f, -0.03186906f, 0.02764620f, -0.00659263f, -0.00670495f, -0.00779193f, -0.01364609f, 
    -0.00783422f, -0.01366179f, -0.03182520f, 0.01486769f, 0.02943236f, 0.02655814f, 0.03988508f, 0.01656361f, 
    -0.03449829f, -0.03453080f, -0.03864675f, -0.02659452f, 0.00257218f, 0.01267986f, 0.02933806f, -0.02845645f, 
    -0.04567297f, -0.02828944f, -0.02220367f, -0.00035554f, 0.02230255f, 0.03278233f, 0.02107321f, -0.03664433f, 
    0.02935821f, 0.01883570f, -0.00821191f, 0.01327765f, 0.00282341f, 0.03047441f, 0.02662721f, -0.02053296f, 
    -0.01176681f, -0.03290700f, 0.00752116f, -0.02599327f, -0.01976454f, 0.01263469f, -0.04029233f, -0.02530107f, 
    -0.00948457f, -0.02886100f, 0.02428766f, -0.04088097f, -0.01368991f, -0.02461071f, -0.01641474f, 0.01794966f, 
    -0.01012505f, 0.03654686f, -0.00003678f, -0.04504132f, 0.02093281f, 0.02409292f, -0.03141854f, -0.03037758f, 
    -0.02094579f, 0.02346234f, 0.02276259f, 0.01206878f, 0.00732871f, -0.03673551f, 0.01670190f, 0.00658748f, 
    0.04193937f, 0.01320216f, 0.01850806f, -0.02322510f, -0.03716720f, -0.01933664f, -0.01723742f, -0.01578393f, 
    0.03265519f, 0.00267468f, -0.01098938f, 0.00023318f, -0.01023174f, -0.00177729f, -0.04199053f, 0.02318399f, 
    -0.02492915f, -0.03543864f, -0.02122514f, 0.02672804f, 0.02721544f, 0.01232544f, -0.02593390f, 0.01555635f, 
    -0.03972915f, 0.02526644f, -0.03247702f, -0.00252179f, -0.01920085f, 0.03293831f, -0.03118010f, -0.02123780f, 
    -0.02226418f, 0.00214821f, 0.03798511f, 0.00715910f, 0.02046862f, 0.03021488f, -0.02825477f, -0.02277607f, 
    -0.00925736f, 0.01247176f, 0.03057534f, -0.01923613f, 0.00571005f, 0.00357753f, -0.00019144f, 0.00325670f, 
    0.02203307f, 0.01896752f, -0.02912266f, 0.01889553f, -0.00262074f, -0.02091663f, -0.03950165f, 0.01541117f, 
    -0.03357378f, -0.00709741f, 0.04603342f, -0.01109450f, -0.01757685f, 0.04431988f, -0.02320387f, -0.00753974f, 
    0.00167698f, 0.01449524f, 0.00528828f, 0.01823207f, -0.01908912f, 0.00628716f, 0.01546812f, 0.01276486f, 
    -0.03023616f, 0.03380791f, -0.03227892f, -0.02701880f, 0.01272864f, 0.01926831f, 0.02801635f, -0.03549796f, 
    -0.01522453f, -0.00215260f, -0.01036705f, -0.04144799f, -0.00642427f, 0.00605316f, -0.01992662f, 0.00813104f, 
    -0.03554222f, -0.02146387f, -0.03824150f, 0.01564999f, -0.00182081f, 0.00263937f, 0.03688629f, 0.03077033f, 
    0.02228652f, 0.00096303f, 0.01750152f, 0.01077091f, -0.00279232f, 0.00593908f, -0.04826985f, -0.00815020f, 
    -0.04153547f, 0.03106998f, -0.01699110f, 0.02424351f, 0.00129806f, -0.03723796f, 0.00477952f, -0.04137094f, 
    -0.02582628f, -0.01359071f, -0.00476767f, -0.01822390f, -0.00462716f, 0.01669502f, 0.00502401f, 0.01754237f, 
    -0.03153939f, 0.01761243f, 0.00806356f, -0.00928613f, -0.02150301f, -0.01576685f, 0.01847950f, 0.01215051f, 
    -0.00755650f, 0.01154474f, -0.03957750f, 0.01568835f, -0.02160593f, 0.02369170f, -0.02092285f, 0.01210897f, 
    -0.03131070f, -0.02681442f, -0.03155775f, -0.01650543f, -0.02920819f, -0.03231371f, -0.00980019f, -0.00128502f, 
    -0.01324030f, 0.02440937f, 0.00771844f, 0.01758085f, -0.01651765f, 0.03039834f, 0.01572623f, 0.02852067f, 
    0.00675615f, 0.01203444f, -0.02871167f, -0.01842440f, -0.02662141f, -0.02094049f, -0.02322875f, -0.01155009f, 
    -0.02846010f, -0.03433880f, -0.01638389f, 0.02325967f, -0.00303287f, -0.02148745f, -0.01862958f, 0.01383855f, 
    0.01201199f, -0.03744531f, 0.00220345f, -0.01130945f, -0.01602646f, -0.01573715f, -0.00156790f, 0.02536529f, 
    0.01899895f, 0.01457475f, 0.03783600f, -0.01018862f, -0.00828980f, 0.03925411f, -0.00956465f, 0.01062525f, 
    -0.02895648f, -0.00579276f, 0.03106515f, -0.02665579f, 0.03303286f, 0.01121089f, -0.02371340f, 0.01506107f, 
    0.00398580f, 0.02120920f, -0.00093691f, 0.02733745f, -0.00486099f, 0.00571619f, 0.00427192f, -0.01140609f, 
    0.01376448f, -0.00759219f, -0.02391359f, 0.02487059f, 0.01386666f, -0.02259805f, 0.04286431f, -0.03781049f, 
    -0.03359181f, -0.01785662f, -0.02984810f, -0.01686663f, 0.00896554f, 0.00190149f, -0.03305400f, -0.00879882f, 
    0.01788807f, -0.01904538f, -0.01798146f, 0.00590558f, 0.01159130f, 0.02827676f, 0.03056176f, 0.04232465f, 
    -0.00216210f, -0.00324289f, 0.01598764f, -0.02025504f, -0.03211965f, -0.03325113f, 0.00229382f, 0.02362242f, 
    0.03102607f, -0.01284002f, 0.01065062f, 0.01360010f, -0.00326777f, -0.01187938f, -0.02176126f, 0.02649769f, 
    -0.04043203f, -0.03292059f, 0.02714120f, 0.02224134f, 0.00948348f, 0.01991132f, -0.02186757f, -0.00244970f, 
    -0.01944317f, 0.03241340f, 0.01313819f, -0.02600843f, 0.00977913f, -0.00262824f, -0.01707900f, -0.03748083f, 
    -0.02816686f, 0.00373619f, -0.03513458f, -0.00187994f, -0.00510639f, 0.00383644f, 0.01818157f, 0.00454833f, 
    0.03093361f, 0.03949873f, 0.04353227f, -0.03195245f, -0.03378185f, -0.02667844f, -0.03886422f, 0.01390332f, 
    0.01526356f, -0.01934427f, -0.00291138f, 0.01448295f, -0.00291587f, -0.00550760f, -0.01929568f, 0.00615347f, 
    0.00163317f, -0.03953465f, 0.01022297f, -0.00126223f, -0.03341968f, 0.03117560f, -0.03005435f, -0.02114309f, 
    -0.02903124f, 0.00583074f, 0.03330188f, -0.04707935f, -0.01123084f, -0.00346330f, 0.01506833f, 0.00615929f, 
    0.00550185f, 0.02427005f, 0.02755894f, -0.00273125f, 0.00745224f, 0.00301866f, 0.03110333f, -0.00687256f, 
    -0.02429136f, -0.00305267f, 0.00884046f, 0.00141298f, -0.03714526f, 0.02427891f, -0.03419105f, -0.03043988f, 
    0.01884528f, 0.03213087f, -0.03694681f, -0.02705844f, 0.01920635f, 0.03063766f, -0.03767356f, -0.02583866f, 
    -0.00575811f, -0.00732399f, -0.00370138f, -0.00844076f, 0.03220663f, 0.02003616f, 0.01793606f, -0.03244621f, 
    0.02995280f, 0.03035068f, -0.00169930f, -0.01233135f, -0.04099289f, 0.00024080f, 0.02787250f, 0.01682525f, 
    0.01249528f, 0.01248847f, -0.03111321f, -0.04050451f, -0.02385178f, 0.03314276f, -0.02733020f, 0.03722116f, 
    -0.03640855f, -0.00992571f, 0.01715139f, -0.01194377f, 0.04267511f, -0.00580928f, -0.04300737f, 0.00584792f, 
    0.03159232f, 0.01561148f, 0.02187646f, 0.02462203f, 0.03960981f, -0.01545909f, -0.01334906f, 0.03060814f, 
    -0.00140407f, -0.00581129f, 0.01861061f, -0.02720693f, -0.03497978f, 0.00450556f, 0.02716926f, 0.00441830f, 
    0.01158220f, 0.00189937f, 0.01444632f, -0.01436165f, -0.02404277f, -0.02385920f, -0.03665481f, 0.02939917f, 
    -0.01953928f, -0.03769038f, -0.00513776f, -0.01174876f, -0.02691985f, -0.03770552f, 0.01880620f, -0.01344032f, 
    -0.02104468f, -0.03793624f, -0.03644989f, -0.01058091f, -0.03353175f, -0.00656360f, -0.03293902f, 0.01275781f, 
    0.02010559f, -0.00815785f, -0.04312361f, 0.01778758f, -0.00829689f, 0.00298940f, -0.03746640f, 0.02620236f, 
    -0.00255249f, -0.02669604f, -0.03357616f, 0.02168251f, 0.03487949f, 0.02967405f, -0.00198464f, -0.03537573f, 
    -0.03166366f, 0.01337735f, -0.04324829f, 0.01705729f, -0.02516451f, 0.00323650f, -0.02630897f, 0.01428336f, 
    0.00269770f, 0.03686094f, -0.00328963f, -0.02456071f, -0.00438600f, 0.02542051f, -0.03465656f, 0.02882830f, 
    -0.03310097f, -0.03056156f, 0.00543487f, -0.04457164f, -0.02383347f, -0.00807847f, -0.03940964f, 0.03317774f, 
    -0.01279802f, 0.01145935f, -0.00800140f, 0.01346887f, -0.01806360f, -0.00333478f, 0.00710046f, 0.01891267f, 
    -0.00590929f, 0.02079631f, -0.01678359f, -0.02515845f, -0.01994659f, -0.02423628f, -0.03592115f, 0.01271712f, 
    -0.04338468f, -0.03733581f, -0.00637882f, -0.02924194f, 0.01798608f, -0.05063613f, 0.01398543f, -0.03428324f, 
    0.02304222f, 0.01990438f, 0.01441374f, 0.01104581f, -0.02180337f, -0.00069850f, 0.01816437f, -0.01881197f, 
    0.03354795f, 0.02033888f, -0.02338335f, 0.01424624f, 0.01569071f, 0.03151661f, -0.04543365f, -0.02710574f, 
    -0.04776533f, -0.01450913f, -0.04189207f, 0.02916086f, 0.01820432f, -0.03666524f, 0.03020160f, 0.01662601f, 
    0.03524950f, -0.01253518f, 0.02946721f, -0.00577138f, -0.00085436f, 0.02612415f, -0.02750784f, -0.02480734f, 
    0.00983564f, 0.03296625f, -0.01549635f, 0.00509095f, -0.02235935f, 0.00888792f, 0.02345382f, 0.02664324f, 
    -0.00635303f, -0.03264430f, -0.03777904f, 0.04344580f, 0.00449997f, 0.01317647f, 0.02119292f, 0.00716294f, 
    -0.00144720f, -0.02327984f, -0.01444150f, 0.00885039f, -0.00270196f, -0.00404433f, -0.02100088f, -0.00623026f, 
    0.00000416f, 0.02783070f, -0.00737760f, -0.00614471f, 0.02552785f, 0.01392628f, -0.03373073f, 0.01973275f, 
    0.02049497f, -0.01309426f, 0.00191784f, -0.01061665f, 0.00824981f, 0.00158122f, 0.02138257f, 0.02877086f, 
    -0.01541540f, 0.00153493f, 0.01595293f, -0.03734715f, -0.01886339f, -0.02285956f, -0.01763890f, -0.02133333f, 
    0.00118954f, -0.02349669f, -0.01539857f, 0.00879206f, 0.01061523f, -0.02386232f, -0.00185799f, 0.01033782f, 
    0.00385121f, 0.02774520f, -0.02672558f, -0.01903752f, 0.01363165f, -0.02973551f, -0.00562990f, -0.00159517f, 
    0.02970830f, -0.03866666f, -0.00292971f, -0.03531492f, 0.00040063f, 0.01264674f, -0.03508843f, 0.01749117f, 
    -0.03434227f, 0.02625591f, 0.00671841f, -0.00950693f, 0.00446793f, -0.04131911f, 0.03450780f, 0.02543113f, 
    -0.01939875f, -0.03702294f, 0.01453452f, -0.03509088f, -0.04596988f, -0.03003688f, 0.02604543f, -0.02588666f, 
    -0.03083078f, -0.01767131f, -0.02481458f, -0.04006328f, 0.02712904f, -0.02682355f, 0.00870244f, 0.01410803f, 
    0.04163224f, -0.02111606f, -0.01987927f, -0.01272158f, 0.02151857f, -0.00831970f, 0.01105624f, -0.02097142f, 
    -0.02099296f, -0.00728182f, -0.04157797f, 0.02821142f, 0.02859518f, 0.00782023f, 0.03034563f, 0.03224152f, 
    -0.02045264f, 0.03488840f, -0.03579592f, -0.02851937f, -0.01130657f, -0.02919233f, -0.01342071f, 0.01686430f, 
    -0.03140881f, 0.02772226f, 0.00429500f, -0.01968521f, 0.00632165f, -0.00832284f, -0.04667853f, 0.04277593f, 
    -0.03288772f, 0.00037584f, -0.03003709f, -0.03705581f, 0.01497933f, -0.00669626f, 0.01743647f, -0.02902653f, 
    0.02924624f, 0.02043468f, -0.03749208f, 0.01982646f, -0.02310126f, 0.01895315f, 0.00058097f, -0.02239730f, 
    -0.00558418f, -0.01114531f, -0.02232170f, 0.02745279f, 0.00589033f, 0.01204833f, 0.01538690f, -0.01382130f, 
    -0.01101911f, -0.01347060f, -0.03703532f, -0.00787899f, -0.00487221f, -0.03532485f, 0.00415167f, -0.03968031f, 
    -0.00318451f, -0.02496688f, -0.02818601f, -0.02390222f, -0.03999107f, 0.01188511f, 0.00233029f, -0.03573982f, 
    -0.03518597f, 0.02616504f, -0.03691684f, 0.02904546f, -0.03824191f, 0.03324459f, 0.03572855f, 0.02825466f, 
    0.02414845f, -0.01338426f, 0.04081747f, 0.00889396f, 0.01432268f, 0.00647605f, -0.01241380f, 0.01507740f, 
    -0.00514648f, 0.01201501f, 0.02672955f, -0.04736630f, 0.03248817f, -0.03489174f, -0.00280509f, -0.00760715f, 
    -0.01564126f, 0.01958684f, 0.01474281f, 0.00156309f, 0.02958422f, -0.02997575f, -0.02479845f, -0.03809157f, 
    -0.00686783f, 0.03577600f, -0.03485546f, 0.01778237f, 0.02622890f, 0.00110579f, 0.01529048f, -0.00157893f, 
    -0.02685697f, 0.02930664f, -0.03433771f, -0.01117633f, 0.01548237f, 0.02738459f, -0.03283777f, 0.03158441f, 
    0.01986355f, -0.02636332f, 0.00609828f, 0.04283250f, 0.00992783f, -0.02371608f, -0.02135552f, 0.04468862f, 
    -0.03577150f, -0.00419054f, -0.00383438f, 0.02611145f, -0.03699205f, 0.01400833f, 0.01824053f, 0.02151640f, 
    0.01901204f, -0.01941660f, 0.00863337f, -0.02418189f, -0.01339806f, 0.00716914f, 0.03537804f, -0.02097007f, 
    -0.04254546f, -0.01375556f, -0.03177740f, -0.02649414f, 0.02353133f, 0.04347891f, -0.03266406f, 0.03910401f, 
    -0.00242765f, -0.03224963f, 0.03155340f, 0.00930826f, -0.01111796f, 0.01071385f, 0.02092458f, -0.05289638f, 
    -0.03564865f, -0.02980934f, -0.02798345f, 0.03448050f, -0.00393503f, 0.02687621f, 0.03560199f, 0.02011500f, 
    -0.01078557f, -0.00550348f, 0.00766435f, -0.03314506f, 0.01349832f, -0.01512348f, -0.04908122f, 0.00278651f, 
    0.01282172f, 0.03971161f, 0.00533105f, 0.00183014f, -0.01185016f, 0.01589062f, -0.03088485f, 0.01690399f, 
    -0.01461101f, 0.00988835f, 0.03234648f, 0.00559245f, -0.01417185f, 0.03233974f, -0.02996441f, -0.02567950f, 
    -0.01808590f, -0.02774057f, -0.02295072f, -0.00238003f, -0.00033149f, -0.00682193f, 0.00440570f, 0.00232419f, 
    0.00574718f, 0.01584292f, 0.03947732f, 0.01387740f, 0.01370595f, 0.03929010f, 0.03771601f, 0.02200273f, 
    -0.04474521f, -0.00962458f, -0.01095675f, -0.00921318f, -0.04178474f, -0.02162725f, -0.00218310f, -0.03813247f, 
    0.01210448f, 0.03126780f, -0.01876698f, 0.01439479f, -0.01147328f, 0.02889087f, -0.03260565f, -0.02611168f, 
    -0.03835401f, 0.00840539f, 0.00429652f, -0.02237789f, -0.04241150f, 0.01028012f, -0.01363167f, -0.03491489f, 
    0.00478805f, 0.00755083f, -0.02528812f, 0.04290436f, 0.03051703f, 0.02477562f, -0.04389179f, -0.00685014f, 
    0.01423899f, -0.02033252f, -0.00960345f, 0.00712355f, 0.01629772f, -0.03522583f, 0.02794645f, 0.00283278f, 
    -0.01046794f, -0.00908547f, -0.00788070f, -0.00649536f, 0.00297726f, 0.02191583f, -0.03057537f, -0.02345301f, 
    -0.03286928f, 0.02283791f, -0.02498074f, 0.02903265f, -0.03251426f, -0.01871533f, -0.03002553f, -0.03955248f, 
    0.01704496f, -0.02442711f, -0.02726670f, -0.00516737f, -0.01418137f, 0.00679294f, -0.03569884f, -0.01871998f, 
    -0.04375769f, -0.01268861f, 0.02019817f, -0.02170247f, -0.03963815f, 0.00842279f, -0.03849939f, -0.00311019f, 
    0.00998592f, 0.02868146f, -0.03116830f, -0.02513135f, -0.03476150f, 0.00053080f, -0.03631438f, -0.00879049f, 
    0.02394855f, 0.00124529f, 0.02329852f, 0.00928017f, -0.03533664f, -0.01930973f, 0.01822542f, -0.00367271f, 
    0.03079605f, 0.03359288f, -0.00250802f, 0.02700704f, -0.00056678f, -0.03078037f, -0.02568703f, 0.01601967f, 
    0.00233772f, 0.02233364f, -0.04404745f, -0.02939890f, -0.00890933f, 0.02166469f, -0.01948230f, -0.01643967f, 
    -0.03723264f, -0.03069940f, 0.02094024f, 0.01045756f, 0.03210495f, -0.03250039f, -0.00891572f, -0.03189869f, 
    -0.00450072f, -0.00695998f, 0.01917596f, 0.00294772f, -0.02401738f, -0.01107647f, -0.02930131f, 0.00802712f, 
    -0.04105741f, -0.03687100f, -0.02260117f, -0.04441258f, -0.03371128f, 0.00656168f, -0.02148888f, -0.04656387f, 
    -0.02769981f, 0.00965956f, 0.00403141f, -0.01616548f, 0.03210087f, -0.01969880f, -0.04261445f, -0.00496983f, 
    -0.02376013f, 0.00104586f, -0.01117134f, 0.01653925f, -0.00239704f, 0.00321217f, -0.02374268f, -0.02745191f, 
    0.01194235f, -0.02629019f, 0.02056563f, -0.02994200f, -0.02112544f, -0.00907166f, -0.00661000f, -0.03282877f, 
    -0.02539938f, -0.04275303f, -0.04102338f, -0.04708220f, 0.00241094f, 0.00740388f, 0.02208284f, 0.00826025f, 
    0.01261148f, -0.01142493f, -0.03459230f, -0.00648042f, -0.01616509f, 0.02184425f, -0.00935799f, -0.01429643f, 
    -0.02113722f, -0.00036564f, -0.00061919f, 0.01442515f, -0.01457445f, -0.03183675f, -0.01544096f, 0.01819323f, 
    -0.00190697f, 0.02300643f, 0.03159162f, -0.00505888f, -0.01660086f, 0.02604705f, 0.01690252f, 0.01132054f, 
    0.00129184f, -0.00012891f, -0.04099927f, 0.02670251f, -0.02948277f, -0.00724728f, -0.01779915f, -0.02869275f, 
    0.01229701f, 0.02678549f, -0.04584000f, 0.02908055f, -0.01067437f, -0.00297110f, 0.00477995f, -0.00307073f, 
    -0.03448639f, 0.00587226f, 0.00734434f, 0.01300113f, -0.04638007f, -0.01901247f, -0.01642383f, 0.03773123f, 
    -0.01549831f, -0.03116992f, 0.02631539f, 0.03305357f, -0.00791824f, -0.02995308f, -0.01641856f, -0.04775076f, 
    0.00065356f, -0.03484184f, 0.02721300f, -0.00885432f, -0.04159255f, -0.03248883f, -0.01980946f, 0.00439607f, 
    0.02978243f, 0.02648722f, 0.02010887f, 0.00009672f, -0.03476204f, -0.02824292f, -0.01534121f, -0.04246788f, 
    0.02249410f, 0.00057081f, -0.00335090f, 0.00816223f, -0.00805447f, -0.01633156f, -0.00163519f, 0.02383224f, 
    -0.02821084f, -0.00291785f, 0.00687722f, -0.01535911f, -0.01637869f, 0.01163988f, -0.00223791f, 0.01738876f, 
    0.03041723f, -0.01569007f, -0.04513966f, 0.01539074f, -0.00637087f, -0.00849910f, 0.02102556f, -0.01910135f, 
    -0.02274426f, 0.01025735f, -0.01603014f, 0.01029527f, 0.03109140f, -0.02619760f, -0.03394470f, -0.02792009f, 
    -0.01671091f, -0.01710884f, -0.02178376f, 0.01968228f, -0.04229577f, 0.02689603f, -0.03814695f, -0.02882872f, 
    -0.03628529f, 0.02610961f, -0.00735130f, 0.01074560f, 0.03353576f, -0.01126479f, -0.03117118f, -0.00833189f, 
    0.02049976f, -0.01906567f, 0.00067856f, -0.02653511f, 0.02536817f, 0.00647199f, -0.02935297f, 0.03040005f, 
    0.00700692f, 0.02538767f, -0.00775378f, -0.00158128f, -0.01497525f, -0.04505178f, -0.00500615f, 0.03380511f, 
    0.01780928f, 0.01859484f, -0.03344007f, -0.03489050f, 0.03042472f, 0.00317433f, -0.01248925f, 0.01551855f, 
    0.02462815f, 0.02322814f, 0.00599634f, 0.01717604f, 0.01646250f, -0.04693089f, -0.00889445f, -0.00803191f, 
    0.01326249f, -0.04234903f, -0.03651209f, 0.00515775f, -0.02443970f, 0.01262505f, 0.02427634f, -0.04158277f, 
    0.01838228f, -0.00609157f, 0.02368120f, 0.02167769f, -0.01206244f, 0.01280208f, 0.02735962f, 0.00933949f, 
    0.03138153f, 0.02275950f, 0.00646447f, 0.02679441f, -0.00962664f, 0.00973398f, -0.00728534f, 0.02847143f, 
    0.02019772f, -0.04096369f, -0.01055448f, 0.02324426f, -0.02257117f, -0.03259181f, -0.04468333f, -0.01181217f, 
    0.02686059f, 0.03030610f, 0.00369241f, -0.03645778f, 0.00827124f, 0.02049376f, -0.04574195f, 0.01584231f, 
    -0.00580499f, -0.03909036f, -0.01126874f, 0.01231905f, -0.04032877f, 0.00032268f, 0.03109679f, 0.01050830f, 
    -0.03257754f, 0.01920528f, 0.04229350f, -0.01046940f, -0.04559690f, 0.02924182f, 0.00437657f, -0.03683705f, 
    -0.04284720f, 0.04391295f, -0.01354464f, -0.01774553f, 0.00188490f, 0.02536612f, 0.01629560f, 0.03177498f, 
    -0.01512812f, 0.01116774f, 0.02611167f, -0.04384420f, -0.03799729f, 0.04333921f, -0.04007306f, -0.02710575f, 
    -0.01989745f, -0.01819978f, -0.03401147f, 0.01038735f, -0.01981925f, 0.02167615f, 0.01540830f, 0.01367409f, 
    -0.00807620f, 0.02307190f, 0.00523076f, -0.02179438f, 0.01756442f, 0.00687297f, 0.01564287f, -0.00194861f, 
    0.01523262f, 0.03493872f, -0.03367694f, -0.00671925f, 0.01825329f, 0.00079537f, -0.01019582f, 0.00725535f, 
    -0.02838271f, -0.00065197f, 0.01592544f, 0.02583520f, -0.04373543f, 0.02736626f, 0.01290244f, -0.04009991f, 
    -0.02922473f, -0.03983041f, -0.04566023f, 0.00738127f, -0.04181173f, 0.02611456f, -0.02421667f, 0.02725561f, 
    -0.02021204f, -0.00131910f, 0.01596036f, -0.01204418f, 0.02189148f, 0.03763698f, -0.00974540f, -0.04528765f, 
    -0.00920444f, -0.03902802f, 0.01168321f, 0.01855687f, 0.02327769f, -0.01864726f, -0.00566183f, -0.01527181f, 
    -0.01377114f, 0.00626334f, -0.02075083f, 0.02437578f, 0.02230835f, 0.00831118f, -0.04519179f, -0.02344065f, 
    -0.01758027f, -0.03430698f, -0.01212606f, 0.02519342f, -0.03097657f, -0.01648393f, -0.00712905f, -0.01894869f, 
    -0.03046695f, 0.02905756f, -0.00107522f, -0.03012420f, 0.00645032f, -0.01461692f, -0.00192680f, 0.03098058f, 
    -0.00505749f, -0.03009086f, -0.02223848f, 0.00718385f, -0.01228536f, -0.04691564f, -0.03315829f, -0.02022923f, 
    0.02293349f, 0.02741340f, 0.00062866f, -0.03640743f, -0.00443063f, -0.00030738f, -0.03230926f, 0.00794066f, 
    0.01687790f, -0.03503807f, 0.02676829f, 0.01834526f, 0.00058919f, -0.00010236f, -0.02221782f, -0.02176292f, 
    -0.00997859f, 0.03095693f, 0.00454935f, -0.02214203f, -0.02686065f, -0.04311759f, 0.02505199f, 0.02661787f, 
    0.00886296f, -0.02785882f, -0.03888562f, 0.00954915f, -0.03114486f, -0.00745031f, 0.01375825f, 0.00252319f, 
    -0.02046459f, 0.02868094f, -0.03524053f, 0.02100083f, -0.01205490f, 0.00101730f, -0.02818002f, 0.02838227f, 
    -0.03834703f, 0.00480576f, 0.00238049f, -0.03527499f, -0.02607348f, -0.04202337f, 0.03035820f, -0.00441639f, 
    -0.01262684f, 0.02704675f, -0.03038780f, -0.01006037f, -0.00192990f, 0.03180280f, -0.00111089f, 0.02737167f, 
    -0.03863629f, 0.02485679f, -0.00390391f, -0.00101690f, -0.00229573f, -0.01968288f, -0.01280963f, 0.01693748f, 
    -0.00566428f, 0.02037929f, -0.02613956f, -0.03526987f, 0.00125012f, 0.02863294f, 0.03241323f, -0.02724464f, 
    -0.02002984f, -0.00339241f, 0.02343674f, -0.00899553f, 0.00546340f, -0.01133224f, -0.00796394f, -0.02173769f, 
    -0.01980911f, 0.00000446f, -0.03361491f, 0.00048500f, 0.00583516f, -0.02081153f, 0.00500390f, -0.01471883f, 
    -0.00703614f, -0.03300342f, 0.03273536f, -0.00542132f, 0.02777436f, -0.01447312f, -0.01857556f, 0.02485253f, 
    -0.03961179f, -0.03414897f, -0.03396671f, -0.02353797f, 0.00678710f, 0.02599062f, -0.02985688f, -0.02225861f, 
    -0.03078414f, -0.01143080f, 0.02310411f, -0.02120031f, 0.00017666f, 0.03761769f, -0.00176990f, -0.01783092f, 
    -0.03537264f, -0.03271425f, 0.01296883f, 0.02087061f, 0.01278655f, -0.02446266f, 0.02395444f, -0.00488398f, 
    -0.02750020f, -0.02894531f, -0.02737339f, -0.04422854f, -0.02768204f, 0.03024413f, 0.02129463f, 0.02497699f, 
    0.00606707f, -0.02442642f, -0.01464467f, -0.04182400f, -0.04684478f, -0.00204552f, -0.04429803f, 0.00806442f, 
    0.02098033f, -0.04035848f, 0.02988353f, -0.00903258f, 0.02270749f, 0.01542470f, -0.03508388f, 0.00061662f, 
    0.01327055f, 0.01306080f, -0.02840796f, 0.02627111f, -0.01607768f, 0.02509747f, -0.00561412f, -0.03080648f, 
    0.01401437f, -0.01075670f, -0.01321891f, -0.02538452f, 0.02053501f, 0.02055233f, -0.00251310f, 0.02990018f, 
    0.02664023f, 0.00941266f, -0.00901872f, 0.01504847f, -0.03842253f, 0.02747262f, -0.03565267f, -0.03401710f, 
    0.00751381f, -0.01318601f, -0.02958499f, -0.03687053f, 0.02107496f, 0.01784377f, 0.00450006f, -0.02179564f, 
    -0.00134657f, -0.02563278f, 0.01664192f, -0.01741252f, 0.01691964f, 0.00808172f, -0.02535171f, 0.02046853f, 
    0.01443575f, -0.00783961f, -0.04448892f, -0.04103437f, 0.02260021f, 0.02186024f, -0.02915255f, -0.01640207f, 
    0.01635322f, 0.01728953f, -0.00293783f, -0.02926708f, -0.02591753f, -0.02957573f, -0.01842320f, -0.00920503f, 
    0.01055883f, -0.02343660f, 0.00102593f, -0.02343571f, -0.00553362f, 0.00799311f, -0.03339973f, -0.04512813f, 
    -0.04104277f, 0.00627469f, -0.04231981f, -0.02682699f, 0.01708867f, -0.04347514f, 0.02759934f, 0.02722758f, 
    0.02235897f, -0.00256237f, -0.01849532f, -0.02596769f, -0.03632748f, 0.00877781f, -0.03102244f, -0.01782820f, 
    0.02634848f, 0.02709405f, -0.03869526f, -0.03702263f, 0.00894745f, -0.02903822f, 0.00032436f, -0.01360583f, 
    -0.03410238f, -0.03302322f, 0.01580424f, -0.00183152f, 0.02613687f, 0.02973381f, -0.00914688f, 0.03033395f, 
    0.01085273f, -0.03097057f, 0.01440310f, -0.00696771f, -0.04376753f, -0.02822493f, -0.02256691f, -0.03289416f, 
    -0.01781510f, -0.04146907f, -0.04507199f, -0.04573017f, 0.02652871f, 0.01234507f, -0.02224770f, 0.02029948f, 
    0.02094783f, -0.02914455f, -0.00160939f, 0.00914370f, -0.01488222f, -0.04599426f, -0.00293513f, 0.01633275f, 
    0.02361304f, -0.03105381f, -0.02618639f, -0.00977346f, 0.01165653f, 0.02973194f, 0.00014789f, -0.01102937f, 
    0.00670866f, 0.02934166f, -0.00700110f, -0.00680376f, 0.00044253f, -0.04504057f, -0.01430708f, 0.00960062f, 
    -0.01387691f, -0.04149124f, 0.02001261f, -0.04020514f, 0.02829253f, -0.00190691f, 0.01682323f, -0.00840987f, 
    -0.03702847f, -0.03426015f, 0.03015616f, -0.02906257f, -0.02349492f, -0.03074484f, 0.01722803f, 0.00042691f, 
    -0.02858686f, 0.01618329f, 0.00916241f, -0.00213716f, 0.01253638f, -0.03022883f, 0.01645247f, -0.03578226f, 
    0.01005232f, 0.00513874f, 0.01518572f, 0.01852544f, 0.00264761f, -0.04546787f, -0.00109648f, 0.01423076f, 
    -0.00383794f, 0.03161927f, -0.02620979f, 0.01687733f, -0.02067854f, -0.00288582f, 0.00341515f, 0.00929135f, 
    0.01019904f, 0.02466173f, -0.01350653f, 0.02711447f, 0.02560819f, -0.03970113f, -0.00567094f, -0.02647601f, 
    0.01141572f, 0.00257957f, -0.01958822f, -0.01523723f, 0.00326638f, -0.02320886f, 0.00013855f, -0.03802517f, 
    -0.01993451f, -0.01464864f, 0.02673729f, -0.04254093f, -0.00791659f, -0.04064877f, -0.02965401f, -0.03439178f, 
    0.01896973f, 0.02153767f, -0.01483063f, -0.02165346f, 0.00006691f, 0.00932762f, -0.04367158f, 0.00508290f, 
    0.01090674f, 0.02657256f, -0.03773911f, 0.00544809f, -0.03987000f, -0.01337328f, -0.01590631f, -0.01280194f, 
    -0.01417204f, -0.00218497f, -0.03728513f, -0.01873507f, -0.02387470f, -0.00495038f, 0.03097240f, -0.01092749f, 
    0.02566118f, -0.02655440f, -0.02363434f, 0.01741944f, 0.01800797f, -0.01357102f, -0.03227576f, -0.02648067f, 
    -0.04703349f, 0.00279130f, -0.01866993f, -0.01674365f, 0.00951119f, -0.00353295f, 0.01545205f, -0.01582360f, 
    0.00249794f, -0.02514111f, 0.01794820f, 0.01005719f, 0.02981194f, -0.04405363f, -0.01221196f, 0.01504785f, 
    0.02184318f, -0.02873588f, -0.02398173f, -0.01759519f, 0.01487640f, -0.04150979f, 0.01727648f, -0.00145880f, 
    -0.02397346f, -0.02346501f, 0.01420098f, -0.00083905f, -0.01913691f, -0.02452786f, 0.01462838f, 0.02061206f, 
    -0.04057942f, 0.00053811f, -0.01244318f, -0.02157403f, 0.01406010f, 0.00474910f, -0.03283901f, -0.02353162f, 
    0.01857346f, -0.01552290f, 0.02062968f, -0.03893518f, 0.01411235f, -0.03680923f, 0.02965655f, -0.04611374f, 
    -0.00832429f, 0.01380882f, 0.00330436f, 0.02088288f, -0.00051996f, -0.00530410f, -0.04302548f, 0.02672509f, 
    -0.03983184f, -0.04733687f, -0.00122305f, -0.01583269f, -0.00750138f, 0.00229931f, 0.01867278f, 0.02219086f, 
    0.00445255f, 0.02693000f, 0.01503448f, 0.01043141f, 0.02811401f, -0.04355178f, 0.00363631f, 0.00580362f, 
    0.01570402f, -0.03432347f, 0.02992247f, -0.02845137f, 0.01429768f, -0.04255548f, 0.00386420f, -0.02770760f, 
    -0.04275819f, 0.02947680f, -0.00272120f, 0.00121758f, -0.04069430f, 0.03035145f, 0.01440816f, 0.01054215f, 
    -0.00540623f, -0.00523808f, 0.02319615f, -0.04481011f, 0.01799242f, -0.03123591f, -0.04235890f, -0.01571831f, 
    0.00379834f, 0.01313503f, 0.01329800f, 0.00272841f, 0.01597078f, 0.02208408f, -0.00891841f, 0.00765578f, 
    0.00396624f, -0.03237660f, 0.01789027f, 0.01485058f, -0.04594017f, -0.00932071f, -0.04626333f, 0.01481591f, 
    0.01762939f, -0.03407763f, -0.04333382f, -0.01054825f, -0.00192887f, -0.00137982f, 0.00991196f, -0.04621984f, 
    0.02094942f, -0.02352160f, 0.01976552f, 0.00542998f, -0.00410892f, 0.01361464f, -0.00364129f, -0.00294075f, 
    -0.00937915f, -0.00490596f, -0.02283093f, -0.00520401f, 0.02727684f, -0.00096275f, -0.02477217f, -0.04125929f, 
    -0.00136465f, -0.03210016f, -0.02030856f, -0.00686707f, -0.03815029f, -0.01719150f, 0.00850264f, -0.02503990f, 
    0.02610399f, 0.03195559f, -0.04294302f, 0.01908952f, -0.01295076f, 0.00800662f, 0.01556173f, 0.01935414f, 
    -0.02139137f, -0.03894952f, 0.02691757f, 0.02826987f, 0.00352445f, -0.01846807f, 0.00757726f, -0.02509006f, 
    -0.02893182f, 0.00358711f, -0.04115251f, -0.01789581f, -0.01125686f, -0.03002464f, -0.01464822f, -0.00773855f, 
    -0.02462261f, -0.03116575f, 0.02249354f, -0.03234231f, -0.00526780f, 0.00270232f, -0.03467041f, -0.03936476f, 
    -0.01032933f, 0.01719239f, -0.01885484f, -0.03795995f, 0.01610175f, -0.04472086f, -0.00075789f, 0.00322183f, 
    0.00693712f, -0.00169416f, 0.00608701f, 0.02970619f, -0.00747880f, -0.04319210f, 0.00728098f, -0.04743658f, 
    0.02584649f, -0.01900665f, 0.00116362f, 0.01763351f, 0.01414075f, -0.01731271f, -0.00571584f, -0.02611666f, 
    0.01213484f, 0.01168234f, 0.02281401f, 0.00378931f, -0.04331479f, -0.04453755f, -0.02480650f, 0.02622838f, 
    0.02836448f, 0.01340155f, 0.00577376f, -0.00965622f, -0.00104997f, -0.03223737f, -0.00149611f, 0.03008795f, 
    -0.04298296f, -0.03319500f, 0.00636517f, -0.01365930f, 0.01570163f, 0.02819810f, 0.01469020f, -0.02555049f, 
    0.00677956f, -0.00312707f, -0.01060010f, -0.00324955f, 0.01678200f, 0.00303733f, -0.03563724f, -0.04238341f, 
    0.02007402f, -0.03792215f, -0.01338464f, 0.00757104f, 0.00774216f, 0.00539101f, -0.00816575f, -0.03287258f, 
    0.02192112f, -0.01973078f, 0.00035434f, -0.02220612f, 0.02865238f, -0.03438168f, -0.00814057f, -0.02727435f, 
    -0.03611463f, 0.02364872f, 0.02272308f, 0.01852343f, -0.01973483f, 0.02117915f, 0.00278854f, -0.01387003f, 
    0.01119523f, 0.02167492f, -0.01913086f, -0.01877206f, 0.00904081f, -0.01710606f, 0.02966606f, 0.00850682f, 
    -0.01668060f, -0.01794146f, -0.01700952f, -0.00386676f, -0.03574412f, -0.00134989f, -0.00280467f, 0.03071547f, 
    -0.04443609f, -0.02058904f, 0.02271945f, -0.00043252f, -0.04318000f, -0.02331382f, 0.02865648f, -0.04367358f, 
    0.01463353f, -0.04275280f, 0.01439943f, 0.00367871f, 0.01138971f, 0.00432588f, -0.04367842f, 0.02942107f, 
    -0.02259678f, 0.00024612f, 0.00626413f, -0.02153813f, 0.02611353f, 0.02054002f, 0.01224093f, -0.01702141f, 
    0.00586974f, -0.03964380f, 0.01312639f, -0.03800364f, 0.01322852f, -0.04130508f, 0.01798188f, 0.00921804f, 
    -0.02179165f, 0.02056044f, -0.01611701f, -0.04366512f, 0.02419752f, -0.01753374f, 0.03075152f, 0.02620932f, 
    0.02041109f, 0.00818033f, -0.02653374f, -0.02548829f, -0.03621486f, 0.02654846f, -0.02706234f, -0.00987548f, 
    -0.02850930f, -0.04473296f, -0.00960475f, -0.02549830f, 0.02389570f, 0.01921837f, -0.04372232f, -0.01529676f, 
    0.01714498f, 0.02247290f, -0.01448984f, 0.00432541f, 0.01035919f, -0.04367745f, -0.04622278f, 0.00158884f, 
    -0.03689721f, 0.00131549f, -0.02933883f, -0.03994967f, 0.01442464f, 0.02045754f, -0.03803807f, -0.00728524f, 
    -0.02211725f, 0.01999411f, 0.00218832f, -0.03000775f, 0.00707989f, -0.04255950f, -0.02539538f, -0.02004457f, 
    -0.04744835f, 0.02646544f, -0.03066332f, -0.03992258f, -0.03198485f, -0.04526838f, 0.01855890f, -0.03736905f, 
    -0.01380036f, -0.02031182f, -0.03075814f, -0.04619494f, -0.04109151f, -0.02800543f, -0.00585043f, -0.04151165f, 
    0.02112854f, -0.03425766f, -0.02241752f, 0.00819673f, 0.00285240f, -0.00193267f, -0.04644597f, -0.00031324f, 
    -0.00146583f, -0.02563518f, 0.02638338f, -0.00587196f, 0.03013930f, 0.01972529f, -0.00943955f, -0.03366164f, 
    -0.01912612f, 0.01045998f, -0.00290554f, -0.01753294f, -0.03690746f, -0.01775585f, -0.04330160f, -0.04500506f, 
    0.02376799f, -0.01500663f, 0.02702919f, -0.02141252f, 0.02691533f, -0.00120435f, -0.04737978f, -0.01514790f, 
    0.01086790f, -0.03984427f, -0.02988559f, -0.00142231f, -0.03706526f, 0.00613239f, -0.00393819f, -0.00498905f, 
    0.00601952f, 0.01832097f, -0.01774593f, -0.03726935f, 0.02535201f, -0.01800563f, 0.01857404f, -0.02140558f, 
    -0.02542874f, -0.01952883f, -0.00412350f, -0.02746998f, -0.03654560f, -0.01577984f, -0.04735705f, 0.01546755f, 
    0.02570928f, -0.02317942f, -0.00991605f, 0.01575580f, 0.01283940f, -0.01488431f, 0.01219929f, -0.00608959f, 
    -0.27683237f, 0.11217730f, 0.00349383f, 0.01511937f, -0.32774028f, 0.17119366f, 0.06925103f, 0.10046541f, 
    0.00783494f, -0.02584141f, 0.07661940f, 0.01676383f, 0.03470516f, -0.05077248f, 0.03773608f, 0.03786344f, 
    -0.00892519f, -0.09876763f, -0.00079452f, 0.00643263f, -0.23422533f, -0.30635172f, 0.17336524f, -0.03274202f, 
    -0.13949075f, 0.03064032f, -0.00497682f, 0.03298651f, -0.03209456f, 0.05430764f, 0.05733467f, 0.11092298f, 
    -0.03323418f, -0.14444833f, 0.02810180f, -0.11437432f, 0.07232621f, 0.07205528f, -0.11742090f, 0.03284259f, 
    -0.21770526f, -0.17315704f, -0.02128153f, -0.08706396f, -0.17825803f, 0.05137540f, 0.12650053f, -0.04052918f, 
    0.02224208f, -0.04058423f, 0.02749163f, 0.08574522f, -0.08811948f, 0.05225212f, -0.15387510f, 0.04937465f, 
    -0.00705422f, -0.02010212f, -0.00633016f, 0.03011356f, -0.29337439f, -0.12266641f, 0.03351061f, 0.36863232f, 
    0.14416251f, 0.07357831f, -0.10745351f, 0.09289338f, -0.03897610f, 0.23721299f, -0.06561677f, -0.09314287f, 
    0.15203954f, 0.13232641f, -0.05218166f, -0.06204708f, -0.10678478f, 0.09994884f, 0.12296353f, -0.05930582f, 
    -0.02722381f, 0.25010228f, 0.06800649f, 0.38089183f, -0.17104262f, 0.03178047f, 0.00581692f, 0.05568090f, 
    -0.08143288f, -0.02298017f, -0.03836092f, -0.00360708f, 0.11414925f, 0.04152256f, 0.04648991f, -0.04745487f, 
    0.03877732f, -0.00036567f, -0.12740704f, 0.03936455f, 0.16313887f, 0.25122845f, -0.29401693f, -0.28632492f, 
    0.12297203f, 0.10368707f, 0.01238076f, -0.09631991f, 0.19820075f, 0.08892792f, 0.06205089f, -0.10796270f, 
    -0.04840072f, 0.01487275f, -0.03886108f, 0.05512165f, 0.06892899f, -0.01302678f, -0.06023159f, -0.04146747f, 
    0.27521765f, 0.10300134f, 0.02067560f, 0.03043137f, -0.12331481f, -0.08115859f, 0.19451489f, 0.10207006f, 
    0.07100329f, -0.05815653f, 0.11866365f, -0.07329657f, 0.01254426f, -0.02999355f, -0.02904094f, -0.05325639f, 
    -0.02624980f, 0.13648367f, 0.21390817f, 0.16867086f, -0.09797885f, 0.27004808f, 0.03503971f, 0.12532112f, 
    -0.25654337f, 0.00299693f, 0.05524889f, 0.05865594f, 0.07828363f, 0.09278545f, -0.08273317f, 0.01465681f, 
    0.04708621f, 0.13084753f, 0.10671550f, 0.01798672f, -0.03452109f, 0.14479931f, -0.02132114f, 0.05181694f, 
    0.35233036f, 0.03552980f, 0.07078053f, 0.22525077f, 0.27700162f, -0.05598587f, -0.14260848f, -0.14619814f, 
    0.08651312f, -0.01691729f, -0.01937800f, -0.01107218f, 0.05259934f, 0.00826096f, -0.00066079f, -0.03041526f, 
    -0.00084929f, -0.00923083f, -0.09293716f, -0.04686493f, 0.25254437f, 0.07589456f, -0.02223464f, 0.07984607f, 
    -0.04172752f, -0.03228488f, 0.18579002f, 0.02060142f, -0.00248254f, 0.01608138f, 0.06299916f, 0.04175075f, 
    0.00715827f, -0.07099268f, -0.05165764f, -0.00376602f, 0.02021190f, -0.01707952f, 0.29506522f, 0.08137392f, 
    -0.08190028f, 0.26887682f, -0.09039678f, -0.11010494f, 0.18769296f, 0.14444342f, 0.10397994f, -0.07953630f, 
    -0.17056978f, 0.17943326f, -0.00053552f, 0.05427011f, 0.05028043f, 0.06203888f, 0.03094291f, 0.04771393f, 
    -0.08439276f, -0.27575782f, 0.01599620f, 0.04802268f, -0.38151732f, 0.04315856f, -0.22101896f, -0.02546847f, 
    -0.29196960f, 0.14791910f, 0.16444148f, 0.00374189f, 0.00426528f, -0.04666557f, -0.10457212f, 0.02839579f, 
    -0.05758027f, 0.09567898f, 0.05250122f, 0.08840367f, 0.10520556f, 0.01841491f, -0.02994436f, 0.11202224f, 
    0.21913438f, -0.30323708f, 0.13306737f, 0.13546434f, 0.41721347f, -0.11731859f, 0.12038846f, 0.00491486f, 
    0.06337349f, 0.12805781f, -0.10087800f, 0.01357346f, 0.15089080f, 0.07073914f, 0.05959764f, -0.03762580f, 
    0.19710879f, 0.03225309f, 0.14766654f, 0.00153893f, -0.32151023f, -0.35768795f, 0.15011688f, -0.09823789f, 
    -0.10840269f, 0.01535695f, 0.11600520f, 0.05030164f, -0.09649322f, -0.03151769f, 0.05027830f, 0.05433724f, 
    -0.03293555f, -0.03902658f, -0.00918704f, -0.02257218f, -0.00475809f, 0.01441672f, -0.04877903f, -0.02072057f, 
    0.00632046f, -0.27551094f, 0.05605787f, -0.13272966f, -0.16203141f, 0.09841806f, 0.14564213f, 0.09162239f, 
    -0.05356072f, 0.04866640f, -0.04443499f, -0.00267099f, -0.00518394f, 0.01670610f, 0.09931935f, 0.01488826f, 
    0.06772935f, -0.03478755f, -0.04278423f, -0.00661602f, 0.25340739f, -0.09755872f, 0.01670004f, -0.10182592f, 
    0.19030030f, 0.08297018f, 0.09390868f, 0.03604694f, -0.06870946f, -0.00699715f, 0.02993587f, 0.10235128f, 
    0.00463151f, -0.01631656f, -0.12244832f, 0.12055368f, 0.12685743f, -0.05982157f, 0.02557687f, 0.08882137f, 
    -0.07580259f, 0.02208817f, -0.01525542f, -0.06088645f, 0.13734770f, -0.04387128f, -0.00334944f, 0.08795467f, 
    -0.06595807f, 0.06567255f, -0.00369426f, 0.05343835f, 0.05391470f, -0.05665929f, -0.06649043f, -0.04662367f, 
    -0.02900471f, 0.01857937f, 0.18241426f, 0.03542659f, 0.38132006f, 0.11897554f, 0.07767317f, 0.16634750f, 
    0.04267401f, -0.09313772f, -0.02433397f, -0.00330983f, 0.06549498f, -0.07847871f, 0.13494508f, 0.01509131f, 
    -0.12347975f, 0.00202469f, 0.11507176f, 0.09411273f, -0.07799216f, 0.13170448f, 0.17337890f, 0.23482832f, 
    -0.05163778f, -0.04735577f, -0.04573920f, -0.23012809f, -0.06905568f, 0.05711938f, -0.02532253f, -0.00079668f, 
    0.08565526f, 0.00748419f, -0.03308328f, 0.00759269f, 0.09884757f, 0.10257608f, -0.11301678f, -0.10371088f, 
    0.00448482f, -0.04322416f, -0.06116054f, 0.06188246f, 0.23649043f, -0.42401281f, -0.16340788f, -0.00274403f, 
    -0.13639203f, -0.05428079f, 0.10453616f, 0.07646333f, -0.06189627f, -0.03376006f, 0.06715773f, -0.01481604f, 
    0.04280944f, 0.07223060f, 0.06398312f, 0.04403286f, 0.05561282f, -0.01864982f, -0.08512699f, -0.05003897f, 
    0.03382150f, 0.07342411f, -0.07140213f, 0.32417300f, 0.02794539f, 0.02822125f, 0.07181164f, 0.02076771f, 
    0.02089853f, 0.03114717f, 0.02777054f, -0.04532027f, 0.03986165f, 0.05660028f, 0.12773530f, 0.11621608f, 
    0.07347032f, 0.05326158f, -0.01450873f, 0.11295471f, -0.13586460f, -0.20901011f, -0.16306794f, -0.08122268f, 
    -0.09571921f, 0.15318634f, 0.04120347f, -0.00600455f, 0.08563303f, -0.03534770f, -0.08649950f, 0.05992381f, 
    0.02193738f, -0.07203460f, -0.07660475f, -0.09902505f, 0.09352601f, -0.01740754f, 0.00823800f, 0.16796304f, 
    -0.30155185f, -0.12876776f, -0.22121042f, -0.15042001f, -0.14917105f, 0.12365753f, 0.16936256f, -0.07566902f, 
    0.03282333f, -0.12171759f, 0.08760888f, -0.04581758f, -0.02281066f, -0.03397852f, -0.05661384f, -0.01891184f, 
    0.06153948f, 0.04901017f, -0.02781755f, -0.00915448f, 0.15125863f, 0.23488060f, -0.17388187f, 0.18430489f, 
    -0.05719284f, 0.03763787f, 0.01712396f, 0.00327512f, -0.02401803f, 0.00649985f, -0.00445020f, 0.06768383f, 
    -0.10769067f, 0.05312820f, 0.11972614f, 0.05531333f, 0.08483714f, 0.11228843f, 0.01920271f, 0.07702607f, 
    -0.16047552f, -0.16450466f, 0.05360968f, 0.28175262f, 0.18303129f, 0.02259958f, -0.15527807f, 0.01318216f, 
    0.07881629f, 0.35519603f, -0.17432779f, -0.01273716f, 0.11807343f, 0.02373243f, 0.02891560f, -0.07586239f, 
    -0.04842229f, 0.08297085f, 0.02454989f, -0.01221478f, 0.29066637f, -0.07602782f, -0.26642519f, -0.14926662f, 
    0.06821364f, 0.04533220f, 0.02287961f, 0.00015862f, 0.08079068f, -0.02349402f, -0.05023986f, -0.05148691f, 
    0.00451528f, 0.11503302f, -0.00325345f, 0.11018773f, 0.14636296f, -0.10879523f, -0.04715302f, 0.06934223f, 
    -0.19866748f, -0.11467169f, -0.10977624f, -0.10394184f, -0.10846967f, 0.08526263f, 0.11996300f, 0.03579820f, 
    -0.07743915f, 0.00513092f, 0.02578449f, 0.18620229f, -0.08968982f, -0.08736357f, 0.03071911f, 0.01690486f, 
    -0.01084956f, -0.02400491f, 0.02347690f, 0.05927855f, 0.13794671f, 0.06242356f, 0.09441720f, -0.05891072f, 
    0.32405469f, -0.00468914f, 0.04267598f, -0.06416461f, -0.08065327f, 0.10827475f, -0.15142931f, 0.03548109f, 
    -0.09262341f, 0.03216902f, 0.00407573f, 0.01657723f, 0.07580040f, 0.05844079f, 0.16926061f, 0.01992822f, 
    -0.04880831f, -0.34968284f, -0.01670080f, -0.15630798f, -0.10965191f, 0.03466226f, 0.15645495f, -0.02698474f, 
    -0.00181540f, -0.03176209f, 0.10542051f, 0.04960377f, -0.01599481f, 0.05816830f, -0.06930152f, -0.00361025f, 
    0.00601610f, -0.01856459f, -0.01515994f, 0.07095955f, 0.16139346f, 0.05692922f, 0.00651056f, 0.18772921f, 
    0.08735374f, 0.14949486f, -0.12417770f, 0.09693445f, 0.11069328f, 0.08597078f, 0.00422454f, 0.03504810f, 
    -0.00203575f, 0.02738352f, -0.12644170f, 0.06377125f, -0.18381251f, 0.11608191f, 0.07195535f, 0.14583358f, 
    -0.03719455f, 0.05368927f, 0.09810235f, 0.17850608f, 0.24899009f, 0.02248569f, -0.07315809f, 0.00480940f, 
    -0.04766138f, 0.22355144f, -0.00398270f, 0.10639680f, 0.01893803f, -0.02542088f, 0.05136835f, -0.10794907f, 
    -0.06594837f, -0.03982238f, 0.07378434f, -0.07775128f, 0.16391034f, -0.09645582f, -0.15562536f, -0.16652709f, 
    -0.09060837f, 0.02317309f, 0.10400775f, -0.00001643f, 0.00881755f, -0.08387937f, 0.10295333f, -0.00482881f, 
    -0.04606760f, 0.02621915f, 0.08047813f, -0.00439114f, 0.01314860f, -0.14170775f, 0.01937482f, -0.00605634f, 
    -0.03004300f, -0.03346693f, -0.03755394f, -0.02245089f, 0.00785725f, -0.01546184f, -0.03967904f, 0.02257314f, 
    -0.02819323f, -0.03523346f, 0.01570383f, -0.00347473f, -0.01132816f, 0.01109089f, -0.02084811f, 0.02890496f, 
    -0.03786087f, 0.01580863f, -0.02201595f, -0.02624442f, -0.01763596f, 0.00525665f, 0.00364061f, -0.00795204f, 
    -0.00790746f, -0.02302241f, 0.03155203f, 0.01528504f, 0.02507477f, -0.03936528f, -0.00919178f, -0.03542411f, 
    -0.02185336f, 0.03200262f, -0.02987423f, 0.00287037f, 0.00066385f, 0.00832284f, -0.00933698f, 0.00108118f, 
    -0.00037557f, -0.00478734f, 0.00918556f, 0.00134758f, 0.01297180f, -0.01756446f, 0.00812777f, 0.02367829f, 
    0.02781080f, 0.00413511f, 0.00812315f, -0.01760099f, 0.01006132f, -0.03997360f, 0.02744422f, -0.02655544f, 
    -0.02631942f, -0.01211282f, 0.00266937f, -0.02599919f, 0.00049917f, 0.01919371f, -0.00963189f, -0.01634913f, 
    0.01519340f, -0.01578750f, 0.02664115f, -0.03197907f, -0.04026870f, 0.03131086f, -0.00565422f, 0.02650990f, 
    -0.02450387f, 0.00071289f, -0.00101984f, 0.01966653f, -0.03121434f, 0.03575091f, -0.02803276f, -0.03300695f, 
    -0.02839071f, 0.01316627f, -0.00512339f, 0.00301078f, -0.03867491f, 0.00250821f, 0.01893089f, -0.03838470f, 
    -0.02354646f, 0.02762351f, -0.03472835f, -0.02454041f, 0.00723721f, -0.01279675f, -0.01528432f, 0.00009751f, 
    -0.00754490f, -0.02050345f, -0.03404495f, 0.01923519f, -0.02842728f, 0.02347694f, 0.01494025f, -0.04215610f, 
    -0.01826454f, -0.04412099f, -0.04309784f, -0.00201598f, 0.02944805f, 0.02064876f, 0.01439462f, 0.00636639f, 
    -0.01250552f, 0.00883518f, 0.03283988f, -0.00269239f, -0.03459816f, -0.00798960f, -0.02876844f, -0.04297970f, 
    -0.02019257f, 0.03061012f, -0.03505798f, -0.01336105f, -0.00600933f, -0.03142443f, -0.00189703f, 0.00237690f, 
    -0.01030658f, -0.03321274f, 0.01409554f, -0.03717536f, 0.03695364f, 0.02128830f, 0.00682925f, 0.00525539f, 
    0.00152609f, -0.02552651f, -0.03466087f, -0.03047780f, -0.02059907f, 0.00700198f, -0.01490112f, -0.03890881f, 
    0.01090063f, -0.03580458f, -0.00935998f, -0.00855031f, 0.01047915f, -0.02048315f, -0.01319855f, -0.02951848f, 
    -0.00003494f, -0.03271652f, -0.00361332f, -0.03818702f, 0.02222764f, 0.02263016f, 0.02564638f, -0.02445339f, 
    -0.03789415f, -0.01070151f, -0.01781123f, -0.03778694f, 0.00723390f, 0.00656101f, -0.01785210f, 0.02772009f, 
    -0.01277264f, 0.02267385f, 0.00266006f, -0.02873157f, 0.01427082f, -0.03874959f, -0.02344112f, -0.02979575f, 
    -0.02989952f, -0.04166247f, 0.01641615f, -0.02480867f, 0.00444449f, -0.00303602f, 0.00019347f, 0.01199962f, 
    0.02090342f, -0.01138760f, -0.01482701f, 0.01698624f, 0.01437734f, -0.03647511f, -0.00782506f, -0.02504697f, 
    -0.03093271f, -0.02137210f, 0.02561689f, 0.02274566f, -0.01711144f, -0.00192505f, 0.02279222f, 0.03212138f, 
    -0.00876547f, 0.00160571f, -0.01768056f, -0.00606257f, -0.02798136f, -0.04335288f, -0.01371214f, 0.01544209f, 
    -0.03141214f, -0.02532523f, 0.00887556f, 0.01917864f, -0.01645722f, -0.00179420f, 0.02329455f, 0.00530596f, 
    -0.02801023f, 0.01991530f, -0.00409489f, 0.01416365f, -0.00799791f, -0.03972783f, 0.03349988f, 0.01538945f, 
    -0.00324321f, -0.02205321f, 0.02469648f, 0.00769835f, -0.00704333f, 0.03142424f, -0.02675756f, 0.01904350f, 
    -0.01620412f, 0.01103540f, -0.00504381f, -0.02663580f, -0.03575396f, -0.04551579f, -0.04427206f, 0.02741647f, 
    -0.02593349f, -0.02875348f, -0.01975816f, -0.02239975f, 0.02028074f, -0.04174333f, -0.04079146f, 0.00955399f, 
    -0.00186270f, -0.00918045f, -0.02204757f, 0.03037042f, -0.01354682f, -0.02605842f, -0.03309921f, 0.02677811f, 
    0.02011904f, -0.00344757f, -0.01350161f, -0.01633814f, 0.02794441f, -0.02531892f, -0.02813275f, -0.00066924f, 
    -0.01272806f, 0.00887328f, -0.00836440f, -0.04347538f, 0.02149567f, 0.02431995f, -0.04133620f, 0.00737738f, 
    0.01226997f, 0.00050128f, -0.01121668f, -0.02657278f, 0.02844980f, 0.00107256f, -0.03494092f, 0.02560413f, 
    0.02566602f, 0.00736603f, -0.00690952f, 0.01431724f, -0.00256436f, -0.04551048f, -0.03209220f, -0.02584115f, 
    -0.04525306f, -0.01936685f, -0.02897817f, -0.01984691f, -0.00823571f, 0.01511368f, -0.00520105f, 0.00602818f, 
    -0.02012652f, -0.03105067f, 0.01742173f, 0.01015981f, 0.02273724f, -0.02121638f, -0.02648723f, -0.00866934f, 
    0.03391315f, -0.01996586f, 0.01645349f, -0.02390063f, 0.00241117f, -0.00311576f, 0.00094752f, -0.01899191f, 
    0.02859786f, -0.03200077f, 0.01352214f, -0.01339091f, 0.02013432f, 0.02391028f, 0.02097655f, 0.00877392f, 
    -0.00706274f, 0.00141436f, -0.02887120f, -0.03290296f, -0.02829946f, 0.01530610f, -0.02979112f, -0.03142227f, 
    -0.02293608f, -0.00380220f, -0.00167857f, 0.01294288f, 0.02365801f, -0.02050618f, 0.01578638f, -0.04066525f, 
    0.01567561f, 0.02949183f, -0.00957146f, -0.01749111f, -0.03383351f, -0.02749755f, -0.00529585f, 0.00000746f, 
    -0.00844399f, -0.01114616f, 0.01138387f, -0.01201563f, 0.02630016f, 0.02848547f, 0.02712187f, -0.03748176f, 
    -0.01495747f, -0.01392198f, 0.00233207f, 0.01928061f, -0.03104819f, -0.03840112f, -0.00592107f, 0.01472863f, 
    -0.03563940f, 0.03198409f, -0.00618260f, 0.02174011f, 0.02957702f, 0.02757100f, -0.04389896f, -0.04301267f, 
    -0.00022449f, -0.04147989f, -0.03757165f, -0.00728645f, -0.02221697f, -0.02594177f, 0.01928385f, -0.01145827f, 
    0.00674990f, -0.04097689f, -0.00866900f, -0.03489641f, -0.01474286f, -0.02279353f, 0.01895133f, -0.01926104f, 
    -0.04201916f, -0.02204545f, 0.01404491f, 0.00874112f, -0.00078176f, 0.03088677f, -0.04251599f, -0.03782223f, 
    0.02723164f, -0.02438214f, 0.00492397f, -0.03886627f, -0.01785924f, 0.01623391f, 0.01429324f, 0.01892387f, 
    0.02029799f, -0.00210532f, -0.01822151f, 0.01908490f, 0.01461851f, 0.00839706f, 0.01396823f, 0.03001211f, 
    0.01719530f, 0.00124123f, 0.03313703f, -0.03180340f, -0.02606233f, 0.01019727f, -0.00785227f, 0.02909919f, 
    -0.00993582f, 0.00247394f, 0.01614357f, 0.00361724f, -0.00944079f, -0.03488878f, 0.00474084f, -0.01868764f, 
    -0.00470278f, -0.02473368f, -0.00654381f, 0.00952910f, -0.00603778f, 0.00522513f, -0.00285605f, -0.01165976f, 
    0.01632848f, 0.02212753f, 0.00954770f, -0.04119276f, -0.04474933f, 0.00774642f, 0.02881313f, 0.00343633f, 
    -0.02245163f, 0.02115151f, 0.03153542f, -0.03688741f, 0.03281395f, 0.01975516f, 0.02737046f, -0.03817466f, 
    -0.01452333f, 0.01811148f, -0.02043809f, 0.01691705f, 0.01479762f, -0.00590311f, -0.01064298f, 0.02192074f, 
    -0.03485062f, -0.01838399f, 0.01834008f, -0.02885099f, -0.01171844f, -0.00945830f, -0.02773428f, -0.02141294f, 
    0.01133891f, -0.00207129f, 0.02131625f, -0.01552177f, -0.02524195f, -0.04447573f, 0.00300265f, 0.01068268f, 
    -0.00618514f, -0.01686142f, 0.02484755f, 0.01416103f, -0.02420021f, 0.02799223f, -0.01560104f, 0.01330696f, 
    -0.01688652f, -0.01166067f, -0.01221310f, -0.00981026f, 0.01888477f, -0.03265644f, 0.02729560f, 0.01187667f, 
    0.01896920f, 0.00748400f, -0.03880455f, -0.00847299f, 0.01530540f, -0.01880730f, 0.02975474f, -0.00813784f, 
    -0.00763291f, 0.00346445f, 0.02798383f, -0.01234022f, 0.01572157f, -0.01223919f, -0.01480292f, -0.04162969f, 
    -0.04298020f, -0.01521250f, -0.01314435f, -0.01778415f, 0.00070481f, -0.01134896f, -0.01255671f, -0.03290349f, 
    0.02919035f, 0.00895835f, -0.01618221f, 0.01098059f, 0.00790995f, -0.03134630f, -0.01870418f, -0.02186339f, 
    -0.04099317f, -0.04094189f, -0.01199927f, -0.00533373f, -0.02294066f, 0.02297128f, -0.04248207f, 0.01996917f, 
    -0.03016289f, -0.01215896f, -0.00407231f, -0.00726812f, -0.03415181f, -0.00162480f, -0.03627763f, 0.03019536f, 
    0.02441428f, -0.03387792f, -0.04310613f, 0.00065724f, 0.01496269f, -0.02082812f, 0.01871161f, -0.00682251f, 
    -0.00205270f, -0.00478259f, 0.02533449f, 0.01484596f, -0.02172647f, -0.00278471f, 0.02692971f, -0.02112439f, 
    0.00742565f, 0.03890859f, -0.01049533f, 0.02178967f, 0.03531029f, 0.02674178f, -0.00171344f, -0.03628324f, 
    -0.01871640f, 0.02769882f, 0.01596341f, -0.04110342f, -0.00583456f, -0.04084720f, -0.02963914f, 0.01480681f, 
    -0.02657781f, -0.02026551f, -0.00157123f, -0.03374374f, -0.00298732f, -0.01399627f, -0.03051310f, 0.01642601f, 
    -0.02742014f, -0.01002133f, -0.00333984f, -0.01104046f, -0.01670775f, -0.00902078f, -0.02148747f, 0.01678306f, 
    -0.00858252f, -0.02692352f, -0.04430919f, -0.01811089f, -0.02426689f, 0.03060021f, -0.00674813f, -0.03788231f, 
    0.00082541f, -0.03059260f, 0.01000887f, -0.01764167f, -0.01342168f, -0.03697148f, 0.00346029f, -0.00776837f, 
    0.00752951f, -0.02201574f, -0.02219983f, 0.01781707f, -0.04382418f, 0.02713069f, -0.04216672f, 0.01454066f, 
    0.02044950f, -0.02369560f, 0.01587861f, 0.01920857f, -0.03558619f, 0.01905860f, -0.00861161f, 0.00322157f, 
    -0.00106613f, -0.01708185f, 0.02405837f, 0.01288786f, -0.00091283f, 0.01452064f, -0.04219937f, -0.00682722f, 
    -0.04450299f, -0.01486692f, -0.00304652f, 0.01145201f, -0.02612714f, 0.01790700f, 0.01208426f, -0.01119275f, 
    0.02967569f, -0.04012074f, -0.00359866f, 0.03620411f, -0.03874455f, 0.00185984f, 0.03147726f, -0.03976204f, 
    -0.00266539f, -0.04219615f, -0.00198843f, -0.02987402f, -0.00700268f, -0.01528015f, 0.00807574f, -0.03534250f, 
    -0.00191899f, -0.00798279f, -0.02294112f, 0.00627280f, 0.03265900f, -0.02670467f, -0.04858579f, -0.00186406f, 
    -0.04580636f, -0.00532193f, -0.03465642f, -0.01586808f, -0.02583742f, -0.00692714f, -0.02704071f, 0.01264707f, 
    -0.00963653f, 0.01590418f, 0.00698302f, -0.02645336f, -0.01114099f, -0.03189792f, -0.00085221f, -0.00820145f, 
    -0.01176487f, -0.03284746f, -0.03063631f, -0.02026318f, -0.02971044f, -0.01537491f, -0.00924528f, -0.00069318f, 
    0.01307733f, -0.00379395f, -0.00980820f, 0.01649550f, -0.05092629f, -0.03464998f, 0.00796787f, -0.03474789f, 
    -0.05408372f, -0.04035601f, -0.00437913f, -0.00236817f, 0.02960524f, -0.04615318f, -0.00640710f, -0.03274934f, 
    -0.03045191f, 0.01313718f, -0.00871655f, -0.04184698f, -0.02210951f, -0.03680842f, -0.03584428f, 0.02196359f, 
    0.01130056f, 0.00187304f, -0.00156480f, -0.01416617f, -0.00786896f, 0.01656796f, -0.02302297f, 0.01689769f, 
    0.02712359f, 0.01847648f, -0.03525292f, 0.03247609f, -0.02011689f, 0.01845091f, -0.04645791f, 0.00394102f, 
    0.02632407f, -0.02481377f, -0.03352307f, -0.00807723f, -0.04714298f, 0.01204210f, -0.03815519f, 0.01541500f, 
    -0.03836611f, -0.01278899f, -0.00819703f, 0.01241215f, -0.03037538f, -0.01595932f, -0.05086622f, -0.01987158f, 
    0.01758055f, -0.02141746f, -0.00389523f, -0.04749063f, -0.04807609f, 0.02741465f, 0.02807287f, -0.01675472f, 
    0.00071628f, -0.02501908f, -0.00541354f, 0.02099318f, -0.03303434f, -0.02029310f, -0.02622490f, -0.03521969f, 
    0.00617099f, 0.00580366f, -0.01206218f, 0.02855616f, 0.02219359f, -0.02488521f, -0.00838865f, 0.01851010f, 
    0.00872276f, 0.00962040f, -0.01667736f, -0.00679761f, -0.02865294f, -0.03049017f, 0.00817984f, 0.00925023f, 
    -0.02555908f, -0.00492462f, -0.02425672f, 0.00966808f, -0.04109916f, -0.02791013f, 0.00140167f, 0.00001713f, 
    -0.02837729f, -0.00874130f, -0.02752345f, 0.01526444f, 0.00772073f, 0.01247478f, 0.02403715f, 0.01319664f, 
    0.01511150f, -0.04971407f, -0.02406227f, -0.03162519f, -0.04606710f, -0.01474494f, 0.01611763f, -0.01626409f, 
    -0.04518306f, -0.01949593f, -0.00968846f, 0.00415006f, 0.00301501f, -0.01174381f, 0.00115083f, 0.00546092f, 
    -0.01873256f, 0.01675998f, -0.02180599f, -0.03301813f, -0.04910264f, 0.02008534f, 0.00075245f, 0.01618521f, 
    -0.00109543f, 0.00048364f, 0.02945713f, -0.03636044f, -0.01480590f, -0.00215830f, -0.04739056f, 0.03179460f, 
    0.01647578f, -0.02829444f, 0.03397106f, -0.00190473f, -0.03195436f, 0.01117401f, -0.00216396f, 0.01305323f, 
    0.01683846f, -0.03356658f, 0.00670133f, 0.02593611f, 0.01134535f, 0.04235788f, -0.02482486f, -0.02163523f, 
    -0.03273132f, -0.02355821f, -0.01629779f, 0.01475664f, -0.03673228f, -0.03792203f, 0.02035301f, -0.02074485f, 
    -0.03434746f, -0.00081540f, -0.00840202f, -0.00175897f, -0.01027646f, -0.00582247f, 0.00885182f, 0.01856459f, 
    -0.01632142f, 0.02552350f, -0.00101884f, -0.01808964f, -0.00603728f, -0.00137458f, -0.02709870f, 0.01023275f, 
    0.01346842f, 0.00985977f, 0.00834420f, -0.02011830f, -0.04822351f, 0.00258219f, -0.03659828f, -0.03177633f, 
    -0.04323566f, -0.04631953f, 0.00345882f, -0.00465614f, 0.00122709f, -0.04192531f, -0.04957378f, -0.03826777f, 
    -0.01369102f, -0.03572329f, -0.03262694f, -0.02523710f, 0.00810988f, 0.00224375f, 0.00633719f, -0.04359283f, 
    -0.03916489f, -0.03699059f, -0.00293107f, -0.02031837f, -0.01409296f, -0.03007249f, -0.03975593f, -0.02743672f, 
    -0.01324402f, 0.00796746f, -0.03395194f, -0.04620209f, -0.00560731f, -0.01354097f, -0.02255315f, -0.01961485f, 
    0.01831327f, -0.03538569f, 0.02926569f, -0.00697013f, -0.00302519f, -0.00100726f, 0.01470864f, -0.03412519f, 
    -0.01245109f, 0.00717196f, 0.01944659f, -0.00351201f, -0.03892203f, -0.03822911f, 0.00842050f, -0.04955677f, 
    0.00607671f, -0.05169436f, -0.00785655f, 0.03223359f, -0.00427627f, 0.00657377f, 0.02785589f, -0.03969373f, 
    0.01814864f, -0.03697253f, -0.05070757f, -0.00523705f, -0.04619421f, -0.00050047f, 0.02174958f, -0.04111034f, 
    -0.01595322f, 0.01104268f, -0.03129022f, 0.00442713f, 0.01200943f, -0.03908084f, 0.00450240f, -0.03231522f, 
    -0.04103427f, 0.00569638f, 0.01569349f, -0.00827861f, 0.00555408f, -0.03128310f, -0.02002357f, -0.04122583f, 
    -0.01395661f, -0.03867519f, -0.01138168f, -0.03691506f, 0.00018463f, 0.03352737f, 0.00963419f, 0.00220848f, 
    -0.02549793f, -0.01670973f, -0.03611599f, -0.04980062f, -0.01244931f, 0.01798067f, -0.00970468f, -0.02241009f, 
    -0.02441991f, -0.02764991f, -0.04046264f, 0.00822711f, 0.01718297f, -0.04345359f, 0.02896729f, -0.02610392f, 
    -0.00898891f, -0.03093677f, 0.01701579f, 0.03054026f, -0.03249530f, 0.01242107f, -0.03982720f, -0.01270533f, 
    -0.02922621f, 0.01859457f, 0.00558765f, 0.00904877f, -0.01662956f, -0.01517645f, -0.01002973f, 0.00869947f, 
    -0.01731960f, 0.01667724f, -0.03116268f, -0.03970694f, 0.03000406f, -0.02232288f, -0.01625826f, 0.02582321f, 
    0.02320044f, -0.00832270f, -0.00291576f, 0.01499468f, 0.00456970f, 0.00513971f, -0.02466064f, 0.00797992f, 
    -0.04929511f, -0.03662637f, 0.00780646f, 0.02049441f, 0.00293155f, -0.03990515f, 0.03330277f, 0.00619871f, 
    0.00530221f, -0.05498648f, 0.03378402f, -0.03659341f, -0.02999015f, 0.01552481f, -0.00259141f, -0.03479114f, 
    0.00047648f, 0.02635428f, 0.00942085f, 0.01791634f, 0.03714634f, -0.03896212f, -0.01665835f, 0.01493043f, 
    0.01611200f, -0.01988843f, -0.02555975f, -0.03486183f, 0.02111521f, -0.03272641f, -0.02660573f, -0.02613249f, 
    -0.02520141f, -0.00362427f, -0.02844832f, -0.03086593f, -0.01538789f, 0.01486689f, -0.00449895f, -0.03611638f, 
    0.01177687f, -0.03436982f, 0.02118391f, -0.03487907f, -0.05070908f, -0.00097571f, 0.00834717f, -0.02371637f, 
    -0.04077923f, 0.00881014f, -0.00439534f, -0.02089380f, -0.03050995f, -0.03501711f, 0.00742812f, 0.02222689f, 
    0.00956761f, -0.03171924f, -0.02361321f, -0.01530890f, 0.02481421f, 0.01135158f, -0.02394796f, 0.02042544f, 
    -0.02467142f, 0.00395406f, 0.01034775f, -0.00016767f, -0.00888247f, -0.04632581f, 0.03169436f, -0.01890242f, 
    0.01945006f, 0.02753730f, -0.05593157f, -0.02361832f, -0.02033476f, -0.00359368f, 0.01612256f, -0.02411404f, 
    -0.03430400f, 0.02947813f, -0.02873721f, -0.02384936f, 0.01032510f, -0.03973722f, -0.00910443f, 0.00977928f, 
    0.00611061f, 0.00783981f, -0.02349100f, 0.03045845f, -0.00208708f, 0.01873126f, -0.03112637f, -0.02894418f, 
    0.02242753f, -0.01339702f, -0.00737647f, -0.02043192f, -0.00547229f, -0.00441631f, -0.01097667f, -0.02445341f, 
    -0.03459235f, 0.01396873f, 0.00301935f, 0.01296214f, -0.03016019f, -0.03462825f, 0.01610139f, -0.02257147f, 
    -0.04451276f, -0.05258426f, -0.03435161f, -0.01115710f, -0.00546484f, -0.03213932f, -0.02351222f, 0.01901918f, 
    0.00412199f, -0.03780660f, -0.04209915f, 0.02009420f, -0.01098354f, -0.04088764f, 0.00864582f, -0.03596384f, 
    -0.00020656f, 0.00524411f, 0.03129163f, 0.01836956f, -0.01735914f, -0.01819284f, -0.03871340f, -0.02132278f, 
    0.02272190f, -0.01782139f, 0.00388151f, -0.00400889f, 0.01878990f, 0.01410883f, -0.04573599f, 0.01630051f, 
    -0.04791996f, 0.00057764f, -0.01434094f, -0.02224268f, -0.00920384f, -0.02326785f, -0.05308064f, 0.01171154f, 
    -0.05255692f, -0.04186355f, 0.00780272f, -0.04182843f, 0.03132043f, -0.04030159f, -0.02153743f, -0.00307993f, 
    -0.02399297f, -0.05213847f, -0.02961496f, -0.04032232f, -0.04492438f, -0.01707822f, -0.02758244f, 0.03379580f, 
    -0.03089383f, 0.01805780f, -0.04160453f, -0.01830123f, -0.02066952f, -0.03574070f, 0.00831523f, -0.00467978f, 
    -0.02007232f, -0.01105628f, 0.02072854f, -0.02008383f, -0.02966372f, -0.02365293f, 0.01752788f, -0.02072071f, 
    0.00116089f, -0.02858001f, 0.00665301f, 0.00219765f, -0.00260494f, 0.01270523f, 0.01803014f, -0.01549065f, 
    -0.00832312f, 0.01220331f, 0.01604116f, -0.02635690f, -0.02738326f, 0.00273825f, 0.02203479f, -0.01115592f, 
    0.01020775f, -0.00295068f, -0.01042532f, -0.00274228f, -0.00260152f, -0.02435983f, -0.02778651f, 0.00798531f, 
    -0.00554863f, -0.00249684f, -0.01183910f, 0.02948446f, -0.02567905f, -0.01705247f, -0.00515002f, -0.02088904f, 
    -0.00870252f, -0.02390080f, -0.04644150f, 0.01877064f, 0.02727087f, 0.02867114f, 0.02629445f, -0.04016583f, 
    0.03270487f, 0.00813336f, -0.00759420f, 0.03583870f, 0.00893800f, -0.01000373f, -0.03815641f, 0.01210158f, 
    -0.00852973f, 0.01365701f, -0.03179770f, 0.01378533f, 0.02690920f, 0.01832547f, -0.00965021f, -0.02256309f, 
    0.01421372f, -0.04006651f, -0.05307323f, -0.04919836f, -0.03858971f, 0.00245081f, -0.04136666f, 0.01591799f, 
    -0.00105298f, -0.00468833f, -0.03414881f, -0.01419491f, 0.02885542f, -0.00203516f, -0.04395382f, -0.02360927f, 
    -0.01671435f, -0.04322303f, -0.01888477f, 0.02476615f, -0.03530097f, -0.03819784f, -0.04485215f, 0.01788013f, 
    0.00448770f, -0.04631185f, 0.02841551f, -0.01235682f, 0.01751490f, -0.01998400f, 0.01016022f, -0.04575935f, 
    0.01043082f, 0.00679932f, -0.04900797f, 0.00642299f, -0.03282057f, -0.01429868f, -0.05288048f, 0.00465349f, 
    -0.10394835f, 0.19508788f, 0.12619592f, 0.08852579f, 0.02482576f, -0.01507626f, 0.03418482f, 0.03821840f, 
    0.06646991f, -0.00774216f, -0.00633261f, 0.03210932f, 0.04028918f, -0.00795070f, -0.08540684f, 0.09351777f, 
    -0.06709885f, -0.07116222f, -0.11805348f, -0.03746292f, -0.43837118f, -0.06936071f, 0.26540887f, 0.04579131f, 
    -0.10315133f, -0.04740639f, 0.02963845f, -0.00046686f, 0.06473776f, 0.12242336f, -0.06372669f, 0.03458239f, 
    -0.12093072f, -0.09712968f, 0.03155750f, 0.02871549f, 0.01695888f, 0.21436927f, 0.05442454f, 0.04525337f, 
    -0.00221030f, 0.13990422f, 0.17450017f, 0.08853301f, -0.04526833f, -0.04226069f, 0.00660252f, 0.03829174f, 
    0.07920811f, -0.09982952f, -0.04589377f, 0.04775224f, 0.01189165f, 0.01927145f, -0.09653018f, 0.04114071f, 
    0.04360792f, -0.11773934f, -0.02043262f, -0.07499980f, -0.46413648f, 0.13993877f, 0.17654204f, 0.08471138f, 
    0.17579016f, 0.00958366f, 0.07802463f, -0.07336420f, 0.03488466f, 0.10184362f, -0.03644052f, 0.14571668f, 
    0.06353338f, 0.14038002f, 0.09760004f, 0.07861111f, 0.00708284f, 0.20415199f, -0.01161486f, 0.04028004f, 
    0.09539731f, -0.03237493f, -0.03860006f, 0.07041966f, 0.00325227f, -0.00056784f, 0.19659398f, 0.04437932f, 
    -0.07931571f, -0.00995371f, -0.08666885f, 0.04116843f, -0.03417672f, 0.06333549f, 0.06919103f, 0.05021439f, 
    -0.09728725f, 0.22649977f, -0.17403775f, -0.02622738f, 0.03477928f, 0.24594608f, -0.02329187f, -0.33105007f, 
    0.13427040f, 0.00054724f, -0.10743705f, -0.02211355f, 0.13133509f, 0.00813325f, -0.02631641f, 0.05805482f, 
    0.03510144f, 0.07448196f, -0.09006148f, 0.01055667f, 0.04204663f, 0.04911841f, -0.11773079f, 0.02340109f, 
    -0.15986834f, -0.27280656f, 0.03544718f, 0.09084385f, 0.03899880f, 0.01322656f, 0.01475862f, 0.03925563f, 
    0.09495043f, 0.01721377f, 0.13686942f, 0.06166314f, -0.01934837f, -0.16417141f, 0.08267315f, 0.00968871f, 
    0.04861617f, 0.14890917f, 0.30883107f, 0.07140775f, -0.02196524f, 0.20757955f, 0.11684119f, -0.00122216f, 
    0.12029252f, 0.00953664f, 0.01041271f, 0.02054684f, 0.09769335f, 0.08742248f, -0.09385367f, 0.02953680f, 
    0.00589404f, 0.06183356f, -0.00754388f, 0.12091032f, -0.10059850f, 0.20752856f, -0.02759211f, 0.07158886f, 
    0.23493008f, -0.01872255f, -0.05661420f, 0.05206159f, 0.14416544f, 0.11397393f, 0.12644669f, -0.06354357f, 
    0.08129852f, 0.12226373f, 0.03500837f, 0.03091099f, 0.01140529f, 0.08581070f, 0.10029840f, 0.08471829f, 
    0.00561170f, 0.02401261f, 0.11269984f, 0.03834131f, 0.05546772f, -0.20614615f, -0.00713926f, 0.24486066f, 
    -0.00982372f, -0.05376160f, 0.19386326f, 0.02406333f, -0.04282366f, -0.00537773f, 0.04591629f, 0.02540270f, 
    -0.09515718f, -0.06232405f, -0.07809243f, -0.05796628f, -0.00033349f, 0.09717073f, 0.26667818f, 0.14091632f, 
    -0.08787274f, 0.46381834f, 0.12144842f, -0.16084480f, 0.09752449f, -0.08002739f, 0.14277068f, -0.08504263f, 
    -0.00932386f, -0.06296326f, 0.00003694f, 0.12288549f, 0.16761026f, -0.04317022f, -0.00352770f, -0.07189866f, 
    0.06412352f, -0.17002648f, -0.08402254f, -0.05616659f, 0.46217018f, 0.00512986f, -0.15529954f, 0.10070971f, 
    -0.26374465f, -0.17803232f, 0.06737488f, -0.03358883f, -0.04658259f, -0.05341890f, -0.04764540f, 0.05076133f, 
    0.01639766f, 0.12743482f, 0.07193179f, 0.08780610f, -0.01372743f, -0.00742678f, 0.06409305f, 0.06877812f, 
    0.20401336f, -0.34340781f, 0.09680934f, 0.17244118f, 0.19236131f, -0.04296631f, 0.10940474f, 0.01905240f, 
    0.03155304f, 0.14449894f, 0.00696765f, 0.01032039f, 0.16048156f, 0.13071334f, 0.04843360f, 0.05659493f, 
    0.25781542f, -0.04464258f, 0.32980463f, 0.04176487f, -0.18805227f, -0.07911476f, 0.30570167f, 0.19524881f, 
    -0.03613171f, 0.04248779f, 0.01785817f, -0.06731994f, -0.02892458f, 0.07210510f, -0.06633421f, -0.01069292f, 
    0.00497136f, -0.04758933f, -0.04031951f, -0.03737109f, 0.09195621f, -0.01517780f, 0.17466885f, 0.01611415f, 
    0.16381943f, -0.01689214f, 0.23694094f, 0.08617692f, 0.00814235f, -0.03780075f, 0.03108471f, 0.04434639f, 
    -0.01532094f, 0.02287624f, -0.05533333f, -0.05690293f, -0.00197348f, -0.13925086f, 0.07749625f, 0.00483802f, 
    0.04521073f, -0.18785109f, 0.06504663f, 0.00913305f, 0.40389276f, -0.32973793f, -0.12202866f, 0.06098512f, 
    -0.01321824f, 0.07577443f, 0.02516149f, 0.09618813f, -0.17613600f, 0.01140769f, -0.00362313f, 0.16195589f, 
    -0.18209526f, 0.00299738f, -0.09505309f, 0.06057025f, 0.02191193f, 0.19166353f, 0.26125988f, 0.16632283f, 
    -0.10191849f, -0.28581712f, -0.08754100f, 0.09178168f, -0.05578790f, -0.01217917f, 0.02804503f, 0.04817746f, 
    -0.24548212f, 0.02954071f, 0.04066790f, -0.00063483f, -0.09359752f, -0.06708296f, -0.12530269f, -0.09607602f, 
    0.00819950f, 0.11778771f, 0.26594746f, 0.02447602f, 0.04976739f, -0.16959029f, 0.25128740f, 0.24914244f, 
    0.10847586f, 0.08544625f, -0.00476792f, 0.05310177f, 0.08512460f, -0.03021498f, 0.03372635f, 0.08672449f, 
    -0.18235961f, -0.07865024f, 0.12651792f, 0.04175098f, -0.06470475f, 0.21387477f, 0.24572970f, 0.08785195f, 
    0.37657967f, 0.12265386f, -0.02747969f, 0.19068587f, 0.14273739f, 0.05467990f, -0.09599382f, 0.24646860f, 
    0.08339795f, 0.05986205f, 0.04479699f, 0.01663363f, 0.02708112f, 0.18237874f, -0.00560661f, 0.09519447f, 
    0.01377288f, -0.22902788f, -0.08571824f, -0.03878226f, 0.12180901f, -0.02776396f, 0.01822221f, 0.03954258f, 
    -0.08553074f, -0.10027131f, -0.00950362f, 0.05914501f, 0.01409766f, -0.02801812f, -0.06957372f, 0.03962882f, 
    0.06525563f, -0.04785938f, 0.00693099f, 0.09198331f, 0.12247266f, -0.29984260f, -0.05766065f, -0.00046835f, 
    0.22971918f, -0.05796352f, -0.02450836f, 0.18098794f, 0.03278507f, -0.10299651f, 0.04478630f, 0.03192357f, 
    0.11900606f, -0.03986878f, -0.03263851f, -0.05464107f, 0.00251905f, 0.06656594f, 0.04731075f, 0.07767605f, 
    0.04331344f, 0.26135433f, -0.06051371f, 0.00414168f, 0.35611442f, -0.09899556f, 0.02004077f, 0.14443713f, 
    0.13591564f, 0.09620015f, -0.03817226f, 0.23179555f, 0.05754694f, 0.04456656f, -0.06370026f, 0.04290350f, 
    0.08103348f, 0.09127782f, 0.04653398f, 0.01753140f, 0.05306040f, -0.07415671f, 0.01875461f, 0.05839522f, 
    -0.05268072f, 0.06610322f, 0.04743759f, -0.01771696f, -0.01820912f, -0.10794830f, 0.17241699f, -0.10891470f, 
    0.08908633f, -0.11432267f, -0.11224902f, -0.14030313f, 0.08187691f, -0.03411417f, -0.04114289f, -0.15118176f, 
    -0.10547291f, 0.01590413f, 0.04245723f, -0.03779453f, 0.26166552f, 0.05747830f, -0.01159624f, 0.01014008f, 
    -0.07239172f, 0.02510800f, 0.13118239f, -0.04337007f, 0.04968433f, 0.08821113f, -0.05926653f, 0.03988562f, 
    -0.06382034f, 0.00119626f, -0.01867625f, -0.04359072f, 0.01049858f, 0.13151817f, 0.08315805f, 0.00512971f, 
    -0.24109820f, -0.13061255f, 0.19637021f, 0.10912040f, 0.07080183f, 0.09486865f, 0.06213998f, 0.10190288f, 
    0.09649468f, 0.24675524f, 0.04639119f, 0.03004776f, 0.19969204f, 0.26701942f, 0.04146191f, 0.13680997f, 
    0.06772370f, 0.07206248f, 0.00308768f, -0.02415996f, 0.82693857f, -0.16420847f, 0.24704312f, -0.27058107f, 
    0.14517274f, 0.13008957f, 0.03678569f, 0.10934555f, -0.01579587f, 0.01940402f, -0.06399380f, -0.03715694f, 
    -0.08243702f, 0.03860568f, -0.04817817f, 0.16764674f, 0.20391658f, 0.13883585f, 0.07701568f, 0.02730644f, 
    -0.31923074f, -0.11492855f, -0.00455849f, 0.07482209f, -0.10699948f, -0.22235242f, -0.00117233f, -0.06449268f, 
    0.01023412f, -0.06071251f, -0.04106778f, 0.00329385f, -0.06386893f, 0.01809541f, -0.08541018f, -0.18372953f, 
    -0.15623787f, -0.00272065f, 0.06239293f, -0.05415212f, 0.33323702f, -0.26226997f, 0.16296585f, 0.01333938f, 
    0.11509195f, 0.05460178f, 0.04954428f, 0.00734428f, -0.03860606f, 0.05084002f, -0.10173590f, 0.01456376f, 
    -0.15042877f, 0.03708971f, -0.02906640f, -0.16583122f, 0.09982464f, 0.05743420f, 0.16766800f, -0.03050304f, 
    -0.00079990f, 0.17265317f, 0.20165084f, 0.05054397f, 0.11332008f, -0.02283742f, -0.03209873f, 0.01859622f, 
    0.08622389f, -0.04727822f, -0.04534647f, 0.02695454f, -0.01973068f, -0.00084211f, -0.09643644f, -0.01467319f, 
    0.04216773f, -0.13490659f, -0.07364484f, -0.01201946f, -0.01020674f, -0.07009312f, 0.27077949f, 0.02492821f, 
    0.19208401f, 0.07211795f, -0.01232033f, -0.04978221f, 0.02302388f, 0.06553357f, 0.14680910f, 0.14543827f, 
    -0.13034345f, 0.01442944f, 0.02122534f, 0.05691755f, -0.13314511f, 0.16299728f, 0.05159021f, 0.13525647f, 
    -0.07142397f, 0.09458198f, 0.22342490f, -0.01077971f, 0.06990325f, 0.06255803f, 0.05461131f, -0.00788805f, 
    -0.09010293f, 0.14463569f, 0.03371682f, 0.14314045f, -0.03672203f, -0.01081822f, -0.05276838f, -0.10664051f, 
    -0.01877190f, -0.00233952f, 0.04356018f, -0.04531701f, 0.06814741f, 0.17621972f, 0.07983593f, -0.04477562f, 
    0.01135700f, -0.06192070f, 0.02853236f, -0.05292013f, -0.02958606f, -0.04481456f, -0.04217332f, -0.04587872f, 
    0.05951524f, -0.04330003f, -0.06958370f, -0.06267208f, -0.00577776f, -0.26035139f, -0.07532258f, -0.12110946f, 
    -0.27266452f, -0.12021179f, -0.18338202f, -0.03424473f, 0.02742737f, -0.11539716f, 0.00740938f, -0.01587029f, 
    -0.02778698f, -0.00246637f, -0.05450412f, -0.01313668f, 0.04476323f, -0.00798445f, 0.03082708f, 0.03769001f, 
    -0.00037049f, -0.03225017f, -0.01311193f, -0.02399735f, -0.24437895f, -0.02004942f, -0.05196327f, 0.13166662f, 
    -0.06581403f, 0.05621247f, -0.00589774f, -0.13005146f, 0.03419712f, 0.06474555f, 0.03383735f, 0.05085130f, 
    -0.01155766f, 0.04128536f, 0.00673029f, 0.02229913f, -0.02504724f, 0.00408418f, 0.06008498f, 0.07852290f, 
    -0.37899697f, -0.18436453f, -0.07286651f, -0.00282909f, -0.10438300f, -0.01271660f, -0.03434828f, -0.04924469f, 
    -0.03367028f, 0.04802455f, -0.01495215f, 0.06616803f, 0.03040673f, 0.03572275f, 0.00869637f, 0.03383778f, 
    -0.01546820f, -0.02445410f, -0.00435176f, 0.05244660f, 0.11353365f, 0.28730863f, -0.11805569f, 0.03204058f, 
    0.03262064f, -0.14524937f, 0.07338619f, 0.11002638f, 0.08098719f, -0.13721135f, 0.06506239f, -0.04226603f, 
    0.04704085f, 0.12299802f, -0.01828198f, -0.03060640f, -0.05224826f, 0.12954953f, 0.00174183f, 0.05063945f, 
    0.02289426f, 0.13480443f, -0.19809121f, -0.10681070f, 0.19472556f, -0.02631470f, 0.11875138f, 0.00153670f, 
    -0.01539300f, -0.10167798f, -0.11072137f, 0.07147190f, 0.04419946f, 0.06530628f, 0.03518194f, 0.01914286f, 
    -0.02274857f, 0.12996352f, 0.00323053f, 0.00933983f, 0.04604833f, 0.14709686f, -0.08462749f, 0.11328124f, 
    0.04960378f, 0.11143768f, -0.07509600f, 0.03304503f, 0.08883970f, -0.03933622f, -0.03366980f, 0.01851230f, 
    0.00738334f, 0.01967543f, -0.02345899f, -0.05069593f, 0.07778001f, 0.08745626f, -0.05273756f, 0.01206049f, 
    0.12867481f, 0.28505436f, 0.03323926f, 0.05854559f, 0.03782346f, 0.01525700f, -0.02282780f, -0.03930254f, 
    -0.00836875f, 0.01090836f, -0.04454933f, -0.03462571f, -0.02504384f, -0.09410451f, 0.10104577f, -0.00591484f, 
    0.02048720f, 0.09693112f, -0.03958027f, 0.10306165f, -0.22852115f, 0.10174351f, 0.20271496f, 0.09452813f, 
    0.35564485f, 0.04232091f, 0.07449598f, 0.04278977f, 0.01920605f, -0.00623879f, -0.02828552f, -0.05206645f, 
    0.08490928f, -0.03073169f, -0.02904419f, -0.07284877f, 0.08743917f, -0.07762244f, 0.01104378f, -0.04763255f, 
    0.04171489f, -0.13843693f, 0.02072207f, -0.10316539f, 0.01224429f, 0.04437507f, 0.04727941f, 0.06722274f, 
    0.00357197f, -0.08110242f, -0.16663317f, 0.08805020f, 0.03125577f, -0.01286171f, -0.00903588f, -0.02838200f, 
    0.02142760f, 0.11185580f, -0.02358469f, -0.08992905f, 0.24810821f, 0.16135941f, 0.07132778f, 0.04048111f, 
    0.07054268f, 0.03499842f, -0.06970531f, 0.00839793f, -0.01402010f, 0.06333144f, 0.02264656f, -0.04407566f, 
    -0.03422104f, -0.13540438f, 0.02387706f, 0.01454927f, -0.06154034f, 0.03514162f, 0.04169139f, 0.01681226f, 
    -0.08801299f, 0.34756047f, -0.03835851f, 0.00822981f, -0.08305915f, -0.06747494f, -0.01976285f, -0.03248448f, 
    0.02553876f, 0.03361970f, 0.09566765f, 0.13207994f, -0.02640483f, 0.07566786f, 0.09368049f, -0.07649188f, 
    -0.05686107f, 0.00061708f, 0.02290446f, 0.07561282f, -0.12347617f, 0.13557582f, 0.08537766f, 0.16214265f, 
    -0.06833199f, -0.17377628f, 0.04225380f, -0.03575232f, 0.00088549f, -0.02999021f, 0.08481256f, 0.00970282f, 
    0.02764733f, -0.03377119f, 0.12570214f, -0.04366812f, 0.01439351f, 0.03298163f, -0.04669163f, 0.06943451f, 
    0.07207913f, -0.20034331f, 0.14749633f, -0.09071961f, 0.11705869f, 0.08912986f, 0.07501049f, -0.06034487f, 
    0.05367358f, -0.05018364f, -0.07831232f, -0.05466405f, -0.02433774f, -0.00100297f, 0.04228213f, -0.00137075f, 
    0.18067066f, -0.01629287f, 0.07404917f, 0.09476069f, -0.39574638f, -0.08228643f, 0.10659096f, 0.03308373f, 
    -0.09089608f, 0.03379445f, -0.04515084f, -0.00128479f, -0.02203923f, 0.07139295f, -0.06426065f, 0.05370778f, 
    0.00225911f, -0.01302966f, 0.05395302f, 0.03483241f, -0.04709756f, 0.01146834f, 0.02813804f, 0.02837383f, 
    -0.16512403f, -0.21128853f, 0.08341507f, -0.05684734f, 0.03593114f, -0.04750785f, 0.01021750f, -0.07379677f, 
    -0.09238469f, 0.00252626f, -0.03547843f, -0.03738376f, 0.05263258f, -0.01535438f, 0.10954627f, -0.05938926f, 
    0.12656377f, -0.05082916f, 0.00723030f, 0.13328743f, 0.44802865f, 0.14005853f, 0.12317552f, 0.18185389f, 
    0.17131752f, -0.00656689f, -0.02264658f, 0.00291579f, -0.06646819f, 0.11470105f, -0.02314432f, 0.05831092f, 
    -0.06473535f, 0.00755942f, 0.03736711f, -0.03516820f, 0.07763716f, 0.00544103f, 0.09044493f, 0.06635452f, 
    0.32103500f, 0.26345566f, 0.11709709f, 0.26873487f, 0.05799874f, 0.06343706f, -0.05466697f, 0.09633639f, 
    -0.07707361f, 0.09741575f, -0.05656610f, 0.01297654f, -0.02266528f, 0.04524340f, -0.04639542f, 0.15605009f, 
    0.00295882f, 0.02963818f, -0.01378427f, -0.00590940f, 0.31160453f, 0.18888877f, 0.09367346f, 0.03596913f, 
    -0.01742835f, 0.15795363f, 0.01264127f, -0.01911549f, 0.01929565f, 0.00736140f, 0.05683017f, 0.01663793f, 
    -0.02518678f, -0.01855985f, 0.04272086f, 0.13119134f, -0.01372786f, -0.05824891f, -0.05591289f, -0.00553024f, 
    -0.19743410f, -0.21880929f, -0.01966106f, 0.05137334f, -0.12748715f, -0.14172387f, -0.03576258f, -0.02015474f, 
    0.01342492f, 0.00119555f, 0.02551192f, -0.07690433f, -0.00263033f, -0.08433596f, 0.04511991f, 0.09438108f, 
    0.07738634f, -0.00247436f, -0.02761887f, 0.09905366f, -0.21198940f, -0.17088185f, -0.10836505f, 0.11920588f, 
    -0.05925698f, 0.09266037f, -0.09539816f, -0.04754374f, -0.04602835f, 0.09091349f, 0.01391815f, 0.03824084f, 
    -0.06776668f, -0.01258726f, 0.04579975f, 0.06523308f, 0.04777556f, -0.07274019f, 0.06769668f, 0.07794075f, 
    0.24411799f, 0.07499527f, -0.03957320f, -0.02237391f, 0.17398451f, 0.08970652f, 0.07995985f, 0.01360925f, 
    0.01697603f, 0.00923451f, 0.03069953f, -0.12327182f, -0.01434216f, -0.01967850f, 0.06399560f, 0.02199126f, 
    0.05888832f, -0.04065851f, -0.00855599f, 0.16164550f, -0.10859578f, -0.03477868f, -0.05147815f, 0.08756397f, 
    -0.19549695f, 0.01175212f, -0.08984110f, 0.01397155f, -0.06377666f, -0.04344119f, -0.04815745f, -0.00249981f, 
    -0.04417518f, -0.02589165f, 0.00485345f, 0.03360896f, -0.04571166f, -0.01458542f, 0.07693097f, 0.12447526f, 
    -0.23210722f, -0.06264157f, 0.01943488f, 0.07236581f, -0.07225312f, -0.04899219f, 0.03965254f, 0.02115393f, 
    0.05433988f, 0.07336565f, -0.06598708f, -0.04918925f, 0.09117384f, 0.00831734f, -0.10336775f, 0.12658271f, 
    0.06455112f, 0.08732388f, 0.06111322f, -0.02182652f, 0.13990408f, 0.12949987f, 0.12311601f, -0.05045125f, 
    0.14456341f, 0.00124379f, 0.10114748f, -0.01941581f, -0.02538090f, -0.02251075f, 0.12468861f, -0.00807741f, 
    0.14370082f, 0.05370867f, -0.01733805f, 0.05617990f, 0.11063625f, -0.05179075f, -0.03464437f, -0.01329791f, 
    -0.02932337f, -0.08678393f, 0.00427722f, -0.12458747f, -0.10018314f, -0.16465689f, 0.01653494f, 0.11926330f, 
    0.01342953f, -0.11007168f, -0.09486981f, 0.05990217f, 0.07756799f, 0.03662415f, 0.00544156f, 0.01265532f, 
    0.05179874f, -0.00742263f, 0.03746889f, -0.05719182f, 0.19812849f, 0.30362046f, 0.19762747f, 0.16612864f, 
    0.02573184f, 0.17544256f, -0.02301082f, -0.09842015f, 0.04145546f, 0.06731634f, -0.03502236f, -0.04279866f, 
    -0.08328366f, 0.03518298f, 0.00925254f, -0.02263944f, 0.05276981f, 0.07443351f, 0.01097714f, 0.09385171f, 
    -0.19933596f, -0.09938337f, 0.06284215f, 0.14304636f, 0.06070281f, 0.05471045f, 0.07573727f, -0.12599021f, 
    0.03877053f, 0.01566050f, 0.01649498f, -0.00644821f, 0.06207495f, -0.00137948f, -0.15552345f, 0.01855706f, 
    0.07964381f, 0.01937110f, 0.04029723f, -0.12251800f, -0.04623964f, 0.13368508f, 0.01175415f, -0.01872677f, 
    -0.07438038f, 0.10127138f, -0.02697816f, -0.00102576f, -0.04171580f, 0.01679022f, -0.00154382f, 0.00977210f, 
    0.04220684f, 0.03530129f, 0.01669833f, 0.01517065f, 0.03865263f, -0.01964200f, -0.00144791f, -0.00137198f, 
    -0.33442533f, -0.12014984f, -0.01861617f, -0.00180397f, -0.09149307f, -0.01611227f, -0.11269175f, -0.05176268f, 
    0.00869066f, 0.03143372f, 0.00308690f, 0.06680933f, -0.02472346f, -0.00237685f, -0.04922784f, 0.01217451f, 
    -0.00663628f, 0.02307514f, 0.04730012f, 0.01190734f, 0.32248902f, 0.15550530f, -0.04943287f, 0.02413068f, 
    -0.04357783f, -0.04629651f, 0.04073485f, 0.09070878f, -0.01211183f, -0.05848853f, 0.00181527f, 0.07807441f, 
    0.02217859f, 0.03479024f, 0.12800482f, 0.00743384f, 0.12831008f, 0.01574233f, -0.01575075f, 0.06625683f, 
    -0.05748756f, 0.18280239f, -0.01066831f, -0.05437896f, -0.09148018f, -0.07723632f, 0.02431870f, 0.01523161f, 
    0.00431750f, -0.07972033f, -0.00582709f, 0.03729416f, 0.03306890f, 0.07928437f, 0.12616789f, 0.00053041f, 
    0.04520442f, 0.00458789f, 0.07060119f, -0.06712142f, -0.18333279f, -0.28142717f, -0.15805089f, 0.00696651f, 
    0.01257988f, 0.02537806f, -0.00566521f, -0.01597666f, 0.00711814f, 0.02839321f, 0.03533747f, 0.07278487f, 
    -0.00577795f, 0.03472451f, 0.09801035f, 0.03817031f, 0.06174405f, 0.05955837f, 0.04196148f, 0.00753484f, 
    0.01982987f, -0.02768802f, -0.00600165f, -0.02533652f, -0.01227050f, 0.01930354f, -0.00739610f, 0.01446461f, 
    -0.00079924f, 0.01770019f, 0.01633398f, 0.01123940f, -0.03921443f, 0.01337140f, 0.02281565f, -0.02698533f, 
    0.01252966f, -0.02237180f, 0.02222931f, -0.01240492f, -0.03454574f, -0.00345532f, -0.00483289f, -0.03921318f, 
    -0.02481023f, -0.03299845f, 0.02946897f, 0.02175855f, 0.03591544f, -0.01053266f, -0.04225876f, -0.02116239f, 
    0.01651978f, -0.01372965f, 0.01903239f, 0.02575183f, -0.00758513f, -0.03168986f, 0.02476142f, -0.04156358f, 
    0.01399969f, 0.03182073f, -0.03857985f, 0.03226721f, -0.03992053f, -0.00149020f, -0.01262084f, -0.02678180f, 
    -0.02236545f, 0.02046249f, 0.02371472f, 0.00126354f, 0.02256849f, 0.02077003f, 0.02125837f, 0.00762998f, 
    0.02235892f, -0.04369280f, -0.04120309f, -0.00557919f, 0.03447763f, 0.00952241f, 0.00009970f, 0.00381198f, 
    0.02129004f, -0.03593189f, 0.02506861f, 0.00780374f, 0.03617082f, 0.01994731f, -0.00373099f, -0.02067129f, 
    0.02449742f, 0.02574078f, 0.00338872f, -0.00867052f, -0.02070284f, -0.03703415f, -0.03050365f, 0.00238540f, 
    -0.01822392f, -0.02260839f, -0.04660737f, 0.00261942f, 0.01164544f, 0.00561992f, 0.03568950f, -0.01954565f, 
    -0.03617203f, 0.01326044f, -0.02801027f, 0.03583614f, -0.03593578f, 0.00121681f, 0.03781584f, 0.00193348f, 
    0.02547535f, -0.03553627f, 0.02047635f, 0.00170970f, 0.00113892f, 0.00249217f, -0.03006248f, 0.01999130f, 
    0.02135204f, -0.01238099f, -0.01865792f, 0.03331811f, -0.00396479f, 0.02490242f, -0.03285252f, -0.01180685f, 
    0.02172210f, 0.00123972f, -0.02830587f, 0.00778743f, -0.04116832f, 0.02486347f, -0.04769623f, -0.00693993f, 
    -0.01157900f, -0.00385974f, -0.03411809f, 0.02117263f, 0.00147697f, 0.00150353f, -0.00779774f, -0.01109934f, 
    -0.03440743f, -0.01102801f, -0.00737678f, -0.03925095f, 0.01207898f, -0.03143078f, -0.01414936f, -0.02501000f, 
    0.03201847f, -0.01817928f, 0.02441076f, 0.00509512f, -0.01630004f, -0.03976138f, -0.03315498f, -0.03448305f, 
    -0.00308898f, 0.03285804f, 0.02821153f, 0.01924207f, 0.00231093f, 0.01821498f, -0.03123309f, -0.02826418f, 
    0.02586973f, -0.03995840f, 0.02096919f, 0.00560165f, 0.02469057f, -0.02079653f, 0.02895239f, 0.02851880f, 
    -0.02823632f, -0.01776890f, -0.03165209f, -0.02317864f, -0.03597821f, 0.03004977f, 0.02045598f, -0.03701491f, 
    -0.01361544f, -0.01288343f, 0.02905750f, 0.00157387f, 0.00165603f, -0.03687934f, -0.00221661f, -0.03646078f, 
    0.02064877f, -0.01736747f, -0.03562059f, -0.01625737f, 0.00412499f, -0.03730042f, -0.00325848f, -0.00435955f, 
    -0.00600868f, 0.00694653f, 0.02621702f, -0.03706693f, -0.00954286f, 0.02166659f, 0.02068787f, 0.01600250f, 
    -0.03549501f, 0.02824482f, -0.01276753f, 0.01362413f, -0.03053402f, -0.02125879f, -0.01225509f, -0.00845454f, 
    -0.02426067f, 0.01652049f, -0.02097534f, -0.01272036f, -0.00726973f, 0.01730872f, -0.01611511f, 0.01468762f, 
    0.02131610f, -0.00741775f, -0.04221711f, -0.02782363f, 0.03575520f, -0.02176630f, -0.04194030f, 0.00715516f, 
    0.01409499f, 0.00180978f, -0.01602053f, 0.02267554f, -0.00217370f, 0.01100681f, 0.00746400f, -0.00482699f, 
    0.00648972f, 0.00404368f, -0.04211738f, -0.03090600f, -0.04117239f, 0.02010511f, 0.01271384f, -0.01851256f, 
    0.02956769f, -0.01832120f, 0.03226456f, 0.00891185f, -0.00581737f, 0.02688061f, -0.03806799f, -0.04238604f, 
    0.03741740f, -0.03138619f, 0.01352516f, -0.00781900f, -0.03993788f, -0.03259545f, 0.01885359f, -0.01740101f, 
    0.01324678f, 0.00051304f, 0.02480787f, -0.00348176f, 0.00646449f, -0.04166419f, -0.01723859f, 0.01320527f, 
    -0.02139128f, 0.03596865f, 0.00250005f, 0.02821219f, -0.00558380f, 0.02197016f, 0.01945786f, -0.00375148f, 
    -0.03340165f, 0.02811228f, -0.01303180f, 0.02158406f, 0.00351459f, -0.00464931f, -0.02545910f, -0.00705583f, 
    0.00916322f, -0.03046381f, -0.00551465f, -0.03598399f, 0.03815972f, 0.02013080f, -0.03308555f, 0.00589286f, 
    0.00540426f, 0.03443524f, -0.03250196f, 0.01858457f, -0.03306592f, -0.04512449f, -0.02627576f, -0.01681324f, 
    -0.02854020f, -0.00117190f, 0.01837472f, -0.00881536f, 0.02833958f, 0.03640886f, -0.05095894f, 0.02200126f, 
    -0.03680295f, 0.01935064f, -0.02499663f, -0.03475318f, 0.00447817f, -0.01744346f, -0.01355292f, -0.02750118f, 
    -0.03105730f, -0.01289911f, -0.01801768f, 0.01758431f, -0.03797314f, 0.03182702f, -0.04814190f, 0.01245649f, 
    -0.02128758f, -0.00348143f, 0.01723251f, 0.01785720f, -0.00265489f, -0.02308760f, -0.00652565f, -0.00801536f, 
    0.04269142f, -0.00523894f, -0.03090499f, -0.00063547f, 0.02414003f, 0.01142709f, -0.00484136f, -0.03322285f, 
    0.01268761f, 0.03071180f, 0.03306956f, 0.00973992f, -0.02194567f, 0.01195323f, -0.01596332f, -0.03195356f, 
    0.02840294f, -0.02621748f, 0.00124893f, -0.00179425f, 0.04368962f, 0.03916614f, 0.02360378f, -0.02086496f, 
    0.00368196f, 0.02206377f, 0.00498526f, 0.03266571f, -0.02614976f, 0.00197297f, 0.02867513f, 0.01858473f, 
    0.02550866f, -0.00460525f, 0.00683849f, 0.02058693f, -0.03175653f, -0.01506343f, 0.03685905f, -0.00671635f, 
    -0.02977921f, 0.03145330f, 0.00992891f, -0.01495046f, 0.00457228f, -0.02477587f, -0.04357587f, -0.00656527f, 
    0.02516995f, -0.02667022f, 0.00179812f, 0.01648650f, -0.00205462f, -0.00753897f, -0.02382635f, 0.01610648f, 
    0.02759479f, -0.02445828f, 0.00319864f, 0.04025134f, 0.01880931f, 0.01702833f, -0.00836980f, 0.02170483f, 
    -0.02009759f, -0.00364592f, 0.00879792f, -0.01093280f, -0.00501433f, 0.04794272f, 0.01525597f, 0.01756649f, 
    -0.02814340f, -0.02673186f, 0.00683798f, -0.02497482f, 0.00859030f, -0.01824084f, 0.02721252f, -0.00670928f, 
    0.03775364f, -0.01699329f, 0.00974640f, 0.02742851f, 0.02052557f, 0.00016309f, 0.02768851f, -0.02135311f, 
    -0.04445810f, 0.00114840f, 0.03081917f, -0.01215170f, 0.02442649f, 0.02884400f, -0.01257393f, -0.02754059f, 
    -0.00109580f, -0.00416189f, -0.02747492f, -0.00370424f, 0.01067271f, 0.01192930f, -0.01493415f, 0.01958502f, 
    0.02117495f, -0.02844422f, 0.00386680f, -0.02861370f, -0.01758919f, -0.04088007f, -0.01073662f, -0.02215355f, 
    -0.03444492f, -0.03124322f, -0.03412721f, 0.03325949f, -0.02629277f, -0.02112247f, -0.04449007f, -0.02284886f, 
    0.03196396f, 0.02087013f, 0.02412035f, -0.01920817f, -0.02852736f, -0.02508674f, -0.03048663f, -0.01456588f, 
    -0.02106107f, 0.01256027f, 0.01492878f, 0.03446104f, 0.01931388f, -0.03797618f, 0.01729644f, -0.00113641f, 
    0.01001083f, -0.04206662f, -0.04470206f, -0.02021740f, -0.00297859f, -0.01419969f, -0.01993540f, 0.02672032f, 
    -0.02163677f, 0.03132829f, -0.03693128f, 0.02217752f, -0.03546460f, -0.00456745f, 0.01703595f, -0.01720036f, 
    0.02964984f, -0.02938439f, 0.03137952f, -0.01572717f, -0.02253115f, 0.00776246f, 0.01144812f, -0.01151489f, 
    -0.03873103f, -0.00951070f, -0.03688131f, -0.03285578f, -0.00753449f, 0.00192000f, -0.03190500f, -0.00200972f, 
    0.03398775f, 0.01128443f, -0.02566314f, 0.02618390f, -0.03594930f, -0.00224511f, -0.01384446f, 0.01955355f, 
    0.00758022f, 0.01787939f, -0.03016578f, -0.03955731f, -0.02468674f, 0.03486048f, -0.01392431f, -0.01948009f, 
    -0.00087966f, -0.04223483f, 0.01178650f, -0.00176147f, -0.00214813f, 0.01900653f, -0.02582906f, 0.00521757f, 
    0.01894587f, 0.02553305f, -0.03847409f, -0.02517876f, 0.01251089f, 0.01427474f, -0.04345036f, -0.02682240f, 
    0.01951286f, 0.01627244f, 0.00049144f, 0.00368401f, -0.02302890f, -0.04200261f, 0.01666810f, -0.00285205f, 
    0.02180040f, 0.02950048f, 0.01591762f, -0.01887744f, -0.00359362f, -0.03045120f, -0.01916295f, -0.01097386f, 
    -0.01274717f, 0.00517341f, -0.03554165f, -0.01003552f, 0.02025998f, 0.03427375f, 0.02235333f, -0.01406695f, 
    -0.02081227f, 0.01737570f, -0.01227559f, 0.01459597f, -0.01177169f, -0.04425224f, -0.02711460f, -0.00180159f, 
    0.02200084f, -0.05038155f, -0.00300810f, -0.00214271f, -0.00112867f, 0.01046008f, -0.01844567f, -0.04270595f, 
    -0.02652688f, -0.01043601f, 0.00102183f, -0.01467143f, 0.03121480f, -0.01865606f, -0.00054231f, 0.00191813f, 
    0.01880347f, 0.00360001f, 0.02356846f, -0.01792694f, -0.01033131f, 0.02566252f, 0.01405716f, -0.03119589f, 
    -0.01800512f, -0.04894091f, -0.00760584f, 0.00072353f, -0.02041838f, 0.00709086f, 0.02027514f, 0.01440437f, 
    -0.02178869f, -0.00973620f, 0.01015719f, 0.02332201f, 0.00862214f, 0.01041473f, -0.02991800f, -0.00043816f, 
    -0.00583793f, -0.03392603f, 0.00554407f, 0.02094180f, -0.02794102f, -0.00684119f, -0.01816503f, -0.01687742f, 
    0.01092234f, -0.03057401f, -0.04715490f, 0.03180366f, 0.03232600f, -0.03693251f, 0.02721599f, 0.03371727f, 
    0.03278954f, -0.01819216f, 0.02237415f, -0.00164366f, -0.02138919f, -0.01891649f, -0.03231980f, 0.00140819f, 
    0.02027516f, 0.02235907f, -0.04921960f, -0.03277703f, 0.01144812f, 0.00661762f, -0.04185991f, 0.00107076f, 
    -0.00875949f, 0.01224239f, 0.00545580f, 0.02856953f, 0.01423182f, -0.03304980f, -0.03855702f, 0.03296342f, 
    0.02530587f, -0.00485214f, -0.00597689f, -0.00134082f, -0.01577736f, -0.01440895f, 0.01074031f, -0.04510271f, 
    0.00138596f, -0.03144129f, -0.02180646f, -0.01551669f, -0.00177639f, -0.01367418f, 0.02305473f, -0.01849403f, 
    -0.00818038f, -0.00466710f, -0.01168373f, 0.02320476f, -0.03522533f, -0.00453613f, -0.02032142f, -0.01934826f, 
    0.00226596f, 0.02992316f, -0.01467685f, -0.03860591f, -0.03679972f, -0.02754823f, -0.02600965f, 0.02073714f, 
    0.03029973f, 0.02720281f, 0.02388151f, -0.01678932f, -0.03867906f, -0.00473982f, -0.00743044f, 0.01216194f, 
    0.02349967f, -0.00204114f, 0.02376997f, 0.00620246f, -0.03969215f, -0.03728906f, 0.01124145f, -0.01723129f, 
    -0.02139797f, -0.00265379f, -0.04093048f, 0.02916516f, 0.01653430f, -0.04155950f, -0.02994284f, -0.03757781f, 
    -0.02909817f, -0.00340579f, -0.03556978f, 0.03077608f, -0.01009700f, -0.03035888f, 0.00180993f, 0.02370210f, 
    -0.03289432f, -0.02309527f, 0.03263957f, -0.03112479f, 0.01883124f, 0.00911177f, 0.00531556f, 0.00917136f, 
    0.00422650f, -0.00196752f, -0.00152954f, 0.03355180f, 0.00437040f, 0.03438049f, -0.02451145f, -0.03313731f, 
    0.00809535f, 0.00969762f, 0.02742065f, -0.01317236f, -0.04255844f, -0.01352483f, 0.01346318f, -0.02396487f, 
    0.01431270f, -0.03517332f, 0.03447799f, -0.01820187f, -0.03904911f, -0.02007023f, -0.03268768f, 0.01864691f, 
    0.01205106f, 0.00376315f, -0.03842334f, -0.00193725f, -0.01007855f, 0.01009028f, -0.01234790f, -0.00509587f, 
    -0.01194115f, 0.02363326f, -0.02927859f, 0.00639360f, 0.00459819f, -0.03843508f, -0.01844910f, -0.03839884f, 
    0.01565801f, 0.01040685f, -0.01050276f, -0.02433604f, 0.00727972f, -0.03658760f, -0.00779035f, 0.02703276f, 
    0.01451336f, -0.03271474f, 0.01456021f, -0.04217533f, -0.03008614f, 0.01195760f, -0.02296039f, 0.00324161f, 
    0.01861620f, -0.04183811f, 0.01015365f, -0.00949541f, -0.02521005f, -0.03203491f, 0.02326889f, 0.03105087f, 
    -0.00253365f, -0.02328742f, -0.03087302f, -0.00571329f, 0.02620955f, 0.00534221f, 0.01754344f, 0.02986530f, 
    -0.00284730f, 0.00165135f, 0.00136628f, 0.02151554f, -0.03504848f, -0.03474127f, 0.02131114f, -0.00871081f, 
    0.00937508f, 0.02132933f, 0.03368035f, 0.02703538f, -0.00142879f, -0.02812730f, -0.02380476f, -0.01124038f, 
    -0.02281956f, -0.00839734f, -0.04100901f, 0.02187335f, 0.00975639f, -0.03840491f, 0.01065099f, -0.00155130f, 
    -0.03161078f, 0.02254453f, -0.00672425f, 0.02882977f, -0.01487383f, -0.02655447f, 0.02299582f, -0.03758489f, 
    0.01659491f, 0.00032107f, -0.02224042f, 0.02830248f, 0.01800971f, -0.04317244f, -0.03810086f, -0.01317396f, 
    -0.01503828f, -0.02962391f, -0.01834413f, -0.02727361f, -0.03217751f, 0.02735800f, -0.01984610f, -0.01934765f, 
    -0.02947816f, 0.00250917f, -0.02974135f, -0.04070385f, -0.00044020f, 0.03366756f, -0.01885534f, 0.03288110f, 
    0.00385145f, -0.03158614f, -0.03668526f, 0.01610357f, -0.02664774f, -0.00487159f, 0.00569357f, 0.02829502f, 
    0.03558260f, -0.03434303f, -0.01997972f, 0.01085322f, 0.01503147f, -0.00777753f, -0.04284002f, -0.00242185f, 
    -0.01571446f, 0.03264210f, -0.02364733f, 0.00218284f, -0.04410243f, 0.02122703f, 0.01491033f, -0.03723485f, 
    -0.03997890f, -0.02763114f, -0.03051384f, -0.00831894f, -0.01879513f, -0.01552490f, -0.00804940f, -0.01189507f, 
    0.02448340f, -0.03113560f, -0.02620920f, -0.03899753f, -0.02884161f, -0.02614650f, -0.01117197f, 0.02765269f, 
    -0.01452986f, 0.01213989f, 0.00937560f, -0.04291702f, -0.04204293f, -0.01681105f, -0.01110485f, 0.02732302f, 
    -0.04000111f, -0.04372798f, 0.02792606f, -0.00596225f, 0.02729299f, 0.01190616f, -0.02386666f, 0.00595159f, 
    0.01994069f, 0.01520183f, -0.01044167f, 0.02420556f, -0.03028486f, -0.02516421f, -0.04431215f, -0.03111756f, 
    -0.01313184f, -0.01931870f, -0.01772475f, 0.01478408f, -0.00690651f, 0.00958792f, 0.01578275f, -0.02674852f, 
    0.02489628f, 0.00141316f, -0.01202227f, -0.02566201f, -0.00742543f, -0.04327183f, -0.02032744f, -0.01473028f, 
    -0.02987126f, -0.03659320f, -0.02940184f, -0.01473339f, 0.00773724f, -0.01280382f, 0.00637673f, 0.01194595f, 
    -0.01292261f, -0.00890039f, 0.02004214f, -0.03391618f, -0.02229701f, -0.01283408f, -0.03181140f, -0.03127145f, 
    0.02376034f, 0.03184161f, -0.03215085f, 0.01362134f, 0.03089592f, -0.03674518f, -0.02170729f, -0.02659480f, 
    -0.04257590f, -0.02732164f, 0.00167416f, 0.01781311f, 0.00127277f, 0.00378821f, -0.01465632f, -0.01831352f, 
    -0.02672954f, -0.03621163f, -0.01467039f, 0.01778391f, -0.04237068f, -0.02511888f, -0.02306764f, -0.03611729f, 
    0.00729694f, 0.01238850f, -0.02220833f, 0.02331807f, 0.01246025f, -0.01990871f, 0.00401653f, 0.02046517f, 
    -0.03590498f, -0.01268843f, 0.02489271f, 0.00170056f, -0.02213836f, 0.00975350f, -0.04052956f, -0.03939442f, 
    -0.03703989f, -0.00148492f, 0.01856618f, 0.02032197f, -0.00178061f, -0.02512132f, 0.02576589f, 0.02086692f, 
    -0.02234967f, 0.01392879f, -0.01904435f, -0.00811167f, 0.03328653f, -0.02494861f, -0.01769423f, 0.03270264f, 
    -0.00656471f, -0.00429657f, 0.00116053f, -0.01578469f, -0.00581223f, 0.01817514f, 0.02729299f, 0.02591755f, 
    -0.00926228f, -0.03882883f, -0.03182174f, 0.03360225f, -0.00511177f, -0.02566037f, -0.02243573f, -0.03276648f, 
    0.01122293f, -0.03030554f, -0.00868416f, 0.01206188f, 0.02195250f, -0.03980516f, 0.01443473f, -0.03290999f, 
    -0.00921388f, 0.01098626f, 0.00233247f, -0.02058860f, -0.00539639f, -0.01613674f, -0.02734519f, -0.02972603f, 
    0.03690552f, -0.00781802f, -0.04163756f, 0.03343956f, -0.03005170f, -0.02552745f, 0.01977908f, -0.01337608f, 
    0.00745563f, -0.02189270f, -0.00630114f, -0.01770342f, 0.01872267f, -0.02570216f, -0.00340229f, 0.00198796f, 
    0.02961898f, 0.00921485f, 0.03923016f, -0.01822395f, 0.00121646f, 0.02451301f, -0.04266703f, 0.00815989f, 
    0.01479025f, -0.03787327f, -0.03160334f, -0.01545784f, -0.03945285f, 0.01718127f, 0.00403091f, -0.02533793f, 
    -0.00750708f, -0.00548196f, 0.00977633f, 0.02205872f, 0.01388087f, -0.00783680f, 0.00416410f, -0.02924478f, 
    -0.03003200f, 0.03093161f, -0.00242849f, -0.02871785f, -0.02510942f, 0.01792554f, 0.02905723f, -0.03093928f, 
    -0.03327984f, 0.03020585f, -0.01825991f, -0.02120714f, 0.00938015f, 0.03230635f, -0.01713053f, -0.02132639f, 
    0.00970412f, -0.00765444f, -0.00651539f, -0.02837686f, -0.01617987f, 0.01514594f, -0.01210354f, -0.00843746f, 
    -0.03423143f, 0.00446349f, -0.04121216f, 0.00405290f, 0.01747690f, 0.03016123f, -0.02674199f, -0.01573999f, 
    0.01501892f, -0.02874434f, 0.01571820f, 0.02665519f, 0.01351889f, -0.03762352f, -0.03806729f, 0.02976514f, 
    0.02600441f, -0.03855404f, -0.00445685f, -0.01717415f, -0.02548855f, 0.03259624f, 0.00151888f, -0.01745651f, 
    -0.01396463f, -0.01937673f, 0.00660826f, 0.02099706f, 0.02931067f, -0.03763709f, 0.00291097f, -0.04174521f, 
    0.03271774f, -0.02610590f, -0.00940211f, -0.01663533f, -0.00985979f, 0.01401978f, 0.00232458f, -0.01819564f, 
    -0.00149168f, 0.01415531f, 0.02572780f, -0.00376429f, 0.02357006f, -0.03893767f, -0.00554631f, -0.01355177f, 
    0.02077812f, 0.03039731f, -0.02047045f, -0.02502345f, 0.00692603f, -0.03813292f, 0.02250490f, -0.04111590f, 
    -0.01763037f, -0.01433228f, -0.01380182f, 0.02009065f, 0.03301100f, 0.03254173f, -0.04111015f, -0.03135056f, 
    0.00123699f, 0.01239278f, -0.03609868f, 0.01661552f, 0.00869693f, 0.01066713f, -0.04063585f, -0.00135104f, 
    -0.01416793f, -0.02185962f, 0.02303061f, -0.02118147f, 0.00654560f, 0.01730883f, 0.02143331f, 0.02803789f, 
    0.02275134f, -0.04427164f, 0.02131620f, -0.00986473f, 0.03039680f, -0.01578863f, -0.03117537f, 0.02590435f, 
    0.00759935f, 0.00639345f, -0.02981379f, -0.01484266f, -0.03437003f, -0.01555149f, -0.02435372f, 0.02032674f, 
    -0.03217863f, -0.03725382f, 0.00803796f, 0.00669177f, -0.00539644f, 0.03196212f, -0.03343180f, 0.01073516f, 
    -0.02064312f, 0.02461882f, 0.02685234f, -0.00504434f, -0.03617617f, -0.03929580f, 0.00215202f, -0.04313486f, 
    0.01787865f, 0.02434197f, 0.00311793f, 0.01600570f, 0.01258778f, 0.03386947f, -0.03190850f, -0.03872080f, 
    -0.04326594f, -0.02937313f, 0.00607502f, 0.02758483f, -0.01439089f, 0.00918644f, 0.01212128f, -0.02152344f, 
    0.02954239f, 0.00297582f, 0.03283264f, -0.03606245f, -0.03700646f, 0.00222658f, -0.02740204f, -0.04307058f, 
    0.03135587f, -0.00810942f, -0.00382901f, 0.01063903f, -0.04198174f, 0.00343000f, -0.02290288f, 0.01978473f, 
    -0.03923174f, 0.00222688f, -0.02349268f, -0.01928798f, 0.01243064f, -0.00893300f, 0.01194874f, -0.00175406f, 
    0.03351113f, -0.03474407f, -0.04324295f, -0.00914609f, -0.03898123f, -0.02351194f, -0.01450878f, 0.00259013f, 
    0.03140725f, -0.00883398f, 0.01662914f, -0.02595950f, -0.02638542f, -0.02841825f, 0.03334305f, 0.01757961f, 
    -0.00573912f, -0.01991527f, -0.04381396f, 0.01720984f, -0.02891024f, -0.02074573f, 0.03355500f, 0.03127920f, 
    0.01991422f, -0.03976615f, 0.01174362f, -0.00269292f, -0.03132879f, 0.01985526f, -0.01361521f, -0.02331978f, 
    0.01129668f, -0.01187730f, -0.00438250f, 0.02288364f, 0.01199861f, 0.01491868f, 0.01486283f, -0.01025077f, 
    -0.02663075f, -0.03807004f, 0.03428511f, -0.01498834f, -0.00519656f, -0.03707154f, 0.00403920f, -0.02020721f, 
    -0.02196209f, 0.00523646f, -0.03691575f, -0.00262868f, 0.03120270f, -0.00907214f, 0.00765298f, -0.01047268f, 
    -0.04457798f, -0.03471287f, 0.01734711f, -0.00574571f, 0.01935904f, -0.00199184f, 0.00728584f, 0.00316889f, 
    0.02970485f, 0.00164680f, 0.00356391f, -0.03077037f, 0.03486015f, 0.01671590f, 0.02577193f, -0.00474012f, 
    0.01755994f, -0.02245145f, 0.00012214f, -0.03952873f, -0.03202381f, -0.02714436f, -0.00761688f, -0.01963103f, 
    0.01568762f, 0.02599359f, -0.00124456f, 0.00147410f, 0.03027154f, 0.01782159f, -0.03507132f, -0.02961966f, 
    0.00791072f, 0.02873977f, -0.01951618f, 0.00194547f, 0.00277883f, -0.03116106f, -0.01548837f, 0.02271198f, 
    0.02739693f, -0.01002343f, -0.01191921f, 0.02358022f, -0.01542617f, -0.02404248f, -0.04228077f, 0.01591731f, 
    -0.01624157f, 0.00491783f, 0.02262827f, 0.02404595f, -0.01782136f, 0.04821511f, 0.01806939f, 0.00497025f, 
    -0.01868374f, -0.02293882f, 0.02227294f, -0.02879952f, 0.01312172f, -0.03929253f, -0.03848874f, -0.00493650f, 
    0.01569239f, -0.02424015f, 0.00968731f, -0.03717829f, -0.02877891f, 0.01332165f, 0.01868954f, -0.02713535f, 
    0.01376442f, -0.00618626f, 0.01942567f, 0.02269958f, 0.01244167f, 0.00941221f, -0.02967007f, -0.02552989f, 
    -0.02886532f, -0.01102563f, -0.03258693f, -0.01676373f, 0.00457857f, 0.03301107f, 0.02542534f, -0.03122430f, 
    -0.01479218f, -0.00819909f, -0.00574634f, -0.01211737f, -0.01400298f, 0.00062018f, -0.03939965f, -0.03028471f, 
    -0.02148126f, 0.00431558f, -0.02172484f, 0.01481315f, -0.00329583f, 0.01806145f, -0.01935049f, 0.00666224f, 
    0.00192200f, -0.01545048f, -0.03332549f, 0.01317443f, -0.00779259f, 0.02469466f, 0.01291211f, 0.00132416f, 
    -0.00375523f, 0.01910676f, 0.02498086f, 0.01512024f, 0.02248372f, 0.02428453f, -0.00481916f, 0.02307627f, 
    0.01322959f, 0.01929148f, -0.01090905f, -0.00624096f, 0.01073362f, 0.00880249f, -0.03151574f, -0.01257987f, 
    -0.02722458f, 0.00114231f, -0.00983784f, -0.02569028f, -0.01253324f, 0.01043250f, 0.03882917f, 0.01081110f, 
    -0.03568795f, 0.02000839f, 0.04311610f, -0.02969639f, -0.02599078f, -0.03201302f, -0.03025102f, -0.03556622f, 
    0.00251873f, -0.03557277f, 0.00201693f, 0.00840958f, -0.03247988f, -0.00081259f, 0.01589428f, -0.02578934f, 
    0.02751367f, -0.00048517f, 0.02774383f, 0.02469216f, 0.00953043f, -0.02177464f, -0.00393520f, -0.03474982f, 
    0.00147770f, -0.03623909f, 0.01404376f, -0.03693227f, 0.02832607f, 0.01149516f, -0.03699615f, -0.04490266f, 
    0.02162709f, -0.03991535f, -0.03954397f, 0.01342344f, 0.03972898f, -0.02699024f, 0.02076333f, -0.03355630f, 
    -0.00629122f, -0.00367339f, 0.04196704f, -0.00112699f, -0.02161427f, -0.00824205f, 0.00980381f, -0.03081920f, 
    -0.00872717f, 0.00603263f, 0.00089053f, -0.02350975f, -0.01210723f, 0.02818941f, -0.01317579f, -0.02660429f, 
    -0.04817002f, -0.02065444f, -0.02016265f, -0.01677513f, -0.00849848f, -0.03193704f, 0.02037844f, -0.04497616f, 
    -0.01372007f, -0.03564212f, 0.02286160f, 0.01344175f, -0.00932395f, 0.00815414f, 0.01380381f, -0.04399396f, 
    -0.04639715f, -0.00140257f, -0.00410715f, 0.02836349f, -0.00764183f, -0.00305819f, 0.00347412f, -0.00431411f, 
    -0.01745468f, -0.04551894f, 0.00082066f, -0.00036198f, -0.02771893f, -0.01466456f, 0.00975005f, 0.02656586f, 
    0.00763784f, 0.01760453f, -0.02280262f, -0.04189680f, 0.02916672f, 0.00229862f, -0.00961490f, 0.03504812f, 
    0.04020124f, -0.02201113f, 0.01565571f, 0.01066145f, -0.03299562f, 0.00523296f, -0.02157117f, -0.01594163f, 
    0.03278632f, 0.00273213f, -0.00153610f, 0.03556605f, -0.00734697f, 0.02658950f, -0.01853355f, -0.04219289f, 
    0.00592764f, -0.04171438f, -0.02790063f, 0.03106067f, 0.03891870f, -0.03516390f, -0.02581207f, 0.01257651f, 
    0.01094169f, -0.02091994f, 0.00863988f, 0.03401276f, -0.01710919f, -0.02849039f, -0.02014266f, 0.01084282f, 
    -0.01213031f, -0.00118431f, -0.03262185f, 0.02871586f, -0.00552824f, -0.03098555f, 0.02375236f, 0.00595258f, 
    -0.02513043f, 0.01591058f, -0.01803165f, 0.01656832f, -0.01892719f, 0.00440719f, 0.00643613f, -0.02209100f, 
    0.01423793f, 0.03042052f, 0.01650620f, 0.01915872f, 0.02380294f, -0.00164198f, -0.02429380f, -0.01676762f, 
    -0.00428751f, 0.01089167f, -0.00808633f, 0.00575805f, -0.02712996f, 0.01712594f, -0.00226528f, 0.00080807f, 
    0.02420322f, -0.03015287f, -0.02908478f, -0.02529417f, -0.00214302f, -0.03796988f, -0.01000170f, -0.04179215f, 
    -0.04227113f, -0.03852852f, -0.02972272f, 0.01226789f, 0.01274060f, 0.01192055f, 0.02253167f, -0.04388959f, 
    0.00469584f, -0.01000114f, 0.03270231f, 0.03734973f, -0.00724874f, -0.03635932f, -0.01623850f, 0.00476312f, 
    0.02554107f, -0.00259677f, 0.02711848f, -0.03785066f, 0.01707549f, 0.02180382f, 0.01801911f, -0.00694066f, 
    -0.02615630f, 0.00612384f, -0.01298238f, 0.03323071f, 0.03827592f, 0.01892333f, -0.02070991f, 0.03936101f, 
    -0.02043055f, 0.00967478f, -0.00790735f, 0.03925778f, 0.00894356f, -0.00835220f, 0.00913732f, -0.00646810f, 
    0.00719191f, -0.00539852f, -0.03026548f, -0.02016038f, 0.00355780f, 0.02457696f, -0.00928787f, -0.01450231f, 
    -0.03016681f, -0.03022606f, 0.01933714f, -0.03307337f, -0.03264003f, 0.01437982f, -0.01514704f, -0.02605037f, 
    -0.03639861f, -0.00117413f, -0.04610794f, 0.03272452f, 0.01577193f, 0.02743702f, 0.01367684f, 0.01122990f, 
    0.00683231f, -0.01033054f, 0.02981024f, -0.00177940f, -0.03123893f, -0.00392961f, 0.01112077f, 0.01746353f, 
    -0.01011523f, -0.03825267f, 0.02061726f, -0.01671621f, -0.03021337f, 0.00732319f, -0.03704397f, 0.01096595f, 
    -0.00407692f, 0.02438410f, -0.00832301f, -0.04041776f, -0.02858384f, -0.01089866f, -0.01603486f, 0.04049378f, 
    0.01251313f, 0.02694359f, -0.01655201f, 0.00926304f, -0.00483346f, -0.02867114f, 0.00444966f, -0.04266103f, 
    0.00555598f, -0.04107910f, -0.00717622f, -0.01560778f, 0.00585572f, -0.03009808f, 0.01910404f, -0.02202016f, 
    -0.00732855f, 0.02408517f, -0.00377366f, -0.00248120f, -0.01536769f, 0.03408903f, 0.02431532f, 0.00172198f, 
    -0.00110935f, 0.02106868f, -0.02659482f, -0.00875963f, -0.01576749f, -0.03648751f, -0.04169378f, -0.00934250f, 
    -0.04020475f, 0.02654774f, 0.03060885f, -0.00533222f, -0.01665707f, -0.02670640f, -0.01842617f, 0.00316959f, 
    0.00195557f, -0.01045376f, -0.00764106f, 0.00445487f, 0.01645580f, -0.03667441f, 0.03349575f, -0.03391591f, 
    0.00708731f, 0.00698797f, 0.01363160f, -0.02516063f, 0.01043022f, -0.03674627f, 0.01653197f, -0.00890536f, 
    -0.04013501f, 0.02503941f, -0.03711477f, -0.03437846f, 0.03329559f, -0.02961307f, 0.01289665f, 0.01594452f, 
    0.00198087f, -0.00629528f, -0.02782296f, -0.00808755f, 0.00167598f, 0.01589862f, -0.01537651f, -0.01723293f, 
    0.02074435f, -0.00470281f, 0.02071216f, -0.00310076f, -0.01953374f, 0.02596778f, 0.00412537f, 0.01370937f, 
    0.01456812f, -0.02700133f, 0.02630273f, 0.03497014f, -0.00764944f, -0.02724729f, 0.00348300f, -0.02907240f, 
    -0.04603679f, 0.00336393f, -0.00771581f, -0.01234871f, -0.01299728f, 0.02661341f, 0.01361928f, 0.00129187f, 
    -0.00114358f, 0.01011781f, 0.02863785f, 0.00263569f, 0.01733592f, 0.00139811f, -0.02514750f, -0.00574737f, 
    0.00965958f, 0.00141707f, 0.03012501f, 0.01397683f, 0.02034481f, -0.00487931f, -0.02410825f, -0.00750651f, 
    0.01712009f, 0.00651220f, -0.00097890f, -0.00961495f, 0.02104580f, 0.00757239f, -0.03524688f, -0.01790074f, 
    0.02925538f, -0.01511791f, 0.02517281f, -0.02702289f, -0.00875370f, 0.02431792f, -0.01033754f, 0.03286623f, 
    -0.01153091f, 0.00428848f, -0.03835933f, -0.04416122f, -0.02857081f, -0.00644736f, -0.00703731f, -0.01837592f, 
    0.02435847f, -0.02622356f, -0.02481017f, -0.00605050f, -0.02237992f, 0.02767637f, 0.03315558f, -0.01294318f, 
    0.00962656f, -0.00355219f, -0.04017671f, 0.02049167f, -0.03783782f, -0.01898573f, -0.03079889f, -0.03809333f, 
    -0.01235839f, -0.02715194f, -0.00332430f, 0.01487691f, -0.01723002f, -0.03813243f, -0.03776420f, -0.02392767f, 
    0.02952857f, -0.00375074f, 0.00359705f, -0.03527062f, -0.03259391f, -0.02906451f, 0.02216013f, -0.02593844f, 
    -0.03232136f, 0.00163587f, -0.00237138f, 0.01482964f, 0.01134046f, -0.03026129f, 0.02101958f, -0.00708484f, 
    -0.00077118f, -0.00793694f, -0.01823735f, 0.03092866f, -0.01966094f, -0.03039562f, -0.01460813f, -0.00895573f, 
    0.03396250f, -0.01276798f, -0.02310058f, 0.00951843f, 0.02877818f, 0.03252118f, 0.01348287f, 0.01870019f, 
    -0.01673071f, 0.00431857f, 0.00067251f, 0.00535112f, 0.02585883f, -0.04603980f, 0.02016925f, 0.02741233f, 
    0.02567625f, 0.01771401f, -0.01127669f, 0.01811220f, -0.03217793f, 0.00843715f, -0.03108252f, -0.02861414f, 
    0.01698657f, -0.04027572f, -0.03891114f, -0.03869852f, 0.03846135f, -0.01378626f, 0.00295084f, 0.03412770f, 
    -0.02906706f, -0.02497981f, -0.01266042f, -0.01708663f, -0.01312169f, 0.01922516f, -0.02569288f, -0.03362114f, 
    -0.04445830f, -0.03821693f, 0.02852860f, -0.00227769f, 0.02728328f, -0.02439015f, 0.00094091f, 0.02526368f, 
    -0.00665774f, 0.03387528f, 0.01613628f, 0.01910200f, -0.01743954f, -0.02129433f, -0.00023853f, -0.00918913f, 
    0.00517965f, 0.01826350f, -0.03369510f, 0.01322411f, -0.01362936f, 0.00554496f, -0.02316485f, -0.03345147f, 
    0.01804487f, 0.01847501f, 0.01542563f, 0.01306641f, -0.03109980f, -0.04455500f, -0.03015730f, -0.00663498f, 
    -0.00557923f, -0.04194293f, -0.00833337f, -0.03413340f, -0.01724544f, -0.04596224f, 0.02349861f, -0.00918944f, 
    -0.00939912f, 0.01883878f, 0.01580235f, 0.02139654f, -0.01245776f, -0.03879268f, -0.04595489f, -0.04606339f, 
    -0.03231743f, 0.00701741f, -0.03186754f, 0.00485082f, -0.03200647f, 0.01646983f, 0.00321418f, 0.02175442f, 
    0.00058647f, 0.00073947f, -0.02544215f, -0.00021337f, 0.00763472f, 0.02018095f, 0.02980753f, -0.04087876f, 
    0.00374843f, -0.03869828f, 0.00511889f, -0.00472079f, -0.01030973f, -0.01979766f, 0.01431365f, 0.02639160f, 
    0.01822716f, -0.02430755f, -0.00545143f, -0.01038660f, -0.03062692f, -0.01499932f, -0.00341940f, 0.03107900f, 
    -0.02212987f, 0.01670274f, -0.00505660f, -0.03158671f, -0.04653753f, 0.01843244f, -0.00544386f, -0.01378936f, 
    -0.01113610f, 0.00453589f, -0.02171891f, 0.00285295f, -0.04097726f, 0.01085809f, -0.04555571f, -0.04302164f, 
    -0.02793385f, -0.01749325f, -0.01856002f, -0.03637251f, -0.01612402f, 0.01033523f, -0.01841746f, 0.02225006f, 
    -0.01685343f, -0.02297023f, -0.02936672f, -0.03290327f, -0.03493341f, 0.02041337f, 0.01416640f, -0.03058409f, 
    -0.04623154f, -0.01378123f, -0.02329179f, 0.00804247f, -0.02422031f, 0.00472948f, -0.01626847f, -0.00340169f, 
    0.02304948f, -0.03109748f, -0.00088148f, -0.00114644f, -0.02224250f, -0.04419550f, 0.02829966f, -0.03503427f, 
    0.01723982f, 0.01488543f, 0.01744571f, -0.02967202f, -0.04520388f, 0.00878726f, 0.03062069f, -0.02495517f, 
    -0.03076396f, -0.03028739f, -0.04484633f, -0.04090060f, 0.00382350f, -0.03632725f, 0.02189485f, 0.03531326f, 
    -0.01775911f, 0.03514092f, -0.03076837f, 0.00878711f, 0.00081904f, 0.02858556f, -0.00297649f, 0.01613739f, 
    -0.00704212f, 0.02216617f, -0.02395524f, 0.01178402f, 0.01574532f, 0.01443800f, -0.00522249f, -0.01199585f, 
    -0.04051531f, -0.01608561f, 0.01824997f, 0.02144212f, -0.02028220f, -0.04183391f, -0.02262489f, -0.01711594f, 
    -0.03605107f, -0.03445956f, 0.02801430f, -0.04493240f, -0.04115164f, 0.02564892f, 0.04305151f, 0.02521059f, 
    0.00648301f, 0.01719601f, -0.01361287f, 0.01221606f, -0.00516050f, -0.02088961f, -0.02449271f, 0.01247412f, 
    -0.04785996f, 0.00848240f, -0.02111530f, -0.00754585f, 0.02728176f, -0.02941633f, 0.03024585f, 0.02359040f, 
    -0.01686635f, -0.03917335f, 0.01503845f, -0.00746831f, -0.01957927f, 0.01948808f, -0.01213627f, 0.02302741f, 
    -0.04281868f, -0.00959160f, -0.02818920f, -0.02895363f, -0.02219890f, -0.02557905f, 0.02108929f, -0.02912007f, 
    -0.02265081f, 0.00976104f, 0.00229799f, -0.04622499f, -0.03280111f, 0.03211826f, 0.01117685f, -0.00972772f, 
    -0.04551412f, 0.03057328f, -0.03859488f, -0.03900024f, -0.02247995f, 0.02017603f, 0.00568329f, -0.02468540f, 
    -0.02452720f, -0.03738905f, -0.00025949f, -0.03847218f, 0.00026461f, -0.00365345f, 0.00180219f, 0.01721155f, 
    -0.03280938f, 0.01296574f, -0.04026788f, -0.03537276f, -0.01003376f, -0.00449968f, -0.03453578f, -0.03236210f, 
    -0.04094480f, 0.01727580f, -0.03607579f, -0.03625117f, -0.03999108f, 0.02489414f, -0.03861618f, 0.03010206f, 
    0.01683151f, 0.01185995f, -0.04115031f, -0.04378302f, 0.00974374f, 0.03291113f, 0.01640288f, 0.01188746f, 
    0.02270615f, -0.01457831f, 0.00166762f, -0.03894066f, 0.01481839f, -0.04730794f, 0.02784098f, -0.00551848f, 
    -0.02189148f, 0.02467036f, 0.02069485f, -0.02189098f, 0.02809975f, -0.00372701f, -0.04088025f, -0.02898120f, 
    0.03131099f, -0.04742790f, 0.01956895f, -0.03281345f, 0.03375403f, 0.01376422f, 0.00984885f, 0.02386354f, 
    -0.02617568f, -0.03773768f, -0.00597252f, 0.00960975f, -0.04654561f, -0.03274251f, -0.01631390f, 0.02334460f, 
    0.00348405f, 0.03956165f, -0.02851988f, -0.03600564f, 0.02744547f, 0.02730409f, 0.02331953f, 0.01831132f, 
    0.02451295f, -0.02190368f, 0.01990052f, -0.03639160f, -0.01680888f, -0.02433406f, -0.01997793f, -0.00414011f, 
    -0.02527171f, -0.03567915f, 0.01468961f, 0.00155521f, -0.02272426f, -0.01298428f, -0.03380520f, 0.02952419f, 
    -0.04226243f, 0.01326823f, 0.01293516f, 0.02841974f, -0.00427426f, -0.04051991f, -0.03752912f, 0.03283721f, 
    -0.04705980f, -0.01170637f, 0.01549590f, -0.02171685f, -0.00599943f, -0.00310621f, 0.02526138f, -0.04527093f, 
    0.02863466f, -0.03860565f, 0.00695062f, -0.02830597f, 0.01885026f, -0.00746484f, 0.01229622f, -0.01134211f, 
    0.00401326f, -0.02568269f, -0.00748645f, 0.02028509f, -0.01656120f, -0.01345476f, 0.01007827f, -0.01887822f, 
    -0.04116912f, -0.04741442f, -0.03524886f, -0.00728526f, 0.02315374f, -0.01953070f, -0.00345261f, 0.01479432f, 
    -0.03048043f, -0.01980310f, -0.04334493f, 0.02348562f, 0.00585990f, -0.00680991f, -0.03434967f, -0.01156684f, 
    0.00715070f, -0.00093879f, -0.01544773f, -0.00358828f, -0.02597238f, 0.00049324f, 0.02581307f, -0.02644246f, 
    -0.03783130f, -0.00182175f, -0.01265265f, 0.02499969f, 0.01357814f, -0.04166991f, -0.01245156f, 0.01855065f, 
    -0.03804762f, -0.02334376f, 0.02069085f, 0.01283787f, 0.01855482f, -0.01868395f, 0.00638911f, -0.00448661f, 
    -0.04327304f, -0.02062197f, 0.03325292f, -0.01625398f, -0.00954990f, -0.00661248f, 0.02777954f, -0.00181943f, 
    0.00648371f, 0.01140812f, 0.00264647f, -0.02007678f, -0.04236870f, -0.02765886f, -0.01155396f, -0.03368570f, 
    0.00589846f, 0.01628519f, -0.02543164f, 0.01598138f, -0.02850575f, -0.02631707f, -0.02327522f, 0.00932604f, 
    0.01581126f, 0.03248937f, 0.03451756f, 0.02001218f, -0.03606181f, -0.01214981f, 0.02940328f, -0.03973151f, 
    -0.03876673f, -0.02566237f, -0.03545063f, 0.00823937f, -0.01313535f, 0.00446856f, -0.03124302f, -0.01389595f, 
    -0.02222441f, 0.02409923f, 0.00631781f, -0.01869188f, 0.00212393f, -0.04424018f, 0.01062050f, 0.00807365f, 
    0.02117646f, 0.02284122f, 0.00488006f, 0.01542283f, -0.02761735f, -0.03010908f, -0.04077669f, -0.04611798f, 
    -0.02664997f, 0.00841734f, -0.03266696f, 0.00638623f, 0.02107519f, -0.04200700f, -0.00566700f, -0.02069836f, 
    0.00915510f, 0.02498395f, -0.03748918f, -0.01249720f, -0.03976258f, 0.02043473f, -0.00783939f, -0.02840529f, 
    -0.01779474f, -0.02051021f, -0.00073256f, -0.00685045f, -0.03862623f, -0.00733553f, -0.03660339f, -0.03812408f, 
    -0.02818519f, -0.02421056f, 0.02227280f, 0.01956950f, -0.02489275f, -0.03991929f, 0.01327238f, 0.02839094f, 
    -0.02376845f, -0.03823668f, 0.01013048f, -0.03811980f, 0.01993965f, -0.00663911f, -0.04737568f, 0.00371199f, 
    0.02707779f, -0.03609513f, 0.01040489f, 0.01656871f, 0.01907520f, -0.00628255f, 0.00117794f, 0.01383051f, 
    0.02482102f, -0.02613596f, -0.01873639f, 0.02999749f, 0.00259177f, -0.01078454f, 0.01036192f, -0.00378034f, 
    -0.01628982f, 0.02807329f, -0.03495616f, -0.03326721f, 0.02267524f, 0.00250171f, -0.02593998f, -0.00720456f, 
    -0.03368658f, -0.01804553f, -0.04796410f, -0.02161454f, -0.02177328f, 0.01168025f, -0.04124302f, -0.04535146f, 
    -0.03989597f, -0.02200640f, -0.00580259f, 0.02513157f, -0.00316864f, -0.01613003f, -0.01315870f, 0.02523976f, 
    -0.01287708f, -0.00551062f, -0.02090464f, 0.01367783f, 0.01919904f, 0.02163888f, 0.02629011f, 0.01826441f, 
    0.00016786f, -0.01913687f, -0.04877065f, -0.01340670f, -0.02869584f, -0.04079027f, -0.04451820f, 0.01234483f, 
    -0.01082207f, 0.00821144f, 0.01427672f, -0.02033461f, -0.01923214f, 0.02712296f, 0.01452479f, 0.01223201f, 
    0.00494312f, -0.03468893f, -0.04313688f, 0.01768060f, -0.03517705f, -0.01340529f, 0.00414065f, -0.02925981f, 
    0.01237858f, -0.02988920f, 0.00198898f, -0.04323358f, -0.04336051f, -0.04733271f, -0.00248543f, -0.03539392f, 
    0.01317662f, 0.01884491f, -0.02095062f, 0.02088970f, -0.04115640f, 0.01107845f, -0.00034434f, 0.02762376f, 
    -0.01295906f, -0.01535918f, 0.01552777f, 0.02262037f, -0.02471865f, -0.03219426f, -0.04571646f, -0.00234934f, 
    -0.04397124f, 0.00115798f, -0.03370407f, -0.04325393f, -0.01072740f, -0.02989491f, -0.00286696f, -0.00943608f, 
    -0.03061272f, 0.02355989f, -0.02155749f, -0.03877065f, 0.02917744f, 0.01900854f, -0.01966892f, -0.03207741f, 
    -0.01339641f, 0.01577049f, 0.01137365f, 0.02250577f, 0.00622392f, -0.03978428f, -0.02578127f, -0.03406636f, 
    -0.01940469f, -0.01310759f, 0.01895897f, -0.01030023f, 0.00530201f, 0.02476946f, 0.01523275f, 0.00633441f, 
    -0.00152977f, -0.03690103f, -0.03059792f, -0.03778678f, -0.04262245f, -0.03498090f, -0.01833337f, -0.00552830f, 
    -0.04658309f, -0.01880128f, 0.01429334f, -0.01928991f, -0.02898439f, -0.02081838f, 0.01458668f, -0.03394806f, 
    0.02173413f, 0.00300265f, -0.00950342f, -0.00201370f, 0.01947556f, 0.01262708f, -0.01957157f, 0.00033500f, 
    -0.00131028f, -0.04117131f, -0.01505824f, -0.00592282f, -0.03449740f, 0.02123983f, -0.01302475f, -0.04180215f, 
    -0.03735087f, 0.02292000f, 0.00913600f, 0.02099134f, 0.02241307f, 0.00972148f, 0.02130313f, 0.01848545f, 
    -0.04072511f, 0.01416389f, 0.00577945f, -0.02921966f, 0.00583628f, -0.00513549f, -0.02616188f, 0.01401240f, 
    -0.33123970f, 0.19088727f, -0.18401664f, 0.06459537f, -0.05779973f, 0.19687341f, 0.11902098f, 0.12523472f, 
    -0.01814971f, -0.02568983f, 0.05638770f, 0.00528963f, 0.00024827f, -0.03143974f, 0.11791574f, 0.03446506f, 
    -0.00288237f, 0.06908322f, -0.04280017f, -0.00381943f, 0.10584544f, 0.47102222f, -0.04663561f, -0.13456212f, 
    -0.30828395f, 0.08225229f, 0.14264639f, -0.02636502f, 0.01922646f, -0.05610064f, 0.02601921f, 0.04259651f, 
    0.00664663f, -0.04080067f, -0.02424898f, -0.03661709f, -0.02141365f, 0.11944383f, -0.15534267f, 0.01885244f, 
    -0.08781834f, -0.07311483f, 0.07059062f, -0.02332541f, -0.12355566f, 0.13906239f, 0.13161696f, 0.03337771f, 
    -0.03455623f, 0.01478724f, 0.03830869f, 0.03648809f, 0.00693395f, 0.09808062f, 0.04505049f, 0.01833661f, 
    0.01976477f, 0.04173628f, 0.07726363f, 0.02788773f, 0.10880632f, -0.13563563f, 0.17508760f, 0.09663109f, 
    0.09376136f, -0.04535001f, 0.04649954f, 0.03614078f, -0.03168773f, 0.10288281f, 0.04940532f, 0.06194634f, 
    0.04478942f, 0.02043342f, -0.03777892f, 0.05774773f, -0.09283077f, -0.06794227f, -0.05831938f, 0.13052127f, 
    -0.23562711f, -0.04616748f, 0.14498375f, 0.06958286f, 0.35173917f, 0.08044136f, 0.00709879f, 0.05301092f, 
    0.06966031f, -0.05211465f, -0.02659771f, -0.06726494f, -0.00891902f, -0.04556338f, -0.02585452f, -0.05085899f, 
    -0.02532907f, -0.01437828f, -0.03990443f, -0.00405242f, -0.17420889f, -0.09406135f, 0.02392952f, 0.22957315f, 
    0.07821061f, -0.00889308f, -0.01325281f, 0.11718293f, 0.05043180f, -0.02026606f, 0.09529520f, -0.05129603f, 
    0.08704137f, -0.00368881f, 0.05833536f, 0.13321619f, 0.05228032f, -0.02721698f, 0.00609292f, -0.01406917f, 
    -0.12689045f, -0.08007929f, 0.05473851f, -0.03458750f, 0.14421965f, -0.25414586f, -0.00889488f, 0.02790218f, 
    -0.13223732f, -0.06568316f, -0.02462776f, 0.04263021f, -0.05596860f, -0.02331329f, -0.04389823f, 0.02838163f, 
    0.11696851f, 0.05519639f, 0.11405483f, 0.03813364f, -0.67651063f, 0.37028074f, -0.09942488f, 0.14191015f, 
    -0.09714122f, 0.20880055f, 0.07306729f, 0.06370154f, -0.02043691f, -0.04166282f, 0.04285772f, 0.00097905f, 
    -0.00576608f, 0.08033396f, 0.03176186f, 0.04056369f, 0.09351161f, 0.13973059f, -0.05046065f, -0.03444270f, 
    0.24986732f, -0.15555272f, 0.05010875f, -0.07185345f, 0.19390513f, 0.04036857f, -0.16533066f, 0.05806615f, 
    0.04144959f, -0.09001326f, -0.10140118f, -0.02048528f, 0.09893689f, 0.00498618f, 0.04272310f, -0.03028101f, 
    -0.12541525f, -0.01334111f, -0.08758676f, 0.02648206f, 0.04063218f, 0.06691365f, -0.10877296f, -0.32438368f, 
    0.11307053f, 0.05516988f, -0.10355031f, 0.11133223f, -0.18305530f, -0.02852470f, 0.08919579f, 0.05810473f, 
    -0.01276953f, -0.06384511f, 0.11017939f, 0.06751284f, 0.00164684f, 0.06575178f, 0.08087653f, 0.02032081f, 
    0.38515031f, 0.09342021f, -0.13526902f, 0.08326732f, 0.01883490f, 0.25676149f, -0.01646626f, -0.02765471f, 
    -0.09767415f, 0.09217591f, 0.14561693f, 0.07093930f, 0.06548680f, 0.10372216f, -0.02908085f, 0.13224269f, 
    -0.20477593f, 0.08603855f, -0.01753857f, 0.18694536f, 0.07453065f, 0.02324039f, 0.06640126f, 0.00142314f, 
    0.19135609f, 0.06252534f, -0.09980803f, 0.01799764f, 0.06526607f, -0.02677019f, -0.07925124f, 0.01004430f, 
    0.02381488f, 0.17686585f, 0.15706939f, 0.03207370f, 0.05009389f, 0.05562806f, 0.00823234f, 0.00222901f, 
    0.16349348f, 0.01944584f, -0.04292631f, -0.14100046f, 0.07892234f, -0.04910967f, -0.03754722f, 0.04785053f, 
    -0.03909904f, -0.02960509f, 0.01539523f, 0.03439531f, 0.10612343f, 0.02677439f, 0.09708107f, 0.09216721f, 
    0.00542546f, -0.06084776f, -0.05809737f, 0.14831722f, 0.31053698f, 0.00938892f, 0.26427042f, -0.42024949f, 
    -0.40105960f, -0.07752871f, 0.06624229f, 0.03489070f, -0.04090874f, -0.01973818f, -0.13694553f, 0.04895065f, 
    0.01887413f, 0.01109797f, -0.00946194f, -0.07782176f, -0.05092864f, 0.09513043f, 0.08568062f, 0.05639412f, 
    0.20308654f, 0.01493139f, 0.01957055f, 0.05824231f, -0.25336081f, 0.22150990f, 0.07902674f, 0.01388328f, 
    -0.03407498f, 0.03036145f, 0.00464610f, 0.01913951f, 0.04246027f, -0.01604432f, 0.03789447f, 0.08570868f, 
    0.04549409f, 0.03404989f, -0.04207907f, 0.05784104f, 0.16133225f, 0.04947058f, -0.17378139f, -0.17249614f, 
    0.18441446f, -0.00994507f, -0.10283928f, 0.09561398f, 0.03549716f, -0.09165844f, -0.03356532f, -0.12748276f, 
    0.04714601f, -0.00671455f, 0.06826439f, 0.03972922f, 0.04602172f, 0.00165567f, -0.01934888f, 0.08383744f, 
    0.29074335f, 0.07349471f, -0.04851851f, -0.24323353f, 0.20144163f, 0.06681117f, -0.03783279f, -0.01141650f, 
    0.13418484f, 0.10557520f, 0.02264538f, 0.00797722f, 0.08871783f, 0.02383622f, 0.04828546f, 0.02550277f, 
    0.10349520f, 0.10743181f, -0.00488713f, 0.04124314f, -0.11344758f, 0.10363891f, -0.10463416f, -0.04858665f, 
    0.08212242f, -0.02474947f, 0.02582765f, -0.05753422f, -0.05477248f, 0.07539084f, 0.13557971f, 0.03560368f, 
    -0.08027963f, -0.03701929f, 0.01237413f, 0.02752898f, -0.06690746f, 0.09417075f, -0.10141880f, 0.15944290f, 
    -0.00975766f, -0.36591130f, 0.01031220f, -0.11953423f, -0.09644242f, 0.03083276f, 0.16967548f, -0.04147084f, 
    -0.00698020f, -0.00291399f, 0.03398531f, 0.07707805f, 0.02563393f, -0.02263495f, 0.02417699f, -0.15470663f, 
    0.04327321f, -0.07078629f, -0.07839108f, -0.05394730f, -0.01776028f, 0.17009002f, 0.19665010f, -0.24936739f, 
    -0.42816252f, 0.13431157f, 0.15066496f, 0.02634177f, 0.08469236f, 0.07388885f, 0.07875352f, -0.01780831f, 
    0.01239320f, -0.06561442f, 0.01021930f, 0.02280037f, -0.01338162f, -0.06708286f, -0.00160582f, 0.04473060f, 
    -0.02399834f, 0.24899727f, 0.00591662f, -0.06801520f, 0.08773355f, 0.10601681f, 0.01423063f, -0.08755872f, 
    -0.05494146f, -0.06632037f, 0.10821003f, 0.04216176f, 0.03544546f, 0.08556463f, 0.04875877f, 0.05705662f, 
    0.00482531f, -0.00854616f, -0.01781166f, 0.18286756f, -0.11752488f, -0.37877706f, -0.07075630f, -0.11318073f, 
    -0.34656134f, -0.00563947f, 0.07934390f, -0.05943507f, 0.00433777f, -0.10648511f, -0.07448656f, 0.04265897f, 
    0.00708423f, -0.03698993f, -0.00885239f, -0.02767489f, 0.01302071f, 0.08785988f, -0.12573522f, -0.05201523f, 
    0.07930347f, 0.33798966f, -0.15980202f, -0.21477255f, -0.08765484f, 0.05848215f, 0.00765949f, -0.08689234f, 
    0.01060653f, 0.05981776f, -0.05209614f, 0.06939164f, 0.07493028f, 0.12302908f, 0.07195476f, 0.21689333f, 
    -0.06544626f, 0.10512119f, 0.01933296f, 0.03706511f, -0.49282977f, 0.16949561f, -0.01297356f, 0.02354547f, 
    0.12450400f, 0.14717892f, 0.03046449f, 0.05066882f, 0.03200239f, -0.01618119f, 0.13810062f, 0.05146731f, 
    0.02845313f, 0.06624535f, -0.02561858f, 0.04569640f, 0.12599804f, 0.01537907f, -0.01972715f, 0.13495950f, 
    0.03479093f, -0.02217689f, -0.07719149f, -0.08934633f, 0.03472412f, 0.01396193f, 0.00181453f, -0.05263800f, 
    0.10561640f, 0.00062359f, -0.05942415f, -0.11056193f, 0.03868466f, 0.00120153f, -0.07479577f, -0.13756673f, 
    -0.11447542f, -0.09719972f, -0.16718386f, -0.05068204f, 0.12371623f, -0.76952070f, 0.10565172f, 0.28716192f, 
    0.21281306f, -0.13055499f, -0.02891790f, -0.01706307f, 0.01014948f, -0.11155864f, -0.10317019f, -0.01361093f, 
    -0.00412608f, -0.00342227f, 0.03475267f, 0.08322276f, 0.00521386f, 0.05067199f, -0.09779371f, 0.06790476f, 
    0.07030701f, 0.44162008f, -0.00884535f, -0.30027679f, -0.07129810f, 0.15717334f, 0.12296191f, -0.06768373f, 
    0.04095920f, 0.13349207f, -0.04114594f, 0.03930345f, 0.08290794f, -0.01165562f, -0.06673824f, 0.07229055f, 
    -0.01604233f, 0.05077459f, 0.13659817f, 0.09882009f, 0.12974927f, -0.11848231f, -0.10392463f, 0.01229053f, 
    0.09590984f, -0.00684954f, 0.13745044f, 0.08988970f, 0.00007979f, 0.09739498f, 0.00044807f, 0.10195431f, 
    0.06392663f, -0.09638583f, 0.03899213f, -0.07646759f, -0.09250122f, 0.04317079f, -0.00174663f, 0.01887662f, 
    0.03717926f, 0.02916799f, 0.13774805f, -0.04506084f, -0.28448373f, 0.07707527f, 0.17432116f, -0.08892865f, 
    -0.02174120f, 0.07119045f, 0.13018711f, -0.00996875f, -0.03674474f, -0.04089633f, 0.06979616f, -0.01575143f, 
    0.07623675f, -0.10005154f, 0.06829423f, 0.07086690f, 0.21909736f, -0.20468526f, -0.03077682f, 0.33085498f, 
    0.00015074f, -0.03489184f, 0.08282968f, 0.11063286f, -0.05319091f, -0.04163354f, -0.05866537f, 0.01119817f, 
    -0.05426168f, -0.04963118f, -0.14139588f, -0.08579517f, -0.02928131f, 0.08759775f, 0.00223217f, 0.07014422f, 
    0.06720959f, -0.17824788f, -0.08362240f, 0.13136783f, 0.00369155f, 0.06789036f, 0.04154050f, 0.01604035f, 
    -0.01058056f, 0.03247746f, 0.02958965f, -0.04183400f, 0.04271795f, -0.00327974f, -0.01353817f, -0.09956511f, 
    -0.09178472f, -0.01102118f, -0.13043942f, -0.02763453f, 0.10120107f, 0.15175793f, -0.07987185f, -0.01909110f, 
    -0.23532316f, 0.12053826f, 0.13441169f, 0.03816408f, -0.02409562f, 0.08114746f, 0.04486572f, 0.01854278f, 
    -0.06221239f, 0.06110010f, 0.03291659f, 0.15553780f, 0.02378703f, -0.00476314f, 0.03276579f, -0.03296538f, 
    0.03862251f, -0.18407504f, 0.03877168f, -0.12623145f, -0.22164169f, -0.01381828f, -0.08502758f, 0.09002151f, 
    -0.04665101f, 0.14872421f, 0.00665135f, 0.05181779f, 0.05428896f, 0.09614981f, 0.08127799f, -0.00597197f, 
    0.00198378f, -0.07557000f, -0.04434336f, -0.02974270f, 0.36459324f, 0.00712019f, -0.33080876f, 0.19864544f, 
    0.13946198f, 0.02564695f, 0.12984997f, 0.02333488f, 0.00051754f, 0.00507114f, 0.03621015f, 0.00457839f, 
    -0.00506482f, -0.02452557f, 0.14219782f, 0.09898371f, 0.10281210f, -0.00802019f, -0.02648699f, 0.14036611f, 
    0.08062637f, 0.10672701f, -0.11037720f, -0.14396407f, -0.14746785f, -0.02244720f, -0.02247304f, 0.07448867f, 
    -0.04287963f, 0.02908267f, 0.07178818f, 0.06282561f, 0.02209854f, 0.05637126f, 0.11611281f, 0.03349233f, 
    -0.01876725f, -0.01741487f, 0.01549468f, 0.04685157f, 0.01800983f, 0.01739942f, -0.11718038f, 0.03917200f, 
    0.11314890f, 0.01157748f, 0.02483998f, 0.09293175f, -0.01819035f, -0.07393648f, -0.04832352f, -0.13106914f, 
    0.09318711f, -0.08185700f, -0.09578834f, -0.06270429f, -0.02671008f, 0.07418813f, 0.05710803f, 0.12683383f, 
    0.08928014f, 0.08048424f, -0.07169040f, 0.00307443f, -0.22449645f, -0.01268923f, -0.11385898f, -0.10457257f, 
    -0.03508968f, 0.00347958f, -0.02515058f, 0.01214375f, 0.03276612f, -0.00841895f, -0.02951554f, -0.00582123f, 
    -0.02645139f, -0.00562332f, -0.00739432f, -0.04128342f, 0.36397484f, 0.08918961f, 0.03837295f, 0.18202482f, 
    -0.21270624f, 0.00121141f, 0.16312529f, -0.03191845f, 0.14405268f, -0.06979785f, -0.03546319f, 0.07114676f, 
    -0.22305229f, 0.03354465f, 0.03760996f, 0.02370550f, 0.16695984f, -0.09318335f, 0.09669605f, -0.06870439f, 
    0.09170210f, 0.36516616f, -0.12968384f, -0.02428428f, 0.03290943f, -0.02168321f, 0.10980976f, -0.03554200f, 
    -0.01333490f, -0.02273637f, 0.06681117f, -0.02448821f, 0.13666272f, 0.12812994f, 0.00349968f, -0.02828064f, 
    -0.08939654f, 0.03723659f, 0.09195984f, 0.13621253f, 0.24526185f, -0.14847478f, 0.20685351f, 0.06533208f, 
    0.15215063f, 0.03198460f, 0.04284015f, 0.03859114f, 0.01379160f, 0.04110908f, -0.00193546f, 0.02827945f, 
    0.00808527f, -0.07003411f, 0.00033776f, 0.03932429f, 0.02673249f, -0.01033418f, 0.01761291f, 0.00353413f, 
    -0.36470857f, -0.18694022f, -0.04085103f, -0.00112749f, -0.08013767f, -0.00919845f, 0.05369451f, -0.02520076f, 
    -0.00745512f, -0.11248963f, 0.01882772f, 0.04792361f, 0.06987458f, -0.08102098f, -0.12403808f, 0.05408496f, 
    -0.11649842f, -0.09665421f, -0.03073456f, -0.06428578f, -0.06477974f, 0.20516098f, -0.15598372f, 0.03808026f, 
    0.29023826f, 0.08332378f, -0.05806962f, -0.09159613f, 0.08631788f, 0.11952851f, 0.02621293f, 0.14824249f, 
    0.00394833f, 0.02554748f, 0.07536580f, 0.02009989f, -0.04429489f, 0.00184108f, 0.06053627f, -0.09847999f, 
    0.09112495f, 0.05164642f, 0.04790123f, 0.01709259f, 0.01388561f, -0.03326797f, -0.10400045f, -0.02401902f, 
    0.02116827f, -0.02960595f, -0.12535296f, -0.03273641f, 0.01327128f, -0.13972391f, 0.05747069f, -0.04000976f, 
    -0.04214265f, -0.11419462f, -0.07155923f, 0.05114757f, -0.59820974f, 0.28629321f, 0.06459514f, -0.05042448f, 
    0.26325360f, 0.01816674f, 0.09862293f, -0.01189824f, 0.15136606f, 0.01851761f, 0.00186027f, 0.02513648f, 
    -0.00223850f, -0.10855926f, -0.00992907f, 0.02188719f, 0.04258939f, 0.02795427f, -0.05987028f, -0.05299143f, 
    -0.22681141f, 0.33555195f, -0.02127166f, -0.03631380f, 0.16367455f, 0.09363430f, 0.04752115f, 0.07179669f, 
    0.07219109f, -0.00559972f, -0.05842816f, -0.00851380f, 0.02551740f, -0.05966034f, -0.00597333f, -0.08087966f, 
    0.08057713f, -0.02528713f, 0.07641611f, -0.07374122f, 0.11046269f, 0.14575243f, -0.14235148f, 0.12698497f, 
    0.26724875f, 0.00189625f, 0.07988904f, 0.10303571f, 0.06160786f, -0.09587846f, 0.12488946f, 0.00273499f, 
    0.15707287f, -0.05347893f, 0.11369296f, 0.08786771f, -0.09534671f, -0.10152487f, -0.04110291f, 0.03879076f, 
    0.06518241f, -0.09931282f, -0.03466851f, -0.19905965f, 0.00074521f, -0.08533997f, 0.00093477f, 0.03673207f, 
    0.00815234f, 0.08179160f, 0.10158774f, 0.06050684f, -0.00135686f, 0.10937420f, 0.08281444f, -0.02048063f, 
    0.08464570f, -0.01350681f, 0.03169296f, 0.03284808f, -0.09995626f, 0.04178261f, 0.12921572f, 0.09882453f, 
    0.55370569f, 0.10616985f, 0.09348794f, -0.03064204f, 0.02636913f, 0.07337213f, 0.11406041f, -0.10474303f, 
    -0.00436187f, 0.05950388f, 0.06362667f, 0.00788440f, 0.10030586f, -0.07466336f, 0.01646752f, -0.02918828f, 
    -0.00108388f, 0.10224803f, 0.04674745f, 0.29047403f, 0.45828918f, 0.07603160f, -0.02435643f, 0.16536611f, 
    -0.02476357f, 0.06190561f, -0.02906350f, -0.06909726f, -0.04560803f, 0.06834394f, 0.00268129f, 0.00977576f, 
    -0.08779138f, 0.05600191f, -0.02155437f, -0.02829115f, 0.16971934f, 0.11051722f, 0.04846891f, 0.01502181f, 
    0.05722219f, -0.07622251f, 0.06576148f, -0.07937630f, 0.02498343f, -0.08351543f, 0.15619570f, 0.07633359f, 
    0.09587781f, 0.03850332f, -0.04977137f, -0.00435138f, 0.01567122f, -0.01951393f, 0.14469628f, -0.00881431f, 
    -0.29979879f, 0.02805213f, -0.04584913f, -0.21566077f, -0.30913490f, -0.07786421f, -0.01853026f, 0.14443792f, 
    0.07047474f, -0.00868646f, 0.01507465f, -0.06340215f, 0.05469815f, -0.00362992f, -0.11929774f, -0.03046226f, 
    -0.03448747f, 0.02599000f, -0.09724165f, 0.11197529f, 0.21386255f, -0.29580599f, -0.25126702f, -0.02549935f, 
    0.10688224f, -0.10730264f, 0.07068097f, 0.01833697f, -0.04711457f, -0.07859313f, 0.02547759f, -0.02878571f, 
    -0.06936485f, 0.04793961f, 0.05395842f, -0.07895045f, -0.09553598f, 0.14103247f, -0.02254450f, 0.04380579f, 
    0.09003097f, 0.19489264f, -0.20327699f, 0.20676361f, 0.03704300f, 0.17806789f, -0.03887755f, 0.16025917f, 
    0.03128143f, 0.19169699f, -0.02966054f, 0.08828089f, 0.08819883f, -0.06128547f, 0.04514968f, -0.03057046f, 
    0.04155714f, 0.05096468f, 0.05295260f, -0.04192650f, -0.15813817f, 0.06477675f, 0.00508628f, 0.10958264f, 
    -0.30295017f, 0.07904462f, -0.02267373f, 0.12689085f, 0.02902491f, 0.07153603f, 0.08003050f, -0.04415349f, 
    0.03082871f, 0.05140509f, -0.13836513f, 0.14231971f, -0.06774808f, -0.08868200f, 0.01191571f, 0.00398228f, 
    0.20909853f, 0.18960087f, -0.03308652f, 0.14234915f, 0.15938677f, 0.09286948f, -0.02785570f, 0.08348963f, 
    0.02394334f, -0.01712562f, 0.07767171f, -0.02301370f, -0.02681194f, -0.01989419f, -0.00856674f, 0.02902968f, 
    0.07914593f, 0.04289529f, -0.01689086f, -0.01373813f, 0.38638544f, 0.26425239f, 0.00928934f, 0.12452117f, 
    0.02361948f, -0.06043077f, -0.10354014f, -0.06303596f, -0.06637975f, -0.01407815f, 0.09042321f, 0.06940150f, 
    0.03843876f, -0.04408767f, -0.06433889f, -0.05123336f, 0.09445640f, 0.03865083f, -0.04661920f, 0.00329980f, 
    -0.42974028f, -0.04400358f, 0.02376013f, 0.06852111f, -0.01022166f, 0.05149667f, -0.01081301f, 0.09711912f, 
    -0.05222294f, -0.00571163f, -0.01313152f, 0.08294744f, 0.02160325f, -0.09695065f, 0.01874105f, -0.01163527f, 
    -0.01551062f, -0.02316943f, 0.05682404f, -0.05766743f, -0.34346354f, 0.53585649f, 0.01814413f, 0.13628273f, 
    -0.54025853f, -0.03093233f, -0.00725672f, 0.10018417f, 0.04001015f, -0.00707293f, 0.00577302f, 0.11262493f, 
    0.09331352f, 0.10862176f, -0.01706627f, -0.06669927f, -0.00159810f, -0.13056961f, 0.06747510f, 0.06507151f, 
    0.04693186f, -0.14771239f, 0.02607899f, 0.24340795f, 0.16317840f, 0.06677580f, -0.04586358f, 0.04661904f, 
    -0.07052779f, -0.01812352f, 0.12647456f, -0.07108940f, -0.00864078f, -0.11436503f, 0.10734393f, -0.02314883f, 
    -0.00600123f, -0.01227363f, -0.06640798f, 0.02548303f, -0.34204882f, 0.45698822f, -0.12542093f, -0.02527846f, 
    0.23667251f, 0.00488065f, -0.05698995f, -0.02185477f, 0.02168806f, 0.02512977f, -0.00093122f, 0.01885138f, 
    0.06044401f, 0.02761452f, 0.02774731f, 0.01347059f, 0.04295412f, 0.00042051f, 0.07255775f, -0.12145737f, 
    0.17876717f, -0.13082944f, -0.05162100f, -0.09010004f, -0.12284783f, -0.01713888f, -0.04343290f, 0.13521589f, 
    0.03098254f, -0.00653847f, 0.09106646f, 0.07955147f, 0.14848994f, 0.01815051f, -0.01758239f, 0.05923200f, 
    -0.00780147f, 0.02361354f, 0.06703270f, 0.03945354f, -0.05682754f, 0.17728749f, 0.09014002f, -0.16868466f, 
    -0.05394514f, 0.06047881f, 0.12412469f, -0.02503273f, 0.06161304f, 0.02628258f, -0.07281476f, 0.05021551f, 
    -0.00209714f, 0.03476447f, 0.07029168f, 0.03540717f, 0.06396978f, -0.02613331f, 0.01638466f, -0.06003974f, 
    -0.31132129f, 0.09720080f, 0.01676001f, -0.01126064f, 0.16466261f, 0.05277042f, -0.04074943f, -0.01432025f, 
    0.01788144f, -0.07787840f, -0.04618802f, 0.00583982f, 0.03195581f, -0.03023276f, 0.05576969f, 0.01337387f, 
    -0.06688175f, 0.06215969f, 0.06522240f, -0.01235665f, 0.05731652f, -0.13088521f, -0.02881049f, -0.11879881f, 
    -0.05807396f, -0.00492266f, 0.02777062f, -0.00352384f, 0.08683782f, 0.02832005f, 0.01306975f, -0.02098847f, 
    -0.00185967f, -0.05628550f, 0.08486591f, -0.05524958f, -0.08977716f, 0.01740455f, -0.01300374f, 0.02465789f, 
    -0.26041320f, -0.05233753f, -0.11218797f, -0.02929569f, -0.05879833f, -0.06945772f, 0.01547342f, -0.02200695f, 
    -0.01615998f, -0.05494614f, -0.02254419f, 0.04613119f, 0.06237349f, -0.00650396f, 0.11475233f, 0.16262427f, 
    -0.03965834f, -0.02497073f, 0.00112472f, 0.07093927f, -0.04746509f, -0.10348982f, 0.00755519f, 0.00324475f, 
    0.00015132f, 0.07929723f, 0.06043473f, 0.02088338f, 0.06993701f, 0.15691923f, -0.06786355f, -0.05826692f, 
    -0.05815053f, -0.04217725f, 0.08295385f, 0.02637159f, 0.02509828f, -0.04574582f, -0.04144813f, 0.05005445f, 
    -0.26303455f, -0.23899303f, -0.03141714f, -0.05504316f, -0.20920824f, 0.01232177f, 0.01036760f, 0.04435423f, 
    -0.01341026f, -0.02831735f, -0.07439084f, 0.07005447f, 0.04901589f, 0.11307316f, -0.06403081f, 0.03602260f, 
    0.04969849f, -0.04688966f, -0.00414807f, 0.04356577f, 0.04577609f, 0.09898444f, -0.38450712f, 0.08886537f, 
    0.11147693f, 0.00762228f, -0.01315110f, 0.06757082f, 0.04803523f, -0.00279818f, 0.05752969f, -0.00838801f, 
    0.12038660f, 0.04785011f, 0.04723211f, -0.00478211f, -0.01382739f, 0.09348388f, 0.03395080f, 0.08295717f, 
    0.07782157f, 0.23530400f, -0.18033774f, 0.05769742f, 0.07640036f, 0.02296298f, -0.02796894f, -0.00181251f, 
    0.05108166f, -0.07281194f, -0.06480873f, 0.01433487f, 0.06226008f, 0.02496840f, 0.08340621f, 0.10157004f, 
    0.01347444f, 0.09622235f, -0.05694466f, 0.01043511f, 0.10041091f, 0.14378969f, 0.06856652f, 0.11283298f, 
    0.04298837f, 0.16735184f, -0.04534553f, 0.02718173f, 0.14701939f, 0.00106791f, -0.03569759f, 0.05988032f, 
    -0.02060073f, -0.00462195f, 0.05065650f, -0.03545243f, 0.08417379f, -0.00289356f, -0.01741061f, -0.05823220f, 
    0.20433226f, 0.34540460f, -0.03014065f, 0.19288148f, 0.14572267f, -0.01419805f, 0.00780529f, 0.08913522f, 
    -0.02176029f, 0.05486693f, 0.03621525f, -0.02340508f, 0.04900935f, -0.06134762f, 0.14230849f, 0.02271878f, 
    0.07666451f, 0.18218441f, 0.02009266f, 0.14803487f, -0.32384974f, 0.00266499f, 0.17083366f, 0.21820050f, 
    0.27874979f, 0.10169851f, 0.05247979f, 0.13782252f, -0.02671853f, 0.14677025f, 0.00106573f, 0.07527094f, 
    0.08608947f, 0.08134334f, 0.07613279f, -0.01570730f, 0.07507927f, 0.02681349f, -0.00868729f, -0.01982722f, 
    0.27737659f, -0.09604370f, -0.12822068f, -0.12067871f, -0.09726158f, 0.06914434f, 0.01956873f, 0.03459619f, 
    0.06630319f, -0.06100287f, -0.11740354f, 0.11906403f, 0.08779437f, -0.01360554f, -0.06526109f, 0.05987063f, 
    -0.03983108f, 0.06731517f, -0.04014670f, -0.01381852f, 0.25058562f, 0.15878077f, -0.04887752f, 0.14425837f, 
    0.18016201f, 0.01351827f, -0.05066876f, 0.05253170f, -0.03195719f, 0.07748106f, 0.06096403f, 0.03025058f, 
    0.06988550f, -0.12540355f, 0.07556819f, 0.07282901f, 0.05008717f, 0.02329289f, 0.08681085f, -0.00097231f, 
    -0.31456375f, 0.18083420f, -0.05938550f, 0.06123034f, 0.03904707f, 0.03528674f, -0.03748297f, -0.08189117f, 
    -0.04376523f, 0.10650707f, 0.13126007f, 0.10267915f, 0.03285325f, 0.01579291f, 0.04850622f, -0.08655344f, 
    -0.02154293f, -0.10142533f, -0.01598821f, 0.18039103f, -0.32449368f, 0.01041430f, 0.08023228f, 0.21077897f, 
    -0.23456159f, -0.06459922f, 0.15953322f, -0.07381410f, 0.10061684f, 0.05219689f, 0.08154181f, -0.04150709f, 
    0.01114377f, 0.01019857f, 0.16531967f, -0.05344828f, -0.04327528f, -0.03089022f, -0.08460864f, 0.06706499f, 
    0.19895309f, -0.04564139f, -0.00984049f, 0.01732316f, 0.07717996f, 0.04278183f, 0.09253845f, 0.08732199f, 
    0.02893627f, -0.02378916f, -0.03319085f, 0.00592228f, 0.01402642f, -0.07699874f, -0.02963292f, 0.00458768f, 
    0.19109839f, 0.03314929f, 0.13326937f, 0.06576916f, -0.30745840f, -0.03857122f, 0.13819049f, -0.07202172f, 
    -0.21690391f, 0.04415697f, 0.04937630f, 0.02160161f, -0.00589007f, 0.05019274f, -0.12268703f, 0.00705028f, 
    0.03909210f, -0.11161853f, 0.12857570f, 0.00683104f, -0.04575212f, -0.03030371f, 0.03453912f, -0.01001140f, 
    -0.08311313f, -0.24421012f, 0.05703021f, -0.01770339f, -0.13209054f, -0.03703422f, 0.05778950f, -0.00652295f, 
    -0.02041398f, 0.00829992f, -0.06208462f, -0.07402460f, 0.11332673f, 0.01140464f, 0.12289770f, -0.01651104f, 
    0.11956262f, -0.05744293f, 0.02021723f, 0.15790240f, 0.57204366f, 0.10769190f, 0.09906278f, 0.23718786f, 
    0.15342717f, 0.04703522f, 0.08925807f, 0.13774487f, 0.02207702f, 0.17389046f, 0.00306701f, 0.00525635f, 
    0.12256993f, 0.05049501f, 0.01844276f, 0.01980512f, 0.15348938f, -0.04559275f, 0.10448376f, 0.08702012f, 
    0.37624207f, 0.42702189f, 0.14378391f, 0.16509211f, -0.01169829f, 0.02340163f, 0.02483289f, 0.18987246f, 
    0.01800869f, 0.11650324f, -0.06602211f, -0.03341579f, -0.00140814f, -0.00705454f, -0.00613175f, 0.08060157f, 
    0.00532379f, 0.04542347f, 0.05292617f, -0.01468505f, 0.34058493f, 0.13520949f, 0.01721467f, 0.10729409f, 
    0.01886366f, 0.11937426f, 0.04827157f, -0.03928813f, -0.07240850f, 0.06446400f, 0.03804286f, 0.05955758f, 
    0.00585543f, 0.00740297f, 0.08710596f, 0.19949315f, -0.02379644f, -0.03951390f, -0.03381291f, 0.09302421f, 
    -0.38453862f, -0.18966353f, 0.11154263f, 0.01322675f, -0.28108260f, -0.10189096f, -0.07731350f, 0.01015235f, 
    0.10137133f, -0.08200750f, 0.04516415f, -0.02646959f, 0.05813680f, 0.01174435f, 0.02657563f, 0.04588126f, 
    0.09774324f, -0.02695954f, -0.00826190f, 0.10441024f, 0.04666001f, -0.29565254f, -0.04023566f, 0.14843179f, 
    -0.18184206f, 0.04461798f, 0.07653014f, 0.06324953f, -0.08378967f, -0.01600778f, -0.01635842f, 0.05246704f, 
    -0.06101391f, 0.05523009f, 0.05761379f, 0.11212503f, 0.01539777f, 0.04639719f, 0.07819550f, 0.07197127f, 
    0.19542775f, 0.00504777f, -0.12495620f, 0.09679917f, 0.14483409f, 0.08157025f, 0.00420709f, 0.04905897f, 
    -0.03658909f, 0.09312168f, -0.04033294f, -0.00654130f, -0.05156321f, 0.00900188f, 0.16277768f, 0.05429605f, 
    0.04741924f, 0.00388278f, -0.05976748f, 0.16669109f, -0.09246389f, -0.12685618f, -0.00931105f, -0.03557393f, 
    -0.31484991f, 0.07233237f, -0.02124079f, 0.04217656f, 0.01179133f, -0.06835483f, 0.05260068f, -0.02375145f, 
    -0.01351134f, -0.03222163f, -0.03340284f, 0.02419481f, -0.01145136f, 0.00250930f, 0.09260369f, 0.15503761f, 
    -0.20296180f, -0.04405119f, 0.00219008f, -0.03442286f, -0.19032454f, -0.04986446f, 0.08074891f, 0.03484730f, 
    0.13502422f, -0.03380265f, -0.12176327f, -0.15501881f, -0.08561296f, 0.09914634f, -0.04347380f, 0.11189507f, 
    0.00699169f, 0.03366615f, -0.02002437f, 0.03853484f, 0.12801541f, -0.00404299f, 0.03013666f, 0.10225828f, 
    0.18023612f, 0.00686166f, 0.04489714f, -0.05124887f, -0.04158734f, 0.03691484f, 0.03145476f, -0.10031974f, 
    0.08522549f, 0.08947948f, 0.01272490f, 0.07272795f, 0.10246057f, -0.01799414f, -0.07475596f, 0.12590656f, 
    -0.17348878f, -0.04298054f, -0.10925276f, -0.12729098f, -0.14856645f, -0.03087205f, 0.01012123f, 0.05182377f, 
    -0.01098859f, -0.03180254f, -0.14404626f, 0.01690462f, 0.09409619f, -0.03709996f, 0.03439718f, -0.06126240f, 
    -0.02165280f, 0.02530404f, 0.04108382f, -0.00974698f, 0.40850434f, 0.21104562f, 0.21912533f, 0.13095529f, 
    0.06598020f, 0.00999704f, -0.01222289f, -0.01794201f, 0.11871141f, -0.02581464f, 0.06476182f, -0.03089070f, 
    -0.02197818f, 0.05880482f, 0.00210833f, 0.00368826f, 0.03629487f, 0.01679542f, -0.01967393f, 0.08335055f, 
    -0.13223781f, -0.06707283f, 0.07900018f, 0.05544396f, 0.06072981f, 0.08420618f, 0.03390354f, 0.06942779f, 
    0.09044848f, 0.09619024f, 0.06834973f, -0.03097469f, -0.04518760f, -0.04733202f, -0.04528605f, 0.04442434f, 
    -0.00072562f, -0.02212257f, 0.07126299f, -0.04893216f, -0.09070389f, 0.17332214f, -0.08880842f, 0.00124148f, 
    0.01557248f, 0.12720172f, -0.08307771f, -0.05675576f, 0.00407101f, 0.01745975f, -0.08616988f, -0.02447631f, 
    0.03281924f, 0.01005451f, 0.05223313f, 0.02926052f, 0.07547710f, 0.01952691f, 0.04488779f, 0.03469459f, 
    -0.19945747f, -0.29365039f, -0.02106926f, 0.00475186f, -0.18826546f, 0.05327494f, -0.04503163f, 0.03564941f, 
    0.00877674f, -0.03282403f, 0.01362103f, 0.04122186f, -0.02240614f, 0.06905165f, -0.05479463f, 0.07270102f, 
    0.01328158f, 0.03474592f, 0.09233169f, 0.03573553f, 0.28854975f, 0.13287567f, -0.08411666f, 0.04171405f, 
    -0.00260182f, -0.02285710f, 0.00547104f, 0.06876364f, 0.02416022f, 0.06809427f, -0.01087188f, 0.12990211f, 
    0.03831794f, 0.06763265f, 0.13066421f, 0.02634490f, 0.00032084f, 0.02535697f, -0.02893367f, 0.07993048f, 
    -0.24001029f, 0.12339328f, -0.13604251f, -0.08296012f, -0.05307389f, 0.04912522f, -0.08739347f, -0.00104229f, 
    0.10685917f, -0.01508513f, 0.05746451f, 0.07421443f, 0.06047917f, 0.00675815f, 0.15953505f, -0.06838479f, 
    0.03241938f, -0.10608766f, 0.11809155f, -0.07725970f, 0.04056421f, -0.31540391f, -0.11623836f, -0.01087144f, 
    -0.16862920f, -0.02074180f, 0.08677858f, 0.10896809f, 0.01510533f, -0.01119500f, 0.05372751f, -0.00222533f, 
    -0.04442036f, 0.06605792f, 0.09808824f, 0.10974003f, 0.02669818f, 0.04083260f, 0.02951981f, 0.09424603f, 
    0.01868865f, 0.00435625f, -0.00794891f, -0.01462915f, 0.01073230f, 0.00642917f, -0.03827154f, -0.01587949f, 
    -0.02051032f, -0.00754787f, 0.02623358f, -0.01342192f, 0.01501346f, -0.04281773f, -0.02790142f, -0.00279823f, 
    -0.01181024f, 0.00154381f, 0.02088464f, 0.00844426f, 0.02343159f, -0.03187194f, 0.00462004f, -0.02401234f, 
    0.01909109f, 0.03223989f, 0.00453822f, -0.01184185f, 0.02009138f, 0.02450648f, 0.00043994f, 0.00202937f, 
    0.01148908f, -0.02910375f, 0.01612072f, 0.01060024f, -0.00338450f, 0.01862557f, 0.02190951f, -0.00802291f, 
    -0.00992709f, 0.00552524f, -0.01364946f, -0.04497013f, -0.04560913f, 0.02700325f, -0.03514668f, 0.01105305f, 
    0.00258585f, 0.00575568f, -0.01299768f, -0.03053806f, 0.00680800f, -0.03918000f, 0.02660340f, -0.02205316f, 
    0.00235332f, 0.03008673f, 0.00858027f, 0.03082689f, 0.01144257f, 0.00448205f, 0.00637736f, -0.04142990f, 
    -0.03078306f, -0.01901753f, -0.03560990f, 0.03693615f, -0.02297278f, 0.00429620f, -0.02222239f, 0.03337407f, 
    -0.04378561f, -0.01360530f, 0.02514653f, 0.03344196f, 0.00178228f, 0.02313724f, 0.02741890f, 0.01135459f, 
    -0.01469835f, -0.02736174f, -0.02108474f, 0.01641426f, 0.00798573f, 0.02419792f, 0.02763474f, -0.03681900f, 
    -0.03410007f, 0.03211412f, 0.00170966f, 0.02308087f, -0.03698098f, -0.04489956f, -0.00932518f, -0.00522702f, 
    -0.01498681f, 0.03264403f, -0.00856151f, 0.00948038f, -0.00262350f, 0.02368615f, -0.03288201f, 0.01688493f, 
    0.00103290f, -0.03731762f, -0.02596473f, -0.02427241f, -0.00123143f, -0.04091890f, 0.02441546f, -0.01467939f, 
    -0.03145317f, 0.01314201f, 0.02941193f, -0.03514249f, -0.01773115f, 0.01973394f, -0.00155966f, -0.00132321f, 
    0.01124085f, 0.02878330f, 0.02749217f, -0.04276485f, 0.01065253f, -0.04284277f, -0.00500426f, -0.00170855f, 
    -0.04050362f, -0.03018638f, -0.03584558f, -0.00503615f, 0.00156297f, -0.01378690f, -0.02834594f, 0.00115516f, 
    -0.01704708f, 0.00918003f, -0.00734692f, 0.03004425f, 0.01043020f, -0.00161776f, -0.01357574f, -0.01351964f, 
    -0.01223194f, 0.01097691f, -0.00020257f, -0.02164809f, -0.01669039f, -0.03787920f, -0.03222268f, 0.00734093f, 
    -0.00952526f, -0.01965417f, -0.00055677f, 0.01818551f, -0.02474857f, 0.02221637f, -0.03263225f, -0.01278849f, 
    0.02509633f, 0.00144555f, -0.02835455f, 0.02345506f, -0.03633505f, -0.01208847f, -0.03475356f, 0.03835036f, 
    0.02377301f, -0.02825985f, -0.02850030f, 0.01887123f, -0.02373319f, 0.02425305f, -0.00746721f, 0.01758227f, 
    0.00505942f, 0.00783669f, -0.02357128f, -0.00340222f, 0.00062228f, -0.02155911f, -0.04343724f, -0.00891281f, 
    -0.01086460f, -0.02676737f, -0.00147699f, 0.01274059f, 0.00961194f, -0.02575188f, -0.01203178f, -0.02597556f, 
    -0.03216510f, 0.02992519f, -0.00120534f, -0.01805288f, 0.01698229f, -0.00494342f, 0.01160533f, -0.02484565f, 
    0.00071247f, 0.02542034f, -0.01377124f, -0.03091291f, -0.02717729f, 0.00061217f, -0.00101829f, -0.02229205f, 
    -0.01274785f, -0.01098631f, -0.03736424f, -0.01180030f, -0.02994375f, 0.01269237f, 0.01895596f, -0.01190061f, 
    0.01139988f, 0.00612530f, 0.00984844f, 0.02449943f, 0.02614619f, 0.02085568f, 0.01233193f, 0.02828494f, 
    -0.00288645f, 0.01829343f, -0.03801089f, -0.01393910f, -0.01855752f, 0.00293690f, -0.02105878f, -0.02980625f, 
    -0.01076545f, 0.00715631f, 0.00707682f, 0.00976784f, -0.00830352f, -0.04407898f, -0.03961153f, -0.00973818f, 
    -0.01681023f, 0.00693741f, -0.03899067f, 0.01284165f, -0.01535287f, 0.03494279f, -0.00181056f, -0.04226947f, 
    -0.04058299f, 0.02770419f, 0.02640708f, -0.00698214f, -0.02442477f, -0.03351042f, 0.02985917f, 0.02176898f, 
    -0.02697892f, -0.00530702f, 0.00161616f, 0.00277725f, -0.00650539f, -0.01755298f, -0.00225488f, 0.02352895f, 
    0.00326664f, 0.00116313f, -0.03242961f, 0.00582334f, -0.00436720f, 0.01041949f, 0.01968487f, 0.02067977f, 
    -0.01600168f, -0.04188817f, 0.01096723f, -0.00781392f, 0.01462197f, -0.00154257f, 0.00605837f, -0.03253776f, 
    -0.03590301f, 0.00099934f, -0.01646450f, 0.00299570f, 0.00130741f, -0.03815095f, 0.02029818f, -0.01520274f, 
    -0.00436459f, 0.00078884f, -0.03715480f, -0.02921174f, 0.03176572f, 0.01423283f, 0.01107258f, -0.04094838f, 
    0.01366696f, -0.01862391f, -0.01788329f, 0.00733105f, 0.00820937f, 0.01890645f, -0.02449644f, 0.00617037f, 
    0.01648861f, 0.01439199f, -0.02408909f, -0.00709074f, -0.00296758f, -0.02057443f, -0.01525576f, -0.01649042f, 
    -0.04080640f, -0.02415009f, -0.03425142f, -0.02951274f, -0.02178621f, 0.01112821f, -0.00211207f, 0.02814295f, 
    -0.02191934f, -0.01015558f, -0.03921426f, 0.01307882f, 0.00263368f, -0.02992242f, -0.04314338f, 0.00894358f, 
    -0.00387603f, 0.01815759f, 0.02629226f, -0.03001908f, -0.03457278f, -0.00718873f, -0.01432301f, 0.00418360f, 
    -0.02790181f, -0.02754157f, -0.01116885f, -0.01530289f, -0.00511075f, -0.02857016f, 0.00910742f, -0.02068390f, 
    -0.01725115f, 0.02684012f, -0.00591146f, 0.02135157f, 0.00517785f, 0.00593992f, -0.01024450f, -0.01259166f, 
    -0.03018836f, 0.00652698f, -0.03216775f, 0.01024623f, 0.01112131f, -0.03002789f, 0.01829753f, 0.00945608f, 
    -0.00670700f, -0.01006342f, 0.00152014f, -0.01841642f, -0.03369445f, 0.00874436f, -0.00666345f, -0.02707820f, 
    0.03307598f, -0.03954253f, 0.01425270f, -0.01046448f, 0.00814584f, -0.02768197f, 0.02597530f, -0.00102371f, 
    0.00837165f, 0.01170989f, -0.00847185f, -0.04653623f, -0.03018924f, -0.03275550f, 0.00784103f, -0.04237564f, 
    -0.00585426f, 0.03461856f, 0.02361498f, -0.02000917f, 0.03247141f, -0.04202187f, -0.03034509f, 0.01506074f, 
    -0.02681137f, -0.03154784f, 0.00092045f, 0.03004206f, -0.03660746f, -0.02834431f, -0.00555265f, 0.01762905f, 
    0.02740579f, -0.02248213f, -0.03109956f, -0.03752545f, 0.00452466f, 0.02092779f, -0.02083440f, 0.02917575f, 
    -0.04266174f, 0.03243043f, -0.00063779f, -0.03589538f, -0.02482051f, -0.04168157f, -0.01383927f, 0.01589731f, 
    -0.02508898f, -0.01168394f, -0.00279007f, 0.00843857f, -0.02826777f, -0.03190797f, 0.01113956f, 0.00867600f, 
    -0.02828229f, 0.00435375f, 0.01608869f, -0.03673168f, -0.00712065f, -0.00218772f, -0.01066620f, 0.01427962f, 
    0.02613167f, -0.00783830f, -0.00320661f, -0.04969708f, -0.01982017f, 0.02821418f, 0.01751406f, -0.02823040f, 
    0.02063894f, -0.00061171f, 0.01945274f, -0.00134501f, -0.02804710f, 0.01288305f, 0.01314831f, 0.00541871f, 
    0.01809670f, 0.03853636f, -0.00361818f, 0.00821725f, 0.03302959f, -0.02514993f, 0.00991158f, -0.00586647f, 
    -0.02068050f, 0.03313755f, -0.03315298f, 0.00736718f, -0.02089088f, -0.02990248f, -0.00666823f, 0.00029910f, 
    -0.03698017f, 0.02724912f, 0.00336291f, -0.01804620f, 0.00438974f, -0.00579437f, 0.02508138f, -0.01077328f, 
    -0.02727916f, -0.02065884f, 0.01988165f, 0.00611751f, 0.01674278f, -0.01497956f, 0.02069879f, 0.03334457f, 
    0.02023665f, 0.01899370f, -0.01837697f, -0.03114228f, -0.03854395f, -0.01703068f, -0.01905532f, -0.02517397f, 
    -0.02321917f, 0.00887604f, 0.02504964f, -0.02378419f, -0.02197410f, 0.00277465f, 0.00600615f, 0.03381977f, 
    0.00662425f, 0.01822720f, 0.00189065f, -0.04461746f, -0.02884197f, -0.00374396f, -0.00268731f, -0.01190430f, 
    0.02672516f, 0.01134621f, -0.01917687f, 0.02503588f, 0.03511071f, 0.02284770f, -0.03373317f, 0.00764790f, 
    -0.01844637f, 0.02996041f, 0.01982895f, 0.00744042f, 0.00457802f, -0.00821587f, -0.03181521f, -0.00006718f, 
    -0.02876120f, -0.00651708f, 0.02732961f, 0.02506361f, 0.00581711f, 0.03355461f, -0.00002347f, 0.01496325f, 
    -0.03802532f, -0.00176890f, -0.02010109f, 0.01899862f, -0.00261182f, -0.00066397f, -0.04144960f, -0.02646797f, 
    -0.01174822f, -0.02404272f, 0.02313060f, 0.01349395f, 0.00273977f, 0.00233205f, -0.01075194f, 0.00365566f, 
    0.02705726f, 0.02881737f, 0.02978550f, -0.02332744f, 0.02273879f, -0.03840008f, 0.01900295f, -0.01079038f, 
    -0.00644937f, -0.00904927f, 0.00909741f, 0.00709883f, -0.02727282f, -0.03627595f, -0.00645817f, -0.02266776f, 
    0.02320347f, -0.02812944f, 0.03004704f, -0.02730058f, -0.04081771f, -0.01120753f, 0.00183696f, 0.01594633f, 
    -0.01089226f, 0.00504630f, -0.03851516f, -0.03948259f, -0.00671439f, -0.02480452f, 0.01040154f, -0.03860752f, 
    -0.01044435f, -0.00510880f, -0.03786043f, 0.01020846f, -0.00814433f, 0.02621510f, -0.03734120f, 0.00350644f, 
    -0.03167178f, -0.03376329f, 0.02310709f, -0.01785126f, -0.01713719f, 0.02856741f, 0.03019376f, -0.00959493f, 
    0.00866956f, -0.02642427f, -0.03482271f, 0.02275020f, -0.03659565f, 0.01550064f, 0.00761109f, -0.00554069f, 
    -0.03276167f, -0.01067421f, 0.02682320f, -0.01219371f, 0.01195902f, 0.02385825f, -0.00839762f, 0.00520157f, 
    0.01272476f, 0.01604832f, -0.00842442f, 0.00384529f, 0.01603627f, -0.02193013f, -0.00601692f, -0.02052663f, 
    -0.03630251f, -0.02765165f, -0.04509818f, -0.03779293f, 0.02238929f, -0.02119390f, -0.00649539f, -0.01535441f, 
    0.01173411f, 0.00450499f, 0.00509947f, 0.02553247f, 0.02495904f, 0.01304606f, -0.01616294f, 0.01044929f, 
    0.01779812f, 0.00724310f, 0.01963899f, -0.04412002f, -0.03218324f, -0.01590526f, 0.00089836f, -0.03359148f, 
    -0.07644989f, -0.06922769f, 0.01409109f, 0.09951840f, 0.00804586f, -0.02826025f, -0.00162305f, 0.02638038f, 
    0.01958945f, 0.05478351f, 0.02686851f, -0.09761892f, 0.07424052f, 0.04039780f, -0.02540530f, -0.08903830f, 
    0.08496165f, 0.09086847f, 0.09545762f, 0.04141916f, 0.00514956f, 0.04359659f, -0.03667984f, 0.01056715f, 
    -0.16862269f, -0.05755858f, 0.02223383f, 0.18134105f, -0.04152496f, -0.04129612f, 0.02319421f, 0.00121987f, 
    0.10612706f, 0.15180172f, -0.09735195f, 0.04109898f, -0.10764696f, -0.14517164f, -0.10090418f, -0.07197164f, 
    -0.19937785f, 0.14459252f, 0.14417306f, 0.12067055f, -0.03124195f, 0.02484043f, 0.02298035f, 0.09842960f, 
    -0.02513928f, 0.07347746f, 0.12568578f, -0.09924304f, -0.01987976f, 0.01266094f, 0.05900287f, 0.03691563f, 
    0.03616056f, 0.06755330f, -0.02164277f, 0.00784366f, 0.33281982f, -0.19020516f, -0.16346319f, 0.02418972f, 
    -0.08911631f, 0.04205975f, -0.12230244f, -0.07023576f, 0.03283579f, 0.07795064f, 0.02342901f, -0.00654470f, 
    -0.06867278f, -0.03284276f, 0.01723022f, 0.00022668f, -0.03351387f, -0.14366987f, -0.01753833f, 0.04498503f, 
    -0.10613517f, -0.34222975f, 0.04236955f, -0.06531168f, 0.20289303f, -0.06093035f, -0.13048601f, 0.02233937f, 
    0.02551896f, 0.11522767f, 0.11129367f, -0.07969220f, -0.00446491f, -0.00026386f, -0.09204359f, 0.00394884f, 
    0.00296610f, -0.10828035f, 0.14263844f, 0.00659141f, 0.06034337f, -0.05903291f, -0.14516145f, 0.09321724f, 
    0.20085609f, 0.02709985f, 0.16836019f, -0.04514551f, -0.05750062f, 0.13143328f, 0.07395647f, -0.03132612f, 
    0.15188570f, 0.02253110f, -0.05580749f, 0.03215585f, -0.01309977f, 0.04980841f, 0.06840044f, 0.17375585f, 
    0.28886613f, 0.03844176f, -0.03965191f, -0.09798157f, 0.02939558f, 0.12071504f, 0.10332868f, 0.03909616f, 
    0.01595336f, 0.08128961f, -0.07631856f, -0.05511130f, 0.00041669f, 0.07587819f, -0.03451689f, 0.04436079f, 
    0.01672806f, -0.11129254f, 0.00143692f, -0.02429224f, 0.28986621f, -0.37490597f, -0.28641599f, -0.03103421f, 
    -0.19701788f, 0.00767609f, 0.09176262f, 0.03745756f, 0.06134332f, -0.06585589f, 0.04595859f, -0.00422094f, 
    0.05736314f, 0.02258643f, 0.02266518f, 0.10643440f, 0.13627793f, -0.06507826f, 0.06850439f, 0.08186933f, 
    -0.10090564f, 0.03595203f, 0.07063092f, 0.03375275f, 0.12163041f, -0.06917372f, -0.17695674f, 0.02557095f, 
    -0.12517591f, 0.09139623f, 0.09380171f, -0.05445198f, 0.06758767f, 0.06832159f, 0.02697478f, -0.09796402f, 
    0.07856114f, -0.07482401f, 0.06184051f, 0.10533175f, 0.11732191f, 0.14040995f, -0.00490089f, -0.24451987f, 
    -0.08704916f, 0.18685968f, 0.03907585f, 0.14920186f, 0.05667735f, 0.03518525f, -0.04055525f, -0.04310701f, 
    0.01107412f, 0.13661976f, 0.05095861f, 0.05288272f, -0.00990543f, 0.06423175f, -0.04929984f, 0.07113273f, 
    0.18119112f, -0.29338181f, -0.12481157f, 0.02469914f, 0.01631569f, 0.07975954f, 0.03769328f, 0.00923528f, 
    0.08396483f, 0.17961577f, -0.02861424f, -0.21092373f, -0.11929305f, -0.06457452f, 0.03593285f, -0.01325146f, 
    0.05549096f, 0.12058395f, 0.13633019f, 0.03589180f, 0.26709479f, -0.14066586f, 0.14046800f, -0.12716939f, 
    0.35880056f, 0.15346017f, -0.05722838f, 0.07892015f, -0.01564763f, 0.05481919f, 0.06678616f, 0.02593400f, 
    0.08450316f, -0.01694810f, -0.07609971f, 0.13081090f, 0.06127678f, 0.10021860f, 0.06117883f, 0.05273753f, 
    0.23108849f, -0.12207048f, -0.08554520f, -0.11682869f, 0.08519645f, -0.07845531f, -0.17294669f, 0.02142301f, 
    -0.03454344f, -0.01020271f, 0.04446520f, 0.03066385f, 0.05978495f, 0.02909971f, -0.02979262f, 0.06986526f, 
    -0.11289053f, -0.01159236f, -0.16668653f, 0.10021476f, -0.06718095f, 0.10967199f, 0.04873125f, 0.05602919f, 
    -0.14353795f, 0.01811520f, 0.02906192f, 0.04574288f, -0.01868314f, 0.00225132f, 0.03016972f, -0.00618726f, 
    -0.06927637f, 0.13562261f, -0.12128464f, 0.13113086f, -0.00063835f, -0.10667926f, -0.14937408f, 0.09797491f, 
    -0.26482770f, 0.21100266f, 0.00439889f, 0.12062409f, -0.01612330f, 0.18643706f, 0.02643202f, 0.06107527f, 
    0.05760842f, -0.02253482f, 0.00937523f, 0.07196884f, -0.05767583f, 0.23262642f, -0.11452814f, 0.10470100f, 
    -0.07807306f, 0.04300097f, -0.03975812f, -0.04297352f, -0.39731374f, 0.22016415f, 0.19874234f, -0.11374792f, 
    -0.25259686f, 0.09709242f, 0.05788822f, -0.04314694f, 0.05891626f, 0.02322266f, -0.00690871f, -0.03786279f, 
    0.08896170f, -0.01215635f, 0.09284231f, 0.03027741f, -0.07052714f, -0.11680650f, -0.01704343f, -0.09185037f, 
    -0.20003478f, 0.03533232f, 0.02100410f, -0.15903348f, -0.09338267f, 0.09788568f, 0.09356225f, -0.09244604f, 
    0.18401277f, 0.05150575f, 0.04224465f, 0.12418835f, -0.02717906f, 0.01400768f, 0.06914479f, 0.05960173f, 
    -0.03367801f, -0.10150336f, -0.00459981f, 0.10612968f, 0.02624007f, 0.02632268f, -0.12599646f, -0.13178031f, 
    0.03222572f, -0.08416070f, 0.05161760f, 0.09460333f, -0.00366640f, 0.11908358f, -0.01933210f, -0.03030750f, 
    -0.01862684f, 0.06622401f, -0.00054015f, -0.01509952f, 0.12523951f, 0.04942760f, 0.05508908f, -0.05099724f, 
    0.07179193f, 0.01541702f, -0.17562413f, -0.14699620f, 0.01874151f, 0.04542499f, 0.12743647f, -0.14860022f, 
    -0.01972567f, 0.02051959f, -0.08000387f, 0.09705736f, -0.04641215f, -0.10507238f, 0.04975114f, -0.09917425f, 
    -0.07063960f, 0.09626293f, -0.03634076f, -0.05298249f, -0.20525649f, 0.23788492f, 0.14503665f, -0.01333471f, 
    0.13939992f, 0.06316752f, 0.13113472f, 0.06210040f, 0.05544133f, 0.06736386f, 0.01697369f, -0.03374201f, 
    0.06344904f, 0.02999935f, -0.03518428f, -0.00226142f, -0.10926742f, 0.05952062f, 0.04671328f, 0.00091293f, 
    -0.22327299f, -0.09305523f, 0.00128981f, -0.10778701f, 0.16478112f, 0.04439172f, -0.02104494f, 0.09681316f, 
    0.09232576f, 0.00464708f, 0.15365471f, -0.00907524f, 0.06682920f, 0.09801352f, -0.07767083f, 0.07924534f, 
    -0.00983209f, -0.05319532f, 0.19421983f, -0.06724291f, -0.21418174f, 0.00650878f, -0.21467678f, -0.05961494f, 
    0.06524009f, -0.13153575f, 0.13162152f, -0.10308080f, -0.00422265f, -0.01050224f, 0.00048104f, 0.03670977f, 
    0.06504127f, 0.02189451f, 0.08050736f, -0.10143249f, 0.04748418f, 0.14629912f, -0.04771106f, -0.08197127f, 
    -0.29628667f, -0.17695704f, 0.15768756f, 0.02352844f, -0.07446740f, 0.12365907f, -0.01428967f, 0.04455338f, 
    -0.08951549f, 0.12550993f, 0.20565930f, 0.12471680f, 0.03930296f, -0.05624415f, 0.11914996f, 0.10323360f, 
    0.07290206f, -0.07744410f, -0.02152394f, 0.02261135f, -0.06404980f, -0.28635970f, -0.06507220f, -0.05010984f, 
    0.03447400f, 0.05817320f, -0.00925966f, 0.08294850f, 0.06729298f, 0.01813361f, 0.04956003f, 0.03696935f, 
    -0.01284626f, 0.02427813f, -0.01989287f, 0.07367613f, -0.00751382f, 0.05786841f, 0.00528708f, -0.04200521f, 
    0.32572591f, -0.29614440f, -0.18133821f, -0.04964610f, 0.07310098f, -0.14675114f, -0.11702956f, -0.19742396f, 
    -0.01128606f, -0.07224905f, -0.02279792f, 0.02555666f, -0.03785163f, -0.05602337f, 0.01551998f, -0.09528793f, 
    -0.04092584f, -0.04984969f, -0.10293135f, 0.05011378f, -0.60051054f, -0.09495724f, -0.47240049f, -0.05340320f, 
    0.31271145f, -0.07005080f, 0.12180392f, -0.03219008f, -0.01084909f, 0.07314342f, -0.05124352f, 0.11336295f, 
    0.08447565f, -0.08202621f, 0.08554801f, -0.08782949f, 0.03405794f, 0.05174815f, 0.01172969f, 0.00336443f, 
    0.15166265f, 0.10386467f, 0.14544894f, 0.00468047f, -0.00403588f, 0.12310492f, 0.13602495f, -0.00358157f, 
    0.03428116f, 0.04338790f, -0.03690340f, 0.06281076f, -0.05357864f, 0.01894436f, -0.04041904f, 0.11512163f, 
    0.04489293f, 0.04864232f, -0.13856408f, 0.04947359f, 0.31375632f, 0.07371378f, -0.13927157f, -0.02170380f, 
    -0.00743828f, -0.15624294f, 0.04592248f, 0.09164166f, 0.01060762f, 0.06822462f, 0.08767267f, 0.01841377f, 
    -0.05037198f, -0.02182920f, -0.02095084f, 0.10132161f, -0.03873699f, 0.02462647f, -0.06206331f, 0.04256389f, 
    -0.18052182f, 0.13311327f, 0.01124717f, 0.09030340f, -0.04049006f, 0.03639754f, 0.13014825f, 0.07459158f, 
    -0.01161276f, 0.12076215f, 0.02388249f, 0.00846846f, 0.00754351f, 0.05808617f, 0.07859808f, 0.04754855f, 
    0.02500730f, -0.00633848f, -0.04942580f, -0.02830513f, -0.10773700f, 0.04730812f, -0.19989745f, 0.02445669f, 
    0.06978816f, -0.07316089f, -0.06827995f, -0.04756036f, 0.02840466f, -0.11283731f, -0.11308474f, -0.14262480f, 
    0.08074428f, -0.05782064f, -0.06870279f, 0.00258739f, 0.09179746f, 0.04299438f, -0.04828931f, -0.07657702f, 
    0.42233935f, -0.20909984f, -0.15990329f, 0.02214998f, -0.04077504f, -0.11999130f, 0.04399954f, 0.03125817f, 
    -0.03055040f, 0.07089533f, -0.05790832f, -0.02798918f, -0.00250888f, -0.00386274f, -0.02269356f, 0.02682975f, 
    -0.02009957f, 0.02979904f, -0.12648712f, 0.09755158f, -0.24667896f, 0.17898932f, 0.11929686f, 0.19362138f, 
    0.06565929f, 0.07714263f, 0.03013436f, 0.02997518f, -0.00291833f, 0.10938872f, 0.00613129f, 0.09890167f, 
    0.07090793f, 0.03833326f, 0.04420665f, 0.04036651f, 0.00784036f, 0.12238261f, 0.02603656f, -0.02841027f, 
    0.07347382f, -0.05424339f, 0.11982848f, 0.02885928f, 0.16530783f, -0.02580682f, -0.05876295f, 0.03285853f, 
    0.09603621f, 0.00116788f, -0.03209476f, 0.03596795f, 0.02861717f, 0.01666319f, -0.04916189f, 0.02521091f, 
    -0.00112877f, 0.01627306f, 0.02116774f, 0.11075111f, 0.25493759f, 0.10668825f, 0.19834146f, -0.20477664f, 
    0.30013847f, -0.01940087f, -0.04495480f, 0.15495871f, 0.05524496f, -0.05139606f, -0.04966250f, 0.00887225f, 
    0.05120283f, -0.00374944f, -0.02194076f, 0.09806945f, 0.05706177f, 0.10026443f, 0.02919028f, -0.07104618f, 
    0.02829479f, 0.19005226f, -0.09205309f, 0.07099469f, 0.15918979f, -0.00434750f, -0.01884039f, 0.03604589f, 
    0.06961094f, 0.03358441f, -0.05829125f, -0.01736718f, 0.00297062f, -0.01985871f, 0.00991427f, 0.01711300f, 
    0.05191568f, 0.03449493f, -0.04767004f, 0.01761239f, 0.39542565f, -0.27556849f, -0.00393721f, -0.15446702f, 
    -0.01328449f, 0.05576548f, -0.00229259f, -0.05835199f, 0.07914246f, -0.01872322f, 0.09943044f, 0.08889749f, 
    -0.08893971f, -0.01146772f, 0.11304139f, 0.06746019f, 0.05430993f, 0.04144593f, -0.07645740f, 0.04417787f, 
    0.10697231f, -0.08354817f, -0.02630161f, -0.03972925f, 0.03352568f, 0.00700700f, 0.02117481f, 0.11740030f, 
    0.08142988f, -0.00157684f, -0.01221953f, -0.00544238f, 0.01694091f, -0.01062948f, 0.01682207f, 0.06569977f, 
    -0.02087566f, -0.02843300f, -0.01048110f, 0.01358624f, 0.02150805f, -0.12176844f, 0.24374911f, 0.10999555f, 
    -0.03144163f, -0.02531128f, 0.00960366f, 0.03435724f, -0.10441455f, 0.03687258f, -0.09379625f, 0.04896971f, 
    0.03332891f, 0.08314612f, -0.03045647f, -0.11573626f, -0.10334134f, 0.01645780f, -0.04160262f, 0.04340874f, 
    -0.07785549f, -0.23094101f, -0.05393499f, 0.09404122f, -0.05062748f, 0.08764932f, -0.05052208f, 0.00321885f, 
    0.04291761f, 0.05277578f, -0.05396799f, 0.02219613f, -0.00375102f, -0.05147802f, 0.00794997f, 0.08341307f, 
    0.08521953f, 0.06138533f, -0.03670153f, -0.12301368f, 0.13818915f, -0.28380418f, -0.04872070f, -0.07944770f, 
    -0.01157739f, -0.04960103f, -0.04397659f, 0.04544590f, -0.04131377f, 0.06595573f, 0.05683268f, 0.07824855f, 
    -0.03495181f, 0.01859296f, -0.01116705f, 0.06560083f, -0.00206578f, 0.05740981f, 0.06819443f, 0.02504438f, 
    0.05642246f, 0.15250805f, 0.04733828f, -0.08712784f, -0.24936372f, 0.03153920f, 0.03453528f, -0.01595188f, 
    -0.04402068f, 0.17440028f, -0.00242049f, -0.06521080f, -0.03104134f, 0.00285584f, 0.14243709f, 0.05346689f, 
    0.09255505f, 0.01902485f, 0.06842367f, 0.07013071f, -0.09221449f, -0.29927838f, 0.04007716f, -0.02081709f, 
    -0.26819569f, 0.02437778f, 0.07799204f, 0.03030770f, 0.05598523f, 0.02310230f, 0.00069084f, -0.06596012f, 
    0.05464185f, 0.03768249f, 0.01179806f, 0.08048975f, 0.08401851f, -0.00357313f, 0.02194813f, 0.05897563f, 
    0.02971436f, -0.36059743f, 0.22448505f, 0.09594451f, -0.08114005f, 0.02945385f, 0.04959730f, 0.16763343f, 
    0.07209587f, -0.07130082f, 0.09817003f, -0.01200315f, 0.03004829f, 0.04736213f, -0.07844678f, 0.04745062f, 
    0.02706881f, 0.07267191f, -0.01274174f, -0.05141776f, 0.48148921f, -0.20048900f, 0.18472773f, 0.06669258f, 
    -0.11702683f, -0.02492340f, -0.02492836f, 0.03188593f, 0.03383614f, 0.08514788f, 0.02365331f, 0.07875939f, 
    0.00128551f, -0.03161038f, -0.06259213f, 0.00383768f, -0.03314521f, -0.06304740f, 0.10233305f, 0.00350603f, 
    0.06370903f, 0.02762424f, -0.20635220f, 0.06485715f, -0.27907413f, -0.03429006f, -0.05632809f, 0.00851082f, 
    0.03318376f, 0.02180119f, 0.14893700f, 0.08336604f, -0.01147878f, 0.02595731f, 0.05228564f, 0.03907389f, 
    -0.17426589f, -0.03263708f, -0.05308696f, 0.00364097f, 0.14751256f, 0.33870390f, -0.12580034f, -0.01849036f, 
    0.16860259f, -0.03364781f, 0.00164256f, -0.04551329f, 0.04208197f, -0.01322170f, -0.06385898f, -0.01833432f, 
    -0.00881041f, 0.01559459f, -0.06590283f, 0.03584333f, 0.16910711f, 0.01537588f, 0.02530322f, 0.09729344f, 
    -0.13042162f, 0.25638101f, -0.06438814f, 0.10697339f, 0.20931514f, -0.03148270f, -0.11907345f, -0.02334458f, 
    0.15154706f, -0.11443245f, -0.07467282f, 0.01418825f, 0.07932916f, -0.02222873f, -0.02623332f, 0.05762044f, 
    0.04886330f, -0.03571352f, -0.01910292f, -0.06143985f, -0.05520029f, 0.00568374f, -0.09082123f, 0.14242552f, 
    -0.47200137f, -0.07223640f, 0.08670556f, 0.04604677f, 0.08010511f, -0.01820315f, -0.05653708f, 0.06885237f, 
    0.02248563f, 0.02320585f, 0.03333305f, -0.03385830f, -0.09809567f, 0.06326748f, 0.15272139f, -0.05273752f, 
    0.06948506f, 0.19296205f, -0.02753824f, 0.00226397f, -0.28167671f, 0.10293089f, 0.17427836f, 0.01391284f, 
    0.07238304f, -0.02607223f, 0.08049901f, 0.02901568f, -0.08847798f, -0.06638858f, -0.02647119f, 0.00010403f, 
    0.08979016f, -0.02242055f, 0.03728108f, 0.04688484f, -0.09273037f, -0.24551740f, -0.06429150f, 0.00336209f, 
    -0.08656338f, 0.08569081f, -0.00077346f, 0.10949657f, 0.01923435f, 0.07415494f, -0.11612046f, -0.00573422f, 
    0.02146540f, 0.01141362f, -0.01972150f, -0.04445260f, -0.01638649f, 0.07806605f, 0.05126907f, -0.05461975f, 
    -0.03456440f, 0.07245983f, 0.10264850f, 0.14460114f, 0.12115459f, 0.00546895f, 0.00717399f, 0.00484058f, 
    0.01824338f, 0.01415889f, 0.06375404f, 0.07116661f, 0.01078117f, -0.05080061f, 0.11396500f, 0.08156193f, 
    -0.04941854f, -0.03350987f, 0.04580732f, -0.03748755f, -0.17084457f, 0.24263844f, 0.11824355f, 0.12846673f, 
    0.21871550f, 0.06108581f, 0.01028569f, 0.04719933f, 0.03157597f, -0.04751112f, -0.13151312f, -0.03826207f, 
    0.01030709f, 0.02277187f, 0.03065176f, 0.06555776f, 0.08421987f, -0.12306571f, -0.03034711f, 0.02852730f, 
    0.13740733f, -0.23378171f, 0.06640716f, -0.02878384f, -0.11689992f, -0.03884702f, -0.04829212f, 0.05233958f, 
    -0.03883267f, -0.01996128f, 0.04933126f, -0.03115819f, -0.02630156f, 0.09596709f, -0.03412686f, 0.07559229f, 
    -0.00393344f, 0.07141597f, 0.00878871f, -0.09943145f, 0.24211064f, 0.06908108f, 0.16558395f, -0.18825746f, 
    0.25150824f, -0.09914099f, 0.01368965f, 0.03608950f, 0.01384515f, 0.08835170f, 0.06412919f, -0.04480009f, 
    -0.00543115f, 0.04417445f, 0.11150796f, -0.05401499f, 0.07987224f, 0.02481638f, -0.04724637f, -0.03381923f, 
    0.08884849f, -0.05536129f, 0.14271335f, -0.09137725f, -0.01909123f, 0.02932674f, -0.01172785f, 0.06222961f, 
    0.07793338f, -0.01696634f, -0.04720116f, 0.08086327f, -0.00254998f, 0.00337844f, -0.04196857f, 0.05306192f, 
    -0.05842383f, 0.05025183f, -0.02423334f, -0.02117326f, 0.05812540f, -0.30967066f, -0.03703821f, -0.01342248f, 
    -0.09149287f, 0.12155955f, 0.03179411f, 0.06569910f, 0.03502003f, 0.11748176f, 0.02529663f, -0.01598888f, 
    0.02192512f, -0.03996674f, 0.05142134f, 0.00357464f, -0.05832893f, 0.02248614f, 0.05300926f, -0.07126686f, 
    0.16723154f, 0.15922494f, -0.01245725f, -0.13214789f, -0.10521962f, 0.00517373f, -0.04580023f, -0.00245826f, 
    0.03644568f, -0.03367816f, 0.08717860f, -0.02170602f, -0.00817865f, 0.03436946f, 0.01603625f, -0.00790962f, 
    -0.04983707f, 0.00935644f, -0.07087769f, 0.16419497f, 0.29125246f, 0.05492519f, -0.00706353f, -0.25751853f, 
    0.18685816f, -0.05999695f, 0.04077860f, -0.00217161f, -0.06147755f, -0.01763445f, 0.03218312f, 0.02117025f, 
    0.01078882f, -0.07296990f, 0.11693725f, 0.00991746f, -0.03129224f, 0.09756396f, 0.02852334f, -0.11546307f, 
    0.16067481f, 0.21336700f, 0.23487629f, -0.03449779f, 0.06741556f, 0.00732460f, 0.15310019f, 0.00256717f, 
    0.01768071f, 0.03156840f, -0.04237758f, 0.00154262f, 0.04029644f, -0.04437784f, -0.05586091f, 0.09053516f, 
    0.00493963f, 0.07648711f, 0.10050053f, -0.09418775f, 0.36526656f, -0.06862074f, -0.16047461f, 0.10276200f, 
    -0.23585466f, -0.09225725f, -0.00601647f, 0.02790536f, 0.05816071f, -0.03154621f, 0.08977596f, -0.06153555f, 
    -0.05211078f, -0.05444132f, -0.01625076f, 0.00242825f, -0.01902754f, 0.00290485f, 0.00738133f, -0.02071849f, 
    -0.02470943f, 0.15213893f, -0.07597008f, 0.10683777f, 0.14057335f, 0.03871589f, 0.04443832f, 0.03255389f, 
    0.01234154f, -0.04944066f, -0.02353474f, -0.02786468f, -0.02764742f, 0.08772585f, 0.05041093f, 0.00629635f, 
    0.05145400f, -0.05587121f, -0.03078219f, -0.01359969f, 0.38134465f, -0.10263752f, 0.02183717f, -0.13902195f, 
    0.01425765f, 0.00175360f, -0.10411204f, -0.15831688f, 0.02648273f, 0.02697620f, 0.08851672f, -0.06018076f, 
    0.02995125f, -0.00186247f, 0.07731738f, 0.00616115f, -0.08723304f, 0.03912257f, 0.02136248f, 0.00448153f, 
    0.18675531f, 0.06833690f, 0.07794223f, -0.12594976f, -0.15067886f, -0.05894114f, -0.01104283f, -0.00750499f, 
    0.04259376f, 0.04563614f, 0.06284393f, 0.00169808f, 0.00592785f, 0.00431286f, -0.04535966f, 0.02562067f, 
    0.06980534f, 0.05620215f, -0.03245581f, 0.04307304f, -0.12706277f, 0.02352313f, 0.09040204f, 0.05654952f, 
    0.04803201f, -0.05875728f, -0.00287425f, 0.10384227f, 0.03290497f, -0.07140286f, 0.00465751f, 0.01152693f, 
    0.05221820f, -0.03331134f, 0.04971690f, 0.02332600f, 0.04388560f, -0.03266565f, -0.01072251f, 0.02499233f, 
    0.02122353f, -0.00434374f, 0.02788867f, 0.01605610f, 0.01281016f, -0.02509353f, 0.02623114f, 0.03308324f, 
    -0.00935793f, -0.03412286f, 0.02864664f, -0.04420403f, -0.02216893f, -0.02247832f, -0.00954652f, -0.01023054f, 
    -0.03405232f, -0.03167062f, 0.03276515f, -0.01903775f, -0.03230428f, 0.00111314f, 0.01698415f, 0.01252698f, 
    -0.03629028f, 0.01878913f, 0.03415046f, -0.02546402f, 0.00512876f, -0.01393433f, 0.02326956f, 0.00834879f, 
    -0.03312174f, -0.03589448f, 0.01510449f, 0.00277521f, -0.03684781f, -0.01310334f, 0.01701259f, -0.00898525f, 
    -0.03560781f, -0.02468211f, -0.03303484f, 0.00900421f, -0.01440168f, -0.01503487f, -0.02632245f, -0.04091804f, 
    -0.02831872f, -0.01076601f, 0.00141186f, 0.00508435f, 0.03125161f, -0.00124087f, 0.01268601f, 0.01347100f, 
    -0.02504629f, -0.02560660f, -0.00240659f, 0.02551045f, -0.02826078f, 0.02414037f, -0.01664370f, -0.02831895f, 
    -0.02065913f, 0.03181345f, -0.01731436f, 0.01302130f, 0.01135560f, 0.01046624f, -0.02638325f, -0.03774873f, 
    0.00605280f, 0.02300137f, -0.00844313f, -0.02133470f, 0.01088678f, -0.00784746f, 0.01332982f, 0.02531317f, 
    -0.00100594f, 0.01880205f, -0.03542398f, 0.01125496f, 0.03273076f, -0.03420506f, 0.02448596f, -0.00431137f, 
    -0.04179196f, -0.03623717f, -0.03168584f, 0.01891462f, 0.02802532f, -0.04092130f, 0.02316909f, -0.02786686f, 
    -0.00931139f, 0.01110045f, -0.01001908f, -0.00164125f, -0.03937566f, -0.01628282f, 0.02194324f, -0.04229143f, 
    -0.04127561f, 0.00000486f, 0.00139024f, -0.02698069f, 0.03293441f, 0.00429306f, 0.00086006f, 0.00278652f, 
    0.00956663f, -0.02564874f, 0.01701042f, 0.03102138f, 0.00896761f, -0.02872518f, -0.00837590f, 0.01540462f, 
    0.01674876f, -0.01547433f, 0.00699649f, -0.03405086f, -0.02746090f, -0.01897959f, -0.02468223f, -0.00790161f, 
    0.03563494f, 0.02921057f, -0.03836081f, 0.00604568f, -0.01581870f, -0.01404569f, -0.00406634f, 0.02740688f, 
    -0.01507798f, -0.02036600f, 0.03410086f, -0.00021471f, 0.02427617f, 0.02672247f, -0.00102869f, 0.03425454f, 
    0.02333261f, -0.00993923f, -0.03900956f, -0.02812489f, -0.02025810f, 0.00723828f, -0.00757703f, -0.02974755f, 
    -0.00991142f, 0.00773501f, 0.02218733f, 0.03057445f, -0.00239714f, 0.00209832f, 0.03534710f, 0.00948457f, 
    0.03192803f, -0.00366447f, -0.00273343f, 0.00528706f, -0.03151193f, 0.00731522f, -0.02161887f, -0.03431731f, 
    0.02720878f, -0.00409650f, 0.02245612f, 0.01694764f, 0.01232762f, -0.00665517f, -0.02931851f, -0.02636107f, 
    -0.00015161f, -0.01105310f, -0.03996658f, -0.03074035f, -0.02692606f, -0.01106509f, 0.02898396f, 0.00712385f, 
    0.00134541f, -0.00269284f, 0.01450898f, -0.01442820f, -0.04132834f, -0.04402561f, -0.02436695f, -0.00960042f, 
    -0.02032460f, -0.00347481f, -0.03474703f, 0.00185330f, -0.00741251f, 0.01768106f, 0.00417439f, 0.00042178f, 
    0.00253259f, 0.00303460f, 0.01935029f, -0.02187894f, 0.02060551f, 0.01359552f, -0.04194187f, -0.03643746f, 
    -0.03208303f, 0.01375256f, -0.03881378f, -0.03264033f, -0.03602467f, 0.02690858f, -0.00000905f, 0.01479567f, 
    -0.01982485f, -0.00171531f, 0.02874778f, -0.02296352f, 0.00498370f, 0.02894740f, 0.01910409f, -0.03723880f, 
    0.02179197f, -0.02597640f, 0.00105997f, -0.03038906f, -0.02211399f, -0.01593188f, 0.01802758f, -0.01074729f, 
    -0.00578088f, -0.00978116f, -0.00352997f, -0.01116648f, 0.01039839f, -0.03358892f, -0.00900741f, 0.02059320f, 
    0.01911887f, -0.02206396f, -0.00558244f, 0.02635758f, 0.03032618f, 0.01089227f, 0.03827358f, 0.00735502f, 
    0.02681378f, 0.00563559f, -0.03048336f, -0.03419493f, 0.00375904f, 0.02106684f, -0.01111546f, 0.03089819f, 
    -0.03941716f, 0.01365606f, 0.01003058f, 0.01011687f, -0.02025633f, -0.03023587f, 0.03089188f, 0.00202396f, 
    -0.02223489f, -0.00641115f, 0.00664233f, 0.01048863f, -0.03819141f, -0.02312914f, -0.02798780f, -0.01660858f, 
    -0.04105771f, 0.01177662f, 0.03248873f, -0.04238830f, -0.00452497f, -0.00681207f, -0.00898819f, -0.03556146f, 
    -0.03760213f, -0.03359209f, 0.01896857f, 0.00887467f, -0.03773778f, -0.03731675f, -0.03098610f, 0.00445214f, 
    0.00052445f, -0.01338141f, -0.00713271f, 0.01612942f, 0.03504418f, -0.03348878f, -0.01404208f, -0.03769784f, 
    -0.03988623f, -0.02566070f, 0.00734991f, -0.01643849f, -0.01264323f, -0.02649768f, 0.01339446f, 0.03289020f, 
    0.00305920f, -0.01461173f, -0.01672158f, -0.03755002f, 0.03250552f, -0.03414337f, 0.01533420f, -0.02216193f, 
    0.03918020f, -0.03529444f, 0.02991131f, -0.01316697f, -0.01678334f, 0.03201173f, -0.02071124f, 0.01584014f, 
    -0.02957272f, 0.00200773f, -0.03592833f, 0.03156117f, -0.01523713f, -0.03479883f, 0.03212414f, 0.03259471f, 
    -0.00903272f, -0.01441273f, 0.02184915f, 0.01325009f, -0.00689655f, 0.00764883f, -0.01110276f, 0.03565256f, 
    -0.03426825f, -0.01573427f, 0.03310929f, 0.03002719f, -0.01925604f, -0.00298274f, -0.03831042f, 0.01591989f, 
    -0.01876811f, -0.02132804f, -0.00297829f, 0.01778603f, -0.03496355f, -0.02320689f, -0.03555231f, -0.00964155f, 
    0.01416370f, -0.02704447f, -0.00680415f, -0.00709430f, 0.00088551f, -0.02708467f, -0.00625575f, -0.03534457f, 
    0.02833714f, 0.02341145f, -0.02875350f, -0.00556471f, 0.01885413f, -0.03466510f, 0.00398646f, -0.02450662f, 
    -0.01776012f, 0.02898435f, -0.02084934f, -0.04123110f, 0.00464311f, -0.02221083f, -0.00012938f, -0.00481459f, 
    -0.01505419f, 0.00721644f, 0.00018614f, -0.00425684f, 0.02194398f, -0.02726558f, 0.03456736f, -0.02722927f, 
    -0.00746524f, -0.04619124f, 0.00654245f, -0.03077873f, 0.02731888f, 0.01205402f, -0.01394486f, -0.01930998f, 
    -0.01937876f, -0.03672688f, 0.00526423f, -0.01797558f, -0.02105884f, 0.02949241f, 0.01314214f, 0.02670738f, 
    0.03540045f, -0.02866836f, -0.00249115f, 0.00594137f, 0.02258866f, 0.03589518f, -0.00663997f, -0.03269154f, 
    -0.03883911f, -0.03991613f, -0.02512099f, 0.00225947f, 0.03076988f, 0.00609057f, 0.01354187f, -0.02720166f, 
    0.01823883f, -0.01225917f, -0.03551374f, 0.01686398f, 0.01364992f, 0.02857912f, 0.01535600f, -0.04007459f, 
    -0.04165971f, -0.01773616f, 0.02847114f, 0.00348308f, -0.03826390f, -0.03884531f, -0.02900793f, 0.01408719f, 
    -0.03144531f, -0.01605872f, -0.00935304f, 0.03343148f, -0.00509245f, 0.01125154f, -0.00458300f, -0.04233065f, 
    0.00792709f, -0.02555445f, 0.00354818f, -0.02596178f, 0.00270634f, 0.03474813f, -0.01066372f, 0.01090478f, 
    -0.02779245f, 0.03287479f, -0.00831971f, 0.01457176f, 0.01440722f, -0.02221846f, -0.01282371f, 0.02999810f, 
    0.02323521f, 0.00545582f, -0.03264214f, -0.03913207f, 0.02880715f, -0.03033239f, -0.02998271f, -0.00241399f, 
    0.03474819f, 0.00836634f, 0.00274196f, -0.01184684f, -0.03283101f, 0.02567512f, -0.03442337f, -0.03434075f, 
    -0.00963600f, -0.01375904f, -0.02562976f, 0.00802250f, -0.01096185f, 0.01871208f, -0.01851599f, 0.03113604f, 
    -0.03101215f, -0.03159442f, 0.02833947f, -0.03470562f, -0.00364000f, 0.01082239f, 0.01373697f, -0.01991513f, 
    0.00481187f, -0.00886144f, -0.01668379f, -0.02648649f, 0.02948191f, -0.03312739f, 0.03858117f, 0.01428184f, 
    0.04137762f, 0.02905836f, -0.01954370f, 0.02597449f, -0.03816549f, -0.01178461f, -0.03169970f, 0.02590286f, 
    0.03410341f, -0.04134901f, 0.00572280f, 0.02982947f, -0.02063853f, -0.03254966f, -0.00577366f, -0.04218912f, 
    0.03151084f, -0.01339107f, 0.03022680f, -0.02260260f, -0.03849761f, -0.04269614f, -0.03865436f, -0.01507091f, 
    0.02572954f, 0.03577071f, -0.01454973f, -0.03692170f, 0.01113430f, -0.02238923f, 0.00418702f, -0.02972065f, 
    -0.04093705f, -0.00324734f, -0.01247205f, -0.02902841f, -0.01453296f, -0.03360718f, -0.01347651f, -0.00476684f, 
    -0.04106611f, -0.03381787f, -0.03736116f, 0.00494589f, -0.00206377f, -0.01935679f, -0.01480521f, 0.01754158f, 
    -0.02941643f, -0.02891395f, 0.00878511f, -0.04240669f, 0.03119358f, -0.02864885f, 0.00915829f, -0.01947192f, 
    0.01382635f, -0.00542191f, 0.02685715f, 0.02515108f, 0.03128554f, -0.01660667f, 0.02478711f, -0.03278136f, 
    0.02737213f, -0.01831496f, 0.01838651f, 0.00454528f, -0.00773064f, -0.00176422f, -0.04055407f, 0.02361531f, 
    0.02292506f, 0.00308391f, -0.02472953f, -0.03361934f, -0.03605781f, 0.00452033f, -0.00150450f, -0.02196667f, 
    -0.00893980f, -0.00521007f, 0.01659436f, -0.02911734f, -0.03513302f, 0.00999583f, 0.00324876f, -0.02073953f, 
    -0.00354087f, 0.00231154f, 0.03768336f, 0.01159345f, -0.01709151f, 0.01296449f, -0.00235997f, 0.02967731f, 
    -0.03603192f, 0.03417010f, 0.01301414f, -0.00072844f, -0.03874188f, -0.01318622f, 0.01859440f, -0.03759886f, 
    0.02132094f, -0.00253435f, -0.02018020f, 0.02301093f, -0.00532056f, -0.01386318f, -0.02982440f, 0.00058779f, 
    0.01497236f, 0.02705885f, -0.04144198f, -0.03416064f, 0.02055846f, -0.01050005f, -0.02811074f, 0.02698904f, 
    0.00184040f, -0.02222873f, -0.01391428f, -0.02036256f, -0.03444028f, 0.01757552f, 0.03271222f, -0.02756828f, 
    -0.02591924f, -0.00520347f, -0.02826040f, -0.04201194f, -0.00109274f, -0.04402973f, -0.01543542f, 0.00711506f, 
    -0.00386104f, 0.01278970f, -0.00170195f, -0.02820961f, 0.00920385f, 0.02267142f, 0.01317559f, -0.00027823f, 
    0.14836948f, 0.25037190f, 0.10563484f, 0.05089125f, 0.17582671f, -0.09636394f, 0.10241899f, -0.04694036f, 
    0.02950975f, -0.09110179f, 0.10517493f, 0.04561316f, -0.03241571f, 0.07786109f, 0.03597409f, 0.09324732f, 
    0.05408185f, 0.21072805f, 0.09561524f, 0.07517391f, -0.15833096f, -0.06458084f, 0.01349225f, 0.11590743f, 
    0.03464518f, 0.08123162f, -0.04476649f, 0.11941378f, -0.09964972f, -0.02652233f, -0.12591834f, -0.15286034f, 
    0.12489105f, 0.20354946f, 0.04237669f, 0.04083830f, -0.04521492f, -0.24425714f, -0.02017111f, -0.12456517f, 
    0.12251421f, -0.15297876f, 0.11775124f, 0.01399180f, 0.09825850f, -0.00869365f, 0.13788390f, 0.00827085f, 
    0.04036080f, -0.02602401f, -0.00202598f, -0.08196710f, -0.00689992f, -0.00576427f, 0.04246472f, -0.02286580f, 
    0.01281283f, 0.02163626f, 0.01022907f, -0.00010753f, -0.20985678f, 0.30240154f, -0.23720342f, -0.11537648f, 
    -0.04957203f, 0.13873066f, 0.04011458f, -0.07561443f, 0.00138844f, 0.11969698f, 0.08144500f, 0.06957228f, 
    -0.04017576f, -0.13515295f, 0.02125945f, 0.08272419f, 0.14506017f, -0.14006244f, 0.03108179f, 0.01737542f, 
    0.03034585f, -0.11089992f, 0.08936911f, -0.18136936f, 0.14968878f, -0.06289038f, -0.07173790f, -0.02796677f, 
    0.14426772f, 0.03469424f, 0.07458044f, 0.03623281f, -0.03421383f, -0.00027764f, 0.00161341f, 0.06998242f, 
    0.02194849f, -0.00993039f, 0.08525992f, 0.04866147f, -0.37872851f, -0.01883233f, 0.07983030f, 0.04191909f, 
    0.03222141f, 0.00098076f, -0.00601564f, 0.00852960f, -0.09419069f, 0.03909633f, -0.07901091f, 0.02454616f, 
    0.14982074f, -0.09006488f, 0.10055309f, 0.04715781f, 0.00816529f, 0.03595968f, 0.19115384f, -0.05409340f, 
    0.16818729f, 0.02883837f, 0.11209580f, 0.20990996f, 0.30849850f, 0.12301463f, -0.05323208f, -0.04475461f, 
    -0.03852451f, 0.10696216f, -0.09321067f, 0.09239000f, 0.16163386f, 0.15428749f, 0.02313619f, -0.00700646f, 
    0.13442802f, -0.10921551f, -0.19000711f, -0.03950899f, 0.11374744f, -0.35059726f, -0.10481286f, 0.09778182f, 
    0.16599721f, 0.06589299f, -0.01701974f, 0.04501522f, -0.01182492f, 0.05413897f, 0.11596900f, 0.02551760f, 
    -0.00119768f, 0.08721744f, 0.08235044f, -0.04839376f, 0.11880641f, -0.06538476f, -0.06027697f, 0.01137967f, 
    0.13579813f, 0.08290281f, -0.19727510f, -0.01661252f, -0.13317724f, -0.01388886f, 0.03146018f, 0.13610542f, 
    0.03062763f, 0.04509870f, 0.08188010f, 0.09221802f, -0.02159538f, 0.02759076f, -0.09813238f, 0.08476824f, 
    0.07511082f, -0.03467526f, 0.05998047f, 0.06619807f, 0.07766274f, 0.06996796f, -0.02810896f, 0.18399815f, 
    0.21221542f, 0.06052373f, -0.08304275f, 0.06255576f, -0.02379822f, 0.12318718f, -0.00239234f, -0.05167469f, 
    0.08421886f, 0.14244416f, 0.10681141f, 0.05651958f, 0.11168002f, 0.00473406f, -0.20209011f, 0.03045219f, 
    -0.37946177f, -0.19313501f, -0.09886967f, -0.00637195f, 0.16700043f, -0.00657637f, 0.01208953f, 0.01422747f, 
    -0.01728275f, 0.07196589f, 0.02596727f, -0.10707319f, -0.07903688f, -0.09625704f, -0.09398106f, -0.02808466f, 
    0.05019551f, 0.20199618f, 0.10477336f, 0.06026828f, 0.05885926f, -0.26315489f, 0.02925253f, 0.19982883f, 
    0.04738704f, -0.07504509f, 0.01290906f, 0.03252261f, 0.01841982f, 0.01981798f, 0.09312721f, -0.11896511f, 
    0.07364264f, 0.03345987f, -0.00592732f, -0.05627491f, -0.00683510f, 0.11459276f, -0.02535736f, -0.10637791f, 
    0.28284714f, 0.10968444f, -0.17468427f, -0.00314847f, -0.20297672f, 0.02461167f, 0.10266905f, 0.05637156f, 
    -0.02687202f, 0.01980313f, 0.00475473f, 0.04555180f, -0.20646682f, -0.08606580f, -0.15566264f, 0.06946032f, 
    -0.05949277f, 0.07408309f, -0.07618853f, 0.01487622f, -0.05717064f, -0.11130702f, 0.10999041f, 0.13157320f, 
    -0.17187631f, -0.00195351f, 0.10088963f, 0.07551432f, -0.01069472f, 0.01362193f, -0.19478202f, -0.10744448f, 
    0.05370634f, 0.10666773f, -0.00040144f, -0.09516376f, 0.03306112f, -0.02904012f, -0.07055458f, -0.06167587f, 
    0.02456898f, 0.07711460f, 0.01995526f, 0.07674970f, -0.13676113f, 0.00464292f, 0.08553008f, 0.00006820f, 
    -0.01913375f, 0.00758844f, -0.01250674f, -0.05557089f, 0.05638061f, 0.08466240f, -0.14291590f, 0.03979772f, 
    -0.05610956f, 0.16381794f, -0.01323001f, 0.05275099f, -0.02107964f, 0.29475731f, -0.01583781f, 0.09245769f, 
    -0.11429130f, -0.09508952f, 0.07018945f, 0.03645197f, 0.05780980f, 0.12940945f, 0.08863368f, 0.00953755f, 
    0.18972634f, 0.01769697f, 0.07402859f, 0.08771090f, -0.06663588f, -0.03573841f, -0.15252833f, -0.03140868f, 
    0.02019536f, 0.09638914f, 0.11140519f, -0.05778136f, -0.12847465f, -0.10401303f, -0.02386504f, -0.03223377f, 
    0.08096043f, 0.08112992f, -0.01059955f, -0.08152216f, 0.13471113f, 0.10019189f, 0.19444767f, -0.00175926f, 
    0.02615299f, -0.12652294f, -0.18589921f, -0.04810021f, -0.02999539f, -0.00572106f, -0.14542541f, 0.13667244f, 
    0.14280310f, 0.03141565f, 0.03554265f, 0.03753846f, -0.04845854f, 0.12864271f, -0.22434102f, -0.00337992f, 
    0.16035268f, 0.13269100f, 0.03609568f, -0.01096817f, 0.10727071f, -0.02849018f, -0.13699555f, -0.03767810f, 
    0.09106207f, 0.17113794f, 0.01765474f, -0.00108952f, -0.06830519f, 0.08001532f, 0.06302723f, -0.11981355f, 
    -0.13698770f, -0.05215814f, 0.07874050f, 0.09243553f, 0.01926650f, 0.03040735f, -0.00615456f, -0.02934844f, 
    0.00241639f, 0.20465085f, 0.11740004f, -0.00770202f, 0.04479462f, 0.15999825f, 0.11308903f, 0.02363039f, 
    -0.17657764f, 0.07435318f, 0.02751172f, 0.07790897f, 0.01109981f, 0.05860032f, -0.05078683f, 0.06409110f, 
    0.04298412f, 0.20456119f, -0.05847076f, -0.01250847f, -0.04142655f, 0.23372112f, 0.06100110f, -0.07398535f, 
    -0.16584198f, -0.16883035f, 0.15390925f, -0.18674178f, 0.14277519f, 0.01409744f, 0.12198347f, -0.14140290f, 
    -0.03593478f, 0.18583761f, -0.03149580f, 0.11753549f, 0.02274835f, 0.00733030f, -0.04604938f, -0.09195594f, 
    -0.01529907f, 0.00577333f, 0.01702709f, 0.03625831f, -0.15579788f, 0.24570049f, 0.11785337f, -0.04494597f, 
    -0.04474711f, -0.04803029f, -0.03499387f, -0.11931319f, -0.08182248f, -0.01250787f, 0.18849885f, 0.06650404f, 
    -0.01521558f, 0.04116812f, 0.03686776f, 0.00766607f, 0.00311979f, 0.11858509f, 0.05541681f, -0.00564247f, 
    -0.11917619f, -0.04232205f, 0.11932352f, 0.04033300f, 0.01662053f, -0.02823085f, 0.06334083f, 0.16298613f, 
    -0.01982483f, 0.04337458f, -0.01965896f, -0.04615833f, -0.05366122f, 0.01525112f, 0.11105988f, -0.03336078f, 
    0.07108098f, -0.17445388f, -0.03325458f, 0.04603905f, -0.19917679f, -0.33700818f, 0.08555027f, 0.02386828f, 
    0.29543382f, -0.02498751f, 0.05990067f, 0.00645851f, 0.15321131f, 0.03592195f, -0.11903281f, -0.10940140f, 
    -0.05088184f, 0.00627894f, 0.04022585f, 0.10461384f, -0.12190125f, -0.10170388f, -0.01960824f, 0.07112186f, 
    0.38825700f, 0.18838662f, -0.19000435f, -0.11054309f, -0.14775763f, 0.06198331f, 0.19059981f, -0.07979978f, 
    -0.05282890f, -0.20996569f, 0.10300580f, 0.15034881f, -0.08066545f, -0.09708466f, 0.00306500f, 0.00258661f, 
    0.00231781f, 0.04569482f, 0.04921955f, -0.01119273f, -0.43591666f, -0.31606081f, 0.09532724f, 0.06812891f, 
    0.09144147f, -0.06379501f, 0.06784081f, -0.03857678f, 0.05940983f, 0.02589207f, 0.06790711f, 0.03544112f, 
    0.10527252f, 0.03196876f, -0.02536066f, -0.04351681f, 0.00393927f, 0.01689740f, -0.04142823f, 0.02930043f, 
    0.04731334f, 0.04505528f, 0.06384712f, 0.02075288f, -0.06001903f, -0.10414305f, -0.11905315f, 0.16149913f, 
    0.02129523f, 0.09922078f, -0.08182532f, -0.06602399f, -0.01063889f, 0.08725493f, 0.06250077f, 0.06180972f, 
    0.02464047f, -0.04915084f, 0.00515224f, -0.03116655f, -0.13593341f, -0.15546343f, -0.10167480f, -0.00540136f, 
    -0.12671834f, 0.04850803f, 0.00097476f, 0.01697901f, 0.10242801f, -0.08592183f, 0.06269391f, 0.04399280f, 
    0.01294757f, 0.03456134f, -0.02148311f, 0.04030059f, -0.02674116f, -0.03739440f, -0.06479999f, 0.17605102f, 
    -0.04583846f, 0.04300633f, 0.05397813f, 0.01285726f, -0.08701035f, 0.00327229f, 0.03807167f, 0.07645226f, 
    -0.00862740f, 0.00882456f, -0.10509765f, -0.01438194f, -0.00296788f, -0.00716067f, 0.07505682f, 0.00909388f, 
    -0.02473727f, 0.08117140f, -0.00464191f, -0.09468025f, -0.57616609f, -0.00564475f, -0.05188313f, 0.02727579f, 
    0.11888328f, -0.09994836f, -0.04323323f, 0.10269993f, 0.01716150f, 0.03142092f, -0.01522172f, 0.02109684f, 
    0.15162435f, -0.09199412f, -0.06771412f, -0.03050344f, 0.08713085f, -0.07818083f, 0.01001139f, -0.02979459f, 
    -0.03460691f, -0.00346509f, -0.26962376f, -0.03477549f, -0.03599700f, 0.09285419f, -0.05017633f, -0.01829307f, 
    0.06957327f, -0.00722314f, 0.01695423f, 0.02384359f, -0.00095549f, -0.09274489f, -0.01096247f, 0.07615555f, 
    0.05074203f, -0.01448817f, -0.00626538f, 0.09923646f, -0.05599383f, 0.16510531f, 0.07807234f, 0.14118168f, 
    -0.08349203f, 0.02761078f, 0.10429197f, 0.11045520f, 0.01863857f, -0.04839185f, 0.01360703f, -0.01290347f, 
    -0.09089730f, 0.01781799f, -0.02410491f, 0.11752177f, 0.07776398f, 0.17636754f, 0.05565653f, 0.08429965f, 
    -0.00924894f, -0.01127615f, 0.00918913f, 0.01345203f, -0.03732127f, -0.01813050f, -0.00975084f, -0.01655568f, 
    0.00331142f, 0.02875546f, -0.00182097f, 0.00086773f, 0.01214271f, -0.03408339f, 0.00675871f, -0.01576823f, 
    0.03165482f, 0.02707135f, -0.03480475f, -0.02840381f, -0.02827755f, -0.02395383f, 0.02720661f, 0.03058851f, 
    -0.00095979f, -0.03901320f, -0.04719911f, 0.01574425f, -0.03321921f, 0.00120149f, 0.01060304f, 0.01575748f, 
    -0.02012633f, -0.00004117f, 0.00870641f, 0.01451995f, -0.02405659f, 0.02901791f, 0.02603884f, -0.02351508f, 
    -0.01995936f, -0.03053351f, -0.01057380f, -0.04254128f, -0.02081444f, -0.02747525f, -0.04254139f, 0.00809051f, 
    -0.03129292f, -0.00811442f, 0.01335426f, 0.00840386f, -0.02151020f, -0.01295191f, 0.02764392f, -0.04300550f, 
    0.00018986f, 0.00500173f, 0.02447064f, -0.04437282f, 0.00492220f, -0.01941803f, -0.02342204f, -0.02862198f, 
    0.00064636f, 0.01774324f, -0.01866448f, -0.00431807f, -0.01443158f, -0.03129640f, 0.00169962f, -0.01803174f, 
    0.01419293f, 0.02690139f, 0.01551025f, 0.00782064f, 0.03529158f, -0.03631619f, 0.01778557f, -0.02149369f, 
    0.01258717f, -0.00788968f, -0.03518460f, 0.01523115f, -0.01363724f, -0.02323167f, 0.00240108f, 0.02794555f, 
    0.00866875f, -0.01189245f, 0.01600289f, 0.00808389f, -0.02886404f, -0.00735387f, 0.02714987f, -0.03662923f, 
    -0.03652874f, -0.03431307f, -0.01371611f, -0.01965736f, 0.00986614f, -0.01371776f, 0.00920529f, 0.02263850f, 
    -0.03471088f, -0.03416614f, 0.02746675f, -0.03452780f, -0.00797311f, -0.02276908f, -0.03860943f, 0.01064360f, 
    0.01120715f, -0.01075592f, 0.00559973f, 0.03674221f, -0.01680505f, -0.03297359f, -0.00009981f, -0.03251252f, 
    0.01876320f, -0.04676896f, -0.02248281f, 0.01842259f, -0.03562647f, -0.01505866f, 0.00689692f, -0.04325431f, 
    -0.01950061f, -0.01061832f, -0.02833866f, 0.00823124f, 0.00381804f, 0.01418054f, 0.01661319f, 0.00698451f, 
    -0.04100557f, -0.03126200f, 0.01802006f, 0.02176787f, -0.03569914f, -0.02173285f, -0.01016573f, 0.02011240f, 
    0.00766314f, 0.03371000f, -0.00697213f, 0.00652835f, 0.00177323f, 0.02057876f, 0.02391802f, 0.00906100f, 
    -0.01513613f, -0.00452774f, -0.04168120f, -0.03483209f, 0.00472151f, -0.03954090f, -0.02484102f, -0.00802471f, 
    0.01316655f, -0.02712676f, 0.01264689f, -0.03460768f, 0.03875075f, -0.00325066f, 0.01909158f, -0.00212001f, 
    -0.00240175f, -0.01552773f, 0.03076700f, -0.03039853f, 0.01960010f, -0.03133574f, -0.03264483f, -0.01418596f, 
    -0.00908193f, -0.01117736f, 0.00046472f, 0.00573658f, -0.00350522f, 0.00468851f, -0.01405194f, -0.02942656f, 
    0.03572879f, -0.00755237f, 0.02771864f, 0.03106433f, -0.02782460f, -0.03821794f, -0.04407866f, -0.02535285f, 
    -0.02397979f, -0.01506878f, -0.04253171f, 0.01585206f, -0.03121443f, -0.03181338f, 0.01755901f, -0.03112114f, 
    0.00243409f, -0.03272483f, -0.03154591f, 0.01832061f, 0.01730108f, 0.02317219f, -0.04675293f, 0.01413158f, 
    0.02839841f, 0.01637535f, -0.02985108f, 0.02907648f, -0.01408491f, 0.00536758f, -0.04175831f, 0.01669352f, 
    -0.02274202f, -0.04430350f, 0.01699067f, 0.01907824f, -0.00938115f, 0.00051213f, 0.03101289f, -0.02866949f, 
    -0.02659179f, 0.02381122f, -0.00454088f, -0.01816527f, 0.02501218f, 0.00650305f, -0.04612082f, -0.00015855f, 
    -0.03148008f, 0.03066790f, -0.03845414f, -0.02160816f, 0.00069264f, -0.01601110f, -0.04157895f, -0.00763477f, 
    -0.01782225f, 0.01271252f, 0.00913032f, 0.00440832f, -0.00932030f, -0.00411595f, 0.01471504f, 0.03357212f, 
    0.00708186f, 0.01115991f, 0.01618135f, 0.02920715f, 0.01794928f, -0.04291845f, 0.00652484f, 0.02465304f, 
    -0.01955705f, 0.01012767f, 0.01094845f, 0.01170713f, 0.02704711f, -0.02481318f, 0.01624345f, 0.00073212f, 
    0.01911559f, 0.01873846f, -0.01067267f, -0.02145717f, 0.02103694f, -0.03010696f, -0.01511631f, -0.01383677f, 
    -0.02739985f, -0.00792680f, -0.01787090f, -0.00451501f, 0.01822188f, -0.04260843f, -0.01627950f, -0.04062511f, 
    0.00985006f, -0.03095261f, 0.01482719f, -0.04232519f, 0.01174903f, -0.03246367f, 0.01178602f, -0.01594759f, 
    -0.01640479f, -0.04303796f, -0.03390487f, -0.02663967f, -0.04137423f, -0.03809666f, -0.00323454f, 0.01997320f, 
    -0.03827490f, 0.02126633f, 0.03042948f, -0.01031967f, -0.02629789f, -0.00767134f, -0.00652635f, 0.02404302f, 
    0.04369707f, -0.00811779f, -0.02330208f, -0.01827691f, 0.00482912f, -0.03448150f, 0.01957187f, -0.02353497f, 
    -0.02696332f, 0.03261881f, -0.01495342f, 0.01225923f, -0.02772587f, -0.00244457f, 0.00078347f, -0.01426471f, 
    0.02907257f, 0.03313319f, 0.00803247f, 0.03524102f, 0.02495647f, -0.03477610f, -0.01621815f, -0.00145305f, 
    -0.02150420f, 0.01953370f, 0.01197533f, -0.02782141f, -0.03967191f, -0.02878744f, -0.00688422f, 0.00889158f, 
    0.02215748f, -0.03857397f, 0.02280998f, -0.03396882f, 0.00140117f, 0.02144326f, -0.02251242f, 0.02697731f, 
    -0.01598220f, 0.02933273f, -0.03329167f, -0.04436506f, -0.04345671f, -0.00479711f, 0.02930294f, -0.01857990f, 
    -0.00737101f, -0.00705307f, 0.03725054f, -0.04144030f, 0.01106836f, 0.01531340f, 0.00062910f, -0.00665442f, 
    0.03345174f, 0.01739961f, 0.00484227f, -0.01154892f, -0.03256338f, -0.00478582f, -0.00181327f, -0.00300808f, 
    -0.01745184f, -0.04276878f, -0.00883454f, 0.00549870f, 0.02550192f, 0.00357750f, -0.00720795f, -0.02276935f, 
    0.02473450f, 0.01400350f, -0.02798572f, 0.02891352f, 0.00827138f, -0.01915160f, -0.04319820f, -0.00272237f, 
    0.02121269f, -0.01033658f, 0.02097852f, 0.01675808f, -0.00393487f, -0.02412251f, 0.01080646f, 0.00523973f, 
    -0.00548359f, -0.00621199f, -0.02226243f, -0.03374629f, -0.02769754f, -0.00963790f, -0.03449361f, 0.00066405f, 
    -0.02731406f, 0.00482724f, -0.01446156f, -0.00330965f, 0.02796580f, -0.04352862f, -0.00984318f, -0.03885818f, 
    0.02259959f, -0.01355338f, 0.01088885f, -0.04155172f, 0.02345446f, 0.01875820f, -0.01506236f, -0.04016183f, 
    0.03320790f, -0.01996130f, 0.01226203f, -0.03823608f, -0.00422290f, 0.03375186f, 0.03435746f, 0.00423168f, 
    -0.03398631f, -0.03548517f, -0.01112436f, 0.01723208f, -0.03023551f, 0.02798851f, 0.01162890f, -0.00024995f, 
    0.01748383f, -0.03676197f, -0.00639735f, 0.01787989f, -0.02400726f, -0.02411697f, 0.02247443f, -0.00458286f, 
    0.02863521f, 0.02038343f, -0.01599074f, -0.03659815f, 0.01822987f, -0.03652445f, -0.02525705f, -0.03771715f, 
    -0.03609838f, -0.00186598f, -0.02943299f, -0.02866429f, -0.00737959f, -0.03207589f, -0.01724348f, -0.03347670f, 
    -0.00355303f, 0.02715355f, -0.00451229f, -0.03308636f, 0.00683860f, -0.00820286f, -0.03129080f, -0.01702740f, 
    0.03065828f, -0.02418854f, -0.00286266f, -0.00943471f, -0.03944668f, -0.04234238f, 0.02762136f, -0.03212937f, 
    -0.03958239f, 0.01689630f, 0.00142794f, -0.03141755f, -0.00226504f, -0.02150405f, -0.01995506f, -0.04514284f, 
    -0.03230772f, -0.01601022f, 0.01604314f, -0.01069037f, -0.02650933f, 0.01176288f, 0.03141126f, -0.00774952f, 
    0.02673414f, 0.00248921f, 0.01010019f, 0.02566273f, -0.03751690f, -0.00417446f, 0.02523474f, -0.04055111f, 
    0.02800713f, -0.03865448f, -0.02279915f, 0.02302730f, -0.00474341f, -0.03261863f, -0.02493660f, -0.01629035f, 
    -0.04084962f, -0.00841675f, 0.00253175f, 0.03399599f, -0.02787233f, -0.00928083f, 0.00198745f, -0.03787373f, 
    0.01642080f, 0.01966305f, 0.01878990f, 0.01335588f, -0.01121489f, 0.00343194f, 0.01280135f, 0.01402919f, 
    0.00968063f, -0.04363570f, 0.01107602f, 0.01305650f, 0.01831354f, -0.00075024f, 0.00069523f, 0.00764517f, 
    -0.01942101f, -0.02248958f, -0.00192051f, 0.01195855f, -0.00703826f, 0.00343419f, -0.03575170f, -0.03013013f, 
    -0.04047845f, 0.00161551f, -0.02803744f, 0.00818535f, 0.01550147f, 0.02041023f, 0.03122088f, -0.00601201f, 
    0.02893697f, -0.00884935f, -0.01814916f, -0.00830046f, -0.01248057f, -0.02240763f, 0.03023811f, -0.01338908f, 
    0.02391247f, 0.01418107f, -0.04480762f, -0.00105067f, -0.01279431f, -0.02157266f, -0.02219942f, -0.04107371f, 
    -0.03300104f, -0.02199450f, -0.00695962f, 0.02701502f, 0.01838379f, -0.00748617f, -0.04417317f, -0.01593103f, 
    0.01669079f, -0.01085004f, 0.00820204f, 0.02136990f, 0.03588645f, 0.00353227f, -0.01796778f, 0.02277715f, 
    0.02996474f, 0.02200607f, -0.02962440f, -0.04630709f, -0.04608600f, -0.02482338f, 0.00098468f, -0.01050389f, 
    -0.00933197f, 0.03214718f, -0.02320858f, -0.01978690f, -0.01526589f, -0.01098745f, 0.02993963f, -0.03091991f, 
    0.00308292f, 0.01650326f, 0.00917675f, -0.01397987f, -0.01230170f, -0.03097610f, -0.04854004f, -0.04115005f, 
    0.00689767f, 0.00800353f, -0.01861084f, 0.01433013f, -0.03504168f, -0.01569087f, -0.00206008f, 0.03199935f, 
    0.02399248f, -0.03600518f, 0.00489813f, 0.01457719f, -0.03379047f, -0.00898077f, 0.01316790f, -0.00931592f, 
    0.02784243f, -0.03190618f, -0.04053155f, -0.01657500f, -0.04361287f, -0.01529268f, 0.00728121f, -0.03403300f, 
    0.02231725f, 0.00879532f, -0.00075676f, 0.00062538f, -0.02706322f, 0.01996282f, 0.00262315f, -0.01174033f, 
    -0.01077472f, -0.01827031f, -0.00281096f, -0.02284356f, 0.03315702f, -0.04626635f, -0.03826549f, -0.00357173f, 
    0.07843968f, -0.10487392f, 0.06999661f, 0.10801414f, 0.10894965f, 0.07913645f, 0.05868966f, -0.01657757f, 
    0.04081700f, 0.12703206f, 0.03482054f, 0.01287498f, 0.08756279f, 0.05666664f, 0.06410160f, 0.01141768f, 
    0.11799727f, -0.02760492f, -0.07839230f, -0.00545243f, 0.50847757f, 0.25630352f, -0.14519678f, 0.03406626f, 
    -0.07957333f, -0.09035888f, 0.16183250f, 0.00724679f, 0.09341934f, -0.00428695f, 0.07664749f, 0.06171225f, 
    -0.01442338f, 0.01190264f, 0.00094724f, 0.16264039f, -0.00902381f, 0.13599224f, 0.08740722f, 0.11100840f, 
    0.24136795f, 0.44469085f, 0.07406288f, 0.08656538f, 0.03773700f, 0.03646089f, -0.04846342f, 0.03979865f, 
    0.10576106f, 0.10329514f, 0.05209191f, 0.04610332f, 0.11850231f, -0.03471134f, 0.13170871f, 0.08279978f, 
    0.07393932f, -0.04087678f, -0.00113197f, 0.03516912f, 0.39862192f, -0.24975118f, -0.28234872f, -0.16232644f, 
    -0.05402678f, 0.00817968f, 0.07119640f, 0.00650017f, -0.03931068f, -0.15454300f, -0.03308352f, 0.00657748f, 
    0.01184035f, -0.05321236f, 0.09622794f, -0.00030001f, 0.06482781f, 0.02648187f, -0.09035117f, 0.17864989f, 
    0.11555631f, -0.34065679f, -0.15957658f, -0.06259328f, -0.00033047f, 0.11312152f, -0.04311766f, 0.01261728f, 
    0.06161126f, 0.09667260f, 0.07337407f, -0.01490763f, -0.01942169f, 0.02508904f, -0.09241860f, 0.05725208f, 
    0.01083095f, -0.07111856f, 0.03137749f, -0.02762331f, 0.20375812f, -0.07148883f, 0.21217501f, 0.17526396f, 
    0.00333086f, -0.09138277f, 0.13062525f, 0.02785029f, -0.00525610f, -0.05324794f, 0.01753270f, 0.08399558f, 
    -0.08948285f, 0.12563439f, -0.10400845f, 0.04056472f, 0.03954167f, -0.01189856f, 0.02132212f, 0.07819810f, 
    -0.20744838f, 0.02657026f, -0.15610552f, -0.12326580f, 0.06143617f, -0.05363850f, -0.00381031f, 0.02431060f, 
    0.00162296f, 0.00197534f, 0.03955983f, -0.00610135f, -0.05365086f, 0.03358907f, 0.13302547f, 0.08776484f, 
    0.03679152f, -0.02492643f, 0.09395609f, -0.01268259f, 0.10457120f, -0.25781786f, -0.20857550f, -0.01374517f, 
    -0.00869452f, 0.03091793f, 0.00588779f, -0.02556203f, 0.04218724f, -0.04850458f, 0.03286955f, 0.00530019f, 
    0.06361563f, -0.02029644f, -0.05834060f, 0.13208787f, 0.10380992f, 0.04910500f, 0.07032215f, 0.12197493f, 
    -0.24280670f, -0.27225599f, -0.01847560f, -0.10501245f, -0.19849162f, 0.05773912f, 0.11777539f, 0.08368415f, 
    -0.04665660f, 0.07449357f, -0.04858357f, 0.00851393f, -0.03152903f, 0.04587342f, 0.04767466f, 0.05337150f, 
    -0.02514380f, -0.04211544f, 0.05518431f, 0.04197326f, -0.24630532f, -0.05461865f, -0.25241762f, -0.07843468f, 
    0.06892715f, 0.14666845f, -0.10678359f, 0.09643130f, 0.08543441f, 0.07675881f, 0.00264763f, 0.00703021f, 
    0.03284471f, 0.04357265f, 0.10057178f, 0.09565771f, -0.07748566f, 0.13293488f, 0.04781481f, 0.04906499f, 
    0.23349375f, -0.20304753f, -0.06171840f, 0.02564508f, -0.07057230f, -0.08681807f, -0.09875884f, 0.05678270f, 
    0.18749969f, -0.03544696f, -0.09007027f, -0.04044585f, 0.05677047f, -0.22599980f, -0.01302013f, -0.01039102f, 
    0.00298115f, 0.07756308f, -0.19761153f, -0.01026930f, 0.24086890f, -0.02338858f, 0.21960324f, -0.02325618f, 
    0.29733518f, 0.09122329f, -0.11025897f, 0.03830408f, 0.05463622f, 0.03556845f, 0.02947467f, 0.08170878f, 
    0.10883594f, -0.04282039f, 0.03064922f, 0.15059106f, 0.02226096f, 0.00745741f, -0.03489435f, 0.00133308f, 
    -0.43135744f, 0.30920845f, -0.19117607f, -0.11612426f, -0.10948577f, 0.03507489f, -0.11975329f, 0.04285725f, 
    0.08022320f, -0.05714741f, -0.02611134f, -0.04982878f, 0.01176990f, 0.05214992f, 0.07402899f, 0.11390870f, 
    -0.01728641f, 0.01309764f, 0.06963716f, 0.01033159f, 0.41791525f, 0.42933303f, 0.01255104f, 0.05883972f, 
    0.04140453f, -0.02047316f, -0.02645969f, 0.00692705f, 0.02870850f, 0.01422014f, 0.11435729f, -0.00819060f, 
    0.07223426f, -0.03518815f, 0.02780667f, 0.13905860f, 0.01339875f, 0.00603963f, 0.03605890f, 0.16135480f, 
    0.10983140f, 0.34528270f, 0.12351522f, 0.06091904f, 0.18228759f, 0.10102443f, -0.03089059f, 0.00531964f, 
    0.12667978f, 0.02066826f, 0.16686209f, 0.10108827f, 0.05963037f, 0.09133019f, 0.06543191f, 0.17779034f, 
    0.02308442f, -0.06990693f, 0.06922092f, -0.01681244f, -0.30105805f, -0.09522839f, 0.04211435f, -0.06627522f, 
    0.03468119f, 0.06438440f, 0.02985895f, 0.05509509f, 0.06097709f, 0.04000087f, 0.07329818f, -0.10850914f, 
    -0.12005629f, 0.05111301f, 0.19045386f, -0.00980717f, -0.02581017f, 0.05383997f, 0.20130420f, 0.04856098f, 
    -0.13509655f, -0.13518699f, -0.00877726f, 0.11977519f, 0.12555343f, 0.14525168f, 0.05413929f, 0.05575552f, 
    0.01786189f, 0.06357559f, 0.10160649f, 0.05470034f, -0.12482835f, 0.10200648f, 0.07002503f, 0.04815358f, 
    -0.07334881f, -0.05307962f, 0.11355001f, 0.04250629f, -0.26044220f, -0.13962178f, -0.02035405f, -0.13900858f, 
    0.01645754f, -0.13371100f, 0.03248093f, 0.06201616f, 0.05845607f, 0.02779199f, 0.04760605f, 0.02159543f, 
    0.01569894f, 0.06017001f, 0.02203178f, -0.04268813f, 0.02505713f, 0.01421014f, 0.13430683f, -0.00597354f, 
    -0.15679850f, 0.02873872f, -0.01858024f, 0.13441515f, -0.03322830f, 0.04085074f, 0.12882482f, 0.14530769f, 
    0.01217495f, 0.14282224f, -0.03417060f, 0.06052818f, -0.02285891f, 0.01337886f, 0.09069535f, 0.14234589f, 
    0.03268281f, -0.01611510f, -0.11767118f, -0.06383993f, 0.04734376f, 0.18875125f, 0.12292522f, 0.03899363f, 
    0.20505774f, -0.02211563f, 0.06481978f, 0.06976271f, 0.05019564f, 0.08429515f, 0.02610382f, -0.03515757f, 
    0.06857092f, -0.04274699f, 0.04382690f, 0.03569303f, 0.01410278f, -0.09891449f, 0.03671023f, 0.01885265f, 
    0.04857280f, 0.02302075f, -0.17350896f, -0.07888915f, 0.00229033f, 0.09554820f, -0.11803075f, 0.15497844f, 
    0.02528032f, -0.00517119f, 0.11132000f, 0.02849819f, 0.18147567f, -0.00971424f, -0.06954610f, 0.07096357f, 
    0.00698409f, 0.07500834f, 0.18645385f, -0.03133382f, 0.10968445f, -0.08637160f, 0.04349459f, 0.09925549f, 
    0.05460156f, -0.01375092f, 0.13454227f, 0.15437895f, 0.09541213f, 0.06525880f, 0.07183374f, -0.03613365f, 
    0.04269055f, 0.11042722f, 0.08075321f, 0.10730463f, -0.00599525f, 0.00428527f, 0.01662603f, -0.06125319f, 
    0.38759041f, 0.25733700f, 0.18322770f, 0.03677553f, 0.13824075f, 0.12911877f, -0.09662404f, 0.02572103f, 
    0.04875023f, 0.08576168f, 0.08941492f, 0.08974759f, 0.08995598f, 0.09355097f, 0.06526949f, 0.07286865f, 
    -0.01300981f, 0.00572749f, 0.04380403f, 0.00229280f, -0.06550478f, -0.11628944f, -0.09153381f, 0.00744052f, 
    -0.01211610f, 0.08121556f, -0.12265536f, -0.01492149f, 0.03221899f, -0.00809194f, 0.10580175f, 0.13675565f, 
    0.04898367f, -0.07256579f, -0.08684631f, -0.04176994f, 0.04112409f, 0.02763814f, 0.02600998f, -0.00520916f, 
    -0.32235801f, -0.32042795f, -0.09170334f, -0.10038707f, -0.08725663f, 0.16708140f, -0.02450535f, -0.00594435f, 
    0.00474109f, -0.11395388f, 0.04005139f, 0.08083100f, 0.06836934f, 0.15877104f, -0.03685245f, 0.05907577f, 
    0.03253498f, -0.09306297f, -0.08308524f, 0.05023541f, -0.12853855f, 0.24364279f, 0.17530100f, -0.06220760f, 
    0.05163420f, -0.12669176f, 0.12276510f, 0.13802563f, 0.03885618f, -0.01877611f, 0.01906483f, 0.10463149f, 
    0.01354756f, 0.02104123f, 0.05660237f, 0.01063805f, 0.04454608f, 0.09101654f, 0.15144806f, 0.03430644f, 
    0.18139261f, -0.02347104f, 0.14795125f, 0.15395549f, 0.09145837f, 0.14901771f, 0.05684722f, 0.03789606f, 
    0.02188404f, -0.00103530f, 0.03142493f, -0.08267921f, 0.02243068f, 0.05414210f, 0.04568171f, -0.07048878f, 
    -0.09821117f, 0.07650522f, -0.03899964f, -0.01465138f, -0.25598070f, 0.34251872f, -0.27751887f, 0.08963489f, 
    -0.01277523f, -0.05776642f, -0.12464635f, 0.09525072f, 0.02474121f, 0.03850751f, 0.13808541f, 0.00062573f, 
    0.10206228f, -0.03803062f, 0.05521027f, 0.03326396f, -0.04222662f, 0.05873638f, -0.12326694f, -0.08280083f, 
    0.17452964f, 0.39216393f, 0.10533158f, 0.12555605f, 0.07480418f, -0.05045442f, 0.02009734f, 0.12506013f, 
    0.06039147f, 0.04755912f, 0.11072634f, 0.06142567f, 0.08528507f, 0.04319110f, 0.08386456f, 0.10884633f, 
    0.06369781f, -0.01981691f, -0.00442570f, 0.01273585f, 0.02412129f, -0.05560975f, 0.04409595f, -0.04491598f, 
    0.01474228f, 0.00881368f, 0.12072702f, -0.11526181f, -0.06891975f, 0.02459065f, 0.03188728f, -0.02623394f, 
    -0.07675418f, 0.00151598f, 0.07976254f, 0.03511236f, 0.05278720f, -0.00359608f, -0.11062126f, -0.08723411f, 
    -0.10082536f, 0.00121813f, -0.05900427f, -0.05571461f, -0.09327161f, 0.17452355f, 0.12199503f, 0.01843595f, 
    0.02215786f, -0.02376691f, -0.03059507f, -0.04636225f, 0.04887126f, 0.08006778f, 0.03318883f, 0.05683117f, 
    0.00825666f, 0.07506510f, -0.09029521f, 0.02868970f, 0.07139504f, 0.07217844f, 0.17194392f, 0.13908836f, 
    0.15480714f, -0.02415101f, -0.01942860f, 0.02641426f, 0.08714025f, 0.17703068f, 0.02996987f, 0.14494064f, 
    0.11995120f, -0.07588148f, 0.08467964f, 0.00965459f, -0.01235003f, -0.07728325f, -0.01458613f, -0.10456568f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.01627642f, 0.04004762f, 0.02716135f, 0.04802212f, -0.02754867f, 0.03444906f, -0.02958888f, -0.04500945f, 
    0.01298985f, 0.00734330f, -0.03145872f, -0.04418017f, -0.01781400f, 0.06718222f, 0.00402418f, -0.04470657f, 
    -0.05448468f, 0.01003184f, 0.02933139f, -0.01234010f, -0.02636073f, -0.02085338f, 0.06609020f, 0.05093518f, 
    0.11598203f, -0.01821665f, 0.10777944f, 0.00427523f, -0.00030444f, 0.04013893f, 0.00680455f, 0.03393546f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.03883626f, 0.31625092f, 0.14187895f, -0.10415130f, 0.11473083f, 0.22086693f, -0.36036325f, -0.00689271f, 
    -0.01099081f, -0.02860654f, -0.06839035f, -0.11054819f, 0.17160355f, 0.03232676f, 0.09645576f, 0.08849415f, 
    0.20563667f, -0.02039516f, 0.11344536f, -0.10912374f, 0.04259307f, -0.10029736f, 0.42391118f, -0.24432519f, 
    0.14579722f, 0.08559002f, 0.19477659f, -0.27405792f, 0.09078462f, 0.34520435f, 0.11071948f, -0.08228377f, 
    0.15640062f, 0.07854901f, -0.05139107f, 0.00940709f, 0.23945701f, 0.42275816f, -0.29499909f, -0.09097746f, 
    0.06955408f, -0.01724806f, -0.16749902f, 0.06034129f, 0.08511370f, 0.09893601f, -0.13019821f, -0.05319070f, 
    0.24000360f, 0.18000975f, 0.15357356f, 0.09972298f, 0.15212987f, -0.03029001f, -0.04786231f, -0.12519319f, 
    0.00977424f, -0.06690843f, -0.21100859f, -0.13405274f, -0.14212058f, -0.03685782f, 0.06429662f, 0.07541668f, 
    0.06434500f, 0.07674985f, -0.07206588f, -0.14703718f, -0.08818880f, 0.13331135f, -0.00117031f, -0.03092552f, 
    -0.09727003f, 0.17244263f, -0.15120827f, 0.15420964f, 0.02257893f, 0.09898341f, -0.06395216f, -0.17294492f, 
    -0.09961789f, -0.12915030f, -0.14170550f, 0.09630173f, -0.12110502f, 0.08646952f, -0.10629527f, -0.16429791f, 
    0.06274118f, 0.01817834f, -0.17976741f, -0.09011695f, 0.06603123f, 0.07935575f, -0.14819695f, 0.07530317f, 
    0.09097161f, -0.11255935f, -0.13873774f, 0.22637232f, -0.08701712f, 0.04266653f, 0.31597900f, -0.12925367f, 
    0.18003967f, 0.07641408f, 0.12686558f, -0.06659166f, 0.15349630f, 0.38049871f, -0.05710451f, -0.05694019f, 
    0.14488050f, -0.24124648f, -0.10312723f, -0.03769848f, -0.02007887f, -0.04569216f, -0.08826794f, 0.04531623f, 
    -0.13165724f, 0.05113864f, 0.19410275f, 0.14961730f, 0.06239692f, -0.39783812f, -0.09646368f, -0.02452640f, 
    0.02226334f, -0.14941457f, -0.10815813f, 0.24518353f, 0.27936950f, -0.19570647f, -0.16290815f, 0.01487107f, 
    0.17694798f, -0.14804779f, 0.05672210f, -0.02194403f, 0.07195853f, 0.00629545f, 0.05959910f, -0.04253397f, 
    0.03239335f, -0.12418447f, 0.09414381f, -0.11113054f, 0.04119452f, -0.10506744f, 0.12562272f, -0.44335228f, 
    0.01785793f, 0.01035334f, 0.38140461f, 0.22862110f, -0.01676526f, 0.38279104f, -0.07565325f, 0.04209663f, 
    -0.16431122f, -0.02217213f, -0.08858258f, -0.03728576f, -0.07713265f, -0.13362262f, 0.04374383f, 0.14480017f, 
    0.04913351f, 0.07499195f, 0.04454292f, 0.17228849f, -0.03649043f, 0.05436912f, -0.07372784f, 0.02927099f, 
    0.16151629f, -0.17545381f, 0.13004784f, 0.05997480f, -0.15732327f, 0.12426262f, -0.02101448f, -0.08485044f, 
    -0.09317998f, 0.08423656f, -0.07975345f, -0.11978469f, 0.07497237f, -0.16960521f, -0.10416368f, -0.16973224f, 
    0.15601006f, 0.46302068f, -0.13449343f, 0.24009345f, 0.07464660f, -0.15729257f, 0.33852032f, -0.00120592f, 
    -0.05521819f, -0.02595244f, 0.11602326f, 0.06806524f, 0.05238114f, -0.14312361f, 0.11372545f, -0.02623253f, 
    -0.34375706f, -0.04010846f, -0.04516539f, -0.06285105f, 0.04058221f, 0.07365224f, 0.26298332f, 0.13585068f, 
    -0.07775312f, 0.12677044f, 0.31306708f, -0.03119071f, 0.17268430f, 0.11615791f, -0.10270125f, 0.16443342f, 
    -0.17029534f, -0.12181315f, -0.02246166f, 0.16691805f, -0.08732834f, -0.21438566f, 0.14471549f, -0.04076904f, 
    0.05867054f, 0.05902072f, 0.00308140f, -0.12671356f, -0.03444142f, -0.14998454f, -0.16110268f, -0.18437508f, 
    -0.09683394f, -0.18231449f, -0.11239086f, 0.01851033f, 0.11329463f, -0.15592790f, -0.07123076f, 0.19057292f, 
    0.05509241f, 0.12293003f, 0.21279053f, 0.42365003f, 0.06501015f, -0.19746011f, -0.08553851f, 0.42443001f, 
    -0.13001500f, 0.14187497f, 0.04245302f, -0.15901975f, -0.08562926f, -0.12152974f, 0.08772135f, -0.02793756f, 
    -0.13427693f, 0.01833333f, -0.13091968f, 0.07643080f, 0.05942634f, -0.15803450f, -0.04398932f, 0.15133911f, 
    -0.12946829f, -0.16344686f, 0.04375432f, -0.10959181f, 0.13653159f, -0.08937549f, -0.08850835f, 0.01984448f, 
    -0.02084887f, 0.01973943f, 0.15892857f, 0.01680428f, 0.15095699f, 0.04300839f, 0.14994343f, -0.01874386f, 
    -0.12196965f, -0.45025423f, 0.09422410f, -0.04455913f, 0.05318343f, 0.47345051f, -0.14313908f, 0.17211521f, 
    -0.03190294f, 0.08000246f, 0.15170397f, -0.01768758f, -0.17036246f, -0.33194718f, 0.01798639f, -0.15539841f, 
    0.09304949f, -0.00685083f, 0.05478487f, -0.08697813f, -0.10618973f, 0.10493993f, -0.22669345f, 0.08245102f, 
    0.21756883f, 0.11277753f, -0.09658828f, 0.46686485f, 0.16486491f, 0.43144047f, -0.06142039f, 0.36379594f, 
    -0.04107084f, -0.23239549f, 0.16458781f, 0.23785119f, -0.14969958f, -0.03478015f, -0.15474012f, -0.03600236f, 
    -0.02213900f, 0.11912262f, -0.04564461f, -0.13837825f, -0.07075165f, -0.12937447f, 0.12751369f, 0.02838566f, 
    -0.00604550f, 0.43588302f, 0.04620555f, -0.08744293f, 0.16219972f, 0.17802580f, -0.63859862f, -0.03572083f, 
    0.31905833f, 0.05052366f, -0.02841090f, 0.01882005f, 0.16440068f, 0.33096114f, 0.02509613f, 0.14653102f, 
    -0.04921586f, -0.09749270f, -0.04295246f, 0.24689741f, -0.15094878f, 0.49281183f, 0.23244414f, -0.00741027f, 
    0.15260096f, -0.00772653f, 0.04226111f, 0.16797362f, 0.00551836f, -0.13938645f, -0.06214345f, 0.13411790f, 
    0.21889688f, -0.16153699f, -0.10637894f, 0.02659802f, -0.05888567f, 0.06908058f, 0.32590130f, -0.37248921f, 
    -0.15101050f, -0.00691183f, -0.23618771f, 0.31805328f, 0.12561499f, 0.01795430f, -0.06494113f, 0.12979059f, 
    -0.17545764f, 0.29635492f, -0.00555211f, 0.19622011f, 0.01035628f, -0.35673216f, 0.52842695f, 0.05530954f, 
    -0.14237665f, 0.15672925f, -0.00290323f, 0.13362400f, -0.10151353f, 0.31338874f, 0.01798228f, -0.07706289f, 
    -0.03442525f, 0.15662082f, -0.12056519f, -0.01820804f, 0.11583690f, -0.11382241f, -0.31278703f, 0.19380626f, 
    0.20058042f, -0.07005458f, 0.31436539f, 0.01679960f, -0.04666030f, 0.46814111f, -0.05409016f, -0.32391742f, 
    -0.04068471f, -0.15291797f, -0.10909860f, -0.19877796f, -0.51007479f, 0.00782419f, 0.09217890f, 0.16139391f, 
    0.02194544f, -0.17671493f, -0.00547075f, 0.14125392f, 0.04168833f, 0.19423284f, -0.17644860f, 0.02615161f, 
    -0.22805451f, 0.14452672f, -0.13298389f, 0.05341274f, 0.01736743f, -0.07658510f, 0.24704520f, 0.35842562f, 
    0.36245596f, -0.00001509f, 0.01760648f, -0.06345487f, 0.00681896f, 0.14389463f, -0.08710200f, 0.19311777f, 
    0.06354944f, -0.05527301f, -0.08859465f, 0.15028545f, -0.00680981f, -0.22713067f, -0.26487800f, 0.12397420f, 
    0.06868394f, -0.00608449f, 0.03360065f, -0.10593100f, 0.02936285f, 0.25446412f, -0.11273173f, 0.03707545f, 
    0.20903417f, 0.11981712f, -0.02942920f, 0.14482109f, -0.08767598f, -0.04407747f, 0.64463758f, 0.25211632f, 
    0.29768029f, 0.05201071f, -0.32304391f, -0.25776324f, 0.15281408f, -0.13495137f, -0.06963649f, 0.05325224f, 
    -0.13714989f, -0.08678347f, -0.09507324f, -0.06399808f, 0.04629363f, -0.14955434f, 0.11925483f, 0.11160403f, 
    0.10361292f, 0.02307292f, -0.06286552f, -0.13128558f, -0.10863186f, -0.07822161f, 0.04652110f, -0.12244348f, 
    -0.12870924f, -0.11311357f, -0.01654007f, -0.07462858f, -0.17293222f, -0.14274810f, 0.10119973f, 0.04219567f, 
    0.14417855f, 0.14199188f, -0.00874715f, 0.06121288f, 0.08567639f, -0.12582655f, -0.13558570f, -0.13909815f, 
    0.15705238f, -0.24779159f, 0.06105625f, -0.04800587f, 0.20921925f, 0.41537660f, -0.11443377f, -0.02997931f, 
    0.01272526f, -0.06048445f, -0.13625699f, -0.16951163f, 0.16731052f, 0.22898498f, 0.00953103f, -0.15454876f, 
    0.01802474f, -0.36128202f, -0.03850957f, -0.02441887f, -0.05075519f, -0.08142865f, 0.03234263f, 0.22394732f, 
    -0.05729560f, 0.07407434f, 0.26773527f, -0.14823116f, -0.11980287f, 0.27838013f, -0.12776673f, 0.26803070f, 
    0.06301770f, 0.07128504f, 0.07335880f, -0.16420896f, -0.44449770f, -0.41674638f, 0.03015532f, -0.16398275f, 
    -0.12115075f, -0.02429236f, -0.11758987f, 0.03678060f, 0.13901770f, 0.03544520f, -0.14761844f, -0.02597609f, 
    0.25227883f, 0.28401336f, 0.13659747f, -0.15172257f, -0.05004461f, -0.00942928f, 0.20119797f, 0.17615940f, 
    0.19632536f, 0.08462421f, -0.13978991f, 0.16851765f, 0.00509256f, -0.48192516f, 0.05146050f, 0.21519670f, 
    -0.04113994f, 0.10947034f, 0.02975998f, -0.02823908f, 0.46820867f, -0.19385909f, -0.40903088f, -0.12051217f, 
    0.06639853f, -0.04289403f, 0.11193429f, 0.12040015f, -0.10152399f, 0.09340797f, 0.13697326f, -0.00149393f, 
    0.31957543f, -0.05796821f, 0.05445677f, 0.09075567f, 0.14130999f, -0.12465964f, 0.32605544f, -0.28808412f, 
    -0.12379131f, 0.15720919f, 0.24371748f, 0.02255736f, 0.07837141f, 0.29628688f, 0.13148811f, 0.09439357f, 
    0.15147385f, -0.02102952f, -0.14187491f, -0.11537836f, -0.03645193f, -0.13857569f, -0.16836703f, 0.09717358f, 
    0.07762710f, 0.06456240f, 0.10968791f, -0.08155398f, -0.10151505f, 0.25667208f, -0.04860547f, -0.04170851f, 
    0.22905125f, -0.05792105f, 0.12508689f, -0.09565878f, -0.03774326f, -0.12936716f, -0.25186342f, 0.24390921f, 
    -0.06368868f, -0.13624637f, 0.21497688f, 0.05059419f, 0.13331831f, -0.44673756f, -0.11476424f, 0.29054129f, 
    -0.10385910f, 0.36651579f, 0.13004482f, -0.00614954f, -0.30470031f, 0.34633076f, 0.03095534f, -0.13405086f, 
    -0.08393624f, -0.03743991f, 0.06595005f, 0.09376617f, -0.13731928f, 0.19792379f, -0.02465945f, 0.16197839f, 
    -0.29265973f, 0.10672253f, -0.01312138f, -0.17311583f, -0.15510245f, -0.04973450f, 0.38841754f, 0.22664103f, 
    0.04775184f, 0.00645114f, 0.11182713f, -0.40722299f, -0.17440125f, 0.10287198f, 0.12392063f, 0.12750494f, 
    0.00802573f, -0.11375891f, -0.03967451f, 0.01311479f, -0.00190272f, -0.12377507f, 0.10769615f, 0.04451896f, 
    0.07236416f, 0.07394639f, -0.16631760f, -0.07372066f, -0.12938975f, 0.07631629f, -0.17159913f, 0.06891355f, 
    -0.07472790f, -0.07211153f, 0.02956125f, 0.07948565f, 0.00406291f, -0.13420856f, 0.10843931f, -0.09419064f, 
    -0.16043043f, 0.03746735f, 0.02940655f, -0.11535735f, 0.15118842f, -0.03727389f, -0.03274829f, -0.11189463f, 
    0.09768070f, -0.02268721f, -0.10724001f, -0.11612841f, 0.01212401f, -0.14749514f, -0.12190238f, -0.15728821f, 
    -0.01694408f, -0.06587145f, 0.08871708f, -0.05139142f, 0.13129070f, -0.12594336f, 0.08433403f, 0.14911732f, 
    -0.14721021f, 0.09927355f, 0.16667670f, 0.10840361f, 0.03046860f, -0.06158192f, -0.02472356f, -0.12940903f, 
    -0.16614731f, 0.07312978f, 0.12248114f, -0.14433360f, -0.12751049f, -0.06745982f, 0.15611798f, 0.05617175f, 
    0.01395387f, -0.19883993f, -0.00186129f, 0.18921490f, -0.49297294f, -0.28982547f, -0.12300913f, -0.07111152f, 
    0.00595418f, -0.02884001f, -0.08092545f, -0.03086933f, -0.10506522f, 0.32213375f, -0.06598270f, -0.14856823f, 
    0.03579032f, 0.31750900f, 0.15138823f, 0.13421002f, -0.14722574f, -0.16490628f, 0.16566136f, -0.37095249f, 
    0.16823111f, -0.14265698f, 0.41010600f, 0.12358369f, 0.15361260f, -0.10741101f, 0.16426878f, -0.03129173f, 
    0.17147121f, 0.00005296f, 0.03519965f, 0.07258383f, 0.20977390f, -0.04147390f, 0.22733046f, 0.07906882f, 
    0.01763466f, 0.16832186f, 0.03594467f, 0.13772075f, 0.16767018f, 0.50341278f, -0.00013361f, -0.04294296f, 
    0.27632621f, -0.01024311f, 0.06497248f, -0.03188774f, -0.13538130f, 0.07689615f, -0.00762904f, 0.06684327f, 
    0.22752587f, -0.09327736f, -0.42257249f, -0.29041606f, 0.08455356f, -0.36518797f, -0.00509150f, -0.14660692f, 
    0.11484104f, 0.36752686f, -0.02402989f, -0.06645367f, -0.01128979f, 0.04557316f, -0.09926693f, -0.14292467f, 
    -0.01742236f, 0.01892172f, -0.06280556f, 0.04618933f, 0.17821671f, -0.10950471f, -0.04771273f, -0.14286290f, 
    -0.15393895f, 0.43551931f, 0.16357359f, 0.04118065f, -0.04966810f, -0.00142563f, 0.10644298f, 0.25397608f, 
    0.15173540f, -0.07383189f, 0.28092423f, -0.25070742f, 0.14750323f, -0.09075176f, -0.14854199f, 0.01893797f, 
    -0.01589410f, -0.04496390f, -0.08003306f, 0.31579974f, -0.07257791f, 0.29718152f, 0.45889699f, 0.00866198f, 
    0.05646409f, -0.14661129f, 0.02879244f, -0.14096020f, -0.09995236f, 0.16268390f, 0.12734482f, 0.02264270f, 
    0.05537461f, -0.19962919f, -0.05910594f, 0.09916810f, -0.04687542f, -0.07544875f, 0.01492977f, -0.35815147f, 
    0.08579636f, -0.02037547f, 0.13468207f, -0.04204614f, 0.14937277f, 0.01412350f, -0.08314130f, -0.17861012f, 
    -0.09562685f, -0.02995593f, -0.03172509f, -0.18590492f, -0.12290635f, -0.12402843f, -0.05120718f, 0.00302945f, 
    -0.00520165f, -0.10627726f, 0.03848107f, -0.05225613f, 0.04960328f, 0.12510593f, 0.13246492f, 0.05216977f, 
    0.10478027f, 0.11213261f, -0.03660806f, -0.13498709f, -0.03447455f, 0.08356411f, -0.20126337f, -0.08168359f, 
    -0.17021665f, 0.15966445f, -0.16644704f, -0.07776907f, 0.03922998f, 0.10999651f, -0.04910437f, -0.05812888f, 
    0.13497877f, 0.07390461f, -0.09648079f, -0.10189734f, -0.27315539f, 0.30049610f, 0.04427332f, -0.10458852f, 
    0.04850201f, 0.14859277f, -0.14492980f, -0.08036012f, 0.11900190f, 0.27025387f, 0.15295836f, -0.03099327f, 
    0.18157540f, 0.29477513f, 0.11636725f, 0.04684065f, 0.01812628f, 0.01688018f, -0.08911774f, -0.13452406f, 
    0.24842797f, -0.07445609f, -0.30372581f, -0.01515482f, 0.07046852f, -0.10085322f, -0.03549035f, -0.06552467f, 
    0.09650524f, -0.05430851f, -0.07431163f, 0.01171931f, 0.02493125f, 0.46069488f, 0.17484175f, -0.09607361f, 
    0.08829684f, -0.00497454f, 0.15927427f, 0.03749003f, 0.03145067f, 0.17580602f, 0.04245930f, 0.11132210f, 
    0.16755044f, 0.12406482f, -0.14793971f, 0.09026869f, 0.04872826f, -0.05658596f, -0.48778552f, 0.34399897f, 
    0.06791314f, -0.15620674f, -0.24453506f, -0.18008900f, 0.13717413f, 0.21327150f, 0.13851972f, -0.06462202f, 
    0.09086502f, 0.12449797f, 0.11875290f, -0.17353962f, 0.09684841f, -0.06919056f, -0.03554967f, -0.02968480f, 
    -0.14553207f, 0.11871476f, 0.04617816f, -0.07033269f, -0.01187654f, -0.04172743f, -0.05050876f, 0.07979356f, 
    -0.14196774f, -0.13124405f, 0.07422937f, -0.14406495f, -0.11141352f, -0.09187219f, -0.08581871f, 0.09404885f, 
    -0.01712492f, 0.01471862f, -0.08660411f, -0.02640999f, 0.09437783f, -0.04032586f, -0.01843355f, -0.09573144f, 
    0.11060096f, 0.51100212f, -0.00212937f, 0.02893521f, 0.43152702f, 0.11886273f, -0.05170683f, 0.07909779f, 
    -0.08500830f, -0.02781248f, -0.14803608f, 0.08034521f, 0.12348924f, -0.11801121f, -0.11133359f, 0.03401537f, 
    0.06961901f, -0.15694660f, -0.12889171f, -0.00128679f, 0.05199432f, 0.08374243f, -0.41447183f, 0.10824658f, 
    -0.07118944f, 0.03837290f, 0.37016064f, -0.17972223f, -0.08755134f, -0.14220472f, -0.09464543f, 0.29963389f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.01829432f, 0.07798048f, -0.06499378f, 0.04574934f, 0.19353884f, -0.17069338f, -0.09674682f, -0.00309955f, 
    -0.13467382f, 0.12795031f, 0.09780324f, 0.10970049f, 0.14003612f, -0.04493873f, -0.03254287f, -0.17777452f, 
    0.05904602f, -0.13645689f, -0.09831997f, -0.15416035f, 0.14805019f, -0.12564076f, -0.07452081f, -0.08199117f, 
    0.16385679f, -0.08188020f, 0.10107675f, 0.06418408f, 0.16054513f, 0.02572739f, 0.10492405f, -0.10142377f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.36739701f, 0.15465863f, -0.03091081f, -0.05831129f, 0.02484692f, 0.08143936f, -0.42491066f, 0.17591663f, 
    0.06570972f, 0.45133710f, 0.38279134f, 0.33254752f, -0.46885154f, -0.21811838f, -0.11186454f, 0.02554862f, 
    -0.17012508f, 0.11126556f, -0.08699185f, -0.09104667f, -0.58725518f, -0.14783631f, -0.06662577f, 0.09912918f, 
    -0.20051798f, -0.23403704f, 0.01267567f, 0.08115344f, 0.14506470f, -0.01857550f, 0.14179775f, -0.31904173f, 
    -0.16445912f, -0.11711966f, -0.13845599f, -0.01211452f, 0.33032411f, -0.14614141f, 0.09969924f, 0.10247460f, 
    -0.07848381f, 0.26461798f, 0.18674773f, -0.05414266f, 0.12869337f, -0.31991896f, -0.51229280f, -0.00920329f, 
    0.30178976f, -0.62179470f, 0.20638552f, -0.01451072f, -0.17433396f, 0.03539591f, -0.03012155f, -0.22755951f, 
    -0.05793546f, -0.20788699f, 0.03396236f, 0.10520242f, -0.48174703f, 0.01112172f, 0.12737527f, 0.35766938f, 
    -0.29934829f, -0.58624816f, -0.15470023f, 0.33738604f, 0.06802654f, 0.06766544f, 0.07996398f, 0.27462086f, 
    0.10705780f, -0.08511337f, -0.41538513f, 0.11252943f, 0.25784135f, -0.19443059f, -0.28715998f, 0.02930592f, 
    -0.09088932f, 0.26600325f, 0.03632035f, 0.21482396f, -0.46085483f, 0.16790034f, -0.08238233f, 0.11646608f, 
    0.01629736f, -0.41024664f, 0.09369937f, -0.10425734f, -0.14298947f, -0.40165800f, 0.07793481f, -0.05516623f, 
    -0.45751953f, -0.22813174f, -0.19138217f, 0.04707800f, -0.41043231f, 0.10525767f, -0.10764338f, -0.06480463f, 
    0.09143381f, -0.08757566f, 0.33912742f, -0.65073973f, 0.27672613f, 0.16530858f, 0.07132639f, 0.09106578f, 
    -0.39626598f, 0.23810664f, -0.65358096f, 0.20741388f, -0.16066860f, -0.08458417f, 0.03264781f, 0.04629211f, 
    0.26339179f, 0.05233045f, -0.10604952f, 0.09030095f, 0.19576031f, 0.16481182f, -0.01344837f, -0.14648128f, 
    0.03086505f, 0.27722293f, -0.00679470f, 0.16565911f, -0.49790829f, -0.03972138f, -0.35518980f, -0.17637245f, 
    -0.14789659f, -0.00080901f, -0.04523641f, -0.08432470f, -0.16838685f, -0.09441305f, -0.10460874f, 0.10499839f, 
    0.25191352f, -0.05744953f, -0.19676685f, 0.32873198f, 0.08160743f, -0.06501079f, 0.06459318f, -0.27416608f, 
    0.21896049f, 0.13393104f, -0.05497913f, -0.13944605f, 0.30986369f, 0.43224144f, 0.08598195f, 0.18956369f, 
    0.24514118f, -0.07291524f, -0.14696091f, -0.52964646f, -0.22639482f, 0.08798960f, 0.04657570f, -0.06867961f, 
    -0.14927253f, 0.36593005f, 0.08255973f, 0.04905644f, 0.05904659f, 0.21881810f, -0.09615932f, 0.15604652f, 
    0.21619521f, -0.26499999f, -0.11108731f, -0.40559235f, 0.18916456f, 0.08823205f, 0.13542828f, -0.68818140f, 
    -0.53557873f, 0.06545237f, -0.07999687f, -0.08276644f, 0.05775654f, 0.32381698f, -0.04365593f, -0.09915093f, 
    0.32143617f, 0.13129602f, -0.05080429f, -0.36497903f, 0.06574239f, -0.01178527f, -0.07937014f, 0.00532119f, 
    0.05887239f, 0.05853368f, -0.00549021f, -0.01683623f, -0.35457844f, -0.16738838f, 0.08662198f, 0.14390796f, 
    -0.17185090f, 0.16052197f, 0.45595309f, 0.20419556f, -0.00044312f, 0.14007273f, -0.09459773f, 0.19430624f, 
    -0.46997842f, 0.20632190f, -0.34987259f, -0.04688931f, 0.01124930f, -0.57341546f, 0.07522105f, 0.28422618f, 
    0.02795197f, 0.14675215f, 0.03846993f, -0.14183927f, -0.25862360f, -0.16417034f, -0.14511663f, -0.46123064f, 
    0.14366417f, -0.54420149f, -0.01904857f, -0.18745528f, 0.30258337f, -0.35401177f, 0.27604750f, -0.15848400f, 
    -0.43878159f, 0.05332857f, 0.26573280f, 0.03114423f, -0.20853791f, 0.04155418f, 0.12261392f, -0.30453473f, 
    0.34119707f, 0.06195749f, -0.25671795f, -0.13676713f, 0.12942748f, 0.32181394f, -0.06792861f, 0.17068714f, 
    -0.02845550f, 0.00592972f, 0.09806421f, 0.21876673f, -0.06245254f, -0.11456496f, 0.24582136f, -0.09936128f, 
    0.12760696f, -0.27245677f, -0.06783824f, 0.39939111f, 0.08691308f, -0.68546307f, -0.28947431f, -0.16722032f, 
    -0.27515531f, -0.42704004f, -0.33053669f, -0.54591155f, 0.23357581f, -0.02748992f, 0.10230734f, -0.13317174f, 
    0.10166787f, 0.01028717f, 0.42303836f, 0.10778561f, 0.09042308f, 0.04627343f, -0.06195246f, 0.18260372f, 
    0.21339943f, 0.07487976f, -0.18827835f, 0.05455066f, 0.15650389f, -0.04347972f, -0.37345436f, -0.29164043f, 
    0.03877468f, -0.03874006f, -0.22708704f, 0.13622753f, -0.13454323f, -0.07527374f, 0.27651566f, -0.15812923f, 
    0.11607941f, -0.21179366f, 0.31769225f, -0.24343596f, -0.02677336f, -0.13997100f, 0.09999226f, 0.19949344f, 
    0.32787448f, -0.39065072f, 0.19951965f, -0.12693821f, 0.12312941f, -0.19052590f, -0.18347692f, -0.64708161f, 
    0.08291965f, -0.33063614f, -0.12180290f, -0.05917871f, 0.22400159f, -0.07068971f, 0.20772082f, -0.17291826f, 
    -0.14175484f, -0.46407193f, 0.17957339f, -0.36290321f, 0.38161644f, 0.17093214f, -0.04998894f, 0.14129038f, 
    -0.28617778f, -0.13573736f, -0.14534506f, -0.51900280f, 0.10721092f, -0.09112958f, -0.05457956f, 0.45094985f, 
    -0.23763543f, 0.30045208f, 0.17848679f, 0.11917148f, 0.06884505f, -0.25607294f, 0.16739464f, -0.34927678f, 
    -0.28055811f, -0.22268394f, 0.08932261f, 0.10251097f, -0.38782108f, 0.06544282f, 0.31904188f, 0.27509710f, 
    0.15887244f, -0.21348959f, -0.26498342f, -0.25692403f, -0.28552324f, 0.27364951f, 0.31606084f, -0.01495242f, 
    0.06726630f, 0.19525680f, -0.24790764f, 0.22518836f, 0.31696099f, 0.17349084f, -0.15179867f, -0.31124634f, 
    0.07657411f, 0.16329582f, -0.29521295f, 0.00769879f, -0.27177364f, -0.31648532f, -0.08991349f, 0.02542661f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    0.07012700f, -0.07856656f, -0.06266856f, -0.21125820f, -0.07840408f, 0.02686753f, -0.06072768f, 0.12981439f, 
    -0.19284523f, 0.00340945f, -0.07632228f, 0.02825686f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
