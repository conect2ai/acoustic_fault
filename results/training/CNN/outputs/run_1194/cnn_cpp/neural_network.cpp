#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.53596276f, 1.41216159f, -0.48397705f, -0.85598278f, -0.06754251f, 0.37647516f, -0.26002529f, 0.01638145f, 
    0.53225410f, -0.32817346f, -0.00705874f, 0.20228770f, -0.31513217f, -0.59937686f, -0.76182896f, 0.69473499f, 
    -0.54083115f, 0.79345268f, 0.59963042f, -0.95259261f, 0.35296318f, 0.69827431f, -0.97803378f, -0.50066972f, 
    0.07199157f, -0.17702408f, -0.16191614f, -0.44229317f, -0.19369785f, 1.01195359f, -0.90198296f, -0.13171583f, 
    -0.33456954f, 0.11244457f, 0.63680291f, -0.20965663f, 1.14701653f, 0.56953329f, -0.10148191f, -0.50002313f, 
    -0.14697914f, -0.66835123f, 0.18989465f, 0.48510191f, 0.62864900f, -0.66232729f, -0.76022089f, 0.84412766f, 
    0.44271371f, -0.14959131f, -0.31955263f, 0.53306925f, 0.22692367f, 0.80008173f, 0.54542905f, 0.84954178f, 
    0.69993389f, -0.26375681f, 0.66203910f, -0.09481575f, 0.27201229f, 0.04557708f, 0.73469484f, -1.21395731f, 
    -0.24427132f, -0.12649798f, 0.65858746f, 0.00748820f, -0.55716050f, -0.54224336f, -0.47367540f, -0.49413925f, 
    -0.73795247f, -0.78521872f, -0.70696276f, 0.23738164f, 0.66800159f, -0.95445591f, -0.38814735f, -0.09445608f, 
    0.29787016f, 0.32443640f, -0.58968502f, 0.57026857f, -0.69694084f, 1.22908413f, -0.77560443f, 0.19454674f, 
    -0.16816162f, -0.15582798f, 0.48466450f, -1.12832224f, 0.26618767f, 0.27560934f, -0.29442316f, -0.10278197f, 
    -0.44496003f, -0.09007301f, -0.97149086f, -0.32135838f, -0.60181153f, -0.87250555f, 0.83789289f, 0.87935668f, 
    0.39847326f, 0.03496728f, -0.32061848f, -0.42382914f, 0.51779550f, 0.75445271f, 0.33188218f, -0.46918204f, 
    -0.51341081f, -0.07519134f, 0.21075279f, -0.57504731f, -0.39320162f, 0.60129380f, 0.28327489f, 0.62198305f, 
    0.35332343f, 0.39906135f, 0.90428680f, 0.28966796f, 0.05788324f, -0.14796491f, -0.76270443f, -0.43605196f, 
    0.09862076f, -0.61381364f, -0.71483403f, -0.90056944f, 0.03726938f, -0.36242050f, -0.51198596f, -0.06429379f, 
    -0.11136647f, -0.66338712f, -1.02441061f, -0.78797603f, -0.74924535f, 0.27751681f, -0.12907642f, 0.57860416f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.02660530f, 0.44961983f, 0.76806217f, 0.19053546f, 0.71390486f, 0.06655648f, -0.09629557f, 0.00523856f, 
    0.05668156f, 0.27128351f, 0.12663062f, -0.17646959f, 0.27068657f, 0.60259742f, -0.03891356f, -0.05191069f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.12466881f, -0.17828527f, -0.25228667f, 0.40554455f, 0.40859708f, 0.16130111f, 0.01193770f, -0.40744886f, 
    0.10130600f, -0.10668480f, 0.34744239f, 0.58827901f, 0.14027362f, -0.12349878f, -0.02214938f, 0.05240161f, 
    0.22195262f, 0.22015832f, 0.13712978f, 0.03769549f, 0.38335279f, -0.10777473f, 0.01752298f, 0.24171114f, 
    0.17047445f, -0.08362444f, -0.10673308f, 0.14864644f, 0.32727495f, 0.45104888f, -0.35225406f, 0.32548532f, 
    -0.12953755f, -0.12891990f, 0.30065912f, 0.19682126f, -0.44491804f, -0.11092709f, -0.23507728f, 0.06268273f, 
    0.09277608f, -0.07202867f, 0.06427032f, 0.24065854f, -0.05473220f, 0.18808106f, 0.04115624f, -0.15133081f, 
    -0.20788632f, 0.38794786f, -0.31761470f, 0.08377615f, 0.06276719f, 0.06359977f, -0.20895867f, 0.21520910f, 
    -0.10661746f, 0.02889351f, -0.00888344f, -0.27080205f, 0.03613413f, 0.07508201f, -0.09371552f, -0.33834982f, 
    -0.14326489f, 0.02165965f, -0.06149219f, 0.16727379f, 0.03703225f, -0.00810993f, 0.07295282f, -0.16691981f, 
    -0.17614575f, 0.24232547f, 0.30900186f, -0.25645235f, -0.19035338f, -0.29329935f, 0.22898205f, 0.03559227f, 
    0.06784306f, -0.08981460f, 0.69111633f, 0.19523078f, -0.26576710f, -0.02334993f, 0.08558556f, 0.14371806f, 
    -0.09439757f, 0.12102970f, 0.06634247f, -0.42792997f, -0.06700280f, 0.04163577f, 0.06823793f, 0.20807512f, 
    0.06936891f, 0.14921536f, 0.02439917f, -0.57500219f, 0.16761592f, 0.07442422f, 0.00391134f, 0.10409947f, 
    -0.16617317f, 0.07889134f, -0.09045432f, 0.04418077f, -0.09708521f, -0.22937146f, 0.28607860f, 0.04196796f, 
    -0.02164329f, -0.01716017f, 0.00904961f, -0.30444258f, -0.01168579f, -0.33756649f, -0.01475308f, 0.13207498f, 
    -0.16690511f, -0.06169929f, -0.20904469f, 0.06375226f, 0.18123901f, -0.09802032f, 0.10156827f, -0.11297116f, 
    0.30051062f, -0.06849688f, -0.13949022f, -0.07969269f, 0.05744116f, -0.01472017f, 0.02107034f, -0.13788551f, 
    0.33900303f, 0.55362386f, -0.00164212f, -0.06850655f, 0.10040428f, 0.08411868f, 0.00468470f, 0.05398509f, 
    -0.68084306f, 0.29097050f, -0.51655132f, -0.05193618f, -0.22816525f, 0.09173822f, 0.06480860f, -0.09751977f, 
    -0.22713144f, 0.42276824f, 0.14679813f, -0.03581020f, 0.30945733f, 0.17932397f, 0.01235636f, 0.04681879f, 
    -0.27254212f, -0.30339622f, 0.05926350f, 0.05446361f, 0.07106362f, -0.02350901f, 0.16420789f, -0.26260483f, 
    -0.03227370f, 0.04161386f, -0.04193874f, -0.21611848f, -0.24833667f, -0.37482083f, 0.00294700f, 0.10345636f, 
    -0.11924589f, 0.12327275f, 0.10494804f, 0.09227432f, 0.03148876f, 0.25501448f, 0.03717569f, 0.09306820f, 
    0.07324482f, -0.00812282f, 0.24033281f, -0.17459749f, -0.29674995f, 0.13560729f, -0.39931500f, 0.02849379f, 
    -0.02894705f, 0.18619084f, 0.04118372f, -0.00517375f, -0.20215979f, -0.54769915f, -0.13460457f, -0.27514395f, 
    -0.20482817f, 0.11241401f, 0.13305520f, 0.08734749f, 0.15523867f, -0.11996095f, -0.11621461f, -0.08191172f, 
    -0.25545090f, -0.33397955f, -0.18661267f, -0.15334152f, -0.26794717f, -0.12337520f, 0.03429483f, 0.20328252f, 
    0.10047724f, -0.32986888f, -0.29786423f, -0.07617344f, 0.09090024f, -0.15840943f, -0.04239574f, 0.13383833f, 
    0.10353442f, 0.11104502f, -0.47603959f, -0.20517512f, 0.12134506f, 0.04776908f, 0.06719483f, 0.18489613f, 
    -0.00023818f, 0.25054955f, -0.29925072f, 0.13989119f, 0.07647359f, 0.01076320f, 0.05123189f, 0.02384029f, 
    -0.05323935f, -0.07481520f, 0.08104834f, 0.14114280f, 0.28844541f, 0.48238400f, -0.17676233f, 0.01580452f, 
    0.01934820f, -0.30229682f, 0.19063838f, 0.27099025f, 0.05455654f, 0.20407847f, -0.14693604f, 0.15402640f, 
    0.13448022f, 0.09370025f, 0.25093490f, 0.34588209f, 0.01470289f, 0.07753620f, 0.04135372f, -0.13840738f, 
    0.08110894f, 0.13604723f, 0.35368624f, -0.08991959f, -0.00408217f, -0.01992398f, -0.26095158f, 0.03728062f, 
    0.01094374f, 0.20981109f, -0.01228832f, -0.13713184f, 0.13926214f, 0.08000309f, 0.17134082f, 0.24219495f, 
    0.33007723f, 0.18666649f, 0.37069991f, 0.24914151f, -0.25038442f, -0.00903594f, 0.06824263f, -0.09857473f, 
    -0.69228685f, -0.01399799f, -0.11225368f, 0.20142215f, -0.09246197f, 0.23111442f, 0.22451535f, -0.01447747f, 
    -0.00943452f, -0.10797681f, -0.01499151f, -0.10008928f, -0.08983691f, 0.01773106f, -0.13859525f, -0.05201109f, 
    0.09127446f, 0.00361150f, -0.10228121f, 0.09074532f, 0.53142107f, -0.02280996f, 0.13130368f, 0.00483047f, 
    0.20032184f, 0.07692683f, -0.02991504f, -0.18493599f, -0.25487947f, -0.42667937f, 0.06151946f, 0.11956651f, 
    0.17923197f, -0.02396442f, -0.17610423f, -0.12491191f, 0.37247255f, 0.29526281f, -0.04303585f, 0.24956618f, 
    0.04863017f, 0.14791383f, -0.18690580f, -0.04097561f, 0.11537343f, -0.11326133f, -0.19835940f, 0.28498986f, 
    -0.09022451f, 0.14085151f, -0.20914954f, -0.15049629f, 0.09626589f, -0.05077826f, -0.10927574f, -0.08833595f, 
    -0.21097194f, 0.07593614f, -0.01938942f, 0.01517001f, -0.05206281f, -0.02277723f, 0.00647144f, 0.09610108f, 
    -0.15244111f, -0.14027548f, -0.07569855f, 0.16095929f, 0.08943065f, -0.05010896f, -0.00672611f, 0.06802547f, 
    0.23701222f, 0.02754653f, 0.02341436f, -0.12951536f, -0.05255568f, -0.06991364f, 0.10123564f, -0.00231109f, 
    0.04928124f, 0.12424145f, 0.13902812f, 0.53289640f, -0.23464416f, 0.30391678f, 0.08375950f, 0.38604623f, 
    0.26446003f, 0.36820066f, -0.13769904f, 0.19504513f, -0.02920705f, 0.22830148f, 0.15875834f, 0.20301118f, 
    -0.01421251f, 0.38623369f, 0.39956799f, 0.01129766f, -0.20747086f, 0.27840328f, -0.18605867f, 0.00258229f, 
    -0.04353969f, 0.08815705f, -0.04429334f, 0.19393979f, -0.20166349f, 0.18781973f, 0.12077817f, -0.09451886f, 
    -0.12621404f, -0.04983324f, -0.01817894f, -0.06862224f, 0.01078813f, 0.06818566f, 0.13178459f, 0.05163059f, 
    0.11194415f, 0.22644897f, 0.14098771f, -0.06763417f, -0.08137009f, -0.22025360f, 0.05872542f, -0.29301560f, 
    0.15838954f, 0.11896519f, 0.20792869f, -0.09936959f, 0.00003282f, -0.21444938f, -0.09253240f, -0.01117249f, 
    -0.05727975f, -0.21650153f, 0.05271630f, 0.00277825f, -0.25048345f, -0.03920380f, -0.02666945f, -0.03764379f, 
    -0.27140346f, -0.90188169f, -0.07120495f, -0.13095035f, 0.42892933f, 0.02086077f, 0.05920970f, 0.05666698f, 
    0.22046284f, -0.46943974f, 0.29944107f, -0.09441798f, 0.09960609f, -0.00874552f, 0.03620549f, -0.02154397f, 
    0.18264660f, 0.22281539f, -0.15464367f, 0.54692966f, -0.38876760f, 0.05760930f, 0.27395418f, -0.03404766f, 
    0.04840914f, -0.00566814f, 0.18086319f, -0.53642982f, -0.19231650f, 0.70988351f, -0.05995111f, 0.06156411f, 
    -0.04562987f, 0.10935575f, 0.01220769f, 0.02197237f, -0.14149109f, 0.25946373f, -0.01158129f, 0.01651234f, 
    0.08501612f, 0.02559005f, 0.20180550f, 0.21604943f, 0.09635320f, -0.09332991f, 0.12884879f, -0.33733991f, 
    -0.00750450f, 0.07839487f, 0.09874527f, 0.21879128f, 0.30601642f, -0.02534524f, 0.20089972f, -0.04557991f, 
    0.03776809f, -0.03865139f, -0.01217074f, -0.17219318f, 0.17149785f, 0.12067214f, 0.05212989f, -0.47586772f, 
    -0.01576958f, -0.17182571f, -0.10412607f, -0.20160355f, -0.21750860f, 0.16296567f, 0.07831360f, 0.05990822f, 
    -0.51944703f, -0.17590801f, -0.47547120f, 0.06078922f, 0.00865744f, -0.20146176f, 0.17678367f, -0.00113475f, 
    -0.09891997f, 0.21577564f, 0.34183285f, -0.14419560f, -0.10716430f, 0.22449477f, -0.13846077f, 0.00551579f, 
    -0.01379204f, -0.15706241f, -0.07292039f, 0.09601918f, -0.28016230f, -0.19111697f, 0.02920917f, 0.13801733f, 
    -0.00302867f, 0.26435283f, -0.19366550f, -0.24707562f, -0.59151024f, -0.63986987f, -0.16581905f, -0.09807961f, 
    -0.20643742f, -0.04716578f, -0.28810242f, -0.14064045f, 0.15070003f, 0.09982999f, -0.08689814f, 0.12209680f, 
    0.03586427f, 0.01139984f, -0.16411921f, 0.08162476f, -0.04249278f, 0.17319004f, 0.28137326f, 0.18224831f, 
    -0.03671162f, -0.01408278f, -0.22360556f, 0.02885724f, -0.12774223f, -0.38232446f, 0.03187971f, 0.12977470f, 
    0.23161860f, -0.06965176f, -0.10441715f, 0.23081830f, 0.10301044f, -0.10051874f, -0.08252720f, 0.20338392f, 
    0.24008027f, 0.23843981f, -0.00097227f, 0.02010567f, 0.20983006f, 0.03374123f, -0.05972916f, 0.00114945f, 
    -0.02948116f, -0.84270138f, -0.78177416f, 0.01103199f, 0.04568399f, 0.18047214f, 0.11039482f, -0.06146771f, 
    -0.04175593f, -0.09172450f, -0.39068931f, 0.21856050f, 0.10631541f, 0.10980526f, -0.15163200f, 0.15607104f, 
    -0.02766708f, -0.18265998f, 0.17749020f, -0.45905805f, 0.10636852f, 0.31717536f, 0.25474533f, 0.05642991f, 
    0.43827859f, 0.01980686f, -0.00610407f, -0.06583391f, -0.66727424f, -0.44729802f, 0.10544416f, 0.04290580f, 
    0.01346579f, 0.00028968f, -0.02589736f, 0.06057158f, 0.66705692f, -0.19073412f, -0.20706654f, 0.25211635f, 
    0.02514979f, 0.20666137f, -0.00278616f, -0.02664213f, -0.03343154f, -0.25162184f, -0.09405980f, 0.42024752f, 
    -0.12928732f, -0.14875673f, -0.15154600f, 0.16502726f, -0.07752723f, -0.08262706f, 0.48245320f, -0.24904168f, 
    0.12578304f, -0.33755952f, -0.38050148f, -0.00372006f, -0.11904008f, -0.18903767f, -0.06307016f, 0.45632964f, 
    0.04384513f, -0.00134189f, -0.23698202f, -0.10514682f, -0.07521596f, -0.09505598f, 0.06459512f, 0.11902680f, 
    -0.60676450f, -0.35674962f, 0.25027314f, 0.18827075f, 0.02598051f, 0.03958450f, -0.14041971f, 0.05712253f, 
    -0.00728861f, 0.27695063f, -0.53593218f, -0.00254447f, 0.15175596f, 0.06687604f, 0.06334048f, 0.26717195f, 
    0.03190718f, -0.02988888f, 0.21551962f, 0.09134147f, -0.16512956f, 0.03012117f, 0.12171508f, 0.03353529f, 
    0.10388661f, -0.05669301f, 0.17095681f, -0.82346243f, -0.15626454f, 0.38553333f, 0.02882128f, -0.04435476f, 
    -0.16946512f, 0.10201681f, 0.13318868f, 0.34727845f, 0.24274753f, -0.00008010f, -0.08853180f, -0.03043013f, 
    0.16148390f, -0.08450852f, 0.16806300f, 0.24521329f, 0.27251399f, 0.20636722f, 0.34966922f, 0.14019877f, 
    0.10523304f, -0.05148337f, 0.07540832f, 0.10935222f, -0.03274547f, 0.25685793f, -0.18156636f, 0.32136190f, 
    -0.77266711f, -0.20259674f, 0.04676567f, -0.07393314f, 0.01329870f, -0.11446504f, 0.10213267f, -0.54589003f, 
    -0.24202606f, -0.52229750f, -0.08101743f, 0.05962636f, -0.18810891f, 0.14649530f, -0.09157179f, -0.06364239f, 
    0.08008211f, 0.04280450f, -0.81700742f, 0.02929726f, -0.00094348f, 0.25767022f, -0.03781027f, 0.15476130f, 
    0.02445854f, 0.29954240f, 0.23753580f, 0.28731307f, 0.13920748f, -0.10788947f, 0.03594033f, -0.02609452f, 
    0.01458743f, -0.01345505f, 0.58755046f, 0.39560360f, -0.24957949f, -0.08614019f, 0.32761687f, 0.01163307f, 
    0.13724416f, -0.01993780f, 0.08713110f, -0.18146926f, -0.18251054f, 0.35178778f, 0.04192396f, 0.02578154f, 
    -0.07879314f, -0.09351251f, 0.23901273f, -0.17541060f, 0.34068662f, -0.25473133f, -0.29009336f, -0.00412866f, 
    0.05598617f, 0.11943628f, -0.03223535f, -0.06954685f, -0.13356765f, -0.02466078f, -0.01241479f, -0.22163060f, 
    0.12294894f, -0.14693472f, -0.17144726f, 0.10143946f, -0.10494839f, -0.04451998f, 0.07868978f, -0.33567369f, 
    0.12670165f, 0.09041975f, 0.16729513f, 0.19022045f, 0.02108439f, -0.10983359f, -0.03373576f, -0.77214152f, 
    -0.00586803f, 0.31328049f, -0.13658881f, -0.04911543f, 0.12579289f, 0.12622206f, -0.04319283f, -0.09448253f, 
    -0.41768897f, -0.11580259f, 0.06351089f, 0.16635026f, 0.13509846f, -0.11272418f, 0.10240348f, -0.01011745f, 
    0.08041356f, -0.07519277f, -0.27889073f, -0.08647507f, -0.09159961f, -0.16230313f, 0.06362005f, 0.18497124f, 
    -0.02414671f, 0.17066288f, 0.46056855f, 0.21704981f, 0.03522856f, 0.14944327f, 0.28075358f, -0.06221215f, 
    0.20295288f, -0.16061571f, 0.07701993f, -0.48875749f, -0.19113478f, -0.24993691f, -0.19439255f, 0.07437216f, 
    0.02189680f, 0.07978157f, -0.04093068f, 0.37400460f, 0.60053325f, -0.35368586f, -0.25702912f, 0.15594722f, 
    0.05280431f, 0.13192827f, 0.02894688f, -0.06376570f, 0.23528996f, 0.06454899f, -0.25044170f, -0.45942882f, 
    0.14348069f, -0.30386794f, -0.05885621f, 0.02409341f, 0.01831811f, 0.14007187f, -0.23960759f, 0.11694892f, 
    0.44470301f, -0.09201808f, -0.16845089f, 0.05073529f, 0.18719807f, -0.02715155f, -0.09183330f, 0.09223877f, 
    0.42498463f, 0.29445779f, 0.08280984f, 0.07728212f, -0.16197906f, -0.00756151f, -0.18717182f, -0.21221671f, 
    0.17805786f, 0.16470945f, 0.64023429f, 0.24837261f, 0.27312195f, 0.32619250f, -0.01350729f, -0.02548373f, 
    -0.15165699f, 0.08470237f, 0.04311906f, 0.22226961f, 0.15020949f, 0.02302597f, -0.03772116f, 0.02811968f, 
    0.14074863f, 0.05950126f, 0.22478314f, 0.03296779f, 0.31687403f, -0.02007134f, 0.13744853f, 0.24738330f, 
    0.05049574f, 0.20977828f, 0.04003759f, -0.15491734f, 0.25323218f, 0.28565419f, 0.03536545f, 0.23304138f, 
    0.19728684f, 0.10777085f, 0.09519669f, 0.19146658f, -0.10320517f, -0.22856006f, 0.02792098f, -0.08589257f, 
    0.15858364f, 0.13398649f, 0.14570612f, 0.14479172f, 0.37478045f, 0.13072556f, 0.41817361f, 0.31048241f, 
    -0.22778991f, -0.14903316f, -0.03133007f, 0.11156373f, 0.23565996f, -0.12775244f, -0.07228336f, -0.02670248f, 
    0.18958651f, 0.19853073f, 0.07723857f, 0.00147695f, -0.07402926f, -0.09242518f, 0.11639595f, 0.16036932f, 
    -0.00260395f, 0.20446865f, 0.11766795f, 0.16562530f, -0.12373006f, 0.06803635f, -0.34064889f, -0.34039089f, 
    0.24466905f, 0.17455927f, 0.01497012f, -0.15561825f, 0.06996539f, -0.05475913f, 0.13293414f, -0.04822019f, 
    0.03473421f, 0.12795526f, 0.30014828f, 0.28070313f, 0.10724140f, 0.21805297f, 0.00659202f, -0.15715992f, 
    0.27310985f, 0.17504697f, 0.01601036f, 0.01824119f, -0.04077474f, 0.11475123f, -0.03616987f, -0.05456746f, 
    -0.12215683f, -0.23837389f, -0.62759829f, -0.19199368f, -0.04828610f, -0.51691043f, 0.09710817f, 0.01513385f, 
    -0.40110663f, -0.13567893f, -0.07296307f, -0.20530877f, -0.19295897f, -0.54433680f, 0.01887005f, 0.07024965f, 
    0.08065202f, 0.11207878f, -0.39541659f, 0.10893323f, -0.08395937f, -0.08041906f, -0.10331490f, 0.00877596f, 
    -0.02715341f, 0.09196512f, 0.30835214f, -0.13713723f, -0.01655458f, 0.04200463f, -0.01457367f, 0.12192837f, 
    -0.07337937f, 0.13522625f, 0.03265121f, 0.32142332f, 0.03353209f, -0.23300181f, -0.32089034f, -0.00351887f, 
    0.05499645f, 0.04764666f, 0.09458654f, 0.09972974f, 0.10125751f, 0.09012204f, 0.06646045f, -0.08089004f, 
    0.29701906f, -0.91678369f, 0.20857932f, 0.24743955f, 0.26860964f, -0.12765405f, -0.14610773f, 0.14014868f, 
    -0.24801619f, -0.15260355f, 0.03672789f, 0.35825267f, 0.09623090f, -0.09691533f, -0.01036201f, -0.03333932f, 
    -0.00216886f, 0.10254440f, -0.20993312f, 0.09030652f, -0.38767686f, 0.10200339f, -0.19432390f, 0.14975742f, 
    0.20172761f, 0.17278636f, 0.03307207f, -0.09058027f, -0.42647997f, 0.22187142f, -0.19214305f, 0.04610385f, 
    0.25432086f, 0.10178804f, 0.08469438f, -0.02767596f, 0.56674445f, 0.46439511f, 0.30267856f, -0.02393804f, 
    0.02441241f, 0.14620960f, 0.10514447f, 0.24075699f, -0.04770753f, -0.12781407f, -0.55077595f, -0.31804839f, 
    0.12679823f, 0.01835233f, 0.13192867f, 0.18216629f, 0.00349753f, -0.14117675f, 0.36133331f, 0.19678372f, 
    0.17128360f, -0.22148894f, -0.32049009f, -0.31386885f, 0.12752682f, 0.07308541f, -0.21100120f, -0.10691732f, 
    -0.17450123f, -0.33404613f, -0.18088503f, 0.02371710f, 0.17923725f, 0.13701929f, 0.05048005f, -0.08178433f, 
    0.17031465f, -0.38208571f, -0.34317976f, -0.16491534f, -0.03110664f, 0.02780339f, -0.06708600f, -0.03018257f, 
    -0.12527286f, -0.49809420f, 0.11848101f, -0.48910466f, 0.02266236f, 0.23460616f, -0.00788618f, 0.14246680f, 
    -0.11326408f, -0.04424258f, 0.16610879f, -0.03990825f, -0.16289917f, 0.07072972f, 0.09423383f, -0.05182749f, 
    0.01813627f, -0.26684931f, -0.02831222f, -0.56573069f, -0.25269642f, -0.56202829f, -0.03094353f, 0.08294220f, 
    -0.05173000f, -0.05834064f, -0.09555630f, 0.10285757f, 0.62604785f, 0.34712029f, 0.31107846f, -0.13582700f, 
    -0.11619291f, -0.23778522f, -0.15359077f, 0.00546620f, 0.30059704f, 0.09769376f, 0.24367256f, 0.07365882f, 
    -0.23419325f, -0.06353267f, -0.20960259f, 0.05145248f, -0.02806866f, 0.09991979f, 0.54110581f, -0.03340626f, 
    -0.12076249f, -0.37860370f, -0.08369544f, 0.14544468f, 0.16186906f, 0.04377952f, 0.02546701f, 0.22410505f, 
    -0.32299855f, -0.13401847f, -0.14762615f, 0.01676285f, -0.08563971f, -0.10761149f, -0.03505551f, 0.01167179f, 
    -0.04033968f, 0.09643868f, 0.14639762f, -0.11426231f, -0.05609176f, -0.04954552f, 0.01741974f, -0.15797666f, 
    -0.08883170f, -0.05225219f, -0.18143022f, -0.21983291f, 0.00068872f, 0.11812228f, -0.04295432f, 0.25304586f, 
    0.10190485f, 0.04378220f, 0.36010996f, 0.08776385f, -0.17026554f, 0.27686703f, 0.00247782f, 0.12085268f, 
    0.18705843f, 0.12536736f, -0.00911898f, 0.15335569f, -0.19106935f, -0.10460978f, 0.06106573f, 0.11577746f, 
    0.07368366f, 0.12998620f, -0.13170677f, 0.11940164f, 0.15336730f, -0.00375275f, -0.25892976f, 0.15017357f, 
    0.16645446f, -0.13325247f, 0.16301048f, 0.22661261f, 0.27177000f, -0.15798408f, -0.22104178f, -0.27222085f, 
    0.03645055f, -0.10456131f, -0.11468171f, 0.21377352f, 0.00170705f, 0.27424872f, -0.05727615f, 0.23795353f, 
    0.23895259f, -0.02436716f, 0.05564722f, -0.07650533f, -0.14642461f, 0.17999718f, -0.08085749f, -0.38517770f, 
    0.00716342f, 0.02790632f, -0.07438823f, -0.05365534f, -0.09777635f, -0.33442116f, -0.16614251f, -0.34453338f, 
    -0.15188853f, 0.21727432f, 0.21704543f, -0.22385134f, -0.31069148f, 0.02779391f, 0.12108935f, -0.29719400f, 
    0.21971187f, 0.38831466f, -0.47147045f, 0.05210708f, 0.12208883f, 0.34851199f, -0.03890808f, -0.22724064f, 
    0.36728948f, 0.01443383f, -0.10704637f, -0.03561610f, -0.16048253f, 0.13670994f, -0.21835142f, 0.10559994f, 
    -0.40765187f, -0.11986975f, -0.39248982f, -0.20197937f, 0.10174106f, -0.05297391f, 0.34910145f, 0.04884931f, 
    0.21314891f, -0.08446926f, -0.31112352f, -0.47541666f, -0.12721653f, -0.30831441f, -0.05768505f, 0.08180430f, 
    0.07742309f, 0.18728191f, 0.02042770f, 0.06316375f, -0.13389251f, -0.15684204f, 0.04291817f, 0.12899898f, 
    0.11716753f, 0.02827610f, 0.17277528f, 0.04935558f, 0.02574994f, -0.17599182f, -0.16168885f, 0.09562422f, 
    -0.02233666f, 0.06125958f, 0.10768852f, 0.12258745f, -0.06994241f, 0.14079089f, 0.15818286f, -0.05757721f, 
    0.28604567f, -0.04845132f, -0.06661064f, -0.01834185f, -0.03588464f, 0.17970535f, 0.34333166f, 0.01213154f, 
    0.15775199f, -0.08516991f, -0.34087482f, -0.02463308f, 0.13732401f, 0.06430317f, 0.03851673f, 0.22742346f, 
    0.13513851f, 0.03464032f, -0.06600035f, 0.16299744f, 0.22299947f, 0.12357958f, 0.07405579f, 0.06212267f, 
    -0.00085204f, 0.14503837f, -0.11593901f, 0.28893971f, 0.36429769f, 0.14784631f, 0.09406013f, -0.15227924f, 
    0.16907862f, 0.06718844f, 0.14635617f, 0.30590409f, -0.31440499f, -0.48480818f, 0.20898826f, 0.01966339f, 
    0.10039253f, 0.03813060f, -0.08031866f, -0.08918817f, 0.13067730f, 0.49301046f, 0.29505017f, -0.05896947f, 
    -0.04852226f, -0.08840552f, 0.02230718f, -0.28101128f, -0.00430553f, -0.12485935f, -0.61459929f, -0.30303204f, 
    0.19665246f, 0.05369960f, 0.00988153f, 0.05618522f, 0.06133445f, -0.15881294f, 0.23290138f, -0.00266769f, 
    0.01169052f, -0.16918127f, -0.14677164f, -0.07928254f, -0.20620032f, 0.06339981f, 0.05640239f, -0.02089214f, 
    0.19748639f, 0.09168376f, 0.11630199f, -0.16388261f, 0.03469925f, -0.11770777f, 0.01166399f, 0.17679036f, 
    -0.39590850f, -0.17812869f, 0.30781409f, 0.31433186f, 0.07363877f, -0.03125372f, 0.01656334f, 0.10634584f, 
    -0.01698605f, 0.25102770f, 0.40538731f, -0.26410869f, 0.00771375f, 0.09486531f, 0.20932899f, 0.23691824f, 
    -0.18178089f, -0.02856520f, -0.23577078f, 0.31912050f, -0.14719000f, -0.09779420f, 0.08627193f, 0.15229432f, 
    0.13151814f, 0.15362355f, 0.20273973f, -0.31640050f, -0.04677330f, 0.17198159f, 0.04204902f, 0.20584448f, 
    0.03784302f, 0.12317223f, -0.09815704f, 0.21812207f, 0.00489852f, 0.04718323f, 0.13987455f, 0.15347026f, 
    -0.02700791f, -0.06965510f, 0.07133019f, 0.10261111f, 0.16516553f, 0.06514224f, 0.09490082f, 0.03521516f, 
    0.04318968f, 0.01832904f, -0.08597128f, 0.02204814f, 0.14654635f, 0.20997941f, -0.10572995f, 0.38373852f, 
    0.48754066f, 0.01359755f, -0.21247353f, -0.04258798f, -0.34134525f, -0.02023956f, 0.18709728f, 0.20021427f, 
    0.02844670f, 0.20217916f, 0.16287868f, -0.06264336f, -0.04078339f, -0.07968827f, 0.02491642f, -0.14894041f, 
    0.47353148f, -0.46946856f, -0.54064125f, 0.04040092f, -0.03725277f, -0.09792984f, 0.04601715f, 0.14097410f, 
    0.03111772f, -0.39473823f, -0.40534967f, 0.05106476f, -0.00655140f, -0.02041430f, 0.10079832f, 0.02801042f, 
    0.22361971f, 0.18669368f, 0.43415657f, 0.27527428f, -0.08957474f, 0.19828439f, 0.17343640f, -0.12830324f, 
    -0.00254746f, 0.25525719f, 0.23763244f, 0.83114433f, 0.01574388f, -0.27549839f, -0.07524386f, -0.09054013f, 
    -0.05849506f, 0.07328276f, -0.00147278f, 0.21878815f, -0.27159873f, -0.31059185f, 0.28932291f, 0.10960440f, 
    0.14193019f, 0.13582475f, 0.04219032f, 0.15540618f, 0.19678141f, 0.41681811f, -0.02495029f, -0.47265959f, 
    0.07501186f, 0.06593574f, -0.16020642f, 0.09694169f, 0.24871455f, -0.03461521f, -0.37244323f, -0.15005814f, 
    0.06802568f, -0.06513835f, -0.26546869f, -0.27541751f, -0.21302822f, 0.07749379f, -0.01699624f, 0.12887172f, 
    0.07754978f, 0.34498087f, -0.05551688f, 0.00786939f, -0.02784533f, -0.01753091f, -0.33086598f, -0.27332839f, 
    0.32072124f, 0.28700563f, 0.56505567f, -0.05024698f, -0.11779780f, 0.01261219f, -0.13876840f, -0.01271438f, 
    -0.04378893f, 0.05254231f, -0.26905337f, 0.07463449f, -0.14270936f, 0.12347040f, -0.11259846f, 0.08905604f, 
    0.04557151f, 0.41692194f, 0.08113672f, -0.09000130f, 0.04666539f, 0.07535010f, -0.02454985f, 0.19931106f, 
    0.04394386f, 0.00666213f, -0.15950130f, -0.31399834f, -0.05550913f, 0.20819822f, 0.07306957f, 0.00521321f, 
    -0.04574038f, -0.04364928f, -0.18901601f, -0.23710522f, -0.21308234f, -0.09006467f, 0.06821690f, -0.03048491f, 
    -0.24930333f, -0.00115051f, -0.18274888f, 0.16233939f, -0.00124127f, -0.15346555f, -0.02739843f, 0.04193973f, 
    0.00209661f, -0.12493783f, -0.12081762f, 0.10966126f, -0.13860901f, 0.22727461f, -0.07846664f, -0.18129519f, 
    -0.39187309f, -0.04494878f, 0.02451827f, -0.06432495f, 0.06526669f, 0.05644855f, -0.25756779f, -0.66241181f, 
    -0.40610686f, -0.53206038f, 0.03291701f, -0.03187293f, -0.17372519f, 0.02711579f, 0.09928624f, 0.14059660f, 
    0.05324398f, 0.02663028f, 0.01096844f, -0.06466330f, 0.00926259f, -0.01326435f, -0.00725615f, -0.03417673f, 
    -0.03236877f, -0.05860548f, -0.06699678f, -0.07666883f, 0.06145602f, -0.05516110f, 0.01708772f, -0.06544809f, 
    -0.00314650f, -0.01462473f, 0.05808684f, 0.05870983f, -0.06685925f, -0.02603853f, -0.04500021f, 0.07076612f, 
    -0.07717778f, -0.07437509f, 0.03289567f, -0.00160207f, 0.00827442f, -0.03948012f, -0.01031564f, -0.08008451f, 
    -0.09213421f, 0.00052976f, -0.06261690f, 0.06311785f, -0.08082750f, 0.05971767f, 0.01075767f, -0.02004107f, 
    0.05662200f, 0.05603085f, 0.05301346f, -0.07635076f, -0.08326830f, -0.08952047f, -0.05642295f, -0.09748283f, 
    -0.05501356f, -0.08609901f, -0.08445599f, -0.00228427f, 0.03295119f, 0.03333237f, 0.01739432f, 0.03458850f, 
    -0.01716067f, -0.05444269f, 0.01636101f, 0.00826820f, -0.05616553f, -0.04990480f, 0.02548641f, -0.07691415f, 
    -0.07971983f, -0.01060183f, 0.03465661f, -0.06837235f, 0.02608577f, -0.02244683f, -0.08218931f, 0.05639413f, 
    -0.05194733f, 0.00634930f, 0.03222727f, 0.03075640f, -0.07759412f, 0.05931232f, 0.05811810f, 0.04933092f, 
    0.06835351f, 0.00270913f, -0.08211069f, 0.00139181f, -0.02940386f, -0.02702620f, 0.05026042f, -0.05806372f, 
    0.07207540f, -0.07551501f, 0.01382373f, -0.07977680f, -0.08039539f, 0.06402621f, 0.01039534f, 0.01483221f, 
    -0.07304780f, 0.01286735f, -0.01069809f, -0.08413368f, 0.03505579f, 0.01272644f, 0.05988955f, 0.06595211f, 
    -0.06899112f, -0.05904826f, -0.02917382f, 0.07557688f, 0.05619400f, 0.01289327f, 0.06217777f, 0.03905822f, 
    -0.07653493f, -0.06363934f, 0.07012639f, -0.01425023f, -0.01127834f, 0.06812371f, -0.05352733f, -0.00132619f, 
    -0.01256381f, -0.04613023f, -0.10407285f, -0.08903591f, -0.07801761f, -0.07385976f, 0.05917539f, -0.05774735f, 
    0.05711733f, 0.06396256f, 0.03401806f, -0.07257596f, -0.02329625f, -0.04703619f, 0.07708638f, -0.02390667f, 
    0.03591582f, -0.07954069f, 0.03311177f, 0.03416467f, -0.02898687f, -0.08008171f, -0.02730142f, -0.00218014f, 
    -0.02589067f, 0.04090887f, -0.00237081f, 0.03980882f, -0.06236626f, 0.02773701f, 0.05963866f, -0.03827205f, 
    -0.02339126f, -0.06329226f, -0.07393975f, -0.02286577f, -0.05156970f, 0.05201693f, -0.05817841f, 0.03200953f, 
    0.02067907f, -0.07903444f, 0.03912823f, -0.01512928f, 0.01044195f, 0.04881518f, -0.05218007f, -0.01459138f, 
    -0.04658914f, -0.02356782f, -0.06277692f, 0.06524920f, 0.03384591f, 0.03792034f, -0.02758030f, 0.06934923f, 
    -0.03678877f, -0.01986557f, -0.05484176f, -0.03745485f, 0.02523923f, -0.02628740f, 0.00907910f, -0.05422993f, 
    -0.02535540f, -0.03794596f, 0.05091411f, -0.07683693f, 0.07449112f, 0.03564976f, -0.02155043f, -0.01572857f, 
    -0.01036636f, 0.05499179f, -0.02832199f, 0.00028067f, -0.07988720f, -0.04959261f, 0.06476413f, -0.07962988f, 
    -0.01309528f, -0.01149250f, -0.01933124f, 0.02278686f, -0.05439183f, -0.03110629f, 0.00164032f, -0.01441840f, 
    -0.05704497f, -0.07575691f, -0.01068320f, 0.00448384f, 0.01323362f, 0.05688206f, 0.06820692f, -0.05364706f, 
    0.01026911f, -0.05813119f, 0.00521725f, 0.03420520f, -0.00697619f, -0.06400649f, -0.02834162f, 0.05498429f, 
    0.00051237f, -0.07311194f, -0.07110565f, 0.03892662f, 0.02372957f, -0.09290025f, -0.05286590f, -0.08462383f, 
    0.02296277f, -0.03768449f, 0.04197552f, -0.05217818f, 0.00411576f, 0.05128058f, -0.03190935f, 0.02042311f, 
    0.00717758f, -0.05715640f, -0.05196182f, 0.04424538f, 0.03921722f, -0.09162264f, 0.05064175f, -0.02442181f, 
    0.00925590f, -0.04776425f, 0.03262930f, -0.02058653f, -0.07566106f, -0.08680350f, -0.08813953f, -0.02305516f, 
    -0.05725079f, -0.06244520f, -0.03746849f, 0.02176990f, 0.02113258f, -0.05377279f, 0.05445973f, -0.08535781f, 
    0.07488056f, -0.08845193f, 0.03356302f, 0.01588909f, -0.02290308f, -0.04207176f, -0.01685956f, -0.06968240f, 
    -0.03301597f, 0.00804071f, 0.05880704f, -0.02515611f, -0.00505589f, -0.01046245f, 0.07014956f, -0.03844319f, 
    0.05159679f, -0.09056029f, 0.03845249f, 0.06729603f, -0.02039577f, -0.04983778f, 0.00631171f, 0.04445208f, 
    -0.18289638f, -0.57438916f, -0.39050171f, 0.07328345f, -0.23892044f, 0.22648448f, 0.25235558f, 0.16613768f, 
    -0.19184762f, 0.18158299f, 0.36744010f, 0.37073830f, -0.02014674f, 0.01268653f, -0.28317070f, -0.10633735f, 
    0.15863796f, 0.19879779f, 0.07522953f, -0.25240278f, -0.66999006f, -0.17193936f, 0.04596936f, -0.08613244f, 
    0.14860526f, 0.11125264f, 0.04479922f, 0.28139895f, 0.02667053f, 0.35979721f, -0.03573715f, 0.12173148f, 
    -0.15253402f, -0.03023322f, 0.16903886f, -0.09958437f, -0.48237759f, -0.22451124f, -0.31733859f, -0.03369353f, 
    -0.14319088f, -0.15102319f, 0.04829219f, 0.10584263f, 0.11195816f, 0.24812536f, 0.40292522f, -0.26849487f, 
    -0.02498075f, 0.16826497f, 0.21457663f, 0.10481072f, 0.10578091f, 0.03614740f, 0.19649811f, -0.10911503f, 
    -0.07478642f, 0.05820120f, -0.08204648f, -0.11442007f, 0.18426688f, -0.05385686f, -0.08010987f, 0.28092656f, 
    0.35799772f, 0.09109660f, -0.12326957f, 0.04011928f, -0.02347384f, -0.03780280f, 0.20075952f, -0.14907332f, 
    0.54153961f, 0.21014759f, -0.11282942f, -0.03406007f, 0.00930365f, 0.29621854f, 0.04517248f, -0.13668580f, 
    0.00269010f, -0.31589288f, -1.11063004f, -0.03980955f, -0.22917171f, -0.21113235f, 0.06381639f, -0.06963494f, 
    0.32395536f, -0.01446384f, 0.36470750f, -0.17974091f, 0.19122793f, 0.06198476f, -0.18683100f, 0.18122649f, 
    0.09626681f, -0.12586451f, -0.11030880f, 0.33943653f, -0.16521464f, -0.24741803f, -0.00675445f, 0.02945540f, 
    0.13498878f, 0.07956578f, 0.01369165f, 0.00134985f, -0.25916561f, 0.09423620f, 0.18260077f, 0.11939234f, 
    0.03742608f, -0.10113428f, -0.04443192f, -0.06162126f, -0.04158602f, -0.13471273f, -0.01418440f, -0.21818882f, 
    -0.17160468f, -0.14832637f, -0.15065409f, -0.02202558f, 0.06802592f, -0.01609922f, 0.39690921f, 0.18001676f, 
    0.16992353f, -0.06339598f, 0.08593379f, -0.20852736f, 0.03142627f, -0.03397692f, 0.10769063f, 0.22564739f, 
    0.39327139f, 0.34278545f, -0.16258541f, 0.04802434f, -0.02926300f, 0.05041275f, -0.04020312f, 0.02775245f, 
    -0.08500043f, -0.08387525f, 0.04859678f, 0.05653775f, 0.06909330f, -0.00023756f, -0.03628178f, 0.02000099f, 
    -0.04327096f, -0.03713386f, -0.07602298f, 0.05022746f, 0.04685819f, 0.01346939f, 0.00076577f, -0.01881480f, 
    0.06810892f, -0.01078506f, 0.03164729f, 0.02609480f, -0.07754515f, -0.00625070f, 0.00161879f, -0.06254221f, 
    0.01002487f, 0.03667422f, -0.04121450f, 0.00273502f, 0.00746984f, 0.06103627f, 0.00656857f, 0.05351493f, 
    -0.00786067f, 0.03990474f, -0.06904868f, -0.01265565f, 0.00968748f, -0.07666901f, 0.05587731f, -0.02871809f, 
    0.06116119f, 0.03773174f, 0.03524374f, -0.02831053f, -0.02225388f, -0.06865610f, -0.05135488f, 0.04251136f, 
    0.03481489f, 0.02039756f, 0.01880985f, -0.01623440f, 0.01113337f, -0.03554628f, -0.08407880f, 0.05312369f, 
    0.03063918f, 0.05156995f, 0.02087417f, -0.05840419f, -0.06974354f, 0.05596987f, -0.08047033f, -0.06457593f, 
    0.06677584f, -0.09032907f, -0.05791812f, -0.00971959f, -0.05378024f, 0.00096747f, -0.06040799f, 0.02255563f, 
    0.04930992f, -0.04288763f, -0.08433924f, -0.01403622f, -0.08886753f, -0.01967997f, -0.02405450f, -0.03819548f, 
    -0.03402997f, 0.02493921f, 0.04368198f, -0.08856744f, -0.07463676f, -0.08749903f, -0.02218115f, -0.02559030f, 
    0.02569166f, -0.08324798f, -0.04826918f, 0.03975045f, -0.01346304f, -0.02851949f, 0.06007287f, 0.01230693f, 
    -0.05619849f, 0.02340454f, -0.05534581f, -0.00219778f, -0.07820555f, 0.06610603f, -0.05220502f, -0.06399301f, 
    -0.03466761f, -0.00648126f, -0.00745305f, 0.01300515f, -0.00223602f, 0.03977649f, -0.05917677f, -0.02590054f, 
    0.06085794f, 0.02224209f, -0.03047161f, -0.06362160f, -0.07970565f, -0.08172356f, 0.05398304f, 0.03860718f, 
    -0.04604267f, -0.07337850f, 0.00928718f, 0.03412444f, -0.02477394f, 0.04526009f, -0.06984698f, -0.03442404f, 
    0.04734096f, -0.07889415f, -0.07810471f, -0.07026825f, 0.05290592f, 0.00535569f, 0.01102340f, 0.01329374f, 
    0.00808628f, -0.05429308f, -0.06851587f, 0.04141659f, -0.06569020f, -0.02189005f, 0.00991425f, -0.01135603f, 
    0.01485741f, -0.00476296f, 0.06537864f, -0.05567959f, 0.06402066f, 0.03807175f, -0.08161642f, 0.00465850f, 
    -0.03949805f, -0.08784684f, -0.02821894f, -0.07351000f, 0.02403074f, 0.06454021f, -0.02958780f, 0.01985592f, 
    -0.05898809f, -0.05235585f, -0.04401970f, 0.02160882f, -0.00667983f, -0.00925171f, -0.00975189f, -0.09324316f, 
    -0.06324492f, -0.07611656f, -0.02380292f, -0.02173343f, -0.05636965f, -0.03641839f, -0.09710420f, 0.01852712f, 
    -0.00410414f, -0.02225332f, -0.00482288f, -0.07756014f, -0.04901106f, 0.02988395f, 0.05559539f, 0.05001315f, 
    -0.05336338f, 0.06134637f, -0.05017992f, -0.05763672f, -0.05469640f, -0.00891880f, 0.04907639f, -0.01019904f, 
    0.05323637f, 0.00144113f, -0.06619386f, 0.05599485f, -0.05774514f, 0.05258655f, 0.00227854f, -0.06887826f, 
    -0.08365226f, -0.07912679f, 0.04971872f, -0.08807692f, -0.01376513f, 0.02502331f, -0.09312590f, -0.09445378f, 
    -0.07221211f, -0.07740854f, -0.03605406f, -0.02003746f, -0.01879607f, -0.05136816f, 0.07756007f, -0.04248350f, 
    -0.06069697f, -0.01509361f, -0.00854100f, 0.01222790f, -0.04015469f, 0.06151742f, -0.06415947f, 0.06510142f, 
    -0.02306572f, -0.05863846f, 0.01148246f, -0.06398799f, -0.01623912f, -0.03643586f, -0.03975259f, 0.04713066f, 
    0.04106151f, -0.08689997f, -0.00007711f, -0.09184944f, -0.05018283f, -0.06836236f, 0.03003502f, -0.08036913f, 
    0.04241564f, -0.07573500f, -0.04332610f, -0.08828774f, -0.07932405f, -0.02025588f, 0.04107607f, 0.01494359f, 
    -0.02052954f, 0.06473094f, 0.03620946f, -0.07815537f, -0.04457387f, 0.00099789f, -0.02465869f, -0.08599589f, 
    -0.08731624f, 0.01806274f, 0.00540552f, -0.07878363f, 0.05918828f, -0.07814101f, -0.07031499f, -0.08727680f, 
    -0.06627141f, 0.03189963f, 0.01183414f, -0.07712218f, -0.05881498f, -0.03138265f, 0.00548400f, -0.06951614f, 
    -0.06179413f, 0.00784447f, -0.00843787f, -0.00397393f, 0.06224680f, -0.06863829f, -0.06887607f, 0.04838963f, 
    0.04979609f, -0.02643437f, 0.03297349f, -0.08718404f, 0.00056016f, -0.03456783f, -0.02662520f, -0.05011079f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.18268992f, 0.03077538f, 0.16124459f, 0.24842985f, 0.24210998f, 0.20290978f, 0.17436479f, 0.25700063f, 
    0.23889691f, 0.23015566f, 0.36221069f, -0.02377968f, 0.02254013f, -0.09722903f, -0.00069151f, -0.08348634f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.04754799f, 0.51715648f, 0.35668316f, -0.29400635f, 0.03178119f, 0.18284687f, -0.07637120f, -0.03934829f, 
    -0.30899304f, 0.51802003f, 0.23082538f, 0.04454868f, 0.14799343f, -0.44130290f, 0.12115207f, 0.26273167f, 
    0.44458434f, -0.25649267f, -0.27208409f, -0.12688047f, -0.29769263f, 0.34274295f, 0.29060242f, -0.90081745f, 
    -0.51883823f, -0.00302075f, 0.59864140f, -0.03885045f, 0.23084904f, -0.33181489f, -0.08546031f, -0.14432198f, 
    0.45024991f, 0.31487444f, 0.05163157f, -0.10628533f, -0.53186774f, 0.20324036f, -0.43317148f, 0.55609739f, 
    -0.58165359f, 0.38231981f, -0.02459243f, -0.24674349f, -0.03719559f, -0.25566146f, 0.18789515f, -0.11031152f, 
    0.21243905f, 0.19014353f, 0.05436116f, -0.23865049f, -0.90981913f, 0.35216981f, 0.11320831f, 0.09469022f, 
    0.02189270f, 0.34023958f, -0.06909611f, 0.04356295f, -0.16930020f, -0.32245225f, -0.19385415f, -0.02002761f, 
    0.15330173f, -0.29247466f, -0.04638400f, 0.09859722f, -0.24918216f, 0.31103623f, 0.22231072f, 0.40663323f, 
    0.43437195f, -0.39560676f, 0.11614802f, 0.00881636f, 0.14391591f, 0.03288903f, 0.04727657f, 0.00812919f, 
    -0.23568842f, -0.29266000f, 0.28460097f, 0.22977164f, -0.53890854f, -0.16352539f, 0.24604183f, 0.47257447f, 
    -0.27609852f, 0.14531557f, 0.17020233f, 0.20008931f, 0.18429674f, 0.18910703f, -0.10092152f, 0.23550576f, 
    0.47519931f, -0.40080917f, -0.02065523f, -0.21205913f, 0.49404168f, -0.09300523f, 0.23732185f, 0.22579874f, 
    -0.00761913f, -0.42860532f, 0.60940510f, -0.09836856f, 0.10340741f, -0.13800782f, 0.23068243f, -0.12414883f, 
    0.42698210f, 0.53985274f, 0.05279787f, -0.00586202f, -0.15160114f, 0.28209576f, -0.29845613f, 0.08524003f, 
    -0.86416745f, -0.17885020f, -0.29275042f, 0.16070509f, 0.14427765f, 0.42585742f, 0.17964451f, 0.16931736f, 
    -0.42798525f, 0.13273539f, -0.22041863f, 0.05805488f, 0.11577138f, -0.07944119f, 0.18912308f, -0.38603655f, 
    0.13282543f, 0.25103647f, 0.47514936f, -0.02047491f, 0.13020933f, 0.37441418f, 0.17827049f, -0.02472653f, 
    -0.00926416f, 0.24689126f, -0.15000953f, 0.18551111f, -0.39455339f, 0.36375913f, 0.37760136f, -0.95532799f, 
    -0.00977406f, -0.02487623f, 0.11506673f, -0.02455375f, 0.00944972f, 0.05999254f, -0.23269545f, 0.15335891f, 
    0.24602331f, -0.00282718f, 0.28294581f, -0.47113204f, -0.13518648f, -0.03627452f, 0.19749555f, -0.06470674f, 
    -0.10703719f, 0.51538205f, 0.36785901f, 0.11032045f, 0.06257638f, -0.45333460f, -0.15972054f, -0.21272692f, 
    -0.25647154f, -0.05290981f, -0.42766422f, 0.58670759f, 0.01040085f, 0.41323516f, 0.26735279f, -0.05131829f, 
    -0.02310764f, -0.00870110f, -0.04571963f, -0.08488815f, -0.20087874f, 0.34852311f, -0.23324299f, 0.11405813f, 
    0.35007384f, -0.46857467f, -0.27110872f, 0.32791868f, -0.37189102f, -0.07998309f, 0.38232064f, 0.58377016f, 
    0.05597411f, -0.17707394f, 0.14052828f, -0.13554333f, -0.06753482f, 0.47032619f, -0.01481242f, 0.20457202f, 
    0.34400168f, 0.00541132f, -0.20028351f, -0.73738170f, -0.86009622f, -0.01076695f, 0.43453518f, -1.04393709f, 
    -0.00891871f, -0.10109297f, -0.28243032f, -0.02674691f, -0.14538202f, 0.33544934f, -0.17957965f, -0.00487301f, 
    0.15465528f, -0.02642190f, -0.42242938f, 0.40292001f, -0.43158206f, 0.19712764f, 0.08486880f, 0.27181756f, 
    -0.23543441f, 0.07007957f, 0.89281839f, -0.05114877f, -0.15167949f, 0.18198849f, -0.22047366f, -0.05981603f, 
    0.26858607f, -0.17739807f, -0.32782102f, -0.29493523f, -0.16228862f, 0.60301226f, 0.20779404f, -0.21156752f, 
    0.25951564f, 0.00115217f, 0.48887864f, 0.15397885f, 0.20674859f, -0.21544196f, -0.10940007f, 0.08577336f, 
    0.44025049f, -0.32233274f, -0.25538710f, 0.39911228f, -0.40113509f, 0.33028346f, 0.22329640f, 0.95469153f, 
    0.43526340f, -0.36156932f, -0.16308486f, -0.22311395f, -0.20648903f, 0.12087724f, -0.19969042f, 0.03864918f, 
    0.41032299f, 0.15436600f, 0.06437360f, 0.29168391f, 0.04641926f, 0.22523718f, 0.08733226f, -0.16680732f, 
    0.25779620f, 0.38378644f, -0.37005866f, -0.02899770f, 0.06191594f, -0.52108425f, -0.17593008f, -0.16508164f, 
    -0.12267363f, 0.33852386f, 0.05796752f, -0.03913352f, -0.70886898f, 0.23069945f, 0.14612919f, -0.20211770f, 
    -0.16608126f, 0.37473062f, -0.55466825f, 0.00183161f, -0.14475796f, 0.21164669f, 0.03293411f, 0.05526751f, 
    -0.27218735f, -0.09843268f, 0.15034871f, -0.02117456f, 0.04433305f, -0.01082143f, 0.12386452f, 0.71266723f, 
    -0.08304816f, -0.14064611f, 0.17394575f, -0.21233185f, 0.06376240f, 0.68175411f, 0.17616299f, -0.14984286f, 
    -0.16023794f, -0.16606428f, -0.13869302f, 0.02955022f, -0.23696300f, -0.17956108f, -0.10246328f, 0.15628369f, 
    -0.18864097f, 0.08472691f, -0.17041522f, 0.06636422f, 0.03794211f, -0.13399166f, 0.01333594f, -0.12116405f, 
    0.39626250f, 0.13152906f, -0.08265240f, 0.06562489f, -0.83009332f, 0.41258726f, -0.19892040f, 0.64480668f, 
    -0.75711083f, -0.26770201f, -0.29142869f, -0.21084777f, 0.02568736f, 0.50424957f, 0.24262865f, -0.23767084f, 
    -0.14389110f, -0.38645160f, 0.16779442f, 0.41107875f, 0.23792258f, 0.67201281f, -0.15663798f, -0.16070087f, 
    -0.26418030f, 0.21532500f, 0.28744775f, -0.20675407f, -0.18358128f, -0.01630848f, -0.23843646f, 0.26575339f, 
    0.02625378f, 0.06463065f, 0.00031008f, -0.17408971f, 0.18964693f, -0.00649647f, -0.32802358f, -0.15279540f, 
    0.00409446f, -0.08479676f, -0.03204748f, -0.21382673f, 0.24278593f, 0.09598191f, -0.04298541f, 0.07439741f, 
    0.59441209f, -0.07914472f, 0.20071593f, -0.78522223f, 0.02319545f, -0.29123819f, -0.02113141f, 0.02185003f, 
    0.14850967f, 0.31189692f, 0.38744342f, -0.06161526f, -0.20157871f, -0.31195477f, -0.05541987f, 0.09395801f, 
    -0.13429071f, 0.01919774f, 0.32600328f, 0.38147876f, 0.27577057f, 0.18791895f, -0.13511111f, 0.49495074f, 
    -0.39703628f, 0.18722336f, -0.57819015f, -0.25625238f, 0.22862126f, -0.40998432f, 0.18300956f, -0.11872398f, 
    -0.08069312f, -0.20008886f, -0.18371473f, 0.05064658f, -0.20327510f, -0.12155331f, -0.00523316f, 0.04412537f, 
    0.02560548f, 0.02595049f, -0.03365799f, 0.13969737f, -0.20504166f, -0.09890734f, 0.01313240f, -0.18195879f, 
    0.33390972f, 0.04863760f, 0.08303379f, 0.12484200f, 0.15545031f, -0.48260838f, 0.39697188f, -0.20050335f, 
    -0.04170223f, -0.50269252f, -0.02844947f, -0.21000969f, 0.10633001f, 0.11863520f, 0.14792563f, 0.11049298f, 
    0.35514027f, 0.32025340f, -0.39913824f, 0.20024943f, 0.04473415f, 0.63219398f, 0.00094576f, -0.44897005f, 
    0.43840700f, -0.15837286f, -0.00398307f, -0.15079904f, -0.16948950f, 0.06177838f, -0.20883352f, -0.07817772f, 
    -0.25800619f, 0.38616475f, -0.18584992f, 0.38300806f, -0.02767169f, 0.31278801f, -0.23702312f, 0.10343667f, 
    -0.05512914f, 0.44721541f, 0.02028299f, 0.12975419f, -0.05885560f, 0.28000531f, -0.16244963f, 0.00504228f, 
    0.17675109f, 0.13408493f, 0.29201415f, -0.31738180f, -0.11747431f, 0.00374562f, 0.24365953f, 0.18228504f, 
    -0.14128482f, -0.12398053f, -0.70070863f, -0.12067574f, 0.02271593f, 0.70627552f, -0.12477937f, 0.22009462f, 
    -0.18925047f, 0.10415205f, 0.05444856f, -0.22434187f, -0.11053821f, 0.05959049f, -0.27655265f, 0.01509139f, 
    0.08682986f, -0.02992701f, -0.11116408f, 0.20736104f, 0.00380266f, 0.11063831f, 0.01637909f, 0.14986399f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.12147696f, 0.42028213f, -0.31801200f, 0.09325319f, 0.07648392f, 0.56145638f, 0.21821995f, -0.00587766f, 
    0.04177966f, 0.42523718f, 0.66167349f, -0.43097687f, -0.51557320f, 0.11137331f, -0.22383638f, 0.30481151f, 
    -0.25785750f, 0.04438891f, 0.33058596f, -0.28512815f, 0.24269101f, 0.06662253f, 0.66255653f, -0.14667554f, 
    0.61843455f, 0.20667338f, 0.17765509f, 0.13911313f, 0.26121557f, 0.65736634f, -0.16843414f, -0.14212775f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.46766427f, -0.06016353f, -0.42942852f, -0.20867534f, -0.13314435f, 0.06136685f, -0.08626318f, 0.38420233f, 
    0.35246116f, -0.01588983f, -0.34591371f, 0.35441583f, 0.35884610f, 0.06691753f, 0.16238025f, -0.31625006f, 
    -0.11806507f, -0.36664683f, 0.13792762f, 0.35264584f, -0.03917141f, 0.55018681f, -0.27134734f, -0.02332478f, 
    -0.70310479f, -0.33943662f, 0.00286067f, 0.19299796f, -0.06763647f, -0.02918607f, 0.40779606f, 0.00557885f, 
    -0.45009592f, 0.07466537f, -0.51767313f, -0.29429993f, 0.25759205f, 0.42262173f, 0.05143980f, -1.41875350f, 
    -0.00251280f, 0.24915463f, -0.07697571f, 0.03978450f, 0.27777150f, 0.70625746f, 0.02158571f, 0.19448626f, 
    0.12553504f, -0.19949707f, -0.04724392f, 0.06533144f, 0.15755537f, -1.28747106f, 0.28354630f, -0.09161699f, 
    -0.49384251f, 0.20436984f, -0.01364802f, 0.02983819f, 0.08820558f, -0.02336028f, -0.05550664f, -0.05721610f, 
    0.28119648f, 0.70133054f, -0.06048606f, 0.26416519f, -0.28078380f, -0.23718952f, 0.23522468f, -0.66282868f, 
    0.11151290f, 0.08061133f, 0.08549941f, 0.00288430f, -1.21323097f, -1.31642485f, 0.44894576f, 0.28327692f, 
    -1.33375955f, -0.07765823f, -0.09042536f, -0.47265661f, 0.03658175f, -0.86467677f, 0.22993971f, 0.03650711f, 
    0.01663008f, -0.54852539f, 0.04654417f, -0.05766439f, -0.04555487f, 0.20651329f, -1.33766270f, 0.15778096f, 
    0.26940092f, 0.10580519f, 0.22152235f, 0.24453551f, -0.62380677f, 0.44303313f, -0.53021878f, 0.07855047f, 
    0.19355729f, 0.08822968f, 0.05768299f, -0.25932601f, 0.01944111f, 0.14726236f, -0.02910318f, -0.18367460f, 
    -0.63058102f, -0.23353711f, 0.29885083f, 0.19340475f, 0.07032670f, -0.05100805f, -0.35762706f, -0.10341824f, 
    0.23034912f, -0.92935884f, 0.08544997f, -0.27328992f, -0.21036744f, -0.12644678f, -0.05386140f, 0.14197832f, 
    0.07999705f, 0.14993608f, 0.32734376f, 0.11221957f, 0.03997577f, -0.78184199f, -0.07503943f, 0.51909804f, 
    -0.40979806f, -0.06011987f, -0.34172624f, -0.03676151f, 0.02282855f, 0.17550087f, -0.10868316f, 0.08057464f, 
    0.16544029f, 0.01476463f, 0.18084367f, 0.13364536f, -0.16665800f, 0.43392369f, -0.32724714f, -0.08332421f, 
    -0.34227154f, -0.07330640f, 0.15106784f, 0.08356755f, 0.31546551f, -0.07281135f, 0.04343005f, -0.11662298f, 
    -0.20340948f, 0.38584271f, -0.90916365f, 0.37999675f, 0.25679576f, -0.16490270f, -0.31072614f, -0.46802831f, 
    -0.05284358f, 0.14479081f, -0.17382711f, 0.38270292f, 0.11777283f, -0.12053759f, 0.31693816f, 0.25134444f, 
    0.39829707f, -0.09692240f, 0.14076151f, -0.10842456f, 0.15567720f, -0.08398800f, 0.03927194f, 0.01120100f, 
    -0.43575829f, -0.03035254f, -0.16651627f, -0.33207271f, 0.36075854f, -0.03747703f, -0.42539048f, -0.14740318f, 
    0.40195110f, -0.93538028f, -0.17903675f, -1.55375099f, -0.42431962f, -0.91021734f, 0.21410489f, 0.41191182f, 
    -0.36730382f, -0.96168715f, 0.24367435f, -0.24453290f, -0.86816758f, -0.30673942f, -1.19529855f, -0.26737598f, 
    -1.69240940f, 0.26314694f, -0.99799484f, -0.32021755f, 0.01189342f, -0.08728996f, 0.44393873f, -0.08899716f, 
    0.46241257f, 0.24240194f, 0.01119728f, -0.14332171f, -0.08650465f, 0.02305426f, -0.46585146f, -0.07529356f, 
    -0.06059352f, -0.89472419f, 0.81570947f, -0.04304305f, -0.05161526f, 0.25025254f, -0.13559522f, 0.47931400f, 
    0.12161557f, -1.32588220f, -0.08255276f, 0.38970068f, 0.44766730f, -0.08183882f, 0.88344574f, -1.74775279f, 
    -0.00172260f, 0.08944537f, -0.37839466f, -0.04051360f, -0.09022268f, -0.01141331f, 0.08191684f, -0.18281214f, 
    -0.77860343f, -0.06463666f, 0.07512722f, 0.04554186f, -0.45767152f, 0.05432610f, -0.76831704f, -0.13502252f, 
    -0.26668406f, -1.15089238f, -0.87845558f, -0.33318856f, 0.30701694f, -0.20293379f, 0.50211024f, -1.04521537f, 
    -0.47323176f, -0.43703541f, 0.09952533f, -0.13106456f, 0.35403714f, -1.10241437f, 0.23184451f, 0.32704157f, 
    0.47715631f, 0.02911865f, -0.94902295f, -0.02830555f, -0.08670773f, -0.21656111f, -0.26895148f, 0.04718675f, 
    0.51035142f, -0.60379982f, 0.02593303f, -0.03738239f, 0.19727926f, -0.00189797f, -0.51863223f, 0.07751348f, 
    0.20284811f, -0.47683206f, 0.11994815f, 0.23712407f, -0.71463960f, 0.02718749f, -0.90793610f, 0.17001548f, 
    -0.55060929f, 0.21794106f, 0.20551944f, -0.53619111f, -1.20216274f, -0.77985859f, -1.26587272f, -0.38781539f, 
    -0.69601345f, 0.34962940f, 0.38429192f, -0.42491400f, -0.07473654f, -1.32383716f, -0.04281868f, -0.13483031f, 
    0.06644447f, 0.11096373f, -0.01088158f, -0.53758967f, -0.03717906f, 0.45906544f, 0.11170930f, -0.05988854f, 
    -0.26378390f, 0.62345856f, -0.63155520f, 0.03148422f, 0.00913673f, -0.06834496f, 0.42970297f, -0.50857812f, 
    -0.67633885f, 0.15584654f, 0.12900093f, -0.64998740f, 0.32890210f, 0.31674752f, -0.04244567f, 0.19302891f, 
    0.12443318f, 0.10964008f, -0.25830245f, -1.25719988f, 0.03363405f, -0.50253046f, -0.44581199f, -0.16823436f, 
    0.44545880f, -0.74644965f, 0.09689797f, 0.65375543f, -0.20068924f, -1.25201142f, -0.35619068f, 0.04492498f, 
    0.03270449f, -0.81670189f, 0.32069856f, 0.24131255f, 0.20236471f, 0.37010100f, 0.19548295f, -0.85986173f, 
    -0.92599112f, -0.57291287f, 0.16232173f, -0.78981936f, -0.11629587f, -1.02484608f, -0.83445859f, 0.00002086f, 
    -0.00497595f, -0.06912766f, -0.12481424f, 0.37822372f, -0.09173343f, -0.49727097f, -0.01708515f, 0.05554399f, 
    0.28044668f, 0.12135311f, 0.00146825f, 0.00287648f, -1.32764459f, -0.28875840f, 0.36533815f, -0.12075172f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.25751817f, 0.50789797f, 0.30917835f, 0.11677741f, -0.35760316f, -0.14579004f, 0.14921871f, -0.42939904f, 
    0.35800537f, 0.49211460f, 0.00168664f, -0.15534414f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
