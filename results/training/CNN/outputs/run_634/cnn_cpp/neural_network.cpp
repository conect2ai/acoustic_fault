#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.44350538f, 0.45380637f, 0.79230320f, 0.52507401f, -0.71066397f, -0.65340006f, 0.60338885f, -0.02163085f, 
    0.11872976f, -0.31832874f, 0.16920179f, -0.10843302f, -0.02055644f, -0.22999753f, 0.26260963f, -0.12359495f, 
    -0.21833862f, 0.01651691f, -0.22047445f, -0.22453260f, -0.19869879f, -0.05095838f, -0.25031263f, -0.04420621f, 
    0.08865011f, -0.55066311f, -0.92565858f, 0.51772749f, 0.87107545f, 0.07276854f, -0.11781200f, 0.23699564f, 
    0.40447733f, -0.38217920f, 0.38598120f, -0.02267482f, -0.02356577f, 0.31339678f, 0.23208459f, -0.15996142f, 
    -0.33856127f, -0.38544351f, -0.18480466f, -0.11004508f, -0.11775310f, -0.13491671f, 0.06181021f, 0.20433980f, 
    0.28204468f, -0.33388019f, 0.53230733f, 0.79787087f, 0.75360858f, 0.23573598f, -0.63810426f, -0.72362202f, 
    -0.05439951f, -0.38873559f, -0.29949555f, -0.20897035f, 0.28330165f, 0.27997380f, -0.26940727f, 0.01513614f, 
    0.13670683f, 0.07544749f, -0.33536023f, 0.32620439f, 0.17895055f, -0.15638457f, 0.03190154f, 0.16995755f, 
    0.18821196f, 0.14656159f, 0.04641697f, 0.03067969f, -0.09630781f, 0.32327369f, 0.52205586f, 0.49018833f, 
    0.55233276f, -0.20901984f, -0.69166762f, -0.10717070f, 0.22863114f, 0.43880993f, 0.12123755f, 0.14364113f, 
    0.34953371f, -0.40365797f, -0.17944449f, 0.06039247f, 0.46999368f, -0.31435367f, 0.04096384f, -0.10781437f, 
    -0.46506023f, -0.00696976f, -0.29447380f, -0.18455300f, -0.34368882f, 1.04792893f, -0.40529686f, -0.72335804f, 
    -0.73529333f, 0.78093249f, -0.18670337f, -0.42298546f, -0.02067745f, 0.17934300f, 0.23029032f, -0.01089269f, 
    0.25731882f, 0.34827679f, -0.08465949f, 0.14916751f, 0.21965408f, -0.04623193f, 0.09384935f, 0.30394843f, 
    -0.09493347f, 0.03895484f, 0.14713883f, 0.01952112f, 0.32212275f, -0.36250660f, -0.83747411f, -0.85986799f, 
    -0.23002529f, -0.32642272f, -0.56628078f, 0.64903063f, 0.27763483f, 0.00763644f, 0.39597380f, 0.29845080f, 
    0.14312454f, 0.17812407f, 0.04215110f, 0.21063873f, -0.29063493f, 0.14956267f, 0.25334665f, 0.28438547f, 
    0.12037034f, -0.02693666f, 0.20490871f, -0.16790845f, -0.02962166f, -0.17658056f, -0.22408065f, 0.74672776f, 
    0.02741821f, 0.61269647f, -0.86650968f, -0.22748610f, 0.05134313f, -0.18522505f, 0.02628280f, -0.66759896f, 
    0.32738835f, 0.08233199f, -0.19868776f, -0.10620434f, 0.32686156f, 0.29886302f, 0.24555868f, 0.35894534f, 
    0.13475263f, -0.20798232f, -0.03545629f, 0.03466463f, 0.08461755f, 0.21324553f, -0.06447256f, -0.37517083f, 
    0.86988783f, -0.03364758f, -0.02916480f, -0.01800217f, -0.20509367f, -0.11852296f, -0.22632501f, 0.40970585f, 
    -0.63789058f, -0.38539049f, -0.06166196f, 0.00797385f, 0.53238720f, 0.32715222f, -0.22834918f, -0.40861785f, 
    0.11939899f, -0.07682539f, 0.09818421f, -0.25556979f, -0.12867184f, 0.11681411f, -0.01795646f, 0.21520862f, 
    -1.25332630f, 0.19075140f, 0.72501063f, -0.22824560f, -0.71318203f, 0.25047970f, 0.58751839f, -0.47180673f, 
    0.11200237f, 0.38904712f, -0.19418487f, 0.32245156f, 0.00735444f, 0.00866935f, 0.18164825f, -0.34936824f, 
    -0.12463809f, -0.14822584f, -0.21775462f, -0.15624335f, 0.34864789f, 0.14996968f, 0.04476953f, 0.01352451f, 
    -0.11295825f, 0.23612098f, -0.46530470f, 0.19239126f, 1.05919909f, 0.34217662f, 0.10492662f, 0.66119963f, 
    -0.20921952f, 0.49784446f, 0.31935939f, -0.64390963f, -0.13561986f, -0.70261025f, 0.17274557f, -0.07131603f, 
    -0.12208365f, -0.39260375f, -0.27357146f, 0.22730845f, 0.00876543f, 0.02892918f, 0.03621083f, 0.16472097f, 
    -0.05947561f, -0.13641696f, -0.58700842f, -0.16059133f, -0.79029828f, -0.32162556f, -0.14045987f, 0.18251608f, 
    0.11479843f, 0.21377920f, 0.15077455f, 0.67842215f, -0.39720634f, -0.47598901f, 0.29601538f, 0.17459272f, 
    0.28051275f, -0.01477323f, -0.20638523f, 0.04202591f, 0.33100238f, -0.36847797f, -0.05869537f, 0.22569706f, 
    -0.30540830f, 0.11634425f, 0.13565819f, -0.91711199f, 0.88675648f, -0.61368501f, -0.90858442f, 0.39212769f, 
    -0.04411369f, -0.32034650f, 0.37026227f, 0.23587357f, 0.37570739f, 0.00660109f, -0.28751943f, -0.26769221f, 
    -0.16524865f, -0.47802895f, -0.20613599f, 0.01063979f, -0.26642260f, 0.23079066f, -0.04057655f, -0.37135345f, 
    -0.03919827f, -0.23475498f, -0.04397290f, 0.26038465f, 0.95767796f, 0.74897271f, 0.53251690f, -0.54430133f, 
    0.08001808f, 0.52800441f, -0.32160765f, -0.44240862f, -0.34008887f, 0.29468861f, -0.38774189f, 0.35830617f, 
    0.08954053f, -0.10002730f, -0.19344571f, -0.31668192f, 0.09003722f, 0.07404278f, -0.25968802f, -0.04481038f, 
    0.20683894f, 0.11957026f, 0.11879230f, -0.20036140f, 0.03251179f, -0.38367233f, -0.24021974f, -0.54363823f, 
    -0.48251691f, -0.27853158f, 0.28188351f, 0.62021941f, 0.40006581f, 0.60707557f, 0.55097604f, 0.39669767f, 
    0.06487323f, 0.10175858f, -0.23038927f, 0.03136960f, 0.11862990f, -0.06109731f, 0.22969151f, 0.14732902f, 
    0.00847057f, -0.11221972f, 0.07059088f, -0.03062730f, -0.21408568f, 0.30380312f, 0.17591006f, -0.47943851f, 
    0.41685805f, -0.40112767f, -0.34800437f, 0.31388655f, -0.50173521f, 0.68862188f, 0.64355922f, -0.24672085f, 
    -0.17543119f, -0.52769321f, -0.15390393f, -0.40892643f, -0.03211176f, 0.10866245f, 0.26343259f, -0.18236004f, 
    0.32651982f, 0.03364583f, 0.14498942f, 0.28144947f, 0.07372952f, 0.04929919f, -0.44088793f, 0.40428612f, 
    -0.18220024f, 0.04326487f, 0.41150174f, 0.53458291f, 0.48842749f, 0.03335893f, -0.58486134f, 0.04516441f, 
    -0.29895082f, 0.23817299f, -0.13746378f, -0.20567232f, -0.00690707f, -0.02956997f, 0.43533608f, 0.33860055f, 
    -0.09769724f, 0.38632777f, -0.05158352f, -0.51142150f, -0.50664622f, -0.34814140f, 0.42278206f, -0.17027561f, 
    0.05260525f, 0.53592819f, 0.74369490f, 0.31374425f, 0.07333156f, 0.18348664f, 0.14059919f, 0.19220604f, 
    -0.12503442f, -0.09388341f, 0.04343433f, -0.07469483f, 0.03716544f, 0.11656857f, 0.17884921f, 0.04568686f, 
    0.28073084f, 0.10728133f, -0.26062816f, 0.28689054f, -0.10459889f, 0.48844850f, -0.19884518f, 0.37150049f, 
    -0.13790157f, -0.43027502f, 0.04428557f, 0.51559573f, 0.90264636f, -0.70114571f, 0.09818726f, 0.07053730f, 
    -0.22907592f, 0.00302831f, -0.12708418f, -0.03666524f, -0.34874359f, -0.19373272f, -0.08842676f, -0.51327282f, 
    -0.43790409f, 0.05651358f, 0.29905486f, -0.10034377f, -0.44412598f, 0.13145244f, -0.17691036f, -0.37845892f, 
    0.05297303f, -0.47709394f, -0.85691786f, 0.72146374f, 0.52022713f, -0.10886285f, 0.32263398f, 0.42300057f, 
    0.67187721f, 0.25835544f, -0.24582337f, 0.27027318f, -0.29407954f, 0.19730663f, 0.30949163f, 0.13440455f, 
    -0.03470265f, -0.25018114f, 0.00906617f, -0.21497998f, -0.31495741f, -0.41372928f, 0.05406212f, -0.23367760f, 
    0.10140558f, 0.07603401f, -0.20274825f, -0.48405862f, -0.61570132f, -0.07417624f, -0.01743405f, -0.33196652f, 
    -0.18292548f, 0.37417904f, -0.36890668f, -0.47184265f, -0.35756525f, 0.27941465f, 0.44019684f, -0.26871482f, 
    0.47491977f, 0.28123674f, 0.33023855f, -0.51728588f, -0.27430582f, 0.03745895f, 0.18260184f, 0.10973205f, 
    -0.09643950f, 0.17332412f, 0.03096684f, 0.42729387f, -0.57215410f, 1.12463021f, 0.44357187f, -0.62275106f, 
    0.53194571f, -0.56415391f, 0.67358321f, 0.48953092f, 0.03849961f, 0.47272056f, -0.07571503f, 0.31815571f, 
    -0.07239822f, -0.20454101f, 0.11081352f, 0.15897107f, -0.05442942f, 0.11375346f, 0.08673818f, 0.11868622f, 
    -0.12749372f, 0.09615344f, 0.17609736f, -0.08385467f, -0.06351461f, 0.66447562f, -0.29299381f, -0.02219055f, 
    -0.28841481f, -0.60097086f, 0.13421802f, -0.08163942f, -0.13115071f, 0.51128554f, -0.45845404f, 0.61029744f, 
    0.40130195f, 0.16937633f, -0.00609744f, -0.13050242f, -0.02245901f, -0.35948348f, 0.50370455f, -0.03979070f, 
    0.23147766f, -0.00006701f, 0.08834650f, 0.06875629f, 0.51854247f, -0.25268838f, 0.33281100f, 0.03573281f, 
    0.70289457f, 0.84242123f, 0.44519514f, -0.26021993f, -0.18034610f, -0.50699759f, -0.60217941f, -0.02773027f, 
    0.66372472f, 0.32718924f, -0.25475681f, 0.26434913f, -0.02887242f, 0.25070205f, -0.44330367f, -0.01527061f, 
    0.01321387f, -0.00165667f, 0.20834193f, 0.27562943f, 0.35838705f, 0.30975002f, -0.22770180f, 0.47820029f, 
    0.42093861f, 0.14009705f, 0.49818507f, 0.77627915f, 0.59034711f, 0.40068540f, 0.53619945f, 0.05903803f, 
    0.46252418f, -0.14580829f, -0.36871681f, 0.02378335f, 0.13052703f, 0.08966672f, 0.08752477f, 0.04724651f, 
    0.20975167f, -0.16671954f, -0.26635897f, -0.23058447f, -0.05089907f, 0.33524567f, 0.06321567f, 0.06703611f, 
    -0.10456647f, 0.55526650f, 0.37310508f, 0.09137726f, 0.75089586f, -0.29937667f, 0.11131212f, 0.28785881f, 
    -0.88376999f, 0.21265332f, 0.52922523f, -0.04107697f, -0.16355050f, 0.16292998f, 0.04703953f, -0.03094720f, 
    0.41672847f, 0.02597774f, 0.20072013f, 0.22490050f, 0.29012695f, -0.23605518f, -0.26726910f, -0.37243703f, 
    -0.06336770f, 0.16401300f, -0.45054415f, -0.10316920f, 0.02075428f, 0.05870905f, -0.84410501f, -0.82145989f, 
    0.51288128f, -0.06577775f, -0.59329379f, 0.00622227f, 0.07938874f, 0.45745468f, -0.40436667f, -0.05437661f, 
    0.17109166f, 0.02243704f, -0.39452541f, 0.30074635f, -0.10391022f, -0.28700435f, 0.20703578f, -0.11929058f, 
    0.06026945f, 0.08688783f, 0.01562085f, 0.16174866f, 0.44261771f, 0.49206406f, -0.37446773f, -0.43135425f, 
    -0.71164215f, -0.47879300f, -0.34340847f, -0.37331066f, -0.14742798f, -0.25175104f, 0.00252051f, -0.37746203f, 
    0.44715738f, -0.30658388f, -0.32550833f, -0.25333118f, -0.34379449f, 0.25288790f, 0.18874961f, 0.16505580f, 
    0.07183707f, -0.05872842f, 0.37581608f, -0.76581943f, 0.07634420f, -0.11896040f, -0.84030771f, -0.10776410f, 
    0.39014143f, -0.39648855f, 0.16635165f, 0.45250276f, -0.52956206f, 0.23571877f, -0.02029192f, 0.01240521f, 
    -0.32802367f, 0.11385052f, 0.36618254f, -0.15110961f, -0.09739247f, -0.24209385f, 0.00070956f, -0.17001638f, 
    0.12318672f, 0.24272802f, 0.01774992f, -0.03401569f, 0.39624432f, 0.65376222f, 0.39898464f, 0.83587730f, 
    0.64038122f, 0.60704398f, 0.17040482f, 0.18952699f, -0.12396556f, -0.18785748f, -0.14991646f, 0.11969439f, 
    -0.33212250f, 0.19401963f, -0.33181223f, -0.23160933f, 0.01858000f, 0.41637260f, 0.12786435f, -0.42580628f, 
    -0.16952285f, -0.03340302f, -0.25926474f, -0.18493994f, 0.16539632f, -0.26975560f, 0.63417953f, -0.02885315f, 
    0.74020720f, -0.50676590f, -0.26436582f, -0.36984265f, -0.72689372f, 0.25311255f, -0.05664170f, 0.43265244f, 
    0.29681873f, -0.01722788f, 0.21340244f, -0.14679728f, 0.34788692f, 0.12291592f, 0.29169866f, 0.06946974f, 
    0.09379178f, -0.15487725f, -0.42171839f, 0.09367654f, -0.25795177f, -0.00025188f, 0.55392271f, 0.66598529f, 
    0.26744974f, 0.25724480f, -0.57984018f, -0.30810195f, 0.13672490f, -0.58878690f, -0.65594399f, -0.06060659f, 
    0.50638020f, -0.11940570f, -0.18019336f, 0.08149958f, -0.34402421f, -0.17460018f, -0.37162656f, -0.23681189f, 
    0.03503121f, -0.09906691f, 0.01510814f, 0.19784500f, 0.31502321f, 0.05240650f, 0.30428603f, -0.08329768f, 
    0.20191500f, 0.78079140f, -0.78170300f, 0.43694863f, 0.87708408f, -0.49327278f, -0.00860532f, -0.94766188f, 
    -0.76330519f, -0.18148875f, -0.06790477f, 0.25313169f, 0.14302231f, -0.29768720f, 0.02252723f, 0.15854146f, 
    0.14129871f, 0.03494823f, 0.20649566f, 0.25747281f, 0.21209162f, -0.03953334f, -0.01380610f, 0.06008680f, 
    0.81617111f, 0.38160220f, -0.41224086f, -0.77938282f, -0.69207191f, 0.22298577f, 0.53631282f, -0.20870005f, 
    0.29567736f, 0.36571580f, 0.09394910f, -0.04094777f, -0.54711634f, -0.26021627f, -0.01275773f, -0.16366550f, 
    -0.03588556f, 0.27674744f, 0.06278731f, -0.07869471f, 0.05043943f, 0.26130190f, -0.17185868f, -0.10526038f, 
    -0.21897118f, 0.05188931f, -0.35665560f, -0.22653159f, -0.36843657f, 0.41380915f, 0.34508824f, 0.78014618f, 
    0.71253020f, 0.52367109f, 0.37183332f, -0.07776842f, 0.30599385f, -0.35833919f, -0.31492764f, 0.13247219f, 
    0.29765233f, -0.27161714f, -0.30382445f, -0.12172526f, 0.02336308f, -0.23639388f, -0.33833680f, 0.35216594f, 
    -0.15495862f, -0.29667401f, -0.49117205f, 0.20748428f, 0.45527157f, 0.71083295f, -0.15617581f, -0.52143246f, 
    -0.36176121f, 0.13105272f, -0.38148698f, 0.06061698f, 0.25877279f, -0.14148292f, -0.07438324f, 0.29904854f, 
    0.04946367f, 0.33083192f, 0.38290960f, 0.10787164f, -0.23818491f, 0.26829141f, 0.26082715f, 0.09185810f, 
    -0.23597793f, -0.37374428f, -0.38847771f, -0.36044466f, 0.22988503f, -0.49368575f, 0.55017185f, -0.08484904f, 
    0.42989194f, 0.50534511f, 0.51551241f, -0.37425390f, -0.00968311f, -0.35394502f, -0.46011078f, 0.28537568f, 
    0.01518648f, 0.05446921f, -0.35297549f, -0.28528443f, -0.04982894f, -0.02405221f, 0.11868081f, 0.18019965f, 
    0.21693005f, 0.27621967f, 0.33745480f, -0.15834711f, -0.61684304f, -0.26636058f, 0.98019665f, -0.19243631f, 
    -0.06080556f, 0.70835710f, -0.60401738f, 0.02937419f, -0.00989060f, -0.15761651f, 0.30811161f, 0.12745193f, 
    0.17990999f, 0.12742640f, -0.15901650f, -0.10276806f, 0.30778936f, -0.21486668f, -0.29702801f, -0.24934736f, 
    0.13248451f, 0.18945977f, -0.15190047f, 0.12804946f, 0.08132645f, -0.90047115f, 0.52085716f, 0.70638484f, 
    -0.33353183f, -0.06246773f, -0.31708658f, 0.12292790f, -0.35072267f, -0.24945389f, -0.48904237f, -0.15918985f, 
    0.03974719f, -0.27505746f, 0.37879196f, 0.05628485f, -0.01741314f, 0.04967703f, 0.00469709f, 0.19157845f, 
    0.17590047f, 0.30886519f, 0.24643959f, 0.12498266f, -0.17038508f, -0.12040456f, -0.47479704f, -0.94128865f, 
    -0.43684766f, 0.13184315f, -0.40926236f, 0.00652819f, 0.63704634f, -0.29542506f, 0.35084593f, -0.36863574f, 
    -0.24167505f, 0.25875366f, -0.22893211f, 0.54818636f, 0.13454111f, -0.17030671f, 0.03820707f, -0.30497682f, 
    -0.07863298f, -0.33439678f, -0.12365664f, 0.08465956f, -0.03681699f, 0.12147034f, -0.31802171f, 1.25591660f, 
    0.43662381f, 0.51271695f, 0.61729020f, 0.85033649f, -0.35629210f, 0.21778090f, -0.20689702f, -0.02195714f, 
    -0.04718298f, -0.06289068f, 0.25566736f, 0.23010433f, 0.13977176f, 0.09552254f, -0.10935709f, -0.16089985f, 
    -0.04603280f, 0.25619689f, -0.07442112f, 0.18643504f, -0.10392403f, 0.00772562f, -0.05010219f, -0.09450588f, 
    0.35509908f, 0.43479490f, 0.30992123f, 0.87939435f, 0.28694788f, 0.18556710f, 0.40609610f, 0.26383308f, 
    0.08125104f, 0.30822328f, -0.45322904f, -0.05113206f, -0.33498335f, -0.23293948f, 0.02875106f, 0.20334083f, 
    -0.21533228f, 0.30973259f, 0.15363644f, 0.39627081f, 0.01566273f, -0.17834298f, 0.44837660f, -0.14869790f, 
    -0.18141112f, 0.74861056f, -1.33656871f, 0.46430364f, -0.11245815f, 0.36565012f, 0.55387747f, -0.27127209f, 
    0.41695160f, 0.06110778f, 0.46050969f, -0.07395349f, 0.14567582f, -0.40668330f, 0.22324982f, 0.00853656f, 
    0.24072351f, 0.27372321f, -0.04334269f, -0.02662751f, 0.34001359f, 0.03248565f, 0.06967958f, 0.19026996f, 
    0.03084769f, -0.02865904f, -0.43320793f, 0.43992189f, -0.37012610f, 0.01042370f, -0.21549398f, -0.51885378f, 
    0.94841355f, -0.00196486f, -0.46123937f, -0.12324861f, 0.24646738f, -0.09767468f, 0.05946166f, -0.16464366f, 
    0.33595502f, -0.14104502f, -0.27227214f, -0.22122712f, 0.13908893f, -0.43271646f, 0.19775528f, 0.21677510f, 
    0.15031847f, 0.28226388f, 0.16073529f, -0.71660894f, -0.49340007f, -0.47541213f, -0.30611181f, -0.26619101f, 
    -0.63165855f, -0.50134057f, -0.73028719f, -0.42145747f, -0.23776802f, 0.28356791f, 0.07673322f, 0.24050409f, 
    -0.17587030f, -0.02615149f, -0.02910551f, 0.26639879f, 0.40511933f, -0.34270051f, -0.14658414f, -0.07254975f, 
    0.04163018f, 0.03244554f, 0.22693291f, -0.05581499f, 0.61330837f, -0.13905253f, -0.72713816f, -0.33596119f, 
    -0.14564134f, 0.12317578f, -0.07801593f, -0.54692411f, 0.04186568f, 0.35444972f, 0.54355305f, -0.24605562f, 
    -0.19517887f, -0.15407594f, 0.34560913f, 0.22879973f, 0.23558508f, 0.07734865f, -0.25588566f, 0.34841692f, 
    0.21011966f, 0.27379328f, 0.08331387f, 0.31305018f, 0.22593531f, -0.93626487f, -0.41391391f, -0.14453579f, 
    0.87521553f, 0.78138661f, 1.05550647f, 0.40876600f, -0.49974963f, 0.44412646f, -0.75985759f, -0.24311508f, 
    0.16353311f, -0.06826254f, 0.46370459f, 0.29735383f, -0.11350830f, 0.05191734f, -0.04128169f, -0.33209172f, 
    0.02441222f, -0.14380321f, -0.07038584f, -0.17534280f, 0.00925163f, -0.18890381f, -0.60735685f, 0.23484883f, 
    -0.28818545f, -0.58584684f, -0.08103836f, 0.72145075f, -0.10392538f, -0.36938128f, -0.16982366f, 0.15909517f, 
    0.40094268f, -0.29058525f, -0.16724159f, -0.12165146f, 0.02392735f, 0.03347167f, -0.41584036f, 0.21698792f, 
    -0.48900247f, -0.31294855f, -0.17329058f, 0.28604236f, 0.48065639f, 0.48705661f, -0.00969955f, -0.17550027f, 
    0.99451655f, 0.08368494f, -0.45589280f, 0.02556652f, 0.56700116f, 0.20835070f, -0.81227088f, 0.49571359f, 
    0.34455085f, -0.09947550f, -0.06531373f, -0.06170439f, -0.01744236f, 0.09257623f, 0.09409863f, 0.26982340f, 
    0.25098959f, 0.50970161f, -0.27314293f, -0.06090117f, 0.16501924f, 0.07757013f, 0.09356089f, 0.22995655f, 
    0.85255754f, 0.39948449f, -0.10510337f, -0.14019611f, -0.01888254f, -0.37815937f, 0.27026999f, -0.10450459f, 
    0.35565019f, 0.60721171f, -0.11816645f, 0.28507382f, -0.02923950f, 0.03328015f, -0.54110086f, -0.25706208f, 
    -0.11764486f, -0.15489569f, -0.24360886f, -0.03702939f, 0.05657867f, -0.31965783f, -0.09659352f, -0.14896435f, 
    -0.17959274f, 0.19963048f, 0.55072749f, 0.64833128f, -0.49462718f, -0.65934515f, -0.65829647f, -0.16227926f, 
    0.32645616f, -0.03204916f, 0.20290609f, -0.01991319f, 0.00229203f, -0.05808358f, -0.26838276f, 0.21771140f, 
    0.12375183f, 0.32358629f, 0.07664733f, -0.01719519f, -0.43077219f, -0.14481193f, -0.27104661f, 0.04009100f, 
    -0.32162067f, -0.10521586f, 0.21361086f, 0.17675260f, 0.32629085f, -0.23562250f, 0.95742768f, 0.41013476f, 
    -0.28649428f, -0.76624030f, -0.06922344f, -0.51991618f, 0.34688255f, 0.09090175f, -0.25721851f, 0.18551800f, 
    0.00875614f, -0.27271381f, -0.35640514f, 0.26960170f, 0.20774879f, 0.23701689f, -0.00633223f, -0.05468107f, 
    -0.16798161f, -0.23127827f, -0.19579108f, -0.37836847f, -1.27092421f, -0.34392318f, 0.12959506f, 0.13400471f, 
    0.16087893f, 0.86359179f, 0.18037245f, -0.33422196f, 0.48189482f, -0.34657940f, 0.26588666f, -0.05406181f, 
    0.15146908f, 0.00994582f, -0.31097198f, 0.18626249f, -0.18346836f, 0.09954952f, -0.01539491f, 0.27858815f, 
    -0.01771461f, -0.08620869f, -0.09383528f, 0.18084082f, 0.76869082f, 0.43220592f, 0.44034201f, 0.58774447f, 
    0.48254108f, -0.37884417f, 0.04821853f, -0.03664332f, 0.43766183f, -0.43543023f, -0.22970597f, -0.40265125f, 
    -0.11326575f, 0.32755560f, 0.05311250f, 0.30402860f, -0.28221965f, 0.02985949f, 0.28588420f, 0.44666022f, 
    0.10567325f, 0.02466788f, 0.33960843f, -0.09020063f, 0.37193787f, -0.70631051f, -0.18730931f, 0.14863943f, 
    -0.25987959f, 0.10599406f, 0.26082286f, -0.07054418f, -0.28094885f, 0.00685387f, -0.43660530f, 0.41529378f, 
    -0.27017596f, -0.30110711f, -0.43767533f, -0.31221607f, 0.09774303f, 0.16892414f, -0.25440112f, 0.17552501f, 
    -0.13127148f, 0.05725530f, 0.36402497f, -0.04670260f, -0.39571401f, -0.30976826f, -1.18632305f, 0.18409823f, 
    0.47253457f, -0.12219461f, -0.51809287f, 0.05146552f, 0.27310935f, 0.37606272f, 0.34386718f, -0.48701945f, 
    -0.09718899f, 0.07780539f, 0.29749262f, 0.10803977f, 0.10814358f, 0.20550618f, -0.44851205f, -0.29251653f, 
    -0.33210525f, -0.00911340f, 0.11415689f, 0.15332747f, 0.21647677f, 0.30204687f, 0.20813118f, 0.91743124f, 
    0.14242010f, -0.26366487f, -0.33479363f, -0.56235552f, 0.29325098f, 0.30191782f, 0.38674054f, 0.84057170f, 
    0.18200696f, -0.22469470f, 0.27835384f, -0.32094833f, 0.21517861f, 0.36337382f, 0.08860865f, -0.09435684f, 
    -0.28875378f, 0.21284382f, 0.11410347f, -0.31905302f, 0.01707864f, -0.08115985f, -0.18293029f, 0.14066419f, 
    0.69787514f, 0.72644603f, 0.56560755f, 0.45443839f, -0.03396134f, 0.48091522f, 0.15692638f, -0.15103731f, 
    0.27331269f, -0.05237829f, 0.41498148f, -0.17011233f, 0.23156759f, -0.25345725f, -0.12915739f, 0.04395813f, 
    0.13069667f, 0.15969059f, 0.24963240f, 0.11747738f, 0.01971524f, -0.27040669f, 0.14893706f, 0.29902977f, 
    -0.01510605f, 0.00699551f, 0.05665296f, 0.29565817f, -0.33773994f, -0.12811577f, -0.53416002f, 0.21626642f, 
    -0.88563389f, -0.59971195f, -0.36397743f, 0.20502360f, 0.46077630f, 0.10030704f, -0.18910962f, -0.48443571f, 
    -0.38886553f, -0.02803231f, 0.14332414f, -0.33990583f, 0.18214408f, -0.20194772f, 0.28221995f, -0.18618272f, 
    -0.11818549f, -0.14875631f, -0.29015458f, -0.32750809f, -0.54788023f, -0.30955186f, -0.79124391f, 0.72406805f, 
    0.38095790f, -0.19578278f, 0.70028538f, 0.44129753f, -0.21415348f, -0.50676119f, -0.14685100f, -0.45503622f, 
    -0.11509281f, -0.26699072f, -0.12215863f, -0.23264469f, 0.11931261f, -0.22283462f, -0.21659227f, -0.20932347f, 
    0.07143894f, -0.19290391f, -0.02261335f, 0.60853928f, 0.46366021f, 0.56456214f, 0.24362467f, 0.19895886f, 
    -0.01054019f, 0.12003816f, 0.39037061f, 0.45747215f, 0.23572823f, -0.19036339f, -0.15398970f, -0.51150554f, 
    -0.42298621f, -0.05214760f, -0.30842119f, -0.27356032f, -0.35814175f, -0.20736144f, -0.37101755f, 0.27858064f, 
    0.50215173f, -0.22271799f, 0.07383736f, 0.07784779f, -0.71405661f, -0.95938951f, -0.48141667f, 0.38490191f, 
    0.15134545f, -0.23183231f, -0.07186447f, -0.09052347f, -0.02219565f, -0.17325845f, 0.38090006f, 0.19650204f, 
    -0.33050379f, 0.44152036f, 0.27705055f, 0.11604082f, 0.25748363f, 0.04438351f, -0.12448411f, -0.00289098f, 
    -0.00375877f, -0.06064769f, 0.06086174f, 0.03110257f, -0.17791668f, -0.31262273f, -0.96198797f, -0.76499975f, 
    -0.36793682f, -0.44053584f, -0.60389560f, 0.23083594f, 0.48910013f, 0.37540489f, 0.29276368f, 0.40831006f, 
    -0.25730267f, 0.09242134f, -0.01824096f, -0.34751046f, -0.01010587f, 0.25656280f, -0.05618341f, -0.25927389f, 
    0.07634315f, 0.01700564f, -0.06315131f, 0.04417785f, 0.04484514f, 0.02939083f, -0.17272289f, -0.20531021f, 
    -0.22816762f, -0.45828700f, 0.47242868f, 0.28654504f, -0.18318683f, 0.52330816f, -0.01805279f, -0.64851451f, 
    -0.09943505f, -0.39564651f, 0.02949086f, -0.15328912f, -0.11786481f, 0.44818011f, -0.08612363f, -0.11962151f, 
    -0.44979256f, -0.41974717f, -0.30236274f, -0.13301036f, 0.12071743f, 0.32137892f, 0.33742738f, 0.80386168f, 
    0.40713942f, 0.61980063f, -0.53033090f, -0.15794723f, -0.20343220f, -0.56540179f, -0.07850048f, -0.28393558f, 
    -0.41247022f, 0.28660670f, -0.07370521f, -0.14126697f, 0.56678790f, -0.29452497f, -0.06767061f, -0.38352838f, 
    -0.04274633f, -0.26405090f, -0.13412526f, -0.32810798f, 0.27777463f, 0.18302520f, 0.02667354f, -0.16305068f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.15440211f, 0.23597279f, 0.09909675f, 0.16216512f, 0.14584096f, 0.30645829f, 0.29803732f, 0.28631949f, 
    0.11327600f, 0.06550699f, 0.11694815f, 0.10972288f, -0.03262123f, 0.06532188f, 0.02129891f, 0.01057719f, 
    0.33884251f, -0.04304402f, -0.01025620f, 0.30299196f, 0.21466278f, -0.05071239f, 0.14685284f, 0.02913212f, 
    -0.04628918f, 0.05803097f, 0.13814893f, 0.23260942f, 0.20011882f, 0.07141123f, 0.22341996f, 0.19642276f, 
    -0.05249862f, 0.04236484f, -0.01887242f, -0.09156498f, 0.20781441f, 0.16126053f, 0.10650692f, 0.07409364f, 
    0.12678948f, 0.03276992f, 0.17988309f, -0.05982910f, 0.14119850f, 0.27048019f, 0.06719926f, -0.06523288f, 
    0.14374091f, 0.09305696f, 0.14294782f, 0.27136987f, 0.24299774f, 0.29455432f, 0.25197151f, 0.34784716f, 
    0.03236587f, -0.00384118f, 0.03207697f, 0.16242571f, 0.35980058f, 0.08592753f, 0.15669444f, 0.22932720f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.05956746f, 0.08511349f, 0.01064197f, 0.20311496f, -0.07126315f, 0.00461361f, 0.06161527f, -0.10685666f, 
    -0.02963291f, 0.00298661f, 0.02930118f, -0.12851256f, -0.23233664f, -0.00884962f, -0.17999731f, 0.22395457f, 
    -0.04890594f, 0.03347561f, -0.06152977f, -0.04796515f, -0.02500643f, -0.07863005f, 0.04226544f, -0.03286342f, 
    -0.02648979f, 0.18371585f, -0.07101665f, 0.11151612f, -0.04136574f, 0.01225686f, -0.12805371f, 0.02105497f, 
    -0.00957311f, -0.01810966f, -0.04278623f, -0.08845443f, -0.16578983f, -0.05973484f, -0.15336892f, 0.12523146f, 
    -0.08786680f, -0.12196603f, 0.02866955f, -0.00219422f, 0.06356192f, 0.18170314f, -0.24074066f, -0.06082204f, 
    0.27040154f, 0.02462641f, 0.03348784f, -0.30183521f, -0.07021440f, 0.01970124f, -0.00694612f, 0.09331470f, 
    -0.07976783f, -0.01742945f, -0.02858074f, 0.06870576f, -0.24087578f, 0.05009778f, -0.11260685f, -0.19397530f, 
    0.05256248f, -0.04770679f, 0.00421604f, 0.00725345f, -0.02324530f, -0.02738551f, -0.02442501f, 0.09773988f, 
    -0.08332382f, 0.22247377f, -0.13493626f, 0.00316876f, -0.02654459f, -0.02404153f, -0.03498181f, -0.05550115f, 
    -0.07016583f, 0.06476585f, -0.03459377f, -0.05602182f, -0.14308137f, 0.09278222f, -0.01964404f, -0.18382333f, 
    -0.07001226f, -0.08167387f, -0.00183413f, 0.01113413f, 0.01049168f, -0.12236354f, -0.07433857f, 0.04468244f, 
    0.27860790f, 0.09859530f, 0.17592019f, 0.05982428f, -0.02467946f, 0.00757923f, 0.06634906f, 0.00032934f, 
    0.03759516f, 0.10335495f, 0.12755622f, 0.01375449f, -0.02860145f, 0.00075907f, 0.06566221f, 0.23618460f, 
    -0.01808434f, 0.00528967f, -0.00314301f, -0.01501898f, -0.11348127f, -0.07654385f, 0.08835761f, -0.03742042f, 
    0.22767819f, 0.08054224f, -0.06609061f, -0.09815102f, -0.01218479f, -0.01406619f, 0.08406414f, -0.13506302f, 
    0.07350089f, -0.05926839f, -0.00346252f, 0.01816701f, 0.30890408f, 0.08214435f, 0.19113524f, -0.14974338f, 
    0.00621422f, -0.03992853f, 0.07295540f, 0.02949668f, 0.02611721f, 0.01910334f, -0.01949523f, -0.12929326f, 
    -0.01873168f, 0.06180380f, 0.17503296f, -0.33778331f, -0.09349717f, -0.15090604f, 0.05063097f, 0.06696445f, 
    -0.03716799f, -0.04760103f, -0.02222509f, 0.00502249f, 0.19655941f, 0.12696236f, -0.08310930f, -0.21525604f, 
    0.08026984f, -0.03601243f, 0.07207831f, -0.02077502f, 0.01384014f, 0.01418064f, -0.07010279f, 0.02919326f, 
    0.12190424f, 0.01351939f, 0.06696793f, 0.18303061f, -0.09421432f, 0.02118274f, 0.01095615f, -0.02434072f, 
    -0.10714583f, 0.06313976f, 0.09895081f, -0.03382452f, -0.00518023f, -0.36478984f, 0.10118334f, 0.11876576f, 
    -0.09323800f, -0.01509717f, -0.00552748f, 0.18402655f, 0.12710075f, 0.03054003f, 0.02409663f, -0.13084911f, 
    -0.07743114f, 0.06134186f, 0.00969938f, 0.10373053f, -0.09133757f, -0.03483706f, 0.01607259f, -0.02567686f, 
    -0.06527075f, -0.06087750f, -0.14941633f, -0.05465492f, 0.00904727f, 0.07257424f, -0.19805506f, 0.28853983f, 
    0.04114529f, 0.02707868f, 0.17400451f, -0.02125603f, -0.03022001f, -0.05621912f, -0.01925604f, 0.01065963f, 
    -0.08197738f, 0.06356223f, 0.08135539f, 0.04265112f, 0.02124210f, -0.05185944f, -0.01048806f, -0.05149619f, 
    0.06427186f, -0.11301036f, 0.02708640f, -0.01911425f, -0.34217292f, -0.08165494f, 0.09106582f, -0.04062418f, 
    -0.12398152f, 0.13262980f, 0.07175764f, 0.04303886f, 0.10478956f, 0.06466142f, 0.05555619f, -0.02322399f, 
    -0.04905360f, -0.03999401f, 0.07944082f, -0.17187513f, -0.02008731f, -0.04993591f, 0.03153798f, -0.10672686f, 
    -0.00804226f, -0.11383074f, -0.00130356f, 0.07836032f, -0.06659150f, 0.05560006f, 0.03224190f, 0.03844766f, 
    -0.06780033f, 0.13962917f, -0.00937217f, -0.11447174f, 0.12981048f, -0.00819898f, -0.05160131f, -0.03187623f, 
    0.14663242f, 0.06692503f, -0.23087746f, 0.19734804f, -0.01736136f, -0.00206097f, -0.05538098f, 0.04378386f, 
    0.00608969f, -0.03992594f, 0.02507603f, -0.10807887f, 0.03832617f, 0.06880708f, 0.14679970f, 0.13811898f, 
    -0.10960793f, 0.02115112f, 0.02074140f, -0.00916597f, -0.00577577f, 0.05638539f, 0.00351385f, -0.13058800f, 
    -0.02237166f, 0.11216524f, 0.24608113f, -0.14613602f, -0.05487501f, 0.10040805f, 0.03563033f, -0.02903904f, 
    -0.00131605f, -0.22365859f, 0.10015223f, 0.02769793f, -0.09415178f, -0.15050243f, 0.00051921f, 0.07313260f, 
    0.06145979f, -0.02337409f, -0.01995562f, -0.03321332f, 0.08502764f, -0.03648454f, 0.02487145f, -0.13923825f, 
    0.04252163f, 0.05009684f, -0.10681972f, 0.21091515f, 0.03827596f, 0.06409238f, -0.07800164f, -0.11264301f, 
    -0.04676774f, -0.01739725f, 0.00298597f, 0.11474730f, 0.14813584f, -0.15114765f, 0.03166353f, -0.22304089f, 
    -0.13907781f, 0.02136745f, -0.05893071f, -0.09325443f, 0.01231097f, -0.12411548f, -0.02632892f, -0.08151269f, 
    0.05762210f, -0.06249845f, -0.06723801f, 0.12384149f, -0.18765156f, -0.00827808f, 0.05479558f, -0.03049232f, 
    -0.04812286f, 0.01794850f, -0.06315751f, -0.07824069f, -0.04483397f, 0.20669235f, -0.10067892f, 0.19184852f, 
    -0.10440592f, -0.05949162f, 0.00347614f, -0.00792962f, 0.03664026f, 0.12554601f, -0.08476811f, -0.03959626f, 
    0.08485809f, 0.11536100f, 0.10328664f, 0.06866196f, -0.02024592f, 0.01609841f, -0.03677447f, 0.05671050f, 
    -0.12211801f, -0.07343929f, -0.02287303f, 0.07333676f, -0.47173628f, 0.11263506f, 0.26708016f, -0.48889509f, 
    0.03729200f, 0.07815374f, 0.05256978f, -0.12103350f, -0.06232687f, -0.05204542f, -0.06736939f, 0.05764576f, 
    -0.02515769f, 0.03139093f, -0.04833483f, -0.22607279f, -0.01948743f, -0.00794982f, -0.12262032f, -0.05821043f, 
    -0.00925192f, 0.10297556f, 0.04287623f, -0.00632676f, 0.02409485f, 0.21426727f, -0.00105007f, -0.10563461f, 
    -0.04178867f, 0.14873421f, 0.03485302f, -0.12847410f, 0.02663057f, 0.02327323f, 0.03631337f, 0.01106530f, 
    -0.09904472f, 0.14816983f, -0.18841481f, 0.25130293f, 0.08924644f, 0.06756142f, 0.08853289f, -0.03593557f, 
    0.00468879f, -0.03524122f, 0.09081100f, -0.00947326f, 0.00577050f, 0.15265775f, -0.06227508f, -0.03525507f, 
    -0.15085934f, 0.10128762f, -0.18161640f, -0.02142335f, 0.13176465f, 0.07477298f, 0.07505117f, 0.08872152f, 
    -0.49354419f, -0.19302352f, 0.09918059f, 0.07192658f, -0.08472744f, 0.03720231f, 0.02901184f, -0.20228827f, 
    -0.08085819f, 0.01568548f, 0.02688866f, -0.05964796f, -0.40247273f, 0.10619098f, 0.00451752f, 0.07210863f, 
    0.07536590f, 0.01847139f, 0.00634501f, 0.10181236f, 0.06108013f, -0.06141356f, 0.09088394f, 0.00993756f, 
    -0.13657989f, 0.05501638f, -0.04132296f, -0.10321150f, 0.07558821f, -0.01443760f, -0.03356553f, 0.07878242f, 
    0.03901458f, -0.02901387f, 0.04207342f, -0.10466116f, 0.23769052f, 0.02611856f, -0.11646611f, -0.02993120f, 
    -0.16080479f, -0.00049686f, -0.04679766f, 0.03641634f, -0.08074370f, 0.01390815f, -0.00904185f, -0.01570540f, 
    -0.01069075f, 0.06112359f, -0.01434665f, 0.23892011f, -0.04814259f, 0.02644400f, -0.03244837f, 0.01316738f, 
    0.06344794f, -0.04445588f, 0.10195506f, -0.01973069f, 0.30417323f, -0.16328412f, 0.11863822f, 0.01275444f, 
    0.03233518f, 0.03913547f, -0.02843573f, -0.02292672f, -0.22159965f, -0.01201657f, 0.10288411f, -0.00528633f, 
    -0.04343491f, 0.08795720f, 0.07052036f, -0.07257044f, 0.04971862f, 0.04608332f, -0.07729062f, -0.07548909f, 
    -0.00565303f, 0.02734335f, -0.03171868f, 0.06580772f, -0.38657445f, -0.44338745f, -0.08738760f, 0.11478039f, 
    -0.08473227f, -0.07710977f, 0.04034315f, 0.00466150f, 0.03504842f, 0.03339994f, -0.06509101f, -0.04016808f, 
    -0.10026450f, -0.12637550f, 0.09850028f, -0.02077277f, -0.07566621f, 0.05038400f, 0.10601504f, -0.06721006f, 
    0.06216091f, -0.04230999f, 0.06746525f, 0.04240770f, -0.42916232f, 0.04131926f, 0.03230976f, 0.07882649f, 
    0.12630247f, -0.08422901f, 0.00102934f, 0.01763480f, 0.06230196f, -0.09665014f, -0.02853017f, 0.06599269f, 
    0.24950662f, -0.08246525f, -0.00965132f, -0.16435957f, 0.02890328f, 0.11300918f, 0.07943342f, 0.04807827f, 
    0.06020144f, -0.09339186f, 0.02497550f, -0.01376225f, 0.27720097f, 0.05569349f, 0.10961204f, -0.04690750f, 
    -0.07783656f, -0.00093009f, 0.03212799f, -0.09822614f, 0.01501445f, 0.05268120f, -0.11716565f, 0.09395152f, 
    -0.00950183f, -0.10650586f, -0.09464277f, -0.01929440f, 0.00248188f, -0.15200242f, -0.06220774f, 0.08273397f, 
    -0.07617899f, 0.15433554f, 0.09029383f, -0.13142672f, -0.32541573f, 0.15723722f, -0.17287256f, 0.02973770f, 
    -0.13306887f, -0.04372055f, -0.03101826f, -0.05999456f, 0.09293298f, 0.04186453f, 0.00396314f, -0.02012851f, 
    -0.00111234f, 0.03366652f, 0.15809746f, -0.10742003f, -0.20602211f, 0.08890603f, 0.04219639f, 0.01377814f, 
    0.05679230f, -0.05177851f, -0.00012696f, -0.00952145f, -0.18735300f, 0.05908567f, 0.00101721f, -0.19059481f, 
    -0.00759869f, -0.02541671f, -0.00761817f, 0.05387896f, 0.01412831f, 0.06199132f, -0.01904824f, 0.04925377f, 
    0.12588228f, -0.02064611f, -0.12418830f, 0.06466463f, -0.17805523f, -0.01227259f, -0.01566341f, 0.09357623f, 
    0.02549984f, -0.08648520f, -0.01581885f, -0.11797687f, -0.15335913f, -0.19180353f, 0.09456220f, -0.00160338f, 
    -0.13345072f, 0.02536795f, -0.02023655f, 0.01581573f, -0.09242859f, 0.07278195f, 0.00815208f, -0.02569844f, 
    -0.00286322f, 0.06676278f, 0.07143712f, 0.15459929f, -0.11327431f, 0.07016365f, -0.07614195f, 0.02370806f, 
    0.11251575f, 0.03796105f, 0.04045208f, -0.05121594f, 0.23334464f, -0.22095874f, -0.19222349f, -0.23967531f, 
    -0.03175231f, -0.03085477f, -0.06953071f, 0.01377905f, 0.08093324f, -0.01088865f, 0.18727612f, 0.07205638f, 
    0.16246097f, 0.01957374f, -0.12581083f, 0.06382176f, -0.10857697f, -0.02634565f, 0.01442760f, 0.02822121f, 
    -0.03126316f, 0.01651730f, -0.01517520f, -0.00807123f, -0.15866116f, -0.04881840f, 0.12481877f, 0.02526953f, 
    -0.15301731f, -0.00182120f, -0.00850841f, 0.04389581f, -0.00110309f, 0.05797355f, -0.07545987f, 0.01413809f, 
    0.36832783f, 0.04501913f, -0.05401874f, -0.09518305f, 0.09244689f, 0.08846359f, 0.05008133f, -0.02883233f, 
    -0.03824900f, -0.02847975f, 0.06065325f, 0.10676874f, 0.07743965f, -0.01128952f, -0.03800068f, 0.04945188f, 
    -0.09785674f, -0.18509795f, -0.00058614f, -0.05102833f, -0.09742559f, -0.07412696f, -0.02444943f, 0.04437431f, 
    -0.33655274f, -0.12872456f, -0.18281031f, 0.18670635f, 0.03160786f, -0.02312411f, -0.01367786f, 0.01917235f, 
    0.00961766f, -0.06938035f, -0.01403357f, -0.05183963f, -0.16372108f, 0.15769893f, -0.23456648f, -0.19783624f, 
    -0.05012023f, 0.09350937f, 0.02042343f, -0.00416362f, -0.05539960f, 0.02184299f, 0.01739044f, 0.02342759f, 
    0.03174955f, 0.07294532f, 0.06735030f, -0.18791488f, 0.00676166f, -0.05065704f, -0.07459585f, -0.09340881f, 
    -0.03302170f, 0.05272061f, 0.02363958f, -0.13108248f, 0.08607101f, 0.18330298f, 0.08433308f, -0.24190062f, 
    -0.14135337f, -0.02238928f, -0.19243230f, 0.04289525f, 0.05509176f, -0.01441801f, -0.08258881f, 0.02022607f, 
    -0.08150937f, -0.01098252f, -0.20655777f, -0.13161646f, -0.11112329f, -0.00593589f, 0.01222396f, 0.03326515f, 
    -0.06964274f, -0.11107510f, 0.02012794f, 0.11331390f, -0.10926408f, 0.12527086f, -0.04926074f, 0.15313965f, 
    -0.05408656f, 0.03703604f, -0.06002245f, -0.09766403f, -0.05695767f, -0.09340265f, -0.00260363f, 0.00861500f, 
    -0.11189649f, -0.02978198f, -0.16609268f, 0.03565084f, -0.00940916f, -0.01660587f, 0.10201669f, 0.08585585f, 
    0.01028711f, 0.00871552f, 0.06790968f, 0.17498425f, -0.06639903f, 0.05403036f, 0.09571797f, 0.00339047f, 
    -0.00651597f, -0.06490335f, -0.02530016f, -0.04417334f, -0.03742515f, -0.23806004f, 0.09748361f, -0.09130701f, 
    -0.34645444f, -0.29964513f, 0.05044369f, -0.29306641f, -0.05834030f, -0.01291752f, 0.03594540f, 0.02129033f, 
    0.08099140f, 0.18263465f, 0.06098030f, -0.04846407f, 0.32124263f, -0.06970747f, -0.09099276f, 0.04248042f, 
    0.04309192f, -0.02771831f, 0.09313088f, 0.01136723f, 0.12201597f, 0.00648236f, 0.04539674f, 0.01449420f, 
    -0.02038718f, -0.15632917f, -0.14295915f, 0.04367516f, 0.01135571f, -0.00070276f, 0.11074224f, 0.02575538f, 
    0.08708601f, 0.05746080f, -0.09395739f, 0.19380254f, -0.05188261f, 0.00150823f, -0.16207860f, -0.07142723f, 
    0.02775935f, -0.03110299f, -0.02876560f, 0.05903687f, 0.04519585f, 0.02300193f, 0.08705559f, 0.12221663f, 
    -0.62701035f, 0.06959139f, -0.06542885f, 0.02884465f, 0.01457910f, -0.03094224f, 0.04687819f, -0.05296082f, 
    -0.05977754f, -0.04132451f, -0.06717063f, -0.06408990f, 0.37802878f, -0.14025207f, -0.01372569f, 0.13574213f, 
    -0.09216315f, 0.01626012f, 0.09167250f, -0.05238489f, 0.10465349f, 0.15874591f, -0.03560476f, 0.04905398f, 
    0.04950052f, 0.02583002f, 0.04016695f, -0.08580526f, 0.05627852f, -0.05054287f, -0.07582069f, 0.04002815f, 
    -0.06117234f, 0.04614503f, 0.00719820f, -0.08759813f, -0.10928448f, -0.03282346f, 0.03415276f, -0.42500764f, 
    -0.03552620f, 0.01749482f, 0.02626681f, 0.05171094f, 0.06842994f, -0.04485909f, -0.01483007f, -0.02848163f, 
    0.25044417f, 0.07416510f, 0.07801190f, -0.08209259f, -0.19623254f, 0.01551255f, -0.03442331f, -0.01192268f, 
    -0.06148851f, -0.07157317f, 0.08456846f, -0.11404819f, 0.08738239f, -0.16864540f, -0.08710537f, -0.07533992f, 
    0.13744073f, -0.04883067f, 0.01775937f, 0.07876425f, 0.09585058f, 0.04321834f, 0.01445943f, 0.12414965f, 
    -0.38554206f, -0.02564688f, -0.01014244f, -0.00354880f, 0.08089238f, -0.12344909f, 0.05930109f, -0.16013062f, 
    0.30719706f, 0.07053317f, -0.08848208f, -0.03657372f, 0.11746442f, -0.10310503f, -0.00271957f, 0.07364254f, 
    0.07670667f, 0.09454967f, -0.10818472f, -0.08810072f, -0.07909045f, -0.10268793f, -0.15435416f, 0.06540686f, 
    0.09114391f, 0.06864280f, 0.10109368f, 0.10175069f, 0.00176540f, -0.08258152f, 0.02948023f, -0.07445310f, 
    0.00110209f, 0.10651165f, 0.11239940f, 0.03365749f, -0.33287200f, -0.08330394f, -0.24982911f, 0.19978522f, 
    -0.02857818f, -0.06694946f, -0.03462003f, -0.05625087f, -0.08718032f, -0.14845258f, -0.02132097f, -0.08815715f, 
    -0.06674643f, 0.18348703f, 0.00523869f, -0.06966992f, 0.02402678f, 0.09937134f, 0.03749801f, -0.11813824f, 
    -0.01012018f, -0.03939731f, 0.06221245f, -0.09398323f, -0.13665113f, 0.01108267f, -0.19462080f, -0.02202962f, 
    -0.05094359f, 0.00522672f, -0.03069688f, 0.07322485f, -0.10743725f, -0.00563740f, -0.19650203f, 0.03146102f, 
    -0.09506209f, 0.16755946f, -0.07429477f, -0.21683580f, -0.03454984f, -0.01663916f, 0.03817468f, 0.05164390f, 
    0.08735539f, 0.06596775f, 0.04148633f, 0.03862208f, 0.16072933f, -0.47599611f, -0.06453271f, 0.04766630f, 
    0.00914838f, -0.04399120f, 0.13391341f, -0.09226448f, -0.06761101f, 0.06176624f, -0.00433460f, 0.02608093f, 
    -0.21170358f, -0.07256570f, 0.25176480f, 0.10229103f, -0.01962472f, 0.01113222f, 0.05939896f, 0.00948609f, 
    -0.01642936f, 0.10402137f, -0.09420054f, 0.00292465f, 0.15981780f, -0.01321306f, 0.06942953f, 0.12359814f, 
    -0.05745503f, 0.03299589f, -0.04268869f, 0.02196778f, -0.00106198f, 0.06088708f, 0.00572944f, 0.12268144f, 
    0.11112484f, -0.03836850f, 0.00517219f, 0.02213998f, -0.03976202f, -0.05258582f, -0.06303184f, 0.01197539f, 
    -0.04809625f, 0.14793244f, -0.03225397f, -0.03216753f, -0.21037340f, -0.22897327f, -0.01062086f, 0.01353900f, 
    0.01150852f, 0.00975506f, 0.00194738f, 0.00107789f, -0.13731620f, 0.10620857f, -0.01404984f, 0.06641994f, 
    -0.30282742f, 0.00355894f, -0.27058449f, 0.03153615f, 0.01996206f, 0.02772212f, 0.04667642f, 0.07288769f, 
    -0.04799637f, -0.05599646f, 0.00072073f, -0.06412050f, -0.19031905f, 0.03578066f, 0.04812028f, -0.12615977f, 
    0.06724899f, 0.05127643f, 0.08939856f, -0.00438136f, 0.20590866f, 0.07259247f, -0.02410257f, 0.02764147f, 
    0.17490949f, 0.09761922f, 0.12034922f, 0.11686640f, 0.01490100f, 0.03455121f, -0.04748951f, 0.04745238f, 
    -0.00367485f, -0.07949042f, 0.02828195f, 0.03136374f, -0.12614410f, -0.18621552f, -0.16710594f, 0.03098447f, 
    0.09738426f, -0.04066247f, -0.04302521f, 0.00564002f, 0.05515995f, 0.00467490f, 0.08264252f, 0.06138347f, 
    0.02138136f, -0.00871598f, -0.16137481f, -0.07118209f, -0.08798220f, 0.02772917f, 0.09707695f, 0.03335807f, 
    0.00797025f, 0.06689432f, 0.02073333f, -0.01256023f, 0.26503390f, -0.04323549f, -0.06573568f, -0.09074742f, 
    -0.16732293f, -0.04289291f, 0.01577516f, -0.07121602f, -0.03308935f, 0.06047334f, -0.00941775f, 0.04116252f, 
    0.26175991f, -0.12841330f, -0.00220158f, -0.26649931f, 0.05341177f, -0.09747667f, 0.00587485f, 0.03710595f, 
    -0.05007092f, -0.09630419f, -0.08828503f, 0.06308401f, 0.18502603f, -0.16216685f, 0.10520365f, -0.02567751f, 
    0.06223426f, 0.05820376f, -0.09781000f, 0.03066075f, 0.01676190f, 0.06751614f, -0.01977167f, 0.11513662f, 
    -0.11275572f, -0.01928222f, 0.01530887f, 0.01738333f, 0.08155882f, -0.17556527f, -0.11235788f, -0.08767245f, 
    0.02537356f, -0.06830128f, 0.01461825f, 0.11214909f, -0.01337765f, -0.02932189f, -0.01813086f, 0.17927699f, 
    0.04025957f, 0.02166065f, -0.00731356f, -0.12214613f, 0.00018131f, 0.06804404f, -0.02912331f, -0.09500341f, 
    -0.16826896f, 0.26311359f, -0.03198120f, 0.04962317f, -0.05093889f, -0.04638135f, 0.03069145f, 0.14018433f, 
    0.01074346f, -0.00009373f, -0.11203929f, -0.07090688f, -0.15194824f, 0.01393962f, -0.09401693f, -0.05365456f, 
    -0.05146084f, 0.04076653f, 0.04902947f, -0.02655258f, 0.02502745f, 0.09136472f, -0.01628650f, 0.01779288f, 
    0.15233345f, -0.02349330f, -0.24008474f, 0.11230907f, -0.05469183f, 0.00494984f, 0.02163521f, -0.00239183f, 
    -0.01513316f, 0.02441954f, -0.11596482f, 0.03891743f, 0.12910195f, 0.03007642f, 0.09678543f, 0.33145970f, 
    -0.05544876f, -0.06148597f, -0.03066627f, 0.05630971f, 0.17433034f, 0.04569515f, -0.08844913f, 0.01811361f, 
    0.27641836f, 0.03854764f, 0.05433283f, 0.12399463f, -0.09521970f, -0.00790834f, 0.00999830f, 0.02506075f, 
    -0.03031206f, 0.09759490f, -0.07629637f, 0.09447627f, 0.32321635f, -0.18235959f, 0.14019240f, -0.15825664f, 
    -0.10881893f, 0.14485013f, -0.00351841f, 0.07497477f, 0.09154911f, 0.07795775f, 0.12402973f, -0.09888151f, 
    0.12463633f, 0.00301835f, -0.21966115f, -0.08192737f, -0.09799926f, 0.05250459f, -0.01569982f, 0.03281366f, 
    0.04977829f, -0.09410008f, -0.11797012f, 0.01535455f, 0.08100416f, 0.05656695f, 0.08997366f, -0.00778951f, 
    0.05505691f, 0.02392147f, 0.06942922f, -0.01278977f, 0.08102405f, -0.07974503f, 0.11389810f, 0.17184673f, 
    0.21236025f, -0.18183310f, -0.12786266f, -0.17641573f, -0.09503906f, -0.03209957f, -0.12437241f, 0.02724738f, 
    -0.04558195f, 0.02048799f, -0.03839898f, 0.13285653f, 0.21500000f, 0.14371863f, -0.28030071f, 0.04215421f, 
    0.03036761f, 0.08383565f, -0.07690994f, 0.00022874f, -0.13033015f, 0.07308546f, 0.05383343f, -0.01965481f, 
    -0.18038081f, -0.13688360f, -0.07274492f, -0.29952860f, 0.07672700f, -0.05580224f, -0.04341701f, -0.12212355f, 
    0.09465446f, -0.12228364f, -0.15379411f, 0.05167896f, -0.17151873f, -0.08026739f, 0.13385987f, -0.09600612f, 
    -0.03233546f, -0.17357734f, -0.03525618f, 0.00890985f, 0.06957763f, -0.07915519f, -0.02353457f, -0.11621220f, 
    0.37178835f, 0.09714492f, 0.17185375f, 0.03153252f, -0.08462986f, -0.09778576f, 0.05394115f, -0.08005854f, 
    -0.04439015f, -0.17885105f, -0.12582849f, -0.03657769f, -0.01546963f, 0.05565524f, -0.20997733f, -0.22410665f, 
    0.06262609f, -0.14275731f, 0.00014848f, 0.02423503f, 0.05384815f, -0.12715790f, -0.02803619f, -0.05897032f, 
    -0.02058221f, -0.10530977f, 0.05285157f, 0.00262617f, 0.01222146f, -0.14511204f, -0.14995286f, 0.06874584f, 
    -0.18888001f, -0.06192671f, 0.02992920f, -0.08438911f, 0.30144352f, -0.09661435f, -0.02147030f, 0.06666583f, 
    0.06662793f, -0.02650193f, 0.07157217f, 0.09181407f, 0.06282073f, 0.01486732f, 0.03443965f, 0.03384027f, 
    0.23308101f, 0.02776164f, 0.05830767f, 0.23027979f, -0.07667443f, -0.06722307f, 0.07772463f, 0.09169092f, 
    0.00282867f, 0.08610689f, -0.05006769f, 0.15164529f, 0.01550808f, 0.07109731f, -0.22835109f, 0.02101194f, 
    0.01162535f, 0.03964297f, -0.01192979f, -0.03876045f, 0.03233916f, 0.03093944f, -0.12011158f, -0.04051669f, 
    -0.48220876f, -0.03192192f, -0.11034341f, -0.11457397f, 0.03227744f, -0.07259635f, 0.09147350f, 0.02687067f, 
    -0.03693451f, -0.10066018f, -0.11250342f, -0.05413203f, 0.27968922f, -0.12342103f, 0.03447466f, -0.10998984f, 
    0.12959623f, -0.16828202f, -0.01280166f, 0.00761581f, -0.15443462f, 0.10213481f, -0.02266795f, -0.02767376f, 
    0.05728352f, 0.04758102f, 0.12862563f, 0.12681288f, -0.12187867f, -0.01355998f, -0.00991608f, 0.00801855f, 
    -0.05068191f, -0.00187650f, -0.06838121f, 0.04670737f, -0.03358642f, -0.13075088f, -0.22080362f, -0.13138966f, 
    -0.07073347f, -0.05088495f, 0.05507815f, -0.04972489f, 0.08397909f, -0.08419106f, 0.13763261f, -0.14011151f, 
    -0.14892553f, -0.11165980f, -0.03492658f, -0.06635405f, 0.07695099f, -0.16640551f, -0.11645325f, -0.01331806f, 
    0.04816798f, 0.03629069f, -0.12208845f, -0.04648885f, 0.09754331f, 0.11588927f, 0.06051500f, 0.20105802f, 
    -0.01148781f, 0.03174954f, 0.07918105f, 0.01861951f, 0.05768283f, -0.06131803f, -0.07952080f, -0.07589986f, 
    0.08260772f, 0.04893933f, -0.21681689f, 0.07531142f, 0.09511145f, 0.01625431f, -0.02369113f, 0.13091445f, 
    -0.08029782f, -0.03709289f, 0.01468953f, 0.17455423f, 0.21123700f, -0.08842681f, -0.07152013f, 0.01858053f, 
    0.00117639f, -0.04097961f, -0.06595453f, 0.04232374f, 0.12480020f, -0.03334000f, -0.07798716f, 0.08371937f, 
    -0.13418557f, -0.05923836f, 0.02080042f, -0.14070770f, 0.02242989f, 0.12089729f, -0.02578004f, 0.01050686f, 
    0.00280023f, 0.02112857f, -0.06030520f, 0.08576592f, -0.00900941f, 0.04217689f, -0.07924470f, -0.06536935f, 
    0.11760910f, -0.04875150f, 0.14195044f, -0.04026323f, -0.04862002f, -0.02519392f, 0.02819063f, 0.02976733f, 
    0.11754284f, 0.02152235f, -0.23428561f, -0.06347081f, 0.00030999f, 0.00215481f, 0.02851932f, 0.05089355f, 
    -0.02564332f, 0.08323804f, -0.01326589f, -0.05708509f, 0.23531556f, -0.03430225f, -0.02263608f, -0.00713706f, 
    -0.19379114f, 0.08874786f, -0.12974009f, -0.02890339f, 0.10541972f, 0.08335067f, 0.05870239f, -0.04895183f, 
    -0.11734001f, 0.11396074f, -0.05489399f, -0.18987033f, 0.00656401f, 0.03637864f, 0.01829382f, -0.00414749f, 
    0.04521107f, -0.04331955f, -0.01125869f, -0.07336629f, 0.11321971f, -0.09411795f, -0.03223898f, 0.08992939f, 
    -0.00052165f, 0.02173211f, -0.06578864f, 0.01041551f, -0.10505614f, 0.02960396f, -0.06573419f, -0.02124514f, 
    -0.09586442f, 0.15920466f, 0.02045749f, -0.17318694f, 0.05931254f, 0.03329171f, 0.00441180f, 0.01729995f, 
    -0.08932670f, -0.03882348f, -0.01172747f, -0.00290332f, 0.25475061f, -0.02519994f, 0.05703416f, 0.14409845f, 
    -0.12928981f, -0.03716379f, -0.01419603f, 0.02410270f, -0.07844885f, -0.02224965f, -0.05413252f, 0.00509264f, 
    0.04546690f, 0.00869157f, -0.22511263f, -0.15684356f, 0.00566842f, -0.07859382f, -0.05975439f, 0.00037860f, 
    -0.07648024f, -0.04540109f, 0.04149260f, 0.00885880f, 0.01585142f, 0.01462573f, -0.18711917f, -0.22759815f, 
    0.04198958f, -0.01808310f, 0.03978280f, -0.09609016f, -0.08685315f, 0.10928089f, -0.04816287f, 0.01088992f, 
    0.44702810f, -0.02543533f, -0.06597450f, -0.27125037f, -0.10576430f, 0.00446994f, 0.01899652f, 0.14415897f, 
    -0.00229967f, 0.05825396f, -0.01973175f, -0.05537676f, -0.04925639f, -0.06194723f, 0.00044499f, -0.09350283f, 
    -0.02181159f, 0.08195177f, -0.06511121f, -0.06662982f, -0.02159288f, 0.00215773f, 0.07243542f, 0.04904154f, 
    0.08676051f, 0.18016303f, -0.01817913f, 0.26544762f, -0.08548611f, -0.11186532f, 0.02797610f, -0.01616674f, 
    -0.00328075f, -0.00191429f, -0.12321585f, 0.03983479f, 0.07875793f, -0.08742278f, 0.08134773f, 0.08151422f, 
    -0.00518342f, 0.00361475f, 0.11474164f, -0.04179663f, -0.03406949f, 0.01595997f, 0.01854064f, -0.01229398f, 
    -0.09917573f, -0.00397107f, 0.04084976f, -0.15214458f, 0.10762938f, -0.01815564f, 0.03269251f, 0.00925946f, 
    -0.01490308f, 0.19269003f, 0.03054695f, 0.02552661f, 0.14415133f, 0.08415801f, 0.19057122f, 0.21014492f, 
    -0.15359811f, -0.10207844f, 0.02485294f, 0.08917249f, -0.01012150f, 0.00343006f, -0.00179295f, -0.09818150f, 
    -0.38725099f, 0.16621299f, -0.05169986f, 0.13175875f, 0.01519422f, 0.05430382f, -0.06832436f, 0.05824478f, 
    -0.05588274f, -0.06143488f, 0.07374546f, -0.01068708f, 0.12281012f, -0.13020796f, 0.04159619f, -0.05626011f, 
    0.02105676f, -0.05826563f, 0.03227822f, 0.00144199f, -0.02874314f, -0.14970674f, -0.03768770f, -0.04658269f, 
    -0.05481881f, 0.04984915f, -0.11553046f, -0.00508062f, -0.08040120f, 0.03750286f, 0.02121169f, -0.03264092f, 
    0.01014863f, -0.06086656f, -0.06985651f, 0.00542648f, -0.11522105f, -0.12839134f, -0.10675260f, -0.09645950f, 
    -0.01442244f, 0.07036267f, -0.01159357f, -0.04491360f, 0.02807639f, 0.14040783f, -0.03788861f, 0.04620706f, 
    0.34554479f, 0.04723598f, -0.07449304f, -0.10821237f, -0.07126025f, -0.00248135f, -0.01436542f, 0.04956983f, 
    -0.06038673f, 0.07732985f, 0.07058549f, -0.00441493f, 0.31749412f, -0.06326229f, -0.01288208f, -0.24654837f, 
    -0.05750328f, 0.01330126f, -0.07800411f, 0.06553748f, 0.06796103f, -0.14316174f, 0.00286979f, -0.12126831f, 
    0.31775811f, -0.05802036f, -0.20396154f, 0.01170060f, 0.02084905f, 0.08816186f, -0.02551330f, -0.02618180f, 
    -0.04270029f, -0.04537781f, 0.00833618f, 0.03556008f, -0.27784687f, 0.02457722f, 0.08628397f, -0.03232892f, 
    -0.14126821f, 0.05782918f, -0.05852745f, 0.07684635f, -0.00397218f, 0.01808543f, 0.09032786f, -0.05611603f, 
    0.05604604f, 0.05579471f, -0.11106120f, -0.01914538f, -0.04629526f, 0.12365144f, -0.03659338f, -0.07992019f, 
    0.06711495f, -0.04692284f, -0.03199473f, -0.08454960f, 0.00315154f, 0.04000234f, 0.07549376f, -0.04327000f, 
    0.10740323f, -0.06960973f, -0.01278256f, 0.03588159f, 0.03398901f, -0.00654990f, 0.03840082f, 0.06900668f, 
    0.09934711f, 0.04109481f, 0.02968176f, 0.13620916f, 0.01825536f, -0.13778137f, 0.04229991f, -0.07132842f, 
    -0.14792545f, -0.07099708f, -0.01693533f, 0.11008986f, 0.08547426f, 0.03964611f, -0.16771601f, -0.06121270f, 
    0.06507744f, -0.04226299f, -0.00346465f, 0.00830860f, -0.00618136f, 0.03631905f, -0.00506110f, -0.15174061f, 
    -0.15090136f, 0.03654727f, -0.28130165f, -0.21729390f, -0.01891977f, 0.09694441f, -0.03300788f, -0.02515155f, 
    0.04678037f, 0.10889666f, 0.01052294f, 0.03046865f, -0.00674143f, -0.04561194f, -0.06004371f, 0.07137524f, 
    -0.09015809f, -0.01584181f, -0.07225091f, 0.02320979f, -0.05410950f, 0.06242181f, -0.04739398f, -0.07507121f, 
    0.00667624f, -0.05639648f, 0.08457838f, -0.00118097f, 0.09725957f, 0.01204453f, 0.08619991f, -0.01107654f, 
    -0.00798669f, 0.05875247f, -0.04642864f, 0.01647563f, 0.05862238f, -0.00626192f, -0.06054498f, -0.01770610f, 
    0.03893175f, -0.03897515f, 0.00551050f, -0.04456095f, -0.06090714f, -0.01984771f, -0.09642607f, -0.05954605f, 
    -0.12124888f, 0.09606513f, -0.00897538f, -0.15535553f, 0.02951624f, 0.02555987f, 0.02218767f, -0.01433054f, 
    -0.02709231f, -0.03603158f, -0.01085125f, 0.02956488f, -0.39746869f, -0.03061889f, 0.01339605f, -0.10387345f, 
    0.06653923f, -0.11497388f, 0.05619659f, -0.05004071f, -0.10412398f, 0.00382318f, -0.07919872f, 0.02042427f, 
    0.02587629f, 0.00589006f, 0.10641474f, -0.10254227f, -0.02991319f, 0.05564705f, 0.08675990f, 0.02448415f, 
    -0.03875422f, -0.09869573f, 0.06879517f, 0.01475617f, 0.16994850f, 0.14532381f, 0.08623981f, 0.13437122f, 
    -0.12080711f, 0.00625350f, -0.00855860f, 0.09556892f, 0.00336565f, 0.00304410f, 0.05490086f, -0.05894193f, 
    -0.00801243f, 0.08888076f, -0.14011282f, 0.09551100f, -0.06352771f, 0.09256496f, -0.02392723f, -0.06243438f, 
    -0.06672540f, -0.07317168f, -0.08089019f, 0.02469847f, 0.04689562f, 0.05317661f, 0.01962204f, 0.07103157f, 
    -0.01676410f, -0.02049555f, -0.05568061f, 0.02622393f, 0.06047489f, -0.11126235f, 0.12292594f, 0.06548329f, 
    0.09105633f, 0.06190921f, -0.03850835f, 0.00835144f, -0.10451099f, 0.07528651f, 0.00246955f, -0.01993307f, 
    -0.00334053f, 0.01136639f, -0.08844166f, -0.00831824f, 0.23467077f, 0.03210974f, -0.28713217f, -0.05460342f, 
    -0.10300391f, -0.01057740f, -0.02284284f, -0.03760486f, 0.01026612f, -0.07480480f, -0.03366025f, -0.06105723f, 
    0.23281671f, -0.00596098f, -0.00310476f, -0.14227465f, -0.30298293f, -0.06280017f, -0.05325983f, -0.00009862f, 
    0.04593746f, -0.07061306f, -0.06834929f, -0.02149813f, 0.01624788f, 0.17087026f, -0.01654573f, -0.04614983f, 
    0.13974741f, 0.06770983f, 0.01398502f, -0.04510975f, -0.03847819f, 0.00800987f, 0.01547926f, -0.04009685f, 
    0.06088330f, -0.10833838f, -0.06340922f, -0.07290173f, -0.02734664f, 0.01777952f, -0.02558180f, 0.03357605f, 
    -0.11938213f, -0.04223946f, 0.01727173f, -0.02194962f, -0.32237157f, 0.05202769f, 0.00242720f, -0.05474355f, 
    0.05619456f, 0.06038298f, 0.02262856f, -0.04683712f, -0.01302723f, -0.13986675f, -0.01694200f, -0.03170468f, 
    0.23671222f, 0.06468431f, -0.05711431f, -0.07311191f, 0.05443327f, -0.05473146f, -0.03187106f, -0.01862334f, 
    0.00997445f, -0.02021419f, 0.10862267f, -0.09704143f, 0.10434036f, -0.31292492f, -0.14359355f, -0.38147217f, 
    -0.06361106f, 0.08349682f, -0.17225927f, 0.00737800f, -0.05461294f, 0.01948595f, 0.00874136f, -0.07894480f, 
    -0.08146621f, -0.17636766f, 0.12770335f, -0.08251459f, 0.01295720f, -0.07138269f, 0.08557025f, -0.06197838f, 
    0.05704791f, -0.05672596f, 0.12207729f, -0.04174953f, 0.32654583f, -0.25170350f, 0.02496018f, -0.04821455f, 
    -0.01951033f, 0.03008117f, -0.10646757f, -0.07214491f, -0.00639737f, -0.05794514f, -0.18363534f, 0.09281582f, 
    0.07812191f, -0.02025629f, 0.01514411f, -0.04483040f, -0.06712227f, 0.04588925f, -0.15415150f, 0.00376616f, 
    -0.03815474f, 0.02287083f, 0.03037734f, -0.00627636f, 0.22572015f, -0.05712207f, 0.03601545f, -0.01884169f, 
    0.04416206f, 0.07434814f, 0.03218776f, -0.06917564f, -0.02154686f, 0.02598638f, -0.07474650f, -0.01473532f, 
    0.04532982f, 0.04487398f, 0.09650926f, -0.20985495f, -0.02369743f, -0.08167192f, 0.07698249f, 0.08069975f, 
    -0.03919936f, 0.10343047f, -0.01703622f, -0.06999964f, -0.01850804f, -0.05854009f, -0.11178378f, -0.02417812f, 
    -0.02578427f, 0.03310393f, 0.03006906f, 0.03334659f, 0.01037142f, -0.03544819f, 0.00189477f, -0.09278512f, 
    0.00356020f, -0.03743915f, 0.02003624f, 0.02672383f, 0.02005812f, 0.00602645f, 0.07004833f, -0.12654281f, 
    -0.01327739f, -0.04271017f, -0.11669225f, -0.01875472f, 0.29110220f, -0.16028385f, 0.12496324f, 0.01451484f, 
    -0.12214173f, -0.07129064f, 0.02228373f, 0.02071721f, 0.08254681f, -0.02560484f, -0.01827003f, 0.04060526f, 
    -0.06839978f, 0.03791523f, -0.17531799f, -0.04113802f, -0.04091101f, -0.04433482f, -0.05712800f, -0.00101216f, 
    -0.12961493f, 0.01481049f, 0.03539769f, -0.02411518f, 0.02038406f, -0.25275296f, -0.08434907f, -0.00560793f, 
    -0.10478098f, -0.01860103f, -0.01464574f, 0.02300735f, -0.02344032f, -0.04150660f, -0.05249134f, -0.05289773f, 
    0.18148428f, 0.09263734f, -0.21337561f, -0.03858993f, -0.06335561f, 0.04665739f, -0.03744706f, 0.02126054f, 
    -0.00983496f, -0.02014200f, 0.03108125f, -0.14043601f, -0.04254210f, 0.14958301f, -0.04834918f, 0.11623816f, 
    0.00032109f, -0.09039742f, 0.04715081f, 0.11305171f, -0.06408753f, -0.11174706f, 0.09536406f, -0.05544912f, 
    0.10179310f, 0.00673646f, 0.05319491f, 0.07254326f, 0.06843841f, 0.03431996f, -0.02359767f, 0.01599784f, 
    -0.11482975f, 0.06339029f, 0.04612741f, -0.00510784f, 0.05215707f, 0.05534538f, -0.06105623f, -0.08821069f, 
    -0.04214717f, 0.05427870f, 0.06159380f, 0.04806380f, 0.04730934f, 0.06302445f, -0.04420983f, -0.07736448f, 
    0.18014559f, -0.00348757f, 0.14697830f, 0.15250960f, 0.01795777f, 0.00652694f, 0.04622300f, 0.10637539f, 
    -0.06433539f, 0.10315134f, -0.00315435f, 0.03667295f, -0.01424285f, 0.07277077f, -0.05109822f, -0.09588325f, 
    0.01554933f, -0.01881466f, 0.08505171f, -0.05994559f, 0.04442638f, 0.05904888f, 0.05208443f, 0.12328545f, 
    0.30274904f, -0.28385559f, -0.04467699f, -0.00215922f, -0.13212121f, 0.04365265f, -0.14726046f, 0.01446932f, 
    -0.01355975f, -0.04539067f, 0.03664195f, -0.02894067f, 0.25223264f, -0.12662438f, 0.19730972f, 0.24375238f, 
    -0.23746264f, -0.03682277f, 0.02133087f, 0.04960264f, -0.04064341f, 0.11489929f, 0.01766268f, -0.05455523f, 
    -0.33496776f, -0.03070909f, -0.04995424f, 0.02316627f, 0.00656715f, -0.07932971f, -0.08482216f, -0.05364056f, 
    0.03258409f, 0.03390496f, -0.04668499f, -0.01658948f, -0.40776831f, 0.11068580f, -0.24677622f, -0.06633069f, 
    0.07236869f, 0.04517978f, -0.01833335f, -0.02526367f, -0.06394864f, 0.12500998f, 0.00088065f, -0.00415787f, 
    -0.37533125f, 0.23783493f, -0.07596372f, -0.09967044f, 0.03205913f, -0.03140611f, 0.01860369f, 0.05460768f, 
    -0.02799978f, -0.08789364f, 0.10262116f, 0.05465079f, -0.03917049f, -0.04536698f, 0.21859920f, -0.07369791f, 
    -0.09217360f, 0.10239353f, -0.06351813f, 0.00826079f, 0.03431417f, 0.01205777f, 0.02823643f, -0.04528617f, 
    -0.23311341f, -0.03510974f, -0.19010709f, 0.07379184f, 0.01603117f, 0.03272631f, -0.05328432f, 0.01697709f, 
    -0.01437057f, -0.01689179f, -0.07002907f, -0.12003265f, 0.13697624f, 0.07590066f, 0.00462231f, 0.17827758f, 
    0.11067960f, 0.13835639f, 0.00093023f, -0.07964821f, 0.09854491f, 0.07670834f, -0.03706982f, 0.02423641f, 
    0.25176108f, 0.17670499f, 0.03208904f, -0.10318336f, -0.03563580f, 0.02487933f, -0.02078081f, 0.16148765f, 
    0.00107757f, -0.06798242f, -0.14143091f, -0.02436957f, -0.02713108f, -0.10786430f, -0.04532365f, -0.13486293f, 
    -0.18166162f, -0.01273076f, -0.00930801f, 0.01593704f, -0.06559281f, -0.03684985f, -0.09657550f, 0.08096928f, 
    -0.10628843f, 0.05984241f, -0.15705194f, -0.00903319f, -0.02422244f, 0.05106131f, -0.05876264f, 0.04101497f, 
    -0.00391477f, 0.01065320f, 0.01921413f, -0.05379450f, 0.30322075f, 0.22886984f, -0.04066958f, -0.07685886f, 
    -0.06707178f, -0.05685192f, 0.00792690f, 0.10883070f, -0.00585641f, -0.04234822f, 0.10932925f, 0.00261033f, 
    0.01988948f, 0.18619689f, 0.22142376f, -0.16635981f, -0.08087686f, 0.01846270f, -0.01008304f, 0.07068015f, 
    0.02674677f, -0.03508913f, -0.00560983f, 0.06203840f, -0.15121050f, -0.18808481f, -0.05538207f, 0.08201367f, 
    -0.06589533f, -0.10537728f, 0.03148811f, -0.10521819f, 0.02639595f, -0.11657974f, 0.17049193f, -0.04054904f, 
    0.03814987f, 0.09406343f, -0.07660189f, -0.07674192f, -0.11468524f, -0.09983364f, 0.00617265f, -0.02054250f, 
    -0.02222750f, -0.06553864f, -0.04600341f, 0.04346142f, 0.02620723f, 0.29459861f, -0.00449049f, -0.09229124f, 
    -0.01021460f, 0.05451753f, 0.04140795f, 0.15648693f, 0.00523357f, 0.07222096f, -0.04859860f, 0.03783733f, 
    0.10545521f, -0.30169120f, -0.23412541f, 0.15483516f, -0.00039501f, -0.05695816f, 0.02402382f, 0.00087408f, 
    -0.04312860f, -0.02969587f, -0.17518377f, 0.00410532f, -0.18193029f, -0.02913118f, -0.02490608f, -0.22493745f, 
    -0.11526301f, 0.01539279f, -0.07370728f, -0.10124774f, 0.03006220f, -0.07692838f, -0.06926471f, 0.04006281f, 
    -0.15217410f, -0.13207744f, 0.03868834f, -0.07604249f, -0.04882271f, 0.10305673f, -0.01373811f, 0.10381033f, 
    -0.00752275f, 0.06654064f, -0.01837878f, 0.06711075f, 0.11140182f, -0.06904690f, 0.05462588f, 0.19322117f, 
    0.12449928f, -0.02508467f, 0.08621794f, -0.03540871f, 0.02857570f, -0.07987334f, 0.05567777f, -0.03376784f, 
    -0.21241133f, -0.40979588f, 0.04184363f, -0.00970403f, -0.08825476f, -0.03884463f, 0.03026498f, 0.01631914f, 
    -0.03533637f, -0.07601365f, -0.00002543f, -0.06209834f, -0.12801835f, 0.01958070f, -0.10237695f, 0.18063664f, 
    0.07278273f, 0.08393273f, 0.08876082f, 0.08203149f, 0.03783770f, 0.07263786f, 0.00446669f, 0.04161754f, 
    -0.05688480f, 0.05661657f, 0.00490515f, -0.13204791f, -0.11174149f, -0.04997174f, -0.01567076f, 0.01651995f, 
    -0.00902712f, 0.02782260f, -0.07669410f, 0.06023743f, 0.05601408f, 0.14461946f, 0.13703774f, -0.05001562f, 
    0.00277348f, -0.11363577f, -0.04607027f, -0.01510634f, -0.07128911f, -0.05411915f, 0.03068627f, -0.03969914f, 
    -0.45474494f, 0.00767244f, -0.00325629f, -0.13713942f, 0.01180892f, -0.01381452f, -0.09307132f, 0.09335120f, 
    0.11349487f, -0.11037229f, -0.08480357f, 0.00773096f, -0.00893146f, -0.12190029f, -0.10677381f, -0.06031320f, 
    0.00497121f, 0.08234735f, -0.06373482f, 0.18086605f, -0.00911920f, 0.03324898f, -0.03897684f, -0.01367593f, 
    -0.47696322f, -0.26641995f, 0.01858866f, 0.22877590f, 0.09285424f, 0.05283267f, -0.12166680f, -0.01498508f, 
    0.01973362f, 0.04653176f, 0.01389494f, -0.21765538f, -0.56317031f, -0.15323196f, -0.10120034f, -0.12287408f, 
    -0.13698746f, -0.06801517f, -0.02374033f, 0.00329431f, 0.06781843f, -0.11749879f, -0.12253951f, -0.01110665f, 
    -0.45532659f, -0.25314593f, 0.21057628f, 0.23733945f, -0.03680487f, 0.12811115f, 0.03262183f, 0.05972488f, 
    0.04063312f, -0.02992955f, -0.00253014f, -0.13375740f, 0.23922165f, 0.07415071f, 0.21394126f, 0.14804110f, 
    -0.06170884f, -0.03572390f, 0.03904537f, -0.10677259f, 0.05231573f, -0.01169216f, -0.03459156f, 0.02985767f, 
    0.26787060f, -0.03178114f, -0.00153978f, -0.02723723f, 0.10425989f, -0.01291557f, -0.03397107f, 0.00416039f, 
    0.06353525f, -0.00728467f, 0.02610028f, 0.01831893f, -0.05835437f, 0.01095483f, 0.07746184f, 0.05585254f, 
    -0.04651121f, 0.04698883f, -0.01042463f, -0.01636144f, 0.01278007f, -0.03966434f, 0.05861750f, -0.06661536f, 
    -0.09001151f, -0.38829148f, -0.12193991f, 0.19206204f, -0.17213324f, -0.06828616f, 0.08122724f, 0.03466152f, 
    0.05349888f, -0.04167055f, 0.01494115f, 0.01823607f, 0.08338070f, 0.09403479f, -0.24175029f, 0.02646887f, 
    0.07839362f, 0.14821672f, 0.19884031f, 0.03736443f, -0.10393980f, 0.00002494f, 0.07448143f, -0.09823867f, 
    -0.05714837f, -0.04557231f, -0.02312152f, 0.03917796f, 0.06840065f, -0.02643156f, -0.05558525f, 0.00355050f, 
    0.01052197f, 0.03268659f, 0.04267634f, -0.05201162f, 0.26553378f, -0.24057533f, 0.07599875f, 0.17788216f, 
    0.10050827f, 0.07915062f, 0.00871394f, 0.02835258f, 0.00497535f, -0.16414803f, -0.06109801f, -0.03852411f, 
    -0.11010803f, -0.07121103f, 0.06096358f, -0.07194851f, -0.15228674f, 0.10479251f, -0.07286031f, 0.01024618f, 
    -0.03161138f, 0.04414101f, -0.17253819f, 0.02590298f, -0.29707354f, -0.00567055f, -0.26927653f, -0.06716934f, 
    0.09618469f, 0.02523746f, -0.09176763f, -0.05738570f, -0.02174098f, -0.00142178f, 0.08407033f, -0.05980979f, 
    -0.11199360f, -0.04973002f, 0.12814358f, 0.19134989f, -0.03837127f, 0.08408806f, 0.22254542f, 0.00806152f, 
    0.05744311f, 0.02910089f, 0.05702838f, -0.06259223f, -0.00026478f, -0.02317548f, 0.05346308f, -0.07170428f, 
    -0.10207376f, 0.02167336f, 0.17607445f, 0.07440324f, -0.11418608f, -0.07590440f, -0.02732075f, -0.00746953f, 
    0.07900345f, -0.09378247f, -0.02795237f, 0.01829674f, 0.08026373f, 0.03229756f, 0.09875168f, 0.05558579f, 
    0.00778985f, 0.09103798f, -0.04894590f, -0.04476143f, 0.08902665f, 0.27064222f, 0.16468346f, 0.09441148f, 
    0.03744157f, -0.02743106f, -0.04948721f, -0.01266122f, 0.04989314f, -0.07640408f, 0.05078688f, 0.09310248f, 
    0.12883385f, 0.10118636f, -0.00318263f, 0.01454669f, -0.07271003f, 0.02725721f, -0.00245680f, -0.00302863f, 
    0.02928346f, -0.00835300f, 0.09042011f, 0.03737008f, -0.29492125f, -0.37554973f, 0.02489930f, 0.01049607f, 
    0.00155676f, -0.00726598f, 0.04986593f, -0.05666813f, -0.02526506f, -0.02002681f, -0.00042248f, -0.01067646f, 
    -0.42380935f, -0.37422299f, 0.02495901f, -0.00901005f, -0.09836089f, -0.08719097f, -0.05327519f, 0.04276675f, 
    -0.07063277f, -0.07319736f, 0.07183742f, -0.03378226f, 0.01383961f, 0.22042975f, -0.22170796f, 0.16836636f, 
    0.07793353f, 0.19138035f, -0.16751467f, -0.00815925f, 0.03527648f, -0.05610469f, -0.04784508f, 0.00817755f, 
    -0.13268924f, 0.13030125f, 0.07526702f, -0.02390986f, 0.02264508f, -0.04496258f, 0.04279789f, -0.02007408f, 
    -0.04749151f, 0.10567892f, -0.01317088f, 0.04091963f, 0.06232557f, 0.10348871f, 0.01351083f, 0.04149258f, 
    -0.00936000f, -0.01820816f, -0.09771716f, 0.03968215f, -0.07202858f, 0.07467114f, -0.06237350f, -0.03435178f, 
    0.08339924f, 0.04949799f, -0.02348404f, 0.09727120f, -0.12320954f, 0.00741231f, -0.02744499f, -0.02531690f, 
    -0.07909919f, 0.01854298f, -0.02929667f, -0.04995513f, 0.32869309f, -0.00724855f, -0.03616152f, 0.12404362f, 
    0.09099001f, 0.04902941f, -0.01606875f, 0.03573980f, -0.00414298f, 0.01756861f, 0.05063700f, -0.11223767f, 
    0.19546592f, 0.25081241f, 0.00234073f, 0.00781111f, -0.01594051f, -0.10338445f, -0.00890786f, 0.10397557f, 
    0.01157814f, -0.01024787f, -0.06057570f, 0.00675999f, 0.45852503f, 0.03163627f, 0.03510164f, -0.11049448f, 
    -0.15347274f, 0.00868561f, -0.08194054f, 0.03594819f, -0.05334218f, -0.10104115f, -0.06147752f, 0.07402294f, 
    -0.07997456f, 0.07744076f, -0.20464918f, 0.02336431f, -0.04296429f, 0.00289953f, -0.08848162f, -0.10537464f, 
    -0.05929561f, 0.07970139f, -0.05655271f, 0.12220155f, -0.16633028f, 0.10072924f, -0.01840235f, 0.01399925f, 
    0.01714566f, 0.00664485f, 0.04275162f, 0.05535394f, -0.00943710f, 0.02616951f, -0.00357832f, -0.05593332f, 
    0.29502264f, 0.02265782f, 0.13868070f, 0.18139704f, 0.05065412f, 0.06392561f, -0.09038413f, -0.00852444f, 
    -0.02047269f, -0.09739974f, 0.00415569f, -0.09808683f, 0.06924918f, -0.00170931f, -0.03788003f, 0.00850874f, 
    0.00141858f, -0.08231637f, 0.01013462f, 0.01821487f, -0.15032107f, 0.01560813f, -0.03034819f, 0.01202815f, 
    -0.13701116f, -0.16191910f, -0.06451132f, -0.09322835f, -0.03831061f, 0.10459192f, 0.01928968f, -0.05988429f, 
    -0.09074978f, -0.07234287f, 0.08254285f, -0.02993479f, -0.02042450f, 0.09742511f, 0.00381604f, 0.06613518f, 
    0.03957979f, 0.07002690f, -0.01264867f, 0.07925016f, 0.11315933f, -0.00437239f, 0.12983845f, -0.00019986f, 
    -0.05765754f, 0.18482183f, 0.16097997f, -0.06230359f, 0.01730886f, -0.07380122f, -0.07256641f, -0.03343218f, 
    0.01830681f, 0.09111194f, 0.02835518f, 0.03924707f, 0.01807591f, -0.34999371f, -0.10815345f, -0.06487499f, 
    -0.05791315f, 0.04099093f, -0.05141861f, -0.05855805f, -0.01040574f, -0.03197158f, 0.00718322f, -0.01159484f, 
    -0.35667825f, -0.39627901f, -0.20951696f, 0.00743265f, -0.04937118f, -0.01982174f, -0.02173930f, 0.05932691f, 
    -0.04236655f, 0.00176761f, 0.09267413f, -0.04108178f, -0.18890676f, 0.28749561f, 0.10213074f, 0.08677723f, 
    0.02991103f, 0.08048926f, -0.08646733f, 0.05611916f, -0.09715211f, 0.09316457f, -0.08235437f, 0.05911037f, 
    -0.11137363f, 0.01471652f, 0.00043969f, -0.15187876f, 0.00170245f, 0.06579436f, 0.04088649f, -0.03933164f, 
    -0.03434317f, -0.10403698f, 0.00867709f, -0.02498547f, -0.43309012f, -0.38144374f, -0.16333431f, -0.15899323f, 
    -0.15984072f, -0.06843485f, 0.04220067f, -0.12127345f, -0.09952153f, 0.05909733f, 0.03391320f, -0.01495170f, 
    0.05219067f, 0.06421761f, 0.07451044f, 0.00720825f, -0.07707335f, -0.00426853f, 0.03333415f, 0.02349000f, 
    0.02950603f, -0.00200019f, 0.11194503f, -0.12240686f, 0.12137164f, -0.14764726f, -0.03402951f, -0.02511380f, 
    -0.08747999f, 0.03137844f, 0.01573520f, 0.03183038f, -0.08021784f, 0.01146496f, 0.00609039f, -0.00995539f, 
    0.02284488f, 0.00665052f, 0.05135563f, 0.17657815f, -0.06778818f, -0.12327947f, 0.00147101f, -0.04499256f, 
    -0.05254012f, 0.07097938f, 0.01191862f, -0.11503767f, 0.02884838f, -0.11806858f, 0.03122401f, 0.08456614f, 
    -0.03803995f, 0.04044819f, -0.01340243f, 0.04738433f, -0.01900159f, 0.04164617f, 0.13438149f, -0.11739178f, 
    -0.24766326f, -0.16526167f, 0.06677982f, -0.14346880f, 0.14282408f, -0.00047579f, 0.13572277f, -0.00050848f, 
    0.08587633f, 0.01913161f, -0.04017849f, -0.04396342f, -0.48707235f, 0.10062220f, 0.07839791f, -0.13833499f, 
    -0.06432206f, -0.03087133f, -0.01871774f, 0.16568485f, 0.00365525f, -0.07094987f, -0.13764308f, 0.03399338f, 
    -0.25622702f, -0.21509650f, 0.18835869f, 0.00717290f, -0.14464515f, -0.04997026f, 0.02722099f, -0.08811244f, 
    0.14748657f, -0.09472199f, -0.01668523f, -0.13454702f, -0.22287208f, 0.01903619f, -0.02212946f, -0.10703132f, 
    -0.02397054f, 0.05787935f, -0.02038444f, -0.00961149f, -0.09950028f, 0.08251274f, -0.09903729f, 0.07052466f, 
    0.10961153f, -0.13333525f, -0.06487840f, 0.17360224f, 0.10404892f, 0.05432630f, 0.11727145f, 0.05090154f, 
    0.01894573f, 0.00307692f, -0.05599432f, -0.08690701f, -0.23636237f, 0.28263396f, 0.04251673f, 0.18439752f, 
    -0.01166567f, 0.05651018f, 0.02506934f, 0.06291205f, 0.05585120f, 0.02081788f, 0.00449359f, -0.06754863f, 
    -0.00561212f, -0.17836750f, 0.08038250f, -0.26332378f, -0.01814578f, 0.02362006f, 0.02911799f, 0.00707136f, 
    0.06515558f, 0.04129073f, -0.04270147f, -0.05202164f, 0.08202164f, 0.14188913f, 0.10462943f, -0.05027638f, 
    0.01416249f, 0.05791601f, -0.03840205f, -0.15999821f, 0.08309033f, -0.15961780f, -0.02589255f, -0.05398870f, 
    0.00728324f, 0.08723021f, -0.06810074f, -0.28283003f, -0.02194042f, -0.08458330f, -0.18366948f, 0.01321595f, 
    0.05370288f, -0.00796873f, -0.13434903f, 0.06766335f, -0.00022770f, 0.35412118f, -0.11370704f, -0.00096325f, 
    0.00175271f, 0.06880752f, 0.01042339f, 0.04100705f, -0.13868211f, -0.05266349f, 0.06325687f, 0.04488586f, 
    -0.05814358f, -0.18496655f, -0.10178821f, 0.24037851f, 0.12257443f, -0.05901734f, -0.08888723f, -0.06877251f, 
    -0.01055441f, -0.10816146f, -0.06745830f, 0.05543316f, 0.33633798f, -0.05636020f, -0.18606693f, 0.13944857f, 
    0.01037470f, -0.03138271f, 0.08872083f, -0.00049931f, -0.06679892f, 0.00749665f, 0.12503736f, 0.07628661f, 
    -0.28023681f, -0.18814906f, 0.06887812f, 0.07919049f, 0.01033776f, 0.07830948f, -0.07290079f, 0.04716478f, 
    0.06151709f, -0.01288307f, -0.03941967f, 0.10114033f, -0.21401894f, 0.12002664f, 0.07689767f, 0.17778923f, 
    0.08042015f, 0.11839838f, 0.00334630f, 0.07522715f, -0.08741947f, 0.07304054f, 0.11692876f, -0.01498314f, 
    0.03307151f, -0.01690322f, 0.03033056f, 0.03391562f, -0.01282724f, 0.14149335f, -0.04850219f, -0.10091220f, 
    -0.06606976f, 0.00839330f, 0.05163962f, 0.07576732f, 0.06830516f, 0.15187226f, 0.01734990f, -0.06917353f, 
    0.06952716f, -0.01118737f, -0.00105290f, 0.08879039f, -0.03353992f, -0.01014083f, -0.04253391f, -0.08324611f, 
    0.04835248f, -0.00367990f, 0.00553845f, -0.17222755f, -0.00821016f, -0.04663471f, -0.03318475f, 0.04461090f, 
    -0.06069921f, 0.00007544f, 0.02665222f, 0.02271617f, -0.09756877f, 0.01361038f, -0.06738297f, -0.25762022f, 
    -0.11120559f, 0.05723420f, 0.04140591f, 0.11646304f, -0.02421111f, -0.01452344f, 0.09078356f, 0.12792809f, 
    -0.02446795f, 0.08371642f, -0.18609145f, 0.01792805f, 0.00930856f, 0.04766566f, 0.10589342f, 0.12066994f, 
    0.03158176f, 0.04916868f, -0.06143436f, 0.02302543f, -0.16960348f, -0.00130422f, 0.11835947f, -0.08021823f, 
    0.09807103f, -0.05394113f, 0.02266623f, 0.08500454f, -0.01054686f, 0.02598242f, 0.03914219f, -0.07673862f, 
    -0.12914112f, 0.20115022f, -0.05017652f, 0.02645047f, -0.15717293f, 0.07268421f, 0.05488615f, -0.02753593f, 
    -0.02330498f, 0.03195354f, -0.07151116f, 0.07209170f, -0.11255594f, 0.12954293f, -0.05540971f, -0.14199315f, 
    0.02558153f, 0.02665076f, -0.10158268f, -0.02350752f, -0.06134038f, -0.02702594f, 0.14463614f, 0.01690187f, 
    -0.45189208f, -0.03515865f, 0.30314898f, 0.05857234f, -0.00463173f, -0.06686761f, -0.09033599f, -0.07719015f, 
    -0.04473928f, -0.01117767f, -0.03906860f, -0.12530366f, 0.09576555f, -0.11482745f, -0.20957617f, 0.09787210f, 
    -0.10027162f, -0.06091350f, -0.07109226f, 0.09012378f, -0.08589754f, -0.06155212f, -0.04512304f, 0.05065667f, 
    -0.30724373f, -0.13230531f, -0.12064283f, 0.15873621f, -0.02493755f, -0.05880661f, 0.07549621f, -0.12809877f, 
    -0.00072368f, -0.04376571f, -0.00151610f, -0.19868846f, 0.08275700f, -0.23040108f, -0.06902541f, 0.12585369f, 
    -0.13360281f, 0.05313926f, -0.12028727f, -0.01073503f, 0.00227829f, 0.08996850f, -0.03012525f, -0.10978470f, 
    -0.15934114f, -0.08101846f, 0.17415622f, 0.16554391f, -0.02577069f, -0.06294306f, -0.12571461f, -0.07095825f, 
    0.06040698f, -0.04186338f, -0.00494283f, 0.01141991f, 0.27146542f, 0.17965886f, -0.11255297f, 0.00735625f, 
    0.03539618f, 0.00703246f, -0.01146841f, 0.05213482f, -0.13139696f, -0.01797117f, 0.09892157f, -0.07657138f, 
    0.22941148f, 0.07866441f, -0.04992355f, -0.01398285f, -0.08173814f, -0.03211251f, 0.05193952f, 0.12184332f, 
    -0.01287901f, 0.01974751f, -0.03041440f, 0.02413204f, -0.02198701f, -0.16982052f, 0.07987200f, -0.06799976f, 
    -0.03593537f, 0.19449541f, -0.12615791f, -0.02009023f, -0.00707272f, 0.01967367f, -0.19594690f, -0.08233029f, 
    -0.27847603f, -0.09739549f, 0.11739520f, -0.10708689f, 0.00405123f, 0.02000569f, -0.02354975f, -0.00970289f, 
    0.08037837f, 0.00833785f, -0.04573894f, -0.06830523f, 0.00784068f, 0.36208415f, 0.15063542f, -0.10438457f, 
    0.13397279f, -0.02308470f, -0.06960454f, 0.01585086f, -0.10815665f, 0.02456065f, 0.06353161f, 0.01515510f, 
    -0.34595081f, -0.05112351f, 0.27383733f, -0.01690623f, -0.14267547f, -0.04432540f, 0.08985048f, 0.01693276f, 
    0.01591861f, -0.00567111f, 0.02687032f, 0.04374428f, -0.35554743f, -0.03054067f, 0.02571859f, 0.09444846f, 
    0.00042433f, 0.13891147f, 0.07217874f, 0.07844456f, -0.13555884f, -0.07182234f, 0.12042288f, 0.12499506f, 
    -0.05767537f, -0.21918483f, -0.10033100f, -0.03680152f, -0.11259632f, 0.11866011f, 0.07298104f, -0.04125709f, 
    -0.01250311f, 0.03500184f, -0.12459958f, 0.04667818f, -0.07851870f, -0.18390778f, -0.14114384f, -0.06958849f, 
    0.17582551f, -0.03475320f, 0.03281274f, -0.08459339f, -0.16604231f, -0.13093869f, -0.01457968f, -0.03686554f, 
    0.22680685f, 0.10712877f, -0.02125844f, -0.30615896f, 0.09447341f, -0.02729850f, -0.09240648f, -0.07750720f, 
    -0.00777410f, 0.00579131f, -0.02550384f, 0.09276824f, 0.11109869f, 0.19123898f, 0.01843477f, -0.09115319f, 
    -0.08113278f, -0.12332319f, -0.06696983f, -0.14163378f, 0.03857813f, -0.07008827f, 0.00068664f, 0.03258013f, 
    -0.31499013f, 0.15418009f, -0.00680021f, 0.00356168f, 0.02771621f, -0.02682910f, -0.00134285f, 0.14868553f, 
    0.01650762f, -0.01484410f, -0.05272753f, 0.02300763f, 0.13002582f, -0.06915485f, 0.12796937f, 0.05737258f, 
    -0.07835332f, -0.13141726f, 0.02028262f, 0.01218222f, 0.09148070f, -0.03192304f, -0.01299546f, -0.04069342f, 
    0.03189934f, 0.01568163f, -0.03187065f, -0.04857634f, 0.02856787f, 0.03039431f, 0.04599884f, 0.02508763f, 
    0.04628621f, -0.14818799f, -0.03324734f, -0.10972283f, -0.44167346f, 0.02035525f, -0.03205279f, -0.04506101f, 
    0.17285547f, -0.10834363f, 0.01425486f, -0.11845254f, 0.14766416f, -0.02052182f, -0.11453974f, -0.05757742f, 
    -0.40927744f, -0.05352609f, 0.11282400f, -0.13842672f, 0.06608207f, -0.05104804f, 0.02241171f, 0.04014188f, 
    0.07534254f, -0.08721049f, 0.03576014f, 0.03805007f, -0.02322508f, 0.01838022f, 0.19975431f, 0.06447721f, 
    0.09293889f, 0.00394806f, 0.07001254f, 0.12613559f, 0.15960903f, 0.01784207f, -0.02746026f, 0.07461438f, 
    0.04394089f, 0.05596236f, 0.08942907f, 0.02667794f, 0.01430467f, 0.06816884f, 0.08521552f, 0.03787768f, 
    0.00270196f, -0.11054601f, -0.05299057f, -0.06220156f, -0.21789818f, 0.13195121f, -0.12839608f, -0.48508212f, 
    -0.01973132f, -0.05067211f, 0.04125961f, 0.00624907f, 0.05446468f, -0.04044394f, 0.01116472f, 0.04022160f, 
    0.01959718f, 0.07130163f, -0.06250671f, -0.06946991f, 0.04380223f, 0.04215322f, -0.04541564f, 0.05808336f, 
    -0.18347327f, -0.02185825f, 0.06018113f, -0.01244003f, 0.02534297f, -0.03004887f, -0.10229053f, -0.01780806f, 
    -0.08735313f, -0.07116395f, -0.00459285f, 0.04136568f, 0.01005274f, -0.01185291f, -0.11684681f, 0.05801537f, 
    -0.13191968f, -0.20595819f, 0.11114276f, 0.05730713f, -0.08956876f, 0.10362201f, 0.09308485f, -0.01133306f, 
    -0.00335708f, 0.05599389f, 0.09526765f, -0.02474537f, 0.12049966f, -0.22833441f, 0.08989783f, -0.10740873f, 
    -0.10275852f, 0.06360154f, 0.06866782f, 0.08927107f, 0.02450135f, 0.15450154f, -0.00073291f, 0.13849090f, 
    -0.12961882f, 0.01673835f, -0.07154178f, -0.00676601f, 0.05385660f, -0.03376618f, 0.09331331f, 0.02117205f, 
    0.03955464f, 0.02570757f, 0.01860057f, 0.01852788f, -0.83914012f, 0.24477994f, 0.06192371f, 0.12216950f, 
    0.05876264f, -0.08745214f, -0.04171850f, 0.00790663f, -0.00861746f, 0.11498297f, 0.03073449f, -0.03311558f, 
    0.14588226f, 0.17594855f, 0.11080407f, 0.09673136f, -0.00796774f, -0.15285365f, 0.01575598f, -0.06299634f, 
    0.08977354f, -0.05323119f, 0.02952523f, -0.12436077f, 0.18361302f, 0.21091008f, 0.02516030f, -0.11302646f, 
    -0.01293169f, 0.04782161f, 0.05505836f, 0.05167297f, 0.08674111f, 0.07372146f, 0.15561119f, 0.07436933f, 
    0.12513977f, 0.05050589f, -0.11062040f, -0.14389217f, 0.05395759f, -0.00344043f, 0.02197118f, 0.00470947f, 
    -0.11423803f, -0.08146295f, -0.02721108f, -0.02015659f, -0.30905983f, 0.09212717f, 0.11502087f, 0.09183262f, 
    -0.12261587f, 0.14192325f, -0.03241456f, -0.03526841f, 0.08358096f, 0.01948178f, 0.03774202f, -0.01361331f, 
    -0.09651093f, 0.04609143f, -0.02902424f, -0.10659489f, -0.01055185f, -0.04018599f, -0.06562541f, 0.10702950f, 
    0.05675882f, -0.07746848f, 0.12089168f, 0.01085969f, -0.17899126f, -0.11342466f, 0.29760060f, -0.04649640f, 
    0.06655484f, 0.06094254f, 0.03662975f, -0.00210961f, 0.07352877f, 0.01879029f, 0.02193321f, 0.00878909f, 
    -0.33763617f, -0.05331993f, 0.07067272f, 0.25958812f, -0.07092290f, 0.03710454f, 0.07370399f, 0.08580559f, 
    -0.05311920f, 0.09866795f, 0.03458682f, 0.08586594f, 0.07691492f, 0.02223197f, 0.16679506f, 0.07781843f, 
    -0.00968153f, 0.01078248f, 0.06084935f, -0.00173900f, -0.04782462f, 0.10043591f, 0.06750105f, -0.03934980f, 
    -0.17667226f, 0.10819545f, 0.01920681f, -0.00076584f, 0.08556812f, -0.04657685f, -0.12094479f, 0.06919225f, 
    0.02429653f, -0.02836946f, -0.02497967f, -0.01818868f, -0.27312639f, 0.06901917f, 0.01189423f, 0.26435897f, 
    0.08037636f, 0.03193023f, 0.04153285f, 0.21465187f, 0.01417600f, 0.02301405f, 0.08564680f, 0.00629909f, 
    0.06670266f, 0.01577050f, -0.21306729f, 0.01506417f, -0.01222168f, -0.07585625f, -0.04325401f, 0.08030684f, 
    -0.04962859f, -0.04263678f, 0.09674674f, 0.01649348f, -0.05667220f, -0.09058758f, 0.14879856f, 0.03143325f, 
    -0.04144126f, 0.07999106f, -0.10170048f, -0.08125655f, 0.01524424f, 0.05972156f, 0.02243897f, 0.00134374f, 
    0.01300752f, 0.06048312f, 0.01081615f, 0.14399755f, -0.05941900f, -0.07641999f, -0.14397299f, 0.10122253f, 
    0.02345767f, -0.05693763f, -0.06334469f, -0.02635064f, 0.06919223f, -0.07682694f, -0.10627883f, -0.19562942f, 
    0.14509264f, -0.14666215f, 0.18252516f, 0.12108042f, -0.08301394f, 0.00307458f, 0.13926873f, -0.07264261f, 
    0.02645124f, 0.12398205f, -0.07629292f, 0.07686098f, -0.11188079f, 0.01467963f, 0.00921084f, 0.03281794f, 
    -0.09398367f, -0.06643364f, 0.04595280f, -0.02830272f, 0.03459905f, -0.14926030f, 0.04299184f, 0.00228538f, 
    0.03832464f, 0.14729339f, -0.02606742f, -0.03785123f, 0.07682408f, -0.13269618f, 0.20328031f, 0.00980373f, 
    -0.22854921f, 0.07229757f, -0.00778328f, 0.05624225f, 0.00006368f, -0.03000206f, -0.02004051f, -0.15383340f, 
    -0.05221277f, -0.08081242f, 0.05301183f, 0.00625162f, -0.45527408f, -0.14469972f, -0.15479922f, -0.02416703f, 
    0.10528844f, -0.08598905f, -0.06084806f, 0.01202630f, 0.00311360f, 0.05201284f, 0.03055609f, 0.01811430f, 
    0.01937854f, 0.12685637f, 0.10078757f, -0.00389346f, 0.11548621f, 0.06775920f, -0.10822541f, 0.06396554f, 
    0.13304690f, -0.03593114f, 0.08527406f, -0.03329753f, 0.12833221f, 0.03131326f, 0.19548906f, 0.18010534f, 
    -0.03905303f, -0.05653727f, 0.00590485f, 0.03523614f, -0.06550923f, 0.06492411f, 0.03845702f, -0.03735786f, 
    -0.54138827f, -0.17131113f, -0.10008769f, 0.08522660f, 0.04236966f, -0.00488023f, -0.03261633f, 0.02941167f, 
    -0.04851468f, -0.10146168f, -0.03791473f, -0.07461987f, -0.25708276f, 0.17602795f, 0.05649266f, -0.07161500f, 
    0.08372313f, -0.04352897f, 0.00547529f, 0.11034067f, 0.11550201f, 0.01798034f, -0.12859105f, -0.24042514f, 
    -0.23388730f, -0.01588531f, -0.09296606f, -0.14421242f, 0.07968769f, 0.10905772f, 0.06013798f, 0.00145809f, 
    0.09682313f, -0.01574240f, 0.20106439f, -0.02237421f, 0.10588959f, -0.08266992f, 0.06218228f, 0.14919224f, 
    0.11347147f, 0.04135075f, -0.18932214f, -0.16561064f, -0.12820776f, -0.06567872f, -0.04175737f, -0.02673532f, 
    -0.07582267f, -0.07832180f, 0.04014622f, 0.08128449f, 0.05806730f, -0.12384512f, 0.07531171f, 0.05451584f, 
    -0.05352665f, -0.06481370f, -0.04451590f, -0.10728770f, -0.15470243f, -0.04928992f, -0.10070617f, -0.07869431f, 
    0.01021280f, -0.02415671f, -0.06655408f, -0.21887794f, -0.05272046f, -0.05853308f, 0.04624825f, 0.08413361f, 
    0.22489847f, -0.01607636f, -0.12490240f, 0.00444676f, 0.06583284f, -0.07175937f, 0.02163295f, 0.00027253f, 
    -0.03127597f, 0.00619147f, -0.07028311f, -0.07002208f, -0.12608349f, 0.14108388f, 0.05711781f, -0.09606083f, 
    -0.07983684f, 0.03375416f, -0.01520559f, -0.20495726f, -0.02610627f, 0.04289911f, 0.00459552f, 0.08768765f, 
    -0.01377055f, 0.00892005f, 0.00160249f, 0.12796530f, -0.08174116f, 0.08379663f, -0.00782988f, 0.06960854f, 
    0.09059169f, 0.06077379f, 0.00424461f, -0.01313289f, -0.01969535f, 0.13822062f, 0.18441926f, -0.04773103f, 
    0.12327944f, -0.09968276f, -0.16418429f, 0.03871473f, 0.03539954f, -0.08295117f, 0.01813013f, -0.25862622f, 
    -0.32536575f, -0.00819266f, 0.11680359f, 0.01249888f, -0.00198130f, 0.00287413f, 0.01418837f, 0.08078149f, 
    0.03190559f, -0.05455069f, -0.08264901f, -0.17001379f, -0.24944185f, -0.17960565f, -0.04247063f, 0.07319555f, 
    0.02367443f, 0.00085105f, -0.06488350f, -0.04051325f, -0.01458142f, -0.00621638f, 0.08159427f, 0.13872004f, 
    0.03568504f, -0.06471997f, 0.05596660f, 0.01378559f, -0.09466209f, -0.11088428f, 0.01370676f, -0.06195607f, 
    -0.02508688f, 0.12208369f, 0.06435096f, 0.11689802f, -0.18522052f, 0.02380903f, -0.14790158f, 0.08993413f, 
    0.00945492f, -0.16142832f, 0.14248683f, 0.00200777f, 0.07037985f, -0.19436349f, 0.01795487f, 0.01663205f, 
    0.08222036f, 0.02646133f, 0.00285388f, -0.00157328f, -0.03728877f, 0.02839590f, 0.04749640f, 0.03483569f, 
    0.07078263f, 0.02753671f, -0.04395646f, 0.11935615f, 0.11688814f, 0.18360503f, 0.16162086f, -0.02566113f, 
    -0.04590177f, -0.00438358f, 0.16138831f, -0.08301093f, 0.12172607f, -0.09145967f, 0.01651279f, 0.12357811f, 
    -0.07044380f, 0.05317660f, -0.00582376f, -0.00909032f, -0.08865831f, -0.05645636f, -0.03432122f, -0.05129405f, 
    -0.07233333f, 0.10156050f, 0.01027486f, 0.15497568f, 0.04816132f, -0.06633939f, 0.06815143f, -0.05323449f, 
    -0.07505817f, 0.04675549f, -0.01272303f, -0.04686693f, -0.01286938f, -0.26600102f, -0.09574769f, 0.11698459f, 
    0.13224657f, 0.06399252f, 0.13512637f, 0.11856189f, -0.21166132f, -0.04596566f, 0.01853820f, 0.09888703f, 
    -0.20841458f, 0.06869540f, -0.10378076f, -0.02409831f, -0.15252793f, -0.25873691f, 0.14022985f, 0.01225223f, 
    0.08562440f, -0.02400829f, 0.06529623f, -0.00991669f, -0.12243301f, 0.07588335f, -0.08311137f, 0.05730123f, 
    -0.01810349f, 0.07735517f, 0.17207290f, 0.05016202f, 0.04008372f, 0.13478912f, -0.05895321f, -0.08123901f, 
    0.02273631f, -0.02595392f, 0.09980051f, 0.06460219f, 0.03408376f, 0.06665649f, 0.08660370f, -0.16794407f, 
    -0.01959934f, -0.03059765f, -0.05487857f, -0.05745937f, 0.02050755f, -0.09397053f, 0.12829560f, 0.18341140f, 
    -0.03117134f, 0.02793532f, 0.10608567f, 0.11143556f, -0.07176133f, -0.02867892f, 0.00825095f, -0.01153714f, 
    -0.06636123f, -0.09535214f, -0.02432008f, -0.05379374f, -0.25051194f, -0.21305837f, 0.14058250f, 0.28303242f, 
    0.11414505f, -0.06905115f, 0.08232765f, -0.04124335f, 0.11274664f, 0.11328783f, 0.06979580f, 0.05034412f, 
    0.21614039f, -0.22451617f, -0.30889273f, 0.08416410f, 0.04946150f, -0.10073805f, -0.09854184f, -0.09361470f, 
    -0.01522861f, -0.00953689f, -0.01870830f, -0.06993732f, 0.05082222f, 0.06550447f, 0.08556711f, -0.18079019f, 
    0.02201699f, -0.11787922f, -0.01454183f, -0.23865704f, 0.03249080f, -0.02931818f, -0.22881235f, 0.02822277f, 
    0.08406714f, -0.04779100f, 0.00236053f, -0.16035950f, 0.02800006f, 0.00820673f, -0.00486693f, 0.08903138f, 
    0.08623929f, 0.14046778f, 0.06226687f, 0.09359226f, -0.16025400f, 0.22672197f, 0.18861949f, -0.25453582f, 
    -0.03936781f, -0.02610509f, 0.11769523f, 0.21825789f, 0.04559977f, 0.09539313f, 0.12489138f, -0.22204654f, 
    -0.22338572f, -0.23019861f, 0.00852020f, 0.23178159f, -0.04642224f, -0.00339341f, -0.01761111f, -0.03594641f, 
    0.08356396f, -0.03539367f, -0.06281050f, 0.05216584f, -0.09370110f, -0.16233237f, 0.04660404f, 0.07389722f, 
    0.08187520f, 0.02116788f, 0.06059600f, 0.06219456f, 0.02314234f, 0.17606981f, 0.01762126f, 0.01237316f, 
    -0.69314510f, 0.00137938f, -0.17566372f, -0.07289728f, 0.06647298f, 0.12879273f, 0.01458348f, 0.03849169f, 
    -0.07120146f, 0.13708892f, 0.02451504f, -0.09874570f, 0.03414439f, -0.02071125f, 0.15345897f, -0.08651707f, 
    0.06322280f, 0.03481993f, 0.04632602f, -0.00007606f, -0.03345630f, -0.02706992f, 0.06036463f, 0.02294798f, 
    0.04383823f, 0.12203832f, 0.10717136f, -0.12694412f, 0.01763922f, -0.04795795f, 0.03340772f, -0.03063081f, 
    0.07668238f, 0.14510743f, -0.08892675f, 0.00774333f, -0.46800604f, 0.20600894f, -0.04597171f, 0.08812091f, 
    0.01011303f, -0.13140664f, 0.06448828f, -0.18463042f, 0.05773994f, 0.09277246f, -0.07969661f, 0.06330451f, 
    -0.14400582f, 0.04604653f, 0.04326554f, 0.04138886f, -0.04247227f, -0.07063165f, 0.04147240f, 0.14437628f, 
    0.10333005f, 0.06614898f, 0.00290547f, -0.11696644f, -0.11257570f, 0.12999307f, 0.02731960f, 0.17548987f, 
    0.02086371f, -0.00870063f, -0.14181091f, 0.07950226f, 0.07778078f, 0.17941856f, 0.13590707f, 0.07141195f, 
    0.01052163f, -0.05732450f, -0.16217662f, 0.04668440f, 0.02855978f, 0.01150103f, -0.08036732f, 0.05349872f, 
    0.01612937f, 0.06206395f, -0.18362413f, 0.01402578f, -0.41131637f, 0.06366479f, 0.42867780f, -0.28487486f, 
    -0.09436318f, -0.00654879f, 0.09749825f, -0.01610986f, -0.01539058f, 0.10189370f, 0.03476693f, -0.02608772f, 
    -0.07049630f, -0.20209068f, 0.05892141f, 0.22191255f, -0.00829369f, 0.04913613f, 0.18317604f, 0.06116727f, 
    0.10537921f, 0.10687148f, -0.14262496f, -0.18328562f, 0.03766579f, -0.11285564f, -0.06260625f, -0.00004818f, 
    0.08710776f, 0.00987139f, -0.02026949f, -0.11468679f, 0.00166060f, -0.01248838f, 0.13077873f, 0.07269735f, 
    0.21093909f, -0.02245405f, -0.04188853f, -0.13674882f, -0.08913038f, -0.01585104f, -0.09561358f, 0.02363377f, 
    -0.02346284f, -0.17837676f, -0.15716408f, -0.15699413f, 0.12106054f, 0.00109796f, -0.08365694f, -0.01422634f, 
    0.09805243f, -0.09245102f, -0.07862797f, -0.06704014f, -0.07390833f, -0.05927069f, -0.03385606f, 0.02260237f, 
    0.04752434f, -0.08415814f, -0.06064861f, -0.06626812f, -0.01122900f, 0.06636794f, 0.02435428f, -0.03570469f, 
    -0.02967441f, 0.03396701f, 0.00744761f, 0.04682590f, -0.42612013f, 0.07551385f, -0.26893756f, -0.14960477f, 
    0.02563308f, 0.06459709f, -0.02529545f, 0.04701408f, -0.01591796f, -0.01020214f, 0.05505730f, -0.17655791f, 
    0.01570333f, 0.03661924f, -0.05648990f, -0.01388216f, 0.15079901f, 0.06990977f, -0.02571326f, -0.06360473f, 
    0.11023388f, 0.08472943f, 0.07761688f, 0.17865419f, -0.11766624f, -0.11478433f, -0.01510634f, -0.05575231f, 
    0.06871205f, -0.01762366f, 0.01607236f, -0.00605726f, 0.03011310f, -0.04381968f, -0.14626889f, 0.08220014f, 
    -0.24573645f, -0.08171918f, 0.03900294f, 0.16851954f, -0.02779180f, -0.04713870f, 0.07397550f, 0.06080587f, 
    0.02060687f, 0.06837117f, -0.04084713f, 0.07323258f, 0.15376301f, 0.05044743f, -0.07881355f, 0.00852424f, 
    -0.02252486f, 0.00367942f, 0.07175300f, -0.24444753f, -0.11830310f, 0.07360849f, -0.14196475f, 0.07017070f, 
    0.10699802f, 0.08487301f, 0.08901503f, 0.06924669f, 0.05138366f, 0.03278172f, 0.03158842f, -0.04809422f, 
    0.12845124f, -0.10005261f, 0.06091925f, -0.01097741f, -0.17580526f, 0.10725010f, 0.04875071f, 0.29980245f, 
    0.13747133f, -0.00847187f, -0.00125308f, -0.04725512f, 0.00014163f, 0.08527993f, 0.03589961f, 0.14172021f, 
    0.16142067f, 0.03750853f, -0.30782717f, -0.12536907f, 0.08531237f, 0.00660916f, -0.00796842f, -0.08002033f, 
    -0.11746325f, -0.05700468f, -0.03801972f, -0.18042947f, 0.07284389f, -0.06492864f, 0.04262680f, -0.04336884f, 
    -0.06035782f, 0.02063070f, -0.08367338f, 0.13332742f, 0.18692636f, 0.00901861f, -0.05436033f, -0.09965122f, 
    -0.28863129f, -0.10602576f, -0.09530178f, -0.23951624f, 0.09902940f, -0.01317676f, 0.07329691f, -0.13655236f, 
    -0.00881642f, 0.13317788f, 0.01767454f, 0.05561926f, -0.31671542f, -0.25086501f, -0.21854892f, -0.04262752f, 
    0.11881195f, 0.09426137f, -0.11029170f, -0.05824960f, -0.00163020f, -0.01570016f, -0.05337757f, 0.11823074f, 
    -0.02334734f, -0.10797279f, 0.12788899f, 0.09648910f, 0.09001423f, 0.14790596f, 0.15191501f, 0.02313156f, 
    0.11749607f, -0.10182662f, -0.05096328f, -0.02160587f, -0.00131250f, 0.04504896f, 0.09584604f, 0.24012607f, 
    -0.18831135f, -0.01715136f, 0.07458758f, 0.04242400f, -0.03735372f, -0.14229590f, -0.01611453f, -0.03903196f, 
    0.25234619f, -0.07683002f, 0.23533347f, -0.06058745f, 0.10083979f, -0.06407145f, 0.15832566f, -0.02807537f, 
    0.06727459f, 0.01240154f, 0.05554615f, -0.08011898f, 0.32682028f, -0.35984290f, 0.15302606f, -0.03066285f, 
    0.01548746f, 0.01931900f, 0.01080451f, -0.01179249f, 0.05110724f, -0.07114839f, -0.04625754f, 0.00391129f, 
    -0.21423127f, 0.04793067f, 0.12741368f, -0.05828745f, 0.12275044f, -0.06260225f, 0.09107292f, 0.00103799f, 
    -0.01719933f, 0.05681687f, -0.12821913f, 0.06828154f, 0.17329672f, -0.04543162f, 0.01412805f, -0.12818633f, 
    -0.04433317f, -0.04286975f, 0.08795201f, 0.08649915f, 0.11311769f, -0.03426984f, -0.07986368f, 0.05375583f, 
    0.09655602f, -0.12344063f, -0.21100819f, 0.28337389f, -0.05761484f, 0.07181027f, 0.00544592f, 0.03085545f, 
    -0.06285094f, -0.03950657f, -0.12411660f, -0.07015628f, -0.20595090f, -0.08981853f, -0.03586300f, -0.19295545f, 
    -0.00337427f, 0.07954164f, 0.07886043f, 0.04249638f, -0.02255871f, -0.00780706f, -0.05773780f, 0.03163840f, 
    0.07389225f, 0.02138903f, 0.20340903f, 0.30903897f, -0.00984818f, -0.08673122f, 0.01448079f, -0.02241877f, 
    -0.03891676f, 0.02606871f, -0.07951950f, 0.01675230f, 0.03140084f, 0.13193654f, 0.02247501f, 0.12594697f, 
    -0.01426476f, -0.09479140f, -0.06007589f, -0.11344552f, -0.06952380f, 0.01224186f, -0.16494609f, 0.00290938f, 
    0.30732766f, -0.24781442f, 0.02623719f, 0.10778768f, -0.06031045f, -0.03432461f, -0.00372526f, -0.05275184f, 
    -0.04451330f, 0.01594162f, 0.09848621f, 0.02091412f, 0.16131268f, -0.14828730f, 0.10713402f, -0.12961240f, 
    0.01877356f, 0.02826928f, -0.07985301f, -0.02928386f, -0.08072219f, -0.01321575f, 0.02088896f, -0.00897946f, 
    -0.17991772f, -0.06255344f, 0.11183424f, -0.13149281f, -0.07284624f, 0.06401677f, -0.05110545f, 0.01125983f, 
    -0.11083216f, -0.03652322f, -0.12769385f, 0.10736495f, -0.57028699f, -0.05913942f, -0.11144657f, -0.11516245f, 
    0.00004492f, -0.04019370f, 0.04801373f, -0.10911872f, -0.01408539f, 0.00011402f, -0.01236819f, 0.07311121f, 
    -0.16467319f, 0.22090521f, -0.12229151f, 0.19139984f, -0.11103562f, 0.09868683f, -0.01943298f, 0.04830580f, 
    -0.00539898f, 0.04997244f, 0.04949564f, -0.03877778f, -0.26280257f, -0.22408247f, -0.16782986f, -0.06179234f, 
    -0.01186895f, 0.06175051f, -0.00246657f, -0.07392617f, 0.11145855f, 0.02261698f, -0.02418564f, -0.05940686f, 
    -0.19196406f, -0.01282686f, -0.15240973f, 0.05538698f, -0.06585115f, -0.05327793f, 0.04779264f, 0.03917236f, 
    -0.11353467f, -0.07617867f, 0.03511364f, 0.02284005f, 0.18699397f, 0.04951142f, -0.19025341f, -0.25254285f, 
    -0.05938760f, 0.02608833f, 0.01060401f, 0.05257078f, 0.05422017f, 0.10932220f, -0.01324377f, -0.11102019f, 
    0.11931427f, 0.06936042f, 0.07220711f, -0.11202762f, 0.11610931f, -0.05656070f, -0.02323641f, 0.00455079f, 
    -0.03509098f, -0.00602233f, 0.00455922f, -0.13837196f, 0.43183461f, -0.18010719f, 0.22922826f, -0.26460889f, 
    0.00413056f, 0.10411128f, 0.05653791f, 0.12368097f, 0.11200483f, 0.15256661f, 0.06432498f, 0.27488998f, 
    0.12237977f, -0.26037985f, -0.05357399f, 0.15354054f, -0.14611448f, -0.14869973f, 0.01759323f, -0.00600532f, 
    -0.09707025f, 0.13751799f, -0.07082159f, 0.19947581f, 0.09436692f, 0.02045301f, -0.14968348f, -0.03419617f, 
    -0.03310635f, 0.02018541f, 0.07691477f, -0.14501813f, 0.00219187f, -0.03110163f, 0.11377588f, -0.15523840f, 
    -0.25281656f, -0.03010975f, 0.10121720f, 0.22180577f, 0.06005759f, 0.01107069f, 0.03131107f, 0.03624658f, 
    0.02351912f, -0.07712304f, -0.05081439f, -0.06928291f, -0.16942470f, -0.02747924f, -0.05914805f, 0.13181925f, 
    0.04176945f, 0.02466651f, 0.05475286f, -0.05466850f, -0.12754872f, 0.05025885f, -0.16057010f, -0.13028279f, 
    0.18480739f, 0.13076583f, -0.06374162f, -0.32997319f, -0.05051661f, 0.00764822f, 0.01510586f, 0.02432540f, 
    -0.05977756f, 0.02127287f, 0.06640467f, -0.04379452f, -0.18728389f, 0.00756933f, 0.12182616f, -0.05958262f, 
    0.01263614f, 0.06862176f, -0.00481367f, 0.07790973f, -0.03042048f, 0.08793410f, -0.00603349f, -0.04323820f, 
    0.24437024f, 0.10823185f, 0.05555640f, -0.09183340f, -0.01660858f, 0.05770452f, 0.03335403f, 0.09129857f, 
    0.05618392f, -0.08552300f, -0.00462585f, -0.07054405f, -0.12572470f, -0.02903646f, 0.04447784f, -0.15468870f, 
    0.06809819f, 0.12750638f, 0.11074603f, -0.00024126f, 0.10971422f, 0.00447389f, 0.15739062f, -0.00563847f, 
    -0.05123840f, 0.07532048f, -0.02443352f, -0.30549639f, 0.13447143f, -0.01688424f, 0.06804726f, 0.09882793f, 
    0.02686277f, -0.03545719f, 0.12786327f, -0.09381444f, 0.05128708f, -0.06499893f, -0.18501376f, -0.10060443f, 
    -0.08383074f, -0.00465726f, -0.01715891f, -0.13400328f, -0.04765174f, 0.13260925f, 0.05820139f, 0.12359254f, 
    0.03487902f, 0.05213566f, 0.00851430f, -0.21495774f, -0.08959256f, -0.01921472f, 0.07672869f, 0.12939979f, 
    0.07764366f, 0.03228363f, -0.05125023f, 0.02708862f, -0.02039151f, 0.14356390f, 0.17934880f, 0.16978011f, 
    0.03238900f, 0.01864141f, 0.04967713f, 0.00694713f, -0.02993222f, 0.05114250f, 0.01991251f, -0.14975666f, 
    -0.07692103f, -0.01448727f, 0.01769255f, 0.00597839f, 0.11955104f, 0.01025735f, -0.03620862f, 0.00253300f, 
    0.02717028f, 0.06493181f, 0.04127154f, 0.02562547f, 0.15372930f, -0.07494382f, -0.20415549f, 0.14319874f, 
    -0.11036768f, 0.05769885f, -0.06814444f, -0.00939871f, -0.04256169f, -0.16480018f, 0.04935813f, -0.06216643f, 
    -0.21990485f, 0.09275751f, -0.10248323f, 0.30280292f, 0.08424029f, 0.02003213f, 0.09448844f, 0.00900528f, 
    -0.06550501f, 0.02794122f, 0.10164016f, -0.06192536f, -0.07753068f, -0.34767935f, -0.01260690f, 0.05763489f, 
    -0.02565960f, -0.05821515f, -0.00268742f, 0.12729543f, 0.13145682f, 0.04005297f, 0.11711187f, 0.06796994f, 
    0.24538076f, 0.09252267f, 0.02354142f, -0.20436423f, 0.00399901f, 0.06082853f, 0.07196075f, 0.08369269f, 
    -0.08417520f, -0.04587207f, 0.07784238f, -0.20143570f, 0.13223113f, -0.09426873f, -0.02334012f, 0.12107758f, 
    -0.03066844f, 0.00611596f, -0.06664551f, -0.18536487f, 0.01348507f, -0.03458982f, -0.05800430f, 0.10595042f, 
    0.07929381f, -0.20058984f, -0.03610507f, 0.04428361f, -0.00501191f, -0.00245054f, -0.07496815f, 0.06769580f, 
    -0.01246736f, 0.04332455f, 0.00211083f, -0.01150853f, 0.20935452f, -0.14745602f, -0.07910185f, -0.17642875f, 
    0.05465087f, 0.01871008f, -0.00155536f, 0.02837179f, -0.14279085f, -0.00345295f, -0.04896904f, -0.10542947f, 
    0.20687278f, 0.03651259f, 0.07113210f, -0.15308882f, 0.06288681f, -0.00091104f, 0.05767692f, -0.19242936f, 
    0.01096043f, 0.01605206f, 0.13200814f, 0.11753168f, 0.10905150f, 0.22343166f, 0.14166522f, -0.28890082f, 
    -0.09488864f, 0.02329785f, -0.02049732f, 0.06966902f, -0.07520812f, -0.03321844f, 0.02129228f, 0.04879998f, 
    -0.01598026f, 0.02649118f, 0.08471008f, -0.14247848f, -0.11931648f, -0.00862419f, -0.10834178f, 0.05182537f, 
    -0.08824641f, -0.05144811f, -0.05176933f, -0.00155896f, 0.13791886f, 0.03535202f, 0.21634157f, 0.07138497f, 
    -0.06979539f, 0.01761716f, 0.00435768f, 0.13447776f, -0.06407813f, -0.00303901f, -0.02073918f, -0.04005235f, 
    -0.13937896f, -0.06840341f, 0.03748193f, 0.12070905f, -0.00208303f, 0.00434095f, 0.05523664f, -0.06709868f, 
    -0.02740572f, 0.04112415f, 0.03572804f, 0.00011930f, -0.03959405f, -0.04983427f, -0.34693384f, -0.17900355f, 
    -0.16991708f, -0.02260988f, 0.00523701f, -0.01286940f, -0.17246418f, 0.02170157f, -0.23902403f, 0.08277393f, 
    -0.27457798f, 0.01368827f, -0.20022485f, 0.02865244f, 0.06610076f, -0.08406539f, -0.05635975f, 0.07472930f, 
    0.02395433f, -0.01332427f, 0.09178418f, -0.14541569f, 0.22109264f, -0.34226409f, 0.02408158f, 0.12180443f, 
    -0.01084085f, 0.14267741f, -0.08014077f, -0.06631819f, 0.02822726f, -0.12741424f, -0.07430035f, -0.04958591f, 
    0.05271249f, 0.08784033f, -0.18602587f, -0.05645955f, -0.18349896f, -0.04429794f, -0.06396801f, -0.10861076f, 
    -0.25992391f, 0.14959392f, 0.13553908f, 0.13074026f, -0.15647723f, 0.20373963f, -0.05593505f, 0.18244143f, 
    -0.11075560f, 0.11745674f, 0.07106061f, -0.01364598f, -0.04100019f, 0.13126957f, -0.12645754f, -0.10789230f, 
    -0.41740969f, 0.07281142f, 0.08406562f, 0.17510752f, 0.10228632f, 0.00008357f, -0.10866164f, 0.09226251f, 
    -0.03114368f, 0.05378302f, 0.14629436f, 0.13223223f, -0.29368761f, -0.04094689f, 0.04248537f, 0.21757230f, 
    0.07937788f, 0.06315607f, -0.05103434f, 0.03808560f, 0.12255242f, -0.00362796f, -0.06944630f, -0.11494809f, 
    0.11663363f, 0.05901025f, 0.12711810f, -0.07423377f, 0.01025079f, 0.08689055f, -0.00980895f, 0.10890377f, 
    0.10882012f, -0.03574802f, -0.14862245f, 0.07695569f, 0.19308937f, -0.25976634f, -0.02878091f, -0.13460323f, 
    -0.01557072f, 0.02400704f, 0.03847397f, -0.10397369f, -0.01071120f, -0.01712145f, -0.03901931f, 0.20381716f, 
    -0.13346118f, 0.20077729f, 0.19517258f, -0.25323695f, -0.02344812f, 0.07403832f, -0.02537433f, 0.03014142f, 
    -0.05906860f, 0.01272246f, -0.06809815f, -0.13787125f, 0.17599116f, -0.05673613f, 0.05922135f, -0.07378585f, 
    -0.02953791f, -0.02381233f, -0.07522970f, -0.00991716f, -0.06435645f, 0.06530230f, 0.01859657f, 0.04048111f, 
    0.19724694f, -0.17027336f, 0.01726819f, 0.04336593f, -0.01947288f, 0.06776980f, -0.07049637f, -0.10580175f, 
    -0.04187727f, -0.01202654f, 0.04427210f, -0.08273885f, -0.31685609f, -0.06455003f, -0.02084320f, 0.11231188f, 
    0.06870510f, 0.04447601f, -0.02143179f, -0.01517483f, 0.08383533f, -0.06605782f, 0.02496994f, -0.01438930f, 
    -0.13648435f, 0.12808697f, 0.09495378f, -0.01834489f, -0.02641788f, -0.04959569f, 0.08663636f, 0.01459782f, 
    0.04650461f, 0.07549358f, 0.00268999f, -0.01922998f, 0.17460196f, -0.18643740f, -0.21413223f, -0.10095929f, 
    0.00357250f, 0.00339146f, 0.05344386f, 0.03555957f, -0.20190303f, -0.19620879f, -0.02000354f, 0.05906121f, 
    0.00359585f, -0.03099853f, -0.04657004f, -0.13054214f, -0.06008850f, 0.10060390f, -0.04799624f, -0.03184042f, 
    0.02453178f, 0.07653005f, -0.00903721f, 0.23243800f, -0.12290236f, 0.17425264f, 0.01125307f, 0.04198124f, 
    -0.08549765f, -0.14015092f, -0.00884444f, 0.02607065f, -0.18193872f, -0.04863378f, 0.18419921f, 0.17207900f, 
    0.03740747f, 0.05563205f, 0.00662758f, -0.15479439f, -0.00497627f, 0.00776095f, 0.05755160f, 0.09345525f, 
    0.02210441f, -0.10014563f, 0.05202070f, -0.08152662f, -0.21521384f, -0.13199091f, -0.03711129f, -0.48984489f, 
    -0.04929654f, -0.04025103f, -0.03242682f, -0.15554246f, 0.04780020f, -0.02713517f, 0.08983228f, -0.02449629f, 
    -0.06888595f, -0.09982667f, -0.07496997f, -0.06296827f, -0.08567968f, -0.05382036f, 0.00418823f, -0.14746949f, 
    0.01446185f, 0.20645887f, -0.00265280f, -0.02208163f, -0.13499048f, 0.14417391f, -0.13360256f, 0.10018569f, 
    0.01207714f, -0.01602684f, -0.00889201f, 0.03823315f, -0.09828703f, 0.04104937f, -0.08651493f, -0.03759112f, 
    0.20589629f, -0.17880452f, 0.04415276f, -0.04040000f, 0.02399570f, -0.04568815f, -0.01249483f, -0.05012873f, 
    -0.04965803f, 0.01987270f, 0.02328399f, -0.00040875f, 0.18632695f, -0.10801271f, -0.14814067f, -0.16946013f, 
    0.06007886f, 0.01640204f, 0.01929915f, -0.00006469f, -0.07047872f, -0.00360371f, -0.07250469f, -0.02594207f, 
    0.10887931f, -0.20104969f, -0.14735359f, 0.07922938f, -0.04450805f, -0.03978118f, -0.04513895f, 0.00099912f, 
    -0.09256336f, -0.03692191f, 0.02103694f, -0.04712000f, -0.30272567f, -0.03507622f, -0.10954096f, -0.11409719f, 
    -0.02321336f, -0.02244295f, 0.05704566f, -0.10785638f, -0.10193627f, 0.04973391f, -0.05276819f, -0.05890884f, 
    -0.03627009f, 0.21442434f, 0.04854517f, 0.24177065f, 0.08341990f, -0.06736258f, -0.03527742f, 0.01683621f, 
    0.01033310f, 0.03959877f, -0.04838281f, -0.04437914f, 0.14377140f, 0.14912881f, 0.19958745f, 0.00722678f, 
    0.01063694f, -0.01820706f, -0.01935751f, -0.09306206f, -0.06569234f, 0.05434896f, -0.02976496f, -0.05104252f, 
    0.03769814f, -0.14553730f, -0.01889187f, 0.07113567f, -0.11048567f, -0.12729669f, -0.01716887f, -0.00475759f, 
    0.00326324f, 0.00867697f, 0.02725927f, -0.11359413f, -0.12164420f, -0.01825839f, 0.00979614f, -0.06231344f, 
    0.04597269f, -0.06421400f, -0.02379548f, -0.01785607f, -0.01329753f, 0.02233577f, -0.04040466f, 0.00604812f, 
    0.26135972f, 0.08896547f, 0.08881670f, 0.16253531f, 0.18081039f, 0.03866180f, 0.07464096f, 0.01376540f, 
    0.00485632f, -0.09202339f, -0.05134545f, -0.06313220f, -0.01674254f, 0.05494533f, -0.07971023f, -0.16648231f, 
    -0.02263125f, -0.00771742f, -0.01913555f, -0.04400321f, 0.02691827f, -0.05955286f, -0.10954656f, -0.03594667f, 
    -0.13603574f, 0.01670356f, 0.13514698f, 0.06401757f, 0.04096849f, 0.03940596f, 0.06865647f, -0.05451221f, 
    -0.03961314f, -0.04104112f, 0.06040340f, 0.03300578f, -0.10480286f, 0.12615111f, 0.05057108f, 0.18055864f, 
    0.17054571f, -0.08012059f, -0.00318511f, 0.00407746f, 0.07553667f, 0.00240455f, -0.00833866f, -0.09133185f, 
    0.01722130f, -0.03963613f, -0.22802927f, -0.15276043f, 0.04042313f, -0.05788382f, -0.00884226f, -0.01321764f, 
    -0.10790800f, 0.05639309f, 0.08274610f, -0.02803292f, -0.02211287f, 0.18978499f, 0.09865014f, 0.07202622f, 
    0.07156851f, 0.00319918f, 0.02391587f, -0.11472387f, 0.03002003f, 0.03021180f, 0.04125176f, -0.06794325f, 
    0.25885630f, 0.16098994f, 0.02081883f, 0.03256319f, 0.02429608f, 0.00603587f, 0.03313660f, 0.00180064f, 
    -0.07640547f, -0.13252398f, -0.00303560f, -0.05922046f, -0.32227021f, 0.15741248f, -0.03770929f, -0.02740518f, 
    -0.18728273f, -0.03432648f, -0.00247572f, -0.08534642f, -0.04954280f, -0.03643291f, 0.04440460f, -0.06025178f, 
    -0.07981936f, -0.16279715f, -0.05453541f, -0.10528566f, 0.00584502f, 0.03223483f, -0.02461231f, -0.07010157f, 
    -0.01224355f, 0.02610761f, -0.08040898f, -0.03857964f, 0.04017784f, 0.08980287f, 0.13489996f, 0.07411863f, 
    -0.03370659f, -0.01745863f, 0.00034835f, -0.03463575f, -0.07957527f, 0.02081975f, 0.06024787f, -0.02333635f, 
    0.05936122f, -0.08573775f, 0.03468309f, -0.00254590f, 0.05962265f, 0.00969118f, -0.01028065f, -0.08833139f, 
    -0.04746468f, 0.06774885f, -0.01763376f, 0.01198562f, 0.20282172f, 0.01431782f, 0.15307046f, 0.05984828f, 
    0.00247242f, 0.07023341f, 0.06281725f, 0.00885235f, -0.01066411f, -0.03563227f, -0.04276424f, -0.02819799f, 
    0.06524456f, -0.14642541f, 0.11482248f, 0.12381396f, 0.00296438f, 0.03528890f, -0.07785660f, -0.01457398f, 
    -0.03705398f, -0.05329627f, -0.03566664f, -0.00312170f, 0.04658540f, 0.11050916f, -0.00629308f, 0.07630492f, 
    -0.22369282f, -0.01076169f, 0.01140631f, -0.08920229f, -0.01136602f, -0.01758633f, -0.05186999f, -0.12856722f, 
    0.03595724f, -0.12884560f, -0.27206329f, -0.01518658f, -0.13294016f, -0.02335955f, -0.03364791f, -0.03432964f, 
    0.00689992f, -0.01111717f, 0.02507992f, 0.03421021f, -0.07787644f, 0.08401243f, 0.00644006f, -0.06468970f, 
    -0.03910912f, -0.00700224f, -0.04882068f, -0.03599559f, 0.01264707f, 0.05706660f, -0.09868186f, -0.03376199f, 
    0.06693655f, -0.13385825f, -0.05368548f, -0.03308210f, -0.00603378f, -0.01164337f, 0.03493986f, -0.02671245f, 
    0.02898668f, -0.09525528f, -0.06385197f, -0.04246433f, 0.25562096f, 0.05567843f, 0.08923905f, 0.04998693f, 
    -0.04294153f, -0.04738449f, -0.03935872f, -0.01993178f, 0.00056707f, 0.06690289f, 0.04515766f, -0.10040556f, 
    0.05888896f, -0.09335819f, -0.03463600f, 0.05291401f, -0.02818635f, -0.12272836f, -0.05018295f, -0.10376966f, 
    -0.10344432f, 0.00552544f, 0.08287754f, 0.05514767f, 0.06684598f, 0.19613472f, -0.00537787f, 0.17005867f, 
    0.09216616f, -0.01132973f, -0.01191200f, -0.03024657f, 0.00110591f, -0.05921499f, 0.01273580f, -0.07260645f, 
    -0.11968941f, 0.13849396f, -0.02200540f, -0.16245824f, -0.04089314f, 0.02931392f, -0.02538712f, -0.04852130f, 
    -0.03948115f, 0.02840338f, -0.01297318f, -0.02907807f, -0.20988132f, -0.08535813f, -0.04375663f, 0.03047408f, 
    -0.04635689f, -0.05495067f, 0.00215218f, 0.11677587f, -0.07198800f, 0.00706450f, -0.03117753f, -0.07062403f, 
    -0.01016467f, -0.19563685f, -0.05394258f, 0.04188686f, -0.08602436f, -0.05437608f, -0.06463057f, -0.06612338f, 
    -0.09962434f, -0.06114532f, -0.02211466f, 0.04450557f, 0.11106100f, 0.07840359f, -0.03599059f, 0.14314382f, 
    -0.01395416f, -0.08715744f, -0.03966597f, 0.02188319f, -0.04858572f, 0.00382863f, -0.04367804f, -0.01992925f, 
    -0.10206369f, 0.20253246f, -0.23248707f, 0.12859529f, -0.06810137f, -0.00412257f, 0.03261826f, -0.03343664f, 
    -0.00054354f, -0.05097464f, 0.03944556f, -0.00496023f, -0.07000626f, -0.07086366f, -0.00307678f, 0.03680731f, 
    -0.06583609f, 0.05719212f, -0.02766784f, -0.02624227f, 0.05806093f, 0.01205116f, -0.00301305f, -0.01387549f, 
    0.15536417f, -0.19686958f, -0.10677382f, -0.01115143f, 0.02340523f, 0.01398703f, -0.05156917f, -0.10249777f, 
    -0.01325256f, -0.03255073f, -0.01960456f, -0.10960671f, -0.01989478f, -0.20378761f, 0.00492660f, -0.07804564f, 
    -0.03730061f, -0.02588653f, -0.04575038f, 0.08667824f, -0.00870621f, 0.00003590f, 0.03016284f, 0.03414822f, 
    0.05639262f, -0.06356541f, -0.05868796f, 0.11352193f, 0.01510580f, -0.04607271f, -0.00766554f, -0.02331937f, 
    -0.11853826f, -0.01884029f, -0.04541476f, -0.06780257f, 0.25749320f, -0.05016541f, 0.06554002f, 0.13369535f, 
    0.08791443f, 0.01389458f, -0.02763473f, -0.00437672f, -0.08426766f, -0.10360182f, 0.02510551f, -0.06853002f, 
    0.05027313f, 0.10947976f, 0.20110591f, 0.07076254f, 0.06378233f, 0.07695123f, 0.04863605f, 0.02531915f, 
    -0.07612155f, -0.00798596f, -0.03059512f, 0.02659411f, -0.11597009f, -0.02429361f, -0.17698996f, -0.09920210f, 
    0.00618018f, -0.01404364f, 0.01769563f, -0.06199754f, -0.08946693f, -0.05674253f, -0.01978105f, -0.07709087f, 
    -0.06717387f, 0.00917938f, -0.04742530f, -0.12138486f, -0.04339378f, -0.03701659f, -0.01790588f, -0.07758500f, 
    0.02511724f, -0.00039439f, 0.00169706f, 0.02096801f, -0.27587616f, -0.12686019f, -0.08476611f, -0.05052614f, 
    -0.07064962f, 0.00280091f, -0.08809803f, -0.04761321f, -0.07267926f, 0.03987773f, -0.06871672f, -0.04228207f, 
    0.13495506f, 0.00303574f, 0.07991122f, -0.01176157f, 0.03281472f, -0.05972118f, 0.01342628f, -0.01950508f, 
    -0.04454209f, -0.09575486f, 0.02757432f, -0.04662661f, 0.19063942f, 0.06398647f, 0.08219269f, 0.12065667f, 
    0.06045769f, -0.06537130f, -0.00628358f, -0.00110931f, -0.00438577f, 0.03628262f, -0.05582077f, -0.11041944f, 
    -0.33909756f, 0.13480563f, -0.09737147f, -0.00091477f, -0.03986459f, 0.02558680f, -0.04180464f, -0.06613468f, 
    0.01030168f, 0.04890493f, 0.03524928f, -0.07629839f, -0.45458150f, 0.15994385f, 0.22660585f, -0.15627886f, 
    0.03242782f, -0.07429755f, 0.05122444f, -0.06321517f, 0.00806293f, 0.02087332f, 0.05779321f, -0.11117685f, 
    -0.05575295f, 0.10695919f, 0.03340603f, 0.19504334f, 0.04227682f, 0.00458192f, 0.00839435f, -0.00280943f, 
    -0.00440787f, 0.01869340f, 0.04888530f, 0.04554994f, -0.19281796f, 0.17672312f, -0.18887736f, -0.04599881f, 
    0.11091989f, 0.01027328f, -0.02311764f, 0.05681134f, 0.05364066f, 0.06429844f, 0.04410456f, 0.04009432f, 
    -0.24244604f, -0.00931280f, -0.23637787f, -0.11463814f, -0.08509383f, 0.01743523f, -0.00249022f, 0.00025328f, 
    -0.04418831f, -0.04665136f, 0.00502416f, -0.02478062f, 0.13917395f, -0.08821108f, 0.02425231f, 0.02391865f, 
    0.08289175f, -0.01762720f, 0.04603495f, -0.01550540f, -0.06331231f, -0.06342509f, -0.05900443f, 0.01412176f, 
    -0.27548775f, 0.04027013f, -0.08476159f, 0.08323517f, -0.10514044f, 0.01869674f, 0.05996368f, -0.09562547f, 
    -0.07801405f, -0.01261060f, 0.04321216f, -0.03347162f, 0.08310617f, -0.03726313f, 0.15179418f, 0.00207827f, 
    0.01363824f, 0.10292475f, 0.04047944f, 0.04243819f, -0.05744114f, 0.07855129f, -0.08269482f, -0.07386359f, 
    -0.07114964f, -0.12955008f, -0.15625861f, -0.06961197f, -0.07873027f, -0.08686046f, -0.03313604f, -0.04746341f, 
    0.02104067f, -0.02127307f, 0.02617123f, 0.00669876f, -0.00270241f, 0.09172434f, 0.07051947f, 0.09145653f, 
    0.09722226f, 0.02541616f, 0.00528077f, 0.00400517f, -0.04830062f, -0.05008405f, 0.00002122f, -0.06091453f, 
    0.18087761f, -0.23441178f, 0.03778898f, 0.09453619f, 0.05949590f, 0.06496793f, 0.02684760f, -0.06663290f, 
    -0.03324870f, 0.01788651f, 0.03284932f, -0.00017669f, -0.01790934f, 0.03868631f, -0.10422230f, 0.02847903f, 
    -0.09978898f, -0.02429995f, -0.01957994f, -0.01071214f, 0.02368405f, -0.04069468f, -0.00515850f, -0.07978505f, 
    -0.31156796f, 0.04030754f, 0.02123266f, -0.17474590f, -0.11234142f, -0.05740810f, -0.00364522f, -0.02530403f, 
    -0.05336729f, 0.00407020f, -0.08137663f, -0.00876103f, 0.14024842f, -0.08052320f, 0.15522742f, 0.14033659f, 
    -0.06178274f, 0.00476467f, -0.06896229f, -0.00547768f, -0.07331636f, -0.02226663f, -0.05720415f, -0.01365761f, 
    0.00777867f, 0.22267546f, 0.05482117f, 0.11316601f, 0.05048888f, 0.07236409f, 0.05152172f, 0.01435539f, 
    0.01531073f, 0.00321820f, 0.03507366f, -0.00245775f, -0.00295568f, -0.14049172f, -0.13991855f, -0.18803068f, 
    0.02315078f, -0.03867342f, -0.02362014f, -0.09713586f, -0.02778728f, -0.09033374f, 0.02248804f, -0.04294034f, 
    0.10778550f, -0.01487769f, 0.12176628f, -0.01939572f, -0.01390437f, 0.01033153f, -0.06949928f, -0.01448062f, 
    0.04407494f, 0.02945354f, -0.02166861f, -0.04574527f, 0.15492105f, 0.21867892f, 0.15471594f, 0.08300138f, 
    0.04768183f, 0.05264503f, 0.04196730f, -0.04243066f, -0.03596724f, 0.12906371f, -0.00187662f, -0.10674246f, 
    0.07504884f, 0.12369037f, 0.09401291f, 0.10010798f, 0.00421419f, -0.03897871f, -0.00474418f, -0.00335279f, 
    0.03009905f, -0.06137213f, 0.05362415f, -0.02114494f, -0.10814588f, -0.23656745f, 0.04020178f, 0.11972786f, 
    -0.06720100f, -0.03849014f, -0.07528348f, -0.02919169f, -0.11462131f, 0.02508377f, 0.06239460f, -0.05193093f, 
    0.07778950f, -0.23345278f, -0.08112716f, -0.00281808f, -0.05511761f, -0.06303912f, -0.00095130f, -0.05975885f, 
    -0.03392463f, 0.06635058f, -0.02301383f, -0.01708711f, 0.04787587f, -0.12522195f, 0.16246593f, -0.01670150f, 
    -0.00039197f, -0.07491574f, 0.09028573f, -0.11398143f, 0.00029587f, 0.01578819f, 0.06402753f, -0.17590286f, 
    0.10924225f, -0.18135016f, -0.12584597f, -0.05276259f, 0.07489631f, 0.00093791f, 0.03179006f, -0.00973073f, 
    0.00861149f, 0.00539128f, -0.00578615f, 0.08215991f, 0.00543045f, -0.15206845f, 0.08793521f, 0.01347009f, 
    0.04526537f, 0.01178508f, 0.00220820f, 0.01904855f, 0.03482633f, -0.07125665f, 0.13121417f, -0.03382261f, 
    0.09973593f, 0.28792143f, -0.16606142f, -0.10066976f, 0.01682753f, -0.14657040f, -0.04310454f, -0.04098821f, 
    0.00378795f, -0.06138348f, 0.02191668f, 0.12837233f, -0.09353106f, 0.04159165f, 0.15603091f, -0.02215459f, 
    -0.11789292f, -0.00676480f, -0.11068563f, 0.02108282f, 0.03746530f, -0.01664218f, 0.01774786f, -0.04046262f, 
    0.13041715f, -0.13503213f, -0.05020753f, -0.00730304f, 0.01082498f, -0.09880240f, -0.02936320f, -0.04918155f, 
    0.02161291f, -0.01502219f, -0.05139463f, 0.07761267f, 0.02690719f, -0.14271632f, -0.10123981f, -0.06232875f, 
    0.06857644f, 0.06165515f, -0.06820576f, -0.01866375f, 0.12990397f, 0.03036440f, 0.05110338f, -0.10777181f, 
    0.09848082f, -0.19361264f, -0.02539652f, -0.10484582f, -0.04429411f, -0.04650260f, 0.08546023f, 0.05251767f, 
    0.02099265f, -0.00311499f, -0.02279990f, -0.11510142f, 0.18116042f, -0.02666425f, 0.03671702f, 0.00130309f, 
    0.03145573f, -0.04491424f, -0.00940519f, -0.01406896f, -0.09473307f, -0.02277447f, 0.00577870f, -0.02884026f, 
    -0.05242080f, 0.02926180f, 0.08705755f, -0.01523738f, -0.04034229f, 0.02630013f, -0.07467073f, 0.07524496f, 
    -0.00131880f, 0.02084722f, -0.00167656f, -0.24629292f, -0.10117698f, 0.12887642f, 0.02442317f, 0.13702820f, 
    -0.09715874f, 0.00262101f, -0.20983946f, -0.05935479f, 0.01407376f, -0.06013358f, 0.09223733f, -0.05806287f, 
    0.08877076f, -0.01778266f, -0.23000669f, 0.05340590f, 0.03658809f, 0.01111747f, 0.00147393f, -0.02860407f, 
    0.06144762f, 0.04163399f, -0.02187906f, -0.02855174f, -0.01927832f, 0.11357512f, 0.12165231f, 0.17439146f, 
    -0.06780262f, 0.00033945f, -0.16377915f, 0.03872347f, -0.05636227f, 0.04540225f, -0.00653153f, 0.04184211f, 
    -0.05796194f, 0.06490396f, 0.00124783f, -0.09683106f, -0.11186469f, -0.01222126f, 0.01189318f, 0.08496461f, 
    0.04201422f, 0.05360858f, 0.03770686f, -0.02385318f, -0.09877427f, -0.06120291f, 0.00281051f, 0.05953183f, 
    -0.02599124f, 0.04239966f, 0.07224011f, -0.08799236f, -0.03044777f, -0.04868276f, 0.12027605f, 0.12260498f, 
    0.08162125f, -0.07270811f, 0.00762476f, 0.06378876f, 0.04718272f, -0.13214038f, -0.00620458f, 0.04163756f, 
    0.03946349f, 0.00379065f, -0.02124654f, 0.00649507f, 0.11579618f, -0.19714761f, 0.02872592f, -0.05812035f, 
    -0.03333649f, -0.17774278f, -0.07842905f, -0.04365729f, -0.00971660f, -0.03448321f, -0.03009207f, -0.08975906f, 
    0.08443981f, -0.01265908f, -0.04797748f, 0.07253350f, -0.02107899f, 0.02250666f, -0.04147556f, -0.11573061f, 
    0.02690432f, -0.04567625f, -0.00690630f, -0.18759035f, 0.04197328f, -0.09429826f, -0.02567796f, -0.11193354f, 
    0.06687628f, 0.04023515f, 0.03902972f, -0.05115197f, -0.00181877f, 0.06591749f, -0.02435600f, 0.03749470f, 
    0.18541792f, 0.15359777f, -0.06054313f, 0.16595587f, 0.06093687f, -0.04663148f, -0.05531517f, -0.06449869f, 
    -0.00737756f, 0.06701568f, 0.00205401f, -0.04524341f, 0.16854228f, 0.14171849f, -0.01841577f, -0.05517637f, 
    0.01515604f, -0.03953789f, -0.06367239f, 0.02015948f, 0.00066606f, 0.04363278f, 0.12206578f, 0.06481372f, 
    -0.11017168f, -0.08974083f, -0.08076737f, 0.15486984f, 0.07236571f, 0.02915343f, 0.08626090f, -0.01232343f, 
    0.06036100f, 0.07860821f, 0.02648475f, 0.10297459f, 0.21903248f, 0.11509693f, -0.04171665f, 0.11481058f, 
    0.05244119f, -0.01113320f, -0.06588738f, -0.05697347f, 0.01720376f, -0.07097222f, 0.01240427f, -0.12313234f, 
    0.13078059f, 0.04958282f, -0.00932010f, 0.18189350f, 0.11744905f, -0.01912306f, -0.09867636f, 0.03779558f, 
    0.05564939f, 0.09954036f, 0.09758923f, 0.05552617f, -0.33009395f, -0.04547167f, 0.06919622f, -0.26648670f, 
    -0.11142166f, -0.02211120f, -0.01429758f, 0.08491132f, 0.07957201f, -0.08079422f, 0.07365261f, 0.10391331f, 
    -0.23517336f, -0.26820445f, 0.02579662f, -0.22033468f, -0.02674372f, -0.02170337f, 0.04133997f, 0.00973062f, 
    0.13643655f, 0.06569964f, -0.10996038f, -0.12889531f, -0.11519921f, 0.04163712f, 0.01163437f, -0.09396757f, 
    0.01976738f, -0.00552312f, -0.07089321f, 0.03742886f, -0.00529207f, 0.03186120f, -0.00168513f, 0.03773440f, 
    0.05964777f, -0.04984000f, 0.02455931f, 0.15802942f, 0.03531433f, -0.00714923f, -0.10821901f, -0.02658384f, 
    0.05797190f, -0.12962224f, 0.12716305f, -0.06130651f, 0.09291658f, -0.13131726f, -0.16385913f, -0.10340417f, 
    0.07065500f, -0.14802109f, -0.12114065f, -0.01399604f, 0.02585766f, -0.01673788f, 0.06455246f, 0.08899442f, 
    0.00679501f, -0.02186424f, -0.17092955f, -0.00102167f, 0.04700694f, -0.02392380f, 0.03606627f, -0.05995423f, 
    -0.02023540f, 0.02026829f, -0.02519332f, 0.05310177f, 0.07570067f, 0.17148986f, -0.16425893f, -0.14025974f, 
    0.01988443f, -0.08847905f, -0.18475454f, 0.03210267f, 0.07471175f, 0.08946800f, 0.08025340f, -0.13584700f, 
    0.21007760f, 0.24397272f, -0.24069223f, -0.05404230f, 0.02376384f, 0.11297860f, -0.14573291f, 0.02786837f, 
    0.04097673f, -0.06641955f, -0.02510428f, -0.11262257f, 0.05677474f, 0.11734311f, 0.02486312f, 0.13157710f, 
    -0.04033012f, -0.11227561f, 0.10334355f, -0.24128421f, -0.09753600f, 0.07589185f, -0.10618524f, 0.06371111f, 
    -0.00311008f, -0.31594524f, -0.02266231f, -0.15154649f, -0.02416852f, -0.16271183f, -0.00612568f, 0.05574009f, 
    0.04654614f, 0.06516779f, -0.09262589f, 0.04425345f, 0.13232984f, 0.07041302f, -0.02183606f, -0.00089088f, 
    -0.08836380f, -0.10666760f, 0.05736626f, -0.05051123f, -0.04365665f, 0.00831290f, 0.03712467f, -0.06269412f, 
    0.11211566f, -0.01982369f, 0.07316929f, -0.07536280f, -0.10236881f, -0.09160497f, -0.03801651f, -0.06175645f, 
    0.03696074f, 0.02200205f, -0.01193201f, 0.06060343f, -0.11068743f, -0.12679125f, -0.08840673f, -0.26866305f, 
    0.05290265f, -0.16423364f, 0.06222883f, -0.04516979f, 0.08348408f, 0.09405239f, -0.01101194f, -0.02824020f, 
    0.00356016f, -0.20095016f, 0.09798849f, -0.17695864f, 0.04862562f, -0.08730441f, -0.02914059f, -0.09084948f, 
    -0.00659773f, -0.07256193f, -0.02257962f, -0.20381580f, -0.00653767f, -0.18613951f, -0.02337272f, 0.16626029f, 
    0.09818186f, 0.00670959f, -0.03793687f, -0.06420076f, -0.01767053f, 0.01963313f, 0.04683622f, -0.03568275f, 
    0.19918625f, 0.03717025f, -0.00172886f, 0.19995019f, 0.10693672f, -0.08480966f, -0.01969264f, -0.08764079f, 
    -0.01984326f, 0.05844151f, -0.02521299f, 0.04092405f, -0.08997247f, 0.09887370f, -0.04917984f, 0.01357565f, 
    -0.17561121f, -0.10821317f, -0.03386469f, -0.09898327f, 0.06069784f, -0.03277923f, -0.01205932f, 0.12128687f, 
    0.09440350f, -0.00154722f, -0.16864699f, -0.05003737f, -0.04540223f, -0.01714814f, 0.06913687f, -0.10101184f, 
    -0.03131721f, 0.00168642f, 0.05228635f, 0.04995514f, -0.24101745f, -0.04425598f, -0.07403914f, -0.18573424f, 
    0.07976862f, -0.11376503f, 0.08343185f, -0.07257443f, -0.00696308f, 0.01403489f, 0.03862406f, 0.01548760f, 
    -0.10885330f, 0.23461792f, 0.05529722f, 0.04435790f, 0.00862629f, 0.00655139f, 0.01745815f, 0.03960834f, 
    0.03589876f, 0.05066698f, -0.05328086f, 0.01744053f, 0.04954391f, -0.32474652f, 0.08776049f, 0.06083069f, 
    -0.06370477f, -0.09787889f, -0.05754593f, -0.13927589f, 0.04367151f, 0.01720159f, -0.04838820f, -0.05050634f, 
    -0.12881190f, 0.12696335f, 0.04801321f, -0.01243413f, 0.12749869f, -0.08584856f, 0.08057974f, 0.05558352f, 
    0.01854894f, -0.03173826f, -0.06039333f, 0.06432876f, 0.08585317f, 0.05926689f, -0.15908484f, 0.09095053f, 
    0.05644949f, 0.00947309f, -0.03388345f, -0.00572231f, 0.06958465f, -0.09647404f, 0.07119055f, -0.00262163f, 
    0.02890702f, -0.02196993f, -0.13559042f, 0.02360164f, 0.00802191f, 0.00943915f, -0.05702263f, -0.01408547f, 
    0.06412958f, -0.07796192f, 0.04634997f, 0.10442206f, 0.02893560f, -0.04093619f, -0.06023428f, -0.26155344f, 
    -0.00929269f, 0.08857663f, 0.02751048f, -0.06890135f, -0.03065953f, -0.04381588f, 0.03010290f, 0.03645932f, 
    -0.12538846f, -0.04312240f, -0.07106299f, 0.10678680f, 0.09581444f, -0.00806306f, -0.05803826f, -0.02114576f, 
    0.04292855f, 0.05024617f, 0.07590980f, 0.02560783f, -0.19002175f, 0.01833187f, 0.08757329f, 0.07848055f, 
    -0.06821222f, -0.03714043f, -0.07582636f, 0.05923252f, -0.00800225f, -0.09304041f, -0.01797660f, 0.01728099f, 
    -0.04081581f, -0.28028128f, -0.00298128f, 0.25024959f, 0.04529689f, 0.10784365f, -0.02396538f, -0.07869440f, 
    -0.04879369f, 0.05808094f, 0.06965242f, 0.07204417f, -0.21447293f, -0.21732636f, 0.01685230f, -0.14612418f, 
    -0.00867240f, -0.14521155f, -0.04346719f, -0.03841169f, 0.05023360f, -0.00737844f, -0.03557834f, 0.01879589f, 
    0.06811361f, -0.16299246f, 0.07370448f, -0.16373532f, 0.10798408f, 0.06229889f, 0.04904038f, -0.10016333f, 
    0.06020992f, 0.02373481f, 0.02059129f, 0.06470495f, 0.07691700f, 0.10170623f, -0.03356594f, 0.09119481f, 
    0.03411898f, 0.02762624f, -0.08832002f, 0.01299253f, 0.01388923f, 0.03054815f, -0.00005221f, -0.00203273f, 
    0.14312291f, -0.00427671f, -0.05126826f, 0.15849945f, 0.10800715f, 0.02225517f, -0.06555385f, -0.06179548f, 
    0.02976042f, -0.01224482f, 0.04253761f, 0.00994689f, 0.14508700f, -0.13522644f, -0.22923364f, -0.18762258f, 
    0.04689717f, 0.00917552f, 0.01177804f, 0.04537239f, 0.01486216f, -0.05097182f, -0.01687367f, 0.04986916f, 
    -0.00203177f, -0.00620427f, 0.15041257f, 0.03975034f, -0.03900292f, -0.01248500f, 0.00029928f, 0.01900500f, 
    -0.06351253f, 0.02340155f, -0.07969540f, -0.07528469f, 0.12433774f, -0.04261873f, -0.05221658f, 0.04078494f, 
    0.09104823f, -0.01695035f, 0.00007480f, -0.00353982f, 0.00527474f, -0.01219739f, -0.08352266f, -0.16925068f, 
    -0.20874415f, -0.13489111f, 0.20439602f, -0.13577905f, -0.06838387f, -0.02479510f, -0.02034243f, -0.04928965f, 
    -0.01131751f, 0.07995912f, -0.06151013f, 0.04751403f, -0.28460565f, -0.07610451f, 0.23361267f, 0.01764712f, 
    -0.02420748f, -0.11139010f, -0.00181383f, 0.07110581f, 0.00555738f, -0.10700338f, -0.06893860f, 0.08652504f, 
    -0.08161466f, 0.07315561f, -0.02251901f, -0.17405057f, -0.02121125f, 0.04365963f, 0.01470990f, -0.19807753f, 
    -0.00953084f, 0.02549913f, -0.15088533f, -0.00293471f, -0.04498051f, -0.01965751f, -0.28961182f, -0.14309889f, 
    0.10091902f, 0.07557806f, -0.00698526f, -0.06217901f, 0.06950205f, -0.00502026f, -0.05011062f, -0.01422112f, 
    0.11799434f, 0.03606405f, 0.08867291f, 0.14275640f, -0.05834036f, 0.05810275f, -0.05648586f, 0.00317799f, 
    0.06732237f, 0.10426603f, 0.03070026f, 0.14704897f, 0.14347894f, 0.08037961f, -0.03043369f, -0.16933738f, 
    0.00873890f, 0.04945009f, -0.05593234f, -0.04689248f, -0.00577644f, 0.13652200f, -0.06816193f, 0.11159870f, 
    0.13273579f, -0.02253379f, 0.13625933f, -0.14342479f, -0.00944848f, 0.06962529f, -0.09180148f, -0.02168705f, 
    -0.14328378f, 0.00507358f, 0.06585714f, -0.00158560f, -0.11237011f, 0.34435439f, -0.04682479f, -0.21677557f, 
    0.07818895f, -0.06166233f, -0.05312125f, 0.04315478f, 0.03512410f, 0.09733807f, -0.07512400f, 0.00869195f, 
    -0.25258759f, -0.10166150f, 0.31768161f, -0.22528104f, -0.05198584f, -0.03042928f, -0.07540798f, 0.02703042f, 
    -0.05238759f, -0.11750049f, -0.01187660f, -0.01509894f, -0.09223133f, -0.37244970f, 0.01335148f, -0.07353814f, 
    0.01151578f, 0.00205901f, -0.16687913f, -0.06603983f, -0.08302475f, -0.01115517f, -0.08076233f, -0.04254008f, 
    -0.08147153f, 0.17259465f, 0.10659787f, -0.00275289f, -0.07853651f, 0.15339224f, 0.04760687f, -0.08243597f, 
    -0.07454729f, -0.05318518f, 0.05184472f, -0.24153109f, -0.04520070f, -0.36517012f, 0.12047994f, 0.03114259f, 
    -0.02346184f, 0.13239413f, 0.09352475f, 0.01396541f, 0.06615826f, -0.02950495f, -0.03708833f, -0.04846212f, 
    -0.01499918f, -0.15233357f, 0.15569076f, -0.09527569f, 0.01235577f, 0.00684871f, 0.05540961f, -0.11207809f, 
    0.06127885f, 0.00685165f, 0.02880537f, 0.12806809f, -0.32805878f, -0.03279904f, 0.06725536f, -0.07191297f, 
    0.00484730f, -0.06070954f, 0.00787755f, -0.04939649f, 0.00478388f, -0.09275553f, 0.04432422f, 0.18703680f, 
    -0.08818284f, -0.26358849f, 0.15711744f, -0.15583934f, -0.05687170f, -0.08556616f, 0.13855232f, 0.13011304f, 
    0.06571700f, 0.14212210f, 0.05780943f, 0.09309615f, -0.03494748f, -0.51377803f, -0.06256777f, -0.05426056f, 
    -0.21678831f, -0.08418941f, -0.00797903f, 0.19598794f, -0.12969711f, 0.12828259f, 0.13723044f, 0.03746587f, 
    -0.03836768f, 0.22230320f, 0.07786870f, -0.08237086f, 0.04540572f, 0.16113758f, -0.05767621f, -0.01153378f, 
    -0.08709993f, 0.01117199f, -0.01636166f, -0.02129306f, -0.14961697f, -0.24776539f, 0.05849814f, -0.02008865f, 
    -0.01218102f, -0.00722503f, -0.02547171f, 0.13061920f, -0.03716489f, -0.06151987f, -0.07953137f, -0.02098140f, 
    0.37704450f, 0.01655769f, 0.10907111f, -0.12722656f, -0.00006052f, -0.05713214f, -0.03869659f, 0.13317150f, 
    -0.07463749f, -0.06043563f, 0.02469514f, -0.02578357f, -0.08926276f, 0.23511106f, -0.12837280f, -0.05453930f, 
    0.04827334f, -0.01857530f, -0.01844173f, 0.11488292f, 0.02765255f, 0.04992839f, 0.04780283f, 0.02643712f, 
    0.16075808f, 0.04338643f, -0.05161786f, -0.08562389f, 0.00203133f, 0.14150056f, -0.00062894f, -0.02967124f, 
    -0.07323845f, -0.08782642f, -0.03087215f, 0.04713340f, 0.01375570f, 0.08108813f, 0.03428160f, 0.07299115f, 
    -0.02528352f, 0.00556721f, 0.02370537f, -0.04773864f, 0.01321675f, -0.00814208f, -0.05375551f, 0.08860714f, 
    0.35819557f, -0.14171231f, 0.03760128f, -0.14099605f, 0.11086362f, 0.01418058f, -0.15646969f, -0.09175182f, 
    -0.04913797f, -0.00994909f, 0.12917775f, 0.03746184f, -0.05350125f, -0.15120265f, -0.08476830f, 0.11404558f, 
    -0.05775777f, -0.07170455f, 0.12591457f, -0.03378228f, -0.03327771f, 0.02073381f, -0.06487831f, -0.01928979f, 
    0.40059265f, -0.56316489f, 0.16542697f, 0.00862061f, 0.10023409f, 0.01250844f, -0.02428510f, 0.04151682f, 
    0.02830997f, 0.00788390f, 0.09597855f, -0.17266053f, 0.29614064f, 0.14165354f, 0.11777055f, -0.11099523f, 
    -0.03753860f, -0.12044889f, -0.00960959f, 0.07416596f, 0.08384666f, 0.00351153f, -0.02943688f, 0.02728345f, 
    -0.09453637f, 0.21250775f, -0.08908347f, -0.31474158f, 0.00964974f, -0.02554619f, 0.00266848f, -0.03660278f, 
    -0.05780352f, 0.02361923f, -0.02114134f, -0.02058838f, -0.09062363f, 0.09594823f, -0.23183851f, -0.12422250f, 
    0.09457238f, 0.00957821f, -0.05967727f, -0.08486252f, -0.01667328f, 0.03851263f, 0.00814386f, -0.10289434f, 
    0.04087310f, -0.06918542f, -0.13741259f, -0.19743097f, -0.08381011f, 0.01937023f, -0.07198640f, 0.12225502f, 
    0.05155503f, -0.02707336f, -0.03995205f, -0.01528110f, -0.02234380f, 0.01263134f, -0.16452779f, 0.11338269f, 
    0.02736153f, -0.05892460f, 0.12238997f, 0.10873427f, -0.02333825f, 0.05652222f, -0.06701539f, 0.10022036f, 
    0.05504278f, -0.03472574f, -0.05625171f, -0.28262281f, -0.05597918f, -0.02727192f, 0.11426261f, -0.15893961f, 
    -0.08952292f, -0.05881827f, 0.04901894f, -0.00233722f, -0.16044012f, -0.17284985f, -0.09597209f, 0.26171938f, 
    -0.00545947f, -0.00300682f, 0.03552242f, 0.16670607f, 0.03108325f, -0.06838728f, 0.02918107f, -0.03412747f, 
    -0.24671781f, 0.23268038f, -0.20377307f, -0.03927639f, 0.14488028f, -0.08836498f, -0.02008892f, -0.10129406f, 
    -0.06622512f, 0.07935542f, -0.11299232f, -0.03819066f, -0.26810560f, 0.15644808f, 0.11949418f, -0.09080837f, 
    -0.07571480f, -0.02176627f, 0.03745508f, 0.12951437f, -0.08311277f, -0.05326959f, -0.15801342f, -0.16764516f, 
    -0.10074124f, 0.03455376f, 0.07695597f, -0.11386807f, -0.07135015f, -0.01068124f, 0.01541210f, -0.06592844f, 
    -0.04915115f, -0.00109990f, -0.00036627f, 0.05377714f, 0.06450375f, 0.05193609f, -0.26438627f, -0.34368348f, 
    -0.00477932f, 0.01829056f, -0.00662280f, 0.07645666f, -0.08052852f, -0.05926711f, -0.08774072f, 0.03342303f, 
    0.01672442f, 0.23175175f, 0.18304089f, 0.17104693f, 0.05192481f, 0.04867342f, 0.04354983f, 0.09053606f, 
    0.07876378f, 0.09549229f, 0.08829480f, 0.10172608f, -0.09225010f, 0.08990508f, -0.18246661f, 0.05112007f, 
    0.17021175f, -0.09553961f, -0.10434990f, 0.09932651f, 0.00964672f, -0.03176479f, 0.15162040f, -0.18473652f, 
    0.04273205f, 0.14439559f, 0.24676834f, 0.01765395f, -0.07720377f, -0.06291197f, -0.01142836f, 0.02759697f, 
    0.11815666f, -0.00736324f, -0.09893508f, -0.02970380f, 0.10939886f, 0.06324304f, 0.02083579f, -0.04019204f, 
    0.08766624f, 0.11434289f, -0.02548485f, -0.00863244f, -0.14381489f, 0.05428446f, -0.11471882f, 0.08692363f, 
    0.19418050f, 0.09283430f, -0.13204521f, -0.22731352f, 0.02056075f, -0.04868196f, 0.09875987f, 0.01138849f, 
    -0.14610548f, -0.01769884f, 0.15516886f, 0.04343336f, -0.01792163f, -0.27417320f, 0.02868066f, -0.10618720f, 
    -0.10751548f, 0.05617148f, 0.07525434f, 0.01867276f, 0.02532106f, -0.11766647f, -0.12136158f, 0.04923676f, 
    -0.13813154f, -0.28034693f, 0.08037624f, 0.21795979f, -0.03102104f, -0.04431387f, -0.07977463f, 0.00180146f, 
    0.04771733f, 0.00043295f, -0.07281317f, 0.09966513f, -0.41758347f, -0.00088553f, -0.15406999f, -0.14057703f, 
    -0.00697997f, 0.00736609f, 0.08354027f, -0.10964868f, -0.11338831f, -0.00024381f, -0.04192991f, 0.01314818f, 
    -0.08319394f, 0.06528660f, -0.08176930f, 0.04442621f, 0.09110034f, 0.00884171f, -0.00231359f, 0.04373915f, 
    0.01960741f, -0.04080806f, 0.05778192f, -0.02656426f, 0.58995157f, -0.03066108f, -0.26724058f, -0.05078854f, 
    0.08143544f, 0.10864183f, 0.00190936f, 0.06266982f, -0.07339901f, -0.11650944f, 0.01684713f, 0.02681763f, 
    0.27070865f, -0.30405536f, -0.07035499f, 0.04292691f, -0.08116437f, 0.03004380f, -0.08249795f, 0.00902632f, 
    -0.04981861f, 0.06103105f, -0.04290788f, 0.05151279f, -0.04063137f, -0.23297802f, -0.01722644f, 0.09383176f, 
    -0.01392709f, 0.15161350f, -0.01147378f, -0.05153958f, -0.04790700f, -0.05167525f, 0.00830242f, -0.18781808f, 
    -0.11939104f, 0.22832663f, 0.07311269f, -0.01210317f, 0.07715648f, 0.05242165f, 0.03892202f, -0.08335667f, 
    -0.09462170f, -0.04914321f, 0.07900698f, 0.03678323f, -0.10747814f, 0.21340483f, -0.40588099f, 0.34048349f, 
    -0.02969431f, -0.08778837f, 0.01138782f, 0.07561589f, 0.05540894f, 0.03283350f, -0.00385255f, -0.03703955f, 
    -0.35153392f, -0.17543513f, 0.15434323f, 0.04082556f, -0.01599075f, 0.02231502f, -0.02627988f, -0.02873522f, 
    0.14295214f, -0.13249849f, 0.02070444f, 0.04254632f, -0.15379415f, -0.00651383f, 0.32309815f, -0.17958979f, 
    0.05825011f, 0.06856605f, -0.04673084f, 0.04183441f, -0.09031356f, -0.05923549f, 0.01673174f, -0.02787807f, 
    -0.17971340f, 0.11332789f, 0.11399574f, -0.04439453f, 0.00452947f, 0.04664785f, 0.12982318f, -0.03391147f, 
    0.08335456f, 0.12844938f, -0.00523821f, 0.07981062f, 0.30369857f, -0.11767968f, 0.12867172f, 0.09534094f, 
    -0.03429462f, 0.00123187f, 0.02730390f, 0.05069293f, -0.06044792f, 0.06431589f, 0.10558512f, -0.01546860f, 
    -0.12108487f, 0.23454042f, -0.23702753f, -0.19905934f, -0.05507298f, -0.20368166f, 0.06503824f, -0.00248301f, 
    0.03903670f, 0.12535159f, 0.04033775f, -0.03478826f, 0.04152623f, -0.14274481f, -0.12352700f, -0.06741770f, 
    0.04603780f, 0.01375261f, -0.05088035f, -0.18151195f, -0.01737756f, -0.01640749f, -0.05335905f, -0.11272740f, 
    -0.15049493f, -0.06694642f, -0.06970108f, -0.19264644f, 0.06724019f, 0.09297660f, 0.07416779f, -0.06621055f, 
    -0.05877310f, -0.05326165f, -0.11097467f, 0.03442834f, -0.04492662f, -0.08494483f, -0.12029132f, 0.15115543f, 
    0.03042324f, 0.05134270f, 0.06108030f, -0.04747381f, 0.00045031f, -0.09466631f, 0.14679296f, -0.03354212f, 
    0.16710679f, -0.00236253f, 0.00926537f, 0.18717584f, 0.02712865f, -0.03620106f, -0.02898390f, -0.00160614f, 
    0.04190457f, -0.03717456f, 0.01475651f, 0.10755578f, -0.00942885f, 0.24591838f, 0.14218204f, 0.06271387f, 
    0.07414939f, -0.05089531f, -0.00039765f, 0.15389559f, 0.10871411f, -0.11663854f, -0.08529570f, -0.05035317f, 
    0.01765280f, 0.08815013f, -0.02304003f, -0.05485175f, 0.00340984f, 0.07923350f, 0.01041389f, 0.03298448f, 
    -0.05118512f, 0.00104245f, -0.10337470f, -0.05158095f, -0.06823486f, 0.00420258f, -0.00990304f, -0.21055718f, 
    -0.01958933f, -0.05040830f, -0.02282786f, -0.00279731f, 0.00193336f, 0.18141916f, 0.00682155f, 0.11555322f, 
    -0.41199961f, -0.03680613f, 0.07815216f, -0.08198759f, 0.06744035f, -0.07442490f, -0.07223204f, 0.01795022f, 
    0.17104414f, -0.04610556f, 0.10412056f, 0.01692279f, 0.04561744f, 0.06241862f, 0.08953936f, -0.11362699f, 
    0.04346554f, 0.10184001f, 0.02536800f, -0.15533453f, -0.01772822f, 0.01984102f, -0.03784706f, 0.02018290f, 
    0.02783664f, -0.16786054f, -0.04294616f, 0.16981275f, -0.12338892f, 0.08007912f, 0.10383996f, -0.12435438f, 
    0.10614062f, 0.02906480f, 0.00004995f, -0.10964552f, 0.04159687f, -0.03147287f, -0.10741605f, 0.08088278f, 
    0.01565044f, -0.02063270f, 0.04986316f, 0.03247575f, -0.11165037f, 0.02823625f, -0.06881616f, -0.07629923f, 
    0.16386086f, -0.07740280f, -0.19409598f, 0.10304064f, -0.02590360f, -0.07956646f, -0.05551439f, 0.10703728f, 
    -0.02665142f, -0.04964791f, 0.06242079f, 0.09032744f, 0.21420513f, -0.20859186f, 0.09404913f, -0.10998519f, 
    -0.02750128f, 0.04582725f, 0.08133698f, -0.07516473f, 0.05362282f, 0.02507154f, 0.02665932f, 0.09593971f, 
    -0.34403837f, -0.06914920f, 0.01682357f, 0.00342141f, 0.04517715f, 0.07624944f, -0.08207090f, -0.06269505f, 
    0.06918912f, 0.01907474f, -0.15553820f, -0.05446299f, 0.09660364f, 0.05863754f, 0.02507362f, 0.20431635f, 
    -0.03422873f, -0.08878392f, 0.02421219f, -0.04302553f, 0.04331727f, 0.04907862f, -0.02399328f, -0.03883333f, 
    -0.22742812f, 0.07904185f, 0.13875818f, -0.06466199f, 0.03534460f, -0.01844053f, 0.00402026f, -0.01945835f, 
    0.00465741f, 0.07102864f, 0.05953517f, 0.10624933f, 0.00986534f, -0.01341150f, 0.00015205f, -0.01392980f, 
    0.01048033f, -0.17171705f, -0.03831271f, 0.11530810f, -0.07172898f, -0.07910901f, 0.08077519f, -0.00490786f, 
    -0.19281551f, -0.14449352f, -0.17840602f, 0.09539524f, 0.05972690f, -0.03342420f, 0.05460362f, -0.01932837f, 
    0.04283407f, 0.11438096f, 0.07107554f, 0.09642596f, 0.20091622f, 0.02397801f, -0.06643604f, -0.09280933f, 
    0.00279607f, 0.03945787f, -0.03063991f, -0.01403289f, 0.01357820f, 0.06107325f, 0.02260987f, -0.00618024f, 
    -0.23113842f, 0.01235435f, 0.15176843f, 0.05669693f, -0.01323977f, -0.02850783f, 0.02736126f, 0.07275869f, 
    0.03902111f, -0.01441209f, 0.11492065f, 0.15913974f, -0.08633288f, -0.08999174f, 0.01758889f, 0.09612083f, 
    0.06650267f, 0.09114191f, 0.01719872f, 0.05219367f, 0.02825709f, 0.13088672f, -0.02861915f, -0.04436353f, 
    -0.13155007f, 0.10771740f, -0.23520091f, 0.13263726f, -0.07929054f, -0.03938988f, 0.04114690f, -0.04592392f, 
    -0.01006170f, 0.04579809f, 0.02590483f, -0.10053637f, 0.05351156f, -0.13981472f, -0.04444873f, -0.03261461f, 
    0.02206726f, 0.00957924f, 0.01484954f, 0.04331792f, 0.05181196f, 0.07634725f, -0.09048812f, -0.06377321f, 
    0.26134139f, 0.01541576f, -0.01605451f, 0.01841187f, 0.01804267f, 0.09539930f, -0.03377168f, 0.00807405f, 
    -0.01070042f, 0.08744416f, 0.10240410f, -0.11086729f, -0.10190473f, -0.01018566f, -0.05717504f, 0.02239745f, 
    0.03970324f, 0.05693678f, 0.03569086f, -0.03620572f, 0.08870394f, -0.11201751f, -0.19637875f, -0.06728105f, 
    -0.64660251f, -0.28585997f, -0.00378140f, -0.06604034f, 0.10318863f, -0.06101657f, -0.04007516f, -0.06099482f, 
    0.04798415f, -0.07272622f, 0.06311136f, 0.03105987f, 0.25889859f, 0.05469057f, -0.02761322f, -0.07039294f, 
    -0.08795767f, -0.03939062f, 0.05403407f, 0.04927637f, -0.04423082f, -0.01750885f, 0.00938153f, -0.00726900f, 
    -0.05142638f, -0.17438257f, 0.02639701f, -0.02675678f, -0.02849440f, -0.01867612f, 0.08605102f, -0.09733757f, 
    0.00848846f, 0.11279021f, -0.02223629f, -0.05150944f, -0.19335328f, -0.07528778f, -0.02524062f, 0.10736880f, 
    -0.05883844f, -0.08592133f, -0.00257230f, -0.02905752f, -0.03946506f, 0.03473623f, 0.07183123f, 0.14941558f, 
    -0.41983330f, -0.04476564f, -0.08374315f, -0.09851567f, 0.09789270f, -0.03922569f, -0.04020397f, 0.03136178f, 
    0.06823830f, 0.07309743f, 0.10702759f, 0.10547364f, -0.14254667f, 0.06637962f, 0.00522798f, 0.02664405f, 
    -0.04319158f, -0.10123209f, -0.09301784f, -0.10294408f, -0.17261077f, -0.21025594f, -0.01666579f, -0.13305663f, 
    -0.41769028f, 0.06568271f, -0.15668841f, -0.02850100f, 0.09459089f, -0.04301167f, -0.10538893f, 0.00088435f, 
    0.02293539f, -0.15482859f, 0.06117385f, -0.16918598f, 0.16596663f, -0.01690688f, -0.01875940f, -0.01359142f, 
    0.01520513f, 0.07700557f, 0.00665451f, 0.05691579f, 0.04976584f, 0.04437806f, -0.04795603f, 0.05137835f, 
    -0.30168426f, 0.08373124f, -0.18129507f, -0.04724469f, 0.02129482f, 0.02451972f, 0.00490082f, 0.00360040f, 
    0.00090218f, 0.14525542f, 0.03200967f, 0.08040846f, -0.11528420f, -0.02811868f, 0.20335697f, -0.07000550f, 
    0.04388919f, -0.02363601f, -0.04918758f, 0.03296402f, 0.11624712f, 0.08463114f, 0.05454632f, 0.14462715f, 
    0.11891105f, 0.12898518f, 0.08529026f, -0.07906052f, 0.08171951f, -0.00382690f, 0.10090056f, 0.07769231f, 
    0.00074757f, 0.03849268f, 0.07995895f, 0.11847431f, -0.15157489f, -0.05372858f, -0.14284864f, -0.06903174f, 
    0.04008223f, -0.02186950f, -0.10091837f, -0.08086768f, 0.01342470f, -0.05798667f, 0.06272832f, 0.02022877f, 
    -0.34400231f, 0.11293856f, -0.18315114f, -0.25024071f, 0.01996616f, -0.05291294f, -0.12257022f, 0.03659114f, 
    -0.01471799f, 0.11154740f, 0.06666985f, 0.17250201f, 0.03006117f, 0.13162719f, -0.00136199f, -0.15227138f, 
    0.12552917f, -0.01601516f, 0.00584773f, 0.01643469f, -0.01590392f, 0.00020390f, 0.01352772f, -0.00595634f, 
    0.04508697f, 0.25880742f, 0.18195178f, 0.10138281f, 0.05085089f, 0.01260921f, -0.03324678f, -0.01819661f, 
    0.00921618f, 0.06500003f, -0.05161255f, -0.02737013f, 0.14044815f, 0.06958465f, 0.11423958f, -0.19918767f, 
    -0.02982040f, 0.00241952f, 0.05272046f, -0.04755927f, -0.07285261f, 0.04643175f, -0.03400307f, 0.07429919f, 
    -0.44999963f, -0.17226870f, -0.10057177f, -0.26579893f, 0.03311997f, 0.03630862f, -0.14616132f, -0.03907868f, 
    0.01082310f, -0.06356048f, 0.00525656f, -0.10296163f, -0.01245969f, 0.09715577f, 0.13448519f, 0.01150320f, 
    0.01171768f, -0.18169062f, 0.01077624f, -0.01006279f, -0.02498462f, 0.07243329f, 0.12983672f, 0.10822900f, 
    -0.13649803f, 0.05219026f, 0.10637312f, -0.05346978f, 0.12496682f, 0.09473603f, 0.11179997f, 0.01253999f, 
    0.09491149f, 0.02329741f, -0.04352662f, -0.06196864f, -0.16498296f, 0.00803111f, 0.01478788f, -0.13450199f, 
    0.11854832f, 0.02265037f, 0.04313584f, -0.01612951f, 0.09055741f, 0.02899574f, 0.00244749f, 0.03889907f, 
    -0.18509182f, -0.22242388f, -0.02436622f, 0.02039404f, 0.03212670f, -0.03104041f, 0.04111518f, -0.04496747f, 
    0.06835800f, -0.05722705f, -0.05617922f, -0.13290964f, 0.34082627f, 0.01995945f, 0.05826604f, -0.07125212f, 
    -0.15500562f, -0.10196993f, 0.00357649f, 0.00398218f, -0.04095007f, -0.13059987f, -0.04690959f, 0.01048416f, 
    -0.07507822f, 0.19691218f, -0.01141404f, -0.09003849f, 0.05932837f, -0.18557204f, -0.10239349f, -0.04019082f, 
    -0.15136243f, -0.03177607f, 0.13695489f, 0.14942878f, 0.08754048f, 0.00674421f, -0.06498422f, 0.06159777f, 
    -0.02645144f, -0.08423318f, 0.03479346f, 0.00634296f, 0.11333787f, 0.07945455f, 0.08540457f, -0.04524473f, 
    -0.19333366f, 0.18918312f, -0.00893807f, 0.02231599f, 0.05782243f, 0.03738111f, -0.03317514f, -0.02107817f, 
    -0.05558005f, -0.04436648f, 0.11701678f, -0.03415764f, -0.19034088f, 0.02771938f, -0.12318561f, -0.00910001f, 
    0.00709363f, -0.03174092f, 0.03666136f, 0.11216469f, 0.01376293f, 0.08303079f, 0.02945160f, -0.00937938f, 
    0.18553114f, -0.07283205f, -0.05329097f, 0.06047239f, -0.04176191f, -0.04235157f, 0.09977539f, 0.07174977f, 
    -0.09102271f, -0.11708712f, -0.09138159f, -0.12124132f, -0.48171479f, -0.29687998f, -0.11747743f, -0.16627304f, 
    0.01524840f, 0.04253647f, -0.04636028f, -0.01857856f, 0.04118473f, 0.07943556f, 0.06088425f, 0.00126302f, 
    -0.39231664f, -0.08305782f, -0.16006911f, -0.12047207f, 0.00796839f, -0.01226346f, 0.00414348f, -0.00753069f, 
    0.06577281f, 0.01799597f, 0.00382370f, 0.06950795f, -0.26782948f, -0.11763953f, 0.13963103f, 0.14427453f, 
    -0.04370279f, -0.16031308f, 0.13293342f, -0.00906667f, -0.03550015f, 0.08137996f, 0.13997509f, 0.06938379f, 
    0.05533826f, -0.01036282f, -0.05107348f, 0.09489967f, -0.07900051f, 0.11742333f, 0.01170038f, 0.00942207f, 
    0.08884320f, 0.02119182f, 0.04974168f, 0.02419952f, 0.20853889f, 0.15124984f, -0.05346834f, -0.12601602f, 
    0.05241409f, 0.03076728f, 0.11581119f, -0.16946107f, -0.03501957f, -0.02004887f, 0.06700020f, -0.03462709f, 
    -0.15173332f, -0.16160253f, 0.01619245f, 0.05096991f, 0.09920088f, 0.03585759f, 0.01650276f, 0.04940719f, 
    0.16722485f, 0.07058052f, 0.04236586f, 0.09229569f, 0.07123583f, 0.03316174f, -0.10442747f, 0.11926898f, 
    0.02452151f, -0.08030909f, 0.03846081f, 0.08290877f, 0.04323274f, -0.05938274f, -0.07481492f, -0.03468233f, 
    0.01270539f, 0.03049713f, -0.00898378f, -0.10286523f, 0.06378035f, 0.01772285f, 0.02496940f, -0.11757478f, 
    0.16891988f, 0.04625196f, 0.04005252f, 0.01212678f, -0.60227597f, -0.08835016f, -0.17871036f, 0.06360715f, 
    0.15295486f, -0.01823822f, -0.02236786f, -0.01040496f, -0.02767142f, 0.06525948f, 0.06795224f, 0.00500189f, 
    -0.33104157f, -0.30525306f, -0.07958768f, 0.06996971f, 0.10128697f, 0.00470271f, 0.08068401f, -0.07892575f, 
    0.02701188f, -0.11288415f, -0.10928479f, -0.02516681f, -0.22452606f, 0.07814430f, 0.11915975f, 0.10166588f, 
    -0.01060341f, 0.07383453f, -0.03736545f, -0.08390772f, -0.12940380f, -0.16513310f, 0.02690272f, 0.10434962f, 
    -0.07976189f, 0.01996777f, -0.00186378f, -0.19784875f, 0.04499517f, -0.01481084f, -0.00848055f, 0.02740496f, 
    0.04652630f, 0.00498345f, 0.04164422f, 0.05171555f, 0.31313613f, 0.08840500f, -0.07052210f, 0.08017667f, 
    -0.14543714f, -0.06351062f, 0.02002726f, 0.04965756f, 0.03053207f, 0.01381862f, -0.01281627f, -0.03208615f, 
    -0.37754267f, -0.27397025f, 0.02250520f, -0.07501388f, 0.06256994f, -0.07229070f, 0.08671791f, 0.12120636f, 
    0.12078713f, 0.16640046f, 0.05512987f, 0.14071408f, 0.05983615f, 0.06478448f, 0.01164704f, -0.02864657f, 
    0.03558595f, -0.16810520f, 0.00265318f, -0.04442805f, 0.01580858f, 0.03834112f, -0.09626644f, 0.13872598f, 
    0.03900938f, 0.02493425f, -0.10471863f, -0.15366220f, 0.00761552f, 0.09184963f, 0.09558353f, -0.01836289f, 
    -0.04033713f, 0.00455709f, 0.03780857f, 0.07506406f, -0.14232372f, -0.17402107f, 0.03930354f, -0.09119184f, 
    -0.01478447f, 0.08948052f, 0.08808590f, -0.01547871f, 0.06766645f, -0.02502991f, -0.04359315f, 0.04572764f, 
    -0.59606802f, -0.31953973f, -0.06302845f, -0.17579757f, 0.08922637f, 0.01676562f, -0.04537055f, -0.11495727f, 
    0.07513465f, 0.03685978f, 0.02433205f, 0.06823087f, 0.12296963f, 0.01854007f, 0.03713615f, -0.06753995f, 
    0.08233181f, -0.01010482f, -0.00450299f, 0.00802922f, 0.09238701f, -0.06298018f, -0.05738820f, -0.10639782f, 
    0.15745598f, -0.03522737f, -0.00107474f, -0.03092608f, -0.05307164f, -0.09907123f, 0.06642225f, -0.05230857f, 
    0.10852163f, -0.04484428f, -0.15797034f, -0.06509718f, -0.12020116f, -0.19511834f, -0.21443255f, -0.09392475f, 
    0.04460475f, 0.11792942f, -0.05661047f, -0.07298367f, 0.09558290f, 0.03756768f, -0.16859339f, 0.00592605f, 
    0.13765402f, 0.02249458f, 0.00976507f, 0.02928310f, 0.00122369f, -0.06604464f, 0.00239874f, 0.04500564f, 
    -0.00949931f, -0.01895834f, -0.02951162f, 0.13979454f, 0.16829221f, -0.00529476f, 0.11054736f, -0.21933365f, 
    -0.03344198f, -0.10748708f, 0.04796893f, -0.14684229f, 0.00942519f, -0.13560641f, 0.00072193f, -0.00731502f, 
    0.18984444f, 0.03414015f, 0.13032235f, -0.09078928f, -0.00340315f, 0.00096803f, 0.04328927f, 0.05943184f, 
    0.08308852f, -0.06230804f, -0.03665182f, 0.02010347f, -0.14672415f, 0.08579303f, 0.10668155f, -0.07580302f, 
    0.10395516f, 0.03214232f, -0.00470023f, 0.02554517f, 0.00069095f, -0.01105677f, -0.08335429f, -0.01908342f, 
    0.20557584f, 0.00926194f, -0.00231789f, 0.08633275f, -0.03406347f, -0.04898635f, -0.07402983f, 0.05504660f, 
    -0.05080621f, 0.06297888f, 0.07234069f, 0.10904446f, -0.33342543f, 0.18087371f, -0.10297623f, 0.03778017f, 
    0.10960044f, 0.00378787f, 0.05970327f, 0.01493930f, 0.05259921f, 0.05486877f, -0.00203302f, 0.09257208f, 
    0.53607893f, 0.01166539f, -0.05223001f, -0.02372259f, -0.01722662f, -0.06162447f, -0.04805940f, -0.00505358f, 
    0.03412538f, 0.01080652f, 0.02594616f, 0.00878991f, 0.21434334f, -0.18787007f, 0.01438711f, 0.08946083f, 
    0.06476101f, -0.00672726f, 0.03457790f, 0.02293034f, -0.02866028f, 0.01076990f, -0.03180616f, 0.10622047f, 
    0.12080806f, -0.29139030f, -0.17663994f, 0.09064052f, 0.01961865f, 0.06588595f, -0.11814477f, -0.02180797f, 
    0.00816107f, 0.00617881f, -0.04929731f, 0.07969581f, 0.04164186f, 0.10476489f, -0.02906943f, 0.08957423f, 
    0.02095292f, -0.04331102f, 0.08097667f, -0.05470012f, -0.02665577f, -0.01751092f, -0.00279548f, -0.10381111f, 
    0.21288791f, -0.18943569f, 0.02395149f, -0.04376732f, -0.00030917f, -0.02624127f, 0.03026479f, -0.08843280f, 
    -0.06193507f, 0.01848814f, -0.05445549f, -0.02293782f, -0.11859674f, -0.13032128f, -0.02324676f, 0.10362028f, 
    -0.04279717f, 0.03417820f, -0.03128156f, -0.01513125f, 0.06703033f, -0.01481185f, 0.01160168f, 0.02541175f, 
    -0.07518689f, -0.00795253f, 0.01150182f, 0.06680800f, -0.03424674f, 0.15441087f, -0.02142518f, -0.05059335f, 
    0.06393320f, 0.02963057f, 0.00608534f, 0.00814800f, -0.02018571f, -0.24346411f, 0.01169374f, -0.15841046f, 
    0.01018883f, 0.00143655f, 0.04450459f, 0.05690984f, -0.03701278f, 0.00928045f, -0.04954876f, 0.08228769f, 
    0.06630661f, 0.01254602f, -0.14223491f, 0.14117824f, -0.06610861f, -0.01821669f, -0.07984401f, 0.01408919f, 
    0.03618089f, -0.03752194f, -0.00578706f, -0.04838234f, -0.13184728f, 0.01858995f, -0.09768112f, 0.16828473f, 
    -0.07730960f, 0.11844358f, -0.03807571f, -0.01290078f, 0.05842182f, 0.04103088f, -0.13380222f, 0.14317523f, 
    0.37769550f, 0.05627035f, -0.22987264f, 0.12306787f, 0.03937010f, -0.01062052f, -0.07528758f, -0.02607955f, 
    0.09019568f, 0.06418279f, 0.05837402f, 0.02296121f, -0.02349412f, -0.07950055f, -0.01233626f, 0.04542118f, 
    -0.02221748f, 0.02743217f, 0.10968380f, 0.04236153f, -0.03732623f, 0.05458338f, -0.05496421f, -0.14792925f, 
    -0.11421566f, 0.03909213f, 0.02326385f, -0.09926593f, 0.01923951f, 0.02999152f, -0.13074131f, 0.04874135f, 
    -0.04406429f, -0.09176081f, 0.03320660f, -0.09403501f, 0.05590067f, -0.22586378f, 0.10891308f, 0.07287560f, 
    -0.04947845f, -0.03410376f, -0.06714688f, -0.05636269f, -0.04315480f, -0.03128351f, -0.04583083f, -0.07666509f, 
    0.09952158f, -0.11548582f, -0.02221595f, -0.03441567f, 0.00301462f, 0.01365325f, -0.01117548f, -0.00764353f, 
    0.01784757f, -0.07281163f, -0.01059488f, -0.04283032f, 0.14045966f, -0.10203393f, -0.00617180f, -0.30582505f, 
    -0.04561406f, 0.03113167f, -0.01438739f, -0.20724851f, -0.03181336f, 0.13503292f, -0.07853713f, -0.07006782f, 
    -0.38147154f, -0.12237176f, -0.01270596f, -0.13188833f, 0.04210523f, 0.01152488f, 0.03610397f, 0.11000685f, 
    -0.00832552f, -0.09467369f, 0.09075848f, 0.16133565f, -0.00733968f, 0.05258106f, -0.01292628f, 0.12285000f, 
    0.03276369f, 0.01624587f, -0.07867341f, 0.01069637f, 0.07963765f, -0.05609833f, 0.02677520f, -0.03040363f, 
    -0.21878691f, 0.17291068f, -0.08563270f, 0.02909455f, 0.00072934f, 0.09487082f, 0.03981418f, 0.15237057f, 
    -0.01868046f, -0.05403302f, 0.11409965f, -0.06889824f, -0.08828788f, -0.10329013f, 0.03391444f, -0.08131931f, 
    0.12255362f, -0.06877065f, -0.07628750f, -0.01069424f, 0.01171604f, 0.10436209f, -0.11340154f, -0.16145338f, 
    0.36537880f, -0.19899169f, -0.16862367f, -0.06650635f, 0.11397702f, -0.00486423f, -0.03130633f, -0.00809929f, 
    -0.01309607f, -0.08485112f, 0.11359788f, 0.02065677f, -0.17384787f, -0.25960791f, -0.16273203f, -0.18368684f, 
    0.04715900f, -0.02197798f, 0.08636941f, 0.04388297f, -0.03065860f, 0.02933974f, -0.02811575f, -0.09002624f, 
    0.02884797f, 0.00594424f, -0.14617673f, 0.05873674f, 0.11103122f, 0.05774065f, 0.09700613f, 0.06836361f, 
    -0.01179344f, -0.05973584f, 0.00237530f, -0.07248598f, -0.32090208f, 0.24044640f, -0.18445069f, -0.17450012f, 
    0.06869946f, -0.08358970f, -0.08475012f, -0.00207788f, 0.07652805f, 0.03179869f, 0.01212207f, -0.03279581f, 
    0.10054208f, -0.03103954f, -0.03654805f, -0.00177743f, -0.06209793f, 0.07427445f, -0.02648942f, 0.09137561f, 
    0.09550127f, -0.06209508f, 0.01396894f, 0.01799232f, 0.00322764f, -0.02807191f, 0.07623527f, 0.07001021f, 
    0.01137976f, 0.06134056f, -0.06723024f, 0.09613933f, 0.06144875f, -0.04713331f, 0.01074244f, -0.01283599f, 
    0.07862291f, -0.17954932f, -0.08066314f, -0.23784059f, 0.03889309f, -0.02460610f, 0.01630805f, -0.01177440f, 
    -0.02665727f, 0.07892089f, -0.01871557f, -0.04099085f, 0.22122432f, -0.08708507f, -0.00491408f, -0.09647398f, 
    -0.06477532f, 0.02833791f, 0.03290071f, 0.04534871f, 0.05943408f, 0.00142228f, -0.04005831f, 0.09449755f, 
    0.48242351f, -0.07622223f, -0.16340780f, 0.09109064f, 0.00396162f, -0.00054256f, -0.12341487f, -0.06883343f, 
    0.08179421f, 0.04136939f, 0.05132715f, -0.00856897f, -0.07874057f, -0.23213375f, 0.00892665f, 0.34987238f, 
    -0.23931606f, -0.03002583f, 0.08500230f, 0.02329295f, -0.05461707f, -0.00539308f, -0.04255416f, -0.03954839f, 
    0.00695175f, 0.06674070f, 0.08138703f, -0.02172219f, 0.03633856f, -0.00216508f, 0.00685471f, -0.14038290f, 
    0.03796407f, 0.04531286f, -0.02207503f, 0.02578883f, -0.44902468f, -0.13462529f, -0.10533304f, -0.09703739f, 
    0.00566821f, 0.01675463f, 0.11466920f, 0.15022840f, -0.08518872f, 0.04825683f, 0.01549397f, -0.16725980f, 
    -0.04689556f, 0.07378352f, 0.10969483f, -0.05987912f, -0.01387944f, 0.00624999f, -0.08184002f, 0.03162107f, 
    -0.01427669f, -0.05031728f, -0.06653601f, -0.06820364f, -0.24229760f, -0.29965097f, 0.12206353f, 0.10979428f, 
    0.03523994f, 0.07066695f, -0.10193080f, -0.01588492f, -0.05601409f, -0.11893979f, -0.12106198f, 0.11668380f, 
    -0.04967330f, -0.14616227f, 0.06269256f, -0.03799099f, -0.03539773f, 0.10778087f, 0.02028873f, 0.10517482f, 
    -0.00566422f, -0.03628692f, -0.08759936f, 0.00191891f, -0.04145679f, -0.00459608f, 0.06026121f, 0.18958755f, 
    -0.16372864f, 0.03043315f, -0.08311894f, -0.05211942f, 0.00104006f, -0.13855478f, 0.04262666f, 0.04985726f, 
    -0.06340128f, 0.00279674f, 0.07420624f, -0.03414745f, 0.04383619f, -0.05680738f, 0.01338781f, -0.16892050f, 
    0.02749012f, 0.06218192f, 0.01071690f, -0.05297123f, 0.14468519f, 0.14155616f, -0.20461775f, 0.02999054f, 
    0.03959333f, -0.00758001f, -0.05167785f, -0.04603345f, 0.08884701f, 0.02631498f, -0.02748588f, -0.04640882f, 
    -0.00045067f, -0.10864660f, -0.04729111f, -0.18828794f, 0.05891906f, 0.04914079f, 0.07641982f, 0.05999260f, 
    -0.09727980f, -0.05884388f, -0.00793644f, -0.10660154f, -0.07074260f, -0.06050844f, -0.11847225f, -0.06426346f, 
    -0.06713188f, -0.07786799f, -0.04453844f, 0.14385876f, -0.11726029f, -0.03884474f, -0.05438144f, -0.07009307f, 
    -0.00505026f, 0.02892006f, 0.00820653f, 0.14244518f, 0.01529580f, -0.01943373f, -0.04468931f, 0.06724734f, 
    -0.18785660f, 0.01021876f, 0.02894964f, -0.05826315f, -0.14866067f, -0.06742413f, -0.19752216f, -0.19913527f, 
    -0.12792590f, -0.00088082f, 0.06194127f, -0.01099636f, -0.04510719f, -0.20641460f, -0.03813240f, -0.19236633f, 
    0.33080721f, -0.07385134f, 0.06851717f, 0.04180044f, 0.14649159f, -0.10269343f, -0.03056789f, -0.00896069f, 
    -0.01444488f, 0.02523388f, 0.03692302f, -0.11489686f, 0.09928919f, -0.08935932f, 0.20661530f, 0.03465065f, 
    -0.05446758f, -0.00523270f, 0.06510968f, -0.04706984f, -0.10871608f, 0.03503083f, 0.08855952f, 0.09401619f, 
    0.05457851f, -0.27149501f, -0.03657352f, 0.20155773f, -0.12328720f, 0.05121852f, -0.11528272f, 0.05531198f, 
    0.00140518f, 0.14091980f, 0.00270222f, -0.01745799f, 0.09030945f, -0.10512378f, -0.06919401f, 0.11655533f, 
    -0.09285843f, 0.05550487f, 0.04428715f, 0.11186379f, -0.03853913f, 0.00325878f, 0.01062327f, -0.05824207f, 
    0.10787512f, 0.24980612f, -0.17107832f, -0.10428853f, 0.07804259f, 0.01817817f, -0.01514681f, 0.06464432f, 
    0.13229494f, 0.04859655f, 0.12412900f, 0.00112595f, 0.02026001f, 0.11290696f, 0.08632226f, -0.04550660f, 
    -0.13864328f, 0.06766748f, -0.00649373f, -0.03114876f, 0.08591013f, -0.05101161f, -0.01041559f, 0.12003722f, 
    0.19753554f, -0.10617334f, -0.07387061f, 0.36688471f, 0.06268178f, 0.05140368f, 0.04961602f, -0.02780322f, 
    0.08620648f, 0.04579451f, 0.04199468f, -0.05771490f, -0.04957156f, 0.03837728f, -0.03530525f, -0.00873829f, 
    0.04884133f, 0.04176970f, 0.03425201f, -0.06506800f, 0.02138864f, -0.12089983f, -0.05692298f, -0.00492135f, 
    0.03067768f, 0.00398115f, 0.02540056f, -0.15091325f, -0.04407290f, 0.01965137f, -0.10093781f, 0.10412908f, 
    0.01440561f, -0.13686265f, -0.05692356f, -0.11937177f, -0.05881162f, -0.02078324f, 0.08208299f, -0.02471508f, 
    -0.13355789f, 0.03496857f, -0.02645499f, -0.08970083f, -0.03435277f, -0.03930113f, 0.02752034f, -0.08012782f, 
    -0.23968977f, 0.08927641f, 0.11511847f, 0.05263125f, -0.00712247f, 0.04170895f, -0.09298325f, 0.03495953f, 
    -0.01355682f, 0.03855579f, 0.06807666f, -0.00044598f, -0.32115871f, 0.03037604f, 0.04060290f, 0.00189282f, 
    0.10713628f, 0.05433911f, -0.05425495f, 0.07027499f, -0.02299503f, 0.03080874f, -0.02134221f, -0.07479678f, 
    0.26082304f, -0.30817419f, -0.16948770f, -0.20648637f, -0.03279835f, -0.02958004f, -0.09004664f, -0.00588233f, 
    0.02274158f, 0.03547646f, -0.08687589f, -0.04070086f, 0.12889652f, 0.03244765f, -0.30010730f, 0.15363206f, 
    -0.01450496f, 0.06305838f, -0.01706123f, 0.00266014f, 0.02057154f, -0.04754451f, 0.08296525f, -0.18645549f, 
    0.06173211f, -0.20548029f, -0.00128504f, -0.01164758f, -0.05308401f, -0.05788173f, -0.04992569f, 0.02875224f, 
    -0.01788924f, -0.04746329f, 0.04804863f, -0.02685138f, -0.00212297f, 0.07195736f, -0.03476012f, -0.26028863f, 
    0.06856827f, -0.01326230f, -0.07678536f, 0.09854299f, 0.00941197f, -0.00584154f, 0.08437753f, 0.07483190f, 
    0.06508043f, 0.23271969f, -0.01802936f, -0.18525475f, -0.00725097f, -0.01220289f, 0.02887228f, -0.02837627f, 
    -0.04825888f, -0.09002006f, 0.00288275f, -0.04033868f, 0.02232336f, 0.21255827f, -0.08690181f, -0.12407925f, 
    -0.06003487f, -0.09129079f, 0.02052139f, -0.06317834f, -0.00810864f, 0.05800696f, 0.05855033f, -0.22051166f, 
    -0.02431506f, -0.04054618f, 0.03597515f, 0.05222274f, 0.03853690f, -0.04730595f, -0.00791615f, 0.10342762f, 
    0.01027634f, 0.02345287f, 0.11833185f, -0.01576477f, 0.36562896f, -0.02908912f, -0.11996932f, -0.02499190f, 
    -0.00943013f, -0.07171977f, 0.01765117f, 0.06797821f, 0.10911889f, -0.01299763f, 0.06460160f, 0.03522899f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.03338055f, 0.00503410f, -0.01133268f, -0.01995085f, 0.00419023f, -0.03275316f, -0.00251847f, -0.02255554f, 
    -0.05582776f, 0.03132870f, 0.06364693f, 0.02584869f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
