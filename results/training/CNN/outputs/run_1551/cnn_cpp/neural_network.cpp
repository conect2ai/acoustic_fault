#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.41986105f, -0.37174538f, -0.31124312f, -0.17431353f, 0.79111522f, 1.03950655f, -0.28477928f, -0.23174246f, 
    -0.43286511f, -0.82364631f, -0.64737809f, 0.31646052f, 0.38148680f, -0.43787721f, -0.25865626f, -0.59645337f, 
    -0.58650184f, -0.65422356f, -0.59820580f, -0.02026221f, -0.53338146f, -0.10455029f, 0.17379272f, 0.52589023f, 
    0.43942860f, -0.22429243f, 0.66175997f, -0.88261205f, -0.96314746f, -0.14307328f, 1.07202899f, -0.41166279f, 
    -0.23088212f, -0.25237352f, 0.00107308f, 0.58504075f, -0.51815277f, 0.42088586f, 0.18291050f, 0.18702134f, 
    0.31533128f, 0.28416166f, 1.12078035f, -0.70893025f, -0.50538993f, 1.07817817f, -0.03510657f, -0.62345415f, 
    -0.06073444f, 0.30185503f, 0.32285249f, 0.13484222f, 0.42286533f, 0.02272099f, -0.39293763f, -0.21089654f, 
    -0.47535253f, 0.77778107f, 0.39697871f, 0.20983185f, -0.34744436f, -0.54443830f, -0.41031954f, 0.29194838f, 
    0.40991935f, 0.71152735f, 0.36427182f, 0.34469876f, 0.00582433f, 0.37244374f, -0.70764887f, -0.33758837f, 
    -0.75403941f, -0.23095344f, -0.06545057f, -0.33995467f, -0.25205392f, 0.14125201f, -0.22170414f, 0.09102034f, 
    -0.82665831f, -1.41986465f, 0.30413160f, 0.54913723f, 0.49722305f, 0.43511641f, -0.72517884f, -0.22099513f, 
    -0.21689986f, -0.29235974f, 0.13454007f, -0.41838610f, -0.26195151f, -0.68818712f, 0.27768302f, -0.46166536f, 
    0.83381903f, -0.07440212f, 0.72089225f, -0.08445667f, 0.41820523f, 0.75442809f, 0.38979623f, 0.44041911f, 
    -0.51099706f, -0.19904608f, -0.72062159f, -0.11172722f, -0.38818434f, 0.09674087f, 0.20660254f, 0.65018308f, 
    0.84053332f, 0.62434214f, -0.29647312f, 0.24865818f, 0.21077059f, 0.54298365f, 1.00493133f, 0.91797704f, 
    -0.96019930f, -1.04493690f, -0.47029567f, 0.02477602f, 0.09000009f, -0.43132478f, -1.26651633f, 0.40660712f, 
    -0.56834966f, -0.23069400f, 0.50716543f, 0.43822837f, 0.42483282f, 0.70594692f, -0.11082895f, 0.50085932f, 
    -1.08412385f, 1.05800915f, -0.04441457f, -0.04730133f, 0.34096333f, -0.16189145f, -0.10165922f, -0.53588676f, 
    -0.36255711f, -0.45124218f, 0.19584402f, -0.91665608f, -0.50702947f, -0.69336241f, -0.46369970f, 1.13602877f, 
    -0.77418357f, 0.58203077f, 1.26746178f, -1.31359279f, 0.36374739f, -0.46676183f, -0.24621728f, -0.18245469f, 
    0.20075990f, -0.17030624f, 0.86472505f, -1.15575969f, -0.59579879f, 1.27936780f, 0.12633675f, -0.07825796f, 
    0.04122002f, -0.36871946f, -0.19389501f, 1.17965913f, -0.63084024f, -0.60952294f, -0.09154601f, 0.75329536f, 
    -0.53772062f, -0.04001829f, -0.21790706f, 0.21642599f, -0.34464711f, 0.13445865f, 0.71251076f, 0.35413742f, 
    0.57029313f, 0.98819101f, 0.16550042f, -0.01620704f, -0.02312625f, -1.02617300f, -1.07360709f, -0.48864743f, 
    -0.01229064f, 0.47945794f, -0.61568540f, 0.34883332f, 0.46211725f, 0.56173730f, -0.40882349f, -0.25217909f, 
    -0.41603580f, -0.69448495f, -0.79627782f, -1.06658459f, -0.51169699f, 0.03839304f, -0.28322160f, 0.40662181f, 
    -0.33959314f, -0.45228133f, 0.19321960f, 0.23311628f, 0.45049128f, -0.64187586f, 0.98282808f, -0.88522762f, 
    0.51903790f, -0.13245742f, 0.07310724f, 0.74879849f, -0.51040459f, -0.22238624f, 0.50617886f, 0.60966575f, 
    0.46879435f, -0.57198399f, -0.13545571f, 0.21895877f, -0.63356590f, -1.15185142f, -0.97648925f, 0.34207734f, 
    -0.27204147f, 0.57145059f, -0.56188041f, -0.48261935f, -0.25529262f, -1.01502097f, -0.88826227f, -0.24239857f, 
    0.64271957f, 0.21233183f, 0.34521621f, -1.00235963f, -0.11211691f, 1.02562988f, -0.53327590f, -0.03614386f, 
    0.87616825f, -0.52943593f, -0.41759509f, -0.16217251f, -0.66234905f, -0.51841897f, -0.98805177f, 0.77556109f, 
    -0.27904916f, 1.05255187f, 0.12161994f, 0.00665369f, 0.06205552f, 0.34851971f, -0.08335971f, 0.28370991f, 
    1.05225027f, -0.45206988f, -0.49873617f, 0.37831435f, 0.36454219f, -0.82100177f, -1.03555453f, -1.13530338f, 
    -0.73294377f, 0.54892021f, -0.46404764f, -0.28243434f, -0.10794976f, -0.75318277f, -0.56210929f, 0.99896294f, 
    1.06046247f, -0.72040588f, -0.77424312f, -0.20177364f, -0.59751052f, 0.35608056f, 0.75611359f, 0.13662134f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.13928609f, 0.48128238f, 0.48425871f, -0.16191034f, 0.57151735f, 0.46105301f, -0.20847930f, 0.09617383f, 
    0.66311973f, 0.07840086f, 0.17843635f, 0.22418876f, 0.49919248f, 0.20477821f, 0.15668209f, -0.28124458f, 
    -0.27573892f, 0.19594091f, 0.13451922f, 0.34752244f, -0.18891774f, 0.06406297f, -0.34957436f, 0.65476030f, 
    -0.03358033f, 0.48262909f, 0.06078725f, -0.07908799f, 0.15737729f, 0.22581469f, 0.10307873f, 0.13920628f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.05274116f, -0.06369580f, 0.22174394f, -0.13399215f, -0.13912567f, -0.28353345f, -0.04062497f, 0.12625584f, 
    0.11883770f, -0.36593798f, -0.15000519f, -0.46219552f, -0.01018496f, -0.16615860f, 0.04076965f, 0.17248827f, 
    0.12330880f, -0.09126743f, 0.16165633f, 0.01233788f, -0.18470852f, -0.17352986f, -0.23693915f, -0.13277310f, 
    0.14462285f, 0.01757645f, 0.12697366f, -0.13941894f, 0.47095960f, -0.52304798f, -0.01492657f, -0.00553828f, 
    -0.00337736f, 0.05956437f, 0.12699044f, -0.01450057f, 0.18032996f, 0.27937579f, -0.02073539f, -0.17545994f, 
    -0.09538060f, 0.02698379f, 0.17369293f, 0.26178995f, -0.07654113f, 0.05674677f, -0.07719789f, -0.34638524f, 
    -0.34124959f, 0.03554467f, -0.19866873f, 0.44143626f, -0.02558686f, 0.05390416f, -0.15350541f, 0.00727612f, 
    0.14958942f, -0.06909533f, -0.19826268f, 0.09037321f, 0.04928188f, 0.26411349f, 0.18877932f, 0.04039784f, 
    0.13350642f, 0.00813320f, 0.05747668f, -0.14611731f, -0.15184012f, 0.16866255f, -0.13845928f, -0.00633588f, 
    -0.39610434f, -0.49827451f, 0.02443746f, -0.10233489f, -0.01607389f, 0.05794780f, 0.04984288f, 0.09811255f, 
    -0.10150740f, -0.36540613f, -0.03294685f, 0.08950400f, -0.14071882f, -0.08879651f, 0.22471158f, -0.04351662f, 
    -0.08538876f, -0.22111893f, 0.01464465f, 0.45173585f, -0.21840183f, 0.24548392f, 0.20523936f, 0.09388899f, 
    0.02418921f, -0.00178513f, -0.06619319f, -0.02433554f, 0.08855554f, 0.08984712f, 0.16034158f, -0.08119010f, 
    -0.07553579f, -0.11698033f, -0.11367281f, 0.24957263f, 0.21169965f, 0.06836008f, 0.14021176f, -0.17165923f, 
    -0.25272587f, -0.43607080f, 0.04690816f, 0.01023523f, 0.12358106f, -0.22371972f, -0.62501001f, 0.56785029f, 
    0.17459342f, 0.02478843f, -0.16748166f, 0.26274684f, 0.06696375f, 0.03535563f, 0.05650177f, 0.12978211f, 
    0.01467972f, -0.44676954f, 0.04272310f, -0.07057726f, 0.23929659f, 0.08357492f, 0.09856237f, 0.08842122f, 
    0.01113402f, -0.17458962f, 0.09885855f, 0.29418179f, -0.35678273f, -0.18549836f, 0.11887781f, -0.49713200f, 
    -0.11433595f, 0.02278702f, 0.42280367f, -0.25428608f, -0.01274914f, -0.14549008f, 0.06533764f, 0.07380497f, 
    0.12579402f, 0.15042076f, 0.25349668f, -0.34794647f, -0.17129904f, 0.46888641f, 0.01222330f, 0.00029612f, 
    0.05713487f, -0.22655888f, -0.18841542f, 0.01614123f, -0.56350887f, -0.14484039f, 0.31655267f, 0.11830643f, 
    0.12030945f, -0.05442122f, 0.00332122f, 0.08942848f, 0.53535020f, -0.34139675f, -0.17102881f, 0.31495500f, 
    0.18452305f, 0.14847624f, 0.12584062f, 0.14166333f, 0.17931008f, 0.03089785f, 0.06617043f, -0.31794542f, 
    -0.37171605f, -0.31791821f, -0.00850794f, 0.05365096f, -0.00896107f, 0.03668991f, 0.52152288f, -0.25700521f, 
    -0.01155765f, -0.08963900f, 0.05006401f, 0.08053797f, 0.10929920f, -0.06331272f, -0.08774338f, 0.21185726f, 
    0.16512893f, -0.10685370f, -0.08494748f, -0.06529756f, -0.03657698f, -0.09424043f, 0.04074395f, 0.16257080f, 
    0.43838200f, 0.15966251f, -0.16287041f, 0.21991540f, -0.23383446f, 0.10525689f, 0.17109248f, 0.13307954f, 
    -0.08826714f, 0.09737702f, -0.19711663f, 0.16924548f, -0.19679864f, 0.05146075f, 0.05775799f, 0.15965547f, 
    0.14252287f, -0.43905184f, 0.26136550f, 0.59212834f, 0.03791036f, -0.01305812f, -0.04922722f, -0.02495161f, 
    -0.16559501f, 0.03116670f, -0.26224682f, -0.38591781f, -0.03527430f, -0.03921916f, 0.05119395f, 0.00951274f, 
    -0.10115019f, -0.02294873f, -0.04772441f, -0.33785248f, -0.52487272f, 0.08806308f, 0.12056440f, -0.00936350f, 
    -0.16989714f, 0.20130554f, 0.11832638f, 0.26094285f, 0.08793202f, 0.09307390f, -0.56553406f, -0.07377531f, 
    -0.05633779f, 0.13955532f, 0.14929029f, 0.04093733f, 0.00356221f, 0.04276007f, 0.29663658f, -0.18578997f, 
    0.12868047f, -0.03865108f, -0.14030100f, 0.07992169f, 0.16852854f, -0.04757526f, 0.02204699f, -0.32749131f, 
    -0.73722541f, -0.13111836f, -0.09115263f, 0.03719572f, 0.09322517f, 0.10690732f, -0.20251729f, -0.31150505f, 
    0.03601494f, 0.05908559f, 0.03393515f, 0.07630274f, 0.04366850f, 0.02907480f, -0.01662564f, 0.01761560f, 
    0.01670931f, -0.05097615f, -0.00454250f, 0.12209459f, 0.00416404f, -0.08905004f, -0.08488425f, -0.26216459f, 
    -0.19526008f, -0.07332359f, -0.01558338f, 0.01088441f, 0.06244392f, -0.01040501f, -0.09813058f, -0.12601799f, 
    -0.07942107f, -0.25279894f, 0.10485151f, -0.16327688f, -0.13721798f, 0.11548835f, 0.05438091f, 0.04401314f, 
    0.10673467f, 0.18750672f, 0.00131675f, 0.23354679f, 0.30376554f, 0.05415019f, 0.14240892f, -0.11887582f, 
    -0.12619343f, 0.06593569f, 0.16513968f, -0.02020368f, 0.08228616f, -0.04021198f, 0.14937468f, -0.10102604f, 
    0.23784044f, 0.06601527f, -0.06439119f, -0.11777443f, 0.01062408f, -0.11240272f, 0.02133957f, 0.16245034f, 
    0.16624694f, 0.09597457f, 0.08159254f, -0.08149363f, -0.08898591f, 0.21231091f, -0.10123898f, -0.08327827f, 
    -0.02330013f, -0.09682345f, -0.06826814f, -0.04221336f, -0.01803986f, -0.60892957f, -0.35073385f, -0.12769818f, 
    -0.14522153f, 0.12596634f, -0.13742088f, 0.00886679f, 0.03485263f, 0.06782705f, -0.13344467f, -0.20239431f, 
    0.08935080f, 0.10402860f, -0.02209048f, 0.04208218f, -0.13254127f, -0.06839773f, -0.02770296f, -0.00840866f, 
    -0.11519161f, -0.20837252f, -0.03091100f, 0.33406627f, 0.31767571f, -0.12441703f, -0.04230724f, 0.02792454f, 
    -0.20156838f, -0.13369721f, -0.10659261f, -0.07325023f, -0.02741638f, 0.00555800f, 0.11815189f, 0.07221078f, 
    0.09623211f, 0.24198748f, 0.05246849f, -0.09300403f, -0.17511047f, 0.04371541f, -0.14147823f, -0.02549590f, 
    0.08193791f, 0.00211488f, -0.20846726f, -0.23972224f, 0.04803405f, 0.05068927f, 0.09042078f, 0.08655839f, 
    0.09055495f, 0.07879101f, 0.06966840f, -0.02057182f, 0.00173875f, -0.22552119f, -0.18003987f, -0.00133382f, 
    0.03733207f, -0.01722814f, 0.06118716f, 0.09293944f, 0.10011299f, 0.09138037f, 0.07144359f, -0.15357485f, 
    -0.10685408f, 0.18142515f, -0.08503562f, 0.15990767f, -0.03096762f, 0.10997634f, 0.15427883f, -0.03781276f, 
    -0.07407822f, -0.01485187f, -0.02787455f, -0.14048992f, -0.04975868f, -0.03583498f, -0.05202533f, -0.36848572f, 
    0.21874562f, -0.58432376f, -0.49974412f, 0.14820644f, 0.07127514f, 0.02013154f, 0.06055241f, 0.03190479f, 
    0.05180007f, -0.29161587f, -0.12139219f, -0.02310172f, -0.17349915f, 0.21615592f, 0.32887682f, 0.18607298f, 
    0.12698486f, -0.09069017f, 0.13351868f, -0.00623445f, 0.09385164f, -0.12002391f, 0.03855281f, 0.01336129f, 
    -0.23859113f, -0.14324540f, -0.26590258f, 0.19110893f, -0.05775551f, 0.33886948f, 0.05366992f, 0.16756532f, 
    0.10087965f, -0.09655268f, 0.19180720f, -0.01011359f, 0.03709828f, 0.01831519f, -0.00843446f, 0.10470705f, 
    -0.02267825f, 0.11104952f, 0.04325280f, -0.09071441f, -0.06885476f, 0.04368604f, -0.01538699f, 0.07487273f, 
    0.08984592f, -0.17228583f, -0.01463554f, 0.05628832f, 0.07243609f, 0.05167713f, 0.06079684f, -0.20191540f, 
    -0.11964281f, -0.03819093f, 0.07022470f, 0.04224737f, 0.04553344f, 0.04171912f, -0.02587239f, 0.11755940f, 
    0.01804456f, -0.04396529f, 0.19093506f, 0.05525170f, 0.06193715f, -0.13669784f, -0.06617428f, -0.08815160f, 
    -0.12143454f, 0.05194498f, 0.06447083f, 0.17170313f, 0.02874294f, -0.07822173f, 0.19630846f, 0.46899620f, 
    0.26869145f, 0.15864174f, 0.00216318f, -0.11441839f, 0.14673400f, 0.11163857f, 0.12593058f, 0.18112478f, 
    0.27283472f, -0.07567748f, 0.14518239f, 0.06890103f, -0.20257497f, 0.04855984f, -0.05093719f, 0.02292017f, 
    0.05361986f, 0.12472000f, 0.10707349f, 0.06618377f, -0.04502885f, 0.22255859f, 0.25221473f, -0.02865173f, 
    0.03546432f, -0.06138544f, -0.12780961f, 0.00707028f, 0.05794791f, -0.06881887f, -0.35052398f, -0.04967390f, 
    -0.07082804f, 0.00172530f, 0.04883987f, 0.02205950f, 0.00291341f, -0.16303021f, -0.02063959f, 0.15803555f, 
    -0.25558442f, 0.06910422f, -0.08617047f, -0.03817212f, 0.04104383f, 0.13771082f, 0.16839701f, 0.00213686f, 
    0.02651628f, -0.04065425f, -0.12143544f, -0.16025396f, -0.10030617f, -0.06927153f, -0.18545935f, -0.37889525f, 
    -0.01281958f, 0.15225303f, -0.04846689f, -0.09228909f, 0.10434617f, 0.30230230f, 0.20352933f, 0.34617284f, 
    -0.11171935f, -0.15171109f, -0.02739828f, -0.03547538f, -0.07323252f, 0.21171504f, -0.04632095f, -0.05027238f, 
    -0.18707138f, 0.13427405f, 0.20549852f, 0.20944309f, -0.02626185f, 0.11520579f, 0.11282796f, 0.04017754f, 
    -0.00701012f, 0.03340840f, 0.07039176f, 0.15209803f, 0.27141166f, -0.02580981f, -0.10049433f, 0.02105393f, 
    0.02138694f, 0.06497432f, 0.09871464f, -0.33213571f, -0.65024573f, 0.02198232f, -0.05067625f, 0.09816927f, 
    -0.16909157f, -0.07192045f, -0.04131819f, 0.16914345f, 0.01799058f, 0.04559220f, -0.12739424f, 0.20648788f, 
    0.04599369f, 0.03636952f, -0.08000248f, 0.06793674f, -0.13143142f, -0.00213181f, 0.18624669f, 0.04489733f, 
    0.03084566f, 0.02950156f, 0.09276178f, 0.07237935f, 0.09652299f, 0.04342575f, -0.04488357f, -0.15347145f, 
    0.01337148f, -0.08390635f, -0.09554283f, 0.06295080f, -0.08749308f, -0.02757746f, -0.22028746f, -0.16896814f, 
    -0.00395685f, -0.10961618f, 0.06398495f, -0.05208363f, -0.08561919f, -0.11827575f, 0.06123862f, -0.11985753f, 
    0.17120624f, 0.20134024f, 0.47120640f, 0.11219289f, 0.13085259f, 0.14794625f, 0.02411663f, 0.00657277f, 
    0.04913327f, 0.10685778f, 0.21202876f, -0.17891252f, 0.04229842f, -0.07301813f, 0.13266855f, -0.03669127f, 
    0.04873787f, 0.15947369f, 0.02566968f, -0.18222794f, -0.09469417f, -0.15489306f, -0.30127850f, -0.24730930f, 
    0.10442676f, 0.05076677f, 0.23844135f, -0.16620326f, 0.04848735f, -0.02848108f, 0.09792155f, -0.12711726f, 
    -0.06661144f, -0.01796635f, -0.13016987f, -0.14225307f, -0.08196478f, -0.02449801f, 0.04178226f, 0.01557783f, 
    0.12536657f, 0.22306529f, -0.09689717f, 0.07694584f, 0.00886910f, -0.65152711f, 0.36789751f, 0.27227786f, 
    0.16161636f, 0.06336390f, -0.15174027f, -0.11497551f, -0.04066699f, 0.01289082f, 0.01548459f, 0.23642991f, 
    0.15279500f, -0.01308710f, 0.01095384f, -0.18517146f, 0.04751039f, 0.07473232f, -0.00212445f, -0.21394794f, 
    0.08562259f, 0.03489433f, -0.14627576f, -0.08993120f, 0.06648885f, -0.01288624f, -0.03524804f, 0.16404523f, 
    -0.01819010f, -0.41826978f, -0.09010038f, 0.01528476f, 0.19749200f, -0.11411018f, 0.00497596f, -0.09211992f, 
    0.20547804f, -0.09920789f, 0.32876584f, 0.11757200f, 0.23651071f, 0.06157636f, -0.30225804f, 0.07962796f, 
    0.17514519f, -0.00874553f, -0.13859597f, -0.02899221f, 0.32975119f, -0.11114550f, -0.11256908f, -0.01103926f, 
    0.14310347f, 0.01789090f, 0.08733489f, -0.14774728f, -0.12795964f, 0.19740044f, 0.19501869f, 0.04688102f, 
    -0.00312192f, 0.12293992f, 0.23630254f, 0.07313113f, -0.19478150f, 0.01969159f, -0.17898166f, 0.07277706f, 
    0.10817763f, 0.07002825f, -0.07524190f, 0.08663622f, 0.00047603f, -0.20497136f, -0.41907009f, 0.02141332f, 
    -0.12770747f, -0.05547538f, -0.14195326f, 0.05965987f, 0.00402900f, 0.04141421f, -0.23487362f, -0.44540125f, 
    -0.03165051f, 0.06028198f, 0.03894800f, -0.06137255f, 0.03056181f, -0.08610855f, 0.07614722f, 0.10861598f, 
    -0.13874002f, 0.17257848f, 0.13586582f, 0.05581386f, 0.13695917f, 0.12003176f, 0.24060147f, -0.12650700f, 
    0.02343777f, -0.10080784f, -0.13346344f, -0.14715186f, -0.07501859f, -0.13847931f, 0.09196129f, -0.03734971f, 
    0.12675887f, 0.02326905f, -0.09408895f, -0.23897287f, 0.08688705f, 0.01565227f, -0.00448103f, 0.02111247f, 
    0.02817589f, 0.19853537f, -0.15403356f, -0.11865793f, -0.32025179f, -0.18936439f, -0.02122289f, -0.15397128f, 
    0.13081408f, -0.03102593f, 0.13588193f, 0.31619224f, 0.09955535f, -0.27478275f, -0.21698931f, -0.26592943f, 
    0.09831482f, -0.17967680f, 0.00735268f, -0.06598169f, -0.22180405f, 0.27114856f, 0.45289221f, -0.02403580f, 
    -0.17690562f, 0.12262641f, -0.08027890f, 0.03616067f, 0.04556027f, 0.07345511f, 0.04101488f, 0.14376581f, 
    0.16652796f, -0.04566178f, -0.20059580f, -0.17137673f, 0.13773258f, -0.05971179f, -0.36882052f, -0.27513051f, 
    0.27828917f, -0.03241219f, -0.01035184f, 0.14981216f, -0.05705915f, -0.09428712f, 0.06468013f, -0.08410774f, 
    0.15669718f, 0.05435497f, -0.08615538f, 0.11148186f, -0.26187190f, 0.04186220f, 0.23770720f, 0.10244545f, 
    -0.21782908f, -0.28281081f, -0.26240036f, 0.02196064f, -0.11239994f, -0.06444105f, -0.20615984f, -0.18952559f, 
    -0.14744829f, 0.13324763f, -0.08411543f, -0.30518603f, -0.02158753f, 0.00247210f, 0.09371296f, 0.15180160f, 
    0.08647252f, 0.13085958f, 0.05563603f, -0.23010962f, -0.09756561f, 0.09592054f, 0.08828483f, 0.05985588f, 
    0.12313358f, -0.15096311f, -0.14927834f, -0.68885338f, -0.49090487f, -0.17820607f, -0.26559347f, -0.00790283f, 
    0.30890283f, -0.17549838f, -0.15252778f, -0.11811489f, 0.19227822f, 0.22453484f, -0.24651033f, 0.09613898f, 
    0.10756680f, 0.09582468f, 0.19281049f, 0.10538451f, 0.17298895f, -0.03921348f, 0.20302191f, 0.20397173f, 
    0.02681506f, 0.07302874f, -0.01226273f, 0.13986573f, 0.12784980f, 0.06157361f, -0.00733199f, -0.42795166f, 
    -0.09185468f, -0.16895542f, 0.04805940f, -0.08236107f, -0.01411963f, -0.07679193f, -0.02913607f, 0.05549748f, 
    0.29194891f, 0.05525308f, -0.02033198f, -0.19144721f, -0.06537324f, 0.07350171f, 0.07674976f, 0.11426368f, 
    0.21221834f, -0.23511739f, 0.00058302f, 0.08198059f, 0.15934485f, 0.26161250f, 0.09421994f, -0.02077277f, 
    0.20297508f, -0.00865426f, -0.32934034f, -0.62140256f, 0.00824763f, 0.29294774f, 0.19464123f, 0.22092210f, 
    0.08628879f, 0.12397244f, -0.50784761f, -0.36807606f, 0.19540565f, -0.02434693f, 0.20734449f, -0.17255124f, 
    0.01651220f, 0.09732507f, -0.18425550f, 0.01998684f, 0.16898061f, 0.22057180f, -0.05522015f, -0.20909689f, 
    -0.02670996f, -0.11229480f, 0.03850793f, 0.23094977f, 0.02936999f, 0.13166875f, 0.11303510f, -0.01713727f, 
    -0.01918627f, -0.04390417f, 0.26171812f, -0.01600241f, 0.11876133f, 0.69122767f, 0.28613096f, 0.03722278f, 
    0.03648958f, 0.14790930f, 0.12320823f, 0.02174001f, -0.00036811f, 0.06894068f, -0.19772080f, -0.45558330f, 
    -0.18421499f, 0.13703306f, -0.05193693f, 0.08926348f, 0.01815445f, -0.00247323f, -0.19756469f, -0.01972500f, 
    -0.16422848f, -0.43854222f, -0.07877607f, -0.15599942f, -0.12184843f, 0.01969902f, 0.01917383f, 0.05763578f, 
    0.10603666f, -0.70429426f, -0.17498936f, -0.15212457f, -0.00124664f, -0.23358305f, 0.03104176f, 0.07052495f, 
    -0.07597338f, -0.38521779f, 0.08876563f, 0.27208686f, -0.08380233f, 0.42552918f, 0.21489508f, -0.09833860f, 
    0.20100851f, -0.01661022f, -1.00963855f, 0.10187959f, 0.10782543f, -0.04409742f, 0.44503364f, 0.03990084f, 
    0.06597555f, -0.02172840f, -0.07284912f, -0.37513727f, 0.42368385f, 0.34339374f, 0.24814087f, 0.36109364f, 
    -0.16994789f, -0.00983366f, 0.07100511f, 0.07440645f, 0.17257416f, 0.04091651f, -0.14896896f, -0.12741263f, 
    -0.08308087f, -0.01790069f, 0.14800955f, -0.17577456f, 0.06262292f, -0.25382566f, -1.03755581f, -0.60247618f, 
    -0.10679345f, 0.01237052f, 0.00732291f, -0.03924274f, -0.08576119f, -0.27251443f, -0.13237618f, -0.17175265f, 
    -0.13969932f, -0.14311767f, -0.01403013f, -0.29010352f, 0.04930682f, -0.03992742f, -0.03239854f, 0.14079311f, 
    0.32495120f, 0.35738730f, 0.17949304f, 0.03855937f, -0.08285203f, 0.33715704f, 0.16194382f, 0.12279410f, 
    -0.14970377f, 0.02916516f, -0.08564815f, -0.06461938f, -0.21847738f, -0.08383676f, 0.21299803f, 0.08660078f, 
    -0.19406565f, -0.35290071f, -0.05489242f, 0.05836608f, -0.02136506f, 0.11462016f, -0.07906744f, 0.00032263f, 
    0.05508048f, 0.07973462f, -0.58501554f, -0.95667392f, -0.02682076f, -0.23998521f, -0.00201966f, -0.14343949f, 
    -0.14169203f, 0.03605583f, -0.03982633f, 0.05512705f, -0.29298645f, -0.05135964f, 0.12426186f, -0.07433484f, 
    0.34114906f, 0.11135007f, 0.03903965f, 0.07512487f, -0.67476320f, -0.95835572f, -0.24540782f, -0.01608241f, 
    0.06640269f, 0.28788996f, -0.01813209f, -0.22172379f, -0.26877859f, -0.22082841f, 0.38442156f, -0.15663473f, 
    0.01650265f, -0.01331627f, 0.15087265f, -0.02921488f, 0.11695724f, -0.01310340f, 0.16862948f, -0.80409610f, 
    -0.75690395f, -0.03174880f, 0.28836444f, 0.28200924f, -0.10651227f, -0.03267983f, -0.01309476f, -0.17445849f, 
    0.10862415f, 0.07081392f, 0.11268422f, 0.18206893f, -0.04108877f, -0.13734397f, 0.04995539f, -0.05002290f, 
    -0.36281058f, 0.18903717f, -0.30845928f, -0.03225342f, -0.10228223f, -0.16126013f, -0.03100752f, -0.00088212f, 
    0.04302044f, 0.04570087f, 0.06268390f, 0.17818011f, -0.03059030f, 0.31249839f, 0.02341113f, 0.18825227f, 
    -0.01215478f, -0.06469488f, -0.43770897f, 0.21223944f, 0.12689261f, 0.09748469f, 0.22740662f, 0.25369018f, 
    0.12616444f, 0.12386099f, 0.30105779f, -0.13124961f, 0.16533734f, 0.62273830f, -0.29064316f, -0.25253397f, 
    -0.23994935f, -0.08312145f, 0.00887620f, -0.36899230f, -0.17331086f, -0.00811706f, 0.29004508f, 0.07021776f, 
    0.02876298f, 0.06525005f, 0.00740259f, 0.29317459f, 0.21916404f, -0.02282408f, -0.15104860f, 0.11227611f, 
    0.18584275f, -0.10254291f, 0.21374466f, -0.27158898f, 0.22472411f, 0.26003852f, 0.06220005f, -0.06670529f, 
    -0.14704978f, 0.12889579f, 0.15157081f, -0.28958061f, 0.10608372f, 0.08225036f, -0.09256338f, 0.00462421f, 
    0.06629722f, 0.20120411f, 0.09047560f, -0.13716264f, -0.45705324f, 0.09643786f, 0.05527247f, -0.03097904f, 
    0.03981038f, 0.30621913f, 0.17123097f, 0.07393607f, -0.11254403f, 0.21566311f, 0.05754938f, 0.09503650f, 
    0.24369574f, -0.43860191f, 0.10616244f, 0.28034154f, -0.00681350f, 0.04316922f, -0.03461564f, -0.03020822f, 
    0.11681096f, -0.04758453f, -0.22817379f, -0.09105396f, 0.35092121f, 0.22234286f, 0.13531062f, -0.07908978f, 
    0.19981413f, 0.16363783f, 0.11926890f, -0.20396698f, 0.13680142f, 0.06817399f, 0.08533169f, -0.03750204f, 
    -0.31513578f, 0.15217799f, -0.03727464f, 0.08599071f, -0.20773594f, -0.09471169f, 0.01109764f, 0.00756108f, 
    0.02548788f, -0.15452716f, -0.05363429f, -0.06330459f, 0.12299290f, -0.31072488f, 0.25221041f, 0.26578799f, 
    -0.12447374f, -0.20887391f, -0.39491090f, -0.02362275f, 0.09556159f, -0.00827531f, -0.58874017f, -0.24533673f, 
    -0.32508928f, 0.04662430f, 0.14795001f, 0.31221092f, 0.01640841f, 0.14941366f, -0.03485494f, -0.01979475f, 
    -0.06753243f, 0.63362581f, -0.15552659f, 0.28533119f, 0.27869260f, -0.18934757f, -0.15525576f, 0.09694384f, 
    -0.15017641f, -0.03135397f, 0.08634270f, -0.08030668f, -0.24072616f, -0.24242662f, -0.03430949f, -0.06583033f, 
    -0.04955919f, -0.23505889f, -0.18059486f, -0.08979382f, -0.07427511f, 0.07945963f, 0.07291812f, 0.05891354f, 
    -0.04235277f, 0.04747568f, 0.60342753f, -0.59927857f, 0.04492962f, -0.05731574f, 0.28759325f, -0.09674089f, 
    0.02561308f, 0.17337723f, 0.01794328f, 0.23482953f, -0.15890053f, -0.14054509f, -0.00484988f, -0.12865023f, 
    0.16165577f, 0.00237600f, 0.14008150f, 0.17893828f, -0.33358619f, -0.04137992f, -0.09274951f, -0.06812555f, 
    -0.11491915f, -0.44841170f, -0.15356131f, -0.00023294f, 0.11916793f, -0.00261968f, -0.03439030f, 0.02880088f, 
    -0.14005716f, 0.01207040f, -0.20641327f, -0.03494890f, 0.05881426f, -0.02296291f, -0.09634825f, -0.20541763f, 
    0.12298440f, -0.26806942f, -0.15181385f, -0.27573171f, -0.08075256f, -0.10087333f, 0.03359042f, 0.24640101f, 
    0.17091092f, 0.27985215f, 0.07714003f, -0.30459666f, 0.07553453f, 0.04555342f, 0.07131243f, 0.44073597f, 
    -0.09139502f, -0.40375626f, -0.11658359f, -0.14100294f, -0.09648972f, 0.01262147f, 0.25666967f, 0.12179909f, 
    -0.08959796f, -0.44672677f, 0.07258555f, 0.09141182f, -0.04551020f, -0.04824681f, -0.30572337f, 0.06640294f, 
    0.07302576f, 0.09949445f, -0.47881600f, -0.01582673f, -0.05767345f, 0.09304043f, 0.07388002f, -0.15313162f, 
    -0.00997192f, 0.16221505f, 0.12051244f, -0.93433148f, 0.24560392f, 0.12037149f, -0.07076595f, 0.06051275f, 
    -0.01148286f, 0.05551944f, -0.17433468f, -0.02532919f, -0.32121253f, 0.37871358f, -0.18312044f, -0.02293242f, 
    -0.08755045f, 0.05028329f, 0.11218810f, -0.05933698f, 0.00163931f, 0.04177020f, 0.14588922f, 0.27584407f, 
    -0.19548039f, 0.08684374f, -0.22055365f, 0.11564633f, 0.20600915f, 0.05819437f, 0.06094674f, -0.20665576f, 
    -0.20428541f, -0.11263133f, -0.05181033f, 0.05377913f, 0.14021970f, 0.13544679f, -0.14534177f, -0.29889116f, 
    0.03514088f, 0.23574029f, -0.03264283f, 0.10124166f, -0.16111717f, 0.00486132f, 0.00191725f, 0.23059030f, 
    0.03677990f, -0.04588064f, -0.03613688f, -0.02036187f, -0.05133846f, -0.03821860f, -0.05926722f, -0.05371207f, 
    -0.03212499f, 0.02679431f, 0.01804523f, 0.01709041f, 0.00460550f, 0.05069009f, -0.06221297f, -0.04379610f, 
    0.04142342f, -0.02902418f, -0.04159711f, 0.02641580f, -0.00550911f, 0.03565335f, -0.06391726f, -0.05722229f, 
    0.00200128f, -0.01980010f, -0.04808700f, -0.00806418f, -0.06402195f, -0.00226827f, -0.04218370f, 0.05383357f, 
    -0.04490227f, -0.01138898f, -0.00398066f, -0.03895350f, 0.02986987f, 0.03493805f, -0.03014396f, -0.01630404f, 
    0.01355307f, -0.06072253f, 0.01980183f, 0.03594764f, -0.02859220f, -0.02499341f, -0.02542975f, 0.01608597f, 
    0.03046407f, 0.01401426f, -0.02642751f, 0.04449786f, 0.01227633f, -0.02068303f, -0.03114439f, -0.04473497f, 
    0.05547831f, -0.01233283f, -0.00559589f, -0.05240297f, 0.04682991f, -0.03216620f, 0.05618113f, 0.03491556f, 
    -0.06455343f, 0.02085402f, -0.02623607f, -0.04865528f, -0.05379226f, 0.00597780f, -0.02400298f, -0.00120039f, 
    -0.05074383f, 0.04004872f, -0.05847809f, -0.01772503f, -0.05409919f, -0.05965470f, 0.02574673f, -0.03793645f, 
    -0.02776393f, 0.03508898f, 0.04189333f, -0.05190532f, -0.00727800f, 0.04375984f, -0.04467600f, -0.00027601f, 
    0.00669177f, 0.02096089f, 0.00498664f, 0.04468238f, -0.00159381f, 0.02422201f, 0.03791325f, -0.01748230f, 
    0.03361247f, -0.04465884f, -0.01912503f, -0.02880258f, -0.02111869f, -0.06259512f, -0.04903324f, -0.04766528f, 
    0.05111357f, -0.06275661f, 0.02649946f, -0.01030784f, -0.05500333f, 0.01005082f, 0.00715627f, 0.04018755f, 
    -0.05366240f, 0.01637704f, -0.00003486f, 0.00817583f, 0.01730421f, 0.02606570f, -0.00461706f, 0.00557247f, 
    -0.00310750f, -0.06431755f, 0.03133890f, 0.01890326f, 0.01499324f, 0.01118894f, -0.01639932f, 0.02771297f, 
    -0.00059544f, 0.03473680f, -0.04986632f, -0.04412502f, -0.05563080f, -0.04455775f, 0.00030129f, -0.01191439f, 
    -0.00351631f, -0.04920562f, -0.00888991f, 0.01608245f, 0.02308093f, 0.04973328f, 0.04590824f, 0.03636991f, 
    -0.03679640f, -0.03735711f, 0.04190995f, 0.02439550f, 0.01812592f, 0.03768685f, 0.02619234f, -0.02499703f, 
    0.02552217f, -0.03863868f, 0.03450183f, -0.05614764f, -0.03180423f, 0.03414485f, -0.02318492f, -0.00875307f, 
    0.01507712f, -0.05847403f, -0.03571850f, -0.03569316f, -0.01296288f, -0.01008128f, 0.04035442f, -0.03972533f, 
    0.04352390f, 0.03065496f, 0.02583445f, -0.03111838f, 0.04031645f, -0.02595393f, -0.02760049f, 0.04486050f, 
    -0.04155762f, -0.02752336f, -0.02792369f, 0.02421648f, 0.02050740f, -0.00950887f, -0.00090648f, -0.00887070f, 
    0.00812757f, 0.01701347f, 0.01124516f, -0.02727036f, -0.01294235f, 0.04703039f, -0.02741835f, -0.00809843f, 
    -0.04929008f, -0.04419363f, 0.02954614f, 0.03955689f, -0.02341991f, 0.02461241f, -0.05095672f, -0.02225709f, 
    0.05245479f, -0.04860381f, 0.03000772f, -0.04676317f, -0.00611189f, 0.04717721f, 0.03488474f, 0.03849736f, 
    0.04739027f, -0.01137663f, -0.02475278f, -0.04049834f, -0.03496131f, 0.01258880f, -0.03590981f, -0.04197239f, 
    0.01760734f, -0.04394207f, -0.06162643f, 0.00136827f, 0.01701212f, 0.04718934f, -0.01379617f, 0.04810907f, 
    -0.02983671f, 0.05539350f, -0.04042938f, -0.05970353f, -0.02645437f, -0.02266905f, -0.02538385f, -0.00352727f, 
    -0.05036484f, 0.04628549f, -0.01930409f, -0.04258509f, -0.03157756f, 0.03928597f, 0.00689921f, -0.02470252f, 
    -0.04344005f, -0.01678214f, -0.00121698f, -0.00156269f, -0.00962694f, 0.02229683f, 0.02948911f, -0.04464163f, 
    0.00142050f, 0.01406108f, -0.01875659f, 0.00832188f, -0.04312734f, 0.03560514f, 0.03719696f, -0.06161947f, 
    -0.06055136f, 0.05515695f, -0.05933610f, -0.04850239f, -0.04193250f, 0.04915542f, -0.00702977f, -0.05694399f, 
    -0.00994851f, -0.02494096f, 0.01836973f, -0.03439790f, 0.05163937f, -0.05955849f, 0.04391732f, -0.01680784f, 
    -0.03323508f, -0.03125366f, 0.01566097f, 0.00794097f, 0.03079226f, -0.00256764f, -0.03106451f, 0.03808111f, 
    -0.01019715f, 0.01063489f, -0.05549676f, -0.00636897f, -0.04184254f, 0.00658219f, -0.01328125f, 0.04246721f, 
    0.01882966f, -0.61237872f, -0.01502393f, 0.27660847f, 0.13597091f, 0.15637723f, 0.02801556f, 0.05034053f, 
    0.18565683f, 0.27418187f, 0.09112936f, 0.04791432f, 0.06498791f, 0.06835443f, 0.04400824f, -0.10676616f, 
    -0.24679409f, -0.23886719f, -0.40703705f, -0.20375863f, -0.27327487f, 0.04998267f, -0.05923315f, 0.03071473f, 
    -0.04254022f, -0.10842567f, 0.06795523f, 0.21396691f, 0.15757832f, -0.12257247f, 0.02689588f, 0.04910091f, 
    -0.08403998f, -0.03942869f, 0.15911737f, 0.13544083f, -0.27848166f, -0.18102008f, 0.05198825f, 0.11076945f, 
    -0.17350350f, -0.11652532f, -0.00278977f, -0.16585727f, 0.06749371f, -0.24415129f, -0.17361261f, -0.36910540f, 
    -0.23125678f, -0.15739384f, -0.14716016f, 0.02163178f, 0.18528552f, -0.17576145f, 0.21313837f, -0.07936615f, 
    -0.11249565f, 0.12246810f, 0.05482281f, 0.06955598f, -0.09275389f, -0.12187112f, -0.01235482f, -0.18311018f, 
    -0.29558271f, 0.24628036f, 0.13533071f, -0.28421611f, -0.05894697f, 0.01959671f, -0.31724072f, -0.22085619f, 
    0.06292149f, 0.01750895f, 0.15020113f, 0.07249001f, 0.11604539f, -0.08697231f, -0.16948166f, -0.03877401f, 
    -0.02943567f, 0.56370223f, 0.34191236f, -0.02646165f, 0.06012936f, 0.06033863f, -0.14493483f, 0.12491059f, 
    0.08263895f, -0.16312873f, 0.14377381f, 0.31877363f, 0.21235591f, -0.03243307f, -0.08870679f, 0.08584543f, 
    0.12037426f, -0.05636849f, -0.16690557f, 0.03312122f, -0.03110517f, 0.09811036f, 0.03651923f, -0.17825273f, 
    -0.21948348f, 0.08454664f, -0.26749536f, -0.25609377f, 0.04523331f, -0.30048925f, -0.48650706f, -0.00747841f, 
    0.06140456f, 0.05765802f, -0.22745562f, -0.08716767f, 0.14134939f, -0.60178310f, -0.12656668f, 0.37115732f, 
    -0.10746864f, -0.08975150f, -0.25486264f, 0.14338714f, -0.12196823f, -0.06939197f, 0.12872018f, -0.01727833f, 
    -0.24403216f, 0.18334413f, 0.07469655f, 0.05811171f, -0.07893707f, -0.04906458f, -0.04617523f, -0.44018474f, 
    -0.21785998f, -0.04791695f, -0.16239373f, 0.03739189f, 0.18930723f, -0.04294763f, -0.35356963f, -0.13276799f, 
    0.45237380f, 0.27200761f, 0.40971348f, 0.06456479f, -0.17625076f, -0.01132378f, -0.04152284f, -0.10398395f, 
    0.03014235f, -0.16513909f, -0.26680255f, -0.28237042f, -0.12274431f, -0.04722634f, 0.16116990f, 0.02490223f, 
    0.02994831f, -0.10753318f, 0.11390582f, 0.11157468f, -0.36420387f, -0.00804090f, -0.05572498f, -0.21350975f, 
    -0.01056851f, 0.02971777f, -0.00584091f, -0.30195257f, -0.14563899f, 0.14583915f, -0.10391504f, -0.25756240f, 
    -0.07329846f, 0.04208634f, 0.10387198f, -0.01482684f, 0.21050848f, -0.22222149f, -0.20701738f, 0.03681454f, 
    -0.05208127f, 0.11939090f, -0.05507162f, 0.04643296f, 0.20928372f, 0.32340446f, 0.26680630f, 0.08962601f, 
    0.31317821f, -0.07269423f, 0.05862826f, -0.04822326f, 0.01188708f, -0.15921247f, 0.42253134f, 0.25014001f, 
    0.32828537f, -0.03889138f, 0.00463933f, 0.01051728f, -0.05420570f, -0.22800437f, -0.02017257f, -0.10057119f, 
    -0.61677223f, -0.01074429f, 0.02633704f, -0.06922943f, 0.02275274f, 0.08861179f, 0.00043670f, 0.05852208f, 
    0.05184372f, 0.10433796f, -0.19866236f, 0.09640867f, 0.17155401f, -0.07365114f, -0.01965228f, 0.04365937f, 
    0.36886424f, 0.31819350f, 0.39053717f, 0.18032774f, -0.06823588f, -0.04689350f, 0.02361679f, -0.01748325f, 
    -0.15649427f, -0.02301022f, 0.57964784f, 0.55810881f, 0.19934160f, 0.05736521f, -0.21870862f, -0.14201361f, 
    -0.00969212f, 0.02568520f, -0.02907434f, 0.32367277f, 0.05451400f, 0.19856080f, 0.04650446f, 0.03144599f, 
    -0.05863555f, 0.05344801f, 0.11402673f, 0.08515952f, -0.09779335f, -0.43893927f, 0.16335885f, 0.22121614f, 
    0.35453930f, 0.12090930f, 0.01532955f, -0.07253937f, -0.01582146f, -0.31438267f, -0.23504122f, 0.16757971f, 
    0.23577651f, -0.09783478f, 0.01210960f, -0.11829433f, -0.07212777f, 0.18438876f, 0.26280943f, -0.01237993f, 
    0.02938012f, 0.13293594f, 0.10888500f, -0.07068446f, -0.04000528f, 0.00478667f, 0.05740181f, -0.18177356f, 
    -0.10428697f, -0.14847323f, -0.07300235f, 0.15151313f, 0.00780021f, -0.04395933f, 0.34132949f, 0.13086347f, 
    -0.45579621f, -0.11920384f, 0.23876876f, -0.21931069f, 0.01820686f, -0.20254086f, 0.07475028f, -0.14402474f, 
    -0.04038194f, 0.02737722f, 0.00656170f, 0.19400641f, 0.19362962f, -0.04437239f, 0.32293627f, 0.05708166f, 
    0.04963407f, 0.19133663f, 0.02756360f, 0.04916104f, -0.23340696f, 0.02575820f, 0.13252023f, 0.06536009f, 
    0.09786315f, 0.08496850f, 0.10703036f, -0.20526804f, -0.04319669f, 0.49593258f, 0.14143141f, -0.19758616f, 
    -0.04351198f, 0.03364684f, -0.14357285f, 0.03797445f, 0.17435633f, 0.07317842f, 0.12623018f, -0.11225335f, 
    0.08157983f, 0.10677725f, -0.12096091f, 0.13172509f, -0.15609217f, 0.40612853f, 0.08401220f, -0.10144377f, 
    0.08320136f, -0.12698482f, -0.05893365f, -0.04322399f, 0.13295020f, 0.05729918f, -0.22066359f, 0.05558034f, 
    0.11205240f, -0.09104139f, 0.05875465f, 0.08655018f, 0.11017435f, 0.09543545f, 0.16472231f, 0.08001861f, 
    0.10258780f, -0.05629073f, 0.08038740f, -0.07986235f, -0.05296487f, 0.08988715f, -0.08977627f, 0.02525173f, 
    -0.17929864f, -0.18360828f, 0.25443056f, 0.11907787f, 0.13027573f, 0.19447222f, -0.00674630f, 0.15471633f, 
    0.05546436f, -0.29149351f, -0.16651025f, -0.18164408f, 0.00966575f, 0.08939636f, -0.16886385f, 0.12979576f, 
    -0.01285231f, 0.16292764f, -0.12021983f, 0.03102602f, -0.21353590f, -0.17495404f, 0.15669993f, 0.22064479f, 
    0.14405188f, -0.11879940f, -0.04108499f, -0.10086139f, 0.06465216f, 0.01500851f, 0.00951649f, -0.07446054f, 
    -0.05535445f, 0.04212518f, 0.04195768f, 0.11377807f, 0.08121622f, 0.16898294f, 0.02303943f, 0.00866684f, 
    0.04825940f, -0.01113273f, -0.00585222f, 0.00519249f, 0.00045374f, 0.21265066f, -0.99017066f, 0.16376197f, 
    -0.16899411f, -0.07901777f, -0.28865322f, -0.02070556f, 0.01969536f, 0.03894685f, -0.25377649f, -0.09494095f, 
    -0.09518185f, 0.16381176f, 0.17960835f, -0.03783396f, -0.04072064f, 0.07705049f, -0.04640008f, -0.18043013f, 
    -0.39079061f, -0.70646137f, -0.07908358f, -0.15392293f, -0.23303410f, -0.03289529f, -0.09451003f, 0.13306364f, 
    -0.25770637f, 0.00758257f, -0.33232415f, -0.27910104f, 0.06691100f, -0.23095118f, 0.02078339f, -0.07377174f, 
    -0.11967247f, 0.11585195f, -0.57796550f, -0.04322263f, -0.03316085f, 0.03920278f, 0.08584663f, 0.08700157f, 
    0.02091466f, 0.09798791f, 0.54312092f, -0.19317250f, -0.01384226f, 0.08839840f, -0.00698140f, 0.21894652f, 
    0.11896627f, -0.03205216f, 0.34812844f, 0.57584864f, 0.04479787f, -0.02625943f, 0.12822142f, 0.07359281f, 
    0.10317482f, 0.15078565f, -0.08110213f, -0.03199708f, 0.15565868f, 0.10632674f, -0.02041055f, -0.15309536f, 
    -0.02699488f, -0.09946734f, 0.06588329f, -0.01548778f, 0.00356307f, -0.04180629f, 0.02281998f, 0.22931097f, 
    0.04796393f, 0.11977091f, 0.03979246f, 0.07143738f, -0.02734114f, 0.15266769f, -0.17313194f, 0.01642150f, 
    -0.15971453f, 0.04994075f, 0.04720110f, -0.18588786f, 0.04336461f, 0.06271735f, 0.04998575f, 0.45750383f, 
    0.13027193f, 0.22172543f, 0.11957072f, 0.04977967f, -0.01410745f, 0.00182564f, -0.05189242f, -0.26677099f, 
    0.00934800f, -0.11809570f, -0.10774917f, 0.17418265f, -0.15113804f, 0.06415781f, -0.13428541f, 0.20369388f, 
    0.01755387f, -0.21039471f, -0.18528689f, 0.12392572f, 0.04919213f, -0.08111565f, 0.03489693f, 0.09770201f, 
    0.00043579f, -0.04063543f, -0.41253850f, 0.08446096f, -0.16456304f, 0.03821538f, -0.01163165f, -0.01911883f, 
    -0.10255215f, 0.03735200f, -0.05844552f, -0.45308369f, -0.35096136f, -0.74486035f, 0.02533258f, 0.02770730f, 
    0.20765781f, 0.17619577f, -0.05127198f, -0.00240075f, -0.01310974f, -0.17632097f, -0.17687067f, -0.16550843f, 
    -0.01159177f, 0.16941710f, -0.11452567f, -0.03738144f, -0.02992292f, 0.12579796f, -0.20379168f, -0.02718569f, 
    0.09589801f, -0.07003296f, 0.02869662f, -0.12652704f, -0.04432867f, 0.00515388f, 0.09139930f, 0.24484268f, 
    0.42799202f, 0.12377356f, -0.05404187f, 0.18053290f, 0.13396844f, 0.04888226f, 0.17681590f, -0.07504003f, 
    -0.32607332f, -0.16967459f, -0.00176384f, -0.04209296f, -0.17114976f, 0.07603952f, 0.01754625f, -0.11391324f, 
    -0.06458540f, -0.29066914f, 0.00779663f, -0.03560840f, 0.13722453f, 0.05750085f, -0.09904219f, -0.21603018f, 
    -0.14213523f, -0.16695879f, 0.07337350f, -0.06408474f, 0.00969857f, -0.02284095f, 0.12967469f, -0.10879278f, 
    -0.32271901f, -0.55140448f, 0.04801905f, -0.11352625f, 0.00050930f, -0.29960001f, -0.08242118f, -0.05322260f, 
    0.05717343f, 0.05113386f, 0.13450247f, 0.38092199f, 0.48685223f, -0.12582718f, 0.21610090f, -0.01997616f, 
    -0.04891615f, 0.03202712f, -0.07115522f, 0.15133746f, 0.14390197f, 0.06087957f, -0.08869168f, 0.10548408f, 
    -0.02779791f, 0.06623790f, -0.34702802f, -0.07561666f, -0.09188958f, 0.02841235f, -0.02523270f, 0.03343281f, 
    0.20152056f, 0.05485944f, -0.03645425f, -0.15284902f, -0.17970984f, 0.14752795f, -0.12668400f, 0.02141561f, 
    -0.00300762f, 0.09458560f, 0.02493840f, 0.01932761f, -0.22784014f, -0.35865301f, -0.34703314f, -0.06141945f, 
    -0.00005353f, -0.06438022f, -0.08642343f, 0.04453951f, 0.00547242f, -0.16743821f, -0.20740440f, -0.32327291f, 
    -0.10660368f, 0.13123132f, 0.07622349f, -0.04605499f, 0.02684269f, 0.00387910f, 0.08567008f, -0.02039815f, 
    -0.33961922f, -0.22337164f, 0.05211963f, -0.07178123f, 0.26237184f, -0.05472255f, 0.25180227f, -0.00840200f, 
    -0.10208216f, -0.25191665f, 0.02946353f, 0.23536295f, 0.21649802f, -0.19642875f, 0.18475150f, 0.06755018f, 
    0.03771462f, 0.24502382f, -0.10396895f, -0.14944488f, -0.01666990f, -0.10719150f, 0.01206521f, 0.00988488f, 
    0.05249912f, -0.43632439f, -0.29490459f, -0.44257230f, -0.03559769f, -0.08666390f, -0.08911606f, 0.18321320f, 
    0.05089768f, 0.00393369f, -0.10732260f, -0.08835004f, -0.02112845f, -0.26516706f, -0.43131757f, -0.02014397f, 
    0.07763007f, 0.12242424f, 0.07147676f, -0.10066977f, 0.17187856f, -0.25532916f, 0.11716889f, -0.06473036f, 
    0.08179267f, -0.18257447f, -0.24534141f, -0.19996734f, 0.04240836f, 0.18914489f, 0.13981849f, 0.07612860f, 
    0.17210586f, 0.21435143f, 0.14980330f, 0.18030402f, 0.09610616f, -0.51002067f, 0.11678378f, -0.17223237f, 
    0.32648793f, 0.37361109f, 0.15421924f, 0.11893201f, 0.28106776f, 0.11874302f, 0.10800110f, 0.10997111f, 
    -0.41601065f, 0.14388525f, 0.35483700f, 0.05135946f, 0.08190106f, 0.23248425f, 0.15337771f, -0.07233692f, 
    0.12249002f, -0.05677169f, 0.18219759f, 0.09994861f, 0.04867351f, -0.01783287f, 0.18326592f, -0.16371574f, 
    -0.10415345f, -0.39600581f, -0.15353394f, 0.10033209f, 0.26034304f, 0.19744171f, 0.13031976f, 0.12359069f, 
    0.00065996f, -0.04315193f, -0.08434708f, 0.19715293f, 0.06637564f, -0.06453042f, -0.00927754f, 0.09743897f, 
    0.13591179f, 0.02871745f, -0.14867374f, -0.12965637f, -0.04380264f, 0.12231981f, 0.31011558f, 0.02102339f, 
    -0.13454378f, -0.06833595f, -0.00896484f, -0.02603026f, 0.10682920f, 0.14661488f, 0.24544632f, 0.44490013f, 
    -0.07975504f, 0.05531348f, 0.14805385f, 0.03810011f, 0.15459350f, 0.02091838f, -0.31695652f, 0.02033350f, 
    -0.07132389f, -0.07327233f, 0.05008128f, 0.30336362f, -0.04903363f, -0.13325441f, -0.31372082f, -0.11532009f, 
    0.05331031f, 0.10020596f, -0.01370148f, 0.24672951f, -0.03629553f, -0.10553481f, 0.26796445f, 0.31083828f, 
    0.06949230f, -0.01700292f, 0.35928866f, 0.25461510f, 0.14775980f, 0.15655173f, 0.14200737f, 0.09818701f, 
    -0.06271507f, -0.14521870f, 0.09585962f, 0.22752658f, 0.11331309f, -0.03201097f, 0.03173904f, 0.13047253f, 
    0.10017052f, 0.06613248f, 0.06583388f, -0.00731257f, 0.13781337f, 0.22054031f, 0.21025288f, 0.14060566f, 
    0.23251344f, -0.40618655f, 0.01302417f, -0.31492576f, -0.01341054f, -0.05202492f, -0.13574071f, -0.02217374f, 
    -0.05349313f, -0.03860502f, -0.06778525f, -0.03689612f, 0.12586041f, -0.03588644f, 0.15142660f, 0.13895625f, 
    0.09903745f, 0.02400738f, 0.10652647f, -0.01303707f, -0.09366161f, -0.30050549f, 0.10111711f, 0.00665644f, 
    -0.34102517f, -0.01465806f, 0.08072709f, -0.03130088f, 0.03577044f, -0.09084179f, -0.05396466f, -0.04081263f, 
    0.10513218f, 0.24551950f, 0.06104763f, 0.04122582f, 0.24803531f, -0.00580305f, 0.32824153f, 0.20919873f, 
    0.02889960f, -0.02844787f, 0.01081403f, -0.02516662f, -0.05920589f, -0.01725722f, 0.02210635f, -0.03698642f, 
    -0.00929642f, -0.02266366f, -0.00536352f, -0.04846356f, -0.06014134f, 0.01627853f, 0.03204273f, -0.05350669f, 
    0.05337096f, 0.02919879f, 0.02691814f, -0.00310600f, 0.01724988f, -0.05432005f, 0.02628835f, 0.03229714f, 
    -0.05894549f, 0.00834648f, -0.03593331f, -0.05257577f, -0.00507173f, 0.04709281f, 0.02144568f, -0.00687677f, 
    0.03253508f, 0.03370075f, -0.05897672f, 0.01888063f, -0.06719596f, -0.00481722f, 0.03998365f, -0.02403119f, 
    -0.02356886f, 0.01778545f, -0.05813575f, -0.02831319f, 0.04552978f, 0.03439454f, -0.01435746f, -0.04933856f, 
    -0.03381476f, -0.00634481f, 0.03988162f, 0.04572826f, -0.05773235f, -0.05406394f, -0.05321391f, 0.02907748f, 
    0.03151440f, -0.02337968f, 0.02990299f, -0.04189849f, 0.00766364f, -0.05929560f, 0.00121223f, -0.00414986f, 
    -0.01574451f, -0.05773544f, 0.03088210f, 0.03511815f, 0.03964698f, 0.05300409f, 0.03049565f, -0.03948198f, 
    -0.01262400f, 0.01001146f, 0.01710667f, -0.00443001f, -0.03767988f, -0.05541508f, -0.01203450f, 0.03814252f, 
    -0.00308214f, -0.00587556f, 0.00745543f, 0.03108319f, -0.02558926f, 0.02937211f, -0.05899783f, 0.03788925f, 
    -0.01508958f, -0.03465350f, 0.01127352f, -0.03418121f, -0.06106797f, 0.03888927f, 0.01179679f, -0.01279199f, 
    0.03953744f, -0.06102237f, -0.03431506f, -0.03435624f, 0.04119112f, 0.01751580f, -0.04683039f, -0.00889973f, 
    0.01606794f, -0.00943810f, -0.05809692f, 0.00746723f, -0.04733523f, -0.06908457f, 0.04070154f, 0.01529480f, 
    -0.02949967f, -0.01457759f, -0.00046624f, -0.05669411f, 0.01807882f, 0.01619587f, 0.03143723f, -0.03802453f, 
    0.00132939f, 0.01148448f, 0.03846249f, -0.06575952f, 0.02469326f, 0.04798968f, -0.05592844f, -0.01662454f, 
    0.02223935f, -0.05368590f, -0.01579526f, 0.01016632f, -0.01664975f, -0.02345738f, 0.00962658f, -0.01614357f, 
    -0.06847420f, -0.04493212f, -0.04304855f, 0.02691934f, 0.03535198f, -0.02227019f, -0.02689686f, -0.05589437f, 
    0.00324899f, 0.00951924f, -0.01959425f, 0.02529625f, -0.04569102f, 0.00853414f, 0.01525756f, 0.03636264f, 
    0.02554169f, 0.02515764f, 0.03238041f, 0.03672377f, 0.03007665f, -0.04576124f, 0.00214763f, 0.02329987f, 
    -0.02678210f, -0.03657674f, -0.06035528f, 0.03060080f, -0.05005907f, -0.05661992f, 0.01986365f, 0.03015939f, 
    -0.01436304f, 0.01444625f, -0.02538655f, 0.01748304f, 0.01632116f, -0.06728493f, 0.02133605f, 0.01080586f, 
    -0.06661441f, -0.05638342f, 0.03554802f, 0.00014258f, 0.00821504f, 0.04033760f, 0.02077732f, -0.06196183f, 
    -0.02462223f, -0.04809675f, 0.00877308f, -0.00316800f, 0.00776524f, -0.00384142f, 0.02266669f, -0.00305509f, 
    -0.03202311f, -0.01034397f, -0.02927202f, 0.02206559f, 0.02506071f, -0.01879815f, -0.04326563f, 0.01638136f, 
    0.02287531f, -0.06748747f, -0.01757784f, -0.05390218f, 0.04714053f, 0.03330747f, 0.00664091f, 0.03334982f, 
    -0.02599464f, -0.03379238f, 0.00938694f, -0.01493227f, 0.03441378f, -0.05454867f, 0.04687225f, 0.04641157f, 
    0.01940309f, -0.01098524f, -0.00839186f, 0.01404646f, -0.02649084f, -0.06602455f, -0.05267534f, -0.05595209f, 
    -0.03981091f, 0.00999718f, -0.00627019f, -0.04550426f, -0.05471233f, -0.04262356f, -0.03114601f, -0.01960422f, 
    -0.04364152f, -0.01376881f, 0.02148725f, 0.01347136f, -0.00249714f, -0.05788212f, 0.01741702f, -0.01373103f, 
    -0.01881215f, 0.02276467f, 0.00016487f, -0.02346369f, 0.05450090f, -0.02843447f, 0.03019835f, -0.03880939f, 
    0.04331997f, -0.04899712f, 0.02928621f, -0.04404182f, -0.04542813f, -0.03719137f, -0.05706750f, 0.02320648f, 
    -0.02851674f, -0.00118337f, 0.01146738f, -0.03628046f, -0.03893891f, -0.02782330f, -0.03954728f, -0.06612902f, 
    -0.02437198f, 0.04252283f, -0.00867451f, 0.05220192f, -0.03774874f, -0.03775067f, 0.04628269f, -0.01934575f, 
    -0.00644751f, 0.00269921f, -0.05560606f, -0.01002753f, 0.01908057f, -0.02211660f, 0.00609060f, 0.03479957f, 
    -0.04894724f, 0.01686126f, -0.00509921f, 0.03556127f, 0.02828056f, 0.00618706f, 0.02084406f, -0.04788664f, 
    -0.32649145f, 0.13043268f, 0.04772346f, -0.01339667f, -0.36898562f, -0.21818128f, -0.11547631f, -0.07618670f, 
    0.13970684f, -0.10727630f, 0.04175501f, 0.09556990f, 0.01771414f, 0.11724688f, -0.01189936f, 0.09255825f, 
    -0.08261023f, 0.11069464f, -0.24119934f, 0.03254998f, 0.09573522f, 0.15802076f, 0.02292749f, -0.01638709f, 
    0.01488849f, 0.18784839f, 0.03618114f, 0.03453317f, 0.07317290f, 0.26837128f, -0.05069022f, 0.06607591f, 
    0.03059712f, 0.07549401f, 0.18179005f, 0.08215308f, -0.19919872f, -0.08380169f, 0.06339869f, -0.16234466f, 
    0.06633472f, -0.26350021f, -0.07357415f, -0.14907405f, 0.19786052f, -0.29258266f, -0.05956424f, -0.05032963f, 
    0.11155700f, -0.54743189f, 0.00989713f, -0.07278901f, -0.01743052f, 0.04888939f, -0.12091196f, 0.01917236f, 
    0.08718917f, 0.07448079f, 0.04495984f, -0.11628524f, 0.05090348f, -0.16789457f, 0.11481014f, -0.25074089f, 
    -0.12454849f, 0.01727426f, -0.18631421f, 0.08271747f, -0.06544401f, 0.22558841f, -0.23028453f, 0.02006118f, 
    -0.06746649f, 0.19366539f, 0.12318385f, 0.01311237f, -0.02333085f, -0.05325209f, 0.05817634f, 0.07739764f, 
    0.10179996f, -0.15628438f, 0.13003139f, -0.25494292f, -0.07922120f, 0.08440743f, -0.06663868f, -0.05101370f, 
    -0.05166942f, -0.03777130f, 0.02363823f, 0.07959974f, 0.39432305f, 0.01682344f, 0.12854557f, 0.13329093f, 
    -0.09222773f, 0.02263786f, 0.20037106f, -0.24192154f, 0.00146156f, 0.02837873f, -0.04120756f, 0.05715701f, 
    0.00215064f, 0.06542649f, -0.03723615f, 0.00888364f, -0.23834044f, -0.04644317f, -0.10121524f, -0.12345852f, 
    -0.02764638f, 0.02363255f, 0.06107162f, 0.01173399f, -0.10728443f, -0.72384554f, -0.40339285f, -0.01494398f, 
    -0.04801461f, -0.06889789f, -0.03924375f, 0.04250010f, -0.10978853f, 0.21932113f, -0.14078452f, 0.00036433f, 
    0.07520767f, 0.17988729f, 0.05787299f, 0.21015723f, 0.17040399f, 0.00717611f, 0.04170227f, -0.17731299f, 
    -0.11346449f, -0.08093935f, -0.04805383f, 0.02853722f, 0.00613182f, 0.14085692f, 0.11891996f, -0.28554416f, 
    -0.10179879f, 0.18271340f, 0.26988003f, -0.01775843f, -0.10393575f, -0.04408234f, 0.17426467f, 0.17111760f, 
    -0.12130969f, -0.28487617f, -0.25006834f, 0.20016931f, 0.02774677f, 0.41792077f, 0.01256992f, -0.04988632f, 
    0.09802991f, -0.05663614f, 0.09133230f, -0.32204527f, 0.11293276f, -0.04068387f, -0.23574588f, -0.21725677f, 
    -0.09664548f, -0.07082154f, 0.20826259f, -0.09298154f, 0.14005141f, 0.06954912f, -0.08963708f, -0.07796076f, 
    0.13226585f, -0.04926080f, 0.06860065f, 0.10173680f, -0.28979635f, -0.03231524f, -0.02178424f, -0.23985180f, 
    0.04111066f, -0.07302519f, -0.00947305f, 0.04292087f, 0.05225997f, 0.05517135f, 0.08627148f, 0.24927965f, 
    -0.00255070f, 0.10272650f, 0.11414713f, 0.13982236f, 0.08911767f, 0.17246832f, -0.10049399f, 0.09848191f, 
    0.46172890f, 0.04940733f, 0.01877310f, 0.04947127f, 0.06305253f, 0.15701397f, -0.14625186f, 0.07094987f, 
    0.28533071f, -0.00233215f, 0.12485410f, -0.17187789f, -0.22642501f, 0.02249737f, 0.14306293f, 0.16482244f, 
    -0.10276677f, -0.27861878f, -0.03504495f, 0.18331748f, -0.08877023f, 0.05847497f, 0.02927904f, -0.12901451f, 
    0.14254236f, 0.04282104f, 0.08952177f, 0.25507852f, -0.03182831f, 0.13083892f, 0.13142890f, 0.08780132f, 
    0.01364401f, 0.07174684f, -0.05637008f, -0.07111487f, 0.32115889f, 0.03308231f, 0.01254090f, 0.16898350f, 
    0.04793967f, 0.00434661f, 0.03227186f, -0.29814830f, -0.04202824f, -0.23211405f, 0.08906139f, 0.01503662f, 
    -0.09749068f, 0.16439772f, 0.06920219f, 0.11831211f, -0.18503125f, 0.10406673f, 0.45285007f, -0.01167844f, 
    -0.17206080f, -0.12499525f, 0.08433662f, 0.06651845f, -0.01645627f, -0.26062128f, -0.14855245f, 0.06904580f, 
    -0.19544664f, 0.05149069f, -0.03417844f, 0.09697017f, -0.01875983f, -0.09562404f, -0.07262161f, -0.14111015f, 
    0.26076949f, -0.00301514f, 0.03251056f, -0.07335386f, 0.14824653f, -0.06052804f, 0.15534154f, -0.46763456f, 
    -0.24907863f, -0.04368008f, 0.00865192f, -0.17940621f, 0.06367397f, -0.16468997f, -0.07279298f, 0.18646325f, 
    -0.02853118f, -0.04820747f, -0.02006727f, 0.04032592f, -0.00660740f, 0.01842332f, -0.04299752f, -0.05760257f, 
    -0.06146206f, -0.00639530f, -0.00716235f, -0.03925274f, 0.04035376f, 0.03546374f, -0.00778812f, 0.00557829f, 
    -0.04375841f, 0.04543969f, -0.04547918f, 0.02981835f, -0.00314391f, 0.04031768f, 0.03589043f, -0.01523722f, 
    0.00795988f, 0.00075094f, -0.02942565f, -0.00909665f, 0.01463750f, -0.03146547f, 0.03445124f, -0.02167159f, 
    -0.02974736f, -0.04707807f, 0.02407095f, 0.00788002f, 0.00198818f, -0.03616710f, -0.03145094f, 0.03175988f, 
    -0.01473626f, -0.03600869f, 0.02916447f, -0.02715638f, 0.04646466f, 0.04148456f, -0.00232975f, -0.00543077f, 
    -0.04781324f, -0.00095954f, 0.03586878f, -0.04513160f, -0.06269065f, 0.03743485f, 0.00799004f, 0.04683705f, 
    -0.06267019f, 0.00575287f, 0.03871967f, 0.00920050f, -0.01996678f, -0.00207603f, 0.01322903f, -0.03905113f, 
    -0.01263340f, 0.01333772f, 0.02039986f, -0.04458034f, -0.02313649f, 0.00565414f, -0.06499604f, -0.01747817f, 
    -0.02131027f, -0.04749715f, 0.00212748f, 0.00706056f, -0.01729968f, -0.02997656f, -0.00728711f, -0.05816825f, 
    -0.05666137f, -0.05405059f, -0.04514819f, -0.05469446f, -0.01477075f, -0.04490764f, 0.03076894f, -0.03135386f, 
    -0.03329504f, -0.05919996f, -0.02539843f, 0.01647353f, 0.03542864f, 0.01350486f, -0.05570146f, -0.06362887f, 
    0.02093866f, -0.05230977f, -0.03318641f, 0.04520015f, -0.02629292f, 0.00012613f, -0.05615157f, -0.00129458f, 
    -0.06228000f, -0.01468733f, -0.03988378f, -0.06435433f, -0.02835369f, -0.02887793f, 0.01296363f, 0.01361900f, 
    -0.02390320f, 0.04511260f, -0.03638627f, -0.05929967f, 0.00166088f, 0.03773828f, 0.02016930f, -0.04442358f, 
    -0.03408629f, 0.05087367f, -0.03961081f, 0.01800898f, -0.05702000f, 0.02159792f, -0.05180432f, -0.05265782f, 
    -0.00513995f, -0.04766951f, 0.00857099f, 0.02412106f, -0.06093338f, 0.02381062f, -0.00642173f, -0.03614500f, 
    -0.02180624f, 0.00632784f, -0.04025918f, 0.00111253f, -0.00196978f, 0.01273471f, -0.00226671f, 0.02943563f, 
    -0.06635498f, -0.00830487f, -0.01635306f, 0.02896604f, 0.00613927f, -0.03709858f, -0.00304808f, -0.01197387f, 
    -0.01661745f, -0.02344835f, -0.04111379f, -0.03019134f, 0.02128484f, -0.02003111f, 0.03973553f, -0.01881081f, 
    0.02372518f, -0.03603403f, -0.05868442f, 0.02375692f, -0.02189206f, 0.03074795f, -0.01675475f, -0.05661116f, 
    -0.05654383f, -0.04490182f, -0.04200633f, 0.02384163f, -0.01350343f, -0.02769043f, -0.01355015f, -0.01081311f, 
    0.03989577f, 0.00928182f, 0.03952015f, -0.06544408f, 0.03894213f, 0.04464786f, -0.03482069f, 0.01360879f, 
    -0.05540847f, 0.02964764f, 0.05334682f, -0.00414596f, -0.04480029f, -0.03723820f, -0.05633113f, 0.04026023f, 
    -0.01563741f, -0.05974027f, -0.02927798f, -0.01821362f, 0.00781016f, -0.02259110f, 0.00408774f, -0.01035902f, 
    -0.00198654f, -0.00743618f, -0.03833655f, 0.04543287f, -0.02057570f, 0.01965848f, 0.04748262f, -0.00952269f, 
    -0.02628041f, -0.03111908f, -0.03207352f, -0.04289417f, 0.01521722f, -0.02828680f, -0.04495857f, 0.03969685f, 
    0.02473302f, -0.01481605f, 0.02964977f, -0.02696654f, 0.05996784f, 0.00557828f, -0.05326865f, 0.04135118f, 
    -0.05355480f, 0.00266946f, -0.02368553f, -0.00965203f, -0.02746333f, -0.06394982f, 0.03935612f, 0.03311684f, 
    0.04937815f, 0.01628453f, -0.01444587f, 0.03159437f, 0.03048684f, 0.03344207f, 0.05260844f, -0.03478260f, 
    -0.03906850f, -0.04231757f, -0.02758719f, -0.01431715f, -0.04270723f, 0.01855772f, -0.06385146f, 0.04224605f, 
    0.04476637f, -0.05251697f, -0.02873862f, -0.04123823f, 0.00129855f, 0.01424042f, -0.03360224f, 0.04402580f, 
    -0.06447756f, 0.02723654f, -0.06224614f, -0.01071863f, -0.03999185f, 0.05175924f, -0.05521883f, 0.02373229f, 
    -0.04436968f, -0.00051448f, 0.04422414f, -0.03905728f, -0.00113408f, 0.02514158f, -0.01553955f, 0.00192114f, 
    -0.03388979f, 0.02169893f, -0.00648372f, 0.04190803f, 0.02602295f, 0.02324704f, -0.02964219f, 0.02332430f, 
    0.04206844f, 0.04846965f, -0.04967879f, -0.01010358f, -0.04719850f, -0.05250706f, -0.02109394f, -0.05606120f, 
    -0.08389548f, 0.27053946f, -0.34995434f, 0.13797213f, -0.40744445f, -0.13995264f, -0.14498346f, -0.11441159f, 
    -0.14238784f, -0.15097672f, -0.13491315f, 0.21653223f, -0.00240783f, 0.01940035f, -0.03775214f, 0.09862835f, 
    -0.00123427f, -0.03124967f, -0.04218828f, 0.16128239f, 0.12702826f, 0.08359009f, -0.07229637f, -0.08696167f, 
    0.06579196f, 0.11892428f, 0.06527236f, -0.22168483f, -0.26986343f, 0.37288344f, -0.24110436f, 0.03812537f, 
    -0.06537332f, 0.12385253f, -0.03133107f, -0.06857178f, -0.11051714f, -0.01443508f, -0.03466789f, -0.01623150f, 
    -0.06018624f, -0.08437713f, 0.02555914f, -0.06561169f, 0.05390327f, -0.37511775f, 0.07033517f, -0.07311580f, 
    0.14871173f, -0.11685908f, -0.00909177f, -0.00607379f, 0.09861117f, 0.15472132f, -0.21347827f, -0.10254570f, 
    0.06914886f, 0.07222823f, -0.06257190f, -0.31433010f, -0.10759611f, 0.01274887f, -0.23007455f, -0.19415854f, 
    -0.03153348f, 0.09318522f, -0.11432132f, 0.12288584f, -0.03236047f, 0.01117220f, -0.08984406f, 0.07678007f, 
    0.07477649f, -0.04409484f, 0.03734583f, 0.04136015f, -0.11496556f, 0.02622276f, 0.10664248f, 0.04108708f, 
    -0.05028248f, -0.09383762f, 0.21607748f, -0.17737004f, -0.14714508f, 0.08812100f, -0.49056873f, -0.17086175f, 
    0.01283413f, -0.06887610f, 0.07604510f, 0.05593286f, 0.42714834f, 0.04007922f, -0.20022057f, -0.03186304f, 
    0.10204466f, 0.04983946f, 0.15707135f, -0.11345382f, 0.08305269f, -0.04375818f, -0.04611557f, 0.02849220f, 
    -0.06195061f, -0.11306736f, -0.14592069f, -0.01789341f, -0.10111332f, 0.12897311f, -0.11072786f, -0.09060322f, 
    -0.03701086f, -0.02416999f, 0.05290732f, -0.06645857f, 0.11013843f, -0.18896741f, 0.09151024f, 0.21226518f, 
    0.06772607f, 0.14762719f, -0.08917725f, -0.22331651f, 0.14969535f, -0.04900238f, 0.25095922f, 0.17827468f, 
    -0.07819887f, -0.11062014f, -0.05483900f, 0.23360121f, 0.06252967f, 0.11691161f, -0.08818904f, -0.09743226f, 
    0.11300708f, -0.09477158f, -0.20405807f, 0.14688312f, 0.15889528f, 0.05851899f, 0.18397327f, -0.07631463f, 
    0.18364657f, 0.48677182f, 0.41874108f, -0.08425663f, -0.02100591f, -0.01052309f, 0.08247546f, 0.08527135f, 
    0.01907319f, -0.26293790f, 0.10205994f, 0.20281859f, 0.13006538f, 0.14355545f, -0.14733937f, -0.22911534f, 
    0.01260317f, -0.08780309f, 0.09540830f, -0.19437841f, 0.22068146f, -0.04093609f, -0.37542185f, -0.30414236f, 
    -0.04089822f, -0.22515501f, -0.01416484f, -0.30694339f, 0.17578530f, 0.11054128f, 0.09996014f, -0.26251286f, 
    0.15285794f, -0.06085411f, 0.00286938f, 0.39450890f, -0.09738033f, 0.17780267f, -0.03717366f, -0.09279931f, 
    0.05677987f, 0.06269904f, 0.10729478f, 0.02429690f, 0.10345906f, -0.00006023f, 0.06398369f, 0.24841134f, 
    -0.14999595f, -0.23993807f, 0.02888673f, 0.07860501f, -0.00487184f, 0.04187620f, -0.05870438f, 0.27022645f, 
    0.55559194f, -0.04161893f, -0.11056811f, 0.05903352f, 0.02552549f, 0.12160324f, -0.01989933f, -0.06585597f, 
    0.39490217f, -0.24169843f, 0.00823461f, -0.29215357f, -0.25107634f, -0.08378679f, 0.15453608f, -0.10798519f, 
    0.03496481f, -0.06120934f, 0.16937110f, 0.15415946f, 0.16571286f, 0.09595300f, 0.23445100f, 0.17743187f, 
    0.03430522f, 0.16665275f, 0.25626287f, 0.36189702f, 0.05628068f, -0.01610149f, 0.04985229f, 0.13075045f, 
    -0.11722300f, -0.01791718f, 0.18558164f, 0.16184886f, 0.25881577f, 0.06167145f, -0.22165321f, 0.07350589f, 
    0.06154158f, -0.05792027f, 0.11206317f, -0.07708810f, 0.05017931f, -0.30800137f, 0.15782818f, -0.10838056f, 
    -0.25317833f, -0.18823236f, 0.10290316f, -0.03715942f, -0.20861286f, 0.27765465f, 0.38340995f, 0.10834953f, 
    -0.27195171f, 0.04901433f, 0.06091160f, -0.12135235f, -0.12473918f, -0.08099736f, -0.19148359f, 0.24004634f, 
    0.10199931f, -0.00293077f, -0.11858498f, -0.06924003f, 0.08828772f, -0.15921196f, -0.17936794f, -0.27326086f, 
    0.28891703f, -0.12414565f, -0.06974776f, 0.01681117f, 0.11387699f, -0.11746452f, 0.08014448f, -0.21183707f, 
    0.28008646f, 0.23289903f, 0.06107316f, 0.17230082f, 0.04020333f, -0.02066578f, 0.37718627f, -0.12635824f, 
    0.45340192f, -0.58338714f, 0.15121780f, -0.15493369f, 0.06678917f, -0.06499805f, -0.11558839f, -0.12172443f, 
    -0.00213218f, 0.13378492f, 0.09387195f, -0.04761989f, 0.03776722f, -0.20278570f, 0.13939187f, 0.06942761f, 
    -0.03656672f, -0.08556047f, 0.19861288f, -0.27330574f, -0.10272919f, 0.01937740f, 0.08245976f, 0.06048875f, 
    0.05342557f, 0.10338877f, 0.12512505f, -0.22061816f, -0.16263199f, -0.72724742f, 0.01184424f, -0.24309492f, 
    -0.06625438f, -0.01780311f, 0.06044699f, -0.21491504f, 0.30219129f, 0.09109484f, -0.15176767f, 0.01002574f, 
    0.11985970f, -0.02152639f, 0.23279232f, -0.02080839f, 0.27420408f, -0.30652618f, -0.10280818f, -0.00868779f, 
    0.12946552f, 0.15644196f, 0.10703743f, -0.03863635f, 0.09874092f, 0.10043370f, -0.00358545f, -0.12118277f, 
    -0.42414623f, -0.08326090f, -0.10330715f, 0.18038139f, -0.14034218f, -0.17569350f, -0.07586838f, -0.17881879f, 
    0.02369653f, 0.25083867f, -0.05027393f, -0.04020170f, 0.05031778f, -0.01571063f, -0.06278764f, 0.12419382f, 
    0.41061473f, 0.09620970f, 0.01700564f, 0.08558680f, 0.03441368f, 0.15398292f, 0.10387760f, -0.04037107f, 
    0.14486663f, 0.08653621f, 0.23263989f, -0.44805425f, -0.14643799f, 0.02740492f, 0.20956747f, -0.03222990f, 
    0.05267929f, -0.08712181f, 0.01745443f, -0.31804463f, 0.02397812f, -0.09350879f, -0.15514384f, 0.17680068f, 
    0.00833676f, 0.19069970f, 0.12770160f, -0.15392868f, 0.04699142f, 0.20100214f, -0.04191280f, -0.00065574f, 
    0.06266931f, -0.15608291f, -0.06801539f, 0.11967871f, -0.09577743f, -0.17899550f, -0.14873813f, 0.01008624f, 
    0.04448216f, -0.04624742f, 0.07756134f, 0.13472612f, 0.15969054f, 0.11454691f, -0.21668696f, 0.67159492f, 
    -0.05520833f, -0.10464873f, -0.06480051f, 0.06601534f, 0.17437850f, 0.09912784f, 0.28195024f, -0.33730972f, 
    -0.40046144f, -0.12588722f, 0.10355678f, 0.02140423f, 0.09887580f, 0.13570210f, 0.08717332f, -0.00565632f, 
    -0.44967228f, -0.02463978f, 0.26631486f, -0.03212265f, 0.15426910f, -0.03853647f, -0.07040270f, -0.04099520f, 
    0.21570195f, 0.01137460f, -0.03706989f, -0.03571548f, 0.03199986f, -0.00760658f, 0.02521254f, 0.09976477f, 
    0.05098445f, -0.18712637f, -0.45457989f, -0.19087541f, 0.18971775f, -0.02044442f, 0.05511385f, 0.12911785f, 
    -0.05499798f, -0.00705482f, -0.66178024f, 0.02453106f, -0.42815733f, -0.04815238f, 0.20030037f, 0.09869108f, 
    -0.09577549f, 0.03212899f, -0.07825240f, -0.30933338f, 0.02632713f, -0.19668266f, 0.10581157f, 0.05965949f, 
    -0.08549610f, 0.07846263f, -0.01281814f, -0.24053703f, -0.09865766f, -0.05874671f, -0.07852497f, -0.08431164f, 
    -0.06030443f, -0.07032710f, 0.00127162f, -0.01566252f, 0.02528818f, 0.07533711f, -0.43600923f, -0.37742379f, 
    -0.14095795f, -0.02158274f, 0.09609886f, -0.10020638f, 0.10299887f, -0.00363763f, 0.13418405f, 0.03547092f, 
    -0.09094594f, -0.08325961f, -0.11121014f, -0.11795157f, 0.03375725f, 0.03591555f, 0.02352151f, -0.02161601f, 
    -0.01740538f, 0.06967344f, 0.02323712f, 0.10825376f, -0.04820045f, -0.19452456f, 0.10599543f, 0.26384833f, 
    -0.20265520f, -0.06573877f, -0.02770374f, -0.12805200f, 0.16478939f, 0.02921059f, 0.22910555f, 0.35262543f, 
    -0.12153818f, 0.25728074f, -0.04934772f, 0.19644971f, 0.05421842f, -0.21779178f, 0.02590414f, 0.14749077f, 
    0.08441778f, 0.10631451f, 0.20412368f, -0.35813767f, -0.03724119f, -0.04378950f, -0.12200031f, -0.11390734f, 
    0.11575044f, 0.03689210f, 0.15665521f, 0.46021181f, 0.00658322f, 0.30122170f, 0.07349806f, 0.09291420f, 
    0.11699551f, 0.05514872f, 0.09586717f, -0.33004570f, -0.01308275f, -0.99698603f, -0.07698851f, -0.05213639f, 
    0.04251112f, 0.10920064f, 0.15297197f, 0.01813873f, 0.23361564f, -0.38941145f, 0.08349494f, 0.03213655f, 
    -0.03029410f, -0.00423687f, 0.24191232f, 0.21829674f, -0.00295808f, 0.34748036f, 0.03721211f, -0.02079606f, 
    -0.38808838f, 0.07854261f, -0.12944944f, 0.00790456f, -0.02633289f, 0.03263428f, 0.13599870f, -0.31350422f, 
    0.02143207f, 0.05254240f, -0.08642898f, 0.15602650f, -0.10624027f, -0.06949307f, 0.32084098f, 0.02212387f, 
    0.08171123f, 0.10278019f, -0.27336574f, -0.12905172f, 0.18555522f, -0.36124292f, -0.02315088f, -0.03262405f, 
    0.02095768f, -0.01009844f, 0.01517157f, 0.25546697f, 0.12127045f, -0.04262430f, 0.13760249f, 0.04764184f, 
    0.14332585f, 0.20814969f, 0.03734281f, 0.00987787f, 0.04157092f, -0.03424690f, 0.04226080f, 0.06006369f, 
    0.03179723f, 0.05517568f, 0.09555103f, -0.44603655f, -0.36887696f, 0.48804331f, 0.23650829f, -0.22873943f, 
    -0.19471775f, 0.04100940f, -0.04329458f, -0.11521208f, 0.06998092f, 0.14305601f, -0.08406182f, 0.00389645f, 
    0.07561463f, -0.07305689f, 0.19948451f, 0.02035315f, 0.13316840f, 0.25146896f, -0.00996935f, -0.24959852f, 
    -0.05806909f, -0.02758996f, 0.01766993f, -0.01981731f, -0.01921831f, 0.18651961f, -0.06671681f, 0.23252897f, 
    -0.12885667f, -0.10532729f, -0.08000966f, -0.25453213f, -0.03672060f, -0.08071735f, 0.03360155f, 0.14374091f, 
    0.06862812f, 0.12845682f, -0.08077883f, -0.02367585f, -0.06362376f, 0.11829548f, 0.09342007f, -0.08830254f, 
    0.00197583f, -0.02729515f, 0.21545713f, 0.06561432f, 0.06573956f, 0.03165657f, 0.11875087f, 0.00084145f, 
    0.19837046f, -1.10117531f, 0.06916104f, 0.34702736f, -0.07495225f, -0.12578356f, -0.01936584f, 0.03030093f, 
    -0.16501074f, 0.04230728f, -0.11780490f, -0.50933427f, -0.14011548f, 0.11775125f, -0.06559123f, 0.02729131f, 
    -0.12268391f, 0.00702663f, -0.04031645f, 0.10035201f, 0.01144424f, 0.13269316f, -0.06656537f, 0.01863964f, 
    0.03996548f, 0.11328158f, 0.13136649f, -0.22705159f, 0.15132470f, -0.03352711f, -0.15441607f, -0.14216982f, 
    0.06457663f, -0.35087967f, 0.07006760f, 0.05357935f, 0.10903654f, 0.03728636f, -0.31814045f, 0.19989951f, 
    -0.06471134f, -0.01877335f, -0.19020505f, -0.14057006f, 0.10087344f, -0.01440863f, -0.03592859f, 0.24431115f, 
    -0.22667336f, -0.19163959f, -0.05634455f, -0.00308917f, 0.01496862f, 0.01858691f, 0.09864749f, 0.50533777f, 
    -0.19222662f, -0.01992410f, -0.09570071f, -0.18876801f, -0.09642563f, -0.07206996f, -0.00428049f, -0.05595240f, 
    0.22429493f, -0.35960001f, 0.34672189f, -0.11392915f, -0.03247301f, -0.18474098f, 0.05296830f, -0.14155243f, 
    0.36822680f, 1.48357391f, 0.02168438f, -0.63338232f, -0.03558894f, -0.12215372f, 0.27090043f, 0.23066166f, 
    0.02125222f, 0.22210029f, -0.11565178f, 0.41682148f, -0.02435228f, -0.03220125f, 0.13504636f, 0.05523437f, 
    0.13069165f, 0.10652710f, 0.00718782f, 0.00371372f, 0.10492775f, 0.10018942f, -0.13734038f, -0.20526154f, 
    0.03261443f, 0.12271418f, -0.05422823f, 0.06562103f, 0.21313095f, 0.03397685f, -0.15031706f, -0.27303839f, 
    0.03621727f, -0.69432461f, 0.03369203f, 0.04186495f, -0.00352783f, -0.37190104f, -0.34510317f, 0.39125490f, 
    0.17669253f, 0.03213153f, -0.10004575f, -0.00762599f, -0.03078858f, -0.02362014f, 0.09901316f, -0.24400681f, 
    0.45237455f, -0.03542593f, -0.08742877f, -0.04327709f, 0.05010682f, -0.06838070f, 0.09164362f, -0.28022939f, 
    -0.11851784f, 0.13232030f, 0.05138456f, 0.16149297f, 0.02232791f, 0.08855400f, -0.33376217f, 0.40979791f, 
    0.03742997f, 0.01057078f, -0.11796060f, -0.48223788f, 0.24392782f, -0.16651924f, 0.08829514f, -0.05538598f, 
    0.20181224f, 0.24815933f, -0.26501626f, 0.47441962f, -0.04475787f, 0.09607622f, -0.16610394f, 0.11181326f, 
    -0.14360899f, 0.02461516f, 0.36019543f, -0.28809422f, 0.08361145f, 0.00334436f, 0.04798120f, -0.04232928f, 
    0.04134512f, -0.05315383f, -0.05112440f, 0.03699267f, -0.05684976f, -0.27584329f, 0.16153163f, -0.21990195f, 
    -0.11300153f, -0.02783626f, 0.25486127f, -0.15564607f, -0.54223675f, -0.00650260f, -0.10281375f, 0.18139823f, 
    0.05853631f, 0.06150498f, -0.06893522f, -0.07431012f, 0.19040714f, -0.23214957f, -0.09273410f, 0.15709123f, 
    -0.04026434f, 0.13085923f, -0.26360920f, 0.18742076f, 0.06068787f, 0.37740776f, -0.20113237f, 0.04760278f, 
    0.21872185f, 0.06668497f, -0.06248900f, 0.01699596f, -0.13049032f, 0.05126361f, 0.20858052f, 0.63183838f, 
    0.14351074f, -0.30679941f, -0.04484841f, -0.05358369f, 0.03334204f, -0.00689956f, -0.07300903f, -0.01038494f, 
    -0.01909219f, -0.07076913f, -0.30260071f, -0.26603341f, -0.08267684f, -0.17355531f, -0.12140768f, -0.22991329f, 
    -0.19423324f, -0.36533254f, -0.52030176f, -0.30822149f, -0.12266029f, -0.03213577f, -0.15551902f, -0.01385456f, 
    -0.06121274f, -0.01881057f, 0.08166033f, -0.07502379f, -0.04428221f, 0.10176489f, 0.00459342f, 0.01699990f, 
    -0.01857860f, 0.06827950f, -0.00012714f, 0.43964306f, -0.21274978f, 0.11007314f, -0.30783519f, -0.00874635f, 
    -0.08392651f, -0.05784480f, -0.12123404f, 0.01797381f, 0.31764823f, 0.19088633f, 0.21408764f, -0.02524817f, 
    0.07820959f, -0.02943947f, -0.06085475f, -0.08534274f, 0.00235785f, 0.13784643f, 0.06614309f, 0.19203857f, 
    0.06373863f, -0.03792567f, 0.03350807f, 0.12333211f, -0.08283631f, 0.22897074f, -0.11124187f, -0.17010148f, 
    -0.27057904f, -0.14591829f, 0.01700347f, -0.02477910f, -0.10396840f, -0.09991115f, -0.16526374f, 0.23357089f, 
    0.13714086f, 0.25513920f, 0.03808846f, 0.14313918f, 0.10760275f, 0.09786102f, -0.17096208f, 0.05020701f, 
    0.02280474f, -0.55435872f, -0.31041604f, -0.02996858f, 0.03176274f, -0.14692949f, 0.03742418f, 0.18536639f, 
    0.00787896f, 0.46555701f, -0.43411434f, -0.39630458f, -0.01516428f, 0.12607293f, -0.10573556f, 0.13352077f, 
    -0.11880211f, -0.19221438f, -0.27100694f, -0.34197712f, 0.06132320f, 0.12212050f, 0.22329845f, 0.13424467f, 
    -0.04072042f, 0.02043477f, 0.06883074f, 0.20140155f, 0.09340051f, 0.14094943f, 0.10342985f, 0.11544069f, 
    -0.03433510f, 0.10426639f, -0.13508585f, -0.08223193f, 0.23596343f, 0.12261664f, 0.14925471f, -0.13046445f, 
    -0.18863741f, -0.17364241f, -0.07307944f, -0.14261004f, -0.03137211f, 0.07005718f, 0.46662992f, 0.32207561f, 
    0.08449162f, 0.05179100f, 0.02660146f, -0.05367186f, 0.16407056f, -0.06475250f, 0.22748931f, -0.31678504f, 
    -0.28614631f, 0.08792802f, 0.01814320f, -0.10702120f, 0.02112790f, -0.07541537f, 0.02164917f, 0.19237480f, 
    -0.01061554f, 0.23450586f, -0.00430043f, 0.06029432f, 0.17746307f, -0.12431630f, 0.19496071f, 0.02153915f, 
    -0.24230736f, -0.03426646f, -0.31017676f, 0.00014479f, 0.01374631f, -0.06143631f, 0.01902785f, -0.02477730f, 
    -0.15129273f, 0.26794204f, -0.08020987f, 0.13649289f, 0.10511556f, -0.04088440f, 0.36346966f, 0.08480619f, 
    0.11122610f, -0.04678250f, 0.09875599f, -0.34861040f, -0.39062023f, -0.41438919f, -0.01082008f, 0.24154684f, 
    -0.16960813f, 0.10202940f, -0.12387506f, 0.30115652f, 0.08818423f, 0.29361823f, -0.04645670f, 0.29109660f, 
    0.19359481f, -0.01886945f, 0.06584314f, -0.24345796f, 0.19987014f, 0.14004110f, 0.21858960f, -0.17623349f, 
    -0.07481498f, -0.08653396f, -0.16339654f, -0.17607890f, -0.06117026f, 0.51309574f, -0.38576722f, -0.29188034f, 
    -0.13382526f, 0.06050881f, 0.00262167f, 0.02204491f, -0.03782567f, -0.03262703f, -0.38808316f, 0.15794647f, 
    -0.22088486f, -0.08379788f, -0.01753517f, -0.05528431f, -0.05111619f, 0.06760924f, -0.00054773f, 0.27981305f, 
    -0.07109468f, 0.02827098f, -0.09541000f, 0.12727030f, -0.07080043f, -0.13395523f, -0.17054503f, -0.15335234f, 
    0.07117186f, 0.20154519f, 0.19631322f, 0.15151057f, 0.06348699f, 0.05152133f, -0.05294913f, 0.08243773f, 
    0.09960413f, -0.31507629f, -0.23792322f, 0.40750775f, 0.03931408f, 0.06275383f, 0.03530107f, -0.13667990f, 
    0.14192820f, 0.05810146f, 0.10702691f, -0.13461350f, -0.05963829f, 0.26395062f, -0.02679469f, -0.02860518f, 
    -0.01178111f, 0.00063230f, 0.04167248f, -0.10483605f, -0.02185011f, -0.04533548f, 0.00546603f, -0.04687024f, 
    -0.15034877f, 0.09870539f, 0.05521021f, -0.05665567f, -0.08317723f, -0.65144849f, -0.64880037f, -0.27505627f, 
    -0.07076441f, -0.26448908f, -0.10413107f, 0.01719333f, 0.03595482f, 0.26757553f, 0.08879199f, 0.33228683f, 
    -0.18095319f, 0.08820096f, 0.07836040f, 0.03524381f, -0.04766855f, 0.05953814f, 0.16154402f, -0.29905143f, 
    0.05966692f, -0.18987094f, -0.02312425f, -0.03043380f, 0.04995417f, -0.03166669f, -0.03097418f, 0.10943542f, 
    0.14416820f, 0.20316289f, 0.15074672f, 0.14216687f, 0.04974180f, 0.04806291f, -0.00677075f, 0.19120479f, 
    0.02476816f, 0.02726389f, -0.05631451f, 0.10579918f, 0.13124204f, 0.01787042f, -0.14561562f, 0.09792741f, 
    -0.25189367f, -0.24385588f, 0.17475444f, 0.10785382f, -0.12241718f, 0.14902993f, 0.05643457f, 0.08038528f, 
    0.00916288f, 0.15626110f, 0.09824039f, 0.13470063f, 0.09275063f, 0.08745452f, 0.11087520f, 0.01697922f, 
    0.05404776f, 0.04150743f, -0.46074885f, -0.27510297f, 0.06395929f, -0.00536244f, -0.08837954f, -0.22959276f, 
    -0.18952651f, 0.08462791f, -0.00938043f, 0.03579114f, 0.16147541f, -0.01803366f, -0.02383515f, -0.00476797f, 
    0.10805446f, 0.13981231f, -0.09436258f, -0.08797036f, 0.15408728f, 0.03879409f, -0.09492225f, 0.18193746f, 
    0.05409453f, 0.15184397f, 0.08333199f, 0.08050422f, 0.08466762f, -0.17109044f, -0.04552070f, -0.15046822f, 
    0.08819105f, 0.10622642f, 0.07119308f, 0.04136416f, 0.08898087f, 0.15975130f, 0.19940214f, 0.12362114f, 
    0.00305943f, -0.14599539f, 0.13767928f, 0.14375766f, 0.04422199f, 0.16074975f, 0.08455539f, -0.04977864f, 
    -0.08864508f, 0.10518253f, -0.07726202f, 0.00619928f, 0.05072545f, 0.16778244f, 0.02164874f, -0.01422202f, 
    0.10425100f, -0.35971802f, -0.08234752f, 0.00629734f, -0.33723602f, 0.19138007f, 0.07212169f, 0.08905803f, 
    0.00035352f, 0.04740214f, 0.00670093f, -0.07122852f, 0.15727681f, 0.28591421f, -0.03634192f, -0.54056156f, 
    -0.00410714f, -0.31704527f, -0.53147560f, 0.14370170f, -0.09493174f, -0.18652098f, 0.12272130f, 0.13731921f, 
    0.11413460f, 0.18377204f, 0.01668296f, -0.08579762f, 0.03230242f, -0.01865884f, 0.05331854f, 0.10336738f, 
    0.15414059f, 0.09055373f, -0.17742805f, -0.08423533f, -0.35604027f, -0.00319477f, 0.04157316f, 0.06304178f, 
    -0.24572505f, -0.31632736f, 0.06614282f, 0.19331935f, 0.10129793f, -0.01675039f, 0.12186546f, 0.08448613f, 
    0.19651812f, 0.05669952f, 0.12677780f, 0.01200053f, -0.06423470f, 0.00039807f, -0.00070329f, 0.02491202f, 
    -0.08202025f, -0.34504262f, 0.15589699f, 0.22824734f, 0.09551090f, 0.13599911f, 0.22053525f, 0.22314779f, 
    -0.19113038f, 0.24656565f, 0.29574764f, 0.19335596f, 0.24760857f, 0.31405798f, -0.11139125f, -0.01271539f, 
    0.21681026f, 0.22822867f, -0.01536941f, 0.16169314f, 0.08743180f, -0.13732503f, 0.08488332f, 0.29885477f, 
    -0.04076376f, 0.20099586f, -0.24064164f, 0.25672412f, 0.20805153f, 0.05795957f, 0.04279086f, 0.06420243f, 
    -0.10485458f, 0.26171821f, 0.57608658f, -0.03896620f, 0.12459981f, 0.10768905f, 0.12904795f, -0.09107210f, 
    0.00448562f, -0.14090966f, 0.16491580f, 0.03183316f, 0.08696838f, 0.00735727f, -0.04259716f, 0.14376721f, 
    0.16786112f, 0.12542368f, -0.20693883f, -0.04985112f, -0.38337755f, -0.30171305f, -0.01370346f, 0.05332667f, 
    0.04399859f, -0.00608659f, -0.35083997f, 0.16423039f, 0.05987940f, 0.01793027f, -0.13128158f, 0.26636952f, 
    0.14408436f, 0.10383186f, 0.29400864f, 0.11555535f, -0.08059783f, -0.04559678f, 0.13500185f, -0.33668554f, 
    -0.08687654f, 0.02900695f, 0.02011647f, -0.00499699f, 0.14044312f, 0.00431015f, -0.01910420f, 0.11969192f, 
    0.02393285f, 0.07464217f, 0.10972863f, 0.17388001f, 0.03032028f, 0.09857015f, -0.42050555f, -0.46081918f, 
    -0.61512375f, -0.15219137f, 0.16955116f, 0.03806812f, 0.15936200f, -0.03210017f, -0.19770537f, -0.08658503f, 
    -0.15491690f, -0.10004666f, -0.14692496f, -0.06044803f, 0.11868630f, 0.21443880f, 0.13268512f, -0.08239653f, 
    -0.01544554f, -0.25737941f, -0.30032146f, -0.00884072f, 0.14002061f, -0.01508448f, 0.02730732f, 0.16092584f, 
    0.00390291f, -0.16493684f, -0.04557064f, -0.21310790f, -0.12513034f, 0.35105726f, 0.13378079f, -0.00612754f, 
    -0.05288053f, -0.09461936f, 0.09310175f, 0.21298447f, 0.09179425f, 0.01035913f, 0.27121100f, -0.06185812f, 
    0.09535000f, 0.16734764f, 0.09128682f, 0.04702099f, -0.05641983f, 0.22524101f, -0.31592163f, 0.25043789f, 
    0.08866982f, -0.00616708f, 0.02377485f, 0.27022591f, 0.02363884f, 0.05317879f, 0.25730863f, 0.18257940f, 
    0.02298327f, 0.20813689f, 0.10550807f, 0.00976365f, -0.16764922f, 0.22812741f, -0.04491213f, -0.28642616f, 
    -0.03000066f, -0.52484143f, -0.14839712f, 0.04252377f, 0.09508498f, 0.21423803f, -0.03048563f, -0.08563560f, 
    -0.16540685f, 0.21813533f, -0.01214244f, 0.13665995f, -0.01451224f, -0.12339827f, 0.06435432f, 0.03739961f, 
    0.14833555f, 0.01623948f, 0.09277177f, -0.03688824f, 0.06004076f, 0.08986253f, -0.03400384f, -0.21711546f, 
    -0.02806688f, -0.26206201f, 0.09304541f, -0.06308451f, -0.00986197f, -0.76471400f, 0.07094654f, -0.09936377f, 
    -0.04803801f, 0.04212812f, 0.08797736f, -0.05720465f, 0.07668069f, 0.07234265f, -0.16102009f, -0.05311751f, 
    0.02127180f, -0.04391758f, 0.24782053f, -0.26031172f, 0.10620444f, -0.13176058f, -0.08543524f, 0.09369178f, 
    0.07178941f, -0.08021959f, -0.05408965f, 0.01787331f, 0.02312696f, -0.02685407f, 0.01727659f, -0.21116897f, 
    -0.36892474f, 0.07725368f, -0.03034098f, 0.07072897f, 0.11119618f, 0.13514927f, 0.08611991f, -0.26625988f, 
    0.24388634f, 0.03933303f, 0.03357546f, -0.02357802f, -0.00938597f, 0.04935978f, 0.03684240f, -0.00959177f, 
    0.28177282f, -0.05594611f, 0.11373094f, -0.07940744f, 0.10696357f, 0.13302527f, 0.06196852f, 0.09941624f, 
    0.05325452f, 0.59278017f, 0.42319062f, -0.27946854f, 0.10137475f, -0.04334699f, 0.01414808f, 0.12997240f, 
    -0.02261901f, 0.04143421f, 0.14144160f, 0.03983695f, 0.14974026f, -0.01863728f, 0.08778065f, -0.28368375f, 
    0.09657090f, -0.03832343f, -0.31799012f, -0.06503260f, 0.12443593f, 0.09296901f, -0.02424657f, 0.10443206f, 
    -0.05096338f, 0.00366077f, 0.02340532f, -0.01260467f, -0.19763231f, -0.10509969f, -0.21706979f, 0.10959377f, 
    0.12352181f, 0.15253216f, -0.01123989f, -0.08430598f, -0.16806567f, 0.11535888f, 0.22047824f, 0.28775018f, 
    -0.10240570f, 0.04313991f, 0.00942178f, 0.09663964f, -0.07463371f, -0.11388544f, 0.10150036f, 0.06886245f, 
    0.11137836f, -0.02433011f, 0.00024875f, -0.01903354f, -0.08486898f, -0.21307056f, -0.09978984f, -0.21609807f, 
    0.00212768f, -0.36967850f, -0.00480528f, 0.02385377f, 0.08110584f, 0.09321077f, 0.07058646f, -0.25532976f, 
    0.32636991f, 0.08732256f, 0.24765612f, 0.08956709f, -0.15248813f, 0.18242638f, 0.03663189f, 0.10150564f, 
    -0.18647121f, 0.09318597f, 0.01140602f, 0.46255195f, 0.02384681f, 0.05063219f, 0.10003659f, 0.14834104f, 
    -0.13170581f, 0.21976781f, -0.40599391f, 0.30673584f, 0.10502788f, -0.05896335f, -0.08150303f, 0.17391697f, 
    -0.07083789f, 0.21234554f, 0.07559998f, -0.19479392f, 0.21651857f, 0.16322511f, 0.09181475f, -0.05567534f, 
    -0.05440677f, 0.17879364f, -0.06820743f, -0.17676947f, -0.16713664f, -0.01314047f, -0.04680868f, -0.07230293f, 
    0.06463284f, 0.01012427f, 0.04460802f, -0.21330495f, -0.08889079f, 0.00468609f, -0.11199652f, -0.20493159f, 
    0.09056242f, -0.00416213f, 0.12428218f, -0.10031823f, -0.19572146f, -0.08644516f, 0.17052551f, 0.14574642f, 
    0.14931996f, 0.04543426f, 0.00069323f, 0.16684002f, 0.04133663f, 0.00623599f, -0.03730460f, -0.18048799f, 
    -0.13095284f, -0.13151062f, -0.02204309f, 0.05002849f, 0.30909094f, -0.03785231f, 0.08015081f, 0.15631898f, 
    -0.14752045f, -0.08543874f, -0.01947475f, -0.01768026f, -0.14667434f, -0.10960723f, 0.05614959f, -0.00956308f, 
    -0.25246146f, 0.02093717f, 0.00684265f, 0.08487173f, 0.17028701f, 0.04645382f, 0.01505550f, -0.02120859f, 
    -0.14759515f, -0.12958460f, 0.03572359f, -0.02607039f, 0.15239236f, 0.09135781f, 0.15534714f, 0.08327019f, 
    -0.00094834f, -0.05710934f, -0.28103188f, 0.54145837f, 0.17844355f, -0.07167485f, -0.09233589f, -0.02281404f, 
    -0.16181700f, 0.00604328f, 0.09348389f, -0.19457355f, -0.02010428f, -0.82054490f, -0.00634967f, 0.18745668f, 
    0.28758436f, 0.08168477f, 0.02749778f, 0.05586752f, 0.06499942f, -0.33499855f, 0.07332941f, -0.17014697f, 
    -0.04150863f, -0.03322242f, 0.18696083f, 0.06878730f, 0.05572605f, -0.01150654f, 0.00417800f, -0.07798603f, 
    -0.01542976f, 0.01960305f, -0.05813685f, 0.17672135f, -0.01605778f, 0.03425657f, 0.08536697f, -0.19380088f, 
    0.04746185f, 0.14061230f, 0.06172626f, -0.10489474f, 0.10646718f, 0.01192385f, -0.01009250f, -0.19302718f, 
    -0.39667213f, -0.05320964f, 0.02909840f, -0.14647277f, 0.05421390f, -0.00927042f, 0.03241530f, 0.04445652f, 
    -0.06084819f, -0.11379907f, 0.16135865f, 0.19578531f, 0.00782812f, 0.13743111f, 0.16593356f, -0.08001481f, 
    -0.05101511f, -0.06396423f, -0.09196348f, 0.16400778f, 0.23274742f, 0.02728920f, 0.14072330f, 0.15387122f, 
    -0.05947456f, -0.01588833f, -0.03560231f, -0.25763175f, 0.50775951f, 0.47524959f, -0.31030965f, -0.06894851f, 
    -0.01866779f, 0.03934150f, -0.04313213f, -0.03933306f, 0.01073748f, 0.16415372f, 0.06598231f, 0.12170395f, 
    -0.11518901f, 0.25729790f, 0.04257143f, -0.06716903f, 0.12482742f, 0.30761313f, 0.07588100f, 0.25591159f, 
    0.10847336f, 0.06467247f, -0.07969044f, -0.24789284f, -0.06750181f, 0.15640058f, -0.31540671f, -0.02419868f, 
    -0.13116947f, -0.08974046f, -0.01649877f, 0.01721195f, 0.08781365f, 0.04105210f, 0.22420608f, 0.11329205f, 
    0.15888275f, 0.11870283f, 0.10759677f, -0.09737434f, -0.21246977f, 0.15836844f, 0.03896394f, 0.14218853f, 
    -0.00255617f, 0.01796175f, 0.26587793f, 0.12192685f, 0.03284603f, 0.17535464f, -0.04290602f, 0.06630674f, 
    0.05461911f, -0.10992164f, 0.08021024f, 0.20790797f, 0.11560822f, 0.18358189f, 0.08396930f, -0.04445440f, 
    0.27508351f, 0.06404045f, -0.08013339f, 0.05614420f, -0.24120075f, -0.13015403f, -0.03598779f, 0.14756820f, 
    -0.00940958f, -0.01763005f, 0.02158678f, -0.02896090f, 0.15954681f, 0.11820001f, 0.10260638f, 0.01202780f, 
    -0.18793154f, 0.12028282f, 0.09893502f, 0.12603188f, -0.07081847f, 0.03501624f, 0.02570203f, 0.07758295f, 
    -0.06799347f, -0.06362361f, 0.07542553f, -0.07179310f, -0.03489317f, -0.26950127f, -0.22080238f, 0.14983663f, 
    -0.03413945f, 0.01562378f, 0.00104037f, 0.11062079f, 0.02509417f, -0.05667134f, -0.16089347f, 0.12509198f, 
    0.20305665f, 0.01779514f, -0.23095851f, 0.19159418f, 0.01568495f, -0.08283444f, 0.01589107f, -0.10484342f, 
    0.20251106f, -0.00208048f, -0.06953380f, -0.12208535f, -0.03841348f, 0.25589308f, -0.39614981f, -0.19416367f, 
    -0.42653498f, -0.49768186f, -0.28679740f, 0.09025340f, -0.10924610f, -0.10026284f, 0.08374308f, -0.23301318f, 
    -0.09385257f, 0.15796551f, -0.04274128f, 0.14532427f, 0.04641475f, 0.10804823f, -0.08664533f, -0.02225650f, 
    0.24200498f, 0.19055539f, -0.17398869f, 0.26689753f, 0.27744234f, -0.01403392f, 0.23922780f, 0.04348323f, 
    0.02972930f, 0.22277121f, 0.18172428f, 0.06517304f, 0.02396608f, 0.31100899f, 0.06643084f, 0.20345709f, 
    -0.03610620f, -0.06236627f, -0.07533442f, 0.06778080f, -0.00508483f, 0.07386611f, 0.04721568f, 0.07680445f, 
    -0.10844593f, -0.23945262f, -0.00774619f, -0.02902465f, -0.03526031f, -0.24218599f, 0.38870999f, 0.25354913f, 
    -0.21767694f, 0.11417405f, -0.13248619f, 0.09286904f, -0.08511426f, -0.05335383f, -0.22583786f, -0.36625627f, 
    -0.44775546f, 0.03587627f, 0.03388427f, -0.11611007f, -0.03749557f, -0.06332763f, -0.15615962f, 0.02805595f, 
    -0.11130749f, 0.25061902f, 0.14941469f, -0.09051298f, 0.25224936f, -0.02951050f, -0.07357880f, -0.02729291f, 
    0.11576701f, 0.00009562f, -0.06224556f, -0.15936287f, 0.02423439f, -0.04572650f, -0.27053794f, -0.02119871f, 
    -0.03131300f, -0.66839641f, -0.38096139f, -0.25454548f, -0.02199591f, -0.01547323f, -0.11750980f, 0.06009118f, 
    0.13397291f, -0.06008350f, -0.42004764f, -0.10161043f, -0.51767015f, -0.15475886f, -0.04056412f, -0.03219132f, 
    0.07643443f, 0.12995917f, -0.10055664f, -0.11138438f, 0.23403220f, -0.18246789f, 0.03544070f, 0.20078987f, 
    0.09088546f, -0.27626419f, 0.03523974f, -0.29095969f, -0.38837993f, 0.18354267f, 0.15259744f, -0.31041011f, 
    -0.07852945f, -0.01153337f, -0.04090475f, 0.04405380f, -0.00310681f, 0.03921246f, 0.25735858f, -0.01368012f, 
    0.08673553f, 0.12715101f, 0.03463693f, -0.11480518f, 0.04685342f, 0.03692604f, -0.33241212f, 0.16115475f, 
    0.37776694f, -0.01831941f, 0.01962025f, -0.14619957f, -0.15727665f, 0.11044525f, -0.11644284f, 0.13940790f, 
    -0.39108887f, -0.11288347f, 0.24143170f, 0.09851968f, -0.00260359f, -0.20809942f, -0.12819099f, 0.25722086f, 
    -0.05427371f, -0.13218971f, 0.31578955f, -0.10353610f, -0.25637710f, -0.33663663f, 0.16563772f, 0.05332321f, 
    -0.08135311f, 0.39872617f, 0.25377703f, 0.04983810f, -0.04590075f, 0.13481563f, 0.04263564f, 0.05306353f, 
    0.09077419f, 0.19784088f, -0.12614481f, 0.21320051f, 0.28193942f, 0.10989661f, 0.07869417f, 0.22025360f, 
    0.03403977f, 0.18620580f, -0.01354848f, -0.35637465f, 0.09607252f, 0.31108639f, -0.35445976f, -0.20805757f, 
    -0.07941326f, 0.26813394f, -0.01770600f, 0.02348568f, -0.14245825f, 0.12569453f, 0.05742623f, 0.02111907f, 
    -0.01831323f, -0.04795651f, 0.00758432f, 0.20176023f, 0.50872517f, 0.17547396f, 0.32697943f, 0.03605538f, 
    -0.01094808f, 0.05542700f, -0.09563928f, -0.11261689f, 0.13971300f, 0.08758716f, -0.00088936f, -0.05594854f, 
    0.00227488f, -0.11644871f, -0.23175827f, -0.20007451f, 0.04000143f, 0.15489981f, 0.10001282f, -0.18716946f, 
    0.01009487f, -0.02717698f, 0.11221109f, -0.01977899f, -0.00706090f, 0.02762668f, 0.04384676f, 0.26992083f, 
    0.22765303f, 0.10418332f, 0.39123130f, 0.07322615f, 0.11834324f, 0.25088033f, 0.05289032f, 0.04470259f, 
    0.20088366f, 0.21819015f, 0.06850179f, -0.06473339f, -0.25043678f, -0.21150164f, -0.37657654f, 0.09801383f, 
    0.00693983f, 0.14655089f, -0.09576394f, 0.00217057f, -0.03464649f, -0.12622598f, 0.08603556f, 0.18647645f, 
    0.17408593f, 0.07706551f, -0.00585858f, -0.26288196f, 0.01548607f, 0.18249151f, 0.09858518f, 0.06658708f, 
    -0.01337960f, 0.03775355f, 0.19200616f, 0.16390683f, 0.03477472f, -0.00608480f, 0.16628775f, 0.03213157f, 
    -0.02223125f, -0.03116700f, 0.01081719f, 0.13177218f, 0.21289298f, -0.12154429f, -0.45551383f, -0.63989669f, 
    0.05152459f, 0.05857244f, 0.14800881f, 0.01447586f, 0.02750226f, -0.09106705f, -0.39325103f, 0.10999176f, 
    0.35315618f, -0.09752307f, 0.02308822f, -0.03746461f, -0.05642264f, 0.01059152f, -0.09155655f, -0.36007532f, 
    -0.32695046f, -0.55315280f, -0.10316541f, -0.20518486f, -0.07895509f, 0.00782923f, 0.00902879f, 0.30958495f, 
    -0.28795180f, -0.67186356f, -0.28448978f, -0.16521934f, -0.19839168f, -0.18628851f, -0.01869126f, -0.03199211f, 
    -0.06714301f, 0.25335881f, -0.33232552f, -0.77497232f, -0.02014459f, -0.13577056f, -0.05044509f, 0.29588336f, 
    0.07126888f, 0.06488804f, 0.30961815f, -0.06939954f, -0.08435922f, -0.17157176f, -0.13801429f, -0.24630100f, 
    0.19777757f, 0.02739577f, -0.16572903f, 0.19626784f, 0.13497058f, -0.25252733f, -0.03576987f, 0.07703556f, 
    -0.26465908f, 0.23151812f, 0.16451682f, -0.06797942f, -0.13004230f, -0.01686354f, 0.05694321f, -0.03078426f, 
    -0.08448244f, -0.02219448f, -0.02587972f, -0.01956901f, 0.11213957f, -0.39539254f, 0.16531356f, 0.56113869f, 
    -0.21296985f, 0.06467604f, -0.06374238f, -0.00018986f, -0.08615904f, 0.00276982f, -0.30499947f, -0.22485539f, 
    -0.00056824f, -0.20566355f, -0.23675945f, -0.21768242f, 0.07922652f, 0.08888958f, 0.05150859f, 0.27524585f, 
    0.23989351f, 0.28955358f, 0.09022769f, 0.01216163f, 0.02895447f, 0.22911528f, 0.19739057f, 0.29919425f, 
    0.01670095f, -0.04676156f, -0.07273698f, -0.11131985f, 0.02071508f, -0.01387086f, 0.01655764f, -0.00723124f, 
    0.00209497f, -0.26428065f, -0.49073738f, -0.22965214f, 0.06631834f, -0.02923253f, -0.07532965f, 0.18037771f, 
    -0.05525533f, 0.01384152f, -0.40566140f, -0.07865284f, -0.10392017f, -0.16341744f, 0.16451152f, -0.06359392f, 
    0.01103533f, -0.14266677f, -0.01994044f, -0.16661425f, -0.30182174f, -0.66207176f, -0.14717467f, -0.14608410f, 
    -0.12431139f, 0.08354732f, -0.23983829f, 0.31790370f, -0.07398070f, 0.03594275f, 0.36589643f, -0.19838290f, 
    -0.08834176f, 0.13091993f, 0.02507440f, 0.13472821f, 0.07919512f, -0.05455751f, -0.19090071f, -0.32705039f, 
    -0.07780361f, 0.03373936f, 0.05902505f, 0.18155724f, 0.12546833f, 0.28404558f, 0.18745036f, 0.26020375f, 
    0.55228698f, -0.16693133f, -0.20431057f, -0.02388500f, 0.08588250f, 0.04539482f, 0.17045099f, 0.23499788f, 
    -0.02194663f, -0.40588436f, -0.06183599f, -0.08672874f, -0.04079993f, 0.04375107f, 0.06871255f, -0.11754358f, 
    -0.06662664f, 0.02640392f, -0.16100593f, -0.08495753f, -0.10411043f, -0.04451440f, 0.08140358f, -0.03855538f, 
    -0.02255646f, 0.36666754f, -0.19889565f, -0.20279920f, -0.06301414f, 0.02069090f, 0.32463527f, -0.13423154f, 
    -0.02939763f, 0.07937387f, -0.23027146f, 0.28437799f, 0.25770369f, 0.04847029f, 0.01749385f, 0.01235338f, 
    0.04518707f, -0.06849753f, -0.01303306f, -0.27947995f, 0.03235649f, -0.20557939f, -0.24474832f, -0.25908834f, 
    -0.18413404f, -0.10802126f, 0.01997874f, -0.07636650f, -0.16672507f, 0.19951001f, 0.33789924f, 0.06239578f, 
    -0.03651685f, -0.02944040f, 0.12880531f, -0.01956325f, 0.29202053f, 0.35461426f, 0.16884075f, 0.03895127f, 
    0.02298276f, 0.05854554f, 0.05631011f, -0.11037308f, 0.17122146f, 0.00800781f, 0.07557623f, 0.06406885f, 
    -0.31669280f, -0.05416320f, 0.08403603f, 0.06873338f, -0.02153432f, 0.04416317f, 0.32235014f, -0.10810477f, 
    0.12697548f, 0.12730993f, 0.00759076f, 0.05906970f, -0.13602333f, 0.10619080f, -0.01368616f, 0.19467451f, 
    0.28583106f, -0.14828667f, -0.21967530f, -0.08547700f, 0.03434773f, 0.23791099f, 0.01997793f, 0.01143788f, 
    0.04928821f, -0.65191150f, 0.24599455f, 0.08016032f, -0.07325628f, -0.03192487f, 0.18505152f, 0.10066955f, 
    0.07586282f, 0.29629648f, -0.00369476f, 0.36327559f, 0.14869395f, 0.10505673f, 0.21168229f, -0.11296844f, 
    -0.11236497f, -0.17358461f, -0.19923536f, -0.32718349f, 0.01215230f, 0.22149879f, 0.04355263f, 0.10593115f, 
    -0.02690884f, 0.09603293f, 0.03302886f, 0.27313957f, -0.01184723f, 0.08234855f, 0.04854191f, 0.02036756f, 
    -0.08650514f, -0.09427018f, 0.00151576f, 0.12808082f, 0.05342607f, 0.56360197f, -1.04496539f, -0.86795193f, 
    0.06125158f, 0.21754842f, 0.19004771f, -0.03183590f, 0.05123853f, -0.03772353f, -0.69339442f, 0.04053461f, 
    0.11609247f, -0.06870157f, -0.08711395f, -0.14983425f, -0.03033048f, 0.13451234f, -0.14904003f, -0.43590546f, 
    0.14962325f, -0.11716019f, -0.08089096f, 0.00077712f, -0.05374645f, 0.09029139f, -0.22361718f, 0.20446108f, 
    -0.34450352f, 0.35138184f, -0.37723294f, -0.22413939f, -0.08468294f, -0.06776834f, 0.09204830f, 0.05443447f, 
    0.08168976f, 0.18382314f, -0.15088214f, -0.21327510f, 0.09941880f, 0.09461308f, 0.17041099f, 0.28700060f, 
    -0.04528056f, 0.16134703f, 0.06330940f, -0.17063689f, -0.35526454f, -0.13809934f, -0.03309748f, 0.09386522f, 
    0.11915350f, 0.04160469f, 0.12053339f, 0.46139875f, 0.17238484f, -0.03481713f, -0.01321463f, -0.00538951f, 
    0.20954897f, 0.22073059f, 0.17607513f, -0.01882521f, -0.09729542f, 0.14490038f, 0.06464111f, 0.05801133f, 
    -0.07306986f, -0.23532163f, 0.12710829f, 0.03679416f, 0.01385153f, -0.53218663f, 0.16661288f, 0.24853088f, 
    0.05867904f, -0.11623206f, -0.13314329f, -0.05052188f, 0.04877930f, -0.02636787f, 0.21468061f, 0.03673563f, 
    -0.29281324f, -0.10292892f, -0.05836441f, -0.02201878f, -0.01240661f, 0.04956871f, 0.17326155f, 0.27662867f, 
    0.12077817f, 0.14796390f, 0.15490392f, 0.03102613f, 0.08200447f, 0.05706045f, 0.02055370f, 0.29798594f, 
    0.19741587f, -0.07779339f, -0.03967615f, 0.08798245f, 0.04968112f, -0.07575639f, -0.05394604f, -0.16845156f, 
    -0.32589814f, -0.26457390f, -0.43258163f, -0.91134161f, -0.08867272f, -0.16236123f, -0.02153019f, 0.05854652f, 
    -0.09401120f, -0.02105303f, -0.34460288f, -0.08898336f, -0.08556141f, -0.14159496f, -0.01379063f, -0.17432146f, 
    -0.01731542f, -0.13407737f, -0.12639146f, -0.32269633f, 0.28509489f, -0.16251089f, -0.23803671f, -0.07267185f, 
    0.06705867f, 0.04522020f, -0.08772273f, 0.00971723f, -0.19700187f, 0.07578697f, 0.26707324f, -0.20609963f, 
    -0.21041349f, -0.21552891f, 0.01217037f, 0.00688139f, 0.12853391f, -0.06668060f, -0.10997133f, 0.22801779f, 
    0.09518458f, 0.19496930f, 0.00249704f, 0.09565701f, 0.03674150f, 0.11011071f, 0.56799448f, -0.61098701f, 
    -0.46484083f, -0.02611593f, 0.01997092f, 0.04959912f, 0.03725871f, 0.12926869f, 0.04308277f, 0.61586511f, 
    0.08073980f, -0.42364624f, 0.07437915f, 0.28588074f, 0.38190684f, -0.05433132f, -0.13257448f, -0.29687190f, 
    0.17724247f, 0.37827924f, -0.24830872f, -0.04439123f, -0.27753296f, -0.15851560f, 0.02571334f, -0.05159536f, 
    0.16519384f, -0.09596054f, -0.06242388f, -0.01061861f, 0.01899550f, 0.11579739f, 0.02945232f, -0.03674311f, 
    -0.09761765f, 0.17000499f, -0.07504658f, 0.11954858f, -0.03610587f, 0.03114798f, -0.06524203f, -0.01779437f, 
    -0.00773078f, 0.03574518f, 0.01644241f, 0.12208343f, -0.04969309f, 0.12381572f, -0.53623569f, 0.09789630f, 
    -0.29893771f, -0.10662727f, -0.00751108f, -0.15918534f, -0.10080560f, 0.20206754f, 0.31572500f, -0.25987330f, 
    -0.00408022f, -0.01804397f, -0.03041914f, -0.00856931f, 0.18680818f, -0.05567992f, -0.19046189f, 0.14370009f, 
    0.09983577f, 0.04909491f, 0.20229377f, -0.07842775f, 0.09991322f, 0.08032501f, 0.09790142f, -0.20580983f, 
    -0.18067800f, 0.04637083f, 0.08848935f, 0.04040919f, -0.00713744f, -0.09769019f, 0.22842588f, 0.02930933f, 
    0.19723071f, 0.12310855f, -0.07883953f, 0.12440021f, -0.18263301f, 0.11437692f, 0.11507612f, 0.11271545f, 
    -0.23921719f, 0.06303536f, -0.17824975f, -0.01371315f, -0.04750248f, -0.05772771f, -0.00364902f, -0.08050512f, 
    0.04955998f, -0.71370625f, -0.10334594f, -0.19899336f, -0.36239314f, 0.16358525f, -0.45944530f, -0.02240016f, 
    -0.02720820f, 0.04344031f, -0.25203097f, 0.22073559f, 0.47641382f, 0.11685281f, 0.05542732f, -0.18132961f, 
    -0.10166959f, -0.00898724f, -0.02050222f, -0.08504039f, 0.08050719f, -0.02300679f, -0.01520259f, 0.07015390f, 
    -0.21017826f, 0.01104918f, 0.03074140f, 0.20874220f, 0.14856191f, 0.21336527f, -0.10086349f, -0.10758825f, 
    -0.14402534f, -0.22923431f, 0.02889576f, -0.08185507f, -0.14879319f, 0.08760913f, 0.14676136f, -0.10349627f, 
    -0.11521688f, -0.03416092f, -0.20487139f, 0.13099825f, 0.05888993f, -0.02019759f, -0.19511026f, -0.02732975f, 
    -0.26898172f, -0.08999453f, -0.04509936f, 0.12995529f, 0.05416273f, 0.09262532f, -0.02576355f, -0.27809739f, 
    -0.16797179f, -0.13330923f, -0.01680969f, 0.01053427f, 0.01221008f, -0.03992707f, -0.06392265f, -0.04956069f, 
    -0.11482767f, 0.46963274f, 0.37842420f, -0.14825967f, -0.12554853f, -0.18369634f, 0.09158110f, 0.22586553f, 
    -0.01827392f, -0.02464955f, -0.09370992f, 0.29124910f, 0.12334012f, -0.01667732f, 0.28198442f, -0.04797423f, 
    0.21717457f, -0.00127431f, 0.24886994f, -0.68883049f, -0.01518431f, -0.04904392f, -0.02712534f, 0.11296656f, 
    -0.04323543f, -0.04165117f, 0.14365548f, 0.15553591f, -0.21264507f, 0.31878829f, 0.09109946f, -0.07039185f, 
    0.21277681f, 0.14743029f, 0.04981019f, -0.02540780f, 0.13734509f, 0.28852603f, -0.05014347f, -0.15178731f, 
    -0.06435144f, -0.11132047f, 0.18650946f, 0.00636494f, -0.17818099f, -0.01187492f, -0.06027990f, 0.14176331f, 
    0.13442193f, -0.05835168f, -0.29302579f, 0.08217310f, 0.03998702f, 0.08229807f, 0.05533427f, 0.27715567f, 
    0.38817775f, -0.02654356f, -0.19426000f, -0.07475032f, 0.06413809f, 0.03891115f, 0.08761513f, 0.07127123f, 
    0.18807465f, 0.10209919f, 0.04616142f, -0.00434334f, -0.03993298f, -0.05444548f, 0.01591370f, 0.10646259f, 
    0.14010054f, -0.18254629f, 0.04224687f, 0.13833728f, 0.16691634f, 0.03449214f, 0.20786142f, 0.09943028f, 
    -0.11594953f, -0.03968289f, 0.16031736f, 0.28602403f, -0.21739769f, -0.01313085f, -0.13829288f, 0.03445292f, 
    -0.16355410f, -0.04359968f, -0.13097897f, 0.13861530f, 0.42589018f, -0.06795094f, -0.10664228f, -0.15207581f, 
    0.03473656f, 0.07701071f, 0.03454243f, -0.49110401f, 0.23501308f, -0.50537246f, 0.14706364f, -0.04327829f, 
    -0.11873490f, 0.04270502f, -0.00073600f, 0.08408456f, 0.11603522f, 0.21923344f, 0.17076264f, -0.21109560f, 
    -0.33900550f, -0.29729638f, -0.01813396f, -0.04647113f, -0.02069389f, -0.06905627f, 0.02278348f, 0.29778522f, 
    -0.15116757f, 0.14360413f, -0.31251729f, 0.02067642f, 0.18731798f, 0.01028313f, 0.23858039f, -0.27736998f, 
    0.01021207f, 0.02108106f, 0.23640254f, -0.08411942f, 0.03854054f, -0.05732748f, 0.00485874f, 0.16946650f, 
    0.02826899f, 0.26810074f, 0.23946817f, 0.09043248f, 0.15989432f, 0.01239081f, 0.05621672f, -0.22430766f, 
    -0.05220503f, -0.01485192f, 0.00024103f, -0.01639270f, 0.01872053f, 0.04216484f, -0.03163707f, -0.01765226f, 
    -0.02224698f, 0.03399992f, 0.02658872f, 0.03818000f, -0.01079041f, -0.01935137f, 0.02162741f, 0.04236392f, 
    -0.06550641f, 0.01794228f, -0.00682354f, -0.06580725f, 0.03404528f, -0.06771784f, -0.05192804f, 0.00736525f, 
    0.00524549f, -0.04682297f, -0.03446454f, -0.01865461f, -0.04635011f, -0.01949476f, 0.04252881f, -0.01722469f, 
    0.00004110f, -0.01721546f, -0.06743982f, 0.04008683f, -0.00638515f, 0.03768836f, -0.01411395f, -0.05926403f, 
    -0.01663199f, -0.01505503f, -0.02105626f, 0.00070083f, -0.00411483f, -0.02228128f, 0.02458045f, -0.01803406f, 
    -0.02613406f, -0.00650048f, 0.03125679f, 0.02006811f, 0.04551998f, 0.01740677f, -0.04094001f, -0.06356048f, 
    -0.00892210f, -0.01331432f, -0.04645968f, 0.04462649f, 0.04178860f, -0.06613214f, -0.03850144f, -0.00748926f, 
    -0.00104131f, -0.06619200f, -0.05692623f, 0.03581683f, 0.01980974f, -0.05855441f, 0.03662412f, -0.01995458f, 
    -0.01973431f, 0.01964673f, -0.03011739f, -0.00772933f, 0.01298687f, -0.04936688f, -0.02020691f, -0.05885356f, 
    -0.02302481f, -0.05405996f, 0.02318829f, -0.01728946f, 0.04188216f, -0.01643977f, -0.06728239f, -0.04539398f, 
    0.03281552f, 0.04867750f, -0.03315481f, -0.05168300f, -0.05505914f, 0.01204333f, -0.03560878f, -0.00424709f, 
    -0.04577671f, -0.02721570f, -0.04460446f, -0.04866583f, -0.01199594f, 0.01685698f, 0.04215103f, 0.00868221f, 
    -0.02692532f, 0.04514413f, 0.05041500f, 0.01147515f, -0.01705153f, -0.04508155f, -0.02694569f, -0.00383662f, 
    -0.04528113f, 0.01387242f, 0.04150704f, -0.05041917f, -0.06036089f, 0.00628221f, 0.01908374f, -0.01247870f, 
    0.05012808f, 0.04136630f, 0.00113469f, -0.06824803f, 0.01903701f, -0.03235775f, -0.06151747f, 0.04050805f, 
    -0.04057857f, -0.04380517f, -0.02319409f, 0.04208201f, 0.04378130f, -0.05647114f, -0.03284618f, 0.01699503f, 
    -0.05268776f, -0.05299151f, 0.04579130f, 0.02446963f, 0.04634954f, 0.00563144f, 0.01461993f, 0.04086290f, 
    -0.03456129f, 0.04237429f, -0.01047145f, -0.06238546f, 0.03935593f, -0.04918051f, 0.03393047f, -0.00933553f, 
    -0.04909192f, -0.02287468f, 0.03879820f, -0.01823726f, 0.02609812f, -0.03292848f, -0.00734778f, 0.00703764f, 
    -0.00507983f, 0.03545688f, -0.04347046f, 0.03586862f, -0.05542091f, -0.02412956f, 0.02855033f, 0.04746693f, 
    -0.05234158f, -0.01397799f, 0.03243268f, 0.04906937f, 0.00529062f, -0.03739466f, -0.04592270f, 0.01121251f, 
    -0.03590996f, -0.03293624f, 0.01277749f, 0.01806946f, 0.03184358f, -0.01215565f, -0.06408712f, -0.06065244f, 
    0.01655279f, 0.02602858f, 0.01939498f, 0.04358828f, -0.02837631f, 0.00182325f, -0.06308599f, -0.02062433f, 
    -0.03481084f, -0.06161683f, -0.06084671f, 0.03730383f, 0.02854622f, -0.02467709f, -0.03468611f, -0.04741455f, 
    0.02174492f, 0.00767353f, 0.01748964f, 0.04311591f, 0.01902230f, 0.03445540f, 0.02593603f, -0.05903484f, 
    0.04865674f, 0.03163571f, -0.00816554f, -0.06430821f, -0.03478017f, -0.03147399f, 0.03172245f, -0.03053619f, 
    -0.01257813f, 0.04925846f, 0.00939235f, 0.00363772f, -0.02406549f, 0.02310052f, 0.01632334f, -0.05104104f, 
    -0.02534214f, -0.01078892f, -0.02125285f, 0.01864933f, -0.00936172f, -0.00762253f, 0.01132748f, -0.05329037f, 
    0.00321819f, 0.02686355f, -0.03843212f, -0.03699318f, -0.02042939f, -0.02574907f, -0.01638667f, -0.05145193f, 
    0.00303228f, 0.04413943f, -0.03072798f, -0.03954728f, 0.03318968f, 0.02728633f, 0.02292551f, -0.02764078f, 
    0.01792492f, -0.00896545f, 0.01149739f, -0.04443742f, -0.00727739f, -0.04688667f, 0.02852941f, -0.04263458f, 
    -0.03601193f, -0.04076891f, -0.05770692f, 0.03880820f, -0.04403076f, -0.04288571f, -0.04927692f, 0.01849373f, 
    -0.05385390f, 0.02797379f, -0.02300857f, 0.04799118f, 0.01558920f, 0.03531324f, -0.00306124f, -0.03781717f, 
    -0.01569680f, -0.03605704f, -0.04502627f, -0.05238553f, -0.03232130f, -0.02488706f, 0.01561187f, 0.03432259f, 
    -0.00498391f, -0.05120305f, -0.00558683f, 0.04663391f, -0.02480751f, 0.01405282f, -0.02411644f, -0.02472516f, 
    0.01006201f, -0.98364687f, 0.02774999f, -0.08187190f, -0.16466559f, -0.11354348f, 0.09288595f, -0.00417692f, 
    0.12825467f, 0.38584372f, 0.05406824f, 0.09137256f, 0.11309889f, 0.08326537f, 0.16591454f, 0.23607764f, 
    -0.10518412f, -0.03466526f, -0.24313356f, -0.12936805f, -0.19311450f, -0.03115557f, -0.03096938f, 0.07761797f, 
    -0.04464988f, -0.14088002f, 0.00690240f, 0.66969687f, 0.16453983f, -0.04479345f, -0.21862209f, -0.26095888f, 
    0.17790888f, 0.06112633f, 0.07471517f, 0.03833814f, -0.34491396f, -0.05090931f, 0.32949656f, 0.16163670f, 
    -0.19232219f, -0.31438217f, 0.02153561f, 0.03001787f, 0.03138768f, -0.04625593f, -0.34624258f, -0.80753136f, 
    0.10424348f, -0.21784954f, -0.05599998f, -0.08470729f, 0.07207171f, -0.04892706f, 0.00119087f, -0.01369166f, 
    0.15361708f, -0.06954183f, -0.13834625f, -0.21488430f, 0.14929771f, -0.05092749f, -0.03738694f, -0.02178497f, 
    0.05476132f, 0.02523367f, 0.05805498f, -0.36603162f, -0.26924521f, -0.04081869f, -0.11907665f, -0.08292065f, 
    0.07553977f, 0.25564730f, 0.34253073f, -0.05285678f, 0.05189337f, 0.03637060f, -0.05772493f, 0.07439318f, 
    0.06707723f, -0.34552616f, -0.01690416f, -0.32336107f, 0.05304072f, -0.16371338f, 0.28482699f, 0.11515652f, 
    0.01294384f, -0.12699583f, -0.03081103f, 0.19042954f, 0.15549923f, -0.06785098f, -0.10289653f, -0.02583860f, 
    0.02485694f, 0.23573703f, -0.01980262f, -0.31560600f, -0.31013504f, -0.36309439f, 0.10390578f, -0.47046044f, 
    -0.33351716f, 0.10177565f, 0.02879996f, -0.13139100f, 0.21733223f, -0.15421261f, 0.19296615f, 0.00200072f, 
    -0.18690120f, -0.08571944f, 0.25552899f, 0.08669746f, 0.13170090f, -0.03991757f, -0.03793415f, -0.26072717f, 
    -0.24261206f, -0.10932460f, -0.31319883f, 0.01644539f, -0.00156884f, 0.19686790f, -0.08413354f, -0.28620306f, 
    -0.22223718f, -0.11656874f, 0.11027224f, 0.40072939f, 0.10099725f, 0.04104419f, 0.00445882f, 0.54172575f, 
    -0.41248864f, -0.04958990f, -0.30750769f, -0.51374394f, 0.64114678f, 0.10380128f, -0.29643232f, -0.07472607f, 
    0.07670913f, 0.25096792f, 0.53653765f, -0.26175967f, 0.14903179f, -0.14350611f, 0.12606052f, 0.13278967f, 
    0.22945520f, 0.09849091f, -0.48862535f, -1.60538578f, -0.10159370f, -0.13105038f, 0.09192174f, 0.02940673f, 
    0.11855873f, 0.01057205f, 0.36513364f, -1.13484180f, -0.78082472f, -0.03578007f, 0.02916115f, -0.02206117f, 
    0.12538952f, 0.09453494f, -0.09286250f, 0.15958704f, 0.01683800f, -0.38801366f, -0.07153942f, -0.24717429f, 
    0.06118194f, -0.16112943f, 0.15844700f, 0.23425727f, -0.25606242f, 0.06702063f, 0.26133075f, -0.12821464f, 
    -0.38624302f, -0.10568936f, 0.31250599f, 0.13472830f, 0.12034544f, 0.39566013f, 0.22626193f, -0.05144709f, 
    0.01948890f, -0.00751425f, 0.33810791f, 0.10962122f, -0.13041727f, 0.09779315f, 0.21776931f, 0.34508425f, 
    0.33078685f, -0.12064334f, 0.15970348f, 0.04623390f, 0.18613584f, -0.04143262f, 0.19480962f, 0.03215075f, 
    -0.30656344f, 0.11649498f, 0.16853660f, -0.15012570f, -0.18831378f, -0.03332760f, 0.12911828f, -0.02792376f, 
    0.06438162f, 0.03400596f, 0.39051080f, -0.24687411f, -0.09432381f, 0.06345933f, 0.23497766f, 0.17835616f, 
    0.13189882f, 0.11117887f, 0.40011770f, 0.39327753f, -0.16837928f, -0.07094616f, -0.10909131f, 0.01429658f, 
    0.04724393f, 0.04751898f, 0.22459227f, 0.31375495f, 0.36867976f, -0.09355078f, -0.06488319f, -0.07908583f, 
    0.14852750f, 0.09925941f, -0.15193543f, -0.09320065f, -0.01364076f, 0.47135684f, 0.02795639f, -0.16554898f, 
    0.22752774f, 0.34767362f, -0.12430337f, 0.06531132f, 0.33976912f, -0.11788490f, -0.04653011f, -0.27848071f, 
    -0.05147810f, 0.14487328f, -0.13278025f, -0.12239353f, -0.15943547f, -0.26956874f, -0.28250182f, -0.14123748f, 
    -0.04898204f, -0.10011351f, -0.18242484f, -0.11219785f, 0.00517761f, 0.15202248f, 0.50464755f, 0.13371609f, 
    0.13993756f, 0.09622514f, 0.05342379f, 0.02985532f, 0.07272414f, 0.08449458f, -0.08380336f, 0.16204527f, 
    -0.63315654f, -1.31197667f, 0.01628487f, -0.19142552f, 0.03478020f, -0.06502344f, 0.22145721f, -0.00208058f, 
    -0.03204299f, -0.08117133f, 0.02357155f, -0.23593459f, -0.13387641f, -0.12081597f, -0.18439423f, 0.06725256f, 
    0.01506019f, -0.11955708f, 0.14985348f, 0.16170417f, 0.06104350f, 0.08083739f, 0.09660666f, 0.10060058f, 
    -0.08107299f, -0.12141360f, 0.15233451f, 0.07637709f, -0.01758960f, -0.22266452f, -0.11322850f, -0.37594187f, 
    -0.02182739f, 0.18596421f, 0.04852183f, -0.04891079f, -0.06471155f, -0.02309709f, -0.06650749f, -0.04375510f, 
    0.01105083f, -0.03270598f, 0.08150118f, 0.19649009f, -0.03508030f, 0.05951153f, 0.06628759f, -0.00772217f, 
    -0.01226071f, -0.19640037f, 0.14417046f, -0.10658174f, 0.17218409f, -0.16028534f, 0.11426605f, -0.50705332f, 
    -0.11472859f, 0.07120335f, 0.11359125f, 0.19742675f, -0.05222557f, 0.03418643f, -0.19287896f, -0.01360367f, 
    0.32218984f, -0.19696513f, -0.03773228f, -0.06991594f, 0.08029854f, -0.18848120f, -0.03752163f, -0.49776286f, 
    0.04388240f, -0.11464638f, 0.02755897f, -0.04566524f, -0.00687090f, 0.02360840f, -0.20852202f, 0.11264022f, 
    0.00725520f, 0.26021704f, 0.02599289f, 0.02321400f, 0.20647159f, 0.14219990f, 0.14512323f, 0.05457988f, 
    -0.12346311f, -0.72108394f, -0.47993550f, 0.03217474f, -0.01216616f, -0.10144552f, 0.14044614f, 0.15617691f, 
    -0.24044526f, -0.08087238f, 0.22180353f, 0.08823154f, -0.14421190f, -0.13702413f, 0.15977792f, -0.26226372f, 
    -0.14677826f, 0.04821973f, -0.07095524f, -0.30411452f, 0.07024107f, -0.17417300f, -0.03406198f, 0.01427038f, 
    0.06644033f, 0.28719932f, -0.18791562f, -0.15125719f, 0.17570737f, 0.11486755f, 0.17227523f, -0.17021707f, 
    -0.02006582f, 0.13540551f, 0.21553595f, 0.05943350f, 0.14967239f, 0.10592761f, -0.13945998f, 0.22061105f, 
    0.22249509f, 0.12162197f, -0.08835303f, -0.05952092f, 0.03374916f, 0.00347166f, 0.29571566f, 0.25293875f, 
    0.11826345f, -0.05264795f, -0.19810736f, -0.01133438f, -0.07521570f, 0.18815419f, 0.02809653f, -0.18679143f, 
    -0.65307045f, -0.60021365f, -0.22859859f, -0.05821962f, -0.40362093f, 0.09884224f, 0.07939708f, -0.38304719f, 
    -0.03913279f, 0.09809887f, 0.13008372f, -0.31938821f, 0.28206918f, -0.31453237f, -0.03763862f, 0.07821580f, 
    -0.22961465f, 0.01127173f, -0.57700396f, -0.87581027f, 0.05032192f, 0.19223072f, -0.11695398f, 0.27509928f, 
    0.08093420f, 0.13469458f, -0.22668046f, -0.30515397f, -0.16777444f, -0.09843127f, 0.14914075f, 0.16326424f, 
    0.21243568f, -0.18654801f, 0.30826649f, 0.07596426f, -0.04259449f, -0.83788437f, -0.09787159f, 0.32215369f, 
    -0.18991375f, 0.08972482f, 0.03441854f, 0.05216061f, -0.03131113f, -0.27691817f, -0.05036501f, -0.22247209f, 
    -0.02377076f, -0.26650226f, 0.06794489f, 0.10669834f, -0.01133668f, -0.04842907f, 0.06129994f, 0.25936267f, 
    -0.00840241f, -0.18618041f, 0.09693791f, 0.07198717f, 0.03749679f, 0.08342634f, -0.16890596f, 0.09900760f, 
    0.16516830f, -0.07256762f, 0.06100317f, -0.13428140f, 0.14968073f, -0.00581958f, 0.01501139f, -0.18219666f, 
    0.06129795f, -0.30182871f, 0.13917632f, 0.17294550f, 0.13377652f, 0.16684462f, 0.02499176f, -0.01921744f, 
    -0.04727034f, -0.01113961f, -0.21564712f, 0.30274266f, 0.00151277f, 0.00375501f, 0.21042760f, 0.08643159f, 
    0.25818667f, 0.42933512f, 0.10512346f, 0.22873336f, 0.12605090f, 0.21748462f, -0.07269080f, -0.02837714f, 
    0.05123541f, -0.07533632f, 0.42955461f, 0.25022659f, 0.25166106f, 0.02074538f, -0.09657973f, -0.07539856f, 
    -0.15183394f, -0.00914229f, -0.24747723f, -0.27429304f, -0.28549984f, -0.01594565f, -0.20813385f, 0.21540466f, 
    0.06577692f, 0.08567443f, -0.05047152f, -0.16468209f, -0.11897003f, 0.27149242f, 0.08743671f, -0.07253258f, 
    -0.00212410f, 0.13464136f, -0.06572090f, 0.03756050f, 0.00447030f, -0.47516608f, -0.16198705f, -0.20425580f, 
    0.14489180f, -0.28339154f, 0.06088048f, 0.13993621f, 0.06774434f, 0.06887522f, -0.12556753f, 0.26052326f, 
    0.36231098f, 0.06609091f, -0.01636466f, 0.18715563f, 0.00843600f, -0.10456821f, 0.01529155f, 0.08892716f, 
    -0.27137208f, -0.57995182f, -0.01771735f, 0.03766943f, 0.06809916f, -0.08211888f, 0.00773194f, -0.07511754f, 
    0.27184442f, 0.07185332f, 0.41870186f, -0.10703650f, -0.10266054f, -0.31331339f, 0.10208229f, 0.12907055f, 
    -0.04308186f, 0.25843528f, -0.03653400f, 0.10749939f, 0.10120431f, -0.04073221f, 0.22681634f, -0.28599706f, 
    -0.21090752f, 0.03229792f, 0.07185851f, -0.00522598f, -0.03711078f, -0.04229461f, -0.02093571f, -0.16655476f, 
    -0.02399600f, 0.04947810f, -0.07349451f, -0.12361255f, 0.01874672f, -0.34873924f, 0.18826450f, -0.28599176f, 
    -0.07624476f, 0.04358686f, 0.13972861f, 0.03758177f, 0.09185512f, 0.15617178f, 0.20690626f, 0.05374893f, 
    0.04745053f, 0.00190168f, -0.08008293f, -0.04657958f, -0.07341804f, 0.18027519f, 0.22331394f, -0.17018868f, 
    0.02722052f, 0.06037380f, 0.00887071f, 0.08416637f, -0.00066613f, -0.05265776f, 0.26276556f, -0.00152935f, 
    0.25782946f, 0.06916013f, -0.02527656f, -0.04677072f, 0.03749515f, -0.06394683f, 0.14471932f, -0.11687101f, 
    0.03888098f, 0.03971750f, 0.15725178f, 0.23872717f, -0.03858799f, -0.00689583f, 0.07431257f, 0.14487162f, 
    0.07569839f, -0.02368452f, 0.04760696f, 0.06181664f, 0.05822993f, -0.02817253f, -0.11901724f, 0.10368148f, 
    -0.00330832f, -0.11522353f, 0.42878968f, 0.10727426f, 0.37972072f, -0.07061175f, 0.03526764f, -0.23744527f, 
    0.02752983f, -0.11447010f, 0.19010206f, 0.25725687f, 0.01441378f, -0.18017738f, 0.21761312f, 0.03224336f, 
    0.03252694f, 0.02229884f, 0.01511348f, -0.18368632f, 0.02066894f, 0.06142829f, 0.03774912f, 0.25724134f, 
    0.03411169f, 0.02090113f, 0.08085737f, 0.21783400f, 0.25105917f, 0.18319175f, 0.26298758f, 0.03895573f, 
    -0.13632266f, -0.23824613f, -0.03314464f, -0.02586842f, -0.04393199f, 0.15257826f, -0.56004518f, 0.46355581f, 
    0.09871405f, -0.03463501f, -0.06580786f, 0.14551592f, -0.06805998f, 0.08781411f, -0.10263722f, 0.00976296f, 
    -0.23809242f, -0.11064394f, -0.07595269f, -0.15545104f, -0.07758396f, -0.00520946f, -0.19050053f, -0.07341801f, 
    -0.11525082f, 0.09741595f, -0.11465213f, -0.18471788f, -0.04061911f, -0.01550643f, -0.23799066f, -0.02169350f, 
    0.00079870f, -0.04186948f, -0.28506190f, -0.21451429f, -0.03963971f, -0.10340759f, -0.00743716f, 0.13857581f, 
    -0.14283092f, -0.16952147f, -0.19627175f, -0.19068339f, -0.04168066f, 0.05569492f, -0.10777868f, 0.09092091f, 
    -0.05287082f, -0.07765988f, 0.05160121f, -0.20577389f, -0.29915318f, 0.07465561f, -0.09800744f, -0.18660909f, 
    -0.06103237f, 0.02836533f, -0.00007134f, -0.02825745f, -0.12029199f, -0.52077049f, -0.02546936f, -0.06600267f, 
    -0.04575966f, 0.04095937f, -0.16084488f, -0.07981233f, 0.05955169f, 0.08015735f, 0.31054851f, 0.13134423f, 
    -0.05757998f, -0.13426015f, -0.00404049f, -0.08405976f, -0.05076107f, -0.31068754f, 0.32574448f, -0.01979595f, 
    0.14553712f, -0.31967354f, -0.04328240f, -0.05382277f, -0.00841529f, -0.07272681f, 0.17902932f, -0.11475300f, 
    0.06493935f, -0.04399707f, 0.00805533f, 0.02741241f, 0.07678310f, 0.10004873f, 0.00376041f, 0.25228509f, 
    0.07097060f, -0.08833641f, -0.05074287f, -0.20005366f, -0.06330709f, -0.01950957f, -0.01237923f, -0.02278680f, 
    0.13559483f, 0.11017542f, -0.05851503f, 0.05167744f, 0.20423505f, 0.10632906f, 0.07228366f, -0.00031873f, 
    0.04473898f, 0.24267222f, -0.15646993f, -0.12300227f, -0.22543491f, 0.04043227f, 0.03538014f, -0.04837218f, 
    0.01958127f, 0.16649222f, 0.23718160f, 0.32714820f, 0.07720820f, -0.30759999f, 0.06831879f, 0.06516182f, 
    -0.00943538f, -0.02682907f, 0.03181875f, 0.21338186f, -0.05940676f, 0.49035186f, -0.05106574f, -0.05056568f, 
    0.06368518f, 0.00607661f, -0.14640705f, 0.12017125f, 0.23676850f, 0.14073500f, -0.13027371f, -0.11610390f, 
    -0.21115747f, -0.31415403f, 0.00343607f, 0.09530338f, -0.00151976f, -0.18619213f, -0.09235074f, 0.04991763f, 
    0.08342008f, -0.10792625f, -0.14983809f, 0.00403858f, -0.06024170f, 0.00518970f, 0.41958618f, 0.17202182f, 
    0.18853678f, 0.19876438f, 0.02630771f, 0.10460953f, -0.13959238f, 0.07129274f, -0.05681852f, 0.26545841f, 
    -0.04944899f, -0.32253316f, -0.02425591f, 0.09604979f, 0.01187405f, 0.09122654f, -0.08421589f, -0.10853198f, 
    -0.01704272f, -0.05170342f, -0.02557447f, -0.05313509f, -0.00490628f, -0.02537303f, -0.01161436f, -0.03641404f, 
    -0.02886373f, -0.04206556f, 0.03690728f, 0.02354112f, -0.01434840f, -0.03218611f, -0.00526800f, -0.03736379f, 
    -0.01959516f, -0.04710300f, -0.03638795f, 0.02017642f, -0.00309093f, -0.03993741f, -0.00961330f, -0.04449410f, 
    0.01949175f, 0.00299791f, -0.05385193f, -0.04935687f, -0.02568691f, -0.00777204f, 0.01925403f, -0.01879694f, 
    0.03611146f, 0.00842194f, -0.02867026f, 0.02497177f, -0.00181526f, -0.00275185f, -0.02727908f, -0.03347575f, 
    -0.03203201f, 0.04903953f, 0.00557858f, 0.02091482f, -0.01573103f, -0.00605717f, -0.04152622f, -0.01957894f, 
    -0.04321577f, -0.03033810f, 0.01393182f, 0.00182450f, 0.01755801f, -0.02871253f, 0.04488838f, 0.04536735f, 
    -0.04818636f, 0.02246896f, -0.03766228f, 0.01215272f, -0.04369003f, -0.04435421f, -0.00675245f, -0.03227556f, 
    0.03778792f, -0.06400432f, -0.06249508f, 0.01851399f, -0.02010941f, 0.00889392f, -0.05090074f, 0.02871229f, 
    0.01253565f, -0.01476554f, 0.04386726f, -0.06337233f, -0.03209427f, -0.05896407f, -0.06313662f, -0.04778033f, 
    -0.05425790f, -0.05795296f, 0.04963575f, -0.03091215f, -0.04039118f, -0.06414282f, 0.03494963f, 0.03720039f, 
    -0.00745448f, -0.04607549f, -0.04943053f, -0.04079206f, -0.00630592f, 0.01519386f, 0.01044948f, 0.03644449f, 
    -0.02262284f, -0.00011445f, -0.03417733f, -0.05868652f, -0.02124382f, 0.03849976f, -0.05799093f, 0.00081446f, 
    0.00876889f, -0.06597841f, -0.01071740f, -0.01538230f, 0.00425772f, -0.01414776f, -0.05145258f, -0.04662679f, 
    -0.03239110f, -0.02438563f, 0.01513484f, -0.05669314f, -0.05348824f, -0.04873275f, -0.01002177f, -0.01223255f, 
    0.02388708f, -0.05346817f, -0.02852849f, 0.00593086f, -0.05448463f, 0.03282467f, 0.04241416f, -0.01555222f, 
    -0.05645755f, 0.03636355f, 0.04167920f, 0.04782735f, 0.01966080f, 0.00294720f, 0.02076105f, 0.03630527f, 
    -0.05448835f, -0.05781299f, 0.01792132f, -0.05374641f, 0.04854140f, -0.00831851f, -0.06002624f, 0.00263893f, 
    -0.06303401f, -0.05212405f, -0.06146617f, -0.05628693f, -0.01415967f, 0.01552154f, -0.05512505f, 0.00543177f, 
    0.05987870f, -0.01855828f, -0.05865231f, -0.02347496f, 0.03286589f, 0.03546516f, 0.03849394f, -0.05534637f, 
    0.05036078f, -0.01767612f, 0.01910672f, 0.03421716f, 0.01170744f, 0.00287702f, 0.00784090f, 0.00401951f, 
    0.03452906f, -0.04140146f, -0.01561911f, 0.02323942f, -0.04163003f, 0.00362024f, -0.05240913f, 0.03793520f, 
    0.04415126f, 0.02364253f, 0.03397701f, -0.03176347f, 0.04065296f, 0.02889379f, -0.03940683f, 0.00612389f, 
    -0.03596063f, 0.04744270f, -0.05422923f, -0.05390306f, -0.03369171f, -0.03701754f, 0.05330607f, -0.00951930f, 
    0.04889122f, -0.02121229f, -0.02870353f, -0.03845589f, -0.02694734f, 0.03488303f, -0.03419574f, -0.01887278f, 
    -0.05436843f, -0.02217405f, 0.03678437f, -0.03744962f, -0.02304655f, -0.04560243f, 0.04134060f, 0.01046532f, 
    -0.06257346f, -0.06081834f, 0.02369762f, -0.02960694f, -0.04153584f, -0.02614083f, -0.02801215f, 0.03589880f, 
    0.04794951f, -0.01626297f, -0.05240043f, 0.02738822f, -0.04278345f, -0.01849700f, 0.02217884f, 0.04871378f, 
    0.04195172f, 0.01530234f, 0.02448906f, 0.00656834f, 0.00369984f, 0.03238974f, 0.02142547f, 0.01355138f, 
    0.00085762f, -0.01022472f, 0.03263569f, -0.06171994f, 0.02881917f, 0.00561565f, 0.05235089f, -0.05685629f, 
    0.00887721f, -0.05945725f, 0.00940115f, 0.01044971f, -0.00354349f, -0.03338142f, -0.00702198f, -0.01182382f, 
    -0.00733467f, 0.00853318f, -0.04061327f, -0.01533393f, -0.01462653f, -0.05449023f, 0.02997761f, -0.01672271f, 
    0.02057248f, -0.00025395f, 0.03642483f, 0.04485644f, 0.02009595f, -0.00181725f, 0.03313204f, 0.01295870f, 
    0.00947732f, 0.03092594f, -0.02068578f, -0.06299217f, -0.02019862f, -0.02439527f, 0.03417069f, -0.00252786f, 
    -0.01221825f, 0.04087044f, 0.04131766f, 0.04109668f, -0.05071230f, 0.00651610f, -0.03932440f, -0.02933200f, 
    -0.05671251f, 0.04923833f, -0.02658797f, 0.02808259f, -0.00279952f, 0.01515492f, -0.03353202f, 0.04599859f, 
    0.26485813f, 0.43362716f, 0.28841344f, 0.04487687f, 0.00007037f, 0.12807503f, -0.02440195f, 0.03998956f, 
    -0.05010824f, 0.27251333f, 0.25587994f, 0.01441184f, 0.04700559f, 0.03798824f, 0.09759288f, -0.02505552f, 
    0.09946338f, -0.28416643f, -0.35569766f, -0.22652990f, 0.02451270f, 0.16954342f, 0.24946733f, 0.01375652f, 
    0.12296115f, 0.20129244f, 0.19339657f, -0.18144836f, 0.07548191f, 0.12584917f, 0.08556810f, 0.29465282f, 
    0.09169213f, -0.15631488f, -0.02839853f, 0.03355856f, -0.26914662f, -0.26554057f, -0.15885715f, 0.24243341f, 
    0.11820606f, 0.25132626f, 0.03653086f, -0.13355152f, 0.32055581f, 0.62090534f, -0.03197046f, 0.05966190f, 
    -0.06985940f, -0.18236503f, 0.17519929f, 0.22532210f, -0.03353090f, 0.28972155f, 0.24512281f, 0.36634755f, 
    0.14273784f, -0.03326162f, 0.06594360f, -0.22018518f, -0.07270761f, -0.02504317f, -0.20308833f, 0.00936381f, 
    -0.45779046f, 0.06965585f, 0.10030670f, -0.26450101f, -0.03996648f, -0.02343558f, -0.13416126f, 0.26130235f, 
    0.22604494f, 0.16624285f, -0.04733301f, 0.10224974f, 0.07289986f, 0.22359870f, 0.02528788f, 0.09856229f, 
    -0.10177857f, 0.79123658f, 0.48019436f, 0.03266698f, 0.05839114f, -0.01813378f, -0.00651920f, -0.03845729f, 
    0.01855646f, 0.13952991f, -0.00174463f, 0.04579971f, 0.12464879f, -0.10282336f, 0.26041582f, 0.18593809f, 
    -0.02474192f, 0.22814533f, 0.31333911f, 0.12595780f, 0.06614465f, 0.03833445f, 0.05556947f, -0.16946466f, 
    -0.20353867f, -0.02606287f, -0.06562462f, 0.10909121f, -0.13222727f, -0.07556795f, 0.03543337f, 0.00385470f, 
    0.10625125f, -0.08572241f, 0.06789140f, -0.00429777f, -0.08946972f, -0.77285254f, -0.29531199f, 0.15309790f, 
    -0.30385816f, -0.46790874f, 0.15872762f, 0.05987239f, 0.03657474f, 0.34264067f, -0.20283893f, -0.34843355f, 
    -0.39691803f, 0.09135810f, -0.09478620f, 0.04356966f, -0.10742151f, 0.05275580f, 0.11021796f, -1.15220642f, 
    -0.39472234f, -1.00294185f, -0.01244055f, 0.15560576f, -0.16599520f, -0.09770717f, -0.09178220f, -0.09765613f, 
    0.28505838f, -0.07177061f, -0.29508379f, -0.05329050f, -0.33034283f, -0.05413423f, 0.05744367f, -0.20460376f, 
    0.15178110f, -0.13642286f, -0.03528916f, 0.18131958f, -0.18432280f, -0.11994379f, -0.32085088f, -0.07731786f, 
    0.08687589f, -0.41143385f, 0.46673539f, 0.47955295f, 0.32565013f, -0.10520881f, -0.00761959f, -0.01647878f, 
    -0.05084034f, 0.05859542f, 0.18146238f, 0.22136027f, 0.05800213f, -0.11713842f, -0.47163624f, -0.05501235f, 
    -0.00996560f, 0.12043917f, -0.01582394f, 0.01774557f, -0.19323033f, -0.42457595f, -0.32697937f, -0.21275413f, 
    -0.06035157f, -0.38027754f, 0.06376611f, 0.00697554f, -0.05210780f, 0.21015315f, -0.05252725f, 0.16599356f, 
    0.12998749f, 0.05159449f, 0.02666251f, -0.14811879f, -0.02682920f, -0.04614594f, 0.13686815f, -0.02555455f, 
    -0.05219433f, -0.12136423f, -0.19912103f, -0.22318017f, 0.04140666f, -0.03560441f, -0.12421548f, 0.24124753f, 
    0.04924171f, -0.05490690f, -0.07805792f, 0.04519666f, -0.00349011f, 0.13620514f, -0.03361825f, 0.23123489f, 
    -0.19121209f, -0.85107070f, -0.01947534f, -0.16661607f, -0.08564157f, 0.09673748f, 0.05476487f, 0.27020228f, 
    0.06222003f, 0.19255373f, 0.06276984f, -0.02527514f, -0.28819478f, -0.00694516f, 0.00596074f, 0.04342077f, 
    0.01872253f, 0.11920737f, 0.19025898f, -0.05829674f, 0.08138737f, -0.03902364f, 0.02591580f, -0.05607705f, 
    -0.01722026f, 0.01440732f, 0.22241262f, 0.36417526f, 0.12498984f, -0.18723080f, -0.14322640f, 0.10964654f, 
    -0.24155799f, 0.10828009f, 0.09484698f, -0.20192455f, 0.00847679f, -0.21580581f, -0.05368763f, 0.18986806f, 
    0.14767934f, 0.18059821f, -0.01005925f, 0.23063643f, -0.22211580f, -0.24928838f, 0.12790444f, -0.07100134f, 
    -0.10629669f, 0.14416063f, 0.02557549f, 0.04412326f, 0.03648300f, 0.22507668f, 0.15020750f, 0.27312091f, 
    0.25158119f, -0.07579706f, 0.04840597f, 0.16621844f, 0.15035795f, 0.16271397f, -0.41762483f, -0.63297558f, 
    -0.28434628f, 0.01820349f, -0.09477970f, -0.12369927f, 0.00449884f, -0.00683411f, -0.04486027f, 0.21794161f, 
    -0.03656632f, 0.01775487f, 0.04082135f, -0.00180054f, -0.05082124f, -0.02269139f, -0.02651121f, -0.00183150f, 
    -0.02527010f, 0.01694812f, 0.02159068f, 0.02818427f, 0.01980445f, 0.01390578f, 0.02817067f, -0.04150301f, 
    0.01858477f, -0.02597767f, 0.02270287f, 0.02672431f, 0.03439579f, -0.04482236f, -0.06441770f, -0.03605170f, 
    -0.06011163f, -0.04220283f, -0.05825111f, -0.02518708f, -0.03325683f, 0.00942907f, -0.02017638f, 0.02530916f, 
    0.02213307f, -0.06502834f, -0.04518929f, -0.01194134f, 0.04335991f, -0.02763161f, 0.04052212f, -0.06536429f, 
    0.01238251f, -0.06103313f, -0.02582899f, 0.02605220f, 0.00652957f, -0.03456796f, -0.01453330f, 0.04286910f, 
    -0.04337398f, 0.04410372f, -0.00860800f, -0.01615155f, -0.05433874f, -0.01445711f, -0.00309491f, 0.00737429f, 
    -0.02946156f, -0.03778281f, -0.05939028f, -0.02232485f, 0.01196948f, 0.00585734f, 0.01719568f, -0.01956987f, 
    0.01256270f, 0.00269643f, -0.01188132f, -0.06222786f, -0.02143195f, -0.03573186f, 0.04852055f, 0.00102678f, 
    -0.06459400f, 0.03107720f, -0.02129099f, 0.02966296f, 0.01957694f, -0.03346871f, 0.01263997f, -0.06630109f, 
    0.01592674f, 0.02846049f, -0.06571264f, -0.01637537f, 0.03074083f, -0.04502499f, 0.03929692f, -0.04739989f, 
    0.03997960f, 0.00527970f, -0.05337061f, -0.00114915f, 0.01540054f, 0.01866325f, 0.03022835f, -0.05954248f, 
    0.02624646f, -0.04575996f, -0.05020838f, -0.06426932f, 0.00146101f, -0.05399211f, -0.06343833f, -0.06646353f, 
    -0.01447124f, -0.00574849f, -0.01735921f, 0.01515736f, -0.00860726f, -0.06285387f, 0.01759743f, 0.01076442f, 
    0.02130798f, 0.01917036f, -0.06909805f, -0.04124233f, -0.03298394f, -0.03685289f, 0.02997975f, -0.06635874f, 
    -0.01899722f, -0.02451679f, -0.00732907f, -0.02162991f, -0.01407657f, -0.03078236f, 0.00954118f, -0.03449031f, 
    -0.00740295f, -0.05824727f, -0.01188236f, -0.01195342f, -0.06277822f, -0.01216684f, 0.00095252f, -0.00230423f, 
    -0.01195908f, 0.02725948f, -0.01103997f, 0.04666237f, -0.04023265f, -0.04964073f, 0.05312600f, -0.03658124f, 
    0.00247689f, 0.05271894f, -0.06911724f, 0.02179687f, 0.00965535f, -0.03465826f, -0.03603103f, -0.01109346f, 
    -0.02053296f, 0.03966063f, -0.03009176f, -0.03040030f, 0.02671680f, 0.04240030f, 0.00875918f, -0.04347537f, 
    -0.02642764f, 0.02688441f, -0.03132987f, -0.06686865f, -0.05613862f, 0.01521984f, -0.02072603f, -0.00697608f, 
    0.03020552f, 0.04849219f, 0.03543380f, 0.03635430f, 0.03311454f, 0.02231934f, 0.04615793f, 0.01706398f, 
    0.03898419f, 0.04680611f, 0.01068114f, 0.03408146f, 0.01291585f, 0.02828191f, 0.04271964f, -0.03068449f, 
    -0.04373049f, 0.04509108f, 0.03661167f, 0.03451212f, 0.01998322f, -0.06393404f, 0.02848134f, 0.01754198f, 
    0.04104136f, -0.01639910f, 0.04893379f, 0.04761847f, 0.00892383f, 0.03372580f, 0.01192941f, 0.04418012f, 
    -0.00663424f, 0.02007451f, -0.00122383f, 0.00113559f, -0.04564305f, 0.02408858f, 0.02506538f, 0.00267212f, 
    -0.00258086f, -0.03611552f, -0.04957180f, 0.01581668f, 0.00416162f, -0.02459789f, -0.05386426f, -0.01641934f, 
    0.03861178f, 0.02286698f, 0.04744193f, 0.00845854f, -0.04072371f, 0.05113801f, -0.02585981f, -0.00063627f, 
    -0.04525780f, 0.03174555f, 0.00228065f, 0.03878770f, -0.06705099f, -0.00839020f, 0.01129417f, -0.03301810f, 
    0.04153533f, 0.00666517f, -0.04217158f, -0.03599488f, -0.01461963f, 0.02854912f, 0.04771325f, -0.00823776f, 
    0.00711968f, -0.02027128f, 0.01126789f, -0.00048779f, 0.00494349f, 0.02025492f, 0.03338898f, -0.02119815f, 
    -0.03253095f, -0.03638091f, 0.01228284f, 0.00776596f, -0.01932848f, -0.03558122f, -0.05257767f, 0.02690280f, 
    -0.05557758f, -0.04220638f, -0.05669863f, -0.05201544f, -0.05808319f, 0.03698215f, 0.00339391f, -0.03029570f, 
    0.03245993f, -0.05859393f, 0.03679086f, -0.04379864f, -0.04857417f, -0.02905592f, -0.05265197f, -0.04952319f, 
    -0.00142475f, -0.02992414f, -0.04661542f, -0.00104383f, 0.03903821f, -0.03001280f, 0.01283721f, 0.04448494f, 
    0.00190929f, 0.00506388f, 0.03763010f, -0.01659793f, -0.02195877f, 0.02971066f, -0.04057664f, -0.06074305f, 
    -0.56967402f, -0.17280364f, -0.16358858f, 0.04787527f, -0.00672050f, 0.00122131f, -0.05678288f, -0.11864814f, 
    -0.15820777f, 0.18483804f, -0.10268120f, -0.10889468f, 0.08840055f, 0.04128046f, 0.05741087f, -0.02173069f, 
    -0.16167578f, -0.12206643f, -0.14257872f, 0.23379834f, 0.33739781f, 0.06078622f, 0.02423566f, 0.15124410f, 
    0.01049533f, 0.07684387f, 0.08737392f, -0.14868042f, 0.26313815f, 0.33920842f, 0.32789046f, -0.03481304f, 
    -0.06771558f, 0.08797198f, -0.03920105f, -0.05399555f, 0.00210468f, 0.06348050f, 0.02599307f, 0.22924455f, 
    0.11531378f, -0.25562200f, -0.06139714f, 0.09343477f, 0.19746687f, 0.18297853f, 0.19988309f, -0.06997512f, 
    -0.02052342f, -0.07819074f, 0.12328747f, -0.14681603f, 0.09977375f, 0.01616437f, -0.18141209f, -0.05049530f, 
    -0.09519391f, 0.01421866f, -0.12334282f, -0.27924967f, -0.02581624f, -0.20930019f, -0.19614810f, 0.10767350f, 
    0.02820109f, -0.02581378f, -0.08946553f, -0.12957112f, -0.24585833f, -0.04992301f, 0.06711213f, -0.01112158f, 
    0.09404690f, -0.00035697f, 0.20212904f, 0.05198130f, 0.13681227f, 0.07119954f, 0.03096376f, -0.07622661f, 
    -0.10544630f, -0.17182772f, -0.04704377f, 0.01915533f, 0.15935127f, 0.01605595f, 0.19771592f, 0.05313126f, 
    -0.04015628f, 0.12045582f, -0.03990214f, 0.05927535f, -0.11046330f, -0.11501664f, -0.12166066f, -0.08979555f, 
    0.19520798f, 0.10672928f, -0.07241829f, -0.02338369f, 0.04678850f, 0.04715933f, -0.15142153f, -0.06439523f, 
    -0.26305464f, -0.09678344f, 0.09117313f, 0.00912988f, -0.08234870f, 0.07744084f, 0.09691407f, 0.20826340f, 
    0.18055226f, 0.09462799f, 0.04138116f, 0.06526589f, 0.17037866f, 0.16959974f, -0.47663581f, -0.31183630f, 
    -0.01078382f, 0.06771521f, 0.03896507f, -0.12171120f, 0.08188552f, 0.05316188f, -0.26415646f, 0.13530929f, 
    0.33400819f, -0.03559977f, 0.15950850f, -0.02374905f, 0.07087911f, 0.19700545f, 0.04902312f, -0.13007393f, 
    0.12312567f, 0.11200762f, -0.11669313f, -0.07414134f, 0.18693590f, 0.05717381f, -0.45296970f, 0.01133810f, 
    0.38359684f, -0.05475388f, -0.32113686f, 0.02932024f, 0.02788332f, 0.00869687f, 0.11933614f, -0.03254857f, 
    0.12718877f, -0.04578985f, 0.11490563f, 0.17895477f, 0.16266343f, 0.16186970f, -0.05969362f, 0.03818176f, 
    0.09483776f, 0.06393573f, -0.11326449f, -0.09856187f, 0.06392062f, 0.04516819f, -0.01113942f, -0.22151077f, 
    0.26382181f, -0.09534008f, -0.20292783f, 0.08006408f, 0.20374484f, 0.07913007f, 0.00690274f, -0.12616698f, 
    -0.15304950f, 0.08927077f, 0.26802698f, 0.18518353f, -0.08884022f, -0.10767463f, 0.05934927f, 0.20308435f, 
    -0.03708807f, -0.16573568f, 0.02737927f, -0.05706302f, 0.14287321f, -0.25171566f, 0.06730265f, 0.04158296f, 
    0.04566256f, 0.14031671f, -0.05991809f, 0.00759256f, 0.10776030f, -0.05978977f, 0.23181377f, -0.17747650f, 
    -0.43057442f, -0.02961838f, -0.10525057f, -0.07919453f, 0.12126050f, 0.09427959f, 0.02592424f, 0.18685216f, 
    -0.00486624f, 0.06361950f, 0.04527086f, 0.03915311f, 0.13395941f, 0.13474870f, 0.05094899f, 0.06623069f, 
    -0.02891994f, -0.11961218f, -0.02314832f, -0.12712333f, -0.09760112f, -0.06928412f, -0.08080172f, 0.01042063f, 
    0.10569876f, -0.17328598f, 0.01601426f, -0.22902070f, 0.13739987f, -0.10285901f, -0.12189914f, 0.22405100f, 
    0.11175661f, 0.08671407f, -0.29225624f, -0.13381143f, -0.24396828f, -0.19747974f, 0.02915684f, -0.14702366f, 
    0.10753959f, 0.04920527f, 0.06719432f, -0.29611593f, 0.09244841f, 0.17864756f, 0.14656115f, -0.03540900f, 
    0.05654214f, -0.22951816f, -0.01797205f, -0.01453790f, -0.42049381f, 0.32546061f, 0.20837453f, 0.18557061f, 
    0.14394599f, -0.08508934f, -0.07121808f, -0.13042620f, -0.13632911f, 0.09301008f, -0.04163038f, 0.01746248f, 
    0.23863034f, -0.05469997f, -0.03843961f, 0.00318526f, 0.06722327f, 0.10753490f, 0.01583999f, -0.18450770f, 
    -0.19553995f, 0.08562051f, -0.13368189f, -0.16543271f, -0.08702789f, -0.16454162f, -0.24238318f, 0.09552282f, 
    0.01665078f, -0.24167904f, -0.03564727f, 0.04372452f, 0.19790946f, -0.03006204f, -0.02047741f, 0.30623475f, 
    0.09214689f, 0.46513969f, 0.24787129f, -0.06005081f, 0.15425360f, -0.02386642f, 0.01380714f, 0.10487722f, 
    0.14808339f, 0.20426677f, -0.17501090f, -0.16987166f, -0.05218953f, 0.06908993f, -0.13150719f, -0.11692504f, 
    0.14886476f, 0.01088744f, 0.02023132f, 0.10997384f, 0.05249883f, 0.12775971f, 0.01667574f, -0.09855093f, 
    0.14263275f, -0.25203311f, -0.26152194f, 0.58735359f, -0.33926943f, 0.04923090f, -0.32666233f, 0.11156936f, 
    -0.16538832f, 0.31608915f, 0.09569243f, 0.19866942f, -0.16875666f, 0.07850497f, -0.05927337f, -0.09499131f, 
    0.11826418f, 0.04806145f, -0.07710676f, 0.00294445f, -0.19841069f, -0.23294088f, -0.03565044f, 0.09604812f, 
    -0.05854731f, -0.07054418f, -0.08359312f, 0.12967092f, -0.15473987f, 0.13712548f, -0.21669717f, -0.28779548f, 
    0.20783255f, 0.05618760f, 0.04196097f, 0.11633399f, 0.10615649f, 0.29147342f, 0.20038101f, -0.30634207f, 
    -0.04227391f, -0.08010682f, -0.01989938f, 0.03099121f, 0.02660964f, 0.15082359f, 0.14349630f, -0.06467333f, 
    0.25031143f, -0.01804010f, -0.23922588f, -0.04169164f, 0.11152073f, 0.06895933f, -0.06572817f, 0.07903986f, 
    -0.01787763f, 0.76194274f, -0.03673427f, -0.19988541f, -0.14150791f, 0.15246961f, -0.15133332f, -0.00903941f, 
    -0.11142890f, 0.03851076f, -0.02343148f, -0.17229936f, 0.00973147f, 0.47234344f, 0.17182878f, -0.10318714f, 
    -0.22524928f, -0.16583709f, -0.33071044f, -0.27120486f, -0.12210045f, -0.20817427f, 0.04160015f, 0.12592028f, 
    0.00724380f, 0.09680843f, 0.13434921f, -0.07684928f, 0.02933689f, 0.01357749f, 0.09617072f, -0.12467025f, 
    0.03540573f, -0.05094559f, -0.17738242f, -0.44476691f, -0.27098280f, -0.12531506f, 0.13152613f, 0.01871641f, 
    -0.30457270f, 0.02667439f, -0.19933508f, 0.14513598f, 0.04065678f, 0.04793093f, 0.26504025f, 0.23489994f, 
    -0.02388143f, 0.13077807f, 0.07544434f, -0.03234643f, -0.02176051f, -0.50474238f, -0.01404894f, -0.21741040f, 
    -0.23712952f, -0.50877106f, -0.02430429f, 0.07671501f, 0.17420109f, 0.30963650f, 0.06672886f, -0.10302468f, 
    0.39342812f, -0.08704739f, 0.00168233f, -0.02588522f, 0.16202055f, 0.11585639f, 0.07100244f, 0.04526730f, 
    -0.01403516f, -0.36922142f, -0.23801798f, 0.32327369f, -0.33741531f, -0.23100425f, 0.24121712f, 0.17571430f, 
    0.07482307f, 0.09108871f, -0.08478069f, -0.05015045f, 0.48502001f, -0.05396231f, 0.04961351f, 0.01880716f, 
    0.09177160f, 0.25831097f, 0.10054888f, -0.13070169f, -0.12175759f, 0.44333073f, -0.20259155f, 0.08073405f, 
    -0.12329669f, 0.07036937f, -0.09657832f, -0.01055812f, -0.00777405f, 0.19224417f, 0.14476877f, 0.02155389f, 
    0.03534131f, 0.08830304f, -0.32099405f, -0.55685490f, -0.39531851f, 0.57550043f, -0.19946238f, -0.13311869f, 
    0.04005537f, 0.08456799f, -0.10399806f, 0.05598927f, -0.39393297f, -0.02023420f, 0.35672468f, -0.01902674f, 
    0.03999031f, -0.02953078f, 0.04899041f, -0.07080902f, 0.02042826f, 0.02087391f, -0.04717638f, -0.19656153f, 
    -0.13722457f, 0.07534491f, -0.04410913f, 0.01635226f, 0.15268128f, 0.21999231f, -0.14307150f, 0.08003215f, 
    -0.19013140f, -0.06786148f, -0.07590201f, 0.17915118f, 0.01713141f, 0.13979124f, -0.13009521f, -0.18152981f, 
    -0.27823263f, 0.17132923f, -0.10723121f, -0.22116140f, 0.09778400f, 0.01629771f, -0.04453946f, 0.01695500f, 
    -0.07342466f, -0.07624375f, 0.30349687f, -0.04642214f, -0.14236851f, 0.11294066f, 0.22647040f, 0.23603071f, 
    0.05963626f, -0.14222531f, -0.15131125f, 0.56420320f, 0.12603080f, -0.47849667f, -0.07127354f, 0.03816205f, 
    -0.03294799f, 0.05281016f, 0.02758995f, 0.01967087f, 0.16684143f, 0.01803132f, 0.39046273f, 0.03970686f, 
    -0.14544801f, 0.03013257f, 0.33708966f, 0.18502003f, -0.18877003f, -0.06730025f, 0.04089298f, 0.17829157f, 
    -0.02356689f, 0.02918656f, 0.07403640f, 0.12267829f, 0.06908599f, -0.04887109f, 0.26228261f, -0.10750275f, 
    -0.04129556f, 0.10947986f, 0.04245891f, -0.10081744f, -0.04884824f, 0.09943528f, 0.12379415f, -0.12973300f, 
    0.03038885f, 0.24559189f, -0.05095359f, -0.00727534f, -0.04434319f, 0.09107328f, -0.01200156f, 0.04611262f, 
    0.03917513f, -0.04484135f, -0.02982065f, 0.01713657f, -0.02663065f, -0.00157324f, -0.05149650f, 0.00443412f, 
    -0.03185073f, -0.01307300f, -0.02306153f, 0.00018658f, -0.05766696f, -0.05948726f, -0.01096493f, 0.00003748f, 
    -0.02024399f, -0.00490053f, -0.01502793f, 0.00414960f, -0.02685217f, -0.00348250f, -0.07986277f, -0.06393215f, 
    -0.03126232f, -0.08373297f, -0.06669252f, -0.01121170f, -0.01657687f, -0.01346930f, -0.03400841f, -0.07079148f, 
    0.00187013f, 0.01308014f, -0.05044353f, 0.02447934f, -0.01549608f, -0.03885270f, -0.02844216f, -0.01487423f, 
    0.04032354f, 0.00736817f, 0.00565640f, -0.03170388f, -0.05070130f, 0.04410403f, -0.06708449f, 0.02475721f, 
    0.02225345f, -0.04995906f, -0.01208484f, 0.04573533f, 0.05155073f, 0.01552014f, -0.06458438f, -0.02492183f, 
    0.02302966f, 0.06413260f, 0.04032785f, -0.02928707f, -0.07532528f, 0.00168345f, -0.00678724f, -0.01172029f, 
    0.06574438f, -0.03027599f, -0.05107421f, 0.05327191f, -0.06951419f, 0.00504173f, -0.03045728f, -0.03505521f, 
    -0.01247565f, 0.00962914f, -0.01277185f, 0.02731135f, -0.02047019f, -0.02014131f, 0.02408758f, 0.04606311f, 
    0.00868578f, -0.02383984f, -0.07382853f, -0.02980606f, 0.03102642f, -0.01670920f, -0.00286406f, 0.01917860f, 
    0.00306588f, -0.00272664f, -0.05373444f, 0.01944068f, -0.00262572f, -0.04983507f, -0.06150266f, -0.08161769f, 
    -0.03702323f, 0.01045270f, -0.00827412f, 0.04741998f, 0.05917697f, -0.00805511f, -0.02968662f, -0.01315695f, 
    -0.05476592f, 0.03259657f, -0.07523668f, 0.02275254f, -0.01817561f, -0.01854710f, -0.04426772f, 0.04141737f, 
    0.02328397f, -0.04447564f, -0.00566869f, -0.05188610f, -0.06132447f, 0.07183398f, 0.03786928f, -0.01110264f, 
    -0.03851433f, -0.00464844f, -0.04654913f, 0.02841111f, 0.01539464f, -0.03528501f, -0.05900226f, -0.00447151f, 
    -0.03130163f, 0.01571886f, -0.01584537f, -0.06387824f, 0.01888219f, -0.06067130f, -0.08682759f, -0.01451746f, 
    -0.04175511f, -0.01933542f, 0.02702259f, -0.00396693f, -0.01004834f, 0.00628551f, 0.01558185f, -0.00332510f, 
    -0.03558453f, -0.03374207f, -0.06887624f, -0.02888034f, -0.00204586f, -0.02679349f, -0.05820497f, -0.00690500f, 
    -0.02261282f, -0.04802830f, 0.04786791f, 0.00911201f, 0.00018576f, 0.02060319f, -0.04979322f, -0.05450930f, 
    -0.02232037f, 0.00399126f, -0.00750035f, 0.00617705f, 0.03119338f, 0.00944583f, -0.01913089f, -0.03461238f, 
    0.01718457f, -0.03235350f, -0.00676803f, -0.06458310f, -0.05084232f, 0.04368085f, -0.05199627f, 0.02050850f, 
    0.01106995f, -0.02157025f, 0.03740096f, 0.02711877f, 0.02016574f, -0.05835504f, 0.05398030f, -0.02973837f, 
    0.00404225f, 0.02776237f, -0.04215895f, -0.03108580f, -0.05227476f, 0.03421416f, -0.06173518f, -0.07510746f, 
    0.01999845f, -0.08990531f, -0.08989575f, -0.00304516f, -0.01873542f, -0.06611652f, -0.06214452f, -0.01863378f, 
    0.00615656f, -0.00266678f, 0.00329029f, -0.08266030f, -0.03228069f, 0.00542195f, -0.07144105f, 0.03579742f, 
    0.05392006f, -0.02294293f, 0.03311472f, -0.05292778f, 0.01647132f, 0.01092565f, 0.01836620f, -0.06342853f, 
    -0.03260008f, 0.04365676f, 0.02029980f, -0.03005212f, -0.04451317f, -0.08271814f, 0.05135438f, 0.01858050f, 
    0.00717779f, -0.03316340f, -0.02078054f, -0.04412903f, -0.04123459f, 0.00632248f, -0.01235308f, -0.08513489f, 
    -0.06543267f, -0.04313412f, -0.02494449f, -0.02389211f, 0.03351653f, 0.02400750f, 0.02175060f, -0.01305385f, 
    -0.04466391f, -0.09887232f, -0.05472525f, 0.05633358f, -0.07444461f, 0.00102227f, -0.01842604f, -0.07158617f, 
    0.02032078f, -0.01401193f, -0.03249330f, -0.02283608f, -0.00279824f, -0.04054788f, -0.03564131f, 0.00991427f, 
    -0.01139028f, -0.05272976f, -0.02352084f, 0.04248682f, 0.00728902f, 0.00425927f, 0.04284798f, 0.01090020f, 
    -0.07533139f, 0.04268408f, -0.07798646f, -0.06298953f, -0.04577143f, 0.00772468f, -0.05947931f, -0.07783831f, 
    -0.03923095f, -0.02654994f, 0.02541051f, -0.03135657f, -0.06112379f, -0.07487085f, -0.00844611f, 0.03822940f, 
    0.04746776f, 0.05403496f, 0.00752973f, 0.03124920f, -0.07365222f, 0.01422611f, -0.02573162f, -0.01375780f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.13819927f, 0.14806768f, 0.17839274f, 0.35473314f, 0.16425700f, -0.03408416f, -0.11926340f, 0.23735414f, 
    -0.02422655f, -0.04702045f, 0.05253395f, 0.02746424f, -0.01213963f, 0.14088236f, 0.10580188f, 0.10911153f, 
    -0.06101519f, 0.02809271f, 0.15941042f, 0.48977247f, 0.26500648f, -0.01648355f, -0.02597264f, 0.03593057f, 
    0.22890516f, 0.08096346f, 0.02286348f, 0.05356080f, -0.02015760f, 0.20121166f, -0.13848871f, -0.01240958f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.18360129f, -0.18400897f, -0.26566565f, -0.13032997f, -0.06444338f, 0.10685205f, 0.44264412f, -0.45274553f, 
    0.03067107f, 0.11050162f, -0.20649621f, 0.00100126f, -0.41317567f, -0.36951575f, -0.83203197f, 0.01544719f, 
    -0.10192749f, 0.01197337f, 0.15909709f, -0.35464093f, 0.06457062f, -0.40786201f, 0.16702941f, 0.71729743f, 
    0.13994180f, 0.36198008f, -0.00102685f, 0.09850012f, 0.02960119f, 0.12806542f, 0.30940834f, -0.07081962f, 
    0.02821946f, 0.30295810f, -0.37295711f, 0.11828108f, 0.15453385f, -0.10220215f, -0.01518066f, 0.52533334f, 
    0.10172335f, -0.13132866f, 0.37378541f, -0.06572129f, -0.26720697f, -0.34722880f, -0.26448441f, 0.38101622f, 
    -0.36517462f, -0.36686501f, 0.15959047f, 0.09187549f, 0.08583835f, -0.19268255f, 0.12985376f, 0.11839777f, 
    -0.16248222f, 0.16542177f, -0.12627624f, 0.55938601f, 0.06237796f, 0.07999676f, -0.31218353f, 0.13806793f, 
    -0.24654292f, -0.05027590f, 0.36218721f, -0.34397519f, 0.09836093f, 0.05089694f, -0.53079218f, 0.26431134f, 
    -0.39474663f, 0.12443291f, -0.01467570f, 0.10156741f, -0.19358341f, -0.69171238f, 0.10315882f, -0.04393282f, 
    0.25142512f, 0.03651370f, 0.40239862f, 0.43863794f, -0.44681209f, -0.78236198f, -0.06568755f, -0.62605500f, 
    0.13071358f, -0.16460627f, 0.12497224f, 0.44786349f, 0.07339157f, 0.10610928f, -0.00691258f, 0.00394545f, 
    -0.23126510f, -0.26074681f, 0.03272275f, -0.62994617f, -0.51812506f, 0.01876086f, 0.26393071f, -0.39782545f, 
    -0.09866711f, 0.13904542f, 0.02961345f, 0.00113922f, 0.13735098f, 0.63115573f, -0.24407481f, 0.04854590f, 
    0.09363931f, 0.54310411f, -0.70884830f, 0.20058480f, -0.54630226f, -0.09620521f, 0.03113392f, -0.49543759f, 
    -0.33012897f, 0.14645308f, 0.01681527f, 0.58448327f, 0.07061146f, -0.79611534f, 0.37154815f, -0.04116946f, 
    0.06839813f, -0.31726414f, -0.18026403f, -0.51561379f, -0.41467506f, -0.01575847f, 0.22800475f, 0.16255742f, 
    -0.03850342f, -0.00776957f, 0.33775887f, 0.03750963f, 0.41754529f, -0.22972298f, -0.29231283f, 0.04685941f, 
    0.27000979f, -0.08956119f, -0.18845613f, -0.17032382f, -0.04366532f, 0.38775012f, -0.07985207f, 0.18736938f, 
    0.48276770f, -0.10924855f, 0.06009199f, -0.49050900f, -0.15489399f, -0.25283477f, -0.09167966f, -0.10611015f, 
    0.06958523f, 0.24170469f, 0.10128378f, -0.60132319f, 0.12803294f, 0.07831684f, 0.01362190f, -0.15137085f, 
    0.28539643f, 0.01181653f, -0.09643035f, -0.17954762f, -0.08756197f, 0.41429719f, 0.64568901f, -0.02981072f, 
    -0.10520045f, -0.06368704f, -0.29157895f, -0.01853577f, -0.23818754f, -0.27425247f, -0.07481672f, 0.31532618f, 
    0.35832843f, -0.06977347f, -0.09983743f, -0.30124879f, 0.05327705f, 0.09668524f, -0.46011293f, -0.10198566f, 
    0.13500728f, -0.28881010f, 0.09934521f, -0.07569874f, -0.22619005f, -0.11569308f, -0.37524176f, 0.54295939f, 
    -0.32907131f, 0.18048370f, -0.69036758f, 0.08397204f, -0.53299510f, -0.52420944f, 0.03056460f, -0.79905033f, 
    0.06662333f, -0.07272095f, 0.29085603f, 0.44837585f, 0.76952624f, 0.00491633f, -0.15603696f, -0.78310764f, 
    -1.12787557f, -0.37085500f, -0.03630840f, -0.56484038f, 0.02989728f, 0.40647796f, 0.13150015f, 0.07433826f, 
    0.38674030f, 0.13591960f, -0.28655139f, 0.42261136f, -0.75937998f, -0.02371594f, -0.00115209f, 0.15688582f, 
    -0.01069639f, -0.01183612f, -0.12279271f, -0.05875143f, 0.09253409f, 0.43985602f, 0.20361930f, 0.08943541f, 
    0.00345791f, -0.16060477f, -0.28167245f, -0.31168687f, -0.37562704f, 0.06001607f, -0.07778904f, -0.05672112f, 
    -0.62853545f, -0.27019271f, 0.02509853f, 0.01172841f, -0.09436525f, -0.32290977f, 0.20155002f, 0.02624345f, 
    -0.23511717f, 0.38582027f, 0.38741571f, 0.82373977f, -0.10550318f, 0.12418351f, -0.49276188f, -0.08387130f, 
    0.32082331f, -0.04254910f, -0.03165702f, 0.06092556f, 0.13059701f, 0.63737965f, -0.51349550f, -0.27403632f, 
    -0.52135289f, 0.11050761f, -0.08784370f, -0.03584345f, -0.18116598f, -0.52361923f, 0.05492008f, -0.29419321f, 
    -0.02098802f, -0.21033749f, -0.04772430f, 0.00811280f, 0.12191471f, 0.23069228f, -0.14134127f, 0.16141653f, 
    0.09282967f, -0.02201948f, -0.11607172f, -0.05994428f, -0.50920147f, -0.10241240f, -0.94737732f, 0.08999587f, 
    -0.52801591f, 0.06149735f, 0.05522032f, 0.00449813f, -0.25880706f, -0.16596310f, 0.03632094f, -0.50297481f, 
    0.07111304f, 0.49243212f, -0.33249691f, 0.35208631f, 0.26752922f, 0.43959489f, 0.12078355f, 0.11149908f, 
    0.58326477f, 0.80634481f, -0.00006683f, -0.42481667f, -0.11105958f, -0.28374234f, -0.05763948f, -0.09261637f, 
    -0.16152577f, -0.09162295f, 0.47301939f, -0.43271562f, 0.79065180f, -0.12288877f, -0.08701672f, -0.21435615f, 
    0.30127683f, -0.01805052f, 0.54816699f, 0.16326590f, 0.52991831f, -0.30195588f, -0.51874155f, -0.52637279f, 
    -0.43041804f, -0.02640549f, -0.29560307f, -0.06316706f, 0.20990929f, 0.40726739f, -0.01548822f, -0.22258385f, 
    -0.66871911f, -0.28188550f, -0.14587231f, -0.12989640f, -0.17067546f, 0.35109639f, -0.27728510f, -0.18283948f, 
    -1.06754351f, -0.37978360f, 0.05755627f, -0.04828619f, 0.94333696f, -0.10899785f, -0.73391157f, -0.26168635f, 
    -0.13261481f, -0.07884581f, -0.66483396f, 0.02579348f, -0.05971207f, 0.30181539f, 0.23476116f, -0.13404064f, 
    0.28064916f, 0.05592365f, 0.42693919f, -0.30260426f, 0.12568226f, 0.57390207f, 0.10809229f, -0.44986174f, 
    -0.64893764f, 0.04184172f, 0.12310088f, -0.11484100f, 0.08448730f, -0.19635190f, -0.12493331f, -0.13412526f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.44457763f, 0.23320171f, 0.07396698f, 0.17907815f, 0.00952117f, 0.10348175f, -0.10162309f, -0.36865395f, 
    -0.04497305f, 0.00099465f, -0.09133797f, -0.00893434f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
