#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.15824422f, -0.03444580f, 0.24540068f, -0.31416169f, 0.96517348f, -0.49167153f, 1.05671954f, -0.88846523f, 
    -0.31754923f, -1.56444407f, -1.71739089f, -1.11963749f, -0.47996935f, -0.24710128f, 0.15709461f, 0.20126908f, 
    0.50116223f, -0.25813502f, -0.44868442f, -1.00732923f, 0.49328086f, -0.64450312f, -0.95456624f, -0.18459700f, 
    -0.36494690f, -0.95989352f, -0.32792073f, 1.29921806f, -0.17568208f, -0.42802966f, 0.13825440f, 0.11069322f, 
    0.17499757f, -0.59801000f, 0.42646846f, -0.74909127f, 0.44071230f, 0.21167067f, -0.58243614f, 0.84896547f, 
    0.04674399f, -1.23065329f, -0.19466223f, -0.00274502f, 0.18079112f, 0.36787042f, -0.33608544f, 0.46860167f, 
    -0.92833430f, -1.45243526f, -1.03435779f, -0.03690937f, 0.77613330f, -0.56745887f, -0.98965365f, 1.28921223f, 
    -0.56091678f, -0.69349790f, -0.56144482f, -0.91322935f, 0.52378833f, 0.77918100f, 0.27468663f, 0.15074059f, 
    0.50493044f, -0.84196502f, -0.74784273f, -0.60064566f, 0.12543641f, -0.76149946f, -0.63350743f, -0.89340538f, 
    0.66533583f, 1.10711193f, -0.07008913f, -1.10033476f, -0.38513958f, 0.22041517f, -0.21323301f, 0.41672745f, 
    0.86298203f, -1.01122558f, -0.24081095f, 1.27159917f, 0.62111086f, 0.72362500f, 0.59206504f, -0.12972999f, 
    0.69674397f, -0.58241194f, -0.68081725f, -0.06889294f, -0.78202468f, -0.83793384f, -0.85159266f, -1.21320534f, 
    -0.52544826f, -0.30845448f, 0.87059093f, 0.30635455f, 0.14957546f, -0.06572099f, 0.58485836f, -0.24271022f, 
    -0.33804980f, 0.61654729f, 0.37426561f, 0.54353023f, -0.27337626f, 1.20369101f, -0.65219945f, 1.27793181f, 
    0.12846543f, 0.56635088f, -0.28014278f, 0.72857380f, -0.31644765f, 0.71882945f, 1.06845868f, -1.09975648f, 
    0.03039967f, -0.28264862f, 0.07396522f, -0.18615150f, 0.74179196f, -0.45271763f, 1.06218123f, 0.96276069f, 
    1.09100997f, -0.35780823f, 0.16973926f, 1.11628556f, 0.26323184f, -0.11761291f, -0.26454243f, -1.03453434f, 
    -0.88692141f, -0.48163548f, 0.75361198f, 1.33493090f, 0.20340119f, -0.68866551f, -0.78727537f, -0.75964445f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.47946310f, 0.77651966f, -0.41838542f, 0.31722370f, 0.16231972f, 0.51475418f, 0.11197396f, 0.88218504f, 
    0.71944517f, 0.24468936f, -0.57998818f, 1.20987141f, 0.02098588f, 0.83982581f, -0.41110831f, -0.39262488f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.40132058f, 0.51175463f, 0.12093288f, -0.29125854f, 0.49009955f, -0.05507934f, -0.16484503f, -0.08108858f, 
    -0.02729076f, -0.15119007f, 0.21473826f, 0.06221163f, -0.23698607f, 0.03260867f, 0.09125517f, -0.10310441f, 
    -0.03790982f, 0.15095679f, -0.53072172f, -0.04950011f, -0.10345756f, 0.17158931f, 0.04450215f, -0.01772452f, 
    0.01055396f, 0.17648020f, -0.69916999f, 0.12608559f, 0.23306777f, 0.18711786f, 0.05943541f, -0.22476935f, 
    -0.15674502f, -0.28308427f, -0.25784516f, -0.01867876f, -0.09372681f, 0.07031143f, -0.28177935f, -0.15520585f, 
    0.25049958f, 0.02465521f, -0.24918717f, -0.31405371f, 0.20526840f, 0.15579510f, -0.31331062f, -0.08324734f, 
    0.06088051f, -0.13594395f, 0.08353104f, 0.05343532f, 0.35812616f, -0.25300992f, -0.18522480f, 0.31874478f, 
    0.14622025f, 0.02214449f, -0.37899160f, 0.07881211f, 0.12805144f, 0.31703445f, -0.13293201f, 0.16358840f, 
    0.14837857f, 0.33850101f, 0.01045253f, -0.01218268f, -0.11565560f, -0.19993548f, -0.38415322f, -0.18422970f, 
    0.34612361f, -0.07107346f, 0.31605825f, 0.33401176f, 0.18532076f, -0.01353972f, -0.02086885f, 0.03431446f, 
    0.32684079f, -0.24581014f, -0.19670048f, -0.00788337f, 0.17014904f, 0.04896457f, 0.02829943f, 0.05211779f, 
    -0.05054574f, -0.38121811f, 0.09848279f, 0.11542869f, 0.09339660f, -0.09107053f, -0.01891863f, -0.04231523f, 
    0.19523668f, 0.06487306f, -0.07775815f, 0.14681216f, 0.01383105f, 0.07440804f, 0.15729393f, -0.06369138f, 
    0.01190615f, 0.22912546f, 0.37739244f, 0.03717791f, -0.04530038f, -0.05119564f, -0.21127659f, 0.13714120f, 
    0.03054109f, -0.04151395f, 0.03447410f, -0.05161297f, -0.22374025f, 0.12620446f, 0.31933427f, 0.06394518f, 
    -0.06811971f, 0.46693462f, 0.04266068f, 0.08820765f, 0.18163505f, 0.16012588f, -0.11352286f, -0.00114482f, 
    0.13779519f, -0.14199261f, 0.02531037f, -0.20361724f, -0.05902172f, -0.32969871f, -0.06538526f, -0.17057897f, 
    -0.46494913f, -0.37985447f, 0.06560232f, -0.16647255f, 0.17512375f, -0.40939808f, -0.57868195f, -0.38890356f, 
    0.03661644f, 0.00415681f, 0.05426878f, 0.05347677f, 0.02963905f, -0.03030893f, -0.05836862f, -0.07874902f, 
    -0.07277199f, -0.04476196f, -0.02570346f, 0.06831366f, -0.04303989f, -0.04143183f, 0.02216223f, 0.05773157f, 
    -0.00252139f, -0.03576653f, -0.03415349f, 0.02485878f, 0.03782642f, -0.03478925f, 0.04401258f, -0.00556269f, 
    -0.02525023f, 0.06127932f, -0.05605985f, 0.02934638f, -0.05458310f, -0.03144864f, 0.06976560f, 0.03333785f, 
    -0.01912261f, -0.02829754f, 0.05470810f, 0.05633181f, -0.01923590f, 0.05066414f, 0.02796394f, -0.02807069f, 
    -0.00261768f, 0.06136345f, -0.06891729f, 0.05317924f, -0.00442243f, -0.00838483f, 0.04432594f, -0.03182731f, 
    -0.06420211f, -0.03528879f, 0.07520396f, 0.03800563f, 0.03785882f, 0.00374583f, 0.04635429f, 0.02428442f, 
    -0.08126349f, 0.01892346f, -0.01584711f, -0.07235171f, -0.04182450f, -0.01006849f, -0.05524382f, -0.07611406f, 
    -0.02401047f, -0.05121483f, 0.02331747f, -0.06881440f, -0.05372701f, -0.02945785f, -0.08387488f, -0.04800532f, 
    -0.00225576f, -0.06430208f, 0.05983930f, 0.03476715f, 0.03206939f, -0.06107999f, 0.02482509f, 0.01276752f, 
    -0.00290662f, 0.05279480f, 0.07033656f, 0.03314091f, -0.00730766f, -0.01347179f, 0.06571921f, -0.02940684f, 
    0.03394493f, -0.05945690f, 0.00860704f, -0.00384428f, -0.08382694f, 0.08024361f, -0.02695604f, -0.03793182f, 
    -0.02524134f, -0.05346674f, -0.02454468f, 0.01863946f, 0.00171322f, -0.08269487f, -0.02201436f, 0.03433079f, 
    0.02435893f, 0.01035970f, -0.06517307f, -0.05504570f, 0.05082148f, -0.04143239f, -0.08245792f, -0.01142912f, 
    0.06676394f, -0.00128831f, -0.01504560f, -0.03577288f, 0.01188182f, -0.02870758f, -0.06423827f, -0.01574709f, 
    -0.03701716f, 0.02120790f, 0.00586036f, -0.04400051f, 0.00922276f, -0.08542323f, -0.02796961f, -0.01155456f, 
    -0.05003565f, -0.07436780f, -0.06956600f, -0.02755490f, -0.03803119f, 0.07795440f, -0.02788653f, 0.03019832f, 
    -0.03361485f, -0.06428513f, -0.06943685f, -0.06137817f, -0.07133745f, -0.06357561f, -0.03287669f, 0.04326611f, 
    -0.15924038f, -0.13276635f, -0.23788284f, 0.09806763f, -0.37421915f, 0.11084829f, 0.32610151f, -0.24794643f, 
    -0.10423432f, -0.15893403f, -0.19550201f, 0.54307824f, -0.03157703f, 0.24613778f, -0.02125853f, 0.02598409f, 
    0.06136895f, 0.02025919f, -0.38298917f, -0.15857126f, -0.14079972f, -0.15247747f, -0.04722133f, -0.09888253f, 
    0.18922631f, 0.01990321f, -0.17846112f, 0.04987534f, -0.28668150f, -0.52589041f, 0.37523803f, -0.19409281f, 
    -0.11465892f, 0.23522153f, 0.01543150f, 0.23753451f, -0.20176309f, -0.06702418f, -0.07476716f, -0.17828383f, 
    -0.33014980f, -0.11909690f, 0.12942527f, 0.05311967f, 0.06124642f, 0.31933722f, -0.16845773f, 0.51192480f, 
    -0.06313818f, 0.18633512f, -0.02765615f, -0.11917701f, -0.19565320f, 0.11087587f, 0.32995334f, 0.14319958f, 
    0.15237439f, -0.13976446f, -0.13329522f, -0.14645451f, 0.08567432f, -0.01356871f, -0.03844906f, 0.12446272f, 
    0.11319199f, -0.10276067f, 0.28100055f, 0.09969997f, 0.12290943f, 0.14126635f, 0.10073718f, -0.04394833f, 
    0.07062595f, -0.18254310f, -0.56372392f, -0.21858107f, 0.04102279f, 0.12186589f, -0.05147536f, -0.08467988f, 
    0.01437936f, 0.13770577f, 0.21023639f, -0.13816704f, -0.13105725f, -0.24505521f, 0.00850103f, 0.18364663f, 
    -0.15514027f, 0.07824896f, -0.33013427f, -0.18103997f, 0.65491509f, -0.12978244f, -0.05013909f, -0.13877812f, 
    0.15807655f, -0.07344349f, 0.01100731f, 0.25245616f, 0.02908959f, -0.32414928f, 0.05639809f, 0.00674401f, 
    -0.03945218f, 0.33509266f, 0.26287439f, 0.27397677f, 0.35306770f, -0.01132983f, -0.21151003f, -0.41940320f, 
    0.03129842f, 0.24055189f, 0.20329280f, -0.11856642f, 0.19558083f, 0.08988336f, -0.01233811f, -0.62064832f, 
    -0.10051860f, 0.14546447f, 0.09109882f, -0.00539733f, 0.08874159f, 0.16178069f, -1.62052262f, -0.69946754f, 
    0.26472402f, 0.02768805f, 0.10265982f, -0.09631021f, 0.12064522f, -0.23212110f, 0.10486286f, -1.09119761f, 
    -0.11505372f, 0.36989486f, -0.20629656f, 0.09306988f, -0.02833303f, 0.14725831f, 0.07949987f, 0.05368058f, 
    -0.10556727f, 0.38938722f, 0.64271533f, -0.04480776f, -0.10458160f, -0.06559924f, -0.27193710f, 0.02501693f, 
    0.18304753f, 0.21214572f, -0.20146087f, 0.20372127f, 0.13441272f, -0.14410090f, -0.16727787f, -0.10008724f, 
    -0.09344022f, -0.09802838f, 0.38499096f, 0.44375047f, 0.43677989f, 0.16329706f, -0.05024635f, -0.23738237f, 
    0.02984665f, -0.24320784f, 0.10477327f, -0.36112222f, 0.47720671f, -0.18053178f, 0.03544486f, -0.09088621f, 
    0.28638133f, 0.32847244f, 0.16025147f, -0.29636648f, -0.23903678f, -0.18113387f, 0.05441704f, -0.38262230f, 
    0.12365639f, 0.22071016f, 0.20400319f, -0.02732041f, -0.34363845f, -0.23929268f, 0.40606284f, -0.20439267f, 
    -0.02324680f, 0.42957598f, -0.22113399f, -0.03000563f, 0.01535620f, -0.27039692f, 0.26251945f, 0.68394625f, 
    0.01231669f, -0.08868980f, 0.32154727f, 0.11293233f, 0.15594409f, 0.17696613f, 0.08125506f, -0.11207361f, 
    0.16567524f, 0.14352664f, 0.07511955f, -0.10674690f, -0.05406860f, -0.01209242f, 0.13014658f, -0.15829781f, 
    -0.59126270f, -0.10730939f, -0.00955136f, 0.10055607f, 0.15329550f, -0.17441964f, -0.01296363f, 0.16797791f, 
    -0.14452334f, 0.04387887f, 0.18750739f, -0.29818389f, -0.18093693f, 0.05230037f, -0.12227159f, -0.06936622f, 
    0.12564166f, 0.07702220f, 0.28238627f, 0.53122997f, 0.12459749f, -0.13126166f, -0.19227161f, -0.23495047f, 
    -0.06791178f, -0.04319889f, 0.24715710f, -0.04482165f, -0.39041427f, 0.15140714f, 0.02414905f, -0.20201109f, 
    -0.17489269f, -0.03451589f, -0.18418948f, -0.23920484f, 0.02444125f, 0.14247219f, 0.28744212f, 0.29846302f, 
    0.09609931f, -0.13231610f, -0.00047759f, 0.19814189f, 0.02308809f, 0.03315477f, 0.43382996f, -0.13342699f, 
    -0.17981529f, 0.05347955f, -0.05472463f, 0.07234147f, 0.14242236f, 0.24336387f, 0.06440456f, -0.13598078f, 
    -0.56861842f, -0.14312206f, -0.14132500f, -0.12903206f, 0.00664251f, -0.03758351f, 0.09375818f, 0.11276866f, 
    -0.78771204f, -0.04000190f, 0.14640917f, 0.00247731f, 0.21724702f, 0.00699776f, -0.25420102f, 0.31720617f, 
    -0.03523322f, 0.03183122f, -0.03668048f, -0.03624693f, -0.02615343f, -0.04238350f, 0.02203643f, -0.01343038f, 
    -0.09619219f, -0.03632460f, 0.02873766f, -0.03491018f, 0.05106101f, -0.01128840f, -0.06631918f, -0.04694738f, 
    -0.04573539f, -0.07058675f, 0.06213271f, -0.01277939f, -0.04857816f, 0.01293967f, -0.07396259f, 0.03471832f, 
    -0.08204380f, 0.06941563f, 0.01620649f, 0.07421554f, -0.09737421f, -0.03479780f, 0.02655340f, 0.06420667f, 
    0.04458001f, -0.06209941f, 0.03567626f, 0.01115990f, -0.05625653f, -0.08578532f, 0.04246216f, -0.11962134f, 
    0.04942649f, 0.02096412f, -0.07280007f, 0.02446036f, -0.07181287f, -0.00709778f, -0.05917013f, -0.11788572f, 
    0.06540338f, 0.04736727f, 0.00588372f, -0.03191472f, -0.05196200f, -0.08046142f, -0.00255834f, -0.00814332f, 
    0.06522290f, -0.07192778f, 0.00689398f, -0.05611849f, -0.13992305f, -0.04946688f, -0.03933885f, 0.06511904f, 
    -0.04570080f, 0.04418942f, -0.03807349f, -0.07636339f, -0.05071012f, 0.03709900f, -0.01175041f, -0.04354624f, 
    0.02950877f, -0.08036701f, -0.07175073f, -0.02677126f, -0.01517244f, -0.01128740f, -0.09988314f, 0.03532124f, 
    0.00236396f, -0.01597542f, -0.08791842f, -0.00686082f, 0.00513032f, -0.05403677f, -0.03908625f, 0.00394730f, 
    -0.00557303f, -0.07028881f, 0.02816768f, 0.08284929f, -0.04930337f, -0.00790890f, -0.04474156f, 0.03888683f, 
    -0.01142817f, 0.01210929f, -0.03899873f, -0.03196577f, 0.00824301f, -0.05181809f, 0.03436446f, -0.04364832f, 
    0.02771703f, -0.06707343f, 0.02827695f, 0.02700213f, -0.09134472f, -0.03808552f, -0.04131766f, -0.01569721f, 
    0.07624246f, 0.06214964f, 0.03453440f, 0.02992227f, -0.08997460f, 0.01592268f, -0.00788660f, -0.08330572f, 
    -0.02502495f, 0.00127120f, -0.04711412f, -0.07083310f, 0.01434613f, 0.01249608f, -0.00080733f, 0.03382011f, 
    -0.08273161f, 0.03002548f, -0.01011866f, 0.04165934f, -0.05618282f, 0.08188386f, -0.03484679f, -0.07147621f, 
    -0.00906056f, -0.06581315f, -0.02951697f, 0.10521257f, -0.08737981f, -0.03968720f, -0.11508017f, -0.04135913f, 
    0.00842949f, 0.04289775f, -0.07904132f, -0.01555940f, -0.05007599f, -0.02549237f, 0.03926962f, -0.08398377f, 
    -0.07456053f, -0.07149263f, 0.06594586f, -0.04339962f, 0.04900824f, 0.05953819f, -0.08684205f, 0.04277446f, 
    0.05800681f, -0.08785605f, -0.03587047f, -0.07563369f, 0.05288259f, 0.01200865f, -0.02302901f, 0.03566818f, 
    -0.03583104f, -0.07826617f, 0.00180072f, -0.03486109f, 0.03323791f, -0.03635951f, 0.02812713f, 0.03899608f, 
    -0.04920375f, -0.01678589f, 0.05514491f, -0.07501878f, -0.07131161f, -0.00627084f, 0.03977784f, -0.03195175f, 
    0.06280306f, 0.02937011f, -0.07251914f, 0.03597401f, -0.04561243f, 0.04120309f, -0.05031097f, -0.03833492f, 
    -0.09212797f, -0.02290504f, -0.00892606f, -0.01996855f, 0.01686263f, -0.04103626f, -0.00934793f, 0.02136229f, 
    -0.09434541f, -0.01766931f, -0.04630257f, -0.06871476f, -0.06282239f, 0.00384659f, -0.06213644f, 0.00769184f, 
    0.03612484f, 0.01343933f, 0.05877072f, 0.01132328f, 0.01805834f, 0.01848330f, -0.05062132f, 0.06703336f, 
    0.04618538f, 0.07155790f, 0.00090867f, -0.02167761f, 0.00134236f, 0.04069362f, -0.02361178f, -0.02067320f, 
    -0.00136917f, -0.08295035f, 0.00969884f, 0.04194683f, -0.05795414f, -0.05440095f, 0.04181609f, -0.01401173f, 
    -0.08412185f, 0.04943463f, 0.05233390f, -0.02083797f, -0.07909432f, -0.05264112f, -0.04066989f, 0.01889844f, 
    0.02768825f, -0.01525335f, -0.05860181f, -0.06844507f, 0.02141762f, 0.02139834f, -0.05391109f, -0.01277586f, 
    -0.00665545f, 0.06369403f, 0.00320157f, 0.06589628f, -0.06275260f, 0.03322362f, 0.01129127f, 0.02884555f, 
    -0.07014836f, 0.02890915f, -0.03944054f, -0.04107891f, -0.04515623f, -0.01034866f, -0.05027914f, -0.05352832f, 
    -0.07698193f, -0.07079480f, 0.00730192f, -0.09041097f, 0.03934633f, -0.04883688f, -0.04442759f, 0.02482620f, 
    -0.03531324f, -0.05843246f, -0.08518890f, -0.05886360f, 0.00422369f, -0.03388893f, -0.02615838f, -0.00208220f, 
    0.03484648f, -0.03112821f, 0.04251834f, 0.00400986f, -0.03424050f, -0.02806029f, -0.03502183f, -0.08906393f, 
    0.03235155f, 0.14240195f, 0.99711972f, -0.03410802f, 0.29856667f, -0.05466057f, 0.03191365f, 0.50003988f, 
    -0.05123695f, 0.49405158f, 0.07363236f, -0.55814391f, -0.02571267f, -0.13395292f, 0.29899833f, 0.03210625f, 
    0.07937676f, -0.10128099f, -0.20242478f, 0.32899827f, -0.26935795f, 0.11243472f, -0.18770953f, -0.18868548f, 
    0.09034568f, 0.15965222f, -0.33776498f, -0.24318792f, -0.23385638f, 0.45274621f, -0.22680767f, -0.09947601f, 
    0.25866571f, -0.27787343f, 0.24287298f, 0.27885935f, 0.03816732f, 0.00896440f, 0.55311990f, 0.11537629f, 
    0.03415022f, -0.13174686f, 0.14982815f, 0.36066490f, 0.07678427f, -0.39849117f, -0.40121067f, 0.68250149f, 
    -0.15828229f, 0.01391262f, -0.14253126f, -0.03479328f, 0.31093079f, 0.06414352f, -0.26297051f, -0.79033881f, 
    -0.07440078f, -0.10204056f, -0.08337647f, 0.33431193f, 0.08013793f, -0.05534668f, 0.05240723f, -0.26890048f, 
    0.34348220f, -0.21066520f, 0.18471020f, -0.08465338f, 0.05316301f, 0.16584000f, 0.09827245f, -0.28550053f, 
    -0.27350008f, 0.45165938f, -0.16913447f, 0.17472680f, -0.14114334f, 0.36973631f, 0.38105509f, 0.09634590f, 
    0.30084059f, -0.03932366f, -0.03328130f, -0.26993632f, 0.02997931f, 0.26800224f, -0.17701595f, 0.00629735f, 
    0.00445658f, -0.09771730f, 0.17076209f, -0.11675461f, 0.16694212f, -0.08877789f, 0.17858906f, -0.07062116f, 
    0.03737982f, 0.14240317f, 0.00924418f, -0.04140823f, 0.15605384f, 0.19828759f, -0.04265929f, 0.19334875f, 
    -0.13812768f, 0.05818089f, 0.36790460f, 0.27686763f, 0.07382745f, -0.21304013f, -0.19734308f, 0.07718469f, 
    -0.02843407f, 0.14701141f, 0.11639000f, -0.39741379f, -0.10727901f, -0.24245204f, -0.02143030f, 0.56093931f, 
    0.04225919f, -0.06037910f, 0.24675184f, 0.17991708f, 0.32408527f, 0.22382352f, -0.16247164f, 0.08069488f, 
    0.07375466f, -0.20687406f, -0.30630863f, -0.35831222f, -0.05600801f, -0.02879752f, -0.03384798f, 0.49200249f, 
    -0.82911128f, -0.78655303f, -0.07264743f, -0.24313352f, -0.07991917f, -0.28387991f, -0.04215088f, -0.10914317f, 
    -0.32788238f, -0.25519368f, -0.19392528f, 0.34200609f, 0.21765447f, -0.05710563f, 0.01406471f, -0.18538487f, 
    0.12440815f, 0.29596952f, 0.19808567f, 0.43764919f, 0.20351143f, 0.21812731f, 0.34693396f, 0.34811008f, 
    0.01510348f, -0.01354310f, 0.32284972f, 0.08292504f, 0.37635055f, -0.19016278f, -0.27525374f, -0.29321760f, 
    0.10921949f, 0.00023005f, -0.19215803f, 0.44448012f, 0.01188382f, 0.42785737f, -0.03607527f, -0.03439479f, 
    0.12428752f, 0.16659130f, -0.14245462f, 0.11026242f, -0.28121287f, -0.12183130f, -0.27054447f, -0.01588474f, 
    -0.41533437f, -0.01321846f, 0.10482892f, 0.03129992f, -0.25036594f, -0.21278875f, -0.07471567f, -0.15994120f, 
    -0.33926761f, -0.01918777f, -0.40349814f, -0.01662490f, -0.32392296f, -0.05545686f, -0.02655862f, 0.03995790f, 
    -0.13046002f, -0.01374447f, -0.19456430f, -0.15668145f, -0.31908539f, -0.04165303f, -0.27460867f, -0.11547980f, 
    0.25996941f, 0.45807683f, 0.13035522f, -0.25776327f, 0.06024433f, -0.03237134f, 0.03941549f, 0.14550686f, 
    0.32947773f, -0.56227630f, -0.22615649f, -0.10353554f, 0.01747607f, -0.00976949f, 0.01325037f, -0.01988684f, 
    -0.14403793f, -0.25962153f, -0.34433076f, -0.43292445f, -0.16608970f, -0.20805334f, -0.26399496f, 0.13049789f, 
    0.14078102f, 0.21332553f, 0.21013454f, 0.09581056f, 0.08605085f, -0.00265402f, -0.17506328f, -0.08163534f, 
    0.17236601f, -0.22766048f, 0.04992222f, 0.15521623f, 0.32541299f, -0.10065301f, -0.01883730f, 0.26627317f, 
    0.02917994f, -0.03749258f, 0.10258616f, 0.07589518f, -0.05231831f, -0.39889231f, -1.55847549f, 0.03076820f, 
    -0.35575148f, -0.01732002f, 0.14994214f, -0.12056978f, 0.32986447f, 0.57280433f, -0.43224549f, -0.72176093f, 
    0.01048614f, -0.40833548f, 0.03692085f, 0.28513551f, 0.22946981f, 0.09346689f, 0.39895114f, -0.63460195f, 
    0.18049811f, 0.39808312f, -0.17518771f, -0.30438906f, 0.25757048f, -0.09784163f, -0.16000023f, 0.32891372f, 
    -0.05300003f, 0.05320425f, 0.12523173f, 0.10650583f, 0.36688080f, 0.21495719f, 0.20557436f, 0.28241539f, 
    0.11087943f, 0.13593988f, 0.19134741f, 0.09865189f, -0.10056639f, 0.29865700f, 0.18658674f, -0.02792161f, 
    0.18448834f, -0.69225633f, 0.06106579f, 0.27340516f, -0.13730749f, 0.06569134f, -0.08139404f, 0.01747423f, 
    -0.06047109f, 0.00292077f, 0.14433004f, 0.11520984f, -0.03890382f, 0.07897199f, 0.11567058f, -0.04071411f, 
    -0.27521840f, 0.13850620f, -0.05662158f, -0.04784623f, -0.43214881f, -0.22412647f, -0.03625012f, -0.07042797f, 
    -0.11777870f, -0.33509135f, -0.03714043f, -0.25297752f, 0.01524602f, -0.58327830f, 0.22460678f, 0.06124729f, 
    0.33876061f, 0.30884239f, 0.05087419f, 0.17481565f, 0.32809201f, 0.04665825f, -0.61215025f, -0.98994482f, 
    0.10407505f, 0.19992416f, 0.30596858f, 0.16935045f, 0.21810603f, -0.00186526f, -1.18333614f, 0.08244833f, 
    0.03547410f, 0.13826847f, 0.17110215f, -0.07678975f, 0.30888522f, 0.14951609f, -0.16888317f, 0.25079021f, 
    -0.18188363f, -0.47998002f, 0.07917500f, 0.11904737f, 0.14083986f, -0.00776693f, -0.00019152f, -0.23133026f, 
    0.37493265f, -0.08964174f, -0.08898532f, 0.13638140f, 0.11626492f, 0.15318547f, 0.01651127f, 0.21982552f, 
    0.32107204f, -0.29178905f, 0.01663946f, 0.22167508f, 0.26181948f, -0.16307928f, 0.02701076f, -0.13400920f, 
    -0.07706396f, -0.09166295f, 0.26005259f, 0.33292499f, -0.06017043f, -0.00146548f, -0.05332260f, -0.04546072f, 
    0.15068434f, 0.08434824f, -0.10880207f, 0.24382091f, 0.08364853f, 0.18135116f, -0.02307777f, 0.05972593f, 
    -0.08285719f, 0.13025333f, 0.44411883f, 0.16936135f, -0.13724847f, -0.11669711f, -0.04151844f, 0.22819354f, 
    0.21728222f, -0.06963994f, -0.07266825f, 0.03371625f, -0.12378129f, 0.39326599f, -0.02984584f, -0.17288278f, 
    0.21328308f, 0.21818137f, 0.37390125f, 0.18372153f, 0.11558188f, 0.21265006f, 0.04789850f, -0.13229845f, 
    -0.15902980f, -0.17023602f, -0.15015514f, -0.06967216f, -0.00917392f, -0.14143340f, -0.13281031f, -0.43346617f, 
    -0.03366122f, -0.23583603f, -0.01138152f, -0.27693114f, -0.15937482f, -0.31279531f, -0.10826883f, 0.14882410f, 
    0.02294805f, 0.03901973f, 0.00840865f, 0.02122330f, -0.00308759f, -0.02580725f, 0.05820721f, 0.06322021f, 
    -0.04324763f, 0.04572583f, -0.03645766f, 0.05298176f, 0.02894924f, -0.03821266f, -0.07302587f, -0.08855290f, 
    -0.02796639f, -0.08724237f, -0.03000570f, 0.06353954f, 0.05129461f, 0.07008310f, -0.06720691f, 0.06803639f, 
    0.06215558f, 0.05539504f, -0.02349762f, -0.08481623f, -0.00719016f, 0.05751909f, -0.09325405f, -0.01720294f, 
    -0.07769315f, 0.04822803f, -0.09331872f, -0.02150257f, 0.04762574f, 0.05337409f, 0.05151277f, -0.03827494f, 
    -0.02248271f, -0.04440157f, 0.06537491f, -0.08840021f, 0.04449312f, -0.09113714f, -0.08082125f, 0.05380908f, 
    -0.08258191f, 0.01806460f, 0.02549391f, 0.02024932f, -0.08974764f, 0.06851809f, 0.04409282f, -0.05790153f, 
    -0.05939388f, -0.09507726f, 0.05890540f, -0.03466109f, 0.04952918f, 0.05865927f, -0.05523720f, 0.04699127f, 
    0.03718211f, -0.09191871f, -0.04451676f, -0.02894707f, 0.04842857f, -0.06169008f, 0.00935668f, -0.08214904f, 
    -0.03739262f, -0.03019856f, -0.02774279f, -0.06729972f, -0.07483504f, 0.05164688f, -0.00102943f, 0.03912809f, 
    -0.05549546f, -0.03359872f, -0.06017985f, -0.04137064f, -0.08488233f, 0.00579417f, -0.05408988f, -0.07441969f, 
    0.02605901f, 0.05589971f, -0.06556042f, 0.02908903f, 0.05420820f, -0.01097581f, 0.04621053f, -0.07582022f, 
    0.02440502f, 0.00190348f, 0.01258063f, 0.02562944f, 0.06662236f, -0.01443222f, 0.01538427f, -0.07389368f, 
    -0.06240485f, 0.05644732f, -0.09259248f, -0.06927370f, 0.00322490f, 0.05235992f, -0.05246095f, -0.01510101f, 
    0.05017171f, -0.09153831f, -0.07101542f, 0.06274765f, -0.05660912f, -0.06226337f, -0.00956379f, -0.04936005f, 
    0.03749210f, 0.03208226f, 0.06789812f, -0.02909697f, 0.06846822f, 0.00372829f, -0.08607500f, -0.03145359f, 
    0.01846320f, 0.06487019f, 0.03293752f, -0.02082730f, 0.01203874f, -0.08382298f, -0.08483225f, -0.07905021f, 
    -0.03908538f, 0.03925884f, 0.01132536f, 0.05639298f, 0.05426303f, -0.05241019f, -0.07838184f, 0.04530295f, 
    0.17393649f, 0.04848306f, -0.25183108f, 0.11725187f, 0.09939398f, -0.23435329f, 0.03354321f, 0.23775660f, 
    0.16216362f, 0.02166064f, 0.16367383f, 0.23411304f, 0.02782827f, 0.08161148f, 0.06183359f, -0.07472729f, 
    -0.09057639f, 0.07850593f, -0.43282697f, -0.30159253f, -0.31488636f, 0.01898638f, 0.21700226f, -0.18537176f, 
    -0.11643363f, 0.04121117f, -0.01284890f, -0.34057915f, -0.16150914f, -0.20241231f, 0.05875993f, 0.34481555f, 
    0.09585439f, 0.14529882f, -0.07876488f, -0.02082442f, -0.43813646f, -0.44950113f, -0.06050612f, 0.10490282f, 
    -0.08323456f, -0.08669306f, 0.20567457f, 0.29384243f, 0.01526774f, -0.26680928f, -0.41684237f, -0.12332629f, 
    0.13050376f, 0.16459841f, -0.11767107f, 0.28614578f, 0.08142418f, -0.10781978f, 0.31459004f, -0.03193174f, 
    0.07440259f, 0.08864523f, -0.05947779f, -0.05128536f, 0.09638029f, 0.21802673f, 0.19264604f, 0.27783355f, 
    -0.44487485f, 0.17681551f, 0.22687180f, 0.34499234f, 0.18938611f, 0.20150580f, -0.11625062f, -0.08058421f, 
    -0.19086772f, -0.14327295f, -0.14255476f, -0.08114036f, 0.23506959f, 0.14693065f, 0.18415482f, 0.32342187f, 
    0.33360547f, 0.14207518f, -0.09573406f, -0.26744926f, -0.07703142f, -0.21067403f, -0.35445365f, 0.04121689f, 
    -0.13939646f, 0.14655431f, -0.39418745f, -0.71750355f, -0.01008037f, 0.09015857f, -0.13997099f, -0.08385397f, 
    0.02681997f, -0.06587005f, 0.33779439f, -0.12546627f, 0.07796051f, 0.14265512f, 0.20876454f, -0.01049915f, 
    -0.03084507f, 0.22111472f, 0.41661361f, 0.24398082f, -0.17171322f, -0.38908598f, -0.27941698f, 0.26796496f, 
    -0.05789246f, -0.36384854f, 0.13671961f, 0.25874326f, 0.22217631f, 0.10188515f, 0.11989772f, -0.47351366f, 
    0.20836838f, 0.15913846f, -0.07293034f, 0.24974579f, 0.22339010f, 0.00918648f, -0.78664100f, -0.20716091f, 
    -0.07442471f, -0.20019080f, -0.00207530f, -0.26244146f, -0.37511179f, 0.05295486f, -0.01472673f, -0.14232078f, 
    0.05952103f, 0.10998445f, -0.04664014f, -0.39068356f, 0.22081633f, -0.28575435f, -0.16463232f, -0.50365138f, 
    0.07359102f, -0.08760957f, 0.07879391f, 0.05559486f, -0.14622447f, -0.28549448f, 0.18518351f, 0.24946751f, 
    -0.06863414f, 0.60438108f, 0.33334148f, -0.36620301f, -0.08644065f, 0.17822191f, -0.23023203f, 0.01339726f, 
    -0.00977322f, -0.11584829f, 0.19897217f, 0.06482692f, -0.55173802f, 0.00217789f, -0.06056990f, -0.26836574f, 
    -0.04788922f, -0.02662934f, -0.15186365f, 0.07185991f, -0.34874097f, -0.38061517f, 0.12424347f, 0.13672596f, 
    -0.05718196f, 0.41862306f, -0.08704786f, -0.15168007f, -0.38359302f, -0.78274381f, -0.02060467f, -0.05712311f, 
    -0.12349650f, -0.06175147f, -0.15833025f, 0.19173472f, 0.21675655f, -0.42581987f, -0.02924521f, 0.03277931f, 
    -0.18249118f, -0.11741018f, 0.37310278f, -0.02703301f, -0.06654193f, 0.21876617f, 0.32309714f, 0.33960494f, 
    0.48667085f, 0.13648166f, -0.24187867f, 0.27383453f, 0.06663222f, 0.09387346f, 0.29185519f, 0.28114846f, 
    0.35577592f, 0.13182536f, 0.09227897f, 0.10495643f, 0.00875067f, -0.01109814f, -0.11575436f, -0.11127298f, 
    -1.06371200f, -0.48156902f, -0.59123725f, 0.21029940f, -0.12717302f, 0.08215565f, 0.09843305f, 0.01594995f, 
    0.18415751f, 0.06210142f, -0.55386239f, 0.09666634f, -0.05436567f, 0.27180085f, -0.07474388f, -0.14623414f, 
    0.04046876f, 0.15164454f, 0.39069024f, 0.39663538f, 0.51163977f, -0.09611324f, -0.04679233f, -0.08418881f, 
    0.22585101f, 0.13355123f, 0.05745077f, -0.28287345f, -0.27948314f, 0.03070818f, -0.05599439f, 0.07765184f, 
    -0.15759458f, 0.18115103f, 0.13301530f, 0.43914807f, -0.12215939f, -0.30651745f, 0.14198257f, -0.01080101f, 
    0.15500893f, 0.34694818f, -0.08278473f, 0.00075240f, -0.02651839f, -0.85032707f, -0.33362079f, 0.12757021f, 
    0.01948572f, 0.23900867f, 0.18955113f, -0.05304874f, 0.15610160f, 0.11412531f, -0.36298537f, -0.28581089f, 
    -0.05220212f, -0.05774694f, -0.39655253f, -0.09586886f, 0.00454395f, 0.06429683f, 0.02694797f, -0.03023016f, 
    0.39617059f, 0.16882077f, 0.01992589f, 0.17364644f, -0.06424943f, 0.08039044f, 0.09239346f, -0.36976311f, 
    0.17123491f, 0.05289701f, 0.08271593f, 0.22657822f, -0.06094712f, 0.15933010f, -0.11014777f, -0.17525478f, 
    0.06265476f, 0.70772052f, 0.03872011f, -0.49789858f, -0.43789488f, 0.00159038f, -0.07424835f, 0.15971892f, 
    0.02411350f, 0.01292904f, 0.07783643f, 0.22082783f, -0.31998834f, -0.08677369f, -0.06496698f, 0.10271065f, 
    0.15945446f, 0.02181665f, -0.00421840f, 0.41148692f, 0.11377558f, -0.10205583f, -0.09303102f, -0.10054699f, 
    -0.20196350f, -0.14645472f, -0.11667335f, -0.19593748f, 0.18425703f, -0.58069235f, 0.12911651f, -0.01870326f, 
    -0.15471436f, 0.26100758f, 0.23607528f, 0.18697104f, -0.01751523f, -0.78843981f, -0.28362066f, 0.15393585f, 
    0.14257123f, -0.16620751f, 0.09218920f, -0.04415309f, 0.14310022f, 0.06548976f, 0.10557906f, -0.42548689f, 
    0.16172193f, 0.05326515f, 0.11913562f, 0.08686810f, -0.08719928f, 0.05754167f, 0.25388017f, -0.02991116f, 
    0.29842848f, -0.19389448f, 0.00907906f, 0.27614272f, -0.01982670f, 0.06363504f, -0.13292177f, -0.11253292f, 
    -0.59311360f, -0.19083971f, -0.13703367f, 0.08280528f, -0.00001180f, 0.04032806f, 0.11886527f, 0.10763944f, 
    0.17971227f, 0.38034502f, -0.01413741f, 0.43899095f, -0.38252783f, -0.10162298f, -0.10305131f, 0.12638608f, 
    -0.24649999f, 0.05448303f, 0.18565962f, 0.68562585f, 0.66819149f, -0.08831981f, -0.15065049f, 0.14635433f, 
    0.01914463f, 0.08436985f, -0.12322922f, 0.07149806f, 0.06861445f, -0.10738137f, -0.07109751f, 0.06352765f, 
    0.08644097f, 0.06202175f, 0.23283494f, 0.41423777f, 0.31091255f, 0.07077034f, 0.17733088f, -0.24458835f, 
    -0.30294588f, -0.11902364f, -0.16600819f, -0.15605119f, 0.01200419f, 0.06994183f, -0.09906146f, -0.06143079f, 
    0.21755581f, -0.00176796f, 0.34341961f, 0.03636756f, 0.08355092f, 0.18084820f, 0.15512137f, -0.15536821f, 
    0.46233556f, -0.12217185f, -0.30206338f, -0.32803047f, -0.14820373f, -0.00537409f, -0.07946489f, -0.36741358f, 
    -0.31819469f, -0.01891550f, 0.06819251f, -0.27596393f, -0.38449505f, -0.07878780f, -0.30954927f, -0.32668203f, 
    -0.64847797f, -0.07026266f, 0.25521114f, 0.10260401f, -0.06675482f, 0.14312415f, 0.02778912f, 0.22150260f, 
    0.41619334f, -0.08223473f, 0.85046804f, 0.79582101f, 0.06071503f, 0.07613152f, 0.05904440f, 0.04756106f, 
    0.14297165f, -0.03925007f, 0.11005814f, -0.62858307f, -0.52290326f, -0.18864726f, 0.00712669f, -0.28980199f, 
    -0.14115809f, -0.07498779f, 0.13502599f, -0.06007414f, 0.19740187f, -0.08830477f, -0.00333491f, 0.10647704f, 
    0.01735530f, 0.17870815f, 0.41856915f, 0.43864837f, -0.28830704f, -0.41220877f, 0.14133741f, -0.17137691f, 
    -0.51868725f, 0.12027904f, 0.21115452f, 0.18224160f, 0.05115554f, -0.63014895f, -0.79877514f, -0.45514882f, 
    0.02677229f, -0.01827343f, -0.14692745f, -0.12473190f, -0.07571362f, -0.27897426f, 0.15604189f, -0.30861229f, 
    -0.34036079f, -0.32337025f, 0.03255789f, -0.06414571f, -0.06966870f, -0.13535385f, -0.23273335f, -0.13757469f, 
    -0.66128743f, -0.34278384f, 0.15867327f, 0.10417518f, 0.34058037f, 0.19605422f, 0.14543965f, 0.24411291f, 
    0.30602056f, -0.32666060f, -0.38246354f, -0.18138541f, 0.06639782f, 0.04689927f, 0.27837649f, -0.10608131f, 
    -0.15248331f, 0.29735014f, 0.43403271f, 0.47955668f, -0.43313178f, -0.27971467f, -0.36017498f, 0.22858933f, 
    0.10867789f, 0.18288001f, -0.60586065f, -0.77813023f, -0.32622752f, -0.17698860f, -0.21331811f, -0.36903057f, 
    0.07657953f, -0.10776104f, -0.05963524f, 0.21656772f, 0.06451174f, 0.23046184f, 0.19515565f, -0.08061717f, 
    0.18570137f, -0.11648905f, 0.00528789f, -0.00033185f, 0.12965846f, -0.07629916f, -0.14080909f, -0.29251415f, 
    -0.14748773f, -0.20330815f, 0.06385881f, 0.09597433f, -0.17773589f, 0.40543666f, 0.33359867f, -0.25105476f, 
    0.04792279f, 0.02627039f, 0.47956601f, 0.28820294f, 0.21168682f, -0.12130902f, -0.05802945f, -0.33922294f, 
    -0.23193665f, 0.11956957f, -0.05869898f, -0.30108178f, 0.01269945f, 0.23909037f, 0.05133339f, -0.26068988f, 
    0.02840439f, 0.43021554f, 0.08722145f, -0.06930015f, -0.01615877f, -0.00264677f, 0.09481814f, 0.51896030f, 
    -0.00378898f, 0.22033912f, -0.38533190f, -0.11363454f, 0.06721275f, 0.10028469f, 0.23314255f, -0.01399285f, 
    0.37861183f, 0.47712824f, -0.40208384f, -0.17710084f, 0.08575438f, 0.08283794f, 0.18863796f, 0.14230417f, 
    -0.06216114f, -0.01531216f, -0.09193811f, -0.01144387f, 0.18038520f, 0.00437422f, -0.02810189f, -0.11027542f, 
    -0.07727227f, 0.11185418f, -0.03765873f, -0.45218873f, -0.07148205f, 0.17696601f, 0.04082719f, 0.25235847f, 
    0.06040341f, -0.00115477f, -0.00707595f, 0.19883466f, -0.06358495f, 0.03273963f, 0.11811572f, 0.11335155f, 
    0.30506939f, -0.00957831f, -0.15476607f, 0.31628999f, 0.24831139f, 0.21018268f, 0.20830691f, 0.27353781f, 
    0.12617844f, -0.12112781f, 0.30431306f, 0.06883396f, -0.03638227f, -0.21556236f, -0.01756676f, -0.64249140f, 
    -0.25392866f, 0.19223769f, -0.18544517f, -0.04361983f, -0.03077192f, -0.27030078f, -0.27872854f, 0.12382046f, 
    -0.25352773f, 0.32868055f, -0.12947120f, -0.06359472f, 0.07760588f, 0.09712531f, 0.21682365f, 0.24938191f, 
    0.34642792f, 0.21344973f, 0.36361295f, -0.14884411f, -0.20674650f, -0.12268413f, 0.17548499f, -0.12397277f, 
    -0.22594063f, 0.21719953f, -0.02329947f, -0.70936275f, 0.17644982f, 0.13824891f, 0.10038696f, 0.16782767f, 
    -0.00810874f, -0.00697249f, -0.02168855f, 0.27017948f, -0.18044035f, 0.37363169f, -0.00206646f, -0.09319817f, 
    -0.15001090f, -0.16469903f, 0.01390965f, -0.17888880f, 0.07821526f, -0.05939815f, -0.06800646f, -0.03976953f, 
    -0.10526929f, -0.02853345f, 0.01293295f, -0.20663548f, -0.04685240f, -0.22577702f, -0.47914505f, 0.19392005f, 
    0.09200816f, 0.29448983f, 0.03345001f, -0.21529405f, -0.23123837f, -0.20272821f, 0.09389485f, -0.01092210f, 
    -0.09615661f, -0.03409410f, -0.14353763f, 0.03475431f, 0.21483019f, 0.07288110f, 0.28904983f, 0.31767264f, 
    0.08566989f, -0.13225147f, 0.04591196f, 0.07639793f, 0.15638818f, -0.06243824f, -0.22068560f, 0.15936400f, 
    -0.37480575f, -0.51213044f, 0.19874774f, -0.09678401f, 0.23591834f, -0.10624190f, -0.00815319f, 0.35674855f, 
    0.06525287f, -0.03016166f, 0.08623724f, 0.02491159f, 0.01700408f, 0.15103501f, 0.22105360f, 0.22589219f, 
    0.37295532f, -0.30898154f, 0.36109915f, 0.32472634f, -0.06766350f, 0.09599960f, 0.07137755f, -0.11181128f, 
    -0.20681801f, -0.11637597f, -0.41332069f, -0.36629236f, -0.59805822f, 0.09078300f, 0.04490260f, -0.02620777f, 
    0.05335802f, 0.01791677f, -0.30927312f, -0.42416015f, 0.38632762f, 0.07068434f, 0.00880890f, 0.13262981f, 
    0.07653122f, -0.18262947f, -0.00073008f, 0.23085049f, -0.37380734f, -0.06913533f, 0.16798766f, -0.13277346f, 
    0.03975815f, -0.31395867f, 0.16967466f, 0.07877291f, 0.24869329f, -0.49431604f, -0.65285295f, -0.23577867f, 
    -0.00581258f, 0.07336238f, -0.23076272f, 0.05516569f, -0.01309340f, 0.11803789f, -0.08288545f, -0.99352145f, 
    -0.61948162f, -0.06000197f, -0.08389878f, -0.09764718f, 0.24535717f, 0.08118208f, -0.25303787f, 0.32784149f, 
    0.24879161f, 0.29865402f, 0.09134109f, 0.05190394f, -0.05448657f, 0.01060413f, 0.15919809f, 0.35130107f, 
    0.58460450f, 0.08027303f, 0.16039076f, -0.00429348f, 0.01319601f, 0.14482647f, 0.21339025f, -0.09301904f, 
    0.15102826f, -0.42234704f, -0.14161414f, -0.14974643f, 0.09876885f, 0.09570050f, 0.19269149f, 0.12955865f, 
    -0.06819939f, 0.19114944f, -0.62576407f, -1.09113789f, -0.64184380f, -0.15936407f, -0.21519560f, -0.50350463f, 
    0.02014769f, -0.24221371f, -0.01345164f, -0.23470889f, 0.23799352f, 0.17523272f, -0.10649385f, -0.08347449f, 
    0.05892149f, 0.12259949f, 0.34059387f, 0.24978264f, -0.26303515f, -0.56570077f, -0.09005637f, -0.24611218f, 
    0.03025743f, 0.43705916f, 0.16009948f, 0.19960882f, 0.04408024f, 0.50209659f, -0.01525627f, 0.11441290f, 
    0.16864176f, -0.10253268f, 0.11902805f, -0.00234432f, 0.08225738f, 0.15701549f, 0.30040261f, -0.15760264f, 
    -0.53142947f, -0.44606715f, -0.45551524f, -0.50933248f, -0.48052683f, -0.07335866f, -0.21168935f, -0.83399868f, 
    0.09499463f, 0.65800160f, -0.25077477f, 0.22831444f, -0.18477128f, -0.04945907f, -0.08672051f, 0.22883572f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.22760333f, 0.00665512f, 0.38473430f, -0.23835345f, -0.08127658f, 0.05602813f, -0.00969848f, 0.21996500f, 
    0.51882941f, 0.05609418f, 0.49244544f, 0.09176500f, 0.11224372f, 0.45470315f, 0.02032498f, 0.58440435f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.81331092f, 0.18932821f, -1.21678913f, 0.30245841f, -0.08339016f, -0.06692929f, -0.46446800f, 0.64360195f, 
    0.17454769f, -0.20427737f, -0.94867021f, 0.59628701f, 0.30396408f, 0.30612358f, -0.28104484f, -0.41592076f, 
    0.35062793f, -0.15887037f, -0.37543175f, -0.79310477f, 0.03329369f, -0.11317782f, 0.02354393f, 0.48935676f, 
    0.37692171f, -0.11685412f, -0.19209182f, 0.44460061f, 0.28493559f, -0.12646204f, -0.46180436f, -0.34530011f, 
    -0.81003803f, 0.08732579f, 0.44226193f, -0.47259620f, 0.28385556f, -0.23508316f, -0.61448866f, 0.10047942f, 
    -0.48197502f, -0.06051929f, 0.53834766f, -0.23913769f, 0.43253499f, 0.36851129f, -0.12097504f, 1.05195355f, 
    -0.35375589f, 0.06115887f, -0.34031278f, 0.24171747f, -0.07073833f, 0.10271668f, 0.31616989f, 0.11515398f, 
    -0.76021153f, -0.02348508f, 0.27036923f, 0.10106369f, -0.53608036f, -0.20279294f, 0.47719094f, -0.80401587f, 
    -0.14272779f, -0.08684758f, 1.01153195f, 0.15801796f, -0.07699711f, -0.19805156f, -0.46985075f, -0.17817958f, 
    -0.40998730f, -0.07738226f, -0.53606951f, 0.36075157f, 0.24943587f, 0.17516634f, 0.24565281f, -0.49212232f, 
    0.38785669f, -0.19333710f, 0.43616456f, 0.21287486f, 0.05348904f, -0.14053492f, -0.34063384f, 0.38211012f, 
    0.37197214f, -0.06326747f, 0.22553651f, -0.32263058f, 0.11775884f, -0.55974889f, -0.20059381f, -0.11836983f, 
    -0.84626651f, -0.04584737f, -1.66094112f, 0.28698424f, 0.05873028f, -0.23693419f, -0.59319365f, -0.23848282f, 
    0.41551656f, -0.20607537f, -0.01759756f, -1.05781269f, -0.29505986f, 0.81274283f, 0.06063621f, 0.74315494f, 
    -0.57008737f, 0.21318638f, -0.25034773f, 0.50855851f, -0.00018504f, -0.21832684f, 0.76994604f, -0.06329545f, 
    -0.80352390f, -0.21407786f, -0.60193998f, -0.90092605f, 0.29651371f, 0.10162816f, 0.15655154f, -0.55666816f, 
    0.63128191f, 0.18167925f, -0.28588742f, -0.38823330f, 0.01258847f, 0.19567762f, 0.14945495f, -0.80572253f, 
    0.33250815f, -0.07951523f, 0.56258088f, -0.05928314f, -0.33756506f, -1.08782208f, 0.09005928f, 0.26937705f, 
    -0.39940926f, 0.20045234f, 0.32585692f, 0.18708177f, 0.07207067f, 0.14917557f, -0.27816996f, 0.13374676f, 
    0.14748687f, 0.20014694f, 0.28641427f, -1.25911224f, -0.76124299f, 0.54218495f, 0.48933259f, -0.75303704f, 
    0.14141035f, -0.05990106f, -0.06775287f, 0.99172330f, -0.24783406f, -0.14914474f, 0.04332994f, -1.30703962f, 
    0.14412020f, -0.18191379f, 0.43484247f, 0.17862391f, 0.28999874f, -0.15874439f, -0.88191378f, -0.50214791f, 
    -0.17093812f, -0.16593796f, -0.57627338f, -0.82571435f, 0.05654135f, 0.13189900f, 0.75808930f, 0.46917745f, 
    0.12679780f, -0.13439609f, -0.42713428f, -0.85769254f, -1.05602956f, -0.55509973f, 0.39870518f, 0.55579191f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.62853521f, 0.20008281f, 0.56079513f, 0.49756002f, -0.15568218f, -0.16419531f, -0.09384584f, -0.68496931f, 
    -0.36765322f, 0.19960985f, 0.10735482f, 0.11207120f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
