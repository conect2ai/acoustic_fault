#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.21111150f, -0.17651683f, -0.02057815f, -0.32339624f, -0.44910854f, -0.50309592f, 0.47370121f, -0.33691460f, 
    0.24379958f, 0.02815876f, -0.02063178f, 0.56204057f, 0.20620552f, -0.33102128f, 0.33125618f, -0.40247855f, 
    -0.31882486f, 0.30535990f, 0.09661010f, 0.04521121f, 0.58591533f, 0.72769749f, -0.72174048f, -0.51565093f, 
    0.00392337f, -0.26758429f, 0.27845907f, -0.69123685f, -0.47560596f, -0.40810362f, 0.62463897f, 0.56817281f, 
    -0.17270477f, -0.08789706f, 0.00975164f, 0.04222702f, -0.33145684f, 0.45515686f, 0.47492909f, -0.00517935f, 
    -0.49548987f, -0.45350260f, -0.08556338f, -0.32575583f, -0.34631714f, -0.33690542f, -0.15740749f, -0.28148231f, 
    -0.26862505f, 0.22316556f, -0.15729061f, -0.16510104f, -0.20538497f, -0.31013826f, -0.50096196f, 0.47474039f, 
    -0.25846472f, -0.00443576f, 0.29681334f, 0.07015499f, -0.48014241f, 0.42347664f, -0.07777839f, -0.51436603f, 
    0.26891145f, 0.34024003f, 0.01086672f, 0.18726109f, 0.54133630f, 0.06784084f, 0.31147522f, 0.49369666f, 
    0.66433972f, -0.53491461f, 0.57696277f, -0.40844649f, 0.22294764f, -0.23213509f, -0.07187163f, 0.16766453f, 
    0.44635859f, -0.09894637f, 0.12996331f, 0.03834572f, -0.14381297f, -0.33137164f, -0.06886135f, 0.33611888f, 
    0.64201307f, -0.36597532f, 0.37091660f, 0.14993383f, 0.29486728f, 0.37007365f, 0.14721438f, -0.18601598f, 
    0.36829159f, -0.30086875f, 0.05145576f, 0.32056773f, -0.54695398f, -0.57032639f, 0.26598966f, 0.60727668f, 
    0.19350158f, -0.06667519f, -0.28507259f, -0.27240109f, 0.36252758f, 0.43116125f, 0.42448974f, -0.40537760f, 
    -0.43917328f, -0.23483337f, 0.29296356f, 0.25569478f, 0.12469024f, 0.22960150f, -0.21320289f, -0.05004118f, 
    0.08282090f, 0.58038247f, -0.56871903f, -0.06909096f, 0.51135528f, -0.44815603f, 0.24243356f, 0.19546495f, 
    0.24467576f, 0.30803895f, -0.29457459f, 0.08271354f, -0.09871950f, 0.49294987f, -0.40447003f, 0.76469064f, 
    0.02627171f, -0.31703159f, 0.02942037f, 0.38768268f, 0.24144782f, -0.28618842f, 0.71166110f, -0.15391974f, 
    -0.18856268f, -0.30890745f, 0.17168073f, -0.02271178f, -0.35580680f, -0.43366328f, 0.25224936f, 0.44109434f, 
    0.46286440f, 0.33689922f, -0.04573974f, 0.28992862f, -0.49645916f, 0.19063823f, 0.17041732f, -0.25435174f, 
    -0.26532444f, 0.13178381f, -0.69757688f, -0.49007267f, 0.58426702f, -0.60062742f, -0.14451514f, 0.57236785f, 
    -0.18442814f, -0.01743019f, 0.28581339f, 0.08516826f, -0.08221961f, 0.00029770f, 0.03647050f, 0.13637933f, 
    -0.58070087f, 0.34989098f, -0.39436436f, -0.09981380f, -0.09963097f, -0.31123137f, -0.57719618f, 0.04895150f, 
    0.72481197f, 0.85868305f, -0.00908663f, 0.16543281f, -0.07369155f, -0.57096130f, 0.02150213f, 0.18591286f, 
    0.41498888f, -0.09222375f, 0.16150942f, -0.30383855f, -0.49105227f, -0.06158232f, -0.18542005f, 0.22588837f, 
    -0.07545874f, -0.14554387f, -0.04299560f, 0.04532825f, -0.34435561f, 0.49210712f, 0.19003969f, 0.26079822f, 
    0.69855636f, -0.73768359f, -0.15232733f, -0.35247108f, 0.37541980f, -0.18974096f, -0.11001698f, 0.35024971f, 
    -0.06723756f, 0.43320572f, 0.13506472f, -0.49178353f, -0.56341940f, 0.46281445f, 0.41425294f, -0.30015782f, 
    0.16951717f, -0.64317101f, -0.22621538f, -0.19836856f, 0.41999459f, 0.27173817f, 0.21898071f, 0.43485603f, 
    0.40521282f, -0.20565312f, -0.38633013f, -0.13517812f, -0.04578444f, 0.47586754f, -0.40207732f, -0.59945470f, 
    -0.20398028f, -0.13225542f, -0.31183723f, 0.26464823f, 0.52635616f, 0.09296230f, -0.41123417f, 0.18976472f, 
    0.40291286f, 0.11362626f, 0.03805115f, 0.03184523f, -0.38130423f, -0.10381500f, -0.07342567f, -0.00895747f, 
    -0.48417127f, -0.14543934f, -0.21583988f, 0.46371865f, -0.04005555f, -0.11417919f, 0.16359867f, 0.26246572f, 
    0.22315501f, 0.37968713f, 0.56635374f, -0.33847809f, 0.43808627f, -0.31900695f, 0.37670958f, 0.42219156f, 
    0.37215203f, -0.02769378f, 0.08741510f, 0.17056628f, 0.09039582f, -0.38431719f, -0.24205963f, -0.59116185f, 
    0.36104012f, 0.11163117f, -0.23678057f, -0.34292525f, -0.43765235f, -0.05580482f, 0.05315201f, 0.28562254f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.32905102f, 0.19098972f, -0.19212693f, -0.11347821f, -0.10535359f, 0.05790154f, 0.22640680f, -0.31902036f, 
    -0.07596426f, -0.13485490f, -0.13275598f, -0.18472533f, -0.05072432f, 0.28708798f, -0.02799048f, -0.37533805f, 
    -0.11135343f, -0.02406032f, -0.31119317f, -0.18922995f, -0.09129142f, -0.11712216f, 0.24779083f, -0.01540445f, 
    -0.08337740f, 0.19523740f, -0.42907462f, -0.00054058f, -0.20171845f, -0.32847771f, -0.20728640f, 0.09680442f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.27649781f, -0.26680627f, -0.06300485f, -0.04019715f, -0.06443485f, -0.10041746f, -0.07284704f, 0.12795304f, 
    0.10409998f, 0.06795151f, 0.16024928f, 0.03650724f, -0.06084806f, 0.03472327f, 0.07170298f, 0.08895787f, 
    -0.07835126f, 0.17515685f, -0.54134464f, -0.03215858f, 0.02256476f, 0.10567559f, -0.00954547f, -0.17942508f, 
    0.17720588f, 0.01488453f, 0.06844243f, -0.33741060f, -0.02748182f, 0.14210172f, -0.18006709f, 0.05716667f, 
    0.02896054f, -0.12207678f, -0.05481768f, 0.11356479f, -0.12141223f, 0.03657471f, -0.05015255f, 0.02247805f, 
    -0.06086702f, -0.06836002f, 0.10000690f, -0.05223469f, 0.09108344f, -0.10705066f, -0.04272366f, -0.03273902f, 
    0.06312004f, 0.01564397f, 0.07978925f, -0.03659309f, -0.08360033f, 0.01300133f, 0.04359078f, 0.11751268f, 
    0.13947132f, 0.05644997f, 0.04012940f, 0.09271111f, -0.00714192f, 0.00953241f, 0.16905220f, -0.05310476f, 
    -0.05799096f, -0.21823221f, -0.22810680f, -0.18912399f, -0.08351560f, 0.06467240f, -0.01049937f, -0.04459051f, 
    0.14995620f, -0.19478357f, -0.14302842f, -0.04505907f, -0.12567687f, 0.12876201f, 0.02138102f, -0.08258861f, 
    -0.02374219f, 0.06101981f, -0.16594049f, -0.23137623f, 0.06765328f, -0.00489132f, -0.11694565f, 0.26390374f, 
    0.09785841f, 0.12699077f, -0.05876256f, 0.16442303f, -0.03190281f, 0.06722784f, -0.19012609f, 0.01367944f, 
    -0.05063919f, 0.04870046f, -0.07374718f, -0.07180369f, -0.01614753f, -0.02107249f, 0.00372374f, 0.06792165f, 
    -0.09334192f, 0.08649105f, 0.00932829f, 0.13694307f, -0.05198265f, -0.40858570f, -0.17883065f, 0.02404402f, 
    0.12030579f, -0.02031806f, 0.02148461f, 0.11697535f, 0.03321568f, 0.07767859f, 0.05987520f, 0.21772249f, 
    0.09101813f, 0.15331441f, -0.05856458f, 0.01567308f, 0.07214637f, 0.20246157f, -0.06431103f, 0.03637680f, 
    -0.14349958f, 0.05784111f, 0.01104031f, -0.10615877f, 0.20926793f, 0.06854685f, 0.04419097f, 0.02103325f, 
    -0.04216966f, -0.18355732f, -0.14600188f, -0.03936639f, -0.20469953f, -0.06571282f, 0.07227409f, -0.00928971f, 
    -0.06944094f, -0.38772947f, -0.08959264f, -0.03327196f, -0.00551847f, -0.10917253f, 0.16912405f, 0.12861133f, 
    0.11420845f, -0.01393533f, -0.07718115f, -0.10243766f, -0.11090779f, 0.07147047f, 0.04844429f, -0.13936390f, 
    0.11449952f, -0.01738459f, 0.23100096f, -0.26949149f, -0.18279390f, -0.03316315f, 0.05926408f, -0.12977386f, 
    -0.21713977f, -0.03993469f, 0.07394263f, -0.13416389f, -0.18622242f, -0.02346735f, -0.05228400f, -0.06107019f, 
    0.00473369f, 0.04110500f, 0.11373176f, 0.10233527f, -0.04644379f, 0.17190777f, 0.18329394f, -0.13999736f, 
    0.02832592f, 0.09076624f, 0.07375931f, 0.01209406f, 0.11492825f, 0.16991892f, 0.22832528f, -0.00564871f, 
    -0.17073238f, -0.06036710f, -0.00206335f, -0.10301724f, 0.03845750f, 0.07025463f, 0.02078899f, -0.04833389f, 
    -0.04827597f, 0.06691571f, 0.03661240f, 0.05128455f, 0.22717348f, 0.06714295f, 0.07243608f, 0.29958016f, 
    -0.13734359f, -0.07900177f, 0.05326174f, -0.00844704f, 0.01658969f, 0.00875933f, 0.11239080f, -0.02462345f, 
    0.02291880f, -0.39805534f, -0.35613370f, -0.04773723f, 0.10385157f, 0.09370803f, 0.04525532f, 0.10979082f, 
    0.06073512f, -0.20059605f, 0.14438803f, 0.14432958f, -0.09413724f, 0.04615620f, 0.04204023f, 0.13572609f, 
    0.09494109f, -0.02904315f, -0.20726568f, -0.10109490f, -0.16538545f, -0.08280231f, -0.05532407f, -0.20698176f, 
    0.07273291f, -0.01563559f, 0.11186318f, 0.13277870f, -0.17630741f, -0.15970989f, 0.06159280f, -0.15817955f, 
    -0.00998856f, 0.01807472f, -0.07240330f, -0.00036452f, 0.08463069f, -0.16080551f, -0.04373240f, 0.08343048f, 
    -0.01981745f, -0.15431562f, 0.11871135f, -0.03035667f, 0.12045387f, 0.05159459f, -0.20146087f, -0.09065694f, 
    -0.10239526f, -0.20506248f, 0.18678595f, -0.04248017f, -0.02077136f, -0.10112023f, -0.07008587f, 0.00855422f, 
    -0.09506271f, 0.02798081f, -0.20529076f, -0.04935532f, 0.00966584f, 0.14879580f, 0.07119878f, -0.04563583f, 
    -0.30812010f, -0.05797569f, 0.02913882f, 0.05070006f, -0.10108654f, 0.19397016f, -0.02799609f, 0.06291160f, 
    0.20505716f, 0.31047416f, -0.14331138f, 0.01927061f, -0.00687288f, -0.02649292f, -0.04745390f, 0.04377551f, 
    -0.02767526f, 0.11449537f, -0.02667003f, 0.07554870f, 0.07825721f, 0.09281871f, -0.01644231f, -0.05640838f, 
    0.06083523f, 0.04560957f, -0.06081343f, -0.17718968f, 0.16661960f, -0.03726457f, 0.04614617f, 0.02381587f, 
    0.15662311f, -0.07662684f, 0.04539351f, 0.46354741f, -0.28836772f, -0.20871164f, -0.04918355f, -0.05292742f, 
    -0.19323708f, 0.09819896f, -0.02518206f, 0.03020593f, 0.18387347f, -0.04746364f, -0.13916197f, 0.00431409f, 
    -0.05707539f, 0.10641970f, -0.14012559f, 0.04953675f, 0.05147348f, 0.16215728f, 0.01035027f, -0.24518672f, 
    0.07563043f, 0.00171713f, -0.05993918f, 0.00139144f, 0.06027693f, -0.00831881f, 0.06245100f, -0.01165136f, 
    0.03373098f, -0.09963382f, -0.05216933f, -0.09966177f, 0.06959073f, -0.06524424f, -0.08272816f, 0.18825841f, 
    0.10306527f, 0.15663581f, -0.16557182f, -0.02574504f, -0.19565061f, 0.06391805f, 0.05314797f, 0.06404524f, 
    -0.01316098f, 0.13822110f, 0.03005049f, -0.02966451f, 0.02001538f, 0.14246473f, 0.09762783f, 0.15066640f, 
    0.01944898f, -0.23563248f, 0.00472528f, 0.23386733f, -0.01447626f, -0.23952429f, 0.14987741f, 0.04571485f, 
    0.03359900f, 0.20704992f, 0.11286069f, -0.01887367f, 0.10354397f, -0.06174568f, -0.01243217f, -0.02532976f, 
    0.06505076f, -0.17744760f, -0.00553511f, -0.12516253f, -0.21443252f, 0.07442218f, -0.13069730f, -0.04171425f, 
    -0.05944572f, -0.17668746f, -0.03945430f, -0.02258039f, -0.24668968f, 0.01213154f, 0.18041447f, 0.06553378f, 
    0.11495983f, 0.18926950f, 0.04935145f, 0.05907172f, 0.04176597f, -0.19908141f, -0.20992924f, -0.00765997f, 
    -0.07338159f, -0.03482530f, 0.07482301f, 0.01471991f, -0.02836563f, -0.09012798f, -0.05294843f, -0.02797088f, 
    0.28380036f, -0.05173947f, 0.04515812f, 0.10167576f, 0.00957986f, -0.13878469f, 0.00813821f, 0.19247551f, 
    -0.03262716f, 0.10998746f, -0.18194228f, -0.22706625f, -0.03671549f, 0.17406265f, -0.05718964f, -0.01262395f, 
    0.37423307f, 0.32138473f, -0.00898431f, 0.07564320f, -0.08789556f, 0.05923606f, 0.09153951f, 0.03600409f, 
    0.03603036f, 0.05151689f, 0.04213854f, 0.14203170f, 0.06635327f, -0.05835252f, -0.05422002f, -0.18020694f, 
    0.04901743f, 0.06605167f, 0.36994955f, 0.27409151f, -0.20408362f, -0.02397953f, -0.01511084f, -0.00412247f, 
    0.01972991f, -0.02967302f, -0.13783513f, -0.08386791f, -0.10197160f, -0.08078122f, -0.00240860f, 0.05645793f, 
    -0.02621849f, -0.03740765f, 0.05598129f, 0.04404117f, 0.03880873f, -0.04062082f, 0.07216904f, -0.05301488f, 
    -0.31035563f, -0.29101449f, 0.02107297f, -0.05389842f, -0.04117498f, 0.13010965f, -0.20215954f, -0.14517240f, 
    0.01380271f, 0.07678550f, -0.11237774f, -0.10908560f, 0.00985189f, -0.06835081f, 0.03555001f, 0.06159645f, 
    -0.00950059f, -0.01485651f, -0.03230441f, 0.01042130f, -0.03401565f, -0.09242678f, 0.07926994f, -0.14591569f, 
    -0.04703085f, -0.04690973f, -0.01185906f, 0.09446065f, 0.13995756f, -0.04336138f, -0.21285456f, 0.15703812f, 
    -0.15337849f, 0.29702571f, 0.17642005f, 0.07935957f, -0.09048802f, 0.11185749f, -0.08406244f, -0.01622139f, 
    -0.02216631f, 0.22036240f, -0.11247048f, 0.03185222f, 0.00904302f, -0.04238855f, -0.03577590f, -0.06742295f, 
    0.00524116f, -0.07207571f, 0.33251283f, -0.23140256f, -0.21010929f, -0.03528536f, -0.07901798f, -0.09180249f, 
    0.04813109f, 0.07819217f, 0.03627364f, 0.01852783f, 0.04194897f, 0.16714813f, -0.01090283f, -0.05476969f, 
    -0.02491203f, -0.05600519f, 0.07102239f, 0.02155348f, 0.29909444f, 0.10315456f, -0.12864812f, -0.00835190f, 
    0.01008880f, -0.10073920f, 0.03538068f, -0.06643976f, 0.06932216f, 0.20896398f, 0.26627016f, 0.32539240f, 
    -0.29838425f, -0.26089796f, -0.33439875f, 0.02783404f, -0.03647837f, -0.11404122f, 0.19072691f, 0.06441964f, 
    0.15770070f, 0.04971709f, 0.05062412f, -0.07962672f, -0.01467959f, -0.04844543f, -0.04582017f, 0.16693982f, 
    -0.00292720f, -0.00498794f, -0.00500475f, -0.04293384f, 0.00192042f, 0.03842842f, 0.00498527f, 0.07659208f, 
    -0.01094892f, 0.22161333f, 0.23880452f, -0.14611290f, -0.03204171f, -0.04636366f, -0.03083959f, 0.06670079f, 
    0.14201449f, -0.32680407f, -0.11539727f, 0.16344766f, -0.18353526f, 0.00672757f, 0.03368285f, 0.05500858f, 
    -0.00025672f, -0.05455332f, -0.22629368f, -0.27397588f, -0.00714202f, -0.10820495f, 0.05134897f, -0.11060102f, 
    -0.13775803f, 0.03852285f, -0.00397463f, 0.02701255f, -0.06868948f, -0.04008063f, -0.04416990f, -0.01713818f, 
    -0.07880001f, 0.07608591f, -0.00151418f, -0.05671600f, -0.22191241f, -0.38636234f, -0.12173402f, 0.11348262f, 
    0.09359866f, -0.00214243f, 0.02965075f, 0.00334958f, 0.06171834f, -0.01497783f, 0.10510554f, 0.08371912f, 
    0.05662387f, 0.03262759f, 0.07484909f, 0.11373304f, 0.00581463f, -0.08159461f, -0.17101091f, 0.00060492f, 
    -0.03263626f, 0.05000511f, 0.04549487f, 0.05845427f, -0.00263957f, 0.11464500f, -0.07868338f, -0.17041217f, 
    0.16815434f, -0.11119502f, -0.04704770f, 0.05480174f, -0.02495586f, -0.02236405f, -0.00127918f, -0.02922346f, 
    -0.01582911f, -0.03401313f, -0.05449937f, 0.00748121f, -0.02225313f, 0.08265896f, -0.08642795f, 0.03608728f, 
    -0.07243714f, 0.18908818f, 0.17563680f, 0.00430088f, -0.13072371f, 0.05400971f, 0.10587123f, -0.15882280f, 
    0.14093123f, -0.01103222f, -0.10217654f, -0.05147227f, 0.38568455f, -0.02022494f, 0.03299138f, -0.14068934f, 
    0.00623267f, -0.10874560f, 0.01259661f, -0.06575630f, -0.45081568f, -0.00966451f, -0.05921818f, -0.02183588f, 
    0.03378610f, 0.02954004f, 0.03255009f, -0.02066154f, -0.37992868f, -0.27393356f, -0.00990139f, -0.00245530f, 
    0.03884602f, 0.04785943f, -0.04200731f, -0.00783451f, 0.22237502f, -0.02559457f, 0.08571199f, 0.02827764f, 
    0.00871439f, -0.01691709f, -0.00893095f, 0.00562050f, 0.03897956f, 0.01479732f, -0.11952034f, 0.02533861f, 
    0.20617513f, -0.02203303f, -0.03087843f, -0.01118390f, 0.05963527f, 0.08396254f, -0.14607826f, -0.02044719f, 
    0.41264984f, -0.03971290f, -0.13197568f, -0.17636754f, -0.02170744f, 0.06229656f, -0.02748802f, -0.03123693f, 
    0.19571494f, 0.14063922f, 0.11243705f, 0.03724467f, 0.08866853f, -0.05501105f, 0.00000878f, 0.10915300f, 
    0.11720048f, 0.02509055f, -0.21818145f, 0.09074087f, 0.00005768f, -0.03657594f, 0.09226242f, 0.08116707f, 
    -0.03017401f, -0.16062386f, -0.19977562f, 0.01015925f, 0.02388126f, 0.03762429f, -0.12351523f, 0.13111235f, 
    0.04112722f, 0.05470517f, 0.06017311f, 0.09334181f, 0.22544377f, -0.00968221f, -0.04342628f, -0.03749017f, 
    -0.03707613f, 0.00508200f, -0.10004888f, 0.05606006f, -0.24419360f, 0.03517871f, -0.09360559f, -0.02819189f, 
    -0.06108990f, -0.13860118f, 0.06104578f, -0.07124876f, 0.03917997f, -0.25433868f, -0.09955535f, 0.02797787f, 
    -0.02291960f, 0.10510446f, 0.14681946f, 0.13042028f, -0.06322725f, -0.08855060f, 0.08237584f, -0.00411849f, 
    0.05998300f, 0.11908130f, 0.03455427f, 0.09138365f, 0.10887730f, 0.11840904f, -0.02336460f, -0.13133878f, 
    -0.21725552f, -0.00775519f, 0.10195523f, 0.06693931f, -0.04625582f, -0.02851365f, -0.21918409f, -0.10515488f, 
    -0.45648733f, 0.11209848f, 0.19216898f, 0.05654897f, 0.07953907f, -0.26673833f, -0.02993412f, -0.11213706f, 
    0.15523247f, 0.04930359f, 0.04982582f, -0.19256598f, -0.15630904f, -0.02637311f, 0.08204609f, 0.11562536f, 
    0.01995732f, -0.04518657f, 0.10496227f, -0.00497829f, -0.08261580f, 0.02132182f, -0.09887630f, -0.00691601f, 
    0.23212361f, 0.10625176f, -0.01837845f, -0.19185853f, 0.00207126f, 0.06270926f, 0.11593222f, 0.00222457f, 
    -0.05764479f, -0.00764718f, -0.03001600f, 0.05676011f, 0.19341500f, 0.22939305f, 0.28190765f, -0.22722767f, 
    0.06844702f, 0.05988682f, 0.08755924f, 0.08723538f, 0.00288941f, -0.16290946f, 0.19672678f, -0.05795670f, 
    0.00017751f, -0.00818063f, -0.25007895f, 0.07481339f, 0.14807290f, -0.13205661f, -0.29597825f, -0.01508921f, 
    0.34119454f, 0.04599718f, -0.01387851f, -0.08966538f, -0.04999517f, -0.05098469f, 0.06543376f, -0.14095500f, 
    0.05512317f, 0.16710970f, 0.07813861f, -0.00584319f, 0.10330613f, -0.01032643f, 0.07290040f, 0.03703241f, 
    -0.09501578f, 0.03105101f, -0.09218076f, 0.00997545f, 0.13266556f, 0.08871481f, 0.05453768f, -0.05587080f, 
    -0.33455834f, 0.11520590f, -0.20506661f, 0.01088936f, 0.03346522f, 0.05582398f, -0.11399359f, -0.00236574f, 
    -0.04947075f, -0.10162655f, 0.02725825f, -0.26073375f, -0.19388796f, -0.13681397f, 0.07382815f, -0.13321368f, 
    -0.00428316f, -0.12646034f, -0.05419997f, 0.12660386f, 0.44840461f, 0.10874513f, -0.07800870f, -0.06126796f, 
    -0.08888741f, -0.04263461f, 0.00668149f, 0.05477166f, -0.11194572f, -0.14943096f, -0.08153012f, 0.09845576f, 
    0.05857717f, 0.06535137f, -0.05079688f, -0.17543414f, 0.06568339f, -0.08758710f, 0.11779831f, -0.01522464f, 
    0.00952937f, -0.03131185f, 0.06429517f, 0.10561495f, 0.01090867f, 0.05298399f, -0.05409316f, 0.03541300f, 
    0.14594093f, -0.00737540f, -0.28450248f, 0.00582580f, 0.05972448f, 0.00616576f, -0.02071142f, -0.02563397f, 
    -0.02779871f, 0.03786527f, -0.18325329f, -0.01547194f, -0.19279194f, 0.08410420f, 0.20853017f, 0.05859622f, 
    -0.09869107f, -0.19577019f, -0.05953389f, -0.07482491f, -0.11543801f, -0.14930239f, 0.04172297f, 0.13075937f, 
    0.14255537f, 0.10578847f, -0.18817042f, 0.07681379f, -0.01785941f, -0.23144431f, -0.01272103f, 0.05214283f, 
    0.31578928f, -0.01454957f, -0.14318931f, -0.02338126f, -0.07913546f, -0.08330248f, 0.10180917f, 0.02233272f, 
    -0.05542371f, -0.00966412f, 0.05211170f, 0.03752074f, 0.06188349f, -0.13167694f, -0.19601214f, -0.07436085f, 
    -0.23735769f, -0.10906526f, -0.15467517f, -0.03656504f, -0.35846457f, -0.03556243f, 0.05152301f, 0.04171556f, 
    -0.11671287f, 0.02197315f, -0.01813772f, -0.07397986f, 0.14695084f, 0.22384065f, -0.00370901f, 0.03071769f, 
    0.03484658f, 0.03833697f, 0.06932078f, 0.04155315f, -0.04217738f, 0.07768975f, 0.03373551f, -0.01048782f, 
    -0.04179290f, -0.04458924f, -0.05232480f, -0.00138650f, 0.03611243f, 0.04053898f, 0.00910792f, -0.07216784f, 
    -0.17562565f, -0.06798366f, -0.16174388f, -0.02139988f, 0.10820499f, -0.17710800f, -0.08127945f, 0.17744212f, 
    -0.02597631f, -0.09536158f, -0.14329009f, 0.07867603f, -0.10007221f, 0.16344805f, 0.14952867f, 0.08285660f, 
    0.04190923f, 0.07479562f, -0.06588367f, 0.04463973f, 0.07964373f, 0.02540301f, -0.05631526f, -0.06138944f, 
    -0.11634448f, -0.10445833f, -0.03811506f, 0.02397182f, -0.01471176f, 0.06667911f, -0.01595291f, 0.01397501f, 
    0.02677621f, 0.15733722f, -0.17232896f, 0.03154939f, 0.23393759f, -0.08944145f, 0.02000036f, 0.15688263f, 
    0.06394694f, -0.03473780f, -0.04293090f, -0.15176189f, 0.11342390f, 0.19680832f, -0.02741797f, 0.11359566f, 
    0.08818384f, -0.13953087f, -0.02254138f, -0.14367560f, 0.03519586f, -0.22067451f, 0.03601939f, 0.20161395f, 
    0.10125072f, -0.05920168f, -0.06532009f, 0.00333857f, -0.05391846f, -0.22192411f, -0.03277281f, -0.09784602f, 
    0.09913629f, 0.01351982f, -0.01830657f, 0.03720097f, 0.18218605f, 0.01655075f, 0.03704119f, 0.08194277f, 
    -0.09883556f, -0.06395681f, 0.26983237f, 0.02300521f, -0.11494100f, -0.03909601f, -0.01827312f, 0.03810429f, 
    -0.11966681f, 0.02783295f, -0.03277271f, 0.05564690f, 0.06466427f, -0.18272249f, -0.07055908f, 0.02578074f, 
    0.18210261f, 0.13961355f, 0.12594977f, 0.04056023f, 0.08606973f, -0.03063119f, 0.06793062f, 0.02580930f, 
    0.14011724f, 0.03199798f, 0.05714017f, 0.03782602f, -0.01957709f, 0.01081523f, 0.21656951f, -0.00669657f, 
    0.06503206f, -0.10674080f, -0.10013658f, -0.02376556f, -0.06800265f, 0.03680028f, 0.03628553f, -0.11262330f, 
    -0.05360995f, -0.11498220f, 0.03428566f, 0.22513032f, -0.18989575f, -0.19524114f, 0.07219651f, -0.02153544f, 
    -0.02998622f, 0.07328413f, 0.08517404f, -0.00868769f, -0.11270413f, -0.07757454f, -0.09094984f, -0.07110179f, 
    -0.08952619f, 0.06453792f, -0.12805299f, -0.11078258f, 0.01135475f, 0.01292984f, -0.09572205f, -0.01226052f, 
    -0.00911105f, -0.01326894f, 0.09676805f, 0.04312935f, -0.04248625f, -0.22064871f, -0.02288516f, 0.00503022f, 
    -0.05544649f, 0.22417876f, 0.14002870f, 0.10468573f, 0.03916869f, 0.14387149f, -0.13301729f, 0.01048649f, 
    0.15047802f, -0.02097511f, 0.08087994f, -0.11166571f, -0.03413479f, 0.18029609f, -0.08303877f, 0.04628363f, 
    -0.12689856f, -0.20207447f, -0.08281375f, 0.01910995f, 0.03146266f, -0.15787500f, -0.21739805f, -0.06413748f, 
    -0.03447904f, -0.21078107f, -0.17653191f, 0.19011849f, 0.14773053f, 0.01095360f, 0.09324855f, -0.03893233f, 
    0.15174769f, -0.21535227f, -0.15810417f, -0.37112004f, 0.18009350f, 0.36489239f, -0.04174408f, -0.10578060f, 
    0.18639414f, -0.03341474f, 0.01713979f, -0.12740159f, 0.09682611f, -0.03651795f, 0.27520338f, 0.07676799f, 
    -0.05570173f, -0.13015348f, -0.00774807f, -0.10956465f, -0.11445396f, -0.14626171f, 0.03729178f, 0.13118570f, 
    -0.06684364f, -0.00916111f, 0.07070924f, 0.20462371f, -0.08308845f, 0.00069575f, 0.14210486f, 0.00266252f, 
    0.07396308f, -0.04596550f, -0.08718042f, -0.04520751f, -0.10429493f, 0.14371195f, 0.24115601f, 0.11355999f, 
    -0.06044252f, -0.10556946f, -0.15580933f, -0.15723275f, -0.05069751f, -0.03339757f, 0.21568942f, -0.01381409f, 
    -0.13175939f, -0.05665891f, -0.20793119f, -0.12536104f, -0.01102877f, -0.05336596f, 0.33552018f, 0.32486385f, 
    -0.02235231f, 0.10095071f, 0.07313699f, 0.21308987f, -0.00235416f, -0.16566937f, 0.01540764f, -0.02251725f, 
    -0.02816775f, 0.10501035f, -0.11945064f, -0.09775072f, 0.05108886f, 0.10539857f, -0.05985839f, -0.03143619f, 
    0.05306889f, -0.00496670f, -0.15127560f, -0.00748931f, 0.41499767f, 0.03884724f, -0.10213996f, -0.16523059f, 
    0.26012442f, 0.01849281f, -0.13116859f, -0.29052985f, 0.06735116f, 0.38785771f, 0.08283304f, 0.06817653f, 
    -0.00773077f, -0.00993154f, -0.14342202f, 0.03006878f, -0.06684430f, 0.10396624f, 0.13782690f, 0.10816349f, 
    0.02713037f, 0.09336056f, 0.20414793f, 0.01720548f, -0.18196496f, 0.11990232f, -0.16740111f, -0.03145140f, 
    -0.13230413f, -0.01884292f, 0.05914743f, -0.06169492f, -0.11452427f, 0.07100790f, -0.07155307f, -0.05491834f, 
    -0.07416633f, 0.04724747f, 0.06108171f, -0.03454619f, 0.01501739f, 0.26395974f, -0.10174772f, 0.02365413f, 
    0.11809443f, 0.05339679f, 0.09150442f, -0.12933639f, 0.01944502f, 0.01681245f, -0.03694848f, 0.08936930f, 
    0.03557366f, -0.02822758f, -0.20019984f, -0.26415193f, 0.06691143f, -0.08524216f, -0.14564510f, -0.04013975f, 
    0.04240054f, -0.17695735f, 0.00488493f, 0.01267738f, 0.02012074f, 0.10352557f, -0.06627727f, -0.14428188f, 
    0.31034547f, 0.01971495f, -0.04044350f, -0.08082333f, 0.09014136f, 0.20553979f, 0.10251126f, 0.02635975f, 
    0.08078738f, -0.05360331f, -0.21003886f, -0.12405641f, 0.35897887f, 0.19820839f, 0.21680267f, -0.00268087f, 
    0.05589987f, -0.01235931f, -0.03704362f, -0.04550903f, -0.04409462f, 0.01615760f, 0.10607820f, 0.08563627f, 
    0.14832111f, -0.04232632f, -0.05097954f, 0.12680161f, -0.02711097f, -0.37530607f, 0.10045263f, 0.01322535f, 
    0.03276220f, 0.03130806f, -0.11729383f, -0.16283402f, 0.15597610f, -0.02092058f, 0.02847279f, 0.16770907f, 
    0.03658837f, -0.10018678f, 0.02708255f, 0.15592080f, -0.02332658f, 0.08054253f, 0.00974541f, -0.20938805f, 
    0.06682515f, -0.07049091f, -0.28264859f, 0.03792814f, 0.00121148f, -0.11346125f, 0.04465595f, 0.03685186f, 
    -0.11425656f, 0.00966054f, 0.06232072f, 0.03592154f, -0.03799080f, 0.06345422f, -0.00495119f, 0.03889751f, 
    0.04387530f, 0.08454822f, -0.23934323f, 0.01900098f, 0.20007092f, 0.13177137f, -0.12031095f, 0.05403072f, 
    0.21843939f, -0.15533641f, -0.05088145f, -0.04761213f, -0.09868696f, -0.14930491f, 0.04067672f, -0.16866326f, 
    -0.02770958f, -0.06866992f, 0.05875840f, -0.00680976f, 0.03314050f, 0.08842859f, 0.05000231f, 0.14606622f, 
    -0.26751292f, 0.13924322f, 0.14296661f, -0.06330297f, 0.10453398f, 0.06238193f, 0.04154624f, -0.03816383f, 
    -0.02351567f, -0.04010933f, -0.11682335f, 0.05404489f, -0.00086878f, -0.06284931f, -0.16793406f, -0.07281592f, 
    0.01307588f, -0.02538421f, -0.14701268f, -0.02392059f, -0.19872896f, -0.11068185f, -0.04770492f, 0.14352852f, 
    0.09209535f, 0.22618553f, 0.10084008f, -0.08150656f, 0.02324556f, 0.01481304f, -0.09236345f, -0.26959306f, 
    0.34058544f, 0.04460954f, -0.00267245f, 0.11935387f, -0.20190167f, -0.20561434f, 0.07314014f, 0.05530287f, 
    0.08360697f, -0.08563599f, -0.00083316f, 0.18357900f, 0.03847364f, -0.01600720f, -0.00966324f, 0.09911178f, 
    -0.12131462f, 0.09100069f, -0.20829149f, -0.35612193f, 0.04922232f, -0.13205512f, -0.11509727f, -0.10341889f, 
    0.11529617f, -0.03369563f, 0.10133526f, -0.04794333f, -0.14783052f, -0.80086333f, -0.06245700f, -0.05828147f, 
    0.02864980f, -0.11315152f, -0.16245408f, -0.08817063f, -0.10856462f, 0.16419339f, -0.02524483f, -0.12010589f, 
    -0.39726648f, -0.04502629f, 0.05161016f, 0.11743969f, 0.00327446f, 0.27433145f, 0.02112709f, -0.08765122f, 
    -0.11143837f, 0.09963626f, 0.08117801f, 0.00723507f, 0.00974948f, 0.06364162f, -0.00717016f, 0.06726090f, 
    -0.13186885f, -0.11510020f, 0.04105508f, 0.03091806f, -0.12465481f, -0.00209619f, 0.04832222f, 0.25276759f, 
    -0.02732887f, -0.00955821f, -0.22150514f, -0.07670296f, -0.09008560f, 0.17055294f, 0.01367965f, -0.04964531f, 
    0.29263452f, 0.02858614f, -0.02487971f, -0.03518734f, 0.16584963f, -0.08638567f, 0.19018184f, 0.15079798f, 
    -0.03033459f, 0.13073295f, -0.10643838f, -0.12771966f, -0.02167817f, -0.01291743f, -0.07409249f, 0.09362791f, 
    0.17532413f, 0.13380840f, -0.14405292f, 0.19225590f, 0.14025964f, -0.01654384f, -0.18811207f, -0.09979595f, 
    -0.11596666f, 0.01555284f, 0.17411080f, 0.06974903f, -0.44496691f, -0.17114475f, -0.24991553f, -0.08704986f, 
    0.01802338f, 0.04344414f, -0.04305880f, -0.06578097f, 0.12183446f, 0.19925329f, 0.15064223f, -0.04107252f, 
    -0.10264245f, 0.00577416f, 0.05040335f, 0.17609817f, 0.10643165f, 0.00592182f, 0.01763077f, 0.05064409f, 
    0.05617195f, 0.05014033f, -0.04472584f, 0.10479369f, -0.04963194f, -0.06771582f, -0.27911830f, -0.08935592f, 
    0.13618179f, -0.10339736f, -0.05352942f, -0.10444535f, 0.00136476f, 0.11520686f, 0.01518533f, -0.18082690f, 
    -0.17340399f, 0.24417499f, -0.08529729f, 0.11145100f, -0.19891702f, -0.03757616f, 0.24312800f, -0.01632053f, 
    0.40669307f, -0.12954776f, -0.21190435f, 0.03235551f, -0.00011829f, -0.00842412f, 0.17446710f, 0.10569848f, 
    -0.05127767f, -0.23884860f, 0.04953997f, 0.24931332f, 0.05962490f, -0.14756486f, 0.04027972f, -0.00171012f, 
    0.13214706f, 0.09218886f, 0.26697141f, -0.06861389f, -0.01236567f, -0.19691621f, -0.26654491f, 0.03991717f, 
    -0.08576302f, 0.03853922f, -0.04753674f, 0.02734883f, -0.03256568f, 0.01838659f, 0.05415183f, 0.07802618f, 
    -0.01610939f, 0.00821436f, 0.01611760f, 0.03935235f, -0.47729990f, -0.75177503f, -0.08552660f, -0.10555214f, 
    0.11306805f, -0.05988533f, 0.15577599f, -0.06239420f, 0.07882648f, 0.23260921f, 0.13899951f, -0.05916277f, 
    -0.10104459f, -0.06026769f, 0.05424039f, 0.08882809f, 0.12197351f, 0.01616605f, 0.00343375f, -0.04135153f, 
    0.00389315f, -0.04000245f, -0.05681160f, -0.00025320f, 0.08967197f, 0.02464441f, -0.01741999f, -0.28199449f, 
    -0.26192272f, -0.18362755f, 0.19804803f, 0.16534787f, 0.12689270f, -0.03439832f, -0.11701575f, -0.04635762f, 
    0.19114839f, 0.05745696f, 0.10508806f, 0.05670441f, -0.11808147f, -0.05577299f, -0.05386096f, 0.08210555f, 
    -0.06113555f, -0.00649300f, -0.19345143f, -0.14602110f, -0.05868175f, 0.09019250f, 0.10268956f, 0.09538551f, 
    -0.00426243f, 0.00673138f, 0.06939595f, 0.13471918f, -0.24744789f, -0.16693215f, -0.20469233f, -0.10212289f, 
    0.06066886f, 0.12591293f, 0.14390995f, -0.03373863f, 0.22073792f, 0.24281631f, -0.13873491f, 0.00530992f, 
    -0.04874150f, -0.10089429f, 0.05046087f, 0.04124927f, 0.16238259f, 0.08883254f, -0.20122872f, 0.10420693f, 
    0.06006353f, -0.16490641f, 0.01635904f, -0.00911226f, 0.15578774f, -0.18915178f, -0.07852769f, 0.26555279f, 
    -0.16438198f, -0.04965170f, -0.09838615f, -0.16264530f, 0.06573008f, 0.14725085f, -0.05231845f, 0.20946272f, 
    0.25361827f, 0.12352818f, -0.13540503f, -0.13510126f, -0.13943146f, -0.03313934f, 0.14376093f, 0.25483534f, 
    0.03719088f, -0.06798141f, 0.04428829f, -0.02082472f, 0.21952325f, 0.04118661f, 0.11402902f, 0.10734506f, 
    -0.16227178f, -0.07223003f, 0.36682117f, -0.11243856f, -0.02582214f, -0.02731299f, 0.02187300f, 0.13123110f, 
    0.02511424f, -0.14380921f, 0.10560323f, -0.06307575f, 0.02161776f, 0.20321865f, -0.14194612f, 0.39387071f, 
    0.16696079f, -0.12623495f, -0.33975786f, 0.25878647f, 0.15628634f, -0.03763633f, 0.22488108f, -0.09210243f, 
    0.00476392f, 0.20297156f, 0.04363929f, -0.20397153f, 0.12486000f, 0.27016819f, -0.13287462f, -0.08036888f, 
    -0.38223892f, -0.03145896f, -0.12837733f, -0.15285778f, -0.08638070f, 0.10658639f, -0.14607280f, -0.04266418f, 
    0.09446087f, 0.15036556f, 0.09558614f, -0.01837779f, -0.16863695f, 0.12111399f, 0.03884176f, 0.22095038f, 
    -0.00204798f, 0.05779074f, -0.16741042f, -0.00681687f, 0.01934792f, -0.00627937f, 0.04882700f, 0.00620058f, 
    -0.01586202f, -0.04338120f, -0.11730523f, 0.01146454f, -0.00416448f, -0.14250165f, 0.18574317f, 0.06089128f, 
    0.03367602f, -0.11431187f, 0.04306689f, -0.06729385f, -0.16013134f, -0.06167418f, -0.03649990f, -0.07758711f, 
    -0.09476346f, -0.05332738f, -0.15951288f, -0.00653173f, 0.09505151f, 0.27837974f, 0.02718504f, 0.01383745f, 
    0.14725409f, 0.00693882f, -0.02902194f, 0.20101525f, 0.11057526f, -0.16379270f, 0.07950338f, -0.18258813f, 
    0.13932581f, 0.12430353f, -0.23447150f, -0.02860264f, 0.00055802f, -0.00192843f, 0.05918579f, 0.05666393f, 
    0.04145086f, 0.09449300f, 0.16206504f, 0.06042490f, 0.18344936f, 0.16234373f, -0.09907667f, -0.29096070f, 
    -0.06938384f, -0.16722402f, -0.07037918f, -0.12062148f, -0.36680976f, 0.05281923f, -0.05646329f, 0.08552399f, 
    0.10765453f, -0.03436562f, -0.05672131f, 0.11283370f, 0.26265997f, 0.11397728f, -0.00820784f, 0.16336432f, 
    0.13182011f, 0.06744429f, 0.27605766f, 0.11654364f, 0.19453318f, 0.10088117f, -0.05136042f, 0.06869522f, 
    0.19643025f, 0.05377920f, 0.06061542f, 0.07893457f, -0.02100586f, 0.10865723f, 0.16879806f, -0.27362370f, 
    -0.15078422f, 0.33212647f, -0.13377783f, -0.05775626f, 0.19828384f, 0.08860786f, -0.14644624f, 0.30428770f, 
    0.02818437f, -0.02698982f, 0.24427432f, 0.06641672f, -0.00169257f, -0.05815783f, 0.03259766f, 0.09098899f, 
    -0.07261238f, -0.07230975f, 0.08128557f, -0.13931389f, -0.13244556f, 0.10488164f, 0.10744835f, 0.17713737f, 
    0.00923273f, -0.19222605f, 0.29113737f, 0.23963618f, -0.20934236f, -0.10219835f, 0.15303008f, -0.10883218f, 
    0.12016349f, 0.13502094f, -0.06816261f, 0.01723664f, 0.16620158f, 0.22526371f, 0.12541452f, 0.03208016f, 
    0.01758056f, 0.08256313f, 0.18111697f, 0.20364854f, -0.00844995f, 0.16929898f, 0.03919654f, -0.08397743f, 
    -0.31802526f, -0.00758481f, -0.05276744f, -0.10669834f, 0.02430372f, 0.10965253f, 0.10041700f, -0.11062609f, 
    0.05109632f, 0.03559054f, -0.08772696f, 0.05269465f, -0.08263097f, -0.19386926f, 0.13438146f, 0.11952920f, 
    0.19861600f, 0.08377113f, -0.00254746f, 0.16228616f, 0.09010852f, -0.02556176f, 0.14794502f, -0.25751114f, 
    0.25299954f, -0.11084803f, 0.08776379f, 0.05201257f, 0.05606101f, 0.16387668f, 0.09458220f, 0.13925180f, 
    -0.14097926f, 0.07848477f, -0.00037815f, -0.00858921f, -0.02245403f, -0.00355951f, 0.04073002f, 0.13950981f, 
    0.10916226f, -0.07672986f, -0.06747236f, 0.14742839f, -0.07044084f, 0.08960344f, 0.02814501f, -0.03906885f, 
    0.05554984f, -0.15978062f, 0.09180219f, -0.07897932f, 0.27228814f, 0.06388976f, 0.14942108f, -0.15985560f, 
    0.00369161f, -0.03750454f, -0.09583499f, -0.10806002f, 0.01647511f, -0.03953480f, -0.00655965f, -0.17272325f, 
    0.04852797f, 0.02294887f, -0.02016802f, 0.02651012f, 0.13780759f, -0.10054569f, 0.28409672f, -0.04441130f, 
    -0.18331978f, 0.07877208f, -0.06963874f, 0.03534574f, -0.05019332f, -0.15004133f, 0.00752757f, -0.02112309f, 
    -0.01249733f, -0.21791781f, -0.08673555f, -0.08536715f, -0.17116274f, 0.08405823f, -0.22165962f, -0.00271222f, 
    0.00109535f, -0.06064430f, -0.11823497f, -0.01653558f, 0.01068033f, -0.00253479f, -0.10315551f, 0.11966687f, 
    0.01834625f, 0.13229212f, 0.04990241f, -0.07400412f, 0.08246802f, 0.03233110f, 0.17608203f, 0.01297893f, 
    0.05607196f, 0.10325636f, 0.29915020f, 0.07881033f, -0.18752508f, -0.12126400f, 0.09472601f, -0.03069714f, 
    0.01233574f, -0.17067456f, -0.19127336f, -0.17329916f, -0.10482319f, -0.00517688f, 0.02699918f, 0.11625811f, 
    0.01460440f, 0.04124651f, 0.01815428f, -0.26349851f, -0.14578550f, -0.14376113f, -0.10654536f, 0.01881184f, 
    0.08341837f, 0.00008731f, -0.08044407f, -0.07788792f, -0.00359829f, 0.24162228f, -0.03260121f, -0.11888801f, 
    -0.29205707f, 0.03231253f, -0.00508773f, 0.02403809f, -0.12275361f, -0.17152716f, -0.07138326f, -0.04435273f, 
    -0.00903130f, -0.05838046f, 0.03250568f, 0.09989677f, -0.01793318f, -0.11708755f, -0.03621228f, 0.06436542f, 
    0.16588433f, -0.02619246f, 0.09855016f, 0.07141682f, -0.02844638f, -0.02977856f, -0.14038365f, 0.07573817f, 
    -0.04863001f, 0.02457490f, 0.04649885f, 0.07396509f, 0.13130565f, 0.04742582f, -0.05938645f, -0.07860736f, 
    0.19877502f, -0.02192995f, 0.01678031f, 0.13667051f, 0.05539162f, 0.10284723f, -0.07420173f, 0.00866990f, 
    -0.01407977f, -0.03724773f, -0.15447481f, 0.17334078f, 0.11709261f, 0.24185009f, 0.02765161f, -0.05854700f, 
    -0.09160743f, -0.00447343f, 0.04888332f, 0.13074890f, -0.01333054f, 0.10296124f, 0.04255913f, -0.01257124f, 
    0.09890777f, -0.12365694f, 0.15658066f, -0.18896541f, 0.10720283f, -0.08527903f, -0.04450411f, 0.02159535f, 
    0.11533575f, 0.01854395f, 0.06877904f, 0.03864911f, -0.17950070f, -0.03881241f, 0.06487507f, -0.16089614f, 
    -0.03799945f, 0.00645910f, -0.09083524f, 0.09240565f, 0.21784563f, 0.16190584f, -0.25004098f, 0.09177072f, 
    0.00700086f, 0.08907343f, 0.03315197f, 0.01490842f, -0.10287216f, -0.10716075f, -0.05612832f, 0.14451839f, 
    -0.03618515f, 0.17144178f, -0.03041527f, 0.03454085f, 0.12419086f, 0.01236783f, -0.10705438f, -0.00295470f, 
    -0.05967461f, 0.01866601f, 0.06957430f, -0.02146981f, 0.08507633f, 0.13477844f, 0.05494590f, -0.07990934f, 
    0.22965795f, 0.40553549f, -0.09489688f, -0.08112004f, 0.04693545f, 0.12249425f, 0.03644028f, -0.08069164f, 
    0.13300987f, 0.05353038f, 0.22093758f, -0.02496828f, -0.09326368f, -0.10720376f, 0.11680119f, -0.07108185f, 
    -0.05386613f, -0.32297045f, -0.45180672f, -0.29248857f, 0.14743611f, 0.03493665f, 0.07193379f, 0.03054096f, 
    -0.02308498f, 0.04976258f, -0.62284976f, 0.12272100f, -0.18801883f, -0.06041611f, 0.03431638f, 0.00098095f, 
    -0.05480588f, 0.12591460f, -0.11798116f, 0.06848510f, -0.04517642f, 0.12590794f, -0.19836003f, -0.09658815f, 
    -0.11335794f, 0.04721657f, 0.04944046f, 0.13559619f, 0.07939005f, 0.26443225f, 0.15975487f, -0.00778089f, 
    -0.18763676f, -0.26697582f, -0.04162976f, -0.02750438f, 0.02297776f, -0.16570069f, -0.02230208f, -0.00450964f, 
    -0.10511892f, 0.17003962f, -0.01105101f, 0.06520273f, 0.05935017f, 0.05999592f, -0.08679089f, 0.09339901f, 
    0.09809764f, 0.05899908f, 0.03864893f, 0.11758655f, 0.15369707f, -0.09779617f, -0.06305048f, -0.51483762f, 
    0.21199456f, -0.60178906f, 0.10562589f, -0.07580888f, 0.02887852f, 0.04005440f, 0.10237080f, 0.05658483f, 
    -0.22729418f, 0.01655554f, -0.47337908f, 0.03797597f, -0.00701298f, 0.14086184f, 0.01817909f, 0.13169563f, 
    -0.03816958f, -0.00615191f, -0.01599046f, 0.24146785f, 0.13880385f, 0.05880230f, -0.14256310f, 0.03715213f, 
    0.03659485f, -0.04147034f, -0.26314476f, 0.09373248f, 0.04868702f, -0.22439261f, 0.06854185f, -0.15121344f, 
    0.02687313f, -0.05213597f, 0.10183860f, -0.04984326f, 0.01588389f, -0.14148019f, -0.05254914f, 0.00435404f, 
    0.16467308f, 0.10816205f, -0.02863835f, 0.02783564f, -0.08263657f, -0.00027521f, 0.20359822f, -0.12391182f, 
    -0.05223373f, 0.13715358f, 0.08112872f, 0.01701388f, 0.05424353f, 0.07546502f, 0.27606320f, 0.13411625f, 
    0.01405965f, -0.08221712f, -0.00114149f, 0.02756588f, 0.11728442f, 0.09024935f, -0.04641157f, -0.35497108f, 
    -0.18371075f, -0.08542813f, -0.03401056f, 0.01252576f, 0.10820761f, -0.02073902f, 0.02634533f, -0.04352669f, 
    0.17289294f, -0.12000053f, -0.10223816f, -0.07820556f, -0.04918443f, -0.03053281f, -0.07753539f, 0.08336214f, 
    -0.03117178f, -0.03965054f, 0.03853527f, 0.12239293f, 0.19522804f, -0.00014312f, 0.00301217f, -0.05034921f, 
    0.05094373f, 0.17157245f, 0.04226419f, 0.11470010f, -0.11928535f, 0.03093470f, 0.05617065f, -0.02177132f, 
    0.08370809f, -0.08947170f, 0.35753131f, 0.09054337f, 0.10119352f, -0.03296045f, -0.07378543f, 0.10117425f, 
    -0.27798915f, 0.10523721f, 0.04660331f, -0.15978900f, -0.13644533f, 0.00041578f, 0.05849492f, 0.01705629f, 
    0.15168843f, 0.06856374f, 0.16759518f, 0.26336524f, 0.36551133f, 0.24326187f, 0.23446245f, 0.02294206f, 
    0.06129061f, 0.06151550f, -0.03764935f, 0.08300947f, 0.10751416f, -0.02150387f, 0.11126440f, -0.04111674f, 
    0.02423697f, 0.09133545f, -0.00512349f, 0.09098594f, 0.13634381f, 0.20879787f, 0.10902430f, -0.02124468f, 
    -0.04713669f, 0.09091948f, 0.03668657f, 0.05364124f, -0.05636341f, 0.10375252f, 0.13903105f, 0.06274626f, 
    -0.03833019f, -0.03904039f, 0.05200134f, 0.12544362f, 0.00809783f, -0.00856670f, 0.04339096f, -0.16365126f, 
    0.07561980f, 0.22423826f, 0.13176349f, -0.15646473f, 0.11460009f, -0.17295900f, -0.15945151f, -0.09927189f, 
    -0.16057447f, -0.06959740f, -0.08225831f, 0.09638686f, -0.01104750f, 0.05271266f, 0.10158813f, -0.12620473f, 
    -0.28642225f, -0.03372663f, 0.26265782f, 0.02007988f, -0.01765012f, -0.02309838f, 0.04694007f, -0.03506558f, 
    -0.06173121f, -0.02556687f, 0.12322807f, -0.12629932f, -0.02234228f, 0.24192218f, 0.03691800f, 0.10138204f, 
    0.22630309f, 0.19449309f, 0.18875813f, 0.19714743f, 0.12657721f, 0.18183619f, -0.00790334f, -0.01182480f, 
    -0.01158368f, -0.08117457f, -0.11650316f, -0.08693491f, -0.10042282f, -0.02826380f, 0.13706161f, 0.07342497f, 
    -0.05530394f, 0.09804204f, 0.09659519f, 0.05541934f, -0.01566233f, 0.11653343f, 0.14883775f, 0.14150193f, 
    -0.03523925f, -0.00349254f, -0.18563542f, -0.04994556f, 0.02210198f, -0.04811152f, 0.12375183f, 0.05242575f, 
    -0.08927516f, 0.07987159f, -0.20839933f, 0.07808101f, 0.18929243f, -0.04570120f, -0.16283518f, 0.07673480f, 
    -0.25921667f, -0.09228906f, 0.00122140f, -0.04933096f, -0.00497326f, 0.01455420f, -0.20329560f, 0.00693835f, 
    -0.25900596f, 0.01874169f, 0.18770908f, 0.16247518f, 0.09117861f, 0.05909031f, -0.05353012f, 0.09320575f, 
    -0.01240098f, 0.01595685f, 0.21323603f, 0.06105020f, 0.01269984f, 0.00011325f, 0.06088044f, 0.12391686f, 
    0.06150863f, -0.01015457f, 0.01967244f, 0.01387832f, 0.04396460f, 0.09710531f, 0.05161694f, 0.03842011f, 
    0.02474122f, -0.02778313f, 0.02879849f, 0.15712792f, 0.09890875f, 0.02153084f, 0.00191144f, -0.12657690f, 
    -0.02425020f, 0.08882587f, 0.05476454f, 0.01798796f, -0.01356887f, -0.09211520f, -0.15020449f, 0.00444393f, 
    0.02726368f, 0.10103783f, 0.16335411f, 0.10020754f, 0.17798832f, 0.12122899f, -0.01030398f, -0.00352282f, 
    0.05610872f, 0.11891778f, 0.11314858f, 0.00679050f, -0.04853657f, -0.00867637f, -0.07528906f, 0.00323705f, 
    0.17000535f, 0.02898097f, 0.06880928f, -0.00668422f, 0.03098297f, -0.04860738f, 0.11892579f, -0.04005650f, 
    -0.04980870f, 0.17307764f, -0.05740737f, -0.07208037f, -0.01034505f, 0.09603655f, -0.10426780f, 0.10377790f, 
    0.00499984f, 0.12957205f, -0.11905778f, 0.00362278f, -0.06389454f, -0.06731001f, 0.03474614f, 0.03190462f, 
    -0.12038696f, -0.05661637f, 0.10090845f, 0.17688471f, 0.19205379f, -0.01625090f, -0.12349608f, 0.12348085f, 
    -0.04320604f, 0.16138536f, 0.08475021f, 0.08744002f, 0.05176395f, 0.02080687f, 0.03340500f, 0.00043634f, 
    0.03759704f, -0.14306545f, -0.02860447f, 0.04620875f, 0.02822351f, -0.05291185f, 0.11714228f, 0.13610394f, 
    0.01059971f, -0.02801518f, 0.02633302f, 0.10006770f, 0.07331167f, 0.04083232f, -0.11856234f, -0.04020518f, 
    -0.10662994f, 0.17083311f, 0.01529179f, -0.04199642f, -0.10639067f, 0.08138297f, 0.03003229f, 0.13008876f, 
    0.04417278f, 0.05983799f, -0.03013288f, 0.01993989f, 0.09969110f, -0.01492097f, -0.03325380f, 0.06861089f, 
    0.12771563f, 0.05651097f, 0.12724830f, -0.01466940f, -0.04353288f, -0.04314874f, 0.06983674f, 0.08905475f, 
    -0.55938530f, 0.01812170f, -0.04393905f, 0.00949847f, -0.11734813f, -0.16541865f, -0.07584100f, -0.06569959f, 
    -0.15550362f, -0.03583089f, 0.19298513f, 0.27156949f, -0.00774394f, 0.20844916f, 0.06955281f, 0.01515629f, 
    -0.01253393f, -0.00147646f, -0.23089658f, -0.31052557f, 0.16709322f, -0.03711574f, 0.10707251f, -0.15518598f, 
    0.15667848f, -0.01564408f, 0.02393470f, -0.50215918f, -0.00585790f, 0.23076870f, -0.04663222f, 0.00907739f, 
    -0.15658574f, 0.02697227f, 0.10586229f, 0.09479584f, -0.07686158f, 0.02217324f, -0.24947190f, -0.14498658f, 
    0.02884966f, -0.09031090f, 0.06325957f, 0.01028730f, 0.06748392f, -0.08980503f, -0.07074147f, -0.04965219f, 
    0.04019757f, 0.00914241f, -0.01116229f, -0.03704166f, -0.06664161f, 0.03302755f, -0.09236468f, 0.06242096f, 
    0.26042494f, 0.12253202f, 0.11114490f, 0.18777010f, 0.03222589f, 0.04459086f, 0.04743493f, -0.09943252f, 
    0.07542711f, 0.07381769f, -0.07943578f, -0.08416027f, -0.08172761f, 0.02539166f, -0.00669266f, -0.02556018f, 
    0.35106325f, -0.02870818f, 0.02367092f, -0.07262430f, -0.03828106f, 0.14606261f, -0.01085406f, 0.03638783f, 
    -0.03054995f, -0.03976225f, -0.14950550f, 0.04481903f, -0.10439684f, 0.07702829f, 0.00574452f, 0.09130775f, 
    -0.13095883f, 0.05307366f, 0.06928280f, 0.09566083f, 0.18298496f, -0.07472363f, 0.04582902f, -0.05622542f, 
    0.00056127f, 0.08483056f, -0.02497188f, -0.50617713f, 0.08818969f, -0.16606848f, -0.03249714f, 0.05355087f, 
    -0.11594371f, 0.08803470f, -0.03923814f, -0.01616780f, 0.26755714f, -0.38603345f, -0.23187684f, 0.13227563f, 
    0.04250568f, -0.00253331f, -0.17496090f, -0.03400030f, -0.15576853f, 0.06870624f, 0.03246399f, 0.13802782f, 
    0.04936425f, 0.15610576f, 0.10605089f, 0.06365064f, -0.03343623f, 0.34365791f, 0.11478413f, 0.03945897f, 
    0.02892108f, 0.05559799f, 0.06408530f, 0.12501997f, 0.07171278f, 0.02117338f, 0.14415495f, 0.12661721f, 
    0.15247276f, 0.00702587f, -0.04287417f, -0.02987324f, 0.05645217f, -0.23514119f, -0.01966851f, -0.04804665f, 
    -0.39485830f, -0.09295189f, -0.35275796f, -0.03493224f, -0.07467566f, -0.07019816f, 0.03613750f, -0.16614707f, 
    -0.13744560f, 0.07086735f, 0.16879576f, 0.08971727f, -0.12354939f, 0.05574918f, 0.08435510f, -0.04424733f, 
    0.10204651f, -0.07115040f, -0.32410800f, -0.26869830f, -0.02825649f, -0.04213086f, -0.01444891f, 0.03488950f, 
    -0.08815586f, -0.05618658f, 0.05770053f, -0.19015560f, -0.01306104f, -0.16195016f, 0.09023299f, 0.01490979f, 
    -0.06549166f, 0.04831901f, 0.11571316f, 0.10813430f, -0.32416502f, 0.08098474f, 0.06719407f, -0.15947621f, 
    -0.07295486f, -0.17216845f, -0.01053062f, -0.07883278f, 0.05844541f, 0.07952152f, -0.09918247f, -0.05679677f, 
    -0.09957785f, -0.06310323f, -0.06022425f, -0.02817288f, 0.01864329f, 0.01942562f, -0.12920415f, 0.07091793f, 
    0.10839341f, 0.09494229f, 0.05980073f, 0.03290796f, 0.10279668f, 0.04809491f, 0.11080521f, 0.32692149f, 
    -0.02552926f, 0.10063595f, 0.05805859f, 0.04765457f, 0.07816159f, -0.04793421f, 0.01930459f, -0.10920454f, 
    0.27792251f, -0.11012893f, -0.11599676f, -0.03833032f, -0.05663087f, 0.06076483f, 0.06272795f, 0.00152409f, 
    0.00864242f, -0.25526631f, 0.03331301f, 0.17128932f, -0.07179683f, 0.00300175f, 0.00054133f, 0.00153334f, 
    0.03625141f, 0.03612578f, 0.09128589f, -0.01088122f, -0.52422643f, -0.19408430f, -0.09486953f, -0.22440007f, 
    0.14550018f, -0.07928668f, 0.14770395f, 0.43334484f, 0.11889154f, 0.06730640f, -0.02416173f, -0.08550159f, 
    0.02589371f, -0.00556790f, -0.04346235f, 0.00174005f, -0.22870158f, -0.41489998f, 0.05690731f, 0.03758221f, 
    -0.10290353f, -0.14725287f, -0.07597293f, -0.23716643f, 0.05127011f, -0.07350474f, 0.00182473f, 0.04350277f, 
    0.10859306f, 0.09032821f, -0.15656573f, -0.12986694f, -0.00615060f, 0.05932723f, 0.08357003f, 0.20607640f, 
    0.05085155f, -0.07858089f, -0.08099336f, -0.12841503f, -0.04981780f, 0.03504644f, 0.10483124f, -0.40211821f, 
    -0.34608886f, -0.28370479f, 0.03603856f, 0.13007295f, 0.04984857f, 0.07000906f, -0.01810618f, 0.01916980f, 
    -0.03573483f, 0.03812139f, 0.00218261f, -0.00165886f, -0.04060248f, 0.02058489f, -0.06315462f, -0.05982310f, 
    0.04696193f, 0.00982109f, 0.04950408f, -0.05283338f, -0.01354691f, -0.03428943f, -0.05649149f, 0.04511692f, 
    0.04634291f, 0.03198715f, -0.04461449f, -0.04703710f, 0.00449713f, 0.03094108f, -0.01746637f, 0.01571629f, 
    -0.06057689f, -0.00324444f, -0.04760301f, -0.04739393f, -0.04831848f, -0.05774834f, -0.02849110f, 0.02244608f, 
    0.01447710f, -0.03319430f, -0.06532326f, -0.00852982f, 0.00875378f, -0.04786745f, 0.03582510f, -0.00124244f, 
    0.03434865f, 0.04967228f, 0.03871487f, -0.04621353f, -0.01624077f, -0.05979991f, -0.01782434f, 0.04903032f, 
    -0.03443171f, -0.02816739f, 0.00540859f, -0.05833042f, -0.06148852f, -0.05497025f, -0.04904765f, -0.01415968f, 
    0.04538483f, -0.03858558f, 0.02519273f, -0.02695200f, -0.04919045f, -0.03124657f, -0.03710593f, -0.04109996f, 
    0.01470035f, -0.05585409f, -0.03980000f, -0.00352127f, -0.00534343f, -0.00739734f, -0.05143330f, 0.02860710f, 
    0.02753626f, 0.02467531f, 0.03213166f, -0.03226565f, -0.01267384f, 0.03873029f, -0.03258646f, 0.01867290f, 
    -0.04396034f, 0.02483987f, -0.05310875f, -0.04017609f, -0.01031502f, 0.04432682f, 0.00956023f, 0.04460828f, 
    -0.01252124f, -0.04177685f, -0.00864583f, 0.00225261f, -0.05853588f, -0.02651481f, 0.05047887f, 0.03614738f, 
    0.01148651f, -0.04785893f, 0.04628361f, -0.03818569f, -0.05829133f, 0.01626415f, -0.00436467f, -0.05328904f, 
    0.04315506f, 0.00817315f, 0.01310238f, -0.01434535f, 0.00222031f, 0.00869434f, -0.03296126f, -0.06591974f, 
    -0.05169750f, -0.02209148f, -0.05902692f, -0.04788991f, -0.03813424f, 0.00716651f, -0.05608626f, 0.00579913f, 
    0.00316181f, -0.02818638f, 0.03267894f, 0.03065168f, 0.01299086f, -0.00485515f, 0.01560642f, -0.03845125f, 
    -0.03608388f, -0.04917021f, 0.01032236f, 0.01179662f, -0.00921294f, 0.02218511f, -0.02950047f, 0.01024247f, 
    0.05124680f, 0.04516495f, -0.03385408f, -0.06539499f, -0.06336390f, -0.04166922f, 0.04538101f, -0.06187654f, 
    -0.06277207f, -0.03662877f, -0.02761512f, 0.02348773f, 0.01816731f, 0.04600319f, 0.01684239f, -0.04070994f, 
    -0.04671445f, 0.04107407f, 0.00767445f, 0.00605177f, 0.03631483f, -0.03617282f, -0.01100435f, -0.04611828f, 
    -0.00941774f, 0.04825409f, -0.05318330f, -0.01712664f, 0.02429611f, -0.05513897f, -0.04523569f, -0.01712182f, 
    -0.04476996f, 0.03023467f, -0.02661165f, -0.06277105f, -0.03717572f, -0.04288337f, -0.03554776f, 0.04174720f, 
    0.03846335f, 0.04938973f, -0.01362057f, -0.05511364f, 0.00067675f, -0.01966695f, 0.00675633f, 0.03455365f, 
    0.03023513f, -0.03203363f, -0.03845037f, -0.03833801f, -0.05441124f, -0.03256368f, 0.05033275f, -0.01821630f, 
    -0.04118279f, -0.02554266f, -0.05975348f, -0.06105765f, -0.05881720f, 0.01415466f, -0.04556368f, -0.04098328f, 
    -0.06704220f, -0.05433233f, 0.01967908f, 0.00089502f, -0.03856774f, 0.03409714f, 0.01741681f, -0.02662875f, 
    -0.05080686f, -0.03051314f, -0.05999360f, 0.01782984f, -0.05026556f, 0.03170155f, -0.06181756f, -0.04816860f, 
    0.03717621f, 0.01267929f, 0.00007601f, 0.03651870f, -0.02487937f, -0.00387034f, -0.04102392f, 0.04605252f, 
    -0.03139439f, 0.00891736f, -0.03840024f, -0.04625380f, 0.04931984f, 0.02967821f, -0.02185324f, 0.04950847f, 
    -0.05379388f, 0.02641975f, -0.02723092f, 0.00273525f, 0.03149072f, 0.03054939f, -0.06682136f, -0.01195788f, 
    -0.04637448f, 0.01105373f, 0.04480936f, -0.00425857f, -0.03759898f, -0.00948340f, 0.03599293f, -0.00593875f, 
    -0.04934819f, 0.04669347f, 0.03478924f, 0.02565260f, 0.01180236f, -0.06081123f, -0.06004660f, 0.01540677f, 
    -0.00375034f, -0.05280942f, 0.01836360f, 0.02306141f, 0.03572791f, 0.05016226f, -0.05536678f, 0.02395082f, 
    -0.03912707f, -0.03975479f, 0.02160319f, 0.03845210f, 0.02532947f, -0.03302331f, -0.00541725f, -0.02435764f, 
    -0.04619375f, -0.04356794f, -0.00581428f, 0.04741452f, 0.04079749f, 0.04690585f, 0.04778828f, 0.02632387f, 
    -0.02837039f, -0.05286748f, -0.03110485f, -0.01026233f, -0.03943405f, 0.01696888f, -0.04475312f, -0.05667473f, 
    0.20054115f, -0.12078890f, 0.26364383f, 0.18056287f, 0.09080873f, -0.04344486f, -0.01923910f, 0.07380699f, 
    -0.15176503f, 0.12391409f, -0.02019607f, 0.07266843f, -0.01989800f, -0.12001999f, 0.02823546f, 0.10038646f, 
    0.02964207f, -0.05028900f, 0.05243075f, -0.21947789f, 0.47111729f, -0.21681237f, 0.04532019f, -0.03079197f, 
    0.06074549f, -0.07145108f, -0.11218926f, -0.59079087f, -0.19667935f, 0.07966864f, 0.17505376f, -0.00006183f, 
    -0.04577224f, -0.10042623f, 0.02119519f, 0.05443998f, 0.34930888f, 0.22224642f, 0.39999938f, -0.22604904f, 
    -0.07549711f, -0.19103155f, -0.09448532f, 0.04010519f, 0.09080583f, 0.02270490f, 0.05924194f, 0.07696105f, 
    -0.07000916f, -0.04654274f, -0.05717503f, -0.07585879f, 0.04728834f, 0.23102145f, 0.30343249f, 0.12503278f, 
    -0.01859017f, -0.03423929f, 0.02927619f, 0.08633863f, -0.10934053f, 0.18407933f, 0.10182571f, -0.09020192f, 
    -0.09770716f, -0.13517861f, -0.13835891f, -0.12335792f, -0.06431529f, -0.06025495f, -0.05986407f, -0.18979509f, 
    -0.06238828f, -0.08307538f, -0.06140716f, 0.05086169f, -0.00712007f, 0.09444535f, 0.07486033f, -0.12069104f, 
    -0.22150728f, -0.00563781f, -0.15985157f, -0.10411298f, -0.04842739f, 0.02471547f, 0.01054700f, 0.21088624f, 
    -0.17971781f, 0.09666718f, 0.13611270f, 0.05277033f, -0.13049436f, -0.01010733f, 0.01360187f, 0.11714357f, 
    0.05775544f, -0.06340732f, 0.18563177f, -0.34544501f, 0.36476028f, 0.16792887f, -0.03283759f, 0.19391297f, 
    -0.02612952f, 0.00153742f, 0.02338156f, 0.19386736f, 0.16390447f, 0.05671468f, 0.05867554f, -0.07663602f, 
    -0.10210868f, -0.02879103f, -0.06579182f, -0.11535185f, -0.14642262f, 0.02115879f, 0.25206885f, 0.23346449f, 
    0.07974078f, 0.06879913f, 0.07734005f, 0.02979489f, 0.12393790f, 0.20540667f, -0.00311251f, 0.07670961f, 
    0.02826015f, -0.03121122f, -0.11946248f, -0.12807563f, 0.19333097f, -0.01518486f, 0.24996160f, -0.43286690f, 
    -0.01386744f, 0.19842851f, -0.17432724f, -0.09151857f, 0.01345369f, 0.00612585f, 0.01194321f, 0.12158266f, 
    -0.01159833f, -0.18313494f, -0.00985003f, 0.10715764f, 0.03956874f, 0.06102999f, -0.05955329f, 0.00120314f, 
    -0.36827683f, 0.17523597f, 0.08990832f, -0.05759509f, -0.02426847f, -0.19756891f, -0.17572396f, 0.03282187f, 
    -0.00665952f, 0.00248554f, 0.59663653f, -0.18639265f, 0.05039641f, 0.23058823f, -0.20046885f, 0.03898171f, 
    -0.17297174f, -0.04964887f, -0.10826218f, -0.02411130f, 0.05179282f, 0.19656041f, 0.05252697f, 0.07193670f, 
    -0.04711031f, 0.07642926f, -0.03065781f, 0.25728804f, -0.70271164f, -0.29418746f, 0.16571635f, 0.18068835f, 
    0.04444598f, 0.07226047f, -0.18437798f, -0.05069737f, 0.03110511f, 0.12108097f, 0.05139117f, -0.06422921f, 
    0.02722920f, -0.09739516f, 0.09083805f, 0.14273158f, -0.01952455f, 0.08566720f, 0.18780755f, 0.09335189f, 
    0.22569406f, 0.04696250f, 0.07604671f, 0.12840386f, -0.11962082f, 0.02325466f, -0.01300637f, 0.33340278f, 
    -0.06086665f, -0.02704105f, 0.02987716f, 0.01166331f, -0.06776685f, 0.09869946f, 0.04675996f, -0.04515467f, 
    0.43960643f, -0.18728480f, -0.37896869f, -0.11587269f, 0.01378711f, -0.07538970f, -0.07731068f, 0.09244490f, 
    0.00472879f, -0.07670329f, -0.11890455f, 0.00492954f, 0.06208039f, -0.04282241f, 0.07074836f, -0.07107838f, 
    -0.07301024f, -0.04517298f, -0.17744304f, 0.24032146f, 0.14840016f, -0.08416769f, -0.01216478f, -0.07875970f, 
    -0.05122590f, 0.11821572f, 0.19674332f, -0.01714578f, 0.07022400f, 0.04879996f, 0.00347285f, -0.07995791f, 
    -0.01426545f, -0.07912238f, 0.01315508f, 0.03035196f, 0.10713699f, 0.03935064f, 0.00093661f, 0.18629570f, 
    -0.06833488f, 0.00320155f, -0.12644283f, 0.04821951f, 0.06218052f, -0.11966370f, -0.25007579f, -0.09544081f, 
    0.08995100f, 0.10009233f, 0.15428266f, -0.18245156f, -0.04087678f, -0.02869876f, -0.18966143f, 0.10642193f, 
    0.01424391f, -0.06189750f, 0.00664892f, 0.02694560f, -0.15350264f, -0.03868944f, 0.04327445f, 0.31438398f, 
    0.09160534f, 0.25333989f, -0.01298686f, -0.03582451f, -0.00064091f, -0.04971246f, -0.09966272f, -0.00772576f, 
    0.18143414f, 0.10013374f, 0.07945659f, 0.07714590f, 0.04331300f, 0.04550878f, 0.02232999f, -0.00668876f, 
    0.00326197f, -0.12172684f, -0.00850611f, -0.15890199f, -0.01687470f, 0.03111810f, 0.03668705f, 0.11794689f, 
    0.04548225f, -0.08002256f, 0.13451079f, 0.01997196f, 0.05873479f, 0.04556478f, 0.01399386f, 0.10718738f, 
    0.10879177f, 0.02820401f, -0.07720232f, 0.15236580f, -0.00737560f, -0.06839787f, 0.14782761f, 0.01268570f, 
    0.18819761f, 0.03977164f, 0.04489544f, 0.07081615f, -0.00558919f, 0.27369189f, 0.02048387f, -0.00626585f, 
    0.02589181f, 0.14965098f, -0.08261456f, -0.05658733f, -0.03265023f, 0.09923764f, 0.02351560f, 0.07379460f, 
    0.00112047f, -0.01308476f, 0.13555866f, 0.10180636f, -0.03425461f, 0.01444458f, -0.15744323f, -0.10307927f, 
    -0.15382048f, 0.01693849f, 0.00568985f, 0.10416476f, 0.02873656f, -0.01621826f, -0.04662703f, -0.11592880f, 
    -0.28594822f, -0.20731628f, -0.04020581f, 0.08371694f, 0.02292557f, -0.11038991f, 0.00670147f, -0.05079695f, 
    -0.04036511f, -0.02156643f, -0.04742648f, 0.01078811f, -0.17095363f, 0.02753575f, 0.08756807f, -0.01028235f, 
    -0.12293228f, 0.01555466f, -0.10498562f, -0.08054418f, 0.01979912f, -0.02799686f, 0.00491194f, -0.09854045f, 
    -0.02124934f, 0.00156359f, -0.13911368f, 0.14692134f, -0.12386908f, 0.04698381f, -0.12768404f, -0.05841609f, 
    -0.17683527f, -0.13265675f, 0.00232842f, 0.39719635f, 0.08911376f, 0.06526294f, -0.01497738f, 0.01738251f, 
    0.11025192f, 0.18821737f, 0.01428848f, -0.01499013f, 0.04300835f, -0.11700594f, -0.06835271f, -0.03200913f, 
    -0.01421074f, -0.08302230f, 0.03619431f, 0.00747627f, -0.00454311f, -0.05630980f, 0.08654054f, 0.03023610f, 
    -0.00941854f, 0.04970742f, -0.03583922f, 0.04416257f, -0.00850697f, 0.02191499f, 0.04980858f, 0.07663201f, 
    -0.09889879f, -0.10216789f, -0.03238916f, 0.03274964f, -0.08670063f, -0.06103480f, 0.05582545f, -0.13909622f, 
    0.14049146f, -0.36963713f, -0.07852178f, -0.09953948f, -0.05628496f, -0.10995194f, -0.19090013f, -0.14037213f, 
    0.12509933f, 0.16954041f, 0.06455812f, 0.14872786f, -0.06015818f, 0.11776865f, 0.08244179f, -0.04258441f, 
    -0.11400124f, -0.11343892f, -0.00155377f, 0.01935707f, 0.16973837f, -0.03479286f, -0.02565229f, 0.06021960f, 
    -0.02824652f, 0.03005248f, 0.30796698f, -0.09828013f, 0.06616215f, 0.11084510f, -0.00162429f, -0.01485095f, 
    0.09766656f, 0.10520624f, -0.05863463f, 0.06036557f, 0.07756364f, 0.09339190f, -0.03766172f, 0.15566589f, 
    -0.01758047f, 0.00404829f, 0.04285021f, 0.07002562f, 0.04304668f, 0.01613083f, -0.04502806f, -0.01436070f, 
    -0.00193579f, 0.03936113f, -0.07694130f, -0.02212349f, 0.06529522f, 0.22509274f, 0.04797370f, 0.05139097f, 
    -0.00987408f, 0.08530218f, -0.04021150f, 0.06858479f, 0.24250665f, -0.08170369f, -0.16601726f, -0.13585408f, 
    0.07326025f, 0.06211609f, -0.00703891f, 0.01463124f, 0.03915387f, 0.03573299f, -0.03450558f, -0.11634731f, 
    0.43157700f, -0.28564310f, -0.04295909f, -0.09860703f, -0.04689667f, 0.12387123f, -0.06052195f, -0.05458300f, 
    -0.05968417f, -0.11995308f, 0.18812355f, -0.03460097f, -0.05829273f, 0.00816943f, 0.04794319f, -0.06818878f, 
    -0.00909323f, -0.09869794f, -0.26365817f, -0.03822588f, -0.04872833f, 0.12309208f, -0.06631463f, -0.14667997f, 
    0.00346887f, 0.06311274f, 0.23108818f, 0.18622440f, -0.02496631f, -0.05528303f, 0.03488263f, -0.00390876f, 
    -0.06821794f, -0.02719243f, -0.03333687f, 0.02005106f, -0.02493978f, -0.20525500f, 0.03111576f, 0.04121620f, 
    -0.06889447f, -0.09882522f, -0.04878450f, -0.07605925f, -0.04006814f, -0.04628458f, 0.15545957f, 0.11408696f, 
    0.06797148f, 0.14379165f, -0.05556760f, 0.09929451f, 0.04298275f, -0.16435140f, -0.07647275f, -0.04292383f, 
    0.17279635f, 0.04268771f, 0.05839269f, -0.11626843f, -0.18741679f, 0.10496973f, -0.03317152f, 0.22102392f, 
    -0.19245383f, 0.02499273f, -0.00073149f, -0.13749124f, -0.15527640f, 0.00621949f, 0.00321993f, 0.06912662f, 
    0.15860327f, 0.02723193f, -0.02110715f, -0.10306345f, 0.05899544f, 0.02592501f, 0.08739305f, 0.04307181f, 
    0.02570777f, -0.05419266f, -0.06153636f, -0.05907667f, -0.01501940f, -0.04972113f, -0.04144452f, -0.01388447f, 
    -0.03667889f, -0.03213084f, -0.03203022f, -0.03061406f, -0.01855789f, 0.03220528f, 0.05221023f, -0.06119280f, 
    0.05125488f, 0.03913195f, -0.04839416f, 0.00087261f, -0.06448335f, 0.00482443f, -0.00652669f, -0.06098090f, 
    0.02782519f, -0.03057118f, -0.04802531f, -0.03698610f, -0.01111372f, -0.01301013f, -0.03949289f, -0.04648030f, 
    -0.01493170f, 0.00008731f, -0.05445339f, 0.04719633f, 0.00869970f, 0.01605637f, 0.01628764f, -0.01220384f, 
    0.03856515f, 0.03124998f, -0.00549158f, -0.00228440f, -0.00921598f, 0.05074662f, -0.00728545f, -0.03973876f, 
    -0.04201115f, -0.00300416f, -0.00806070f, -0.06226129f, -0.02086103f, 0.01701698f, -0.02839483f, 0.00911767f, 
    -0.01144595f, -0.04869772f, -0.01556820f, -0.05806949f, -0.00173596f, -0.04817367f, -0.01984593f, -0.01020907f, 
    0.03645523f, -0.03617346f, 0.03399727f, -0.04044632f, -0.00602688f, 0.01176137f, 0.04032264f, 0.04249794f, 
    0.00067753f, -0.00504129f, -0.03752529f, -0.05746734f, -0.05923646f, -0.02206158f, -0.03533299f, -0.03267108f, 
    0.03026715f, -0.03996136f, -0.03261254f, -0.01598832f, 0.04868118f, 0.04002473f, -0.02031320f, -0.04586454f, 
    0.00507808f, 0.05377175f, 0.04213587f, -0.03964599f, 0.01200754f, 0.00143291f, 0.04482857f, -0.03660867f, 
    -0.00081132f, 0.01385120f, -0.00368641f, 0.01619433f, -0.04902199f, 0.03606778f, 0.02487514f, -0.03988537f, 
    0.00757407f, 0.01325185f, -0.02307565f, -0.03422610f, -0.01213780f, -0.05339419f, 0.00097316f, -0.00449781f, 
    0.04456889f, -0.01988645f, -0.01920461f, -0.01643881f, -0.02965390f, 0.03206596f, -0.04717610f, -0.04452292f, 
    0.05339500f, -0.04234111f, -0.06143315f, -0.04629601f, 0.04577298f, -0.05694500f, 0.00197145f, -0.05242818f, 
    -0.01912256f, 0.01433155f, 0.00143177f, -0.00616682f, -0.05236806f, -0.00608389f, -0.00655882f, -0.00776988f, 
    -0.00686049f, 0.04918972f, -0.00001503f, -0.05049577f, 0.00456696f, 0.00526329f, 0.00070248f, 0.03751857f, 
    0.01461945f, 0.01804446f, -0.00270456f, -0.03356135f, -0.04916161f, 0.02610717f, 0.03698120f, -0.04011282f, 
    -0.01237509f, -0.03835688f, 0.01045748f, -0.06309180f, -0.04800996f, 0.04532762f, 0.04152929f, -0.00612901f, 
    0.05709725f, -0.03556416f, 0.02042416f, -0.04859272f, -0.03204084f, 0.02122380f, 0.02805946f, -0.00859614f, 
    -0.03367398f, 0.05688636f, 0.00430112f, -0.04958446f, 0.01199838f, 0.00788769f, 0.04527093f, -0.01743038f, 
    0.02778069f, 0.02584690f, 0.01627428f, -0.05980435f, -0.04072841f, -0.06122391f, 0.04437438f, 0.01670069f, 
    -0.00041595f, 0.00892890f, -0.01422654f, -0.05898552f, 0.01942067f, -0.04674908f, -0.00009176f, 0.05034758f, 
    -0.02510822f, 0.03171174f, 0.02959785f, -0.04284296f, -0.04699989f, 0.05041433f, 0.00309123f, 0.04868239f, 
    0.00326554f, -0.01867125f, 0.00401614f, 0.02484614f, 0.04178294f, 0.01316412f, 0.05166854f, 0.03708779f, 
    -0.03655677f, -0.02567448f, -0.01208343f, 0.00149971f, -0.02936954f, 0.04710104f, -0.05217344f, -0.00695940f, 
    -0.01948382f, 0.04259396f, 0.02225530f, 0.03791898f, 0.03790885f, -0.02783579f, 0.02550720f, -0.03937444f, 
    -0.04119827f, -0.05787371f, 0.03981751f, 0.04757987f, 0.00022736f, -0.04710165f, 0.02017942f, -0.03787099f, 
    -0.00973316f, -0.05786671f, 0.01096653f, -0.01694887f, -0.02619626f, -0.02397374f, -0.03864697f, -0.02340252f, 
    0.03284533f, 0.03140358f, 0.04003958f, -0.02083570f, -0.01783020f, 0.03091189f, 0.05179080f, -0.01119383f, 
    0.04926379f, 0.05236800f, 0.00370700f, -0.01474295f, 0.03225994f, -0.02509951f, 0.00186506f, -0.03599359f, 
    -0.02000666f, 0.04082078f, 0.02619386f, 0.04840678f, -0.02476011f, -0.04628387f, 0.02437530f, -0.05216532f, 
    -0.02124630f, -0.01570786f, 0.04263664f, 0.00805558f, 0.05519188f, 0.04339245f, 0.01027921f, -0.06525669f, 
    0.04889732f, -0.00731922f, -0.04037738f, -0.05980130f, 0.04424615f, -0.03726095f, -0.02212157f, 0.03265921f, 
    0.04536510f, 0.01235103f, 0.02231648f, -0.02907039f, -0.00294723f, -0.03158711f, -0.05429303f, -0.02318156f, 
    0.00266166f, -0.01745190f, 0.03638187f, -0.05320587f, 0.03244973f, 0.04616951f, -0.03534571f, -0.06181110f, 
    0.00573745f, -0.01766319f, 0.01369955f, -0.03677172f, -0.00064196f, -0.05547157f, -0.05767617f, 0.01093903f, 
    -0.05610050f, -0.00735544f, -0.01419807f, 0.04192223f, 0.03314645f, 0.02947706f, -0.06065784f, -0.06049296f, 
    -0.01616343f, -0.05563863f, 0.04561847f, -0.00484034f, -0.04030883f, -0.06158651f, 0.03914493f, -0.03352289f, 
    -0.02610489f, -0.00807265f, 0.04729101f, -0.05052897f, 0.04282060f, 0.02195963f, 0.02089109f, 0.00118046f, 
    -0.04954142f, -0.01305319f, -0.04188384f, -0.02566892f, 0.01320030f, 0.02611496f, -0.03938514f, -0.01581924f, 
    -0.00280263f, -0.05108358f, 0.04582615f, -0.02026745f, -0.06643566f, 0.04715212f, 0.01005206f, -0.00015235f, 
    0.00981293f, 0.01320889f, 0.04806493f, 0.02875368f, 0.00154806f, 0.02722164f, 0.03458156f, -0.01330171f, 
    -0.01355708f, -0.02656179f, 0.03385805f, -0.04836112f, 0.04662034f, -0.02282421f, -0.00434683f, -0.06431728f, 
    -0.04344309f, -0.01089199f, -0.06880011f, 0.03910250f, -0.01603879f, 0.03567665f, -0.00765893f, -0.02939401f, 
    0.04791987f, -0.00373645f, 0.03584453f, -0.05398691f, 0.03616105f, -0.00829427f, -0.03755308f, -0.03539564f, 
    -0.00776384f, -0.04963607f, 0.04739449f, -0.03673279f, 0.02021486f, 0.01597214f, -0.03568748f, -0.05216119f, 
    -0.02059179f, 0.01895572f, -0.04662619f, 0.02924274f, 0.02609684f, -0.03675612f, 0.00115974f, -0.02466225f, 
    -0.01459575f, 0.04030996f, -0.01598866f, 0.03803676f, -0.02733015f, -0.00365473f, -0.06840461f, -0.02163597f, 
    -0.04977760f, -0.03771202f, -0.04017031f, -0.02568400f, -0.03428088f, -0.04779329f, -0.04712787f, 0.00512889f, 
    -0.01793666f, -0.00200980f, -0.02905129f, 0.00405650f, 0.02472147f, -0.01104169f, -0.06128227f, -0.01254492f, 
    -0.04266690f, -0.02326731f, 0.04444962f, -0.01140439f, -0.02672508f, 0.02423364f, 0.01635768f, -0.05085822f, 
    0.00988571f, 0.01768886f, -0.00384636f, 0.00499245f, -0.03814967f, 0.04885025f, -0.02823179f, -0.01375590f, 
    0.03586419f, -0.06785840f, -0.03279031f, -0.02046495f, -0.00187928f, 0.04737564f, -0.02484631f, 0.00696343f, 
    0.01970877f, -0.06399022f, -0.05276750f, 0.02124127f, -0.00402948f, 0.01916570f, -0.06702464f, 0.03221399f, 
    -0.04724659f, 0.00871641f, -0.05048674f, 0.02345818f, 0.02434736f, 0.02130815f, -0.00833649f, -0.02085412f, 
    -0.04764675f, -0.06007753f, -0.00005766f, -0.02571691f, -0.04726999f, -0.02458433f, -0.04851442f, -0.02822785f, 
    0.04777889f, -0.03129034f, 0.04745033f, -0.04645355f, 0.00945223f, -0.05796870f, 0.01832643f, -0.04930925f, 
    0.04050657f, -0.02753293f, -0.02647879f, -0.03212478f, 0.03310580f, 0.01162002f, 0.03300397f, -0.00626879f, 
    0.02903505f, -0.06630912f, 0.02371815f, -0.03831222f, 0.00593670f, -0.06086563f, -0.02878716f, -0.01340524f, 
    -0.01101715f, -0.00923735f, -0.02506814f, 0.01713873f, 0.01495846f, -0.00816368f, -0.00795769f, -0.03186522f, 
    -0.06779099f, 0.00467065f, -0.02772291f, 0.03626179f, -0.04395693f, -0.02567423f, 0.02511020f, -0.00352171f, 
    0.03949606f, -0.01613710f, -0.00895419f, -0.04623730f, 0.04327546f, -0.00345031f, 0.03061161f, -0.01855190f, 
    -0.02600601f, -0.06130267f, 0.04341145f, -0.01872072f, -0.01407835f, -0.01682146f, 0.04509933f, 0.04568671f, 
    0.00524661f, 0.00096118f, 0.01682426f, -0.04105880f, 0.04140862f, -0.03576586f, 0.04982313f, -0.01149959f, 
    -0.05952996f, -0.04486093f, -0.00962136f, -0.01774740f, 0.03654975f, -0.05999945f, 0.04582879f, -0.01044313f, 
    -0.01004991f, 0.05441817f, -0.05241184f, -0.05457433f, -0.04444478f, 0.02984227f, 0.03815628f, 0.05101193f, 
    -0.06563182f, -0.03642908f, -0.02444681f, 0.00775402f, 0.04597653f, -0.02861807f, 0.04018165f, 0.03818023f, 
    -0.01608214f, 0.02902090f, 0.01366428f, -0.01227725f, -0.02998652f, 0.02331365f, 0.02753752f, -0.06363753f, 
    0.00117221f, 0.02163703f, 0.01060229f, 0.01107553f, -0.01353718f, 0.01630006f, 0.03090534f, 0.01308996f, 
    -0.05396097f, 0.04003966f, -0.02444088f, -0.05908991f, -0.00384187f, -0.03684229f, 0.00249311f, -0.00362473f, 
    0.24933602f, 0.07476202f, -0.02738410f, -0.00052881f, -0.10428197f, 0.06639888f, 0.10951680f, 0.07373792f, 
    -0.10057256f, -0.01940315f, -0.13084264f, -0.28873995f, 0.07063717f, 0.04851852f, -0.04738431f, -0.00655994f, 
    0.18905428f, -0.12696145f, -0.06720057f, -0.04702732f, -0.27792832f, 0.03420431f, -0.10472624f, 0.09913452f, 
    0.09507602f, 0.06719477f, -0.05930118f, 0.02424173f, -0.08130263f, -0.21501413f, 0.18829557f, -0.01474030f, 
    0.12845296f, 0.05718950f, -0.06099273f, 0.06939470f, -0.15845934f, 0.23815951f, 0.08487721f, -0.14319342f, 
    0.06778701f, 0.03663246f, 0.02049231f, 0.00533776f, 0.10197439f, 0.10935314f, 0.00281483f, 0.10601602f, 
    0.10739174f, 0.02997050f, 0.05314927f, -0.02576710f, 0.11301666f, 0.01389565f, -0.08431445f, -0.10306333f, 
    -0.05572121f, -0.07169003f, -0.00091805f, 0.16459645f, 0.06901852f, 0.03556342f, -0.01981700f, -0.10859919f, 
    -0.23442258f, -0.24207707f, -0.23015758f, -0.06024738f, -0.14499032f, -0.08230566f, 0.13702713f, 0.04303945f, 
    -0.02357061f, -0.03920253f, -0.61644155f, 0.10242447f, -0.02191579f, 0.19709422f, -0.07811585f, -0.02217275f, 
    -0.02469373f, 0.00414940f, -0.18811387f, -0.03391182f, 0.00246703f, -0.07448460f, -0.15978487f, -0.03719215f, 
    -0.03258727f, -0.01449037f, 0.15130749f, 0.02225004f, -0.10733721f, 0.14957476f, -0.01361774f, 0.09892412f, 
    0.01938382f, 0.09491587f, 0.08925746f, 0.30029663f, 0.14362557f, 0.11784338f, 0.03201424f, -0.03567187f, 
    -0.19031352f, -0.05136306f, 0.10944415f, -0.02832067f, -0.22287382f, -0.31092134f, -0.07631899f, -0.08805209f, 
    -0.09540261f, -0.22589698f, -0.13455810f, -0.01262965f, 0.03548183f, -0.08120878f, 0.03485835f, 0.05236414f, 
    -0.11353236f, 0.07543077f, 0.03938788f, 0.11713268f, -0.04735304f, -0.00163011f, -0.04904443f, -0.05595094f, 
    -0.20545870f, -0.01605527f, 0.18145829f, -0.04150208f, 0.02428067f, 0.01058775f, 0.10335962f, -0.11543394f, 
    0.18765534f, -0.79389369f, 0.06328896f, -0.00136852f, 0.03960546f, 0.13692699f, 0.00464338f, 0.06967349f, 
    0.11293761f, 0.09319602f, 0.00486554f, 0.02357908f, -0.01462494f, 0.03836181f, 0.12673377f, -0.19480617f, 
    -0.02288455f, 0.09053560f, -0.09815130f, -0.12059154f, 0.08491305f, -0.20067862f, 0.02431669f, 0.09731282f, 
    0.07475524f, 0.00129999f, 0.32326895f, -0.22352897f, -0.02017361f, 0.15779644f, -0.15251601f, 0.01422836f, 
    0.13317621f, 0.09211396f, -0.05872356f, 0.04820981f, 0.08347728f, -0.01636147f, -0.09736010f, 0.00305178f, 
    0.02845770f, 0.00507735f, 0.10046941f, 0.09258842f, -0.10869256f, -0.07908075f, -0.03005856f, 0.02700679f, 
    -0.00611932f, 0.11602247f, 0.05569919f, 0.11584346f, 0.05467006f, 0.15099065f, 0.10082655f, 0.14591593f, 
    0.15374668f, -0.04604799f, -0.12756309f, -0.07626583f, 0.15570126f, -0.06198882f, -0.05799406f, -0.13038848f, 
    0.04980499f, -0.03467089f, -0.00702741f, 0.09640752f, 0.09519036f, -0.02693626f, -0.13041736f, 0.28753543f, 
    0.25609812f, -0.16815671f, -0.17661959f, 0.16111968f, 0.06085438f, 0.09694295f, -0.05172957f, -0.04833624f, 
    -0.00059943f, -0.16629772f, 0.16046497f, 0.02561553f, 0.04964664f, -0.07722461f, -0.05275314f, 0.06096752f, 
    -0.04492966f, -0.20080540f, -0.17296934f, -0.13662389f, -0.10969169f, 0.04999480f, 0.13923827f, 0.07254812f, 
    -0.00810619f, 0.07838465f, 0.15102586f, 0.27610883f, -0.12718928f, -0.00237777f, -0.01233620f, 0.01742046f, 
    -0.09686080f, -0.03207786f, -0.01901732f, 0.06664646f, -0.29110846f, -0.28509885f, 0.02430709f, 0.00696576f, 
    0.02251874f, -0.07600722f, 0.02518388f, -0.06699587f, 0.00966493f, -0.09087579f, -0.10822812f, 0.18152487f, 
    0.09457655f, 0.13427742f, 0.10832811f, 0.03556695f, -0.02613631f, -0.22436020f, -0.34617153f, -0.39911181f, 
    0.00591176f, -0.12667552f, 0.04940662f, 0.06984791f, 0.03532950f, 0.06155180f, -0.03542121f, -0.16239986f, 
    -0.01281803f, 0.28401545f, 0.12847112f, 0.00600277f, -0.07025064f, 0.04359351f, 0.07456499f, 0.10576486f, 
    0.07116933f, 0.08734651f, -0.05784700f, -0.10410558f, -0.10667548f, -0.01621708f, 0.03262073f, 0.09403160f, 
    0.01683762f, 0.34220764f, 0.25216550f, -0.06958644f, 0.07989219f, -0.08994844f, -0.00515651f, -0.14168233f, 
    0.09297869f, -0.20984794f, -0.21534877f, -0.15090811f, -0.07604074f, 0.04842513f, -0.02181566f, 0.18001461f, 
    0.06398637f, -0.13687247f, -0.20188677f, -0.11983691f, -0.26468697f, -0.10405140f, 0.03353370f, -0.07506774f, 
    -0.09859076f, -0.07749656f, -0.03125121f, 0.26791832f, 0.16916367f, 0.20694503f, 0.02754827f, 0.16689406f, 
    0.05640970f, -0.04550626f, -0.12970100f, 0.09026707f, -0.29038724f, -0.06349733f, -0.14517033f, -0.05703845f, 
    -0.12212110f, -0.10469511f, -0.01818493f, -0.01883275f, 0.00844433f, 0.13764928f, 0.18383282f, 0.18861447f, 
    0.15213059f, 0.10708325f, 0.10674864f, 0.04342853f, 0.01865234f, -0.14520980f, -0.30435419f, 0.00376017f, 
    0.03881448f, 0.13447213f, 0.15619951f, -0.01584704f, 0.04888644f, -0.02215269f, 0.06394823f, -0.04662391f, 
    -0.09068865f, -0.18678345f, -0.06942964f, -0.12423228f, 0.09877080f, -0.13208340f, -0.05893280f, -0.01266877f, 
    -0.01231544f, -0.01610835f, -0.15533605f, -0.02636005f, -0.01004744f, -0.12121676f, -0.01089272f, -0.01639027f, 
    0.14805922f, 0.13260902f, 0.00335201f, 0.15398462f, -0.06483376f, 0.14016609f, -0.12680274f, 0.03206624f, 
    0.03163041f, 0.05304598f, -0.25360659f, -0.07885251f, 0.02824905f, -0.02191244f, -0.07541252f, -0.01582050f, 
    -0.03028023f, -0.09719831f, 0.01061611f, 0.24489744f, 0.06411017f, 0.05307743f, -0.04284513f, -0.05156279f, 
    0.19791348f, 0.05300499f, 0.12575084f, -0.00919736f, -0.20183323f, -0.11929516f, 0.00575335f, -0.04251622f, 
    0.02449687f, 0.02546023f, -0.00435306f, 0.02651563f, 0.03677396f, 0.02949035f, -0.03924682f, 0.08535430f, 
    0.04498507f, 0.12372020f, -0.04034152f, 0.02178541f, 0.06019002f, 0.09263281f, -0.05482679f, -0.11145800f, 
    0.14323680f, 0.01346720f, 0.02452578f, 0.04425818f, -0.03103634f, -0.04558165f, -0.04074461f, 0.04309125f, 
    0.16789991f, -0.08395779f, -0.14001974f, -0.11483651f, 0.01825631f, -0.00910934f, 0.00317672f, -0.03409054f, 
    0.13790934f, 0.18262434f, 0.32828468f, 0.06594300f, 0.06993975f, -0.04276505f, 0.10884544f, -0.05075625f, 
    0.12469537f, 0.12753606f, -0.16251506f, 0.08102785f, 0.03146146f, -0.03237900f, -0.08727034f, -0.07953972f, 
    0.08022806f, -0.01359492f, 0.12380704f, -0.00741715f, 0.26392108f, 0.05106680f, 0.09357604f, 0.01720611f, 
    0.05113459f, 0.16078116f, -0.02660592f, 0.15854649f, 0.14124595f, -0.02536478f, -0.13321795f, -0.09081863f, 
    0.01715051f, 0.10016135f, 0.06584607f, -0.06650583f, 0.01443178f, 0.07901382f, -0.12491618f, 0.04479880f, 
    0.01387375f, 0.08383194f, -0.01792431f, 0.07288676f, 0.00152533f, -0.15362611f, 0.22334327f, 0.09407080f, 
    0.11935690f, 0.00453155f, -0.06266837f, 0.11462937f, -0.02667977f, -0.09423964f, -0.00786021f, 0.03891888f, 
    0.15278007f, 0.06840815f, 0.08917040f, 0.13155918f, 0.14582954f, -0.06398087f, 0.19515607f, -0.20080811f, 
    0.13810480f, -0.19463763f, -0.02164632f, -0.01009922f, 0.10887664f, -0.03353566f, 0.04807793f, -0.04514629f, 
    -0.34547490f, 0.04345340f, 0.16570310f, -0.00906587f, -0.11926915f, 0.09047012f, 0.04112341f, 0.00943386f, 
    -0.08444525f, -0.10914680f, -0.17978756f, -0.02883911f, 0.00054032f, 0.02257124f, -0.03267114f, -0.09574520f, 
    0.00575247f, 0.08477032f, 0.06957857f, 0.14762536f, 0.16197194f, -0.02548713f, -0.08730088f, -0.00968236f, 
    -0.00140236f, 0.00850772f, 0.06002146f, 0.02603041f, -0.09881739f, -0.06022204f, 0.00010314f, -0.07829618f, 
    0.08465335f, -0.05765468f, 0.00924027f, -0.00794176f, 0.08433167f, 0.18836235f, 0.45840734f, -0.07562312f, 
    0.04185656f, 0.10315550f, 0.04744852f, -0.02546346f, 0.04449999f, -0.17461394f, 0.01241045f, -0.06675212f, 
    0.05142689f, 0.03815399f, -0.17506154f, -0.06757760f, -0.01901424f, 0.09754445f, -0.29591969f, -0.20409344f, 
    -0.08235334f, 0.19839467f, -0.07317415f, -0.11274076f, -0.05313439f, -0.05461699f, -0.04400166f, -0.01662058f, 
    0.10098344f, 0.16140796f, 0.06965716f, 0.04987511f, 0.00971765f, -0.06354849f, 0.12340295f, 0.12190536f, 
    0.19638218f, 0.28355548f, 0.36170816f, -0.07816548f, -0.04131070f, -0.07608765f, 0.01247838f, -0.04890511f, 
    0.10666609f, -0.09449232f, -0.11167391f, 0.06344045f, -0.02936815f, -0.04951371f, -0.00775041f, -0.15167047f, 
    -0.00047900f, 0.02966599f, -0.18888819f, -0.03418280f, 0.14005657f, -0.18024686f, 0.05231030f, 0.04488536f, 
    -0.01589246f, -0.00155292f, -0.10579471f, 0.27106044f, -0.03020683f, -0.02342606f, -0.02125346f, -0.00331743f, 
    -0.04683019f, -0.00527770f, -0.14905514f, 0.11378905f, 0.01805165f, -0.16212760f, 0.04786124f, 0.04312306f, 
    0.09957872f, -0.12891820f, 0.00913734f, -0.02555389f, -0.01645681f, 0.03386253f, -0.01471684f, 0.01350028f, 
    0.09349584f, -0.08954911f, 0.01313574f, 0.02755195f, -0.07682087f, 0.02773747f, 0.14004047f, 0.15188301f, 
    -0.16438952f, -0.16791196f, 0.23434155f, -0.05302292f, -0.04522588f, 0.12685977f, 0.00257903f, 0.11871665f, 
    0.12879606f, -0.06209922f, -0.14067939f, -0.13078469f, 0.04731370f, -0.02110547f, 0.01120317f, 0.02726700f, 
    -0.18766764f, -0.10677349f, 0.02021249f, -0.04570094f, -0.09459848f, 0.14397684f, 0.02823414f, -0.04571175f, 
    -0.08895633f, 0.05826830f, 0.26836973f, 0.05708378f, 0.01919176f, 0.12045487f, -0.02311804f, 0.12223893f, 
    0.02599273f, -0.12490355f, -0.01163462f, -0.09059919f, 0.17288992f, -0.07686619f, -0.11524104f, -0.11773613f, 
    0.04909552f, -0.17652622f, 0.06856873f, -0.35450622f, -0.04234932f, -0.23430207f, 0.14516032f, -0.14072488f, 
    0.23491812f, -0.04379837f, -0.05029412f, 0.11586781f, 0.16160163f, -0.01323161f, 0.04228253f, -0.04696411f, 
    0.07657139f, -0.06352661f, 0.07774086f, -0.01849846f, -0.09690680f, -0.32152623f, 0.03678640f, 0.09945218f, 
    -0.02601703f, 0.05589601f, -0.07387157f, -0.10047648f, 0.05900108f, -0.18104008f, -0.06623106f, 0.05642692f, 
    0.21210234f, -0.04222602f, -0.03692785f, -0.17065081f, -0.04025662f, 0.07510154f, -0.10672889f, -0.11494887f, 
    0.14758730f, -0.03600741f, -0.33028498f, -0.09651683f, -0.27434117f, 0.17593801f, 0.09447469f, 0.02660448f, 
    0.08724347f, 0.15627153f, -0.06084379f, -0.03702862f, 0.10791454f, 0.07636861f, 0.09962377f, -0.02309178f, 
    -0.00896108f, -0.11496314f, -0.18581671f, -0.07015847f, 0.08699606f, -0.02153569f, 0.11748933f, -0.04363531f, 
    0.10487514f, 0.12199448f, 0.16505967f, 0.25696835f, -0.11365625f, -0.04857100f, 0.07636121f, -0.01461560f, 
    0.09409159f, 0.06226430f, 0.01423540f, -0.01729398f, 0.07179730f, 0.05903153f, -0.06272154f, -0.08482325f, 
    -0.02660581f, 0.04363183f, -0.07902633f, 0.02862383f, 0.12080760f, 0.21880876f, -0.17964330f, -0.15069871f, 
    -0.37102476f, -0.04017173f, -0.00329045f, 0.02497118f, 0.04156872f, -0.16842444f, -0.04996045f, 0.05828660f, 
    -0.00848382f, -0.02878658f, -0.06695267f, -0.11862119f, 0.07521959f, 0.06518156f, 0.00876072f, 0.15574689f, 
    -0.07953427f, -0.10900797f, 0.15106612f, 0.03903258f, -0.03486360f, 0.05967651f, -0.06877103f, 0.14661703f, 
    -0.02665113f, -0.34067550f, -0.05064338f, -0.02482612f, 0.00549313f, 0.06882966f, 0.12885864f, 0.05581170f, 
    -0.03360332f, -0.28363526f, 0.19149885f, -0.07382856f, 0.06048816f, -0.24426250f, -0.05931166f, 0.12342539f, 
    -0.05090176f, 0.30278686f, 0.21869583f, 0.12162228f, 0.10341211f, -0.01330982f, 0.03833200f, 0.04470663f, 
    -0.04883540f, -0.10376182f, -0.27459729f, 0.04935657f, 0.20162989f, -0.08759089f, -0.07842623f, -0.23743263f, 
    0.03064657f, 0.05225886f, 0.11798999f, -0.14799839f, -0.09239281f, -0.06771401f, -0.06528840f, 0.04095776f, 
    -0.07561920f, 0.05331100f, 0.05233811f, 0.08237908f, 0.13674738f, 0.46006548f, 0.17466673f, -0.07007819f, 
    0.15343393f, -0.02299488f, 0.12602648f, 0.08022469f, 0.03641447f, 0.24913570f, 0.35033849f, 0.09403907f, 
    -0.39978969f, -0.25011525f, -0.23400983f, -0.01413065f, 0.12735285f, 0.15941255f, 0.04804013f, -0.16320941f, 
    0.08314171f, 0.09210674f, 0.00702788f, -0.15752959f, -0.00382934f, -0.09374353f, 0.02446489f, 0.10081363f, 
    0.14717972f, 0.04254602f, -0.17047971f, 0.01125075f, -0.04012382f, -0.01112268f, -0.02876643f, 0.04739392f, 
    -0.04803717f, -0.07256123f, 0.21503560f, 0.02410973f, 0.00536990f, -0.02833058f, 0.00322878f, -0.14940120f, 
    -0.05915352f, -0.18389946f, -0.17648508f, -0.01226297f, 0.01106638f, -0.13301782f, 0.11756153f, 0.06447528f, 
    0.16438608f, -0.12042731f, -0.22315463f, -0.19280468f, -0.15534759f, 0.09707946f, -0.12239939f, -0.04043738f, 
    -0.05787284f, -0.15737602f, -0.02624972f, -0.60282362f, 0.08502997f, 0.19947731f, 0.01997353f, 0.07431824f, 
    -0.12003954f, 0.10536705f, -0.01546898f, 0.06147139f, -0.02669396f, -0.03007525f, 0.02410780f, 0.04115213f, 
    -0.18002695f, -0.05620728f, -0.06478137f, 0.04940899f, -0.13841707f, -0.09819456f, 0.21903750f, 0.25271413f, 
    -0.10810702f, -0.03755450f, 0.06954569f, 0.12260447f, 0.11853573f, 0.07655501f, 0.07733238f, 0.05292694f, 
    0.07296998f, 0.09074384f, 0.04963132f, 0.06434555f, 0.15010668f, 0.06230845f, 0.10442684f, -0.05965763f, 
    -0.08798920f, 0.03118627f, -0.33588651f, 0.10097570f, -0.19281158f, 0.05494244f, 0.00746179f, 0.01544040f, 
    -0.36769083f, 0.01834525f, 0.00629539f, 0.09738310f, 0.03780447f, 0.01517432f, 0.12333051f, -0.04271527f, 
    -0.04058240f, 0.29761076f, 0.05631490f, 0.13824242f, -0.10510219f, 0.17463993f, 0.14512438f, 0.00074177f, 
    -0.20697668f, -0.00300489f, -0.16133112f, -0.08213842f, 0.15471824f, 0.16479768f, -0.23767100f, 0.06104985f, 
    0.08432648f, -0.00114069f, 0.24937859f, 0.08405334f, 0.06613415f, -0.15100671f, 0.11221147f, -0.02246780f, 
    -0.18346035f, 0.02357666f, 0.04120656f, 0.02657004f, -0.02659297f, 0.14553128f, 0.08928673f, -0.03727431f, 
    0.00169855f, 0.15104870f, -0.03483310f, -0.10250042f, -0.07269898f, 0.01179055f, 0.23016363f, 0.07011016f, 
    -0.01206302f, 0.13538131f, -0.11450594f, 0.14670871f, 0.08028685f, 0.22589771f, -0.10290959f, -0.02219647f, 
    0.09043978f, -0.12894925f, 0.02584776f, 0.16186844f, -0.08470020f, 0.05494207f, 0.25857967f, -0.20802861f, 
    0.22969881f, -0.03111849f, -0.22125073f, -0.45672932f, -0.12608379f, 0.09295455f, 0.05884122f, 0.02915297f, 
    0.07135267f, -0.18324752f, 0.17158732f, 0.07028350f, 0.11285892f, -0.04839349f, -0.04913387f, -0.20433328f, 
    -0.11036544f, -0.11245337f, -0.18900687f, -0.26871839f, 0.13373187f, -0.07674507f, 0.02555169f, -0.05517862f, 
    0.12573990f, -0.04155914f, -0.23736823f, -0.23471469f, 0.00283064f, 0.10717987f, -0.10055510f, -0.01895014f, 
    0.11942580f, 0.13713279f, -0.08413022f, 0.11338332f, 0.24990728f, 0.20342627f, 0.15607876f, -0.06989732f, 
    -0.03988422f, 0.08773613f, -0.16971637f, 0.05017058f, -0.13208236f, -0.08722429f, 0.13838321f, 0.15567397f, 
    -0.25650886f, -0.20350882f, -0.02615826f, 0.06021373f, 0.10233356f, -0.20445935f, 0.20664132f, 0.06821489f, 
    0.05458908f, -0.07257411f, 0.14283779f, 0.12863214f, 0.05718419f, 0.01564480f, 0.16851251f, 0.05112979f, 
    0.21234532f, 0.04647280f, 0.06022284f, 0.06466851f, 0.06515618f, -0.03554318f, 0.06583839f, 0.33934036f, 
    0.03649487f, -0.12389401f, 0.11254570f, 0.10846978f, 0.05719979f, -0.15043382f, 0.17866257f, -0.11144520f, 
    -0.01894826f, 0.07349854f, -0.25643352f, -0.00767295f, -0.07443236f, 0.05227286f, -0.13899861f, 0.13483025f, 
    0.12009969f, 0.03422360f, -0.04125347f, 0.07167841f, 0.07431555f, 0.06362873f, -0.08372127f, 0.13601570f, 
    -0.08828834f, 0.18252906f, -0.37216106f, 0.21632391f, 0.15661074f, -0.08105649f, -0.04482666f, -0.19317292f, 
    0.31787810f, -0.01693628f, 0.11166795f, -0.10650352f, 0.01531565f, 0.11336972f, -0.07635147f, -0.10611043f, 
    0.01663872f, 0.05664372f, 0.19251785f, 0.09564784f, -0.02094886f, 0.03904083f, 0.30970457f, -0.05527798f, 
    0.02631138f, 0.00322016f, -0.06078137f, -0.29032204f, -0.00769108f, -0.07246498f, -0.08094486f, 0.11416312f, 
    -0.11863976f, -0.21576890f, -0.23916309f, -0.04542996f, -0.00321785f, 0.04842773f, -0.19882423f, -0.09037640f, 
    -0.05079426f, 0.01595062f, -0.29393965f, -0.01737773f, -0.09942437f, -0.11531957f, 0.05331224f, -0.02618461f, 
    0.09955619f, 0.28728867f, 0.09091102f, -0.02734737f, 0.12086766f, -0.06092852f, -0.21801922f, -0.10600846f, 
    -0.26020619f, -0.01808934f, 0.30492240f, -0.00778182f, -0.19336838f, -0.01341402f, 0.02420298f, -0.01110964f, 
    0.22337508f, -0.24928465f, 0.18886200f, -0.02344280f, -0.04901565f, 0.05486436f, 0.02935123f, -0.05728050f, 
    -0.11328013f, 0.14638408f, -0.28430748f, 0.30376783f, 0.32709995f, -0.29825220f, 0.13270782f, -0.04907754f, 
    -0.00142909f, -0.03267394f, -0.09426732f, -0.27382660f, -0.00599253f, 0.10900114f, -0.07340226f, 0.01826134f, 
    -0.09140917f, 0.19167338f, 0.04826636f, -0.03677269f, -0.15782224f, -0.01355312f, 0.13716193f, -0.06322324f, 
    0.08677471f, -0.12424456f, 0.05274170f, -0.01165036f, -0.13003981f, -0.02018227f, 0.00230865f, 0.24638309f, 
    0.08363690f, 0.05511417f, 0.00653990f, -0.02776685f, -0.02223531f, 0.17205033f, 0.17614298f, 0.20139830f, 
    0.06035373f, 0.02431049f, 0.03467688f, 0.18311206f, -0.07364521f, 0.07844153f, 0.09290036f, -0.04248531f, 
    0.02359173f, -0.23387778f, -0.13114503f, -0.06785828f, 0.04191134f, -0.02168615f, -0.02768083f, -0.04800799f, 
    -0.05134572f, -0.21027657f, -0.01654281f, -0.15444219f, 0.13795145f, 0.36245850f, 0.07936643f, -0.21589115f, 
    0.07785883f, -0.05988382f, 0.29291624f, 0.09755696f, 0.05534224f, -0.09999049f, 0.08447075f, 0.14782701f, 
    0.09801011f, -0.07099695f, -0.09684651f, 0.02154436f, -0.00689208f, -0.10595763f, 0.02125681f, 0.05168314f, 
    0.14283201f, 0.17054527f, -0.02655778f, -0.05712846f, -0.01568476f, 0.10222892f, -0.00388758f, 0.10464315f, 
    0.06846227f, 0.05062425f, 0.07815589f, 0.02677513f, -0.14265358f, -0.05605879f, -0.17580478f, -0.16486961f, 
    0.09907209f, -0.01414703f, 0.04661629f, 0.00442544f, -0.11559521f, 0.26102147f, 0.27577159f, 0.30824259f, 
    0.09122935f, 0.05021916f, 0.19291596f, -0.02102585f, 0.08376857f, 0.08886473f, -0.15701349f, 0.11466088f, 
    0.09939906f, -0.03531796f, 0.03739062f, -0.08376642f, 0.13512702f, 0.21581854f, -0.02266661f, 0.08223055f, 
    0.01331555f, 0.39937344f, -0.03967310f, -0.07362672f, -0.05825510f, 0.01391362f, -0.08394570f, -0.00566103f, 
    -0.20810099f, 0.01143173f, 0.05247525f, -0.07393485f, 0.04044133f, -0.11863293f, -0.07179084f, 0.01728572f, 
    -0.00127813f, -0.26588908f, -0.21591923f, -0.13355376f, -0.03402082f, 0.00264908f, 0.05199779f, -0.12432864f, 
    -0.01929582f, -0.06754058f, -0.24126501f, 0.22277662f, -0.10598961f, -0.02877259f, 0.08951057f, 0.02684256f, 
    0.09370462f, 0.01169348f, -0.03170061f, -0.11928226f, 0.09360582f, 0.28524926f, 0.06344514f, 0.03521983f, 
    -0.06779150f, -0.01634832f, 0.09055637f, 0.11433864f, -0.14614494f, 0.08541393f, -0.12534866f, -0.10778595f, 
    -0.03574558f, 0.06726510f, 0.02245645f, 0.05631040f, 0.05044502f, -0.09535255f, 0.10821247f, 0.06718920f, 
    0.08136218f, 0.12834494f, 0.01298118f, -0.01819655f, -0.09056489f, 0.19757080f, -0.00475830f, 0.26589426f, 
    0.08685856f, 0.04186305f, -0.08288496f, 0.11340205f, -0.05509681f, -0.01616051f, 0.03048185f, 0.16089007f, 
    0.03884253f, -0.08768763f, 0.07864852f, 0.02717322f, 0.09356199f, 0.03115201f, -0.02885983f, 0.01014091f, 
    -0.25988331f, -0.19669396f, -0.13785975f, 0.07110309f, 0.01662883f, -0.02620345f, 0.05441591f, -0.01794173f, 
    0.03150772f, -0.06263158f, 0.11900033f, 0.03908125f, 0.04771581f, 0.03366428f, 0.00832122f, 0.07960955f, 
    0.05056653f, -0.03624645f, -0.20868538f, -0.01192952f, 0.19193396f, -0.00391340f, 0.04882647f, -0.01237129f, 
    0.17438225f, 0.08801331f, 0.07543325f, -0.08317661f, -0.11913802f, -0.19173534f, -0.04118396f, -0.02836137f, 
    -0.04661346f, 0.02314300f, -0.01843744f, -0.14948598f, -0.05554591f, 0.18210372f, 0.16969047f, -0.10861810f, 
    -0.02913998f, 0.12094077f, 0.06740334f, 0.05126197f, 0.13214985f, 0.01300406f, 0.10471259f, 0.12621427f, 
    0.14996889f, -0.21911861f, -0.20267701f, 0.06287767f, 0.16454856f, -0.09864364f, -0.06466302f, -0.05974346f, 
    -0.19554050f, -0.04792081f, -0.16323414f, -0.05244587f, -0.05964215f, 0.05049336f, 0.01340999f, -0.10045454f, 
    0.01959925f, 0.07420784f, 0.08333518f, 0.07956430f, 0.00894603f, 0.01694754f, -0.00062070f, 0.03548546f, 
    -0.00727107f, 0.07359747f, -0.09092438f, 0.04112126f, 0.01555015f, 0.12020902f, 0.00863759f, 0.02828087f, 
    -0.14547963f, -0.01862592f, -0.08322404f, -0.15042409f, -0.01054306f, 0.05629515f, -0.04579156f, -0.02367483f, 
    -0.13236292f, -0.09088124f, -0.11150885f, -0.21702255f, -0.35657138f, -0.01488725f, -0.15420212f, 0.06734622f, 
    0.05834557f, 0.09981751f, -0.01755555f, 0.18477097f, 0.14579369f, -0.16654749f, -0.06925354f, -0.16627789f, 
    -0.03127816f, 0.10634554f, 0.07421075f, 0.08571193f, -0.18278319f, -0.04030960f, -0.16595720f, 0.07576077f, 
    -0.02385286f, 0.03952440f, 0.03015588f, 0.01780212f, -0.16491048f, 0.00581079f, 0.05098663f, 0.06280991f, 
    -0.01019172f, 0.06205519f, 0.09994957f, -0.01435241f, 0.02211000f, 0.06667014f, -0.00693127f, 0.06313180f, 
    0.01757072f, -0.06953134f, -0.08094984f, -0.07044249f, -0.12360509f, 0.06872701f, -0.05108747f, -0.03561275f, 
    0.02618293f, -0.09589862f, -0.14455634f, -0.03388023f, -0.15061024f, 0.01024451f, 0.18025009f, 0.16922198f, 
    0.17650062f, -0.10304841f, -0.09548201f, -0.21534294f, 0.06068604f, -0.10505897f, 0.07020660f, 0.10560633f, 
    0.18258776f, -0.10349074f, -0.12774403f, 0.02136386f, 0.09659245f, -0.10729738f, 0.03102097f, 0.12684822f, 
    0.23405755f, 0.06490314f, -0.15840156f, 0.01772836f, 0.02119636f, -0.32260126f, -0.08919809f, 0.20112513f, 
    0.13579556f, 0.02368860f, -0.05261041f, 0.09511489f, -0.11002672f, 0.07654794f, -0.02474698f, -0.06076738f, 
    -0.27090514f, -0.11626772f, -0.17620061f, -0.01799467f, -0.28659365f, -0.15630162f, 0.10477340f, -0.01628183f, 
    -0.13931738f, 0.05992654f, 0.07956065f, 0.03248825f, 0.21812958f, 0.05392481f, 0.06543162f, -0.13793270f, 
    -0.00258286f, 0.08195296f, 0.11515585f, 0.04471833f, 0.02490817f, 0.14204592f, 0.02335885f, -0.04720264f, 
    -0.04110354f, -0.02608659f, 0.00703834f, 0.01378073f, 0.20234306f, 0.13922206f, -0.05344214f, 0.04624961f, 
    0.00950978f, -0.08073862f, -0.38142624f, 0.18455380f, 0.01665401f, -0.08899508f, -0.05447283f, 0.01692038f, 
    -0.02994233f, 0.06996821f, 0.12224260f, 0.24152282f, -0.07439500f, -0.00420468f, 0.03873276f, 0.00324233f, 
    0.01044605f, 0.07651708f, -0.02458058f, -0.02723927f, -0.10427332f, 0.02715559f, -0.03191537f, -0.10756671f, 
    -0.04162303f, -0.03853908f, -0.07010044f, -0.03876589f, -0.14625397f, 0.04693646f, -0.13150096f, -0.00834205f, 
    -0.00932431f, 0.16535833f, -0.01706782f, 0.15706174f, 0.14199288f, 0.03229596f, 0.03677282f, 0.08829623f, 
    0.09219419f, 0.13902783f, 0.09753477f, -0.19301322f, -0.07400914f, -0.10815069f, -0.07626515f, 0.01913205f, 
    0.13594399f, -0.03168817f, -0.04224655f, 0.04918765f, 0.02818542f, -0.18987297f, 0.13938999f, 0.13969851f, 
    0.07267775f, 0.02291270f, -0.01522030f, 0.05700375f, -0.20350087f, -0.11075669f, 0.06254435f, -0.14449477f, 
    0.11933085f, 0.01383760f, 0.01245860f, 0.02481009f, 0.04300396f, -0.01864323f, 0.04352776f, 0.13028440f, 
    0.02345758f, -0.12788709f, -0.02748062f, 0.13231224f, -0.09255593f, 0.10316844f, -0.19737774f, 0.15701544f, 
    -0.02288513f, 0.05192574f, -0.11734586f, 0.07318862f, 0.01307193f, -0.11862990f, -0.05233316f, 0.05716829f, 
    0.18217880f, -0.07207191f, -0.09644787f, -0.14455321f, 0.10353946f, 0.01609839f, 0.12984733f, 0.12554564f, 
    0.17540812f, 0.13650012f, 0.06162266f, 0.15998979f, -0.08362704f, 0.05341171f, 0.19015031f, 0.01095984f, 
    -0.00564078f, -0.04754110f, -0.05817524f, 0.00096306f, 0.00117493f, 0.07152218f, -0.06391153f, -0.06722269f, 
    -0.06413036f, -0.04553983f, -0.01693181f, 0.21763207f, -0.00990050f, 0.02634276f, -0.02552001f, -0.03017427f, 
    0.02361031f, 0.09746668f, 0.09205996f, 0.02246851f, -0.07492549f, -0.16830786f, -0.00017394f, 0.05795035f, 
    -0.19540465f, -0.01115945f, -0.49019799f, -0.16438699f, -0.11364558f, -0.10222837f, -0.00391150f, -0.02394468f, 
    -0.00394274f, -0.08738850f, 0.02914205f, -0.00854189f, 0.00171434f, -0.10567562f, -0.02506130f, 0.02188587f, 
    0.02089962f, 0.01958862f, 0.11234491f, 0.01475943f, 0.08097169f, -0.03843143f, 0.08887645f, -0.03629031f, 
    -0.04517776f, 0.04452156f, 0.03915623f, -0.04602197f, 0.04093248f, -0.04362991f, -0.03921333f, -0.01947972f, 
    0.02971352f, 0.03984205f, 0.01629479f, -0.00265187f, 0.02248837f, -0.03166892f, -0.02242806f, 0.01336450f, 
    -0.03139925f, -0.06188088f, -0.04157913f, -0.06156602f, -0.03986887f, 0.00745472f, 0.00652369f, -0.03345476f, 
    -0.03298947f, -0.05289998f, -0.04621338f, 0.00485994f, 0.01619001f, 0.03145544f, 0.00484594f, 0.03014976f, 
    -0.02165370f, -0.02212858f, 0.03069874f, -0.02510073f, -0.01464315f, 0.02204879f, -0.04173519f, -0.04307258f, 
    0.03520681f, -0.01934732f, 0.03954223f, 0.04516391f, -0.01879818f, -0.05593091f, 0.02190409f, 0.04025604f, 
    0.01607109f, 0.04048385f, 0.01875341f, -0.04300273f, -0.02917836f, -0.04511680f, 0.02443222f, 0.02015246f, 
    -0.03375699f, 0.01906707f, -0.04430008f, -0.01997817f, -0.03635049f, -0.03536000f, 0.04147851f, 0.04367785f, 
    -0.05484065f, 0.01712012f, -0.04853131f, -0.04720433f, -0.00906196f, -0.04042145f, -0.00454746f, -0.03406648f, 
    -0.06573883f, 0.02253829f, -0.02870781f, 0.03021897f, 0.00119689f, 0.05337898f, -0.04823352f, -0.03180606f, 
    0.03821735f, 0.00071239f, 0.01084890f, -0.04605290f, -0.05078519f, 0.03236946f, -0.03111950f, -0.03716372f, 
    0.05046816f, -0.03756136f, 0.04531838f, 0.01473176f, 0.05280039f, 0.00722449f, -0.03334385f, 0.05299499f, 
    -0.04070709f, 0.05027385f, -0.04021247f, -0.02366315f, -0.03715594f, -0.03568421f, 0.04676716f, 0.02316386f, 
    -0.02279269f, -0.02377021f, 0.02024736f, 0.03274579f, 0.00655822f, -0.05142534f, 0.01955781f, 0.02248190f, 
    -0.01621154f, 0.01441434f, 0.03550439f, 0.01579762f, 0.03816668f, -0.05841213f, 0.00584383f, 0.01536882f, 
    -0.04817011f, -0.05518415f, -0.06162526f, -0.06129795f, -0.04416094f, -0.02498215f, 0.03633527f, 0.03287294f, 
    -0.06103214f, 0.02887223f, -0.02600308f, 0.00141409f, -0.04134772f, 0.03932061f, 0.02024932f, 0.03395532f, 
    0.01584277f, -0.00878669f, 0.03599893f, -0.02303705f, -0.02682611f, 0.01185331f, -0.01143158f, 0.01129786f, 
    0.02812153f, -0.04828447f, 0.00320686f, -0.00168598f, 0.06185493f, -0.03092057f, 0.01678385f, -0.05328751f, 
    0.02519417f, 0.03959648f, -0.03988626f, 0.04939189f, -0.00352781f, -0.05748022f, -0.00218555f, -0.01679794f, 
    -0.02358090f, 0.05321606f, 0.00722232f, 0.01869991f, 0.02653804f, 0.02756878f, -0.04183412f, 0.01750785f, 
    0.00668213f, 0.05175333f, -0.02046760f, 0.01882441f, 0.00986572f, 0.03745023f, 0.03670608f, -0.03458820f, 
    -0.01315342f, 0.01031308f, 0.03752993f, -0.06763227f, -0.01170667f, 0.02887850f, -0.02565838f, 0.00438141f, 
    -0.05293227f, -0.03297049f, 0.00038915f, 0.04615920f, 0.03028678f, 0.00132838f, 0.03045120f, 0.02086610f, 
    -0.01509104f, 0.03624734f, 0.01093029f, -0.00772284f, -0.02892575f, 0.04391862f, -0.01577796f, 0.03134489f, 
    -0.05875421f, -0.00651651f, -0.03925893f, -0.02154958f, -0.02639898f, -0.05863897f, -0.02768436f, 0.03889691f, 
    -0.04091603f, -0.02291486f, 0.04960633f, -0.00392677f, -0.04931294f, 0.00102549f, 0.03986737f, 0.00853191f, 
    -0.00070940f, -0.04196099f, -0.02714272f, 0.02149545f, 0.02864002f, -0.01465994f, -0.03354583f, -0.01518007f, 
    -0.05070335f, -0.05781316f, 0.00327033f, 0.00543261f, -0.04534346f, -0.05329019f, 0.02401868f, -0.02402644f, 
    -0.00221302f, 0.01321627f, 0.00166367f, -0.03295380f, -0.04523331f, 0.04729307f, 0.00564354f, -0.05512054f, 
    -0.05072000f, 0.03624168f, -0.03405205f, -0.02249968f, -0.05283294f, -0.04227816f, -0.00481584f, -0.02332952f, 
    -0.04612231f, -0.05884279f, 0.01396668f, 0.03621647f, -0.04103457f, 0.00781622f, -0.03174298f, -0.01540712f, 
    -0.03949232f, 0.04599193f, 0.01224184f, 0.01765398f, -0.05696624f, 0.03052670f, 0.02973318f, -0.04695886f, 
    -0.02200307f, -0.04444663f, 0.00519906f, -0.04288152f, -0.06313674f, -0.03827564f, -0.00100333f, -0.05886515f, 
    0.00409070f, -0.05205780f, -0.01460712f, -0.01257574f, 0.00429825f, 0.00040645f, 0.01086758f, -0.06485954f, 
    -0.02539244f, -0.06257588f, 0.01711499f, 0.05096480f, 0.00028976f, -0.04674405f, -0.01300941f, -0.02231986f, 
    0.14352964f, 0.08545493f, -0.01632505f, 0.10408942f, -0.06866403f, 0.14150818f, -0.05032374f, 0.07391051f, 
    -0.14101945f, -0.05623727f, -0.06413819f, -0.22864096f, 0.07197780f, -0.01404796f, 0.14461386f, 0.06030158f, 
    0.08295898f, -0.07346751f, 0.21090567f, 0.03419774f, -0.03564326f, 0.05039939f, -0.02956372f, -0.01057989f, 
    0.08678982f, 0.09691482f, 0.00805936f, 0.11795615f, -0.11377941f, -0.06998334f, 0.08566608f, -0.00903649f, 
    0.05666726f, -0.03472346f, 0.07113365f, 0.02242544f, 0.03304455f, 0.16354290f, 0.06877514f, -0.00099025f, 
    0.05907879f, 0.04589354f, 0.01530191f, 0.00943005f, 0.00110643f, 0.07019577f, -0.01266430f, 0.12845486f, 
    0.02477553f, -0.05071467f, -0.01901831f, 0.00001626f, 0.04486240f, 0.03257080f, -0.14211024f, -0.13830373f, 
    -0.19113171f, -0.14956498f, -0.00332539f, 0.26294327f, 0.10251244f, -0.06964798f, -0.00635766f, -0.15077600f, 
    -0.16748536f, -0.45793396f, 0.11445864f, 0.03920107f, -0.12209999f, -0.01067314f, -0.05384305f, 0.12492472f, 
    0.02876081f, -0.11753690f, -0.32121286f, 0.13400362f, -0.01630497f, 0.15210673f, 0.08150185f, -0.03066130f, 
    -0.00015671f, 0.14170733f, -0.20590219f, 0.07944489f, 0.12158816f, 0.07133750f, -0.10791878f, -0.17173417f, 
    -0.00212780f, -0.02889109f, 0.23118486f, -0.06547627f, -0.02178453f, 0.17004348f, 0.08998029f, -0.01089840f, 
    0.11261228f, -0.09961828f, 0.04918937f, 0.28976324f, 0.09001413f, 0.06038798f, 0.01484412f, -0.11896983f, 
    -0.02178107f, 0.10404793f, 0.06421380f, -0.10280727f, 0.01747659f, 0.00235003f, -0.07723226f, -0.04458568f, 
    -0.02967984f, -0.17226346f, -0.03279323f, -0.00301587f, 0.01927651f, -0.11531501f, -0.00799829f, 0.14961222f, 
    -0.12672725f, 0.05978937f, 0.13587487f, 0.05569011f, 0.06610722f, -0.09594838f, 0.08902765f, -0.05939446f, 
    0.00746416f, -0.02123453f, 0.07302221f, 0.06017340f, 0.07334965f, -0.08757724f, -0.01120115f, -0.21228679f, 
    -0.04349686f, -0.36537844f, 0.31511566f, 0.01110361f, 0.12070351f, -0.07293296f, 0.17876710f, -0.00299698f, 
    0.09650966f, 0.04865682f, 0.01454961f, 0.06793007f, -0.02565462f, 0.17853381f, 0.06567234f, -0.02795247f, 
    -0.15355033f, -0.02642069f, -0.07352519f, -0.12063505f, 0.22014771f, -0.15034112f, 0.09252890f, 0.01465007f, 
    -0.01496796f, 0.02163673f, 0.29860896f, -0.25720900f, 0.02350922f, 0.11880075f, -0.24967384f, 0.05794440f, 
    0.10475220f, -0.01211551f, 0.04151957f, 0.06780142f, 0.08233029f, -0.07208458f, -0.05906785f, 0.09032600f, 
    -0.07247796f, -0.08734886f, 0.13699014f, -0.04129968f, -0.14778651f, -0.23404239f, -0.02861653f, -0.02300229f, 
    0.13922584f, 0.09762508f, -0.02768894f, 0.08293910f, 0.04636329f, 0.26004612f, 0.08595704f, 0.10290238f, 
    -0.00574751f, 0.07113536f, -0.03760230f, -0.13677728f, 0.05070764f, -0.11006463f, -0.04367114f, -0.04825149f, 
    -0.03168561f, -0.03197372f, 0.05352262f, 0.11801043f, 0.00964999f, -0.05822191f, -0.07640728f, -0.18536200f, 
    0.30958360f, -0.05275351f, 0.02294782f, -0.12870379f, 0.09273297f, 0.10631315f, 0.04360463f, -0.01709194f, 
    0.01092294f, -0.10974420f, -0.06497864f, 0.08150464f, 0.02024511f, -0.14642753f, 0.03528884f, -0.07837766f, 
    0.03140385f, -0.18473423f, -0.31099677f, -0.12735252f, -0.03111613f, -0.00975801f, 0.01574085f, -0.03525678f, 
    -0.04046995f, 0.23241036f, 0.09811185f, 0.16567297f, -0.05653604f, 0.21708669f, -0.02922561f, 0.02265211f, 
    -0.20194562f, -0.05286881f, -0.22954746f, 0.08138884f, -0.06202476f, -0.32882538f, 0.11309504f, 0.01614387f, 
    0.13610995f, -0.11007411f, -0.04962327f, -0.05191750f, -0.02736234f, 0.00250354f, 0.03368444f, 0.24741703f, 
    0.02714776f, 0.09853481f, -0.07656772f, 0.14780274f, -0.14649045f, -0.36340585f, -0.38597322f, -0.36597833f, 
    0.01814272f, 0.10419539f, 0.21759653f, -0.07855181f, -0.06215190f, -0.13401861f, -0.05946757f, 0.16598329f, 
    -0.28497231f, 0.10999256f, 0.12670168f, -0.02203415f, 0.03904409f, -0.07789066f, -0.02617330f, 0.12358240f, 
    0.13483538f, -0.03426533f, -0.07375919f, -0.09679107f, -0.05531194f, -0.01332900f, 0.08200809f, -0.07046551f, 
    0.00640581f, -0.02389131f, 0.03373832f, -0.04018788f, -0.03472244f, -0.31151280f, -0.06594501f, 0.06838215f, 
    0.10853080f, 0.11021259f, -0.02047441f, 0.14901547f, -0.05681086f, 0.09461423f, 0.00118419f, 0.09335920f, 
    -0.04203673f, -0.02815263f, 0.12839569f, 0.01614439f, 0.10890177f, -0.19513164f, -0.19951282f, -0.16085245f, 
    0.07508906f, 0.01620144f, 0.01873003f, -0.19602960f, -0.68580252f, -0.39252239f, -0.15806897f, 0.10785441f, 
    -0.13734992f, -0.09505235f, -0.05974498f, -0.12855402f, 0.28479317f, 0.05846732f, 0.04666338f, -0.02564679f, 
    -0.06346247f, 0.05051821f, 0.01092425f, -0.05875404f, 0.05522187f, -0.00694390f, -0.19443420f, -0.36801293f, 
    0.04431574f, 0.10794207f, 0.09445553f, 0.09784110f, 0.12045544f, 0.09059047f, -0.07491659f, 0.11165349f, 
    -0.02551060f, -0.06239373f, 0.02175209f, -0.04551956f, 0.00161027f, 0.00573148f, -0.07626942f, 0.02801056f, 
    0.12503347f, -0.11280151f, 0.06219076f, 0.07385944f, 0.05761582f, 0.13131501f, -0.02767913f, 0.04732001f, 
    0.34148893f, 0.11147584f, -0.15194666f, 0.00976597f, 0.00481035f, 0.06766728f, 0.12014318f, 0.11784673f, 
    -0.17723361f, -0.27504185f, -0.31139079f, 0.16947423f, 0.19702531f, -0.01748226f, -0.00528496f, -0.20388055f, 
    0.04299914f, 0.08426193f, 0.25818384f, 0.16335656f, 0.13251516f, -0.13388778f, -0.06092881f, -0.00134502f, 
    0.10113936f, 0.05552432f, 0.16292621f, -0.42212147f, -0.37575981f, -0.37835002f, 0.03448836f, 0.10620569f, 
    0.05733269f, -0.17073557f, -0.06733895f, 0.08088174f, 0.34309044f, 0.05335871f, -0.04252424f, 0.14281282f, 
    0.01687531f, -0.16079521f, -0.00268527f, 0.05152630f, -0.05145372f, -0.02941370f, -0.17306982f, 0.00713760f, 
    0.11000264f, 0.24570191f, 0.06820714f, 0.02342789f, 0.02597314f, 0.03729323f, 0.16597125f, 0.06830109f, 
    0.21627195f, -0.00266233f, -0.05008254f, 0.01783101f, 0.17900310f, 0.05100322f, 0.03319548f, 0.19113751f, 
    0.01005306f, 0.06791839f, -0.19434711f, 0.04156614f, 0.04893010f, -0.03888953f, 0.00325536f, 0.08030467f, 
    -0.30224007f, -0.38264516f, 0.14370473f, 0.13688625f, -0.04261154f, -0.04053962f, -0.02070689f, 0.09721529f, 
    -0.03806328f, 0.21115166f, 0.09758377f, 0.13451457f, 0.01911771f, 0.02340471f, 0.06283659f, -0.01406344f, 
    0.06985546f, -0.07280912f, -0.00536394f, -0.17908068f, -0.03501315f, 0.18385996f, -0.12472746f, 0.04488004f, 
    0.24090609f, 0.00995815f, -0.06703361f, -0.10571507f, -0.06860334f, -0.22946705f, -0.06107693f, 0.20667964f, 
    -0.14214288f, 0.02649525f, -0.06416438f, 0.16346447f, -0.11049210f, -0.14794554f, -0.28602609f, 0.02542567f, 
    0.03525523f, -0.04326897f, -0.20489940f, -0.05205522f, 0.02618456f, -0.22096720f, -0.09553418f, -0.17146446f, 
    0.05541084f, 0.17703162f, 0.01438985f, 0.08360929f, -0.00618185f, 0.08692642f, -0.14729255f, 0.04239183f, 
    0.07228724f, 0.12091353f, 0.11143022f, 0.09538404f, 0.14495216f, 0.03320546f, -0.02966051f, 0.04033329f, 
    -0.06925979f, -0.16010420f, 0.12184797f, -0.16314451f, 0.13337380f, -0.07696912f, -0.08974961f, -0.07558770f, 
    0.07912630f, -0.12657009f, 0.12545519f, -0.06040013f, -0.04821734f, -0.24898151f, -0.03128303f, -0.09080906f, 
    -0.17789331f, 0.10041736f, 0.04770393f, -0.04304773f, 0.02267347f, 0.21647775f, 0.00840742f, 0.09286220f, 
    0.06602859f, 0.00672552f, -0.17652084f, -0.12170949f, 0.08291844f, -0.17174961f, 0.02791967f, 0.05426241f, 
    -0.02687014f, 0.06237782f, 0.19783793f, 0.29589579f, 0.19704533f, -0.01818709f, -0.12630971f, 0.02587074f, 
    0.02620437f, -0.09503120f, 0.01224131f, -0.08701571f, 0.13727275f, -0.09879249f, -0.09390850f, 0.04131315f, 
    -0.35410422f, -0.13449156f, -0.03132043f, -0.13954994f, 0.05810779f, -0.04754166f, 0.20159934f, 0.06421436f, 
    -0.01496590f, 0.11862596f, -0.11177761f, -0.13553375f, -0.18147956f, 0.13657197f, 0.33221692f, 0.31685546f, 
    0.19737846f, -0.00114432f, -0.07354123f, -0.03606556f, 0.01420103f, 0.02880054f, 0.19129437f, -0.18658344f, 
    -0.20955825f, -0.23128009f, 0.01116644f, -0.13022554f, 0.03483013f, -0.10720924f, 0.00238237f, 0.07088656f, 
    -0.08676679f, 0.00579411f, -0.20846088f, 0.05861803f, 0.07962863f, -0.02667741f, -0.06696080f, 0.17239426f, 
    0.03404086f, 0.14075281f, -0.05618968f, -0.04540986f, -0.05827553f, -0.05746467f, 0.01124317f, 0.01928639f, 
    -0.01073171f, -0.13216864f, 0.13387308f, 0.05183508f, -0.22211069f, 0.06318230f, 0.01306684f, 0.07973649f, 
    -0.01737054f, 0.09777543f, 0.18171224f, -0.12625428f, 0.29421932f, 0.06918322f, 0.13101001f, -0.03290518f, 
    -0.04542976f, -0.07930156f, -0.16194491f, -0.22740750f, 0.05057861f, -0.36691362f, -0.12792817f, 0.05405849f, 
    -0.06458539f, 0.03242581f, -0.00974415f, -0.21425542f, -0.14748628f, -0.12868841f, -0.00747420f, -0.04688229f, 
    -0.03911488f, -0.17244364f, -0.17372827f, -0.12067495f, -0.14354165f, -0.12612532f, -0.03843652f, 0.08678846f, 
    0.16322644f, 0.13751799f, 0.04062202f, -0.01909642f, -0.01052425f, -0.05028435f, 0.03383968f, -0.04843858f, 
    -0.15368630f, 0.15316986f, -0.09126481f, 0.04663773f, -0.16820942f, -0.08967774f, -0.05863565f, 0.16884750f, 
    0.01990110f, 0.13664784f, -0.16700628f, 0.02852795f, 0.01670364f, -0.00244518f, 0.05538741f, 0.06481665f, 
    0.10435460f, 0.07841541f, -0.01404987f, 0.09619398f, 0.08698729f, 0.01805519f, 0.03899081f, 0.05458244f, 
    -0.00914098f, 0.32914177f, 0.01393144f, -0.17404765f, -0.09272034f, -0.04081544f, 0.09679343f, -0.03300349f, 
    -0.15655765f, -0.01817412f, -0.15220699f, 0.00205493f, 0.12121216f, -0.01370327f, 0.09364947f, 0.07073490f, 
    0.11185864f, -0.00477568f, -0.16380286f, -0.18900244f, -0.00547130f, 0.01236968f, -0.11955016f, -0.00655058f, 
    -0.06788399f, 0.15093403f, 0.04379599f, 0.06885781f, 0.17651524f, 0.07872961f, 0.00673660f, 0.12161428f, 
    0.11471568f, 0.03926395f, 0.07809708f, -0.03690299f, 0.15477446f, -0.01329784f, -0.03729756f, -0.06259814f, 
    0.09969090f, 0.06101737f, 0.02581048f, 0.02332513f, -0.18381631f, -0.19507490f, -0.03223347f, 0.02834304f, 
    -0.12266538f, -0.08927662f, -0.02570506f, 0.06015032f, 0.02578299f, -0.41785401f, -0.36552715f, 0.05268019f, 
    0.02997125f, 0.01317347f, -0.17348900f, -0.10434140f, 0.00226852f, 0.05728865f, 0.14096743f, 0.17078325f, 
    0.25417352f, 0.14823429f, 0.07788297f, -0.08878987f, -0.04766908f, -0.00789057f, -0.03117960f, -0.10710450f, 
    -0.03044218f, -0.09446637f, 0.22491105f, 0.08670969f, 0.19134195f, 0.17193614f, 0.01460626f, 0.10359539f, 
    0.08940904f, 0.14783394f, 0.07155393f, 0.04331867f, 0.15336607f, -0.19974734f, 0.09547177f, 0.18047664f, 
    -0.08691847f, -0.18614025f, -0.05030135f, -0.27936858f, 0.04053980f, 0.04394383f, 0.05607387f, 0.16772038f, 
    0.07606051f, 0.09150225f, -0.02051364f, -0.03854330f, -0.14178520f, 0.01573616f, -0.15476121f, 0.17207238f, 
    0.16467792f, 0.00543185f, -0.06778260f, 0.08638191f, -0.33505005f, -0.05880576f, 0.13059670f, -0.05005227f, 
    0.08824962f, 0.05391644f, 0.08965122f, 0.01892760f, 0.17425747f, 0.02984397f, 0.05063792f, 0.13598633f, 
    0.01770413f, 0.24914527f, 0.05216769f, 0.05686510f, 0.05056559f, 0.14220285f, -0.15402758f, -0.07287797f, 
    0.04321620f, 0.04444724f, 0.21580060f, 0.05828905f, -0.09943733f, 0.17546231f, -0.06127205f, 0.01939431f, 
    -0.01005116f, -0.10739220f, 0.02317365f, 0.12036828f, 0.07954454f, -0.05734558f, -0.01144409f, -0.18083893f, 
    0.03454063f, 0.05307990f, 0.20677444f, -0.39694282f, -0.24910577f, 0.09772114f, -0.02155913f, -0.10968298f, 
    -0.02091575f, -0.11733403f, -0.01864183f, -0.04189781f, 0.11848930f, 0.02388090f, 0.05154148f, -0.06321936f, 
    -0.00160237f, -0.10523647f, -0.07869917f, 0.03565117f, 0.06317712f, -0.07892722f, 0.02922661f, -0.15432426f, 
    0.14822441f, -0.06750142f, 0.10613141f, -0.06701273f, 0.01714456f, -0.20183052f, -0.07436321f, -0.04836948f, 
    0.18249576f, 0.18049110f, 0.02287721f, -0.04296302f, -0.04419260f, -0.13875134f, 0.13472609f, -0.09939830f, 
    -0.23025593f, -0.15933795f, -0.05303080f, 0.10569161f, -0.13724628f, 0.02356080f, -0.18419293f, -0.00420302f, 
    -0.09236135f, 0.02697814f, 0.00329779f, 0.07386070f, 0.17475714f, 0.05577961f, 0.08112273f, 0.09634815f, 
    0.03904921f, -0.19763805f, -0.08284418f, 0.31736708f, 0.24413320f, -0.06974147f, -0.02011982f, -0.09404100f, 
    -0.12572849f, -0.05466039f, 0.05064598f, -0.12449141f, 0.03498046f, 0.10327847f, -0.03903592f, 0.06585666f, 
    0.07737966f, -0.14442460f, 0.18264748f, 0.00615357f, -0.02094669f, 0.08254533f, -0.00183021f, -0.00985067f, 
    -0.03804524f, 0.08195320f, -0.14436905f, 0.08659113f, -0.09039856f, -0.13618916f, -0.08036740f, 0.07040543f, 
    0.01352971f, -0.00925946f, 0.09929381f, 0.21239179f, 0.24294865f, 0.12029292f, 0.08778198f, -0.03341185f, 
    -0.00670352f, -0.07142311f, 0.08238719f, 0.15812147f, 0.01931072f, 0.01809455f, 0.00748712f, -0.07674244f, 
    0.03502178f, -0.03756998f, 0.05133079f, 0.04865599f, 0.02548848f, 0.25354698f, 0.07329239f, -0.06129116f, 
    0.00620518f, -0.06053435f, -0.02976717f, 0.15753195f, -0.06823720f, 0.07497101f, 0.00349107f, -0.10055581f, 
    -0.12724981f, 0.01549474f, 0.01208904f, 0.20608093f, -0.01508067f, 0.02751658f, -0.21477814f, -0.07870280f, 
    -0.14791548f, 0.10446629f, -0.08097079f, 0.05007754f, 0.02188306f, -0.13428570f, 0.11854760f, -0.18963437f, 
    0.00429730f, -0.04626649f, -0.09264809f, 0.00030674f, 0.14919613f, 0.10197968f, 0.06073575f, -0.00265084f, 
    -0.23557015f, -0.28477338f, 0.23764253f, -0.16850376f, -0.22363062f, 0.06161568f, 0.12930396f, -0.02837109f, 
    -0.08970575f, 0.04123072f, -0.02700959f, -0.05424993f, -0.00686011f, -0.04723309f, 0.02872872f, 0.15316986f, 
    0.15575571f, -0.15692398f, 0.16481081f, 0.18275632f, 0.05991399f, 0.11379973f, -0.25575885f, -0.20443954f, 
    0.00360690f, -0.02087432f, 0.00721171f, 0.05756118f, -0.11766550f, -0.15127383f, 0.06411447f, -0.04877267f, 
    0.00245397f, 0.06877586f, 0.02862597f, -0.18358932f, -0.06259069f, -0.01057289f, 0.08790676f, 0.07282700f, 
    -0.14151068f, -0.04971962f, 0.03319118f, 0.03691186f, 0.04337216f, 0.05145951f, -0.03184602f, -0.03567188f, 
    0.00951306f, -0.20259628f, 0.04699161f, 0.02703744f, 0.22778445f, -0.15800296f, 0.01563458f, 0.01508937f, 
    0.02719645f, -0.05552845f, -0.09879624f, 0.09414110f, 0.11135745f, -0.16485016f, -0.01053872f, -0.37012392f, 
    -0.37521741f, -0.12244774f, 0.03770935f, -0.01557894f, 0.09845185f, 0.04136344f, -0.04803586f, 0.12893654f, 
    0.05696511f, 0.09737277f, 0.21681234f, 0.08241361f, -0.30498093f, 0.01101759f, 0.20032783f, 0.09856706f, 
    0.07369003f, -0.06104282f, -0.12934746f, 0.13559973f, -0.05516279f, 0.06439248f, -0.04152429f, 0.01792448f, 
    -0.04757176f, -0.06106945f, 0.03706187f, 0.09627531f, -0.12247643f, 0.04775344f, -0.08670536f, -0.05046794f, 
    0.22895387f, 0.03774612f, -0.21359305f, -0.06074378f, 0.07738610f, 0.15552768f, -0.08330032f, -0.13584292f, 
    0.00740537f, -0.09781263f, 0.10254137f, -0.11263701f, -0.04488581f, 0.17357701f, -0.13052987f, -0.06593527f, 
    -0.02596841f, 0.05387431f, 0.01659094f, -0.00357144f, -0.02742896f, -0.17607348f, -0.15175270f, -0.11527850f, 
    0.20652792f, -0.05781164f, 0.01416770f, -0.05563927f, -0.12403414f, -0.00514391f, 0.01535429f, -0.03254983f, 
    0.02234048f, -0.01113262f, -0.22668923f, 0.07159268f, 0.02652512f, 0.04667116f, -0.03518139f, 0.03985768f, 
    -0.02811151f, 0.10129107f, -0.04529599f, 0.11535364f, 0.00944354f, 0.07671937f, -0.07332467f, -0.06648067f, 
    -0.08195301f, -0.26061752f, 0.22111130f, -0.08767949f, 0.02400284f, 0.06154331f, -0.11668727f, -0.01854285f, 
    0.06255510f, -0.05908001f, 0.13908422f, 0.03064552f, -0.10760584f, 0.00345971f, 0.04794462f, -0.02631229f, 
    -0.00447772f, -0.08328404f, 0.05312445f, -0.11592855f, 0.05737033f, -0.10841450f, 0.04047818f, 0.22832540f, 
    0.03053427f, -0.03199730f, 0.11155553f, -0.03105332f, 0.04002631f, 0.11264875f, -0.08966038f, -0.01107675f, 
    0.03411185f, 0.12461298f, 0.12433273f, -0.25630665f, -0.18304029f, 0.04651629f, 0.15315382f, -0.03443643f, 
    -0.24225888f, 0.11509399f, 0.04264666f, 0.06579442f, 0.14773023f, 0.12933175f, 0.00440685f, 0.08105998f, 
    -0.00030864f, -0.15038331f, 0.10162769f, -0.00864726f, -0.07143921f, -0.02169416f, -0.15316103f, 0.02379437f, 
    0.21028303f, 0.23276787f, 0.14066231f, 0.05095391f, 0.04895386f, -0.14624079f, 0.19671361f, -0.05685265f, 
    -0.03455139f, -0.17351833f, -0.25298780f, 0.00052181f, 0.12234300f, -0.14797020f, 0.10578354f, -0.02057378f, 
    0.10036429f, -0.06517752f, -0.02628339f, -0.41722101f, -0.07755005f, -0.06555435f, 0.01692390f, -0.02445696f, 
    0.01231034f, 0.10327072f, 0.10629132f, 0.03921789f, -0.25249305f, 0.14404617f, 0.01201682f, -0.03608182f, 
    0.01867259f, 0.00049781f, -0.10291173f, 0.06490093f, 0.18771228f, 0.04974953f, 0.09704250f, 0.10663068f, 
    0.03702771f, 0.08745214f, -0.00784869f, -0.06469549f, 0.03988514f, 0.07549189f, 0.10541157f, 0.13757694f, 
    0.05901798f, -0.02001308f, 0.03039010f, 0.00124890f, 0.08870134f, 0.08576348f, -0.09842265f, -0.39097834f, 
    -0.26451701f, 0.05123864f, 0.07859083f, 0.04896765f, 0.02605673f, 0.14395599f, -0.17912452f, -0.29368559f, 
    -0.39310497f, -0.26733494f, 0.01517463f, -0.06282981f, 0.03339119f, 0.11591750f, 0.03256068f, 0.00430896f, 
    -0.52754664f, -0.09381562f, -0.20216595f, -0.01506988f, -0.08623134f, -0.13095063f, 0.07086875f, -0.04962656f, 
    -0.07115734f, 0.06174207f, -0.22210868f, 0.23033512f, -0.08556957f, 0.11796490f, -0.07691017f, 0.18218875f, 
    0.06304289f, 0.01306011f, -0.31266257f, -0.17029689f, -0.13122603f, -0.01884124f, -0.20835195f, -0.22984958f, 
    0.05842583f, -0.04838195f, -0.01404319f, -0.08889770f, -0.48563078f, -0.17209038f, 0.05330598f, -0.10945559f, 
    0.01587939f, 0.04974611f, 0.07822473f, 0.08743509f, -0.17971022f, -0.35982946f, -0.00517041f, 0.11675810f, 
    0.08346600f, -0.05271344f, -0.00512398f, -0.04212544f, -0.04156764f, -0.03304709f, -0.16840091f, 0.09807865f, 
    0.12131196f, 0.05427373f, -0.02072553f, -0.02549488f, 0.06563511f, -0.03770880f, -0.12069619f, -0.21252313f, 
    -0.00986735f, -0.06345623f, 0.16311277f, 0.03763809f, 0.03698275f, 0.05998396f, -0.08747931f, 0.06141439f, 
    -0.41087446f, -0.41696507f, -0.09564965f, 0.11830734f, -0.13813585f, -0.05203608f, 0.01435914f, -0.31762356f, 
    0.31988937f, 0.29355574f, 0.11191846f, -0.00775972f, 0.09071511f, -0.01829766f, 0.25225174f, 0.08712720f, 
    0.01803549f, -0.15834166f, 0.17920867f, -0.08947013f, 0.01413507f, -0.06481141f, 0.01707435f, -0.06029890f, 
    -0.08063785f, -0.07737944f, 0.14000714f, 0.01637089f, -0.03866468f, -0.07634242f, 0.14104246f, 0.10020825f, 
    0.09959852f, 0.10973045f, -0.15053171f, 0.14836040f, 0.10132980f, -0.01951923f, -0.10320229f, 0.01244446f, 
    -0.01884905f, 0.11704604f, -0.07687135f, 0.06017202f, 0.20049924f, -0.18938576f, -0.05668332f, 0.01861664f, 
    -0.06617855f, 0.05401978f, 0.13582578f, -0.03339535f, -0.01040270f, -0.10563575f, -0.05652448f, -0.11624023f, 
    -0.12971590f, -0.04881518f, -0.04776340f, 0.11659807f, 0.12984210f, 0.07112249f, 0.00255806f, -0.06664116f, 
    -0.05615581f, 0.17956410f, 0.21169342f, -0.01068969f, 0.06650792f, 0.11379243f, -0.17201975f, -0.47314304f, 
    -0.11510900f, -0.40647361f, -0.06044163f, -0.07635375f, -0.05242090f, 0.05225449f, -0.05762083f, -0.05306592f, 
    -0.44255292f, 0.07026973f, 0.10250653f, 0.01301691f, -0.02015495f, -0.07971784f, 0.06893954f, 0.13048942f, 
    -0.12843916f, 0.26456052f, -0.10802591f, 0.01713759f, -0.19326480f, -0.00269631f, 0.11123740f, 0.03280255f, 
    -0.01003252f, -0.12423763f, 0.20107633f, 0.06889863f, 0.08943946f, -0.02970697f, -0.05755837f, 0.12712015f, 
    -0.03804204f, 0.04337427f, -0.03187950f, -0.46272027f, -0.47642300f, -0.23244150f, -0.02928092f, -0.03293519f, 
    0.01900893f, -0.10162149f, 0.05224925f, 0.05172922f, 0.21389647f, 0.16356118f, 0.17753950f, 0.02960615f, 
    0.14740057f, -0.00985446f, 0.05392858f, -0.06995798f, -0.10230815f, 0.03439124f, -0.08606952f, -0.39555052f, 
    -0.06427520f, -0.07540952f, 0.16650113f, 0.20326918f, 0.05132193f, -0.13029450f, -0.22472343f, -0.43268049f, 
    0.24366103f, -0.18522495f, -0.23900105f, -0.15711673f, 0.03327461f, 0.03914795f, 0.03640052f, 0.11969172f, 
    0.18949245f, 0.10136236f, 0.07711244f, 0.04230011f, -0.07150317f, 0.03254203f, 0.07538402f, 0.13958646f, 
    -0.01237587f, -0.22059403f, -0.10718925f, -0.16954280f, -0.08763462f, -0.16878524f, -0.02479755f, -0.08725487f, 
    0.05336718f, 0.05381567f, 0.07554275f, -0.10074836f, -0.02031865f, 0.06066905f, 0.08096308f, 0.09134006f, 
    0.09274536f, 0.07833768f, -0.11906121f, -0.19950184f, -0.48793527f, 0.03599396f, -0.10140021f, 0.03983093f, 
    0.11999205f, -0.08479617f, 0.00112019f, -0.09047806f, -0.01780255f, 0.42064190f, -0.09739815f, -0.03531837f, 
    0.05851423f, 0.07014520f, 0.05120368f, -0.01577816f, -0.08118779f, -0.14887056f, -0.02994982f, 0.00550046f, 
    -0.01197930f, -0.04124365f, 0.01506160f, 0.11775567f, -0.00622462f, -0.04852667f, 0.10981223f, 0.05823354f, 
    -0.01982562f, -0.10537232f, -0.04828560f, 0.08665209f, 0.08647546f, -0.06140770f, 0.09040662f, -0.00291867f, 
    0.01535217f, -0.01761435f, 0.08133096f, 0.03545131f, 0.12338945f, 0.04422300f, 0.11402439f, 0.11515616f, 
    -0.00859249f, 0.01216478f, -0.24809261f, -0.21744230f, -0.24819830f, 0.11356196f, 0.08192601f, 0.22184378f, 
    -0.16778804f, -0.20526698f, -0.31794333f, 0.12634589f, 0.00537241f, 0.01849150f, -0.03534210f, -0.07711178f, 
    0.09837654f, -0.04464236f, -0.00028077f, -0.02885503f, 0.05020247f, 0.01038707f, -0.29245093f, -0.10673580f, 
    0.02667723f, -0.11796741f, 0.03964546f, 0.03278643f, -0.02443460f, 0.14220636f, 0.06614340f, 0.01094776f, 
    0.07283585f, -0.04726985f, 0.09362900f, -0.01765807f, -0.11138977f, 0.28067189f, -0.07359353f, 0.06827854f, 
    -0.16516498f, 0.05749844f, -0.03197147f, -0.28337541f, -0.20765403f, -0.27340677f, 0.14631200f, 0.15895380f, 
    0.06193148f, 0.04346905f, 0.06572805f, -0.06528303f, -0.10723934f, -0.16179267f, -0.09957067f, -0.02261236f, 
    0.07176509f, 0.04621611f, -0.03080667f, 0.09096852f, 0.02378737f, -0.12366748f, 0.03697810f, 0.05145293f, 
    0.00384474f, 0.08286984f, -0.00315755f, 0.10203870f, 0.00736180f, 0.07702342f, 0.11229798f, -0.04840869f, 
    0.29473305f, -0.20572883f, -0.20039171f, -0.23983195f, -0.37618715f, 0.06116580f, 0.04337787f, -0.07247324f, 
    0.22969460f, -0.07074329f, 0.15244906f, 0.06303070f, 0.01828355f, -0.01557140f, -0.10512365f, -0.04415268f, 
    0.01854792f, -0.04871879f, -0.21116206f, 0.00890914f, 0.15118676f, 0.05153070f, -0.05326028f, 0.21076126f, 
    -0.17775752f, 0.15047440f, -0.03057179f, -0.40372899f, -0.34161636f, -0.23226379f, 0.01337261f, -0.15132068f, 
    -0.10499712f, 0.05134309f, 0.02835239f, -0.22284515f, -0.07669321f, -0.05422894f, 0.00874680f, 0.00579934f, 
    -0.10301392f, 0.22182934f, -0.07777832f, -0.16667868f, 0.06534515f, 0.17068215f, 0.41741404f, -0.16253397f, 
    -0.15443633f, -0.12024622f, 0.07640168f, 0.02150166f, 0.00622419f, -0.20683418f, -0.09112900f, -0.03858526f, 
    -0.04322966f, -0.00432129f, 0.09019955f, 0.16933458f, 0.16459265f, 0.07374689f, 0.00929480f, -0.03705060f, 
    -0.03752526f, 0.02638469f, 0.00579010f, 0.05869451f, -0.01246826f, 0.05199853f, 0.16934887f, -0.18457676f, 
    -0.13988534f, -0.17510293f, -0.20913227f, 0.17012645f, 0.10245001f, 0.06750492f, -0.04965567f, -0.14754996f, 
    -0.10999236f, -0.19664790f, -0.00825685f, -0.03318231f, 0.31760317f, 0.07355891f, 0.14345108f, -0.20492889f, 
    0.16719621f, 0.11597010f, 0.14382094f, 0.30517739f, -0.06125370f, -0.12276649f, 0.04237917f, 0.09984684f, 
    0.16334246f, 0.03607307f, -0.08493237f, 0.05519452f, -0.26093104f, -0.06908597f, -0.15471071f, -0.21767704f, 
    -0.01607242f, -0.01284882f, -0.01221578f, 0.06192751f, -0.06282975f, 0.01254856f, 0.02382618f, 0.20334159f, 
    0.03885706f, 0.20841204f, 0.07371964f, 0.16990007f, -0.24638771f, -0.07884555f, 0.15983774f, -0.10733868f, 
    -0.06674303f, -0.20961168f, -0.07208634f, -0.03441808f, -0.03469855f, 0.09449757f, 0.13455380f, 0.04980940f, 
    -0.36897728f, -0.14196506f, -0.20604052f, 0.01467088f, -0.07483553f, 0.16286173f, 0.01577724f, -0.08477257f, 
    0.09072187f, 0.15146348f, 0.17213595f, -0.01619516f, 0.09802172f, -0.01912924f, 0.09011304f, 0.00187349f, 
    -0.04782159f, 0.04183804f, -0.04787105f, -0.08874573f, -0.25187635f, -0.05440840f, 0.00440976f, -0.01658435f, 
    -0.18374114f, 0.11432681f, 0.14813632f, -0.09052245f, 0.00165318f, 0.00498854f, -0.02323742f, 0.09111847f, 
    -0.00294293f, -0.02643946f, -0.21147031f, 0.01368450f, 0.00114834f, -0.04285927f, -0.00381082f, 0.11221097f, 
    0.01220188f, -0.09572656f, -0.07817129f, -0.43274498f, -0.23027863f, -0.02932836f, -0.10160168f, -0.03127001f, 
    -0.02030879f, 0.00313770f, -0.10942435f, 0.13519149f, -0.10445084f, -0.07574096f, 0.02355907f, -0.03038260f, 
    -0.10429319f, 0.02190108f, 0.03218063f, 0.03135001f, -0.09711768f, -0.38604003f, -0.38434279f, 0.07705920f, 
    -0.06626306f, 0.00595729f, -0.04985872f, 0.02425887f, 0.02947244f, -0.09182656f, 0.11127428f, 0.09302507f, 
    -0.05763181f, -0.02711450f, 0.04710416f, 0.02641544f, 0.02067980f, 0.02154386f, -0.07640543f, -0.09816971f, 
    0.14328453f, 0.01277894f, 0.01024058f, 0.09307381f, -0.01928006f, 0.05715209f, -0.09029009f, 0.17877078f, 
    -0.07941424f, 0.06954238f, -0.13150373f, 0.07107621f, 0.05780692f, -0.05629142f, 0.07881425f, 0.13595542f, 
    0.09021328f, -0.00173800f, 0.01938352f, -0.12589797f, -0.03244018f, -0.21701768f, 0.00082068f, -0.01521281f, 
    0.03373568f, 0.10676335f, 0.03104582f, 0.28174016f, -0.02388253f, -0.06127352f, -0.00794234f, -0.03326863f, 
    0.07708497f, 0.09575019f, 0.05596169f, 0.03226494f, 0.08089729f, -0.02228837f, 0.00641559f, 0.01386039f, 
    0.03115746f, -0.02668458f, -0.09910447f, 0.14663257f, -0.25269768f, 0.04425557f, -0.04218965f, -0.14088412f, 
    -0.02752407f, 0.09870311f, -0.03712921f, -0.15000264f, -0.00972731f, -0.19051372f, -0.01781557f, -0.06554449f, 
    -0.07727917f, -0.09923983f, -0.02541129f, 0.06151681f, 0.17737971f, 0.21896769f, -0.01352524f, 0.18332517f, 
    0.04031624f, -0.03729892f, -0.05649457f, 0.05804126f, -0.04564337f, 0.11351849f, 0.10511351f, -0.02379516f, 
    0.25970435f, 0.00207708f, 0.07759479f, -0.04834550f, 0.12052879f, 0.02210727f, 0.05002893f, 0.24259336f, 
    -0.03239857f, 0.31538197f, -0.46204242f, 0.03565428f, -0.18259311f, -0.07643817f, 0.05255036f, 0.01031306f, 
    -0.03890731f, 0.08717120f, 0.01164736f, 0.06650653f, 0.00145350f, 0.05314390f, 0.03179313f, 0.07029483f, 
    0.05326745f, 0.15894353f, -0.13051853f, -0.02177278f, -0.07812529f, -0.10508538f, -0.03600715f, -0.14157338f, 
    0.14428480f, -0.09084821f, -0.41939273f, -0.10059015f, 0.16412421f, -0.21519519f, -0.00979756f, 0.06174397f, 
    -0.00783908f, -0.04837507f, 0.10209430f, 0.18246251f, 0.18793352f, -0.10170663f, 0.02473902f, -0.06276578f, 
    0.12606584f, 0.03578998f, 0.06164004f, -0.00372356f, 0.02570318f, -0.34044883f, 0.03139318f, 0.02839119f, 
    0.01186375f, -0.09791909f, 0.07840136f, 0.00441288f, -0.06736325f, -0.20197947f, -0.02484242f, 0.11857990f, 
    -0.06721572f, 0.10762740f, -0.01205772f, 0.07812022f, 0.03993065f, -0.14590149f, 0.08125282f, -0.09021677f, 
    0.17071287f, 0.12730886f, 0.02851016f, 0.16692419f, 0.01823451f, 0.08856110f, 0.06667805f, -0.08073816f, 
    -0.24382666f, -0.02053806f, 0.14856079f, -0.04881571f, 0.10810941f, -0.08549526f, -0.03784157f, 0.05189538f, 
    -0.32123834f, 0.04868597f, 0.22868156f, -0.14573583f, -0.10389797f, -0.05078461f, -0.03585928f, 0.02024118f, 
    0.01689354f, 0.21257424f, -0.19022138f, -0.04968249f, -0.00272077f, 0.20427176f, 0.05519278f, -0.00796913f, 
    0.00727708f, 0.02646170f, 0.07601495f, 0.06637286f, -0.09391280f, -0.02474138f, 0.10465955f, -0.05655760f, 
    0.06270455f, 0.06639776f, 0.15312400f, 0.02048703f, -0.06590579f, 0.16714656f, -0.11277345f, -0.01746649f, 
    0.02972060f, -0.08453591f, 0.14635010f, 0.11287550f, 0.03442563f, 0.08169290f, 0.13116546f, -0.13744861f, 
    0.01626125f, 0.00689655f, -0.01822760f, 0.06075130f, 0.01983818f, 0.07105859f, 0.04654445f, 0.28875795f, 
    -0.00830678f, -0.21184796f, -0.52323264f, 0.07741380f, -0.00138251f, 0.03983364f, 0.12421337f, -0.15887015f, 
    0.06784293f, 0.01750402f, -0.04206542f, -0.07705820f, -0.14737524f, -0.04037819f, 0.01042901f, -0.09064589f, 
    0.04605234f, 0.07196954f, 0.01741160f, 0.08112905f, 0.16159236f, 0.08772076f, 0.11463308f, 0.11461307f, 
    0.12794165f, -0.15573546f, 0.14826265f, -0.00042056f, -0.06115548f, -0.05662297f, -0.08770768f, -0.08613518f, 
    0.04793745f, 0.12783070f, -0.04557371f, 0.09251706f, 0.02809265f, -0.01982263f, -0.06164978f, 0.09238395f, 
    0.07234261f, -0.08707830f, 0.18766923f, 0.26109600f, -0.29768836f, 0.00388151f, -0.08817576f, 0.07349256f, 
    -0.02331466f, 0.05294867f, -0.07451671f, -0.12345809f, -0.12764713f, -0.40805465f, 0.01804906f, -0.29778585f, 
    0.12333938f, 0.12272968f, -0.01057018f, -0.15492032f, 0.08511943f, 0.16944814f, 0.20294577f, 0.06607226f, 
    0.07964679f, -0.02007087f, -0.03499508f, -0.08405307f, 0.03614974f, -0.10551312f, -0.23864172f, -0.25282621f, 
    -0.02228813f, -0.08568544f, 0.13003761f, 0.06585599f, -0.03451513f, 0.03292126f, 0.17378554f, 0.00975109f, 
    -0.13940370f, 0.10180610f, 0.02165047f, 0.06688166f, -0.04172639f, 0.18405120f, -0.06619512f, 0.21064056f, 
    -0.26922095f, -0.06782086f, 0.10938791f, -0.05789820f, -0.03029601f, -0.17730427f, -0.01460839f, -0.03540821f, 
    0.11347339f, 0.24722669f, -0.12339064f, 0.00327066f, 0.00074535f, 0.05119713f, 0.10779481f, -0.16223712f, 
    0.03018694f, -0.00302220f, 0.06973936f, 0.04930976f, 0.04400057f, -0.00840553f, 0.10546746f, -0.00423302f, 
    0.11829027f, -0.01599479f, 0.06559201f, 0.19677553f, -0.09163041f, -0.02306193f, -0.08191272f, -0.14119318f, 
    0.03444524f, -0.07067480f, 0.00710798f, -0.08137588f, -0.30471519f, -0.09244312f, -0.20168605f, 0.06709937f, 
    0.00449827f, 0.28798851f, 0.08113386f, 0.07763337f, 0.08044990f, 0.05732860f, 0.07401116f, 0.04361450f, 
    -0.06069389f, 0.07400430f, 0.07087070f, -0.04282683f, 0.06598768f, -0.15550372f, 0.29228684f, -0.07761897f, 
    0.11628550f, 0.06446644f, 0.10424782f, 0.09474510f, 0.03672828f, -0.03745788f, 0.11503685f, 0.27583551f, 
    -0.07854760f, -0.00646401f, 0.00336940f, 0.01191097f, -0.01884173f, -0.00126643f, -0.04988541f, 0.06149567f, 
    0.01198199f, 0.01963154f, -0.15162209f, 0.02112851f, 0.02409679f, 0.09933147f, -0.03559240f, 0.01288131f, 
    -0.11425768f, 0.08425861f, 0.10922758f, -0.07057177f, -0.06658249f, -0.04631638f, -0.02792032f, 0.01384882f, 
    0.06204021f, 0.13860829f, -0.04445948f, 0.12532817f, 0.09977733f, 0.04549937f, -0.03222540f, 0.06299811f, 
    -0.00349874f, -0.03471481f, 0.22880530f, -0.12698476f, 0.11222923f, 0.12104320f, 0.11742049f, -0.11318547f, 
    0.06770626f, 0.01973297f, -0.31234074f, -0.15206550f, 0.07984729f, -0.20872402f, 0.07772674f, 0.07739843f, 
    0.09771893f, -0.05349734f, 0.06751633f, -0.01903018f, 0.20030534f, -0.38968480f, -0.03076220f, -0.24011901f, 
    -0.03392568f, -0.12481137f, -0.00900828f, -0.13412349f, -0.02378381f, -0.22831170f, -0.06179183f, -0.11886794f, 
    -0.01146033f, -0.17002688f, 0.10907615f, 0.02067687f, 0.11165987f, 0.06444293f, 0.09258036f, 0.00522157f, 
    0.03576102f, 0.07131349f, 0.10586911f, 0.00086837f, -0.20678793f, 0.09602265f, -0.02827770f, 0.35172799f, 
    -0.21579583f, -0.00091775f, 0.11020476f, 0.23450822f, -0.01259461f, -0.11731126f, 0.09872724f, 0.01827294f, 
    -0.03094064f, 0.04726868f, 0.08819472f, -0.00525088f, -0.05988339f, -0.03932589f, 0.12289655f, -0.01198727f, 
    0.01630936f, 0.17953089f, 0.00250292f, -0.20952483f, 0.00141673f, 0.00437485f, 0.03187467f, 0.05495219f, 
    -0.18383202f, 0.03462700f, -0.15492836f, 0.31609070f, -0.23641129f, 0.03019921f, 0.05249054f, 0.22417322f, 
    -0.07416036f, -0.06263679f, 0.00810201f, 0.18486695f, 0.03302586f, 0.11416543f, 0.03125852f, -0.06670766f, 
    -0.13524587f, 0.10998274f, 0.04546519f, -0.00418493f, -0.01549138f, 0.15702924f, -0.04902356f, -0.02554942f, 
    -0.07763033f, -0.06391948f, 0.08443841f, -0.01443075f, -0.12606341f, 0.22755001f, 0.02414877f, 0.00007321f, 
    -0.03674746f, -0.10805523f, 0.10026165f, -0.12004962f, -0.02470320f, -0.10737520f, -0.01706413f, 0.18838713f, 
    0.19811901f, -0.10529409f, -0.03517554f, -0.22861275f, 0.08972374f, -0.01670199f, 0.02171509f, -0.28018445f, 
    0.10496524f, 0.11203955f, -0.05926682f, -0.05579468f, -0.04299749f, -0.00310681f, 0.01676774f, 0.02118672f, 
    -0.28031462f, -0.07079995f, -0.08030696f, 0.07099048f, -0.00893213f, 0.09907563f, 0.03971453f, 0.07827947f, 
    0.06487933f, 0.05533242f, -0.04017173f, 0.05242663f, 0.00992553f, -0.07564419f, 0.03960649f, 0.04029730f, 
    -0.20228131f, -0.02884385f, -0.17643867f, 0.06463246f, 0.21167271f, 0.17177634f, -0.06993234f, -0.18147872f, 
    -0.00004886f, 0.06726155f, 0.14072880f, -0.22240983f, 0.11802080f, 0.12134399f, 0.04198796f, 0.04371372f, 
    -0.00108099f, 0.04222946f, -0.16663551f, -0.03706554f, -0.21012774f, -0.15421967f, -0.05971967f, 0.06757063f, 
    -0.05212414f, 0.07735330f, 0.07496583f, -0.13495763f, -0.23182599f, -0.10984365f, -0.13197649f, 0.16307212f, 
    0.06085382f, -0.05821623f, -0.06684789f, -0.21887921f, -0.02576930f, -0.01363092f, 0.02323983f, 0.02099951f, 
    0.11706379f, 0.08690907f, 0.08210934f, -0.05482056f, 0.03725711f, 0.01880823f, 0.00050822f, -0.02344650f, 
    -0.00486939f, -0.00978409f, 0.12528196f, 0.08040227f, -0.06378265f, 0.07457472f, 0.05323524f, 0.21200866f, 
    0.22419874f, 0.05416935f, 0.01058124f, 0.12075466f, -0.01885403f, 0.03854993f, -0.01574215f, 0.01429794f, 
    0.36364976f, 0.22391935f, -0.03079068f, 0.07279464f, -0.05244044f, 0.10551500f, -0.22710738f, 0.04696505f, 
    0.04710425f, 0.21623291f, -0.07430040f, -0.07957263f, 0.20094118f, 0.03483190f, -0.00447396f, 0.08017186f, 
    -0.05161409f, -0.04077264f, -0.11975621f, -0.04517652f, -0.03845260f, -0.00600905f, 0.05806269f, 0.08906742f, 
    -0.15680964f, -0.08881300f, -0.10752230f, -0.28477502f, 0.00494198f, -0.02575986f, -0.08223379f, 0.05436724f, 
    0.09724965f, -0.07569453f, 0.03000532f, 0.15508148f, 0.11969201f, 0.06588191f, -0.02738412f, 0.16534664f, 
    0.12683569f, 0.10177107f, -0.08495356f, 0.08292942f, -0.06736531f, 0.07237006f, 0.04919343f, 0.06224294f, 
    0.12132356f, 0.05269484f, 0.07114393f, -0.01028212f, -0.01799357f, -0.09869211f, 0.06713973f, 0.15191375f, 
    0.00502989f, 0.19044569f, 0.06173607f, 0.13130735f, 0.12175256f, -0.14463145f, -0.12743887f, 0.13179936f, 
    -0.10956775f, -0.02462653f, -0.24490790f, -0.07330725f, 0.06718622f, -0.09646503f, 0.19219805f, 0.10621530f, 
    0.13284948f, 0.05801561f, -0.07450318f, 0.08633516f, -0.09812032f, 0.11818569f, 0.06418235f, -0.06986354f, 
    0.02128865f, -0.20222236f, 0.13154422f, -0.06912768f, 0.04319641f, -0.01768133f, 0.18483898f, 0.00578276f, 
    -0.11028036f, 0.08014435f, 0.10650228f, -0.17640010f, -0.00317166f, 0.11565848f, 0.08145921f, 0.07495758f, 
    -0.03293515f, -0.10285309f, 0.04593865f, 0.04976745f, 0.06832554f, -0.04787391f, 0.12687269f, 0.07619756f, 
    0.19003232f, 0.03348024f, 0.05123754f, -0.15283208f, 0.10685188f, -0.14480768f, 0.03230619f, -0.00027216f, 
    0.07160336f, -0.03941782f, -0.05767201f, -0.21245266f, -0.16876791f, -0.16081849f, -0.00794188f, -0.02117413f, 
    0.08901841f, -0.01812583f, 0.08831775f, -0.14982240f, 0.18584050f, 0.12054497f, 0.12272424f, 0.22015080f, 
    -0.01482390f, 0.24534553f, 0.01797128f, -0.05164117f, 0.10450819f, 0.08997336f, 0.20289887f, 0.05079954f, 
    0.09777965f, -0.05540220f, 0.03433016f, -0.01045836f, 0.05046672f, 0.05834770f, -0.02984518f, 0.11821758f, 
    -0.03005376f, -0.09136642f, 0.01589961f, 0.03720745f, 0.02784530f, 0.01504188f, -0.14356628f, -0.19014663f, 
    0.05464221f, 0.15314957f, -0.12478949f, -0.21793908f, -0.14228328f, 0.03524061f, -0.00159220f, 0.13186732f, 
    -0.03679229f, -0.13720042f, -0.09322593f, 0.23277315f, 0.09266956f, 0.11432603f, 0.00214019f, 0.00979409f, 
    -0.01118494f, -0.11303333f, 0.00348052f, -0.00710404f, 0.04224167f, -0.01538887f, -0.04386255f, -0.00794149f, 
    0.07883147f, -0.01900195f, -0.12459218f, 0.00375642f, -0.01323261f, 0.00581740f, -0.25612381f, 0.03817508f, 
    0.16570559f, 0.18490100f, 0.04994938f, 0.07198403f, -0.05343743f, -0.00468643f, 0.06142186f, -0.06346785f, 
    -0.02530861f, -0.01733443f, -0.02989501f, 0.01936190f, -0.00155210f, -0.02243630f, -0.15505695f, -0.03614326f, 
    -0.03408099f, -0.08278293f, -0.03989878f, 0.06743687f, 0.07627447f, 0.08343281f, 0.06393471f, 0.02183754f, 
    0.08980770f, 0.21084780f, -0.01185802f, -0.24156094f, -0.02876375f, -0.02423204f, -0.09256461f, -0.05622514f, 
    0.00883068f, -0.21087018f, -0.00925854f, -0.07924949f, 0.01062552f, 0.07411458f, 0.02538122f, 0.00785588f, 
    0.17507982f, -0.15468216f, -0.33477721f, 0.31965360f, -0.15412663f, -0.13701588f, 0.06850675f, 0.06536797f, 
    0.01523961f, -0.06755842f, -0.12913011f, 0.13723692f, -0.16463952f, -0.13056597f, -0.00044167f, 0.10614596f, 
    0.09390572f, 0.02537099f, 0.04292997f, 0.06480516f, -0.09067895f, 0.10349251f, 0.09126941f, -0.02494357f, 
    0.13085604f, -0.02218782f, 0.04251891f, 0.06028087f, 0.12213588f, 0.07383494f, -0.05647272f, 0.00812220f, 
    -0.05224126f, -0.07414810f, 0.09851537f, -0.16627231f, 0.01989686f, 0.02420999f, -0.16494341f, -0.10994826f, 
    -0.12882589f, 0.12379204f, 0.08529420f, 0.00023404f, 0.05675094f, 0.07524039f, 0.07178394f, -0.01264296f, 
    -0.41216895f, 0.02635446f, -0.03614911f, -0.00549401f, -0.15061501f, 0.10539774f, 0.01979915f, 0.11654804f, 
    -0.20885637f, -0.13791642f, -0.25479048f, 0.03206075f, 0.04845506f, -0.10026965f, -0.12611774f, 0.20734999f, 
    0.02254827f, -0.00203928f, 0.08319928f, 0.07284716f, -0.06434844f, -0.02938506f, -0.05623338f, -0.07476573f, 
    -0.03507981f, 0.15194637f, -0.24133173f, -0.01494260f, 0.10465535f, 0.05685827f, -0.05940628f, -0.06142436f, 
    -0.01982529f, -0.04877497f, 0.16120869f, 0.19479495f, -0.12037114f, 0.00159362f, -0.00513567f, -0.10792880f, 
    0.01084376f, -0.07112710f, 0.05804038f, 0.09165025f, -0.22579354f, -0.11257542f, 0.05967478f, -0.08426709f, 
    -0.12465598f, 0.04195929f, -0.05577356f, -0.04558922f, 0.06410720f, -0.03937895f, 0.05935845f, -0.01737123f, 
    0.07567421f, 0.13198513f, -0.04778156f, 0.10148858f, 0.08189705f, 0.02395358f, -0.10042510f, 0.05326052f, 
    0.13976575f, 0.00326071f, -0.01935124f, 0.04379487f, 0.04010817f, 0.02477005f, 0.04488435f, 0.16576360f, 
    0.06145988f, -0.33062837f, -0.01935904f, -0.07603306f, -0.05825713f, 0.14926893f, 0.12564923f, -0.05382492f, 
    0.08755340f, 0.20093395f, 0.08487014f, -0.02518469f, -0.07494374f, 0.07869768f, 0.03750837f, 0.06524517f, 
    0.09056955f, -0.33882365f, -0.12068315f, 0.18276693f, 0.00040349f, -0.05837668f, -0.00309422f, 0.06359774f, 
    0.21471666f, 0.10425444f, 0.02284208f, 0.08843517f, -0.12384801f, -0.06127942f, 0.09026355f, -0.06631140f, 
    -0.01255773f, 0.04828440f, 0.03134124f, 0.10595247f, 0.14551058f, -0.02011815f, -0.11540038f, 0.01850588f, 
    0.00980686f, 0.03897185f, 0.02983930f, 0.09107870f, 0.06261367f, -0.11248934f, 0.02632126f, 0.14089204f, 
    0.02345785f, 0.00375486f, 0.13686383f, 0.05861505f, -0.03983619f, 0.11532950f, 0.16715333f, 0.03097819f, 
    -0.03068622f, -0.07655933f, -0.08239806f, -0.18853825f, 0.02745811f, -0.02719123f, -0.06256299f, 0.05647900f, 
    -0.06957314f, -0.04979765f, -0.03637261f, 0.15413012f, 0.02592926f, -0.02009791f, -0.01087013f, 0.13490649f, 
    0.11735553f, -0.38624930f, -0.24153861f, 0.21639434f, -0.02018676f, 0.09904850f, 0.16596685f, -0.04937647f, 
    -0.27578190f, 0.20085134f, 0.13718003f, 0.02790005f, -0.10770453f, -0.13149966f, -0.09003313f, 0.00303566f, 
    0.01277680f, -0.06590488f, -0.19866139f, -0.09537487f, 0.02693122f, 0.10985863f, 0.08423158f, 0.04061917f, 
    -0.04033741f, 0.12446982f, 0.19118485f, 0.15205261f, -0.13231251f, -0.03878313f, -0.05575123f, -0.11902834f, 
    -0.17490815f, 0.01896380f, 0.11511429f, -0.04179148f, -0.32832712f, 0.04497604f, 0.05822197f, -0.06316043f, 
    -0.04004237f, 0.13549723f, -0.00534658f, 0.04291470f, 0.03697792f, 0.07823244f, 0.02401366f, -0.14050278f, 
    -0.01951133f, 0.05601317f, -0.06562470f, 0.05049789f, 0.11132762f, -0.04494976f, -0.11230877f, 0.01924947f, 
    0.17530273f, -0.06838656f, 0.00642722f, 0.03564356f, 0.05644253f, 0.09526654f, -0.18311894f, -0.19355181f, 
    0.32926038f, 0.07177260f, -0.16326544f, -0.13414089f, 0.15486871f, 0.05075078f, 0.06601711f, 0.03909729f, 
    0.12506533f, 0.13679358f, -0.17952152f, -0.03638778f, 0.08576392f, -0.20412676f, -0.01752262f, 0.10237878f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.18603952f, -0.08552967f, 0.00378693f, 0.12245870f, 0.08289732f, 0.08026268f, 0.04010660f, 0.11824115f, 
    -0.00593842f, 0.15327695f, -0.02688900f, 0.15563752f, -0.05690794f, -0.02700892f, -0.03487659f, 0.07095785f, 
    0.02580844f, 0.04439063f, 0.22328651f, 0.15316215f, 0.05419671f, -0.04520336f, 0.04711649f, 0.04166661f, 
    0.04662971f, -0.07115547f, 0.03767465f, 0.18378241f, 0.09511372f, 0.08322988f, -0.04129054f, -0.03841594f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.08601961f, -0.08456100f, 0.16732141f, 0.15320323f, -0.02099331f, 0.11612400f, 0.10820696f, -0.39410686f, 
    -0.23608169f, 0.25381708f, 0.07277425f, 0.05878383f, 0.08287144f, -0.01338114f, -0.05240009f, 0.24671754f, 
    0.27370563f, -0.49851042f, 0.23457499f, -0.08608320f, 0.31726599f, 0.01243407f, 0.22441785f, -0.00849438f, 
    0.32733709f, -0.38848275f, -0.35510126f, 0.12616470f, 0.29340100f, 0.02899750f, 0.07584655f, 0.05315237f, 
    -0.16262843f, 0.30060613f, 0.15952037f, -0.03418128f, -0.16871084f, 0.14530227f, -0.23459913f, -0.29260397f, 
    0.03743290f, 0.18693615f, 0.05495317f, 0.03329347f, 0.29007491f, -0.10396675f, -0.04162671f, 0.03162863f, 
    0.14291671f, 0.20326920f, -0.13375148f, -0.25096115f, -0.17464188f, -0.05290993f, 0.13376716f, 0.08521965f, 
    0.39923075f, 0.10928097f, 0.11784814f, 0.20734000f, 0.00121451f, 0.06079673f, -0.07186718f, 0.00911304f, 
    0.09103846f, -0.11956508f, 0.16004843f, -0.05176287f, -0.07594450f, 0.11923382f, -0.11815412f, -0.12147172f, 
    0.00972682f, -0.07080902f, -0.04506973f, 0.02262935f, 0.12638098f, 0.13766763f, 0.14995445f, 0.06075485f, 
    -0.08893816f, 0.05011981f, -0.04701859f, -0.16917706f, -0.04540103f, 0.03336868f, -0.08013233f, 0.00706033f, 
    -0.16949849f, -0.11801495f, -0.14001504f, -0.18006775f, -0.05949018f, -0.04902347f, -0.08527631f, -0.11396338f, 
    -0.28948933f, 0.01414182f, 0.11752964f, -0.19279973f, -0.06470623f, 0.05752996f, 0.20495081f, -0.19884537f, 
    -0.02698502f, -0.11547790f, 0.06762574f, 0.07576384f, -0.11789657f, 0.12600937f, -0.16036779f, 0.11914909f, 
    0.15601945f, 0.17108132f, -0.05033189f, -0.02575144f, -0.05149551f, 0.13987376f, 0.02822770f, 0.36003509f, 
    0.00125033f, 0.11820678f, 0.26136649f, -0.32599795f, 0.14151958f, 0.38538483f, -0.21011853f, 0.19971028f, 
    -0.24671388f, 0.18425141f, 0.00867017f, 0.13050261f, 0.24782026f, 0.02115025f, 0.19521122f, 0.25450358f, 
    0.07042724f, -0.39612642f, 0.12453844f, 0.09087819f, 0.13041644f, -0.12371188f, 0.10594780f, 0.07922667f, 
    -0.06548467f, 0.18729037f, 0.23505627f, -0.18792473f, 0.01816349f, -0.15129329f, 0.33507794f, -0.07592914f, 
    -0.30447778f, 0.05449976f, 0.44987515f, 0.05026204f, -0.02936432f, 0.10304636f, -0.20043685f, 0.37897837f, 
    0.34058744f, 0.02768530f, -0.09813354f, -0.07834857f, 0.17112459f, 0.31718421f, -0.08154120f, -0.37530464f, 
    -0.10649859f, -0.23855893f, 0.15514658f, 0.23763458f, 0.24689099f, 0.07705440f, 0.06469286f, 0.28042895f, 
    -0.09660045f, -0.17883071f, 0.19742939f, -0.00248841f, -0.01578528f, 0.06703881f, 0.05807138f, -0.30349749f, 
    0.01908156f, -0.01486532f, -0.19474037f, -0.11129185f, -0.22727585f, -0.17094781f, 0.20865908f, 0.27072248f, 
    0.38698646f, -0.15455744f, -0.09681971f, 0.18606532f, 0.12792757f, -0.05160479f, 0.05037322f, -0.02351287f, 
    0.17428717f, 0.35931224f, -0.07012916f, 0.21282524f, -0.19549333f, -0.04498940f, 0.10274731f, -0.10541750f, 
    0.10659172f, -0.24189065f, 0.09837956f, 0.03471763f, 0.05872424f, 0.07222854f, 0.03165567f, 0.03023159f, 
    -0.08068644f, -0.04719540f, -0.30867290f, 0.02806334f, -0.22342023f, -0.16269577f, 0.20448647f, -0.13047948f, 
    0.07086793f, -0.09048285f, 0.04469340f, -0.22664700f, -0.07456234f, 0.02828092f, -0.10245206f, -0.26397547f, 
    -0.11375917f, -0.09789228f, -0.14054845f, 0.12170652f, -0.10680408f, 0.14658570f, 0.13009840f, -0.15703012f, 
    -0.13272330f, -0.04248515f, -0.21750858f, -0.03387060f, -0.08648859f, -0.14206441f, 0.08015770f, 0.04610854f, 
    -0.16019759f, -0.18288623f, -0.17929101f, -0.26297930f, -0.05686878f, 0.08600477f, 0.14753620f, -0.19421960f, 
    -0.25099650f, -0.25031805f, 0.37517253f, -0.16848803f, 0.21008791f, -0.29841763f, 0.19836815f, 0.42695525f, 
    0.18703087f, -0.28307760f, 0.00827908f, -0.00775529f, -0.12137463f, -0.15600467f, 0.14949511f, -0.30523178f, 
    0.22255133f, 0.13664001f, 0.30633152f, 0.12982912f, 0.04693286f, 0.15746690f, -0.13660687f, 0.02022767f, 
    -0.12392157f, 0.20095064f, 0.25944984f, 0.06855941f, 0.04033589f, 0.30746984f, -0.15126254f, -0.08249028f, 
    -0.16976717f, -0.08731601f, 0.04873485f, -0.27084795f, 0.15686968f, -0.09740803f, -0.20454988f, 0.24745645f, 
    0.03737165f, -0.41700479f, -0.12976679f, 0.05491335f, 0.02115867f, -0.16440254f, -0.15478840f, -0.09333833f, 
    0.15999018f, 0.44581380f, 0.20819895f, 0.22064966f, -0.12022841f, 0.02240024f, 0.09439566f, 0.05718745f, 
    -0.09864527f, 0.06643108f, 0.41653094f, -0.25139099f, -0.02266743f, 0.30661619f, -0.16968155f, -0.02869577f, 
    0.52042198f, -0.66159475f, 0.34264696f, 0.09553863f, 0.07684974f, -0.49057567f, -0.03053996f, -0.25956541f, 
    -0.05118414f, 0.34947860f, -0.05336728f, 0.06377285f, -0.09400015f, 0.16128911f, -0.12583694f, 0.04424717f, 
    -0.07355099f, -0.04300050f, 0.25566158f, 0.22921605f, 0.10604102f, -0.11687552f, 0.13273275f, -0.52248424f, 
    0.18092968f, -0.08525316f, 0.08350963f, 0.41895062f, 0.28010890f, -0.14709881f, 0.12096663f, -0.00226857f, 
    0.31248662f, -0.11270164f, -0.24471529f, -0.17093287f, -0.05794701f, 0.26776898f, -0.14654651f, 0.15797265f, 
    0.11518007f, 0.33250436f, -0.04349642f, 0.16800813f, 0.00248700f, -0.14481018f, 0.03640262f, 0.20693907f, 
    0.05354072f, -0.34986186f, -0.04528019f, 0.02418513f, 0.22990103f, -0.12924406f, 0.02801094f, 0.15003864f, 
    -0.03372890f, 0.08526310f, -0.25193223f, -0.16816585f, -0.21292457f, -0.19148695f, 0.15633020f, -0.21592720f, 
    -0.19397488f, -0.11723208f, 0.07085022f, -0.40493077f, 0.02703889f, 0.03810329f, -0.13203955f, 0.45432898f, 
    0.06662911f, 0.01558890f, -0.17519121f, 0.19464770f, 0.04219004f, 0.00641369f, 0.17134985f, -0.34367752f, 
    0.04853704f, 0.27643088f, 0.10480054f, 0.24942461f, -0.29934376f, -0.12754269f, 0.10654064f, 0.01319790f, 
    -0.13134383f, 0.14410673f, -0.06615835f, -0.27938941f, 0.13979505f, 0.36363676f, 0.11863448f, -0.22043020f, 
    0.09407813f, 0.05631358f, -0.04603153f, 0.04656266f, 0.18293887f, 0.54810244f, 0.04148287f, -0.31690231f, 
    -0.01005654f, -0.07664254f, 0.01707639f, 0.11788195f, -0.24157336f, 0.18319103f, -0.16798545f, -0.12558083f, 
    -0.17717934f, -0.21567327f, -0.16116421f, 0.20791997f, 0.06714997f, -0.04926309f, -0.02008696f, 0.28492624f, 
    -0.14833815f, 0.09451718f, -0.20917682f, -0.41755888f, 0.03430106f, -0.14403765f, 0.24518894f, 0.07597320f, 
    0.06584800f, -0.20004404f, 0.14564976f, 0.34204689f, -0.09295062f, -0.17539352f, 0.07450471f, -0.39984378f, 
    -0.05195997f, 0.01537008f, 0.06043463f, 0.01510637f, 0.09567916f, 0.15381853f, -0.00946303f, 0.36733478f, 
    0.18452863f, -0.56962204f, 0.23714164f, -0.21191718f, 0.27693364f, 0.11424817f, 0.24887343f, -0.08548556f, 
    0.16497162f, -0.35660514f, -0.01594986f, 0.19933008f, 0.10562435f, 0.02736267f, 0.11029434f, 0.05875985f, 
    0.03434844f, 0.08486024f, 0.17668095f, 0.18151668f, -0.00313962f, -0.55180258f, 0.07459223f, 0.25262684f, 
    0.10753729f, 0.08551826f, -0.00718020f, -0.10350259f, -0.09845390f, 0.09117657f, 0.02275707f, -0.38936767f, 
    0.24588914f, 0.25039047f, 0.21870649f, 0.06307824f, -0.11006474f, 0.02286135f, -0.22625659f, -0.30152988f, 
    0.17792203f, 0.08504490f, -0.17469963f, 0.04160616f, 0.19683622f, -0.34844303f, -0.05096257f, -0.22185506f, 
    0.12368451f, -0.24565259f, 0.32322359f, -0.14641146f, -0.19697817f, -0.33781099f, -0.20551302f, 0.24437287f, 
    0.18558188f, -0.11710035f, 0.14736596f, 0.06743630f, -0.07087330f, 0.00324067f, 0.03491949f, -0.14209472f, 
    -0.23818269f, 0.43996799f, 0.14559518f, 0.14919566f, 0.00982659f, 0.05057224f, -0.13251477f, -0.19775510f, 
    -0.00732622f, -0.09297132f, 0.03666764f, 0.13370520f, 0.16437158f, 0.23521511f, 0.08263078f, 0.10706896f, 
    -0.13552114f, 0.16257618f, 0.10140674f, -0.07111488f, -0.24331748f, -0.28784981f, 0.02499749f, -0.19567564f, 
    -0.17257483f, 0.35223904f, -0.07441580f, -0.18226759f, 0.21900097f, 0.11401164f, 0.10910843f, 0.30352828f, 
    0.18143493f, -0.32622343f, -0.00566386f, -0.19193034f, 0.21034378f, -0.16612861f, 0.17927553f, 0.19710976f, 
    0.25023735f, -0.28387555f, 0.06697902f, 0.06645569f, 0.42046389f, 0.25954419f, -0.14315282f, 0.23554029f, 
    -0.16720687f, 0.19931212f, -0.19447459f, -0.20421599f, 0.24412762f, 0.14025867f, 0.23750591f, -0.10879195f, 
    0.01292691f, -0.20014068f, 0.04451961f, 0.16603886f, -0.05522249f, -0.15140122f, -0.05589005f, 0.27274796f, 
    0.08908340f, -0.19381064f, 0.06511774f, 0.03399608f, 0.04045448f, -0.17341635f, 0.05766221f, -0.26057351f, 
    0.03255571f, 0.01453941f, 0.20004600f, 0.02738217f, -0.32232940f, 0.06596786f, -0.09264521f, 0.16249736f, 
    0.11615779f, -0.25929931f, -0.49575418f, -0.18394546f, -0.12027031f, 0.11043441f, 0.21419403f, 0.15274110f, 
    0.14147545f, -0.01455067f, -0.02134232f, 0.28835586f, 0.09727584f, -0.11919316f, 0.10002596f, -0.04145530f, 
    -0.01850811f, -0.18551418f, -0.18201199f, -0.13453674f, 0.14113419f, 0.17353328f, 0.32606328f, 0.19164191f, 
    0.01211983f, 0.04614644f, -0.00366727f, 0.23702949f, -0.20347881f, 0.16134760f, -0.15454862f, -0.08393917f, 
    0.12409192f, -0.15845321f, 0.51362175f, 0.00488732f, 0.19294806f, 0.36417544f, -0.08012709f, 0.11449925f, 
    -0.20191613f, -0.04174047f, 0.03485727f, 0.02107228f, -0.25675711f, 0.01920023f, 0.13033834f, -0.24027985f, 
    0.28433219f, 0.17899816f, 0.27507016f, 0.08071829f, -0.09830204f, 0.03058516f, -0.26137334f, -0.04478876f, 
    0.39760691f, -0.13462706f, -0.03364429f, -0.26984438f, 0.30066624f, 0.08639103f, 0.12227038f, -0.05600204f, 
    0.21185538f, -0.25187197f, 0.26661596f, 0.20401858f, -0.10272786f, -0.03847602f, 0.14242332f, -0.12160090f, 
    -0.02133794f, -0.32490566f, -0.09727132f, 0.27126646f, -0.24696605f, -0.04107835f, 0.11516912f, -0.10012779f, 
    -0.06925821f, 0.24730432f, 0.18860568f, 0.21521150f, 0.20694794f, 0.13384517f, -0.02214318f, -0.47140577f, 
    0.00329890f, -0.12883247f, -0.18965650f, 0.08342495f, 0.28932270f, -0.11093539f, 0.19745708f, -0.10334092f, 
    0.21882513f, -0.02676552f, -0.04960068f, -0.22592756f, -0.04634582f, -0.39058721f, 0.10435134f, 0.30648234f, 
    0.25430036f, 0.00032835f, 0.16081031f, 0.30700949f, 0.14120001f, -0.03450281f, -0.04103964f, 0.12946279f, 
    -0.25895610f, 0.00598228f, -0.07742024f, -0.03615215f, -0.20624085f, -0.08504197f, 0.21909206f, -0.28863546f, 
    -0.11194257f, -0.03056872f, 0.19161212f, 0.33939785f, 0.04342072f, 0.33648634f, -0.34889773f, -0.03029143f, 
    0.23849967f, -0.14729767f, -0.27563134f, 0.10863059f, 0.27704579f, -0.08064149f, 0.31296435f, -0.04794222f, 
    0.11827611f, 0.22817971f, -0.00215121f, 0.30892265f, -0.12201120f, 0.14224371f, -0.09850217f, -0.00077979f, 
    -0.16802809f, -0.32237172f, 0.05199274f, 0.07760213f, -0.06532905f, 0.07692703f, -0.02711866f, 0.08381357f, 
    -0.04851560f, 0.11699176f, -0.23230658f, -0.09704106f, -0.42156383f, 0.12908971f, 0.10554630f, -0.26314849f, 
    -0.07020210f, 0.03458191f, 0.23171256f, 0.15596429f, 0.06685881f, 0.27070826f, -0.01328721f, 0.08887425f, 
    -0.30112389f, -0.03276604f, -0.04679002f, -0.07401422f, 0.00499329f, 0.14220603f, -0.07743511f, -0.11558844f, 
    0.28798786f, 0.20811640f, -0.09199131f, 0.09831171f, 0.23250791f, -0.05565602f, -0.14169109f, -0.03788911f, 
    0.25625339f, -0.34957030f, -0.12868617f, -0.05626491f, 0.17188838f, -0.19249736f, 0.23181854f, 0.00691573f, 
    0.33356419f, -0.36702770f, -0.10592920f, 0.07446560f, 0.23609704f, 0.33959076f, 0.07735488f, 0.00308716f, 
    0.19504534f, -0.02614702f, -0.15880251f, 0.30761978f, -0.02411278f, 0.06538130f, 0.15492599f, 0.00758335f, 
    -0.33285144f, -0.04562417f, 0.23680234f, 0.23202175f, -0.05238399f, -0.04937354f, -0.19107777f, 0.12077024f, 
    -0.11735626f, 0.07155044f, -0.07189938f, -0.17204773f, -0.37615761f, 0.21881136f, -0.02182148f, -0.27924559f, 
    -0.03107312f, 0.14824848f, -0.07540391f, -0.08419374f, -0.09308942f, 0.38240895f, 0.15854813f, -0.19708255f, 
    -0.06056185f, 0.39162880f, 0.07893436f, 0.28405619f, -0.27843311f, -0.05100667f, -0.09629932f, 0.06277007f, 
    -0.19917834f, 0.16178581f, -0.16264778f, 0.23913009f, -0.15885088f, -0.07218421f, -0.11084739f, 0.16749473f, 
    -0.00060865f, 0.06362215f, -0.36026388f, 0.10693778f, 0.10220747f, -0.00140115f, -0.14452194f, -0.24309464f, 
    0.08461427f, 0.20544164f, -0.12483301f, -0.37137851f, -0.29340041f, 0.03025292f, 0.18638106f, -0.27876022f, 
    -0.11977117f, 0.17196701f, -0.06171220f, 0.14567064f, 0.10787732f, 0.15347527f, 0.04814277f, -0.12469090f, 
    0.14765437f, 0.13189366f, 0.00452411f, 0.11315285f, 0.05383379f, 0.13176680f, 0.30133104f, 0.32187632f, 
    -0.17752276f, 0.08021581f, -0.24253102f, -0.31664908f, 0.22210035f, 0.41306111f, -0.13841185f, 0.16439424f, 
    -0.06157669f, 0.01396180f, -0.16377711f, -0.14720264f, -0.19498529f, 0.04713441f, -0.09480748f, 0.07985184f, 
    0.01176900f, -0.16792926f, 0.07827844f, 0.05157262f, 0.00200036f, 0.15008159f, 0.12228838f, -0.01538588f, 
    0.07179508f, -0.12286789f, -0.13395299f, -0.18175644f, -0.18788899f, 0.10847466f, -0.15749100f, -0.08407016f, 
    0.08186293f, -0.03311252f, 0.16154553f, -0.16036491f, 0.07736149f, -0.06626873f, 0.00658763f, -0.02372152f, 
    0.22127372f, -0.52945602f, 0.29540896f, 0.13872239f, 0.25876880f, 0.16337067f, 0.11218640f, -0.06070129f, 
    -0.04334280f, 0.03905045f, 0.00627108f, 0.29922000f, -0.29319301f, -0.11644519f, 0.09468268f, -0.05431739f, 
    -0.03215492f, -0.24419659f, 0.39607495f, 0.23733215f, -0.03339669f, 0.16586092f, -0.25283426f, -0.30780211f, 
    0.16140150f, -0.00410104f, -0.12902139f, 0.14765261f, 0.18190704f, -0.26533347f, 0.18347491f, 0.08284553f, 
    0.34995133f, -0.32361674f, 0.32219937f, -0.04880511f, 0.06753290f, 0.17333524f, 0.11340305f, -0.16695355f, 
    -0.14888918f, 0.27627507f, 0.10240356f, 0.24453704f, -0.15187697f, -0.06535619f, -0.07839750f, -0.20020862f, 
    0.03728959f, 0.16079451f, 0.13946642f, 0.27586263f, 0.09720101f, -0.11529506f, -0.14939071f, -0.27356389f, 
    -0.03251348f, -0.09122624f, -0.21607333f, -0.07015117f, 0.00372381f, -0.17647150f, 0.03485805f, -0.21695919f, 
    -0.19993196f, 0.24429211f, 0.06198476f, -0.02867589f, -0.08599130f, -0.04738187f, 0.20468362f, 0.26062068f, 
    0.11176759f, -0.32017609f, -0.15824527f, -0.17968270f, 0.22824356f, -0.11897480f, -0.09500977f, 0.07445379f, 
    0.11669968f, 0.11986300f, 0.14367938f, -0.06522454f, -0.20878339f, 0.09982735f, 0.00738945f, 0.12907445f, 
    0.04465773f, -0.16728389f, 0.08938652f, -0.21542567f, 0.16717854f, 0.21030155f, -0.22756316f, 0.34150302f, 
    -0.15745862f, -0.16971813f, -0.00898809f, 0.01797114f, -0.12629925f, 0.04900654f, -0.17690231f, -0.01008581f, 
    -0.13687406f, -0.14170422f, 0.08572867f, 0.08229098f, 0.01088195f, -0.03588225f, 0.04427502f, 0.03566331f, 
    -0.00811310f, 0.08556023f, 0.09485318f, -0.03463460f, -0.13111946f, 0.09817290f, -0.04846158f, -0.11825961f, 
    -0.01598614f, 0.12448408f, -0.07788076f, 0.03273153f, -0.17897239f, 0.00484980f, -0.12886237f, 0.15169981f, 
    -0.14994928f, -0.15196246f, 0.07664807f, -0.06605227f, 0.04618292f, -0.01694560f, -0.11897665f, -0.10785753f, 
    -0.07018889f, 0.05598081f, 0.09507360f, -0.03934899f, -0.14548978f, 0.05281356f, 0.09523477f, 0.00653567f, 
    -0.11297954f, -0.09472658f, 0.01801894f, -0.13332851f, 0.04217176f, 0.11230993f, -0.09778589f, -0.12594312f, 
    0.05825773f, -0.03524530f, 0.10244852f, 0.15007536f, 0.07138247f, 0.15632445f, -0.07524648f, -0.13168286f, 
    -0.07375294f, -0.07847174f, -0.14744139f, 0.15686320f, -0.14988160f, -0.15647702f, -0.08391593f, -0.08005058f, 
    -0.12092459f, -0.16621540f, -0.06987486f, -0.15970345f, 0.09936932f, -0.00470131f, -0.12012825f, 0.01810742f, 
    -0.08022315f, -0.09424617f, -0.06151305f, -0.07381456f, -0.07816072f, 0.10226897f, 0.10654631f, -0.01069466f, 
    0.13282193f, -0.05315902f, -0.07645396f, 0.08462185f, -0.15537739f, -0.02050579f, -0.03506797f, -0.16831826f, 
    -0.33575776f, 0.01434831f, 0.20147669f, 0.15792677f, 0.10611380f, 0.14317666f, 0.14554358f, -0.08895241f, 
    -0.23249924f, 0.19212796f, -0.04090173f, -0.12547244f, -0.10222462f, 0.07139042f, 0.12391435f, 0.19045329f, 
    0.41267616f, -0.28387007f, 0.06827807f, -0.02745567f, -0.00549643f, -0.11549863f, 0.16672926f, 0.08998021f, 
    0.22030231f, -0.41760275f, 0.25544953f, 0.11727025f, 0.07292951f, 0.08089948f, 0.05830926f, 0.15401512f, 
    -0.11534017f, -0.09843315f, 0.40067860f, 0.30622360f, 0.17459241f, 0.19963008f, -0.23107935f, -0.25691664f, 
    -0.13076022f, 0.05584411f, -0.02197644f, -0.14867900f, -0.08631977f, 0.11995814f, 0.10958800f, 0.21707617f, 
    0.30859935f, 0.00136425f, 0.12969822f, -0.19755179f, 0.30009642f, -0.16682737f, 0.10996632f, 0.02220223f, 
    0.38749364f, -0.39102644f, 0.00510234f, -0.04205208f, 0.15794969f, 0.17201127f, 0.21464603f, -0.18132815f, 
    -0.09292626f, -0.15609859f, -0.17138606f, -0.07904455f, -0.06011444f, -0.09230704f, -0.14557745f, -0.17638417f, 
    -0.01975049f, -0.21709277f, 0.07258387f, -0.04900448f, -0.20831133f, 0.16808856f, -0.03331531f, -0.00935445f, 
    0.04865900f, -0.14656742f, -0.13201828f, 0.04441252f, 0.01137083f, 0.10413329f, 0.08452999f, -0.01445265f, 
    0.10442067f, 0.03934728f, -0.17017227f, -0.01455171f, 0.01917908f, 0.05266782f, -0.16095671f, 0.06292595f, 
    0.01348971f, -0.11010180f, 0.08412182f, -0.06026519f, -0.13476770f, 0.26137969f, 0.31191540f, 0.08201478f, 
    -0.13433695f, 0.25748530f, -0.12366280f, -0.02226457f, 0.10605596f, -0.17291851f, -0.12700406f, 0.08785374f, 
    0.20998533f, -0.48260510f, -0.04679276f, 0.20094961f, -0.08981003f, 0.11440701f, 0.17626552f, 0.11635046f, 
    0.26278508f, -0.26585725f, -0.30889446f, -0.28656581f, 0.29717317f, -0.24855727f, 0.21069729f, -0.13643037f, 
    0.10085166f, -0.13542472f, 0.00071037f, -0.13287520f, -0.05937082f, -0.10467411f, -0.12855494f, 0.12844278f, 
    0.01733625f, -0.12666366f, -0.14745815f, -0.09051006f, -0.05303315f, -0.07661650f, 0.02703961f, -0.15288658f, 
    0.05723993f, -0.14122956f, -0.10295126f, -0.07066341f, 0.07495547f, 0.02978625f, -0.01517404f, -0.16689986f, 
    -0.09496862f, -0.04772415f, 0.00108190f, -0.21140443f, -0.14304917f, -0.04365298f, 0.01727740f, 0.00790959f, 
    0.05439656f, 0.05105419f, -0.04020937f, -0.24241067f, -0.13428925f, -0.29752269f, -0.00082530f, 0.33718187f, 
    0.20401636f, -0.16267048f, -0.17058466f, 0.13719396f, 0.10462246f, 0.10824601f, 0.04068676f, 0.05816584f, 
    -0.07456282f, 0.15697277f, 0.08860572f, -0.19407229f, -0.19951387f, -0.16062593f, 0.18372567f, 0.11372904f, 
    -0.17908563f, 0.24120127f, 0.22540705f, 0.25867105f, -0.27507138f, -0.05523866f, -0.16302483f, -0.08263591f, 
    -0.25247410f, -0.10911055f, 0.05703364f, -0.01756186f, 0.22012667f, -0.47607297f, -0.01200047f, 0.09252440f, 
    0.07669052f, 0.10149316f, 0.09675737f, -0.04255027f, 0.24125707f, 0.04178045f, -0.10855163f, 0.16885617f, 
    0.29747841f, -0.08735190f, 0.22001562f, 0.05775596f, 0.10221657f, -0.12456667f, 0.13784856f, -0.12514964f, 
    -0.28637311f, -0.03579745f, 0.52610254f, 0.31198707f, -0.07569169f, -0.04246272f, -0.16025256f, 0.19135572f, 
    0.03861159f, -0.19787447f, 0.24305241f, -0.07809749f, 0.14121845f, -0.14760840f, -0.26040697f, 0.40164411f, 
    0.05107425f, -0.05270885f, -0.04035174f, 0.19161627f, -0.05420172f, -0.02398869f, -0.05716417f, 0.02588914f, 
    -0.21523681f, 0.41793287f, 0.15997708f, 0.21621756f, 0.07004278f, 0.15421279f, -0.01274996f, 0.00054057f, 
    -0.27621844f, 0.10266927f, 0.28683412f, 0.12487870f, 0.06010370f, 0.37146562f, -0.33626133f, 0.19719602f, 
    0.09047224f, 0.23260918f, -0.07709081f, 0.14437735f, 0.21063896f, 0.21233341f, -0.07081521f, -0.13437785f, 
    -0.06582194f, -0.42481166f, -0.04371009f, 0.25620791f, 0.24740900f, -0.01417768f, 0.05202075f, 0.33022279f, 
    0.18953837f, -0.03736432f, 0.03170695f, -0.01081509f, 0.01189149f, -0.02627802f, 0.32846799f, -0.45981517f, 
    -0.13384302f, 0.17778090f, 0.10058754f, 0.06130001f, -0.15350607f, -0.22157392f, -0.31582627f, 0.35635120f, 
    -0.22693598f, 0.24178261f, -0.05228673f, -0.30768985f, 0.06030649f, 0.13623384f, 0.22494249f, -0.36093333f, 
    -0.12487020f, 0.14729171f, -0.02711513f, 0.24034218f, -0.12038760f, -0.13121247f, -0.16482507f, 0.12161024f, 
    0.04567449f, -0.25265744f, -0.10513532f, 0.06937494f, 0.02908103f, -0.01655305f, 0.00932580f, 0.21810815f, 
    -0.16461559f, 0.01319439f, -0.41174096f, -0.45587096f, 0.19870237f, 0.16789944f, 0.16659421f, 0.42384359f, 
    -0.19675286f, 0.35629475f, -0.27488989f, -0.07055707f, 0.13155915f, 0.33576199f, 0.16107501f, -0.07727784f, 
    -0.05317787f, -0.29826212f, 0.02274466f, -0.02968854f, 0.24423331f, -0.11392231f, -0.10214055f, 0.37773442f, 
    0.27067649f, -0.04087279f, 0.14070784f, 0.07506210f, 0.18051001f, 0.03723183f, 0.21133959f, -0.17587888f, 
    0.10936259f, -0.06620161f, 0.22863698f, -0.13626243f, -0.16510633f, 0.01812260f, -0.15339510f, 0.31985569f, 
    -0.40578145f, 0.15018433f, 0.08235221f, -0.07615697f, 0.08268273f, -0.16475292f, 0.13274126f, 0.17822883f, 
    0.06130130f, 0.11127941f, 0.02630393f, 0.09321944f, -0.07060057f, -0.03496098f, 0.05527079f, 0.14120597f, 
    0.17168967f, -0.37911925f, -0.21465226f, 0.04659773f, -0.33483791f, 0.05134662f, 0.06933301f, 0.16733351f, 
    -0.31988543f, -0.06362066f, -0.17082407f, -0.00235366f, 0.04644199f, -0.16426943f, 0.06505831f, 0.37983704f, 
    0.37244487f, -0.09126379f, -0.17793703f, -0.15513249f, -0.11431190f, 0.09671764f, -0.14808786f, 0.06757025f, 
    0.13134840f, -0.00840699f, 0.14475821f, 0.34545407f, 0.06859849f, -0.17277995f, -0.15470901f, 0.00160515f, 
    -0.24719740f, -0.03283133f, 0.18432949f, 0.25146291f, 0.04554614f, 0.13930061f, 0.13715091f, 0.16573815f, 
    0.04252271f, 0.02152752f, -0.13639405f, -0.27229208f, -0.24764220f, 0.33874437f, 0.19819139f, -0.27477634f, 
    0.19819760f, -0.02699649f, -0.29457477f, 0.09159125f, -0.10073885f, -0.38840607f, -0.17175442f, -0.21256466f, 
    0.33158654f, 0.34571061f, -0.02558666f, 0.08421604f, 0.08202206f, 0.03707741f, -0.17945939f, 0.19184436f, 
    -0.08272095f, 0.01761655f, 0.08356594f, 0.11132085f, -0.08556334f, -0.16301811f, 0.06168028f, 0.00205233f, 
    0.06602865f, 0.25881246f, -0.28828269f, -0.08050762f, -0.30652601f, 0.20607346f, -0.14056787f, -0.18664469f, 
    -0.17546146f, 0.06199919f, -0.09521575f, -0.05040306f, -0.11047132f, -0.02984768f, 0.11925106f, -0.14999399f, 
    -0.19758108f, 0.10672165f, 0.15775235f, 0.07461267f, -0.05819064f, 0.03261220f, -0.09079504f, -0.15463533f, 
    -0.09996124f, -0.15805227f, -0.08994822f, -0.06782605f, -0.06531630f, -0.09156586f, 0.00027897f, -0.12656704f, 
    -0.12723449f, 0.00028929f, 0.02351002f, -0.00862566f, 0.06570539f, -0.04338035f, -0.11223044f, -0.00689931f, 
    -0.09039418f, 0.07175776f, -0.15949334f, 0.00637098f, -0.12023577f, -0.04997071f, 0.08870667f, -0.03792049f, 
    -0.08766373f, 0.05977138f, 0.08798947f, -0.17891978f, -0.13582642f, 0.13788797f, 0.07117726f, -0.13935678f, 
    -0.08790880f, -0.17082562f, -0.07153670f, -0.02545200f, -0.03564895f, -0.07925694f, -0.19649009f, -0.08503408f, 
    0.10991032f, 0.10044610f, 0.04737220f, -0.14518817f, 0.13388821f, -0.09762388f, -0.05623483f, 0.17690016f, 
    0.23484631f, -0.41980410f, -0.27560198f, -0.17454471f, -0.10155360f, -0.32859743f, -0.00240098f, 0.07140628f, 
    0.19267234f, 0.31333092f, 0.10570217f, 0.31154686f, 0.13678694f, -0.05014035f, 0.04799979f, -0.10177944f, 
    0.01879426f, 0.10296220f, 0.08666378f, 0.06286315f, -0.31247431f, 0.17665775f, -0.10948040f, -0.08777468f, 
    -0.32869932f, 0.07926312f, -0.02758959f, 0.10255023f, -0.26605791f, -0.01737169f, -0.01864655f, -0.09737541f, 
    -0.19335043f, 0.21537222f, 0.04761056f, 0.17024414f, -0.05818290f, 0.01345056f, 0.15921545f, 0.07471532f, 
    0.08605664f, -0.22493610f, -0.14612250f, -0.01394293f, 0.09115670f, 0.00042212f, 0.01118862f, 0.27507749f, 
    0.17263319f, -0.21760353f, 0.20416209f, -0.07149679f, -0.01168849f, 0.08923919f, 0.18696557f, -0.32696825f, 
    -0.13569114f, 0.07176695f, 0.54677135f, 0.24768971f, -0.06078107f, -0.14507414f, -0.23828751f, 0.32259560f, 
    -0.03676818f, -0.12373712f, 0.04827942f, 0.24493504f, 0.31039521f, 0.02987886f, 0.30221072f, -0.08506689f, 
    -0.12211131f, 0.07114015f, -0.10922834f, 0.13151839f, -0.18450126f, 0.04800548f, -0.03951534f, 0.04371268f, 
    -0.07242923f, -0.18454224f, 0.24242544f, 0.16524018f, 0.15537722f, 0.15163378f, -0.19634704f, -0.09037743f, 
    0.08547934f, -0.11552799f, -0.24313220f, 0.04717862f, -0.07700922f, -0.15250270f, 0.08214636f, 0.00941804f, 
    0.34590518f, 0.10262650f, -0.32663694f, -0.13026574f, 0.24979894f, 0.35485953f, 0.04502831f, -0.17059538f, 
    0.12665346f, 0.08258356f, -0.11723683f, 0.22955477f, 0.01586523f, 0.01274177f, -0.14994508f, 0.23571746f, 
    -0.26163697f, -0.24599473f, 0.01455110f, 0.00435292f, 0.14020845f, 0.07217592f, 0.17094205f, -0.12218390f, 
    0.17367099f, 0.21513386f, -0.34050211f, 0.00617270f, -0.46369654f, -0.09705280f, -0.01522053f, -0.23315769f, 
    -0.08427764f, 0.00014264f, 0.05911186f, 0.09896709f, 0.04304880f, 0.00337251f, -0.16921648f, -0.12043103f, 
    -0.17598462f, -0.14530951f, -0.11818828f, -0.09161449f, 0.05264998f, -0.04325480f, 0.05117807f, 0.01330188f, 
    -0.18172437f, -0.08285311f, 0.14775848f, 0.12152224f, -0.04777941f, 0.14917694f, -0.05444497f, -0.15880010f, 
    -0.10568050f, 0.07597191f, 0.00830272f, 0.07210557f, -0.18013729f, -0.07920904f, -0.01699081f, -0.05251880f, 
    0.12707543f, 0.01312968f, -0.09081812f, 0.19173788f, -0.18157133f, 0.04753350f, -0.01251629f, -0.15680227f, 
    0.07563968f, 0.19739285f, 0.00557226f, -0.17091283f, -0.08835308f, 0.05239256f, -0.12815750f, 0.00417930f, 
    0.07009548f, -0.06484184f, 0.00194648f, 0.17909184f, 0.31777918f, -0.15083712f, 0.14576903f, 0.22953874f, 
    0.19797134f, -0.28091857f, -0.22564419f, -0.03052799f, -0.04488797f, -0.24235198f, 0.04805726f, -0.01825724f, 
    0.16792735f, 0.00643452f, -0.23779756f, -0.02585215f, 0.07693017f, 0.20712036f, -0.26884633f, 0.05370245f, 
    0.10705873f, 0.04676540f, 0.05577260f, 0.12760381f, 0.17064911f, -0.08547715f, 0.01605969f, 0.37097678f, 
    -0.21893632f, 0.06306460f, 0.00355788f, -0.23254296f, 0.02961178f, 0.15122505f, 0.31320176f, 0.04360464f, 
    -0.11928032f, 0.21597685f, 0.10900033f, 0.29032964f, -0.22423805f, 0.31161523f, -0.02979482f, 0.11349336f, 
    -0.21197808f, -0.06911923f, 0.20349231f, 0.02955776f, 0.24600793f, 0.37373960f, -0.17550917f, 0.08802051f, 
    -0.15950593f, -0.31887680f, -0.11577549f, 0.23476595f, 0.12701133f, -0.07696586f, 0.08844367f, 0.24932681f, 
    0.21610044f, 0.08898924f, 0.18791951f, -0.02248640f, 0.09432953f, -0.11185781f, 0.17234719f, 0.06433561f, 
    0.18221517f, -0.27154741f, 0.04038531f, -0.22119263f, 0.08407857f, 0.39092362f, 0.05625743f, 0.19516781f, 
    -0.26762289f, 0.20826618f, 0.09648166f, 0.07580313f, 0.08225772f, -0.03516277f, -0.18682049f, 0.12124396f, 
    0.12647441f, -0.03194216f, 0.13367608f, -0.17801291f, -0.09875126f, 0.09566974f, 0.07821241f, -0.18306293f, 
    0.32408780f, -0.03830226f, -0.06527153f, -0.25083539f, 0.17208171f, 0.04446249f, 0.06742256f, -0.05604264f, 
    0.25396982f, -0.17309798f, 0.25724775f, 0.37513712f, 0.31542096f, -0.20272009f, 0.02456176f, 0.04511008f, 
    0.17209622f, -0.18215318f, 0.06620350f, -0.11187646f, -0.11876778f, 0.02718083f, 0.03793706f, -0.07676300f, 
    -0.15151343f, -0.20177719f, 0.07400426f, -0.18093714f, -0.20453750f, -0.07896022f, 0.11016723f, 0.16365442f, 
    -0.15083286f, -0.11778582f, 0.03647412f, -0.10056672f, 0.13157074f, 0.05371772f, -0.09098741f, 0.06577548f, 
    0.01959307f, -0.10015422f, 0.14334875f, -0.13746415f, -0.00061884f, -0.17285906f, -0.02106256f, -0.05442804f, 
    -0.02323165f, -0.20368645f, 0.16458270f, 0.15203451f, -0.09827045f, 0.12631346f, -0.09046326f, 0.05888894f, 
    -0.19185789f, 0.11526384f, -0.17296126f, -0.10443057f, -0.11370417f, -0.00967394f, -0.09619518f, -0.15343998f, 
    -0.17136849f, -0.16970380f, -0.00743550f, -0.00529077f, -0.14226335f, 0.05896909f, 0.05109201f, 0.12535042f, 
    -0.09958391f, -0.02923710f, 0.00933706f, -0.12878786f, -0.14661524f, -0.10591650f, -0.08727472f, -0.12747112f, 
    -0.02891477f, 0.06333534f, -0.07099301f, 0.10966011f, -0.27314979f, -0.22020501f, -0.16694221f, 0.11153472f, 
    -0.17923693f, -0.10033353f, -0.16421841f, -0.08752891f, -0.19275521f, -0.05051171f, -0.03997528f, 0.10645054f, 
    0.00385868f, 0.12111076f, 0.04548385f, 0.04619433f, 0.09731533f, -0.04944303f, 0.04840824f, 0.05964326f, 
    0.01985428f, -0.22169577f, 0.06824656f, -0.08633462f, 0.09949479f, -0.00130318f, -0.03664713f, -0.06968684f, 
    -0.03001253f, -0.11381150f, -0.10454800f, -0.24957444f, -0.09002422f, -0.19587375f, 0.32756534f, 0.24565195f, 
    0.24179009f, 0.24774575f, -0.11924506f, 0.08720210f, -0.17995551f, -0.10040033f, 0.16502272f, -0.14936739f, 
    -0.02474080f, 0.09354253f, 0.08415763f, 0.37778497f, 0.06297895f, -0.07824369f, 0.02525022f, 0.24505995f, 
    -0.13796686f, -0.14058782f, -0.34300277f, -0.28793779f, 0.02983646f, 0.00744499f, 0.20196195f, -0.16662438f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.05017490f, -0.18414958f, 0.16607837f, -0.12354853f, -0.10253172f, -0.09199871f, 0.29573929f, -0.16973419f, 
    0.11860839f, -0.00418640f, 0.37984675f, 0.02319173f, 0.14550124f, -0.01976553f, 0.05185980f, 0.26478022f, 
    0.11364943f, 0.19811721f, -0.00030964f, 0.04402055f, -0.09450513f, 0.14312167f, 0.19559138f, 0.26211435f, 
    -0.04992051f, 0.18360046f, -0.06399142f, -0.05832407f, 0.00519513f, 0.27910924f, 0.07427155f, -0.01230795f, 
    0.01936856f, -0.15524292f, 0.06650014f, 0.08068154f, -0.12938808f, -0.00977131f, 0.07217568f, -0.00114977f, 
    0.08655480f, 0.02748585f, 0.10685467f, 0.15698907f, 0.04307052f, 0.17718323f, -0.11104055f, 0.15176006f, 
    0.03630070f, -0.01471080f, -0.10876489f, 0.11779627f, 0.22524163f, 0.25577751f, 0.15669440f, -0.08182967f, 
    -0.03460535f, 0.01795258f, -0.02767144f, -0.18557408f, 0.02171084f, -0.20479053f, -0.14863616f, 0.19938648f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.08968293f, -0.16099007f, -0.08495897f, -0.08871282f, 0.25393459f, -0.21512683f, 0.01260529f, 0.06082690f, 
    0.24401678f, 0.17444094f, -0.10843686f, -0.03928130f, 0.09572385f, -0.04699464f, -0.10918385f, 0.30091852f, 
    0.23408286f, -0.34739417f, -0.04243322f, -0.12676637f, 0.20698111f, 0.30308115f, 0.09642149f, -0.05256519f, 
    -0.01588486f, -0.02592591f, -0.53286308f, -0.26656622f, 0.00961313f, 0.18386993f, -0.00345002f, 0.10146327f, 
    -0.03941125f, 0.09301753f, 0.12315927f, -0.13185859f, -0.17978069f, 0.12176237f, -0.05320576f, 0.06957759f, 
    0.06169044f, 0.09746239f, 0.08257236f, 0.10981802f, -0.00915203f, -0.14148943f, 0.18060966f, -0.00369458f, 
    -0.06581429f, -0.01672587f, -0.01871502f, 0.03009616f, 0.20236996f, 0.04778533f, -0.12176925f, -0.02121870f, 
    0.04164168f, -0.08926591f, 0.02932412f, 0.09906799f, -0.14946972f, 0.10904880f, -0.11918951f, 0.04601718f, 
    0.08703090f, 0.08915193f, -0.07407743f, -0.11825399f, -0.10625786f, 0.00529371f, -0.09781012f, 0.08417174f, 
    -0.07281093f, -0.00299962f, -0.00952803f, -0.00750369f, 0.09480233f, 0.01530373f, 0.05686523f, -0.07943065f, 
    -0.09703645f, -0.11225177f, 0.07966170f, 0.09930772f, 0.01974921f, -0.06912033f, 0.03015983f, 0.11235654f, 
    0.07498954f, 0.00448184f, 0.03788382f, -0.03839445f, 0.02853747f, -0.11639756f, 0.00794166f, -0.00831570f, 
    -0.11113599f, 0.11491196f, -0.02418266f, -0.01109013f, 0.02849434f, 0.04845387f, -0.05520546f, 0.12176898f, 
    -0.07402968f, -0.01591539f, 0.10715787f, -0.07431726f, -0.04376784f, -0.10904792f, -0.02723354f, -0.03048009f, 
    -0.11261298f, -0.02829483f, -0.03215297f, 0.11471096f, 0.07626221f, -0.10606757f, -0.11520298f, -0.07677627f, 
    -0.10330904f, -0.09207624f, -0.03774740f, -0.10892369f, -0.04216194f, -0.12227304f, 0.07053643f, -0.02998875f, 
    -0.14314827f, -0.13470256f, 0.10540888f, 0.32060766f, -0.06066985f, -0.08855226f, 0.08905540f, 0.11879332f, 
    -0.03720839f, 0.23975442f, -0.19510046f, 0.11375015f, 0.25188497f, 0.39183837f, -0.38166359f, -0.28776950f, 
    -0.14013696f, 0.11722430f, -0.00730746f, -0.07880417f, -0.14574614f, -0.30448410f, -0.23830129f, 0.17904326f, 
    -0.27727044f, 0.15657958f, 0.19963476f, 0.25774390f, -0.04856683f, -0.08296261f, 0.03832643f, 0.22947638f, 
    -0.11889187f, 0.00366454f, 0.06748897f, 0.00308776f, -0.00088912f, 0.12634562f, 0.34765449f, 0.03948408f, 
    -0.02657623f, -0.14751098f, -0.14250189f, -0.31925488f, 0.36628729f, -0.11335470f, 0.04736089f, 0.02385534f, 
    0.16848515f, -0.01995663f, -0.08954269f, -0.02569187f, -0.22107558f, -0.04972930f, 0.09740638f, 0.02692832f, 
    0.17920062f, 0.06038203f, 0.03117775f, -0.00056055f, 0.02488198f, 0.09346563f, -0.02497954f, 0.24324585f, 
    -0.03729521f, -0.11403197f, 0.11908567f, 0.01043515f, -0.02857720f, 0.00847495f, -0.14920160f, 0.01594938f, 
    -0.10328227f, -0.03811409f, 0.06099198f, 0.01699070f, -0.00075749f, -0.13152692f, -0.08549069f, -0.06606165f, 
    -0.15055342f, -0.11670362f, 0.07033899f, 0.00463231f, 0.01316711f, -0.05180581f, -0.07773383f, -0.01894815f, 
    -0.00202553f, 0.02390883f, 0.02877039f, -0.03463009f, 0.06826366f, -0.04800687f, -0.09606401f, 0.05731904f, 
    0.05658209f, -0.00318444f, -0.06042925f, -0.11659856f, 0.06197304f, -0.08670449f, 0.04536867f, 0.07806915f, 
    -0.06102827f, -0.01710925f, -0.10713479f, -0.07546942f, -0.03736228f, 0.05007873f, -0.06048546f, 0.02314411f, 
    0.03501379f, 0.09961845f, -0.00827025f, 0.00649645f, 0.03173088f, 0.00205501f, 0.06543722f, 0.03600856f, 
    0.03235479f, -0.00918747f, -0.15834607f, 0.06940392f, -0.11671795f, 0.00806366f, 0.09786780f, -0.10060503f, 
    -0.13205139f, -0.12939043f, 0.03457303f, -0.14838684f, 0.04170180f, -0.03377745f, -0.09785240f, -0.04274274f, 
    0.08563356f, -0.27015018f, 0.06333062f, -0.10555860f, -0.03413630f, -0.12030504f, 0.04302146f, -0.00473693f, 
    -0.09924088f, 0.12306372f, -0.03554437f, -0.00883980f, 0.04298624f, -0.06772748f, 0.02556408f, 0.04161084f, 
    0.02536298f, -0.19801345f, -0.06014754f, 0.12246367f, -0.00365001f, -0.03314377f, 0.04532928f, -0.00734497f, 
    0.10323389f, 0.06803972f, 0.05404629f, -0.03809616f, -0.00923572f, -0.09137931f, -0.25380197f, 0.10249119f, 
    0.06518976f, 0.04181540f, -0.21702722f, 0.03466132f, -0.05140907f, -0.19078109f, 0.08549786f, -0.21992260f, 
    -0.18193105f, -0.00395438f, -0.03824181f, -0.18706287f, -0.01970118f, -0.19600601f, -0.17976417f, -0.11324972f, 
    0.04723857f, -0.04906054f, -0.25726548f, 0.03283980f, -0.04241019f, -0.09360410f, 0.08953974f, -0.01403311f, 
    0.03424335f, -0.07745492f, 0.06694326f, 0.00588334f, -0.06362776f, -0.08223900f, -0.13471413f, -0.04431514f, 
    -0.06559441f, -0.11545880f, 0.07593609f, -0.06217882f, -0.11492480f, 0.01832870f, -0.00599603f, 0.01488983f, 
    -0.10284472f, 0.08313601f, -0.09219440f, -0.07925531f, 0.02485950f, -0.03348586f, -0.09854016f, 0.04776280f, 
    0.04575062f, 0.10187346f, 0.09340297f, 0.05471256f, -0.07780653f, -0.08283977f, -0.05560455f, 0.08325677f, 
    0.00483036f, -0.00022222f, -0.07056306f, -0.03033160f, -0.11508670f, 0.02929126f, -0.10367377f, 0.02640648f, 
    -0.12581360f, -0.09010077f, 0.00660032f, -0.10206023f, -0.11211340f, 0.01693868f, -0.09602974f, -0.06732649f, 
    0.08377135f, 0.05057569f, -0.10945746f, 0.12439622f, 0.04340747f, -0.11809048f, 0.09917738f, 0.11586682f, 
    -0.06879684f, -0.14009030f, -0.10186418f, -0.00474517f, -0.05019346f, 0.05812833f, -0.10977912f, -0.06971375f, 
    0.03210304f, -0.20870581f, -0.03077519f, 0.04379064f, -0.02171292f, -0.38080901f, 0.01201961f, -0.08567075f, 
    0.23793052f, 0.07704785f, 0.29367101f, -0.16851227f, -0.01102549f, -0.47260952f, 0.14182298f, 0.42059070f, 
    0.20325175f, -0.33514354f, -0.09777069f, -0.15767518f, 0.19241756f, 0.07891796f, 0.16273984f, -0.00188290f, 
    0.00111232f, 0.04956673f, -0.44852719f, -0.41790247f, -0.03952828f, 0.25479707f, 0.15351930f, 0.06822816f, 
    -0.03341083f, -0.08935703f, 0.05048834f, 0.08699179f, 0.18158205f, -0.10092902f, -0.08416181f, -0.11304986f, 
    -0.04795452f, 0.12453593f, 0.14500229f, -0.18836114f, -0.44418266f, -0.31586093f, -0.06844614f, -0.17089392f, 
    0.02187505f, -0.06854771f, 0.03403522f, 0.12844567f, 0.03902776f, 0.14468804f, -0.34914789f, -0.01933295f, 
    -0.23616846f, -0.17380953f, 0.06648984f, -0.03008214f, -0.00627426f, -0.09524547f, 0.15409504f, -0.03445075f, 
    -0.05518263f, -0.27508965f, -0.08538672f, 0.25146240f, 0.33006108f, -0.27538675f, -0.04299113f, 0.01560872f, 
    0.24558376f, 0.26128474f, -0.31861758f, -0.08897119f, 0.15120742f, 0.16028057f, -0.13116705f, 0.02041813f, 
    0.00766780f, 0.01046609f, 0.18119933f, 0.13096395f, 0.03090824f, -0.20765947f, -0.02711172f, 0.01323656f, 
    -0.13813984f, -0.10947836f, -0.06321322f, 0.42155951f, -0.11338942f, -0.07170384f, -0.19641934f, 0.38855863f, 
    -0.01331536f, 0.11156753f, 0.00041373f, 0.14294757f, -0.25563729f, -0.05605055f, 0.14289111f, 0.08647045f, 
    0.07633429f, 0.12039381f, 0.01401984f, 0.18013349f, 0.29385880f, 0.23181632f, 0.02622559f, 0.02485086f, 
    -0.10684881f, 0.04265667f, 0.03917735f, -0.18265052f, 0.00169668f, 0.12140716f, -0.17787524f, 0.02228623f, 
    0.00316593f, -0.22816665f, 0.10377548f, 0.06824946f, 0.02952479f, -0.09470361f, -0.03445049f, 0.16890740f, 
    -0.01098643f, -0.16218232f, 0.08600253f, -0.14034112f, 0.43254310f, 0.00628079f, 0.05141521f, -0.07553359f, 
    0.22398397f, 0.01387031f, 0.02745704f, 0.04195047f, -0.14507242f, -0.05331540f, 0.08854858f, -0.05993695f, 
    -0.14681572f, -0.27809340f, 0.25487608f, 0.15040053f, -0.11523613f, 0.14247702f, 0.32750657f, 0.06634557f, 
    -0.27339152f, -0.00890477f, -0.29850858f, -0.36881110f, 0.12590788f, 0.12523149f, -0.10196503f, 0.13873504f, 
    0.12821238f, 0.10227308f, 0.00081407f, 0.10329883f, -0.13505855f, 0.06397069f, -0.18218876f, 0.07206668f, 
    0.17299002f, 0.21797903f, 0.07825160f, 0.34273809f, -0.16292344f, 0.25035501f, 0.19775173f, -0.17310202f, 
    -0.17240711f, 0.03061062f, -0.06282025f, 0.00618823f, 0.27581218f, 0.13302557f, -0.05211309f, 0.04942169f, 
    -0.21896601f, 0.17941572f, 0.19728458f, 0.00782972f, 0.00755395f, 0.11282592f, 0.11826589f, -0.17220569f, 
    -0.42092213f, -0.18569699f, 0.03439533f, 0.35977611f, 0.16616172f, -0.26782927f, -0.16005844f, 0.05663789f, 
    0.26193884f, 0.50728881f, -0.16392571f, -0.18504164f, 0.33152112f, -0.10298260f, -0.15782897f, -0.12474054f, 
    0.27590290f, -0.28733918f, 0.03172056f, -0.02917522f, 0.08169177f, -0.00686118f, 0.05434817f, -0.00666055f, 
    -0.17023675f, 0.05813265f, -0.01493559f, 0.11074443f, 0.03173534f, -0.11155082f, 0.02078923f, 0.11473566f, 
    0.08907713f, -0.00908345f, 0.05643488f, -0.09217494f, -0.06515405f, 0.01405260f, -0.24041416f, -0.04638952f, 
    0.11134886f, 0.01587427f, 0.35248962f, 0.04000003f, -0.12699190f, 0.05908102f, -0.30936334f, 0.14798160f, 
    -0.09144054f, 0.07386869f, -0.05754150f, -0.11301979f, 0.08063492f, -0.10942335f, -0.13535798f, -0.02088685f, 
    -0.30056986f, 0.07067132f, 0.26864448f, -0.21937369f, -0.07851426f, 0.11758697f, -0.02718739f, -0.04042199f, 
    0.20522843f, -0.04594276f, -0.01417327f, -0.30601823f, -0.09016600f, 0.07874285f, 0.21324797f, -0.07235989f, 
    0.04461310f, -0.14349565f, 0.47099856f, 0.36728266f, 0.08432014f, -0.06103712f, 0.10264083f, 0.18870355f, 
    0.08802190f, -0.01573934f, 0.13627163f, 0.27160406f, -0.08585856f, 0.17683280f, 0.22218995f, 0.27380148f, 
    -0.10611780f, 0.35767862f, -0.15966417f, -0.26957327f, 0.03219280f, 0.29354963f, 0.33260095f, -0.22137161f, 
    0.01714876f, 0.06397180f, 0.07837579f, -0.03949061f, -0.00009729f, -0.10136125f, 0.11732411f, -0.05851022f, 
    0.06118915f, 0.17969811f, 0.07067079f, 0.02262552f, -0.24830800f, 0.00514146f, 0.00610845f, 0.19896747f, 
    0.18026900f, -0.06647667f, 0.00754283f, 0.41497621f, -0.07631487f, 0.27484599f, 0.25008148f, -0.00841389f, 
    -0.02751378f, 0.16336749f, -0.20321192f, 0.00448550f, 0.03239930f, -0.00789198f, 0.02885809f, 0.18542817f, 
    0.07516551f, -0.06292265f, 0.10792761f, -0.08401853f, 0.01492967f, 0.01186504f, -0.12906821f, 0.08134732f, 
    -0.04318771f, -0.11270884f, -0.00031127f, -0.11047893f, 0.07229950f, 0.00456565f, -0.09260455f, 0.05736028f, 
    0.04552237f, -0.06050275f, -0.05446580f, -0.12674053f, -0.02378057f, -0.14289486f, -0.10821219f, -0.09256406f, 
    -0.04812264f, 0.08777536f, 0.13334191f, -0.04672217f, -0.04378746f, -0.09872166f, 0.02596449f, -0.00403634f, 
    0.10860667f, 0.01776455f, 0.12209985f, -0.14574663f, -0.12964109f, -0.03289805f, 0.03095632f, 0.09829323f, 
    -0.10810219f, 0.03843662f, -0.14631571f, 0.00501655f, 0.05261438f, 0.06206283f, -0.06530697f, -0.03062384f, 
    -0.11330765f, 0.02444245f, -0.08628806f, -0.07048801f, -0.04227210f, 0.00090826f, -0.01769705f, -0.03534089f, 
    0.07925572f, -0.05968167f, 0.02737947f, 0.01380724f, 0.09687302f, 0.00065723f, -0.01310409f, -0.11872457f, 
    0.38335335f, -0.18966344f, 0.02644168f, -0.19989152f, -0.11504706f, 0.24112430f, -0.00613891f, 0.00880699f, 
    -0.15846936f, -0.00370530f, 0.26372820f, 0.10754465f, -0.07649162f, 0.20507272f, 0.18382947f, -0.07016170f, 
    0.21394008f, -0.00993341f, -0.09906378f, -0.13079681f, 0.42836592f, 0.26068121f, -0.21132855f, -0.13722949f, 
    0.36207163f, -0.10776517f, -0.08973050f, -0.13929912f, -0.07226754f, 0.21680887f, 0.23821753f, 0.01313806f, 
    0.05115116f, 0.04460046f, 0.05616109f, -0.01098902f, 0.36989740f, 0.14362741f, 0.10295346f, -0.10530625f, 
    -0.24676403f, 0.05201149f, -0.04379788f, -0.01952840f, -0.10638361f, -0.02212324f, -0.40879026f, 0.07183504f, 
    -0.29968548f, -0.04525782f, -0.04608633f, -0.39581367f, -0.14419958f, 0.03724003f, -0.18276103f, 0.02950021f, 
    0.12320485f, -0.10746832f, 0.26536259f, -0.27086037f, 0.01006947f, 0.04640067f, 0.13557981f, -0.13811234f, 
    -0.30980417f, 0.15806420f, -0.01472014f, 0.31933790f, 0.01849291f, -0.14164433f, -0.44876298f, -0.04705478f, 
    0.18065245f, 0.23226944f, 0.03594634f, -0.25547576f, 0.17241798f, -0.08324674f, -0.15736823f, -0.03509765f, 
    0.23071446f, -0.25272226f, -0.08112967f, -0.20576721f, 0.19988194f, -0.01677921f, -0.08490315f, -0.55317551f, 
    -0.02210775f, -0.09474146f, -0.21957855f, -0.08815060f, 0.12477536f, 0.11503899f, 0.08261181f, 0.13117987f, 
    0.01750848f, -0.09057041f, 0.10121541f, 0.07340422f, -0.04409662f, 0.00468565f, -0.34670106f, -0.04780955f, 
    0.06157779f, 0.15684603f, 0.26548144f, 0.20742324f, -0.22177127f, 0.09916911f, -0.08830654f, -0.38904747f, 
    -0.31420246f, 0.02011909f, 0.08160608f, 0.09712341f, 0.13493763f, -0.16431685f, -0.69282943f, -0.04511007f, 
    -0.41532415f, -0.16646187f, -0.03185546f, -0.05711147f, 0.02645610f, -0.07037424f, -0.13215910f, -0.24102534f, 
    -0.12053157f, -0.10209887f, 0.08561917f, 0.20129938f, 0.02246313f, -0.31516474f, -0.11444978f, 0.05406564f, 
    0.07924761f, 0.09161683f, -0.12836750f, 0.17071857f, 0.13231611f, -0.17601319f, 0.02888655f, -0.10035592f, 
    0.16942033f, 0.19180401f, -0.04588246f, 0.23762968f, -0.29682630f, -0.18868642f, 0.33999336f, 0.01044238f, 
    -0.33305225f, 0.01636932f, 0.04256072f, 0.36141914f, -0.09312091f, -0.22089559f, -0.07804601f, 0.22279736f, 
    0.08912063f, -0.05710147f, -0.03802858f, -0.15140596f, -0.22619385f, 0.12530132f, 0.00322342f, 0.10058910f, 
    0.10500518f, -0.04997505f, 0.20064178f, 0.01374230f, 0.00408773f, 0.18337837f, -0.20388925f, 0.21897435f, 
    0.14026491f, -0.09406219f, -0.07602313f, 0.17515920f, -0.06596511f, -0.09229933f, -0.09891897f, -0.02976037f, 
    0.03129727f, 0.05083014f, -0.11319724f, -0.01768674f, -0.11995852f, -0.08860067f, -0.03549589f, 0.20172189f, 
    0.05794469f, -0.10690355f, 0.10405254f, 0.22929832f, -0.01037550f, 0.09622703f, -0.13412297f, 0.02109422f, 
    0.11745395f, 0.18974043f, 0.04295307f, -0.05834423f, 0.04155967f, 0.16241004f, -0.11728603f, -0.03573322f, 
    0.01808586f, 0.10046655f, -0.00130838f, -0.29660070f, 0.30321583f, 0.26874870f, -0.05479452f, -0.10108601f, 
    0.17724580f, -0.06433964f, -0.00691075f, 0.31125921f, -0.00678214f, -0.05293224f, 0.21872781f, 0.07766491f, 
    0.06368862f, 0.06181516f, 0.01475450f, 0.04550748f, 0.18888193f, 0.06991142f, 0.21093343f, 0.10771626f, 
    -0.33505732f, -0.00494841f, 0.12292819f, -0.02214418f, 0.40486065f, 0.07332421f, 0.08500186f, 0.07358732f, 
    0.07461379f, 0.07180985f, 0.04803074f, -0.51452380f, -0.16594061f, 0.06398428f, -0.00213030f, 0.10271136f, 
    0.04875586f, -0.07773980f, 0.24936406f, -0.14739855f, -0.02173337f, -0.05716081f, -0.07913096f, 0.14167373f, 
    -0.06971800f, -0.10178438f, 0.11345419f, -0.04560857f, 0.04471286f, -0.03658275f, -0.05408479f, 0.02308732f, 
    0.01687234f, -0.05568282f, 0.03125795f, 0.08802468f, -0.02719841f, -0.02527145f, 0.07734938f, -0.04880787f, 
    -0.11330890f, 0.10922891f, -0.15332608f, 0.00836404f, -0.05837762f, -0.01941537f, 0.07361410f, -0.12675415f, 
    0.01268536f, -0.12842369f, -0.04926363f, 0.05853003f, -0.05179228f, -0.01859704f, 0.08709382f, 0.07633203f, 
    0.06951134f, -0.02563328f, -0.09682111f, -0.05586834f, -0.15103281f, -0.10135201f, -0.06423667f, 0.08775260f, 
    -0.10852040f, -0.17573996f, -0.08437438f, -0.09089283f, 0.04882665f, 0.00660940f, 0.09080596f, -0.09311207f, 
    -0.08520505f, -0.06591761f, 0.12089612f, -0.00647187f, -0.04224748f, -0.02525836f, -0.08615290f, -0.11212181f, 
    -0.01319298f, -0.10026480f, 0.00664486f, -0.01269097f, -0.02194668f, 0.11178201f, -0.03230233f, -0.12261231f, 
    0.00933908f, -0.16282362f, -0.11673158f, 0.03851676f, -0.00130324f, 0.12771541f, 0.02897138f, -0.02998241f, 
    0.15227719f, 0.00912069f, -0.20514360f, 0.11464378f, 0.03317946f, 0.27923334f, -0.09400051f, -0.04810806f, 
    -0.23195766f, -0.61226392f, 0.11452113f, -0.05576352f, 0.20421642f, 0.16508785f, -0.18103929f, 0.27675125f, 
    -0.07076883f, 0.53562397f, -0.08150228f, -0.30571267f, 0.12107831f, 0.25314018f, 0.46960673f, -0.03289412f, 
    0.03118712f, 0.03887528f, -0.05738690f, -0.01233041f, -0.05818933f, -0.12166291f, -0.10867124f, -0.14614615f, 
    -0.17723665f, -0.09393290f, 0.04426239f, 0.15059823f, 0.09983646f, 0.01412900f, -0.12346566f, 0.12201860f, 
    -0.05265402f, 0.11052515f, 0.06610881f, -0.19273104f, -0.07993659f, 0.27692708f, 0.37205917f, 0.08342088f, 
    -0.18990174f, -0.05371035f, 0.03508623f, -0.26152772f, -0.12631010f, -0.08597845f, -0.04282890f, 0.11003606f, 
    0.01283532f, 0.04771071f, -0.03804755f, -0.04918040f, -0.02730846f, -0.05934729f, -0.06911880f, -0.09610906f, 
    -0.07100643f, -0.06157383f, 0.00462644f, -0.11556517f, -0.06090915f, -0.12817943f, 0.03007440f, -0.13987562f, 
    -0.07640876f, -0.09501445f, -0.05785754f, 0.08308701f, -0.11889218f, 0.01871204f, 0.07795376f, -0.01405828f, 
    -0.15538393f, 0.01745766f, 0.00734189f, -0.08642232f, 0.05407503f, 0.06517968f, -0.06815863f, -0.08829637f, 
    -0.08515507f, -0.06248836f, 0.12313886f, -0.03695979f, -0.08488195f, 0.11320002f, 0.03491113f, -0.06466363f, 
    -0.14198023f, -0.06621093f, -0.05683993f, -0.04735620f, 0.00640387f, -0.10870387f, -0.06357007f, -0.07136030f, 
    -0.10551127f, -0.10090983f, -0.00789689f, 0.08179581f, 0.09492359f, -0.04529287f, 0.08180413f, 0.08151267f, 
    -0.10408008f, -0.14733920f, 0.06776761f, 0.05450483f, -0.05696118f, -0.03534353f, 0.09787728f, 0.02535029f, 
    -0.16160543f, -0.30974847f, 0.02655049f, -0.02397149f, 0.23219155f, 0.21557195f, 0.13255183f, 0.00999990f, 
    0.17474994f, 0.19763607f, 0.06850637f, -0.17579179f, 0.09598061f, -0.13828686f, -0.01069630f, 0.25768062f, 
    0.25126654f, -0.34304869f, 0.05593457f, 0.02241425f, 0.08418516f, 0.26761734f, 0.22418348f, -0.02890572f, 
    -0.26140058f, 0.22581220f, -0.53817987f, -0.30092046f, 0.11959626f, 0.22420117f, -0.00487254f, 0.01587851f, 
    0.06015543f, 0.00782178f, 0.07108358f, -0.12932949f, -0.31982327f, -0.11400454f, -0.14561525f, -0.13548641f, 
    0.14168686f, -0.05632130f, 0.20460603f, 0.08983236f, -0.12207232f, 0.06519068f, 0.29923603f, 0.08824531f, 
    -0.18399453f, -0.08663762f, -0.16424859f, 0.00580611f, 0.04725400f, 0.19175276f, 0.08096880f, -0.04870999f, 
    -0.23570313f, -0.03217063f, 0.01221139f, -0.12427850f, -0.06534414f, -0.12373254f, -0.08536065f, 0.11832505f, 
    -0.16969387f, -0.11934789f, 0.08789489f, 0.27891761f, 0.05520609f, -0.69602066f, 0.02100348f, 0.02196577f, 
    -0.00731956f, 0.14079966f, -0.17433904f, 0.27610555f, 0.32756335f, 0.09300616f, -0.10180083f, -0.24302204f, 
    0.18606555f, 0.16667897f, -0.21909989f, 0.37109309f, -0.04349960f, -0.09328110f, 0.36214900f, 0.01535906f, 
    -0.35470802f, 0.12021056f, -0.12072223f, 0.35883760f, 0.11114625f, -0.03031392f, -0.21429655f, 0.19184428f, 
    0.00139220f, 0.07068574f, -0.10333660f, -0.17730311f, 0.07891085f, -0.04378226f, 0.05479295f, 0.03782408f, 
    0.08697733f, -0.05899613f, 0.06457337f, -0.18133461f, -0.05040004f, -0.23942707f, -0.13383321f, 0.31901973f, 
    0.22936748f, -0.05526461f, 0.02844132f, 0.17439763f, -0.25050804f, -0.24747722f, -0.03818670f, -0.13092373f, 
    0.11428438f, 0.12221805f, 0.09376950f, -0.23616029f, -0.10197333f, -0.07663380f, -0.14038625f, 0.23969057f, 
    0.07306119f, -0.20397063f, -0.08034749f, 0.14228742f, -0.13715187f, 0.05253353f, -0.07793294f, -0.03404594f, 
    0.13119884f, 0.14878838f, 0.11556811f, -0.19308510f, 0.22153771f, 0.04063426f, 0.04973070f, 0.07654725f, 
    0.18169497f, 0.06516890f, 0.05463944f, -0.02141786f, 0.38998947f, 0.13271120f, -0.25850996f, -0.01370870f, 
    0.21888785f, -0.02557574f, 0.00158128f, 0.11287066f, 0.11579230f, 0.17066428f, 0.10814799f, 0.10158939f, 
    0.00028184f, 0.06238966f, 0.04211068f, 0.12826075f, 0.25078720f, 0.02291679f, 0.10762256f, -0.03453502f, 
    -0.28811285f, 0.00302160f, 0.13325098f, -0.20702951f, 0.28418729f, -0.21565092f, -0.09724416f, 0.16304909f, 
    -0.05370710f, 0.06825568f, 0.03200783f, -0.31626481f, -0.07707946f, 0.11560450f, -0.25407201f, -0.12019699f, 
    -0.08167551f, -0.24312031f, 0.14411564f, -0.18063164f, 0.15734173f, 0.05319767f, -0.11185434f, 0.17240132f, 
    0.03747118f, -0.00835278f, 0.06116216f, 0.09420140f, 0.21256886f, -0.08483039f, -0.11364368f, -0.17443877f, 
    0.22327435f, -0.00576537f, 0.00511614f, -0.03520719f, -0.12348367f, -0.40563864f, 0.03095944f, 0.11442677f, 
    0.07881539f, 0.10499598f, 0.13338707f, 0.07045748f, 0.17815340f, -0.17288698f, -0.00869456f, -0.11872568f, 
    0.17726757f, -0.39871192f, -0.19027452f, -0.39393443f, 0.05957780f, 0.05386328f, -0.24282242f, 0.02594975f, 
    -0.10842147f, 0.09527731f, -0.01167253f, 0.19652832f, 0.08349739f, 0.09535579f, -0.06176079f, -0.10991373f, 
    -0.02609921f, 0.20828477f, 0.10381277f, 0.11034387f, -0.62293750f, 0.04194545f, -0.03747312f, -0.42809874f, 
    -0.34232545f, 0.08904885f, 0.05992092f, -0.05045523f, 0.22901352f, 0.00242926f, -0.27197823f, 0.08086893f, 
    -0.11426748f, -0.03609675f, -0.01677405f, 0.21929821f, -0.06387054f, 0.09417170f, -0.13594982f, -0.22430122f, 
    -0.10096110f, 0.00434504f, -0.11446703f, -0.13126637f, -0.10216616f, -0.08326907f, -0.09535499f, 0.07090867f, 
    -0.08817635f, 0.09219982f, -0.11033488f, -0.11756922f, -0.10929447f, -0.02700564f, -0.15919968f, -0.06398650f, 
    0.02500451f, 0.06222566f, 0.06372982f, 0.06174733f, -0.02805988f, -0.10586376f, -0.03911444f, 0.05761707f, 
    -0.01073167f, 0.08380235f, -0.01677500f, 0.00281998f, -0.12176087f, -0.06611573f, -0.09276409f, 0.04358589f, 
    -0.03087077f, -0.10147719f, -0.02552059f, -0.01747574f, -0.02183562f, 0.00535572f, 0.01179415f, -0.08900467f, 
    -0.13094014f, -0.01471483f, -0.09826928f, 0.04075025f, -0.02171496f, 0.08003980f, 0.06673700f, -0.00821688f, 
    -0.10652140f, 0.07947713f, -0.01496595f, 0.02861383f, 0.02862185f, -0.08041720f, -0.01538878f, 0.07687037f, 
    -0.04177798f, -0.09442255f, 0.04898656f, -0.09966802f, 0.09476937f, -0.05502692f, 0.03326694f, -0.04053596f, 
    0.10409911f, -0.08233882f, 0.00068050f, 0.07396434f, 0.02564717f, -0.24005052f, -0.20950110f, -0.10909161f, 
    0.16454853f, 0.09440452f, 0.18410406f, -0.24113515f, 0.07603329f, -0.66114801f, 0.20588203f, 0.25632086f, 
    0.09732360f, 0.03340454f, 0.11735487f, -0.23893525f, 0.16926369f, 0.01623823f, 0.01260278f, -0.32015839f, 
    0.12869948f, -0.19526495f, -0.05994111f, -0.41735157f, 0.15050346f, 0.03805485f, 0.06358739f, 0.12192635f, 
    -0.05281933f, -0.04502866f, 0.02375780f, 0.08739963f, 0.07291336f, 0.06730575f, -0.06398022f, 0.11719788f, 
    -0.17571966f, 0.22257422f, 0.02773119f, -0.03863950f, -0.47947028f, 0.01928207f, -0.01652659f, -0.48391411f, 
    -0.35775483f, 0.10088967f, -0.03473894f, -0.08731287f, 0.10250358f, 0.02379594f, -0.59022927f, 0.12344379f, 
    -0.18226250f, -0.21539806f, 0.18752651f, 0.20815748f, 0.08913264f, -0.09837012f, -0.08986419f, -0.07354055f, 
    -0.05380239f, -0.02750556f, -0.02883999f, -0.10179348f, -0.06905460f, 0.09125924f, 0.09723134f, -0.10086143f, 
    -0.04988209f, -0.09560266f, 0.02498106f, -0.09889769f, -0.02731825f, -0.12299722f, -0.07040663f, 0.07401719f, 
    -0.01451143f, -0.00725298f, -0.02376068f, -0.06548232f, 0.00606376f, -0.11104959f, 0.08691020f, 0.01255314f, 
    0.09473816f, 0.03536499f, 0.03217638f, -0.05249611f, 0.05305712f, -0.02113109f, -0.04390042f, 0.01831904f, 
    -0.07350630f, 0.12003542f, 0.07940987f, 0.03910388f, -0.13250273f, 0.03414297f, 0.10377596f, -0.08135131f, 
    -0.00517858f, -0.03513094f, -0.01013828f, -0.03472300f, -0.08848314f, -0.13792531f, -0.10068384f, -0.04005387f, 
    0.00847306f, 0.10262090f, -0.09423641f, -0.13562512f, -0.08209016f, -0.01431371f, -0.00016523f, -0.01607151f, 
    0.04985139f, -0.08653433f, 0.10751859f, -0.11021025f, 0.07917488f, -0.07334274f, -0.10403232f, -0.07134262f, 
    0.43970719f, -0.03559625f, -0.04335248f, -0.06919928f, -0.13619320f, 0.10154594f, 0.09056455f, 0.06878064f, 
    0.10172431f, -0.05591758f, 0.27878225f, -0.10524464f, -0.14781424f, 0.05928302f, 0.25774670f, 0.30353698f, 
    0.19130264f, 0.13225384f, -0.01487518f, -0.16721249f, 0.44035378f, 0.20238520f, -0.43522274f, 0.02871633f, 
    0.40796196f, -0.00577735f, 0.02648609f, -0.14504755f, -0.12869385f, -0.00002900f, 0.23791164f, -0.05451602f, 
    -0.08991191f, 0.05148838f, -0.07719298f, 0.07016423f, 0.46675056f, 0.06960759f, 0.16347116f, 0.06822855f, 
    -0.35516146f, -0.05051206f, 0.07893116f, -0.31017649f, -0.14140315f, -0.03957989f, -0.15744106f, -0.00553037f, 
    -0.10166558f, -0.09770234f, -0.00202184f, -0.49889487f, -0.00127179f, 0.12324394f, 0.00831946f, -0.16435963f, 
    0.25333917f, -0.27505594f, 0.10649128f, 0.15013883f, -0.09649526f, 0.03556415f, -0.02022347f, -0.03150242f, 
    0.29177839f, -0.04975237f, -0.07085016f, 0.34806082f, -0.09415679f, 0.33052179f, -0.06104744f, -0.17564499f, 
    0.05150877f, 0.02550589f, -0.36795986f, -0.01512632f, 0.21679592f, 0.04428212f, 0.03260975f, -0.28988019f, 
    -0.17636979f, -0.02054645f, 0.13744754f, -0.13673870f, 0.28349093f, 0.04863873f, -0.20604186f, 0.08911741f, 
    0.26987046f, 0.08655492f, 0.07324907f, 0.29562482f, -0.06193674f, -0.00479768f, -0.10060073f, 0.11200539f, 
    -0.09047105f, 0.07564294f, 0.00355308f, 0.25576067f, 0.27303350f, 0.00748762f, 0.20920360f, 0.07690506f, 
    -0.30456400f, -0.19023795f, 0.04640164f, -0.07178923f, -0.00857464f, 0.13245076f, -0.05725240f, 0.01432793f, 
    -0.11447050f, 0.00605131f, 0.12767512f, -0.38914219f, -0.07294347f, -0.02391859f, 0.11188018f, 0.00242980f, 
    -0.21404667f, -0.06502553f, 0.32461685f, -0.06381545f, 0.05813136f, -0.03447504f, -0.02475244f, 0.05891927f, 
    0.22597697f, -0.27040306f, -0.04630203f, 0.27952668f, 0.13219349f, 0.05460865f, -0.05625145f, 0.00621443f, 
    0.02515842f, 0.14145018f, -0.33398679f, -0.09353939f, 0.12754454f, -0.13772860f, 0.06523896f, -0.27562621f, 
    -0.11262992f, 0.26490724f, 0.11030927f, 0.18259001f, -0.07515357f, -0.00199439f, 0.06768995f, 0.11090101f, 
    0.10936879f, -0.08763634f, 0.16829076f, 0.38067997f, -0.13816200f, -0.14685585f, -0.40240651f, 0.25068852f, 
    0.12518667f, -0.04079877f, -0.09188248f, 0.11792050f, -0.15055785f, -0.04503089f, 0.27698627f, -0.07607970f, 
    -0.06331131f, 0.01271623f, 0.01208234f, 0.18708891f, 0.14983405f, 0.25322396f, -0.06946728f, 0.01771418f, 
    -0.12128518f, 0.02252763f, -0.01772200f, -0.19694142f, 0.17544711f, 0.04947026f, 0.01904060f, -0.05301165f, 
    -0.00294441f, -0.00516846f, 0.28926790f, -0.19398417f, 0.09124877f, 0.04453334f, -0.17609115f, 0.15844095f, 
    0.22084443f, -0.40178552f, 0.01933266f, -0.18687476f, 0.07410028f, -0.26513296f, -0.01617168f, -0.15536766f, 
    0.06917747f, 0.06744044f, 0.08705549f, -0.26118878f, 0.16030468f, -0.01403357f, 0.09003405f, 0.31052577f, 
    0.15237898f, 0.16763097f, 0.07824131f, -0.11723340f, 0.21082985f, 0.28845641f, -0.10243796f, 0.00407491f, 
    0.17337173f, -0.18376100f, -0.27264446f, -0.17327753f, 0.00153435f, 0.20476146f, 0.11730915f, 0.08538145f, 
    -0.08146448f, 0.08952795f, 0.10375965f, 0.09666029f, 0.01822198f, -0.06359453f, 0.12553312f, -0.11850584f, 
    0.00975463f, 0.06241666f, -0.08760104f, -0.18978423f, 0.09684795f, -0.11612741f, 0.21130218f, -0.10554475f, 
    -0.22554639f, -0.01959801f, 0.11350153f, -0.27793059f, -0.12130941f, 0.22495538f, -0.12416618f, -0.13958006f, 
    -0.06406959f, -0.34487787f, 0.06659298f, 0.06650267f, -0.05967077f, 0.04524823f, 0.01988938f, 0.07755948f, 
    0.05209994f, 0.03084294f, 0.00890816f, -0.12120253f, -0.13562337f, 0.12489353f, -0.15169363f, -0.05957905f, 
    -0.00189164f, 0.11531661f, 0.03023191f, 0.07092737f, -0.04555941f, 0.07884120f, 0.07608403f, -0.07733364f, 
    0.05751154f, 0.01340492f, 0.04151480f, -0.08717277f, -0.00984425f, -0.13207574f, 0.06172601f, -0.10717339f, 
    0.02016190f, 0.02988208f, -0.10983824f, 0.00044207f, 0.09805520f, -0.09124723f, -0.06032230f, -0.06508606f, 
    -0.09165200f, 0.09619568f, 0.08708364f, 0.09203529f, 0.00492440f, 0.11423393f, -0.06662982f, -0.02952350f, 
    -0.00178074f, -0.10373082f, -0.01197795f, 0.04043483f, 0.08310830f, -0.05568826f, -0.03898512f, -0.01780776f, 
    0.06840165f, -0.02112436f, 0.07984320f, -0.04483804f, -0.01442706f, 0.02449873f, -0.08661895f, -0.11463946f, 
    -0.14374058f, -0.05363439f, -0.12897921f, -0.05255387f, 0.00727995f, 0.08776209f, 0.00076082f, -0.01481352f, 
    -0.29683009f, -0.41888919f, -0.04912991f, 0.05321271f, 0.00511006f, 0.12648852f, 0.09873112f, 0.10458922f, 
    0.03617628f, 0.17994866f, -0.04694464f, -0.06912389f, 0.17343856f, 0.19430366f, -0.13786867f, 0.21764040f, 
    -0.04840582f, -0.20027967f, 0.04236253f, 0.02137852f, -0.28940022f, -0.11321252f, 0.08671112f, 0.16918223f, 
    -0.51455396f, 0.27518880f, -0.22362867f, 0.18551673f, -0.10086595f, 0.02845383f, 0.09580397f, 0.16731448f, 
    -0.05261092f, 0.05056427f, 0.11917865f, -0.25493354f, -0.53282058f, -0.01494595f, 0.11976571f, -0.00450128f, 
    0.09122879f, 0.15066163f, 0.07052005f, 0.11977146f, 0.19973481f, -0.05023995f, 0.01265166f, 0.12201186f, 
    0.09246994f, -0.11064592f, 0.07122356f, 0.38809109f, -0.05708307f, 0.02651553f, -0.02002345f, -0.02489784f, 
    0.08003893f, -0.22961245f, 0.04489340f, -0.51699162f, -0.15046699f, 0.02459420f, 0.00593365f, 0.25036952f, 
    -0.07960187f, 0.16536160f, 0.06374921f, 0.03165735f, -0.03958574f, 0.09416538f, -0.06156807f, -0.01095269f, 
    0.12644005f, 0.01652816f, -0.17489257f, 0.08099423f, -0.08824187f, -0.08220033f, -0.05553782f, 0.06119916f, 
    -0.08265015f, -0.00437442f, -0.15981877f, -0.00296281f, 0.05877098f, 0.01549374f, 0.07952652f, -0.11644955f, 
    0.03676674f, -0.04682155f, -0.05186033f, -0.11636476f, -0.08071075f, -0.03591211f, -0.07267167f, -0.13691205f, 
    -0.08339308f, -0.11389512f, -0.04908419f, -0.09668291f, 0.03229490f, 0.04075266f, -0.05624428f, -0.07513231f, 
    -0.08097748f, -0.08638772f, 0.03991248f, 0.01782888f, 0.06586210f, -0.06149863f, 0.06350797f, 0.00844515f, 
    -0.09679487f, 0.01272750f, 0.12426992f, -0.13736328f, 0.07520529f, -0.24524163f, -0.04536000f, -0.04127660f, 
    0.09187151f, 0.11738332f, 0.04704159f, -0.05030906f, -0.08126971f, -0.01759709f, -0.11845256f, 0.01408351f, 
    -0.03178981f, -0.12027967f, 0.11851707f, -0.04809108f, 0.11648100f, -0.03260203f, -0.09480117f, 0.12195107f, 
    -0.04754437f, -0.13276623f, -0.12555297f, -0.02384509f, 0.04677952f, 0.06806225f, -0.04035668f, -0.01892942f, 
    -0.12319788f, -0.08920179f, -0.07119846f, -0.05703358f, -0.09580892f, -0.09154807f, 0.06766775f, -0.02158119f, 
    0.08878106f, 0.03144525f, -0.09936810f, 0.03618033f, 0.05718763f, 0.07141175f, -0.00008059f, -0.08630906f, 
    -0.06134273f, -0.04329266f, -0.03402284f, -0.01661082f, -0.05676145f, -0.07402797f, 0.04969758f, -0.00003138f, 
    0.09818395f, 0.03186356f, -0.01827218f, -0.06045403f, -0.08208856f, -0.07849425f, -0.06046059f, 0.03712387f, 
    -0.11892837f, 0.11482958f, 0.01673667f, -0.06135795f, -0.10988302f, 0.00948033f, 0.06617720f, -0.06581726f, 
    0.04501260f, 0.01111633f, -0.09327281f, -0.06155985f, -0.09336089f, -0.04635008f, 0.06671681f, -0.08035369f, 
    0.00901065f, -0.33294198f, -0.01906975f, 0.44319609f, -0.14957486f, -0.00404803f, -0.07210105f, 0.02301292f, 
    0.03194872f, 0.11804998f, -0.24607068f, 0.00930959f, -0.01191424f, 0.28747031f, -0.20402740f, -0.12860247f, 
    -0.18660736f, 0.23072864f, 0.01126742f, 0.08701708f, -0.12536541f, -0.23066998f, -0.04744899f, 0.03053703f, 
    -0.28400102f, -0.08438197f, 0.03999593f, 0.49825481f, 0.06878499f, 0.04864290f, -0.12291314f, 0.14170077f, 
    0.06937043f, -0.07379672f, 0.11200933f, -0.07064604f, -0.35471267f, -0.06989989f, 0.32418767f, 0.10301647f, 
    -0.22653577f, -0.05408005f, -0.12064245f, -0.09853726f, 0.44992307f, 0.13037093f, 0.02203933f, 0.01053380f, 
    0.14209069f, 0.01256751f, -0.07285834f, 0.05823157f, -0.06048288f, 0.12193658f, 0.00760018f, -0.06224123f, 
    0.04262213f, -0.23191781f, 0.05196235f, -0.47760990f, 0.08272554f, 0.04180760f, 0.02270888f, 0.20600094f, 
    0.20257063f, -0.16286404f, 0.07491999f, -0.18196593f, -0.15433516f, 0.36950651f, 0.15749343f, 0.08618878f, 
    -0.01909889f, -0.15023823f, 0.30715233f, 0.44421682f, -0.01791697f, 0.19507822f, 0.13036151f, -0.20155127f, 
    -0.04846768f, 0.11342023f, 0.05360159f, 0.05177950f, 0.12734663f, 0.28486907f, -0.02060645f, 0.09664161f, 
    -0.06025155f, 0.30644348f, 0.16313601f, -0.00319632f, 0.13625231f, 0.30095306f, 0.15769885f, -0.25296387f, 
    0.03433614f, 0.09201099f, 0.08071662f, 0.05449133f, 0.06256819f, 0.04315524f, 0.24321544f, 0.04062682f, 
    -0.10608624f, 0.00858072f, 0.14446940f, 0.04503841f, 0.10069454f, -0.06817599f, 0.15416320f, 0.18388136f, 
    0.14890377f, 0.01791264f, -0.11584449f, 0.16931008f, 0.03013037f, 0.21104592f, 0.14997225f, -0.02633646f, 
    -0.02723498f, 0.03544683f, 0.09897993f, -0.19494647f, -0.03853073f, 0.02661850f, 0.21607119f, 0.19614059f, 
    -0.00789595f, 0.00856123f, 0.04788405f, 0.09698734f, 0.10016739f, -0.04790746f, -0.05369762f, 0.09361708f, 
    -0.09888050f, -0.09207489f, -0.00700788f, 0.07392810f, -0.05730005f, -0.08316544f, 0.07468545f, -0.09951353f, 
    -0.07250174f, -0.11640049f, -0.04958594f, 0.02803929f, -0.10578007f, -0.01800136f, -0.14127377f, 0.07072981f, 
    -0.02153922f, 0.09016096f, -0.07723992f, -0.08694920f, -0.01551081f, -0.04870238f, 0.02553048f, 0.02181891f, 
    0.08453068f, -0.09744649f, -0.07669058f, -0.05515981f, 0.07757923f, 0.01940139f, -0.01280178f, 0.02932879f, 
    0.04355244f, 0.02403437f, -0.10846899f, -0.07446025f, -0.03165383f, -0.12452841f, 0.01664879f, -0.06368648f, 
    -0.10515879f, -0.06689328f, -0.12434963f, 0.06250525f, 0.07806262f, -0.04179703f, 0.01038064f, -0.08281428f, 
    -0.10277652f, -0.13958433f, 0.05557870f, 0.04341774f, 0.03967434f, -0.10666475f, -0.10575843f, 0.03348405f, 
    -0.12753442f, -0.02308498f, 0.11249770f, 0.01916519f, -0.06673709f, -0.11503899f, -0.01247703f, 0.10191661f, 
    -0.09031289f, -0.06346432f, -0.17128114f, 0.03425010f, -0.01789297f, -0.11051545f, 0.07274197f, -0.11584844f, 
    -0.13721979f, -0.06329213f, 0.02588477f, -0.10699769f, 0.05559860f, -0.09454494f, -0.02268232f, -0.08024267f, 
    -0.10226904f, -0.03749876f, 0.01258303f, 0.09324928f, -0.12239002f, -0.11217354f, 0.02796284f, -0.18295217f, 
    0.08861005f, 0.10678649f, 0.10437916f, -0.04833058f, -0.04252078f, 0.00668961f, -0.07956047f, -0.03645429f, 
    0.04065252f, 0.04234612f, -0.12968868f, 0.16107504f, 0.01731335f, 0.01314740f, -0.05993801f, 0.07901767f, 
    -0.13492174f, -0.12406170f, -0.08516183f, 0.04684270f, 0.07969801f, -0.00580364f, -0.02128216f, 0.01583339f, 
    -0.10708112f, -0.17577714f, 0.01642348f, 0.00053086f, -0.12248106f, -0.08087352f, 0.07524646f, -0.02724227f, 
    0.09388900f, -0.03840192f, -0.03063519f, -0.04314745f, -0.22025974f, 0.05736300f, -0.10722817f, -0.02797241f, 
    -0.11494999f, -0.30089384f, -0.27631405f, -0.00858868f, 0.10507948f, 0.10995287f, -0.25985894f, -0.21366762f, 
    -0.24298286f, -0.25495401f, 0.05481512f, 0.13191882f, 0.29661244f, -0.08610506f, -0.24723619f, 0.09931248f, 
    0.19664942f, 0.25764322f, 0.10747166f, 0.20342268f, -0.11607335f, 0.04006214f, -0.02249055f, -0.32834914f, 
    -0.06107728f, -0.03843476f, -0.09989588f, -0.08003899f, 0.02213401f, 0.08499513f, -0.00059691f, -0.03883657f, 
    -0.43113530f, -0.33410555f, -0.17770113f, -0.21324256f, 0.07756632f, -0.03004789f, -0.29538077f, 0.13099641f, 
    0.08231017f, 0.05696987f, -0.12942454f, -0.35481113f, -0.14746618f, 0.11420555f, 0.16003160f, -0.06093271f, 
    -0.18836063f, -0.14170521f, 0.24817209f, -0.16834588f, -0.11256414f, 0.07725783f, 0.13788800f, -0.07912843f, 
    -0.22797355f, -0.40801156f, -0.07744253f, -0.09518154f, 0.03056587f, -0.03675057f, 0.03010531f, 0.00590021f, 
    0.28486887f, 0.15571836f, 0.41042876f, -0.00234167f, 0.30669677f, -0.01841018f, -0.13644776f, 0.07397123f, 
    0.34285143f, -0.56530398f, 0.13510539f, 0.15015201f, 0.00146288f, 0.21962519f, 0.36661789f, 0.12500602f, 
    -0.14669570f, 0.49990451f, -0.37747535f, -0.23823737f, 0.00332167f, 0.31254330f, 0.36204788f, -0.12080526f, 
    0.04570548f, 0.01248944f, -0.05912188f, -0.24750802f, -0.18486808f, -0.09212860f, -0.10508359f, -0.00356121f, 
    0.13764672f, 0.06955744f, 0.23705602f, -0.00224580f, -0.16432859f, -0.22833554f, -0.10871974f, 0.31042531f, 
    0.28281525f, -0.09926242f, 0.05281783f, 0.70957220f, 0.05069846f, 0.03157042f, -0.02499606f, 0.04925532f, 
    -0.07664305f, 0.12572747f, -0.09089886f, -0.31352478f, 0.07019454f, 0.12233391f, 0.01795034f, 0.23060355f, 
    0.17343318f, -0.17596334f, -0.03145426f, -0.06477546f, -0.18302491f, -0.14642927f, 0.03990529f, -0.10973153f, 
    0.06765604f, -0.10325118f, -0.07002078f, 0.18423711f, 0.08297601f, 0.06356198f, 0.00224224f, -0.16694212f, 
    0.02228084f, 0.20568974f, -0.11341801f, 0.19502687f, 0.14519329f, 0.12350654f, -0.15322085f, 0.11253169f, 
    0.21952723f, 0.07527110f, 0.18395782f, 0.18532236f, -0.03557090f, 0.08350025f, 0.13692306f, -0.21397582f, 
    -0.00332771f, 0.09296121f, 0.02564594f, 0.09695019f, 0.30806303f, -0.07646982f, 0.37787336f, -0.04902375f, 
    -0.16153264f, -0.16286808f, -0.06315596f, -0.14449713f, 0.12042215f, 0.05428036f, -0.17008209f, 0.20852378f, 
    0.02531436f, 0.01136995f, -0.04115466f, -0.20856179f, -0.22268520f, 0.11280610f, 0.01476384f, -0.07384912f, 
    0.12602852f, 0.02250343f, 0.21397582f, -0.07846107f, 0.01070370f, -0.02743564f, -0.08896760f, 0.01743273f, 
    -0.22409050f, 0.09996231f, 0.00294428f, -0.18057150f, 0.06266452f, 0.18697791f, -0.01212896f, -0.13223298f, 
    0.09230308f, 0.20866111f, 0.07895929f, -0.21815652f, 0.24405810f, -0.43349338f, 0.01276573f, -0.10942064f, 
    0.12348621f, 0.06623104f, 0.15835811f, 0.13895419f, -0.16623902f, -0.06260051f, 0.57608944f, 0.14127447f, 
    -0.24358101f, 0.17510846f, -0.13146423f, 0.03784698f, -0.06181772f, -0.12926632f, 0.11540146f, 0.01843966f, 
    -0.08737942f, -0.02362083f, 0.10195005f, -0.00042265f, 0.16136362f, -0.04331034f, -0.38184878f, 0.11696947f, 
    0.23892020f, 0.02643642f, 0.12302738f, 0.17432609f, -0.12253031f, -0.03171979f, -0.11868621f, 0.06372766f, 
    0.12638922f, -0.00736460f, -0.05288224f, 0.22900008f, -0.07737777f, 0.12523988f, 0.17587718f, -0.06265648f, 
    -0.19069152f, 0.17989843f, 0.09851561f, -0.08859979f, -0.03701766f, 0.05760056f, 0.19309402f, -0.05112265f, 
    0.24591556f, 0.20543364f, -0.07802694f, 0.20206963f, 0.29821879f, -0.02684029f, -0.13657923f, 0.08510960f, 
    0.11539284f, 0.08806204f, 0.03674202f, -0.28248030f, -0.20756133f, -0.12523852f, 0.33906159f, 0.00992354f, 
    0.05520887f, 0.52665234f, 0.06263302f, -0.07705406f, -0.20013358f, -0.08107663f, 0.18622787f, -0.09981077f, 
    -0.28855145f, -0.17137803f, 0.14284389f, 0.37414134f, 0.03370489f, 0.00346311f, -0.17056498f, 0.29824415f, 
    -0.10593030f, 0.10334955f, -0.07246597f, 0.05557965f, -0.01348445f, 0.03850484f, -0.19992486f, 0.06509240f, 
    0.05765244f, 0.28670594f, 0.15119895f, 0.28947756f, 0.09793030f, 0.21272494f, 0.12794247f, -0.20472921f, 
    0.09852829f, 0.01016574f, 0.03287764f, -0.10509899f, 0.23782654f, -0.03555242f, -0.17106566f, -0.05236838f, 
    0.01107709f, 0.09199525f, -0.04467972f, 0.16665861f, -0.08575396f, 0.03584193f, 0.13294804f, -0.18168615f, 
    0.17909262f, -0.03460559f, 0.14505690f, 0.10309295f, -0.22364090f, 0.06167713f, 0.15019274f, 0.18366790f, 
    0.09041968f, -0.01081418f, -0.03792545f, -0.06457940f, 0.04356792f, 0.22619373f, 0.13974990f, 0.40080035f, 
    -0.18883961f, -0.22668482f, 0.02186306f, -0.00558792f, 0.11644170f, 0.17421533f, -0.13660201f, 0.16909762f, 
    0.12146459f, 0.03423157f, 0.13888779f, 0.04289251f, 0.01474674f, 0.22482009f, 0.16644579f, 0.11137696f, 
    0.08100888f, -0.09730339f, -0.06759809f, -0.06323196f, -0.14779873f, -0.05097421f, 0.44384229f, 0.07285628f, 
    -0.24543010f, -0.12347396f, -0.25827694f, -0.01520105f, 0.08737031f, 0.05818700f, 0.13537627f, -0.10918549f, 
    -0.06584501f, -0.01690765f, -0.10554954f, 0.10419854f, -0.02305378f, 0.23531695f, 0.06865017f, -0.06118755f, 
    0.05370693f, -0.37822968f, -0.20207131f, -0.19693400f, 0.03520757f, 0.09577633f, 0.10059764f, 0.16263972f, 
    0.35247719f, -0.11461893f, 0.03301247f, -0.22307138f, 0.06243425f, -0.17518455f, 0.14592277f, -0.15829122f, 
    -0.12048221f, -0.24474348f, 0.14628531f, 0.18986990f, -0.23204720f, 0.05004989f, 0.14287290f, -0.02930837f, 
    0.07031442f, -0.12941945f, 0.03127719f, 0.31306064f, -0.15626547f, 0.02242864f, 0.08431568f, 0.19433130f, 
    -0.04306556f, 0.03794391f, 0.18886566f, -0.15553845f, 0.17686693f, 0.16948918f, 0.14130679f, -0.31234872f, 
    -0.03972672f, 0.11297841f, -0.05568698f, 0.10029459f, 0.03285925f, 0.13495195f, 0.15071166f, 0.02749613f, 
    0.00892071f, 0.07097579f, -0.04890401f, -0.07297178f, -0.18315548f, -0.06612275f, -0.00707773f, -0.12791875f, 
    0.09090835f, -0.06462304f, 0.09588204f, 0.39153367f, -0.01540660f, 0.21782634f, 0.26798308f, -0.09154786f, 
    0.13390471f, 0.18146503f, -0.01147746f, 0.05542994f, 0.02460087f, -0.05247480f, 0.05155849f, -0.07000921f, 
    -0.08385558f, 0.01672707f, 0.06972878f, 0.01723275f, 0.22983280f, 0.26879233f, 0.00013101f, -0.08421041f, 
    -0.09977026f, 0.00756569f, -0.12899636f, 0.03270481f, -0.09110050f, 0.16932635f, 0.13465351f, -0.37225032f, 
    0.08144336f, -0.17560211f, 0.09798362f, 0.22845984f, -0.03618630f, 0.09018434f, 0.08136274f, -0.06142995f, 
    -0.06715333f, 0.09978352f, -0.14983699f, -0.07096276f, -0.13221589f, -0.05108866f, -0.06007494f, -0.05178250f, 
    -0.05113546f, -0.07071188f, -0.11456615f, -0.07232551f, -0.01959069f, -0.05099778f, -0.29974777f, 0.01586600f, 
    0.05820742f, 0.08177713f, 0.16752151f, 0.25845703f, -0.02990423f, 0.27138045f, -0.01331113f, 0.08642111f, 
    -0.03505147f, 0.00261307f, 0.01945188f, -0.11903340f, 0.16313840f, 0.02333638f, 0.31638378f, -0.00714012f, 
    0.05217402f, 0.19445224f, 0.22588642f, 0.07537250f, 0.00740506f, 0.10771626f, -0.00771910f, -0.17331238f, 
    -0.11130816f, -0.21923466f, -0.06883384f, 0.02741032f, 0.04544226f, 0.23649098f, 0.20857821f, -0.05716677f, 
    0.17767310f, 0.05094153f, 0.37834316f, 0.12823588f, 0.23034097f, -0.21051000f, -0.12448955f, -0.06649560f, 
    0.03669668f, -0.30502743f, 0.00366203f, 0.17275463f, -0.09038684f, 0.13024786f, 0.37411740f, 0.24439211f, 
    -0.19444992f, 0.42025822f, -0.15597819f, -0.00398893f, 0.09938077f, 0.24163827f, 0.35290480f, -0.16089453f, 
    -0.04172924f, -0.04796681f, 0.08258100f, -0.15619254f, -0.03242965f, -0.09855585f, -0.38468313f, 0.08367137f, 
    0.18588863f, 0.17699581f, 0.28890550f, -0.02882739f, -0.24589306f, -0.01479654f, -0.32441625f, 0.28850779f, 
    0.30311072f, 0.04662482f, -0.11048218f, 0.57694656f, 0.11093399f, 0.19892433f, 0.22153421f, -0.11246817f, 
    -0.06828837f, 0.01116695f, -0.11795262f, -0.31048176f, 0.01586858f, -0.00844972f, 0.09379163f, -0.01490500f, 
    0.46504444f, -0.01848391f, -0.04601792f, 0.08837280f, 0.10881409f, 0.38074592f, 0.12060913f, -0.08132097f, 
    -0.16174066f, -0.22482067f, 0.01103336f, -0.00539689f, -0.34731975f, 0.10834695f, 0.44168946f, -0.12680377f, 
    -0.13223417f, 0.18396269f, 0.16870961f, 0.08640523f, -0.22163574f, 0.14576787f, -0.13567126f, 0.02258497f, 
    -0.05769861f, 0.13155623f, 0.18757081f, 0.05922205f, -0.04292972f, 0.15058605f, 0.03151813f, 0.02350630f, 
    0.09172793f, -0.04869528f, 0.06730500f, 0.19571255f, 0.14972895f, 0.06702525f, 0.02749862f, -0.00418884f, 
    -0.01253581f, 0.06104480f, -0.13724831f, 0.17878595f, 0.18523058f, 0.11129018f, 0.10545143f, -0.17672971f, 
    -0.03660940f, -0.06265513f, 0.01356242f, -0.23107372f, 0.19683102f, 0.14819115f, 0.09153067f, -0.07154593f, 
    0.02473466f, -0.00151800f, -0.06899037f, 0.08861077f, 0.16307643f, -0.03643252f, 0.04771351f, -0.14173397f, 
    0.12047821f, 0.00282711f, 0.07406281f, -0.07097702f, -0.04684097f, -0.00182736f, -0.12176075f, 0.17982040f, 
    -0.09278390f, -0.06788862f, 0.03187203f, 0.05254437f, 0.03622051f, -0.10170244f, -0.03113583f, -0.10800172f, 
    -0.01893915f, -0.06676234f, 0.00562595f, -0.06559762f, 0.13104860f, -0.04726806f, -0.02451861f, -0.07197292f, 
    -0.00608574f, -0.08263984f, -0.14365743f, -0.06814026f, -0.08710019f, -0.06548245f, -0.11273982f, -0.05617076f, 
    -0.08819957f, 0.12216948f, -0.06686246f, -0.12745619f, 0.07475903f, 0.12138957f, -0.02143418f, 0.06733605f, 
    -0.04728504f, -0.07498089f, -0.10932972f, -0.07618007f, -0.07768405f, -0.12424209f, 0.06435488f, -0.00026568f, 
    -0.08980707f, -0.00765142f, -0.07388888f, 0.05795163f, 0.02142816f, -0.07414259f, -0.05336639f, 0.02783862f, 
    -0.13513215f, -0.01077597f, 0.01035730f, -0.08472247f, -0.11080208f, -0.12438580f, -0.03166240f, 0.03726861f, 
    0.09909272f, 0.07571344f, -0.00497330f, 0.18172526f, 0.09002408f, 0.23455651f, 0.03719571f, -0.03349269f, 
    0.00758623f, 0.06091071f, -0.08745109f, 0.01548611f, 0.24977200f, 0.08964789f, -0.00045480f, -0.25220007f, 
    -0.04922399f, -0.16779783f, 0.24430096f, 0.05992108f, 0.43292803f, -0.00208235f, -0.19283089f, -0.10204854f, 
    0.26477230f, 0.15787715f, 0.08857705f, -0.06047151f, -0.07686143f, 0.15048721f, 0.12974849f, 0.06678642f, 
    -0.10705086f, -0.02233061f, 0.02610330f, 0.20952870f, 0.11079972f, 0.05157523f, 0.25957596f, 0.07359537f, 
    -0.05996139f, 0.02791267f, 0.09054454f, 0.20701717f, 0.12909180f, 0.30019012f, -0.08721048f, 0.14635211f, 
    -0.22652638f, -0.01802268f, 0.00262346f, -0.47105396f, -0.06923562f, -0.01989710f, -0.00602700f, 0.09110133f, 
    -0.05514362f, -0.10136513f, 0.43481803f, -0.07780340f, 0.04024911f, 0.03509353f, -0.03882961f, -0.10614920f, 
    0.09299360f, -0.06477758f, 0.00799967f, 0.15126146f, 0.19736855f, -0.01164355f, -0.18816032f, 0.09181982f, 
    0.00470263f, 0.00582204f, -0.03250004f, -0.01523400f, -0.42122543f, -0.24558885f, 0.19650275f, 0.10619831f, 
    -0.17771699f, 0.02785154f, 0.10939551f, 0.09323410f, -0.16607106f, -0.15760346f, -0.12709996f, -0.01120876f, 
    0.00982910f, -0.27775085f, -0.01054456f, 0.10622426f, -0.02107912f, -0.02280631f, -0.25735804f, 0.24213688f, 
    0.05623402f, 0.02320449f, -0.03299908f, 0.11706781f, 0.03119996f, -0.07163020f, 0.15245271f, 0.04588915f, 
    -0.00933725f, 0.10034606f, 0.02738406f, 0.23349869f, -0.35399297f, 0.23166822f, -0.16041900f, -0.24589251f, 
    -0.22338527f, -0.05759569f, -0.00586346f, -0.22747259f, 0.23804829f, 0.01374425f, -0.08244712f, 0.17245393f, 
    -0.05298196f, 0.02505036f, -0.01315887f, -0.05790776f, 0.09996352f, -0.09056567f, 0.09666407f, -0.22002450f, 
    -0.11259803f, 0.03649022f, 0.09226626f, 0.37562466f, 0.09095372f, 0.35024855f, -0.13862284f, -0.00860549f, 
    0.15043084f, 0.36360121f, -0.16336706f, 0.09276450f, 0.04930681f, 0.18836866f, 0.10559396f, -0.56759369f, 
    -0.14723450f, -0.21901710f, 0.17276025f, 0.00002017f, 0.07743654f, -0.18829006f, 0.09501900f, 0.06642712f, 
    -0.23278864f, 0.19863850f, -0.05137696f, -0.06668991f, -0.15184072f, 0.06995998f, -0.15429538f, 0.10345273f, 
    0.10051178f, -0.01881742f, -0.10124040f, 0.08364106f, -0.05862018f, 0.03791166f, -0.11985692f, 0.05081783f, 
    -0.02625074f, 0.14204533f, -0.01139840f, 0.31413773f, 0.23686239f, 0.19140223f, 0.14591265f, -0.03067156f, 
    -0.06068838f, 0.07776962f, -0.10743202f, -0.14964861f, 0.11925003f, -0.10293335f, 0.11989946f, -0.05022493f, 
    -0.20404752f, 0.18549564f, 0.25384510f, -0.02737344f, 0.01916776f, -0.07173897f, -0.02364202f, -0.23780105f, 
    0.31578732f, 0.02717036f, 0.11175752f, -0.12985636f, 0.31107867f, 0.23540252f, -0.01794854f, 0.05797058f, 
    0.16401157f, -0.01616356f, 0.13036792f, -0.18443890f, -0.13859066f, -0.28302273f, 0.48328939f, -0.07905156f, 
    0.00389008f, 0.28603554f, 0.10291712f, 0.00358717f, -0.24820910f, 0.08016537f, 0.38343957f, -0.10569255f, 
    -0.24052459f, 0.04476490f, -0.10299650f, -0.22882147f, -0.04649349f, 0.05708708f, -0.24543104f, 0.18995970f, 
    -0.09033521f, 0.00687476f, 0.01004048f, 0.02326388f, -0.19226924f, 0.09817668f, -0.10880501f, -0.06319845f, 
    0.05827282f, 0.30608505f, 0.10302206f, 0.14684275f, -0.09764823f, 0.21719009f, 0.06886501f, 0.00057824f, 
    0.07095145f, -0.03815667f, -0.02715354f, -0.09884986f, 0.23130660f, -0.01649574f, -0.11495347f, -0.07345982f, 
    -0.28436184f, 0.08056564f, 0.24338594f, -0.09824833f, -0.00910614f, 0.06652050f, 0.04779603f, -0.00834486f, 
    0.11544459f, -0.03618360f, -0.01290002f, 0.09859721f, -0.40837458f, -0.28978473f, 0.03239958f, 0.19241461f, 
    -0.07247874f, -0.13532671f, -0.11232428f, 0.23412721f, 0.09493765f, 0.09257107f, 0.10198911f, -0.22318190f, 
    -0.29800102f, 0.20232713f, -0.10045705f, 0.15363857f, 0.21788599f, -0.10377946f, -0.10788361f, 0.01694838f, 
    -0.19315812f, -0.05694585f, 0.01355980f, 0.16900615f, -0.01346570f, 0.20627828f, 0.20406136f, -0.07254997f, 
    0.05181061f, -0.10349058f, -0.03285924f, 0.19738293f, -0.36600807f, -0.07758822f, 0.27845532f, -0.09007540f, 
    0.00729648f, 0.05424560f, 0.00188773f, 0.03646811f, 0.14150484f, -0.32793075f, 0.14661765f, 0.11978333f, 
    0.11713378f, 0.02678495f, 0.09888195f, -0.02513135f, -0.23126584f, 0.02001022f, -0.07892199f, 0.00256239f, 
    -0.01198452f, -0.14037348f, -0.21955812f, -0.17193662f, 0.06731115f, -0.03372538f, 0.10334137f, 0.20434542f, 
    0.41409883f, -0.26223689f, 0.10347664f, -0.02289578f, -0.14484397f, 0.58124626f, 0.03549772f, -0.02331829f, 
    0.01863130f, -0.20820899f, 0.31459931f, 0.25534683f, -0.17994791f, 0.09368122f, 0.38336840f, -0.15182680f, 
    -0.08457053f, 0.07647500f, -0.08306722f, -0.07067568f, 0.09166393f, 0.10995880f, -0.15409993f, 0.15448147f, 
    0.02144184f, 0.15864952f, 0.07480079f, -0.04595324f, 0.12563448f, 0.24046636f, 0.15106814f, -0.24731573f, 
    0.09784671f, 0.11169021f, 0.05382308f, 0.01465322f, 0.17744510f, -0.05479001f, 0.24192919f, -0.01631195f, 
    -0.16049662f, -0.03722425f, -0.17650607f, 0.13977568f, 0.23236527f, -0.08175916f, -0.13229512f, 0.10830569f, 
    0.13692553f, -0.02772139f, 0.08996907f, 0.00427947f, 0.04747271f, 0.19532357f, 0.15819244f, -0.01129732f, 
    0.07266137f, -0.15474460f, -0.06253050f, -0.30521643f, 0.14292715f, 0.07182121f, 0.06390355f, 0.00956093f, 
    0.20698445f, -0.19352555f, 0.08954722f, -0.09606386f, 0.02006509f, -0.08283205f, -0.08374365f, -0.06805374f, 
    0.19819874f, 0.09751379f, 0.32148203f, -0.15590647f, -0.23835829f, -0.39637536f, 0.35165066f, 0.22528651f, 
    -0.02428144f, 0.32919568f, 0.08943047f, -0.08419872f, 0.12862140f, 0.07547724f, 0.02286297f, -0.24600476f, 
    0.07846410f, -0.29931074f, -0.30386800f, -0.05737114f, -0.02672196f, 0.18998709f, -0.01206198f, 0.22483733f, 
    0.03305554f, -0.05594054f, -0.07022904f, 0.32144439f, 0.14714271f, 0.00526658f, 0.30781248f, 0.09200854f, 
    -0.12832046f, 0.27385998f, 0.05888975f, 0.03346593f, -0.24273415f, 0.25728825f, -0.16845179f, -0.28649595f, 
    -0.50564212f, -0.01600631f, -0.10322327f, -0.26745194f, 0.28888535f, 0.12637958f, -0.43945342f, -0.05702230f, 
    0.02813286f, -0.31464475f, 0.03736114f, 0.05822309f, -0.01910824f, -0.06866081f, 0.02356588f, -0.07375351f, 
    0.50779456f, 0.03989693f, 0.07528821f, 0.07391015f, -0.19455719f, -0.18629122f, 0.07724936f, 0.06113337f, 
    0.06640426f, -0.34244722f, -0.15959856f, 0.04395440f, -0.04941485f, -0.11242039f, 0.34950095f, 0.02615974f, 
    -0.20908037f, 0.10597460f, -0.11565629f, 0.19122025f, -0.07498357f, -0.06880787f, -0.18342008f, 0.14576630f, 
    -0.10026662f, -0.06918829f, 0.20277274f, 0.03915334f, -0.00722582f, -0.02708547f, -0.16967785f, -0.05316916f, 
    0.04516602f, 0.00260122f, -0.10459059f, 0.15351331f, -0.29811084f, 0.08390763f, 0.35401675f, 0.04349647f, 
    0.10249437f, 0.07673401f, -0.03212029f, -0.02146308f, 0.08327208f, -0.07949916f, 0.20668918f, -0.09101152f, 
    0.00775330f, -0.05884248f, 0.06816945f, 0.13611840f, -0.08833739f, 0.01629311f, -0.00369892f, 0.11881252f, 
    0.01688813f, 0.05321251f, -0.03324519f, -0.17302147f, -0.06634185f, -0.07104172f, -0.12283050f, 0.16795824f, 
    0.51104367f, -0.16515812f, 0.07364004f, 0.08167692f, -0.17542727f, 0.18519521f, 0.10930561f, 0.03732661f, 
    -0.17152625f, -0.19154863f, 0.43043163f, 0.11071979f, -0.25419423f, -0.16416413f, 0.30628112f, -0.02171513f, 
    -0.09126352f, 0.32049429f, 0.03028005f, -0.04273675f, -0.01932546f, 0.15980373f, 0.08840980f, 0.02491714f, 
    0.10321441f, -0.17148241f, 0.09363329f, 0.31619611f, -0.03084071f, 0.24306077f, 0.10867579f, -0.17928720f, 
    0.04185697f, 0.02835365f, -0.00900190f, 0.20337056f, 0.27328315f, 0.12983665f, 0.19950855f, -0.08310106f, 
    -0.29718223f, -0.01684399f, -0.11758776f, -0.12665658f, 0.16875950f, -0.11451913f, 0.01385624f, -0.05963864f, 
    -0.01200392f, 0.05834372f, -0.03724895f, -0.14218034f, 0.00738091f, 0.21652432f, -0.07739869f, 0.02582226f, 
    0.06822278f, -0.16455261f, -0.05134553f, -0.06090758f, 0.05549772f, -0.06579979f, -0.09407158f, 0.04101849f, 
    -0.06577309f, -0.12632486f, 0.11114842f, 0.04420214f, -0.12741747f, -0.27102873f, 0.28011471f, -0.04779246f, 
    0.25847185f, 0.16291735f, 0.17472550f, 0.19671419f, 0.11261328f, 0.08761995f, 0.02446154f, 0.06373075f, 
    0.09844822f, 0.15244246f, -0.12845038f, 0.16229253f, 0.21834344f, 0.05056911f, -0.02239631f, 0.20006268f, 
    -0.07610804f, 0.16724716f, -0.19576296f, -0.08668651f, 0.00564242f, 0.03069925f, 0.02013043f, -0.05746030f, 
    0.08723367f, -0.07372981f, -0.03390099f, 0.21120237f, 0.10962101f, -0.02286222f, 0.00323788f, -0.07102369f, 
    0.06080790f, 0.09007854f, 0.16678701f, -0.16202588f, -0.07230975f, -0.22818394f, -0.04693019f, 0.08896178f, 
    -0.14380129f, -0.08798496f, -0.03777676f, 0.22235483f, -0.09687209f, 0.13545991f, -0.22466315f, -0.14804445f, 
    0.13759065f, -0.02398243f, -0.11399218f, 0.07858467f, 0.08824311f, 0.12383448f, -0.10372355f, 0.26302567f, 
    -0.09006694f, 0.22744823f, -0.04560649f, 0.04059590f, -0.04336405f, -0.42266443f, 0.10195164f, -0.23124468f, 
    0.11322171f, 0.24245192f, -0.03169098f, -0.06770483f, 0.05262495f, -0.10897671f, -0.07027291f, -0.08794860f, 
    0.18206093f, 0.27156335f, -0.13020934f, 0.01033301f, -0.04695079f, -0.34617227f, 0.14911224f, 0.01647528f, 
    -0.13993548f, -0.14649038f, -0.00443785f, 0.30786821f, 0.02151851f, -0.26266375f, -0.08296240f, 0.07950774f, 
    0.07955636f, 0.08660324f, 0.05396222f, -0.02203339f, 0.35257408f, 0.12084251f, -0.21716075f, -0.06005800f, 
    0.09817217f, 0.09698312f, 0.22563779f, -0.25347409f, -0.06419419f, -0.11873008f, -0.10155187f, 0.14561693f, 
    0.19722193f, 0.11729410f, 0.13447402f, 0.09368413f, -0.05061081f, -0.35305515f, 0.02886702f, 0.01933421f, 
    0.09367773f, 0.27971184f, 0.16018443f, 0.12037719f, 0.12259394f, -0.07394368f, 0.00934863f, 0.06016462f, 
    0.07142779f, 0.15515897f, 0.03977340f, 0.09574019f, 0.08580167f, 0.14808603f, -0.10419335f, -0.10513777f, 
    0.03523255f, 0.13680968f, 0.11262440f, -0.17880264f, -0.00270650f, -0.07194045f, -0.02402409f, -0.07827090f, 
    0.17765835f, 0.16124220f, 0.14666750f, 0.01865350f, 0.15942816f, 0.00427154f, 0.13563785f, -0.09466021f, 
    -0.08443411f, -0.10879027f, -0.05801510f, 0.07394984f, -0.04552595f, -0.01429440f, -0.09506804f, 0.24558154f, 
    -0.07346329f, -0.08649480f, 0.07797711f, 0.15720540f, 0.08573112f, 0.01288882f, -0.07495982f, -0.13634333f, 
    -0.02757316f, -0.02998047f, 0.16833134f, 0.02660424f, 0.10312643f, 0.08801608f, -0.00336444f, -0.01847946f, 
    0.02874840f, 0.12025407f, 0.06620119f, -0.24710658f, 0.11155587f, 0.05168308f, -0.07518184f, 0.04294220f, 
    -0.09738117f, 0.17657660f, 0.20261633f, -0.00672299f, 0.17101629f, 0.03027068f, -0.04590802f, -0.08684579f, 
    0.07694609f, 0.05675312f, 0.08008970f, 0.03494743f, 0.00361006f, 0.00946886f, -0.13757062f, 0.08759410f, 
    -0.02255122f, -0.02104583f, -0.03215121f, 0.11653479f, 0.01860377f, -0.05162784f, 0.03009682f, -0.02279544f, 
    0.06162840f, -0.14466226f, 0.01390517f, -0.01767188f, -0.11944615f, 0.09705269f, -0.11769825f, -0.18094563f, 
    -0.10786168f, 0.00218554f, 0.00939179f, 0.00933997f, -0.00922675f, 0.01453828f, 0.05293177f, -0.11819307f, 
    -0.04994456f, -0.12006718f, 0.09577955f, -0.07210159f, 0.02353119f, -0.11283751f, 0.01096469f, 0.09552842f, 
    -0.08090194f, -0.10485971f, -0.09443995f, 0.04060815f, -0.12292681f, 0.03575804f, 0.01165214f, -0.03631958f, 
    -0.09843624f, 0.05269785f, -0.10195030f, 0.07489443f, 0.00683331f, -0.06906573f, -0.05199842f, -0.09906296f, 
    0.05123739f, 0.04323664f, -0.09548812f, -0.17092663f, 0.05378267f, -0.06847946f, -0.10027476f, -0.02902969f, 
    -0.09980528f, 0.13727933f, -0.00932551f, -0.24677370f, 0.14385439f, -0.04275486f, -0.12539977f, -0.10078640f, 
    -0.03479899f, -0.13497473f, -0.07705469f, -0.12282407f, -0.33343244f, -0.25159261f, -0.16063002f, 0.11289814f, 
    0.24693492f, -0.11271068f, -0.04623239f, -0.01807643f, -0.15958329f, -0.26005211f, -0.13111675f, -0.00418332f, 
    0.05018057f, 0.00951727f, -0.03684369f, -0.05840483f, 0.08740456f, -0.02609536f, -0.12112642f, 0.08209815f, 
    -0.11430709f, -0.10263515f, 0.06297129f, -0.29246652f, -0.14909317f, 0.00154485f, 0.07242031f, -0.00529981f, 
    0.09144171f, -0.17703561f, 0.11272839f, -0.25744748f, -0.26208168f, -0.20681712f, -0.18907997f, -0.11338466f, 
    -0.18716942f, -0.10920608f, -0.11495052f, -0.16660632f, -0.08076753f, -0.17853631f, 0.07724319f, -0.01885664f, 
    -0.04938908f, 0.01659085f, -0.04301869f, 0.08550954f, 0.07634117f, 0.10594806f, 0.07330842f, -0.06938098f, 
    -0.19835246f, -0.02042890f, -0.07316610f, -0.36740413f, -0.28065428f, -0.27284956f, 0.20040977f, 0.09071744f, 
    0.09514467f, -0.11588852f, 0.43903297f, 0.24743848f, 0.31991270f, -0.11539766f, -0.06447104f, 0.36263204f, 
    0.35414034f, -0.08712309f, -0.22604217f, 0.04323983f, -0.07112364f, 0.32388794f, 0.32314023f, 0.01184260f, 
    0.05174667f, 0.25026882f, 0.11509848f, -0.27505177f, 0.08780489f, 0.19847703f, 0.24105442f, -0.08966509f, 
    -0.10164898f, 0.04391876f, 0.11864601f, -0.40068528f, -0.21179341f, 0.07308371f, 0.23135024f, -0.01098701f, 
    0.06525738f, -0.15458095f, 0.06461009f, -0.38800341f, -0.30550310f, -0.39930886f, -0.03334238f, 0.26977956f, 
    0.29308650f, 0.06285425f, -0.06044601f, 0.64884418f, -0.06789996f, -0.03719058f, 0.16334859f, 0.04414750f, 
    0.00583445f, -0.00720284f, -0.26257676f, 0.10345079f, 0.05747586f, 0.03287116f, -0.03413911f, 0.23857729f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.19963267f, -0.07716089f, -0.09520410f, -0.12369198f, -0.05750123f, -0.06704260f, 0.13490386f, 0.12350493f, 
    0.23279132f, -0.01514428f, 0.14807606f, -0.09444825f, 0.02239777f, -0.01432591f, 0.11534011f, -0.05465843f, 
    -0.12983094f, 0.03481137f, -0.14812475f, 0.18390059f, 0.22139770f, -0.03658776f, -0.14324377f, -0.03004179f, 
    0.00841593f, -0.04639997f, -0.02002985f, -0.03252450f, 0.22551624f, 0.09912209f, -0.06830494f, -0.10156425f, 
    -0.12755360f, -0.11619484f, -0.09819519f, 0.16535833f, -0.10313790f, -0.16492788f, -0.01685862f, 0.21210830f, 
    0.07071152f, -0.00849572f, 0.15819827f, 0.04406051f, 0.06717581f, 0.03311779f, 0.13501836f, 0.00382340f, 
    -0.14975771f, -0.13994329f, -0.05553317f, 0.05789940f, 0.26219338f, -0.05386887f, 0.20771439f, 0.01991143f, 
    0.20811042f, 0.21580464f, 0.29003769f, 0.07004332f, 0.15172011f, -0.14684844f, -0.21305318f, 0.06746901f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.11741061f, 0.11214058f, -0.34272513f, 0.03911886f, -0.16026622f, 0.02210717f, -0.23622876f, 0.09872648f, 
    0.08428424f, 0.06801973f, -0.44147217f, 0.05090741f, -0.07611135f, 0.30630058f, 0.04371760f, -0.03377134f, 
    -0.10583510f, -0.50540149f, 0.06330528f, -0.22703892f, -0.23487459f, -0.14599344f, 0.21580987f, -0.01406626f, 
    0.11163532f, -0.06221482f, -0.14663109f, 0.10881474f, 0.19752777f, -0.18337093f, -0.06222075f, -0.28083149f, 
    -0.05660788f, -0.08669928f, -0.06633333f, -0.52360564f, 0.02345796f, -0.17072698f, 0.05129215f, -0.60445362f, 
    -0.02948911f, -0.04715818f, 0.18561418f, -0.02841735f, -0.25629562f, -0.00039071f, -0.55395412f, -0.03770569f, 
    -0.06250624f, 0.15798922f, 0.28597522f, 0.17033055f, 0.12434374f, -0.38771853f, -0.25711846f, 0.14029200f, 
    -0.41296420f, -0.23294020f, -0.40111333f, -0.00878169f, 0.09867867f, 0.08815519f, 0.16315410f, 0.10203643f, 
    -0.10959076f, -0.02673195f, 0.02973818f, -0.10542846f, -0.09931146f, -0.03185682f, 0.04533600f, 0.06153360f, 
    -0.00898754f, -0.56276888f, -0.06569892f, -0.00904992f, 0.07292052f, -0.48140913f, 0.07364926f, 0.02777959f, 
    0.06407935f, -0.36461681f, 0.01806935f, -0.34156650f, 0.16712148f, 0.12133096f, 0.22616908f, -0.05257809f, 
    0.34644264f, -0.09830933f, 0.07736710f, 0.07921202f, 0.14282411f, 0.13167469f, -0.10652409f, -0.16700020f, 
    0.03592824f, -0.09946702f, 0.31762612f, 0.00492119f, -0.07140619f, -0.00251864f, -0.46288699f, -0.59770972f, 
    0.08442307f, -0.22776714f, 0.09719945f, -0.06076596f, 0.12887985f, -0.21422613f, -0.40096584f, 0.13720216f, 
    -0.12762919f, -0.06416073f, 0.18052451f, -0.14485784f, 0.08371093f, 0.02265962f, 0.11915690f, 0.32434711f, 
    0.23398726f, 0.32068592f, 0.01244633f, 0.06779440f, 0.00241034f, -0.07098582f, 0.12121192f, -0.17779952f, 
    -0.03290914f, -0.06669113f, -0.56219530f, -0.07170464f, -0.05271750f, -0.02305585f, 0.23194320f, -0.44513059f, 
    0.10325217f, -0.85933679f, 0.19734278f, -0.06500240f, -0.29933909f, -0.22323726f, -0.13406599f, -0.33211413f, 
    0.01569870f, 0.08430646f, -0.04834885f, 0.12401186f, -0.50433141f, -0.22939594f, -0.31574669f, 0.05659797f, 
    -0.12538810f, -0.08308576f, 0.06611276f, -0.28228042f, -0.38672307f, -0.10192128f, 0.08167347f, 0.01350800f, 
    0.09379429f, -0.08544275f, -0.53072292f, 0.05101126f, -0.06869147f, -0.10073079f, -0.13811229f, 0.20423953f, 
    -0.18690550f, 0.15305980f, 0.10094627f, 0.12043405f, 0.15255724f, -0.15703560f, 0.16372058f, 0.11641784f, 
    -0.09060294f, -0.31791580f, -0.51157087f, -0.16451862f, 0.22843072f, -0.30326772f, 0.24987881f, -0.50889921f, 
    -0.02048184f, 0.08977445f, 0.01780904f, -0.17858052f, -0.01804586f, 0.00395917f, -0.04208833f, 0.11253659f, 
    -0.01274831f, 0.06769548f, -0.30896816f, -0.03417033f, -0.21664131f, -0.06477802f, -0.44111186f, 0.21435992f, 
    0.17497443f, 0.04598052f, -0.06073583f, -0.00831383f, -0.42725563f, -0.29696918f, 0.14096940f, -0.04359058f, 
    -0.00072916f, 0.15696435f, 0.04177715f, 0.15099861f, -0.62433207f, -0.31773153f, -0.18664484f, -0.05806734f, 
    -0.34038076f, 0.02976900f, -0.34416577f, -0.00436504f, 0.17896251f, -0.14454876f, 0.04740655f, 0.14618595f, 
    -0.00161787f, -0.08488942f, 0.15635227f, -0.03168198f, 0.05419630f, 0.01973599f, -0.13803728f, -0.04278021f, 
    -0.31388694f, 0.00074258f, 0.10078852f, -0.13748856f, 0.02791095f, 0.21368971f, 0.02981151f, 0.04683585f, 
    -0.02423669f, 0.03264079f, 0.06148973f, 0.13777228f, 0.14422187f, -0.90323794f, -0.09968874f, -0.08182734f, 
    -0.74732691f, -0.18588708f, -0.32538238f, -0.56138396f, -0.01232049f, 0.07853319f, -0.07871699f, -0.39339659f, 
    0.05045081f, -0.07340287f, 0.16631889f, 0.03718190f, -0.05350845f, -0.01225155f, 0.26378646f, 0.11147778f, 
    0.18913569f, 0.20722881f, -0.07911593f, -0.04345390f, -0.33901849f, 0.29386663f, -0.02177222f, -0.02499692f, 
    -0.07612786f, 0.00325700f, -0.13201576f, 0.06581553f, -0.31648070f, -0.06317270f, 0.13097689f, 0.07936995f, 
    0.18483730f, 0.09502552f, -0.19401760f, -0.15321364f, -0.17676044f, 0.01427139f, 0.07368126f, -0.10648963f, 
    -0.00000581f, -0.10662692f, -0.37178642f, -0.34968710f, -0.07073131f, -0.10312170f, 0.03752716f, 0.13610208f, 
    -0.48902699f, -0.02803489f, 0.17545843f, -0.28621221f, -0.04979866f, 0.05249065f, 0.03177935f, -0.00267735f, 
    -0.01959693f, -0.05720238f, -0.05365821f, 0.08768024f, -0.01956610f, -0.22342870f, -0.34386489f, 0.06999043f, 
    0.03936290f, -0.29160735f, 0.11696793f, 0.09775846f, 0.05811190f, -0.03296749f, -0.30988246f, -0.57330203f, 
    -0.09789672f, -0.09340765f, 0.03719369f, -0.07606716f, -0.14995919f, 0.06230425f, -0.01360838f, -0.13001366f, 
    -0.00588814f, 0.17079899f, -0.05399606f, 0.02024127f, 0.24963890f, 0.16669385f, -0.19624510f, 0.08096447f, 
    0.00299337f, 0.06893539f, -0.05876013f, -0.00006811f, 0.04507628f, 0.11617631f, -0.14551060f, 0.08122358f, 
    -0.03719387f, -0.07726455f, 0.04760417f, 0.12844478f, -0.08187651f, -0.04805420f, -0.02152926f, -0.55281895f, 
    -0.15204930f, 0.03998632f, -0.17536977f, 0.12928680f, 0.07657231f, -0.16401802f, -0.18367016f, 0.00674091f, 
    -0.05017893f, -0.00387800f, 0.04688726f, -0.29529923f, 0.00061393f, 0.16862248f, 0.00822066f, 0.10781009f, 
    -0.07898681f, 0.18693456f, -0.17670536f, 0.18522334f, 0.05078254f, -0.44858238f, 0.15103187f, -0.01652713f, 
    -0.48964149f, 0.10009980f, -0.11974097f, 0.07952927f, 0.09377509f, 0.04037687f, -0.07274587f, -0.31352904f, 
    -0.52153826f, 0.01217668f, -0.08629192f, 0.02361677f, -0.24987818f, -0.09189750f, -0.23517402f, -0.54970348f, 
    -0.75253302f, -0.41161573f, 0.27339992f, -0.00476129f, -0.52893901f, -0.02247270f, 0.12397510f, -0.30466554f, 
    -0.00297929f, -0.10663326f, -0.01536008f, -0.27217469f, 0.08112676f, -0.35840660f, -0.03435826f, 0.02921003f, 
    -0.14647667f, 0.06455800f, -0.25911796f, -0.38495860f, -0.56710356f, -0.66473264f, 0.03900474f, 0.07087369f, 
    -0.10961699f, -0.05839054f, -0.00770679f, 0.19912553f, -0.02939619f, 0.01409782f, -0.19119093f, 0.25117409f, 
    0.03225162f, 0.05370571f, -0.28141013f, 0.04114601f, 0.26064047f, -0.08853740f, 0.26759434f, -0.28162870f, 
    -0.07142785f, -0.68026447f, -0.23728815f, -0.47753072f, -0.58012944f, -0.06144486f, -0.02226208f, -0.17893718f, 
    -0.24936165f, -0.08633629f, 0.08940662f, 0.08587167f, -0.35902995f, -0.07617014f, 0.13405171f, 0.31223151f, 
    -0.39240131f, 0.01973405f, 0.07802079f, 0.04275623f, 0.00921549f, -0.07283211f, -0.28866136f, 0.30327630f, 
    -0.69335866f, 0.54949296f, -0.15303048f, -0.11120976f, -0.18808937f, -0.08784267f, 0.24038510f, 0.03702454f, 
    0.01015979f, -0.31923673f, -0.06080250f, -0.57004005f, 0.08744874f, 0.07008741f, -0.31119066f, 0.11516333f, 
    -0.19500042f, -0.11915338f, 0.25139788f, 0.19205095f, 0.13177341f, 0.12247469f, -0.03587993f, 0.15205567f, 
    -0.02130696f, -0.11597948f, 0.12162542f, -0.52904892f, 0.09534444f, 0.02333390f, 0.16774477f, -0.10469801f, 
    -0.03334013f, 0.20912737f, 0.08166560f, -0.12246953f, -0.49112082f, -0.18403096f, -0.02570512f, -0.14745690f, 
    -0.02038842f, -0.10487574f, -0.16050883f, 0.08190628f, -0.17981331f, -0.31524134f, -0.58882403f, -0.28462070f, 
    -0.14518061f, -0.07651181f, 0.03933326f, 0.26209101f, 0.01655931f, 0.00391953f, -0.15359983f, -0.22856328f, 
    -0.28202924f, -0.06469262f, -0.01843229f, -0.12931275f, -0.15031724f, -0.12428153f, -0.09988228f, -0.18002686f, 
    -0.14204046f, -0.25762948f, 0.07437647f, -0.01632080f, 0.12696135f, -0.09495852f, -0.36483192f, -0.03253933f, 
    -0.09629115f, 0.27289644f, 0.00037800f, -0.54923600f, -0.23520680f, 0.05315361f, -0.43460310f, -0.05422828f, 
    -0.27505761f, -0.04125849f, 0.20257895f, 0.34430090f, 0.07248862f, -0.13380028f, -0.00864913f, -0.29044849f, 
    -0.03641837f, 0.07401124f, 0.03689067f, 0.19222984f, -0.07789331f, -0.08966969f, 0.40463853f, -0.41931975f, 
    0.28149429f, -0.03970109f, -0.45671469f, 0.09342470f, 0.23965965f, -0.07865643f, -0.18583059f, 0.06796275f, 
    -0.07509381f, 0.27184919f, -0.50431556f, -0.06322164f, -0.67348462f, 0.01803652f, 0.10279133f, -0.72853351f, 
    0.08279077f, 0.05657084f, 0.11581723f, -0.10036570f, -0.17952949f, -0.07620198f, -0.08292916f, -0.08478019f, 
    0.11931653f, 0.08564687f, -0.21646148f, 0.01204826f, -0.41881830f, 0.09135037f, 0.20580806f, -0.06005746f, 
    0.05298718f, 0.12513892f, 0.02138893f, 0.12252070f, -0.09222846f, -0.40402701f, 0.22325550f, -0.40306753f, 
    0.10089561f, -0.21774383f, -0.12932362f, 0.19289753f, 0.22908458f, -0.16040456f, -0.33037332f, -0.07841121f, 
    -0.25850663f, 0.08376885f, 0.08060486f, -0.23967960f, 0.00074113f, -0.12814634f, 0.11607441f, -0.01824520f, 
    -0.05862594f, -0.05784678f, -0.39219740f, -0.02055471f, 0.04742431f, -0.05446093f, 0.02664738f, 0.19072533f, 
    -0.02282277f, 0.16543587f, -0.17241430f, -0.46425796f, 0.05106699f, 0.03898438f, 0.11839080f, -0.48878071f, 
    0.02980738f, -0.19819495f, -0.55003327f, -0.03565447f, 0.09350125f, -0.18056338f, -0.40933982f, -0.29954830f, 
    -0.00153964f, -0.36566198f, 0.21170525f, 0.03596631f, -0.09199525f, -0.03517224f, -0.19419065f, 0.12245645f, 
    0.22318974f, 0.03010014f, -0.39234024f, -0.07928205f, -0.16416687f, -0.10577566f, 0.19503760f, 0.08208381f, 
    -0.26097411f, 0.13240877f, -0.07226060f, -0.09250479f, 0.17160970f, 0.21308789f, -0.10594484f, 0.31082439f, 
    -0.01587739f, -0.07408380f, -0.02839836f, 0.05546566f, -0.21545486f, 0.31400967f, -0.28590026f, 0.07029274f, 
    0.06159035f, -0.06815407f, 0.21506236f, 0.09838715f, -0.19666368f, 0.33715865f, -0.11232982f, -0.02430132f, 
    -0.03372764f, -0.06934692f, -0.18943925f, 0.00753078f, -0.05907374f, -0.14852390f, -0.21130663f, -0.04542476f, 
    0.03398171f, -0.46329296f, -0.11435402f, 0.22783078f, -0.23209371f, -0.69454229f, -0.26538050f, -0.23202704f, 
    0.15490225f, 0.10263343f, -0.54452437f, -0.54306102f, -0.25233731f, -0.59932220f, 0.00968608f, -0.00367097f, 
    -0.14620489f, 0.17745475f, 0.10808291f, -0.18586354f, 0.03125142f, -0.02804756f, -0.14962564f, 0.11354561f, 
    -0.05864349f, -0.07966155f, 0.19630763f, -0.08247212f, -0.04456986f, 0.07585063f, -0.09759182f, 0.18485039f, 
    -0.19823895f, -0.07403995f, 0.04117557f, -0.12194963f, -0.63019961f, -0.06481977f, -0.03192826f, -0.15883499f, 
    -0.09790785f, 0.28853917f, 0.11225648f, 0.14808373f, 0.00043921f, 0.18616015f, -0.13207623f, 0.03701668f, 
    -0.21062681f, 0.09958930f, -0.48083988f, 0.04330397f, -0.03309774f, -0.15515730f, 0.04980428f, 0.33809537f, 
    0.06814916f, 0.10847970f, 0.18791157f, 0.09313225f, -0.05101242f, -0.04028737f, 0.08409778f, 0.12846798f, 
    0.01846801f, -0.25651547f, -0.50355923f, 0.32166353f, -0.07210654f, -0.36628702f, -0.07921308f, -0.18838164f, 
    0.04200379f, -0.11265060f, -0.32524154f, 0.03635278f, -0.21342704f, 0.09388163f, 0.14209518f, -0.44178876f, 
    0.02528445f, -0.27336848f, 0.15419407f, -0.37198049f, -0.40311986f, -0.08272272f, 0.03744389f, 0.04066395f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.17764430f, -0.00029852f, -0.01842910f, 0.04481416f, 0.06614364f, -0.00458487f, 0.01166005f, -0.00613935f, 
    -0.01444379f, 0.21812396f, -0.07565839f, -0.10806397f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
