#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.53069288f, -0.85080212f, -0.64665252f, -0.26513276f, -0.11174593f, -0.51018298f, 0.47873902f, 0.59679449f, 
    -0.11204246f, 0.36713302f, 0.38229313f, 0.06016332f, -0.01059569f, -0.24322017f, -0.01833309f, 0.08952054f, 
    0.25647420f, 0.01493651f, 0.21964467f, -0.07162701f, -0.03763310f, -0.19960676f, 0.07473799f, 0.12478453f, 
    0.13546787f, -0.68757898f, -0.25707749f, -0.21980239f, 0.87354034f, 0.59371322f, 0.46477029f, 0.69846147f, 
    0.02929703f, 0.33599648f, 0.06460712f, -0.43845111f, 0.04133674f, 0.08114530f, 0.14212018f, 0.04362532f, 
    -0.17602566f, 0.09208580f, 0.16208290f, -0.08510689f, 0.05885345f, 0.22608484f, 0.07408676f, -0.33166090f, 
    -0.10537955f, -0.17556344f, -0.44337639f, -0.33106899f, -0.51375949f, -0.50642747f, -0.16899088f, -0.32914373f, 
    -0.08538093f, -0.33795241f, -0.03017799f, 0.20207602f, -0.13223438f, -0.14841703f, -0.14259693f, 0.20506564f, 
    -0.03576930f, -0.41818479f, -0.06812950f, 0.02159020f, -0.32738975f, -0.08691594f, 0.24353978f, -0.19006920f, 
    -0.44809097f, -0.10527975f, -0.31745464f, -1.02653968f, -0.49388438f, 0.25033611f, 0.20375268f, -0.24663801f, 
    0.49359578f, 0.48415357f, 0.36889157f, 0.23203288f, 0.14911014f, -0.03992544f, -0.12829235f, 0.05041614f, 
    0.24424838f, 0.28593644f, -0.28269896f, -0.15730312f, -0.24415895f, -0.12248842f, -0.01061073f, 0.18663974f, 
    0.23547956f, 0.07736362f, 0.20728037f, -0.09074131f, 1.00670016f, 0.67441773f, -0.79724383f, -0.78956169f, 
    -0.47399670f, 0.08866371f, -0.18322667f, -0.26636878f, 0.07139083f, 0.19775310f, -0.03181231f, 0.01949228f, 
    0.26830795f, 0.05778178f, -0.21341370f, 0.05392195f, 0.06506459f, 0.02421474f, 0.02538200f, 0.26440108f, 
    0.22899984f, -0.03011515f, -0.09835097f, -0.09615534f, -0.06328838f, 0.13327208f, 0.56858963f, -0.13436870f, 
    -0.12253023f, -0.23859145f, -0.43588698f, -0.63081568f, -0.72608113f, -0.54031336f, -0.12107033f, 0.07984585f, 
    0.47269711f, -0.08611126f, 0.06389213f, 0.22529082f, 0.13152391f, -0.47611997f, 0.04841618f, -0.14950180f, 
    -0.10083418f, 0.04536900f, 0.31793237f, 0.03701508f, -0.03270870f, 0.14837947f, 0.48310599f, 0.47406843f, 
    0.09651876f, -0.20146282f, 0.08606684f, -0.28371817f, -0.76598597f, -0.23957904f, 0.56192195f, 0.05242423f, 
    -0.17438932f, -0.51598847f, -0.05365318f, 0.37612829f, -0.05376871f, 0.08968322f, -0.30835575f, -0.06518011f, 
    -0.07667578f, -0.12051307f, 0.28079915f, 0.32669559f, -0.27205265f, 0.23125440f, 0.12833764f, 0.72055411f, 
    0.23218924f, 0.72307336f, 0.86230451f, 0.77782750f, -0.01863144f, 0.12543309f, -0.17813896f, -0.55651700f, 
    -0.50615817f, 0.10635642f, -0.09050632f, -0.26856440f, 0.15243624f, 0.14337678f, -0.19917686f, -0.21450798f, 
    -0.01041942f, 0.11712475f, -0.00978489f, -0.19444360f, 0.11124547f, -0.11652309f, 0.03117171f, -0.05093002f, 
    -0.56662774f, 0.41835114f, -0.39791939f, -0.54554677f, -0.41010252f, 0.01207610f, 0.51724207f, -0.23622742f, 
    0.02548344f, 0.44185716f, -0.02482372f, 0.17007653f, -0.33317053f, -0.38193816f, -0.31623459f, 0.13321880f, 
    0.16164339f, 0.12231919f, -0.00964715f, -0.18258087f, -0.10775357f, -0.01120306f, -0.01066323f, -0.39555588f, 
    0.33344826f, -0.81650209f, -0.01264612f, -0.43579116f, -0.47552392f, -0.42021814f, 0.37821665f, -0.45474702f, 
    -0.25070557f, 0.42238438f, 0.22204605f, -0.03553654f, -0.39169538f, -0.27404240f, 0.31681368f, 0.13015808f, 
    -0.05899486f, 0.21166608f, -0.19707656f, 0.12077136f, -0.05600721f, -0.06304368f, 0.17911018f, 0.40077415f, 
    0.23231944f, 0.37782121f, 0.04140391f, -0.70846689f, 0.75906193f, 0.41520184f, -0.52139866f, 0.10879326f, 
    -0.57929814f, 0.60728651f, -0.02686676f, -0.22306475f, 0.08465496f, -0.36927643f, -0.39622247f, 0.00267604f, 
    0.18080330f, 0.18960033f, 0.31083369f, -0.26807526f, -0.21388040f, -0.14980760f, 0.02607945f, 0.06629179f, 
    0.30062613f, 0.00146599f, 0.10595000f, 0.43988115f, -0.54765403f, 0.38275900f, 0.21078332f, 0.44885144f, 
    -0.56608588f, -0.57190597f, 0.13350078f, 0.00255616f, -0.14627172f, 0.09073222f, -0.04622892f, 0.08687904f, 
    0.00510676f, 0.16216761f, 0.37412879f, 0.17858648f, -0.08785036f, 0.07139944f, -0.06974366f, -0.04576566f, 
    -0.10457143f, -0.34956688f, -0.42830175f, 0.11016458f, -0.51671547f, -0.08833995f, -0.31273785f, -0.32568511f, 
    0.03082773f, -0.67559963f, 0.62220615f, -0.40414497f, -0.75896209f, -0.15454383f, 0.43426913f, 0.31961349f, 
    0.13241336f, -0.24670111f, 0.09429806f, -0.19902764f, 0.01701547f, 0.12975739f, 0.10518960f, -0.14034055f, 
    0.01951454f, -0.13264340f, -0.03537418f, 0.03763461f, 0.10871518f, 0.71799362f, 0.06639478f, 0.25907436f, 
    -0.50230193f, -0.52047086f, 0.17442679f, -0.07850803f, 0.62051225f, 0.27583930f, 0.27991951f, 0.12725182f, 
    0.01616144f, 0.01430682f, 0.04596653f, 0.08936454f, -0.00106824f, 0.03318033f, -0.27972019f, 0.25778586f, 
    -0.15502255f, 0.04052661f, 0.19627459f, -0.47324759f, 0.28442350f, -0.37027332f, -0.37709433f, 0.16905682f, 
    -0.39990976f, -0.55122232f, -0.34937233f, 0.69239330f, 0.69527000f, 0.29219660f, 0.35337549f, 0.52469218f, 
    0.19344275f, -0.30460134f, -0.03673044f, -0.05264408f, -0.09782755f, 0.15437011f, 0.04341673f, 0.01840311f, 
    0.29831567f, 0.01350479f, -0.09967937f, -0.05177921f, -0.18605785f, -0.26395598f, -0.03168170f, -0.99376953f, 
    0.76847637f, 0.39863393f, -0.82896268f, 0.44568291f, -0.45229915f, 0.06988879f, 0.63292247f, -0.02987098f, 
    -0.40344572f, 0.01221271f, -0.08830029f, 0.10118805f, -0.07513610f, -0.11276266f, 0.13744146f, -0.17981002f, 
    -0.01558702f, 0.11138442f, 0.06111838f, 0.03839544f, 0.13737354f, 0.12101655f, 0.11385319f, 0.18723097f, 
    0.88061845f, 0.48157039f, 0.42710948f, 0.46597296f, 0.04404024f, -0.22346018f, 0.03252411f, 0.15228693f, 
    0.20439780f, 0.46067792f, -0.60368937f, 0.07994246f, 0.31812862f, -0.27599961f, -0.07029474f, -0.37503356f, 
    -0.23999336f, -0.06295960f, 0.10768425f, 0.02041930f, 0.10099483f, -0.22714075f, -0.06039296f, -0.22660236f, 
    -0.18557152f, -0.94418359f, 0.47651896f, 0.90811759f, -0.22529073f, -0.17901942f, 0.17739336f, 0.32230017f, 
    -0.20675287f, 0.38264564f, -0.54017258f, -0.17708866f, 0.15122244f, -0.36373937f, 0.28466651f, 0.11769256f, 
    -0.14552112f, -0.01939948f, -0.32568470f, -0.18537161f, -0.22756700f, -0.05135571f, 0.04962937f, -0.05919847f, 
    0.22216128f, -0.16979252f, 0.14969558f, -0.32918015f, 0.10257570f, 0.71946144f, 0.63465804f, 0.33774748f, 
    0.58442414f, 0.08576034f, 0.38459399f, 0.41945150f, -0.24324550f, -0.18388073f, -0.40805501f, 0.14526989f, 
    -0.03053159f, 0.04742140f, -0.04074148f, -0.24933276f, -0.08388127f, -0.03222140f, 0.28790274f, 0.07976935f, 
    0.06448011f, -0.29171458f, 0.23314941f, -0.81658393f, 0.47808427f, 0.29668862f, 0.17930119f, 0.44028139f, 
    0.63226706f, -0.22726800f, -0.75893044f, -0.20015123f, -0.65464419f, 0.31423464f, -0.19690764f, 0.40014368f, 
    0.33231819f, -0.13200355f, 0.00486880f, -0.07248735f, -0.12027957f, -0.06330115f, 0.15625282f, -0.11589935f, 
    0.10791481f, 0.18058173f, -0.10233357f, 0.13223743f, -0.55654204f, -0.25178003f, -0.08750644f, -0.46589899f, 
    -0.18448767f, 0.49504870f, 0.56610745f, 0.03506746f, 0.26475471f, 0.30522048f, 0.30523756f, 0.03129187f, 
    0.09748498f, -0.25419506f, -0.22700550f, 0.31943357f, -0.20440808f, 0.05034303f, -0.43632481f, -0.00320764f, 
    -0.26190776f, -0.12147776f, -0.12975043f, 0.35941273f, -0.18565549f, 0.81632060f, 0.23188993f, 0.83152688f, 
    -0.49408227f, 0.23909450f, 0.02499495f, 0.01673765f, 0.04535764f, -0.25524274f, -0.04170586f, 0.20721143f, 
    0.35270748f, -0.01234844f, 0.28304055f, 0.06959819f, 0.16874650f, 0.02967855f, 0.12693769f, 0.19579545f, 
    0.18013266f, 0.08775818f, 0.35587880f, 0.15420042f, -0.06063385f, 0.32855716f, -0.17943037f, -0.29391998f, 
    0.41308841f, 0.38588676f, 0.48888257f, 0.23905878f, 0.40548545f, -0.42437238f, -0.16938695f, 0.31400543f, 
    0.06232633f, 0.06632996f, 0.52482527f, -0.05836475f, 0.17843136f, -0.28716895f, 0.08628520f, -0.24145384f, 
    -0.10294044f, -0.13757464f, 0.11945010f, -0.43909201f, -0.17523961f, 0.12563507f, 0.23577937f, 0.82079846f, 
    0.10561012f, 0.61883414f, 0.47753337f, -0.12825169f, 0.13107181f, 0.13908902f, 0.02949867f, 0.13556804f, 
    0.37688920f, -0.03150256f, 0.22198001f, 0.14811954f, 0.05863085f, -0.38772437f, 0.26007521f, 0.27774343f, 
    0.24706905f, -0.15853235f, -0.25340736f, -0.25944892f, 0.11464087f, -0.20376301f, -0.09655524f, -0.28678066f, 
    0.43837875f, 0.52276349f, 0.05279741f, 0.59444726f, 0.76367444f, 0.90369219f, -0.08083277f, -0.34764245f, 
    -0.10134728f, -0.41389897f, -0.39726764f, 0.02733208f, -0.20860004f, 0.18652549f, -0.07554817f, 0.28283957f, 
    0.13429445f, 0.31616372f, 0.13221096f, 0.12411395f, 0.34348604f, 0.19475310f, -0.04076226f, -0.16297966f, 
    0.22516312f, 0.46253413f, 0.75182813f, 0.44144702f, 0.38864142f, 0.05878878f, -0.26082221f, 0.25321287f, 
    0.12962836f, 0.30309394f, 0.29182553f, 0.02806477f, -0.13156535f, 0.15229259f, -0.10891854f, -0.37398967f, 
    0.31797984f, -0.01679111f, -0.27878982f, 0.13477497f, -0.33774227f, 0.10879997f, -0.12781395f, 0.15231073f, 
    0.10706139f, 0.27837631f, 0.53550792f, -0.01758630f, -0.75228816f, -0.38893288f, -0.13850090f, 0.46414861f, 
    0.59205633f, -0.21863183f, 0.16712815f, 0.00943418f, 0.39715841f, 0.27924785f, -0.39177546f, 0.34963724f, 
    0.22930729f, 0.07603073f, -0.09807010f, -0.32058769f, -0.16276981f, -0.16002902f, 0.21343398f, 0.18780063f, 
    0.06835854f, 0.17415822f, 0.23311979f, 0.43471879f, -0.04613552f, 0.18749103f, 0.59355092f, 0.53620857f, 
    0.46548557f, 0.01674284f, 0.22279660f, 0.05342900f, 0.17237070f, 0.22007185f, 0.08832536f, 0.23709254f, 
    -0.11040179f, 0.08231568f, 0.31210953f, -0.30922273f, 0.22855462f, -0.10602313f, 0.21445309f, -0.22423741f, 
    -0.22309913f, 0.39364064f, 0.53391051f, 0.12084998f, -0.43627745f, 0.74139780f, -0.37780821f, 0.33040908f, 
    -0.45992038f, 0.28665993f, 0.43471012f, -0.04007418f, 0.20057611f, 0.14322019f, -0.30219501f, -0.39097947f, 
    -0.25223348f, -0.35032749f, -0.21597543f, 0.30133554f, 0.16901095f, -0.36807594f, -0.28278455f, -0.28883407f, 
    -0.18769446f, -0.31411377f, -0.05875397f, -0.14438337f, -0.03625683f, -0.44121775f, 0.57863498f, 0.49480605f, 
    -0.78773636f, 0.63979387f, 0.67120039f, -0.41825524f, -0.65573156f, -0.29321706f, -0.47669685f, 0.10426934f, 
    -0.12957011f, 0.22792247f, 0.16703986f, -0.32942891f, -0.43503878f, 0.01869449f, 0.03941238f, -0.33501774f, 
    -0.19037092f, 0.15564053f, -0.06804346f, -0.19295283f, -0.15017517f, -0.25826612f, -0.16436432f, -0.43774325f, 
    -0.51837194f, -0.41074091f, -0.26471660f, -0.61866641f, -0.34213021f, 0.13042535f, -0.11789411f, -0.03362531f, 
    -0.09431920f, -0.20473550f, -0.05764899f, 0.00436585f, -0.29136831f, 0.31445178f, 0.04620375f, -0.25900197f, 
    0.12504220f, -0.09771376f, 0.28206578f, -0.06339094f, 0.36723965f, -0.21008277f, 0.34377736f, 0.11482182f, 
    0.47281387f, 0.34357193f, -0.08914033f, -0.51935756f, -0.73023534f, 0.50596809f, -0.11789387f, -0.30751780f, 
    0.40175691f, -0.11915832f, -0.12556882f, -0.27812350f, -0.49341404f, -0.08681408f, -0.42768806f, -0.28456596f, 
    -0.12552099f, -0.30679205f, -0.20945607f, 0.10202096f, 0.13246489f, -0.10154344f, 0.02819838f, 0.05792792f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.06936911f, 0.28179926f, 0.14979410f, 0.07548954f, -0.01461597f, 0.17427357f, 0.20424443f, -0.05827999f, 
    0.01339167f, 0.09395101f, 0.00076334f, 0.10127951f, 0.27724269f, 0.11525224f, -0.10630802f, 0.31017235f, 
    0.12593113f, -0.03814295f, 0.22510894f, -0.01829980f, 0.16843039f, 0.10146361f, 0.15914617f, 0.20618311f, 
    0.00532830f, 0.26492497f, 0.24697958f, 0.01656139f, 0.00899877f, 0.09882016f, 0.19627504f, 0.02879166f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.32760257f, 0.11865638f, -0.05199189f, -0.09342527f, 0.05889418f, 0.06493892f, 0.09665829f, -0.07104956f, 
    -0.03787693f, 0.08867685f, 0.08817378f, -0.12716249f, -0.15384890f, 0.04628576f, 0.04624046f, -0.14022502f, 
    -0.02962520f, 0.03974305f, 0.15489677f, 0.02107871f, -0.04505944f, -0.01622219f, -0.01376417f, 0.12579679f, 
    0.09982733f, 0.07857392f, 0.01079107f, 0.12165398f, -0.03194108f, 0.03277658f, 0.07956239f, -0.02189485f, 
    0.02175017f, 0.01816094f, 0.01700103f, 0.23803264f, -0.11825264f, -0.18001559f, 0.00041776f, -0.15391199f, 
    0.09199691f, 0.01384047f, -0.07835987f, 0.01574470f, -0.04036864f, -0.02846700f, 0.06626866f, 0.08725099f, 
    0.04234691f, -0.07862439f, -0.17259346f, 0.45418254f, 0.04041259f, 0.05405889f, 0.08875521f, 0.03414031f, 
    0.04434694f, 0.08597930f, -0.06770176f, -0.08611745f, 0.10656332f, 0.00350280f, 0.00557722f, 0.33583084f, 
    -0.04733978f, -0.00644057f, -0.08153478f, -0.04497623f, 0.01601264f, -0.13766472f, -0.04396331f, -0.07330373f, 
    0.29130086f, 0.05813526f, -0.12755695f, 0.10371631f, 0.02846407f, -0.06588811f, 0.01308750f, -0.12749103f, 
    0.03556852f, 0.08234200f, 0.01565316f, 0.10229563f, -0.02896184f, -0.01005055f, 0.06321753f, -0.27089730f, 
    0.03040894f, -0.05681893f, 0.08711168f, 0.03202039f, 0.11300742f, -0.00854177f, 0.06761661f, 0.00475182f, 
    -0.04731608f, 0.01102608f, 0.10773256f, 0.16440088f, -0.02100656f, 0.04549664f, 0.04707921f, 0.01347555f, 
    -0.09403951f, 0.12316675f, -0.03753513f, 0.01540242f, 0.33590066f, 0.12482694f, -0.13255519f, 0.10997463f, 
    -0.08693879f, 0.07605224f, -0.00953741f, 0.05866326f, -0.02440637f, -0.01403159f, -0.01120581f, 0.04078463f, 
    0.37015808f, -0.10532320f, 0.02900691f, -0.25522986f, 0.06122998f, 0.03205803f, 0.01665999f, -0.02691461f, 
    -0.09624853f, -0.03790753f, 0.07547984f, 0.06820510f, 0.03557197f, 0.13274679f, 0.05880209f, 0.15929362f, 
    0.01841091f, 0.02570242f, 0.15505570f, 0.01358660f, 0.00956223f, 0.00843608f, -0.06499233f, -0.02106626f, 
    -0.16936314f, 0.13178034f, 0.21885245f, 0.11663496f, -0.03967298f, 0.08154882f, 0.00482835f, 0.07066046f, 
    0.02263583f, -0.00404808f, -0.13858247f, 0.06798209f, -0.11934973f, -0.00747385f, 0.08486120f, 0.02437493f, 
    0.06760402f, 0.14116850f, -0.08484093f, 0.10618750f, 0.05514483f, -0.06000498f, 0.05905558f, -0.05802576f, 
    -0.26385686f, -0.14554924f, -0.03388629f, 0.05147532f, -0.07169931f, 0.03022316f, 0.00038586f, 0.04802359f, 
    0.14004658f, -0.00364893f, 0.05722778f, -0.05432855f, 0.01191207f, 0.11069042f, 0.13765122f, 0.42937240f, 
    -0.03879559f, -0.03598350f, 0.05936160f, 0.01560016f, -0.01194784f, -0.06960627f, -0.03405960f, -0.03935998f, 
    -0.20876116f, 0.00891063f, 0.02245341f, -0.16932958f, 0.01995053f, 0.01780444f, -0.01834911f, 0.04309325f, 
    0.07258511f, -0.07112214f, 0.04718721f, 0.08500065f, 0.25334758f, 0.06184187f, 0.19855024f, -0.14695202f, 
    0.09822565f, -0.08653381f, 0.00587821f, 0.04205066f, -0.02605421f, 0.11030748f, 0.04895180f, 0.12219077f, 
    -0.28415617f, 0.08137035f, -0.05722677f, -0.18194748f, -0.00624448f, -0.02225837f, 0.09418681f, 0.02776063f, 
    -0.05268850f, -0.18066660f, 0.09525132f, -0.00459963f, 0.10601344f, -0.06092414f, 0.14678705f, 0.13385907f, 
    -0.06617276f, -0.04908278f, -0.02574516f, 0.10315657f, -0.04041503f, -0.12113091f, 0.02758897f, -0.01209924f, 
    -0.18302761f, 0.09509937f, -0.07453607f, 0.15862714f, 0.03790182f, 0.02318783f, 0.05119946f, 0.05574370f, 
    -0.01078059f, 0.07340210f, 0.07761794f, -0.04188281f, 0.01153411f, -0.24295565f, -0.03923696f, 0.15545034f, 
    -0.10338970f, 0.00511402f, -0.04583970f, 0.01256482f, -0.00038904f, -0.04916853f, 0.04558007f, -0.11195664f, 
    -0.27675146f, -0.05829571f, -0.03090419f, -0.07887000f, 0.10037521f, 0.04082468f, 0.05103265f, 0.10349619f, 
    -0.03156293f, -0.00011819f, -0.06391277f, 0.11421528f, -0.21785949f, -0.01316277f, -0.02916460f, -0.14079614f, 
    -0.01006724f, 0.06264579f, 0.02790120f, 0.15042542f, -0.03514595f, 0.12724879f, -0.09719568f, 0.08521376f, 
    0.11817706f, 0.24586473f, -0.08252373f, -0.06744844f, 0.08536227f, 0.03243788f, 0.09932019f, 0.03163101f, 
    -0.08723030f, -0.14167273f, -0.00533967f, -0.03025490f, -0.27065417f, -0.05138971f, -0.03563083f, -0.11379466f, 
    -0.04033184f, -0.02898927f, 0.08809830f, 0.00238685f, 0.02083817f, 0.10244931f, -0.02908327f, -0.01649999f, 
    -0.15987720f, 0.01594095f, -0.01713946f, 0.12447595f, 0.08782250f, 0.03824655f, 0.07054473f, -0.03153881f, 
    0.03200029f, 0.08336385f, 0.05123654f, -0.15757519f, -0.07893436f, -0.03105180f, -0.05729628f, -0.10217515f, 
    0.03629506f, -0.05448128f, 0.10420952f, 0.01899131f, -0.06108955f, -0.04883241f, 0.01340032f, 0.01454696f, 
    -0.16171297f, -0.02916086f, 0.14030887f, 0.03941097f, -0.02951708f, -0.05522811f, 0.11391358f, 0.17906132f, 
    -0.02924266f, 0.13126981f, 0.17750409f, 0.05731322f, 0.29196286f, 0.09503897f, -0.00942694f, 0.25567615f, 
    -0.04947974f, 0.05417188f, 0.11853006f, 0.09284579f, 0.04419748f, 0.10344071f, -0.01454871f, 0.05429012f, 
    0.16947132f, 0.17927675f, -0.00613242f, 0.03894098f, 0.03772690f, -0.01824533f, -0.00852056f, -0.00978232f, 
    -0.00559493f, 0.07986568f, 0.12962256f, -0.12321275f, -0.20640595f, -0.10349089f, 0.12905718f, 0.05702837f, 
    -0.02866347f, -0.05930779f, -0.05677095f, -0.02293857f, 0.03261904f, 0.04027446f, 0.11432195f, 0.13028073f, 
    -0.00879154f, 0.00175105f, 0.03071287f, -0.00445350f, -0.04459172f, 0.03599868f, -0.03368538f, -0.05946194f, 
    -0.02340076f, -0.00989234f, -0.04022643f, -0.02794445f, -0.00511913f, -0.02699055f, -0.04852715f, -0.02890366f, 
    -0.05020782f, -0.02738802f, -0.02423914f, -0.03449930f, 0.00910966f, 0.03912820f, 0.00261890f, -0.05431798f, 
    -0.06139891f, -0.03285374f, -0.04502821f, 0.02563486f, 0.01313551f, -0.03065460f, 0.01378961f, 0.00802927f, 
    -0.03956133f, -0.02633656f, 0.03301779f, -0.01209738f, -0.04330394f, 0.01904311f, 0.00891131f, -0.02464664f, 
    -0.01026860f, 0.03921513f, -0.01466208f, 0.03121267f, 0.04532488f, 0.02909148f, -0.00988442f, 0.01095981f, 
    0.01697196f, 0.01105368f, -0.01365450f, -0.03835578f, 0.04266673f, -0.05175509f, -0.04259165f, 0.00286994f, 
    0.00627162f, -0.05483070f, 0.04903695f, 0.00671838f, 0.03975680f, -0.01793755f, -0.01766665f, 0.03496956f, 
    -0.05120608f, 0.03423112f, 0.00570567f, 0.04898220f, 0.02198419f, 0.00607275f, 0.03712818f, 0.04017195f, 
    0.03534021f, -0.02703559f, -0.00826155f, 0.02563399f, -0.05657908f, -0.03068888f, 0.00516846f, 0.03073378f, 
    0.00596735f, -0.00165486f, -0.00018913f, 0.00946718f, 0.03938841f, 0.03138486f, -0.04145098f, 0.04978841f, 
    0.02817203f, -0.05256652f, 0.02869630f, 0.00415344f, 0.00697391f, -0.03474548f, -0.06085911f, -0.02667668f, 
    -0.02002191f, -0.05776969f, 0.01243900f, 0.00152321f, -0.00382817f, -0.00073228f, -0.00617915f, 0.02376078f, 
    -0.04920869f, 0.01100006f, -0.02784614f, 0.01917629f, 0.03166268f, -0.02883260f, 0.02019595f, 0.00347605f, 
    -0.01062653f, 0.01191574f, 0.03379219f, -0.00239905f, 0.04748105f, 0.00123109f, 0.01483148f, -0.02251056f, 
    0.02332858f, 0.04168834f, -0.00771686f, 0.05288632f, -0.02357014f, -0.00299284f, 0.02499918f, 0.02226424f, 
    0.03592710f, 0.02418759f, 0.01861852f, -0.00028958f, -0.03335534f, -0.00720148f, 0.00595690f, 0.01334085f, 
    0.03389696f, -0.01745755f, 0.02244855f, 0.03220579f, -0.05591910f, -0.01922358f, -0.02841446f, 0.00899256f, 
    0.01083135f, 0.02820244f, -0.02016784f, 0.00873517f, -0.03340784f, 0.02653994f, 0.02415130f, 0.02823578f, 
    0.01641970f, -0.02287403f, -0.01628040f, -0.04408757f, -0.04345180f, 0.00522002f, 0.05244349f, -0.04183588f, 
    -0.05129292f, 0.01909127f, 0.01413804f, 0.05218171f, 0.00981174f, 0.00334601f, -0.02938129f, -0.05378420f, 
    0.02584166f, -0.03303301f, -0.00005112f, -0.01017369f, -0.00913568f, -0.05436411f, -0.04235763f, -0.00171655f, 
    -0.00686258f, -0.04417245f, -0.03270809f, -0.03878558f, 0.04830987f, -0.01886982f, -0.05053538f, -0.06179523f, 
    -0.01851593f, 0.02603570f, -0.03664127f, -0.02841352f, -0.01911545f, -0.04369106f, -0.00828496f, -0.04410881f, 
    0.01032285f, 0.01787985f, -0.01841339f, 0.04941269f, -0.00481303f, -0.05804247f, 0.03006496f, -0.02427478f, 
    -0.04521073f, -0.00899677f, 0.03660870f, 0.01841888f, -0.00211249f, -0.05108001f, 0.01640596f, -0.04065226f, 
    0.02952926f, 0.02299762f, -0.00163362f, 0.02543007f, 0.02916988f, 0.01864250f, -0.05019132f, 0.00439656f, 
    -0.00607030f, 0.00205193f, 0.04256969f, -0.02591767f, 0.00039520f, -0.05449121f, 0.03683461f, 0.00068893f, 
    -0.05464334f, 0.00521409f, 0.01202039f, -0.00581975f, -0.00010476f, 0.02501003f, -0.00185915f, -0.01355878f, 
    0.02931991f, 0.03601107f, 0.02011822f, 0.02060428f, -0.04961390f, -0.03388929f, -0.01833248f, -0.02208735f, 
    -0.00999753f, -0.00452356f, 0.01918482f, 0.03926503f, 0.02461992f, -0.00251337f, 0.02745782f, -0.00469320f, 
    -0.01506547f, -0.00256758f, -0.05963376f, 0.00863972f, 0.01462890f, 0.02073418f, 0.05486156f, 0.02821078f, 
    0.01468648f, -0.01550853f, -0.04627850f, 0.04499913f, -0.02102257f, -0.00386672f, -0.00153251f, -0.03569864f, 
    0.04750310f, -0.02829747f, 0.01794823f, -0.05212761f, -0.00019722f, -0.00818518f, 0.04457624f, 0.01032731f, 
    -0.00085830f, -0.03670629f, -0.04659360f, -0.03016534f, 0.01775467f, 0.00537325f, 0.02620366f, -0.03331240f, 
    -0.04857157f, 0.00516653f, -0.03633137f, 0.02222203f, -0.05633439f, 0.02062210f, -0.00591666f, -0.03916314f, 
    -0.03262445f, 0.01314999f, -0.01049567f, -0.01220696f, 0.02738365f, 0.03779358f, -0.01729869f, -0.00625854f, 
    0.00282502f, 0.03616168f, -0.02561988f, -0.01681679f, -0.01144592f, -0.03044052f, -0.02397638f, 0.01915254f, 
    -0.03823515f, 0.00616509f, 0.00574070f, -0.05834861f, -0.04684287f, -0.01208174f, 0.03038063f, -0.04316239f, 
    0.00634490f, 0.02002847f, -0.03792433f, 0.01810529f, -0.02997328f, 0.02952282f, 0.04240240f, 0.04668519f, 
    0.00940713f, -0.03439862f, -0.01402884f, -0.05656854f, 0.05224302f, -0.02233154f, 0.00482505f, -0.03127514f, 
    -0.00117316f, -0.03251982f, -0.03157873f, -0.03136892f, -0.00231135f, -0.00870190f, -0.01796133f, -0.01099486f, 
    -0.02323862f, -0.04227341f, -0.05644296f, 0.02019679f, -0.02699843f, -0.02209064f, 0.03845755f, 0.01740721f, 
    0.02652557f, -0.04689047f, -0.04734363f, 0.00829102f, 0.02073526f, -0.00431842f, -0.00774446f, 0.03529481f, 
    -0.02227286f, -0.02901249f, -0.00642241f, -0.03905766f, -0.03054507f, -0.04512925f, 0.01240786f, 0.02625240f, 
    -0.01809304f, -0.00770639f, 0.02667896f, -0.01784731f, -0.04988425f, 0.00191913f, 0.01184034f, -0.03570578f, 
    0.03503002f, 0.02370586f, -0.00655175f, 0.00707756f, -0.00004088f, -0.05985055f, -0.01843800f, 0.02455732f, 
    0.00930065f, -0.05002943f, 0.04912383f, 0.04560176f, -0.02506747f, -0.04890954f, -0.00069878f, 0.03253816f, 
    -0.05402151f, 0.01669350f, -0.07213432f, 0.01794061f, 0.13405059f, 0.04161790f, -0.01171948f, 0.00994879f, 
    0.05700602f, 0.01142422f, 0.09984723f, 0.07898460f, 0.04564923f, -0.08132524f, -0.06793316f, 0.29205877f, 
    0.01136174f, 0.10403359f, 0.00902879f, 0.10905237f, 0.06578466f, 0.01277230f, -0.00919998f, 0.02376816f, 
    0.01454125f, -0.00583675f, 0.03134191f, -0.09709473f, -0.03367019f, -0.04919191f, 0.08060152f, 0.06609025f, 
    -0.15218313f, 0.04580860f, -0.05724245f, 0.03273861f, 0.34573585f, -0.10310279f, -0.01601678f, -0.02581736f, 
    -0.01445432f, 0.12031671f, 0.06116752f, -0.02495622f, -0.04466702f, -0.05176850f, -0.00343408f, -0.06461126f, 
    -0.21433708f, -0.36870006f, 0.04764691f, 0.04728047f, -0.04844446f, 0.11198857f, 0.09265634f, 0.00942724f, 
    -0.00412078f, -0.05781473f, 0.08823833f, -0.00352097f, -0.22622383f, -0.01529431f, 0.11203673f, -0.09491544f, 
    0.12780312f, 0.08396210f, 0.05221289f, 0.00775087f, 0.02871537f, 0.03049266f, -0.03065546f, 0.05325751f, 
    -0.22080533f, -0.07926146f, 0.17317975f, 0.12150677f, 0.12967731f, 0.03361340f, -0.07036248f, 0.07880493f, 
    0.04817912f, -0.02835739f, -0.04364847f, 0.01190950f, 0.28368357f, 0.31670451f, 0.11288419f, -0.17098022f, 
    -0.04562498f, -0.09045222f, -0.01417823f, 0.09712724f, 0.05899315f, -0.00736536f, 0.00076358f, -0.08619288f, 
    0.06141104f, -0.15000318f, -0.00493744f, -0.02608683f, -0.00290971f, -0.15112524f, 0.12247691f, 0.04117369f, 
    -0.07146525f, 0.04068013f, 0.00556691f, 0.03972339f, 0.25738233f, -0.12443282f, -0.07628976f, -0.09445394f, 
    -0.05390262f, -0.01305701f, -0.06646095f, -0.02810771f, -0.11106119f, 0.04603715f, 0.00911004f, -0.02714700f, 
    -0.31501544f, -0.15307149f, 0.04011966f, 0.06696314f, 0.02710121f, 0.11629456f, 0.01557204f, -0.15116639f, 
    0.13810296f, -0.02648103f, 0.00246260f, -0.01116252f, 0.06597335f, 0.00200173f, 0.07676695f, 0.01213060f, 
    0.00537085f, 0.04431070f, 0.05706834f, 0.04110135f, 0.08505615f, 0.13692084f, 0.08734896f, -0.00134110f, 
    -0.12704153f, -0.15479989f, -0.08190993f, -0.02228802f, 0.11853927f, 0.07394244f, 0.04259501f, 0.01654555f, 
    0.10085102f, -0.06702944f, -0.03465348f, 0.04507985f, -0.11344696f, -0.04951179f, 0.03040083f, 0.10672826f, 
    0.04752712f, 0.08158386f, -0.07339730f, -0.06430613f, 0.02921267f, 0.04158426f, 0.07570791f, 0.08324276f, 
    0.20460628f, -0.15644604f, -0.00736403f, 0.09401907f, -0.10178145f, -0.00191255f, 0.07018784f, 0.14851651f, 
    -0.01756632f, 0.02974323f, -0.02785251f, 0.11264445f, 0.14465868f, 0.15260392f, -0.21705028f, -0.19536218f, 
    -0.01151556f, -0.00961302f, 0.14160311f, -0.05553408f, 0.07476513f, -0.01413119f, -0.03146130f, 0.00354592f, 
    -0.18988737f, -0.00194836f, 0.16308907f, 0.22454432f, -0.16373190f, 0.01965422f, -0.10030030f, 0.02812556f, 
    0.06717471f, 0.05358845f, 0.08416612f, 0.15157877f, 0.12660782f, 0.09330362f, -0.16756518f, -0.07165943f, 
    0.08927769f, 0.07923068f, 0.00955780f, -0.03619091f, -0.02984804f, 0.15674405f, -0.06035242f, 0.01340246f, 
    0.15479758f, -0.00041032f, 0.00135384f, 0.22501372f, 0.06068255f, 0.01525914f, 0.00821938f, 0.10769214f, 
    -0.00806061f, 0.02796486f, 0.06440994f, 0.15369554f, 0.03114595f, 0.15572448f, -0.08354017f, -0.19348440f, 
    0.03113942f, -0.04129542f, -0.07558040f, -0.01686645f, 0.16739260f, -0.07007909f, 0.02524315f, -0.00020166f, 
    0.17407680f, 0.06663600f, 0.02502183f, -0.04390359f, -0.04993050f, 0.09872749f, -0.12774679f, 0.06421641f, 
    -0.11691416f, 0.06193020f, 0.04265691f, 0.10698984f, -0.33874285f, 0.01365136f, 0.11688904f, -0.04385777f, 
    0.06081074f, 0.00187602f, -0.12836179f, -0.02117626f, 0.10577624f, 0.05425093f, 0.06875397f, 0.00828125f, 
    0.03394458f, -0.00146599f, 0.01288625f, 0.14713079f, 0.00419121f, -0.16550177f, -0.03567182f, 0.03774965f, 
    0.20636557f, -0.11128344f, 0.05350915f, 0.12005161f, -0.10011657f, 0.01466473f, 0.01728890f, 0.09375879f, 
    -0.05828153f, -0.04604222f, 0.02081329f, 0.08069400f, 0.00437299f, 0.01926712f, 0.10758827f, 0.05157789f, 
    -0.01779360f, -0.05254623f, 0.03046249f, -0.08749442f, -0.00560314f, 0.01818949f, 0.01095715f, 0.07902908f, 
    0.06035238f, -0.01671963f, -0.00849007f, 0.00580566f, -0.07582162f, 0.16112834f, 0.04757664f, 0.17114085f, 
    0.03014492f, -0.04390764f, 0.16190393f, 0.06637741f, 0.04957573f, -0.00840006f, 0.09268699f, -0.13674155f, 
    -0.00950126f, -0.03999208f, 0.00978410f, -0.13039370f, 0.06336944f, 0.08518130f, 0.03698029f, -0.06361473f, 
    0.05136703f, -0.02983236f, 0.04696139f, -0.03440072f, 0.05193008f, -0.08076362f, -0.02605376f, 0.10530046f, 
    -0.07723171f, 0.03662992f, 0.03629110f, 0.10941005f, -0.04380672f, 0.17193647f, 0.13093206f, 0.01752009f, 
    0.31209508f, -0.03291700f, 0.05109852f, 0.17538559f, 0.06468274f, 0.06410639f, 0.00497061f, 0.07369944f, 
    0.02748230f, -0.08843575f, 0.04775903f, 0.00829662f, -0.11162578f, 0.17686492f, -0.03043403f, -0.32915238f, 
    -0.06849038f, -0.04714840f, 0.05647518f, 0.01934258f, -0.00754866f, 0.06810039f, -0.03402035f, 0.11162613f, 
    -0.11384986f, -0.07042145f, -0.03374449f, -0.05593222f, -0.00976849f, -0.04984269f, 0.01478432f, 0.03836646f, 
    -0.00388716f, 0.02358788f, 0.14047143f, -0.01012788f, -0.30720878f, 0.03487382f, 0.20624354f, 0.07337689f, 
    0.03427849f, 0.00212836f, 0.04555599f, -0.10733670f, 0.04228240f, -0.09181315f, 0.04377620f, 0.05007872f, 
    -0.05181659f, -0.04406348f, 0.01102923f, -0.04057883f, -0.03664443f, -0.05144748f, -0.04880976f, 0.03232130f, 
    -0.01494279f, -0.02154448f, -0.01263995f, 0.00899938f, -0.01042793f, -0.04579451f, -0.02208466f, 0.03082733f, 
    -0.01986825f, -0.05065826f, -0.03000749f, -0.03889121f, 0.02604649f, 0.02308536f, -0.05489529f, -0.03979548f, 
    -0.01591675f, 0.01504554f, 0.02578406f, 0.00827372f, 0.00963998f, 0.03736234f, 0.00191029f, 0.02181585f, 
    -0.02021973f, -0.04967851f, -0.01766519f, -0.01302778f, 0.01282223f, 0.01210270f, -0.01554074f, 0.01940720f, 
    -0.00613361f, -0.02333479f, -0.02975494f, -0.02898807f, -0.02999569f, -0.03133508f, -0.02401663f, 0.02050941f, 
    -0.03254867f, -0.02687209f, 0.01177778f, 0.00027297f, -0.03377948f, -0.00594049f, 0.01878709f, -0.05360647f, 
    0.02624298f, -0.01039093f, 0.02542920f, -0.01971439f, 0.01089934f, -0.01893994f, 0.02291801f, -0.00556659f, 
    0.03390281f, 0.01449406f, 0.02139604f, 0.03427337f, 0.03644255f, 0.02856991f, -0.03180666f, -0.00188241f, 
    -0.01899579f, -0.05367706f, 0.00799603f, -0.04644664f, 0.00832200f, 0.03051556f, 0.03192459f, 0.02350336f, 
    -0.01823709f, -0.00775420f, 0.00026981f, 0.04086604f, -0.02296161f, -0.00979477f, -0.01215416f, 0.01430442f, 
    0.01614673f, 0.00473135f, 0.01733912f, -0.03767619f, 0.03201975f, -0.02971797f, -0.00304830f, -0.04196612f, 
    -0.03197402f, 0.01761934f, 0.03941985f, 0.01256887f, -0.01595052f, 0.00101756f, -0.01372211f, -0.02528574f, 
    0.00157297f, -0.02399790f, -0.03222593f, -0.01012454f, 0.01676084f, 0.03924654f, -0.02627331f, -0.02199128f, 
    0.01006416f, -0.01219173f, 0.01907681f, 0.02860153f, -0.01959321f, -0.00739376f, -0.02001839f, 0.03441493f, 
    0.04070658f, -0.00110339f, 0.03490908f, 0.01563819f, 0.02460053f, -0.05609035f, 0.03974243f, -0.04142027f, 
    0.03722204f, -0.01962801f, 0.02920913f, 0.01497355f, -0.02019133f, -0.03908661f, -0.05710758f, 0.03158479f, 
    -0.03643742f, -0.03465984f, -0.02266301f, -0.03076017f, 0.00249315f, -0.04687832f, 0.01346947f, 0.02818643f, 
    0.00200473f, 0.02300076f, 0.03902761f, 0.01015653f, -0.03742828f, -0.01084674f, -0.02411153f, 0.02724478f, 
    -0.02224189f, -0.02964868f, -0.03914342f, -0.04450807f, -0.02172871f, 0.03005307f, 0.01022748f, -0.04513958f, 
    -0.02897081f, 0.03202768f, -0.00871878f, 0.01322822f, 0.01735246f, -0.05780423f, 0.01488849f, -0.02780772f, 
    0.00685177f, -0.05608866f, -0.05117363f, -0.03350603f, 0.00628749f, -0.03199269f, 0.01807616f, -0.04978761f, 
    -0.04539941f, -0.03401515f, -0.03688290f, -0.00562257f, -0.03782345f, -0.03075805f, 0.02034998f, -0.03111706f, 
    -0.04702486f, -0.01239551f, 0.01457428f, 0.02084689f, -0.03335914f, -0.01764965f, 0.02645692f, 0.03865024f, 
    0.02867137f, 0.01804785f, 0.04044480f, -0.04173282f, -0.03236817f, -0.04642813f, -0.04566117f, -0.04298292f, 
    -0.00372330f, -0.01830574f, 0.03746278f, 0.04085735f, 0.02609519f, 0.00638188f, 0.00712895f, -0.05937695f, 
    0.02635752f, 0.00305073f, 0.03142638f, 0.02509161f, 0.02677424f, 0.00555753f, 0.03043735f, 0.00794746f, 
    0.02975033f, 0.03618571f, -0.01672441f, -0.04615209f, 0.00020490f, -0.00403539f, 0.02256000f, -0.01191963f, 
    -0.02003009f, -0.05044404f, 0.03483432f, 0.03793961f, 0.01139836f, -0.04853549f, -0.03848254f, -0.00360335f, 
    0.03476575f, -0.03569664f, -0.05003704f, -0.00203768f, 0.02490209f, 0.03933228f, 0.02755975f, -0.05825588f, 
    0.01636749f, -0.01370884f, -0.00806850f, 0.03801468f, -0.00464490f, 0.03319345f, -0.03905649f, 0.01858725f, 
    0.02254603f, -0.04194544f, 0.01431224f, -0.02784439f, -0.02172144f, -0.01404230f, -0.04764330f, -0.04238119f, 
    0.04321181f, 0.02331142f, -0.00128760f, 0.00945113f, 0.01182987f, 0.00072501f, -0.03609937f, 0.01289216f, 
    -0.03001381f, -0.02837955f, -0.05604546f, -0.02535367f, -0.04614225f, -0.05040339f, -0.03104293f, -0.00356666f, 
    0.00591973f, 0.03465447f, 0.02027447f, 0.00651415f, 0.00914715f, -0.03939543f, -0.03910984f, 0.03187963f, 
    -0.04250998f, -0.00341924f, -0.02792710f, 0.00071480f, 0.00134270f, 0.03276589f, -0.02821700f, -0.01824686f, 
    0.02307293f, -0.00607463f, -0.00612889f, -0.03933159f, -0.05109845f, -0.01007978f, -0.01603074f, -0.02402011f, 
    -0.04718213f, -0.00219173f, 0.03900623f, -0.01622548f, -0.04706477f, -0.04755991f, -0.03750565f, -0.03854482f, 
    -0.04265766f, -0.02173218f, -0.03777671f, 0.00434999f, 0.00113360f, 0.03151308f, -0.04157233f, -0.04117528f, 
    -0.02718264f, -0.02784665f, -0.02619286f, -0.02837418f, 0.02536657f, -0.03671909f, -0.01589189f, -0.03046097f, 
    -0.04121803f, 0.00871339f, -0.01644472f, 0.04091194f, -0.00208609f, -0.03527489f, 0.03620695f, 0.01583964f, 
    -0.05435079f, -0.03561482f, -0.02231142f, -0.04629331f, 0.00647345f, -0.02919089f, 0.00563446f, -0.01552835f, 
    -0.02545570f, 0.00718982f, -0.03480223f, -0.03988199f, 0.01578183f, 0.03786850f, 0.02625534f, -0.03722341f, 
    -0.00436216f, 0.02983809f, -0.04866630f, 0.00314122f, -0.04358279f, -0.05652725f, -0.03433712f, -0.00122519f, 
    0.02367607f, -0.04631421f, -0.01041837f, 0.00304314f, 0.03560418f, -0.01863860f, -0.03159641f, 0.00229614f, 
    -0.00009889f, -0.05842400f, -0.01230997f, -0.02531844f, 0.00443155f, -0.04447110f, -0.02921929f, -0.02524859f, 
    -0.02040671f, -0.02149820f, -0.05278770f, -0.04617639f, -0.04012848f, 0.03886418f, -0.02417390f, 0.00620054f, 
    -0.02068090f, 0.02945911f, 0.03440300f, -0.00646866f, 0.00355121f, -0.02990740f, 0.01306031f, -0.05414866f, 
    -0.13788907f, -0.09731239f, -0.18896367f, 0.23057744f, 0.05658864f, 0.00585422f, -0.02251112f, 0.19860348f, 
    0.04185942f, -0.02150838f, -0.02184081f, 0.05074937f, 0.04110114f, 0.14115553f, -0.11874036f, 0.14537515f, 
    0.08321360f, 0.01383057f, 0.01891822f, 0.08321828f, 0.08525986f, 0.02107818f, 0.05808050f, -0.05235691f, 
    -0.01126738f, -0.11895453f, 0.10902303f, -0.03418414f, 0.04077863f, 0.05923272f, 0.11555459f, 0.20640874f, 
    0.03585543f, 0.05319506f, 0.03848910f, -0.11490419f, -0.13740136f, 0.21305028f, -0.08924807f, -0.04169358f, 
    0.05282148f, 0.01979538f, -0.01661675f, 0.12017031f, 0.00663476f, -0.01909095f, -0.12124632f, 0.01918935f, 
    0.01470613f, -0.23766573f, 0.36837113f, -0.39986470f, -0.14679553f, -0.02654571f, 0.15001856f, -0.02496081f, 
    -0.00025378f, -0.02118557f, 0.00580312f, 0.04451295f, -0.19832106f, -0.09359121f, 0.19626115f, -0.14167543f, 
    -0.05090822f, 0.10303701f, 0.02383907f, 0.00756682f, 0.04220455f, -0.01949553f, 0.02994977f, 0.05241247f, 
    0.06587024f, -0.06041110f, 0.06313901f, 0.09852770f, -0.02375475f, 0.05413393f, 0.06104152f, 0.05430675f, 
    0.05884928f, -0.05440972f, -0.04328591f, 0.03586186f, 0.04148328f, 0.23118417f, 0.06852530f, 0.26197642f, 
    0.07101205f, -0.01759033f, -0.00438462f, 0.05367951f, -0.11825401f, 0.03768718f, 0.03507729f, 0.01030727f, 
    0.04804774f, -0.22370990f, 0.09517273f, -0.14460394f, -0.03356066f, -0.01555997f, 0.07269069f, 0.06674644f, 
    0.06305338f, 0.09212856f, 0.05395031f, 0.03772559f, -0.02671167f, -0.23745778f, -0.00578204f, -0.10379043f, 
    0.05426749f, -0.09247573f, 0.01733201f, 0.16523491f, 0.09608876f, -0.05368079f, 0.02087575f, 0.01696029f, 
    0.06800603f, 0.12944718f, 0.05007401f, 0.13514994f, 0.00520455f, 0.04606380f, 0.02883699f, -0.01125246f, 
    0.07803854f, 0.09098347f, -0.00193151f, 0.01307545f, -0.07193466f, -0.22897024f, -0.02944650f, 0.03815016f, 
    -0.03695549f, -0.02745218f, -0.00059450f, 0.03470895f, 0.06729846f, 0.14211029f, 0.02278246f, -0.01425779f, 
    -0.16849642f, -0.12503043f, -0.06950682f, -0.15199670f, 0.06231837f, 0.05306746f, 0.05385314f, 0.04699416f, 
    0.11543037f, 0.04423672f, 0.16785473f, -0.04587359f, 0.25235251f, 0.01869761f, 0.21681714f, -0.11429714f, 
    0.12989233f, 0.06688411f, -0.01836533f, -0.06423179f, 0.00390261f, 0.01715828f, 0.06939203f, 0.20540157f, 
    0.19326384f, -0.06969997f, 0.15505667f, 0.02822726f, 0.07829446f, 0.00511215f, 0.03246728f, 0.07604069f, 
    -0.01435137f, 0.00117176f, -0.06399580f, 0.08544938f, 0.18378352f, 0.13694993f, -0.35309982f, -0.39727482f, 
    0.03648322f, 0.00204175f, 0.01523811f, 0.06007070f, -0.04748246f, 0.06289332f, 0.05679762f, 0.00660575f, 
    0.38198629f, -0.04990381f, 0.15124054f, 0.35055831f, -0.04392378f, 0.06424008f, 0.07610475f, 0.06105039f, 
    -0.03004307f, 0.07326292f, 0.05803023f, -0.03078846f, -0.06054522f, 0.17261593f, -0.22163551f, -0.08942248f, 
    -0.22863725f, -0.00549042f, -0.02619195f, 0.02516472f, 0.04385456f, -0.00426280f, -0.01511635f, -0.01948183f, 
    0.16323432f, 0.12001127f, -0.03633618f, 0.18871754f, 0.03717902f, 0.03646249f, 0.04808068f, -0.02895532f, 
    0.04528621f, 0.15042645f, 0.03620983f, 0.07646453f, -0.30322075f, 0.27755079f, 0.05477967f, -0.27481985f, 
    0.05075265f, 0.09418952f, 0.00166103f, -0.09347991f, 0.08435064f, 0.06794474f, 0.04824407f, -0.00080513f, 
    -0.04303771f, -0.02489257f, -0.02016080f, -0.01813714f, 0.05314080f, 0.03232225f, -0.02814623f, 0.06300859f, 
    -0.05433238f, -0.06327412f, 0.05470308f, 0.02002538f, 0.07752828f, 0.06332376f, 0.13701010f, -0.22144549f, 
    0.04745382f, 0.05800022f, -0.05907358f, -0.01002795f, 0.03803287f, 0.04552100f, -0.02807962f, 0.08956341f, 
    0.00815519f, 0.17274721f, -0.01447652f, -0.06902370f, 0.07335746f, -0.04066409f, -0.02398682f, 0.05365734f, 
    0.00218106f, -0.00832272f, 0.05733004f, -0.00248070f, 0.24536917f, 0.08394340f, 0.04013591f, 0.10243294f, 
    0.05298784f, 0.01257532f, -0.06863769f, 0.04633345f, 0.16833553f, -0.06213784f, 0.06816296f, 0.16609895f, 
    0.12000504f, 0.10461077f, 0.05964298f, 0.03021873f, 0.00114509f, -0.06299588f, -0.08699483f, 0.03374914f, 
    -0.02291024f, 0.03592578f, -0.03269952f, 0.04991860f, 0.32307723f, -0.03753796f, 0.00434068f, 0.28219160f, 
    -0.04442147f, -0.00694698f, 0.02661114f, 0.02630029f, 0.01215179f, -0.01944644f, 0.01192094f, -0.04523193f, 
    0.01864011f, -0.07498508f, 0.07625806f, -0.21684280f, 0.10710408f, 0.01112877f, -0.07527126f, 0.03102864f, 
    -0.00763802f, -0.08984314f, -0.08609157f, 0.02196634f, 0.06282356f, 0.09553600f, -0.03111252f, 0.13277379f, 
    0.11317083f, -0.01835855f, -0.11985739f, 0.11271781f, -0.04950731f, -0.09775156f, 0.03219290f, 0.06775010f, 
    0.13615353f, -0.19262913f, -0.01272143f, -0.04893098f, 0.10379690f, 0.03235672f, 0.05057626f, -0.02369057f, 
    0.05591762f, 0.09410837f, 0.05976722f, -0.00588387f, -0.25349268f, 0.12720357f, -0.07687986f, -0.37147421f, 
    -0.04662512f, 0.00391335f, -0.01971584f, -0.07461969f, -0.05327951f, 0.06712819f, 0.10125381f, 0.01706570f, 
    -0.04165489f, -0.12913392f, -0.06071446f, 0.01210920f, -0.00453370f, 0.00660197f, 0.07504120f, 0.15690011f, 
    0.00208439f, 0.12596621f, 0.03239124f, 0.06084600f, -0.07354264f, 0.11635210f, 0.10378084f, -0.02005561f, 
    -0.05367837f, 0.01372283f, 0.15931053f, 0.02295352f, 0.10191598f, 0.06946311f, -0.02472165f, 0.01944975f, 
    -0.27077001f, 0.18206377f, -0.03059210f, -0.09976865f, 0.12011086f, 0.02908358f, -0.05316444f, 0.00053000f, 
    0.01758353f, 0.13280734f, 0.00053862f, -0.12134690f, -0.25617301f, 0.11589555f, 0.19709457f, -0.15975922f, 
    0.03080602f, -0.04560414f, 0.09898636f, -0.07729042f, -0.04891074f, -0.04966702f, 0.00662875f, 0.09609125f, 
    0.02610087f, -0.08309726f, -0.07087727f, 0.12802219f, 0.04622603f, 0.06279802f, 0.18099576f, 0.04317741f, 
    0.11269639f, -0.06160538f, 0.00027155f, 0.10398290f, -0.24468577f, -0.01692964f, -0.01958427f, -0.00141621f, 
    0.04550547f, 0.03184700f, -0.01540025f, 0.02276747f, 0.03726814f, -0.04751270f, 0.04629640f, 0.14171596f, 
    -0.00349584f, 0.14447679f, 0.18896566f, -0.03427375f, -0.01704874f, -0.03931722f, 0.05388645f, 0.00559777f, 
    0.04027687f, 0.02106069f, -0.07582194f, 0.03514351f, 0.12816353f, 0.13504711f, 0.15079217f, 0.35265166f, 
    -0.08792917f, 0.03089689f, -0.03337679f, -0.04561860f, -0.11158764f, -0.06849412f, 0.01093018f, -0.11986522f, 
    0.37535900f, 0.13755029f, -0.01865227f, -0.08819808f, 0.09520020f, 0.02514694f, 0.06737968f, -0.19517162f, 
    0.07687840f, 0.09494719f, 0.11279164f, 0.08303122f, 0.05176390f, -0.10023700f, -0.12308141f, -0.11030176f, 
    -0.16465455f, 0.00858822f, 0.01374828f, 0.03413450f, -0.04692390f, -0.08950009f, 0.04628820f, -0.00945121f, 
    0.32675174f, -0.04108133f, 0.19429669f, -0.07606955f, 0.18287227f, 0.06807514f, -0.07451022f, -0.03183316f, 
    -0.02849185f, -0.00406320f, -0.04492324f, 0.06049071f, 0.24614379f, -0.07622062f, -0.13408549f, 0.08491332f, 
    0.14099398f, 0.09528162f, 0.04011368f, -0.03663738f, 0.04244410f, -0.06032632f, -0.03283199f, 0.12966995f, 
    0.49913818f, -0.03057933f, -0.11965074f, 0.17520940f, 0.09748479f, -0.02234179f, 0.13856536f, 0.06601945f, 
    -0.07487307f, 0.07680085f, 0.13087296f, 0.02251642f, 0.16566393f, -0.00342546f, -0.11565533f, 0.16734138f, 
    -0.03919772f, -0.05048002f, 0.13758607f, -0.02525755f, -0.00603486f, -0.00211508f, -0.05574348f, 0.12545004f, 
    -0.19163814f, -0.03527484f, 0.22168039f, 0.16238506f, -0.04595574f, -0.04974662f, 0.04810902f, -0.04073068f, 
    0.00452171f, -0.02738520f, -0.09559172f, 0.07605524f, 0.02743561f, -0.09893849f, 0.03197923f, -0.13573413f, 
    0.14284484f, 0.11869288f, -0.03794570f, -0.06343686f, 0.00788102f, 0.01715131f, -0.00180140f, -0.07850814f, 
    0.10905921f, -0.09829298f, 0.09604714f, -0.17106825f, 0.14456479f, 0.05469798f, 0.02842239f, -0.05822144f, 
    0.16677850f, 0.00085782f, -0.01919405f, 0.06490893f, -0.21484433f, -0.03806251f, 0.24641803f, 0.32263204f, 
    -0.03661408f, -0.03742016f, -0.03488065f, 0.03818987f, 0.03188034f, -0.02825523f, 0.13605981f, -0.05598611f, 
    -0.00127328f, -0.02740783f, -0.06051461f, -0.18338391f, 0.04817849f, -0.00635237f, 0.03757853f, 0.00286618f, 
    0.07248351f, -0.04349669f, -0.12562577f, 0.01311823f, -0.35641885f, -0.02302101f, 0.42812935f, 0.18669632f, 
    -0.00387398f, 0.04339532f, 0.04641763f, 0.10049104f, -0.00054332f, -0.01813241f, 0.07630528f, 0.09942356f, 
    -0.32000074f, 0.12442525f, 0.04042671f, -0.07991289f, -0.03648513f, 0.02507460f, 0.04107472f, -0.00628574f, 
    -0.02773608f, -0.09877273f, -0.03947675f, -0.11544471f, -0.13519719f, -0.12212532f, 0.20714964f, 0.13843219f, 
    -0.16359060f, -0.01429806f, 0.00231980f, 0.04272031f, -0.04617910f, -0.05319680f, -0.09080348f, 0.12015371f, 
    0.08225361f, 0.06301990f, 0.02513285f, -0.02473382f, 0.14907598f, -0.00031756f, 0.10606635f, 0.08924911f, 
    0.06135868f, 0.03642568f, 0.03328136f, -0.12641135f, 0.12999043f, -0.08259099f, 0.07838564f, -0.06176955f, 
    -0.18761069f, 0.09766416f, 0.07364242f, 0.01183338f, -0.07039410f, -0.10771283f, 0.02815595f, -0.02001297f, 
    -0.06824202f, 0.00812875f, -0.02858959f, -0.20911039f, -0.07616065f, 0.01722292f, 0.02375942f, -0.07964061f, 
    -0.13770084f, 0.11160824f, -0.05594402f, 0.02657643f, -0.02307223f, 0.05593474f, -0.15675876f, 0.01061812f, 
    -0.00116183f, -0.02648263f, 0.06812231f, 0.12416374f, -0.04004020f, 0.16267754f, -0.05947101f, -0.02714943f, 
    0.03427271f, 0.19550279f, 0.03374266f, 0.03854646f, 0.03705606f, -0.02747382f, 0.10689815f, 0.03876827f, 
    -0.08207503f, 0.03730937f, -0.06048558f, 0.10709158f, -0.09278475f, -0.04301697f, 0.01797001f, -0.11192983f, 
    -0.04457872f, -0.02542559f, 0.03288671f, -0.04623701f, -0.00568743f, -0.08078207f, -0.04652330f, -0.03825491f, 
    -0.21894290f, 0.04866219f, 0.05727112f, -0.00529995f, -0.06431916f, -0.04671491f, 0.11683194f, 0.03036992f, 
    0.05673775f, 0.15115632f, 0.05836230f, 0.01780641f, 0.05233891f, -0.07913826f, -0.18219650f, -0.09389454f, 
    0.04206632f, 0.06171817f, 0.04087633f, -0.01401505f, 0.00646922f, -0.10152010f, -0.06188560f, -0.01731977f, 
    0.18413262f, 0.04908879f, 0.16366600f, -0.12154528f, -0.08444711f, -0.04381168f, 0.18830717f, -0.02120604f, 
    0.00623541f, 0.07648971f, -0.03875633f, 0.03650736f, -0.20326449f, -0.04808091f, 0.22024333f, 0.15623827f, 
    -0.02498700f, 0.04655156f, 0.08050710f, -0.04734621f, 0.09151173f, 0.04838969f, 0.11829559f, -0.02192469f, 
    0.15115160f, -0.00196808f, -0.03944734f, 0.14752391f, 0.07842056f, 0.04572826f, 0.06128739f, 0.02296495f, 
    0.03672387f, 0.03851521f, -0.09461955f, -0.10247091f, 0.20282780f, 0.00995320f, 0.10171165f, 0.05506223f, 
    -0.06137927f, -0.08796600f, -0.11108181f, -0.03469921f, 0.01104017f, 0.07932094f, 0.14762619f, 0.15087691f, 
    0.09275053f, -0.00485376f, 0.17049074f, 0.06462881f, 0.04731115f, 0.00389294f, 0.06334601f, -0.06261598f, 
    -0.00174614f, -0.02436416f, 0.05169837f, -0.08138356f, -0.02977080f, -0.07505814f, 0.05835973f, -0.02158459f, 
    -0.07769564f, 0.05891015f, 0.01956133f, 0.01506507f, 0.07777573f, 0.09466723f, -0.03011099f, 0.05675322f, 
    -0.10132702f, 0.23687276f, 0.02791551f, 0.07696761f, -0.06740195f, -0.12080628f, -0.05708328f, -0.00933078f, 
    -0.12699831f, 0.08057593f, 0.03037531f, 0.14704485f, 0.42619711f, -0.04197438f, 0.06183505f, -0.10953522f, 
    0.00689678f, 0.04760412f, -0.00972506f, -0.03857044f, 0.05849187f, -0.08253098f, 0.05101033f, -0.02895517f, 
    -0.04921851f, -0.14435895f, -0.28987437f, 0.29584956f, 0.01334008f, 0.08642218f, 0.07543720f, 0.01493537f, 
    -0.01151155f, -0.03800525f, 0.00582468f, -0.14439167f, -0.15572454f, -0.14498554f, -0.14398949f, 0.02938586f, 
    0.02285482f, -0.09395204f, -0.00543055f, -0.01712158f, 0.12740456f, -0.00372619f, -0.06919370f, -0.00592428f, 
    -0.15820654f, -0.00915607f, -0.21400289f, 0.05707305f, 0.12667949f, -0.04223261f, -0.13690063f, -0.17185271f, 
    -0.09400458f, 0.04920889f, 0.05470318f, -0.00895090f, -0.05298695f, 0.11847819f, 0.20582783f, -0.00154405f, 
    0.09425101f, 0.06362937f, 0.02388409f, -0.00230573f, 0.14791842f, 0.08708945f, 0.11739940f, -0.10619285f, 
    -0.15062931f, 0.27369973f, 0.07304124f, 0.11965239f, 0.04167012f, 0.00060281f, 0.09012163f, 0.09456480f, 
    -0.05892593f, 0.02744368f, 0.03949785f, -0.01489841f, 0.22404695f, 0.27459902f, -0.06272204f, 0.13850375f, 
    -0.09296611f, 0.09120098f, -0.05089121f, 0.00587948f, -0.10534001f, -0.06083537f, 0.04111170f, -0.05464517f, 
    -0.15858169f, -0.20344993f, -0.03028543f, -0.09425180f, -0.06652083f, 0.11554091f, -0.05902821f, -0.00039250f, 
    0.07557575f, -0.03708565f, -0.00761878f, -0.06385012f, 0.11711624f, 0.08117092f, 0.12134315f, 0.12166028f, 
    -0.00538440f, 0.08119277f, 0.11825659f, 0.07668829f, 0.05722255f, -0.06285980f, 0.01655548f, -0.16809361f, 
    0.03680024f, 0.13320608f, 0.33092922f, -0.06059120f, 0.08831229f, 0.01947246f, 0.00761733f, 0.14556538f, 
    0.05989294f, 0.03048080f, -0.20734608f, -0.05933703f, -0.32242736f, -0.02621095f, -0.04651121f, 0.03645714f, 
    -0.16196226f, 0.02878458f, -0.02405189f, 0.18481757f, 0.01218009f, -0.07161703f, 0.07708621f, 0.03630158f, 
    -0.29893461f, 0.20186843f, -0.00438307f, 0.27392706f, -0.10472149f, -0.01186557f, 0.05885772f, 0.05424649f, 
    0.06137385f, 0.01152441f, 0.00835938f, 0.02456750f, 0.31223848f, 0.05583850f, 0.01222333f, 0.18694641f, 
    0.04012276f, -0.14065675f, 0.05285431f, -0.21713398f, 0.03901479f, -0.08830775f, -0.11311204f, -0.03211087f, 
    -0.14403489f, 0.01744268f, 0.01031825f, -0.04609460f, -0.20083611f, 0.01690968f, 0.07203423f, 0.01401498f, 
    0.01016856f, -0.00922010f, 0.12265518f, 0.11272839f, 0.72088432f, 0.19381456f, -0.04338359f, -0.19030789f, 
    0.10818129f, 0.02845031f, 0.08518127f, -0.08213854f, -0.07917237f, 0.04374582f, 0.00748112f, 0.04244758f, 
    -0.10105387f, -0.08536226f, 0.00486331f, -0.07216392f, -0.09204813f, -0.03103615f, 0.00885064f, 0.01181841f, 
    -0.03501777f, 0.00648609f, 0.13858059f, 0.03428933f, 0.26882145f, 0.28343436f, 0.06999172f, 0.03930167f, 
    0.06287733f, -0.11339806f, -0.07796010f, 0.06529564f, 0.08663043f, -0.03851284f, 0.01056257f, -0.11196484f, 
    0.00979122f, 0.21211903f, 0.14589810f, 0.11859684f, 0.00286833f, 0.08891850f, -0.05232007f, 0.07455783f, 
    -0.03551257f, 0.07881101f, 0.07265265f, 0.00167717f, -0.40940326f, -0.25034180f, -0.09809419f, 0.08264186f, 
    0.10512909f, 0.00720363f, -0.12556337f, 0.00234491f, -0.01236012f, -0.13700023f, -0.03571873f, -0.16003273f, 
    -0.14227563f, -0.17856550f, 0.08463996f, -0.01637808f, 0.00060517f, -0.01693191f, -0.00799829f, 0.02929316f, 
    0.06832108f, -0.04549677f, -0.06947733f, 0.09830503f, -0.26645711f, 0.06372143f, 0.01598737f, -0.06297053f, 
    -0.14638887f, 0.08130748f, 0.10606955f, 0.08652827f, -0.10961077f, 0.13721654f, -0.06623143f, 0.02078925f, 
    0.13587078f, -0.02537666f, -0.05845195f, 0.07929008f, -0.00476190f, -0.00326930f, 0.04655923f, 0.08046054f, 
    0.00059052f, -0.14336514f, -0.07667568f, -0.01526554f, -0.24174210f, 0.09488345f, -0.02163923f, -0.01512308f, 
    -0.08607526f, -0.01532249f, 0.09583760f, -0.02548599f, -0.06051078f, 0.17667969f, 0.08057773f, -0.05452435f, 
    -0.15491256f, 0.08793049f, -0.11342305f, 0.08393055f, -0.01339868f, -0.04162586f, 0.03299389f, -0.06862455f, 
    -0.07701796f, -0.05764202f, 0.00695801f, -0.06496725f, -0.08253391f, 0.07173584f, 0.08733393f, 0.01564754f, 
    -0.20803401f, -0.07919098f, 0.04271687f, -0.05839966f, -0.07735925f, -0.01483850f, 0.17786032f, -0.01161102f, 
    0.03836216f, 0.05466010f, -0.00301449f, 0.20863555f, 0.10282496f, 0.06546021f, -0.02339256f, 0.21837640f, 
    -0.01277269f, 0.05432726f, 0.18226549f, 0.05388910f, 0.41709122f, 0.17711560f, -0.08116349f, 0.16267380f, 
    0.04347743f, -0.05868857f, -0.01461481f, 0.05299740f, -0.00329622f, 0.02167431f, -0.17157510f, 0.02651386f, 
    0.09333512f, -0.04365530f, -0.00738919f, -0.05048065f, -0.04648108f, 0.03861192f, -0.01095355f, -0.01343534f, 
    -0.05321505f, -0.08283470f, 0.15289918f, -0.07471552f, -0.34219632f, -0.05651112f, 0.10112642f, -0.04996553f, 
    0.11619090f, -0.00698694f, 0.00643978f, -0.15609835f, -0.05572508f, -0.02378703f, 0.15315694f, 0.08298913f, 
    -0.20581102f, 0.14186186f, -0.07469962f, 0.13890913f, 0.08770686f, 0.08391404f, -0.01769015f, 0.08833428f, 
    -0.00734549f, 0.07674972f, -0.02602539f, 0.06750783f, -0.14323772f, 0.14885809f, 0.07507316f, -0.26195729f, 
    0.05457896f, 0.09765606f, -0.01741368f, 0.03488866f, 0.04110637f, 0.08171333f, 0.15293649f, -0.14890319f, 
    0.14604928f, 0.14672558f, 0.09743429f, 0.16129622f, 0.11910902f, 0.09345714f, 0.03884434f, 0.07014039f, 
    0.05077008f, -0.00156692f, 0.17363168f, 0.01708963f, -0.53497809f, -0.01714830f, -0.18906911f, -0.06002245f, 
    0.09574939f, 0.14099389f, 0.01703425f, 0.10179772f, -0.05097239f, -0.03348397f, -0.17046382f, -0.01750470f, 
    0.40557787f, -0.16169290f, -0.29238546f, 0.11809597f, 0.10678864f, -0.16917336f, 0.08609353f, -0.07730396f, 
    -0.01146928f, 0.00833500f, -0.02915750f, -0.05488298f, 0.11176869f, 0.04380739f, -0.13702640f, 0.19991852f, 
    -0.15443896f, -0.13285598f, -0.01762776f, 0.04249010f, 0.01681348f, -0.00914361f, 0.06213148f, 0.00602964f, 
    0.20202735f, 0.11720515f, -0.23161693f, 0.13063788f, -0.04990160f, -0.06535816f, -0.03137209f, -0.03195579f, 
    0.03153203f, -0.04901848f, -0.10470732f, 0.09302352f, 0.18608359f, 0.08856211f, 0.17954879f, 0.02343522f, 
    0.10656935f, 0.08509374f, 0.02730483f, -0.08581702f, 0.03643237f, 0.14273849f, 0.03342205f, 0.10981426f, 
    -0.16215870f, 0.01419697f, -0.09223436f, 0.14465517f, 0.05302320f, 0.05334634f, 0.09772461f, -0.04093216f, 
    0.04598488f, 0.07038641f, 0.06177454f, -0.05424166f, 0.18966356f, 0.08591353f, -0.01073653f, 0.26405016f, 
    -0.01101829f, 0.12749691f, 0.04481855f, 0.09023874f, 0.00358325f, -0.02272480f, 0.00556151f, -0.09292144f, 
    -0.31000063f, -0.01690488f, -0.02995135f, -0.15978605f, 0.04503514f, -0.04443081f, -0.08057766f, 0.03750306f, 
    0.03823276f, -0.01120605f, -0.06513345f, 0.06429013f, -0.12655962f, -0.00920521f, -0.00339230f, -0.01233955f, 
    -0.01393516f, -0.06702202f, -0.09002414f, -0.00807687f, 0.03986130f, -0.05852470f, -0.09451195f, -0.01609677f, 
    0.07589666f, 0.04786042f, 0.06279466f, -0.08859588f, -0.02614066f, -0.02270338f, 0.05554288f, 0.09150191f, 
    -0.03195177f, 0.04151242f, 0.05713852f, -0.04597799f, -0.01427156f, 0.00538601f, 0.08851436f, -0.14174023f, 
    0.02088268f, -0.11098027f, -0.15888147f, 0.00333672f, 0.01485414f, -0.03466848f, 0.04315718f, -0.02108345f, 
    -0.08671550f, -0.03200105f, -0.02832543f, 0.23933792f, 0.02152392f, -0.07828201f, 0.03474402f, -0.00935808f, 
    -0.03458185f, 0.06182333f, 0.04576205f, -0.03759554f, 0.05151844f, 0.18585704f, -0.14082119f, 0.06855791f, 
    0.03013496f, -0.02506522f, -0.04419790f, -0.10460161f, -0.00607473f, 0.03064140f, -0.11229680f, -0.04978773f, 
    0.20263582f, 0.23591736f, 0.15314068f, -0.08402098f, -0.06956932f, 0.02872628f, -0.01791707f, 0.12745494f, 
    -0.02849093f, -0.09619933f, 0.06742847f, -0.11599123f, 0.09285332f, 0.13770126f, -0.08700275f, -0.16571090f, 
    -0.09813762f, -0.05041358f, -0.05503140f, -0.02164300f, -0.06696989f, 0.07130842f, -0.05292296f, 0.00450280f, 
    0.12942103f, -0.04028991f, -0.05693849f, -0.09458305f, -0.01427759f, -0.00902453f, 0.03766974f, 0.15181580f, 
    -0.05460815f, -0.00431135f, -0.08425847f, -0.03226354f, -0.30840090f, 0.03680112f, 0.18394263f, 0.11059649f, 
    0.02201916f, 0.12272638f, 0.04732133f, -0.08933102f, -0.10315771f, 0.00363969f, 0.17147158f, 0.04231331f, 
    -0.11399395f, 0.03000267f, -0.05507304f, 0.08004842f, 0.06506981f, 0.01195470f, 0.05856360f, -0.08387432f, 
    -0.06388342f, -0.01367385f, -0.07343064f, -0.03074385f, 0.01407788f, 0.03754722f, 0.07220448f, 0.19610047f, 
    -0.10920683f, -0.10507046f, 0.02010470f, -0.00585341f, 0.12919316f, -0.06445875f, -0.01895696f, -0.04991526f, 
    -0.08124357f, 0.02475370f, 0.03151459f, -0.02639646f, 0.10972796f, 0.00992269f, 0.07086983f, 0.24015212f, 
    -0.14729647f, -0.13861948f, -0.02567493f, 0.01068018f, 0.10732294f, 0.09054160f, 0.07267617f, -0.08304596f, 
    0.04838090f, -0.04680427f, -0.04359411f, 0.00753922f, 0.05047242f, -0.12049930f, 0.02646699f, 0.03143983f, 
    0.21164770f, 0.02810382f, 0.14035735f, -0.06143503f, -0.01766927f, 0.05470464f, -0.01866718f, 0.03248487f, 
    0.05442582f, 0.02443510f, 0.08015456f, 0.13396995f, 0.15407911f, 0.12359931f, 0.03991597f, -0.05446189f, 
    -0.09492462f, -0.03057176f, 0.01826888f, 0.05995828f, 0.01590405f, 0.09228201f, -0.05203976f, 0.00779656f, 
    -0.07306788f, -0.23563038f, -0.13333887f, -0.09804718f, 0.02790589f, -0.01523550f, 0.08163237f, 0.12184236f, 
    0.03186650f, -0.09969092f, -0.11481353f, -0.03893773f, -0.00906202f, -0.07520084f, 0.21169126f, 0.08757062f, 
    0.07522427f, -0.08658047f, 0.10901061f, 0.00057993f, 0.00969287f, -0.08296894f, 0.01471335f, 0.12603813f, 
    -0.26000920f, -0.07885895f, 0.06744831f, 0.04287517f, 0.10899132f, -0.01942796f, 0.10666898f, 0.09302212f, 
    -0.16172121f, 0.13999917f, 0.00400620f, -0.01266477f, 0.14034757f, -0.04848847f, -0.07417450f, 0.34563050f, 
    0.08116000f, 0.00762813f, -0.02473112f, -0.01166115f, -0.05732742f, 0.04704098f, -0.09384274f, 0.03229978f, 
    0.03087169f, 0.05828590f, 0.08219318f, 0.06038858f, 0.11704039f, 0.01987636f, 0.01399934f, -0.03650907f, 
    0.03627209f, -0.02970268f, -0.00385258f, -0.02910403f, -0.14811391f, 0.01559057f, -0.03564135f, 0.02932922f, 
    -0.00598591f, -0.10840143f, -0.03514893f, 0.23520255f, 0.10406274f, 0.03789176f, 0.02220894f, -0.12169271f, 
    -0.01157069f, 0.08511735f, 0.12487335f, 0.11808079f, 0.00548728f, 0.00562577f, 0.09335271f, 0.03378050f, 
    -0.03776694f, 0.06157847f, 0.06781532f, -0.12121216f, 0.04368327f, -0.00003643f, -0.02023097f, -0.09346974f, 
    -0.02930178f, -0.03680581f, 0.04925834f, 0.09407010f, 0.01954765f, -0.00158125f, -0.04606088f, 0.08619040f, 
    0.09605813f, -0.00662852f, 0.06516450f, 0.12396023f, -0.07669093f, 0.11942888f, 0.09920964f, 0.05881791f, 
    0.04796476f, 0.05330838f, -0.08590730f, -0.00354027f, 0.09779763f, 0.04546102f, -0.03743150f, -0.10720816f, 
    -0.04079036f, -0.00773067f, -0.03608986f, 0.15143888f, 0.05280209f, 0.04404838f, 0.00900068f, 0.09911956f, 
    -0.25424528f, -0.17144130f, 0.07598554f, 0.22039120f, 0.03525330f, 0.00961698f, 0.01312678f, -0.13212824f, 
    0.08198684f, 0.00839245f, -0.01001738f, 0.03498811f, 0.09154385f, 0.01768459f, 0.06813195f, 0.14895129f, 
    -0.04448411f, -0.01170315f, -0.00682865f, -0.14436506f, 0.11964083f, -0.06281526f, 0.01151676f, 0.01705298f, 
    0.06675838f, -0.04795904f, -0.03966333f, 0.19352150f, -0.00978477f, 0.12007084f, -0.05519032f, -0.06089764f, 
    0.07487293f, 0.10928728f, -0.03840494f, 0.06987876f, -0.25190169f, 0.16322626f, -0.15952659f, -0.27569407f, 
    0.17466980f, -0.10333989f, -0.09543592f, 0.03064229f, 0.09497347f, 0.00010975f, -0.08507714f, 0.07033765f, 
    -0.01555963f, -0.13262719f, 0.26624081f, 0.28643614f, -0.01947247f, -0.00316740f, 0.05055362f, 0.05291314f, 
    -0.17538166f, 0.16838011f, 0.00286657f, 0.02126071f, 0.27359655f, -0.02662063f, -0.12289878f, 0.27316996f, 
    0.00206163f, 0.11163657f, -0.00626280f, 0.03483843f, -0.05264009f, -0.03537155f, 0.04631208f, 0.05246594f, 
    0.22519262f, -0.02542636f, 0.01188749f, -0.25754857f, 0.01785538f, 0.08181944f, -0.00183852f, 0.00775003f, 
    -0.00232023f, 0.06080466f, 0.07029957f, 0.08345679f, -0.07204191f, 0.07715876f, -0.07093754f, -0.01993073f, 
    0.02677243f, -0.09924506f, 0.05950398f, 0.01120209f, 0.03878773f, 0.06145923f, -0.00186108f, -0.04796427f, 
    0.07547397f, -0.05040171f, 0.07388990f, 0.02134313f, 0.02339381f, 0.08587120f, 0.02638358f, -0.04280477f, 
    0.04684802f, 0.07010296f, 0.02295018f, -0.02274616f, -0.04543513f, 0.00548287f, 0.26753625f, 0.04618077f, 
    -0.01252577f, 0.14700203f, -0.07078727f, -0.00925955f, 0.08720871f, -0.09359343f, 0.08897641f, -0.00130901f, 
    0.04306803f, -0.01171007f, 0.14900371f, 0.21676810f, 0.03586208f, -0.00439680f, 0.10848963f, 0.14557475f, 
    -0.06997810f, 0.03061599f, -0.00260544f, -0.06986170f, 0.39867663f, 0.03794941f, -0.02434734f, 0.17138773f, 
    -0.01784817f, 0.01618674f, -0.05464118f, 0.02143784f, -0.00666888f, -0.02393894f, 0.00716430f, 0.02695979f, 
    -0.30822131f, -0.13928413f, 0.04217073f, -0.20782891f, 0.09004925f, 0.19340377f, 0.01481515f, -0.07430578f, 
    0.02747873f, 0.00535599f, 0.08452269f, -0.01462112f, 0.17375624f, 0.15708767f, -0.04051299f, -0.23873605f, 
    0.07679380f, 0.06339201f, -0.03744059f, 0.03382704f, -0.03653709f, 0.02640661f, -0.08131149f, 0.10543353f, 
    -0.21638355f, 0.06799597f, -0.17168717f, -0.14073889f, 0.05345223f, 0.00300179f, 0.02528208f, 0.01241329f, 
    -0.04919785f, -0.07561707f, 0.10424722f, -0.01059796f, -0.21015194f, 0.22637515f, -0.14127448f, -0.13670339f, 
    0.06221124f, 0.08232754f, -0.13891876f, 0.09440889f, 0.07476099f, 0.00447328f, 0.08542763f, -0.02054140f, 
    0.03290656f, 0.18192838f, 0.03234199f, 0.24212191f, 0.02471585f, -0.05580885f, 0.02704358f, 0.16804488f, 
    0.01951496f, 0.07459828f, 0.09529164f, -0.12554795f, -0.17169778f, -0.21345894f, -0.01669032f, -0.11517318f, 
    0.01338066f, 0.04420526f, -0.03189533f, 0.03647998f, 0.01920958f, 0.10042821f, -0.02287213f, 0.02329183f, 
    -0.10213043f, 0.14607576f, -0.18939473f, -0.10800126f, 0.08927080f, 0.04116271f, -0.02773662f, 0.15471025f, 
    0.00349416f, -0.01435357f, -0.01611086f, 0.08869560f, -0.33424515f, 0.04558670f, -0.07475789f, -0.29917181f, 
    0.08973318f, 0.11660767f, -0.01035016f, 0.05344264f, -0.01426062f, -0.03164678f, 0.01541041f, 0.10362946f, 
    -0.20343029f, 0.20110473f, -0.11694848f, -0.21966374f, 0.20124130f, -0.01254820f, -0.02759549f, -0.05758940f, 
    0.00529294f, -0.06572705f, 0.03674733f, 0.00809989f, -0.01605415f, -0.10625028f, 0.02084103f, -0.18716377f, 
    -0.04063699f, 0.04148026f, 0.00420590f, 0.04048243f, 0.01238870f, 0.01559144f, -0.00029765f, 0.02907420f, 
    -0.28055492f, 0.20936598f, 0.17461731f, 0.07722807f, 0.02371100f, -0.01855750f, 0.05356149f, 0.08056469f, 
    0.16434190f, 0.01495093f, 0.08576033f, 0.04920280f, -0.09856098f, 0.01612973f, -0.23585600f, -0.04908077f, 
    0.08394115f, -0.09896729f, 0.01374093f, 0.05178032f, -0.07402922f, -0.09428255f, 0.15138316f, -0.07169356f, 
    -0.11945620f, -0.25341934f, 0.03745733f, -0.01217919f, -0.06522080f, -0.07340110f, 0.13314712f, 0.14474976f, 
    -0.00060233f, 0.06445348f, 0.08379287f, 0.13938130f, -0.09175200f, 0.22758771f, -0.23000950f, -0.01664641f, 
    0.17798351f, -0.07335349f, 0.01633803f, 0.13116412f, 0.02631781f, 0.11811440f, 0.08307034f, 0.12459245f, 
    0.15372768f, 0.04136893f, 0.04046500f, 0.13848880f, 0.04750188f, 0.00279636f, 0.05950717f, 0.00623980f, 
    0.01156587f, 0.06605898f, 0.08458199f, 0.05629206f, -0.05638311f, -0.12093642f, 0.21110977f, -0.01096333f, 
    0.03172430f, -0.02958858f, -0.02487558f, -0.07035694f, 0.09605750f, 0.02986452f, 0.02532039f, 0.07546784f, 
    0.03310918f, -0.04436811f, -0.03975265f, 0.03559233f, -0.04396279f, -0.00340200f, -0.04770746f, 0.02024689f, 
    0.00605481f, -0.04088454f, 0.02235663f, -0.00493924f, -0.03266149f, -0.03745398f, -0.05314786f, 0.01228708f, 
    0.01802033f, -0.01264131f, -0.01765089f, -0.02433596f, 0.01605674f, 0.03831977f, 0.01389994f, 0.00469417f, 
    0.01247582f, 0.04346286f, -0.02802483f, -0.03688904f, -0.02959969f, 0.01411161f, -0.05981940f, 0.01866935f, 
    0.04705258f, -0.01877908f, 0.02459919f, 0.01196710f, 0.02702740f, 0.00078240f, -0.00757431f, 0.03154831f, 
    -0.02286621f, 0.02798375f, 0.03164914f, -0.03694317f, 0.03516549f, 0.00676619f, -0.05521209f, 0.01779557f, 
    -0.03494157f, 0.02771816f, 0.02672542f, -0.04251122f, -0.01292162f, 0.01095026f, 0.01371835f, -0.04521517f, 
    -0.01670587f, 0.01140488f, 0.00977851f, -0.02373145f, 0.00412540f, -0.01890027f, -0.02474187f, 0.00187889f, 
    0.00998302f, -0.01947679f, -0.01133841f, -0.00464895f, 0.01936347f, 0.01705998f, -0.00864923f, 0.00797823f, 
    -0.04250102f, 0.04468474f, 0.00830145f, -0.00373181f, -0.00001193f, -0.03528335f, -0.00704430f, -0.04323488f, 
    0.01906353f, 0.02097037f, 0.00718960f, 0.01366576f, 0.02803821f, 0.01701429f, -0.04364594f, 0.04034560f, 
    -0.05353419f, -0.04032199f, -0.03770781f, 0.04214441f, -0.00305905f, -0.00179563f, -0.01483056f, -0.04593077f, 
    0.03602772f, -0.05280711f, 0.00006259f, -0.05378400f, -0.04406004f, -0.04380333f, -0.01081986f, -0.05183686f, 
    -0.02510980f, -0.05015363f, 0.00670270f, 0.04637384f, 0.00605831f, -0.04408513f, -0.04116565f, -0.04949353f, 
    0.01694852f, 0.03526479f, 0.00508223f, -0.03617832f, -0.01569388f, -0.02327172f, 0.03126458f, -0.03888598f, 
    0.00202018f, 0.03785736f, -0.02234712f, -0.02490459f, -0.00057824f, 0.03008763f, 0.04189417f, 0.00016329f, 
    0.04264529f, 0.04448746f, 0.03090088f, -0.01346969f, 0.02542501f, -0.02876529f, 0.01525266f, 0.00446304f, 
    0.03331636f, -0.00663157f, -0.02169820f, -0.01211063f, 0.02246349f, 0.00351418f, -0.01585348f, 0.00426303f, 
    -0.03310734f, -0.02912996f, 0.01642319f, -0.02325938f, -0.01267470f, 0.04008732f, 0.01040213f, -0.00513776f, 
    0.03573848f, -0.01343244f, 0.03415831f, -0.03370171f, 0.00066777f, -0.03804291f, -0.01379796f, -0.00897005f, 
    0.04228487f, 0.00762402f, -0.04147844f, -0.02769241f, -0.03115055f, 0.02052394f, 0.01144811f, -0.03837402f, 
    0.02622199f, -0.01867245f, 0.01920428f, -0.04076293f, -0.03323724f, -0.03930913f, 0.02664456f, -0.03272752f, 
    0.04886545f, 0.02536912f, 0.00172436f, 0.00780750f, 0.00731521f, 0.00202987f, 0.02786905f, 0.04050321f, 
    -0.04465684f, -0.01444805f, 0.04537845f, -0.03390847f, 0.03595281f, 0.02513290f, -0.05363008f, -0.05253570f, 
    -0.02965681f, 0.02767896f, 0.00576701f, -0.05498967f, -0.00882323f, -0.02088592f, 0.04673418f, 0.02295917f, 
    -0.01916016f, -0.04042352f, 0.03172577f, 0.02211790f, -0.04784093f, -0.00117572f, 0.02841344f, 0.04270057f, 
    -0.01667602f, 0.01696706f, -0.05412154f, 0.01488078f, 0.01278492f, 0.00724017f, 0.01640343f, 0.01298053f, 
    -0.01344367f, -0.04588065f, -0.02132861f, 0.03958558f, -0.05833682f, 0.00268293f, 0.04724346f, -0.04216960f, 
    0.00573429f, 0.03184467f, -0.04481016f, -0.05481244f, -0.03115424f, 0.00608757f, -0.01241305f, -0.00352030f, 
    -0.00341391f, -0.02880100f, -0.05483317f, 0.03732506f, 0.03005815f, -0.01505798f, 0.04165745f, 0.02149158f, 
    -0.01447612f, 0.01042885f, -0.03926639f, -0.04157109f, 0.01858749f, -0.02755993f, 0.02006436f, -0.05487476f, 
    -0.05523301f, -0.01887676f, -0.04927254f, 0.02154088f, -0.01846037f, -0.01744447f, -0.01212485f, -0.02065377f, 
    0.03257819f, 0.02052092f, -0.00634434f, 0.00578549f, 0.04681285f, 0.03325653f, 0.03534076f, -0.00503982f, 
    0.03282034f, -0.00272812f, -0.00063203f, 0.00790637f, -0.01571056f, 0.02575846f, 0.00215873f, -0.01714580f, 
    -0.05509858f, -0.05165349f, -0.04509052f, 0.01374944f, -0.02289409f, -0.04515426f, -0.01788372f, 0.03357017f, 
    -0.05414086f, -0.04319456f, -0.04771977f, 0.00639274f, -0.03591396f, -0.04620055f, -0.01504973f, -0.00944298f, 
    0.04570222f, -0.03780225f, -0.00640312f, 0.00630482f, 0.04397856f, 0.02804408f, -0.00325087f, 0.01096880f, 
    0.02031925f, -0.02457163f, -0.04083202f, 0.04580130f, 0.01643578f, -0.02570143f, 0.03820840f, -0.05073411f, 
    0.01210496f, 0.02327391f, -0.02720205f, 0.02231075f, 0.02055614f, 0.01710225f, -0.01303016f, 0.03340352f, 
    -0.02879121f, -0.01035950f, 0.00927576f, 0.01134243f, 0.00483638f, 0.01196810f, -0.00777620f, -0.04465853f, 
    -0.01464710f, 0.01229286f, 0.04515094f, -0.00779189f, -0.03856834f, 0.03515796f, 0.00626462f, -0.00969521f, 
    0.02813801f, -0.03410261f, -0.02336565f, -0.03089637f, -0.05082493f, -0.02574292f, -0.02289052f, -0.02989894f, 
    -0.04747384f, -0.00044569f, -0.05719440f, -0.01420213f, -0.04335299f, 0.03369757f, 0.04093708f, 0.03248742f, 
    0.04733947f, -0.00959511f, -0.05909576f, 0.02217693f, -0.03927298f, -0.02606619f, 0.04114604f, -0.05153517f, 
    -0.00938033f, -0.02785587f, 0.01962101f, -0.02268723f, -0.01256795f, -0.03034128f, -0.01976111f, -0.02227755f, 
    -0.04027516f, 0.03798246f, 0.00131043f, 0.00842074f, -0.05408621f, -0.03859712f, 0.00011133f, 0.00877634f, 
    0.02315514f, -0.00747231f, -0.00576435f, 0.02474123f, -0.02888946f, -0.02372159f, -0.00289888f, -0.04522136f, 
    0.00800167f, -0.05716568f, -0.00698779f, -0.01343104f, 0.00632666f, 0.00589136f, -0.02601145f, -0.05452273f, 
    -0.14012556f, 0.22805232f, 0.10848521f, -0.18116373f, 0.04740321f, 0.07008877f, -0.01196741f, -0.03878340f, 
    0.01564087f, 0.07113117f, -0.10360662f, 0.08483461f, -0.15789548f, 0.22152346f, 0.11268012f, -0.21993561f, 
    -0.04143947f, -0.08954420f, -0.02885164f, -0.03079068f, -0.05284019f, -0.00700111f, 0.02728848f, -0.10113854f, 
    0.09298701f, 0.02637236f, -0.06113131f, 0.07800741f, 0.17549002f, 0.10677282f, 0.05240679f, -0.03195186f, 
    0.11547168f, -0.01113035f, 0.12775329f, -0.00409641f, -0.25733137f, -0.03222098f, 0.07179670f, 0.00326822f, 
    0.05104416f, 0.05220563f, 0.12973128f, 0.06179658f, 0.03669391f, 0.07897198f, -0.00919757f, -0.00510191f, 
    -0.11262487f, 0.29306474f, -0.12690027f, -0.04109283f, -0.03949573f, -0.06311890f, -0.13345270f, 0.03390116f, 
    0.07382528f, -0.05487968f, -0.03107748f, 0.12195956f, 0.21863022f, 0.23173751f, -0.01907582f, 0.28431723f, 
    -0.05952602f, 0.03623774f, -0.08422254f, 0.01148088f, -0.10820057f, 0.02448948f, 0.10823090f, 0.01604845f, 
    0.16893318f, -0.02007617f, 0.01027949f, -0.00920123f, 0.03400269f, 0.06184596f, 0.05296230f, 0.00709418f, 
    0.05871677f, -0.01719122f, 0.02273274f, 0.06062283f, -0.13624716f, -0.17805672f, -0.05600486f, 0.15379669f, 
    -0.10370024f, 0.02122611f, 0.00294974f, -0.10380156f, -0.00737279f, 0.01663296f, -0.02091197f, 0.03046308f, 
    0.21779609f, 0.11699463f, -0.00023125f, 0.13120887f, 0.10836077f, 0.13273720f, -0.05465241f, 0.00098576f, 
    0.08348805f, -0.07583874f, -0.05283826f, 0.01946037f, 0.01985015f, 0.05193467f, 0.03257552f, 0.17848009f, 
    0.15330105f, 0.12438034f, 0.15523472f, -0.05104409f, 0.09056856f, 0.03612231f, -0.06709694f, 0.03780947f, 
    0.03185996f, 0.03472629f, -0.02860740f, 0.12999123f, 0.06025662f, -0.09707605f, 0.05867295f, 0.13660701f, 
    -0.10784502f, 0.16752411f, -0.00262049f, 0.03931445f, -0.06588692f, 0.01979573f, -0.01821074f, -0.02460122f, 
    0.03725037f, -0.06367682f, -0.08570699f, -0.01492162f, -0.07864699f, -0.05411608f, -0.03182830f, 0.18136489f, 
    0.08545934f, 0.16655950f, 0.02439793f, 0.17761946f, -0.08598398f, -0.10594619f, 0.09290145f, 0.02101255f, 
    0.01998948f, -0.01035782f, 0.02463174f, 0.09574075f, 0.20596001f, -0.09841283f, -0.06364641f, -0.12260939f, 
    0.10526185f, -0.04747261f, -0.02864100f, -0.06313445f, 0.05862594f, 0.04147011f, 0.00527771f, -0.10066751f, 
    0.17233267f, 0.17024963f, -0.03899448f, -0.11835706f, 0.10308478f, -0.05393680f, -0.09193589f, -0.13955982f, 
    -0.06040450f, 0.01032535f, -0.00051606f, -0.02104963f, -0.10604271f, 0.03005149f, 0.36282900f, 0.09194022f, 
    -0.04123881f, 0.01119427f, -0.13848792f, 0.05425182f, 0.08715079f, 0.05723606f, 0.11386553f, 0.05297651f, 
    0.10549099f, -0.15368225f, -0.08770729f, -0.14458525f, 0.14883366f, -0.05242740f, -0.09100655f, 0.00274648f, 
    0.00705948f, -0.04749111f, -0.07184489f, -0.17991914f, -0.43101195f, -0.10924514f, 0.30882457f, 0.16618717f, 
    0.07147298f, -0.01187764f, -0.02319097f, 0.12031509f, 0.06404466f, -0.01226565f, -0.05305117f, -0.07338943f, 
    -0.18231042f, 0.11199044f, 0.05001113f, -0.04159630f, -0.03780656f, 0.05674702f, -0.03273009f, 0.02406999f, 
    0.05517205f, -0.06381664f, -0.24393208f, -0.06227020f, -0.24129190f, -0.21975967f, 0.06302462f, 0.14714137f, 
    -0.02086857f, 0.08363102f, 0.09358257f, 0.02671896f, -0.08785669f, 0.12426796f, 0.02892592f, 0.06775797f, 
    0.01465477f, 0.15648118f, 0.05182115f, 0.02206853f, 0.11096167f, -0.07787555f, 0.13715383f, -0.10204154f, 
    0.08184803f, -0.06745859f, -0.06986855f, -0.05779508f, 0.11361719f, -0.03484548f, 0.05668700f, -0.03614001f, 
    -0.15538138f, 0.07601885f, 0.14804915f, 0.04110697f, 0.05921802f, 0.10977044f, 0.05392646f, 0.06641712f, 
    -0.06094421f, 0.08871878f, -0.04085875f, 0.02796570f, -0.09876112f, 0.09335836f, 0.02256161f, 0.00025079f, 
    -0.16590823f, -0.00342177f, -0.00310573f, -0.05424155f, 0.00989162f, -0.11546163f, -0.06586079f, 0.06780010f, 
    0.00717909f, -0.05489574f, -0.14242293f, -0.05197127f, -0.02563190f, -0.02064280f, 0.03953527f, -0.05331001f, 
    -0.02567866f, -0.02278499f, 0.14392810f, -0.03467762f, 0.01982025f, -0.04279873f, 0.09075081f, 0.00556135f, 
    0.05469670f, 0.08119610f, 0.13465232f, 0.19885886f, -0.11607629f, -0.12063528f, -0.10690204f, -0.17265193f, 
    0.06222501f, 0.03171727f, -0.07412433f, -0.03205900f, 0.00834515f, -0.08950040f, -0.00422434f, 0.07533395f, 
    -0.11703721f, 0.04599754f, 0.00484813f, 0.06145296f, -0.08414901f, 0.01930294f, 0.10581466f, 0.14231025f, 
    0.12946899f, 0.04763952f, 0.02689845f, 0.12916191f, -0.06991179f, -0.14595483f, -0.06436747f, -0.07164171f, 
    0.16478406f, -0.00803621f, 0.08158778f, -0.03336440f, 0.06672951f, -0.02486913f, 0.00749020f, 0.01262186f, 
    -0.03780119f, 0.16613202f, 0.08953150f, -0.16165049f, -0.10791385f, -0.07193071f, 0.03136695f, -0.20281422f, 
    -0.04894496f, 0.05907927f, -0.15844305f, 0.02427869f, -0.06752144f, -0.10345433f, 0.13623579f, 0.23953992f, 
    0.13627072f, -0.02392202f, 0.02494350f, -0.00430895f, 0.05001503f, -0.00727278f, 0.10991657f, -0.08631314f, 
    0.15894634f, 0.09735814f, 0.10148146f, 0.17414147f, 0.10892880f, 0.17889693f, 0.05158085f, -0.02810127f, 
    0.02978541f, 0.05684280f, -0.12116997f, -0.07635859f, 0.16644637f, -0.03420475f, -0.12913941f, 0.06102078f, 
    -0.02012838f, -0.03197438f, -0.09068094f, 0.04331758f, 0.01420570f, 0.05673653f, -0.02416817f, -0.17990540f, 
    -0.32254899f, 0.02841646f, -0.01430751f, 0.12285201f, 0.28844494f, 0.06384131f, -0.01656239f, -0.02288714f, 
    0.08936767f, 0.14480850f, 0.17636253f, -0.01494483f, -0.16329102f, -0.04395586f, 0.18820457f, 0.11793924f, 
    0.04352386f, -0.01240524f, 0.01860510f, 0.02589256f, 0.12768090f, -0.01502013f, -0.05211451f, 0.00393618f, 
    -0.25286692f, -0.01638869f, 0.07449335f, 0.04086803f, 0.10266259f, 0.02987966f, 0.00967614f, 0.04282542f, 
    0.08567704f, 0.00016447f, 0.01862730f, 0.06680229f, -0.13041332f, -0.16579810f, 0.13265163f, 0.13981541f, 
    0.23351303f, 0.14895211f, -0.08539947f, -0.01885533f, -0.03950965f, 0.02207348f, 0.09037539f, 0.06176504f, 
    0.15450986f, 0.39080682f, -0.13505490f, 0.07584959f, -0.03112233f, 0.06569231f, -0.11339633f, 0.07217448f, 
    -0.02071695f, 0.06092874f, 0.07162069f, -0.04974710f, -0.08964104f, -0.01785644f, -0.17531744f, 0.02643052f, 
    -0.07166812f, -0.04139971f, -0.05392075f, -0.01948969f, -0.04288622f, -0.08212253f, -0.05794596f, 0.10420152f, 
    0.05815246f, 0.01307678f, -0.00312777f, -0.08061744f, -0.03041432f, 0.04769127f, -0.04058712f, 0.06151923f, 
    0.00684974f, -0.10033091f, 0.06388853f, -0.08761245f, 0.43928126f, 0.23824483f, -0.01657335f, 0.13293718f, 
    0.01550121f, -0.12232593f, 0.00918217f, 0.02859738f, -0.03307817f, 0.01416218f, 0.05080357f, 0.02283185f, 
    0.16039915f, 0.03427749f, -0.00950338f, 0.08901227f, 0.14404014f, -0.02323244f, 0.03330060f, 0.09360528f, 
    -0.04086119f, 0.07893350f, 0.04699043f, 0.10427272f, -0.03026489f, 0.03315808f, 0.09531072f, 0.01708538f, 
    0.09810124f, 0.01696969f, 0.09179763f, 0.12942399f, -0.06037415f, -0.05145985f, -0.05100260f, -0.06548071f, 
    0.43412122f, 0.12079595f, 0.08023825f, -0.21173224f, 0.06820773f, -0.04406414f, 0.05394854f, -0.01512739f, 
    0.01068126f, -0.07133141f, -0.07827260f, 0.05196665f, 0.22057249f, -0.10494281f, 0.06460600f, -0.04698192f, 
    -0.11221217f, 0.02333381f, 0.03120128f, 0.01143066f, 0.07685968f, 0.04273193f, 0.03922918f, 0.04892767f, 
    -0.16614060f, -0.11848629f, 0.05988439f, -0.02804976f, 0.03333024f, 0.04054664f, 0.05610830f, 0.04695802f, 
    0.09056567f, 0.04245311f, 0.06823947f, 0.11060296f, 0.14336902f, 0.08386575f, -0.05864355f, -0.08119089f, 
    0.14919899f, 0.07524034f, -0.03729014f, -0.03615021f, 0.03295271f, -0.04779181f, 0.02895707f, -0.00422664f, 
    -0.19731307f, -0.05093027f, 0.06171170f, 0.15517902f, 0.08944838f, 0.11704518f, -0.04644244f, 0.00859539f, 
    0.15601148f, 0.05972870f, 0.06476703f, 0.04400809f, 0.18614505f, -0.24868231f, 0.15142813f, 0.26199514f, 
    -0.06173306f, -0.03132200f, -0.04755116f, 0.05233332f, -0.13640398f, -0.10478582f, 0.13020173f, -0.09170318f, 
    0.23394141f, 0.15457009f, 0.14897467f, 0.11068489f, 0.08552408f, -0.01138853f, -0.02994093f, -0.03676151f, 
    -0.12978220f, 0.01071449f, 0.05267448f, 0.02174012f, 0.25040701f, -0.29680654f, 0.15838319f, -0.01241546f, 
    0.05257449f, -0.15769777f, 0.07424371f, -0.08023384f, 0.05401579f, -0.00999175f, 0.12207745f, 0.14205068f, 
    0.02663268f, 0.17511597f, 0.18540394f, 0.06581921f, 0.04517927f, 0.03332405f, -0.03612919f, -0.08132830f, 
    -0.02456504f, -0.06230050f, -0.01163899f, 0.00782308f, -0.29042283f, -0.12112558f, -0.01137491f, -0.06247030f, 
    -0.12427784f, -0.01462764f, -0.05463978f, -0.09872298f, 0.09649842f, -0.01866780f, 0.08815520f, 0.03673755f, 
    -0.18656221f, -0.00527530f, -0.00719362f, 0.13338643f, 0.06961403f, 0.16249010f, 0.04807079f, -0.01873770f, 
    -0.07652798f, 0.09003007f, 0.08547369f, 0.10529203f, 0.53868628f, 0.08408161f, -0.07278910f, 0.05979560f, 
    0.01494804f, 0.09870218f, -0.09223960f, -0.06553883f, 0.01827885f, -0.09949902f, -0.00698503f, -0.15146612f, 
    -0.02609224f, -0.00662404f, -0.21008436f, -0.03002068f, 0.00803503f, -0.07567438f, -0.04963765f, 0.05697056f, 
    0.00136776f, -0.01675614f, -0.01281182f, -0.02254038f, 0.40121353f, 0.26514095f, 0.08597057f, 0.03788722f, 
    0.05427375f, 0.05034377f, -0.00261743f, 0.07053460f, -0.01754716f, 0.04722275f, 0.03918209f, -0.01585049f, 
    0.09658115f, 0.59577638f, -0.08218481f, 0.09372824f, -0.01847016f, 0.05830139f, 0.00967452f, 0.05832570f, 
    -0.03414591f, -0.01866400f, -0.04562874f, 0.00270331f, 0.17716342f, 0.12643614f, 0.17343827f, 0.14956240f, 
    0.06729745f, -0.07990859f, 0.01518774f, -0.04343877f, -0.05459218f, 0.00062390f, 0.04076822f, -0.06811612f, 
    -0.21555990f, 0.32521445f, -0.02632408f, 0.06553583f, 0.00972971f, 0.09330548f, -0.10223149f, 0.03065266f, 
    -0.02076000f, 0.00380366f, 0.01262135f, -0.02538338f, 0.17894034f, 0.16173095f, -0.10449618f, 0.10991304f, 
    0.08882819f, -0.06040655f, 0.06154846f, -0.07156155f, -0.09837885f, -0.01753680f, -0.11394075f, -0.02802409f, 
    0.23084716f, -0.14144491f, 0.16857748f, 0.11479403f, -0.01852314f, -0.17525381f, 0.02366646f, 0.00260195f, 
    -0.02174377f, 0.04736723f, 0.11712019f, 0.23907658f, -0.20796968f, 0.10220995f, 0.00980028f, 0.02239830f, 
    -0.12379026f, -0.03446285f, 0.00752182f, 0.01655034f, -0.03004325f, 0.06887577f, 0.12191740f, 0.02478665f, 
    -0.10560121f, 0.09579189f, 0.04466883f, -0.07678735f, 0.04092560f, 0.10734095f, -0.01934837f, 0.10451060f, 
    -0.07159882f, -0.04172844f, -0.00882051f, -0.11996512f, 0.34330851f, -0.09497532f, 0.08184867f, -0.01343301f, 
    0.03893150f, -0.12701386f, -0.04151885f, -0.10108584f, 0.00829357f, -0.06575835f, 0.10284042f, 0.12614071f, 
    -0.21291102f, 0.04886102f, 0.12337856f, -0.13305330f, 0.04391793f, 0.02671399f, 0.01865997f, -0.06898403f, 
    0.01388629f, 0.00316702f, 0.04913811f, 0.01854989f, 0.05743546f, -0.00074371f, 0.18204358f, -0.02143707f, 
    -0.06735298f, -0.04301163f, -0.03194031f, -0.04959041f, -0.00020137f, -0.03648911f, -0.03960251f, 0.02485458f, 
    -0.04671238f, -0.05135554f, -0.09109368f, -0.03660170f, 0.13212803f, 0.00702197f, -0.01803263f, -0.12987988f, 
    0.07669097f, 0.06776866f, 0.04591693f, 0.04815261f, -0.11707542f, -0.26023537f, 0.12434657f, -0.01975655f, 
    -0.01395972f, -0.07802258f, 0.00917136f, 0.01960864f, -0.05325904f, 0.09618114f, 0.06398757f, -0.05708495f, 
    -0.06834619f, 0.34846625f, -0.30431756f, 0.39772752f, 0.04612892f, 0.08771101f, -0.12804905f, 0.00538063f, 
    0.16566449f, 0.00834925f, 0.03626613f, 0.05174667f, 0.19815715f, 0.13812485f, -0.18397580f, 0.10867957f, 
    -0.03063113f, 0.09767075f, -0.02741393f, 0.09092210f, 0.01355677f, -0.07898436f, 0.03795119f, -0.02578175f, 
    -0.04026363f, 0.01111988f, 0.03070786f, -0.00270444f, -0.00774759f, 0.06692474f, 0.00081000f, 0.12892359f, 
    0.03620755f, 0.03139231f, 0.03994603f, -0.05078525f, -0.07327082f, -0.11208186f, -0.04582144f, -0.08465494f, 
    0.04989947f, -0.02446948f, -0.03198620f, -0.02969209f, 0.02569233f, -0.03311483f, -0.02322706f, 0.16372697f, 
    -0.06945799f, 0.00588025f, -0.17256291f, 0.29743728f, 0.07107224f, 0.09707455f, -0.15015772f, -0.00054087f, 
    0.00678088f, -0.01077155f, -0.04056033f, 0.02662137f, -0.15323964f, -0.03401562f, 0.12209642f, 0.15533563f, 
    -0.09319546f, 0.07801669f, 0.02847352f, -0.07500405f, 0.03681032f, 0.00318410f, 0.01061910f, 0.02076625f, 
    0.27158809f, -0.03895640f, -0.02743423f, -0.27722555f, 0.09105916f, -0.03155430f, 0.06338356f, 0.09897838f, 
    -0.00370323f, -0.03140195f, -0.08833744f, 0.10493539f, -0.04664879f, 0.10788705f, 0.02339321f, -0.10641126f, 
    0.03785896f, 0.01269663f, -0.00172801f, 0.02995407f, -0.02719404f, -0.05947905f, 0.08358443f, 0.10441247f, 
    0.06511485f, 0.10554846f, -0.15132858f, 0.09574548f, -0.00380585f, 0.00956012f, 0.02397382f, 0.02286622f, 
    -0.01835513f, 0.02187175f, 0.07776605f, 0.13216297f, 0.11608929f, 0.13043779f, -0.06562077f, 0.12151092f, 
    0.03396197f, -0.00054472f, 0.03033011f, -0.01832839f, 0.02343433f, -0.03950903f, -0.04462394f, -0.08995708f, 
    -0.07853868f, -0.06175578f, -0.10026975f, 0.05934114f, -0.06325962f, -0.00597920f, -0.05154137f, -0.12909253f, 
    -0.01101271f, 0.01576875f, 0.04760469f, -0.01610542f, -0.09773481f, -0.25004679f, 0.31782058f, 0.29320005f, 
    -0.02038057f, 0.00334495f, -0.08467581f, 0.02101437f, 0.03774455f, 0.04243294f, 0.02807824f, 0.06080256f, 
    -0.08558273f, -0.02143882f, 0.00692891f, -0.21143983f, 0.18487416f, 0.09053653f, -0.01738054f, -0.08816950f, 
    -0.00638721f, 0.02958873f, 0.00824426f, -0.04857409f, -0.02568202f, -0.29633918f, 0.24608418f, 0.03599723f, 
    0.16681781f, -0.04657064f, -0.04704371f, -0.00885017f, 0.02102463f, 0.05424755f, 0.01379174f, 0.01128617f, 
    -0.12421103f, 0.00687734f, 0.05510389f, -0.10584898f, 0.07978093f, -0.07640127f, -0.06469901f, 0.05722969f, 
    0.04943099f, -0.21802285f, -0.11389288f, -0.03849447f, 0.02962606f, -0.34889793f, -0.07733652f, 0.17346564f, 
    -0.03731368f, 0.03872789f, 0.04261923f, 0.10147292f, 0.02198368f, 0.01388762f, 0.00420910f, 0.05137555f, 
    -0.09804079f, -0.07977770f, -0.06703796f, 0.05453208f, 0.02428478f, -0.06702378f, 0.12675954f, -0.05961351f, 
    0.10342257f, 0.01551591f, -0.00473819f, 0.02535493f, 0.31661633f, 0.08111046f, -0.00922772f, 0.25299603f, 
    -0.02543905f, 0.12150279f, 0.17026083f, 0.02363410f, 0.01941927f, 0.05221525f, 0.04549157f, 0.08694129f, 
    0.08579377f, 0.01813968f, -0.08458843f, 0.00746217f, 0.03850652f, 0.10811200f, 0.04680977f, 0.06002246f, 
    -0.11603101f, 0.08951581f, -0.03591046f, -0.03679654f, 0.01307055f, -0.03765538f, 0.11343952f, -0.02333774f, 
    0.13313468f, -0.03628403f, -0.06475291f, -0.08712655f, -0.02233025f, 0.03745608f, 0.09363807f, 0.01556678f, 
    -0.23806632f, 0.12077776f, -0.03781525f, -0.05436724f, 0.14007939f, 0.02468001f, 0.02870155f, 0.04237746f, 
    0.06120065f, 0.03129825f, 0.00959438f, -0.02508899f, -0.07154576f, 0.03530362f, -0.00501339f, -0.06143872f, 
    0.07132665f, 0.02538145f, -0.08789229f, -0.05858495f, -0.00675763f, -0.03066086f, -0.01143989f, 0.16250587f, 
    -0.05064632f, 0.24121508f, 0.05239261f, 0.27736232f, 0.06156029f, 0.07490574f, 0.08867130f, 0.00636762f, 
    0.08180889f, 0.04173438f, 0.06474008f, 0.08935833f, 0.05633038f, -0.03178151f, 0.02070787f, -0.05725477f, 
    0.08564185f, -0.05256275f, 0.15873301f, -0.06361460f, 0.04680280f, 0.03725934f, -0.12817611f, 0.03752618f, 
    -0.08261370f, 0.15114936f, 0.06562628f, -0.00481861f, -0.07043447f, -0.07305378f, 0.01348518f, -0.14091735f, 
    0.02056869f, -0.00536279f, -0.12343453f, 0.07056492f, 0.03193201f, -0.23139074f, 0.07423510f, 0.27389860f, 
    0.04708473f, 0.03282156f, -0.05960914f, 0.09792621f, 0.07045244f, 0.05478724f, 0.17018583f, 0.03456499f, 
    -0.05106718f, 0.07668329f, 0.00669023f, -0.00244370f, 0.04837319f, 0.03379239f, -0.01525920f, -0.06274124f, 
    0.06910778f, -0.05045770f, -0.09056076f, -0.02538124f, 0.16284204f, -0.12937255f, -0.04720360f, 0.05947391f, 
    0.09585395f, 0.02182181f, 0.01685717f, 0.11968324f, -0.07154060f, 0.10683566f, 0.00758343f, -0.09510175f, 
    -0.04802565f, 0.01440991f, -0.02132949f, -0.01203669f, -0.01475045f, 0.02683199f, -0.00098712f, 0.01613595f, 
    0.00571280f, 0.02672364f, -0.02415523f, -0.04080168f, -0.02072081f, 0.02680348f, -0.00766328f, -0.00264045f, 
    -0.04927600f, 0.01081487f, 0.03969390f, 0.00064797f, 0.00281755f, -0.05025539f, -0.03148651f, -0.00474222f, 
    -0.03644411f, 0.01556564f, 0.03842000f, -0.05354939f, 0.00914343f, 0.00464435f, 0.01722557f, -0.03809246f, 
    -0.02791014f, 0.02854412f, 0.00970305f, 0.00754321f, -0.04690108f, 0.01795950f, -0.00315397f, -0.04601027f, 
    0.02368155f, 0.04477676f, -0.01286282f, -0.02300828f, 0.01435458f, -0.04986052f, 0.04352407f, 0.00354922f, 
    0.00537832f, -0.01431954f, -0.05358553f, 0.02445739f, 0.04537232f, -0.00981363f, 0.03929362f, 0.03371560f, 
    -0.03206788f, 0.01362303f, -0.05403135f, -0.00360250f, 0.03527426f, -0.04752389f, -0.00431946f, -0.01544438f, 
    0.02714214f, -0.05022817f, 0.00781465f, -0.02805458f, 0.01174306f, -0.01053612f, -0.05109530f, -0.02788770f, 
    -0.01240903f, 0.01845433f, 0.03256372f, -0.04694031f, -0.03968517f, -0.01284405f, -0.04650323f, 0.00289270f, 
    -0.01733681f, -0.00183225f, -0.00876904f, 0.04552135f, 0.04309684f, -0.05306518f, -0.01383053f, -0.05335719f, 
    0.01100562f, 0.01355022f, -0.00694483f, 0.00551137f, 0.03697751f, -0.02912720f, -0.02938698f, -0.03437942f, 
    0.01309980f, 0.03318349f, -0.05321431f, -0.04722054f, -0.05299257f, -0.03049056f, 0.01397776f, -0.05038581f, 
    -0.01737845f, -0.03058125f, -0.00330740f, -0.00626718f, -0.02718794f, -0.03300225f, -0.04454419f, -0.01926183f, 
    0.01416905f, 0.04458642f, -0.04849654f, 0.04169520f, 0.03025350f, 0.02896345f, -0.04195585f, 0.02357379f, 
    0.00142833f, -0.01024446f, -0.05277555f, -0.00717371f, -0.01311559f, -0.01400525f, -0.01064967f, -0.02504778f, 
    0.00463679f, -0.00803659f, -0.00776819f, -0.01925526f, 0.00528170f, 0.02707873f, 0.03798559f, 0.02270136f, 
    -0.02928830f, -0.04670627f, 0.03693417f, 0.03403617f, 0.03040231f, -0.01015454f, 0.00790928f, -0.02936941f, 
    0.05572018f, -0.00704183f, 0.00274437f, -0.03248713f, 0.00208846f, -0.03755160f, 0.00983256f, -0.05305954f, 
    -0.03727649f, -0.00926025f, 0.00736411f, -0.05154148f, 0.00646515f, -0.03301168f, -0.02528520f, -0.01938140f, 
    0.00789320f, -0.04987061f, 0.00018644f, -0.02101260f, 0.01650649f, 0.00859573f, 0.02186671f, -0.01340464f, 
    -0.04614565f, -0.01272982f, -0.04869459f, -0.02968516f, -0.00263807f, -0.01613025f, -0.00315465f, -0.03475778f, 
    -0.01446126f, -0.02334603f, -0.00657608f, -0.05036209f, -0.01896264f, 0.03807195f, -0.00435325f, -0.03112421f, 
    0.02771544f, -0.04333379f, 0.04494027f, -0.00662829f, -0.04997716f, -0.05161264f, -0.02649549f, -0.01796870f, 
    -0.04189194f, -0.02728373f, 0.05466652f, -0.03937545f, 0.03976646f, -0.04291567f, -0.02390792f, -0.03792295f, 
    0.03178944f, 0.01343166f, 0.01000863f, 0.02375312f, 0.01397966f, 0.00973767f, 0.01653484f, 0.03704744f, 
    0.02806707f, -0.05401037f, -0.03980353f, 0.01824101f, -0.01968550f, -0.00267139f, -0.01935693f, 0.04371149f, 
    0.04018556f, 0.02749866f, 0.02614507f, -0.00503424f, -0.03987102f, -0.05613568f, 0.03619263f, 0.01799459f, 
    0.02403627f, -0.03988369f, -0.03688204f, -0.00926336f, 0.04047273f, 0.04240412f, 0.03859894f, -0.00887477f, 
    -0.05483818f, -0.02028400f, 0.00427160f, -0.03110846f, -0.05034880f, -0.02695850f, 0.01235618f, 0.03874475f, 
    -0.02207973f, 0.02496012f, 0.00997481f, -0.00192062f, 0.02821943f, 0.01439533f, -0.01627770f, 0.02085697f, 
    -0.03600064f, -0.02490612f, -0.03398897f, -0.05236403f, -0.02318197f, -0.05539458f, 0.02301585f, -0.03947121f, 
    -0.00748084f, 0.03542989f, -0.03229013f, 0.00402761f, 0.01798115f, 0.03456222f, 0.02708401f, -0.02714607f, 
    -0.00649991f, -0.03875547f, -0.01022189f, -0.04438837f, -0.05264559f, 0.01529907f, -0.00430885f, 0.03815763f, 
    -0.05090633f, -0.04632850f, 0.04115153f, -0.04725115f, 0.03494110f, 0.03805591f, -0.01529574f, -0.04541807f, 
    -0.02755916f, -0.00201177f, -0.04402508f, 0.01947232f, -0.03725350f, -0.03944328f, 0.03220703f, -0.04022407f, 
    -0.02127604f, -0.03978956f, 0.03855878f, 0.01815319f, 0.04030470f, -0.04460604f, -0.00187248f, 0.02335147f, 
    0.02631314f, -0.03597990f, -0.00413211f, -0.04893056f, 0.01037774f, 0.01548561f, -0.04639095f, 0.02140009f, 
    0.03306187f, -0.05129986f, -0.00392271f, 0.01554324f, -0.02172350f, 0.00916788f, -0.05040514f, -0.00161182f, 
    0.00509251f, 0.01615730f, 0.03204639f, 0.00242737f, -0.03556879f, 0.02231470f, -0.03290023f, -0.00154967f, 
    0.01789563f, 0.00907249f, 0.03675665f, 0.00061487f, -0.01998905f, -0.01943726f, -0.01671114f, 0.00577136f, 
    -0.04972181f, -0.00410367f, 0.02593999f, 0.00666670f, 0.01911387f, 0.04172568f, -0.00583218f, -0.00654745f, 
    -0.00473623f, -0.04221201f, 0.03570470f, 0.03357937f, -0.05009658f, 0.01843705f, -0.02079219f, 0.01297939f, 
    0.03550962f, -0.04543912f, 0.01924710f, -0.03110314f, -0.02618287f, 0.01759890f, 0.03347505f, -0.04996148f, 
    -0.01369687f, 0.02277462f, 0.04073666f, 0.02600464f, -0.03888046f, -0.01318712f, -0.01157279f, -0.03739526f, 
    -0.04607410f, 0.00560545f, -0.01381810f, 0.02359238f, -0.01433983f, 0.02405590f, -0.00790258f, -0.04743817f, 
    -0.03041298f, 0.01592110f, -0.01542689f, -0.02600954f, 0.02220873f, -0.02210589f, 0.03442021f, 0.03744299f, 
    -0.01415770f, -0.04565199f, -0.03232807f, -0.02952991f, -0.00887031f, 0.04046930f, -0.03847083f, -0.01802160f, 
    0.18438229f, 0.04093857f, 0.03480956f, 0.11118183f, -0.07803918f, 0.03938085f, -0.02871285f, 0.07212600f, 
    0.03094321f, -0.10458631f, -0.05752572f, 0.10019232f, 0.06398807f, 0.17241786f, -0.25722563f, -0.05969783f, 
    0.02467662f, 0.02063140f, -0.02613451f, 0.09062753f, 0.01853226f, 0.04443523f, 0.14156157f, -0.18233955f, 
    0.23934789f, 0.27226746f, 0.25375119f, 0.06679654f, -0.00259650f, -0.00464866f, 0.00043476f, 0.18713859f, 
    0.08387357f, -0.00472061f, 0.07498536f, -0.02413959f, -0.07515869f, 0.16587365f, -0.13134024f, -0.05505235f, 
    -0.07958321f, 0.12864845f, 0.10618037f, 0.02583914f, 0.00626856f, -0.05873663f, -0.18016332f, -0.03687265f, 
    0.17844616f, -0.25383624f, -0.15484214f, -0.18105645f, -0.01514945f, -0.03628766f, 0.04490396f, -0.01546089f, 
    -0.03532512f, -0.01563658f, -0.04676719f, 0.00315459f, 0.11104962f, -0.04239607f, -0.04859279f, -0.02541550f, 
    0.03556716f, -0.02769567f, 0.01335607f, 0.01456282f, 0.10766703f, 0.04055586f, 0.03404794f, 0.11516074f, 
    0.03210236f, -0.11600842f, -0.07602891f, 0.17955047f, 0.02216464f, -0.04223616f, -0.03219981f, 0.16896480f, 
    -0.02465256f, -0.02739403f, -0.11679541f, 0.05351312f, -0.25985473f, -0.12567878f, 0.27191189f, 0.38013217f, 
    0.05723291f, 0.07204202f, 0.04525021f, -0.02024407f, 0.02078827f, 0.14492819f, 0.06745189f, 0.01707400f, 
    -0.29276636f, 0.26775736f, 0.02197419f, -0.04061638f, -0.01030512f, -0.03540622f, 0.09412327f, -0.00871879f, 
    0.07916155f, 0.07115389f, 0.01731188f, 0.03967135f, 0.09937709f, 0.10791527f, 0.05119465f, 0.01532415f, 
    0.08237218f, 0.06080293f, 0.12352993f, 0.04932965f, 0.23062223f, 0.01075933f, -0.02856769f, -0.11046527f, 
    -0.41332552f, 0.05204009f, 0.11398517f, 0.05058956f, -0.09126430f, 0.01117707f, -0.11033203f, -0.03198273f, 
    -0.01328898f, 0.07653139f, -0.10992489f, 0.11212575f, -0.32876229f, -0.18148600f, 0.10938604f, 0.08202618f, 
    0.00328146f, -0.02283289f, -0.12801625f, 0.01058120f, -0.01558862f, 0.01362608f, -0.04411437f, -0.07110112f, 
    -0.09517496f, 0.31318510f, 0.12266205f, -0.19758858f, 0.02568052f, 0.06592136f, 0.04751917f, 0.09073610f, 
    0.09193756f, 0.06769428f, 0.03572990f, 0.03060683f, 0.10464206f, -0.16095257f, 0.10654747f, -0.16196701f, 
    0.01101254f, -0.03089589f, -0.04492153f, -0.00084540f, 0.05792528f, 0.11390522f, 0.04212863f, 0.16697744f, 
    -0.07300322f, 0.21997462f, -0.00308666f, 0.09397212f, -0.00025169f, -0.07255348f, -0.05851425f, -0.01919036f, 
    -0.08814985f, 0.03120378f, 0.05785126f, -0.02350833f, 0.07234482f, 0.45875025f, -0.11780383f, -0.43566266f, 
    0.07007841f, 0.06101664f, 0.03199942f, 0.04291535f, 0.04834696f, 0.08021577f, -0.06332172f, 0.02627577f, 
    0.22208636f, -0.12721406f, 0.05181286f, 0.29181710f, -0.03334022f, -0.00281236f, -0.03558348f, -0.02110762f, 
    0.05939171f, -0.08846463f, 0.08445493f, -0.04741192f, -0.09671815f, 0.35823625f, -0.22454488f, -0.21425375f, 
    -0.11183009f, -0.13315801f, -0.00051216f, -0.04517472f, 0.03491021f, -0.02662984f, -0.14555551f, -0.09452190f, 
    0.26814434f, 0.03090157f, -0.17973672f, 0.16978891f, -0.04795655f, 0.00696824f, 0.02604761f, -0.00722409f, 
    0.00423679f, 0.11266405f, 0.06871309f, 0.00609609f, -0.19716458f, 0.22446848f, -0.02055459f, -0.11139042f, 
    0.15092486f, 0.11280299f, -0.00852022f, -0.03038674f, -0.01980708f, 0.09473926f, 0.13729401f, -0.05292611f, 
    -0.11178795f, 0.18733235f, -0.00801702f, 0.04839722f, 0.05553342f, -0.02207236f, 0.00497144f, -0.03630404f, 
    -0.06117724f, -0.15846233f, 0.01995234f, 0.04630709f, -0.19558841f, -0.19575331f, 0.02742935f, -0.04232711f, 
    0.00467702f, -0.08190963f, -0.03214987f, 0.01547449f, 0.10149687f, 0.09433515f, 0.08888993f, -0.04586420f, 
    -0.17591161f, 0.05501460f, 0.04314932f, 0.15695967f, 0.02868797f, -0.04414781f, -0.05518014f, 0.12904081f, 
    0.04099389f, -0.13228056f, -0.06925495f, -0.05016023f, 0.10057627f, -0.14712803f, 0.04169241f, 0.05305623f, 
    -0.03823397f, -0.06433787f, -0.15267190f, -0.01385260f, 0.10056520f, -0.10839842f, 0.03714612f, 0.08003377f, 
    0.28691992f, -0.16842899f, 0.04914047f, 0.14591238f, -0.14688629f, 0.03779824f, -0.08446755f, 0.09946686f, 
    0.05939860f, 0.09023603f, 0.19222353f, 0.03818691f, 0.13485526f, -0.01688257f, -0.06054584f, 0.11264049f, 
    -0.01890755f, -0.03365475f, -0.09539804f, 0.12897256f, -0.06533425f, 0.02018960f, -0.02607004f, 0.06905138f, 
    0.15585081f, -0.22352155f, -0.11605574f, -0.11623570f, -0.07288069f, -0.00906072f, 0.02724739f, 0.10573243f, 
    -0.05315003f, -0.05357510f, -0.13128817f, 0.00352234f, -0.18566370f, -0.00880469f, 0.15343009f, 0.20937197f, 
    0.01855894f, 0.02963892f, -0.00261227f, -0.03760470f, 0.03462116f, -0.05066385f, 0.06226231f, 0.14131521f, 
    -0.18732443f, -0.10551458f, -0.15658149f, 0.01137521f, 0.10696115f, 0.09533834f, -0.04576070f, 0.09541642f, 
    -0.03450497f, 0.03959002f, -0.03408531f, -0.03855926f, 0.34322897f, 0.17289409f, -0.13689376f, -0.03226624f, 
    0.19902529f, -0.05601025f, -0.10127470f, 0.02780575f, -0.09480852f, -0.01157720f, -0.10279246f, -0.04675633f, 
    0.19475420f, 0.05853919f, 0.21101944f, 0.00741711f, 0.02025897f, 0.05113437f, -0.00036856f, 0.13860241f, 
    -0.00925783f, 0.08258063f, 0.04438201f, 0.00541959f, -0.30281001f, 0.15693402f, -0.07285550f, 0.02489548f, 
    -0.02758165f, 0.03871389f, 0.03404568f, 0.05805564f, 0.14338623f, 0.01890259f, -0.07563428f, -0.06823939f, 
    -0.15122443f, -0.01121384f, -0.09408202f, 0.16650963f, 0.10953787f, -0.02932976f, 0.01489433f, 0.12700796f, 
    -0.06970280f, 0.08473976f, 0.00646012f, -0.16517450f, -0.22500017f, 0.24605995f, 0.00511282f, -0.00502553f, 
    0.07108391f, 0.04880456f, 0.19418053f, -0.02186418f, 0.09282824f, 0.02561722f, 0.05237292f, 0.00567690f, 
    -0.09142686f, 0.03217512f, 0.13943133f, 0.17541485f, -0.00288751f, 0.03520598f, 0.07012321f, 0.15632632f, 
    0.11667788f, 0.01019599f, -0.01442346f, 0.05262174f, -0.13522947f, 0.15970589f, 0.01771301f, -0.02838160f, 
    0.11190381f, 0.06119185f, -0.11176937f, -0.00489414f, 0.05437832f, -0.12590429f, -0.01164496f, 0.16652216f, 
    0.31028000f, 0.06433662f, 0.23073861f, -0.17211875f, -0.06489326f, -0.01334017f, 0.03439813f, 0.08189029f, 
    -0.07019025f, -0.02338344f, -0.07460083f, -0.01291601f, -0.11563198f, -0.15217331f, 0.07937443f, 0.20527206f, 
    -0.05954123f, -0.11111151f, -0.02325677f, -0.12002770f, -0.03311184f, -0.04127527f, 0.02030330f, -0.04178583f, 
    0.35008249f, -0.06791554f, -0.16660278f, -0.04963584f, 0.03083198f, -0.01429752f, 0.04377773f, -0.16491233f, 
    0.04385215f, -0.01795025f, 0.07929279f, 0.04552023f, -0.03143804f, -0.06783826f, 0.07757950f, 0.31953862f, 
    -0.05012874f, -0.00454441f, 0.09047049f, 0.02226346f, -0.04856146f, -0.02846938f, 0.07638852f, -0.07000799f, 
    0.13146020f, 0.00951696f, 0.21009007f, -0.18005216f, 0.15144329f, 0.07948602f, 0.10236964f, 0.16857572f, 
    -0.02127041f, 0.08687101f, 0.12404156f, 0.01260174f, 0.23705697f, -0.00155529f, -0.07538729f, 0.02448986f, 
    0.14536986f, -0.09363432f, 0.05731164f, 0.14187506f, 0.06056864f, -0.17404510f, -0.05807393f, 0.03831250f, 
    0.53651959f, 0.04082370f, -0.06546605f, 0.03871358f, -0.02048907f, 0.06541527f, -0.04260265f, -0.04040945f, 
    -0.06981461f, 0.07931478f, 0.05444985f, -0.08857644f, 0.23520322f, -0.15085559f, -0.03748478f, 0.26536757f, 
    -0.02888740f, -0.00394975f, 0.18633555f, -0.00044970f, 0.14445415f, 0.00300994f, -0.07776884f, -0.12777102f, 
    -0.29313499f, -0.11093811f, 0.36381328f, -0.02781454f, 0.07285058f, -0.08194029f, 0.06341375f, -0.00660116f, 
    0.02472976f, 0.08197702f, -0.07939904f, -0.03254728f, 0.09430385f, -0.22516975f, 0.11910044f, -0.26942223f, 
    0.10531144f, 0.13022417f, -0.04046305f, 0.00603564f, -0.10910907f, -0.09421315f, 0.11210243f, 0.06362361f, 
    -0.25946587f, 0.03680843f, 0.17278817f, -0.10230114f, 0.08628990f, 0.01555419f, 0.07989586f, 0.07237939f, 
    0.13728659f, 0.00363414f, -0.01028368f, 0.04811801f, 0.04522057f, -0.02273188f, -0.04565652f, 0.08864303f, 
    -0.10276857f, -0.09611205f, 0.02046757f, 0.00625875f, -0.10684771f, -0.04033960f, 0.03702265f, -0.05307667f, 
    0.37281430f, 0.01412896f, -0.01167569f, 0.15049243f, -0.00235102f, -0.00117373f, 0.13054767f, 0.05481351f, 
    -0.05586271f, 0.06513620f, -0.03326501f, 0.06274113f, 0.08378894f, 0.12168886f, 0.22673368f, -0.09924501f, 
    -0.12223322f, -0.11842169f, 0.12736019f, 0.02822491f, 0.02752345f, -0.07906587f, 0.14568175f, 0.11077836f, 
    -0.27432224f, 0.19414146f, 0.00842863f, 0.11672037f, 0.01221730f, 0.00535060f, 0.08000098f, -0.13521264f, 
    -0.12010242f, 0.02863497f, 0.08535168f, -0.12108897f, -0.14470848f, 0.13232641f, 0.20106043f, -0.02274120f, 
    -0.11792441f, 0.06702433f, -0.13955963f, 0.00674516f, -0.02535683f, -0.05977326f, -0.00710918f, -0.02247640f, 
    -0.13122755f, 0.08311185f, -0.00341855f, 0.04085014f, 0.13056348f, 0.08925316f, 0.04116461f, 0.12790911f, 
    0.02987094f, 0.00641860f, 0.05583819f, -0.03895192f, 0.18345906f, -0.15064381f, -0.07263280f, -0.18470630f, 
    -0.01338324f, -0.00203187f, -0.07092814f, -0.04655711f, -0.06667961f, -0.13024071f, -0.02393882f, -0.11370787f, 
    -0.26536095f, 0.02960641f, -0.02994811f, -0.19018619f, 0.00917392f, -0.09976052f, 0.00790697f, -0.00092937f, 
    -0.08457226f, 0.03052438f, -0.03442059f, -0.02128534f, 0.35017371f, 0.19484062f, -0.11317798f, 0.03658099f, 
    -0.07741077f, 0.07902448f, 0.04524464f, 0.22862060f, 0.04408800f, 0.10021921f, -0.10883336f, 0.01445451f, 
    0.37462088f, 0.29010326f, -0.07069702f, 0.12814316f, -0.00969051f, -0.05037813f, 0.02929446f, 0.01096829f, 
    -0.12138580f, -0.01359559f, -0.14234470f, 0.03335902f, 0.18053097f, -0.03689720f, 0.01686674f, 0.08903041f, 
    -0.08471959f, -0.05766141f, -0.03644406f, -0.02926134f, -0.07775786f, 0.03258910f, 0.00306714f, -0.21128666f, 
    -0.07878793f, 0.10141949f, 0.05251647f, -0.11579972f, -0.00262481f, -0.04354912f, 0.00055849f, -0.02804208f, 
    -0.11609932f, -0.00054924f, 0.00096672f, -0.10538319f, 0.03950541f, 0.19091542f, -0.12715830f, -0.00168874f, 
    0.05690020f, 0.00223413f, -0.01241604f, 0.09291148f, -0.08022205f, -0.12537068f, -0.03477497f, -0.16375148f, 
    0.24283625f, -0.19963379f, -0.00741696f, 0.03690736f, 0.05692844f, -0.07085995f, 0.07342983f, 0.19392601f, 
    0.06080106f, 0.18353984f, 0.14888291f, 0.14987998f, 0.00656345f, 0.14540879f, 0.10988129f, -0.03751418f, 
    -0.13868299f, 0.09080454f, 0.04567168f, -0.09426064f, -0.05181235f, 0.08919922f, -0.04441032f, 0.03974670f, 
    0.03939730f, 0.00960725f, 0.02986847f, 0.07737363f, -0.01186790f, -0.01930645f, 0.08608419f, 0.08301199f, 
    -0.08853395f, 0.06711286f, 0.02095844f, -0.02299699f, 0.14123021f, -0.00150096f, 0.14688174f, -0.04411765f, 
    -0.03823528f, -0.02724081f, -0.06098448f, -0.10214166f, 0.01662449f, 0.03259087f, 0.19806951f, 0.19623022f, 
    0.00850009f, 0.04342918f, -0.01206310f, -0.03797179f, -0.00554523f, -0.01051997f, 0.02979194f, 0.01244458f, 
    -0.04811586f, 0.00938360f, -0.00792624f, 0.01521998f, 0.03177978f, -0.02536735f, 0.04076990f, -0.00886050f, 
    -0.04817951f, 0.00192547f, -0.01160714f, -0.04689744f, -0.05068393f, 0.03868822f, 0.03016388f, 0.03073095f, 
    -0.05202501f, 0.03158636f, 0.03768919f, 0.01456849f, -0.02242552f, -0.01994695f, -0.04731764f, -0.02446431f, 
    -0.03221107f, -0.04763810f, 0.00951406f, -0.02947752f, -0.02681689f, -0.00171966f, -0.05555081f, 0.01208842f, 
    -0.00945931f, -0.02460618f, -0.04207159f, 0.00860220f, -0.04594597f, 0.02312666f, -0.02586929f, -0.03218202f, 
    -0.03012021f, 0.02185645f, 0.02563803f, -0.00189721f, -0.01284907f, 0.01497900f, -0.00675773f, -0.00897606f, 
    0.02855749f, 0.01969445f, 0.01157532f, 0.01856264f, -0.01304438f, -0.05052933f, 0.01444843f, 0.00152463f, 
    -0.04865343f, -0.02729887f, -0.04598936f, 0.03299374f, -0.03187858f, -0.05098604f, 0.03502478f, 0.02743455f, 
    -0.03533133f, -0.05758946f, -0.00990102f, -0.02032124f, 0.00404186f, -0.03149877f, 0.02428980f, -0.05846872f, 
    -0.01951921f, 0.02473898f, -0.03841329f, 0.01747092f, 0.00473761f, -0.01313359f, 0.03689795f, 0.04751403f, 
    -0.02067268f, 0.02855496f, -0.02409405f, 0.03821915f, 0.01120218f, 0.04691850f, -0.02997257f, -0.02106843f, 
    -0.05264509f, 0.02777709f, 0.02719421f, 0.01450550f, -0.00636014f, -0.00851096f, -0.01851584f, -0.02842923f, 
    0.01006293f, 0.02211558f, -0.01910543f, 0.02867343f, 0.02423620f, -0.01799971f, 0.03814756f, 0.00457634f, 
    0.02927207f, 0.03581977f, -0.04300990f, -0.03858935f, 0.03455814f, 0.00659815f, 0.03962984f, -0.02596231f, 
    -0.00388772f, 0.04188751f, -0.04870174f, -0.03974886f, 0.00245298f, -0.03704740f, -0.02541484f, -0.04980425f, 
    -0.00008959f, 0.00966503f, 0.01672964f, 0.03551271f, -0.05605178f, -0.01518030f, 0.03448646f, 0.04158265f, 
    0.01015921f, -0.00148362f, -0.01710701f, -0.03728292f, 0.00772455f, -0.04741907f, -0.03345392f, -0.01245310f, 
    -0.00634247f, -0.01685594f, 0.02208234f, -0.02200868f, -0.03803104f, -0.02996633f, 0.01689623f, -0.03124798f, 
    -0.00676828f, 0.02240388f, 0.01608779f, -0.02674961f, 0.00502891f, -0.02622541f, -0.04380947f, -0.05130888f, 
    -0.01904546f, 0.03472530f, 0.03308343f, -0.04384060f, 0.01327937f, -0.03206390f, -0.01621199f, -0.03469828f, 
    0.00911992f, -0.00344871f, 0.04140970f, -0.04051903f, 0.03715868f, -0.00832418f, -0.04086968f, -0.04182666f, 
    0.01972828f, 0.00996154f, 0.04628562f, -0.01955259f, -0.01403377f, -0.00965770f, 0.00372901f, -0.03202495f, 
    0.01387092f, -0.00066260f, -0.03322136f, -0.05960114f, -0.03154848f, 0.04020457f, -0.02979541f, -0.03064797f, 
    0.02435752f, 0.01014558f, -0.00862908f, -0.02644312f, -0.01044155f, 0.00150666f, 0.03232282f, -0.04499345f, 
    0.02937486f, -0.03169370f, 0.02400433f, 0.00114127f, -0.04182607f, 0.02214392f, 0.02675770f, -0.00907439f, 
    -0.01834817f, -0.01628055f, -0.00459551f, -0.02644894f, 0.03830621f, -0.01315619f, 0.02539711f, -0.00987409f, 
    -0.00219276f, 0.04040458f, 0.04208421f, -0.03836993f, 0.02373065f, -0.04717814f, 0.00429993f, -0.02862865f, 
    0.03820716f, -0.04636635f, -0.02794502f, -0.00505927f, -0.01525509f, -0.05385300f, -0.01038583f, -0.00056585f, 
    -0.01532973f, -0.03706539f, 0.04273617f, 0.00025452f, 0.00309889f, -0.03348749f, -0.00725444f, -0.04563290f, 
    -0.03181424f, -0.05349195f, 0.01683381f, 0.03524369f, -0.04892112f, -0.05172836f, -0.04253963f, 0.00668388f, 
    0.02285607f, 0.02970557f, 0.02205676f, -0.01901474f, -0.02932430f, 0.04284604f, 0.00687972f, 0.01613933f, 
    0.02472483f, -0.01221645f, 0.01739273f, 0.00666058f, -0.02983410f, 0.02410271f, -0.04446173f, 0.01686484f, 
    -0.00262741f, -0.04346992f, 0.04537551f, -0.05589385f, 0.02549158f, 0.04303627f, -0.03246062f, -0.03817785f, 
    -0.03311641f, -0.03701817f, -0.02508337f, -0.02885663f, -0.05092618f, 0.00957337f, -0.05013385f, -0.02007787f, 
    -0.03356868f, -0.00532758f, 0.00506709f, 0.04180547f, 0.02284624f, 0.02681056f, -0.01422583f, -0.04431757f, 
    0.00597991f, -0.05475291f, 0.00642385f, 0.03599020f, -0.01814670f, -0.00577214f, -0.04028583f, -0.03676523f, 
    0.02715782f, -0.01778282f, 0.01476363f, 0.03842749f, 0.00113397f, -0.02214540f, 0.02684269f, 0.04563427f, 
    -0.01923282f, -0.00058643f, 0.01661897f, -0.01850375f, -0.02934298f, -0.00239639f, -0.04601266f, -0.04593985f, 
    -0.02500927f, -0.05393572f, 0.03844025f, 0.02053723f, -0.02943186f, 0.01228821f, -0.01088745f, -0.02122235f, 
    0.01980691f, -0.00458472f, -0.01299362f, -0.05342833f, 0.01060380f, -0.02824075f, -0.03450237f, -0.02859148f, 
    0.00325071f, -0.01598375f, -0.01341030f, -0.02731925f, -0.01807178f, -0.02749697f, 0.00442065f, 0.02496209f, 
    0.04172992f, -0.02079124f, -0.05839260f, 0.02395647f, -0.00934074f, -0.00651861f, -0.01570397f, 0.03844946f, 
    -0.03665479f, -0.05018936f, -0.02714294f, -0.00713624f, 0.00103546f, 0.01860446f, 0.02460277f, -0.03124571f, 
    -0.03760708f, -0.05944496f, 0.03807758f, -0.01364589f, 0.01518459f, -0.03715055f, -0.05831291f, -0.00329354f, 
    -0.04699273f, 0.02238128f, 0.00080882f, 0.02035526f, -0.02968829f, -0.05683219f, -0.04155906f, -0.00275947f, 
    0.02455239f, 0.00464442f, 0.03332519f, -0.00518960f, 0.03453942f, -0.02797605f, 0.03092430f, 0.03286041f, 
    -0.05132398f, -0.01573724f, 0.03954992f, -0.01169138f, 0.02960193f, -0.01110408f, 0.03733762f, 0.03878556f, 
    -0.00227206f, -0.05087901f, 0.02609430f, 0.03481228f, 0.02801051f, -0.01436648f, 0.01686993f, -0.02911522f, 
    -0.04537372f, -0.04947219f, -0.05108454f, -0.02066579f, -0.01999657f, 0.02618131f, 0.03376310f, -0.00212559f, 
    -0.01509101f, 0.01682815f, 0.03962280f, -0.02500163f, -0.05370152f, 0.01855694f, -0.00900640f, -0.01787285f, 
    -0.04372850f, -0.00616445f, -0.03276448f, -0.02212507f, -0.04227170f, -0.04655445f, 0.03640220f, -0.04589073f, 
    -0.02561483f, 0.02209202f, -0.02802690f, 0.00446498f, 0.00080925f, 0.00412229f, 0.02225069f, -0.05643250f, 
    0.00421441f, -0.01500683f, -0.00664671f, 0.03093839f, 0.04524648f, 0.02423829f, 0.04110899f, 0.02847414f, 
    -0.00540820f, -0.01924318f, 0.01163229f, 0.02144900f, -0.01354019f, 0.02035222f, -0.01078878f, -0.03930626f, 
    -0.03737116f, -0.02900042f, -0.02254751f, -0.04051451f, 0.01931062f, 0.03243225f, -0.05485471f, 0.01906386f, 
    0.00293843f, -0.01691231f, 0.04043955f, 0.02016450f, 0.02006212f, 0.03238401f, 0.00718052f, 0.01196678f, 
    0.00295761f, 0.01303683f, 0.02034330f, -0.01097965f, -0.03781019f, 0.03691027f, -0.00123165f, 0.02991765f, 
    -0.00691146f, 0.00519170f, -0.00104897f, 0.03146691f, -0.03270168f, -0.03686483f, 0.04072488f, -0.00079178f, 
    -0.05797848f, 0.00820083f, 0.02211920f, 0.04338415f, 0.04082232f, -0.05187858f, -0.03140542f, -0.02546440f, 
    0.00751915f, 0.03481599f, -0.05319677f, -0.01433925f, -0.02113062f, -0.01088191f, 0.03274972f, 0.01792302f, 
    -0.00860009f, -0.03470236f, 0.01503462f, -0.00264962f, -0.00896866f, -0.05101076f, -0.01712850f, -0.01836634f, 
    -0.03883274f, -0.00221464f, 0.01560379f, -0.01910657f, -0.03133268f, -0.04171816f, 0.00476978f, 0.02086154f, 
    0.01245028f, -0.01229083f, -0.02616847f, -0.00409080f, -0.04843486f, -0.03110450f, 0.01085891f, 0.00018181f, 
    -0.01228254f, 0.00233898f, -0.02918906f, 0.03343338f, -0.05966703f, 0.03590428f, -0.03220430f, -0.02648443f, 
    -0.04734281f, -0.00450604f, -0.05593868f, -0.05077387f, -0.00383920f, -0.02510080f, 0.01215828f, -0.02131338f, 
    -0.04155995f, -0.00684152f, 0.00918481f, 0.03149116f, -0.03437328f, -0.04483729f, 0.00565753f, -0.03935621f, 
    -0.05327928f, 0.02554226f, 0.03258086f, -0.00957445f, 0.00198920f, -0.06451433f, 0.01706740f, -0.01102804f, 
    -0.01498261f, -0.04522510f, 0.02216543f, -0.03646393f, 0.03637132f, 0.01677072f, -0.02337924f, 0.04056235f, 
    -0.04699013f, -0.05907109f, -0.04521250f, -0.05509575f, -0.01225258f, -0.04736634f, -0.04208665f, 0.04154530f, 
    -0.04216781f, 0.01967626f, 0.03725700f, -0.02130144f, 0.02818636f, -0.03931657f, -0.00244549f, -0.01155130f, 
    0.03452975f, 0.02754906f, -0.01797076f, 0.00932655f, -0.04507172f, -0.03480264f, 0.01400556f, -0.04256385f, 
    -0.02758757f, -0.05411429f, -0.04141911f, 0.04755501f, -0.02787216f, -0.03572693f, 0.00836040f, 0.00939250f, 
    -0.01843199f, -0.03388358f, -0.04057255f, 0.04127679f, -0.05618427f, -0.05476706f, -0.01922880f, -0.02089213f, 
    -0.02666479f, -0.03115470f, 0.03254190f, -0.04759663f, 0.00828052f, 0.03102916f, -0.03494014f, -0.00612482f, 
    0.00472579f, 0.02014956f, -0.05961511f, -0.00429437f, 0.00949132f, 0.01372563f, -0.03764987f, 0.01373548f, 
    -0.02745939f, -0.02763365f, 0.02957172f, -0.03850073f, 0.02444411f, -0.02492197f, -0.04885295f, -0.00867288f, 
    -0.00011990f, 0.01466238f, 0.04594546f, -0.03189532f, 0.01970720f, 0.03289883f, 0.02638259f, -0.03120192f, 
    -0.01128897f, -0.03509758f, 0.01693299f, -0.03669620f, -0.04540166f, 0.01249471f, 0.01850695f, 0.02386788f, 
    0.01711850f, -0.02497810f, 0.00646043f, 0.00342315f, -0.02819159f, -0.00920075f, 0.02678837f, 0.01583817f, 
    0.00652912f, -0.01459164f, 0.00258257f, -0.01235406f, -0.00455644f, 0.00737738f, -0.00675019f, 0.01880373f, 
    0.02447871f, 0.02278176f, 0.01246331f, -0.04663219f, -0.05264404f, 0.04581825f, 0.04147381f, -0.01733106f, 
    0.03506216f, -0.03154573f, -0.04658525f, 0.02972402f, -0.03635631f, -0.00489201f, 0.02848042f, -0.03744746f, 
    0.04688856f, 0.01409693f, 0.01059158f, 0.04424118f, -0.03695816f, 0.00560149f, 0.04172408f, 0.00662661f, 
    -0.03089017f, 0.03145652f, -0.04276120f, -0.02184432f, 0.03831587f, 0.01747633f, -0.03603219f, 0.03327901f, 
    0.03760576f, 0.03842911f, 0.02380750f, -0.01920337f, -0.00422599f, -0.03021061f, 0.02167708f, -0.03953006f, 
    -0.00250887f, 0.03994552f, -0.05336704f, -0.04869312f, 0.04407473f, 0.03884957f, -0.00243122f, 0.01362569f, 
    -0.01009007f, 0.02917404f, -0.00503936f, -0.01163732f, 0.00326683f, -0.02862601f, -0.06771676f, -0.03758157f, 
    -0.01332796f, -0.03985080f, 0.01549203f, -0.04854986f, -0.02502072f, 0.03274183f, 0.03981831f, -0.02344458f, 
    0.00337822f, -0.02429036f, 0.00687863f, 0.01606836f, -0.02118705f, 0.00826248f, 0.02773957f, -0.04465001f, 
    0.00838450f, -0.04860698f, 0.02922547f, -0.05072550f, 0.01329084f, -0.01645468f, 0.03140085f, -0.03364652f, 
    0.02699809f, -0.03652275f, 0.01675650f, 0.02764341f, -0.01917081f, 0.03138658f, 0.04569898f, -0.03921848f, 
    -0.01998432f, 0.03896365f, 0.01310766f, -0.02333535f, -0.04890443f, -0.02126163f, -0.04898607f, -0.00168061f, 
    -0.04114754f, -0.02892938f, 0.02939559f, -0.05863200f, 0.00912291f, 0.03835166f, 0.01566217f, 0.00857327f, 
    0.02225700f, -0.04043560f, 0.04000062f, 0.04152662f, -0.01646128f, 0.03342016f, -0.06066790f, -0.04389874f, 
    0.02138066f, 0.02355688f, -0.01744547f, 0.01815107f, 0.01405282f, 0.01694066f, -0.01364455f, -0.01459782f, 
    0.20513926f, -0.23846753f, -0.11764561f, 0.02551254f, 0.00008794f, 0.08043226f, -0.04232705f, 0.15865876f, 
    -0.00526691f, -0.03157195f, -0.08845106f, 0.15154064f, -0.16767673f, 0.08578145f, 0.00260717f, -0.11184465f, 
    0.10831081f, 0.07799160f, 0.05436916f, -0.09090503f, 0.01832643f, 0.09896923f, 0.07814012f, -0.22281499f, 
    -0.13926230f, 0.06174812f, 0.09859744f, 0.08985665f, 0.14465615f, 0.02891659f, 0.07971352f, 0.14124985f, 
    -0.01940588f, 0.08491936f, 0.04780956f, -0.08285394f, -0.02912450f, 0.20784222f, -0.16249433f, 0.05704620f, 
    -0.00673464f, -0.04633306f, 0.15279666f, 0.05339006f, 0.04125144f, 0.01223891f, -0.14280322f, -0.03807541f, 
    0.14725552f, -0.15715934f, 0.16073334f, -0.30282354f, -0.03747315f, -0.01150713f, 0.07575294f, 0.06740640f, 
    -0.08149565f, -0.11420064f, -0.06115187f, -0.07733607f, -0.25352421f, -0.08772393f, 0.07249967f, -0.05965896f, 
    -0.09173280f, 0.04117581f, -0.04164001f, 0.08268465f, -0.14427844f, -0.01420580f, 0.04092824f, 0.04392878f, 
    -0.19178930f, -0.00108803f, -0.09780107f, -0.04084567f, -0.04627521f, -0.08385398f, 0.09508216f, -0.04299908f, 
    -0.02616944f, -0.04266030f, 0.13427946f, -0.01843380f, -0.13619377f, 0.01656537f, 0.23459518f, 0.38643652f, 
    -0.02285557f, 0.22020428f, 0.05483386f, 0.06010042f, -0.15621760f, 0.03548065f, 0.04957373f, -0.02815419f, 
    -0.03203579f, -0.07510022f, -0.08390199f, -0.18309179f, 0.12477841f, 0.09864832f, -0.02786419f, 0.02769615f, 
    0.16580708f, -0.10610054f, 0.04086740f, 0.06512528f, -0.26451284f, 0.07876560f, 0.12865661f, 0.00819002f, 
    0.22732948f, -0.10374552f, 0.06616197f, 0.00717110f, 0.04063882f, -0.07547725f, -0.03285339f, 0.02852351f, 
    -0.08913163f, 0.15190434f, -0.04501190f, 0.29230732f, 0.04735786f, 0.01456907f, 0.09895495f, 0.07793663f, 
    0.08562185f, 0.11535080f, -0.06975606f, -0.07908230f, 0.16670929f, -0.11011019f, -0.05689820f, 0.12249632f, 
    0.02546459f, 0.10116525f, -0.00191674f, -0.09307744f, 0.00599952f, -0.02809440f, -0.03851105f, -0.03829561f, 
    0.03151562f, -0.04589280f, 0.07855096f, 0.02785258f, 0.03107351f, -0.07399338f, 0.05318512f, 0.02285660f, 
    0.05958209f, 0.09307428f, -0.01293616f, -0.04062141f, 0.21429650f, -0.03379292f, -0.01577557f, -0.06793783f, 
    -0.04533322f, -0.04062614f, 0.12244687f, 0.00590635f, 0.03938225f, 0.00923181f, -0.04609894f, 0.02784876f, 
    0.05036138f, 0.32459840f, 0.04143085f, -0.09773652f, 0.17618965f, -0.04256794f, -0.05785830f, -0.13807157f, 
    0.08011329f, -0.03008885f, 0.02496310f, 0.03498769f, 0.22366735f, -0.16569988f, -0.20142244f, -0.11288071f, 
    0.04471717f, -0.08225439f, 0.02413916f, -0.05007511f, 0.02779966f, 0.03561066f, 0.01423211f, 0.03592309f, 
    0.38192272f, -0.04860936f, 0.04611737f, 0.20412461f, -0.14109407f, -0.09331377f, 0.13618143f, -0.00352970f, 
    -0.09922713f, 0.06863779f, -0.01905615f, -0.03879600f, 0.03557941f, 0.03213174f, -0.03348414f, 0.12547626f, 
    -0.09169260f, 0.01151771f, 0.01766793f, 0.09813540f, -0.05467137f, 0.00387913f, -0.06913117f, -0.07412694f, 
    0.12443147f, 0.09760345f, 0.07030926f, 0.07768138f, 0.02666724f, 0.10551412f, 0.05041937f, -0.06809442f, 
    0.14506519f, 0.11784296f, -0.09498265f, -0.01777651f, 0.00095905f, 0.05669298f, 0.11132947f, 0.03764890f, 
    -0.05833994f, 0.11760461f, 0.08004630f, -0.05318017f, -0.11692680f, 0.07544597f, -0.09582146f, 0.06078345f, 
    0.06707422f, -0.09644887f, 0.00150060f, -0.05513176f, 0.08257335f, -0.06212632f, 0.02445612f, -0.08472721f, 
    0.10513747f, -0.03072273f, -0.05758135f, -0.03751377f, -0.07382659f, 0.21005760f, 0.19343998f, -0.06335235f, 
    0.03175541f, 0.07367444f, 0.01227901f, -0.00680298f, -0.06122937f, -0.04983474f, -0.03768611f, 0.08151835f, 
    -0.03445257f, 0.06496179f, 0.19830199f, -0.14661299f, -0.04646240f, 0.07381032f, 0.06024581f, -0.05598778f, 
    -0.05371947f, 0.05844227f, 0.06086305f, -0.14730948f, 0.38664997f, 0.01938104f, 0.12900884f, 0.17033237f, 
    -0.07640565f, -0.04571607f, -0.04014878f, 0.02472115f, 0.12631473f, -0.01312458f, 0.03557322f, -0.03117855f, 
    0.22440892f, 0.03455032f, 0.11827662f, 0.02995832f, -0.08123862f, -0.06894983f, -0.00599214f, -0.03174080f, 
    0.05788533f, 0.12799975f, -0.00354322f, 0.19898488f, 0.04531316f, 0.02442874f, 0.09064037f, 0.23947830f, 
    -0.08386690f, 0.00168540f, 0.01532572f, -0.02024596f, -0.02555730f, 0.01657950f, -0.00142933f, -0.02811616f, 
    0.03701258f, -0.03274769f, -0.03288799f, -0.12022875f, -0.02123226f, -0.00696549f, 0.02858392f, 0.01535811f, 
    0.02816159f, -0.02646801f, -0.10937891f, 0.08367127f, 0.04717943f, 0.22264074f, 0.19580410f, 0.01927450f, 
    0.02751659f, 0.02615477f, -0.02097929f, 0.07924926f, 0.14309929f, -0.00207343f, -0.03706810f, 0.04457796f, 
    0.11889714f, 0.14238250f, -0.10849614f, 0.00087594f, 0.19754626f, 0.07939495f, -0.04085365f, -0.11432908f, 
    0.05450500f, 0.00739656f, -0.09246127f, -0.03299385f, -0.06785107f, -0.01045211f, 0.11299036f, -0.09552106f, 
    0.05161576f, 0.13205771f, 0.01778907f, -0.04069144f, -0.06801994f, 0.05750233f, -0.06290366f, -0.14823712f, 
    0.01167406f, -0.26710731f, 0.08543186f, 0.16827354f, -0.04959586f, 0.07154610f, 0.01224009f, -0.00990306f, 
    0.02201810f, 0.05571576f, -0.15130106f, 0.04107789f, -0.04178870f, 0.03537007f, -0.15247488f, -0.04871576f, 
    0.01643046f, 0.09417459f, 0.09610936f, 0.06545091f, 0.00483579f, 0.02571247f, 0.02354801f, -0.04119070f, 
    -0.30642793f, -0.02685168f, -0.17572892f, -0.03838740f, 0.12332357f, -0.00329375f, -0.04984496f, 0.11101893f, 
    0.00389692f, 0.00706358f, 0.05596067f, 0.02359390f, -0.07612935f, -0.07565721f, -0.00667001f, 0.05908339f, 
    0.02868470f, 0.13346787f, 0.06880574f, 0.09009507f, -0.03073838f, -0.02210849f, 0.06490336f, 0.01160541f, 
    -0.02166450f, -0.11907063f, 0.02077840f, -0.06820897f, 0.03684712f, 0.03696192f, 0.12021250f, 0.14152607f, 
    -0.09982453f, 0.10076182f, 0.04362654f, 0.10028774f, 0.03797723f, -0.06676248f, -0.13584974f, -0.09814917f, 
    -0.05124961f, 0.04120461f, -0.00432736f, -0.00045575f, 0.05290438f, -0.02575371f, -0.03615469f, -0.06267303f, 
    -0.21842465f, -0.39286965f, 0.22071008f, 0.04364715f, -0.06719225f, 0.04561700f, 0.19270885f, -0.01147028f, 
    -0.06049312f, -0.08044677f, -0.01526091f, -0.03407822f, -0.23629010f, -0.07851718f, 0.16208552f, 0.05772800f, 
    0.02914296f, 0.05198190f, 0.08240061f, -0.08708012f, -0.09296878f, -0.05407681f, 0.05311770f, 0.07976560f, 
    -0.02778475f, -0.02385744f, 0.16748394f, 0.06408106f, 0.09980613f, 0.03874727f, 0.04280929f, -0.11123209f, 
    0.02002161f, 0.01192855f, 0.00284345f, 0.00541944f, 0.23496816f, 0.33144140f, 0.11291932f, -0.16220313f, 
    -0.10089473f, 0.00758010f, 0.04497922f, 0.07039436f, 0.10863891f, 0.01635005f, 0.04511382f, -0.05745250f, 
    0.11766205f, -0.22166973f, 0.03451113f, -0.09704493f, -0.05052939f, 0.00498003f, 0.03141424f, 0.00462325f, 
    -0.12204895f, 0.00245336f, 0.03741111f, 0.08985623f, 0.29895714f, -0.12446368f, -0.08182648f, -0.01089046f, 
    -0.13318771f, -0.00106067f, -0.11069132f, -0.02089860f, -0.04379321f, 0.07580824f, -0.02151033f, 0.07392885f, 
    -0.16732424f, -0.20621695f, 0.04223452f, 0.20023832f, 0.11591832f, 0.08625867f, 0.09389062f, -0.12855184f, 
    0.06984840f, 0.08494806f, -0.05604624f, 0.00572976f, 0.11394231f, 0.01117414f, 0.07551603f, 0.13345207f, 
    0.00404332f, 0.02360775f, 0.00479977f, 0.01825566f, 0.11088651f, 0.06795518f, 0.00512687f, 0.04421195f, 
    -0.24157919f, -0.10503266f, 0.00160927f, 0.02786282f, 0.09375338f, -0.01268856f, 0.12362663f, 0.05258303f, 
    0.06867071f, 0.00838117f, -0.10692838f, -0.01583862f, -0.03300923f, -0.12346399f, 0.02484563f, 0.03871186f, 
    0.09604774f, 0.10826197f, -0.12822044f, -0.02824982f, -0.04675698f, 0.12929551f, 0.01346353f, 0.09499335f, 
    0.26282784f, -0.12445159f, 0.01490563f, -0.00473391f, -0.07167161f, 0.05380940f, 0.08901176f, 0.10658160f, 
    0.08367427f, 0.04067198f, -0.02664278f, 0.09917309f, 0.01149762f, 0.20391534f, -0.23338594f, -0.00954068f, 
    -0.02672119f, -0.06959736f, 0.06323853f, -0.07269116f, 0.01806360f, -0.04359637f, 0.05271475f, 0.00404788f, 
    -0.07022316f, -0.00034010f, 0.16997305f, 0.09959363f, -0.13985413f, -0.01064522f, -0.03615578f, 0.04055433f, 
    0.06827478f, -0.02427209f, -0.01827517f, 0.12565154f, 0.12875944f, 0.12809728f, -0.02258229f, 0.04142980f, 
    -0.01582204f, 0.04084945f, 0.01340987f, 0.04070716f, -0.09934407f, 0.16675490f, -0.04613508f, 0.00388185f, 
    -0.04370788f, 0.07677127f, 0.06352352f, 0.05915242f, 0.04759903f, -0.04371075f, 0.02823824f, 0.07759390f, 
    0.03231499f, 0.03036792f, 0.05817564f, 0.15361145f, 0.12029041f, 0.08532401f, 0.12857270f, -0.09964811f, 
    0.04251188f, 0.01910851f, -0.07996479f, -0.01164080f, 0.06841582f, -0.10143190f, 0.02642373f, 0.06443836f, 
    0.19056290f, -0.00620516f, -0.01820975f, -0.06233533f, -0.00584784f, 0.01311507f, -0.06056868f, 0.12510522f, 
    -0.08913028f, 0.01039160f, 0.08999600f, 0.05166206f, -0.27070469f, 0.08579931f, 0.22784284f, -0.06453628f, 
    -0.01894236f, 0.01910080f, -0.04168942f, 0.07533897f, 0.06482130f, 0.04720348f, 0.08719713f, 0.06395859f, 
    -0.13773231f, -0.02584687f, 0.14813812f, 0.03253997f, -0.06857000f, -0.10124160f, 0.00312611f, -0.04420483f, 
    0.08986671f, -0.02160988f, 0.09271490f, 0.11920401f, -0.14333916f, -0.02209099f, -0.01798649f, 0.08438702f, 
    -0.03834424f, -0.03689759f, 0.02453085f, 0.12761091f, 0.03954733f, 0.10332165f, -0.01240428f, 0.12009025f, 
    0.09274029f, -0.12213794f, 0.03320763f, -0.08319002f, -0.00625750f, -0.04630106f, 0.02181810f, 0.07032011f, 
    0.03803025f, -0.06778025f, -0.06823099f, 0.09798262f, -0.11541161f, 0.11261357f, 0.01309847f, 0.10928673f, 
    -0.00534100f, 0.01576076f, 0.16149643f, 0.08106089f, 0.01192981f, 0.06421820f, 0.13294059f, -0.12450592f, 
    -0.14786546f, -0.13753209f, -0.00980360f, -0.12049384f, 0.10322471f, 0.00623331f, 0.05339974f, 0.04574313f, 
    0.02897703f, 0.08597570f, 0.01770245f, -0.08869161f, 0.09421456f, -0.16687980f, -0.04758698f, -0.04296551f, 
    -0.05508354f, 0.05248411f, 0.01927501f, 0.12743509f, -0.02638563f, 0.06191454f, 0.15704833f, 0.03638704f, 
    0.25715324f, 0.08958701f, 0.04496487f, 0.05246161f, 0.06660074f, 0.11831015f, 0.04759520f, 0.02356705f, 
    -0.02569551f, 0.01040438f, 0.02895633f, 0.04549567f, -0.07391775f, 0.03282021f, 0.11955370f, -0.20508525f, 
    0.01302667f, 0.07789513f, 0.12162919f, -0.03506636f, 0.04112251f, 0.06999159f, -0.06538057f, 0.12202945f, 
    -0.08532862f, -0.08242999f, -0.08773401f, -0.02028559f, 0.04040410f, -0.07258085f, 0.07229674f, 0.00166127f, 
    0.05210585f, 0.03138617f, 0.14596564f, -0.05339297f, -0.45382255f, 0.00841887f, 0.19133954f, 0.03767157f, 
    0.06396950f, -0.03371537f, 0.01954663f, 0.02281513f, 0.04755703f, 0.04410772f, 0.07360494f, 0.05730135f, 
    0.03509483f, 0.05665917f, -0.02647298f, 0.00185926f, -0.03750033f, -0.00478547f, -0.01548024f, 0.01839790f, 
    -0.02602952f, -0.00750589f, 0.01916929f, 0.01900469f, -0.01559314f, -0.00647547f, 0.03869000f, -0.05097784f, 
    -0.05321271f, -0.05261961f, -0.01247878f, 0.01839864f, -0.01499048f, 0.03672806f, -0.05492088f, -0.02848860f, 
    0.01861039f, -0.03915894f, -0.02222975f, -0.01734659f, -0.01234897f, 0.03045993f, -0.04204506f, 0.03986405f, 
    -0.04705741f, 0.00927128f, -0.01069826f, 0.01549985f, 0.00997570f, -0.00227978f, 0.02256195f, -0.03722149f, 
    -0.05051696f, 0.02556180f, 0.03084536f, -0.02225637f, -0.00960442f, -0.00986826f, 0.03107996f, 0.02235771f, 
    -0.03694130f, 0.03356567f, -0.02764358f, -0.01237161f, 0.00854214f, 0.00854860f, 0.04362893f, -0.04899717f, 
    0.03532468f, -0.04362944f, 0.01234638f, -0.05697164f, 0.02609924f, 0.01761498f, -0.00371080f, -0.02000624f, 
    -0.01250393f, 0.03703800f, -0.02276391f, -0.04036491f, -0.01354156f, 0.03022605f, -0.00632160f, -0.04246545f, 
    0.03004083f, 0.01522338f, 0.01234848f, 0.01203369f, -0.02986619f, 0.01748408f, 0.00946692f, 0.02244773f, 
    -0.03735798f, 0.04092872f, 0.02404706f, 0.02034593f, 0.04629887f, -0.02966067f, 0.04590530f, -0.03965960f, 
    -0.00330369f, 0.04897717f, -0.03247418f, -0.00512581f, -0.01760994f, -0.02564223f, 0.00112779f, -0.05594814f, 
    0.04740153f, -0.00595316f, -0.03578485f, -0.05017769f, 0.02629247f, 0.03518391f, 0.00875738f, -0.00188327f, 
    0.01291802f, -0.02504878f, 0.00670181f, 0.03014636f, 0.02850396f, -0.04487189f, -0.02468441f, -0.05585383f, 
    0.01981159f, -0.03640171f, 0.00312806f, 0.03374097f, -0.00675610f, -0.03919399f, 0.03020987f, 0.02107996f, 
    -0.02994525f, -0.04834558f, 0.04087413f, 0.00755360f, -0.01286349f, -0.00165721f, -0.00267930f, 0.01812490f, 
    0.00874572f, 0.03190424f, -0.03280582f, -0.05069904f, 0.03371377f, 0.03570129f, -0.04887960f, -0.03028334f, 
    -0.00124922f, -0.00468976f, 0.03356947f, 0.04188643f, 0.04490872f, -0.01729482f, -0.00160973f, 0.00094995f, 
    -0.01934295f, 0.04480933f, -0.00078488f, -0.05010846f, -0.04947666f, -0.04257469f, 0.03421082f, 0.00394464f, 
    -0.01049976f, 0.02669914f, 0.04122134f, -0.02180028f, 0.01036111f, 0.04329490f, 0.01757452f, -0.01136369f, 
    -0.00724136f, 0.00349812f, 0.02520784f, -0.00356440f, 0.00439509f, 0.02374060f, -0.02915652f, -0.04942464f, 
    -0.03144167f, 0.01864455f, -0.04440938f, 0.01297234f, 0.00871549f, -0.01718256f, 0.01830694f, -0.02217989f, 
    0.00585945f, -0.01504804f, 0.03049793f, -0.03693918f, 0.00040793f, -0.01298828f, 0.01104817f, 0.00881313f, 
    -0.00730263f, 0.02059696f, 0.01665810f, 0.02988156f, -0.03650475f, -0.00477360f, -0.03971934f, 0.04193411f, 
    0.02054741f, -0.04102542f, -0.03171548f, -0.05334983f, -0.01727294f, -0.05276506f, -0.03427875f, 0.01029634f, 
    -0.04842201f, -0.01755414f, 0.03210529f, -0.05347168f, -0.03879724f, 0.04246290f, 0.02678975f, -0.01030760f, 
    0.00186763f, 0.01727563f, -0.05658477f, 0.01335068f, 0.03132037f, -0.04199851f, -0.03122729f, -0.03015019f, 
    0.04848248f, 0.00476753f, -0.02770892f, 0.00040557f, 0.03157293f, 0.02904242f, -0.03240185f, -0.02794854f, 
    0.03233238f, -0.01468244f, 0.01060420f, -0.02833128f, -0.04540639f, -0.02636166f, 0.01245771f, -0.02774174f, 
    -0.04771334f, -0.06068436f, -0.01648231f, 0.03287743f, 0.03206513f, 0.01390096f, 0.03550854f, 0.01862531f, 
    -0.00707338f, -0.05274198f, -0.03562960f, 0.00241380f, 0.01302674f, -0.04087514f, -0.05371217f, -0.02264523f, 
    0.02252859f, -0.04850500f, 0.02369710f, -0.01553451f, -0.02009542f, 0.01162596f, -0.00702638f, -0.01360461f, 
    0.02706875f, -0.00093940f, 0.01012107f, 0.02399553f, 0.02531754f, -0.02272185f, 0.00951515f, -0.04690257f, 
    -0.03661041f, 0.02014853f, 0.04937263f, 0.01483349f, 0.04498255f, -0.03265116f, -0.00212489f, 0.00871419f, 
    0.04701447f, -0.03739643f, 0.02062813f, -0.02954014f, -0.05325802f, 0.02193799f, -0.01309379f, 0.01958678f, 
    -0.01136124f, -0.00021476f, 0.03822932f, -0.02325921f, -0.05718217f, -0.01577643f, -0.04505651f, 0.01759050f, 
    0.01103718f, -0.03682986f, 0.02494735f, 0.03509947f, 0.00282395f, -0.02708215f, -0.03233714f, -0.03636574f, 
    -0.03460908f, 0.00815567f, -0.03092542f, 0.02559972f, -0.03700841f, 0.00791148f, 0.02815609f, 0.04607425f, 
    -0.03963014f, -0.01881524f, -0.04839898f, -0.04707130f, -0.01099910f, 0.02588563f, -0.02906628f, -0.03629818f, 
    0.04752525f, -0.04687728f, 0.03596042f, -0.03082996f, -0.05641550f, -0.05492641f, -0.02425758f, -0.01241077f, 
    0.01553630f, -0.03615423f, -0.00411999f, -0.00706731f, -0.00070691f, 0.03953296f, 0.04229223f, -0.03484991f, 
    -0.01298888f, 0.04416623f, 0.00263394f, 0.03603137f, -0.00998855f, -0.05284104f, 0.02017759f, 0.01115070f, 
    -0.01929852f, -0.03274358f, 0.01486886f, -0.05593768f, 0.03730641f, -0.03288062f, -0.01054563f, -0.00502432f, 
    -0.00294143f, -0.05118164f, -0.04854765f, 0.03107166f, 0.00920878f, 0.00315069f, 0.01480256f, -0.04024886f, 
    0.02447846f, 0.00231715f, 0.01089889f, -0.01734009f, -0.02248202f, -0.03326263f, -0.03390181f, 0.04364083f, 
    -0.05010590f, -0.02974196f, -0.04061631f, 0.03741271f, 0.04111067f, 0.03393974f, -0.02022237f, 0.02040551f, 
    0.00450620f, 0.01706788f, -0.02327624f, -0.04917027f, -0.03633463f, -0.05362066f, 0.03068397f, -0.04428117f, 
    0.01683844f, 0.02747504f, -0.02185747f, -0.00477809f, -0.00662164f, -0.02026523f, 0.01619910f, 0.02437380f, 
    0.45291498f, -0.00458389f, -0.06921010f, 0.13293430f, 0.04155528f, 0.02091866f, 0.07852567f, 0.07784518f, 
    -0.00936349f, -0.06751546f, 0.00041420f, 0.05528544f, 0.19703932f, -0.15248312f, -0.17667224f, 0.15645814f, 
    -0.02614220f, 0.00141945f, -0.08102536f, 0.05737596f, -0.00714388f, 0.05359382f, -0.00724936f, 0.17325887f, 
    0.13479412f, 0.09025091f, 0.01135155f, -0.11577131f, -0.08468242f, -0.02544521f, -0.03455976f, -0.04492078f, 
    0.06154626f, -0.08640149f, -0.10696494f, -0.07344067f, 0.33145988f, 0.14158864f, -0.01093634f, 0.12503946f, 
    0.05794131f, 0.02780818f, 0.00074148f, -0.14434260f, -0.01360568f, 0.05521877f, 0.04034816f, 0.07074358f, 
    0.21872041f, 0.00702811f, 0.22732611f, -0.02494068f, 0.07890295f, 0.11943352f, 0.03750012f, 0.09210448f, 
    -0.03109393f, 0.04580256f, 0.08098669f, -0.00530611f, 0.01523354f, -0.00099158f, -0.05596080f, -0.19766499f, 
    0.14841457f, 0.04841839f, 0.04789338f, 0.07492404f, 0.10497720f, 0.13605919f, -0.05134410f, 0.03399802f, 
    0.07462881f, 0.05755780f, 0.12288067f, -0.06787214f, -0.09488696f, 0.01822678f, -0.09665865f, 0.14026570f, 
    -0.04801195f, -0.00064438f, -0.04732227f, 0.01753430f, 0.25723565f, 0.12948146f, -0.06113950f, -0.08063913f, 
    0.06332375f, -0.09212556f, -0.01069967f, 0.00200023f, 0.00985852f, -0.05416564f, -0.22252150f, 0.00152569f, 
    -0.05548459f, -0.06038041f, -0.06683525f, -0.04272838f, 0.04257355f, -0.20902640f, 0.04522529f, 0.06147354f, 
    0.05369058f, -0.00878700f, 0.11607954f, -0.01900315f, -0.19645748f, 0.06430692f, 0.03218363f, -0.02603406f, 
    0.02945357f, -0.08943495f, -0.03263551f, 0.13115996f, -0.06369143f, 0.06391848f, 0.05996550f, 0.02696046f, 
    0.12465240f, 0.10648175f, 0.09839768f, 0.10072505f, 0.03673020f, -0.00047181f, -0.01468737f, -0.15664780f, 
    0.10332124f, -0.03675542f, 0.10123549f, 0.02805326f, 0.11853763f, 0.05060073f, -0.01573832f, -0.12072849f, 
    -0.03675918f, -0.02553444f, -0.08822061f, -0.02391690f, 0.00473010f, 0.09334275f, -0.03274517f, -0.09465854f, 
    0.26818466f, -0.12740079f, -0.15891156f, 0.07594518f, 0.02412598f, 0.07393866f, -0.18483473f, -0.02896817f, 
    0.05046479f, 0.01593486f, 0.10349575f, -0.13041899f, -0.13701782f, 0.11071954f, -0.00506006f, 0.16481483f, 
    0.00294520f, -0.03199560f, 0.08132883f, 0.06907695f, -0.05723823f, -0.13253155f, -0.05637137f, 0.08203238f, 
    0.01580318f, -0.19957241f, 0.06745084f, -0.01351558f, -0.01950400f, 0.04170395f, 0.17593482f, 0.27121150f, 
    0.10422289f, 0.07614807f, -0.06155591f, 0.01116353f, -0.10322747f, -0.26033592f, -0.05829439f, -0.16383782f, 
    0.02320283f, 0.13897814f, 0.12693019f, -0.00427603f, 0.04808484f, 0.08402447f, -0.02087890f, -0.01864782f, 
    -0.16507655f, 0.09274670f, -0.03943014f, 0.03852759f, -0.10352153f, 0.04881367f, 0.11914913f, 0.00315180f, 
    0.06105941f, -0.00632346f, 0.01794880f, 0.04738845f, -0.13229157f, -0.10953704f, -0.13183630f, 0.06426550f, 
    0.02209112f, 0.05730352f, -0.00831428f, -0.01507244f, 0.02462438f, -0.01820808f, 0.09033251f, -0.01073093f, 
    0.22258691f, -0.05128332f, -0.05093715f, 0.04659046f, -0.02594224f, 0.00264997f, -0.10807978f, -0.02226141f, 
    0.00663749f, 0.18692909f, 0.10761453f, 0.07193206f, 0.07847939f, 0.12778880f, -0.12010044f, -0.12421454f, 
    -0.02282667f, -0.09209967f, -0.02863764f, -0.03923699f, -0.06403922f, -0.01963985f, -0.01323560f, -0.12414347f, 
    0.06541265f, -0.09666010f, 0.06295490f, -0.07100363f, -0.00703246f, 0.14349595f, -0.02121007f, 0.12091995f, 
    -0.09113277f, 0.07597223f, 0.07138618f, 0.15643902f, 0.06874008f, 0.00444162f, 0.01896668f, 0.13811301f, 
    -0.02902080f, -0.04884613f, -0.05336825f, 0.00013374f, -0.09768712f, -0.01105106f, -0.11496290f, -0.00551119f, 
    0.18462318f, 0.03226968f, -0.09118291f, 0.05444773f, 0.08872290f, -0.05054978f, -0.13066655f, 0.06506233f, 
    0.15851128f, 0.08128374f, 0.13721217f, -0.06579190f, 0.05708083f, 0.03959344f, 0.02684811f, -0.01532531f, 
    -0.04188318f, -0.05133388f, 0.04474120f, 0.00562578f, -0.07014571f, -0.08185381f, -0.02341882f, -0.13515136f, 
    -0.16682313f, 0.06962064f, -0.07621634f, -0.01243422f, -0.07809222f, 0.07652916f, -0.15814219f, 0.02011735f, 
    -0.18595809f, -0.01575773f, -0.15046796f, -0.10366321f, 0.17068298f, -0.04224131f, 0.13665295f, 0.03357416f, 
    -0.05471301f, 0.00503677f, 0.03907563f, 0.07260641f, -0.00460639f, -0.09718366f, 0.01727189f, -0.02412905f, 
    0.05753637f, -0.04876781f, 0.03880592f, 0.10014615f, -0.04730114f, 0.07979847f, -0.18702546f, -0.04201069f, 
    -0.12498041f, -0.01484631f, -0.07632018f, 0.01176060f, -0.13116327f, 0.10106442f, -0.02263921f, 0.02885509f, 
    -0.15009181f, -0.02790763f, -0.04006304f, 0.04476726f, -0.12073367f, 0.10234630f, -0.11570485f, -0.02008411f, 
    -0.11136746f, -0.08089383f, 0.05629121f, 0.06322538f, -0.05104059f, 0.08604393f, -0.02300745f, 0.09441815f, 
    0.06162643f, -0.06275927f, 0.10407077f, -0.03532685f, -0.19726454f, 0.07500155f, -0.24818718f, -0.12071177f, 
    -0.13407713f, -0.05090896f, 0.01082862f, -0.03210730f, -0.04789444f, -0.15751582f, 0.10670135f, 0.06945869f, 
    0.12855770f, 0.12035859f, 0.12480380f, -0.09438181f, -0.08579914f, -0.04342195f, -0.18344834f, 0.01714583f, 
    -0.07341458f, -0.03401226f, 0.13030511f, 0.09814253f, 0.36397883f, 0.05297301f, 0.08289634f, 0.01507338f, 
    -0.07057671f, 0.05652055f, 0.05392158f, 0.03011727f, 0.03610575f, -0.12185653f, -0.03268475f, 0.21483535f, 
    0.00173097f, -0.03876962f, 0.02136555f, -0.29019082f, -0.04885110f, -0.00747617f, -0.00597040f, 0.00862846f, 
    0.03945494f, -0.07138631f, -0.13047294f, 0.11217465f, 0.02875632f, 0.14388393f, 0.01377815f, -0.12968118f, 
    0.01049547f, -0.03287245f, -0.05376755f, 0.05293109f, -0.10069484f, -0.00564922f, 0.11698912f, -0.10970506f, 
    0.09977189f, -0.03733337f, -0.17494147f, -0.01118018f, 0.10248502f, -0.01678492f, 0.03778012f, -0.00024493f, 
    -0.02624216f, 0.03950154f, 0.11130498f, 0.10211989f, -0.06354976f, -0.02496071f, -0.16520435f, 0.01612135f, 
    -0.07037464f, -0.03419043f, 0.16962074f, 0.04646593f, -0.02391236f, 0.10823762f, -0.04491309f, -0.06157197f, 
    -0.26824400f, -0.17346594f, 0.00734418f, 0.15860198f, -0.01314646f, 0.02768434f, 0.00975383f, -0.01926125f, 
    0.02979338f, -0.02175147f, -0.11116019f, 0.03381513f, 0.21158236f, 0.09944769f, 0.09833686f, 0.24233459f, 
    0.04816565f, 0.11781620f, -0.06257318f, 0.10681871f, -0.14793260f, -0.04844692f, 0.11207765f, -0.00444591f, 
    -0.14286408f, -0.06370776f, 0.12846266f, 0.08505382f, 0.02539935f, -0.07459763f, 0.09433367f, 0.00568527f, 
    0.05617009f, -0.00414673f, 0.02256070f, 0.06638815f, -0.24222410f, -0.12430939f, 0.16600871f, -0.09907123f, 
    -0.05409721f, 0.06724565f, -0.06618384f, -0.04414924f, -0.00796142f, 0.01270639f, 0.13242677f, 0.12052301f, 
    -0.21353337f, 0.00144055f, -0.18857218f, -0.06070926f, 0.00263316f, 0.13767770f, -0.10322447f, -0.00876743f, 
    0.07647639f, -0.05018113f, -0.11630969f, -0.03797580f, -0.21416306f, -0.02153396f, 0.01627995f, -0.03209121f, 
    -0.05135096f, 0.06741788f, 0.04646420f, -0.09148465f, 0.15875660f, 0.09990979f, -0.02314467f, -0.02472012f, 
    -0.05597443f, -0.03241108f, -0.00424444f, 0.14052354f, 0.04064319f, -0.05900108f, 0.09014836f, 0.05773273f, 
    -0.03431781f, 0.03639087f, -0.03760318f, 0.10054876f, -0.05980717f, 0.07634114f, 0.21727389f, 0.14221318f, 
    0.13372679f, 0.04786410f, -0.11001636f, -0.02647783f, -0.04707750f, 0.05769694f, -0.01640834f, 0.17684883f, 
    -0.09514368f, 0.21881147f, -0.03247845f, 0.03701445f, 0.00837796f, -0.03872949f, 0.11997623f, 0.10835828f, 
    0.01331324f, 0.03049362f, 0.01465844f, 0.07020635f, 0.17630462f, -0.10580906f, -0.03728110f, 0.04537293f, 
    -0.01295318f, -0.02101850f, 0.05445028f, -0.01981459f, 0.06635590f, 0.15494537f, -0.01475636f, -0.03020522f, 
    -0.04490650f, 0.09248793f, -0.11990640f, -0.29302803f, -0.02754944f, -0.04453867f, -0.06899393f, -0.19499974f, 
    -0.04203177f, -0.08163501f, 0.00939078f, -0.07375125f, -0.20003858f, 0.16444448f, 0.17771524f, -0.04631310f, 
    0.06531398f, 0.01720143f, -0.00003604f, -0.01239666f, 0.15879950f, 0.17558998f, -0.02304627f, 0.08720654f, 
    -0.02882344f, -0.14475062f, 0.03501251f, -0.04864676f, -0.00173273f, -0.04102498f, -0.01213134f, -0.06141400f, 
    0.13615663f, 0.01297274f, -0.11761504f, -0.07354667f, -0.40023488f, 0.06564176f, 0.13650286f, 0.17850192f, 
    0.09383425f, 0.07250907f, -0.11071469f, 0.14965616f, -0.03494321f, 0.07067738f, -0.03865404f, -0.06544473f, 
    -0.03980417f, 0.06328967f, -0.08010818f, -0.11014536f, -0.02086306f, 0.02829678f, 0.00735536f, 0.06670021f, 
    0.11119287f, -0.11295106f, -0.15713628f, -0.03379153f, 0.22925904f, -0.11963187f, 0.04415587f, 0.22731666f, 
    0.09283887f, 0.01916130f, 0.13588805f, 0.13033719f, 0.01681538f, 0.10550753f, -0.05509632f, 0.08340450f, 
    -0.03808103f, -0.07082279f, -0.10862222f, -0.08545820f, 0.01581150f, -0.08229755f, 0.11893255f, -0.10770961f, 
    0.10328591f, -0.10951799f, -0.03750106f, 0.09592761f, -0.26538622f, 0.00625124f, 0.10952676f, 0.12105641f, 
    -0.14165564f, 0.02794821f, 0.17183235f, 0.11468604f, 0.04426221f, 0.13162872f, 0.06938373f, 0.15306355f, 
    -0.04014560f, 0.10318851f, 0.18680772f, 0.03372652f, -0.05689686f, 0.15401112f, 0.00949185f, -0.07774480f, 
    -0.03522550f, 0.00794468f, 0.03990105f, -0.00103852f, -0.16358675f, -0.14061947f, 0.08659453f, 0.10091804f, 
    0.01487511f, 0.01809178f, -0.05950363f, -0.17332788f, 0.09016728f, -0.09016563f, 0.07249938f, -0.02871769f, 
    -0.07053824f, -0.21613342f, 0.10196612f, -0.08941488f, -0.02805836f, 0.03134530f, 0.01335523f, 0.01816937f, 
    0.11727123f, 0.04811542f, 0.13409945f, 0.06682219f, -0.22379836f, -0.04466164f, -0.13342458f, -0.03243658f, 
    0.01185107f, 0.04287073f, -0.01904359f, -0.02773838f, 0.07019653f, 0.07035707f, -0.01841243f, 0.19743617f, 
    0.05258534f, -0.19393282f, -0.08373909f, 0.00927482f, -0.03278160f, 0.01256908f, 0.06832849f, 0.04596085f, 
    0.09566001f, 0.11286317f, -0.00529941f, 0.01828196f, -0.11272911f, -0.11208778f, 0.15829279f, -0.10733326f, 
    0.03805528f, 0.00004344f, 0.11408156f, -0.00576493f, 0.14857939f, 0.10103457f, 0.03697904f, 0.10978296f, 
    -0.19486648f, 0.22205091f, -0.01083017f, -0.06855818f, -0.00639522f, 0.10982066f, -0.07248303f, -0.12382577f, 
    0.02103200f, -0.03409523f, -0.07497696f, -0.12153937f, 0.28960678f, -0.08128007f, 0.19614939f, 0.13643551f, 
    0.17847042f, 0.02942565f, -0.02296966f, 0.05254850f, 0.01622913f, -0.03416381f, -0.06225348f, -0.04163150f, 
    0.14508188f, -0.07358834f, 0.01564840f, -0.02804696f, 0.07845228f, 0.04595349f, 0.08086930f, -0.00299571f, 
    0.12786992f, 0.06823296f, -0.04394919f, 0.00837373f, -0.27728817f, 0.03476973f, -0.22748394f, 0.05140359f, 
    0.09546622f, 0.05460123f, -0.02188204f, 0.17833802f, 0.01421806f, 0.09190293f, -0.04199751f, -0.05920997f, 
    0.44055346f, 0.09242332f, 0.08650021f, -0.09171403f, 0.07010873f, 0.05057758f, -0.02490753f, 0.04301716f, 
    0.05422866f, -0.02640678f, -0.03779702f, 0.00413340f, 0.00977539f, 0.18323854f, -0.18365371f, 0.01259382f, 
    0.02103739f, -0.01486339f, 0.03819848f, 0.03893272f, 0.00056214f, 0.00102384f, 0.09423267f, 0.04284414f, 
    0.12880379f, 0.15485725f, -0.00955194f, 0.06153564f, -0.11606340f, -0.12100588f, 0.04009258f, 0.04590338f, 
    -0.09149665f, -0.07205720f, -0.01911712f, 0.00319846f, 0.36749476f, 0.25683367f, -0.02000208f, 0.07572909f, 
    -0.02613014f, 0.02848885f, 0.08406341f, -0.01701756f, 0.08052835f, -0.02998533f, 0.02484947f, 0.04471168f, 
    0.01253242f, -0.17183365f, 0.32704037f, -0.25882772f, -0.04846518f, -0.01587966f, 0.00374364f, 0.08982679f, 
    -0.08242632f, 0.05233665f, -0.03578142f, 0.08302403f, 0.04474628f, 0.02804231f, 0.12202102f, 0.12169047f, 
    0.12067620f, 0.06600898f, 0.04113201f, 0.01691444f, -0.03028450f, 0.14207000f, -0.01927052f, 0.00985666f, 
    0.06898633f, 0.04647604f, 0.07098864f, 0.03205999f, 0.06140701f, -0.00625340f, -0.01894540f, -0.01212700f, 
    -0.09548514f, 0.04225063f, 0.02225266f, 0.04306984f, -0.19009241f, -0.14079112f, 0.00298016f, 0.03350099f, 
    -0.28054777f, 0.05324233f, 0.10930332f, 0.01534850f, -0.00892061f, -0.06071571f, 0.00676085f, -0.13844253f, 
    0.10869963f, 0.20985456f, 0.07950292f, -0.24439016f, 0.12849462f, -0.08062754f, 0.09807074f, -0.00029901f, 
    0.11085024f, -0.05875842f, 0.02106202f, -0.05446485f, 0.13472980f, 0.19316202f, -0.04067399f, -0.00712894f, 
    0.14996228f, -0.03659219f, -0.02173200f, 0.01998040f, 0.14585440f, 0.07407235f, -0.06618854f, 0.02037348f, 
    0.01489069f, 0.00369808f, -0.02285702f, 0.49663025f, -0.07426333f, 0.03145331f, 0.06925805f, -0.03574023f, 
    -0.00890736f, 0.10188428f, 0.14236042f, -0.04078302f, 0.17298318f, -0.03779321f, -0.08087716f, 0.15628028f, 
    0.00134216f, 0.06826325f, 0.08872316f, 0.00183090f, -0.02863530f, 0.05318098f, -0.00859191f, 0.01465041f, 
    0.05877960f, 0.15277554f, 0.19934419f, 0.09363919f, 0.04638783f, -0.04733665f, 0.02207305f, -0.01086274f, 
    0.02928909f, 0.01230215f, -0.08971909f, -0.01003481f, -0.10948510f, -0.27945355f, -0.01750993f, -0.04130203f, 
    -0.06806012f, -0.01586027f, 0.11393100f, -0.02019240f, -0.04771188f, 0.03673218f, 0.06371383f, 0.04884420f, 
    0.18247944f, 0.17958842f, 0.10458024f, -0.24231003f, 0.13357803f, 0.01429749f, 0.08485085f, 0.01884914f, 
    0.09937213f, 0.03238893f, -0.11203121f, 0.06452385f, -0.18805817f, 0.25029120f, 0.08906920f, -0.13338844f, 
    0.17191495f, 0.06286716f, 0.03635156f, 0.06596730f, 0.08422125f, 0.04017689f, 0.01605036f, 0.01110572f, 
    -0.07864504f, -0.23909689f, -0.19931528f, 0.10060880f, -0.05971105f, -0.08748738f, -0.00221856f, 0.02581768f, 
    0.09770843f, -0.05279212f, -0.07322684f, 0.02650795f, -0.43408620f, 0.25121388f, 0.10019628f, 0.12471792f, 
    0.05143443f, 0.12142569f, 0.14012717f, 0.00066443f, 0.11293442f, -0.08114389f, -0.02306655f, -0.13245317f, 
    -0.03520266f, -0.05340784f, 0.01846280f, 0.12635750f, -0.04682161f, 0.05909416f, 0.00554969f, -0.08276652f, 
    0.06203793f, 0.10644358f, -0.00481986f, 0.03423136f, 0.07408439f, 0.17480038f, 0.02185098f, 0.03217067f, 
    0.06998473f, -0.08034388f, -0.00257043f, 0.07283084f, 0.02175055f, 0.05338878f, 0.00753395f, -0.07242571f, 
    0.20521693f, 0.19868067f, 0.09941556f, -0.12424723f, -0.07112348f, 0.08500674f, -0.01629627f, 0.07837197f, 
    0.03025175f, -0.04302035f, 0.04029037f, -0.00071362f, -0.33255872f, -0.21477106f, 0.05178847f, -0.15502535f, 
    -0.01066603f, -0.02410889f, 0.00411188f, 0.01498466f, 0.00066461f, 0.06044306f, -0.01315367f, 0.09163182f, 
    -0.00706567f, -0.07451422f, 0.08079047f, -0.00503509f, -0.05250967f, -0.03214730f, -0.08130600f, -0.07920445f, 
    0.14228013f, 0.04752634f, -0.07261505f, -0.02275432f, -0.14464512f, -0.19030017f, -0.16232882f, 0.08820529f, 
    -0.14521739f, -0.01961426f, 0.04592219f, 0.01259689f, 0.00932472f, 0.04340745f, -0.08743154f, -0.01837178f, 
    0.09155428f, -0.20439208f, -0.01887092f, -0.00370123f, -0.24161890f, -0.03866909f, 0.05215660f, 0.08389947f, 
    -0.08183189f, 0.08084510f, 0.01535430f, 0.08735518f, -0.20863299f, -0.05319869f, -0.11396105f, -0.10978498f, 
    0.05613380f, 0.00609329f, -0.00763883f, 0.02497675f, 0.02194430f, 0.00053267f, 0.03919113f, -0.07475121f, 
    0.04258038f, -0.23511340f, -0.05158595f, -0.13842368f, -0.15112856f, -0.01110559f, 0.05981355f, 0.02349775f, 
    -0.02321494f, 0.06046556f, 0.01431994f, 0.06267165f, -0.09187159f, -0.10328877f, -0.03391620f, 0.05413678f, 
    -0.06054325f, 0.11440212f, -0.15215771f, 0.05232886f, 0.05351945f, 0.06826052f, 0.09454161f, -0.02957554f, 
    0.07981718f, 0.11705082f, 0.01437945f, 0.00522460f, 0.01723811f, 0.16073981f, 0.00137527f, 0.01092861f, 
    0.03114037f, -0.04265890f, 0.08587138f, -0.04464642f, 0.02210881f, 0.19494101f, 0.09193397f, -0.09669171f, 
    -0.00147775f, -0.06312609f, 0.03603398f, -0.00319819f, 0.01220161f, -0.08824313f, -0.05174280f, -0.11298874f, 
    0.23818737f, -0.02192297f, 0.20260702f, 0.08483085f, 0.00546061f, 0.02364786f, 0.04943348f, 0.01142462f, 
    0.06323047f, 0.05576696f, -0.02737615f, 0.03831932f, -0.06747686f, 0.21210068f, 0.00685763f, 0.04176717f, 
    -0.03321793f, 0.13067621f, -0.04429534f, -0.11627277f, 0.04208750f, -0.04368432f, -0.04103778f, 0.14237380f, 
    0.02491475f, 0.01217849f, 0.04346565f, -0.00309750f, 0.01086970f, -0.00797587f, 0.01689347f, 0.01983524f, 
    -0.05284514f, 0.00656428f, -0.00837212f, -0.01741108f, 0.03845803f, 0.03378792f, -0.01599666f, -0.02147881f, 
    -0.03203638f, 0.03632701f, 0.02277314f, 0.02990274f, -0.02411341f, -0.01433265f, -0.04583071f, 0.01434630f, 
    -0.02650174f, -0.05590328f, 0.01390620f, -0.01387220f, 0.03481956f, 0.00728786f, 0.02877734f, 0.01442521f, 
    0.00175506f, 0.01665476f, -0.01295722f, -0.02250734f, -0.01282891f, -0.00720194f, -0.05104123f, -0.01419623f, 
    -0.03751311f, 0.04559391f, -0.03531765f, 0.01899325f, -0.01308135f, -0.05252454f, -0.02475756f, -0.01115821f, 
    -0.02788417f, -0.00937040f, 0.00101751f, 0.00230767f, -0.02201323f, 0.04166475f, -0.04088533f, -0.02422483f, 
    0.02028657f, -0.00498914f, -0.01816847f, 0.03877090f, 0.00461852f, -0.01310170f, 0.02082913f, -0.04980341f, 
    -0.05178289f, -0.02332239f, -0.05102221f, 0.01667417f, -0.03302501f, -0.01206762f, -0.00658429f, 0.00034997f, 
    -0.03553540f, -0.03581109f, -0.01303544f, 0.01345301f, -0.03883792f, 0.00992002f, 0.01352201f, -0.00693517f, 
    0.02233659f, -0.03730457f, -0.00765410f, -0.04776117f, -0.02933767f, -0.04924131f, 0.01247758f, -0.00400863f, 
    -0.05351219f, 0.00236774f, -0.03583487f, 0.00343016f, -0.02112909f, -0.01310986f, -0.02496042f, 0.03700524f, 
    -0.02265381f, -0.00346806f, -0.01934990f, 0.00477288f, -0.02454439f, 0.02582836f, 0.01770798f, -0.01508222f, 
    -0.03445127f, 0.03396137f, 0.02230832f, 0.00477404f, -0.03929802f, -0.00567076f, -0.01425699f, 0.04125686f, 
    0.01419879f, -0.00610599f, -0.04111603f, -0.01854328f, -0.04410703f, 0.03710682f, -0.00497967f, 0.00774064f, 
    0.00611643f, -0.05014556f, -0.00389453f, -0.02368537f, 0.04952680f, 0.03703480f, -0.01362691f, -0.04871837f, 
    0.02669472f, 0.00610405f, 0.00033688f, -0.03655346f, -0.04060184f, 0.02678376f, -0.05248243f, -0.01774031f, 
    -0.02291070f, 0.02565587f, -0.03718400f, -0.01418836f, 0.02610498f, 0.01699168f, 0.01830390f, -0.00462559f, 
    0.03289377f, -0.03477336f, -0.03430631f, -0.00852637f, 0.03255075f, -0.05558232f, -0.00242711f, 0.03312223f, 
    -0.01903337f, 0.00342197f, 0.00808745f, -0.00875841f, -0.01549014f, 0.02319711f, -0.00173739f, -0.01284714f, 
    -0.03863611f, 0.01633473f, -0.03098013f, -0.01337683f, 0.03697208f, -0.04242047f, 0.00480928f, -0.03770750f, 
    -0.01757808f, -0.01364435f, -0.00044849f, 0.01477390f, 0.02078918f, -0.05462347f, 0.04123690f, 0.02278129f, 
    0.02259198f, 0.03583142f, -0.03995231f, -0.04894519f, -0.02681664f, -0.05140031f, -0.05310547f, -0.03149711f, 
    -0.00769157f, -0.03550173f, -0.04551829f, 0.02024707f, 0.00634013f, 0.00238318f, 0.02856876f, -0.03499528f, 
    0.00405434f, 0.00163414f, 0.02157935f, -0.03037895f, -0.03212260f, -0.00918785f, 0.03274693f, -0.01234499f, 
    0.00270069f, 0.00941184f, -0.03632114f, 0.02032355f, -0.03641554f, -0.04390935f, 0.00007583f, 0.03255104f, 
    -0.00472867f, 0.01005168f, 0.04339573f, 0.01954093f, 0.02119109f, -0.02123014f, 0.04215819f, 0.03943068f, 
    -0.00482084f, -0.04727145f, -0.04890538f, 0.02298190f, -0.03389053f, -0.00595606f, -0.02029042f, 0.02203546f, 
    0.03706284f, -0.02232543f, 0.00593407f, 0.01887699f, 0.02470130f, -0.02831327f, 0.02645643f, -0.03804351f, 
    0.01083803f, -0.03103912f, -0.01073862f, -0.02948299f, -0.01470265f, -0.05151588f, 0.00994337f, -0.04384709f, 
    0.01096681f, -0.04896537f, 0.00591614f, -0.05575922f, -0.03957814f, 0.01912490f, -0.01407662f, -0.02486047f, 
    -0.04310281f, -0.02797947f, -0.01810448f, -0.01585266f, 0.01674669f, 0.00950008f, 0.00176462f, 0.01391269f, 
    -0.04536213f, -0.00710513f, -0.02713431f, -0.05004385f, -0.04365259f, 0.01312019f, 0.01426805f, -0.03267156f, 
    -0.04114745f, -0.01834358f, 0.00116431f, -0.03231014f, -0.03071986f, -0.05215405f, -0.04324925f, 0.03459737f, 
    -0.02783714f, 0.01590365f, -0.03745402f, -0.05219033f, -0.01890722f, -0.01983676f, -0.04602561f, 0.03846605f, 
    0.01302165f, 0.02551929f, -0.02524963f, 0.02925090f, 0.00270220f, -0.04593327f, 0.02038474f, -0.04957358f, 
    -0.03709992f, 0.00463915f, -0.04305627f, -0.00216918f, -0.01808310f, -0.03248858f, -0.04814944f, -0.05543182f, 
    0.03532218f, -0.01902624f, -0.04487208f, -0.04203032f, -0.04059211f, 0.01948579f, 0.00805435f, 0.04097929f, 
    -0.04704589f, 0.02337753f, 0.02415272f, -0.02526901f, -0.01207323f, 0.00245164f, 0.02705595f, 0.00259623f, 
    -0.05075832f, -0.03085219f, -0.02123283f, -0.05491872f, -0.01466013f, 0.02948626f, -0.00139431f, -0.03795666f, 
    0.01205417f, 0.03265639f, 0.02571404f, 0.00374764f, 0.02275517f, -0.04318882f, 0.03473805f, -0.03752799f, 
    -0.04001240f, 0.00712508f, -0.00054415f, 0.00323513f, -0.05333401f, 0.03806632f, 0.03773218f, -0.05459685f, 
    -0.03694723f, -0.00883458f, 0.00618855f, -0.05561020f, -0.05035054f, 0.04166075f, 0.01145946f, -0.01743850f, 
    0.01199048f, -0.04078769f, 0.00421249f, 0.02785692f, -0.01999766f, -0.02053020f, -0.04787193f, 0.00174203f, 
    0.02068492f, 0.01015631f, -0.00111776f, -0.02485159f, -0.03611533f, -0.02016553f, 0.00353666f, -0.02810915f, 
    -0.04699961f, 0.03295558f, 0.02604969f, -0.01135246f, -0.02661317f, -0.01220405f, 0.01754949f, -0.04507065f, 
    0.04288260f, 0.04454570f, 0.00525376f, 0.00521784f, -0.03027708f, 0.00084480f, 0.04322848f, 0.02943292f, 
    0.00473939f, 0.00592060f, 0.04112042f, -0.00834673f, -0.04173121f, 0.04316631f, 0.04054209f, 0.04097182f, 
    0.00119842f, 0.03265706f, -0.03494514f, -0.04815990f, -0.05147364f, -0.05454817f, -0.04662491f, -0.02142902f, 
    -0.05310742f, 0.02719543f, -0.00704694f, 0.03910486f, -0.01474235f, -0.03073724f, -0.00585105f, 0.02754894f, 
    -0.00052532f, -0.04162103f, -0.04011269f, -0.05185581f, 0.03462131f, -0.06053182f, 0.00084590f, -0.01622284f, 
    -0.04963158f, -0.00132179f, 0.02738915f, 0.00225566f, -0.01889983f, -0.01971727f, -0.03373145f, 0.01315303f, 
    -0.01874426f, 0.02703731f, 0.01537901f, 0.02066155f, 0.01752140f, 0.02552664f, 0.00755644f, -0.02269636f, 
    -0.00939895f, -0.00012057f, 0.00613669f, 0.03602236f, 0.01159451f, -0.03849488f, -0.02492707f, 0.03367000f, 
    -0.02499634f, -0.05155820f, 0.02110991f, 0.03973468f, -0.02410043f, -0.03895291f, 0.02198703f, -0.02521944f, 
    0.03022566f, -0.03951238f, -0.01440762f, -0.05817224f, 0.02053035f, -0.02012907f, 0.02818900f, -0.00744281f, 
    0.03584914f, -0.03023412f, 0.02391504f, 0.01422301f, -0.02290817f, 0.00678874f, -0.03795566f, -0.05874498f, 
    0.01506098f, 0.03720862f, 0.03897780f, -0.00341606f, -0.00416552f, -0.01307109f, 0.03124774f, -0.04453749f, 
    -0.01996359f, 0.03100920f, -0.02364747f, -0.03943627f, 0.01352477f, 0.00575971f, -0.03687351f, -0.04118283f, 
    0.01673958f, 0.02337050f, -0.00138043f, 0.01917302f, 0.04457747f, 0.00558132f, 0.02312004f, -0.05884704f, 
    0.00016543f, 0.02702626f, -0.03999259f, -0.03922773f, -0.02910707f, -0.04720395f, 0.02186006f, 0.01731128f, 
    0.03741946f, -0.04054260f, -0.02091232f, 0.00750232f, -0.03031550f, -0.02346228f, -0.00540339f, -0.06063382f, 
    0.01173660f, -0.05324297f, -0.01236570f, -0.05949444f, -0.04036620f, -0.00963305f, -0.02549482f, -0.04900956f, 
    -0.00993200f, -0.04146390f, -0.00957425f, -0.04565017f, 0.00911853f, -0.00702102f, -0.02158408f, 0.01523260f, 
    -0.00442264f, 0.02089840f, -0.02796211f, -0.01365839f, 0.03782628f, 0.00361957f, -0.03128150f, -0.03146027f, 
    0.02205250f, -0.05261843f, -0.00373869f, -0.00836695f, 0.01512700f, 0.03917450f, 0.00804311f, -0.00657687f, 
    -0.02267428f, -0.05312454f, -0.03492163f, -0.00284447f, 0.03916886f, -0.05831930f, -0.02933103f, 0.03764167f, 
    0.03307772f, 0.00499917f, -0.02805413f, 0.04561871f, -0.03150418f, 0.01745182f, 0.01752361f, -0.00328217f, 
    -0.01709726f, 0.01257460f, 0.00321400f, 0.03458958f, -0.04913289f, -0.05202817f, -0.02975163f, -0.04944900f, 
    0.03030482f, 0.01409778f, -0.03670604f, -0.01550283f, -0.02320267f, 0.00708733f, -0.04641749f, -0.02768349f, 
    0.01417886f, -0.03325216f, -0.04592012f, -0.01480793f, 0.04730385f, 0.03714408f, 0.03218935f, -0.03818277f, 
    0.03563085f, 0.04566940f, 0.04847054f, 0.00961911f, -0.03478596f, 0.03981007f, 0.01874201f, -0.05054150f, 
    0.04130146f, -0.04528154f, 0.04119408f, 0.04322935f, -0.03366219f, -0.02386212f, -0.01453964f, -0.02475483f, 
    0.02371146f, 0.03478863f, 0.03375397f, -0.00755698f, -0.05290011f, -0.04418315f, 0.00439507f, -0.03443360f, 
    -0.04213142f, 0.00929136f, -0.04501231f, -0.04007569f, -0.03922386f, 0.02529728f, 0.03706123f, 0.04200967f, 
    -0.05134054f, 0.00466558f, 0.04655629f, -0.02173225f, -0.01834903f, -0.04863211f, 0.01994639f, -0.00696541f, 
    -0.04292653f, 0.04278607f, -0.04427811f, -0.01293534f, 0.02399875f, -0.01644000f, 0.03156588f, 0.03789555f, 
    -0.05463549f, 0.03024040f, 0.00799385f, -0.03782059f, -0.03191733f, -0.02880828f, -0.05320742f, -0.02803848f, 
    0.00709396f, -0.00739462f, -0.01209276f, 0.02824676f, -0.03692615f, -0.05530338f, -0.05418380f, 0.02258787f, 
    -0.04944608f, 0.00806376f, -0.01267564f, 0.01818007f, -0.03726134f, 0.00588168f, -0.00109906f, 0.01690474f, 
    0.03902905f, 0.01739705f, -0.04260476f, -0.01846641f, -0.04280852f, -0.04977484f, 0.00783768f, -0.02678720f, 
    -0.02980109f, 0.00958911f, -0.05172697f, -0.02116202f, -0.00280784f, 0.00837098f, 0.00349054f, 0.00395956f, 
    -0.04464032f, -0.04087538f, 0.00279355f, -0.02380989f, -0.02062243f, -0.01646980f, 0.04607815f, 0.03573081f, 
    0.02864430f, 0.00235507f, -0.02331720f, 0.03605334f, 0.00455965f, -0.01738205f, -0.00629935f, 0.00668002f, 
    0.00881867f, -0.03637548f, -0.03832347f, 0.01312394f, -0.04935166f, 0.02864834f, 0.03261381f, -0.01077818f, 
    -0.00639692f, 0.04018674f, 0.01729092f, 0.01002087f, 0.03880561f, -0.00813997f, -0.03764407f, -0.04695787f, 
    0.00523142f, 0.02096637f, 0.01545905f, -0.05266921f, 0.04018538f, -0.00092903f, 0.02572419f, 0.00119832f, 
    -0.01321313f, 0.03148843f, -0.00323055f, -0.02083949f, -0.00999951f, 0.02068075f, 0.03993738f, -0.00175195f, 
    0.00353825f, 0.02826818f, -0.00399359f, -0.03568222f, -0.02304246f, -0.00892051f, -0.01238359f, 0.03565101f, 
    -0.02375015f, -0.02313175f, 0.01438734f, 0.03182090f, -0.01607860f, -0.01401533f, -0.02598538f, 0.01674618f, 
    0.00599476f, -0.04425144f, 0.03910886f, -0.01637946f, -0.00352924f, 0.04148765f, 0.00464036f, 0.03854272f, 
    0.03028627f, -0.04903648f, -0.03060047f, -0.01128971f, 0.03044615f, -0.01410574f, -0.03525469f, 0.02780318f, 
    -0.02180948f, -0.00877053f, -0.03389759f, -0.05547386f, -0.04112898f, -0.04001525f, -0.04911849f, -0.03620358f, 
    -0.01599181f, -0.02787379f, -0.02384735f, -0.02017941f, -0.01641122f, 0.02078733f, -0.01687152f, 0.02167228f, 
    -0.05130125f, 0.03963502f, -0.03881792f, -0.02490295f, -0.02235713f, 0.01763405f, 0.04845799f, 0.00580805f, 
    0.03364684f, -0.02215614f, 0.00083082f, -0.00834538f, -0.04306052f, -0.00507369f, -0.04105971f, -0.03896280f, 
    0.06863061f, -0.03869759f, -0.10742537f, -0.03180378f, 0.06054222f, 0.08555706f, 0.01070902f, 0.04788267f, 
    0.09922474f, 0.03072452f, -0.04341711f, 0.08138774f, 0.07171948f, -0.03645334f, 0.12683193f, -0.10471190f, 
    0.10763703f, 0.03573624f, -0.04523739f, -0.07036740f, 0.02579047f, 0.08131059f, 0.06556736f, 0.03659222f, 
    0.07604607f, -0.18535613f, -0.14408082f, -0.07585740f, 0.13723278f, 0.12468265f, 0.06114014f, -0.03744416f, 
    0.05715144f, 0.04586265f, 0.06327797f, -0.12337969f, -0.06945306f, 0.01023883f, -0.17125361f, 0.15056439f, 
    0.00829944f, -0.02285482f, 0.18015741f, -0.01593359f, 0.01127775f, 0.08271360f, -0.07155634f, -0.01851478f, 
    -0.06613791f, -0.26229659f, 0.03955553f, 0.00015069f, 0.04539856f, -0.01806492f, 0.12077610f, -0.11782690f, 
    0.02091292f, -0.01874500f, 0.10500199f, 0.04023452f, -0.03388882f, 0.12353384f, 0.14121547f, -0.06594593f, 
    -0.02565492f, 0.11757497f, 0.08651772f, 0.07147680f, -0.06762650f, -0.00769118f, 0.02241001f, 0.02133664f, 
    -0.04212398f, 0.12793554f, 0.17981799f, 0.02910160f, 0.05156947f, 0.04307371f, 0.09599716f, 0.10233625f, 
    -0.03260937f, -0.03236907f, -0.03635734f, -0.00913063f, 0.49801826f, 0.33888599f, -0.06565897f, -0.28053525f, 
    0.03063365f, -0.00814254f, -0.08553010f, 0.05886381f, -0.02029582f, -0.00459491f, -0.06723796f, 0.10222715f, 
    0.17547388f, -0.19226444f, -0.15982752f, 0.09995969f, 0.08244167f, -0.11916897f, -0.05782218f, -0.05330520f, 
    0.03846959f, -0.03038918f, 0.04592089f, -0.02117177f, -0.08540505f, -0.16133115f, -0.07761429f, 0.13312690f, 
    0.03512073f, 0.01372878f, 0.00313881f, -0.06689287f, -0.12325533f, 0.19711804f, 0.02918515f, 0.12002803f, 
    -0.35638398f, 0.08846539f, -0.06627622f, 0.19692187f, 0.07265236f, -0.05297166f, 0.07684956f, -0.00561601f, 
    0.13887389f, -0.02020789f, 0.07318648f, 0.02847345f, -0.00667702f, 0.20932357f, -0.04004712f, -0.15675132f, 
    0.05636106f, -0.03757155f, -0.16404653f, -0.00601829f, -0.05437808f, 0.02926504f, -0.03385558f, 0.12597136f, 
    0.20358987f, -0.17101187f, -0.31976321f, 0.13912690f, 0.08316477f, -0.01514752f, -0.00982769f, 0.07920173f, 
    -0.01213426f, 0.03671109f, 0.17128591f, -0.03944588f, -0.07397535f, 0.14752463f, 0.02617486f, 0.18288435f, 
    -0.00587587f, -0.10849617f, 0.04499522f, -0.05903198f, 0.07576863f, 0.06114113f, -0.11226460f, -0.05009173f, 
    0.53698444f, -0.07453315f, -0.08042522f, -0.00835199f, 0.05532996f, -0.01316185f, 0.05766343f, -0.02363599f, 
    -0.07405125f, 0.08567200f, -0.04783930f, 0.03343351f, -0.06980038f, -0.13308500f, -0.14962566f, 0.00292323f, 
    0.06535193f, 0.15032305f, -0.10085753f, -0.05582950f, 0.10584337f, 0.03784490f, 0.05525759f, 0.06120702f, 
    -0.02631546f, 0.20129341f, 0.17112306f, -0.17622216f, 0.01193827f, 0.06993454f, -0.10772099f, 0.03588824f, 
    0.06585054f, -0.02669861f, 0.01182305f, 0.01958734f, -0.28372040f, -0.18068711f, -0.06628892f, 0.23326930f, 
    -0.04534227f, 0.19267824f, -0.02689192f, 0.06417676f, -0.00540753f, 0.09350128f, -0.05070680f, -0.08044932f, 
    0.15756442f, -0.08144809f, 0.07799520f, -0.07501030f, 0.08809008f, 0.09386182f, 0.01039453f, 0.17361616f, 
    0.14222978f, 0.01538860f, -0.10312516f, 0.11172122f, -0.13018928f, -0.07770406f, -0.04983701f, 0.00937444f, 
    -0.09415230f, 0.03568446f, 0.21372539f, -0.11454538f, -0.05260289f, 0.09337370f, 0.02663168f, 0.19190292f, 
    0.21374378f, -0.10661457f, 0.00582398f, -0.12272867f, -0.01279685f, 0.03602740f, 0.02070832f, -0.03015879f, 
    0.04119174f, 0.09296287f, -0.04154320f, -0.05666982f, -0.01901770f, 0.39953804f, 0.26676160f, 0.06025495f, 
    -0.09067496f, 0.05722737f, 0.03694985f, 0.09684099f, 0.05966467f, 0.08870943f, -0.02057615f, 0.21583243f, 
    0.39787388f, 0.12550110f, 0.05414138f, -0.00698679f, -0.00875564f, 0.06520665f, 0.06439744f, 0.10490020f, 
    0.04963098f, 0.02182486f, 0.17552277f, -0.02537695f, -0.10691915f, 0.01852795f, 0.14525005f, -0.02703744f, 
    0.06762637f, -0.03953565f, -0.01137239f, -0.03829019f, -0.02085770f, -0.09507359f, 0.12271500f, -0.01033524f, 
    -0.24519245f, -0.01586559f, 0.29168966f, -0.31225398f, 0.20547178f, 0.04803751f, 0.11740710f, -0.09715347f, 
    0.00925339f, 0.18522292f, 0.04578346f, 0.13636543f, 0.05018841f, 0.19539417f, 0.17682096f, -0.03560612f, 
    0.03208941f, 0.02687352f, 0.01008885f, 0.03995256f, 0.16253318f, -0.00508043f, 0.10526752f, 0.13534956f, 
    -0.07123616f, -0.19192405f, 0.03333435f, -0.12491605f, 0.05119835f, 0.04010051f, 0.13054009f, 0.03806717f, 
    0.20994242f, 0.08241185f, 0.00702232f, 0.03905991f, 0.14201231f, -0.17476535f, 0.13433018f, -0.09907373f, 
    -0.07829579f, 0.05089173f, 0.00317510f, 0.16206767f, 0.10951605f, 0.04373972f, 0.01078114f, 0.08984230f, 
    -0.02904968f, 0.17993957f, 0.12079669f, -0.07562006f, 0.01946549f, 0.06488033f, 0.05691353f, -0.20440739f, 
    -0.03861323f, -0.04992367f, -0.11873888f, -0.03074627f, -0.33346444f, -0.17134407f, 0.02967442f, 0.02345394f, 
    -0.02175700f, 0.02472728f, 0.03297166f, -0.02807745f, -0.04220775f, 0.00647275f, 0.07671524f, 0.10818232f, 
    -0.10426117f, -0.05603489f, -0.05696131f, 0.08848756f, 0.16846642f, 0.00535833f, 0.06210189f, -0.00971626f, 
    0.11152825f, 0.03972068f, 0.07279922f, 0.06052520f, 0.05405555f, 0.00781623f, 0.05342459f, 0.06429350f, 
    -0.02156317f, -0.11273327f, 0.17172021f, 0.15582247f, 0.03971616f, -0.03143818f, -0.04547668f, -0.16395126f, 
    -0.03619247f, 0.00804892f, 0.01794487f, -0.05325589f, -0.00848917f, -0.02150944f, -0.05414217f, 0.01511993f, 
    -0.03321543f, -0.03518695f, 0.02323391f, 0.03229794f, -0.05484250f, -0.05791413f, 0.00012836f, 0.01624124f, 
    -0.04038701f, -0.01639461f, 0.03061254f, -0.03264638f, -0.01250328f, 0.04280808f, 0.01579953f, 0.04195717f, 
    -0.00861473f, -0.05983888f, 0.00926848f, 0.04470839f, -0.00157288f, -0.01919577f, 0.01434527f, 0.00524145f, 
    -0.00216420f, 0.00733329f, -0.02225258f, 0.01142702f, -0.02420243f, -0.04398331f, 0.01365035f, -0.03933213f, 
    -0.03405850f, -0.03775714f, -0.00415395f, -0.04730575f, -0.05642231f, -0.03388100f, -0.04761980f, -0.04405132f, 
    -0.00940496f, -0.05336928f, 0.03975528f, 0.03819106f, -0.02162951f, 0.01905850f, 0.04438464f, -0.04756669f, 
    0.05614962f, -0.02597903f, 0.04052768f, -0.00232380f, -0.02651160f, -0.01676764f, 0.01207950f, -0.04704758f, 
    -0.00448839f, 0.01943727f, 0.02202256f, -0.05415113f, 0.00575198f, 0.03606139f, 0.01461720f, 0.01100007f, 
    -0.04011986f, 0.01406636f, 0.01826203f, -0.01350331f, -0.03974305f, 0.03342332f, 0.03748398f, 0.00826748f, 
    0.02660391f, -0.03610304f, -0.02885503f, -0.04314934f, 0.05119130f, 0.02504767f, 0.03874729f, 0.00208000f, 
    0.01936622f, -0.02561181f, 0.01940988f, -0.05482739f, -0.05448579f, -0.01995232f, -0.04703199f, -0.02676782f, 
    -0.00508037f, -0.01435701f, -0.00384515f, 0.03268901f, 0.02783321f, -0.03116530f, -0.02976617f, -0.04368021f, 
    -0.02561671f, 0.00884226f, -0.04667066f, -0.04050468f, 0.03461191f, -0.00928310f, -0.04696531f, -0.02194731f, 
    -0.03760196f, 0.04072716f, 0.00514061f, -0.01540466f, -0.04087186f, 0.02557711f, -0.04430960f, -0.05559812f, 
    0.03158730f, 0.02829360f, 0.01837425f, 0.02843426f, -0.04083114f, -0.00855874f, -0.04971411f, -0.00038153f, 
    -0.03416441f, 0.00784282f, -0.04391034f, -0.04677140f, 0.01661873f, 0.01130882f, -0.02698505f, 0.03146772f, 
    -0.04019465f, -0.01065483f, -0.03423936f, -0.04696798f, -0.02022415f, -0.03894518f, -0.03128782f, -0.03762316f, 
    0.04389615f, -0.01814016f, -0.03071467f, -0.01624350f, 0.00410557f, -0.02114872f, 0.02758540f, 0.02632174f, 
    0.02422651f, -0.05224593f, -0.04816762f, -0.04638834f, 0.00297485f, -0.04850375f, 0.04036211f, -0.05355538f, 
    -0.01523960f, -0.04139166f, -0.03692053f, 0.02049858f, -0.00761252f, 0.03940907f, -0.01143209f, -0.06100117f, 
    0.02211791f, 0.02660661f, 0.01394211f, -0.05413641f, 0.02992974f, -0.00299570f, -0.03372458f, -0.00141251f, 
    -0.01130028f, 0.01988177f, -0.01992659f, -0.02338705f, -0.04714201f, -0.01692585f, -0.02663536f, -0.05459762f, 
    0.02751322f, 0.03138937f, -0.00728431f, 0.02068720f, -0.04750175f, 0.02437089f, 0.03884602f, 0.00183911f, 
    0.00125244f, 0.03673990f, -0.04929413f, -0.04533742f, 0.00647312f, -0.01285205f, -0.05503283f, 0.00508541f, 
    -0.00270604f, 0.00217773f, 0.01618906f, -0.02259877f, -0.05938205f, -0.01302829f, 0.02673895f, -0.06213289f, 
    -0.03959456f, 0.02638596f, -0.05175499f, 0.00843461f, -0.01979004f, 0.03706797f, -0.03943615f, 0.04211773f, 
    0.02865836f, 0.03919275f, -0.02095017f, 0.03599272f, 0.02461657f, -0.00638774f, 0.01996861f, 0.03039193f, 
    -0.02755335f, 0.01170945f, 0.02481704f, -0.01916323f, -0.00150676f, 0.01932657f, -0.04993363f, 0.02831596f, 
    -0.00372339f, 0.02522971f, -0.03320928f, -0.03157118f, -0.03974086f, -0.01586565f, 0.02404011f, 0.02463728f, 
    -0.02906660f, -0.00743731f, -0.03473301f, 0.01305354f, -0.00315037f, 0.03685214f, 0.01246909f, 0.04518982f, 
    -0.01620939f, -0.05165029f, -0.05123507f, -0.02520863f, 0.01919079f, 0.00704786f, -0.02037593f, -0.04418709f, 
    -0.04619873f, 0.04398285f, 0.00348973f, 0.01108140f, 0.01408031f, 0.01641691f, 0.01745102f, -0.04443678f, 
    -0.05087067f, 0.01809190f, -0.01486979f, -0.01606452f, -0.04488060f, -0.00140507f, 0.01385705f, 0.03588908f, 
    -0.03302410f, 0.01014607f, -0.04831832f, -0.00584486f, -0.05238608f, 0.04025166f, -0.01847302f, -0.02558820f, 
    -0.03581944f, -0.02658739f, -0.03957498f, 0.01629695f, -0.03376619f, -0.01187070f, -0.02798782f, -0.00451349f, 
    0.01654867f, 0.03891467f, -0.05032014f, -0.02346210f, 0.00732461f, 0.03606685f, -0.05321172f, -0.00210994f, 
    -0.04070833f, -0.00873415f, -0.03973454f, -0.04463600f, 0.01875399f, 0.02364992f, -0.03466089f, -0.01082163f, 
    -0.05434214f, -0.01090022f, 0.00788605f, 0.00249044f, 0.03968408f, 0.00631661f, -0.03615659f, -0.00638489f, 
    0.03522593f, 0.00566229f, 0.03861123f, 0.03781290f, 0.04777393f, -0.00963579f, 0.04187207f, 0.00894445f, 
    -0.03768086f, -0.00231829f, -0.04690016f, 0.00787199f, -0.00589093f, -0.00132043f, -0.03976473f, -0.02652097f, 
    -0.04382649f, 0.02410887f, 0.02005019f, 0.01683217f, -0.00807808f, -0.02804785f, 0.02780612f, -0.02170928f, 
    -0.00069835f, 0.03273492f, -0.00193214f, -0.00886038f, -0.04220715f, -0.02817644f, -0.03203242f, 0.03972790f, 
    0.02022937f, 0.03701132f, -0.02338154f, -0.05763397f, -0.00030038f, -0.02816732f, -0.02910001f, -0.04559582f, 
    0.01009951f, 0.03137662f, -0.05099895f, -0.03086346f, -0.05083902f, -0.01293170f, -0.04428533f, -0.00552022f, 
    0.03204058f, 0.00264931f, -0.00147233f, -0.03022373f, 0.00284594f, -0.02844479f, 0.03389413f, 0.00461558f, 
    -0.05418153f, 0.01383269f, 0.00986793f, 0.02969785f, -0.05099212f, -0.02985428f, -0.05814783f, -0.02852720f, 
    0.01934148f, -0.01038274f, -0.01623683f, 0.02746163f, -0.01509249f, 0.02350592f, 0.00591512f, -0.05576527f, 
    -0.20802630f, 0.03000211f, -0.14118567f, -0.23683806f, -0.02732292f, -0.00044766f, -0.10484084f, 0.03856208f, 
    0.08147663f, -0.03240501f, -0.07906893f, 0.13586757f, -0.13796312f, 0.19350387f, -0.10753252f, -0.12668189f, 
    0.09310272f, 0.07272161f, 0.03778017f, 0.10602230f, -0.04207043f, 0.02415666f, 0.14391156f, -0.10037638f, 
    0.19744271f, 0.11900713f, 0.02395080f, 0.02209180f, 0.11589435f, -0.04333990f, -0.02934224f, 0.05669205f, 
    0.02219827f, 0.04181360f, 0.17200035f, 0.07999618f, -0.33023742f, -0.06637800f, -0.14402658f, -0.07578759f, 
    -0.00587609f, 0.07036304f, 0.12352375f, -0.04688660f, -0.01123863f, -0.00246207f, -0.01644276f, -0.03782625f, 
    0.24030437f, -0.22570536f, -0.08072699f, 0.08256007f, -0.08377565f, -0.02816975f, 0.02181254f, 0.06458361f, 
    -0.04553186f, 0.00939126f, -0.03587590f, 0.00753151f, 0.28122431f, 0.02164139f, 0.01005567f, 0.22380389f, 
    -0.03638864f, 0.06628959f, -0.06391930f, 0.13601536f, -0.08080769f, -0.03407460f, 0.08013944f, 0.04589057f, 
    0.09440961f, -0.00710583f, -0.04467929f, 0.06496049f, 0.03640042f, -0.01547058f, 0.09609764f, 0.08356253f, 
    0.04717226f, -0.12605603f, -0.03996656f, 0.05661368f, -0.08600681f, -0.13263744f, 0.33325714f, 0.10261010f, 
    -0.12697628f, 0.12846862f, 0.01487990f, 0.04150388f, -0.05492188f, 0.10597393f, 0.16172870f, 0.05082572f, 
    -0.27639803f, 0.13269323f, -0.11768201f, -0.08854063f, -0.08761849f, 0.09612974f, 0.03492258f, 0.03733519f, 
    0.08907879f, 0.03408843f, -0.01789411f, 0.00025676f, 0.06470989f, 0.08026259f, -0.01441677f, -0.12038878f, 
    -0.02642473f, 0.08568262f, 0.10233349f, 0.06770135f, 0.16862516f, 0.11035895f, -0.05018024f, -0.06249973f, 
    -0.26130691f, -0.11845674f, 0.04238109f, 0.09875011f, 0.08422466f, -0.04379538f, 0.09729420f, 0.07633108f, 
    -0.00223588f, 0.01524504f, -0.12431145f, 0.06005127f, -0.13917017f, -0.04211601f, 0.23072115f, 0.19790436f, 
    0.07755199f, 0.12739740f, -0.05070914f, -0.00531886f, -0.00816720f, 0.03316864f, -0.02931621f, 0.06210424f, 
    -0.21706368f, 0.25152555f, 0.00723519f, -0.01045592f, 0.00639861f, -0.04837445f, 0.05876144f, 0.13647284f, 
    -0.00539382f, -0.00209690f, -0.02061884f, 0.03017064f, 0.18392617f, -0.19840632f, -0.05395059f, -0.10060769f, 
    0.06598257f, -0.03968886f, -0.07632042f, -0.01458900f, 0.04067501f, 0.13379781f, 0.05624840f, 0.01478667f, 
    -0.14404787f, -0.09732796f, -0.21188794f, -0.20826626f, -0.04009607f, -0.03376828f, -0.09336090f, -0.12193266f, 
    -0.05700548f, 0.02681629f, 0.02104017f, 0.02843997f, -0.29610336f, 0.37052482f, 0.17153968f, -0.18518451f, 
    0.03572578f, -0.07484870f, 0.06222950f, 0.01562994f, 0.07548095f, 0.14216194f, 0.00004588f, 0.05621725f, 
    0.17991897f, -0.08885428f, 0.09579980f, 0.19586873f, -0.04012162f, -0.07181533f, -0.06176871f, -0.01881559f, 
    0.11521820f, -0.04329338f, -0.03677378f, -0.05461730f, -0.32712677f, 0.18801859f, 0.22961709f, 0.05069561f, 
    -0.04420099f, -0.09523981f, -0.05022473f, 0.05580197f, 0.01429991f, 0.08741888f, -0.01483752f, 0.00663401f, 
    0.08637225f, 0.09162860f, -0.05738209f, 0.08107238f, -0.01399546f, -0.00225135f, 0.05922077f, 0.12117725f, 
    0.04180633f, 0.02215719f, -0.09702838f, -0.01083323f, 0.04208916f, -0.10452966f, 0.18385532f, 0.15807749f, 
    0.11515007f, 0.04842712f, 0.15256470f, 0.00797017f, -0.01969684f, 0.06458355f, 0.07159941f, 0.04624107f, 
    -0.07275513f, -0.02778426f, -0.14604427f, -0.10435916f, 0.01224036f, -0.02177617f, 0.04174580f, -0.10650031f, 
    0.07933364f, -0.12594923f, -0.00694766f, 0.16270573f, -0.07038068f, -0.14926639f, 0.09314884f, 0.12733772f, 
    -0.09146041f, -0.06108871f, 0.04620612f, 0.10616375f, 0.11581510f, 0.06880412f, 0.14448112f, 0.03747720f, 
    -0.24034359f, 0.08624922f, 0.12227646f, 0.13335651f, -0.01011484f, 0.06933302f, 0.06873804f, -0.01040963f, 
    -0.02680882f, -0.09493309f, -0.06769126f, 0.02457783f, 0.04298728f, -0.09378619f, -0.02858007f, 0.09047162f, 
    0.02606769f, -0.04876534f, -0.06527220f, 0.00087522f, 0.08896819f, -0.04391125f, 0.03154640f, 0.06911074f, 
    0.27239183f, -0.17166178f, 0.05922575f, 0.05201732f, -0.14199720f, 0.00112741f, -0.00247759f, 0.10858466f, 
    0.02336514f, 0.00069849f, 0.17523071f, 0.09288920f, -0.14360930f, -0.02028974f, -0.08583063f, 0.09904351f, 
    0.04006173f, 0.03632975f, 0.02530254f, 0.03313574f, -0.04542316f, 0.04029548f, 0.02121234f, 0.06501891f, 
    0.16755445f, -0.29487395f, -0.13152577f, -0.03447959f, 0.01023275f, 0.01999015f, 0.02106317f, 0.14591633f, 
    -0.09267963f, 0.02442910f, -0.12044229f, -0.03541129f, -0.11287086f, -0.14646111f, 0.18556568f, 0.05366689f, 
    0.04622635f, 0.03298964f, 0.16515672f, -0.08233679f, 0.07410071f, 0.05794385f, 0.06980256f, 0.16151938f, 
    -0.17596635f, 0.05772830f, -0.00248143f, -0.03507062f, 0.06648941f, 0.04889577f, -0.05104640f, -0.01352513f, 
    0.01966922f, 0.04224611f, -0.02316333f, -0.06835903f, 0.36243013f, -0.03319927f, 0.13790627f, 0.15055825f, 
    0.02440704f, 0.04302165f, 0.03503202f, 0.04841524f, 0.07144520f, -0.01370522f, -0.04787138f, -0.07559680f, 
    0.11403704f, 0.09016311f, 0.00339430f, -0.12910531f, 0.07226504f, 0.07742675f, 0.08776093f, 0.05108349f, 
    0.10203611f, 0.10489452f, -0.00258073f, -0.01565431f, -0.37088916f, 0.12707908f, -0.09975606f, 0.05874302f, 
    -0.01567611f, 0.00097867f, -0.08460898f, 0.16553079f, 0.05707083f, 0.04520893f, -0.01670161f, -0.15084875f, 
    -0.00681879f, 0.02566451f, 0.00534893f, -0.02365979f, 0.02243367f, -0.03430924f, 0.03236491f, 0.03386785f, 
    -0.04270268f, 0.00146573f, -0.03193460f, -0.05287002f, 0.03235565f, -0.00845470f, -0.00492303f, 0.03914054f, 
    0.00315997f, -0.02581158f, -0.05032021f, -0.00077540f, -0.04879975f, 0.00888467f, -0.04074246f, 0.04349057f, 
    -0.02275890f, -0.01607211f, -0.03985931f, -0.02271950f, -0.03252917f, 0.02755722f, -0.01689896f, -0.01565095f, 
    0.01560681f, -0.04845012f, -0.05136669f, -0.05090316f, -0.00649221f, -0.04490718f, 0.01249529f, -0.04694622f, 
    0.01089134f, 0.03730370f, -0.04713925f, -0.03075127f, 0.02586153f, -0.00114835f, -0.00378983f, -0.00729292f, 
    -0.05370258f, 0.03606642f, 0.03249704f, -0.03730202f, 0.02175073f, -0.05212810f, -0.04701816f, -0.04876101f, 
    0.02161596f, -0.01960477f, -0.03073364f, -0.05185581f, 0.00650375f, -0.02460711f, 0.03510857f, 0.03652290f, 
    0.03112465f, 0.03895706f, -0.02983031f, 0.01738228f, -0.00975952f, 0.00030660f, 0.00232126f, -0.02123916f, 
    -0.00980549f, -0.02534530f, 0.02353463f, -0.00550360f, 0.04498992f, -0.02178615f, -0.02462295f, -0.02651426f, 
    0.04494809f, -0.01858674f, 0.01082461f, 0.04206715f, 0.03296207f, -0.01009376f, -0.03202737f, -0.03120639f, 
    -0.01740644f, -0.02497566f, -0.04135938f, -0.03501369f, 0.04584076f, 0.02095288f, -0.01985644f, 0.01614672f, 
    0.01070128f, -0.01204189f, -0.05238251f, -0.04037433f, 0.04029733f, -0.02977726f, -0.03309073f, -0.02776739f, 
    -0.01563335f, -0.02171984f, 0.00480948f, -0.02349998f, -0.02930447f, 0.02145222f, -0.00965857f, -0.05558044f, 
    0.03575334f, -0.01006192f, -0.03117145f, 0.04690409f, 0.00042149f, -0.00142675f, 0.03047489f, -0.04493669f, 
    0.00595166f, 0.03223645f, -0.01196527f, -0.01556187f, 0.00685329f, 0.03638304f, 0.02179493f, 0.02857595f, 
    -0.04562720f, 0.01899100f, 0.00810786f, -0.01411708f, -0.00955379f, -0.04681456f, -0.03567262f, -0.05443972f, 
    -0.03672165f, -0.02298671f, -0.05292180f, 0.02559202f, 0.02815586f, -0.04618767f, 0.02200513f, 0.00708498f, 
    0.02020943f, -0.05213880f, -0.00974925f, -0.01521670f, 0.03468150f, -0.01163067f, 0.01199464f, -0.03529490f, 
    0.00550099f, -0.01992055f, 0.04296016f, 0.04322699f, 0.03247461f, 0.03583585f, 0.03656730f, -0.04495525f, 
    -0.02484246f, -0.04610824f, -0.00246158f, -0.02174268f, -0.03022127f, 0.02947646f, -0.04670198f, 0.02486110f, 
    0.02248765f, 0.00371342f, -0.00712938f, 0.02465542f, 0.01964017f, 0.02556930f, -0.00420856f, -0.03118833f, 
    0.03034324f, -0.01346311f, -0.01642757f, -0.03693377f, 0.00163629f, 0.00427101f, -0.02013461f, 0.00708821f, 
    0.03229487f, -0.04195644f, -0.01146271f, -0.01543695f, 0.03531561f, 0.00818010f, 0.01970129f, -0.01083301f, 
    -0.00890351f, -0.01885735f, -0.02585433f, -0.00376656f, -0.04766692f, -0.00539660f, -0.04342705f, 0.00310839f, 
    -0.05159539f, -0.03203284f, -0.00518294f, -0.04013062f, 0.02086347f, -0.02015685f, 0.02919961f, -0.00644962f, 
    -0.03252916f, -0.01645983f, 0.04170362f, -0.00405105f, -0.04324882f, -0.01437549f, -0.03215636f, -0.05205020f, 
    -0.03272121f, 0.00717636f, -0.01484078f, -0.01038334f, 0.04201897f, -0.04781249f, -0.02585703f, 0.00970308f, 
    -0.05022458f, -0.04148683f, 0.01960206f, 0.00204911f, 0.03278806f, 0.02913477f, -0.05085068f, 0.01792206f, 
    -0.05523554f, -0.03048800f, 0.01315576f, 0.01513654f, -0.04331347f, -0.04093553f, -0.05137403f, -0.01004471f, 
    -0.05044436f, 0.04448523f, -0.01361885f, -0.02639912f, -0.02068620f, -0.01974750f, -0.01948386f, -0.01341207f, 
    0.01286971f, 0.03940096f, -0.02929332f, -0.00836848f, -0.02995117f, 0.03288495f, -0.04902523f, -0.03859778f, 
    -0.00915813f, 0.00356104f, 0.03031133f, -0.04978593f, -0.04527540f, 0.03739306f, 0.03317419f, -0.05453916f, 
    0.03679574f, -0.05510733f, -0.03641190f, 0.00630109f, -0.04416714f, -0.01581888f, -0.00238633f, -0.00300883f, 
    -0.02654327f, -0.01805039f, -0.03047580f, -0.01104797f, -0.04825822f, -0.02322885f, 0.03951677f, -0.02241395f, 
    0.04282808f, 0.00144678f, -0.00228791f, 0.02527882f, 0.02131516f, 0.01810966f, -0.04452766f, -0.01131744f, 
    -0.00770426f, 0.01213889f, -0.04738319f, -0.01611484f, 0.01109286f, -0.02734518f, -0.03406551f, -0.00365106f, 
    -0.03324695f, -0.00467263f, -0.02334369f, -0.00787060f, 0.03728126f, -0.03673326f, 0.00054227f, -0.05486066f, 
    0.03193049f, 0.03641925f, -0.02518154f, 0.02743950f, 0.00877138f, -0.04256583f, 0.00336837f, -0.04962693f, 
    -0.05564489f, 0.01296619f, 0.02971571f, 0.01320394f, -0.00205502f, -0.01978217f, 0.01117162f, 0.00356490f, 
    -0.00501466f, 0.03396165f, 0.00875127f, 0.01388986f, -0.02870947f, -0.00362667f, -0.02504421f, -0.00644800f, 
    0.00574617f, -0.02834498f, 0.01502755f, 0.03843653f, -0.01513533f, 0.01490166f, 0.03303605f, -0.05474223f, 
    -0.00008483f, 0.04540925f, 0.01713436f, -0.04410784f, -0.04560716f, -0.05594893f, -0.01704421f, 0.00664761f, 
    -0.00045860f, -0.02053231f, 0.04057880f, -0.02962916f, -0.04982827f, -0.05464435f, -0.03187731f, -0.01153271f, 
    0.01385742f, 0.03921947f, 0.01005673f, 0.03950182f, 0.03712400f, -0.05185796f, 0.04358429f, 0.01150216f, 
    0.02916863f, 0.04258087f, 0.00534561f, -0.03436687f, -0.04844557f, -0.01780487f, 0.00113261f, 0.02734442f, 
    -0.04585852f, -0.04835740f, -0.03551467f, 0.04245678f, -0.02732639f, -0.03832237f, -0.01735028f, 0.03068703f, 
    -0.04879761f, -0.04360175f, 0.04889493f, -0.01649196f, 0.00931725f, 0.03485012f, -0.00878515f, -0.02268453f, 
    0.39846122f, -0.00733325f, 0.13223626f, 0.24143204f, -0.13605933f, 0.00595695f, 0.05873032f, -0.02619041f, 
    -0.04983916f, -0.00253755f, 0.05399353f, -0.11363523f, 0.21998510f, -0.10067873f, -0.08587352f, 0.01314143f, 
    0.02115951f, 0.07881673f, 0.00555680f, -0.03337649f, -0.00036933f, 0.03498000f, -0.01543663f, 0.12293917f, 
    0.03299433f, 0.01270145f, -0.08766539f, 0.03599517f, -0.12343847f, -0.01919186f, -0.11451955f, -0.06512926f, 
    0.12450964f, -0.02513260f, -0.01621662f, -0.01312744f, 0.11130646f, 0.17488517f, 0.01652970f, -0.04576455f, 
    0.02063324f, 0.00034410f, -0.07287695f, -0.01163690f, 0.01350437f, 0.03058077f, -0.02781042f, 0.14033215f, 
    0.36896130f, 0.11053158f, 0.03604926f, 0.08167828f, 0.17499103f, -0.09213809f, 0.02524053f, -0.09370438f, 
    -0.04426052f, 0.09476715f, -0.05059945f, 0.06205127f, 0.10284510f, -0.08176395f, -0.08643037f, -0.14890303f, 
    0.05907254f, -0.12667085f, 0.00566730f, -0.00236542f, 0.11704399f, 0.11573824f, -0.05565163f, -0.05223576f, 
    0.17653102f, 0.18587300f, -0.11941866f, 0.00285432f, -0.08205711f, -0.09422205f, 0.05767963f, 0.03154853f, 
    -0.07623547f, 0.00136735f, -0.06786946f, 0.10125114f, 0.03394154f, -0.14151266f, -0.08765244f, -0.02560325f, 
    0.25602192f, 0.01791091f, 0.02435723f, -0.12328116f, 0.13414533f, 0.02063117f, -0.00603359f, -0.02125625f, 
    -0.03345477f, 0.00391018f, 0.05023682f, -0.04871497f, -0.06207781f, -0.04999800f, 0.14622402f, -0.00099758f, 
    0.05635933f, 0.05256157f, 0.05232534f, -0.10358949f, -0.06030440f, 0.08676487f, -0.00975423f, 0.01300512f, 
    -0.08852153f, -0.11273396f, -0.03859079f, 0.07888704f, -0.08809104f, -0.09308703f, 0.07466535f, 0.03687100f, 
    -0.07611872f, 0.20885064f, 0.01962731f, -0.22813152f, -0.13470612f, 0.03903474f, -0.10860060f, 0.06326563f, 
    0.01523723f, -0.09657775f, 0.23508713f, -0.11304308f, -0.01362093f, 0.08059917f, -0.07023580f, -0.11950250f, 
    -0.01205556f, 0.01960008f, 0.01884817f, 0.02007682f, 0.03810886f, -0.11892842f, -0.01060629f, -0.05858085f, 
    0.30393344f, 0.09271236f, -0.13010739f, -0.10953344f, -0.03192884f, 0.10036364f, -0.14678207f, -0.00491413f, 
    -0.06150755f, 0.05603768f, 0.09883746f, -0.08851989f, -0.25618786f, 0.20176722f, 0.14018781f, 0.01205266f, 
    -0.08983260f, -0.01762686f, 0.09416620f, 0.08172729f, -0.05794689f, -0.11630482f, -0.09339089f, 0.03991693f, 
    -0.03841062f, -0.03664995f, 0.07433511f, 0.13873257f, 0.08174878f, -0.03627185f, 0.11983630f, 0.15492019f, 
    -0.05724023f, 0.02701047f, -0.06484413f, -0.08864035f, -0.03547700f, -0.01388727f, -0.21493149f, 0.01624032f, 
    0.09054904f, 0.13185498f, -0.02144997f, 0.03710844f, -0.04993946f, -0.06790414f, -0.01172139f, -0.03013315f, 
    -0.06885084f, 0.29081261f, -0.09609632f, -0.03226921f, 0.06296774f, 0.05375829f, 0.08520316f, -0.00089648f, 
    0.03271607f, -0.02489036f, 0.03935576f, 0.06973460f, 0.21583506f, -0.00486929f, -0.19078396f, -0.13238579f, 
    -0.10839917f, -0.00305560f, 0.00571879f, -0.01671029f, 0.01998677f, -0.03907883f, 0.07132014f, 0.06673048f, 
    0.11170274f, -0.17829813f, -0.09169883f, -0.12464619f, 0.06129665f, -0.04495923f, -0.01529754f, -0.06948897f, 
    -0.00109451f, 0.09753631f, 0.19293477f, -0.01811311f, 0.17013526f, 0.12194792f, 0.00043457f, 0.04310771f, 
    0.04627965f, -0.01067063f, 0.05836973f, -0.06710488f, -0.12138715f, -0.02135658f, -0.04146904f, -0.05631422f, 
    0.00255360f, -0.16217282f, 0.14264670f, 0.06704177f, 0.02608165f, 0.10010085f, -0.05593638f, 0.06430947f, 
    0.01691456f, 0.15203139f, 0.04697588f, -0.10455652f, 0.24913187f, 0.07243887f, -0.13631929f, 0.12078886f, 
    0.05452275f, -0.07081131f, -0.00776173f, -0.03364031f, -0.09853615f, -0.08522660f, -0.13092998f, -0.06154556f, 
    0.16478463f, -0.09357657f, 0.01249946f, 0.02367234f, 0.18164998f, 0.04066334f, 0.04877258f, 0.13815172f, 
    0.03578521f, 0.08403742f, -0.00468846f, -0.02453130f, 0.07346777f, 0.13121636f, 0.09925970f, -0.15356287f, 
    0.06461790f, 0.10708291f, 0.11532339f, -0.00616929f, 0.06463144f, 0.08777151f, -0.11242875f, -0.10785308f, 
    0.00530596f, -0.04026723f, 0.06317794f, 0.13413085f, 0.10346916f, 0.04557182f, -0.01128752f, -0.10903621f, 
    -0.09127584f, -0.00067625f, -0.15960070f, -0.17815506f, 0.23606429f, 0.00555442f, 0.09588248f, -0.00257876f, 
    -0.00647995f, 0.03143978f, -0.04148101f, 0.02911406f, -0.02463819f, 0.07542980f, -0.06654575f, -0.04329654f, 
    0.21121497f, -0.05308562f, 0.10640786f, 0.13122210f, 0.05197443f, -0.02491397f, -0.02258996f, -0.13038972f, 
    -0.13911703f, -0.03979117f, -0.03956222f, -0.05945139f, -0.03681799f, 0.11476605f, -0.02193745f, -0.00159429f, 
    -0.00248448f, -0.06672763f, -0.07241938f, 0.00226684f, -0.07640615f, 0.02796386f, -0.05160085f, -0.07271947f, 
    -0.33311963f, -0.10066346f, -0.01194892f, -0.02544340f, 0.01904489f, -0.00033499f, 0.03778733f, 0.15676296f, 
    -0.00612184f, 0.09952050f, 0.15007357f, -0.03675456f, 0.14782068f, -0.15270296f, -0.16257691f, 0.19804564f, 
    -0.03895339f, 0.01595643f, 0.00415967f, -0.06381750f, -0.03134531f, 0.00677891f, -0.05042895f, 0.10813142f, 
    0.01841347f, 0.11888286f, -0.01055087f, 0.06401707f, -0.15614265f, -0.18582818f, -0.12459254f, -0.02543658f, 
    -0.06154828f, -0.02718440f, 0.05565027f, 0.08026125f, 0.32690564f, 0.01042381f, -0.06976157f, 0.01334838f, 
    -0.05021330f, 0.09989436f, 0.09880874f, 0.09579834f, 0.00072629f, -0.00707176f, 0.09077884f, 0.14712916f, 
    0.28502154f, -0.09257421f, 0.00736183f, 0.07389843f, -0.03165733f, -0.12796375f, -0.01032106f, 0.02143240f, 
    -0.12788594f, -0.10215933f, 0.05197611f, 0.01979255f, 0.22386469f, 0.01073571f, -0.23387679f, 0.15345119f, 
    -0.00155051f, -0.02125648f, 0.10764810f, 0.13884442f, 0.03859577f, -0.02620834f, 0.03533192f, 0.12340495f, 
    0.14603995f, -0.01536888f, 0.08439481f, 0.00984548f, -0.13899802f, -0.06161789f, 0.07986256f, 0.03217751f, 
    -0.03235719f, -0.01235132f, -0.10997788f, 0.02197614f, 0.28986609f, 0.25260291f, -0.11341874f, -0.07552541f, 
    -0.07233062f, -0.07454547f, -0.11035070f, 0.01869639f, 0.06053074f, 0.01292002f, -0.03236916f, 0.06239176f, 
    -0.20127594f, -0.12366733f, 0.44918841f, 0.01052618f, -0.09235793f, 0.11767308f, 0.10751773f, 0.00426861f, 
    -0.00473712f, 0.07221655f, -0.09973152f, 0.08199760f, 0.08288287f, -0.06541337f, 0.18944219f, 0.00705693f, 
    0.07259249f, 0.08248015f, 0.03402291f, -0.10623378f, 0.13769436f, 0.08401117f, -0.09179548f, 0.02281044f, 
    -0.03103200f, -0.10767679f, 0.24005787f, 0.11861658f, -0.08676516f, 0.04397184f, 0.02651957f, -0.00090869f, 
    0.08013304f, 0.02888548f, 0.01435828f, 0.08079945f, -0.55238682f, -0.09351499f, -0.06908429f, -0.18763594f, 
    0.13270859f, -0.00906979f, 0.01619776f, 0.04900986f, 0.00801841f, -0.12703978f, -0.05641921f, -0.12458564f, 
    -0.13467203f, -0.08323247f, 0.22308943f, -0.17332357f, -0.08656186f, -0.00505531f, 0.09153976f, -0.00206844f, 
    0.00989546f, 0.14777105f, 0.00523958f, -0.01642526f, -0.03887349f, -0.01310634f, 0.01201937f, -0.05699551f, 
    0.06611399f, -0.18320973f, -0.00835074f, 0.01230428f, 0.11774222f, -0.06820066f, 0.10514351f, 0.04324225f, 
    0.29286563f, 0.03347376f, 0.12560777f, 0.12568617f, 0.05559305f, 0.04972421f, -0.02730276f, 0.00143525f, 
    0.05276210f, 0.12806863f, 0.18085447f, 0.00637614f, 0.03901254f, -0.00944613f, 0.02103931f, 0.05007111f, 
    0.08949918f, -0.08177548f, 0.16670026f, -0.01406764f, 0.00859711f, 0.01391284f, 0.14699756f, -0.03550880f, 
    0.03923130f, 0.09982234f, 0.02166540f, 0.01972886f, -0.03104642f, 0.05275251f, 0.02405670f, -0.13604699f, 
    0.06898260f, 0.02845804f, -0.05798796f, -0.03671733f, -0.00441364f, -0.06944157f, 0.27953240f, 0.10365688f, 
    0.02897530f, 0.14451195f, 0.10830685f, 0.08505243f, 0.00702722f, -0.04232243f, 0.13375732f, 0.16536950f, 
    -0.04402317f, -0.06600606f, 0.05180139f, -0.16858438f, 0.08593876f, 0.05452112f, 0.08957285f, 0.02287401f, 
    -0.01304915f, -0.04924081f, 0.01119354f, 0.06267797f, 0.10856245f, 0.05074399f, -0.10021797f, -0.20603077f, 
    0.11901996f, 0.02442026f, 0.06919473f, 0.10901251f, 0.05684819f, 0.09750573f, -0.00108322f, 0.00155705f, 
    -0.27459374f, -0.39133278f, -0.09130410f, 0.19044690f, -0.06863928f, 0.05227440f, 0.08961205f, 0.01929890f, 
    0.11726277f, 0.09930868f, -0.08218049f, 0.09294916f, -0.18458061f, 0.28101489f, -0.07851094f, -0.06979039f, 
    0.03518761f, 0.07495409f, 0.04910972f, 0.05640086f, -0.04384805f, -0.13367043f, -0.00390132f, -0.02822134f, 
    -0.16901787f, -0.00270946f, -0.20872629f, 0.00500864f, 0.09731190f, -0.01333163f, -0.00541390f, -0.11458197f, 
    -0.01537154f, 0.07189656f, 0.17310174f, 0.01147427f, 0.13175823f, 0.31314179f, -0.07310732f, -0.07831142f, 
    0.11499040f, 0.02508945f, -0.04056037f, 0.14853758f, -0.00245108f, 0.05241205f, -0.01465077f, -0.09217431f, 
    -0.04467824f, 0.07822329f, -0.06353890f, -0.03831611f, -0.03996069f, -0.01418931f, -0.13186003f, 0.12225903f, 
    0.02388052f, -0.02725283f, 0.20634945f, 0.02539645f, -0.27719969f, -0.18564123f, 0.01227967f, -0.16799152f, 
    0.07157107f, -0.01024255f, -0.03478863f, 0.11032792f, -0.14534089f, 0.09597863f, -0.03059724f, 0.03892171f, 
    -0.10728808f, 0.10909213f, 0.06850304f, -0.05999169f, 0.07612116f, 0.02433325f, -0.05652067f, 0.00987776f, 
    0.06990688f, -0.00640662f, 0.03329292f, 0.08200767f, -0.23467630f, -0.11650456f, -0.16627190f, -0.09660622f, 
    -0.02916456f, 0.09545970f, 0.03612376f, 0.04810247f, 0.06439346f, -0.04962947f, -0.02572458f, 0.08864775f, 
    -0.14649826f, -0.02211379f, -0.22582817f, 0.01893385f, 0.02644895f, -0.00352084f, -0.06928273f, 0.04698998f, 
    -0.08551743f, -0.06865575f, -0.06801490f, -0.16550271f, -0.10320948f, -0.31196916f, -0.08570556f, -0.00073232f, 
    -0.01765797f, 0.07043266f, -0.00825256f, 0.09442994f, 0.06169090f, 0.00493964f, 0.00293493f, 0.06062688f, 
    0.05274617f, 0.08873981f, 0.09477641f, 0.09920436f, 0.08571553f, 0.04735399f, -0.11192098f, -0.03959661f, 
    0.01848095f, 0.05234041f, -0.01088646f, 0.08279878f, -0.20269398f, 0.03924884f, -0.15912236f, -0.07673700f, 
    0.03491777f, -0.01582590f, -0.02795161f, 0.15935819f, 0.00687413f, -0.06445999f, 0.04904142f, -0.05348087f, 
    -0.04317392f, -0.17515029f, 0.01362133f, 0.05500750f, -0.05758558f, 0.10859187f, 0.00259362f, 0.12469990f, 
    0.12538138f, -0.03059746f, 0.13409874f, 0.04260614f, 0.09067445f, 0.30436176f, -0.13263619f, -0.34766451f, 
    0.00292137f, -0.04899382f, -0.02532493f, -0.02919202f, -0.07155821f, -0.09198212f, 0.01274534f, 0.04553610f, 
    0.22040963f, -0.04576215f, 0.09084272f, -0.02099540f, -0.07859945f, -0.06066679f, 0.08618012f, 0.02708007f, 
    -0.03621843f, 0.10004737f, 0.06618603f, 0.13379219f, -0.02570579f, 0.02540679f, 0.10662172f, 0.09509381f, 
    -0.09140334f, 0.13274157f, 0.04214498f, -0.06957859f, -0.01426540f, 0.09831215f, -0.09909817f, 0.29362026f, 
    0.44090194f, -0.07685237f, 0.14757036f, 0.06206535f, -0.14894387f, 0.01267122f, 0.01514187f, -0.00884699f, 
    -0.01587000f, -0.11298387f, -0.04366791f, 0.09762377f, 0.14581425f, 0.04547489f, -0.03336682f, -0.13204227f, 
    0.02443934f, -0.04699561f, -0.11880614f, -0.02400403f, 0.02337003f, 0.04654902f, 0.08415873f, -0.15697429f, 
    0.14027947f, 0.19786896f, 0.10568108f, 0.10979151f, -0.01903023f, -0.04830096f, -0.06547227f, 0.02184609f, 
    0.04125401f, 0.04548116f, 0.08654415f, -0.03912376f, 0.02839107f, 0.13821973f, 0.02754079f, 0.06826598f, 
    0.00660446f, -0.02258104f, 0.09788937f, 0.05675426f, 0.02075565f, 0.13469514f, -0.12388874f, -0.02813799f, 
    0.13012670f, 0.08662032f, -0.15936175f, 0.20321676f, 0.10738955f, 0.01030242f, -0.00690426f, -0.05533879f, 
    0.02365085f, -0.01126882f, 0.00089870f, 0.01600088f, 0.11979973f, 0.01012062f, -0.17414476f, -0.01559222f, 
    0.00958609f, -0.00697887f, -0.00516534f, 0.07309819f, 0.13100599f, 0.04625526f, 0.06426574f, 0.08310355f, 
    -0.19194484f, -0.00950312f, -0.08776630f, 0.11121640f, -0.10360171f, 0.01133605f, 0.03252610f, 0.11404026f, 
    -0.01251868f, -0.03494697f, -0.05372784f, -0.02012095f, -0.27067423f, -0.10486728f, 0.06624044f, 0.02693460f, 
    0.26533422f, 0.10788687f, -0.04925244f, -0.08850764f, 0.03167330f, 0.02771288f, -0.00545906f, 0.02868298f, 
    -0.29050252f, 0.16675900f, -0.15684910f, 0.09833704f, 0.03671279f, -0.03504784f, -0.01805660f, 0.03794101f, 
    0.14162633f, 0.01419325f, 0.01505669f, -0.07158230f, -0.43904319f, 0.22922866f, 0.22486553f, 0.24410382f, 
    0.06242617f, -0.06532647f, 0.07861517f, 0.04880207f, 0.12629943f, -0.05095070f, 0.06805074f, -0.03590891f, 
    -0.11719042f, 0.21671841f, 0.02551389f, -0.15260717f, -0.03874687f, -0.05053817f, -0.11499546f, 0.04901899f, 
    0.06512453f, 0.04788737f, -0.03918960f, -0.02712869f, -0.20900576f, 0.05506444f, -0.02866837f, -0.13569067f, 
    0.01457086f, 0.00431947f, -0.05076352f, -0.02773359f, -0.08442536f, -0.03287116f, 0.03784478f, 0.01332554f, 
    0.45003679f, 0.23419854f, -0.12263023f, -0.12324125f, -0.05048573f, -0.02812501f, -0.06326614f, 0.04801061f, 
    0.02626707f, 0.09830736f, 0.16183054f, -0.06413318f, 0.04092795f, 0.13277046f, 0.04722134f, 0.02670857f, 
    -0.07359967f, -0.14639355f, 0.10674167f, 0.07894946f, 0.06061083f, -0.02610658f, -0.08784056f, 0.00473815f, 
    -0.16288860f, 0.14984809f, -0.08354712f, 0.08035176f, 0.04389945f, -0.05647627f, -0.06524429f, -0.06902259f, 
    -0.09839126f, 0.03231714f, 0.01264098f, -0.08092398f, 0.20537922f, -0.15552767f, 0.04926141f, -0.04100624f, 
    0.12326083f, 0.10628588f, 0.00267146f, -0.00283043f, 0.02195163f, 0.15342110f, -0.09209208f, 0.01868924f, 
    0.04540675f, -0.04276104f, 0.05772619f, -0.09909315f, 0.09093782f, 0.07482599f, -0.00070344f, -0.05390398f, 
    0.01012642f, 0.04698413f, 0.02456710f, -0.04437793f, 0.07581075f, -0.07710120f, -0.17987050f, -0.09973116f, 
    -0.00319157f, -0.00532475f, -0.07218163f, 0.04050760f, -0.03517330f, -0.01859961f, -0.09120960f, 0.00038092f, 
    0.15031378f, -0.05135146f, -0.05383486f, -0.12886514f, 0.03648137f, 0.01224014f, -0.07402084f, 0.05906486f, 
    0.12518652f, 0.01762898f, -0.02550733f, -0.05521739f, 0.01091352f, 0.13932481f, -0.09573791f, 0.04610378f, 
    0.10020611f, 0.01887051f, 0.04678825f, 0.02497775f, -0.11544427f, 0.10805262f, 0.01616503f, 0.00802764f, 
    -0.09040965f, 0.06212298f, -0.03742623f, 0.16820282f, -0.02038496f, -0.08311312f, 0.06272717f, -0.13418248f, 
    0.07209122f, 0.00270350f, 0.05298118f, 0.08924378f, -0.05461960f, 0.05063065f, -0.04651276f, 0.07998794f, 
    0.06890386f, -0.04792204f, 0.05191538f, 0.00752285f, 0.00171620f, 0.00982948f, 0.03815746f, 0.09004743f, 
    0.07117692f, 0.22866239f, -0.02266767f, -0.01321571f, 0.17554949f, 0.14290823f, 0.02109875f, 0.16446120f, 
    -0.01310256f, 0.01540909f, 0.03369649f, -0.04507584f, 0.04550897f, -0.00122782f, 0.12293409f, -0.07670742f, 
    0.11409152f, 0.02807292f, -0.08759506f, -0.15520900f, 0.02270687f, -0.08258528f, 0.06869345f, 0.00626678f, 
    -0.16010304f, 0.04426393f, -0.03311354f, -0.03325640f, 0.04314885f, 0.04603310f, -0.09687641f, 0.00287532f, 
    0.03162003f, 0.02410332f, 0.05405049f, -0.02334673f, 0.04848516f, -0.11014570f, -0.02375877f, -0.04407009f, 
    0.05210224f, 0.08471125f, -0.07070293f, -0.02224754f, -0.04169603f, 0.10506465f, -0.01611032f, 0.21736662f, 
    0.23135105f, 0.01669805f, -0.04965257f, 0.15916631f, 0.00462995f, -0.00411116f, -0.00404988f, 0.08694867f, 
    -0.05797189f, -0.06845265f, -0.06383859f, 0.05357275f, -0.10692264f, 0.23108779f, 0.18428640f, 0.01080250f, 
    0.06370162f, -0.03875460f, 0.01959177f, -0.03575810f, 0.14811800f, 0.00796568f, -0.03104540f, 0.11478692f, 
    -0.38967890f, 0.02513215f, -0.04521470f, 0.06526757f, 0.06489719f, 0.05374413f, -0.10558464f, -0.04505698f, 
    0.04765653f, -0.01359328f, -0.05392163f, -0.05778571f, 0.27980655f, -0.08146425f, -0.19003819f, 0.24109156f, 
    0.14388134f, 0.01056996f, -0.02587548f, 0.06073339f, -0.03302005f, -0.01052856f, -0.01128469f, -0.07632562f, 
    0.13534196f, -0.01671770f, 0.14835201f, 0.01903826f, 0.03346626f, 0.12325641f, -0.01698524f, 0.01890873f, 
    0.05825749f, -0.10026227f, -0.01226566f, 0.12171445f, 0.12221845f, -0.01008427f, -0.11413001f, 0.00276532f, 
    0.04770204f, 0.11985076f, 0.09699333f, 0.24339026f, -0.01540127f, 0.04896501f, -0.10855161f, -0.15195750f, 
    0.02767011f, 0.03920221f, -0.02669162f, 0.03660193f, -0.03028714f, -0.04616519f, -0.05409554f, -0.01750056f, 
    0.03552514f, 0.02251935f, -0.06047209f, -0.04898283f, 0.01048282f, 0.00345638f, 0.03106115f, -0.03870675f, 
    -0.02304304f, -0.00182407f, -0.00964377f, -0.04165052f, 0.02853490f, -0.01875532f, 0.00875114f, -0.01604541f, 
    -0.00547742f, -0.03284532f, -0.02185518f, -0.04872698f, -0.02002212f, 0.02697184f, -0.03438745f, 0.00753200f, 
    -0.00369361f, 0.03788654f, -0.05563157f, -0.05423441f, 0.00432285f, 0.02573713f, -0.02516345f, 0.02133754f, 
    0.01697177f, 0.02607448f, 0.02468629f, 0.00448908f, -0.01915464f, 0.01755193f, -0.01888428f, -0.03353735f, 
    0.02379218f, -0.02015416f, 0.02868904f, 0.00386319f, 0.00930873f, 0.02318438f, 0.03170796f, 0.03653330f, 
    0.03371710f, -0.01892595f, -0.02346440f, 0.02897575f, 0.03863487f, 0.02997037f, -0.05846976f, -0.01902429f, 
    0.02442645f, 0.00707042f, -0.04403143f, -0.00462338f, -0.05431243f, -0.04556044f, -0.04779458f, -0.00012530f, 
    -0.03023584f, 0.00756349f, -0.01389872f, -0.01170356f, -0.01826348f, -0.01433785f, -0.05641747f, -0.05892706f, 
    0.02031162f, -0.00858419f, -0.04171420f, 0.03794619f, -0.03073616f, -0.01381074f, 0.03007186f, 0.01709726f, 
    0.01097895f, -0.04979589f, -0.01190916f, -0.04407248f, -0.04761392f, -0.02308014f, -0.01506225f, -0.01956085f, 
    0.00136640f, -0.00502826f, -0.00191335f, -0.03559510f, -0.00836685f, 0.03414876f, -0.02053835f, -0.03704292f, 
    -0.01190591f, -0.01634020f, 0.00989848f, -0.04675761f, 0.00262201f, -0.02251394f, -0.00788569f, -0.05843410f, 
    -0.03678837f, 0.02798009f, -0.04753501f, -0.04540171f, 0.01256385f, 0.03462635f, -0.04736621f, -0.00708451f, 
    0.04502208f, -0.04210855f, 0.00378202f, 0.04393638f, 0.01505861f, -0.05583985f, 0.01930616f, -0.02714906f, 
    -0.04293802f, -0.03689573f, -0.05120334f, -0.05020386f, -0.02247666f, -0.03073398f, -0.01433876f, 0.01713172f, 
    -0.03977017f, 0.03289948f, 0.02071351f, -0.03104001f, -0.01991218f, -0.00380015f, 0.00932924f, 0.00598151f, 
    0.01652032f, -0.02395980f, 0.01379247f, -0.00118390f, -0.02612658f, -0.00864077f, -0.04515329f, 0.03661443f, 
    -0.01271795f, 0.04066360f, -0.04130698f, -0.05024142f, -0.03044751f, -0.01014180f, 0.00124520f, 0.03465271f, 
    -0.04468841f, 0.02871563f, 0.00786427f, -0.04510571f, 0.01158988f, 0.01528990f, -0.05583790f, 0.03106180f, 
    -0.01142045f, -0.00268047f, 0.03267112f, -0.02655563f, -0.00107138f, 0.03126338f, 0.00911318f, 0.00791815f, 
    0.03530088f, -0.01897493f, -0.05253334f, 0.03109253f, 0.04265827f, -0.03336353f, -0.01529171f, -0.01850643f, 
    0.01270520f, 0.03869948f, 0.03392843f, -0.04935770f, -0.04167997f, -0.04614929f, -0.03177936f, -0.01269404f, 
    0.04731677f, 0.00160813f, -0.04960148f, 0.01462718f, -0.01387041f, 0.02968042f, 0.02407567f, 0.02084653f, 
    -0.02600178f, -0.03233222f, 0.02198645f, 0.03607156f, -0.01889988f, 0.02710080f, -0.00822742f, -0.02577360f, 
    -0.02401930f, 0.01334831f, -0.02254607f, -0.05418203f, 0.00202644f, -0.02558116f, 0.02923538f, 0.02904721f, 
    0.03817039f, 0.03802911f, 0.03716322f, 0.04093194f, 0.02313208f, 0.00730085f, -0.00798199f, -0.04076320f, 
    -0.02593749f, -0.00904579f, 0.01353309f, -0.02589696f, -0.03428746f, -0.01392085f, -0.05491341f, -0.01051018f, 
    -0.04302578f, 0.01251042f, 0.02280890f, -0.01596067f, -0.03645603f, -0.05279504f, -0.05367998f, -0.03469619f, 
    0.01751480f, 0.02086851f, 0.01273971f, 0.02458487f, -0.05694952f, -0.00072941f, -0.04965217f, -0.02751264f, 
    0.00972899f, 0.02683778f, -0.05044011f, 0.01449230f, -0.01029846f, 0.04585671f, 0.03299335f, -0.01670717f, 
    -0.04615038f, 0.02436451f, 0.01315034f, -0.03288347f, -0.03693924f, 0.00162175f, -0.05401574f, -0.02318954f, 
    -0.03290989f, -0.00899127f, -0.05105040f, -0.02783241f, 0.01792543f, 0.00938354f, 0.02280585f, 0.01743518f, 
    -0.00300043f, -0.02883655f, 0.01356613f, -0.03899776f, 0.00666424f, -0.01271108f, -0.05977308f, -0.05112856f, 
    0.03806949f, -0.04592753f, 0.01000776f, -0.04661458f, -0.04586726f, -0.00381441f, -0.00674130f, -0.02438057f, 
    0.01744652f, -0.01364192f, 0.03745955f, -0.01736838f, -0.00776722f, 0.02302174f, -0.03015208f, -0.05180655f, 
    -0.02581808f, -0.04429706f, 0.04115396f, -0.05761376f, 0.00497126f, 0.01400985f, -0.01258923f, -0.03661072f, 
    0.03588123f, -0.05574593f, -0.01802486f, 0.03481843f, 0.04067205f, -0.05573175f, 0.03371221f, 0.00097697f, 
    -0.00616020f, 0.02343145f, -0.05682242f, 0.02398108f, 0.03221206f, 0.03223797f, -0.02694299f, 0.03391616f, 
    0.02401120f, 0.00554146f, 0.00633867f, 0.02938798f, -0.03579937f, 0.03368653f, -0.05378549f, 0.00708184f, 
    0.01676730f, 0.03356182f, -0.01491184f, -0.03066113f, 0.04535182f, 0.00818077f, -0.04493965f, -0.00388781f, 
    0.04422522f, 0.01543866f, -0.03636404f, -0.05853417f, 0.01230571f, -0.01390638f, 0.03051111f, -0.00753294f, 
    0.01871653f, -0.01386535f, 0.00654533f, 0.00462753f, -0.02932796f, 0.00442073f, 0.03864064f, -0.02641414f, 
    -0.04990582f, -0.03143026f, 0.00670117f, -0.03750253f, -0.04012223f, -0.03814335f, -0.05614366f, 0.03656956f, 
    -0.04624311f, -0.01583351f, -0.05016545f, 0.01126570f, 0.02854219f, 0.01055245f, 0.00501421f, -0.02197812f, 
    -0.04934683f, 0.00175972f, -0.04588814f, -0.00712035f, -0.04185756f, -0.03895481f, 0.03680237f, -0.03777445f, 
    -0.05403372f, 0.00372093f, -0.04768302f, 0.02180770f, 0.00043055f, 0.01263294f, 0.02838228f, 0.04916847f, 
    0.03784839f, -0.00457856f, -0.01425033f, 0.02982199f, -0.04896963f, -0.03435588f, -0.03471721f, -0.01204638f, 
    0.03905236f, 0.03167790f, -0.02733336f, -0.02137223f, 0.01981110f, -0.02534310f, 0.04046013f, -0.00506620f, 
    -0.01211494f, -0.03056504f, 0.02594186f, 0.01154655f, -0.03170702f, -0.01074106f, -0.01220964f, 0.04606147f, 
    0.03836416f, -0.02828351f, 0.00311866f, -0.02926069f, -0.04464619f, -0.02853944f, 0.02417938f, 0.00619623f, 
    0.04224499f, -0.03933129f, 0.02051902f, -0.04438156f, 0.03723719f, 0.00695978f, 0.04835841f, 0.01991733f, 
    -0.01894719f, -0.01747216f, 0.02206034f, -0.01216285f, -0.05343470f, 0.00457310f, 0.01986602f, -0.03269355f, 
    -0.01941337f, 0.03488117f, 0.02238582f, -0.00247087f, 0.02325826f, -0.03697596f, 0.01477706f, 0.03792722f, 
    -0.03742192f, 0.03502164f, -0.03352810f, 0.02592517f, 0.02263413f, -0.02794637f, -0.03232788f, -0.02909862f, 
    -0.03460509f, -0.05726331f, 0.03334899f, 0.01891061f, -0.04767239f, 0.02568300f, -0.05749635f, 0.04192402f, 
    -0.01901139f, -0.00704443f, 0.00357211f, -0.03848601f, -0.00902694f, -0.02683377f, -0.01160170f, 0.00230391f, 
    0.03344651f, 0.02724426f, -0.00741453f, -0.04147140f, -0.03955473f, -0.03560694f, -0.02038593f, 0.00960712f, 
    -0.01211215f, -0.03779851f, -0.04319415f, 0.03829952f, -0.05464344f, 0.03322386f, 0.01495080f, -0.03187947f, 
    -0.03844710f, -0.04470175f, 0.04165867f, 0.02224925f, 0.03452682f, 0.01474314f, -0.02880510f, -0.01770279f, 
    0.01802403f, -0.00499585f, -0.00539434f, -0.00883217f, -0.04232768f, -0.04270058f, -0.05296025f, -0.01434201f, 
    -0.02208254f, -0.03820282f, -0.00902269f, 0.03093697f, 0.00823410f, 0.01760390f, -0.01488862f, -0.00792653f, 
    -0.03534425f, 0.01328560f, -0.03052352f, 0.04137240f, -0.03162627f, -0.05498885f, -0.02883283f, -0.03474745f, 
    0.01948079f, 0.03982771f, -0.00326546f, 0.01122299f, 0.03366577f, 0.00317974f, 0.02434877f, 0.02186724f, 
    -0.04143610f, -0.02648606f, 0.03284794f, 0.01086840f, -0.04565625f, -0.02224060f, 0.03365231f, -0.04846966f, 
    -0.04848687f, -0.01536804f, 0.03394443f, -0.03681645f, 0.01680186f, -0.02344192f, 0.05051566f, -0.05572624f, 
    0.00670927f, -0.01299025f, -0.00765458f, -0.05727729f, -0.00829975f, -0.03807311f, -0.01247335f, 0.04314324f, 
    -0.05489590f, -0.01286130f, -0.01326867f, -0.01988663f, 0.01914784f, -0.02689097f, -0.00758950f, -0.01907280f, 
    -0.01400900f, -0.03297342f, 0.01304843f, -0.03850602f, 0.05305785f, -0.00743727f, 0.01860067f, 0.03149859f, 
    -0.04319049f, -0.00468725f, 0.00412414f, -0.03068529f, -0.05482966f, -0.01191996f, -0.03256387f, -0.04245702f, 
    0.02109970f, 0.03226015f, -0.03407708f, 0.02845740f, -0.03407054f, -0.02994371f, -0.04210392f, -0.02131524f, 
    -0.02851317f, 0.00765121f, 0.04498075f, -0.00856322f, -0.01314103f, 0.02821131f, 0.02912006f, -0.02830617f, 
    -0.02486707f, -0.04467084f, -0.02164917f, -0.03707809f, -0.05393013f, 0.02680072f, 0.02259690f, -0.05484665f, 
    -0.01213457f, 0.03890416f, 0.02201756f, 0.01916712f, -0.01671155f, 0.02542772f, -0.02851618f, 0.01703833f, 
    -0.01235997f, -0.01588676f, -0.01143960f, 0.03142760f, 0.00680308f, 0.02154361f, 0.04473155f, -0.05769190f, 
    0.02758957f, -0.04950804f, 0.00541110f, -0.02674159f, 0.00538341f, -0.04304595f, 0.00128763f, -0.02796771f, 
    -0.04098523f, 0.01390847f, -0.03391084f, -0.04406446f, 0.03782373f, -0.00977738f, 0.02607523f, 0.02544416f, 
    -0.00600761f, -0.03454261f, -0.04828655f, 0.01486077f, -0.04904664f, -0.03205637f, 0.04380431f, -0.00458663f, 
    0.01024639f, 0.00321355f, -0.04704936f, 0.01554266f, 0.04108445f, -0.01075848f, -0.01405566f, 0.03807980f, 
    -0.03229659f, -0.01448534f, -0.03970039f, -0.02057734f, -0.02807458f, 0.01226762f, 0.01980394f, -0.05341335f, 
    -0.00586116f, -0.00302575f, -0.00057143f, -0.01144521f, 0.02014683f, -0.05174956f, 0.02685485f, -0.03505687f, 
    0.02971082f, -0.04436465f, -0.02271706f, -0.02280873f, 0.03001732f, 0.01785497f, 0.00158756f, -0.00686889f, 
    0.04279316f, -0.01878948f, -0.00388229f, 0.01838788f, -0.02818818f, -0.02867502f, -0.04779944f, 0.01152532f, 
    0.01800384f, 0.02737591f, -0.01850483f, 0.01520419f, 0.04211611f, -0.02727072f, -0.03011866f, -0.04178349f, 
    -0.03219852f, -0.05750694f, -0.01232287f, 0.00292218f, 0.03776945f, -0.02672512f, -0.01559578f, 0.01997490f, 
    -0.02644878f, 0.03270490f, 0.00637748f, 0.00095636f, -0.03539519f, 0.03577547f, -0.05402711f, 0.01657628f, 
    0.05054614f, -0.02988089f, 0.00531561f, -0.01194017f, -0.00804191f, -0.03500492f, -0.02728361f, -0.04810118f, 
    -0.01216180f, 0.02579996f, -0.01651309f, -0.04979834f, 0.02396647f, -0.00456034f, -0.01851301f, -0.01075962f, 
    -0.02451027f, 0.01069819f, -0.03387219f, -0.03102790f, -0.03543727f, -0.00360498f, -0.04384421f, 0.00317091f, 
    -0.00692913f, 0.01993291f, 0.04115088f, 0.02510132f, -0.02048095f, 0.01201368f, 0.03508767f, -0.03503904f, 
    -0.04615755f, -0.01807617f, 0.03684350f, 0.00098896f, 0.02869939f, -0.00540732f, -0.04872409f, 0.04479811f, 
    -0.04354413f, -0.02161168f, 0.04397910f, 0.03410485f, -0.03811081f, 0.03413500f, -0.01547966f, 0.03858088f, 
    0.01193179f, -0.04594791f, -0.01512352f, 0.01304330f, -0.01459383f, -0.00152785f, 0.01036142f, 0.02622030f, 
    0.00796130f, -0.02503679f, 0.01013584f, -0.03101697f, 0.04307523f, -0.02500409f, 0.03344212f, -0.03521243f, 
    0.03120684f, -0.01570836f, -0.00509576f, 0.02317891f, 0.00085404f, 0.04997211f, -0.05144713f, -0.01727733f, 
    0.12838887f, 0.34892032f, 0.15514331f, 0.15216567f, -0.04580913f, -0.00017188f, 0.05327528f, -0.00817464f, 
    0.08169604f, 0.11509719f, -0.11796208f, 0.07235687f, 0.02920878f, 0.15763856f, 0.00664638f, -0.08538449f, 
    0.01546499f, -0.01977825f, -0.08274233f, 0.00711902f, 0.02744435f, -0.03101340f, 0.03230254f, 0.10207169f, 
    0.22557449f, -0.02510459f, -0.01628043f, 0.04480612f, -0.08357980f, 0.03524362f, -0.06830061f, 0.03998429f, 
    0.17546962f, -0.12956966f, -0.03557633f, -0.17389636f, -0.28033096f, 0.18298039f, 0.03234802f, 0.08423875f, 
    0.01451673f, 0.03885087f, -0.00364036f, 0.04477010f, 0.07760097f, -0.00744011f, -0.04178311f, 0.04533685f, 
    0.05553922f, 0.26850572f, -0.06662334f, -0.23633704f, 0.08102790f, -0.06604689f, -0.11668672f, -0.06674478f, 
    0.06606334f, 0.07854903f, 0.02164501f, 0.18844901f, 0.23318817f, 0.13635993f, -0.06205444f, -0.04053239f, 
    0.10433471f, -0.01614571f, 0.00281796f, -0.05580194f, 0.10893819f, 0.11101649f, 0.02096508f, 0.02769966f, 
    0.25406364f, 0.05261379f, -0.05893740f, -0.03862099f, -0.04624167f, -0.00265505f, -0.03753790f, 0.22619033f, 
    0.07368690f, 0.02268523f, -0.07258879f, 0.08106825f, 0.07690458f, -0.11012643f, -0.20182663f, 0.17098974f, 
    -0.03743144f, -0.03786324f, -0.03675129f, -0.08377289f, 0.06298380f, 0.07656354f, -0.03283985f, -0.01718540f, 
    0.27452058f, 0.19927618f, 0.07117292f, 0.01753285f, -0.03727661f, -0.01976170f, 0.04186426f, -0.04619803f, 
    0.04803076f, -0.05068769f, 0.08422793f, -0.11089095f, 0.15450175f, -0.08973952f, -0.05016523f, 0.08305514f, 
    0.09442792f, 0.04267424f, 0.00365289f, -0.01648959f, 0.06013855f, 0.14874713f, -0.02768741f, 0.00227831f, 
    -0.26529950f, 0.12821645f, -0.00543813f, 0.13148980f, -0.04660929f, -0.07429025f, -0.09240845f, 0.04908377f, 
    -0.03728814f, 0.04848550f, 0.13659951f, 0.10133426f, -0.22875443f, -0.01265776f, -0.20598777f, -0.08483806f, 
    -0.02142431f, -0.11230589f, -0.16653380f, 0.12893349f, 0.02664771f, -0.01662843f, -0.00694231f, 0.10699026f, 
    0.19316739f, -0.00674234f, -0.20771162f, 0.02916411f, -0.03042340f, 0.04745466f, 0.01947053f, -0.10447390f, 
    -0.04436101f, 0.02169368f, 0.14954208f, -0.04520640f, -0.00799394f, -0.03108690f, 0.04953477f, -0.12792365f, 
    0.09761380f, -0.06273223f, -0.03610304f, -0.08588362f, 0.00903085f, 0.10457632f, -0.00215033f, 0.07777239f, 
    0.43240276f, 0.05140641f, 0.07477594f, 0.04865087f, -0.00892025f, -0.05277027f, 0.11075618f, 0.07997923f, 
    -0.14684227f, 0.12821943f, 0.01727986f, -0.09745447f, -0.26559454f, 0.21947041f, 0.05839036f, -0.13932358f, 
    0.01105700f, 0.14585990f, -0.14069125f, 0.21407299f, 0.04272196f, -0.00948553f, 0.01949820f, 0.10223120f, 
    0.08010601f, 0.02366716f, -0.16362424f, -0.19070114f, 0.19087583f, 0.08857825f, -0.16829209f, 0.02226603f, 
    0.12125476f, -0.01534490f, 0.06223524f, -0.07019927f, -0.40022418f, 0.03390362f, 0.01945724f, 0.06350412f, 
    -0.12954322f, 0.05071927f, 0.00157855f, -0.00509832f, 0.12747158f, -0.09198663f, -0.00022290f, -0.06705032f, 
    0.14272526f, -0.11364215f, -0.06777770f, 0.04241133f, 0.03026725f, 0.08295679f, 0.07917066f, 0.11440450f, 
    -0.10300441f, 0.11594599f, 0.00596076f, -0.03055896f, -0.34077781f, -0.14519583f, 0.01524364f, 0.03862493f, 
    0.03190650f, -0.01394650f, 0.08053450f, -0.10076122f, -0.00004636f, 0.10917144f, 0.21318005f, 0.07865375f, 
    0.16492078f, 0.20585650f, 0.11855316f, -0.06365021f, -0.01036298f, 0.02950777f, 0.05908354f, 0.06780989f, 
    -0.07372213f, -0.03831250f, -0.01962535f, -0.07974955f, 0.25552061f, 0.00369196f, -0.00311252f, -0.05468521f, 
    -0.07366376f, -0.03267301f, -0.03665891f, -0.01507611f, 0.12171373f, 0.14212683f, -0.03632103f, 0.04837856f, 
    0.16337848f, 0.05973947f, -0.15025008f, 0.22046207f, 0.00152341f, -0.01648777f, 0.01549015f, 0.15267466f, 
    -0.02334498f, 0.10367151f, -0.04580814f, -0.03575565f, 0.03757631f, -0.12593795f, -0.03350242f, -0.10461410f, 
    0.19689934f, -0.08482606f, -0.01008291f, -0.10531610f, 0.07776415f, -0.05995197f, 0.00258322f, -0.02090726f, 
    -0.12694411f, -0.14805198f, 0.19655558f, 0.02554606f, 0.02756758f, -0.04801502f, 0.02833367f, -0.04664669f, 
    -0.05030252f, 0.14995682f, 0.12341427f, 0.04160871f, 0.36738056f, 0.00363563f, -0.08173449f, -0.15561099f, 
    0.08192590f, 0.08178582f, -0.11221952f, 0.04517701f, 0.05641281f, -0.04022955f, -0.05815822f, 0.03275228f, 
    0.07626328f, -0.15612559f, 0.00451301f, -0.05230256f, -0.07282608f, -0.03594883f, -0.00626421f, 0.01510172f, 
    0.01347827f, -0.01133495f, 0.02104185f, 0.07246933f, -0.00016929f, -0.20090799f, -0.09912120f, 0.15275735f, 
    0.08747235f, 0.07553952f, -0.07160061f, 0.03814553f, -0.04499259f, -0.02944790f, 0.02239720f, 0.08860299f, 
    -0.11159174f, -0.07006892f, 0.05328721f, -0.28074813f, -0.09005373f, -0.01526153f, -0.04447701f, -0.08760836f, 
    -0.07220267f, 0.00737053f, -0.03182031f, -0.03266346f, -0.23499112f, -0.09634291f, -0.02033746f, 0.08597211f, 
    0.14137320f, -0.02643727f, -0.01283532f, -0.01746873f, 0.04116684f, -0.04724582f, 0.09310415f, -0.05996237f, 
    0.04611253f, 0.18958902f, 0.11941600f, 0.15370983f, 0.03608300f, 0.01010914f, 0.02583369f, 0.06429890f, 
    0.07280809f, 0.00258705f, -0.03263058f, 0.06854010f, 0.35298154f, 0.11679991f, -0.06321060f, 0.03847378f, 
    -0.06905808f, 0.00154762f, -0.12117882f, 0.01065927f, 0.15650813f, -0.01965603f, -0.09100977f, -0.10004040f, 
    -0.34232527f, -0.01302205f, 0.05679112f, 0.09833129f, -0.01275853f, -0.02944690f, -0.06101888f, 0.00606807f, 
    0.02165831f, 0.04736240f, 0.01480773f, 0.09394870f, -0.12122183f, 0.09215447f, 0.12479231f, -0.04061809f, 
    -0.02314016f, -0.00351292f, 0.06843182f, -0.02953268f, 0.05018611f, -0.11559737f, 0.02435096f, -0.13721003f, 
    0.02170493f, -0.13444969f, -0.01712154f, 0.03127485f, 0.16725048f, 0.08642301f, 0.12299500f, 0.14851063f, 
    0.03039209f, 0.07699405f, 0.08088734f, -0.14129022f, -0.08940680f, -0.00313767f, 0.01127818f, -0.04401468f, 
    -0.04886308f, -0.06870074f, 0.05862374f, 0.18881765f, 0.01925422f, -0.07050674f, -0.08064464f, -0.02453923f, 
    -0.29734024f, -0.10068377f, -0.06056656f, -0.18403088f, -0.19384520f, -0.09961826f, -0.00112212f, -0.04035480f, 
    0.04532636f, -0.06797671f, -0.03640691f, 0.10898975f, -0.17850021f, 0.05994283f, 0.12102216f, 0.01984010f, 
    -0.12894607f, 0.02460865f, 0.06988306f, -0.10318009f, 0.03209022f, -0.06693695f, 0.12676729f, 0.03316430f, 
    -0.05611231f, -0.15022454f, -0.05028613f, 0.11985120f, 0.10924406f, 0.04988184f, 0.03077949f, -0.03253652f, 
    0.09832136f, -0.01302315f, 0.01769855f, -0.05132832f, -0.29438627f, 0.05388706f, 0.11473705f, 0.31793639f, 
    0.08001766f, -0.03496316f, -0.07713979f, -0.03511462f, 0.00709208f, -0.01126314f, 0.09581349f, -0.00784982f, 
    0.09060868f, -0.08987579f, 0.13844804f, 0.11985164f, 0.01388264f, 0.05696653f, -0.01402174f, 0.05701615f, 
    -0.11092891f, 0.03826754f, -0.01394628f, 0.12446862f, 0.23135196f, -0.18040282f, -0.03286481f, 0.07954012f, 
    0.12156588f, 0.15850928f, 0.05521268f, -0.08138496f, 0.00372041f, -0.06741671f, 0.04232395f, 0.09253699f, 
    -0.16292205f, -0.14762326f, -0.06070065f, 0.08683079f, 0.01609796f, 0.04028525f, -0.00428319f, 0.04420937f, 
    -0.06250276f, 0.10655101f, -0.11209281f, 0.02577285f, -0.17564538f, -0.03624619f, -0.03956101f, 0.03651112f, 
    0.00603901f, -0.08682895f, -0.02035226f, 0.01464832f, 0.05694826f, 0.06711016f, -0.01321145f, 0.00420823f, 
    -0.07351648f, -0.03955859f, 0.16291034f, -0.12759914f, -0.01739397f, -0.03104234f, 0.11217532f, -0.04927977f, 
    0.06671780f, 0.08400550f, 0.01009173f, 0.13350768f, 0.23275495f, -0.10756078f, 0.11675069f, -0.03341125f, 
    -0.00694435f, 0.06109290f, -0.01826138f, -0.09938283f, 0.07110127f, 0.07299573f, 0.03382616f, -0.04978427f, 
    0.26516649f, 0.27544191f, 0.12097414f, 0.20812178f, -0.02056203f, -0.11711178f, -0.01941103f, -0.05985719f, 
    -0.03477576f, -0.07135053f, 0.08712935f, 0.07690083f, 0.33282265f, 0.10353707f, -0.02607627f, -0.10511769f, 
    -0.09193284f, -0.06035943f, -0.00820509f, -0.05160877f, -0.05179976f, -0.01534650f, 0.09377261f, 0.06644410f, 
    0.14465706f, -0.26551262f, -0.02898141f, 0.00280083f, 0.09856607f, 0.08295335f, -0.02047298f, -0.00582439f, 
    -0.07149760f, 0.00646211f, 0.07176715f, -0.08323729f, 0.14209762f, 0.12773803f, -0.02224144f, -0.07292038f, 
    -0.09005979f, 0.02412608f, 0.01902743f, 0.01884910f, 0.01578401f, 0.02887640f, -0.03634287f, -0.07188002f, 
    -0.11773517f, 0.15895890f, -0.06541140f, 0.12345928f, 0.10099139f, -0.05652978f, 0.03527601f, 0.02146955f, 
    -0.02946608f, -0.06623265f, -0.11362056f, 0.04048042f, -0.20082840f, 0.17070337f, 0.09430584f, 0.04417117f, 
    -0.00219693f, 0.17265861f, -0.08527095f, -0.04614109f, -0.00182369f, 0.03699391f, 0.09397720f, 0.05161060f, 
    0.04950867f, 0.19599338f, 0.10370219f, 0.10105569f, 0.08989551f, -0.09215150f, 0.03060800f, -0.01696625f, 
    0.00010465f, -0.11998509f, -0.05460342f, -0.04498458f, -0.21526398f, 0.02344748f, 0.11067637f, -0.22734582f, 
    0.04339979f, 0.09224071f, 0.01947365f, 0.03172072f, 0.12289807f, 0.07036386f, 0.11694331f, 0.09367988f, 
    -0.16278006f, 0.04532406f, 0.05491028f, -0.04743071f, -0.05305107f, -0.02638693f, -0.00238874f, -0.03948732f, 
    -0.08317602f, 0.05810379f, -0.05963010f, -0.04737604f, -0.07444898f, -0.09055337f, -0.00220399f, 0.10518235f, 
    0.01294074f, -0.00363611f, -0.10850344f, -0.01227157f, 0.09404286f, -0.06730706f, -0.01182131f, 0.21809694f, 
    0.06384930f, -0.05729868f, 0.12768662f, 0.05523443f, 0.18104255f, -0.11705043f, 0.09651668f, 0.05155363f, 
    0.15453626f, 0.10440003f, 0.11863013f, 0.12477984f, 0.04026515f, -0.06094779f, -0.05903983f, 0.03925734f, 
    -0.00315832f, 0.02939393f, -0.04650130f, -0.10430133f, -0.00949703f, 0.00130163f, -0.01907822f, -0.04334750f, 
    -0.20282592f, 0.14669938f, 0.00238295f, -0.06035788f, -0.03737273f, -0.04579163f, 0.05842398f, 0.11666699f, 
    0.12871005f, 0.00396134f, -0.01688536f, 0.15616560f, -0.00773759f, -0.04003617f, -0.11211033f, 0.07299136f, 
    0.08064404f, 0.04659200f, 0.01705580f, 0.06425796f, -0.02455029f, -0.12187307f, 0.09846000f, -0.03410082f, 
    0.27749303f, -0.00664916f, -0.05392456f, -0.10449529f, 0.04908892f, -0.00162785f, 0.02401197f, -0.09274881f, 
    0.00573939f, 0.12430302f, -0.10467616f, 0.06827314f, -0.18071361f, 0.12865430f, 0.07996511f, -0.11635746f, 
    0.24512708f, 0.06301976f, -0.01125346f, -0.03247224f, 0.03619235f, 0.06981163f, 0.04867749f, -0.07720547f, 
    0.00542335f, -0.18152668f, 0.03840148f, 0.20794773f, 0.06280529f, 0.15375987f, 0.08196436f, -0.02818581f, 
    -0.01774961f, 0.10072396f, -0.06442697f, -0.00144054f, -0.19362214f, -0.11067965f, -0.01358239f, -0.00428143f, 
    -0.00884906f, -0.09051926f, -0.02736303f, 0.00367281f, 0.06980339f, 0.08083027f, -0.04571234f, -0.13137138f, 
    0.03614661f, 0.00827917f, 0.01008302f, 0.02005793f, 0.01109681f, 0.00055277f, 0.04566753f, -0.04791699f, 
    -0.00896779f, -0.02616209f, -0.02196864f, 0.01808534f, -0.02319346f, 0.03252712f, 0.00033975f, -0.02439893f, 
    -0.05073768f, 0.04295626f, 0.03130763f, -0.05928608f, 0.02535457f, 0.03269830f, -0.05425343f, -0.01780391f, 
    -0.01596810f, 0.02700219f, 0.03728742f, -0.02825587f, 0.01884983f, -0.04210597f, -0.00344958f, -0.03608036f, 
    -0.03759415f, 0.04589167f, 0.02124160f, 0.00516240f, 0.00523112f, -0.03959228f, -0.02039755f, -0.05360308f, 
    0.01096622f, -0.02436457f, 0.00502869f, -0.02897417f, 0.01667010f, 0.04152716f, -0.04874758f, 0.02330123f, 
    -0.02404019f, 0.02426064f, 0.03533782f, -0.02080923f, 0.04859038f, -0.01338391f, -0.03051655f, 0.03115180f, 
    0.02075783f, 0.01349881f, 0.02938943f, -0.00694237f, -0.00037423f, -0.04465694f, -0.00723387f, -0.03900878f, 
    0.03243829f, -0.01125268f, 0.02620555f, -0.03335313f, -0.04903677f, -0.03847123f, 0.02035169f, -0.01872252f, 
    0.04552973f, -0.01031212f, -0.05591154f, -0.03643436f, 0.01699747f, -0.03648784f, 0.02422726f, 0.02099295f, 
    0.02739237f, -0.02164145f, -0.01458622f, 0.00479396f, -0.04733970f, 0.00462174f, 0.03885170f, -0.02982565f, 
    0.03913382f, 0.02663763f, -0.05843719f, -0.04578874f, -0.01421247f, -0.04547415f, -0.01948665f, -0.04372955f, 
    -0.04977376f, -0.03358161f, 0.04957948f, -0.01593074f, 0.00654805f, 0.03255917f, -0.02081322f, 0.04100605f, 
    -0.02992303f, 0.02490536f, 0.03158951f, 0.02271069f, -0.03878223f, 0.03583445f, -0.01911042f, -0.00600243f, 
    0.04088080f, -0.01867372f, 0.02084224f, 0.02953137f, 0.00208169f, 0.01322538f, 0.03233423f, -0.01860950f, 
    0.00692588f, -0.02275647f, 0.03658703f, 0.03556268f, 0.03145547f, 0.02877254f, 0.00678712f, -0.05176438f, 
    -0.04601577f, -0.04440801f, 0.01639537f, 0.01631226f, -0.03451651f, -0.04072410f, 0.02960330f, -0.02244695f, 
    -0.03994439f, -0.00892089f, -0.05389091f, 0.02328700f, -0.02981583f, 0.03464701f, -0.02626471f, 0.01076657f, 
    0.01699171f, 0.01094717f, -0.04226433f, -0.02128967f, 0.03778333f, -0.03879918f, -0.02363283f, 0.01401753f, 
    0.01646472f, 0.03719366f, 0.01167115f, -0.03084708f, -0.00631655f, -0.02617548f, -0.02015954f, 0.01792475f, 
    0.03944584f, -0.01357481f, -0.01012488f, -0.04912767f, 0.03926454f, -0.02271327f, 0.03417706f, -0.01655123f, 
    0.00691873f, -0.00487660f, 0.02521478f, -0.02051260f, -0.03940443f, 0.01561621f, -0.03523684f, -0.05438454f, 
    0.00442342f, -0.02390026f, -0.04563624f, 0.03834366f, 0.00954044f, 0.02878109f, 0.03409366f, 0.00710967f, 
    0.02116636f, -0.05776902f, -0.02183150f, -0.03047153f, -0.00253735f, -0.03865346f, 0.03441752f, -0.05588635f, 
    -0.02495886f, -0.02203679f, 0.00175760f, -0.01534260f, -0.03626888f, 0.00450225f, -0.02631582f, -0.04893548f, 
    0.01744121f, 0.03397476f, 0.03161071f, 0.01554113f, 0.02240792f, -0.03141826f, -0.01607320f, 0.00415493f, 
    -0.00961848f, -0.00702573f, -0.00715293f, -0.02359297f, 0.03300186f, -0.03939277f, 0.04095225f, -0.04703801f, 
    -0.01897405f, -0.02706316f, -0.01065211f, 0.00163330f, 0.02537738f, -0.00397817f, -0.01423094f, -0.01019874f, 
    -0.04453716f, -0.02164147f, -0.05949662f, 0.01466280f, 0.00131910f, 0.03090439f, 0.02489069f, -0.02147673f, 
    0.04305688f, 0.03300206f, 0.02765021f, 0.02639200f, 0.02289219f, -0.00634856f, -0.04744773f, -0.03725163f, 
    0.01889507f, 0.02121512f, -0.03770609f, 0.01097237f, -0.02945540f, -0.04126474f, -0.00624945f, 0.02522620f, 
    0.02154812f, 0.04614194f, -0.02826440f, -0.01126163f, 0.00267505f, -0.00997390f, -0.04471928f, -0.00102972f, 
    -0.03958594f, 0.00376651f, 0.03314859f, 0.01040840f, -0.00707464f, -0.00613264f, -0.00849612f, -0.01013480f, 
    0.04454810f, -0.04280144f, 0.01517461f, -0.03655286f, 0.02857583f, 0.00133617f, 0.02662785f, 0.03809175f, 
    0.00416562f, -0.02773355f, -0.02602302f, 0.03756869f, -0.05157311f, -0.00562007f, -0.02678571f, -0.04012912f, 
    -0.03853954f, -0.05526470f, 0.00870370f, 0.00688908f, -0.04744683f, 0.01609645f, -0.00659088f, -0.02142929f, 
    -0.00130567f, -0.04875777f, -0.03622101f, 0.03207787f, 0.00216467f, -0.03689207f, -0.03840487f, -0.00568150f, 
    -0.04987809f, -0.00969716f, -0.01357358f, -0.01612584f, -0.04293115f, -0.04942280f, 0.03859612f, -0.03924317f, 
    0.01397715f, -0.02924177f, 0.03781730f, -0.04801875f, 0.01587970f, 0.03533367f, -0.04890221f, -0.03291743f, 
    -0.05670913f, -0.03817194f, 0.02089445f, -0.04116971f, -0.04928290f, -0.03954149f, 0.01398431f, 0.00350600f, 
    0.04308295f, 0.02692281f, -0.05190133f, -0.04389236f, 0.00885876f, 0.02168020f, -0.02543381f, -0.02989344f, 
    -0.02483469f, -0.01254940f, -0.04438202f, 0.00889179f, 0.00122374f, 0.03892868f, 0.00880982f, -0.00295085f, 
    -0.04462413f, -0.02552994f, 0.00150103f, 0.02509918f, -0.04934148f, -0.05704500f, -0.04312951f, -0.02908516f, 
    -0.02591808f, 0.02492521f, 0.03089410f, 0.02429893f, 0.03782872f, -0.00450195f, 0.00021607f, -0.01704835f, 
    -0.03564829f, -0.04078187f, -0.01647327f, -0.02884095f, 0.03801816f, -0.04390635f, 0.02740004f, -0.03991151f, 
    0.00384207f, -0.03827423f, 0.02420667f, -0.02708531f, 0.02519280f, 0.01911059f, -0.01619706f, 0.04035673f, 
    -0.03140513f, -0.05098251f, 0.01723967f, -0.05458023f, 0.02088415f, 0.00527902f, 0.04196362f, -0.00333904f, 
    0.00615470f, 0.02805716f, 0.01484726f, 0.00435606f, 0.00364071f, -0.02404033f, -0.02811104f, -0.03231291f, 
    -0.01192773f, 0.03340461f, 0.00356720f, -0.02759158f, -0.03542502f, 0.00577358f, -0.02250639f, -0.02545830f, 
    0.02145204f, 0.01183962f, 0.03883760f, -0.02805325f, 0.01360314f, -0.03992227f, 0.02666660f, 0.00346257f, 
    -0.01994772f, -0.04210832f, 0.00884807f, -0.04709641f, -0.03984386f, -0.00311059f, 0.02191126f, -0.05241337f, 
    0.00540627f, -0.03865216f, 0.04105481f, 0.01886060f, -0.01232435f, 0.02201327f, 0.01483039f, -0.00845647f, 
    0.04091729f, -0.03432728f, -0.05399980f, -0.03410640f, -0.01464379f, -0.00759969f, -0.04625113f, -0.01697459f, 
    0.01170914f, -0.05604804f, -0.02209360f, -0.03741714f, -0.04823501f, 0.02042960f, -0.00333437f, -0.04539919f, 
    -0.02607331f, -0.05372514f, -0.02951227f, -0.04041889f, 0.00334031f, -0.02555738f, 0.01952522f, 0.01125358f, 
    -0.04677587f, -0.01985676f, -0.03004315f, 0.03618026f, -0.03893618f, 0.03542471f, -0.04023373f, -0.01742557f, 
    -0.04316666f, -0.01334595f, 0.01583253f, -0.02561155f, -0.00998125f, -0.01226497f, 0.00013839f, -0.03509970f, 
    -0.00369182f, 0.00257748f, 0.03068542f, -0.00229249f, -0.05371926f, 0.01098159f, -0.02999115f, 0.00951441f, 
    -0.03126376f, 0.03622665f, 0.01370377f, 0.01601661f, -0.02183998f, -0.04266810f, -0.03091869f, 0.02911903f, 
    -0.00503512f, -0.02589244f, 0.03303594f, -0.05942137f, -0.05599130f, -0.00942659f, 0.01016057f, 0.01346537f, 
    0.04352483f, -0.02495077f, 0.04000244f, -0.04734550f, 0.01065271f, 0.03471629f, 0.03588434f, 0.00839338f, 
    0.03292902f, -0.00272706f, -0.01460074f, -0.01008890f, -0.02797575f, -0.02593683f, -0.00223767f, -0.03014477f, 
    -0.04610846f, 0.03137440f, -0.04867391f, -0.02718907f, -0.03998097f, -0.02863486f, -0.02237023f, -0.01292426f, 
    0.04322644f, 0.00307783f, -0.00803130f, 0.03302075f, -0.02290267f, -0.02010104f, 0.02864990f, -0.04493428f, 
    -0.01958898f, 0.00657147f, -0.01582411f, -0.03840264f, -0.02479102f, -0.04171929f, -0.05171680f, -0.04596625f, 
    -0.01643525f, -0.01961479f, 0.01756294f, -0.02174396f, -0.02262156f, 0.02499186f, -0.02808516f, 0.00495198f, 
    0.03856292f, -0.02549325f, -0.03564637f, -0.02963417f, 0.01622588f, 0.02639905f, -0.02448997f, -0.02094315f, 
    0.03180119f, -0.05872341f, 0.00946627f, 0.00224919f, -0.02201044f, -0.04055830f, 0.03496792f, 0.03649484f, 
    0.01711717f, -0.04519511f, -0.04916455f, -0.00114744f, -0.04082719f, -0.01515101f, -0.02854853f, -0.00425099f, 
    0.04686438f, 0.04384977f, 0.03437602f, 0.03397777f, -0.03558752f, 0.01553384f, 0.00241550f, 0.00224661f, 
    -0.00258869f, -0.05272134f, 0.02347338f, 0.03548216f, -0.00518349f, -0.00854425f, 0.04213887f, 0.02882518f, 
    -0.04771658f, 0.00848894f, 0.01463714f, 0.01856291f, 0.00571795f, 0.00193773f, 0.01445114f, 0.03913996f, 
    -0.04550774f, 0.03193126f, -0.01863251f, -0.01949481f, 0.01785058f, -0.02935199f, 0.03878726f, 0.02407075f, 
    -0.00650115f, 0.00214352f, 0.02592666f, 0.01346178f, -0.04472496f, -0.05188691f, -0.00544498f, 0.00684945f, 
    -0.00071431f, 0.04265406f, 0.03814729f, 0.01054120f, 0.01194388f, -0.01879579f, -0.01363837f, 0.02705511f, 
    0.03831394f, 0.00140863f, -0.03474397f, -0.04825757f, -0.02625923f, 0.03597484f, -0.03929792f, -0.03866385f, 
    -0.04609600f, -0.04526672f, -0.00831542f, -0.04641037f, -0.03568816f, -0.02953352f, 0.01454818f, -0.03691953f, 
    0.03917886f, 0.00625670f, -0.00302347f, 0.03182033f, 0.03207297f, -0.01071916f, 0.03613847f, -0.02351137f, 
    0.02547421f, 0.00164146f, -0.00643553f, -0.01498188f, -0.04020501f, 0.02910532f, -0.04960488f, -0.02565974f, 
    -0.01183539f, -0.04961499f, 0.00786767f, -0.04468656f, -0.02006854f, -0.04205920f, -0.04575898f, 0.01142811f, 
    -0.02537044f, -0.00636543f, 0.04231806f, 0.03081525f, -0.01413382f, -0.04061584f, -0.00964797f, 0.02888753f, 
    -0.03592724f, 0.01065177f, -0.01100873f, -0.01495707f, 0.01375315f, 0.01607112f, -0.03913037f, 0.02104621f, 
    0.01239719f, -0.03157169f, 0.03283453f, -0.04840671f, -0.05516830f, 0.01489950f, -0.04331902f, -0.03647684f, 
    -0.00428069f, -0.00361674f, 0.01714778f, -0.00653611f, 0.02846286f, 0.01689413f, 0.03705227f, 0.01782146f, 
    0.00106504f, 0.02865020f, -0.01671024f, -0.05529327f, 0.01941097f, 0.03517485f, -0.02743671f, 0.01516482f, 
    -0.02541031f, 0.02766309f, -0.05187471f, -0.03867028f, 0.03106347f, -0.03325594f, 0.03921527f, -0.01853515f, 
    -0.03299049f, 0.00937506f, -0.04701043f, -0.03598409f, -0.04797455f, -0.03359814f, -0.02058853f, 0.01876824f, 
    -0.02879119f, -0.01159442f, -0.02444492f, -0.01589286f, 0.00255650f, -0.03065489f, -0.04162438f, -0.04288537f, 
    0.00640795f, -0.00737740f, 0.02101933f, -0.02014629f, 0.02596244f, -0.03975517f, 0.03300310f, 0.03645550f, 
    0.02863502f, 0.00249852f, 0.01545875f, 0.03410162f, -0.00963604f, 0.02936615f, -0.04480510f, -0.05477777f, 
    0.00290189f, 0.01957170f, -0.05264065f, -0.00835430f, -0.01639190f, 0.02423741f, -0.02662096f, 0.00241612f, 
    -0.05131871f, -0.03982798f, 0.04157972f, 0.01714511f, 0.01884752f, -0.04168500f, -0.02952505f, 0.00851361f, 
    0.03784885f, -0.05298694f, 0.03891443f, 0.00753404f, -0.04748742f, -0.01425025f, -0.04284278f, -0.04094213f, 
    0.01307175f, -0.01289294f, 0.01650992f, -0.00109670f, -0.01670789f, 0.03004716f, 0.02864094f, -0.04101969f, 
    -0.01642897f, -0.00137021f, 0.03123312f, 0.02642165f, -0.01235768f, -0.01680959f, 0.03708580f, 0.02812512f, 
    0.03113565f, -0.00841278f, -0.00862260f, -0.03816468f, -0.03356746f, 0.01370782f, 0.02883403f, -0.04986254f, 
    0.01991555f, -0.04503377f, -0.07550647f, -0.05098414f, -0.00334347f, 0.00997603f, -0.07642996f, -0.02425883f, 
    -0.02131944f, -0.05389988f, -0.03197525f, 0.02542935f, -0.07091827f, -0.04772518f, -0.01837272f, -0.06232736f, 
    -0.04922332f, -0.05866097f, -0.05979965f, -0.07121179f, -0.03768488f, 0.02373460f, -0.05329697f, 0.00430009f, 
    -0.03327290f, -0.03233555f, 0.01085935f, -0.03296054f, -0.03493991f, 0.00086495f, -0.00158399f, 0.02217533f, 
    -0.07475869f, -0.02025988f, -0.05738143f, 0.00532640f, -0.01602311f, 0.01088145f, 0.00797789f, -0.07433915f, 
    -0.05164730f, -0.04778337f, -0.06145056f, -0.00362233f, -0.05900196f, -0.04218272f, -0.03184228f, -0.01086487f, 
    -0.04406284f, -0.05486329f, 0.02181083f, -0.03636321f, 0.01724683f, -0.04652201f, -0.07319317f, 0.00939379f, 
    -0.02661843f, -0.00229169f, 0.02612131f, -0.02247106f, -0.02872377f, -0.07017697f, -0.07119298f, -0.04322587f, 
    0.02281162f, 0.02694170f, -0.01493053f, -0.06947371f, -0.03348118f, -0.07262260f, -0.02951874f, -0.02748962f, 
    -0.00289386f, -0.03779760f, -0.05798715f, -0.03072102f, -0.05987112f, 0.02048951f, -0.06965846f, -0.05708474f, 
    -0.06478999f, -0.04084524f, -0.05605777f, -0.01006043f, -0.03501568f, -0.01332631f, 0.02315579f, -0.06177646f, 
    -0.06946928f, -0.06764093f, 0.02717268f, -0.01956495f, 0.01254458f, -0.05413420f, -0.02389208f, -0.06811783f, 
    -0.02922922f, -0.04972957f, 0.00205140f, 0.01030357f, -0.02350591f, -0.06042923f, -0.06662571f, -0.04461359f, 
    0.02343841f, -0.06505281f, -0.04367852f, -0.06659761f, -0.07152419f, -0.02959245f, -0.00930915f, -0.01327716f, 
    -0.03435455f, -0.05418840f, -0.05790616f, -0.03449281f, -0.06848417f, -0.05428590f, -0.00331578f, 0.02605878f, 
    -0.00715072f, -0.00187984f, -0.06903167f, -0.03808007f, -0.04503210f, 0.01965895f, -0.01124706f, -0.04839738f, 
    0.01391555f, -0.05978493f, -0.03619444f, -0.04491524f, -0.03621387f, -0.07133789f, 0.00796395f, 0.01496465f, 
    -0.05283915f, 0.02540620f, 0.02374945f, -0.04457385f, -0.01407472f, -0.00503101f, -0.05909783f, -0.01476495f, 
    -0.01617471f, -0.01562118f, -0.05557637f, 0.02043856f, -0.04639311f, -0.07391624f, -0.00060473f, 0.02165877f, 
    -0.04349294f, -0.04460922f, -0.01468246f, -0.04980012f, -0.03428092f, 0.02661190f, -0.04932880f, -0.02956260f, 
    -0.04777300f, -0.03506397f, -0.04379721f, -0.02128132f, -0.03330347f, 0.00106690f, -0.03709710f, 0.00180432f, 
    -0.04065978f, -0.06952775f, 0.00923619f, -0.07352474f, -0.03591510f, -0.01477902f, -0.02006494f, -0.03954480f, 
    -0.01376167f, -0.00270963f, -0.00502713f, -0.03117460f, 0.01868883f, -0.01389054f, 0.02544428f, -0.02711529f, 
    -0.06678012f, -0.07387353f, -0.07421386f, -0.06649341f, -0.05768708f, -0.02778939f, -0.06077474f, -0.01606884f, 
    -0.03695608f, 0.00201553f, -0.03227933f, -0.04500476f, -0.04850385f, -0.01820485f, -0.04741681f, 0.02039757f, 
    -0.02434801f, -0.02857394f, 0.00819692f, 0.02356070f, -0.01675049f, -0.02244642f, -0.01185444f, 0.01210996f, 
    -0.03495936f, -0.01192596f, -0.02976210f, -0.04327595f, -0.00555061f, 0.02146119f, -0.03392819f, -0.07300801f, 
    -0.03636766f, 0.02320316f, 0.00790152f, -0.02935254f, -0.06430478f, -0.00118956f, 0.00284552f, -0.04674444f, 
    0.02690545f, -0.01928733f, -0.03221931f, -0.06414356f, 0.01655991f, 0.02570505f, -0.04372315f, 0.01439166f, 
    -0.03158310f, 0.01281375f, -0.06434705f, -0.06060769f, -0.02245709f, -0.07456294f, -0.01708664f, 0.01773735f, 
    -0.02710283f, -0.06102806f, 0.01682699f, -0.05084186f, -0.05768012f, -0.00930947f, -0.02631108f, -0.06851064f, 
    -0.02135453f, -0.01335437f, -0.07393216f, -0.03227337f, 0.00306973f, -0.02620641f, 0.02681633f, -0.05879490f, 
    0.01247012f, -0.02688030f, -0.01869489f, -0.03802952f, 0.01507169f, -0.04866777f, 0.01340038f, -0.06079006f, 
    -0.04034447f, -0.05723020f, -0.07276563f, 0.02603135f, -0.03893655f, -0.05172198f, -0.03752431f, -0.07119085f, 
    -0.00721039f, -0.01393137f, -0.07302669f, -0.01149505f, -0.05459177f, 0.02441694f, -0.00491354f, -0.02007898f, 
    0.02254176f, -0.05972503f, -0.02157255f, -0.06858438f, -0.00468654f, -0.02518952f, -0.06475280f, -0.04253946f, 
    -0.03256689f, 0.00102719f, -0.04018187f, 0.00657614f, -0.03483615f, -0.03760074f, -0.03609242f, 0.00100733f, 
    -0.00095010f, -0.07170788f, -0.03378709f, -0.00150130f, -0.03192287f, 0.01973921f, -0.01584231f, -0.03460575f, 
    0.01572645f, -0.06243246f, -0.00340305f, -0.00158632f, -0.07225954f, 0.01941540f, 0.00156960f, -0.01100291f, 
    -0.05361547f, -0.00291902f, -0.04475882f, -0.06014878f, -0.01451331f, -0.05568317f, -0.02395709f, -0.04249671f, 
    -0.04698551f, -0.02446289f, -0.06590429f, 0.02315633f, 0.02699619f, -0.04971090f, -0.01582442f, 0.01270505f, 
    0.00714289f, 0.02284908f, 0.00740843f, -0.06009453f, -0.05219010f, -0.04450899f, -0.07022563f, 0.01556083f, 
    0.01021640f, -0.07257877f, 0.01205282f, 0.01810041f, 0.02149962f, -0.03475297f, -0.01340705f, -0.05716414f, 
    -0.06269221f, -0.05048753f, -0.03866261f, -0.06575922f, 0.00670295f, -0.02445165f, -0.05738378f, -0.05592805f, 
    -0.00700511f, -0.06233473f, 0.01574568f, -0.05590464f, -0.00108034f, -0.01607537f, 0.01358802f, -0.07444866f, 
    -0.07452458f, -0.06711825f, -0.01516779f, -0.04707015f, -0.06366809f, -0.07311724f, -0.04804042f, -0.04567336f, 
    -0.04837723f, -0.06537294f, -0.01905362f, -0.05685869f, -0.05350289f, -0.07487373f, -0.02663119f, -0.00148095f, 
    -0.01884361f, 0.01973085f, -0.04199206f, -0.03444002f, 0.02534735f, 0.00872401f, -0.00418558f, -0.06537407f, 
    -0.00859942f, 0.01121363f, -0.03964762f, 0.01447209f, 0.01427185f, 0.04081419f, -0.04809783f, 0.04219750f, 
    0.04673911f, 0.00602250f, 0.03110734f, -0.03376576f, 0.01110776f, -0.02210569f, 0.00631751f, -0.02856519f, 
    -0.04732936f, -0.04061855f, 0.01974758f, -0.00737501f, -0.05529834f, 0.01924799f, -0.00758122f, -0.01258662f, 
    -0.05759822f, -0.03102779f, 0.02821541f, 0.03209888f, 0.01717298f, -0.02210087f, -0.03304414f, -0.04643548f, 
    -0.04365937f, -0.00861294f, -0.04950818f, -0.00851037f, 0.01836944f, -0.00449155f, -0.03576819f, 0.01222830f, 
    -0.01283561f, 0.01293452f, -0.01526344f, 0.03303026f, -0.02384242f, -0.02635371f, -0.05211328f, 0.02730136f, 
    0.02829660f, 0.01715346f, -0.01166511f, -0.02933854f, 0.03986221f, -0.02093572f, 0.03949555f, 0.03713772f, 
    -0.05852992f, 0.03410828f, -0.02485406f, -0.04456673f, -0.00876033f, -0.00802294f, -0.01022526f, -0.01617370f, 
    -0.04042463f, -0.01764905f, -0.03398343f, 0.01916287f, 0.01183183f, -0.01800452f, 0.02429826f, 0.00423858f, 
    -0.00138907f, -0.00791176f, -0.00423662f, -0.02872406f, -0.04401430f, 0.03749092f, -0.05875757f, -0.03483802f, 
    -0.04709677f, -0.01981241f, -0.00168359f, -0.03783019f, -0.05363218f, -0.05569798f, -0.03504543f, 0.02499050f, 
    -0.02932909f, 0.03084125f, -0.05369885f, 0.04936371f, 0.02190384f, -0.00253455f, -0.03358263f, 0.00801556f, 
    -0.03941733f, -0.00744068f, -0.04038154f, 0.04290171f, 0.02864251f, -0.00522805f, -0.01808423f, 0.04327808f, 
    -0.00675132f, -0.01565965f, -0.00078971f, 0.04384333f, -0.03537434f, 0.03162180f, -0.01386722f, -0.03863173f, 
    -0.00516811f, -0.00619279f, 0.01005409f, 0.02344331f, 0.03558145f, -0.05421751f, 0.01966196f, -0.02610948f, 
    -0.01046168f, -0.02869140f, 0.02283231f, -0.04447639f, -0.04712213f, 0.04618073f, 0.02361398f, 0.04313600f, 
    0.01112784f, -0.00787491f, 0.00468646f, -0.02445417f, -0.05120991f, -0.05117711f, -0.01946162f, -0.05116505f, 
    0.00799389f, 0.03733984f, 0.02431785f, -0.03900689f, 0.01248399f, -0.03641223f, -0.04449139f, -0.02582310f, 
    0.00215342f, 0.03812014f, -0.01491117f, -0.00266823f, -0.01152691f, 0.01297360f, -0.03195926f, -0.00884067f, 
    0.00339871f, -0.03320687f, 0.00709042f, 0.00286989f, 0.03460578f, -0.03737582f, 0.02577433f, -0.05359324f, 
    -0.04908584f, -0.02425673f, -0.02004755f, 0.01790594f, -0.01590125f, -0.04227362f, -0.03871962f, 0.01998360f, 
    -0.04201288f, -0.05373622f, -0.02690673f, -0.04692459f, 0.00684037f, -0.02436461f, 0.02410529f, -0.00303796f, 
    0.03827757f, -0.03724550f, -0.02408227f, 0.00002915f, 0.02563152f, -0.02696226f, -0.00117131f, -0.01706661f, 
    0.04373891f, 0.01606862f, 0.00642940f, 0.01494688f, -0.05489571f, 0.01542566f, 0.03969093f, 0.02950741f, 
    0.03102715f, -0.00289212f, 0.03367915f, 0.01933535f, 0.01673472f, 0.00089564f, -0.04871600f, -0.01282635f, 
    0.03988328f, 0.02339329f, -0.01561658f, -0.05717890f, 0.03318615f, 0.01108521f, 0.01087646f, 0.01862182f, 
    0.01658952f, -0.04028509f, 0.02629299f, -0.02972281f, -0.01985458f, 0.01602002f, -0.02208927f, -0.01577221f, 
    -0.03917966f, -0.00379205f, 0.02162385f, -0.02672197f, -0.01274588f, 0.00912608f, -0.00173315f, 0.02276741f, 
    0.02339194f, 0.03039720f, -0.03212509f, -0.04520646f, -0.03592367f, 0.02968402f, -0.04288832f, -0.03340692f, 
    -0.01213338f, -0.02424143f, -0.02845642f, 0.01510504f, 0.00931189f, -0.01170546f, 0.01461559f, -0.04180355f, 
    -0.05680152f, -0.04428147f, -0.00369837f, 0.02205783f, -0.00898054f, -0.04521758f, -0.01799391f, 0.02790200f, 
    -0.00793572f, 0.05124063f, -0.02190616f, -0.00401246f, 0.01463397f, -0.01196860f, 0.02100607f, 0.00705608f, 
    0.00414758f, 0.01364764f, -0.03684505f, -0.01078436f, 0.03434597f, -0.01697465f, 0.01007603f, 0.00101443f, 
    -0.02014373f, -0.00484025f, 0.01814325f, 0.03194827f, -0.01399547f, 0.02632267f, -0.00179591f, 0.03377411f, 
    0.04149275f, -0.02280157f, -0.02561263f, 0.01364118f, -0.03888137f, 0.03584433f, 0.04173696f, 0.02397502f, 
    0.00030819f, -0.03273370f, 0.03623248f, 0.01092575f, -0.04358964f, -0.03170538f, 0.03433506f, 0.03666258f, 
    0.03466293f, -0.02186967f, -0.03829735f, -0.04358093f, 0.00599083f, -0.01243329f, -0.02004515f, -0.05229219f, 
    -0.05208121f, -0.05640583f, 0.03600406f, -0.02005400f, -0.04124733f, 0.01574528f, -0.00574673f, -0.01898464f, 
    -0.04010355f, -0.00467471f, -0.05825358f, 0.00189957f, 0.01871266f, -0.01756772f, 0.03686703f, -0.02690597f, 
    -0.00254707f, -0.02359791f, 0.03648424f, -0.04318114f, -0.04696202f, 0.02537899f, -0.03116094f, -0.03624108f, 
    0.00383319f, 0.03100454f, -0.01296701f, -0.04903814f, -0.04991391f, 0.02699480f, 0.03062264f, 0.00997707f, 
    0.03756064f, -0.05201367f, 0.03194815f, 0.03372613f, -0.04483712f, 0.01326787f, -0.02671409f, 0.01221302f, 
    0.00705589f, 0.01543534f, 0.04222887f, -0.00243088f, 0.03061728f, -0.03221102f, 0.02483848f, 0.00283124f, 
    -0.05250346f, -0.01747265f, 0.02532790f, -0.04187518f, -0.01931178f, 0.02886051f, -0.03613351f, -0.01041203f, 
    -0.01036705f, 0.03965582f, 0.02451129f, -0.05273248f, 0.03674848f, -0.02624881f, 0.01395903f, -0.01887328f, 
    -0.04349556f, 0.03831032f, 0.02743702f, 0.01714822f, 0.00335592f, -0.00040135f, -0.01066906f, -0.04349158f, 
    -0.00344358f, 0.03713737f, -0.02588564f, -0.01920577f, -0.04480051f, -0.04523497f, 0.01304918f, 0.00577944f, 
    -0.04589058f, 0.00872026f, 0.03488918f, 0.05330276f, 0.04697293f, -0.03550316f, 0.02485135f, 0.05055956f, 
    -0.41637415f, -0.18892334f, -0.07695404f, -0.17304458f, 0.07487755f, 0.03522745f, 0.07505623f, -0.08376408f, 
    0.04278202f, -0.08160242f, 0.04661648f, -0.09093567f, 0.04213930f, -0.14625302f, 0.16851602f, 0.00155056f, 
    -0.02037487f, 0.04853331f, 0.04607948f, 0.01798958f, -0.03980885f, 0.04379309f, -0.05341627f, -0.06132987f, 
    -0.14543474f, 0.04214072f, -0.05124893f, -0.06612019f, 0.09421787f, 0.00537346f, -0.00061672f, -0.06311306f, 
    -0.03800443f, 0.15994218f, 0.04689080f, 0.18919830f, -0.01235251f, -0.33121213f, 0.05221644f, -0.06760443f, 
    -0.01883615f, -0.02339101f, 0.05787362f, 0.00272323f, -0.11470260f, 0.09960170f, 0.04834735f, -0.02668255f, 
    -0.03366973f, 0.06582142f, -0.29010516f, 0.53089607f, 0.04380098f, 0.11740047f, -0.03658845f, 0.01183599f, 
    0.05446326f, -0.00162576f, -0.04002188f, -0.12150122f, -0.02532121f, -0.04346701f, -0.08291405f, 0.10801356f, 
    -0.01926471f, 0.03350313f, -0.06145273f, 0.06654643f, -0.07366269f, -0.07837392f, -0.03876071f, 0.03308079f, 
    -0.19401276f, 0.00923939f, 0.10490542f, 0.03078765f, -0.04040332f, 0.04806299f, -0.03052713f, 0.01089604f, 
    0.02918335f, -0.01519059f, 0.11617498f, 0.00612538f, 0.09844824f, 0.18513694f, 0.16584651f, -0.33639625f, 
    0.04545574f, -0.02033359f, -0.01324157f, 0.00801385f, 0.05855318f, 0.04120324f, 0.04353357f, 0.17181449f, 
    -0.16778247f, -0.05869747f, -0.14823711f, 0.20268372f, -0.05101727f, 0.02348959f, -0.04475809f, 0.01887067f, 
    -0.08955166f, 0.06903632f, 0.01145454f, 0.03680408f, -0.12625907f, 0.05019978f, 0.10006413f, 0.01733962f, 
    -0.21951421f, 0.09243039f, -0.01981211f, -0.02805550f, -0.03682448f, -0.04921431f, 0.02210842f, -0.07287515f, 
    0.26950228f, -0.12796628f, 0.07027005f, -0.34393427f, 0.16002645f, 0.05409065f, 0.02648720f, 0.02909124f, 
    0.03506876f, -0.05242531f, -0.12076313f, -0.02437305f, 0.14443924f, 0.10667463f, 0.30486476f, -0.06013350f, 
    0.07909328f, 0.01945371f, 0.08685493f, -0.03419364f, -0.04748000f, 0.05558075f, 0.05370549f, 0.10083345f, 
    -0.14473239f, 0.00308708f, -0.04783301f, -0.05290158f, 0.06716128f, 0.01186527f, 0.06898261f, 0.06552424f, 
    0.04582091f, 0.01482482f, 0.04446149f, 0.12148359f, 0.03385023f, 0.13314250f, -0.09277621f, 0.15142788f, 
    0.03951702f, 0.00590379f, -0.02694025f, 0.10431863f, 0.09979534f, -0.00124321f, 0.00450393f, -0.09392979f, 
    -0.38502249f, -0.21230198f, -0.23885480f, 0.18300290f, -0.10621713f, 0.03475478f, -0.04832267f, 0.01917750f, 
    0.00439473f, -0.02646885f, 0.05090975f, -0.05403226f, 0.11007284f, -0.17465559f, 0.17727222f, 0.26744312f, 
    0.00600046f, -0.12568556f, 0.07138979f, -0.11522022f, 0.02546092f, 0.00023264f, 0.02753590f, -0.00941008f, 
    -0.07398535f, 0.03775520f, 0.16142300f, -0.04646127f, -0.09035660f, 0.03782562f, 0.00102148f, -0.04031203f, 
    -0.05501880f, 0.00293869f, 0.08617394f, 0.07721823f, 0.31304750f, -0.22283949f, 0.11871005f, -0.04142040f, 
    0.11303057f, -0.11734879f, -0.13435000f, -0.02232325f, -0.08034939f, 0.11661579f, 0.03515631f, 0.05615288f, 
    -0.09292654f, 0.13250732f, 0.05612563f, -0.13354795f, 0.08503853f, -0.02586794f, -0.06135908f, 0.06592065f, 
    0.05419387f, -0.17127439f, -0.04726637f, 0.03380553f, 0.29868004f, -0.14601274f, -0.04060585f, 0.10418936f, 
    -0.07977791f, -0.01308630f, -0.02528598f, 0.05769649f, 0.08466754f, -0.08543205f, -0.03445296f, -0.01059717f, 
    -0.16103807f, -0.15515515f, -0.15538163f, 0.08766443f, 0.01918939f, 0.02177559f, -0.02022051f, -0.09468432f, 
    0.08115183f, 0.11382092f, 0.01997713f, 0.14598837f, 0.11354060f, 0.04062431f, 0.01310883f, 0.31745508f, 
    0.04954104f, 0.11270840f, 0.06382287f, 0.00632795f, 0.00899046f, -0.06106055f, 0.11753611f, -0.04558808f, 
    -0.09781772f, 0.05323540f, 0.01677847f, -0.01882046f, 0.03571572f, 0.11309829f, 0.04747320f, 0.04394177f, 
    0.06743526f, 0.03239472f, -0.01531208f, 0.09398028f, -0.05540051f, 0.11769557f, 0.09482923f, -0.02191852f, 
    0.00698775f, -0.02540258f, -0.06425709f, -0.00100967f, -0.06365258f, 0.02408700f, 0.11013985f, 0.03690217f, 
    -0.01201543f, 0.17815474f, -0.17239885f, -0.07065406f, 0.08837360f, 0.07765523f, 0.06823181f, 0.06730642f, 
    0.02420680f, -0.11796301f, -0.01285583f, -0.13193858f, -0.17733791f, 0.09287563f, 0.11447325f, 0.07723541f, 
    0.04376933f, -0.04041646f, 0.06532514f, -0.02129323f, 0.03140492f, 0.14099763f, 0.03532519f, 0.12492569f, 
    -0.11423397f, 0.24067095f, -0.05802504f, 0.15713429f, 0.19716692f, 0.06893859f, -0.02127741f, 0.03088794f, 
    0.04109868f, 0.01036534f, 0.05795094f, -0.03673488f, 0.01835719f, 0.16086185f, 0.02499104f, -0.14341186f, 
    -0.05662750f, -0.08393133f, 0.18237433f, -0.00056023f, 0.12165529f, 0.07255137f, -0.00954320f, -0.01344180f, 
    -0.07258799f, 0.11645859f, 0.08799929f, 0.20227484f, -0.03368260f, -0.06634830f, 0.05572118f, 0.02354277f, 
    -0.00873635f, 0.00673682f, 0.09616506f, 0.12519184f, 0.30950719f, -0.06044069f, 0.02016432f, 0.07399165f, 
    -0.02570257f, 0.00817074f, -0.00585274f, 0.08622185f, 0.04348629f, 0.09919634f, 0.00385401f, 0.10343149f, 
    -0.20855738f, -0.02352936f, -0.17652243f, -0.18838763f, 0.06450161f, -0.01679974f, 0.04193193f, -0.01405630f, 
    -0.03718475f, 0.03433021f, 0.07269210f, -0.02210325f, -0.18291646f, -0.11397481f, 0.06165671f, -0.06248983f, 
    0.11787239f, -0.09379024f, 0.07516703f, 0.04214787f, -0.12580456f, 0.08771182f, 0.08261417f, -0.03263909f, 
    0.11775481f, -0.03946293f, 0.01496256f, 0.02361145f, -0.04989322f, 0.01440170f, -0.01057984f, -0.03991270f, 
    0.03633504f, -0.12582630f, 0.06851625f, 0.05387565f, 0.28275955f, -0.17325272f, -0.13062634f, 0.37594679f, 
    0.05563964f, -0.02059406f, -0.08863764f, 0.08956046f, 0.08719666f, 0.01276079f, 0.03176864f, 0.07935934f, 
    -0.00214565f, 0.02631946f, 0.07121351f, -0.21265070f, -0.08013709f, -0.09621157f, -0.10588766f, -0.04664640f, 
    -0.05956949f, -0.03465106f, -0.04184317f, 0.05927458f, 0.30599678f, -0.10107429f, 0.14611094f, 0.08066930f, 
    -0.03460198f, 0.02706068f, -0.06265483f, -0.10990871f, -0.10208814f, 0.07733249f, 0.04576787f, 0.01858077f, 
    0.00163489f, 0.11321563f, 0.07136740f, 0.09835171f, 0.02025877f, 0.11625113f, -0.10538327f, 0.03900472f, 
    0.06900407f, 0.07754615f, 0.09570289f, 0.02798603f, 0.04788036f, 0.03893794f, -0.12038984f, -0.28042224f, 
    0.24279004f, 0.03026766f, 0.01185160f, 0.01525647f, 0.16344737f, 0.08100274f, -0.06078123f, 0.07966195f, 
    -0.18005311f, -0.11766399f, 0.25007659f, -0.01908567f, -0.07443970f, 0.04265376f, -0.01573862f, 0.22591636f, 
    0.01929604f, -0.00117939f, -0.00765897f, -0.02088198f, 0.14680122f, 0.15297651f, -0.03417053f, -0.08442718f, 
    0.06943802f, -0.10399260f, 0.03098768f, 0.07983682f, 0.08457603f, 0.06744305f, -0.04427890f, 0.02367171f, 
    -0.17723189f, 0.04313041f, -0.14419542f, -0.01492838f, -0.14456210f, -0.07703499f, 0.07341567f, -0.00149020f, 
    0.07153291f, 0.09344598f, -0.00628873f, -0.01109316f, -0.18680046f, -0.01196582f, 0.12917738f, -0.25595436f, 
    -0.12919033f, -0.05706719f, -0.00998017f, 0.04512046f, -0.06795666f, 0.10937803f, 0.03231233f, 0.02927620f, 
    -0.01882882f, 0.09229939f, 0.17899501f, -0.17394358f, 0.02440865f, 0.05199924f, -0.02946285f, -0.10234567f, 
    0.09862815f, -0.12339150f, 0.04556178f, 0.05652001f, 0.00042939f, -0.00181695f, 0.11337267f, -0.14463440f, 
    0.00227388f, 0.01281455f, -0.01888605f, 0.04426670f, 0.04308546f, 0.05304830f, 0.17869766f, -0.05553114f, 
    0.03155303f, 0.03237089f, -0.23425591f, -0.05343574f, 0.03912532f, 0.12803641f, -0.05976931f, -0.00451461f, 
    0.04848682f, -0.02392079f, 0.15547359f, -0.02414876f, -0.02157137f, 0.21795458f, 0.00806078f, 0.09283869f, 
    0.02657763f, 0.07048724f, 0.05093939f, 0.04933984f, 0.05320305f, 0.02639773f, 0.06706480f, 0.14076480f, 
    -0.03545453f, -0.27040321f, -0.05243010f, 0.01688709f, -0.11862815f, 0.10507172f, 0.03384925f, 0.09188490f, 
    0.01920639f, -0.02371118f, -0.02718000f, 0.02500211f, -0.08673554f, -0.00280895f, 0.01775698f, -0.24774398f, 
    0.05635937f, 0.09801947f, 0.04455049f, 0.07828164f, 0.00540561f, 0.12763487f, -0.04139172f, 0.00465020f, 
    -0.11332041f, 0.03889194f, -0.02726886f, 0.18223044f, 0.03486850f, 0.06661249f, 0.02073482f, 0.02505455f, 
    0.05254086f, 0.05092439f, 0.05895325f, 0.10119015f, 0.03814400f, -0.10612149f, -0.19362947f, -0.08390491f, 
    0.09440095f, -0.00902078f, 0.01983512f, -0.10295362f, 0.09512519f, 0.01727357f, 0.04053751f, 0.02060565f, 
    0.24735609f, -0.09242748f, 0.02168612f, 0.12487339f, 0.00827659f, -0.07320011f, -0.06300300f, 0.02063694f, 
    -0.03785129f, 0.11410088f, 0.14200623f, 0.08145374f, 0.17160954f, 0.04109135f, -0.16265504f, -0.16049981f, 
    0.11198626f, -0.09506195f, -0.06164299f, 0.00993114f, 0.13298833f, 0.02858087f, 0.05277371f, -0.01673842f, 
    0.03016626f, -0.14941026f, -0.00113664f, -0.08205573f, -0.12172993f, 0.07527143f, -0.02274934f, 0.01860771f, 
    -0.06255518f, 0.00931554f, 0.13389480f, 0.17293036f, 0.13775943f, 0.04323833f, -0.09411529f, 0.09300826f, 
    0.13515022f, -0.03498217f, -0.00657468f, -0.03243618f, -0.01807252f, 0.10320325f, 0.01518863f, -0.04625120f, 
    0.24782155f, 0.02597388f, -0.04494475f, 0.22951983f, 0.14473499f, 0.00454983f, -0.04149985f, 0.01847012f, 
    0.20766342f, 0.06156219f, 0.03973874f, 0.10006182f, 0.11154814f, 0.03805620f, 0.05398177f, 0.04805122f, 
    0.08641461f, 0.00232953f, 0.03610072f, -0.08255840f, 0.01684985f, -0.06916109f, 0.04953785f, -0.02346039f, 
    -0.15692693f, -0.01247434f, -0.14455180f, 0.04683270f, -0.01340423f, 0.10434101f, -0.09588376f, 0.05192417f, 
    0.04913572f, -0.05652771f, 0.00535312f, -0.15745796f, 0.13175735f, -0.00011928f, 0.05955271f, 0.14996071f, 
    0.10047658f, 0.01276823f, -0.00980415f, 0.04344603f, 0.06992244f, 0.03622172f, 0.06909437f, 0.04898205f, 
    0.25745374f, 0.12621678f, 0.04101875f, 0.11260058f, 0.10586119f, 0.10365789f, -0.10906636f, -0.00723361f, 
    -0.02424046f, -0.02127503f, 0.00150682f, -0.01407713f, 0.05383131f, 0.01905644f, -0.00141995f, 0.11051828f, 
    -0.07003999f, -0.01561960f, -0.00108402f, -0.04209055f, -0.06606107f, 0.17871599f, -0.01900314f, 0.03399802f, 
    0.00851399f, -0.09612057f, -0.01529376f, 0.10361976f, -0.01825299f, 0.04536971f, -0.09195013f, 0.05402131f, 
    0.03165124f, -0.10539857f, 0.12415368f, -0.02440323f, 0.02672748f, 0.07158264f, -0.16743259f, -0.21614270f, 
    -0.08239917f, -0.12607548f, -0.10432313f, 0.12319238f, 0.07246096f, -0.07384797f, 0.02685398f, 0.14765017f, 
    -0.07665762f, 0.15291530f, 0.01541578f, -0.27540058f, -0.09445045f, -0.09990582f, -0.01329366f, 0.04474231f, 
    -0.02094515f, 0.00164423f, 0.15467991f, 0.08680554f, 0.04342198f, 0.11331368f, 0.03392827f, 0.03059197f, 
    0.06529216f, 0.08977934f, 0.10712905f, -0.03951210f, -0.00277883f, -0.04428322f, -0.06955457f, 0.04424062f, 
    -0.00730318f, -0.02217151f, -0.03982623f, -0.02339059f, 0.04517613f, 0.03624285f, -0.04410665f, 0.00185333f, 
    -0.00478232f, -0.03297288f, 0.03895180f, 0.03543713f, 0.02066404f, 0.00353155f, 0.01702860f, -0.00656541f, 
    -0.02710692f, 0.01713763f, -0.02364843f, -0.02252246f, -0.02157062f, 0.01046744f, 0.03928875f, -0.04754136f, 
    0.03443227f, -0.03424700f, -0.03554200f, -0.01272665f, 0.03729869f, 0.02948768f, -0.03692528f, -0.02635069f, 
    0.01889358f, -0.03428029f, -0.05121811f, 0.04216991f, 0.03529814f, -0.03686050f, -0.03848418f, -0.05584017f, 
    0.00475997f, -0.05488019f, 0.00041267f, 0.04198041f, 0.04414715f, -0.01587974f, -0.01813591f, 0.03995311f, 
    -0.03303573f, 0.04972861f, 0.00468201f, -0.04374887f, -0.04076279f, -0.02185987f, -0.03041378f, -0.05310242f, 
    0.04094778f, 0.02987728f, 0.00783480f, -0.04080759f, 0.00629692f, 0.04458876f, -0.00127047f, -0.01267191f, 
    -0.03498014f, 0.03833809f, 0.03299918f, 0.01794096f, -0.02939691f, -0.05222162f, -0.01172998f, -0.03105208f, 
    -0.05473361f, -0.05413339f, 0.03172777f, 0.01310645f, 0.02719767f, 0.01943081f, 0.04007436f, 0.02921118f, 
    -0.02339750f, 0.00185589f, 0.04099575f, -0.00154182f, 0.01290858f, -0.04173045f, 0.00269693f, -0.00713004f, 
    -0.02237493f, 0.00865387f, -0.05382828f, 0.01647851f, 0.03188964f, 0.02851453f, 0.01710820f, -0.01498716f, 
    -0.01751508f, -0.03916187f, 0.00890836f, -0.00740854f, -0.03772623f, -0.02874170f, -0.04888176f, 0.00124915f, 
    -0.04603424f, 0.01226981f, -0.02440122f, -0.04785410f, 0.03795076f, -0.00046298f, -0.01249505f, 0.00324704f, 
    -0.01676063f, -0.01868966f, -0.05588279f, -0.04201072f, -0.00125835f, 0.00288814f, -0.03563821f, 0.03929119f, 
    -0.04538232f, 0.02676986f, -0.00006713f, 0.01830553f, 0.03953242f, 0.00750942f, 0.01428363f, 0.01583091f, 
    0.02590084f, 0.03219818f, -0.05605114f, -0.01739396f, -0.04494393f, -0.03589441f, 0.04299319f, -0.04408776f, 
    -0.05389026f, -0.02941533f, 0.02108274f, -0.05171010f, 0.03025426f, 0.01491814f, -0.03564078f, 0.01819865f, 
    -0.01766652f, -0.00961427f, -0.03769957f, -0.01821363f, 0.03352091f, -0.01336302f, 0.01307289f, 0.00420060f, 
    0.00128882f, -0.00964320f, -0.01498299f, -0.03840073f, -0.03779414f, -0.05036735f, 0.01919051f, 0.01261007f, 
    -0.01319728f, -0.00788901f, -0.01585562f, 0.00182944f, -0.05281440f, -0.04086363f, 0.00207643f, 0.01440703f, 
    -0.01479238f, -0.01822851f, -0.00778955f, 0.01340745f, 0.03645408f, -0.02934378f, -0.00791493f, 0.02892972f, 
    -0.02781736f, -0.03222842f, -0.00605261f, 0.04591839f, -0.04323770f, 0.00558694f, 0.01390251f, -0.01729898f, 
    -0.03353706f, 0.03962325f, 0.03154643f, -0.00949466f, 0.01996941f, 0.03821236f, -0.05473011f, -0.05086696f, 
    -0.00922789f, 0.02858900f, -0.02309662f, -0.02922576f, 0.03589479f, 0.01093799f, 0.03733991f, 0.03632132f, 
    -0.03723580f, -0.00880680f, 0.01804579f, -0.02035964f, 0.00701181f, -0.02129085f, 0.02725019f, 0.03187661f, 
    -0.04386662f, -0.03521569f, -0.00122918f, 0.00262633f, 0.01779179f, 0.00902943f, -0.01730983f, 0.01676687f, 
    0.00419156f, -0.02509878f, -0.02098754f, 0.03859316f, -0.02137244f, -0.03187099f, 0.00848781f, 0.02889010f, 
    0.03714426f, -0.02150033f, 0.00063568f, -0.01267628f, 0.03024817f, -0.03414788f, 0.00910505f, -0.02324490f, 
    0.04188347f, 0.02982334f, 0.03659686f, -0.05302272f, 0.01276521f, 0.03633244f, 0.00359649f, -0.02237658f, 
    -0.00899177f, 0.03485939f, -0.03940319f, -0.03201398f, 0.02604910f, -0.01786840f, 0.03251120f, -0.05222394f, 
    -0.05449888f, -0.03378400f, -0.04613208f, 0.00110339f, 0.01216088f, -0.02254656f, -0.04342423f, -0.01667441f, 
    0.00621955f, 0.00331768f, -0.02881229f, 0.04137622f, -0.05128712f, -0.04155942f, 0.01950065f, 0.03018776f, 
    -0.00238791f, -0.00018742f, -0.02991710f, -0.03099754f, -0.02625322f, -0.05427587f, -0.05434186f, -0.04795411f, 
    -0.02626566f, -0.02236303f, 0.01639375f, -0.04916356f, -0.03178815f, -0.03251358f, 0.00719059f, -0.03730368f, 
    0.03659617f, 0.02537787f, 0.01274820f, -0.04074270f, -0.04111436f, -0.03257991f, -0.03166584f, -0.03094217f, 
    -0.01986285f, -0.01657517f, -0.03654289f, -0.01139340f, -0.00342416f, -0.02071489f, 0.03913777f, 0.01650041f, 
    0.00740552f, -0.00540058f, 0.00158933f, -0.04751443f, -0.03939035f, 0.03577773f, -0.03390274f, 0.03918763f, 
    -0.00159462f, -0.03700097f, -0.03541506f, -0.02178497f, -0.00877447f, -0.02786966f, -0.01908880f, 0.04250573f, 
    0.01493333f, -0.01925079f, -0.01285989f, -0.02543105f, -0.02671458f, 0.00393163f, -0.03880567f, 0.02096616f, 
    -0.04673782f, 0.02116365f, 0.01722403f, 0.02974280f, -0.00553529f, -0.01013341f, 0.03455222f, -0.03119959f, 
    -0.03013295f, 0.00558141f, 0.00767291f, -0.03134900f, -0.01522097f, 0.02408352f, -0.00587388f, 0.03107800f, 
    0.03943393f, -0.00531048f, 0.02856173f, -0.02399757f, -0.01156950f, -0.01788063f, -0.03913452f, -0.02020586f, 
    -0.00270927f, -0.01713043f, -0.00899533f, 0.02199000f, -0.05399811f, 0.02743933f, 0.03257813f, -0.02528048f, 
    0.00782728f, -0.00661244f, 0.02925473f, 0.03779726f, -0.04648662f, -0.04728505f, 0.04219737f, -0.02025956f, 
    0.02809481f, 0.01993214f, 0.03413721f, 0.00072329f, -0.00858467f, 0.04238886f, -0.04929059f, -0.04738516f, 
    0.00857120f, -0.01560816f, -0.01564056f, -0.05253318f, 0.02290443f, -0.01666375f, -0.03776484f, -0.02764775f, 
    -0.04873930f, -0.02430905f, -0.04914765f, -0.03659214f, -0.03398610f, -0.00263852f, -0.05561101f, -0.03292733f, 
    -0.05748165f, 0.01362726f, -0.00744193f, -0.01945320f, -0.02962761f, -0.01200371f, -0.00872357f, 0.03579139f, 
    0.00190031f, -0.02007075f, -0.00285282f, 0.02281729f, -0.00150337f, 0.03683306f, 0.02312022f, 0.01064654f, 
    0.01160400f, -0.00168026f, 0.01555775f, -0.00637290f, 0.00632756f, -0.05125011f, -0.04095854f, -0.05055356f, 
    0.00437462f, -0.00666404f, -0.01599278f, -0.02115502f, -0.01279826f, -0.01961007f, 0.02940743f, -0.04455661f, 
    0.00384606f, -0.03437698f, -0.01567793f, -0.04699001f, -0.00777098f, 0.00190448f, -0.00851962f, 0.04212213f, 
    -0.02842467f, -0.03185749f, -0.02494626f, 0.03114334f, -0.03479152f, 0.01502220f, 0.03344811f, 0.03047338f, 
    -0.03929589f, -0.01412862f, -0.01484422f, -0.02572599f, 0.04613756f, -0.02312541f, 0.03478293f, -0.02191607f, 
    0.00784056f, -0.03888228f, 0.00603995f, -0.03219149f, 0.01774932f, -0.00779488f, 0.03519345f, -0.04325113f, 
    -0.02141364f, -0.02351932f, 0.04642347f, -0.00358749f, -0.04615650f, -0.02783077f, -0.00941581f, -0.00399405f, 
    0.02081755f, 0.03329925f, -0.01618705f, 0.01532706f, 0.03144027f, 0.03034405f, -0.02111500f, 0.00102470f, 
    -0.00511611f, 0.01112353f, -0.03566306f, -0.05801046f, 0.03265508f, -0.02293191f, 0.04250960f, -0.01581650f, 
    0.02467541f, 0.04197077f, 0.03260131f, 0.03786876f, -0.02290058f, 0.01092171f, -0.03804282f, 0.02988016f, 
    -0.00594887f, -0.05565565f, -0.05429693f, -0.00972898f, -0.01323281f, -0.02322870f, -0.03073799f, 0.03811301f, 
    0.01034170f, -0.05256644f, -0.02574355f, 0.01468441f, -0.02209926f, -0.04873377f, 0.00808224f, 0.03843974f, 
    0.01948621f, 0.03540986f, -0.00995078f, 0.01586785f, -0.02230959f, -0.00713096f, -0.04544484f, 0.02867819f, 
    0.02231137f, 0.03073605f, -0.02200252f, 0.00937591f, -0.00607779f, -0.03084898f, -0.01033412f, -0.01067488f, 
    -0.05103500f, -0.04033183f, 0.00143404f, -0.00585839f, 0.03414936f, -0.00490448f, -0.00969516f, 0.00837307f, 
    -0.01196852f, 0.04082904f, -0.05607824f, 0.02402940f, 0.02651940f, -0.02484705f, -0.02726280f, 0.03484277f, 
    -0.05422973f, 0.01531210f, 0.02243050f, -0.02931490f, 0.00764770f, -0.00444992f, 0.00265906f, -0.03026642f, 
    0.02174499f, -0.00350670f, -0.02198297f, -0.04347660f, 0.03349951f, 0.04070280f, 0.01020383f, 0.04071172f, 
    0.01870506f, -0.04239782f, 0.04761378f, -0.05482429f, 0.00938728f, -0.02528473f, -0.02363325f, 0.04628246f, 
    0.02453091f, 0.02815498f, -0.00810718f, 0.01737403f, 0.04207497f, 0.00612807f, 0.00640459f, -0.02773742f, 
    -0.00464631f, -0.04134100f, -0.04419351f, -0.01567344f, 0.04039953f, -0.02322170f, -0.03018295f, -0.00003829f, 
    -0.00038595f, -0.03078707f, 0.02328429f, 0.02749197f, 0.03930801f, -0.03873343f, 0.02589004f, 0.03188558f, 
    -0.00531903f, -0.03297443f, 0.02169389f, -0.01308933f, -0.04181274f, 0.04507896f, -0.02196028f, -0.01753725f, 
    -0.04210932f, -0.00852378f, -0.04350227f, -0.04776130f, -0.04717071f, -0.04511473f, -0.02850676f, -0.04443112f, 
    0.00299660f, -0.01689583f, -0.01167274f, -0.03068325f, 0.02553222f, -0.05517615f, 0.04124549f, 0.00915972f, 
    0.02879191f, 0.02111768f, -0.00475989f, 0.01652096f, -0.00676892f, -0.02102551f, -0.01603106f, 0.04161078f, 
    -0.01395411f, -0.01203863f, -0.03285908f, -0.02812524f, -0.03149145f, -0.03078014f, -0.05949305f, -0.02358135f, 
    0.00222603f, 0.03686060f, -0.01317038f, 0.03541749f, -0.00706554f, 0.01654021f, 0.02283855f, 0.02601728f, 
    0.01193079f, 0.03270137f, -0.04033073f, 0.02612896f, 0.02684764f, -0.04196040f, -0.04917350f, 0.04453399f, 
    0.04671058f, -0.00549655f, -0.03386629f, -0.01397475f, 0.00509719f, 0.00144605f, 0.00044951f, -0.04310773f, 
    -0.03669219f, -0.00432718f, -0.03863474f, 0.01789410f, 0.00596950f, -0.03268860f, -0.02834589f, -0.00908307f, 
    -0.03347556f, 0.02478104f, -0.02909746f, -0.02233054f, 0.03738008f, -0.04375040f, -0.02685034f, -0.02382199f, 
    -0.04967714f, 0.04868347f, -0.02847588f, 0.02117838f, 0.01706230f, -0.00536473f, -0.02250250f, -0.00648480f, 
    -0.03627770f, -0.05089126f, -0.05457092f, -0.00317835f, 0.04175154f, -0.03057953f, -0.01686920f, 0.03804929f, 
    -0.00579916f, -0.03283869f, -0.04895224f, 0.01365275f, -0.00277628f, 0.01679827f, -0.03254267f, 0.02782662f, 
    0.00839506f, -0.04544125f, 0.02111387f, 0.03715549f, 0.01272400f, -0.02979181f, -0.04055934f, 0.03089745f, 
    -0.02063935f, -0.03913759f, -0.00913187f, -0.00922092f, -0.03155467f, -0.00382800f, 0.02386936f, -0.00928277f, 
    -0.01876880f, 0.01750737f, 0.03763536f, 0.01311675f, 0.02553761f, 0.04585185f, -0.00368564f, 0.01708811f, 
    0.04218144f, 0.02055167f, -0.01590660f, -0.01961438f, 0.04369180f, 0.02948727f, -0.04892907f, -0.02867260f, 
    -0.03875769f, -0.00913362f, -0.03745478f, 0.02945459f, 0.02382753f, -0.04445251f, 0.01198110f, -0.04201950f, 
    0.01429600f, -0.02031423f, 0.04398020f, 0.03630500f, -0.00748307f, 0.00543942f, 0.00621447f, 0.03171854f, 
    -0.00815417f, 0.01787564f, 0.04059564f, -0.01497130f, 0.00420750f, 0.01783303f, -0.03841699f, -0.04297849f, 
    -0.03844733f, -0.05572986f, -0.03884885f, -0.02915402f, -0.03268277f, -0.00881049f, -0.01704220f, -0.05067836f, 
    -0.03979867f, 0.01337350f, -0.03489998f, 0.02332977f, 0.00274946f, 0.04720680f, 0.02286284f, 0.00027548f, 
    -0.03267824f, -0.04560816f, 0.00824944f, 0.00755536f, -0.02643426f, -0.04439471f, -0.04226608f, 0.01570292f, 
    0.01444997f, -0.02635525f, 0.02889192f, -0.03163436f, -0.04620768f, -0.04050467f, -0.00426797f, -0.00838467f, 
    -0.02806647f, 0.03512127f, -0.03530968f, 0.02089311f, 0.03896572f, -0.00317016f, -0.01173523f, -0.01231553f, 
    -0.04162207f, -0.04544512f, -0.00950207f, 0.00758041f, -0.04386188f, 0.03462276f, 0.01271555f, 0.00088840f, 
    0.00066527f, 0.03913558f, -0.01887025f, 0.02580399f, -0.04143754f, 0.03073220f, 0.00161094f, -0.00133505f, 
    -0.02571715f, -0.05141916f, -0.01107718f, -0.02264705f, -0.05384842f, 0.01548713f, 0.03959791f, -0.04315005f, 
    0.00942024f, 0.02197206f, 0.05160347f, -0.03645049f, -0.04797217f, -0.00842305f, -0.04597600f, 0.02381306f, 
    -0.02081986f, -0.03719943f, -0.01763738f, 0.01620863f, 0.01191790f, 0.01066399f, -0.00952361f, 0.02422772f, 
    -0.04193188f, -0.00239358f, 0.00091373f, -0.02700336f, -0.06244725f, -0.04299612f, -0.00646973f, 0.03093508f, 
    -0.04757822f, -0.00606127f, 0.05175594f, -0.02442005f, 0.05068415f, -0.01888063f, -0.01285738f, -0.02404503f, 
    0.02078238f, 0.02696902f, -0.02512667f, 0.03781963f, -0.02921477f, -0.03224472f, 0.02076960f, -0.02812531f, 
    -0.04095575f, -0.03102744f, 0.03576239f, 0.01283732f, -0.00055930f, 0.00021462f, -0.02806919f, 0.04335873f, 
    -0.02245186f, -0.03703730f, -0.02973027f, -0.04012007f, -0.05024847f, 0.01675892f, -0.04362232f, -0.01558252f, 
    0.00508256f, 0.00783766f, 0.01811134f, 0.02672984f, 0.03955885f, -0.00489477f, 0.00182741f, 0.03588895f, 
    0.01229174f, -0.05170596f, -0.00997870f, -0.00935351f, -0.00630964f, -0.01395527f, 0.01197543f, -0.03308421f, 
    -0.00857665f, 0.02855770f, -0.00256704f, 0.00383657f, -0.03558814f, 0.01237046f, 0.02605444f, 0.02017872f, 
    -0.02266688f, 0.01376897f, -0.05038515f, 0.00153209f, 0.03579296f, 0.04478081f, -0.03408810f, -0.05313684f, 
    -0.02477288f, -0.01837175f, 0.01012298f, -0.04793740f, -0.01443739f, 0.03327821f, -0.00557700f, 0.02770652f, 
    -0.02956556f, 0.03815748f, -0.06031840f, -0.02957513f, 0.03577632f, 0.01044002f, 0.02078514f, 0.00579342f, 
    0.03883933f, 0.00410721f, 0.03408901f, 0.00129219f, -0.01693118f, 0.01250884f, -0.04885137f, -0.03639038f, 
    0.00636999f, -0.02170215f, -0.03996190f, -0.02632922f, 0.03044168f, 0.02478655f, -0.03633492f, 0.00168820f, 
    -0.03658886f, -0.04670119f, -0.00211652f, 0.04887551f, -0.01564781f, -0.04734363f, -0.03617506f, 0.01997265f, 
    -0.03144844f, -0.05252305f, -0.01844641f, -0.04205830f, -0.05002971f, -0.01995740f, 0.02865352f, -0.03769534f, 
    -0.04048119f, -0.03911284f, 0.00435896f, -0.02156696f, -0.05299475f, 0.02668209f, 0.02122568f, 0.02407139f, 
    0.04660868f, -0.03812435f, -0.03279132f, 0.05027108f, -0.00273091f, 0.02802938f, 0.00706218f, 0.02690178f, 
    -0.04085472f, 0.02905322f, -0.04634503f, -0.00095296f, 0.00659080f, -0.00119897f, -0.05515251f, -0.01944678f, 
    -0.03161521f, 0.01700248f, 0.03338599f, -0.01920621f, -0.04133497f, 0.00966347f, -0.02507575f, -0.00153292f, 
    -0.00058428f, 0.04614478f, -0.00066346f, 0.02906508f, -0.02911034f, 0.04316085f, 0.04681234f, -0.02839454f, 
    -0.03071962f, -0.00150596f, 0.01258694f, -0.00288276f, -0.01165419f, 0.01350846f, 0.01083665f, 0.02987874f, 
    0.00516401f, -0.03443591f, -0.00998275f, 0.00623546f, -0.04137769f, 0.03581829f, 0.02451684f, 0.01549596f, 
    -0.04715167f, 0.04370243f, 0.01158897f, -0.04556424f, 0.04783420f, 0.00781708f, 0.02071219f, -0.01679903f, 
    -0.05014113f, -0.01074607f, 0.01508516f, 0.00760478f, 0.02603258f, 0.04230416f, 0.04290652f, -0.00238498f, 
    0.01278276f, -0.05271525f, 0.03239046f, -0.04856985f, -0.05299557f, -0.03765087f, 0.03506896f, -0.04600769f, 
    0.02891525f, -0.03962253f, 0.03402967f, 0.05094435f, 0.00789848f, -0.05018765f, 0.02091471f, -0.04520601f, 
    0.02457963f, 0.03769249f, -0.00297749f, -0.00510154f, -0.04858325f, -0.04417758f, -0.03469061f, 0.03949843f, 
    0.03604897f, -0.05034794f, 0.03889182f, -0.03803962f, -0.03081542f, 0.01284255f, 0.00620531f, 0.01572767f, 
    0.01214768f, 0.01309850f, -0.02748931f, -0.05186636f, 0.02293571f, 0.02362842f, 0.03307531f, -0.01563340f, 
    0.02344803f, 0.00713036f, -0.04770480f, -0.04110175f, 0.01518375f, -0.04029936f, -0.03372072f, -0.04947249f, 
    0.02226525f, 0.01010311f, -0.00042109f, -0.05570183f, 0.01284266f, 0.04017904f, 0.02282316f, -0.04974087f, 
    0.00188618f, 0.03118200f, 0.03746508f, -0.03916271f, -0.03603530f, 0.01918455f, -0.01378639f, 0.01121566f, 
    0.04106899f, 0.00745651f, 0.02436396f, 0.01386242f, 0.01385272f, -0.00345511f, -0.00326953f, -0.03672519f, 
    -0.00388523f, 0.01689922f, -0.01504943f, -0.05496215f, -0.04603775f, -0.00235324f, -0.02308919f, -0.00036323f, 
    -0.04096213f, -0.03733538f, 0.01429547f, 0.01854284f, -0.04024185f, 0.00915339f, -0.04898534f, -0.05316488f, 
    0.01691323f, 0.00612596f, 0.00140686f, -0.02280808f, -0.05207854f, 0.04010671f, -0.02118596f, -0.02602019f, 
    -0.03986943f, -0.04739439f, -0.04881271f, 0.03176502f, -0.02319328f, 0.03939550f, -0.00156759f, 0.02493071f, 
    -0.01311479f, 0.01740470f, 0.03408383f, -0.01208809f, -0.02475372f, -0.03113726f, 0.03568825f, -0.05392480f, 
    0.01095432f, -0.00828353f, 0.01661078f, 0.00737559f, 0.02678229f, -0.05714815f, -0.03564595f, -0.00785554f, 
    -0.00041165f, 0.02352684f, 0.02772459f, -0.04494926f, 0.01463327f, -0.02058074f, -0.01005453f, -0.04170696f, 
    0.02985314f, -0.03278062f, -0.03518655f, -0.04067509f, -0.02742110f, -0.02926722f, 0.02602929f, 0.03369844f, 
    -0.02945718f, -0.02474476f, -0.04019580f, -0.02339032f, 0.04500995f, 0.00498106f, 0.02076893f, -0.00268302f, 
    0.48338157f, -0.02089941f, 0.03287085f, 0.06741248f, -0.15592895f, -0.00978876f, 0.08285367f, -0.06515545f, 
    0.01680129f, -0.01934895f, 0.00194942f, -0.05661874f, 0.37386709f, -0.12933803f, -0.13916790f, -0.00093030f, 
    0.01045932f, -0.01195982f, -0.06074689f, 0.02074651f, 0.05421703f, 0.04024084f, 0.05721106f, 0.10231080f, 
    0.23902740f, 0.11018337f, -0.00586739f, -0.06575613f, -0.15524396f, -0.04087212f, -0.07623155f, -0.03348033f, 
    0.05207753f, 0.04409612f, 0.00275839f, 0.04434831f, 0.19742385f, 0.09730219f, 0.02510874f, 0.02662325f, 
    0.01782425f, 0.01847329f, -0.03665753f, -0.03935741f, -0.01443614f, 0.06293581f, 0.01085663f, 0.11106839f, 
    0.10853174f, 0.08451890f, 0.01822369f, 0.23485456f, 0.12609525f, 0.00974892f, 0.00625177f, -0.09871458f, 
    0.01354070f, 0.09742811f, 0.03653242f, 0.03204701f, 0.28605309f, -0.00883754f, -0.07537994f, -0.15369423f, 
    0.10894931f, -0.04642139f, -0.00228492f, 0.05824956f, 0.10666647f, 0.08253919f, -0.01702160f, 0.08137014f, 
    -0.03403110f, 0.06878664f, 0.16462667f, -0.02324415f, -0.07931683f, -0.00698858f, 0.01163378f, 0.20262595f, 
    -0.06413464f, -0.02119313f, -0.06582235f, 0.10286088f, -0.09221362f, -0.07734402f, -0.11229148f, -0.27681828f, 
    0.21115068f, -0.02945452f, 0.00782220f, -0.02583120f, 0.01641424f, 0.02561524f, -0.10714827f, 0.05941015f, 
    -0.26622632f, 0.04456580f, -0.10492437f, 0.07727515f, -0.10078441f, -0.05437671f, 0.05043425f, -0.02734909f, 
    0.10772541f, 0.04950740f, 0.00818497f, -0.06838091f, -0.29062670f, 0.10988808f, 0.07225999f, 0.03800777f, 
    -0.13174590f, -0.12055021f, 0.03774344f, 0.05957133f, 0.01018974f, 0.07899775f, 0.06793727f, 0.01038494f, 
    0.04066113f, 0.13778125f, 0.07004776f, -0.16960865f, -0.05160684f, 0.00717769f, -0.02174746f, 0.00383345f, 
    0.05261032f, -0.11812840f, 0.17856956f, 0.02806614f, -0.12170082f, 0.16681240f, 0.03321619f, -0.16520701f, 
    0.04741339f, 0.06309091f, 0.00448143f, 0.06636172f, -0.06244810f, -0.02009604f, 0.03962099f, -0.00770344f, 
    0.32549673f, 0.12770838f, -0.22678697f, -0.05393624f, 0.02099895f, 0.09053682f, -0.10752746f, -0.02486500f, 
    0.01161069f, 0.00143210f, 0.14821246f, -0.06163315f, -0.14257988f, 0.21134639f, 0.11672526f, 0.10277974f, 
    -0.11657950f, -0.08675889f, 0.11512397f, 0.12065329f, 0.05271111f, -0.05014208f, -0.04999959f, 0.03269365f, 
    -0.18508539f, -0.14869976f, -0.07526597f, -0.01776418f, 0.02095545f, 0.03346728f, 0.09570055f, 0.06678255f, 
    -0.03339804f, 0.00720649f, -0.02067722f, -0.10048061f, -0.10244294f, -0.03457480f, 0.01780559f, -0.00896379f, 
    0.15740126f, 0.11126342f, 0.00942347f, 0.15198810f, 0.05169812f, 0.11741861f, -0.10428292f, 0.02254598f, 
    -0.22748281f, 0.09085345f, -0.01555116f, -0.09073722f, 0.00862861f, 0.03317060f, 0.02741883f, -0.03069964f, 
    0.05316635f, 0.01649431f, -0.00057570f, -0.01843185f, -0.03805346f, -0.04092563f, -0.15941927f, -0.05612532f, 
    0.09953213f, -0.02749358f, -0.08886173f, -0.06590921f, -0.04805627f, 0.02239137f, -0.01890543f, 0.07016397f, 
    0.18589067f, -0.14967100f, -0.08661535f, -0.09442078f, 0.06203877f, -0.02597428f, -0.06130048f, 0.03718125f, 
    0.01588997f, 0.05162907f, 0.10932358f, -0.03981028f, 0.20435248f, 0.06959683f, -0.16939068f, -0.02165526f, 
    0.11508490f, -0.00419984f, 0.04112144f, 0.08346592f, -0.03708538f, 0.01109439f, -0.01067987f, -0.03637683f, 
    0.01035902f, -0.05271694f, -0.02453659f, 0.06447670f, -0.08664073f, 0.04245711f, -0.01555603f, 0.01947991f, 
    0.00302327f, 0.08286422f, 0.06608049f, 0.08928298f, 0.09725935f, -0.07033049f, -0.13356096f, 0.20242178f, 
    0.07919915f, -0.11213573f, -0.00223640f, -0.01767844f, -0.04860063f, 0.05007623f, -0.05593862f, 0.04815622f, 
    0.21481057f, 0.09943864f, -0.03961574f, 0.10117032f, 0.20393842f, 0.13303679f, 0.00604147f, 0.15943156f, 
    0.07803404f, -0.02550965f, 0.09130683f, 0.03744014f, -0.08908895f, -0.07079282f, 0.02634636f, -0.21429975f, 
    0.11579849f, 0.11038392f, -0.01117442f, -0.07672641f, 0.00261917f, -0.01386693f, 0.08296011f, -0.05500501f, 
    -0.23265739f, 0.00674011f, -0.10423312f, -0.12682328f, 0.02787259f, 0.04288492f, -0.08354050f, -0.05752093f, 
    -0.02098121f, -0.04585881f, -0.06986960f, -0.14145240f, 0.00483351f, -0.02922627f, 0.00213041f, -0.08670286f, 
    0.10662653f, 0.06371582f, -0.06537514f, 0.04726404f, -0.00638021f, 0.03133479f, 0.00694178f, 0.20204763f, 
    0.18687560f, -0.09687915f, 0.06751209f, 0.19347481f, 0.10861810f, 0.02906268f, -0.00613114f, -0.02994849f, 
    -0.07161284f, -0.02430720f, -0.00185046f, -0.09141795f, -0.11889479f, 0.08675469f, 0.02132528f, -0.01106561f, 
    -0.05696339f, -0.01094117f, -0.01590038f, -0.05238050f, 0.03936592f, 0.10023285f, 0.02885721f, 0.08215176f, 
    -0.35092112f, -0.03817792f, -0.00053778f, 0.03609086f, -0.01137310f, 0.00836278f, -0.03051784f, 0.01992551f, 
    0.04515806f, -0.00571385f, 0.13347465f, -0.00038734f, 0.27354789f, -0.05086670f, -0.21590781f, 0.06146345f, 
    0.00455389f, -0.05291881f, -0.01352941f, 0.09900600f, 0.04535212f, -0.04325389f, 0.06237437f, 0.07951751f, 
    0.08650403f, 0.17402086f, 0.09468336f, -0.14948224f, -0.00799435f, -0.03245109f, -0.03215789f, 0.05305006f, 
    0.04102809f, -0.07716738f, 0.04549352f, 0.09548228f, 0.21646439f, 0.02558005f, -0.04642964f, 0.05069018f, 
    0.03543877f, 0.12366506f, 0.07520253f, 0.12946422f, 0.00500443f, -0.02794069f, -0.09215841f, 0.05114485f, 
    -0.16666967f, -0.03532283f, -0.17542528f, 0.03073266f, 0.08506490f, -0.08310023f, -0.00981336f, 0.07036250f, 
    -0.00426461f, 0.06517612f, 0.00605942f, -0.13565767f, 0.12796822f, -0.14390977f, 0.00167435f, 0.10148457f, 
    -0.00766352f, 0.08622077f, 0.07060205f, 0.06522547f, -0.01232212f, 0.03398022f, -0.03085920f, 0.18480459f, 
    -0.06248246f, -0.09297217f, -0.09936857f, -0.12445743f, -0.09004550f, 0.02376180f, 0.04218654f, -0.00683660f, 
    0.07255971f, 0.07605711f, -0.01222078f, 0.15467215f, -0.00397515f, -0.09951985f, -0.03170015f, -0.03653241f, 
    0.10199051f, 0.06079073f, -0.10924906f, -0.11423668f, -0.04433195f, -0.06158073f, 0.09108122f, 0.16008705f, 
    0.14022134f, -0.07915322f, 0.26728687f, 0.10478951f, 0.08081429f, 0.05994176f, 0.13227291f, -0.03774790f, 
    -0.02344980f, 0.00265266f, 0.08198924f, -0.00095873f, -0.04389722f, 0.00751828f, 0.10347962f, -0.04470452f, 
    -0.00724493f, 0.09819034f, 0.08562633f, 0.01464255f, -0.05808279f, 0.03246254f, -0.00591776f, -0.04205033f, 
    0.11639415f, 0.09433040f, 0.14660615f, -0.04938661f, 0.00274949f, 0.06114724f, 0.10170383f, -0.01576703f, 
    -0.00534366f, 0.03245181f, 0.01268079f, 0.08164383f, 0.44883549f, 0.20196766f, -0.14750578f, -0.33728233f, 
    -0.02994525f, -0.09581280f, 0.02784855f, 0.11495746f, 0.08387565f, -0.06551243f, 0.01218380f, 0.06141584f, 
    0.14058095f, -0.26482716f, 0.00217987f, -0.11043329f, -0.05593307f, -0.05885759f, 0.00126860f, -0.02057716f, 
    -0.00647125f, 0.02657307f, 0.07161628f, 0.02421875f, 0.06414945f, -0.20565218f, -0.07387653f, -0.16022703f, 
    -0.18828841f, -0.08784741f, -0.11355712f, 0.05594265f, -0.09599187f, 0.01174887f, -0.00376498f, 0.10095476f, 
    0.21336260f, -0.06676734f, 0.01345004f, -0.03227139f, 0.06423222f, 0.01406246f, 0.05781505f, -0.06691337f, 
    0.00871530f, -0.07608391f, 0.19307880f, -0.01531697f, 0.18503588f, 0.00198827f, 0.01669336f, 0.06718148f, 
    0.02144780f, 0.06159012f, 0.10175430f, 0.03123962f, 0.10334186f, 0.10572286f, 0.03942328f, -0.02498453f, 
    -0.11115514f, -0.15749767f, -0.13626385f, 0.02798698f, 0.07183439f, 0.07134029f, -0.03551765f, 0.02419504f, 
    0.00593359f, -0.01180976f, 0.08775046f, -0.06392676f, -0.07717843f, 0.08070766f, 0.04564781f, 0.09507100f, 
    0.01889914f, 0.06716499f, -0.04635055f, -0.00484635f, -0.03254278f, 0.00183307f, -0.03707669f, 0.06316413f, 
    0.10593233f, -0.35673693f, -0.05753338f, -0.13168916f, 0.03585412f, 0.03795106f, 0.17381881f, 0.18299070f, 
    0.04513207f, 0.02481718f, -0.02425268f, 0.04026435f, -0.20256457f, -0.08059069f, -0.12774006f, 0.10650265f, 
    -0.08064448f, -0.00992342f, 0.08177429f, 0.11938315f, -0.03739006f, -0.05892912f, 0.08116855f, -0.03538014f, 
    -0.09085963f, 0.22746980f, 0.06323107f, -0.03264363f, -0.11450900f, 0.09103355f, 0.08251115f, 0.04524966f, 
    0.02535257f, 0.03336011f, -0.02861321f, 0.17074332f, 0.03457460f, -0.09572204f, 0.02514499f, 0.08075650f, 
    -0.00563747f, 0.09411220f, -0.00792379f, 0.01224336f, 0.00427147f, 0.08355805f, 0.15569191f, 0.12475246f, 
    0.02474293f, -0.02471472f, 0.10132450f, -0.01888955f, 0.03491421f, 0.01274437f, -0.00099793f, 0.07966406f, 
    -0.02829566f, 0.01601073f, 0.12072736f, 0.05645755f, 0.20224738f, -0.10973413f, 0.07817198f, -0.04209341f, 
    -0.03760116f, -0.02569262f, -0.01873168f, -0.04972800f, 0.06207689f, -0.15090233f, -0.13240205f, -0.02595268f, 
    0.08031961f, -0.23821929f, 0.00111646f, -0.11140595f, -0.01062683f, 0.09991696f, -0.07725319f, 0.11938959f, 
    -0.07982762f, 0.20632882f, 0.09389225f, -0.00124079f, 0.23578370f, 0.18903801f, 0.05549450f, 0.04849344f, 
    -0.05960013f, 0.04983072f, -0.03139674f, 0.02362172f, -0.08134792f, -0.04396775f, -0.00514368f, -0.08317158f, 
    0.24259970f, -0.04880306f, 0.01664755f, -0.08096414f, -0.00929216f, -0.08813158f, 0.07353235f, -0.00644165f, 
    0.16304547f, 0.08458696f, 0.05279067f, 0.15373226f, 0.06685487f, 0.10181145f, -0.02463558f, -0.01342196f, 
    0.05923659f, 0.08526587f, 0.15013237f, 0.05807041f, -0.01018228f, 0.14173400f, -0.04599793f, -0.02534406f, 
    -0.06538658f, 0.09761781f, 0.00904956f, -0.06669699f, 0.12807873f, 0.07117177f, 0.03403080f, -0.01261568f, 
    -0.10052470f, -0.13519253f, -0.17972669f, -0.08216838f, 0.05593546f, 0.09076113f, 0.07273733f, 0.04648393f, 
    0.03612421f, -0.02334035f, 0.07365118f, 0.02251602f, 0.06773243f, -0.02228612f, 0.09616593f, -0.09825333f, 
    0.05532493f, -0.05941640f, 0.10907087f, 0.01699284f, 0.17292649f, 0.06819285f, -0.06276137f, -0.13191658f, 
    0.00324752f, 0.00684538f, -0.00753589f, -0.14778663f, 0.10919687f, -0.04686747f, -0.07978120f, -0.07630767f, 
    -0.01906489f, 0.00161892f, -0.04606513f, 0.13346109f, -0.08998964f, 0.11719943f, -0.03421858f, -0.01858644f, 
    0.18365274f, 0.05270840f, 0.12810118f, 0.07357854f, -0.02433119f, -0.01155042f, 0.16844571f, 0.07546866f, 
    0.01663764f, 0.01010866f, 0.10433127f, 0.04537694f, -0.16697587f, -0.09673838f, 0.04318833f, -0.08877924f, 
    -0.22221890f, 0.02114981f, 0.14121252f, -0.02871958f, 0.04704018f, -0.03902940f, 0.08799599f, 0.22500978f, 
    -0.15312730f, -0.02775670f, -0.17604338f, -0.01752921f, -0.06819249f, -0.15554196f, -0.05066880f, 0.00714271f, 
    -0.06282763f, 0.06400868f, 0.17370062f, 0.02916403f, 0.04490659f, 0.04004382f, 0.19014467f, 0.03047069f, 
    0.06014863f, -0.00406554f, 0.02632003f, -0.03478597f, 0.00510078f, 0.02201523f, 0.16043702f, 0.14616671f, 
    -0.11647008f, 0.06298379f, 0.08047210f, 0.05477414f, -0.20576616f, -0.10879868f, 0.01099170f, -0.02798139f, 
    0.03610527f, -0.13847674f, 0.04193981f, -0.06880040f, 0.12640879f, -0.11007293f, -0.08474580f, 0.15939865f, 
    0.02627609f, 0.01755190f, 0.07511760f, 0.07360076f, 0.02291446f, 0.00230342f, 0.02887846f, 0.17357896f, 
    -0.00512818f, 0.03634210f, -0.07709799f, -0.08162294f, -0.17578162f, -0.11408011f, -0.17440806f, -0.01453864f, 
    0.01645837f, -0.00156576f, 0.03296831f, 0.09767944f, -0.03080929f, -0.06402599f, 0.13056891f, -0.09239344f, 
    -0.03331723f, -0.01993683f, -0.07183070f, -0.08358271f, -0.04640423f, -0.13056432f, 0.09115095f, -0.03295580f, 
    0.23931868f, 0.05642321f, -0.12729055f, 0.00579927f, 0.04316253f, -0.00072831f, 0.00124238f, -0.04074144f, 
    0.02097004f, 0.09412756f, -0.00035739f, 0.07547437f, 0.19442227f, 0.00939336f, -0.04467700f, -0.08361972f, 
    0.13391581f, -0.05183931f, 0.02937502f, 0.06659326f, 0.10431545f, 0.07034281f, -0.00358960f, 0.02470964f, 
    0.20485018f, 0.02897259f, -0.03235636f, -0.08058546f, 0.01874295f, -0.05024422f, 0.01193092f, 0.11661223f, 
    0.03763201f, 0.06963428f, -0.10428947f, 0.03185071f, 0.03768221f, -0.19179524f, 0.14538817f, 0.25521696f, 
    0.15195292f, 0.09427840f, -0.02159291f, -0.01647212f, 0.13712662f, 0.09786402f, 0.13204862f, 0.02485605f, 
    -0.15170802f, 0.10632747f, -0.01989917f, -0.07691887f, -0.19732989f, 0.05764078f, 0.08832277f, 0.01627656f, 
    0.07392130f, 0.09087578f, 0.06160961f, -0.07773974f, 0.22184914f, -0.03993617f, 0.07845287f, -0.24333991f, 
    -0.19146515f, -0.04609293f, -0.09129424f, 0.05360040f, 0.01395936f, -0.06049142f, -0.02645246f, 0.02575285f, 
    -0.23762421f, -0.14201424f, 0.04508663f, -0.12559171f, -0.06587644f, 0.09840018f, -0.09039655f, 0.02420736f, 
    0.02046926f, -0.07751333f, -0.01219369f, 0.06154377f, -0.15809301f, -0.05189563f, 0.05224680f, 0.13625036f, 
    0.06111350f, 0.11558781f, 0.00390245f, 0.02621021f, 0.10844942f, 0.04268111f, -0.01495696f, -0.06410939f, 
    -0.08691005f, 0.16826490f, 0.01476510f, -0.08865850f, 0.08926885f, 0.09424970f, 0.02747809f, 0.02072348f, 
    -0.05558756f, 0.01533457f, -0.04819934f, -0.02514719f, -0.20206776f, 0.07683551f, -0.02143631f, -0.08864430f, 
    -0.01581434f, 0.01871076f, -0.08906332f, 0.05962867f, -0.03669585f, -0.00654699f, -0.02708467f, 0.14066428f, 
    -0.01167283f, -0.16768526f, 0.00212391f, 0.05992871f, -0.09787748f, 0.06970312f, 0.02406008f, 0.14502344f, 
    -0.06528986f, 0.00661802f, -0.08682583f, -0.04502238f, -0.36156711f, 0.38518900f, -0.02537402f, -0.14090545f, 
    -0.02761778f, 0.05042176f, 0.15194738f, 0.05184792f, 0.00451826f, -0.01046942f, -0.03096900f, 0.01231522f, 
    0.05669451f, 0.12489294f, -0.12697291f, 0.12582734f, 0.04384693f, -0.08480036f, -0.03175936f, 0.07317724f, 
    0.05242653f, -0.01074334f, 0.09885529f, 0.15077564f, 0.20739102f, 0.16956034f, 0.00022682f, -0.10171763f, 
    -0.09986284f, -0.04374195f, -0.01974405f, 0.06802525f, 0.05472374f, 0.11211525f, 0.13215597f, 0.15782429f, 
    0.16214556f, -0.15324764f, -0.01592497f, 0.09559428f, -0.03744338f, -0.05528281f, 0.07729641f, 0.06050524f, 
    -0.05887956f, 0.12739056f, 0.14221327f, 0.04682294f, 0.27288729f, -0.00526900f, 0.10634456f, -0.02310400f, 
    0.15365760f, 0.01178498f, -0.08776132f, 0.03431641f, 0.07171620f, -0.08545599f, 0.00312234f, -0.01265184f, 
    0.03639400f, -0.13346757f, 0.07991999f, -0.02715818f, -0.03361920f, 0.08242264f, 0.00253564f, 0.03965760f, 
    -0.08239961f, 0.00861645f, 0.04195463f, 0.02223023f, 0.16518427f, -0.06389682f, -0.18510033f, 0.17363098f, 
    0.14462085f, -0.11556225f, 0.02923280f, 0.00868059f, 0.01300197f, -0.08327792f, 0.00336183f, -0.09740200f, 
    0.07525561f, -0.23426376f, 0.07652624f, 0.23318471f, 0.01779318f, -0.01105653f, 0.04029401f, -0.02840381f, 
    0.13144657f, 0.01708988f, -0.11087318f, 0.15239635f, 0.04876679f, -0.08492481f, -0.11586258f, 0.01333070f, 
    -0.01220037f, 0.13295360f, 0.07466247f, 0.08805551f, 0.02239593f, 0.05002595f, -0.04934271f, -0.03650237f, 
    0.27979732f, -0.37574032f, 0.01716521f, 0.36724734f, -0.02610677f, 0.10393020f, -0.08383599f, 0.01228523f, 
    -0.02946114f, -0.11686525f, -0.06359112f, -0.13498220f, 0.16471413f, 0.08923459f, -0.14686131f, 0.08382627f, 
    0.05546344f, 0.03098208f, 0.11121754f, 0.06440297f, -0.05630562f, 0.06807134f, 0.05321423f, -0.05792449f, 
    0.40302262f, -0.13047430f, 0.01260077f, -0.00157482f, 0.07443483f, -0.03492657f, 0.00920644f, -0.09281480f, 
    -0.22208323f, -0.07301128f, 0.07277662f, -0.10140996f, -0.01819480f, -0.13687293f, 0.05473677f, 0.12455554f, 
    -0.02443376f, 0.01175504f, 0.04491277f, -0.03186199f, -0.12270835f, 0.10036385f, 0.04659002f, 0.05717409f, 
    0.00308421f, 0.01712406f, -0.14346634f, 0.03318817f, -0.01933859f, -0.00937828f, 0.04074026f, 0.18092844f, 
    -0.00064546f, 0.10552913f, 0.06715617f, -0.00022850f, 0.39924857f, -0.09818670f, 0.07383105f, 0.10445189f, 
    -0.08271770f, 0.08280098f, 0.05807594f, 0.06722013f, 0.15276815f, 0.00047477f, -0.06673429f, 0.08049302f, 
    -0.05695641f, 0.07905737f, -0.10370599f, -0.15920869f, -0.11499473f, -0.21374740f, 0.00716491f, -0.01337129f, 
    -0.04522685f, 0.02017053f, 0.14029978f, 0.00126767f, -0.05753722f, 0.13897504f, -0.04343916f, -0.06716876f, 
    -0.03593566f, 0.13386115f, -0.06351350f, 0.04379691f, 0.06952160f, 0.06087730f, 0.08525776f, 0.04684713f, 
    0.04463056f, -0.01012927f, -0.02930732f, 0.00384444f, -0.01627109f, -0.05010417f, 0.01490183f, 0.00961026f, 
    0.01437839f, -0.00487945f, 0.03369692f, 0.02984331f, -0.02832700f, 0.01437854f, 0.01084283f, -0.01541098f, 
    -0.00115719f, -0.02084722f, 0.01883536f, 0.02364818f, 0.01494436f, -0.00992072f, -0.04705920f, -0.02979235f, 
    0.01065662f, 0.00990916f, -0.01062102f, 0.01063719f, 0.01133825f, 0.01733737f, 0.03112619f, 0.03894354f, 
    0.01963912f, -0.00897904f, -0.01626873f, 0.02328591f, -0.03258320f, -0.04955844f, 0.04472068f, 0.04549132f, 
    0.03692900f, 0.00232242f, -0.02811366f, 0.00112046f, -0.04918072f, -0.05025048f, -0.03995030f, -0.03166608f, 
    0.01314455f, 0.04148173f, -0.04829090f, -0.00428717f, -0.05403164f, -0.04536444f, 0.00845309f, 0.02051689f, 
    -0.00941442f, -0.00250427f, -0.04228681f, -0.04010709f, 0.03890199f, -0.06219799f, -0.02359824f, -0.02120923f, 
    0.02282161f, 0.01872100f, -0.03551677f, -0.01909675f, -0.00089404f, 0.02603667f, 0.04138727f, -0.05434068f, 
    0.02814175f, 0.00650742f, -0.01433033f, -0.04646314f, 0.01800151f, 0.03893832f, 0.01161467f, -0.04630315f, 
    -0.03901642f, -0.04440667f, 0.02219714f, 0.03332308f, 0.01362718f, 0.03723462f, -0.01915921f, -0.01537914f, 
    -0.05078382f, -0.03725361f, 0.00954607f, -0.05183655f, -0.01045919f, -0.04502479f, 0.01649473f, 0.03034575f, 
    -0.03053355f, -0.05119660f, -0.04609105f, 0.00998145f, 0.02114660f, 0.01455153f, -0.03348933f, 0.02220198f, 
    -0.04040741f, -0.05754720f, -0.04494638f, -0.04982293f, -0.06293905f, 0.02930304f, -0.03655367f, -0.01348961f, 
    -0.02238154f, -0.00990270f, -0.04469525f, 0.00834533f, -0.04475855f, -0.01872042f, -0.04548128f, -0.04434350f, 
    0.00407791f, -0.04627644f, 0.04617845f, -0.06017239f, 0.00747011f, -0.02909445f, 0.02538340f, -0.03047970f, 
    0.03322580f, -0.05168942f, -0.02905602f, -0.01018787f, 0.00720647f, 0.04316116f, 0.02349932f, 0.02405278f, 
    -0.02982757f, -0.01058308f, 0.03985984f, -0.02374363f, 0.03936322f, -0.04587766f, 0.04513760f, 0.02086080f, 
    -0.02619342f, -0.01491572f, 0.00777980f, -0.02035164f, -0.03096857f, 0.01867460f, 0.02123361f, -0.04394072f, 
    -0.05907120f, 0.00696414f, 0.00679325f, 0.03238613f, -0.05206306f, -0.01017752f, 0.02152597f, -0.03008720f, 
    -0.02493235f, -0.04778219f, -0.01197179f, -0.01522156f, 0.02513456f, -0.04694561f, -0.00658555f, 0.02788529f, 
    0.00419013f, 0.03053621f, -0.04736742f, -0.00015280f, 0.03389332f, 0.00029006f, -0.04202829f, -0.04248365f, 
    0.03834403f, -0.02209073f, -0.05069156f, 0.05391564f, 0.00654368f, 0.04047651f, 0.00873782f, 0.03510164f, 
    0.01634627f, -0.04717214f, 0.00608835f, 0.00629103f, -0.02717183f, -0.00542283f, -0.02862498f, 0.01620446f, 
    0.04278386f, -0.00989622f, 0.00267896f, 0.00060079f, -0.03498881f, -0.06013626f, -0.01523145f, -0.03817574f, 
    -0.05527600f, -0.03724512f, -0.02180488f, 0.03523980f, -0.05519991f, 0.04129176f, 0.03996084f, -0.01407790f, 
    0.01808739f, -0.01221444f, -0.01077314f, 0.00753020f, -0.03900276f, 0.01028925f, -0.05731725f, -0.05732123f, 
    -0.02402514f, -0.01012307f, -0.00534735f, 0.00241265f, 0.01617121f, -0.05833764f, -0.02094860f, 0.03794053f, 
    0.02056005f, 0.01394349f, -0.00229370f, -0.04803144f, 0.03969879f, 0.04015965f, -0.00341969f, -0.02700783f, 
    -0.04046452f, 0.03426195f, 0.00353297f, -0.03676475f, -0.02931452f, -0.02124237f, 0.00018980f, -0.04292055f, 
    0.01904412f, -0.02524746f, -0.01001201f, -0.02154938f, -0.03135915f, 0.03801169f, -0.02366887f, 0.02826346f, 
    -0.05365788f, -0.02447133f, 0.04143209f, 0.00778885f, -0.01525316f, -0.04914223f, -0.02837768f, 0.02207565f, 
    0.00646098f, -0.04214543f, -0.05140623f, -0.03244066f, -0.02306098f, 0.02514942f, 0.03424300f, -0.00167612f, 
    -0.01553192f, 0.01407699f, -0.05743792f, -0.05052786f, 0.00316276f, -0.01787795f, -0.01793729f, 0.00412122f, 
    -0.01874555f, 0.02053506f, 0.02397276f, -0.03955247f, -0.00074115f, 0.01370740f, 0.02117579f, 0.04187615f, 
    -0.02046057f, 0.00235119f, -0.04823557f, -0.00296619f, 0.04281039f, -0.03780486f, -0.03904321f, 0.01571525f, 
    -0.00376806f, 0.00195709f, -0.03239627f, -0.03562394f, 0.02362594f, -0.04758643f, 0.00252180f, 0.01154136f, 
    -0.00494167f, -0.02235830f, 0.02071412f, 0.02225196f, -0.00613974f, -0.01292830f, -0.01450734f, -0.06199866f, 
    0.03954416f, 0.00316112f, -0.03455039f, -0.05478781f, -0.05621958f, -0.00318362f, 0.02218878f, -0.06216166f, 
    0.03676762f, -0.03716180f, -0.03595250f, -0.04997432f, 0.00176559f, 0.03499266f, 0.01691603f, -0.02815678f, 
    0.02627420f, 0.03949018f, 0.03402222f, 0.02283538f, 0.03437547f, 0.03073293f, -0.04055138f, 0.02409244f, 
    -0.05314582f, 0.00023430f, 0.03452604f, -0.01369619f, -0.03206548f, 0.01452454f, -0.00534052f, -0.02892752f, 
    0.00955367f, 0.01186746f, -0.04017305f, -0.03501997f, -0.04361116f, 0.03365060f, 0.01699782f, -0.05109695f, 
    -0.01360868f, -0.02814475f, -0.03964613f, 0.00466002f, -0.02470335f, 0.02936935f, -0.01855917f, 0.00228485f, 
    -0.04694054f, -0.02111361f, -0.01927769f, 0.00063237f, 0.02498749f, 0.03435123f, 0.00363813f, -0.04813033f, 
    0.02383764f, 0.01861229f, 0.02819006f, 0.01656654f, 0.02623395f, 0.02109569f, 0.02247636f, 0.01544838f, 
    0.01327827f, 0.01230566f, -0.02017433f, -0.05332862f, 0.03821491f, -0.02575396f, 0.03882724f, 0.03504877f, 
    0.02170693f, 0.00615624f, 0.00643750f, -0.01459641f, -0.00353438f, -0.04211485f, 0.00232722f, -0.04740299f, 
    0.04240166f, 0.01865441f, -0.04378619f, 0.04499724f, -0.02683275f, 0.00036221f, -0.02131176f, -0.00520846f, 
    -0.03404628f, 0.03492925f, -0.00675259f, -0.05564966f, -0.02829172f, 0.02603620f, -0.02288328f, -0.02838117f, 
    -0.02053598f, -0.00159746f, -0.00595451f, 0.04480245f, 0.00391105f, -0.01031224f, -0.04723901f, 0.04407573f, 
    -0.03480584f, -0.03779726f, -0.00142256f, -0.01816158f, -0.02312657f, 0.01916435f, -0.00897016f, -0.04293944f, 
    -0.03433465f, 0.02754899f, -0.01961474f, -0.03631477f, -0.02266260f, 0.02622859f, 0.01298032f, 0.02003938f, 
    -0.05181758f, -0.02280980f, -0.04161027f, -0.02957645f, -0.00833119f, -0.01569102f, -0.05325555f, -0.00567591f, 
    0.04493867f, 0.01395324f, -0.01405439f, 0.02857794f, 0.04233577f, 0.01937327f, -0.04415206f, -0.05477413f, 
    -0.01419309f, -0.04545994f, -0.02505403f, -0.00969784f, -0.02031563f, -0.00788618f, -0.02539592f, 0.00451774f, 
    -0.03693606f, 0.01430419f, -0.02802694f, -0.03976471f, -0.02071049f, 0.03721333f, -0.02321874f, 0.00306929f, 
    0.03355631f, 0.01891417f, 0.03329288f, -0.04953622f, 0.02190588f, -0.03008743f, -0.03427553f, 0.00212876f, 
    -0.04446407f, -0.04424951f, 0.03486089f, -0.02463916f, 0.03241152f, 0.01676403f, -0.01618439f, -0.02109657f, 
    -0.05174788f, 0.01259373f, 0.03996522f, -0.02670514f, 0.00125168f, 0.04398865f, 0.00818910f, -0.01626862f, 
    0.03377875f, -0.00919164f, 0.02739027f, -0.04353485f, -0.05208951f, -0.02659578f, 0.00292254f, -0.04235720f, 
    -0.04652379f, -0.02020450f, 0.02352838f, -0.00644552f, 0.00133362f, -0.05587759f, 0.01169777f, -0.00197000f, 
    0.00421803f, 0.03340489f, -0.01274013f, -0.01893463f, 0.02088593f, 0.00633400f, -0.02280932f, -0.00747744f, 
    -0.01324652f, -0.04177641f, -0.04201809f, 0.00596200f, -0.05582788f, 0.02581258f, -0.05071120f, 0.02784248f, 
    0.00349931f, -0.01152301f, -0.02826209f, -0.03344563f, -0.03460742f, 0.04378824f, 0.00215249f, -0.01940257f, 
    0.02505077f, 0.03173515f, -0.01721589f, 0.03435341f, -0.01234273f, -0.03365540f, -0.04777392f, -0.00484335f, 
    0.02024762f, 0.03107581f, -0.05214605f, 0.02498253f, -0.02679406f, -0.03097977f, -0.05626949f, -0.01910592f, 
    -0.04291541f, 0.02101640f, 0.00356348f, -0.04390077f, -0.04848692f, 0.00120829f, 0.02289523f, 0.01704458f, 
    -0.04061585f, -0.03867166f, -0.03183093f, -0.01579482f, -0.02050696f, 0.03095756f, -0.03264910f, 0.03883860f, 
    0.02274298f, 0.01360317f, 0.03061711f, 0.01111414f, 0.03807126f, -0.02993890f, 0.02518460f, 0.00324591f, 
    0.02282157f, 0.03511439f, -0.00652893f, 0.02136819f, 0.01891136f, 0.00285347f, 0.00294231f, -0.04752726f, 
    0.03057367f, -0.05208708f, 0.00859370f, -0.04381380f, 0.02329219f, -0.04215978f, -0.04782457f, 0.01437654f, 
    0.00908475f, 0.03355093f, 0.00438543f, -0.00474696f, -0.03545902f, 0.01611865f, 0.03859949f, -0.03802944f, 
    -0.03139167f, 0.03212017f, -0.03137291f, -0.03752991f, 0.00765193f, -0.00895203f, 0.01888238f, -0.02101726f, 
    -0.05315128f, -0.02740650f, 0.00716811f, 0.02931141f, 0.00560293f, -0.01430726f, -0.00957797f, 0.01051983f, 
    -0.00368130f, -0.00860671f, -0.04952331f, -0.02546844f, 0.04257961f, 0.03970065f, -0.03528263f, 0.03726952f, 
    -0.01401883f, -0.02779430f, 0.04546525f, 0.00048713f, -0.03900878f, -0.01617381f, 0.03993125f, -0.03609054f, 
    -0.00725997f, -0.02695363f, -0.00556078f, -0.04918630f, -0.00476054f, -0.01879345f, 0.00395507f, -0.03530726f, 
    -0.01284200f, -0.05643585f, 0.00389411f, -0.05607057f, -0.01742514f, 0.02677491f, 0.01739710f, -0.02744770f, 
    -0.04351081f, -0.00417932f, -0.02827310f, -0.05292357f, -0.02074941f, 0.02368744f, 0.03335431f, -0.00299155f, 
    0.01582621f, -0.00503302f, -0.04875885f, 0.00328687f, 0.01557702f, 0.01342873f, -0.00999613f, -0.05609201f, 
    0.00983611f, 0.00709705f, -0.02945165f, -0.00527059f, 0.02395247f, 0.01509404f, -0.00813423f, -0.04294082f, 
    -0.02631725f, -0.01327281f, 0.03373558f, 0.00432755f, -0.03989453f, 0.02167996f, -0.01213829f, 0.02709337f, 
    -0.03775712f, -0.00296890f, -0.03978810f, 0.03968319f, -0.03782342f, -0.03241699f, -0.03732033f, 0.02395177f, 
    -0.01864995f, 0.03333572f, -0.01463427f, -0.01241615f, -0.00140433f, 0.00479071f, -0.03561570f, -0.00402158f, 
    0.01232246f, -0.02205745f, -0.02175782f, -0.01991015f, -0.00475998f, 0.01861742f, -0.02460579f, 0.01470451f, 
    0.04265375f, -0.00283594f, -0.01832636f, 0.03246679f, 0.02305166f, 0.00636065f, 0.04341634f, -0.04756242f, 
    -0.02456455f, 0.01130480f, -0.02224999f, -0.05565887f, -0.04011666f, 0.02145966f, -0.02906400f, 0.01904005f, 
    -0.02464047f, -0.01860262f, -0.00305277f, 0.01692859f, 0.00613890f, 0.00384204f, 0.02711702f, -0.03901028f, 
    -0.00068121f, 0.01266531f, 0.02492293f, -0.00355387f, -0.04088955f, 0.03765528f, 0.02852516f, -0.00715689f, 
    -0.05415145f, 0.01165702f, 0.04316033f, 0.04233966f, 0.03154199f, 0.04218628f, -0.04050360f, 0.02710856f, 
    0.03109660f, -0.00305123f, -0.03738160f, -0.00783704f, -0.04498458f, 0.01213233f, 0.00130624f, -0.01440725f, 
    -0.02022738f, -0.00639535f, 0.01636835f, 0.03157504f, -0.01551138f, -0.00908103f, -0.04680666f, -0.03821893f, 
    0.02700108f, -0.03675796f, -0.04030428f, -0.00342729f, -0.01539589f, -0.01509259f, -0.04726926f, 0.01017535f, 
    -0.01587189f, -0.05528546f, -0.03366501f, -0.01159667f, 0.03449471f, -0.04691547f, 0.02421875f, 0.04176984f, 
    0.02048622f, 0.01553273f, -0.04597292f, 0.04126480f, 0.01026738f, -0.01174475f, -0.03933839f, -0.01903878f, 
    -0.04774436f, -0.03654052f, 0.03492361f, -0.05688239f, -0.04725647f, 0.03585008f, 0.03548698f, -0.02843622f, 
    0.03991044f, 0.04005528f, 0.02303987f, -0.02698271f, 0.00567167f, -0.00675941f, 0.04294031f, -0.01704630f, 
    -0.01573837f, -0.01562304f, 0.02073075f, -0.05118522f, -0.03298098f, -0.04267974f, 0.03395635f, 0.03883458f, 
    0.00717352f, 0.02847116f, -0.04834377f, -0.02142527f, 0.00605261f, 0.00490930f, -0.04547251f, 0.04194104f, 
    -0.00877267f, 0.04151388f, -0.00130109f, 0.01326384f, 0.01436042f, 0.00956515f, 0.03321661f, 0.02103715f, 
    0.00018831f, -0.01172620f, 0.00756371f, -0.00883246f, -0.03782427f, -0.04044578f, 0.02815979f, 0.00522406f, 
    -0.01910587f, -0.02260833f, 0.01291811f, -0.02111428f, -0.00680568f, 0.00271226f, -0.03303352f, -0.02472834f, 
    0.02692732f, -0.02659988f, 0.02352079f, -0.05962763f, -0.05698545f, -0.01710121f, -0.04942762f, -0.02331009f, 
    -0.00498312f, -0.04084738f, 0.00447349f, 0.03425974f, -0.06011918f, 0.01988548f, 0.04197627f, -0.05896638f, 
    -0.00007175f, -0.00317537f, 0.04029121f, -0.05341907f, -0.05567122f, 0.00010226f, -0.05031798f, 0.00380254f, 
    -0.01586617f, -0.00109699f, -0.04856061f, -0.01940808f, 0.02279535f, -0.01257170f, -0.01157619f, 0.02404097f, 
    -0.04914901f, -0.01804496f, 0.03140092f, -0.01131641f, 0.03900313f, 0.00224730f, -0.03784165f, -0.03159697f, 
    0.02974607f, 0.01568966f, 0.03236798f, -0.05286691f, -0.00558731f, -0.03562873f, -0.00603196f, 0.02576089f, 
    -0.00544620f, -0.02976679f, -0.01617017f, -0.01057077f, 0.03250891f, 0.03643965f, -0.02142564f, -0.05761589f, 
    -0.00808198f, 0.00516100f, -0.01041607f, 0.02390607f, 0.02024751f, 0.01321957f, 0.01129269f, -0.05388852f, 
    -0.04849745f, -0.05332300f, 0.00008641f, -0.01460114f, -0.00114905f, -0.04117754f, 0.00642562f, -0.03259138f, 
    -0.04859742f, 0.01798807f, -0.00507164f, -0.05207640f, 0.03234291f, 0.00140994f, -0.03374519f, 0.02404446f, 
    -0.02525325f, -0.01895262f, -0.02066754f, -0.03297177f, 0.02030205f, 0.02778173f, 0.00346213f, -0.01869389f, 
    0.00019337f, -0.03370908f, 0.02036293f, -0.05145879f, -0.01327279f, 0.03591987f, -0.00583896f, 0.00734973f, 
    0.04440057f, -0.04762965f, -0.04497455f, -0.04859056f, 0.00320985f, -0.04954574f, 0.02176367f, 0.00724540f, 
    0.00445892f, -0.05006333f, -0.01354097f, 0.01776203f, -0.01930672f, -0.05693446f, -0.04751652f, -0.03185753f, 
    0.02806517f, -0.02104374f, -0.03034376f, -0.00704524f, -0.03846334f, -0.04001497f, -0.00189075f, -0.00391273f, 
    -0.01559530f, 0.01631545f, -0.02896510f, 0.01785587f, -0.00154938f, -0.02909372f, -0.05283380f, 0.00136266f, 
    0.01298574f, 0.01043378f, 0.02619073f, 0.00216122f, -0.05164738f, -0.05267413f, 0.02387165f, 0.04163143f, 
    0.03832246f, -0.05006723f, -0.05855248f, -0.04579825f, -0.03946556f, 0.02940467f, 0.02554939f, -0.00467804f, 
    -0.03064808f, -0.03363753f, -0.05559168f, 0.03465144f, -0.00713759f, -0.04964095f, -0.05562830f, 0.03724157f, 
    0.01838259f, 0.00517289f, -0.00325828f, 0.03374445f, -0.04891745f, 0.00122646f, 0.02203786f, -0.04036967f, 
    -0.00371803f, -0.00838403f, -0.04438964f, 0.03588464f, -0.00790324f, -0.05990170f, 0.03661633f, -0.00969590f, 
    -0.00827967f, -0.05272342f, -0.02380126f, -0.02099289f, 0.01747394f, 0.02933740f, -0.02076750f, -0.00027292f, 
    -0.01095213f, -0.03660454f, 0.02919894f, -0.01338998f, 0.04592349f, -0.00409904f, -0.00304441f, -0.02870154f, 
    0.03700606f, 0.03699024f, -0.02997376f, 0.01103033f, -0.04963157f, 0.00983145f, 0.02026854f, -0.05096522f, 
    -0.00177784f, 0.00891354f, 0.04654378f, -0.03229854f, -0.03074805f, 0.04136229f, -0.01713467f, -0.02795518f, 
    -0.02880003f, 0.03223034f, -0.00419691f, -0.06177906f, -0.03132866f, -0.00969979f, -0.04562762f, -0.03581540f, 
    -0.04321553f, -0.00266824f, -0.03107209f, 0.01285423f, -0.01962350f, -0.01439776f, -0.02226522f, 0.01924322f, 
    -0.02375478f, -0.04310922f, -0.03011887f, -0.02966121f, 0.01724906f, -0.05655058f, 0.02331753f, -0.01361430f, 
    0.02358068f, -0.04272263f, 0.03487678f, 0.01684757f, -0.04893226f, 0.01914722f, 0.04225868f, 0.04203691f, 
    -0.01682674f, 0.01718030f, -0.01265605f, -0.00241782f, -0.01423646f, -0.02218501f, 0.04293858f, 0.02088419f, 
    -0.03336458f, 0.02511098f, 0.01412652f, -0.03095061f, -0.00102499f, 0.02638366f, -0.02682717f, -0.04125765f, 
    -0.03815284f, -0.04748445f, -0.05220705f, -0.01534663f, 0.04155790f, -0.00101023f, 0.01816608f, -0.01904617f, 
    -0.05895757f, 0.01260806f, -0.01889817f, -0.01222822f, 0.03935889f, -0.03187294f, -0.03155966f, 0.03601608f, 
    0.02593323f, -0.04071057f, -0.01447897f, 0.02061740f, 0.00929721f, -0.06052655f, -0.04461785f, 0.01515508f, 
    -0.04057578f, -0.00793956f, 0.00892052f, 0.03797445f, -0.05465598f, -0.03371227f, 0.03274845f, 0.02220781f, 
    0.03429805f, -0.03636164f, -0.04976575f, 0.01109896f, -0.03852112f, 0.01775390f, 0.02747654f, -0.04776927f, 
    -0.05245060f, -0.00306339f, 0.01035494f, 0.01880370f, 0.01333611f, 0.00216848f, 0.04017746f, -0.02811617f, 
    0.02507859f, 0.03737977f, 0.04485950f, 0.03940366f, -0.00988711f, 0.03156097f, 0.01861810f, 0.03508487f, 
    -0.01388731f, 0.00692437f, 0.02009393f, 0.03874717f, -0.01207202f, 0.00740298f, 0.01857466f, -0.03367571f, 
    -0.05084578f, 0.00587922f, -0.05507397f, -0.00611145f, 0.04302953f, -0.00889624f, 0.01796793f, 0.02926319f, 
    -0.03315116f, 0.03960923f, -0.03526793f, 0.03837919f, -0.01661996f, -0.02451019f, -0.00034813f, -0.02568458f, 
    -0.04150521f, -0.00688743f, -0.03317179f, 0.02524796f, -0.01105399f, -0.00749895f, -0.05485625f, -0.03582552f, 
    -0.03633343f, 0.04348842f, 0.02078480f, -0.05361692f, -0.04163269f, 0.04311942f, -0.04418243f, -0.02374870f, 
    0.00133176f, 0.03913226f, -0.00819767f, 0.01964704f, -0.05140948f, 0.00431288f, -0.05330793f, 0.04170892f, 
    0.01255985f, 0.02930477f, -0.04563279f, -0.03148543f, -0.03070532f, -0.04385469f, 0.02014265f, 0.03369076f, 
    0.03444441f, 0.02127821f, 0.04298165f, 0.01191179f, 0.01252346f, -0.00482799f, 0.02441501f, 0.00695450f, 
    -0.00742198f, 0.03820920f, 0.00643334f, -0.04591944f, 0.01285049f, -0.04488888f, 0.00344151f, -0.03462486f, 
    -0.03376974f, -0.00697985f, -0.00226519f, -0.03073368f, -0.04138979f, -0.04386524f, 0.00363986f, 0.02939201f, 
    -0.04361749f, 0.02214417f, -0.04462553f, 0.00966274f, -0.04260055f, -0.04872337f, 0.02850050f, -0.05360639f, 
    0.03624543f, -0.00210258f, -0.05164777f, -0.00066080f, 0.02960536f, -0.00881192f, -0.03966396f, 0.00059015f, 
    -0.01581270f, -0.04825504f, -0.03810264f, 0.01387202f, -0.00351443f, 0.01101987f, 0.02138637f, 0.03810070f, 
    -0.01611602f, -0.05635942f, 0.01189640f, -0.00224975f, 0.04025230f, -0.04865457f, -0.01201960f, 0.01943179f, 
    -0.00681456f, -0.04186625f, 0.02195063f, 0.00327697f, 0.02575236f, -0.02207778f, 0.01832974f, -0.00664956f, 
    0.03381646f, -0.03049741f, 0.00395292f, -0.01660193f, 0.02824482f, -0.04199683f, 0.01786434f, 0.00188195f, 
    -0.02189784f, -0.01642549f, -0.03082723f, 0.02798315f, -0.01231015f, 0.03803238f, -0.02880793f, 0.04668366f, 
    0.00293510f, -0.00292065f, -0.01362708f, -0.00660482f, 0.02472847f, -0.02434415f, -0.03254751f, -0.03295979f, 
    -0.00096908f, -0.00523755f, 0.01552344f, -0.04280489f, -0.01702093f, 0.02367807f, 0.00465046f, 0.01538468f, 
    -0.00705589f, 0.03949378f, -0.05721800f, 0.01414744f, 0.02515249f, -0.01181350f, -0.04238062f, 0.03197030f, 
    -0.01634675f, 0.02011902f, -0.02069111f, 0.01450013f, -0.02478549f, -0.01559606f, -0.05654945f, -0.02155973f, 
    0.02074629f, -0.02486850f, 0.01749429f, 0.02106411f, 0.00919415f, 0.02592040f, 0.00410200f, 0.01099033f, 
    -0.00268773f, 0.02036512f, -0.05492591f, 0.01580624f, 0.04048675f, 0.01100615f, -0.05193321f, 0.01212506f, 
    0.03103961f, -0.04714067f, -0.00673863f, -0.04721535f, -0.02044537f, -0.05464081f, -0.00000785f, -0.04043674f, 
    -0.03638026f, 0.04182217f, 0.00994954f, -0.02472712f, 0.01086313f, -0.01240421f, -0.04487093f, 0.03422186f, 
    -0.03484601f, 0.03564781f, 0.02720560f, -0.00425603f, -0.01728666f, 0.04308440f, -0.00678788f, 0.00691571f, 
    0.03485781f, 0.02317440f, -0.01370571f, 0.03421762f, 0.01959508f, -0.00889303f, -0.03575328f, -0.01645825f, 
    -0.00745734f, -0.05881038f, 0.00327584f, 0.02681665f, -0.00264961f, -0.04679213f, -0.03854338f, 0.02567705f, 
    0.01569688f, 0.00355213f, -0.05396371f, 0.01161094f, 0.01523807f, 0.01555058f, -0.02931115f, 0.04163237f, 
    0.03483209f, -0.04708852f, 0.02071109f, 0.00579418f, -0.01962442f, -0.05278621f, -0.01529816f, -0.01235121f, 
    -0.04086675f, -0.04049740f, -0.02158403f, -0.05812869f, -0.03323169f, 0.02906744f, 0.00715278f, -0.02924219f, 
    -0.05046501f, -0.04683496f, -0.04492129f, -0.02304098f, -0.05017384f, 0.00117969f, 0.02422804f, 0.00156160f, 
    -0.00303648f, -0.01007648f, -0.00356611f, 0.02549658f, 0.04346232f, -0.05017698f, 0.04397186f, -0.03329154f, 
    0.02300030f, -0.02290327f, 0.02764742f, -0.05164557f, 0.02058116f, 0.04288933f, 0.01734370f, -0.03258539f, 
    -0.05068512f, -0.00709923f, 0.01169739f, -0.00771546f, 0.02985826f, -0.00713292f, 0.03991294f, -0.01380756f, 
    0.00950183f, 0.02942308f, -0.02788250f, -0.05667356f, -0.04220814f, 0.03801991f, 0.00295530f, 0.01446705f, 
    0.00833543f, -0.02264264f, 0.01028344f, -0.02890996f, -0.03182628f, -0.00376127f, -0.01892042f, -0.03693927f, 
    -0.02344876f, -0.02874139f, 0.01747715f, -0.02881335f, 0.00358837f, -0.00414525f, 0.03539266f, 0.01678021f, 
    -0.01840809f, -0.02725290f, 0.04080676f, 0.01581303f, -0.05814090f, -0.03107586f, -0.04355559f, 0.01081563f, 
    -0.03096161f, -0.05114850f, -0.03063225f, -0.01303084f, -0.04190821f, 0.02015377f, -0.03038220f, -0.03903363f, 
    -0.03482885f, 0.00558054f, -0.02358705f, 0.00678424f, 0.03490638f, -0.00498931f, -0.05246684f, -0.02229988f, 
    0.01276584f, -0.03958756f, -0.03607853f, 0.04275838f, 0.01045076f, -0.04857496f, -0.02774196f, -0.01528087f, 
    0.04098235f, -0.01958691f, -0.03384146f, 0.00319181f, 0.00936843f, -0.05637538f, 0.01350419f, -0.03439757f, 
    -0.02225840f, 0.00918416f, 0.03552183f, -0.05645167f, 0.00363380f, 0.02718898f, -0.01558971f, 0.02031127f, 
    -0.00701028f, 0.00353748f, -0.01884048f, -0.01678677f, -0.05802829f, -0.02208753f, 0.02886825f, -0.04827811f, 
    0.02905499f, 0.03841174f, -0.02912359f, -0.00471539f, 0.04364108f, -0.04457534f, 0.03253462f, 0.01105581f, 
    0.02158740f, 0.02215557f, -0.00867933f, -0.00230007f, -0.02270198f, -0.02880736f, 0.04044845f, 0.01677571f, 
    -0.04089257f, -0.00776453f, -0.00800581f, 0.00111407f, 0.01390983f, 0.01458991f, -0.03355658f, -0.01919743f, 
    -0.02010775f, -0.03357455f, -0.00479764f, -0.04674054f, 0.03094616f, 0.03008953f, 0.00649683f, 0.00089229f, 
    0.03346636f, 0.02250205f, -0.00055394f, 0.00714563f, -0.01626683f, -0.02437904f, -0.05367847f, 0.03875475f, 
    0.00954394f, -0.01342975f, -0.00268013f, -0.01488263f, 0.03846927f, 0.01803571f, 0.03409101f, -0.01360649f, 
    0.12229878f, -0.26798227f, -0.16011938f, -0.10894279f, 0.10532708f, 0.01435701f, -0.02667357f, 0.04183189f, 
    0.15291788f, -0.11021198f, 0.02086200f, 0.17703106f, -0.02894649f, 0.06655930f, -0.08977190f, 0.07005048f, 
    0.04010696f, 0.01444218f, 0.00919143f, 0.02892045f, -0.03350365f, 0.07909337f, 0.11931702f, -0.20567515f, 
    -0.06812965f, 0.07239379f, 0.05808513f, -0.03938745f, 0.18614694f, -0.04578646f, 0.02137622f, 0.03763391f, 
    -0.05898341f, 0.06847886f, 0.06524023f, -0.02239987f, -0.04935941f, -0.01273843f, -0.06610183f, 0.06398963f, 
    0.11610021f, 0.06059769f, 0.07463847f, -0.06536620f, -0.05783635f, 0.04447037f, -0.05858853f, -0.03837987f, 
    0.13483799f, -0.05797669f, 0.12953112f, -0.22013302f, -0.08830797f, 0.01602196f, -0.03386199f, 0.18371654f, 
    -0.03231230f, -0.05334911f, -0.00536491f, -0.02079153f, -0.11028916f, -0.07133616f, -0.02872922f, -0.03923599f, 
    0.03802108f, 0.13034725f, 0.01140417f, 0.11764936f, -0.18903750f, 0.07456034f, 0.00550925f, 0.09892589f, 
    -0.18734558f, -0.07699745f, 0.10641486f, -0.09406637f, -0.00548029f, -0.04525710f, 0.12193720f, 0.11364923f, 
    -0.11644287f, -0.17169802f, 0.08117621f, -0.00771448f, 0.05500280f, -0.00775138f, 0.21125051f, 0.20308448f, 
    -0.25608385f, 0.12620252f, 0.09677508f, 0.09289107f, -0.14723013f, -0.01447473f, 0.03830089f, 0.05986748f, 
    -0.08167474f, 0.02587790f, -0.23784320f, -0.26969978f, 0.12447311f, -0.02836188f, -0.06828782f, 0.04672647f, 
    0.15711029f, -0.05654190f, 0.04677796f, 0.06817222f, -0.38014188f, 0.05017961f, 0.11262046f, -0.18919602f, 
    0.15955429f, -0.04179125f, 0.15873811f, 0.09666790f, 0.11834765f, 0.07335252f, -0.02657617f, -0.08644219f, 
    0.11323118f, 0.11081733f, -0.00787909f, 0.27663773f, 0.06339400f, -0.00992299f, 0.10914500f, 0.03009572f, 
    0.03695339f, 0.05666012f, -0.13145266f, 0.00235774f, 0.22007771f, -0.19083147f, 0.14215049f, 0.11072772f, 
    0.03743662f, 0.14253223f, -0.00846393f, -0.06841303f, -0.01976525f, 0.06176712f, 0.07892302f, 0.11190034f, 
    -0.05379664f, 0.03173372f, -0.07517169f, 0.09428497f, -0.00724121f, -0.06690087f, 0.04375584f, 0.05970632f, 
    0.12172424f, 0.05679071f, 0.06393578f, 0.01143902f, 0.29076129f, -0.06634207f, -0.17622438f, -0.02964444f, 
    0.04012125f, -0.08434113f, 0.08834012f, -0.01272223f, 0.02693747f, 0.12531835f, 0.05730828f, 0.00441104f, 
    -0.16452889f, -0.01631342f, -0.13425018f, -0.23631738f, 0.06653760f, 0.06225606f, -0.06913855f, -0.17739701f, 
    0.07071216f, -0.02682561f, 0.01699706f, 0.05831644f, -0.15913309f, -0.18766971f, 0.04026882f, -0.22928464f, 
    0.07218263f, 0.03743873f, 0.00878769f, 0.03432883f, -0.01991507f, 0.15794830f, 0.02228818f, 0.07077598f, 
    0.22982825f, -0.06201689f, 0.11101809f, 0.33650562f, -0.12463948f, -0.12907104f, 0.04792607f, 0.03946215f, 
    -0.01852123f, 0.03694845f, -0.07234616f, 0.01712476f, -0.31949994f, -0.05860513f, 0.11348148f, 0.19675016f, 
    -0.00841328f, -0.01348296f, 0.00964360f, 0.01709710f, -0.02306264f, -0.03874094f, -0.06268796f, -0.08803184f, 
    0.23254591f, 0.10586853f, 0.09719084f, 0.11552507f, -0.03745105f, 0.06646203f, -0.05473065f, -0.04911713f, 
    0.17179246f, 0.11469575f, -0.08649223f, 0.07218946f, 0.05734068f, -0.14170586f, 0.00626368f, -0.00860939f, 
    -0.05641283f, -0.03249704f, 0.11004733f, -0.07589096f, -0.00535809f, 0.08716322f, -0.10288488f, 0.04425820f, 
    -0.09318147f, -0.20987409f, -0.12967955f, -0.20255804f, 0.04111296f, 0.06390578f, 0.04912823f, -0.13737190f, 
    0.03939817f, -0.02677764f, -0.08195526f, 0.19915083f, 0.08126428f, 0.16202243f, 0.09778776f, -0.01462919f, 
    -0.04853202f, -0.00263724f, 0.04557311f, -0.03425866f, -0.03899797f, 0.06445461f, 0.00655332f, 0.10377450f, 
    -0.02033635f, 0.11275512f, 0.06837291f, -0.02222648f, -0.14506173f, 0.02844583f, -0.00982449f, -0.13907687f, 
    0.04395521f, -0.02142525f, 0.09801190f, -0.05174645f, 0.41613832f, 0.02740826f, 0.11804895f, 0.32097739f, 
    -0.09195748f, -0.06348405f, 0.00044134f, -0.03486593f, 0.08398795f, -0.07289190f, 0.07290833f, -0.05280781f, 
    0.09842301f, 0.05769510f, -0.05748048f, 0.07459580f, -0.16124271f, -0.00317873f, 0.00532932f, 0.07289492f, 
    0.01495747f, 0.03948101f, 0.04989463f, 0.11808012f, -0.00320382f, 0.06411817f, 0.09346871f, 0.23110838f, 
    0.03543745f, -0.05542498f, 0.01275584f, -0.05249022f, 0.01449729f, -0.06814697f, 0.03341830f, 0.12664311f, 
    0.15303059f, -0.04548451f, -0.14493056f, -0.05685908f, 0.00654051f, 0.11027612f, -0.03946085f, 0.03916775f, 
    -0.06160804f, -0.00747804f, -0.05149679f, 0.01418499f, -0.03099447f, 0.17209794f, 0.19931738f, 0.05674191f, 
    -0.04326308f, 0.06565014f, -0.02136446f, -0.00157207f, 0.10558063f, 0.16783930f, -0.08419920f, 0.10526509f, 
    0.10416957f, 0.14846425f, -0.04989291f, 0.12853846f, 0.02000551f, 0.08057500f, -0.15932713f, -0.17329413f, 
    0.09739962f, -0.05186135f, -0.07863275f, -0.11081786f, 0.02048149f, -0.02823641f, 0.12677021f, -0.15779702f, 
    -0.04756976f, -0.02925296f, -0.03625335f, 0.01004830f, -0.05133590f, -0.11783220f, -0.00219910f, -0.10766912f, 
    -0.07308663f, -0.04683032f, 0.04973304f, -0.15348768f, 0.04641333f, 0.13326253f, -0.00839638f, 0.12750350f, 
    0.01787703f, 0.02516869f, -0.04152934f, 0.05917306f, -0.02335605f, 0.14371175f, -0.13446052f, 0.07195583f, 
    0.08239251f, 0.03501916f, 0.05166221f, 0.06262146f, 0.00496514f, -0.05252403f, -0.08652981f, -0.06283277f, 
    0.33018485f, -0.09193707f, 0.18595524f, 0.13529536f, 0.02257857f, 0.01178218f, 0.02093288f, 0.03818748f, 
    -0.01352127f, 0.07216796f, 0.04327793f, -0.05205068f, 0.10916193f, 0.00855296f, -0.03376084f, -0.00498236f, 
    0.00417861f, -0.05857684f, 0.06659278f, -0.07776760f, 0.03025099f, 0.03268982f, -0.04382388f, 0.00503356f, 
    -0.09783382f, -0.01077188f, 0.01894320f, 0.13911231f, 0.05978275f, 0.03549924f, 0.13182983f, 0.05951800f, 
    0.00762791f, -0.05213723f, -0.09696858f, -0.00521507f, 0.39889380f, 0.17571038f, 0.07141297f, 0.00159758f, 
    -0.04595394f, -0.15604883f, -0.05132119f, 0.07524300f, 0.14679836f, 0.06300274f, 0.04029989f, 0.02308607f, 
    -0.20118804f, 0.11282444f, 0.30879003f, -0.29485804f, 0.03779188f, 0.00049576f, -0.01490324f, 0.01651701f, 
    -0.06423000f, -0.04931464f, 0.00555651f, 0.07033031f, -0.25045791f, -0.03846570f, 0.10364564f, -0.08822386f, 
    0.01751294f, 0.01957023f, 0.07666698f, -0.08058698f, 0.04056510f, 0.00586399f, -0.02721435f, -0.11818655f, 
    -0.04299031f, -0.06992278f, 0.01104193f, -0.01348233f, 0.04366018f, 0.04276431f, 0.05213160f, -0.18256314f, 
    -0.00079849f, 0.08725058f, 0.05757664f, 0.02266904f, -0.20209074f, -0.01693166f, -0.22090296f, 0.18462692f, 
    0.11262413f, -0.05094234f, 0.00853009f, -0.05953971f, -0.05633016f, -0.08671220f, -0.02060431f, -0.07276044f, 
    0.13472886f, 0.00250284f, 0.20008796f, -0.00196940f, 0.08432666f, 0.03041232f, -0.05673360f, 0.12946859f, 
    -0.06284525f, 0.04975579f, 0.03893908f, 0.07405096f, -0.20615339f, 0.03859495f, -0.02463547f, 0.10826898f, 
    0.18983407f, -0.07564195f, -0.07533032f, -0.05015324f, -0.04723084f, -0.10720754f, 0.01474594f, 0.07831611f, 
    0.34748200f, 0.08611424f, -0.08012095f, 0.14653228f, -0.05993466f, 0.02485341f, 0.00992434f, -0.00091751f, 
    -0.04119484f, 0.07329118f, 0.08624279f, -0.11452448f, 0.11162958f, 0.00080685f, -0.23368372f, -0.03630948f, 
    -0.03158778f, -0.01417691f, 0.17746231f, -0.02998045f, 0.05871715f, 0.01422075f, -0.03239560f, 0.00202201f, 
    0.18040732f, -0.05795477f, 0.16058069f, -0.00813324f, 0.03581893f, -0.09401273f, -0.00060066f, -0.08605257f, 
    0.00546152f, 0.05482217f, -0.06361659f, -0.06402830f, 0.05348537f, 0.10974892f, 0.11526521f, 0.05116439f, 
    -0.09642027f, 0.07413276f, 0.19377810f, 0.00807195f, -0.01915231f, -0.04772833f, -0.00949587f, 0.01111236f, 
    0.06596348f, 0.30046850f, 0.24280258f, 0.01197377f, 0.07443681f, -0.00676349f, 0.08428095f, -0.00198894f, 
    0.02564849f, -0.01238974f, 0.00651706f, 0.00734653f, 0.39542618f, -0.21881934f, -0.11125457f, 0.06022983f, 
    0.01970669f, 0.02192096f, 0.03705436f, -0.02602433f, -0.00462034f, -0.06399229f, 0.01513397f, -0.01404915f, 
    -0.05635147f, -0.10952306f, -0.18222614f, -0.02613784f, 0.03491735f, 0.09956335f, 0.09723867f, -0.05662744f, 
    -0.13748394f, 0.02544690f, -0.06733771f, 0.08009871f, 0.18043073f, 0.06895921f, -0.15738906f, -0.05741516f, 
    0.05307788f, 0.10739207f, 0.04305708f, -0.04763578f, 0.05016516f, -0.13774139f, 0.08004606f, -0.01373223f, 
    -0.14271088f, 0.01199221f, -0.06168650f, -0.01340660f, 0.02871164f, 0.00549928f, -0.04242641f, -0.18873957f, 
    0.03255758f, 0.07557347f, 0.01990906f, 0.01054842f, -0.06085965f, 0.20213789f, -0.06761230f, -0.02236138f, 
    -0.04284153f, 0.05210811f, -0.04140173f, -0.00757819f, -0.07784231f, 0.03155383f, -0.10808319f, -0.11335489f, 
    0.14428043f, 0.14850155f, 0.12684676f, 0.08307362f, 0.02968909f, -0.01702391f, -0.04865355f, 0.05335905f, 
    0.13459291f, 0.05701655f, 0.04043524f, -0.11717597f, -0.22032878f, 0.06554296f, -0.03077115f, -0.35658643f, 
    0.07709977f, 0.09441459f, 0.06575958f, -0.05687074f, -0.09028338f, -0.10999548f, -0.03928622f, 0.04095312f, 
    0.06430601f, 0.04586538f, -0.05635503f, -0.16716824f, -0.04826543f, -0.04829258f, -0.03491400f, -0.07402313f, 
    0.00433137f, 0.17419659f, -0.01222272f, -0.10171665f, 0.02539335f, 0.10187114f, -0.08622769f, -0.03119618f, 
    -0.04683641f, 0.03983720f, 0.02604437f, 0.01530239f, -0.01377940f, 0.04824053f, -0.05165966f, -0.04291643f, 
    -0.00641269f, 0.15044762f, -0.04453212f, 0.04267279f, 0.13120535f, -0.10006328f, 0.04990062f, -0.10220637f, 
    -0.01109359f, 0.02105201f, -0.01540430f, 0.02412594f, 0.13374145f, -0.10819194f, 0.04267449f, 0.03139851f, 
    -0.12390981f, 0.02018118f, -0.03040784f, -0.11308607f, 0.05712634f, 0.00926870f, -0.02229072f, -0.04648517f, 
    -0.15762065f, 0.23112892f, 0.15222901f, -0.00425670f, -0.08598217f, -0.09639560f, -0.01659000f, -0.02593220f, 
    0.14602879f, -0.01377202f, 0.09372523f, 0.12730195f, -0.01608589f, 0.24004036f, -0.13623372f, -0.07724531f, 
    -0.03472450f, 0.01278007f, -0.15297878f, 0.05615640f, 0.00837925f, -0.05403312f, -0.03603157f, -0.17573848f, 
    0.17468508f, -0.01206105f, -0.01932324f, 0.00852521f, 0.07392689f, 0.01052618f, -0.00891930f, 0.04258281f, 
    0.06231327f, 0.02267734f, 0.06324203f, 0.04575442f, -0.20596907f, 0.17852652f, -0.03983153f, -0.17799124f, 
    0.06534810f, -0.01911560f, 0.04840485f, -0.03166630f, 0.02039441f, 0.05237457f, 0.05878557f, -0.10646791f, 
    0.07162531f, -0.10279893f, 0.08054087f, 0.22833110f, -0.05024830f, 0.09143303f, 0.04505151f, 0.01807957f, 
    -0.09546406f, -0.00432501f, -0.06311972f, 0.15492190f, 0.26925847f, 0.01131610f, 0.06038993f, 0.03052009f, 
    0.03862501f, 0.10977716f, 0.08796544f, -0.13200825f, -0.02499209f, 0.03485501f, -0.00612205f, 0.14241327f, 
    -0.04426895f, 0.00137795f, -0.01932756f, 0.02856156f, -0.00238585f, 0.03560322f, -0.01313424f, 0.00404984f, 
    -0.03847418f, 0.01377755f, -0.04217735f, -0.04463466f, -0.03245838f, 0.01302213f, -0.05165058f, 0.04210205f, 
    -0.03254903f, 0.02160225f, -0.04447004f, -0.01322258f, -0.00342483f, 0.01235102f, 0.04246626f, -0.00810134f, 
    0.04352300f, 0.01053911f, -0.02074361f, -0.00705983f, -0.00926889f, -0.00091611f, -0.02640134f, 0.02840758f, 
    -0.05945707f, -0.02970969f, -0.03892527f, -0.01773621f, 0.02721061f, 0.00177327f, -0.00238502f, -0.05205833f, 
    -0.01901605f, -0.02219143f, -0.05012770f, -0.02445990f, -0.01730258f, 0.01517630f, -0.03949682f, -0.02497027f, 
    0.03775548f, -0.03395727f, -0.04866040f, 0.04049192f, -0.02315228f, 0.01212396f, 0.02767248f, -0.00103874f, 
    -0.02920676f, -0.01102256f, -0.02387238f, -0.04716733f, 0.01787659f, 0.01565806f, 0.04285040f, -0.00091221f, 
    -0.00949016f, 0.01298534f, -0.02845401f, 0.02476495f, 0.02641838f, 0.01767915f, -0.05403512f, 0.00680591f, 
    0.00389057f, 0.03765834f, 0.02829498f, 0.02666371f, -0.02837508f, 0.00234735f, 0.01263747f, -0.00673808f, 
    -0.05832886f, 0.00419834f, -0.01227237f, -0.03979659f, -0.01023719f, -0.01951244f, -0.03086120f, 0.03956839f, 
    -0.05541787f, -0.00126729f, -0.04933967f, 0.02079529f, 0.02769913f, -0.02165448f, 0.03293280f, -0.03994862f, 
    -0.03981912f, -0.00189929f, 0.00198180f, -0.01250339f, -0.01117682f, -0.05464312f, 0.00083069f, 0.03228426f, 
    0.03274055f, -0.00201084f, -0.02860634f, 0.04003845f, -0.04145735f, -0.00470135f, -0.03535389f, -0.01799032f, 
    -0.03906596f, -0.02751643f, -0.05115404f, -0.02881287f, 0.02009940f, 0.02885853f, 0.04263689f, -0.01616398f, 
    0.03227565f, 0.00549597f, 0.03634406f, -0.04962265f, 0.04735051f, 0.01492036f, 0.00759193f, -0.01761545f, 
    -0.00977884f, -0.00659677f, 0.02745029f, 0.03581454f, -0.00850798f, -0.03210337f, -0.00837606f, -0.02147518f, 
    -0.01670782f, -0.00432380f, 0.03025921f, -0.02373079f, 0.03292096f, 0.01103526f, -0.00137199f, -0.01105794f, 
    -0.04817486f, 0.00461076f, 0.03459032f, -0.02337871f, -0.03782768f, 0.01052455f, 0.04890910f, 0.02627680f, 
    0.03416637f, -0.01081177f, -0.02562215f, -0.03271066f, 0.02857745f, -0.05070540f, -0.03217098f, -0.02763154f, 
    -0.05428901f, -0.02066410f, -0.01722501f, 0.00027469f, 0.04625231f, -0.01633594f, -0.03258203f, 0.03688836f, 
    0.05139312f, -0.00380655f, -0.01511162f, -0.00936656f, -0.04905079f, -0.00722112f, 0.00351084f, 0.00790797f, 
    -0.04195350f, -0.00038409f, 0.04376156f, -0.00840280f, -0.01256669f, -0.04005839f, 0.00817388f, -0.02764207f, 
    0.03680386f, -0.05284658f, 0.03191397f, -0.00970183f, -0.03580786f, 0.00396091f, 0.03643850f, -0.02267304f, 
    -0.02783822f, 0.00928543f, -0.04769297f, -0.00598759f, 0.03114459f, 0.04344745f, -0.01615405f, -0.04990503f, 
    0.00677062f, -0.00330428f, 0.02360959f, 0.03818108f, 0.01629190f, 0.02899073f, -0.03360890f, -0.00856496f, 
    -0.05362175f, 0.00901149f, 0.02130502f, 0.04400460f, -0.05810780f, -0.05475738f, -0.04162913f, -0.00038180f, 
    -0.02397792f, 0.00654066f, 0.03180842f, 0.02509568f, -0.04090682f, 0.01735975f, -0.03724535f, -0.01141197f, 
    0.02708492f, 0.03994871f, 0.03967777f, -0.01848688f, 0.03093139f, -0.01130008f, 0.00118126f, -0.02362973f, 
    -0.01699723f, 0.02802584f, -0.03517440f, 0.00059344f, 0.03151005f, 0.04880518f, -0.01762107f, -0.00659736f, 
    -0.00983617f, 0.03214067f, -0.02883133f, -0.02767466f, 0.01919866f, 0.03752972f, -0.02066839f, -0.01213144f, 
    -0.00308427f, 0.03380493f, 0.01116711f, -0.04108971f, -0.04796021f, 0.01586694f, -0.04885114f, 0.02803472f, 
    0.00783176f, -0.05571977f, 0.01538492f, -0.03082277f, -0.02091386f, 0.02886288f, 0.01148868f, -0.04264551f, 
    -0.01097044f, -0.01060465f, -0.03589747f, -0.01215035f, -0.00736971f, -0.03195461f, -0.03264014f, -0.03845472f, 
    -0.00884750f, 0.01308833f, 0.02104235f, -0.01227756f, 0.03896340f, 0.01234306f, -0.02380500f, -0.03693692f, 
    0.00954877f, 0.00041124f, 0.00398531f, 0.00698737f, 0.00418373f, -0.02721105f, 0.03979875f, -0.01451575f, 
    -0.04809147f, -0.04169662f, -0.01789109f, -0.00118423f, -0.01267516f, -0.05639018f, -0.01811786f, -0.04808539f, 
    -0.02645732f, 0.00939942f, -0.03857917f, 0.02605419f, -0.00112554f, -0.02522251f, 0.02219531f, -0.00272440f, 
    0.03297568f, -0.04970770f, -0.02575588f, 0.01732506f, 0.00237348f, -0.03757615f, -0.00728726f, -0.04621826f, 
    -0.04523539f, -0.04638337f, -0.05298618f, -0.00730238f, -0.01152189f, -0.03554085f, 0.00457764f, -0.00716406f, 
    -0.05049361f, 0.04648653f, -0.05340337f, -0.04036936f, -0.02125489f, 0.03303638f, 0.01643410f, -0.05642536f, 
    -0.04478548f, -0.05743499f, 0.02935054f, 0.02428742f, 0.01100245f, 0.03211778f, 0.02317827f, 0.00989746f, 
    0.04477435f, 0.00073756f, -0.02433640f, -0.00842841f, 0.03198378f, -0.04283935f, -0.02358687f, -0.04008680f, 
    0.00108206f, 0.02226260f, 0.01457018f, 0.00211267f, -0.04251756f, -0.00522884f, -0.00928834f, -0.02978259f, 
    0.03826936f, 0.02205268f, 0.04218110f, -0.03126262f, -0.01790367f, -0.03397924f, -0.03375293f, -0.00943302f, 
    0.00331641f, 0.00265197f, 0.02862301f, -0.00072088f, -0.02311808f, -0.00115291f, 0.04036797f, -0.00381029f, 
    0.00324182f, -0.01667999f, -0.00489869f, 0.01999452f, 0.02210440f, -0.01236166f, 0.03546346f, 0.00875614f, 
    -0.04919580f, 0.03766763f, -0.02618381f, 0.03487433f, 0.02639967f, 0.02477886f, 0.03957842f, 0.00930389f, 
    -0.01574472f, 0.00587241f, -0.02750388f, 0.00233914f, 0.00579347f, -0.03395779f, -0.03531418f, 0.00233037f, 
    -0.04285653f, 0.02140119f, 0.04241773f, 0.01604728f, 0.00084483f, 0.03218259f, -0.03157495f, -0.03892332f, 
    -0.01188865f, -0.00831387f, 0.01075376f, -0.04391674f, -0.05339775f, -0.03828992f, 0.04086404f, 0.01117963f, 
    0.01835908f, 0.00680456f, -0.02314402f, 0.00542679f, 0.02198420f, 0.01592450f, -0.01963941f, -0.00931260f, 
    -0.00908306f, -0.01674952f, -0.00296278f, -0.00339907f, -0.02841736f, 0.01113845f, 0.01864178f, 0.03152345f, 
    -0.02526262f, 0.00215744f, 0.03544804f, -0.03541036f, -0.01112305f, 0.01359087f, -0.02743908f, -0.02487133f, 
    -0.00853098f, -0.05058284f, -0.00997408f, 0.00124039f, -0.05421772f, -0.03310057f, -0.02781844f, 0.00295997f, 
    -0.02164094f, 0.02700433f, 0.01594358f, -0.00980396f, -0.00254895f, 0.00210789f, 0.01901092f, 0.03860517f, 
    -0.03323064f, -0.01671298f, -0.01879266f, -0.01735144f, 0.04533192f, -0.03012043f, 0.01041000f, 0.01159496f, 
    0.01342077f, 0.03044642f, 0.02326341f, -0.00414213f, 0.03464320f, -0.03604227f, 0.02685474f, -0.02948615f, 
    0.03884676f, 0.01246111f, -0.03088840f, -0.03902496f, -0.04672395f, -0.03040927f, -0.01301908f, -0.00719908f, 
    -0.02373994f, -0.00631129f, 0.02703970f, -0.03606745f, 0.03011727f, -0.03770686f, -0.00890297f, -0.01180563f, 
    0.02206545f, -0.00546924f, -0.03737057f, -0.01303296f, 0.02931911f, 0.01239063f, 0.00928468f, -0.02936619f, 
    -0.00664229f, 0.02365157f, -0.01666103f, 0.02913971f, -0.01747867f, -0.01777136f, 0.00726288f, -0.05795940f, 
    0.04274590f, -0.04312144f, -0.00961932f, -0.03391123f, -0.04087774f, 0.01614494f, 0.02128302f, 0.00215334f, 
    -0.00759638f, -0.00003350f, -0.05712838f, -0.00323102f, 0.04344450f, -0.01231793f, -0.02463352f, -0.03696993f, 
    0.01424427f, 0.01111326f, 0.03797591f, -0.04203943f, -0.06108735f, 0.00752743f, -0.04089236f, 0.02087810f, 
    0.05536775f, -0.02831676f, -0.01497811f, -0.03259147f, 0.02944127f, -0.00529008f, 0.04018971f, 0.01633000f, 
    0.01168287f, -0.02456480f, 0.03038676f, -0.04077367f, -0.02329800f, 0.00919060f, -0.05443787f, -0.00083648f, 
    0.03626369f, -0.00803313f, -0.02140225f, -0.01415659f, -0.04320205f, -0.00708501f, 0.02315842f, -0.03958654f, 
    0.02786012f, -0.01398726f, 0.03360518f, -0.05522839f, 0.02817134f, 0.00851709f, -0.03075861f, 0.05523010f, 
    0.00102362f, -0.03224778f, 0.03014072f, -0.02026356f, 0.02969760f, 0.05553865f, 0.03153224f, -0.02157450f, 
    -0.05940139f, 0.01029043f, -0.00781409f, -0.01838627f, 0.02379040f, -0.04137244f, -0.05201014f, -0.06265147f, 
    -0.00766630f, 0.02527133f, -0.01046940f, 0.00738956f, -0.03765795f, -0.01547952f, -0.02867791f, -0.02224305f, 
    0.03335600f, 0.02355826f, -0.05739279f, -0.04277484f, -0.02972129f, 0.00490484f, 0.03038001f, 0.00829649f, 
    -0.02547641f, 0.01685168f, -0.00886566f, 0.03825217f, -0.01868251f, -0.03437861f, -0.02987086f, -0.05170862f, 
    0.02669198f, -0.01976112f, 0.02310153f, 0.02286715f, -0.04001990f, -0.04381786f, -0.02255549f, -0.06407671f, 
    -0.04481046f, -0.05408624f, -0.00341926f, -0.05074196f, -0.04136099f, 0.02554045f, -0.03421130f, 0.00900845f, 
    0.03966274f, -0.00300904f, -0.04460147f, -0.03452731f, 0.01357447f, 0.03150881f, -0.03743839f, -0.04361895f, 
    -0.01936216f, -0.00472263f, 0.03354800f, -0.02742644f, 0.01242620f, 0.01359172f, 0.04436931f, -0.02303516f, 
    -0.02595763f, -0.02753732f, -0.01780821f, 0.01441638f, -0.02827119f, 0.02959061f, 0.04839080f, 0.02232883f, 
    0.00172651f, -0.02629774f, 0.04427079f, -0.01259703f, -0.03355565f, 0.01182422f, -0.02140748f, 0.00252056f, 
    -0.05353145f, 0.04332294f, -0.03615945f, 0.02843040f, 0.00303177f, 0.00079105f, 0.01861359f, -0.03296172f, 
    -0.03948602f, -0.04191853f, -0.00834957f, -0.01399292f, 0.00370416f, -0.00906813f, -0.02071799f, 0.01885159f, 
    0.03204108f, -0.02480579f, 0.02188099f, -0.01850417f, 0.03138801f, 0.02201971f, -0.00211826f, 0.02465060f, 
    -0.04314807f, -0.03224941f, 0.03943861f, -0.00135947f, -0.04117904f, -0.01359862f, 0.00583274f, 0.04077595f, 
    0.03672289f, 0.01096543f, -0.00036593f, -0.02406886f, -0.05832673f, -0.01323448f, 0.00000905f, -0.02382544f, 
    0.01708758f, -0.04396914f, 0.02312438f, -0.02908268f, -0.06012706f, 0.03639163f, -0.04379927f, -0.02831670f, 
    0.01900025f, 0.00796274f, 0.03407632f, -0.01201005f, -0.05255247f, -0.03007352f, -0.00693299f, -0.05453116f, 
    -0.02619878f, 0.00916447f, -0.05296689f, 0.00268192f, 0.00823602f, 0.03195926f, -0.00406733f, -0.04563129f, 
    -0.00944134f, -0.01844345f, 0.03825096f, -0.04182716f, -0.03112117f, -0.02470263f, -0.01735167f, -0.04783939f, 
    -0.05601964f, 0.00749513f, -0.03471810f, -0.03000911f, 0.02434646f, 0.02168833f, -0.00672133f, -0.04321973f, 
    -0.03528744f, -0.06134373f, -0.03725471f, -0.01575922f, -0.03869661f, 0.00652075f, -0.01574262f, -0.01694778f, 
    -0.01843037f, -0.03321480f, -0.05076799f, -0.00837928f, -0.06015076f, 0.02852025f, 0.02303122f, -0.05425276f, 
    0.01580878f, -0.02955433f, -0.05048968f, -0.05725440f, -0.00939688f, -0.04569750f, -0.04874899f, -0.01603991f, 
    -0.02872725f, -0.01370499f, -0.04106983f, -0.04300893f, 0.01158869f, 0.02424012f, -0.04153417f, 0.03538848f, 
    -0.03114928f, 0.03934859f, 0.00404555f, 0.03581787f, 0.03458967f, -0.04674703f, -0.00534191f, -0.04029314f, 
    0.01912464f, 0.01143267f, 0.02384414f, 0.00064562f, -0.06923789f, -0.00646081f, -0.06546527f, -0.05821074f, 
    0.35857740f, -0.14553165f, 0.07842894f, 0.01702393f, -0.02233509f, -0.00016604f, -0.00337365f, 0.04689058f, 
    0.05794247f, -0.00214544f, -0.08396437f, 0.18558191f, 0.09210356f, 0.00211103f, 0.03257804f, -0.01012491f, 
    0.10112897f, 0.01501056f, -0.15623052f, -0.04013614f, 0.07934910f, 0.07368625f, 0.06463964f, -0.14354174f, 
    -0.05704075f, 0.05497830f, -0.02353629f, -0.00720232f, 0.11531439f, -0.00553490f, -0.03352730f, 0.02398061f, 
    0.06371625f, -0.01297513f, 0.02642458f, -0.17689526f, 0.04149483f, 0.10261619f, -0.02573656f, 0.18481983f, 
    0.00397367f, -0.00932309f, 0.17818840f, 0.05832582f, -0.03355927f, 0.13008876f, -0.04645467f, -0.05247586f, 
    0.11427479f, 0.06035006f, -0.13279930f, -0.27879581f, 0.04701730f, -0.07478649f, -0.04688208f, 0.03159349f, 
    0.02408613f, 0.00129436f, 0.12050825f, -0.01093323f, -0.18044262f, -0.01005608f, -0.12523928f, -0.23884863f, 
    0.02115828f, -0.00934074f, 0.02317132f, 0.04310281f, -0.02666419f, 0.02197433f, 0.02156708f, 0.05480614f, 
    -0.29643288f, -0.02100833f, -0.05069662f, 0.01695617f, 0.01712610f, 0.06492583f, 0.04391198f, 0.07996762f, 
    -0.11267442f, -0.02941022f, -0.02894709f, -0.12923516f, 0.09559810f, 0.05436781f, 0.10950739f, 0.19569001f, 
    0.05943322f, 0.03584573f, -0.04995001f, -0.02184796f, -0.06714619f, 0.06807896f, -0.05261294f, 0.05873399f, 
    -0.00475399f, 0.01457038f, -0.16466740f, -0.02395437f, 0.09669909f, -0.02080384f, -0.02077582f, -0.03544492f, 
    0.14771840f, -0.13954361f, 0.01475892f, 0.02026775f, -0.47402412f, -0.00367397f, 0.04633058f, 0.02132816f, 
    0.08740602f, -0.03274890f, 0.05028315f, -0.01147644f, 0.06505948f, 0.13538995f, -0.00758295f, -0.04004102f, 
    -0.40382847f, 0.17244250f, -0.01523871f, 0.19315262f, -0.04306780f, -0.02368937f, 0.04962569f, 0.01096544f, 
    0.11562188f, -0.01330432f, -0.10257847f, -0.00087528f, -0.07688875f, -0.02963543f, -0.08283690f, -0.19725125f, 
    -0.03338166f, 0.00167408f, -0.11124703f, 0.00040982f, -0.04271407f, 0.02184533f, 0.05165279f, 0.07016800f, 
    0.24414439f, -0.04565658f, -0.27592808f, 0.00366603f, -0.04017472f, -0.05891661f, -0.00201507f, -0.01172434f, 
    -0.00145345f, 0.07389585f, 0.13194180f, -0.04609007f, 0.19322358f, 0.14775409f, -0.04553708f, 0.01907582f, 
    -0.01377225f, -0.20343380f, 0.12156282f, 0.04454630f, 0.05020110f, 0.07923453f, -0.03061944f, 0.01723109f, 
    0.22627631f, 0.25496402f, -0.01440881f, 0.03698647f, -0.02352536f, -0.09598407f, -0.03413450f, -0.06359153f, 
    -0.07432657f, 0.04339755f, -0.03065251f, -0.04024163f, 0.08037336f, -0.21605007f, -0.07924255f, -0.12922561f, 
    0.09269276f, 0.12654224f, -0.03973158f, -0.06392027f, 0.09222551f, 0.10938251f, 0.03013243f, 0.07199458f, 
    0.21614197f, 0.18341878f, 0.09160167f, 0.14237969f, 0.03313143f, 0.03759614f, 0.05908616f, 0.02828079f, 
    -0.07486870f, 0.06584284f, 0.04603273f, -0.05576514f, -0.08761640f, -0.11564452f, -0.17494538f, 0.11811566f, 
    0.00450623f, 0.06111858f, -0.01446768f, -0.06035250f, 0.01002421f, 0.00822874f, -0.03631290f, -0.10311596f, 
    0.37236914f, -0.02834153f, 0.16769093f, 0.08724928f, 0.08145182f, 0.06198578f, -0.08067252f, 0.08608571f, 
    0.07589925f, 0.15842545f, -0.12731470f, 0.05637999f, -0.15335737f, -0.06039152f, -0.04438145f, 0.00118913f, 
    -0.00375925f, 0.02976977f, 0.11194228f, -0.09563123f, -0.07247861f, 0.10153962f, 0.05517827f, 0.05617633f, 
    0.06783427f, -0.05765986f, 0.09657723f, -0.01403188f, -0.00979832f, -0.05226247f, 0.02230589f, -0.09269676f, 
    0.05438246f, 0.01518425f, -0.12945333f, 0.00549010f, 0.13337405f, 0.27529982f, 0.09170881f, 0.03271649f, 
    0.07578396f, 0.07970984f, 0.11027008f, 0.01647356f, 0.02408157f, 0.03668067f, 0.01385839f, 0.14212964f, 
    0.27837083f, 0.13134077f, 0.12303872f, 0.09063103f, -0.02761669f, 0.04695954f, -0.01508330f, 0.02425917f, 
    0.01974090f, 0.00902605f, 0.08526458f, -0.17146222f, 0.28266680f, 0.05903934f, 0.19737077f, 0.11428539f, 
    0.02059611f, -0.04038297f, -0.05569480f, -0.07515024f, 0.08412755f, -0.05569787f, 0.14533114f, -0.07398451f, 
    -0.12269953f, -0.03638038f, 0.16593027f, -0.02106051f, -0.00505528f, -0.00069239f, 0.01539540f, -0.03206295f, 
    0.08313129f, 0.22898579f, 0.14869894f, 0.10847237f, 0.26106736f, 0.19427788f, 0.09573409f, 0.08001947f, 
    0.02900029f, 0.04460899f, 0.02065253f, 0.02209723f, 0.10290028f, -0.06052107f, 0.02782074f, 0.13987516f, 
    0.11431769f, -0.00195684f, -0.05988179f, -0.08945501f, -0.01191095f, 0.00760714f, 0.03772287f, 0.06240623f, 
    0.09575021f, 0.03467073f, -0.07608654f, 0.08532912f, 0.10925762f, 0.12591191f, 0.25937465f, 0.13128869f, 
    -0.01602193f, 0.04193295f, -0.01671727f, -0.03467876f, 0.13205521f, 0.10408186f, -0.07219282f, 0.07839601f, 
    -0.07343145f, 0.12712890f, -0.08688140f, 0.05806658f, 0.14355445f, 0.04426875f, -0.06554575f, -0.19178796f, 
    -0.03511510f, -0.07602908f, -0.17598492f, -0.04638310f, -0.23450263f, -0.18361469f, 0.00744550f, 0.00336281f, 
    0.02500843f, 0.00553153f, -0.03524156f, 0.00344220f, -0.01471687f, -0.00541828f, -0.00713278f, -0.05260983f, 
    -0.12572189f, -0.13665277f, 0.03063263f, 0.01602589f, 0.02624342f, 0.06811283f, -0.04184502f, 0.03550812f, 
    0.09021260f, -0.04211570f, -0.12713158f, 0.09983147f, 0.13230667f, 0.00734912f, -0.19729863f, 0.02948417f, 
    -0.00389615f, 0.06483144f, 0.17252278f, 0.12691694f, 0.00195681f, -0.01576363f, -0.15918480f, -0.20534900f, 
    -0.01836521f, -0.05420493f, -0.05936395f, 0.01066253f, 0.02373040f, 0.03848954f, -0.00464679f, 0.02190480f, 
    -0.00135508f, -0.04807933f, -0.01449638f, -0.02440428f, 0.02250400f, 0.03955467f, -0.02814104f, -0.01052135f, 
    0.01749902f, 0.03597042f, -0.01068927f, -0.04069852f, 0.01740682f, -0.00467284f, -0.00893452f, 0.04259896f, 
    -0.00099888f, -0.01871892f, 0.02169765f, -0.02967860f, -0.00082304f, -0.01505902f, 0.01318278f, 0.01598360f, 
    -0.01331246f, -0.01627614f, -0.05243320f, 0.01285907f, -0.05338483f, 0.00439585f, -0.01220779f, 0.03335664f, 
    -0.04886565f, -0.01699440f, -0.05496702f, -0.03004881f, 0.02696090f, -0.01765015f, 0.02442881f, 0.01164890f, 
    -0.04914239f, 0.00082006f, -0.00577249f, 0.02070554f, -0.02273681f, -0.00776779f, -0.00784569f, -0.01483831f, 
    0.01410106f, 0.00171870f, -0.02237486f, 0.00843917f, 0.01147154f, 0.01884120f, 0.00864692f, -0.02394681f, 
    -0.05007265f, -0.02013783f, -0.00901402f, 0.00264739f, -0.00519681f, -0.03853999f, 0.03998530f, -0.00156164f, 
    0.02827866f, 0.04087717f, -0.03479565f, -0.05280576f, -0.02849306f, 0.03555667f, -0.01666261f, -0.02295811f, 
    0.01916761f, 0.02040478f, 0.03212645f, -0.05029117f, 0.01779839f, 0.01865693f, 0.04216027f, 0.02817191f, 
    -0.03564690f, 0.00591184f, -0.01321531f, -0.03922778f, 0.01474787f, 0.03561293f, -0.03213871f, 0.01240493f, 
    -0.00476171f, 0.02639982f, 0.03673359f, -0.00425837f, -0.00564952f, 0.03359190f, 0.01652291f, 0.00639934f, 
    0.01151984f, 0.02197075f, 0.01345032f, -0.00570237f, 0.00276911f, -0.00390543f, -0.03691950f, -0.02679847f, 
    0.04741450f, -0.03915769f, -0.05110966f, 0.01253187f, -0.03702678f, -0.04076460f, 0.03995080f, -0.02852694f, 
    0.04338421f, 0.00134811f, 0.03055146f, 0.01414405f, -0.03101213f, 0.01866135f, -0.03437973f, -0.01567287f, 
    0.02548557f, -0.01337256f, -0.04345457f, -0.02275172f, -0.04270899f, 0.00011684f, -0.01828871f, -0.05031727f, 
    -0.01947857f, -0.05315132f, 0.04624492f, -0.04061131f, 0.03027865f, -0.02926105f, 0.01523191f, -0.04299600f, 
    -0.03517816f, 0.01366981f, 0.02683166f, -0.01460989f, 0.02968020f, -0.02116828f, 0.04028274f, 0.01654062f, 
    0.03815008f, -0.05064760f, 0.01846977f, 0.03373407f, -0.06320819f, -0.04641915f, 0.01708590f, 0.02729143f, 
    0.00341558f, -0.00537431f, -0.05263387f, 0.01366245f, -0.03709709f, 0.01251283f, -0.04643197f, -0.02329952f, 
    0.00414515f, 0.01319246f, 0.00508668f, 0.01841289f, 0.02700099f, 0.02988764f, -0.00008096f, 0.02599497f, 
    -0.02248496f, -0.01683880f, 0.00079357f, 0.03876324f, 0.02399686f, -0.05152937f, -0.00477410f, 0.04686627f, 
    0.02438225f, 0.03623497f, -0.05304729f, -0.05825852f, -0.03530322f, -0.02555609f, -0.02998832f, 0.01574972f, 
    -0.01589379f, -0.02819046f, -0.02809934f, 0.03026853f, -0.05210255f, -0.01261841f, -0.00384458f, 0.01153240f, 
    0.01722298f, -0.01302761f, 0.00294889f, -0.00746127f, 0.02248399f, 0.01157321f, 0.00151542f, -0.01187952f, 
    -0.00433305f, 0.01143054f, 0.03923782f, 0.02367125f, -0.01933252f, -0.00133900f, -0.01206656f, 0.03680893f, 
    -0.03809881f, 0.01746365f, 0.03288729f, 0.02114533f, -0.04580550f, 0.00306984f, -0.02068364f, 0.03485982f, 
    0.03570253f, -0.05167644f, -0.04194511f, -0.01964424f, -0.02004291f, 0.01699764f, -0.05594745f, 0.02942950f, 
    0.01462905f, -0.01914619f, -0.02997876f, -0.00659484f, 0.03948644f, -0.03877568f, 0.00719902f, -0.00078870f, 
    -0.04388367f, -0.04402003f, 0.02805365f, -0.03147828f, -0.04284164f, -0.01943808f, 0.00210024f, -0.00667824f, 
    0.01917860f, -0.03576296f, 0.02179823f, -0.00464499f, -0.04226473f, 0.03310338f, -0.03319663f, -0.02150953f, 
    -0.02179880f, -0.00561478f, 0.02512827f, -0.00916441f, 0.03655713f, 0.00728589f, 0.00730945f, 0.03531346f, 
    -0.00268344f, -0.04742061f, 0.02621335f, 0.01672872f, -0.03009880f, -0.01608153f, -0.00831408f, -0.04992007f, 
    -0.03155737f, -0.01082809f, 0.03265065f, -0.02211744f, -0.00221502f, 0.01022898f, 0.00785062f, 0.00853201f, 
    -0.00772696f, 0.00911537f, -0.01524611f, 0.04896589f, 0.02790938f, -0.02619755f, -0.00274732f, 0.03897232f, 
    -0.04805621f, -0.01208492f, 0.04038462f, -0.01885594f, -0.00383693f, -0.03927910f, -0.00694932f, 0.02529426f, 
    -0.04136354f, -0.02278565f, 0.02015737f, 0.04353705f, -0.02926734f, -0.00931721f, -0.03566173f, 0.00388631f, 
    -0.01818433f, 0.00416812f, -0.04948738f, -0.02723013f, -0.04300887f, -0.05099823f, 0.03296945f, -0.03317750f, 
    0.02250098f, -0.05411221f, 0.04180637f, 0.04328878f, 0.01051222f, -0.04328668f, -0.05670130f, -0.00300908f, 
    0.01134593f, 0.01118769f, 0.04312079f, -0.04791731f, -0.00516257f, -0.02102410f, -0.02214102f, 0.03602407f, 
    0.03070223f, -0.02956886f, -0.00949518f, -0.04426749f, 0.02852912f, -0.03405128f, -0.05470617f, 0.03311155f, 
    0.04364796f, -0.02835129f, -0.03691550f, 0.01017499f, -0.01992266f, -0.01870853f, -0.04317345f, 0.02284026f, 
    0.00411754f, -0.01044831f, -0.00006598f, -0.01644846f, 0.04433295f, 0.01412821f, 0.02295244f, -0.00382114f, 
    0.00432981f, -0.01045975f, 0.01915875f, 0.03174356f, -0.01477228f, 0.02093483f, 0.03504443f, 0.03357526f, 
    -0.02939522f, 0.00049805f, 0.00572464f, 0.01038237f, 0.02678968f, -0.00501368f, -0.00832726f, -0.02441736f, 
    0.01584540f, -0.03107716f, -0.02141037f, -0.00996377f, 0.03945278f, -0.01476931f, -0.04467307f, -0.04935420f, 
    -0.02982812f, -0.04604038f, 0.01221546f, -0.00516580f, -0.03341236f, -0.00639587f, -0.00426988f, 0.01986672f, 
    0.03066943f, 0.04241652f, 0.16626188f, -0.21986674f, -0.07507736f, -0.02599336f, 0.04837527f, -0.07671473f, 
    -0.09350771f, -0.02108942f, -0.00727941f, -0.00544372f, 0.09770950f, -0.24631479f, 0.16418926f, 0.11963970f, 
    -0.13274014f, -0.07733798f, 0.07911123f, -0.02845965f, -0.09853346f, -0.04736735f, -0.10237884f, 0.12636968f, 
    -0.09299855f, -0.06022165f, -0.14768630f, -0.10405914f, -0.04149358f, -0.04195911f, -0.06123071f, -0.13501936f, 
    -0.02532459f, 0.07107528f, 0.05443163f, 0.13688910f, 0.41765517f, -0.18314496f, 0.19994910f, -0.01468882f, 
    -0.09893493f, -0.06231537f, -0.04827797f, -0.00969772f, -0.00803833f, -0.03389411f, 0.19327021f, -0.08761569f, 
    -0.28463292f, 0.22730164f, -0.05659039f, 0.07332775f, 0.10799668f, 0.16859408f, -0.04228568f, -0.04762577f, 
    -0.00851445f, 0.03221625f, 0.01444466f, 0.04377505f, 0.00692779f, 0.11332676f, -0.04173249f, -0.14993252f, 
    0.13646291f, 0.07265640f, 0.06464531f, 0.04436078f, -0.06311291f, -0.02337633f, 0.03573744f, -0.00134638f, 
    -0.09465768f, 0.03286127f, 0.09417513f, -0.09038872f, 0.18060508f, -0.00382598f, -0.00395924f, 0.00088233f, 
    0.06223958f, 0.10708433f, 0.11180171f, -0.06602085f, 0.06491482f, -0.05793652f, -0.06555798f, -0.02697483f, 
    -0.06668812f, 0.03919814f, -0.09876823f, -0.05740852f, 0.09240073f, -0.04926132f, 0.04688361f, -0.00847454f, 
    0.26188725f, 0.08644704f, -0.06991181f, 0.04735915f, 0.07030054f, 0.08680961f, -0.05338109f, -0.03358996f, 
    -0.01921133f, -0.08089838f, -0.06909845f, 0.02789006f, 0.05153765f, 0.02457831f, 0.01836434f, -0.12173439f, 
    -0.09895829f, 0.08031332f, -0.17083317f, -0.17486766f, -0.12663123f, 0.04504739f, -0.00601455f, 0.10046209f, 
    -0.14058138f, -0.15881211f, -0.08827163f, 0.10209125f, -0.00152473f, 0.06254195f, 0.08370339f, 0.01110957f, 
    0.03379440f, -0.07029671f, 0.05381671f, -0.04874120f, 0.23187590f, 0.19660380f, 0.01014362f, 0.05563657f, 
    0.10833488f, 0.05841543f, 0.08667096f, -0.00555234f, 0.02688808f, 0.02578949f, 0.09229565f, -0.02976842f, 
    0.14564677f, 0.14010230f, -0.02295949f, 0.13260110f, 0.12584157f, -0.04959226f, 0.01376698f, -0.06440526f, 
    -0.04558241f, -0.02878176f, -0.04731752f, 0.04323776f, -0.15292343f, 0.12483142f, -0.31886068f, 0.13775776f, 
    -0.05786855f, -0.00327632f, 0.08416674f, -0.01402593f, -0.00047398f, 0.01264459f, -0.07540231f, 0.01196802f, 
    0.32425538f, 0.17227465f, -0.11707011f, -0.05957660f, -0.13943978f, 0.09319145f, 0.05139623f, 0.05962339f, 
    -0.04347468f, -0.03570900f, -0.02238339f, 0.00751852f, -0.11927856f, 0.00192725f, 0.25552401f, 0.17240684f, 
    0.04657723f, 0.03174770f, -0.03924073f, -0.11070920f, -0.02534442f, -0.04108405f, 0.07777281f, 0.14993122f, 
    -0.16992129f, 0.06686044f, -0.15981892f, -0.12099759f, -0.04890646f, -0.03334897f, -0.05757806f, -0.05414492f, 
    0.06713086f, 0.02229320f, -0.00794947f, 0.11579448f, 0.27718124f, -0.12946513f, 0.08063544f, 0.19229141f, 
    0.16584791f, 0.10801656f, -0.01357505f, 0.08567884f, 0.00399020f, 0.08444301f, 0.08773443f, 0.06424486f, 
    -0.06124820f, -0.20705964f, 0.09186241f, -0.03663235f, -0.02237269f, -0.02597995f, -0.05654090f, -0.01925451f, 
    0.02527253f, -0.02830968f, 0.08145666f, 0.07141925f, 0.54629010f, -0.14535250f, 0.02077326f, 0.22686873f, 
    0.09606493f, -0.08344353f, -0.07315750f, 0.08775618f, -0.03289378f, -0.08717697f, -0.11669529f, -0.04785871f, 
    0.33265793f, -0.12705876f, 0.11141700f, -0.16402790f, -0.12452769f, 0.09506570f, -0.00378654f, 0.02149579f, 
    0.02133437f, 0.07231950f, -0.02818596f, 0.05111972f, -0.09344264f, 0.20980814f, -0.08196995f, 0.06456356f, 
    0.07115319f, 0.02866226f, -0.01836479f, 0.00174579f, -0.11170307f, -0.12314126f, -0.08755566f, 0.04037457f, 
    0.27267504f, -0.30700126f, 0.13062721f, 0.17610689f, -0.09711991f, -0.02838134f, 0.01292731f, -0.19855151f, 
    0.03077510f, 0.10654479f, -0.06179553f, 0.04920504f, -0.14978075f, -0.06906562f, -0.09055687f, 0.13516527f, 
    -0.05261992f, 0.00385760f, 0.05655456f, -0.04231436f, -0.09291150f, 0.14376059f, -0.06620245f, -0.11860906f, 
    0.00352003f, -0.36893609f, 0.11681947f, 0.11693786f, 0.06518698f, -0.03122372f, -0.02332323f, -0.07882705f, 
    0.11333649f, -0.13541734f, 0.03864916f, 0.02549667f, -0.15784732f, 0.07036554f, -0.11865485f, -0.06916351f, 
    0.13272296f, 0.02422779f, 0.04627638f, -0.11492708f, 0.05693655f, 0.03455275f, 0.06788889f, -0.01477568f, 
    0.24002604f, -0.01364330f, 0.06391962f, 0.01839660f, -0.02185025f, -0.00938258f, 0.01600518f, -0.15092991f, 
    0.00160594f, 0.04755916f, 0.04483493f, 0.03539103f, 0.05958908f, -0.13368367f, 0.05102848f, -0.08237635f, 
    -0.06458392f, -0.04361695f, 0.00840487f, -0.10415938f, 0.08197739f, 0.13774620f, -0.08859300f, -0.12103649f, 
    0.29589638f, 0.44937104f, -0.06240216f, 0.04840961f, -0.03531100f, 0.06466322f, 0.01041965f, -0.00190078f, 
    -0.03941035f, -0.06063716f, 0.00084599f, -0.10199317f, 0.24487293f, -0.11069764f, 0.30806136f, 0.17119321f, 
    0.06045728f, -0.00120510f, 0.01403869f, 0.02512678f, 0.05861554f, 0.05144603f, 0.03595162f, -0.01059542f, 
    -0.12234987f, -0.04565971f, -0.11390555f, 0.01391456f, -0.06306593f, -0.00505661f, 0.02641181f, -0.05225760f, 
    0.01926898f, 0.01214757f, -0.00791268f, -0.07649068f, 0.03298518f, 0.08974483f, -0.00347171f, 0.00377625f, 
    0.03408262f, 0.10573807f, -0.02002019f, -0.06907310f, -0.10353494f, 0.00873059f, 0.21900736f, 0.03317924f, 
    -0.19100799f, -0.30946711f, -0.27051327f, -0.08504861f, 0.04712884f, -0.05460976f, 0.00821452f, 0.03291472f, 
    -0.05793329f, 0.02121033f, 0.00159929f, -0.06034851f, 0.00067796f, 0.02323671f, 0.04613718f, -0.17852312f, 
    0.03818718f, -0.01666519f, 0.06732184f, 0.00081336f, 0.01755804f, 0.03796723f, 0.06381574f, 0.00711827f, 
    -0.15074715f, -0.29434860f, -0.06569308f, -0.00823350f, 0.07603504f, 0.10478894f, 0.12299886f, -0.02245355f, 
    0.11641550f, 0.12426479f, 0.02718168f, -0.02297643f, -0.37370199f, -0.00187411f, -0.14148577f, -0.08189666f, 
    0.12047128f, -0.13015498f, 0.06425940f, 0.07664814f, -0.02661610f, 0.05863981f, 0.03117671f, 0.08480145f, 
    0.11925331f, 0.05262060f, 0.30262521f, 0.20985392f, 0.05912427f, -0.01891845f, 0.10221647f, -0.00106348f, 
    0.05688076f, -0.05899903f, -0.10098122f, 0.02203670f, 0.01890271f, -0.00994881f, 0.18042415f, 0.17784512f, 
    -0.12684715f, 0.12020542f, 0.01199226f, 0.07062040f, -0.11624508f, -0.03323470f, -0.04231322f, -0.01660881f, 
    0.06070821f, 0.06522254f, 0.11601337f, -0.01944698f, -0.09977505f, 0.00138729f, 0.17919126f, -0.02180175f, 
    0.10017058f, -0.07767102f, 0.08615827f, 0.08635531f, -0.01117193f, -0.03202783f, -0.05232555f, -0.24673265f, 
    0.04331453f, -0.00313322f, -0.04848463f, 0.05682806f, -0.09705617f, -0.04073045f, 0.00097585f, 0.17150335f, 
    -0.03369300f, -0.38761678f, -0.12357122f, -0.04660210f, 0.00894754f, 0.08040711f, -0.12336150f, 0.03312700f, 
    0.03647417f, 0.05042205f, -0.01155742f, 0.05539253f, -0.46083984f, -0.22340815f, 0.04518960f, -0.01629716f, 
    -0.01544673f, -0.03292441f, 0.12660971f, -0.00272588f, 0.04148467f, -0.08011241f, 0.01020868f, 0.10423503f, 
    0.50163120f, 0.08253593f, -0.04142322f, -0.12527283f, 0.17562589f, -0.09153036f, 0.10677583f, 0.04722263f, 
    -0.02281913f, -0.00424055f, 0.07324754f, -0.05059478f, 0.15519433f, 0.04296372f, 0.03770307f, -0.00185510f, 
    0.05371644f, 0.01231199f, 0.02165793f, -0.09802163f, -0.02112804f, 0.04744746f, 0.06532836f, 0.14886023f, 
    -0.09424393f, -0.10384528f, -0.06573328f, 0.07266979f, -0.07172424f, -0.03898413f, 0.05182605f, 0.00618089f, 
    0.00499066f, 0.04075110f, 0.06399196f, -0.01450059f, 0.23682843f, 0.05028999f, 0.10168572f, 0.00153836f, 
    0.02766437f, 0.06957070f, 0.07213733f, 0.01926397f, -0.01328045f, -0.04942892f, -0.01857304f, -0.01622596f, 
    -0.19838096f, -0.21605884f, -0.06917869f, -0.27921426f, 0.10775881f, 0.02841043f, -0.03462051f, -0.00771136f, 
    0.06976730f, -0.01121063f, 0.00453416f, -0.00763690f, -0.08048071f, -0.40641412f, 0.12932181f, 0.15190914f, 
    -0.04790282f, 0.02401562f, -0.02612300f, 0.11845677f, 0.00605964f, 0.08294088f, 0.11979068f, -0.02875176f, 
    0.08852188f, 0.00712015f, 0.15753423f, -0.03507875f, 0.00188931f, 0.03018311f, 0.16724308f, -0.01902827f, 
    -0.05447102f, 0.10283171f, 0.00118914f, 0.04547898f, -0.23052141f, -0.23285520f, 0.25350472f, 0.13760887f, 
    -0.01187214f, -0.01636076f, -0.12031136f, 0.11446656f, -0.07752565f, 0.04361379f, 0.05930308f, 0.05174913f, 
    -0.08905116f, 0.23080516f, 0.02746479f, -0.17803264f, 0.07207868f, 0.00651508f, -0.01633158f, -0.09167857f, 
    0.14049569f, -0.02003238f, -0.02562558f, -0.06794918f, 0.14455344f, -0.16753931f, 0.08589228f, 0.08787815f, 
    -0.19322707f, 0.05061511f, 0.17456688f, 0.01235493f, -0.09309737f, 0.04213494f, -0.09365786f, 0.02241949f, 
    -0.19958147f, -0.29500720f, -0.17989080f, -0.00894647f, 0.10707808f, -0.05177766f, 0.06177306f, -0.06751406f, 
    0.12994672f, 0.09779847f, 0.04197490f, 0.01142898f, 0.31383952f, 0.22141619f, 0.20483509f, 0.11240844f, 
    -0.04006285f, 0.06408389f, 0.09856752f, 0.02619518f, -0.14354375f, -0.11297996f, 0.02630260f, 0.03358676f, 
    0.03270817f, 0.14503607f, -0.02997187f, -0.29874015f, 0.01593125f, 0.17931314f, 0.11707587f, 0.03683529f, 
    -0.07228599f, 0.06400716f, 0.11910726f, -0.01394358f, 0.21185103f, 0.10141701f, 0.09845909f, -0.00256330f, 
    0.09019174f, 0.03238403f, -0.04175661f, -0.01144773f, 0.07800922f, 0.01022928f, 0.11531660f, -0.00457887f, 
    -0.04710878f, 0.27674875f, -0.06920558f, -0.11370345f, 0.14602970f, 0.06014103f, 0.08527655f, -0.03160420f, 
    -0.09023053f, 0.00189111f, -0.02749438f, 0.02193076f, 0.03903340f, -0.06597674f, 0.13757476f, 0.10063355f, 
    -0.04773458f, -0.00776109f, 0.04016718f, -0.06932547f, 0.08338362f, 0.02519588f, 0.03866486f, 0.13316935f, 
    -0.10643164f, 0.11791008f, 0.12847899f, 0.09415225f, 0.08436142f, 0.01414729f, 0.05747681f, 0.05198179f, 
    0.04546630f, 0.08837799f, 0.02030213f, -0.01925010f, 0.00871023f, 0.18271056f, 0.00058221f, -0.21602036f, 
    0.19552445f, -0.01252878f, 0.07118441f, 0.07598451f, 0.17620152f, 0.01910434f, -0.09300055f, -0.01464596f, 
    -0.06630297f, 0.09354509f, 0.10362952f, -0.10344953f, -0.05051752f, 0.02413821f, 0.04777925f, -0.09869620f, 
    0.08743723f, 0.13047995f, -0.05147408f, 0.03944536f, -0.03551998f, -0.19017188f, 0.09546305f, 0.08750883f, 
    -0.07711670f, 0.06057028f, 0.01632565f, 0.01400729f, -0.02461541f, 0.03134621f, 0.13383028f, 0.05745287f, 
    -0.06831804f, -0.08982275f, -0.09988742f, 0.04306057f, 0.03861202f, 0.03978718f, 0.04340645f, 0.02391344f, 
    0.06745602f, 0.09183607f, -0.07115703f, -0.00477453f, 0.21002479f, -0.06573974f, -0.02923761f, -0.04593968f, 
    0.05567637f, 0.06111128f, 0.06184310f, 0.14779346f, -0.01878533f, 0.10294935f, 0.09935971f, 0.06501061f, 
    -0.03565884f, 0.03768998f, 0.21120633f, 0.00912374f, -0.03006480f, 0.03381347f, 0.03433676f, -0.05021560f, 
    -0.07370521f, 0.10091145f, 0.10643046f, -0.03057611f, 0.09558371f, -0.03944584f, 0.04017727f, 0.09526760f, 
    -0.03153713f, -0.08602714f, -0.00007850f, -0.01569052f, 0.08293153f, -0.06808769f, -0.14016588f, 0.05180968f, 
    0.03164314f, 0.03284950f, -0.00329701f, 0.03996004f, 0.01939522f, 0.09086277f, 0.09879176f, -0.06215324f, 
    -0.02740788f, 0.04968445f, -0.04279166f, 0.04086872f, 0.35225320f, -0.00335021f, 0.10351828f, -0.08271169f, 
    -0.04086891f, -0.06139957f, -0.08094810f, 0.09257847f, 0.06530805f, 0.03713539f, 0.04728199f, -0.02867682f, 
    -0.38928309f, 0.14280695f, -0.01915189f, 0.32779992f, -0.07634386f, 0.08283637f, -0.01229697f, 0.00189213f, 
    0.14178990f, 0.03309383f, 0.03622592f, 0.06662069f, 0.04959595f, 0.03104557f, 0.03589430f, 0.10360900f, 
    -0.01288569f, -0.01282341f, -0.02669058f, -0.05976238f, 0.16495816f, -0.01315867f, 0.06858788f, 0.00018423f, 
    -0.08156722f, -0.11316222f, 0.05086349f, 0.13506134f, 0.10761258f, 0.12980309f, -0.10817379f, -0.07074973f, 
    0.12895714f, 0.07253852f, 0.01736700f, 0.00842932f, -0.44874609f, -0.00911513f, -0.09977023f, -0.08920486f, 
    0.17948678f, -0.12753759f, -0.09846888f, -0.05409025f, 0.08297405f, -0.06038633f, 0.01656704f, 0.00080112f, 
    0.04664122f, 0.10490911f, 0.16906726f, 0.28867811f, 0.03527623f, -0.01339407f, 0.02996948f, 0.01678643f, 
    -0.10532754f, 0.10988685f, -0.05914472f, 0.06519376f, 0.17504020f, 0.04419952f, -0.01439241f, 0.18846095f, 
    -0.05189121f, 0.07895037f, 0.00315321f, -0.10714816f, 0.00883912f, -0.00454008f, 0.04762862f, 0.06701786f, 
    0.34495747f, -0.09408094f, 0.05729819f, -0.21478680f, 0.06122413f, 0.03675057f, -0.06031477f, 0.04460382f, 
    0.00425235f, 0.08180986f, 0.01371751f, 0.04645785f, -0.04887031f, 0.12918663f, 0.04908961f, 0.01620643f, 
    0.03573610f, -0.02701188f, 0.08128448f, 0.00784267f, -0.03630523f, 0.04004899f, 0.00312321f, 0.03976868f, 
    0.05425163f, 0.08221246f, 0.18566810f, -0.03081651f, 0.03101742f, 0.08812628f, 0.00149455f, -0.04717217f, 
    0.03128459f, 0.08238073f, -0.06648901f, 0.04487611f, 0.04077607f, 0.03764033f, 0.05679218f, 0.08287722f, 
    0.01980406f, 0.20930241f, 0.01631654f, 0.01764001f, 0.08658717f, -0.07368998f, 0.07374374f, -0.02196364f, 
    -0.05400858f, 0.14807877f, 0.10591685f, 0.12488981f, -0.06578941f, 0.02765191f, 0.00765407f, 0.06254955f, 
    0.00941974f, -0.03732276f, 0.04359807f, -0.02673338f, 0.37984219f, 0.01172261f, 0.16389985f, 0.19304053f, 
    0.05477091f, 0.00072066f, 0.03537688f, 0.03698941f, -0.03765151f, -0.02687345f, 0.03256047f, 0.00619835f, 
    -0.35913429f, -0.24666314f, -0.06043787f, -0.16496840f, 0.12082258f, 0.13986246f, -0.05267490f, -0.03642392f, 
    -0.02089444f, 0.03920481f, 0.06363134f, -0.08607075f, 0.32854050f, 0.04757665f, -0.05739563f, -0.14099582f, 
    0.18364798f, 0.01909779f, -0.00343601f, 0.00367815f, 0.01638509f, -0.07144777f, 0.03253614f, 0.06600934f, 
    -0.26442850f, 0.03712736f, -0.08190709f, -0.03496179f, 0.08080489f, -0.08876587f, -0.02587254f, -0.06061276f, 
    -0.06858918f, -0.19148669f, 0.01202824f, -0.00604001f, 0.04197312f, 0.24768488f, -0.14237227f, -0.09368668f, 
    0.03895653f, 0.02735069f, -0.07526079f, 0.16775706f, 0.10167344f, 0.03097871f, 0.09328478f, -0.02380598f, 
    0.03769523f, 0.20214990f, 0.08693763f, 0.22634989f, -0.01603052f, -0.09078120f, 0.01515914f, 0.10018422f, 
    0.10406072f, -0.03496084f, 0.11115868f, 0.02905361f, -0.28350019f, -0.19982886f, -0.07916147f, -0.07263036f, 
    0.11233014f, 0.13051645f, 0.06722797f, -0.00399060f, -0.03511046f, 0.07549580f, 0.07369947f, 0.06244103f, 
    -0.17335333f, 0.08687074f, -0.03711317f, 0.00909998f, 0.07401757f, 0.00306959f, 0.03491792f, 0.04523634f, 
    -0.03098123f, 0.00555895f, -0.02932517f, 0.10390581f, -0.40170759f, -0.02785643f, -0.06041186f, -0.12957641f, 
    -0.00007891f, 0.11422808f, -0.01261136f, 0.00895204f, 0.01742202f, 0.09583395f, 0.03342415f, 0.11166396f, 
    -0.23739007f, 0.11854089f, -0.16288923f, -0.03646803f, 0.22836886f, 0.02076918f, 0.01433518f, -0.02768400f, 
    0.04924811f, -0.13070522f, 0.08507319f, 0.02038703f, -0.24242049f, -0.14321683f, -0.02073457f, -0.11501764f, 
    0.00215761f, 0.03305173f, -0.00886124f, -0.07105052f, -0.00712883f, 0.06863199f, -0.00728157f, -0.00484874f, 
    -0.12976146f, 0.37129852f, 0.08632967f, 0.22585067f, -0.00703093f, -0.03064948f, 0.09424546f, 0.01213142f, 
    0.16351229f, -0.00128658f, 0.13049158f, 0.03760630f, -0.03509744f, 0.08819293f, -0.20598787f, -0.08545750f, 
    0.01617777f, -0.08548365f, 0.04483733f, -0.00421089f, 0.00753242f, -0.04974028f, 0.10823189f, -0.08927595f, 
    0.06768785f, -0.15715846f, -0.03018740f, -0.01733878f, -0.04816889f, -0.04824284f, 0.06990904f, 0.10614422f, 
    0.08006596f, 0.03791394f, 0.08946712f, 0.19835307f, 0.10071712f, 0.22014454f, -0.14389691f, -0.06934074f, 
    0.19369377f, -0.03207528f, -0.06368314f, 0.15115769f, 0.04169897f, 0.02000966f, 0.13315861f, 0.00461987f, 
    0.12813511f, 0.01985013f, 0.06545491f, 0.12054120f, -0.01147936f, 0.07876265f, 0.03794075f, -0.04435038f, 
    -0.04201693f, 0.01812532f, 0.06464823f, -0.00089096f, -0.04218768f, -0.12382619f, 0.15267223f, 0.01468916f, 
    -0.00551865f, 0.02125092f, 0.02921750f, -0.06760712f, -0.01927986f, 0.03545650f, -0.02730074f, 0.07954203f, 
    0.00851558f, 0.12833802f, 0.22452298f, 0.03273101f, -0.16155782f, -0.07029788f, -0.06354130f, -0.05075536f, 
    -0.00314193f, 0.00153978f, 0.00179224f, 0.01613507f, 0.19110388f, 0.05699423f, 0.01084242f, 0.15340920f, 
    0.04239206f, -0.01815138f, 0.02867574f, -0.02380749f, -0.02804697f, -0.01437100f, -0.01246288f, 0.13917024f, 
    0.02693201f, 0.00049608f, -0.05948719f, -0.11975529f, -0.13013068f, -0.05711480f, -0.14886510f, -0.04746298f, 
    0.17377102f, -0.00358339f, 0.00548431f, -0.07838796f, 0.03744152f, 0.03755254f, 0.21850981f, -0.00949825f, 
    -0.02804739f, 0.00046923f, -0.14411208f, 0.03908906f, 0.03695262f, -0.08254260f, 0.10834492f, 0.00459785f, 
    0.05025784f, 0.37094542f, 0.08268036f, -0.40781519f, -0.02210769f, -0.01569425f, -0.10000000f, 0.03102784f, 
    0.06693532f, 0.10730264f, -0.00357368f, 0.18285450f, 0.17697473f, 0.09296954f, -0.07086544f, -0.15164931f, 
    0.14072835f, -0.01187424f, 0.07008549f, 0.05994132f, 0.07813738f, 0.03105967f, 0.06215227f, -0.00300252f, 
    0.15391818f, -0.08067127f, -0.01932682f, -0.13235259f, 0.00690054f, 0.00621229f, 0.01839410f, 0.14118798f, 
    0.07088582f, 0.05660986f, -0.06642361f, 0.00176976f, -0.08957899f, -0.33994132f, -0.06248443f, 0.43989819f, 
    -0.01272503f, 0.05092243f, -0.01971442f, -0.06668223f, 0.00593117f, 0.01809071f, 0.11769396f, -0.01661700f, 
    0.10186709f, 0.23602404f, 0.10101174f, -0.15005544f, -0.09235697f, 0.07118865f, 0.01590237f, 0.03392612f, 
    0.07894289f, -0.00401298f, -0.03447755f, -0.06097782f, 0.08043142f, -0.09095632f, 0.06351975f, -0.28721157f, 
    -0.02486724f, -0.06951883f, -0.06018973f, -0.01455027f, 0.14487819f, 0.02084400f, -0.02856754f, 0.04630051f, 
    -0.13984351f, -0.04338687f, 0.03749518f, 0.12782675f, -0.10616403f, -0.02349306f, -0.05905784f, 0.04306146f, 
    -0.02994951f, -0.02377700f, -0.02358215f, 0.09157619f, -0.19673479f, -0.10334495f, -0.11580287f, 0.08095969f, 
    0.00723168f, 0.01948910f, -0.05352414f, -0.01588569f, 0.08377466f, -0.00110874f, -0.02749851f, -0.00336274f, 
    -0.03030066f, 0.21763648f, -0.03886347f, -0.00407468f, -0.01359535f, -0.04355684f, -0.05606013f, -0.13362981f, 
    -0.03158604f, -0.02114719f, 0.06058000f, 0.02710231f, 0.00834823f, 0.03683127f, 0.01001029f, -0.13818529f, 
    -0.01737563f, 0.02302753f, 0.09832673f, -0.08523382f, -0.04376056f, 0.02022749f, -0.00656522f, 0.11335222f, 
    0.26895308f, 0.14115925f, 0.08152341f, -0.06982896f, -0.03739249f, -0.00471182f, 0.05744966f, 0.05103880f, 
    -0.12591337f, -0.00954007f, -0.05086800f, -0.06094201f, -0.44117528f, 0.36736625f, 0.19032511f, -0.18071285f, 
    -0.00887236f, 0.08172943f, 0.05682064f, 0.13185996f, 0.00900033f, -0.02341342f, 0.00608737f, 0.13248548f, 
    0.17774941f, -0.05827179f, -0.25561816f, 0.06894413f, 0.17216949f, -0.05936017f, -0.09733690f, 0.01998746f, 
    0.06401435f, 0.06924506f, 0.00535550f, -0.02293545f, -0.14352266f, 0.05692304f, 0.08664342f, -0.02660689f, 
    -0.11369648f, -0.01852342f, 0.11436201f, 0.04105728f, 0.16125950f, -0.07920512f, 0.14644976f, 0.06121364f, 
    0.05356688f, -0.12837490f, -0.04225469f, 0.17530753f, -0.01572808f, -0.01963330f, 0.04648738f, -0.04861712f, 
    -0.06691495f, 0.09361906f, 0.03173789f, -0.00250241f, 0.08374029f, -0.05916568f, 0.09524313f, 0.09655956f, 
    0.17377047f, -0.00647595f, -0.00905525f, -0.00141983f, 0.10675259f, 0.01592335f, 0.03363926f, 0.04470010f, 
    0.13594213f, 0.00347294f, 0.19002301f, -0.10084412f, -0.02021674f, -0.00635771f, -0.04829540f, 0.11942347f, 
    -0.02588938f, -0.08308505f, -0.06643545f, -0.05050483f, 0.24149239f, 0.00501600f, -0.15891275f, -0.09297225f, 
    0.09944063f, -0.03186009f, 0.10525208f, 0.04080684f, 0.00465579f, -0.01072966f, -0.00284816f, 0.02162983f, 
    0.11339916f, -0.20443031f, -0.01460898f, 0.27035844f, -0.00113709f, 0.01154002f, 0.03400414f, -0.04094420f, 
    -0.02614131f, 0.17809023f, -0.10703236f, 0.00918207f, 0.16087544f, -0.12445530f, -0.10707951f, 0.07155383f, 
    0.03413492f, 0.03060716f, -0.03364793f, -0.00525966f, 0.13370058f, -0.02859272f, -0.07057928f, -0.01481136f, 
    0.19822703f, -0.41692677f, 0.11559433f, 0.41804492f, -0.06601162f, -0.02657117f, -0.03280948f, -0.06687123f, 
    0.05328611f, -0.02093246f, 0.06015513f, -0.02179452f, 0.29918402f, -0.06051404f, -0.15205695f, 0.06187317f, 
    0.01520967f, 0.03404414f, -0.08454902f, 0.04535128f, -0.07253369f, -0.02496257f, -0.03275188f, -0.01919779f, 
    0.31551963f, -0.04312439f, 0.09746871f, 0.00427914f, -0.06351557f, -0.06622349f, 0.03981159f, -0.01034705f, 
    -0.05019600f, -0.06078255f, 0.11856703f, 0.09293398f, 0.07618137f, -0.15752664f, -0.05647905f, 0.18283145f, 
    0.13002418f, 0.09530677f, -0.14488225f, -0.08886640f, -0.06413604f, 0.03573323f, -0.05080944f, -0.10265152f, 
    0.12216223f, 0.04878915f, -0.08701992f, -0.21653418f, -0.02217060f, 0.05641269f, -0.05153549f, -0.01209531f, 
    0.00558964f, 0.02564215f, -0.01252127f, 0.01531909f, 0.14547515f, -0.01513389f, 0.11462512f, 0.07868638f, 
    0.02164043f, 0.07580180f, 0.02397443f, -0.04160581f, 0.19107231f, 0.04845721f, 0.04967316f, -0.01445105f, 
    -0.03950115f, 0.05528232f, -0.00497002f, -0.12253975f, -0.10842609f, -0.11013275f, 0.04532344f, 0.00992768f, 
    0.00620336f, 0.03644802f, -0.09059076f, 0.07498115f, 0.23900844f, 0.17291336f, -0.13629487f, 0.00430366f, 
    -0.08364151f, 0.11043305f, -0.06950894f, -0.09653477f, 0.02651310f, 0.09349533f, -0.02805785f, 0.01885671f, 
    -0.05616729f, 0.10328256f, -0.02879637f, -0.01339351f, -0.00469831f, -0.00769529f, 0.02657400f, -0.01404626f, 
    0.03942264f, -0.02001662f, 0.04700360f, -0.04449327f, -0.20879611f, -0.09626891f, 0.13300112f, -0.14379625f, 
    0.02937373f, 0.20609373f, 0.11313491f, -0.03520652f, 0.01531006f, 0.05703368f, 0.05401550f, 0.06801002f, 
    -0.01900451f, 0.16821061f, -0.10832566f, 0.07050399f, -0.06138112f, -0.05530643f, -0.04694151f, -0.09392429f, 
    -0.00828756f, 0.01067612f, 0.08948488f, 0.06442498f, -0.07315890f, -0.09170306f, -0.05007362f, -0.03579413f, 
    0.07249898f, 0.08501484f, -0.06773560f, -0.00456083f, 0.03471198f, -0.02559156f, 0.00664632f, -0.01881569f, 
    0.39464825f, -0.04139385f, -0.28023311f, 0.14876059f, 0.12029947f, -0.02206973f, 0.08672988f, -0.00156594f, 
    -0.05185895f, 0.11948953f, 0.02118846f, -0.13987036f, -0.00889443f, -0.01124406f, -0.13689281f, 0.05350862f, 
    -0.01451708f, -0.11992954f, 0.00176630f, 0.05562867f, -0.04882618f, -0.06278870f, -0.02716231f, -0.04682298f, 
    0.18260936f, 0.19449282f, -0.28079098f, -0.06526839f, 0.09054840f, -0.06722061f, 0.00691964f, -0.07573383f, 
    -0.10135564f, 0.06474005f, -0.03071651f, 0.00341035f, 0.39771292f, -0.10606921f, 0.20687193f, -0.07860890f, 
    0.01081977f, 0.11375068f, 0.02732707f, -0.06734888f, 0.18384895f, 0.04503678f, 0.10048801f, 0.08366877f, 
    -0.03794580f, 0.04097218f, -0.02785008f, 0.05000938f, -0.05793659f, 0.10451382f, 0.06480401f, -0.01044369f, 
    0.00712533f, 0.00284588f, 0.07116608f, -0.03589475f, 0.25470257f, 0.06925464f, -0.04511768f, 0.12026509f, 
    -0.16057675f, 0.01651631f, -0.08706351f, 0.00090346f, -0.08521038f, -0.02588370f, 0.00458611f, -0.08943547f, 
    -0.38926420f, -0.10023715f, -0.12826261f, -0.09535521f, -0.03270258f, 0.09667368f, 0.00094664f, 0.05752183f, 
    -0.00466344f, -0.11963871f, -0.02031700f, -0.04474006f, 0.14192316f, 0.07819624f, 0.00238452f, 0.11823530f, 
    -0.00884572f, 0.09854788f, -0.01128112f, 0.05560400f, 0.06218738f, -0.04589148f, -0.14403008f, -0.06216509f, 
    0.02639551f, 0.06344843f, 0.05052056f, 0.01100211f, 0.07703789f, 0.01769800f, -0.02247367f, 0.12392627f, 
    -0.01776965f, -0.00373681f, -0.04880400f, -0.05191099f, -0.36142862f, 0.09173410f, -0.11840447f, -0.10175396f, 
    -0.04722588f, -0.05484422f, -0.06195397f, 0.05199594f, 0.00364650f, -0.05559461f, -0.06395268f, -0.05476389f, 
    -0.02624400f, -0.02553603f, -0.04727942f, 0.19432332f, -0.05882886f, 0.02828130f, 0.05797376f, 0.06306268f, 
    0.09614735f, 0.09653585f, 0.05216523f, -0.00229159f, -0.18526024f, 0.12701207f, -0.04552265f, 0.25826958f, 
    -0.02372061f, 0.00172835f, 0.08040968f, -0.18284179f, 0.01471420f, -0.09911778f, -0.13064176f, -0.00164551f, 
    0.10131935f, 0.43743449f, 0.04363269f, -0.18134272f, -0.09723530f, -0.03656374f, 0.03998804f, 0.08324095f, 
    0.06381104f, -0.05070039f, 0.03376213f, 0.11390478f, 0.39571878f, 0.09075256f, 0.03621504f, 0.04197470f, 
    -0.03895358f, 0.07435715f, 0.01807968f, 0.07473319f, -0.08542677f, 0.16471575f, 0.03822725f, 0.03104196f, 
    0.00413245f, -0.11769444f, 0.16769378f, -0.08157160f, -0.01700679f, 0.01611903f, 0.01720236f, 0.14517741f, 
    -0.05790667f, 0.07828833f, 0.01870348f, -0.03316845f, 0.22381262f, -0.08902376f, 0.27037597f, 0.18720719f, 
    0.02961429f, -0.01230877f, 0.03782871f, 0.02119885f, -0.13816296f, -0.16697302f, -0.02497737f, 0.02307507f, 
    0.10313807f, -0.05355394f, 0.14971022f, -0.04633218f, -0.00102567f, 0.16161561f, -0.04689758f, 0.01672098f, 
    0.03462514f, 0.12727104f, -0.04221293f, -0.07113677f, -0.00221078f, 0.06463457f, -0.04379202f, 0.22953105f, 
    0.03258342f, -0.07251202f, 0.02235847f, 0.01528728f, -0.01521705f, -0.17545523f, -0.02305625f, -0.07406425f, 
    0.06257110f, -0.28745607f, 0.18822737f, 0.08016560f, -0.03931344f, 0.01253981f, 0.04720550f, 0.05613583f, 
    0.05888097f, 0.00553911f, -0.04709223f, 0.12796964f, 0.04661049f, 0.14568380f, 0.08822138f, -0.01357475f, 
    -0.03455927f, 0.07010584f, 0.10214681f, 0.17823243f, -0.10220252f, 0.07923253f, -0.03555093f, -0.03185589f, 
    0.25657400f, -0.08750478f, 0.11659522f, 0.12336122f, 0.02758334f, 0.10810892f, 0.03817649f, -0.01289209f, 
    -0.05149651f, -0.08113402f, -0.05584903f, -0.02632637f, -0.02073261f, 0.30570084f, -0.01675358f, -0.12891416f, 
    -0.02650835f, -0.00687472f, 0.12335069f, 0.05453086f, -0.08396965f, 0.08101587f, -0.01979528f, -0.10549397f, 
    0.05837497f, -0.31263909f, -0.12016343f, -0.04529731f, 0.11539342f, -0.08119734f, 0.06982046f, -0.03840284f, 
    -0.05383919f, -0.03776104f, -0.06756088f, -0.17420220f, 0.08932357f, -0.07309295f, 0.22333561f, 0.00074422f, 
    -0.04469086f, -0.00814095f, 0.13986254f, -0.01559716f, -0.02246213f, 0.06144647f, -0.02079047f, -0.02772597f, 
    -0.08391687f, 0.17580646f, 0.01702062f, 0.04212018f, 0.09498986f, -0.00203186f, 0.13698688f, 0.16268496f, 
    -0.10994460f, 0.09644571f, 0.07930884f, -0.00645489f, 0.31565580f, -0.17559218f, 0.10376485f, 0.37070605f, 
    -0.10028882f, 0.07889037f, 0.14620912f, -0.03672194f, -0.04276865f, 0.04287320f, -0.19514118f, 0.00901566f, 
    0.00443926f, 0.02023822f, -0.14526042f, 0.01400272f, -0.04668266f, -0.08038110f, -0.09023619f, -0.12648085f, 
    0.03204767f, -0.00745227f, 0.12088392f, -0.10087489f, -0.20586856f, 0.11528344f, -0.03102182f, -0.09132785f, 
    0.03705771f, 0.04465263f, -0.08146080f, 0.10896868f, -0.04310617f, 0.03559432f, 0.14252074f, 0.01018491f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.02959331f, 0.03678416f, 0.08516175f, -0.02845292f, 0.00621888f, 0.02608581f, 0.01469005f, -0.00700273f, 
    -0.00744074f, -0.02761455f, -0.00969925f, -0.03993802f, 0.01288703f, -0.02453859f, 0.05728357f, -0.10109348f, 
    -0.01947948f, -0.00669624f, -0.01588879f, 0.05219332f, -0.01459145f, -0.00269006f, 0.12801363f, -0.01365173f, 
    0.02508804f, -0.01485359f, 0.09301413f, -0.04180186f, 0.11666544f, 0.02387403f, -0.01063822f, 0.09979291f, 
    0.05720602f, -0.02437185f, -0.05827703f, 0.00415296f, -0.04119867f, -0.05625786f, -0.01367753f, -0.00888977f, 
    -0.00538144f, 0.05813692f, 0.08576425f, -0.02801395f, 0.00400170f, 0.03997150f, 0.08372557f, 0.06956915f, 
    0.00778289f, -0.04583317f, -0.03703990f, 0.02509424f, 0.04361120f, -0.03381720f, -0.02947719f, -0.02836979f, 
    -0.04384126f, 0.00229292f, -0.04219003f, 0.00555789f, 0.00466427f, 0.03047264f, -0.05139020f, -0.02713156f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.20838585f, 0.04093805f, 0.21379404f, 0.11133894f, 0.11331697f, 0.28299809f, -0.31510252f, -0.33501264f, 
    -0.28097102f, -0.10079186f, 0.05015874f, 0.10448212f, -0.31256539f, -0.08688179f, -0.19423552f, 0.20510094f, 
    0.10740396f, 0.03149580f, 0.08233274f, 0.23037052f, 0.11278596f, -0.05733221f, -0.22132282f, 0.30039930f, 
    0.09352427f, -0.06988164f, 0.04427695f, -0.03601037f, -0.09873465f, 0.09688876f, -0.41638890f, -0.09173488f, 
    -0.61109072f, 0.10356960f, -0.04343906f, 0.14906749f, 0.16305165f, 0.10245930f, -0.04024473f, -0.04374566f, 
    0.10265128f, -0.38599664f, -0.02444051f, -0.04199912f, 0.05287531f, -0.10894588f, -0.54460764f, 0.14101733f, 
    -0.02516739f, -0.07061253f, -0.00422114f, 0.12461148f, -0.04292266f, 0.10712527f, 0.04876828f, 0.11254161f, 
    0.04386707f, -0.05123519f, 0.00821344f, 0.30264366f, -0.16219591f, -0.24385294f, 0.24612021f, -0.07934589f, 
    -0.35956505f, 0.08059368f, 0.01712934f, 0.09479076f, 0.15291801f, -0.31468552f, -0.23920237f, 0.14804180f, 
    -0.44722888f, 0.09609752f, -0.21292344f, -0.00569736f, -0.32922146f, -0.03105512f, 0.34517735f, 0.02703999f, 
    0.09251247f, 0.02341097f, 0.24721092f, -0.07290809f, 0.07803252f, 0.23545510f, 0.00210532f, 0.10628457f, 
    -0.05451908f, 0.05136766f, 0.00008135f, 0.02126233f, 0.11464397f, 0.00992253f, 0.15670727f, 0.05225047f, 
    0.17034703f, -0.10381532f, 0.09556918f, 0.05569464f, -0.23142500f, -0.07846378f, -0.09669238f, -0.13669547f, 
    -0.08555864f, -0.26115558f, 0.14534320f, 0.01368786f, 0.05911842f, 0.03669063f, 0.16273686f, -0.04540690f, 
    0.08027147f, 0.02813458f, -0.06812097f, 0.00718179f, -0.06615688f, 0.30767760f, -0.15884843f, -0.07183650f, 
    -0.04453686f, 0.21159351f, 0.07731696f, -0.42915630f, -0.02245465f, -0.49432671f, 0.03552960f, 0.00123896f, 
    -0.30869594f, 0.01656877f, 0.12208808f, -0.11930485f, 0.01311034f, -0.34156781f, 0.33557200f, -0.03700108f, 
    0.08134352f, -0.06047468f, -0.46712592f, -0.28735754f, -0.31988686f, -0.06330597f, -0.13577880f, -0.17815155f, 
    -0.02711427f, -0.09204233f, 0.18191373f, 0.06418888f, 0.09942927f, 0.07355295f, -0.49699628f, -0.02017448f, 
    0.10358083f, 0.02086753f, 0.13622269f, -0.02907225f, -0.57301188f, 0.09650780f, 0.39874911f, 0.00299773f, 
    0.12383790f, -0.09997831f, -0.04316933f, -0.00879860f, 0.16292927f, 0.11375972f, -0.03148900f, -0.07798202f, 
    -0.05852615f, -0.29505461f, -0.00390244f, 0.04752102f, -0.08818025f, -0.02534640f, 0.09108228f, 0.01383741f, 
    0.08260959f, 0.08819781f, -0.05069382f, 0.08182384f, -0.00736550f, -0.33869505f, 0.31962952f, -0.03725808f, 
    -0.13376565f, 0.16328321f, 0.01072123f, 0.38064942f, -0.31810206f, 0.01211467f, 0.05835595f, 0.24112034f, 
    0.20184068f, -0.06151662f, -0.20477267f, -0.08970965f, -0.22030267f, 0.00008313f, 0.32623461f, -0.23489599f, 
    -0.14073485f, 0.00383820f, -0.05122070f, -0.30367240f, -0.09686257f, 0.04331142f, 0.19606437f, 0.14720836f, 
    -0.07014921f, 0.08159820f, 0.06119377f, -0.07128803f, 0.07352962f, -0.49917123f, 0.29939905f, 0.23481467f, 
    0.05262588f, -0.00058598f, -0.59006333f, -0.09023690f, 0.24027549f, -0.05331022f, -0.00335896f, 0.24701186f, 
    0.04261469f, -0.09737224f, -0.05656046f, -0.34713516f, -0.02147857f, 0.05181190f, 0.06072683f, 0.05792372f, 
    0.00882527f, 0.02962349f, -0.07987060f, 0.09993432f, 0.01679093f, 0.08861932f, 0.02452096f, -0.21829747f, 
    0.34509191f, -0.08348418f, 0.04055373f, 0.12493704f, 0.09677126f, 0.08599751f, -0.02774128f, 0.08666308f, 
    -0.09128187f, -0.40613082f, -0.07055675f, 0.28571263f, -0.13893774f, 0.08178689f, 0.25599638f, 0.08268157f, 
    0.22851767f, -0.05037037f, 0.20367445f, 0.06082091f, 0.17285036f, -0.08901991f, 0.31032744f, 0.31149378f, 
    0.31633881f, -0.13307023f, -0.24804559f, 0.13837048f, -0.25708854f, 0.11165181f, 0.28316432f, 0.25713015f, 
    -0.02060128f, -0.05994212f, -0.04216487f, 0.20043923f, -0.10598605f, -0.29040682f, -0.37152925f, -0.20396596f, 
    -0.09228515f, 0.02031526f, -0.18325067f, -0.11704887f, -0.00863675f, 0.01909505f, -0.12686139f, 0.03164811f, 
    -0.11109531f, 0.07592793f, 0.09028354f, -0.18992235f, 0.33164969f, 0.05413802f, 0.10855746f, -0.04014565f, 
    0.10296781f, 0.03076166f, -0.05305113f, 0.05772047f, -0.11421676f, -0.07344097f, -0.19854157f, -0.05332567f, 
    0.00752997f, -0.08322304f, -0.09811234f, 0.08285535f, -0.09537742f, -0.24570854f, -0.10507550f, -0.09182610f, 
    -0.04250195f, -0.26116702f, -0.03236125f, -0.61755222f, -0.16279267f, 0.10082488f, -0.23206560f, 0.02024147f, 
    0.00905709f, 0.09121633f, -0.15277812f, 0.02880985f, -0.04070975f, 0.16929208f, -0.33585259f, 0.23668849f, 
    -0.19798920f, 0.00736697f, 0.29780865f, 0.03505523f, 0.20573454f, 0.02741155f, -0.15790944f, -0.03607852f, 
    -0.06302500f, 0.07647251f, 0.25553277f, 0.03980146f, -0.04829727f, -0.43383202f, 0.29044837f, -0.20310012f, 
    0.08456958f, 0.01449193f, 0.16524211f, 0.00018152f, 0.15467462f, -0.00642570f, -0.29827547f, -0.54841596f, 
    0.08326899f, -0.07966063f, -0.03323549f, -0.10260614f, 0.19899151f, -0.09733294f, -0.11571741f, 0.01922219f, 
    0.06242648f, 0.09954555f, -0.24744605f, 0.11651366f, 0.04127953f, 0.04640738f, -0.20468514f, -0.06911573f, 
    -0.29589218f, 0.08550808f, -0.06513620f, 0.04231450f, 0.02970724f, 0.15925951f, -0.14171870f, 0.02527773f, 
    0.02595573f, 0.12737775f, 0.08107828f, -0.02989237f, 0.32868811f, -0.21108843f, -0.23571488f, 0.06539849f, 
    0.18514715f, 0.04516905f, 0.28481859f, 0.00527740f, -0.20814458f, -0.20758468f, 0.41604003f, -0.08662573f, 
    -0.14825155f, 0.05626873f, -0.43466884f, 0.14666544f, 0.10897370f, -0.09938388f, -0.41689724f, -0.21762593f, 
    -0.10335481f, 0.03964875f, -0.19741073f, 0.17823340f, 0.00139496f, 0.15422758f, -0.07644321f, -0.23113783f, 
    -0.08547421f, 0.04310140f, 0.04169660f, -0.09993104f, -0.08146213f, 0.03078167f, -0.02831718f, -0.23258017f, 
    -0.06682877f, 0.08894788f, -0.03683306f, -0.52101064f, -0.42887083f, -0.00503442f, -0.12149113f, -0.00472921f, 
    0.10321297f, 0.36819696f, 0.25129390f, -0.03743947f, -0.09211986f, -0.03098840f, 0.16594219f, 0.22407994f, 
    0.09340546f, -0.11978775f, 0.11905765f, -0.05605961f, -0.09787977f, 0.03487075f, -0.39893183f, 0.01252099f, 
    -0.07409912f, -0.09698795f, 0.10697448f, 0.43025395f, -0.00183352f, -0.05741944f, -0.40756229f, 0.28255242f, 
    0.19233172f, -0.03323178f, -0.37483814f, -0.04617501f, -0.39758113f, 0.19302030f, 0.32989478f, 0.09599335f, 
    0.18592459f, 0.07279103f, 0.20014824f, 0.22261761f, 0.05888880f, -0.12961756f, -0.05633850f, 0.18477793f, 
    -0.11302719f, -0.03796313f, -0.02908644f, -0.49036497f, -0.06984500f, -0.02919540f, -0.25675255f, 0.22028379f, 
    -0.11162180f, 0.07943226f, -0.24427177f, 0.00138083f, -0.28545538f, -0.04298420f, 0.09444031f, -0.10088234f, 
    0.18151383f, -0.00678841f, 0.09331609f, 0.06790139f, -0.12281822f, -0.02139162f, -0.02910998f, -0.04721988f, 
    -0.04028818f, -0.18491550f, -0.25172064f, -0.05104812f, -0.02912039f, -0.10191000f, 0.06133025f, -0.43875545f, 
    -0.46098429f, 0.12658484f, 0.01048461f, 0.00525559f, 0.07457861f, -0.16060731f, 0.24573430f, -0.03949178f, 
    -0.02896011f, 0.07356991f, 0.10942428f, -0.18911049f, -0.29407397f, 0.16079289f, -0.19039415f, 0.05787713f, 
    -0.42831576f, 0.05441960f, -0.07262030f, -0.10815541f, -0.00637882f, -0.47693434f, -0.14725988f, -0.14861096f, 
    -0.20305218f, -0.10586603f, 0.10307935f, 0.29376239f, 0.31140870f, 0.09046150f, 0.17404111f, -0.28147793f, 
    0.08283684f, 0.02399155f, -0.02321749f, -0.38511059f, -0.01096575f, -0.28149465f, -0.16410419f, -0.42612207f, 
    0.04832965f, -0.04781739f, -0.16961110f, 0.00946202f, -0.12937644f, -0.08077208f, -0.06023717f, -0.47797844f, 
    0.20424016f, 0.05220549f, 0.00788396f, 0.16280976f, 0.24655452f, -0.08380508f, -0.00058851f, -0.12690201f, 
    -0.06791613f, 0.06651884f, 0.27171421f, 0.07524996f, -0.03556331f, 0.00554316f, 0.05201957f, -0.36215156f, 
    0.13651526f, 0.10780748f, 0.03845125f, 0.04313510f, 0.10786496f, 0.09371199f, 0.00236169f, 0.09213495f, 
    -0.07517657f, 0.25163582f, -0.11697116f, 0.18805631f, -0.27281836f, 0.10977910f, 0.37574890f, -0.32427594f, 
    0.00209932f, -0.04077684f, -0.06058685f, -0.05373097f, 0.10801730f, 0.10520705f, -0.36265275f, -0.47078419f, 
    0.22389241f, -0.04534668f, -0.20749809f, 0.19746864f, 0.05939058f, 0.09807338f, -0.58379728f, 0.17106625f, 
    0.00296740f, -0.04707385f, -0.04261269f, -0.07681417f, -0.07695474f, 0.31880650f, -0.32374391f, -0.17482315f, 
    -0.04373828f, 0.03585441f, -0.07514529f, -0.03431245f, -0.47992313f, -0.07581247f, 0.13360019f, 0.40856245f, 
    -0.01440349f, 0.03910316f, -0.08640882f, -0.24334222f, -0.12006883f, 0.07797260f, 0.06988761f, 0.04158166f, 
    -0.03610761f, 0.05433688f, 0.15283720f, -0.03958143f, 0.02400304f, 0.10254280f, 0.19244905f, 0.20529780f, 
    -0.32394505f, 0.09875157f, 0.09188755f, 0.03825169f, -0.06678224f, 0.00563386f, 0.27182949f, 0.02454593f, 
    -0.08412029f, -0.15956914f, -0.02004177f, -0.25872618f, 0.39550480f, 0.12773174f, -0.16711240f, -0.50683475f, 
    -0.07635267f, 0.02319652f, 0.17675795f, 0.05388215f, -0.10555869f, -0.19002949f, -0.10965833f, -0.12875579f, 
    0.29303783f, -0.10100928f, 0.11522339f, -0.50760603f, -0.00624750f, -0.01698903f, 0.20362975f, -0.60704404f, 
    0.03188920f, -0.01821091f, -0.31147155f, 0.06058811f, 0.00480151f, 0.01134385f, 0.37992439f, 0.23564568f, 
    0.02825041f, -0.01428850f, 0.14964844f, 0.00209432f, 0.06361383f, 0.09857277f, -0.22940870f, 0.32656717f, 
    0.16342506f, -0.07336532f, -0.02190053f, 0.19199559f, 0.13880965f, -0.04110520f, 0.06671644f, 0.08129329f, 
    -0.06522578f, -0.20014550f, 0.11184220f, 0.02311509f, -0.07865787f, 0.10711949f, 0.26124138f, -0.25427264f, 
    -0.18553498f, -0.12166083f, 0.02243475f, 0.01255381f, 0.05907188f, -0.20181206f, -0.09311653f, 0.09796838f, 
    0.09919297f, -0.05479901f, -0.00300446f, 0.00531759f, -0.36676466f, 0.20423436f, -0.03934147f, -0.44473520f, 
    0.23654136f, -0.08823458f, -0.24151437f, -0.08169883f, -0.19854124f, 0.12728342f, -0.23726174f, 0.24541971f, 
    0.04868723f, -0.01361444f, 0.05854039f, 0.01870221f, 0.17771095f, -0.10068686f, -0.15051669f, -0.04408593f, 
    -0.02374129f, 0.07217892f, -0.55939144f, -0.16287090f, 0.05006776f, 0.01179837f, -0.13698252f, -0.22812024f, 
    -0.09938376f, -0.09359487f, 0.00377007f, 0.06542922f, 0.00768842f, -0.11122276f, 0.35724047f, -0.28361475f, 
    -0.01458734f, 0.00041253f, -0.05916253f, 0.34996173f, -0.28679207f, 0.06884737f, 0.05778288f, -0.09701130f, 
    -0.12605268f, -0.05755852f, 0.04159175f, -0.00164919f, -0.07835063f, -0.09416360f, 0.23717415f, 0.14728804f, 
    0.34285304f, -0.13028216f, -0.04096005f, -0.03808637f, -0.06921253f, -0.45158556f, -0.46583757f, -0.02553352f, 
    0.01973632f, -0.23111638f, 0.09721872f, 0.04266478f, -0.00514735f, -0.14204794f, 0.26969197f, 0.28597751f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.03126040f, -0.00362501f, -0.05037913f, -0.02134747f, -0.08712328f, 0.05294688f, -0.09408134f, -0.00917049f, 
    -0.07754713f, -0.04458120f, -0.05821474f, 0.02604738f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
