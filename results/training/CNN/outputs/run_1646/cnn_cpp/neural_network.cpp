#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.33688211f, -0.51842308f, -0.12987347f, 0.32232809f, 0.36223832f, 0.06632921f, -0.20481421f, 0.25833857f, 
    0.48490572f, 0.47896126f, 0.23062924f, -0.05999724f, -0.33965257f, -0.22525303f, 0.03466279f, 0.00456926f, 
    0.14315943f, -0.10734592f, -0.10050669f, 0.17277215f, -0.29922968f, -0.30940583f, -0.23266713f, -0.34188420f, 
    -0.01406614f, -0.97063953f, 0.37716085f, -0.79562396f, 0.04730481f, 0.96099222f, -0.29845560f, 0.45422664f, 
    0.10988662f, 0.25111282f, -0.17586786f, 0.37082607f, -0.03884967f, 0.03293012f, -0.05761390f, 0.09510502f, 
    0.17025432f, -0.15883194f, -0.40866056f, -0.04213577f, 0.09658685f, -0.00230132f, -0.09857833f, 0.36132723f, 
    0.02119125f, 0.25455791f, -1.03837228f, 0.32611012f, 0.23585090f, 0.11664917f, 0.22554548f, -0.06498621f, 
    0.00595923f, 0.45038053f, 0.36721507f, 0.46487987f, -0.00031007f, 0.38999468f, -0.25968632f, -0.38585025f, 
    -0.32116777f, -0.10571310f, -0.34621155f, -0.01938644f, -0.70804137f, -0.10874785f, 0.27598512f, -0.00831346f, 
    0.40604010f, 0.33930400f, -0.16523327f, 0.91560376f, -1.15211987f, -0.30771971f, 0.17955986f, 0.16646431f, 
    -0.07391386f, 0.13239239f, 0.71897870f, -0.07154384f, -0.39195839f, -0.30918679f, -0.13886464f, 0.02433140f, 
    -0.16218607f, 0.27014118f, -0.20978449f, 0.00943690f, 0.17264453f, 0.14200543f, 0.05028314f, 0.27339998f, 
    -0.25956362f, -0.22657116f, 0.09341245f, 0.14276369f, 0.16444689f, -0.23075043f, 0.19289380f, 0.25606966f, 
    0.26052463f, 0.55972022f, -0.23133381f, -0.28851613f, -0.29210883f, -0.21591310f, -0.10126767f, 0.66932678f, 
    -0.28165054f, -0.36184675f, 0.24859832f, -0.63368648f, 0.07702022f, 0.23804642f, 0.16095276f, 0.20358023f, 
    -0.05253213f, 0.09193703f, -0.11948106f, 0.15988724f, 0.18388692f, -0.35136992f, -0.31269717f, -0.24170728f, 
    -0.89014542f, -0.43217793f, 0.52521026f, -0.11032829f, -0.28636587f, -0.25127295f, -0.11581083f, 0.13805827f, 
    0.06994235f, 0.18457012f, 0.38177040f, 0.14019382f, 0.02856711f, 0.17928956f, -0.13780664f, -0.25284153f, 
    -0.33695930f, -0.30084416f, -0.31553781f, -0.27901626f, -0.13675445f, -0.41809815f, -0.73493272f, -0.57580549f, 
    -1.00200200f, 0.35257754f, -0.09137040f, -0.09142388f, 0.93101108f, 0.20541951f, -0.32473987f, -0.26792949f, 
    -0.14762367f, 0.00617617f, 0.13316105f, 0.09658901f, -0.09465215f, -0.30669674f, 0.23945595f, 0.21680683f, 
    -0.67042017f, -0.05524088f, -0.09194636f, 0.16517334f, -0.17510307f, 0.34768438f, -0.03402504f, 1.19742966f, 
    -0.50476068f, -0.79528743f, -0.90609616f, -0.68993443f, 0.50896257f, 0.43863049f, 0.34246925f, 0.25868014f, 
    0.05600528f, 0.07828128f, 0.60104942f, -0.05516382f, -0.29817945f, -0.06419206f, -0.21574633f, -0.26505250f, 
    0.00022471f, -0.00502803f, 0.23116016f, 0.41131645f, -0.20983315f, -0.01927583f, 0.11121662f, -0.01290347f, 
    -0.56617242f, -0.59417462f, -0.60045141f, -0.61927325f, -0.26933751f, -0.17196283f, 0.03747531f, -0.30141589f, 
    0.04684376f, -0.35368013f, -0.00205379f, -0.01429877f, -0.24402620f, -0.39917448f, -0.38656268f, -0.23374644f, 
    -0.59226054f, -0.30895156f, -0.25906029f, -0.46985924f, 0.31256965f, 0.24419506f, -0.39315993f, 0.11158685f, 
    0.22551860f, 0.41194487f, 0.64813000f, 0.42910397f, -0.17577870f, -0.10052751f, -0.09253349f, 0.13098285f, 
    -0.09885542f, -0.34022012f, 0.21272379f, -0.17293394f, -0.14298667f, 0.27927327f, -0.18502742f, -0.35653657f, 
    0.02337816f, -0.34886196f, -0.10691019f, 0.19094405f, -0.39731240f, 0.12393460f, 0.00242276f, 0.17084123f, 
    0.03131784f, 0.45374534f, -0.88483292f, -0.78312832f, -0.88104457f, 0.74600828f, 0.91930860f, 0.79989040f, 
    0.32339856f, -0.43643653f, 0.09579132f, 0.14623022f, -0.23443067f, -0.31964922f, -0.20427865f, -0.05446784f, 
    -0.50524622f, 0.00981584f, 0.09839867f, 0.08925365f, 0.07651313f, 0.02585173f, 0.07945114f, -0.29451546f, 
    -0.30052423f, -0.11676808f, -0.40965900f, -0.56743306f, 0.21444832f, 0.08753499f, 0.32955632f, -0.37495446f, 
    -0.82217592f, -0.74257594f, 0.14795043f, -0.06291506f, 0.09799741f, -0.34546503f, -0.26314008f, 0.50472105f, 
    -0.21762575f, -0.22825757f, 0.24792075f, 0.41253433f, 0.18465810f, -0.22524156f, -0.05596677f, 0.33422884f, 
    0.18679979f, -0.15764807f, -0.17354430f, 0.06181113f, 0.68501723f, 0.51562744f, -0.35320306f, 0.61905724f, 
    -0.68699199f, -0.33625495f, -0.32806405f, 0.14008117f, 0.12964198f, 0.07798308f, 0.19769453f, -0.16500691f, 
    -0.28483999f, -0.04751148f, 0.10448256f, 0.02924551f, 0.00066551f, -0.22541474f, 0.29344979f, -0.24476099f, 
    -0.10075856f, 0.09593204f, -0.14958113f, -0.10858005f, -0.28491312f, 0.55923527f, 0.82374895f, -0.45184502f, 
    -0.74263966f, -0.45450342f, -0.35259348f, -0.13190986f, 0.24504153f, -0.47458306f, -0.22664458f, -0.03801042f, 
    0.54563057f, 0.24753484f, 0.46362451f, 0.08552760f, -0.15420704f, -0.07920412f, -0.29728100f, 0.25481156f, 
    -0.43175608f, 0.07442252f, -0.06480920f, 0.16145335f, 0.30189136f, 0.19798149f, 0.65753359f, 0.51917660f, 
    0.51369327f, 0.41525814f, 0.41566387f, -0.15311036f, 0.17994519f, 0.08972012f, 0.00067827f, 0.00183818f, 
    -0.07135526f, -0.13510351f, 0.10209013f, 0.15618031f, -0.16805357f, 0.05263504f, 0.05142891f, 0.14674461f, 
    0.15308727f, -0.09120675f, -0.13418025f, 0.22335851f, 0.07951361f, -0.04703690f, -0.12656516f, -0.44341967f, 
    -0.57166195f, -0.17938729f, 0.46182829f, -0.13293235f, -0.44370461f, -0.73350662f, -0.62826997f, 0.17823970f, 
    -0.53517824f, -0.15556414f, 0.44158369f, -0.38455591f, 0.44622558f, -0.29305819f, -0.11287944f, -0.04873544f, 
    0.05545685f, 0.23023854f, 0.05076074f, -0.00501521f, 0.22202359f, 0.02687195f, 0.30148456f, 0.29820955f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.38923544f, 0.10600433f, 0.16387765f, 0.30140916f, 0.20143531f, -0.02873737f, 0.22321780f, 0.46451667f, 
    0.02516192f, 0.23389055f, 0.11747582f, 0.24025959f, 0.45172465f, 0.15746936f, -0.08748189f, 0.16811997f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.15617909f, 0.19448586f, -0.01857674f, 0.09572448f, -0.09153154f, 0.04615536f, 0.08400049f, -0.39456588f, 
    0.18023703f, 0.07960487f, -0.09216266f, 0.08254478f, 0.36898646f, -0.39618289f, -0.30685630f, -0.04724110f, 
    0.09272996f, 0.12843642f, 0.02914460f, -0.14426260f, -0.03633874f, 0.19226061f, 0.12467085f, 0.02745253f, 
    -0.04848271f, -0.15880728f, 0.24259219f, -0.33791837f, 0.39632249f, 0.11950019f, 0.10251346f, 0.13761115f, 
    -0.05455611f, 0.04044894f, -0.16473679f, 0.09503268f, 0.33304834f, 0.50342894f, 0.12805022f, 0.47089005f, 
    -0.01629296f, -0.01312317f, 0.16147920f, -0.20555362f, 0.00872712f, 0.12618072f, 0.01670055f, -0.09535226f, 
    0.04156445f, 0.38856640f, -0.17693128f, -0.05931461f, -0.05628216f, -0.19306575f, -0.05896761f, 0.13406160f, 
    -0.20200743f, -0.03419449f, -0.40354380f, -0.10970181f, 0.12937714f, -0.25749028f, 0.09770078f, 0.22099209f, 
    0.02720775f, 0.04898150f, 0.06368017f, 0.13390915f, -0.04694385f, 0.20572676f, 0.05881026f, 0.17817508f, 
    0.21558352f, -0.11845385f, 0.31008789f, -0.16037323f, 0.10931022f, -0.11166228f, 0.09949123f, -0.02006465f, 
    -0.07019594f, 0.00812485f, -0.13881992f, 0.01312433f, 0.23735857f, 0.21815675f, -0.07242795f, 0.20910956f, 
    0.07431789f, 0.07441044f, 0.20941043f, -0.06413414f, -0.06539982f, 0.08343872f, -0.04049500f, 0.09710816f, 
    -0.01370238f, 0.21970290f, -0.02108960f, 0.12759113f, 0.12333298f, 0.07009549f, -0.00234822f, 0.18278579f, 
    -0.16054597f, 0.03571104f, -0.15345229f, 0.03435159f, 0.22008657f, -0.00619239f, 0.43962401f, -0.04958939f, 
    -0.02854713f, 0.14838770f, -0.15082571f, -0.08882207f, -0.28428763f, -0.07991390f, 0.22336976f, -0.16976775f, 
    0.34893826f, 0.19480461f, -0.18633826f, 0.08705080f, 0.16920246f, 0.04272075f, 0.13408348f, 0.05708808f, 
    0.07259291f, 0.15151975f, 0.15005985f, 0.02431044f, -0.11308484f, 0.08980980f, -0.11902193f, -0.09984789f, 
    -0.18336616f, -0.07387008f, -0.06657171f, -0.10525115f, -0.05846018f, 0.04645326f, -0.01714603f, 0.09943212f, 
    -0.62757373f, 0.11657208f, 0.29229033f, 0.07548933f, -0.10817426f, -0.05901767f, -0.09284202f, -0.03461851f, 
    -0.03498688f, -0.07034305f, 0.13550936f, 0.14300047f, -0.14744601f, -0.26409256f, 0.09380299f, 0.04368450f, 
    0.02536662f, 0.05629126f, 0.06714726f, 0.07585911f, 0.05782702f, -0.11126846f, -0.03897316f, -0.02799674f, 
    0.46707907f, 0.25831211f, -0.00420369f, 0.00454831f, -0.29009819f, -0.28292590f, -0.15209396f, -0.03891960f, 
    -0.10634223f, 0.08845329f, 0.27885449f, 0.00179465f, -0.01445408f, 0.04829087f, -0.25925264f, -0.03574022f, 
    -0.05370815f, -0.11228701f, -0.02634998f, 0.18421610f, -0.14922997f, -0.05846967f, 0.00476781f, -0.03628887f, 
    0.14419077f, 0.01910391f, 0.12796338f, -0.00621719f, 0.06474141f, 0.05090574f, -0.03788389f, -0.03558464f, 
    -0.07986807f, 0.13066423f, 0.04187093f, 0.03379018f, 0.18251328f, 0.05181100f, -0.09273376f, -0.01082695f, 
    -0.10380190f, 0.00808988f, -0.00866994f, -0.15041494f, -0.20383292f, 0.18005022f, -0.10271436f, 0.13184342f, 
    0.18037143f, 0.10042224f, 0.21098907f, -0.02499945f, -0.00669606f, 0.03740156f, 0.06597926f, 0.05815379f, 
    0.03535777f, -0.03208848f, 0.17897524f, 0.06367254f, 0.27298516f, -0.13639994f, -0.03435872f, -0.02134205f, 
    0.03174706f, 0.03746986f, 0.12780830f, 0.05809615f, 0.00568230f, 0.01667442f, -0.03537582f, -0.10333017f, 
    0.07658271f, 0.11360822f, 0.14727576f, 0.01393897f, -0.11444068f, -0.02969815f, -0.08654033f, -0.02181054f, 
    -0.01114857f, 0.06080978f, -0.04795034f, -0.00422426f, -0.36539689f, -0.45759723f, -0.20815407f, -0.18463607f, 
    -0.00459934f, 0.01253809f, -0.01195028f, 0.19559193f, 0.24978645f, 0.13001683f, -0.01051968f, -0.26799202f, 
    0.08364364f, -0.37807095f, -0.64840698f, -0.05909333f, 0.23516642f, -0.01745018f, -0.04264738f, 0.07732988f, 
    -0.13057408f, -0.05499108f, -0.01874116f, -0.13945599f, -0.00967713f, -0.33745915f, -0.68386847f, -0.35058925f, 
    -0.13403314f, -0.17120251f, 0.00176734f, 0.32117093f, 0.04267985f, 0.01898352f, -0.00839140f, -0.04095001f, 
    -0.28085738f, 0.00675672f, -0.60431325f, -0.22688413f, 0.29005992f, 0.20228602f, -0.02307246f, 0.18162639f, 
    0.07398139f, -0.05745571f, 0.05021222f, 0.17975174f, 0.35594925f, 0.24061023f, 0.30885068f, 0.30456319f, 
    -0.04162779f, -0.08943056f, 0.00470505f, -0.09192155f, -0.01520647f, -0.06342775f, 0.04088410f, 0.10489368f, 
    0.11021324f, -0.08965826f, -0.03197636f, -0.28479609f, 0.01005933f, 0.17007388f, -0.14860547f, 0.01135989f, 
    0.01514454f, 0.02568726f, -0.03671877f, 0.03615408f, -0.29328427f, -0.43888754f, 0.18827495f, 0.04278589f, 
    0.26779771f, 0.08404663f, -0.16489021f, 0.23481463f, -0.08801733f, 0.02340977f, 0.10232875f, 0.01567553f, 
    0.25783896f, 0.05546779f, 0.11971486f, 0.22091873f, -0.01479265f, -0.00720338f, -0.11407053f, 0.08918400f, 
    0.05272500f, 0.07190257f, 0.13187011f, 0.12958227f, -0.22077870f, -0.08146151f, -0.10884106f, -0.06634363f, 
    -0.14235897f, 0.06632107f, -0.00182239f, -0.03718788f, -0.15989031f, 0.03181954f, 0.05691681f, 0.02472959f, 
    0.28943130f, 0.18228699f, 0.23021519f, 0.24538743f, -0.05655963f, -0.02860930f, 0.02508345f, -0.02522627f, 
    0.09240881f, 0.00442752f, 0.02441497f, 0.06957141f, -0.73792791f, -0.22862877f, -0.04954612f, -0.43998826f, 
    0.00786047f, 0.32959718f, 0.18942387f, 0.09323800f, -0.06239457f, 0.09750110f, 0.02892788f, 0.10321920f, 
    -0.06811357f, -0.04837951f, -0.07067554f, -0.04448668f, 0.05602320f, 0.05320520f, 0.00220605f, 0.04538657f, 
    0.03296355f, -0.03573874f, 0.00577530f, -0.07365500f, -0.02033515f, -0.05505643f, 0.01577846f, 0.04757754f, 
    0.04367966f, -0.01961796f, 0.01816087f, -0.07306632f, 0.00960735f, 0.02410886f, 0.05485908f, 0.03443464f, 
    -0.04380248f, 0.05471708f, 0.03154917f, -0.00204141f, 0.05492406f, 0.01745908f, 0.05007623f, -0.00307616f, 
    0.01760679f, 0.00763095f, -0.06374088f, -0.00402375f, -0.01908348f, -0.07767937f, -0.00123914f, -0.00587832f, 
    -0.01953056f, 0.01461490f, -0.00886616f, 0.00848831f, 0.04327546f, -0.00237088f, -0.02114137f, -0.02936059f, 
    0.00819788f, -0.04949240f, 0.04503862f, 0.03150254f, 0.00260390f, 0.01619028f, 0.00072121f, -0.05618691f, 
    0.01016891f, -0.05680858f, -0.03832781f, -0.04692160f, 0.04059065f, 0.02361792f, -0.04666520f, 0.01449120f, 
    -0.07564856f, -0.02640836f, 0.00758829f, 0.05541483f, 0.05010233f, -0.05376602f, -0.01123160f, 0.05174324f, 
    0.00531247f, -0.02123159f, 0.03583053f, 0.05976298f, -0.03618260f, 0.04169163f, 0.04938004f, 0.05864282f, 
    -0.05330782f, -0.06482655f, -0.08294683f, 0.03107614f, 0.01397172f, 0.05472440f, -0.02254737f, 0.00553638f, 
    -0.00621536f, -0.04630189f, -0.00538649f, -0.00451688f, -0.06054854f, -0.06623092f, -0.02928113f, -0.04292705f, 
    0.05812948f, -0.01139727f, -0.00365728f, -0.00275008f, -0.02240160f, -0.07096368f, -0.06846477f, 0.03014740f, 
    -0.05556225f, 0.03847817f, -0.01686442f, -0.00027624f, 0.03760106f, -0.06802259f, -0.01012070f, 0.05637777f, 
    0.01830212f, 0.04366877f, -0.00353127f, 0.00162560f, -0.07195870f, -0.07472312f, -0.07074855f, 0.05023573f, 
    -0.05048468f, -0.03127746f, 0.00570038f, -0.05326384f, -0.08200904f, -0.08369999f, 0.03661399f, 0.03924344f, 
    -0.05515791f, -0.05153076f, -0.03056538f, -0.07507408f, -0.05115268f, 0.05380135f, -0.07016998f, -0.05301354f, 
    0.02678980f, 0.03362047f, 0.05722980f, -0.06610677f, -0.00461281f, 0.00147991f, 0.05223058f, 0.02630156f, 
    0.03793428f, -0.04314823f, -0.02358254f, 0.06447604f, -0.02349701f, -0.04062312f, -0.07103608f, -0.05271114f, 
    -0.03055905f, 0.02146769f, -0.05858903f, 0.05624667f, 0.00589757f, -0.00485197f, -0.05020631f, 0.00917087f, 
    0.00236184f, -0.05157048f, -0.03855078f, -0.00306463f, -0.06940562f, -0.07057454f, -0.06855242f, -0.01964485f, 
    0.02293070f, 0.08243012f, -0.01386412f, -0.05196519f, -0.06119685f, -0.06098396f, 0.03069603f, -0.01816347f, 
    -0.02556781f, 0.00610607f, 0.05869097f, 0.04523158f, 0.02540853f, -0.01196955f, -0.06397127f, 0.00377986f, 
    0.05799300f, 0.01520748f, 0.00647482f, 0.04040254f, -0.02748722f, 0.04360178f, 0.00454942f, -0.01239955f, 
    -0.13121788f, 0.27169502f, -0.14562976f, -0.20617975f, 0.01807752f, -0.04681391f, -0.13086204f, -0.10907362f, 
    0.08038349f, -0.10123625f, -0.06026828f, -0.12429451f, 0.14022025f, 0.07576289f, -0.14780535f, -0.22777578f, 
    -0.01578439f, 0.11815583f, -0.00611508f, 0.07897840f, 0.10482587f, 0.16423813f, 0.21739127f, 0.00055545f, 
    0.32502624f, 0.07707824f, 0.25941375f, -0.25903264f, 0.08442651f, -0.01345432f, -0.07791560f, 0.00108227f, 
    0.01659008f, 0.03136063f, 0.00582107f, 0.11541853f, -0.14594455f, 0.89434499f, 0.03313035f, 0.22573185f, 
    0.08664566f, -0.00752143f, -0.13338383f, 0.14107181f, 0.05355494f, -0.05888921f, 0.10125963f, -0.11622728f, 
    -0.34095502f, 0.21521500f, -0.03582520f, 0.14549701f, -0.06312622f, -0.04990018f, 0.00803594f, 0.03989839f, 
    -0.12541078f, -0.02745497f, -0.11708814f, 0.09363791f, -0.16001096f, -0.09612992f, -0.06362567f, 0.06593495f, 
    0.05496114f, -0.10732732f, -0.02017901f, 0.01116397f, -0.07782073f, 0.13235681f, 0.06019340f, -0.04384382f, 
    -0.08083545f, 0.17822081f, 0.12817551f, 0.02868229f, 0.02291395f, 0.03481400f, -0.01197805f, 0.03663456f, 
    -0.05272820f, 0.24347937f, -0.02473100f, 0.12959448f, -0.08850563f, 0.20006154f, 0.01526301f, 0.49168101f, 
    -0.03874177f, -0.03595238f, 0.06936789f, 0.15098307f, -0.01225184f, 0.03606997f, 0.17733359f, 0.04880984f, 
    -0.01100164f, -0.09462427f, 0.04298450f, -0.00753655f, 0.01431525f, 0.06528139f, 0.04518016f, 0.19510242f, 
    -0.04255887f, 0.08243436f, 0.00011104f, -0.02376558f, 0.10966814f, 0.13207588f, 0.27709606f, -0.14782035f, 
    -0.17855023f, 0.05749239f, -0.00463189f, -0.05474360f, 0.00436219f, 0.20201688f, 0.16117126f, 0.11731520f, 
    -0.02537645f, 0.66521358f, -0.32919881f, -0.02149259f, 0.18678831f, 0.03811960f, -0.06647309f, -0.05128369f, 
    -0.08683600f, -0.09915151f, 0.14385313f, -0.08946306f, 0.00077232f, -0.20432147f, 0.03756872f, -0.03186429f, 
    -0.04059374f, 0.00000253f, 0.12651095f, -0.08901427f, -0.09946288f, 0.19433010f, -0.02079293f, 0.01395118f, 
    0.18117844f, 0.12555289f, 0.13978250f, 0.02404718f, -0.17230695f, 0.03768888f, 0.12354371f, 0.13114789f, 
    -0.00702178f, -0.03666007f, -0.08830070f, -0.02327326f, 0.24562518f, -0.30631283f, 0.09592710f, -0.04370872f, 
    0.01362168f, 0.05721127f, 0.02427191f, 0.03505250f, 0.04227553f, 0.10284309f, 0.00796627f, 0.01450670f, 
    0.23593515f, 0.14745180f, -0.06236391f, -0.17515962f, -0.26189822f, -0.10847597f, -0.22955714f, -0.10319505f, 
    -0.17293866f, 0.10094664f, -0.00513449f, -0.20508650f, -0.17954685f, 0.01474047f, -0.22901680f, 0.09773823f, 
    0.05215537f, -0.08517302f, -0.22339308f, 0.00339760f, 0.01058569f, -0.01748231f, 0.09597272f, -0.05385883f, 
    -0.02862024f, 0.04639497f, -0.01123920f, -0.07854302f, 0.03189788f, -0.06721270f, -0.01638966f, -0.07784222f, 
    -0.02831003f, 0.01766470f, 0.00175466f, 0.05913454f, -0.02156478f, -0.07824501f, 0.01181974f, 0.06380705f, 
    -0.02157290f, 0.02230490f, -0.05208969f, -0.03344153f, -0.07864545f, 0.03390875f, -0.05523980f, -0.01006662f, 
    0.03672123f, 0.05846520f, 0.04252611f, 0.06235773f, 0.05110659f, -0.03925363f, 0.01067167f, -0.07520197f, 
    -0.08011083f, -0.03452732f, 0.00807677f, -0.04888495f, -0.01262069f, -0.00854683f, -0.03333690f, 0.02846737f, 
    -0.04005799f, -0.07877618f, 0.00596883f, -0.02833852f, 0.02408515f, 0.04103053f, 0.05408639f, 0.00205159f, 
    -0.07367387f, -0.01352462f, 0.01963416f, 0.01472758f, 0.02747349f, 0.01071718f, 0.01941228f, -0.01031218f, 
    -0.07945584f, 0.06324383f, -0.04519656f, -0.07511833f, 0.03700873f, 0.02952303f, 0.04698644f, -0.06725694f, 
    0.03269871f, 0.03064898f, -0.03060772f, -0.00655040f, -0.04333590f, 0.03236715f, -0.04882408f, 0.06246894f, 
    -0.05957032f, -0.02194871f, -0.01975527f, -0.01222127f, -0.00250474f, 0.02630600f, -0.06594995f, 0.04449597f, 
    0.00485565f, -0.04033518f, 0.01644672f, -0.07338143f, -0.01501206f, 0.03180603f, 0.04561707f, -0.03136882f, 
    -0.05876118f, 0.00268049f, -0.00896679f, -0.08033533f, -0.01194129f, -0.03794418f, 0.01428182f, -0.01634598f, 
    -0.07138663f, 0.05751937f, 0.02087662f, -0.01772750f, -0.00535637f, 0.01036614f, -0.06287090f, 0.07539075f, 
    -0.02351306f, -0.04160687f, -0.01136497f, -0.06080310f, 0.04602242f, 0.02474477f, 0.00099107f, -0.08026312f, 
    -0.06079601f, 0.00978726f, 0.06218383f, 0.06224288f, -0.07941994f, -0.00534594f, 0.00803255f, -0.00686706f, 
    -0.03894344f, -0.04002881f, -0.06684440f, -0.07038015f, -0.01010910f, -0.03842290f, -0.00358453f, -0.05391007f, 
    0.02628643f, 0.06109278f, 0.04510221f, -0.02234523f, -0.03610691f, 0.00628358f, 0.00352122f, -0.04322311f, 
    -0.01470949f, 0.02662639f, 0.03965580f, -0.05744451f, -0.02970786f, 0.02162226f, -0.07532524f, 0.01273902f, 
    0.01795915f, 0.04294855f, 0.05695456f, -0.03414617f, 0.00965621f, 0.04019722f, 0.03911343f, 0.05556361f, 
    -0.02907793f, 0.00395588f, -0.05118356f, -0.07427876f, -0.02555282f, -0.02242844f, -0.06824221f, -0.01042721f, 
    -0.05893365f, -0.05991670f, -0.04051247f, 0.00892114f, 0.04196922f, -0.00849772f, -0.02165751f, 0.00782008f, 
    -0.06216363f, 0.01812341f, -0.06100125f, 0.05088264f, 0.02886896f, -0.04661565f, -0.03187394f, -0.06430554f, 
    -0.04636453f, 0.00971964f, 0.05511704f, 0.02553461f, -0.04631229f, -0.02234507f, -0.07440823f, -0.04482911f, 
    0.01779588f, 0.04177650f, -0.07008290f, 0.01753996f, 0.04880361f, 0.03964477f, 0.03107383f, -0.06329476f, 
    -0.17357665f, -0.12938337f, -0.23703608f, -0.02575821f, -0.03709467f, -0.07093670f, 0.07754619f, -0.08358818f, 
    0.17786546f, 0.09042721f, 0.07946463f, 0.03079490f, -0.09402183f, -0.19955678f, 0.16688487f, 0.03023704f, 
    0.06305832f, 0.14013919f, 0.04343084f, 0.31996572f, 0.34631738f, 0.03351444f, 0.00858758f, 0.08644360f, 
    -0.02375637f, 0.03510335f, -0.12610760f, 0.08041152f, 0.05679878f, 0.05361209f, -0.05618292f, -0.07012215f, 
    0.02159720f, -0.16445315f, 0.00767544f, 0.27662650f, -0.05292940f, 0.12005787f, 0.19087310f, 0.19728075f, 
    0.20957577f, -0.02043255f, 0.00625296f, 0.20005068f, 0.09900620f, -0.08771846f, 0.01455322f, 0.21932334f, 
    -0.00738814f, 0.25176716f, -0.10874449f, 0.21448706f, 0.02715150f, 0.03349193f, 0.11138605f, 0.11869641f, 
    -0.13252559f, -0.01904460f, -0.20878664f, 0.15007900f, -0.09102369f, -0.19593480f, -0.02386977f, 0.24711581f, 
    -0.07344528f, -0.01768038f, -0.01336731f, 0.00176551f, -0.06873044f, 0.03786517f, -0.00805361f, -0.04082402f, 
    -0.07712363f, -0.12610240f, 0.15542124f, 0.11465588f, 0.00773061f, 0.10816707f, 0.00224158f, -0.01266446f, 
    0.05935921f, -0.12398469f, 0.01911387f, 0.01389909f, 0.19608328f, 0.26574957f, 0.53211397f, 0.26115948f, 
    -0.04195855f, 0.26525140f, 0.00603928f, 0.05128185f, 0.00622240f, 0.14252628f, 0.06251876f, 0.09165192f, 
    -0.05457633f, -0.02876883f, -0.02644742f, 0.05440855f, -0.04980576f, 0.00438504f, -0.08785864f, -0.00127821f, 
    0.01722540f, 0.15046866f, 0.06962540f, -0.10089505f, 0.11623862f, 0.04606446f, 0.44446796f, -0.06701718f, 
    -0.13691135f, -0.04223141f, -0.09318339f, -0.06224376f, -0.14762940f, -0.01682669f, 0.04911562f, -0.04872550f, 
    -0.09497918f, -0.12016838f, 0.00186020f, 0.26532438f, -0.11481081f, 0.09169012f, -0.11135461f, -0.15062693f, 
    0.05728401f, 0.07128732f, 0.18467750f, 0.22516277f, -0.02830242f, 0.09738720f, -0.02203547f, 0.08144741f, 
    -0.06640938f, -0.10796932f, 0.01787550f, -0.14527270f, -0.17196403f, -0.14851712f, -0.04187919f, -0.12035162f, 
    -0.37658742f, 0.34478185f, 0.02538336f, 0.15223762f, -0.04103925f, -0.02138719f, 0.06248980f, -0.04875694f, 
    0.06475812f, -0.05361507f, 0.06200821f, 0.20917530f, -0.07193512f, -0.22860290f, 0.06829914f, -0.11353460f, 
    0.17486055f, 0.23002554f, -0.07474843f, 0.10679246f, -0.06610852f, 0.07638472f, -0.04907683f, -0.11100987f, 
    0.02939141f, 0.16522153f, 0.19800550f, 0.00504425f, 0.01239484f, -0.04177388f, -0.01575455f, 0.08652309f, 
    -0.03553108f, 0.13667168f, 0.09599941f, 0.00085459f, 0.04156395f, -0.13234790f, -0.14903308f, 0.09798162f, 
    -0.01735892f, -0.11776413f, 0.03329409f, 0.01517124f, -0.10528924f, -0.23768348f, -0.12799141f, 0.01857035f, 
    -0.19829826f, 0.07169605f, 0.02259010f, -0.00113493f, 0.06606819f, 0.02969394f, -0.13331057f, -0.07456651f, 
    0.12301784f, 0.05021479f, 0.07221808f, -0.07152479f, -0.32893297f, 0.24634312f, 0.32930535f, 0.06071913f, 
    -0.00212138f, 0.09808420f, -0.03925182f, 0.00575105f, 0.01378514f, -0.14134647f, 0.18115622f, 0.00146556f, 
    -0.15760058f, 0.15362751f, 0.50134844f, 0.16394572f, -0.17747767f, -0.07421795f, -0.07904319f, -0.03615973f, 
    0.10501628f, -0.04088828f, 0.08916480f, -0.00398756f, -0.25852802f, 0.01404677f, 0.21451351f, 0.18352786f, 
    0.25995162f, -0.10373758f, -0.25788504f, 0.34530404f, 0.12573355f, 0.03460077f, 0.11626485f, 0.00211433f, 
    -0.05794311f, -0.13292406f, -0.04800371f, 0.06376554f, 0.02998425f, 0.10751735f, -0.06742143f, 0.03560758f, 
    -0.06513286f, 0.03208484f, -0.00745864f, 0.07157670f, 0.19357331f, 0.17675275f, -0.08613531f, -0.05521457f, 
    -0.11992516f, -0.07579178f, -0.07990143f, 0.01000133f, -0.25078684f, -0.08774828f, 0.03244209f, -0.18577899f, 
    -0.08822515f, 0.33999276f, -0.31810695f, 0.10907654f, 0.02783856f, 0.23638040f, -0.11717074f, 0.09164979f, 
    0.04069034f, -0.00357335f, -0.02006101f, 0.25122586f, -0.08553922f, 0.01209295f, 0.30653158f, -0.01545305f, 
    -0.05100474f, 0.02305165f, -0.19689421f, 0.16484286f, -0.06849749f, 0.11951101f, 0.16048482f, 0.04835908f, 
    0.15825941f, 0.02086117f, -0.10547699f, -0.24563909f, 0.03358273f, 0.02854967f, 0.11311550f, -0.04513881f, 
    0.02497984f, 0.02329603f, 0.06143623f, -0.06629936f, -0.25250396f, 0.00774765f, -0.00387742f, 0.06458145f, 
    -0.03762672f, -0.06390252f, 0.05519994f, -0.03521205f, -0.02597588f, 0.05476428f, -0.03318013f, 0.15266229f, 
    -0.03212247f, 0.56045783f, -0.20115912f, 0.22218533f, 0.17140487f, 0.04126391f, 0.05688139f, -0.13197306f, 
    -0.07387438f, 0.04769015f, 0.06842777f, 0.03563123f, 0.08642995f, 0.08781793f, 0.02988119f, -0.22626904f, 
    -0.06449326f, 0.03483225f, 0.07084664f, 0.14298250f, -0.02097481f, 0.03152085f, -0.00458327f, -0.00422525f, 
    0.10503874f, 0.00505786f, 0.00629702f, 0.07482449f, -0.03182209f, 0.20762487f, 0.23401251f, 0.16936889f, 
    -0.14538807f, 0.02695883f, -0.01744318f, -0.12908292f, -0.07138020f, -0.06246657f, 0.00568055f, -0.31507400f, 
    0.07642449f, 0.02367394f, -0.00760393f, -0.01300233f, 0.07285363f, -0.02389811f, 0.14008079f, 0.00613458f, 
    -0.07127306f, -0.12925877f, -0.08264995f, -0.01214154f, -0.01367522f, -0.01210363f, -0.01936874f, -0.00960567f, 
    -0.17662607f, -0.06685780f, -0.18140896f, -0.14702135f, 0.02056637f, 0.24157026f, -0.23511611f, -0.30877441f, 
    0.14931482f, -0.14121397f, 0.12630409f, 0.00858226f, 0.07049102f, 0.04312171f, 0.16157755f, -0.01613319f, 
    0.03609519f, -0.00016569f, -0.05598288f, -0.05689446f, 0.04109551f, -0.06727062f, -0.00578905f, 0.01764053f, 
    -0.02284139f, 0.05685678f, -0.06047215f, 0.01484525f, 0.04221116f, -0.01762052f, 0.00584404f, 0.01519482f, 
    -0.05663739f, -0.06945876f, -0.03357077f, -0.04627098f, 0.00956378f, -0.03361483f, -0.05703137f, -0.04674338f, 
    -0.05806810f, 0.05018481f, -0.04368276f, -0.01096833f, 0.04697423f, 0.05899261f, -0.06142132f, 0.03741232f, 
    -0.04429140f, -0.04701267f, -0.00241854f, -0.04547644f, 0.02282361f, -0.01661780f, 0.02169582f, -0.04779270f, 
    0.02540674f, 0.03314085f, -0.01861072f, 0.00346997f, 0.05400552f, 0.03192348f, 0.02316768f, 0.04949210f, 
    0.04269243f, -0.05715547f, -0.01229375f, 0.04365556f, -0.02512308f, -0.01782702f, 0.02029967f, -0.02178535f, 
    -0.05339353f, 0.05949106f, -0.03960032f, 0.06053143f, -0.00005467f, 0.02142892f, 0.01393331f, 0.02554819f, 
    -0.06266537f, -0.04690116f, 0.03730821f, -0.00414931f, -0.06393605f, -0.00226228f, 0.02937040f, 0.07202154f, 
    0.04929194f, 0.06317409f, -0.06868982f, -0.01728777f, -0.02527931f, -0.01823789f, -0.02456096f, 0.01220125f, 
    0.01448467f, 0.06000901f, -0.01652125f, -0.05710853f, -0.03243690f, 0.04138545f, -0.03607505f, -0.05257537f, 
    -0.04330553f, -0.02327445f, -0.01382954f, 0.03726320f, -0.02551129f, 0.00412772f, -0.02189135f, -0.06653336f, 
    0.05371397f, -0.03720740f, 0.00997690f, -0.01360551f, -0.04725699f, -0.03704915f, 0.01430324f, -0.04006634f, 
    -0.03389450f, 0.05104744f, -0.02582621f, -0.05685430f, -0.01145113f, 0.06961946f, -0.04491250f, -0.06030311f, 
    0.01960089f, -0.02469983f, -0.01210679f, -0.01190674f, 0.05544673f, 0.01290356f, 0.02791122f, 0.00392181f, 
    0.01252266f, -0.05891024f, -0.01123722f, -0.01235581f, -0.00265820f, -0.05559688f, 0.04324493f, -0.01568416f, 
    0.05923983f, -0.05928469f, 0.01879924f, -0.00780648f, 0.03561587f, -0.03864357f, -0.06948894f, -0.05576998f, 
    0.01725018f, -0.00561278f, 0.03925323f, 0.01047046f, 0.06293632f, -0.01877346f, 0.04741984f, -0.06154497f, 
    0.05033347f, -0.06042818f, 0.02616068f, -0.03469071f, -0.05019278f, 0.03693031f, 0.00449551f, -0.00281220f, 
    -0.06274736f, -0.00197366f, 0.05106674f, -0.06578541f, -0.02275763f, 0.04935388f, 0.02678577f, 0.06198054f, 
    0.02530181f, -0.03836753f, -0.01457970f, 0.03456192f, -0.05335686f, 0.03460019f, -0.06302174f, -0.04997350f, 
    0.03084492f, -0.01633579f, -0.02619080f, -0.00314075f, 0.05191274f, -0.06980874f, -0.05145748f, 0.00923059f, 
    0.02922804f, -0.03343438f, -0.05050922f, -0.01496494f, 0.06175299f, -0.00001889f, 0.05597471f, -0.03989961f, 
    -0.01469176f, 0.00300716f, 0.01630615f, -0.02378919f, -0.05569304f, 0.03288778f, 0.03517999f, 0.03140059f, 
    -0.05885714f, 0.13154708f, -0.33943647f, -0.21906695f, -0.02779455f, -0.11359265f, 0.05375401f, -0.16494337f, 
    0.02436357f, -0.12074995f, -0.08101808f, -0.00958343f, 0.03722791f, -0.45828834f, -0.33320123f, -0.23057367f, 
    -0.18156165f, 0.00687219f, -0.08315472f, 0.12393805f, 0.10723770f, 0.28300297f, 0.13728762f, -0.05576386f, 
    0.27701500f, -0.04916966f, -0.27296427f, -0.06132850f, 0.11509382f, 0.00140011f, 0.02622231f, 0.01380535f, 
    0.05517425f, 0.08754221f, -0.01258091f, 0.21994944f, 0.29003215f, 0.56512320f, 0.13400777f, 0.10878700f, 
    -0.04709321f, 0.06997027f, 0.12405399f, -0.11120880f, 0.01861586f, -0.08328402f, 0.03103796f, 0.20705196f, 
    -0.03466956f, 0.28523123f, -0.17770422f, 0.04528154f, -0.05702581f, -0.11120596f, 0.03986798f, -0.00295362f, 
    -0.08987291f, -0.13157324f, -0.24430829f, 0.16781941f, -0.25757310f, -0.21353215f, 0.05941057f, 0.14252011f, 
    0.00304194f, 0.11955331f, 0.05564907f, 0.03065141f, -0.00442433f, 0.13712746f, -0.06577671f, -0.20693569f, 
    -0.19034266f, -0.16643415f, 0.33986208f, -0.06894771f, 0.10337364f, 0.17642988f, 0.09258465f, -0.00897223f, 
    0.10215626f, 0.06187380f, -0.07644150f, 0.00027402f, 0.12999150f, -0.02922868f, -0.10393997f, 0.52983326f, 
    -0.08253016f, 0.20532206f, 0.20852990f, 0.00485145f, 0.05535389f, 0.02682944f, 0.14100440f, 0.11551447f, 
    -0.17991856f, -0.11075109f, 0.02488603f, 0.17396826f, 0.01563963f, -0.04290465f, -0.08009853f, 0.05185862f, 
    0.00020624f, 0.07641910f, 0.12985291f, -0.04663371f, 0.07743665f, 0.09554657f, 0.23133887f, -0.10260070f, 
    -0.09338301f, 0.10755063f, -0.11686619f, -0.04643260f, -0.17389292f, 0.05049063f, 0.02460311f, -0.07384014f, 
    0.04305489f, 0.11565089f, -0.09830801f, -0.18363941f, -0.08187474f, -0.06738050f, 0.04226162f, -0.03266019f, 
    0.15984581f, 0.04588778f, 0.07895452f, 0.07536099f, 0.01603822f, -0.05698549f, -0.07070565f, 0.19682102f, 
    0.14686781f, -0.02652352f, 0.03124078f, -0.10324139f, 0.00077113f, 0.05556858f, 0.10980123f, -0.09399483f, 
    0.05947532f, 0.33503276f, 0.26377958f, 0.05327855f, 0.09646795f, -0.04822142f, -0.00191531f, 0.02335823f, 
    -0.00348430f, -0.07256880f, -0.06952056f, 0.04492019f, 0.03739512f, -0.20276652f, 0.11484699f, -0.07230444f, 
    -0.02018350f, 0.10421337f, -0.07679032f, 0.24192011f, 0.07048070f, -0.00800045f, 0.03707990f, 0.09201550f, 
    0.10984723f, 0.33090031f, 0.06871278f, -0.11052807f, -0.17466190f, -0.14095575f, -0.29639569f, -0.16420399f, 
    -0.30810031f, -0.01204368f, -0.00891400f, -0.04714014f, 0.10463744f, -0.21348822f, -0.03802303f, 0.38015971f, 
    0.01827024f, -0.06499853f, -0.23304006f, 0.03514480f, -0.04111267f, -0.07594438f, -0.10982899f, 0.00842121f, 
    -0.12589814f, 0.21969981f, -0.25918168f, -0.09310459f, -0.02415773f, -0.03076272f, -0.08066326f, -0.12768331f, 
    -0.03208141f, -0.04481059f, -0.02514143f, 0.08481900f, 0.21451125f, -0.38240522f, -0.14873172f, 0.05665642f, 
    -0.17747909f, 0.03400690f, -0.03878208f, 0.18238139f, 0.05990123f, 0.10468689f, 0.13025507f, 0.07155035f, 
    0.30909255f, 0.07805192f, -0.17486751f, -0.09999868f, 0.15605491f, 0.05214552f, -0.01606234f, 0.02869456f, 
    0.01054575f, -0.21418957f, -0.07487517f, 0.23371607f, -0.11266348f, 0.66015303f, 0.02979455f, 0.10961010f, 
    -0.16795555f, 0.18498889f, -0.10015427f, 0.09360253f, 0.09408973f, 0.10524296f, 0.01312778f, 0.05624569f, 
    -0.04807156f, 0.23578513f, -0.05928572f, 0.17515010f, 0.18246889f, -0.26389906f, 0.11551981f, 0.00851030f, 
    -0.14758968f, -0.08278024f, -0.12081789f, -0.01566596f, -0.11619805f, -0.04483088f, 0.10742659f, 0.20253330f, 
    0.07363180f, -0.00715886f, 0.09979457f, 0.01581861f, 0.08119284f, 0.06660218f, -0.00575763f, 0.04735222f, 
    -0.11388409f, -0.20096347f, 0.46150815f, 0.06947309f, -0.06334681f, -0.03365120f, 0.03430885f, 0.02290996f, 
    -0.02039726f, 0.22529055f, 0.03503751f, 0.04748330f, 0.23772004f, 0.60680503f, 0.35054791f, 0.28128085f, 
    -0.07382128f, 0.03062917f, 0.15187958f, -0.08600200f, 0.19634655f, -0.09166915f, 0.03540581f, 0.02679681f, 
    -0.15247107f, -0.03836776f, 0.17658167f, 0.22425310f, -0.09989915f, -0.01378015f, -0.15145138f, 0.10849234f, 
    0.08588558f, 0.17599128f, 0.00758119f, 0.06332770f, 0.28941289f, -0.09587475f, 0.36450341f, -0.20119682f, 
    -0.19231357f, 0.09579034f, 0.03556592f, 0.03348555f, -0.03267860f, -0.07227790f, 0.00792719f, -0.23934081f, 
    -0.11659575f, -0.04072408f, 0.01636150f, -0.05636005f, -0.10712720f, 0.02990495f, -0.24835259f, -0.07161140f, 
    0.01744312f, 0.09849659f, -0.02304767f, -0.07129181f, -0.25343469f, -0.25185221f, -0.18784206f, 0.24822128f, 
    -0.10355362f, 0.10908174f, 0.07893516f, -0.16624011f, -0.11070421f, 0.01377320f, 0.10729058f, 0.04281057f, 
    -0.08506332f, 0.37532762f, -0.05940024f, -0.03193055f, 0.04874677f, 0.05510221f, -0.10531088f, -0.17208047f, 
    0.05726947f, 0.00399674f, -0.01876626f, 0.08902054f, 0.09575749f, -0.32181910f, 0.14596529f, -0.08455507f, 
    0.00812846f, 0.16685256f, 0.11642568f, 0.05715985f, -0.01815145f, -0.02480419f, 0.05756093f, -0.16102494f, 
    0.14698613f, 0.20975912f, 0.05761260f, -0.17745955f, -0.26705065f, -0.13026412f, -0.19987792f, -0.02270961f, 
    -0.18801261f, -0.02622570f, 0.18909650f, 0.02971374f, -0.35903981f, -0.07505301f, 0.06766652f, 0.38925773f, 
    -0.15657705f, 0.04396254f, -0.05049428f, 0.06700984f, -0.13379444f, 0.10187580f, 0.04869680f, -0.06299384f, 
    0.00127777f, 0.14319436f, 0.06860226f, -0.00884977f, 0.01740294f, 0.03898091f, 0.09057312f, 0.05297140f, 
    0.16164468f, -0.04192093f, 0.13864149f, 0.10337135f, -0.08371274f, 0.03731613f, 0.07465807f, 0.08897100f, 
    -0.15607914f, -0.10114805f, -0.10074127f, -0.07542399f, -0.07974222f, -0.11831392f, 0.07269050f, -0.10883726f, 
    0.30324474f, 0.26232770f, 0.28592527f, 0.16957976f, -0.12253148f, -0.00996351f, -0.00792587f, 0.05417516f, 
    0.23891416f, 0.11080980f, -0.01461091f, -0.00336287f, 0.12918776f, 0.14521098f, -0.10839327f, 0.05693549f, 
    -0.05256770f, -0.09860297f, 0.10186716f, -0.12170848f, -0.01640229f, -0.18762693f, 0.09707221f, 0.13635796f, 
    0.03661796f, -0.16011772f, 0.08557396f, 0.17522025f, 0.23574337f, 0.03447058f, 0.00512330f, -0.01407334f, 
    -0.24106096f, -0.07663271f, 0.00955244f, -0.08935195f, -0.16245358f, 0.08456691f, -0.19402918f, -0.30009469f, 
    -0.05317501f, 0.02017593f, -0.10409416f, 0.05254152f, 0.04646425f, 0.03840406f, 0.00960717f, -0.05188562f, 
    -0.20921081f, -0.03513981f, 0.12704718f, -0.25609928f, -0.01828109f, -0.10855944f, -0.02493933f, -0.33488908f, 
    -0.18145829f, -0.12905400f, -0.12944317f, 0.07598589f, 0.51839238f, 0.10003255f, -0.25717899f, 0.04241131f, 
    0.00293399f, -0.24643898f, -0.05543479f, -0.11259571f, 0.04503035f, 0.15960336f, 0.13444851f, 0.03740041f, 
    -0.36604178f, -0.09184553f, -0.11880952f, -0.07294974f, -0.05636990f, -0.25204977f, 0.04999572f, 0.00021717f, 
    -0.04962026f, -0.02119817f, -0.04321786f, 0.05127133f, 0.28490192f, 0.25797638f, 0.02750647f, 0.01976175f, 
    -0.13619398f, -0.17651920f, 0.04555189f, -0.13624765f, 0.00566538f, -0.11732365f, -0.11270921f, -0.06970885f, 
    0.05973095f, -0.09226374f, 0.07965393f, -0.00571208f, -0.07143223f, 0.23172477f, -0.07956363f, 0.06013224f, 
    0.22002040f, 0.13151750f, -0.00656042f, 0.14628008f, -0.32959419f, -0.24292232f, -0.52061433f, -0.55895942f, 
    -0.06919545f, 0.05595144f, 0.08597755f, -0.12577502f, -0.05370800f, -0.15289536f, -0.11211393f, -0.06748001f, 
    0.50153071f, 0.12130876f, 0.00633155f, -0.07574818f, -0.02002903f, 0.03956009f, 0.20906819f, 0.11156110f, 
    0.15845115f, 0.23963916f, 0.14422755f, 0.14030759f, 0.38581690f, -0.00264006f, -0.07119752f, -0.08796492f, 
    -0.00504232f, -0.08515406f, 0.20072050f, 0.10672636f, -0.11618312f, -0.06139893f, -0.24162520f, 0.00205645f, 
    0.15669687f, 0.07502843f, 0.06703493f, 0.05654839f, 0.01001468f, 0.02454878f, -0.06363257f, 0.02033800f, 
    -0.03589430f, -0.08193377f, 0.07781741f, 0.08505688f, -0.28961262f, -0.16547821f, -0.23157443f, -0.02509468f, 
    -0.09043730f, -0.00649569f, -0.06231697f, -0.10717768f, -0.21063592f, -0.13879949f, -0.22787352f, -0.12386570f, 
    0.01526390f, 0.02142353f, 0.02957589f, -0.01615288f, 0.01064260f, 0.01278124f, -0.01426692f, -0.06804261f, 
    0.06424026f, -0.04134833f, -0.01814932f, -0.02632486f, -0.00681169f, 0.00644887f, -0.03265467f, 0.01007819f, 
    -0.06366332f, -0.05917287f, -0.05172044f, 0.00375686f, -0.04694847f, -0.07629003f, 0.03753224f, -0.00312622f, 
    0.01461495f, -0.05782891f, 0.05004666f, 0.01786887f, -0.04342886f, -0.03688858f, -0.03779447f, 0.06646958f, 
    -0.04686157f, 0.00858317f, 0.02250086f, 0.02168097f, 0.02693773f, -0.06618419f, 0.02840378f, 0.03229965f, 
    0.04801532f, 0.04081258f, 0.03251547f, -0.02289769f, -0.02525109f, -0.06283077f, 0.04489380f, 0.02932464f, 
    -0.04654548f, -0.04520807f, 0.05627163f, 0.02531778f, 0.02547810f, -0.05714802f, -0.04211878f, -0.06100249f, 
    0.03852092f, -0.00986251f, -0.03250553f, 0.06847835f, -0.02441818f, -0.07593815f, 0.00181984f, 0.05218383f, 
    -0.00098496f, 0.01057590f, -0.03843845f, -0.02869920f, -0.05133183f, -0.03653381f, -0.07317510f, 0.05445698f, 
    0.06148751f, 0.03758895f, -0.04886769f, 0.05552698f, 0.03123345f, -0.00901414f, -0.00488946f, 0.03436521f, 
    0.03790301f, 0.00420192f, 0.00015344f, -0.01386789f, -0.03987241f, 0.06033509f, -0.05649885f, -0.00194704f, 
    0.03765596f, -0.05233493f, -0.05905506f, -0.03876590f, 0.00445954f, 0.00995750f, -0.03786409f, 0.03713410f, 
    -0.05601870f, -0.01546632f, 0.01066025f, 0.04888568f, -0.05184512f, -0.03308648f, 0.02404247f, 0.05258125f, 
    0.03136905f, -0.07100322f, 0.04664695f, -0.05871549f, -0.03387922f, -0.00112428f, -0.02975164f, 0.01226245f, 
    0.03687983f, -0.06377951f, -0.01511930f, 0.01125758f, -0.03502154f, -0.00262722f, 0.05657860f, 0.03936879f, 
    -0.06687155f, 0.01989624f, -0.04603548f, -0.02887616f, 0.06164991f, 0.02230869f, 0.03637811f, 0.05226940f, 
    -0.06396127f, -0.04705073f, 0.00208907f, -0.01465858f, 0.02586861f, -0.05904523f, -0.02890072f, -0.01686116f, 
    0.06052710f, -0.02297629f, -0.05287463f, 0.02585761f, -0.07423405f, -0.07095996f, -0.00893314f, -0.02117857f, 
    -0.01220633f, 0.05015710f, -0.02573583f, -0.02162696f, 0.00093319f, -0.06866995f, 0.01011799f, -0.02619777f, 
    -0.06849956f, -0.05879095f, -0.06965646f, -0.04011752f, 0.07308996f, 0.06880168f, -0.07421944f, -0.04903458f, 
    -0.05412749f, -0.05418460f, -0.05781506f, 0.05266294f, 0.00970980f, 0.02293460f, -0.02927341f, -0.04426282f, 
    0.04790197f, -0.04263607f, 0.01628340f, 0.01797898f, -0.04249650f, -0.02104471f, -0.01843482f, 0.02115798f, 
    0.01877029f, -0.05035016f, 0.05448513f, -0.07634290f, -0.02043524f, 0.01440009f, 0.05987294f, -0.04384051f, 
    -0.07771245f, 0.03478120f, 0.05436733f, -0.02472452f, -0.02470297f, -0.02586838f, 0.00265956f, 0.02671122f, 
    0.17546274f, -0.05137381f, 0.14842913f, 0.07250010f, 0.03343575f, -0.10717299f, -0.20819518f, -0.28359032f, 
    0.10041668f, 0.05176830f, -0.11701934f, 0.17851752f, 0.24589044f, -0.07352632f, -0.27550671f, -0.13177770f, 
    0.08665138f, -0.06741489f, 0.20805670f, -0.41231388f, 0.04600313f, 0.18257900f, -0.01989887f, 0.16686741f, 
    0.07910255f, -0.03752151f, 0.22945075f, -0.00446735f, -0.22702867f, -0.01780042f, 0.01472338f, -0.01533480f, 
    0.16763598f, 0.19472663f, -0.08627031f, 0.10359155f, 0.57236153f, -0.06810097f, 0.04341266f, 0.22516924f, 
    0.14044957f, -0.05870977f, 0.07004319f, -0.28778949f, -0.00582701f, 0.07925425f, 0.11867057f, -0.08744898f, 
    0.10157725f, -0.10958723f, -0.15019545f, -0.39454848f, -0.19005845f, 0.17096196f, -0.13855170f, 0.14361383f, 
    0.14235200f, -0.00650030f, 0.09981190f, 0.16489647f, 0.19606455f, -0.04406782f, 0.15100853f, -0.05682888f, 
    0.02332870f, 0.07275297f, -0.10678617f, 0.04936959f, 0.04763985f, 0.02255067f, 0.15184404f, -0.26387006f, 
    0.17323750f, 0.02060374f, -0.00509852f, -0.11832754f, 0.12793286f, 0.16024172f, 0.02948103f, 0.14899640f, 
    0.11619909f, -0.12381178f, -0.06454843f, 0.13994350f, 0.06917109f, -0.00847617f, -0.07641803f, -0.21307035f, 
    0.02561054f, -0.03847729f, -0.05598668f, 0.19545275f, -0.00538176f, 0.02915138f, 0.11994862f, 0.17885882f, 
    0.11564359f, 0.25008252f, -0.12952007f, -0.22108185f, 0.11234999f, 0.21110789f, 0.09976596f, 0.08506397f, 
    -0.04286226f, -0.07371781f, -0.18746847f, -0.04911931f, -0.18848467f, 0.04153958f, 0.06627992f, 0.08401835f, 
    -0.13520682f, -0.01518371f, -0.14108051f, -0.03871282f, 0.01035543f, -0.00504419f, 0.15808642f, 0.17096062f, 
    0.58481932f, 0.09463699f, -0.11743109f, 0.06322195f, 0.08997072f, -0.29765499f, 0.20675167f, -0.02822846f, 
    0.24485770f, 0.01824329f, -0.04971181f, -0.02141307f, -0.18871850f, 0.22735702f, -0.21899538f, 0.16551641f, 
    0.25984633f, 0.01174207f, 0.00291523f, 0.07808127f, 0.04571912f, 0.04050929f, -0.02666205f, 0.23140150f, 
    -0.31228286f, -0.01351272f, 0.39956251f, -0.08311783f, -0.03907114f, -0.12318864f, -0.18455544f, -0.06151656f, 
    0.07012746f, -0.13627993f, -0.05019908f, 0.01178712f, -0.42739472f, 0.04721274f, -0.10578440f, -0.07634912f, 
    0.01458812f, -0.07713253f, -0.00644078f, -0.02774677f, 0.12491826f, -0.06094863f, 0.05320746f, 0.26212808f, 
    -0.16188852f, 0.09207220f, 0.02146018f, 0.06241976f, -0.18231493f, -0.13184083f, -0.03301271f, -0.15188642f, 
    -0.07301535f, 0.00717781f, 0.07317500f, -0.06176863f, 0.10312416f, 0.03168473f, -0.35198614f, -0.16744354f, 
    0.08593205f, -0.08750091f, 0.16294242f, 0.10639328f, -0.01839888f, -0.04247696f, -0.04850299f, 0.08839558f, 
    0.08863779f, -0.23799521f, -0.13096140f, -0.10725278f, 0.05915284f, -0.06724694f, -0.05982017f, -0.00482006f, 
    0.12699869f, 0.07552996f, -0.06748822f, 0.02468365f, 0.06021509f, -0.08927666f, -0.10805714f, 0.07360470f, 
    0.09443630f, 0.01798202f, -0.17447113f, 0.11811072f, 0.13076471f, -0.02104603f, -0.12679139f, -0.08174623f, 
    -0.02519059f, -0.11849690f, -0.21567924f, 0.12247913f, 0.18273899f, -0.02920456f, -0.17166166f, -0.08565169f, 
    0.00683894f, -0.01561944f, 0.08836979f, 0.02022607f, -0.16850765f, -0.03173709f, -0.02685121f, -0.13644908f, 
    0.03501293f, 0.05756649f, 0.07287728f, 0.26985422f, -0.20677720f, 0.01701716f, 0.04677595f, 0.22547340f, 
    0.01167735f, 0.08046124f, -0.06795015f, -0.18494794f, -0.06165431f, -0.00250072f, 0.03758991f, 0.14436026f, 
    -0.11528084f, 0.00061996f, -0.12483916f, -0.00298573f, -0.26332054f, 0.03760052f, 0.18493067f, 0.19658639f, 
    -0.11028085f, -0.10524385f, 0.17404349f, -0.04816473f, 0.19055839f, 0.14611050f, -0.00943477f, 0.11550618f, 
    -0.14408234f, 0.10245243f, -0.01171213f, 0.44475234f, 0.10960773f, -0.03692882f, -0.05932419f, 0.18493944f, 
    -0.00422752f, -0.04973611f, -0.03078128f, -0.01263498f, -0.38448781f, 0.08265436f, 0.42744046f, -0.11505218f, 
    -0.08541922f, 0.12264363f, 0.09119932f, -0.09279543f, -0.14593855f, -0.03518919f, 0.04486014f, -0.00885440f, 
    -0.23306265f, -0.16416001f, 0.14854783f, 0.27986065f, 0.03736331f, -0.12002610f, -0.10636699f, 0.10667044f, 
    0.10924215f, 0.12289643f, 0.12556604f, -0.04499178f, 0.04888482f, 0.03713246f, 0.14291389f, -0.19686306f, 
    0.04846945f, 0.05178314f, -0.02676906f, -0.06604717f, 0.00279927f, 0.03057723f, -0.07212535f, -0.11540589f, 
    -0.42305183f, -0.25265694f, 0.13167298f, 0.22517258f, 0.14865936f, 0.09068044f, -0.10819609f, 0.08852828f, 
    -0.03039407f, 0.08667522f, -0.00306113f, 0.09472149f, 0.22478099f, -0.05942478f, 0.06827019f, 0.37140810f, 
    0.26056069f, -0.07194576f, 0.01464275f, 0.00218237f, -0.03380736f, 0.03768873f, 0.03039001f, -0.25508997f, 
    0.22826454f, 0.13249719f, -0.08223198f, 0.41118252f, 0.04016746f, 0.09328904f, 0.07771253f, -0.04910826f, 
    0.10694130f, 0.00328397f, -0.04790569f, -0.00712468f, -0.20336482f, 0.25597337f, 0.21790564f, -0.01287023f, 
    -0.01857388f, -0.06858235f, -0.06197181f, 0.00732053f, -0.09631943f, -0.14284925f, -0.11381218f, -0.10757753f, 
    0.01851331f, -0.06791356f, -0.10051256f, -0.11413269f, 0.00932557f, -0.02021365f, -0.02165974f, 0.02315073f, 
    0.12203418f, 0.01461437f, 0.00552433f, -0.13725039f, -0.00272186f, -0.19598095f, 0.17998230f, 0.29262176f, 
    -0.05983321f, 0.06238253f, -0.02340559f, 0.18640918f, 0.02476252f, 0.05981563f, -0.04673604f, -0.07546469f, 
    0.14292979f, -0.06780124f, 0.06129116f, 0.12601300f, -0.05176916f, 0.14412525f, -0.14991659f, 0.10683022f, 
    0.12082328f, 0.18271732f, 0.19016029f, 0.18876959f, 0.31286949f, 0.21189362f, -0.07093603f, 0.15132999f, 
    -0.00234268f, -0.29925448f, -0.06391219f, -0.10718213f, -0.04236729f, -0.10121154f, -0.14123759f, -0.37232330f, 
    0.43967831f, 0.23360986f, 0.10173108f, 0.09197187f, -0.13515089f, -0.07434763f, -0.09262530f, -0.03402503f, 
    0.25623018f, -0.03105848f, -0.13900927f, 0.06891143f, -0.34850973f, 0.46979782f, -0.14150240f, -0.18747135f, 
    0.05788180f, -0.17525710f, 0.06041783f, 0.24779367f, 0.00583637f, 0.06834631f, 0.14227405f, 0.09537073f, 
    -0.07774220f, -0.26053494f, 0.28347442f, -0.25674662f, 0.04687851f, 0.09849442f, 0.18311387f, 0.19779649f, 
    0.04769290f, -0.20341690f, 0.02696446f, -0.01088780f, -0.05714795f, 0.14743057f, 0.21149580f, 0.16583724f, 
    -0.11059970f, 0.07834097f, 0.11800845f, 0.11219495f, 0.17382082f, 0.12412792f, -0.01945596f, 0.29795280f, 
    -0.09240780f, 0.03570925f, 0.11760826f, -0.11111264f, -0.08585785f, -0.10496894f, -0.06134310f, 0.21344677f, 
    -0.05879045f, 0.13515303f, 0.05144625f, 0.02418937f, -0.27226883f, 0.81039733f, 0.36472553f, -0.08207301f, 
    -0.20719925f, -0.09636764f, 0.06661212f, -0.12700967f, -0.03688117f, -0.02034461f, 0.12925629f, 0.14169106f, 
    -0.23415433f, -0.17164052f, 0.13588364f, 0.27919251f, -0.12576801f, -0.11035471f, 0.01694725f, 0.08135836f, 
    -0.04527305f, -0.04771025f, -0.02947553f, 0.13812768f, -0.03327037f, -0.01608106f, -0.08502422f, -0.03936727f, 
    0.05125059f, 0.05456165f, -0.04380932f, -0.03152258f, -0.11128096f, -0.18018718f, -0.07041418f, -0.26496631f, 
    0.12061962f, 0.13140179f, 0.08402842f, -0.21099775f, -0.06255103f, 0.13441290f, -0.36998641f, 0.16445877f, 
    0.18265145f, 0.15566453f, 0.05844482f, 0.04691793f, -0.21258390f, -0.31306833f, -0.24649490f, 0.11145212f, 
    0.00282256f, 0.04521429f, 0.13116878f, -0.02187961f, -0.15250202f, 0.10366425f, -0.08672916f, 0.06026131f, 
    0.04846037f, -0.04859496f, -0.21941206f, 0.12670980f, -0.05497379f, 0.36711353f, 0.01436061f, -0.05737302f, 
    0.23421595f, 0.25350359f, -0.01646106f, 0.09302421f, -0.29187346f, 0.61808330f, -0.11572441f, 0.05348244f, 
    -0.02686129f, -0.02692515f, 0.04439892f, -0.35658246f, -0.15861134f, 0.02647053f, 0.12680054f, -0.46421078f, 
    -0.36361846f, -0.35827652f, -0.21384996f, -0.00533259f, 0.03840394f, -0.06986598f, 0.03177148f, -0.11192076f, 
    -0.07310122f, -0.15980889f, 0.02980804f, 0.10171515f, -0.26144671f, -0.23356391f, -0.09672634f, 0.19796446f, 
    -0.03026276f, 0.02636438f, 0.12434664f, 0.09899905f, -0.05202030f, -0.05057594f, 0.16832130f, -0.07802749f, 
    0.18328895f, -0.11695856f, 0.07309233f, -0.08249872f, 0.01044724f, -0.05026516f, 0.32106623f, 0.34644634f, 
    0.08251783f, 0.13865867f, 0.18074994f, 0.32504597f, 0.32866985f, 0.29930362f, -0.20847926f, -0.14227231f, 
    0.00448817f, -0.15307900f, -0.07872210f, 0.19113794f, -0.08982931f, -0.17887130f, -0.08064751f, -0.38754863f, 
    0.31349710f, 0.15397303f, -0.09529497f, 0.10503880f, 0.08572114f, -0.09323980f, 0.02759127f, -0.06463967f, 
    -0.02487993f, 0.15798165f, 0.10772145f, 0.09557766f, -0.41254789f, -0.14095782f, -0.21558006f, -0.25497961f, 
    0.01022747f, -0.14398269f, 0.40501872f, 0.17012490f, -0.01787431f, 0.05560499f, -0.09835780f, 0.18314673f, 
    -0.22687326f, -0.06608374f, 0.34606352f, -0.11738070f, 0.09901806f, 0.09885775f, 0.00712061f, 0.02341622f, 
    -0.15409662f, -0.09833219f, -0.07592463f, -0.24031861f, -0.05871101f, 0.11470186f, 0.05532669f, 0.09334686f, 
    0.03075668f, 0.19782037f, 0.19473210f, 0.12249941f, 0.29720205f, 0.04942507f, -0.01321664f, 0.36851206f, 
    0.13347152f, 0.05141937f, -0.16793545f, -0.05201620f, 0.03596044f, -0.14847162f, -0.04421626f, 0.07538528f, 
    -0.16687052f, 0.04770398f, -0.18312481f, -0.10679282f, -0.40943336f, 0.42212978f, -0.26626852f, 0.20899992f, 
    -0.00325366f, -0.04435705f, 0.20816809f, 0.00974014f, -0.03159635f, 0.01092069f, 0.03197993f, 0.08431247f, 
    0.10882653f, -0.03510606f, -0.01308746f, 0.18926087f, 0.14380747f, 0.05831905f, 0.08635484f, -0.08504826f, 
    -0.04232354f, -0.10583410f, 0.11853799f, 0.23251480f, 0.04039349f, 0.03460759f, -0.23198672f, 0.00665129f, 
    0.26604882f, -0.17746040f, -0.25982305f, -0.10706182f, -0.30389759f, -0.21781296f, -0.17733331f, -0.18108386f, 
    0.21212721f, 0.02316925f, 0.30043274f, -0.11615810f, -0.05373721f, -0.00502896f, 0.04541898f, 0.26373920f, 
    0.13481215f, 0.13254268f, 0.24195580f, 0.22315350f, 0.36046034f, -0.03223986f, 0.07821894f, 0.04472242f, 
    -0.05865370f, 0.04160126f, 0.10915741f, 0.08701210f, 0.12331768f, -0.09508032f, -0.04637920f, -0.05676486f, 
    0.13127087f, -0.04952284f, -0.04880561f, 0.15669860f, -0.09120742f, 0.17354800f, 0.14696531f, -0.11077218f, 
    0.18430650f, 0.14995223f, 0.00862489f, 0.29419288f, 0.16029543f, 0.53937960f, -0.22743843f, 0.24885997f, 
    0.02777067f, -0.17122345f, -0.06593157f, -0.15379721f, -0.00366287f, -0.01117003f, -0.25799823f, -0.46354049f, 
    -0.11046020f, -0.11765563f, -0.06923095f, 0.10305174f, 0.09970636f, -0.10351007f, -0.14785430f, -0.00599907f, 
    0.04660848f, -0.26726910f, -0.03629931f, 0.00275341f, 0.23139744f, 0.01331748f, 0.15345837f, -0.10738104f, 
    0.06843849f, 0.08663623f, -0.00636288f, -0.02601607f, -0.00473493f, -0.01049196f, -0.18979681f, -0.19630574f, 
    0.03449518f, 0.05174368f, -0.13590027f, -0.48476005f, 0.04466842f, -0.03781318f, 0.08267864f, -0.07712533f, 
    0.00770418f, 0.15243228f, 0.05417957f, 0.00898568f, 0.26688102f, 0.08459160f, -0.14397211f, -0.38930711f, 
    0.11030830f, 0.10311598f, -0.06584932f, 0.01422066f, 0.09763286f, 0.05087792f, 0.09385593f, -0.08861496f, 
    0.57794815f, 0.08366130f, -0.01409695f, -0.16495481f, 0.04935280f, 0.14416905f, 0.03169077f, -0.15740430f, 
    -0.09626074f, 0.09514549f, 0.07216599f, 0.22834197f, -0.27985334f, 0.34823728f, -0.03950316f, -0.10240576f, 
    0.14129847f, -0.04921858f, 0.19550996f, 0.20218088f, 0.04528555f, 0.00387879f, 0.02943964f, -0.01241851f, 
    -0.11358090f, 0.23241407f, 0.10333303f, -0.06537310f, -0.15434240f, 0.00336303f, 0.01267391f, -0.05370088f, 
    -0.00747271f, 0.00159193f, -0.09810044f, 0.00441171f, -0.10164436f, -0.02444872f, -0.30361328f, 0.17414115f, 
    -0.00378288f, 0.10455941f, 0.09560385f, 0.01534729f, -0.04451607f, 0.10856360f, -0.05096111f, 0.10112146f, 
    0.04999211f, 0.16053890f, -0.36033013f, 0.08487245f, 0.07584059f, 0.04020490f, -0.09026224f, 0.13014358f, 
    -0.16728634f, 0.10841623f, -0.11834159f, 0.15509199f, -0.79263091f, -0.02557663f, -0.05244381f, 0.62200087f, 
    -0.03300458f, 0.12542458f, 0.19142908f, 0.11609258f, -0.17140895f, 0.03287980f, 0.19254506f, 0.06817129f, 
    0.11319607f, -0.14808497f, -0.12900603f, 0.15364899f, 0.05432948f, 0.05937610f, 0.01094016f, -0.06619942f, 
    -0.06859127f, 0.13897380f, 0.18097825f, 0.09280214f, -0.33173034f, 0.18189584f, 0.15811659f, 0.12644988f, 
    0.09831407f, -0.01345851f, -0.13162275f, -0.09142537f, -0.09722406f, 0.00982733f, 0.10347231f, -0.04977173f, 
    0.26578104f, 0.50802952f, -0.53960794f, -0.23242137f, 0.22782287f, 0.09729242f, 0.18285914f, -0.07064589f, 
    -0.19768168f, 0.08428284f, 0.27407232f, 0.05973215f, 0.41056377f, 0.02319953f, 0.14777045f, -0.00981654f, 
    -0.01850840f, -0.20490985f, 0.09633224f, 0.03365502f, -0.03321897f, 0.05590356f, -0.10378849f, -0.10704155f, 
    -0.40722093f, 0.08062053f, 0.15979703f, 0.09595717f, -0.06217439f, 0.15968661f, 0.08478393f, 0.05946864f, 
    -0.03898768f, 0.01162942f, -0.16856456f, -0.00487635f, -0.11216138f, 0.18935162f, 0.18485953f, 0.43316099f, 
    0.09603725f, -0.07157353f, 0.00446366f, 0.11512693f, -0.01221439f, 0.03777150f, 0.17136808f, -0.04277201f, 
    -0.15426512f, 0.17253846f, 0.02566284f, -0.12422638f, -0.07318582f, -0.06633378f, -0.08187854f, -0.01648026f, 
    -0.01413989f, 0.02992560f, -0.07517634f, -0.06102893f, 0.19191518f, 0.05895164f, -0.16872571f, -0.11838292f, 
    0.11884374f, -0.18413654f, 0.01070749f, -0.04862666f, 0.05654246f, -0.12417123f, 0.06092366f, -0.07482783f, 
    -0.07530158f, -0.25898805f, -0.15481271f, -0.08246769f, 0.06328458f, -0.06917619f, -0.03317658f, 0.03201267f, 
    -0.00614551f, 0.00112860f, 0.05555798f, 0.14910556f, -0.10704438f, 0.08469900f, 0.03126895f, -0.10400616f, 
    0.00049481f, -0.05042987f, 0.11159691f, -0.03911104f, -0.09089226f, -0.03439929f, -0.00226840f, 0.14458108f, 
    -0.19754136f, -0.13107947f, 0.12187449f, -0.00729110f, 0.02892379f, -0.08156621f, 0.15956292f, 0.12832026f, 
    -0.16525635f, -0.11944550f, -0.25157171f, 0.17541701f, 0.00828528f, 0.04941717f, 0.00468651f, 0.00616478f, 
    -0.11006944f, 0.02282461f, 0.01813075f, 0.06409194f, 0.09925575f, 0.12503491f, 0.01952700f, -0.17279686f, 
    -0.13536562f, -0.06609238f, -0.11497608f, -0.16334578f, -0.00871676f, 0.07799182f, -0.03888169f, 0.09789087f, 
    0.08522157f, 0.02619897f, 0.00683079f, -0.06732279f, 0.29289812f, 0.22297129f, 0.10760451f, 0.22081891f, 
    0.06962448f, 0.00668594f, 0.09381007f, -0.04070313f, 0.05182692f, -0.02355778f, -0.07480540f, 0.23171471f, 
    0.49524361f, 0.42743769f, 0.02318951f, 0.29933113f, -0.01452723f, -0.12482939f, 0.00621477f, 0.01674013f, 
    0.06517304f, -0.02379396f, 0.02543225f, -0.12302332f, -0.12178347f, 0.23001248f, -0.47295952f, 0.17443477f, 
    0.01365105f, 0.02584775f, -0.02990380f, 0.02471711f, 0.08011831f, 0.02563880f, -0.00097462f, -0.02427332f, 
    0.17495994f, 0.35190234f, 0.11559872f, 0.20806603f, 0.12571172f, 0.08999361f, -0.01909722f, -0.06825229f, 
    -0.03920517f, -0.17418998f, -0.00366004f, 0.05231369f, -0.06074530f, -0.15914023f, -0.31194350f, 0.26152140f, 
    -0.01692920f, -0.01874860f, -0.08074342f, 0.03295923f, -0.05126533f, -0.09320510f, -0.08923328f, -0.03635805f, 
    -0.06958357f, 0.32439348f, 0.19750379f, -0.16564249f, -0.02961116f, 0.09210854f, 0.23740491f, 0.02420309f, 
    -0.16107850f, 0.00559364f, 0.14310130f, 0.01705826f, 0.28509557f, 0.18824255f, 0.46774432f, 0.16175796f, 
    -0.02637151f, 0.21111792f, -0.02095934f, 0.29542297f, 0.13830799f, 0.06068391f, 0.05020218f, 0.00673935f, 
    -0.42843294f, -0.36870977f, 0.02274771f, 0.12073976f, -0.04293076f, -0.06723369f, -0.16650544f, -0.11693873f, 
    0.04158908f, 0.02824091f, -0.05954355f, 0.20368153f, 0.03657885f, -0.02318497f, -0.11460035f, 0.28442067f, 
    0.00333905f, 0.04230528f, 0.13792428f, -0.09028573f, -0.14853731f, 0.02530705f, -0.01414204f, -0.10218005f, 
    -0.17129795f, -0.57969576f, -0.20898646f, 0.22603263f, -0.03205319f, -0.24958235f, -0.07447067f, -0.04022744f, 
    0.05768795f, -0.06608646f, 0.13327776f, 0.09628505f, 0.25467661f, 0.30772319f, 0.52388757f, 0.01330381f, 
    0.15893956f, 0.21940029f, 0.31190908f, 0.03839428f, 0.12132140f, 0.02436944f, -0.11322825f, -0.08665938f, 
    -0.00259653f, -0.09060096f, 0.14436975f, 0.08027975f, -0.07644033f, 0.11748581f, -0.01268653f, 0.01747655f, 
    -0.13912688f, 0.07120455f, 0.12870112f, -0.04511475f, -0.21200363f, 0.02931651f, 0.17616317f, 0.08484381f, 
    -0.16575503f, 0.09972695f, 0.06923912f, -0.08187098f, 0.00753513f, 0.10761756f, -0.05967468f, -0.07011081f, 
    -0.18396722f, 0.22881827f, 0.18571025f, 0.14586969f, 0.03289599f, -0.00588807f, 0.06896391f, -0.11077700f, 
    0.02414246f, 0.04124761f, -0.07561441f, 0.10594802f, 0.18109359f, 0.14719725f, 0.05292196f, 0.04418717f, 
    0.16229227f, 0.06034378f, 0.13251428f, 0.11266552f, 0.05542802f, -0.09259091f, -0.07965094f, 0.06157247f, 
    0.04202814f, 0.03461706f, -0.01658102f, 0.09972172f, 0.05329364f, 0.02205531f, -0.00792983f, -0.00781795f, 
    -0.03803929f, -0.08791818f, -0.00825914f, 0.01815974f, -0.01926992f, 0.19878294f, -0.28142560f, -0.24735487f, 
    0.17261311f, 0.00120917f, -0.10108344f, 0.09931593f, 0.14440285f, 0.11788104f, 0.18449128f, -0.05085939f, 
    0.02783702f, 0.03904838f, -0.63744676f, -0.33741921f, 0.13505122f, 0.01027852f, -0.10509628f, -0.07245152f, 
    -0.02215462f, -0.14673890f, 0.02943987f, -0.10101980f, 0.66544336f, -0.20357035f, -0.41409597f, -0.13860433f, 
    0.07993560f, -0.13642368f, -0.09223732f, 0.11103693f, 0.19229543f, 0.28386918f, -0.16336915f, 0.00791184f, 
    -0.23412414f, -0.00342702f, -0.38469481f, -0.16832519f, 0.12634577f, 0.04303757f, 0.01276397f, 0.12643909f, 
    0.07671380f, 0.11802428f, -0.00420812f, 0.08697056f, 0.32993150f, 0.17365985f, 0.09663495f, 0.13521157f, 
    -0.01019680f, -0.04741973f, 0.08156916f, -0.12387288f, -0.04721588f, -0.08938956f, -0.07873537f, -0.02822551f, 
    -0.14733411f, 0.14351487f, 0.10716872f, 0.13192190f, -0.10310949f, 0.24618234f, -0.01928334f, -0.02718103f, 
    0.10503177f, 0.10852256f, -0.14397322f, 0.04244157f, -0.13061294f, -0.15441127f, 0.08056662f, -0.55317086f, 
    -0.11592978f, -0.09806994f, -0.04531538f, -0.05249375f, -0.15616278f, 0.01448887f, -0.02779439f, -0.02044889f, 
    0.29036650f, -0.07530079f, 0.10842139f, 0.13171555f, -0.04990775f, 0.13412383f, 0.08310132f, 0.10569491f, 
    0.09590116f, 0.13190083f, 0.16382581f, 0.09778747f, 0.14651224f, -0.18190372f, -0.04353982f, 0.02393387f, 
    -0.04437372f, -0.03934313f, 0.16422488f, 0.19405164f, -0.09729140f, -0.11749277f, -0.12892309f, 0.00296961f, 
    0.10917744f, 0.11196171f, 0.15353908f, 0.20273046f, -0.09556004f, -0.07949109f, 0.02997677f, -0.04636547f, 
    0.03867342f, 0.01413856f, -0.03979058f, -0.00742245f, -0.33894339f, 0.05510436f, -0.26970756f, -0.37684041f, 
    -0.05624983f, 0.13390628f, 0.03802412f, -0.10599503f, -0.07434594f, -0.05961413f, -0.08178934f, 0.01116144f, 
    0.00839583f, -0.03679103f, -0.04152568f, 0.02955822f, -0.01039899f, 0.03276259f, 0.02872961f, -0.03171417f, 
    -0.04318753f, -0.05665262f, 0.00319149f, 0.04407380f, 0.00693233f, 0.05423647f, -0.06898432f, -0.04095344f, 
    -0.03859694f, -0.00068436f, 0.04218379f, -0.05187443f, 0.00627932f, 0.04963757f, -0.05717620f, 0.06127617f, 
    -0.05822465f, 0.01369541f, -0.01807701f, 0.02702349f, 0.06158276f, -0.05320686f, -0.06618474f, 0.00497974f, 
    -0.06954861f, -0.04759532f, 0.05739929f, -0.01224694f, 0.03466992f, -0.00130170f, 0.00151765f, -0.04457727f, 
    0.03488733f, -0.06833810f, 0.05791910f, 0.00061036f, -0.03669889f, 0.04215965f, -0.06795702f, -0.04249569f, 
    0.02475324f, -0.04975849f, 0.03881320f, -0.01754607f, -0.03727429f, 0.01786916f, -0.06430602f, -0.07761721f, 
    0.03818706f, -0.06386767f, 0.06287614f, 0.03083983f, -0.07056137f, 0.02559719f, 0.01901233f, -0.05491164f, 
    -0.02638618f, -0.05656854f, -0.03195843f, 0.06055414f, 0.06618253f, -0.04067459f, -0.01074524f, -0.02769067f, 
    -0.03769344f, -0.03169198f, 0.03675414f, 0.03677129f, -0.02251044f, -0.07397576f, -0.02297180f, 0.05639221f, 
    -0.03956371f, 0.03139782f, 0.01366557f, -0.05245780f, 0.05857252f, -0.05566366f, 0.03756443f, -0.00814424f, 
    0.05081680f, 0.00230207f, -0.03753116f, -0.00174368f, -0.05291675f, 0.01163807f, 0.01545628f, -0.05176580f, 
    -0.05063294f, -0.00967295f, -0.00224305f, -0.00532983f, -0.01719422f, -0.07299699f, -0.06225076f, 0.04957736f, 
    0.02201703f, 0.02535428f, -0.01865328f, -0.06580907f, -0.01763671f, 0.01091927f, 0.02782271f, -0.00183134f, 
    -0.04558545f, -0.01137268f, 0.00309250f, -0.02714437f, 0.03770207f, 0.04118741f, -0.07608291f, 0.04998298f, 
    -0.02574984f, -0.02719331f, -0.00014476f, -0.03200979f, -0.01626485f, -0.06180492f, -0.07239377f, 0.04628047f, 
    0.01898449f, 0.02655974f, -0.05126058f, 0.01680470f, -0.02533945f, 0.01364647f, -0.07208452f, 0.03640288f, 
    -0.05645256f, 0.02184230f, -0.02588861f, -0.02996904f, -0.05122789f, -0.01324783f, 0.03281837f, 0.04316420f, 
    0.02395498f, -0.07603202f, -0.01989830f, -0.06112737f, -0.00439291f, 0.03782812f, 0.06513592f, -0.02317529f, 
    0.03239357f, -0.03788925f, -0.00298108f, -0.05387508f, 0.02202450f, 0.00058283f, 0.03741857f, -0.03474317f, 
    0.04318693f, -0.06956516f, 0.04804765f, -0.03360661f, -0.02870822f, -0.00772288f, 0.06026345f, -0.07155720f, 
    -0.02751401f, 0.03535388f, -0.06730504f, -0.06872599f, 0.04937407f, -0.03355921f, -0.01297437f, -0.01780316f, 
    -0.07540426f, -0.05521694f, -0.01951165f, 0.04021144f, 0.01205528f, -0.06961387f, -0.06674313f, -0.03135381f, 
    -0.00354286f, -0.04531966f, 0.00861365f, 0.02044609f, -0.01091983f, -0.04163263f, -0.02754579f, -0.00312652f, 
    0.00324520f, -0.07083262f, -0.04761571f, -0.09613304f, 0.01306291f, -0.10202276f, -0.08584014f, -0.00115590f, 
    0.26640728f, 0.01270203f, 0.06791905f, 0.11924496f, -0.15105073f, 0.17099743f, -0.01464010f, 0.06069000f, 
    -0.02220055f, -0.03691519f, 0.15281008f, 0.17085618f, 0.15536185f, 0.00676584f, 0.05501332f, -0.09242881f, 
    -0.17678086f, -0.00863838f, -0.03949775f, 0.50643301f, -0.17448303f, -0.10840526f, -0.12873243f, -0.25903961f, 
    0.15586939f, 0.07657725f, 0.12182429f, 0.03990010f, 0.04807463f, -0.21350840f, -0.00217887f, 0.10543709f, 
    0.28762189f, 0.10580084f, 0.12139331f, 0.05170354f, 0.01698542f, 0.08995818f, 0.16146281f, 0.18583649f, 
    0.04630335f, 0.04104118f, -0.13269362f, -0.13088521f, -0.13611099f, 0.33978757f, -0.02833110f, -0.04249419f, 
    0.17291567f, -0.02173075f, -0.05604586f, -0.01360297f, -0.21034864f, -0.04194793f, -0.07271216f, -0.40451631f, 
    -0.01009580f, 0.00862998f, 0.18143688f, -0.01783829f, -0.06342919f, 0.05440090f, 0.02163168f, -0.30121934f, 
    -0.37375703f, 0.16048916f, -0.24947743f, 0.05719353f, -0.07284142f, 0.16254897f, -0.02075022f, 0.30433068f, 
    -0.00604504f, 0.11112932f, -0.04035341f, 0.23025830f, -0.18723290f, -0.23578690f, -0.07012379f, -0.01197745f, 
    -0.16393389f, 0.24819452f, 0.06157238f, 0.06299286f, -0.07491382f, 0.20610009f, 0.15068921f, -0.02879397f, 
    -0.15060268f, -0.25301298f, -0.11660701f, -0.38118282f, -0.04747633f, -0.05547113f, 0.01907662f, -0.09206457f, 
    0.18918587f, -0.01206529f, 0.15021983f, 0.11297512f, -0.14737065f, 0.13158303f, 0.04215856f, -0.01249958f, 
    0.12414884f, -0.06444745f, -0.15131360f, -0.05105489f, -0.06050522f, 0.06343108f, -0.07756868f, 0.11144050f, 
    -0.22192514f, 0.19990878f, 0.01602017f, 0.03706988f, -0.01224569f, -0.16585691f, 0.21481016f, 0.05130859f, 
    -0.02496293f, -0.05620139f, 0.21395597f, -0.01603172f, 0.13021484f, -0.00233638f, -0.03190971f, 0.18375899f, 
    0.27143505f, -0.01712359f, -0.02005858f, 0.28829700f, 0.00856491f, 0.08840032f, 0.04691763f, 0.01014833f, 
    0.68327570f, 0.25144359f, 0.19748698f, 0.29673436f, 0.14777505f, 0.12843607f, 0.13633364f, 0.23173085f, 
    -0.02505696f, -0.04482368f, 0.02763066f, 0.04276621f, 0.12086941f, 0.05672083f, 0.00088304f, -0.20261680f, 
    0.10446376f, 0.08897611f, -0.04969148f, 0.18839803f, -0.02058506f, 0.02152419f, -0.11611474f, 0.01455001f, 
    -0.03592040f, 0.12963203f, 0.07216480f, -0.14192472f, -0.04013208f, -0.00313134f, 0.01375248f, 0.03450362f, 
    -0.09948790f, -0.10316145f, -0.16658226f, -0.20039935f, -0.01367027f, -0.13892919f, -0.10433070f, -0.09586759f, 
    0.08879376f, -0.03627432f, 0.00906490f, 0.01505311f, 0.07323498f, -0.06318004f, 0.00110541f, 0.06630231f, 
    0.05384869f, 0.03897727f, 0.05640324f, 0.03435234f, -0.04082935f, 0.01304164f, -0.00178809f, -0.02222781f, 
    0.05990438f, -0.07779092f, 0.03333290f, 0.00638082f, -0.04210201f, -0.04101629f, 0.05956001f, -0.03020665f, 
    -0.00932922f, -0.07101539f, -0.04529192f, -0.02536445f, 0.01356425f, -0.02563923f, 0.03078807f, 0.03009906f, 
    -0.06014877f, -0.01630738f, 0.05226943f, 0.03902547f, 0.01365643f, -0.02674336f, 0.03799436f, 0.01756611f, 
    0.04949422f, 0.01703855f, -0.01251158f, 0.05840530f, -0.04914882f, 0.05595623f, 0.03674103f, -0.00418123f, 
    0.01161016f, 0.04020284f, -0.06109934f, -0.04590556f, 0.04767616f, 0.03989236f, -0.08038247f, 0.04405282f, 
    0.04827354f, -0.00628407f, 0.04435347f, -0.02197107f, 0.05168476f, 0.01150252f, -0.06125752f, -0.08065204f, 
    0.02251595f, 0.03096999f, 0.01092634f, -0.02866806f, -0.02012503f, -0.06840690f, -0.04927990f, -0.04688124f, 
    -0.03062315f, -0.04198375f, 0.00221692f, -0.04063033f, -0.06252564f, 0.03941246f, -0.06476571f, 0.00976700f, 
    0.06160587f, -0.04483544f, 0.03612316f, 0.01953330f, 0.05890116f, -0.02704318f, -0.04237885f, -0.07742632f, 
    -0.06154420f, -0.07368870f, -0.00023437f, -0.07925090f, -0.07701243f, -0.01318874f, -0.05667079f, 0.02776602f, 
    0.01750455f, -0.00401334f, -0.01850428f, -0.02010678f, 0.01443032f, -0.07117436f, -0.07299865f, 0.04264870f, 
    -0.05194682f, -0.05186903f, -0.06871886f, 0.02921724f, 0.05154929f, 0.05687052f, -0.00431741f, -0.02813919f, 
    -0.00405698f, 0.01059858f, -0.06042229f, -0.04336112f, 0.02109302f, -0.02237395f, -0.02283380f, -0.01090337f, 
    0.03670464f, 0.02224403f, 0.01865837f, -0.07278214f, -0.00772544f, 0.00632891f, -0.01964361f, -0.03916667f, 
    -0.04255890f, 0.02710479f, -0.06083478f, 0.02813132f, 0.02949215f, 0.02887050f, 0.00267248f, -0.04768863f, 
    -0.01263969f, -0.00351843f, -0.01046259f, 0.06279749f, -0.07803094f, 0.01707734f, -0.02315546f, -0.06602821f, 
    0.03637009f, -0.03312724f, -0.03805652f, 0.00261563f, -0.01292496f, -0.00280913f, -0.01256163f, -0.02027011f, 
    -0.03662990f, -0.07875361f, -0.05589656f, -0.02602640f, -0.03152646f, 0.05925479f, 0.04243319f, 0.03958960f, 
    -0.03948782f, 0.01633719f, 0.01345215f, -0.00729158f, -0.04658963f, 0.01912419f, -0.06043570f, -0.04463951f, 
    -0.07817598f, -0.06007651f, 0.00034882f, -0.05775610f, -0.00249117f, -0.03336154f, -0.06589138f, -0.00395122f, 
    -0.03997133f, -0.06277614f, -0.05461596f, -0.03889208f, -0.05934124f, -0.03135693f, -0.03841734f, 0.00512598f, 
    -0.00066135f, -0.07308654f, -0.03032592f, 0.01742624f, -0.06358236f, -0.07471140f, 0.01861800f, 0.02658475f, 
    -0.01602695f, -0.08023579f, -0.01943252f, -0.00345346f, -0.00695681f, -0.07452761f, 0.05720546f, 0.02104677f, 
    0.09398773f, -0.04062183f, 0.18771560f, -0.08874491f, -0.01840948f, 0.02171806f, -0.20050143f, -0.31621233f, 
    0.14104743f, 0.09195770f, 0.22959661f, -0.09340354f, 0.26424107f, 0.09433015f, -0.07162370f, 0.05206274f, 
    0.17880154f, -0.24603705f, -0.17339490f, -0.47942427f, -0.03891405f, -0.08000810f, 0.04958099f, -0.05368976f, 
    0.21597122f, 0.19584304f, 0.35640171f, 0.02063901f, -0.02453052f, 0.14897373f, -0.14758974f, -0.21358423f, 
    0.05522149f, -0.00296771f, -0.02837108f, -0.10475524f, 0.35540015f, -0.13151871f, -0.15313879f, -0.20123197f, 
    0.20593792f, -0.11172493f, 0.13086386f, -0.03392766f, -0.05674390f, 0.04945275f, 0.01452726f, 0.06207312f, 
    0.15486199f, -0.38468984f, 0.13798429f, -0.37211937f, -0.16743244f, 0.12160639f, -0.14148007f, 0.15385856f, 
    0.05833207f, 0.01012884f, 0.01546415f, -0.16454455f, -0.02525432f, 0.00218684f, -0.01565059f, -0.04647309f, 
    -0.13855933f, 0.02242662f, 0.08339609f, 0.20300286f, 0.09148020f, -0.01204933f, -0.03414690f, -0.07099678f, 
    -0.06817922f, 0.15479991f, -0.34917051f, 0.02412476f, 0.27417666f, -0.04149842f, 0.09541152f, 0.10123666f, 
    -0.02032954f, -0.04944462f, -0.07078280f, 0.01490559f, 0.10925571f, -0.13217679f, 0.41273901f, -0.95090872f, 
    -0.08397633f, -0.16078356f, 0.10411278f, 0.14352435f, 0.03596226f, 0.16786273f, 0.05835900f, 0.00975815f, 
    0.10184626f, 0.11427574f, -0.07038365f, -0.05912423f, 0.06029052f, 0.00245420f, 0.13702394f, 0.19815306f, 
    0.02234603f, 0.04369701f, 0.10625994f, 0.04296747f, 0.03607988f, 0.05890809f, -0.06678388f, 0.20682469f, 
    -0.05780485f, -0.04729463f, 0.00295675f, -0.14578278f, 0.05970087f, 0.00467315f, 0.03762087f, 0.04941359f, 
    0.37066782f, 0.00377123f, -0.04961791f, 0.07323812f, 0.01472338f, -0.06763662f, -0.18106239f, 0.23920539f, 
    -0.06545760f, 0.01405065f, 0.00289255f, 0.03206432f, -0.15866044f, 0.34139246f, -0.47826216f, 0.25350764f, 
    0.09500067f, -0.08760910f, 0.09546477f, -0.07870146f, -0.04952548f, -0.03862281f, -0.06288472f, 0.07485699f, 
    0.03029441f, -0.02438815f, -0.09231248f, 0.01082439f, -0.13747890f, 0.05061093f, -0.02190938f, -0.12848212f, 
    -0.04054513f, -0.03471417f, 0.08560918f, -0.05455858f, -0.42923725f, 0.55709505f, 0.18128958f, -0.09914754f, 
    -0.07060250f, -0.12574057f, 0.15664132f, 0.11317055f, 0.07291064f, 0.02984921f, -0.03777875f, 0.06526858f, 
    0.03460006f, -0.14568901f, -0.05127805f, -0.05577717f, 0.13440403f, 0.06011623f, 0.15016380f, -0.14477754f, 
    0.19584946f, 0.10086606f, -0.00234560f, 0.07303207f, -0.13488699f, -0.11659241f, -0.28295437f, -0.00306479f, 
    -0.04336795f, -0.29245493f, 0.06568186f, 0.27688450f, -0.13152955f, -0.06329509f, 0.06029902f, 0.03630431f, 
    0.03535932f, -0.26334453f, -0.18913162f, -0.09790550f, 0.05896964f, -0.05577851f, -0.07439077f, -0.02658631f, 
    -0.11842211f, -0.00206927f, -0.02126027f, 0.14501488f, 0.00911740f, -0.13680573f, -0.28820434f, -0.24976932f, 
    -0.01392196f, -0.23848939f, 0.03647988f, -0.05548815f, -0.05351722f, 0.07811304f, -0.12259880f, 0.14433345f, 
    0.08525959f, 0.03598272f, -0.13716850f, 0.04914140f, -0.07745671f, -0.06728330f, 0.08322964f, 0.01366029f, 
    0.06837399f, 0.18084793f, 0.04225213f, 0.32230884f, 0.41133577f, 0.00256998f, -0.06934471f, 0.04943892f, 
    -0.19973952f, 0.03826860f, 0.15923984f, -0.25425783f, 0.12311829f, -0.13161953f, -0.00184666f, -0.11171837f, 
    0.01748390f, -0.07995078f, -0.19627874f, -0.22107920f, -0.06768901f, -0.15269376f, -0.11812922f, 0.00586033f, 
    0.18474039f, 0.00732627f, -0.01915267f, 0.15737021f, 0.02731961f, -0.15928900f, -0.03520869f, 0.07573140f, 
    0.08618630f, 0.14984812f, 0.21599461f, 0.13436390f, 0.14919037f, -0.03003573f, -0.08584595f, -0.19696911f, 
    0.13474101f, 0.07072343f, 0.02765109f, -0.06804097f, 0.08569533f, 0.15314445f, 0.38839307f, -0.05667349f, 
    0.09873782f, -0.00030454f, 0.01982591f, 0.09123274f, -0.15947358f, -0.08030662f, -0.31529298f, 0.24065019f, 
    0.13044955f, 0.17627852f, 0.14024553f, 0.01266302f, 0.17130001f, 0.06697185f, 0.08676581f, -0.00418270f, 
    0.10019601f, 0.09256502f, -0.00250285f, 0.17899592f, 0.18827298f, 0.12113241f, 0.08327757f, 0.14071412f, 
    0.07235960f, 0.11604883f, 0.14450169f, 0.17662102f, -0.12852742f, 0.16241306f, 0.02702677f, 0.33900207f, 
    0.02193632f, -0.02934310f, -0.04641629f, -0.07645877f, 0.00010413f, -0.03510008f, 0.14142732f, 0.13178042f, 
    0.02834990f, 0.11927099f, -0.11821554f, -0.40924245f, -0.11390561f, -0.15012242f, 0.15107116f, 0.03376490f, 
    -0.07999866f, -0.18744709f, -0.16976029f, -0.02978636f, 0.29168135f, 0.10255066f, 0.07461303f, 0.31719053f, 
    0.23169573f, 0.07183942f, -0.02217441f, 0.27987832f, -0.05845123f, 0.09425608f, -0.02901554f, -0.00233217f, 
    -0.34159082f, -0.12955877f, 0.09889849f, 0.04357572f, 0.16001365f, 0.04022255f, -0.23744790f, -0.05092211f, 
    -0.02110267f, 0.01454541f, 0.00676463f, 0.09406895f, -0.58172429f, -0.05934919f, -0.25548783f, 0.21584563f, 
    -0.08787762f, 0.10863544f, -0.02281043f, -0.08118393f, 0.02141375f, -0.01732120f, 0.09236136f, 0.13903357f, 
    -0.31898114f, 0.14988054f, 0.03630895f, 0.07953130f, 0.00964899f, -0.14823022f, -0.23718995f, -0.18757853f, 
    -0.08413028f, -0.05502094f, 0.06836786f, 0.07528343f, 0.25460342f, 0.05570888f, 0.08840593f, 0.05008491f, 
    0.07988207f, 0.29170075f, 0.28231755f, -0.01854526f, 0.08208472f, 0.06591582f, -0.00738596f, 0.11818314f, 
    -0.12726887f, -0.07256554f, -0.02355029f, 0.30302054f, -0.01724196f, 0.09230009f, 0.18477243f, 0.10363127f, 
    0.16370067f, -0.01252575f, 0.04954017f, 0.22700667f, -0.18218121f, -0.19753313f, 0.02180790f, 0.05513182f, 
    -0.11400713f, 0.08751696f, 0.09558415f, 0.19345336f, 0.06281317f, 0.05379913f, -0.12948965f, -0.05484356f, 
    -0.39736962f, -0.18131888f, -0.24196653f, 0.08040804f, -0.04548891f, 0.07832198f, 0.13786381f, 0.09919440f, 
    0.15246131f, 0.10569482f, -0.06251241f, -0.09164239f, 0.00031301f, -0.01312752f, 0.07995871f, 0.00129544f, 
    0.06846715f, 0.14097334f, 0.08396483f, -0.20581479f, 0.02518895f, 0.07589944f, -0.04706060f, -0.09787282f, 
    -0.05367868f, 0.13874412f, -0.10602542f, 0.14328341f, -0.06955080f, 0.15399268f, -0.00874553f, -0.02009035f, 
    -0.08757959f, 0.03086081f, -0.03085608f, 0.02019191f, 0.08078766f, -0.06034556f, 0.07141874f, -0.04430604f, 
    0.01470391f, 0.00653822f, -0.03236068f, -0.09915249f, 0.09824339f, 0.05761509f, 0.09416978f, 0.27179193f, 
    0.27198389f, -0.18303613f, 0.34221202f, -0.10385428f, -0.07798617f, -0.04460433f, 0.03127440f, -0.06051232f, 
    -0.03551889f, -0.18990128f, 0.01260481f, -0.18863919f, 0.35716277f, 0.03946488f, -0.25976098f, 0.04969145f, 
    0.10259356f, 0.03947655f, -0.09594736f, -0.23657046f, 0.02872879f, 0.15948035f, -0.18939152f, -0.12467577f, 
    0.04828302f, 0.26675633f, 0.04195999f, 0.06441534f, 0.08478036f, 0.02353743f, -0.10542976f, -0.01542394f, 
    -0.03209523f, -0.10136636f, -0.24682607f, -0.15100119f, 0.32151562f, -0.17439693f, 0.00093586f, -0.21372904f, 
    -0.00027518f, 0.09423354f, 0.07046916f, 0.08071283f, -0.09845772f, -0.15988113f, 0.06036776f, -0.19110779f, 
    -0.03332968f, -0.44041008f, 0.23890941f, 0.27033749f, -0.13371150f, 0.06036846f, 0.06266927f, 0.08815116f, 
    0.19448349f, 0.08083446f, 0.13425480f, 0.08879106f, -0.00820808f, 0.13287398f, 0.08109703f, -0.20615521f, 
    -0.08723071f, 0.00001970f, -0.04606674f, 0.10936722f, 0.10942000f, 0.01142784f, 0.09739472f, -0.09831753f, 
    -0.19674619f, 0.07860725f, 0.22575024f, 0.02237850f, 0.04469020f, -0.17443985f, -0.04553956f, -0.00452306f, 
    0.03055997f, -0.13175553f, 0.05471651f, 0.18541110f, 0.22642131f, -0.29962590f, -0.20307299f, -0.03717072f, 
    0.00842165f, 0.03277192f, -0.25528491f, -0.16566163f, -0.08077316f, 0.09894977f, -0.07568420f, -0.01301759f, 
    0.02692419f, 0.00005489f, 0.04847270f, 0.12167757f, 0.05636682f, -0.07246529f, 0.02454316f, 0.15126593f, 
    -0.01941014f, -0.08216477f, 0.02197349f, 0.06572423f, 0.15431488f, -0.00132061f, -0.02287894f, -0.00186157f, 
    0.05926818f, 0.01160784f, -0.00034698f, 0.01752118f, 0.02442759f, -0.08481956f, -0.06073292f, 0.02542790f, 
    -0.04792048f, 0.06023910f, -0.14243962f, -0.03004677f, -0.00687509f, 0.03245796f, -0.03520430f, -0.11282443f, 
    0.16044389f, 0.09182499f, -0.01010452f, 0.06952730f, 0.18084799f, -0.15048398f, -0.01653281f, 0.09603417f, 
    -0.13097735f, 0.30802137f, 0.05996023f, 0.14627296f, 0.32471839f, 0.21669184f, 0.32076302f, 0.03337480f, 
    0.12579831f, -0.00209454f, 0.06776773f, 0.01406792f, -0.03617424f, -0.05805404f, -0.04020970f, 0.00300590f, 
    0.02628799f, -0.05649769f, 0.16245233f, 0.10641988f, -0.06438831f, 0.12509595f, 0.06869213f, 0.17793952f, 
    0.05445353f, 0.13958165f, -0.00257882f, 0.09172157f, 0.06724609f, 0.19113193f, 0.26292115f, 0.18674707f, 
    0.02598206f, 0.23003908f, -0.13241090f, 0.08310345f, 0.20115188f, 0.13380957f, 0.13305746f, 0.17411584f, 
    -0.01182937f, 0.10331794f, -0.03304119f, -0.00528581f, 0.01737065f, -0.13312256f, 0.12603605f, -0.06323728f, 
    -0.02854153f, -0.21391542f, -0.04090065f, 0.14506689f, 0.08784419f, -0.01475103f, -0.03337124f, -0.04052026f, 
    -0.20261294f, -0.32696840f, 0.38238108f, 0.16254158f, -0.08874397f, 0.09696389f, 0.00322922f, 0.02111547f, 
    -0.09787846f, -0.11553105f, 0.10104269f, -0.06750239f, 0.03255648f, 0.22899032f, 0.71962923f, 0.10309930f, 
    -0.13404579f, 0.07395701f, 0.16121426f, 0.24129531f, 0.06487996f, 0.09368595f, -0.14207849f, -0.12293434f, 
    -0.19471389f, -0.17853951f, -0.03989674f, -0.13659170f, -0.14440291f, -0.05691186f, -0.05434155f, 0.04213727f, 
    0.04143799f, -0.05721499f, -0.07585594f, 0.01947775f, 0.05830994f, -0.09420045f, 0.22204083f, -0.33879501f, 
    -0.08772036f, 0.05544716f, 0.03051450f, 0.01028454f, -0.05383532f, -0.00666321f, 0.13525246f, -0.00877077f, 
    -0.15175353f, -0.23154207f, -0.09595905f, 0.32508138f, 0.04352463f, -0.08176532f, -0.00593181f, 0.15922251f, 
    0.20078754f, 0.08686714f, 0.07138436f, -0.00408025f, -0.17116530f, -0.25454277f, -0.01440790f, 0.13405752f, 
    0.01164358f, 0.03560889f, 0.00233714f, -0.01718763f, -0.08889119f, -0.08740575f, 0.08199003f, -0.01827145f, 
    0.05107926f, 0.36525103f, 0.04592954f, 0.10845662f, -0.09392943f, -0.05074831f, 0.10914794f, -0.01113097f, 
    0.09389089f, -0.13692175f, 0.05767276f, 0.20146957f, 0.06017023f, -0.21091935f, 0.09402713f, -0.03664867f, 
    -0.13348907f, 0.13113490f, 0.03990033f, 0.02388730f, -0.04655645f, -0.09199774f, -0.02850572f, -0.01112004f, 
    0.09051280f, 0.17303757f, 0.04896816f, -0.15072195f, -0.05448217f, 0.05022185f, 0.02086256f, 0.01609833f, 
    -0.11489995f, 0.03154696f, 0.00277769f, 0.02794230f, -0.23050854f, -0.15064108f, -0.08139421f, 0.13161883f, 
    -0.12062775f, -0.05965544f, -0.07595402f, 0.04528183f, -0.00739337f, 0.00035160f, 0.01963435f, -0.00479909f, 
    -0.07788718f, -0.06827705f, -0.03765472f, -0.22668758f, 0.00690220f, -0.01756280f, -0.12336420f, -0.04944840f, 
    -0.11487059f, 0.08657718f, 0.08176877f, -0.08594668f, 0.09814820f, -0.11190662f, -0.16037634f, -0.02249846f, 
    -0.15424110f, -0.01608142f, -0.10563489f, -0.08295404f, -0.01047832f, 0.08236589f, 0.07442341f, 0.29811636f, 
    0.32400373f, 0.34213093f, 0.23319599f, -0.03818779f, -0.16748877f, -0.06090403f, -0.08385107f, -0.10774037f, 
    0.07695594f, -0.15501399f, 0.15646377f, 0.05337366f, -0.17378415f, 0.09114928f, 0.03765957f, 0.02330200f, 
    0.02207240f, -0.09347172f, -0.14682996f, 0.20589258f, 0.04032870f, 0.00204235f, 0.10417151f, 0.14336774f, 
    -0.06755726f, -0.27351168f, 0.03238283f, -0.07326960f, 0.09737118f, -0.06914977f, 0.00131464f, 0.10016411f, 
    -0.13897230f, 0.01076764f, 0.02018785f, 0.10057587f, 0.18637706f, 0.16062775f, 0.07987756f, 0.37891397f, 
    0.10856465f, -0.01347386f, 0.10730863f, 0.19878191f, 0.04476898f, -0.12750475f, 0.01500155f, 0.01767131f, 
    -0.05636816f, -0.07876135f, -0.05915611f, 0.11130483f, -0.07391928f, 0.00526758f, 0.17328468f, 0.03814825f, 
    -0.00745806f, 0.01026754f, 0.08716675f, 0.12131990f, 0.03539352f, 0.10843183f, 0.57249308f, 0.01687381f, 
    -0.01484327f, -0.04628904f, -0.03255248f, 0.01267789f, 0.03463582f, -0.00432043f, 0.08628908f, 0.07325266f, 
    -0.07660288f, -0.04407245f, 0.02546955f, 0.28129208f, -0.00303008f, -0.00621200f, -0.06427800f, 0.24279435f, 
    0.08434470f, 0.18370165f, 0.08740170f, 0.04362734f, -0.35618493f, -0.05100923f, 0.03779529f, 0.33496433f, 
    -0.07243337f, -0.04648551f, 0.11762106f, 0.02876717f, 0.15013930f, 0.04031694f, 0.06406790f, -0.00177870f, 
    -0.01505168f, 0.01436222f, -0.10205352f, -0.09868894f, -0.04958973f, 0.12125614f, -0.26632315f, 0.07419017f, 
    0.06444985f, -0.09137361f, -0.19882920f, -0.07137895f, 0.00514578f, -0.05062751f, 0.09424924f, 0.37399030f, 
    0.05241837f, 0.10839908f, 0.08672182f, -0.10858431f, 0.04475958f, 0.07980063f, 0.00848103f, -0.02306997f, 
    -0.39023092f, -0.23069711f, -0.17861152f, -0.17431533f, 0.06891724f, 0.17366113f, 0.02722112f, -0.01287497f, 
    -0.00453428f, -0.00557426f, -0.17606230f, -0.01899044f, -0.46493131f, 0.03066105f, 0.17979905f, 0.00992482f, 
    0.06399722f, 0.08738776f, 0.32426500f, 0.06942518f, 0.07736680f, 0.06102877f, 0.18447250f, 0.05354970f, 
    -0.68949676f, -0.54642564f, -0.37628853f, -0.40803257f, 0.00146481f, -0.11239999f, -0.11065647f, -0.12226892f, 
    -0.04616591f, 0.00578911f, -0.10216470f, 0.01699112f, -0.07321418f, 0.05441364f, 0.30430067f, 0.28475219f, 
    -0.04584492f, 0.10847431f, 0.08691081f, 0.01829806f, 0.01269235f, 0.06601378f, 0.14673533f, 0.10640264f, 
    -0.07906850f, 0.18565112f, -0.15509124f, -0.04571098f, -0.04806421f, -0.09870423f, -0.01932179f, -0.22550189f, 
    0.02797661f, -0.10185449f, -0.20234133f, 0.04078059f, 0.10276458f, -0.31304458f, -0.20173009f, -0.06057202f, 
    -0.17636915f, 0.09238669f, 0.06469596f, 0.03191180f, 0.12331223f, 0.17266533f, 0.22920883f, 0.07205784f, 
    0.03306817f, -0.03020515f, 0.11210310f, -0.19187421f, 0.03609380f, 0.05356847f, -0.06176045f, 0.04498575f, 
    0.04512661f, -0.01652705f, -0.07438607f, 0.06456577f, 0.22297522f, 0.50938570f, 0.07830147f, 0.24658827f, 
    -0.11787670f, 0.15137289f, -0.02601378f, -0.11657477f, 0.05676533f, -0.01286749f, 0.07883427f, 0.03157793f, 
    -0.07185409f, 0.17495562f, -0.15236519f, -0.02339225f, -0.01752753f, -0.10634147f, 0.05199721f, -0.00296589f, 
    -0.04113935f, 0.04954654f, -0.07692389f, 0.06959184f, 0.00978484f, -0.21928123f, 0.09921139f, 0.12117539f, 
    0.04336913f, 0.05673484f, -0.03085693f, 0.11654149f, -0.08644515f, 0.02530430f, -0.02469356f, -0.21776418f, 
    -0.11026764f, -0.08822837f, 0.50485665f, -0.03373887f, 0.02932266f, -0.01236547f, 0.18661527f, 0.06276079f, 
    0.04638993f, 0.12067705f, 0.03064979f, 0.05206157f, 0.36877492f, 0.19429661f, 0.11216386f, 0.25061354f, 
    -0.11672124f, 0.09619558f, 0.12627266f, 0.17472911f, 0.07233813f, 0.06430901f, -0.01533081f, -0.05031821f, 
    -0.10967722f, 0.01301588f, -0.04574955f, 0.04587892f, -0.13752240f, 0.01279131f, -0.00726245f, 0.22226639f, 
    0.03954639f, 0.07531646f, 0.01327148f, -0.06748632f, 0.16951638f, -0.03751284f, 0.38475171f, -0.16390988f, 
    -0.11940350f, -0.04031319f, -0.01268523f, -0.05860928f, -0.07864426f, -0.03236527f, 0.03523958f, -0.01983681f, 
    0.09134787f, 0.23894489f, -0.15314588f, 0.07708406f, -0.06234359f, -0.14728972f, -0.06499211f, 0.01411285f, 
    0.20749496f, -0.09699966f, 0.01212691f, -0.14755055f, -0.37463734f, -0.10725556f, -0.05141640f, 0.17227480f, 
    -0.08709913f, 0.05623415f, 0.05343612f, -0.09597597f, -0.13277407f, 0.05406547f, -0.08723072f, 0.03877614f, 
    -0.08930894f, 0.25003627f, 0.23898126f, -0.15341234f, 0.02864645f, -0.13474941f, -0.02093090f, 0.01576841f, 
    0.06669793f, -0.00350993f, 0.05746639f, 0.10272849f, -0.02661853f, -0.36426300f, 0.07603448f, -0.08213480f, 
    -0.11414030f, 0.13780381f, 0.05102609f, 0.12887311f, 0.03103196f, 0.00403357f, -0.05379316f, 0.06984912f, 
    0.15353933f, 0.22734486f, 0.06499692f, -0.16407098f, -0.13598791f, -0.07817698f, -0.15899453f, -0.10988639f, 
    -0.11633249f, -0.02624951f, 0.10550213f, -0.04718314f, -0.16238526f, 0.01812203f, -0.18382379f, 0.20132570f, 
    -0.08322173f, -0.06343099f, -0.13344368f, 0.01893953f, -0.16117436f, -0.12265364f, -0.08133824f, -0.09342232f, 
    -0.03913591f, 0.04528929f, 0.05640539f, 0.06989770f, -0.11994907f, 0.06839918f, 0.00267982f, -0.02368634f, 
    0.02425525f, 0.06183629f, 0.03996277f, 0.09019970f, 0.01718901f, -0.09474406f, 0.05534288f, 0.08460594f, 
    -0.10372746f, 0.09148785f, 0.03199551f, 0.04052035f, -0.04896722f, -0.09673923f, 0.19298810f, -0.05330419f, 
    -0.13820285f, 0.07626410f, 0.31117189f, -0.04424429f, 0.09955683f, 0.10434861f, 0.07281729f, 0.17579618f, 
    -0.09511364f, -0.13678733f, -0.09840558f, -0.05369576f, 0.07652650f, 0.24244815f, -0.11076223f, 0.19632153f, 
    -0.19715889f, 0.05246810f, 0.01016178f, -0.22178984f, 0.08644143f, -0.00434368f, -0.01690170f, -0.04800786f, 
    -0.15579462f, -0.08510309f, -0.12667446f, 0.03021432f, -0.00151648f, -0.08380523f, -0.00775420f, -0.07430030f, 
    -0.20032631f, 0.02677520f, 0.02672965f, 0.00462821f, 0.35844401f, 0.13839063f, 0.15737222f, 0.24451697f, 
    -0.04983985f, 0.09094480f, -0.07367553f, 0.10739288f, 0.14428742f, 0.26019838f, 0.24558178f, 0.19066641f, 
    0.37770239f, -0.03624927f, 0.37579140f, 0.09371355f, -0.00673373f, 0.02390835f, 0.01776298f, 0.00188941f, 
    0.10210121f, -0.12903313f, 0.04092263f, -0.12188659f, 0.46139798f, 0.20145319f, 0.16797765f, 0.06269462f, 
    0.00404741f, -0.12653320f, -0.09097129f, 0.02378351f, -0.21498771f, -0.17367472f, -0.09944358f, -0.05693679f, 
    0.23002797f, 0.30554640f, 0.06527197f, 0.24930920f, 0.01015698f, 0.09303997f, -0.14584503f, 0.02791520f, 
    -0.08734086f, -0.03908733f, -0.13326557f, -0.03340807f, -0.51896590f, -0.56779176f, -0.04532883f, 0.00532778f, 
    -0.00783243f, 0.15962581f, 0.16188015f, 0.17464387f, -0.07697496f, -0.13552886f, -0.00019106f, -0.13321085f, 
    0.23921531f, -0.10126533f, 0.10544267f, 0.25441924f, -0.02216198f, 0.09269384f, -0.01796818f, -0.15621968f, 
    0.09312035f, 0.19847997f, 0.09637947f, 0.12485424f, -0.17745952f, 0.27685273f, 0.11466873f, -0.05963544f, 
    -0.14589714f, -0.00017232f, -0.11710305f, 0.04016899f, 0.04653217f, 0.01988643f, -0.12125813f, -0.04198937f, 
    -0.99243945f, -0.35428980f, -0.01432901f, -0.40021053f, 0.05776112f, -0.00560028f, -0.09322321f, -0.05784917f, 
    0.00300112f, -0.01283319f, 0.04999204f, 0.11333200f, 0.04341055f, -0.26347092f, 0.09914838f, 0.06215960f, 
    0.03251974f, 0.17262362f, 0.08535051f, -0.01131056f, -0.23575842f, 0.00859331f, -0.03418225f, -0.07168118f, 
    -0.48114693f, -0.47753534f, -0.31126240f, 0.00654422f, 0.15672812f, -0.08162905f, 0.04339879f, 0.06950419f, 
    0.09229133f, 0.05887305f, 0.11308368f, 0.17977984f, 0.09263455f, 0.24971724f, 0.09675580f, 0.09096680f, 
    -0.14836533f, -0.00304948f, 0.02242794f, 0.19267261f, -0.01531009f, -0.13995016f, 0.04763115f, 0.01816396f, 
    0.00779572f, 0.02352542f, -0.03607773f, 0.03428677f, -0.07440148f, 0.00474766f, -0.05588452f, -0.02901802f, 
    0.02703582f, -0.04219096f, 0.03329707f, -0.04301303f, 0.02908473f, 0.03327891f, 0.03642386f, -0.00435655f, 
    -0.06256028f, 0.05760442f, -0.07454477f, -0.02073314f, -0.04489480f, -0.05765729f, -0.04284450f, -0.02144117f, 
    -0.01146848f, 0.00139742f, -0.02318931f, -0.03516235f, -0.07429817f, 0.01076792f, -0.00081064f, 0.03803432f, 
    -0.05893556f, -0.07414858f, 0.05395045f, -0.01567522f, 0.03094419f, -0.07788339f, -0.03931599f, -0.04366672f, 
    0.06038375f, -0.05710225f, -0.05544913f, 0.06127797f, 0.05015562f, 0.00011955f, -0.07617036f, -0.07278760f, 
    0.00049409f, 0.05466830f, -0.06595193f, -0.07427441f, -0.04598185f, -0.06325141f, 0.03642710f, -0.07614727f, 
    0.00025879f, -0.02691871f, 0.03588764f, -0.00297030f, 0.05560113f, -0.01397126f, -0.01727698f, -0.01486783f, 
    0.05216718f, 0.04112326f, -0.04876813f, -0.06780865f, -0.01272788f, -0.00835411f, 0.04068316f, -0.02945237f, 
    -0.00753877f, 0.01267712f, 0.03225097f, 0.04214853f, 0.02646157f, -0.06667368f, 0.05126651f, -0.05993172f, 
    0.02379026f, -0.07091486f, -0.05783276f, 0.03644495f, -0.06656844f, -0.03245164f, -0.06994974f, -0.03965776f, 
    -0.02117949f, -0.03818692f, -0.05535962f, -0.06708278f, -0.04672089f, 0.04839708f, -0.04579283f, 0.03579026f, 
    0.00285451f, 0.00841662f, -0.02443649f, -0.06169403f, 0.03281796f, 0.03626037f, 0.05087012f, -0.05881274f, 
    -0.05884437f, -0.07381575f, -0.04362790f, -0.02917224f, 0.01879937f, 0.05239527f, 0.04936400f, 0.03472726f, 
    -0.07406001f, 0.00529864f, 0.01240437f, 0.05617549f, 0.03745135f, 0.05455507f, -0.05959084f, 0.05553279f, 
    -0.03591194f, -0.03447340f, 0.02721983f, 0.03996490f, -0.02822707f, -0.03095526f, 0.03347753f, -0.00553973f, 
    -0.01140788f, 0.01811520f, -0.01801383f, 0.03649218f, 0.02019544f, 0.01443731f, 0.05511393f, -0.04141719f, 
    -0.00044302f, -0.06087092f, -0.04589591f, -0.00305864f, -0.04865019f, -0.04600336f, -0.00686660f, 0.03923017f, 
    0.02384838f, -0.06086389f, -0.00454471f, -0.06525810f, -0.04007990f, 0.00120492f, 0.01192807f, 0.04514263f, 
    0.02437449f, -0.03726733f, -0.03904424f, -0.06691280f, 0.03472704f, 0.01067976f, -0.01930340f, 0.04459465f, 
    0.01629864f, 0.03520523f, -0.02766575f, -0.05733630f, 0.04350434f, -0.01422570f, -0.02559919f, -0.05039517f, 
    -0.07790057f, -0.03911369f, 0.02114647f, 0.00966955f, -0.06847768f, 0.06048369f, 0.03075876f, 0.03567630f, 
    -0.02507932f, 0.00257658f, -0.06595686f, 0.00832093f, -0.02768185f, -0.06257706f, -0.00406227f, -0.03654221f, 
    -0.06160050f, -0.08325653f, 0.02615678f, 0.01824496f, -0.06718936f, -0.03980658f, 0.02410364f, 0.05493875f, 
    0.24336226f, -0.04255956f, 0.01036592f, 0.12663996f, -0.01428567f, -0.15990125f, 0.07694986f, 0.02336857f, 
    0.18086736f, 0.13749501f, 0.06766851f, 0.27841797f, 0.02842952f, 0.01639535f, -0.10188730f, -0.04807912f, 
    0.17257293f, -0.22023289f, -0.02633996f, 0.15411703f, 0.00850177f, -0.05289676f, -0.11313064f, -0.16357978f, 
    -0.08890434f, 0.03810244f, -0.39521170f, 0.26622301f, 0.17849524f, -0.01832641f, -0.15337771f, -0.09501089f, 
    -0.08439891f, 0.07328252f, 0.17785327f, -0.05707934f, -0.08229705f, -0.38791218f, 0.12309555f, 0.00111129f, 
    -0.04490054f, 0.00026922f, 0.08567969f, 0.03181510f, 0.15790975f, 0.19829753f, -0.06139141f, 0.16605774f, 
    0.01101590f, 0.03459679f, 0.06788792f, -0.13300747f, 0.21073814f, 0.08365033f, 0.11610083f, 0.05003337f, 
    0.18235697f, -0.07305319f, -0.00986177f, -0.05976814f, -0.18753649f, 0.10846674f, 0.11881115f, -0.06420647f, 
    -0.10149472f, -0.10967493f, 0.14019230f, -0.14320204f, 0.10759924f, -0.01682485f, -0.02353976f, 0.03393514f, 
    -0.19590588f, -0.06094722f, -0.11411339f, 0.11358985f, -0.04273976f, 0.07368284f, 0.00879458f, 0.14644270f, 
    0.05928202f, 0.11828122f, 0.06135998f, 0.09304692f, -0.43101060f, 0.12795310f, 0.14181770f, 0.01394410f, 
    0.02885651f, 0.17600439f, 0.12324445f, -0.02629591f, 0.11315391f, 0.04433233f, 0.06054690f, 0.06629953f, 
    -0.13553631f, -0.09087177f, -0.07994630f, -0.10583304f, 0.04636818f, -0.10343806f, -0.00961427f, -0.11916191f, 
    -0.01597409f, 0.11666495f, 0.15543847f, 0.08023869f, 0.00449847f, -0.14094211f, 0.06640535f, -0.09201813f, 
    0.17438334f, 0.04664742f, -0.06333452f, 0.01896231f, -0.05098877f, 0.08502822f, -0.14620584f, -0.05890328f, 
    -0.18372965f, -0.37054569f, 0.34446660f, 0.12262931f, -0.03078970f, -0.15557724f, 0.11056127f, 0.31419009f, 
    0.00984556f, 0.15814868f, 0.26860091f, 0.07970335f, 0.10061092f, -0.14414422f, -0.12984818f, 0.15190679f, 
    0.27538610f, -0.01224903f, 0.07946490f, 0.18917847f, 0.09035486f, 0.03701156f, 0.05346148f, -0.12654498f, 
    0.44918555f, 0.31694645f, -0.01873480f, 0.19373628f, 0.12894857f, 0.01304573f, 0.14193620f, -0.04886428f, 
    0.09603367f, 0.07298964f, 0.08322982f, 0.15398887f, 0.08813580f, 0.34223709f, -0.09189120f, -0.04274903f, 
    0.11681060f, -0.16560109f, -0.00521111f, 0.08252631f, 0.21693973f, -0.13008483f, -0.04345756f, -0.10672382f, 
    0.01474078f, 0.14836937f, 0.08529565f, 0.08976641f, 0.11498182f, 0.00444910f, -0.01107724f, 0.00951787f, 
    0.01419638f, -0.04320081f, -0.11914159f, -0.08955229f, 0.02798963f, -0.30121538f, 0.04234500f, -0.04288282f, 
    0.07887212f, 0.09808742f, 0.07032064f, -0.02868670f, 0.00175873f, 0.07622064f, -0.05860410f, 0.07002357f, 
    0.05514798f, -0.18654655f, 0.06234607f, 0.15932728f, 0.00291301f, -0.04535985f, -0.00079494f, 0.14765932f, 
    0.03852754f, 0.10767785f, 0.23133610f, 0.10989077f, -0.48682645f, 0.42555279f, 0.29811174f, 0.12279420f, 
    0.06708194f, -0.11214280f, -0.21397418f, -0.04587228f, -0.07166185f, -0.13305472f, -0.06599937f, -0.20007525f, 
    -0.08338651f, 0.26797602f, -0.09757516f, 0.30965942f, -0.11294468f, -0.12986806f, -0.01599241f, -0.16549736f, 
    -0.11938123f, -0.03347851f, 0.02283713f, 0.00619985f, -0.24478814f, -0.45486844f, -0.06830679f, -0.45098907f, 
    -0.00454013f, 0.12974986f, 0.08584803f, 0.21776715f, 0.04094306f, 0.13411227f, -0.13357659f, -0.04278316f, 
    -0.03339723f, -0.44399348f, 0.08447862f, 0.21183001f, 0.14590174f, 0.22884955f, 0.07739646f, 0.03049919f, 
    -0.05289521f, -0.13122304f, 0.04888911f, -0.25142372f, 0.00969344f, 0.36334544f, 0.01580275f, 0.02753553f, 
    0.04293403f, 0.02679148f, 0.09751514f, 0.10291087f, 0.19335413f, 0.10771959f, 0.13311297f, 0.36780483f, 
    0.11703121f, 0.15753466f, -0.25025308f, 0.18811262f, 0.06543928f, 0.16927773f, 0.00484113f, -0.01519569f, 
    0.06376612f, -0.06319494f, -0.01235113f, -0.08532014f, 0.04408321f, -0.07317548f, -0.02759739f, -0.24807256f, 
    0.08764345f, -0.16695431f, -0.09414467f, 0.04666305f, 0.13681275f, -0.09736793f, -0.08045948f, 0.01521405f, 
    0.20244052f, 0.02648503f, 0.13065872f, 0.13325773f, 0.15646502f, 0.16213356f, 0.09637866f, -0.10440882f, 
    -0.04420330f, -0.01443059f, 0.12137344f, 0.24391706f, 0.03717169f, -0.09808018f, -0.32590935f, 0.19240932f, 
    0.06594754f, -0.04712738f, -0.04310144f, -0.00400082f, -0.02782254f, -0.05093578f, -0.29506123f, -0.03290947f, 
    -0.15311898f, -0.08154933f, 0.34167597f, 0.20046116f, 0.00588669f, 0.14988430f, -0.10859573f, 0.09864357f, 
    0.01796272f, 0.24503353f, 0.07631478f, 0.14721960f, 0.17683558f, 0.13762926f, 0.28405347f, -0.15574530f, 
    0.07216977f, 0.05633695f, 0.07571033f, 0.13345736f, 0.13039516f, 0.05487793f, -0.00326839f, -0.08497028f, 
    0.36377248f, -0.23692225f, -0.35097143f, -0.01788581f, -0.02381695f, -0.07517036f, 0.15497395f, -0.01604279f, 
    -0.05631014f, 0.10980408f, 0.07220411f, 0.08997174f, 0.39314306f, 0.35585141f, -0.09153581f, -0.06820597f, 
    0.04241978f, -0.12166598f, 0.09752928f, 0.06894527f, -0.06551055f, -0.08169327f, -0.11376330f, -0.30748102f, 
    -0.06994299f, -0.36829731f, -0.14453679f, 0.17572163f, 0.28117415f, 0.25661609f, 0.15564330f, 0.02030543f, 
    0.17996529f, -0.09135709f, -0.05930821f, 0.05408145f, 0.34865099f, 0.08207709f, 0.46306360f, -0.01124176f, 
    -0.01379587f, 0.09669351f, 0.13617019f, -0.00221454f, 0.06089297f, -0.00942601f, -0.07006377f, -0.11172798f, 
    0.26103809f, -0.11174661f, 0.06926605f, 0.04886317f, 0.03932046f, -0.09168718f, -0.07160871f, -0.04048211f, 
    0.03142232f, 0.00161678f, 0.04331898f, 0.07777432f, 0.24472344f, 0.11813933f, -0.17112011f, 0.08570652f, 
    0.19779932f, -0.19426261f, 0.13400991f, -0.15281330f, -0.20257454f, 0.15972430f, 0.09225082f, 0.05771087f, 
    -0.00152813f, 0.10492685f, -0.23509268f, 0.21622892f, 0.00860994f, 0.07455051f, -0.06753645f, -0.03679536f, 
    0.00894723f, 0.14641623f, -0.08271438f, -0.06850710f, 0.68178117f, -0.43201509f, -0.06100464f, 0.00825105f, 
    -0.04402707f, 0.05225071f, 0.31958082f, -0.31107703f, -0.00300121f, 0.03050910f, 0.01508540f, 0.16828808f, 
    0.11398892f, -0.16497451f, 0.01206228f, -0.22512391f, 0.04892116f, 0.05300235f, 0.15675476f, 0.11247922f, 
    0.17939566f, -0.07328069f, 0.05106813f, -0.04532509f, -0.04444232f, -0.04404847f, 0.27904570f, -0.12712017f, 
    -0.03006366f, -0.00021821f, 0.08084998f, -0.10596750f, 0.02346819f, -0.12445807f, -0.02266496f, -0.07329054f, 
    -0.06560916f, 0.00449396f, 0.21388802f, -0.10340725f, 0.14984506f, 0.03420818f, 0.09890726f, 0.04541547f, 
    0.15274753f, -0.02218936f, -0.07552698f, 0.10365862f, 0.06633587f, 0.11739482f, 0.06728990f, -0.28567034f, 
    0.04934230f, -0.09104001f, 0.07709050f, 0.15386008f, -0.06413574f, 0.07165416f, -0.00344876f, 0.11797109f, 
    -0.16252679f, 0.06900816f, 0.03720853f, -0.14178680f, 0.11288288f, 0.03514262f, -0.00834229f, -0.04457351f, 
    0.07489949f, -0.00769022f, -0.08571767f, 0.01514428f, -0.08299744f, -0.12868866f, -0.08904593f, 0.04089216f, 
    0.00426261f, -0.00631149f, -0.09545565f, -0.08740924f, 0.04334100f, -0.07981393f, -0.06629991f, -0.03533588f, 
    0.37518641f, -0.34108204f, 0.34611094f, 0.00473236f, 0.04469750f, -0.28206584f, 0.01217958f, 0.05430064f, 
    0.14023204f, -0.00291075f, -0.11410578f, 0.04829198f, -0.15664786f, 0.14037825f, -0.28016800f, 0.29739282f, 
    0.35484657f, -0.00301558f, -0.06397221f, 0.10597553f, 0.01128577f, -0.01004455f, 0.09074636f, 0.06126361f, 
    0.30880004f, 0.16163485f, -0.03141490f, -0.07581358f, 0.02338806f, 0.03632256f, -0.16474998f, -0.03644858f, 
    0.08126917f, 0.08837122f, 0.10887458f, -0.01156518f, -0.14618689f, 0.56749982f, -0.00413908f, 0.09456380f, 
    -0.01267985f, -0.03465986f, 0.04840621f, 0.08801251f, 0.14760198f, -0.07437076f, -0.07068914f, 0.16054338f, 
    -0.10006422f, -0.01281989f, 0.03356380f, 0.05606154f, 0.08028857f, -0.04649497f, 0.04848005f, -0.04687721f, 
    0.07320032f, -0.07047943f, 0.07611410f, -0.01927519f, 0.03962040f, -0.26479399f, -0.02029496f, 0.01424886f, 
    -0.07505646f, 0.04012996f, -0.02299114f, 0.00556280f, 0.10511477f, 0.01755407f, -0.11350868f, 0.01552560f, 
    -0.07284013f, -0.11806550f, 0.03612960f, 0.07243942f, -0.02113576f, -0.00692465f, -0.03212763f, 0.14605880f, 
    -0.01485002f, 0.00662470f, 0.12522115f, -0.00042838f, -0.58857751f, 0.19325396f, 0.14630349f, 0.10952039f, 
    0.19732961f, -0.07315533f, -0.10078243f, 0.15803367f, 0.21129370f, 0.01447097f, -0.04373945f, -0.05674058f, 
    -0.37000516f, 0.09956995f, 0.00543923f, 0.22741228f, -0.13913806f, -0.19108607f, -0.12228232f, -0.18994646f, 
    0.12354052f, 0.13871928f, 0.07003050f, -0.06364964f, -0.19052424f, -0.28655338f, 0.09203345f, -0.04823148f, 
    0.13689989f, 0.17383052f, -0.17981887f, 0.30650556f, 0.02546489f, -0.02217272f, -0.03932736f, 0.14313252f, 
    0.06850997f, -0.24239115f, -0.10896777f, 0.19852687f, 0.15671103f, 0.29790550f, 0.09988751f, -0.06035773f, 
    0.06696595f, 0.00384362f, 0.09192119f, -0.04404630f, -0.24625029f, 0.27675354f, 0.00208048f, -0.21066366f, 
    -0.02275978f, -0.26183048f, -0.00817513f, -0.14566661f, 0.09133745f, 0.01581019f, 0.05877153f, 0.01047368f, 
    -0.25298378f, 0.18438934f, -0.00444072f, 0.30575386f, 0.00039286f, 0.06964567f, -0.06876860f, 0.14667815f, 
    -0.01223648f, -0.00716565f, 0.07008281f, 0.04272887f, 0.30671364f, -0.49777168f, -0.08841176f, -0.25942290f, 
    0.07419697f, -0.01057748f, -0.03085997f, 0.16842470f, 0.05019635f, 0.00023000f, 0.12559177f, 0.04387524f, 
    -0.08118174f, -0.08897336f, 0.18640454f, 0.00524824f, 0.01688225f, -0.01633807f, 0.04478999f, 0.11304735f, 
    0.10282064f, -0.02116924f, 0.17688867f, 0.07948349f, 0.18725194f, 0.11200105f, -0.13078645f, -0.14901264f, 
    0.00917690f, -0.00286407f, 0.11477982f, -0.13216533f, 0.16314542f, 0.04808209f, -0.27814931f, 0.10191911f, 
    -0.64166158f, -0.08428507f, 0.28798240f, 0.10084251f, -0.18912524f, 0.05742314f, -0.23502548f, -0.06402589f, 
    0.04946470f, -0.08922620f, -0.10211024f, 0.06316286f, 0.03070724f, 0.02872134f, 0.12696928f, 0.08677109f, 
    0.06360074f, 0.10637580f, 0.07796815f, 0.09131635f, -0.05965372f, 0.08863424f, 0.09891068f, -0.18758796f, 
    1.01120651f, -0.06137672f, -0.27557915f, 0.04302374f, 0.04663964f, -0.04889956f, 0.14524457f, 0.22329304f, 
    -0.03910775f, 0.06138445f, 0.21695225f, -0.09979729f, 0.48846585f, 0.07923765f, 0.00252476f, -0.11885798f, 
    -0.05581454f, 0.02233355f, 0.11957961f, 0.16620249f, 0.00836257f, 0.06603441f, 0.05195131f, -0.04394566f, 
    0.23997746f, -0.17390148f, -0.07937630f, -0.06959377f, 0.03581192f, 0.14865752f, 0.06455580f, -0.00948023f, 
    0.11262699f, -0.02672506f, -0.08056542f, -0.13228276f, 0.00913575f, 0.00608702f, 0.29437652f, 0.26503873f, 
    -0.01692795f, 0.11018202f, 0.01042938f, -0.03063180f, -0.00320337f, 0.05879534f, -0.07117628f, -0.01528290f, 
    -0.14399894f, -0.06239902f, 0.02993236f, -0.15005243f, -0.03957246f, -0.04629318f, 0.08552514f, -0.03509295f, 
    -0.20128153f, -0.12583059f, -0.05620303f, -0.01546266f, -0.02976794f, 0.17554931f, -0.00315414f, -0.02701803f, 
    0.00361364f, 0.06893986f, 0.11964143f, -0.11818942f, -0.14394192f, 0.01455967f, -0.21114539f, 0.24375361f, 
    0.07167798f, 0.05087424f, 0.27855703f, -0.11704583f, -0.03064458f, 0.03303982f, -0.01613335f, -0.03103570f, 
    -0.10493443f, 0.00299862f, 0.20384277f, 0.21975698f, 0.25307748f, -0.21679127f, 0.08885925f, 0.05190478f, 
    -0.13795678f, 0.09139709f, -0.06647645f, 0.05941448f, -0.00094127f, -0.05671541f, 0.09170651f, -0.17820276f, 
    0.05093808f, -0.12492331f, 0.03108201f, -0.03904349f, -0.01988999f, -0.18844230f, -0.04552593f, -0.06059837f, 
    0.03284660f, 0.04367444f, -0.02370414f, -0.01163747f, 0.20858808f, -0.01758026f, -0.19722168f, 0.08840201f, 
    0.12887725f, 0.07670663f, -0.00780038f, -0.05801049f, 0.10388126f, -0.10727669f, -0.25512263f, -0.30336142f, 
    0.31718773f, 0.27151781f, -0.20154177f, 0.05514433f, 0.06723408f, 0.07428446f, 0.12412776f, 0.07117857f, 
    -0.01670566f, 0.10823476f, 0.02415351f, 0.05389876f, -0.13857743f, -0.15811220f, -0.52579927f, 0.15788338f, 
    0.14726251f, 0.05072639f, 0.12116852f, 0.19548270f, 0.23219946f, -0.07714011f, 0.22027825f, -0.14405343f, 
    0.25230917f, 0.22343752f, 0.01361556f, 0.06039823f, 0.07687241f, 0.26920947f, 0.15572621f, 0.10057483f, 
    0.08185586f, -0.16761895f, 0.05154669f, 0.13682781f, 0.00667389f, 0.10250824f, -0.13876759f, 0.38316482f, 
    0.04550117f, -0.09460603f, -0.02123971f, -0.03549580f, 0.07137097f, 0.08390822f, 0.09266906f, 0.14913008f, 
    0.30237427f, 0.38252431f, 0.01581392f, -0.51671815f, -0.05973356f, -0.08465236f, 0.10089497f, -0.10424960f, 
    -0.23256911f, -0.07067224f, -0.27509123f, -0.08560374f, 0.28189230f, 0.24452494f, 0.45451614f, 0.18471110f, 
    0.10685834f, 0.17925617f, 0.02275350f, 0.31316450f, -0.11141653f, -0.06003361f, -0.05397614f, 0.03096882f, 
    -0.32078564f, -0.31454900f, 0.06339635f, -0.08353284f, 0.09513553f, 0.06306735f, -0.13079000f, 0.00794543f, 
    -0.12521864f, 0.22953893f, 0.11494122f, 0.03010310f, -0.05600047f, -0.01655841f, 0.04645576f, 0.12662415f, 
    0.10327505f, 0.27029881f, 0.13838831f, -0.03604410f, -0.07152804f, 0.14739446f, 0.04317838f, -0.07347323f, 
    -0.03786777f, -0.10994883f, 0.04405240f, -0.00958860f, -0.05069397f, -0.02667642f, 0.00176396f, -0.02744384f, 
    0.06639226f, 0.12618044f, 0.01292977f, 0.07289832f, 0.25300992f, 0.51935244f, 0.36219946f, -0.03183500f, 
    0.14289689f, 0.22196127f, 0.21034956f, 0.00361690f, 0.00667525f, 0.00553485f, 0.10448132f, -0.01835669f, 
    -0.01940092f, 0.06374498f, -0.04368769f, 0.00570030f, 0.04974661f, -0.02138184f, 0.02983701f, -0.06522517f, 
    -0.02875423f, 0.00024020f, -0.06980133f, -0.00506074f, 0.06226599f, 0.07442360f, -0.03519927f, -0.04238696f, 
    -0.06199907f, -0.03624523f, -0.01568587f, 0.01777331f, 0.02339785f, 0.00044177f, -0.02587595f, 0.05952253f, 
    -0.05553633f, -0.00578315f, -0.07145713f, 0.04286551f, 0.07040913f, 0.03550902f, -0.05956808f, -0.00763958f, 
    -0.04122297f, 0.02552587f, -0.06080961f, -0.06351263f, 0.05690854f, -0.01461375f, -0.07100449f, -0.06559056f, 
    -0.01292102f, 0.01362193f, 0.03110601f, 0.01480113f, 0.00696890f, -0.05950319f, 0.05027897f, 0.03086549f, 
    0.03622279f, -0.03987590f, 0.06306660f, 0.00425003f, 0.00238739f, 0.00983000f, 0.03153999f, 0.03737694f, 
    -0.08095048f, -0.07886471f, -0.06689246f, -0.06893001f, -0.02534145f, -0.03040460f, -0.03595476f, -0.00134420f, 
    -0.03108685f, 0.07643618f, 0.01556903f, 0.06715719f, 0.01852106f, 0.01035390f, 0.03278295f, 0.02066637f, 
    -0.02620057f, 0.04220931f, -0.00245565f, 0.04231485f, 0.00967340f, -0.07404609f, -0.02540899f, 0.01686304f, 
    0.05812147f, -0.01748904f, 0.04729016f, -0.05384452f, 0.04190947f, 0.01695830f, 0.05768311f, -0.00669223f, 
    -0.05110876f, -0.03706566f, -0.03505956f, 0.06957845f, -0.06341643f, -0.03384423f, -0.08517776f, -0.02933144f, 
    0.02614672f, 0.01685697f, 0.02227506f, 0.05053369f, 0.05444203f, -0.03080874f, 0.01367221f, -0.02070086f, 
    -0.01380353f, -0.06620369f, 0.03504650f, -0.07173885f, -0.00424955f, -0.00103194f, -0.06564620f, -0.04792947f, 
    -0.05566744f, -0.04147955f, -0.06708678f, 0.02745814f, -0.05520035f, 0.01708209f, -0.06919998f, 0.01082029f, 
    -0.07092191f, -0.03576497f, 0.06790742f, 0.06759504f, -0.02751119f, 0.00039149f, -0.03051595f, 0.00088331f, 
    -0.02097145f, -0.04310955f, -0.07170254f, -0.02612762f, 0.05355795f, -0.04143910f, -0.07720659f, 0.04528934f, 
    -0.03112932f, 0.03728266f, -0.01897450f, 0.03687505f, 0.04212362f, 0.04112795f, -0.04669702f, -0.04008349f, 
    0.04530657f, -0.03102325f, -0.03087260f, -0.04376169f, 0.00561058f, -0.03801190f, -0.04396442f, 0.02427562f, 
    -0.05808691f, -0.08322192f, 0.01292437f, -0.04325283f, 0.05234219f, -0.00705330f, -0.02525515f, 0.01235479f, 
    -0.05445590f, -0.04385381f, -0.02764845f, -0.08015633f, 0.01037484f, -0.05581771f, -0.07476176f, -0.05806325f, 
    0.04571193f, 0.03694251f, -0.02419035f, 0.00578326f, -0.07268336f, -0.00395023f, 0.02649903f, -0.07543209f, 
    0.01099669f, -0.01217031f, 0.01268504f, -0.00562869f, -0.00003352f, -0.00177580f, 0.01719228f, -0.06993280f, 
    0.00597232f, -0.01720115f, 0.06525932f, -0.07247598f, -0.01934687f, -0.05722938f, -0.06900387f, -0.02212397f, 
    0.03113457f, 0.02793921f, 0.14855324f, 0.08798317f, 0.01781184f, 0.02914034f, -0.04659897f, -0.05631000f, 
    0.02246881f, 0.05315316f, 0.07861639f, 0.03117249f, -0.14491194f, -0.00407662f, 0.09323444f, 0.00659392f, 
    -0.14320023f, 0.05714399f, -0.06896494f, -0.22294740f, -0.03425758f, 0.03499337f, -0.11222554f, 0.09265792f, 
    0.06656264f, 0.18921228f, 0.34838676f, 0.06254631f, -0.07735118f, 0.01451889f, 0.02718048f, -0.08302646f, 
    0.15627494f, 0.00710988f, -0.10126802f, 0.12255034f, 0.26016736f, 0.01123898f, -0.04985128f, -0.00856405f, 
    0.19739695f, -0.06138373f, 0.01204025f, 0.04020214f, 0.02233615f, 0.00634834f, -0.08236441f, 0.01452958f, 
    0.06285579f, -0.09096416f, 0.02143659f, -0.00603918f, 0.08643461f, 0.07537127f, -0.02837006f, 0.04096448f, 
    -0.11205576f, -0.00980276f, -0.01674198f, 0.04182379f, -0.04386654f, -0.01856369f, -0.19028261f, -0.38767242f, 
    0.10788482f, 0.12202121f, 0.05023931f, 0.17877473f, 0.12515694f, -0.01489288f, 0.06080319f, -0.09728491f, 
    -0.13792156f, -0.09178440f, -0.65204370f, -0.24724184f, 0.11961914f, -0.05370076f, 0.06902470f, -0.17478856f, 
    0.01186997f, -0.07973583f, 0.08110196f, 0.04774845f, 0.34042612f, -0.24060003f, -0.06047537f, -0.55870742f, 
    0.00710060f, -0.13235787f, -0.07428697f, 0.07160141f, 0.15626127f, 0.23361947f, -0.04113802f, -0.01971621f, 
    -0.30601066f, -0.06362841f, -0.34442613f, -0.31210199f, 0.08566813f, 0.02014824f, -0.01867074f, 0.17971435f, 
    0.09444013f, 0.01980731f, -0.02587038f, -0.00380228f, 0.47375211f, 0.25139850f, 0.20211874f, 0.25370455f, 
    -0.16557217f, -0.08023656f, -0.01161398f, -0.07163151f, -0.06623159f, -0.12581076f, -0.02199058f, -0.00782450f, 
    -0.06320730f, 0.04955099f, 0.10228607f, 0.05663141f, -0.08018909f, 0.22509573f, -0.13551129f, -0.02540074f, 
    0.04906026f, 0.00156994f, -0.09335996f, 0.06594962f, -0.10906328f, -0.03665062f, -0.07477953f, -0.37523904f, 
    0.07512514f, -0.15524745f, -0.02247262f, -0.03110807f, -0.09889887f, -0.04431176f, 0.03612285f, -0.08643094f, 
    0.26065901f, 0.16390406f, 0.14645174f, 0.14904454f, -0.04968213f, 0.09237058f, 0.13579974f, 0.13635956f, 
    -0.01077713f, 0.15630917f, 0.18412770f, 0.01784970f, -0.14082076f, 0.03148972f, 0.00517129f, -0.02431892f, 
    -0.09338678f, -0.04176776f, 0.21091835f, 0.21751215f, -0.00938291f, -0.12580159f, -0.07930446f, -0.12033128f, 
    0.26642576f, 0.12274177f, 0.17922071f, 0.08017296f, 0.01391828f, 0.04993329f, 0.06855810f, -0.08826540f, 
    0.02143500f, -0.08097478f, -0.03038394f, 0.01911315f, -0.59393007f, -0.04632502f, -0.29195839f, -0.46417615f, 
    0.03872056f, 0.13795716f, 0.11255282f, 0.06287808f, -0.10019992f, 0.01744724f, -0.01582615f, -0.03409386f, 
    -0.03948987f, 0.02226887f, -0.05302118f, -0.08933175f, -0.00248730f, -0.03732178f, 0.00794013f, 0.05665101f, 
    0.12500350f, 0.00366047f, 0.08048847f, -0.06396095f, -0.12873165f, 0.21565616f, 0.04189302f, 0.03716034f, 
    0.00158220f, 0.10767954f, -0.08421054f, 0.14319843f, 0.16909350f, -0.11500154f, -0.30518562f, 0.05030499f, 
    -0.33594930f, -0.23603915f, 0.18690537f, 0.05839749f, -0.02796701f, -0.04067170f, 0.03206602f, -0.06936664f, 
    -0.10197240f, -0.09330224f, 0.34336567f, -0.08725577f, -0.09940957f, -0.60426754f, 0.24756993f, 0.00325396f, 
    0.00317325f, 0.07434855f, -0.21229523f, 0.27096954f, -0.19756654f, 0.07228531f, 0.01000213f, 0.04729202f, 
    -0.03876348f, -0.03421869f, 0.02561951f, 0.09605481f, -0.11870819f, -0.07139277f, -0.04089291f, -0.09528609f, 
    -0.13065830f, 0.06902561f, -0.08554553f, -0.06779543f, -0.02665328f, 0.10972808f, -0.19179158f, -0.03962066f, 
    0.04025376f, 0.02353121f, 0.01399258f, -0.11804957f, 0.04705363f, -0.00202156f, -0.05654305f, -0.02314731f, 
    0.08648089f, 0.16879946f, -0.32140118f, 0.31535077f, 0.15715696f, 0.10365506f, 0.05647049f, 0.02282934f, 
    0.02864668f, 0.11057092f, -0.05459608f, 0.14816794f, -0.13642196f, -0.65987855f, -0.30722439f, 0.05936883f, 
    0.03342620f, 0.06545795f, 0.01136395f, 0.08309453f, -0.07524078f, -0.03214276f, 0.10633639f, -0.15283667f, 
    0.21874134f, -0.09487968f, -0.07405481f, -0.16310650f, 0.14773808f, 0.09425326f, 0.00659346f, -0.09867258f, 
    0.06928406f, 0.02836331f, 0.15494639f, 0.12358882f, 0.06743939f, 0.11375853f, 0.16832253f, 0.08110889f, 
    0.02313142f, -0.02457212f, -0.06824014f, -0.00852807f, 0.03857454f, 0.00573141f, -0.07861751f, 0.15171321f, 
    -0.09505205f, 0.14116170f, -0.06730326f, 0.05096017f, -0.02938583f, 0.08760910f, 0.01012130f, -0.19744362f, 
    -0.00516703f, 0.03265961f, 0.05306575f, 0.08617427f, 0.25027263f, 0.23522274f, 0.58587080f, 0.01870389f, 
    0.01963114f, 0.10525759f, 0.04591012f, 0.17562699f, 0.07514708f, -0.02665779f, 0.07320428f, -0.03641282f, 
    0.05042917f, -0.14747930f, 0.15050676f, 0.21144582f, 0.12571537f, 0.05577906f, 0.13819803f, 0.08789078f, 
    -0.11425563f, 0.10758378f, -0.00147470f, 0.06003760f, 0.14118060f, -0.25431809f, 0.09052830f, -0.02179101f, 
    0.10016795f, 0.07046780f, -0.01743151f, 0.15700120f, -0.16815615f, 0.01104503f, 0.08736417f, -0.06249799f, 
    0.16779880f, -0.01142025f, 0.08122613f, -0.06475171f, 0.00083082f, 0.08451781f, 0.03841647f, 0.04064946f, 
    0.01905278f, 0.01340575f, -0.11417437f, -0.09016437f, 0.39874187f, 0.38847825f, 0.49002504f, -0.10742250f, 
    0.04520716f, 0.03397365f, -0.02728425f, 0.06699842f, 0.06514970f, 0.04837685f, 0.03335776f, 0.07125150f, 
    0.06829114f, 0.13067560f, -0.04862156f, 0.01138435f, 0.05160365f, 0.01933328f, 0.05047370f, 0.01252694f, 
    0.09975462f, 0.18074048f, 0.17733458f, -0.01156492f, 0.26445103f, -0.23933788f, -0.11602499f, -0.01380264f, 
    0.13537319f, 0.02249434f, -0.11904105f, 0.00779755f, -0.01945462f, -0.06370322f, 0.09788740f, -0.12785201f, 
    0.56329000f, 0.05838422f, -0.15738849f, -0.11418848f, 0.12762672f, 0.12406215f, 0.03015369f, 0.03082232f, 
    -0.03351392f, 0.06041775f, -0.34045854f, -0.03462002f, -0.19247906f, 0.77611655f, -0.14860058f, -0.05685103f, 
    -0.08764274f, -0.00664384f, 0.10454969f, -0.10708468f, 0.03153367f, -0.05490215f, 0.04773811f, 0.01516802f, 
    -0.11869997f, 0.14769915f, 0.05582861f, -0.03597942f, 0.08938493f, 0.00171874f, 0.03962167f, 0.10026595f, 
    -0.09687196f, -0.13989361f, -0.06787987f, -0.01445286f, -0.07906382f, 0.03346859f, 0.20534536f, 0.25895879f, 
    -0.07242846f, -0.11197684f, 0.11879253f, 0.04867293f, 0.08604261f, 0.25706241f, 0.14082444f, 0.51834273f, 
    -0.14639306f, -0.11303452f, 0.14828628f, -0.07171827f, -0.00375147f, -0.12072115f, -0.08134784f, -0.00608547f, 
    -0.19058266f, 0.00619157f, 0.02067812f, -0.06961463f, -0.27682137f, 0.53562939f, 0.18498795f, 0.26610166f, 
    -0.10207865f, -0.11943324f, 0.05750816f, -0.13678840f, -0.11439127f, -0.09947938f, -0.10432678f, 0.20546931f, 
    -0.06454679f, -0.13571018f, 0.12186712f, 0.31830361f, 0.02560573f, -0.10711396f, 0.04414137f, 0.10529287f, 
    -0.18482216f, 0.10113091f, 0.04994504f, 0.02378993f, 0.05170550f, 0.01444894f, 0.26847789f, -0.12626123f, 
    0.08426455f, 0.05038632f, 0.11063920f, -0.05190538f, -0.05852293f, 0.02463983f, 0.02409506f, -0.16368540f, 
    0.13017926f, 0.07811763f, -0.22239962f, 0.14897607f, 0.17571257f, 0.07874739f, -0.14350778f, 0.19593714f, 
    -0.00655765f, 0.29218066f, 0.28892687f, 0.12293430f, 0.10065876f, -0.26058245f, -0.21701659f, -0.10061337f, 
    -0.20156279f, -0.18426521f, -0.04843010f, -0.04512072f, 0.10898397f, 0.07195107f, -0.07842951f, -0.04177531f, 
    -0.05455201f, 0.27457345f, 0.02791818f, -0.04929651f, -0.06005010f, -0.06103778f, -0.02653429f, -0.04034796f, 
    0.17780749f, 0.06190433f, 0.02132018f, 0.02941727f, -0.01337592f, 0.09630100f, 0.00094020f, 0.07950988f, 
    -0.04113249f, -0.09929787f, -0.00215886f, 0.08852186f, 0.27613842f, -0.13265719f, 0.03143573f, -0.12296569f, 
    0.11842559f, 0.05952421f, 0.00172089f, -0.04930412f, -0.02531722f, 0.05315189f, 0.00716543f, 0.01268624f, 
    0.05302668f, 0.01186762f, 0.06294418f, 0.06038409f, -0.08043276f, -0.29551122f, -0.20602234f, 0.12655845f, 
    -0.16729984f, -0.17158277f, -0.00780339f, 0.00021496f, -0.01179923f, -0.09476661f, -0.06920613f, -0.15311253f, 
    -0.07104733f, 0.01807591f, -0.14553088f, -0.16032620f, 0.03806559f, -0.08634696f, -0.25125930f, 0.21982509f, 
    0.01159967f, -0.03296630f, -0.00201541f, -0.00074422f, 0.06531889f, 0.39773726f, 0.06048024f, -0.09288316f, 
    -0.18495159f, 0.13564090f, 0.29011640f, 0.13837375f, 0.07863323f, 0.04487553f, -0.03896846f, 0.15522674f, 
    0.36889696f, 0.01795595f, 0.24222203f, 0.05264220f, -0.32282701f, -0.22918113f, -0.04461772f, -0.07580268f, 
    0.09274867f, -0.01662137f, 0.25110850f, 0.14516613f, -0.30700761f, 0.32474872f, 0.08699707f, 0.12394242f, 
    0.06374516f, 0.12889129f, -0.24309206f, 0.37123248f, 0.07615136f, 0.14701676f, 0.26736742f, -0.04405930f, 
    -0.24172303f, -0.09979519f, 0.15407583f, 0.02822095f, 0.00188751f, 0.19017737f, 0.06196684f, -0.02578324f, 
    0.04366205f, -0.00805173f, 0.22622094f, 0.13353254f, 0.08262081f, 0.16065864f, -0.02685367f, -0.17108203f, 
    -0.04944136f, -0.09271368f, -0.01734822f, 0.03358038f, -0.10650899f, -0.20461246f, -0.21182920f, -0.29827499f, 
    -0.15789409f, 0.16171442f, -0.11407666f, 0.00870287f, -0.13034198f, 0.29084352f, 0.12322415f, 0.17849594f, 
    -0.06758624f, 0.09150733f, 0.09910387f, 0.16618299f, -0.28796923f, 0.38942325f, -0.00191190f, 0.34034479f, 
    -0.19388050f, 0.03020254f, -0.01594441f, 0.29826838f, 0.19772993f, -0.01899909f, 0.13778463f, -0.10730678f, 
    -0.07645641f, -0.21066839f, -0.04549468f, -0.20434667f, -0.00942810f, 0.10631998f, 0.17195128f, -0.02909126f, 
    0.02250687f, -0.15743664f, 0.00866035f, -0.01991604f, -0.04154618f, 0.28283966f, -0.09353348f, -0.01669987f, 
    -0.03721737f, -0.13984284f, -0.02782994f, 0.08875092f, 0.13673675f, 0.09058721f, 0.02231332f, 0.28292251f, 
    -0.16037999f, 0.49605882f, -0.06307049f, -0.21507758f, 0.03742855f, -0.18545355f, 0.04064225f, 0.04371699f, 
    -0.11115229f, -0.08741596f, -0.10207387f, -0.19488864f, 0.21479309f, -0.33767596f, 0.13279468f, 0.11791394f, 
    0.14565966f, 0.33268079f, 0.21113016f, 0.23153509f, -0.03060893f, 0.09234408f, 0.03016445f, -0.01467079f, 
    0.33835968f, -0.00355885f, 0.10127527f, 0.04964961f, -0.08236419f, 0.14584439f, -0.05230322f, 0.01373802f, 
    -0.05125782f, 0.11823518f, -0.22713120f, -0.08468030f, -0.10753992f, -0.15881762f, -0.05917361f, -0.07809845f, 
    0.12205389f, 0.10987714f, -0.03834184f, -0.10667733f, -0.01939818f, 0.16108204f, 0.02506766f, 0.04789243f, 
    -0.33512184f, -0.07060613f, -0.05022495f, -0.07692804f, -0.30485818f, -0.18119352f, -0.21347973f, -0.20015439f, 
    -0.10993427f, -0.12421002f, -0.24091831f, -0.23753817f, -0.10933439f, 0.14320345f, 0.14577773f, 0.10192481f, 
    0.16589351f, 0.24515243f, 0.07933720f, -0.14010972f, 0.12455835f, 0.16867213f, -0.01230563f, 0.07919950f, 
    0.05784874f, 0.05571894f, -0.03616600f, 0.02131863f, 0.00683714f, 0.04096336f, 0.02243362f, -0.04658716f, 
    0.00373255f, -0.02529846f, -0.05699657f, 0.03549286f, -0.02006001f, -0.03100352f, -0.05927379f, -0.07606158f, 
    0.03878654f, -0.02976848f, 0.04297372f, 0.05822354f, -0.01270782f, -0.01023479f, -0.02334996f, 0.00790891f, 
    -0.06221941f, -0.05169471f, -0.02604425f, -0.05651627f, -0.02941318f, -0.08015396f, -0.07741396f, -0.01289112f, 
    -0.03404684f, -0.03814483f, -0.07804058f, 0.06860061f, -0.02012719f, -0.01536617f, 0.00348117f, -0.06604476f, 
    -0.02181527f, 0.04749389f, -0.08249032f, 0.00836359f, -0.00472343f, 0.05037349f, -0.06134612f, 0.01537130f, 
    -0.00175765f, -0.02527067f, -0.01455622f, 0.06438985f, -0.03081879f, -0.00206531f, -0.05976212f, -0.08222757f, 
    0.04674394f, 0.05311499f, -0.00543165f, -0.02634206f, 0.01252627f, -0.04475963f, -0.04692632f, -0.00920888f, 
    -0.06644320f, -0.01635009f, -0.05466450f, -0.07645022f, -0.07268204f, -0.01667026f, -0.05096884f, 0.05524680f, 
    0.00835953f, 0.05751249f, -0.04340939f, -0.05515236f, -0.04959140f, 0.05018720f, 0.03476569f, -0.03569942f, 
    -0.06097043f, 0.00386099f, -0.02492670f, -0.06032434f, 0.03004771f, -0.04245122f, 0.00407435f, 0.02319760f, 
    -0.05522440f, -0.03714395f, -0.03869648f, 0.00176234f, -0.00208721f, 0.05412056f, 0.05641788f, 0.02787914f, 
    0.00198641f, -0.08570833f, 0.02085365f, 0.01013025f, -0.03614850f, 0.04777107f, 0.05055147f, -0.04394331f, 
    -0.05919537f, -0.00219417f, -0.04767810f, -0.08226556f, 0.00668480f, -0.05440649f, 0.05464224f, 0.03092054f, 
    -0.06655436f, -0.04909468f, -0.02345590f, 0.05428839f, -0.04834320f, 0.05511446f, -0.06967631f, 0.03061629f, 
    -0.02562426f, 0.04870911f, -0.04043451f, -0.02456051f, 0.03279369f, 0.00350462f, -0.00407500f, 0.00063073f, 
    -0.05502987f, 0.02623615f, 0.03748731f, -0.02170800f, 0.05004793f, 0.01490223f, 0.04006011f, 0.04609775f, 
    0.02456471f, 0.06085925f, 0.05083124f, 0.01690302f, 0.05194486f, -0.07562946f, 0.03696033f, -0.03951625f, 
    -0.04803102f, 0.00438965f, -0.04617232f, -0.02793093f, -0.00814226f, 0.03682627f, -0.04419878f, -0.06430788f, 
    0.05160255f, 0.00413203f, 0.03762254f, 0.03058532f, -0.05229347f, 0.04692502f, -0.03991632f, 0.05738529f, 
    0.05092651f, -0.05334404f, 0.05580167f, -0.06810881f, -0.04229977f, 0.04800788f, -0.06003117f, 0.02752654f, 
    -0.04592052f, -0.01877126f, -0.00007429f, 0.02748473f, 0.02492336f, 0.00679998f, -0.05946787f, 0.03631603f, 
    -0.01686987f, -0.06914201f, -0.07016479f, -0.01516144f, -0.01839402f, -0.06154727f, -0.03195539f, 0.04598206f, 
    -0.02009672f, -0.05043529f, 0.01924995f, 0.03264840f, -0.00463070f, 0.04172676f, 0.05213814f, -0.03100847f, 
    -0.08815739f, -0.05980265f, 0.13150482f, 0.18594280f, -0.01200536f, 0.04194846f, -0.01301026f, 0.13931867f, 
    0.07862833f, -0.03369717f, -0.01780276f, 0.07304121f, -0.16965576f, -0.06552564f, 0.02476896f, 0.02666484f, 
    -0.08611947f, -0.07021883f, 0.29385263f, -0.00764736f, -0.01267918f, 0.12434857f, 0.08045810f, -0.10697725f, 
    -0.19388153f, -0.10177588f, -0.00211551f, 0.16017382f, -0.08247828f, -0.01389539f, 0.06274158f, 0.11344969f, 
    0.24921751f, 0.06070435f, 0.09435638f, 0.09318029f, 0.40300524f, 0.22208433f, -0.09918881f, 0.12088890f, 
    0.01904275f, -0.06103831f, 0.25340372f, -0.32593170f, 0.10592044f, -0.00578174f, -0.01845315f, 0.09035483f, 
    -0.03189945f, 0.03546897f, -0.14891633f, 0.00723931f, 0.05779137f, 0.08762950f, 0.05759518f, -0.04713022f, 
    0.08181297f, -0.02807331f, -0.00704782f, 0.19891682f, 0.23264730f, -0.05097118f, 0.05573042f, -0.12674993f, 
    0.07256404f, 0.15070960f, -0.15054391f, -0.06673910f, 0.11797881f, 0.12483834f, -0.01788864f, -0.11891963f, 
    0.16404629f, -0.10828326f, 0.43319735f, -0.31264377f, 0.09638434f, 0.00639185f, 0.11894292f, -0.01598271f, 
    -0.00026136f, -0.02687507f, -0.05652566f, -0.15061513f, 0.52832448f, 0.37170938f, -0.35071400f, -0.01699563f, 
    0.11644711f, -0.08463737f, -0.04367424f, -0.14763685f, 0.07986533f, 0.17506731f, -0.21909687f, -0.09421705f, 
    -0.06371590f, 0.36444002f, 0.16651224f, -0.04173873f, 0.06302653f, 0.20535833f, 0.12902491f, -0.10067524f, 
    -0.00729216f, -0.11114578f, -0.31316465f, -0.26525679f, 0.00453202f, -0.09174088f, -0.22001778f, -0.09338403f, 
    -0.12456703f, -0.03183335f, 0.07089052f, 0.00935358f, -0.00456051f, -0.05177951f, 0.06154202f, 0.06912327f, 
    0.30699697f, -0.08856131f, 0.11803815f, -0.03036959f, -0.04617413f, 0.03739333f, 0.25487101f, 0.12040819f, 
    0.26800567f, 0.15984879f, -0.06218622f, -0.00366206f, -0.29848871f, 0.09915636f, -0.30855626f, -0.21385451f, 
    0.06656146f, 0.17651306f, 0.00370082f, 0.14240199f, 0.07053046f, -0.01437556f, -0.08347642f, 0.13479008f, 
    -0.01002629f, -0.21951306f, -0.10638371f, -0.25116757f, -0.00517576f, -0.08540271f, -0.10653213f, 0.00854573f, 
    -0.05520982f, 0.06503369f, 0.14665188f, 0.06127531f, 0.35618195f, -0.12163112f, -0.21336217f, 0.06835510f, 
    -0.15760179f, -0.03431419f, -0.14440311f, -0.32188502f, -0.04722753f, 0.01786092f, -0.16089599f, 0.06728385f, 
    -0.11559442f, -0.02016257f, 0.00959598f, 0.09512080f, -0.14221317f, -0.00598656f, -0.05241370f, -0.00351975f, 
    -0.13262001f, -0.02843844f, 0.14289491f, 0.12414226f, -0.15559843f, 0.02476713f, -0.24268728f, 0.02874382f, 
    0.02860427f, 0.13242686f, 0.01494072f, -0.04555350f, -0.08581530f, 0.02827411f, -0.11090375f, -0.02400963f, 
    0.14387447f, 0.00096925f, 0.08044068f, -0.07670642f, 0.03458314f, -0.05482791f, 0.01288323f, -0.12172794f, 
    -0.06461671f, 0.01203035f, 0.02911261f, -0.08270967f, 0.27037889f, -0.06143779f, -0.04017646f, -0.16225374f, 
    0.04947303f, -0.11424034f, -0.15650162f, -0.21954641f, 0.01139439f, 0.01576478f, 0.01060046f, 0.20445065f, 
    0.51220751f, 0.07621436f, 0.06863577f, -0.06021094f, -0.10980692f, -0.03245498f, 0.08213243f, 0.06413150f, 
    0.05902897f, 0.02854760f, -0.15995026f, 0.19089341f, 0.37777326f, -0.13497488f, -0.02028023f, -0.08601154f, 
    0.10070007f, 0.23669909f, 0.05311799f, -0.08962309f, -0.09465837f, -0.06412549f, -0.09717866f, -0.00965072f, 
    0.18330112f, -0.09154655f, 0.16019663f, -0.11014581f, -0.13154370f, 0.06970276f, -0.10855309f, -0.02617340f, 
    -0.03828162f, 0.02517211f, 0.11326107f, 0.01014264f, -0.05402070f, -0.23783052f, -0.05627767f, 0.13528566f, 
    -0.00841485f, 0.16066504f, -0.06523352f, 0.08482466f, -0.09825315f, -0.09411184f, 0.04204346f, -0.00895383f, 
    0.16008319f, -0.11546896f, -0.32490247f, -0.42553100f, -0.01901200f, 0.20328552f, 0.21365562f, -0.11018100f, 
    -0.00746882f, -0.01508252f, -0.06087247f, 0.08873301f, 0.03996528f, -0.05240554f, 0.04500967f, -0.16566214f, 
    -0.08801705f, -0.08237027f, 0.07865237f, 0.26584154f, 0.06139795f, -0.15575802f, 0.25867459f, 0.08127326f, 
    0.04654182f, -0.14237413f, -0.31189412f, -0.06875124f, 0.11898270f, -0.12803720f, 0.10675935f, 0.14883085f, 
    -0.11343595f, -0.16114464f, -0.02117790f, 0.16419052f, 0.04321741f, 0.23071508f, 0.12897688f, 0.40659350f, 
    -0.04285427f, -0.06977760f, 0.00025238f, -0.03903458f, 0.07161204f, -0.00827689f, -0.02913562f, -0.04440114f, 
    0.61045510f, 0.00362555f, 0.21251059f, -0.07810463f, -0.05689690f, -0.05078941f, -0.14961788f, -0.12990358f, 
    0.13346112f, 0.04919770f, -0.21952836f, 0.04339748f, 0.05985359f, 0.24722555f, -0.12943263f, 0.02197191f, 
    0.05707539f, -0.13199401f, -0.14780048f, -0.31087193f, -0.04905419f, -0.07399108f, -0.12986638f, -0.05683956f, 
    -0.21053931f, 0.12824538f, 0.06998233f, -0.12830712f, -0.00961282f, -0.03425289f, -0.14591813f, -0.09416148f, 
    -0.01183770f, 0.07146223f, 0.06328721f, -0.10569568f, -0.28310788f, 0.36236888f, 0.03559574f, 0.11003256f, 
    0.20583591f, 0.00030414f, 0.21177109f, 0.14879376f, 0.07767542f, 0.18863006f, 0.14365475f, 0.08112510f, 
    0.00010667f, 0.18681388f, 0.17508949f, 0.03353777f, 0.04562985f, -0.00350502f, 0.02711703f, -0.04726825f, 
    0.18085867f, 0.09542570f, -0.02998447f, 0.11458553f, 0.33012146f, 0.01442807f, 0.02297127f, 0.02842052f, 
    -0.18017906f, -0.17376077f, -0.10047517f, 0.02354563f, 0.04588594f, -0.06044510f, 0.00297597f, 0.04806023f, 
    -0.31701520f, -0.02579092f, -0.05540455f, 0.14936307f, -0.00718490f, -0.05197680f, -0.01560352f, -0.10619897f, 
    0.10074382f, 0.06849226f, -0.11269483f, 0.16869003f, -0.17898770f, -0.13319942f, 0.09676098f, 0.10120244f, 
    0.06994757f, 0.11869527f, 0.09596848f, 0.00337406f, 0.01247544f, 0.03747855f, -0.02456115f, 0.19538675f, 
    -0.35938719f, -0.09594604f, 0.10937633f, -0.18795206f, 0.15941957f, -0.05978218f, -0.01969481f, -0.03463573f, 
    -0.12082905f, -0.17632237f, -0.24703427f, 0.13948047f, -0.04709055f, 0.26003394f, 0.22179356f, 0.26954004f, 
    0.08455658f, 0.10135800f, -0.07966559f, 0.12386271f, 0.01141922f, 0.06607004f, -0.02411196f, -0.05541123f, 
    -0.06138726f, 0.08447776f, -0.18955491f, 0.12554052f, 0.08135845f, -0.01057531f, -0.05207746f, 0.05971189f, 
    -0.08847549f, -0.01400110f, -0.06775126f, -0.00668994f, 0.16138239f, 0.20967524f, 0.10986234f, 0.40113819f, 
    0.07116584f, -0.05037380f, 0.05260795f, -0.02806162f, 0.19417569f, 0.10878469f, 0.03546689f, 0.24392428f, 
    0.40629673f, 0.35120338f, 0.12980099f, 0.37036818f, 0.17523600f, -0.10749841f, -0.11531918f, 0.16218224f, 
    0.02994475f, -0.07604676f, -0.01218648f, -0.07424864f, 0.18793100f, 0.08405270f, 0.13619307f, 0.08820907f, 
    0.10133585f, 0.03555329f, -0.15262073f, -0.02130321f, 0.12239669f, 0.13783045f, -0.03552359f, -0.04111253f, 
    0.18872340f, 0.43411627f, 0.20458457f, 0.16133389f, 0.05915720f, 0.09930659f, -0.08766477f, 0.18914965f, 
    -0.01913299f, -0.02109594f, -0.02568191f, 0.10734510f, 0.19953005f, -0.02718631f, 0.06776671f, -0.11353850f, 
    -0.05690157f, -0.00666117f, -0.02448303f, -0.05062874f, -0.00918316f, -0.08920365f, 0.04650188f, -0.09732855f, 
    -0.42493895f, 0.05575139f, 0.09375513f, 0.30189088f, 0.05507836f, 0.08690060f, 0.05858903f, -0.02559711f, 
    0.02995378f, -0.18988033f, 0.02981174f, 0.07912828f, 0.24811457f, 0.09393368f, 0.55882615f, 0.04345923f, 
    -0.08854651f, 0.10957214f, -0.10525722f, 0.19289531f, -0.02082850f, 0.06797658f, 0.01678304f, 0.02434289f, 
    -0.32679862f, -0.11443150f, -0.10995046f, 0.13592838f, -0.12995690f, -0.09282736f, -0.08913423f, -0.00798071f, 
    0.02891621f, 0.05153362f, 0.00427206f, 0.16468960f, 0.20145905f, -0.32066339f, 0.17618275f, -0.08156336f, 
    0.12568256f, 0.20779935f, -0.08285594f, 0.05590278f, -0.04009315f, 0.10187821f, -0.01128882f, -0.04132881f, 
    0.09705902f, -0.27793083f, -0.11731241f, -0.07705874f, -0.10841540f, -0.06280829f, 0.06999841f, 0.07126535f, 
    0.06289098f, 0.10663573f, 0.00336473f, -0.07923324f, -0.01140749f, 0.34474203f, 0.33441374f, -0.02189153f, 
    0.03964640f, 0.08478100f, 0.22179766f, 0.06479304f, -0.11729760f, 0.01984321f, -0.08050291f, 0.01200291f, 
    0.08447132f, 0.19865456f, 0.08892036f, 0.09702009f, 0.00815700f, 0.00577305f, -0.04763963f, -0.06178366f, 
    0.12587535f, -0.01922657f, 0.06415216f, -0.05937798f, -0.33187550f, 0.01241454f, 0.16906837f, 0.11505608f, 
    -0.10647573f, -0.04183822f, 0.11788517f, 0.01065668f, 0.23885515f, 0.17799027f, 0.19447136f, -0.00990873f, 
    -0.26187161f, 0.10582563f, 0.27764189f, 0.34365445f, -0.22166264f, -0.14667565f, -0.11618536f, -0.07009748f, 
    0.17973074f, 0.07033686f, 0.22272238f, 0.00118448f, 0.12855159f, -0.05636118f, 0.00674950f, 0.13987786f, 
    0.11309179f, 0.02274032f, -0.15229639f, 0.12030169f, 0.23698881f, -0.07844383f, 0.06128857f, 0.44955820f, 
    -0.01769085f, -0.25639412f, -0.12546469f, -0.04545281f, 0.14166893f, 0.09840113f, 0.01075591f, -0.06693856f, 
    0.10233318f, -0.05454269f, 0.04747616f, 0.18001692f, 0.12032936f, 0.12949510f, 0.03718430f, -0.44162223f, 
    0.07678051f, -0.03513715f, 0.05762248f, 0.10542013f, -0.07870924f, -0.00412752f, 0.08174516f, -0.17276269f, 
    -0.27162367f, 0.05018048f, 0.18819323f, -0.01219791f, 0.00561780f, 0.26075539f, 0.13347480f, 0.06915686f, 
    0.20991969f, 0.20631918f, 0.12193868f, 0.26336998f, 0.45639113f, 0.04156844f, 0.39309156f, -0.21140344f, 
    -0.01550406f, 0.01585789f, -0.01474473f, 0.12717828f, -0.01878659f, 0.03210894f, -0.05549180f, 0.14961798f, 
    -0.20593087f, -0.21377726f, -0.02807598f, -0.23605822f, -0.15388361f, -0.11058328f, 0.10125720f, 0.04179311f, 
    0.10694017f, 0.24158162f, -0.01279253f, -0.21853392f, -0.09795657f, -0.09526654f, -0.03764908f, -0.16845891f, 
    -0.10712152f, -0.11281128f, 0.09635232f, -0.02422367f, 0.07901713f, 0.10561356f, 0.01366508f, 0.14914072f, 
    -0.07175500f, 0.08420242f, 0.00281777f, 0.33187324f, 0.06415465f, -0.04103000f, 0.03222251f, -0.12247390f, 
    0.33484775f, 0.03851054f, -0.13530292f, -0.09044108f, -0.48152941f, -0.08557756f, -0.24216107f, -0.00813437f, 
    0.10862218f, 0.15461908f, 0.14347401f, 0.05719037f, -0.07742718f, 0.12795959f, 0.00982309f, 0.08873526f, 
    0.54920548f, 0.22888231f, -0.02778097f, -0.02836997f, 0.00374483f, 0.11902054f, 0.06574465f, 0.18470946f, 
    -0.08704943f, -0.05327707f, 0.06641415f, -0.09594638f, 0.20150620f, -0.16358225f, 0.00303701f, -0.24315745f, 
    -0.16582295f, -0.09876075f, 0.04714168f, 0.11670728f, 0.08310215f, -0.09883393f, 0.01299633f, 0.24016882f, 
    -0.12856653f, 0.00887685f, -0.03132153f, -0.13484609f, -0.04671208f, 0.04246373f, -0.13927266f, -0.15569274f, 
    -0.15370135f, -0.13739629f, -0.07245099f, -0.12597209f, -0.25521231f, 0.09277874f, -0.16174619f, 0.05349023f, 
    0.03767549f, 0.06545240f, -0.12760679f, -0.00622545f, 0.13380682f, 0.09372246f, 0.13543563f, 0.05075932f, 
    0.01567395f, -0.03006683f, -0.04484848f, -0.01622568f, -0.04578516f, -0.07176159f, 0.04890458f, -0.03971016f, 
    0.02278312f, 0.05977326f, -0.01370261f, 0.03603350f, -0.03426455f, 0.03992186f, 0.00928554f, -0.03183761f, 
    -0.06508439f, -0.03072540f, -0.00890082f, 0.03376590f, -0.03125462f, -0.02664570f, -0.06439026f, -0.07514335f, 
    0.00934944f, -0.04974582f, 0.01811052f, 0.06742527f, 0.02750255f, -0.00789315f, 0.02081492f, -0.00407931f, 
    0.00483786f, -0.06047808f, 0.04211993f, 0.02978343f, -0.01949039f, 0.04505103f, -0.01609163f, -0.05159121f, 
    0.02850552f, 0.02368295f, -0.03224739f, -0.01990980f, 0.06198469f, -0.03893104f, -0.06074221f, -0.05826922f, 
    0.02292731f, -0.04104801f, 0.05813946f, -0.02382774f, 0.03026619f, -0.00842651f, -0.06117310f, 0.03508263f, 
    -0.02198344f, 0.00972169f, 0.00282355f, -0.01736048f, -0.00526941f, -0.07157318f, 0.02733130f, -0.03862091f, 
    0.06774776f, -0.07578852f, 0.06663823f, -0.02388223f, -0.06511080f, -0.06482107f, 0.05305479f, -0.01119004f, 
    -0.02164804f, 0.01132909f, -0.03784709f, 0.05963307f, -0.06577273f, -0.07277676f, -0.02443326f, -0.05822518f, 
    0.03414705f, 0.00621263f, 0.00176464f, 0.04972805f, 0.06647649f, 0.07302628f, -0.01520174f, 0.00999700f, 
    -0.05200510f, 0.06218791f, 0.05019084f, -0.03959736f, -0.04443172f, -0.02051342f, 0.02023787f, -0.03869044f, 
    0.04830077f, -0.01439850f, 0.04195740f, -0.00016309f, -0.04273140f, 0.00941496f, 0.05863939f, -0.03634581f, 
    0.05180513f, -0.06215509f, -0.05124788f, -0.07097492f, 0.02383821f, 0.07820639f, -0.05226346f, 0.00957211f, 
    0.04190259f, -0.01494918f, -0.06243046f, -0.00469237f, -0.02492633f, -0.06641220f, -0.02410477f, -0.04276811f, 
    -0.03051728f, -0.00344593f, 0.04092105f, -0.06524877f, 0.06576277f, 0.05148421f, 0.03672074f, 0.04100248f, 
    0.02568349f, -0.04092903f, 0.01370259f, 0.04175491f, 0.04653699f, 0.04506587f, 0.04281510f, -0.01913738f, 
    -0.04068531f, -0.05187152f, 0.02540105f, -0.01902288f, -0.04307332f, -0.00664775f, 0.03970223f, -0.04561348f, 
    -0.03197553f, -0.03906522f, 0.03317149f, -0.03082217f, -0.01405820f, 0.00245096f, 0.04216047f, -0.04702528f, 
    0.02137217f, -0.03374596f, -0.08087140f, -0.02546762f, -0.03324208f, 0.01826958f, 0.03382800f, -0.01636605f, 
    -0.00395447f, 0.05550409f, -0.01144839f, -0.00225241f, -0.04549558f, -0.04494602f, 0.04841309f, -0.01629249f, 
    0.01851710f, 0.05519260f, -0.00500712f, -0.03567395f, -0.05982523f, -0.06401546f, -0.03848311f, -0.02933479f, 
    0.00916526f, 0.05047493f, 0.01107748f, 0.01693363f, -0.07031334f, -0.07951546f, -0.07745346f, -0.04907167f, 
    -0.04505102f, -0.07143670f, -0.04400264f, 0.00427669f, -0.03260698f, -0.02274576f, 0.05628754f, 0.06239910f, 
    0.09833322f, -0.24314149f, 0.30188566f, 0.04378607f, -0.11661836f, 0.11929639f, -0.08867311f, -0.51222265f, 
    0.17047752f, 0.27247295f, 0.01774612f, 0.19267230f, 0.65192258f, 0.29568896f, -0.32513353f, -0.00468184f, 
    0.11843708f, -0.15683720f, 0.04848324f, -0.26504222f, -0.17662574f, -0.13666309f, -0.40390110f, -0.26946810f, 
    0.14849702f, 0.00084771f, 0.13863742f, -0.09318869f, 0.03941591f, -0.13244675f, -0.00289053f, -0.05894909f, 
    0.03173063f, -0.14576405f, 0.01131418f, -0.15872830f, 0.00822434f, -0.46413633f, -0.15559803f, -0.08498753f, 
    0.13323598f, -0.10316827f, 0.17191751f, 0.07553013f, -0.27345252f, 0.37349555f, 0.08998138f, 0.02366968f, 
    0.21635677f, -0.02058571f, 0.20723338f, -0.54922813f, -0.15123670f, 0.03573648f, -0.20891245f, 0.08619153f, 
    -0.04109914f, -0.03685483f, -0.06477581f, -0.52208245f, 0.29184812f, 0.11258677f, 0.03492792f, -0.06077081f, 
    -0.05819758f, -0.06436086f, -0.01381185f, 0.01109056f, 0.22847651f, 0.01996026f, 0.08348113f, 0.18368819f, 
    0.37195519f, 0.02431897f, -0.09491955f, 0.12442658f, -0.04736561f, -0.09009068f, 0.08715163f, 0.15401620f, 
    0.01855915f, -0.09433178f, 0.10595527f, -0.13409398f, -0.35787246f, 0.20189695f, 0.16086374f, -0.41170588f, 
    0.04831061f, -0.18547305f, -0.09711944f, 0.12007035f, -0.06061896f, 0.18655267f, -0.00212449f, 0.04854018f, 
    0.15687498f, 0.21554583f, -0.13324411f, -0.01925474f, 0.21908163f, 0.16406748f, 0.05651005f, 0.31760061f, 
    0.05983551f, -0.00660402f, -0.04685694f, 0.07632052f, -0.08507800f, 0.06130473f, 0.05352915f, 0.11505776f, 
    0.10917992f, 0.02542514f, -0.33713022f, -0.04299244f, 0.04223521f, -0.25818363f, -0.00987682f, -0.28967959f, 
    0.34389758f, -0.15704066f, 0.16309157f, 0.15553740f, -0.17730701f, -0.01724088f, 0.12015186f, 0.03494499f, 
    0.22592674f, 0.00335397f, 0.14692585f, 0.13710372f, 0.06184202f, -0.01626793f, 0.15898934f, 0.21208528f, 
    0.28333443f, 0.01822772f, 0.09110454f, 0.07409941f, 0.03006780f, -0.21869028f, 0.14300299f, 0.02239362f, 
    -0.30746794f, -0.05833875f, 0.08083977f, 0.17445746f, -0.07222085f, 0.19415316f, -0.07707949f, -0.22627805f, 
    0.16312645f, 0.03329922f, -0.02267474f, 0.25118604f, -0.61062551f, 0.31889063f, -0.00817154f, 0.18264925f, 
    0.05259404f, -0.14612119f, -0.04167610f, -0.15934326f, -0.15460373f, 0.03618500f, -0.18403864f, -0.05964267f, 
    0.00537099f, -0.08795039f, 0.08957879f, 0.13576642f, 0.16063718f, -0.18700965f, 0.09868640f, -0.15363167f, 
    0.14328903f, -0.06630079f, -0.02326989f, 0.01180350f, -0.05598107f, 0.05214695f, 0.17383176f, -0.26306167f, 
    0.09016075f, -0.00376431f, 0.13612501f, 0.07002319f, -0.07709375f, 0.06848330f, -0.07617105f, -0.10770412f, 
    -0.03820946f, -0.23694131f, 0.12206656f, 0.15148839f, -0.06684991f, -0.06765315f, -0.01913811f, -0.17746583f, 
    0.05025533f, 0.12356988f, 0.05253375f, 0.07083666f, -0.09388860f, -0.18701816f, 0.00570964f, 0.16452374f, 
    0.12826902f, -0.05907063f, -0.13212630f, -0.05342831f, -0.07766570f, -0.02604227f, 0.15071034f, 0.00046799f, 
    -0.17856191f, -0.02379074f, -0.07331384f, 0.14886531f, 0.10035166f, 0.05114768f, 0.02526953f, 0.01561129f, 
    0.09612828f, 0.10794374f, -0.13276193f, -0.00218198f, 0.36537838f, 0.05936400f, -0.03453180f, -0.00548480f, 
    0.01106918f, -0.04656130f, 0.20229308f, -0.22493368f, -0.10258274f, -0.11146893f, 0.03974388f, 0.06980298f, 
    0.17609148f, -0.11348540f, -0.05614987f, -0.19404848f, 0.01988534f, -0.02337344f, 0.01776800f, 0.03665570f, 
    -0.06734626f, -0.12856086f, -0.18402885f, 0.08006015f, 0.12415253f, 0.04376272f, 0.15888622f, 0.24198499f, 
    0.03083120f, 0.13101882f, -0.03083947f, 0.08836610f, 0.10292821f, 0.24789591f, 0.22910717f, 0.25223881f, 
    0.12157945f, -0.11701632f, 0.23241971f, 0.01231743f, 0.11314987f, -0.02936095f, -0.00757904f, 0.12654909f, 
    0.00078515f, -0.12800063f, 0.09875496f, -0.21785915f, 0.25000232f, 0.01778367f, 0.41093287f, -0.32831872f, 
    0.21527147f, 0.02946768f, -0.05197663f, -0.14878710f, -0.13860975f, 0.04663095f, 0.00664133f, 0.10081322f, 
    0.04683768f, 0.32118353f, 0.21666758f, 0.24966891f, 0.08023383f, 0.04331695f, -0.09878038f, 0.09080859f, 
    -0.01390670f, 0.18792270f, 0.05926050f, 0.01951033f, -0.42509452f, -0.41859099f, -0.05140941f, -0.09335470f, 
    -0.04724332f, 0.08445710f, 0.13346897f, 0.00327074f, -0.03125272f, -0.09311437f, -0.04095249f, -0.16126087f, 
    0.03249011f, -0.40611517f, 0.27407786f, 0.21427868f, -0.07180533f, 0.05344790f, -0.04193362f, 0.00723654f, 
    -0.01322413f, 0.06361160f, 0.06963260f, 0.30560735f, -0.06963292f, 0.37834549f, -0.03363166f, 0.12373415f, 
    -0.02449293f, -0.12803188f, -0.01728511f, -0.13202870f, 0.12040305f, -0.00717000f, -0.03066136f, -0.03472520f, 
    -0.56670445f, -0.18929292f, -0.09031331f, -0.14090443f, 0.02029772f, -0.12526004f, -0.17505434f, -0.12902728f, 
    0.18630986f, -0.04482352f, 0.20715895f, -0.00201877f, -0.09732008f, 0.13631326f, 0.13719666f, -0.00676861f, 
    0.13660131f, -0.01060633f, -0.02139539f, 0.04958322f, -0.13014638f, 0.02012287f, -0.07086229f, -0.00700727f, 
    -0.41101259f, -0.59141839f, -0.29082641f, -0.05262028f, 0.20291464f, -0.01783012f, -0.03005900f, -0.00507386f, 
    0.21154390f, 0.10800599f, 0.18722098f, 0.10368844f, 0.15163042f, -0.00814748f, 0.05525972f, 0.19566286f, 
    -0.19137783f, -0.20073245f, -0.01083161f, 0.14032127f, -0.05000842f, -0.22124121f, -0.03976004f, -0.05644899f, 
    0.07607845f, 0.09242681f, -0.02918524f, 0.02692365f, 0.01221782f, -0.02347586f, -0.01562150f, -0.09209968f, 
    0.26480418f, 0.12541758f, 0.18026616f, 0.11324038f, 0.06430321f, -0.12021981f, 0.00288014f, 0.06773268f, 
    0.07494108f, 0.10113349f, -0.02009509f, 0.03092756f, -0.01581094f, -0.02054354f, 0.16858397f, 0.04291661f, 
    0.17697984f, 0.24195307f, 0.04546695f, -0.00389365f, -0.00292347f, -0.05193357f, -0.11910249f, -0.13578056f, 
    0.06806853f, -0.07088189f, -0.20998161f, -0.10997146f, -0.22476637f, 0.54322088f, 0.07788851f, 0.07362235f, 
    0.15450463f, 0.01880814f, -0.00442155f, 0.16767436f, 0.15663278f, 0.09571312f, 0.17000607f, 0.17351839f, 
    -0.08025125f, -0.05651453f, -0.07855806f, -0.01038537f, 0.03838386f, 0.04891094f, 0.15330991f, 0.08034289f, 
    -0.04051729f, -0.12835599f, -0.00756638f, 0.02334823f, -0.09005954f, 0.10430812f, 0.28474495f, 0.18295400f, 
    -0.08624534f, -0.15226620f, 0.06869420f, 0.01848611f, -0.04332998f, 0.14224826f, 0.11563877f, 0.21812750f, 
    -0.22003096f, 0.05116073f, 0.17711073f, 0.17687365f, 0.07181211f, -0.10352260f, -0.20388100f, 0.15375470f, 
    -0.02789805f, -0.02316891f, 0.07578166f, -0.07333117f, -0.06074361f, 0.46158233f, 0.58921415f, -0.01938523f, 
    -0.08743590f, -0.11338156f, -0.00262320f, -0.21479850f, -0.07618694f, -0.03482094f, -0.08216402f, 0.10752169f, 
    -0.15545098f, -0.06942973f, 0.07889561f, 0.07215618f, 0.03991373f, -0.19862802f, -0.14804539f, -0.00345142f, 
    -0.00093503f, 0.20148826f, 0.02143955f, -0.12589704f, -0.09771335f, -0.11941678f, 0.19819535f, -0.27931526f, 
    -0.02859855f, 0.01076819f, 0.09724706f, -0.01401895f, -0.03509621f, 0.00596338f, 0.01674083f, -0.12826107f, 
    -0.22683363f, 0.14614081f, -0.06482850f, 0.17038350f, 0.16385356f, 0.07191399f, -0.20894034f, 0.17175478f, 
    0.12967390f, 0.09534821f, 0.24474746f, 0.02330011f, -0.10945247f, -0.25430778f, -0.29758072f, 0.17379194f, 
    0.01553645f, 0.01778293f, 0.07048028f, -0.14005670f, 0.03395988f, -0.02960557f, 0.06816124f, 0.01143591f, 
    0.28626427f, 0.34431329f, -0.10251199f, 0.11649250f, -0.11403876f, 0.10467775f, 0.10900481f, 0.05641028f, 
    0.20035057f, 0.01846622f, -0.01896749f, 0.05860441f, -0.21808629f, 0.19110258f, 0.01177920f, -0.06369492f, 
    -0.12293154f, -0.11730295f, -0.06957241f, 0.09314665f, 0.06931026f, -0.10638589f, 0.04752471f, -0.02526766f, 
    0.11380053f, -0.01630759f, -0.10926452f, -0.09580796f, -0.01546535f, -0.00231876f, -0.02296677f, -0.03529920f, 
    -0.00749834f, -0.07342791f, -0.03107737f, -0.05949826f, -0.39299229f, -0.31031591f, -0.20152193f, 0.14411078f, 
    -0.13609354f, -0.05704762f, -0.01188247f, 0.18065202f, -0.05111719f, 0.04318197f, 0.01938624f, 0.01724150f, 
    0.01028907f, 0.00227346f, 0.04519926f, -0.01266075f, 0.02642803f, 0.05404077f, -0.07707525f, -0.00944230f, 
    -0.01084219f, 0.00913644f, -0.01489056f, 0.02803547f, -0.00208901f, 0.05084193f, -0.01926101f, 0.03529770f, 
    0.01834943f, 0.04496485f, 0.03855259f, -0.00623939f, 0.05247891f, 0.00786272f, 0.04856867f, 0.01084164f, 
    0.03089685f, -0.07663259f, -0.03509241f, -0.06141703f, 0.01191166f, -0.02923109f, -0.05470398f, 0.03567649f, 
    -0.04266441f, 0.05745224f, 0.00787486f, 0.03755164f, 0.01548997f, -0.01984964f, -0.00803708f, -0.03894061f, 
    0.05135561f, -0.07076497f, 0.02150424f, -0.00451708f, 0.00832456f, -0.07824612f, -0.07368131f, 0.05617359f, 
    0.06149742f, 0.04261000f, -0.03771803f, 0.02085333f, -0.03716871f, -0.04942936f, -0.00840286f, 0.05028323f, 
    0.01399862f, -0.02490785f, -0.05730009f, 0.04095643f, -0.06753058f, 0.02742504f, 0.00621714f, -0.01066049f, 
    -0.04109992f, -0.00580156f, 0.05979517f, 0.03384128f, -0.01179472f, -0.07069732f, -0.04143118f, 0.04657325f, 
    -0.07358488f, -0.03792897f, -0.04245211f, -0.00790917f, -0.02679979f, -0.05825967f, -0.02474317f, -0.03411397f, 
    0.01151136f, -0.03853657f, 0.00029527f, -0.06770539f, -0.04740005f, 0.05310308f, -0.01220616f, 0.02424717f, 
    0.05901037f, -0.05027981f, -0.05325672f, 0.02065046f, -0.04688862f, -0.00301336f, 0.02706210f, -0.01914119f, 
    0.00063689f, -0.00262716f, -0.03158039f, 0.05836880f, -0.01532124f, -0.04781628f, -0.02680531f, -0.06092519f, 
    -0.02254884f, -0.01952539f, 0.05517385f, -0.03589480f, -0.01455171f, -0.04680023f, 0.01483293f, -0.05126311f, 
    -0.02103040f, -0.05610832f, 0.01528034f, 0.05017989f, -0.01241793f, -0.03128757f, -0.05453258f, 0.04087433f, 
    -0.01502403f, -0.06830510f, 0.00694688f, -0.06571484f, -0.00744464f, -0.03653418f, -0.03844880f, 0.04009106f, 
    0.03741131f, -0.01775286f, -0.03804731f, -0.02663569f, -0.01770636f, -0.07877231f, 0.05046488f, -0.00363124f, 
    -0.02810595f, -0.06310788f, 0.01976283f, -0.05177558f, 0.00432909f, -0.01938830f, -0.05572120f, 0.02101891f, 
    -0.03817571f, 0.01674214f, -0.08262187f, -0.02011977f, -0.02020257f, -0.02135147f, -0.04988101f, 0.00038487f, 
    -0.00308423f, 0.01542094f, -0.01039634f, 0.05613738f, -0.02910314f, -0.00004716f, -0.01747295f, -0.00949011f, 
    0.01663356f, -0.07976171f, 0.00532463f, -0.04590914f, 0.05648640f, 0.03734720f, -0.03230929f, -0.02061077f, 
    0.02486965f, 0.04652124f, 0.03202442f, -0.02496383f, 0.04951306f, -0.04503351f, -0.01015182f, -0.05646942f, 
    -0.04719958f, 0.04206178f, -0.07625968f, 0.04230557f, 0.02315918f, -0.01734851f, 0.02696634f, 0.01701057f, 
    0.01147777f, -0.05357199f, 0.06216862f, -0.06001318f, -0.05371971f, -0.07352692f, -0.04243044f, -0.03977705f, 
    -0.04670072f, -0.06833507f, -0.07379513f, -0.06072298f, -0.03976047f, 0.00144501f, 0.01098983f, 0.04100128f, 
    0.00735534f, 0.05966297f, 0.01106394f, -0.04011561f, 0.05275772f, 0.01096370f, -0.02956487f, -0.03918523f, 
    0.06102704f, 0.03474342f, 0.05903109f, 0.04507647f, 0.03579789f, -0.07086827f, 0.04509093f, 0.02771972f, 
    0.05696268f, 0.03254615f, 0.05773406f, -0.03297121f, -0.04073958f, -0.03398474f, -0.05074983f, -0.00454399f, 
    0.04184984f, -0.01517242f, -0.00879340f, -0.03990796f, -0.06008183f, -0.05040952f, 0.02339930f, -0.05234334f, 
    -0.02639352f, -0.05965813f, -0.01970280f, -0.07779031f, -0.07689058f, -0.03643873f, -0.02364501f, 0.03432940f, 
    -0.01650857f, 0.00311172f, -0.03070174f, 0.02852412f, -0.00468802f, -0.05782459f, 0.05686375f, -0.07831513f, 
    0.03088039f, 0.04399804f, -0.05172300f, 0.01699058f, -0.03080891f, -0.07654579f, 0.01921157f, -0.03131559f, 
    -0.04318266f, -0.01727755f, -0.03634382f, -0.07702539f, -0.04192181f, -0.02507841f, -0.06758255f, -0.07426763f, 
    0.04178473f, 0.00605422f, -0.04307387f, -0.01092410f, 0.01411184f, 0.01984168f, -0.00376837f, 0.04524025f, 
    -0.07502304f, -0.01717791f, 0.00765821f, 0.03888091f, -0.01806445f, 0.03036782f, -0.07523691f, -0.03773277f, 
    0.00210146f, -0.05201149f, -0.03795512f, 0.03675710f, -0.07182837f, 0.05564333f, -0.01681481f, 0.01043183f, 
    -0.07644521f, -0.00742294f, 0.03181132f, -0.00095421f, -0.03248367f, 0.03599771f, 0.01155877f, 0.02476518f, 
    0.03531547f, -0.03568642f, 0.03267614f, -0.02183838f, 0.05304541f, 0.04279770f, -0.00662636f, 0.05047166f, 
    0.05161713f, 0.05611545f, -0.03677142f, 0.03984467f, 0.05542812f, -0.05903793f, -0.02081230f, -0.06945542f, 
    -0.06485919f, 0.05331830f, -0.07834551f, -0.06142837f, 0.05684092f, 0.01002459f, 0.04909671f, -0.00701018f, 
    -0.00904330f, -0.02507775f, 0.05149320f, -0.02902571f, -0.04167417f, -0.06295592f, 0.01643063f, -0.02138032f, 
    -0.04177095f, 0.04574937f, -0.01227180f, -0.01698490f, -0.00703011f, -0.00834012f, 0.03646249f, -0.01467690f, 
    0.05650485f, -0.06014103f, 0.02042005f, -0.05214939f, 0.02727451f, -0.00161902f, -0.07232696f, -0.01001298f, 
    -0.07506988f, -0.06401478f, -0.04714274f, -0.04981948f, 0.05154469f, -0.06795026f, -0.05498790f, -0.07256576f, 
    0.06034256f, 0.01372582f, 0.00564496f, -0.06357696f, 0.01534712f, 0.04056503f, -0.06780525f, 0.01125543f, 
    0.02274235f, -0.02178916f, -0.02301274f, -0.01688476f, -0.06138090f, -0.00355935f, -0.02008988f, 0.02549796f, 
    -0.00706840f, 0.00379547f, 0.00073669f, -0.04870005f, 0.06179512f, -0.07440755f, 0.04480800f, 0.00648922f, 
    0.04102038f, 0.02146960f, -0.06569047f, 0.01628971f, 0.04814233f, -0.05091705f, -0.03641488f, 0.05192676f, 
    -0.00535191f, 0.00982917f, 0.02520495f, 0.04735241f, -0.00569922f, 0.00705777f, -0.05327521f, -0.00733901f, 
    -0.02375872f, 0.01797038f, 0.04843010f, 0.00858030f, -0.05873692f, 0.00342439f, -0.07612567f, -0.04332857f, 
    0.01179766f, -0.05114270f, 0.06418418f, 0.00388631f, 0.05134047f, -0.01684655f, -0.04283965f, 0.05668757f, 
    0.04569430f, -0.07391979f, -0.00465524f, -0.01179817f, -0.04501858f, -0.06820033f, -0.05037869f, 0.00522117f, 
    0.01392062f, 0.04643669f, -0.00938008f, 0.01690001f, 0.04630139f, 0.00390688f, -0.02646213f, 0.00405116f, 
    0.02756572f, -0.01202438f, -0.01380706f, -0.05025283f, 0.02386164f, -0.02678268f, -0.01295442f, -0.06116028f, 
    0.05574231f, -0.07239415f, -0.04975306f, 0.03762960f, -0.02798923f, -0.00979050f, -0.02825113f, -0.03135698f, 
    0.05193884f, 0.03856949f, -0.00992974f, -0.01458759f, -0.03450551f, 0.05657876f, 0.04762845f, -0.03384268f, 
    0.06016704f, 0.01500025f, 0.05791654f, -0.05873892f, -0.03289848f, -0.01957584f, 0.03400655f, -0.01019575f, 
    -0.06992999f, -0.00409150f, -0.03203278f, -0.00744494f, 0.00633727f, -0.02704927f, -0.02744867f, -0.03671836f, 
    0.04105317f, -0.04070804f, -0.01581873f, -0.05164439f, 0.01009149f, 0.04912485f, -0.07663804f, 0.01809108f, 
    0.05745118f, -0.04239754f, 0.03069372f, -0.05199664f, -0.03708577f, 0.01600493f, -0.00219100f, -0.07468040f, 
    0.03242590f, -0.06087273f, -0.03556872f, -0.01664522f, -0.02884961f, -0.04111999f, -0.03933215f, -0.05096655f, 
    0.01238387f, 0.02101895f, -0.04969992f, -0.00920324f, -0.06434153f, -0.03920919f, -0.05249409f, 0.01042463f, 
    -0.02931761f, 0.04138724f, -0.00724688f, 0.03079072f, -0.01880024f, -0.01899711f, -0.02988493f, 0.01457804f, 
    0.05333644f, 0.00609838f, -0.04393033f, -0.00525620f, -0.02322847f, 0.06507667f, -0.05565786f, 0.04884174f, 
    -0.04400352f, 0.03782347f, -0.04011454f, 0.06480222f, 0.01884257f, -0.02614403f, -0.04058351f, -0.04695527f, 
    -0.03432188f, 0.02241026f, 0.01924404f, -0.06107322f, -0.07181566f, 0.04146264f, -0.05353490f, -0.03455475f, 
    -0.00408432f, -0.06771930f, -0.05204619f, 0.05162533f, -0.05593508f, 0.06054687f, -0.02078492f, 0.00945174f, 
    0.04842510f, -0.02014465f, -0.07314418f, 0.04395376f, 0.05395863f, -0.05408023f, 0.06420714f, -0.06718136f, 
    0.04443111f, 0.00169070f, -0.03459166f, 0.05319839f, 0.01331189f, -0.02156233f, -0.00751438f, 0.06204922f, 
    0.03395692f, -0.02749030f, 0.04229591f, 0.03470752f, -0.01940616f, 0.01722706f, -0.01708399f, -0.03261594f, 
    -0.04042912f, 0.04100635f, -0.01259242f, -0.06195688f, -0.05301335f, -0.02738398f, 0.05588444f, -0.00909881f, 
    -0.05424828f, -0.01271815f, -0.02983112f, -0.07286290f, -0.05872276f, 0.03015502f, 0.04206307f, 0.01347138f, 
    0.09798621f, 0.07686467f, -0.16960718f, -0.12780052f, 0.01151736f, -0.09515349f, 0.09010534f, 0.11431923f, 
    0.12742054f, 0.09400634f, 0.07015412f, 0.08418758f, -0.13158046f, 0.01452076f, -0.13227418f, -0.17723863f, 
    0.02680980f, -0.03385951f, -0.15413602f, 0.26478574f, -0.09035706f, 0.14033352f, 0.09672945f, -0.33491036f, 
    0.18127462f, -0.08625717f, -0.06009730f, -0.04033226f, 0.11379090f, 0.00727418f, -0.08339194f, -0.00087584f, 
    0.02179845f, 0.22891033f, -0.05556940f, -0.03263334f, -0.25917459f, 0.64752787f, -0.01821131f, 0.03059494f, 
    0.02226928f, -0.01711692f, 0.09396865f, 0.01749074f, -0.14529048f, -0.12108118f, -0.10451141f, -0.00972294f, 
    -0.18549277f, 0.22402981f, 0.02101534f, 0.27335101f, -0.03497736f, 0.14087117f, 0.10349047f, -0.04350465f, 
    -0.10514837f, -0.11549319f, -0.06686526f, 0.03053838f, -0.26393941f, -0.06081661f, -0.01761623f, 0.06433966f, 
    0.04115906f, -0.01547835f, 0.07259106f, 0.07636190f, -0.00671886f, 0.17142481f, 0.01908736f, 0.03459627f, 
    -0.24661407f, 0.06352686f, 0.08538959f, -0.05059804f, 0.06558637f, 0.00315474f, -0.05816009f, 0.19741583f, 
    -0.19330266f, 0.11392649f, -0.05218453f, 0.00655993f, -0.25423634f, -0.03361478f, -0.45970577f, 0.50447613f, 
    -0.16613618f, -0.01717307f, 0.14185005f, 0.02061380f, -0.25762251f, -0.07426317f, 0.06779473f, 0.02910498f, 
    -0.09586070f, -0.24610406f, -0.04318342f, 0.12657402f, 0.00188786f, -0.02173722f, -0.01238276f, 0.07583216f, 
    -0.03115634f, 0.08192957f, 0.01104149f, 0.10469369f, 0.02634248f, 0.16226804f, 0.06285208f, -0.15974009f, 
    0.04721135f, -0.00049801f, -0.12533838f, -0.14301805f, -0.15281154f, 0.09033409f, -0.05334951f, 0.02282490f, 
    -0.05025655f, 0.35702389f, -0.20656583f, -0.10902417f, 0.15967667f, 0.08352359f, 0.04025175f, 0.08640128f, 
    0.11887735f, 0.19079854f, 0.15997322f, 0.18306619f, 0.06426255f, -0.27082539f, 0.03147793f, -0.13738869f, 
    0.04899367f, 0.02360590f, 0.05764623f, 0.15185882f, 0.04030620f, 0.16869506f, 0.03654816f, -0.07418042f, 
    0.32779750f, 0.05825039f, 0.20017821f, 0.19331139f, 0.03130362f, 0.03928779f, 0.16729613f, 0.20888427f, 
    0.02042872f, 0.03095080f, -0.01541711f, -0.06678472f, 0.39743283f, 0.07293363f, 0.15169987f, 0.07021091f, 
    -0.00315674f, 0.00730943f, 0.09970456f, 0.13204169f, -0.22510022f, -0.05401129f, -0.11632372f, -0.10107864f, 
    0.19890015f, 0.04812730f, 0.00273018f, -0.06167404f, 0.03331852f, 0.11615025f, -0.15464087f, 0.06494308f, 
    -0.16805525f, -0.09807789f, -0.07227342f, -0.21065581f, -0.03124450f, -0.25801617f, -0.01191999f, 0.08107799f, 
    0.03547572f, 0.00582756f, -0.18676423f, -0.02768328f, -0.03848362f, -0.14091566f, -0.20683506f, -0.06539842f, 
    -0.03667368f, -0.03579143f, -0.02412908f, 0.04857713f, -0.07685380f, -0.00345417f, 0.00332542f, 0.04349411f, 
    -0.06008562f, 0.06566353f, -0.02774988f, -0.01641501f, -0.03970447f, -0.01534759f, 0.04612792f, -0.06443132f, 
    -0.02748254f, -0.02559763f, 0.00134084f, 0.04792808f, 0.04635236f, -0.06409013f, -0.05205935f, -0.02090140f, 
    0.04055590f, -0.02951814f, 0.00990476f, 0.03382479f, 0.01325116f, 0.05752700f, -0.02102940f, 0.05390063f, 
    0.04831573f, -0.01613360f, -0.06234998f, 0.01792225f, -0.02930517f, -0.05957561f, 0.01054111f, 0.04329161f, 
    -0.04957270f, -0.03886262f, -0.04398831f, -0.03580964f, -0.06599558f, -0.05688306f, -0.05470974f, 0.06437615f, 
    0.03709659f, 0.04266749f, 0.05842867f, -0.00119360f, 0.03367802f, -0.06496628f, 0.05227318f, -0.00137313f, 
    -0.00712528f, -0.05724332f, -0.01697566f, 0.00354475f, -0.02233185f, -0.06070953f, -0.00538885f, -0.01739490f, 
    -0.03268420f, -0.06884752f, 0.05080190f, -0.00738076f, 0.03232251f, -0.01521564f, 0.01867100f, 0.04339340f, 
    0.02216425f, 0.06472991f, 0.06567793f, 0.05272547f, -0.03002539f, -0.06577078f, -0.00134050f, -0.00253154f, 
    -0.06984387f, -0.06144869f, -0.03459563f, -0.05312341f, 0.06320302f, -0.04508755f, 0.00640390f, 0.04926930f, 
    -0.06664395f, 0.03770122f, 0.04812026f, 0.02969069f, -0.05516775f, -0.01735816f, 0.02771453f, -0.02294807f, 
    -0.00319624f, -0.02176377f, 0.00829100f, -0.05331920f, -0.03386059f, 0.05888863f, 0.02301690f, 0.05621769f, 
    -0.06214654f, -0.04182743f, -0.03829905f, 0.01307410f, -0.07748699f, 0.02801660f, 0.01993066f, -0.02842744f, 
    0.03307755f, 0.02280694f, -0.04755958f, 0.02158910f, -0.05412204f, -0.05174536f, 0.00312028f, -0.02434271f, 
    0.04839192f, 0.00142076f, -0.04773096f, -0.07548131f, -0.05892380f, -0.01366620f, 0.03862332f, -0.06355057f, 
    0.05321622f, -0.02258617f, 0.03391315f, -0.05116075f, -0.04690890f, -0.02511052f, -0.00560598f, -0.05926846f, 
    -0.01247170f, -0.07227819f, -0.06801026f, -0.01596803f, -0.06664661f, 0.03246267f, 0.01071829f, 0.01688687f, 
    0.06157935f, -0.04060932f, -0.00280469f, -0.05875625f, -0.07614566f, 0.00313113f, -0.06426825f, -0.07551116f, 
    0.01436057f, -0.00611500f, -0.02955844f, 0.03653956f, 0.02225280f, -0.03298219f, 0.06199533f, -0.00608639f, 
    0.02090363f, -0.00394169f, 0.01160187f, -0.00380506f, 0.01556843f, 0.04650035f, -0.03533524f, 0.00083861f, 
    -0.00491640f, -0.05944279f, -0.02030752f, 0.04956918f, -0.03649415f, -0.02663811f, 0.00898361f, -0.05675888f, 
    -0.03382144f, -0.02880342f, 0.00296313f, -0.04319151f, 0.01662517f, -0.00540384f, -0.06441691f, -0.06217211f, 
    0.04065199f, 0.04793926f, -0.02964808f, 0.03243530f, 0.05759317f, 0.01861750f, 0.06312652f, 0.01991860f, 
    0.05601994f, -0.36041117f, -0.22927251f, -0.19746172f, -0.09250427f, 0.00243204f, -0.03863557f, 0.05616973f, 
    -0.11298329f, -0.11567377f, 0.00135736f, 0.01706940f, -0.46163228f, -0.17236648f, -0.15111691f, -0.19887868f, 
    0.15095331f, -0.23220322f, -0.04489486f, -0.02612828f, 0.16897823f, 0.20270751f, 0.03828608f, 0.12061615f, 
    -0.07141402f, -0.26318315f, -0.35482335f, 0.09422156f, -0.20785142f, -0.16814257f, -0.07410958f, -0.05978757f, 
    0.06922212f, 0.16729306f, -0.05025059f, 0.21067947f, 0.36003843f, -0.23975012f, -0.00845816f, -0.18866201f, 
    0.13028194f, 0.03570136f, 0.14532857f, -0.06259051f, -0.04198320f, -0.08840623f, 0.03079832f, 0.20590864f, 
    0.10879043f, -0.48879597f, -0.08354788f, -0.38317522f, 0.06280651f, 0.11662477f, 0.00591302f, 0.05453112f, 
    0.27528092f, -0.04956139f, 0.06997488f, 0.17872784f, 0.00924644f, 0.18318923f, 0.05015159f, -0.00807650f, 
    0.06607404f, 0.04649886f, -0.01684693f, -0.02415096f, 0.05594265f, -0.01213812f, 0.11266119f, -0.11724428f, 
    0.19135472f, 0.34008929f, -0.00280996f, 0.14612667f, 0.19187707f, 0.17567287f, 0.22678412f, 0.03056432f, 
    0.11290725f, -0.05966197f, -0.03441447f, -0.10385669f, 0.36787561f, -0.71250844f, -0.36914638f, -0.11030355f, 
    0.12209983f, 0.03723542f, -0.00390484f, -0.05906002f, -0.04007823f, 0.04349899f, 0.04008796f, 0.03766893f, 
    0.23312649f, 0.18848267f, 0.19766147f, 0.32741559f, 0.15544367f, 0.17136073f, 0.12296553f, 0.21916628f, 
    0.04081932f, -0.07521103f, 0.11824973f, 0.20604220f, -0.29735780f, -0.13057452f, -0.61296958f, 0.12201077f, 
    -0.09794690f, -0.16101226f, -0.00753402f, -0.02676773f, 0.20449983f, 0.10651300f, -0.11719280f, 0.02734503f, 
    0.15368640f, 0.02043140f, 0.26260507f, -0.15646483f, -0.13053210f, 0.10537610f, 0.02574346f, 0.03515649f, 
    -0.12599650f, 0.03829269f, 0.06811883f, 0.05018190f, 0.28664830f, 0.29697484f, 0.25346854f, 0.13450690f, 
    0.22412288f, 0.05029684f, 0.05529396f, 0.03778579f, 0.02535505f, -0.00946233f, -0.08881560f, -0.13529095f, 
    0.13251244f, -0.36499071f, -0.17066324f, -0.17794456f, 0.05238206f, -0.23824221f, -0.04077185f, -0.05671972f, 
    -0.02755208f, -0.00184345f, 0.09155047f, -0.21250381f, 0.12237829f, 0.31610581f, 0.09002029f, 0.31771123f, 
    0.14769763f, 0.06557016f, 0.06065418f, 0.19182515f, 0.00718395f, 0.25368530f, 0.00293995f, 0.11259910f, 
    -0.47243172f, -0.58509362f, -0.33079633f, -0.12555753f, 0.07351552f, 0.12333300f, -0.15498011f, -0.04432342f, 
    0.13729243f, -0.02749928f, 0.03763853f, 0.10587613f, 0.37798753f, 0.04361916f, 0.42643896f, 0.33130237f, 
    -0.09186599f, 0.24037924f, -0.04562496f, 0.12511715f, 0.01419684f, -0.06156638f, -0.15400584f, 0.18118924f, 
    -0.00685533f, -0.27883893f, -0.24857345f, -0.20936765f, -0.07962486f, -0.06662570f, -0.13948266f, -0.09336881f, 
    -0.04386331f, -0.13466501f, -0.23836797f, 0.09968058f, -0.08807848f, -0.05790717f, -0.22810155f, -0.13369574f, 
    -0.05366354f, -0.04156011f, 0.20712204f, -0.04383776f, 0.06088387f, 0.12481209f, -0.08552191f, 0.05480823f, 
    -0.00410725f, -0.18367571f, -0.14094071f, -0.00166890f, -0.04297773f, -0.12842681f, -0.02533678f, -0.18240358f, 
    -0.07836700f, -0.00381722f, 0.03420068f, 0.24981987f, 0.25916544f, 0.26088619f, -0.01216015f, 0.07712785f, 
    0.12291076f, 0.07435022f, -0.00998171f, 0.07323255f, 0.03285388f, -0.00070603f, -0.02999859f, -0.08036427f, 
    -0.01927214f, 0.17804949f, -0.12707356f, -0.05447268f, -0.03411606f, 0.14420629f, -0.13135672f, -0.07569951f, 
    0.16451550f, 0.12041491f, -0.00838508f, 0.12751268f, -0.14395209f, -0.16337335f, -0.02713198f, -0.06289370f, 
    -0.04566234f, 0.04984199f, 0.04258339f, 0.03270797f, 0.01278279f, 0.00900193f, 0.00231731f, -0.26226687f, 
    -0.07141811f, 0.23854125f, 0.01413708f, 0.09034674f, 0.14396356f, 0.13034278f, 0.13076977f, 0.24748850f, 
    0.16487917f, 0.09037226f, 0.01586295f, 0.06503227f, -0.30884686f, -0.19645159f, -0.31384578f, 0.22420911f, 
    -0.05275186f, 0.26759741f, 0.16668722f, 0.12915196f, 0.21347740f, 0.07002996f, 0.18360822f, 0.00547537f, 
    -0.05999101f, -0.06041896f, -0.06854202f, 0.04146770f, 0.09111722f, 0.13980027f, 0.06967612f, 0.14740141f, 
    0.17919527f, 0.06988525f, 0.20540991f, 0.03607628f, 0.05330490f, 0.18342507f, 0.05834556f, 0.12321951f, 
    0.06178356f, -0.07679264f, -0.08139548f, -0.09136373f, 0.06287295f, 0.06370896f, 0.05804828f, 0.15529831f, 
    -0.08608963f, 0.38032249f, -0.17986594f, -0.30315885f, 0.00938094f, -0.01652716f, 0.20386903f, -0.01187201f, 
    -0.08084558f, -0.22731882f, -0.17424905f, -0.13814725f, 0.32263950f, 0.05572497f, 0.09323329f, 0.25097325f, 
    0.27096891f, 0.00238195f, -0.00855615f, 0.25550151f, -0.17109573f, 0.10346130f, 0.08829569f, 0.03261948f, 
    0.10060084f, 0.12047071f, 0.22663525f, 0.26890388f, 0.05338561f, -0.07034786f, -0.15359309f, 0.13404138f, 
    -0.06574080f, -0.09236844f, -0.10195402f, -0.06497115f, -0.08455815f, -0.06710160f, 0.07272889f, 0.02910131f, 
    0.00679483f, 0.19884340f, 0.03818902f, 0.04696330f, 0.10354195f, 0.14064957f, -0.01681361f, 0.06561778f, 
    0.01170368f, 0.15958440f, 0.21790810f, 0.10063392f, -0.12638162f, -0.00206091f, -0.05205908f, -0.11260433f, 
    -0.07526215f, -0.14401886f, 0.00210175f, -0.10325865f, 0.13584086f, -0.10141031f, 0.07224841f, 0.09190202f, 
    0.10624035f, 0.17707030f, 0.09813824f, 0.05891638f, -0.07628766f, -0.08923347f, -0.01031775f, 0.03858831f, 
    -0.01712719f, -0.25096560f, 0.14346465f, 0.11543237f, 0.16168873f, 0.00407396f, 0.03206441f, -0.05812201f, 
    0.09076755f, 0.18915251f, 0.23280735f, 0.16260991f, -0.14636892f, 0.14168903f, 0.16666818f, 0.00689782f, 
    0.20963109f, -0.18549553f, -0.22190505f, -0.19805637f, -0.16819069f, -0.04704084f, 0.10166048f, -0.21831317f, 
    0.15118051f, 0.27688995f, 0.02943305f, 0.19148965f, 0.01277382f, 0.18015878f, 0.06393687f, -0.17969950f, 
    0.00287059f, 0.33269799f, -0.20139866f, 0.04178751f, -0.11291996f, 0.31649634f, -0.18893923f, -0.26612645f, 
    0.14797530f, -0.19788021f, 0.27787411f, 0.01647209f, 0.08497363f, -0.10680004f, -0.13786422f, -0.07445769f, 
    -0.14876290f, -0.22769296f, 0.05465088f, -0.06735760f, 0.04425221f, 0.14733462f, -0.19255322f, 0.07761073f, 
    0.15301634f, -0.19052930f, -0.18969229f, -0.00294956f, -0.22021927f, 0.08669835f, 0.03895794f, 0.10173884f, 
    -0.02852444f, 0.24012440f, 0.05356459f, -0.01254429f, -0.02071421f, 0.09885019f, -0.05749496f, 0.21654254f, 
    0.00973093f, 0.35700196f, -0.30770478f, 0.00269921f, 0.11165751f, -0.11779197f, -0.16211958f, 0.18027076f, 
    -0.25517944f, -0.08374767f, -0.12085546f, -0.14815781f, -0.13609549f, 0.24501826f, 0.08925899f, -0.04695971f, 
    -0.00062375f, -0.15616091f, -0.04125311f, -0.11576917f, -0.13379149f, 0.13707946f, 0.17685890f, 0.14969681f, 
    0.14985012f, 0.16577736f, 0.09930202f, 0.13948031f, 0.20625246f, -0.05900835f, 0.03417669f, 0.03122308f, 
    -0.17982718f, 0.05126041f, 0.14945410f, 0.13180099f, -0.00595823f, 0.04782549f, -0.14298449f, 0.19088583f, 
    0.05681626f, -0.11169927f, -0.03055699f, -0.17426483f, -0.09530747f, -0.04140759f, -0.12948103f, -0.04426357f, 
    -0.01904571f, 0.26001865f, -0.14866343f, -0.03494745f, 0.15588436f, 0.09703129f, -0.03860228f, 0.04206881f, 
    -0.07149497f, 0.09298296f, 0.15001790f, 0.19292805f, 0.15632279f, 0.18270670f, -0.14070624f, -0.13987964f, 
    -0.07688493f, -0.19097753f, 0.00483201f, -0.15236388f, 0.15170416f, 0.02739333f, -0.01899502f, -0.02544797f, 
    0.18315201f, -0.11516450f, -0.32872355f, 0.11619017f, -0.20113549f, 0.10110302f, 0.05067003f, -0.02016730f, 
    0.11982626f, 0.15289012f, 0.23365007f, 0.04159540f, 0.03748241f, 0.57322478f, 0.04556180f, 0.13091497f, 
    0.10980386f, -0.15347344f, 0.12575419f, 0.09131542f, 0.14009753f, -0.19503120f, -0.14012198f, -0.12029441f, 
    -0.03072125f, -0.30902627f, -0.27857631f, -0.00854804f, 0.21509494f, 0.09998395f, 0.04546082f, 0.05144458f, 
    0.23324658f, 0.02263490f, -0.02938624f, -0.00386034f, 0.11003517f, -0.12524325f, -0.17453311f, -0.02336253f, 
    0.08975190f, -0.21444254f, 0.05957232f, 0.01111131f, 0.02634972f, -0.07466397f, 0.03754514f, -0.12386677f, 
    0.20013107f, -0.10525186f, 0.10324340f, 0.06685980f, 0.04402366f, -0.09334439f, 0.00269486f, 0.26231271f, 
    -0.07539737f, 0.01285319f, 0.12404626f, -0.00676699f, -0.06386064f, 0.18195190f, 0.06425100f, -0.08623789f, 
    -0.04404874f, -0.13422056f, -0.06132840f, 0.03731849f, 0.03860324f, -0.09868537f, -0.05768849f, 0.01284894f, 
    -0.00425953f, 0.05551180f, -0.19219457f, 0.34862342f, -0.09963560f, -0.03987265f, -0.05927044f, -0.05340200f, 
    0.02471306f, -0.09466415f, 0.30080301f, 0.16509436f, -0.02457609f, -0.67370778f, -0.06863108f, -0.19690132f, 
    0.02396277f, 0.15282772f, 0.02849611f, 0.05082310f, 0.18715349f, 0.04741705f, 0.01582930f, 0.14503504f, 
    0.08187822f, -0.23297222f, 0.19711591f, -0.06211416f, 0.21356808f, 0.04055731f, 0.04364109f, -0.10956953f, 
    0.06469268f, -0.11050760f, 0.21493155f, -0.09418399f, 0.16224773f, 0.19616739f, 0.07287977f, -0.11825861f, 
    -0.06293011f, 0.01297485f, -0.03368026f, -0.03317769f, 0.19251846f, -0.10717064f, 0.00771108f, 0.04909060f, 
    0.11704911f, -0.04612072f, -0.10668866f, -0.05018979f, -0.03616666f, 0.10092417f, 0.16645260f, -0.01906084f, 
    0.11374637f, 0.03052961f, 0.06424795f, -0.01122693f, -0.05511089f, 0.15316787f, -0.00792450f, -0.15215081f, 
    -0.02420305f, 0.03616221f, -0.06256360f, 0.14886071f, 0.21289210f, -0.07419945f, -0.00883890f, -0.08211415f, 
    0.02472070f, -0.00086447f, -0.04053370f, -0.01777851f, -0.07445451f, 0.06088154f, 0.12027737f, -0.10060627f, 
    0.04592673f, -0.15110949f, 0.08619252f, 0.11374810f, 0.00554491f, -0.08936892f, -0.25767472f, 0.21809556f, 
    -0.01581412f, -0.01305133f, 0.06144582f, -0.01607528f, 0.07776199f, -0.00880775f, -0.07601354f, 0.01864841f, 
    0.15579288f, -0.39805752f, 0.41115457f, 0.03484940f, -0.17379788f, -0.13846393f, -0.00148081f, 0.13556458f, 
    0.16051188f, 0.10812841f, -0.08531787f, 0.04905001f, -0.04676436f, -0.04003143f, -0.03740438f, -0.00529324f, 
    0.14696814f, 0.22978179f, 0.03394281f, 0.18328135f, 0.00543733f, -0.13066058f, -0.00150576f, -0.00549884f, 
    0.28981641f, 0.01554826f, -0.13979469f, -0.09093138f, 0.16531464f, -0.07938750f, 0.10574207f, -0.02125273f, 
    -0.05308912f, 0.14249513f, -0.07554362f, 0.02393596f, 0.18671784f, 0.22806345f, -0.13619424f, 0.06846838f, 
    -0.03262772f, -0.13977838f, 0.01647886f, -0.12112510f, 0.00885548f, 0.15539502f, -0.02333756f, -0.00890490f, 
    -0.39041793f, -0.10076208f, 0.01466179f, 0.13027555f, 0.07292433f, 0.03856679f, -0.02133982f, -0.03779791f, 
    -0.00184495f, -0.12102247f, -0.15161601f, -0.05159682f, 0.03697252f, 0.08323533f, 0.23082516f, -0.05316890f, 
    -0.06485702f, 0.11725011f, 0.03749740f, -0.05897912f, 0.06685631f, 0.09144995f, -0.00643072f, 0.00976731f, 
    -0.08083471f, 0.11612497f, 0.01781315f, 0.10775206f, -0.02410843f, 0.12434915f, 0.06845958f, 0.09935915f, 
    0.07002816f, 0.18460046f, 0.26674989f, 0.12389876f, -0.10114835f, 0.00147551f, 0.29154715f, 0.19965865f, 
    -0.14419188f, -0.16627890f, -0.22971453f, 0.07154225f, -0.05831267f, -0.13646948f, -0.07043007f, -0.13338129f, 
    -0.00032756f, 0.35524201f, 0.05219170f, 0.36218694f, 0.04483545f, 0.04967638f, 0.01915582f, -0.05139924f, 
    -0.01710967f, -0.13523604f, 0.03707589f, -0.01450970f, -0.31809178f, -0.25096583f, 0.06599329f, -0.12133482f, 
    -0.06180482f, 0.07986759f, -0.05649258f, 0.12986563f, 0.14809620f, 0.06573281f, 0.02231254f, 0.14919333f, 
    -0.11481638f, -0.10565516f, 0.10230691f, 0.10748491f, 0.16425841f, -0.09673896f, 0.13751341f, 0.00559856f, 
    -0.16524324f, -0.13873598f, 0.01300990f, -0.14723796f, 0.13049059f, 0.09987572f, 0.05768472f, 0.17182624f, 
    -0.09768194f, -0.03083961f, -0.02995772f, 0.03092775f, 0.19847059f, 0.04253247f, 0.06974397f, 0.35357830f, 
    0.11874583f, -0.16241109f, 0.05148044f, 0.00194361f, -0.13126180f, -0.07621609f, 0.07074388f, -0.04914863f, 
    -0.07484171f, -0.00114580f, -0.05000003f, -0.10033068f, 0.21008816f, 0.58299619f, 0.50714767f, -0.15668371f, 
    -0.07958292f, -0.20001054f, -0.08016163f, -0.03221567f, 0.05426578f, -0.05489373f, -0.12427443f, 0.00588176f, 
    -0.06271494f, 0.07556448f, 0.10445118f, 0.07952647f, -0.09012756f, -0.03156484f, -0.02227614f, -0.02819929f, 
    -0.06979882f, 0.04991129f, 0.04084150f, 0.01163425f, -0.00260874f, -0.22420707f, 0.04072382f, -0.01052141f, 
    0.06124819f, -0.01988567f, 0.01675286f, 0.09189191f, -0.11226583f, -0.19915327f, -0.13048244f, -0.24209139f, 
    -0.07533206f, -0.43364748f, 0.35284600f, 0.25547969f, -0.11093073f, 0.15088426f, -0.17491689f, 0.12049981f, 
    0.13849255f, 0.20293085f, 0.19613200f, 0.17867981f, -0.06499469f, -0.02514887f, -0.21823248f, -0.12380569f, 
    -0.13974141f, 0.02754011f, -0.01906610f, -0.08940078f, 0.07031072f, -0.06999402f, -0.08726331f, -0.02001146f, 
    -0.14133905f, 0.04106868f, -0.36652601f, -0.07642312f, 0.03239742f, 0.11773210f, 0.06350604f, -0.02296835f, 
    0.09990423f, 0.12296857f, 0.04622452f, 0.22304876f, 0.14499255f, 0.07602552f, -0.02532005f, -0.24167331f, 
    0.01852429f, -0.07156893f, 0.15664868f, -0.07252573f, -0.08609830f, -0.15085444f, -0.04575712f, -0.28443041f, 
    -0.20805374f, -0.14749165f, -0.03780448f, 0.06031452f, 0.05691333f, 0.05940010f, 0.07824517f, -0.03237131f, 
    0.02901930f, -0.11044797f, -0.07018571f, 0.11634604f, 0.00267449f, 0.01700376f, 0.06787323f, -0.03258504f, 
    -0.10605612f, -0.06075070f, 0.17232803f, -0.04569674f, -0.06277794f, 0.05536622f, 0.01077465f, -0.12288377f, 
    -0.17941372f, 0.02671545f, -0.12952098f, 0.03715936f, 0.02607754f, 0.05705162f, -0.05003858f, 0.04347866f, 
    0.16545038f, -0.01932060f, -0.05251971f, 0.14405264f, -0.05379903f, -0.17298666f, -0.09150033f, 0.18948108f, 
    -0.03579190f, 0.35307175f, 0.06826684f, 0.25886118f, 0.11153272f, 0.10960762f, -0.04180282f, 0.04727431f, 
    -0.41124067f, -0.21990390f, -0.01552167f, -0.15094239f, -0.03099701f, -0.00719789f, 0.05247257f, 0.07499648f, 
    -0.03817708f, -0.06859128f, 0.10791103f, -0.11277828f, 0.02792603f, -0.15343462f, 0.17630860f, 0.14760926f, 
    -0.01541096f, 0.18828502f, -0.02383551f, 0.16174106f, -0.05112289f, 0.21046628f, 0.17126805f, 0.02432786f, 
    -0.04093069f, 0.37033078f, -0.06766154f, 0.07406295f, -0.04700067f, 0.07565401f, 0.09130551f, 0.04563692f, 
    -0.20498897f, 0.07483498f, -0.07741378f, -0.04384670f, -0.02268814f, -0.12207741f, 0.01064929f, -0.10936968f, 
    -0.09508599f, -0.25546154f, -0.07179767f, 0.01543892f, 0.07605892f, 0.16777368f, 0.00763786f, 0.08041573f, 
    0.05663358f, -0.10356513f, 0.49855945f, 0.15479633f, -0.02884744f, -0.02374656f, -0.02316521f, 0.05852346f, 
    -0.04748718f, -0.02194885f, -0.05151160f, -0.09009892f, 0.24325296f, -0.27715987f, -0.11558104f, 0.02042088f, 
    -0.14268260f, 0.07771342f, 0.10150606f, 0.15079376f, -0.02135971f, 0.04870816f, -0.19833690f, -0.14527485f, 
    -0.04283710f, 0.01936305f, 0.05355187f, -0.13665277f, 0.02187364f, -0.06443536f, -0.12742203f, 0.00524518f, 
    0.09405741f, 0.04307550f, -0.11874305f, 0.03917291f, 0.31686273f, -0.00172028f, 0.23791312f, -0.20261136f, 
    -0.08814351f, -0.04877118f, 0.03592146f, -0.01025061f, -0.04267977f, -0.05735412f, 0.09547870f, -0.11734381f, 
    -0.37040058f, -0.32708547f, 0.10754608f, 0.33732516f, 0.05670594f, 0.09176873f, 0.07449333f, 0.02510513f, 
    0.25823107f, -0.01454302f, 0.12957595f, -0.04768773f, -0.09893617f, -0.02702364f, 0.34611434f, 0.02781191f, 
    -0.04741536f, 0.19445235f, -0.07117233f, 0.04867441f, 0.01742527f, -0.11882953f, 0.08807103f, -0.07600025f, 
    0.09970945f, 0.21010420f, 0.15570442f, 0.21057837f, -0.08874971f, -0.06121284f, 0.13418674f, 0.09034477f, 
    0.00004520f, -0.05228730f, 0.11758301f, 0.17120330f, 0.29941800f, -0.57678860f, 0.08794523f, -0.12767692f, 
    -0.12101114f, 0.07640544f, -0.06648099f, 0.00158270f, -0.31574571f, 0.03391904f, -0.03405202f, 0.00573906f, 
    0.29798034f, 0.15416236f, 0.09139091f, 0.03010232f, -0.19161461f, -0.03880814f, -0.01900958f, 0.12633859f, 
    -0.19147450f, 0.05696188f, 0.08978193f, -0.02330805f, -0.12202887f, 0.18560076f, 0.26749128f, -0.02512764f, 
    0.05986309f, 0.14579363f, -0.02010448f, 0.03417185f, -0.01846064f, -0.02166100f, -0.13036598f, -0.02466113f, 
    0.02739846f, 0.02020239f, 0.01179814f, -0.01279329f, 0.01425657f, -0.05012809f, -0.15359508f, -0.19360146f, 
    -0.10083991f, -0.05837905f, -0.23110262f, 0.00190458f, -0.11064639f, -0.08262400f, 0.02792421f, 0.00857919f, 
    0.01266182f, 0.16360885f, 0.16115195f, -0.18576235f, 0.17046130f, 0.14799128f, 0.10418077f, 0.32986131f, 
    -0.26631996f, -0.05762901f, 0.32066369f, -0.02908675f, -0.13505073f, -0.07195769f, -0.12265854f, -0.13490778f, 
    0.11204931f, -0.03845649f, 0.06845991f, 0.03925031f, 0.43006641f, -0.18048637f, 0.06456430f, 0.18200617f, 
    0.12675756f, 0.08487198f, -0.18868199f, 0.06261400f, 0.09658577f, 0.04882308f, 0.08505784f, 0.11666424f, 
    0.19168617f, -0.03044779f, -0.16304001f, -0.15748847f, -0.05263457f, 0.09096390f, -0.06009346f, 0.10023613f, 
    0.07562999f, 0.04595265f, 0.02815915f, 0.07601587f, 0.28483939f, 0.06617197f, 0.03644439f, -0.21321940f, 
    -0.03878607f, -0.14089310f, -0.05736713f, -0.07118180f, -0.08540288f, -0.17819546f, -0.00084034f, -0.39466378f, 
    0.14364320f, 0.18105741f, 0.05084189f, 0.10691535f, 0.11587220f, 0.26783675f, 0.22569913f, 0.07065752f, 
    0.23561154f, -0.04334913f, 0.10674603f, 0.05272935f, 0.30503166f, -0.55156308f, 0.13020749f, -0.40829092f, 
    0.00761005f, 0.06898014f, -0.21350019f, 0.20403019f, 0.04528582f, 0.23293455f, 0.09249777f, 0.09455830f, 
    0.22477393f, 0.09747076f, 0.00751858f, -0.13812660f, 0.15269063f, 0.29732904f, 0.02626327f, 0.12569954f, 
    0.10845014f, 0.01860910f, -0.03927318f, -0.06539752f, -0.10217123f, 0.06042302f, 0.04527172f, 0.11109392f, 
    -0.08631975f, 0.00129471f, -0.00011943f, -0.00438286f, 0.01412479f, 0.01886130f, 0.05822281f, 0.10065561f, 
    0.15885343f, 0.23309846f, -0.02756261f, 0.07069363f, -0.02582940f, -0.08841374f, -0.00380928f, -0.16492964f, 
    0.14768152f, -0.15373930f, -0.24978514f, -0.09771198f, -0.12031277f, 0.21298486f, 0.18738452f, 0.09522541f, 
    0.24286908f, 0.16775414f, -0.06942576f, 0.11570027f, -0.09901736f, -0.06414916f, 0.05418605f, 0.05634309f, 
    0.04666118f, -0.01230816f, 0.20136259f, 0.07251682f, 0.01439079f, -0.05342815f, -0.08534487f, -0.01953311f, 
    -0.12357109f, -0.13884340f, -0.15463357f, -0.17781886f, -0.27650994f, -0.19592576f, 0.09781950f, -0.16913432f, 
    -0.01896046f, 0.10517379f, -0.00130871f, 0.12969451f, 0.14933312f, 0.11167163f, 0.10027305f, 0.11584628f, 
    0.05571513f, 0.03992230f, 0.01728422f, 0.05384078f, 0.00224547f, -0.11553990f, -0.05338025f, -0.04509928f, 
    -0.12194133f, 0.02043561f, -0.05022316f, -0.15852739f, -0.05499213f, 0.25318018f, 0.03619255f, -0.02122500f, 
    0.06933009f, 0.17947140f, 0.11512858f, 0.18758263f, 0.05490236f, 0.05669800f, -0.01429120f, 0.06746759f, 
    0.09453971f, -0.13150036f, 0.00147085f, 0.17447908f, -0.04702613f, 0.06686745f, 0.04490403f, 0.20399015f, 
    0.17957877f, 0.04486322f, 0.17353687f, 0.23510469f, -0.53472692f, 0.14686419f, 0.26537699f, 0.33003691f, 
    0.17437229f, -0.22222182f, -0.15759291f, 0.25624663f, -0.02003260f, -0.06984233f, -0.05028952f, -0.11556071f, 
    -0.33743834f, 0.12661161f, -0.44216016f, 0.51683629f, -0.01717427f, -0.05912708f, -0.10080703f, -0.02060239f, 
    0.15976550f, 0.13915713f, 0.03719420f, 0.07390757f, 0.05221033f, -0.48870161f, 0.21708782f, -0.09604929f, 
    0.23988958f, 0.17501739f, 0.17855419f, 0.08738110f, 0.03107165f, 0.01597492f, -0.04786622f, 0.28985137f, 
    0.20252874f, -0.28483617f, -0.25712338f, -0.04704141f, 0.00056762f, 0.20516063f, 0.12035231f, 0.09282025f, 
    0.07214221f, -0.05504630f, 0.02133569f, -0.01757824f, -0.23247023f, 0.11734716f, 0.21104997f, 0.04084161f, 
    -0.07492881f, -0.01225529f, 0.02872731f, -0.20150846f, 0.15451771f, 0.00388065f, 0.06951730f, 0.18635480f, 
    -0.09608909f, 0.06859802f, 0.09209657f, 0.05863073f, -0.07757547f, 0.03493083f, -0.10845618f, 0.10836438f, 
    0.01206073f, -0.11951735f, 0.11595096f, -0.12210731f, 0.19630097f, 0.29132909f, 0.41142198f, -0.43875429f, 
    -0.00942608f, 0.03124684f, -0.13119990f, 0.01319087f, 0.06837389f, 0.16213495f, 0.08853328f, 0.04312452f, 
    -0.19937517f, 0.02767706f, 0.12091978f, -0.15192328f, 0.01273378f, 0.01815173f, -0.02787408f, -0.20390306f, 
    0.00246104f, 0.07179993f, 0.11116187f, 0.01860959f, 0.01461057f, -0.25286609f, -0.04554209f, -0.24359359f, 
    -0.09973019f, -0.02723949f, -0.02030204f, 0.04150230f, -0.01647291f, -0.02254922f, -0.32701245f, -0.11984967f, 
    -0.39891163f, -0.43662047f, 0.54323912f, 0.32402596f, -0.04691044f, -0.00953403f, -0.05657034f, 0.17307650f, 
    0.15681528f, -0.03843151f, 0.11838220f, 0.20090120f, 0.05527934f, 0.00747455f, -0.21678720f, -0.03596406f, 
    0.16322258f, -0.06957020f, -0.04322648f, -0.01745956f, -0.01646424f, -0.01551905f, 0.16045879f, -0.16781428f, 
    0.56829274f, 0.34988984f, -0.20879766f, 0.21558063f, 0.15185063f, -0.16787089f, -0.08357479f, 0.04129430f, 
    0.24212050f, 0.07014938f, 0.20118788f, 0.02639896f, 0.08806376f, 0.26921007f, -0.00323522f, -0.29969501f, 
    0.08514629f, 0.12619549f, -0.14099263f, 0.07370874f, 0.00710364f, -0.02809739f, -0.10376260f, -0.13720559f, 
    -0.26085085f, -0.07497124f, -0.00950382f, -0.05478317f, 0.07473259f, 0.09348189f, 0.03738568f, 0.15523742f, 
    0.06781311f, -0.10232822f, -0.15177819f, -0.09308882f, -0.05840019f, -0.29157290f, -0.02524157f, 0.02040506f, 
    -0.09923744f, 0.00082509f, 0.08963674f, -0.03656575f, 0.06839659f, -0.07743969f, -0.01099584f, 0.07243757f, 
    -0.19269328f, 0.00170901f, 0.09704255f, 0.05333254f, 0.01044611f, -0.06863398f, 0.25417376f, -0.04094295f, 
    0.16348025f, 0.11584727f, 0.25358695f, 0.02753302f, -0.13461030f, 0.05490099f, 0.08119017f, 0.15733141f, 
    0.10877907f, 0.15036784f, -0.28574410f, 0.10448951f, 0.14696157f, -0.16229230f, 0.09357471f, -0.39457697f, 
    -0.29661915f, 0.00649183f, 0.21409351f, 0.28002924f, -0.06316271f, 0.15049858f, -0.05853255f, -0.02408781f, 
    -0.23884431f, -0.06911413f, 0.19990098f, -0.06713168f, -0.20095071f, -0.92533743f, -0.05857162f, -0.27376172f, 
    0.15370801f, -0.01267713f, 0.25748223f, 0.12840191f, 0.10777518f, 0.13500279f, -0.23682825f, 0.13225739f, 
    0.03914781f, -0.00066961f, 0.01962839f, 0.15389179f, 0.02478610f, -0.12032684f, -0.07329879f, -0.13868995f, 
    -0.29018167f, -0.02856553f, -0.29283714f, -0.44095245f, 0.07794809f, 0.08172403f, -0.15880576f, -0.10619969f, 
    -0.07097394f, 0.07400290f, 0.08319695f, -0.05731877f, 0.07211165f, 0.02016085f, 0.09571952f, 0.26508236f, 
    0.20408516f, 0.01552727f, -0.24603865f, 0.09961515f, -0.01630112f, 0.11035138f, 0.11357768f, -0.03441208f, 
    -0.00112182f, -0.05652072f, -0.09827770f, -0.06641041f, 0.12987156f, -0.27082473f, 0.09348426f, -0.04753519f, 
    0.06420055f, 0.12373632f, 0.01451002f, 0.07390117f, 0.04224207f, 0.05231598f, -0.01104423f, -0.09415308f, 
    0.22986582f, -0.01087119f, -0.16761273f, -0.15971431f, 0.02472113f, 0.05545425f, 0.13503173f, 0.01196625f, 
    -0.13510250f, -0.08384046f, 0.04342084f, 0.10990571f, -0.00927325f, -0.01146938f, -0.02440851f, 0.04511733f, 
    0.23351762f, -0.07000781f, -0.14579448f, -0.01291368f, -0.29758531f, -0.14089137f, -0.12766451f, -0.30982578f, 
    0.20932981f, -0.33935875f, 0.12048221f, 0.50280315f, -0.01210223f, 0.07431684f, 0.24502556f, -0.00542068f, 
    0.02972974f, 0.30593324f, 0.16504881f, 0.17298417f, 0.07823192f, 0.23302568f, 0.26727262f, -0.15271948f, 
    -0.08226343f, -0.09562502f, 0.09129126f, -0.02029600f, 0.05246506f, -0.16498923f, -0.08593027f, -0.10035829f, 
    -0.07969591f, 0.15484025f, 0.05002950f, 0.12918754f, -0.09478520f, 0.06993909f, 0.26731986f, -0.08812681f, 
    -0.20683709f, 0.00763059f, 0.25123340f, 0.14516623f, 0.33801770f, 0.17606552f, -0.06687769f, -0.25586191f, 
    0.08712199f, -0.11554738f, -0.09722598f, 0.06434281f, -0.08810542f, -0.14205192f, -0.18179724f, -0.10453620f, 
    0.19824381f, 0.02093952f, -0.06322124f, -0.02095018f, 0.30118570f, -0.02375312f, -0.11630005f, -0.10047479f, 
    0.07051592f, 0.00822740f, -0.16120143f, -0.01943576f, 0.41137737f, 0.20808972f, 0.17825465f, -0.24945763f, 
    0.10811312f, -0.04357386f, 0.03535148f, 0.06229035f, 0.07126291f, -0.08475190f, -0.09734540f, -0.10464498f, 
    0.17138916f, 0.01399619f, 0.20986907f, 0.06267243f, -0.00973825f, -0.07196558f, -0.11312882f, 0.04371131f, 
    0.05954866f, 0.11330550f, 0.12442180f, 0.06748821f, -0.16685468f, 0.13992399f, 0.22316821f, 0.09004219f, 
    0.12809941f, -0.19438660f, 0.08062940f, -0.01266729f, -0.10959342f, 0.00168873f, 0.11492795f, -0.01383082f, 
    0.11955094f, 0.31925786f, 0.09210792f, 0.25944707f, -0.04499856f, 0.02499053f, -0.15197127f, -0.02692165f, 
    -0.00531652f, 0.09095999f, 0.18830103f, -0.01776824f, -0.18529004f, 0.16818276f, 0.00939333f, 0.03392805f, 
    0.13925789f, -0.03772069f, 0.05510514f, 0.24235040f, 0.21899927f, 0.14519490f, 0.08229115f, 0.26001185f, 
    -0.02965504f, -0.25917560f, 0.01850114f, -0.12782827f, 0.21576817f, 0.11084291f, 0.05669243f, 0.05354930f, 
    0.07503299f, -0.14499779f, 0.03175337f, 0.00888733f, -0.02845283f, 0.29451346f, 0.31827614f, -0.20672438f, 
    -0.04939380f, -0.02487964f, 0.01944005f, -0.01996906f, 0.06228341f, -0.01142250f, 0.03537482f, 0.01272207f, 
    -0.30126837f, 0.06521244f, 0.06038184f, 0.01927552f, -0.07233869f, 0.12733980f, 0.00721903f, 0.14531372f, 
    0.12883233f, 0.09390946f, 0.08028028f, 0.11268776f, 0.13828753f, 0.66648942f, 0.51493019f, -0.38287428f, 
    -0.02434863f, -0.16246070f, -0.02793056f, -0.08618256f, 0.20890307f, 0.04332404f, 0.04369220f, 0.09606499f, 
    -0.21698299f, -0.10019322f, 0.14748152f, -0.18449999f, -0.12896489f, -0.03461106f, 0.20594022f, -0.10393815f, 
    -0.04535187f, 0.13750039f, 0.03737741f, -0.12773132f, -0.11530592f, -0.05116893f, -0.18409091f, -0.14144175f, 
    -0.00976717f, 0.04519925f, 0.12133558f, -0.01648935f, 0.01933038f, 0.04651698f, -0.07598803f, 0.00519445f, 
    -0.20945537f, 0.04145558f, 0.23473920f, 0.03088893f, -0.04672884f, -0.09239405f, -0.05959046f, 0.20897421f, 
    -0.01851393f, -0.01629715f, -0.02494035f, -0.01182560f, -0.29609314f, -0.40935317f, -0.56131941f, 0.06178061f, 
    0.15421268f, 0.22694024f, 0.18114732f, 0.04174426f, 0.03439152f, -0.03308403f, -0.00835490f, 0.01386979f, 
    0.55053312f, 0.10771430f, -0.29200968f, -0.06722031f, -0.01768087f, 0.06744115f, 0.03373745f, 0.01723301f, 
    0.15715075f, 0.04166467f, 0.00159008f, -0.08099642f, 0.12200058f, 0.34270510f, -0.12449833f, -0.08292565f, 
    0.02219694f, -0.17864025f, 0.08262218f, -0.01534267f, 0.10479324f, -0.05120576f, -0.04857415f, 0.00079824f, 
    -0.09472141f, -0.16934615f, -0.11857480f, 0.02586594f, 0.02184235f, 0.06539146f, -0.03843728f, -0.05382014f, 
    0.02369558f, 0.01438117f, -0.04099254f, -0.05330115f, -0.57057369f, -0.20447996f, -0.20791388f, 0.10066029f, 
    0.05661747f, 0.18579975f, 0.06518951f, -0.01828677f, 0.06272316f, 0.15254989f, 0.01334797f, -0.01479535f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.00367459f, -0.01250980f, 0.00630901f, -0.05185295f, -0.05965472f, 0.12090388f, 0.16566403f, -0.04815729f, 
    0.09040972f, 0.08133294f, -0.00409053f, -0.01765882f, 0.13476209f, 0.20796300f, 0.05285216f, -0.01204235f, 
    -0.08791585f, 0.05403544f, 0.17728305f, 0.02104892f, 0.20921998f, -0.02723537f, 0.04232700f, 0.12415266f, 
    -0.03496649f, 0.27468932f, 0.03673384f, 0.10935312f, -0.07673267f, 0.05447564f, 0.16568995f, -0.01458595f, 
    0.11632550f, 0.11927636f, -0.08858086f, -0.01782724f, 0.08852407f, -0.02447267f, -0.01483326f, 0.15559252f, 
    -0.00525032f, 0.07442057f, -0.03817405f, 0.00524570f, 0.27084514f, 0.02747340f, 0.03361496f, -0.04557649f, 
    0.14581583f, -0.07280710f, -0.04393049f, -0.07647626f, -0.07785036f, -0.07406816f, -0.04207943f, 0.12372965f, 
    0.04777185f, 0.12767534f, 0.03587487f, 0.13595256f, 0.17859735f, 0.23118332f, 0.00660522f, 0.19593254f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.20424174f, -0.34632140f, 0.11949251f, -0.33017549f, -0.12538055f, -0.32062787f, 0.13019954f, 0.00419904f, 
    -0.52383971f, -0.80349493f, 0.01566652f, -0.02702312f, 0.29694673f, -0.73744076f, -0.47797561f, 0.22885200f, 
    0.07446896f, 0.18429582f, -0.21367927f, -0.10106913f, -0.39621672f, 0.04148919f, -0.08114035f, -0.05924739f, 
    0.17516340f, -0.20167725f, -0.25412568f, -0.33551595f, 0.26948857f, 0.03498013f, -0.15541454f, 0.20785199f, 
    -0.11475882f, -0.30106151f, 0.24068187f, -0.06956519f, -0.10725607f, 0.13640772f, -0.22612520f, -0.17234519f, 
    -0.11484744f, 0.19028553f, 0.10016750f, 0.07180016f, -0.36889768f, -0.04444394f, 0.35465410f, -0.06816394f, 
    -0.60891408f, 0.06174473f, 0.09655305f, 0.05054965f, -0.52644002f, 0.00554808f, 0.04303591f, -0.23684691f, 
    0.02580733f, 0.16658460f, 0.06229835f, -0.02310079f, 0.01036522f, -0.53362775f, 0.64390033f, -0.40010113f, 
    0.42101145f, 0.20596211f, 0.03383555f, 0.04318284f, -0.11495322f, 0.05712701f, -0.16628101f, -0.02854493f, 
    0.21496470f, 0.18234305f, 0.32884556f, -0.02337482f, 0.32282674f, -0.37202385f, -0.78953964f, -0.66585094f, 
    -0.72999662f, -0.01094687f, 0.27745241f, -0.12671329f, -0.06604024f, -0.03799597f, 0.01994859f, 0.06132889f, 
    0.07821216f, -0.00064385f, -0.10743498f, 0.31536469f, 0.27957100f, 0.07694212f, -0.19802168f, -0.19252674f, 
    0.04028400f, 0.04757706f, -0.02504759f, -0.05541630f, 0.37808940f, -0.07354587f, -0.14859834f, -0.24003048f, 
    -0.03348803f, 0.28401139f, 0.00880962f, 0.09604622f, -0.01179333f, 0.00330634f, -0.63298422f, 0.27779192f, 
    -0.13368616f, -0.10089730f, -0.02696756f, -0.09102923f, -0.06905515f, 0.04188670f, 0.19580795f, 0.12232975f, 
    -0.37753412f, -0.14193359f, -0.35606834f, 0.11144387f, 0.21750234f, -0.06911607f, -0.43813881f, -0.08413608f, 
    0.47432619f, -0.55352378f, -0.03263708f, -0.13000076f, 0.10214731f, 0.23161778f, -0.17609194f, 0.06948759f, 
    -0.06210841f, 0.29807201f, -0.70307630f, 0.10154320f, 0.19740102f, 0.12371400f, 0.25308436f, 0.13901842f, 
    -0.41600502f, -0.08112938f, -0.40638545f, 0.11391256f, -0.04295394f, -0.08672642f, -0.51644135f, -0.00902660f, 
    0.15207794f, 0.17336465f, -0.06456366f, 0.10567486f, 0.05516722f, 0.06847066f, 0.11829873f, -0.32787937f, 
    0.05725928f, -0.40287119f, -0.17701121f, -0.08748963f, -0.68919522f, -0.30200183f, 0.08382510f, 0.06681773f, 
    0.05891757f, 0.21712954f, -0.08122384f, 0.06707821f, -0.08503591f, -0.12212697f, 0.38118169f, -0.05283298f, 
    0.14372917f, -0.01367691f, 0.01380996f, -0.05926308f, -0.29996106f, 0.07636660f, -0.70184773f, -0.01021753f, 
    -0.19924287f, -0.04864859f, 0.26684788f, 0.07071973f, -0.17282215f, 0.23522483f, -0.39828357f, 0.08554386f, 
    0.30204895f, -0.20518160f, -0.08969461f, 0.32841918f, 0.06159988f, -0.08039714f, -0.00799670f, 0.02705646f, 
    0.05715270f, 0.08502575f, -0.23153226f, 0.03422325f, -0.14849272f, -0.08351970f, 0.38650087f, 0.10722434f, 
    0.59170687f, 0.12458690f, 0.10065237f, 0.00523693f, -0.26706618f, 0.07516047f, 0.17111972f, 0.16228668f, 
    -0.23889986f, -0.38275120f, 0.11359169f, -0.03193001f, 0.04446696f, -0.08884213f, -0.39036769f, -0.03259534f, 
    -0.30833328f, -0.25933474f, 0.08151806f, -0.02847351f, -0.03328758f, -0.20508267f, 0.44674239f, -0.01220948f, 
    0.08600478f, -0.06810370f, 0.04146553f, 0.10271133f, -0.46317023f, -0.13180560f, -0.13046472f, 0.00481675f, 
    0.06638766f, -0.07458115f, -0.00181479f, -0.02652992f, 0.40326136f, 0.05876603f, 0.04967822f, 0.13122106f, 
    0.32674691f, -0.40685681f, -0.16404232f, -0.50315821f, -0.19040768f, -0.48070678f, -0.48128593f, -0.18634577f, 
    -0.19468929f, 0.19723479f, -0.04255043f, -0.45831573f, -0.11887880f, -0.00346009f, -0.34220520f, 0.11474483f, 
    -0.14368939f, 0.15481217f, -0.01745963f, -0.08736697f, -0.68254387f, 0.11917704f, 0.04957774f, 0.13199434f, 
    -0.19740631f, 0.07608227f, 0.02839311f, 0.03047505f, -0.58143544f, -0.10409427f, -0.53983235f, -0.01164250f, 
    0.07378589f, -0.10289966f, 0.20439653f, -0.22752906f, 0.16106872f, 0.11722565f, 0.04802144f, 0.27427316f, 
    -0.02238542f, 0.09024239f, -0.03093911f, 0.08932788f, -0.16796008f, 0.05189817f, 0.06557506f, -0.43737185f, 
    -0.08228136f, -0.13952710f, 0.15748999f, 0.12927227f, -0.28161183f, -0.07550925f, 0.11240225f, 0.28304461f, 
    -0.11385372f, -0.02260238f, 0.10247461f, -0.10132515f, -0.33294576f, 0.07713145f, 0.14052840f, -0.17528057f, 
    -0.07561595f, 0.21261393f, 0.37596825f, -0.00561146f, -0.18112767f, 0.08195128f, 0.20669465f, -0.14152478f, 
    -0.83763963f, 0.12530118f, -0.04946912f, -0.20748289f, 0.09054576f, -0.27628347f, 0.02560865f, -0.09350999f, 
    -0.22471654f, -0.37655628f, -0.24590181f, 0.02194470f, -0.01386924f, 0.03221264f, -0.24647988f, -0.13138369f, 
    -0.36624950f, 0.07749539f, 0.07815576f, -0.00003675f, 0.32216287f, -0.12507284f, -0.28045544f, 0.18260486f, 
    -0.11454856f, -0.16021883f, -0.03096473f, -0.26999900f, -0.31654230f, -0.06491136f, 0.18070827f, 0.19487543f, 
    0.11506021f, 0.37903109f, 0.11550813f, 0.07194433f, -0.03795517f, 0.05607836f, -0.49038556f, 0.31584048f, 
    -0.09561291f, 0.05590459f, -0.11574853f, 0.00587879f, -0.01163008f, 0.00032057f, 0.03189133f, -0.24218889f, 
    -0.23276857f, -0.04290351f, 0.10234359f, -0.06562631f, -0.01948356f, -0.05210745f, 0.24326843f, 0.25478131f, 
    -0.08703234f, 0.23228240f, -0.26810536f, -0.11508335f, 0.12302989f, 0.16653430f, -0.32685465f, 0.08387517f, 
    -0.38025513f, -0.40155274f, 0.10546368f, 0.16805536f, 0.10853955f, 0.03980238f, 0.03087019f, -0.08011538f, 
    0.04335517f, 0.12952726f, 0.32368484f, 0.10746126f, -0.44890761f, -0.21206984f, 0.13790733f, 0.21238081f, 
    -0.18554106f, -0.76279032f, -0.04292486f, 0.07473454f, 0.04780068f, 0.05831545f, -0.32308242f, -0.50328404f, 
    -0.00163789f, 0.00336326f, -0.31054237f, 0.11223091f, -0.57030839f, 0.11153442f, 0.17023624f, 0.13756126f, 
    0.01482454f, 0.21655689f, -0.45331818f, 0.08447777f, -0.25696358f, -0.22946277f, 0.18762191f, 0.09135190f, 
    -0.02056028f, 0.24254362f, -0.12847663f, -0.39399931f, 0.18346578f, 0.06856389f, -0.91005766f, -0.62641174f, 
    0.18851660f, -0.03062264f, 0.03163585f, -0.01692405f, 0.27472025f, -0.01031022f, -0.40762648f, -0.39560336f, 
    0.07889295f, 0.15437506f, 0.25426221f, -0.16322207f, -0.46599329f, 0.24232510f, 0.10876059f, 0.31247902f, 
    0.19421721f, 0.16597600f, 0.01562726f, 0.03632136f, 0.04534246f, -0.41619834f, -0.55256712f, 0.07623646f, 
    0.06437864f, 0.02979560f, 0.00467591f, -0.12589122f, 0.27526161f, -0.02138268f, 0.24916065f, 0.38577327f, 
    0.20023364f, -0.35134855f, -0.19355685f, -0.00158826f, -0.06919152f, 0.10603268f, 0.34151590f, -0.05407325f, 
    -0.21380635f, 0.03179266f, -0.04787934f, 0.08585453f, -0.27243567f, -0.08375326f, 0.05439116f, -0.31633949f, 
    0.23791955f, -0.18593352f, 0.04119399f, -0.08215208f, -0.07093702f, -0.18786511f, 0.20369980f, -0.07615462f, 
    -0.09288347f, -0.05208544f, 0.23778298f, -0.77257550f, -0.27889508f, 0.00682792f, 0.64976102f, -0.23348218f, 
    0.07239852f, 0.11708996f, -0.03943567f, -0.01246809f, 0.08374445f, 0.01297370f, -0.34392542f, -0.00009562f, 
    -0.13906099f, -0.00088610f, -0.44443762f, -0.11664144f, -0.10894293f, -0.49734646f, -0.20935304f, 0.00984813f, 
    -0.08991348f, -0.21679716f, -0.11394997f, -0.05191172f, 0.04790192f, 0.30237389f, 0.07260724f, -0.09339565f, 
    0.30396903f, -0.11319371f, -0.21760486f, -0.00351032f, 0.40563762f, -0.13823706f, -0.40868527f, -0.25160956f, 
    0.54117572f, -0.60126185f, -0.18653555f, 0.01003105f, 0.25614005f, -0.06701956f, 0.16341038f, 0.35677177f, 
    -0.19287755f, 0.09243319f, 0.18739185f, 0.15531845f, -0.39359248f, -0.02778184f, 0.06173471f, -0.87917227f, 
    0.06412820f, -0.60917693f, -0.00159224f, 0.06215847f, -0.15452020f, -0.07547323f, -0.08684148f, 0.19386505f, 
    0.00322278f, -0.23264669f, 0.19873494f, -0.57074612f, 0.04526566f, -0.08260849f, -0.17925926f, -0.40515757f, 
    -0.20735210f, -0.10959242f, -0.08831860f, 0.09411591f, -0.19182789f, 0.03086409f, 0.02277824f, 0.29917091f, 
    -0.49253327f, 0.09034359f, -0.38126442f, -0.23695467f, 0.14609386f, -0.13909616f, 0.09188890f, -0.16118903f, 
    -0.19904785f, -0.20352101f, -0.01481612f, -0.38331383f, -0.11509574f, 0.05463307f, 0.29705194f, 0.05106902f, 
    -0.53072917f, -0.38729325f, 0.03254385f, -0.05959547f, 0.11562204f, 0.12327967f, 0.14074521f, -0.10865526f, 
    -0.41374147f, -0.41628140f, -0.02433591f, 0.03685892f, -0.00443740f, 0.00989080f, 0.62561399f, -0.43646678f, 
    -0.11013827f, -0.03205098f, 0.09037349f, -0.31126565f, -0.04502865f, -0.05942958f, 0.03100484f, 0.11444573f, 
    0.11268855f, 0.12921330f, -0.31321788f, 0.00605605f, 0.18382654f, -0.07871579f, -0.09464607f, -0.51710355f, 
    -0.00563816f, -0.11298918f, 0.09753133f, -0.13983469f, 0.12118580f, 0.09071236f, 0.28194284f, 0.43472174f, 
    0.27409786f, -0.03518322f, -0.07527215f, 0.11015091f, -0.40964621f, 0.09051930f, 0.08096000f, -0.49862343f, 
    0.39206240f, -0.13602693f, 0.19583455f, -0.36104590f, -0.03175107f, 0.26529106f, 0.30100816f, 0.22238331f, 
    -0.12104855f, -0.25834128f, 0.06067577f, 0.42675048f, -0.05770731f, 0.07266418f, 0.39104834f, 0.09111704f, 
    -0.20441748f, 0.31814322f, -0.08749864f, -0.07911109f, -0.38770917f, -0.08480415f, -0.06937703f, -0.62915224f, 
    0.03586856f, -0.07406683f, -0.08468623f, 0.01734753f, -0.06736223f, 0.06338945f, -0.19166803f, -0.19619097f, 
    -0.58733243f, 0.21509671f, 0.33369127f, 0.21083978f, 0.00815515f, 0.01980705f, -0.43478495f, -0.21298325f, 
    -0.57445532f, 0.10936451f, 0.20503560f, -0.01767460f, -0.22321427f, 0.21227524f, -0.26083142f, 0.49720523f, 
    0.01188434f, -0.34072402f, -0.42468289f, 0.21455376f, 0.15212616f, -0.00941935f, -0.53273815f, -0.71740919f, 
    0.16110383f, -0.12472232f, -0.03024951f, 0.00268833f, -0.32390320f, 0.09658694f, -0.21637733f, -0.01005066f, 
    -0.70299006f, -0.09868016f, -0.06474687f, 0.17497940f, 0.20752205f, -0.60284376f, -0.33388090f, 0.12186138f, 
    0.24677533f, -0.09596863f, 0.07003457f, 0.23222233f, -0.06814479f, 0.26474220f, 0.06707977f, 0.00572737f, 
    0.21377327f, -0.03507014f, -0.08191827f, 0.09909955f, -0.39661428f, 0.31747007f, -0.68250889f, -0.04931809f, 
    0.27008671f, -0.23382361f, -0.05432291f, 0.10115786f, 0.28636238f, 0.03106491f, -0.45666349f, -0.44486946f, 
    0.06651095f, 0.13614032f, -0.68262523f, 0.11186703f, -0.54318362f, 0.08850992f, 0.20923720f, -0.05010526f, 
    -0.17884187f, 0.27065310f, -0.35200092f, -0.09127451f, -0.20141819f, 0.33367774f, 0.11299856f, -0.17282732f, 
    -0.00168194f, -0.55877459f, -0.33664140f, 0.23525953f, -0.10791709f, 0.10410988f, -0.28110680f, -0.39982486f, 
    0.15119009f, 0.04982640f, 0.00813521f, -0.03533301f, 0.37869364f, 0.02491226f, -0.31482950f, 0.11945892f, 
    -0.09742510f, -0.44228339f, -0.32837999f, 0.40649733f, -0.02431074f, 0.05388032f, 0.43632501f, -0.21077116f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.13344134f, 0.10668928f, 0.08918586f, -0.20638148f, -0.01568492f, -0.00200288f, 0.04609954f, -0.12737994f, 
    0.01082850f, -0.01528344f, 0.10908288f, -0.06707279f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
