#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -1.35562730f, 1.21083641f, -0.54814106f, -0.26069483f, -0.14828354f, 0.65637600f, 0.13855335f, -0.06354247f, 
    -0.01718199f, 0.72771680f, 0.71471167f, 1.24958038f, 0.12153017f, -0.66245604f, 0.45990539f, 0.75653511f, 
    0.23469929f, -0.21265347f, -1.17813706f, -1.03096414f, -0.77490181f, 1.18085456f, 1.26012671f, 0.58773464f, 
    -0.05002977f, -0.06449409f, -0.13413118f, 1.07844996f, 0.55276942f, 0.86408502f, 0.20637476f, 0.25411895f, 
    -0.38202149f, -0.37796324f, -0.18763827f, 0.10283136f, 0.65994066f, -0.73552155f, -0.32469726f, -0.67550665f, 
    -1.63177466f, -1.39730489f, -0.14796335f, 0.37169400f, 0.03924068f, 1.33975708f, -0.06604778f, -1.24264896f, 
    0.10328174f, 0.79598010f, -0.14298350f, 0.20343192f, -0.51385099f, 0.23353601f, 0.83276320f, -0.59258378f, 
    0.19097741f, 0.83551371f, -0.53325033f, 0.23411687f, -0.11663218f, 0.51180607f, 0.80058759f, 0.91829312f, 
    -0.62766415f, 0.99062973f, 0.69149917f, 0.22295234f, 0.84732461f, -0.61634523f, -0.52347207f, -0.60930330f, 
    -0.61793625f, -0.70086461f, -0.97405118f, -0.94893652f, 0.63956970f, 1.22869265f, 0.19946666f, -0.19513993f, 
    0.19571075f, 0.73390198f, 0.25304341f, 0.48925668f, 1.06329346f, 0.60385281f, 0.15570091f, 0.49891952f, 
    0.77332443f, 0.35795483f, -1.29208815f, 1.01436961f, 0.57097757f, 0.22802135f, 0.82089323f, -0.87836999f, 
    -0.24489228f, -0.05491953f, -0.29688677f, 0.89484364f, 0.78217411f, 0.17989928f, -1.38773227f, 0.45949021f, 
    -1.03364396f, 0.49374974f, 0.22860201f, 0.10846642f, -0.17480356f, -0.61135042f, 1.06403494f, 1.28701484f, 
    0.10851387f, 0.51595235f, 0.60421944f, -0.35325360f, 0.69419211f, 1.09677672f, 0.90559804f, 0.73296273f, 
    0.49172863f, -0.05586604f, 0.24516732f, -0.06839518f, 0.11546619f, 0.51682210f, 1.08132482f, 0.94130784f, 
    0.81190324f, -0.83712000f, -0.58894318f, 0.31185108f, 0.05297744f, 0.29684079f, -0.17926410f, -0.90734136f, 
    -1.04688597f, -0.44785702f, -1.09218752f, 0.22575359f, -0.93523455f, 0.20144004f, 0.47134888f, -0.28188536f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.20674974f, 0.03624531f, 0.24860583f, 0.09833207f, 0.35974893f, 0.17653559f, 0.07977899f, 0.16698387f, 
    0.23575538f, -0.20883679f, 0.14698628f, 0.38117406f, -0.10519262f, 0.75140864f, 0.24852854f, 0.07403293f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.03140439f, 0.03764007f, 0.01791423f, 0.03453818f, 0.03837838f, -0.05073819f, 0.07647909f, 0.03459598f, 
    -0.05647684f, -0.02835943f, -0.06335050f, -0.04747263f, -0.06440447f, 0.01606933f, -0.01352805f, 0.04293970f, 
    -0.05791438f, -0.02963799f, 0.04125948f, -0.00666151f, -0.07607647f, -0.01044401f, -0.03737116f, 0.01947515f, 
    0.04101004f, 0.00450239f, 0.01266578f, 0.04299861f, -0.04057117f, -0.04671379f, 0.01750523f, 0.05666185f, 
    -0.06321928f, -0.04865933f, -0.07038316f, -0.07301137f, 0.01099622f, -0.03948014f, 0.00724430f, -0.03647705f, 
    0.04134116f, -0.08160631f, 0.06935883f, 0.00319822f, -0.08991215f, -0.08040361f, -0.01034087f, -0.08514263f, 
    0.06550600f, 0.01608004f, -0.06145390f, 0.03762529f, -0.05877826f, -0.04272738f, 0.06136122f, -0.04555535f, 
    -0.03862751f, 0.05624201f, -0.01105280f, 0.02489751f, 0.00035512f, 0.06901837f, -0.04827901f, -0.06130776f, 
    -0.06853049f, -0.07971887f, -0.02497717f, -0.02189051f, -0.05265863f, -0.02522430f, -0.02785503f, 0.06741677f, 
    -0.01617266f, -0.04936282f, -0.08662716f, -0.07584514f, -0.08475023f, -0.03140879f, 0.04564374f, 0.00348731f, 
    0.00730491f, 0.01491254f, -0.04433791f, 0.02740330f, 0.01717024f, 0.03064953f, -0.05302905f, -0.00545128f, 
    0.06230823f, -0.08127807f, 0.03850853f, 0.01040804f, -0.00747425f, -0.01035378f, -0.08243056f, -0.01327384f, 
    0.05776723f, -0.07045613f, 0.04071666f, 0.02945875f, -0.07907850f, -0.04531693f, -0.04612766f, -0.07397322f, 
    0.04198930f, -0.04602837f, 0.02788071f, 0.07134210f, 0.02522482f, 0.01945907f, 0.01307133f, 0.02957526f, 
    -0.08445939f, -0.05462734f, -0.01804431f, 0.03368197f, 0.06740189f, -0.06268562f, -0.06937827f, -0.03104632f, 
    0.07161466f, 0.01960430f, 0.02108519f, -0.02142708f, -0.04444557f, -0.02683141f, -0.09345930f, 0.01237329f, 
    0.06619835f, -0.07317137f, 0.05625033f, -0.02354444f, -0.07913436f, 0.06052188f, -0.03004147f, 0.05245449f, 
    -0.03536390f, 0.06873437f, -0.04293524f, 0.05951020f, 0.03782291f, -0.08380401f, 0.02340006f, -0.01632428f, 
    -0.08406751f, 0.04421937f, -0.00596391f, -0.09783871f, 0.06796752f, -0.03475269f, -0.02057999f, 0.04597511f, 
    -0.06889661f, 0.01633351f, -0.04791351f, -0.03151972f, 0.01812559f, -0.04234745f, 0.02077045f, -0.05086959f, 
    -0.02837102f, -0.04330346f, -0.07236317f, -0.09641334f, -0.09435478f, -0.00044949f, 0.03227155f, -0.01749565f, 
    -0.08303145f, 0.02824754f, 0.04904686f, 0.06675441f, 0.04834818f, 0.01473841f, -0.02080482f, -0.05895399f, 
    -0.01522360f, -0.07358016f, -0.07405229f, -0.08350337f, -0.04966896f, 0.05115663f, 0.05175977f, 0.05129968f, 
    -0.02089538f, -0.09717285f, 0.01472987f, 0.05155115f, 0.00241849f, -0.00626033f, -0.06252898f, 0.00190043f, 
    0.07623710f, -0.03802267f, -0.09393125f, 0.01919727f, -0.01253060f, 0.04311383f, 0.06548704f, 0.00366607f, 
    -0.04249051f, -0.04575340f, -0.04988479f, 0.02921022f, -0.04914273f, 0.03005062f, -0.05263449f, 0.00555195f, 
    -0.00595340f, 0.00361898f, -0.06624895f, -0.00786714f, 0.04926278f, 0.02157307f, -0.04628639f, -0.06062926f, 
    0.01495799f, 0.05323502f, -0.05579242f, -0.05008233f, 0.03877396f, -0.06077186f, -0.05256774f, -0.04223379f, 
    -0.06288270f, -0.00246215f, -0.08790530f, -0.01416678f, -0.05575718f, -0.06792736f, -0.07113259f, 0.02709647f, 
    0.05529835f, 0.00718292f, 0.01317740f, 0.03436913f, -0.08103900f, -0.00862448f, -0.04001769f, -0.01941729f, 
    0.01239194f, -0.09384089f, -0.05659705f, 0.02957552f, -0.01891368f, -0.02746290f, 0.06786699f, 0.03215545f, 
    0.05014880f, 0.03300245f, 0.04111392f, 0.01423042f, -0.02798991f, -0.02097553f, 0.00637178f, -0.00023039f, 
    0.04385291f, -0.07220820f, 0.03339017f, 0.05674369f, 0.04514122f, -0.04900399f, -0.01372818f, -0.09047697f, 
    0.04085622f, -0.02825760f, -0.08003668f, -0.07919934f, 0.02505180f, -0.02380227f, -0.02775815f, 0.06070580f, 
    -0.05143790f, -0.08593259f, 0.02091097f, 0.05280760f, -0.05655177f, -0.03389214f, 0.02438588f, -0.08738449f, 
    0.02122059f, 0.03419754f, 0.06204994f, 0.01784321f, -0.06076641f, 0.04482329f, -0.05841971f, -0.03310908f, 
    -0.62449557f, -0.19599381f, -0.03592131f, -0.24400395f, -0.24772030f, -0.24114369f, -0.00383355f, 0.04835068f, 
    -0.14077117f, 0.73961467f, -0.05012308f, 0.18553843f, 0.13899314f, -0.01973834f, 0.19097696f, 0.21005304f, 
    0.02078787f, -0.01095112f, -0.46827427f, 0.30066511f, -0.53437644f, -0.17263834f, 0.19202349f, -0.04909395f, 
    0.02759894f, 0.08035246f, -0.15125901f, 0.22269489f, 0.11415253f, -0.02146772f, 0.06014781f, 0.23995471f, 
    0.18889707f, -0.09420256f, 0.01067249f, -0.01605768f, -0.11390013f, -0.05738016f, -0.46914881f, 0.10433506f, 
    -0.07893496f, -0.01148414f, 0.10441344f, -0.05615129f, 0.08215754f, -0.30819860f, -0.14920956f, 0.38456607f, 
    0.00561874f, 0.05842392f, -0.16666682f, -0.14365764f, 0.00684441f, 0.09073946f, 0.25559694f, -0.03079719f, 
    0.13504416f, 0.14409575f, -0.05580930f, -0.04262722f, 0.10076065f, 0.02846404f, 0.08436467f, -0.13368088f, 
    -0.12353757f, 0.23993440f, -0.06149865f, -0.03278677f, 0.10302794f, -0.00273232f, -0.04961892f, 0.12606582f, 
    -0.42813542f, 0.39026132f, -0.33963516f, 0.09912614f, 0.22025008f, -0.03394552f, -0.00612178f, 0.13735400f, 
    -0.04905653f, -0.31105676f, -0.35506755f, 0.18468381f, -0.05502212f, 0.28785649f, -0.04899480f, 0.07921896f, 
    -0.09903633f, -0.10661700f, -0.62510335f, -0.19857858f, -0.00913913f, -0.09340015f, -0.08832616f, -0.10059290f, 
    -0.01709688f, -0.09884434f, -0.01264792f, 0.67850459f, 0.07758265f, -0.07843366f, 0.06817330f, 0.02998388f, 
    -0.10806701f, 0.05179043f, -0.24911882f, 0.21765421f, -0.91909635f, -0.03310160f, 0.25697270f, -0.00068875f, 
    0.14930619f, -0.03271814f, 0.15649824f, 0.03739328f, -0.04521351f, 0.69515640f, -0.11985518f, 0.08503854f, 
    0.07366196f, 0.11787966f, -0.01796492f, 0.02682345f, 0.00441284f, 0.04627478f, 0.78230196f, 0.17848976f, 
    -0.10292365f, -0.08093683f, -0.17222346f, 0.12114022f, 0.11634462f, -0.07415061f, 0.04200632f, -0.04494211f, 
    -0.08802139f, -0.25460857f, 0.00314794f, 0.30114067f, 0.22168505f, 0.11139338f, 0.21470936f, -0.29390529f, 
    0.26517701f, -0.34748825f, -0.05908909f, -0.12646839f, -0.31175631f, 0.19509822f, 0.19531891f, -0.35809773f, 
    -0.21445180f, 0.10334136f, 0.01069093f, -0.30742535f, -0.11538940f, -0.24360467f, 0.47733808f, 0.03343987f, 
    0.05590552f, 0.20269737f, 0.33001101f, 0.29217419f, -0.11316712f, 0.35906804f, 0.35234407f, 0.24709827f, 
    0.07035120f, -0.13588731f, 0.03735532f, 0.36077702f, 0.15536596f, 0.12321458f, -0.02903798f, 0.10765092f, 
    -0.17691211f, 0.20003434f, 0.22228891f, 0.06717407f, 0.14341465f, -0.06688831f, 0.39284560f, -0.02742330f, 
    0.13571504f, -0.05693406f, 0.03329942f, 0.11221351f, 0.16586803f, -0.33633316f, -0.30554008f, 0.06476238f, 
    -0.20914574f, 0.06348739f, 0.08224510f, -0.22878315f, 0.08971105f, 0.33797246f, 0.06553005f, -0.30323529f, 
    -0.48529041f, -0.10438215f, -0.01210606f, 0.04313492f, 0.04932433f, 0.06610168f, -0.14601080f, 0.70137435f, 
    0.24541759f, -0.32239085f, -0.46990299f, 0.02842618f, -0.13420321f, 0.17295474f, -0.28302005f, 0.22593984f, 
    -0.52321166f, 0.51033485f, -0.42104766f, -0.07578801f, 0.12765306f, 0.10586385f, 0.07687045f, -0.20075150f, 
    0.35808036f, -0.32275328f, 0.21204019f, -0.20242400f, 0.35875037f, 0.11627746f, 0.31622785f, -0.04052442f, 
    0.21631734f, -0.01370689f, 0.04399642f, -0.23465252f, 0.61398602f, -0.05795466f, 0.06932084f, -0.10996395f, 
    -0.08986443f, 0.14775008f, 0.27566639f, -0.26488623f, 0.08148883f, 0.19133145f, 0.12790060f, -0.08015307f, 
    -0.13144787f, -0.17925054f, -0.13714696f, 0.03760156f, -0.30302995f, -0.10747468f, -0.11797324f, 0.21367416f, 
    0.45688999f, -0.17352483f, -0.49602056f, -0.07489433f, -0.20860034f, 0.08372768f, 0.15275742f, 0.25057638f, 
    0.03844927f, 0.06781307f, 0.15478301f, 0.15602015f, -0.11197869f, -0.17017680f, 0.05837738f, 0.03150637f, 
    0.17154181f, -0.16894871f, -0.16815864f, -0.19923559f, -0.10168043f, 0.16069636f, 0.00873573f, -1.05348957f, 
    -0.55650169f, -0.30018139f, 0.17162129f, 0.23303294f, -0.08481606f, 0.19155538f, 0.32220697f, -0.26027939f, 
    0.03000568f, 0.01502504f, -0.10095300f, -0.08665681f, 0.04119309f, -0.11637869f, 0.02616476f, -0.00606525f, 
    0.02991308f, 0.00070830f, -0.06345879f, -0.11165942f, 0.02954571f, 0.07001058f, 0.05960328f, -0.05709873f, 
    -0.08093016f, 0.04802809f, -0.06814700f, 0.03184757f, 0.06615758f, 0.00359162f, 0.04521511f, 0.02061117f, 
    -0.09056219f, -0.02968942f, -0.08197787f, 0.06648714f, -0.02662533f, -0.01810020f, -0.00796250f, -0.06088200f, 
    0.02322188f, -0.13349493f, -0.05169213f, 0.02404079f, -0.03804218f, 0.01687384f, 0.06047333f, -0.04570986f, 
    -0.09194324f, -0.05557151f, -0.01462039f, -0.00731721f, 0.05207359f, 0.02152169f, 0.04470465f, 0.00017680f, 
    0.04023144f, -0.00253805f, 0.05587610f, -0.03782677f, -0.02508592f, -0.06742655f, 0.04046449f, -0.05336082f, 
    -0.08514068f, -0.04443078f, 0.01973568f, -0.08783575f, -0.04212251f, -0.08484884f, -0.01044191f, 0.04804113f, 
    -0.07085072f, 0.03743344f, -0.11378844f, 0.07973830f, -0.06724663f, 0.01879922f, 0.02386619f, -0.05976942f, 
    0.00460878f, -0.06601328f, 0.00548361f, -0.04236059f, 0.01721296f, 0.02013676f, -0.04125851f, 0.06064134f, 
    0.00520309f, -0.03825359f, -0.04657278f, 0.02040483f, -0.05550404f, 0.04719619f, -0.08495837f, -0.00833749f, 
    -0.11725055f, -0.00197795f, 0.02333864f, -0.10365320f, 0.04544031f, 0.02241525f, -0.03589267f, -0.03575522f, 
    0.01166624f, 0.03442462f, -0.01182535f, -0.04314158f, 0.06747449f, -0.09405286f, -0.01069363f, 0.04116447f, 
    0.03771687f, -0.03423377f, -0.10470951f, -0.05670338f, 0.08440825f, -0.06945369f, -0.05160642f, -0.10821253f, 
    0.04919821f, 0.06821664f, -0.03015941f, -0.09288315f, -0.05311158f, -0.06238125f, -0.06290726f, -0.12705731f, 
    -0.02196826f, -0.04703753f, 0.05893737f, 0.00323100f, -0.07658622f, -0.04594026f, 0.05433876f, -0.00505195f, 
    -0.05332092f, -0.10244787f, -0.06662019f, 0.01947054f, 0.03070260f, 0.00096568f, -0.09250878f, 0.03432711f, 
    0.03621915f, -0.03093517f, -0.06774905f, -0.09199144f, -0.05362344f, 0.05722643f, -0.05090728f, 0.02445627f, 
    0.05019912f, -0.05285204f, -0.09377207f, -0.04514863f, -0.05424709f, -0.06399646f, -0.02759398f, -0.03867493f, 
    -0.07763600f, 0.03234582f, -0.02748905f, 0.04862113f, -0.08926704f, -0.00504426f, -0.06824282f, -0.09742288f, 
    0.02531260f, -0.01396660f, -0.01062369f, -0.03718229f, -0.02287625f, -0.04195644f, -0.08582263f, 0.03022707f, 
    -0.04654553f, -0.09193262f, -0.06677838f, -0.13595486f, -0.00068835f, -0.06010753f, -0.03627129f, -0.04674879f, 
    -0.06190930f, 0.01387762f, -0.02654109f, -0.07667919f, 0.02295342f, -0.02303914f, -0.09598380f, 0.00037514f, 
    0.00672004f, 0.01838537f, 0.01946457f, -0.07178222f, -0.10787451f, -0.05066774f, -0.10499940f, -0.02097359f, 
    -0.07390509f, -0.08224579f, 0.02818806f, -0.02712216f, -0.00723528f, 0.05682339f, -0.11281369f, 0.03833159f, 
    0.01724060f, -0.08331130f, 0.04626989f, 0.03569988f, 0.01051280f, 0.02131842f, 0.02421561f, 0.01581438f, 
    -0.08233598f, 0.03165588f, 0.02822769f, 0.03160545f, 0.03758045f, 0.03005800f, 0.00778126f, -0.06837087f, 
    0.01424526f, -0.01074088f, -0.11525594f, -0.06118515f, -0.08712599f, -0.05185341f, 0.06940701f, -0.09459634f, 
    -0.10969548f, -0.01375473f, -0.02326397f, -0.03919991f, -0.10009144f, -0.04533755f, 0.00516226f, 0.04835098f, 
    0.07967997f, -0.06567469f, -0.01368630f, -0.01314878f, 0.04461173f, 0.02608417f, 0.04413475f, 0.04302501f, 
    -0.01948512f, 0.04861644f, -0.09132998f, -0.06547127f, -0.06575926f, -0.01192212f, -0.06826330f, -0.05415218f, 
    -0.10650516f, 0.03040348f, 0.00706765f, -0.06559536f, 0.05385062f, 0.00971737f, -0.05393325f, -0.04457322f, 
    -0.01911800f, -0.11115585f, -0.04632002f, 0.02278104f, 0.03142976f, -0.11133747f, -0.08323019f, -0.09857419f, 
    0.04431791f, -0.08574104f, 0.00751922f, 0.00283849f, -0.02325228f, 0.02085887f, -0.06921367f, -0.04120581f, 
    0.03767898f, -0.00892261f, -0.03547817f, -0.04343341f, -0.13513954f, -0.02296608f, -0.03441034f, -0.01124925f, 
    0.06008400f, -0.00911957f, -0.02815273f, -0.00767020f, -0.07361493f, -0.04430843f, 0.04898267f, -0.04274236f, 
    0.06523670f, -0.08130177f, -0.09630050f, 0.03461580f, -0.00773090f, 0.04299140f, 0.01115521f, 0.04906166f, 
    -0.03311983f, 0.00132225f, 0.04416809f, 0.02686737f, -0.02557123f, -0.02448640f, -0.07062654f, 0.01305658f, 
    0.07454822f, -0.08536173f, -0.04142840f, -0.01713857f, -0.09608012f, -0.07620325f, 0.00895905f, -0.06730308f, 
    0.05196289f, 0.01441450f, 0.02384058f, 0.01790844f, 0.00554072f, -0.04657626f, 0.01548212f, -0.06916122f, 
    0.06384819f, 0.04261063f, -0.06003950f, -0.07426330f, -0.00642932f, -0.08933806f, -0.06199703f, -0.02699980f, 
    0.00609212f, 0.06863552f, -0.00989875f, 0.03989881f, -0.06436921f, 0.04648393f, 0.02376732f, 0.03471467f, 
    -0.07766157f, -0.09644794f, 0.01190870f, 0.03329345f, 0.03430190f, -0.08281125f, -0.01147013f, 0.04310456f, 
    -0.06314387f, 0.04501044f, 0.01228090f, 0.02469214f, -0.02046828f, 0.07572543f, -0.06743684f, -0.07183343f, 
    -0.06721278f, -0.03191322f, -0.07893431f, -0.00112181f, 0.03527553f, -0.03752999f, 0.05948195f, -0.07921599f, 
    0.00528597f, -0.08033422f, -0.03663158f, 0.01568309f, 0.05501122f, -0.04249430f, -0.00843730f, -0.02551562f, 
    -0.01553919f, -0.07311700f, -0.05163196f, 0.03683415f, -0.04816604f, -0.07968790f, 0.06976065f, 0.05456739f, 
    -0.00656253f, -0.03824987f, -0.09533967f, -0.06848396f, -0.08350409f, -0.07997477f, -0.01804034f, 0.00378515f, 
    0.02601045f, 0.03706514f, -0.01874976f, -0.03631499f, 0.03555068f, 0.02453401f, -0.09392948f, -0.03493831f, 
    -0.03407032f, 0.03937944f, -0.02546075f, -0.03503086f, -0.07034682f, -0.06385270f, 0.02392104f, 0.02708502f, 
    0.05165306f, -0.05046627f, -0.07439134f, 0.02850658f, -0.04804232f, 0.05603234f, -0.03405508f, 0.03780439f, 
    -0.07842606f, 0.03181880f, 0.07297205f, 0.02298690f, 0.05057541f, 0.00735897f, -0.02328983f, -0.05134548f, 
    0.00969078f, -0.01217311f, 0.07459290f, 0.03785477f, 0.03733802f, -0.06928188f, -0.08780021f, -0.08645574f, 
    -0.08100224f, 0.02926204f, 0.04096674f, 0.05180427f, 0.01674973f, -0.06592871f, -0.06152395f, -0.04180127f, 
    -0.05547442f, 0.04931487f, -0.08512135f, 0.06802018f, -0.01532347f, 0.06335500f, -0.00494830f, 0.01435675f, 
    0.00772791f, -0.00922719f, 0.06017977f, 0.03949822f, -0.05543348f, 0.07080335f, -0.07638909f, -0.01725588f, 
    0.01769210f, -0.03290557f, -0.04317780f, -0.08924027f, 0.06069501f, 0.07561433f, -0.08057382f, -0.05542913f, 
    0.02483890f, 0.04725448f, 0.01667989f, 0.02645984f, -0.01612520f, -0.03402261f, -0.01952029f, -0.06133417f, 
    -0.03113747f, -0.05446862f, -0.05956401f, 0.06377145f, -0.03972879f, -0.01254791f, -0.02202713f, -0.00304366f, 
    0.03327790f, 0.01077811f, -0.05236818f, -0.03255854f, -0.03770291f, 0.04700067f, -0.01765797f, 0.04888605f, 
    -0.06044653f, -0.09220342f, 0.03269911f, -0.03284449f, -0.02650314f, 0.07288994f, 0.00674440f, -0.03568454f, 
    -0.04624913f, 0.03689294f, 0.03929924f, -0.09056056f, 0.01264366f, -0.01603065f, 0.00387541f, -0.08407170f, 
    0.01674568f, -0.06465131f, -0.07542250f, 0.02774003f, 0.03367568f, 0.03763893f, 0.06295371f, -0.05653835f, 
    0.05279800f, -0.01750092f, 0.06002609f, -0.05601299f, -0.07225029f, 0.07048556f, -0.03890602f, 0.01355624f, 
    0.03356522f, -0.08751045f, 0.04857152f, -0.04514269f, -0.06485979f, -0.03105890f, 0.03721854f, 0.03348590f, 
    -0.07329931f, 0.02857280f, 0.06093489f, 0.06941961f, 0.00668727f, 0.02965593f, 0.06172226f, -0.03000410f, 
    0.01119113f, -0.07712148f, 0.01168380f, -0.05940856f, -0.08466246f, -0.05642841f, -0.04518084f, -0.04893827f, 
    -0.04003285f, -0.07926866f, -0.07400357f, 0.05976122f, -0.02518334f, -0.04160983f, -0.07016154f, -0.03916291f, 
    -0.00157751f, -0.00657523f, 0.07138915f, -0.05732902f, 0.00463346f, 0.03565316f, 0.00497233f, -0.05782811f, 
    -0.03332659f, 0.04069231f, -0.04467556f, 0.00930345f, -0.07830134f, 0.03661635f, 0.00414445f, -0.08227059f, 
    -0.02549073f, -0.07252488f, 0.05893421f, -0.02585820f, -0.01246085f, -0.00841275f, 0.01150271f, 0.01315420f, 
    -0.01801246f, -0.03855996f, -0.08194039f, 0.01734108f, -0.05825862f, 0.03659234f, 0.05103372f, -0.05433458f, 
    -0.80796057f, -0.12129701f, 0.02627631f, -0.10453379f, 0.04176063f, 0.00741143f, -0.03620477f, -0.02407563f, 
    -0.03056846f, 0.26990986f, 0.39092204f, -0.06037925f, 0.08185052f, -0.08966961f, -0.23247345f, -0.24211285f, 
    0.10450011f, 0.11745450f, -0.22860810f, -0.23049761f, 0.56469828f, -0.00070898f, -0.08543326f, 0.01508730f, 
    -0.11446895f, 0.00746597f, -0.02673527f, 0.14581919f, -0.12650874f, -0.11530082f, 0.18432377f, 0.23280025f, 
    -0.05840308f, 0.04057864f, 0.03565869f, 0.06813303f, 0.23641038f, 0.16385795f, -0.39219299f, 0.14003034f, 
    -0.29125699f, -0.05089537f, 0.11903798f, 0.13105211f, -0.05574316f, 0.51501459f, 0.04246489f, 0.08672421f, 
    -0.04709726f, -0.25303346f, -0.09736975f, 0.16081275f, -0.04596470f, 0.03583490f, -0.10631498f, -0.43266737f, 
    0.02050952f, -0.12363791f, 0.03847728f, 0.13409629f, 0.21684480f, -0.11008163f, 0.00379905f, 0.27351284f, 
    0.36280847f, -0.02854956f, -0.03579942f, -0.13344714f, -0.06567577f, 0.18011162f, 0.24679063f, 0.12223278f, 
    -0.05932206f, -0.06448440f, 0.37944025f, -0.08456386f, 0.06913051f, -0.04439795f, -0.05748850f, 0.12724181f, 
    0.10463937f, 0.30372742f, 0.32480747f, 0.03103560f, -0.02382963f, -0.24886841f, 0.09871130f, -0.00481012f, 
    0.28650436f, -0.00284854f, -0.69225204f, -0.28562024f, -0.77417195f, 0.23185389f, -0.00018862f, -0.06846539f, 
    0.05488784f, -0.09836081f, -0.07122026f, 0.14498223f, -0.12051000f, -0.76917940f, 0.26014137f, 0.14145541f, 
    0.16959226f, -0.08241176f, -0.22766288f, 0.02918133f, 0.10744177f, 0.08113053f, 0.14674334f, -0.16121885f, 
    -0.04788255f, 0.00917047f, 0.12150355f, -0.16760963f, 0.08522005f, -0.07413626f, 0.29635546f, 0.02588629f, 
    0.23463044f, 0.07277181f, -0.16291299f, 0.09000745f, -0.04298172f, 0.06848380f, -0.48387355f, 0.23696083f, 
    -0.00522595f, 0.30911884f, -0.03231525f, 0.03773579f, 0.11230942f, 0.06611013f, 0.01422840f, -0.20600033f, 
    0.10550953f, 0.46098685f, 0.11216553f, 0.09506281f, -0.04850243f, -0.00872417f, -0.25026938f, 0.27464777f, 
    0.18689400f, 0.06667227f, -0.55058908f, 0.24903551f, 0.16858694f, -0.04647002f, 0.10249482f, 0.01749106f, 
    -0.14149281f, 0.12478531f, 0.08717843f, 0.13666679f, -0.18956946f, 0.02028156f, -0.24492188f, -0.04394163f, 
    -0.09051328f, -0.06750836f, 0.57891333f, 0.25800550f, -0.08111037f, 0.26411480f, 0.01489581f, 0.13053696f, 
    0.30275869f, 0.12791619f, 0.15189797f, 0.13474715f, -0.02770017f, 0.22652964f, -0.07739068f, -0.04656427f, 
    -0.05942706f, -0.19941108f, 0.04122177f, 0.27993506f, -0.59092748f, 0.09428051f, -0.08806057f, -0.05110494f, 
    0.16040923f, 0.05430124f, 0.01687338f, 0.16665639f, 0.02400534f, -0.09155246f, -0.57400841f, 0.04766813f, 
    -0.02450545f, 0.03525781f, -0.20605265f, 0.10348450f, 0.01596621f, 0.15557761f, 0.09258995f, -0.04934759f, 
    -0.00741201f, 0.10372518f, 0.04146809f, -0.11586677f, 0.09480188f, -0.02735495f, 0.12532601f, 0.14181122f, 
    -0.21008562f, 0.07226802f, 0.24819584f, 0.18775164f, -0.05153100f, 0.14989983f, 0.28653666f, -0.07505958f, 
    0.41373640f, 0.29535511f, -0.14487261f, 0.07469414f, -0.22664653f, -0.08619110f, -0.03128701f, -0.14597729f, 
    0.00319655f, -0.09092601f, 0.15903546f, 0.58860940f, 0.05014385f, -0.06480205f, -0.18335097f, -0.23574907f, 
    -0.15122360f, 0.00163430f, -0.65036440f, -0.08420787f, -0.23874643f, -0.13463616f, 0.20071150f, -0.00286355f, 
    0.18792899f, -0.06312011f, 0.09212195f, -0.20221651f, -0.54130822f, -0.40012789f, -0.10318519f, -0.17359541f, 
    0.02998307f, 0.10045654f, -0.04472689f, -0.13110037f, -0.45541921f, 0.13844091f, 0.13662058f, -0.18828142f, 
    0.18767029f, -0.04923492f, 0.01934923f, -0.12573001f, -0.15263891f, 0.29168168f, 0.31044427f, 0.17138128f, 
    -0.12970677f, -0.25325793f, 0.02126051f, -0.07903623f, -0.00596919f, 0.11308262f, -0.15422672f, -0.23927274f, 
    -0.18940693f, -0.05492036f, -0.14331093f, -0.04905882f, -0.12710230f, -0.12525453f, 0.17207703f, 0.10996068f, 
    -0.02401366f, 0.43780765f, 0.12406188f, 0.23707898f, 0.02668035f, 0.05523448f, -0.24691716f, -0.05418688f, 
    -0.36370400f, -0.52261901f, 0.28449598f, 0.26392052f, 0.06253344f, -0.04513117f, -0.09947798f, 0.02113650f, 
    -0.01124804f, -0.19159430f, -0.20431876f, -0.23121595f, -0.05405017f, 0.01753700f, 0.21141277f, -0.36173719f, 
    -0.06958487f, 0.04101355f, 0.64558238f, 0.68945235f, 0.23811007f, 0.21073565f, 0.18261980f, 0.21220309f, 
    0.18418980f, 0.29644516f, 0.09246272f, -0.91323942f, -0.45528296f, -0.05438539f, 0.15362450f, -0.10607242f, 
    0.36181715f, 0.03550211f, -0.32463282f, 0.21254499f, 0.47311667f, -0.12284309f, -0.09634028f, -0.12666312f, 
    0.00203999f, 0.00472725f, -0.37562689f, 0.08343763f, 0.09670300f, 0.22413167f, 0.17962201f, -0.45824450f, 
    -0.08804712f, 0.30472627f, -0.11738538f, -0.02165753f, 0.06033538f, -0.07432394f, 0.06106889f, -0.07912619f, 
    -0.09017812f, 0.16971897f, -0.04326633f, 0.10639843f, 0.28400722f, 0.16353960f, 0.21288356f, -0.24863574f, 
    -0.47512493f, -0.04959267f, 0.02174560f, -0.03746666f, -0.08744560f, 0.12887700f, 0.02457165f, 0.28648275f, 
    0.02875178f, 0.09567003f, 0.08005755f, 0.11990028f, 0.09181700f, -0.36069289f, 0.25291735f, 0.37590691f, 
    0.01362741f, -0.38517982f, 0.13924560f, 0.00440894f, -0.07873868f, 0.04594609f, -0.02130895f, 0.36265919f, 
    0.01387626f, 0.13546287f, 0.35515830f, 0.25174576f, -0.42309010f, 0.05176426f, -0.13516621f, 0.00939365f, 
    -0.07562260f, 0.03455520f, -0.04090101f, -0.45600930f, -0.19812749f, 0.22366913f, -0.01877606f, 0.06719882f, 
    -0.08603639f, -0.02110265f, 0.00368632f, -0.22545759f, -0.00148627f, 0.00038419f, -0.18559520f, 0.13310997f, 
    -0.07575838f, 0.02881468f, -0.16473004f, 0.09558457f, 0.19335315f, -0.84316576f, -0.10159530f, -0.05419726f, 
    0.12780729f, 0.01538740f, 0.10934983f, -0.05471636f, -0.16651730f, -0.06850896f, -0.20445231f, 0.01324249f, 
    -0.02068941f, 0.07489190f, -0.04086834f, -0.22043304f, -0.03099741f, 0.05113007f, -0.00953260f, -0.17967568f, 
    0.38857171f, 0.44851717f, -0.03756124f, 0.12025230f, -0.03709136f, 0.03573535f, -0.03541560f, -0.05188682f, 
    -0.07348733f, -0.15942834f, -0.50002950f, 0.00607300f, 0.09852125f, -0.04322463f, -0.13766190f, -0.02347597f, 
    0.07060754f, -0.74844068f, 0.09082937f, -0.25901675f, 0.16626239f, 0.32132646f, -0.20502709f, 0.11805294f, 
    0.02093885f, 0.13938875f, 0.68253165f, 0.01682013f, 0.25095201f, -0.10072857f, -0.22050607f, 0.06258804f, 
    0.06045176f, -0.09228639f, -0.04152445f, -0.30140167f, -0.13655330f, -0.01082270f, 0.24347849f, 0.16945572f, 
    -0.00125209f, -0.26501268f, 0.07302052f, 0.02847756f, -0.55186498f, 0.19585143f, -0.24271157f, -0.07943571f, 
    0.28954023f, 0.07567828f, -0.16656789f, 0.21397811f, 0.03150169f, 0.01543183f, -0.39086029f, -0.14829218f, 
    -0.08079745f, -0.20301346f, -0.00004294f, 0.17813104f, -0.02444232f, 0.09913421f, -0.90052617f, -0.16602203f, 
    0.35190263f, 0.05427925f, -0.06541649f, -0.12165526f, 0.16836333f, 0.14189442f, -0.13647076f, -0.43911541f, 
    0.51528400f, -0.31082150f, 0.12028663f, -0.02539916f, -0.27151281f, -0.01358789f, -0.10578121f, 0.10988604f, 
    0.60675156f, -0.10263904f, 0.00830352f, 0.13576993f, -0.01895860f, -0.02625085f, 0.05032014f, 0.02490353f, 
    0.11400933f, -0.05429946f, 0.10295565f, 0.30744573f, 0.00202425f, -0.14376582f, -0.18645898f, 0.15747313f, 
    -0.05257189f, 0.09957003f, 0.08623307f, -0.39659438f, -0.76252127f, 0.01664672f, 0.00254562f, 0.10653916f, 
    -0.15318811f, 0.17639956f, 0.06673620f, 0.43484354f, 0.41705108f, 0.07486801f, 0.00772230f, 0.10875348f, 
    0.06741432f, -0.14366224f, 0.02501939f, -0.09522919f, 0.01927323f, 0.25140500f, 0.31035709f, -0.20915252f, 
    0.21042641f, 0.15945551f, 0.06732864f, -0.00387771f, -0.06880505f, -0.00881489f, 0.04202066f, -0.09140184f, 
    0.22434853f, 0.05004237f, 0.16416538f, -0.10782460f, 0.07608853f, 0.26477835f, -0.43302295f, 0.44901770f, 
    -0.22456580f, 0.22992703f, -0.03441916f, 0.15355752f, -0.07306542f, -0.03566943f, 0.06694462f, 0.19584958f, 
    -0.33563229f, -0.55713129f, 0.06960049f, 0.01064981f, 0.15133290f, 0.07192560f, -0.22975846f, -0.02429021f, 
    -0.14014959f, 0.29467180f, -0.24656609f, -0.03712453f, -0.13034704f, -0.14014328f, 0.01950462f, -0.17505223f, 
    0.20153941f, -0.13591373f, -0.15747903f, 0.26540017f, 0.20631294f, 0.10127412f, -0.01465704f, -0.33754069f, 
    -0.06446393f, -0.05899860f, -0.03680322f, 0.07372459f, 0.06067106f, -0.35157874f, -0.26125285f, 0.08354662f, 
    0.10506826f, 0.15813677f, -0.05288336f, -0.33815160f, -0.33268508f, -0.00469912f, 0.11234313f, 0.17024276f, 
    0.01106804f, -0.12108257f, -0.04738885f, 0.19122307f, 0.58916575f, 0.65233064f, -0.16694491f, -0.03252661f, 
    -0.06060155f, -0.07526165f, 0.02322535f, -0.07187314f, 0.14107937f, 0.33746800f, 0.25953376f, -0.45666718f, 
    -0.11606752f, 0.04423821f, 0.03624417f, -0.09056402f, -0.04845297f, 0.01099174f, -0.12364436f, 0.12274183f, 
    0.01847082f, 0.15029734f, -0.11018331f, -0.04980713f, 0.17320451f, 0.22092159f, 0.21494256f, -0.15632059f, 
    0.12896433f, 0.07242943f, -0.08416352f, 0.15144566f, -0.15532780f, -0.07353399f, 0.22596240f, -0.08838046f, 
    0.06090809f, 0.02542295f, 0.11725425f, -0.15156019f, 0.19268806f, -0.10753696f, 0.02154078f, 0.25322554f, 
    0.04516776f, -0.24082077f, -0.12859176f, -0.16498165f, -0.23515266f, -0.03783486f, -0.01152775f, -0.12948902f, 
    0.08271724f, 0.07025216f, 0.15122256f, -0.27780482f, -0.26677468f, -0.13354625f, -0.03413532f, -0.01114540f, 
    -0.16334482f, -0.00627510f, 0.01409326f, 0.28737897f, -0.17074682f, -0.66909128f, 0.08941083f, 0.19304413f, 
    0.01651650f, 0.21456960f, 0.06107717f, -0.05348575f, 0.27796930f, 0.25152588f, 0.07434056f, -0.02028421f, 
    -0.05911787f, -0.23580149f, -0.10527214f, -0.09862635f, 0.17380400f, -0.14930910f, -0.40194380f, 0.14538591f, 
    0.17404637f, 0.08701455f, 0.08714207f, 0.19797112f, -0.02821320f, -0.08129460f, 0.10544437f, -0.22078659f, 
    0.34269533f, 0.46097931f, 0.13123651f, 0.08181046f, 0.26220489f, -0.24165933f, -0.14745709f, -0.52280885f, 
    -0.05142153f, -0.20776993f, -0.17032352f, -0.12402412f, -0.09422680f, 0.20404311f, -0.00935982f, 0.01106112f, 
    -0.01574266f, 0.02854499f, 0.06044951f, -0.08035047f, -0.04207618f, 0.02639082f, 0.06385636f, -0.01305559f, 
    -0.03782882f, -0.02454231f, 0.03006248f, -0.01234218f, 0.05240186f, 0.08310614f, -0.04055442f, -0.01183821f, 
    0.03688776f, 0.05495247f, -0.04161481f, -0.06764534f, -0.04261129f, -0.02421294f, 0.04441818f, -0.05057982f, 
    -0.00989004f, 0.06882740f, 0.06822217f, -0.00811121f, -0.06588522f, -0.07133950f, -0.01095468f, -0.06559610f, 
    -0.07568678f, 0.07361612f, 0.05692524f, -0.03793723f, -0.01176117f, 0.06354749f, -0.01694763f, -0.01631440f, 
    -0.03298529f, -0.08719896f, -0.06895310f, -0.08819994f, -0.02637878f, -0.03045676f, -0.03880477f, 0.02702103f, 
    -0.08283629f, 0.04251056f, -0.02698358f, 0.01420760f, -0.01589755f, -0.05625186f, -0.06291460f, -0.01391197f, 
    0.05107246f, 0.03340216f, -0.03569935f, 0.04255730f, -0.06351780f, 0.01730483f, 0.01149155f, -0.02223296f, 
    -0.02312885f, -0.00033372f, -0.02801025f, 0.00829141f, 0.05644237f, 0.02018121f, -0.03200556f, -0.02920215f, 
    0.06483881f, -0.00786656f, -0.07654011f, 0.05998079f, 0.05791389f, -0.03506464f, 0.07146072f, -0.01117192f, 
    -0.02024684f, -0.00847613f, 0.07892658f, -0.04069455f, -0.06803554f, -0.07708104f, -0.08047319f, 0.02911541f, 
    -0.01822607f, -0.05526819f, -0.00210672f, -0.09030827f, -0.04621749f, 0.00878803f, -0.08015477f, 0.02758773f, 
    0.05080982f, -0.08457507f, 0.00957735f, 0.05699323f, 0.06878432f, -0.05201823f, -0.06400805f, -0.01919952f, 
    0.00470225f, -0.04647435f, 0.04254719f, -0.00137276f, -0.03613865f, -0.01719667f, -0.03840631f, -0.03718042f, 
    -0.04369764f, -0.06286941f, 0.01316412f, 0.00813666f, -0.00143862f, -0.05860454f, 0.04684956f, -0.03557300f, 
    0.01494166f, -0.02084753f, 0.03107135f, 0.04451517f, -0.04637998f, 0.03762418f, -0.04644888f, -0.03299566f, 
    0.02306125f, -0.01084366f, 0.02153018f, -0.08430596f, -0.08924988f, -0.02662388f, -0.07958577f, -0.09456707f, 
    -0.07516462f, 0.06158531f, 0.04179435f, -0.08862733f, -0.01077364f, -0.06180991f, -0.08355337f, -0.09090174f, 
    -0.22226721f, -0.42482993f, -0.31285024f, -0.14415276f, 0.10344927f, 0.11691163f, 0.02033961f, -0.01128552f, 
    0.29667538f, 0.05375919f, 0.27139822f, 0.40341356f, 0.00456615f, 0.22565672f, -0.08807296f, 0.03516085f, 
    0.04473726f, -0.04157681f, -0.18976176f, -0.50248301f, -0.28695929f, 0.11338137f, -0.14183825f, 0.14597467f, 
    0.21855332f, -0.14104415f, -0.12994540f, -0.15561481f, 0.16035357f, 0.42883518f, 0.13133322f, 0.14328258f, 
    -0.19233325f, 0.10775138f, -0.03508271f, -0.11113925f, 0.21192069f, -0.12263885f, -0.32312161f, -0.27538937f, 
    0.33282208f, 0.10590935f, 0.23424377f, -0.04510856f, 0.07553477f, -0.79495895f, -0.13729566f, 0.22576573f, 
    0.15821734f, 0.02237891f, -0.10397408f, 0.18812241f, -0.13361219f, 0.11522502f, -0.19817767f, 0.08928785f, 
    -0.22844633f, -0.12406696f, -0.05380074f, -0.16372225f, -0.00870258f, 0.17246139f, 0.08162601f, 0.58490825f, 
    -0.07779965f, -0.29642147f, 0.06324534f, 0.14640112f, 0.27455857f, 0.17853250f, -0.03428439f, 0.09026566f, 
    -0.18939687f, -0.31279442f, -0.26816261f, 0.07793262f, 0.07088154f, 0.06812761f, -0.08828971f, -0.10201348f, 
    0.17836541f, -0.21322447f, -0.02864461f, 0.07976766f, -0.00446213f, -0.20728472f, -0.04232573f, -0.16674833f, 
    0.00395623f, -0.24629062f, 0.10720441f, -0.35504273f, 0.07110280f, 0.03358901f, -0.07065711f, -0.10161276f, 
    0.21258788f, 0.02016168f, 0.07428066f, -0.14665066f, 0.36910594f, 0.11109093f, -0.16538228f, 0.11273575f, 
    0.01939590f, -0.07395336f, 0.03197466f, 0.01211363f, 0.41037840f, -0.60899651f, -0.20848264f, 0.09695549f, 
    0.08759488f, 0.13542870f, 0.06848419f, -0.20543103f, -0.19266176f, -0.21957876f, 0.20271464f, 0.43373206f, 
    -0.01297718f, 0.18752508f, 0.03408758f, -0.00909114f, 0.06204832f, -0.02713820f, -0.19036260f, 0.25540778f, 
    0.49709833f, -0.00649231f, 0.00547596f, -0.02614802f, 0.00111670f, 0.22328660f, -0.05101846f, -0.29471520f, 
    0.07660793f, -0.24106790f, 0.13317741f, 0.24023028f, 0.05218531f, -0.02912400f, -0.05183990f, -0.24818915f, 
    -0.21419664f, -0.00370703f, 0.19219573f, -0.57525778f, 0.17223480f, -0.05399825f, 0.03291520f, 0.00082013f, 
    -0.06105480f, 0.02756336f, -0.20479265f, 0.00381000f, 0.11708402f, 0.15488592f, 0.11349338f, 0.12992504f, 
    0.11255562f, -0.00449935f, -0.17000039f, 0.20150034f, 0.31513157f, 0.17998409f, 0.12763219f, 0.03950625f, 
    -0.33598638f, 0.24440731f, 0.18952242f, 0.33678314f, 0.13811679f, 0.14507727f, 0.31143430f, 0.13231985f, 
    0.24368602f, 0.11255040f, 0.16749042f, 0.15153123f, 0.40877181f, -0.09013791f, -0.06041525f, 0.07958490f, 
    -0.24824369f, -0.27408963f, 0.22880764f, 0.01753743f, 0.02048037f, 0.34706905f, 0.00796171f, -0.08452331f, 
    0.04425602f, 0.10785979f, 0.10220682f, -0.20488583f, -0.11024048f, 0.06916477f, 0.02456735f, -0.21351364f, 
    -0.43158880f, -0.11217689f, -0.08938192f, -0.04631954f, 0.13669011f, 0.04498130f, -0.49399665f, -0.74376792f, 
    0.06940395f, 0.08146525f, 0.10851553f, 0.28073639f, 0.22275899f, 0.04724386f, -0.15493420f, -0.06812605f, 
    -0.29980886f, 0.04889693f, 0.08028728f, -0.07555987f, -0.09966761f, -0.00858925f, -0.09808077f, -0.12574883f, 
    0.15413275f, -0.73428732f, -0.10535146f, -0.12161352f, 0.24968891f, -0.10044897f, 0.01925831f, -0.15460683f, 
    0.19763476f, -0.36545375f, 0.70254809f, 0.21331744f, 0.04594705f, -0.01403601f, 0.00405908f, -0.11344858f, 
    -0.21452770f, 0.02286831f, 0.06159043f, 0.13593295f, 0.21551025f, -0.01718496f, -0.14086267f, 0.09214772f, 
    -0.07886041f, -0.12003068f, -0.01401058f, -0.15878297f, -0.31456071f, -0.31618983f, -0.64861923f, 0.14153087f, 
    0.10932958f, 0.05468670f, -0.12184979f, -0.15572521f, -0.42535424f, 0.25540194f, 0.36114761f, 0.24526176f, 
    0.11006256f, 0.10426259f, 0.30435339f, -0.02975022f, 0.07650107f, 0.13892105f, 0.26419783f, -0.22662190f, 
    -0.11321724f, -0.10927971f, 0.02489150f, 0.12930471f, 0.20417815f, 0.12794732f, -0.07281063f, -0.23146422f, 
    0.37779891f, -0.11216170f, 0.24571055f, 0.01998368f, -0.05161034f, 0.10439830f, -0.13704275f, 0.13263674f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.01895547f, -0.01726758f, -0.08311062f, 0.20559815f, -0.08494180f, -0.01871559f, -0.02662645f, -0.08202615f, 
    0.21627514f, 0.11162815f, 0.00528397f, 0.10584261f, 0.27368453f, 0.04779875f, 0.53417492f, -0.14119700f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.10981624f, 0.01273196f, -0.05242280f, 0.94409084f, 0.18273322f, -0.05088899f, 0.01328776f, -0.05933383f, 
    -0.71959543f, 0.43487754f, -0.24288471f, -0.32659280f, -0.55567050f, -0.28405020f, -0.47942880f, -0.18579526f, 
    -0.24759106f, -0.11264247f, 0.08417796f, 0.02743093f, 0.09715959f, 0.21338998f, -0.03430526f, 0.01529544f, 
    -0.11764675f, 0.82800806f, -0.30841041f, 0.23512229f, -0.22053576f, -0.05472263f, 0.11789515f, -0.42968434f, 
    -0.20872058f, 0.04775776f, -0.06699504f, -0.13006239f, 0.16242063f, 0.18548943f, -0.19448152f, 0.20620193f, 
    -0.09980049f, -0.35930434f, -0.82430106f, 1.31348240f, 0.02741808f, 0.19256973f, -0.25248894f, -0.22983329f, 
    0.16844572f, 0.06268720f, -0.23231706f, -0.62607110f, -0.03075886f, 0.18654631f, -0.21558130f, 0.14018407f, 
    -0.50018048f, -0.59990913f, 0.33810222f, -0.30671677f, 0.66781008f, -0.08438332f, -0.12030717f, 0.28440225f, 
    0.22241728f, 0.03122018f, -0.84482110f, 0.17557450f, -0.18625066f, 0.01361963f, 0.14698821f, -0.15516014f, 
    0.08560339f, -0.09314024f, -0.17684452f, -0.30645162f, -0.44412050f, -0.23381470f, 0.36726466f, 0.41854817f, 
    -0.24855572f, 0.10658877f, 0.28876299f, 0.27404964f, -0.25267762f, -0.10482786f, 0.19721699f, -0.20234653f, 
    -0.34991398f, -0.04286354f, -0.11143636f, -0.10931086f, -0.75367308f, -0.10151049f, 0.34772563f, -0.05910932f, 
    -0.08053131f, -0.14610840f, 0.81201607f, 0.00655660f, -0.22424875f, 0.02536727f, -0.14380066f, -0.19732468f, 
    -0.71480221f, -0.55439603f, -0.36443782f, -0.29591209f, -0.23211744f, -0.01394661f, 0.50519586f, 0.12393107f, 
    0.15430984f, -0.19252820f, -0.44714412f, -0.46320403f, 0.13347100f, 0.08312035f, -0.21567693f, 0.16642295f, 
    -0.02614011f, 0.42207801f, 0.70065606f, -0.23689219f, -0.63677514f, -0.05954489f, -0.59278888f, 0.14526609f, 
    -0.11758193f, -0.17601661f, 0.30642164f, -0.05332379f, 0.04224484f, 0.04847877f, -0.12304921f, -0.02816110f, 
    0.88955778f, 0.05146404f, -0.60458606f, -0.26068908f, 0.71103871f, -0.15280990f, -0.38209659f, -0.44566387f, 
    -0.15809479f, -0.06977874f, -0.63283902f, 0.44532031f, -0.00881499f, -0.22347811f, 0.08257057f, 0.22432430f, 
    0.68873048f, -0.40408868f, -0.36635247f, -0.68419361f, -0.36072350f, -0.01139754f, 0.55247074f, -0.14565493f, 
    0.18546070f, 0.02567211f, 0.05279658f, -0.52117455f, 0.00569451f, 0.00697030f, -0.11975434f, 0.18031305f, 
    0.04748287f, -0.48506349f, 0.56288928f, 0.48696110f, 0.27382809f, 0.08970270f, -0.57496059f, -0.52493638f, 
    0.02636303f, 0.23819806f, 0.55317235f, -0.27017954f, 0.11539275f, -0.01018670f, -0.19687530f, -0.13716958f, 
    -0.24987924f, -0.22693469f, -0.33996725f, -0.20657343f, 0.17301886f, 0.12947719f, -0.57937354f, 0.74547082f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.19889051f, 0.26729405f, -0.68520999f, 0.37733835f, 0.86335838f, -0.14329021f, -0.44699591f, -1.11504626f, 
    -0.67011088f, -0.05401650f, 0.44846436f, -0.21757607f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
