#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.00894778f, -0.04863332f, 0.25955084f, 0.41813162f, 0.20295173f, 0.25545347f, 0.20174052f, 0.24555880f, 
    0.18296511f, 0.12884489f, -0.01006129f, -0.16477640f, -0.21825217f, -0.26377207f, 0.10879567f, 0.13000530f, 
    -0.07785983f, -0.03902281f, -0.03421517f, 0.06084935f, -0.13228965f, -0.16958684f, -0.12636709f, -0.23857580f, 
    -0.07864598f, 0.46935588f, 0.23728245f, -0.12852356f, -0.44309127f, 0.44117475f, 0.20274954f, -0.24403304f, 
    -0.17893332f, -0.17286618f, -0.11374579f, -0.24358205f, 0.19683455f, -0.28552949f, 0.02215548f, 0.14760982f, 
    0.15571773f, 0.00161822f, -0.03367822f, 0.08742615f, -0.26768655f, 0.19204006f, 0.12327911f, 0.01962491f, 
    0.24623871f, 0.33050525f, -0.72644949f, -0.37700793f, -0.21980663f, -0.37722576f, 0.27462402f, -0.41169712f, 
    -0.22411609f, 0.19675022f, -0.42933831f, -0.13047157f, 0.51876128f, 0.50824171f, 0.28260344f, -0.16094559f, 
    -0.19821137f, -0.32461485f, -0.32423893f, -0.42384663f, -0.37420470f, -0.28104940f, 0.32944974f, 0.09644204f, 
    0.04338699f, 0.11565813f, 0.20812660f, 0.39446157f, -0.35318679f, 0.03836571f, -0.42669332f, 0.25673416f, 
    0.19917150f, 0.03513671f, 0.23360379f, 0.09172633f, 0.31515092f, -0.31478056f, -0.07909384f, -0.03050785f, 
    -0.15676662f, 0.25253847f, -0.20232821f, -0.07642454f, -0.23032056f, 0.35228023f, -0.18914816f, 0.17017905f, 
    -0.17791475f, 0.00795015f, 0.00912888f, 0.46474692f, 0.06175681f, -0.90839601f, -0.31233832f, 0.48087656f, 
    0.32804576f, 0.08454032f, -0.26982671f, -0.36214432f, -0.18888414f, 0.27597460f, 0.14162794f, 0.09270837f, 
    -0.29205865f, -0.28099629f, 0.51108730f, 0.19055355f, -0.04209551f, 0.23670998f, 0.54182172f, 0.12902223f, 
    -0.41338927f, -0.36969650f, -0.13720047f, 0.04529545f, -0.35616088f, -0.40147582f, 0.10693729f, 0.12241765f, 
    -0.08751766f, -0.29101929f, -0.36806723f, -0.60663497f, 0.29682988f, -0.28495115f, -0.27035421f, 0.45619428f, 
    0.44618717f, -0.08609224f, -0.01174847f, 0.04192387f, 0.03096631f, -0.16801132f, -0.07732056f, -0.05843150f, 
    -0.08989757f, -0.10106472f, 0.01196212f, -0.23207371f, -0.23180012f, -0.31102157f, 0.36877275f, 0.40314794f, 
    0.24724606f, 0.06694771f, 0.23331575f, 0.09734916f, 0.06118483f, 0.22007672f, -0.15407658f, -0.20615132f, 
    0.13595334f, 0.20742054f, -0.14920241f, -0.10591687f, 0.05887279f, -0.07419604f, 0.17898729f, -0.18994334f, 
    -0.26552173f, 0.24215111f, -0.09358935f, -0.12958673f, -0.17915346f, -0.11776284f, 0.06822759f, -0.24632996f, 
    -0.92673761f, -0.11088253f, 0.76101869f, 0.57384408f, -0.13368167f, 0.79344743f, -0.67215210f, -0.73377281f, 
    0.05883451f, -0.54502422f, -0.08805570f, 0.15907133f, -0.07295761f, -0.36646199f, -0.00438756f, 0.07328006f, 
    -0.11528632f, 0.21669392f, -0.03480374f, -0.02798765f, -0.15173861f, -0.00793334f, -0.01991979f, -0.15928552f, 
    -0.60172844f, 0.05232436f, -0.45356205f, -0.77546549f, -0.36486372f, -0.23674138f, -0.17535649f, 0.23361883f, 
    -0.02778199f, -0.23030666f, -0.42770672f, -0.44065800f, -0.32162797f, 0.03614928f, -0.15201119f, 0.09530206f, 
    -0.47820783f, -0.21080682f, -0.12879860f, -0.35251021f, 0.01396898f, 0.08191409f, -0.20881192f, 0.07106246f, 
    -0.22182742f, 0.03396783f, -0.00314759f, 0.30961803f, -0.32218191f, -0.55804765f, 0.33155894f, -0.32172763f, 
    -0.34044558f, -0.27732739f, -0.46903089f, 0.64411384f, -0.58907682f, -0.03970874f, 0.02324291f, -0.14225596f, 
    0.03518601f, 0.21298656f, 0.06688616f, -0.09424838f, -0.28033978f, 0.02393559f, 0.08146089f, 0.31901109f, 
    0.12412103f, 0.06106145f, 0.44097790f, 0.43492356f, 0.28289965f, -0.26973900f, -0.22757404f, -0.01284604f, 
    -0.20037436f, -0.27078727f, 0.16370414f, 0.29013249f, 0.15431118f, -0.05979786f, -0.16712736f, 0.02513341f, 
    0.04610847f, -0.12052249f, 0.18589583f, -0.09864176f, 0.14227165f, 0.17016573f, -0.00981898f, 0.00662177f, 
    -0.26653731f, -0.19032201f, -0.40223679f, -0.60906535f, -0.55760598f, -0.87650484f, -0.47060192f, 0.16170080f, 
    0.16148320f, 0.50478190f, -0.02344805f, -0.03531965f, 0.15397368f, -0.12388576f, -0.20645745f, -0.33201957f, 
    -0.51571780f, -0.20448107f, 0.14047413f, 0.35780630f, -0.08673777f, 0.22197241f, 0.28780663f, 0.03440674f, 
    -0.29580763f, -0.02934981f, 0.05796938f, -0.33921126f, 0.61730617f, -0.44675815f, -0.23709354f, 0.06761962f, 
    0.28902087f, 0.49819204f, 0.22886141f, 0.50550205f, -0.19807109f, -0.35322663f, -0.16057169f, 0.24411593f, 
    -0.20306863f, -0.32311121f, 0.01378329f, 0.08001142f, 0.08257447f, 0.12773542f, -0.07269816f, -0.04463703f, 
    0.34172377f, -0.07515199f, -0.24046774f, -0.20064718f, -0.18537666f, 1.10106623f, -0.79156226f, -0.22985712f, 
    -0.62406528f, -0.33603263f, -0.11105331f, 0.09201551f, 0.33530599f, 0.28767851f, 0.24959441f, -0.04431805f, 
    -0.08711555f, 0.07735500f, 0.10670649f, -0.06871547f, 0.11619485f, -0.21993650f, -0.25192878f, -0.01122723f, 
    -0.34087124f, -0.30662689f, 0.01900291f, -0.06761263f, -0.08300545f, -0.31132969f, 0.50949377f, 0.37595218f, 
    -0.55736268f, -0.31571600f, -0.33941916f, 0.22219849f, 0.34490457f, -0.08737440f, -0.70676237f, -0.76402736f, 
    0.15940486f, -0.19103029f, -0.12807094f, -0.43424079f, -0.06495192f, -0.28206787f, -0.21881531f, -0.25185782f, 
    -0.32231197f, -0.16351266f, -0.20153826f, -0.19134353f, 0.12371097f, -0.04756252f, -0.25052315f, 0.53495896f, 
    0.36756733f, 0.18564691f, 0.10237452f, -0.10977620f, -0.28217462f, 0.08367222f, 0.09926777f, -0.07536457f, 
    -0.12535617f, 0.41782019f, -0.09740511f, 0.04678366f, 0.11301460f, 0.19791506f, 0.33433470f, 0.18622132f, 
    0.03390605f, -0.05383923f, -0.36263442f, -0.24559830f, 0.08740597f, 0.31017902f, 0.29009059f, 0.12395964f, 
    -0.13731538f, 0.65377468f, -0.04423211f, -0.34298491f, -0.56498134f, -0.17629652f, 0.46685705f, -0.13413796f, 
    -0.11747739f, -0.36166999f, 0.39611009f, 0.33083397f, 0.07065166f, 0.00920374f, 0.13694486f, -0.05644874f, 
    -0.16846186f, -0.07528095f, -0.02005614f, -0.26008645f, 0.00533127f, 0.14449652f, -0.11555398f, -0.06169924f, 
    -0.23657110f, 0.21856700f, -0.00656961f, 0.10765069f, -0.51499575f, -0.71631253f, 0.57918209f, 0.19530192f, 
    -0.36357093f, 0.12330704f, 0.55332786f, 0.09410992f, 0.14262128f, 0.17129810f, -0.25435618f, 0.32353961f, 
    -0.22828028f, -0.06795781f, 0.06575089f, -0.39325234f, -0.33650357f, 0.30847979f, 0.14189743f, 0.19320095f, 
    0.09630633f, -0.01630200f, 0.45243350f, -0.21029510f, -0.37550169f, 0.41037017f, -0.10913355f, -0.52793407f, 
    -0.46445253f, -0.38302246f, -0.49014938f, -0.46335855f, 0.43366888f, 0.62461120f, -0.08420869f, 0.20131175f, 
    0.00955500f, -0.28313008f, 0.35374403f, -0.00955234f, -0.14220843f, -0.17432775f, 0.13885993f, 0.03239148f, 
    -0.08547696f, -0.08587048f, -0.01339676f, 0.55970800f, 0.20154566f, 0.20426545f, 0.14974976f, 0.42813963f, 
    -0.51304370f, -0.15236756f, -0.16307978f, -0.35325935f, 0.04436666f, -0.34320995f, 0.34108165f, 0.06310202f, 
    -0.00573621f, -0.12841605f, -0.21182363f, -0.09236956f, 0.32230303f, 0.12764530f, -0.00973455f, -0.10334545f, 
    0.16400585f, -0.03926624f, -0.21389385f, -0.22314978f, 0.57255322f, -0.25582379f, -0.88421226f, -0.12736636f, 
    0.82838953f, 0.28443280f, 0.16706432f, -0.23262867f, -0.38940796f, -0.59055072f, 0.29684979f, -0.09955858f, 
    -0.01421918f, 0.15579256f, -0.23489253f, 0.14860906f, -0.18168664f, 0.00290064f, -0.12233234f, 0.03923581f, 
    -0.10250309f, 0.34309408f, 0.15838355f, -0.04785492f, 0.18360107f, -0.48926973f, 0.35795355f, 0.15768577f, 
    -0.03480938f, 0.11232937f, 0.12952203f, 0.13637647f, -0.02695731f, -0.10599409f, 0.05008747f, 0.54329801f, 
    -0.36472109f, -0.47975823f, -0.13958016f, 0.22456484f, 0.01792023f, -0.07595441f, -0.08036570f, 0.13045806f, 
    0.30030969f, -0.20852479f, 0.06670457f, 0.34091303f, -0.06492871f, -0.32943812f, -0.26087940f, 0.46248189f, 
    -0.35140461f, 0.39798418f, -0.44777086f, -0.75591737f, -0.53918302f, 0.00907926f, -0.11818013f, 0.31296209f, 
    -0.07983066f, 0.14606267f, 0.61824304f, -0.34159347f, 0.01828063f, -0.33430779f, 0.33041647f, -0.08408210f, 
    -0.22545718f, -0.23524390f, 0.21791418f, -0.13208309f, -0.20761867f, -0.21276233f, -0.08718923f, -0.02659578f, 
    0.19392687f, 0.01154208f, -1.11347973f, -0.88232827f, -0.00346893f, -0.09079845f, 0.20052715f, 0.27971807f, 
    0.40783074f, 0.10126090f, -0.24671496f, 0.42669690f, 0.10627560f, 0.04328710f, 0.00119957f, -0.00344998f, 
    -0.18202928f, -0.24251296f, 0.17734407f, 0.01696423f, -0.01010008f, 0.09621399f, -0.06511725f, 0.19990799f, 
    -0.90100598f, -0.80286121f, -0.11962065f, 0.34311411f, 0.14480682f, 0.63825011f, 0.60058361f, 0.25568855f, 
    0.03141324f, -0.05833827f, 0.02253318f, -0.17790690f, 0.06752760f, 0.29729807f, -0.03145444f, 0.08160473f, 
    0.07739317f, -0.13412865f, -0.32866845f, -0.09760341f, -0.09484225f, -0.02573228f, 0.27337047f, 0.16232103f, 
    -0.15536672f, -0.97162235f, -0.44148067f, 0.23546274f, 0.48732117f, 0.68916750f, -0.40402421f, -0.58435941f, 
    -0.24643384f, 0.61326677f, 0.51355243f, -0.00905531f, 0.11769857f, -0.07655782f, 0.40861365f, -0.20352824f, 
    -0.01737558f, 0.23832199f, 0.03126176f, -0.13016050f, -0.28365973f, 0.04372270f, 0.14814623f, -0.17923340f, 
    0.28557947f, -0.14709701f, -0.24524738f, -0.67197883f, -0.59018219f, -0.31805906f, -0.26286700f, 0.39537442f, 
    -0.11705160f, 0.48808068f, 0.09974733f, 0.30695003f, 0.00402820f, 0.00243031f, 0.02505024f, 0.04934621f, 
    0.21281034f, 0.19053158f, 0.08928322f, 0.02392510f, -0.21367158f, 0.17135905f, -0.28125897f, -0.01415310f, 
    -0.07500473f, -0.08052342f, -0.11879958f, 0.40136442f, -0.59376949f, 0.07316124f, 0.31212267f, -0.73898774f, 
    -0.39502645f, -0.25808275f, -0.38915753f, -0.17496568f, -0.31034124f, -0.14493470f, -0.28284848f, -0.21901478f, 
    -0.21348801f, -0.25850290f, -0.25160748f, -0.29533321f, 0.02017280f, 0.23576023f, -0.26933146f, -0.18332870f, 
    -0.26945385f, 0.02876370f, -0.20869295f, 0.38249680f, -0.37459153f, -0.45603570f, -0.44528016f, 0.01099358f, 
    0.17761272f, -0.37451166f, -0.60681289f, -0.29172057f, -0.43628925f, -0.32795432f, 0.04240329f, 0.11961048f, 
    -0.02754860f, 0.41175899f, -0.45187700f, 0.32288840f, 0.21938863f, 0.09826725f, -0.12986310f, 0.04195755f, 
    -0.10369432f, 0.12361886f, 0.03161546f, 0.08414000f, 0.41773814f, -0.75329798f, -0.59460080f, -0.41237947f, 
    -0.55914265f, -0.41816071f, 0.06140550f, -0.10792861f, 0.14215967f, 0.38626876f, -0.04068363f, -0.13976775f, 
    0.16192566f, 0.27880397f, -0.09773391f, -0.06863912f, 0.18972386f, -0.37922731f, -0.12394078f, -0.19114612f, 
    -0.27332938f, -0.25426418f, 0.22064383f, -0.14512132f, -0.19771455f, -0.07657334f, -0.20735170f, -0.02010513f, 
    -0.21564506f, 0.62802565f, -0.10416884f, -0.40484387f, 0.00964082f, 0.48046127f, -0.30282769f, -0.04792432f, 
    -0.18305975f, -0.14086294f, -0.11974191f, 0.32029730f, 0.18219681f, -0.19413736f, 0.21091528f, -0.19825819f, 
    -0.10759907f, 0.05704617f, 0.25053617f, 0.07999894f, -0.23610626f, 0.16853073f, 0.15643111f, -0.02413241f, 
    0.86652869f, 0.35445759f, -0.21482046f, -0.32150373f, -0.20638700f, -0.15660320f, 0.21983697f, 0.27164003f, 
    -0.45598331f, -0.19506928f, 0.04283321f, 0.20102863f, -0.04890276f, -0.24071413f, 0.46925348f, -0.45023683f, 
    -0.21069914f, 0.24208342f, -0.24359505f, -0.20966661f, 0.40901792f, 0.22350867f, -0.25540593f, -0.11254989f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.10253055f, 0.21561690f, -0.04000723f, 0.36703807f, 0.12409035f, -0.07557204f, -0.08653814f, 0.31050608f, 
    -0.01030832f, 0.35213509f, 0.19141148f, -0.02579392f, 0.43459290f, 0.07213929f, -0.09160563f, -0.04789234f, 
    0.09937171f, 0.22403625f, 0.00283961f, 0.01472520f, 0.17695343f, 0.25656518f, 0.29158086f, 0.39119178f, 
    0.23774664f, 0.25272983f, -0.11545503f, -0.02272173f, -0.02245869f, -0.06971381f, 0.02138463f, 0.15393421f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.10825288f, 0.05405182f, 0.05924470f, 0.02410448f, -0.03861762f, -0.08620993f, -0.11661797f, -0.11797938f, 
    -0.12855107f, -0.16512632f, -0.00186803f, 0.02255772f, -0.06747764f, -0.00429581f, -0.03537537f, -0.12306431f, 
    -0.05505456f, 0.08513993f, -0.09404093f, 0.04429505f, 0.03335742f, 0.06643033f, 0.03308719f, 0.06648186f, 
    -0.07889182f, 0.01605733f, -0.05806435f, -0.07822812f, 0.09515654f, 0.08749109f, 0.01749764f, -0.00609601f, 
    0.00148989f, -0.10736515f, 0.06276102f, -0.04176763f, -0.00728178f, -0.09747388f, 0.03534847f, 0.10358170f, 
    -0.08439517f, -0.04838565f, -0.05213208f, 0.01379153f, 0.17376718f, 0.06740241f, 0.07822202f, 0.26796135f, 
    -0.01027971f, -0.02914447f, -0.06355985f, -0.13507806f, 0.13288526f, 0.11667956f, 0.05400856f, 0.06943356f, 
    -0.00564594f, 0.14454916f, 0.07131889f, -0.13206315f, -0.06894764f, 0.01554879f, -0.03352808f, -0.01998974f, 
    -0.05081248f, 0.08211038f, -0.00376792f, -0.01600795f, -0.06377576f, 0.02056298f, -0.00494213f, -0.09781861f, 
    -0.03686643f, 0.08438596f, 0.10484339f, 0.04878256f, 0.00190046f, -0.04341565f, 0.00460380f, -0.07601470f, 
    -0.10526566f, -0.13390253f, -0.04391678f, -0.00453844f, 0.39556858f, 0.03783943f, 0.14937931f, -0.05027356f, 
    0.12473237f, -0.05654399f, 0.05256437f, 0.11775924f, 0.11003552f, 0.06566514f, 0.05308137f, 0.00150661f, 
    -0.05357666f, 0.15586960f, 0.01223996f, -0.05893746f, 0.01199613f, 0.04094108f, -0.03618012f, 0.10624122f, 
    -0.03315368f, -0.02561623f, -0.08115618f, -0.04195815f, -0.00115139f, 0.07810110f, -0.02428383f, -0.16718325f, 
    0.08736152f, -0.01943831f, -0.00757834f, 0.05762107f, 0.01003130f, 0.03290740f, 0.03449594f, 0.06847508f, 
    -0.02132683f, -0.04458581f, 0.05556687f, -0.04533538f, 0.02635530f, -0.07630949f, -0.00330602f, 0.02763048f, 
    -0.16843578f, -0.04566674f, 0.06910222f, -0.10655373f, 0.07705994f, 0.02558717f, -0.03084740f, -0.11499242f, 
    -0.07734838f, 0.10685848f, 0.11105130f, 0.10329064f, 0.04960690f, -0.13053940f, 0.01298569f, -0.16568068f, 
    0.04061906f, -0.26139396f, 0.06581856f, -0.06681361f, -0.05281940f, -0.09223736f, -0.06867304f, -0.10193833f, 
    0.05878188f, 0.06199751f, 0.00649782f, -0.09030256f, 0.31168282f, 0.07096458f, -0.20324162f, -0.04464792f, 
    0.02163854f, -0.07127286f, 0.02222407f, 0.04613828f, 0.17559443f, 0.07568283f, 0.01871826f, -0.01367256f, 
    0.21809311f, 0.03374465f, -0.17703871f, -0.10825890f, -0.08611647f, -0.02910180f, -0.00294482f, 0.05938953f, 
    -0.09360571f, -0.05822656f, 0.07649701f, -0.02574113f, -0.05856789f, -0.02879646f, -0.08591335f, -0.04904585f, 
    -0.02962025f, 0.02781085f, -0.06612387f, -0.09484242f, 0.08935463f, 0.05204921f, 0.07966937f, 0.06873362f, 
    0.09913569f, -0.18570399f, 0.02197580f, -0.12844428f, -0.14543959f, 0.01440125f, 0.04489913f, 0.07141107f, 
    0.04463509f, 0.03765363f, 0.07835338f, 0.02176360f, 0.17442773f, -0.16108769f, -0.11274698f, 0.00132186f, 
    -0.03900533f, 0.00245616f, -0.03382822f, 0.08494031f, 0.18845893f, 0.11376119f, 0.11482821f, 0.02872895f, 
    0.07024895f, 0.04479434f, -0.08422122f, -0.22808935f, 0.03035975f, 0.00675713f, -0.06246919f, -0.15407631f, 
    0.00627707f, -0.03955174f, 0.04348449f, 0.00998429f, -0.14870133f, -0.08923000f, -0.22595972f, 0.01969168f, 
    -0.04845810f, 0.01025977f, 0.09878839f, 0.15799953f, -0.05798855f, 0.03672826f, -0.07274439f, -0.02310158f, 
    -0.09912394f, 0.11297901f, -0.10822897f, -0.15318182f, -0.04667287f, 0.11588017f, 0.33819070f, -0.04240110f, 
    -0.02919769f, 0.10127395f, -0.12164041f, 0.14223365f, -0.13890986f, 0.01360662f, -0.02637859f, 0.09745649f, 
    0.01007351f, -0.02297134f, 0.01017686f, 0.15886298f, 0.19415496f, 0.07684978f, -0.10916825f, 0.02489453f, 
    0.14773928f, -0.06428979f, 0.11917967f, 0.03310725f, 0.00769685f, 0.06881119f, 0.10797777f, 0.13365798f, 
    -0.00966796f, 0.06922213f, 0.00281498f, 0.02236700f, 0.01986272f, -0.10436723f, -0.17411934f, 0.04250076f, 
    0.11001755f, 0.14168070f, 0.17078808f, 0.10919838f, 0.02036534f, -0.07479979f, -0.03761791f, 0.00212799f, 
    -0.03347183f, -0.34607145f, -0.09271431f, -0.09630629f, -0.05793368f, -0.11417715f, -0.01981825f, -0.00812679f, 
    0.23603226f, 0.12711832f, 0.06159441f, 0.07030145f, 0.27283219f, -0.16133611f, 0.27336407f, -0.14046714f, 
    0.00171681f, -0.05151768f, -0.00286847f, 0.12315828f, 0.06847923f, -0.04884012f, 0.09560964f, -0.01663651f, 
    -0.02527287f, -0.04085794f, -0.15106992f, -0.14269264f, -0.05143334f, 0.08742620f, 0.11841896f, 0.10057103f, 
    0.09149916f, -0.05822359f, 0.08960241f, -0.10892499f, 0.25105333f, 0.09402267f, 0.06355448f, -0.15160359f, 
    0.04890741f, 0.07914533f, -0.02928998f, -0.01613955f, -0.00328369f, -0.01689141f, 0.01311474f, 0.15308844f, 
    0.08194731f, 0.10660651f, 0.01403582f, -0.13623948f, 0.01365187f, 0.03966757f, 0.11884204f, 0.02526749f, 
    0.00381564f, -0.05478630f, -0.01844244f, 0.10862043f, -0.11887432f, 0.03971734f, -0.02150231f, -0.18074974f, 
    0.10545161f, 0.11383478f, 0.13788769f, 0.06380840f, 0.03645520f, -0.04278280f, -0.02746737f, 0.00768376f, 
    -0.08471458f, -0.07323470f, 0.08569234f, 0.03116267f, 0.05915169f, 0.06972504f, 0.09466790f, -0.02755076f, 
    -0.07035462f, 0.07247110f, 0.09867259f, 0.06082578f, -0.12118350f, 0.06402591f, -0.06318527f, -0.03000178f, 
    0.08669336f, -0.02109234f, 0.12268583f, 0.00018234f, -0.06956089f, 0.07886814f, -0.22531106f, 0.02646296f, 
    -0.12202828f, 0.08327324f, -0.12693234f, -0.17261688f, -0.05849690f, 0.00666647f, -0.04363590f, 0.01334799f, 
    0.10927650f, 0.08675239f, 0.02836086f, -0.05218855f, -0.17577747f, -0.14005448f, 0.11075372f, -0.10184500f, 
    0.06087920f, 0.09735750f, 0.12995583f, 0.01601654f, 0.00014526f, -0.01869542f, 0.01568283f, 0.02903968f, 
    0.03088194f, -0.24752100f, 0.00783334f, -0.06232048f, 0.03379790f, -0.11362806f, -0.02950790f, -0.03625610f, 
    0.12978888f, 0.15173507f, 0.05924883f, 0.02616297f, -0.07950428f, 0.04908434f, 0.02562990f, -0.08788931f, 
    -0.04386083f, -0.10152975f, 0.00261435f, 0.02117692f, 0.17275462f, 0.09961896f, 0.20395570f, 0.20225382f, 
    -0.22709358f, -0.01602314f, -0.12813845f, 0.10266131f, 0.04887092f, 0.13216034f, 0.00678389f, 0.22638433f, 
    -0.13570118f, 0.03630330f, 0.01840717f, -0.09269941f, 0.02347967f, -0.10532051f, 0.04138160f, 0.03649014f, 
    0.04155515f, 0.16119893f, 0.11055829f, 0.00556299f, 0.05564524f, -0.15552552f, -0.06344995f, -0.04741830f, 
    -0.24653178f, -0.20721257f, -0.05216870f, -0.22481987f, -0.05180955f, -0.06662012f, 0.01274098f, -0.01707011f, 
    -0.00966791f, -0.10571147f, 0.02434058f, -0.10061089f, -0.48193240f, 0.08162653f, -0.06935897f, 0.24283682f, 
    0.09570229f, 0.18809398f, -0.06822848f, 0.05034153f, 0.03195120f, 0.13453014f, 0.02312344f, 0.10545073f, 
    -0.03425276f, -0.23171580f, -0.13446239f, -0.05089812f, -0.14457695f, -0.07518948f, 0.02780412f, 0.01016729f, 
    0.02177347f, 0.12083276f, 0.11840619f, 0.07783818f, -0.00046439f, -0.16762106f, 0.08649869f, 0.32868013f, 
    0.10685664f, 0.02164055f, 0.08584376f, -0.11166763f, 0.08926371f, 0.00095265f, -0.00623191f, 0.11192589f, 
    0.02154422f, -0.00351527f, -0.18050557f, -0.00200585f, -0.11375807f, 0.05062784f, 0.04868348f, -0.06438907f, 
    0.09188816f, 0.10102278f, -0.05717346f, -0.00264788f, -0.32625517f, -0.01592477f, 0.01792502f, 0.13231078f, 
    -0.03122143f, -0.01677099f, -0.14067495f, 0.11223455f, -0.00353863f, 0.07853790f, 0.13062574f, -0.02145299f, 
    -0.34538096f, 0.42541483f, 0.15072408f, -0.04102606f, 0.06824943f, 0.07778070f, 0.03875436f, -0.04287609f, 
    0.00304773f, 0.01371775f, 0.13936831f, 0.10394354f, -0.09958587f, 0.37821752f, 0.11355427f, -0.05241463f, 
    -0.00847592f, -0.00444623f, 0.02027119f, 0.11524556f, 0.09196714f, 0.04248841f, 0.05663656f, -0.05110222f, 
    -0.25605369f, -0.01385546f, 0.12833869f, 0.12683859f, 0.11530394f, 0.17512317f, 0.00838881f, -0.05196211f, 
    0.07638436f, 0.03021697f, 0.06016789f, 0.00601151f, -0.07935414f, -0.20803250f, -0.12881999f, -0.16607851f, 
    -0.02462843f, -0.07204198f, 0.01068055f, 0.08518091f, 0.02015875f, -0.00850178f, -0.08862964f, -0.09337666f, 
    0.09332423f, 0.28177175f, 0.34772801f, 0.07932276f, -0.03269617f, -0.02965013f, 0.10301340f, -0.02439343f, 
    -0.10215352f, 0.08607593f, -0.05597685f, -0.02163082f, -0.00931472f, 0.28604844f, 0.19666922f, 0.13135055f, 
    -0.00521946f, -0.03502001f, 0.05561309f, -0.05305827f, 0.04103382f, 0.08731851f, 0.00457895f, 0.13448322f, 
    0.00166265f, -0.23608750f, 0.24164113f, 0.25962016f, 0.19411643f, 0.18048494f, 0.10561563f, -0.02418955f, 
    0.05038790f, 0.01933655f, 0.06082662f, -0.02851938f, -0.07165190f, -0.19010617f, -0.01031271f, 0.02614391f, 
    -0.07243969f, 0.08488823f, 0.11292214f, -0.04836734f, 0.02836372f, 0.05405573f, -0.13642897f, 0.05089397f, 
    -0.18197589f, -0.10416612f, 0.14929838f, 0.15578678f, 0.14635016f, 0.09107840f, -0.24438363f, 0.13580036f, 
    0.06118264f, -0.01279561f, 0.14724781f, 0.05307018f, 0.07183921f, -0.07646995f, -0.00743636f, -0.01964932f, 
    -0.04264052f, 0.07720362f, -0.02204556f, 0.00598901f, 0.05545838f, 0.01149564f, 0.03649225f, -0.01188050f, 
    0.16041397f, -0.09017232f, -0.08109424f, 0.02847311f, 0.04239763f, 0.18648493f, 0.11791691f, 0.06684199f, 
    0.04759821f, 0.07609499f, -0.04406347f, 0.05561727f, 0.28325513f, 0.30054569f, 0.16511297f, 0.40042976f, 
    0.02942435f, -0.10889746f, 0.05527422f, 0.09456935f, 0.12295982f, 0.15935393f, 0.02508131f, 0.05907079f, 
    -0.34696490f, 0.40684333f, 0.09399290f, -0.11266486f, 0.05850615f, 0.11788751f, -0.08121033f, -0.02442332f, 
    -0.06097364f, 0.07320087f, 0.03017807f, 0.19526601f, 0.15529732f, -0.03726453f, -0.31543472f, 0.00365780f, 
    0.14122637f, 0.06404491f, -0.01259210f, -0.00926957f, -0.00154355f, 0.18318309f, 0.04637558f, 0.11134562f, 
    -0.28218314f, 0.09570796f, 0.12953669f, 0.07455086f, -0.03550578f, -0.03574432f, 0.02124805f, 0.28378624f, 
    -0.08902784f, 0.11011777f, -0.05534721f, -0.00948677f, -0.23121816f, -0.18044472f, -0.08895206f, 0.28434092f, 
    -0.02645922f, 0.09255674f, 0.17920308f, 0.00411587f, 0.04255188f, 0.02883079f, 0.08546494f, 0.05110672f, 
    -0.23858145f, -0.11450558f, -0.07168806f, 0.15895627f, -0.04755120f, 0.00304313f, -0.12800299f, 0.03533252f, 
    0.01754429f, 0.09211996f, -0.00612639f, -0.02070391f, -0.06361582f, -0.08734045f, -0.01513749f, 0.02696201f, 
    0.05624013f, -0.08568087f, 0.06267624f, 0.08350443f, 0.00057145f, 0.09116495f, -0.05269834f, 0.03507242f, 
    0.06947421f, 0.12572980f, -0.14665172f, -0.01899987f, 0.05788735f, 0.15933551f, 0.12758960f, 0.14709382f, 
    0.07400449f, -0.01567496f, 0.06443079f, 0.05615339f, 0.28155854f, 0.12071645f, 0.25795409f, -0.14851055f, 
    -0.10651370f, 0.06208253f, -0.04548334f, -0.00627561f, 0.03012518f, -0.00198818f, 0.06721932f, 0.07228587f, 
    -0.03643169f, -0.01663499f, 0.03029978f, 0.02147251f, -0.04171964f, -0.01344827f, -0.00178868f, 0.02249062f, 
    0.03723124f, 0.01621192f, -0.00123858f, -0.00658733f, -0.03417121f, 0.00840829f, 0.03891036f, -0.02347763f, 
    0.03968166f, 0.00672795f, 0.00720967f, 0.01769014f, -0.03161842f, -0.02925106f, -0.05486143f, -0.04651235f, 
    -0.04907833f, 0.01616157f, -0.03978666f, -0.03550611f, 0.04481713f, -0.05088415f, -0.00232806f, -0.02795289f, 
    -0.00869061f, 0.03577014f, 0.03760475f, -0.04016773f, -0.01440655f, -0.00022373f, -0.02090186f, 0.01286276f, 
    0.02231275f, -0.05213878f, 0.00634594f, -0.00602947f, 0.04355671f, -0.03247533f, -0.05131346f, 0.00128676f, 
    -0.01850740f, -0.04439824f, 0.00606254f, 0.03880632f, -0.04720263f, 0.00142406f, 0.01292549f, 0.01330601f, 
    0.01768032f, -0.01043196f, -0.03271399f, 0.01371706f, -0.03129571f, 0.02118398f, 0.04163194f, -0.04495474f, 
    0.03717823f, -0.03798476f, -0.05549790f, 0.03551091f, -0.03173847f, -0.00323332f, 0.00603731f, -0.04084255f, 
    0.03642296f, -0.03251426f, 0.03607155f, -0.03273837f, -0.03696262f, -0.02765469f, -0.03748284f, 0.03827263f, 
    -0.03624974f, -0.02577062f, 0.01304262f, 0.00946221f, 0.02069560f, -0.03719740f, 0.00962108f, 0.02998470f, 
    -0.04973775f, -0.00366063f, -0.00812096f, -0.01200621f, -0.04641199f, 0.02499828f, -0.02097139f, 0.03825737f, 
    -0.03606534f, -0.00751030f, -0.02690645f, -0.03648212f, 0.02226086f, -0.04562297f, 0.01625205f, -0.01532247f, 
    0.03022592f, -0.01114541f, 0.02011261f, 0.02713584f, -0.00619825f, -0.05204056f, 0.02893324f, 0.00053518f, 
    -0.05195048f, -0.04519340f, 0.00963133f, 0.00126502f, 0.02385717f, -0.00606839f, 0.03140511f, -0.01964442f, 
    -0.03611789f, 0.03363290f, -0.02848516f, 0.00801124f, 0.01568685f, -0.00613977f, -0.05170514f, -0.00485562f, 
    -0.03669814f, -0.00037066f, 0.03918557f, -0.03380664f, -0.05534031f, 0.00922525f, -0.01886419f, -0.04928010f, 
    -0.05209763f, -0.02042904f, 0.00223021f, -0.04146103f, -0.05189497f, -0.02609471f, 0.00554191f, 0.01589882f, 
    -0.04858371f, -0.03160939f, 0.03648176f, 0.00982625f, 0.02169360f, -0.04304344f, -0.03760159f, 0.01645865f, 
    -0.04799214f, -0.01494574f, -0.03291180f, -0.00441973f, 0.04248093f, 0.01197314f, -0.00765010f, 0.00994404f, 
    -0.01995500f, -0.04081868f, 0.00636963f, -0.04751667f, 0.00506495f, -0.03534405f, -0.02231611f, 0.00372136f, 
    -0.04398396f, 0.02150488f, 0.01170299f, 0.02810811f, -0.01216764f, -0.00305930f, -0.04160238f, -0.01703243f, 
    -0.02405563f, -0.01879477f, -0.00132145f, -0.02271832f, 0.01955583f, -0.02099772f, -0.04283430f, 0.00376212f, 
    -0.03841034f, -0.04306414f, -0.01813770f, 0.00437504f, 0.02764874f, 0.02911889f, -0.03242460f, 0.01178108f, 
    -0.01246484f, 0.00248540f, -0.01993499f, -0.03140154f, 0.01786703f, 0.02213635f, 0.03662520f, -0.04003573f, 
    0.00814948f, 0.01122544f, 0.01957227f, -0.01276106f, -0.02664509f, -0.03213288f, 0.02426782f, 0.04106279f, 
    0.01765191f, 0.00808803f, -0.02266447f, 0.02472446f, -0.00791106f, -0.03705395f, 0.00467706f, -0.04339933f, 
    -0.04351271f, -0.04353599f, 0.01711566f, 0.03400609f, -0.02331966f, -0.02774481f, -0.03885463f, -0.05676622f, 
    -0.02274065f, -0.00846946f, 0.03680573f, 0.03837754f, 0.02667274f, -0.04953988f, -0.02576667f, 0.02522338f, 
    -0.04455113f, 0.01420956f, -0.04295361f, 0.03019067f, -0.01393694f, 0.03998942f, 0.00498360f, -0.04303364f, 
    -0.02715564f, -0.00868382f, -0.04981156f, -0.03146316f, -0.02182944f, -0.05437687f, 0.01592848f, -0.00307054f, 
    0.04419680f, 0.02091983f, 0.01740087f, 0.01679272f, 0.03657328f, -0.05423239f, 0.04415641f, -0.03479525f, 
    -0.05303932f, -0.03111484f, -0.03354548f, -0.00442364f, -0.03395364f, -0.00056813f, 0.00308604f, -0.01605208f, 
    -0.04765389f, -0.01518671f, -0.02669213f, 0.02677887f, -0.00845947f, 0.00946817f, -0.00208096f, -0.05082945f, 
    0.00217272f, 0.00559512f, -0.05484855f, -0.04159857f, 0.01606467f, -0.05570696f, 0.04489687f, 0.02961658f, 
    0.01099496f, 0.02903470f, 0.03865311f, 0.00678900f, -0.02577072f, 0.03174931f, -0.02289589f, -0.03495851f, 
    -0.00679512f, -0.00018271f, -0.00195162f, 0.04233791f, -0.00064950f, -0.00311275f, -0.03982069f, 0.01168852f, 
    0.00224018f, 0.00681625f, 0.01015989f, 0.03120439f, -0.05463123f, -0.04730099f, 0.00800543f, 0.01533292f, 
    -0.05092407f, 0.03601613f, -0.01026523f, 0.03066765f, 0.00391166f, 0.02784167f, -0.05205402f, 0.02252252f, 
    -0.03328239f, -0.03630732f, -0.03222590f, 0.02525839f, -0.03550463f, -0.01208721f, -0.00098802f, 0.04443178f, 
    -0.01342428f, -0.02405632f, -0.04516753f, -0.02865228f, 0.02416393f, 0.02387205f, -0.03371861f, 0.03069036f, 
    -0.01094724f, -0.00611194f, 0.00722036f, -0.05666384f, 0.03465776f, -0.03152436f, 0.04466928f, -0.02071487f, 
    -0.05219489f, 0.00265358f, 0.03138614f, -0.03507341f, 0.00062169f, 0.03013563f, -0.03831717f, -0.05674534f, 
    -0.01437813f, 0.03698432f, -0.00804630f, 0.01295216f, 0.04061463f, 0.04473879f, -0.00771627f, 0.03485238f, 
    -0.05241561f, 0.01583488f, -0.00602968f, -0.01197807f, -0.00286846f, -0.02267484f, 0.00401708f, -0.00782084f, 
    0.03018111f, 0.01158700f, -0.05666490f, 0.04008904f, -0.04017203f, 0.02112519f, -0.01281970f, 0.01534185f, 
    -0.05384992f, 0.02789598f, -0.02656833f, -0.00983988f, -0.04558524f, 0.01105501f, -0.03196190f, -0.03302141f, 
    -0.03806787f, -0.04130433f, 0.02114383f, -0.01502775f, -0.03110362f, -0.03534970f, 0.00371050f, 0.03813503f, 
    0.02507067f, 0.14561883f, -0.04096664f, -0.04569177f, -0.06495081f, -0.13246670f, -0.01530163f, -0.12126698f, 
    -0.01025310f, -0.14767662f, -0.02452136f, -0.13321042f, -0.00605956f, 0.02063125f, -0.01575380f, -0.07190309f, 
    -0.00205110f, 0.22959159f, -0.13494201f, -0.04065076f, -0.03781248f, 0.01907112f, 0.13450195f, 0.09411181f, 
    -0.06302556f, -0.13170432f, -0.03231405f, -0.17120257f, -0.03974476f, 0.10582606f, 0.06393045f, 0.08104998f, 
    -0.01785826f, -0.01879147f, 0.17025225f, -0.03292798f, -0.13936603f, 0.06212900f, 0.04163266f, 0.11096555f, 
    -0.09221556f, -0.03168968f, 0.03334459f, -0.04165316f, 0.22915539f, -0.04735410f, 0.10214870f, 0.29433990f, 
    -0.11931258f, 0.19721663f, -0.23963864f, -0.01956498f, 0.16050230f, -0.00731962f, 0.09076006f, 0.03192956f, 
    0.15287584f, 0.09238498f, 0.09334422f, -0.06821550f, -0.00571498f, -0.15900655f, 0.10600822f, -0.12099547f, 
    -0.04264487f, 0.03052210f, -0.01138524f, 0.00947419f, -0.18672886f, -0.10367829f, -0.21032192f, -0.11082596f, 
    0.19109833f, 0.17477480f, 0.21495283f, 0.10616630f, -0.12290546f, -0.01792213f, -0.09674082f, -0.07986272f, 
    -0.20019105f, -0.16581622f, -0.11771403f, -0.01608005f, 0.11451607f, 0.57506239f, -0.24252884f, 0.30207652f, 
    0.12318465f, -0.04858463f, 0.16417183f, 0.06737893f, 0.12333503f, 0.05280409f, 0.09167329f, 0.03590895f, 
    0.21937539f, -0.02231982f, 0.02578157f, -0.15452008f, -0.00170320f, -0.03093754f, -0.00500484f, -0.01219664f, 
    -0.08311279f, 0.06236746f, 0.00249830f, 0.00136499f, 0.03767521f, -0.01916937f, 0.04537593f, 0.10953613f, 
    0.03014174f, 0.05565733f, 0.05925275f, -0.12821583f, 0.04177861f, 0.02533911f, 0.07988535f, 0.13739085f, 
    -0.00047853f, 0.05132802f, 0.10199133f, 0.07944081f, -0.11626294f, -0.00926467f, -0.04178097f, 0.09399274f, 
    -0.11223163f, -0.03752251f, -0.05999744f, -0.17496584f, 0.22354794f, 0.23893474f, -0.22519682f, -0.15547413f, 
    0.18620884f, 0.20766255f, 0.12125771f, -0.02957050f, 0.07983597f, -0.01208522f, 0.07507297f, -0.05161438f, 
    -0.04236836f, 0.23877743f, 0.00018142f, 0.12116644f, -0.06273920f, 0.05214178f, -0.11424689f, 0.01229633f, 
    -0.13154064f, -0.01225423f, 0.10100757f, -0.06925730f, 0.11951412f, -0.00790934f, -0.13890608f, -0.09330866f, 
    -0.05956525f, -0.01611183f, 0.03349769f, 0.17296024f, 0.01222453f, 0.06736945f, -0.03255782f, -0.08602369f, 
    0.08940120f, -0.08430941f, -0.28687665f, 0.03872925f, -0.09659139f, 0.12763248f, -0.08835111f, -0.00369377f, 
    -0.05428517f, 0.04901695f, 0.05058175f, -0.03844527f, 0.06021581f, -0.05070028f, -0.13678578f, -0.05823541f, 
    -0.07688758f, -0.04106307f, -0.09941433f, -0.14392839f, -0.00557471f, -0.06653812f, 0.02350791f, 0.04406855f, 
    -0.01225386f, -0.20192622f, -0.05439477f, 0.00269839f, -0.15039107f, 0.06713358f, -0.05826373f, 0.10438459f, 
    -0.11072186f, -0.02157263f, 0.04153676f, -0.02255941f, -0.12468161f, -0.14100544f, -0.05627512f, 0.11357170f, 
    -0.07457203f, -0.06859972f, 0.07573714f, 0.10218830f, 0.17202193f, 0.15362281f, 0.06360576f, 0.08196351f, 
    0.00751192f, -0.06076801f, -0.13297641f, -0.06789268f, 0.02922304f, 0.04967719f, 0.09621153f, -0.01573108f, 
    0.04298373f, 0.02922908f, -0.02415141f, 0.12065886f, 0.09339983f, 0.10438079f, 0.08611158f, 0.02940884f, 
    -0.05835352f, 0.02633469f, 0.02005920f, 0.10790193f, -0.18673795f, 0.09634816f, -0.01710812f, -0.05220088f, 
    -0.16616163f, 0.28097701f, -0.36008760f, 0.08396396f, 0.01115855f, 0.27038646f, 0.04073853f, -0.05122604f, 
    -0.05721130f, 0.06281725f, 0.01040827f, 0.12806931f, -0.07187099f, 0.06655331f, -0.03421316f, -0.00921638f, 
    -0.03883318f, -0.04685488f, -0.04138696f, 0.06830557f, 0.21323125f, 0.15282379f, -0.04103570f, 0.02268255f, 
    0.19781251f, -0.12761347f, 0.14548659f, -0.00347353f, 0.05620547f, 0.08615382f, 0.04217952f, 0.15925631f, 
    -0.01332833f, 0.00315135f, 0.03390358f, 0.04434547f, 0.08236390f, -0.27351043f, 0.11980438f, -0.00479493f, 
    0.13752997f, 0.01351428f, 0.12649110f, 0.10058516f, 0.09836338f, 0.10570253f, -0.00958611f, 0.10860949f, 
    -0.34724909f, -0.11353175f, -0.22235753f, -0.17741942f, 0.07218517f, -0.00371224f, -0.03853737f, -0.10176642f, 
    0.07064839f, 0.06804043f, 0.06660305f, 0.20273700f, 0.03497720f, 0.07762626f, 0.17781168f, -0.30518782f, 
    0.15062878f, 0.04251165f, 0.08388902f, 0.11900382f, 0.10458203f, 0.04281621f, 0.23209102f, -0.01637186f, 
    -0.22403364f, -0.07631926f, -0.22089410f, -0.22401707f, 0.03758872f, -0.02050378f, -0.03790008f, 0.13225552f, 
    -0.03359136f, 0.06327172f, 0.05403583f, -0.12895012f, 0.15686727f, -0.01556853f, -0.00643628f, 0.09105155f, 
    0.09134065f, -0.01390620f, 0.05349118f, -0.12055484f, -0.00322146f, -0.07963482f, 0.08397774f, 0.08631974f, 
    0.10626122f, 0.08883179f, -0.07434190f, -0.08662863f, 0.15964526f, -0.02088003f, 0.08705281f, -0.14263624f, 
    -0.04610255f, -0.02570020f, -0.03180524f, 0.05017236f, -0.08438408f, -0.07505215f, -0.01576969f, -0.20056239f, 
    0.14216711f, 0.10386907f, 0.08066715f, -0.03520563f, -0.09745430f, -0.01206890f, -0.00176130f, 0.02020286f, 
    0.02457087f, 0.11309075f, -0.02337362f, -0.02010825f, 0.24402003f, 0.11384066f, 0.27601469f, 0.11618625f, 
    0.04386620f, -0.07959809f, 0.05917655f, 0.07230101f, 0.20399059f, 0.04456089f, 0.34296444f, -0.10102383f, 
    0.03920360f, 0.00258983f, 0.04156543f, 0.09008445f, -0.09732077f, 0.11841045f, -0.02966440f, 0.09533352f, 
    0.01989965f, -0.05012248f, 0.14805621f, 0.10234039f, -0.04404614f, 0.04118092f, -0.04361032f, 0.05332851f, 
    -0.02434086f, 0.08186395f, -0.04344980f, 0.10872319f, 0.02325667f, 0.06612223f, -0.06364568f, -0.04589597f, 
    0.06845295f, 0.02242617f, 0.13177501f, -0.08690112f, 0.06624635f, 0.02506099f, -0.11465323f, -0.09271731f, 
    0.11989655f, 0.28573081f, 0.28207999f, 0.21514219f, 0.14801073f, 0.07986534f, 0.01156441f, 0.10027830f, 
    0.13896765f, -0.07377599f, -0.00514802f, 0.03242923f, 0.04409286f, -0.05443171f, 0.10714166f, -0.14486602f, 
    0.01328479f, -0.14060119f, -0.15465061f, -0.22865714f, -0.05102775f, 0.05668766f, -0.09498168f, -0.05463709f, 
    0.17817706f, -0.19149612f, 0.37975430f, -0.19855967f, 0.04274457f, -0.00924688f, -0.07844874f, 0.01006678f, 
    -0.03290838f, 0.07863019f, -0.05442400f, 0.01952391f, 0.11787214f, 0.32747436f, 0.15996937f, 0.17870885f, 
    0.05076068f, -0.08490407f, -0.00888531f, 0.10220055f, 0.09246546f, 0.11764292f, 0.02676967f, 0.07781546f, 
    -0.01481750f, -0.11112086f, -0.09625264f, 0.21239857f, 0.15183641f, 0.04895361f, 0.02667153f, 0.00859644f, 
    0.01876082f, 0.06650738f, 0.05009189f, 0.08234312f, -0.17071915f, -0.29660437f, 0.28153706f, -0.35123181f, 
    0.06569988f, 0.04118988f, -0.18577352f, 0.07006658f, -0.00530068f, 0.02948206f, -0.03358961f, -0.01836329f, 
    -0.08725899f, 0.23690844f, -0.01745740f, -0.06564364f, 0.13937342f, 0.08384837f, 0.11247715f, 0.04827716f, 
    0.07140537f, 0.01525990f, 0.01158743f, 0.01100588f, 0.26809967f, 0.05714192f, -0.22330657f, 0.15241024f, 
    -0.01590638f, 0.14727184f, 0.07906715f, 0.19439340f, 0.03950501f, -0.05102640f, 0.05074010f, -0.01365768f, 
    -0.09292474f, -0.04130662f, -0.09383376f, -0.08139367f, -0.11309709f, -0.05783422f, 0.11751474f, -0.02219124f, 
    0.10883445f, 0.02313690f, -0.03830287f, 0.15122077f, -0.16625650f, -0.00823408f, 0.00061549f, -0.20837675f, 
    0.00370861f, -0.03216800f, -0.19770877f, 0.01410105f, -0.01488223f, 0.01064066f, 0.04532054f, 0.12452888f, 
    -0.00040858f, -0.15130430f, 0.10881700f, 0.00725308f, 0.06454559f, -0.13637058f, -0.07346906f, 0.09174965f, 
    -0.03126239f, 0.01870692f, 0.12897554f, 0.11612466f, 0.12460730f, -0.30634704f, 0.17884307f, -0.02437830f, 
    0.01774146f, -0.11950275f, -0.02437439f, -0.20308299f, 0.06158084f, 0.01095437f, -0.06427477f, -0.04944784f, 
    0.36392584f, 0.20007904f, -0.00564969f, 0.15210937f, 0.04315515f, 0.01808390f, 0.07010709f, 0.17907351f, 
    0.04342678f, -0.06319973f, -0.02672653f, -0.08429129f, -0.24204624f, -0.13339753f, -0.03269873f, 0.15821810f, 
    0.19166476f, 0.09335771f, -0.00624602f, 0.16101687f, -0.12644833f, 0.05923171f, 0.11715046f, -0.05031470f, 
    -0.10369435f, 0.36820707f, -0.15302965f, 0.13070107f, 0.03467148f, -0.07760227f, -0.03396059f, 0.02563902f, 
    0.02819194f, -0.01595556f, -0.01938782f, 0.03533572f, 0.06849095f, 0.02149640f, -0.19126831f, -0.38337395f, 
    -0.18659279f, 0.05597173f, -0.18117376f, -0.22360994f, 0.11354857f, -0.04147689f, -0.02030348f, -0.03198574f, 
    0.27443403f, 0.05543743f, 0.25425816f, -0.02724726f, 0.02265009f, 0.01883831f, -0.00951359f, 0.20261553f, 
    -0.05688296f, 0.04265117f, 0.02803903f, -0.11932909f, -0.14379483f, -0.12305125f, -0.06216834f, -0.05698593f, 
    0.15219551f, 0.00493361f, 0.16251795f, 0.02877846f, 0.11104841f, -0.10367673f, -0.03803390f, -0.04427062f, 
    0.15714461f, -0.05998230f, -0.05109001f, -0.25579301f, 0.05107323f, 0.04589099f, 0.18496788f, 0.00438603f, 
    0.05266443f, -0.04877894f, -0.10062408f, 0.01042664f, -0.16815178f, -0.17131495f, 0.07098255f, -0.03579232f, 
    0.06620836f, -0.03835720f, 0.02522576f, -0.08571931f, 0.22995967f, -0.03225871f, -0.10757023f, -0.03842147f, 
    -0.08464266f, 0.41411102f, 0.23847634f, 0.14095040f, -0.06913072f, -0.02384191f, -0.01978014f, 0.08416597f, 
    0.05762745f, -0.06756981f, 0.03291217f, -0.06853177f, -0.29485801f, 0.04432325f, -0.03294758f, -0.62673753f, 
    -0.07066314f, -0.13783751f, -0.02816905f, -0.13489784f, 0.02473589f, -0.01891760f, 0.05739262f, -0.01404847f, 
    0.32686752f, 0.26415721f, -0.07003031f, 0.31204715f, -0.02618047f, -0.06297091f, -0.19228461f, -0.08828145f, 
    0.08550920f, -0.04520765f, 0.03531017f, -0.04333761f, -0.19639841f, 0.13533269f, 0.35061702f, 0.36142603f, 
    -0.08324944f, 0.07345479f, -0.08102381f, -0.22077125f, 0.07966994f, -0.00454067f, -0.06724751f, -0.01705224f, 
    0.29681104f, -0.28732130f, -0.04683222f, -0.03588723f, -0.00104587f, -0.11741704f, -0.14865305f, -0.07907672f, 
    0.14258818f, 0.01976699f, 0.04307767f, 0.12306950f, 0.31485429f, 0.12104886f, 0.10336097f, 0.15622315f, 
    0.02314440f, 0.07053354f, -0.02651166f, 0.26396000f, 0.01110315f, 0.12116849f, -0.02354679f, -0.06725409f, 
    0.04525767f, 0.22931436f, 0.25129890f, -0.08372412f, 0.22025497f, 0.20042315f, 0.20305850f, 0.27350724f, 
    0.00013865f, -0.03504970f, 0.11444563f, 0.02065989f, 0.16179320f, -0.15716052f, -0.05172718f, -0.02332456f, 
    0.06834154f, -0.01047722f, 0.02503924f, 0.08154572f, 0.12423030f, -0.05021928f, -0.07708689f, 0.06228183f, 
    -0.01970268f, -0.22224858f, -0.10289896f, -0.12463779f, 0.04458680f, 0.06864446f, -0.01270691f, -0.07617309f, 
    -0.13916148f, 0.10217065f, -0.16011629f, -0.14013804f, -0.23989984f, 0.07387191f, -0.31272414f, 0.40074635f, 
    -0.05796461f, 0.01114507f, 0.05101566f, -0.04207696f, 0.06984762f, -0.09629677f, -0.11710378f, 0.00710516f, 
    -0.02622081f, -0.01088568f, -0.04097569f, -0.00320488f, -0.05230106f, -0.04562900f, -0.00870468f, -0.02863787f, 
    0.00343123f, 0.00479363f, -0.03132276f, -0.05554407f, 0.00697093f, -0.07235854f, 0.01246012f, -0.01017819f, 
    0.04038062f, -0.04664245f, -0.01752735f, 0.00123377f, 0.01446392f, 0.03706658f, -0.03071646f, -0.02325884f, 
    0.02781831f, 0.01314537f, 0.05485793f, -0.04499993f, -0.03040113f, 0.01462722f, 0.04253629f, 0.02898546f, 
    -0.06738843f, 0.01484289f, -0.02371120f, -0.01067856f, -0.05829754f, 0.02067781f, 0.00004610f, -0.07394481f, 
    -0.00122419f, -0.01467927f, -0.01513927f, -0.03635481f, -0.00108953f, 0.01384286f, -0.00544451f, 0.06661814f, 
    -0.01322436f, 0.00712973f, -0.04378618f, -0.06752598f, 0.03758510f, 0.02266105f, -0.04291219f, -0.04175415f, 
    0.04293543f, -0.07015996f, -0.00116573f, -0.05224800f, 0.03701372f, -0.05579901f, -0.06953937f, 0.03350007f, 
    0.03708028f, 0.00231436f, -0.04794068f, -0.00362091f, 0.01887091f, 0.01381793f, 0.00210347f, -0.07295031f, 
    -0.04798651f, -0.06188330f, -0.03444175f, -0.01746326f, -0.01205100f, -0.06755348f, -0.00684668f, -0.08024808f, 
    -0.00488318f, 0.02090733f, -0.06744067f, -0.04669989f, -0.01895413f, 0.02545309f, 0.02749542f, -0.00921285f, 
    0.02410574f, -0.02583138f, 0.02310616f, 0.04128186f, -0.02466616f, -0.01485857f, -0.03760737f, -0.04409711f, 
    -0.03393320f, 0.06511415f, -0.02989497f, 0.02077929f, -0.02937020f, -0.03968563f, 0.03962594f, -0.00068266f, 
    -0.00518402f, -0.07161232f, -0.01570401f, -0.02983685f, 0.06832509f, 0.00118840f, -0.04685074f, -0.03210224f, 
    -0.02009476f, 0.04155348f, -0.04460815f, 0.01991645f, -0.03856726f, -0.06446201f, 0.02188303f, -0.08647728f, 
    -0.01555979f, -0.04102588f, -0.06248060f, -0.06143210f, -0.05180411f, -0.06149868f, 0.02245406f, -0.04764099f, 
    0.00798619f, -0.07152816f, 0.00884721f, -0.03436215f, -0.06397950f, -0.02653376f, -0.00941546f, 0.03625256f, 
    -0.01081740f, 0.05993549f, -0.02406345f, -0.02068103f, -0.07939372f, 0.00114234f, -0.04537494f, -0.05891117f, 
    0.01300743f, -0.06155064f, -0.03923067f, 0.00582884f, 0.02096910f, -0.03765592f, 0.02249807f, -0.00359812f, 
    -0.02729655f, 0.03302981f, -0.01009206f, 0.00789776f, 0.03310173f, 0.03615488f, -0.01306953f, -0.07505486f, 
    -0.03294731f, -0.00387490f, -0.03997977f, -0.06530223f, 0.04719077f, 0.01000925f, 0.00582299f, 0.00033778f, 
    -0.01046440f, -0.03144310f, -0.01457633f, 0.02424636f, -0.01947764f, -0.00177749f, -0.07295391f, 0.03366490f, 
    -0.01181233f, -0.08311917f, -0.06856286f, -0.03911706f, 0.01215916f, -0.05033432f, -0.04189956f, -0.06656787f, 
    0.01782521f, 0.00276264f, 0.01651208f, -0.02352381f, -0.01249887f, 0.04296202f, -0.01772492f, 0.00068355f, 
    -0.06031960f, -0.05304382f, 0.02715018f, -0.06532164f, -0.01757627f, -0.00480326f, -0.03368842f, 0.00661839f, 
    0.01789952f, -0.02995581f, 0.03472117f, -0.07119865f, -0.03057335f, -0.00209560f, 0.01726997f, -0.03560399f, 
    -0.05455485f, -0.03594144f, -0.01654022f, -0.04067433f, 0.02288319f, 0.03426306f, 0.00215936f, 0.00277375f, 
    -0.08049063f, -0.04973030f, -0.05213212f, -0.03637639f, 0.02002604f, 0.02090414f, -0.04393931f, -0.02732872f, 
    0.01009152f, -0.02913735f, -0.06146661f, 0.01124164f, -0.05816597f, -0.01101713f, -0.05493066f, -0.00008085f, 
    -0.01589659f, -0.02012049f, -0.00276783f, -0.03863625f, -0.05418956f, -0.04968660f, 0.01165544f, -0.03892309f, 
    -0.01611658f, -0.03216310f, -0.01331760f, 0.03943593f, 0.03560350f, -0.00911792f, 0.05157594f, -0.03437263f, 
    0.01627983f, -0.01905233f, -0.05724234f, -0.04508630f, 0.00376727f, -0.01797412f, -0.02726851f, -0.05214567f, 
    -0.05898428f, 0.01389309f, -0.07835195f, 0.00667917f, 0.03826316f, 0.00939598f, 0.01018531f, -0.02096548f, 
    -0.01771643f, 0.00953520f, -0.00603789f, -0.02487384f, 0.03867709f, -0.04679495f, 0.03308888f, -0.01147813f, 
    -0.00273271f, -0.00436327f, -0.07554923f, -0.09094122f, -0.02902731f, -0.04157868f, -0.01555005f, -0.02305764f, 
    -0.00898851f, -0.02306156f, 0.02114562f, 0.04908534f, -0.06469437f, 0.02956932f, -0.03035040f, 0.01622408f, 
    -0.01625409f, -0.02614940f, -0.04208300f, -0.04371503f, 0.02222844f, 0.03694601f, 0.01444944f, -0.03083664f, 
    0.01875545f, -0.03037228f, 0.01386456f, 0.05460773f, -0.03708451f, -0.08150027f, -0.07888778f, -0.02154272f, 
    0.02082421f, -0.04799557f, -0.00695416f, -0.05392720f, 0.06482062f, 0.01358122f, 0.02503652f, 0.01703866f, 
    -0.02772250f, -0.04986115f, 0.01299779f, -0.05744253f, 0.00337452f, -0.02391781f, -0.01910837f, 0.04599206f, 
    0.03572842f, -0.07058291f, -0.05755980f, -0.01852190f, -0.04041168f, 0.04858498f, 0.02609318f, 0.04229277f, 
    0.03716809f, 0.04924103f, 0.01438554f, 0.03960412f, -0.01598114f, -0.02879233f, -0.05089778f, 0.00803093f, 
    0.03805654f, 0.02847627f, -0.02379432f, 0.02762698f, 0.06502595f, -0.04322432f, 0.03349441f, -0.00750973f, 
    -0.05199423f, -0.07011849f, -0.05909045f, -0.03838869f, -0.03419437f, 0.01398386f, 0.00514514f, 0.00595484f, 
    -0.07831886f, -0.05381890f, 0.00873271f, -0.04575946f, -0.05218800f, -0.04677338f, 0.00955245f, -0.07764326f, 
    0.01024964f, 0.02603684f, -0.04554978f, -0.06379655f, -0.02477203f, -0.03002685f, 0.06241903f, 0.03010808f, 
    -0.04011245f, 0.00094146f, -0.06708068f, 0.02992676f, -0.00842777f, 0.00900950f, -0.05712192f, -0.00196405f, 
    -0.06422265f, -0.07428118f, -0.01075285f, -0.03052732f, 0.00405619f, -0.02185571f, -0.06751708f, -0.00159400f, 
    0.07206751f, 0.01575898f, 0.10058489f, -0.07198885f, -0.09532184f, -0.09261095f, 0.04162597f, -0.02483884f, 
    -0.03244803f, 0.05445679f, -0.02767499f, 0.04970220f, -0.26596618f, 0.15274246f, 0.09272096f, 0.02496487f, 
    0.06706262f, -0.03155659f, -0.07591822f, 0.03195643f, -0.01025002f, -0.01049159f, 0.10616989f, 0.05742896f, 
    0.27936560f, -0.01934441f, -0.07901207f, -0.05874459f, 0.17947103f, 0.07696373f, 0.19334418f, 0.01830382f, 
    0.08044606f, -0.05685076f, 0.14046742f, -0.00722940f, -0.08739296f, -0.10361301f, 0.10329986f, -0.04718772f, 
    0.01880824f, -0.00367987f, -0.08124445f, -0.16190565f, 0.09061298f, 0.14363332f, 0.06977087f, 0.13270532f, 
    0.22062886f, -0.01450896f, 0.03277615f, -0.22829853f, 0.32115570f, 0.09806653f, -0.07122720f, -0.03376353f, 
    -0.10740221f, 0.05920602f, -0.14519595f, -0.02433713f, 0.05149102f, -0.01062307f, 0.02424835f, 0.11507846f, 
    0.16305932f, -0.04303641f, -0.05139496f, 0.00247174f, 0.06414243f, 0.04909486f, -0.05659168f, -0.05655867f, 
    -0.00585415f, 0.12368302f, 0.01172655f, 0.05819318f, 0.03568389f, -0.08591208f, 0.02580313f, -0.02232931f, 
    -0.05225949f, -0.02144803f, 0.05098274f, 0.01947585f, 0.21018822f, 0.35131720f, 0.19720013f, -0.06279462f, 
    0.14525190f, -0.02441638f, 0.01351071f, -0.02836299f, 0.02326680f, 0.02376523f, -0.01864036f, 0.03728795f, 
    0.02312770f, -0.01722031f, -0.03872587f, -0.07001019f, 0.05408580f, 0.08073072f, 0.09940731f, 0.01475305f, 
    0.02234063f, -0.00772266f, -0.07162117f, -0.08275176f, 0.04314441f, 0.03233507f, -0.07476318f, 0.13701952f, 
    0.01865393f, 0.21888202f, 0.01032386f, 0.09631089f, -0.01358838f, -0.01449714f, 0.01537321f, 0.04578710f, 
    -0.23910715f, -0.04111129f, 0.08897497f, -0.02113890f, -0.05768391f, -0.06313553f, -0.06399040f, 0.05782387f, 
    -0.13927753f, 0.02973429f, -0.04846165f, 0.02429429f, 0.16038549f, 0.05224402f, -0.24669316f, -0.25342694f, 
    0.10225902f, 0.08954891f, 0.13975376f, 0.11365730f, -0.09057719f, -0.03077108f, -0.06844276f, 0.08152659f, 
    -0.15836854f, 0.01121139f, 0.08912504f, 0.07524790f, -0.05827443f, -0.08390547f, 0.00818805f, -0.08474211f, 
    0.04418278f, -0.04489822f, 0.08991349f, -0.00685612f, -0.11156490f, -0.23952805f, 0.05028006f, 0.06013791f, 
    -0.03489752f, -0.04877758f, -0.00786307f, -0.00509758f, 0.05860139f, 0.00331321f, -0.02819942f, -0.11452720f, 
    0.02191508f, 0.29134598f, -0.16237853f, 0.08902112f, -0.07086225f, -0.02826798f, 0.04190534f, 0.02084692f, 
    -0.03427068f, -0.06738573f, 0.04245459f, -0.12410223f, -0.24726000f, 0.03463709f, 0.07105218f, 0.06705534f, 
    0.04582529f, 0.05750140f, -0.11790483f, -0.01947805f, -0.04741610f, -0.06809300f, 0.13560781f, 0.04401171f, 
    -0.07027703f, 0.02007875f, -0.20304765f, 0.33917242f, -0.02048172f, 0.01435143f, -0.01792265f, 0.00143725f, 
    0.06801838f, -0.05478297f, -0.00114243f, 0.02146112f, -0.21720107f, -0.08035825f, 0.02936142f, 0.10923915f, 
    -0.01683997f, 0.05256502f, -0.04964776f, -0.02316760f, 0.07179870f, 0.03178038f, 0.05776808f, 0.05877954f, 
    -0.04572770f, -0.05919224f, 0.06042906f, -0.05677870f, 0.04469418f, 0.06229755f, -0.05435033f, 0.13096146f, 
    -0.00613918f, -0.00891358f, 0.09832896f, -0.07198137f, -0.12271486f, 0.14237383f, 0.05504020f, -0.00864961f, 
    -0.07473262f, -0.03877516f, -0.03455361f, 0.05437112f, 0.01716230f, -0.00579870f, 0.09654270f, -0.13990240f, 
    -0.01530925f, 0.20442218f, -0.16752973f, 0.01982216f, -0.09175332f, 0.15312679f, 0.28071827f, -0.03093609f, 
    0.04494160f, 0.05042604f, -0.04029363f, 0.07742516f, 0.03247447f, -0.00048367f, 0.08862571f, -0.10490789f, 
    0.01524272f, -0.08219080f, 0.07207502f, 0.05297362f, 0.12516952f, 0.13679190f, -0.15195186f, 0.09875201f, 
    0.15751439f, 0.05507965f, 0.12374092f, 0.11334246f, 0.07308640f, 0.05955638f, 0.01748241f, 0.05291419f, 
    -0.05657584f, -0.09774550f, 0.12147692f, -0.01067450f, -0.26563078f, -0.28286207f, -0.05564721f, -0.12508591f, 
    -0.03456249f, 0.13417231f, 0.11432708f, -0.10659797f, -0.02217563f, 0.04052035f, -0.03986482f, 0.02652945f, 
    0.22057921f, -0.00904467f, -0.37391266f, -0.13564467f, -0.09879421f, -0.02246952f, 0.00398779f, -0.09146696f, 
    0.07985032f, 0.10161709f, -0.06539829f, 0.13891125f, 0.64039737f, 0.10322116f, 0.15356947f, -0.22394834f, 
    0.14857438f, 0.17642064f, -0.04412054f, -0.00696709f, -0.06321670f, 0.01716367f, 0.17331392f, 0.06166824f, 
    0.11099512f, -0.29544523f, -0.17639521f, -0.10250071f, 0.01765602f, -0.06628323f, -0.02625033f, 0.06719649f, 
    0.07375049f, 0.02261366f, 0.00385637f, -0.01066944f, 0.11240833f, 0.03785678f, 0.04699128f, 0.16330461f, 
    0.03934662f, 0.07899513f, 0.04612001f, 0.10117311f, -0.03347427f, 0.00036399f, 0.00149961f, 0.05447135f, 
    0.09012942f, 0.13446143f, -0.06109236f, -0.22987947f, 0.19738427f, 0.08675481f, 0.13177325f, 0.22488229f, 
    -0.00204035f, 0.00719746f, 0.03804997f, 0.06730320f, 0.20102009f, -0.17301619f, -0.14015688f, -0.23343612f, 
    0.13436007f, 0.07368860f, 0.06922223f, -0.05029902f, 0.09273100f, -0.05312002f, -0.08241425f, -0.00806623f, 
    0.11763672f, 0.04517692f, -0.06130062f, -0.00908720f, 0.03910184f, 0.15249594f, 0.15373266f, -0.06035249f, 
    0.04109332f, 0.20049597f, -0.03809728f, 0.03142732f, -0.08376603f, 0.14232408f, -0.05145194f, 0.29109639f, 
    -0.05719059f, 0.00903493f, 0.00101233f, -0.01917046f, 0.01205559f, 0.03092613f, -0.17733555f, 0.09118918f, 
    -0.01449735f, -0.09057574f, -0.02866862f, -0.01271171f, -0.04449496f, -0.07596993f, 0.08527488f, 0.09186396f, 
    0.24498671f, 0.22268957f, 0.14997812f, 0.14830028f, -0.04061037f, -0.17982550f, -0.14723614f, 0.04387962f, 
    0.08637963f, -0.00775608f, 0.03874962f, -0.04341947f, -0.23180540f, -0.21572471f, -0.26253611f, -0.39805734f, 
    0.08415947f, 0.16350053f, 0.20789132f, 0.04545635f, -0.01805629f, -0.18289775f, -0.09249988f, -0.07900497f, 
    -0.00489757f, -0.02483158f, 0.01864836f, -0.09178603f, 0.04491894f, 0.01967521f, -0.01584816f, -0.01350564f, 
    -0.03097681f, -0.14253487f, 0.01938432f, -0.00616813f, -0.05618301f, -0.00737018f, 0.01413983f, -0.11380973f, 
    0.06420169f, -0.18245463f, -0.03970719f, -0.00946820f, 0.04888922f, 0.05020491f, -0.00183525f, 0.08084634f, 
    0.11353622f, 0.02278499f, 0.06045445f, 0.05337775f, -0.00546015f, 0.13128823f, 0.08226638f, 0.02748185f, 
    0.00279250f, -0.00149820f, 0.08205400f, -0.07214752f, 0.29365113f, 0.18943793f, 0.27910587f, 0.15929008f, 
    -0.05833308f, -0.11078954f, -0.16884218f, -0.08370696f, -0.04274303f, 0.07310369f, -0.07833973f, -0.06127145f, 
    0.02305998f, 0.10446548f, 0.12547927f, 0.10885174f, -0.03117485f, -0.43722877f, 0.17966448f, 0.02933223f, 
    0.09389981f, 0.04923304f, -0.11302183f, 0.02873113f, -0.00204831f, 0.11706051f, 0.08175332f, 0.02306235f, 
    -0.20829339f, -0.04639477f, -0.08122317f, -0.02913138f, 0.02043574f, -0.02690587f, -0.08003873f, 0.03437961f, 
    0.06099506f, -0.03438198f, 0.04500216f, 0.17574537f, -0.02174173f, -0.03884495f, -0.02790508f, 0.03344539f, 
    0.03955551f, 0.06620412f, -0.09613511f, -0.03849059f, -0.07842822f, -0.08378147f, -0.10230345f, -0.12724614f, 
    0.19626544f, -0.17069313f, -0.28203550f, -0.00854012f, 0.07297951f, 0.04707206f, 0.02132412f, -0.10862616f, 
    0.09009931f, 0.08000852f, 0.11722073f, 0.21109788f, -0.26910692f, -0.15243407f, 0.17827486f, 0.11101778f, 
    -0.09643352f, 0.02085859f, -0.13086554f, 0.02063939f, -0.07514384f, 0.04182825f, 0.12148188f, 0.06872908f, 
    -0.25522056f, -0.21427077f, 0.01956847f, -0.06337523f, -0.06719992f, -0.01856670f, 0.11443003f, -0.01714505f, 
    0.18935306f, 0.18914688f, 0.07137529f, 0.09919707f, -0.07464336f, 0.14038701f, 0.03864321f, -0.00059234f, 
    -0.00964251f, -0.02960735f, 0.06510724f, 0.04115370f, 0.13484152f, 0.02405685f, 0.22597535f, 0.21523942f, 
    -0.11747344f, 0.01089681f, 0.17600545f, 0.07519704f, 0.06962831f, 0.06689408f, 0.09673423f, 0.04554980f, 
    0.08319975f, 0.10532673f, 0.20448747f, 0.20343654f, 0.10466516f, -0.13145040f, -0.03978928f, -0.03110876f, 
    0.07819017f, 0.16983920f, 0.11312973f, 0.11102098f, -0.22052845f, -0.14388227f, -0.19038042f, -0.28550082f, 
    0.13459757f, 0.29272252f, -0.03206306f, -0.00263559f, -0.04663711f, -0.00099722f, 0.07722493f, -0.07561390f, 
    0.21903841f, 0.23244692f, 0.10293905f, 0.05304464f, 0.29208782f, 0.25611123f, -0.04566415f, 0.01770574f, 
    -0.08195423f, -0.12902167f, -0.05534241f, -0.18929219f, -0.07928634f, -0.05339369f, -0.11957328f, -0.02184420f, 
    0.01253446f, 0.07203303f, 0.20219824f, 0.03321721f, 0.05820003f, 0.10485788f, 0.02797107f, 0.04722176f, 
    0.03830449f, 0.16319135f, 0.09513217f, -0.13871945f, 0.00199208f, -0.18636775f, -0.10512267f, 0.18093820f, 
    0.25457421f, 0.12982470f, 0.04517427f, -0.12869069f, 0.03383623f, -0.00453860f, -0.03218681f, 0.15675811f, 
    -0.05053343f, -0.34802696f, 0.27774483f, 0.00150778f, 0.03318664f, 0.06691971f, -0.26784304f, 0.10256337f, 
    0.00046365f, -0.16160390f, -0.03251777f, -0.23711963f, -0.05326283f, -0.02843327f, 0.03154527f, 0.22565085f, 
    -0.07781346f, 0.01227643f, 0.01900748f, -0.08413414f, -0.02622679f, -0.13167028f, 0.07523233f, -0.02549274f, 
    -0.04830085f, 0.17574562f, 0.02258357f, -0.06393040f, -0.02666459f, 0.03740479f, 0.22579458f, 0.00711149f, 
    0.06146346f, 0.15569857f, 0.10549840f, 0.09849778f, 0.14578629f, 0.35323599f, 0.06349989f, 0.03678314f, 
    -0.12466335f, -0.07227808f, -0.00293626f, 0.07437772f, 0.02957998f, -0.13784540f, -0.04093044f, -0.12388845f, 
    0.14254642f, 0.18894649f, 0.19860537f, 0.25740138f, -0.15119500f, -0.12611510f, -0.12578411f, -0.04750584f, 
    0.09681988f, 0.03203405f, 0.02270464f, -0.07908172f, -0.10454839f, -0.01084405f, 0.04408838f, 0.40145168f, 
    0.01609493f, 0.03896302f, -0.00228567f, -0.19810854f, 0.09241135f, 0.05253140f, 0.02870428f, -0.01547225f, 
    0.12510392f, 0.17665370f, 0.24410136f, 0.16395386f, -0.16095804f, -0.02023175f, 0.03776421f, 0.11066449f, 
    0.06502673f, -0.05913056f, -0.00567305f, 0.06337810f, 0.01361922f, -0.02703080f, -0.04015197f, -0.13076645f, 
    0.04757149f, -0.00400293f, 0.11584499f, 0.13593644f, 0.08058899f, 0.01566478f, -0.16023777f, 0.02438323f, 
    -0.02591096f, 0.05013944f, 0.03680644f, -0.08609746f, -0.07254475f, -0.06786240f, -0.04803130f, 0.12756130f, 
    -0.07077813f, -0.03880199f, -0.01675516f, -0.17168035f, 0.08941738f, 0.13275324f, 0.19539119f, 0.03612687f, 
    -0.15721208f, -0.10225615f, -0.05879720f, 0.05460867f, 0.13862368f, -0.02432808f, 0.01687599f, 0.00609785f, 
    -0.17399746f, -0.26675680f, 0.07795890f, -0.23556139f, -0.02288697f, 0.03463814f, -0.10810030f, -0.03741287f, 
    -0.15920940f, -0.12132382f, -0.06064166f, -0.18174300f, -0.00489610f, 0.06489042f, -0.10250435f, 0.06257007f, 
    0.21174569f, 0.02758749f, -0.01783066f, -0.17520274f, -0.01100453f, -0.08963480f, 0.09332332f, 0.10208904f, 
    0.08719280f, 0.05995911f, 0.08552689f, 0.03225745f, -0.01453106f, -0.03339612f, -0.08317988f, -0.04473131f, 
    0.14382869f, 0.04659565f, 0.08502782f, 0.08028478f, 0.10515531f, -0.08298086f, -0.03087458f, 0.08113548f, 
    0.03425683f, -0.16091268f, 0.18594646f, -0.02036180f, 0.01563616f, 0.01765568f, -0.04955105f, -0.03340007f, 
    -0.15330891f, -0.07638151f, -0.00080210f, 0.17213419f, -0.00736674f, -0.06574095f, -0.03813417f, -0.00114045f, 
    -0.11898463f, 0.03070204f, -0.00656528f, 0.10408512f, 0.24193926f, 0.17963357f, -0.04987549f, 0.04052029f, 
    0.04414673f, -0.00586996f, 0.06488147f, 0.13004735f, -0.02795487f, 0.08509567f, 0.01516784f, -0.07866700f, 
    -0.09233849f, -0.06054714f, -0.04440589f, -0.00019385f, -0.12342925f, 0.11612874f, -0.04925717f, 0.02699104f, 
    0.10107245f, -0.22515687f, 0.11928824f, -0.05935490f, -0.22684710f, -0.09595061f, -0.02465597f, 0.08753347f, 
    0.02168282f, 0.08616256f, 0.03648929f, 0.01162684f, -0.01700959f, 0.03345501f, 0.11580151f, -0.03734897f, 
    0.00087152f, -0.04854478f, 0.14244908f, -0.01779423f, 0.01782741f, -0.04819566f, 0.03854278f, -0.06019361f, 
    0.10008922f, 0.04090312f, -0.05364530f, 0.01544633f, 0.08336683f, -0.44665208f, 0.17518789f, -0.08306601f, 
    -0.07805022f, 0.11823124f, 0.06192607f, 0.08706220f, 0.02065136f, 0.11281388f, 0.07932799f, -0.02786403f, 
    -0.15639795f, 0.07248475f, 0.04434152f, 0.18640079f, 0.03546129f, 0.02278162f, 0.02621592f, 0.11396813f, 
    -0.03384274f, 0.06799771f, -0.04529948f, -0.02613432f, -0.09782425f, 0.06544401f, 0.00313895f, -0.07869575f, 
    0.11408438f, -0.06993049f, 0.05926669f, 0.21167377f, -0.09291150f, -0.05429183f, -0.03801082f, -0.07400016f, 
    0.17312811f, 0.01490220f, 0.00082353f, 0.00411419f, 0.04878267f, 0.04915383f, -0.06241118f, -0.12663831f, 
    0.19638652f, 0.12112197f, 0.12271339f, 0.04213900f, 0.00407048f, -0.12423039f, 0.28221938f, 0.23246278f, 
    -0.14362410f, -0.17979771f, -0.06858142f, 0.01714222f, -0.03172925f, -0.13702722f, -0.12323862f, -0.05285560f, 
    0.41113535f, -0.09320895f, 0.05922179f, -0.04286135f, 0.04319222f, -0.05436841f, 0.02611478f, -0.01380877f, 
    0.24668823f, 0.09677015f, -0.02211030f, -0.03486107f, 0.18369257f, 0.29520983f, -0.05554647f, 0.00071486f, 
    -0.03458148f, -0.06082594f, -0.04434415f, -0.07307062f, 0.11952200f, -0.00812955f, 0.05387477f, 0.15582421f, 
    0.06973203f, -0.02653168f, 0.36896765f, -0.10487059f, 0.03674616f, -0.05541799f, 0.09471127f, 0.05900725f, 
    -0.06932788f, 0.00298931f, 0.04781204f, 0.08938673f, 0.06410373f, 0.01475933f, 0.06519642f, -0.02486657f, 
    0.01955158f, 0.00280785f, 0.04363729f, 0.02254637f, 0.01045930f, 0.03600343f, -0.00479887f, 0.07570491f, 
    0.06036124f, -0.15171503f, 0.19766787f, -0.13680704f, 0.03842736f, -0.09293881f, -0.00100093f, 0.01689838f, 
    0.20342305f, 0.06367733f, -0.05235867f, -0.10696511f, 0.16879503f, 0.11443239f, 0.13109571f, -0.05188146f, 
    0.08201164f, -0.01803048f, -0.00895191f, 0.09149370f, -0.06755161f, 0.05930921f, 0.06124088f, -0.01913075f, 
    -0.15596834f, 0.10739456f, 0.05466671f, 0.07270247f, -0.05081521f, -0.07341325f, -0.03711691f, -0.12977917f, 
    -0.03665789f, -0.10128541f, -0.05984654f, -0.00078468f, 0.17140274f, 0.00985070f, -0.00336741f, -0.03670993f, 
    0.09574722f, -0.07962238f, 0.01639730f, -0.05123679f, 0.01082344f, -0.07635122f, 0.02010021f, 0.12672792f, 
    0.05290847f, -0.22394660f, 0.34986082f, -0.05263174f, 0.14867480f, -0.09464706f, 0.15261947f, 0.13195035f, 
    -0.02366553f, 0.09898228f, 0.04476418f, -0.05624182f, 0.18734041f, -0.04064204f, -0.01935258f, 0.05800014f, 
    0.07778385f, 0.14623849f, 0.07694053f, 0.02443804f, -0.10863312f, -0.00014154f, 0.17829062f, -0.08005151f, 
    -0.21397799f, -0.07932669f, -0.06813867f, 0.06277213f, 0.05730017f, 0.10236440f, 0.12080076f, -0.09393840f, 
    0.10683468f, 0.11242639f, -0.01356491f, 0.02277229f, 0.02168951f, 0.15109535f, -0.11658821f, 0.13572623f, 
    -0.00439883f, 0.05905510f, -0.07041268f, 0.11902766f, 0.02474477f, -0.05268768f, 0.05729260f, -0.13337313f, 
    0.33736011f, -0.18042383f, 0.32147035f, -0.02178554f, -0.13322365f, -0.00623950f, 0.06045343f, 0.03344501f, 
    0.08892372f, 0.06412072f, 0.15428934f, -0.06572423f, -0.12567611f, -0.09314133f, -0.29219988f, 0.10507364f, 
    -0.04138270f, 0.00581971f, 0.03359930f, 0.00398520f, -0.09380359f, 0.12659876f, 0.00083487f, 0.09758731f, 
    -0.11794721f, 0.01354369f, 0.04153164f, -0.00641041f, -0.04991126f, 0.07058742f, 0.08974802f, -0.15695198f, 
    0.05450086f, -0.03284937f, 0.03225826f, -0.04114448f, -0.04011063f, 0.07983057f, -0.06391775f, -0.12987763f, 
    0.05092284f, -0.00203244f, -0.02566751f, -0.07901900f, 0.04994966f, 0.00274343f, -0.01861243f, -0.11619738f, 
    -0.15763961f, -0.09784710f, 0.13683142f, 0.18770254f, -0.16494854f, 0.04365970f, -0.02006652f, -0.04026362f, 
    -0.09324864f, 0.03038150f, -0.08533660f, -0.07109074f, -0.10221214f, 0.11777259f, 0.02807366f, 0.18665409f, 
    -0.12621155f, 0.02638548f, -0.03041761f, 0.06589519f, 0.01311598f, 0.07789204f, 0.09623126f, 0.01316344f, 
    -0.17480510f, -0.03237264f, 0.08207422f, 0.02340721f, -0.07297042f, -0.09374390f, -0.07265704f, -0.00683026f, 
    -0.12349517f, -0.03726021f, 0.12115926f, -0.07279600f, 0.17778865f, 0.10895082f, 0.09222563f, -0.05956613f, 
    -0.09582999f, -0.08809553f, 0.09124808f, -0.07717194f, -0.01494917f, -0.03376288f, 0.04105949f, -0.02275456f, 
    0.03245937f, -0.04915318f, -0.04517321f, 0.02678337f, 0.00437503f, 0.04067537f, 0.04529773f, -0.03876526f, 
    0.04786609f, -0.00033594f, -0.01267110f, 0.00739139f, -0.01457201f, -0.04307333f, 0.03983191f, 0.02857237f, 
    -0.02373325f, 0.04645320f, 0.01626021f, 0.02534507f, 0.02849070f, 0.04306786f, -0.02971822f, -0.00296198f, 
    0.03816019f, -0.02645982f, -0.02907249f, 0.01663716f, -0.00513249f, 0.01235415f, 0.01658711f, -0.02002190f, 
    0.01994123f, 0.02382101f, -0.03245632f, 0.02905835f, -0.00271249f, 0.02180527f, -0.03719540f, -0.01477238f, 
    -0.03546962f, -0.03797764f, -0.01855995f, -0.02027696f, 0.00630335f, -0.00715664f, 0.04672007f, 0.00403560f, 
    0.03803838f, -0.03032856f, 0.04781379f, -0.04141083f, 0.01899825f, -0.04604826f, -0.04814171f, -0.00957571f, 
    0.00221494f, 0.01688501f, 0.02556673f, -0.01212075f, 0.01520079f, -0.04446789f, 0.02441895f, 0.00248643f, 
    -0.01574323f, -0.01721622f, -0.03520732f, -0.04939708f, -0.03095371f, -0.00431597f, 0.01376244f, -0.00694893f, 
    0.00469954f, -0.03941669f, 0.00337586f, 0.03308705f, -0.02016547f, 0.03876051f, 0.00651125f, 0.00014851f, 
    0.04398122f, -0.02824650f, 0.00545402f, -0.02247418f, -0.03108330f, 0.03728538f, 0.02866727f, -0.03247990f, 
    0.02033191f, -0.04648057f, 0.00721358f, -0.02790694f, 0.01293735f, 0.01302431f, -0.00112027f, 0.01774491f, 
    0.01133342f, 0.00440886f, -0.03285225f, 0.01864993f, -0.03236907f, -0.00949717f, 0.04611891f, -0.02092510f, 
    -0.02438104f, 0.00812130f, -0.01748526f, 0.02103168f, 0.01055617f, 0.03772577f, 0.03374421f, -0.00090153f, 
    0.04481941f, 0.02276206f, -0.04992700f, -0.05064053f, 0.02925628f, -0.00431204f, 0.00247863f, 0.01839331f, 
    0.02491605f, -0.02038935f, -0.01934531f, -0.02070950f, 0.02873481f, 0.03179828f, -0.04291760f, -0.00185726f, 
    -0.00589304f, -0.04784942f, -0.01536217f, 0.04455456f, 0.00520653f, -0.02982183f, 0.04144321f, -0.02630166f, 
    0.01591258f, 0.04923809f, -0.01766879f, 0.01626162f, -0.02194303f, 0.02945722f, -0.01947915f, 0.01526076f, 
    -0.03958703f, -0.01410491f, -0.00157246f, -0.00742741f, -0.04108370f, 0.03627349f, -0.02322455f, -0.04968554f, 
    0.03213052f, 0.01769677f, -0.04422351f, 0.01839351f, -0.01968324f, 0.02785306f, -0.01474185f, -0.00516247f, 
    0.05016537f, 0.03969298f, -0.00475597f, -0.03944032f, -0.01156020f, 0.03206904f, -0.00080666f, -0.04019142f, 
    -0.02294723f, 0.04747663f, -0.02124632f, 0.00732318f, 0.03160195f, -0.02783913f, -0.02849897f, -0.02768439f, 
    -0.05083512f, 0.01597201f, 0.00627672f, -0.00747029f, 0.03639726f, 0.00123569f, -0.02378410f, 0.04305370f, 
    -0.00900103f, -0.03942163f, -0.04287958f, -0.02736693f, -0.01111046f, -0.00328765f, 0.00923680f, -0.03785873f, 
    0.03251591f, -0.02240387f, -0.00707415f, 0.01454891f, -0.02779111f, -0.02407693f, -0.02464242f, -0.02631656f, 
    -0.04781539f, 0.03264829f, 0.03324699f, 0.01826058f, 0.03097172f, 0.02183473f, 0.00316033f, 0.00553695f, 
    -0.03632293f, 0.02415807f, 0.00210631f, -0.03336494f, 0.01105576f, -0.03548100f, -0.02755923f, -0.00229080f, 
    0.02304567f, 0.00950475f, -0.03817492f, -0.04912633f, -0.04870610f, -0.01458898f, -0.00819388f, -0.03276441f, 
    -0.02751772f, 0.03593939f, -0.04844978f, 0.02440237f, -0.02791379f, 0.02664016f, 0.04138009f, 0.00354209f, 
    -0.02890241f, 0.01025733f, -0.00583695f, -0.04923730f, 0.01754700f, -0.04492687f, -0.05054124f, 0.00169383f, 
    -0.04957964f, -0.03581570f, 0.02585110f, 0.03951615f, -0.00105848f, -0.02608470f, -0.00367038f, -0.04780394f, 
    0.00262240f, 0.01238561f, 0.03743450f, 0.01135854f, 0.03754052f, -0.01709068f, -0.03157193f, -0.02110665f, 
    0.01189332f, 0.02363478f, 0.03173833f, 0.01118237f, -0.02394770f, 0.01119717f, -0.02482916f, -0.01403456f, 
    0.01837844f, -0.03545062f, -0.04684890f, 0.00758148f, -0.01860804f, -0.03264299f, -0.03327013f, -0.00886609f, 
    -0.02593937f, 0.04086512f, -0.01712877f, 0.02950475f, 0.00286955f, -0.02900089f, -0.00132450f, -0.00159384f, 
    0.02568201f, 0.01404026f, 0.04874213f, 0.03882168f, -0.02060223f, 0.04528735f, 0.01406104f, 0.01812060f, 
    0.04708679f, 0.04279045f, -0.02414161f, -0.00099405f, -0.03420835f, 0.01508017f, -0.01613583f, -0.03838080f, 
    0.04416266f, 0.02173115f, -0.04611643f, 0.00147602f, -0.04541847f, 0.03221996f, 0.01108446f, 0.00142468f, 
    -0.00899791f, -0.04660955f, -0.01324747f, -0.02782407f, -0.01597782f, -0.04719133f, -0.01813877f, -0.01973995f, 
    0.00628015f, 0.02221644f, -0.00882392f, -0.04568476f, -0.00762814f, -0.02473122f, 0.00643371f, 0.01669378f, 
    -0.04890888f, -0.01630413f, 0.03215387f, -0.02882312f, 0.02287908f, 0.02649037f, -0.05083309f, 0.00793095f, 
    0.01942632f, 0.03766622f, -0.02727414f, -0.04434883f, -0.04389962f, -0.04193664f, 0.03316611f, 0.00900971f, 
    -0.02325838f, -0.03094078f, -0.02680939f, -0.05097457f, 0.04948460f, 0.00415822f, 0.01284466f, -0.03571795f, 
    -0.01965401f, -0.01267548f, -0.02073286f, -0.02475686f, -0.00108619f, -0.01027819f, -0.01560034f, -0.04194366f, 
    0.02501256f, 0.04436767f, 0.01741431f, -0.00073954f, -0.04409259f, -0.02768614f, -0.03899871f, 0.00133256f, 
    -0.03806034f, 0.00773646f, 0.05098575f, 0.01690011f, -0.03837892f, 0.01149035f, -0.03160669f, -0.01969386f, 
    0.03687283f, 0.01173035f, -0.03098085f, -0.02309737f, -0.04164433f, -0.01393253f, 0.01258177f, -0.00872284f, 
    -0.02523588f, -0.02894378f, -0.00649558f, -0.00330675f, -0.01214544f, 0.02877736f, -0.04880195f, 0.04261968f, 
    -0.19942248f, -0.21812683f, -0.10158544f, -0.09117256f, 0.00268884f, -0.10825137f, -0.06112563f, -0.09418269f, 
    -0.20708412f, -0.09906892f, 0.06075024f, 0.04295751f, 0.04195484f, 0.07799059f, -0.18739384f, -0.06991303f, 
    -0.01806078f, 0.04407411f, 0.08320471f, -0.06019109f, 0.02190282f, 0.06759019f, 0.04260835f, -0.03467046f, 
    0.15846020f, 0.42457238f, 0.44412729f, 0.41580424f, 0.12766568f, 0.19662048f, 0.14016792f, 0.25369966f, 
    -0.07097779f, -0.02918538f, 0.10508091f, -0.00046456f, -0.03764586f, -0.16838093f, -0.28687066f, -0.25857288f, 
    0.03532966f, 0.04829468f, -0.00610410f, 0.03855510f, -0.02014248f, -0.02660666f, -0.03976923f, -0.04364642f, 
    0.16365373f, 0.12366939f, 0.10678791f, 0.00649400f, -0.03834987f, -0.07134137f, -0.01156343f, 0.03405040f, 
    0.07125681f, -0.09335729f, 0.07102672f, -0.03956342f, 0.05573783f, 0.10088361f, 0.27527452f, 0.11223727f, 
    0.09012365f, 0.02107717f, -0.01637444f, 0.04792142f, -0.05540740f, -0.04143972f, 0.09275957f, -0.02448149f, 
    -0.23736969f, -0.40511587f, -0.29371330f, -0.00631621f, -0.01273722f, -0.00348188f, -0.02006665f, -0.01325784f, 
    -0.02067466f, -0.08516783f, -0.00869765f, -0.07257319f, 0.17779525f, -0.05242814f, 0.26961640f, -0.18854249f, 
    0.06143856f, -0.03470972f, 0.18164678f, 0.09934276f, -0.01628665f, -0.07700656f, -0.03073040f, -0.02185643f, 
    0.04773480f, 0.29773587f, 0.22481714f, 0.08401040f, 0.16197449f, 0.17421301f, -0.01205126f, 0.07281055f, 
    -0.04229096f, -0.01750454f, -0.07935943f, 0.06488478f, 0.24558677f, 0.29186234f, 0.16002171f, 0.02988275f, 
    -0.06170433f, -0.06476460f, 0.02857946f, 0.17428051f, -0.06404626f, 0.03480823f, -0.02599481f, -0.06622962f, 
    -0.05796397f, -0.28335708f, -0.13016546f, -0.09120053f, -0.06850162f, -0.09325510f, -0.03843727f, -0.08507763f, 
    -0.01908119f, -0.07473661f, 0.17108855f, -0.06705272f, 0.35333565f, 0.30318725f, 0.07168171f, 0.02000392f, 
    0.08891296f, 0.19918388f, 0.11177669f, 0.03706882f, -0.01126891f, -0.04629996f, -0.03376009f, 0.04478190f, 
    0.09629516f, -0.30827799f, -0.02369501f, -0.09949970f, -0.11674481f, -0.04131946f, -0.10937947f, -0.04445182f, 
    -0.07504549f, 0.01862947f, 0.02490865f, -0.03781955f, 0.32264176f, -0.47576955f, -0.12355667f, 0.04873822f, 
    0.04565661f, -0.07913351f, -0.09007442f, 0.00444868f, -0.09240253f, -0.19758277f, -0.07103832f, 0.10780944f, 
    0.31919363f, -0.02663731f, -0.19586185f, 0.05551041f, -0.02685665f, 0.03179888f, 0.01625764f, 0.11260448f, 
    -0.12041000f, -0.10685614f, -0.05263643f, -0.03682966f, -0.01000621f, -0.10259629f, -0.09280856f, -0.09331670f, 
    -0.01973481f, 0.10962457f, 0.01691959f, 0.07118188f, 0.00122062f, 0.19637288f, -0.01077636f, 0.06223090f, 
    -0.00829877f, -0.07518428f, 0.07302726f, 0.14704870f, -0.00994274f, -0.01799062f, -0.02017554f, -0.02754397f, 
    0.10225677f, -0.16901642f, 0.09189400f, -0.01564949f, 0.11543291f, -0.22658069f, 0.01574941f, -0.16115536f, 
    0.00362003f, -0.01726400f, 0.06751196f, 0.06729469f, -0.12643465f, -0.03690106f, 0.10100365f, 0.09467757f, 
    0.30541387f, 0.35553715f, 0.32806507f, -0.00377976f, -0.09649807f, 0.04044070f, 0.06213848f, 0.14462417f, 
    -0.00403397f, 0.03228187f, 0.02142007f, -0.08697071f, 0.02293492f, -0.11828688f, -0.34782696f, -0.20693535f, 
    0.00862057f, -0.05350656f, 0.07969876f, -0.00296435f, -0.02177037f, 0.00976391f, 0.06573824f, -0.01814291f, 
    0.20827863f, 0.17276964f, -0.05354061f, -0.07862375f, -0.04611539f, 0.04601127f, 0.26071507f, -0.00563725f, 
    0.05668790f, 0.02576444f, -0.04227222f, 0.03061154f, -0.21658084f, -0.16207258f, -0.13220416f, -0.00136648f, 
    -0.00585731f, 0.00049958f, 0.03916351f, -0.01431513f, 0.04571334f, -0.12362827f, 0.05074882f, -0.07054075f, 
    -0.02041105f, 0.34376034f, 0.20677961f, 0.09642300f, 0.05348032f, -0.01777424f, 0.02201638f, 0.02001588f, 
    0.04267189f, -0.00161548f, 0.08623303f, -0.03233063f, 0.17440736f, -0.13287814f, 0.14806698f, -0.11883615f, 
    0.09230444f, -0.01763275f, 0.03512299f, 0.19493157f, 0.02013847f, -0.05117392f, 0.01929220f, 0.04549446f, 
    0.19697341f, -0.04713800f, -0.04121098f, -0.08709650f, -0.00324495f, 0.02388190f, 0.08268700f, 0.01967121f, 
    0.09263677f, 0.08239134f, 0.07346473f, -0.06328206f, -0.45329881f, 0.14567937f, 0.34811190f, -0.12812719f, 
    0.09750596f, -0.08689078f, 0.06042594f, -0.10393461f, -0.05633551f, 0.08011606f, 0.02406505f, -0.02196435f, 
    0.13311040f, 0.01953917f, -0.01533305f, -0.01131200f, 0.14038585f, 0.17508513f, 0.00756819f, -0.05682766f, 
    0.07508736f, -0.07251292f, 0.07649765f, 0.01281693f, 0.36886227f, 0.20044765f, 0.14641193f, -0.18680064f, 
    0.02347187f, -0.02619845f, -0.09123866f, -0.00060406f, -0.05118988f, -0.00218070f, -0.03761845f, 0.01215738f, 
    0.36825854f, 0.35059887f, 0.40133655f, 0.19857462f, -0.00567443f, -0.10606188f, 0.02044612f, -0.07835763f, 
    0.01797078f, -0.01206120f, -0.02583510f, 0.00526754f, 0.19524685f, 0.16058022f, 0.03166926f, 0.05411347f, 
    0.07641916f, 0.15351456f, -0.00006085f, 0.03216046f, -0.07652684f, -0.03096943f, 0.06076580f, -0.00803479f, 
    0.01015928f, -0.05678312f, 0.14915286f, -0.05979094f, 0.08508156f, -0.04127456f, -0.00656936f, 0.09719277f, 
    -0.02437711f, -0.01391547f, 0.01633048f, -0.03624571f, -0.29512429f, -0.38600904f, -0.31350309f, 0.02483965f, 
    -0.08493181f, -0.02968768f, -0.00822498f, -0.01720685f, -0.00339042f, 0.05110378f, -0.13297598f, -0.14385392f, 
    -0.03647370f, -0.13998792f, -0.16233896f, -0.02530867f, 0.05518455f, -0.02146867f, 0.13707182f, 0.02127077f, 
    0.06294300f, 0.17572895f, -0.01251662f, 0.05667536f, -0.05259311f, 0.13071603f, -0.05061093f, -0.03062025f, 
    0.15653081f, 0.14111045f, -0.05543406f, 0.03651908f, -0.19339998f, -0.10555460f, -0.13748960f, -0.08172660f, 
    0.18069331f, 0.17535698f, 0.21676923f, 0.07197075f, 0.05210324f, -0.03137841f, -0.06768940f, -0.06838619f, 
    0.09880535f, 0.03577538f, -0.03869211f, -0.11878381f, -0.19621827f, -0.24256226f, -0.02673785f, -0.03780265f, 
    0.02762376f, -0.08804618f, -0.03750553f, -0.07979318f, -0.01691202f, 0.00026078f, -0.01990320f, 0.03063218f, 
    -0.00858837f, -0.10528791f, -0.03742905f, 0.13621810f, 0.07186098f, -0.15856005f, 0.10417204f, 0.09663687f, 
    0.03002449f, 0.29916885f, -0.01501837f, 0.04930129f, 0.13934915f, 0.07230198f, 0.18145318f, 0.23776869f, 
    0.09765366f, 0.05325782f, -0.08313508f, -0.14962906f, 0.30653411f, 0.05420437f, 0.20371784f, 0.28076106f, 
    0.28212461f, 0.06360894f, -0.08906703f, 0.08099128f, 0.07955186f, 0.14529504f, -0.01506875f, -0.02062577f, 
    0.06718241f, 0.10382860f, 0.15310049f, 0.08127847f, -0.23483942f, 0.07479744f, -0.08059724f, 0.06124750f, 
    0.11283780f, -0.02016415f, -0.05180811f, 0.16612270f, -0.06171967f, 0.08338110f, -0.07045065f, -0.03375655f, 
    0.00813283f, -0.03648946f, -0.01591957f, -0.16597250f, 0.10723438f, -0.08631890f, -0.07571807f, -0.07446002f, 
    0.04269740f, -0.05258984f, 0.05354732f, 0.20882252f, 0.03735670f, 0.08294310f, 0.21939771f, 0.16725004f, 
    -0.02653114f, 0.12236540f, 0.01160728f, -0.19966286f, 0.04380896f, -0.09674496f, 0.05049636f, -0.18017748f, 
    0.00092910f, -0.11634674f, -0.09277715f, 0.01080102f, -0.10923114f, 0.03144646f, 0.02259578f, 0.00936035f, 
    0.15054461f, -0.07444852f, 0.15783739f, 0.16863263f, -0.30668610f, 0.03198342f, -0.15677333f, -0.12587351f, 
    0.00997191f, 0.08028845f, -0.02386040f, 0.14712739f, -0.05055300f, 0.08915781f, 0.11356456f, 0.25121683f, 
    -0.39774558f, 0.03256333f, -0.12497661f, 0.04554371f, -0.00768349f, 0.00953975f, 0.10098840f, -0.04900519f, 
    -0.08134503f, 0.00610272f, 0.14633346f, 0.07671766f, 0.05141352f, -0.38538629f, -0.05565654f, 0.12206405f, 
    0.01869544f, 0.02725864f, 0.07331352f, 0.11379420f, 0.03466425f, 0.07865907f, 0.22236785f, 0.02139255f, 
    -0.04600135f, 0.41342196f, -0.11868430f, 0.06636626f, 0.08838649f, -0.04190597f, 0.00705200f, 0.00529867f, 
    0.01388738f, 0.10948019f, 0.25483570f, 0.04424458f, 0.09129988f, 0.04067645f, -0.05260983f, 0.04355026f, 
    0.10628174f, 0.14689241f, 0.03986274f, 0.17284791f, -0.26408631f, -0.11036932f, -0.01333557f, -0.16611125f, 
    0.00272328f, 0.38015905f, -0.29140854f, 0.40225694f, 0.05372988f, -0.09095099f, -0.00157166f, -0.09982301f, 
    0.02814620f, 0.10935822f, 0.17011185f, 0.11370457f, -0.15033291f, -0.04098279f, -0.37596169f, -0.13614479f, 
    -0.03457836f, -0.10502111f, 0.00686452f, -0.06419995f, 0.11542225f, -0.01108483f, -0.20699468f, -0.10842812f, 
    0.19346739f, -0.03445430f, 0.36170709f, 0.13680007f, 0.06657928f, 0.01486501f, 0.08845518f, 0.13999115f, 
    -0.01011827f, -0.05218028f, 0.03025227f, -0.04060305f, 0.14367238f, -0.05088010f, 0.02299333f, 0.16519921f, 
    0.11973567f, 0.06053551f, 0.03480464f, 0.14929114f, 0.12271696f, -0.04170081f, 0.07165039f, -0.00456379f, 
    -0.08059102f, 0.15311231f, 0.15025054f, -0.27869537f, 0.08472615f, 0.19358850f, -0.08358359f, 0.06147032f, 
    -0.01775942f, -0.21872139f, -0.04534621f, -0.13066493f, -0.09790516f, 0.07722127f, -0.11227386f, 0.21332602f, 
    -0.12875092f, -0.17175393f, -0.01973583f, 0.03743006f, 0.19359587f, -0.09436079f, 0.01932043f, -0.05660375f, 
    0.20848674f, 0.04049421f, 0.11639620f, 0.05120468f, 0.01871339f, -0.03908725f, 0.00864192f, 0.09033856f, 
    0.12101986f, 0.08916176f, 0.05705512f, 0.04729264f, -0.05752593f, -0.06647434f, 0.12503076f, -0.04646062f, 
    0.04486670f, 0.01741062f, 0.00403108f, -0.12972629f, 0.02599373f, -0.01622114f, -0.14483468f, -0.01260990f, 
    -0.14060560f, -0.04729198f, -0.35449761f, 0.08807361f, 0.07946463f, -0.08446234f, -0.03127160f, -0.05672209f, 
    0.00572850f, -0.06064908f, -0.14620318f, 0.02833073f, 0.10152840f, -0.23383585f, 0.35826078f, 0.14411308f, 
    -0.01791922f, 0.19199170f, -0.05697453f, 0.01302642f, 0.08202867f, 0.03581956f, 0.08707424f, -0.11674963f, 
    0.04230186f, -0.06557345f, -0.02760759f, -0.17039995f, 0.00979447f, -0.02226313f, 0.01330827f, 0.11287121f, 
    0.07824851f, -0.14594355f, -0.10487247f, 0.02705742f, 0.20002942f, 0.10663223f, 0.24008088f, 0.28404412f, 
    -0.01897715f, -0.01110695f, 0.08362143f, 0.18913189f, -0.02298300f, 0.11197591f, -0.14623034f, 0.01714078f, 
    0.13076824f, -0.01547219f, 0.24561809f, -0.05825176f, 0.07128587f, 0.05680087f, -0.08296777f, 0.01066362f, 
    -0.07513194f, -0.10353729f, -0.02402212f, -0.16956218f, 0.04592310f, -0.17024900f, 0.06902946f, -0.04671916f, 
    0.06450966f, -0.01602423f, -0.01042885f, 0.00053132f, 0.25525334f, -0.05132485f, 0.01752302f, 0.01310264f, 
    0.32702407f, 0.02670352f, -0.01026300f, 0.00716916f, 0.05963551f, 0.03696539f, -0.02474860f, 0.01354440f, 
    -0.06170000f, -0.07488424f, -0.21683991f, -0.03246515f, 0.11101239f, 0.06445765f, -0.10801017f, 0.13194269f, 
    -0.03095982f, -0.08094516f, -0.11165108f, 0.01482022f, 0.11344461f, -0.09365489f, 0.14705271f, -0.00901399f, 
    -0.04643177f, 0.03133013f, -0.00173971f, -0.02357534f, -0.00691034f, 0.00232296f, 0.03479686f, -0.01386997f, 
    0.00582231f, -0.02483509f, -0.04110776f, 0.00810481f, 0.02794039f, -0.01837754f, -0.01376795f, -0.04345701f, 
    -0.04255223f, -0.00071315f, -0.03753043f, -0.02627084f, -0.02945455f, -0.02827747f, -0.03395271f, 0.01787912f, 
    0.00301059f, 0.01972365f, -0.03898863f, -0.00074967f, 0.03456630f, -0.02899080f, 0.02396902f, 0.02649679f, 
    0.03051931f, -0.02777643f, 0.00935439f, 0.00325344f, 0.04001986f, 0.00417143f, -0.03986119f, -0.01805516f, 
    -0.01217458f, -0.03426922f, -0.04095851f, -0.01357959f, -0.05100927f, -0.02252605f, 0.01270952f, 0.03605445f, 
    -0.03282240f, 0.00332298f, -0.01400810f, 0.02390156f, 0.00691430f, 0.01559680f, -0.00879059f, -0.01202368f, 
    -0.02782440f, 0.02713855f, -0.03935432f, 0.03278936f, -0.02898745f, 0.01029093f, 0.00391998f, 0.04135066f, 
    -0.05283235f, 0.04082315f, -0.00457313f, -0.04168044f, -0.02783213f, -0.04541323f, 0.02110862f, 0.04044538f, 
    0.01152669f, 0.00203916f, 0.02679510f, 0.02385430f, -0.04889548f, 0.02761157f, -0.01917545f, 0.04263958f, 
    0.02965258f, -0.02536179f, -0.04202454f, 0.03181908f, 0.00221184f, -0.02885487f, 0.02070454f, 0.02627980f, 
    0.00137922f, -0.03388327f, -0.01361192f, 0.01854883f, 0.04316311f, -0.02117415f, 0.02614192f, -0.02835684f, 
    0.00242418f, 0.00716947f, -0.04339301f, -0.01827841f, -0.01471134f, 0.03341023f, -0.01733233f, 0.01682079f, 
    -0.00803839f, -0.03394996f, -0.02745767f, 0.03936308f, 0.00132662f, -0.01619993f, -0.04894891f, -0.05671575f, 
    0.03807308f, -0.05609868f, 0.01537874f, 0.00319367f, -0.02139241f, 0.00186397f, -0.04881122f, -0.02877555f, 
    -0.05233308f, -0.05012473f, -0.04605843f, -0.03935141f, 0.00693959f, 0.02274045f, 0.01685293f, -0.01660158f, 
    0.00323551f, 0.02331121f, 0.01410745f, -0.01558495f, -0.04259767f, -0.03873825f, 0.02015820f, 0.00261096f, 
    0.01479496f, 0.01317325f, 0.01495974f, -0.02224396f, -0.02030374f, 0.04268816f, -0.04169063f, 0.03141584f, 
    0.01061883f, -0.02954127f, -0.05059974f, -0.03801559f, 0.04236272f, 0.01422262f, -0.02388460f, 0.00325207f, 
    -0.04928506f, -0.01233130f, -0.01635676f, -0.04756818f, -0.04700949f, -0.05394027f, -0.02026584f, 0.00735422f, 
    -0.04494501f, 0.03035715f, -0.02789686f, -0.01699076f, -0.01541786f, 0.02478540f, -0.00210295f, 0.01635613f, 
    0.04389489f, -0.00600822f, 0.02888997f, -0.01911893f, 0.00560091f, -0.01359531f, 0.01574556f, 0.03312771f, 
    0.02560021f, 0.00454540f, 0.00696704f, -0.04553569f, -0.03031700f, -0.03342255f, -0.00880907f, 0.01936660f, 
    -0.03152986f, 0.04300166f, -0.02940355f, -0.02331630f, -0.03169953f, -0.01519990f, -0.02181795f, -0.02341797f, 
    -0.00662495f, -0.01278413f, -0.02912678f, 0.01086839f, 0.03447318f, 0.00987885f, 0.01841351f, 0.01582090f, 
    -0.04216016f, 0.00299184f, 0.05112539f, 0.03405256f, 0.00434474f, -0.05485752f, -0.04696910f, -0.02850544f, 
    0.03596171f, 0.02257594f, 0.03146579f, -0.02463153f, -0.02831178f, 0.01782437f, -0.03703892f, 0.03460497f, 
    -0.02996228f, -0.01724548f, 0.01742441f, -0.04153892f, 0.04035387f, -0.03663376f, -0.01648309f, -0.01586948f, 
    0.03188647f, -0.05086488f, -0.03236538f, 0.02308281f, 0.00853415f, -0.00110590f, -0.03203978f, -0.05344535f, 
    -0.03909241f, 0.03595531f, -0.04350027f, 0.01385946f, -0.02122132f, 0.04614938f, -0.05022143f, -0.01401484f, 
    -0.00320053f, 0.00647912f, -0.00825446f, -0.00195457f, 0.00408871f, -0.00972117f, -0.04488851f, 0.02780585f, 
    -0.03377771f, 0.04634931f, 0.02735882f, -0.02615736f, -0.03389261f, -0.02967208f, -0.01710999f, 0.02008048f, 
    -0.03771147f, -0.01013445f, -0.01016202f, -0.03107422f, 0.04055776f, 0.01946105f, 0.01684975f, 0.02501972f, 
    -0.04746496f, -0.01318444f, -0.02662225f, -0.04312151f, -0.05618644f, -0.02736945f, -0.02630990f, -0.01794972f, 
    -0.01602216f, -0.01214395f, 0.01028583f, 0.00179236f, -0.02331954f, -0.00608493f, -0.02876197f, -0.04318424f, 
    -0.05505468f, 0.00916600f, 0.02448638f, -0.00165762f, 0.02937948f, -0.02808623f, -0.03225246f, -0.00460019f, 
    -0.04278802f, -0.04881678f, 0.01064864f, -0.04351246f, -0.00822659f, 0.02005065f, 0.00755330f, 0.03598246f, 
    0.03540888f, -0.05134712f, -0.01329305f, -0.03124510f, -0.04182191f, 0.02343470f, 0.04846971f, -0.03179818f, 
    -0.05942171f, -0.01689803f, 0.03452695f, -0.03510800f, -0.00529058f, 0.04501126f, -0.00401581f, 0.01319574f, 
    0.03536066f, 0.03334578f, -0.04737425f, -0.02716701f, 0.02508701f, 0.04270643f, -0.04172367f, 0.04208795f, 
    -0.00499572f, -0.03734280f, 0.02342435f, -0.04402259f, 0.00897024f, -0.01302281f, 0.00144296f, 0.00696255f, 
    -0.03510917f, -0.01535326f, -0.00783476f, -0.00264362f, 0.03952853f, 0.04202069f, 0.00414812f, 0.03535930f, 
    -0.01119326f, 0.04349947f, -0.03374419f, -0.03149701f, 0.00325827f, -0.01593763f, 0.01281584f, 0.02316166f, 
    -0.03421519f, -0.02251229f, 0.04211840f, 0.00109627f, -0.02222148f, 0.00219988f, -0.02507975f, 0.02065622f, 
    0.03608156f, 0.03804989f, -0.03537668f, -0.00512656f, -0.02584036f, 0.03129034f, -0.03526496f, -0.01988163f, 
    -0.00325580f, -0.03924915f, 0.02997266f, 0.02161720f, -0.02422546f, 0.00616139f, -0.02984743f, -0.02013790f, 
    -0.02254702f, -0.00400535f, -0.03515658f, -0.03993043f, -0.03754421f, -0.01647765f, 0.02913060f, -0.03460556f, 
    0.00662243f, 0.00820923f, -0.01198237f, 0.00061746f, 0.03960580f, -0.03492048f, 0.03202028f, -0.02061551f, 
    -0.02798611f, -0.03514827f, -0.00615048f, -0.03945659f, -0.03401814f, -0.00590544f, -0.00018813f, -0.02913514f, 
    -0.01040886f, 0.00017540f, -0.05328448f, -0.02807181f, -0.01353102f, -0.01955224f, 0.01081173f, -0.02553791f, 
    0.00373788f, -0.00657591f, 0.04573051f, 0.03111896f, 0.03706720f, 0.00296715f, -0.01730388f, 0.03608300f, 
    -0.00486461f, 0.02633770f, -0.04342222f, 0.01170104f, 0.05178246f, 0.00202459f, 0.02132317f, -0.03059963f, 
    -0.00852025f, -0.02011236f, -0.02035227f, 0.04800631f, 0.03613158f, -0.04580974f, 0.03942148f, 0.03516115f, 
    -0.05086936f, 0.00300324f, -0.04546674f, -0.00580048f, 0.02713077f, -0.03835908f, -0.06108083f, 0.00879666f, 
    -0.00188872f, -0.03664567f, 0.01490223f, -0.00164846f, 0.03182069f, 0.03699023f, 0.00220765f, -0.00671043f, 
    -0.04515544f, 0.00693827f, 0.01791029f, -0.05232923f, -0.01916455f, 0.00553862f, -0.01619288f, 0.00256137f, 
    -0.02839953f, -0.01034131f, 0.01831997f, -0.04179162f, 0.04549528f, 0.02473729f, 0.03567852f, -0.04682122f, 
    -0.02346136f, -0.00912837f, -0.04616150f, 0.02728575f, -0.03693496f, -0.01372873f, 0.04827040f, -0.02660817f, 
    -0.01810184f, -0.03061489f, 0.03913840f, 0.01866066f, -0.04958523f, 0.03704481f, -0.01672876f, -0.06175232f, 
    0.04431289f, -0.02300088f, -0.03722757f, 0.00916163f, -0.03266159f, 0.03292612f, 0.02217529f, -0.02443571f, 
    -0.03983255f, -0.05534854f, -0.00772374f, -0.01851740f, -0.00700802f, 0.02939279f, 0.03778331f, -0.04147269f, 
    -0.03904091f, -0.03086993f, 0.01150806f, 0.01168804f, -0.01092554f, -0.00807440f, 0.02231656f, 0.02900686f, 
    -0.01286136f, -0.01919638f, -0.05680030f, -0.04761290f, 0.00368592f, -0.04887056f, -0.02525611f, -0.02023216f, 
    -0.01584386f, 0.01730739f, 0.00206933f, 0.03315630f, -0.01591613f, -0.03098482f, 0.00284774f, -0.00488892f, 
    -0.04805826f, -0.03980364f, -0.02438289f, -0.04140444f, -0.02826361f, 0.02496466f, 0.04767409f, -0.00372232f, 
    0.04061039f, 0.02578635f, -0.04356066f, -0.04217817f, -0.03887679f, -0.01440397f, 0.04664168f, -0.03338248f, 
    -0.00332843f, -0.03865054f, -0.04694774f, -0.04148792f, -0.03083350f, 0.00022455f, 0.01862410f, 0.00434335f, 
    -0.02509400f, 0.03341727f, 0.01638833f, -0.01801435f, -0.02688818f, 0.02807462f, 0.03503393f, 0.00605745f, 
    0.02975503f, -0.03430065f, -0.04601165f, -0.02998829f, -0.00931929f, 0.00211598f, 0.02904836f, -0.00613374f, 
    -0.05071522f, -0.04163275f, 0.00359053f, -0.02384355f, 0.04372160f, -0.04362385f, -0.05722710f, -0.05516154f, 
    0.04583357f, 0.04164245f, -0.01336173f, -0.00776849f, 0.00716008f, -0.04393297f, -0.05139760f, -0.03099010f, 
    0.03046532f, -0.00261073f, -0.03953569f, 0.00166427f, 0.00101994f, -0.04534564f, -0.04960249f, -0.05554556f, 
    0.03993827f, 0.00114194f, -0.03199690f, -0.01213692f, 0.04544814f, -0.01479555f, 0.01812391f, 0.00832614f, 
    -0.04879696f, -0.02947531f, -0.00899101f, 0.03357976f, 0.00960446f, -0.05803808f, -0.01871836f, 0.01997500f, 
    0.04924199f, -0.04751695f, -0.03799780f, -0.00623966f, -0.01201835f, -0.02508824f, 0.02289820f, 0.02456481f, 
    -0.02961664f, -0.03841248f, -0.02518461f, -0.04336535f, -0.04219341f, 0.03720668f, 0.02611898f, 0.03936239f, 
    -0.00874666f, -0.05792997f, -0.02864440f, 0.02792784f, -0.01430673f, 0.03608849f, -0.01299562f, 0.01187147f, 
    -0.01811673f, 0.02751175f, 0.00620165f, 0.01816962f, 0.00352896f, -0.02336953f, -0.04616841f, 0.00546762f, 
    0.03082851f, -0.02652020f, -0.03331843f, 0.00983167f, -0.04388002f, -0.01543973f, -0.03535801f, -0.01282584f, 
    -0.02766697f, 0.00495405f, 0.02612021f, -0.06346571f, 0.02423594f, -0.04536651f, -0.03329538f, 0.02851423f, 
    -0.04768865f, 0.02601676f, -0.03511392f, 0.03632984f, -0.00642770f, -0.01717317f, -0.02731474f, -0.00716558f, 
    -0.03895643f, 0.01215356f, -0.03818018f, -0.01098205f, -0.02248972f, -0.01617024f, -0.02804870f, -0.02814689f, 
    0.00457997f, 0.02907102f, 0.00485159f, 0.04213546f, -0.00989428f, -0.00442831f, -0.01693846f, -0.01616379f, 
    -0.01943659f, 0.02244512f, -0.04850991f, -0.01198517f, -0.03384099f, 0.01428379f, -0.02766267f, -0.05469888f, 
    -0.05545835f, -0.00017354f, 0.03334770f, -0.05575144f, -0.05832304f, -0.03055804f, -0.01469423f, 0.04613711f, 
    0.01837275f, -0.05811317f, -0.06061230f, -0.05164668f, 0.00245339f, -0.06094008f, 0.02497346f, 0.03307503f, 
    0.02844897f, 0.03084581f, -0.05208304f, 0.03121798f, 0.01921928f, 0.00291625f, -0.03051863f, 0.02315298f, 
    -0.00804373f, -0.01036486f, 0.02718231f, 0.03871264f, 0.03154787f, 0.03263646f, -0.01932555f, -0.01596405f, 
    -0.00377156f, 0.03167798f, -0.02437982f, 0.02872252f, -0.00986968f, -0.01578484f, -0.03789989f, 0.00602717f, 
    0.01153042f, -0.03854865f, 0.01099910f, -0.04106728f, -0.03098824f, 0.01186452f, 0.01957320f, -0.02778769f, 
    0.01184531f, 0.03725053f, -0.02022677f, 0.01226469f, 0.02448847f, 0.01575626f, 0.00445224f, 0.00881911f, 
    0.04579500f, -0.01775231f, -0.02001349f, -0.02356378f, -0.01829935f, 0.03703419f, -0.01721755f, -0.04071071f, 
    -0.03552025f, -0.01082413f, 0.01188950f, -0.02599163f, -0.05280206f, -0.00798274f, -0.01058111f, 0.03097655f, 
    0.00005444f, 0.01737167f, -0.03826693f, 0.03323624f, 0.02704064f, -0.03960856f, 0.00549071f, -0.02907187f, 
    0.05011997f, -0.03027436f, -0.04431855f, 0.04313833f, 0.04032899f, 0.04481416f, -0.01530618f, -0.03472596f, 
    -0.05251336f, -0.01654218f, -0.00427224f, 0.02752207f, 0.05062325f, 0.00244104f, -0.03531592f, -0.01770020f, 
    -0.17550795f, -0.05881047f, -0.05368106f, -0.13116623f, -0.03763932f, -0.02511117f, -0.04433822f, -0.09691204f, 
    -0.03136921f, 0.08007295f, 0.03862474f, -0.02210066f, -0.03139420f, 0.04576262f, -0.04653690f, 0.09589870f, 
    0.03268912f, -0.01082308f, 0.04782717f, -0.08535466f, -0.01876241f, 0.00824549f, 0.06107260f, -0.01954545f, 
    0.19287287f, 0.07629760f, 0.05249865f, 0.18750997f, 0.00000513f, 0.07721357f, 0.08205684f, 0.12642570f, 
    -0.00679931f, 0.04114096f, 0.07927496f, 0.08972089f, -0.05761675f, 0.19486944f, -0.07400992f, 0.01359607f, 
    0.01912870f, 0.03927226f, 0.04246625f, -0.00431549f, 0.05629079f, 0.08688913f, 0.05347542f, -0.09758793f, 
    -0.02672028f, 0.16955829f, -0.14159456f, 0.07655201f, 0.03573154f, 0.16667615f, -0.02617942f, -0.21184318f, 
    0.18200481f, -0.12656173f, -0.03691962f, 0.03710185f, 0.10359495f, -0.14734767f, 0.05915514f, -0.05913782f, 
    0.09101760f, -0.05132291f, 0.12685609f, 0.16117714f, -0.11044730f, 0.10391347f, -0.08891222f, -0.02197184f, 
    -0.13826132f, -0.10964713f, 0.01233050f, -0.09119546f, -0.11484026f, -0.12263587f, -0.04034103f, -0.08369650f, 
    -0.02382813f, 0.08024752f, 0.00231373f, -0.08837197f, -0.13588113f, 0.25077307f, -0.05068501f, 0.06135429f, 
    -0.08173069f, -0.02618993f, 0.13129382f, -0.18900824f, 0.03661893f, -0.01503502f, 0.01649336f, 0.07460429f, 
    0.26773757f, 0.00623233f, 0.00869629f, 0.23532565f, 0.04644910f, 0.02625609f, 0.04709444f, 0.07303020f, 
    -0.04545033f, 0.04662260f, -0.05455125f, -0.00780104f, 0.14595848f, -0.06480650f, 0.03430224f, 0.22628500f, 
    0.04913193f, -0.01475248f, 0.01347322f, 0.07328793f, -0.01332757f, 0.05595509f, 0.02063242f, 0.07826551f, 
    -0.19664322f, -0.03145652f, -0.04892384f, -0.07949959f, -0.01623593f, -0.05486585f, -0.03658704f, 0.02202730f, 
    0.03088173f, 0.04141378f, -0.04638401f, -0.16270487f, 0.40094516f, 0.12598109f, -0.17158049f, 0.07873422f, 
    0.16812627f, -0.01069470f, -0.08365180f, -0.16687138f, -0.03610042f, -0.00258448f, -0.13871104f, -0.06109896f, 
    0.00292899f, 0.14776793f, -0.02350535f, -0.00211908f, -0.11638889f, -0.02203429f, -0.06586090f, 0.04061850f, 
    -0.10390883f, 0.00825898f, -0.04971796f, -0.01576800f, -0.27355564f, 0.05002292f, 0.06684693f, -0.08554464f, 
    0.01121505f, 0.02527123f, -0.00567031f, 0.07461376f, -0.08865695f, -0.05510847f, -0.16135159f, -0.06434689f, 
    -0.01247232f, -0.23409265f, -0.00607394f, 0.30616009f, 0.03541461f, -0.03620010f, -0.03236129f, 0.06712724f, 
    -0.07686990f, -0.04492145f, -0.17347065f, 0.05405204f, -0.13684249f, -0.09419499f, -0.05454613f, -0.03562337f, 
    -0.08906955f, -0.07058115f, 0.02752102f, -0.12082705f, -0.02984074f, -0.00821613f, 0.00787941f, 0.07076251f, 
    -0.01310541f, -0.27677232f, 0.22096451f, 0.11866851f, 0.07157794f, 0.08347012f, -0.02363115f, 0.05075077f, 
    -0.16968134f, -0.14429276f, -0.00972193f, -0.05093010f, -0.02046585f, 0.02552635f, 0.12059297f, 0.03140349f, 
    -0.01407332f, -0.03101644f, -0.00592920f, 0.02391651f, -0.08944789f, -0.00242072f, 0.13582759f, 0.03446111f, 
    -0.03818130f, 0.05160634f, 0.07563141f, 0.21412174f, -0.01837707f, 0.07094681f, 0.06153922f, 0.11526825f, 
    -0.08534885f, 0.04080706f, 0.02133662f, 0.09079455f, -0.06099132f, 0.06930288f, 0.05475872f, -0.17674370f, 
    -0.10682203f, -0.04268016f, -0.06743357f, -0.13715160f, 0.00527228f, -0.00730687f, 0.01983107f, -0.00808827f, 
    0.15815742f, 0.03185257f, -0.08415275f, 0.43520951f, 0.04145971f, 0.04830058f, -0.05077967f, -0.12451110f, 
    -0.10143388f, 0.07977492f, 0.08579670f, 0.14471528f, 0.08662739f, -0.08085810f, -0.01972230f, -0.09913535f, 
    -0.07308507f, -0.02839396f, 0.08124297f, -0.01916515f, -0.13734306f, 0.01661808f, -0.04643745f, 0.03826359f, 
    0.00217890f, 0.07645561f, -0.03221621f, 0.00836709f, -0.02603461f, -0.01335453f, -0.04644575f, -0.00268716f, 
    -0.00746174f, 0.01284346f, 0.01842825f, 0.01961494f, 0.09739546f, -0.19850959f, 0.17804120f, 0.08189468f, 
    -0.03346817f, 0.02403867f, -0.11384206f, 0.04864115f, -0.02695820f, 0.03264878f, 0.09799640f, -0.00597641f, 
    0.10802147f, 0.30870500f, 0.00726587f, -0.18692333f, -0.01439413f, 0.02617641f, -0.04387151f, 0.00152663f, 
    -0.04197420f, 0.04256571f, 0.07870998f, 0.03833476f, -0.10185297f, 0.51949179f, -0.26281065f, -0.55280626f, 
    -0.03768740f, 0.12192500f, 0.12923475f, -0.12095448f, -0.04842130f, 0.00090225f, -0.10228874f, -0.02018585f, 
    -0.01647466f, 0.03402987f, 0.01975144f, 0.01777971f, 0.06981863f, 0.04294504f, -0.03287992f, -0.05110372f, 
    -0.04544716f, 0.10703199f, -0.10050301f, -0.08595091f, -0.11060329f, -0.05014010f, -0.10381944f, 0.04677447f, 
    0.06257515f, 0.05698411f, -0.10237581f, -0.01790610f, 0.02371538f, -0.02377207f, 0.00491824f, -0.14048451f, 
    0.10595075f, 0.15362658f, -0.06863135f, 0.25368208f, 0.09477413f, 0.06840479f, -0.00547769f, -0.09587473f, 
    0.03972058f, 0.07264708f, 0.01709156f, 0.00617451f, 0.19587773f, 0.04600979f, 0.01828476f, 0.13085924f, 
    0.01072522f, 0.05158670f, 0.03071533f, -0.03148088f, -0.05556739f, 0.12144502f, 0.02254339f, 0.00607115f, 
    -0.08439972f, 0.15394998f, 0.07623157f, -0.04803043f, 0.02815808f, 0.10417750f, 0.07391544f, 0.11224459f, 
    0.02946690f, 0.00991790f, 0.01881622f, -0.04833445f, -0.04180822f, 0.01647511f, 0.36548305f, -0.07577775f, 
    -0.09959704f, 0.00735487f, -0.07376160f, -0.05563387f, -0.03649741f, 0.02748885f, 0.07262566f, 0.00271812f, 
    0.04459340f, 0.07741781f, 0.13539708f, 0.15136924f, -0.07391853f, -0.02436303f, -0.01811374f, -0.05110645f, 
    0.18749422f, 0.07053269f, 0.11708120f, 0.21572803f, 0.08451317f, 0.01361504f, -0.00468905f, 0.02508702f, 
    0.20413648f, -0.02185676f, -0.06048269f, -0.14069419f, -0.08382063f, -0.08541647f, -0.04477755f, -0.05545855f, 
    -0.29549414f, -0.10478012f, -0.08122703f, -0.02204064f, -0.06608892f, 0.07818590f, 0.08818606f, 0.12411556f, 
    0.15886331f, 0.06413703f, -0.01125490f, -0.02887342f, 0.14703430f, 0.17317049f, 0.09414571f, 0.11815856f, 
    -0.00031574f, -0.08657651f, -0.06882975f, -0.01668238f, 0.04584413f, 0.01992986f, 0.04290887f, 0.10230230f, 
    -0.04466213f, -0.02826954f, -0.05469665f, -0.16166718f, -0.17357683f, -0.09263092f, 0.25971669f, -0.05826829f, 
    0.09160409f, 0.01166900f, 0.03601860f, 0.01931635f, -0.03569884f, -0.04766651f, 0.27281862f, -0.12687612f, 
    -0.04286220f, 0.12191776f, 0.13793564f, 0.24754144f, -0.11964744f, 0.08091142f, 0.00741987f, 0.10490477f, 
    0.08635170f, 0.09720433f, 0.16812938f, 0.17381610f, 0.01204415f, 0.00667089f, 0.00203086f, -0.01864241f, 
    0.05618552f, 0.00600229f, -0.00717832f, 0.15507238f, 0.07305792f, -0.25218821f, -0.08944319f, -0.15558970f, 
    0.22722232f, 0.06128902f, -0.08927473f, -0.01952834f, 0.15869953f, 0.14441836f, 0.03345364f, 0.08076195f, 
    -0.33513153f, -0.50684088f, -0.47485623f, -0.42419598f, -0.04988891f, -0.05871133f, 0.05128945f, 0.08723178f, 
    0.00879650f, -0.04292101f, 0.11155902f, 0.20345260f, -0.04514622f, -0.31834456f, -0.26830980f, -0.07288738f, 
    0.16981786f, -0.11638771f, 0.02939379f, 0.20901373f, -0.09161113f, 0.04692842f, 0.06205225f, -0.04657330f, 
    -0.02580246f, -0.02605520f, 0.01105126f, 0.03640499f, -0.04604435f, 0.10756122f, -0.02720302f, -0.00776470f, 
    0.14736572f, 0.02045888f, 0.08427368f, 0.07299000f, -0.28479549f, -0.52430588f, -0.50840300f, -0.11454445f, 
    -0.30706918f, -0.08003399f, -0.19232796f, -0.17453100f, -0.07137480f, -0.02800687f, 0.09318522f, 0.13224147f, 
    0.35222089f, 0.03259936f, 0.12569930f, 0.08760165f, 0.01865807f, 0.02562348f, 0.02595749f, 0.08321252f, 
    0.21893306f, 0.10794554f, 0.17959760f, 0.23008806f, 0.25447136f, -0.11398016f, 0.07243623f, -0.13142414f, 
    -0.04962904f, 0.02310288f, 0.04372450f, -0.05999979f, 0.10568675f, -0.16643667f, -0.02469915f, 0.01397043f, 
    0.25417238f, -0.35167813f, -0.10450634f, 0.00556984f, -0.04889003f, -0.05989628f, 0.15313222f, 0.27068424f, 
    -0.01388873f, 0.05158887f, 0.06681865f, 0.10725653f, 0.09740820f, 0.05345473f, 0.02278792f, 0.03314712f, 
    0.04554769f, -0.00366283f, 0.04665646f, -0.01823777f, -0.04801618f, 0.04555677f, -0.01926959f, -0.04145576f, 
    -0.03666538f, -0.08475319f, 0.21892588f, -0.11019009f, -0.08519849f, -0.00491750f, -0.09764040f, 0.09306530f, 
    0.04473388f, -0.12011026f, -0.05202287f, 0.04341590f, 0.15900460f, 0.05282300f, -0.07632476f, -0.07285806f, 
    -0.08408922f, 0.01619413f, -0.08072925f, -0.02180061f, 0.32217476f, 0.02028380f, -0.05657636f, -0.18141080f, 
    -0.01272652f, 0.23988177f, 0.07825384f, 0.06610487f, 0.05686614f, 0.05983181f, 0.15636842f, 0.13662776f, 
    -0.11878464f, 0.08602001f, -0.10782740f, -0.01607974f, 0.07143771f, 0.10981143f, 0.08554408f, 0.09440354f, 
    0.15742017f, 0.08260436f, 0.16288675f, 0.00388642f, -0.06047140f, -0.05132839f, -0.01069787f, 0.05046960f, 
    0.04046423f, -0.07070085f, -0.09849287f, 0.08513352f, 0.20542490f, -0.02854701f, -0.01287105f, -0.01219156f, 
    -0.13295369f, 0.06386286f, -0.05659800f, -0.03549786f, 0.02273986f, 0.03466740f, 0.01064978f, 0.00806347f, 
    0.01347925f, 0.18002442f, 0.01180244f, 0.02713915f, -0.04865185f, 0.03522213f, 0.04763955f, 0.04124880f, 
    -0.03234845f, 0.08858845f, -0.03194132f, -0.18090002f, 0.10016223f, 0.03720770f, 0.14392765f, 0.03281540f, 
    0.10160606f, -0.10320149f, 0.13629270f, 0.06941512f, -0.36850506f, -0.28417557f, -0.21644157f, -0.38587984f, 
    0.06182744f, 0.04938501f, -0.03797508f, 0.19046667f, 0.06226345f, 0.09949337f, -0.03631965f, -0.15335481f, 
    0.05084966f, -0.19339567f, -0.08656429f, 0.06691206f, -0.00316284f, -0.02633969f, -0.02539525f, -0.01593139f, 
    -0.01876689f, -0.10934802f, 0.07586382f, 0.12731731f, 0.08086928f, 0.20481306f, 0.17553154f, -0.04396512f, 
    0.09180415f, 0.22795737f, -0.01568492f, -0.04775297f, 0.10976493f, -0.00149269f, 0.21588941f, 0.15451138f, 
    -0.15823099f, -0.23454995f, -0.24221723f, -0.18534599f, -0.08502170f, -0.00015127f, -0.00445349f, -0.03060976f, 
    0.10791227f, -0.00611115f, -0.03088998f, -0.17206889f, -0.07480650f, -0.42186230f, -0.42646787f, -0.16062689f, 
    -0.02917749f, -0.10970613f, -0.05253240f, 0.09367967f, -0.03866095f, 0.05581806f, 0.06821530f, 0.12042287f, 
    -0.26664677f, -0.10730891f, -0.19353326f, -0.02111296f, 0.07997285f, 0.03386169f, -0.15902174f, -0.00145905f, 
    -0.13504811f, -0.13854234f, -0.09124465f, -0.01146262f, -0.55360490f, -0.36338016f, -0.16294305f, -0.41285658f, 
    -0.03575648f, 0.11267781f, 0.20050959f, 0.04706798f, 0.15792029f, 0.11630487f, 0.04478531f, 0.06641099f, 
    -0.17820427f, -0.04804097f, 0.01198975f, -0.10725509f, -0.01390393f, 0.13549019f, 0.02936095f, -0.10234945f, 
    -0.14511833f, -0.18363658f, 0.02209049f, -0.03084218f, 0.42452136f, 0.25301513f, 0.20875387f, 0.36348549f, 
    0.02785473f, 0.01921242f, 0.00766829f, 0.01605693f, -0.03779898f, 0.02526692f, 0.11998120f, 0.03446509f, 
    0.05818512f, -0.04837480f, -0.01284179f, -0.00308562f, -0.13021889f, -0.11110009f, -0.02358176f, 0.14630719f, 
    0.07544055f, 0.13827850f, -0.00479691f, 0.15285416f, -0.13650830f, -0.05152602f, -0.05634063f, -0.01509369f, 
    -0.02148652f, -0.00923376f, -0.01583515f, 0.04754307f, 0.05758939f, -0.04222197f, -0.17547424f, -0.10940561f, 
    0.16461840f, 0.33875352f, 0.08994634f, -0.03985910f, 0.04363040f, 0.01209985f, -0.04065638f, 0.07316142f, 
    0.03617122f, -0.05452030f, -0.18694012f, -0.11596421f, 0.05733415f, 0.01369934f, 0.12520598f, 0.00942492f, 
    -0.07089099f, -0.02333795f, -0.11458581f, -0.00874571f, 0.02982371f, 0.09270238f, -0.08339365f, -0.06874789f, 
    -0.04057055f, -0.18068090f, 0.11894890f, -0.10239635f, 0.20577203f, 0.03063054f, -0.11750234f, 0.00522367f, 
    0.00388726f, 0.07596473f, 0.03403807f, 0.02667354f, 0.03588175f, 0.19337231f, 0.00524516f, 0.03074746f, 
    0.00334285f, -0.02875795f, 0.02663083f, -0.03602021f, 0.28097579f, 0.17046632f, 0.15144001f, 0.10989606f, 
    -0.28237349f, -0.17719491f, -0.16554500f, 0.10210247f, 0.03729716f, 0.00305274f, -0.06253147f, -0.06964683f, 
    0.10432919f, -0.01307524f, 0.20245618f, 0.17867345f, 0.03817167f, -0.34726897f, 0.12327812f, -0.19273216f, 
    0.04956036f, 0.07731867f, -0.15534066f, -0.02601915f, 0.03974565f, 0.07762049f, 0.00377017f, 0.00196340f, 
    -0.10262019f, 0.06241602f, 0.02578478f, 0.00680419f, 0.07884947f, 0.07945679f, -0.03584934f, -0.00422730f, 
    0.06661133f, 0.00768670f, -0.02332960f, -0.00707313f, 0.09239893f, 0.08312932f, -0.19222955f, -0.10026747f, 
    0.12007489f, 0.07219288f, 0.00922191f, 0.07153982f, 0.04869542f, -0.03756657f, 0.00468368f, -0.03116738f, 
    -0.16172880f, -0.07400755f, -0.32962182f, -0.05623791f, -0.00300869f, -0.05566635f, 0.08171993f, 0.03842673f, 
    0.15762168f, 0.03979792f, 0.09098293f, 0.20338933f, -0.22645563f, 0.06432798f, 0.21135370f, 0.07094837f, 
    0.04128289f, 0.04437361f, -0.07628636f, -0.01259877f, -0.09365752f, 0.00964948f, 0.08240864f, 0.02157449f, 
    -0.07741910f, -0.15745373f, 0.09305915f, -0.07434574f, -0.00319168f, -0.06860664f, -0.04433203f, 0.13280648f, 
    0.17049819f, 0.12619197f, 0.08563916f, 0.07994588f, -0.01815478f, 0.09251689f, 0.21501461f, -0.05113034f, 
    0.00722901f, -0.10503575f, 0.04527023f, 0.01543259f, 0.04754671f, -0.02392568f, 0.07618922f, 0.02682378f, 
    0.09997095f, -0.07762344f, -0.04743832f, -0.01757039f, -0.00462794f, 0.00756962f, -0.04331695f, 0.00081055f, 
    0.15425166f, -0.07610746f, 0.02607306f, 0.07533323f, -0.38499340f, -0.27679807f, -0.13092867f, 0.01685765f, 
    0.14028092f, 0.08508784f, 0.12317035f, 0.08544200f, -0.08681758f, 0.00430207f, 0.07297841f, -0.05123743f, 
    -0.05964547f, 0.22782241f, -0.00750375f, -0.10698477f, -0.05678607f, -0.01214005f, 0.04052854f, -0.02009096f, 
    0.12723215f, 0.07864669f, 0.06029881f, 0.11505499f, 0.37956518f, 0.16788448f, -0.05149227f, -0.06221741f, 
    -0.15953442f, -0.06017998f, -0.13490602f, -0.07903848f, 0.05336595f, 0.02711239f, 0.02707214f, 0.04677273f, 
    -0.04710742f, -0.10907830f, -0.01095312f, -0.16912827f, 0.04403946f, 0.10543665f, -0.05847484f, 0.05707745f, 
    -0.03937930f, 0.08348702f, 0.13851662f, -0.17916401f, -0.39942005f, -0.24217914f, -0.13838521f, 0.09416822f, 
    0.15701616f, -0.05095351f, 0.06562384f, -0.08217556f, 0.09212808f, -0.14195846f, 0.02375160f, 0.00181479f, 
    0.22649437f, -0.16381741f, -0.17495655f, -0.02431286f, 0.05171577f, -0.01370511f, 0.03288937f, -0.02185225f, 
    0.08945303f, -0.11258347f, -0.19417255f, -0.11602676f, -0.22270069f, -0.19482926f, 0.03323825f, 0.16833261f, 
    0.07475239f, -0.05721827f, 0.06386532f, -0.01134251f, 0.07834776f, 0.06228891f, -0.12677160f, 0.02553708f, 
    -0.00764440f, 0.26720363f, 0.07846955f, -0.02281683f, -0.01904663f, 0.14778382f, 0.00619781f, 0.03578870f, 
    0.08312825f, 0.05299339f, 0.12769119f, 0.06777278f, 0.12930906f, 0.30090234f, 0.05665340f, -0.00322950f, 
    -0.23480475f, -0.11865372f, 0.08965337f, -0.00300788f, 0.09187696f, 0.00411751f, 0.01599500f, -0.00154385f, 
    0.19482203f, 0.21144971f, 0.33185446f, 0.40304980f, -0.03994341f, -0.13681383f, -0.15584128f, -0.01642746f, 
    0.07204913f, -0.01889924f, -0.02430882f, -0.00669423f, -0.09975950f, 0.00725489f, 0.30807346f, 0.37460199f, 
    -0.04838297f, -0.02299956f, 0.02288010f, -0.05288022f, 0.08690094f, -0.10805000f, 0.01739670f, 0.04162467f, 
    0.23314080f, 0.06780595f, 0.24534196f, 0.19025683f, 0.01814115f, -0.02839974f, -0.01666253f, 0.00628276f, 
    -0.00820194f, 0.04824581f, 0.10614795f, 0.17482680f, -0.00702388f, 0.10672688f, 0.02413077f, -0.11894264f, 
    0.00097297f, 0.10033552f, -0.02842376f, 0.18489264f, 0.00954355f, 0.12722102f, -0.10284931f, 0.03647667f, 
    0.10692220f, 0.10627168f, 0.01204885f, -0.10546245f, 0.05348284f, 0.11470720f, 0.11257701f, 0.14108258f, 
    -0.00986302f, -0.06429706f, 0.04252133f, 0.06775092f, 0.11585032f, 0.15189868f, 0.04515109f, 0.14534734f, 
    -0.00365892f, -0.05148726f, 0.05749720f, 0.03945158f, 0.05807955f, -0.08748295f, -0.02347029f, 0.15134242f, 
    -0.06620171f, -0.44019207f, -0.01458547f, 0.06897834f, -0.10377146f, 0.08061179f, -0.15188813f, -0.02530950f, 
    -0.03307700f, 0.07420114f, -0.13698107f, -0.15810993f, -0.18109223f, -0.16179660f, -0.23370716f, 0.22621886f, 
    0.03725028f, 0.01005669f, -0.03002409f, -0.06227124f, 0.03357597f, -0.14455158f, -0.02519402f, 0.09518548f, 
    0.03149285f, 0.04284233f, -0.05170658f, -0.03012798f, -0.00449899f, 0.01178710f, 0.01101576f, 0.00581575f, 
    0.16831851f, 0.19947189f, 0.09963434f, 0.11024600f, 0.21452768f, -0.09681649f, -0.02489851f, 0.09027953f, 
    0.06217628f, 0.08814421f, 0.06913625f, 0.02630479f, -0.05935073f, -0.03937369f, -0.09322272f, -0.18255730f, 
    -0.02131978f, -0.02968902f, 0.02686145f, 0.12814249f, -0.02019923f, -0.11702290f, -0.07053266f, -0.08976189f, 
    -0.07793891f, 0.06333955f, -0.09263813f, 0.07097329f, 0.11742197f, 0.11782882f, -0.08104859f, -0.00172823f, 
    0.07882999f, 0.05895907f, 0.03251407f, 0.11452163f, -0.03517602f, -0.02094613f, 0.08584081f, -0.15589811f, 
    -0.17773503f, -0.10211198f, -0.09632447f, 0.07715696f, -0.11830468f, 0.01472538f, 0.02645375f, 0.11728687f, 
    0.05149967f, -0.03861826f, 0.13906580f, 0.13356048f, -0.12036685f, -0.13877477f, -0.01918919f, -0.00533558f, 
    -0.05709793f, -0.00653308f, 0.04087856f, -0.00540829f, 0.09204433f, 0.00936114f, 0.13603915f, 0.16983907f, 
    0.19642666f, -0.01673740f, 0.00455063f, -0.05657019f, -0.03653843f, -0.05158990f, -0.02133635f, 0.03134817f, 
    0.12716313f, 0.08050953f, 0.01668236f, 0.05290401f, -0.25557488f, -0.21528251f, 0.02398415f, 0.14492807f, 
    -0.15085556f, 0.09595439f, -0.00775920f, 0.13725471f, -0.14255054f, 0.01875940f, 0.08161970f, -0.05983632f, 
    -0.15616460f, -0.03776815f, -0.03570023f, 0.09046013f, -0.02100453f, -0.01950849f, -0.03963597f, 0.00344021f, 
    -0.06068096f, 0.02725927f, -0.00770369f, 0.10941515f, -0.09763654f, -0.01255245f, 0.11712888f, 0.03812866f, 
    0.11569001f, -0.09545634f, 0.03191448f, 0.05147021f, -0.11202839f, -0.08420263f, -0.03888863f, -0.07750990f, 
    0.12160361f, -0.02481338f, -0.05366000f, 0.00289153f, 0.02207936f, 0.06318019f, -0.05511081f, -0.12200042f, 
    0.23013069f, 0.15923940f, 0.15612750f, 0.17754978f, -0.16977827f, -0.06069452f, 0.25170243f, 0.20833023f, 
    -0.06326456f, -0.14508581f, -0.11464380f, 0.03394407f, 0.03713397f, 0.02164058f, 0.01120509f, 0.00121265f, 
    0.24261183f, 0.11693198f, 0.00547389f, 0.13814241f, 0.03640820f, 0.07748068f, 0.07931206f, -0.03058936f, 
    0.17428012f, 0.13482569f, -0.01047124f, 0.04083002f, -0.10947698f, 0.24256547f, 0.01647777f, 0.00371935f, 
    -0.05584692f, 0.03086437f, -0.06479112f, -0.08400970f, 0.07874795f, -0.01977977f, 0.19394849f, 0.18040885f, 
    -0.16887003f, -0.00135317f, 0.34556383f, -0.01660123f, 0.03798665f, -0.06482165f, -0.00777766f, -0.07803948f, 
    0.01798277f, 0.06679744f, 0.05274820f, 0.14498557f, 0.21799999f, -0.00173733f, 0.03139113f, 0.03124752f, 
    -0.06848820f, 0.03238039f, 0.07255644f, 0.09322771f, 0.02784969f, -0.00240414f, -0.04046239f, -0.08466609f, 
    0.06275845f, 0.01617433f, 0.18068457f, 0.00610414f, 0.02476954f, -0.06916527f, 0.02321406f, -0.04531430f, 
    0.14193521f, 0.14203010f, 0.01185214f, 0.05534000f, 0.09343561f, 0.20916939f, 0.15772803f, 0.06342370f, 
    0.12985758f, 0.02215474f, 0.04507955f, -0.00824035f, -0.11812875f, -0.03877129f, 0.07767385f, 0.00109396f, 
    -0.20877644f, -0.05231070f, 0.13256323f, 0.29031238f, -0.02158183f, -0.02871844f, -0.00376447f, 0.02543222f, 
    0.05716951f, -0.00259722f, -0.00414251f, 0.01266292f, 0.34726915f, 0.00135801f, 0.03687405f, 0.07373120f, 
    -0.02731039f, -0.05202671f, 0.01475314f, -0.07766759f, 0.04598608f, -0.07058871f, -0.04731204f, 0.03734921f, 
    0.03326048f, -0.20953324f, 0.34477019f, 0.09148832f, 0.14625627f, -0.00003544f, -0.12885495f, 0.17408405f, 
    -0.05459082f, -0.04710484f, 0.04502722f, -0.08762112f, 0.13700150f, 0.08309826f, -0.02109747f, 0.01057565f, 
    -0.02099373f, 0.11472136f, 0.10554338f, -0.03675858f, -0.09740967f, -0.05200177f, 0.17389774f, -0.00405213f, 
    -0.19921954f, -0.07952728f, -0.02732225f, -0.04733331f, 0.06544424f, 0.00324570f, 0.12631917f, -0.09954088f, 
    0.11760288f, 0.14706026f, 0.07714015f, 0.11568597f, 0.10283472f, 0.23497066f, 0.10030431f, 0.18912636f, 
    -0.05473359f, -0.00073093f, -0.00023947f, 0.03084978f, 0.05042773f, -0.05656713f, 0.06811765f, 0.03061999f, 
    0.08906031f, 0.03591904f, 0.27791354f, -0.00791827f, 0.01044649f, 0.00375997f, 0.07280726f, -0.00999010f, 
    0.02401889f, 0.07822984f, 0.09764827f, -0.01862424f, -0.28136235f, -0.05590602f, -0.39728284f, 0.31843343f, 
    0.00444919f, -0.00877444f, -0.01245849f, -0.02123828f, -0.00209481f, 0.10672110f, -0.10524175f, 0.11931982f, 
    -0.12845491f, 0.07165705f, 0.11679786f, 0.08374532f, -0.04795870f, -0.08076658f, -0.05753142f, -0.04321242f, 
    0.01142530f, 0.05198289f, -0.03714630f, 0.16177514f, -0.22551513f, -0.01212533f, 0.00458316f, -0.05336446f, 
    -0.08010328f, 0.00170241f, 0.05316016f, 0.01605444f, -0.01618044f, -0.00355339f, -0.04581176f, -0.15415663f, 
    -0.13823657f, -0.20353982f, 0.04690982f, 0.14015508f, -0.11338551f, -0.02474025f, -0.10728749f, -0.03573248f, 
    -0.04823586f, -0.02488725f, -0.08163600f, -0.06117358f, 0.03573989f, 0.08711309f, 0.09123119f, 0.22621001f, 
    -0.16283052f, -0.05687598f, -0.11265794f, 0.08094487f, 0.02949728f, 0.06657901f, 0.10040454f, 0.02635013f, 
    -0.06927299f, -0.01530489f, -0.00330431f, -0.06498212f, -0.04262763f, -0.04689886f, -0.06708039f, 0.18972595f, 
    -0.03623108f, -0.16226740f, -0.08792252f, 0.01041516f, 0.41403833f, -0.00277960f, 0.22648458f, -0.19910231f, 
    -0.05997101f, -0.04433487f, -0.09448698f, -0.12687591f, 0.06006684f, -0.06603602f, 0.12313770f, -0.00619246f, 
    0.15073559f, 0.03441250f, 0.02723527f, 0.03458440f, 0.06793115f, 0.03275160f, -0.07073466f, -0.00290450f, 
    -0.06424405f, -0.07629498f, -0.14494194f, 0.09546360f, -0.04322244f, 0.03379593f, -0.01500861f, 0.01992074f, 
    -0.07908488f, 0.02398617f, 0.17339867f, 0.09992692f, 0.11808892f, 0.08621923f, -0.06069687f, -0.04364828f, 
    -0.00833660f, 0.13182437f, 0.05779365f, 0.19599958f, 0.16203050f, 0.01607758f, -0.10496250f, 0.02036816f, 
    -0.01448295f, -0.11280558f, 0.08191693f, 0.05845609f, 0.03911336f, -0.08846228f, 0.07638781f, -0.04606038f, 
    0.04175298f, 0.06704497f, -0.03234723f, 0.04849080f, -0.08714983f, -0.02957264f, -0.05688574f, -0.04820564f, 
    0.06524279f, -0.23353721f, 0.17896378f, -0.05802337f, -0.09027351f, -0.13999382f, -0.26309267f, 0.07703587f, 
    -0.22865905f, 0.03101367f, 0.07053701f, -0.01744262f, -0.08677913f, 0.07879451f, 0.06479170f, 0.23579527f, 
    0.05209211f, 0.12675108f, 0.00047918f, -0.13825691f, 0.16056494f, -0.08769717f, 0.17327608f, -0.04923872f, 
    -0.01798320f, 0.03227146f, 0.00019010f, 0.01921200f, 0.10257700f, -0.04530622f, -0.04690602f, -0.02539352f, 
    0.06547998f, -0.05061887f, 0.02720311f, 0.04126129f, 0.01787017f, -0.44427240f, 0.33245191f, -0.24291313f, 
    -0.06368371f, 0.02330540f, -0.09269508f, 0.20863545f, -0.14247714f, -0.04236407f, 0.07376900f, 0.00369909f, 
    -0.27629548f, 0.12263566f, -0.10896088f, 0.01303186f, 0.03048876f, -0.05046153f, 0.04262978f, -0.04394083f, 
    0.01261456f, -0.04855755f, -0.04832148f, -0.05387796f, -0.02253774f, 0.14924708f, 0.01702047f, -0.12070393f, 
    0.09792420f, 0.03314149f, 0.03840170f, 0.01829054f, -0.01291206f, -0.00891857f, 0.05674261f, -0.04969900f, 
    0.11962043f, -0.00158966f, -0.04396435f, 0.00920433f, 0.00083892f, 0.04094175f, 0.03645085f, -0.06707601f, 
    0.11939152f, 0.18063593f, 0.08813711f, 0.13007493f, -0.35063091f, -0.11340392f, 0.33468667f, 0.14905864f, 
    -0.14688970f, -0.18634191f, 0.00197359f, 0.16262661f, 0.00154401f, 0.03632935f, 0.02437232f, 0.00605882f, 
    0.09602506f, -0.04953819f, 0.18512765f, -0.01009998f, 0.07743405f, -0.02969568f, 0.02361670f, -0.02115999f, 
    0.12561230f, -0.00431604f, 0.00415279f, -0.01229627f, 0.17251951f, 0.11348789f, 0.05840383f, 0.08162057f, 
    0.02118065f, 0.00594164f, -0.02949924f, -0.12350213f, 0.14060989f, -0.03616016f, 0.05053623f, 0.00296736f, 
    0.08632897f, 0.23499253f, 0.14032838f, -0.11393840f, -0.01350231f, -0.04316489f, 0.11719276f, -0.04130598f, 
    -0.00870631f, -0.04536806f, -0.01499484f, -0.08350334f, -0.03562146f, 0.05407401f, -0.01833439f, 0.01265423f, 
    0.06822277f, 0.07779732f, -0.00885949f, 0.00469184f, 0.13360564f, 0.01890697f, -0.02264834f, -0.03401368f, 
    0.11020225f, 0.22866157f, 0.05109365f, -0.10774261f, 0.04394377f, -0.08675370f, 0.10273048f, -0.02268149f, 
    0.14834219f, 0.02441700f, 0.00824464f, 0.01882123f, 0.22083494f, -0.01838117f, 0.04861385f, -0.02887809f, 
    0.07787830f, 0.01264597f, -0.02082277f, 0.06295839f, -0.01138851f, -0.03761367f, 0.19633338f, 0.07117793f, 
    -0.02520460f, 0.01083276f, 0.20756446f, -0.07357517f, 0.11785830f, 0.01313077f, -0.07584300f, 0.10003559f, 
    0.06729774f, 0.03638005f, 0.04976613f, -0.09389499f, -0.03108808f, -0.23088105f, -0.06426277f, 0.02827482f, 
    0.04730465f, -0.07712670f, 0.14007638f, 0.05899329f, 0.13319145f, -0.09962509f, 0.06535249f, 0.07107140f, 
    -0.02126323f, -0.07530766f, 0.24399044f, -0.15751824f, 0.00720839f, -0.09394886f, 0.22411522f, 0.16142550f, 
    0.19007637f, -0.06589947f, -0.02847705f, -0.03141959f, 0.04841596f, -0.08469535f, -0.00511399f, 0.01603826f, 
    0.06318460f, -0.02428931f, -0.03344678f, -0.06734919f, 0.00639830f, -0.09509682f, -0.05289124f, 0.11526194f, 
    -0.05085029f, 0.09760087f, 0.00976073f, 0.15489236f, -0.06899507f, 0.16155082f, -0.02807118f, -0.05424764f, 
    0.05820511f, -0.13061596f, 0.10068730f, -0.09461851f, -0.08386764f, 0.37974650f, -0.13870460f, 0.03494500f, 
    -0.13988981f, 0.03157197f, -0.04162687f, -0.01662005f, 0.13036722f, 0.05516898f, 0.11815501f, 0.08959970f, 
    0.33250004f, 0.02783847f, 0.24025469f, 0.14150831f, -0.02578299f, 0.02704561f, -0.04211039f, 0.03817914f, 
    0.10626036f, 0.01643953f, -0.01668517f, 0.01431374f, 0.20902750f, -0.28864348f, -0.05506897f, 0.42434290f, 
    -0.08213832f, -0.10456666f, -0.12890610f, 0.02311048f, -0.07971071f, 0.05119434f, -0.09485205f, 0.14503264f, 
    0.03189347f, -0.00326050f, 0.05189529f, 0.10339181f, -0.03950756f, -0.14769022f, -0.02805052f, -0.00881528f, 
    0.07403163f, 0.12516050f, 0.06295811f, 0.15138073f, 0.07908763f, 0.16950247f, 0.12364902f, -0.06588697f, 
    -0.13801172f, 0.18630369f, 0.08188802f, 0.00058384f, -0.05306938f, -0.00491732f, 0.00678129f, 0.07886127f, 
    -0.12146851f, -0.17933169f, 0.26169744f, -0.01556655f, -0.04805124f, 0.07014228f, 0.01714545f, 0.01860068f, 
    0.05352047f, 0.05091240f, -0.02486594f, -0.04795404f, -0.02619590f, 0.04025277f, 0.04004583f, 0.23143241f, 
    -0.03973010f, -0.07025420f, 0.06063332f, -0.01509566f, 0.08092608f, -0.15477096f, -0.02676179f, 0.10293858f, 
    0.08105078f, -0.10245447f, -0.09781248f, -0.01228568f, -0.07691924f, -0.00205478f, -0.23890032f, -0.15451811f, 
    -0.10426842f, 0.10441710f, -0.02802014f, -0.11758292f, -0.10992949f, 0.03098759f, -0.39195171f, 0.04907733f, 
    0.04306132f, 0.00904243f, 0.10289668f, -0.02833433f, 0.12910299f, -0.04450749f, -0.08417427f, -0.00003587f, 
    0.09629262f, 0.06234251f, -0.00461072f, -0.02967164f, 0.02301462f, 0.00487661f, 0.02416492f, -0.02108702f, 
    0.05920683f, 0.09923837f, -0.00941498f, 0.00589136f, 0.06413380f, 0.09223681f, 0.06452926f, 0.00568880f, 
    0.03245173f, 0.04658404f, 0.08243699f, -0.00746238f, -0.00923495f, -0.08483458f, -0.12406766f, -0.11118940f, 
    0.05062763f, -0.05730988f, -0.09426574f, 0.15426241f, 0.03197007f, -0.15651236f, -0.06382097f, 0.04972289f, 
    -0.12616731f, 0.06192781f, 0.07937380f, 0.08842333f, 0.06062901f, -0.07002430f, -0.13454908f, -0.01483407f, 
    0.06464579f, 0.04113683f, 0.06096346f, -0.06822590f, -0.00349791f, -0.10251287f, -0.02705038f, -0.02241795f, 
    -0.08823952f, -0.05822969f, -0.07300293f, 0.11044622f, 0.04387378f, -0.01600116f, -0.09369360f, 0.06172584f, 
    0.03542719f, 0.08098532f, 0.12510753f, 0.13311823f, -0.03897354f, -0.09617454f, -0.07832678f, 0.05620969f, 
    0.10556740f, 0.02384917f, 0.01769452f, -0.01818829f, 0.06947596f, 0.03983253f, 0.11556609f, 0.18705447f, 
    0.20872997f, 0.10424617f, 0.08651942f, -0.01380333f, -0.05740751f, -0.00211900f, -0.03414279f, -0.00741806f, 
    0.05190957f, 0.09580267f, -0.00584180f, 0.01243742f, -0.28553721f, 0.21512081f, -0.25536439f, 0.20472048f, 
    0.05674675f, 0.01123204f, 0.09246936f, 0.04837674f, -0.06717317f, 0.00603370f, -0.11811212f, 0.11886601f, 
    0.02940957f, -0.20969139f, -0.00264022f, 0.12525797f, -0.02259726f, -0.07797712f, 0.09301938f, -0.00265144f, 
    0.03648499f, -0.02068603f, 0.01954366f, 0.11891612f, -0.04570514f, -0.02112972f, 0.16787143f, 0.19665714f, 
    -0.03913573f, 0.05955929f, 0.07401007f, -0.04960874f, 0.07664800f, -0.05269327f, -0.09132566f, -0.05043054f, 
    0.06010436f, 0.12397691f, 0.07297353f, -0.01631399f, -0.12750119f, 0.03828318f, -0.02537806f, -0.07498024f, 
    0.20244704f, 0.14183052f, 0.11090377f, 0.19063957f, -0.07029052f, -0.04701693f, -0.08961145f, 0.01607492f, 
    0.10975704f, -0.03592894f, 0.04737147f, 0.10145555f, -0.01039773f, 0.05779158f, 0.05762736f, 0.18834573f, 
    -0.01861891f, 0.37079859f, 0.13787937f, 0.07750259f, 0.03339088f, -0.00517157f, 0.02321260f, 0.03639623f, 
    0.03243311f, -0.02753546f, 0.03413627f, 0.12504074f, -0.22184157f, -0.02702000f, 0.17336379f, 0.07655741f, 
    -0.06192949f, 0.01939390f, 0.01937196f, -0.02707074f, -0.05546230f, 0.08034921f, 0.13686937f, 0.04505014f, 
    -0.11931571f, 0.16621497f, 0.15674844f, 0.15189740f, 0.04343596f, -0.10442454f, 0.03770079f, 0.00827105f, 
    0.03092422f, 0.03112771f, -0.00842913f, 0.05983959f, 0.07944089f, 0.14676701f, 0.01628363f, -0.03631452f, 
    -0.01191247f, 0.03438716f, 0.00064508f, 0.00308165f, 0.02651828f, -0.03974738f, -0.00324054f, -0.12561499f, 
    0.02208838f, 0.20953922f, 0.02686362f, 0.16904435f, 0.08841012f, 0.01085898f, 0.08780386f, -0.03243307f, 
    0.01621721f, 0.07654683f, 0.08222703f, 0.21362977f, -0.17101903f, 0.07241212f, 0.19888690f, 0.03579423f, 
    -0.01427155f, -0.00142930f, 0.13909405f, 0.05829953f, -0.07146291f, -0.04888810f, -0.08361077f, 0.01552221f, 
    -0.10751684f, -0.08274309f, 0.14840710f, 0.26761472f, 0.15812229f, 0.10402040f, 0.09338105f, 0.15815100f, 
    0.06527540f, -0.08339054f, 0.02864856f, 0.09431630f, 0.23052146f, 0.07526977f, 0.06357256f, -0.07067753f, 
    -0.02848149f, 0.06607680f, 0.00676662f, 0.00669440f, 0.09033390f, 0.01705238f, 0.06940132f, 0.04654489f, 
    -0.13928708f, 0.06226308f, 0.22534658f, 0.01940641f, 0.12411621f, -0.02724063f, -0.21834831f, 0.10766434f, 
    0.05640494f, -0.12877673f, 0.06996382f, -0.08433011f, 0.09489404f, 0.02388397f, -0.01858239f, -0.08936539f, 
    -0.02594752f, 0.10378900f, 0.01545003f, -0.10403918f, -0.09386411f, -0.02851244f, 0.04417524f, -0.10667338f, 
    -0.02631535f, -0.04048042f, -0.10249998f, 0.09837714f, 0.08256389f, -0.05574900f, -0.03080232f, 0.01441070f, 
    0.10416120f, 0.09672861f, 0.04447776f, -0.01342101f, 0.10077036f, -0.00405544f, 0.00118613f, 0.05929231f, 
    -0.06683825f, 0.04703549f, 0.16765228f, -0.06466495f, 0.08681826f, 0.16213018f, 0.08446957f, 0.10069167f, 
    -0.00265786f, 0.37262958f, -0.09831271f, -0.05185621f, 0.13780606f, 0.09480798f, -0.02861106f, -0.06747085f, 
    -0.15199505f, -0.01364661f, 0.09331089f, -0.00048825f, 0.34291127f, -0.04335601f, -0.22173196f, 0.03460052f, 
    0.20034063f, 0.01632019f, -0.18141636f, -0.07845277f, -0.13361536f, 0.21956976f, 0.00287730f, -0.06301205f, 
    0.00488197f, -0.03113017f, 0.05799845f, -0.05448180f, -0.03880190f, -0.14324518f, -0.08415226f, 0.15659037f, 
    0.05111040f, 0.11080629f, 0.08014664f, 0.08622533f, -0.21765380f, -0.05109894f, 0.08962592f, 0.24089774f, 
    -0.03408707f, 0.01436939f, 0.11624709f, -0.01794057f, -0.07956567f, -0.03897137f, 0.00081450f, -0.13328947f, 
    -0.17484257f, -0.24975024f, -0.06433395f, 0.10977084f, 0.03077122f, 0.03387339f, -0.16323017f, 0.00167319f, 
    -0.02497277f, 0.00286414f, -0.07701885f, -0.17791201f, 0.01310878f, -0.12303925f, -0.04104281f, 0.10326577f, 
    -0.12506229f, -0.12093104f, -0.04370832f, 0.02978452f, 0.08208889f, 0.12024318f, 0.17661285f, 0.06296939f, 
    0.34924644f, 0.22717969f, -0.23951070f, -0.07365330f, 0.04734267f, 0.00298954f, 0.04725853f, 0.02623562f, 
    0.03618889f, -0.01328566f, -0.11996568f, -0.11021972f, 0.33645117f, 0.07474624f, 0.14096375f, 0.00284545f, 
    -0.05898764f, 0.01502213f, -0.08529699f, -0.03064254f, 0.01670190f, -0.05627219f, 0.15861353f, 0.01931040f, 
    -0.05605875f, -0.00547599f, -0.03302145f, -0.00359266f, -0.03245915f, -0.06163323f, -0.01735341f, -0.02042854f, 
    -0.08283565f, -0.09943610f, -0.06856003f, -0.17178896f, -0.08956683f, 0.05338340f, 0.00883763f, 0.04845085f, 
    -0.05637128f, 0.02861660f, 0.00427941f, -0.06731834f, -0.04786105f, -0.00222049f, 0.16611578f, 0.15878133f, 
    0.25752556f, 0.09689783f, 0.14344855f, 0.14869547f, -0.00676593f, 0.23932579f, 0.26287770f, 0.10146160f, 
    0.05779769f, -0.01564099f, 0.04669037f, 0.02803630f, -0.07296772f, 0.16296026f, 0.02783716f, 0.04178707f, 
    -0.09845220f, 0.05650822f, 0.00503373f, 0.07066374f, 0.09093836f, 0.14670739f, 0.11750475f, 0.05097999f, 
    -0.13096857f, 0.26379892f, -0.03588173f, 0.02490756f, 0.06713661f, 0.09340465f, 0.18381633f, -0.01078900f, 
    0.03588874f, -0.06940573f, -0.01382106f, 0.04725877f, 0.14929801f, -0.00428067f, -0.02221646f, -0.16620512f, 
    -0.01382684f, -0.03522521f, 0.13133562f, 0.11291436f, -0.06447797f, 0.12109318f, -0.02078989f, -0.13728283f, 
    -0.16633920f, -0.18952027f, -0.00855630f, -0.01001535f, -0.01441114f, -0.09735594f, -0.01372880f, -0.09597680f, 
    -0.03340175f, 0.00297389f, 0.05986291f, 0.07388201f, 0.14983095f, 0.32139599f, 0.04937965f, -0.09970040f, 
    -0.11218067f, -0.09246109f, 0.05688903f, -0.05366926f, 0.00786993f, 0.01031972f, -0.09512884f, -0.01056072f, 
    0.12543505f, 0.07770615f, -0.06265264f, 0.06826525f, -0.02528894f, 0.16883136f, 0.09037247f, 0.11084995f, 
    0.06625725f, 0.06195375f, -0.03189532f, -0.00840586f, 0.16725513f, 0.08255792f, 0.01934643f, 0.04397019f, 
    0.09817495f, 0.00266362f, 0.03471730f, 0.08922462f, -0.00565355f, 0.09014004f, 0.03055112f, 0.15122113f, 
    -0.13883929f, -0.03865625f, -0.07155086f, 0.03158158f, 0.05956213f, -0.10924549f, -0.03494863f, 0.06869707f, 
    -0.06295697f, -0.04630565f, -0.09189507f, -0.25541461f, 0.11455885f, 0.18832359f, -0.09111075f, 0.03235990f, 
    0.08115037f, 0.15089571f, 0.06622266f, -0.10463629f, 0.06810835f, 0.04184624f, -0.12911347f, -0.01729731f, 
    0.15176196f, -0.04135179f, -0.04328020f, -0.11609349f, -0.09582019f, -0.04869114f, -0.09788010f, 0.00326867f, 
    -0.04524161f, -0.06566438f, -0.10164559f, -0.20101728f, 0.05522830f, 0.01069185f, -0.20556508f, -0.02008718f, 
    -0.01011537f, -0.00559841f, -0.03892086f, 0.10652015f, 0.06667801f, -0.08029842f, -0.20141836f, -0.13129075f, 
    0.14734410f, -0.10252689f, -0.12990984f, 0.20755258f, -0.08675475f, -0.03188974f, 0.01375525f, 0.01053204f, 
    -0.05078461f, -0.11660380f, -0.14825322f, -0.08966403f, -0.11721689f, -0.11820782f, -0.10009548f, 0.02707713f, 
    -0.07922360f, -0.08583414f, -0.12193444f, -0.06603942f, -0.11847955f, 0.10636269f, 0.04332495f, 0.15525946f, 
    0.15571430f, -0.15721221f, 0.15418449f, 0.06234718f, 0.04399111f, 0.09019674f, -0.00214402f, 0.12939228f, 
    0.00893617f, -0.11014398f, -0.00536636f, -0.13903505f, 0.20288542f, -0.06623468f, 0.08983433f, 0.01664436f, 
    0.00118763f, -0.02268602f, -0.06309044f, 0.05041264f, 0.07784238f, 0.16027752f, 0.14730319f, -0.11870658f, 
    0.10097004f, 0.03787861f, 0.08680802f, 0.06871511f, 0.08200415f, 0.11483265f, 0.06905075f, -0.01021176f, 
    -0.06097857f, 0.07068081f, 0.04213219f, 0.02253365f, -0.18735398f, 0.05434090f, -0.00881742f, 0.03212820f, 
    -0.04762468f, -0.07091911f, -0.08905507f, -0.05481101f, -0.03664814f, 0.05073094f, -0.01916260f, 0.09772009f, 
    0.21744420f, 0.30761379f, -0.16903611f, 0.31167477f, -0.02869019f, 0.08724601f, 0.17247634f, -0.26595941f, 
    -0.02475921f, 0.07490414f, 0.01506702f, 0.13373195f, -0.09584185f, -0.01979720f, 0.03443718f, 0.03402082f, 
    0.04562831f, -0.15404928f, 0.03757389f, 0.07357434f, 0.11981266f, 0.05323608f, -0.06845517f, 0.03693873f, 
    0.15987048f, -0.08319910f, 0.18872690f, -0.04419679f, -0.05873168f, -0.09936483f, 0.04428199f, 0.15442984f, 
    -0.15868881f, -0.02818684f, -0.10656397f, -0.05077387f, 0.22895275f, -0.27085263f, 0.06766409f, 0.25754976f, 
    0.13150479f, 0.03928348f, -0.19585963f, 0.04492652f, 0.04053668f, 0.03785349f, -0.02794951f, -0.07448135f, 
    0.07151694f, -0.07900073f, 0.02331390f, -0.30635288f, 0.02141391f, 0.05722109f, 0.03397045f, 0.05633659f, 
    0.11486580f, 0.14608946f, -0.04880310f, 0.07990467f, -0.42677274f, 0.23232712f, 0.04456564f, -0.41525832f, 
    -0.12861611f, 0.00176285f, 0.08957253f, 0.16220327f, 0.10331514f, -0.06167299f, 0.00455870f, -0.12830091f, 
    -0.06924736f, -0.01380233f, -0.08763539f, 0.07833713f, 0.19994171f, 0.23056552f, 0.02001338f, -0.14126253f, 
    -0.04142569f, 0.07280248f, -0.09293451f, -0.13818577f, -0.07233086f, 0.10505112f, -0.02528389f, -0.02431381f, 
    0.13273162f, -0.04701354f, -0.17049873f, 0.04489568f, 0.10239150f, 0.00126906f, 0.02221701f, 0.08828635f, 
    0.22804771f, 0.37322161f, -0.06090887f, 0.07233173f, 0.21878378f, 0.25736970f, 0.25244939f, -0.12944704f, 
    0.04369118f, 0.10893813f, 0.04689745f, 0.09984931f, 0.14659078f, 0.11004028f, -0.08410005f, -0.03561325f, 
    0.06271473f, 0.06588355f, 0.11883102f, -0.02727283f, -0.01368988f, 0.12414459f, -0.12526491f, -0.07961412f, 
    -0.23343386f, -0.04476328f, 0.13284369f, 0.13339421f, 0.02816038f, 0.13043365f, 0.04005956f, 0.04759884f, 
    -0.00334189f, 0.05783143f, 0.11517671f, 0.09071097f, 0.00301339f, -0.22371364f, 0.00958562f, -0.08085572f, 
    -0.05850842f, 0.00334942f, -0.00945817f, 0.01558112f, -0.00972999f, 0.06556415f, -0.08883056f, -0.01401494f, 
    0.06447032f, 0.03417948f, -0.09234130f, -0.07295921f, -0.02893935f, -0.04255136f, 0.00427156f, -0.04853243f, 
    0.12980334f, 0.08139650f, 0.10286090f, 0.05021861f, 0.05598789f, 0.08011926f, 0.17308690f, 0.03557052f, 
    -0.07480050f, -0.07524506f, -0.05872635f, -0.18735185f, -0.22533834f, -0.20060191f, -0.14955081f, -0.22048695f, 
    -0.05382096f, -0.03490020f, -0.15599452f, 0.02635413f, 0.01466069f, -0.10112696f, -0.06603803f, 0.05229671f, 
    -0.06958079f, 0.07191074f, -0.03652409f, -0.07979719f, -0.04033777f, 0.11511143f, -0.06107385f, 0.08850136f, 
    0.01924215f, -0.00846798f, 0.07128874f, -0.19797872f, 0.01885558f, -0.07689747f, 0.05583330f, -0.02737973f, 
    -0.45155910f, 0.08204772f, -0.06523322f, 0.10079114f, 0.03328400f, 0.08561885f, 0.17054941f, -0.00010897f, 
    0.14921567f, 0.04761833f, 0.27118298f, 0.05942357f, -0.10373165f, -0.10681516f, -0.19188210f, -0.06929532f, 
    0.07247646f, 0.07346535f, 0.03203133f, 0.07284831f, 0.04969456f, 0.02701365f, -0.05068912f, 0.05047392f, 
    0.19610783f, 0.09696205f, -0.02183441f, -0.14273836f, -0.07827685f, -0.15097038f, 0.06764057f, 0.01382264f, 
    0.02516980f, -0.04365313f, -0.07357150f, -0.04631322f, -0.13008453f, 0.26750529f, -0.28366867f, 0.26675072f, 
    0.12979716f, 0.01215113f, 0.14170378f, 0.06461872f, -0.00222219f, 0.04894377f, 0.05196108f, 0.03387494f, 
    0.18233985f, -0.16282223f, -0.04186880f, 0.11477310f, -0.02988012f, 0.04789535f, 0.15103552f, 0.02764316f, 
    -0.08061155f, -0.09434147f, 0.09906951f, 0.09206668f, -0.04347205f, -0.15634659f, 0.11295378f, -0.00457566f, 
    -0.08159146f, 0.02333927f, -0.01238111f, -0.04163305f, 0.02763890f, 0.03383386f, -0.00661587f, 0.12327545f, 
    0.03195350f, -0.03078477f, 0.17055990f, -0.08923846f, -0.23957296f, 0.10991079f, -0.01187145f, -0.01800307f, 
    0.17843352f, 0.19630851f, -0.05526317f, 0.09708878f, 0.31146565f, 0.03488042f, -0.04779273f, -0.02039493f, 
    0.18513216f, 0.01018835f, 0.14616844f, 0.10316308f, -0.03714285f, 0.09334201f, 0.13971730f, 0.05282717f, 
    0.05558782f, 0.44694787f, -0.04249665f, 0.17038320f, 0.07502294f, -0.00208231f, 0.11393106f, 0.00111165f, 
    -0.02231452f, 0.06980771f, 0.12404761f, 0.08575746f, -0.27056146f, 0.18321070f, -0.01481775f, 0.22549810f, 
    -0.15109059f, 0.06500309f, 0.01603372f, -0.01969621f, -0.02982669f, 0.23323347f, 0.13842884f, 0.14069864f, 
    -0.06834890f, -0.06647009f, 0.15019843f, 0.27991197f, -0.03110832f, 0.03053666f, 0.04827202f, 0.00310661f, 
    0.06983080f, 0.03315952f, 0.00482323f, 0.17379268f, 0.19454996f, 0.12503868f, -0.07990992f, -0.08599731f, 
    -0.20440800f, -0.11162641f, -0.16032036f, -0.11041985f, -0.24345359f, -0.11460407f, -0.18478979f, -0.23278023f, 
    0.14354800f, -0.06178224f, 0.21600568f, 0.09075642f, -0.06126853f, -0.08738299f, -0.07387996f, -0.02082779f, 
    -0.02716630f, 0.06202042f, -0.04595158f, 0.01954386f, 0.05243681f, -0.01205677f, 0.31762683f, 0.01458314f, 
    -0.06209798f, 0.03493011f, 0.03515518f, -0.05788797f, -0.08048346f, -0.01926816f, -0.19520207f, -0.02559518f, 
    -0.23565477f, 0.03537203f, -0.11897239f, 0.14420645f, 0.05167624f, 0.06300133f, -0.04051982f, 0.10247952f, 
    0.04977881f, 0.03518675f, -0.09313193f, 0.09149785f, 0.00722828f, 0.04682799f, 0.10428539f, -0.11982067f, 
    -0.09920426f, 0.19415112f, -0.11983144f, 0.19603764f, 0.03334057f, 0.01488767f, 0.02991969f, 0.12788324f, 
    -0.14501801f, 0.19973479f, 0.08951689f, 0.35816643f, 0.11430905f, -0.07859353f, -0.04400424f, 0.05991823f, 
    -0.05990242f, -0.05919224f, 0.05963595f, -0.19053905f, 0.10721859f, -0.02824612f, 0.06741098f, -0.16599360f, 
    -0.10111196f, 0.09377438f, 0.00398524f, -0.09174961f, -0.01481207f, 0.01074184f, 0.10993432f, -0.04092246f, 
    -0.09614399f, -0.19048898f, -0.12760727f, -0.05726707f, 0.01368592f, 0.09063625f, 0.05477944f, 0.06560844f, 
    0.01052471f, 0.07731809f, -0.07585505f, 0.16949756f, 0.30104932f, 0.00918829f, 0.14316539f, 0.20148717f, 
    0.00311839f, 0.10362384f, 0.02170161f, 0.04394275f, 0.13387711f, 0.08762787f, -0.02463322f, 0.01629077f, 
    -0.12085690f, 0.32277992f, -0.10651048f, -0.18838848f, 0.22577846f, 0.06988461f, -0.03723277f, 0.12008656f, 
    -0.23276657f, -0.04086709f, 0.08965441f, -0.01391138f, 0.14147933f, 0.22229351f, -0.19105174f, -0.15298963f, 
    0.08586933f, 0.04064084f, 0.01110841f, 0.14800484f, -0.02868142f, -0.04403096f, -0.07378460f, -0.18662822f, 
    0.01172301f, 0.09662867f, 0.01508610f, -0.05030099f, 0.05155570f, 0.04209026f, 0.14148194f, 0.18774940f, 
    -0.09617955f, 0.15479635f, 0.04641430f, -0.09063286f, -0.23819393f, -0.16428952f, -0.02766681f, 0.09774821f, 
    0.06055783f, -0.04312190f, 0.08247841f, -0.05180290f, -0.05238660f, -0.08297924f, 0.02068151f, -0.03454368f, 
    -0.12514634f, -0.14036304f, -0.31016490f, -0.03010649f, -0.01000357f, -0.00879387f, 0.00202945f, 0.04949202f, 
    -0.08882643f, 0.03650048f, -0.13574654f, -0.21701898f, 0.04986588f, 0.05446804f, 0.01032433f, 0.05239224f, 
    -0.03059249f, -0.01393149f, 0.07145867f, 0.02689565f, -0.08852071f, 0.21491010f, 0.04262756f, 0.14354447f, 
    0.05369642f, 0.32335597f, -0.20145299f, 0.09479096f, 0.20946924f, -0.07651867f, 0.13355449f, -0.13858716f, 
    0.21492918f, -0.20614076f, -0.11603402f, 0.03664567f, 0.18506508f, 0.19774127f, 0.29410973f, -0.02417859f, 
    -0.11492415f, -0.02824450f, -0.23474132f, 0.02977993f, -0.08262289f, 0.06409789f, 0.14413984f, 0.13623528f, 
    0.01647373f, 0.03081166f, 0.02587584f, 0.00940635f, -0.05685220f, -0.01006868f, 0.00039863f, -0.01815538f, 
    -0.01863528f, 0.02559391f, -0.05384121f, -0.00007202f, -0.02278591f, -0.04798846f, -0.03109755f, 0.01704722f, 
    -0.00225075f, 0.01930928f, -0.04664518f, -0.00378059f, -0.03861322f, 0.01882242f, -0.05467598f, -0.01213152f, 
    -0.00573137f, -0.02254373f, -0.02532393f, 0.00817259f, -0.05454602f, 0.01206140f, -0.05842277f, -0.04458035f, 
    0.03259624f, -0.04868220f, -0.00447131f, -0.02640793f, 0.02719411f, 0.02417211f, -0.03176860f, 0.00220209f, 
    -0.04386255f, -0.05395604f, 0.02456658f, -0.00022702f, -0.00984131f, 0.01799413f, -0.02460364f, 0.02352572f, 
    -0.03972124f, 0.03162255f, 0.02267793f, 0.03539054f, -0.04607718f, 0.02281590f, -0.03104019f, -0.03412347f, 
    -0.02232763f, -0.04890138f, -0.04506254f, -0.00486658f, -0.05366593f, 0.03494154f, 0.03042814f, 0.02484485f, 
    -0.00298307f, 0.00877577f, -0.00243911f, 0.00712046f, 0.02468942f, -0.04823982f, 0.01478976f, -0.04229262f, 
    -0.04740046f, -0.03593560f, -0.01574698f, 0.00585817f, 0.03712405f, 0.03088353f, -0.04266924f, -0.03618026f, 
    0.05247782f, 0.00816972f, -0.01816455f, -0.00647475f, -0.01285956f, -0.05754931f, -0.02292376f, -0.05478455f, 
    0.01237492f, -0.02068162f, -0.00517797f, -0.03249267f, 0.04148847f, -0.00469759f, 0.00600959f, 0.03901955f, 
    0.00010710f, -0.03460653f, -0.04756146f, -0.01485221f, -0.01356745f, -0.00311790f, 0.04148862f, -0.02734571f, 
    0.01867593f, 0.04250760f, -0.05212618f, 0.03637460f, -0.02140555f, -0.05838818f, -0.03084297f, 0.02119915f, 
    0.03535825f, -0.02342777f, 0.00184943f, -0.05120781f, 0.03470621f, 0.02505526f, -0.04855247f, -0.00888453f, 
    0.01324117f, -0.00649726f, -0.00208093f, -0.03117154f, -0.05808074f, -0.02258178f, -0.04754925f, -0.04532864f, 
    -0.00134794f, -0.00351096f, 0.00575101f, 0.03689079f, -0.04009516f, -0.02696029f, -0.05187952f, -0.05469316f, 
    -0.02573053f, 0.00453286f, -0.00381849f, -0.01891849f, -0.04069351f, 0.01447756f, 0.02064734f, 0.01827169f, 
    -0.04686857f, -0.02684594f, 0.02256092f, -0.00860310f, 0.04218690f, 0.01911906f, -0.03766934f, 0.00379901f, 
    -0.02677140f, -0.01511705f, 0.02923428f, 0.03371469f, -0.00183695f, -0.00434057f, 0.00498828f, 0.04100404f, 
    -0.01311958f, -0.02733445f, 0.00444882f, 0.02573399f, 0.00836756f, -0.03222925f, 0.00811793f, -0.03974357f, 
    -0.03921051f, -0.05818113f, -0.00627101f, 0.03211724f, 0.00552996f, -0.02370458f, 0.02015568f, 0.02201771f, 
    0.01807669f, 0.03936632f, 0.02530199f, -0.04998261f, -0.03999349f, 0.04027249f, -0.00512432f, 0.03280345f, 
    -0.02739700f, 0.03224230f, 0.01998633f, -0.04452948f, 0.00895828f, -0.05949361f, -0.03706979f, 0.04417045f, 
    0.00008098f, 0.02150663f, -0.01201314f, -0.05166539f, 0.00526235f, 0.00521973f, -0.02118270f, 0.03559085f, 
    -0.04481690f, -0.02291490f, -0.00928354f, -0.05704865f, -0.01507636f, 0.00522313f, -0.04535772f, 0.03145194f, 
    0.01435396f, 0.02291574f, -0.03503028f, 0.00077422f, -0.00600100f, -0.00727744f, 0.03103294f, -0.05658373f, 
    -0.02208210f, 0.01418323f, -0.04355439f, -0.00258566f, 0.00410711f, 0.02775942f, 0.02031218f, 0.03961385f, 
    0.03809291f, 0.01904202f, -0.03718580f, -0.01811575f, -0.00268545f, -0.00625887f, -0.02753568f, 0.00537959f, 
    0.02276658f, -0.01227974f, -0.04465139f, -0.02811348f, 0.00012728f, -0.04824286f, 0.03379459f, -0.05868077f, 
    -0.02726140f, 0.02422154f, -0.00372059f, 0.01885593f, -0.00907642f, 0.00347218f, -0.04690079f, 0.01914945f, 
    -0.04466448f, -0.04221105f, 0.04202364f, 0.03567905f, 0.02528526f, -0.04388316f, 0.02115940f, -0.03668963f, 
    -0.05808975f, -0.03097978f, -0.01020516f, -0.01441999f, -0.03696765f, 0.01897671f, 0.00146997f, -0.03436887f, 
    0.01307697f, 0.00314149f, -0.01377800f, -0.00840335f, -0.05703204f, -0.05769933f, -0.01147708f, -0.04295528f, 
    -0.02664964f, -0.02099666f, -0.03395367f, -0.02076965f, 0.01769325f, 0.03811670f, -0.00597453f, -0.05496824f, 
    -0.01290699f, -0.05765111f, -0.03782409f, -0.01122791f, 0.02023572f, -0.01522219f, 0.02287623f, 0.00115258f, 
    -0.03265677f, -0.02275548f, 0.01102605f, -0.03559307f, -0.02542587f, 0.01807154f, -0.03122551f, -0.01902751f, 
    0.01656571f, -0.01569212f, -0.05653789f, 0.00889304f, 0.00702899f, 0.01182862f, -0.00534285f, -0.02773467f, 
    -0.06098127f, 0.01655506f, -0.00678307f, -0.05956498f, 0.00175914f, 0.02749371f, -0.01972273f, -0.00342689f, 
    -0.04148600f, 0.00562879f, -0.02188720f, -0.02343931f, -0.02579676f, 0.02993969f, -0.05649539f, 0.00507468f, 
    -0.00599983f, -0.04301038f, -0.03509074f, -0.02614989f, 0.03371563f, -0.05637334f, -0.01706915f, -0.00168434f, 
    -0.00910045f, 0.00619292f, -0.00535325f, -0.04823745f, -0.02096285f, -0.00653694f, -0.03567682f, 0.01574427f, 
    0.00091330f, -0.02871592f, 0.02563442f, 0.02175248f, 0.00465752f, 0.04082907f, 0.01110418f, -0.02086616f, 
    -0.00667976f, 0.02767318f, 0.01419592f, -0.01851354f, 0.00401289f, 0.03634354f, 0.02604852f, -0.01584405f, 
    -0.04983304f, -0.04625189f, -0.02541459f, 0.03232148f, 0.03431029f, -0.00306891f, 0.03827772f, -0.01061387f, 
    -0.03586213f, -0.01793188f, -0.02440184f, -0.00031227f, 0.01927829f, -0.03714515f, 0.01815635f, 0.04852934f, 
    -0.03802805f, 0.02015782f, -0.02440863f, -0.00239894f, 0.00828712f, -0.05330003f, 0.02772283f, -0.01535065f, 
    0.04343561f, 0.03894395f, 0.00546773f, 0.02144084f, 0.03750203f, 0.01380026f, 0.04235459f, -0.01076041f, 
    0.13812710f, 0.06037055f, -0.00335712f, 0.03225922f, 0.00706644f, -0.04408074f, -0.15832627f, -0.09651715f, 
    -0.06649192f, -0.11762751f, -0.02687430f, -0.04676297f, -0.03292298f, -0.14597960f, -0.08150145f, -0.13341181f, 
    -0.08709574f, 0.06767681f, -0.01242141f, 0.04002876f, 0.02578928f, 0.02029962f, -0.01012884f, 0.02129782f, 
    -0.19186412f, -0.03400711f, -0.08715823f, -0.07619671f, 0.10004235f, 0.00777080f, -0.08006227f, 0.09358156f, 
    -0.12488411f, -0.12754044f, -0.08787660f, -0.03296109f, -0.03228710f, 0.08379019f, -0.03427015f, 0.06079376f, 
    -0.14236598f, 0.02549092f, 0.03901019f, 0.14039287f, 0.16475335f, 0.01504673f, 0.02588222f, 0.11731039f, 
    -0.27988732f, -0.03905166f, -0.05779731f, -0.05113974f, 0.03663958f, 0.02427259f, -0.02214435f, 0.00913742f, 
    0.06673634f, 0.02427629f, 0.21420459f, 0.02336322f, -0.13795079f, 0.03253091f, -0.12349117f, -0.08786640f, 
    -0.04613627f, 0.02478204f, -0.02656505f, 0.00948658f, 0.06432916f, -0.02510475f, -0.03659069f, -0.07717985f, 
    -0.05380776f, -0.06349992f, 0.00196211f, 0.07635120f, -0.04842164f, -0.08789814f, -0.04135841f, -0.05437043f, 
    -0.04827372f, -0.17162767f, -0.10791354f, 0.06539229f, 0.10632578f, 0.02938074f, -0.05115996f, 0.02874110f, 
    0.00146051f, -0.03922009f, 0.04553443f, 0.08625220f, 0.11666658f, 0.04295941f, -0.01192894f, 0.02477278f, 
    0.05962116f, 0.15078278f, 0.09433983f, 0.07152420f, 0.06572841f, 0.08221072f, 0.11083433f, -0.00817555f, 
    0.03432745f, -0.00574221f, -0.00281129f, -0.05291024f, 0.05125157f, -0.10054629f, 0.00366105f, -0.25638664f, 
    0.04670335f, -0.05948824f, 0.04758085f, 0.04277834f, 0.03059670f, 0.01682767f, 0.02394593f, 0.10187476f, 
    0.00130920f, 0.02753162f, -0.03779540f, 0.01187516f, -0.01199120f, -0.05809071f, 0.08054776f, 0.10890440f, 
    0.11383875f, 0.04722286f, -0.00230099f, -0.01967412f, -0.02813299f, 0.22450344f, 0.27517888f, 0.06968195f, 
    0.05916829f, -0.13939102f, 0.01697470f, 0.04008674f, 0.07627315f, -0.04272073f, -0.08719651f, -0.06629393f, 
    0.33195588f, 0.14650139f, 0.04021299f, 0.02448133f, 0.01344792f, -0.04367070f, -0.14108378f, 0.07887052f, 
    0.15268536f, 0.05188465f, 0.07186406f, 0.01642866f, 0.18926193f, 0.37559798f, -0.14074035f, 0.01003129f, 
    -0.05893696f, -0.02708357f, 0.03966347f, -0.03716073f, 0.07181651f, 0.06684509f, 0.07976836f, -0.03954562f, 
    0.20921503f, -0.22690585f, -0.07040309f, -0.10197928f, 0.04633008f, 0.01522992f, -0.03896994f, -0.04129549f, 
    0.03432339f, 0.01837668f, -0.08519316f, 0.00205171f, -0.01713560f, -0.22348757f, -0.15442351f, -0.15971917f, 
    -0.14463785f, -0.02136412f, -0.02105803f, -0.19704519f, 0.00168933f, 0.05163342f, -0.00401225f, -0.02064062f, 
    0.11633082f, -0.23743148f, 0.26912987f, -0.34203565f, -0.07942357f, -0.06786123f, -0.00014966f, 0.09422782f, 
    0.05036741f, 0.07144064f, 0.02168617f, 0.03693743f, 0.37245274f, -0.08630841f, 0.08273473f, -0.02046787f, 
    -0.03364876f, -0.11996743f, -0.07561032f, 0.12445269f, 0.08580854f, 0.10193840f, 0.13171290f, 0.04201461f, 
    -0.16432296f, -0.03689476f, -0.17984971f, -0.21230498f, 0.07239874f, 0.07414927f, -0.10894612f, -0.13952267f, 
    -0.04813668f, -0.10812546f, -0.15821955f, 0.10986181f, -0.16784260f, -0.20929779f, -0.07748561f, -0.08721265f, 
    -0.13700581f, -0.09948558f, 0.01204154f, 0.13136606f, -0.01160909f, -0.07947282f, -0.07898641f, -0.02145595f, 
    0.02301919f, 0.25501552f, -0.15422961f, 0.14584003f, 0.04338488f, -0.10347977f, 0.26035854f, -0.01278122f, 
    0.01567565f, -0.00373225f, -0.09792818f, 0.03792827f, -0.04022522f, -0.02671820f, -0.01291501f, 0.02584624f, 
    0.08243344f, -0.01680561f, 0.07620375f, 0.07945321f, 0.18002802f, 0.16408485f, -0.00866693f, 0.05333225f, 
    -0.02518005f, -0.17837456f, -0.01023071f, 0.01063061f, -0.11875075f, 0.18595713f, -0.03242843f, 0.01053592f, 
    0.04273856f, 0.00469822f, 0.08679988f, 0.14997962f, 0.40457818f, 0.21565743f, -0.05242016f, 0.31203532f, 
    -0.02870851f, -0.01090857f, 0.06915659f, 0.09887849f, 0.05203934f, 0.02970001f, 0.00628551f, 0.07472768f, 
    -0.04195710f, -0.06317226f, 0.37180099f, -0.05063013f, 0.05247197f, -0.13560425f, -0.07382908f, -0.00316417f, 
    0.05940846f, 0.11412410f, 0.06357530f, 0.04676624f, -0.26982138f, -0.10455302f, 0.04383309f, 0.09881297f, 
    -0.11262533f, -0.04904497f, 0.02907477f, 0.18971871f, 0.08096264f, -0.00468520f, 0.01118037f, 0.02068040f, 
    -0.16292991f, 0.21720439f, -0.00924828f, 0.03339375f, 0.08114842f, -0.02695064f, -0.02266419f, -0.01039970f, 
    -0.02535247f, 0.05432228f, 0.13022684f, 0.08532350f, -0.08977080f, 0.08867676f, 0.00434692f, -0.20554383f, 
    0.03117912f, 0.16358149f, 0.00403361f, -0.12958708f, -0.03541956f, 0.00180196f, 0.06367448f, 0.05669254f, 
    -0.15103197f, -0.06779187f, -0.20128724f, -0.06704936f, 0.05480411f, 0.03788254f, 0.10446081f, -0.10469744f, 
    0.04455136f, -0.06209228f, -0.00143816f, 0.08235756f, -0.08301078f, 0.26099512f, 0.08162791f, 0.12852126f, 
    -0.00029477f, 0.05074091f, 0.17078482f, -0.01328432f, -0.09687161f, 0.06741322f, 0.03846545f, 0.10691354f, 
    -0.07187762f, -0.13204885f, -0.13607259f, 0.18532203f, 0.08519671f, 0.03302732f, -0.15319385f, -0.11550365f, 
    -0.03324199f, 0.05852297f, 0.02032172f, -0.03240434f, -0.00746856f, -0.09366459f, -0.03261061f, -0.11547560f, 
    -0.01171779f, -0.05941653f, 0.11516084f, -0.04254457f, -0.00006262f, -0.00623091f, -0.04193992f, -0.08517180f, 
    -0.24898034f, -0.20926073f, -0.15654188f, -0.16886705f, 0.00881184f, -0.05974161f, 0.02799027f, 0.05854869f, 
    -0.06608109f, -0.03215263f, -0.02299352f, 0.00855925f, 0.00780362f, -0.00862623f, -0.00815191f, -0.09554005f, 
    0.13720506f, -0.00960838f, -0.11465260f, 0.01293120f, 0.02860666f, 0.02706291f, -0.01136861f, 0.03111376f, 
    0.13070953f, 0.15134051f, 0.00666402f, 0.16515389f, -0.05018941f, -0.04426887f, 0.18847114f, 0.06259148f, 
    -0.01246611f, 0.03041492f, 0.09688700f, 0.03669507f, 0.01666214f, -0.34762591f, -0.06134339f, -0.16374671f, 
    0.08696361f, 0.01667385f, -0.08803539f, -0.04125150f, 0.05439188f, 0.03039504f, -0.00554020f, 0.20346771f, 
    0.22626491f, -0.05980629f, 0.10349415f, -0.03436168f, 0.01850349f, -0.17784178f, 0.22763644f, 0.15664431f, 
    0.03428748f, -0.04747546f, -0.00388063f, -0.02037063f, 0.17179689f, 0.22710736f, 0.01238049f, 0.16036421f, 
    0.03560460f, 0.04137981f, 0.07224055f, -0.05727503f, -0.08479682f, 0.01175902f, 0.06954847f, -0.00320661f, 
    -0.17539528f, -0.11051656f, -0.13918458f, -0.05196594f, 0.03079179f, -0.04058325f, -0.05820093f, -0.01703846f, 
    0.00163824f, -0.04699923f, 0.11747341f, 0.16987546f, 0.23746680f, 0.16217706f, 0.09332532f, -0.11762024f, 
    -0.15002730f, -0.11420884f, 0.14538167f, 0.17565621f, 0.08428147f, 0.04667500f, -0.08312187f, -0.03163759f, 
    0.13606964f, 0.11644524f, 0.15662934f, 0.04167296f, 0.04133386f, -0.02863064f, 0.01681182f, 0.08258944f, 
    0.07717341f, 0.10322305f, 0.09160191f, 0.00113977f, 0.16179132f, 0.41437340f, 0.28307009f, -0.03154561f, 
    0.10646912f, -0.05759509f, 0.12354967f, 0.00271164f, -0.00880583f, 0.03265512f, 0.05767263f, -0.10918460f, 
    -0.12288373f, -0.15273373f, -0.09413173f, -0.12512979f, -0.00318869f, 0.03692355f, -0.12440069f, 0.00368307f, 
    -0.03657219f, -0.15920608f, 0.14216384f, -0.09586160f, 0.19740584f, 0.20608680f, -0.08921976f, 0.17750469f, 
    -0.03339411f, 0.05525217f, 0.11057814f, -0.02404623f, -0.04819291f, -0.14151059f, -0.03650189f, 0.20981543f, 
    -0.03957547f, -0.20033257f, -0.14238900f, -0.25549859f, -0.04740451f, 0.02576085f, 0.01064548f, -0.04993824f, 
    -0.12568229f, 0.03986575f, 0.10598794f, 0.10401054f, 0.19680452f, -0.36594486f, 0.04998064f, -0.01020997f, 
    0.07711851f, -0.00027929f, -0.03457736f, -0.04731616f, 0.10952105f, -0.03139076f, -0.00808467f, -0.11008126f, 
    0.08419495f, 0.10938778f, -0.12972070f, -0.32712966f, -0.01633766f, 0.07083727f, 0.01184556f, 0.10245518f, 
    0.01229507f, -0.01296967f, 0.15405817f, -0.06506515f, -0.09251713f, 0.04701675f, -0.06980979f, -0.07844780f, 
    0.11865218f, -0.09419443f, -0.10532492f, 0.04703284f, 0.02561111f, 0.00844225f, 0.15043716f, -0.10192879f, 
    -0.13410631f, 0.10233424f, -0.30922702f, 0.02426040f, 0.07706883f, 0.01153622f, 0.01219598f, 0.04354777f, 
    0.09367643f, 0.12609760f, 0.10070371f, 0.03053275f, -0.36623839f, -0.19917139f, -0.26841897f, -0.07412155f, 
    0.01348164f, 0.03437981f, -0.00696689f, 0.03345757f, 0.21063720f, 0.16676582f, 0.03518488f, -0.11105529f, 
    0.38084960f, 0.27292964f, 0.14974587f, 0.07093057f, -0.07103492f, 0.03630976f, 0.13406335f, -0.00753818f, 
    -0.06832556f, -0.05617063f, 0.03641957f, 0.02047327f, 0.05550974f, -0.06985598f, -0.04925089f, 0.07782909f, 
    0.01614926f, -0.06998193f, -0.07533619f, 0.02492286f, 0.05220560f, 0.01664665f, -0.03552473f, -0.00822347f, 
    0.22540639f, 0.13463739f, 0.08531523f, -0.25023362f, 0.07432559f, -0.03876423f, 0.00412759f, -0.09421533f, 
    -0.06230442f, -0.09070950f, 0.00299022f, -0.03129024f, -0.12249913f, 0.06658769f, -0.12625423f, -0.07052421f, 
    0.11915494f, -0.11156054f, -0.09340933f, 0.20554888f, 0.10078099f, -0.01735780f, 0.05043546f, -0.08991499f, 
    0.38380954f, 0.13230129f, -0.00157252f, 0.13306132f, 0.07736898f, -0.22842906f, -0.02743318f, -0.04214423f, 
    0.07783503f, 0.16258752f, 0.07810894f, 0.00729198f, -0.08723852f, -0.03327351f, -0.00335607f, 0.06236412f, 
    0.16528724f, 0.09342248f, 0.03921816f, 0.01694977f, -0.05306003f, 0.08414157f, 0.01033701f, -0.04010094f, 
    -0.24981132f, -0.21899009f, -0.21046720f, 0.01485209f, 0.01033927f, -0.02907299f, 0.00734608f, 0.04561290f, 
    0.14758237f, -0.05520788f, -0.07796945f, 0.00016563f, 0.18134260f, -0.44876823f, 0.30098349f, -0.03932149f, 
    -0.15463753f, -0.12709017f, 0.00524880f, 0.02685144f, 0.05662800f, 0.06275006f, 0.22815230f, 0.10511898f, 
    0.01262872f, -0.06879687f, -0.16709192f, 0.01205759f, 0.07291658f, 0.09677029f, 0.10066990f, 0.02339059f, 
    0.13341588f, -0.28730211f, -0.12167460f, 0.00977034f, 0.31294599f, 0.16073333f, 0.22333603f, 0.12441611f, 
    -0.13645323f, -0.12493175f, -0.11004753f, 0.02063947f, 0.03120834f, 0.02986311f, 0.08338053f, 0.05021129f, 
    0.36242211f, 0.21529028f, 0.39955512f, 0.20945153f, 0.00500097f, -0.04835618f, 0.00643323f, -0.12756899f, 
    0.03063330f, -0.04486722f, -0.05906854f, 0.05836866f, -0.00818211f, -0.08945043f, -0.10026856f, 0.09953735f, 
    0.14681935f, 0.20528717f, 0.08223182f, 0.08284926f, 0.15111488f, 0.09416321f, -0.03542028f, 0.00793852f, 
    0.23665091f, -0.13200803f, -0.03486077f, 0.00641007f, -0.03344051f, -0.20752861f, 0.04152979f, -0.02246036f, 
    -0.08433814f, -0.02108731f, -0.04074528f, 0.01159996f, -0.18003650f, 0.00729910f, -0.17177108f, 0.04739565f, 
    -0.04260593f, -0.06809173f, -0.06717575f, 0.04553148f, -0.03112344f, 0.00654372f, 0.02661795f, -0.09737837f, 
    0.06269961f, 0.03048360f, 0.02749715f, -0.04806679f, -0.00882483f, 0.05351886f, -0.00458747f, -0.07638174f, 
    0.09988455f, 0.07202347f, 0.14032051f, 0.03612071f, 0.02585582f, 0.05056135f, 0.08768957f, 0.03106565f, 
    0.13262713f, -0.09906717f, 0.15026620f, 0.05363619f, -0.03633488f, 0.05523893f, -0.00833854f, -0.05678803f, 
    0.02264944f, -0.10987531f, -0.01704863f, 0.14735363f, -0.07709536f, 0.03415274f, 0.02641631f, 0.08660396f, 
    0.05386769f, 0.05624467f, 0.06307252f, 0.15387771f, 0.25312138f, 0.19190167f, 0.01310693f, -0.03707631f, 
    0.07645450f, -0.00204442f, 0.03760209f, 0.00792701f, 0.03903300f, 0.07754835f, 0.15504704f, -0.06716874f, 
    -0.07781973f, -0.00181343f, -0.08650877f, 0.00682962f, -0.07461304f, 0.09073942f, -0.04015085f, -0.01591152f, 
    0.08168453f, -0.21833517f, -0.10330476f, -0.01985607f, -0.09902929f, -0.24043860f, 0.01597898f, 0.02508462f, 
    0.04354592f, -0.04127263f, 0.06537072f, 0.21384235f, -0.14266749f, 0.06259000f, -0.04006470f, -0.02777266f, 
    -0.01658998f, 0.04798680f, 0.07505274f, 0.03383205f, -0.03811815f, -0.01303650f, -0.03843021f, -0.00334363f, 
    0.10238620f, 0.13396449f, 0.01204214f, -0.07236159f, -0.10400970f, 0.01506479f, 0.07640450f, 0.05091303f, 
    -0.04207134f, 0.18654755f, 0.13400315f, -0.08028933f, -0.02841966f, -0.00916272f, 0.01949834f, 0.08591499f, 
    0.06028419f, -0.08769622f, 0.04981322f, 0.21652517f, 0.00005876f, 0.01206764f, 0.12047457f, 0.12645371f, 
    0.03887346f, 0.04033428f, 0.00594175f, 0.06351045f, -0.05120661f, -0.02210396f, 0.04612823f, 0.16824232f, 
    0.03763761f, -0.03637351f, 0.02641677f, 0.17883722f, -0.08677412f, 0.02664285f, -0.06265346f, 0.07500415f, 
    -0.08850567f, 0.03615950f, 0.04527659f, -0.03406266f, -0.01890579f, 0.03696405f, -0.06693514f, -0.03541492f, 
    0.00248920f, 0.13390951f, 0.03574749f, -0.04433690f, 0.24702387f, -0.02748277f, -0.04554193f, 0.08735098f, 
    -0.00627681f, -0.07279803f, -0.11342978f, -0.18701163f, -0.03889313f, -0.10764780f, -0.21223031f, -0.11435878f, 
    0.19679347f, 0.12424087f, 0.13314329f, 0.07680961f, 0.03336962f, -0.01470978f, 0.05173393f, -0.00970344f, 
    0.10179301f, 0.02152698f, -0.11109339f, 0.05117119f, -0.21530524f, 0.06939611f, 0.06216860f, -0.05533621f, 
    -0.02005347f, 0.04290494f, -0.05205084f, -0.05504176f, -0.10333432f, -0.12334584f, -0.18642803f, -0.00522273f, 
    -0.06075559f, -0.10436182f, 0.27343601f, 0.25348935f, 0.01587773f, -0.04156345f, 0.03884956f, 0.07878464f, 
    -0.08210014f, -0.04733095f, -0.11360410f, 0.08942557f, -0.00813587f, 0.10852354f, 0.06481636f, 0.01044903f, 
    0.07158999f, -0.01717224f, 0.05666843f, 0.02296383f, 0.06131032f, 0.09420166f, 0.02958623f, 0.04400500f, 
    -0.14260145f, -0.21757387f, 0.11609814f, 0.06723174f, -0.00615879f, 0.03621642f, -0.06563177f, 0.03814311f, 
    -0.01948330f, -0.11942443f, -0.08973412f, 0.05190954f, -0.06814108f, 0.13176318f, 0.18163830f, 0.07689098f, 
    0.00749551f, 0.03144509f, 0.07626688f, 0.08883449f, -0.02752878f, -0.02040408f, 0.11361358f, 0.00881451f, 
    -0.16497681f, 0.00464597f, 0.07222044f, 0.16345936f, -0.02076202f, 0.00069898f, 0.00690883f, 0.08947596f, 
    -0.06760362f, 0.00000437f, 0.05487303f, 0.04318416f, 0.10290284f, 0.21794651f, 0.11088827f, -0.04598631f, 
    -0.02548167f, -0.07112475f, -0.04662879f, -0.10311291f, -0.01085976f, -0.00948808f, -0.03464064f, 0.04233734f, 
    0.05782591f, -0.14555964f, 0.10926250f, 0.08311346f, 0.05365149f, -0.07022855f, -0.01602955f, 0.06698290f, 
    -0.03660550f, 0.04461415f, 0.04383403f, 0.05313575f, 0.20069121f, 0.02540407f, 0.08640217f, -0.08027309f, 
    -0.03985387f, 0.22460756f, 0.08314329f, 0.02119548f, -0.18412463f, 0.15646537f, 0.11458757f, -0.01362495f, 
    -0.14221005f, 0.07609221f, -0.09179109f, 0.09576864f, 0.13347472f, 0.03139658f, 0.02759320f, -0.10440577f, 
    0.02915125f, -0.05483002f, 0.06495989f, -0.00469380f, -0.17635590f, -0.08915115f, 0.01485822f, -0.06755777f, 
    -0.00251682f, 0.08381429f, 0.04281618f, 0.07009929f, -0.02628947f, 0.04720639f, 0.05847420f, -0.05738330f, 
    0.32591027f, 0.15910028f, 0.07479374f, -0.12922566f, -0.05502874f, -0.00984966f, 0.02205581f, 0.06340479f, 
    0.05342898f, 0.01891956f, 0.10229608f, 0.04529272f, 0.10942857f, 0.25879142f, -0.32771459f, -0.08076306f, 
    0.17146181f, -0.01952365f, -0.00440104f, -0.17043829f, -0.06402475f, 0.11490892f, 0.02699232f, 0.17059760f, 
    -0.11757221f, -0.17273571f, -0.14189990f, -0.07408929f, -0.06869825f, -0.00093048f, -0.00380270f, -0.06600007f, 
    -0.01901834f, -0.00156480f, -0.06564654f, -0.15035747f, -0.10594591f, -0.05260220f, -0.03333445f, 0.08187310f, 
    0.03171941f, -0.01048244f, 0.02316822f, 0.01067238f, 0.04720723f, -0.00321528f, -0.01178360f, -0.12487576f, 
    -0.06103658f, 0.00303261f, 0.00760986f, 0.19143309f, -0.01795275f, 0.02535016f, -0.01058013f, 0.01673696f, 
    -0.02681870f, -0.01264695f, -0.00718062f, -0.04668223f, 0.07992728f, -0.03838286f, -0.08174173f, 0.09265710f, 
    -0.15578383f, -0.05659095f, -0.04821104f, 0.05303228f, -0.05228651f, 0.09642418f, 0.04072160f, -0.16092519f, 
    -0.08992597f, 0.11010809f, 0.01849899f, -0.06607654f, 0.06260514f, 0.04575954f, 0.10569248f, 0.08779776f, 
    0.06399974f, 0.00652622f, 0.12280576f, -0.05401846f, 0.28442675f, 0.20408982f, 0.30918631f, 0.13037445f, 
    -0.13419001f, 0.02357907f, 0.02750696f, -0.01332583f, -0.03271745f, -0.03106955f, 0.02518153f, 0.02309932f, 
    0.05584480f, -0.02088663f, 0.06006595f, -0.06613959f, -0.07588119f, 0.00118035f, 0.01148217f, 0.10841023f, 
    -0.02802523f, 0.12623991f, 0.03820169f, 0.01294116f, -0.35794559f, -0.07303230f, 0.14422287f, -0.13090628f, 
    0.05832440f, -0.12713127f, -0.00484940f, -0.00693948f, -0.03119771f, -0.09173895f, -0.11827168f, -0.05151903f, 
    0.33249903f, 0.14256215f, -0.14372075f, 0.03593566f, 0.17210168f, -0.03730520f, 0.10847440f, -0.12422834f, 
    0.08560260f, 0.14782353f, 0.02738210f, -0.06975203f, -0.04294314f, -0.16217381f, 0.02721998f, -0.08646221f, 
    0.01766932f, -0.11652824f, -0.09049112f, 0.05164680f, 0.07664856f, 0.09845530f, 0.10579528f, 0.13553652f, 
    0.22858734f, -0.22118907f, 0.12547295f, 0.00084097f, 0.11251339f, 0.06357518f, 0.10293498f, 0.03566297f, 
    -0.13112164f, 0.06957847f, -0.05117858f, 0.05401268f, 0.05094079f, 0.18816508f, -0.17367017f, 0.38856888f, 
    0.16999137f, 0.14550766f, 0.04172729f, -0.14285848f, 0.26445326f, 0.00240130f, 0.06620415f, 0.02717779f, 
    -0.28732270f, -0.11247201f, -0.05028476f, -0.04699543f, 0.06336433f, -0.12926997f, -0.01496768f, -0.07617647f, 
    -0.01375830f, 0.03599380f, 0.03275308f, 0.05700597f, 0.18679155f, -0.07962196f, 0.15920101f, -0.14303319f, 
    0.06565138f, -0.03941223f, -0.04024779f, 0.00895321f, -0.05141804f, 0.09443709f, -0.00918209f, 0.07308768f, 
    -0.09585729f, -0.17124417f, -0.30572528f, 0.08662429f, 0.05404040f, -0.01890851f, -0.06365144f, 0.02962602f, 
    0.00019311f, -0.03810159f, 0.00556340f, 0.11598346f, -0.07815382f, 0.08111750f, 0.01097906f, -0.04421559f, 
    0.13362315f, 0.12214673f, -0.12586240f, -0.11728650f, -0.01911367f, -0.06038604f, 0.02346196f, -0.06285416f, 
    -0.10238896f, -0.14618167f, -0.03726016f, -0.00774446f, -0.03550284f, 0.14215490f, -0.02664413f, -0.07814614f, 
    0.10257135f, 0.07854008f, 0.02475293f, 0.04104775f, -0.14461918f, -0.13985130f, -0.01444602f, 0.04010594f, 
    -0.09803546f, -0.04931781f, 0.03630870f, 0.15230028f, -0.05488527f, -0.03641159f, 0.01005233f, 0.12183178f, 
    -0.25038469f, 0.05312665f, 0.14585295f, -0.17865296f, 0.02425192f, -0.08457793f, 0.17062794f, -0.14784250f, 
    0.10699448f, 0.04882727f, 0.06831176f, -0.02128523f, -0.05167095f, 0.10375278f, 0.04296578f, 0.12031202f, 
    0.03417519f, -0.01769885f, 0.17438927f, -0.06276402f, 0.21382388f, 0.05511653f, 0.09934559f, 0.06837072f, 
    -0.22999828f, 0.25604776f, 0.10260483f, 0.06103780f, 0.07974336f, -0.07627759f, 0.02448847f, -0.06819592f, 
    -0.00928524f, 0.06046277f, 0.17155096f, -0.00653802f, -0.30611753f, -0.13933244f, -0.08010910f, 0.01801076f, 
    0.01215624f, 0.04668068f, -0.11268339f, 0.11287953f, 0.01869449f, -0.10070016f, 0.03652482f, -0.13102868f, 
    0.18209377f, 0.33765879f, 0.05801307f, 0.15787177f, 0.07334927f, -0.07638265f, 0.06965362f, 0.04119084f, 
    0.17928538f, 0.13398859f, 0.04764259f, -0.14818373f, 0.11747769f, -0.07587941f, -0.03483878f, 0.06277151f, 
    -0.03432282f, -0.01029290f, -0.06422229f, 0.06446709f, 0.17217700f, -0.01570372f, -0.07271439f, 0.05479258f, 
    0.12823011f, -0.13046256f, 0.16561741f, 0.01900647f, 0.16715109f, 0.10616302f, 0.05397172f, 0.01032092f, 
    0.01433005f, 0.07908546f, 0.06899632f, -0.05642154f, -0.37088686f, -0.31840682f, 0.01008463f, 0.12033372f, 
    0.14224687f, -0.03424390f, 0.11377901f, -0.07367589f, 0.15130700f, -0.07607961f, 0.05389664f, 0.11605886f, 
    -0.01388422f, -0.11572716f, 0.33401969f, -0.03091784f, 0.18042111f, -0.14665233f, -0.01188126f, -0.02206696f, 
    0.01882399f, -0.02315854f, -0.05599562f, -0.05930749f, 0.11843628f, -0.04335588f, 0.01602217f, 0.00910871f, 
    0.01758466f, -0.05897697f, 0.03193639f, 0.10036401f, -0.00875486f, -0.06351080f, 0.00524887f, 0.02794017f, 
    0.29419538f, 0.05393855f, -0.22094291f, 0.12552229f, 0.03437117f, 0.11713989f, 0.01620298f, 0.03832399f, 
    0.04721973f, -0.01976338f, -0.07983176f, 0.01244223f, 0.02526875f, 0.25799143f, -0.21744183f, 0.44797355f, 
    -0.00437870f, 0.09185775f, -0.06897925f, 0.11234486f, -0.01052523f, 0.00207242f, 0.00882772f, 0.11833513f, 
    0.19426167f, 0.09870315f, -0.03572217f, -0.27659544f, -0.08427198f, 0.09087873f, 0.02784962f, 0.00061386f, 
    0.06980520f, 0.12608100f, -0.13913083f, 0.08120608f, 0.81554562f, -0.24643348f, 0.13716178f, -0.12426375f, 
    -0.08142090f, 0.05890580f, -0.12143973f, 0.06987716f, 0.09792896f, 0.04343781f, -0.04547798f, 0.09824233f, 
    0.10460452f, -0.07331742f, 0.01032174f, 0.10112435f, 0.04105315f, 0.07553971f, 0.22167715f, 0.17344779f, 
    0.09811683f, -0.07980029f, -0.08759330f, 0.14442170f, -0.12308379f, -0.02563348f, 0.09111893f, 0.18827061f, 
    -0.01254239f, -0.03264784f, 0.08753327f, 0.10372374f, -0.06752890f, 0.05132199f, 0.02047980f, 0.06986280f, 
    0.05818218f, -0.22559598f, -0.06182056f, -0.14450353f, 0.01517556f, 0.03973773f, -0.02323629f, 0.01212408f, 
    0.01461228f, -0.09145088f, 0.00027723f, 0.02094496f, 0.12103046f, -0.10065024f, -0.08176600f, 0.16720408f, 
    0.03932619f, -0.00341294f, 0.15702498f, 0.06749997f, 0.12526545f, -0.07779559f, -0.12168480f, 0.15200520f, 
    0.18364811f, -0.00013769f, -0.26150706f, -0.00601643f, -0.01017587f, 0.06413599f, -0.05653195f, -0.12442453f, 
    -0.02786335f, 0.00975965f, -0.04295549f, 0.02882342f, -0.18491964f, 0.21910341f, -0.14324695f, 0.18441746f, 
    0.00093166f, 0.01537723f, -0.11460581f, -0.00483854f, 0.03341126f, -0.09769878f, 0.04526253f, -0.06902400f, 
    0.02151870f, -0.00498861f, -0.11356576f, -0.14526556f, -0.02027050f, -0.05582975f, -0.06962116f, -0.00799135f, 
    -0.00627211f, 0.05126265f, -0.08731521f, -0.03567437f, -0.13058044f, -0.00502441f, 0.09358113f, -0.11260156f, 
    0.09591772f, 0.16863245f, -0.15142211f, 0.06557139f, -0.01596860f, 0.00236061f, -0.04158970f, 0.03663482f, 
    0.09844382f, -0.11529686f, -0.03478312f, 0.04415615f, 0.02522202f, -0.08544827f, 0.06060612f, 0.00674750f, 
    0.09045269f, 0.07053527f, -0.02368338f, -0.01947987f, -0.13711783f, -0.20989722f, 0.03996523f, 0.00436813f, 
    -0.03279513f, 0.00117113f, -0.06261519f, -0.09994362f, 0.06590875f, 0.05142379f, 0.09194624f, 0.15706211f, 
    -0.13392273f, -0.05405828f, -0.06025589f, -0.00999802f, 0.05196810f, -0.11633780f, 0.08180682f, -0.03998267f, 
    -0.00890225f, 0.17254320f, -0.04504534f, -0.03383752f, -0.02413729f, -0.02655794f, -0.07344694f, 0.20073450f, 
    0.11747680f, 0.03022567f, -0.01236210f, -0.03770174f, 0.07657205f, -0.16242908f, 0.05511794f, 0.00057426f, 
    0.07989039f, 0.11455979f, 0.00831421f, -0.05453407f, -0.08143640f, -0.07331607f, -0.10538362f, -0.03496680f, 
    -0.05947742f, 0.01091425f, 0.02811476f, 0.00040886f, -0.20551413f, 0.38428795f, -0.05830907f, 0.16000205f, 
    -0.10355905f, -0.03567354f, 0.03241903f, 0.17939587f, -0.03138003f, 0.00244321f, -0.02633183f, -0.04177028f, 
    0.00135637f, -0.05722917f, -0.02982118f, -0.00749202f, -0.01293729f, -0.10355736f, 0.05825587f, -0.04168308f, 
    0.05712850f, 0.00162178f, 0.09195209f, 0.04856800f, -0.07325642f, 0.10684217f, 0.22385633f, 0.17266054f, 
    0.00996234f, 0.08571076f, 0.09092023f, -0.08455560f, 0.04350319f, -0.03026943f, 0.03338296f, -0.07925975f, 
    0.00022781f, -0.00719889f, 0.09671062f, 0.00072331f, -0.05235982f, 0.01442756f, -0.06619085f, -0.03968777f, 
    0.13971861f, -0.00196066f, -0.01082833f, 0.01705051f, -0.26564187f, 0.00472450f, -0.04878217f, -0.03798632f, 
    0.02912096f, -0.01965086f, 0.10309270f, 0.07381503f, 0.01823483f, 0.00705636f, 0.03260944f, 0.15406571f, 
    -0.19734752f, 0.23407522f, 0.00557210f, 0.10897729f, -0.02080833f, -0.00285736f, -0.01279749f, -0.03097399f, 
    0.00552492f, -0.02507778f, 0.10775664f, 0.07051817f, 0.02157117f, -0.08723115f, -0.06318378f, 0.00848936f, 
    -0.04478664f, 0.11771242f, 0.04063245f, -0.04672384f, 0.03801187f, 0.03228074f, 0.02693785f, -0.08521642f, 
    -0.08756247f, 0.40358114f, -0.02268850f, -0.10733401f, 0.08001164f, 0.05622973f, 0.01381988f, -0.05284739f, 
    -0.00790449f, 0.00132788f, 0.05976306f, -0.13636929f, -0.05453884f, 0.03329721f, -0.00989421f, -0.02876689f, 
    0.02329958f, -0.06050037f, -0.13223517f, -0.05550094f, 0.01217203f, -0.10924710f, 0.02718275f, -0.03257765f, 
    -0.05179039f, 0.16553092f, -0.24271999f, 0.15195219f, -0.01832887f, -0.01319625f, -0.03054467f, -0.07789259f, 
    0.02325856f, 0.04958429f, 0.05103605f, 0.05682988f, -0.24190766f, -0.00801508f, -0.09509853f, -0.02217643f, 
    0.05385940f, -0.00357819f, 0.06038228f, -0.01089773f, 0.16854686f, 0.12280918f, -0.00434785f, 0.02920927f, 
    -0.07699388f, -0.17207623f, 0.23205288f, 0.16178769f, 0.11757732f, 0.01435977f, -0.00240294f, -0.04840310f, 
    -0.01679893f, -0.20790152f, 0.10722242f, -0.00318523f, 0.07545906f, 0.03757833f, 0.13798115f, 0.10269929f, 
    -0.09753747f, -0.01934951f, -0.06441066f, 0.09083604f, 0.02785999f, -0.04330049f, -0.02028973f, -0.05235379f, 
    -0.17127012f, 0.29676527f, 0.09085721f, -0.18689477f, 0.11166860f, 0.11825261f, -0.00431798f, -0.01248030f, 
    0.03186018f, -0.07267751f, -0.01293088f, 0.02214236f, 0.04739454f, 0.09167363f, -0.09234059f, -0.04759703f, 
    -0.00537970f, -0.11174475f, -0.01306246f, 0.02807876f, 0.17585237f, 0.10100053f, -0.05363103f, 0.03553730f, 
    0.17287137f, -0.17175174f, -0.00354225f, 0.22417182f, 0.09433223f, -0.00320068f, -0.05599216f, 0.06726411f, 
    0.05796703f, 0.13961673f, 0.05055920f, 0.00573263f, -0.11031597f, -0.03892691f, -0.05053970f, 0.23704427f, 
    -0.00531903f, 0.16615380f, 0.09620459f, -0.11380393f, 0.07282069f, 0.05998105f, -0.11314966f, 0.14687076f, 
    -0.28703904f, -0.13679753f, -0.12122262f, -0.15936369f, 0.03576018f, -0.03947756f, -0.00650512f, 0.01692321f, 
    0.12248652f, 0.10182587f, -0.05508237f, 0.08763744f, 0.17970131f, -0.26341960f, -0.01252357f, 0.00982252f, 
    0.04515095f, 0.04189371f, -0.07255553f, 0.12674549f, 0.13566242f, 0.01292749f, 0.15682022f, -0.02637131f, 
    -0.23230004f, -0.11003440f, -0.08470131f, -0.03991744f, -0.03891882f, -0.11439982f, -0.03622129f, 0.13739434f, 
    0.00512207f, -0.03353311f, -0.14219089f, 0.01259472f, -0.05903278f, 0.12020389f, 0.20830368f, 0.37340823f, 
    -0.05154041f, 0.10422307f, 0.05691929f, 0.02907610f, 0.05252211f, 0.01896582f, 0.02142960f, 0.01868526f, 
    -0.10429913f, -0.18029191f, 0.10892998f, 0.04547002f, 0.13267560f, 0.04689891f, -0.01779192f, -0.03268873f, 
    -0.02551627f, -0.01582029f, 0.00277803f, 0.03802838f, -0.00586388f, -0.15028229f, 0.00618593f, 0.09434950f, 
    0.00759158f, -0.06923179f, 0.00169065f, 0.06039433f, 0.19872388f, -0.03810038f, 0.00386529f, 0.05356982f, 
    0.31374845f, 0.03197368f, -0.15227558f, 0.06557292f, -0.04485623f, -0.02546121f, 0.10534013f, 0.08054024f, 
    -0.06913404f, 0.06886285f, -0.07449324f, 0.02981454f, 0.33235064f, 0.05330856f, 0.08293580f, 0.02211412f, 
    -0.04067272f, -0.06351984f, -0.11753280f, -0.03054271f, 0.00235432f, -0.02772663f, 0.02943726f, 0.05080334f, 
    -0.02019891f, 0.02328368f, 0.04057102f, 0.02602507f, 0.00276993f, -0.01633283f, -0.03458335f, -0.03375935f, 
    -0.03258642f, -0.01346394f, -0.04607834f, 0.02866538f, -0.00901790f, 0.03035222f, -0.02655961f, -0.02818303f, 
    -0.00716944f, -0.04170072f, 0.03001944f, 0.01827382f, -0.05302044f, 0.03976159f, 0.00779412f, 0.02730590f, 
    -0.02758025f, -0.00990012f, -0.05150121f, 0.03043629f, -0.01284178f, -0.03857864f, 0.04054795f, -0.01131357f, 
    0.01300013f, 0.01311566f, -0.04087854f, -0.03321930f, -0.00499115f, 0.02570048f, -0.02711214f, -0.00578488f, 
    -0.04938988f, 0.01115841f, 0.02253433f, 0.03561750f, 0.03075067f, 0.00809438f, 0.01045181f, -0.01043564f, 
    0.00583267f, -0.04796205f, -0.05390966f, -0.00700535f, -0.04326986f, -0.02935975f, -0.02433782f, -0.04001725f, 
    -0.03321980f, -0.01963964f, 0.00470547f, 0.03067006f, 0.03995203f, -0.01597422f, 0.03448349f, -0.01125573f, 
    -0.01946576f, 0.01538705f, -0.00325767f, -0.02862886f, 0.01610339f, 0.01598840f, 0.02707039f, -0.01798746f, 
    -0.00087636f, -0.02706505f, -0.01400377f, -0.02275995f, -0.05300074f, 0.02833039f, 0.02060439f, -0.04190217f, 
    -0.00804263f, -0.04684045f, -0.04923920f, -0.05690481f, 0.03601779f, -0.02326876f, -0.01716983f, -0.02882336f, 
    -0.01157181f, -0.00796126f, -0.02286335f, -0.05318869f, -0.05272400f, -0.00742815f, -0.00400481f, 0.02785900f, 
    -0.05440699f, -0.05182784f, 0.03975279f, 0.03460638f, -0.04913152f, -0.03889586f, -0.00831964f, 0.02136188f, 
    0.01142680f, -0.02917100f, -0.00629695f, 0.02997756f, -0.00936916f, -0.03356527f, 0.02839354f, -0.03357473f, 
    0.02978549f, 0.00894175f, -0.02937617f, 0.04194974f, -0.03905016f, -0.01416945f, -0.03262103f, -0.00955164f, 
    -0.03092732f, 0.04366434f, -0.05308908f, 0.02349842f, 0.01442510f, -0.03434181f, -0.01379107f, -0.03813176f, 
    -0.03672854f, 0.01791060f, 0.03914359f, 0.00022700f, 0.00499468f, -0.02377642f, -0.04245858f, -0.03383427f, 
    -0.00298729f, -0.00552908f, -0.03170051f, -0.01314927f, -0.05367146f, 0.03292124f, -0.04175084f, 0.01198804f, 
    -0.04976042f, -0.02851920f, -0.04750531f, 0.03600080f, -0.02000697f, 0.01598303f, 0.00746159f, 0.04083369f, 
    -0.03116979f, 0.00839601f, 0.01615977f, 0.02515470f, -0.02395300f, 0.00716153f, -0.04130945f, -0.03229343f, 
    -0.03216271f, 0.01803642f, 0.02049228f, -0.00436811f, 0.01753938f, -0.02206073f, -0.02944309f, -0.01679894f, 
    0.02346758f, 0.00570838f, 0.01453957f, -0.04440797f, 0.00174011f, 0.02188117f, 0.04420881f, 0.00746893f, 
    -0.02825892f, -0.00207019f, -0.02480290f, -0.00506304f, -0.01012629f, 0.01119357f, -0.03063550f, 0.01016962f, 
    -0.03632267f, -0.03391442f, -0.00110991f, -0.03609181f, -0.05021000f, 0.02961211f, -0.03116786f, 0.02013448f, 
    -0.01478142f, -0.02572694f, -0.02317731f, 0.03568583f, 0.01109016f, 0.02392018f, -0.00486283f, 0.03428243f, 
    -0.03658454f, -0.01125963f, 0.04102112f, 0.02832565f, 0.02621402f, -0.02146649f, -0.02770632f, -0.05258305f, 
    -0.04522079f, -0.03554750f, -0.00014739f, -0.01168828f, 0.03032563f, -0.03928022f, 0.02203261f, -0.01114852f, 
    0.00164387f, -0.01775590f, 0.00070779f, 0.03388362f, -0.04566388f, -0.00817148f, -0.01338115f, 0.00915496f, 
    -0.05537948f, -0.04390173f, -0.04809517f, 0.02599575f, -0.03896207f, -0.00685151f, -0.00422372f, -0.04065507f, 
    0.03315778f, -0.02997460f, 0.01073429f, 0.04596620f, -0.02472103f, -0.03493827f, -0.03682600f, -0.03347699f, 
    0.03742720f, -0.00487351f, 0.03065455f, 0.01067453f, 0.04436569f, -0.04863280f, -0.03123070f, -0.00404758f, 
    -0.00789090f, -0.03387383f, -0.04649081f, -0.03865713f, -0.03814836f, -0.01186265f, -0.03108623f, -0.03534013f, 
    0.05087835f, -0.03475611f, 0.03927591f, 0.01659928f, 0.00306212f, -0.03112203f, -0.04094572f, -0.04947562f, 
    0.03619570f, -0.03930353f, 0.01696919f, -0.01525855f, -0.04580940f, 0.02776905f, -0.01156188f, -0.01923175f, 
    -0.00971965f, -0.01410434f, -0.05555703f, -0.05465941f, -0.05061022f, -0.01197420f, 0.01469359f, -0.00050314f, 
    0.04106004f, 0.04435274f, 0.02920492f, 0.02730677f, -0.04067849f, 0.02280618f, 0.00103845f, -0.02687903f, 
    0.03881979f, -0.00613548f, 0.03405570f, 0.02280444f, 0.02869871f, -0.00055125f, 0.02069519f, 0.04385112f, 
    0.01543713f, -0.00384910f, -0.01467883f, -0.00534941f, 0.00226409f, -0.01046566f, 0.01893320f, -0.01722978f, 
    -0.03021886f, -0.03660042f, -0.03005311f, -0.01621079f, -0.02998915f, 0.02108479f, -0.03182174f, 0.01224103f, 
    0.04107204f, 0.02991025f, -0.05097617f, 0.02721687f, -0.02843672f, -0.03337761f, 0.01520909f, -0.03238955f, 
    0.01293478f, 0.00062607f, 0.02363943f, -0.04736088f, -0.00209211f, -0.03593889f, -0.02683588f, 0.03228745f, 
    0.04333490f, -0.04478879f, 0.04469831f, 0.02746705f, -0.03061434f, 0.03069192f, 0.02438345f, -0.00673736f, 
    0.03470045f, -0.01434474f, -0.01746785f, -0.03265647f, -0.03078860f, -0.04377516f, 0.03435314f, -0.00396452f, 
    -0.04270854f, 0.03746019f, 0.00547940f, 0.03976985f, 0.00573526f, 0.02948553f, -0.02577205f, 0.01156054f, 
    -0.04147731f, 0.00123288f, 0.00281823f, -0.05550414f, -0.02607748f, -0.00506183f, -0.05540794f, -0.00576877f, 
    -0.02894053f, 0.01790750f, -0.04451197f, 0.03831330f, 0.01410172f, -0.01567981f, -0.04946258f, -0.04916913f, 
    -0.00913828f, 0.02890073f, 0.00155745f, 0.04138567f, 0.00583401f, 0.03647309f, -0.04492792f, 0.01547911f, 
    -0.01613343f, 0.02916943f, -0.04747632f, -0.02345994f, 0.01343817f, 0.01802330f, 0.04471346f, -0.01386071f, 
    0.00833154f, 0.04375711f, -0.03835412f, -0.00246786f, 0.02056417f, 0.03921619f, 0.01571581f, 0.00129508f, 
    -0.02852037f, 0.02141873f, -0.04600808f, -0.00837104f, 0.00308946f, 0.03488458f, -0.05353044f, -0.02080299f, 
    -0.01981876f, 0.02118658f, -0.01215528f, -0.05430623f, -0.03563772f, 0.03027380f, 0.00309385f, 0.01892048f, 
    0.02018516f, 0.01786431f, 0.03744986f, -0.05517351f, -0.03739337f, -0.00178667f, -0.01845586f, 0.02242465f, 
    -0.03981911f, 0.00024461f, 0.00026941f, 0.01597727f, 0.02853731f, 0.01389295f, -0.04371470f, -0.00145744f, 
    0.03445713f, -0.02761245f, -0.05235971f, -0.00545942f, -0.02978582f, -0.04086275f, -0.01960665f, -0.05081128f, 
    -0.02125258f, 0.04481525f, -0.00163798f, -0.02488171f, -0.05331284f, -0.05501735f, 0.01859357f, 0.01494609f, 
    -0.01939916f, -0.01626459f, -0.03064674f, 0.03776820f, -0.02769802f, -0.02156463f, -0.02463053f, 0.03843090f, 
    -0.00826843f, -0.02380169f, 0.02598349f, 0.00379673f, -0.03343768f, -0.04219553f, 0.03007220f, -0.02967575f, 
    -0.01506044f, -0.01649787f, -0.01062049f, 0.02660500f, -0.00624146f, -0.02454038f, -0.05387462f, -0.05513895f, 
    -0.04561388f, -0.01368762f, 0.03493832f, 0.02244218f, 0.00031669f, -0.03915558f, 0.00695966f, -0.01608520f, 
    -0.01603214f, -0.02499925f, 0.03962451f, 0.01443167f, -0.04270031f, -0.04121305f, 0.02679407f, 0.01075432f, 
    -0.04290677f, -0.00569155f, -0.00450696f, -0.01988672f, 0.01254669f, -0.04405538f, 0.01587033f, 0.03026930f, 
    0.00147883f, -0.04899952f, -0.01404524f, 0.02372623f, -0.00011913f, 0.01693799f, 0.03841621f, -0.02198432f, 
    0.00808901f, 0.04001943f, 0.05339888f, -0.00118220f, -0.04024829f, 0.00557094f, -0.05522454f, 0.03879602f, 
    0.01375458f, -0.05331796f, 0.00989404f, -0.03841560f, -0.01270053f, -0.02515186f, 0.04036191f, -0.02920116f, 
    -0.05484868f, -0.01557468f, 0.02288043f, 0.00835169f, 0.00083446f, 0.03614399f, 0.00012725f, -0.01989515f, 
    -0.01797387f, 0.03614032f, 0.03672770f, -0.04670509f, -0.03141202f, -0.04391554f, -0.02661202f, -0.00471549f, 
    0.00371212f, 0.00644884f, 0.04246139f, 0.03683130f, 0.01900072f, -0.05061811f, -0.04651802f, -0.05346378f, 
    -0.03395376f, -0.02639350f, 0.04474596f, -0.02975096f, 0.01076900f, -0.04694322f, -0.04502601f, -0.03914205f, 
    0.03733363f, -0.03620235f, 0.03047492f, -0.03343094f, -0.03595364f, -0.01038387f, 0.01952124f, 0.00435898f, 
    -0.02502525f, 0.04249085f, -0.05050468f, -0.02198902f, -0.03688028f, -0.04440699f, -0.03067823f, -0.02527517f, 
    -0.03411517f, 0.02262964f, -0.04096741f, -0.04425983f, 0.01402957f, -0.00358521f, -0.02631349f, 0.02863016f, 
    0.01934639f, 0.01108919f, 0.03603584f, 0.03373678f, -0.03235959f, -0.02451632f, 0.03366945f, -0.03037434f, 
    0.01256090f, 0.01336348f, 0.03799115f, -0.02838161f, -0.04332534f, -0.04282974f, -0.00046016f, 0.02630738f, 
    -0.04387520f, 0.04258238f, -0.00052339f, -0.05018703f, -0.03590935f, -0.03859778f, 0.03716716f, 0.00362630f, 
    0.02038557f, -0.01599677f, 0.04150187f, -0.03339521f, -0.00007083f, -0.05627453f, 0.01745886f, -0.05236819f, 
    -0.01872424f, 0.02020668f, 0.00762196f, -0.03083601f, -0.03248768f, -0.04434992f, -0.00198598f, 0.02140199f, 
    -0.05117424f, -0.02515243f, -0.01377928f, 0.04323246f, -0.01893964f, -0.01688768f, -0.00212014f, -0.01011493f, 
    -0.03814735f, 0.03670847f, -0.03567233f, -0.00667199f, 0.00133835f, 0.01642039f, 0.04004826f, -0.02656331f, 
    -0.00987324f, -0.02903623f, -0.00182704f, 0.03501273f, -0.04601663f, -0.00600176f, -0.04091670f, 0.02446036f, 
    -0.01605312f, -0.02966955f, -0.04034534f, 0.02631716f, -0.05362096f, -0.03454700f, -0.02953205f, -0.05404964f, 
    0.02911322f, 0.03863828f, 0.01404367f, 0.01536395f, -0.01495718f, -0.03198195f, 0.00161888f, -0.00017765f, 
    0.02696470f, -0.02034248f, 0.04380563f, 0.00112604f, -0.03907476f, -0.04876632f, -0.03052141f, -0.04793449f, 
    -0.04906309f, -0.01190048f, -0.04869162f, 0.00777514f, 0.02086419f, 0.02168014f, 0.00681262f, 0.00402562f, 
    -0.05555292f, -0.05667225f, -0.00478064f, -0.03547785f, 0.01598322f, -0.04839011f, -0.05600411f, 0.04035019f, 
    0.00436943f, 0.04044370f, 0.02038621f, 0.01617835f, 0.01691920f, -0.01681960f, -0.01079136f, 0.02626836f, 
    -0.03223159f, 0.03933460f, -0.02388990f, 0.03239483f, -0.03615621f, 0.03471281f, 0.02565342f, -0.00733192f, 
    -0.05163345f, 0.04423803f, -0.04192518f, 0.03135807f, -0.02829698f, -0.02554520f, 0.03638678f, 0.02561945f, 
    -0.03114663f, -0.00107102f, 0.03050197f, -0.00674144f, -0.03940452f, 0.01053783f, 0.00436241f, -0.01360617f, 
    -0.00117228f, 0.00294632f, 0.02581721f, -0.00774533f, -0.03370104f, 0.03393130f, 0.03141154f, -0.04489953f, 
    0.00845800f, 0.01199258f, -0.05656825f, -0.01214797f, 0.02138434f, 0.04264323f, -0.01361224f, -0.01269494f, 
    0.03043151f, 0.02109934f, -0.02838792f, -0.05671255f, 0.00154068f, -0.03991563f, 0.01110393f, 0.04259222f, 
    -0.03055947f, 0.00125690f, -0.01554714f, -0.03044926f, 0.02151586f, 0.03578558f, 0.03808595f, -0.05177615f, 
    -0.05549072f, -0.04798365f, 0.03811259f, 0.00353466f, -0.03467207f, 0.00624281f, -0.04464020f, 0.02773539f, 
    -0.04769307f, 0.04078696f, -0.03497016f, 0.00430755f, -0.00252749f, -0.02676746f, -0.02387328f, -0.05554692f, 
    0.03966955f, 0.00377615f, 0.00097096f, -0.01556482f, -0.03680031f, -0.02667800f, -0.01560372f, -0.00033902f, 
    -0.02135220f, -0.00416834f, 0.01707394f, 0.01057651f, -0.01608417f, 0.01091624f, -0.01923439f, 0.02438524f, 
    -0.01682001f, -0.00473782f, -0.02466560f, -0.10399981f, -0.02549931f, -0.10974256f, -0.24561256f, -0.13767350f, 
    -0.10738800f, -0.10673430f, -0.06016342f, -0.06228152f, -0.13356015f, -0.16386120f, 0.11067111f, -0.15348159f, 
    -0.00178290f, 0.14993753f, -0.01743928f, 0.17030022f, 0.08693127f, 0.14739347f, 0.15288298f, 0.18978399f, 
    0.01464832f, -0.34993771f, -0.20579772f, -0.11539485f, -0.01912216f, 0.08157031f, 0.11218052f, 0.10604043f, 
    0.05127783f, -0.04339528f, -0.03186108f, 0.03974783f, -0.08238501f, -0.00458826f, 0.16199526f, 0.13053419f, 
    -0.12532321f, 0.06170828f, -0.13094021f, 0.05600308f, 0.29235166f, 0.13340957f, 0.12438037f, 0.30244645f, 
    -0.16471609f, -0.08837399f, -0.18829919f, -0.09134911f, 0.06010307f, 0.04726571f, 0.01724559f, 0.05241240f, 
    0.01895244f, 0.07516278f, -0.08650582f, -0.09773650f, -0.05085447f, -0.16505633f, -0.06845739f, -0.00290421f, 
    -0.04879357f, 0.05935242f, -0.07499964f, 0.08816488f, -0.13106221f, -0.15636720f, -0.20782216f, -0.23058425f, 
    -0.26348415f, -0.05016327f, 0.06293381f, -0.05202778f, -0.06232645f, -0.10775194f, -0.16436246f, -0.29870838f, 
    -0.09459333f, -0.16837621f, -0.09341876f, 0.04326897f, -0.01779344f, 0.36337176f, -0.02063100f, 0.17930384f, 
    -0.08843214f, 0.02813584f, 0.12000456f, 0.03080373f, 0.07878859f, -0.02451406f, 0.00623632f, 0.00874615f, 
    0.06958694f, 0.01287872f, 0.03464945f, 0.04121628f, -0.01151098f, -0.02662740f, 0.01512296f, 0.07768142f, 
    0.00376860f, 0.06286699f, 0.06672170f, -0.18444048f, 0.05447089f, 0.10205689f, 0.14376093f, 0.06101108f, 
    0.19091253f, 0.06538560f, 0.16776972f, 0.13063924f, 0.12758011f, 0.08298427f, 0.00002689f, 0.17175764f, 
    -0.25616252f, 0.05012032f, 0.09003587f, -0.05734203f, 0.08417891f, -0.12064932f, -0.13717622f, 0.10295848f, 
    -0.02157402f, 0.06792392f, -0.08160888f, -0.11102834f, -0.16319451f, 0.16393049f, 0.15070237f, 0.17094344f, 
    -0.01837448f, -0.07752207f, 0.01446433f, 0.01212301f, 0.14403483f, -0.07118857f, -0.15413381f, -0.10988345f, 
    0.12258255f, 0.15441038f, 0.15520155f, 0.05789908f, -0.01274267f, -0.00848990f, -0.15899582f, -0.00189584f, 
    0.04064821f, -0.03695057f, -0.01552398f, -0.02268448f, 0.12180991f, 0.32987446f, -0.01977808f, -0.06751117f, 
    -0.07727532f, -0.03163151f, -0.07397548f, 0.02257847f, 0.08901262f, 0.06288676f, -0.13721664f, -0.16953593f, 
    -0.01862251f, -0.06202488f, -0.03939904f, -0.22521344f, 0.03916593f, 0.04753859f, -0.08902588f, -0.07733763f, 
    -0.07348993f, -0.03006040f, -0.14761095f, -0.10319087f, -0.31553033f, -0.23760082f, -0.14216547f, -0.20118092f, 
    -0.05866572f, -0.16639453f, -0.17216100f, -0.15958065f, 0.24760616f, -0.04241405f, 0.14026833f, 0.23726438f, 
    -0.02963794f, -0.18769649f, 0.07508367f, -0.19398277f, 0.00097242f, -0.00337591f, -0.06696465f, 0.08861061f, 
    -0.01829820f, -0.03309832f, -0.00616343f, 0.07017049f, -0.20993602f, -0.02340311f, 0.08679559f, 0.02581209f, 
    0.08122246f, -0.01963391f, 0.04169330f, 0.08128541f, 0.11837319f, 0.21348220f, 0.19593100f, 0.07961821f, 
    -0.15575805f, -0.19335209f, -0.11261582f, -0.04863814f, 0.08109750f, 0.08435523f, -0.05684181f, -0.13913028f, 
    -0.11085058f, -0.18490027f, -0.01822478f, 0.12882558f, -0.13423759f, 0.00277275f, 0.03489932f, 0.04274023f, 
    -0.13884695f, -0.10629971f, -0.09439927f, -0.01080468f, -0.14837055f, 0.00707351f, -0.07155465f, -0.07230344f, 
    -0.09375396f, 0.10489501f, -0.13814725f, 0.05657641f, 0.02724138f, 0.04873974f, 0.26643920f, 0.00479198f, 
    0.06655850f, 0.09276535f, 0.02642867f, 0.28395954f, 0.03707249f, 0.06347099f, -0.09095866f, -0.06406754f, 
    0.13221362f, -0.04061093f, 0.04931658f, 0.09654652f, 0.10343719f, 0.24830106f, -0.10953987f, 0.10533699f, 
    0.17862594f, -0.22233765f, 0.04484690f, 0.13228549f, 0.11782061f, 0.10584753f, -0.03238012f, 0.01655020f, 
    -0.00374491f, 0.02552224f, 0.07653799f, -0.06155996f, 0.13961761f, 0.03101292f, 0.04569232f, 0.38857529f, 
    0.08725938f, 0.11848942f, 0.16175757f, 0.06639233f, 0.02139894f, 0.14689058f, -0.00627016f, 0.13637842f, 
    -0.22720726f, -0.18491349f, 0.21105544f, -0.13188699f, -0.08971265f, -0.03784963f, -0.01976342f, -0.06081893f, 
    0.19768761f, 0.10138725f, -0.01208358f, 0.10133837f, 0.07659084f, -0.14827400f, -0.29331243f, -0.19087863f, 
    0.01527709f, -0.03532715f, -0.00086707f, 0.18962638f, 0.12592836f, 0.05852917f, 0.12678641f, 0.16447917f, 
    -0.27557933f, -0.05387579f, -0.13724285f, 0.06337271f, -0.00317847f, -0.08551755f, -0.05547590f, -0.00218068f, 
    -0.10305231f, 0.03485680f, -0.01393106f, 0.04376358f, -0.02625551f, 0.12441337f, -0.00308674f, 0.19714127f, 
    0.03053453f, 0.08897347f, 0.01898052f, -0.10706060f, 0.05943026f, -0.01528904f, 0.06306172f, 0.06877667f, 
    -0.17582116f, -0.08306573f, -0.10690945f, 0.14736092f, 0.17247698f, 0.12816754f, 0.08079934f, -0.12365940f, 
    0.10854474f, -0.10034230f, -0.01685961f, 0.11713742f, -0.12300891f, 0.10989377f, 0.00134269f, 0.20658536f, 
    0.11624081f, -0.00787542f, 0.08653183f, 0.06749115f, -0.06392064f, -0.06912709f, -0.02077210f, -0.06204249f, 
    0.06174406f, -0.04859431f, -0.11087223f, 0.26914471f, -0.02361521f, 0.14659968f, 0.10410390f, 0.23373532f, 
    0.00641423f, 0.17181122f, 0.19314045f, 0.06106606f, 0.18574876f, -0.07153875f, 0.21965788f, -0.16495728f, 
    -0.11527421f, -0.10784452f, 0.00941951f, 0.04580171f, 0.02768613f, 0.10866910f, -0.13883395f, -0.02957702f, 
    0.05734663f, -0.00393120f, 0.12577716f, -0.03480056f, -0.14835247f, -0.06556858f, -0.00788465f, -0.02122027f, 
    -0.05418047f, 0.01950364f, -0.00676625f, 0.07416451f, -0.30204308f, 0.10878262f, 0.09400314f, -0.11178526f, 
    0.00065890f, -0.20326957f, -0.10586622f, -0.12706232f, -0.10366406f, -0.02862332f, -0.12672877f, -0.08583043f, 
    0.10142371f, 0.12495816f, -0.21351218f, 0.08982659f, 0.20473139f, 0.08234744f, 0.11353199f, 0.16263472f, 
    0.03074791f, 0.00765913f, -0.00782523f, -0.04001556f, 0.01591044f, -0.12009657f, 0.08049949f, -0.12804680f, 
    0.08323701f, -0.08065500f, -0.19912371f, -0.31360802f, 0.02815927f, 0.05530433f, -0.06824610f, 0.09602927f, 
    0.18162084f, -0.10577799f, 0.34291419f, -0.09102250f, 0.12344638f, 0.02826536f, 0.05273427f, -0.01800094f, 
    -0.04151245f, 0.04050657f, -0.01006347f, 0.10817981f, -0.01705595f, 0.21312165f, -0.10691024f, 0.19360816f, 
    0.11600207f, -0.05728705f, 0.02126275f, 0.03345572f, 0.06748186f, 0.10580622f, -0.00704430f, 0.03225410f, 
    -0.11898044f, 0.00803435f, -0.04607513f, 0.07451171f, -0.01297430f, -0.13228171f, -0.06542159f, 0.02386431f, 
    0.01813487f, 0.04912585f, -0.03010484f, 0.10962244f, 0.14057580f, 0.23236877f, 0.00368097f, -0.16817020f, 
    0.16353342f, -0.04478054f, -0.02524527f, 0.13268973f, -0.03390118f, -0.04237033f, -0.03391792f, 0.03307687f, 
    0.11919260f, 0.06873613f, -0.05973375f, 0.15073453f, 0.09244171f, 0.05769009f, 0.16592366f, -0.05568125f, 
    -0.03443826f, -0.12605079f, 0.10191656f, 0.09044372f, 0.12491936f, 0.03220376f, -0.09095032f, -0.05695052f, 
    -0.05143207f, 0.19861825f, -0.00689746f, 0.13830672f, 0.00166082f, -0.01936893f, 0.09694995f, -0.01082011f, 
    -0.30812061f, 0.00341090f, 0.16024609f, -0.05548466f, -0.19292736f, 0.08831372f, -0.07295485f, -0.00952381f, 
    0.10164922f, -0.01770675f, 0.01313792f, 0.11354507f, 0.36084929f, 0.10535938f, 0.06808592f, -0.12792918f, 
    0.20844761f, -0.04769819f, 0.11104856f, 0.12499673f, -0.04721938f, -0.08653538f, 0.01800870f, 0.13246989f, 
    -0.04486066f, 0.13809457f, 0.13158748f, -0.01613854f, 0.01490789f, -0.05157643f, 0.15077925f, 0.14963152f, 
    0.03657946f, -0.03318339f, 0.07821591f, 0.07897916f, -0.06311274f, -0.11553725f, 0.15970929f, 0.11696249f, 
    -0.10617631f, -0.06472788f, 0.14832808f, -0.20720187f, 0.00498812f, 0.09393644f, 0.02737726f, -0.03166602f, 
    0.10347655f, 0.12478031f, 0.04964693f, 0.07043823f, -0.07026066f, -0.03233980f, 0.04370370f, 0.10185105f, 
    -0.00236966f, 0.00465773f, 0.07344359f, -0.03060019f, -0.45203516f, -0.06092807f, -0.05411737f, 0.06175007f, 
    0.03905743f, 0.04192115f, -0.16382647f, -0.09550674f, -0.06882429f, -0.05446901f, 0.13305975f, -0.01182071f, 
    -0.06082381f, 0.17033325f, -0.17231944f, 0.07080595f, 0.02445249f, -0.14434303f, -0.02330932f, -0.06494861f, 
    0.00767944f, 0.02295852f, 0.01235904f, -0.03662705f, -0.06188261f, -0.19030032f, -0.01641468f, -0.21913517f, 
    -0.16060606f, 0.18841331f, -0.15831645f, -0.08641597f, 0.21142551f, 0.09122273f, -0.07841884f, 0.05773927f, 
    0.05074927f, -0.06749407f, -0.18121871f, -0.06015881f, 0.13243945f, 0.09482393f, -0.03312159f, 0.21034414f, 
    -0.05620683f, 0.01812473f, -0.07452446f, -0.00816041f, -0.37923762f, -0.02088011f, 0.23568821f, -0.10266422f, 
    0.06034210f, 0.00455764f, -0.03908616f, 0.01866790f, 0.08057006f, -0.09578630f, 0.03963119f, -0.02197720f, 
    0.13239329f, 0.20897843f, -0.04405677f, -0.10898707f, 0.10377964f, -0.15553336f, 0.15109380f, 0.01349608f, 
    0.00152666f, -0.01274694f, -0.09689630f, -0.06651977f, 0.05265392f, -0.06205468f, 0.17714779f, -0.17293650f, 
    0.05514056f, 0.01029902f, 0.04795631f, -0.06860398f, 0.11457649f, 0.02251059f, -0.09265611f, -0.01776048f, 
    0.01884523f, 0.13411219f, -0.10480826f, 0.16457675f, -0.02273192f, 0.08022458f, -0.10214294f, 0.04004949f, 
    0.07078835f, -0.10623965f, -0.06162398f, -0.01059191f, -0.05178782f, 0.06054929f, -0.09821498f, -0.09681886f, 
    -0.03570728f, 0.08156065f, 0.08151596f, -0.05877672f, 0.06197291f, 0.10269766f, -0.03736771f, 0.13535340f, 
    0.16512989f, 0.25827247f, -0.11371803f, 0.08531698f, 0.10398006f, 0.10883628f, -0.07454449f, -0.00225745f, 
    -0.05540228f, -0.00591217f, -0.03374759f, -0.01040776f, 0.50582653f, -0.01177419f, 0.25420332f, 0.02883330f, 
    0.03716334f, 0.08251281f, -0.12877265f, 0.13513866f, 0.05627380f, -0.14749560f, -0.09112117f, 0.01637693f, 
    0.34164807f, -0.24917771f, -0.09850068f, -0.02401676f, 0.16141738f, -0.04899633f, 0.13280253f, 0.02428195f, 
    0.05363797f, 0.03081296f, 0.01298605f, 0.14013442f, -0.03259128f, 0.05021987f, 0.13210520f, 0.17781146f, 
    0.04297967f, -0.02934352f, 0.06637970f, 0.09267191f, -0.10224309f, -0.00870196f, -0.00122226f, -0.00175850f, 
    0.10927215f, -0.10034335f, -0.10278202f, -0.08115089f, 0.19121642f, 0.04278178f, 0.10354882f, 0.12079308f, 
    -0.02019233f, -0.08770882f, 0.00494013f, 0.03912582f, 0.14769749f, -0.00554393f, -0.07948990f, 0.06376599f, 
    0.03869414f, -0.00073597f, 0.03996114f, 0.07438575f, 0.02972988f, 0.07197134f, -0.03023585f, 0.15314147f, 
    0.19855963f, 0.14387539f, -0.38619643f, 0.10766265f, 0.10833768f, 0.03702691f, 0.03483827f, -0.16754399f, 
    0.00785808f, 0.04463612f, -0.31819233f, 0.06307130f, -0.32318780f, 0.24726933f, -0.08287927f, 0.40509507f, 
    -0.06787255f, 0.03075134f, -0.15199417f, 0.06127074f, 0.02429727f, -0.08661436f, 0.02171104f, 0.07124453f, 
    0.01478679f, 0.15713246f, -0.18649392f, -0.16404283f, -0.02446341f, -0.00718773f, -0.00272451f, -0.02868140f, 
    0.08400542f, 0.09745169f, 0.06962995f, 0.05964756f, -0.13926886f, 0.02855221f, 0.03268538f, 0.05520071f, 
    0.03414767f, -0.02044504f, -0.00642499f, -0.05939791f, -0.10146706f, -0.13049774f, -0.03974829f, -0.04944849f, 
    0.18956143f, 0.01611228f, -0.24637012f, -0.07489768f, 0.09959232f, 0.04761514f, 0.10976687f, 0.04545229f, 
    -0.02340130f, 0.08426985f, -0.09189302f, -0.09722533f, -0.19672756f, 0.18071596f, -0.20122874f, 0.11393581f, 
    -0.01246317f, 0.07541330f, 0.05806122f, 0.00774425f, -0.02757041f, -0.12604532f, 0.06677521f, -0.07895368f, 
    -0.12834619f, 0.19178754f, -0.25167668f, 0.18412842f, 0.12855344f, 0.08856664f, 0.03486962f, -0.15664020f, 
    0.15454414f, 0.04393028f, 0.08200575f, 0.09540958f, 0.03011068f, -0.01930650f, -0.07723642f, -0.06522743f, 
    0.10514628f, -0.01904165f, 0.01020733f, 0.03402470f, 0.08813859f, 0.05320129f, 0.03219344f, 0.00897499f, 
    -0.14802943f, 0.03214123f, 0.03994330f, -0.14584954f, -0.10940526f, -0.07263807f, -0.03469002f, 0.00423183f, 
    -0.05442501f, 0.03214478f, -0.08435552f, 0.00736118f, 0.11412316f, 0.39670283f, -0.34851009f, 0.23648939f, 
    0.09679100f, -0.03242379f, 0.21753004f, -0.10196519f, -0.00274228f, 0.03681283f, 0.04372997f, 0.02893872f, 
    0.25269637f, -0.05330944f, -0.00894411f, 0.20665824f, -0.02180678f, 0.08093850f, 0.03887128f, -0.05257524f, 
    -0.07416000f, -0.09045349f, 0.02835269f, 0.08361318f, 0.03129016f, -0.13083048f, 0.10285603f, -0.00625651f, 
    0.06275279f, 0.04675087f, -0.02396251f, -0.11875471f, 0.01174004f, 0.04735619f, -0.03213979f, 0.10495401f, 
    -0.23305376f, 0.03720747f, 0.12865491f, 0.04637653f, -0.07107875f, -0.04887456f, -0.13392660f, -0.04984980f, 
    0.14501040f, 0.13139743f, -0.01668935f, 0.08184540f, 0.31008816f, 0.09614243f, -0.01930991f, 0.09926723f, 
    0.24565348f, 0.02632318f, 0.23231125f, -0.04089633f, 0.03795195f, 0.04784908f, 0.04416515f, 0.03166793f, 
    0.08009687f, 0.35610688f, -0.10356055f, 0.02229152f, -0.02415314f, -0.00481532f, 0.04884635f, -0.04679507f, 
    0.10919414f, 0.07857949f, -0.03973259f, 0.00367552f, -0.25828391f, 0.29426122f, -0.05986336f, 0.20489717f, 
    -0.10426927f, 0.02048779f, 0.06684148f, -0.08318890f, -0.02512994f, 0.02968577f, 0.00809059f, 0.12613568f, 
    -0.19164938f, -0.12184907f, 0.02477549f, 0.22526178f, -0.02556777f, -0.08014819f, -0.05031593f, -0.09163620f, 
    -0.05671130f, 0.08022398f, -0.07604574f, 0.09685879f, -0.14775625f, -0.03606442f, 0.02306080f, 0.05610216f, 
    -0.24518123f, -0.05329847f, -0.06634951f, -0.20334440f, -0.09481268f, -0.07212892f, -0.05945994f, -0.09324469f, 
    0.13152328f, -0.34883344f, 0.18417139f, 0.08463024f, -0.01143296f, -0.00312083f, -0.05740563f, -0.04037798f, 
    -0.03024289f, 0.01034541f, 0.06468467f, -0.00439462f, -0.04734373f, -0.09865285f, 0.30615392f, 0.35004348f, 
    0.13422886f, 0.00544095f, 0.05157271f, 0.01310503f, -0.12667318f, -0.00870177f, -0.05571142f, 0.03804789f, 
    -0.18144275f, -0.11709370f, -0.10382127f, 0.15603937f, 0.09150775f, 0.10287494f, -0.02903678f, 0.09103175f, 
    0.07338738f, 0.08277225f, -0.08783603f, 0.11440431f, -0.13414983f, 0.23383777f, 0.24861185f, -0.05452634f, 
    -0.16213788f, -0.02268756f, -0.11413657f, -0.02189267f, 0.03283231f, 0.00121757f, 0.03220820f, 0.08266418f, 
    0.05427803f, 0.10613803f, -0.16887091f, 0.36079246f, 0.02578347f, -0.02516373f, -0.05981642f, -0.01842055f, 
    -0.04256391f, -0.00147606f, 0.02486766f, -0.12687410f, 0.24482192f, 0.07151708f, -0.00768429f, -0.22473694f, 
    -0.00210889f, 0.01826403f, 0.13472953f, 0.00682990f, -0.09064286f, 0.14286238f, -0.00423324f, 0.07683127f, 
    0.07640436f, -0.14619863f, -0.11439243f, -0.07340451f, 0.08614939f, 0.12043995f, -0.09160853f, -0.05871551f, 
    -0.04734702f, 0.02836037f, -0.06513370f, 0.13243963f, 0.25944623f, -0.02010074f, 0.01922530f, 0.42087165f, 
    -0.10944722f, 0.12798996f, -0.03545980f, 0.05388258f, 0.01740046f, 0.06617554f, -0.07299168f, 0.09554476f, 
    0.00599447f, 0.07528536f, 0.18432927f, -0.26315060f, 0.11998739f, 0.07311320f, 0.18319288f, 0.06143246f, 
    -0.09414483f, 0.03880325f, 0.07648946f, -0.04643840f, 0.31299815f, 0.24682346f, -0.23670532f, -0.44781598f, 
    0.10543388f, 0.04538325f, 0.01575387f, 0.12819561f, -0.03850904f, 0.04650761f, -0.02772758f, 0.06448798f, 
    0.06659000f, 0.02385496f, 0.05686554f, 0.12234619f, 0.07285899f, 0.08669171f, 0.11024085f, 0.01010401f, 
    -0.00772543f, 0.15840074f, -0.05000540f, 0.07958352f, -0.23084100f, -0.02144175f, -0.05543903f, 0.04315083f, 
    0.10890383f, 0.11828815f, 0.04954443f, -0.07435019f, -0.08003048f, -0.07736121f, 0.05077238f, -0.07766502f, 
    0.07387816f, -0.10684505f, -0.29316902f, -0.05783198f, -0.00383889f, 0.00168617f, -0.05880906f, -0.17169128f, 
    0.00774329f, 0.04661419f, -0.08571181f, -0.10320830f, 0.18392278f, 0.06551305f, 0.00504580f, 0.14636986f, 
    0.02861919f, 0.04364907f, 0.08210852f, -0.03824922f, -0.10688876f, 0.12134108f, 0.04350363f, 0.09746368f, 
    0.04435110f, 0.20320794f, -0.14175363f, 0.02415910f, 0.04449856f, 0.03422423f, -0.01871479f, -0.01521238f, 
    0.14406270f, -0.04135247f, -0.03273816f, -0.07028544f, 0.09883889f, -0.01142343f, 0.54783994f, -0.14308068f, 
    -0.09800228f, 0.01474220f, -0.12833254f, 0.02653912f, -0.08879370f, -0.07037761f, 0.16942558f, 0.03407128f, 
    -0.07675728f, 0.03190834f, -0.04120994f, -0.11316790f, -0.03109896f, 0.02671944f, 0.00979754f, 0.06073904f, 
    -0.07892233f, 0.07204581f, -0.08804201f, -0.00443067f, -0.11503652f, -0.03107539f, 0.09841752f, -0.11860705f, 
    0.12386393f, 0.20480490f, -0.10304140f, 0.03152120f, 0.02396189f, 0.04324461f, 0.08084131f, 0.08393328f, 
    0.05622892f, -0.04253246f, 0.04066511f, -0.10322052f, -0.02955431f, -0.12502916f, -0.02338874f, 0.01947825f, 
    0.11115131f, -0.01634761f, 0.08390922f, -0.13398765f, -0.12032917f, -0.20665105f, 0.04532025f, 0.08144040f, 
    0.06498555f, -0.18179825f, -0.02698887f, -0.06901415f, 0.13169655f, 0.04470285f, 0.13609266f, 0.30467132f, 
    -0.04378469f, -0.17894322f, -0.10621191f, -0.04765591f, 0.08969728f, -0.09179199f, 0.04713788f, 0.10094750f, 
    -0.05833056f, 0.13951281f, -0.02853549f, -0.04490100f, 0.06460088f, -0.03810780f, 0.01093623f, 0.02856013f, 
    0.01210056f, 0.07307877f, 0.00056562f, -0.03618433f, 0.02150768f, -0.13126349f, -0.06408778f, -0.09750530f, 
    -0.04243983f, -0.02356751f, -0.03810309f, -0.02849405f, 0.01794752f, 0.19441514f, -0.00587707f, 0.00808911f, 
    -0.02929034f, -0.03541299f, 0.15268524f, 0.00579363f, -0.37794927f, 0.29085752f, -0.12980665f, 0.26410517f, 
    0.07422110f, 0.01700987f, -0.04211742f, 0.12951544f, -0.00267437f, 0.07687289f, -0.10780614f, 0.05184494f, 
    0.11320972f, -0.13019937f, -0.10795885f, -0.20646733f, -0.01220904f, -0.08353794f, -0.02272001f, 0.05074994f, 
    -0.05109967f, 0.01888965f, 0.12575477f, 0.09315817f, 0.02952293f, 0.06265187f, 0.16846593f, 0.20529658f, 
    -0.01067499f, 0.06136501f, 0.08677568f, -0.12859851f, 0.07455153f, -0.06412490f, -0.03346511f, -0.04578976f, 
    0.03427115f, -0.04643140f, -0.23334616f, -0.00705995f, -0.16046412f, 0.11750067f, -0.03607858f, 0.03668546f, 
    -0.03162732f, -0.03172141f, -0.03043680f, -0.02273038f, -0.22316101f, 0.11705922f, -0.10332040f, -0.04531825f, 
    0.08237784f, 0.11573122f, -0.03581474f, 0.11026848f, -0.14727017f, -0.06040047f, 0.15081064f, 0.12271272f, 
    -0.46706620f, 0.35488272f, 0.11326384f, -0.03359403f, 0.00157153f, 0.11504631f, -0.00063692f, -0.04904899f, 
    -0.07499570f, 0.01170120f, 0.16163334f, 0.11386123f, 0.10648528f, -0.07441893f, 0.10864394f, -0.17241938f, 
    0.01496166f, -0.03938127f, -0.07142223f, 0.09681327f, 0.02440794f, 0.03164424f, 0.08394306f, -0.15088478f, 
    -0.11751515f, 0.17986527f, -0.14527737f, -0.02777514f, -0.03643681f, 0.13335955f, -0.07726806f, 0.03085928f, 
    -0.07847679f, 0.05226319f, 0.12343121f, -0.02648457f, 0.08964033f, -0.01473786f, -0.09051057f, -0.08507850f, 
    0.21294995f, 0.08967902f, 0.01025291f, 0.11144558f, 0.19013330f, -0.01122642f, 0.04388593f, -0.04095756f, 
    -0.07446822f, 0.36760417f, -0.08774856f, 0.07730593f, -0.05155038f, 0.02724137f, 0.04465712f, 0.04419050f, 
    -0.12139459f, 0.03586422f, 0.10442111f, -0.01426836f, -0.17573701f, 0.26283228f, -0.12462283f, 0.03922803f, 
    -0.00739871f, -0.10209496f, 0.15283494f, -0.05665113f, 0.24156168f, 0.21248831f, -0.06298808f, 0.03109784f, 
    0.23701274f, -0.13379374f, 0.11887039f, 0.09845372f, 0.20156865f, 0.10084989f, 0.17368355f, 0.00547190f, 
    -0.02895215f, -0.14432465f, 0.06627455f, 0.01580173f, 0.01873919f, -0.19084930f, -0.03156815f, 0.22973408f, 
    0.10625390f, 0.16175584f, 0.19978975f, 0.02264398f, 0.08192352f, -0.01527746f, -0.19526216f, 0.01718935f, 
    -0.13503627f, 0.02129307f, 0.01702333f, -0.14670025f, 0.15567368f, 0.11621446f, -0.21039517f, -0.12429781f, 
    -0.01175598f, -0.10681800f, 0.01972285f, 0.00055746f, -0.11978446f, 0.03821253f, -0.05713929f, 0.10048012f, 
    -0.07166248f, 0.03171209f, -0.09876526f, 0.13429679f, 0.22765617f, -0.02439640f, 0.05453453f, -0.09335615f, 
    0.31588513f, 0.05104252f, -0.04822749f, 0.06992383f, 0.08249833f, -0.03781668f, 0.09166646f, 0.12812282f, 
    0.00124210f, 0.04849442f, -0.01436315f, -0.01834146f, 0.13473836f, 0.18705490f, 0.15711269f, 0.07296224f, 
    0.06847044f, -0.06370184f, 0.05093807f, 0.02337908f, -0.03062513f, 0.12995787f, -0.04742346f, 0.05056345f, 
    -0.48673561f, 0.24677432f, -0.24279928f, 0.06159697f, 0.07684965f, 0.08849707f, -0.12054338f, -0.03423570f, 
    0.01724801f, 0.00393342f, -0.09120186f, 0.11267271f, 0.19455357f, -0.27466512f, 0.13160881f, 0.09276408f, 
    0.06535438f, 0.07869238f, -0.01096882f, -0.04029700f, 0.21264510f, 0.14013773f, 0.14159295f, 0.04590007f, 
    -0.24147706f, 0.00503194f, -0.07145452f, -0.02000931f, -0.04650060f, -0.03832934f, -0.08719176f, 0.25666422f, 
    -0.00276858f, -0.05401128f, -0.08000829f, -0.07571130f, 0.03196730f, -0.06600760f, -0.03205276f, 0.37266177f, 
    0.00454185f, -0.03986847f, 0.06022035f, 0.08398379f, -0.01975649f, 0.00222793f, -0.04932946f, -0.00161154f, 
    -0.06898472f, 0.00831635f, 0.01238251f, 0.06954119f, 0.08353235f, -0.02038999f, -0.03602454f, -0.04880090f, 
    -0.08348667f, -0.07048497f, -0.01169478f, -0.01563229f, -0.12773915f, -0.12981518f, 0.06562954f, -0.02338625f, 
    0.13046588f, -0.07559396f, -0.02911659f, 0.09423218f, 0.10280922f, -0.02409212f, -0.08372576f, -0.04849116f, 
    0.24313438f, 0.06261276f, -0.12836699f, -0.03009265f, 0.12028179f, 0.00433999f, 0.10886971f, 0.12593523f, 
    0.01945807f, -0.01768022f, -0.05464194f, 0.14855386f, 0.22622462f, 0.11867705f, 0.14831349f, 0.02196653f, 
    0.10743340f, -0.02626408f, -0.11264595f, 0.07693493f, 0.05612437f, -0.00342243f, 0.13180643f, -0.00911416f, 
    -0.10860883f, -0.06516302f, -0.04275498f, 0.02659766f, -0.01163679f, 0.05500484f, 0.01824463f, 0.12466807f, 
    0.14271934f, 0.04856759f, 0.13903293f, 0.11067731f, 0.16803069f, -0.02937155f, -0.12920669f, 0.08244461f, 
    0.05576587f, 0.10207701f, 0.07848386f, 0.07407849f, -0.06344733f, 0.00731290f, -0.10000220f, -0.11998408f, 
    -0.07581472f, 0.31262347f, 0.18616144f, -0.06030541f, 0.03686164f, 0.02020740f, -0.14160950f, 0.06820960f, 
    0.03018346f, 0.10361221f, -0.16200717f, -0.06477472f, -0.05439588f, 0.05571443f, -0.01514470f, 0.08175057f, 
    0.02471332f, 0.02074730f, 0.02747898f, 0.03321701f, -0.05983198f, 0.02425273f, -0.00687270f, -0.08458620f, 
    -0.04346837f, 0.02006315f, -0.08282632f, 0.18644650f, -0.05272319f, -0.14255834f, 0.00226105f, -0.07042363f, 
    0.10092532f, 0.05451869f, 0.09520170f, 0.20875056f, 0.00436561f, 0.01976221f, 0.12989081f, -0.26879448f, 
    -0.14364685f, 0.03661333f, -0.02292597f, -0.04989083f, 0.14398353f, 0.06375723f, 0.17327902f, 0.22930144f, 
    -0.00429832f, -0.11239371f, -0.04730324f, -0.02794696f, 0.00773080f, 0.08355522f, 0.00709073f, 0.11327132f, 
    -0.02068553f, 0.01172930f, -0.06026412f, 0.07520679f, -0.09235448f, -0.23870035f, -0.18238896f, 0.22251821f, 
    0.12724346f, 0.05063177f, -0.03509865f, 0.06793926f, -0.06723747f, -0.07118735f, 0.18106765f, -0.02597569f, 
    -0.03732216f, 0.01226713f, 0.19352332f, -0.09351604f, -0.00897185f, 0.04510191f, -0.00808764f, -0.10292428f, 
    0.01850184f, -0.02594738f, 0.10508942f, 0.14678992f, 0.17576887f, -0.01710869f, 0.06338302f, -0.15983407f, 
    -0.03813749f, -0.06720281f, 0.11652059f, -0.02755567f, 0.04444111f, -0.01523582f, 0.01478200f, -0.05000338f, 
    0.10644026f, -0.06185827f, -0.01967296f, 0.08239646f, -0.00947894f, -0.00200827f, 0.06439791f, -0.06870584f, 
    0.16912979f, 0.01960590f, -0.05632709f, 0.23416491f, 0.08351006f, 0.21310841f, 0.33511543f, 0.08281449f, 
    0.11768213f, 0.09685550f, 0.04337324f, -0.03674560f, 0.03568904f, 0.03784153f, 0.10660598f, 0.02572050f, 
    0.13612074f, 0.02093350f, -0.25584170f, -0.05091562f, 0.05262384f, 0.16796143f, 0.01534644f, 0.08261443f, 
    0.03438819f, 0.24419884f, 0.07100473f, -0.00055621f, -0.06359541f, 0.21270673f, 0.18650013f, -0.04219200f, 
    0.01966015f, 0.03208475f, -0.03877893f, -0.09448722f, 0.01535788f, 0.02097634f, 0.22221041f, 0.26760754f, 
    -0.00497277f, -0.28940576f, 0.02478116f, -0.10479487f, 0.10834870f, 0.04287650f, 0.03571192f, -0.10328970f, 
    -0.01469298f, 0.19786569f, 0.05277590f, 0.19283916f, 0.19818047f, -0.13075808f, 0.06622531f, -0.01205143f, 
    0.04861367f, 0.06197649f, 0.13281120f, 0.04308132f, -0.03644193f, 0.05902452f, -0.15029329f, -0.00827823f, 
    -0.05014027f, -0.12124596f, 0.06718864f, -0.21962535f, -0.01744694f, -0.01121000f, -0.03252252f, -0.11231863f, 
    0.13647555f, 0.24531265f, 0.13523079f, 0.06634413f, 0.14361511f, 0.07560709f, -0.22661005f, -0.04642861f, 
    0.06435262f, -0.00759031f, 0.01702556f, -0.07669127f, 0.09103481f, 0.06993300f, -0.07883344f, 0.03952854f, 
    0.07356153f, -0.04556510f, -0.01260202f, -0.06519665f, 0.00685437f, -0.05933062f, 0.03220016f, 0.12145253f, 
    -0.01453514f, 0.09038789f, -0.17614949f, -0.00526643f, 0.12119552f, -0.07165121f, 0.08676127f, 0.07429752f, 
    0.07099118f, 0.04755677f, 0.14077649f, 0.05493460f, 0.01526275f, -0.01216892f, -0.05346988f, 0.03179990f, 
    0.16132750f, -0.21092540f, -0.03757632f, -0.14001589f, 0.10270977f, 0.07409009f, -0.28601977f, 0.03890332f, 
    -0.02042306f, -0.01074623f, 0.03732881f, -0.20500676f, 0.03821022f, -0.07199138f, -0.13977762f, 0.09180297f, 
    -0.09219158f, 0.07696382f, 0.08527597f, -0.06868114f, 0.16344374f, -0.05593484f, 0.09937243f, 0.07340856f, 
    -0.16119397f, 0.18639329f, -0.08985946f, -0.26434195f, -0.01572421f, 0.08656215f, 0.07572809f, 0.01813872f, 
    0.13977771f, -0.05358542f, 0.10499018f, 0.10233217f, 0.33469889f, 0.53390300f, 0.14382514f, -0.10793760f, 
    -0.00544554f, -0.20128272f, -0.11796226f, 0.05685136f, 0.07768440f, 0.01354307f, -0.01308600f, 0.04562214f, 
    -0.15066741f, -0.16914353f, 0.32485557f, 0.32083860f, 0.09562940f, -0.04138187f, 0.05810628f, -0.02200451f, 
    -0.03954070f, -0.11674459f, 0.01945882f, -0.12300220f, -0.50436568f, 0.12355424f, -0.01272734f, 0.31410068f, 
    -0.15980574f, 0.09546529f, 0.03964456f, 0.10332582f, 0.28285277f, -0.20857108f, -0.16965705f, 0.07091235f, 
    0.08503486f, 0.21858376f, 0.17606483f, 0.15764843f, -0.06917220f, 0.00443916f, -0.03340957f, -0.26315832f, 
    -0.01085906f, 0.01892276f, 0.08948316f, 0.12231696f, -0.03764484f, -0.04640506f, -0.01361627f, -0.20784071f, 
    -0.12024749f, 0.06145691f, 0.04431763f, 0.08166184f, -0.01449601f, 0.00639859f, -0.00970130f, -0.07099222f, 
    0.06029390f, -0.08002503f, 0.11760424f, 0.01337618f, -0.06896731f, -0.17641887f, -0.01935132f, -0.07696516f, 
    -0.04168609f, 0.00721535f, -0.00669162f, -0.06659060f, -0.00001019f, 0.27359828f, 0.21948546f, 0.25602710f, 
    -0.16281524f, -0.05100115f, -0.07688694f, 0.01968555f, -0.15266056f, -0.06063537f, 0.13331898f, 0.10446072f, 
    -0.18628247f, -0.07200216f, 0.02003615f, -0.02978455f, 0.08145998f, -0.07140197f, -0.05275351f, 0.25379696f, 
    0.08957884f, -0.09826760f, -0.12064071f, 0.04264389f, 0.00828260f, -0.23321532f, 0.16598772f, -0.21614315f, 
    0.03595567f, -0.00893071f, 0.04248282f, 0.05421307f, 0.04393482f, -0.03704648f, 0.16387141f, -0.00265747f, 
    -0.03209534f, 0.03384857f, 0.17500252f, 0.10262960f, 0.00155114f, 0.01519827f, 0.02717376f, 0.01565331f, 
    -0.08342192f, 0.02317100f, 0.06006810f, 0.06965857f, -0.09808470f, 0.04582788f, 0.05495735f, -0.12540670f, 
    0.07555164f, -0.06259584f, 0.07518070f, 0.07902502f, 0.12909813f, 0.07060727f, 0.08450563f, 0.04504576f, 
    -0.06837014f, 0.11256823f, 0.09816535f, -0.04283152f, 0.02957604f, -0.06870016f, 0.03172071f, -0.08267108f, 
    0.05854736f, -0.12525350f, 0.05937881f, -0.01658338f, 0.06510162f, -0.12279903f, 0.17753233f, -0.11011251f, 
    -0.01323787f, -0.08260809f, -0.02726290f, -0.11221421f, 0.07202640f, 0.12694053f, 0.02845318f, 0.20265175f, 
    0.34924504f, -0.28255901f, 0.28225285f, -0.21228331f, 0.10216644f, 0.06350540f, -0.03815483f, 0.03440246f, 
    -0.08969831f, 0.04234580f, 0.00865395f, -0.04916046f, -0.06726985f, 0.19930845f, 0.02418703f, 0.07519286f, 
    -0.01878837f, 0.00259124f, -0.03399356f, -0.06194661f, 0.00678323f, 0.00698453f, -0.01596146f, -0.08633488f, 
    -0.10495103f, 0.02581080f, -0.03558714f, 0.09288207f, 0.02970494f, 0.04537665f, 0.04589664f, 0.04284847f, 
    -0.00280981f, -0.09906157f, 0.08893252f, -0.05435245f, 0.31410724f, -0.23296282f, 0.28791887f, -0.23267110f, 
    0.18579312f, -0.01249052f, -0.06865285f, 0.12587066f, 0.08899420f, -0.02871409f, 0.01386708f, 0.03618245f, 
    -0.14723606f, 0.11735095f, -0.06305631f, -0.10708178f, 0.11953119f, 0.01002941f, -0.01461660f, 0.04555721f, 
    -0.01772606f, -0.03629482f, 0.00392135f, 0.00788563f, 0.02159193f, 0.10436732f, -0.18253228f, -0.04076694f, 
    0.00831112f, 0.15958109f, 0.00065627f, 0.11064380f, 0.03826666f, -0.01687651f, 0.03136543f, -0.08307444f, 
    -0.07874770f, -0.09720562f, -0.01620311f, -0.10534016f, 0.06613296f, 0.07653958f, 0.06067361f, 0.09508725f, 
    -0.14464054f, 0.00645208f, 0.02354987f, -0.00357735f, 0.00568274f, -0.04108749f, 0.04024702f, -0.13511908f, 
    -0.02111457f, 0.09778556f, -0.00223319f, 0.18094726f, 0.04417580f, -0.07428265f, 0.02869729f, 0.10715074f, 
    -0.16318220f, -0.25514492f, 0.10616862f, -0.03538270f, 0.05645659f, -0.06666193f, 0.01071830f, -0.01413059f, 
    0.04832963f, -0.00462844f, 0.13548766f, 0.06000884f, 0.31404513f, -0.13586402f, 0.14666390f, -0.08178748f, 
    0.08061707f, -0.13916810f, -0.02229592f, -0.08029439f, 0.16421475f, 0.08918229f, 0.02554160f, -0.09307314f, 
    0.13693283f, 0.12114684f, -0.08666819f, -0.13542031f, -0.03799180f, -0.02049149f, 0.05054112f, 0.09407690f, 
    0.05377815f, -0.04406348f, 0.16868295f, -0.01014098f, -0.16781819f, 0.06619332f, -0.09157389f, -0.06540493f, 
    0.21918903f, 0.05417338f, 0.03640880f, 0.12115903f, 0.10309653f, -0.06503196f, 0.10998782f, 0.02937282f, 
    -0.08459334f, 0.31262776f, -0.11658136f, -0.04863038f, 0.02537192f, -0.00794990f, -0.01247001f, 0.03579240f, 
    0.12614098f, 0.01883977f, 0.09730148f, 0.00650888f, 0.12748311f, -0.07880522f, -0.07570691f, -0.18367049f, 
    -0.14553715f, 0.03424538f, -0.04419563f, -0.04724828f, 0.17068683f, 0.07879857f, 0.02173382f, 0.11853452f, 
    0.16498686f, 0.08816464f, -0.05701713f, -0.25945529f, 0.03523355f, -0.01505534f, 0.01503553f, 0.02206130f, 
    -0.01469786f, 0.04190167f, 0.05482773f, -0.05639356f, -0.24282207f, -0.20866451f, -0.15896291f, -0.10605663f, 
    0.13811785f, 0.06221394f, 0.19870937f, 0.13717318f, 0.11414313f, -0.05679591f, -0.04703966f, -0.01683422f, 
    -0.04993992f, -0.11315838f, -0.02561493f, -0.27356088f, -0.07517849f, 0.01355578f, 0.21541834f, -0.01702529f, 
    0.04800251f, 0.03271608f, -0.08662444f, 0.00931360f, -0.10527375f, -0.02184140f, 0.04914432f, 0.07488680f, 
    -0.03484285f, 0.12127277f, -0.02337880f, 0.04707628f, 0.19695282f, 0.02189875f, 0.04138551f, -0.03930900f, 
    0.07165769f, 0.17802210f, 0.01442770f, 0.13155027f, 0.02174806f, -0.06389726f, 0.10545720f, 0.09464926f, 
    0.01414386f, -0.01787352f, 0.06075609f, -0.10209482f, -0.24826418f, 0.12101106f, -0.15029712f, -0.35335007f, 
    -0.01960267f, 0.02280866f, 0.08527965f, 0.03387733f, -0.07342882f, -0.00348946f, 0.09825499f, 0.03496709f, 
    0.11723600f, 0.03281025f, -0.24731833f, 0.14798599f, -0.08202408f, -0.06483714f, -0.15201315f, -0.06693502f, 
    0.18501315f, 0.04444671f, -0.01075939f, 0.09765437f, 0.44187835f, -0.15320732f, 0.32355982f, 0.19190347f, 
    0.10522912f, 0.01086161f, -0.01620136f, -0.20003723f, 0.13177100f, -0.04199351f, 0.08370418f, 0.00438846f, 
    0.18276133f, -0.11326598f, -0.04716944f, -0.10069136f, -0.05373237f, -0.07548662f, -0.08431037f, 0.04592853f, 
    0.07907014f, -0.00273295f, 0.08009873f, 0.06011518f, 0.34459010f, -0.00504642f, -0.02000419f, -0.12559873f, 
    0.03426395f, -0.06135093f, 0.00631440f, 0.15359975f, -0.06401397f, 0.08695517f, -0.02523952f, 0.15619436f, 
    0.03649100f, 0.09129409f, 0.04580628f, -0.19429241f, 0.12171792f, -0.04583245f, 0.07961903f, 0.19387101f, 
    -0.03529067f, -0.06018620f, -0.03050230f, 0.06466856f, -0.05405353f, -0.08577520f, -0.06891211f, -0.14697975f, 
    0.13194612f, -0.00673361f, 0.00873766f, 0.06598546f, 0.13053790f, -0.08170446f, -0.05438646f, 0.03347979f, 
    0.00527528f, -0.11377606f, -0.01981616f, -0.13065377f, 0.09371283f, 0.03270178f, 0.03154157f, -0.06744086f, 
    -0.00342665f, 0.10410396f, -0.04274237f, -0.01409148f, -0.35584819f, 0.15656711f, -0.41121548f, 0.24032120f, 
    0.12736909f, 0.02712531f, 0.16314031f, -0.00233500f, 0.07133220f, 0.03957038f, -0.23369940f, 0.00417203f, 
    -0.05238510f, -0.02536424f, 0.03361313f, 0.02827363f, 0.02371641f, -0.03752073f, -0.05116583f, 0.04241123f, 
    -0.05325013f, -0.01497734f, 0.02756493f, -0.00762536f, -0.02646978f, 0.02258529f, 0.02816314f, 0.00623106f, 
    -0.05680948f, 0.03115031f, -0.01744417f, -0.02592716f, -0.02197647f, -0.00692835f, -0.03050876f, 0.04016805f, 
    0.02463261f, -0.02606181f, -0.04705908f, -0.00835785f, -0.02125875f, 0.00336705f, 0.00634589f, -0.01609600f, 
    -0.03591186f, -0.01126950f, -0.01979157f, 0.01270479f, -0.01687630f, -0.04151671f, -0.05479544f, 0.00540020f, 
    -0.00458763f, -0.03747529f, 0.01025632f, -0.02340221f, -0.00412860f, -0.04593502f, -0.04448408f, 0.02136160f, 
    -0.00977017f, 0.04245635f, -0.01896524f, 0.03014166f, -0.03328900f, -0.01004685f, -0.03278091f, 0.04218056f, 
    -0.05334340f, -0.05443518f, 0.01813760f, -0.03884751f, -0.00645683f, 0.02064884f, -0.01149399f, 0.03033987f, 
    -0.02525157f, 0.01961984f, -0.02647578f, 0.00132349f, -0.00485398f, -0.01767290f, 0.04354741f, 0.01371900f, 
    -0.02219974f, 0.03162172f, -0.04466240f, -0.00747645f, 0.00509990f, -0.04982212f, 0.03799787f, -0.01518063f, 
    -0.01946131f, 0.00274700f, 0.00969521f, -0.03048890f, -0.02680674f, -0.05036370f, -0.03303619f, 0.03532812f, 
    -0.00696894f, -0.00323713f, -0.05445521f, 0.04265426f, -0.01542167f, 0.03726341f, 0.01486800f, -0.05150910f, 
    0.03589980f, -0.00289991f, -0.03431973f, 0.02223358f, 0.02612562f, 0.03038214f, -0.02171769f, 0.02057135f, 
    -0.00675998f, -0.00093857f, -0.05001339f, 0.02983832f, 0.03617597f, -0.01210599f, 0.02097820f, -0.04079837f, 
    0.01787973f, -0.04087596f, 0.01307734f, -0.01705128f, 0.00955552f, 0.03434839f, 0.00714947f, -0.00628593f, 
    -0.04663260f, -0.03747672f, -0.03609390f, 0.02598504f, -0.00370612f, 0.02952935f, 0.01768201f, -0.05137271f, 
    0.00091500f, -0.05060835f, 0.02846778f, -0.04701839f, -0.02138976f, 0.04222898f, -0.03265241f, 0.05401222f, 
    -0.02526491f, 0.01967019f, -0.03901083f, 0.03301859f, 0.03419496f, -0.04733845f, 0.03145754f, 0.00171314f, 
    0.00285219f, 0.03889306f, -0.00529299f, 0.00317660f, -0.03205360f, 0.04483275f, -0.01450397f, 0.03586763f, 
    -0.03070422f, 0.00034013f, -0.03467819f, -0.05069937f, -0.01209471f, 0.04615604f, 0.03838085f, 0.03290179f, 
    0.01368342f, 0.00460187f, -0.04725192f, -0.04019232f, 0.00446877f, -0.00804695f, -0.04469831f, -0.02578789f, 
    0.04612470f, 0.01790426f, 0.01373785f, -0.01345851f, -0.04044622f, 0.03325969f, 0.01725003f, -0.04101579f, 
    -0.04317282f, -0.02888726f, -0.04924000f, 0.01250173f, 0.04606541f, 0.00336546f, -0.03162609f, 0.01473966f, 
    -0.04753800f, 0.00350680f, -0.03560756f, -0.02574345f, -0.00838786f, -0.04393379f, 0.01903053f, -0.00209712f, 
    0.01488968f, 0.04367639f, 0.02269370f, -0.00441095f, -0.00244019f, 0.04364810f, -0.05023459f, 0.04300705f, 
    0.04546635f, -0.00183258f, 0.01579817f, 0.03701375f, 0.04028663f, -0.03507450f, -0.04806158f, 0.02933279f, 
    0.01397558f, -0.01284700f, -0.04861647f, -0.00850932f, -0.00855448f, -0.01638494f, -0.05100095f, -0.00523167f, 
    -0.00830637f, 0.03012736f, 0.02773600f, -0.02781123f, -0.03189424f, -0.01257358f, -0.00908080f, -0.05603010f, 
    -0.03979623f, -0.01607333f, 0.02922242f, -0.04743179f, -0.01791957f, -0.03649034f, -0.00055182f, 0.03713711f, 
    0.01537795f, -0.02104066f, -0.01777256f, 0.01725117f, 0.03592663f, -0.04346548f, 0.01088477f, -0.00619505f, 
    0.00448582f, 0.03967871f, -0.04557918f, 0.04299267f, -0.02038766f, -0.05398006f, -0.00992938f, 0.02116662f, 
    0.03122303f, -0.01188039f, -0.04157048f, -0.01310115f, -0.03756740f, -0.00822386f, 0.03844567f, -0.05075905f, 
    0.02640469f, 0.01559285f, -0.02477323f, -0.02247434f, -0.00001108f, -0.03537987f, 0.00323307f, -0.03805988f, 
    0.00379840f, -0.04856331f, -0.04987670f, -0.02840163f, -0.00896088f, -0.00039808f, -0.00679748f, 0.03720184f, 
    0.01238482f, -0.05535541f, -0.01091949f, 0.02261134f, -0.04177402f, 0.03284321f, -0.05086850f, -0.03373181f, 
    -0.05394454f, 0.00906119f, -0.04685063f, 0.03715092f, -0.00800415f, 0.03242919f, 0.02085154f, -0.01859901f, 
    0.04040596f, -0.04455163f, 0.02543770f, -0.04927122f, -0.03592828f, -0.00257504f, -0.02963299f, 0.04490435f, 
    -0.01310587f, -0.05588583f, -0.02190258f, -0.02911731f, 0.00960212f, 0.03621194f, 0.02131263f, 0.01388653f, 
    0.04160913f, -0.04618242f, -0.04424199f, -0.02405646f, -0.02204468f, 0.02600265f, -0.04656814f, 0.02798544f, 
    0.04107966f, -0.03418566f, 0.02457749f, -0.00611542f, -0.03791786f, 0.01854556f, -0.01404517f, -0.00983733f, 
    -0.01455053f, 0.01197324f, 0.01120241f, -0.02823037f, 0.01959681f, -0.01555141f, 0.02313613f, -0.01951399f, 
    -0.00387490f, -0.00354685f, -0.02326486f, 0.02441229f, -0.04363564f, 0.00904226f, 0.00685693f, -0.04175050f, 
    -0.02240875f, -0.03274288f, 0.01256413f, -0.01560113f, -0.03928250f, 0.03726098f, 0.01582412f, -0.05515338f, 
    -0.00659507f, -0.00546179f, -0.00141277f, 0.03632478f, -0.05399404f, -0.01354898f, 0.04104555f, -0.03333294f, 
    0.02828451f, 0.01231102f, -0.02181332f, -0.01084709f, 0.04284074f, 0.00395920f, 0.00816672f, 0.04335154f, 
    0.01141953f, 0.03524959f, 0.01260425f, 0.02068572f, 0.03733651f, -0.01968758f, 0.03862889f, 0.02374943f, 
    0.01915015f, 0.01318751f, -0.04175865f, 0.00722745f, -0.05083001f, 0.02709593f, -0.01401345f, 0.03628124f, 
    -0.04976105f, -0.00141478f, 0.03277364f, 0.00458868f, -0.03635298f, 0.02116748f, 0.02905378f, 0.00722924f, 
    0.01527681f, 0.01524564f, -0.04084496f, 0.00638774f, 0.00488286f, -0.04045016f, -0.04196253f, 0.02701557f, 
    0.12646307f, 0.07966289f, 0.16732354f, 0.02058307f, -0.00933270f, -0.08366713f, -0.05747001f, -0.01614989f, 
    0.07501682f, -0.11943226f, 0.14663507f, -0.00210674f, -0.01919133f, -0.01307547f, 0.04814959f, 0.00695210f, 
    -0.16694552f, -0.13797422f, -0.28812563f, -0.16068533f, -0.02123336f, -0.03007685f, -0.06083769f, 0.00160951f, 
    -0.01965141f, 0.13240945f, -0.16100129f, 0.07871117f, 0.14368974f, 0.07475968f, -0.12864509f, 0.09498305f, 
    -0.07814739f, 0.05838978f, 0.02426617f, 0.03399708f, 0.10457822f, -0.01068489f, 0.12005579f, -0.02148381f, 
    0.02603883f, 0.03419254f, -0.14064553f, 0.02986572f, -0.01253929f, 0.17547639f, 0.20061663f, -0.00266640f, 
    0.31509173f, 0.09619071f, 0.13659854f, 0.03660977f, -0.07859234f, -0.06840763f, -0.13558975f, -0.15870732f, 
    -0.10162994f, -0.04139076f, 0.04995692f, 0.12119872f, -0.11946478f, 0.06527141f, -0.05457565f, 0.10285242f, 
    -0.06908096f, 0.03933479f, 0.11238761f, -0.04761145f, -0.08991064f, 0.00348435f, 0.06477977f, 0.03240906f, 
    -0.03609879f, -0.04173492f, -0.10569289f, 0.08860528f, 0.46984965f, 0.06299252f, -0.15715158f, 0.05167114f, 
    0.26501021f, -0.02216673f, 0.13294019f, 0.00337046f, 0.20329927f, 0.11457913f, -0.04266974f, -0.02819494f, 
    -0.01506730f, 0.04453030f, 0.09012932f, 0.06994507f, -0.00999622f, 0.04978609f, -0.02659676f, 0.07682909f, 
    -0.07083003f, -0.07968505f, -0.03731850f, 0.02580478f, -0.12045530f, -0.09954403f, -0.07549699f, -0.30290106f, 
    0.03597659f, -0.01678584f, 0.00368207f, 0.07560955f, -0.06393699f, 0.01019155f, -0.00075200f, 0.04247505f, 
    -0.02597302f, -0.03656341f, 0.07654908f, -0.06884591f, -0.00665308f, 0.01775678f, -0.08204801f, 0.04932009f, 
    0.00702724f, -0.09480409f, 0.04763385f, 0.04200393f, 0.36080036f, 0.03678594f, 0.11802790f, 0.11835373f, 
    0.05630073f, -0.03351020f, 0.14092648f, 0.00586123f, 0.11148027f, -0.02722986f, 0.03736396f, -0.16613784f, 
    0.16796394f, -0.19398209f, -0.05354181f, -0.00289914f, -0.03178608f, -0.06413727f, 0.02055612f, 0.04847669f, 
    0.16982989f, 0.17742413f, -0.02774939f, 0.13184343f, 0.10290363f, 0.23094450f, 0.02112821f, 0.08180711f, 
    -0.01850966f, 0.04307118f, -0.00185757f, 0.01788306f, 0.10588931f, 0.18042579f, 0.04713576f, 0.17531112f, 
    -0.02418551f, -0.26530480f, 0.17821273f, -0.12782644f, -0.04704174f, -0.07870068f, -0.05386503f, -0.02101445f, 
    -0.06371593f, 0.10104858f, -0.08789117f, 0.20781848f, -0.09726813f, 0.03097129f, -0.02450611f, -0.03739669f, 
    -0.12879932f, -0.03329218f, 0.10991173f, -0.03468383f, 0.04655052f, 0.06629638f, 0.08154873f, 0.09987114f, 
    0.09721605f, -0.27822208f, 0.14631568f, -0.34419116f, -0.12700655f, -0.04898251f, -0.08849369f, 0.03989003f, 
    0.15753683f, 0.10597133f, 0.06493179f, 0.21564215f, -0.04099523f, -0.10346797f, 0.11236412f, 0.07852832f, 
    -0.01280267f, 0.00293661f, -0.01370885f, 0.11433305f, 0.16091704f, 0.12998833f, -0.13271378f, -0.00270370f, 
    -0.09215271f, 0.04706867f, -0.42225036f, -0.10966361f, -0.10680422f, -0.06531084f, -0.04124409f, -0.04195710f, 
    0.11294362f, -0.00969991f, -0.16750109f, 0.15143448f, -0.07761346f, 0.13262363f, 0.00495674f, -0.25635439f, 
    0.04466731f, 0.01946882f, -0.11323161f, 0.16349564f, -0.06608051f, 0.01861667f, -0.01015974f, 0.07954945f, 
    0.04998425f, -0.05419866f, 0.08124688f, -0.05929973f, -0.00099505f, -0.05739616f, 0.09804235f, 0.03895107f, 
    -0.01377982f, 0.10199472f, -0.02172608f, -0.01159354f, 0.06711382f, 0.01834427f, -0.06644928f, 0.01380595f, 
    0.01746926f, 0.18635970f, 0.18061960f, 0.01718169f, -0.06993757f, 0.14298917f, 0.14684822f, 0.04662903f, 
    -0.06826380f, -0.12211173f, -0.18290401f, -0.12609035f, 0.01209925f, 0.10598090f, 0.00661151f, -0.05875443f, 
    0.10305195f, 0.11953052f, -0.01046313f, 0.05655161f, 0.13818067f, -0.00727133f, -0.03590269f, 0.14645451f, 
    0.11950150f, 0.24655321f, 0.10139592f, 0.10282487f, -0.07297079f, 0.04057176f, 0.00409885f, -0.00094692f, 
    -0.07859290f, -0.28885552f, 0.16473393f, 0.06396522f, -0.07372086f, 0.01308421f, 0.07520074f, 0.01288360f, 
    0.09670501f, 0.02022956f, 0.10520611f, -0.02285206f, -0.02703950f, 0.02196562f, -0.01764264f, -0.10955293f, 
    0.13468608f, 0.20411177f, -0.01041308f, 0.09609425f, 0.05102395f, -0.07876345f, 0.07130207f, -0.02649570f, 
    0.05376854f, 0.04605329f, -0.00312016f, -0.02671626f, -0.02066127f, 0.12715279f, 0.17649083f, -0.03149894f, 
    0.08851523f, -0.00012514f, 0.15402278f, -0.08868547f, -0.06980095f, -0.04493435f, -0.09159487f, -0.24670438f, 
    0.05653426f, -0.08937607f, 0.04340234f, -0.16468306f, 0.01271374f, -0.13815559f, -0.00907229f, 0.00310154f, 
    0.03379985f, -0.16562921f, -0.22523895f, -0.11178622f, -0.09303065f, -0.13288152f, 0.01845894f, -0.09535295f, 
    0.01455555f, -0.10401873f, -0.05187424f, -0.03933081f, -0.11441226f, 0.20490891f, -0.04732989f, -0.02784905f, 
    0.04609834f, 0.13947761f, 0.07186875f, -0.04072803f, -0.01488569f, 0.15039073f, 0.08569583f, 0.02237371f, 
    -0.14383112f, 0.17644455f, 0.03120749f, 0.02949905f, 0.07060974f, -0.01829080f, -0.02059287f, 0.03718499f, 
    0.06081974f, -0.10185274f, 0.10861707f, 0.02264856f, 0.05664729f, 0.07723307f, 0.36353379f, -0.17479295f, 
    -0.01716481f, 0.00597072f, 0.00758651f, 0.04919314f, -0.12179238f, -0.00080959f, 0.10648157f, 0.01975363f, 
    0.01024997f, -0.04481793f, -0.00937666f, 0.02968777f, -0.05237336f, -0.09590668f, -0.05405630f, -0.04917623f, 
    0.20703691f, 0.04234425f, 0.10044803f, 0.09811792f, 0.15967093f, 0.03667375f, -0.15634604f, 0.10315823f, 
    0.03581451f, 0.11530586f, 0.00966078f, 0.02261063f, -0.13810141f, -0.08523718f, -0.06294322f, -0.07122590f, 
    -0.01304181f, 0.00845244f, -0.05650033f, -0.00311269f, 0.08039322f, 0.11165114f, 0.06293103f, 0.14428896f, 
    -0.01839756f, -0.00216412f, -0.07951965f, -0.03254326f, 0.04787988f, 0.10736848f, 0.00042887f, 0.09470184f, 
    -0.03573832f, 0.00559733f, -0.07870437f, -0.02695583f, -0.08384629f, -0.06745008f, -0.01454499f, -0.19981994f, 
    -0.09149891f, 0.17024858f, -0.10949499f, -0.01430825f, 0.00832629f, -0.00364397f, 0.14277813f, -0.00007475f, 
    0.24093474f, -0.04786180f, 0.08862676f, 0.04578478f, 0.00330234f, -0.10525674f, 0.07509136f, -0.13997300f, 
    -0.02495847f, -0.03149933f, 0.00899981f, 0.12785502f, -0.08766785f, 0.01983833f, -0.02434728f, 0.08377901f, 
    0.13444118f, 0.04680755f, 0.03871192f, 0.03670407f, -0.12145911f, -0.03296637f, -0.02163169f, -0.04456161f, 
    -0.03629488f, 0.05011747f, -0.12882152f, 0.04995715f, 0.27428696f, 0.13862514f, -0.15743262f, 0.12446340f, 
    0.00916211f, 0.08184742f, 0.19822440f, 0.06494518f, 0.09408738f, 0.04614013f, 0.12193379f, -0.02799621f, 
    0.05538230f, 0.22840708f, 0.20391053f, 0.09729121f, 0.10306248f, 0.12294647f, 0.01281819f, 0.06645110f, 
    -0.09211677f, -0.03173401f, -0.08772966f, -0.01003426f, 0.02834435f, -0.00427125f, 0.05896367f, -0.10011219f, 
    -0.03830200f, -0.03158215f, 0.07923947f, 0.13815393f, -0.12741216f, -0.02896727f, -0.01176366f, -0.02449178f, 
    -0.02521976f, 0.02442400f, 0.11591280f, -0.00215915f, 0.06380857f, -0.07075964f, -0.05169353f, 0.00872850f, 
    0.09089360f, 0.03275346f, 0.02504424f, 0.09401872f, 0.37002262f, 0.13296428f, 0.04980688f, 0.02338219f, 
    0.10447017f, 0.08490065f, 0.07797994f, -0.14024726f, 0.04741529f, -0.02780434f, -0.05707952f, -0.02634357f, 
    0.43430504f, -0.11426762f, -0.11910167f, 0.17246813f, -0.13375849f, -0.05745669f, -0.02129141f, 0.02402568f, 
    0.15578087f, 0.12071826f, -0.01909979f, 0.02905887f, 0.02912113f, -0.03420367f, -0.06331552f, -0.00031981f, 
    -0.03258822f, 0.03097745f, -0.05808065f, -0.05440538f, -0.14509343f, -0.07174511f, -0.04531908f, 0.14375120f, 
    0.22281162f, -0.22487713f, -0.04286589f, -0.03315371f, -0.04365627f, -0.03151515f, 0.02927552f, 0.08611740f, 
    -0.02270052f, -0.01889406f, -0.11440927f, 0.04026845f, 0.04885260f, 0.01869527f, 0.04066868f, 0.02975699f, 
    -0.05149540f, 0.02852079f, 0.01561143f, -0.07522821f, -0.07816959f, 0.01735035f, -0.04450860f, 0.07096929f, 
    -0.06354882f, -0.44063514f, -0.06744521f, -0.02528895f, -0.04081960f, -0.02200830f, -0.05599205f, -0.00068102f, 
    -0.03946205f, -0.00808769f, -0.03188236f, 0.10057101f, -0.00378019f, -0.01500268f, -0.05304870f, -0.03034592f, 
    -0.02719810f, 0.02755146f, 0.01857555f, 0.00594128f, -0.05271119f, -0.04365427f, 0.04372905f, -0.05258392f, 
    -0.15447433f, 0.17370486f, -0.21684514f, -0.03727886f, -0.19325204f, -0.13204883f, -0.07042354f, 0.07524502f, 
    0.03756660f, 0.01105148f, -0.12314655f, 0.05824340f, 0.17501748f, 0.28659812f, 0.13889514f, -0.03415754f, 
    -0.12648326f, -0.06736905f, -0.09932477f, 0.05427661f, -0.12779149f, -0.08155450f, 0.02505581f, -0.12274756f, 
    0.18270011f, 0.11434626f, -0.14849767f, 0.01269457f, -0.13962802f, 0.10486756f, 0.18365788f, 0.13669373f, 
    -0.05935929f, 0.09264473f, -0.08514781f, -0.04352915f, -0.03837764f, 0.05365710f, 0.01969439f, -0.01287319f, 
    -0.03640793f, 0.03564397f, 0.12224377f, 0.02251119f, 0.05065608f, 0.07873075f, -0.01462595f, 0.07033181f, 
    -0.10358583f, 0.04902252f, 0.23800705f, -0.10032022f, 0.17385392f, 0.08637556f, -0.01466845f, 0.01930792f, 
    0.12808359f, -0.05050908f, 0.08983847f, 0.14667800f, -0.04449051f, -0.10482673f, 0.10872544f, -0.15640070f, 
    0.00528250f, 0.10671487f, 0.00903954f, 0.05045020f, 0.07730305f, 0.03338592f, -0.07627135f, -0.02204566f, 
    0.04596484f, -0.18953760f, 0.21792060f, 0.15214148f, -0.02775955f, -0.05701666f, 0.01425191f, -0.01426496f, 
    -0.04243903f, -0.04655394f, 0.07451844f, -0.06911192f, -0.43146530f, 0.30505654f, 0.06372654f, 0.03438822f, 
    0.07394335f, 0.07282258f, 0.13911548f, 0.06920752f, 0.05759050f, -0.07863302f, 0.04303484f, 0.03251556f, 
    0.04415161f, -0.03856224f, -0.09265295f, -0.06609468f, -0.07556999f, 0.01313285f, 0.04405503f, -0.23273571f, 
    0.02105851f, 0.03754041f, 0.01183183f, -0.00511929f, 0.03081399f, 0.09993721f, 0.01987862f, -0.26056322f, 
    0.03544683f, 0.09614246f, 0.05650758f, -0.03885928f, 0.01028028f, -0.06461003f, 0.02741255f, -0.02863633f, 
    0.17635421f, 0.20068479f, 0.06246579f, 0.04769094f, 0.00017060f, -0.01485140f, 0.05784623f, -0.07788660f, 
    -0.01573364f, -0.01052127f, -0.02544292f, -0.03904038f, 0.06223289f, 0.15046197f, 0.05043945f, 0.07306241f, 
    -0.03942697f, 0.12511414f, -0.01792870f, -0.06614428f, -0.11225276f, 0.02472131f, 0.09041467f, -0.02789100f, 
    -0.16756259f, 0.00888603f, 0.14541957f, 0.05159535f, 0.01007065f, -0.03689719f, 0.07702131f, 0.05537510f, 
    0.08781924f, -0.05865688f, 0.01047539f, -0.05512792f, 0.13772176f, -0.11525308f, 0.31508437f, -0.01398600f, 
    -0.03785373f, -0.02457896f, 0.00866593f, -0.01343492f, -0.09278127f, -0.04062947f, -0.00060799f, 0.04810386f, 
    -0.06437152f, 0.07504155f, -0.07082435f, -0.02971025f, -0.09405094f, -0.09256209f, 0.00307605f, -0.04515073f, 
    0.00334520f, 0.04429607f, 0.01795325f, -0.04243227f, 0.03920360f, -0.05959669f, 0.08269410f, -0.09798923f, 
    0.15649439f, 0.29689321f, -0.01531663f, 0.09159356f, 0.04256574f, 0.03759562f, 0.09664316f, 0.01700075f, 
    -0.15598559f, -0.22930105f, 0.18186545f, -0.03478124f, -0.15633167f, -0.08758223f, -0.02267476f, 0.00604971f, 
    0.05935680f, -0.04062229f, 0.10733639f, -0.05413945f, 0.03879884f, -0.01700014f, 0.13037416f, 0.11524057f, 
    -0.00279935f, -0.10634629f, -0.08533414f, -0.04482963f, 0.13333295f, 0.10565767f, 0.14187036f, 0.29110357f, 
    -0.17068657f, -0.11477982f, -0.14465703f, -0.15289760f, -0.03974868f, 0.02889005f, 0.03602338f, 0.14566484f, 
    -0.05972532f, 0.10621867f, -0.02405759f, -0.16559288f, -0.01172201f, -0.13521561f, 0.11362623f, -0.04177671f, 
    -0.02159221f, 0.01502239f, 0.00997184f, 0.03522918f, -0.11365861f, -0.01925314f, -0.05477433f, -0.05243494f, 
    0.12362790f, 0.09639352f, 0.06627751f, -0.02803191f, -0.06722815f, 0.05119577f, -0.01331567f, -0.08518873f, 
    -0.00425202f, 0.03461215f, 0.08906130f, -0.10402003f, -0.40076476f, 0.10763671f, 0.11537170f, 0.24408446f, 
    -0.05465007f, 0.22198571f, -0.01069836f, 0.11907855f, 0.03351560f, 0.05374306f, 0.16621223f, 0.03469702f, 
    -0.08914968f, -0.04338478f, -0.00741750f, -0.12964368f, -0.03016297f, -0.10527134f, -0.00611733f, 0.10435098f, 
    0.10453159f, 0.12356130f, 0.06543976f, 0.02138288f, -0.04868644f, 0.09020090f, 0.09524111f, 0.28094018f, 
    -0.01926733f, 0.00342786f, 0.20755537f, 0.01027159f, -0.01064703f, -0.11198566f, -0.10254630f, -0.04013153f, 
    0.17073053f, 0.04473956f, -0.05711971f, -0.02736681f, -0.03482055f, 0.01124451f, 0.04631996f, -0.01725437f, 
    -0.06013579f, -0.04349623f, -0.03317095f, 0.02860745f, -0.45434448f, -0.07082599f, -0.00731250f, -0.02394223f, 
    -0.06932043f, 0.09164198f, -0.13092397f, 0.08106397f, -0.01781504f, 0.00468547f, 0.08586599f, 0.08706080f, 
    -0.24090701f, 0.10281724f, 0.12714392f, 0.10902946f, -0.03945161f, 0.07801564f, -0.11819860f, 0.04093579f, 
    0.00011310f, 0.00921454f, 0.07327294f, 0.11565450f, 0.09190741f, -0.01487792f, 0.13339858f, -0.19652314f, 
    0.04422326f, 0.04187283f, -0.08233296f, 0.15849569f, 0.01500496f, 0.06117579f, -0.02351283f, -0.15984993f, 
    -0.02476272f, 0.01364823f, -0.02336471f, -0.09374628f, 0.02206787f, 0.18430328f, 0.00495139f, 0.05573178f, 
    -0.02239759f, 0.09994465f, 0.10886727f, -0.02464077f, 0.04962563f, -0.08909225f, -0.03501532f, -0.08730313f, 
    0.13848566f, -0.01571424f, 0.07462789f, 0.06534447f, 0.13724652f, -0.00758915f, 0.05290214f, 0.04109652f, 
    -0.13962092f, 0.18833028f, 0.00152054f, -0.00417673f, -0.07819259f, 0.07427838f, 0.00070056f, -0.00069116f, 
    -0.05744699f, 0.04913969f, -0.07875522f, 0.06272169f, -0.26269171f, 0.32521230f, -0.06309576f, -0.01058224f, 
    -0.06204456f, -0.00836631f, 0.12218666f, -0.14789738f, 0.11568911f, 0.21098986f, 0.08006503f, 0.08402836f, 
    0.06922034f, -0.08055437f, 0.17645906f, 0.14260744f, 0.07908729f, 0.01739250f, 0.02632712f, -0.05163810f, 
    -0.04238852f, -0.02680681f, 0.11604982f, -0.05174676f, 0.24905270f, 0.10321182f, 0.04841039f, 0.12664294f, 
    -0.02127114f, 0.09505434f, 0.00954453f, -0.04808190f, -0.03347543f, 0.02235390f, -0.10982171f, -0.12010275f, 
    -0.18327208f, -0.05099474f, -0.04501837f, -0.15520211f, 0.00390297f, 0.29184589f, -0.14197250f, 0.02824975f, 
    -0.06245235f, -0.05886187f, 0.09682491f, 0.01926258f, -0.15100323f, 0.11048964f, 0.01336627f, 0.05035510f, 
    -0.04496671f, 0.12887529f, -0.03142637f, 0.05997568f, 0.15491553f, 0.14238840f, 0.06298582f, -0.00817843f, 
    0.07669932f, -0.00062927f, 0.16323183f, 0.08392520f, 0.16356330f, -0.00171944f, 0.18474448f, 0.12928671f, 
    0.10346781f, 0.16268381f, 0.20216686f, -0.02791537f, -0.12846461f, 0.11403849f, 0.25662750f, -0.22149076f, 
    0.13101834f, -0.12756497f, 0.26729321f, 0.07500779f, 0.09340876f, 0.08683379f, -0.08634552f, 0.01627151f, 
    -0.40462440f, 0.05345799f, -0.15974678f, 0.25144321f, 0.03014174f, -0.02653875f, -0.10662026f, -0.04535371f, 
    0.18262154f, 0.03168619f, 0.10768501f, 0.17774832f, -0.34858331f, -0.11638362f, -0.14735523f, 0.27831024f, 
    0.08239242f, 0.17144053f, 0.08036143f, -0.07553358f, 0.17307740f, 0.13316712f, 0.15584445f, 0.12622361f, 
    -0.27670777f, -0.05296250f, -0.05844511f, -0.11152872f, -0.06996942f, -0.20483282f, -0.24064346f, 0.13062175f, 
    0.05363844f, 0.00876504f, 0.02597512f, -0.09285954f, 0.06612913f, -0.03942262f, 0.00274612f, 0.21703506f, 
    0.06691844f, 0.08874987f, -0.01189026f, 0.06963935f, 0.10016015f, 0.12440046f, 0.00916570f, 0.04873427f, 
    -0.22859140f, 0.02830820f, 0.13450627f, 0.11772043f, 0.01467440f, 0.07190970f, -0.02963284f, 0.03558106f, 
    -0.06156805f, 0.02678946f, -0.02744503f, 0.02430019f, -0.14833683f, -0.17197318f, 0.10773064f, -0.12201588f, 
    0.02371540f, -0.06661092f, -0.03596630f, 0.12261472f, 0.05134950f, 0.07870373f, 0.01466710f, -0.14049293f, 
    0.06041886f, 0.02834404f, 0.06406485f, -0.01142937f, 0.13088824f, 0.15176941f, 0.25807750f, 0.26475531f, 
    -0.07895765f, -0.06359822f, 0.05081401f, 0.05412835f, 0.26031536f, 0.06635195f, 0.22319120f, -0.05441396f, 
    -0.02577838f, -0.00266580f, 0.07532838f, -0.08416720f, 0.02532081f, 0.12650946f, -0.03917199f, 0.12759532f, 
    -0.00893753f, 0.03724959f, -0.01052350f, 0.02764937f, -0.03623950f, 0.00391314f, -0.06018732f, -0.01744616f, 
    0.06420008f, -0.03681603f, 0.07246067f, 0.01882702f, -0.11368475f, -0.09546632f, -0.08943106f, -0.01772567f, 
    -0.00154663f, 0.23958193f, -0.02967221f, 0.03733821f, 0.03857912f, 0.01977476f, 0.07268286f, 0.03194461f, 
    -0.01380563f, 0.01249905f, 0.19915086f, -0.24294104f, -0.08158749f, 0.02299033f, -0.01228871f, -0.07476750f, 
    0.04785332f, -0.03334993f, 0.12056928f, -0.04894580f, -0.11256231f, 0.04435270f, 0.12322715f, 0.09000096f, 
    -0.08145813f, -0.12374810f, 0.05073273f, 0.12139751f, 0.11689836f, 0.05916001f, 0.14286831f, 0.19809014f, 
    -0.06503411f, 0.03502141f, -0.10551167f, -0.11789229f, 0.11976543f, 0.05881721f, 0.00390216f, 0.13425562f, 
    0.00086264f, 0.10187335f, 0.04451214f, -0.07706774f, 0.00052977f, -0.06258324f, 0.11792108f, -0.17213003f, 
    -0.12505947f, 0.07415960f, -0.05241805f, -0.04521834f, 0.00001085f, 0.07258774f, -0.03568217f, -0.05743173f, 
    -0.14661644f, -0.04270089f, 0.06186377f, 0.01142457f, 0.02042081f, 0.05535698f, -0.04000970f, 0.04911931f, 
    -0.13298728f, -0.06184856f, 0.07082094f, -0.11281380f, 0.13835101f, -0.07574390f, 0.07288644f, 0.14556758f, 
    0.13890068f, 0.06390060f, -0.07406396f, 0.04852515f, 0.12679090f, 0.08493032f, 0.05788727f, 0.05365413f, 
    -0.11920910f, -0.00879391f, -0.00919060f, -0.29278103f, -0.06278162f, 0.06807810f, -0.07984453f, 0.09795429f, 
    0.01167732f, 0.03728075f, -0.07515610f, 0.00127170f, 0.09052289f, 0.00232352f, -0.16022080f, 0.01280386f, 
    0.01426593f, 0.03089142f, -0.05505749f, -0.06764868f, -0.02613309f, -0.00617422f, -0.00225307f, 0.08650822f, 
    0.09013670f, -0.09926093f, -0.18676941f, 0.12034205f, 0.03745916f, -0.01178259f, 0.11754662f, 0.05733069f, 
    -0.12197325f, 0.03839370f, 0.03089370f, -0.00174692f, -0.14015311f, 0.06566301f, -0.08698572f, -0.09099250f, 
    -0.02942555f, 0.23074934f, 0.00564454f, 0.03767432f, -0.08690916f, -0.00818747f, 0.11704779f, -0.09351393f, 
    -0.26994416f, -0.12657082f, 0.00726670f, -0.04187313f, -0.05382602f, 0.07252587f, -0.08431325f, -0.00229409f, 
    -0.00045437f, 0.07495029f, 0.08461510f, 0.01268004f, 0.10618912f, 0.24162792f, -0.01080659f, -0.11635663f, 
    -0.00966134f, -0.12487419f, -0.06361271f, 0.24696581f, 0.11297744f, 0.01169829f, 0.02078437f, -0.00561917f, 
    0.02205217f, -0.18764251f, -0.25678551f, -0.07387249f, 0.06981282f, 0.20201740f, -0.01817314f, 0.09008323f, 
    0.00222356f, 0.03536033f, 0.16424622f, 0.07830828f, 0.01372566f, -0.10030369f, -0.09513082f, -0.02553367f, 
    0.13301504f, 0.04227937f, 0.10565504f, -0.00524119f, -0.02555857f, -0.07630981f, -0.02058458f, -0.05007166f, 
    0.04615849f, -0.01441944f, 0.17274632f, -0.09321897f, -0.07336368f, 0.13669021f, 0.02297809f, 0.02630009f, 
    0.04233893f, 0.03159084f, 0.03355977f, 0.04487780f, 0.19452094f, 0.09696633f, -0.06413225f, 0.13692583f, 
    -0.00721724f, -0.11284891f, 0.00192489f, 0.00336247f, -0.01942275f, 0.11964730f, 0.02324474f, 0.09353002f, 
    0.18213648f, -0.03922265f, 0.05989302f, -0.25445065f, 0.03861966f, 0.06264145f, 0.04254688f, -0.09031885f, 
    0.03451345f, 0.18957157f, 0.09972595f, -0.15236002f, -0.11080881f, -0.10965221f, -0.13739440f, 0.10891850f, 
    -0.01336847f, 0.17356128f, 0.22881524f, 0.08123428f, -0.12118986f, 0.10609073f, -0.11355888f, -0.09371040f, 
    -0.09297955f, -0.12816522f, -0.34702674f, 0.03200083f, -0.19110653f, 0.26167372f, -0.04648898f, -0.00782974f, 
    -0.06208432f, 0.01493999f, -0.07697792f, 0.00056204f, -0.21424389f, -0.06949250f, -0.02224108f, 0.26281705f, 
    0.01868703f, -0.02879368f, -0.03083488f, 0.10424212f, 0.07869077f, 0.05041755f, 0.02813473f, 0.00670371f, 
    0.12595208f, 0.13660893f, 0.15775993f, -0.11950367f, -0.02840855f, 0.03970628f, 0.20590478f, 0.13841784f, 
    -0.03622338f, 0.12250841f, 0.13506171f, 0.00353543f, 0.21593842f, 0.08464522f, 0.15157838f, -0.11360182f, 
    -0.00599167f, -0.11613814f, 0.14165856f, 0.14859337f, 0.00955115f, -0.02387400f, -0.01839170f, 0.00573697f, 
    -0.15731950f, 0.04665191f, -0.05171349f, 0.11397683f, 0.02148089f, -0.10341942f, -0.13258612f, -0.01968112f, 
    0.03966094f, 0.07643046f, -0.01338848f, 0.10949514f, 0.04047797f, 0.08747110f, 0.22783661f, -0.05715080f, 
    0.06597178f, 0.00849677f, 0.03355258f, -0.04069691f, 0.05198831f, 0.00521393f, 0.12891516f, -0.01954839f, 
    -0.02824156f, 0.11245964f, -0.01927241f, -0.01252645f, 0.01043585f, 0.04754947f, -0.09752514f, 0.26182064f, 
    -0.03790699f, 0.06283099f, 0.07662640f, -0.08410885f, 0.13932486f, -0.05227492f, -0.12309705f, -0.15597872f, 
    0.02454104f, -0.04425071f, 0.00583926f, 0.02270088f, 0.06421607f, 0.07612101f, -0.03389354f, 0.11354672f, 
    0.05338316f, 0.20403910f, -0.08588047f, -0.22427377f, -0.04600584f, -0.09319860f, 0.05060408f, 0.01483377f, 
    -0.10687137f, 0.00285764f, 0.03113600f, -0.02992566f, -0.07697613f, 0.04816187f, 0.05659473f, -0.28543550f, 
    0.09458754f, -0.01639546f, 0.07256780f, 0.04102759f, -0.01244052f, 0.02916542f, -0.00207674f, -0.05920123f, 
    -0.15700559f, -0.19004156f, 0.25119394f, -0.08815509f, 0.08063237f, 0.14920208f, 0.11743131f, 0.10181431f, 
    0.00969491f, -0.01313606f, 0.02751984f, 0.09609875f, -0.11749165f, -0.04654135f, -0.05217708f, -0.05834294f, 
    0.11836067f, 0.06766137f, 0.15500301f, 0.05956288f, 0.02747604f, 0.07436907f, -0.20220914f, 0.14307046f, 
    0.02514491f, -0.02995647f, -0.05186540f, 0.03775918f, -0.02480430f, 0.03665527f, -0.04308111f, -0.01401345f, 
    0.01495374f, -0.00357620f, -0.01665832f, -0.00520243f, 0.01698419f, 0.04271908f, -0.00603409f, 0.01797402f, 
    -0.02451767f, -0.03987471f, -0.02269791f, -0.01706927f, 0.04112510f, 0.00253160f, 0.00367742f, -0.03408730f, 
    0.00727769f, -0.02676699f, 0.00641295f, -0.02528773f, 0.01034751f, 0.02838634f, -0.02781766f, 0.02472941f, 
    0.04722830f, -0.00542796f, -0.04391807f, 0.00877161f, 0.02026239f, 0.01086347f, -0.01849111f, 0.01086283f, 
    -0.03757535f, 0.01776081f, 0.02734634f, -0.04390951f, 0.03728636f, 0.00788666f, 0.00706530f, -0.01826902f, 
    -0.05715095f, -0.01964219f, 0.02107647f, 0.00303604f, -0.05139536f, 0.03807453f, 0.01088261f, 0.04083716f, 
    -0.02463851f, 0.01769961f, 0.03273867f, 0.02049046f, 0.03615519f, -0.00980769f, 0.03707430f, 0.03104855f, 
    -0.02862491f, -0.01911016f, -0.04515942f, -0.00063958f, 0.04751865f, 0.01825337f, -0.04684142f, -0.05007068f, 
    -0.03078170f, 0.01931318f, -0.03180791f, -0.05084528f, -0.01041829f, -0.04654305f, -0.01382122f, -0.05995924f, 
    0.03582274f, 0.01325842f, 0.01098663f, -0.03116319f, 0.04585949f, -0.03812425f, 0.01275182f, 0.04321776f, 
    0.00780950f, -0.04335029f, -0.01512176f, 0.01100625f, -0.03871813f, -0.02446248f, 0.00391903f, 0.01404222f, 
    -0.02074775f, -0.05035165f, 0.02167762f, 0.02240157f, -0.01330239f, 0.01547418f, -0.03433735f, 0.03727520f, 
    -0.03872401f, -0.04005250f, -0.01078083f, 0.02169167f, 0.04476245f, 0.01913379f, 0.00020846f, 0.00396775f, 
    -0.00472092f, -0.04468747f, -0.03832563f, 0.03555054f, 0.00744104f, -0.04163261f, 0.01908048f, -0.00404748f, 
    0.03173802f, -0.01588206f, 0.00484700f, -0.03340435f, -0.01192766f, -0.02244288f, 0.01047108f, 0.01501991f, 
    -0.00948763f, -0.03187827f, -0.02314607f, -0.04282583f, 0.02576307f, -0.01980119f, -0.01639962f, -0.00325478f, 
    -0.00896293f, 0.02586360f, 0.04721675f, -0.02910710f, -0.05451633f, 0.01122904f, -0.00466148f, 0.04706208f, 
    -0.04492192f, 0.02982577f, -0.03491271f, 0.03107696f, -0.03582799f, -0.01694367f, -0.03657621f, -0.01625102f, 
    0.00310705f, 0.01361140f, -0.05367960f, 0.00316384f, 0.00948688f, -0.03706313f, -0.04865137f, -0.04516296f, 
    -0.01406220f, -0.04687364f, -0.02606008f, -0.03480317f, -0.01107809f, -0.04542609f, -0.03568349f, -0.03089747f, 
    0.02265763f, -0.04420492f, -0.00226437f, -0.03273926f, 0.00502208f, 0.04040255f, 0.00882433f, 0.00176179f, 
    0.00439738f, -0.01958080f, -0.04669492f, -0.05392903f, -0.05291688f, -0.00804661f, -0.04421412f, -0.02734840f, 
    -0.01120144f, 0.02780567f, -0.05488530f, -0.04515199f, -0.00628558f, 0.01873736f, 0.04678106f, -0.02239385f, 
    -0.01108583f, -0.01676104f, 0.00703800f, -0.01071838f, 0.03002908f, 0.02445292f, -0.01912688f, 0.03595259f, 
    -0.04266274f, -0.04625609f, -0.04897852f, 0.00094870f, -0.01617946f, 0.02372228f, 0.03708183f, -0.02694778f, 
    -0.02184963f, -0.05185223f, -0.00792294f, -0.02698243f, 0.00293725f, -0.00271665f, 0.03616123f, -0.02819354f, 
    0.01676263f, -0.05070952f, -0.04259523f, 0.00441222f, -0.04864495f, 0.02893262f, -0.00364648f, -0.02184282f, 
    -0.01158846f, 0.02837082f, 0.02388706f, -0.01606829f, -0.03705268f, -0.06255987f, -0.00768718f, 0.02506855f, 
    0.02467923f, -0.01967313f, -0.00235282f, -0.04451629f, -0.04002394f, -0.00929199f, 0.02331168f, 0.00045711f, 
    0.00513801f, -0.05613320f, -0.02565679f, -0.01981817f, 0.04251120f, -0.02270268f, -0.01281464f, -0.04048574f, 
    0.04158538f, -0.02699807f, -0.00769286f, 0.01210534f, 0.00587535f, 0.02016158f, -0.01120505f, -0.04639375f, 
    0.02101778f, 0.00661336f, 0.01648560f, 0.02732552f, 0.00363496f, -0.01535570f, 0.00373846f, -0.01482591f, 
    0.03275404f, 0.03351722f, 0.01129612f, 0.00635153f, 0.00473444f, -0.05096171f, 0.04423336f, 0.03691703f, 
    -0.01368441f, 0.02346698f, -0.00082424f, -0.01213526f, 0.03582768f, -0.00266522f, -0.05248956f, 0.02563717f, 
    -0.03055239f, 0.01659734f, 0.00985214f, 0.03047170f, -0.00162272f, 0.00680826f, 0.04219029f, -0.00148025f, 
    -0.05640588f, 0.01276294f, 0.03745602f, 0.02282219f, 0.04463114f, -0.03685222f, 0.02410956f, 0.03244276f, 
    -0.03687063f, 0.04316065f, 0.04036815f, -0.01601033f, -0.03719539f, -0.05175843f, -0.05259608f, -0.04339543f, 
    0.00680882f, 0.03457566f, -0.00510148f, -0.03098196f, 0.02717578f, -0.00856617f, 0.03408150f, 0.02111534f, 
    0.01222994f, 0.00818143f, -0.01617461f, -0.04960675f, 0.00333400f, -0.00652937f, -0.02875382f, -0.00537209f, 
    -0.00565080f, -0.02451143f, 0.04138858f, 0.00389029f, -0.03927786f, -0.04024496f, 0.03390452f, 0.03758839f, 
    -0.02872974f, 0.00650933f, 0.03161062f, 0.03421348f, 0.04335195f, -0.01612615f, 0.01215256f, -0.03521485f, 
    0.01788845f, -0.04991981f, 0.00414028f, -0.01227357f, 0.00387797f, -0.00871154f, -0.00967914f, 0.04921333f, 
    0.00210671f, -0.05371733f, -0.00490810f, -0.04080568f, 0.04387750f, 0.00925619f, -0.00309446f, 0.03750062f, 
    -0.01153434f, -0.04116059f, 0.01046875f, -0.04585092f, -0.03814067f, 0.03209113f, -0.01780095f, -0.01964531f, 
    0.03498501f, -0.02749860f, -0.00744095f, 0.02986548f, 0.04605936f, 0.04073161f, 0.02064895f, -0.04735117f, 
    -0.00664794f, 0.00595992f, 0.04088606f, 0.02382750f, 0.00422437f, 0.03629675f, 0.02338210f, 0.04640345f, 
    0.03058323f, 0.04554869f, 0.01373518f, -0.04390753f, -0.04343780f, -0.05163394f, -0.04587081f, 0.01311952f, 
    0.06582425f, -0.01981570f, 0.09683693f, 0.08607686f, -0.06481321f, -0.05120460f, -0.03286343f, -0.07297388f, 
    -0.20738491f, -0.08834753f, 0.08475836f, -0.07750247f, -0.14945345f, -0.11686417f, 0.05588353f, -0.16912811f, 
    0.11224394f, -0.08991782f, 0.09523314f, 0.03743806f, 0.06540281f, 0.09612875f, 0.01630606f, 0.03158773f, 
    -0.35329923f, -0.14676133f, -0.05470625f, -0.13788518f, -0.08234971f, -0.21088116f, 0.00550494f, -0.03728836f, 
    0.08098084f, 0.16011548f, -0.06272087f, -0.01201109f, 0.06476896f, -0.12762684f, 0.07462661f, -0.04743743f, 
    -0.02647523f, -0.05208730f, -0.03164419f, -0.06415293f, 0.07727079f, 0.00352226f, 0.09377077f, 0.31429133f, 
    0.06035149f, -0.12247313f, 0.10385735f, -0.14393766f, -0.07513282f, 0.00152351f, 0.05571574f, 0.18167783f, 
    0.04640911f, 0.10906386f, 0.28246167f, -0.17905281f, -0.02978462f, 0.14126107f, -0.07056257f, 0.04515783f, 
    -0.03419258f, 0.08382062f, 0.08565883f, 0.05064067f, -0.14718616f, -0.14736718f, -0.22092248f, -0.08067052f, 
    -0.04181091f, -0.02385282f, -0.00308331f, -0.02354035f, 0.06190832f, 0.01493119f, 0.05395648f, -0.04136408f, 
    -0.04858744f, -0.17962790f, 0.04206531f, -0.07674892f, 0.08709535f, -0.10878100f, 0.03420791f, -0.03505522f, 
    0.20987363f, 0.02705597f, 0.02506692f, 0.16757917f, 0.18080492f, 0.16553850f, 0.02335970f, -0.01266557f, 
    -0.07544740f, -0.01720514f, -0.12292074f, -0.09638251f, -0.08319844f, -0.10719924f, 0.06385438f, 0.04971548f, 
    0.01867499f, 0.04721801f, -0.00888693f, -0.06185136f, -0.17724986f, -0.06482430f, -0.05314502f, -0.09666424f, 
    -0.00655179f, 0.05211028f, 0.03764794f, 0.05545476f, 0.07611605f, 0.00301172f, 0.04996904f, -0.09753025f, 
    0.05910427f, 0.02049814f, -0.02971219f, -0.07202726f, -0.02654024f, 0.06752628f, -0.03608298f, 0.01258706f, 
    -0.17179585f, -0.12753856f, 0.04051417f, -0.08098229f, -0.07688291f, -0.12266545f, -0.00224176f, -0.04660270f, 
    -0.00439063f, 0.01828911f, -0.01356094f, 0.27680427f, 0.15961105f, -0.04862958f, 0.24818137f, 0.01804766f, 
    -0.12823817f, -0.09831574f, 0.23845640f, -0.03638703f, 0.09170081f, -0.07739157f, -0.00079827f, -0.10806057f, 
    -0.13059571f, 0.09884941f, 0.13281566f, 0.19030178f, 0.34672204f, 0.13775750f, 0.11760215f, 0.02323915f, 
    0.03072409f, -0.01700659f, -0.04963834f, -0.03893229f, 0.25433379f, 0.19046438f, 0.06563843f, 0.01407154f, 
    -0.00869514f, -0.03530583f, 0.04932577f, -0.30863592f, 0.03590614f, 0.17993890f, -0.05659875f, -0.01639174f, 
    0.08970711f, -0.00413827f, 0.07362588f, 0.03296393f, -0.09916215f, 0.03852311f, -0.09816463f, -0.07326615f, 
    0.03670628f, -0.04569997f, -0.02198658f, 0.12834337f, 0.11697811f, -0.03093643f, 0.05906124f, -0.05714121f, 
    0.05566142f, 0.32854632f, 0.06914601f, -0.12701002f, -0.01114858f, 0.01002730f, -0.05251354f, 0.11814595f, 
    0.00236804f, 0.18453902f, 0.05274133f, 0.04024153f, -0.02149111f, 0.00754811f, 0.09848136f, 0.02511166f, 
    0.00305165f, -0.01216299f, -0.03641453f, -0.00051149f, 0.17799757f, 0.20160110f, -0.00383799f, 0.17933333f, 
    0.10409280f, 0.04006940f, -0.27140462f, -0.19172888f, 0.04710526f, 0.13428579f, 0.01684637f, -0.03090259f, 
    0.17411441f, 0.05434713f, -0.03106545f, 0.05828593f, -0.04976801f, -0.05896760f, -0.10561299f, -0.10477312f, 
    0.16824205f, 0.17248800f, -0.00571034f, 0.18829247f, 0.04578179f, 0.01070104f, -0.11170360f, 0.03946634f, 
    -0.14451462f, -0.20359753f, 0.02760741f, -0.21232140f, 0.13362919f, -0.12741084f, 0.01748075f, 0.22601882f, 
    0.00700361f, 0.05436675f, 0.00079391f, -0.00797793f, -0.04332229f, -0.07274438f, 0.05555243f, -0.03414189f, 
    0.00693124f, 0.23006321f, -0.19818722f, 0.16346718f, 0.09758426f, -0.12475181f, 0.13618597f, -0.02590876f, 
    0.08331807f, -0.01437049f, -0.20237190f, 0.00163335f, -0.02000277f, 0.06412905f, 0.10199913f, 0.03496556f, 
    0.12237692f, 0.16832122f, -0.16091539f, 0.05687374f, 0.08399326f, 0.12979722f, -0.03224409f, -0.12769975f, 
    0.04097642f, -0.00857718f, 0.11468301f, 0.10429934f, 0.18277650f, 0.00023219f, 0.01558275f, 0.12783186f, 
    -0.26416230f, 0.13136889f, -0.00908537f, 0.18739638f, 0.00315808f, 0.06451801f, -0.05574275f, -0.00020659f, 
    0.14025371f, 0.07327122f, 0.14859103f, 0.17303701f, 0.21996075f, -0.35582253f, 0.11916511f, 0.29679313f, 
    0.17611188f, -0.07941075f, -0.02304287f, 0.01516234f, 0.13136432f, 0.21148510f, 0.19199947f, 0.15867516f, 
    -0.01045067f, 0.06412721f, -0.06459515f, -0.05978522f, -0.03624212f, -0.08711804f, 0.02197070f, 0.03056191f, 
    0.21629222f, 0.04038851f, 0.15910603f, 0.03197630f, 0.12186037f, -0.08612502f, -0.08360178f, 0.00736547f, 
    0.12231020f, -0.05949059f, 0.07426783f, 0.00228282f, 0.01258830f, 0.04860817f, 0.06538124f, 0.13375732f, 
    -0.23405941f, -0.30022788f, -0.20455773f, -0.18680495f, -0.00407956f, -0.15559177f, 0.03442563f, 0.03959523f, 
    0.03585638f, 0.01993687f, 0.01921695f, -0.01441069f, -0.31438366f, -0.09021694f, -0.15247019f, -0.23627926f, 
    0.18413496f, -0.00265704f, 0.05897305f, -0.03517759f, 0.11531165f, 0.16058874f, -0.06516822f, 0.13721316f, 
    -0.01889233f, -0.03143097f, -0.12885070f, 0.00618576f, 0.12032845f, -0.00065044f, 0.17503728f, -0.20835909f, 
    0.08226522f, 0.02581056f, 0.05241423f, 0.06262679f, -0.25443330f, 0.11221604f, -0.12723207f, 0.11381478f, 
    0.05122221f, 0.02496690f, -0.00751761f, 0.01224376f, -0.01099210f, -0.01821433f, -0.02420784f, 0.01783642f, 
    -0.05334082f, 0.00183323f, 0.02667901f, -0.00293609f, -0.00074925f, -0.03044314f, -0.02386278f, -0.02115730f, 
    0.02935893f, -0.02651335f, -0.03992575f, 0.00667391f, 0.01116627f, -0.05081639f, 0.03292372f, -0.01762299f, 
    -0.01318486f, -0.03834391f, 0.01733703f, 0.03633194f, 0.00781186f, 0.02190804f, 0.01241474f, 0.01645940f, 
    -0.02932786f, -0.03599438f, 0.02989210f, -0.04390622f, -0.01544898f, 0.03051093f, -0.02423810f, -0.00279155f, 
    0.00590581f, 0.03440361f, -0.00538308f, 0.01000554f, 0.04021150f, -0.02841852f, 0.02050658f, -0.00871845f, 
    -0.00233002f, 0.02390064f, 0.02744525f, 0.03997310f, 0.02214311f, -0.03096542f, 0.03765992f, -0.01012598f, 
    -0.03214253f, -0.05720668f, 0.03711512f, -0.02422550f, -0.04016148f, -0.00549596f, -0.01418721f, 0.02814049f, 
    -0.01076856f, 0.00629308f, -0.02454085f, -0.02154131f, -0.04905055f, 0.02469310f, -0.00191266f, 0.02830163f, 
    0.02745483f, -0.02960774f, 0.00843991f, 0.00088543f, 0.01624442f, -0.01798138f, 0.04964798f, -0.03268097f, 
    -0.03221054f, 0.01502284f, 0.00401831f, 0.02620876f, 0.01280290f, -0.05017785f, -0.00933446f, 0.02586495f, 
    0.02549651f, -0.01080495f, -0.03977846f, -0.00477326f, 0.00102562f, -0.02707513f, -0.02849007f, 0.00194473f, 
    -0.01025296f, -0.02532960f, -0.03209620f, 0.01300594f, -0.03548806f, 0.02442884f, -0.03456594f, -0.02947218f, 
    0.02019578f, -0.01659694f, 0.02188716f, 0.01045832f, -0.02320071f, 0.03322253f, 0.00914208f, -0.03660265f, 
    -0.03697172f, -0.02424175f, -0.00385436f, 0.03024455f, -0.00602318f, -0.02968246f, 0.01343306f, -0.00238441f, 
    0.03230897f, -0.03418092f, -0.01063424f, -0.02866775f, -0.03232095f, 0.00384211f, -0.03218047f, -0.03958859f, 
    -0.03646507f, -0.02288430f, -0.01713879f, 0.00094403f, -0.04970239f, 0.00066143f, -0.00340345f, 0.01561995f, 
    -0.00389160f, -0.03077973f, -0.04791645f, 0.00467161f, 0.00111435f, -0.04893697f, 0.01676040f, -0.02686781f, 
    -0.04414599f, -0.01946883f, -0.04184406f, -0.01714328f, -0.03137071f, 0.04413472f, -0.00707030f, -0.02825977f, 
    0.02602463f, -0.03690756f, -0.01750745f, -0.02770295f, -0.01434848f, 0.01756997f, 0.02106878f, 0.02752866f, 
    0.02871373f, -0.02920642f, 0.00356253f, -0.03985408f, -0.02221587f, 0.00276988f, -0.05202998f, 0.03123779f, 
    -0.03334375f, -0.04043526f, -0.00622424f, -0.00812256f, 0.04001682f, 0.00512233f, -0.00648287f, -0.05400182f, 
    -0.00980700f, -0.05506624f, -0.03387569f, 0.04089918f, 0.02715338f, 0.01983440f, -0.01564046f, -0.01598286f, 
    0.01965844f, -0.01515254f, -0.03693327f, -0.02572482f, -0.01081699f, -0.05685399f, -0.02792669f, 0.02567852f, 
    -0.02698131f, -0.00018106f, -0.05065105f, -0.00806013f, -0.02387359f, -0.01972548f, 0.04051572f, -0.04710693f, 
    0.00054918f, 0.02507588f, 0.02922770f, -0.01129296f, -0.04615507f, -0.01047718f, 0.00074881f, 0.02842761f, 
    -0.03725171f, 0.00781665f, -0.04815339f, -0.05428893f, -0.03443269f, 0.02716729f, 0.02372454f, -0.04609877f, 
    0.01152206f, 0.02007370f, 0.00133635f, -0.05073431f, -0.01850356f, 0.03413327f, -0.04090264f, -0.04048097f, 
    -0.01423076f, 0.01216352f, -0.03681929f, 0.02912288f, -0.02256953f, -0.02114023f, -0.00299136f, 0.03761349f, 
    0.02355931f, -0.00230173f, 0.01778618f, -0.02340308f, 0.03539736f, -0.05537864f, -0.03309126f, -0.03129536f, 
    0.02527975f, -0.01159323f, -0.02429995f, -0.02772048f, 0.03408353f, -0.04341410f, -0.01692725f, -0.05809100f, 
    -0.02820245f, -0.04008493f, -0.01075178f, 0.03946071f, -0.02665704f, 0.02533943f, 0.02821562f, 0.02009307f, 
    0.02225394f, 0.03523656f, -0.02665420f, 0.03033103f, -0.03345213f, 0.00182229f, 0.03632306f, -0.05514935f, 
    -0.03676749f, -0.02568425f, -0.01520859f, 0.03531287f, -0.00979997f, 0.01921867f, -0.02427150f, -0.04039310f, 
    0.02910877f, 0.02306424f, -0.00081599f, -0.04138385f, -0.00401561f, -0.02236325f, -0.01859867f, -0.04655128f, 
    -0.02140582f, 0.03669930f, -0.03728376f, -0.04083816f, 0.00340315f, 0.01497782f, -0.01709703f, 0.03611554f, 
    0.02036846f, -0.03085466f, 0.01556299f, -0.00965069f, 0.01260213f, 0.01894083f, -0.04410420f, 0.03138892f, 
    0.00039681f, -0.02522149f, 0.01643586f, 0.03393771f, 0.03634137f, -0.01354472f, -0.04273705f, -0.05797141f, 
    0.00175232f, -0.02985064f, -0.02197976f, 0.01653143f, 0.00755576f, -0.05053267f, 0.01007812f, 0.03578436f, 
    -0.04274834f, -0.05853287f, 0.02281133f, -0.04842381f, -0.05213284f, -0.03140221f, -0.03064837f, -0.03142482f, 
    -0.05805550f, -0.04736587f, -0.04340973f, -0.04034466f, 0.00904086f, -0.00042998f, -0.04391426f, -0.01216893f, 
    0.00465939f, 0.02983520f, 0.04268468f, 0.02550876f, 0.01693929f, 0.01241408f, -0.05437302f, -0.02135253f, 
    -0.00509175f, -0.03596271f, 0.01363365f, -0.00118653f, 0.00116530f, -0.01573412f, 0.00364149f, -0.04643795f, 
    -0.03234658f, -0.00917802f, -0.00034484f, -0.03849708f, 0.03868931f, -0.00318496f, -0.05623830f, -0.03272336f, 
    -0.00982619f, -0.05511175f, -0.01272445f, 0.01582960f, -0.03139390f, 0.01526539f, -0.02700949f, -0.01387363f, 
    -0.01146486f, 0.03280795f, -0.04946686f, 0.00626267f, -0.03560015f, -0.02359430f, 0.02560666f, 0.01231438f, 
    0.02449428f, -0.01835348f, 0.02815411f, 0.04633619f, -0.02330009f, -0.00021227f, 0.03537627f, 0.02773307f, 
    -0.04384523f, -0.04534816f, 0.02555154f, 0.03058010f, 0.02896556f, 0.03684954f, 0.02439459f, 0.02969487f, 
    0.03021460f, -0.05823925f, 0.03621909f, -0.03255881f, 0.03524581f, 0.01937403f, -0.00292557f, 0.00073519f, 
    0.02756002f, -0.01611711f, 0.16571967f, 0.05324468f, -0.09449900f, -0.04505828f, -0.13328624f, -0.11910084f, 
    -0.20899208f, -0.16763723f, -0.13673632f, -0.05951886f, 0.01148621f, 0.00232242f, 0.00796993f, -0.16713248f, 
    0.00391573f, 0.05083857f, 0.16644770f, 0.10885288f, 0.27733883f, 0.22450267f, 0.21237448f, 0.16096319f, 
    -0.08945283f, -0.10713226f, 0.15580681f, 0.10068566f, -0.04357892f, 0.10320496f, 0.05759426f, 0.11422376f, 
    0.10288012f, -0.20164219f, 0.11098641f, 0.00868580f, 0.09116936f, 0.01314915f, 0.17598814f, -0.08605327f, 
    -0.12247604f, -0.14246859f, -0.06357236f, -0.03307026f, 0.23290569f, 0.13793951f, 0.12210616f, 0.23239616f, 
    -0.00435247f, -0.12813821f, 0.17126389f, -0.26785931f, 0.07139096f, 0.03608996f, -0.08156791f, 0.06137297f, 
    -0.14058948f, 0.11014199f, -0.00472788f, -0.19515997f, -0.11045776f, 0.03017582f, 0.13347082f, 0.05735444f, 
    -0.06167947f, -0.00642269f, 0.00905803f, 0.09638640f, -0.27641508f, -0.07821837f, -0.21604122f, -0.18461922f, 
    -0.17376496f, -0.11653480f, 0.03916944f, 0.01391707f, -0.00788751f, -0.04450370f, -0.07094605f, -0.03345746f, 
    -0.03755320f, -0.14986262f, 0.02112163f, -0.12590741f, -0.11742903f, -0.10980155f, 0.32927948f, -0.20219818f, 
    0.15150867f, 0.09673543f, -0.07508610f, 0.12008590f, 0.11067279f, -0.06997769f, -0.01158866f, 0.00267454f, 
    -0.07045120f, 0.18897004f, 0.04458465f, -0.08200754f, 0.03856268f, 0.12760250f, 0.16464891f, 0.10549968f, 
    0.01789245f, 0.10331308f, -0.06933962f, -0.14205015f, 0.11953415f, 0.08850629f, -0.15957445f, 0.18285573f, 
    0.03114524f, 0.12080651f, 0.08776605f, 0.24292621f, 0.01512321f, 0.04479951f, -0.01094920f, 0.04922678f, 
    -0.06276840f, -0.04861692f, -0.05293567f, -0.01332525f, -0.11128546f, -0.05637293f, 0.09760822f, 0.04821072f, 
    -0.13044013f, -0.02082198f, -0.02487221f, -0.23931612f, -0.11648604f, 0.05942002f, -0.00573761f, -0.10822356f, 
    -0.04490051f, 0.14382136f, -0.06218021f, 0.03505040f, 0.07100501f, -0.06552048f, -0.06573936f, -0.12020359f, 
    0.09970269f, -0.13223346f, 0.19951412f, 0.01585529f, 0.07689928f, -0.04340822f, -0.13975233f, 0.09396502f, 
    -0.00745040f, -0.10340218f, 0.02260746f, -0.02890040f, 0.39011931f, -0.14796570f, 0.08821685f, -0.23297371f, 
    0.03329387f, -0.11765434f, -0.01468487f, 0.06042045f, -0.02047244f, -0.00825467f, -0.15402669f, -0.25002599f, 
    0.24844770f, 0.05103849f, -0.19583601f, -0.02501077f, 0.02611420f, 0.01673126f, 0.00492051f, 0.16368854f, 
    -0.01107514f, -0.07816126f, -0.14628409f, -0.14953884f, -0.21310593f, -0.13554122f, -0.13283843f, -0.01961224f, 
    0.12416849f, 0.02421531f, 0.05556916f, 0.02794229f, 0.09534253f, 0.10971712f, 0.08396449f, 0.17114548f, 
    -0.12473670f, 0.14472784f, 0.11911590f, -0.08132713f, -0.11267770f, -0.00184493f, 0.05066438f, 0.11071727f, 
    -0.09701845f, -0.20019898f, -0.11579931f, -0.01102261f, 0.16170402f, 0.01938946f, -0.08988541f, -0.23461284f, 
    -0.14322892f, -0.06704454f, -0.11738536f, -0.06387734f, 0.14850213f, 0.14203128f, 0.23666769f, 0.05370964f, 
    0.11511334f, 0.00564096f, 0.10172389f, -0.16071534f, 0.06992280f, 0.04447843f, 0.02229703f, 0.00987138f, 
    -0.14005388f, -0.04247759f, 0.02164309f, -0.09676398f, -0.23238826f, -0.14653085f, -0.22723871f, -0.06602754f, 
    0.10636620f, 0.03942932f, 0.15316527f, 0.07818751f, -0.10049503f, -0.12899987f, -0.13632371f, -0.10745942f, 
    0.03027872f, 0.05759720f, -0.19755481f, -0.05665889f, 0.01181887f, 0.16827956f, 0.35154951f, 0.04780407f, 
    0.04631046f, 0.10245263f, 0.00567302f, 0.19059806f, -0.14762442f, -0.13283555f, 0.04716414f, 0.00308703f, 
    0.10808504f, -0.04236787f, -0.02378140f, 0.09412316f, 0.19446769f, 0.13584165f, -0.07942300f, 0.01496969f, 
    0.02665399f, 0.18309857f, 0.15920620f, 0.24205227f, -0.03467894f, 0.07736331f, 0.01909217f, 0.15473802f, 
    -0.04019480f, -0.05435099f, 0.00198051f, -0.18984060f, -0.15867572f, -0.06164418f, -0.00577168f, -0.31901813f, 
    0.08635369f, -0.04905820f, 0.14360063f, 0.05320875f, 0.02354944f, 0.05327213f, 0.15017740f, 0.02714494f, 
    0.07547433f, 0.03312657f, -0.16041601f, 0.06740624f, -0.03521105f, -0.04344124f, -0.14576468f, -0.09108290f, 
    0.17877099f, 0.13814622f, 0.10492262f, 0.13907208f, -0.22143897f, 0.08607811f, 0.21893586f, 0.18098007f, 
    0.07925478f, 0.02505271f, 0.02430109f, -0.11715779f, 0.08133655f, 0.02897748f, 0.12387875f, -0.02413463f, 
    -0.01209189f, -0.20708992f, -0.21477015f, -0.16221720f, 0.02903365f, -0.13352937f, -0.22613227f, -0.02512436f, 
    0.03575044f, 0.05132677f, 0.05365168f, -0.07307623f, 0.23942037f, 0.04894319f, 0.02367356f, 0.08304991f, 
    0.09370609f, 0.08928849f, -0.05849998f, 0.08553751f, 0.04873203f, 0.08357526f, 0.00669481f, 0.17561053f, 
    -0.03078735f, 0.27313608f, 0.09598689f, 0.10569531f, 0.20405635f, 0.13667199f, 0.19162048f, 0.10538074f, 
    -0.06784589f, 0.01108732f, 0.09081128f, 0.18078820f, -0.08795669f, -0.06451882f, 0.01132498f, -0.14928459f, 
    0.09205779f, 0.04124153f, 0.02171925f, 0.07917166f, -0.00334984f, -0.09786490f, -0.08447882f, -0.05340879f, 
    -0.11735023f, -0.14375496f, 0.06267276f, -0.00578614f, 0.12660080f, 0.15080611f, 0.14746307f, 0.11032742f, 
    -0.06846280f, 0.14287373f, 0.09394331f, 0.08072443f, -0.10939083f, 0.10996375f, -0.28038254f, 0.14793441f, 
    -0.08507732f, 0.07401306f, 0.17786649f, -0.02347332f, 0.03378164f, 0.07654119f, -0.30305597f, 0.00528431f, 
    0.03198722f, -0.01794123f, 0.02716763f, -0.04167464f, -0.01669624f, -0.01256059f, 0.01170678f, 0.00570789f, 
    0.01310664f, 0.02358951f, 0.02563784f, 0.01931869f, -0.02055620f, -0.04493697f, -0.04209486f, -0.01778394f, 
    -0.04931881f, -0.00164768f, 0.03931452f, -0.02120114f, 0.00041356f, -0.00686783f, -0.01013666f, -0.04487351f, 
    -0.01787248f, 0.00855685f, 0.01791201f, -0.04391691f, -0.01195277f, -0.01101361f, -0.03526720f, -0.02924695f, 
    0.01485984f, 0.01637388f, 0.04261822f, -0.01584188f, 0.04096929f, 0.03148936f, 0.00063843f, 0.01032223f, 
    -0.01307966f, 0.00791326f, -0.01926209f, -0.01255358f, -0.00665292f, 0.01897535f, -0.01576244f, 0.01103752f, 
    0.01893496f, -0.03081354f, 0.04115995f, 0.00159655f, 0.01612409f, -0.05579278f, 0.03843096f, 0.00852099f, 
    -0.01932700f, -0.04153294f, -0.00108513f, 0.02333722f, -0.04424922f, -0.01396049f, -0.02216609f, -0.02276375f, 
    0.03171985f, 0.04355409f, -0.02280263f, -0.02044788f, -0.02564760f, -0.05258590f, -0.05479183f, -0.03379482f, 
    -0.01360434f, -0.03033551f, 0.04186891f, -0.02274316f, -0.00036012f, 0.03461161f, -0.01929371f, 0.04036942f, 
    -0.02384018f, -0.05758442f, -0.01650583f, -0.02338260f, -0.03019435f, -0.03000017f, 0.03420262f, 0.04060957f, 
    0.04129411f, -0.00224897f, -0.00421275f, -0.03046448f, -0.00098133f, -0.01119072f, -0.04186593f, 0.00578649f, 
    -0.00644125f, -0.03836484f, -0.01061352f, -0.00001596f, -0.03562699f, -0.00758562f, 0.02522806f, 0.00276046f, 
    0.00095906f, -0.02273077f, -0.02597455f, -0.04307589f, -0.02449337f, 0.01812425f, -0.03471142f, 0.04501018f, 
    0.00555814f, 0.00508698f, -0.00104328f, -0.02715872f, -0.05144637f, -0.05356790f, 0.00966840f, -0.01720732f, 
    0.03274369f, -0.05307269f, 0.00732106f, 0.01869067f, -0.05826035f, -0.04189058f, -0.01701917f, 0.00451959f, 
    0.00428317f, 0.03595877f, 0.01078040f, -0.03704357f, -0.02733310f, 0.02177780f, -0.00435333f, 0.04735022f, 
    -0.02186249f, -0.01977979f, 0.03787454f, 0.01617027f, 0.05609741f, 0.03934059f, -0.04812476f, -0.00553830f, 
    -0.03017266f, -0.02679341f, -0.02580054f, -0.03260641f, 0.01006017f, 0.03319868f, -0.02545636f, 0.01307681f, 
    0.00328250f, 0.00847199f, -0.00668956f, 0.01793998f, 0.02035151f, 0.00079341f, -0.01776017f, -0.00460713f, 
    -0.04946808f, -0.03023156f, 0.00686560f, -0.03216987f, 0.03040604f, -0.02015013f, -0.01461775f, -0.05133349f, 
    0.02823851f, -0.01752912f, -0.04392733f, -0.03267789f, 0.00824366f, 0.03659060f, -0.01554896f, -0.05282934f, 
    -0.02439902f, 0.01368932f, 0.00756711f, -0.01629618f, -0.05057394f, -0.00236681f, -0.01124083f, -0.04891840f, 
    0.01911301f, 0.00776917f, -0.00125390f, -0.00820130f, -0.01698033f, -0.05426677f, -0.02540388f, 0.00320162f, 
    -0.00983336f, 0.02996739f, 0.02743915f, 0.03863411f, 0.01523374f, -0.04565148f, -0.03769895f, -0.03090102f, 
    0.01485173f, -0.04193242f, 0.00206130f, -0.03660175f, 0.02384732f, -0.01095419f, 0.02273994f, 0.01798629f, 
    0.03559625f, -0.01717047f, -0.03348498f, -0.05847666f, -0.03595543f, -0.00819729f, -0.03304189f, 0.02486474f, 
    0.01363872f, -0.00038788f, 0.00370928f, -0.01264743f, 0.02442152f, -0.02105067f, -0.02271233f, -0.02938071f, 
    -0.01472191f, 0.04215593f, -0.01359290f, 0.01531617f, -0.03944361f, -0.00999952f, -0.05191592f, 0.01674345f, 
    -0.03115311f, -0.04348962f, -0.02473630f, -0.00306260f, -0.01103099f, 0.02603395f, -0.03538296f, -0.03364976f, 
    -0.02029134f, -0.00041234f, 0.00723545f, -0.02584083f, -0.04963594f, 0.02717852f, -0.05180074f, -0.01739270f, 
    0.01045383f, 0.03370517f, 0.00263741f, 0.00845943f, -0.02446574f, 0.02303289f, 0.00079936f, 0.02744664f, 
    0.00165007f, 0.02253719f, 0.02771010f, -0.03719552f, 0.00528334f, -0.04177851f, 0.00019509f, 0.00908382f, 
    -0.04020098f, -0.01812731f, -0.01494115f, -0.01239476f, 0.00746581f, 0.00184355f, -0.01199658f, 0.00757087f, 
    -0.00765964f, 0.00223014f, 0.01722002f, -0.00300582f, -0.02506082f, -0.01510662f, 0.02597794f, -0.03046237f, 
    -0.04190433f, -0.04682778f, -0.01514482f, -0.01518833f, -0.02258703f, 0.02463153f, 0.01403788f, 0.01512089f, 
    -0.04983323f, -0.01552230f, -0.01516455f, 0.01415437f, -0.01214548f, -0.01446315f, 0.04194415f, 0.02571278f, 
    0.01171035f, 0.00229291f, 0.03465460f, -0.03925785f, -0.00496137f, 0.02216486f, 0.03159620f, 0.00505103f, 
    -0.01244639f, 0.03415325f, 0.02369324f, -0.02448735f, -0.02568427f, -0.02073481f, -0.04253044f, 0.00820621f, 
    0.01596435f, -0.02150828f, -0.02585150f, 0.03629915f, -0.02531235f, 0.00825193f, -0.04188265f, 0.04367546f, 
    0.00110240f, -0.04182754f, -0.04117637f, 0.02503357f, 0.04503367f, -0.00874344f, 0.02513565f, -0.02841957f, 
    -0.02122248f, -0.02781587f, -0.02804499f, -0.02602051f, -0.03847453f, -0.02677631f, -0.00295285f, -0.05126026f, 
    0.03001484f, 0.01184644f, -0.03310351f, 0.02523275f, -0.04624417f, 0.02357685f, 0.02594096f, 0.00612996f, 
    -0.03945653f, 0.03298566f, -0.02957860f, 0.01924335f, 0.03030358f, 0.02113830f, 0.02798115f, 0.01917274f, 
    -0.01873170f, 0.01179052f, -0.04451994f, -0.02235469f, -0.04878303f, 0.01299644f, -0.05292776f, -0.05542067f, 
    -0.01360137f, -0.03827065f, 0.02680676f, 0.04171848f, -0.00177123f, 0.04012646f, 0.04274285f, -0.01981656f, 
    -0.01040263f, 0.01544163f, 0.00394005f, -0.04557852f, -0.00961080f, -0.03287101f, -0.04167763f, 0.03977678f, 
    -0.03595924f, -0.02055642f, -0.03876985f, -0.03615175f, -0.02410627f, -0.05824200f, -0.05061438f, 0.04932495f, 
    -0.14519557f, -0.22139740f, -0.16984047f, -0.08040048f, -0.02367689f, -0.02103452f, -0.00030107f, -0.06833415f, 
    -0.01718409f, 0.06103801f, -0.02129603f, 0.12715518f, 0.09826455f, 0.01442373f, -0.15427846f, 0.04288630f, 
    0.03186913f, 0.08899649f, -0.08201487f, 0.07929227f, -0.05688710f, -0.03984839f, 0.01914365f, -0.10063154f, 
    0.08451192f, 0.19047540f, 0.14934371f, 0.17180221f, 0.02649395f, 0.07689940f, 0.07355406f, 0.19402921f, 
    -0.08014214f, -0.09379010f, -0.01834323f, 0.01387060f, -0.08417944f, -0.00181454f, -0.18762748f, -0.01577371f, 
    -0.02755420f, 0.12743856f, -0.03440826f, 0.00838829f, -0.14914158f, -0.02641444f, -0.10748909f, -0.22415878f, 
    0.02813105f, 0.14069343f, 0.03152585f, 0.08203951f, -0.03404389f, 0.13485262f, -0.01415135f, -0.05553889f, 
    0.18846712f, -0.02086276f, -0.04731098f, 0.18503740f, 0.12266961f, 0.04652128f, 0.13857096f, -0.09294128f, 
    0.11546354f, -0.03040772f, 0.06802244f, -0.00203752f, 0.04424661f, 0.15819602f, 0.17576905f, 0.19293636f, 
    -0.02298343f, -0.15932281f, -0.13425088f, -0.11959086f, -0.04423703f, -0.02923158f, -0.00816731f, 0.01746788f, 
    -0.02023227f, 0.12522222f, -0.09082668f, -0.04751270f, 0.16428490f, -0.12675841f, 0.20344785f, -0.01827836f, 
    0.00498539f, 0.04879785f, 0.01945301f, -0.07769445f, 0.04632714f, -0.04350230f, 0.10378831f, 0.00636062f, 
    -0.00815892f, 0.26399955f, 0.24658482f, 0.08996293f, 0.05886469f, 0.06820557f, 0.03718008f, 0.06735408f, 
    0.06955403f, 0.01565206f, 0.03290204f, 0.03764214f, 0.14867310f, 0.19500031f, 0.03210188f, -0.01231418f, 
    -0.02821836f, -0.07122584f, 0.12912579f, 0.15663046f, -0.01145585f, -0.01603177f, -0.01375864f, 0.03980495f, 
    -0.08633184f, -0.00275963f, -0.01054247f, -0.06074360f, 0.09846838f, -0.05719030f, -0.03293398f, -0.00907949f, 
    -0.03232590f, 0.00815289f, 0.02875797f, 0.04940239f, 0.22055991f, 0.11766646f, 0.19804102f, 0.10380145f, 
    -0.01167856f, -0.07778536f, 0.00152945f, -0.12328001f, 0.08381949f, 0.07871429f, -0.04321455f, 0.08714182f, 
    0.11259315f, -0.25145414f, -0.20833042f, 0.01575419f, -0.02300169f, 0.00037130f, -0.09830604f, 0.02289269f, 
    0.15684962f, 0.08180369f, -0.00995306f, 0.00964924f, -0.08661093f, -0.07374428f, 0.07677693f, -0.05558464f, 
    -0.05442362f, 0.04471866f, -0.01694858f, 0.06083540f, -0.05823473f, -0.04071251f, -0.09621324f, 0.13402127f, 
    0.21419835f, -0.15264033f, 0.00082745f, 0.03717356f, 0.04073003f, 0.03806622f, 0.06517610f, 0.03016294f, 
    0.02748062f, 0.08110137f, -0.09488883f, 0.11952057f, 0.02305600f, -0.07719673f, -0.06038680f, 0.06665695f, 
    -0.17102295f, -0.08450551f, 0.01136973f, -0.06463838f, -0.02163600f, 0.06838150f, 0.02146838f, 0.09386818f, 
    -0.01282955f, -0.15927377f, 0.01429223f, 0.01280188f, 0.04163495f, 0.06960863f, 0.05323235f, -0.00787104f, 
    0.06214401f, 0.04209963f, -0.01354652f, 0.12841779f, -0.12381506f, -0.06946186f, -0.09212133f, -0.13161555f, 
    0.00357628f, 0.07181899f, 0.03636909f, -0.01245658f, -0.17339239f, -0.13333882f, 0.03304951f, -0.11198267f, 
    -0.11793567f, 0.26861167f, 0.20285471f, 0.04595529f, -0.23444982f, -0.11645187f, -0.05465518f, 0.05619740f, 
    -0.01741461f, 0.06110524f, 0.01806183f, -0.02720644f, -0.00698050f, 0.09199128f, -0.05948110f, -0.27332082f, 
    -0.01840965f, -0.04341152f, 0.02186700f, -0.12066533f, -0.05655532f, -0.05611012f, 0.10741802f, -0.06864309f, 
    0.15831231f, 0.02555258f, 0.02722275f, 0.02446535f, -0.08740455f, 0.06735987f, 0.07571860f, -0.00480111f, 
    -0.02160825f, 0.02835352f, -0.07887533f, 0.04324095f, -0.06392184f, -0.09308244f, -0.02882571f, -0.08031024f, 
    -0.00681779f, 0.00567752f, 0.17125593f, -0.14327495f, -0.08608294f, 0.10930173f, -0.12538658f, 0.13657477f, 
    -0.13914181f, 0.19915184f, 0.19684723f, -0.01048418f, 0.11709179f, -0.03654268f, -0.01435008f, -0.09506505f, 
    0.10142431f, 0.06374370f, 0.15568526f, 0.04506074f, -0.03518894f, 0.04056006f, 0.16642548f, -0.19698608f, 
    -0.06204426f, 0.02402040f, 0.10155767f, -0.04395822f, -0.00360858f, -0.00332904f, 0.00263006f, -0.07181841f, 
    0.12639502f, -0.17899741f, 0.21153526f, 0.11822376f, -0.04317013f, -0.00040924f, 0.01062716f, 0.01558496f, 
    0.02204650f, -0.00692872f, 0.08956884f, -0.10419711f, -0.55996144f, 0.26815000f, -0.12242121f, 0.19164769f, 
    -0.13576905f, 0.10566536f, 0.05122608f, -0.10349040f, -0.02028408f, -0.04434645f, -0.05262775f, -0.05570274f, 
    0.21925105f, 0.10115653f, 0.24772073f, 0.10670282f, 0.07542945f, -0.01276128f, 0.01392940f, -0.16324134f, 
    0.06839677f, 0.09485199f, -0.01922003f, 0.05040181f, 0.05250262f, 0.17320593f, 0.00945508f, -0.18657294f, 
    -0.04761865f, 0.08432741f, -0.07592460f, 0.09088056f, 0.03183317f, -0.03339881f, 0.09594811f, -0.10985368f, 
    0.23677889f, 0.24594919f, 0.26222542f, 0.23647131f, -0.02974952f, 0.08730391f, 0.07572495f, 0.02140657f, 
    -0.00623358f, 0.05681197f, -0.01339777f, 0.01685683f, 0.16142118f, 0.24462283f, 0.14630023f, 0.23879737f, 
    -0.12326764f, 0.08194575f, 0.05037379f, 0.00044621f, -0.01598664f, 0.07073750f, 0.17281595f, -0.02495702f, 
    -0.19564945f, -0.07258287f, 0.12971336f, -0.04005462f, -0.06295503f, 0.02810116f, -0.06650265f, 0.13470557f, 
    -0.06963507f, 0.01497006f, -0.00163015f, -0.16500798f, 0.03663648f, -0.20200241f, -0.04877242f, -0.03296410f, 
    0.06880596f, 0.00558285f, 0.02942681f, -0.05943009f, 0.00427518f, 0.00083414f, -0.03913314f, 0.07237086f, 
    -0.04542094f, -0.02180898f, -0.00642383f, -0.05379650f, 0.00782206f, -0.00392870f, 0.05828033f, -0.01169293f, 
    0.02619024f, 0.00839237f, -0.03965183f, 0.11096410f, -0.03065516f, 0.08392349f, 0.03830219f, 0.09383569f, 
    0.01017776f, 0.05313645f, -0.20656770f, 0.00342681f, 0.00287194f, 0.04377123f, 0.09564054f, 0.08892158f, 
    0.24612914f, 0.04475090f, 0.00106115f, -0.04364308f, 0.09592285f, 0.11330897f, 0.19002272f, -0.03826994f, 
    -0.02010935f, -0.10039123f, 0.08931249f, -0.07423066f, -0.06960111f, -0.01414506f, 0.15885657f, 0.01859793f, 
    0.01318439f, 0.02318300f, -0.03855534f, 0.06896574f, 0.05966242f, 0.12425140f, 0.10809862f, 0.10663425f, 
    0.16267750f, 0.13848819f, 0.04449619f, -0.01826806f, 0.20020418f, 0.08159312f, 0.09996829f, 0.07468355f, 
    -0.13509424f, -0.04172536f, -0.14896640f, -0.07515176f, 0.11861067f, 0.11296304f, -0.02124100f, 0.06020871f, 
    0.08117604f, -0.07778107f, 0.01810042f, -0.03464231f, 0.04966878f, 0.06442248f, -0.01843989f, -0.09267081f, 
    -0.05162916f, 0.10115292f, -0.01823932f, 0.09163320f, 0.03548849f, 0.03954291f, 0.01479678f, -0.08673684f, 
    -0.01697889f, 0.04513177f, 0.09882285f, 0.18262622f, 0.44655114f, 0.11727295f, 0.17540061f, -0.09607051f, 
    -0.21553347f, -0.17060223f, 0.07105923f, 0.02783205f, 0.01269674f, 0.00297416f, 0.02709587f, 0.00076426f, 
    -0.01115626f, 0.09754550f, 0.05736211f, -0.10766230f, 0.06340770f, 0.01434622f, -0.04487541f, 0.13261594f, 
    0.03400296f, -0.01933394f, -0.06168924f, -0.05318398f, 0.06687392f, 0.24237713f, -0.03515843f, -0.05082333f, 
    0.10654157f, 0.10492960f, 0.02315077f, -0.03784715f, -0.00689330f, 0.02304470f, 0.07387030f, 0.07815217f, 
    -0.08793581f, -0.05960294f, 0.00083402f, 0.05591011f, 0.15543710f, -0.04345789f, -0.00894089f, 0.01662167f, 
    -0.06895079f, -0.01069107f, -0.06995749f, -0.03302089f, 0.05934525f, 0.03515097f, -0.14927630f, -0.04203165f, 
    -0.02041941f, 0.08803046f, 0.12925227f, 0.05180022f, -0.02717476f, 0.00543677f, -0.11274896f, 0.11476471f, 
    -0.02789368f, -0.18616432f, -0.11261111f, -0.01598905f, -0.07328515f, 0.03089086f, -0.04342736f, 0.00654539f, 
    0.00915437f, 0.00568011f, 0.05213181f, -0.05039646f, 0.06728717f, -0.26628566f, -0.22956297f, -0.01854714f, 
    0.01720602f, 0.06784081f, 0.07148830f, 0.10474863f, 0.13058782f, -0.00768693f, -0.11870161f, 0.03008115f, 
    0.11874046f, 0.18333131f, -0.23834281f, -0.05500085f, -0.13094246f, 0.02217802f, 0.01282484f, 0.11615325f, 
    -0.03992230f, -0.08668101f, 0.17677580f, -0.06693847f, -0.03210572f, 0.00563620f, 0.00996043f, 0.06980124f, 
    0.13327171f, 0.07938565f, -0.08915950f, -0.04718163f, 0.03044103f, 0.00974322f, 0.16256890f, 0.04291607f, 
    -0.06196993f, -0.06793649f, -0.26961586f, 0.17717607f, 0.03017829f, 0.10729431f, 0.00465536f, 0.05560798f, 
    0.06741957f, 0.00637509f, 0.04222898f, -0.15606059f, -0.11527903f, -0.14049256f, -0.15698394f, 0.03334849f, 
    -0.03643616f, 0.01516632f, 0.04546791f, -0.01024848f, 0.00810503f, -0.02773616f, 0.08662257f, 0.01644558f, 
    0.07321932f, 0.17191002f, 0.08951454f, -0.04974332f, -0.06039618f, 0.00541457f, -0.06250297f, 0.00221469f, 
    -0.03741163f, -0.00998929f, 0.08924129f, -0.08594792f, -0.02372753f, 0.07134884f, 0.08860300f, 0.25271687f, 
    0.00378021f, 0.00091556f, -0.03708143f, -0.03345621f, -0.01957281f, 0.07240068f, 0.04216868f, -0.08209264f, 
    0.09196538f, 0.23588231f, -0.17692496f, -0.02573148f, -0.12075342f, 0.11643333f, 0.19138345f, -0.19358955f, 
    0.02629989f, -0.04366537f, -0.04602512f, 0.11100899f, -0.13040425f, 0.16718002f, 0.03163554f, 0.04929631f, 
    0.09164726f, -0.14336739f, 0.04824428f, 0.18494962f, 0.16856606f, 0.03412228f, -0.11891168f, 0.09946746f, 
    0.14380208f, -0.02712616f, 0.14303632f, 0.10143044f, 0.13201691f, -0.03506944f, 0.00692895f, 0.03811306f, 
    -0.08423935f, -0.00387667f, 0.01756101f, -0.04413502f, -0.23306468f, -0.20724344f, -0.07601477f, 0.07260975f, 
    0.13719003f, 0.16730022f, -0.00295565f, 0.03599349f, -0.08637456f, -0.04708207f, -0.03254372f, -0.03087584f, 
    0.03871417f, -0.36664206f, -0.21754186f, -0.14585094f, -0.05318872f, 0.01561010f, 0.08026525f, 0.07617003f, 
    0.24867687f, 0.08471747f, -0.07072305f, 0.04657200f, 0.23793894f, 0.07861567f, 0.28362030f, -0.26128814f, 
    0.01502780f, -0.06782430f, 0.09695652f, 0.11135750f, 0.04820775f, 0.06500201f, 0.08322932f, 0.04741159f, 
    -0.05730765f, -0.17103049f, -0.06140176f, -0.07536995f, 0.11303809f, 0.09710672f, 0.19489308f, 0.04359528f, 
    -0.00314058f, -0.16756903f, -0.12304478f, -0.06315285f, 0.18720299f, 0.15199637f, 0.11502837f, -0.13492225f, 
    0.08985380f, 0.06235202f, -0.10063647f, 0.05571571f, -0.00235679f, -0.00982795f, -0.00868277f, 0.01780803f, 
    0.35192248f, 0.29268458f, 0.19703378f, -0.03753785f, 0.12470552f, 0.10204899f, 0.09416227f, 0.03161016f, 
    0.03429869f, 0.00947459f, 0.04034522f, 0.06085172f, 0.02429818f, -0.01079296f, -0.06171425f, -0.12478004f, 
    0.12860407f, 0.11441924f, 0.14469039f, -0.01281245f, 0.03966492f, -0.13172939f, -0.10552755f, -0.10642499f, 
    0.04098857f, -0.04654522f, 0.07113182f, 0.10433625f, -0.02041641f, 0.03237800f, 0.04482740f, -0.06574093f, 
    0.02902039f, 0.08450416f, -0.01782292f, 0.05824980f, -0.08861334f, -0.08232870f, -0.04549870f, 0.10701387f, 
    0.06384198f, 0.03933722f, -0.02999731f, 0.01205868f, -0.00401187f, 0.15838759f, 0.00081591f, 0.09621437f, 
    -0.02404865f, -0.04338727f, 0.03319421f, -0.05468966f, 0.01277676f, -0.03371748f, -0.04470831f, -0.04037246f, 
    0.02082835f, 0.04203809f, 0.01855222f, -0.04440875f, -0.04231415f, -0.00282775f, 0.00668280f, 0.01772868f, 
    -0.04338829f, 0.02874521f, 0.00832158f, 0.00171470f, -0.05167642f, 0.01985802f, -0.04378552f, -0.00618244f, 
    0.04211063f, -0.03137151f, 0.03475885f, -0.04901767f, 0.03876757f, 0.02416814f, -0.01218479f, 0.00851178f, 
    0.01536392f, -0.03256452f, -0.03930206f, -0.05387004f, -0.04131361f, -0.02714068f, 0.02174879f, 0.02303963f, 
    -0.05395172f, 0.02387975f, -0.03188453f, -0.04614346f, -0.03291772f, 0.00186346f, 0.03043654f, -0.04152537f, 
    0.02416432f, -0.04848106f, 0.02332247f, 0.04533926f, 0.01616362f, -0.01644205f, -0.03598359f, -0.05130645f, 
    0.04569678f, 0.04891098f, -0.05261063f, -0.03941471f, 0.02171159f, -0.01438066f, 0.03380777f, 0.03473512f, 
    0.00820092f, 0.04403355f, -0.04587000f, -0.04239565f, -0.03169390f, -0.02177334f, -0.03190285f, 0.00325804f, 
    -0.00573174f, 0.00582267f, -0.01034425f, -0.05277102f, -0.02132804f, 0.01930960f, -0.04834628f, -0.02317750f, 
    -0.00519875f, -0.01024576f, 0.01634833f, -0.04795341f, -0.04137957f, -0.03872829f, -0.05201723f, 0.00459606f, 
    -0.01195392f, -0.02423279f, 0.00168875f, -0.04240462f, -0.00129415f, -0.03796766f, -0.03975498f, -0.00958371f, 
    -0.04775920f, -0.01886711f, -0.01593616f, -0.00458970f, -0.01955449f, 0.01421963f, -0.05511509f, 0.02778112f, 
    -0.02691034f, -0.03360440f, -0.01648150f, 0.03158127f, 0.01775307f, -0.02115079f, -0.03095627f, 0.02236328f, 
    0.01087112f, 0.01656239f, -0.02002991f, -0.04362981f, 0.03733524f, -0.05195841f, -0.00757635f, -0.05593137f, 
    -0.02693959f, 0.02163462f, 0.00472679f, -0.05622352f, 0.02327397f, 0.02722734f, -0.02152163f, 0.02888018f, 
    0.00318615f, 0.00266965f, 0.01094211f, 0.00617606f, 0.00844266f, 0.01012498f, 0.04063034f, 0.02318142f, 
    -0.04250609f, 0.02114734f, -0.03958968f, 0.02480996f, -0.05469369f, -0.04663252f, -0.04753336f, 0.02647425f, 
    0.00640535f, 0.01769694f, 0.01044028f, -0.00941989f, -0.03155971f, -0.01532582f, 0.00198193f, 0.01453224f, 
    0.01633431f, -0.05554531f, 0.00281291f, -0.03090280f, -0.01627812f, 0.01006236f, -0.02044570f, 0.00234730f, 
    -0.00153147f, 0.04257773f, 0.02921285f, 0.03226586f, -0.04730539f, -0.00960829f, -0.01678648f, 0.02009211f, 
    -0.03003635f, 0.00600497f, 0.00685063f, -0.05001817f, 0.02864068f, 0.04390242f, -0.00805308f, 0.00434044f, 
    0.01217455f, -0.00150337f, -0.00080404f, -0.00467828f, -0.01337383f, -0.00905202f, 0.00385060f, -0.01282463f, 
    -0.03071696f, -0.04421951f, -0.02797264f, -0.01076367f, 0.03013672f, -0.03848555f, 0.00050438f, 0.03069638f, 
    -0.04583095f, 0.00113100f, 0.02329869f, -0.01878272f, 0.03413291f, 0.02791286f, 0.00900302f, -0.00195634f, 
    -0.04665454f, 0.00032958f, -0.04486961f, 0.03836837f, 0.04150278f, -0.03760212f, -0.01085661f, -0.00751527f, 
    -0.04015892f, 0.02706921f, 0.04276819f, 0.01895988f, 0.04155382f, 0.02404681f, 0.03708291f, -0.04716408f, 
    0.04478059f, 0.00147974f, 0.01976031f, -0.04285529f, -0.05304105f, -0.04480585f, 0.03009510f, -0.04327507f, 
    0.03013546f, 0.00606227f, 0.03690302f, -0.04701533f, 0.00389366f, -0.05476910f, 0.04383175f, -0.04328592f, 
    0.01004095f, 0.02780613f, -0.04810984f, 0.03176557f, 0.00456851f, 0.02459059f, -0.02045774f, -0.01332717f, 
    -0.00378273f, -0.01544881f, 0.00337272f, 0.03216034f, -0.00793664f, -0.00164398f, -0.00870889f, -0.01332786f, 
    -0.03548344f, 0.00131286f, -0.05084653f, -0.01602716f, -0.03285129f, 0.04132494f, 0.03622412f, 0.04434720f, 
    0.03074615f, -0.01644630f, 0.03175468f, 0.02621559f, 0.00808016f, 0.00601983f, 0.01611081f, 0.00069307f, 
    -0.05196950f, -0.05308129f, -0.02110061f, -0.02605567f, 0.00579183f, 0.03040920f, -0.02169202f, 0.04264707f, 
    0.04244887f, 0.00837581f, -0.02828429f, -0.01985212f, -0.05083101f, -0.01627114f, 0.04257158f, -0.02927917f, 
    0.02502631f, -0.02873210f, 0.03344427f, 0.03484965f, 0.03082790f, 0.01334093f, 0.04007619f, -0.05311420f, 
    0.00318562f, -0.05157299f, -0.04397969f, -0.00817113f, -0.05387439f, -0.03929819f, -0.02336004f, -0.02796792f, 
    -0.05427084f, 0.01139499f, 0.00122277f, 0.02727987f, -0.00118652f, 0.01980646f, 0.04151678f, -0.02900160f, 
    0.00815165f, 0.01096623f, 0.04031071f, 0.02796995f, -0.03904388f, 0.00218727f, 0.04210553f, -0.02113235f, 
    -0.05616415f, 0.02806081f, -0.04558624f, -0.01401933f, -0.00407387f, -0.02419463f, -0.02090164f, 0.02886190f, 
    -0.03903633f, 0.00151127f, -0.02463979f, 0.02370565f, 0.02317452f, -0.01251203f, -0.02794415f, 0.01702017f, 
    0.03949835f, -0.00416104f, -0.02333520f, 0.04253510f, -0.02702080f, 0.04110519f, 0.03583333f, 0.01468295f, 
    0.01577080f, 0.03947617f, -0.01488413f, -0.00319036f, -0.03452212f, -0.04751350f, -0.01977004f, 0.00119978f, 
    0.04523760f, -0.01879998f, -0.04165815f, 0.01319850f, -0.03893541f, -0.01478809f, 0.03309105f, -0.05027823f, 
    0.01583565f, -0.01908705f, -0.04760038f, -0.01394710f, -0.01847474f, 0.01177498f, -0.02655671f, -0.03337878f, 
    -0.03745241f, -0.02326150f, -0.01493079f, -0.03496202f, 0.00916705f, 0.01696004f, 0.01707414f, -0.02042466f, 
    -0.05358275f, -0.03815423f, -0.02691972f, -0.05594050f, 0.04601062f, -0.02326946f, -0.02369108f, 0.01612515f, 
    -0.02466501f, -0.03564807f, -0.05480248f, 0.00612720f, 0.02480263f, -0.02259051f, -0.01874974f, -0.03067145f, 
    -0.06020306f, -0.15033905f, 0.02173444f, -0.12587497f, -0.18361315f, -0.19403915f, 0.01753426f, -0.02116097f, 
    0.04046148f, 0.20233251f, 0.06352130f, 0.14211714f, -0.20883113f, 0.22988994f, -0.18383397f, 0.19485721f, 
    0.12342025f, -0.13961188f, -0.04216636f, -0.13063927f, -0.19303113f, -0.22928286f, -0.27403754f, -0.50416172f, 
    0.21339318f, 0.16532886f, 0.05450264f, 0.09266093f, 0.02366075f, -0.03483744f, 0.11989561f, 0.02752771f, 
    -0.08049283f, -0.04621436f, -0.08748212f, 0.03515621f, -0.41727400f, -0.07349084f, -0.22823413f, -0.04813494f, 
    -0.08776509f, -0.11721080f, -0.21974914f, -0.32422388f, -0.15202034f, -0.05590318f, -0.15066156f, -0.17007083f, 
    -0.09018851f, 0.16897441f, -0.34184554f, 0.01805423f, -0.07400636f, -0.06065782f, 0.10180198f, 0.09151405f, 
    0.08814863f, 0.15643078f, -0.02658378f, 0.15506117f, 0.18888639f, 0.10425606f, 0.05733608f, 0.09705086f, 
    0.05435116f, -0.07578753f, 0.05199683f, 0.09839468f, 0.25479749f, 0.07035065f, 0.23784761f, 0.27857378f, 
    -0.11904933f, -0.12958337f, 0.00903305f, 0.23199320f, -0.18649733f, 0.04004559f, -0.11306183f, -0.10220326f, 
    -0.01191721f, 0.09051636f, 0.03256892f, 0.18082756f, 0.15434708f, 0.18072441f, -0.03006508f, 0.09841223f, 
    0.07253917f, 0.06149495f, 0.17992647f, -0.13629182f, -0.12419379f, 0.13099414f, -0.02669328f, 0.16300379f, 
    0.14067169f, -0.03347153f, 0.03020828f, 0.17481202f, 0.07139560f, 0.08982894f, -0.05555118f, 0.03320510f, 
    0.02180958f, -0.10084259f, 0.08558989f, 0.12655514f, 0.09328539f, 0.08223353f, 0.09433676f, 0.15713577f, 
    0.12451734f, 0.06246966f, 0.03527099f, 0.00600616f, -0.10182352f, 0.02640613f, -0.00684666f, -0.18310864f, 
    -0.27359763f, -0.17629798f, -0.27830708f, 0.19903037f, -0.16050096f, -0.12446559f, -0.15198517f, -0.00758679f, 
    0.15643471f, -0.03192223f, 0.09789351f, 0.25839940f, -0.00324365f, -0.06125572f, -0.34041575f, 0.02710884f, 
    -0.00930371f, 0.02451302f, 0.03427566f, -0.06805708f, -0.09019211f, 0.06628992f, 0.08566194f, 0.21383958f, 
    -0.14587957f, -0.07828785f, -0.24471416f, -0.09838138f, -0.05683133f, 0.00427873f, 0.09867305f, -0.19249031f, 
    0.04026011f, 0.12804021f, 0.07861321f, 0.09263946f, -0.26574805f, -0.07672618f, 0.05746458f, 0.21010303f, 
    -0.07776458f, 0.08805795f, -0.01745128f, -0.09043727f, -0.03764070f, -0.00390069f, 0.12152748f, 0.38045326f, 
    -0.14290135f, 0.19852053f, 0.01816088f, 0.39511579f, 0.02081182f, -0.03343890f, -0.00032080f, -0.00913033f, 
    -0.03810614f, 0.09054498f, 0.05402660f, 0.15041037f, -0.06509627f, 0.11983398f, 0.15150470f, 0.02872694f, 
    -0.00936418f, -0.06657341f, 0.03110067f, 0.04247968f, -0.17972392f, -0.08691442f, -0.01297643f, -0.39467341f, 
    0.13482153f, 0.12568828f, -0.12809324f, 0.36483634f, 0.04030486f, -0.07995608f, -0.00215339f, -0.14829800f, 
    0.16655676f, 0.07649203f, 0.07949474f, 0.15577823f, -0.16679703f, -0.04321882f, -0.17819461f, 0.32209060f, 
    0.08533644f, -0.09575069f, -0.09253712f, -0.24287550f, 0.01555812f, -0.12010297f, -0.16200513f, 0.05769597f, 
    0.07648379f, -0.10942873f, 0.20121016f, 0.23671082f, -0.09877754f, 0.05075337f, 0.01664983f, 0.12767127f, 
    -0.01139868f, 0.13623939f, 0.01089888f, -0.04564999f, -0.00951099f, 0.10072517f, 0.31870994f, 0.33146212f, 
    0.04339499f, -0.22507948f, 0.03514856f, -0.12804411f, -0.01405452f, -0.06492482f, 0.01718486f, 0.05736311f, 
    0.10199168f, -0.08128665f, -0.03752837f, 0.04517519f, 0.08489945f, -0.00728950f, -0.20605275f, 0.07990170f, 
    -0.04700832f, -0.10648675f, 0.02970345f, -0.30818808f, 0.14284082f, -0.12050248f, -0.21734126f, -0.08093154f, 
    -0.06205330f, -0.08114309f, 0.05938794f, -0.08163562f, -0.09675137f, -0.12856783f, 0.02279609f, -0.09303286f, 
    0.14499196f, 0.07063854f, 0.11899996f, 0.02307929f, 0.04347686f, -0.08777386f, 0.11116846f, 0.04052291f, 
    -0.02967394f, -0.04508028f, -0.11209784f, 0.11863179f, 0.01335798f, -0.04639509f, -0.02989944f, 0.32780027f, 
    -0.06758586f, 0.01609018f, -0.18385428f, -0.13986099f, 0.04503792f, -0.06771486f, 0.00444157f, -0.00447004f, 
    -0.02109497f, -0.07533856f, -0.08957459f, -0.14791217f, -0.11953656f, 0.05820225f, 0.17026439f, -0.21369174f, 
    -0.06116566f, -0.06764706f, -0.06033917f, 0.00719798f, 0.10496715f, 0.05559330f, 0.30598664f, -0.27698821f, 
    -0.04652227f, 0.04928898f, -0.17936599f, -0.16363348f, -0.07002735f, -0.03092341f, 0.07689771f, 0.15112188f, 
    -0.03831534f, -0.10644006f, -0.09647377f, 0.02439028f, -0.04073570f, 0.17792568f, -0.00115156f, -0.09618355f, 
    0.09102921f, -0.04271105f, 0.03746170f, 0.25438479f, 0.02287357f, 0.14550403f, 0.16491087f, 0.12331188f, 
    0.05114169f, 0.02662626f, 0.10849962f, 0.19304711f, -0.01255029f, 0.06403110f, -0.07959579f, -0.05783338f, 
    0.20136245f, -0.03229365f, 0.07960447f, -0.09423960f, 0.07749478f, 0.13990986f, 0.11040574f, 0.07712042f, 
    -0.03128984f, -0.00800003f, 0.07445605f, -0.14556076f, 0.24124141f, -0.07082045f, 0.09254043f, 0.20284799f, 
    -0.05845170f, -0.01848675f, -0.03251056f, -0.07708610f, 0.03189589f, -0.08724391f, -0.00037565f, 0.13260064f, 
    0.05269310f, -0.23527338f, 0.01609359f, -0.25339469f, -0.06075050f, 0.03872956f, -0.02300692f, 0.01808424f, 
    -0.08640765f, -0.10541856f, -0.21126465f, -0.22747114f, 0.29158467f, -0.11348569f, 0.26550657f, 0.25276020f, 
    0.08770546f, -0.03167329f, -0.30766302f, 0.02539347f, 0.01860948f, -0.15250969f, 0.25709578f, 0.05876935f, 
    -0.07640297f, -0.12339818f, -0.07371286f, -0.02098222f, -0.01980663f, -0.02019232f, -0.10166299f, 0.00210899f, 
    0.08525576f, -0.03272356f, -0.05698427f, 0.04932876f, 0.12287170f, -0.04276063f, -0.10249938f, -0.01200042f, 
    0.00203041f, 0.22974417f, 0.04586709f, 0.15362370f, 0.00783756f, 0.02213959f, -0.07276975f, -0.03923978f, 
    -0.00350694f, -0.05393326f, 0.25911105f, 0.03251976f, -0.08735266f, 0.02093654f, -0.01446689f, -0.00317676f, 
    0.10977934f, -0.11775455f, -0.03759854f, -0.01944430f, -0.04425520f, -0.00951921f, 0.13920280f, 0.01030555f, 
    -0.00209031f, -0.00812472f, -0.01077409f, 0.04450083f, 0.01537704f, 0.04252544f, 0.07137737f, 0.03226826f, 
    -0.15189233f, -0.04513989f, -0.03912819f, -0.02208335f, -0.04005583f, 0.00406935f, -0.04262065f, 0.19941731f, 
    -0.04682358f, 0.01256951f, 0.09565414f, -0.03073360f, -0.02636939f, -0.00754970f, 0.25672838f, 0.08062494f, 
    -0.00719607f, 0.03243791f, -0.00047952f, -0.04326648f, 0.03399950f, -0.01028147f, 0.12290081f, 0.06627218f, 
    0.09203240f, -0.11414129f, -0.05476177f, -0.01354826f, -0.05691436f, -0.02035004f, -0.11892301f, -0.06023077f, 
    -0.00717576f, -0.00011126f, 0.03161296f, -0.02556224f, -0.20620537f, -0.33473319f, 0.15665956f, 0.01575928f, 
    -0.08945525f, 0.14344923f, -0.04150970f, 0.17254254f, 0.01869053f, 0.09402867f, 0.07631450f, -0.06818144f, 
    -0.17377420f, 0.01449679f, 0.05604294f, -0.11127732f, 0.04813486f, -0.00828388f, 0.01084565f, -0.00340959f, 
    0.13049708f, 0.09251009f, 0.02279926f, 0.06153237f, -0.01021684f, 0.23313890f, 0.12457947f, 0.07996673f, 
    0.01314307f, -0.03866645f, 0.12154364f, -0.02327166f, -0.02415007f, -0.15866944f, -0.06221067f, -0.07211398f, 
    0.18660158f, -0.00496618f, -0.15245543f, 0.01503327f, 0.06304180f, -0.08582301f, -0.02339540f, -0.11406132f, 
    0.07776450f, 0.03321980f, 0.12088210f, 0.09193900f, -0.53364909f, -0.09946667f, 0.23625422f, 0.15006930f, 
    -0.10672486f, 0.07265088f, -0.14243931f, -0.00476793f, -0.05533086f, 0.04917706f, 0.02851830f, 0.02104441f, 
    -0.01307154f, -0.19375570f, 0.05686055f, 0.05762719f, -0.08522868f, 0.03220207f, -0.08212782f, 0.03060197f, 
    0.09641337f, 0.01375068f, 0.16084772f, 0.04690920f, 0.20757659f, -0.02498126f, 0.04175589f, -0.10139944f, 
    0.08077352f, -0.05830694f, -0.02177679f, 0.04929565f, 0.03029896f, -0.12214355f, 0.00210569f, -0.04839890f, 
    0.04573224f, 0.06127090f, -0.05873574f, -0.17572469f, 0.14492683f, 0.14111312f, -0.01328542f, 0.01953637f, 
    0.08349674f, 0.03576953f, 0.02422502f, 0.02915971f, 0.07907109f, -0.15646242f, -0.07805954f, -0.05495791f, 
    0.03584475f, 0.06552502f, 0.01767508f, 0.07562027f, -0.09967514f, -0.00901452f, -0.04774889f, 0.00086918f, 
    0.04517487f, 0.15495892f, 0.06626974f, 0.01484749f, 0.00296849f, 0.06706239f, 0.10650432f, -0.10295086f, 
    0.00891901f, 0.00428922f, 0.00132390f, 0.08121713f, -0.01007514f, 0.26298937f, -0.13363528f, -0.16623953f, 
    -0.02780845f, -0.03037392f, 0.01511607f, -0.08739182f, -0.00514151f, 0.11317813f, 0.14434485f, 0.00490731f, 
    0.06349655f, -0.03074379f, 0.31442058f, 0.00210146f, -0.02412060f, 0.00047623f, 0.05080663f, -0.08604986f, 
    -0.01695822f, -0.11018793f, 0.09478164f, -0.09781165f, 0.23704654f, -0.05274567f, -0.08151853f, 0.13295469f, 
    0.00456661f, -0.01483638f, 0.03289699f, 0.04507411f, 0.00088751f, -0.00427562f, -0.07987124f, -0.05325377f, 
    -0.01613123f, -0.00766741f, 0.01073762f, -0.11443631f, -0.07399404f, 0.23462507f, 0.09823490f, 0.11494667f, 
    0.02680414f, -0.10525275f, -0.06962267f, 0.01569862f, -0.10764159f, -0.02889532f, -0.08194835f, 0.22506899f, 
    -0.00759014f, -0.12808353f, 0.02000892f, 0.02259126f, 0.13933152f, 0.01147178f, -0.03760043f, 0.06659026f, 
    -0.02572883f, 0.07386953f, 0.26572680f, 0.04344299f, 0.03701092f, 0.07339145f, 0.06651809f, 0.04598815f, 
    0.14059363f, 0.13291650f, 0.15110888f, 0.01845625f, -0.06115732f, 0.19223459f, 0.18376736f, -0.08214558f, 
    0.02260496f, -0.04461903f, 0.14185816f, 0.03564310f, 0.10245702f, 0.00472096f, -0.08918874f, -0.03305610f, 
    -0.11262897f, -0.16400348f, 0.13931002f, 0.27428013f, 0.01927103f, -0.08628351f, -0.08809148f, -0.04669691f, 
    0.09249172f, 0.03612785f, -0.00675756f, 0.08945490f, -0.61277050f, -0.17183562f, 0.08392607f, 0.51040608f, 
    -0.05573457f, 0.06203587f, 0.02079184f, 0.06440952f, 0.04610591f, 0.10879771f, 0.13750623f, 0.03253278f, 
    -0.13989602f, 0.02181534f, 0.06923214f, 0.02461646f, -0.00032478f, -0.12502432f, -0.18140651f, 0.10672098f, 
    -0.01516027f, -0.01574944f, -0.00333225f, -0.00154462f, 0.04042589f, 0.06608316f, -0.00321632f, -0.04280726f, 
    0.00022538f, 0.11695186f, 0.03684249f, 0.11453829f, 0.05490717f, 0.14158650f, -0.03870301f, 0.01440996f, 
    -0.07505544f, 0.21610022f, 0.31270507f, 0.10290115f, 0.00328221f, 0.07971957f, -0.04483852f, -0.01632134f, 
    -0.00952243f, -0.00641519f, -0.05406997f, 0.01826717f, -0.08354450f, 0.06848767f, 0.11109802f, 0.00968621f, 
    -0.06787449f, 0.01329221f, -0.01010573f, 0.09250187f, 0.08111067f, -0.02117746f, 0.01224372f, -0.09503207f, 
    -0.08737390f, -0.19760182f, 0.12959729f, 0.09075771f, 0.03353325f, 0.12090882f, 0.06942571f, 0.23418175f, 
    -0.08932538f, 0.02583040f, 0.01312699f, -0.01004131f, 0.30587959f, -0.10071818f, -0.18956657f, -0.08514225f, 
    -0.01751715f, 0.02482734f, 0.06794401f, -0.04807570f, 0.10968844f, 0.00091511f, -0.06404667f, 0.02294152f, 
    0.10794551f, 0.03454850f, 0.01308527f, 0.15087205f, -0.03980388f, -0.05892517f, -0.00664000f, -0.03228047f, 
    0.11656773f, 0.05622334f, 0.10238066f, 0.08220324f, 0.12505099f, 0.00433549f, -0.04696405f, 0.04249405f, 
    -0.02506865f, -0.06200075f, -0.05883606f, -0.12984356f, -0.08756682f, -0.00335887f, -0.10714222f, -0.01626308f, 
    -0.14147662f, -0.00076958f, -0.26325598f, 0.12027071f, 0.12970932f, 0.05969834f, 0.06063879f, 0.20807163f, 
    -0.01486317f, 0.05082281f, -0.15999590f, 0.06242669f, 0.24277875f, 0.06995038f, 0.02941322f, 0.06757955f, 
    0.01795117f, 0.05895809f, -0.06102635f, -0.05207564f, -0.02803293f, 0.01149109f, -0.00793007f, -0.12095673f, 
    -0.11046872f, -0.12263921f, -0.00506249f, 0.01428958f, -0.04341754f, -0.03251213f, 0.01266864f, -0.09727971f, 
    0.19599715f, -0.01368944f, 0.12897038f, 0.06012052f, -0.12785503f, 0.07609808f, -0.20570913f, 0.01556244f, 
    0.03633640f, -0.09987939f, 0.03400908f, 0.12679961f, -0.12026839f, -0.01009541f, -0.03990593f, 0.03596188f, 
    0.03602139f, 0.14612271f, 0.09133921f, 0.14264193f, -0.07698943f, -0.09407575f, -0.05171919f, -0.02303498f, 
    0.06750850f, -0.02247634f, -0.17410758f, 0.16384615f, 0.32330212f, 0.09874074f, -0.13224788f, -0.13325649f, 
    0.02987526f, 0.01476813f, 0.11168902f, 0.02607895f, 0.07510573f, -0.05144109f, 0.14460437f, -0.05307632f, 
    0.17640178f, 0.33321908f, 0.19507518f, 0.32335731f, 0.12109471f, 0.18786159f, 0.19059841f, -0.02293443f, 
    -0.00518353f, 0.04780419f, 0.00083812f, -0.08047125f, 0.02641167f, 0.02420127f, 0.01340938f, -0.29620093f, 
    -0.04316682f, 0.04221165f, 0.14683725f, 0.24935983f, -0.09855265f, 0.07734110f, 0.03677128f, 0.04070614f, 
    -0.15941690f, 0.11645708f, 0.11952620f, -0.00737772f, 0.05545984f, 0.03202594f, -0.11410356f, 0.04012493f, 
    0.21888626f, 0.06349315f, 0.03268610f, 0.12630896f, 0.49895650f, 0.21390279f, 0.27671039f, 0.11277580f, 
    0.10994580f, -0.15055943f, 0.12667543f, -0.07478254f, 0.06312360f, -0.20469229f, -0.19421223f, 0.06196640f, 
    0.59913778f, 0.14919841f, 0.09820011f, 0.14013179f, -0.10949540f, -0.00146689f, 0.02359359f, 0.12715818f, 
    0.21236980f, 0.17368664f, -0.10558595f, 0.08104925f, 0.08574006f, 0.04700648f, 0.19522220f, 0.05238285f, 
    -0.08657628f, 0.01432559f, 0.02248274f, -0.24513325f, -0.04746631f, -0.01927940f, -0.08070518f, 0.04363815f, 
    0.21743618f, -0.21382529f, 0.09974480f, -0.21853995f, -0.07005670f, 0.02054555f, 0.03115867f, 0.08631593f, 
    0.01877633f, 0.05440423f, -0.11076596f, -0.03375241f, -0.09255397f, 0.03844132f, 0.01633691f, -0.02162475f, 
    -0.03989726f, -0.00647455f, -0.03264192f, -0.17963862f, 0.03875692f, 0.02880575f, 0.01830066f, 0.08914782f, 
    -0.26292971f, -0.29052126f, -0.06251729f, -0.22979778f, -0.08839286f, -0.05069401f, -0.14130299f, -0.03062190f, 
    0.04231039f, 0.04406391f, -0.03703039f, 0.01476108f, -0.03502573f, -0.12806386f, 0.01675028f, -0.21305579f, 
    -0.09800369f, 0.03015125f, -0.08622355f, 0.08311989f, 0.06979222f, -0.01188200f, 0.08910400f, -0.03231664f, 
    -0.25032216f, 0.16932489f, -0.40679523f, -0.00377259f, -0.11342412f, -0.10276119f, 0.00553384f, 0.04577747f, 
    -0.08329251f, -0.01084210f, -0.22591475f, 0.11393063f, 0.05902170f, 0.18289718f, 0.27866229f, -0.01902463f, 
    -0.05905392f, -0.09157038f, -0.10852268f, -0.08753520f, -0.09411538f, -0.14944530f, 0.00203624f, -0.08205613f, 
    0.19372769f, 0.08580782f, -0.09656679f, -0.02538805f, 0.00369039f, -0.15236241f, 0.33563575f, 0.08665568f, 
    -0.07596025f, 0.06313006f, -0.03802960f, 0.04723824f, 0.00427845f, 0.08968680f, 0.01128191f, -0.10859349f, 
    0.05119207f, 0.06010545f, 0.06404757f, 0.02054512f, 0.00774457f, 0.18341748f, 0.03662028f, 0.06694168f, 
    -0.13625480f, 0.09488516f, -0.08284978f, 0.02619678f, 0.22046861f, 0.02153831f, -0.18763365f, -0.04011125f, 
    0.11216670f, -0.16448179f, 0.14395742f, 0.10293297f, -0.08405416f, 0.03888297f, -0.10323825f, -0.10009509f, 
    -0.06231086f, 0.11969238f, 0.03544751f, -0.00948931f, 0.02593258f, 0.05744907f, 0.02743208f, 0.02739487f, 
    0.13345759f, -0.08710407f, 0.31108844f, 0.22224163f, -0.02944921f, -0.09635168f, 0.05573397f, 0.02036225f, 
    -0.00519533f, -0.11336627f, 0.07031675f, -0.06007061f, -0.17796780f, 0.08897308f, -0.16676016f, 0.10829198f, 
    0.06267288f, -0.05529758f, 0.08977173f, 0.12005726f, 0.06684410f, -0.14004230f, 0.05835894f, 0.13432044f, 
    0.00481631f, -0.22711591f, -0.19074906f, -0.06564923f, 0.00206698f, -0.04212696f, 0.08491010f, -0.22444688f, 
    0.06598150f, 0.02555692f, 0.03876333f, 0.16962411f, 0.04593808f, 0.14270282f, 0.01867716f, -0.18155599f, 
    -0.02645473f, 0.09834717f, -0.02196908f, -0.02637358f, -0.02580240f, -0.06716829f, 0.12048066f, -0.07193753f, 
    0.04635026f, -0.09305678f, -0.01538026f, 0.09320613f, 0.05303413f, -0.04517210f, 0.07842996f, -0.10233901f, 
    -0.03421482f, -0.07640024f, -0.04474053f, 0.03755795f, -0.06168219f, 0.25238368f, -0.04983044f, 0.31263715f, 
    -0.00541868f, 0.17621435f, 0.07510692f, -0.00343272f, -0.15425211f, 0.00864622f, 0.12114018f, 0.06229739f, 
    -0.01153994f, 0.01052941f, -0.16838388f, 0.12911022f, -0.07415239f, -0.14084503f, 0.00185874f, -0.04925327f, 
    0.01374254f, -0.08874492f, -0.09059099f, -0.07610956f, 0.02070971f, 0.03333354f, 0.19752619f, 0.14402124f, 
    -0.09160025f, -0.02713593f, -0.06851199f, 0.05226383f, -0.09409370f, -0.08139072f, 0.03365133f, 0.04339761f, 
    0.03858365f, -0.04134013f, -0.05501823f, -0.01175741f, -0.02068874f, 0.03778294f, -0.01875421f, -0.04809795f, 
    -0.04334662f, -0.01783556f, -0.03019902f, 0.01967182f, -0.05327496f, -0.04974782f, 0.00201073f, 0.02473107f, 
    -0.02436485f, -0.02382479f, 0.03457101f, -0.01880114f, 0.03251845f, -0.01326782f, 0.04124267f, -0.00919197f, 
    -0.00083162f, 0.04154638f, 0.03990074f, 0.03931140f, 0.02629595f, 0.04580738f, 0.02245133f, -0.03372238f, 
    -0.02597901f, -0.02337739f, -0.03440615f, -0.00011972f, -0.02581423f, -0.05522463f, 0.02842433f, 0.02833667f, 
    -0.03649300f, -0.01399395f, -0.00034815f, -0.05210473f, 0.00161138f, -0.04252847f, -0.02931588f, 0.02140633f, 
    -0.04436716f, -0.00399128f, 0.04527638f, 0.00971234f, -0.03780589f, 0.04136094f, -0.04675675f, 0.00278953f, 
    0.04001452f, 0.02013970f, -0.04869845f, -0.02194702f, 0.01201432f, -0.00175924f, 0.01818682f, -0.01714148f, 
    -0.04243095f, -0.03756912f, 0.03689098f, -0.01899798f, -0.01474517f, -0.01796140f, -0.03074891f, -0.00034483f, 
    0.04373446f, -0.05459108f, 0.03484096f, 0.03121336f, -0.03938222f, 0.01259096f, 0.00165049f, 0.02059526f, 
    0.02584629f, -0.03670480f, -0.05419791f, 0.04241571f, 0.03803911f, -0.01258037f, -0.01217270f, -0.05641568f, 
    -0.02060992f, -0.01802249f, -0.00013150f, -0.04075046f, -0.05032311f, -0.04637702f, 0.01440496f, -0.02552406f, 
    -0.02995544f, 0.03869595f, -0.01436698f, 0.04481623f, -0.05001051f, 0.02955685f, 0.03396499f, -0.00741935f, 
    -0.05600745f, 0.00877422f, -0.00364699f, -0.03196563f, 0.03559370f, -0.01030229f, -0.00330876f, -0.03077057f, 
    0.00091046f, 0.04174509f, -0.03797770f, 0.00021485f, -0.00094892f, 0.00530415f, 0.02544847f, -0.02657309f, 
    -0.01148253f, 0.04383551f, -0.03170546f, 0.03927308f, -0.01444596f, -0.00521015f, -0.01239566f, -0.00321425f, 
    -0.00695257f, -0.05012931f, -0.02631572f, 0.03210666f, 0.03847261f, -0.02212981f, 0.01119341f, 0.00358129f, 
    -0.01008522f, -0.00919097f, -0.04959553f, -0.02719494f, -0.05101652f, -0.03993329f, 0.01979257f, -0.03960979f, 
    -0.02773475f, 0.04303741f, 0.00996632f, 0.01327343f, 0.04187581f, -0.00205323f, 0.03190149f, -0.01239929f, 
    -0.05518501f, 0.03544617f, 0.02265078f, 0.00337848f, 0.04445817f, 0.00987320f, -0.02194325f, 0.00091103f, 
    0.01562261f, 0.03737910f, -0.02446721f, -0.04134568f, 0.03479223f, 0.00370202f, -0.04975303f, 0.03727647f, 
    0.00723675f, 0.02477519f, -0.03632422f, 0.00532095f, -0.03081223f, -0.05773567f, 0.00004666f, -0.03567431f, 
    -0.04898051f, 0.00816960f, -0.01592731f, -0.01889002f, 0.00463779f, 0.03525084f, -0.00638762f, 0.03731262f, 
    0.02538820f, 0.03908231f, -0.05262212f, -0.00855563f, 0.02871745f, -0.03249792f, -0.03271208f, -0.02319281f, 
    -0.04020752f, -0.05221044f, 0.01559014f, -0.03988469f, 0.01679296f, -0.04120443f, -0.05142089f, -0.02164228f, 
    -0.02556933f, -0.03030939f, -0.00326548f, -0.03444082f, -0.02553165f, -0.00027641f, -0.04670419f, 0.00070605f, 
    -0.05652129f, -0.04494432f, -0.03511326f, 0.01625194f, 0.02035145f, -0.00382933f, -0.01563870f, 0.02895360f, 
    0.02186859f, 0.00225515f, 0.00736927f, -0.02591711f, 0.01930920f, 0.03499723f, 0.02863191f, 0.00556009f, 
    -0.01753397f, -0.05528507f, -0.00438875f, -0.03638754f, -0.02381116f, 0.02911014f, -0.04460918f, 0.01372721f, 
    -0.01143960f, -0.00890507f, -0.04257973f, -0.02139369f, 0.00102880f, -0.00363798f, -0.01220635f, -0.03676403f, 
    -0.04439082f, 0.03576319f, 0.00046073f, 0.04052437f, 0.00963074f, 0.01395968f, 0.00295807f, -0.01622466f, 
    -0.01247482f, -0.04586959f, -0.00392763f, -0.02695279f, -0.04869100f, -0.02089588f, 0.00596900f, -0.00312653f, 
    -0.01788971f, -0.01549832f, -0.02562948f, -0.05293782f, -0.00163865f, -0.00365589f, -0.02659415f, -0.05610847f, 
    0.00803019f, -0.05530882f, -0.02041963f, 0.02449827f, 0.04203894f, 0.03969093f, -0.04485878f, 0.04198132f, 
    0.02972487f, -0.02262336f, -0.01864509f, -0.01967440f, -0.00699845f, -0.03756609f, 0.04366140f, -0.03767291f, 
    -0.00687587f, 0.02743397f, -0.04262083f, -0.00559211f, -0.01856150f, -0.05359790f, 0.04425061f, -0.01045660f, 
    0.01887542f, -0.01578109f, 0.00000050f, 0.01337466f, 0.01222271f, -0.04789506f, 0.03969106f, -0.00148584f, 
    0.02520003f, 0.00724600f, 0.00906575f, 0.00413708f, -0.04215339f, -0.02231517f, -0.05054436f, -0.04639436f, 
    -0.00079777f, -0.01928746f, -0.04284238f, -0.04803672f, -0.01628990f, -0.01645071f, -0.04318416f, 0.00248071f, 
    -0.00625546f, 0.01542019f, -0.00605009f, -0.01418204f, -0.03752083f, -0.00187912f, -0.00813342f, -0.00271846f, 
    -0.05688975f, 0.00200530f, 0.01985921f, -0.04214125f, 0.03883066f, -0.02957473f, -0.01321144f, 0.03627920f, 
    -0.05715874f, 0.03866952f, -0.04341281f, -0.02753052f, -0.01127523f, -0.00225505f, -0.05536001f, -0.03582393f, 
    -0.04026266f, 0.02809181f, -0.00368106f, -0.03414624f, 0.03482565f, -0.01598220f, 0.00290327f, -0.01525949f, 
    -0.03239675f, -0.04796475f, -0.03596604f, 0.01053364f, 0.01820408f, -0.04807507f, -0.04981571f, -0.04410801f, 
    0.00605881f, -0.04302609f, 0.01862562f, -0.04618537f, -0.04867218f, 0.02694141f, -0.01359185f, -0.04956952f, 
    -0.02994424f, 0.03014133f, 0.03818741f, -0.00646480f, 0.03716547f, -0.00267011f, -0.05051390f, 0.01443035f, 
    -0.05089452f, -0.04437890f, -0.03649861f, -0.00626748f, 0.00218722f, -0.04257552f, -0.00692853f, -0.00526580f, 
    0.00399801f, 0.03704812f, 0.03766412f, 0.02120615f, -0.02466311f, -0.02260679f, -0.01646351f, -0.00841526f, 
    -0.01078364f, -0.04668747f, -0.03134622f, 0.03021958f, -0.02815001f, -0.04846805f, -0.02853444f, 0.03282196f, 
    -0.00868203f, -0.02728210f, -0.05382084f, -0.05268914f, -0.00936210f, -0.01543466f, -0.02348714f, -0.00184604f, 
    -0.03939263f, -0.02011602f, 0.01912316f, 0.02054305f, -0.00101479f, 0.00360972f, 0.02846211f, -0.01143931f, 
    -0.05274181f, 0.03333085f, -0.01217759f, -0.06452152f, -0.00737416f, -0.01735364f, -0.00288619f, -0.04810730f, 
    0.04678611f, 0.02177666f, -0.03568873f, -0.03570056f, -0.04554475f, -0.01217585f, 0.00038307f, 0.02151703f, 
    0.01007548f, -0.00361359f, -0.05344970f, -0.02059659f, -0.00268979f, -0.02041922f, 0.01769226f, -0.02094790f, 
    0.04359527f, 0.00678117f, 0.02790004f, 0.05192047f, -0.04212894f, -0.04582430f, -0.02990592f, 0.00785427f, 
    0.00504666f, -0.01637645f, -0.00273263f, 0.01929706f, -0.03644029f, -0.04865940f, 0.01705418f, -0.04483394f, 
    -0.04218790f, -0.02160281f, -0.00642080f, -0.02991270f, -0.04755296f, -0.00411094f, -0.02445226f, 0.00721839f, 
    0.01979915f, -0.02732046f, 0.02621391f, -0.02054455f, -0.02735644f, -0.03806869f, -0.04828488f, -0.00860144f, 
    0.03830539f, -0.01976494f, -0.01419170f, -0.01196016f, -0.03923742f, -0.04137036f, 0.00312619f, -0.01658367f, 
    -0.03768891f, 0.03026626f, 0.02775393f, -0.01975750f, -0.02424476f, -0.05235668f, -0.01673106f, 0.01771506f, 
    0.01615975f, 0.03564589f, 0.02635028f, 0.01050573f, -0.02752539f, -0.02318568f, 0.04423095f, -0.02278634f, 
    -0.01351781f, 0.03811865f, 0.02793232f, -0.00528051f, -0.00573222f, -0.04784853f, 0.04209358f, -0.03337187f, 
    0.03972517f, 0.00496067f, -0.02336024f, -0.01298280f, 0.03454509f, 0.04264729f, 0.01087957f, 0.02583368f, 
    0.04981520f, -0.01540017f, 0.01838776f, -0.04005453f, 0.01062465f, -0.02617659f, -0.04390845f, 0.03970933f, 
    -0.03062814f, 0.03516396f, -0.05088820f, -0.00209993f, -0.00387588f, -0.04717967f, -0.00285051f, 0.00857470f, 
    -0.03018193f, 0.01966181f, 0.01467813f, 0.00430902f, -0.00982214f, 0.02233372f, -0.05381597f, -0.02442364f, 
    0.03339248f, 0.02064969f, -0.03918051f, -0.04685042f, -0.04336791f, -0.03602320f, 0.04001810f, -0.00214096f, 
    -0.03602907f, 0.01307651f, 0.02456496f, 0.01374723f, -0.02435542f, 0.04468619f, 0.01034031f, 0.04407395f, 
    0.04320904f, -0.00703453f, -0.00397664f, 0.01772915f, 0.04727321f, -0.01744449f, 0.04466187f, 0.02016390f, 
    -0.05847476f, -0.02442017f, 0.03834164f, 0.02901429f, -0.00305784f, 0.00610865f, 0.02363954f, -0.02492277f, 
    -0.00189212f, -0.01824657f, 0.00594249f, 0.00415338f, -0.00742598f, -0.04863161f, 0.01928136f, 0.00086063f, 
    0.01063386f, -0.01759822f, 0.04355685f, 0.00049257f, -0.05221137f, 0.01239020f, -0.03812601f, 0.00870090f, 
    0.01283184f, -0.00574709f, -0.01521753f, -0.01575556f, -0.03366945f, 0.03738996f, 0.02934820f, -0.04204354f, 
    -0.02162133f, 0.01884292f, -0.03572968f, 0.04088873f, 0.03490444f, -0.01445975f, 0.02585275f, -0.00232308f, 
    -0.02853058f, -0.00198583f, -0.04894681f, 0.01543268f, -0.02365175f, 0.02091191f, -0.02073824f, -0.03709041f, 
    -0.05180781f, -0.02075294f, -0.02355925f, 0.01732995f, -0.02402907f, -0.04785731f, -0.04587838f, -0.00421967f, 
    0.03309692f, 0.02463399f, 0.04402236f, -0.04113495f, 0.04613481f, 0.04052309f, 0.02438000f, -0.01467035f, 
    -0.01422071f, 0.03530480f, -0.03306795f, 0.04496840f, -0.02219016f, -0.02285930f, -0.02708432f, -0.04522124f, 
    -0.01548939f, -0.02284638f, -0.03554490f, -0.03015641f, -0.04479345f, -0.01371461f, 0.02908276f, -0.01060557f, 
    -0.03972786f, 0.04291222f, 0.01843869f, -0.03650727f, 0.04502113f, 0.04991249f, 0.04135090f, 0.04014003f, 
    0.03425083f, -0.02373900f, 0.04093652f, 0.02112805f, 0.02720604f, 0.01888280f, -0.04906077f, 0.01660238f, 
    -0.00308602f, 0.02516064f, -0.00568387f, -0.03645392f, 0.03589720f, 0.00057530f, 0.01055269f, -0.05000408f, 
    -0.03303917f, 0.04182360f, -0.00548131f, 0.04814585f, 0.04853134f, -0.01146700f, 0.00143446f, 0.02810586f, 
    -0.00231554f, -0.02262460f, 0.04203158f, 0.03999605f, -0.04749323f, -0.05193136f, -0.02171512f, 0.03727791f, 
    -0.01854595f, 0.00170472f, 0.00947711f, -0.00496388f, -0.00095115f, -0.03311620f, -0.03515017f, -0.02640941f, 
    0.02872531f, -0.00297808f, -0.01050755f, -0.05846354f, -0.04130236f, -0.01020568f, 0.03459692f, 0.01752026f, 
    0.04013790f, 0.03009428f, 0.00213929f, -0.00503439f, 0.03401276f, -0.02195869f, -0.04158075f, 0.01280857f, 
    -0.01824788f, 0.04298152f, -0.03147176f, -0.00811572f, -0.00790781f, 0.02794150f, -0.03747611f, 0.00448475f, 
    -0.02034386f, 0.04362506f, 0.03823250f, 0.04828674f, 0.01874095f, -0.00244790f, 0.03328483f, -0.03215167f, 
    -0.04338244f, 0.04895965f, 0.01167196f, -0.02449204f, -0.00784585f, 0.01077681f, 0.01725700f, -0.02002155f, 
    0.03240767f, 0.00971494f, -0.03443553f, -0.05758704f, -0.04244306f, -0.03975159f, -0.04477282f, -0.01122483f, 
    0.00462974f, 0.02588976f, 0.02028511f, 0.01404239f, -0.05228399f, -0.02320410f, 0.02671097f, -0.01355935f, 
    0.04913164f, 0.00838885f, -0.04275768f, -0.03586590f, -0.01975083f, 0.00372003f, -0.03081852f, 0.00663068f, 
    -0.02474426f, -0.03851560f, -0.00737994f, -0.02526739f, 0.04302507f, 0.03873707f, -0.04332843f, 0.02577119f, 
    -0.04743608f, 0.03620343f, -0.02679845f, -0.04848010f, 0.03255570f, 0.00109867f, -0.02946210f, -0.01387711f, 
    -0.03613575f, -0.00750410f, -0.02620015f, 0.04343585f, -0.02393044f, -0.03701331f, 0.02958834f, 0.02661978f, 
    -0.15397325f, -0.07291219f, -0.04719467f, -0.07241388f, -0.01509323f, -0.01125759f, 0.11337177f, -0.01362471f, 
    0.08861829f, 0.12041132f, 0.08775721f, 0.09013357f, 0.01338697f, 0.00708293f, 0.05986078f, 0.12448324f, 
    0.11017659f, -0.00583552f, -0.03378760f, -0.01855893f, -0.04792900f, -0.04237311f, 0.07934391f, -0.08120397f, 
    0.16401213f, -0.03020417f, -0.07662855f, -0.01278021f, 0.09137281f, 0.06808429f, 0.07838925f, 0.11262654f, 
    -0.07052863f, 0.01751216f, -0.01370687f, -0.10262097f, 0.00530945f, 0.09847403f, -0.04241888f, 0.03271148f, 
    0.11472831f, -0.04180007f, -0.04328787f, -0.10887561f, -0.04920493f, 0.05642614f, -0.01564749f, -0.18675122f, 
    -0.05078177f, 0.13638991f, -0.06698275f, 0.06891160f, 0.05751378f, 0.06240020f, -0.06276548f, -0.09279845f, 
    0.06343047f, -0.12714680f, -0.08883594f, 0.11655138f, 0.12629013f, -0.09302026f, -0.06109698f, -0.17729075f, 
    0.01085661f, -0.11161590f, -0.00460420f, 0.12248602f, -0.02077805f, 0.14482905f, -0.09065942f, -0.01391019f, 
    -0.03593377f, 0.01351839f, -0.03136720f, -0.05231094f, -0.11537524f, -0.00616274f, 0.02474297f, 0.04361260f, 
    -0.01145003f, 0.10814045f, -0.00031338f, 0.04261353f, -0.08055852f, 0.33876812f, -0.14318834f, 0.16693164f, 
    -0.04435952f, 0.15793942f, 0.07909019f, -0.07056499f, -0.04810887f, -0.04715122f, 0.07044146f, 0.01116790f, 
    0.28239930f, -0.05874891f, 0.05349958f, 0.13605268f, 0.00048125f, 0.12899667f, 0.13054694f, 0.10449373f, 
    -0.08236775f, -0.08104943f, -0.02410886f, 0.09551541f, 0.13336498f, -0.13480568f, -0.02280295f, 0.13188785f, 
    -0.12469734f, 0.14181422f, 0.07352874f, 0.11407369f, -0.05442868f, -0.00766833f, -0.12037279f, 0.07608525f, 
    -0.11594420f, 0.05619730f, 0.07160760f, -0.05079005f, -0.13724823f, -0.03149375f, -0.05882746f, -0.03369775f, 
    0.10321341f, 0.08067572f, -0.15913460f, 0.15750596f, 0.34264416f, 0.13944411f, -0.03291195f, -0.03154552f, 
    0.21179515f, 0.03344711f, -0.03799066f, -0.07522652f, -0.04292985f, 0.03134798f, 0.03557296f, 0.07040923f, 
    0.00046714f, 0.11674336f, -0.03294072f, 0.18022555f, -0.06926804f, 0.02445885f, 0.08390818f, 0.11127502f, 
    -0.00445551f, 0.02632254f, -0.03545630f, 0.18253183f, -0.36985031f, 0.06044601f, 0.21574704f, 0.00994060f, 
    -0.03759511f, -0.04617700f, -0.06445639f, -0.05085844f, -0.06542189f, 0.02364277f, -0.04196864f, 0.00560645f, 
    -0.10369265f, -0.19454324f, -0.00430106f, 0.19809355f, -0.12548229f, 0.01759854f, -0.05161459f, 0.04038073f, 
    -0.07970867f, 0.03646192f, -0.05442984f, 0.07289337f, -0.06324839f, -0.00502620f, 0.10151352f, 0.08870208f, 
    0.00552550f, 0.04413381f, 0.01591373f, 0.09088315f, 0.01120418f, 0.04444464f, 0.10268430f, 0.10043748f, 
    -0.19032396f, -0.06759813f, -0.02160256f, 0.15470476f, 0.00766485f, 0.06368267f, -0.10395508f, -0.11373912f, 
    -0.07285748f, 0.03720280f, -0.00228696f, -0.02333972f, -0.29954806f, 0.14555116f, 0.13292633f, 0.09527034f, 
    0.05539850f, 0.07885987f, 0.04618548f, -0.13282457f, -0.10030856f, 0.00116620f, -0.11049775f, 0.07766499f, 
    -0.15833829f, 0.03375502f, -0.18339293f, 0.23760834f, -0.09118230f, 0.02970023f, -0.03069887f, 0.16929831f, 
    0.06090647f, 0.12486053f, -0.04119802f, -0.05145564f, 0.06778801f, 0.27530146f, 0.27681586f, -0.14908952f, 
    -0.00127492f, 0.08028047f, -0.04807584f, -0.05908475f, -0.02791597f, 0.04393185f, 0.03767848f, -0.07830161f, 
    0.12544914f, -0.08153485f, -0.19820176f, 0.24246441f, -0.00842652f, 0.09216843f, -0.17411876f, 0.07515034f, 
    -0.11684234f, 0.01322891f, 0.08251075f, -0.09762449f, 0.09188189f, -0.06986867f, 0.07579899f, -0.09595800f, 
    -0.10272645f, 0.14450425f, 0.10908214f, -0.06383951f, -0.08838826f, 0.14030018f, 0.01140847f, 0.14057679f, 
    -0.16469340f, 0.16012247f, -0.00376692f, -0.04208276f, 0.19122219f, 0.02696122f, -0.01772240f, -0.03467395f, 
    -0.05944914f, -0.08633072f, 0.02165634f, 0.02084125f, -0.09134855f, 0.02032176f, 0.35299829f, -0.16045943f, 
    -0.01008926f, 0.02610938f, 0.06561743f, -0.01662226f, 0.01991881f, 0.08804077f, -0.07187094f, -0.01137452f, 
    -0.00827692f, 0.23870173f, 0.00124354f, 0.19010358f, 0.15813085f, 0.11643994f, -0.01836696f, -0.05211892f, 
    -0.14186624f, -0.02002922f, 0.04122406f, -0.01602321f, -0.10598157f, 0.55476600f, -0.18808602f, -0.01253193f, 
    0.16742906f, 0.19245984f, 0.18039107f, -0.09812699f, -0.00072262f, 0.02991158f, 0.02171742f, 0.17919518f, 
    0.08596514f, 0.03314862f, 0.07875953f, 0.05376215f, 0.06042051f, -0.05372229f, -0.00957811f, -0.11291379f, 
    0.00225582f, 0.09178432f, -0.02096024f, -0.01125847f, -0.26211190f, -0.14585893f, -0.12487649f, 0.06197741f, 
    0.08267584f, 0.01733029f, 0.08116221f, 0.15194850f, -0.03358844f, -0.05194241f, 0.02834504f, -0.20781110f, 
    0.01909861f, 0.03494309f, -0.21827690f, 0.08037885f, 0.03956961f, -0.03439387f, -0.00194393f, 0.09128027f, 
    -0.08776968f, 0.05199451f, -0.02892539f, -0.06379455f, 0.20637205f, -0.06136060f, 0.08701666f, 0.06432112f, 
    -0.02092696f, -0.00221565f, -0.05620117f, 0.02785650f, -0.10710883f, 0.04535139f, 0.00780377f, -0.02191481f, 
    -0.03120190f, 0.22993807f, 0.04471388f, -0.07923777f, 0.07432292f, 0.07619695f, 0.15911087f, 0.15860039f, 
    0.20407295f, -0.07329337f, -0.02258875f, 0.03811811f, 0.03309987f, 0.06818068f, 0.24963179f, 0.08485071f, 
    -0.08596386f, 0.07118709f, -0.15617523f, -0.01776535f, -0.05256496f, 0.01439062f, 0.03900846f, 0.17883660f, 
    0.02191859f, 0.00714206f, 0.03253541f, 0.01381774f, 0.03816897f, -0.05222666f, 0.02317584f, -0.03582209f, 
    0.03652632f, 0.03824419f, 0.04715029f, -0.00997187f, 0.01982047f, -0.00834422f, -0.02688567f, -0.04240552f, 
    -0.04828037f, -0.04900690f, -0.04888287f, -0.01656369f, -0.03425010f, 0.02135579f, -0.02486756f, 0.00175672f, 
    -0.00135354f, -0.01487585f, 0.00313501f, 0.00381562f, -0.03628160f, -0.03758579f, 0.02827254f, 0.02458929f, 
    -0.00135002f, -0.01789042f, -0.03228774f, -0.05453060f, -0.05648401f, -0.01081302f, -0.00095459f, -0.00052061f, 
    -0.03084336f, -0.00187597f, -0.04471936f, -0.02319055f, -0.05608191f, -0.02420242f, 0.03886318f, 0.01639051f, 
    -0.05785953f, 0.01040845f, 0.04082715f, -0.02055338f, -0.01723698f, -0.01258161f, -0.03599373f, -0.02832956f, 
    -0.04389051f, -0.03989965f, 0.01712138f, 0.02850000f, -0.01616609f, -0.04962784f, 0.03544464f, -0.04136273f, 
    -0.03728480f, -0.00104181f, -0.02330964f, 0.00292742f, -0.04549209f, 0.00378708f, 0.04267071f, -0.05725990f, 
    0.04085475f, -0.03882589f, 0.02681790f, -0.01375893f, 0.03133556f, 0.00352505f, -0.05459601f, 0.00486802f, 
    -0.03481410f, 0.01737607f, -0.00266175f, 0.02790442f, -0.00817072f, -0.01777560f, 0.02251679f, 0.01592908f, 
    0.01332578f, -0.01398078f, 0.03677767f, -0.05642349f, -0.05564233f, 0.01382301f, -0.02141371f, -0.05409718f, 
    0.03237197f, -0.02619556f, 0.04142977f, -0.01087969f, -0.05787883f, -0.05304416f, 0.00509883f, -0.05587156f, 
    -0.00103997f, -0.04575309f, -0.00747152f, 0.01249226f, 0.02815655f, 0.02147722f, 0.02156284f, -0.00349992f, 
    0.00502167f, -0.01002501f, -0.04511791f, 0.03145080f, -0.01826917f, 0.02289762f, 0.01033797f, 0.01193020f, 
    -0.01943344f, 0.00222246f, 0.01648071f, -0.00428417f, -0.05335995f, -0.03187170f, -0.00578807f, -0.00058632f, 
    -0.05825284f, -0.02688161f, -0.01208616f, -0.00444182f, -0.01747121f, -0.02313351f, -0.04220034f, -0.00655212f, 
    0.00101126f, -0.03408108f, 0.00627958f, -0.02939866f, -0.00833095f, -0.05182533f, -0.00192197f, 0.01741802f, 
    0.00684825f, -0.00536610f, -0.04286650f, 0.02029995f, 0.02196622f, -0.02235732f, 0.00417663f, 0.02983498f, 
    0.02864451f, -0.04404382f, 0.00384841f, 0.03647524f, -0.00050856f, -0.02697852f, 0.03819660f, -0.02983546f, 
    -0.03025964f, 0.04241068f, -0.01775853f, -0.03660007f, 0.03700157f, -0.03234695f, 0.00398484f, 0.01264687f, 
    0.01586258f, 0.03808234f, -0.02484923f, 0.03606030f, 0.03706709f, 0.02213860f, -0.01917478f, -0.04750346f, 
    0.04284949f, 0.01743238f, 0.03035958f, -0.04146160f, -0.05367244f, -0.03072003f, 0.01785221f, 0.05246842f, 
    0.03103780f, 0.02181495f, -0.02655501f, -0.04563378f, -0.05562364f, -0.02158307f, -0.03081049f, -0.00805665f, 
    0.00026484f, -0.04017938f, -0.01878988f, 0.01915381f, 0.03367101f, 0.00753818f, -0.01679603f, 0.00472382f, 
    -0.05405416f, 0.03766022f, 0.00092379f, 0.03355833f, 0.02423978f, -0.01213112f, -0.00295929f, 0.02800938f, 
    0.01717744f, -0.04104075f, 0.02570273f, 0.03339406f, -0.02696981f, -0.03843842f, 0.00986181f, -0.01792608f, 
    -0.03573408f, 0.02352210f, -0.01168291f, -0.00261870f, -0.00250757f, 0.03365963f, -0.04101229f, -0.04426457f, 
    -0.05429280f, 0.03586416f, 0.01962571f, -0.05982754f, -0.05687628f, -0.01316831f, -0.05610443f, -0.00610929f, 
    0.04029819f, 0.01949023f, 0.02182247f, 0.02895153f, -0.02405632f, 0.00005497f, 0.01510643f, -0.04189527f, 
    0.00797447f, 0.01156422f, 0.00138953f, -0.04563845f, -0.03447982f, -0.05752139f, 0.03532086f, 0.03826595f, 
    -0.03164669f, -0.01949912f, -0.03298926f, 0.05310668f, -0.01291428f, -0.01102179f, -0.00118018f, -0.00278181f, 
    -0.03378998f, 0.01654376f, 0.00482268f, -0.00875454f, -0.04327682f, -0.00533055f, -0.00007634f, -0.01014631f, 
    0.02948618f, -0.02234632f, -0.00885010f, -0.03233697f, -0.06118003f, -0.01349609f, -0.00089144f, -0.01704106f, 
    -0.04845294f, -0.04362134f, -0.00453042f, 0.00445496f, 0.00989351f, 0.00127557f, -0.04493688f, -0.01139008f, 
    -0.04078685f, 0.00271059f, 0.03749363f, 0.02440486f, 0.02388976f, 0.03310353f, -0.05336567f, -0.05646232f, 
    -0.04345940f, -0.05307278f, 0.04355029f, 0.00905573f, -0.04288133f, -0.02811198f, -0.01785303f, -0.02377365f, 
    0.02462465f, 0.00522494f, 0.01616389f, 0.02941527f, 0.00953329f, -0.05971641f, -0.02422302f, -0.01894308f, 
    -0.00035394f, -0.01404060f, -0.03645080f, 0.03648036f, 0.01825759f, -0.04755362f, -0.03293521f, 0.00875766f, 
    -0.02426904f, -0.01368409f, -0.00425654f, 0.01491158f, -0.03749442f, -0.05937182f, -0.00543438f, 0.01507952f, 
    0.01256935f, -0.04307403f, -0.02515435f, 0.04003108f, 0.01727623f, -0.01998376f, -0.00800784f, -0.00957017f, 
    0.01466084f, -0.01337281f, -0.01089183f, 0.03457064f, -0.02588822f, -0.01270193f, -0.01295734f, 0.02410882f, 
    0.03372218f, -0.03997301f, -0.01360587f, 0.01840200f, -0.03716510f, 0.03107369f, -0.02299918f, -0.05652420f, 
    0.02565831f, 0.03199227f, 0.02965950f, -0.02518593f, -0.04235202f, -0.00247993f, 0.01955717f, -0.05509748f, 
    0.03062551f, 0.01453880f, -0.03476706f, -0.01946152f, -0.04111795f, -0.04875692f, -0.03557026f, -0.02580868f, 
    0.01085860f, -0.00275216f, -0.03682636f, 0.04327995f, -0.00905468f, -0.01475183f, -0.01969032f, 0.00811441f, 
    0.01469039f, 0.00741534f, -0.04724091f, 0.01951244f, -0.04017937f, 0.04307087f, -0.04474164f, 0.04081296f, 
    0.02888588f, -0.02203552f, -0.01246368f, -0.01337408f, -0.00478909f, 0.03173084f, 0.04107817f, -0.02233817f, 
    -0.04361901f, 0.05544952f, -0.00032136f, -0.00478337f, -0.04727910f, -0.04064810f, 0.03320197f, 0.05102464f, 
    0.01688500f, 0.04211368f, 0.03000006f, -0.04034859f, 0.00438867f, 0.01162365f, 0.04489827f, -0.04090857f, 
    0.04409748f, -0.02989079f, 0.04002108f, -0.03591805f, -0.04329585f, 0.03404485f, -0.05003281f, -0.04349193f, 
    -0.04900319f, 0.00640379f, -0.00971192f, -0.00379335f, -0.01733907f, -0.00216644f, 0.02887457f, 0.03399577f, 
    -0.04834136f, -0.05233430f, -0.00542026f, -0.00003880f, 0.03744231f, -0.03293098f, -0.02847782f, -0.01825945f, 
    0.00528968f, 0.03677968f, -0.01720000f, -0.01939494f, -0.02270900f, -0.01155028f, 0.03919841f, -0.04945791f, 
    0.00487576f, -0.00882433f, -0.01331689f, 0.01148644f, -0.02031585f, 0.03248356f, -0.01536901f, 0.01468966f, 
    0.02294887f, 0.04303078f, -0.04912578f, 0.03718371f, 0.02751954f, -0.02977672f, -0.01832828f, 0.00996943f, 
    0.01419202f, -0.00583491f, -0.03195053f, -0.05133427f, -0.03596548f, -0.02417503f, -0.04858582f, -0.00018926f, 
    -0.00039261f, -0.02479616f, -0.01808125f, -0.00648360f, 0.02169240f, 0.04596522f, 0.00846357f, 0.03743268f, 
    0.04058234f, 0.01038039f, -0.02965762f, -0.03724559f, -0.00732935f, -0.04581086f, -0.00549258f, -0.03204872f, 
    0.00228495f, 0.00403108f, -0.00694433f, 0.00249820f, -0.04713472f, 0.01629277f, -0.00090478f, 0.03914121f, 
    0.03091648f, -0.04298223f, 0.00614913f, -0.02377558f, 0.00065270f, -0.01809562f, 0.03599021f, 0.04159809f, 
    0.01946112f, 0.01183937f, -0.02894535f, 0.02813652f, 0.00405011f, -0.04820744f, 0.01120096f, -0.01772382f, 
    -0.03631320f, 0.01754914f, -0.04208835f, 0.00666684f, -0.04142840f, -0.01567181f, -0.00020943f, -0.03656885f, 
    -0.01162997f, -0.02459610f, -0.01510355f, -0.02957917f, 0.04048337f, -0.05600149f, -0.04526221f, 0.00247482f, 
    -0.00087208f, -0.01323497f, -0.00661763f, 0.03561353f, 0.02200671f, -0.05188200f, -0.01517912f, 0.02267287f, 
    -0.03400946f, -0.00027626f, -0.04388428f, -0.04471072f, 0.01633450f, 0.01050602f, 0.03421894f, 0.03493904f, 
    -0.02611987f, -0.04875780f, -0.01716069f, -0.01252364f, 0.02117301f, -0.02765289f, 0.00399793f, -0.01845857f, 
    -0.05667396f, 0.03261073f, 0.01623158f, 0.00353119f, 0.01317791f, 0.04479674f, 0.03277897f, -0.04993501f, 
    -0.01843411f, -0.03109496f, 0.02958648f, 0.00043807f, -0.01621984f, -0.04601837f, -0.02602024f, -0.01471721f, 
    -0.01056075f, -0.04263940f, 0.03063607f, -0.04248276f, -0.01494295f, -0.00287231f, -0.01305672f, -0.05309473f, 
    0.03057055f, -0.00552114f, -0.02756977f, -0.01480305f, 0.01077619f, 0.04233877f, 0.03674024f, -0.00705132f, 
    0.03934684f, 0.01330789f, -0.03476347f, 0.00938585f, 0.04158168f, -0.04160234f, 0.01008236f, 0.02934383f, 
    0.01857260f, 0.02606023f, 0.00149347f, -0.02654456f, -0.00304705f, -0.02962828f, 0.04492253f, -0.03135931f, 
    0.02445112f, 0.00523186f, -0.02359593f, -0.04018614f, -0.03549453f, 0.02695804f, -0.00221938f, -0.00487186f, 
    -0.04070268f, -0.03914655f, -0.02351423f, 0.01539439f, 0.04015193f, 0.01129468f, 0.00037723f, 0.03345830f, 
    -0.02128369f, -0.04737481f, -0.01467299f, -0.02308015f, 0.03517844f, -0.02333852f, 0.02772506f, -0.04714812f, 
    -0.04912995f, 0.01479155f, -0.04895618f, 0.00236353f, 0.02457302f, 0.02640069f, 0.00485762f, 0.00316889f, 
    -0.05796731f, -0.03018654f, -0.02865860f, -0.00100211f, -0.03145002f, 0.02191441f, -0.02395902f, 0.03402876f, 
    0.01115010f, 0.04953261f, -0.00048345f, 0.01476592f, 0.00750542f, -0.05380160f, -0.02864039f, -0.03347756f, 
    -0.01347002f, -0.01422940f, -0.01758176f, -0.05176071f, -0.02629981f, -0.02320278f, 0.04620008f, 0.00328645f, 
    -0.05487029f, -0.04419082f, 0.00671919f, -0.05494329f, 0.01395639f, 0.01120082f, -0.03171681f, -0.00617066f, 
    0.02738157f, -0.00083025f, 0.02019317f, -0.01456413f, -0.00112791f, -0.04421670f, -0.03547102f, -0.00091054f, 
    0.02926725f, 0.04197407f, 0.01331763f, -0.01186504f, 0.04584774f, -0.05607753f, -0.01869655f, 0.00095228f, 
    -0.02269053f, -0.04644376f, 0.02474158f, 0.00229901f, -0.01008292f, 0.01728995f, -0.04074001f, -0.03974763f, 
    -0.04494177f, -0.03057510f, -0.01212741f, 0.03072882f, -0.01642044f, -0.02264209f, 0.01019515f, 0.02676685f, 
    -0.04671688f, 0.03719221f, -0.02035973f, 0.02859008f, -0.02291449f, -0.00490173f, 0.04220616f, 0.03963102f, 
    -0.03259338f, -0.05245307f, -0.02644810f, 0.03310666f, -0.01325169f, -0.01375710f, -0.02133070f, -0.02379274f, 
    0.05377108f, 0.01370260f, 0.02684612f, -0.02322002f, -0.05138559f, 0.00795816f, 0.04062298f, -0.00454077f, 
    -0.04844620f, 0.03587979f, 0.02546655f, -0.03624419f, 0.01101421f, -0.01675844f, 0.03282445f, -0.03950780f, 
    0.02891601f, -0.02435218f, -0.03565804f, 0.03628206f, -0.03808817f, -0.03654108f, 0.04244913f, -0.01495625f, 
    0.02661367f, 0.03114353f, -0.05481763f, -0.04041404f, 0.01881065f, -0.01825119f, -0.04525204f, -0.04957085f, 
    0.04488945f, 0.01564240f, 0.05371277f, -0.01812332f, 0.03130973f, 0.03394559f, -0.03139553f, -0.01475020f, 
    -0.03320527f, -0.02857780f, -0.02591677f, -0.05464324f, -0.02272597f, -0.05014637f, 0.03477039f, -0.01122075f, 
    -0.03808515f, 0.03957702f, -0.01797065f, 0.01391889f, -0.01899004f, -0.02060329f, 0.02803772f, -0.03914364f, 
    -0.02533908f, -0.02749566f, 0.03769759f, 0.01276796f, -0.05328841f, -0.01552420f, -0.05559369f, 0.01750969f, 
    0.02132963f, 0.00797842f, -0.04513917f, 0.03191752f, -0.03808383f, -0.01492218f, 0.01007481f, -0.02606025f, 
    0.08111040f, -0.00600076f, 0.00661456f, -0.01611099f, 0.05905686f, -0.00039705f, 0.01528925f, 0.04947708f, 
    -0.04773808f, -0.00581462f, -0.16224644f, -0.00556640f, -0.06539415f, 0.04888477f, 0.11368188f, 0.01724719f, 
    -0.07781327f, 0.14037675f, -0.08627609f, 0.03315350f, 0.05634543f, 0.05911506f, -0.03585008f, -0.01859723f, 
    0.33855474f, 0.00038354f, 0.11876519f, 0.09983555f, 0.02375442f, 0.00489568f, 0.05068208f, 0.05747690f, 
    -0.06028932f, -0.13481165f, 0.03807728f, -0.01923422f, -0.05740408f, -0.03304423f, 0.10005628f, 0.01239165f, 
    0.00857840f, 0.03725488f, 0.03614957f, 0.01749797f, 0.02535362f, -0.00740506f, 0.00010862f, 0.01077355f, 
    -0.05739386f, -0.01113315f, -0.00071850f, -0.02097800f, 0.12331204f, -0.06768329f, -0.15630996f, -0.00856362f, 
    -0.26826617f, 0.00542291f, -0.10572315f, 0.06517886f, 0.02606384f, -0.05717845f, 0.09601169f, 0.18808740f, 
    0.04610087f, 0.07983456f, -0.00605075f, -0.10150181f, 0.09159973f, -0.03090029f, 0.06402626f, -0.03203840f, 
    0.05766628f, 0.04607184f, 0.04120120f, -0.02230774f, 0.03261555f, -0.03875111f, -0.03372107f, -0.00937642f, 
    0.05741097f, 0.03470798f, 0.04720353f, 0.00937522f, -0.30766436f, 0.05929155f, 0.04894631f, -0.02567640f, 
    -0.17082334f, -0.04064172f, -0.10656884f, 0.01693764f, -0.15630983f, -0.04614632f, 0.05858177f, -0.03741947f, 
    0.00654905f, -0.00960340f, -0.10447380f, -0.02202496f, 0.01168396f, 0.04626793f, 0.04267206f, -0.04553515f, 
    0.04068815f, -0.01985599f, -0.00891286f, -0.05021243f, 0.04568363f, 0.01283316f, 0.10787131f, 0.23445790f, 
    0.01355457f, 0.05716009f, -0.02550208f, -0.08247838f, 0.03118552f, 0.00275873f, -0.00492974f, 0.08437146f, 
    0.01857769f, 0.06977788f, 0.03570445f, 0.04030937f, 0.01175312f, -0.02165250f, 0.08237218f, -0.03283999f, 
    0.09202704f, 0.19898559f, -0.05379646f, 0.08231512f, -0.38502762f, 0.09623846f, 0.05350771f, 0.02636052f, 
    0.03148708f, -0.03502505f, 0.05313018f, 0.04112671f, -0.11352813f, 0.12124933f, -0.00733152f, 0.04866960f, 
    -0.08860405f, 0.28639272f, 0.03577385f, 0.10623182f, 0.07755072f, 0.04851637f, -0.04034716f, 0.01841519f, 
    0.08209021f, -0.05138319f, 0.05281034f, -0.08741878f, -0.26815107f, 0.00816727f, -0.21926652f, 0.05469516f, 
    0.00743609f, -0.01508482f, 0.08782563f, -0.04550593f, -0.09636869f, -0.10914842f, -0.07284891f, -0.13415086f, 
    -0.05520614f, 0.37237424f, -0.07855928f, 0.17062846f, -0.07467724f, -0.04562557f, 0.00526778f, -0.02956377f, 
    0.04677382f, -0.06644905f, -0.01766993f, -0.08321820f, 0.03944920f, 0.01214856f, -0.03270139f, 0.12727247f, 
    0.07675691f, 0.05751941f, -0.08087252f, -0.03630271f, -0.03131133f, 0.04507215f, 0.05044905f, 0.04641841f, 
    0.05746746f, 0.06507506f, 0.07466324f, 0.15911114f, -0.00355780f, 0.04419711f, 0.09901594f, -0.11780930f, 
    -0.04000116f, -0.15990110f, -0.06899928f, -0.10234237f, 0.05103159f, 0.06991454f, 0.15785855f, 0.07902897f, 
    0.06253052f, 0.01254984f, 0.01289706f, -0.01234812f, -0.14512400f, -0.08228088f, 0.13832462f, 0.09989000f, 
    -0.15295945f, -0.19470166f, 0.37677991f, 0.06736007f, 0.18703561f, 0.05832919f, 0.02736862f, 0.07234042f, 
    -0.04883225f, -0.06073393f, 0.17921278f, -0.11291540f, -0.05316982f, -0.07592614f, 0.03598205f, 0.16516286f, 
    -0.07571030f, -0.07428174f, 0.06229983f, -0.06422583f, 0.06948119f, -0.01377279f, 0.08897134f, -0.03219054f, 
    -0.13995031f, 0.17960486f, -0.03602224f, 0.13975944f, -0.03795581f, 0.03715634f, 0.11744110f, -0.08679213f, 
    0.12268564f, -0.12667191f, 0.09402009f, 0.06625128f, 0.01416126f, 0.00712131f, 0.04812256f, 0.06136579f, 
    0.11504477f, -0.21301474f, 0.05847047f, -0.04892965f, 0.00162024f, -0.00396215f, -0.22526862f, 0.09385798f, 
    0.13279133f, -0.10802639f, 0.21987817f, 0.17101176f, -0.01080988f, 0.16349158f, -0.07299135f, 0.01319861f, 
    -0.15461315f, -0.11853950f, 0.09188206f, 0.00057897f, 0.07267647f, 0.10270314f, 0.02330958f, 0.30947772f, 
    -0.14961979f, -0.02071851f, 0.00736217f, -0.11669569f, 0.16635460f, -0.04477035f, -0.01365620f, 0.16232695f, 
    0.15686856f, 0.16321817f, 0.05647802f, -0.10628043f, 0.09687408f, 0.03702863f, 0.05104109f, 0.02339186f, 
    -0.11698366f, 0.09211835f, -0.11067515f, 0.03939481f, 0.14953683f, 0.07836614f, -0.12020334f, 0.03756814f, 
    -0.08785371f, -0.07989324f, -0.02658947f, 0.03164575f, -0.13988484f, 0.04956909f, -0.12235395f, 0.06673400f, 
    -0.13147673f, -0.04323922f, 0.04539393f, 0.07834306f, 0.00427018f, -0.05795921f, -0.10796922f, 0.10052957f, 
    -0.14746037f, 0.15347894f, -0.15223235f, 0.07841170f, -0.26814869f, 0.05233895f, 0.16500089f, 0.26956055f, 
    -0.11340528f, 0.23788442f, 0.05626618f, 0.03019070f, -0.06262957f, 0.03905298f, -0.02491474f, 0.00462007f, 
    -0.12953164f, 0.06199547f, 0.08610827f, 0.00663542f, 0.08875906f, 0.25977254f, -0.03116237f, 0.03468665f, 
    -0.03591273f, 0.02378398f, 0.04066280f, -0.04727205f, 0.21922047f, -0.02966655f, 0.07706575f, 0.17720903f, 
    -0.13664366f, -0.11988317f, 0.02513023f, -0.01384509f, -0.01221396f, -0.12687115f, -0.05936210f, 0.00294247f, 
    0.10982569f, -0.12849012f, 0.01071159f, 0.10807513f, -0.13502868f, 0.14824761f, -0.02660418f, -0.09825440f, 
    -0.09012388f, 0.08448592f, -0.05165802f, -0.09453493f, 0.15556630f, -0.12154723f, -0.20611215f, 0.12117290f, 
    0.01160178f, 0.07973667f, 0.00990572f, -0.04364018f, 0.06781686f, 0.04645282f, -0.05884695f, 0.07471462f, 
    -0.03205290f, -0.01607657f, -0.05107601f, -0.02489292f, -0.03677621f, -0.03067107f, -0.02944712f, 0.03983455f, 
    0.02878457f, -0.00351066f, -0.01352103f, 0.02252754f, -0.03114209f, 0.01809907f, -0.00361189f, 0.00891665f, 
    -0.04996774f, -0.03544227f, -0.01082779f, -0.02938064f, -0.05913250f, -0.00284721f, -0.01435663f, 0.01357986f, 
    -0.00109716f, -0.02841925f, -0.00673649f, 0.00496493f, 0.01056267f, -0.05271126f, -0.01582101f, 0.01438667f, 
    -0.02047277f, -0.02160519f, 0.01204574f, 0.02217756f, 0.02092048f, 0.00251773f, -0.00957891f, -0.02272834f, 
    0.01687169f, -0.00248249f, 0.03003155f, -0.02885373f, -0.02940745f, -0.00344233f, 0.02533698f, 0.03621789f, 
    -0.01067113f, -0.00736651f, -0.03415637f, -0.02137414f, 0.02646961f, -0.01260392f, 0.02361864f, -0.01492198f, 
    0.04133105f, 0.00040753f, 0.01261259f, 0.02919715f, -0.00751514f, 0.03843845f, 0.02811068f, -0.05165529f, 
    0.02298983f, 0.01175386f, -0.01406107f, -0.03589132f, -0.04121998f, 0.03539553f, -0.02169190f, 0.00717133f, 
    -0.04725482f, 0.03861150f, -0.03552447f, -0.03402575f, 0.04908361f, 0.02166689f, -0.03959372f, -0.03186265f, 
    0.00154242f, -0.04501386f, -0.01229175f, -0.01823149f, -0.03032717f, 0.01654070f, 0.00209385f, 0.03170144f, 
    0.00561353f, -0.02612720f, 0.00351133f, -0.05424498f, -0.02862626f, -0.02426371f, 0.03141365f, -0.00313872f, 
    -0.04378074f, -0.05522923f, -0.03454614f, -0.03426062f, 0.03093851f, 0.03847518f, -0.04983887f, 0.04045974f, 
    0.03274152f, 0.00939121f, -0.03550183f, -0.01976800f, -0.05091999f, -0.02450185f, -0.01999140f, -0.00192411f, 
    -0.01547154f, -0.04404098f, 0.03450553f, 0.04289816f, -0.00188644f, -0.05351885f, 0.00404635f, 0.00893780f, 
    -0.01446296f, -0.02615423f, -0.03200983f, 0.03049018f, -0.01607787f, 0.02262900f, -0.03808042f, 0.03720906f, 
    0.03616380f, 0.03129841f, -0.04194216f, -0.04933246f, 0.01136459f, 0.03568512f, -0.00545519f, 0.01748033f, 
    0.03642713f, -0.02034790f, -0.02346033f, -0.02596880f, 0.00412427f, 0.01297857f, -0.03028565f, -0.00801424f, 
    -0.01435874f, 0.00227365f, -0.01338170f, -0.04921434f, -0.05414297f, -0.00094059f, 0.02755541f, -0.00885461f, 
    0.04238347f, -0.05348730f, -0.00513273f, -0.02582322f, -0.03871980f, 0.02631560f, 0.02203298f, -0.05283519f, 
    -0.00329301f, -0.05452961f, 0.04053973f, -0.01343777f, 0.01411492f, 0.01765484f, 0.02762600f, -0.03857616f, 
    -0.04134503f, -0.03213616f, 0.03049167f, 0.00199750f, 0.04588364f, 0.03265968f, 0.00482224f, -0.03502531f, 
    -0.01547524f, 0.02788380f, -0.04723323f, -0.04924502f, -0.03655218f, -0.00920402f, 0.03288819f, 0.02284886f, 
    -0.01510977f, 0.04196631f, -0.02546631f, 0.00692622f, -0.05111116f, -0.04059644f, 0.04685353f, 0.01612793f, 
    -0.01629020f, 0.01252321f, 0.02590259f, -0.02533704f, -0.04240831f, 0.02152307f, 0.02817850f, -0.04884462f, 
    -0.00337786f, 0.02754055f, -0.04786815f, -0.03009167f, -0.02742585f, -0.00257700f, -0.01945117f, 0.03730948f, 
    -0.01643214f, -0.00078709f, -0.04636956f, 0.00722983f, -0.04236415f, -0.01920985f, -0.02866321f, 0.00351323f, 
    -0.00474397f, -0.05785185f, -0.03237204f, 0.04675829f, 0.02662914f, -0.00531799f, -0.00481788f, 0.00264314f, 
    -0.02336397f, -0.00256709f, -0.04326140f, -0.02434207f, 0.04135676f, 0.03375365f, 0.01440682f, -0.02777086f, 
    0.00493190f, -0.05230898f, 0.04119672f, -0.02881524f, -0.03593042f, -0.01823463f, -0.05355644f, -0.02332490f, 
    -0.04514404f, -0.02145032f, 0.04151505f, 0.01008887f, 0.03673944f, 0.01275096f, -0.02564301f, -0.02418315f, 
    0.01808733f, 0.02649031f, -0.02936114f, -0.03866767f, -0.03113736f, 0.04061232f, -0.00159400f, 0.00857543f, 
    -0.05490233f, 0.00356913f, -0.04812400f, 0.03860399f, 0.02524754f, -0.01800238f, -0.03456325f, -0.04694687f, 
    0.00602833f, -0.03216873f, 0.01685825f, 0.00260772f, -0.04152351f, -0.04232538f, -0.00103331f, 0.02241901f, 
    0.03357467f, -0.00171357f, 0.03533924f, 0.02690675f, -0.02014302f, -0.04068770f, -0.04112042f, 0.03389299f, 
    -0.00127755f, -0.04624848f, 0.04029630f, -0.04577469f, 0.00014162f, -0.03875172f, 0.02334978f, -0.04079956f, 
    -0.01770500f, 0.03710781f, 0.02414896f, 0.03873469f, 0.03842915f, 0.01347590f, -0.00387833f, 0.04614500f, 
    0.00581562f, -0.02891418f, 0.01593360f, -0.02610818f, -0.03188417f, -0.00000865f, 0.03472197f, 0.00024604f, 
    -0.01911137f, -0.02199071f, -0.05491481f, -0.02661586f, -0.05437711f, -0.04122639f, -0.06249107f, -0.01419432f, 
    0.03487588f, -0.04362598f, -0.01561100f, -0.03854890f, -0.04949560f, -0.02085659f, 0.02827085f, 0.00888475f, 
    0.00343829f, 0.03890393f, -0.00041141f, 0.00261937f, -0.04397646f, -0.04870642f, -0.02273102f, 0.02361433f, 
    -0.05132966f, -0.04716565f, -0.05601679f, 0.00403780f, 0.00337401f, 0.02872185f, -0.00433162f, 0.01955063f, 
    0.01109513f, 0.00948256f, -0.02253651f, 0.02742483f, 0.03677055f, 0.00416051f, -0.03039914f, -0.01364542f, 
    -0.01635394f, 0.02303565f, -0.02682540f, -0.04640764f, -0.04805856f, -0.00160870f, 0.04015040f, -0.00769816f, 
    0.02487942f, 0.00570290f, 0.03670794f, -0.05600695f, -0.01330993f, -0.04595215f, -0.00653058f, -0.05159897f, 
    0.03808663f, -0.03740522f, 0.03470345f, 0.02205555f, -0.00382380f, 0.03706164f, -0.04362374f, -0.04143862f, 
    -0.04341341f, -0.03300481f, 0.03805989f, 0.00640573f, 0.02057579f, -0.03760530f, 0.00237653f, 0.04190322f, 
    -0.01537712f, -0.02112823f, -0.03436920f, 0.02874946f, -0.04349740f, -0.02311758f, -0.01969761f, -0.05519882f, 
    0.04993707f, -0.01951467f, 0.00028942f, 0.00672870f, -0.02967552f, 0.04343241f, -0.01082135f, -0.02881955f, 
    0.04809271f, -0.04569548f, 0.00733412f, 0.02977950f, -0.00050333f, 0.05045691f, 0.00777339f, -0.00299882f, 
    0.01633298f, -0.04437647f, 0.03854122f, -0.02603742f, -0.03808884f, 0.02163525f, -0.03791269f, 0.04077497f, 
    -0.05063825f, 0.02587096f, 0.01032686f, 0.04893254f, 0.04257045f, -0.00505510f, -0.04857114f, 0.02252690f, 
    -0.03469903f, -0.00564299f, -0.02474563f, 0.00274092f, 0.01523684f, -0.02912084f, -0.02664011f, -0.01062576f, 
    -0.02896171f, 0.00775105f, -0.04770565f, -0.00201608f, -0.05049988f, -0.04914768f, 0.03563900f, -0.04191884f, 
    0.01535424f, 0.04550197f, -0.01590445f, 0.04172493f, -0.00616805f, 0.03991885f, -0.00847275f, 0.01004600f, 
    0.03230809f, -0.02160510f, -0.01407084f, -0.02560906f, -0.02732828f, -0.02699907f, -0.01979151f, -0.03587343f, 
    0.01301207f, -0.00292499f, 0.03381641f, -0.02671164f, 0.00365224f, 0.04796986f, 0.00330889f, -0.00435874f, 
    -0.01750112f, 0.04709397f, 0.01313150f, -0.05007468f, -0.01317434f, -0.04093739f, -0.03092636f, 0.01910313f, 
    -0.04853019f, 0.02366732f, 0.03342762f, -0.03731634f, 0.00638240f, -0.05062549f, -0.00125490f, -0.04324759f, 
    0.01939261f, -0.04974958f, 0.04112395f, 0.00224739f, -0.01690830f, 0.00415651f, 0.03541493f, 0.03917278f, 
    0.02346349f, -0.03834378f, -0.03300792f, -0.00314585f, -0.00650538f, -0.03639306f, -0.03017321f, -0.01253558f, 
    0.03069995f, 0.04312858f, -0.03342647f, 0.01330490f, 0.04212167f, -0.01657168f, -0.03903702f, -0.01887159f, 
    -0.00929849f, 0.02385102f, -0.02198522f, -0.00451081f, -0.04727000f, -0.01293027f, 0.01315601f, -0.01861921f, 
    -0.04759268f, 0.04874472f, 0.04696666f, -0.02472146f, 0.04682957f, 0.05063574f, -0.02063719f, 0.03580026f, 
    -0.04915673f, -0.03630083f, 0.02695723f, -0.02172665f, -0.00027646f, 0.01220460f, 0.03297547f, -0.02493765f, 
    -0.00740684f, 0.02045498f, 0.00850915f, 0.03195509f, 0.00090627f, 0.02024397f, -0.00286394f, -0.03747570f, 
    -0.01119708f, -0.01358538f, 0.01406972f, -0.03873537f, -0.02726428f, 0.00208972f, -0.04979584f, -0.02454436f, 
    0.02305879f, -0.01417794f, -0.00111994f, 0.02212183f, -0.04446573f, -0.02813675f, 0.04609201f, -0.03340476f, 
    0.02597270f, 0.03416354f, 0.03782459f, 0.01483735f, -0.02032365f, -0.02919769f, 0.04718349f, -0.02213579f, 
    0.01886472f, 0.04233780f, 0.01903222f, -0.02382147f, -0.04496159f, -0.02131176f, -0.04716104f, 0.03425083f, 
    0.00274569f, 0.03106036f, 0.03624573f, -0.05041546f, -0.00436763f, -0.03211061f, -0.02245953f, 0.02990299f, 
    -0.00449782f, 0.03876411f, 0.04810486f, 0.00446941f, -0.01575820f, 0.04412974f, -0.02631347f, -0.00081858f, 
    0.02853207f, 0.03583745f, -0.00353302f, -0.02857066f, -0.02184837f, -0.02816180f, 0.01061235f, 0.04903388f, 
    0.00346903f, -0.01315567f, -0.02122956f, -0.03274507f, 0.01279627f, -0.02031635f, 0.01953846f, 0.00744492f, 
    -0.00298139f, -0.00438971f, 0.00645094f, -0.03241311f, 0.01598440f, -0.00308962f, 0.03219009f, -0.03075557f, 
    0.01140149f, -0.04104613f, -0.02924377f, -0.02020740f, -0.03736422f, -0.02574435f, 0.02704549f, 0.00789834f, 
    0.00967327f, 0.00556631f, -0.04724031f, 0.00699301f, -0.02690414f, 0.01341381f, -0.01886485f, -0.00635543f, 
    0.01007164f, -0.02354152f, -0.03982086f, -0.03639788f, -0.02557466f, -0.01188832f, -0.02565373f, -0.01718116f, 
    0.00460972f, -0.00032513f, -0.00730992f, -0.00083989f, 0.02251747f, 0.01128111f, 0.05046550f, 0.01694329f, 
    -0.01356228f, 0.00833120f, 0.00206172f, 0.04635922f, -0.03278519f, 0.03827270f, -0.02335076f, -0.01546091f, 
    -0.04021522f, 0.02188607f, -0.02747371f, -0.00864929f, 0.02342923f, -0.04094130f, 0.02090639f, -0.02663971f, 
    0.01893954f, -0.01095317f, -0.04150904f, 0.03900812f, -0.00941988f, -0.00775275f, -0.03253057f, 0.01547528f, 
    -0.02669589f, -0.01839649f, -0.01650922f, -0.04483697f, -0.02896629f, -0.04586008f, 0.05000927f, -0.01730843f, 
    0.00572915f, 0.02525569f, -0.04058119f, 0.02205294f, 0.02692511f, 0.01487544f, -0.02918688f, -0.03187127f, 
    0.01657057f, 0.02202332f, 0.00241156f, 0.02311569f, -0.04142498f, -0.03144141f, -0.04096839f, 0.00963848f, 
    0.04219875f, -0.04631849f, 0.03754005f, -0.04634432f, -0.02056301f, -0.04964541f, -0.00084507f, 0.05070323f, 
    0.00101141f, -0.03746623f, -0.02713979f, -0.00681276f, 0.01705694f, 0.00659463f, -0.04167585f, -0.02605858f, 
    -0.04241741f, -0.01955739f, -0.04325487f, -0.02581186f, 0.03051027f, -0.04112481f, -0.00653019f, 0.04296682f, 
    0.02267570f, -0.03687146f, -0.02496402f, -0.02691453f, 0.05006377f, -0.04901433f, 0.04703599f, -0.03627042f, 
    -0.00209951f, 0.02200065f, 0.00505850f, -0.02630995f, 0.02047745f, 0.03393279f, -0.03483276f, -0.03047249f, 
    0.00618345f, 0.02884514f, -0.03593188f, -0.01305299f, 0.04658698f, -0.03567686f, -0.00074124f, -0.00610947f, 
    0.02000601f, -0.01254539f, -0.00109984f, 0.03190761f, 0.04376624f, -0.02614380f, -0.03899214f, 0.01769412f, 
    -0.04629513f, -0.02527866f, 0.05043291f, 0.02465290f, 0.04189861f, -0.03714175f, 0.00495728f, -0.01037151f, 
    0.01131609f, -0.04326938f, -0.05043640f, -0.00968311f, 0.04944996f, -0.04861710f, 0.01171396f, -0.03749232f, 
    -0.00422078f, -0.01442628f, -0.01861664f, -0.03474506f, 0.02572866f, -0.01781278f, 0.00987363f, 0.00696049f, 
    0.01980622f, -0.03996206f, 0.02495432f, 0.04233324f, 0.03791109f, -0.01330575f, 0.00078070f, -0.03844948f, 
    0.05068900f, 0.08478998f, 0.05008008f, 0.02898840f, 0.02670662f, -0.04708111f, -0.01711170f, -0.04300379f, 
    0.03563820f, -0.04840501f, 0.00493723f, -0.03143854f, 0.07568091f, 0.03729696f, -0.00755156f, -0.00926157f, 
    0.13532481f, 0.05584240f, 0.01147398f, 0.06013149f, -0.02507810f, -0.03990025f, 0.01288337f, -0.03106871f, 
    -0.11852498f, -0.16942088f, -0.05916651f, 0.21885198f, 0.03117497f, -0.06515134f, 0.02946586f, 0.16078135f, 
    0.09527501f, 0.05510257f, 0.08439718f, 0.10670584f, 0.20364982f, -0.03009373f, 0.07633620f, 0.04546290f, 
    0.02221711f, 0.00140987f, 0.02950084f, -0.08458905f, -0.00037294f, 0.04936361f, 0.09273543f, 0.07231873f, 
    -0.02436442f, -0.09360202f, -0.01253806f, -0.05428637f, -0.04608418f, 0.04309358f, 0.04336802f, 0.06489622f, 
    0.24327958f, -0.03799201f, -0.01582588f, -0.04988756f, -0.02608418f, -0.12216836f, -0.03141806f, 0.09793177f, 
    0.14349657f, 0.05729685f, 0.09518351f, 0.24622634f, -0.18644746f, 0.02370984f, -0.05081886f, 0.05107224f, 
    0.15582615f, 0.14231282f, 0.04587150f, -0.00573334f, -0.05931732f, -0.01311246f, -0.05070042f, -0.09200114f, 
    0.02151388f, 0.05542817f, -0.00724008f, -0.03181374f, -0.19934605f, 0.14087400f, 0.04576467f, 0.04103582f, 
    0.02862831f, 0.08810515f, 0.07886954f, 0.12185171f, 0.11661369f, 0.05200611f, -0.01559127f, 0.03521432f, 
    0.05352606f, -0.03174224f, -0.02379461f, 0.05497698f, 0.04904061f, -0.02029012f, 0.04716403f, 0.10153842f, 
    0.10367104f, 0.16108219f, 0.04198802f, 0.00868183f, -0.07499737f, 0.05957474f, 0.15425295f, 0.20450370f, 
    -0.02067962f, 0.01865373f, 0.16410029f, 0.22678731f, 0.01947625f, -0.01049665f, -0.05785631f, 0.08417728f, 
    0.04096238f, 0.00919903f, 0.04138568f, -0.00764475f, -0.01836541f, 0.01966363f, -0.02800577f, -0.01236869f, 
    0.04285070f, 0.00755543f, 0.12256022f, -0.03842649f, 0.03120090f, -0.10381041f, -0.12005806f, 0.07770338f, 
    0.03185774f, -0.14097323f, -0.08351914f, -0.04660340f, 0.02263190f, -0.03143975f, -0.04426951f, 0.15353267f, 
    0.18726696f, 0.21189395f, 0.22714713f, 0.04736417f, 0.00084816f, -0.00236511f, -0.07469095f, 0.05291462f, 
    0.02785290f, -0.06046547f, -0.01784796f, 0.18813337f, 0.14382772f, -0.17121343f, 0.18131755f, 0.00945417f, 
    0.01651182f, 0.02649980f, -0.02504812f, -0.02943250f, -0.03256210f, -0.01761920f, -0.08772563f, -0.08295800f, 
    -0.00879914f, 0.13710374f, 0.21130590f, -0.05118202f, 0.03914007f, 0.05525754f, 0.02570252f, 0.13770956f, 
    0.03030109f, 0.00582119f, -0.09434248f, -0.06453697f, -0.01549755f, 0.03136918f, -0.05439408f, -0.04937254f, 
    -0.04720819f, -0.05928262f, 0.01362248f, -0.02211455f, 0.05699224f, -0.04205315f, 0.04508355f, 0.05685329f, 
    -0.17691281f, 0.13460855f, -0.13644479f, 0.05661609f, 0.07199385f, 0.01392246f, 0.04077963f, 0.02810508f, 
    -0.00640503f, -0.07881440f, -0.04078347f, 0.15155894f, -0.16533850f, 0.06997134f, 0.01498308f, -0.18151201f, 
    -0.07853581f, 0.03470728f, 0.00536980f, 0.02141752f, 0.07164472f, 0.04774946f, -0.03015915f, -0.08883763f, 
    -0.07622197f, 0.09870330f, 0.08822300f, 0.23535943f, -0.01591244f, -0.01359229f, 0.03629078f, 0.03410301f, 
    -0.04498053f, -0.09777554f, -0.00889914f, 0.09721173f, 0.19109604f, 0.09804038f, 0.02676673f, -0.03805210f, 
    0.03913118f, -0.04208482f, -0.11400183f, 0.00475083f, 0.01315112f, -0.04197484f, 0.01073332f, -0.04223112f, 
    -0.06207836f, 0.04296438f, 0.17812660f, -0.07265445f, 0.09039205f, -0.01621487f, 0.04864360f, 0.03820991f, 
    0.01491597f, -0.03200276f, -0.00043918f, 0.13127413f, 0.06859441f, 0.11088523f, 0.05577558f, -0.06208302f, 
    0.02552968f, 0.13594469f, -0.01578177f, 0.06707836f, -0.00876302f, 0.12169992f, 0.06303665f, -0.02728650f, 
    -0.02996623f, -0.00120476f, -0.03896425f, 0.18048863f, 0.18045565f, -0.09718161f, -0.04311727f, 0.01384302f, 
    0.17276669f, 0.15017252f, 0.16178761f, -0.02799774f, -0.28582215f, -0.12146469f, 0.04143435f, -0.24767759f, 
    0.05785950f, 0.10558857f, 0.11109763f, -0.09048026f, -0.05847962f, 0.15563050f, 0.03119964f, 0.00014601f, 
    0.05248551f, 0.20411704f, -0.12495162f, 0.05399729f, -0.05797235f, -0.01872296f, -0.02813010f, -0.04638220f, 
    0.01582814f, -0.05471415f, 0.09226798f, 0.06335331f, -0.00185764f, -0.00882374f, -0.17885976f, 0.09162522f, 
    0.18075828f, 0.12487727f, -0.06271291f, -0.09357987f, 0.00833461f, 0.16356456f, 0.19153726f, 0.08051622f, 
    -0.06150671f, -0.20149240f, -0.16589525f, -0.12865819f, -0.09781967f, -0.13189384f, -0.00917621f, 0.02356409f, 
    0.05392386f, -0.06873532f, -0.09505983f, -0.09121962f, 0.02223636f, 0.03800413f, 0.03422527f, 0.28043222f, 
    0.02118632f, 0.02456649f, -0.01413372f, -0.00391156f, 0.08690558f, 0.09186765f, 0.02577210f, -0.04230561f, 
    -0.09976823f, -0.04513846f, 0.19659315f, 0.24254236f, 0.03220624f, 0.08965857f, 0.03626528f, 0.06155493f, 
    0.07512620f, -0.04514653f, -0.05300279f, 0.04993721f, -0.05862939f, -0.19815339f, -0.14143409f, 0.05554957f, 
    0.00519610f, 0.08394951f, -0.04720043f, 0.13845305f, 0.20611557f, 0.09289760f, 0.07662427f, -0.03750968f, 
    0.12492264f, 0.07574645f, -0.14138262f, -0.00902854f, 0.09595772f, -0.05539216f, 0.22118045f, 0.12453339f, 
    -0.01833990f, 0.07200815f, 0.07693642f, 0.04913612f, 0.29255518f, 0.27753481f, 0.21895891f, 0.13966312f, 
    -0.08267143f, -0.03582747f, 0.01330151f, 0.00157952f, 0.01223021f, 0.04600333f, -0.03772679f, 0.00812762f, 
    0.19530526f, 0.09758620f, 0.07788800f, 0.16668108f, 0.04062121f, -0.00065721f, -0.01002536f, 0.02020271f, 
    0.24633205f, 0.06981778f, 0.07076342f, -0.06624100f, 0.05774520f, 0.09139265f, -0.01150972f, -0.00309360f, 
    0.02030039f, 0.03166853f, 0.10454819f, -0.06931387f, -0.04881177f, -0.10104849f, -0.07988898f, -0.07675941f, 
    -0.68453777f, -0.11874083f, 0.25198907f, -0.17850706f, 0.11469060f, 0.06224042f, -0.11724920f, -0.04693206f, 
    -0.02843132f, 0.08587173f, 0.03220858f, 0.03614862f, 0.13950232f, 0.13803987f, -0.00794206f, 0.04340713f, 
    -0.04128895f, -0.02243719f, 0.06691755f, 0.04982393f, 0.13835959f, 0.05980928f, -0.00063042f, 0.04427880f, 
    -0.20900559f, 0.01165693f, -0.06863073f, 0.01905628f, -0.02323179f, 0.06079840f, 0.25295594f, 0.08642540f, 
    0.04637297f, 0.02888742f, 0.19639745f, 0.00836351f, -0.15358345f, -0.19338046f, -0.01884701f, -0.09865317f, 
    -0.12080436f, 0.10268487f, 0.13373271f, 0.03409661f, 0.15941308f, 0.04348662f, 0.10955279f, 0.16738595f, 
    0.17198244f, 0.05686021f, 0.14583440f, 0.09782094f, 0.06163384f, -0.05900665f, -0.03261586f, -0.04521200f, 
    0.06741090f, 0.02018622f, 0.00607287f, 0.02009691f, -0.07675885f, -0.27145523f, -0.14600003f, -0.01564687f, 
    0.20662639f, 0.01487540f, 0.04153307f, 0.12112506f, 0.01560998f, 0.19009073f, -0.07311431f, 0.05792375f, 
    -0.39604750f, -0.65112698f, -0.57091171f, -0.55599284f, 0.02273318f, 0.07807308f, 0.16318682f, -0.00211396f, 
    -0.03160556f, -0.07066748f, -0.07577591f, 0.15749630f, -0.09378131f, -0.40741196f, -0.16318747f, -0.11329386f, 
    0.18717799f, -0.10315919f, -0.03151527f, -0.07656419f, 0.03040270f, 0.01190175f, 0.03729048f, -0.09221258f, 
    0.17558204f, -0.00195847f, -0.02941393f, 0.04896190f, 0.04794934f, 0.04337518f, 0.02421843f, 0.09569730f, 
    0.27975410f, 0.03019933f, 0.24937305f, -0.12415674f, -0.20856848f, -0.35635847f, -0.36410302f, -0.28077373f, 
    -0.16492660f, 0.07673793f, -0.15938231f, 0.01492575f, -0.06362788f, 0.01548903f, 0.05026937f, -0.07812367f, 
    0.23207569f, 0.12748034f, 0.10888671f, 0.06450065f, 0.01748934f, 0.03598408f, 0.06658966f, 0.01059308f, 
    0.19898179f, 0.03343697f, 0.12024616f, 0.05387285f, 0.31140554f, 0.10112720f, -0.12871750f, -0.09873329f, 
    -0.08566763f, 0.02340371f, -0.03659511f, 0.13059665f, 0.09703137f, -0.00076141f, 0.15040779f, 0.02162468f, 
    0.29882750f, 0.02608580f, 0.11424341f, 0.27275166f, 0.02416111f, -0.13834976f, -0.02733479f, 0.09720594f, 
    -0.06188400f, -0.05521259f, -0.03255130f, 0.05291253f, 0.21169169f, 0.07264124f, 0.07413235f, -0.05248719f, 
    0.04915038f, 0.06540155f, 0.08263334f, -0.00841277f, -0.17375559f, -0.01786795f, -0.02584945f, -0.09371594f, 
    0.18274447f, -0.09651680f, 0.13469271f, 0.01006316f, -0.05259541f, -0.00802304f, 0.06381278f, 0.05285851f, 
    0.01210266f, 0.03053024f, 0.00148711f, 0.11082385f, 0.39083126f, 0.09105282f, -0.05097451f, 0.02667506f, 
    -0.04906629f, -0.09740244f, -0.00560160f, 0.10202740f, 0.24857399f, 0.10932376f, 0.00929524f, -0.17561853f, 
    -0.08203150f, -0.16260469f, 0.04726014f, -0.14847212f, 0.17596351f, 0.20394914f, 0.07022604f, 0.05985767f, 
    -0.07925788f, -0.03072104f, -0.01283880f, 0.08663302f, 0.13495429f, 0.06540119f, 0.03239230f, 0.10397191f, 
    0.02700683f, -0.02706258f, -0.06965132f, 0.09239031f, 0.05428836f, -0.00784198f, 0.01754306f, 0.13053702f, 
    -0.05701983f, 0.20931388f, 0.10433376f, 0.05288033f, 0.25729793f, 0.05833966f, 0.01634360f, 0.25857708f, 
    -0.03973118f, 0.01410278f, -0.10489117f, 0.03987260f, 0.13585861f, -0.01708031f, -0.02215607f, 0.17783704f, 
    0.03434984f, 0.03693197f, -0.02860279f, -0.02807733f, 0.10882755f, 0.03790272f, 0.09720378f, -0.22301601f, 
    -0.12763923f, -0.17377038f, -0.08055095f, -0.28817505f, -0.25308126f, 0.14329700f, 0.17833067f, 0.11088564f, 
    -0.01311477f, 0.01618570f, -0.10821304f, 0.04657713f, 0.18331592f, -0.31900787f, -0.30755958f, -0.14569548f, 
    0.00055158f, 0.00454022f, -0.03693321f, 0.22993708f, 0.13479286f, 0.04029036f, 0.04156684f, 0.01571116f, 
    0.13312000f, -0.01044808f, 0.07811189f, -0.12176196f, -0.02662321f, -0.03838369f, -0.08113629f, -0.03065304f, 
    -0.06840432f, -0.02221985f, 0.08311909f, 0.01854288f, -0.02340920f, 0.01038280f, 0.22629660f, -0.17847537f, 
    0.04031994f, 0.13753022f, -0.10453204f, 0.05420547f, -0.04277827f, -0.04693578f, 0.16071780f, -0.26235119f, 
    -0.07770393f, 0.04174665f, -0.06288771f, -0.16955754f, -0.10817553f, 0.00967673f, -0.06199299f, 0.09255288f, 
    0.04756511f, -0.04418393f, 0.05912467f, -0.09466363f, -0.05141343f, -0.44334400f, -0.27194971f, -0.06491251f, 
    0.08433165f, -0.09590852f, 0.05187420f, 0.00477383f, 0.01322358f, 0.02025622f, -0.11200275f, 0.00663039f, 
    -0.34574130f, -0.14822650f, -0.35842755f, -0.36280432f, -0.03920839f, 0.05556403f, -0.22073255f, -0.10460877f, 
    -0.03142108f, 0.00457550f, -0.00259848f, 0.00618153f, -0.50868100f, -0.22599430f, -0.08389644f, -0.54234195f, 
    -0.09356756f, -0.09632586f, -0.02832995f, -0.06991667f, 0.12256861f, 0.08997063f, 0.01780535f, -0.01863775f, 
    -0.10263226f, 0.05613825f, -0.00171714f, -0.04072460f, 0.00690725f, 0.09454135f, -0.05375540f, -0.09525894f, 
    -0.07634285f, -0.03644824f, 0.03455219f, 0.05837452f, 0.34417194f, 0.22666124f, 0.16338629f, 0.09101795f, 
    -0.05390787f, -0.04151537f, 0.06158165f, -0.01998344f, -0.00958301f, 0.02079364f, 0.04417317f, -0.05212279f, 
    -0.11490804f, 0.03365460f, 0.12008003f, -0.05816997f, -0.17339227f, -0.11506665f, 0.02400946f, -0.05808759f, 
    -0.01537953f, 0.16470917f, -0.01070759f, 0.04127708f, -0.22196642f, -0.03960260f, -0.14091992f, -0.01963883f, 
    0.10659028f, -0.10610563f, -0.02125283f, -0.12866889f, -0.25062555f, -0.17637224f, -0.23052186f, -0.40667260f, 
    0.15067397f, 0.21036102f, 0.09627587f, 0.02042800f, 0.02525112f, -0.09620600f, 0.01435828f, 0.11968901f, 
    -0.02096494f, 0.02318789f, 0.02386694f, 0.00871228f, -0.20125222f, -0.07663671f, -0.08223677f, -0.05136418f, 
    -0.04898403f, -0.25675577f, -0.11940847f, -0.33795467f, -0.10765032f, -0.05824703f, -0.06179324f, -0.07972754f, 
    -0.02624983f, 0.04457048f, -0.15023339f, -0.03082914f, -0.03437383f, 0.01309024f, -0.05756190f, 0.13995799f, 
    0.11100277f, 0.05051637f, 0.01038428f, 0.08202811f, 0.19936343f, 0.20013189f, 0.13747975f, 0.18280940f, 
    0.04639611f, -0.12236296f, -0.00492097f, -0.02844542f, 0.24202837f, 0.17760451f, 0.15122700f, 0.13330790f, 
    -0.25184244f, -0.14691296f, -0.07056636f, 0.15923728f, 0.02944604f, 0.11300691f, 0.04244424f, -0.04816265f, 
    -0.05374261f, -0.02814981f, -0.05181520f, -0.01477140f, -0.08486709f, 0.01726237f, -0.01429501f, 0.06355638f, 
    0.13122211f, 0.11410306f, 0.05450179f, -0.02387591f, -0.08262821f, 0.10476492f, -0.00473212f, 0.09431154f, 
    0.19059880f, -0.10024456f, 0.04590230f, 0.16196726f, 0.10353978f, 0.02652120f, 0.03686921f, 0.11001913f, 
    0.06317896f, -0.00058782f, 0.07445863f, 0.12712084f, 0.15122439f, 0.00727383f, 0.02567525f, 0.17305018f, 
    0.13034624f, 0.08658612f, -0.02022806f, -0.05293101f, -0.06453833f, 0.02422594f, 0.02771981f, -0.16878140f, 
    -0.13738321f, -0.24657661f, -0.34387887f, 0.14686979f, -0.33151299f, -0.01012966f, 0.06599058f, -0.13235889f, 
    0.16099951f, -0.06161041f, -0.01226130f, 0.09223584f, -0.00705087f, 0.03243069f, -0.21248609f, -0.04156906f, 
    0.11391138f, 0.09695113f, -0.07639453f, -0.08795682f, -0.08362205f, 0.12285718f, 0.18968785f, 0.14170162f, 
    -0.14197569f, 0.08239474f, -0.10219431f, -0.07116701f, 0.00555296f, 0.00059404f, 0.08092870f, -0.11021420f, 
    0.00947375f, 0.06629916f, 0.10341296f, 0.03012430f, -0.15244389f, -0.01225509f, 0.10332273f, 0.10721621f, 
    0.02477643f, -0.03360796f, -0.01640702f, -0.05432231f, 0.07156188f, 0.02348621f, 0.07879441f, 0.23463303f, 
    -0.06119656f, 0.12591974f, 0.08752528f, 0.28203458f, 0.05320721f, 0.04810196f, 0.08331673f, 0.05752434f, 
    0.09060072f, 0.03038139f, 0.02994519f, 0.05661264f, 0.08876098f, 0.00286126f, -0.09972797f, -0.03794579f, 
    0.11303160f, 0.05176193f, -0.07671999f, 0.02990495f, -0.23126788f, -0.01097569f, -0.11126933f, -0.43758038f, 
    -0.00471584f, 0.22793332f, 0.04129963f, 0.26480201f, 0.00209867f, -0.11264877f, -0.04430540f, -0.10186734f, 
    0.09150598f, 0.06068369f, 0.12534313f, 0.07170957f, -0.10315694f, -0.01462799f, -0.14495479f, 0.18303773f, 
    -0.04550311f, -0.16521297f, -0.07858587f, -0.31594554f, 0.00396395f, -0.03689267f, -0.24745041f, 0.07727052f, 
    0.29776779f, 0.00646473f, 0.17184463f, 0.24491240f, 0.02602542f, 0.04751183f, -0.12331939f, 0.16845150f, 
    0.03494012f, 0.14167982f, 0.13187057f, -0.03654412f, -0.02732102f, -0.08563638f, 0.17242730f, 0.28553638f, 
    0.18958469f, -0.06694093f, 0.22515915f, -0.17862166f, -0.01096374f, -0.20016243f, -0.13605137f, -0.02703294f, 
    0.08420900f, -0.21955085f, -0.10259460f, 0.00271186f, 0.20581974f, 0.03416949f, -0.22212076f, 0.04975152f, 
    0.00997482f, -0.18822163f, 0.00249010f, -0.25579849f, -0.00906168f, -0.11494523f, -0.08194190f, -0.16524757f, 
    -0.10869846f, 0.06391890f, -0.04413392f, -0.08528304f, -0.15830429f, -0.19106339f, 0.00800818f, -0.10012786f, 
    0.10342620f, 0.23660925f, 0.09716777f, 0.06640281f, -0.04915144f, -0.06192405f, 0.09721280f, 0.03844398f, 
    0.04387122f, 0.03893286f, -0.09363762f, -0.01980795f, 0.05223339f, 0.04600493f, 0.05681011f, 0.16365756f, 
    -0.05505489f, -0.15616037f, -0.13312852f, -0.08532484f, 0.05050558f, 0.00573972f, 0.03328558f, -0.01832600f, 
    0.05913865f, 0.23246960f, -0.07514042f, -0.00373662f, -0.16747025f, 0.06494784f, -0.19016355f, -0.24357730f, 
    -0.05235721f, 0.00572314f, -0.06246282f, 0.04295214f, 0.10572086f, 0.17436497f, 0.18786627f, -0.15736985f, 
    0.10119537f, 0.01134238f, -0.13889927f, -0.27449590f, -0.01652786f, 0.12455513f, 0.03469306f, 0.06241680f, 
    0.17680404f, -0.07905740f, -0.10127121f, -0.05021146f, 0.02937911f, 0.02354894f, -0.03930342f, -0.03389529f, 
    0.11286049f, 0.04053913f, -0.00504419f, 0.07257358f, 0.11670889f, 0.05374375f, 0.08585820f, 0.24757567f, 
    -0.01932568f, -0.05121157f, 0.00818165f, 0.17039442f, -0.03337853f, 0.00934354f, -0.06735678f, -0.02397650f, 
    0.18609455f, 0.04461798f, 0.01772424f, -0.04135296f, 0.02488590f, 0.04556146f, 0.04516869f, 0.14944130f, 
    -0.03758118f, 0.13938260f, 0.06477365f, -0.21098921f, 0.33067572f, -0.03515159f, 0.11765224f, 0.10188667f, 
    0.02698818f, 0.01466188f, -0.02792967f, -0.07377806f, 0.06896210f, 0.02082107f, -0.07534376f, 0.04316675f, 
    -0.06519538f, -0.18242800f, -0.12640126f, -0.41537711f, 0.00009655f, 0.04785900f, -0.02797858f, 0.00535652f, 
    -0.09566082f, -0.18912646f, -0.07095771f, -0.29635930f, -0.07742237f, -0.11140943f, 0.03560870f, 0.25642899f, 
    0.12858811f, 0.08081333f, -0.12272047f, 0.00641433f, 0.09021776f, -0.11927086f, 0.17808487f, -0.03897321f, 
    0.08764385f, 0.05119516f, -0.00993109f, -0.03616054f, -0.05599413f, 0.00348482f, -0.05792645f, -0.09328753f, 
    0.10986461f, -0.00818993f, 0.09031976f, 0.02762564f, 0.08791400f, -0.11647602f, -0.03029109f, 0.08088495f, 
    -0.01335353f, 0.01346136f, 0.13057971f, -0.10824531f, -0.03182197f, 0.00202172f, 0.04563098f, 0.04131893f, 
    -0.08537828f, -0.13175124f, -0.06926341f, 0.00107188f, -0.04925929f, 0.07609781f, -0.02148244f, 0.09069988f, 
    0.02698803f, 0.05776211f, -0.05133380f, 0.07442053f, 0.08943819f, 0.31358445f, -0.01788123f, 0.18350464f, 
    -0.05277117f, 0.06494987f, 0.04547699f, 0.04790168f, 0.01560413f, 0.02744926f, 0.10064511f, -0.10752341f, 
    -0.39375773f, 0.19462043f, -0.16274194f, 0.00524583f, -0.02749763f, 0.12418563f, -0.01395464f, -0.06377605f, 
    0.10468784f, -0.06315637f, 0.09399361f, -0.01655925f, -0.12541743f, -0.09039138f, -0.01900738f, -0.14817137f, 
    0.01361727f, -0.01437583f, 0.02855748f, 0.15107584f, -0.05709930f, 0.05541313f, -0.00049982f, -0.07967842f, 
    0.05221415f, -0.02099067f, 0.09830845f, -0.01816462f, -0.17127876f, -0.18826874f, -0.07038232f, -0.10300611f, 
    0.02764870f, -0.10155448f, -0.05673958f, -0.06089656f, 0.10726923f, -0.12403065f, -0.00332918f, 0.05961765f, 
    -0.00481384f, 0.14868988f, 0.15497679f, -0.05458317f, 0.04242123f, -0.01808687f, 0.12463152f, 0.01306639f, 
    -0.04707642f, 0.17569302f, 0.05869072f, 0.26163343f, 0.04047404f, 0.15963681f, 0.14651901f, 0.07968094f, 
    0.00749138f, 0.06378546f, -0.07170006f, -0.03569514f, -0.07741655f, -0.12102250f, -0.02002058f, -0.01825397f, 
    0.09560484f, -0.11412713f, 0.02636950f, 0.17951901f, -0.01671345f, 0.05004327f, -0.01590342f, 0.11417890f, 
    0.02384965f, 0.08146790f, 0.01502134f, -0.03055680f, 0.09630974f, -0.08747296f, 0.01739166f, -0.04599338f, 
    0.08665907f, 0.05035130f, -0.02663648f, -0.01800870f, 0.17817673f, 0.05744979f, 0.23783173f, 0.15189905f, 
    -0.03976422f, -0.08058812f, -0.05976191f, -0.08674581f, 0.08848456f, 0.10041223f, -0.12922457f, -0.21265747f, 
    0.50531954f, 0.06638724f, 0.04664940f, 0.12656204f, -0.06840698f, -0.06575041f, -0.11501403f, -0.00049900f, 
    0.12594791f, 0.09596848f, -0.09864576f, -0.05013226f, -0.03017353f, 0.44715834f, -0.17729680f, 0.00745662f, 
    -0.11001752f, -0.03877137f, -0.03275054f, 0.01059563f, -0.02304930f, -0.07575776f, -0.07444679f, 0.07001287f, 
    0.08369880f, -0.22908375f, 0.19649768f, 0.03709557f, 0.00066453f, -0.00514997f, 0.10809310f, -0.02777310f, 
    0.05259555f, -0.02126886f, -0.17046329f, 0.09489301f, -0.03092904f, -0.11110047f, -0.03929057f, -0.04963741f, 
    -0.08034036f, 0.03592093f, 0.07429706f, -0.13804403f, -0.11750838f, 0.11141843f, -0.07332059f, 0.14914882f, 
    0.20893238f, -0.45356479f, 0.34225637f, -0.22559407f, -0.08469649f, -0.02722425f, -0.00660299f, 0.02314346f, 
    -0.03448794f, -0.04182808f, -0.06075008f, 0.00001037f, 0.32875180f, 0.00888658f, 0.27628267f, 0.09467094f, 
    0.05629738f, 0.04334581f, -0.03876053f, 0.03838716f, -0.16276018f, -0.00144042f, 0.17488982f, 0.03362480f, 
    -0.35123670f, 0.04670347f, -0.17432657f, -0.05637745f, 0.01669998f, 0.04773273f, -0.11709718f, -0.10933945f, 
    0.03494019f, -0.00352175f, -0.02689708f, -0.01755832f, -0.05860221f, 0.11520701f, -0.00108747f, -0.07296249f, 
    -0.06126504f, -0.05783931f, -0.12535550f, -0.02665454f, -0.13448001f, -0.04735330f, 0.00244886f, 0.06373090f, 
    0.07277762f, -0.04535784f, -0.07288453f, 0.33071145f, 0.00929169f, -0.00746283f, 0.11861245f, -0.01371202f, 
    -0.04193988f, 0.10128240f, 0.00097233f, -0.01876866f, 0.06417057f, -0.06304478f, 0.04105595f, -0.03141484f, 
    0.04645575f, 0.03054313f, 0.13901089f, -0.04222575f, -0.10664589f, 0.06343705f, 0.03594942f, 0.12902658f, 
    -0.17955703f, -0.07476033f, 0.09268448f, -0.06648929f, -0.02562116f, 0.25700727f, 0.00353881f, -0.04871180f, 
    0.05664078f, 0.03004324f, 0.10935222f, 0.10519646f, 0.26874730f, 0.01417313f, 0.02711903f, 0.27805397f, 
    -0.03154213f, 0.03791514f, 0.05000655f, 0.07376654f, 0.06579475f, 0.00614637f, 0.03516422f, -0.04178900f, 
    0.23758540f, 0.04179223f, 0.43078685f, -0.10392265f, -0.00995022f, -0.01301022f, 0.07974518f, 0.05713005f, 
    0.05855304f, 0.12236711f, 0.11011045f, 0.01403301f, -0.48546165f, 0.27717647f, -0.37313744f, -0.05144982f, 
    -0.08570398f, -0.03544690f, 0.08213590f, 0.02846021f, -0.07552758f, 0.05467144f, -0.08483216f, 0.07816448f, 
    -0.19947042f, 0.11364838f, -0.02743878f, 0.00637645f, 0.06371289f, -0.03604101f, 0.02510144f, -0.04290818f, 
    -0.05694691f, 0.08961252f, 0.03622673f, -0.11435540f, -0.22162028f, 0.09028142f, -0.14366829f, -0.22870342f, 
    0.16504626f, 0.15504676f, 0.01845443f, -0.05981611f, 0.06408722f, -0.00849177f, 0.09720970f, 0.01192347f, 
    -0.16141486f, 0.07996926f, -0.17450412f, 0.19337606f, -0.10688186f, 0.10818213f, 0.00935186f, -0.03953431f, 
    -0.01356412f, 0.02844083f, -0.03573493f, -0.00794418f, 0.01307915f, 0.28104243f, 0.08976924f, 0.17914040f, 
    -0.10440125f, 0.08182621f, 0.15494585f, 0.03306914f, -0.11200006f, 0.08831850f, 0.11724313f, -0.01018951f, 
    -0.35057971f, 0.00069959f, 0.08440468f, 0.08519261f, 0.03707804f, 0.09670435f, 0.02950336f, -0.03156427f, 
    -0.03186543f, 0.01911800f, 0.12661459f, -0.06267352f, 0.11144583f, -0.03875080f, 0.15694840f, -0.10921678f, 
    -0.08370759f, -0.01754035f, 0.03406908f, -0.12581889f, -0.16711327f, 0.04226839f, -0.05971194f, -0.04492262f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.11872018f, 0.10836136f, -0.01489192f, 0.07270315f, -0.06244494f, -0.01316852f, -0.02890981f, 0.01554957f, 
    0.06573457f, -0.04342736f, -0.05955286f, -0.02486641f, -0.05379585f, -0.01309901f, -0.05621885f, 0.17662752f, 
    0.07770757f, 0.04668872f, 0.08652101f, -0.02408200f, -0.07048933f, -0.03263059f, -0.03836570f, 0.15510464f, 
    0.01857830f, 0.04630813f, 0.02277518f, 0.02129943f, -0.01156326f, 0.04238951f, 0.22059366f, -0.01178970f, 
    0.02798533f, 0.03144123f, 0.09064452f, 0.03683562f, -0.05496788f, 0.08269352f, 0.09388106f, 0.16303131f, 
    0.05393553f, -0.02568799f, 0.09739079f, 0.03834596f, 0.15143661f, -0.03109353f, 0.00753898f, 0.06737789f, 
    -0.02102016f, -0.10093965f, 0.10235276f, 0.06679037f, 0.02600800f, -0.04884284f, -0.02950364f, -0.04662239f, 
    0.01130668f, 0.02747282f, 0.02648776f, -0.01763599f, 0.02392635f, 0.01687021f, -0.06325529f, 0.03978281f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.20668828f, -0.54214722f, -0.09217266f, 0.09492658f, 0.07253417f, -0.08779529f, 0.20571384f, 0.00861686f, 
    -0.32721677f, 0.10272697f, 0.20624554f, 0.00120396f, 0.04531490f, -0.09065600f, 0.06019990f, -0.12488322f, 
    0.18440412f, -0.45688275f, -0.07791492f, -0.30849111f, 0.10775350f, -0.00376994f, -0.07802591f, 0.01120929f, 
    -0.00791464f, -0.21710999f, 0.02615693f, -0.40412068f, -0.05983963f, -0.06947459f, -0.35833484f, 0.15543094f, 
    0.13806751f, -0.48530555f, 0.07745031f, 0.11541351f, 0.00567917f, 0.07939366f, 0.22454982f, -0.45890784f, 
    0.21342424f, -0.10010836f, -0.32100174f, -0.04062344f, -0.11451849f, 0.05958310f, 0.14463943f, 0.22298294f, 
    -0.02445550f, 0.19951965f, -0.25440904f, 0.05947335f, -0.07349380f, -0.08902294f, 0.10864832f, -0.11230523f, 
    -0.00812410f, 0.00064526f, 0.10628415f, 0.07809058f, -0.29938093f, -0.26749519f, 0.16457605f, -0.03266756f, 
    0.10431451f, -0.27066493f, 0.11452775f, 0.07694121f, -0.07345200f, 0.02493040f, -0.16680035f, -0.43512952f, 
    0.26854631f, -0.01749925f, 0.25400627f, -0.37252581f, -0.12042946f, 0.07530392f, 0.06440607f, 0.34556687f, 
    -0.15565585f, 0.10418027f, -0.06790387f, -0.14124103f, 0.08865499f, -0.13709262f, 0.02359452f, 0.20328781f, 
    0.10709323f, 0.10694001f, -0.33851793f, -0.14896908f, -0.00531829f, -0.04998131f, 0.15262672f, -0.15114576f, 
    -0.03690229f, -0.45535114f, 0.00002224f, -0.18169031f, 0.08731296f, 0.17499059f, 0.32421100f, -0.05827218f, 
    -0.14741336f, -0.06294580f, -0.11344308f, 0.00558372f, 0.14493543f, -0.02487015f, 0.25589600f, 0.01871927f, 
    0.08567166f, -0.47697312f, 0.02008801f, 0.42100286f, -0.07609499f, -0.09686905f, -0.04653151f, -0.06908464f, 
    0.02635355f, -0.19445579f, 0.07024954f, -0.07704866f, 0.08127162f, 0.25814214f, -0.55018872f, 0.28100309f, 
    -0.03239157f, 0.04987374f, -0.05046387f, -0.29556531f, -0.27551836f, 0.02696756f, -0.13343593f, 0.04825890f, 
    0.05918398f, 0.03727324f, -0.59465003f, -0.17962502f, 0.05245873f, 0.11396803f, -0.12602077f, -0.47336152f, 
    0.24395391f, 0.22660275f, 0.13903388f, -0.04727529f, -0.08759934f, 0.14306264f, -0.05659134f, 0.35874233f, 
    -0.23950389f, -0.05511752f, 0.13230029f, 0.11467829f, 0.02183713f, -0.12434107f, 0.36359483f, 0.15699545f, 
    0.21836302f, -0.27802986f, 0.12083668f, -0.20341216f, 0.00784760f, 0.22066741f, 0.11790886f, -0.14292268f, 
    -0.20320182f, -0.12649265f, -0.03038371f, 0.06252362f, -0.48559424f, 0.01932449f, 0.08016302f, -0.07485078f, 
    -0.08002084f, -0.20180140f, 0.02257382f, 0.39684555f, 0.11360650f, 0.06565887f, 0.08594976f, -0.04223170f, 
    0.02876664f, 0.06008524f, -0.03333313f, -0.02990012f, -0.04263178f, -0.55073678f, -0.55829972f, 0.26018500f, 
    -0.43255484f, 0.22663714f, 0.02152235f, 0.09738659f, -0.07013549f, 0.01089470f, -0.00332622f, -0.25741652f, 
    -0.34970105f, 0.12496254f, 0.00547239f, 0.05363156f, -0.09167916f, -0.04471468f, 0.25507915f, -0.55800021f, 
    -0.06400834f, -0.03978887f, -0.25973919f, 0.20454480f, 0.09017102f, 0.39774394f, 0.08386385f, -0.01615532f, 
    0.03815571f, 0.14948799f, 0.13448745f, 0.12096507f, -0.07511381f, 0.04221484f, 0.01633080f, 0.21918240f, 
    0.40228954f, 0.17231193f, 0.00230891f, -0.64707756f, -0.08718292f, -0.13440080f, -0.14384040f, -0.21429540f, 
    -0.28425246f, -0.10801471f, -0.18294117f, 0.04437450f, -0.36243609f, 0.03388955f, -0.14108454f, -0.15231420f, 
    -0.01222201f, 0.20388430f, -0.40002179f, 0.04774518f, -0.03304739f, -0.07976913f, 0.19664283f, 0.09045058f, 
    0.00022213f, 0.13544574f, -0.01095205f, 0.09066133f, 0.03137255f, -0.15937775f, 0.21603678f, -0.05729158f, 
    -0.19459236f, 0.00128590f, -0.02008456f, -0.34050566f, 0.13661018f, 0.02641424f, -0.08792511f, 0.26255336f, 
    0.11052150f, 0.10999720f, 0.17746133f, 0.20768349f, 0.03388468f, -0.07458864f, -0.04290819f, -0.15604179f, 
    0.13549691f, 0.19354171f, 0.15298323f, -0.04809750f, -0.03215098f, -0.44546932f, -0.06799175f, -0.28525615f, 
    0.14273311f, 0.02687476f, 0.17066762f, 0.00841284f, -0.01905351f, -0.04873748f, -0.25626352f, -0.20457859f, 
    -0.19375947f, -0.02286788f, 0.07753422f, -0.09121548f, -0.06994500f, -0.32973737f, -0.11227440f, -0.07149999f, 
    -0.07229010f, 0.11102566f, -0.35292155f, -0.05600172f, -0.21160537f, 0.07952167f, 0.15048735f, 0.06718074f, 
    -0.05055493f, 0.29154038f, 0.23854610f, -0.20840301f, 0.01983604f, 0.02167130f, -0.14428940f, -0.09707307f, 
    -0.02462900f, 0.14908144f, -0.03510409f, -0.03240491f, 0.00996485f, 0.04584982f, 0.24525347f, -0.17729433f, 
    0.22691792f, -0.10515511f, -0.07206044f, 0.17033292f, 0.21375588f, 0.07796017f, 0.16310036f, -0.27712083f, 
    -0.32645935f, -0.11529008f, 0.12849496f, 0.17978983f, 0.05490988f, 0.03533036f, -0.18471302f, 0.02095000f, 
    0.05990140f, -0.41108575f, 0.04492326f, -0.18094197f, 0.06839211f, -0.47429684f, -0.11025321f, 0.07871477f, 
    0.25715715f, -0.32759222f, 0.01852865f, 0.17957401f, -0.02254934f, 0.10301746f, 0.20387238f, 0.07577013f, 
    -0.36792082f, 0.23757142f, -0.11911311f, 0.25977668f, 0.03739128f, -0.22203733f, -0.16759939f, 0.07571400f, 
    0.09744034f, 0.11628652f, 0.06017379f, 0.02914011f, 0.37134105f, 0.05458415f, -0.13375469f, 0.18848541f, 
    0.07216657f, -0.19300856f, 0.18092194f, -0.08164359f, -0.08323873f, 0.03472883f, -0.30243266f, 0.08280232f, 
    -0.03648788f, 0.06110541f, 0.05444129f, -0.10819742f, 0.03015115f, 0.01287313f, -0.18881664f, -0.31504798f, 
    0.17519820f, 0.24908686f, -0.01371291f, 0.04443736f, -0.66113615f, -0.03040891f, -0.57215697f, 0.28353256f, 
    0.20597647f, 0.00955644f, -0.52878278f, -0.02968793f, -0.00056828f, 0.06805465f, -0.39944774f, -0.04779256f, 
    -0.06521675f, 0.18688856f, 0.04608339f, -0.04870763f, -0.07603470f, 0.21339406f, -0.10729661f, 0.30686724f, 
    -0.54585743f, -0.27001536f, 0.16465941f, -0.11094910f, 0.02949941f, -0.04355019f, -0.03852827f, -0.47684789f, 
    0.00573250f, 0.20694809f, 0.14625293f, -0.00853682f, -0.01847944f, 0.17677253f, -0.39374360f, -0.00245333f, 
    0.27950308f, 0.01373804f, 0.18654525f, 0.06048206f, -0.38882470f, -0.02459680f, -0.47221479f, -0.27163306f, 
    0.10553154f, -0.17796673f, 0.04818175f, -0.44363120f, -0.02966164f, 0.08371915f, -0.44815406f, -0.09671300f, 
    0.07849318f, -0.21655142f, 0.10319947f, 0.07666540f, -0.13330498f, 0.26757234f, -0.06190937f, 0.14898463f, 
    0.08631564f, -0.10821079f, -0.04478306f, -0.20455320f, 0.20667270f, -0.09445557f, 0.34950608f, -0.03396390f, 
    0.08387487f, 0.00322741f, -0.35988173f, 0.27710479f, -0.06814301f, -0.05566482f, 0.04838992f, -0.05154526f, 
    -0.35548231f, -0.05944168f, 0.19248661f, 0.12371854f, -0.33483109f, 0.26424634f, -0.07307145f, -0.28486830f, 
    -0.36154118f, 0.09742650f, 0.38950455f, 0.18431050f, -0.03695409f, 0.06043155f, -0.42485285f, 0.41920251f, 
    -0.07905792f, -0.35184363f, -0.42961392f, 0.24139310f, -0.06280772f, -0.07857820f, -0.26470655f, -0.21393451f, 
    -0.53514171f, 0.09250326f, -0.03846869f, 0.00272005f, 0.02370742f, -0.07779995f, -0.33221203f, -0.00788442f, 
    0.07814555f, -0.05140729f, -0.22442649f, -0.15440156f, -0.13077186f, -0.13392349f, -0.13083455f, -0.06899682f, 
    0.06323255f, 0.11847004f, 0.09836383f, 0.03605975f, 0.18750240f, 0.16017941f, -0.03344076f, -0.17205995f, 
    0.24064478f, 0.17282878f, 0.00205614f, 0.21274784f, -0.76435387f, -0.09058672f, 0.32999524f, -0.40561557f, 
    -0.04598505f, 0.01242146f, -0.61073232f, -0.56597453f, -0.06261899f, -0.06583279f, 0.08254431f, 0.09817100f, 
    -0.47117504f, -0.27189139f, -0.24788128f, -0.11840869f, -0.05257416f, -0.23580059f, 0.01072471f, -0.36678824f, 
    0.24332546f, 0.17590359f, 0.30689269f, 0.06131154f, -0.02879295f, -0.02330595f, 0.34479630f, 0.04462595f, 
    0.13145086f, 0.12739152f, -0.41335797f, 0.26181233f, 0.11032321f, 0.23881064f, -0.21788394f, 0.05676533f, 
    0.09643336f, -0.03206820f, 0.24187961f, -0.09884197f, 0.07522102f, -0.00309133f, -0.38107416f, 0.17069544f, 
    -0.03046624f, -0.33318448f, -0.52386820f, 0.02154693f, -0.04217815f, 0.09511916f, 0.06331123f, 0.02540827f, 
    -0.02310761f, -0.36923900f, -0.01899587f, 0.10879511f, 0.13677752f, -0.31886053f, -0.27071711f, -0.25411898f, 
    -0.28218672f, 0.05774197f, 0.09161849f, -0.53678340f, 0.47101417f, 0.07818469f, -0.30595112f, 0.26264328f, 
    0.03449408f, 0.05951194f, -0.13748966f, -0.03935681f, -0.07216141f, 0.08208767f, -0.22412358f, 0.04481784f, 
    0.26817268f, 0.06562957f, 0.15147056f, -0.04636505f, -0.45418480f, -0.01045457f, 0.05389236f, -0.10375743f, 
    0.06287514f, 0.00519465f, 0.02205239f, -0.30426610f, 0.07335249f, 0.04628017f, -0.51332372f, 0.24436738f, 
    -0.61362135f, 0.04451148f, 0.20349312f, 0.38092330f, 0.04066625f, -0.09654078f, -0.24411003f, 0.03581727f, 
    0.00099022f, -0.08655918f, 0.19212741f, 0.06314931f, 0.19375260f, -0.07658431f, 0.04298355f, -0.44366798f, 
    -0.04342995f, -0.34858391f, 0.08211484f, 0.12388940f, -0.06379669f, 0.04326846f, 0.11867211f, 0.06482444f, 
    -0.05977257f, -0.32869080f, 0.01146162f, -0.00418343f, 0.09319112f, -0.15248220f, 0.24373375f, -0.24175100f, 
    -0.08204022f, 0.37461337f, -0.02382513f, 0.09508947f, -0.06937694f, 0.10217778f, 0.09652861f, -0.18167506f, 
    -0.05721047f, -0.00400610f, -0.08512060f, -0.45677805f, -0.06371168f, -0.13352993f, 0.32334223f, -0.36268866f, 
    0.00181827f, 0.00582040f, -0.28097293f, -0.15167603f, 0.25498229f, 0.12597215f, 0.09730430f, 0.01087697f, 
    -0.52459371f, 0.24545050f, -0.41694960f, -0.16570270f, 0.07943895f, 0.03602342f, 0.21125421f, -0.51791191f, 
    -0.01149270f, -0.04450142f, -0.20998167f, -0.37855119f, -0.06085026f, -0.30208108f, -0.02763760f, 0.22968349f, 
    0.29401639f, 0.03204055f, -0.23895907f, -0.01958377f, 0.40238369f, 0.06251966f, 0.09769426f, -0.11342158f, 
    0.10939363f, -0.31005982f, 0.29884973f, -0.49270889f, -0.09803962f, -0.06765690f, 0.25601146f, 0.06084422f, 
    -0.10584847f, 0.35098395f, -0.10092483f, -0.04741375f, -0.02348671f, -0.30544156f, -0.09499249f, 0.40585464f, 
    -0.12630089f, 0.11965064f, -0.03673926f, 0.42045248f, -0.40342355f, 0.07623170f, -0.05747218f, -0.06085029f, 
    -0.31632823f, -0.00025183f, -0.18445714f, 0.45002693f, 0.03548091f, -0.01709254f, -0.07155477f, -0.05390957f, 
    -0.59079653f, 0.12929560f, -0.45822108f, 0.19690950f, -0.50094444f, 0.28573653f, -0.08100954f, -0.55746073f, 
    -0.01787503f, -0.06171882f, -0.47543105f, 0.27565163f, 0.06817597f, 0.02278732f, -0.19054595f, -0.26094639f, 
    0.08624331f, 0.36054268f, 0.14086655f, -0.34657934f, 0.04825884f, 0.03180723f, 0.33827776f, 0.30339390f, 
    0.09489419f, -0.00805876f, -0.07608712f, -0.12783991f, -0.47992423f, 0.01010912f, 0.10314555f, -0.13534488f, 
    0.03711413f, -0.04612243f, 0.21105801f, -0.12052200f, -0.07338487f, 0.11843669f, 0.28653729f, 0.05788743f, 
    0.09540482f, -0.20246498f, -0.02809193f, -0.08739975f, 0.17524755f, -0.00841035f, -0.22628997f, -0.40610144f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.18028156f, 0.13555773f, 0.12039352f, -0.12112615f, -0.13706031f, 0.07899333f, 0.06394343f, -0.00690443f, 
    0.03844003f, 0.08620131f, -0.10663500f, -0.03176289f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
