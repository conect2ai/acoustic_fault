#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.94526917f, 1.07812738f, 0.50907201f, -0.58498544f, 1.06763256f, 0.54115546f, -0.60881847f, 0.27559146f, 
    0.17778818f, -1.44300985f, 0.62578285f, 0.27401215f, 0.19375454f, 0.60798174f, -0.19675344f, -0.48158935f, 
    -0.14558241f, -0.55086291f, 1.15328550f, 0.98243749f, -0.74963808f, -0.70753264f, 0.89850831f, 0.71942830f, 
    -0.25055841f, 0.15605786f, 0.25883284f, -0.37679887f, -0.70475769f, -0.76257676f, 0.26620546f, 1.06951761f, 
    0.89213502f, -0.03750630f, 0.09870316f, 0.32585359f, 0.42934200f, 1.21695542f, 1.04275322f, 0.59482914f, 
    0.05862467f, -0.06890478f, -0.42388883f, -0.17981264f, -0.30871326f, -0.86539662f, -0.41100040f, 0.00161469f, 
    -0.82774121f, -0.53800058f, -1.22303975f, 0.63951015f, -0.27880114f, 0.34872097f, -0.74748540f, -1.67223644f, 
    -0.11032240f, 0.85335016f, 0.89183432f, 0.31151921f, -0.22806261f, -0.27673000f, -0.35307971f, -0.23529623f, 
    -0.03057887f, -0.89467692f, 0.87337142f, 1.01715195f, -1.26588738f, -0.33701274f, -0.36926544f, 0.60857785f, 
    -0.77421439f, 0.13770758f, -0.22871824f, -0.63061714f, 0.69794321f, -0.49286589f, -0.83636630f, 0.87550080f, 
    0.30491108f, -0.18145880f, 0.30694023f, -1.04967725f, 0.87068111f, -0.60944331f, 0.58412862f, -0.79046226f, 
    -0.58724982f, -0.08764020f, 1.30023587f, 0.84029138f, -1.05617702f, 0.53329068f, 0.24400294f, -0.51242912f, 
    -0.20090023f, 0.25129515f, -0.01670178f, 0.88356006f, 0.81846029f, 0.94117540f, 0.24584359f, -0.22382241f, 
    0.33388641f, -0.09878144f, 0.39449662f, 0.43779498f, 0.68334216f, 1.12223864f, -0.12227274f, 0.63456756f, 
    0.58618420f, 0.84958613f, -0.51630467f, -0.49509367f, -0.00753543f, -1.00154853f, -1.25030816f, -0.47256729f, 
    0.70491892f, -0.29333836f, 0.04723772f, -0.25644726f, -0.13991661f, 0.52519089f, 0.79568970f, 0.90827441f, 
    0.63233578f, -0.00239467f, -0.38007537f, 0.52389461f, -0.21820040f, -0.66549671f, -0.65662742f, -1.30931890f, 
    0.66711545f, 1.31694829f, 0.09600262f, -0.55396843f, 0.04558011f, -0.08651281f, 0.22511311f, -0.44911948f, 
    -1.46642017f, 0.26576439f, 0.55766410f, 0.71925557f, 0.72207475f, 0.73532665f, 0.19210789f, -0.16774043f, 
    0.23672760f, -0.72909814f, -1.09766221f, -0.32622147f, -0.92714596f, 0.47959986f, 0.98447317f, -0.36785895f, 
    -0.56373525f, -0.50830132f, -0.37159041f, 0.87474793f, 0.17145079f, 0.46110153f, -1.08229399f, 0.79654735f, 
    -0.34751323f, -0.28995159f, 0.29334423f, -0.74379629f, 0.77368730f, 0.59211600f, 0.73448294f, 1.03862441f, 
    0.35754511f, -0.11919611f, -0.54597217f, 0.13051338f, 0.69505125f, 0.62311906f, 0.87114167f, 0.31997228f, 
    -0.99468815f, -0.56520170f, 0.62072080f, 0.80148268f, -0.03128472f, -0.43425450f, 0.72480315f, 1.43668115f, 
    0.69112962f, 0.56194603f, 0.18684763f, 0.46198279f, 0.44994897f, 0.34016964f, 0.91690606f, -0.61063361f, 
    -1.08664811f, -0.34360650f, -0.54283822f, -0.82386345f, 0.37432206f, 0.20403551f, 0.42758238f, 1.58682013f, 
    0.72594905f, 0.45577067f, -1.08537638f, -0.03196700f, -0.54627371f, -0.00948710f, 0.27394345f, -0.05931903f, 
    0.30843073f, 0.38691956f, -0.84345520f, 1.31425893f, -0.82810020f, 0.10545225f, 0.25204340f, -0.36917111f, 
    -0.23698279f, -0.70284104f, -0.31103167f, -0.77641010f, 0.09864566f, -0.56774324f, 0.61220956f, -0.65508765f, 
    -0.01682377f, -0.64126253f, -0.02319895f, 0.91397816f, -1.06390238f, 0.38492423f, -1.23759246f, -0.28992850f, 
    0.48120803f, 0.56085646f, -0.14249958f, 1.17752743f, -1.56589258f, 0.79592592f, 0.55138487f, 0.23085400f, 
    0.44050655f, -0.13441680f, 0.17052792f, -0.74125904f, 0.94186521f, -0.77028263f, -0.84557021f, -0.58096492f, 
    -1.17628276f, -0.80907571f, -0.50305194f, -0.52822727f, -0.24573757f, 1.17702317f, 0.96435070f, 0.61419183f, 
    -0.63775492f, -0.93908787f, -0.39060807f, 0.07680109f, -0.12466164f, 0.49874690f, 0.37386271f, -1.38934219f, 
    -0.85892987f, -0.13832529f, 1.04020309f, 0.26662537f, -0.56397301f, 0.51751381f, -0.27206087f, 0.73577106f, 
    0.74880379f, -1.11314619f, 0.32019508f, -0.31614006f, -0.89574021f, -0.09677223f, -0.06785112f, 0.76455909f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.18430534f, -0.01416222f, 0.45552468f, 0.27387762f, 0.00680262f, 0.27185154f, 0.31543034f, -0.04630888f, 
    0.03975908f, -0.13841957f, 0.23304328f, 0.36851788f, -0.05879314f, 0.27106145f, 0.38474751f, 0.08346039f, 
    0.27551839f, 0.00511243f, 0.03632205f, -0.05222046f, 0.12886441f, 0.24917012f, 0.42528951f, 0.16720387f, 
    -0.02750808f, 0.07095844f, 0.07823846f, 0.00208366f, 0.02706076f, 0.09490353f, -0.00519333f, 0.30427998f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.05958537f, 0.14034078f, 0.10183516f, -0.03889666f, 0.27551195f, -0.00733992f, -0.01285470f, 0.02899290f, 
    0.05729328f, -0.06379382f, 0.00131226f, -0.03267186f, 0.00910943f, 0.01025300f, -0.02440749f, 0.10715397f, 
    0.02937887f, -0.01800148f, 0.15078986f, -0.01310397f, 0.35695496f, 0.13399422f, 0.27292505f, 0.04716646f, 
    -0.03468207f, 0.05884088f, 0.04612226f, 0.07913074f, 0.13117541f, 0.07853360f, 0.06490927f, 0.02012939f, 
    -0.02910628f, 0.00305283f, -0.09357087f, 0.04478274f, -0.06658229f, -0.09640135f, 0.07335089f, 0.04085990f, 
    -0.21862504f, 0.02314279f, 0.01639445f, -0.30474138f, 0.31460002f, -0.20378341f, -0.09094168f, -0.16398576f, 
    0.08748376f, -0.02841575f, -0.10551826f, -0.03123388f, 0.11756109f, 0.00610377f, 0.01414583f, -0.09934133f, 
    0.01691750f, -0.08169414f, 0.00678831f, -0.07181651f, -0.17273894f, 0.28289828f, -0.12314353f, -0.36407539f, 
    -0.16644174f, 0.08158950f, 0.04368953f, 0.00329035f, 0.08508887f, -0.08765031f, 0.00307216f, -0.00222831f, 
    0.00669936f, 0.05887247f, 0.05386009f, -0.03837408f, 0.04571458f, 0.00849433f, 0.01062715f, 0.04924048f, 
    -0.06993906f, 0.14269525f, 0.01169896f, 0.00949139f, 0.17848924f, -0.09004880f, -0.25846031f, 0.05392662f, 
    0.00631070f, -0.07431378f, 0.02585551f, 0.02552385f, -0.10679836f, 0.12907813f, -0.05704085f, 0.04671298f, 
    0.07497419f, -0.04903584f, -0.06267061f, 0.07418360f, -0.27815855f, -0.49876747f, 0.02926816f, 0.12653358f, 
    -0.07350473f, -0.08484491f, -0.11513388f, -0.08953912f, 0.08837189f, 0.04740307f, 0.05555823f, 0.02491320f, 
    -0.08142279f, -0.00012061f, -0.13361287f, 0.00274341f, -0.09246763f, 0.02927750f, 0.08787675f, -0.13929057f, 
    -0.24576738f, 0.20413391f, 0.16106802f, -0.12195609f, -0.49230200f, 0.10641245f, 0.03425295f, 0.05839661f, 
    0.05830062f, -0.08275688f, 0.00961936f, -0.01346218f, -0.01547636f, -0.00172024f, -0.03089173f, 0.03680573f, 
    0.09226662f, 0.00894407f, 0.03959487f, 0.03411465f, 0.48078313f, 0.13428088f, 0.07668048f, -0.07797601f, 
    0.11345191f, -0.09613129f, -0.08264198f, -0.01075810f, -0.10861741f, 0.00201127f, 0.07391112f, 0.11343204f, 
    -0.06481547f, 0.08886339f, -0.00044116f, -0.09464584f, -0.09962330f, -0.06088867f, -0.19304848f, 0.01504004f, 
    -0.04685307f, -0.18325545f, 0.03513866f, -0.07640745f, -0.08253868f, -0.00140719f, 0.10146935f, -0.15640125f, 
    0.12920673f, 0.05797429f, -0.02643771f, 0.06338720f, 0.07196228f, -0.11790365f, 0.09615966f, -0.10939520f, 
    -0.05907837f, 0.03428807f, -0.00180542f, -0.03901237f, 0.24830070f, -0.11857861f, 0.00899014f, 0.06569156f, 
    -0.09594747f, 0.01972409f, 0.06135353f, 0.07459074f, -0.09682810f, -0.14223023f, 0.07822277f, 0.05394046f, 
    -0.06866135f, 0.02837862f, 0.08003418f, 0.06078149f, 0.05128995f, 0.04520378f, -0.13552174f, -0.02618189f, 
    0.01340351f, 0.05535717f, -0.01175601f, -0.12385502f, 0.43416134f, -0.09486727f, -0.06560618f, -0.00045241f, 
    0.05762655f, -0.06317342f, 0.02295538f, 0.02303567f, -0.06714321f, 0.00386221f, -0.13188779f, -0.00407863f, 
    -0.01736499f, 0.01763437f, 0.06945355f, 0.07141697f, 0.18833223f, 0.08478816f, -0.03766412f, -0.21873158f, 
    -0.00326533f, -0.03964525f, -0.14707513f, -0.06755845f, 0.02477091f, -0.05916910f, -0.00874388f, -0.08810079f, 
    -0.07237789f, 0.03659929f, -0.14102979f, -0.08926978f, -0.00604770f, -0.00887419f, 0.03279470f, 0.00565043f, 
    0.06944823f, 0.05380118f, -0.07117922f, -0.13390924f, 0.24673972f, -0.08199508f, -0.00683736f, 0.07238001f, 
    0.05157211f, -0.11745996f, 0.01547679f, 0.08123146f, -0.00506028f, 0.03720418f, 0.02931895f, 0.06162429f, 
    0.07592867f, 0.02872852f, -0.08879245f, 0.14232263f, -0.15286545f, -0.23478854f, -0.02225906f, -0.09570502f, 
    -0.38329902f, -0.05251835f, 0.06599488f, -0.13290936f, 0.10795389f, -0.09622160f, -0.12189217f, -0.00801064f, 
    -0.06809024f, -0.07755319f, 0.04536491f, 0.04373247f, -0.04854059f, 0.03295025f, -0.07745044f, -0.07268937f, 
    0.15225144f, 0.08221002f, 0.08510247f, -0.06302159f, 0.07525088f, -0.19426160f, -0.18988256f, -0.04298085f, 
    0.01730612f, 0.01668709f, 0.00924302f, 0.11563272f, -0.00107695f, -0.07390609f, 0.13141130f, 0.09454674f, 
    0.06318858f, -0.11889143f, 0.00865964f, 0.04556755f, -0.63941175f, 0.17384709f, 0.08380007f, 0.16942711f, 
    0.06711465f, -0.05137414f, -0.09035817f, 0.02790809f, 0.04568980f, -0.01405638f, 0.07743675f, 0.00048661f, 
    0.09660757f, 0.02925118f, -0.14399630f, -0.06095472f, -0.16003555f, -0.04325566f, 0.00248572f, -0.04686879f, 
    0.35317340f, -0.00286269f, 0.22826433f, -0.03593525f, 0.01149525f, -0.02467662f, 0.01679309f, -0.00790412f, 
    -0.00490631f, -0.08826477f, 0.01373636f, -0.14863208f, 0.06275507f, -0.06758933f, 0.06066735f, 0.02246858f, 
    -0.08520380f, -0.09365650f, 0.08654875f, -0.01088198f, -0.29835457f, 0.24828310f, -0.12028447f, -0.02722757f, 
    -0.26558155f, -0.08164286f, 0.14818302f, -0.21913169f, 0.14362693f, -0.00256665f, 0.09540079f, 0.10562967f, 
    -0.00243800f, -0.00186701f, -0.03389006f, -0.00004829f, -0.09152206f, -0.08040925f, 0.16882154f, -0.01761016f, 
    -0.19439094f, 0.07021958f, 0.18721792f, 0.19512217f, -0.09857184f, -0.06359476f, -0.01861766f, 0.04577948f, 
    -0.18248275f, -0.04098623f, -0.05135538f, 0.04937838f, -0.08487878f, 0.02401375f, 0.11644831f, -0.04254586f, 
    0.10608351f, 0.00009647f, -0.03681483f, 0.01286908f, 0.35236242f, 0.01587521f, 0.26616377f, 0.00348110f, 
    0.14347596f, -0.06062288f, -0.02360827f, 0.08014929f, 0.00191777f, -0.09631781f, 0.03129137f, -0.08147933f, 
    0.01265894f, 0.03221513f, 0.04202220f, 0.05734164f, -0.03206529f, -0.02501564f, 0.04712515f, 0.02191274f, 
    -0.01108832f, 0.01292581f, 0.13505380f, -0.11088821f, 0.02311042f, -0.13060926f, -0.03800232f, 0.01472555f, 
    -0.03169616f, -0.04275208f, 0.03604231f, 0.01644443f, -0.00460962f, 0.04197160f, -0.05506302f, -0.04998515f, 
    -0.05348614f, 0.05164956f, -0.02369614f, -0.04663235f, -0.24829800f, -0.14779049f, 0.14337537f, -0.04444774f, 
    0.04989281f, 0.09317538f, -0.10163151f, 0.13266627f, -0.12090115f, -0.05542077f, 0.10062775f, -0.03917542f, 
    0.09831318f, 0.08526118f, 0.02754575f, -0.07563470f, -0.06611057f, -0.02470479f, -0.09271730f, -0.03863708f, 
    -0.28276318f, -0.61440641f, 0.14891411f, 0.14254554f, 0.07697556f, -0.09688645f, 0.10342027f, 0.06124813f, 
    0.04788776f, 0.02086154f, -0.07424355f, -0.06221927f, 0.02921612f, 0.00137468f, -0.01627688f, 0.01487297f, 
    -0.14415735f, 0.05368009f, 0.05112828f, 0.02645448f, 0.20473133f, 0.15539739f, -0.04796444f, -0.17574626f, 
    0.12698938f, -0.05274478f, -0.12167515f, -0.15892771f, 0.07033750f, 0.07195988f, -0.07929874f, 0.02036972f, 
    0.02903794f, -0.07241425f, -0.02757267f, -0.09578709f, -0.00449573f, -0.02395015f, 0.12551989f, -0.01089430f, 
    0.36125827f, -0.60376465f, 0.15640348f, 0.04739089f, -0.02406240f, -0.11609509f, 0.11285962f, 0.03204293f, 
    -0.05581057f, -0.07219380f, -0.13974622f, 0.04963581f, -0.07945243f, 0.12190520f, -0.00564878f, 0.08597466f, 
    0.02082737f, 0.05407665f, -0.10178021f, -0.03729597f, 0.15332517f, -0.03892024f, -0.04419180f, -0.11430841f, 
    -0.28400642f, -0.01424397f, 0.09701895f, -0.01837687f, -0.00231634f, 0.03691449f, 0.02548598f, -0.14561620f, 
    0.01707897f, 0.01350549f, -0.05630067f, -0.02977126f, -0.09910198f, 0.00422151f, -0.02451882f, -0.01142510f, 
    0.18619552f, -0.30155918f, 0.16666982f, -0.00133544f, 0.12757586f, -0.13735095f, -0.03618582f, 0.04932750f, 
    -0.07779434f, 0.07931630f, -0.00024911f, 0.05684555f, -0.05110710f, 0.04493640f, 0.04724040f, -0.07011235f, 
    0.02757722f, -0.03976832f, 0.04247810f, -0.07142460f, 0.31062445f, -0.08848980f, 0.03507989f, -0.02289096f, 
    -0.40681300f, 0.00198728f, -0.02263171f, -0.04647250f, -0.01791513f, 0.05877158f, -0.17821832f, 0.10773433f, 
    -0.03818599f, -0.00601198f, -0.05933778f, 0.02765931f, -0.07729553f, 0.07220457f, -0.09974349f, 0.00231303f, 
    -0.05114298f, -0.60682422f, 0.26346645f, 0.30797204f, 0.02365305f, 0.06658860f, 0.05093009f, -0.00744356f, 
    -0.02433002f, 0.03466951f, -0.06401257f, -0.06943136f, 0.06708466f, 0.05253030f, 0.07572992f, -0.04898109f, 
    0.02006552f, 0.07091855f, 0.02934161f, -0.12562118f, 0.18662818f, 0.18746559f, 0.05097351f, -0.24792124f, 
    0.03426737f, -0.18384491f, -0.17738885f, -0.08643816f, 0.08560752f, -0.03710469f, -0.01560281f, -0.03758307f, 
    0.01144524f, -0.02556387f, -0.06792969f, 0.03202653f, 0.02827797f, 0.00456902f, 0.10195982f, 0.02232781f, 
    -0.05625482f, 0.05368391f, -0.07387864f, -0.20074767f, -0.29404005f, -0.07153282f, -0.05655530f, 0.06506136f, 
    -0.15978445f, 0.13791862f, -0.11899026f, 0.00887689f, 0.15493451f, -0.00504350f, 0.04913762f, -0.00630030f, 
    0.06411483f, -0.00222459f, -0.04928676f, 0.08467732f, -0.05313027f, -0.02603847f, 0.02593526f, -0.16703728f, 
    0.17304409f, -0.17703611f, 0.05575840f, -0.09642445f, 0.04789229f, -0.02969875f, -0.07795952f, 0.02258327f, 
    0.05440293f, 0.02582994f, -0.12821946f, 0.12241797f, -0.04497164f, 0.04138670f, -0.11320759f, -0.12823100f, 
    -0.32310078f, 0.22116381f, -0.09131183f, -0.18981835f, 0.04201427f, 0.05608452f, 0.08604169f, -0.02901627f, 
    -0.07322691f, -0.07762704f, 0.03804544f, -0.00194524f, 0.06253006f, -0.01778267f, -0.02067624f, -0.03264322f, 
    -0.07309180f, 0.09933430f, 0.00478548f, 0.06106769f, -0.60082769f, -0.03978584f, -0.28815916f, -0.18482400f, 
    0.14484105f, -0.05188794f, 0.00671316f, -0.04598057f, -0.02542877f, 0.13348946f, 0.07635403f, 0.17348678f, 
    -0.00448953f, -0.12402683f, 0.00972917f, -0.04430084f, -0.09734272f, 0.10692423f, -0.02437345f, -0.13821006f, 
    0.54319072f, 0.04037805f, 0.14829738f, -0.12853926f, -0.00871781f, 0.06877403f, -0.06963492f, -0.09904833f, 
    0.09410304f, -0.05563707f, -0.04628924f, 0.02958846f, -0.16252860f, 0.17204919f, -0.03395960f, 0.03297966f, 
    -0.09057929f, 0.13131964f, -0.01328442f, 0.00762784f, 0.26899016f, -0.02742713f, -0.13778739f, 0.00863453f, 
    -0.14839564f, 0.01139017f, 0.05123584f, -0.02314507f, -0.00673259f, 0.06837606f, -0.05441079f, -0.01519539f, 
    0.00547031f, 0.00210879f, -0.01473014f, 0.12187710f, -0.01642062f, 0.00316499f, -0.01790772f, 0.01971345f, 
    0.25668085f, 0.19559997f, 0.19991462f, -0.01028271f, 0.30507043f, -0.14276394f, -0.01753513f, 0.02804410f, 
    0.01420693f, 0.08363418f, -0.08190054f, -0.05225961f, 0.00232476f, -0.03576466f, -0.01071357f, -0.00847893f, 
    0.00098043f, 0.00726254f, -0.03248041f, 0.01985129f, -0.16459452f, -0.12596145f, -0.04213656f, -0.10164077f, 
    -0.15480916f, 0.17189814f, -0.01215243f, 0.08151234f, -0.01829067f, 0.03601997f, -0.08154619f, -0.06813845f, 
    0.12190510f, 0.01778506f, 0.08538417f, -0.00201759f, 0.14761008f, -0.10036018f, -0.13286765f, -0.13941357f, 
    0.36557484f, 0.00859310f, -0.26598513f, 0.01912129f, -0.30374539f, -0.02529455f, 0.03555954f, -0.02738237f, 
    -0.03566568f, 0.10411149f, 0.05168548f, 0.08223777f, -0.05773623f, 0.04421886f, -0.02120786f, 0.03295923f, 
    0.11797701f, 0.03081255f, -0.04361409f, 0.01744776f, -0.31668198f, -0.54887676f, -0.04480997f, -0.09617306f, 
    -0.09718091f, 0.02629772f, 0.00854112f, -0.04612374f, 0.12224289f, 0.01306117f, -0.13056058f, -0.00838005f, 
    0.00137591f, -0.09820820f, 0.13442810f, -0.10934344f, -0.09349358f, -0.09705208f, 0.06165585f, -0.15014012f, 
    -0.20019431f, 0.09400912f, -0.03298794f, -0.37048116f, 0.05645079f, -0.07641733f, 0.04967583f, 0.07873984f, 
    -0.04800395f, 0.25957751f, -0.02129121f, -0.13233022f, 0.01143537f, 0.04137445f, -0.18219635f, -0.04523006f, 
    0.02106968f, 0.06705645f, -0.14011453f, 0.11607990f, -0.39078134f, -0.09029299f, 0.00218893f, -0.11417774f, 
    0.12123631f, -0.10956115f, -0.09674133f, -0.11073814f, -0.01332372f, 0.03870276f, 0.17952819f, 0.06335168f, 
    0.02347895f, -0.07600202f, -0.01256514f, -0.09951439f, -0.05323129f, -0.00732596f, 0.10113109f, -0.03697460f, 
    0.24481200f, -0.41784409f, 0.12728374f, -0.20768973f, -0.11291701f, -0.01058701f, -0.05626696f, -0.03007817f, 
    -0.04193829f, 0.03659203f, -0.09878130f, 0.00484136f, 0.00500725f, 0.06347464f, 0.07431576f, -0.07855953f, 
    -0.00208439f, -0.13981687f, 0.06855388f, -0.06919215f, 0.11083438f, 0.22844461f, 0.08558854f, 0.16026817f, 
    0.23397776f, -0.08000535f, -0.06602024f, 0.00652377f, -0.01357593f, 0.06029354f, 0.05958652f, 0.02554190f, 
    0.01763518f, -0.01849841f, 0.12352303f, 0.03059000f, 0.02593354f, 0.03613268f, -0.02222116f, 0.06221842f, 
    0.16727142f, 0.06183518f, 0.16130960f, 0.07451908f, 0.18987553f, -0.06917244f, 0.04653107f, -0.11265987f, 
    0.03888167f, -0.04624300f, 0.00990642f, 0.00981966f, -0.02578131f, 0.01206957f, 0.00749728f, -0.03202043f, 
    0.10712455f, 0.05704299f, 0.04452447f, -0.06000591f, 0.02777578f, 0.31257787f, -0.06952270f, 0.20830783f, 
    -0.26332992f, 0.03146519f, -0.10914385f, 0.18363377f, -0.04625394f, 0.00063075f, 0.10309251f, -0.02369589f, 
    -0.05087546f, 0.12419423f, -0.07400564f, 0.03703411f, 0.10407708f, -0.07178791f, 0.11261127f, -0.05989893f, 
    0.06349929f, 0.09750751f, 0.13487338f, 0.18300728f, 0.24408722f, 0.01341186f, -0.00233318f, 0.08724048f, 
    0.07125411f, 0.05573411f, -0.07918856f, -0.07154584f, -0.12423991f, 0.00952801f, -0.12593530f, -0.02341872f, 
    -0.00220330f, 0.04892184f, 0.00929636f, -0.07843304f, -0.04385534f, -0.03442843f, -0.32674441f, -0.23920120f, 
    -0.20615256f, -0.08088493f, 0.06673072f, -0.03425897f, -0.21359946f, 0.06603610f, -0.04614629f, 0.01522393f, 
    -0.01265485f, -0.09602370f, -0.05820436f, -0.03645011f, -0.04820722f, 0.08881124f, -0.07952695f, 0.17383535f, 
    -0.41521007f, 0.11650222f, -0.01062702f, -0.03379373f, -0.03952363f, 0.01102220f, 0.02945553f, 0.02754622f, 
    -0.07436055f, 0.06962758f, -0.01139930f, 0.05239292f, -0.01562208f, -0.03470710f, 0.02288031f, 0.10214938f, 
    -0.05883791f, 0.02806794f, 0.08224357f, 0.00278467f, -0.01299863f, -0.15663655f, -0.03415193f, 0.01649067f, 
    -0.31337300f, -0.23489307f, -0.17198190f, -0.04452827f, 0.02370083f, 0.01551928f, 0.05932202f, 0.01795203f, 
    -0.12867409f, -0.01632123f, -0.04973223f, 0.01984310f, -0.06181607f, -0.00464248f, 0.00496083f, 0.00225406f, 
    0.35095653f, -0.01939585f, -0.07315840f, -0.00315134f, 0.29698467f, -0.08437081f, -0.15629475f, 0.04416280f, 
    -0.00997613f, 0.03052997f, 0.07017237f, -0.00295531f, 0.11259148f, 0.10047704f, -0.00937907f, 0.00303726f, 
    -0.05079690f, 0.17891803f, 0.13844702f, -0.01819793f, -0.38930386f, 0.13153520f, 0.06817173f, -0.04684163f, 
    0.13517214f, -0.09448392f, 0.05792719f, -0.02499082f, -0.08125336f, 0.01782337f, 0.03011327f, 0.02936197f, 
    0.02107088f, -0.02096010f, 0.00643673f, 0.14250699f, -0.03996945f, 0.01230973f, 0.00394362f, -0.02692064f, 
    -0.19852091f, 0.13439810f, 0.14722839f, -0.06695196f, 0.10736541f, 0.00943187f, -0.07601084f, 0.01700898f, 
    -0.04391943f, -0.00250528f, 0.01559224f, 0.02059030f, 0.12715724f, -0.01170109f, -0.02253943f, -0.10991801f, 
    0.02067637f, -0.12171730f, -0.04879427f, 0.09125488f, -0.20299339f, 0.18473631f, 0.16423479f, -0.07835206f, 
    0.20573588f, -0.28285900f, 0.01989854f, 0.00255608f, -0.12776735f, 0.07122978f, -0.03858759f, 0.00138925f, 
    -0.03473468f, -0.10184884f, -0.08340153f, 0.06546140f, -0.03641744f, 0.04685113f, 0.03147570f, 0.11554463f, 
    0.23030744f, -0.26532385f, -0.03866187f, -0.04818013f, -0.05490404f, 0.08591476f, -0.08101751f, -0.01454170f, 
    0.01869416f, 0.08775495f, -0.06953458f, 0.07507510f, 0.02178562f, -0.05207470f, 0.10321201f, 0.16915831f, 
    -0.10808157f, -0.23377161f, -0.02022743f, -0.11374146f, 0.37619832f, -0.05014078f, 0.01959646f, 0.11527299f, 
    -0.02122861f, 0.09846608f, -0.17102967f, 0.07460772f, 0.01481454f, -0.05485478f, 0.06921124f, 0.02560161f, 
    -0.11713891f, 0.13286960f, -0.06530289f, 0.06539518f, 0.03223674f, -0.01681646f, -0.12308040f, -0.00404202f, 
    -0.26879600f, -0.26745766f, 0.05577941f, -0.18976341f, 0.25610361f, 0.07393346f, -0.08575812f, -0.00627000f, 
    -0.10485211f, 0.09360709f, 0.11433014f, -0.02058639f, -0.01511160f, -0.07782975f, -0.16259646f, -0.08337674f, 
    0.02892724f, -0.00096967f, 0.02009545f, 0.11786336f, -0.16638604f, -0.03623668f, -0.05077114f, -0.12727503f, 
    0.01276421f, -0.04058233f, -0.06744100f, -0.09547210f, -0.05103954f, 0.01554714f, 0.18688071f, 0.14755280f, 
    -0.02610329f, -0.07136478f, -0.04999724f, -0.09949184f, 0.07338355f, -0.14782181f, 0.10798427f, -0.09023990f, 
    -0.33007181f, -0.27628273f, -0.08743814f, -0.12697001f, 0.11718575f, 0.11200868f, 0.00110415f, 0.07447428f, 
    -0.02520827f, 0.03248766f, 0.12353621f, 0.14265163f, 0.03326556f, 0.05712774f, -0.06855746f, 0.00774618f, 
    0.00615380f, -0.15802254f, -0.03715134f, -0.05956703f, 0.51012206f, -0.25887543f, 0.16886100f, -0.00317605f, 
    -0.04323362f, -0.01853513f, 0.12487959f, 0.04742249f, -0.04732900f, 0.02719549f, 0.18447243f, 0.02513474f, 
    0.05021937f, -0.05521544f, -0.14265679f, 0.02542740f, 0.03429686f, 0.02426090f, 0.01519382f, 0.10631133f, 
    0.10943542f, -0.12552625f, 0.06767224f, -0.56008190f, -0.10367458f, -0.05606598f, 0.03866161f, 0.06989287f, 
    -0.02735915f, -0.01531343f, -0.13528889f, -0.04169941f, 0.03602751f, 0.04495145f, -0.13037719f, -0.18283479f, 
    -0.12790555f, -0.25172883f, -0.05011595f, -0.03338982f, 0.09106071f, -0.09018656f, -0.02322533f, 0.08739342f, 
    0.09857545f, 0.08445811f, -0.08708774f, 0.04383666f, -0.02316034f, -0.01559248f, -0.07241140f, -0.02875383f, 
    -0.07655087f, 0.11633250f, 0.05543552f, -0.03271784f, -0.06440422f, -0.06569463f, -0.12262598f, -0.11278269f, 
    0.36250803f, -0.55744433f, -0.03215617f, -0.07805128f, -0.06350502f, -0.06903293f, 0.14030179f, 0.00909729f, 
    0.09788183f, 0.02713015f, 0.01058819f, -0.00402386f, 0.02098358f, 0.09310744f, -0.10725857f, 0.17624384f, 
    0.08024269f, -0.02723147f, 0.00150473f, 0.10025273f, 0.12365675f, -0.30510226f, -0.00627434f, -0.26302612f, 
    0.00497731f, 0.00313948f, -0.14978656f, 0.07873976f, 0.04495539f, 0.02834385f, -0.07642293f, -0.04146843f, 
    -0.07018179f, -0.10490947f, 0.22607127f, -0.14289628f, 0.02526325f, -0.15071245f, 0.00894069f, -0.03050075f, 
    0.28069454f, 0.12190995f, -0.27037323f, -0.02231400f, -0.05492904f, -0.00961341f, -0.00265316f, 0.05846329f, 
    0.01684558f, -0.00093092f, -0.02380915f, -0.05464101f, 0.02878862f, -0.05742767f, -0.00789631f, 0.04020965f, 
    -0.06896604f, -0.11473737f, -0.01956456f, 0.04674241f, 0.47251040f, 0.03875361f, -0.19054678f, -0.10525869f, 
    0.07862835f, 0.05920921f, -0.08279710f, -0.02145540f, -0.03890774f, 0.05637748f, 0.01945117f, 0.04366768f, 
    -0.00635963f, -0.01515401f, 0.01614647f, -0.00790924f, -0.03582818f, -0.13508566f, 0.00422998f, 0.04060028f, 
    -0.01514268f, 0.09220884f, -0.02563926f, -0.01985760f, -0.09101529f, 0.02368811f, -0.11668094f, 0.15537935f, 
    0.04119648f, 0.05869028f, -0.02543882f, 0.02357132f, 0.11007412f, -0.08832020f, 0.00344648f, 0.01424413f, 
    -0.05270236f, -0.00069986f, -0.03272638f, -0.01840128f, 0.20134906f, 0.05431076f, 0.20320968f, 0.18941095f, 
    0.14724025f, -0.04375028f, -0.15149692f, -0.06320845f, 0.04495333f, 0.06251109f, 0.04142341f, -0.05114297f, 
    -0.04833029f, 0.04389876f, -0.06687664f, 0.00240408f, -0.06825791f, -0.01967777f, -0.00490938f, -0.00985804f, 
    -0.11874253f, -0.21310380f, -0.04075076f, -0.03172446f, -0.00423479f, 0.07507462f, 0.08760041f, 0.09106470f, 
    0.04863762f, 0.00488161f, -0.03752698f, 0.02627985f, 0.02747659f, 0.02734755f, -0.01623803f, -0.01774741f, 
    -0.05639672f, 0.06974321f, -0.15396139f, 0.00593108f, 0.27349260f, -0.17822403f, -0.10434940f, 0.00079919f, 
    -0.20932236f, -0.02912076f, 0.05493710f, -0.14348224f, 0.02830758f, -0.06370334f, -0.06269651f, -0.09438699f, 
    0.04404471f, -0.01105010f, -0.08163390f, 0.02751353f, -0.01449588f, 0.04844787f, 0.04643903f, -0.05964166f, 
    0.20409997f, -0.15304331f, 0.25454664f, 0.07444012f, 0.25854883f, -0.21847825f, -0.02882349f, -0.10886721f, 
    -0.06085519f, -0.03813884f, 0.06547168f, -0.06654062f, -0.05573270f, -0.10894560f, 0.02780312f, 0.01317655f, 
    -0.06386071f, -0.04813315f, 0.02634708f, 0.07972329f, 0.16523670f, -0.12839703f, 0.21921368f, -0.17490248f, 
    -0.03038344f, 0.18304421f, -0.10701442f, -0.10025684f, 0.00754361f, 0.18911214f, 0.05315370f, 0.04069712f, 
    -0.02414518f, 0.01873250f, 0.03596681f, -0.00254646f, -0.23320836f, 0.06154875f, -0.08114623f, -0.02704578f, 
    0.37045649f, 0.11023832f, -0.02242625f, -0.25574383f, -0.16444996f, -0.18949728f, -0.05402014f, -0.12332230f, 
    -0.12427705f, -0.03252929f, 0.02778104f, -0.01085102f, 0.08137137f, -0.14019361f, -0.00210675f, -0.09516476f, 
    0.01117744f, -0.05997228f, -0.12262280f, -0.03834681f, -0.24622650f, 0.19372332f, -0.03335664f, 0.15120879f, 
    0.07504180f, 0.09747580f, -0.03216654f, -0.05829114f, -0.03323269f, 0.15429506f, -0.00461432f, -0.11092133f, 
    0.00826091f, 0.11748078f, -0.03711149f, -0.04944598f, 0.10788206f, -0.02678816f, -0.10062946f, -0.05326942f, 
    0.38290489f, -0.49307689f, -0.08875617f, -0.21466200f, -0.14227217f, -0.01513220f, -0.17281076f, 0.15029258f, 
    -0.04854861f, 0.04344421f, -0.06074293f, 0.07124278f, 0.05505824f, -0.03339070f, -0.00578557f, 0.08595060f, 
    -0.09350979f, 0.03409197f, 0.01554667f, -0.10789449f, -0.15149094f, 0.04454663f, 0.02321612f, 0.00929112f, 
    0.01950303f, 0.01815110f, 0.02421464f, 0.08766711f, 0.02853051f, -0.08057362f, -0.07791761f, 0.06430051f, 
    -0.05128717f, 0.05412518f, 0.03682079f, -0.03890987f, -0.09178298f, -0.02708264f, -0.09981164f, -0.01738392f, 
    0.07640959f, -0.12444159f, 0.04189369f, -0.04051198f, -0.06266278f, 0.07401707f, -0.07239416f, 0.10471949f, 
    0.04978744f, 0.12990350f, -0.12360207f, 0.06111927f, 0.12662788f, 0.12099320f, -0.09330715f, -0.13365906f, 
    -0.01353387f, 0.01631560f, -0.13987975f, -0.06625878f, 0.07824010f, -0.04630626f, 0.14355251f, 0.01793685f, 
    0.26564166f, -0.25649443f, -0.10132498f, -0.23471291f, -0.06746977f, 0.06536306f, -0.03674503f, -0.04967966f, 
    0.00701740f, -0.00640131f, -0.01383254f, -0.10565157f, -0.00158128f, 0.00274472f, 0.02450093f, 0.09792134f, 
    -0.19238767f, 0.01980948f, -0.01191267f, -0.12173998f, 0.03370971f, 0.07077484f, -0.09088080f, 0.03049873f, 
    0.04857439f, -0.00032778f, -0.07487436f, -0.04210839f, 0.08493908f, -0.01930840f, -0.02924051f, -0.16049446f, 
    0.07096330f, -0.01159515f, -0.17435539f, -0.09826337f, 0.47510991f, -0.08034643f, -0.36595228f, 0.06926817f, 
    -0.11299330f, -0.21639419f, 0.08344991f, 0.11015527f, 0.07059935f, -0.13904463f, -0.04446550f, -0.06120393f, 
    0.07229047f, -0.08667910f, -0.02762953f, 0.02724836f, 0.10011441f, -0.02616258f, 0.09014270f, 0.03780745f, 
    0.33415958f, 0.09392816f, 0.09328558f, -0.01417883f, 0.16147895f, -0.07100920f, -0.05239262f, -0.07911912f, 
    0.06192414f, -0.01528566f, 0.03581458f, 0.03271682f, 0.00706941f, 0.00604907f, 0.00286937f, 0.02512228f, 
    -0.03799984f, -0.06372588f, 0.01076890f, 0.00015897f, 0.48554948f, -0.02109447f, -0.18115088f, 0.33069259f, 
    -0.09647730f, -0.11271998f, -0.06066280f, 0.01054731f, 0.08458603f, 0.08385631f, 0.01468197f, 0.08303130f, 
    0.10580088f, 0.03373193f, -0.05435435f, -0.02964005f, -0.05968977f, -0.06015557f, 0.05624941f, -0.06975007f, 
    -0.03691038f, 0.27082288f, 0.05191022f, 0.02481178f, -0.04238985f, 0.04825525f, -0.08459622f, -0.01002217f, 
    -0.05328628f, -0.03292610f, -0.12633608f, -0.10463781f, -0.02917552f, 0.09390818f, -0.07840614f, -0.05575527f, 
    0.08141498f, -0.09084351f, -0.01028407f, -0.07420921f, 0.30948269f, 0.12067384f, 0.13628928f, -0.10462958f, 
    0.10896266f, 0.02301378f, -0.08301710f, 0.04180092f, 0.06383191f, 0.08423731f, 0.03694869f, 0.12780635f, 
    0.00276119f, 0.08221081f, 0.02178897f, 0.02038097f, -0.10717922f, -0.04174741f, -0.04214771f, -0.03305896f, 
    -0.00506989f, 0.11501858f, 0.10500967f, -0.03931217f, -0.00511980f, 0.00581031f, 0.19559072f, 0.11652074f, 
    -0.09433955f, -0.05049843f, 0.00318443f, 0.03127623f, -0.00384850f, -0.06852183f, -0.00597418f, 0.10070792f, 
    -0.00066712f, -0.01437941f, -0.11815698f, -0.01438416f, 0.26363069f, 0.04825103f, -0.14545572f, 0.06675684f, 
    -0.10655361f, -0.13523118f, 0.06203246f, 0.06913093f, 0.00860908f, -0.06683239f, -0.05921087f, 0.00907066f, 
    -0.05914607f, 0.09346289f, 0.00960033f, 0.03314225f, -0.15353499f, -0.05650528f, 0.01793414f, -0.01861895f, 
    -0.20935419f, -0.48494861f, -0.02646127f, -0.31443581f, -0.41043639f, -0.05375878f, -0.05638104f, 0.10594667f, 
    -0.06058434f, 0.04447651f, -0.08532110f, 0.08413216f, -0.03171913f, -0.13446547f, -0.08582467f, 0.02054282f, 
    0.01128301f, 0.09593038f, 0.03920277f, 0.08387972f, -0.20048794f, 0.23366082f, -0.07600158f, -0.23110767f, 
    0.07679682f, 0.02880334f, 0.04243708f, 0.11002119f, -0.02893459f, -0.03221994f, -0.09168115f, 0.09717612f, 
    0.01859304f, -0.13997959f, -0.06021144f, 0.02011463f, 0.05195552f, 0.00074733f, -0.01766900f, 0.03018378f, 
    0.05078030f, -0.10796647f, 0.00051189f, 0.03180851f, 0.05756821f, 0.05431354f, -0.09712667f, -0.00378939f, 
    0.07213929f, 0.03460761f, 0.03641522f, -0.18043642f, 0.00250710f, 0.03570726f, -0.05423340f, 0.05336972f, 
    0.05259694f, -0.05483882f, -0.12418282f, 0.11525840f, -0.02234558f, -0.07018246f, -0.06656626f, 0.12952329f, 
    -0.17776544f, -0.02676679f, -0.07538071f, -0.10816991f, 0.00282378f, 0.02832562f, 0.01317552f, -0.04795713f, 
    -0.01036498f, 0.04580361f, 0.06806054f, -0.01106380f, -0.02250697f, 0.02981023f, 0.01987065f, -0.04295795f, 
    -0.20751435f, -0.13530383f, 0.05432297f, -0.21193263f, -0.23943049f, 0.06962058f, -0.13056244f, 0.13988121f, 
    -0.09028874f, 0.07823219f, -0.11880353f, 0.00903456f, -0.01150964f, -0.11881137f, -0.00177051f, 0.09165251f, 
    -0.01637401f, 0.11383317f, 0.02112673f, -0.02743815f, -0.61501032f, 0.14500213f, 0.01617940f, -0.18693131f, 
    0.06746316f, -0.02962974f, -0.04494241f, -0.05582893f, 0.11666401f, 0.04540378f, -0.03470303f, -0.02024680f, 
    0.04299335f, -0.07937527f, 0.01963371f, -0.01142891f, 0.05913499f, -0.12784822f, 0.05697847f, -0.01910723f, 
    -0.51858491f, -0.43682915f, -0.26440924f, -0.22378670f, -0.40248105f, 0.01713310f, 0.03367922f, -0.04781650f, 
    -0.03935086f, -0.01937333f, 0.02488191f, 0.02968924f, 0.00098569f, 0.03755071f, -0.06674683f, -0.05164130f, 
    -0.02965143f, 0.12791835f, 0.07463751f, -0.06008176f, -0.25941119f, 0.19315204f, -0.01868845f, -0.14347009f, 
    0.05024986f, 0.11505134f, 0.16049835f, 0.13111745f, -0.05812363f, -0.11993475f, -0.16362508f, 0.08803184f, 
    0.01048247f, -0.11412960f, -0.05700684f, -0.06724435f, 0.06664619f, 0.11693745f, -0.00814359f, -0.04481958f, 
    0.35757154f, -0.05120783f, 0.15110046f, 0.06625888f, 0.06520040f, -0.20140894f, -0.14322639f, 0.04199578f, 
    0.01275762f, -0.00903183f, 0.07885172f, -0.01998719f, -0.01742421f, 0.08783703f, 0.03059545f, 0.05692982f, 
    0.00245612f, -0.02865394f, -0.09403197f, -0.00080962f, 0.01448481f, -0.31018999f, 0.04884677f, -0.25515318f, 
    -0.20882860f, 0.07542671f, -0.11802537f, 0.10362494f, -0.12038661f, -0.06704915f, -0.09525295f, 0.05348843f, 
    0.01231542f, -0.05276888f, -0.02572076f, 0.07638370f, -0.06784258f, 0.02700287f, -0.03088601f, -0.04543812f, 
    -0.54951930f, 0.27006182f, 0.00046094f, -0.22761561f, -0.07484734f, -0.11810353f, 0.01756127f, -0.10252732f, 
    0.12543729f, -0.03111321f, 0.00642934f, -0.01696570f, -0.07531955f, 0.00696328f, 0.03073401f, -0.02219233f, 
    0.04248310f, -0.16319695f, 0.06368314f, 0.06528118f, -0.05994578f, 0.33027193f, 0.05251889f, -0.04859180f, 
    -0.02327581f, -0.07397266f, -0.07619891f, -0.07968398f, 0.10568755f, 0.00870035f, 0.04304030f, -0.08435290f, 
    0.02405679f, 0.03914471f, -0.07719772f, -0.16740090f, 0.09720165f, -0.01092528f, 0.13055429f, 0.13066502f, 
    0.05046100f, -0.58549851f, -0.07692347f, -0.09001455f, 0.06348457f, -0.21358337f, -0.00281918f, -0.00237812f, 
    0.02464968f, 0.02268654f, 0.00394799f, 0.06510024f, 0.03348594f, -0.02034090f, 0.00867170f, -0.00107996f, 
    -0.07601193f, -0.08563402f, -0.00313279f, 0.07244817f, 0.03972250f, -0.19515137f, -0.11925282f, -0.03526557f, 
    -0.17792329f, 0.00081143f, -0.05359660f, 0.10956858f, -0.10539188f, 0.12648141f, -0.12396968f, 0.09701416f, 
    0.01825903f, 0.04194849f, 0.08489037f, 0.07874258f, -0.03597392f, 0.03330914f, -0.03675517f, 0.01145025f, 
    -0.05279252f, -0.73298973f, -0.34275052f, 0.01375298f, 0.01948737f, -0.23028198f, 0.02040237f, 0.07181686f, 
    0.06792325f, -0.10199987f, -0.03093908f, -0.02709932f, 0.02012208f, 0.10657496f, -0.01925398f, 0.04797461f, 
    0.00388088f, 0.07914756f, -0.03248511f, 0.03523985f, -0.18569838f, 0.32935342f, 0.08879820f, 0.16022140f, 
    -0.10851372f, 0.11358872f, 0.03294150f, -0.03300272f, -0.04200576f, -0.03394526f, -0.07452378f, -0.01872826f, 
    -0.04425345f, -0.10971116f, 0.00063570f, -0.04328113f, 0.01859974f, 0.05246887f, 0.00064083f, -0.04688957f, 
    0.10663228f, -0.19214146f, 0.05520646f, -0.11657392f, -0.11475417f, -0.06030802f, -0.17441736f, -0.03854570f, 
    -0.01078572f, 0.00563325f, 0.01582622f, -0.02896420f, 0.09774460f, -0.11957680f, 0.14909750f, -0.01849690f, 
    0.04114188f, 0.00222274f, 0.05235499f, 0.05583673f, 0.28249559f, 0.16857520f, -0.05352086f, 0.07426113f, 
    -0.04573559f, 0.09366573f, -0.09051953f, 0.08538394f, -0.03430831f, -0.05764997f, -0.21521710f, -0.07337274f, 
    -0.20324105f, 0.08759874f, -0.07141223f, 0.01370335f, 0.00133468f, -0.02643332f, 0.08052766f, 0.03188454f, 
    -0.27439642f, 0.36768290f, 0.08709605f, 0.12818275f, 0.06713264f, -0.01337607f, 0.04755627f, -0.11356659f, 
    -0.08831981f, -0.07732891f, -0.03944442f, 0.02935485f, -0.09544948f, 0.15043549f, -0.00967191f, 0.14578977f, 
    0.00819566f, 0.10773524f, 0.05712825f, -0.04849684f, -0.01080962f, 0.05643922f, -0.14277852f, 0.20311975f, 
    -0.01887556f, -0.04446398f, 0.02924566f, 0.12484467f, 0.09961820f, 0.08587193f, -0.08179224f, -0.01861271f, 
    -0.01594054f, 0.00796428f, 0.03344886f, -0.06098992f, 0.02265207f, 0.10145637f, -0.05479880f, 0.06899781f, 
    0.04901540f, -0.06077383f, -0.02549796f, 0.01895270f, 0.11702597f, -0.17146820f, 0.00876777f, -0.02611642f, 
    0.11502304f, 0.03328517f, -0.07914757f, -0.04163485f, -0.01888749f, 0.03420140f, 0.06096937f, -0.12032966f, 
    0.06623228f, -0.03121333f, 0.03069525f, 0.05271630f, -0.04978567f, -0.70180351f, -0.15232670f, 0.06772164f, 
    0.05801835f, -0.04843176f, -0.00811534f, 0.14343022f, 0.02163041f, -0.18219776f, -0.02874778f, 0.01265302f, 
    -0.09934954f, -0.05257071f, 0.03020415f, -0.00651260f, -0.07794655f, 0.01199329f, -0.08499068f, 0.00896521f, 
    -0.49216497f, -0.45100045f, -0.05760020f, -0.21630444f, -0.23624791f, -0.10149641f, 0.01205984f, -0.00188889f, 
    0.10364059f, -0.02254065f, -0.12623292f, -0.05188713f, 0.15720096f, 0.09851588f, -0.07754470f, 0.09158918f, 
    -0.07979032f, -0.09213335f, -0.00290794f, 0.18786351f, 0.11543559f, 0.05518931f, -0.15852979f, 0.04421287f, 
    -0.11224591f, -0.11560592f, -0.09390745f, -0.08315643f, 0.03507289f, -0.04897049f, -0.07850531f, 0.04532013f, 
    -0.08763121f, -0.04892366f, 0.03927915f, -0.08725936f, -0.12728547f, 0.05875698f, -0.12580755f, -0.02815547f, 
    -0.29561931f, -0.48528615f, -0.32346979f, -0.02144156f, 0.10871367f, -0.03085949f, 0.10933879f, 0.05122529f, 
    -0.01236498f, -0.06766880f, -0.06820694f, 0.01215835f, 0.07739929f, 0.03401068f, -0.01994275f, 0.02426549f, 
    0.02561713f, -0.07387862f, 0.01326510f, 0.02496102f, 0.00972878f, -0.00854772f, 0.15610085f, 0.10422629f, 
    0.08514269f, 0.16144598f, -0.04699531f, 0.00775623f, 0.05114716f, -0.02870729f, 0.08716226f, 0.08482006f, 
    -0.06732929f, -0.02590585f, -0.14316791f, -0.18629076f, 0.01292470f, -0.02939232f, -0.00741572f, 0.06494617f, 
    -0.34096304f, 0.15218726f, 0.00239463f, -0.20396927f, -0.19901721f, -0.03340267f, -0.16512130f, -0.05674713f, 
    -0.03419774f, -0.05866919f, 0.05922325f, -0.09978890f, -0.04269329f, 0.03839885f, -0.03007401f, 0.00000699f, 
    0.00482731f, -0.12345582f, -0.00135312f, 0.00501003f, 0.06845110f, -0.18474917f, 0.18040200f, 0.12543675f, 
    -0.00828170f, -0.03603198f, -0.05408608f, 0.15096031f, -0.04130302f, -0.03717671f, -0.07218526f, 0.01444871f, 
    -0.09101507f, -0.05315886f, 0.10040823f, 0.05843518f, 0.05779170f, 0.14250542f, 0.04490293f, 0.03630761f, 
    0.16659147f, -0.05492209f, -0.16862044f, 0.28337765f, 0.18978775f, -0.01317122f, 0.02740472f, 0.03380589f, 
    -0.00056060f, 0.01001652f, 0.09632471f, -0.02934833f, -0.03181892f, 0.13870081f, 0.01224700f, -0.00480896f, 
    0.10096487f, -0.01883873f, 0.08002587f, -0.04272970f, -0.43936449f, -0.09326452f, -0.04957394f, -0.17279804f, 
    -0.23662454f, -0.04205618f, -0.11565217f, -0.05522181f, 0.09575412f, -0.07633033f, 0.03075700f, -0.16692519f, 
    0.02156531f, 0.01497949f, 0.01314973f, 0.10506919f, 0.03388879f, -0.06242246f, 0.00881839f, 0.03454040f, 
    0.05224098f, -0.33210430f, -0.20658869f, 0.35267413f, 0.13210258f, 0.09849868f, 0.01843259f, 0.10727143f, 
    0.08012937f, -0.04604654f, -0.10107753f, 0.05087107f, -0.16588531f, -0.21078189f, -0.11699823f, -0.01144850f, 
    0.00580335f, 0.14201722f, -0.02248009f, -0.20504183f, -0.20672828f, -0.31485435f, 0.07320333f, -0.12353101f, 
    -0.08395536f, -0.06709068f, -0.09405298f, 0.00250439f, 0.02591899f, -0.16213605f, 0.09325547f, 0.03726670f, 
    -0.06368717f, 0.01007205f, 0.04164257f, -0.06374925f, -0.03079951f, -0.17866972f, 0.03472895f, -0.09858282f, 
    0.27804661f, 0.13471900f, 0.19265039f, 0.07630628f, -0.11405820f, -0.13295922f, 0.05189217f, -0.04624924f, 
    0.01769374f, 0.04198135f, 0.05642273f, -0.02690168f, -0.00793515f, -0.11226549f, 0.01479350f, 0.00826972f, 
    0.02820641f, 0.09486829f, -0.06467190f, 0.05303349f, -0.27612096f, -0.11165146f, -0.04271941f, -0.03953967f, 
    0.26548672f, -0.07687463f, 0.18209222f, 0.03444816f, -0.02165886f, -0.03888659f, 0.08716930f, -0.00389395f, 
    -0.02094839f, -0.06796915f, 0.03114333f, 0.03141420f, -0.06933114f, 0.00661654f, 0.01047881f, 0.01883870f, 
    0.09036121f, 0.39564520f, -0.31673118f, 0.31991917f, 0.04486169f, -0.00709445f, 0.05851850f, 0.07334110f, 
    -0.00424674f, -0.08416860f, -0.02674968f, -0.06442991f, -0.10237467f, -0.02322908f, 0.07046968f, -0.02138422f, 
    0.13078155f, 0.13013923f, -0.04167740f, -0.06283459f, -0.15631777f, -0.07219576f, -0.06125484f, 0.11324038f, 
    0.05439239f, -0.14155309f, -0.09710884f, 0.09541006f, -0.03642416f, 0.01918533f, -0.09346182f, -0.04642848f, 
    0.06619965f, 0.03141901f, 0.04822484f, -0.01961793f, 0.09328371f, 0.15172154f, -0.01849606f, -0.00056103f, 
    0.38170981f, 0.33002242f, -0.27805901f, 0.27158177f, 0.10264752f, -0.01475784f, 0.09438072f, 0.01340840f, 
    0.07132593f, 0.03348811f, -0.13069996f, -0.05191763f, -0.15025568f, -0.12689495f, 0.01728048f, 0.01437737f, 
    0.01630582f, 0.18999857f, -0.01790534f, -0.03970671f, -0.16969179f, -0.04853944f, -0.18836690f, 0.10500889f, 
    -0.21011911f, -0.07814041f, 0.12663360f, -0.08381183f, -0.02237053f, -0.05913804f, 0.02900641f, 0.10417668f, 
    0.02237921f, -0.01370603f, -0.04954072f, -0.06625210f, -0.01788175f, 0.02684047f, -0.02216749f, 0.06918376f, 
    0.25350249f, 0.14649554f, 0.39668486f, 0.11797921f, 0.08223825f, 0.00354428f, 0.11967087f, -0.02022618f, 
    -0.07024903f, 0.11504690f, 0.07836986f, -0.02680177f, -0.13713972f, -0.01371017f, -0.08323692f, 0.14565459f, 
    -0.03382855f, 0.02947398f, 0.13043049f, 0.10888210f, 0.20235774f, -0.53254795f, -0.19714859f, 0.07685275f, 
    0.21854194f, -0.01421633f, 0.18535683f, 0.06546142f, -0.03766154f, -0.03979247f, 0.05154821f, 0.03673047f, 
    -0.10505828f, -0.04637329f, -0.08770543f, 0.07565275f, 0.02330937f, 0.06539503f, -0.00516113f, -0.03337996f, 
    0.04347112f, 0.03248307f, -0.05127580f, 0.14360280f, -0.30237752f, -0.01169169f, -0.06980000f, 0.01820767f, 
    -0.05088203f, 0.04458485f, -0.07150662f, 0.07516922f, 0.02071878f, 0.02352762f, 0.06717306f, 0.02801183f, 
    -0.04693044f, 0.00314152f, -0.03187835f, 0.08251665f, 0.26319888f, 0.13377623f, 0.11492798f, 0.04332474f, 
    -0.01412326f, 0.01865044f, 0.01816386f, -0.08425327f, 0.00719912f, -0.00527027f, 0.05597534f, -0.03778752f, 
    -0.03290024f, 0.03610529f, -0.01970055f, 0.00571225f, -0.00534370f, 0.07170220f, -0.04050376f, 0.06868070f, 
    -0.14779921f, 0.21527660f, 0.06032840f, 0.06661313f, -0.01916014f, -0.01940184f, -0.14189275f, 0.17806834f, 
    0.02089852f, 0.02595431f, -0.07415984f, -0.02050246f, -0.02086813f, -0.00950903f, 0.01353207f, 0.02801461f, 
    -0.02394026f, -0.05109555f, -0.15354474f, -0.13661057f, 0.28223139f, 0.23387036f, -0.04152045f, -0.14225577f, 
    -0.07920188f, -0.04256599f, -0.01194440f, 0.06730594f, -0.10900415f, -0.11981691f, -0.00723441f, -0.03254018f, 
    0.02783045f, 0.12685195f, 0.13768737f, -0.11278623f, 0.06965369f, -0.01750991f, 0.06336605f, -0.00467341f, 
    0.32735470f, -0.34479192f, 0.10026110f, -0.18413977f, -0.06153413f, -0.02659746f, 0.00830920f, 0.12204733f, 
    -0.14097826f, 0.04019877f, 0.03199071f, 0.06724519f, -0.02053925f, -0.12118188f, 0.00852888f, 0.04366629f, 
    0.07001112f, -0.09809772f, 0.04388530f, -0.22589600f, -0.26912570f, 0.03538865f, 0.01686250f, 0.10917637f, 
    0.08927018f, 0.02508862f, 0.01471930f, 0.10009712f, -0.00800510f, 0.11416890f, -0.03411096f, -0.02678374f, 
    0.07503092f, -0.02340519f, 0.10558382f, 0.08324121f, -0.02148903f, 0.09042004f, 0.06568214f, -0.17528550f, 
    0.05634562f, 0.18512124f, 0.01529551f, -0.01697875f, 0.13187490f, -0.07595773f, 0.04581700f, 0.02995843f, 
    0.09568986f, 0.10229968f, 0.02470576f, -0.00514499f, 0.08767353f, 0.01621694f, -0.08002365f, 0.06003543f, 
    0.08666483f, 0.03560065f, 0.05848001f, 0.07380193f, -0.19639353f, 0.05733498f, 0.15207826f, 0.07040703f, 
    -0.14384060f, 0.11698794f, 0.17181824f, 0.04942277f, -0.06206648f, 0.04728247f, 0.18040812f, -0.02752376f, 
    -0.03737632f, -0.08275726f, 0.07486680f, -0.07222550f, -0.08108424f, -0.00834577f, 0.02289179f, 0.07537474f, 
    -0.66890967f, 0.03049452f, -0.06954320f, 0.07937796f, 0.21830907f, -0.02540877f, 0.01651341f, -0.04766987f, 
    0.07095064f, 0.07820897f, 0.04158969f, 0.00628818f, -0.07011790f, 0.07580665f, 0.08047710f, 0.05761073f, 
    0.09385522f, 0.18934098f, 0.07785808f, 0.00879154f, -0.53096014f, 0.02294658f, 0.00913222f, -0.06272567f, 
    -0.23355517f, -0.04353780f, -0.00128018f, 0.09128276f, -0.00307657f, -0.01217114f, 0.04220828f, -0.03729207f, 
    -0.01048705f, 0.04843485f, 0.13055991f, -0.03782136f, 0.02046053f, 0.17750734f, 0.02495552f, 0.15243939f, 
    -0.19050148f, 0.16512077f, 0.31461662f, 0.10846659f, -0.01621464f, 0.17827792f, -0.10336082f, -0.04808053f, 
    0.05077419f, -0.02533990f, -0.05715929f, 0.11621042f, -0.13630275f, -0.02214954f, 0.14332521f, -0.00512612f, 
    -0.16451073f, -0.05021583f, 0.05293381f, -0.07087415f, 0.09216114f, -0.31115857f, -0.14417715f, 0.25110227f, 
    0.08086219f, 0.19378975f, -0.04080133f, 0.01286681f, -0.12480393f, -0.05362753f, -0.03064564f, 0.04053344f, 
    0.10406832f, -0.04387341f, -0.03290645f, -0.03746520f, -0.00887909f, -0.00372972f, 0.05593621f, 0.07271269f, 
    0.12390388f, 0.01774308f, -0.11273419f, -0.09639507f, -0.25254181f, 0.03156739f, -0.00923603f, 0.04455668f, 
    0.05575548f, -0.03215362f, -0.01982754f, -0.05012539f, -0.00913567f, 0.03615791f, -0.00106611f, 0.03076934f, 
    0.11233889f, -0.09649406f, -0.11151164f, -0.07481530f, -0.12677813f, -0.08906344f, 0.04023619f, 0.05490601f, 
    0.09869614f, -0.04154685f, -0.11837761f, -0.06147424f, 0.06164129f, 0.00181243f, 0.06434479f, 0.02598083f, 
    0.05581246f, 0.03517726f, -0.04792269f, -0.04265277f, 0.03055176f, -0.03870463f, 0.03672961f, 0.04227406f, 
    0.08295529f, -0.22578442f, -0.15423663f, 0.18902048f, 0.00498736f, 0.13007970f, -0.09853907f, 0.07218385f, 
    0.02370040f, 0.13111795f, -0.02033303f, -0.00973233f, 0.06392136f, -0.12699723f, -0.00017728f, -0.03702321f, 
    -0.00399416f, -0.03145274f, 0.02349035f, -0.10053594f, -0.23079127f, 0.00578537f, -0.03291802f, -0.09150482f, 
    0.19781318f, -0.09146264f, 0.01495296f, 0.02227758f, 0.10318297f, 0.00225067f, 0.09867448f, -0.00397724f, 
    -0.16997389f, -0.02851366f, -0.02402604f, 0.07926500f, -0.10140114f, -0.02701778f, 0.07960843f, 0.15507351f, 
    0.16264841f, -0.03229583f, 0.11265763f, 0.07182227f, 0.00160463f, 0.03810738f, 0.02826028f, 0.03485579f, 
    -0.03026202f, 0.06484541f, 0.10331029f, 0.01174676f, -0.00755433f, -0.07314380f, -0.07963879f, 0.01696303f, 
    0.07251392f, -0.00987770f, 0.01749339f, 0.02357232f, 0.45490164f, 0.21801148f, -0.02631173f, -0.35809416f, 
    -0.16604143f, -0.19198582f, -0.01491618f, -0.05831719f, 0.01790238f, -0.06863516f, -0.06816194f, -0.01940180f, 
    -0.03234728f, -0.00284751f, 0.00755749f, -0.06990132f, -0.01908590f, 0.03234111f, -0.01764410f, 0.03919413f, 
    0.17370760f, 0.15520403f, -0.24535067f, -0.00720185f, 0.07024973f, 0.10697012f, 0.05300217f, 0.11391607f, 
    0.13265948f, -0.07078167f, -0.05085932f, -0.05105632f, -0.04448082f, 0.01463230f, -0.10524066f, -0.00258060f, 
    0.05937548f, -0.06201566f, 0.03121202f, -0.03113082f, -0.33946288f, -0.11224408f, 0.00530457f, 0.10130626f, 
    0.30048922f, 0.18169515f, 0.01011273f, -0.04861932f, 0.03722312f, 0.17091568f, -0.12261085f, -0.16267578f, 
    0.14347745f, 0.11016311f, 0.02976293f, -0.13714874f, 0.15468086f, 0.01357229f, 0.10270948f, -0.20226599f, 
    0.31101233f, -0.21439561f, -0.06327800f, -0.09517742f, 0.10170661f, -0.05634976f, -0.02732425f, -0.02158907f, 
    0.04090386f, -0.01922023f, -0.15127014f, 0.05977083f, -0.04203562f, -0.09931885f, -0.20083255f, -0.01726882f, 
    -0.16288106f, -0.12762217f, -0.01975057f, 0.05506979f, -0.07349930f, 0.12710369f, -0.31171185f, 0.14765278f, 
    0.04275944f, 0.11110501f, -0.04490842f, 0.13273081f, 0.08651788f, 0.01561954f, 0.06404936f, 0.02523001f, 
    -0.03436023f, -0.00174907f, 0.03840264f, -0.09465021f, 0.17202045f, -0.07300163f, -0.00522684f, -0.06378569f, 
    -0.45762339f, -0.32042086f, 0.13998929f, -0.01164376f, 0.02460863f, -0.11235350f, 0.03928894f, -0.26200721f, 
    -0.09750482f, 0.05280431f, 0.04315674f, -0.08127466f, -0.03723808f, -0.02506703f, 0.07550132f, -0.07266343f, 
    -0.16478813f, -0.05275730f, -0.08212902f, -0.02885402f, -0.04808612f, 0.39593711f, -0.34769043f, -0.21014203f, 
    0.06015549f, -0.01098557f, -0.08021861f, 0.07914945f, 0.08463656f, -0.03345672f, -0.02797095f, 0.00997605f, 
    0.06957010f, -0.04046528f, 0.00730954f, 0.15609571f, 0.02123353f, -0.12658533f, -0.04361419f, -0.07527409f, 
    -0.02585485f, 0.10414010f, -0.14473324f, 0.16967756f, -0.20640789f, -0.08835714f, -0.06473096f, 0.07524431f, 
    -0.05347136f, -0.19026668f, 0.07861495f, -0.08494414f, -0.00008383f, 0.06902470f, -0.01414936f, -0.06003081f, 
    -0.01403081f, 0.21134071f, -0.03602950f, 0.02110332f, -0.10119824f, -0.33350939f, 0.25686219f, 0.21650384f, 
    -0.08323995f, -0.15673290f, 0.04999243f, 0.00765346f, -0.09015478f, 0.03402922f, 0.15985745f, -0.01033143f, 
    -0.04517358f, -0.17781687f, 0.03832831f, 0.06293484f, 0.04279576f, 0.01106301f, -0.02123408f, 0.06854094f, 
    -0.30169219f, 0.10972117f, -0.13952860f, 0.32848635f, -0.17490615f, 0.06154023f, -0.05129563f, -0.00896249f, 
    -0.07848338f, -0.04817913f, -0.13245517f, -0.04965873f, -0.00544994f, -0.02969660f, -0.03239965f, -0.00280091f, 
    -0.05301606f, -0.05083318f, -0.13874820f, 0.12572724f, 0.12031448f, -0.21058860f, -0.09363003f, 0.04082702f, 
    0.17427407f, 0.06306091f, -0.00558567f, 0.16036098f, 0.09603238f, 0.05241636f, 0.03477383f, -0.00312843f, 
    0.07616003f, -0.02091570f, 0.06391198f, 0.01568890f, -0.00821548f, -0.01768255f, 0.07727525f, 0.00227742f, 
    -0.03666993f, -0.13557075f, -0.16677585f, -0.05998665f, -0.15958259f, -0.03251473f, 0.00284380f, -0.01007711f, 
    -0.04511159f, -0.11835958f, -0.02848322f, -0.13059287f, 0.09124410f, 0.00569585f, 0.02082866f, -0.07767261f, 
    -0.04539239f, 0.13306473f, -0.12875120f, 0.00483822f, -0.49323648f, 0.23185675f, 0.05204594f, -0.18239631f, 
    -0.17516580f, 0.19326082f, -0.01252939f, -0.12039092f, -0.07466882f, -0.09143474f, -0.00338952f, -0.02880920f, 
    0.02791628f, -0.04396299f, 0.02361575f, -0.01471357f, -0.04106008f, -0.22322020f, -0.02082873f, 0.00465885f, 
    -0.00315785f, 0.18667516f, -0.12587492f, 0.23944330f, -0.06794736f, 0.02846702f, -0.00650239f, 0.12576003f, 
    0.04338050f, -0.09155934f, 0.04350848f, 0.09660486f, 0.02008897f, -0.07194249f, 0.03195117f, 0.07030671f, 
    0.06465694f, 0.07432264f, 0.01285466f, 0.14956397f, -0.26795295f, -0.34921160f, 0.19926666f, 0.27697241f, 
    -0.03140999f, -0.17436387f, 0.10889260f, 0.00460326f, -0.17364246f, -0.01524566f, 0.10185187f, 0.08461108f, 
    -0.02199634f, -0.08940323f, -0.01385302f, -0.13463242f, -0.00970075f, -0.02172184f, 0.08721100f, 0.04271173f, 
    -0.64380562f, 0.48573130f, 0.12195309f, 0.11867056f, 0.01622719f, 0.04648687f, -0.13873617f, -0.06448799f, 
    -0.02444419f, 0.05440048f, -0.12527393f, 0.04417748f, 0.04414281f, 0.00321206f, 0.02347900f, -0.00226754f, 
    -0.06275080f, 0.01048887f, 0.08039043f, -0.11727842f, 0.09386194f, -0.14866807f, -0.01488575f, 0.00374598f, 
    -0.27524522f, -0.11418029f, 0.00633248f, -0.02749462f, -0.06489770f, -0.09297638f, -0.00211527f, -0.02699985f, 
    0.04854310f, -0.01893819f, 0.00719511f, -0.10478303f, 0.11451326f, 0.00881017f, -0.03698032f, 0.04239732f, 
    -0.10250484f, -0.11343721f, 0.00220000f, 0.22058918f, -0.20269960f, 0.00789808f, 0.06277782f, -0.05359498f, 
    0.02260010f, 0.05390351f, 0.12389351f, 0.02702205f, -0.02418773f, 0.09243951f, -0.08276522f, 0.00211622f, 
    -0.07831654f, 0.05039888f, 0.00045449f, 0.02397988f, -0.17708963f, 0.02112661f, 0.20167314f, 0.20571721f, 
    -0.35673577f, 0.04926871f, 0.09181380f, 0.08884204f, -0.03437871f, -0.06850673f, -0.02306120f, -0.00259868f, 
    0.05132845f, -0.11230310f, -0.09087566f, 0.02022268f, -0.06505750f, 0.09424748f, 0.08428992f, 0.01917968f, 
    -0.01878305f, -0.00098630f, 0.04688410f, 0.09564473f, 0.09712770f, -0.07421894f, 0.03625754f, -0.01353530f, 
    -0.16781390f, 0.08286314f, 0.03459513f, 0.00282489f, 0.00891560f, -0.05032174f, -0.03538915f, 0.01270481f, 
    -0.11074123f, 0.07828695f, 0.04917077f, 0.06721900f, -0.29877707f, 0.15333094f, -0.11213149f, -0.11851228f, 
    0.02989418f, 0.00316397f, -0.01847502f, 0.01493142f, -0.00890041f, -0.25231010f, 0.10937269f, 0.10904868f, 
    0.06870168f, -0.09301987f, -0.01778721f, 0.04307112f, 0.03072250f, 0.03313950f, 0.06544983f, 0.05279004f, 
    0.10225170f, -0.03927754f, 0.12155010f, 0.10862973f, -0.34557039f, 0.03754865f, -0.10430002f, -0.05015009f, 
    -0.11436609f, -0.09509304f, -0.09904205f, 0.08371069f, 0.08284727f, -0.13098109f, 0.19002885f, 0.05035280f, 
    -0.12913218f, 0.08904173f, 0.09859135f, -0.04952174f, 0.07631972f, 0.06894022f, -0.01168924f, 0.13705012f, 
    0.18833537f, -0.04732378f, -0.02046521f, -0.06867345f, 0.00137537f, 0.00089999f, -0.08550449f, 0.07481830f, 
    0.16235343f, 0.15885088f, 0.12995043f, 0.05615904f, 0.05345757f, 0.02867889f, -0.18477027f, 0.06641670f, 
    -0.32215205f, 0.15024377f, -0.32947385f, -0.17392555f, -0.11365987f, 0.11798204f, 0.02572978f, 0.01577201f, 
    -0.08385013f, -0.15396145f, -0.01973785f, 0.04531026f, 0.07343137f, -0.11922447f, -0.05430617f, 0.06112597f, 
    0.03729661f, -0.05795701f, 0.02752453f, 0.00653788f, -0.29174972f, 0.10730866f, -0.13205913f, -0.15997225f, 
    0.13279650f, -0.07126494f, 0.06153982f, 0.03415978f, 0.07450861f, -0.11408238f, 0.13815261f, -0.01029848f, 
    0.21521661f, -0.13525932f, -0.09293644f, 0.05852441f, 0.20153914f, -0.24755432f, 0.12211569f, 0.09415658f, 
    -0.04630526f, -0.30643961f, -0.23689798f, 0.07910537f, 0.03171360f, 0.13365924f, 0.12758914f, 0.02393095f, 
    0.14796975f, -0.06358370f, -0.00229437f, 0.06340200f, 0.01479277f, 0.01244503f, 0.03441399f, -0.03469840f, 
    -0.00092651f, -0.14128216f, -0.06103873f, -0.16305357f, 0.03922249f, 0.14369188f, 0.20425692f, -0.22480518f, 
    -0.11245829f, 0.02712981f, 0.07541782f, -0.06278991f, 0.21350780f, 0.05795588f, -0.04532324f, 0.00805208f, 
    -0.00788013f, -0.05975072f, -0.16321300f, -0.03169231f, 0.07842530f, 0.03517174f, 0.02609221f, -0.00199693f, 
    -0.04175467f, -0.02517544f, -0.00023643f, -0.01597748f, 0.07131112f, -0.01580050f, 0.00038233f, -0.08148993f, 
    -0.11662278f, 0.08784754f, -0.00838839f, -0.03289109f, -0.08202797f, 0.02744632f, -0.01843851f, 0.03007709f, 
    -0.01058588f, -0.05889164f, 0.00303414f, 0.00010923f, 0.16495742f, 0.01001015f, 0.06987597f, 0.12873822f, 
    -0.07808775f, -0.03743395f, 0.07996719f, 0.04070560f, -0.02231999f, -0.02347771f, -0.05965490f, -0.02387345f, 
    -0.05306690f, 0.06965373f, 0.09037811f, 0.07893244f, -0.00143588f, 0.05586570f, -0.00166920f, 0.03057908f, 
    0.37345630f, 0.33006179f, 0.24748372f, -0.08531190f, -0.02437340f, -0.01230446f, -0.01863158f, 0.01903732f, 
    -0.22466451f, 0.08831197f, -0.00215317f, -0.00299982f, -0.02794083f, 0.07241497f, -0.05941380f, 0.04945275f, 
    -0.06510241f, 0.04336589f, 0.09931579f, 0.02678167f, -0.64118677f, -0.45399222f, -0.28980544f, -0.10540722f, 
    -0.05836677f, 0.11691713f, 0.21309954f, -0.09830464f, 0.01428232f, 0.04281542f, -0.00097325f, 0.16002147f, 
    0.12440404f, 0.01359972f, 0.08554874f, 0.08952585f, 0.11072887f, 0.00626750f, 0.01512078f, -0.00488084f, 
    0.10363460f, 0.00920516f, -0.00022945f, 0.00013040f, -0.07328930f, -0.10594784f, -0.04385002f, -0.08401726f, 
    -0.14110348f, 0.07026464f, 0.04281662f, 0.08115055f, 0.17899576f, 0.10515953f, 0.02531627f, -0.05105458f, 
    -0.08258892f, 0.12410518f, 0.06564713f, -0.10260995f, -0.26908121f, -0.13147689f, 0.04680974f, 0.25261351f, 
    -0.07019585f, 0.02325701f, -0.04994822f, -0.06034162f, 0.08532572f, -0.07928573f, 0.03193714f, -0.05999244f, 
    -0.05729258f, 0.10515014f, 0.17971869f, -0.06224097f, 0.17432286f, 0.05787854f, 0.08166932f, -0.14328890f, 
    -0.46374106f, -0.04901971f, 0.12635724f, -0.00756655f, -0.22944312f, 0.04611252f, -0.01413532f, 0.02025877f, 
    -0.09126294f, -0.04584777f, 0.07769725f, -0.03170306f, -0.08470062f, 0.02635163f, -0.10472632f, -0.03553288f, 
    0.07819613f, 0.11369933f, 0.03566383f, 0.05174520f, -0.01438660f, 0.19534920f, -0.40810806f, -0.25682867f, 
    0.00438173f, 0.17233330f, 0.04669910f, 0.16692290f, -0.04205113f, -0.02610554f, -0.01403465f, -0.05443328f, 
    -0.18798973f, -0.04796170f, -0.10473479f, -0.04362398f, -0.06545247f, 0.07526959f, -0.16338184f, 0.05725379f, 
    -0.26121369f, -0.05718956f, 0.18136440f, 0.03278944f, -0.25185424f, 0.18424484f, 0.08925009f, -0.00194394f, 
    0.06068249f, 0.15817125f, 0.04620327f, 0.04045925f, -0.17731009f, -0.10521372f, -0.11980906f, 0.04977735f, 
    0.00280392f, 0.05997949f, 0.02744974f, 0.09333319f, -0.17386192f, 0.17636949f, 0.20238794f, 0.05533170f, 
    -0.25249147f, -0.00203828f, -0.06456758f, 0.00680581f, -0.13494366f, -0.08065170f, 0.05363967f, -0.08142509f, 
    -0.10699845f, -0.06547349f, -0.08231954f, 0.08031885f, -0.05528346f, 0.09852604f, 0.04168153f, 0.01057652f, 
    0.22006980f, 0.04153213f, -0.08395941f, 0.23548040f, 0.06896645f, -0.15408680f, 0.01848328f, 0.02385984f, 
    0.11131800f, 0.06979869f, -0.08328091f, -0.04973250f, -0.07119651f, 0.09627310f, 0.14037506f, 0.00289400f, 
    0.13329914f, -0.00905042f, 0.03023141f, -0.09180085f, -0.22123484f, -0.23924446f, 0.11059012f, 0.14156692f, 
    -0.24346584f, 0.12551136f, -0.00169997f, -0.07139286f, 0.05171586f, 0.00054645f, -0.06705568f, 0.01667122f, 
    -0.04223861f, 0.02411283f, 0.03599909f, -0.10574894f, 0.18043573f, 0.10702606f, -0.01681572f, -0.01439570f, 
    -0.14716385f, -0.22286455f, 0.08122764f, 0.09172284f, 0.17521062f, -0.04204025f, -0.08350112f, 0.00071978f, 
    0.10753602f, 0.07981391f, -0.03248819f, 0.00708644f, 0.08841749f, 0.09445089f, 0.00344008f, -0.03697410f, 
    0.12634635f, -0.33055365f, -0.02488628f, -0.00274277f, 0.00828263f, 0.00072167f, -0.00813073f, 0.03223028f, 
    0.23442335f, -0.13481764f, -0.06727668f, -0.02091288f, 0.02507687f, -0.00247617f, -0.13674982f, -0.18293922f, 
    0.15252848f, 0.00998997f, 0.12716646f, -0.10207229f, -0.04901882f, -0.07916980f, -0.03871676f, -0.01088894f, 
    0.01566277f, 0.03299997f, -0.08758880f, -0.10242478f, -0.18547717f, 0.05351304f, -0.05933424f, 0.02471467f, 
    0.06115099f, 0.06721272f, 0.10152174f, 0.06056258f, 0.03588880f, -0.11414183f, -0.06627192f, -0.02530044f, 
    -0.02380442f, -0.11286327f, 0.14570187f, -0.19563346f, -0.01516662f, 0.21070381f, -0.00569864f, -0.12876169f, 
    0.05084221f, 0.10296987f, 0.07452644f, 0.07433756f, -0.07676162f, 0.14773269f, -0.04107116f, 0.06497496f, 
    -0.04720056f, -0.03075204f, -0.02033868f, -0.05512117f, 0.00614346f, -0.01254944f, -0.09566823f, 0.01388132f, 
    -0.17195922f, 0.13587439f, -0.00645835f, 0.10863745f, -0.19866702f, -0.07595200f, 0.02107803f, -0.06415987f, 
    0.00282667f, 0.09290745f, -0.07252620f, -0.10905249f, -0.11432005f, 0.05168936f, -0.03321956f, 0.06283331f, 
    -0.01607436f, -0.12977034f, -0.03263975f, 0.05805294f, -0.43298849f, 0.17588183f, 0.07792672f, 0.23345855f, 
    0.05032311f, -0.04749126f, 0.04832216f, -0.00768081f, -0.13328761f, 0.08323138f, -0.03292064f, -0.01042222f, 
    -0.07209674f, 0.06773934f, 0.00655206f, -0.06741457f, -0.05636250f, -0.01076877f, -0.04171870f, -0.16991903f, 
    -0.01510738f, -0.14317450f, -0.13131475f, -0.10774662f, 0.16280079f, 0.03485238f, -0.14513369f, -0.10164061f, 
    0.03038993f, 0.09353635f, 0.05955267f, 0.09022005f, 0.20353281f, 0.06253710f, 0.11598819f, -0.08798023f, 
    -0.15584503f, -0.06873702f, -0.12160587f, -0.06285122f, 0.20776065f, 0.12852892f, 0.07112556f, 0.05023958f, 
    0.05337940f, -0.08543979f, -0.16279174f, 0.01269009f, 0.05902673f, 0.05215863f, -0.06203029f, -0.22165924f, 
    -0.01894072f, 0.13385256f, 0.07882155f, 0.02695376f, 0.00417018f, -0.01457543f, 0.00817527f, 0.04764366f, 
    -0.50744456f, 0.03464176f, -0.31128827f, -0.07278605f, 0.07392098f, 0.06370367f, 0.04391019f, -0.06602629f, 
    -0.04589228f, -0.12228774f, 0.03068963f, -0.00188630f, -0.07153802f, -0.07996923f, -0.00319121f, -0.22541144f, 
    -0.00698719f, 0.01686299f, 0.06236631f, -0.04159813f, -0.02816902f, -0.00342024f, 0.03309254f, 0.17051809f, 
    0.03777384f, -0.07591952f, -0.09481005f, 0.09721579f, -0.01103600f, 0.17435753f, 0.06834469f, -0.06716528f, 
    -0.05409206f, 0.02462843f, -0.12255159f, -0.01417504f, -0.04431333f, -0.22495283f, 0.11971079f, 0.04624860f, 
    0.01870245f, -0.21881947f, -0.03447965f, 0.06181820f, -0.05922711f, 0.00557613f, -0.07532562f, 0.09910984f, 
    -0.05912064f, 0.03869531f, -0.04971324f, 0.02082994f, -0.09990691f, -0.07514974f, -0.02320700f, -0.01910464f, 
    -0.02128366f, 0.05115319f, 0.01555264f, -0.04542742f, 0.27196088f, -0.34950781f, -0.19037187f, 0.06725236f, 
    0.02644685f, 0.02709610f, 0.07906035f, 0.00202260f, 0.01439478f, 0.07063162f, -0.04425031f, 0.00851566f, 
    -0.01294064f, 0.01787568f, -0.02447803f, 0.21374989f, -0.03067616f, 0.09989445f, -0.10422995f, 0.13692084f, 
    -0.59043241f, 0.17098346f, 0.05008756f, 0.21180765f, 0.02139254f, 0.02651109f, 0.00940286f, 0.07023167f, 
    0.12680945f, -0.09057777f, -0.05355152f, -0.07719050f, 0.06596803f, 0.00364816f, -0.09841491f, 0.03196551f, 
    0.03381376f, -0.08773561f, -0.09994692f, -0.06819227f, -0.13104783f, -0.37485135f, -0.04428862f, -0.07605568f, 
    0.09150952f, 0.05875363f, -0.03473320f, -0.04982648f, -0.07160908f, -0.02490535f, 0.06082394f, -0.00551902f, 
    0.10900873f, 0.13135830f, -0.02477521f, -0.05662733f, 0.01341872f, -0.11088543f, -0.10088672f, -0.02095929f, 
    -0.21093406f, 0.41305816f, -0.03628909f, 0.21306321f, -0.30290952f, -0.12397338f, -0.13394776f, 0.04266266f, 
    0.08309814f, 0.04370642f, 0.06837127f, 0.05742192f, -0.07948989f, 0.07317550f, 0.02644739f, -0.00683547f, 
    -0.01368404f, -0.03554972f, -0.03309337f, 0.00882238f, 0.11159039f, 0.11485764f, -0.11703246f, -0.22837958f, 
    0.02833766f, -0.02849510f, -0.03990565f, -0.08277623f, 0.02198792f, 0.02183769f, -0.09629710f, -0.11507303f, 
    -0.18035798f, -0.01793479f, -0.11427585f, -0.03138389f, 0.06202733f, 0.00824215f, 0.12359986f, -0.08519837f, 
    0.13916117f, -0.45596486f, -0.04606284f, -0.21360479f, 0.03176060f, -0.05948881f, 0.08906712f, -0.02477666f, 
    0.08386370f, 0.00830174f, -0.01949871f, 0.10729425f, 0.09968955f, 0.12432317f, 0.07832069f, 0.01187844f, 
    0.10072869f, -0.05819466f, -0.19655611f, 0.10116909f, 0.06689677f, -0.05001022f, 0.13088873f, 0.02660388f, 
    0.22764041f, -0.02944122f, 0.13678887f, -0.08830569f, -0.19272843f, -0.20833910f, -0.12554637f, 0.02206551f, 
    -0.00118329f, 0.07180152f, 0.05051762f, 0.17120765f, -0.03441102f, 0.09886277f, -0.05616311f, 0.03289893f, 
    -0.20035420f, -0.11082625f, -0.00910604f, 0.00329864f, 0.12213609f, -0.02018059f, 0.07633138f, 0.06935330f, 
    -0.27676338f, -0.19107161f, 0.02210377f, -0.06933656f, 0.03154361f, 0.16031466f, -0.11174629f, 0.00147303f, 
    0.05889778f, 0.17735332f, 0.28153467f, -0.00476986f, -0.04083288f, 0.06333437f, -0.03481342f, -0.00674300f, 
    0.02152804f, -0.13782772f, -0.00913921f, -0.06649916f, -0.07994605f, -0.05376552f, -0.01035126f, -0.03655281f, 
    -0.00515028f, 0.10237651f, -0.04471245f, 0.05666528f, -0.02471120f, -0.02833166f, 0.08929271f, -0.07059807f, 
    0.02417526f, -0.03032435f, -0.20978627f, 0.27909049f, -0.25354138f, -0.05442763f, 0.20371841f, 0.07525859f, 
    0.05024847f, 0.07614960f, 0.06014745f, 0.02630438f, -0.03122832f, -0.03468913f, -0.00270453f, -0.01878603f, 
    -0.06073700f, 0.13706423f, -0.01777226f, 0.06538820f, -0.34478509f, 0.36422047f, 0.04423404f, 0.21544166f, 
    -0.17253910f, -0.09041064f, 0.03867737f, -0.04865137f, 0.03410676f, 0.08830602f, -0.01221494f, 0.07449710f, 
    0.07176606f, -0.11049464f, 0.00572647f, -0.02318376f, 0.01784673f, -0.09433451f, -0.00215784f, -0.17662807f, 
    -0.30135554f, 0.12322910f, -0.22586726f, 0.16065119f, -0.18198776f, -0.15211004f, -0.01555338f, 0.00842773f, 
    0.03241144f, -0.02251630f, -0.07565736f, -0.02575438f, 0.02065331f, 0.09244852f, -0.01183073f, 0.05323230f, 
    -0.11650117f, -0.08607879f, -0.17986114f, -0.04112451f, -0.06215510f, -0.15549503f, -0.02034249f, -0.48631623f, 
    0.00966128f, -0.04113498f, -0.04180910f, 0.06674058f, -0.15541774f, 0.01317458f, -0.03790167f, 0.01671425f, 
    -0.11562818f, 0.11195912f, -0.06033530f, -0.09811689f, 0.10191238f, -0.03378922f, -0.00015235f, 0.02505209f, 
    -0.35642999f, 0.26417810f, 0.03313581f, 0.18828681f, -0.07965538f, 0.09274222f, -0.12234358f, -0.00283957f, 
    0.10379753f, -0.00606535f, 0.09217124f, 0.00280682f, -0.15593380f, 0.07294182f, 0.11878265f, 0.16851451f, 
    0.00747726f, -0.11807445f, 0.01503424f, 0.05854848f, 0.24309783f, 0.11736215f, -0.04676827f, -0.17126006f, 
    0.08274309f, 0.14091159f, -0.21852615f, 0.09917550f, 0.00514424f, 0.14120004f, 0.10836828f, 0.03994972f, 
    0.03497748f, -0.04896588f, -0.06439486f, 0.10507780f, -0.03347841f, 0.02613547f, 0.02265999f, -0.07204926f, 
    0.25693616f, -0.55634904f, -0.18021432f, 0.16325654f, -0.07477338f, -0.09400787f, -0.02474538f, -0.00207287f, 
    -0.03916171f, 0.09450642f, -0.00239300f, 0.03587650f, -0.13139516f, 0.03653245f, 0.10874107f, -0.08358896f, 
    -0.02364014f, -0.00932508f, -0.06613072f, -0.05413067f, -0.03284262f, -0.32561281f, -0.01794354f, -0.36964253f, 
    0.02256277f, 0.08747291f, -0.03542926f, 0.09953667f, -0.13000262f, -0.02448063f, -0.09268202f, -0.09981576f, 
    0.18996462f, 0.03956502f, 0.15788160f, 0.02178968f, -0.06446335f, -0.08442085f, 0.06156335f, 0.05378762f, 
    -0.18912831f, 0.31855249f, -0.01771027f, -0.00949335f, -0.27324581f, 0.00953384f, 0.07082693f, 0.04648219f, 
    -0.07156105f, 0.11257222f, -0.00802632f, -0.05536830f, 0.17790157f, -0.02617216f, 0.09209311f, 0.01998233f, 
    -0.05955575f, -0.14850512f, 0.07887073f, -0.08160574f, 0.18197642f, -0.46456188f, -0.17216721f, 0.11486251f, 
    -0.16773669f, -0.04706553f, 0.03997003f, 0.01903493f, 0.06272778f, 0.12248233f, -0.16689190f, -0.03696521f, 
    0.01136031f, -0.00747299f, 0.09625375f, 0.03247431f, -0.04567853f, -0.04496027f, -0.14784834f, 0.01490306f, 
    -0.10248598f, 0.38852975f, -0.15805802f, 0.16404912f, -0.22957130f, -0.08184249f, 0.00565022f, 0.03673182f, 
    0.03549863f, -0.10557912f, 0.03743954f, 0.10695190f, -0.14076234f, -0.02145301f, -0.22401464f, 0.01601281f, 
    -0.10455415f, 0.09919177f, -0.06432427f, 0.04451987f, 0.39197734f, -0.16666651f, -0.19712533f, 0.28157255f, 
    0.01597640f, -0.11839026f, -0.11013936f, -0.03022583f, 0.08479591f, -0.01535358f, 0.04754961f, 0.09348652f, 
    -0.01043480f, 0.03609625f, -0.00485416f, -0.06230008f, 0.01764944f, -0.04032009f, -0.20381977f, -0.06465819f, 
    -0.05664915f, -0.06699240f, -0.35513037f, -0.15605620f, 0.09119453f, 0.07747918f, 0.03847130f, -0.03191254f, 
    -0.17259851f, 0.09026882f, 0.00009185f, -0.08634049f, -0.06410104f, 0.07148243f, -0.14471491f, -0.01016996f, 
    0.08807077f, 0.19392598f, 0.03766282f, 0.06218773f, -0.24793576f, 0.27898878f, 0.16970499f, -0.00761200f, 
    -0.50378644f, 0.01405726f, 0.09906771f, -0.01337746f, 0.04762559f, 0.07264099f, -0.05443723f, -0.03179953f, 
    0.03345467f, 0.16156764f, -0.17404951f, 0.09832924f, -0.01655035f, -0.02128997f, 0.03147995f, 0.05212404f, 
    0.15713982f, -0.09640019f, -0.28139585f, 0.08639815f, 0.13142377f, -0.19201225f, 0.22923662f, 0.05405662f, 
    0.03362356f, -0.09046952f, 0.04748831f, -0.01403310f, 0.03350504f, 0.02251628f, 0.17849779f, -0.07397094f, 
    -0.05265760f, 0.21541283f, -0.10919085f, 0.04544983f, -0.16040044f, -0.01513831f, -0.01127240f, -0.28207847f, 
    0.04697123f, -0.08506738f, -0.09317324f, 0.02851848f, 0.03644935f, -0.15513651f, -0.03809346f, -0.06214450f, 
    0.01967889f, -0.00266288f, 0.01537217f, 0.14671533f, -0.02058970f, 0.02637866f, 0.02726661f, -0.06538876f, 
    0.27381453f, -0.08186833f, 0.07650799f, 0.26386678f, -0.10478713f, -0.01092864f, 0.08632440f, -0.08640125f, 
    -0.01212167f, -0.05800461f, 0.01692843f, -0.03896553f, 0.01408913f, 0.08418451f, 0.09310731f, -0.09632209f, 
    -0.13690408f, 0.15946156f, -0.08566064f, 0.13042934f, 0.29685628f, -0.19114831f, 0.01737766f, 0.04195609f, 
    0.64132208f, -0.00117862f, -0.09642393f, -0.00262459f, 0.02482293f, -0.04051298f, -0.20741944f, -0.11509793f, 
    0.03584339f, -0.00410543f, 0.14916392f, -0.06028315f, -0.22238423f, 0.02079582f, 0.09193376f, 0.05482033f, 
    -0.01215621f, -0.13936476f, -0.32350773f, -0.34918898f, 0.05217584f, 0.05046621f, 0.09456189f, 0.08563539f, 
    0.01539143f, 0.06102217f, -0.04260433f, -0.09699827f, -0.09937946f, -0.04697210f, -0.08871281f, 0.04522405f, 
    0.05493955f, 0.15572478f, 0.02487643f, 0.08082248f, -0.25938901f, 0.33511516f, 0.08453713f, -0.02927438f, 
    -0.33959606f, 0.13717055f, 0.02561147f, 0.02189771f, 0.04225329f, 0.03091505f, -0.05825137f, 0.10421450f, 
    0.04161525f, -0.12080136f, -0.06458343f, -0.00548169f, -0.01103957f, 0.00313210f, 0.04756938f, -0.11019919f, 
    0.23912957f, -0.48675153f, 0.13304248f, -0.38079727f, 0.29827243f, 0.05587719f, -0.00152222f, -0.05598818f, 
    -0.03580967f, -0.17772993f, -0.02124031f, -0.09536638f, 0.07182480f, 0.01047018f, -0.06112867f, 0.04861525f, 
    -0.04430254f, -0.05244018f, -0.01233561f, 0.11456359f, 0.17866287f, 0.06174180f, -0.07924405f, 0.21503866f, 
    -0.04738753f, 0.06929918f, 0.13279550f, -0.17499352f, -0.03453717f, -0.05136571f, 0.00398966f, 0.15090913f, 
    0.00960462f, 0.03907880f, -0.05284792f, 0.05958901f, 0.01820671f, 0.19899732f, -0.01155934f, -0.03757033f, 
    0.18174903f, -0.53499871f, 0.03885563f, 0.03246172f, -0.22935225f, 0.05327957f, 0.01519587f, -0.03239309f, 
    -0.15234624f, -0.06207730f, 0.00227526f, -0.04560439f, -0.13867562f, 0.04308657f, -0.14912328f, -0.00832040f, 
    0.10315323f, -0.03769265f, -0.07816349f, -0.02774173f, 0.01018987f, 0.03759170f, 0.17286745f, 0.16847785f, 
    -0.14344664f, 0.21117328f, 0.04565107f, 0.00596209f, -0.05416657f, -0.03255749f, -0.02501466f, -0.03893473f, 
    0.03729554f, 0.11229412f, -0.14619066f, 0.02886046f, 0.00006245f, -0.02003036f, -0.05456730f, -0.01048478f, 
    -0.13851546f, 0.03944243f, -0.11830740f, -0.12812401f, -0.16130254f, 0.02743669f, 0.07656197f, -0.07420049f, 
    -0.07117709f, 0.00255785f, -0.10178663f, 0.06607011f, 0.00203520f, -0.04884295f, -0.02225933f, -0.02565844f, 
    0.06304196f, -0.06431098f, -0.05215040f, -0.02633554f, 0.15114543f, -0.14363195f, 0.22916682f, -0.08124643f, 
    0.07719631f, -0.05760020f, 0.05159467f, -0.09155866f, -0.04432091f, -0.00794156f, -0.03872773f, 0.05839758f, 
    -0.07352269f, 0.06072580f, -0.08217327f, -0.04273817f, -0.01139854f, 0.04602891f, -0.03546100f, -0.02498010f, 
    0.13099876f, -0.04268742f, -0.17280100f, -0.28027779f, -0.21759531f, 0.04873871f, -0.06864756f, -0.01768193f, 
    -0.05885068f, -0.16255720f, -0.02100651f, -0.00106692f, -0.07670002f, 0.10307682f, -0.14500841f, 0.10203035f, 
    -0.11060591f, -0.03426487f, -0.00007852f, -0.05394143f, 0.09439444f, -0.01968615f, 0.06026864f, 0.07582091f, 
    0.05774881f, -0.05699602f, -0.08283547f, -0.09351455f, 0.02907789f, -0.02748201f, -0.01668338f, -0.02049891f, 
    0.03275543f, -0.06298991f, -0.03555843f, -0.02444750f, -0.09304767f, -0.01407786f, 0.10093064f, -0.02846152f, 
    -0.11945752f, 0.11100581f, 0.24308135f, 0.17325023f, 0.26404810f, 0.02029173f, 0.16274464f, 0.01719725f, 
    -0.03246303f, -0.02885393f, 0.00489461f, 0.00229822f, 0.08516078f, -0.01392232f, -0.08138131f, -0.05308342f, 
    -0.00924526f, 0.04936782f, -0.01023890f, -0.03134814f, -0.25507212f, 0.23542529f, 0.11247680f, 0.02089865f, 
    0.13138227f, -0.04212402f, -0.00826008f, -0.03014698f, 0.07404371f, 0.07995417f, 0.00038144f, 0.04258538f, 
    0.01814230f, 0.02315729f, -0.13473277f, 0.06289093f, 0.05323576f, 0.09884896f, -0.00230963f, -0.01862482f, 
    0.25793251f, -0.28423345f, 0.23722084f, 0.06973794f, -0.00215084f, 0.01939870f, -0.00786424f, -0.05602017f, 
    0.00145138f, -0.02546171f, -0.05127129f, 0.10523810f, -0.03549105f, -0.01638711f, 0.03127212f, -0.11270607f, 
    0.07858523f, -0.07448559f, 0.07028718f, -0.06267006f, 0.27451378f, 0.28242445f, 0.01794566f, 0.09768901f, 
    0.02706813f, -0.06504080f, -0.03634333f, 0.03777961f, 0.02657570f, 0.00340334f, -0.04834364f, -0.04435889f, 
    0.01673039f, 0.04864342f, 0.03727628f, -0.05262523f, -0.10303783f, -0.03096032f, -0.00454651f, 0.00858509f, 
    -0.19866641f, 0.24510227f, -0.06309262f, 0.03427389f, -0.03649035f, -0.00393647f, 0.00290885f, -0.06679068f, 
    -0.02707980f, -0.07374740f, 0.02883164f, 0.02592867f, -0.03025205f, -0.06480610f, -0.08418244f, 0.02694911f, 
    0.03790672f, 0.02496827f, -0.01018662f, -0.07771677f, -0.29868060f, -0.12100420f, -0.16427341f, -0.30586037f, 
    -0.20965765f, -0.00415245f, -0.13842523f, -0.05503310f, -0.00509110f, -0.09005702f, -0.12523423f, -0.07064925f, 
    0.01312220f, -0.03051187f, -0.11798860f, -0.02133721f, 0.06604899f, -0.01251339f, -0.03243256f, 0.03251821f, 
    0.04372375f, 0.06499617f, 0.02204346f, -0.16999649f, -0.18663093f, -0.09477375f, -0.04541748f, 0.05003360f, 
    -0.02678779f, -0.00683897f, 0.11088013f, 0.05759173f, -0.03849554f, 0.02330770f, 0.01602344f, -0.05004647f, 
    -0.04973562f, -0.06132821f, -0.03847174f, 0.09789437f, -0.00580161f, 0.24933106f, 0.18504356f, 0.22904913f, 
    0.26098388f, 0.14871711f, 0.07180670f, 0.03543016f, -0.04623370f, -0.05932932f, -0.10065351f, -0.02918863f, 
    0.06576855f, -0.08360454f, -0.03230400f, 0.08619787f, 0.02825410f, 0.06803924f, 0.03350137f, -0.09912999f, 
    0.03109397f, -0.02178863f, -0.29554015f, -0.27307135f, -0.20471144f, -0.05749994f, -0.07155108f, 0.02363555f, 
    0.00227358f, -0.11201725f, 0.01452866f, -0.04630647f, -0.03175170f, 0.00877243f, -0.05940584f, -0.04345349f, 
    -0.05680008f, -0.06705675f, -0.07665510f, 0.00055219f, 0.16380216f, -0.11270011f, 0.12437654f, 0.11957573f, 
    0.05322414f, 0.18076290f, 0.03157241f, -0.06883369f, -0.11610094f, -0.01366104f, -0.02106988f, -0.03184353f, 
    -0.17810354f, -0.08261432f, -0.02172358f, 0.11105540f, 0.08789438f, -0.05095347f, 0.02179619f, 0.00329915f, 
    0.06323106f, -0.18058901f, 0.00649115f, 0.02635879f, -0.12419993f, 0.07588576f, -0.09624311f, -0.02082735f, 
    -0.05931007f, -0.02994776f, -0.03708431f, -0.04852040f, -0.00349924f, -0.05883279f, -0.10929642f, -0.03122901f, 
    0.00987156f, 0.01281625f, 0.00950735f, -0.03519988f, 0.28885376f, -0.01809589f, 0.30760214f, 0.06492711f, 
    0.27402747f, 0.04632936f, 0.10329679f, -0.08068608f, 0.00305530f, 0.05508455f, -0.01832726f, 0.06625216f, 
    0.06922554f, -0.03322346f, 0.01231192f, -0.09513251f, 0.01566990f, -0.05551717f, 0.03624504f, -0.10465293f, 
    0.17642607f, 0.27650136f, -0.14628634f, 0.02848463f, -0.18809977f, 0.02080525f, -0.09607588f, -0.00709265f, 
    0.05972392f, 0.01589765f, -0.06788044f, 0.02030241f, -0.00156237f, 0.15817586f, 0.02064751f, -0.06223468f, 
    -0.04280371f, -0.02216443f, -0.12067520f, 0.04067684f, -0.09490427f, -0.14297312f, 0.05467111f, -0.02102243f, 
    -0.14803880f, 0.00318621f, -0.07510806f, -0.02828699f, -0.05899751f, 0.00196752f, -0.02270739f, -0.00640465f, 
    -0.02362571f, 0.06426373f, -0.11104249f, 0.01472436f, -0.02574673f, 0.06478051f, 0.01371309f, -0.01957879f, 
    -0.47193083f, -0.12953097f, -0.33110449f, -0.09452678f, 0.02471716f, 0.09426379f, -0.16282779f, -0.04124338f, 
    0.01911252f, -0.06480193f, -0.19410329f, 0.06538796f, -0.04982208f, -0.09641258f, 0.00223825f, -0.06819136f, 
    -0.03164872f, -0.03378430f, -0.02708335f, 0.06387815f, 0.16501838f, -0.08982661f, 0.17195828f, -0.08814879f, 
    -0.14633796f, 0.18477912f, 0.03281094f, 0.03170369f, -0.04771783f, -0.07291996f, -0.14127019f, -0.04039334f, 
    -0.10157417f, 0.01947880f, -0.05638558f, 0.03632858f, 0.02581599f, 0.02864115f, 0.06232359f, 0.02102425f, 
    -0.04459257f, 0.25289539f, -0.18726251f, 0.01036900f, 0.23115112f, -0.17335093f, 0.01158838f, -0.18185712f, 
    -0.02249564f, -0.08370026f, -0.02782245f, 0.03328514f, -0.10371400f, -0.06715742f, -0.05725782f, -0.00218488f, 
    -0.02156500f, 0.18345939f, -0.04913638f, -0.11749708f, -0.17680892f, -0.18851368f, -0.35423204f, 0.08211028f, 
    0.01165012f, -0.04048835f, -0.11920317f, 0.04554268f, -0.01680584f, -0.09824695f, -0.11992731f, 0.00655892f, 
    -0.05948017f, -0.02471717f, -0.01470623f, 0.01685930f, 0.04981892f, -0.03383325f, 0.02465587f, 0.01777001f, 
    0.11063505f, 0.21682823f, -0.17102437f, -0.07164089f, -0.05762909f, -0.16520305f, 0.02204691f, -0.13535446f, 
    0.12389103f, -0.00606070f, -0.14523835f, 0.06977995f, 0.00690427f, 0.05478619f, 0.00353000f, 0.07347029f, 
    -0.13223274f, 0.06724726f, 0.00194292f, -0.00124914f, 0.15953439f, 0.19391084f, 0.26493403f, 0.17728914f, 
    0.11803371f, 0.09176068f, 0.08194731f, 0.03829280f, 0.00756587f, -0.03864511f, 0.02310466f, 0.01598031f, 
    -0.01523373f, 0.06662079f, -0.09804548f, -0.02727393f, 0.03028225f, -0.00513552f, -0.07060782f, -0.09188899f, 
    -0.21578816f, 0.20345585f, -0.07115571f, 0.00542239f, 0.09543332f, -0.01484167f, -0.20839117f, -0.10264636f, 
    0.01303322f, -0.08342291f, 0.00484643f, 0.04156481f, -0.03652212f, -0.02484202f, -0.00845926f, -0.06787516f, 
    -0.06087900f, 0.10316671f, -0.01860727f, -0.03613399f, -0.12024643f, -0.11681509f, -0.08461413f, 0.07159578f, 
    0.17984353f, -0.17323527f, 0.01360685f, 0.00247397f, 0.18842234f, -0.00965386f, -0.00838129f, 0.03961204f, 
    -0.11390217f, -0.04376707f, 0.06638933f, 0.05347818f, -0.09925939f, -0.00744648f, -0.12189016f, -0.07515960f, 
    0.07615135f, 0.24589582f, -0.00982689f, 0.17026749f, 0.31113732f, -0.10602371f, 0.05214451f, -0.14472798f, 
    0.00618319f, -0.07048937f, -0.03198194f, 0.06276791f, -0.01761484f, -0.07241637f, -0.08294742f, 0.04544248f, 
    -0.03526526f, 0.07349109f, -0.02090330f, -0.06963287f, -0.37572432f, -0.10497071f, -0.27248812f, -0.06145869f, 
    -0.08365544f, -0.02542806f, -0.07744502f, -0.03764843f, 0.03341972f, -0.11084495f, -0.12004282f, -0.01886017f, 
    0.07277753f, -0.12895575f, -0.10593458f, -0.08675911f, 0.00195344f, 0.02128454f, -0.01183463f, 0.05720942f, 
    0.20770568f, 0.02122852f, 0.36481750f, -0.00720728f, 0.34382677f, -0.11488260f, 0.17705281f, 0.03516369f, 
    0.05925063f, 0.11444508f, 0.03929947f, 0.02988884f, -0.13423805f, 0.04301226f, -0.00576676f, -0.02217204f, 
    0.04355945f, 0.12115152f, -0.04167597f, -0.12492958f, -0.07201909f, 0.25464565f, -0.05770286f, -0.01076145f, 
    0.09190922f, -0.03275838f, -0.02364558f, -0.10231158f, 0.07234029f, -0.02382020f, -0.05375027f, 0.01913254f, 
    -0.01953528f, -0.01880552f, -0.09413259f, -0.00349132f, -0.01714552f, 0.05728096f, -0.02782458f, -0.07477908f, 
    0.16450213f, 0.04130290f, -0.01045036f, 0.09887312f, 0.16870070f, -0.04945324f, -0.00497395f, -0.07723076f, 
    -0.11597650f, 0.10075849f, -0.11975383f, -0.02267352f, -0.01368501f, -0.03610437f, 0.00418987f, 0.03232377f, 
    -0.09107749f, 0.01121731f, 0.09752251f, 0.05138206f, -0.15691783f, -0.06193997f, -0.10564518f, 0.03081135f, 
    0.05813112f, -0.05097805f, -0.07650471f, -0.15375081f, 0.01572346f, 0.01615377f, -0.00936072f, -0.04672008f, 
    -0.18858045f, -0.00880161f, 0.08957861f, 0.04000675f, 0.05574157f, -0.00047095f, 0.12400297f, 0.01048960f, 
    0.09599221f, 0.11732956f, -0.35425994f, 0.04393706f, -0.06736281f, 0.10553150f, -0.00591775f, -0.09364063f, 
    -0.11763574f, 0.00724104f, 0.03148539f, 0.06087488f, -0.11770385f, 0.05362092f, 0.00920396f, -0.04863012f, 
    -0.06464663f, -0.00114810f, 0.06038654f, 0.02722851f, 0.01192758f, -0.02002827f, 0.10611618f, 0.07878935f, 
    0.18107060f, -0.09866124f, -0.05554401f, 0.04442481f, -0.01062323f, 0.02985957f, -0.00534004f, -0.06316647f, 
    -0.02653185f, -0.02846052f, 0.00046860f, 0.06277226f, 0.00900114f, 0.04789903f, 0.11411901f, 0.04860747f, 
    0.11742083f, 0.07065618f, -0.06131039f, 0.16764155f, 0.18591470f, 0.06349191f, 0.03977895f, -0.17185615f, 
    -0.01904011f, -0.03287732f, 0.09842641f, -0.03136870f, 0.04906559f, -0.04094190f, 0.01499873f, -0.10554853f, 
    0.08801774f, 0.04772514f, 0.12383278f, 0.00334862f, -0.16148901f, -0.25744256f, -0.04136983f, -0.35022321f, 
    -0.21491855f, 0.04281159f, -0.06193984f, 0.02316429f, -0.07410801f, -0.12701669f, -0.00464582f, 0.09362681f, 
    -0.01750540f, 0.03479101f, -0.05867110f, -0.01139601f, -0.06211326f, -0.12458505f, -0.17572623f, -0.05415358f, 
    -0.14802580f, -0.14098674f, 0.29657665f, 0.00998169f, 0.15044443f, -0.13531533f, -0.06616238f, 0.01951159f, 
    -0.05258553f, 0.02396266f, 0.02340401f, -0.05732033f, -0.09374069f, -0.13142949f, 0.07028953f, -0.04329998f, 
    -0.04176543f, -0.02663030f, 0.11504414f, 0.01816954f, 0.17427188f, 0.11276758f, -0.07475421f, -0.03207598f, 
    -0.23179375f, -0.05591368f, -0.00701642f, -0.00693784f, -0.11164772f, 0.11820663f, 0.09703607f, -0.09756753f, 
    0.03352073f, -0.12499585f, 0.01317715f, -0.03190516f, -0.01708417f, -0.19619840f, 0.21691795f, -0.05812826f, 
    -0.07872244f, 0.02753327f, -0.12761573f, 0.04971777f, -0.15337525f, -0.02419075f, -0.01257336f, -0.01333543f, 
    -0.08446805f, -0.06363684f, 0.11642308f, -0.04084161f, -0.03617929f, 0.03677844f, -0.00512059f, 0.04468631f, 
    -0.09323815f, -0.17990711f, -0.16116829f, 0.00416740f, -0.04492117f, 0.10489237f, -0.05198498f, -0.25979334f, 
    -0.10414813f, 0.00848202f, 0.01622744f, -0.03803778f, 0.02002020f, -0.05402083f, 0.03772603f, -0.00668649f, 
    -0.02443193f, -0.17013493f, 0.04267818f, 0.00603931f, 0.14995761f, -0.11711799f, 0.09356146f, -0.13514231f, 
    0.08063804f, 0.09038591f, -0.20073843f, 0.07808852f, -0.03891344f, -0.04802535f, 0.02925408f, -0.17765908f, 
    -0.04950861f, -0.03692630f, 0.04975549f, -0.01245081f, 0.02899876f, -0.13373946f, 0.09871953f, 0.01276622f, 
    -0.03099948f, -0.06293300f, 0.18189824f, 0.01926667f, 0.15735276f, -0.01585571f, -0.07501160f, 0.09382206f, 
    0.13957900f, 0.09551714f, 0.06440689f, -0.08813994f, -0.02038922f, -0.00479536f, -0.00648579f, 0.02439831f, 
    0.00710507f, 0.04131526f, -0.06302340f, -0.01578474f, 0.07242896f, 0.06731889f, 0.08882559f, 0.04563533f, 
    0.22678140f, 0.17393452f, -0.12894699f, 0.07235043f, 0.10420375f, -0.00912975f, 0.03252588f, -0.18605013f, 
    -0.05804338f, -0.13646786f, -0.01193020f, 0.03627999f, 0.01979531f, -0.20874403f, -0.02498869f, -0.10870368f, 
    0.02247727f, 0.01738819f, 0.14923796f, -0.02349001f, -0.29640964f, -0.19437735f, 0.23954335f, -0.20164347f, 
    0.00487477f, -0.01946684f, 0.01164475f, -0.01310845f, -0.11214344f, -0.09922452f, 0.06645301f, -0.02365759f, 
    0.07171277f, -0.23230220f, -0.02961267f, -0.08464784f, -0.05745059f, 0.03242308f, -0.08078355f, 0.00791538f, 
    -0.03716522f, 0.11711888f, -0.01442393f, 0.01919395f, 0.12984663f, 0.00909945f, 0.08006933f, -0.06406303f, 
    -0.01712559f, -0.07510116f, 0.03456029f, 0.02157767f, -0.00278349f, -0.02427512f, 0.02666972f, -0.19858646f, 
    0.02932518f, 0.02604830f, 0.05384304f, -0.09489030f, 0.01435995f, -0.20012456f, 0.12788324f, -0.13166437f, 
    0.03787698f, -0.03768023f, -0.04737924f, 0.01091606f, -0.02765727f, -0.13672538f, 0.07108053f, -0.01067987f, 
    -0.02686355f, 0.08195291f, 0.00564651f, 0.00704866f, -0.02092502f, 0.02106182f, -0.13395175f, 0.02792790f, 
    0.04346641f, -0.03850430f, 0.07088110f, 0.06092221f, 0.17438871f, -0.12632601f, -0.07328515f, -0.03949239f, 
    -0.06682355f, -0.00462476f, -0.08291856f, -0.08904161f, -0.02818801f, -0.03733443f, -0.07752810f, 0.08062149f, 
    0.02354018f, 0.09034479f, 0.05399494f, 0.03473576f, -0.19309840f, -0.09435121f, 0.23505296f, -0.21985561f, 
    -0.02695431f, 0.07933141f, -0.00302690f, 0.12603803f, -0.06285875f, 0.10604277f, 0.06137412f, -0.09266275f, 
    -0.15526527f, 0.04436635f, 0.12814467f, -0.07238480f, -0.04591991f, 0.16497104f, -0.13315600f, -0.06754042f, 
    -0.12679233f, 0.04098087f, -0.03811612f, -0.28471270f, -0.02804245f, 0.05414667f, 0.04325505f, -0.20340988f, 
    0.00627780f, -0.14719872f, 0.13226834f, -0.00773370f, 0.10045108f, -0.16665792f, 0.04026517f, -0.07902052f, 
    0.00379953f, -0.00948536f, -0.09907313f, -0.02217037f, 0.11601179f, 0.09850755f, -0.01349154f, 0.05603979f, 
    0.14284810f, -0.08390468f, -0.06804460f, -0.10452732f, -0.01176002f, -0.02996244f, -0.07456647f, -0.10048745f, 
    -0.04955638f, -0.12597838f, 0.06529666f, 0.01659778f, 0.08756724f, 0.00610180f, 0.07812504f, 0.00501481f, 
    0.23895757f, 0.09929447f, -0.11424338f, -0.02578013f, 0.10146911f, 0.11120015f, 0.02665628f, -0.00223083f, 
    0.00903086f, -0.06867938f, 0.04768090f, -0.01619173f, 0.00220426f, 0.09924091f, -0.01845116f, 0.10291985f, 
    0.09423966f, 0.11403159f, 0.10471096f, -0.01746486f, 0.17141809f, 0.13064924f, -0.09503809f, 0.06296483f, 
    0.10112888f, 0.07055608f, -0.05121504f, -0.07368290f, 0.06064210f, 0.00572660f, 0.02348785f, 0.04603989f, 
    0.06981391f, 0.03303972f, -0.03253032f, 0.04733334f, -0.01997790f, 0.06360624f, 0.07413513f, 0.06250226f, 
    -0.21611536f, 0.29320011f, 0.04803189f, -0.16385135f, -0.31091601f, -0.16754143f, 0.01053961f, -0.04587588f, 
    0.04913751f, -0.07873265f, 0.03914043f, 0.06139766f, 0.12126706f, 0.06065651f, -0.03315551f, -0.01644915f, 
    0.00850469f, -0.31060860f, -0.03608331f, 0.15288819f, 0.00758060f, -0.23878303f, -0.19732681f, -0.00027193f, 
    0.05020630f, 0.05502187f, 0.08552344f, -0.03717518f, -0.06335805f, -0.08019583f, 0.09636992f, -0.01175091f, 
    0.01157418f, 0.07476540f, 0.04954682f, -0.06294735f, 0.04287729f, 0.03766415f, 0.05283206f, -0.08548272f, 
    -0.11546346f, 0.15987739f, 0.07250985f, -0.04736248f, -0.27188227f, -0.06371552f, -0.07979347f, -0.05784040f, 
    0.06235243f, -0.17288011f, 0.08577158f, 0.07510664f, 0.02248277f, 0.03454939f, 0.08765192f, -0.13300736f, 
    0.12020245f, -0.18349302f, 0.11345239f, -0.26211333f, -0.22096612f, -0.14696811f, 0.04418838f, -0.03979810f, 
    -0.15412982f, 0.03896250f, -0.03903756f, 0.00056916f, 0.01711966f, -0.03999976f, -0.00897340f, -0.01922644f, 
    -0.09928326f, 0.03450290f, -0.02972502f, 0.02652770f, 0.11548170f, 0.00643037f, -0.15051451f, -0.01296485f, 
    -0.16760802f, 0.14859878f, -0.08146613f, -0.13002867f, -0.15504602f, 0.04981733f, -0.00834361f, -0.19838497f, 
    0.05956731f, -0.03671845f, -0.00369761f, 0.02993138f, -0.05611724f, 0.08360703f, 0.07660723f, 0.14101270f, 
    0.02431996f, -0.04004699f, 0.04261088f, -0.02279103f, -0.02514706f, 0.16224416f, 0.09096561f, -0.11810865f, 
    0.03528381f, -0.00052637f, -0.06468660f, -0.07874136f, -0.12230466f, -0.18608162f, 0.15586680f, -0.03198145f, 
    -0.05199974f, -0.02205869f, -0.02743473f, -0.18131629f, 0.13339387f, -0.07546729f, 0.02064444f, -0.20529519f, 
    -0.21861111f, 0.03148579f, -0.10877521f, -0.33545807f, -0.34435540f, -0.05712950f, -0.01134493f, -0.10410132f, 
    0.01131466f, -0.14613976f, 0.10842792f, 0.01156664f, 0.04941599f, 0.00070442f, 0.00888023f, -0.04384014f, 
    0.01802976f, -0.20772365f, -0.15535150f, -0.00070668f, -0.01980679f, -0.21352969f, -0.24157035f, 0.05964582f, 
    0.09434168f, 0.05850084f, 0.00316114f, -0.04529219f, 0.02882479f, -0.08017414f, 0.11768185f, -0.02295682f, 
    0.07046820f, 0.04000737f, 0.12381959f, -0.00448620f, 0.15268457f, 0.02953039f, 0.04416581f, -0.03051835f, 
    -0.15048522f, 0.26692992f, 0.05794437f, -0.04041279f, -0.00170054f, -0.04652328f, -0.04218775f, 0.05545733f, 
    0.06905501f, 0.07820027f, 0.07121666f, 0.02432442f, -0.04608682f, -0.04657458f, 0.09470379f, -0.02515206f, 
    0.12717359f, -0.01626341f, 0.09232049f, 0.06457171f, -0.17823148f, 0.01877880f, -0.23920251f, -0.00441113f, 
    -0.14272173f, -0.06922510f, 0.03306366f, -0.02637521f, -0.03180512f, -0.00824402f, 0.10521567f, 0.06915837f, 
    0.09161981f, -0.09083247f, 0.04464562f, -0.04657499f, -0.02236801f, -0.13152310f, 0.11488593f, 0.02608040f, 
    0.60231113f, -0.59752333f, 0.27902353f, -0.01073703f, -0.01396363f, 0.02832325f, -0.06179424f, -0.01819592f, 
    0.06194669f, -0.05868477f, -0.01921514f, 0.08066092f, 0.08279575f, 0.00723396f, 0.03212535f, -0.06184832f, 
    0.05088950f, -0.20895824f, -0.04858564f, 0.05493236f, 0.00940152f, -0.34499446f, -0.00708605f, 0.06771117f, 
    0.31150433f, 0.01319373f, -0.08839142f, 0.02196464f, 0.04172999f, -0.00639332f, -0.03014816f, -0.07905640f, 
    0.04635451f, 0.08392370f, 0.02806777f, 0.00383909f, 0.13129584f, -0.10056835f, -0.08886324f, -0.00716653f, 
    -0.13241996f, 0.07923494f, 0.08854906f, 0.16307539f, -0.29108265f, 0.06798461f, -0.00541089f, 0.03571438f, 
    0.01538244f, -0.00551646f, -0.00149629f, -0.11219601f, 0.02001892f, 0.01756196f, 0.01899750f, 0.06874460f, 
    0.07124729f, 0.08845823f, -0.03418498f, 0.06610040f, 0.00095208f, -0.17322619f, 0.05408974f, 0.20350121f, 
    -0.01106312f, 0.10415640f, -0.01528235f, -0.12593593f, -0.02249495f, 0.09456015f, -0.09547582f, 0.07977258f, 
    -0.05465195f, -0.02799368f, 0.02218680f, -0.10486820f, -0.11422075f, -0.08153289f, -0.04635138f, 0.02437849f, 
    -0.15564744f, -0.20911795f, 0.16236791f, -0.09816289f, -0.05624133f, 0.09122097f, 0.14313596f, -0.20164147f, 
    -0.02012703f, -0.05287810f, -0.02234975f, -0.02784114f, -0.08283350f, -0.02809015f, -0.10341613f, -0.00317752f, 
    0.03497883f, -0.14294778f, -0.12099346f, -0.04764341f, -0.07955416f, -0.06122458f, -0.13349852f, -0.10219983f, 
    0.21513364f, -0.16426259f, 0.00242178f, 0.03513593f, 0.03425550f, -0.09980039f, -0.00001443f, 0.15559152f, 
    -0.13262212f, -0.06322976f, -0.06735662f, 0.00618934f, -0.08803771f, 0.13505176f, 0.08073262f, 0.06288617f, 
    0.36534125f, -0.13522761f, -0.17493351f, 0.04730643f, 0.20877920f, 0.19531509f, -0.10714269f, 0.02372440f, 
    -0.14986508f, 0.25503549f, -0.04036956f, -0.10161570f, 0.04100103f, 0.06963770f, -0.04011070f, -0.05430990f, 
    -0.11070813f, -0.06488709f, 0.11093873f, -0.12575826f, -0.36248994f, -0.09377886f, 0.13002530f, 0.27246618f, 
    0.24494290f, 0.14061330f, -0.06750956f, -0.16928667f, 0.04506275f, 0.17876247f, 0.03057122f, 0.07846275f, 
    -0.22545139f, 0.03176144f, -0.16435006f, 0.07146440f, -0.07680181f, 0.17544906f, -0.07840800f, 0.01423242f, 
    0.25517985f, -0.39117640f, 0.02243819f, 0.13677743f, 0.17973773f, -0.15884733f, -0.20943630f, 0.13533026f, 
    0.13015363f, -0.11324285f, 0.03586857f, -0.12634981f, -0.02631095f, -0.11119691f, 0.02220946f, -0.03768791f, 
    0.02127102f, -0.03093484f, 0.05765332f, 0.27752203f, -0.20243759f, -0.03183759f, 0.16086198f, -0.19584700f, 
    0.00601779f, -0.01869615f, -0.03723394f, 0.05606376f, 0.07407427f, -0.03363555f, -0.10267239f, 0.03351926f, 
    -0.04535431f, 0.10859369f, 0.17296308f, 0.13729361f, -0.04217101f, 0.02401788f, -0.05630241f, 0.10429870f, 
    -0.76362848f, 0.44607437f, 0.31215718f, 0.04340351f, 0.15621774f, 0.11774295f, -0.05283461f, 0.03596707f, 
    -0.03320904f, 0.01072886f, 0.01981878f, 0.05241945f, 0.09340546f, 0.01282056f, -0.01482216f, 0.10931616f, 
    0.02361933f, 0.16898257f, -0.11621271f, 0.17007491f, 0.02655544f, -0.13813998f, 0.16623630f, -0.16029176f, 
    -0.23609979f, -0.02952233f, 0.11496633f, -0.03548091f, -0.01046649f, -0.04493898f, -0.01118123f, -0.00137594f, 
    -0.05231813f, -0.10309195f, -0.11285426f, -0.06352837f, 0.01482490f, -0.13491814f, 0.01530198f, -0.03134468f, 
    -0.15106878f, -0.15588929f, 0.06308911f, 0.06062628f, 0.00143820f, 0.03422787f, 0.00095512f, 0.13288961f, 
    0.04205128f, -0.17460042f, 0.11460391f, 0.09543474f, -0.04884200f, -0.03855855f, 0.02072241f, 0.10715865f, 
    -0.07283811f, -0.06233249f, -0.21351330f, 0.05628221f, 0.26233748f, -0.11776427f, -0.13201979f, 0.13000713f, 
    0.11119476f, 0.14924382f, -0.11027246f, -0.07893477f, -0.03260644f, 0.19695082f, -0.09253605f, 0.05177344f, 
    0.11726552f, 0.04187004f, 0.10879412f, 0.02628582f, -0.12791683f, 0.06975507f, -0.05318696f, -0.10460482f, 
    0.13539684f, -0.13323882f, 0.02581597f, -0.00502495f, -0.16204172f, -0.05722530f, 0.10616743f, -0.07604623f, 
    0.03223535f, -0.08223006f, -0.05781509f, 0.03070893f, -0.05781358f, -0.08587418f, -0.06253149f, 0.02615584f, 
    -0.00159721f, -0.05947645f, -0.09795717f, 0.00291825f, -0.17201963f, -0.27727345f, 0.15015569f, -0.07176790f, 
    -0.00008377f, 0.06912779f, 0.06646466f, -0.07236797f, 0.01324999f, 0.14222349f, -0.03759184f, 0.02653880f, 
    0.06626257f, 0.07469625f, -0.01104655f, 0.12385955f, -0.08059369f, -0.13450755f, -0.01251440f, -0.11120280f, 
    0.12159355f, -0.11106117f, -0.08600624f, -0.08227909f, -0.01406861f, -0.02725076f, 0.05832813f, -0.00784112f, 
    -0.01950189f, 0.00134620f, 0.00019904f, 0.06533051f, 0.10688496f, 0.06358065f, 0.06400032f, -0.10329273f, 
    -0.12069774f, -0.02225875f, -0.02621338f, -0.05062075f, 0.30500364f, -0.00630814f, -0.21719414f, 0.18378875f, 
    -0.00905406f, -0.10967711f, 0.02160565f, 0.00697348f, 0.03361741f, 0.03306828f, -0.08524136f, 0.01901184f, 
    0.13833828f, -0.06877241f, 0.02492252f, 0.17837732f, 0.02859137f, 0.06558614f, 0.02597506f, 0.10153098f, 
    -0.06704239f, -0.23366556f, -0.19660440f, -0.07066888f, -0.25145966f, -0.17345043f, 0.02917959f, -0.00375808f, 
    0.05618254f, -0.10673806f, 0.04503154f, -0.03164890f, 0.12762055f, 0.15637384f, 0.10400283f, 0.21305043f, 
    0.09841818f, -0.16236170f, -0.13039275f, -0.07753269f, 0.12880631f, -0.28247589f, -0.05113786f, -0.15033145f, 
    0.10777798f, 0.00831019f, 0.14018039f, -0.00750329f, -0.08143341f, -0.11818165f, -0.04636415f, 0.09753518f, 
    -0.02076910f, 0.12945141f, -0.01023070f, -0.13739005f, -0.07974928f, 0.01480568f, -0.12848419f, -0.05783317f, 
    0.19556601f, 0.07766866f, 0.08500197f, -0.58176750f, -0.32670707f, -0.06617998f, -0.04910548f, 0.07004101f, 
    -0.00393832f, 0.10886635f, -0.10244813f, 0.00542795f, 0.20300050f, -0.25463298f, 0.02909018f, 0.13482186f, 
    0.13579485f, -0.13274975f, 0.10059831f, -0.02388279f, -0.15274905f, 0.01475280f, 0.15736638f, -0.24540593f, 
    -0.05533601f, 0.08617565f, 0.02725308f, -0.04200172f, -0.02677965f, -0.02910121f, -0.09838262f, -0.01947092f, 
    -0.07035271f, 0.06782372f, -0.02004523f, 0.00524283f, -0.13153191f, -0.08817590f, 0.03820920f, 0.02328630f, 
    -0.27591410f, 0.21545491f, 0.07393682f, 0.03579994f, -0.12541012f, 0.13211855f, 0.14019364f, -0.09093270f, 
    0.00822390f, -0.08973851f, -0.03663503f, -0.00322865f, -0.13098781f, -0.04152590f, 0.10244755f, 0.01054802f, 
    0.06292760f, 0.05383435f, -0.03545602f, -0.11703415f, -0.25730520f, -0.01134762f, 0.01931256f, -0.06920195f, 
    -0.41601902f, 0.06123494f, 0.05764920f, -0.00200899f, -0.01088070f, 0.02195603f, -0.11088157f, 0.12304803f, 
    -0.06748975f, -0.07108959f, -0.06070787f, -0.09451925f, -0.09277773f, 0.19152179f, 0.08813901f, -0.05386479f, 
    -0.18769537f, 0.22617079f, 0.31447804f, -0.24502322f, 0.07060568f, -0.06409478f, 0.02032899f, -0.04428212f, 
    0.11062308f, 0.07843103f, -0.04263142f, -0.09097750f, 0.02570012f, 0.05191714f, 0.07937117f, -0.00845128f, 
    -0.00356705f, 0.05808643f, -0.00577950f, 0.11362360f, -0.04338037f, -0.14709999f, -0.10931733f, 0.18513846f, 
    -0.10578944f, -0.07823484f, 0.03606923f, -0.03627579f, -0.03017205f, -0.09049889f, -0.11774832f, -0.07844792f, 
    0.04153086f, 0.09191807f, 0.06256760f, -0.02160299f, -0.06295137f, 0.01564329f, -0.06500596f, 0.17760701f, 
    -0.13552822f, -0.11564383f, 0.14103730f, -0.31938767f, -0.02807255f, -0.04100082f, 0.03543681f, 0.05723412f, 
    0.10798111f, -0.02982977f, -0.14481242f, -0.05470414f, 0.15611932f, -0.07818335f, -0.18752536f, -0.05341234f, 
    0.13556297f, -0.09858698f, 0.07499917f, -0.05999976f, 0.59045684f, -0.00040178f, -0.43762830f, 0.02362093f, 
    -0.33154330f, 0.05365811f, 0.03833262f, 0.17213917f, 0.13547850f, -0.11029354f, -0.00954887f, 0.00175621f, 
    0.02994171f, 0.20560208f, -0.06480089f, 0.18911858f, 0.13493235f, 0.11670288f, 0.01776027f, 0.11378595f, 
    -0.04589355f, 0.09539168f, 0.00063970f, -0.01628407f, -0.31062600f, -0.10193703f, -0.01289641f, -0.08619053f, 
    0.00262535f, -0.04694312f, -0.04364036f, -0.02640283f, -0.06982400f, 0.00682916f, 0.16897179f, 0.09079212f, 
    0.12451321f, 0.10835446f, 0.02024513f, 0.03259854f, -0.08595047f, -0.20804618f, 0.04269927f, -0.16296144f, 
    -0.32162449f, -0.12113870f, 0.10188961f, 0.03398225f, 0.03327639f, 0.10461352f, 0.07379551f, -0.10320983f, 
    -0.00357462f, -0.17093599f, -0.06900331f, -0.05150171f, -0.04764743f, 0.01785547f, -0.06673647f, 0.10107915f, 
    -0.54054308f, 0.06640256f, -0.22221564f, 0.23077732f, -0.28317088f, -0.00041823f, 0.05149126f, -0.12947573f, 
    -0.01048367f, 0.06887490f, -0.09971391f, -0.05568888f, -0.00397835f, 0.01080293f, 0.16698073f, 0.06606996f, 
    -0.11134454f, -0.01681493f, 0.03147666f, -0.05345663f, -0.67618406f, 0.13827729f, 0.15125081f, -0.07146902f, 
    0.06622586f, 0.12429213f, 0.14043747f, 0.06051036f, 0.00293739f, -0.02552802f, -0.03675500f, -0.06019366f, 
    -0.09608644f, 0.04537111f, 0.02721138f, 0.07025564f, 0.04037800f, 0.20986295f, -0.04533725f, 0.04767546f, 
    -0.41588044f, -0.04595023f, -0.23183778f, -0.06995330f, 0.09189720f, 0.01609363f, 0.07070432f, -0.19582857f, 
    -0.02345430f, 0.04008761f, 0.04412772f, 0.04055188f, 0.08278026f, -0.01607962f, 0.11047853f, 0.01460810f, 
    0.09168550f, 0.13450791f, -0.07138618f, 0.05929846f, -0.19902284f, -0.01629872f, -0.15566212f, 0.04910024f, 
    0.15198386f, -0.03321346f, -0.06789076f, -0.16270551f, 0.07154898f, -0.00425622f, 0.01907100f, 0.08551788f, 
    -0.05442659f, -0.13513359f, 0.09133589f, -0.03813133f, -0.05709958f, 0.04949148f, -0.08833615f, -0.04392039f, 
    -0.48407495f, -0.22171818f, -0.02632426f, 0.01009746f, 0.26445940f, 0.08739743f, 0.07341599f, 0.04115982f, 
    -0.06331433f, -0.00765013f, 0.07817773f, -0.02025847f, -0.02518128f, 0.10215457f, 0.03344063f, 0.03639719f, 
    0.09592944f, 0.15512966f, 0.11005979f, 0.02338967f, 0.32975581f, 0.07925113f, 0.04140322f, -0.01933863f, 
    0.02611579f, -0.19000416f, -0.01624964f, 0.06638405f, 0.07504293f, -0.10866743f, -0.02677184f, 0.02786120f, 
    -0.10509966f, -0.07001305f, 0.05438106f, -0.08015510f, 0.12509778f, 0.05780880f, 0.03532438f, 0.02755226f, 
    -0.76620340f, -0.44116056f, -0.40669420f, -0.32694027f, -0.38555554f, 0.11186817f, 0.06706350f, -0.14686579f, 
    -0.10383999f, 0.01968690f, -0.00066041f, -0.14774874f, -0.06391808f, -0.03622632f, -0.02802798f, -0.10604215f, 
    -0.12715738f, -0.06525330f, -0.01469015f, 0.01241732f, 0.39486700f, 0.28405723f, -0.01387421f, 0.05573365f, 
    0.01038259f, 0.10424006f, 0.05721918f, 0.12143985f, -0.02574896f, 0.08461750f, -0.05454295f, -0.06020307f, 
    0.00138615f, -0.04891924f, 0.01941964f, 0.06799250f, 0.06953467f, -0.03682204f, -0.02203033f, 0.07091434f, 
    0.28545988f, 0.22992724f, -0.10424066f, 0.07390287f, -0.07727227f, -0.15113935f, -0.04218480f, 0.08164903f, 
    0.09947951f, 0.02878987f, -0.03481963f, -0.03678275f, -0.00286073f, -0.08684103f, -0.11275816f, -0.01018503f, 
    -0.05478412f, 0.11391682f, -0.06108620f, -0.09550423f, 0.17012274f, 0.16375072f, -0.34156808f, 0.17371827f, 
    -0.14820211f, -0.04879534f, -0.00821145f, 0.12022690f, -0.01358841f, -0.04276353f, 0.07467892f, 0.03035674f, 
    0.15585402f, -0.17775634f, 0.08401081f, 0.03751826f, 0.09782694f, -0.05531226f, 0.08058886f, -0.09167273f, 
    0.15910594f, 0.05874294f, -0.18923499f, -0.03281964f, 0.00811281f, 0.05004020f, -0.03351073f, 0.14501573f, 
    0.09017726f, 0.05055878f, -0.03237307f, 0.03589821f, 0.02984781f, -0.05687577f, -0.08235542f, 0.10851782f, 
    0.20713574f, -0.06200579f, -0.07195589f, 0.08484919f, -0.05739254f, -0.15153675f, 0.07398076f, -0.10850845f, 
    -0.02791645f, -0.00017658f, 0.07271541f, -0.03410522f, -0.04995551f, -0.06795415f, 0.03477018f, -0.00505979f, 
    -0.11971674f, -0.09902671f, 0.06351519f, 0.06158185f, -0.04759975f, -0.02700056f, -0.03217144f, 0.03033556f, 
    -0.49713868f, -0.35215962f, -0.05903368f, 0.00853274f, 0.10270681f, 0.08091982f, 0.01557017f, 0.04678913f, 
    -0.02746728f, -0.09177576f, 0.17559649f, 0.00069958f, 0.04487870f, -0.11076082f, -0.01159166f, 0.05170597f, 
    0.01866167f, 0.03044575f, 0.17609817f, 0.02771732f, -0.61871588f, -0.37000948f, -0.10183289f, -0.11474802f, 
    -0.08268522f, 0.12249472f, 0.03023944f, -0.04749814f, -0.06785917f, 0.05154436f, 0.01132987f, -0.04943444f, 
    -0.00959021f, 0.11116480f, 0.01662200f, 0.09315764f, 0.02714242f, 0.07341507f, 0.03217491f, 0.04918201f, 
    -0.37147295f, -0.41998622f, -0.24267365f, -0.11084797f, -0.12327765f, 0.01575712f, 0.03475779f, -0.20429267f, 
    -0.03298385f, -0.13412029f, -0.00183827f, -0.18979247f, -0.15461510f, -0.11632299f, 0.13407303f, -0.04330677f, 
    0.05377375f, 0.07693731f, 0.10364407f, -0.08752405f, 0.28103560f, 0.26789826f, -0.08084322f, 0.06771130f, 
    -0.11874317f, -0.02649717f, -0.12477811f, 0.24242581f, -0.10318425f, 0.07937080f, -0.03885566f, -0.03199416f, 
    0.02998332f, -0.17670584f, -0.09183935f, 0.02754049f, -0.02494611f, -0.02617773f, -0.02547940f, -0.05954835f, 
    -0.41114116f, -0.06034797f, -0.05095232f, -0.00787992f, -0.15469265f, 0.09127072f, -0.03902990f, 0.00345887f, 
    -0.10023565f, 0.00036255f, -0.05291614f, -0.02749212f, -0.08003838f, 0.06061728f, -0.01475883f, -0.02666303f, 
    -0.02736550f, 0.01572403f, -0.01416119f, 0.00570413f, -0.37271288f, 0.25592890f, 0.00835494f, 0.07202613f, 
    0.00288904f, 0.07600456f, -0.02894868f, 0.03981584f, -0.01622406f, 0.03795417f, 0.01896265f, 0.06456064f, 
    0.10585878f, 0.03476288f, 0.01652557f, -0.01325455f, -0.01135677f, 0.05161313f, -0.00312279f, 0.04011107f, 
    0.02337806f, 0.06937595f, -0.16451363f, -0.03056189f, 0.00790205f, -0.04224432f, 0.04589402f, -0.00674841f, 
    0.06220993f, 0.06127289f, 0.05121628f, 0.00152636f, -0.01652259f, 0.01412091f, 0.09839521f, -0.05856118f, 
    0.04726104f, 0.16536132f, 0.06789865f, 0.02881413f, 0.21208505f, -0.08948332f, 0.02196681f, -0.07339182f, 
    0.12163440f, -0.09244391f, 0.00505124f, -0.12192879f, 0.01926173f, -0.15743752f, 0.00987994f, 0.04707095f, 
    0.00935761f, -0.01600835f, -0.15893613f, -0.09417623f, -0.06749882f, -0.06491111f, -0.27119392f, 0.09850829f, 
    -0.41169587f, -0.13839039f, -0.04867032f, -0.10878371f, -0.01022157f, 0.08106050f, 0.07549397f, -0.02941082f, 
    -0.09527687f, 0.04936796f, 0.03817002f, -0.01973209f, -0.06906198f, -0.13278702f, 0.17787527f, 0.01083916f, 
    0.01308507f, 0.20636894f, 0.01649949f, 0.17015682f, -0.29543585f, 0.04234713f, -0.33501303f, -0.14969715f, 
    -0.08652416f, 0.04775047f, 0.04561366f, -0.23346508f, 0.05391487f, -0.04426585f, 0.04450778f, -0.00306495f, 
    -0.01921665f, -0.09909878f, 0.12682603f, -0.15854134f, -0.02069594f, 0.15260494f, 0.04443079f, 0.06354216f, 
    -0.27922809f, -0.12145744f, -0.01965543f, -0.10976398f, -0.06935963f, 0.11756647f, -0.03762880f, -0.04865195f, 
    0.03918623f, 0.04482039f, -0.02317725f, -0.02373080f, 0.11221863f, 0.11015831f, -0.08040760f, 0.09586764f, 
    0.10721224f, -0.00448791f, -0.00102621f, 0.08064474f, -0.53149062f, -0.11271720f, -0.19131231f, -0.16640741f, 
    -0.02002743f, 0.10722435f, 0.05362549f, -0.07359693f, 0.00075348f, 0.11806981f, 0.06762671f, -0.00444895f, 
    0.04898941f, -0.03481040f, 0.05767186f, -0.07797520f, 0.02445790f, 0.15816709f, 0.12572473f, 0.10616374f, 
    0.02656763f, -0.05779763f, 0.08597565f, 0.05415813f, 0.07988321f, 0.13974506f, 0.15079761f, -0.01782322f, 
    0.15750843f, 0.01038940f, 0.11516283f, 0.02860466f, 0.00922046f, 0.02675770f, 0.06805123f, 0.04971860f, 
    0.04014946f, -0.24375184f, 0.06963246f, 0.04801557f, -0.57276332f, -0.20468412f, 0.20727953f, -0.00399505f, 
    -0.24068844f, 0.11597925f, 0.02592087f, 0.04657162f, 0.05858036f, 0.05302035f, 0.07676488f, 0.07471037f, 
    0.01902767f, 0.05157521f, 0.01693927f, 0.14218585f, 0.02275407f, -0.00904441f, -0.14538030f, -0.03405040f, 
    -0.30367333f, -0.30972064f, -0.02884194f, -0.06984827f, 0.04187316f, 0.10627437f, -0.03466786f, 0.08000455f, 
    0.02766204f, 0.02470512f, 0.16500542f, 0.08995073f, -0.13432220f, -0.00192853f, 0.05387514f, 0.06211608f, 
    -0.14922564f, -0.09225524f, 0.07216219f, 0.14072748f, 0.21493530f, -0.02446076f, 0.06340142f, -0.13879272f, 
    -0.00275250f, 0.07738157f, 0.04197915f, -0.00156663f, 0.05210425f, -0.00646544f, -0.01465084f, 0.11498614f, 
    -0.10396610f, -0.06795815f, -0.00661664f, -0.01343095f, -0.06363477f, -0.12818779f, -0.05567242f, 0.08401204f, 
    0.07625209f, -0.07419904f, -0.00016238f, -0.04387931f, 0.12033874f, 0.11690304f, -0.03321159f, 0.05437754f, 
    0.11409731f, -0.06504205f, -0.03968260f, 0.08461487f, -0.02107710f, 0.06352563f, -0.04834897f, 0.05163004f, 
    0.14184108f, -0.07438707f, 0.10736805f, 0.15600745f, -0.17281607f, -0.03585726f, 0.27929810f, 0.07527488f, 
    -0.02448847f, -0.07737334f, 0.03492175f, 0.03061493f, -0.10488425f, 0.09458176f, 0.07177678f, -0.00087770f, 
    0.14241074f, -0.23618233f, 0.04421211f, -0.03863904f, -0.08163816f, 0.01860776f, 0.01727939f, 0.05952364f, 
    -0.11383671f, -0.17747137f, 0.15152948f, 0.12006379f, -0.09838998f, 0.02690883f, 0.07133242f, 0.06755641f, 
    0.05277841f, -0.00485859f, 0.02297637f, 0.02826481f, -0.02213821f, 0.01880246f, -0.10395779f, -0.07999237f, 
    -0.09250081f, -0.42270494f, -0.09125949f, -0.13325664f, -0.60568440f, -0.07597179f, 0.09573224f, -0.14257321f, 
    -0.12506376f, 0.17441623f, -0.02388015f, -0.04462184f, -0.02354229f, -0.02722057f, 0.05145170f, 0.05918252f, 
    -0.04942273f, 0.24549595f, 0.03739378f, 0.14272647f, -0.05819855f, -0.08916148f, -0.13031273f, -0.09941264f, 
    0.28123501f, -0.04596661f, -0.17074290f, -0.06515817f, 0.03117079f, -0.19055647f, -0.02402981f, -0.05630605f, 
    0.07742471f, -0.00372979f, 0.00111988f, -0.12723713f, -0.11178005f, -0.20367597f, -0.07715309f, -0.12432717f, 
    0.02341128f, -0.03370676f, 0.03743633f, 0.03942138f, -0.13833335f, -0.18861960f, -0.01870966f, 0.06052051f, 
    0.10266631f, 0.06900696f, 0.12494960f, 0.12307806f, 0.04243608f, -0.01308575f, 0.10292871f, 0.03630237f, 
    0.06604562f, -0.04033124f, 0.12405836f, 0.05234143f, -0.00182852f, -0.13268618f, 0.12902655f, -0.04132220f, 
    -0.47331795f, 0.13577418f, -0.14611892f, 0.01616958f, -0.08367307f, 0.01180053f, -0.04789221f, -0.05736391f, 
    0.05982470f, 0.09703915f, -0.01288557f, -0.02327975f, 0.01353890f, -0.00368642f, -0.01502511f, 0.01008387f, 
    -0.03233249f, -0.14508669f, -0.00169971f, 0.03350252f, -0.57057631f, -0.05293779f, 0.07099018f, 0.00112853f, 
    -0.14933987f, -0.13747740f, -0.05841740f, 0.00825846f, 0.03636237f, -0.19711860f, -0.02772860f, 0.04214133f, 
    0.02917082f, 0.20819914f, 0.11036563f, -0.00079780f, 0.08935277f, -0.11426670f, -0.13715993f, -0.01381690f, 
    -0.32784507f, 0.36834329f, -0.09062361f, 0.11441576f, -0.21797608f, 0.13260284f, 0.14153281f, -0.02585159f, 
    0.07822733f, 0.05070361f, 0.01491381f, -0.01889170f, 0.00207334f, 0.09558784f, 0.12273035f, -0.07980917f, 
    0.08135784f, -0.01441943f, -0.06079721f, 0.03823398f, -0.24455334f, -0.08958855f, 0.04842801f, 0.05397214f, 
    -0.04387993f, 0.05959205f, 0.00131684f, 0.00487581f, 0.00404056f, 0.01054920f, -0.01329542f, -0.12388445f, 
    0.00375030f, -0.04828694f, -0.06947025f, -0.08806870f, 0.07459934f, -0.07021753f, -0.02826244f, -0.07070059f, 
    0.18801357f, -0.27907676f, -0.18167838f, -0.13409171f, -0.36067554f, -0.05582405f, 0.07084648f, 0.07543243f, 
    -0.01571370f, -0.02516355f, 0.21414703f, -0.03519424f, 0.04237190f, -0.08848688f, -0.06413106f, -0.02261016f, 
    0.04031807f, -0.07695992f, 0.00940879f, 0.08806803f, -0.07579384f, -0.12980261f, -0.14767827f, -0.00382686f, 
    0.13699217f, -0.11937658f, -0.04537626f, 0.04026761f, 0.09653666f, -0.11250154f, 0.09473845f, -0.14678879f, 
    -0.07696209f, 0.04723695f, -0.03691942f, 0.05832431f, -0.05449114f, -0.00928908f, 0.18413948f, 0.12404622f, 
    -0.15374838f, -0.01718330f, 0.08864492f, -0.09708687f, 0.04763798f, -0.14057784f, 0.07897776f, 0.06301805f, 
    0.05550344f, -0.17983429f, -0.15580516f, -0.08939233f, 0.07185301f, -0.00371366f, -0.08621539f, -0.14166699f, 
    -0.15222745f, -0.01563496f, -0.08279166f, 0.06186575f, 0.50352120f, -0.38617733f, -0.02526051f, 0.07517631f, 
    -0.25244418f, -0.05119210f, 0.20796852f, 0.04947917f, 0.00857778f, 0.05375979f, -0.15960707f, -0.13166682f, 
    -0.07278573f, 0.13769063f, -0.09816231f, -0.16214660f, -0.03351803f, 0.02756261f, -0.21883911f, -0.16649258f, 
    -0.06063697f, 0.15601157f, -0.19009081f, -0.03687260f, -0.14006814f, -0.24832678f, -0.10648332f, -0.05523634f, 
    -0.12450648f, -0.05690027f, 0.01816259f, -0.05336841f, 0.12714507f, -0.04900983f, 0.02527312f, 0.19505528f, 
    -0.05548401f, 0.02514498f, -0.08970355f, -0.10804470f, 0.21673194f, -0.04438220f, 0.04668671f, 0.03372422f, 
    0.02541583f, 0.06450498f, 0.00583726f, -0.00910145f, -0.04519557f, 0.03309763f, -0.06263113f, -0.02843209f, 
    0.15286209f, 0.01028642f, -0.03273651f, -0.07431013f, 0.02363451f, -0.04282207f, -0.05470860f, 0.02221706f, 
    0.05344358f, 0.10848694f, -0.02655680f, 0.16424210f, -0.04298138f, 0.13499562f, 0.06374592f, -0.00656822f, 
    -0.01124507f, -0.10790645f, -0.04449850f, -0.00128513f, 0.11206657f, 0.06392299f, -0.03549948f, -0.04236721f, 
    -0.01057972f, -0.08397316f, -0.16383091f, 0.03014239f, 0.41001183f, 0.03086359f, -0.13160206f, -0.08911865f, 
    -0.05049953f, 0.04494749f, -0.02474062f, -0.03265933f, 0.00985161f, 0.04303424f, 0.14663330f, 0.06342930f, 
    0.03741505f, -0.01009172f, 0.04941151f, 0.00052923f, -0.05353730f, -0.02347180f, -0.05702267f, 0.02466909f, 
    -0.39563769f, -0.35724375f, -0.10705122f, -0.13748834f, -0.49799037f, 0.13136715f, 0.08597244f, 0.02069316f, 
    0.03230469f, 0.06648150f, -0.05210300f, -0.07889207f, -0.02562697f, 0.04153561f, -0.00570902f, -0.17502280f, 
    -0.09628303f, -0.06809140f, -0.18228865f, -0.04083866f, 0.33366650f, -0.01235254f, 0.07128822f, -0.07641543f, 
    0.02962408f, -0.12323524f, 0.05359156f, 0.03765190f, 0.01244206f, -0.29003465f, 0.07178283f, -0.18234079f, 
    0.08473933f, 0.05401584f, -0.04270391f, -0.11513858f, -0.12060443f, -0.03201300f, -0.13268511f, 0.02209340f, 
    0.23109618f, -0.09201661f, -0.06102634f, -0.20921545f, -0.33363611f, 0.05310712f, 0.06926803f, 0.02301998f, 
    -0.00430056f, 0.07932846f, 0.02867444f, -0.03257457f, -0.01343176f, -0.02153347f, 0.03158604f, -0.07713238f, 
    0.03797109f, -0.04270292f, -0.02859318f, 0.06684008f, -0.05827377f, -0.06887489f, 0.10837519f, 0.13408969f, 
    0.29526302f, -0.14761946f, 0.25740212f, 0.06064782f, 0.03907668f, -0.03594066f, -0.02470841f, -0.07304437f, 
    0.09624352f, 0.13552001f, 0.05123574f, 0.13374203f, 0.10197239f, -0.03283362f, 0.10270074f, 0.07403523f, 
    -0.40721804f, -0.15696195f, 0.13627148f, -0.02950721f, 0.11061305f, 0.00204155f, 0.08989102f, -0.04627023f, 
    0.06502012f, 0.00418242f, -0.06196430f, 0.12697071f, 0.08268894f, 0.07824976f, -0.04499902f, -0.08030338f, 
    -0.06331953f, 0.02036155f, -0.27050388f, 0.05203626f, -0.49535763f, 0.36266798f, 0.03293992f, -0.06747952f, 
    -0.09925830f, -0.05740126f, -0.16449720f, -0.04467620f, -0.03425080f, -0.02258616f, 0.06230650f, 0.03482630f, 
    -0.01365003f, -0.04135768f, 0.01746529f, 0.06190803f, -0.02027748f, -0.09723064f, 0.03468388f, 0.10714379f, 
    -0.19184437f, -0.00799726f, 0.08962268f, -0.08730055f, 0.17426975f, 0.00225547f, 0.11729869f, -0.05048803f, 
    0.07750940f, -0.02242287f, -0.01467710f, -0.11075333f, -0.07389380f, -0.11787794f, -0.03041522f, -0.07934385f, 
    0.03204272f, -0.03091775f, -0.11499535f, 0.05874780f, -0.41877648f, -0.35896617f, -0.10200880f, -0.05067238f, 
    -0.10909943f, -0.07319181f, 0.04961869f, -0.03073702f, 0.11614744f, 0.07342605f, -0.15095378f, 0.04528585f, 
    0.03684359f, 0.05956522f, -0.01193760f, -0.15469275f, -0.04987027f, -0.08847481f, -0.16958177f, -0.07128809f, 
    0.43880954f, -0.26889163f, -0.15479553f, 0.08360671f, 0.01495794f, 0.08291414f, 0.05256368f, -0.01878606f, 
    0.05678267f, 0.05549970f, 0.12279680f, -0.01665296f, 0.02987611f, 0.03495007f, 0.16938850f, 0.04767653f, 
    -0.13527766f, -0.05063844f, 0.00246656f, 0.05947496f, 0.24808285f, -0.10366388f, -0.10392982f, 0.19496246f, 
    -0.04637560f, -0.05886945f, 0.18141066f, 0.00090640f, -0.00989661f, 0.03310115f, 0.08763652f, -0.06799537f, 
    0.00082846f, -0.01177715f, -0.01581940f, 0.01652286f, 0.00391998f, -0.07840397f, 0.00006907f, -0.02596716f, 
    0.06010002f, 0.08836149f, -0.10268577f, -0.09624768f, 0.23804642f, 0.10946104f, -0.18466952f, -0.06396779f, 
    0.01348139f, 0.05360977f, 0.10634589f, 0.05341872f, -0.10435390f, 0.00213453f, -0.03635787f, -0.07252628f, 
    0.00240132f, 0.07883343f, -0.03330826f, -0.02597606f, 0.43779528f, 0.24512160f, -0.24754447f, -0.17029984f, 
    0.09156054f, 0.01251660f, -0.06356657f, 0.01064204f, 0.00886118f, -0.02978171f, 0.08067071f, 0.01689271f, 
    -0.01427732f, -0.03497774f, -0.04684715f, 0.07437343f, -0.00318074f, 0.06284982f, 0.03612005f, 0.03141453f, 
    0.21462500f, -0.44101956f, 0.00284871f, 0.08860005f, 0.05648971f, 0.05371742f, -0.02650712f, -0.05851434f, 
    0.07046141f, 0.03161460f, -0.03424793f, 0.03258957f, 0.11037238f, 0.09108832f, -0.12455781f, 0.05947138f, 
    -0.01396527f, 0.03304082f, 0.02359562f, -0.09683231f, 0.11015417f, 0.13678327f, -0.10052743f, 0.00154947f, 
    -0.03097440f, 0.05365091f, 0.03293367f, -0.10916051f, -0.03759293f, -0.04892422f, -0.12909944f, -0.01700952f, 
    0.09387848f, 0.04314504f, -0.06732374f, 0.10928980f, -0.00213782f, -0.03129190f, 0.05562971f, -0.04692120f, 
    0.20224808f, 0.11641207f, 0.08260096f, 0.13696426f, 0.20645000f, 0.20850123f, 0.01180958f, 0.00696292f, 
    -0.01011973f, -0.01865285f, 0.04951486f, 0.20122178f, 0.05218097f, -0.09040561f, -0.02486801f, 0.02121207f, 
    -0.00081473f, 0.05297231f, -0.00962845f, -0.00910980f, -0.58478779f, -0.13157415f, -0.08254419f, -0.10887427f, 
    0.09476816f, -0.02379641f, -0.15158464f, -0.00450546f, 0.08149677f, 0.16017590f, -0.03755716f, 0.01350866f, 
    -0.09468316f, 0.10996599f, -0.04869923f, 0.09021927f, 0.13282548f, 0.04638034f, -0.05157757f, -0.03925414f, 
    -0.01341112f, 0.20144954f, -0.27985108f, -0.12827030f, 0.24469578f, -0.06601001f, -0.20906234f, 0.00909909f, 
    0.01823003f, -0.07107009f, 0.02423862f, 0.07287762f, -0.00789161f, -0.05954412f, 0.02988711f, 0.08774901f, 
    0.13066912f, 0.06518634f, 0.08398996f, 0.10557231f, 0.47954497f, 0.31725934f, -0.30537376f, -0.14810343f, 
    0.07806259f, 0.00476171f, 0.03992181f, -0.01542330f, 0.07345469f, -0.05661881f, 0.09961442f, 0.02323163f, 
    -0.05860262f, -0.04797301f, -0.01376693f, -0.01157226f, 0.00373805f, 0.01180374f, -0.01782908f, 0.04755065f, 
    -0.29700488f, -0.00798418f, -0.06690515f, 0.14061253f, -0.07844850f, 0.16490592f, -0.11854572f, 0.12669459f, 
    -0.08032839f, -0.01872413f, 0.08303938f, 0.05716430f, 0.05473573f, -0.08394073f, 0.00834520f, 0.07925609f, 
    0.04694428f, -0.09671867f, -0.07904640f, -0.14496347f, 0.17280950f, 0.15915111f, -0.14771709f, 0.12101420f, 
    0.08123595f, 0.19108053f, -0.04714874f, -0.08228482f, 0.03217046f, -0.07580646f, -0.01878290f, 0.03795975f, 
    0.00654022f, 0.06264954f, 0.00355428f, 0.00765635f, 0.06537342f, 0.02450843f, -0.16296057f, -0.03297042f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.04977306f, 0.07645313f, -0.05290340f, 0.01519687f, 0.02710831f, 0.03090971f, -0.01863968f, -0.05660861f, 
    -0.05296273f, -0.00518765f, 0.10412440f, 0.02731841f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
