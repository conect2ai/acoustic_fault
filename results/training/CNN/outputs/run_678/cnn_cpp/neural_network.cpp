#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.81569397f, 0.80253071f, 1.20501280f, 0.69432139f, 0.42789936f, -0.31653753f, -0.12443213f, -0.62974626f, 
    -0.54250252f, 0.17415977f, 0.03365977f, 0.31201386f, 0.02312911f, 0.29158726f, 0.25828964f, 0.09531774f, 
    -0.05030223f, 0.12430154f, 0.03889480f, -0.03036457f, 0.08185346f, 0.24215345f, 0.16115168f, -0.08195756f, 
    0.16885594f, 0.10788784f, -0.40573844f, -0.64533645f, -0.28440824f, 0.09712401f, 0.30468848f, 0.23943819f, 
    0.43775031f, 0.55430841f, 0.57841307f, -0.15390195f, -0.24173476f, -0.24993424f, -0.42112133f, -0.29513317f, 
    -0.07776587f, -0.03497135f, -0.19163491f, 0.43788019f, -0.34629795f, -0.15653843f, -0.25045869f, -0.24270757f, 
    0.01014593f, 0.11431845f, 0.40662688f, -0.06164233f, 0.04632713f, 0.68230653f, 0.29256693f, -0.31595013f, 
    0.19977422f, 0.34808612f, 0.22702964f, -0.47385257f, -0.33404642f, -0.38252339f, -0.49550197f, -0.12461296f, 
    -0.27861238f, 0.07983687f, 0.01456716f, -0.12650260f, -0.01324183f, -0.17867075f, 0.33362255f, 0.17667985f, 
    0.18632731f, 0.25624922f, 0.33936566f, 0.44043565f, 0.45981678f, -0.67167282f, -0.71681058f, -0.10815650f, 
    0.37581930f, -0.43405056f, -0.36150828f, 0.01039029f, -0.41068920f, -0.33368957f, 0.18779716f, 0.33159477f, 
    0.30824316f, 0.10627633f, -0.19330773f, 0.36258277f, 0.01292205f, -0.22760916f, -0.15861240f, 0.00500628f, 
    0.19416107f, 0.05681571f, 0.04254042f, 0.03664043f, 1.33182609f, 0.11685051f, -0.77798116f, 0.66591233f, 
    -0.29881027f, -0.36565712f, 0.46229002f, 0.05224802f, 0.11023545f, 0.31185758f, -0.17702663f, -0.11700271f, 
    0.15620261f, -0.08812919f, 0.04553550f, 0.05842805f, -0.21210380f, -0.14158356f, -0.03893578f, 0.25731009f, 
    0.00095964f, -0.02989792f, 0.12465214f, 0.08496670f, 0.02878368f, -0.47720775f, -0.10286726f, -0.61311096f, 
    -0.60699439f, 0.21021135f, -0.10814875f, 0.85034996f, 0.55427063f, -0.09396283f, 0.26129222f, -0.04782038f, 
    -0.04320819f, 0.10776137f, -0.31503654f, -0.11122870f, -0.01482927f, 0.07681155f, 0.22840048f, 0.21470186f, 
    0.00963470f, 0.00254885f, -0.00819870f, -0.21523777f, -0.33796754f, -0.19315064f, -0.68928808f, -0.11531506f, 
    -0.36629066f, 0.30305630f, 0.16995436f, -0.55084968f, 0.66042542f, 0.57536095f, -0.39072359f, 0.12588415f, 
    -0.30091158f, 0.14321698f, 0.23429567f, -0.34347200f, 0.06814937f, -0.03364155f, -0.17043613f, -0.19433066f, 
    -0.14804104f, -0.38449603f, 0.02840339f, -0.04067026f, -0.05721695f, 0.09922009f, -0.01903636f, -0.81921870f, 
    1.17931914f, 0.23739284f, -0.18134607f, 0.36040172f, -0.21173066f, 0.16944547f, 0.36365408f, -0.12224586f, 
    -0.35750538f, 0.11057872f, -0.25818598f, -0.28576645f, -0.01797591f, 0.26914665f, -0.19199958f, -0.30911189f, 
    -0.31823394f, -0.12022244f, 0.13817218f, -0.09675982f, 0.01806022f, 0.12179530f, 0.18039127f, 0.21074189f, 
    0.98373127f, 0.68654662f, -0.29859543f, -0.64686817f, -0.75550783f, 0.34005752f, 0.18078059f, -0.02174598f, 
    -0.01781344f, 0.23599318f, 0.61255842f, -0.05367394f, 0.18501365f, 0.09008253f, 0.10945489f, 0.11781131f, 
    0.07607670f, 0.13831301f, 0.28798619f, 0.36017701f, 0.32259637f, -0.06334646f, -0.05421660f, -0.09842017f, 
    0.20711367f, -0.42951652f, -0.59761149f, -0.71343189f, -0.58507127f, -0.28076458f, -0.13562571f, -0.64645642f, 
    -0.15330729f, -0.11338300f, 0.06206511f, -0.40161085f, -0.04261597f, -0.10153814f, 0.13969044f, -0.03564307f, 
    -0.06041104f, -0.14004457f, -0.12382764f, 0.26398706f, 0.11739150f, -0.09740266f, 0.06510566f, -0.21510866f, 
    -0.04909658f, 0.18974523f, -0.11728036f, -0.00267901f, -0.15306497f, 0.47324514f, -0.21124467f, -0.10144994f, 
    -0.83640331f, -0.35124576f, -0.25558776f, -0.16505113f, -0.14084303f, 0.39384559f, 0.11774929f, 0.01161043f, 
    -0.02356258f, 0.22964661f, 0.18303917f, 0.35537332f, 0.09673647f, 0.41981205f, -0.02074690f, -0.05717560f, 
    0.57567954f, 0.07156590f, -0.45567065f, 0.48066884f, 0.54124212f, 0.39441994f, 0.48364654f, 0.57881266f, 
    0.48482990f, 0.32063115f, 0.40282586f, 0.45453778f, -0.05156292f, -0.14436564f, 0.27844769f, -0.02864384f, 
    0.37919381f, -0.37737933f, 0.22871426f, -0.13828120f, 0.27702436f, -0.12480448f, 0.04283858f, -0.04850992f, 
    0.21175274f, -0.11096340f, -0.21341476f, 0.18663813f, -0.46611309f, -0.70781684f, 0.30300179f, 0.37693483f, 
    -0.51995641f, -0.22856858f, 0.34332088f, 0.09994426f, 0.27108046f, -0.03355581f, 0.19388413f, 0.07289293f, 
    -0.16665763f, 0.00999316f, -0.39532587f, 0.22252437f, 0.18603562f, 0.01542393f, 0.34774792f, -0.20387994f, 
    0.01829035f, -0.00034040f, 0.06395619f, -0.20956637f, 0.22915091f, 0.24524775f, -0.00013539f, -0.46907890f, 
    -0.51896608f, 0.47370216f, -0.31854832f, -0.64698094f, -0.37739664f, 0.22668849f, -0.36667702f, -0.28204551f, 
    -0.43000978f, 0.06917281f, 0.28890580f, -0.07299621f, -0.06658839f, -0.07911871f, -0.18370584f, 0.00526539f, 
    -0.03722179f, 0.17126355f, 0.25178668f, 0.09914303f, -0.21027359f, -0.42324603f, -0.12546097f, 0.36142242f, 
    -0.02475226f, -0.23857042f, 0.10192282f, -0.90491825f, -0.61464459f, -0.24408536f, -0.74247289f, -0.29917461f, 
    0.29239437f, 0.48669326f, -0.23771307f, -0.22497329f, -0.30433258f, -0.46158099f, -0.13468052f, 0.01898763f, 
    -0.44899407f, 0.05050958f, 0.12286784f, -0.00006607f, 0.00447439f, 0.22163369f, -0.10367265f, -1.07427895f, 
    -0.06948861f, -0.27427924f, -0.28589934f, -0.35865742f, 0.67910564f, 0.89600843f, -0.20792206f, 0.32370612f, 
    0.40070343f, 0.02575633f, -0.00662878f, 0.25168544f, 0.12592421f, 0.09248797f, 0.10883632f, -0.03405776f, 
    0.05458047f, -0.04158960f, -0.13423976f, 0.09430210f, -0.08268656f, 0.13429672f, 0.04818896f, 0.12874557f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.08158363f, -0.06826555f, 0.08817550f, 0.13381530f, 0.19319008f, 0.16468084f, 0.05988796f, 0.11553198f, 
    0.25038853f, 0.11632406f, 0.15962423f, -0.06451423f, 0.13807422f, 0.29111588f, 0.07836966f, -0.01881709f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.23006842f, -0.26412588f, -0.29332206f, 0.29098848f, -0.09291366f, 0.13037972f, -0.07165376f, -0.15545596f, 
    0.03542525f, -0.09432719f, 0.06018580f, 0.00913416f, 0.10666674f, -0.01534198f, 0.14482068f, 0.16212443f, 
    -0.02958899f, -0.07362355f, 0.17229234f, 0.19362365f, -0.09363501f, -0.10822795f, -0.08561917f, -0.06022950f, 
    -0.16756020f, 0.06880512f, -0.14256983f, 0.14624001f, -0.19272119f, 0.05037808f, -0.20915478f, 0.07632950f, 
    -0.00142492f, 0.12669642f, 0.15370092f, 0.03142415f, -0.25124761f, 0.09902600f, -0.09085928f, -0.41269851f, 
    0.17539155f, -0.16542993f, 0.04147101f, -0.10621431f, -0.06680465f, -0.06154469f, -0.00672743f, -0.07932942f, 
    0.20663424f, -0.22537540f, -0.06459098f, 0.04420779f, 0.13646550f, -0.08562748f, 0.03124161f, 0.22389093f, 
    0.14656305f, 0.09923743f, -0.13014974f, 0.17720261f, 0.23686197f, 0.19558997f, 0.18957461f, 0.07053382f, 
    0.11161837f, -0.11682910f, 0.09136260f, 0.16338982f, -0.00951230f, 0.00419875f, 0.08273441f, -0.01958110f, 
    0.35138044f, 0.08081706f, 0.05511156f, 0.09362841f, 0.08477020f, 0.16392323f, -0.12970643f, -0.07628329f, 
    0.02691917f, 0.18388629f, -0.08509537f, -0.08907883f, -0.11291587f, 0.31097803f, -0.10797584f, -0.17427835f, 
    0.13210040f, 0.23861115f, 0.05175468f, 0.08212560f, 0.07474513f, -0.07479811f, 0.02594297f, 0.05637695f, 
    -0.01472402f, -0.12919860f, 0.19553554f, -0.24952094f, -0.11558204f, -0.11371975f, 0.05375798f, 0.03636007f, 
    -0.04548434f, 0.09443369f, -0.02596446f, 0.13633405f, 0.11074805f, 0.05263661f, -0.03610910f, -0.05678125f, 
    -0.22677834f, -0.17323060f, -0.15737548f, -0.06342909f, -0.10202181f, 0.03909664f, -0.04195793f, -0.08521637f, 
    -0.05295904f, 0.10812571f, -0.20049490f, -0.03532740f, 0.01320628f, -0.05994390f, 0.04744453f, -0.07059003f, 
    -0.04565927f, 0.03546239f, 0.06171494f, -0.07787757f, 0.27590793f, -0.34896252f, -0.04307810f, 0.04681931f, 
    0.11625291f, -0.10181823f, -0.07211217f, -0.19509834f, 0.04602341f, 0.09628483f, 0.01160845f, -0.15492582f, 
    0.00571831f, -0.04954537f, 0.02334760f, -0.04691544f, -0.22060949f, -0.01677890f, 0.02709428f, 0.13741443f, 
    0.10159547f, 0.01958560f, -0.00908259f, -0.01008357f, -0.20888878f, 0.00434355f, 0.02631644f, -0.02529943f, 
    -0.00410524f, -0.06075344f, 0.08038422f, 0.13359858f, -0.01177536f, 0.01427151f, -0.17540082f, -0.08379823f, 
    0.11773122f, 0.44219971f, 0.04785588f, -0.30869189f, 0.04842782f, 0.04339636f, 0.12694882f, 0.00141728f, 
    -0.04618542f, 0.20747536f, 0.11152392f, -0.12673889f, 0.56616074f, 0.29533383f, 0.10327595f, 0.06552806f, 
    -0.02474822f, -0.02993854f, -0.14204358f, 0.14011244f, -0.03221213f, 0.00009602f, -0.01455442f, -0.05421248f, 
    0.23176935f, -0.21165536f, -0.20088509f, -0.06946315f, 0.09861130f, 0.10071689f, 0.02757130f, -0.09764576f, 
    0.08437297f, 0.04641327f, 0.07496411f, 0.22620972f, 0.15435138f, -0.17770478f, 0.05733010f, 0.16045341f, 
    -0.05055258f, -0.03961388f, -0.06636366f, 0.13240154f, 0.14987881f, -0.18899958f, -0.23294888f, 0.00127858f, 
    -0.37556192f, -0.00399627f, -0.18754120f, 0.11682656f, -0.02521699f, 0.15247181f, -0.11024965f, 0.11044840f, 
    0.16621910f, 0.00523551f, -0.27192488f, 0.12988529f, -0.28907922f, -0.01493843f, 0.13925424f, -0.13790195f, 
    0.08098362f, -0.13018560f, -0.02650872f, -0.08104090f, 0.09270129f, -0.12156361f, 0.10433307f, -0.06119632f, 
    0.15052153f, -0.22337388f, -0.00432331f, -0.11953308f, 0.13416873f, -0.21815374f, 0.06003429f, -0.02162245f, 
    0.16925736f, 0.15194763f, -0.10080981f, 0.17799327f, 0.52159405f, 0.15524518f, -0.03586364f, -0.05573810f, 
    0.00446385f, -0.10271257f, -0.13754320f, -0.03119493f, 0.00938609f, -0.04720053f, 0.18606636f, -0.11161272f, 
    0.11180308f, 0.15672231f, -0.16866930f, -0.06275675f, -0.02174072f, 0.20099540f, 0.09051999f, 0.06242689f, 
    0.12574574f, -0.13202311f, -0.06167285f, -0.07716583f, -0.28468227f, 0.15525217f, -0.02050986f, 0.08405041f, 
    -0.00543759f, 0.10173758f, -0.07180120f, 0.17138308f, -0.02261763f, 0.13577728f, -0.08262549f, 0.17241228f, 
    0.30046979f, 0.08702400f, 0.24066369f, -0.10320687f, 0.12126540f, -0.20141801f, -0.05859745f, -0.03266866f, 
    0.05110052f, 0.16857155f, 0.10518383f, 0.25954878f, -0.25046468f, -0.00037565f, 0.09812652f, 0.18238208f, 
    0.11632831f, 0.22192131f, -0.27068231f, -0.05617815f, 0.03805476f, 0.04146927f, 0.12601091f, -0.07666514f, 
    -0.22526015f, -0.02650048f, -0.13997610f, -0.15990271f, 0.06014722f, -0.19228581f, 0.20284133f, -0.23245491f, 
    0.02503669f, 0.24760813f, 0.18651606f, 0.23183003f, 0.35539520f, -0.14559168f, 0.02733697f, -0.17257701f, 
    0.20089248f, 0.00022461f, -0.24500205f, -0.14410584f, 0.07868241f, -0.16322953f, 0.17752971f, 0.19138037f, 
    -0.22041367f, -0.14071862f, -0.21962544f, 0.09142084f, -0.06629677f, -0.27973095f, -0.13326192f, 0.05408543f, 
    0.14453936f, -0.15283939f, 0.00414495f, 0.19757849f, -0.12523080f, -0.18761744f, 0.01636076f, 0.04272295f, 
    0.07269216f, -0.14344679f, 0.11021976f, 0.05742669f, 0.15734448f, 0.15129840f, 0.01437266f, 0.03057840f, 
    0.06743599f, 0.23718491f, -0.25215441f, 0.05179749f, -0.02932229f, -0.06281984f, 0.07764187f, 0.16560842f, 
    0.04295186f, 0.12164193f, 0.01195491f, 0.13764817f, -0.33596572f, -0.34759435f, -0.15560050f, -0.03839358f, 
    -0.10635114f, -0.06038356f, 0.10635060f, -0.11913266f, 0.16422509f, -0.02883703f, 0.16148999f, -0.12902193f, 
    -0.19979833f, 0.18445233f, 0.00814334f, -0.35496968f, 0.05901900f, -0.02511864f, 0.01570773f, 0.08822954f, 
    -0.09802345f, 0.19171996f, -0.05990085f, -0.05240675f, 0.03971526f, 0.08769108f, -0.04690548f, -0.38320366f, 
    0.06062422f, 0.12540978f, 0.09335885f, -0.23097253f, 0.17891470f, 0.03228350f, -0.06736250f, 0.00395535f, 
    -0.07364225f, -0.26204801f, 0.28547224f, -0.20497273f, 0.14707236f, 0.01288341f, -0.01581390f, -0.10904043f, 
    -0.15020241f, -0.03898766f, 0.08756215f, 0.04697176f, 0.22217977f, -0.01058930f, 0.19959298f, 0.36464176f, 
    -0.10420571f, 0.13839592f, -0.05278143f, 0.01829558f, 0.12216223f, 0.15999760f, -0.08424063f, 0.10029421f, 
    -0.63325870f, -0.23174202f, 0.13093327f, 0.09347712f, -0.00007660f, 0.14055084f, 0.00704756f, -0.00551451f, 
    0.09441726f, 0.04284728f, 0.09974927f, -0.03368909f, -0.37533876f, -0.06656246f, -0.16882585f, -0.11056795f, 
    0.00184573f, 0.09017332f, -0.01359856f, 0.10212892f, -0.07457862f, 0.10993497f, -0.20726794f, 0.10058345f, 
    -0.28946468f, -0.16564909f, 0.14534158f, 0.16074739f, 0.03344687f, -0.00336850f, -0.03493725f, 0.07697143f, 
    0.15202869f, 0.08492287f, 0.22393374f, 0.05200620f, -0.05456244f, -0.14077333f, 0.08027347f, -0.10576618f, 
    -0.05569636f, -0.06781000f, -0.08000701f, 0.14520058f, 0.21479969f, 0.05733620f, 0.04839036f, -0.12567620f, 
    -0.31146270f, -0.08792998f, -0.09495809f, 0.49583453f, 0.13509242f, 0.13159662f, 0.08263791f, 0.12488034f, 
    0.20145185f, -0.15631478f, 0.11628916f, -0.07120623f, 0.11492132f, -0.08493270f, -0.12727220f, -0.41552761f, 
    -0.24693646f, -0.10871431f, 0.21428333f, 0.01458688f, 0.10713067f, -0.01023712f, -0.09978714f, 0.01419111f, 
    0.53174442f, 0.17076474f, 0.21049030f, 0.20554186f, 0.21954663f, 0.02374582f, 0.00243300f, 0.19560976f, 
    -0.06875687f, 0.11858661f, -0.00346260f, 0.06828061f, -0.61636990f, 0.02000977f, 0.01359210f, -0.43090680f, 
    -0.11476155f, 0.10403192f, 0.03476673f, 0.05849939f, -0.17774557f, -0.00444509f, -0.08436408f, 0.05492416f, 
    0.29107100f, 0.39090768f, 0.14376119f, -0.04801214f, 0.03511069f, 0.01513841f, -0.12187075f, 0.00352504f, 
    -0.07630074f, 0.12443828f, 0.13655892f, -0.12711754f, 0.25724626f, 0.17575620f, 0.36382285f, 0.15524705f, 
    0.09401111f, 0.06042584f, 0.02315461f, 0.12228796f, 0.10251968f, 0.11387175f, 0.30886361f, -0.08419849f, 
    0.30654934f, 0.21117450f, 0.03220982f, 0.27552062f, 0.05487282f, 0.18453553f, 0.00281959f, 0.19702940f, 
    -0.02542100f, -0.10986955f, -0.02352014f, 0.03467427f, 0.22831297f, 0.11235346f, -0.13367814f, -0.02662323f, 
    -0.14549589f, -0.00157125f, 0.04832713f, 0.02907172f, -0.08053464f, 0.02681614f, -0.07324304f, -0.05926218f, 
    -0.03389788f, 0.04725425f, 0.02657348f, 0.01315236f, 0.01519207f, 0.03015492f, 0.05456940f, -0.06655543f, 
    -0.03235576f, -0.04630461f, -0.05129972f, 0.04959210f, -0.00843722f, 0.00625364f, -0.05714355f, -0.00472843f, 
    -0.07280059f, 0.02976326f, -0.07457356f, 0.03687337f, 0.02921135f, -0.07147820f, -0.05780220f, -0.07827623f, 
    -0.07900746f, -0.00230153f, 0.04103341f, -0.07721178f, -0.00091096f, -0.04414568f, 0.04784285f, -0.05361034f, 
    0.02545875f, -0.05204440f, 0.03326318f, -0.03166451f, 0.05438497f, -0.06768214f, 0.00634609f, 0.04226814f, 
    0.04770811f, -0.03087028f, -0.00293084f, -0.03753471f, 0.02027650f, -0.03919384f, 0.05727482f, -0.07936972f, 
    0.05200603f, 0.00896791f, -0.07386227f, 0.02274390f, 0.01071878f, -0.03107705f, -0.02907322f, -0.00207906f, 
    -0.05974436f, 0.00517540f, -0.06318061f, -0.01287259f, -0.05684032f, -0.07638529f, 0.03041843f, -0.04763833f, 
    0.02439400f, 0.04714783f, 0.02678461f, 0.00549220f, -0.04447205f, -0.06222465f, -0.05340306f, -0.03073351f, 
    0.04105425f, -0.07678588f, 0.01403305f, 0.00151422f, -0.01130847f, 0.00974402f, -0.06115175f, 0.04111927f, 
    -0.01258282f, -0.02767013f, -0.03654097f, -0.04760038f, -0.03539863f, -0.02363978f, -0.04167014f, 0.01443025f, 
    0.04894413f, -0.06297620f, -0.07599683f, 0.00279970f, -0.04987044f, 0.00517679f, 0.03854496f, 0.00860188f, 
    -0.02408878f, 0.03944668f, -0.01433796f, -0.04686879f, 0.06126234f, 0.01218206f, 0.03232589f, 0.05314388f, 
    -0.02012570f, 0.00963600f, -0.03441456f, -0.01774576f, -0.05017989f, 0.05020002f, -0.05585415f, 0.02718312f, 
    0.02855794f, -0.05005063f, -0.03177487f, 0.01263507f, -0.06729671f, 0.01049693f, -0.05403508f, -0.06984970f, 
    -0.03859732f, -0.02992254f, -0.07132578f, -0.01206720f, -0.03142665f, 0.04843457f, 0.01561977f, 0.00997856f, 
    0.03851897f, -0.06856817f, -0.05110472f, 0.04120050f, -0.03172961f, 0.04972844f, 0.00709092f, 0.05627314f, 
    -0.03813173f, -0.07240812f, -0.05550578f, -0.06397010f, 0.04041844f, -0.04473336f, 0.00886743f, 0.01162846f, 
    0.01320927f, 0.04448331f, -0.07303055f, -0.04712404f, 0.04169249f, 0.04565605f, 0.00273396f, -0.06708238f, 
    0.05170910f, 0.05888444f, -0.01388368f, -0.02708819f, -0.06465060f, 0.06148154f, -0.05480127f, -0.03190821f, 
    0.06027124f, -0.03296302f, 0.00763614f, -0.01857950f, -0.02608296f, -0.02001224f, 0.05395847f, 0.00776916f, 
    -0.03419919f, -0.02486466f, -0.02926685f, -0.05305999f, -0.02862494f, -0.01205935f, 0.03735197f, -0.07085426f, 
    0.01996024f, -0.00257142f, -0.06864698f, -0.02496728f, 0.03553751f, -0.01078401f, -0.00816078f, -0.04134516f, 
    0.04974818f, 0.03759610f, -0.01508444f, -0.05936627f, 0.04256406f, 0.01640492f, 0.02351714f, 0.03534427f, 
    0.05087454f, -0.01252156f, -0.04720287f, 0.02248631f, -0.02763876f, 0.05495585f, 0.04754001f, 0.02401210f, 
    0.01869586f, -0.05053324f, -0.01465823f, -0.07730292f, 0.04809887f, 0.02668928f, 0.02142076f, -0.04881348f, 
    -0.01832508f, 0.00106778f, 0.04990468f, 0.01808449f, -0.04752763f, 0.02718959f, 0.05902286f, -0.07712473f, 
    -0.03061767f, -0.05721303f, -0.04572062f, -0.07558676f, 0.01677429f, 0.03534801f, 0.01114329f, 0.02431374f, 
    0.02181120f, 0.01584396f, 0.04898856f, -0.03243727f, 0.03221042f, -0.06054707f, -0.01968620f, -0.02820263f, 
    -0.05013451f, -0.02731420f, -0.01011513f, -0.05506285f, -0.04112732f, 0.05605930f, -0.03188631f, 0.04952763f, 
    0.00433999f, -0.04831471f, -0.04996379f, 0.03329568f, -0.03519482f, 0.06024360f, 0.01190954f, -0.04479632f, 
    0.06028241f, 0.04332027f, -0.08423541f, 0.05741284f, -0.08621926f, -0.07459883f, -0.07485311f, -0.04713385f, 
    -0.06219347f, 0.02417693f, 0.00197591f, 0.02130159f, 0.00109456f, -0.04238603f, 0.03704219f, -0.05167319f, 
    0.05718653f, 0.03686360f, -0.00821455f, 0.01034897f, 0.00338380f, 0.05728604f, -0.04799642f, 0.01647991f, 
    0.02221061f, -0.06859561f, -0.02249389f, 0.00618564f, 0.03970741f, 0.01824056f, -0.02994322f, 0.00812586f, 
    0.02400867f, -0.02266365f, 0.00497846f, -0.05857883f, -0.02240705f, 0.03913845f, 0.02363706f, -0.01528069f, 
    0.05572692f, 0.01109449f, 0.01055571f, 0.02844570f, 0.06104592f, -0.06232011f, -0.04532794f, 0.01851380f, 
    -0.03277524f, 0.03609844f, 0.03482896f, 0.03503076f, -0.00918937f, 0.05454820f, 0.02531308f, 0.05517088f, 
    -0.00676752f, 0.02215275f, 0.06048607f, 0.01982266f, -0.07460339f, -0.06268361f, -0.07786018f, -0.01074343f, 
    0.04115042f, 0.01687813f, 0.00459766f, 0.00914609f, -0.06157924f, -0.07035949f, 0.02306995f, 0.00752018f, 
    0.01323604f, -0.02408298f, -0.02171621f, -0.02634026f, 0.01088173f, 0.01339247f, -0.05949315f, -0.06538963f, 
    -0.03498593f, -0.02070442f, 0.04426000f, -0.04989043f, -0.03861145f, 0.03147740f, -0.06584264f, -0.03456684f, 
    -0.06077059f, 0.01913412f, 0.05772444f, -0.06053307f, 0.02869434f, 0.01636866f, -0.03340604f, -0.06325851f, 
    0.00734258f, -0.01873235f, -0.04036465f, 0.02136810f, 0.00255090f, -0.02576005f, -0.02937691f, -0.04344467f, 
    -0.03063995f, 0.00437067f, -0.03568194f, -0.04307924f, -0.01119246f, -0.01471068f, 0.00878279f, -0.05845848f, 
    0.01102528f, -0.07869329f, -0.06223119f, 0.00414671f, 0.01501018f, -0.04829777f, -0.05239249f, 0.00844757f, 
    0.03598792f, -0.07036287f, -0.01640138f, -0.07043679f, 0.01176218f, -0.08020061f, -0.02757470f, -0.03481532f, 
    0.05719386f, -0.02969451f, -0.07232927f, 0.02877617f, 0.00959946f, 0.05047598f, 0.00183404f, -0.07402190f, 
    0.24783996f, 0.24773584f, 0.29092231f, -0.07123349f, 0.01612785f, -0.01239992f, -0.00467722f, 0.14391711f, 
    -0.05565981f, 0.09472955f, 0.03636174f, 0.28787908f, 0.24813125f, -0.04494330f, 0.04247241f, -0.13107835f, 
    0.24463661f, 0.09510778f, -0.23841619f, -0.19109692f, 0.18759446f, -0.14587454f, -0.04017759f, 0.06749398f, 
    -0.19996352f, 0.05440102f, -0.03311047f, 0.25117862f, -0.04866122f, 0.16079648f, -0.02230762f, 0.03499411f, 
    0.06562886f, -0.02293894f, -0.22130330f, -0.13628507f, -0.09066300f, -0.12977834f, 0.22228140f, -0.16141035f, 
    -0.09868690f, -0.08771843f, 0.07882451f, -0.01575835f, 0.08521149f, -0.12873036f, 0.12791373f, 0.04412752f, 
    0.06374715f, -0.33040005f, 0.10366805f, 0.09785619f, -0.05187882f, 0.07650537f, -0.09431707f, -0.03352527f, 
    0.04230472f, 0.00923435f, 0.03163739f, 0.04338815f, 0.11415651f, 0.02976274f, -0.08992869f, -0.32306400f, 
    0.07844706f, -0.01171846f, -0.15732254f, 0.14426000f, 0.11065117f, 0.00910127f, 0.10794368f, -0.02187942f, 
    -0.44255999f, 0.21838763f, -0.12219401f, -0.10712425f, -0.09214004f, 0.20191039f, -0.09346215f, 0.13308005f, 
    0.01743551f, -0.20101829f, -0.00672208f, -0.03202406f, -0.27260512f, -0.08114536f, -0.00424610f, 0.06762560f, 
    -0.08939439f, 0.00032236f, 0.08773381f, 0.09783703f, 0.19865751f, 0.02452662f, -0.00707470f, 0.12466922f, 
    0.15758993f, -0.11086566f, 0.06407523f, 0.05285648f, 0.19253467f, -0.05825844f, 0.03976499f, -0.02026791f, 
    0.07008562f, 0.09375560f, 0.09389888f, 0.11434902f, -0.18690674f, -0.21926610f, -0.05994438f, -0.02676702f, 
    0.14277941f, 0.14029615f, -0.11626981f, -0.03042456f, 0.03748455f, 0.02724390f, 0.20146427f, -0.02086594f, 
    0.05294622f, -0.06231028f, 0.07496012f, -0.05095707f, 0.09833974f, -0.24617019f, 0.12203511f, -0.15861213f, 
    0.07004446f, 0.12275603f, 0.03147526f, 0.29115081f, -0.01991617f, 0.18160853f, 0.19884850f, -0.05671792f, 
    0.08663062f, 0.07161120f, -0.05471228f, 0.04772274f, 0.03855333f, -0.07179990f, 0.13874540f, 0.17929150f, 
    -0.08607792f, 0.16514291f, -0.29977685f, 0.19612622f, 0.13914955f, -0.15835343f, -0.00695379f, 0.03443728f, 
    0.05065279f, -0.06660568f, 0.01320955f, 0.09340123f, 0.18336901f, -0.18235920f, 0.10763099f, -0.15742928f, 
    0.13088140f, -0.01103269f, 0.11375469f, 0.05155757f, 0.06115325f, 0.10929234f, 0.16202806f, -0.04545837f, 
    0.11117495f, 0.06580335f, 0.03451953f, 0.07285447f, -0.03977309f, 0.00082963f, 0.01178045f, 0.18800934f, 
    -0.02166661f, -0.10973807f, 0.10632364f, 0.07684414f, -0.18619880f, -0.19999267f, -0.16184895f, -0.26484326f, 
    -0.08634878f, 0.01799320f, 0.20710474f, -0.14785565f, 0.09373828f, -0.02504422f, 0.05598054f, -0.00688661f, 
    -0.00329688f, -0.05818546f, -0.06622739f, 0.03467854f, 0.00077989f, 0.04873682f, -0.07737193f, -0.07320341f, 
    -0.02821080f, 0.01064335f, 0.00676434f, -0.03463146f, -0.00201102f, 0.01395946f, 0.01592567f, 0.04926240f, 
    -0.07248889f, 0.05394587f, -0.03021331f, 0.04311712f, -0.03105737f, -0.04034847f, 0.02319170f, 0.01282816f, 
    0.01243601f, -0.04609418f, 0.04310929f, -0.05300164f, 0.03809635f, 0.05841408f, -0.00187221f, -0.01346096f, 
    -0.04634986f, -0.00501381f, -0.03331026f, -0.00398169f, -0.03820651f, -0.06720910f, 0.05949751f, 0.03040972f, 
    -0.05524266f, 0.03347297f, -0.03752288f, 0.00644211f, -0.03212821f, 0.01808696f, -0.07254805f, 0.00739807f, 
    -0.04991574f, -0.00970622f, 0.03342279f, 0.02661894f, -0.05597577f, 0.05409978f, -0.00567590f, 0.03835830f, 
    -0.03230605f, 0.04813538f, 0.01993395f, -0.06577574f, 0.02715742f, -0.04447655f, -0.03648321f, -0.07137792f, 
    -0.03810454f, -0.02026969f, -0.00947874f, 0.01128673f, -0.05856545f, -0.06995963f, 0.03618947f, 0.04049955f, 
    0.03504337f, 0.00051176f, -0.06112523f, -0.04974390f, -0.07561024f, -0.00903893f, -0.03146552f, 0.02590314f, 
    0.01638215f, -0.01020943f, 0.00175332f, 0.05434993f, 0.06780392f, -0.00611082f, 0.00684875f, -0.06934309f, 
    0.00092429f, 0.02113677f, -0.01121269f, 0.04509458f, -0.00634883f, -0.00135018f, -0.02614989f, -0.06833250f, 
    -0.04765874f, -0.02338025f, -0.01023137f, 0.05262772f, -0.00825394f, -0.00638126f, 0.02606051f, 0.02618201f, 
    -0.01106493f, -0.01507879f, 0.00310843f, 0.03031126f, -0.03130637f, -0.00765255f, -0.00105587f, 0.00070022f, 
    -0.03634745f, 0.03491696f, -0.01475084f, 0.03346054f, 0.00055552f, -0.02654434f, -0.05114814f, 0.02438717f, 
    0.03126818f, 0.03739694f, -0.04714590f, -0.06923438f, -0.01035758f, -0.06919862f, 0.02603237f, -0.07953642f, 
    0.00271427f, 0.05104521f, 0.00576691f, 0.04891717f, 0.02256724f, 0.00547914f, -0.03812803f, -0.05788333f, 
    -0.06146464f, 0.03749278f, 0.01169439f, -0.01004880f, -0.03799096f, -0.00928448f, 0.03731669f, -0.05041656f, 
    -0.00590029f, 0.00452377f, 0.04400082f, 0.04165199f, -0.06020297f, -0.05501607f, -0.05184064f, -0.05526425f, 
    0.03255745f, -0.06938965f, 0.03498661f, -0.06482175f, 0.06488674f, 0.04680520f, -0.07032748f, 0.04453775f, 
    0.00005871f, 0.03733361f, -0.01656839f, 0.01397861f, -0.05118087f, 0.02234983f, 0.02149549f, -0.02803054f, 
    -0.06074847f, 0.02566841f, -0.03226661f, 0.02654160f, -0.05790669f, -0.05728809f, 0.00295536f, -0.03103740f, 
    -0.06624144f, 0.00752585f, -0.05819362f, -0.04919909f, 0.01711561f, 0.04147933f, 0.00622822f, 0.01003570f, 
    -0.01398405f, 0.00200716f, 0.06064949f, 0.01745929f, -0.04552832f, -0.04636887f, 0.00164290f, 0.02305247f, 
    -0.12413159f, 0.06090086f, -0.16993789f, -0.33204681f, 0.11642379f, 0.12882456f, 0.00085100f, 0.03289095f, 
    0.03924021f, 0.07120854f, -0.03480889f, -0.09246290f, -0.26651102f, 0.12741210f, -0.00700285f, 0.26870364f, 
    -0.06362248f, -0.07050119f, 0.19428459f, 0.20566916f, -0.06115649f, 0.16455507f, 0.13890442f, 0.02195506f, 
    -0.07971015f, 0.00580411f, -0.06189220f, -0.14161150f, 0.05457705f, 0.02022949f, -0.06683473f, -0.12534603f, 
    -0.12573850f, -0.07575746f, 0.18431899f, 0.09528535f, -0.08691765f, 0.20139788f, 0.01357615f, 0.21761155f, 
    0.11657259f, 0.13951272f, 0.07295438f, 0.08611967f, -0.00617051f, 0.11833021f, -0.08619743f, 0.03907719f, 
    -0.41837582f, 0.37175769f, -0.00955399f, -0.07822388f, 0.12136785f, 0.04907817f, 0.17264785f, 0.02629717f, 
    0.06380100f, 0.00022116f, 0.06205287f, 0.05577558f, 0.07396800f, -0.13899530f, 0.18460049f, 0.35249752f, 
    0.00861003f, -0.11718251f, 0.13017257f, 0.12129018f, -0.11593860f, -0.00813036f, -0.04228307f, 0.00148455f, 
    0.36643553f, -0.24803905f, 0.10687187f, 0.03766158f, 0.00649972f, -0.11308915f, -0.05823119f, 0.08822830f, 
    0.09943402f, 0.19955410f, 0.15615252f, 0.00970593f, 0.17621182f, -0.40720078f, -0.12765101f, 0.05077650f, 
    0.04096089f, 0.11182718f, -0.10500894f, 0.05530993f, -0.05994630f, -0.07284301f, 0.03286016f, -0.01392956f, 
    -0.13205069f, -0.04509974f, 0.37499878f, 0.08426521f, -0.03007181f, 0.16368617f, -0.03582480f, 0.02159242f, 
    0.02009939f, 0.01352167f, -0.04172307f, -0.15045185f, 0.17325565f, 0.15489246f, 0.07828996f, 0.03755556f, 
    -0.10972133f, -0.12633412f, 0.09923542f, 0.01585059f, -0.03145757f, -0.04395228f, -0.24296442f, 0.15633856f, 
    -0.12672631f, 0.14733461f, 0.06355311f, -0.04035998f, -0.15138058f, 0.28178838f, -0.04846528f, 0.05291846f, 
    -0.01654060f, -0.10177933f, -0.11121616f, -0.27392155f, -0.20146482f, -0.00478729f, -0.21895196f, -0.13480589f, 
    0.11532776f, 0.07178608f, 0.07580826f, -0.02627221f, -0.04146397f, 0.02412967f, -0.07360570f, -0.09687838f, 
    0.22851561f, -0.05134031f, 0.21628772f, -0.02006303f, -0.04153509f, 0.16620617f, 0.06474265f, -0.10205925f, 
    -0.06408454f, 0.19101474f, -0.03145237f, 0.05750680f, -0.10937654f, -0.04633520f, -0.24896647f, 0.26817951f, 
    -0.05569533f, 0.13170986f, 0.00241211f, -0.00610792f, -0.02989287f, -0.00297975f, -0.05539139f, 0.03963476f, 
    0.14635834f, -0.16119476f, -0.01576515f, -0.16281885f, 0.03558549f, 0.17846991f, 0.05691691f, -0.14413472f, 
    0.13223571f, 0.08042648f, 0.12240487f, -0.12905604f, 0.26829273f, 0.13971438f, 0.18138911f, 0.22491230f, 
    0.23414360f, -0.05927663f, -0.10779700f, 0.03505234f, -0.10561910f, 0.01754436f, 0.01083990f, 0.02497066f, 
    -0.03036883f, -0.06285916f, -0.01451321f, -0.04871244f, -0.03536439f, -0.07298015f, 0.00471143f, 0.04526159f, 
    -0.00778160f, -0.05171223f, -0.01287302f, -0.07106162f, -0.06468155f, -0.02298725f, -0.00894155f, -0.07997678f, 
    0.05528852f, 0.06015853f, -0.00176925f, 0.05695533f, -0.07260539f, -0.02084094f, 0.04863886f, 0.04458361f, 
    -0.04733450f, -0.05998255f, 0.01104895f, -0.03860171f, 0.04748498f, 0.05872706f, 0.00821546f, 0.00500801f, 
    -0.05113280f, -0.05124591f, -0.01756928f, -0.02434332f, 0.05727846f, 0.02883935f, 0.00970555f, -0.05618395f, 
    -0.03557290f, 0.00001575f, -0.04529310f, 0.04551475f, 0.01276108f, -0.02555017f, -0.07899780f, -0.02159438f, 
    -0.02314932f, -0.02551340f, 0.03873720f, -0.07938714f, 0.00935466f, 0.05876438f, -0.07615622f, -0.06135436f, 
    0.03891582f, 0.04993631f, -0.04455215f, -0.02689487f, 0.02171605f, -0.00218596f, 0.04210896f, -0.06810634f, 
    -0.04405089f, -0.03933803f, -0.07854174f, -0.03596295f, -0.05171167f, 0.00890757f, 0.00339648f, 0.04820993f, 
    -0.06468910f, 0.02020769f, -0.01051440f, 0.01261088f, 0.00436570f, 0.04624345f, 0.01510444f, 0.03003977f, 
    0.04467735f, 0.03376807f, 0.04176087f, 0.00269958f, 0.02131309f, 0.03367766f, -0.01080302f, -0.05757156f, 
    0.05884043f, -0.06584093f, 0.04736049f, 0.05342562f, -0.00551643f, -0.05978293f, -0.06982873f, 0.06069295f, 
    -0.00136917f, 0.00070046f, 0.01555203f, 0.01362091f, 0.02024389f, 0.03290821f, -0.05911392f, -0.06739788f, 
    0.03979677f, -0.06039571f, 0.06162816f, 0.04452553f, 0.04520974f, -0.04658325f, 0.01390454f, -0.05904330f, 
    -0.07270406f, -0.00209133f, 0.00586824f, -0.00555568f, -0.06271608f, 0.00916933f, 0.05952070f, -0.06056676f, 
    0.04112121f, -0.05638538f, -0.03753912f, 0.02709310f, 0.04950565f, -0.03271822f, 0.00930277f, 0.03273327f, 
    -0.05843937f, 0.00464965f, -0.00358596f, -0.07307713f, 0.02725524f, -0.05750757f, -0.05808826f, -0.05910751f, 
    0.04553458f, -0.05907113f, -0.01189745f, 0.00721940f, -0.07431740f, 0.02358827f, -0.05275153f, 0.00609725f, 
    0.05588598f, 0.06199457f, 0.06365751f, -0.04665834f, -0.03231064f, -0.07504857f, 0.00526511f, -0.04790559f, 
    -0.00444754f, -0.02890540f, 0.02693371f, 0.02194237f, 0.00311479f, -0.00626056f, -0.07096370f, -0.04276377f, 
    -0.00016678f, 0.04170620f, -0.01989590f, 0.01266327f, -0.00189577f, -0.06789547f, -0.07735018f, 0.03376836f, 
    -0.05959405f, 0.05488414f, 0.06494147f, 0.03600734f, -0.01427850f, 0.04637430f, -0.01021952f, -0.01624529f, 
    -0.03355902f, -0.07566752f, -0.07727737f, 0.04720509f, 0.01935768f, -0.03535613f, 0.00709293f, 0.04202710f, 
    0.05284233f, 0.04262257f, -0.05072606f, -0.03554503f, 0.01224416f, -0.01470059f, -0.07277898f, -0.02786712f, 
    0.09312349f, 0.14917946f, 0.17656845f, 0.21139576f, 0.00682591f, -0.15256418f, -0.14544196f, -0.03113229f, 
    0.00435054f, -0.10828963f, -0.05602350f, -0.16253188f, -0.30798599f, 0.07071128f, -0.16702837f, 0.02781942f, 
    0.04084712f, 0.02887958f, 0.12387509f, 0.04442332f, -0.12858069f, 0.23249850f, 0.26075339f, 0.13129731f, 
    0.31725770f, 0.08750273f, 0.14219461f, -0.15034638f, 0.23822807f, -0.12076231f, 0.08997922f, -0.16551672f, 
    -0.19663583f, -0.05140291f, 0.09076007f, 0.09155314f, 0.15533012f, -0.01311212f, -0.17268717f, 0.18340103f, 
    -0.13000245f, 0.16219142f, 0.10657325f, 0.15220401f, 0.05912408f, 0.17189732f, -0.05478081f, 0.07941844f, 
    0.05596977f, 0.35478133f, -0.12408164f, -0.03343929f, 0.11274204f, 0.19010457f, -0.13287321f, -0.17547606f, 
    -0.07466942f, -0.02036200f, 0.09699858f, -0.04286978f, -0.41069120f, -0.06485310f, -0.03613865f, 0.09650337f, 
    -0.09088456f, -0.01821326f, 0.19864760f, -0.05768512f, 0.11413542f, -0.02636420f, -0.07276143f, 0.03104594f, 
    -0.50050282f, -0.08408774f, 0.13206604f, 0.02862412f, 0.08584074f, -0.16782339f, 0.13843174f, 0.14980149f, 
    -0.16022457f, 0.04705170f, 0.18827930f, 0.20932339f, 0.47038162f, -0.26600370f, 0.18727729f, 0.08915906f, 
    -0.09456930f, 0.05867500f, -0.09490678f, 0.04214637f, -0.03660684f, -0.06029199f, 0.23095135f, -0.01347578f, 
    -0.11549358f, 0.07572249f, -0.05452349f, 0.01373147f, -0.11566177f, 0.23937158f, 0.00537244f, 0.09352264f, 
    0.07675871f, -0.05110469f, -0.12948471f, -0.16714004f, 0.03051890f, -0.09461760f, 0.09024968f, 0.11788101f, 
    -0.03687051f, 0.01390115f, 0.11229696f, 0.28559265f, 0.22934373f, 0.01980059f, 0.04253116f, 0.29926628f, 
    0.06366260f, -0.07631824f, 0.05445427f, 0.15837285f, -0.19948998f, 0.27093762f, 0.03477509f, 0.19215705f, 
    0.11769848f, -0.12378284f, -0.17366129f, -0.11371297f, 0.09910069f, 0.06777219f, -0.26541200f, 0.02236042f, 
    -0.05747222f, -0.09454590f, 0.24034524f, 0.08751033f, 0.09660716f, 0.00462529f, -0.20155832f, -0.17542988f, 
    -0.10711926f, 0.17614929f, 0.15035073f, -0.10656162f, 0.06739040f, 0.22616705f, 0.08898353f, 0.07136403f, 
    -0.04249018f, 0.20233247f, 0.06123710f, -0.15248774f, 0.24199656f, 0.06177476f, -0.01368465f, 0.33009723f, 
    -0.22029884f, -0.00307766f, -0.10334141f, -0.05012507f, -0.00358520f, 0.05183603f, 0.10769922f, 0.16946277f, 
    -0.34207782f, -0.35837516f, 0.12646773f, 0.27677044f, 0.00397533f, 0.07965765f, 0.00704877f, -0.03715779f, 
    0.13043749f, 0.08560284f, -0.05574277f, 0.07926412f, -0.22222354f, 0.12945682f, 0.21268971f, -0.06234805f, 
    0.25528532f, 0.11240334f, -0.14094573f, 0.15477212f, -0.03799172f, -0.01797982f, -0.14404215f, 0.06256694f, 
    -0.04325260f, -0.03055011f, -0.03047298f, -0.04586597f, 0.01687836f, -0.02587387f, -0.04710044f, -0.03249228f, 
    0.03160001f, 0.00488511f, 0.03529163f, -0.05255623f, 0.01488804f, 0.04206270f, -0.05994958f, -0.04852143f, 
    0.00895313f, 0.03820635f, -0.01764646f, 0.04511316f, -0.04064915f, -0.05372957f, 0.03545176f, -0.05916299f, 
    -0.06360685f, -0.00138836f, -0.00375232f, 0.05369906f, -0.04575996f, -0.03222916f, -0.03466460f, -0.07716213f, 
    -0.02188368f, -0.00024409f, -0.04293194f, -0.06699412f, -0.03502349f, 0.05649059f, 0.05209891f, -0.04524028f, 
    -0.03956483f, 0.01815783f, 0.04884115f, -0.02626410f, -0.05095072f, -0.03564275f, -0.07050895f, -0.02823390f, 
    -0.03731827f, -0.00021466f, 0.00059065f, 0.00383061f, 0.04452438f, -0.04195868f, -0.01794015f, -0.07466590f, 
    0.04692204f, 0.00780173f, -0.03565825f, 0.00046615f, 0.01589002f, 0.01488630f, 0.01418949f, -0.04835885f, 
    0.05918291f, -0.07494517f, -0.03952146f, 0.00017813f, 0.01314274f, -0.03617845f, 0.05024122f, 0.03726984f, 
    -0.01761930f, -0.05982814f, -0.06011489f, -0.07982802f, -0.05117635f, -0.00215682f, 0.03709092f, 0.05630963f, 
    0.05635163f, -0.02805330f, -0.00523309f, -0.06460708f, -0.01133485f, -0.01073287f, -0.03815747f, -0.00067192f, 
    -0.01200796f, 0.05289636f, 0.01734662f, -0.04576412f, 0.03882707f, -0.06555017f, 0.01137509f, -0.05121478f, 
    0.00455355f, -0.07392754f, -0.06119844f, -0.04313904f, 0.05337620f, 0.01886012f, -0.07259921f, 0.02363546f, 
    0.01535395f, -0.00019610f, -0.02311374f, -0.06366976f, 0.02917840f, -0.07348603f, -0.05328522f, 0.04706267f, 
    0.05277005f, -0.01118101f, 0.04498644f, -0.04844188f, 0.00370998f, -0.02888695f, 0.02951219f, -0.00165749f, 
    -0.00459639f, 0.00708474f, -0.01183947f, 0.02639586f, 0.02244188f, 0.03417197f, -0.00696043f, 0.04933906f, 
    -0.04874018f, -0.03593532f, -0.03468587f, -0.07461175f, 0.05404589f, 0.04437342f, -0.04129452f, -0.02200985f, 
    -0.01417500f, -0.02562796f, 0.01634992f, 0.04208253f, 0.06215443f, -0.04180854f, 0.04306487f, -0.01309282f, 
    0.03802340f, -0.03066154f, -0.00331174f, 0.03920174f, -0.05709102f, -0.02455681f, 0.00826845f, 0.02079664f, 
    0.00590234f, -0.03035460f, -0.07401607f, -0.06237537f, -0.00683581f, 0.02371525f, 0.03748353f, -0.01778540f, 
    0.04778928f, 0.02636939f, 0.02489326f, -0.06633171f, -0.02200134f, 0.01790329f, 0.00257438f, 0.04560550f, 
    -0.03507498f, -0.04624084f, -0.06323096f, -0.06508040f, -0.03032264f, -0.07404515f, 0.00864124f, -0.06151779f, 
    0.04412073f, -0.00113987f, -0.06937259f, -0.02091235f, -0.07441512f, 0.03010860f, -0.03570517f, 0.04106420f, 
    -0.07236516f, -0.01601716f, -0.00070702f, 0.06329002f, 0.04440810f, 0.05460880f, 0.03153751f, 0.00321106f, 
    0.67123890f, 0.47254851f, 0.08225565f, -0.29863626f, 0.06529827f, -0.09055147f, 0.03799685f, -0.02274277f, 
    -0.15437119f, -0.02095054f, -0.05744604f, -0.04671090f, -0.24020706f, -0.18538979f, 0.09158259f, -0.01589504f, 
    -0.09661984f, -0.12098575f, -0.03845775f, 0.10103743f, 0.09461107f, 0.06276157f, 0.27666041f, 0.08813216f, 
    0.24430212f, 0.17645282f, 0.07125353f, -0.25666419f, 0.19828504f, -0.02005994f, 0.05553980f, -0.13319026f, 
    -0.26736090f, -0.06026832f, -0.04434834f, 0.02614170f, 0.12195491f, -0.13987136f, -0.02981395f, 0.35851213f, 
    -0.01803096f, 0.08898164f, -0.10014590f, 0.06194518f, 0.04004256f, -0.00574615f, -0.16247636f, 0.03155245f, 
    -0.08120805f, 0.63093626f, 0.16045026f, -0.08342754f, 0.00689777f, -0.04054487f, -0.03141434f, -0.10789328f, 
    -0.07545607f, -0.00967831f, -0.05248713f, 0.13451254f, -0.05741152f, -0.39034674f, -0.09287573f, 0.18390003f, 
    0.23406263f, 0.03548747f, 0.02821926f, 0.14145051f, -0.05059854f, 0.05590144f, -0.02302234f, 0.01591454f, 
    -0.04650341f, 0.03296184f, -0.28402328f, 0.01558360f, 0.05829142f, -0.11245099f, 0.21896079f, 0.10555391f, 
    -0.09331540f, -0.04717099f, 0.22206341f, 0.09015883f, 0.24816149f, -0.40193549f, -0.09775148f, 0.30287901f, 
    -0.19908303f, 0.06568427f, 0.08434970f, 0.06299061f, -0.10647364f, 0.02678047f, 0.28381407f, -0.09113863f, 
    0.35928321f, -0.03451319f, 0.09465562f, 0.20627220f, 0.10960145f, 0.11847503f, -0.01450372f, 0.15301462f, 
    0.02869788f, -0.09802276f, -0.08359139f, -0.30548269f, 0.06488185f, 0.14264649f, -0.00171700f, -0.08369838f, 
    -0.05791712f, 0.01819467f, 0.13650882f, 0.04913742f, 0.16306351f, 0.18553646f, 0.04733765f, 0.14862683f, 
    -0.21870744f, 0.03077629f, 0.11957091f, -0.07726987f, -0.00931122f, 0.31749931f, -0.01728391f, 0.18845680f, 
    -0.05433317f, -0.16128431f, -0.03597347f, -0.09092683f, -0.22010008f, 0.16040191f, 0.08648750f, -0.14135300f, 
    -0.02059776f, 0.00829320f, 0.12379797f, 0.10789833f, 0.16711314f, -0.15818918f, -0.20200750f, -0.17535567f, 
    0.05829593f, -0.05586455f, -0.17762379f, 0.02933296f, 0.05599941f, 0.10630111f, 0.06103343f, -0.05300014f, 
    -0.07528759f, 0.13661917f, 0.13802427f, 0.06652212f, 0.14238621f, 0.00899627f, -0.18652761f, 0.04575919f, 
    -0.08584999f, -0.04883061f, 0.02265841f, -0.03915802f, 0.13413846f, 0.09164998f, 0.06661236f, 0.18904150f, 
    0.14471674f, -0.28276721f, -0.28774321f, 0.15571325f, 0.05583953f, 0.31057340f, 0.04871713f, 0.09262976f, 
    0.02233174f, 0.13733806f, -0.01132949f, -0.10830218f, -0.33426374f, -0.40411934f, -0.04985918f, 0.06402764f, 
    -0.00245999f, 0.11580240f, -0.15342028f, 0.03334143f, -0.11311541f, 0.04268359f, -0.16073583f, 0.01037530f, 
    -0.04636191f, -0.02533451f, 0.10874444f, -0.02309362f, 0.27645022f, -0.06188577f, -0.11613671f, -0.06841800f, 
    0.00282118f, 0.07936831f, 0.04001667f, 0.36557192f, -0.01487141f, -0.09305639f, -0.04365604f, 0.01459377f, 
    -0.03011450f, 0.06374073f, -0.07587264f, 0.04525767f, 0.13680588f, -0.21464531f, -0.26668596f, -0.11815751f, 
    0.02701778f, 0.08271579f, 0.11106527f, -0.04339829f, -0.06388979f, 0.14861743f, 0.00032999f, -0.04465873f, 
    0.29751331f, -0.04663828f, -0.19761923f, -0.04612657f, -0.13077386f, 0.01849839f, -0.11063805f, 0.11901999f, 
    -0.00759599f, 0.15150109f, -0.06603599f, -0.07585479f, 0.09754404f, -0.13511050f, 0.16671427f, -0.01844930f, 
    -0.19629335f, 0.04269762f, -0.01520559f, -0.01151279f, 0.12385597f, -0.04352715f, 0.13249427f, -0.06216405f, 
    0.16146432f, 0.05104224f, 0.00009794f, 0.05854931f, 0.26419088f, 0.14633253f, -0.09735278f, 0.02320358f, 
    -0.13427027f, -0.04066301f, -0.15942547f, -0.02502266f, 0.06087457f, -0.05916885f, 0.14329159f, -0.21622348f, 
    -0.07320914f, -0.03615805f, -0.09865663f, -0.32781145f, -0.03093521f, 0.13081999f, 0.18665527f, 0.17027470f, 
    0.06090369f, -0.22699900f, -0.02902020f, -0.07984891f, -0.12281913f, -0.20972304f, 0.03999029f, 0.31731558f, 
    0.05286305f, 0.04577516f, -0.19611450f, -0.00706630f, 0.04416987f, 0.05101924f, -0.05670317f, 0.15019402f, 
    0.25145668f, 0.11334019f, -0.07608322f, 0.10510430f, 0.21025699f, -0.11469819f, -0.04503885f, -0.15137888f, 
    0.20742548f, 0.11254817f, 0.06013942f, 0.29126534f, -0.13771060f, 0.09855559f, 0.14161974f, 0.22593878f, 
    0.34992599f, 0.50584787f, -0.18977474f, 0.03729586f, 0.06968067f, 0.01308259f, 0.11881035f, -0.12407175f, 
    -0.11633058f, 0.00759950f, 0.03960351f, -0.27993837f, 0.01397820f, -0.23723628f, 0.12947378f, -0.13013323f, 
    0.18564299f, 0.28849572f, 0.14249593f, 0.23189253f, 0.09380899f, 0.15019222f, -0.01446604f, -0.03290931f, 
    0.08132032f, 0.07030084f, -0.26071832f, -0.17268267f, 0.03701068f, -0.19915023f, 0.21893595f, 0.27401385f, 
    -0.21337235f, -0.09833629f, -0.06825484f, 0.06455987f, 0.16388398f, -0.03746976f, -0.08128300f, -0.08465545f, 
    0.03162587f, -0.11176881f, -0.02128846f, 0.23659237f, -0.03948657f, -0.24067198f, -0.16422133f, 0.25706029f, 
    0.02504230f, -0.15991533f, 0.07494225f, 0.15300623f, 0.17530721f, 0.08364312f, 0.03886045f, 0.13788606f, 
    0.04539334f, 0.03542254f, -0.24967174f, 0.13009982f, -0.08443996f, -0.16819249f, -0.01877455f, -0.01440744f, 
    0.07549027f, 0.05133438f, -0.04386145f, 0.09534799f, -0.75331664f, -0.19334631f, -0.07337613f, -0.01584196f, 
    0.12852332f, 0.11119585f, 0.28612736f, -0.10203003f, 0.02412652f, -0.13258967f, 0.13377294f, -0.07173772f, 
    -0.22827098f, -0.19844846f, 0.22793706f, 0.49889114f, 0.11780208f, -0.00476616f, 0.09157573f, 0.11044302f, 
    0.08032615f, -0.18328650f, 0.11143384f, -0.09340105f, -0.00159020f, 0.03963613f, 0.00198437f, 0.10295384f, 
    -0.10735223f, 0.14287625f, -0.11289093f, -0.00600663f, -0.03514719f, -0.01925804f, -0.01112508f, -0.00757111f, 
    0.34952360f, -0.10996942f, 0.09964380f, 0.10754450f, -0.03697049f, -0.08117823f, 0.24924201f, -0.04064098f, 
    0.01605699f, 0.10751566f, 0.02905144f, -0.04378875f, 0.16924027f, 0.04032106f, -0.12154187f, 0.04767794f, 
    -0.09915112f, -0.02562118f, -0.16830724f, 0.14223345f, -0.04431481f, 0.06732124f, 0.06596880f, 0.04070382f, 
    0.88303494f, 0.02137918f, -0.14642310f, -0.01564192f, -0.19630770f, 0.03377115f, -0.12415139f, -0.10858840f, 
    -0.04948978f, -0.14443925f, -0.04755367f, -0.15483885f, -0.06655078f, 0.12961251f, 0.02583076f, -0.05872760f, 
    -0.01606535f, 0.17762649f, 0.01323084f, -0.18370380f, 0.19056992f, 0.09266012f, 0.04812706f, 0.01029463f, 
    0.02745884f, -0.06099201f, 0.28518280f, -0.27687854f, -0.03409946f, 0.14859295f, 0.12440757f, 0.00613961f, 
    -0.09396541f, -0.04221771f, -0.12567696f, 0.06212306f, 0.14814979f, 0.12911235f, 0.25664243f, 0.12206282f, 
    0.12583087f, -0.14484298f, 0.04679485f, -0.16024593f, -0.13485880f, -0.00237439f, -0.09445790f, -0.04188871f, 
    0.13319626f, 0.22065738f, -0.23170552f, -0.21259722f, -0.21807422f, 0.09066196f, -0.03983343f, 0.06560076f, 
    -0.08949865f, 0.06880333f, -0.07266219f, -0.02956887f, -0.13501441f, 0.11419236f, 0.32058135f, 0.33254454f, 
    0.30050674f, 0.28499904f, -0.00908444f, 0.12583229f, 0.13003549f, 0.09494911f, 0.14124575f, 0.00613941f, 
    0.01853710f, -0.13032699f, -0.16975109f, 0.05815045f, -0.09072537f, -0.05056573f, 0.05387813f, -0.01581608f, 
    0.15769292f, -0.07022410f, 0.03429807f, 0.06810075f, 0.42874587f, 0.18856531f, 0.24563219f, 0.34489977f, 
    -0.14382043f, -0.09841756f, 0.00607265f, 0.03496256f, 0.17689620f, 0.06119229f, 0.05764776f, -0.02854007f, 
    -0.15520886f, -0.09943192f, 0.09074315f, 0.05321202f, 0.17409576f, 0.14031702f, 0.03035245f, 0.05309506f, 
    -0.06570532f, -0.00363469f, 0.06331892f, 0.01990937f, 0.09955945f, 0.08959202f, -0.03064039f, -0.03756646f, 
    -0.04020228f, 0.13787758f, -0.14858238f, -0.17809395f, 0.01450583f, 0.05204992f, -0.10398487f, 0.16224425f, 
    -0.28827590f, -0.13624093f, 0.17019835f, 0.18096802f, -0.13056250f, -0.30442709f, -0.09762078f, 0.04679240f, 
    0.01562969f, -0.01979453f, -0.08729477f, 0.22666889f, -0.64406371f, 0.03674247f, 0.05535867f, 0.03053485f, 
    0.12195192f, 0.16047321f, 0.12646598f, 0.01372237f, 0.15030044f, 0.01466376f, 0.07908496f, -0.05466626f, 
    0.04704670f, -0.02621570f, 0.02365519f, -0.05915150f, -0.04397071f, 0.00160490f, 0.03006199f, -0.02857565f, 
    0.05599625f, -0.03585269f, 0.04093669f, -0.03285785f, 0.03422418f, -0.08274671f, -0.04881629f, -0.07708842f, 
    -0.06876194f, -0.05329088f, -0.03352882f, -0.03224285f, 0.00984134f, 0.00094130f, 0.02519134f, -0.04794355f, 
    -0.02267476f, -0.05172416f, 0.03877535f, -0.02396540f, 0.00049781f, -0.04909850f, 0.02393810f, -0.00448905f, 
    -0.00544559f, -0.01660035f, 0.04302298f, -0.04165831f, 0.05868962f, 0.02224103f, 0.02660190f, 0.04543102f, 
    -0.05222077f, -0.00423670f, -0.07765891f, 0.06067778f, 0.00996254f, 0.00917896f, -0.07258552f, 0.05610373f, 
    0.05595070f, 0.00221270f, -0.01787809f, 0.01368213f, -0.06555075f, -0.00785500f, -0.06419797f, 0.01838718f, 
    0.02684155f, 0.02058836f, 0.05323745f, 0.03493719f, -0.07212892f, -0.00210692f, 0.02761569f, -0.05243658f, 
    -0.04055251f, 0.06677894f, 0.04723440f, -0.02063079f, -0.00955259f, 0.03470610f, -0.00447810f, -0.02932866f, 
    0.05760894f, -0.01337788f, 0.02251465f, -0.07525830f, -0.04772716f, 0.05329565f, 0.03343788f, 0.04184338f, 
    -0.00522069f, 0.06646391f, 0.00434247f, -0.00186123f, -0.03412925f, 0.02837711f, 0.02006280f, -0.02633094f, 
    -0.05841763f, -0.00099439f, -0.07751761f, -0.06768718f, 0.04683197f, -0.01085113f, 0.04502171f, -0.07584789f, 
    -0.05993565f, -0.02949050f, -0.03263211f, 0.01058849f, -0.05466830f, 0.03971173f, -0.05907504f, 0.02565139f, 
    0.05587872f, -0.07404607f, 0.03333791f, -0.03411027f, 0.02713263f, -0.01139403f, -0.06804409f, -0.05567782f, 
    -0.04047880f, 0.00575643f, -0.05806309f, 0.03114588f, -0.01508440f, -0.07284360f, -0.04262334f, -0.00952883f, 
    -0.06935500f, -0.07250860f, -0.05079534f, -0.06519587f, 0.06151493f, -0.06228806f, -0.01337252f, 0.00790999f, 
    0.02865537f, 0.06072495f, 0.01713288f, -0.03301154f, -0.06131650f, -0.04118177f, -0.03311319f, 0.00659041f, 
    -0.02983730f, -0.05203466f, -0.07266930f, 0.05775983f, 0.06313559f, -0.07738128f, 0.00419426f, -0.00790381f, 
    0.02057149f, -0.07742807f, 0.00756293f, -0.05062034f, 0.03039698f, -0.01434965f, -0.05306858f, -0.00542890f, 
    0.02199054f, 0.03006070f, 0.00188965f, 0.01551431f, -0.04961929f, 0.05271342f, 0.00462687f, 0.00774788f, 
    -0.03871537f, -0.02519530f, 0.05070596f, 0.02965869f, -0.06167940f, -0.02460005f, 0.01887275f, 0.06044329f, 
    0.00806780f, -0.04092822f, -0.07095504f, 0.02229720f, -0.00311632f, 0.06412320f, -0.03797685f, 0.00203389f, 
    -0.05087779f, 0.00506636f, -0.05620124f, 0.04469895f, 0.03019215f, -0.05648846f, 0.02385362f, -0.01862616f, 
    -0.06487734f, 0.04082597f, 0.01278443f, -0.00774131f, 0.01197875f, -0.06762809f, 0.00389840f, -0.01821511f, 
    1.03589535f, -0.27522993f, -0.38370827f, 0.15472206f, 0.04770531f, -0.11638187f, 0.04750977f, -0.05916294f, 
    0.08598784f, 0.08558612f, 0.06861821f, 0.07391614f, -0.06734300f, -0.08666317f, 0.08472168f, 0.13962308f, 
    -0.05987424f, -0.20869380f, 0.01722766f, 0.15190637f, 0.09564082f, -0.06681199f, -0.10374972f, -0.11933725f, 
    0.14194712f, -0.12223611f, 0.13845260f, -0.20106150f, 0.11138838f, 0.06327225f, 0.03024190f, 0.07652835f, 
    0.00844116f, 0.07866871f, -0.10622759f, -0.16484915f, 0.22264569f, -0.00262431f, -0.26398435f, 0.21234234f, 
    0.08304639f, 0.03151014f, 0.05549566f, -0.12773436f, -0.01223852f, -0.05065443f, -0.02891326f, -0.03170190f, 
    -0.07460160f, 0.15460718f, -0.05195030f, 0.03830218f, 0.27884972f, -0.13478538f, -0.02025862f, 0.10074448f, 
    0.06182725f, -0.02209147f, -0.03987487f, 0.11818436f, 0.06552168f, 0.07221458f, 0.04102748f, 0.15037848f, 
    0.21276675f, -0.02731534f, 0.06701666f, 0.01269129f, -0.10330997f, -0.02906118f, 0.01741798f, -0.15787253f, 
    -0.57363582f, 0.26441240f, -0.02756959f, -0.06881780f, 0.14266190f, -0.13768840f, 0.15841326f, -0.02288398f, 
    0.00542593f, 0.04705650f, 0.07658178f, -0.06002884f, -0.32060760f, -0.19128573f, 0.17528228f, 0.18520541f, 
    0.05474722f, 0.23455104f, -0.21363011f, 0.15521121f, -0.02409311f, 0.01225096f, 0.24474370f, 0.07002807f, 
    0.48249316f, -0.01407353f, -0.11066690f, 0.12706660f, 0.16470832f, -0.04762845f, -0.12378135f, 0.10794750f, 
    -0.20528530f, 0.12100698f, -0.10408524f, 0.04162500f, 0.28931493f, 0.30787280f, -0.21655253f, -0.10666735f, 
    -0.17022049f, -0.07658111f, -0.08122473f, -0.19133621f, 0.14887293f, -0.08442205f, -0.10530460f, -0.11137993f, 
    -0.02543725f, 0.08697169f, -0.12203724f, -0.04952315f, 0.11493661f, 0.04206157f, -0.05842406f, 0.01257547f, 
    -0.22421113f, 0.01313119f, -0.10167490f, 0.00949104f, 0.01484349f, -0.40780455f, -0.01608813f, -0.17823283f, 
    -0.03055441f, 0.22081797f, -0.09673063f, 0.05373443f, 0.17313747f, -0.01865683f, -0.02133764f, -0.11007172f, 
    -0.24421886f, 0.27188602f, 0.03757914f, -0.12253483f, -0.19271849f, -0.06225091f, 0.09085438f, -0.01145545f, 
    0.04246351f, 0.04681880f, -0.04343374f, -0.06692378f, 0.11467975f, 0.26275417f, -0.03516445f, 0.15236476f, 
    -0.01928966f, -0.23915191f, 0.03974138f, -0.14051162f, 0.17088945f, -0.06342164f, 0.01919513f, 0.08384733f, 
    0.01669345f, 0.07466065f, -0.46622819f, 0.37403974f, 0.03335251f, 0.03832732f, 0.00482520f, 0.08002960f, 
    0.09942884f, 0.11111061f, -0.01821167f, -0.23944837f, -0.14683233f, -0.12509020f, 0.05768583f, 0.14542124f, 
    -0.17874454f, 0.17584513f, -0.01620158f, 0.07532045f, -0.25571775f, -0.08348933f, -0.04593952f, -0.04785399f, 
    0.28263056f, 0.24535961f, -0.00196934f, -0.03965374f, -0.27214530f, 0.00294343f, 0.09907266f, 0.02316297f, 
    -0.03076130f, 0.01240844f, -0.12836203f, -0.00139403f, 0.34273273f, 0.00630038f, 0.17168194f, -0.06512578f, 
    0.22474054f, -0.12331168f, -0.19876479f, 0.11196403f, 0.02745766f, -0.03176438f, 0.09658883f, 0.03692604f, 
    -0.18953730f, 0.22368695f, -0.06086798f, 0.36652216f, -0.02727179f, 0.04456735f, -0.13214946f, 0.05353358f, 
    0.01266713f, 0.03732907f, 0.00139705f, 0.04838262f, -0.11930168f, -0.04881310f, 0.24487726f, -0.49109203f, 
    -0.08953257f, -0.27076209f, 0.14259270f, -0.02058056f, 0.07298768f, -0.10842184f, -0.02115280f, -0.02950765f, 
    0.21432360f, -0.30884483f, 0.12703232f, 0.18999536f, -0.12039573f, -0.02442494f, 0.08031326f, 0.12982598f, 
    -0.08765722f, 0.16046177f, 0.02655379f, 0.11886492f, 0.15802480f, 0.08123544f, 0.05573145f, -0.29453987f, 
    0.21219751f, -0.06628305f, -0.07483365f, 0.28124449f, 0.12188797f, 0.05273578f, 0.03773624f, 0.03907919f, 
    0.05516956f, 0.13807911f, -0.23512132f, 0.03752541f, 0.17423627f, 0.16510698f, -0.14749961f, 0.03080755f, 
    0.06189939f, 0.08979463f, 0.04516009f, 0.00593974f, -0.03128254f, 0.32487687f, -0.07101952f, -0.17995571f, 
    -0.09099138f, 0.05126153f, 0.21299914f, 0.00074895f, 0.12415271f, -0.00986902f, 0.05508509f, 0.12928087f, 
    0.25133991f, -0.03035350f, 0.09037136f, -0.20277236f, -0.01861433f, -0.08928566f, 0.17713846f, 0.03422694f, 
    -0.06757917f, 0.14355378f, 0.17298159f, 0.11543135f, -0.08276600f, -0.17834447f, -0.05156983f, -0.16973436f, 
    -0.01443512f, -0.19181772f, -0.01172970f, -0.01786553f, -0.08198600f, 0.10793380f, 0.12698956f, 0.05978315f, 
    -0.00477718f, 0.10740069f, 0.03829386f, -0.13303384f, 0.18306509f, 0.00681665f, 0.13692270f, 0.02086496f, 
    -0.03786839f, 0.14698151f, 0.09651566f, 0.08496929f, 0.09599517f, 0.07481987f, 0.06659382f, 0.18502967f, 
    0.07647872f, -0.07302682f, 0.00346457f, -0.11294722f, -0.03079139f, 0.00465148f, 0.10196801f, -0.05629162f, 
    -0.04192664f, -0.11176579f, -0.27684227f, 0.18503742f, -0.00780563f, -0.14447413f, 0.05987696f, 0.18360226f, 
    0.03745420f, 0.01902861f, 0.01318504f, 0.12327534f, -0.26785734f, -0.16224895f, 0.03067804f, -0.38393065f, 
    0.06091801f, 0.10381933f, 0.23091166f, 0.13680862f, -0.05456010f, 0.00540680f, -0.05808458f, -0.13682386f, 
    0.05121315f, 0.10664523f, 0.12241863f, -0.33038038f, 0.12645660f, 0.17142119f, 0.09098328f, 0.11826649f, 
    -0.03308672f, -0.04959036f, 0.26107389f, 0.02441474f, 0.53949404f, -0.13283910f, -0.02103296f, -0.22682673f, 
    -0.05046925f, -0.10020529f, -0.12512459f, 0.03510524f, 0.11359791f, 0.14199354f, 0.06685863f, 0.03613818f, 
    -0.41151661f, -0.14743295f, -0.00599591f, 0.25166240f, 0.20466830f, 0.11449336f, -0.07610362f, -0.03392616f, 
    0.17150436f, -0.05162268f, 0.04920857f, 0.01115959f, -0.23528130f, 0.10617315f, -0.01652228f, 0.35215059f, 
    -0.15220623f, -0.06768792f, 0.33538389f, 0.24291889f, -0.12253009f, 0.06070093f, -0.03892930f, 0.00878831f, 
    0.04913604f, -0.00387621f, -0.11110450f, -0.04654664f, 0.01508565f, -0.05473327f, -0.01904135f, 0.05256628f, 
    0.02743901f, 0.03163976f, 0.12304787f, 0.09757246f, -0.10205320f, 0.11625645f, -0.22969541f, -0.13676281f, 
    0.12892517f, 0.10540173f, 0.05953807f, 0.11937737f, -0.06163417f, 0.06743940f, 0.04163228f, 0.02295395f, 
    0.03056728f, 0.19338042f, -0.15600419f, -0.04952125f, 0.19021034f, 0.04957934f, 0.16780597f, 0.05703064f, 
    0.10184503f, 0.01072847f, 0.04434873f, -0.04484596f, 0.02860595f, 0.22769588f, 0.19578859f, 0.34502462f, 
    -0.36653984f, -0.12773797f, 0.17416313f, -0.04769907f, 0.04488577f, 0.02739735f, 0.04092831f, 0.03545699f, 
    0.21967024f, -0.04054951f, 0.18409026f, 0.12272465f, -0.02225958f, -0.05300882f, -0.06435569f, 0.11359438f, 
    0.01286188f, 0.10150767f, 0.06342661f, 0.07586050f, 0.12259442f, 0.05142855f, -0.02204582f, 0.00820317f, 
    0.23727366f, 0.15986726f, -0.16477086f, -0.06707220f, -0.06603318f, -0.09212860f, 0.09037271f, 0.11906979f, 
    -0.11665344f, 0.08194678f, 0.11578595f, -0.16543797f, -0.14626235f, 0.03894281f, 0.01510351f, -0.02105474f, 
    0.08020771f, 0.11560598f, -0.12902199f, 0.08153722f, 0.16053106f, 0.21444181f, 0.04841603f, 0.10626655f, 
    -0.09031781f, -0.02224590f, -0.10286983f, 0.12979499f, 0.06498624f, 0.07201698f, 0.00682458f, 0.12220808f, 
    -0.21061848f, -0.02559069f, -0.12451972f, 0.05891808f, -0.25020561f, 0.01811502f, -0.05635646f, -0.06639788f, 
    0.13944288f, -0.04608150f, 0.01543223f, -0.03324762f, 0.30182800f, -0.05151182f, -0.27189732f, 0.08246519f, 
    -0.00851398f, -0.05985831f, -0.07219662f, -0.06038168f, 0.10246267f, 0.03387070f, -0.01438497f, 0.06231674f, 
    -0.07630660f, -0.04884857f, 0.33845550f, -0.19804627f, 0.01228427f, 0.20531492f, 0.06479777f, 0.02012490f, 
    0.07178085f, 0.02408331f, 0.03887761f, 0.03214323f, -0.07795354f, -0.06113089f, -0.25845650f, 0.30165938f, 
    0.02588940f, -0.03655644f, -0.10865808f, 0.15269451f, -0.02055820f, -0.01635957f, -0.09826019f, 0.04203669f, 
    -0.27662030f, -0.02343371f, 0.06215813f, -0.16850722f, 0.02210699f, -0.04656638f, 0.00721540f, -0.26795495f, 
    0.13170001f, 0.24002838f, 0.01648211f, 0.03436394f, 0.24022211f, 0.21924065f, 0.16615982f, 0.22839428f, 
    0.02215231f, -0.04560630f, 0.01243316f, 0.04183454f, -0.00306253f, 0.02052328f, 0.11253333f, -0.04788739f, 
    0.01429399f, 0.03711269f, -0.02906022f, -0.07944709f, -0.00499611f, 0.02119991f, 0.04061370f, 0.03044899f, 
    0.01204540f, 0.03911848f, -0.03198219f, 0.02250911f, -0.00374438f, 0.04242371f, -0.02299293f, 0.04649204f, 
    -0.07510518f, -0.01308134f, -0.04060936f, -0.05534859f, 0.01683259f, -0.03917457f, -0.07554504f, -0.07436033f, 
    -0.00492461f, 0.01188815f, -0.07639535f, 0.03680984f, 0.04282651f, -0.04577372f, -0.06564309f, 0.02098327f, 
    -0.02163619f, -0.02499631f, -0.00587155f, -0.05500494f, -0.03397239f, -0.06651364f, 0.04540227f, 0.00579220f, 
    0.00661794f, -0.07176030f, -0.04899899f, -0.04878575f, -0.01104898f, 0.00818314f, -0.02515419f, -0.03855295f, 
    -0.03741147f, -0.01797111f, 0.00256900f, -0.01249535f, -0.00294972f, 0.04927103f, -0.02312692f, -0.01953359f, 
    -0.04335819f, -0.05599635f, -0.02013808f, -0.05667267f, -0.02736365f, -0.06396320f, -0.02309022f, -0.05687957f, 
    0.04849499f, 0.05543915f, 0.01435952f, 0.05641515f, 0.04713749f, -0.01494358f, 0.04744779f, 0.05132069f, 
    -0.02750132f, 0.02007213f, 0.03898073f, 0.03146354f, 0.00623382f, -0.05751998f, -0.06692677f, -0.00515011f, 
    0.05252954f, -0.06543892f, -0.03187731f, 0.01733481f, -0.05677339f, 0.03874661f, -0.00052978f, -0.01798889f, 
    -0.05283215f, 0.02647249f, -0.00166758f, 0.02001991f, 0.04117163f, -0.03729351f, -0.02845195f, 0.03257062f, 
    -0.04005110f, 0.01327042f, -0.06107084f, 0.02139555f, 0.03651753f, 0.01689499f, 0.00969962f, 0.00449740f, 
    -0.02210699f, -0.03867590f, -0.05031062f, 0.01820700f, 0.03475182f, 0.01061713f, -0.01745590f, 0.05789375f, 
    -0.06287144f, -0.01246612f, -0.02952256f, -0.06374035f, 0.04590369f, 0.03873871f, 0.00006702f, -0.02157890f, 
    0.02565886f, 0.03893907f, 0.06229980f, -0.03372678f, 0.01238527f, 0.05060015f, -0.02069401f, -0.04364730f, 
    -0.00031457f, 0.03910697f, -0.05968815f, 0.04267522f, 0.02037468f, -0.01753402f, -0.05911639f, -0.08251843f, 
    0.00232223f, 0.00265996f, -0.03962457f, -0.04989860f, -0.02054320f, -0.02385669f, 0.02465668f, 0.05469190f, 
    0.03634652f, 0.00830265f, -0.05118372f, -0.08327153f, 0.02566566f, 0.02212879f, 0.00600243f, 0.05352353f, 
    0.03925815f, -0.00990682f, -0.07512738f, -0.08185746f, -0.02877666f, -0.00322408f, -0.07934045f, 0.03089342f, 
    0.02465015f, -0.06356572f, 0.00936185f, -0.07313054f, -0.00630421f, -0.03436382f, 0.03752881f, 0.01061899f, 
    0.05843704f, 0.04745585f, -0.01319854f, -0.03008632f, -0.02279833f, 0.04702462f, 0.02118569f, 0.03986320f, 
    -0.02587198f, -0.03612596f, 0.04999704f, 0.02752546f, -0.01469245f, 0.02615039f, 0.02706543f, -0.02914558f, 
    0.01860096f, 0.02505911f, 0.01001802f, -0.05768064f, -0.03618601f, -0.03567497f, -0.06980743f, 0.01674630f, 
    0.03241095f, -0.07433794f, -0.04049315f, -0.04622574f, -0.05776808f, 0.05343272f, 0.01223401f, 0.02261103f, 
    -0.01213569f, 0.01263201f, 0.02384403f, -0.06638931f, -0.05986997f, 0.06025748f, -0.01641188f, -0.07212805f, 
    0.00019659f, -0.01118601f, -0.04613620f, 0.03189089f, 0.00358112f, -0.06079812f, 0.04170041f, 0.04826384f, 
    -0.05786952f, -0.04516374f, -0.05568178f, -0.04253573f, -0.02823599f, 0.02125171f, 0.00286208f, 0.01187703f, 
    -0.06797293f, -0.07338713f, 0.05221576f, 0.04598496f, 0.05471134f, -0.00139760f, -0.06539113f, 0.03914911f, 
    0.04542029f, 0.00859495f, -0.00992858f, 0.02212434f, 0.02092009f, 0.02780386f, -0.03897018f, 0.05236237f, 
    0.03955777f, -0.06978369f, -0.05303505f, -0.07172015f, -0.07044838f, -0.03692196f, 0.01662788f, -0.06235792f, 
    0.01086071f, -0.07313047f, 0.05669922f, -0.02046567f, 0.02658627f, -0.04876867f, 0.02124527f, 0.02555878f, 
    0.07147443f, -0.04954304f, 0.00507117f, -0.06359350f, 0.04974196f, -0.03371502f, -0.06092271f, -0.04734472f, 
    -0.00682145f, -0.01326571f, 0.05366709f, -0.04530572f, 0.03429470f, -0.00491862f, -0.03336943f, -0.03455725f, 
    -0.07720571f, -0.04808178f, -0.04763962f, -0.05130798f, -0.07367060f, 0.05764379f, 0.02532569f, -0.00806695f, 
    0.00372362f, -0.07570864f, -0.02034206f, 0.03183637f, -0.00722261f, 0.03279570f, 0.03877219f, -0.06907499f, 
    -0.05099806f, -0.01671127f, -0.01012919f, -0.03010575f, 0.01358165f, -0.01737788f, -0.05015101f, 0.05934273f, 
    0.04690788f, 0.03821645f, -0.04245650f, -0.06266023f, -0.04549205f, 0.04288210f, -0.07359921f, 0.06617775f, 
    0.01790757f, 0.04655342f, -0.03490782f, -0.03651619f, -0.01919226f, -0.00518171f, -0.07658508f, 0.03411805f, 
    0.00252546f, 0.06290632f, -0.05553202f, -0.03766092f, 0.01245466f, -0.07206152f, 0.03764012f, -0.04067926f, 
    -0.05355535f, 0.03376431f, -0.06787527f, 0.00221011f, -0.01015849f, -0.05528690f, 0.01246741f, -0.01864101f, 
    -0.07458321f, 0.01972406f, 0.04940613f, 0.02016702f, -0.00614693f, 0.02721510f, -0.01325330f, -0.02050048f, 
    -0.01572016f, -0.04433766f, 0.01709391f, -0.04201724f, -0.07272292f, 0.04868718f, -0.00559109f, 0.00467264f, 
    -0.05124407f, -0.04137987f, 0.04093973f, 0.00253390f, 0.00624767f, -0.00407340f, 0.00180709f, -0.04586269f, 
    -0.02330291f, 0.03475314f, 0.00744463f, -0.02227803f, 0.00836995f, 0.02368581f, 0.03735106f, -0.07405181f, 
    0.06047900f, -0.06607074f, 0.01324189f, -0.06376963f, -0.05092060f, 0.06193146f, -0.01220840f, -0.05563904f, 
    -0.02387756f, 0.03352085f, 0.01967438f, -0.04965534f, 0.00373004f, -0.04133151f, 0.04609931f, -0.03107726f, 
    0.02781453f, 0.06123669f, -0.06569930f, 0.02559746f, -0.00682723f, 0.05167726f, -0.03804012f, 0.02726973f, 
    -0.31191009f, 0.56826955f, 0.20029871f, -0.40632513f, 0.10336033f, 0.13041528f, -0.05555618f, -0.15047950f, 
    0.10631348f, 0.09920489f, 0.01716938f, -0.00314372f, -0.31926921f, -0.21488538f, 0.01286569f, 0.16441068f, 
    -0.17693910f, -0.09882441f, 0.13540350f, 0.04310542f, 0.13264744f, 0.11548418f, 0.19998461f, 0.16658726f, 
    -0.13723321f, 0.22311786f, 0.12621072f, -0.23244217f, 0.15890779f, -0.08821305f, -0.05006902f, -0.00330698f, 
    -0.13460536f, 0.00990158f, 0.15666656f, 0.21297875f, -0.08838727f, 0.16633093f, -0.03741083f, 0.02116799f, 
    -0.05627055f, 0.22955035f, 0.00024732f, -0.06871366f, -0.03983773f, -0.05277080f, 0.03977074f, 0.09073994f, 
    -0.70649970f, 0.22673848f, 0.23356542f, 0.04345770f, 0.09250677f, 0.07129099f, 0.18581331f, -0.04515693f, 
    0.04741070f, 0.17401221f, 0.13622864f, 0.16504684f, 0.00559859f, -0.26065746f, -0.16053440f, 0.22190700f, 
    -0.08287376f, -0.03606192f, 0.02261479f, 0.23770109f, -0.10169762f, -0.03846973f, 0.06328404f, 0.02825560f, 
    0.26618263f, -0.27964774f, -0.17234160f, 0.25778964f, -0.15045048f, -0.08638028f, 0.06040433f, 0.06812050f, 
    0.18424778f, 0.03219198f, 0.00940732f, 0.12889668f, 0.25317878f, -0.15197717f, -0.26426342f, 0.02919050f, 
    0.11241473f, 0.02826082f, -0.14901194f, -0.03021119f, 0.18802546f, 0.04415540f, 0.08181824f, 0.01996031f, 
    -0.03724864f, 0.01778618f, 0.15745141f, 0.44186631f, 0.12846598f, 0.05422435f, 0.13525546f, -0.03870251f, 
    0.10601816f, -0.05429762f, 0.05463672f, -0.15050407f, -0.13735576f, 0.21587718f, 0.05133029f, -0.32786497f, 
    -0.13382368f, -0.17680274f, 0.13769129f, -0.01928092f, -0.10164542f, -0.07976045f, -0.04050730f, -0.00616927f, 
    -0.22495924f, 0.26330814f, 0.24897845f, -0.13732293f, 0.04839646f, 0.16512662f, 0.06831586f, 0.02386532f, 
    0.00956160f, 0.07012127f, -0.11830009f, -0.03103101f, -0.19318801f, 0.11507620f, -0.22011408f, -0.16939618f, 
    0.29445744f, -0.00392195f, -0.00493955f, -0.03136050f, 0.04109207f, 0.05004151f, -0.00119684f, 0.18394463f, 
    0.36639833f, -0.32769138f, 0.05660662f, -0.11102023f, 0.11427723f, -0.00816071f, 0.10066623f, -0.13247104f, 
    -0.03006239f, 0.01551592f, 0.13844991f, 0.06206546f, -0.24591807f, -0.20646389f, -0.07592428f, 0.09564967f, 
    -0.04664150f, -0.06185135f, -0.07904173f, 0.06112308f, -0.07568680f, 0.06700423f, 0.01464104f, -0.00044889f, 
    0.25002465f, 0.21362728f, -0.11459852f, -0.54916871f, -0.03986164f, 0.38242143f, -0.00582690f, 0.00083865f, 
    0.04897881f, 0.02821532f, 0.03665868f, -0.04577815f, 0.37406951f, -0.27761143f, -0.10106211f, 0.26092973f, 
    -0.02947821f, -0.15058820f, -0.03959640f, -0.07623526f, -0.14505540f, 0.10169468f, -0.01743821f, -0.03655614f, 
    0.14150074f, -0.06772763f, 0.02591211f, -0.02790406f, 0.05094350f, -0.05907269f, -0.10305534f, -0.05864978f, 
    -0.03380962f, 0.12435398f, 0.03547859f, 0.27520970f, -0.06496755f, 0.14874940f, -0.25462016f, -0.08133484f, 
    0.01946172f, 0.09534631f, 0.12889628f, -0.02385874f, 0.13274127f, 0.12705113f, 0.07465888f, 0.08602859f, 
    0.10511237f, 0.08379255f, 0.08114725f, -0.22154050f, 0.06499761f, -0.02514036f, 0.02424727f, -0.08226661f, 
    0.03252454f, 0.01891675f, -0.05476493f, 0.04066127f, 0.14156049f, -0.08455379f, 0.00439700f, 0.36352336f, 
    -0.00202298f, 0.16246222f, 0.18116808f, 0.12276151f, 0.00249054f, 0.20159265f, -0.02999268f, 0.08851770f, 
    -0.29389688f, 0.14774735f, -0.04548660f, -0.00565386f, 0.17131577f, 0.11052097f, -0.00679459f, -0.08107001f, 
    0.02854601f, -0.14774373f, 0.08194657f, -0.11058069f, -0.25605625f, 0.07286065f, -0.02134048f, -0.03723690f, 
    -0.15257674f, 0.11279474f, 0.03475922f, 0.01658229f, 0.00987948f, -0.02315363f, -0.09012377f, 0.02592011f, 
    -0.41028193f, -0.06540853f, 0.02072486f, -0.02144009f, -0.12351625f, -0.19343138f, 0.00149170f, 0.20927687f, 
    0.05187790f, 0.07115863f, 0.17939915f, 0.02642978f, 0.21628425f, -0.49110052f, 0.09274658f, 0.16914853f, 
    -0.11318461f, -0.03865557f, -0.04118121f, -0.04485458f, 0.06303789f, -0.02707851f, 0.05433675f, 0.02712957f, 
    -0.17727853f, 0.00018638f, 0.05875005f, 0.13007227f, 0.06507496f, 0.15159497f, 0.13195130f, 0.13254511f, 
    0.02462336f, -0.05622538f, 0.03331808f, -0.09193495f, 0.19918965f, -0.04971835f, -0.14893891f, 0.11911405f, 
    0.09067069f, 0.05569446f, -0.02763846f, 0.08009107f, 0.15373489f, -0.01655262f, 0.02182190f, 0.04507938f, 
    0.21902780f, -0.09091089f, 0.09922036f, 0.21061771f, -0.08609970f, 0.27618560f, -0.13150033f, 0.07838830f, 
    0.06095589f, -0.01732011f, -0.11708754f, 0.01635827f, -0.29246315f, 0.04950495f, -0.20033188f, -0.35242984f, 
    -0.02209428f, 0.04792495f, 0.05560558f, 0.14712021f, 0.09484597f, 0.03074770f, -0.08131155f, 0.21727103f, 
    -0.09498879f, 0.41806784f, 0.21773233f, -0.12042895f, -0.02518254f, 0.24396420f, 0.02497139f, -0.09156263f, 
    -0.08011982f, 0.06289193f, -0.05375655f, -0.12914473f, 0.47099799f, 0.07236730f, 0.09154565f, 0.38641658f, 
    0.00195936f, -0.00324007f, 0.08554795f, -0.04473641f, 0.09950396f, 0.00416203f, 0.30318865f, 0.22578388f, 
    0.04317915f, -0.28416079f, 0.12316693f, 0.47834155f, -0.07408118f, -0.13469443f, -0.04377677f, -0.18306842f, 
    0.02344451f, -0.13888110f, -0.08278546f, 0.00470958f, -0.15233079f, 0.10900208f, 0.11766738f, -0.08056740f, 
    0.10674684f, 0.09355385f, 0.08622975f, 0.11303893f, 0.05900033f, -0.17790478f, 0.02446234f, -0.07579780f, 
    -0.03748238f, -0.24447884f, -0.09266122f, -0.13932745f, -0.29154351f, 0.03748446f, -0.18161027f, -0.00113856f, 
    -0.30699605f, 0.03136053f, -0.13394053f, 0.00510822f, 0.52288640f, 0.38963190f, -0.17103070f, -0.26185676f, 
    0.34595129f, 0.15732758f, 0.12552138f, -0.04943175f, -0.08204532f, -0.02547267f, 0.07886860f, -0.04163028f, 
    -0.08656945f, 0.09282349f, -0.32424846f, 0.21674997f, -0.15678605f, -0.07608203f, -0.11640055f, -0.17371894f, 
    0.05221371f, 0.05883715f, 0.16099413f, -0.06469255f, -0.18980916f, 0.24897541f, 0.35585436f, -0.19274482f, 
    -0.07130115f, -0.10269163f, 0.00642147f, 0.13830329f, 0.11705519f, -0.04296731f, -0.08101580f, 0.10941499f, 
    -0.18707082f, -0.12515166f, -0.13056955f, 0.23159720f, -0.10903324f, -0.15057185f, 0.11941847f, -0.31043068f, 
    -0.00248635f, 0.00383789f, 0.07179934f, 0.02274336f, 0.39064452f, 0.24841458f, 0.04765741f, -0.24981877f, 
    0.06947756f, 0.05419061f, -0.16895153f, 0.20773025f, -0.06601457f, 0.13607761f, -0.02818102f, 0.07666937f, 
    0.29698461f, 0.00046057f, -0.19131421f, 0.05500301f, 0.09586307f, 0.06968166f, -0.13935700f, 0.21174753f, 
    0.10760001f, 0.25941440f, -0.03197753f, -0.10013869f, -0.02970666f, -0.18526635f, -0.01699592f, -0.30273458f, 
    -0.11314949f, -0.12170506f, -0.01842846f, 0.09556162f, 0.08532218f, -0.18633260f, 0.00450991f, -0.03260660f, 
    -0.24855961f, -0.03195308f, 0.26744688f, -0.37369633f, -0.01334494f, -0.03853745f, -0.00983829f, -0.04073625f, 
    -0.10659865f, 0.00714550f, 0.06301297f, 0.08223291f, 0.19011578f, -0.24821793f, -0.00569125f, 0.05842398f, 
    0.15615638f, -0.02230507f, 0.08630168f, -0.04167746f, -0.08886506f, 0.00052844f, 0.00032091f, 0.10625011f, 
    0.23379849f, 0.10403296f, -0.00421817f, 0.24762395f, 0.08232047f, -0.20754999f, -0.12524350f, 0.10962181f, 
    0.08649506f, 0.09164684f, -0.00138933f, -0.06742074f, 0.02474250f, -0.04789468f, -0.18147969f, -0.09281799f, 
    0.12731543f, -0.11593039f, -0.24820021f, -0.19121283f, -0.14104858f, -0.00535585f, -0.14980802f, -0.01861464f, 
    0.25604135f, 0.07129663f, 0.15186124f, 0.27251908f, 0.04415622f, 0.05783213f, -0.08401704f, 0.08328678f, 
    -0.03913619f, -0.04705405f, -0.08319180f, -0.07027268f, 0.04827913f, 0.07296591f, 0.25632414f, -0.05566851f, 
    0.04169057f, 0.15947156f, 0.10074221f, 0.01139744f, 0.00247912f, -0.08080048f, 0.09701560f, 0.07754183f, 
    0.14174135f, 0.07987078f, 0.32265714f, 0.14805633f, 0.00441814f, -0.06626740f, -0.08122197f, -0.07225528f, 
    -0.00497581f, -0.12712015f, 0.24688274f, 0.06762706f, 0.75806415f, 0.48288962f, 0.20408992f, -0.26278692f, 
    0.25322753f, 0.20437452f, -0.03237333f, 0.02829399f, 0.12176676f, -0.09013383f, -0.01440286f, 0.09102300f, 
    0.20645048f, 0.42817304f, 0.34964734f, 0.18415332f, -0.12099812f, 0.09815975f, -0.08196964f, -0.11159229f, 
    -0.05191351f, -0.04421310f, 0.04117465f, -0.02032270f, 0.10759670f, 0.00515054f, -0.05182661f, -0.08790795f, 
    0.18699516f, -0.21119528f, -0.04053216f, 0.20951071f, -0.03430490f, 0.11470453f, 0.28513822f, 0.05790699f, 
    -0.10242635f, 0.37057850f, -0.04374488f, 0.50778526f, -0.01932872f, -0.14633027f, -0.16283774f, -0.17549625f, 
    0.15945305f, 0.00872748f, -0.06969650f, 0.20041084f, -0.28343624f, 0.09213642f, 0.02538915f, -0.27831006f, 
    0.06978094f, -0.04108563f, -0.00544093f, 0.09615064f, 0.14827769f, -0.13482159f, -0.06666154f, 0.16052005f, 
    0.06712782f, 0.34373438f, 0.09127133f, 0.26560909f, -0.08440142f, 0.02907676f, 0.18378250f, -0.04954356f, 
    -0.11062765f, 0.15335372f, 0.02905876f, 0.04517917f, 0.05017334f, -0.25600642f, -0.27168649f, -0.13717780f, 
    0.21063058f, -0.12092696f, -0.10319228f, 0.34773427f, 0.05533035f, 0.09804775f, 0.10962495f, -0.13126963f, 
    0.16491957f, 0.11711895f, -0.33473831f, -0.04465906f, 0.15964420f, 0.10020252f, 0.04067550f, 0.00657708f, 
    -0.02976684f, 0.02686447f, 0.13557820f, -0.03281515f, 0.09610247f, -0.05761281f, 0.04123300f, 0.01358060f, 
    0.12503402f, 0.07723927f, 0.14378954f, 0.02722481f, -0.00229234f, 0.12203389f, 0.14947435f, 0.07126780f, 
    0.03498720f, 0.14211516f, 0.05898114f, -0.26719385f, 0.08404116f, 0.17517790f, 0.13240081f, 0.09920122f, 
    -0.00516920f, 0.06465339f, 0.12022804f, 0.09179760f, -0.63375574f, -0.37480202f, -0.22652628f, -0.29499871f, 
    0.19842805f, 0.02056084f, 0.01076035f, -0.00130516f, -0.07136632f, 0.01586022f, -0.10425903f, -0.00994700f, 
    -0.22349060f, -0.00181251f, 0.10736071f, -0.03068081f, 0.01110372f, 0.06530001f, 0.11872713f, 0.08566634f, 
    0.12268329f, -0.03489525f, 0.08357935f, 0.04496120f, 0.45957822f, 0.41848865f, 0.16260424f, 0.40114164f, 
    0.17632850f, -0.19654027f, -0.04733063f, -0.42248237f, -0.00697289f, 0.00180770f, 0.18313920f, 0.04362574f, 
    -0.11207343f, -0.43838704f, -0.24243364f, 0.13680232f, 0.12807445f, -0.15935059f, -0.05810090f, 0.05608100f, 
    0.00876335f, -0.06518880f, 0.05421117f, 0.07743225f, -0.40366068f, -0.26961848f, -0.06783129f, -0.19614297f, 
    -0.05225251f, 0.11261681f, 0.06877335f, -0.05704581f, 0.10955193f, 0.12861197f, -0.13563922f, 0.02795664f, 
    -0.09872755f, 0.02626211f, 0.12171461f, -0.21436432f, 0.01397269f, -0.07799681f, 0.03543627f, 0.05081910f, 
    0.03095559f, 0.02495842f, 0.09653451f, 0.13341402f, -0.31519526f, -0.44030577f, 0.03596072f, -0.25357786f, 
    0.25185317f, -0.01066909f, 0.07422934f, 0.03024953f, -0.04623121f, -0.00704702f, -0.05498910f, -0.00083338f, 
    0.05478127f, 0.45648602f, 0.21316183f, -0.03480355f, -0.22654910f, -0.08743057f, 0.00872338f, 0.03807180f, 
    -0.07064013f, 0.14144804f, 0.07156911f, -0.03220087f, -0.00649079f, -0.22642249f, 0.08148430f, -0.03574202f, 
    -0.03173622f, 0.03551598f, -0.20592219f, -0.02107651f, 0.10681769f, -0.11266988f, -0.14263290f, 0.06703185f, 
    -0.04947596f, 0.16925113f, 0.06050507f, -0.01822077f, 0.24783845f, -0.02274096f, 0.03003629f, 0.11284062f, 
    0.03596329f, 0.03631174f, 0.02094255f, 0.14891160f, 0.06697933f, -0.18218435f, 0.05013632f, 0.01946554f, 
    -0.21438110f, -0.06581890f, 0.02320005f, -0.16273157f, 0.10995280f, -0.10878702f, 0.12390774f, 0.02450001f, 
    0.11043523f, -0.03279221f, 0.30906686f, 0.10124896f, -0.07863081f, 0.12412198f, 0.02946010f, 0.02282768f, 
    -0.21969208f, -0.06849478f, -0.03133602f, -0.04129485f, -0.17787977f, -0.15726461f, -0.19094762f, -0.10079645f, 
    0.05305295f, -0.02377534f, 0.00104327f, 0.02737068f, 0.03494683f, 0.02826837f, 0.00653428f, -0.00714482f, 
    -0.08613687f, 0.13380094f, -0.22740318f, 0.08200225f, -0.04025502f, 0.27800956f, 0.08007984f, -0.10578958f, 
    0.06482246f, -0.20893034f, -0.02245875f, -0.01067456f, -0.00723013f, 0.40407583f, 0.06027592f, 0.24224474f, 
    -0.09122760f, 0.02896681f, 0.22298616f, -0.09837259f, 0.00412051f, 0.17826360f, 0.03697558f, 0.05607311f, 
    0.05364967f, 0.06172483f, -0.27126423f, 0.39511353f, 0.07911403f, -0.13905264f, 0.17732756f, -0.10375386f, 
    0.17229657f, -0.01083708f, 0.17879397f, -0.04317400f, -0.25040370f, -0.04926594f, -0.01442869f, -0.09679064f, 
    0.00495967f, 0.05936171f, 0.02928947f, 0.05503561f, 0.05741354f, -0.03775713f, 0.15256722f, -0.08397926f, 
    -0.07731491f, 0.04440494f, 0.12224270f, -0.04598146f, 0.05680259f, -0.05649987f, 0.02121240f, -0.18135953f, 
    0.02649616f, 0.13083565f, 0.08848346f, 0.36738798f, -0.09265578f, 0.35006180f, 0.26544932f, 0.02412634f, 
    -0.04503519f, 0.10191029f, 0.04085521f, 0.02722309f, -0.01378971f, 0.01953158f, 0.16959496f, 0.07541028f, 
    0.13050610f, -0.13876243f, -0.29659361f, 0.04495776f, 0.03273380f, -0.10304087f, -0.00280585f, -0.05595463f, 
    0.03699152f, -0.15311868f, 0.00960418f, -0.07986799f, -0.05538856f, -0.09288675f, 0.08304030f, -0.29280490f, 
    0.11397275f, -0.05029065f, 0.04171666f, 0.07810888f, 0.10340641f, 0.02759041f, 0.13693452f, -0.14267112f, 
    -0.03658642f, 0.00966539f, -0.06966998f, -0.10990949f, -0.02674871f, 0.04613001f, 0.08652771f, 0.08485566f, 
    -0.05359659f, -0.14150283f, -0.05969623f, 0.14372268f, -0.01468212f, -0.22931494f, -0.20616712f, -0.00896732f, 
    -0.27621526f, 0.00235402f, 0.25289696f, -0.08423886f, 0.14991553f, 0.13213931f, -0.05704978f, 0.00750716f, 
    -0.74232197f, -0.26894003f, 0.23925532f, 0.15580350f, -0.06821261f, -0.06305075f, -0.12198449f, 0.02099257f, 
    0.20467423f, -0.12643963f, 0.08310481f, 0.19477198f, -0.07034527f, -0.22745654f, -0.05460764f, 0.38542366f, 
    0.27153614f, -0.12823066f, 0.17307025f, 0.15856275f, -0.08662957f, -0.04141057f, 0.03163056f, 0.05137391f, 
    0.07475293f, 0.18795662f, -0.08488458f, 0.20132536f, -0.15019755f, -0.10283470f, -0.04133770f, 0.12418742f, 
    0.18484157f, 0.25397828f, 0.09630508f, -0.03870284f, -0.03087642f, -0.39108092f, 0.02293804f, -0.11419831f, 
    0.01785965f, -0.08305246f, 0.27485168f, 0.02129987f, -0.21121986f, -0.04827332f, 0.09944126f, -0.05535258f, 
    0.08289001f, -0.35821059f, -0.15455988f, 0.09558795f, 0.18261243f, 0.09888190f, 0.07177274f, -0.17423879f, 
    0.06530042f, 0.02303995f, -0.06178020f, 0.00542204f, 0.23157240f, 0.34158149f, 0.24163915f, 0.14407516f, 
    -0.06126019f, -0.02139621f, 0.20911145f, 0.00763483f, 0.10847235f, 0.05113949f, 0.19381925f, -0.01638749f, 
    0.10425267f, 0.12714264f, -0.07382441f, 0.11347450f, -0.17709084f, -0.04462034f, -0.20390642f, 0.20112239f, 
    -0.09707103f, -0.00031531f, -0.09438960f, 0.07989759f, 0.07253713f, 0.37323940f, -0.16493651f, -0.38339394f, 
    -0.00602247f, 0.04886094f, -0.01801368f, -0.02368643f, 0.01402275f, -0.14555384f, 0.03128842f, 0.05964914f, 
    -0.11931963f, -0.57608318f, 0.60832334f, -0.29440933f, -0.14665973f, 0.15179403f, 0.03488154f, -0.05804611f, 
    -0.08933166f, 0.01341110f, -0.08731452f, 0.03845436f, 0.43970701f, 0.00422397f, 0.00335798f, 0.39479357f, 
    0.01251918f, 0.00709971f, 0.05158874f, 0.28556558f, -0.00990906f, -0.02306753f, 0.05633249f, 0.20809960f, 
    0.24163941f, -0.00394923f, -0.06046367f, 0.16591281f, -0.14513086f, 0.01161980f, 0.00497547f, -0.15702499f, 
    0.16378836f, -0.04006268f, 0.12382610f, 0.07753762f, 0.20646171f, -0.03318381f, -0.32058424f, -0.05775878f, 
    0.14598469f, -0.21976593f, 0.04160640f, 0.10138496f, -0.02620306f, 0.15270504f, 0.01427960f, 0.08731754f, 
    -0.04760904f, 0.20672026f, -0.13275713f, -0.03679445f, -0.01662041f, 0.16876267f, -0.07693432f, 0.22671163f, 
    -0.10396609f, 0.12340657f, 0.00145278f, -0.00171722f, 0.39690396f, -0.12700869f, -0.03488636f, 0.09269066f, 
    -0.12153599f, 0.08073726f, -0.02447536f, 0.12904064f, 0.03819530f, -0.15974209f, -0.12546034f, 0.06480237f, 
    -0.01945739f, 0.02859548f, 0.42272177f, -0.09870164f, -0.11270650f, -0.05753294f, 0.05097578f, -0.31116435f, 
    -0.01121220f, 0.20211321f, 0.08999261f, -0.17095976f, 0.13282295f, 0.32407194f, -0.05713696f, -0.00984667f, 
    0.09005913f, -0.13468869f, -0.05990734f, 0.23062772f, -0.11793786f, 0.05174233f, 0.03034273f, -0.10746343f, 
    0.46212217f, -0.07879571f, 0.13762602f, 0.23734751f, -0.14850034f, -0.19702907f, 0.12009995f, 0.15440579f, 
    0.01528982f, -0.00104845f, 0.07871132f, 0.07158186f, 0.10728672f, -0.06248335f, 0.01687452f, -0.12953229f, 
    0.17013453f, 0.02936436f, -0.28029966f, -0.06786248f, 0.03398341f, -0.12213340f, -0.04950922f, -0.00351560f, 
    0.18692094f, 0.03242678f, 0.07023512f, 0.13737474f, -0.01127551f, 0.13856316f, 0.15298466f, 0.10366837f, 
    0.12808411f, 0.07421499f, -0.09114861f, -0.18451956f, 0.18876323f, -0.39577329f, 0.03929741f, 0.00942056f, 
    -0.08189619f, -0.05366605f, -0.00099792f, -0.03849661f, -0.05311770f, -0.03029787f, 0.10434979f, -0.06695098f, 
    0.52550334f, -0.18481378f, 0.07102458f, 0.06880080f, -0.05686716f, -0.07167669f, -0.10980873f, 0.05307899f, 
    0.03511077f, -0.05577788f, -0.03071718f, -0.02804515f, 0.02824601f, 0.19996464f, -0.06579957f, -0.15843369f, 
    0.16787341f, 0.05708858f, -0.02373552f, -0.09187344f, 0.13697012f, 0.08385402f, 0.07240201f, -0.04304983f, 
    -0.44707319f, 0.31487224f, -0.02852929f, -0.31181565f, -0.00346268f, 0.11656991f, -0.01208809f, 0.13122693f, 
    -0.16993389f, -0.15724997f, -0.12095857f, 0.06687086f, -0.06786969f, 0.20748393f, 0.26637313f, 0.03631086f, 
    -0.08687129f, -0.10064748f, 0.12476388f, 0.08117622f, -0.10978313f, 0.07947192f, -0.08873203f, 0.03725705f, 
    0.19213259f, -0.08169384f, -0.10770728f, -0.15900022f, -0.07138252f, 0.04986313f, 0.06218905f, -0.01531781f, 
    0.01635809f, 0.03411605f, -0.05480562f, 0.07384521f, 0.10829781f, -0.10688081f, -0.00027489f, 0.18303096f, 
    0.13658284f, 0.14194848f, -0.02396732f, 0.01475528f, 0.03266730f, -0.04079829f, 0.20973161f, -0.08709268f, 
    0.18030521f, -0.17303266f, -0.10129968f, 0.04555048f, 0.03654863f, -0.11834980f, -0.00548484f, -0.14232090f, 
    0.08384276f, -0.01474482f, 0.01347764f, 0.06501369f, 0.20247744f, 0.07368815f, 0.18663560f, 0.04238919f, 
    -0.20706832f, 0.02404822f, 0.02921541f, 0.13990636f, 0.06135337f, -0.03249875f, 0.03074850f, 0.04204443f, 
    -0.28941971f, 0.34713843f, -0.37670338f, 0.04846511f, 0.12483682f, 0.04605538f, 0.04090381f, 0.07210367f, 
    0.06841811f, -0.03656977f, -0.03943602f, 0.04066166f, 0.43829462f, 0.02196718f, 0.08726669f, -0.09108017f, 
    0.03100196f, -0.04920848f, 0.16238740f, -0.07255412f, 0.00527936f, -0.02671514f, 0.02985890f, 0.17545862f, 
    -0.15513317f, -0.21317570f, 0.04070828f, 0.38187137f, -0.15267809f, -0.18702121f, -0.03348853f, 0.08555890f, 
    -0.10945582f, -0.07143991f, -0.06522648f, 0.06636170f, -0.47294244f, -0.05022423f, -0.16649921f, -0.25241798f, 
    -0.05685003f, 0.17608568f, 0.09001170f, 0.03668059f, 0.11847866f, -0.00200414f, -0.07133829f, -0.08608610f, 
    -0.15048470f, -0.06276742f, -0.09747257f, 0.07240877f, 0.19280447f, 0.19632028f, -0.00302954f, -0.24840400f, 
    -0.04316693f, -0.00929121f, 0.04905952f, -0.05231428f, -0.15308973f, -0.08369289f, 0.10653858f, 0.10769589f, 
    -0.39587402f, -0.06535754f, 0.09838046f, 0.17475720f, 0.00856737f, -0.18411389f, -0.01704328f, 0.00223094f, 
    -0.16698976f, -0.28823677f, 0.00372904f, -0.22384427f, 0.04508294f, -0.08130298f, -0.06786320f, -0.04786434f, 
    0.10465308f, -0.03720170f, 0.13603611f, 0.30834636f, 0.00102248f, 0.38942149f, -0.34446380f, 0.09182411f, 
    0.11398360f, 0.12567009f, -0.27022246f, -0.08246627f, 0.11437549f, -0.05678893f, 0.08277132f, 0.08954266f, 
    -0.12298530f, 0.12379683f, -0.07255118f, -0.05113546f, 0.02859345f, -0.11730424f, 0.18906379f, 0.07120080f, 
    0.14148644f, 0.17481574f, 0.00363583f, 0.23491809f, 0.12060558f, -0.04048510f, -0.00400380f, 0.36657172f, 
    -0.25484988f, -0.18945423f, -0.02670701f, 0.05965110f, -0.12644380f, -0.08550154f, 0.05666209f, 0.00034727f, 
    0.55847335f, -0.14131510f, 0.16699137f, 0.12880681f, -0.01836135f, 0.17257905f, 0.12872037f, -0.01353646f, 
    -0.00983404f, 0.13513047f, -0.07441905f, 0.04370038f, 0.00090185f, 0.21068981f, -0.02298007f, 0.13077453f, 
    0.26473510f, 0.28491452f, -0.20979175f, 0.06014774f, 0.00629517f, -0.01391777f, -0.03409958f, 0.20500229f, 
    0.11391558f, 0.30568257f, -0.16375890f, 0.12354965f, -0.00448381f, -0.06548679f, -0.07069657f, -0.06032071f, 
    0.08910701f, 0.06694680f, 0.02818287f, 0.08679008f, -0.12679717f, 0.38177136f, 0.15964048f, -0.19137615f, 
    -0.01120836f, 0.06036756f, 0.01695858f, -0.19091192f, 0.04971870f, 0.02268606f, -0.04626831f, -0.08762765f, 
    -0.25716650f, 0.19944407f, -0.15451056f, -0.34723359f, -0.08483404f, -0.15249401f, 0.10644621f, 0.00200837f, 
    -0.09247074f, 0.22500598f, 0.02951451f, 0.10856105f, 0.10501637f, -0.15585028f, 0.15422650f, 0.09820044f, 
    0.18038715f, -0.03202998f, -0.15699200f, -0.15472490f, -0.06339584f, -0.01240199f, 0.17179780f, -0.11829884f, 
    0.20787300f, -0.42577505f, 0.26677465f, -0.20404261f, -0.05225197f, -0.02813791f, -0.09363443f, -0.11440186f, 
    0.13834764f, -0.06849943f, 0.14560251f, 0.19524750f, -0.49371889f, -0.12005233f, -0.19363813f, 0.01907536f, 
    0.06743844f, -0.11242998f, -0.00088147f, 0.06239778f, 0.11418826f, 0.10661345f, -0.05952410f, -0.04846414f, 
    0.00437472f, 0.40812403f, -0.39238933f, -0.40166938f, 0.09522089f, 0.25006717f, 0.04048556f, 0.13366812f, 
    0.10616160f, 0.26155484f, -0.04883237f, 0.13257508f, 0.11028608f, 0.04160348f, 0.10115357f, 0.25112644f, 
    -0.25331330f, -0.11109927f, 0.10670976f, -0.06780702f, 0.05393703f, 0.16828585f, 0.08987446f, 0.06689233f, 
    0.01419835f, -0.07272781f, 0.00378377f, -0.03204089f, -0.02486695f, -0.02943386f, -0.03202756f, 0.02377023f, 
    0.02209531f, -0.08901004f, -0.04548189f, 0.00881503f, -0.07707474f, -0.06629834f, -0.02072689f, -0.06933068f, 
    -0.06835958f, -0.02735762f, -0.06617878f, -0.04999270f, -0.07883839f, 0.01562734f, 0.05101689f, 0.05171163f, 
    -0.03424120f, -0.03090392f, -0.04398330f, -0.06941199f, -0.06852882f, 0.01161818f, -0.06955674f, -0.01139247f, 
    -0.01816360f, 0.01078238f, -0.05815245f, -0.03995759f, 0.03608744f, -0.00157347f, 0.02568856f, 0.05792237f, 
    0.00825130f, -0.00365382f, 0.04632363f, 0.02038775f, -0.06422167f, -0.04116197f, 0.03296045f, -0.06040928f, 
    -0.00153646f, 0.05089334f, 0.02990689f, 0.00377487f, -0.07187366f, -0.02290903f, 0.02696535f, 0.03465813f, 
    -0.02932158f, -0.03586910f, -0.01057662f, -0.06395148f, -0.07788254f, 0.02281919f, -0.07047419f, 0.01233233f, 
    0.03351365f, -0.00822333f, 0.03655537f, -0.00746394f, 0.01309887f, -0.01799091f, -0.00039603f, 0.02287375f, 
    0.05055375f, 0.01804368f, 0.02600391f, -0.06775633f, -0.08752363f, 0.05792337f, -0.02840511f, 0.00656356f, 
    0.03082470f, 0.03939020f, 0.02761262f, -0.01333749f, 0.06269769f, -0.03239132f, -0.02817826f, -0.07088967f, 
    -0.04161164f, -0.03612529f, -0.04758696f, -0.00004092f, -0.01569339f, -0.03189622f, 0.00658829f, -0.00110733f, 
    -0.07680900f, -0.01724199f, 0.01456850f, -0.08071782f, -0.03824289f, 0.04654763f, -0.02261489f, -0.03268846f, 
    -0.07710124f, 0.03196997f, 0.06102102f, -0.00941947f, -0.04626399f, 0.04840803f, 0.05012598f, -0.02639381f, 
    0.04586795f, -0.04794952f, -0.06012402f, 0.03537378f, 0.01313089f, -0.01222238f, -0.05616052f, -0.07880905f, 
    -0.07161769f, -0.02487876f, 0.03285369f, -0.03041355f, 0.01363617f, -0.02614856f, -0.06049631f, 0.01372025f, 
    -0.01860294f, 0.06373804f, -0.00341001f, -0.06584138f, -0.06309897f, -0.03123042f, 0.04876988f, -0.01652797f, 
    0.00672982f, -0.00747949f, 0.06148849f, 0.03472163f, 0.01453714f, 0.01433035f, -0.07766592f, -0.05497595f, 
    0.05889574f, 0.01386694f, 0.03349873f, -0.05083893f, 0.04210511f, -0.00513447f, -0.01776682f, 0.00636560f, 
    -0.03364945f, 0.02107664f, -0.01988647f, -0.06091761f, -0.07121983f, -0.06959518f, -0.03330687f, -0.00929245f, 
    -0.06655552f, -0.06661014f, 0.04833709f, 0.03426235f, -0.01355885f, -0.05389934f, 0.04557243f, 0.03244862f, 
    -0.07815021f, -0.08281150f, -0.02010201f, -0.04032113f, -0.00291537f, -0.04854078f, -0.06256892f, -0.02601591f, 
    -0.08449360f, -0.02457279f, 0.04609549f, 0.03688625f, -0.06423903f, -0.02702521f, 0.02271188f, -0.02195636f, 
    -0.05880650f, -0.00082805f, 0.04941298f, -0.07471099f, 0.04386109f, -0.04691550f, -0.05808149f, -0.00540458f, 
    0.13135791f, 0.06542833f, -0.01906140f, 0.56718701f, -0.18132339f, -0.10313796f, -0.02899149f, 0.05965327f, 
    0.16189410f, 0.12814456f, 0.00103493f, -0.06948665f, -0.06161861f, -0.09496690f, -0.10916792f, -0.14130148f, 
    -0.01193894f, 0.04371644f, 0.07751587f, -0.08009293f, -0.02027133f, 0.07719637f, 0.00522153f, 0.18775339f, 
    0.08104442f, 0.03248649f, 0.03763508f, -0.03084126f, 0.15845761f, 0.03595935f, 0.08175156f, 0.13552044f, 
    -0.10532603f, 0.16291708f, 0.18307811f, 0.06481360f, 0.12272546f, -0.20352039f, -0.10725091f, -0.16434383f, 
    0.01119466f, -0.03078257f, 0.05492469f, -0.03263097f, 0.03496803f, 0.09986057f, -0.10528517f, 0.03636203f, 
    0.28454638f, -0.50032628f, 0.05123370f, 0.01485328f, 0.09172904f, 0.12019753f, -0.09021237f, 0.23105893f, 
    0.02719670f, 0.01521753f, 0.08702740f, -0.02901173f, -0.62350059f, 0.21013533f, -0.16338518f, -0.24196394f, 
    -0.00602318f, 0.02444858f, 0.18061891f, 0.04895930f, 0.11254402f, 0.01785688f, -0.14578429f, 0.11575466f, 
    -0.56297517f, 0.14561307f, 0.12153211f, 0.29627001f, 0.12557912f, -0.03369452f, 0.08398405f, -0.13084479f, 
    -0.08668409f, 0.07946963f, 0.14980185f, 0.13920191f, 0.06635338f, 0.79654998f, 0.06704827f, -0.16269466f, 
    0.00605729f, -0.15074117f, 0.01749827f, 0.06474845f, 0.09223933f, 0.09876037f, 0.01336176f, -0.03855799f, 
    -0.18627961f, -0.05754993f, -0.33956024f, 0.20094626f, -0.00870759f, 0.04226776f, 0.03889891f, 0.00365153f, 
    0.07630315f, -0.02938253f, 0.12364312f, -0.04118178f, -0.15911952f, -0.20821813f, -0.17636755f, -0.28271589f, 
    -0.23745184f, -0.28873041f, 0.02400140f, 0.02230559f, 0.05218512f, -0.02021185f, 0.12613885f, 0.01599957f, 
    0.32378149f, 0.08140324f, -0.06055578f, 0.25663516f, 0.07703457f, 0.03126888f, -0.02825981f, 0.03032083f, 
    -0.00053374f, 0.02396895f, 0.00420727f, 0.13505800f, 0.03944020f, -0.23489973f, -0.05469698f, -0.07151365f, 
    -0.18274948f, -0.03035045f, 0.11715541f, 0.22294858f, -0.11697360f, 0.16832554f, 0.01271809f, -0.05696900f, 
    -0.03328290f, 0.13208447f, 0.10263647f, -0.21697655f, -0.15259202f, 0.06887967f, -0.02635742f, 0.08623130f, 
    0.05103146f, 0.07689847f, 0.15566316f, -0.24946278f, 0.07352241f, 0.16374886f, 0.34190640f, -0.15671112f, 
    0.05739234f, -0.18826635f, -0.04902591f, 0.01036495f, 0.09111378f, 0.08443554f, 0.05271059f, -0.06343530f, 
    -0.14868671f, 0.34118927f, 0.19957380f, 0.05944079f, 0.19513494f, 0.11279923f, 0.01641715f, 0.03507880f, 
    -0.01980999f, -0.12600322f, -0.09971970f, 0.09787294f, 0.51351905f, 0.07721149f, -0.11264724f, -0.12054287f, 
    -0.34159842f, -0.05654463f, -0.03136982f, 0.05595917f, 0.00962421f, 0.05949705f, -0.09820890f, 0.01680439f, 
    -0.46930093f, -0.47300145f, -0.16959238f, 0.04579503f, 0.18071368f, -0.02539349f, -0.05845392f, -0.04619817f, 
    -0.01800817f, -0.00066681f, 0.03964722f, 0.11991649f, 0.16540466f, 0.12822403f, -0.12492367f, -0.24276924f, 
    -0.23241207f, 0.18244331f, 0.21881050f, -0.29271504f, 0.00358443f, -0.04792029f, -0.11648351f, -0.00077812f, 
    0.06301245f, -0.49146017f, 0.18271068f, -0.23278776f, -0.04633877f, -0.03858595f, 0.00920756f, -0.02871799f, 
    0.10723437f, -0.02514094f, -0.04218648f, 0.09887714f, 0.28433451f, 0.12097079f, -0.14759298f, 0.48993376f, 
    0.06919771f, 0.22862637f, -0.21411985f, 0.12050693f, 0.04476777f, 0.14138047f, -0.03626703f, -0.08211906f, 
    -0.29832762f, -0.15146305f, -0.09898388f, -0.07223286f, 0.04896984f, -0.02296244f, 0.04764701f, -0.06137679f, 
    0.28402415f, -0.02650623f, 0.06997323f, 0.07610183f, -0.00007514f, 0.01777102f, 0.02766088f, 0.08584404f, 
    -0.18741350f, 0.21531186f, -0.02323408f, -0.22035794f, -0.06195255f, 0.11466584f, -0.10071403f, -0.10057902f, 
    0.07898752f, -0.18223558f, 0.17759340f, 0.00234429f, -0.01458961f, -0.00075920f, 0.09867748f, 0.06228660f, 
    0.13204819f, 0.07963382f, -0.16352198f, 0.10123559f, -0.23525959f, 0.04858162f, 0.11676469f, -0.03449149f, 
    0.19709072f, 0.01041923f, -0.19779170f, 0.06872829f, 0.01513065f, 0.03496623f, -0.17913100f, -0.01612467f, 
    -0.27063742f, 0.03030024f, -0.26968285f, 0.28944612f, -0.07277352f, -0.04515188f, -0.15789874f, 0.02555730f, 
    0.08523753f, 0.07590059f, -0.04408248f, 0.02787546f, 0.25689530f, 0.19536467f, -0.00640803f, -0.02062609f, 
    0.16684353f, 0.22485605f, 0.07074423f, -0.06489095f, 0.07446579f, -0.15263706f, 0.03073681f, -0.03162574f, 
    0.46623486f, 0.12411676f, -0.10893130f, 0.08124602f, 0.06069848f, -0.19706208f, 0.00957699f, 0.03436927f, 
    -0.02432383f, 0.27106023f, -0.03569983f, 0.02017578f, -0.31145975f, -0.16166629f, 0.06117756f, -0.21618697f, 
    -0.18367611f, 0.12338409f, -0.21556288f, 0.01851857f, -0.12170809f, -0.09058334f, -0.00860029f, 0.15376875f, 
    0.16293415f, 0.22568977f, 0.47129142f, -0.12017930f, 0.03799751f, 0.05486568f, -0.13325615f, -0.02067365f, 
    0.03836094f, -0.02346737f, 0.06337525f, 0.03874683f, 0.34947616f, 0.26830351f, 0.22662531f, 0.32950318f, 
    0.10485392f, 0.08034557f, -0.06739829f, 0.04253369f, 0.02536756f, -0.03896965f, 0.12028055f, 0.08060138f, 
    0.20550856f, 0.29486907f, -0.04715667f, 0.31044158f, 0.05340669f, -0.07319674f, -0.06586584f, 0.07298183f, 
    -0.00413848f, -0.02409917f, -0.12664154f, 0.00449647f, -0.11960195f, 0.32719836f, -0.00119409f, 0.08817634f, 
    -0.14268580f, 0.11352936f, 0.23168024f, 0.04879976f, -0.00437612f, -0.05414834f, 0.12602477f, 0.00592726f, 
    0.05963995f, -0.03583846f, -0.03480352f, -0.04709772f, 0.01722717f, 0.05546353f, -0.01747108f, 0.02927410f, 
    0.02652406f, -0.03813824f, -0.06840114f, -0.06331149f, 0.04817502f, 0.03176729f, 0.03757964f, 0.01696950f, 
    0.00921330f, -0.03205706f, 0.01962436f, -0.00894032f, -0.07506453f, -0.00778109f, -0.06977558f, -0.05511662f, 
    -0.04422229f, 0.03278945f, 0.05345436f, -0.06384311f, -0.01892310f, -0.03932618f, 0.06090600f, 0.02002916f, 
    0.03255615f, -0.05012531f, 0.02485538f, 0.03974793f, 0.00239592f, -0.07029787f, 0.00332490f, 0.04148700f, 
    -0.01448688f, 0.05189997f, -0.06550485f, 0.04486487f, 0.03304932f, 0.00575705f, -0.00496330f, -0.00704266f, 
    -0.07364736f, -0.04874039f, -0.04264854f, 0.04325547f, -0.06034563f, 0.00900840f, -0.01403885f, 0.00915913f, 
    -0.07770749f, 0.02533565f, 0.01159954f, -0.02697812f, 0.02221857f, 0.02207611f, -0.06571577f, 0.05065857f, 
    0.04464260f, 0.00925333f, -0.07599239f, 0.00720077f, -0.03062143f, 0.00721595f, -0.05668293f, 0.05978910f, 
    -0.04318551f, -0.04355304f, 0.01743479f, 0.01577048f, -0.06087173f, -0.07375618f, 0.02963468f, -0.04831550f, 
    0.00091152f, -0.04024759f, 0.05033724f, 0.02951371f, -0.06987666f, 0.02648210f, 0.01902064f, 0.02483853f, 
    0.04065392f, 0.05722422f, 0.02281364f, -0.05594779f, 0.01094539f, -0.06482522f, 0.05010586f, -0.02059646f, 
    0.03057391f, -0.00148434f, -0.05934088f, 0.00776395f, -0.07130399f, 0.05923312f, 0.01642685f, 0.00953878f, 
    0.04189643f, -0.01022789f, -0.05991877f, 0.02296763f, -0.03825654f, -0.06311832f, 0.02771006f, -0.06999678f, 
    -0.02336491f, -0.06973735f, -0.07188721f, -0.04809267f, 0.04504611f, 0.02844134f, 0.03799957f, -0.02058707f, 
    -0.01946385f, -0.06463233f, -0.04296890f, 0.01002249f, -0.03210742f, -0.00490443f, -0.04025542f, -0.03907305f, 
    -0.07546737f, -0.01024476f, 0.05684493f, 0.03724436f, -0.03340135f, -0.04930619f, -0.06982857f, -0.03511619f, 
    0.05656974f, -0.03360727f, -0.03721491f, 0.00094379f, 0.00299499f, 0.02695641f, 0.03860384f, -0.02156983f, 
    -0.03928309f, 0.01397977f, 0.00465220f, -0.04550941f, -0.07255937f, -0.06914413f, -0.02586252f, 0.01680275f, 
    -0.05142836f, 0.04947260f, -0.05213022f, -0.06220621f, 0.02545174f, 0.03893771f, -0.01156282f, 0.04038734f, 
    0.01162305f, -0.06159853f, -0.02411766f, -0.08111420f, 0.04598104f, -0.08091994f, -0.01460093f, -0.04739475f, 
    0.01281617f, 0.04076412f, -0.03968722f, -0.04686770f, -0.05233504f, 0.05909527f, 0.03240211f, -0.07385872f, 
    -0.02520959f, -0.02670405f, 0.03757200f, 0.02988378f, -0.01011926f, 0.00320555f, 0.02578984f, -0.02623079f, 
    -0.06861106f, 0.01954526f, -0.06046498f, -0.05974299f, -0.00630192f, -0.02277465f, -0.03189806f, 0.00394658f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.02856684f, 0.01915453f, 0.03993906f, -0.00205069f, 0.01822229f, 0.08012646f, -0.07107651f, 0.02902600f, 
    0.01366893f, 0.07069361f, -0.07007917f, 0.05369386f, 0.07958413f, -0.01706272f, -0.01089314f, 0.06752459f, 
    0.08754347f, -0.07455997f, 0.02846525f, 0.06514985f, 0.17705138f, 0.03222138f, -0.06504653f, -0.06830832f, 
    0.08349488f, 0.05952735f, 0.06832885f, 0.06203829f, -0.05994876f, 0.16141996f, 0.00450396f, -0.02729084f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.01990775f, -0.08401682f, -0.10995574f, 0.15216054f, -0.10879375f, 0.06038238f, 0.16592990f, -0.06293309f, 
    0.09935413f, 0.10359003f, 0.08054607f, -0.05683586f, 0.11987864f, -0.18569170f, 0.05639808f, -0.07943007f, 
    -0.14170286f, -0.02795690f, -0.14327972f, 0.01836277f, -0.15551522f, -0.11350978f, 0.18297720f, -0.10806683f, 
    -0.02572655f, 0.04284421f, -0.00020161f, -0.16607206f, -0.09489597f, 0.01229914f, -0.05241169f, 0.10563502f, 
    0.26795760f, -0.42707634f, 0.27074578f, 0.04788795f, 0.02744398f, -0.08950847f, 0.15982097f, 0.25976688f, 
    -0.03033554f, -0.11311652f, 0.00621382f, -0.20348255f, -0.48830250f, -0.40591338f, 0.17126243f, -0.42702070f, 
    0.33644840f, 0.10972020f, 0.14800142f, 0.07888180f, 0.51556516f, 0.05173172f, 0.37202892f, -0.11699965f, 
    0.18308304f, 0.00211105f, -0.35789979f, 0.15870185f, -0.07162629f, 0.45262673f, 0.07309247f, 0.05836708f, 
    -0.33605120f, -0.30826858f, 0.39521909f, 0.08017880f, 0.05473363f, 0.14679289f, 0.02444087f, 0.28038761f, 
    0.15802664f, 0.34130883f, 0.01256495f, 0.49964020f, -0.17870107f, 0.04668510f, 0.06910051f, 0.24148200f, 
    -0.22968385f, 0.12561519f, 0.05666275f, -0.06474051f, 0.01094143f, 0.46736115f, -0.29624370f, -0.41657442f, 
    0.12104880f, 0.05160916f, 0.29902893f, -0.09491511f, -0.14841861f, 0.25768521f, 0.24180180f, 0.06761387f, 
    -0.28137249f, 0.43422049f, 0.25355408f, 0.00484107f, 0.11074772f, 0.38390866f, -0.10779870f, 0.06973259f, 
    -0.03693690f, 0.08481166f, 0.17259794f, 0.28369689f, 0.82260859f, -0.35844544f, 0.02533762f, 0.36055759f, 
    -0.01893399f, -0.04242447f, 0.17711160f, -0.10876597f, 0.61813182f, 0.08890072f, -0.40082097f, 0.19025730f, 
    0.23142524f, -0.25370964f, -0.07207466f, 0.31253734f, 0.07339272f, -0.18688865f, 0.17688890f, -0.16100527f, 
    0.43424571f, 0.42937568f, -0.49082229f, 0.16189612f, -0.10781131f, 0.10337796f, 0.06150391f, 0.25588477f, 
    -0.06377034f, 0.03207658f, 0.03953652f, -0.23595077f, 0.26618400f, 0.00449157f, 0.09409897f, 0.04106539f, 
    0.23291864f, 0.41214809f, 0.01873553f, -0.12490289f, -0.11483661f, 0.01458684f, 0.12329178f, 0.46781164f, 
    -0.16479591f, 0.01317182f, -0.05841304f, 0.14815289f, -0.12293561f, -0.34082264f, -0.42291704f, 0.05844529f, 
    -0.05259990f, 0.02311569f, -0.16849491f, 0.08046080f, 0.11881463f, -0.12300711f, -0.12038791f, 0.10969038f, 
    0.13694996f, -0.17283335f, 0.06876425f, -0.13666995f, 0.08911221f, -0.06753446f, 0.00139847f, -0.08242120f, 
    0.04291724f, -0.02976412f, 0.14503585f, -0.13481146f, -0.12384032f, 0.11010861f, 0.01075317f, 0.08110508f, 
    -0.07812332f, -0.04436822f, -0.15786040f, -0.04249625f, -0.01878126f, -0.10128807f, 0.01909065f, -0.15471071f, 
    -0.00708113f, 0.11842827f, -0.07013603f, 0.00929190f, 0.14605904f, -0.04323034f, -0.14723113f, 0.11655601f, 
    0.09583764f, -0.01225404f, 0.10011078f, -0.16892333f, -0.04383419f, -0.02806661f, 0.16840015f, -0.00181909f, 
    -0.21787106f, 0.06387480f, -0.09448600f, -0.14821555f, -0.15509550f, -0.16128467f, -0.26510066f, 0.07524342f, 
    -0.18272129f, -0.04518091f, -0.22143804f, 0.08353380f, -0.17110528f, -0.11583769f, -0.04330533f, 0.06791443f, 
    -0.13544737f, -0.03985732f, -0.10201276f, -0.08639033f, -0.10651474f, -0.17131501f, 0.13988592f, -0.03735974f, 
    -0.17000473f, 0.01688344f, -0.12966871f, 0.08643695f, -0.08721197f, -0.17026424f, -0.07464689f, -0.07706246f, 
    -0.14001749f, 0.08405175f, -0.10613122f, -0.08825645f, 0.00663448f, -0.04956554f, 0.01135466f, 0.05124300f, 
    -0.01100789f, -0.00522398f, 0.02940320f, 0.05061480f, 0.17610919f, 0.05284536f, -0.17385525f, 0.16487135f, 
    0.41117439f, 0.26214212f, -0.07313713f, 0.09190653f, -0.02311921f, -0.08692571f, 0.15734860f, 0.09286015f, 
    -0.17187305f, 0.15357247f, -0.15128212f, 0.38418615f, -0.09110186f, -0.15458770f, 0.11896650f, 0.45869994f, 
    -0.00563930f, 0.25628749f, -0.07938984f, -0.10707803f, 0.39299193f, 0.13250901f, -0.29094142f, -0.06821596f, 
    -0.06331539f, 0.21881607f, -0.25437331f, 0.19812450f, -0.07209058f, 0.39894372f, -0.27536932f, -0.14372340f, 
    0.29662889f, 0.01398931f, 0.07843474f, 0.05321486f, -0.16766243f, -0.16291068f, -0.11440036f, -0.02843927f, 
    0.08490441f, -0.20556977f, -0.00044636f, -0.18389666f, -0.26411316f, 0.31144255f, 0.10502493f, -0.37737489f, 
    0.12507404f, 0.23886564f, 0.02886268f, -0.01798562f, -0.00367056f, -0.13306914f, 0.43141073f, 0.24415293f, 
    -0.08663086f, -0.14006168f, -0.32739401f, 0.43954819f, 0.04239783f, 0.03894665f, 0.39623627f, 0.04244711f, 
    -0.14943136f, -0.09177624f, -0.09364645f, -0.09151661f, -0.17309365f, -0.13560049f, 0.01693032f, 0.02266652f, 
    -0.05817403f, -0.06873079f, -0.14209470f, -0.04920505f, 0.02266661f, -0.11742794f, 0.02978176f, -0.01698861f, 
    0.09521922f, 0.01541766f, -0.01989266f, 0.07189544f, -0.16961738f, -0.10764071f, -0.15175021f, -0.05747044f, 
    0.13765657f, -0.00085749f, -0.01072867f, 0.11107683f, -0.04434165f, -0.14674941f, -0.17576833f, -0.00444371f, 
    0.03456169f, 0.24274994f, 0.35334268f, -0.02189245f, 0.01339001f, 0.25472397f, 0.10119017f, -0.27094752f, 
    -0.10325638f, -0.03485204f, 0.00438781f, -0.46490300f, 0.00097360f, 0.14598082f, -0.06750089f, -0.07976905f, 
    -0.08730732f, -0.02786907f, -0.00759557f, 0.14652251f, -0.24343202f, 0.35363203f, 0.64291680f, -0.44720730f, 
    -0.13858214f, -0.02059627f, 0.23061574f, -0.21628651f, -0.09725535f, 0.44196081f, 0.50824517f, -0.00695493f, 
    -0.16482040f, 0.13232261f, -0.16488776f, -0.15821840f, 0.16551583f, -0.18114518f, -0.07609466f, 0.04306598f, 
    -0.04995102f, -0.15565796f, 0.15609613f, -0.20639758f, -0.25840679f, 0.00203133f, 0.12735663f, -0.06667430f, 
    0.02648773f, 0.06014829f, 0.13163918f, 0.01470316f, -0.21366039f, -0.22064804f, 0.12007263f, -0.06781849f, 
    -0.21311946f, 0.06102665f, -0.00384063f, 0.15086652f, -0.02139369f, -0.09583429f, -0.02249115f, 0.11791212f, 
    0.03799367f, 0.39445403f, 0.32872513f, 0.16224010f, -0.02352449f, 0.22911739f, 0.13800442f, 0.31396288f, 
    0.15160863f, -0.40824550f, -0.03308218f, 0.13210398f, 0.13651049f, -0.36116332f, -0.00307391f, -0.15436456f, 
    0.27368879f, -0.14797868f, -0.04223113f, 0.10900585f, 0.35691571f, 0.04744298f, 0.32863891f, 0.19520596f, 
    0.03066768f, -0.19596569f, -0.36801097f, 0.33116183f, -0.15461028f, -0.51998103f, -0.00966574f, -0.10283505f, 
    0.30731121f, 0.54078984f, -0.36961091f, -0.16003764f, -0.07476109f, 0.15349226f, -0.16324528f, -0.36031795f, 
    0.10615959f, -0.48882213f, 0.08237382f, -0.34675297f, 0.52512854f, 0.35456011f, -0.10094779f, -0.10204037f, 
    0.16169257f, 0.27117318f, -0.02202147f, -0.14840315f, -0.21187867f, -0.16009533f, -0.24594674f, 0.17754261f, 
    0.16111648f, 0.54993331f, 0.32722989f, 0.29681623f, -0.00087973f, -0.09114526f, 0.21027496f, -0.01451390f, 
    0.04265501f, -0.15275458f, -0.09997240f, -0.16275682f, 0.14181031f, -0.02171846f, -0.00543066f, -0.13947988f, 
    0.15924037f, -0.17622299f, -0.13990520f, -0.04275028f, -0.09745894f, -0.00909721f, 0.04563399f, -0.00578301f, 
    0.07375846f, 0.11216566f, -0.07336702f, 0.13678311f, -0.10834496f, 0.03865165f, -0.15483236f, -0.06441960f, 
    -0.04797335f, -0.13949703f, -0.14754876f, -0.04191755f, 0.02576763f, -0.15310954f, -0.04861220f, -0.15399152f, 
    -0.14167935f, 0.19162707f, 0.00247948f, -0.08186668f, -0.16917625f, -0.04987060f, 0.06612237f, -0.24638030f, 
    0.08108126f, 0.29591054f, 0.05244210f, 0.49103722f, -0.07988130f, 0.25501266f, 0.04152286f, 0.68244904f, 
    0.17554736f, -0.14614964f, -0.05189081f, 0.01371095f, -0.30138269f, 0.16930172f, 0.04991881f, 0.41535702f, 
    -0.10681344f, -0.31994385f, 0.32262337f, 0.08753201f, -0.17509679f, -0.06392854f, -0.02818124f, -0.00157197f, 
    -0.01228839f, -0.13547628f, 0.44430736f, -0.04134521f, -0.14474531f, 0.10578249f, 0.06517757f, -0.17404693f, 
    0.13297410f, 0.33891249f, 0.01050942f, -0.40681249f, 0.14208423f, -0.13937847f, 0.02598066f, -0.09062772f, 
    0.00130898f, -0.02646754f, -0.06617012f, -0.04820967f, -0.33779231f, 0.26569411f, 0.52385789f, -0.11956839f, 
    -0.36321709f, 0.42865464f, 0.04020837f, -0.20575444f, -0.13747166f, 0.19983159f, 0.33146286f, -0.05727809f, 
    0.07215309f, 0.11993759f, 0.13286385f, 0.10299999f, 0.06306053f, 0.22698586f, -0.14002313f, -0.40784866f, 
    -0.09529257f, -0.25469330f, -0.13655289f, 0.05065696f, 0.49979350f, 0.20617796f, -0.05609390f, 0.44719017f, 
    0.06174392f, -0.16049562f, 0.01878866f, -0.13416129f, -0.04903186f, -0.15160653f, -0.17818485f, 0.11866897f, 
    0.23541531f, -0.30780327f, 0.29804960f, 0.13549888f, 0.06801499f, -0.04407910f, 0.08586123f, 0.12232577f, 
    -0.24302886f, 0.12243035f, 0.11699232f, 0.11995316f, 0.14377108f, 0.47011068f, 0.03657316f, -0.34384701f, 
    -0.15753229f, -0.03688745f, 0.15783195f, -0.09937477f, 0.19789065f, 0.16503865f, 0.12399939f, -0.57666570f, 
    0.35714555f, -0.04559013f, -0.08542798f, 0.12253157f, -0.15414514f, 0.14198585f, 0.33307171f, 0.16851124f, 
    0.20928082f, 0.54096442f, 0.38799271f, -0.31838334f, -0.03437497f, -0.04642528f, -0.16047503f, -0.04623428f, 
    -0.09150842f, -0.05372248f, -0.06906231f, -0.04480634f, -0.09011842f, -0.06289228f, 0.12211969f, 0.14075136f, 
    0.03335185f, -0.01722670f, 0.17298432f, 0.08587311f, -0.16762041f, -0.09548438f, 0.01309667f, -0.10950464f, 
    -0.15575506f, 0.11819775f, -0.16383991f, 0.03505237f, -0.01380200f, -0.12836322f, -0.08717282f, -0.04879854f, 
    0.15917219f, 0.00275962f, -0.06171638f, -0.14831324f, -0.17034051f, 0.22490513f, 0.09662884f, 0.11953548f, 
    0.06450500f, -0.16818993f, -0.19635865f, -0.13649039f, 0.06054662f, 0.16450404f, -0.10899476f, -0.16937502f, 
    0.14918387f, 0.24202870f, -0.07225921f, 0.11313395f, -0.08460061f, 0.26933107f, 0.16871396f, 0.19774337f, 
    0.34065801f, -0.03930349f, -0.06470985f, -0.14116295f, -0.30951855f, 0.19295779f, 0.29304665f, 0.29661414f, 
    0.27311680f, -0.23668936f, 0.51518035f, -0.21158223f, -0.03560759f, 0.01407715f, -0.29762316f, 0.08583996f, 
    -0.05864340f, -0.07750054f, 0.13787641f, 0.08859228f, -0.16154748f, -0.08250945f, 0.10648309f, -0.09749875f, 
    0.12360256f, -0.06758617f, -0.05606839f, 0.00632208f, 0.09201393f, -0.15723136f, 0.02987036f, -0.18481284f, 
    -0.02201036f, 0.04835038f, 0.02111308f, -0.10168032f, -0.15588923f, 0.00009754f, -0.17669539f, -0.16216479f, 
    0.15840968f, 0.11955156f, -0.12615548f, 0.03741803f, 0.13646106f, -0.06738488f, -0.01872667f, 0.04016833f, 
    -0.10443154f, -0.05571247f, -0.17982852f, -0.06937053f, -0.09026582f, -0.06142493f, 0.09531415f, 0.12221216f, 
    -0.16040447f, -0.17844361f, -0.06353256f, 0.00694783f, -0.13694493f, -0.10421550f, 0.06053549f, -0.17663144f, 
    0.02399631f, -0.14648381f, 0.04681958f, 0.08437993f, -0.00801771f, -0.03263251f, 0.12289671f, -0.08466958f, 
    -0.02823249f, 0.11847837f, -0.15682828f, -0.06544337f, 0.01523354f, 0.10099676f, -0.13661824f, 0.04788537f, 
    -0.10266989f, 0.04424221f, 0.11314517f, -0.06353934f, -0.01406535f, -0.05055412f, 0.16743103f, 0.12455535f, 
    -0.10953987f, 0.02473257f, 0.02912252f, 0.08983310f, -0.15336670f, 0.13172816f, -0.05833880f, -0.02209369f, 
    -0.05133514f, -0.05101735f, 0.01995660f, -0.00688443f, -0.17135125f, -0.08823619f, -0.23064522f, -0.06108277f, 
    0.12270781f, -0.24706770f, -0.08664484f, 0.11801498f, -0.00272221f, -0.09852251f, -0.08734836f, 0.03840036f, 
    0.40564811f, -0.20292959f, 0.21489124f, -0.16832536f, -0.07852863f, -0.36229375f, -0.11768877f, 0.15325782f, 
    0.01520156f, 0.21189518f, 0.14384499f, -0.23706590f, -0.31750742f, 0.08322764f, -0.08856384f, 0.03030385f, 
    0.02467119f, 0.41251060f, 0.16227841f, -0.18057504f, 0.01751866f, 0.01051494f, -0.16008219f, -0.36210880f, 
    -0.03680978f, 0.30250028f, 0.02456739f, 0.39420900f, -0.12213276f, 0.46995336f, 0.33055037f, -0.08084294f, 
    -0.16242549f, -0.17221285f, -0.09183027f, -0.16236703f, -0.12012561f, 0.24128130f, -0.15440618f, -0.33103445f, 
    0.15759663f, 0.44397050f, 0.11370184f, 0.31798115f, -0.36074039f, 0.53069741f, -0.08716864f, -0.30797416f, 
    0.34081742f, 0.00263721f, 0.04202799f, 0.00162646f, 0.11603689f, 0.00503421f, -0.33480525f, 0.52779418f, 
    0.23372301f, -0.04414554f, 0.31445634f, -0.00402561f, 0.12098555f, 0.63955837f, -0.24965554f, 0.07985126f, 
    0.40040562f, 0.06809141f, 0.12331226f, 0.11695470f, -0.12049861f, 0.08218606f, 0.02247217f, 0.33728954f, 
    0.00279400f, -0.15284795f, 0.08986323f, 0.21578564f, -0.44825095f, -0.22046016f, -0.08807840f, -0.09672957f, 
    0.44002181f, -0.02660214f, 0.10995603f, 0.12399666f, 0.12306497f, -0.05638522f, 0.52461517f, 0.26067036f, 
    -0.09517004f, 0.48124915f, 0.03868654f, -0.19486986f, -0.07009322f, -0.28739822f, -0.17904551f, 0.14572369f, 
    -0.29488152f, -0.25500163f, -0.06343766f, -0.08916743f, -0.13443051f, -0.19011992f, -0.03447482f, 0.23700251f, 
    0.08334366f, 0.25126588f, 0.15435818f, 0.04305885f, 0.36064214f, 0.25237003f, 0.15620212f, -0.73564899f, 
    -0.19863038f, 0.25459558f, 0.04243132f, -0.05540966f, 0.47770748f, 0.12431806f, -0.00721764f, 0.05759985f, 
    0.01345659f, 0.44407165f, -0.18056524f, 0.00274678f, -0.13025169f, -0.43235591f, 0.04003992f, -0.10317124f, 
    0.16262867f, 0.05405622f, -0.10864536f, -0.16727418f, 0.15788285f, -0.19771689f, 0.03726982f, 0.29327676f, 
    0.15628554f, 0.11818273f, -0.05190460f, 0.19608769f, 0.24784088f, 0.03602197f, -0.08479135f, 0.80404860f, 
    -0.15000573f, 0.22874793f, -0.12756404f, -0.03583622f, -0.12538345f, 0.23863840f, 0.20570150f, -0.46174330f, 
    -0.42781046f, 0.10853013f, 0.13398553f, -0.06118500f, 0.15816909f, -0.44695920f, 0.39357880f, 0.17555031f, 
    -0.42261344f, -0.07642241f, 0.31212914f, -0.05702572f, -0.08131419f, -0.15608384f, 0.01464501f, 0.22683904f, 
    -0.01511919f, 0.37711760f, 0.05610261f, 0.30877063f, 0.16557516f, 0.16710126f, 0.15846266f, -0.31554842f, 
    -0.22904469f, 0.10189573f, 0.16282041f, 0.14255476f, 0.10634270f, 0.26774743f, 0.11522477f, 0.19945216f, 
    0.02561984f, -0.33474761f, -0.17667024f, 0.11678198f, -0.16609775f, -0.48435518f, 0.24925745f, 0.02768123f, 
    0.06449091f, -0.23090972f, -0.13590237f, 0.04837029f, -0.07890452f, -0.15436800f, -0.00130314f, 0.48780966f, 
    0.15945794f, 0.34855562f, 0.06571218f, -0.00970326f, -0.12678593f, 0.37478203f, 0.13910675f, -0.14476265f, 
    -0.23969273f, 0.19846536f, 0.01594779f, 0.00841411f, 0.04107950f, 0.03078056f, -0.02398173f, -0.00331439f, 
    -0.40708238f, 0.15754955f, -0.06913479f, 0.24101225f, 0.17402607f, -0.47484609f, 0.19774066f, -0.07397693f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.04511879f, 0.22600423f, 0.29070720f, 0.17860776f, -0.09677137f, 0.09544834f, -0.07696594f, -0.02534153f, 
    0.09287398f, -0.05786755f, -0.15604818f, 0.00485100f, 0.06434451f, 0.22782287f, 0.24175760f, -0.11643147f, 
    0.19039313f, -0.02444264f, 0.12147371f, 0.20800766f, -0.13266021f, -0.11255992f, -0.16078940f, 0.08407504f, 
    0.10394254f, 0.13316654f, 0.18999045f, -0.02141344f, -0.05476898f, 0.18309319f, -0.02259753f, 0.00491066f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.11093038f, 0.31937152f, -0.28522119f, -0.45385313f, 0.03414541f, -0.02726737f, 0.05466229f, 0.09861290f, 
    -0.26439020f, 0.10521460f, -0.05447073f, 0.13631850f, 0.00729187f, -0.03187684f, -0.29011503f, 0.11413775f, 
    -0.05779453f, 0.24897860f, -0.15082791f, 0.27448255f, -0.19336587f, 0.34373933f, 0.15578602f, -0.10487017f, 
    -0.00177441f, -0.09226085f, 0.21349940f, 0.29531699f, -0.57695144f, -0.98201859f, -0.46644545f, -0.66265452f, 
    -0.01638834f, -0.57576358f, -0.39531654f, -0.12892346f, -0.03409846f, -0.05038634f, -0.07654562f, -0.17283230f, 
    -0.14993463f, -0.04477276f, 0.07657455f, -0.43347400f, 0.15206796f, 0.01447756f, 0.39452982f, 0.16134246f, 
    0.20328395f, -0.40332597f, 0.22469747f, 0.26024896f, 0.03250448f, 0.14840767f, 0.11507816f, -0.08491903f, 
    -0.01973509f, -0.23182717f, 0.28433782f, 0.13655147f, -0.71195406f, 0.24469301f, -0.73489279f, 0.10516790f, 
    -0.02734250f, 0.39745885f, -0.45033887f, -0.28485548f, 0.31912884f, -0.10520291f, -0.18771988f, 0.06172794f, 
    0.27153155f, 0.40689552f, 0.07174598f, -0.49084207f, -0.06525578f, 0.38461614f, -0.05017185f, -0.08978610f, 
    -0.32198885f, -0.43027279f, -0.55592549f, -0.16141637f, -0.12722266f, -0.23292139f, -0.15740587f, -0.10205749f, 
    0.07294881f, 0.11336815f, -0.10498989f, 0.46611235f, -0.07788173f, -0.76293504f, -0.43080866f, -0.20704290f, 
    -0.14130966f, -0.01794912f, 0.09189454f, -0.49073294f, -0.45023626f, -0.14798835f, -0.09106464f, 0.03543463f, 
    -0.03953929f, 0.18409637f, -0.14462085f, 0.43386498f, -0.11601775f, -0.55508822f, -0.16018181f, 0.01760592f, 
    -0.08878434f, 0.35803425f, -0.33477116f, -0.13161746f, 0.07109909f, -0.47358796f, 0.04994078f, -0.16816847f, 
    -0.09202950f, 0.37252316f, 0.11642297f, -0.35601091f, -0.36884177f, -0.11293159f, -0.07099463f, -0.00477832f, 
    0.09261069f, -0.29624313f, 0.17832609f, -0.11188981f, -0.00891331f, 0.10876848f, -0.02374478f, 0.15334697f, 
    0.15382041f, -0.39401224f, 0.05425082f, -0.14911476f, 0.15436479f, -0.46643630f, -0.03469631f, 0.10866935f, 
    -0.16823202f, 0.15999106f, -0.43020582f, 0.17704959f, 0.14664580f, 0.00190521f, 0.05181026f, -0.10259253f, 
    -0.08417136f, 0.06602324f, 0.29416117f, -0.28893727f, 0.51160163f, -0.18023245f, 0.05515032f, 0.07242728f, 
    -0.06170128f, -0.74846536f, 0.02921871f, 0.19903050f, -0.08062116f, 0.04879280f, 0.14007109f, -0.12564051f, 
    -0.20453122f, -0.29756933f, -0.18727678f, 0.37917718f, -0.15378758f, 0.21193120f, 0.04814634f, -0.00060167f, 
    0.18657178f, -0.08526564f, 0.28646317f, 0.19085203f, 0.01889557f, 0.21372414f, -0.17737751f, 0.14930017f, 
    -0.10584179f, -0.70925051f, 0.07876366f, -0.45825616f, -0.22525267f, -0.19669737f, 0.26070014f, -0.69187266f, 
    0.09387287f, 0.40373012f, 0.19145760f, 0.26550493f, -1.18772066f, 0.04322037f, 0.13908133f, 0.03485392f, 
    0.00815863f, 0.02711667f, -0.04713685f, -0.38484284f, 0.03834384f, 0.17415887f, -0.69239146f, -0.01922615f, 
    0.14020905f, -0.54477012f, 0.15930985f, -0.08560083f, -0.03534547f, 0.03987113f, 0.12938473f, 0.10867685f, 
    0.15000927f, 0.00495095f, 0.35815910f, -0.36427107f, -0.23914607f, -0.79866576f, 0.29728553f, -0.42040151f, 
    0.07755734f, -0.34378466f, -0.02312738f, -0.55475163f, 0.15559500f, -0.16968136f, -0.14041726f, 0.15444566f, 
    -0.42770100f, 0.17537414f, -0.02644440f, 0.05825171f, -0.14790221f, -0.18191500f, -0.15540074f, 0.04656773f, 
    -0.05987063f, 0.13700123f, -0.09778943f, -0.54075307f, 0.07646830f, 0.10366499f, 0.12764026f, -0.00240016f, 
    0.08613127f, 0.14969593f, -0.54552627f, -0.24747430f, 0.29918078f, 0.36610645f, 0.41451827f, 0.52342141f, 
    0.01043742f, -0.26733321f, -0.66857255f, 0.15563408f, 0.36694720f, 0.07970375f, -0.01884644f, 0.09418052f, 
    0.09793350f, 0.45173654f, -0.13616814f, -0.24219289f, -0.02302158f, -0.04066099f, 0.33124927f, 0.02272145f, 
    0.01834830f, -0.68402880f, 0.21928048f, -0.45561898f, -0.06872693f, -0.22147891f, 0.01662774f, -0.14924145f, 
    0.02869472f, 0.13490784f, 0.06658274f, -0.86994720f, -0.06792732f, -0.29025951f, -0.03376806f, 0.27594444f, 
    -0.07066988f, -0.00325633f, -0.16352664f, 0.29824799f, 0.01127054f, -0.13843015f, -0.14969942f, -0.05995235f, 
    0.00805086f, -0.03147395f, -0.08022594f, -0.43064612f, -0.04991652f, 0.48160508f, -0.63858366f, 0.10687667f, 
    -0.09606540f, -0.07456940f, -0.62739390f, 0.04768328f, -0.16317244f, -0.30931312f, -0.00727170f, 0.10587192f, 
    0.00769989f, -0.43111870f, -0.02751771f, 0.30342719f, 0.26325372f, 0.18446937f, 0.34010488f, 0.20598477f, 
    -0.10411070f, 0.31402066f, -0.09429812f, 0.25375578f, -0.42371088f, 0.08922648f, -0.11095470f, -0.17504990f, 
    -0.06210495f, 0.09313893f, 0.01601504f, 0.31560257f, -0.07464781f, 0.32375866f, 0.34271523f, -0.05187731f, 
    -0.74587435f, 0.24037334f, 0.16187304f, 0.18226081f, 0.16036400f, -1.22659290f, -0.10196602f, -0.06702083f, 
    -0.02626886f, 0.15934229f, -0.49539888f, -0.08452275f, 0.13159227f, -0.17825863f, -0.24860854f, -0.46338356f, 
    0.16623044f, -0.22327155f, 0.21940401f, 0.24711195f, -0.11281533f, 0.16434319f, 0.01090793f, 0.12387932f, 
    0.46350619f, -0.66356903f, -0.16866916f, -0.08970795f, -0.02296591f, 0.08966123f, -0.43220049f, 0.17365420f, 
    0.26498684f, 0.02900248f, -0.16626644f, -0.31112915f, -0.11526928f, -0.09141250f, -0.05192281f, -0.08146743f, 
    -0.12594594f, 0.05256220f, -0.16903675f, -0.01393849f, -0.86184108f, 0.42093757f, -0.23372652f, -0.35904920f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.25611207f, -0.08363545f, 0.09166190f, 0.05790663f, -0.14049543f, 0.00525019f, 0.10440607f, -0.34112078f, 
    -0.16995519f, -0.09783579f, 0.19449945f, 0.16245782f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
