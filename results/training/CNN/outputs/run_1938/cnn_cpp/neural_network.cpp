#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.53559268f, -0.22349007f, 0.19783817f, 0.36852422f, -0.17450063f, 0.14393422f, -0.02342634f, 0.05388255f, 
    -0.24382293f, -0.22764294f, 0.21173464f, -0.16435049f, -0.12867288f, -0.05339720f, 0.02053731f, -0.34262055f, 
    0.09364334f, 0.13290754f, 0.22035773f, -0.03650087f, 0.14401762f, 0.23829424f, -0.11543882f, -0.26245803f, 
    -0.40430161f, 0.97102791f, -0.63309568f, -0.53522843f, -0.38672072f, -0.67963588f, 0.04053472f, -0.02700491f, 
    0.19916849f, 0.47505325f, -0.29675144f, 0.15299262f, -0.03788629f, 0.15557355f, -0.29180861f, -0.12040725f, 
    0.25624752f, -0.03985056f, -0.09170305f, -0.09012068f, -0.21858348f, -0.14199525f, -0.02551586f, -0.18538368f, 
    0.05045324f, -0.12743717f, 0.30188280f, -0.76026332f, -0.05931408f, 0.22011675f, 0.69671053f, 0.01134126f, 
    0.66062886f, -0.18874858f, -0.42885157f, -0.43813530f, -0.32891709f, -0.08825112f, 0.40631890f, -0.34131989f, 
    -0.09638795f, -0.07399520f, 0.16345845f, 0.05819211f, 0.20359099f, 0.08750633f, 0.15299548f, -0.14323848f, 
    -0.15360756f, -0.08319733f, 0.08106161f, -0.47286350f, 0.43840963f, -0.33206409f, -0.71512902f, -0.44298160f, 
    0.15546317f, 0.11655211f, 0.19818385f, -0.04840051f, -0.02797459f, -0.04854888f, -0.34501895f, 0.14610469f, 
    -0.20581323f, -0.03118597f, 0.16232070f, 0.08068151f, 0.06523009f, 0.05411076f, -0.02657100f, -0.02453329f, 
    -0.21907683f, -0.47253433f, -0.19671161f, -0.48071444f, 0.26497456f, 0.34132552f, 0.53725880f, 0.38295385f, 
    -0.11585312f, -0.41687283f, -0.37033156f, -0.30240986f, -0.05941102f, -0.45307711f, 0.14963266f, -0.22502984f, 
    0.35587615f, -0.08009976f, -0.04082208f, -0.09158909f, 0.17168131f, -0.22488771f, -0.18491818f, 0.18267699f, 
    -0.12311648f, 0.04396463f, 0.21112595f, 0.05220873f, 0.22608003f, -0.01534886f, 0.22202584f, 0.37996280f, 
    0.00520760f, -0.54987550f, -0.18456075f, -0.42840838f, -0.20784387f, 0.39547986f, 0.45702955f, 0.11623044f, 
    -0.01227565f, -0.41032317f, 0.16992003f, 0.24550356f, 0.07924682f, 0.04545810f, -0.13250604f, 0.08768275f, 
    -0.18187626f, -0.00765231f, 0.33675411f, -0.16700143f, -0.14630215f, 0.17331342f, -0.11530932f, -0.20865256f, 
    -0.44789293f, -0.30548510f, -0.54082209f, 0.10013246f, 0.44701296f, 0.15644847f, 0.35163066f, -0.07957656f, 
    -0.19272731f, 0.15863627f, -0.29054248f, 0.03472601f, 0.02201296f, -0.05614665f, 0.35480595f, -0.16990189f, 
    -0.14275691f, -0.02181931f, -0.00398769f, -0.25304565f, 0.00784725f, -0.15647772f, 0.18655673f, 0.29997933f, 
    -0.47316641f, -0.26804981f, -0.34438890f, -0.76369172f, 0.09428768f, 0.34217662f, 0.16565870f, 0.46060270f, 
    -0.12098042f, -0.15435116f, 0.04815602f, -0.16102782f, -0.27615592f, -0.13422543f, 0.24258354f, -0.03926423f, 
    -0.11934842f, 0.14618744f, 0.04250869f, -0.18195029f, 0.10751209f, -0.05150284f, -0.15938886f, 0.17333439f, 
    0.73741913f, 1.06945789f, -0.19363299f, -0.51679611f, -0.75001121f, -0.67458522f, -0.20451474f, 0.06317004f, 
    0.39439124f, 0.27982438f, -0.00347247f, -0.01535270f, 0.28427538f, 0.08386416f, 0.17557184f, -0.16878526f, 
    -0.02485866f, 0.20558214f, -0.37436029f, -0.17866315f, 0.12292892f, 0.26214913f, -0.08706529f, -0.06307505f, 
    -0.05278157f, -0.58543283f, -0.06261739f, 0.01987863f, 0.50471044f, 0.40526313f, 0.16343448f, -0.00181406f, 
    0.29263198f, 0.04023664f, 0.09393361f, -0.00679785f, 0.04459901f, -0.38595241f, 0.26272118f, -0.22834599f, 
    0.14130901f, 0.30113196f, -0.20637687f, -0.06913414f, -0.18603006f, -0.00814177f, -0.14919686f, -0.09841174f, 
    -0.14464636f, 0.00342031f, -0.13422491f, -0.48340544f, -0.49459213f, 0.05007810f, 0.45555553f, -0.14338084f, 
    -0.33466157f, -0.33073303f, -0.37743816f, -0.01161071f, 0.11185157f, -0.13204099f, 0.13223772f, 0.32454431f, 
    0.02501152f, 0.11486308f, -0.14547157f, -0.35153344f, 0.00345869f, 0.02979485f, -0.12430266f, 0.16441062f, 
    0.05988470f, -0.24091408f, 0.10871890f, 0.52609551f, 0.16164881f, -0.07127238f, -0.15790524f, -0.34726763f, 
    0.54483998f, 0.42163402f, 0.07674344f, -0.04934296f, -0.28400573f, 0.02230949f, 0.25637707f, -0.18672556f, 
    -0.07493202f, -0.34954414f, 0.20852557f, 0.06347854f, -0.00464114f, -0.25874734f, -0.18134123f, 0.01409609f, 
    -0.20570377f, 0.12388833f, 0.16805366f, 0.37614366f, 0.20032868f, 0.13874225f, 0.18864670f, -0.15137188f, 
    -0.10563684f, 0.17595086f, -0.18402740f, 0.22810245f, -0.22586447f, 0.36564115f, -0.09163927f, -0.25246394f, 
    0.28585070f, -0.11783195f, -0.15834111f, -0.00596249f, -0.21337393f, -0.05665022f, 0.00988435f, 0.13900971f, 
    0.20033734f, 0.16242214f, -0.13663842f, -0.23235448f, 0.08851800f, 0.16964622f, -0.12054455f, 0.02731355f, 
    0.10002237f, -0.34364843f, 0.31338242f, -0.38467380f, -0.34161806f, -0.33987373f, -0.45411810f, -0.04046544f, 
    0.27912456f, -0.17939158f, -0.27676186f, -0.28179008f, -0.06438758f, -0.13754043f, -0.13241081f, 0.02497696f, 
    0.22778597f, 0.16778286f, -0.15150572f, -0.24759972f, -0.34728989f, -0.17124256f, -0.29494959f, -0.00016677f, 
    -0.15276237f, 0.28919542f, -0.10487415f, -0.24561591f, -0.37426239f, 0.03891965f, -0.24069150f, -0.45496428f, 
    -0.05697565f, 0.49322486f, -0.27670187f, -0.20407337f, -0.09895089f, 0.26190096f, 0.09763114f, 0.17812569f, 
    -0.08181635f, -0.20785823f, 0.00046423f, -0.09467582f, -0.06817724f, 0.08212788f, 0.41089955f, 0.24041659f, 
    -0.01581378f, 0.30764952f, 0.24806808f, 0.37447610f, 0.22634734f, -0.34571236f, -0.25470582f, -0.19051403f, 
    0.38330904f, 0.14175195f, -0.20483381f, 0.29962721f, 0.05925573f, -0.01987777f, -0.26940286f, -0.18346207f, 
    -0.03974168f, 0.00899481f, 0.05233609f, 0.12478290f, -0.08784246f, -0.08678053f, 0.09464605f, 0.12999405f, 
    0.24704190f, -0.39894509f, -0.15238860f, 0.47900933f, 0.09407046f, -0.19138630f, -0.09013268f, 0.14291428f, 
    -0.00490132f, -0.17503576f, -0.00856977f, 0.20145027f, 0.07922481f, -0.31510645f, -0.15912248f, 0.08732457f, 
    0.27484429f, 0.11151882f, 0.19745135f, 0.05328373f, -0.30625579f, -0.15658860f, -0.18977988f, -0.22549585f, 
    0.21127920f, 0.36373320f, 0.42083320f, 0.03331188f, 0.51908213f, -0.41458005f, 0.29121730f, -0.43235081f, 
    -0.15078606f, -0.46589145f, -0.34952968f, 0.33172703f, -0.09758669f, -0.04098785f, 0.22284858f, -0.18225029f, 
    0.10305247f, 0.19103557f, 0.17548187f, -0.12922458f, 0.18610866f, -0.09567557f, -0.03419684f, 0.10190869f, 
    -0.06319889f, -0.03246275f, 0.64556128f, 0.23302981f, -0.25845122f, 0.25111875f, -0.58502251f, 0.21060421f, 
    -0.35944170f, 0.06368513f, 0.14806640f, 0.24241282f, 0.31190258f, -0.24075474f, -0.31212598f, 0.17170963f, 
    0.01092584f, 0.22780980f, -0.05370645f, 0.03042345f, 0.04583930f, -0.05978035f, -0.20561768f, 0.02326444f, 
    0.12651585f, 0.05329389f, 0.16442184f, 0.31743187f, 0.14170070f, 0.19376133f, 0.33351746f, 0.11719243f, 
    -0.12624502f, -0.33426186f, -0.02401780f, 0.16851602f, -0.16485450f, 0.13026679f, -0.00959866f, -0.18028648f, 
    -0.15250145f, 0.20440678f, -0.08912309f, -0.06127704f, 0.08066592f, -0.02802312f, 0.02167873f, -0.11945583f, 
    -0.16640911f, -0.05681236f, 0.02957811f, -0.31947565f, -1.00962460f, -0.47771069f, 0.33122331f, 0.14450036f, 
    0.13134520f, 0.92354798f, -0.14423607f, -0.57336146f, 0.01130018f, 0.42793602f, -0.02052916f, -0.26852810f, 
    -0.45300308f, -0.09898077f, -0.21854898f, -0.17124721f, 0.01975311f, -0.03748628f, 0.03200326f, 0.18972306f, 
    0.03510755f, -0.11002114f, -0.13176081f, -0.04634775f, -0.07428587f, -0.26748016f, 0.69640249f, 0.15561381f, 
    0.15417734f, -0.11212499f, -0.32265195f, -0.62119126f, 0.22643548f, 0.52676988f, -0.08879665f, 0.12121040f, 
    -0.32248205f, -0.18130985f, 0.05005969f, -0.22973056f, 0.18325242f, 0.11193863f, 0.23996420f, -0.05769580f, 
    -0.27900141f, -0.03177680f, 0.06969202f, -0.13672997f, 0.04329081f, -0.16993414f, 0.66109926f, 0.74897712f, 
    -0.36076328f, -0.65112668f, -0.26036027f, 0.29951239f, 0.05024288f, 0.15085207f, -0.37886140f, -0.09063180f, 
    -0.15551125f, -0.06606297f, 0.51470131f, -0.15812157f, -0.12412209f, -0.05646123f, 0.26550424f, 0.33345360f, 
    -0.17912443f, -0.31503767f, -0.15222555f, -0.17932081f, -0.49341506f, 0.30801660f, 0.28750369f, -0.70465630f, 
    0.28552580f, 0.74092096f, -0.35180354f, -0.15542617f, 0.40751857f, -0.30400467f, -0.16983058f, 0.28707859f, 
    0.01607013f, -0.23895271f, -0.24264370f, -0.22405440f, -0.10733929f, 0.02811928f, -0.08527013f, -0.19429061f, 
    0.10404547f, 0.14520277f, 0.38997689f, 0.01068338f, 0.14692137f, 0.09795631f, -0.36738732f, -0.27668810f, 
    -0.65847003f, -0.29561284f, -0.10760391f, -0.23853971f, -0.06232329f, 0.24201041f, -0.10054690f, -0.37051356f, 
    -0.45461363f, -0.28530574f, 0.09491800f, -0.08858390f, -0.08798477f, -0.28620338f, -0.32396585f, 0.05875113f, 
    -0.01475115f, -0.04431655f, 0.09861534f, -0.04508227f, -0.05870111f, -0.07805680f, -0.19288163f, -0.06569172f, 
    -0.26438141f, -0.20205662f, -0.50707716f, -0.51038146f, -0.12136076f, 0.42642099f, -0.07523666f, 0.03435778f, 
    0.07729965f, -0.05192088f, 0.05000761f, -0.06417147f, -0.19894968f, -0.46682057f, -0.11777017f, 0.35979626f, 
    -0.50708193f, -0.01668653f, -0.09432850f, 0.09730636f, -0.52690542f, 0.17291357f, 0.23737061f, -0.09258650f, 
    -0.22409429f, -0.18105640f, -0.42194906f, -0.33544460f, -0.40116584f, -0.21300502f, -0.30948853f, 0.02517856f, 
    0.04645584f, 0.08643360f, 0.00246449f, 0.06171970f, 0.06296020f, -0.10787460f, -0.18251328f, -0.29398695f, 
    -0.11580890f, -0.08300292f, 0.04255898f, -0.26173523f, 0.17265442f, 0.18314517f, -0.01964756f, 0.40037626f, 
    0.31320900f, 0.06561720f, 0.01087025f, -0.82211244f, -0.24568804f, -0.62134343f, -0.44886640f, 0.04101077f, 
    0.46639359f, 0.19415806f, 0.12867200f, 0.31042266f, 0.47872165f, 0.22363481f, 0.09698110f, -0.11483909f, 
    0.31622195f, -0.25295207f, -0.31569993f, 0.09609318f, -0.09907913f, -0.12211956f, 0.14052424f, -0.04737970f, 
    -0.01768365f, 0.14531943f, 0.13160552f, -0.17002481f, -0.14541321f, -0.22695091f, 0.32444364f, 0.26951885f, 
    -0.04759933f, -0.44089970f, 0.13370220f, -0.02724772f, 0.09695848f, -0.08315437f, 0.24344155f, -0.43074217f, 
    0.28376636f, 0.50963187f, -0.37165096f, -0.13822150f, -0.21738653f, 0.11630572f, -0.13353638f, 0.22596368f, 
    0.21639749f, 0.10569488f, -0.35711434f, -0.24943717f, 0.39718238f, 0.37224370f, -0.47593623f, 0.01655430f, 
    -0.31234437f, -0.80118036f, 0.60092449f, -0.20363775f, 0.41997737f, -0.18856159f, -0.08459078f, -0.43924990f, 
    -0.24380460f, 0.24716723f, 0.32818159f, 0.09963449f, -0.13705119f, 0.00015558f, 0.28936571f, -0.41788182f, 
    0.26474029f, -0.02496086f, -0.16459125f, 0.24730438f, -0.00315844f, -0.20292568f, -0.35413390f, -0.39813834f, 
    -0.45031533f, -0.16008735f, -0.27845651f, -0.06715472f, 0.16980168f, -0.22819020f, -0.27640373f, 0.29176047f, 
    -0.11233620f, -0.05441366f, -0.19532828f, -0.01357248f, 0.26866505f, -0.02283722f, -0.17359026f, -0.22796769f, 
    -0.34592691f, -0.37268624f, -0.02343046f, -0.22087976f, 0.24061809f, 0.17144386f, 0.17594647f, -0.36082444f, 
    -0.80272663f, -0.38737807f, 0.20344748f, -0.11144394f, 0.32601747f, -0.19869590f, -0.11186615f, 0.70674819f, 
    0.27976814f, 0.15197173f, 0.03069346f, -0.02725896f, -0.00852987f, 0.34751469f, -0.22747174f, 0.11837045f, 
    -0.17702976f, -0.02833969f, 0.10523592f, 0.15166445f, -0.30242026f, -0.05909372f, 0.05942338f, 0.17721261f, 
    0.22675025f, -0.17321536f, 0.03651718f, 0.40067595f, 0.09556942f, -0.44563901f, -0.06236076f, 0.06650566f, 
    0.19207810f, -0.12055565f, -0.08215604f, -0.07644317f, 0.27932048f, 0.12571432f, -0.21164878f, -0.21437629f, 
    0.04370108f, 0.23644760f, -0.18989015f, -0.29831296f, 0.02210730f, 0.01726457f, 0.22947159f, 0.20888139f, 
    0.03843424f, -0.46060780f, 0.09883756f, 0.43608171f, 0.01712378f, -0.02086543f, 0.01556721f, -0.29580128f, 
    -0.02131164f, 0.12127335f, 0.05487568f, 0.05159295f, 0.04116731f, 0.21648462f, -0.24601163f, -0.14350225f, 
    0.07967141f, 0.23193970f, -0.10654642f, -0.09180807f, 0.03544911f, 0.08791757f, -0.29960585f, 0.14391950f, 
    0.06866968f, 0.11476450f, 0.32200819f, 0.29758009f, -0.10528746f, 0.15097582f, -0.15593420f, 0.08204030f, 
    0.45636341f, -0.28160030f, 0.49287781f, -0.49844173f, -0.14341804f, 0.14559115f, -0.12658484f, 0.09690510f, 
    0.06784062f, 0.22268179f, -0.16276735f, -0.04083889f, -0.14553525f, 0.13887602f, 0.02406817f, 0.02599437f, 
    0.00609071f, -0.17474820f, -0.01192141f, 0.34459615f, 0.16970018f, 0.23787807f, -0.27674758f, -0.14742854f, 
    0.30305699f, -0.30076876f, -0.38070568f, -0.14163688f, 0.16485825f, 0.27723089f, -0.46182877f, -0.00121375f, 
    0.43130496f, -0.18780516f, -0.33578202f, 0.17760400f, 0.14637803f, -0.13427095f, -0.03835109f, 0.28034976f, 
    0.03053751f, 0.00637755f, -0.20820124f, -0.05975128f, 0.41550985f, 0.46109307f, 0.12385173f, -0.18676552f, 
    -0.18942796f, -0.20495428f, 0.34131154f, 0.12286373f, -0.03848263f, -0.23596461f, -0.21984468f, 0.33707404f, 
    0.09416819f, 0.27636844f, -0.12038754f, 0.26478836f, -0.33145532f, -0.15159155f, -0.22909664f, 0.02008318f, 
    -0.07649757f, 0.10401744f, 0.24690670f, -0.27828819f, 0.32027337f, 0.33155659f, -0.36101049f, -0.05160744f, 
    0.22748303f, -0.43906954f, -0.11567759f, 0.52819395f, -0.24958962f, -0.28132251f, -0.27451605f, -0.04665037f, 
    -0.03804513f, -0.04378103f, -0.23084649f, 0.18758409f, -0.02377916f, -0.35026482f, 0.18837444f, 0.04998616f, 
    0.15760335f, 0.07550278f, -0.18621211f, 0.01537550f, -0.07427286f, -0.47823477f, -0.86365122f, -0.60005546f, 
    0.34002128f, 0.63596243f, 0.41853413f, 0.73741561f, -0.36818591f, -0.50733972f, -0.12525375f, 0.10935284f, 
    -0.20654902f, 0.08974545f, -0.25277248f, 0.10027444f, -0.22213346f, 0.13092496f, -0.09891390f, 0.00120892f, 
    0.16470970f, 0.17470580f, -0.15554017f, -0.22305447f, -0.16211526f, 0.29961887f, -0.24483213f, -0.65490031f, 
    0.05009659f, -0.33125302f, -0.30147627f, -0.16422988f, 0.17010188f, 0.47359803f, -0.04040202f, 0.15269354f, 
    0.29899001f, 0.30499703f, 0.24629104f, -0.27637750f, 0.09322135f, -0.16126917f, -0.18647942f, 0.06899343f, 
    0.04430283f, 0.08622172f, -0.06054502f, 0.20573737f, 0.21049853f, -0.05682640f, 0.32341462f, -0.13187498f, 
    0.14150743f, 0.31887075f, 0.41172931f, 0.17476326f, 0.09057156f, -0.39933622f, -0.14361203f, 0.18184100f, 
    0.00139522f, 0.06438725f, -0.01561291f, 0.12024070f, -0.04870869f, -0.18970080f, 0.09270798f, -0.15563555f, 
    0.19870642f, -0.02255654f, -0.16402580f, 0.13361843f, -0.01381764f, -0.15681902f, -0.16694599f, -0.12043401f, 
    -0.26860026f, -0.42542562f, -0.33227670f, -0.25710800f, 0.16098227f, -0.00291687f, 0.44154093f, 0.47050366f, 
    0.08201835f, -0.29842269f, 0.19461997f, 0.27829006f, 0.02696908f, -0.05249324f, -0.54929382f, -0.06973423f, 
    0.01890010f, 0.11919109f, 0.08165947f, 0.12248649f, 0.24941000f, 0.19270402f, -0.15366477f, -0.11866394f, 
    -0.08311602f, -0.31110531f, -0.03633874f, -0.38253492f, -0.15574944f, -0.18603665f, -0.08895265f, -0.07923489f, 
    -0.17865780f, -0.30526608f, 0.19359244f, -0.46548244f, -0.06676961f, 0.45800218f, -0.06957849f, -0.22557257f, 
    0.03755332f, -0.21712187f, -0.07962684f, -0.03572873f, 0.05249934f, -0.20339970f, 0.41618407f, 0.38232768f, 
    0.05357827f, 0.04733286f, 0.24782225f, -0.90134430f, -0.27093542f, -0.27930805f, -0.02332035f, 0.16124649f, 
    0.00593464f, 0.25755435f, 0.32900199f, 0.69130790f, 0.08507628f, -0.11016550f, -0.12202612f, 0.43376622f, 
    0.06181603f, 0.12978815f, 0.07892890f, -0.04113501f, -0.13490240f, -0.07532553f, -0.08223793f, -0.12200066f, 
    0.03101065f, 0.07807159f, -0.03600738f, 0.00956764f, 0.51543868f, 0.01257756f, -0.40609553f, -0.32551360f, 
    0.13313203f, -0.03238854f, -0.07914992f, -0.29676950f, 0.10693447f, 0.17465572f, 0.31815243f, -0.13320358f, 
    0.22751066f, 0.14453878f, -0.17431410f, 0.20837735f, -0.24898881f, 0.06553989f, -0.31358048f, -0.34579077f, 
    0.02882927f, 0.13542230f, 0.02701966f, 0.13731371f, 0.33877686f, 0.19623253f, 0.08147075f, 0.20620655f, 
    -0.12774016f, -0.36646679f, -0.38771334f, -0.56746930f, -0.18437994f, 0.41743571f, 0.37675589f, 0.37826762f, 
    -0.04581321f, 0.07148682f, 0.17081027f, -0.24896592f, -0.05791777f, 0.19114108f, 0.08537405f, -0.06461591f, 
    -0.44492480f, 0.00646251f, -0.06771073f, 0.10917209f, -0.26225641f, 0.21659760f, 0.49957398f, -0.04720065f, 
    -0.14437699f, -0.19135845f, 0.19883235f, -0.02370727f, 0.18820524f, -0.39109722f, -0.07768141f, 0.24977706f, 
    -0.24676007f, 0.15407875f, -0.26195514f, -0.13169426f, 0.42441916f, -0.09709030f, 0.04481601f, -0.09056805f, 
    0.03072429f, 0.06678556f, 0.33438811f, -0.34253162f, 0.05979601f, -0.09792996f, 0.13343541f, -0.01751397f, 
    -0.18087961f, -0.10678227f, 0.02330647f, -0.38580722f, -0.60083526f, -0.43174013f, -0.39865580f, -0.31543210f, 
    -0.59012288f, 0.31408814f, 0.15923277f, 0.39889702f, 0.27329522f, 0.17519750f, 0.01208406f, 0.11116095f, 
    -0.02644563f, -0.44120032f, -0.20036198f, 0.08590797f, 0.26079583f, -0.10830521f, 0.01332059f, 0.18347217f, 
    -0.35727370f, 0.10419108f, 0.31134662f, 0.48014259f, -0.13598365f, 0.23958099f, 0.16428292f, 0.03334886f, 
    -0.17146008f, -0.00155244f, -0.23233885f, -0.25622690f, -0.30247265f, 0.27272871f, 0.31283653f, 0.22322425f, 
    0.16626477f, -0.22958726f, 0.28061077f, -0.40757573f, 0.10426997f, -0.27433312f, -0.09025513f, -0.14127301f, 
    0.12391356f, -0.28316128f, 0.05910280f, -0.10831986f, -0.40606177f, -0.05709490f, -0.18423912f, -0.40792522f, 
    -0.49625492f, -0.11359099f, 0.20968837f, 0.18991032f, 0.29131684f, 0.26750922f, 0.20030114f, 0.25311762f, 
    -0.20080917f, -0.01715612f, -0.25541297f, -0.08702513f, -0.10944439f, -0.12210524f, -0.14750908f, -0.13634497f, 
    0.06580635f, -0.34778091f, -0.47440913f, -0.18766768f, -0.26818186f, 0.55553132f, 0.41287276f, -0.06395248f, 
    -0.16361819f, 0.20795882f, -0.11551148f, 0.19539411f, 0.25490212f, -0.04750224f, -0.23864247f, 0.04861159f, 
    0.08921893f, 0.17211796f, -0.18357535f, 0.02999544f, 0.03980264f, -0.55453527f, 0.04347473f, 0.00243907f, 
    0.15386176f, 0.23367029f, 0.29213813f, 0.79924512f, -0.29826212f, -0.12117264f, 0.07621124f, 0.21812981f, 
    0.03522138f, 0.19652630f, -0.04435833f, 0.09713516f, -0.02099650f, -0.26521811f, 0.29004952f, -0.18527685f, 
    -0.04683400f, -0.03850788f, -0.00246727f, 0.00768826f, 0.23529804f, -0.29721490f, 0.00995703f, -0.02861001f, 
    -0.15669601f, -0.06423811f, -0.21127377f, -0.24076200f, 0.20450275f, -0.15027694f, -0.26337102f, -0.16018339f, 
    -0.16980137f, -0.06605859f, 0.26091239f, -0.41187641f, -0.32764602f, -0.12276493f, -0.21399119f, 0.06415647f, 
    -0.30113894f, 0.00226570f, 0.42346856f, 0.10938247f, 0.15767550f, -0.26244318f, -0.22198956f, -0.24746774f, 
    -0.31305951f, -0.14568327f, 0.11265843f, 0.07307001f, -0.28920481f, -0.06094293f, -0.33982152f, -0.41207823f, 
    -0.35574740f, 0.10527448f, 0.07687224f, -0.18765959f, -0.40612847f, -0.26095283f, 0.32276487f, 0.21380794f, 
    -0.27224696f, -0.16892482f, 0.27335191f, 0.21040966f, -0.18709348f, 0.19119979f, -0.11809689f, 0.00984373f, 
    -0.05048775f, -0.36671382f, 0.05411108f, -0.00117665f, 0.27720532f, -0.16158099f, -0.15509824f, -0.29343858f, 
    -0.38809121f, -0.39308015f, -0.13530315f, 0.07959812f, -0.61194026f, -0.23103499f, -0.13326360f, -0.54026228f, 
    0.16714801f, 0.01436272f, 0.09629911f, 0.19680859f, -0.00479825f, 0.03505583f, 0.14846213f, 0.08053654f, 
    0.20447651f, 0.13385700f, -0.12506571f, -0.13853647f, 0.11568728f, -0.02190003f, 0.06658778f, -0.36899728f, 
    -0.35877189f, 0.13186091f, 0.08769239f, 0.04983957f, 0.58351785f, 0.01771356f, -0.08588338f, 0.17618750f, 
    0.47441590f, -0.14493886f, 0.29984301f, -0.13906910f, -0.11084361f, -0.00857976f, -0.18535396f, 0.06152198f, 
    -0.00397569f, 0.03504723f, -0.22506052f, -0.04083170f, 0.42692643f, -0.13782647f, 0.10996345f, 0.02658344f, 
    0.46109954f, 0.13013548f, 0.02545528f, -0.02856202f, -0.14087325f, 0.06398174f, -0.15451667f, -0.08759843f, 
    -0.07920360f, 0.27641505f, -0.22232549f, 0.34132388f, 0.03848403f, -0.26511863f, -0.09715128f, 0.02374734f, 
    -0.01449603f, -0.32145366f, 0.08175628f, -0.32332999f, -0.26128721f, -0.22624384f, -0.18880081f, -0.08367217f, 
    -0.44543073f, -0.54419667f, 0.55675495f, 0.43462542f, 0.12692744f, -0.27614227f, -0.19928864f, 0.15136220f, 
    -0.07620741f, -0.11801454f, 0.13599731f, -0.33235162f, -0.05331089f, 0.34143600f, -0.11285326f, -0.00753756f, 
    -0.01416287f, 0.29546878f, -0.12050785f, -0.10989466f, 0.07189868f, -0.16094109f, 0.01588347f, -0.06899784f, 
    -0.02387979f, -0.03110306f, -0.15893826f, 0.10110702f, -0.20906815f, -0.33588865f, 0.02371451f, 0.28702462f, 
    0.09265142f, 0.23893382f, -0.44818813f, 0.29444802f, -0.08349955f, -0.10120450f, -0.03639770f, -0.15045938f, 
    0.29057372f, 0.02380093f, 0.19876157f, -0.02887257f, -0.05297644f, -0.00091435f, -0.11357146f, -0.28354827f, 
    0.24517518f, -0.05654522f, 0.29729053f, -0.35732830f, -0.49927589f, -0.45911720f, -0.43575555f, -0.53172749f, 
    -0.08385138f, 0.38409248f, 0.53046507f, 0.45715368f, -0.07417050f, 0.21625353f, 0.20622215f, 0.24591182f, 
    -0.07618333f, 0.24630471f, -0.01415742f, -0.19910420f, 0.08330917f, -0.07441803f, 0.01044565f, -0.01454591f, 
    -0.11526874f, 0.10496178f, 0.25694910f, -0.25749907f, 0.13233221f, -0.19534136f, -0.33973137f, -0.44827822f, 
    0.16620827f, 0.09794973f, 0.30093879f, 0.07051741f, -0.20197137f, -0.07444523f, -0.18948893f, 0.05746277f, 
    -0.15804631f, -0.00227311f, -0.04530516f, -0.25718781f, -0.34956428f, 0.18010524f, 0.13208774f, -0.30499339f, 
    0.28605360f, -0.15692048f, -0.49817786f, 0.28199247f, 0.31789324f, -0.41015241f, -0.17953779f, 0.10939670f, 
    0.22477114f, 0.27024460f, 0.08983468f, -0.09983437f, -0.07166933f, -0.07515786f, 0.36072937f, 0.10485306f, 
    0.12869273f, -0.13023292f, -0.06463637f, 0.28148660f, -0.34995508f, 0.01372775f, 0.14809111f, -0.05545125f, 
    -0.16588557f, 0.28493938f, -0.04866690f, 0.17974189f, 0.05906187f, -0.02149915f, -0.35849291f, 0.21750043f, 
    0.19284265f, -0.15713432f, -0.09688742f, 0.09645279f, 0.14272298f, -0.24140061f, -0.12847476f, -0.11199583f, 
    -0.09995074f, 0.35720706f, -0.27927041f, 0.26434416f, -0.27178383f, -0.02341999f, -0.14059436f, 0.07250001f, 
    0.02613116f, -0.11711475f, 0.08513599f, 0.23199670f, -0.08912120f, 0.28231612f, 0.16778962f, -1.01787794f, 
    0.44553468f, 0.25619638f, -0.16077390f, 0.07649666f, -0.63956010f, -0.00859811f, 0.18881881f, 0.48627055f, 
    0.17650111f, 0.12387192f, 0.04034712f, -0.11070543f, 0.13934757f, 0.01134348f, -0.07545371f, -0.21283364f, 
    -0.03579652f, 0.03803211f, -0.17888753f, -0.17500238f, -0.00926359f, 0.28280032f, 0.13808987f, 0.07780306f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.01771479f, 0.01578274f, 0.13698289f, -0.03345295f, 0.01726570f, 0.06353291f, 0.23528996f, 0.22811806f, 
    0.11819902f, 0.20607062f, 0.06570602f, 0.02843367f, 0.26446769f, -0.00110101f, 0.14385557f, 0.26176259f, 
    -0.18487130f, 0.01019212f, 0.26439795f, -0.23996525f, 0.13913874f, -0.00548233f, 0.15514757f, 0.14623676f, 
    -0.27307135f, 0.11191219f, -0.21836312f, 0.23791742f, -0.01550930f, -0.02892037f, -0.27231705f, -0.01770288f, 
    0.10254963f, 0.20340225f, -0.14592886f, 0.17540921f, 0.09787233f, -0.04582959f, -0.00763255f, -0.04525791f, 
    -0.13520990f, -0.05501886f, -0.21890126f, -0.03434700f, 0.06080731f, 0.26930940f, 0.07890832f, 0.06157405f, 
    -0.11164764f, -0.19390836f, -0.07972073f, -0.05838136f, -0.20741637f, -0.15746087f, -0.17981745f, -0.16699718f, 
    -0.02548351f, 0.04943084f, -0.03620563f, -0.09851890f, -0.08826462f, -0.06637316f, 0.04313933f, 0.23162438f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.03005287f, 0.01308168f, -0.00403711f, -0.03596558f, 0.01559394f, -0.01637548f, -0.04155768f, -0.00168398f, 
    0.01507843f, -0.03392051f, -0.01565280f, 0.01517416f, 0.00401771f, 0.03369089f, 0.03315337f, 0.01493409f, 
    -0.00927393f, -0.01581805f, 0.00320182f, 0.00267207f, 0.01836662f, -0.00973484f, 0.01621740f, 0.00528142f, 
    -0.00187682f, 0.00744296f, -0.03288190f, -0.04097234f, 0.01948444f, -0.00508724f, -0.00750060f, -0.01165225f, 
    -0.00389403f, -0.02475480f, -0.00938649f, -0.02323714f, -0.04005634f, 0.00111745f, 0.01516594f, 0.02604759f, 
    0.00170105f, -0.02778594f, 0.00458321f, -0.02896186f, 0.00080441f, 0.03243599f, 0.03952669f, -0.00665147f, 
    -0.03264654f, -0.03137571f, 0.02610358f, 0.01879567f, -0.01022653f, 0.01476124f, 0.00487960f, -0.02468688f, 
    -0.00141337f, -0.02470483f, -0.02488437f, 0.00987539f, -0.02866371f, -0.00214360f, -0.01608274f, -0.01898621f, 
    -0.02071922f, -0.01071575f, 0.00444351f, -0.02275486f, -0.01612760f, 0.01402149f, -0.01017417f, 0.03831721f, 
    -0.03683121f, 0.01891290f, 0.01864907f, -0.02098420f, -0.02971680f, -0.02058277f, 0.03912417f, 0.02631921f, 
    -0.00292758f, -0.04190760f, -0.02807807f, -0.04230206f, 0.00445604f, 0.03687794f, -0.00027989f, 0.02709276f, 
    -0.01799429f, -0.01673346f, -0.00469162f, -0.02018583f, -0.00590365f, -0.03918530f, -0.00991840f, -0.02109271f, 
    0.01739901f, -0.02401769f, -0.01193922f, -0.01421742f, -0.01380077f, -0.02043151f, -0.01075828f, -0.00617705f, 
    -0.00864589f, -0.04075684f, 0.01305841f, 0.00400444f, -0.03879048f, 0.02826160f, 0.01805352f, -0.03089256f, 
    0.01569172f, -0.02604595f, 0.02355048f, -0.03315835f, 0.01582523f, -0.02363746f, -0.00935717f, 0.00481442f, 
    -0.03283071f, 0.02199475f, -0.00134135f, 0.00209580f, -0.02164052f, -0.02010800f, -0.00857747f, -0.02436584f, 
    -0.02820356f, -0.04019778f, -0.03436808f, -0.04171185f, 0.01503414f, -0.02524570f, 0.02791192f, 0.02517343f, 
    0.01396816f, -0.01605938f, 0.00342201f, 0.02040197f, 0.01988639f, -0.02091401f, -0.02903020f, 0.00418853f, 
    -0.02143823f, 0.01920704f, 0.02520969f, -0.02933610f, 0.01127075f, 0.02886152f, 0.00641582f, 0.00721952f, 
    -0.00784497f, -0.01238048f, -0.03095532f, -0.03175395f, 0.04095336f, 0.00654272f, 0.00254991f, 0.01109151f, 
    0.02285658f, -0.02995507f, 0.04055051f, -0.00528607f, -0.01673776f, 0.01521771f, 0.02232442f, -0.03156273f, 
    0.00878538f, 0.01659054f, -0.00880556f, -0.04146825f, -0.01227482f, -0.00349384f, -0.01258344f, 0.01897722f, 
    0.01578672f, -0.01139000f, -0.01503373f, -0.02746628f, 0.00988246f, 0.00895044f, -0.01615288f, 0.02225916f, 
    -0.00012928f, 0.01644110f, -0.02534406f, 0.00517760f, 0.02072068f, -0.01931864f, 0.01646443f, -0.00739772f, 
    -0.03365009f, -0.02585005f, -0.01584733f, 0.02840973f, -0.03342272f, -0.00567888f, 0.01466551f, -0.00699159f, 
    -0.03679782f, -0.01660694f, -0.04045989f, -0.00956149f, 0.01288026f, 0.02666375f, 0.01494811f, 0.00558790f, 
    0.00272676f, -0.02038044f, -0.03238517f, -0.00413901f, -0.02474614f, -0.03375901f, -0.00138583f, -0.02666204f, 
    -0.02061955f, 0.02613779f, -0.00361683f, 0.01344310f, -0.02828267f, 0.00678300f, -0.00700208f, -0.00130485f, 
    0.01997263f, 0.00521481f, -0.04131528f, -0.00565986f, -0.02627533f, 0.01988354f, 0.00250675f, 0.01316740f, 
    0.00054609f, 0.01945709f, -0.01565130f, 0.00719407f, -0.01327631f, -0.04094911f, 0.02437179f, -0.01670067f, 
    0.00926496f, 0.01855834f, -0.02176998f, 0.00916997f, 0.00520374f, 0.01530474f, -0.02791067f, -0.00903228f, 
    0.02665677f, -0.03231873f, -0.01414997f, 0.02294082f, 0.00406373f, 0.02874816f, 0.00680026f, 0.00380784f, 
    -0.00920898f, -0.02895697f, -0.01612468f, 0.01604482f, -0.00905164f, -0.02887693f, -0.00846802f, 0.01802782f, 
    -0.00709372f, 0.01153013f, 0.01683374f, 0.01493579f, -0.02681893f, 0.02596543f, 0.00573458f, -0.01582792f, 
    0.01946666f, -0.04322166f, 0.00131354f, 0.02841275f, 0.02801957f, -0.02662820f, -0.01827678f, 0.01456842f, 
    -0.00714668f, 0.01138122f, 0.01023456f, -0.00722929f, 0.02555481f, -0.01458343f, 0.02697548f, -0.03266545f, 
    0.02159344f, -0.00538913f, 0.01052749f, -0.01128080f, -0.02360835f, 0.01434045f, 0.00711295f, 0.02005107f, 
    0.01761664f, 0.04024909f, 0.03907321f, 0.00096878f, 0.03678839f, -0.02426882f, -0.02165610f, -0.01598190f, 
    -0.02516918f, -0.01853438f, 0.01049360f, -0.00667240f, 0.02516994f, 0.02460333f, -0.02845162f, -0.02286577f, 
    -0.01023921f, -0.02402273f, 0.02377881f, -0.03871961f, -0.01067803f, -0.01309796f, 0.02666033f, -0.01541715f, 
    -0.01130571f, -0.00971975f, 0.02915322f, 0.01055210f, 0.01388338f, -0.03946928f, -0.02194248f, -0.01146467f, 
    -0.03004548f, 0.02721769f, -0.01706611f, 0.00178849f, -0.02181878f, -0.00963137f, -0.03679446f, -0.00977417f, 
    0.01563991f, -0.00805414f, -0.02998105f, -0.03584423f, -0.04041610f, 0.01134808f, 0.00827426f, -0.00275953f, 
    -0.00802164f, -0.03895084f, 0.02534594f, -0.00511658f, -0.02987090f, -0.03577459f, -0.01948248f, -0.03481215f, 
    0.00897288f, 0.01005817f, 0.02791385f, 0.03757954f, 0.02435642f, -0.00236128f, -0.01563656f, -0.03463288f, 
    -0.03290049f, -0.02247908f, -0.04185626f, -0.02866774f, 0.01387873f, 0.00819071f, 0.00924876f, -0.02758170f, 
    -0.01526374f, 0.00697681f, 0.01686985f, -0.02885964f, -0.02953816f, 0.02300359f, -0.00033219f, 0.02559887f, 
    0.00651217f, -0.00296810f, 0.00274488f, -0.02861154f, 0.02715318f, -0.01919632f, 0.00183359f, 0.00325002f, 
    -0.01321706f, -0.03330557f, -0.03387813f, 0.01351224f, -0.02027414f, -0.03963312f, 0.01503241f, 0.01668292f, 
    0.02450807f, -0.01979880f, -0.00837803f, -0.01698672f, -0.01792738f, -0.00169423f, -0.02930500f, 0.02589467f, 
    -0.04195549f, -0.03000075f, -0.01320047f, 0.01365992f, -0.01009166f, -0.01545597f, -0.02636919f, 0.00739017f, 
    -0.03353754f, 0.01461908f, -0.03380162f, -0.03132994f, 0.00592050f, 0.01152528f, -0.02942351f, -0.02654071f, 
    -0.00045775f, -0.01943201f, -0.00821026f, -0.01689482f, -0.01163786f, -0.01497528f, 0.00389907f, -0.02698397f, 
    0.01878311f, 0.00923011f, 0.01954904f, 0.02603808f, -0.00784052f, 0.02481525f, -0.01887324f, -0.00220729f, 
    -0.01019277f, -0.02273014f, -0.01367553f, -0.03286775f, 0.02457555f, 0.02215406f, -0.00696182f, -0.02974934f, 
    -0.00003234f, -0.01192175f, -0.01197389f, -0.02436150f, 0.03818212f, -0.02700247f, -0.01221491f, 0.02292774f, 
    -0.02071842f, -0.01616260f, -0.01611249f, 0.02816612f, 0.01132764f, -0.02720482f, -0.00644952f, -0.01817041f, 
    0.04146713f, 0.02893220f, 0.01241611f, -0.00059805f, 0.01157958f, 0.02746663f, 0.01828813f, 0.01419951f, 
    -0.04170804f, 0.01530780f, 0.02523160f, -0.01775251f, -0.01273048f, 0.00268292f, -0.04106845f, -0.00563799f, 
    -0.00922922f, -0.03916013f, -0.02540773f, -0.03447924f, 0.01276476f, 0.02790907f, -0.03507436f, -0.04190369f, 
    -0.03471131f, 0.00898587f, -0.00036762f, 0.01180479f, 0.01258904f, -0.00816450f, -0.01343559f, 0.02477874f, 
    -0.00289269f, -0.00664008f, 0.01920222f, 0.00000795f, -0.00346228f, 0.01270517f, -0.01421403f, -0.00320661f, 
    -0.00886514f, 0.02528229f, -0.01248062f, 0.00548216f, 0.01421266f, -0.02453402f, 0.00266426f, 0.00239581f, 
    0.02728507f, 0.03593218f, -0.02670664f, 0.00313120f, 0.02394035f, -0.01062333f, 0.02514197f, 0.02639831f, 
    0.01294861f, 0.00881600f, 0.02983236f, -0.03068993f, 0.00085253f, -0.03351263f, -0.01596770f, 0.02461700f, 
    -0.03891030f, -0.02781954f, 0.01560560f, 0.00805876f, -0.01984631f, -0.02225984f, 0.01205269f, -0.00122589f, 
    0.01065423f, 0.00883836f, 0.02008960f, -0.02267455f, 0.02990088f, 0.02252911f, 0.00753402f, 0.00716351f, 
    -0.01571516f, -0.02495201f, -0.02945795f, 0.02096297f, -0.03025189f, -0.02410814f, 0.01249350f, 0.00385079f, 
    0.00339211f, 0.00520043f, -0.02307058f, -0.01211614f, -0.02105142f, -0.03905350f, -0.00486716f, -0.02547870f, 
    0.02039686f, -0.00811765f, 0.00400703f, 0.01131859f, 0.02330028f, -0.02728168f, -0.03871771f, 0.01602182f, 
    -0.03681017f, -0.00480067f, -0.03618661f, -0.04047913f, -0.01758912f, 0.02478384f, 0.02017999f, 0.00304218f, 
    0.00741082f, -0.01262298f, -0.02624079f, -0.02207938f, 0.02317381f, -0.01760622f, 0.00719925f, -0.01494687f, 
    -0.01470265f, -0.01981330f, -0.03156374f, -0.03083388f, 0.02234810f, -0.02644311f, -0.01904257f, -0.03941626f, 
    -0.03235103f, 0.01280860f, -0.00395787f, -0.03324545f, -0.02398133f, -0.02669371f, -0.00105768f, -0.03574668f, 
    -0.00317593f, -0.00490662f, 0.02724449f, 0.01227101f, 0.00840445f, 0.03567275f, 0.00443689f, -0.00843557f, 
    -0.00768999f, -0.03259199f, 0.01580488f, -0.01853269f, -0.02724804f, -0.01283391f, 0.02344905f, -0.01285121f, 
    -0.04154877f, 0.01637819f, 0.01384398f, -0.03131974f, -0.00447009f, 0.01864840f, 0.02773533f, -0.00579123f, 
    0.01610792f, 0.00101785f, -0.00849735f, -0.02833316f, -0.00054643f, -0.03864846f, 0.02791901f, -0.01273356f, 
    0.00553293f, -0.01853808f, -0.02213997f, 0.01742719f, 0.03295682f, -0.01917113f, 0.00967302f, -0.02957239f, 
    -0.03376723f, -0.01680584f, 0.01803002f, 0.03585842f, -0.03538107f, -0.00749219f, -0.01402556f, -0.02891008f, 
    0.00344985f, -0.01220828f, -0.00919237f, -0.02979343f, 0.02445620f, 0.02626967f, -0.03966177f, 0.02154826f, 
    -0.00471252f, 0.01889126f, 0.00754822f, -0.02297495f, 0.01584644f, 0.01748766f, 0.00499462f, -0.01467082f, 
    -0.01879158f, -0.04203345f, -0.01183694f, 0.01886460f, -0.01904303f, -0.03656865f, -0.02113521f, 0.01632360f, 
    0.02268181f, -0.02739333f, 0.02766030f, -0.01858349f, -0.00358344f, -0.01018645f, 0.02147505f, 0.00258791f, 
    -0.02031532f, -0.00754882f, 0.01386878f, 0.00745715f, -0.03956156f, -0.00116999f, -0.03722295f, -0.02212380f, 
    -0.01320794f, 0.00217252f, 0.02175077f, -0.00258278f, 0.02590528f, -0.01998462f, -0.02477757f, 0.02774954f, 
    0.00509691f, 0.00655301f, -0.02233112f, 0.01024054f, 0.01676670f, -0.02448590f, 0.01971126f, -0.03028457f, 
    -0.03424222f, -0.00869848f, 0.01502491f, -0.00567392f, 0.00726281f, -0.02793571f, -0.03942135f, -0.00531958f, 
    -0.00306238f, 0.01724460f, 0.01514574f, 0.02839524f, 0.01944742f, -0.00846133f, -0.01369308f, 0.00800972f, 
    0.00811209f, -0.00796772f, 0.01421857f, 0.00080574f, -0.01741529f, -0.02376835f, 0.01977876f, -0.01683182f, 
    -0.01798123f, 0.01248703f, 0.00604808f, 0.02943840f, 0.00038793f, 0.02126825f, 0.00139534f, 0.01270033f, 
    0.02245953f, 0.01396445f, -0.02674889f, -0.00912998f, -0.01071724f, 0.00225287f, 0.01404235f, -0.03085396f, 
    -0.01171779f, 0.02266449f, -0.01229474f, 0.01189731f, 0.02219030f, -0.03323136f, -0.01204007f, 0.01564160f, 
    0.01311390f, -0.03955695f, 0.01021678f, -0.00506901f, 0.01939123f, 0.04106569f, -0.02863110f, 0.00113197f, 
    0.02051101f, 0.02869536f, 0.02414691f, -0.03862876f, 0.01947170f, 0.01766277f, -0.00180809f, 0.00301598f, 
    -0.02753541f, 0.01719772f, -0.00208187f, 0.00761035f, -0.00172181f, -0.04152989f, 0.02780608f, 0.00337740f, 
    -0.07693636f, 0.14763835f, 0.03295306f, 0.14299558f, 0.06243216f, 0.00709477f, 0.10105950f, -0.03976341f, 
    0.10767090f, -0.05444843f, 0.02901882f, 0.21587859f, -0.14072682f, 0.16481988f, 0.09854771f, 0.06248933f, 
    0.03502354f, 0.06029407f, -0.02397727f, 0.15104410f, 0.01405119f, 0.11721727f, 0.11005287f, 0.06400978f, 
    -0.19901969f, 0.22336721f, 0.00020351f, 0.14986718f, 0.04570952f, 0.07988847f, -0.01916001f, 0.08668550f, 
    -0.09654687f, 0.00932241f, -0.11327135f, 0.02338350f, 0.02241323f, 0.01073441f, 0.03254322f, -0.09917446f, 
    -0.01703528f, -0.09833338f, 0.17421597f, 0.09920549f, 0.11675055f, 0.09108825f, 0.12785220f, 0.16673696f, 
    0.14272550f, -0.04856206f, 0.10553709f, 0.00524685f, 0.13665240f, 0.13092661f, -0.03241256f, -0.00107271f, 
    -0.08576501f, -0.09553199f, -0.07046016f, -0.03414875f, 0.24786364f, 0.11396443f, -0.23376192f, 0.34460211f, 
    -0.02819612f, -0.10819358f, 0.12353739f, -0.05199368f, 0.03788052f, -0.00486535f, 0.06271131f, 0.06138857f, 
    -0.04853430f, 0.17779699f, 0.22892797f, 0.05608999f, 0.00418192f, 0.01627579f, 0.10636029f, 0.01708851f, 
    0.01443908f, -0.00004568f, -0.00774060f, 0.16914324f, -0.05790153f, -0.07653448f, 0.21770836f, 0.09241183f, 
    0.05695196f, 0.10329619f, -0.01099530f, 0.08476176f, 0.00231270f, -0.01517110f, 0.10067194f, 0.03595006f, 
    0.55458009f, 0.10245080f, -0.00162594f, -0.10115302f, 0.19560358f, 0.01206809f, 0.15429443f, 0.05708561f, 
    -0.03888105f, 0.00340754f, -0.04864498f, -0.06596076f, -0.10900968f, 0.02430855f, -0.12036424f, -0.04091867f, 
    0.04901493f, 0.04711293f, -0.00117406f, 0.07910402f, 0.20166832f, 0.19801229f, 0.25881308f, 0.20137322f, 
    -0.17711729f, -0.09465237f, -0.02729932f, 0.12549697f, 0.01754223f, -0.04831192f, -0.21648975f, -0.03691418f, 
    0.09246799f, -0.05940254f, -0.08629254f, -0.01444888f, -0.23388980f, -0.09607524f, 0.14755948f, 0.03389526f, 
    0.02918013f, 0.02087568f, -0.05901479f, 0.07054712f, -0.22332263f, 0.09921566f, 0.13631159f, -0.05912741f, 
    -0.10739424f, 0.08538497f, 0.24162045f, -0.13207074f, 0.01987494f, 0.03829659f, 0.00125116f, 0.07504395f, 
    0.02163279f, -0.00071160f, -0.00291349f, -0.01604073f, -0.09454166f, -0.20701011f, 0.05918412f, 0.19366512f, 
    0.05190098f, 0.07152281f, 0.02883811f, -0.11934886f, 0.02771218f, 0.02482184f, -0.08853768f, 0.06278495f, 
    0.00015548f, -0.11516504f, 0.07904490f, 0.04410182f, 0.02962802f, -0.03803142f, -0.04515906f, -0.07549877f, 
    -0.02697787f, -0.12898147f, -0.09848996f, -0.08264963f, 0.18867069f, 0.12511866f, 0.08884782f, 0.11283199f, 
    0.08018859f, 0.06173342f, 0.11243996f, 0.04358882f, -0.05898781f, 0.05500326f, -0.03728498f, 0.00654823f, 
    -0.07834685f, 0.00243141f, -0.06612867f, 0.10152520f, -0.04940576f, 0.03557514f, 0.09956364f, 0.14821269f, 
    0.06279380f, 0.18739004f, -0.10418146f, -0.07585423f, 0.14574450f, -0.11148334f, 0.22554995f, 0.10976095f, 
    0.09069740f, -0.02298368f, 0.09084045f, 0.02973108f, -0.03989257f, -0.03242512f, -0.06828650f, -0.06146706f, 
    0.24073596f, 0.01030261f, -0.00458714f, 0.19359185f, 0.06475566f, -0.05085880f, 0.06806423f, 0.17451762f, 
    0.02313356f, -0.05510457f, 0.01716137f, -0.10182095f, 0.09034881f, 0.07655308f, -0.19436216f, 0.14914142f, 
    -0.09346479f, 0.04318701f, 0.02429724f, -0.02619745f, 0.04940392f, 0.07152887f, 0.01072531f, 0.10417172f, 
    -0.29149225f, -0.01420146f, 0.00223014f, 0.33056211f, 0.11237064f, 0.05348596f, 0.18688537f, -0.12820026f, 
    0.02080648f, 0.06885710f, 0.10464616f, 0.09953415f, 0.29673311f, -0.08529686f, -0.18198198f, -0.03395248f, 
    -0.10438302f, -0.04017080f, 0.04406893f, 0.04114942f, -0.02665624f, 0.10574228f, 0.13572524f, 0.00202372f, 
    0.05512486f, 0.26799974f, 0.30072451f, -0.32306570f, -0.00738514f, -0.03295178f, -0.14698148f, 0.21416338f, 
    -0.08525711f, 0.23194481f, -0.04260550f, -0.17728856f, 0.20548700f, -0.22014123f, 0.13619073f, 0.07824757f, 
    0.02186944f, 0.09060023f, 0.11576790f, -0.09704876f, 0.16854568f, -0.07697884f, 0.02488170f, 0.07152899f, 
    -0.16720696f, -0.20975004f, 0.04735489f, 0.09998827f, 0.00642065f, 0.03718157f, 0.11722273f, -0.13800894f, 
    0.06131827f, 0.05563356f, 0.00726774f, -0.07130046f, -0.10106248f, 0.03505383f, 0.06702713f, 0.12140168f, 
    0.04484552f, -0.05234527f, 0.00834344f, -0.08082786f, 0.12016426f, 0.08043487f, 0.31183094f, 0.20316735f, 
    -0.18977569f, -0.15772764f, 0.05993061f, 0.08687133f, -0.10800229f, -0.02149348f, -0.07799359f, -0.08816297f, 
    -0.09245511f, -0.11647391f, -0.09234577f, -0.25268441f, -0.31374592f, 0.16895458f, 0.23908798f, 0.18537478f, 
    0.02267066f, -0.05011990f, -0.08767390f, 0.11205669f, -0.01405806f, 0.08128272f, 0.06530343f, 0.05847622f, 
    -0.04128969f, -0.18037200f, 0.21827239f, 0.11757283f, 0.15014467f, 0.03509343f, -0.03119017f, 0.03150306f, 
    0.19197775f, 0.10018470f, 0.03878662f, 0.08562407f, -0.16726501f, 0.15268038f, -0.08369016f, 0.21876986f, 
    0.11303706f, -0.13383074f, 0.05943454f, 0.07164431f, -0.10880051f, -0.12712170f, -0.09272244f, 0.11488961f, 
    -0.13608372f, -0.07086147f, -0.10946374f, -0.00695317f, -0.14847590f, -0.16774942f, -0.07075269f, -0.07230214f, 
    0.05535663f, 0.03531451f, 0.02130277f, -0.04414996f, -0.16486081f, 0.04627731f, 0.14309628f, 0.25625715f, 
    -0.05967340f, -0.06235659f, 0.00229930f, 0.11007063f, 0.00162436f, 0.04810481f, -0.03209692f, 0.08026925f, 
    0.18133998f, -0.03194266f, -0.04839242f, -0.03637490f, -0.03400258f, -0.03756384f, 0.02730990f, 0.08467931f, 
    -0.09635705f, -0.10214238f, -0.06738504f, -0.00399006f, 0.13632140f, -0.10869683f, 0.08332141f, 0.10502309f, 
    0.03679804f, 0.10431389f, 0.01245039f, 0.00164370f, -0.00685115f, 0.07151168f, -0.03101029f, -0.09000018f, 
    -0.01094337f, -0.05883320f, 0.20963597f, 0.05350965f, 0.02478964f, 0.08514797f, 0.02155202f, -0.05908038f, 
    0.11396802f, 0.04075652f, 0.12399009f, 0.08255576f, 0.02906912f, -0.02678723f, 0.32989019f, 0.12667817f, 
    0.18047190f, 0.13111806f, -0.08762374f, -0.13419312f, -0.01624006f, 0.00306005f, -0.02977507f, 0.16561140f, 
    0.28801954f, 0.03982010f, 0.12072282f, -0.07364026f, 0.11697643f, -0.00384757f, 0.00356577f, -0.00469544f, 
    0.00252799f, 0.04078411f, 0.12627128f, -0.00926351f, -0.07886265f, 0.00830554f, -0.07727332f, 0.17193338f, 
    -0.03641864f, 0.09152506f, 0.02537685f, -0.01190491f, 0.08561645f, 0.11229362f, -0.08094466f, -0.04178135f, 
    -0.29658815f, -0.05618555f, -0.03691805f, 0.29015923f, 0.04580883f, 0.01228566f, 0.04962971f, 0.10638430f, 
    0.08300631f, 0.17463531f, 0.16611898f, 0.12006919f, -0.10299495f, 0.10472756f, 0.14938006f, 0.19636822f, 
    -0.02468870f, -0.01989585f, 0.08720817f, 0.04499993f, -0.05665469f, 0.03398260f, -0.06056948f, -0.09808440f, 
    0.07106779f, 0.02300164f, -0.13353771f, -0.00429994f, -0.04166283f, 0.04275048f, 0.01748361f, 0.01699234f, 
    0.16583867f, 0.06596719f, 0.02182986f, 0.12362464f, -0.24250695f, 0.00440644f, -0.07693856f, -0.03235720f, 
    0.00999996f, 0.01797349f, 0.13655785f, 0.08837619f, -0.05708936f, 0.05980124f, 0.08478177f, 0.10169595f, 
    -0.08702796f, -0.19692612f, 0.10200700f, -0.02561843f, 0.00449171f, -0.09785620f, -0.02933097f, -0.28190914f, 
    -0.11940071f, -0.08860307f, -0.12585293f, -0.14757720f, -0.21080305f, 0.05414076f, 0.20075972f, 0.18120930f, 
    -0.02657219f, 0.03885109f, 0.01357232f, 0.08187898f, 0.00399924f, 0.01256950f, 0.00005565f, 0.07173777f, 
    0.27599227f, 0.10341264f, -0.07058673f, -0.03195868f, -0.08140909f, 0.01550329f, -0.10657864f, 0.22104025f, 
    -0.10456808f, -0.00570280f, -0.05211495f, -0.18040602f, 0.22992015f, 0.09491123f, -0.03781946f, 0.12561254f, 
    0.05686479f, 0.05167518f, 0.18841909f, -0.09731673f, 0.02222118f, 0.03451135f, -0.03901784f, -0.02696372f, 
    -0.00132909f, -0.02672824f, -0.06991436f, 0.12610568f, 0.04495275f, 0.04117632f, 0.13205892f, 0.10188650f, 
    -0.00011735f, 0.01086818f, -0.04822897f, 0.05444960f, -0.04484598f, -0.07013746f, 0.01885003f, 0.00639518f, 
    0.00851537f, -0.01411507f, -0.09991612f, -0.13197753f, 0.02952112f, -0.10713743f, -0.13317220f, -0.12699974f, 
    -0.00066278f, 0.21386567f, -0.19481266f, -0.25757477f, -0.03953160f, -0.05612837f, 0.10201512f, 0.02081989f, 
    0.02117706f, 0.08119794f, 0.22174960f, 0.16880660f, -0.15788937f, -0.05916566f, 0.01897709f, 0.03522912f, 
    -0.08433673f, -0.14041163f, -0.03455332f, -0.10191187f, 0.13541578f, 0.13039412f, 0.05914292f, 0.04713030f, 
    -0.07461490f, -0.00653741f, -0.01772320f, 0.05781879f, 0.14914519f, 0.01997972f, -0.06401289f, 0.11257233f, 
    -0.05416405f, 0.02942150f, -0.02056136f, -0.16592470f, -0.17178595f, -0.04050767f, -0.19370076f, 0.05551395f, 
    0.03112805f, 0.07322726f, 0.02990702f, 0.08944024f, 0.22409885f, 0.08221109f, 0.11502363f, 0.26398680f, 
    -0.22311452f, -0.04312790f, -0.16164799f, 0.09721101f, -0.13000153f, 0.09119213f, -0.01706495f, -0.09789313f, 
    0.03294297f, 0.06892966f, 0.14852343f, 0.16001847f, -0.18435666f, -0.11548726f, -0.05724404f, -0.01860315f, 
    0.01234473f, 0.00356599f, -0.04460145f, 0.01580391f, 0.07212220f, 0.02835808f, 0.03742046f, 0.02458253f, 
    -0.20672965f, -0.11040494f, -0.01386231f, 0.01816104f, 0.10133789f, -0.05694157f, -0.10921210f, -0.12426379f, 
    -0.04570629f, -0.10661060f, -0.13741694f, -0.07638311f, -0.16796374f, 0.07396687f, -0.03376206f, 0.13616721f, 
    0.08029816f, 0.02944651f, 0.03961397f, 0.05154849f, 0.06935065f, -0.03636856f, -0.01655429f, -0.04712681f, 
    0.12782736f, -0.02076153f, -0.13605197f, -0.10068307f, -0.04399507f, 0.04759419f, -0.01422776f, -0.07102869f, 
    0.20926216f, 0.21297255f, 0.14256857f, 0.20732349f, 0.00859017f, -0.07649939f, 0.24322659f, -0.06440949f, 
    0.00822627f, -0.02503272f, 0.01091377f, -0.02412733f, 0.11206367f, 0.16353144f, 0.22908789f, 0.00966831f, 
    0.00288099f, 0.05974752f, 0.16320473f, -0.04282461f, 0.08546162f, 0.05208488f, -0.01122875f, 0.19028802f, 
    -0.18410648f, -0.06868386f, -0.11951639f, 0.03999170f, -0.04843579f, 0.31983426f, 0.17211533f, 0.10456105f, 
    -0.21466973f, -0.12373012f, 0.09842494f, 0.09877457f, -0.03176376f, 0.09716558f, -0.02502974f, -0.08330851f, 
    -0.11946916f, -0.05499427f, -0.02665054f, -0.09354829f, 0.03880509f, -0.15544967f, 0.00037766f, -0.04832945f, 
    -0.11381470f, 0.12073706f, -0.01092651f, 0.01781725f, -0.08808624f, 0.10960882f, -0.07773928f, 0.18865864f, 
    0.08006010f, -0.05427171f, 0.05631865f, 0.01206217f, 0.08716929f, 0.11169949f, 0.00135409f, -0.03592785f, 
    0.00823455f, 0.02001110f, 0.04110648f, 0.02953649f, 0.07965407f, 0.00007229f, 0.08403074f, -0.10726754f, 
    -0.08526602f, -0.06977565f, -0.22281332f, -0.04661680f, -0.02071186f, 0.04350220f, -0.01140519f, 0.16233994f, 
    -0.05845600f, -0.02227069f, 0.02094503f, 0.07523914f, -0.03975264f, 0.10389526f, 0.10403413f, 0.02512283f, 
    -0.15206301f, -0.30570412f, -0.02473591f, 0.13006638f, 0.04302627f, 0.00381927f, 0.04115372f, -0.02478783f, 
    0.07249726f, -0.07196973f, 0.05592407f, 0.05993493f, 0.04195282f, -0.12107553f, 0.14755669f, -0.03603637f, 
    0.10541352f, 0.11648556f, 0.01686885f, 0.11604554f, 0.02679142f, 0.01734320f, 0.10164730f, 0.03154884f, 
    -0.02459044f, -0.03898354f, 0.13126996f, -0.15552631f, 0.12623316f, 0.00166206f, 0.01735172f, -0.03242327f, 
    0.01306592f, 0.05627615f, -0.16021991f, 0.05327898f, -0.01382525f, 0.00728071f, -0.04451579f, -0.04111961f, 
    0.04315012f, 0.05286135f, 0.00172978f, 0.02903220f, 0.10017404f, 0.01464167f, 0.10433363f, 0.18453281f, 
    0.15662345f, -0.29389343f, 0.22856241f, 0.32563150f, 0.05984513f, 0.15065937f, -0.08370909f, 0.27437761f, 
    -0.14904699f, -0.22308645f, -0.09889405f, -0.31109732f, -0.10158414f, -0.01237608f, -0.20092633f, -0.11136737f, 
    -0.05010615f, -0.12446732f, -0.14238228f, -0.20792089f, 0.00338726f, -0.11266232f, 0.03060754f, -0.00116477f, 
    0.06383650f, -0.14578460f, -0.05827641f, 0.06917242f, 0.10682148f, 0.03078235f, -0.02481179f, 0.02204573f, 
    -0.12257950f, 0.05974005f, 0.03602684f, 0.09823864f, 0.03409599f, -0.16277163f, 0.02738163f, 0.04607864f, 
    0.13998255f, 0.00551159f, -0.00254826f, 0.07532942f, 0.01062537f, 0.04870097f, 0.06738259f, 0.02163624f, 
    -0.13096237f, 0.28923458f, -0.21483475f, 0.11209291f, -0.10200896f, 0.03705288f, -0.00996960f, -0.05815254f, 
    0.06186773f, -0.09005029f, 0.03322120f, 0.05699134f, 0.00208396f, -0.05303964f, -0.03853699f, -0.08906586f, 
    -0.03254660f, -0.04067298f, -0.03922467f, 0.06103527f, -0.10612474f, 0.08908159f, 0.03687066f, 0.08485100f, 
    0.29452184f, 0.15320361f, 0.10188714f, -0.08401537f, 0.03057963f, 0.03006231f, -0.00129330f, 0.07516013f, 
    0.16981354f, -0.06504699f, -0.00481165f, 0.03957766f, -0.15810639f, -0.04249918f, -0.26282927f, 0.00874774f, 
    0.29177579f, 0.02751125f, -0.01239417f, -0.10741373f, 0.14251077f, 0.06674994f, 0.01749809f, -0.09496705f, 
    -0.06624352f, -0.13072319f, -0.21584101f, -0.05386849f, 0.02498180f, 0.04178834f, 0.02267783f, -0.00201612f, 
    0.01825524f, -0.08633788f, -0.12413050f, -0.01315575f, 0.13856259f, 0.14384791f, 0.21488136f, 0.17046295f, 
    0.05442327f, 0.15298744f, 0.06108265f, 0.15891001f, 0.09991514f, -0.01075156f, -0.00849459f, 0.03380083f, 
    0.19268125f, 0.13046828f, 0.13557258f, 0.13397755f, 0.15177833f, 0.08660006f, 0.08291803f, 0.03241961f, 
    -0.01083639f, -0.01929989f, 0.02628144f, -0.10652977f, -0.04797957f, -0.40154943f, 0.13770476f, 0.10228252f, 
    0.03538581f, 0.06724464f, 0.02234372f, -0.10859291f, -0.10461237f, -0.08552425f, -0.14516866f, 0.05219240f, 
    0.15927067f, -0.46092096f, 0.04687819f, 0.01889884f, 0.08983103f, -0.05723827f, -0.04506304f, 0.18489754f, 
    -0.05660020f, 0.19986534f, -0.00174725f, -0.13398342f, 0.38935393f, -0.14582349f, 0.00161019f, 0.24130620f, 
    0.13018651f, 0.02677509f, -0.12221908f, 0.02129573f, 0.09747165f, 0.02226229f, -0.01203847f, -0.25210968f, 
    -0.14574015f, -0.37410545f, -0.34041405f, -0.15215372f, 0.04491804f, -0.03275558f, -0.16022100f, 0.02487336f, 
    -0.06666755f, -0.03073161f, -0.03457553f, -0.20443602f, -0.03614745f, -0.31569752f, -0.06774136f, 0.05281927f, 
    0.01732193f, 0.13636951f, -0.00121491f, -0.04264460f, -0.03761845f, 0.00444203f, 0.03016159f, 0.20170587f, 
    -0.16269493f, -0.01640521f, 0.05446129f, -0.11847540f, 0.01972721f, 0.10567404f, 0.09382460f, -0.13751522f, 
    0.07099061f, 0.09836400f, 0.02616165f, 0.12633450f, 0.24783914f, -0.03681003f, -0.24534516f, 0.10521833f, 
    -0.15431818f, 0.02945604f, -0.00353040f, -0.00486290f, 0.11310730f, -0.01464733f, 0.11245351f, 0.06149320f, 
    -0.16226386f, 0.11839817f, -0.07247414f, 0.11910248f, -0.12862831f, -0.00507175f, -0.10653023f, -0.07160658f, 
    0.10583027f, 0.04599936f, -0.05474599f, 0.05766862f, 0.01976469f, -0.05367627f, -0.00374340f, 0.00053267f, 
    -0.04049837f, 0.11252093f, 0.02106475f, -0.06488764f, 0.12451269f, -0.04479399f, -0.06276172f, 0.13210912f, 
    0.04696428f, 0.14596558f, -0.01615602f, 0.10187472f, 0.22383818f, 0.13744964f, 0.14071406f, -0.00406979f, 
    0.14655931f, 0.11289117f, 0.14242965f, 0.13480134f, 0.16989271f, 0.00310594f, -0.00799079f, 0.02645131f, 
    0.07459266f, -0.00452282f, 0.02734146f, 0.00484590f, -0.00161392f, -0.03365720f, 0.05360869f, 0.13545835f, 
    0.01292556f, -0.02120116f, 0.05942294f, 0.05437719f, -0.02451709f, -0.00323155f, 0.03158687f, 0.03814875f, 
    0.00926899f, -0.12991914f, 0.07793422f, 0.06728872f, 0.03987601f, -0.02600742f, -0.06215364f, 0.02158171f, 
    -0.00777429f, -0.02792892f, -0.06469413f, -0.15371986f, 0.05280837f, -0.01555149f, -0.03317283f, 0.02406737f, 
    0.02690772f, -0.18968198f, 0.05943526f, 0.13834046f, 0.03130114f, 0.11454566f, 0.05947990f, 0.01260003f, 
    0.05705820f, -0.11767690f, -0.17482901f, -0.02795787f, -0.13783801f, 0.01824720f, -0.17545758f, -0.03011660f, 
    -0.02602312f, -0.06420911f, 0.00912538f, 0.08514297f, -0.07987934f, 0.05957081f, -0.02829538f, 0.19544470f, 
    0.12432947f, 0.10458188f, -0.08409523f, 0.26194203f, 0.02142864f, 0.01120819f, 0.13629110f, 0.03553689f, 
    0.00313578f, -0.08738705f, -0.01570209f, 0.08185846f, 0.22164828f, -0.16678703f, 0.14520118f, -0.05584630f, 
    -0.09468231f, 0.00656917f, -0.05797315f, -0.04929936f, -0.01927693f, -0.07209878f, -0.06864826f, -0.00211314f, 
    -0.04804043f, -0.33611959f, 0.08027230f, 0.07349525f, 0.01278117f, 0.04614142f, -0.09489340f, 0.05140293f, 
    -0.15477568f, -0.19081596f, -0.18848658f, -0.10230841f, -0.01791641f, -0.07816953f, -0.07639880f, 0.03157127f, 
    -0.01132873f, 0.06225197f, 0.02475997f, -0.09725209f, -0.08240175f, -0.02460131f, -0.05648082f, -0.07799064f, 
    -0.25152031f, -0.39403066f, -0.26833954f, -0.11218733f, 0.13595474f, 0.09846047f, -0.01925446f, -0.02976741f, 
    0.06315441f, 0.01629689f, 0.02775901f, -0.07045362f, -0.02200319f, -0.01880318f, -0.08397277f, 0.16051999f, 
    -0.02380800f, 0.15129687f, -0.16143875f, -0.21196362f, -0.01129552f, 0.01669296f, -0.12366026f, -0.12247220f, 
    -0.27524117f, -0.05403358f, -0.24647714f, 0.17035004f, 0.15272100f, -0.08342981f, -0.08403291f, 0.05030441f, 
    0.12117305f, -0.09125416f, 0.11770593f, -0.27046406f, 0.04696441f, 0.11231998f, -0.01382816f, 0.11702675f, 
    0.14673603f, 0.05582494f, 0.12848200f, 0.06627655f, 0.13948320f, 0.00403772f, -0.11226286f, 0.06810458f, 
    -0.04673717f, -0.07894928f, 0.18805051f, -0.09628544f, -0.06034525f, 0.08253296f, 0.08861121f, 0.00468462f, 
    -0.00727533f, 0.17455544f, -0.00254305f, 0.09219799f, -0.01115366f, 0.06752913f, -0.12023538f, 0.00185208f, 
    -0.06804685f, -0.04125143f, -0.00845738f, -0.25368401f, -0.03251798f, -0.00856335f, -0.04616389f, -0.07432923f, 
    -0.27786490f, -0.28014642f, -0.17375709f, 0.12630665f, -0.09153000f, 0.21348517f, 0.06418218f, -0.07433543f, 
    -0.01017478f, -0.09213844f, 0.00426589f, 0.17201886f, -0.12792598f, 0.00245476f, -0.22479424f, -0.19092023f, 
    0.13285945f, -0.04495781f, 0.00488838f, 0.06578884f, 0.15537040f, -0.00868208f, 0.07436796f, 0.04818968f, 
    0.19499037f, -0.00073507f, 0.19006614f, 0.01282370f, 0.19664039f, 0.05267472f, 0.06281163f, -0.07672800f, 
    -0.03316026f, -0.11873411f, 0.02455640f, -0.02507172f, 0.07014764f, 0.07275233f, -0.04736685f, -0.00422939f, 
    -0.05760741f, -0.01945864f, -0.12450689f, -0.01236451f, 0.06764308f, -0.00094059f, -0.03339794f, -0.06621928f, 
    0.01464260f, -0.02858251f, 0.08320815f, 0.04852252f, -0.00423503f, -0.05130106f, -0.19859827f, -0.06102367f, 
    -0.02237242f, -0.12023483f, -0.12912473f, -0.14833298f, 0.12571047f, 0.06490231f, 0.06782338f, 0.08600365f, 
    -0.11309256f, 0.05475151f, -0.03583084f, -0.04252439f, -0.07130469f, 0.04815773f, 0.05539846f, -0.04430102f, 
    -0.16761297f, -0.15474638f, -0.23042133f, -0.15086481f, 0.04841047f, -0.03214798f, 0.06528365f, -0.17121078f, 
    0.10492377f, 0.02602150f, -0.00384788f, -0.03016020f, 0.33996814f, 0.24968995f, 0.21386185f, 0.07459057f, 
    0.05543711f, -0.01186871f, 0.08591844f, 0.17412132f, 0.05152677f, -0.06389355f, -0.05462626f, -0.13844933f, 
    -0.17182538f, 0.03264645f, -0.14107625f, -0.10587547f, -0.07089256f, -0.09804773f, -0.08996116f, 0.11860705f, 
    -0.09945288f, 0.01777162f, 0.02212605f, 0.16997930f, 0.13093758f, 0.33588621f, 0.16762407f, 0.05815791f, 
    -0.03686926f, -0.03503566f, 0.04579811f, -0.01392391f, 0.14894974f, 0.07434405f, 0.04555780f, 0.08737335f, 
    -0.09121910f, -0.00610665f, 0.19415376f, -0.02968562f, 0.00026148f, 0.07408673f, -0.09060068f, -0.13829857f, 
    -0.12392543f, -0.10074413f, -0.15433060f, -0.16713093f, -0.08571456f, -0.48552123f, -0.21262124f, -0.20332341f, 
    0.11905566f, 0.01053020f, 0.09054767f, -0.00011424f, 0.35195312f, -0.04630104f, 0.01089519f, 0.08809691f, 
    0.20435613f, 0.19434193f, -0.11298954f, 0.20679109f, 0.04980885f, 0.15254100f, 0.14612237f, 0.17843138f, 
    -0.04499785f, -0.06193610f, 0.12436098f, 0.13130954f, 0.11838913f, 0.06277455f, 0.01049462f, 0.00837824f, 
    0.00822929f, 0.18858962f, 0.03851658f, 0.02608091f, 0.02905409f, -0.02592846f, 0.01901135f, -0.02515156f, 
    0.17577229f, 0.08337504f, 0.15486659f, 0.10299969f, 0.13543314f, 0.09111259f, -0.06081875f, 0.07233237f, 
    0.13009156f, 0.10007904f, -0.02866269f, 0.05897224f, 0.10308378f, -0.12763724f, 0.04256107f, -0.10578015f, 
    -0.08006839f, 0.02179519f, -0.11356436f, -0.24351057f, 0.12720570f, 0.01364647f, -0.02441772f, 0.03034302f, 
    -0.03890966f, -0.23236589f, -0.23252134f, 0.03777563f, -0.04912508f, -0.02338430f, 0.01424464f, -0.09684265f, 
    0.13811557f, 0.06833841f, 0.00832053f, 0.15241094f, -0.07658271f, -0.15429357f, -0.15442924f, 0.08105112f, 
    0.02717919f, -0.11101482f, 0.05110566f, -0.07135252f, 0.06126200f, -0.10884647f, 0.07758995f, 0.12868617f, 
    0.05341865f, 0.13813166f, -0.20138389f, -0.11605525f, 0.03259045f, -0.03117551f, -0.05864409f, -0.00343113f, 
    -0.02700471f, -0.11748567f, -0.00960866f, 0.07096442f, 0.19939445f, -0.13697504f, 0.04965586f, 0.12727818f, 
    0.05643427f, -0.13633794f, 0.02006091f, -0.05568513f, 0.09018979f, 0.00894289f, -0.03199745f, 0.03100917f, 
    -0.03197773f, 0.07576185f, -0.19127895f, 0.18291858f, 0.15216379f, 0.00296137f, -0.04429641f, -0.08579807f, 
    -0.05112932f, 0.05262917f, 0.00777721f, 0.01334604f, -0.06397781f, -0.29613978f, 0.00678115f, 0.09442336f, 
    0.05926186f, -0.14100635f, -0.00201600f, -0.16963455f, -0.12504753f, -0.10481903f, -0.04543129f, 0.06212607f, 
    -0.01652268f, 0.09198570f, -0.21107656f, 0.04084921f, 0.02199648f, -0.00232117f, 0.00557335f, -0.13817658f, 
    -0.03743818f, -0.05678389f, -0.25455195f, -0.23514768f, -0.25523153f, 0.01086608f, 0.05321646f, 0.16475885f, 
    -0.16634372f, -0.06915815f, -0.05869231f, -0.10399742f, 0.00565337f, -0.05800394f, -0.01795977f, -0.04166930f, 
    -0.07737623f, 0.20704852f, -0.04931618f, 0.05408084f, -0.09116418f, -0.08335996f, 0.01284777f, 0.04358879f, 
    -0.15490866f, 0.00285986f, -0.05233566f, -0.10118336f, 0.10098447f, -0.02407546f, -0.08690658f, 0.21943808f, 
    0.00925680f, 0.01391632f, 0.02131010f, 0.07594724f, 0.03611275f, 0.00959334f, -0.14615016f, 0.00439789f, 
    0.13014063f, 0.31486133f, -0.11966169f, 0.15254745f, -0.07394397f, 0.03339178f, 0.06691154f, 0.09181259f, 
    -0.07405919f, -0.05551679f, 0.16712308f, -0.05387160f, 0.14509918f, -0.06119137f, -0.03601489f, 0.10824069f, 
    0.00028073f, -0.02845602f, 0.11159259f, 0.18390204f, -0.09276743f, -0.06478551f, -0.07147602f, -0.25310934f, 
    0.10595059f, 0.19673921f, 0.11784428f, -0.09873952f, -0.10549106f, -0.14907055f, -0.02818646f, -0.11110342f, 
    -0.04182195f, 0.04569332f, 0.01355641f, 0.09162109f, -0.03715273f, 0.04350250f, 0.40960631f, 0.10938723f, 
    0.12535651f, 0.10238235f, 0.13450751f, 0.02724267f, 0.03890317f, 0.07460821f, 0.01845674f, 0.11456481f, 
    0.17938027f, 0.11655817f, 0.07348908f, -0.03226003f, 0.01124142f, 0.02767111f, 0.04115941f, 0.09252676f, 
    0.06139645f, -0.04077071f, -0.03269184f, -0.02104859f, 0.28293633f, 0.22532095f, 0.11922980f, 0.10816944f, 
    0.06730202f, 0.10198910f, 0.02428666f, -0.00104461f, 0.00008173f, 0.01373127f, -0.00388104f, 0.00521336f, 
    -0.00808299f, -0.36776125f, 0.33958760f, 0.20873532f, 0.14007908f, -0.01028314f, 0.02992129f, 0.13820130f, 
    -0.09350752f, 0.10942447f, -0.02775900f, 0.17684364f, -0.06746364f, 0.01481827f, -0.00401105f, -0.21394268f, 
    0.01485213f, -0.00990334f, 0.02089061f, -0.12626585f, -0.01625229f, -0.15121455f, 0.03320067f, 0.00222913f, 
    0.00565865f, 0.08886825f, 0.02912373f, 0.14050713f, 0.04588848f, 0.04247774f, 0.06659710f, -0.00931425f, 
    -0.06018644f, 0.00606059f, 0.05193357f, -0.01494853f, -0.00529299f, -0.03277452f, -0.04928687f, 0.08136509f, 
    -0.13020577f, -0.05837122f, -0.15419787f, -0.06945343f, 0.10102633f, 0.01246668f, 0.10851052f, 0.17958914f, 
    -0.01077618f, 0.11369014f, 0.09775841f, 0.08981888f, -0.11074390f, -0.13741297f, -0.09340923f, -0.07903252f, 
    -0.01955124f, 0.00664840f, 0.09925812f, 0.01346153f, 0.02374286f, 0.04565154f, -0.02453522f, -0.08337142f, 
    0.00098608f, -0.00525092f, -0.04494792f, 0.05645332f, -0.06262358f, -0.00016186f, -0.02081526f, 0.00695834f, 
    0.04408421f, -0.01718079f, 0.16432181f, 0.04201755f, 0.04203032f, 0.12316160f, -0.04013175f, 0.15505806f, 
    0.05660778f, 0.01675770f, 0.03530324f, 0.16017194f, 0.11513931f, 0.36325058f, -0.02489532f, -0.16552341f, 
    -0.17563914f, -0.13743153f, -0.09234019f, -0.00610950f, 0.03000909f, -0.03747047f, 0.04425564f, 0.00275438f, 
    -0.10957557f, 0.02299554f, -0.11199789f, -0.02692917f, 0.08356770f, 0.06684308f, -0.04059671f, -0.04181613f, 
    -0.10979196f, -0.06511310f, 0.02283744f, -0.06099218f, -0.22494748f, 0.14942379f, 0.00437069f, -0.08394806f, 
    -0.00869585f, 0.04448998f, 0.10545449f, 0.02277036f, -0.08038140f, 0.00849980f, -0.00112275f, 0.08002208f, 
    -0.17172673f, 0.01118969f, 0.07970852f, 0.07785533f, -0.02580187f, 0.08102670f, 0.01389750f, -0.06614377f, 
    0.06180573f, 0.07778814f, 0.07592206f, 0.16344969f, 0.04096222f, 0.22753653f, 0.14366816f, -0.06459063f, 
    -0.07832736f, -0.11832118f, -0.08109906f, -0.01248990f, -0.17216320f, -0.06416656f, -0.21906538f, -0.13588108f, 
    0.17431819f, 0.34587741f, -0.05041579f, 0.02228118f, 0.06696558f, -0.00939213f, 0.08766821f, 0.16682926f, 
    -0.00575248f, -0.04336254f, 0.11485095f, -0.02098954f, 0.16926245f, -0.01097947f, 0.33259189f, 0.00302819f, 
    0.00328371f, -0.12458650f, -0.05125869f, 0.05842542f, -0.15628828f, -0.07057343f, -0.11600669f, 0.06807972f, 
    0.07488438f, -0.24717650f, 0.23898375f, 0.30491227f, 0.05289751f, 0.01902142f, 0.10172849f, 0.14276795f, 
    0.11614200f, -0.04415932f, 0.15266767f, 0.07915369f, 0.25993758f, 0.19278969f, 0.13573983f, 0.02524613f, 
    0.02512158f, -0.06044012f, 0.19204159f, 0.12375177f, -0.10555025f, 0.11921668f, 0.02788662f, -0.13859139f, 
    0.13883154f, 0.09359609f, 0.03357044f, -0.04455597f, -0.04797721f, -0.01271818f, -0.00073557f, -0.00465110f, 
    -0.11641628f, -0.01605326f, -0.04063370f, 0.02173944f, 0.09022178f, 0.21356921f, 0.01284673f, 0.01167457f, 
    -0.00160968f, 0.08794201f, 0.11048303f, 0.11147928f, 0.02636721f, 0.01239044f, -0.01116196f, -0.07147238f, 
    0.18065614f, 0.05032650f, 0.01322098f, 0.10131725f, 0.07758610f, 0.11606932f, 0.05982782f, -0.02186330f, 
    -0.03751092f, 0.06567694f, -0.06325179f, -0.02654223f, -0.00091569f, -0.07068478f, -0.20278330f, -0.19461216f, 
    -0.03151025f, 0.08091624f, 0.08630820f, 0.04911619f, 0.07408307f, 0.15077858f, 0.01220076f, -0.09177547f, 
    0.17015420f, 0.29170513f, 0.14956571f, 0.11129376f, -0.10339433f, -0.04417739f, -0.03459632f, -0.01894307f, 
    -0.02331487f, 0.11315826f, 0.22466634f, -0.09622932f, 0.13387264f, 0.02415601f, 0.22598229f, 0.18622376f, 
    0.08181518f, 0.06510335f, 0.10428616f, 0.12114451f, 0.07676952f, 0.10579979f, -0.01308460f, -0.22513135f, 
    -0.06335720f, 0.04243935f, 0.12771969f, -0.09796780f, 0.06009686f, 0.20436233f, 0.08523057f, 0.13904332f, 
    0.10828924f, 0.03401501f, -0.05813499f, -0.00345174f, -0.20831269f, 0.02201280f, -0.24184564f, -0.18051393f, 
    -0.04649924f, 0.00017017f, -0.00424776f, -0.04677452f, 0.03954420f, 0.01949916f, 0.00946034f, -0.13682307f, 
    0.03633200f, 0.20796740f, 0.02091677f, 0.01859102f, -0.03080687f, -0.03740139f, -0.08308621f, -0.04174275f, 
    0.03823209f, 0.14492577f, 0.08783685f, 0.11361767f, 0.09496964f, 0.06396039f, 0.18334153f, -0.05889065f, 
    0.17849714f, -0.07727081f, 0.00729395f, -0.00505685f, 0.04766513f, 0.05061159f, 0.07779152f, 0.05068007f, 
    -0.08542841f, 0.07654922f, 0.11327343f, -0.11085157f, -0.19080251f, -0.10209498f, -0.15599494f, -0.09240318f, 
    0.00675443f, -0.08082606f, -0.04497094f, 0.05669307f, -0.07687411f, 0.09953091f, 0.10253836f, 0.04488591f, 
    -0.06954025f, -0.10275254f, 0.03696146f, 0.04235533f, 0.01650073f, 0.01015949f, 0.13696223f, 0.11078854f, 
    0.14184351f, -0.04702784f, 0.14083640f, -0.10864126f, -0.19960548f, 0.01743607f, -0.00749924f, -0.03112134f, 
    0.00816859f, 0.02792759f, -0.14794303f, 0.18729590f, 0.15360999f, 0.08665454f, 0.06394291f, 0.09174443f, 
    0.01580554f, 0.06992204f, -0.00167756f, 0.11632690f, -0.04989655f, 0.03310965f, 0.07635974f, -0.10885010f, 
    -0.09513187f, 0.38099790f, -0.12199391f, -0.01881250f, 0.07706791f, -0.00624821f, 0.12049452f, -0.03165494f, 
    -0.07249451f, -0.13613558f, 0.03452701f, 0.10005742f, -0.08428837f, -0.11511283f, -0.08921623f, -0.07116003f, 
    0.01090157f, 0.07557826f, -0.01401667f, 0.11435492f, -0.08090345f, 0.00926687f, 0.10102979f, -0.04632556f, 
    0.06077051f, 0.07123569f, 0.14195888f, -0.10813588f, -0.05221375f, -0.15207751f, -0.14871815f, -0.03527834f, 
    -0.12343303f, -0.03843432f, -0.13014640f, -0.21884398f, -0.06201135f, -0.01788726f, -0.20438431f, -0.07559378f, 
    -0.02148441f, -0.02540706f, 0.03874149f, -0.03510699f, -0.03194170f, 0.03798340f, 0.03203190f, -0.11520578f, 
    0.05094377f, 0.17209046f, -0.02838528f, 0.10965050f, -0.11307510f, 0.21374242f, 0.02191704f, 0.24447204f, 
    -0.07133886f, 0.02767685f, 0.06700142f, 0.01419573f, 0.13869464f, -0.28152332f, 0.01171170f, -0.36905777f, 
    -0.06467759f, -0.04463793f, 0.01062502f, -0.11527757f, 0.04110436f, 0.05045679f, 0.02710223f, -0.05048897f, 
    -0.14451008f, -0.04374060f, -0.03093493f, 0.11655309f, 0.02799292f, 0.16531841f, 0.11495342f, -0.01903815f, 
    0.00530449f, 0.04676558f, 0.10896948f, 0.20238948f, -0.00096080f, -0.05401014f, 0.10358857f, 0.12538902f, 
    0.19781296f, 0.04883905f, 0.12771176f, 0.11099026f, 0.03779012f, -0.03909371f, 0.12877652f, 0.17205365f, 
    -0.16052754f, 0.25536847f, 0.09360100f, 0.10325877f, -0.12489605f, -0.02603258f, -0.00135151f, -0.01151207f, 
    -0.02081349f, 0.04450192f, -0.01460804f, -0.04688847f, -0.13366568f, -0.16405553f, 0.07591973f, 0.07729878f, 
    0.00180097f, 0.12758176f, -0.06002649f, -0.01349095f, -0.09488053f, 0.07875612f, 0.02410932f, 0.13277906f, 
    0.00493994f, 0.06798486f, 0.13040990f, -0.07347903f, -0.09111335f, -0.05339121f, -0.00132130f, -0.05076366f, 
    0.11966395f, -0.07372284f, -0.06395482f, -0.04112427f, -0.11344137f, -0.20560965f, -0.09325480f, -0.03111549f, 
    0.10961337f, 0.07949636f, -0.05367325f, 0.14694560f, -0.19055390f, -0.05987549f, -0.14198373f, -0.11195470f, 
    -0.04034114f, -0.02276414f, -0.21172488f, -0.05519567f, -0.10677305f, 0.04347578f, 0.06278124f, -0.05733458f, 
    0.11392444f, 0.05208120f, 0.21121606f, 0.21225654f, -0.11880360f, 0.14571467f, -0.01535961f, 0.11951774f, 
    -0.10147230f, -0.03465866f, -0.10267843f, 0.04564486f, -0.21704537f, -0.02133065f, -0.09719368f, -0.10931490f, 
    -0.00572339f, 0.09770969f, 0.26482409f, -0.05705803f, 0.07369364f, -0.12696186f, 0.08250416f, 0.04516702f, 
    0.07178491f, 0.06109932f, -0.02594027f, 0.02009371f, 0.03484073f, 0.19150440f, 0.04232111f, 0.13190389f, 
    0.09262238f, -0.08184904f, 0.09450227f, -0.06579027f, 0.07165173f, 0.02871071f, -0.07824942f, 0.07413182f, 
    0.03597584f, 0.05035786f, -0.05033972f, 0.05577503f, -0.01334309f, 0.01773630f, 0.04687775f, -0.05298052f, 
    -0.08489431f, -0.06177508f, -0.01572869f, 0.00628758f, -0.21893065f, 0.07477906f, -0.25328156f, 0.02372231f, 
    -0.06263981f, -0.12210505f, -0.04136303f, -0.10781435f, 0.04927740f, 0.04615323f, 0.15000844f, 0.05888888f, 
    -0.13103317f, 0.13251837f, 0.09331767f, 0.03346818f, 0.05844346f, 0.01588544f, -0.02353489f, 0.02703087f, 
    -0.04755197f, -0.02403044f, -0.13295530f, -0.18862413f, 0.27544394f, 0.05644441f, 0.18843585f, -0.01120756f, 
    -0.00448753f, 0.01435556f, 0.03804592f, 0.00051110f, -0.02679488f, 0.01084357f, -0.02935387f, -0.03116916f, 
    -0.11027572f, -0.03449958f, 0.02678880f, -0.01092185f, 0.03706037f, -0.03076861f, -0.05216077f, -0.03890764f, 
    0.05997409f, -0.00342023f, -0.03460778f, -0.07673080f, -0.00599717f, -0.18843225f, -0.03597253f, -0.16134126f, 
    -0.05969982f, 0.14276145f, -0.05548197f, 0.12105767f, 0.08840987f, 0.00473088f, -0.03656242f, -0.16915275f, 
    0.08826537f, 0.18175691f, 0.15541582f, 0.09976865f, 0.04145065f, 0.09872514f, 0.07513576f, 0.08411472f, 
    0.17023937f, -0.04648860f, 0.14926258f, 0.03200737f, -0.13375062f, 0.10740680f, -0.13949375f, -0.21943362f, 
    -0.18088835f, -0.03583584f, -0.00095715f, -0.06757887f, 0.09101636f, 0.06370034f, 0.12533036f, 0.01364043f, 
    0.00067918f, -0.05440798f, 0.03605799f, -0.08523163f, 0.04493435f, -0.03247562f, -0.00035543f, 0.16550589f, 
    -0.03687214f, 0.08204904f, 0.18355095f, 0.05064992f, 0.31850395f, -0.08178324f, -0.02200933f, -0.27243596f, 
    -0.01044517f, 0.11027505f, 0.02391873f, -0.02675320f, 0.09819147f, 0.11881962f, -0.00708454f, 0.04516215f, 
    0.00447068f, 0.02146819f, -0.02107047f, -0.02547525f, -0.02184615f, -0.00916064f, 0.00969883f, -0.02041300f, 
    0.02248912f, -0.04235161f, -0.02249628f, -0.03025527f, -0.03064279f, -0.01389681f, -0.02570574f, -0.03133976f, 
    -0.03213883f, 0.01976907f, -0.00533403f, 0.01834032f, -0.01538436f, -0.02583900f, -0.00822681f, 0.02251242f, 
    -0.03130433f, -0.02449842f, -0.01639799f, -0.04810352f, -0.02762354f, 0.00102248f, -0.02175109f, 0.00736564f, 
    -0.03627318f, -0.02845010f, 0.01236389f, 0.01074191f, 0.02141304f, -0.02161168f, -0.00338974f, 0.02520194f, 
    0.01630807f, 0.00004456f, -0.02864624f, 0.01537143f, 0.00398382f, -0.01662685f, -0.03129309f, 0.00889155f, 
    -0.03284359f, 0.02663594f, 0.00813809f, 0.03766240f, -0.03216513f, -0.03322870f, 0.00304968f, 0.00280581f, 
    0.01074859f, -0.01022997f, -0.00557000f, 0.01823575f, 0.00116920f, -0.03589835f, 0.01661439f, 0.02412027f, 
    0.00457747f, -0.02062271f, 0.02290628f, -0.02722050f, 0.01942600f, -0.00323996f, 0.00644029f, -0.03264229f, 
    0.01618086f, 0.01576877f, -0.03925948f, -0.04414738f, 0.00469189f, -0.02758036f, -0.04460787f, 0.02371037f, 
    -0.00492530f, 0.00099684f, -0.02502084f, 0.01270280f, -0.00753815f, 0.00617175f, 0.01662008f, -0.02887174f, 
    -0.03168638f, -0.00876159f, 0.02647954f, 0.02718987f, -0.04267213f, -0.04262015f, 0.00236195f, -0.03753633f, 
    -0.02640425f, 0.02640349f, -0.03341993f, -0.01739234f, 0.02359180f, 0.00938073f, 0.02494183f, 0.01480362f, 
    -0.02419411f, -0.01522242f, -0.01948331f, -0.02745487f, 0.03012586f, -0.00839855f, 0.02877116f, 0.00174467f, 
    -0.01740917f, 0.01666585f, -0.03324910f, 0.01555829f, 0.02295523f, -0.00410636f, -0.03709363f, 0.02335823f, 
    0.02129081f, -0.01762713f, 0.02463628f, -0.01088455f, 0.02186699f, 0.02383509f, -0.00604695f, 0.02366494f, 
    0.01358071f, -0.02234389f, -0.01636191f, -0.03909179f, -0.00610304f, 0.01747635f, 0.00008212f, 0.00642673f, 
    0.03461214f, 0.00775325f, 0.02113163f, -0.00116591f, 0.02264008f, -0.03224358f, 0.00130964f, -0.01017610f, 
    -0.01827485f, -0.00121478f, -0.01553795f, -0.03368941f, -0.00354529f, 0.02738974f, -0.01012569f, -0.02341852f, 
    -0.01846452f, 0.01483787f, -0.02385735f, 0.00713169f, -0.02721915f, 0.01987744f, -0.01906682f, 0.00721241f, 
    0.02629156f, 0.00547643f, -0.00145263f, 0.01102458f, 0.00605421f, -0.01808182f, -0.01607489f, -0.03626585f, 
    0.02384236f, 0.01614579f, -0.01394237f, -0.04349826f, -0.01026489f, 0.02490363f, 0.00983079f, 0.02165153f, 
    -0.03702319f, 0.02097432f, -0.03268572f, -0.02569854f, -0.02978024f, 0.02397665f, 0.01674947f, -0.03724198f, 
    0.01893605f, -0.01641509f, 0.01631530f, 0.02700022f, -0.00126863f, -0.00125872f, -0.02079583f, 0.00222073f, 
    -0.02293150f, -0.00446682f, 0.01508916f, 0.00536299f, 0.02245028f, -0.01286391f, 0.00789295f, 0.00214349f, 
    0.02733051f, 0.00615626f, -0.00932291f, -0.03553212f, 0.00079868f, 0.01328148f, -0.00290103f, -0.03142307f, 
    0.01905113f, -0.01936501f, -0.03242275f, -0.03955670f, -0.02916293f, -0.00174314f, -0.02353238f, 0.00040932f, 
    -0.00300434f, 0.01570304f, 0.01592892f, 0.01029245f, -0.00808430f, -0.01442912f, -0.04345719f, -0.00340465f, 
    0.00538980f, -0.04190170f, -0.01065841f, -0.03894364f, -0.00510213f, -0.00752649f, -0.00914349f, 0.00398633f, 
    0.03405367f, -0.01016084f, -0.02551957f, 0.00042383f, -0.01981889f, 0.00733290f, 0.02922631f, 0.02773297f, 
    -0.00822755f, 0.01001782f, -0.02209643f, -0.01088193f, -0.04218332f, -0.00422958f, 0.02002859f, 0.00459989f, 
    -0.02584888f, 0.00062514f, -0.02499811f, -0.00235628f, -0.02968340f, 0.02710357f, -0.01114295f, 0.00674066f, 
    0.01584106f, -0.01839918f, -0.03612296f, -0.01618874f, 0.00350616f, 0.01250662f, 0.00332345f, -0.03338132f, 
    -0.03834179f, -0.01836902f, 0.01975694f, 0.02544711f, 0.03176363f, 0.00640505f, -0.02437704f, -0.01455013f, 
    0.00977391f, -0.00715762f, -0.00530404f, -0.00979549f, 0.00110119f, -0.03082668f, -0.01327027f, -0.00894024f, 
    0.01607000f, -0.03167133f, -0.03978506f, 0.01214222f, 0.01031232f, -0.04387404f, -0.01335364f, -0.02766168f, 
    -0.01403622f, -0.03538305f, 0.01796943f, -0.03777750f, -0.00865080f, -0.02959465f, 0.01428815f, -0.02006403f, 
    0.00387446f, -0.03652591f, -0.03818798f, -0.03806180f, 0.02437008f, -0.01852436f, -0.03833038f, -0.04406244f, 
    -0.00996673f, -0.01280889f, 0.01009975f, 0.00686928f, 0.02757347f, -0.04254695f, -0.02870473f, 0.02096898f, 
    -0.02115758f, 0.02089309f, 0.00998270f, 0.01517883f, -0.03337903f, 0.02646340f, -0.04277236f, 0.00514054f, 
    -0.02646025f, -0.03376213f, -0.02484655f, 0.00696469f, 0.00622113f, -0.02467207f, -0.03807884f, 0.02051564f, 
    -0.00832187f, 0.02788467f, -0.01447072f, 0.01225740f, 0.00912652f, -0.01500244f, -0.02571676f, -0.03183385f, 
    0.00420932f, -0.00251662f, 0.03047368f, 0.03321914f, -0.03429491f, -0.02416458f, 0.00549865f, 0.00181386f, 
    0.00678676f, -0.02266651f, 0.01998731f, -0.03377973f, 0.01967657f, 0.01142110f, -0.01353584f, 0.00952229f, 
    -0.01135883f, -0.03219442f, -0.01534966f, 0.00081892f, -0.01584780f, 0.02432632f, -0.03517258f, 0.02208501f, 
    -0.00286916f, 0.02376236f, -0.03479272f, -0.01844368f, 0.02371328f, -0.00590898f, -0.00752936f, -0.00740660f, 
    -0.02034947f, -0.01572332f, -0.01225936f, -0.03562527f, -0.01022586f, -0.02733887f, 0.03227945f, -0.03080093f, 
    0.00249839f, 0.00489933f, 0.02458408f, -0.00612707f, 0.00970167f, 0.02273278f, -0.01297776f, -0.02610137f, 
    -0.03182043f, -0.02875581f, -0.03797688f, -0.03632597f, -0.02463207f, 0.01425344f, 0.01915387f, 0.02181260f, 
    0.02853318f, 0.01294571f, 0.02580259f, 0.01899762f, -0.03629808f, -0.02170121f, -0.01633444f, 0.00969186f, 
    -0.00616022f, -0.03699122f, 0.00326643f, -0.00059940f, 0.01878441f, -0.02842917f, -0.00228103f, 0.00438593f, 
    0.02811632f, 0.00446055f, 0.00071751f, 0.00946580f, -0.00782066f, 0.02362160f, -0.01763557f, 0.02541892f, 
    -0.03164500f, -0.00134642f, 0.01075472f, -0.03124026f, 0.01818566f, -0.01410578f, 0.00319917f, -0.02891860f, 
    0.00047547f, -0.01331680f, 0.02119726f, 0.01027838f, -0.00591266f, 0.02560865f, 0.00389726f, -0.02807501f, 
    0.02324730f, -0.03589917f, 0.01982944f, -0.00661231f, -0.03879577f, -0.04167084f, -0.00447275f, 0.00345993f, 
    0.00472544f, -0.00441785f, 0.02514097f, -0.04703912f, -0.01582556f, 0.01711809f, -0.00611986f, -0.03865381f, 
    -0.04352240f, 0.01222552f, -0.04012259f, 0.00502114f, 0.00828851f, 0.01533238f, 0.00761342f, -0.00385125f, 
    0.01218542f, 0.02445567f, -0.04410838f, -0.04111628f, 0.01247820f, 0.01392351f, -0.03342714f, -0.04144375f, 
    -0.02328820f, -0.00172494f, -0.02199902f, 0.01367654f, -0.02219352f, -0.01911659f, 0.00112846f, -0.00516112f, 
    -0.02568482f, 0.02651929f, 0.01704425f, 0.00202070f, 0.00021569f, -0.00690465f, 0.02224596f, 0.03001052f, 
    -0.00469001f, -0.02959637f, 0.03038566f, -0.00918801f, -0.02031882f, -0.00284702f, -0.01201426f, 0.01738083f, 
    -0.00360414f, -0.00201392f, 0.00300074f, -0.00647439f, -0.00383465f, -0.00606285f, -0.00599823f, -0.00238288f, 
    -0.00211851f, 0.00120449f, 0.01324527f, 0.00740636f, 0.00323123f, 0.00008068f, 0.02255605f, -0.01753623f, 
    -0.02790871f, -0.00724420f, 0.01040597f, 0.00543620f, -0.03499132f, 0.02144003f, -0.03799560f, -0.02432510f, 
    0.03816152f, -0.01662852f, 0.02746107f, -0.03188028f, -0.00009754f, -0.01807297f, -0.01973207f, -0.02118144f, 
    -0.02809823f, 0.00535274f, 0.00118405f, -0.02223127f, -0.00875424f, 0.00052146f, -0.00455440f, -0.01218952f, 
    0.02954928f, -0.03339411f, -0.02448318f, 0.02047920f, 0.01058369f, -0.00104925f, -0.03885417f, -0.03955877f, 
    -0.00534607f, -0.03016608f, 0.01574155f, 0.01816594f, -0.00073619f, -0.04253774f, -0.01071447f, 0.00076824f, 
    0.01655870f, -0.01520631f, -0.01754081f, -0.02224576f, 0.00764939f, 0.01040311f, -0.02078982f, -0.02179043f, 
    -0.00866599f, 0.02979222f, 0.00913303f, 0.01662952f, 0.00374609f, 0.00653065f, 0.03421007f, -0.00936575f, 
    0.02689997f, -0.02275673f, 0.00522881f, 0.00508290f, -0.03971995f, 0.02080644f, 0.01928573f, 0.00678620f, 
    0.01005132f, 0.01856215f, 0.01171712f, -0.01475409f, -0.02948621f, -0.03732092f, 0.03426333f, -0.00710814f, 
    -0.00087089f, -0.02710531f, -0.02696250f, 0.02779845f, -0.03168401f, -0.00832105f, -0.02359428f, -0.01238547f, 
    -0.01382948f, -0.00264499f, 0.00536449f, 0.01395740f, 0.02477640f, 0.02536527f, -0.02375294f, 0.00406856f, 
    0.02000784f, 0.00597916f, -0.02341058f, -0.01946794f, 0.02347762f, 0.02343278f, 0.01037692f, 0.00832564f, 
    -0.00025806f, -0.01257723f, -0.00851621f, -0.00910302f, -0.03797208f, -0.00696151f, 0.02453087f, -0.02622423f, 
    -0.00935312f, -0.01416296f, 0.00858729f, -0.00237606f, -0.00906223f, -0.02703919f, -0.02708262f, 0.01931036f, 
    0.02742082f, 0.03596748f, 0.01872669f, 0.00822144f, -0.02825526f, -0.00703462f, -0.01816654f, -0.01571500f, 
    -0.02784756f, 0.01012300f, 0.00514361f, -0.04320070f, -0.03972422f, -0.00096843f, -0.03943578f, -0.01853216f, 
    -0.02115384f, -0.03904812f, 0.00612893f, 0.01179159f, -0.00178039f, 0.00757316f, 0.01390543f, -0.00282277f, 
    0.00142681f, 0.01320412f, -0.00531732f, -0.00834467f, -0.00163421f, -0.01551982f, 0.03091548f, -0.01607469f, 
    -0.00584732f, 0.00591240f, -0.03220851f, 0.00508052f, -0.03385803f, 0.00599582f, 0.00652548f, -0.00051814f, 
    -0.00279330f, -0.01958402f, -0.02691529f, 0.02379085f, 0.01163857f, 0.03315173f, 0.02703598f, -0.00867489f, 
    0.00060554f, -0.03530323f, -0.02613910f, -0.00686935f, -0.03463385f, -0.00248656f, -0.00258743f, 0.02727285f, 
    0.02151032f, 0.01345239f, 0.00955968f, -0.02627458f, 0.00640961f, 0.00907935f, -0.02049765f, 0.00234084f, 
    -0.03282529f, -0.04081834f, -0.04180044f, -0.03689393f, -0.00939739f, -0.03612224f, -0.03806548f, 0.01469213f, 
    0.02473407f, 0.03020486f, -0.01270200f, -0.01536096f, 0.01697913f, -0.03820976f, 0.00766669f, -0.03345910f, 
    0.03411919f, 0.02559708f, 0.02191451f, 0.01225260f, -0.01342373f, -0.03609709f, -0.03278892f, -0.04211932f, 
    0.00107227f, -0.02150687f, 0.02342572f, 0.01124701f, -0.00893901f, -0.03801721f, 0.01433827f, -0.00663506f, 
    -0.01335172f, 0.01231787f, -0.02227641f, -0.03912504f, -0.04029375f, -0.03041297f, -0.01762422f, -0.04528455f, 
    -0.01149870f, 0.01201658f, -0.02834527f, -0.01283186f, 0.02709663f, 0.02470587f, 0.01179324f, 0.00808845f, 
    -0.02613894f, 0.00021361f, -0.00725429f, -0.02897434f, 0.02778360f, -0.02745224f, 0.03846085f, -0.00420289f, 
    -0.01882611f, -0.03380032f, 0.02348602f, 0.01802995f, -0.02908551f, 0.01592759f, 0.02860582f, 0.00761550f, 
    0.02618354f, 0.02214883f, -0.02170073f, 0.02632546f, -0.02414288f, 0.01004743f, -0.03689686f, -0.01928580f, 
    0.00406051f, -0.02874596f, -0.01667644f, 0.00935384f, 0.01533067f, 0.02323115f, -0.02620923f, -0.01539616f, 
    -0.00397366f, -0.01511137f, -0.02931462f, -0.00099676f, -0.04625688f, 0.01328806f, -0.04291584f, 0.02245462f, 
    -0.23266669f, 0.13172011f, -0.02292990f, 0.01256268f, -0.06139140f, -0.08222888f, -0.13526013f, 0.00786523f, 
    -0.11893207f, 0.08752339f, -0.12351257f, -0.08787408f, -0.04804605f, 0.11535299f, -0.08058587f, 0.20085543f, 
    -0.05277982f, 0.07317860f, 0.03592602f, -0.17818081f, -0.04595969f, 0.01180022f, -0.07444213f, 0.09104355f, 
    0.17471834f, 0.39921609f, -0.16322199f, 0.03312034f, -0.14197502f, -0.18072841f, 0.05512882f, 0.01403227f, 
    0.08158224f, 0.10061707f, -0.02091028f, -0.09948631f, 0.13082309f, -0.04868617f, -0.00387114f, 0.20067801f, 
    0.08910745f, 0.14647229f, 0.01611639f, -0.02168178f, -0.06293190f, 0.02550757f, -0.02840452f, -0.03052434f, 
    -0.32833266f, 0.01034452f, 0.07812417f, 0.07839056f, 0.04393968f, -0.16419353f, -0.08314536f, -0.07413887f, 
    0.05408973f, 0.06647336f, 0.05105906f, 0.12373812f, -0.22095937f, -0.15196273f, 0.18070485f, 0.01422790f, 
    0.13399374f, 0.03834775f, -0.19198535f, -0.01601529f, -0.02501377f, 0.04592893f, -0.01784382f, 0.05626823f, 
    0.17615339f, 0.00527515f, 0.08950710f, 0.15322660f, 0.14876646f, 0.17564780f, 0.04412262f, -0.09544089f, 
    -0.08220888f, -0.00049744f, -0.10085973f, 0.13070495f, 0.16163434f, 0.23754637f, 0.09900104f, 0.16097504f, 
    -0.02439373f, 0.07197511f, -0.00555769f, -0.01633498f, -0.01589886f, -0.01281544f, -0.01696918f, 0.15894827f, 
    -0.39285660f, -0.33649045f, 0.13730264f, 0.24388821f, 0.02086455f, 0.05022339f, -0.15132987f, -0.04895509f, 
    -0.10564961f, -0.00930068f, 0.01830450f, 0.08796299f, -0.09205214f, -0.07564843f, -0.05384547f, -0.17299616f, 
    0.06854562f, 0.01501268f, 0.02091483f, -0.03574352f, -0.18315989f, -0.14867564f, 0.00262714f, -0.02477525f, 
    0.08317313f, 0.05510431f, -0.13846718f, 0.00437130f, 0.08083145f, 0.09504166f, 0.10426800f, 0.05450867f, 
    -0.06294038f, -0.02396679f, 0.06150151f, -0.01549498f, -0.02397001f, 0.05970197f, -0.10914161f, 0.01112765f, 
    -0.03326120f, 0.08439682f, 0.01605586f, -0.06010563f, 0.07943818f, -0.05418803f, 0.07030167f, 0.14474100f, 
    -0.08174655f, -0.10266185f, -0.06126489f, 0.04001690f, 0.01160457f, 0.03244902f, -0.10680483f, 0.02762395f, 
    -0.02574568f, -0.02614305f, 0.15209557f, 0.04605827f, 0.03539749f, 0.18901326f, 0.02259116f, 0.00833420f, 
    0.07622141f, 0.01891314f, -0.02397484f, 0.03641723f, 0.03115713f, 0.01919418f, -0.09606718f, -0.05040437f, 
    0.19483332f, 0.08326946f, 0.09931728f, 0.03004222f, 0.01141218f, 0.13581532f, 0.12748471f, 0.08142473f, 
    0.05346358f, 0.06797447f, 0.04234843f, 0.09165389f, -0.21919891f, 0.02016596f, -0.06362247f, -0.14716358f, 
    -0.03915611f, -0.02113307f, -0.10889331f, 0.00845972f, 0.03110434f, -0.03053996f, 0.10351416f, 0.09343974f, 
    0.04312407f, 0.04028459f, 0.02775220f, 0.02021799f, 0.01318398f, 0.01372122f, -0.08017384f, -0.04103213f, 
    0.01884642f, 0.03419304f, 0.04591762f, -0.01193915f, -0.26083142f, 0.13442606f, -0.05271702f, 0.05679880f, 
    -0.01336922f, 0.03334485f, 0.03400113f, -0.00279856f, 0.00958878f, 0.06687652f, 0.06672148f, 0.04682904f, 
    -0.29576772f, 0.06249352f, -0.03519218f, -0.02648304f, -0.03466940f, 0.08228181f, -0.08630411f, -0.10204187f, 
    -0.05789936f, 0.06798574f, 0.12730597f, 0.12120799f, -0.22625108f, 0.03170242f, 0.10433257f, -0.05062151f, 
    0.04753140f, -0.09952010f, -0.01657292f, -0.05652623f, 0.00130316f, 0.03352407f, -0.03741865f, 0.03770572f, 
    0.12821376f, 0.40096676f, 0.08481110f, -0.09199085f, 0.07974026f, -0.06190531f, -0.00122960f, 0.09302946f, 
    -0.03199919f, 0.03761524f, -0.07898210f, -0.01963728f, -0.01564664f, -0.02993127f, 0.15812303f, -0.15023455f, 
    -0.00677950f, -0.01370981f, -0.07413315f, 0.00722399f, 0.01024533f, -0.07310962f, 0.06166315f, 0.04033168f, 
    -0.11260096f, -0.26520345f, 0.03800949f, 0.29616699f, -0.07652014f, 0.11869798f, 0.00483504f, -0.17436755f, 
    -0.06917078f, -0.16185491f, 0.11386336f, 0.04947387f, 0.21798933f, 0.21044517f, 0.05705960f, 0.08235382f, 
    0.11229579f, -0.06369859f, 0.07126079f, 0.14554639f, -0.03251773f, 0.14299756f, -0.08368739f, -0.22915393f, 
    0.12360980f, 0.19124566f, 0.02078516f, 0.03824539f, 0.05999582f, 0.08260560f, 0.10042591f, 0.04609148f, 
    -0.02721534f, -0.06919792f, -0.12730902f, 0.05408435f, 0.19077753f, 0.23451360f, 0.13807733f, 0.05022243f, 
    -0.02753988f, 0.06795600f, -0.00915779f, 0.05369221f, -0.03719184f, -0.03879996f, -0.11767026f, -0.08927578f, 
    0.30239826f, 0.28258443f, 0.11554819f, 0.20677069f, 0.09773445f, 0.11133914f, 0.15996470f, 0.01901909f, 
    -0.02584379f, 0.05254656f, -0.01235616f, 0.08302096f, 0.02382378f, -0.12271681f, -0.02703162f, 0.01173218f, 
    0.03500430f, 0.16363724f, 0.15213956f, 0.07800257f, 0.04264282f, 0.11019325f, -0.06523900f, -0.02340088f, 
    0.23468210f, 0.06562716f, -0.10917082f, -0.13870323f, -0.04916314f, 0.11606058f, -0.11380330f, 0.00423502f, 
    -0.06449150f, 0.05792688f, 0.09841628f, -0.12370053f, 0.00305804f, -0.15053183f, 0.22050291f, 0.22349519f, 
    0.00357798f, 0.16554156f, 0.10690627f, 0.02369939f, -0.05377588f, 0.10454237f, 0.00373186f, -0.24208385f, 
    0.12534578f, 0.04605733f, 0.20262399f, 0.18984535f, 0.09874978f, 0.17276369f, 0.01725424f, 0.09944502f, 
    -0.06509347f, -0.01981509f, -0.05345901f, -0.02667624f, -0.14851575f, -0.02228347f, -0.11494874f, -0.05537505f, 
    0.10608054f, 0.05988837f, -0.00161724f, 0.07803665f, 0.01780356f, 0.10388865f, -0.00349775f, -0.10767315f, 
    -0.16495435f, 0.05009601f, -0.00336302f, 0.00859093f, -0.00452417f, 0.04182092f, -0.06681279f, -0.01730237f, 
    0.02999589f, 0.05245253f, 0.13449626f, 0.10911636f, 0.06303187f, 0.14256458f, 0.08919614f, -0.11211923f, 
    0.09011686f, -0.10428781f, -0.07336155f, -0.02370978f, 0.12802126f, -0.00265504f, 0.01526494f, 0.03065270f, 
    -0.11363447f, -0.08007521f, -0.04511639f, -0.08013740f, 0.00174133f, -0.03193654f, -0.00571563f, -0.00664303f, 
    -0.19243565f, -0.00212393f, -0.05547604f, 0.15558806f, -0.23130307f, 0.02688215f, -0.06672960f, -0.09647616f, 
    -0.02702663f, -0.03395208f, 0.02711370f, 0.09475989f, -0.01740463f, -0.03517260f, 0.06136952f, -0.03943135f, 
    -0.29601192f, -0.10142380f, -0.08029848f, -0.10297441f, -0.07217053f, 0.08229517f, 0.00935601f, -0.05768099f, 
    -0.08145960f, -0.00479627f, 0.03186840f, 0.23524019f, 0.04409085f, 0.08829823f, 0.03739260f, 0.12905319f, 
    0.08333755f, -0.01479723f, 0.08020944f, -0.03524433f, -0.00038271f, -0.00373854f, 0.02387828f, -0.08454860f, 
    -0.13328731f, 0.47854283f, -0.08886486f, -0.11894226f, 0.06450284f, -0.17894091f, 0.03530452f, -0.18115430f, 
    0.01912416f, -0.11130844f, -0.01982255f, -0.06209528f, 0.07516024f, 0.00028061f, -0.02006200f, -0.06008531f, 
    0.08849840f, 0.14485528f, 0.00152873f, -0.05282981f, -0.02752750f, -0.01120974f, 0.09304646f, 0.04948906f, 
    -0.12322980f, -0.00117965f, 0.08406442f, -0.07466168f, 0.00234705f, -0.03240468f, -0.10465547f, -0.05758044f, 
    -0.00104508f, -0.00553674f, -0.05303156f, -0.04203545f, -0.07094001f, 0.01163913f, -0.04816770f, -0.07988465f, 
    0.16899523f, 0.01158903f, 0.05109472f, -0.00925458f, -0.02858300f, 0.01034257f, 0.03037016f, -0.05578471f, 
    0.20076497f, 0.31265578f, 0.02262941f, 0.18169579f, -0.01046618f, 0.20677783f, 0.11633904f, 0.19991700f, 
    0.02496223f, 0.01493085f, 0.10204199f, 0.07682464f, 0.22936314f, -0.18152116f, -0.06987534f, -0.17058697f, 
    0.06139376f, 0.11487260f, 0.09796423f, -0.00325446f, 0.06286580f, 0.10482991f, -0.00788716f, -0.03540155f, 
    -0.24734993f, 0.02417342f, -0.05445879f, 0.13201682f, -0.06605035f, 0.16996239f, 0.00829192f, -0.07953091f, 
    0.04571240f, -0.02148514f, 0.13489521f, 0.10064895f, -0.07354749f, -0.01708479f, 0.06688854f, -0.04327645f, 
    0.04310856f, 0.00264975f, -0.14412516f, 0.07048322f, -0.00832251f, -0.11488528f, 0.14122306f, 0.09062593f, 
    -0.26035213f, 0.02394805f, -0.00718925f, 0.13588458f, -0.01950505f, 0.00922353f, -0.05683126f, -0.01596276f, 
    0.00945985f, 0.05259638f, 0.01522728f, -0.00596725f, 0.04755764f, -0.11655468f, -0.03289088f, 0.11093705f, 
    0.06004873f, 0.18268508f, 0.07928953f, 0.21245842f, -0.05831358f, 0.06547717f, 0.03652297f, 0.05984738f, 
    -0.16737832f, -0.06487644f, 0.06483895f, 0.02888791f, 0.02216688f, -0.03396809f, -0.08916105f, -0.01278775f, 
    0.00856279f, 0.06037870f, -0.05490528f, -0.00765766f, 0.06879944f, -0.05940083f, -0.12533820f, 0.06987160f, 
    0.08077065f, 0.09687293f, 0.10570822f, 0.12363472f, -0.11173086f, 0.12388477f, -0.15328097f, -0.07777540f, 
    -0.00193246f, 0.16999799f, -0.03191144f, -0.06922230f, -0.09443191f, -0.01791975f, 0.04295086f, -0.00834989f, 
    0.13762709f, -0.01673928f, 0.20281924f, 0.19026396f, -0.12894753f, -0.05851718f, -0.02712584f, -0.05350032f, 
    -0.03672206f, -0.00465437f, -0.03115739f, 0.00292063f, -0.21634901f, 0.01760547f, 0.01493510f, -0.14288861f, 
    0.08322941f, 0.01512830f, 0.16010608f, 0.10743943f, -0.01305513f, -0.03246383f, 0.07943866f, 0.01035240f, 
    0.02733542f, 0.00425595f, -0.15507059f, -0.00471666f, -0.02972298f, 0.07503113f, 0.15342969f, 0.14356172f, 
    0.14476097f, 0.04531990f, 0.14131361f, -0.05748243f, 0.02849393f, 0.01477056f, -0.04155574f, -0.01966979f, 
    0.13516654f, 0.11193891f, -0.11824452f, 0.10249479f, 0.08122420f, 0.19117926f, 0.21183009f, 0.04883101f, 
    -0.04554745f, -0.01004318f, 0.06903016f, -0.00050433f, -0.11761665f, 0.00863282f, -0.06501860f, -0.07107486f, 
    -0.01672105f, 0.02024000f, 0.05431381f, 0.03168293f, -0.00975660f, 0.05836995f, 0.15867390f, 0.11617550f, 
    -0.27593502f, -0.08594392f, -0.06688823f, -0.00658635f, 0.05553928f, 0.05251682f, -0.02717750f, -0.03467826f, 
    -0.12618846f, -0.19234902f, -0.07730071f, -0.14734679f, 0.05924944f, -0.01761933f, 0.02248911f, -0.02008940f, 
    0.02052139f, -0.04407876f, -0.14099491f, -0.07192633f, -0.11227304f, 0.01137131f, -0.00224035f, 0.00235452f, 
    0.08539076f, -0.04064471f, -0.01927119f, 0.10810535f, 0.11215851f, 0.06857058f, 0.04821955f, -0.04450413f, 
    0.04128507f, -0.00093342f, 0.04285758f, -0.00227967f, 0.20076728f, -0.04202335f, -0.02166361f, 0.10617878f, 
    0.14906518f, 0.13441670f, 0.10504296f, 0.07106995f, 0.04120034f, -0.04877852f, -0.07576206f, -0.14994445f, 
    0.23779474f, 0.25080541f, 0.14615627f, 0.17754745f, 0.02235529f, 0.14811578f, 0.02740245f, -0.02820622f, 
    0.05336734f, -0.07674831f, 0.16545106f, -0.02916563f, -0.05482437f, 0.00617751f, -0.00048529f, -0.16712657f, 
    -0.06421161f, -0.01752961f, -0.00650732f, 0.04146638f, 0.00034817f, 0.02801026f, 0.11274005f, 0.11036345f, 
    0.10145505f, 0.03825821f, 0.06002015f, -0.01857537f, 0.07387492f, 0.03430594f, -0.08185261f, 0.06813835f, 
    0.08178733f, 0.03424128f, 0.18045375f, 0.06338239f, 0.35985312f, -0.07663785f, -0.12352057f, -0.21969135f, 
    -0.01032344f, 0.04230229f, 0.00854209f, -0.03572604f, -0.01069599f, 0.02845669f, -0.08804172f, 0.00204265f, 
    -0.07800152f, 0.11859571f, 0.11092763f, 0.19602455f, -0.02900035f, 0.04769223f, -0.06331877f, -0.05114441f, 
    -0.06120211f, -0.04673479f, 0.01704991f, 0.08557058f, -0.13798244f, 0.19520418f, -0.21360435f, 0.29349515f, 
    0.08003327f, -0.00092225f, 0.05393095f, -0.01393092f, 0.10957354f, 0.15814704f, -0.00770264f, 0.05225849f, 
    -0.11702064f, 0.22124881f, -0.16464171f, 0.38740829f, 0.03137352f, 0.06402357f, -0.02189627f, 0.07595792f, 
    0.02488682f, -0.17089444f, 0.15595342f, 0.05581889f, 0.23918256f, -0.19923520f, 0.04182490f, 0.21463333f, 
    0.17869268f, 0.03563541f, 0.17747478f, 0.01889072f, -0.11514470f, 0.14429541f, 0.01421933f, 0.00043791f, 
    0.05748832f, -0.14138731f, 0.06478561f, -0.14151664f, -0.05788275f, 0.05229121f, -0.05741355f, -0.18193118f, 
    -0.06901798f, 0.00100732f, -0.03344179f, 0.02963294f, 0.27108455f, 0.09826352f, -0.16150965f, -0.01511119f, 
    0.03674457f, 0.05376538f, 0.14995700f, -0.11950358f, 0.08309249f, -0.07141063f, 0.16629420f, 0.01191623f, 
    0.01430093f, 0.11953922f, 0.13953194f, 0.14417030f, 0.04689941f, 0.04697741f, 0.12957820f, 0.13252096f, 
    0.08244966f, 0.08505238f, 0.10914638f, -0.03840097f, -0.10286926f, 0.04510912f, 0.07801769f, 0.23032409f, 
    0.12375927f, 0.01281317f, 0.06747063f, -0.01725718f, 0.06043361f, -0.00568422f, 0.06693845f, 0.00174249f, 
    0.31568560f, -0.12209329f, -0.01987312f, -0.06055688f, -0.04488282f, -0.01292474f, 0.08688858f, 0.01518651f, 
    -0.07309105f, -0.03628320f, -0.02397147f, 0.11746798f, 0.06464547f, 0.25390324f, 0.10587492f, -0.10625042f, 
    0.01777763f, -0.04372585f, 0.01152731f, 0.08335368f, 0.07496720f, 0.02228939f, 0.06614917f, 0.08396554f, 
    -0.10239461f, 0.00278431f, -0.29725975f, 0.11969121f, -0.00811308f, -0.00379486f, -0.08814277f, 0.09182558f, 
    -0.07302998f, 0.03994767f, 0.11497803f, 0.00519079f, 0.04458367f, -0.10334191f, 0.23977442f, 0.06701365f, 
    -0.09784456f, -0.11753419f, -0.12097894f, -0.03722508f, -0.00262284f, 0.02681227f, 0.07003561f, -0.03558918f, 
    0.09359166f, 0.21298949f, 0.17973088f, 0.18521810f, -0.02860586f, -0.08320356f, -0.03491879f, 0.03004288f, 
    0.05779714f, 0.01731141f, 0.20306152f, 0.05815095f, -0.02184906f, -0.14342035f, -0.17804931f, 0.03826096f, 
    0.13757129f, 0.05739541f, -0.01023938f, -0.14409494f, 0.07452310f, 0.03079922f, 0.07363832f, 0.00798192f, 
    -0.05492498f, -0.17615019f, -0.16883846f, -0.12228793f, -0.04927014f, -0.00941480f, -0.05960944f, 0.04829020f, 
    0.00790617f, 0.04568449f, 0.03791523f, -0.04301573f, -0.02540805f, 0.16803563f, -0.08788334f, 0.25842944f, 
    0.01330669f, 0.01863743f, 0.00927676f, -0.04735063f, 0.00305065f, -0.01233547f, 0.03950468f, -0.00610659f, 
    -0.13238437f, 0.06359768f, -0.05643884f, -0.01321585f, -0.09257266f, 0.08128187f, 0.07243788f, -0.13445550f, 
    0.00510189f, -0.06998716f, -0.06271106f, -0.12390323f, -0.05997128f, -0.11619668f, 0.00974479f, 0.14706498f, 
    -0.00686764f, 0.02471479f, 0.18805671f, -0.07901575f, -0.06096831f, -0.06765584f, -0.18103606f, 0.11358784f, 
    -0.00746004f, 0.20352453f, -0.11321203f, 0.15299495f, -0.01260466f, 0.01312181f, 0.07665161f, -0.09117494f, 
    0.05030107f, 0.03783819f, -0.07488356f, -0.14880796f, -0.11588328f, 0.06084968f, -0.01024706f, 0.03128175f, 
    -0.09429683f, -0.04822033f, -0.00322388f, -0.08684383f, -0.03152674f, 0.00143954f, -0.08238256f, -0.03245178f, 
    0.33190119f, 0.31642458f, -0.22953801f, 0.05890554f, 0.14761004f, -0.00845663f, 0.04694153f, 0.02040217f, 
    -0.01525988f, 0.08427593f, 0.11580079f, -0.05869245f, 0.08727486f, 0.25023606f, 0.04918993f, -0.15012383f, 
    -0.17568384f, 0.03224599f, 0.05831369f, 0.12505752f, -0.10978657f, 0.22828807f, -0.01921705f, 0.10358152f, 
    0.11733768f, -0.24077079f, -0.12589642f, 0.15094772f, 0.12229646f, -0.19817421f, 0.21347818f, 0.06821115f, 
    0.13494807f, 0.08684412f, -0.00344267f, -0.00581360f, 0.27689680f, 0.04806417f, 0.04249997f, -0.00091625f, 
    0.05977906f, 0.08052688f, 0.09952118f, -0.04529702f, 0.05304897f, 0.01602998f, 0.09459557f, 0.06825751f, 
    0.18993050f, -0.20637333f, -0.25006148f, -0.03881873f, -0.05382257f, -0.08941128f, -0.03826785f, -0.01609487f, 
    -0.07367143f, 0.06836565f, 0.01961329f, -0.06779277f, -0.06738771f, 0.12835078f, -0.23049396f, -0.01853391f, 
    -0.09547278f, 0.11365879f, 0.07073020f, 0.01095701f, -0.04766162f, 0.03253385f, 0.00168944f, 0.13912576f, 
    0.12445871f, -0.10698207f, -0.06386860f, 0.01072945f, 0.05342515f, -0.02163206f, -0.12816994f, -0.02769717f, 
    -0.13636260f, -0.03167241f, -0.03936731f, -0.08532571f, 0.05541644f, 0.20526007f, 0.22102840f, 0.00110358f, 
    -0.02963030f, -0.05237334f, -0.02115564f, 0.01843548f, -0.04307415f, 0.11322790f, 0.00047669f, -0.03451043f, 
    -0.18024670f, 0.26459381f, 0.06035580f, -0.24368857f, -0.18267913f, -0.05850324f, -0.09640472f, -0.10301577f, 
    -0.00329835f, -0.02463770f, 0.07114324f, -0.21740688f, -0.09331340f, -0.10001715f, 0.17262323f, 0.36324635f, 
    -0.03282912f, -0.11671583f, -0.01520975f, 0.14446306f, -0.05917998f, -0.01428934f, -0.05555061f, 0.15659416f, 
    -0.07163120f, -0.12639603f, -0.04488406f, -0.09984586f, -0.10437079f, 0.05730108f, 0.00205587f, 0.06048645f, 
    -0.09658993f, 0.14961524f, 0.08430947f, 0.03714144f, -0.35017258f, 0.56557649f, -0.20970638f, -0.04707677f, 
    -0.05814321f, 0.00539731f, 0.03916885f, -0.04641723f, -0.02837619f, 0.08354483f, 0.13058405f, -0.03136806f, 
    -0.14332761f, 0.25930849f, 0.03696356f, -0.07766146f, -0.11125575f, -0.05540304f, -0.00029146f, -0.09651887f, 
    -0.06310919f, 0.03325329f, 0.01021602f, 0.08557983f, 0.13291977f, -0.07345142f, 0.11529604f, -0.07641306f, 
    0.02376096f, 0.05508966f, -0.04099909f, -0.00535304f, -0.05305135f, 0.04871226f, 0.01011344f, 0.02870513f, 
    -0.00970042f, 0.24219437f, 0.45343211f, 0.03928617f, -0.02653842f, -0.09435560f, -0.01102785f, -0.10580094f, 
    0.02228426f, -0.13631055f, 0.02605496f, -0.05594747f, 0.10625386f, -0.07441670f, -0.14378133f, 0.20532237f, 
    0.11466759f, 0.08245030f, 0.18642750f, 0.01249332f, -0.02718384f, 0.03210169f, 0.07790205f, 0.05068081f, 
    0.23833214f, 0.02749468f, 0.28450292f, -0.14412561f, -0.06718383f, -0.02969618f, -0.06124321f, -0.07393992f, 
    -0.11193980f, -0.05740635f, -0.08556914f, -0.01868807f, -0.00811513f, -0.05488547f, 0.07689855f, 0.13842745f, 
    0.05792324f, 0.08714344f, -0.07148491f, -0.05710324f, 0.04960753f, -0.04132359f, 0.06101536f, 0.00717142f, 
    0.15636928f, 0.41804114f, -0.24466671f, 0.00702032f, 0.06630255f, 0.13223167f, 0.03660250f, 0.06477156f, 
    0.02371938f, 0.07404833f, 0.14789006f, 0.01447198f, -0.05995934f, -0.07924543f, 0.14439273f, 0.06141463f, 
    0.02340262f, -0.03896204f, 0.00107804f, 0.03846435f, -0.10982897f, -0.03817864f, -0.02642118f, -0.06552260f, 
    0.09884098f, 0.01520181f, 0.06543086f, -0.07586122f, -0.12384851f, -0.04904062f, 0.05902003f, -0.02282471f, 
    0.01494843f, -0.04034074f, -0.09729344f, -0.00300300f, 0.12433228f, -0.03362343f, 0.13617902f, -0.03017328f, 
    -0.00434041f, 0.10157567f, 0.00411989f, -0.06371245f, -0.06001497f, 0.00563328f, -0.03012356f, -0.09441325f, 
    -0.09233957f, 0.08403950f, -0.20412971f, -0.03916185f, -0.01392865f, -0.07061494f, -0.02169194f, -0.08791638f, 
    -0.09194269f, -0.06089457f, -0.10516627f, -0.00806275f, 0.08930224f, 0.27828503f, 0.19101585f, -0.19563270f, 
    -0.11539642f, -0.03899211f, 0.03569635f, -0.08015662f, -0.07696486f, 0.03466609f, -0.00548301f, 0.04617622f, 
    0.02793021f, 0.14368062f, -0.27705431f, 0.15579121f, 0.01227623f, -0.12001825f, 0.13737226f, -0.06949279f, 
    -0.03382745f, 0.16311935f, 0.00365899f, -0.10058250f, 0.13728727f, 0.14240630f, -0.16959696f, -0.12684205f, 
    0.11391591f, 0.10417988f, 0.23394753f, 0.00396400f, 0.02859492f, 0.04096148f, 0.00703865f, 0.05405090f, 
    -0.03997543f, 0.21917324f, 0.01531765f, 0.11187799f, -0.13715231f, 0.03101563f, 0.01561118f, -0.08408717f, 
    -0.10659697f, -0.06886218f, 0.06196227f, -0.05609581f, -0.17521518f, -0.26512465f, -0.19761111f, -0.15632950f, 
    -0.01002496f, -0.04075084f, -0.05872395f, -0.03633273f, 0.00622244f, 0.07642689f, -0.01274154f, 0.03330527f, 
    0.11767669f, 0.16221327f, 0.11942557f, -0.06416177f, -0.09117121f, -0.01428795f, -0.03074952f, -0.03110684f, 
    0.14035952f, -0.00958852f, 0.05214354f, -0.07980863f, 0.04771900f, -0.08134545f, -0.27594855f, -0.10404672f, 
    0.01822377f, 0.04330533f, -0.03555612f, 0.13159287f, -0.06183473f, -0.07942664f, -0.03588465f, 0.15760520f, 
    -0.15161562f, 0.07825354f, -0.08108693f, 0.02953815f, -0.12313613f, -0.11091195f, -0.07362136f, -0.00941047f, 
    0.00571969f, -0.01448069f, 0.00729965f, 0.06612023f, -0.08800749f, 0.27478680f, 0.08024829f, 0.02273687f, 
    -0.04456879f, -0.02034417f, -0.01912598f, -0.05370622f, 0.00089200f, 0.30033559f, 0.05510839f, 0.10467473f, 
    -0.10135116f, -0.00692768f, 0.06248958f, 0.06452437f, -0.02758096f, 0.01021238f, 0.01150564f, 0.02743663f, 
    0.09442914f, 0.07716080f, 0.11318187f, 0.06377235f, -0.08867892f, 0.03626498f, -0.35913104f, 0.04333885f, 
    -0.00802572f, -0.09369731f, -0.14373600f, 0.05853939f, -0.00339241f, 0.00994830f, 0.10420397f, 0.04367672f, 
    0.02377462f, -0.13371615f, -0.40261218f, -0.04291631f, 0.00893728f, -0.13718903f, -0.02868873f, -0.00939008f, 
    0.02002612f, -0.00146027f, -0.04006080f, -0.02680533f, 0.00409236f, 0.05477289f, -0.14456223f, 0.16858695f, 
    0.02410260f, -0.17162500f, 0.04409792f, -0.07882634f, -0.11255113f, 0.14763582f, -0.00490782f, 0.06991426f, 
    -0.08627415f, 0.23721392f, 0.00614069f, -0.02638677f, 0.04410395f, 0.02234881f, -0.05582887f, 0.05354856f, 
    -0.00130062f, 0.22300702f, -0.12182488f, 0.12404399f, 0.26158476f, -0.08449409f, 0.31070042f, -0.20233117f, 
    -0.20163701f, 0.08455786f, 0.04276306f, 0.03383131f, 0.08736596f, 0.00693784f, -0.13436209f, 0.04710665f, 
    0.03263652f, -0.11045782f, 0.15128282f, 0.15479717f, 0.13697164f, -0.07929596f, -0.07515325f, 0.02456018f, 
    -0.15098882f, 0.07931513f, -0.01740041f, -0.05421595f, 0.07462617f, 0.30812871f, 0.06217952f, 0.13283274f, 
    -0.16366278f, 0.10542310f, -0.06531544f, 0.06896837f, 0.00578534f, 0.08535215f, -0.01298181f, 0.05448290f, 
    0.05875556f, -0.09329750f, -0.04798900f, 0.14897169f, -0.00137072f, -0.07321805f, 0.15792567f, 0.06380434f, 
    0.06580932f, -0.07919264f, 0.08250990f, -0.00914733f, -0.04146251f, 0.04980793f, -0.04150153f, 0.01531370f, 
    -0.08543888f, -0.05632199f, -0.05640731f, -0.07512368f, 0.01469478f, -0.08208440f, -0.01930112f, -0.01010286f, 
    -0.00250894f, -0.02860108f, 0.02762620f, 0.04735016f, 0.08308730f, -0.01479101f, 0.01763250f, -0.02980118f, 
    -0.11953326f, -0.05396697f, 0.01361733f, -0.00156131f, 0.40436602f, 0.14617468f, 0.19097151f, -0.21035512f, 
    -0.10145792f, -0.05048623f, -0.01896747f, -0.02775748f, 0.09790322f, 0.03170503f, 0.10723276f, 0.02767229f, 
    -0.04247290f, -0.02179590f, 0.00109056f, -0.02631486f, 0.01142221f, 0.00237636f, 0.00827006f, -0.00720440f, 
    0.01884386f, -0.01582600f, 0.00840398f, 0.01644200f, -0.02700346f, 0.02934791f, -0.03960010f, -0.00950667f, 
    0.01549164f, -0.01878261f, 0.02322052f, -0.00081173f, 0.02002349f, -0.00815960f, 0.02163908f, 0.01613691f, 
    -0.02527985f, 0.02380132f, -0.03736489f, 0.02285906f, -0.03822561f, -0.02924982f, 0.02303765f, -0.01860246f, 
    -0.01153607f, -0.00466396f, -0.01975622f, 0.01350344f, 0.02694554f, -0.03641225f, -0.01135613f, -0.01047521f, 
    -0.01239803f, -0.03227925f, 0.01811206f, -0.00973396f, -0.04293499f, 0.00341913f, -0.00908853f, -0.04381717f, 
    0.01819261f, 0.00412961f, -0.00537678f, -0.00235532f, -0.03803606f, 0.00644492f, -0.01454805f, -0.01116615f, 
    0.01579955f, 0.01048864f, -0.01334543f, 0.01332947f, -0.01770200f, -0.03225597f, -0.01374565f, -0.00500615f, 
    -0.01721860f, -0.01011605f, 0.02714945f, -0.00219057f, 0.00867919f, 0.01965163f, -0.03094351f, -0.01950598f, 
    -0.00023647f, -0.01724840f, 0.01073571f, 0.00865693f, 0.01727628f, -0.03405195f, -0.01922139f, 0.02423839f, 
    -0.02755854f, -0.02448429f, -0.01593711f, 0.01406136f, -0.02003119f, 0.00903599f, -0.03834373f, -0.01201844f, 
    0.01381713f, -0.01279728f, 0.00256596f, 0.01061723f, -0.02373707f, 0.00496913f, -0.04142972f, 0.00525220f, 
    -0.02032592f, -0.01000405f, -0.00855622f, -0.00673174f, 0.01314583f, -0.03669715f, -0.00537476f, 0.01201266f, 
    -0.03392019f, -0.01676183f, -0.01487321f, -0.02544583f, 0.00300664f, -0.00814353f, -0.01066028f, 0.00350691f, 
    -0.00148538f, -0.02430965f, -0.03946787f, 0.00184132f, -0.02690028f, 0.02607599f, 0.01199932f, 0.02013053f, 
    -0.03876321f, -0.01094969f, 0.00326574f, -0.03486472f, 0.03497253f, 0.00355142f, -0.01368174f, -0.02542207f, 
    -0.02331402f, -0.00104328f, 0.01886699f, -0.02645424f, -0.01643809f, -0.01992342f, -0.00658794f, -0.03799437f, 
    -0.02251513f, -0.02265688f, 0.00658653f, 0.02243359f, -0.02995847f, 0.00708908f, 0.02209477f, -0.02463833f, 
    0.01334889f, 0.01191606f, 0.01789629f, -0.02966128f, -0.01932503f, 0.00645656f, 0.02547631f, 0.01341003f, 
    0.02082058f, 0.00344214f, -0.01589783f, 0.00381055f, 0.01580366f, 0.00937461f, -0.00725422f, 0.00808259f, 
    0.00101034f, 0.00584350f, -0.01900374f, 0.00149417f, -0.00518593f, -0.00803371f, 0.00000169f, -0.00219686f, 
    -0.02720633f, -0.01552576f, -0.00419882f, -0.03771133f, -0.01282464f, -0.00443539f, 0.00981444f, -0.00166522f, 
    0.02371238f, 0.00970183f, -0.03892490f, 0.00351534f, -0.03877609f, -0.01153195f, 0.01763965f, 0.00030558f, 
    -0.00293936f, -0.03808247f, -0.00805843f, 0.01367636f, -0.00853645f, -0.02415215f, 0.00794122f, -0.02109012f, 
    -0.01982792f, -0.00413357f, 0.02770957f, -0.04221451f, 0.00639675f, -0.02825816f, 0.02678197f, -0.01752152f, 
    0.00598330f, -0.01993519f, -0.00841711f, 0.00850313f, -0.01712668f, 0.02671023f, -0.02568972f, -0.03218539f, 
    -0.03022411f, 0.00343693f, 0.02782506f, -0.02511905f, -0.02033203f, 0.00255987f, -0.00892642f, -0.00077944f, 
    -0.02781384f, -0.01141175f, -0.02223675f, -0.00665940f, 0.01086441f, -0.02371135f, -0.03884238f, 0.02103895f, 
    0.02835692f, 0.01499742f, -0.02685293f, -0.03916226f, -0.04185126f, -0.01106207f, 0.01154746f, -0.00386735f, 
    -0.01176284f, -0.02518633f, 0.02319276f, 0.01495553f, -0.02135212f, -0.03922883f, -0.02581213f, -0.02412240f, 
    -0.00116566f, 0.00714720f, -0.00746488f, 0.02822490f, 0.02741557f, -0.03112510f, 0.02501406f, -0.01956879f, 
    -0.01143696f, 0.02504167f, 0.01230299f, -0.02670960f, -0.03086750f, -0.01478898f, 0.01718041f, -0.01885175f, 
    0.01559033f, -0.00728436f, -0.00360511f, -0.00860233f, -0.01113151f, 0.02262596f, 0.02020816f, -0.03572595f, 
    0.00654025f, 0.00162081f, 0.00589224f, 0.00872189f, -0.02658628f, -0.04124802f, -0.02676566f, 0.01745979f, 
    -0.01105416f, -0.02970565f, 0.01735964f, 0.01926895f, 0.01151214f, 0.02575580f, 0.01089364f, 0.01316504f, 
    -0.02361592f, -0.00938053f, -0.00272967f, 0.01837905f, 0.00905114f, 0.02736633f, -0.01994645f, -0.01877081f, 
    -0.00268011f, -0.01457809f, -0.00709368f, -0.01890987f, 0.00409951f, 0.00534682f, 0.02218563f, -0.00959028f, 
    0.00493017f, -0.01084656f, -0.02474173f, 0.02359337f, -0.03300083f, 0.01772361f, -0.02118785f, 0.02316755f, 
    0.01754509f, 0.02497588f, 0.00602005f, 0.01230649f, 0.00193658f, 0.01393431f, -0.03370403f, -0.04039201f, 
    0.01091641f, -0.01630398f, 0.00582962f, -0.00842736f, -0.01394311f, -0.02768839f, 0.02524315f, -0.03464948f, 
    -0.03340565f, -0.01800412f, 0.02583305f, -0.03267188f, -0.01478877f, -0.01454121f, -0.03841718f, -0.03804101f, 
    -0.01434063f, -0.01425048f, 0.01718829f, -0.01902051f, 0.01803223f, 0.02191771f, -0.00667831f, 0.00351354f, 
    0.02316162f, -0.01194060f, 0.02615124f, 0.00126760f, 0.01117998f, -0.03357823f, -0.03066115f, -0.03562749f, 
    -0.03165600f, 0.02796403f, -0.00457803f, 0.01382193f, -0.00035836f, 0.02021211f, 0.00315740f, 0.01678987f, 
    -0.03261518f, 0.03034276f, -0.02457633f, 0.01315844f, -0.02410679f, 0.02893472f, 0.01921761f, -0.01244315f, 
    -0.02711564f, 0.00073565f, -0.00787067f, 0.01856753f, 0.01285922f, 0.02236678f, 0.02107478f, 0.01131774f, 
    -0.00524822f, 0.00498769f, 0.00984966f, -0.00692805f, -0.04116822f, 0.00881888f, -0.00883453f, -0.00749949f, 
    0.02118016f, 0.00014908f, 0.01202234f, 0.00703834f, -0.00740883f, 0.01507861f, -0.01538893f, -0.02311599f, 
    -0.01356276f, 0.02493293f, -0.01293884f, -0.03245195f, 0.01245352f, -0.02276144f, -0.00441884f, -0.03709022f, 
    0.01448202f, 0.02695157f, -0.01516293f, -0.03723076f, 0.01435554f, 0.01400509f, -0.02652518f, -0.00321263f, 
    -0.03065901f, -0.01174132f, 0.02803832f, -0.04051418f, 0.01477913f, -0.01283150f, 0.00458881f, 0.01369574f, 
    -0.01807747f, 0.01118797f, -0.00036332f, 0.02278576f, -0.04164851f, -0.03741308f, 0.00292526f, -0.04076452f, 
    -0.00441261f, -0.01084931f, 0.02313657f, -0.00647382f, -0.03834823f, 0.00378985f, -0.00196289f, 0.00399981f, 
    0.00695081f, -0.00373803f, 0.02741029f, -0.04017744f, -0.00748855f, -0.01752981f, -0.02170563f, -0.01157191f, 
    0.02510035f, 0.00029134f, 0.02041019f, 0.01432579f, 0.01106040f, -0.03562530f, -0.00131835f, -0.02956310f, 
    -0.00041360f, 0.01887637f, -0.03314611f, -0.01948769f, 0.01371876f, 0.00010464f, 0.00281674f, -0.03689718f, 
    0.00265288f, 0.00807668f, -0.02118339f, -0.00330792f, -0.03947417f, -0.03802648f, 0.02815246f, -0.00306632f, 
    -0.03634071f, 0.02401834f, 0.00523201f, -0.01861412f, 0.00492875f, 0.00121490f, -0.03460532f, 0.00824600f, 
    -0.01513610f, -0.00762636f, -0.00674488f, 0.02010696f, 0.00567910f, -0.00896615f, 0.00746134f, 0.02056371f, 
    0.00932098f, 0.03058500f, -0.00345798f, -0.03269087f, 0.02720069f, 0.00898701f, 0.02667479f, -0.03080857f, 
    -0.01052657f, -0.02170262f, -0.01691075f, 0.01028028f, -0.03724990f, -0.00823499f, -0.02425708f, 0.00462114f, 
    -0.01230472f, 0.01673447f, -0.00300070f, -0.03697434f, -0.03926539f, -0.01924070f, 0.01424909f, 0.02383356f, 
    -0.04102581f, 0.01757302f, -0.00182471f, -0.03687216f, -0.01929936f, 0.00406130f, -0.02661793f, 0.00211849f, 
    -0.04111535f, -0.02629969f, -0.03761083f, -0.03798971f, -0.01958190f, -0.01361016f, -0.00412467f, 0.00653887f, 
    -0.00311074f, 0.02193840f, -0.03864870f, -0.02454033f, -0.01362978f, -0.03258917f, 0.00865593f, 0.02819229f, 
    -0.04202857f, -0.03585246f, 0.02089635f, 0.00933408f, 0.01142703f, -0.00355980f, -0.03878164f, -0.02979451f, 
    0.00197817f, -0.03011011f, -0.02416843f, 0.02002996f, 0.01852976f, 0.00755212f, -0.03875439f, 0.02729507f, 
    -0.02447596f, 0.00499783f, -0.01519101f, 0.00351758f, 0.00839763f, 0.00672164f, -0.00374345f, -0.00909375f, 
    0.02743840f, -0.03975541f, -0.01675772f, 0.01015596f, 0.02013099f, 0.02015979f, -0.01725825f, -0.01854253f, 
    0.01790794f, 0.02190933f, -0.02381428f, 0.00319161f, 0.02369471f, -0.01082446f, -0.03721784f, 0.02899469f, 
    -0.03083260f, -0.03665638f, -0.03550784f, 0.02474815f, 0.01883079f, -0.02101494f, 0.02221985f, -0.04166545f, 
    0.01405326f, -0.02834952f, -0.03751772f, 0.02360102f, -0.02619621f, 0.02626602f, 0.01209356f, 0.00518525f, 
    0.00991957f, -0.01495516f, -0.01187985f, 0.00673449f, -0.01331674f, 0.01851428f, 0.01230496f, -0.00681070f, 
    -0.02388158f, 0.02476941f, -0.00139456f, -0.02659454f, -0.01791754f, -0.00294640f, -0.02187141f, 0.01938004f, 
    -0.01601806f, 0.02782607f, 0.02140564f, 0.00818637f, 0.03020057f, 0.01332437f, -0.00459231f, -0.00797668f, 
    0.01384441f, -0.02768070f, -0.03026070f, -0.03545235f, 0.00356648f, -0.00315730f, -0.04259769f, 0.02298499f, 
    -0.02596914f, 0.01123778f, 0.01823886f, -0.00874784f, 0.02167330f, -0.00806661f, 0.02704018f, 0.02657456f, 
    -0.03404871f, -0.01858258f, 0.02781083f, 0.01133010f, -0.01445416f, 0.01461746f, 0.02687719f, -0.02405335f, 
    -0.03813156f, -0.04075399f, -0.02120513f, -0.00817725f, -0.00716531f, 0.01801469f, 0.00906262f, -0.03398269f, 
    -0.01356314f, 0.02602211f, 0.00857805f, -0.03408229f, -0.01254883f, -0.00287340f, -0.03052341f, 0.01587983f, 
    0.02751424f, 0.02445138f, 0.02067156f, -0.01536043f, -0.01549924f, -0.02475062f, 0.02144841f, 0.00123072f, 
    -0.02375653f, 0.00969172f, 0.02320205f, 0.02825943f, -0.00516947f, -0.00672878f, 0.01206429f, 0.00206687f, 
    -0.01648711f, 0.00175194f, -0.03945448f, -0.02699759f, 0.02418726f, 0.02171433f, 0.02096101f, 0.01733465f, 
    -0.02728262f, -0.03460889f, 0.02316378f, -0.02542034f, -0.01715758f, -0.00709023f, -0.01421782f, -0.00647773f, 
    0.01664078f, -0.01816723f, -0.02142086f, 0.01709305f, 0.02628830f, 0.00318371f, -0.02677820f, -0.00868080f, 
    -0.03540602f, -0.02991983f, -0.02508194f, -0.02950709f, 0.01394780f, -0.02706649f, -0.03701657f, -0.03881806f, 
    -0.02146188f, -0.00117941f, 0.01738497f, -0.00147854f, -0.03784938f, -0.00317744f, 0.02253399f, -0.01930443f, 
    -0.02798368f, 0.02289107f, 0.02268701f, -0.02882246f, 0.02877522f, -0.02464314f, 0.01399683f, -0.00702740f, 
    -0.03000855f, -0.00438746f, 0.02040650f, 0.02018184f, 0.02849831f, -0.03780913f, 0.01684886f, -0.03540296f, 
    -0.03556007f, 0.02994788f, -0.02272050f, -0.00634502f, -0.00295218f, 0.00174160f, -0.02779767f, -0.02519388f, 
    -0.03687127f, -0.00506694f, -0.03108134f, -0.03170130f, -0.01046766f, -0.02809232f, -0.03325298f, -0.00723161f, 
    -0.02093274f, -0.02011374f, 0.02205100f, 0.01166519f, -0.04123078f, 0.02821390f, 0.00591957f, -0.01851175f, 
    -0.02627506f, -0.02668756f, -0.00346191f, -0.03429257f, -0.02784279f, -0.02551249f, -0.01461252f, -0.03156107f, 
    -0.00827500f, 0.01579966f, 0.00054611f, -0.03370711f, -0.02080346f, -0.00295177f, 0.02402162f, 0.00746603f, 
    -0.04021619f, -0.00660824f, 0.01688523f, -0.00139840f, -0.00056570f, -0.03427903f, 0.00290055f, 0.00765388f, 
    -0.01716090f, 0.01774555f, 0.00104478f, -0.02640239f, -0.04304715f, -0.02353618f, -0.00983091f, -0.00217990f, 
    0.07723840f, 0.05019477f, 0.05675082f, 0.17743614f, -0.01592296f, -0.06795824f, 0.17537232f, 0.02934512f, 
    0.06527659f, 0.00136450f, 0.08399986f, 0.02529854f, 0.22130898f, -0.33470112f, 0.22531287f, -0.01304084f, 
    0.03552636f, -0.08486644f, -0.03229111f, 0.12548542f, 0.09040900f, -0.06894276f, -0.00239132f, -0.03526432f, 
    0.04130485f, -0.15231027f, 0.16801955f, 0.16498031f, -0.01696592f, 0.19351405f, -0.02088013f, 0.06770951f, 
    0.03524970f, -0.06516713f, 0.00257543f, 0.06037658f, -0.03466583f, -0.03185523f, 0.05381548f, -0.10991129f, 
    -0.00916897f, 0.10469019f, -0.17585920f, 0.02713993f, 0.03345897f, 0.07632387f, -0.00141580f, -0.02697746f, 
    0.47258997f, 0.23193619f, 0.12137067f, -0.04780149f, -0.03009923f, -0.11689037f, -0.03505611f, -0.00271933f, 
    -0.04455357f, 0.02064540f, -0.02456044f, -0.00166677f, -0.22861107f, 0.18031192f, 0.21091673f, -0.17506468f, 
    0.01635524f, 0.10745558f, 0.19147517f, -0.00670138f, -0.02505056f, 0.06850322f, 0.03258093f, -0.17925698f, 
    -0.00095053f, -0.06971821f, -0.13402240f, -0.16003600f, -0.01335869f, -0.01943014f, -0.11381912f, 0.04078202f, 
    -0.07458421f, -0.10103902f, -0.00079691f, -0.12846938f, 0.10638438f, -0.03198814f, 0.06352653f, -0.08594489f, 
    0.05582103f, -0.02840397f, -0.10972705f, -0.01097373f, -0.01812882f, -0.02845529f, 0.03256527f, -0.13524801f, 
    0.03061772f, -0.50161672f, 0.38958451f, -0.11247363f, 0.04808909f, 0.15632741f, -0.01137610f, 0.14214478f, 
    -0.05275234f, 0.02719647f, 0.04752574f, -0.02883630f, -0.13580742f, -0.03807161f, 0.09835733f, -0.00654303f, 
    -0.01745240f, 0.04821655f, -0.05691231f, -0.01977498f, 0.07381471f, 0.02280146f, -0.01792708f, 0.16594329f, 
    0.20554161f, 0.14050157f, 0.07107717f, -0.04255450f, -0.00277997f, -0.01954585f, -0.01381983f, -0.02351354f, 
    -0.00868503f, 0.04057963f, 0.03449174f, -0.00563563f, 0.23636384f, -0.00613863f, -0.03435262f, 0.11839040f, 
    0.00773511f, -0.01392765f, 0.02879404f, 0.02506577f, -0.06422661f, 0.02916846f, -0.01205496f, -0.00464722f, 
    0.18116564f, 0.03612674f, 0.19545487f, 0.09359627f, -0.13016200f, 0.03146328f, 0.00225309f, 0.00787698f, 
    -0.01837542f, -0.03750029f, 0.00705401f, -0.03596475f, 0.17278184f, 0.00874901f, 0.02461839f, 0.07936863f, 
    -0.05660200f, -0.15539710f, 0.00594298f, 0.01631333f, 0.03111415f, -0.02335372f, -0.01234075f, -0.01634758f, 
    0.16731028f, 0.17183776f, 0.11075786f, 0.04720085f, -0.17075881f, 0.02645609f, -0.03777639f, 0.02072684f, 
    -0.05551758f, 0.03274046f, 0.01014171f, -0.11286861f, 0.17289698f, 0.24227101f, 0.04602880f, 0.13707951f, 
    -0.03941681f, -0.00233177f, 0.00800029f, -0.04180435f, 0.00560720f, -0.00187989f, -0.00199902f, 0.09449872f, 
    0.05631686f, -0.04202285f, 0.06473803f, -0.03497802f, -0.06692041f, 0.00697917f, 0.04314207f, 0.14957111f, 
    -0.01985596f, 0.00699009f, -0.04524261f, -0.00640087f, 0.21047983f, 0.08821949f, 0.10814411f, 0.03616231f, 
    0.00774156f, -0.02389318f, 0.04969998f, 0.05469285f, -0.08898546f, 0.10657841f, 0.00153056f, -0.04397466f, 
    0.09674343f, -0.05248659f, 0.03812901f, 0.20560573f, 0.05376229f, 0.00601299f, 0.02773337f, 0.07162552f, 
    -0.06153851f, 0.09750067f, -0.09112645f, -0.06854066f, 0.18010238f, 0.17284660f, 0.04693862f, 0.16562669f, 
    -0.02729432f, -0.05306612f, -0.01252326f, -0.04626266f, 0.01100470f, 0.06553301f, 0.09758679f, 0.05467092f, 
    0.27330142f, 0.08704331f, -0.34339821f, 0.05176410f, -0.08547880f, 0.01573589f, 0.13393070f, -0.19038920f, 
    0.08762323f, -0.03475231f, 0.13009617f, 0.08731541f, 0.22506653f, -0.12255369f, 0.25991979f, 0.11340274f, 
    -0.07045521f, -0.03099718f, -0.04563558f, 0.04186683f, 0.03687477f, 0.06650761f, 0.03717384f, 0.00677783f, 
    0.22802849f, -0.31139436f, 0.26416883f, -0.06441730f, 0.05147216f, 0.02891509f, -0.08631726f, 0.11931209f, 
    0.03629598f, 0.13083144f, -0.01017417f, 0.02469144f, -0.03144492f, -0.14614068f, -0.00895216f, -0.01732669f, 
    -0.00466680f, -0.00335675f, 0.16116206f, -0.05603920f, -0.04042353f, -0.12299754f, 0.06210167f, 0.00639592f, 
    0.25744939f, 0.08523601f, -0.06177487f, 0.08902732f, -0.00220230f, 0.00083159f, 0.03491565f, 0.02716953f, 
    0.01851453f, 0.01429365f, 0.02777189f, 0.01162187f, -0.07969085f, -0.10382830f, -0.12431630f, -0.07282182f, 
    0.13617457f, 0.06059319f, 0.00357019f, 0.03822356f, 0.03042125f, 0.06755635f, -0.07862322f, 0.06817292f, 
    0.22837843f, 0.20679022f, -0.00801652f, -0.20841964f, 0.09918274f, 0.05816269f, 0.00252786f, -0.01853692f, 
    -0.10437770f, -0.04779737f, -0.12466437f, -0.01001412f, 0.03810428f, 0.06784134f, -0.29899275f, -0.19378738f, 
    -0.03735290f, 0.03949161f, 0.06267373f, 0.11985372f, 0.03270189f, 0.04393155f, -0.01808361f, -0.12475503f, 
    -0.07190766f, 0.04845097f, 0.38514113f, 0.05198820f, 0.03785564f, -0.00490603f, 0.04506110f, -0.00264293f, 
    0.15219419f, -0.08352051f, -0.04900748f, -0.00928608f, 0.19017956f, 0.04548221f, 0.11781899f, 0.04031666f, 
    -0.12378860f, -0.02121782f, -0.08891226f, 0.04315134f, -0.04053848f, -0.15724698f, -0.03288018f, 0.09359314f, 
    0.04924562f, 0.19991533f, -0.14309135f, 0.08999956f, 0.13600340f, 0.03695959f, 0.11758407f, -0.03184529f, 
    0.14659257f, 0.02054191f, 0.00049633f, 0.00959959f, -0.03294917f, 0.04796280f, -0.11503252f, -0.10287941f, 
    0.00561395f, -0.04727517f, -0.00451184f, -0.05400342f, 0.07730652f, -0.10320947f, -0.03846868f, -0.05989045f, 
    0.08804555f, 0.13735142f, 0.28210193f, -0.00119724f, 0.00850753f, -0.09081191f, -0.07031833f, 0.06653479f, 
    -0.06452452f, 0.00407945f, -0.02411594f, -0.02080023f, -0.08790318f, 0.07107517f, 0.15692295f, 0.04897230f, 
    -0.03699985f, -0.06373617f, 0.01070443f, -0.04229823f, 0.00539778f, 0.01925685f, -0.02280213f, -0.04755196f, 
    0.12394369f, 0.00520727f, 0.11280029f, 0.02292795f, -0.06952049f, 0.00464507f, -0.06484976f, 0.02905684f, 
    0.05580194f, 0.01216757f, 0.02511489f, -0.05640283f, 0.06081648f, 0.06591599f, 0.05439085f, 0.25328243f, 
    -0.07761116f, -0.05931852f, 0.04698554f, -0.09088836f, 0.01545300f, 0.03230772f, 0.14966920f, 0.02112275f, 
    0.30681208f, -0.06800393f, 0.17697482f, 0.06921513f, -0.10983855f, 0.00946903f, 0.01549146f, 0.01437503f, 
    -0.01087718f, 0.01563105f, 0.00902325f, -0.01170418f, 0.13053866f, 0.00051237f, -0.04121958f, 0.05465081f, 
    -0.00030685f, -0.10514290f, -0.06233083f, 0.10818673f, 0.05270784f, -0.02629903f, 0.03544234f, 0.19160397f, 
    0.19137788f, -0.14020476f, 0.00705009f, 0.06543664f, -0.00660158f, -0.02192329f, 0.16015115f, -0.03294631f, 
    0.09165002f, -0.00273450f, 0.00996653f, 0.13694175f, -0.12180149f, 0.04026323f, -0.04625871f, -0.03275007f, 
    -0.01692362f, -0.01266379f, 0.04647124f, 0.10364410f, -0.16476926f, -0.04561486f, -0.09750769f, -0.05241839f, 
    0.08894479f, 0.05923496f, 0.17311479f, 0.10648888f, -0.05719171f, -0.03362395f, -0.02280305f, -0.05105389f, 
    0.01228950f, 0.01148244f, 0.07699832f, 0.10091648f, -0.03672788f, 0.02639222f, -0.18922874f, 0.02145532f, 
    -0.05413540f, -0.02098197f, 0.09610940f, -0.01455742f, -0.09258707f, -0.04763978f, 0.03160175f, 0.07723498f, 
    0.23039354f, 0.20921083f, 0.10391238f, 0.14035517f, -0.04523288f, 0.00325864f, -0.07140586f, 0.09500524f, 
    -0.02464257f, -0.02233058f, -0.00031363f, -0.09605618f, -0.13985604f, -0.11054229f, 0.16077580f, -0.24350515f, 
    0.02776622f, -0.05960593f, 0.00218110f, -0.00401769f, -0.11284626f, -0.07029946f, 0.05605032f, 0.00466731f, 
    0.13114884f, 0.07953136f, 0.07805541f, 0.09785626f, 0.02176149f, 0.20985572f, 0.05941233f, 0.09672150f, 
    -0.13469923f, -0.05828010f, 0.03609742f, -0.11762307f, -0.10158918f, -0.07726596f, 0.19902427f, -0.04515437f, 
    0.08062632f, 0.09192616f, 0.05521205f, 0.07595254f, -0.00266231f, 0.07121022f, 0.11261185f, -0.14083938f, 
    0.12372833f, 0.17175430f, -0.21749949f, 0.14759047f, -0.11057433f, -0.04747620f, -0.01687931f, -0.07150878f, 
    -0.01998336f, 0.02529657f, 0.00411394f, -0.01379783f, 0.14330520f, 0.23936519f, 0.20491482f, -0.00517168f, 
    -0.09047044f, -0.06574287f, 0.07053632f, 0.11769243f, -0.07281453f, 0.00325384f, 0.10428162f, -0.01158512f, 
    0.10365082f, 0.00511242f, 0.01109940f, 0.04871063f, 0.00922398f, -0.04097463f, 0.11142640f, -0.01883688f, 
    0.20136864f, 0.15006658f, 0.00619003f, 0.09508087f, -0.03473755f, 0.04266949f, -0.11579279f, -0.00724080f, 
    0.07873605f, 0.02518513f, 0.05439141f, -0.00239786f, 0.08813063f, 0.04601631f, 0.00978255f, 0.10400593f, 
    -0.16147935f, 0.10141265f, 0.11058005f, 0.14380686f, 0.06299651f, 0.10628253f, -0.01710272f, -0.09694505f, 
    0.02003986f, -0.11382142f, -0.12814832f, -0.11481705f, 0.21830224f, -0.02320648f, -0.01851296f, 0.10080502f, 
    -0.00329906f, 0.01896710f, -0.02192741f, 0.12101446f, 0.03593603f, 0.06794347f, -0.01252765f, 0.11604655f, 
    0.17482992f, 0.25647646f, -0.04055877f, 0.05150851f, -0.06048827f, -0.06834990f, 0.03597485f, 0.14439318f, 
    0.08362207f, 0.07734994f, 0.06746816f, 0.09187880f, 0.31286639f, 0.37133387f, -0.16719224f, 0.02924639f, 
    -0.10978766f, -0.05129377f, -0.00976324f, 0.11325309f, 0.09347459f, 0.00312378f, 0.02766341f, 0.00429895f, 
    0.40150613f, 0.18626402f, 0.07945775f, 0.09326911f, -0.16812114f, -0.09225135f, -0.12369000f, 0.02240152f, 
    -0.02185931f, -0.01549151f, -0.05555914f, -0.08747759f, -0.05272379f, 0.22602330f, -0.11264893f, 0.09220245f, 
    -0.06739210f, -0.00704362f, 0.07523061f, 0.01826171f, -0.01694679f, 0.04523709f, -0.12069700f, -0.08656731f, 
    0.09064162f, 0.10001598f, 0.02784792f, -0.02329581f, 0.03627343f, -0.04110913f, -0.02735935f, -0.00253338f, 
    -0.07050775f, 0.08594577f, 0.01968043f, -0.03626428f, 0.04045792f, -0.04893731f, 0.19443622f, 0.05201579f, 
    0.02609487f, -0.00548851f, 0.11041217f, -0.03095546f, 0.13699214f, 0.03752238f, -0.02754291f, -0.03940829f, 
    -0.07045433f, 0.09138219f, -0.03035212f, -0.06746038f, -0.06266359f, 0.05297859f, 0.03811179f, -0.08696338f, 
    -0.01964018f, -0.03970006f, -0.06126707f, -0.07410794f, -0.01758554f, -0.45562029f, -0.15821022f, -0.23830689f, 
    0.00087601f, 0.08336494f, 0.02553341f, 0.10032260f, 0.02978698f, 0.03321869f, -0.08334739f, -0.01181772f, 
    -0.01433086f, -0.06975532f, -0.14354792f, 0.12584189f, 0.07210544f, 0.17281045f, -0.03231725f, 0.01807763f, 
    0.04605611f, -0.05996665f, -0.12470934f, 0.01553895f, -0.04178096f, 0.15525784f, -0.03624550f, 0.05710826f, 
    0.01353165f, 0.01977569f, -0.00192412f, -0.03657022f, 0.01531118f, -0.04798192f, -0.09048226f, -0.03143086f, 
    0.01812210f, 0.04510060f, 0.03938836f, 0.07475613f, 0.01440530f, 0.05001572f, 0.03711281f, -0.12689243f, 
    -0.07848477f, -0.10307556f, -0.03394695f, -0.05127422f, -0.31955996f, -0.21677592f, 0.14740030f, -0.10716616f, 
    -0.00928452f, 0.02581419f, 0.09825371f, 0.08137676f, 0.09513982f, 0.10274190f, -0.02873869f, 0.01178598f, 
    -0.00062935f, -0.00481041f, 0.02265691f, 0.01601432f, 0.00795346f, -0.00292208f, -0.03667806f, 0.02113467f, 
    -0.04152090f, 0.00045873f, -0.02199374f, -0.02068565f, 0.01356952f, 0.03351475f, 0.02220949f, 0.00134111f, 
    0.01089128f, -0.02227115f, -0.01835978f, 0.02390029f, 0.01671852f, -0.03160930f, 0.02433832f, 0.02430269f, 
    -0.01327789f, -0.01768705f, 0.02189287f, 0.01388397f, 0.02488478f, 0.02497722f, 0.01821546f, 0.01056365f, 
    0.01860254f, -0.00566236f, 0.01077620f, 0.01084753f, -0.01606107f, -0.01832936f, -0.02289670f, 0.00822529f, 
    0.00896894f, -0.04244377f, 0.00179942f, 0.02489952f, -0.01595734f, 0.00400112f, 0.00863226f, -0.01918546f, 
    -0.02761305f, -0.03035839f, 0.03150742f, 0.01525942f, -0.01138118f, -0.04011413f, -0.00462555f, 0.02372913f, 
    0.00066031f, 0.01651340f, 0.00369302f, -0.02786520f, 0.02833423f, 0.02510637f, 0.01055174f, -0.01749163f, 
    -0.03065194f, 0.02570984f, 0.03136341f, -0.01768979f, 0.00519283f, -0.02591268f, -0.02388673f, 0.02457230f, 
    0.02605922f, 0.01092596f, -0.00729778f, -0.01414839f, 0.00115843f, -0.01258427f, 0.01227020f, -0.00314557f, 
    -0.01415738f, 0.01722440f, -0.02402643f, -0.01612511f, -0.01865731f, -0.02589531f, 0.01940577f, 0.00136782f, 
    0.00301757f, -0.02310403f, 0.02829579f, -0.02652527f, -0.02231535f, -0.03066458f, 0.00408353f, 0.01993865f, 
    0.00009524f, -0.02999412f, -0.02125034f, 0.01455962f, -0.01117371f, -0.02421520f, 0.01974249f, -0.01954601f, 
    -0.00997528f, -0.02544843f, -0.02685902f, -0.02358017f, -0.03574011f, -0.03869210f, 0.00314082f, -0.03704849f, 
    -0.02465128f, -0.01137171f, 0.00041215f, -0.02820685f, 0.00103284f, -0.00109346f, -0.01795726f, 0.01534352f, 
    0.02092292f, 0.01070421f, -0.01811123f, 0.02203574f, -0.03709811f, -0.02319153f, -0.00543100f, -0.03168770f, 
    -0.00227059f, 0.00907929f, 0.01569455f, -0.01323456f, 0.01224509f, -0.01350015f, -0.01345339f, 0.02306405f, 
    0.01147216f, -0.03189232f, -0.02549478f, -0.00585975f, -0.00482377f, 0.01439639f, -0.00331459f, -0.00143985f, 
    -0.02217100f, 0.01024246f, -0.01593008f, -0.00049748f, -0.01888815f, 0.02030417f, -0.03344717f, -0.02479953f, 
    -0.00926332f, -0.01681474f, -0.01088944f, -0.02139938f, -0.02403064f, -0.02438196f, 0.02944530f, -0.01746448f, 
    0.03091814f, -0.00364959f, -0.00457502f, -0.03879444f, -0.01316462f, -0.01184020f, -0.03752794f, -0.02022632f, 
    -0.03745066f, 0.02259201f, 0.00794086f, -0.01716215f, -0.00494261f, -0.01387869f, -0.02153381f, 0.01985678f, 
    0.02956940f, 0.00985787f, 0.02435060f, -0.00297801f, -0.01834682f, 0.01734904f, 0.00203326f, 0.00997296f, 
    0.00347176f, -0.04084522f, -0.00601695f, 0.00219256f, -0.02303127f, -0.02535764f, 0.00995524f, 0.00451699f, 
    0.02460974f, -0.02751669f, 0.01129172f, 0.00327852f, 0.01692869f, -0.01094164f, 0.02238477f, -0.02904129f, 
    -0.04410559f, 0.01980684f, 0.01041373f, 0.01744630f, -0.01376393f, 0.00756800f, 0.02000246f, 0.02544496f, 
    -0.00654807f, 0.02007221f, 0.00095364f, 0.02618725f, -0.01155174f, -0.02187247f, -0.02511458f, -0.03687647f, 
    -0.00810780f, -0.02978757f, -0.00280767f, -0.02144476f, -0.03835692f, -0.00962810f, 0.02499682f, -0.02679104f, 
    -0.03639875f, -0.00033101f, 0.01743633f, -0.00187511f, -0.01490027f, 0.00499239f, 0.00837615f, 0.00348380f, 
    0.02027189f, -0.01053499f, 0.02334806f, -0.02427683f, 0.01833944f, 0.01844040f, 0.01539208f, 0.03236491f, 
    0.00846933f, -0.02098032f, 0.00527999f, 0.03913141f, 0.00558171f, 0.01560252f, -0.02353816f, -0.03493361f, 
    0.01187020f, 0.03447944f, -0.01677854f, -0.02851276f, 0.00130848f, -0.03792370f, -0.01194914f, -0.00340916f, 
    -0.00910003f, 0.01615796f, 0.01575543f, 0.02344749f, 0.01983967f, -0.01992454f, -0.00748799f, 0.02589461f, 
    -0.00496897f, -0.02421492f, -0.02526702f, -0.02161883f, -0.01938899f, -0.02327153f, -0.01251991f, -0.03018987f, 
    -0.01334747f, -0.01002472f, -0.02268781f, -0.00190072f, 0.00653218f, -0.03989018f, 0.00466662f, -0.01249143f, 
    -0.02126306f, -0.03023377f, -0.00551158f, 0.01097036f, -0.00254087f, -0.03293148f, -0.01034716f, 0.03135223f, 
    -0.03693002f, 0.01035307f, -0.02337851f, 0.03605622f, 0.01045856f, -0.01967339f, -0.02172444f, -0.01422931f, 
    0.01286026f, -0.00056138f, -0.02776248f, -0.01978342f, 0.01938111f, -0.00184047f, -0.00791246f, 0.00399375f, 
    -0.00817009f, -0.03569270f, -0.01014215f, -0.04168835f, -0.00909967f, 0.03203778f, 0.01718158f, -0.03026606f, 
    -0.01836902f, -0.03419711f, 0.00991794f, -0.02544787f, 0.00062625f, 0.01071818f, 0.01220712f, 0.02357229f, 
    -0.03377575f, -0.01078905f, -0.03053890f, 0.00893483f, 0.03026644f, -0.01399551f, -0.01724163f, 0.01000053f, 
    -0.02837234f, -0.01453623f, 0.01655763f, 0.01264842f, 0.03018532f, -0.03161018f, -0.01862460f, -0.00238505f, 
    -0.03750555f, 0.01188898f, -0.00000830f, -0.00271969f, -0.00633132f, -0.02648022f, -0.03329680f, -0.02210918f, 
    0.02749577f, -0.03848363f, -0.01830416f, -0.01612620f, -0.04216025f, -0.00521864f, -0.01696339f, 0.03326425f, 
    -0.02569584f, -0.03972141f, -0.02717675f, 0.00557368f, -0.01035159f, 0.00751217f, -0.02852027f, 0.00364876f, 
    -0.01648224f, 0.02547434f, -0.02331281f, -0.02636159f, -0.02987109f, -0.02440246f, 0.00810374f, -0.03206823f, 
    -0.01181567f, 0.01339937f, 0.00597114f, 0.02160164f, 0.03129760f, 0.00951639f, -0.00620810f, -0.04038597f, 
    0.00769347f, 0.02175111f, 0.01110112f, 0.00093689f, -0.00659054f, -0.01774799f, -0.02248692f, -0.04664982f, 
    0.00505606f, -0.03390032f, 0.00054857f, -0.03304755f, 0.02125494f, -0.03968709f, 0.01604115f, 0.02432700f, 
    -0.01515265f, 0.00760463f, -0.01340337f, -0.03539997f, -0.02497501f, 0.02549080f, 0.02716000f, 0.01198231f, 
    0.01047576f, 0.01528159f, 0.02655260f, -0.04083940f, -0.03455334f, -0.00157023f, -0.02904229f, -0.01861878f, 
    0.02095542f, 0.02650673f, -0.03569069f, 0.01562835f, 0.00902765f, 0.02389221f, -0.04365473f, 0.02680285f, 
    0.01661765f, -0.02924486f, 0.00164163f, 0.01893134f, 0.00990199f, -0.01504370f, 0.01961154f, 0.02370579f, 
    -0.01713013f, -0.02023201f, -0.03626803f, -0.02737015f, -0.01993974f, 0.02369186f, -0.02149648f, -0.01073052f, 
    0.01676456f, -0.01378402f, -0.01658638f, -0.03599441f, -0.01890801f, -0.04123887f, -0.00615316f, -0.00099900f, 
    0.00906768f, -0.01433442f, -0.02169470f, -0.00372497f, -0.00023190f, 0.01789231f, -0.00972377f, -0.02336725f, 
    -0.01462231f, 0.03044232f, -0.03227716f, -0.02709518f, -0.02504393f, -0.01670312f, -0.03551408f, -0.00319045f, 
    -0.02701198f, 0.01882011f, 0.03028090f, 0.01611341f, -0.00658322f, -0.03912560f, -0.02335047f, 0.01359862f, 
    -0.03496387f, -0.02685929f, -0.00108240f, 0.02661170f, -0.01599612f, 0.01518808f, -0.03038358f, 0.00962578f, 
    0.01293506f, 0.00004905f, -0.00080799f, -0.02081618f, -0.00242165f, -0.00830862f, 0.00150528f, 0.02785856f, 
    -0.02158983f, 0.00277292f, -0.02456545f, -0.01594156f, -0.02860349f, -0.00656487f, 0.01598108f, 0.00009103f, 
    0.02115189f, 0.00977323f, 0.01873598f, 0.00402900f, -0.00703399f, 0.00897532f, -0.01087030f, -0.02751801f, 
    0.02147707f, 0.00897660f, 0.00185513f, 0.01409422f, 0.01310637f, 0.01087133f, 0.01846876f, 0.01365392f, 
    -0.00389134f, 0.00160590f, -0.00258038f, -0.00261494f, -0.02785635f, -0.01809793f, 0.01964740f, 0.02130796f, 
    0.02283688f, 0.02717925f, -0.02148217f, -0.01705255f, -0.01886349f, -0.01836064f, -0.01318276f, 0.02389839f, 
    0.02340311f, 0.03014076f, -0.02024437f, -0.00978635f, -0.02916309f, 0.01102551f, -0.02632284f, -0.01408297f, 
    -0.02907236f, 0.00835279f, 0.01063872f, 0.01017295f, 0.02412491f, -0.02619347f, 0.00360469f, 0.02750037f, 
    -0.02040465f, -0.02831949f, -0.03904786f, -0.02079180f, -0.03545715f, 0.01048609f, 0.02439910f, -0.00581688f, 
    0.01586338f, 0.02201393f, 0.00769328f, -0.02945210f, 0.01978372f, -0.02143221f, -0.03207968f, 0.00735906f, 
    0.01485765f, 0.02174756f, -0.02315031f, -0.03863239f, 0.02850914f, 0.01066804f, 0.00598296f, 0.00831692f, 
    0.02284950f, 0.02718576f, 0.00422511f, -0.04171680f, -0.00959576f, -0.03887577f, 0.01483969f, -0.02258135f, 
    0.01660616f, 0.01858146f, -0.00369876f, 0.00482073f, 0.01836661f, -0.03602466f, -0.01890166f, -0.03413837f, 
    0.00044409f, -0.01300802f, 0.01148048f, -0.03247852f, 0.00915678f, 0.01006159f, 0.02665533f, -0.00918858f, 
    0.00715892f, -0.02839403f, 0.00525935f, 0.03373749f, 0.03500371f, -0.02195459f, -0.00170755f, 0.00075104f, 
    0.00281810f, 0.01640923f, -0.00921497f, -0.03058275f, 0.01250779f, 0.03243972f, 0.01161946f, -0.03716417f, 
    0.02336681f, 0.00427966f, 0.00094146f, 0.01224260f, -0.00247132f, -0.00019704f, 0.02557910f, 0.02014317f, 
    0.00097416f, -0.01221907f, -0.01530055f, -0.00107176f, -0.01505456f, -0.02865030f, -0.00976213f, -0.01958267f, 
    -0.02342250f, 0.01630591f, -0.00077548f, -0.02105606f, -0.01044992f, 0.00728683f, -0.01799898f, -0.02384023f, 
    -0.03113659f, 0.03454039f, 0.01711763f, 0.01849364f, 0.00096590f, -0.02389447f, 0.01810997f, -0.01813162f, 
    -0.02249807f, -0.00029976f, 0.00151345f, -0.02461175f, 0.00196473f, -0.02685397f, 0.01174231f, -0.03015699f, 
    -0.02830578f, 0.01915855f, -0.01028441f, -0.01190317f, -0.01061100f, -0.03655757f, 0.00220003f, -0.00689133f, 
    -0.03136285f, 0.01981038f, -0.01862049f, -0.03207118f, -0.02349918f, -0.03269322f, 0.02100655f, -0.02865461f, 
    0.00156885f, -0.03853051f, -0.03065360f, -0.01279110f, -0.02213919f, -0.01439268f, 0.01328344f, -0.00557370f, 
    -0.04293451f, 0.02556749f, 0.01547488f, 0.02430289f, -0.03458093f, 0.00699685f, 0.00348365f, 0.00963516f, 
    0.01707564f, 0.02678379f, -0.02544579f, -0.01821977f, -0.01384952f, -0.00656080f, -0.01271250f, -0.02624901f, 
    0.02010076f, 0.02327636f, 0.02549068f, 0.02785815f, 0.02532624f, 0.00787293f, 0.03030007f, -0.00463856f, 
    0.02650766f, 0.01605849f, -0.02311608f, 0.00453118f, -0.02711816f, -0.01497804f, 0.00967724f, 0.02606719f, 
    -0.04019362f, -0.00230633f, 0.01475073f, 0.02997525f, 0.02297330f, -0.01126951f, -0.00435618f, -0.00918332f, 
    -0.03311734f, -0.00051703f, -0.02367397f, 0.02396015f, 0.01022261f, 0.03151921f, -0.01294601f, -0.02604042f, 
    -0.03320158f, -0.01621543f, -0.02750453f, 0.03063415f, -0.02412065f, -0.01786217f, 0.01862569f, 0.00429495f, 
    -0.00957160f, -0.02835498f, 0.01190983f, -0.00806936f, -0.00087869f, -0.02713993f, 0.02930555f, -0.03850029f, 
    -0.01902748f, 0.01272767f, 0.01527460f, -0.00442574f, -0.02389038f, -0.02652950f, -0.01053221f, -0.01343967f, 
    -0.00325632f, 0.02183986f, 0.01808668f, -0.02810940f, -0.01997368f, -0.02792695f, -0.03998695f, -0.02825476f, 
    -0.02377144f, 0.01070778f, -0.00413852f, 0.02060006f, 0.01145322f, -0.03550705f, -0.01901742f, -0.03047282f, 
    0.02394811f, 0.02477871f, 0.00421348f, 0.02877089f, -0.03584535f, 0.02708725f, 0.01662797f, 0.01167667f, 
    -0.01597756f, -0.01356063f, -0.01736361f, -0.03846147f, -0.00226874f, -0.02670351f, -0.01742081f, 0.02710989f, 
    -0.17115158f, 0.06290507f, -0.13800810f, -0.03543748f, 0.11467794f, 0.03813950f, 0.06851722f, -0.04499397f, 
    -0.15221819f, 0.02561061f, -0.12440690f, -0.20414960f, 0.15121378f, 0.27541310f, -0.24887791f, 0.02010854f, 
    -0.01378738f, 0.14070058f, -0.04689660f, 0.00337994f, 0.05565086f, -0.03578037f, -0.01315050f, -0.05545262f, 
    0.04535071f, 0.17961404f, -0.19207492f, 0.07484683f, -0.14960615f, 0.00735685f, -0.05651486f, -0.01997499f, 
    -0.06868012f, 0.11781811f, -0.04992007f, -0.00266952f, -0.06115554f, 0.17110583f, -0.03203847f, 0.00246847f, 
    -0.03625174f, -0.08620083f, 0.17261687f, 0.13854828f, -0.05642226f, -0.18761884f, -0.13184838f, -0.21561319f, 
    -0.28701639f, -0.15676790f, -0.14731964f, 0.03167614f, 0.06767076f, 0.08404759f, -0.02409835f, -0.11832365f, 
    0.02558953f, -0.02059010f, 0.03716100f, 0.05361565f, 0.17984241f, -0.08841918f, -0.25295693f, 0.24538890f, 
    0.07661318f, -0.18870859f, -0.07327361f, 0.13853033f, 0.00102202f, 0.03772460f, 0.06788452f, 0.09524985f, 
    0.00367859f, 0.07092173f, 0.15025713f, 0.17656595f, 0.04265210f, 0.12941913f, 0.07446948f, 0.02924747f, 
    0.04135725f, -0.01100643f, 0.06374185f, 0.13612445f, 0.19691411f, 0.00237769f, 0.00669397f, 0.16943225f, 
    0.05438593f, 0.12816280f, 0.06713148f, 0.03228343f, -0.03566241f, -0.02639476f, -0.00876269f, 0.04753960f, 
    0.48142633f, 0.27097827f, -0.38581303f, 0.10851407f, 0.11778719f, -0.17677194f, 0.09162447f, 0.16789968f, 
    -0.13740873f, 0.03422654f, 0.00706739f, -0.00329677f, -0.00921358f, -0.09881649f, -0.08044311f, -0.16276844f, 
    -0.00827000f, -0.08278296f, -0.10628735f, -0.08058696f, -0.01565047f, -0.02729680f, 0.17648634f, -0.00238061f, 
    -0.03418855f, 0.00334503f, 0.02428758f, 0.09081213f, 0.13430586f, 0.10480177f, 0.00019225f, 0.00069887f, 
    0.06277027f, -0.03472782f, -0.11140542f, 0.07991476f, -0.37540510f, -0.00690895f, 0.13403001f, -0.06079734f, 
    -0.10598910f, -0.06122981f, -0.15055422f, -0.13713957f, 0.15423156f, 0.05652351f, 0.02866119f, 0.17641100f, 
    -0.19119038f, 0.10221472f, 0.07029869f, 0.09958821f, 0.00149503f, -0.12434901f, -0.02773571f, -0.04563785f, 
    0.03352015f, 0.05573850f, 0.04528113f, 0.03608315f, -0.08556455f, -0.04296404f, 0.04168079f, 0.03236971f, 
    0.03777877f, 0.15023817f, -0.04215981f, -0.13425466f, -0.04952328f, 0.04228902f, 0.07569969f, -0.05394148f, 
    -0.06635311f, -0.01277335f, -0.04051436f, -0.01645837f, 0.18304734f, 0.11653977f, 0.02199862f, 0.00709573f, 
    0.03801301f, -0.11334022f, 0.02791717f, 0.20384735f, 0.06012824f, -0.06504152f, 0.02382595f, 0.00630544f, 
    -0.03669586f, 0.00532633f, -0.01709515f, 0.10153475f, -0.00230319f, 0.01500149f, 0.00480140f, 0.02087298f, 
    -0.07647595f, -0.10152426f, -0.15595491f, -0.03853822f, 0.13033496f, 0.05657115f, -0.04736373f, -0.05358147f, 
    0.08170699f, 0.06050073f, 0.11163280f, -0.05779906f, -0.21864206f, -0.12790771f, -0.08766516f, 0.01359120f, 
    0.14485757f, 0.05242613f, 0.07802197f, 0.02700705f, 0.08668163f, -0.10357060f, 0.01932149f, -0.08876712f, 
    0.04346879f, 0.03727287f, -0.08438586f, -0.05315624f, 0.03796891f, -0.05087879f, 0.01076459f, 0.00542627f, 
    0.19090417f, 0.00640209f, 0.09513416f, 0.10445399f, -0.23595394f, -0.11494587f, -0.10425164f, -0.03247981f, 
    0.09458791f, 0.10615677f, 0.04571411f, 0.00482797f, -0.04331726f, -0.12618862f, -0.09338548f, -0.14391719f, 
    -0.23939781f, -0.00042290f, 0.26191518f, 0.08393668f, 0.11506689f, 0.03448828f, 0.10515985f, 0.11867263f, 
    -0.01614588f, -0.01416135f, -0.00720374f, 0.05768337f, -0.02712836f, 0.09001718f, -0.12365172f, -0.14637350f, 
    -0.01816374f, -0.00886254f, -0.03097095f, -0.05884308f, -0.11683400f, -0.01569236f, 0.05918739f, 0.00399928f, 
    -0.02914479f, 0.12942982f, -0.16873242f, -0.07666306f, -0.02814970f, 0.16778046f, -0.06581519f, 0.13850701f, 
    -0.00754399f, -0.22606221f, 0.12607399f, 0.10315140f, -0.05179749f, 0.08188894f, 0.10117114f, 0.07803538f, 
    0.11441824f, -0.03841909f, -0.06683695f, 0.07969200f, 0.01827882f, 0.15475711f, -0.01754246f, -0.07310762f, 
    -0.15227172f, 0.03563840f, 0.15583543f, -0.16239084f, 0.00315631f, 0.02885097f, 0.09213065f, -0.17691442f, 
    -0.07464211f, -0.06258763f, -0.11293775f, -0.00794097f, 0.10398275f, 0.13839842f, 0.15416050f, -0.07091007f, 
    -0.09432664f, -0.05557861f, -0.00882606f, 0.06042217f, -0.04978755f, 0.07541769f, 0.16241372f, -0.00563913f, 
    -0.16778740f, -0.11088180f, -0.05576907f, 0.15632299f, -0.11687709f, 0.06272434f, 0.00747652f, -0.02611303f, 
    0.03974414f, -0.03652273f, 0.04391132f, -0.01933669f, -0.41709551f, -0.16802049f, 0.23806664f, 0.11499253f, 
    -0.04780579f, 0.01501954f, -0.06144834f, -0.02318432f, 0.15454583f, 0.08841395f, 0.11792907f, 0.13674855f, 
    0.31011310f, -0.04754781f, -0.10952535f, 0.09450430f, 0.15417701f, 0.02900019f, 0.01237291f, -0.01493429f, 
    -0.02291055f, 0.09350637f, 0.09923688f, 0.17803277f, 0.01452959f, 0.01792999f, -0.22770600f, 0.11823145f, 
    0.26862681f, 0.06824519f, 0.10867893f, 0.05971741f, -0.00253293f, 0.11596907f, -0.07476426f, -0.03952482f, 
    -0.14075436f, -0.13144365f, 0.01515368f, -0.12083302f, -0.05322245f, 0.04732932f, -0.07237223f, 0.16456534f, 
    0.11015600f, -0.06968666f, -0.04397384f, 0.01275378f, -0.04109549f, -0.22060885f, -0.03419390f, 0.12011618f, 
    -0.02535504f, 0.03334314f, -0.04463151f, 0.16627498f, 0.12492731f, 0.07666785f, 0.03006069f, -0.01162617f, 
    0.04061539f, -0.01898631f, -0.13754307f, 0.03880969f, -0.04032240f, 0.03771776f, -0.02112452f, -0.08592216f, 
    0.11443296f, 0.13670753f, 0.07764396f, 0.11259919f, 0.24400783f, -0.07546272f, -0.00132319f, 0.11214859f, 
    0.08147077f, 0.03696988f, 0.01634542f, 0.00662646f, 0.12383002f, 0.01089559f, 0.07568145f, 0.07447155f, 
    -0.17410654f, -0.08208441f, 0.12551853f, 0.03069455f, -0.03902977f, 0.01354574f, 0.00129170f, -0.00314892f, 
    -0.06765330f, 0.05843649f, -0.04511981f, 0.06051002f, -0.03037265f, -0.02046270f, 0.10713589f, -0.10139173f, 
    0.16755112f, -0.00024890f, 0.08924235f, 0.08132486f, -0.05110991f, 0.01109962f, -0.03780426f, 0.03467108f, 
    -0.14200288f, 0.06862764f, -0.10839379f, 0.03182811f, 0.02608495f, 0.06699347f, 0.07384717f, 0.03982630f, 
    -0.00585617f, 0.05889103f, 0.04678385f, 0.07084794f, 0.07756212f, 0.05434819f, 0.00492298f, 0.10742927f, 
    0.02303101f, 0.07080787f, 0.07555924f, -0.11203734f, -0.04755419f, 0.03595380f, 0.00496651f, -0.16139247f, 
    -0.03727306f, 0.04293243f, 0.02072621f, 0.00309335f, 0.02241745f, -0.00646173f, -0.08491497f, -0.01097079f, 
    0.07096788f, -0.00274273f, -0.01074201f, 0.00668419f, -0.15455733f, -0.07031377f, 0.07420263f, 0.07245119f, 
    -0.05770944f, 0.06785403f, 0.05634877f, -0.00236475f, 0.16936988f, 0.15727329f, 0.10714431f, -0.01079120f, 
    -0.12108416f, -0.02100026f, -0.11920607f, -0.01545306f, 0.04544096f, 0.06023660f, -0.02117465f, 0.02227976f, 
    -0.09856755f, 0.01263965f, -0.01229228f, -0.16849202f, -0.17331323f, 0.00193514f, -0.04177044f, -0.14219247f, 
    0.01574381f, -0.03495932f, 0.09661943f, 0.08779319f, 0.06739378f, 0.12146931f, 0.02115285f, -0.05993722f, 
    -0.02956882f, -0.15792622f, -0.00866857f, -0.13419133f, 0.02792905f, 0.11887176f, 0.02359246f, -0.13829391f, 
    -0.10077383f, 0.03749277f, 0.11955787f, 0.04059781f, -0.13181898f, -0.19618385f, -0.20278497f, 0.00712567f, 
    -0.10720738f, -0.01728876f, -0.03965367f, 0.02991453f, 0.15096870f, 0.12268500f, 0.08817058f, -0.01301658f, 
    0.08717827f, 0.00370408f, -0.11840104f, -0.19995597f, -0.07487661f, -0.08254971f, 0.02842666f, 0.03469117f, 
    0.08178209f, -0.00774177f, -0.02467938f, 0.13215879f, 0.31016609f, 0.11282158f, -0.22214724f, 0.07649050f, 
    -0.00076344f, -0.08506061f, 0.10273987f, 0.15967968f, 0.05908245f, 0.01928728f, -0.03722913f, 0.09405530f, 
    -0.28467572f, -0.17085651f, 0.14198932f, 0.07644127f, 0.07365327f, -0.03645134f, 0.02390169f, 0.15579677f, 
    0.01787319f, -0.01117441f, -0.04661204f, 0.06373473f, -0.00708459f, -0.13027364f, -0.04464216f, -0.10044979f, 
    0.10383216f, 0.10934743f, -0.04799706f, -0.09969409f, -0.05403367f, -0.14402941f, -0.07388303f, 0.03821631f, 
    -0.10707014f, 0.05255554f, 0.02361740f, -0.10677478f, -0.12434044f, -0.01730645f, -0.18309441f, -0.03553721f, 
    -0.12323812f, -0.03575474f, 0.00083836f, 0.10469237f, -0.12658849f, -0.14400730f, 0.06545573f, -0.13676228f, 
    -0.06032246f, 0.00190064f, -0.04833320f, 0.19419971f, -0.17589051f, -0.06079089f, -0.04081004f, -0.26384240f, 
    0.14320390f, -0.15533350f, -0.06285876f, -0.06513873f, -0.01742431f, -0.08220370f, -0.02893444f, 0.11493605f, 
    0.14401864f, 0.11022656f, 0.11159166f, 0.09880698f, -0.36285609f, -0.06417143f, -0.10519794f, -0.14605266f, 
    -0.01940897f, 0.00268908f, 0.00736655f, -0.13375875f, 0.05315472f, -0.19290942f, 0.05383087f, -0.10407040f, 
    -0.08750179f, -0.11107403f, -0.00193448f, -0.06405201f, 0.02364072f, -0.02340903f, -0.01642915f, -0.09714498f, 
    0.00214029f, -0.06408618f, 0.07994950f, 0.00612946f, -0.11924750f, -0.16106069f, 0.09879030f, -0.01076173f, 
    0.10814435f, 0.07225234f, 0.09493307f, -0.11349684f, -0.00209207f, -0.01024514f, -0.08897326f, 0.10186105f, 
    -0.20432185f, -0.01662325f, -0.05581756f, -0.10267036f, 0.19995178f, 0.16302951f, 0.09541231f, -0.05165691f, 
    -0.12293247f, -0.06416237f, -0.04170572f, 0.02771400f, -0.18711121f, -0.17952782f, -0.04625741f, -0.01661237f, 
    -0.02413746f, -0.03791172f, -0.07339411f, -0.03965620f, 0.20792393f, 0.01761535f, 0.22735709f, 0.16642570f, 
    0.05584893f, -0.11248973f, -0.14369710f, -0.05685934f, 0.01311336f, 0.00937113f, 0.05265095f, 0.09096593f, 
    0.18110426f, -0.08588963f, 0.03923925f, -0.10876139f, -0.11736265f, -0.07107075f, -0.02076939f, 0.09767609f, 
    -0.00985202f, 0.03661110f, -0.07841200f, 0.14230105f, -0.15443273f, 0.01792821f, 0.09740731f, -0.03199558f, 
    -0.04412875f, -0.10464164f, -0.02054506f, 0.04979678f, 0.07499196f, 0.05785618f, 0.05280620f, 0.16591126f, 
    -0.06024274f, -0.08773591f, 0.01425717f, 0.09399931f, -0.04133327f, 0.25856915f, -0.15614158f, 0.07322045f, 
    -0.12906498f, 0.04824076f, -0.01837953f, 0.16774979f, 0.04981387f, -0.13314602f, -0.05186604f, -0.19691733f, 
    0.06041252f, 0.01424907f, 0.01661800f, -0.17095348f, 0.01044283f, -0.06241452f, 0.08558911f, -0.00796237f, 
    0.05188687f, 0.05235625f, 0.14572372f, 0.14098486f, 0.03555456f, -0.07462976f, -0.11489824f, -0.01035141f, 
    -0.09256773f, -0.07705285f, 0.00290298f, 0.03452172f, 0.12933658f, 0.13238381f, 0.10480757f, 0.08094119f, 
    -0.08214139f, -0.02014980f, 0.06424448f, -0.04962970f, 0.07779167f, 0.05654304f, -0.04876514f, 0.04538761f, 
    0.04396040f, 0.12359549f, 0.04001966f, 0.03902067f, 0.25825480f, 0.12417781f, -0.14010184f, 0.10606499f, 
    -0.05702468f, -0.02952901f, -0.09061072f, -0.00837290f, 0.04627539f, 0.18505183f, 0.09302761f, -0.00740544f, 
    -0.03919864f, -0.02471266f, -0.03415170f, -0.01023487f, 0.01657431f, -0.00344371f, 0.01803522f, 0.02279876f, 
    -0.00022863f, -0.00467248f, -0.00445488f, 0.02213051f, 0.01639979f, -0.02024574f, 0.00740881f, -0.00917633f, 
    -0.02882165f, -0.03500236f, -0.01065670f, -0.02367952f, 0.02607250f, 0.03097500f, -0.02766861f, -0.00291941f, 
    -0.01689848f, 0.00389750f, -0.02539200f, -0.03879755f, 0.01618570f, 0.02473095f, -0.03612112f, 0.00226414f, 
    0.02484152f, -0.00933426f, -0.02123711f, -0.02100056f, -0.03383977f, -0.00604646f, -0.03360428f, -0.03319468f, 
    0.01923781f, 0.00057096f, -0.02139457f, 0.03964515f, 0.02456586f, 0.02311595f, -0.01458084f, -0.02855307f, 
    0.02780061f, 0.00520281f, 0.00832727f, -0.00108768f, 0.00819256f, -0.00630322f, 0.01734729f, -0.03913919f, 
    -0.02161192f, -0.04074073f, -0.01398560f, 0.00967888f, 0.02594347f, 0.01456525f, 0.00703222f, 0.03510827f, 
    0.01657218f, -0.02933938f, -0.04053004f, 0.02129672f, -0.01924505f, 0.00755200f, 0.02573283f, 0.01513182f, 
    -0.03814461f, 0.02880080f, -0.01251365f, -0.01220803f, -0.01034221f, -0.01643758f, 0.00947279f, 0.02791480f, 
    -0.00039262f, 0.00240930f, -0.02305924f, 0.00057635f, -0.01481442f, 0.03048486f, 0.00208838f, -0.02021899f, 
    -0.03022812f, -0.00880642f, 0.00399678f, -0.01769658f, -0.01940876f, -0.03126816f, -0.02008168f, 0.02585731f, 
    -0.02094519f, -0.03616003f, -0.01353292f, 0.02780215f, -0.03580367f, 0.00501237f, -0.03932901f, -0.02625527f, 
    -0.03017574f, 0.01176705f, -0.04101213f, -0.00903639f, 0.02291549f, -0.00734098f, 0.01760890f, -0.01420963f, 
    -0.03206766f, -0.03989950f, -0.02401258f, -0.03293498f, -0.02277734f, -0.00699517f, -0.03342140f, -0.00650003f, 
    -0.03214698f, -0.03883660f, -0.02275559f, 0.02336412f, -0.02795915f, 0.00696231f, 0.01858155f, 0.03869505f, 
    -0.03832595f, 0.02153346f, -0.00369394f, 0.02408766f, -0.00772515f, -0.02538423f, 0.00733898f, 0.02852693f, 
    0.02978024f, 0.00720397f, -0.01767277f, 0.01605875f, 0.01002407f, 0.03125536f, 0.01996532f, -0.01729661f, 
    0.03404920f, -0.02207548f, -0.00550359f, 0.03144744f, -0.03394509f, -0.03592550f, -0.03670714f, -0.03463398f, 
    -0.01152050f, 0.02371197f, -0.03074494f, -0.01313466f, 0.00681924f, 0.02124532f, 0.00222005f, 0.00772000f, 
    -0.02408302f, 0.03530556f, 0.03546771f, 0.00600076f, -0.03365346f, 0.02217459f, -0.02652667f, -0.02935660f, 
    -0.00493136f, 0.02677661f, -0.01429080f, -0.02233643f, -0.03510290f, 0.00535049f, 0.00540877f, 0.00954890f, 
    -0.00578809f, -0.02958319f, 0.01836226f, 0.01004470f, -0.01131616f, -0.02617551f, -0.00164558f, -0.02220677f, 
    -0.00704550f, -0.03349848f, -0.02884283f, 0.00470771f, -0.01187688f, -0.01606434f, -0.00231544f, 0.01735111f, 
    -0.02291336f, 0.00715466f, -0.01062783f, 0.02409132f, 0.01847469f, -0.02132809f, -0.01185148f, -0.00480027f, 
    -0.03587755f, 0.01335007f, 0.02504627f, 0.02112426f, 0.00024395f, 0.02501581f, -0.01026138f, 0.00835572f, 
    0.02399535f, 0.02735570f, 0.02009546f, 0.00652155f, -0.03989821f, 0.01508683f, 0.00030089f, -0.02772959f, 
    0.01572829f, 0.00915123f, -0.01723651f, -0.03320961f, -0.00720341f, -0.04012989f, -0.03059671f, 0.02276290f, 
    0.01034266f, 0.02027405f, -0.03472793f, -0.02750858f, -0.01649129f, 0.01961421f, -0.02033012f, 0.02930960f, 
    0.01019691f, 0.02414709f, -0.00157155f, 0.00713109f, 0.02355234f, -0.01827904f, 0.01089747f, 0.02276621f, 
    -0.00942046f, 0.01677006f, -0.03441707f, -0.01212026f, -0.03009982f, -0.01563195f, -0.03000958f, -0.03039376f, 
    -0.02758667f, 0.00287665f, -0.01281116f, -0.01105126f, -0.01830475f, -0.00105375f, -0.03272058f, 0.00074357f, 
    -0.00771359f, 0.01738015f, 0.00491838f, -0.03844503f, -0.03646931f, 0.01377639f, -0.03256156f, 0.00796236f, 
    -0.00804653f, 0.02195596f, 0.00172193f, -0.02389200f, -0.03294578f, -0.00043013f, -0.00806586f, -0.02144635f, 
    -0.00767451f, -0.00668583f, 0.01038326f, 0.01695376f, 0.00881491f, 0.00316237f, -0.00818590f, 0.01511467f, 
    -0.02562460f, 0.01715212f, 0.01084462f, -0.00848541f, -0.02776714f, 0.01542539f, -0.03780479f, -0.00646581f, 
    -0.00864463f, -0.00369732f, 0.00064284f, 0.02203222f, 0.00861593f, 0.02295105f, -0.01090712f, 0.03564084f, 
    -0.00961270f, 0.00938421f, 0.02280693f, -0.01841356f, -0.01120520f, 0.00527599f, 0.00870323f, 0.00139640f, 
    -0.00710790f, 0.02069435f, 0.00486403f, 0.01133753f, 0.00428102f, 0.02843482f, 0.02567009f, 0.02226861f, 
    0.00651320f, 0.00101455f, 0.00830898f, 0.00559665f, 0.02503657f, 0.01210724f, -0.00755213f, -0.03377973f, 
    -0.02235221f, -0.01995733f, -0.04216636f, -0.01115458f, -0.01723246f, -0.00139185f, 0.01889920f, -0.03115053f, 
    -0.04391199f, -0.03360808f, 0.02765146f, 0.01170477f, 0.00173065f, -0.01118733f, -0.02651729f, -0.02218352f, 
    -0.00537599f, 0.01622199f, 0.00957377f, -0.03510415f, -0.02497303f, 0.01483364f, 0.00057450f, 0.02606740f, 
    -0.02569528f, -0.04132594f, 0.01463151f, -0.01413109f, 0.01400464f, -0.02982932f, 0.01008443f, -0.01121791f, 
    0.00430920f, -0.01144134f, 0.01610040f, -0.01235059f, -0.03913488f, 0.01709935f, 0.02907308f, 0.02474893f, 
    0.01127209f, 0.00971518f, 0.03237678f, -0.02243420f, 0.02392339f, 0.02277710f, -0.01712931f, -0.00439190f, 
    -0.01843788f, 0.00580921f, 0.00074679f, -0.03151304f, -0.00696455f, -0.01136406f, -0.01241759f, -0.00995241f, 
    -0.00091235f, 0.02515651f, 0.02751724f, -0.01103048f, -0.01470597f, -0.02646544f, -0.00424485f, -0.01260585f, 
    -0.01743083f, -0.00462014f, -0.03282234f, -0.01296615f, -0.01712831f, 0.02385713f, 0.01567297f, 0.00996153f, 
    -0.02785001f, 0.01847238f, -0.01435832f, 0.01166554f, 0.01384767f, -0.02039378f, -0.00747693f, 0.01529954f, 
    -0.00584959f, 0.00833992f, 0.00920064f, 0.00076695f, -0.03507525f, -0.00708638f, 0.02055324f, 0.00690651f, 
    -0.03546878f, 0.00709904f, -0.00018064f, -0.01052913f, 0.00076357f, 0.01441151f, 0.02587360f, -0.01285340f, 
    0.02105154f, -0.01290714f, 0.00068112f, 0.00873053f, -0.01990032f, -0.04310940f, 0.02036100f, -0.00558892f, 
    -0.02475660f, -0.00205432f, -0.00755138f, 0.00897369f, 0.01087676f, -0.01531469f, 0.00352306f, 0.01178240f, 
    -0.02199437f, -0.02371588f, 0.00740025f, -0.03570311f, -0.02754791f, -0.01132427f, -0.04222149f, -0.01150413f, 
    -0.01613429f, 0.01066480f, 0.00443634f, -0.00685241f, 0.01807777f, -0.02971332f, 0.00968649f, 0.01002007f, 
    0.00241819f, -0.00968102f, -0.00530401f, -0.02811665f, 0.00957656f, -0.00560123f, 0.02619026f, 0.03025800f, 
    0.00719619f, -0.02890570f, 0.03423594f, -0.02927030f, -0.04243512f, -0.03320400f, 0.02309907f, -0.00123723f, 
    -0.02873506f, -0.00326736f, -0.01222823f, -0.01443376f, -0.00910156f, -0.02240088f, 0.02077173f, 0.00727584f, 
    0.02539761f, 0.01349604f, -0.02832591f, -0.01703267f, -0.00169741f, -0.04348128f, 0.00754165f, 0.02280298f, 
    0.02859599f, -0.00343673f, -0.03869192f, -0.01561905f, 0.01774537f, 0.00323104f, -0.00160399f, -0.01939785f, 
    0.00743519f, -0.03747499f, -0.00145553f, -0.02174290f, -0.03284779f, 0.01401892f, 0.00804075f, -0.03341013f, 
    -0.01976571f, 0.01632027f, 0.00525361f, -0.00520159f, 0.00173702f, 0.03361184f, -0.01475025f, -0.03775086f, 
    0.00853055f, -0.00441142f, 0.00728410f, -0.01273279f, 0.02948133f, -0.01585859f, 0.01959087f, -0.02679680f, 
    0.02893868f, 0.00933144f, -0.02191922f, -0.00530755f, 0.00460004f, 0.00966753f, -0.02061607f, -0.02835149f, 
    0.00960219f, -0.04202847f, 0.01218210f, -0.02905435f, -0.03419856f, -0.02063087f, -0.03470008f, 0.01300209f, 
    0.02155077f, -0.02480095f, -0.01564168f, 0.02648479f, -0.00024063f, -0.00435728f, -0.03471134f, -0.03726043f, 
    0.03234711f, -0.03611482f, -0.02008211f, -0.00261551f, 0.02379500f, -0.03626730f, -0.01649444f, -0.00438061f, 
    0.00824278f, -0.00126525f, 0.01769499f, -0.02352575f, 0.02637364f, 0.00352461f, -0.01793486f, -0.01406626f, 
    -0.01527885f, 0.02127741f, -0.00214847f, -0.01595898f, -0.03532494f, 0.00553996f, -0.03699827f, 0.00480404f, 
    0.01464438f, -0.03900813f, -0.03148043f, 0.00427803f, 0.02797255f, 0.01968277f, -0.01743237f, 0.02890017f, 
    0.02696581f, 0.03616403f, 0.01860235f, 0.03068413f, -0.00494757f, 0.02307197f, -0.01185137f, 0.00536004f, 
    -0.03461612f, 0.00704042f, -0.00841216f, 0.02613106f, -0.02479781f, -0.00998235f, -0.00151493f, -0.02765829f, 
    0.01880881f, -0.01028187f, -0.01247203f, 0.00314030f, -0.02740313f, 0.00197734f, -0.01338921f, -0.03618998f, 
    -0.00562456f, -0.01432354f, 0.00651630f, -0.00633227f, 0.00982042f, 0.01430105f, 0.02503463f, -0.02915325f, 
    -0.02645835f, -0.01374636f, -0.02094615f, 0.02084402f, -0.00012034f, -0.02283208f, 0.01589085f, 0.01766123f, 
    0.00749074f, -0.01518382f, -0.03699785f, -0.01603291f, 0.01351991f, 0.01336819f, -0.01131174f, -0.02704671f, 
    0.00355649f, -0.01791246f, 0.00497088f, -0.03420282f, 0.03635832f, 0.00331034f, 0.03077326f, 0.00977721f, 
    -0.00849161f, -0.01441563f, 0.02249582f, 0.02928877f, -0.02316333f, -0.03464640f, 0.00953009f, -0.01633603f, 
    0.01892178f, 0.01420623f, 0.02169419f, -0.01310943f, 0.02841548f, -0.00777002f, -0.00955812f, -0.01200200f, 
    -0.03506906f, -0.00173284f, -0.00045251f, -0.03009007f, -0.04046880f, -0.02351460f, -0.00981801f, 0.01182306f, 
    0.00700129f, -0.01570238f, -0.02016367f, 0.01142071f, -0.00509415f, 0.02916000f, -0.00289146f, 0.03100225f, 
    -0.01687423f, 0.01274818f, 0.01826914f, 0.00660192f, -0.03602985f, 0.02644470f, 0.00754553f, -0.00412039f, 
    0.01085182f, -0.00824642f, -0.01248371f, -0.00190208f, -0.03285737f, -0.02146091f, -0.01482282f, -0.03157882f, 
    -0.00123208f, 0.02590733f, 0.02753263f, -0.03326513f, -0.00396242f, -0.01769975f, 0.00898476f, 0.00937838f, 
    -0.00332894f, -0.00892399f, 0.00042435f, 0.01691014f, -0.02477246f, 0.00941101f, 0.01844330f, 0.03207920f, 
    0.01713433f, -0.03741382f, 0.02131069f, 0.00501564f, 0.01160422f, -0.01543155f, 0.01474111f, 0.02366034f, 
    0.00347776f, 0.00865293f, 0.02796429f, -0.03666634f, 0.00087848f, 0.00207103f, -0.00421614f, 0.01475625f, 
    -0.01152978f, -0.04428842f, -0.03332376f, 0.00310438f, -0.00037209f, -0.00511634f, -0.03262598f, -0.04206029f, 
    0.01211400f, 0.00857296f, 0.04656800f, -0.00001548f, 0.02723063f, -0.02560930f, 0.01984655f, 0.02722856f, 
    -0.02707020f, 0.00946197f, -0.00208583f, 0.02136279f, -0.03910454f, -0.00404114f, -0.00094655f, -0.01569937f, 
    -0.01206787f, 0.02405853f, 0.02647898f, 0.03415294f, -0.03049792f, 0.01120143f, -0.01978101f, 0.00358541f, 
    0.02165550f, -0.00902789f, -0.01470281f, -0.04170289f, 0.00584325f, -0.00376648f, -0.00483903f, 0.00144601f, 
    0.01823841f, -0.03464353f, 0.01902430f, -0.01494349f, 0.00441166f, 0.00454152f, 0.00846627f, 0.02342772f, 
    0.00358882f, 0.02557134f, -0.03288649f, -0.04119516f, 0.04095086f, 0.01277457f, 0.03093693f, -0.02208268f, 
    -0.02034209f, 0.01370153f, -0.00847777f, 0.00706255f, 0.01887259f, 0.01968771f, 0.00402100f, -0.02869638f, 
    0.19464603f, 0.17728628f, -0.02071099f, -0.08338637f, -0.06654114f, 0.07917856f, 0.08237145f, -0.04294858f, 
    -0.01576499f, 0.01949878f, 0.09050258f, -0.08416115f, 0.27380022f, 0.05857720f, -0.09608540f, 0.16072766f, 
    -0.06457559f, -0.06059933f, 0.17360416f, 0.00670936f, 0.21604611f, 0.03970345f, -0.04700296f, -0.08962066f, 
    0.17864940f, 0.08017181f, 0.13495913f, 0.25531361f, -0.04057746f, 0.10540005f, 0.04521571f, -0.04810770f, 
    0.02584839f, -0.02965571f, 0.05400425f, 0.01893065f, -0.13342483f, -0.07079291f, 0.02493640f, -0.05417017f, 
    -0.05179695f, -0.00752629f, 0.10038629f, 0.13315910f, -0.12348352f, -0.13391097f, -0.12577729f, -0.21951440f, 
    0.14959133f, 0.13922307f, -0.13039005f, -0.08362043f, -0.04854142f, -0.24967852f, -0.05286933f, -0.27990085f, 
    0.00049757f, 0.01275660f, -0.00082167f, 0.02488363f, -0.01640100f, 0.12924954f, 0.14308900f, 0.00179524f, 
    0.22571427f, 0.25087079f, 0.06992447f, 0.07305137f, -0.02656920f, 0.16835846f, 0.21939318f, -0.05666063f, 
    -0.09625413f, -0.03752790f, -0.03608853f, 0.02518362f, -0.10020717f, -0.02807240f, 0.13353190f, 0.17967115f, 
    0.06015797f, -0.07811573f, 0.00633966f, -0.16604984f, 0.05834499f, 0.03756003f, -0.03317133f, 0.18370330f, 
    0.02244444f, 0.02089406f, 0.19394775f, -0.00603705f, -0.03437502f, -0.04791899f, -0.10420197f, -0.11077108f, 
    0.18667339f, -0.01403152f, -0.11352038f, -0.05353351f, 0.08458202f, 0.14052941f, 0.13373365f, 0.33280942f, 
    0.05842596f, -0.05194087f, 0.17394961f, 0.02632218f, 0.14984906f, 0.14398830f, 0.05946821f, -0.08526772f, 
    -0.05084639f, 0.07365517f, -0.02721217f, -0.09643058f, 0.07650313f, -0.09970947f, 0.00001802f, -0.03110987f, 
    -0.20927252f, 0.00397121f, 0.10467616f, 0.15499607f, 0.02323347f, 0.05977340f, 0.05775066f, 0.11374329f, 
    -0.16834211f, 0.01880409f, -0.04839787f, -0.01858234f, 0.18949579f, 0.03560440f, 0.08837491f, 0.07413284f, 
    -0.04025837f, 0.05462867f, 0.06571144f, 0.00708820f, 0.17926329f, 0.11368079f, -0.02709449f, 0.18324286f, 
    0.20611720f, 0.22993518f, 0.02818143f, 0.20659935f, -0.05567910f, -0.04708606f, 0.00768963f, -0.03447975f, 
    -0.03393483f, 0.18943688f, 0.05872517f, 0.11156134f, 0.05364789f, -0.01658794f, 0.06073986f, -0.05783215f, 
    0.07038021f, -0.02775654f, -0.00559776f, -0.02826579f, -0.07263042f, -0.09703667f, 0.01518772f, -0.03529784f, 
    -0.25146133f, -0.15102381f, -0.00237674f, 0.04451861f, -0.03278827f, -0.01619911f, -0.04897400f, 0.07436626f, 
    -0.03701499f, -0.04244085f, 0.02444121f, -0.00230336f, 0.22278115f, 0.16668136f, -0.02330765f, 0.06449928f, 
    -0.03032687f, -0.05296595f, 0.03576996f, 0.01792268f, 0.05140409f, 0.06699905f, 0.07968695f, -0.02040635f, 
    -0.04077367f, 0.06780247f, -0.01146282f, -0.07220501f, 0.08728000f, 0.04049474f, 0.07703115f, -0.22448935f, 
    -0.07692309f, -0.18263446f, 0.07280796f, 0.05386725f, 0.02859285f, 0.17579933f, -0.00301328f, -0.05390629f, 
    0.00020386f, 0.07794008f, 0.06408826f, -0.09048128f, 0.01963351f, -0.03635806f, 0.04771714f, 0.03794358f, 
    0.13122888f, 0.10036092f, 0.14339779f, 0.05439850f, 0.11407748f, 0.12131421f, 0.11583976f, 0.00684112f, 
    0.16307536f, 0.17291622f, 0.17553429f, 0.10237733f, 0.17542122f, 0.03554708f, 0.13377616f, -0.05947880f, 
    -0.02385692f, -0.05092435f, 0.01137578f, -0.06062900f, 0.00708795f, 0.05460637f, 0.08681636f, -0.09451105f, 
    0.13881433f, 0.03943270f, -0.04587827f, -0.06184103f, 0.01927143f, -0.02315347f, -0.06113097f, 0.14290945f, 
    -0.07565154f, -0.14642176f, 0.12217963f, -0.00689674f, 0.03832304f, 0.12872601f, 0.20416957f, -0.09573858f, 
    -0.00865641f, 0.02292938f, -0.02420537f, -0.07759673f, -0.11838737f, 0.03708733f, 0.00059206f, 0.14181027f, 
    0.11131686f, -0.11091807f, 0.06423499f, 0.05579608f, 0.17112017f, -0.00889034f, 0.28335086f, 0.13827682f, 
    0.32966504f, 0.00868239f, 0.03617266f, 0.24558182f, -0.03353024f, 0.17343906f, 0.05181144f, 0.03768881f, 
    0.00401282f, -0.07806161f, -0.00297368f, 0.08849631f, -0.16044655f, -0.09905607f, 0.13312936f, -0.09827590f, 
    -0.05431968f, -0.06817680f, 0.18868999f, 0.03191712f, -0.03599444f, -0.08850668f, -0.06922723f, 0.06053984f, 
    -0.18515792f, -0.20498319f, -0.14191003f, -0.05353184f, -0.12492735f, 0.05490333f, -0.06463755f, -0.06798253f, 
    0.07328082f, 0.05721338f, 0.04346922f, 0.20499340f, -0.06888634f, -0.01582262f, -0.04244931f, 0.00528889f, 
    -0.03908261f, -0.07110880f, -0.21846688f, -0.04179631f, 0.05441891f, 0.02325756f, 0.04558569f, 0.02240942f, 
    -0.14290665f, -0.05114338f, -0.11034182f, -0.07704338f, 0.19979453f, -0.04134125f, -0.18426163f, -0.34730867f, 
    -0.12724751f, -0.05592822f, 0.03794513f, 0.09457133f, 0.00114424f, 0.13352522f, 0.07102012f, -0.02789838f, 
    0.03543689f, 0.30872297f, 0.00152929f, 0.04710772f, 0.04628218f, 0.03946259f, 0.05320354f, -0.20006382f, 
    -0.07896773f, 0.07059670f, 0.00495076f, 0.05794898f, 0.13844423f, 0.06077769f, 0.11539450f, -0.09404621f, 
    0.03834603f, 0.07842610f, 0.03323010f, 0.10698488f, 0.01139858f, -0.06992754f, 0.00436489f, -0.17980076f, 
    -0.18478075f, -0.15588304f, 0.03751524f, -0.20493780f, 0.10279457f, 0.16098164f, 0.07850899f, 0.21914451f, 
    0.06887510f, 0.01355842f, -0.00731702f, -0.11354043f, -0.04276181f, -0.04231190f, -0.24399829f, -0.31389943f, 
    -0.04234028f, -0.03462011f, 0.02625027f, -0.00530996f, 0.07346526f, -0.02877551f, 0.17244920f, -0.17155731f, 
    0.13596889f, 0.25216857f, 0.08618318f, -0.04622398f, 0.09851192f, 0.00136846f, -0.00754619f, -0.13476729f, 
    0.06771220f, 0.05073701f, 0.03609592f, 0.07557526f, 0.16283733f, 0.11289769f, 0.10385261f, 0.16633081f, 
    0.13460606f, -0.01239782f, 0.04181851f, -0.16594948f, 0.05854027f, 0.02334551f, 0.08449404f, 0.10067727f, 
    0.13229302f, 0.21902189f, 0.15761307f, 0.04367772f, -0.05367668f, -0.05819738f, 0.01351478f, 0.00230105f, 
    0.16387178f, 0.09744994f, 0.10889757f, 0.01959811f, 0.13478883f, 0.13540709f, 0.01355637f, 0.01843900f, 
    -0.03505456f, -0.00256692f, 0.06997622f, 0.24498795f, -0.04312643f, 0.07799537f, 0.19747548f, -0.01428732f, 
    0.22717538f, 0.12366372f, 0.09247871f, 0.04512686f, -0.06992628f, -0.02850262f, 0.06172988f, 0.07275415f, 
    0.07428813f, 0.11023826f, -0.09225510f, 0.15854794f, 0.08224491f, -0.00625811f, 0.17757545f, 0.07274383f, 
    0.00906337f, 0.13791713f, -0.04881516f, 0.01928296f, -0.15423198f, -0.09474284f, 0.06647102f, -0.00144812f, 
    0.19364862f, -0.00512391f, -0.04521547f, -0.10160027f, -0.05844010f, 0.05569645f, -0.08367936f, 0.10097259f, 
    0.07632577f, -0.07257421f, 0.05952574f, -0.01085968f, 0.10727446f, -0.03956202f, -0.00239140f, -0.09105206f, 
    0.07120024f, -0.01584616f, 0.00795804f, 0.19405520f, -0.07367878f, -0.05134557f, 0.04939908f, 0.02422531f, 
    0.17293049f, 0.06553541f, 0.10463005f, -0.04220617f, -0.05738041f, -0.07886010f, 0.01635955f, 0.01484634f, 
    -0.00179432f, 0.07135713f, 0.08614419f, 0.04690582f, 0.04191607f, 0.00470966f, 0.00722830f, -0.02827711f, 
    -0.00049117f, -0.04644946f, -0.06398480f, 0.03252900f, -0.01308787f, -0.21521519f, -0.07794975f, -0.14509910f, 
    -0.12703939f, -0.02862977f, -0.12353041f, 0.09357345f, -0.11112802f, 0.05932450f, 0.03759659f, 0.08569928f, 
    -0.11404366f, 0.01722022f, -0.00019550f, 0.02314959f, 0.23262796f, -0.09641183f, -0.05487040f, -0.23219252f, 
    -0.09822821f, -0.00326165f, 0.00969933f, -0.14157553f, -0.03733425f, 0.00175612f, 0.16887294f, 0.01682220f, 
    0.00003265f, -0.03209759f, 0.05487911f, -0.10249975f, 0.05101354f, -0.04647613f, 0.19328581f, -0.00176495f, 
    0.04687519f, 0.00451334f, 0.05850231f, 0.06929749f, -0.02851036f, -0.14681852f, -0.02390807f, -0.00343221f, 
    0.23297456f, 0.16408122f, 0.01979177f, 0.17278618f, -0.00998518f, 0.08846318f, 0.11334585f, 0.01722610f, 
    0.09420607f, 0.04741557f, 0.12354380f, 0.03404665f, -0.11091971f, 0.04588925f, 0.03574270f, -0.00584180f, 
    0.02746113f, 0.07601364f, 0.01710462f, 0.02597157f, -0.31451562f, -0.14399274f, 0.02111591f, 0.04820867f, 
    -0.00360319f, -0.05450440f, -0.03892582f, -0.04109092f, -0.16703133f, -0.00632606f, 0.01016420f, 0.06422099f, 
    0.13416740f, 0.08468705f, 0.16045272f, 0.08157896f, -0.13086648f, 0.01067789f, 0.03426617f, -0.10498941f, 
    0.18312339f, 0.11051203f, 0.01637488f, 0.00656360f, -0.32633960f, -0.36139333f, -0.11914673f, -0.01631607f, 
    0.02367517f, -0.01399483f, -0.17574318f, 0.08106257f, -0.01820872f, -0.16489813f, -0.03672742f, -0.15785767f, 
    0.19548702f, -0.06199050f, -0.05115371f, -0.00833107f, 0.01198507f, 0.12065611f, 0.04866369f, 0.00016097f, 
    0.08477549f, 0.00235873f, 0.17233513f, 0.11562702f, 0.08889635f, 0.16136266f, 0.12796271f, -0.06824776f, 
    -0.03846162f, -0.04553138f, -0.04538086f, -0.04520432f, 0.04065562f, 0.12324078f, 0.03050371f, 0.10423160f, 
    -0.07073103f, 0.00015380f, 0.30167142f, -0.02282721f, 0.10614889f, -0.06483395f, 0.08554028f, 0.12080406f, 
    0.06383751f, -0.06312297f, -0.03612665f, -0.05168634f, 0.02296749f, 0.06902979f, -0.01224153f, 0.03063692f, 
    0.01318586f, -0.09379767f, 0.07052799f, 0.10098753f, -0.16192676f, 0.02058391f, -0.05634252f, -0.10441167f, 
    -0.16107070f, -0.01184114f, -0.01244693f, -0.02306152f, -0.07748915f, -0.06261987f, 0.02481868f, 0.03894701f, 
    -0.14146394f, -0.11866395f, -0.07944749f, -0.07927434f, 0.17130439f, 0.10605918f, 0.01452480f, -0.07190013f, 
    -0.00980036f, 0.01250926f, 0.01229094f, 0.01583934f, -0.02221031f, 0.01831701f, 0.04723346f, 0.06033267f, 
    -0.01396562f, 0.03030256f, 0.10203995f, -0.14483781f, -0.00951276f, -0.04744074f, -0.02175163f, 0.03480014f, 
    0.05270446f, 0.00220886f, -0.13402301f, -0.16828899f, 0.21343626f, 0.05509898f, -0.08074063f, -0.07363899f, 
    -0.10033499f, 0.07959846f, 0.10043479f, 0.05450134f, -0.00921165f, 0.05671987f, -0.00855653f, 0.00560727f, 
    -0.07318997f, -0.09189211f, -0.01241844f, 0.06303032f, -0.03016372f, 0.01021568f, 0.19590698f, 0.02181148f, 
    0.07037345f, 0.06731439f, -0.09704663f, -0.09144346f, -0.04950561f, -0.12463555f, -0.11759511f, -0.28428987f, 
    -0.12015262f, 0.19078431f, -0.04163850f, 0.08206975f, 0.12117909f, -0.02011528f, 0.04614081f, -0.13200174f, 
    0.01252533f, 0.01544392f, 0.18176237f, -0.03602669f, 0.02356035f, -0.03863622f, 0.08194768f, -0.04561561f, 
    0.13217795f, 0.03201451f, 0.05485912f, 0.18303409f, 0.11375255f, 0.05999120f, 0.03865857f, -0.08735727f, 
    0.04699316f, 0.04660982f, 0.02146796f, 0.06987024f, 0.14221905f, 0.04221053f, 0.12055396f, -0.01206663f, 
    0.04497628f, -0.02891388f, 0.04412873f, 0.08584999f, 0.00750178f, -0.07296287f, 0.06432058f, -0.01643070f, 
    -0.05178563f, 0.02890021f, 0.08232768f, 0.02422335f, 0.26958323f, -0.09455399f, 0.05824683f, -0.13434941f, 
    0.02214889f, 0.01769982f, 0.01572947f, -0.00764374f, 0.17980969f, 0.09451648f, 0.17932695f, 0.03504418f, 
    0.25716555f, -0.22358263f, -0.00117828f, 0.03581695f, 0.13398804f, 0.07854728f, 0.10183862f, 0.00100945f, 
    -0.04720635f, 0.04554171f, -0.09185717f, -0.22214520f, 0.37526706f, 0.00145714f, -0.16821708f, -0.14337857f, 
    0.13841806f, 0.03636517f, -0.14160006f, 0.12284378f, 0.17122249f, -0.20509709f, -0.04221338f, -0.03783375f, 
    0.09923504f, -0.34975252f, 0.15823866f, 0.03736985f, -0.12371074f, 0.07710653f, -0.08367256f, 0.03238264f, 
    -0.10333360f, 0.00273805f, 0.11398499f, 0.04453327f, -0.21870852f, 0.08944807f, -0.08251155f, -0.18255672f, 
    -0.06911152f, 0.04882506f, 0.11434906f, 0.18049170f, 0.00521686f, -0.16735819f, -0.16063839f, -0.24731594f, 
    -0.12533221f, -0.12902622f, -0.07934520f, 0.10332377f, 0.03691625f, 0.13081314f, -0.01404743f, 0.05210172f, 
    0.01425767f, 0.02152878f, 0.02613289f, 0.06042555f, -0.01136432f, 0.04092952f, -0.06531638f, 0.03504319f, 
    -0.01220841f, -0.15824834f, 0.12939532f, 0.01211472f, -0.05850360f, -0.04159761f, 0.16965678f, -0.01301102f, 
    -0.14974786f, -0.18404731f, -0.11905983f, -0.04192161f, -0.00789092f, -0.01007833f, -0.01745749f, 0.10650080f, 
    0.09278753f, -0.05469279f, 0.06976993f, -0.05737089f, 0.18105097f, -0.16455925f, -0.11055195f, -0.01639731f, 
    0.04419918f, 0.07004466f, -0.05858104f, -0.05939221f, 0.01761853f, 0.02204325f, 0.01534878f, -0.04689749f, 
    0.38051584f, 0.03692836f, -0.40960911f, 0.17228736f, 0.01460234f, -0.20116869f, 0.28057036f, 0.10000105f, 
    -0.05723859f, 0.06162991f, 0.12460748f, 0.06637005f, 0.09153650f, -0.06156218f, 0.22236143f, -0.03615367f, 
    -0.07886019f, -0.08074147f, -0.09620927f, 0.02439714f, -0.07215455f, -0.07746008f, 0.10097056f, -0.13795446f, 
    0.14423275f, 0.23806089f, 0.24215461f, -0.10368697f, 0.10855766f, 0.06572186f, 0.06013289f, -0.04491812f, 
    0.07519028f, 0.06151155f, -0.05784456f, 0.14123037f, 0.07505653f, 0.06314294f, 0.02530427f, 0.06655546f, 
    -0.08453451f, -0.05899708f, -0.06443172f, -0.11473568f, 0.18145192f, -0.11445294f, -0.07376383f, 0.16816811f, 
    0.01058208f, 0.13036789f, 0.09551285f, 0.28048036f, 0.00565915f, -0.16190460f, 0.08339886f, -0.00386694f, 
    0.06753439f, -0.02870544f, -0.18154018f, 0.11859617f, 0.16415946f, -0.05122487f, 0.02210291f, 0.03716172f, 
    0.03034177f, 0.09659307f, -0.04230678f, -0.07330444f, -0.06963191f, 0.01213190f, 0.11015085f, -0.05392131f, 
    -0.00831342f, 0.07553174f, 0.06933187f, 0.10952953f, 0.13813965f, 0.20877744f, 0.07596921f, 0.02131842f, 
    0.02106864f, -0.01028546f, 0.08678248f, 0.10009587f, 0.08877787f, -0.13751815f, -0.04909380f, 0.21681443f, 
    -0.01051420f, 0.02210735f, -0.01078633f, 0.09720221f, 0.06627532f, 0.03019519f, -0.05479190f, 0.07020911f, 
    0.01327472f, -0.07193927f, -0.07182178f, -0.08933773f, 0.20865308f, -0.01327318f, -0.04609454f, -0.05071425f, 
    -0.19426851f, 0.01900675f, 0.25123274f, -0.06522185f, 0.08807407f, -0.12642799f, -0.15972230f, 0.03837818f, 
    0.14312868f, 0.20817526f, 0.09664679f, 0.08028925f, 0.09316947f, 0.01536867f, 0.04555252f, -0.07422069f, 
    0.24164826f, -0.10152927f, -0.08302514f, 0.05305630f, 0.14382999f, -0.03353076f, -0.02793092f, -0.06483616f, 
    0.13696574f, -0.03842560f, 0.00468633f, 0.07253700f, 0.05569151f, -0.04423425f, 0.09234576f, 0.03255995f, 
    0.13371563f, 0.08366004f, 0.01909774f, -0.01353785f, -0.06671286f, -0.08655433f, 0.00466205f, -0.20401371f, 
    -0.10946880f, -0.22317024f, 0.00360495f, 0.00149735f, -0.05121006f, -0.08020381f, 0.14767347f, 0.17396320f, 
    0.00079945f, -0.01972209f, -0.00925217f, -0.01704571f, -0.07915468f, 0.28772232f, -0.03348937f, 0.10700355f, 
    0.07865217f, 0.09242100f, -0.04991642f, -0.09489647f, -0.04377179f, -0.01077449f, -0.07535618f, 0.07009231f, 
    0.14623970f, 0.04147422f, -0.37498072f, 0.08619310f, -0.00576026f, 0.09794053f, -0.04164232f, 0.16219473f, 
    0.05464328f, -0.32169268f, 0.11361320f, 0.13282843f, -0.37293991f, -0.04274792f, -0.09572946f, -0.01553663f, 
    -0.05224530f, -0.18216322f, -0.05553757f, 0.07968822f, -0.02871734f, -0.09547839f, -0.16207920f, 0.10575321f, 
    0.09845841f, 0.07294355f, -0.00958887f, -0.15840438f, -0.05011307f, 0.05568928f, -0.03855077f, -0.10004443f, 
    -0.05797047f, 0.00426025f, 0.11598665f, -0.08344691f, -0.00336207f, 0.03882664f, -0.02387148f, -0.15943605f, 
    -0.05626698f, 0.04759114f, 0.10906956f, 0.11401562f, 0.08647608f, -0.02602344f, -0.05792312f, -0.01886115f, 
    -0.13166760f, -0.14642793f, -0.15442827f, -0.12704405f, -0.14226101f, -0.00173554f, 0.06044437f, 0.06064827f, 
    -0.00193716f, 0.01789081f, 0.05109854f, 0.08877098f, -0.24770719f, -0.01070992f, -0.07307387f, -0.19400354f, 
    -0.04452195f, -0.02822363f, -0.09899347f, -0.09855096f, 0.13516179f, 0.10536329f, 0.08716514f, 0.07024826f, 
    0.20569263f, 0.00556732f, 0.11444145f, 0.25708753f, -0.05314394f, -0.07763443f, 0.24333838f, 0.02559746f, 
    -0.02000811f, -0.08225779f, -0.08485292f, 0.33982626f, 0.12931609f, 0.03686064f, -0.19588508f, 0.03872968f, 
    0.17468657f, 0.13100767f, -0.18023174f, 0.15466212f, 0.08768024f, 0.04069279f, -0.07409749f, 0.13784319f, 
    -0.03130185f, 0.04668332f, -0.13524491f, -0.14216028f, 0.03027973f, 0.02223129f, 0.03479819f, 0.22511950f, 
    0.23195000f, 0.01297396f, -0.02072586f, 0.00822975f, 0.03375459f, -0.07574317f, -0.13812307f, -0.10340194f, 
    -0.08367238f, 0.03996877f, -0.00851679f, 0.01567773f, 0.14018594f, -0.05264355f, 0.09711204f, -0.00020476f, 
    0.02235713f, -0.09821974f, -0.00726240f, 0.06499482f, -0.00659779f, 0.18735333f, 0.00526208f, 0.01729194f, 
    0.12111953f, 0.10664976f, 0.01787803f, 0.07457143f, -0.00361208f, 0.02257877f, -0.05520923f, 0.16247253f, 
    -0.05233128f, 0.11376186f, 0.00724653f, 0.01062682f, 0.01650815f, -0.13983317f, 0.15426894f, 0.07170683f, 
    0.05128656f, 0.06218764f, 0.24921660f, 0.11251563f, 0.02052636f, 0.04340997f, 0.09553442f, -0.09421908f, 
    0.04136886f, -0.04419268f, 0.00162970f, -0.09212814f, 0.15073247f, 0.06980518f, -0.12770875f, 0.10774361f, 
    0.02053831f, 0.00308067f, 0.08423285f, 0.06248903f, 0.01292576f, 0.08132972f, -0.08795298f, -0.04419330f, 
    -0.16309170f, 0.10627132f, -0.08599303f, 0.29775238f, 0.07110070f, -0.04939931f, 0.08167554f, 0.06269993f, 
    0.07542128f, 0.05283963f, -0.07649730f, 0.06420189f, 0.12932618f, 0.04993616f, 0.00911339f, -0.08268753f, 
    0.05109965f, 0.00456864f, 0.01228996f, -0.06012181f, -0.04159322f, 0.03404259f, 0.02965137f, 0.03040499f, 
    0.42461899f, -0.28649315f, 0.24524847f, -0.00260915f, -0.16671151f, -0.03080059f, 0.02238698f, 0.00885100f, 
    0.03892691f, 0.06879392f, -0.15164484f, -0.01677648f, -0.10323552f, -0.07004607f, 0.06051148f, -0.08539514f, 
    -0.14193495f, -0.02136063f, 0.01836672f, -0.05842572f, 0.11942887f, 0.11524259f, 0.03973899f, -0.12306810f, 
    0.04406282f, -0.02070373f, 0.07064106f, 0.12564898f, 0.13129401f, -0.00809211f, -0.00671431f, 0.03242114f, 
    -0.17134123f, -0.05338837f, 0.09398627f, -0.16881190f, 0.00025962f, 0.04822351f, -0.05056527f, 0.00667498f, 
    -0.12452621f, -0.01052088f, -0.04607170f, 0.04127771f, 0.02196163f, 0.01161995f, -0.09159153f, -0.10015137f, 
    0.07244715f, -0.02649430f, 0.11277213f, -0.05722579f, 0.04194927f, 0.13400680f, 0.06229354f, 0.00204387f, 
    0.05379316f, 0.07562053f, 0.16107798f, 0.10228130f, -0.08963709f, -0.05915277f, -0.04733568f, -0.08139958f, 
    -0.11039684f, -0.09767828f, -0.14450362f, 0.05507348f, 0.16187677f, -0.01163419f, 0.05248483f, 0.03849911f, 
    0.09034386f, 0.04337181f, -0.09560267f, -0.20276755f, -0.02439822f, -0.01947667f, 0.03664869f, 0.00317618f, 
    0.01211135f, -0.05396246f, -0.04632725f, 0.27331439f, 0.06590052f, -0.05344194f, -0.13487047f, 0.14292102f, 
    -0.00449092f, -0.09119865f, 0.13655859f, 0.14543810f, -0.05900366f, 0.06043927f, 0.01176323f, 0.08704207f, 
    -0.10508788f, -0.02173282f, 0.23695803f, -0.03957736f, 0.06098874f, -0.12952466f, 0.01007212f, 0.09722979f, 
    -0.00638591f, -0.01319070f, 0.04807832f, 0.04976447f, 0.14893182f, 0.22277100f, 0.14529707f, -0.02098343f, 
    0.04856629f, 0.06283374f, 0.00545817f, -0.04274734f, -0.01001547f, 0.00531345f, 0.03502838f, 0.04231750f, 
    -0.03585769f, -0.17146094f, 0.33796453f, -0.03634096f, -0.06249220f, 0.03220691f, -0.06919704f, 0.02667101f, 
    -0.06132436f, -0.07223640f, -0.17772053f, 0.09502267f, -0.01166446f, 0.14854854f, 0.14341316f, -0.24963389f, 
    -0.01006795f, 0.01780345f, 0.01667566f, 0.01629771f, -0.04834408f, -0.10914841f, 0.12596317f, -0.23411268f, 
    0.08152833f, -0.12664929f, 0.16722728f, -0.08464752f, -0.15741909f, 0.09558976f, -0.07072105f, 0.06095203f, 
    0.03821627f, -0.02574910f, -0.07718506f, 0.08898205f, 0.05071769f, 0.06945600f, 0.13363065f, 0.00982619f, 
    0.03289346f, -0.02934406f, -0.01938970f, -0.06996250f, 0.09050257f, -0.31143439f, -0.04994032f, -0.27637231f, 
    0.06486797f, 0.24656962f, 0.03450329f, -0.05893008f, 0.14229581f, -0.03942842f, 0.07052212f, 0.06636907f, 
    0.04123428f, -0.07562131f, 0.13116221f, 0.01415090f, 0.15815932f, 0.21131174f, 0.01548279f, -0.09322067f, 
    0.05557875f, 0.08006252f, 0.04312415f, -0.05378575f, 0.04977101f, -0.03306158f, -0.07867835f, 0.06294138f, 
    0.12209556f, 0.20780425f, -0.00720129f, -0.04643046f, 0.06279561f, 0.10847083f, 0.01905168f, 0.17032196f, 
    0.01917169f, 0.05014517f, 0.01425652f, 0.09378278f, 0.09811447f, -0.12768300f, 0.12224913f, 0.03210703f, 
    -0.15106533f, -0.09775560f, -0.10039297f, -0.08773894f, 0.21695337f, 0.12067898f, 0.16411313f, 0.12570715f, 
    0.23971783f, 0.06623421f, 0.05260338f, 0.08783165f, 0.06326723f, -0.04103934f, 0.09128316f, 0.13711807f, 
    0.09420087f, -0.13677016f, -0.06534965f, -0.09497880f, -0.04718861f, -0.20837426f, -0.01232800f, 0.30247307f, 
    -0.06827559f, 0.02134457f, 0.12036938f, 0.26621348f, 0.05993485f, -0.09120040f, -0.02751695f, -0.00836734f, 
    -0.12029565f, -0.01695093f, -0.11681081f, -0.04564644f, -0.14200263f, -0.03667247f, 0.01017240f, 0.20922293f, 
    -0.00556265f, -0.02263384f, 0.03249518f, 0.04086073f, -0.07052945f, -0.17069486f, -0.35574871f, -0.14684294f, 
    -0.02484217f, 0.06889054f, -0.21251668f, 0.12871863f, 0.11688872f, -0.17445837f, -0.05015406f, -0.01942779f, 
    0.03127965f, -0.06994897f, -0.10887642f, -0.08062871f, 0.03162515f, 0.00806375f, -0.01463277f, 0.02199797f, 
    0.20785853f, 0.03159830f, 0.01343345f, 0.15985881f, 0.08072963f, -0.07333679f, 0.02981064f, 0.01314538f, 
    -0.09100980f, -0.02643119f, -0.02358436f, -0.03717766f, -0.08789940f, -0.00425541f, 0.01692329f, 0.04474613f, 
    -0.09212743f, 0.00237916f, 0.05635012f, 0.02054180f, -0.08390169f, 0.06242296f, -0.03589524f, -0.01019148f, 
    0.08141745f, 0.12058780f, 0.06478699f, -0.00050107f, -0.13084219f, 0.05171689f, 0.12930804f, 0.16909449f, 
    -0.06164126f, -0.03309066f, -0.01453270f, 0.08376731f, 0.18437685f, -0.02706361f, 0.11572459f, 0.02074908f, 
    0.04988901f, 0.11001445f, 0.10854211f, 0.08756146f, 0.02122391f, 0.03592276f, 0.15638669f, 0.02190479f, 
    0.18825981f, 0.00674113f, 0.14552790f, 0.11833176f, -0.22657588f, -0.00176859f, 0.33879721f, -0.02087432f, 
    -0.08253618f, 0.06465201f, 0.10105070f, 0.08599382f, -0.01806232f, 0.12111408f, 0.16878343f, 0.03730024f, 
    -0.25877339f, 0.02277375f, 0.16740029f, -0.06686898f, 0.21948831f, 0.18372764f, 0.06970153f, 0.05454569f, 
    -0.04070581f, -0.02556076f, -0.05666422f, 0.02564928f, -0.00493586f, 0.07466818f, 0.04139953f, -0.07295700f, 
    -0.10004477f, -0.06719939f, 0.05605749f, -0.01411063f, 0.21085997f, 0.17226943f, 0.19827192f, 0.20172936f, 
    0.31535071f, 0.05303891f, 0.04227297f, -0.00446583f, 0.06520457f, 0.11771045f, 0.10321487f, 0.21635745f, 
    0.00583896f, -0.07548357f, -0.05364832f, -0.11677746f, 0.21714458f, 0.15842211f, -0.19425063f, 0.21496958f, 
    -0.06277625f, -0.14145908f, 0.06944136f, -0.03947704f, 0.00473846f, 0.09330271f, -0.01559656f, 0.05705865f, 
    -0.03637995f, 0.04523368f, 0.04247821f, -0.05730035f, -0.11531778f, 0.00245339f, 0.10555952f, 0.04869436f, 
    0.04820637f, 0.11907400f, 0.03551760f, 0.06624180f, -0.15763922f, -0.13947448f, 0.13456529f, -0.03636627f, 
    0.04817644f, 0.02021802f, 0.00075376f, 0.11123887f, 0.06140238f, 0.03309913f, 0.15418205f, 0.02358833f, 
    0.12674569f, 0.44490036f, 0.01339023f, -0.21006349f, 0.08715096f, 0.07859547f, 0.10144983f, 0.05765987f, 
    0.14457710f, 0.05909939f, 0.01470181f, 0.01734741f, 0.11364604f, 0.13073894f, -0.09444542f, 0.09423678f, 
    -0.00482662f, 0.01670285f, -0.04885134f, -0.05391868f, 0.07526921f, 0.20528416f, 0.13235132f, 0.03468271f, 
    -0.14372446f, -0.16214696f, 0.03880981f, 0.07980575f, -0.00690125f, -0.08827801f, -0.08345678f, 0.02711624f, 
    0.00796505f, 0.02583421f, 0.03134105f, -0.00855503f, -0.20509820f, -0.04633778f, 0.14718412f, -0.03975867f, 
    0.13964984f, 0.07816799f, 0.00280499f, 0.05619642f, -0.18296805f, 0.12164694f, 0.00281618f, -0.15375046f, 
    0.06036620f, 0.08537595f, 0.08305116f, -0.13608883f, 0.03740957f, 0.02633430f, 0.05106062f, 0.03250727f, 
    0.02679896f, 0.08858899f, -0.06193388f, -0.12020834f, -0.14856867f, -0.13690159f, 0.07127404f, 0.12448345f, 
    -0.05632383f, 0.01414462f, 0.12236529f, 0.05720286f, 0.02630002f, 0.04380193f, 0.03549603f, 0.15509589f, 
    -0.12959242f, -0.10091052f, 0.07828136f, 0.03917504f, 0.06012903f, -0.09994993f, -0.01773144f, 0.04101581f, 
    -0.00827686f, -0.03882705f, -0.03259652f, -0.16307607f, 0.29168379f, 0.07236808f, 0.19531849f, 0.02093910f, 
    0.05952927f, 0.03360191f, 0.05107245f, -0.07873156f, -0.00549763f, 0.05176719f, -0.09128119f, -0.14630410f, 
    0.02350575f, 0.00838893f, -0.05031651f, 0.01605079f, -0.06291441f, 0.05189134f, 0.09866649f, 0.15102978f, 
    -0.00512466f, 0.01220735f, -0.03333305f, 0.01406864f, 0.15569165f, -0.07349984f, 0.19321892f, 0.02936716f, 
    0.06567273f, -0.06575511f, 0.11897530f, 0.13034938f, -0.00439118f, -0.01302013f, -0.00976220f, 0.01350026f, 
    0.13874574f, -0.01987862f, 0.05048063f, 0.01872121f, -0.00512448f, -0.06043647f, 0.06225937f, 0.13743787f, 
    0.06110676f, -0.03338875f, -0.06253175f, -0.06283394f, 0.33684462f, 0.04963372f, -0.07826468f, 0.05098919f, 
    -0.06378406f, -0.00856648f, 0.06315019f, 0.00766534f, 0.07390524f, 0.00543631f, 0.01862717f, 0.04943222f, 
    -0.29271039f, -0.18909264f, 0.04698869f, 0.23675822f, 0.07543221f, 0.05746216f, 0.08074650f, -0.18626930f, 
    0.02381941f, -0.09009402f, 0.11679228f, 0.11340528f, 0.29115877f, -0.09776453f, -0.13065718f, 0.11363344f, 
    0.02488548f, 0.05050338f, 0.02725825f, -0.04172361f, 0.01985431f, -0.00362691f, 0.08257107f, -0.04430658f, 
    -0.10225271f, 0.44942197f, 0.30827442f, -0.11204252f, -0.04293916f, -0.03992281f, -0.00680538f, 0.13380392f, 
    -0.00942618f, 0.25457269f, 0.02122781f, -0.11468774f, 0.16797392f, -0.20277180f, 0.12962979f, 0.14422153f, 
    0.04647762f, 0.13573895f, 0.07608533f, -0.11284380f, 0.13734592f, -0.02355053f, 0.00533104f, 0.16984852f, 
    -0.22199993f, -0.18998776f, 0.11105652f, 0.06343460f, -0.03813292f, -0.01866349f, 0.10035341f, -0.01471477f, 
    0.05865898f, 0.05160090f, 0.10920594f, 0.11542322f, -0.08282924f, -0.13336642f, 0.00844224f, 0.18605745f, 
    0.13065948f, -0.06292509f, 0.00551906f, 0.01664270f, -0.00022778f, 0.10187703f, 0.28468862f, 0.12732112f, 
    -0.21953785f, -0.22670124f, 0.05189577f, 0.00322898f, -0.09373068f, -0.02513307f, -0.03845324f, 0.05684609f, 
    0.13206454f, -0.02332377f, 0.07214859f, -0.03517845f, 0.11545188f, 0.09288707f, 0.12949979f, 0.09315394f, 
    0.02609861f, -0.11526801f, -0.14143413f, -0.05829056f, 0.00004528f, -0.08088566f, 0.08104985f, 0.22223856f, 
    -0.07144546f, -0.22087239f, -0.00117766f, 0.28429499f, 0.18922377f, 0.06809467f, -0.00966066f, -0.00535566f, 
    0.11956870f, 0.10426256f, -0.00759250f, 0.01068427f, -0.13106342f, 0.20811623f, -0.09211937f, -0.00861452f, 
    -0.02051758f, -0.18925627f, 0.15027139f, 0.00314704f, 0.01086579f, -0.04909663f, 0.04015537f, 0.05226788f, 
    -0.10111734f, -0.03766930f, -0.12708551f, 0.04848480f, -0.07182730f, -0.09738769f, 0.03995511f, -0.05845829f, 
    0.01216507f, 0.07607169f, 0.14862062f, 0.12708324f, 0.09923726f, -0.13682128f, 0.12803948f, 0.11109954f, 
    0.02926073f, -0.13095012f, -0.11018136f, -0.04510050f, -0.07654608f, 0.03072340f, -0.01560276f, 0.26483873f, 
    0.23606622f, -0.06415144f, -0.07668117f, 0.11585348f, 0.10112263f, -0.10119957f, 0.02487043f, 0.01933318f, 
    0.02909476f, -0.08054014f, -0.08631670f, -0.18453242f, 0.02806746f, -0.08712185f, -0.03363375f, 0.10463765f, 
    0.05627534f, 0.08760874f, 0.07704514f, -0.00059515f, -0.06284048f, 0.05824694f, 0.01804367f, -0.09144395f, 
    0.08165209f, 0.00037580f, -0.03742122f, -0.04989954f, 0.02731835f, 0.07053147f, 0.00498553f, -0.05422450f, 
    0.10802907f, -0.00404104f, 0.08002238f, 0.03948355f, 0.07059123f, 0.04513706f, 0.28686339f, 0.12437519f, 
    -0.02003026f, 0.00490733f, 0.04426106f, -0.14431708f, 0.07778157f, 0.05005925f, -0.00722591f, 0.07504947f, 
    0.23100382f, 0.20807445f, 0.06708808f, -0.04796955f, 0.12348817f, 0.00066612f, 0.03700543f, 0.06167100f, 
    0.10583725f, -0.01637763f, 0.08396617f, -0.10711272f, -0.16114433f, -0.01428536f, -0.06361857f, 0.11975775f, 
    -0.06137408f, 0.04794448f, 0.09657458f, 0.04865443f, 0.02309547f, 0.13508616f, 0.01042184f, 0.03126604f, 
    -0.24449272f, -0.20129737f, 0.12368228f, 0.25062644f, 0.10459528f, 0.09862265f, 0.03529437f, 0.06830744f, 
    -0.02970382f, 0.13647830f, 0.07868820f, 0.18490238f, 0.10702763f, 0.05463336f, -0.02696117f, 0.03848090f, 
    0.04796962f, -0.10328782f, 0.10477753f, 0.02364543f, 0.14146324f, 0.07036968f, -0.00443154f, 0.06769688f, 
    0.21940133f, 0.11312064f, -0.13700974f, -0.06051392f, -0.03902763f, 0.00492889f, 0.00470044f, -0.04555827f, 
    0.05435782f, 0.03833460f, 0.01088866f, 0.04464917f, -0.06885246f, 0.03056029f, 0.06085958f, -0.00603587f, 
    -0.08357090f, -0.01019865f, -0.02063760f, 0.01417548f, 0.07932385f, 0.03240520f, 0.07743571f, 0.15301961f, 
    -0.14287359f, -0.28042528f, 0.09949302f, -0.01629421f, -0.00461149f, -0.13951869f, -0.00555179f, -0.04840175f, 
    0.10274711f, -0.03677224f, -0.06375746f, -0.06658380f, 0.18636526f, 0.11168072f, -0.00591475f, 0.06020831f, 
    0.03128107f, -0.10381614f, -0.09444287f, -0.09795355f, -0.03412963f, -0.01572294f, 0.08395627f, 0.05498111f, 
    0.09856719f, -0.01634173f, 0.19069657f, 0.11745172f, 0.06982286f, -0.04619814f, -0.12859496f, 0.11278310f, 
    0.07743210f, -0.04283695f, -0.00742807f, -0.00630150f, 0.08616047f, 0.01386917f, 0.00338961f, 0.19808479f, 
    0.05279620f, 0.03176614f, 0.07732438f, -0.13507886f, 0.05482887f, 0.08335154f, -0.02080458f, 0.04044204f, 
    0.11240355f, -0.11782843f, -0.07659805f, -0.03041977f, 0.01436226f, 0.09904419f, 0.06740813f, 0.03287900f, 
    0.01997453f, 0.06535840f, -0.10278250f, 0.06710671f, -0.05396720f, 0.05186042f, 0.04876277f, 0.08591008f, 
    0.04270613f, 0.00485748f, 0.05641174f, 0.06620701f, 0.09742087f, 0.03390420f, 0.00135885f, -0.04583603f, 
    0.21118338f, 0.22784729f, -0.09678091f, -0.10340916f, -0.05048852f, 0.02861242f, 0.10580363f, -0.04886986f, 
    -0.09243383f, 0.01248686f, 0.05996099f, 0.04712340f, -0.15250529f, -0.05089815f, 0.07994077f, 0.15742774f, 
    -0.06334984f, -0.14722054f, 0.06806019f, -0.06763425f, 0.08593700f, 0.02435709f, 0.21788806f, 0.17970136f, 
    0.14455028f, -0.10219844f, -0.05861179f, 0.01514748f, 0.24307775f, 0.05653970f, -0.00550465f, -0.00168914f, 
    -0.09788072f, 0.01566903f, -0.00885464f, -0.15723318f, 0.11927646f, 0.06906500f, 0.02670799f, 0.01789387f, 
    0.05184406f, 0.03861164f, 0.02803385f, 0.02586818f, 0.15144369f, 0.07419943f, 0.10199969f, 0.18614572f, 
    -0.16907547f, -0.07381831f, -0.08262699f, 0.06987450f, -0.09552775f, 0.12954946f, 0.03397911f, 0.00189519f, 
    -0.03148413f, 0.07544307f, 0.08554026f, 0.11885176f, -0.11060479f, -0.13428302f, -0.01138289f, -0.01986677f, 
    -0.05042984f, -0.01267463f, 0.06300654f, 0.13915227f, -0.00616643f, 0.07116646f, 0.07488412f, 0.02669496f, 
    -0.27542019f, -0.19986071f, 0.13323386f, -0.05266296f, 0.01000357f, -0.05859354f, -0.00482508f, -0.03205579f, 
    0.09020482f, -0.00426648f, -0.04786707f, -0.06038162f, 0.09921514f, 0.03168182f, -0.00900734f, 0.00403504f, 
    0.16156091f, 0.02774688f, 0.01677809f, -0.03311531f, 0.00245497f, -0.08936923f, -0.15594193f, -0.10969510f, 
    0.16614895f, 0.11233154f, 0.11483134f, 0.05249542f, -0.02664473f, 0.00247046f, 0.03393189f, -0.07891064f, 
    0.13839667f, 0.25246730f, 0.15907629f, 0.23872900f, 0.13024068f, 0.23669153f, 0.01515404f, -0.00942143f, 
    0.06549678f, 0.03072591f, 0.03481354f, -0.03624754f, 0.03391295f, 0.09753310f, 0.16090021f, 0.05596118f, 
    0.00128098f, 0.06490269f, 0.02142105f, -0.08684703f, -0.12513342f, 0.07873370f, 0.02072192f, 0.09122498f, 
    0.05419037f, 0.05727058f, -0.08201252f, 0.05809055f, -0.02269101f, 0.06141500f, 0.23052721f, -0.05224710f, 
    -0.05051521f, -0.27423641f, 0.01307529f, -0.05804277f, -0.03195464f, 0.16511427f, 0.16647550f, 0.16044502f, 
    -0.15434530f, -0.04008880f, 0.05812466f, -0.01789479f, 0.03317223f, -0.05593333f, 0.04250569f, 0.01952494f, 
    -0.15353015f, 0.16160034f, -0.00266955f, 0.04208740f, 0.07331061f, 0.01935124f, -0.08973264f, 0.05157580f, 
    0.12195873f, -0.04600786f, -0.00265236f, -0.12090792f, -0.00657702f, 0.04444252f, -0.09937428f, -0.05907593f, 
    -0.01298247f, -0.02508074f, -0.10874001f, -0.03404014f, 0.03736673f, 0.06313096f, 0.19840506f, -0.01499519f, 
    0.00359846f, -0.00810414f, -0.11289455f, -0.05424381f, -0.01457700f, 0.16707556f, -0.09544220f, 0.12418979f, 
    0.11887394f, -0.07155410f, -0.02658246f, -0.14747488f, -0.15679646f, -0.06160384f, 0.08358544f, 0.04131015f, 
    0.12467650f, 0.12940212f, -0.27603123f, -0.12835722f, -0.09021638f, -0.05052632f, -0.06978264f, 0.05612413f, 
    -0.00698206f, 0.00369759f, 0.05866492f, -0.19582269f, 0.21539629f, 0.35948044f, -0.01218513f, 0.09480479f, 
    -0.02331565f, 0.12575585f, 0.02760541f, 0.06110527f, 0.13418908f, -0.01625253f, 0.01569586f, 0.04509846f, 
    0.06607042f, 0.18139732f, -0.26939347f, 0.01958284f, -0.09556142f, 0.00867550f, 0.11088385f, 0.13941334f, 
    0.11019246f, 0.09239785f, 0.10568314f, -0.07206483f, 0.03523484f, 0.13460755f, 0.12342777f, -0.00855879f, 
    0.08334997f, -0.08235724f, 0.14695665f, 0.09972271f, -0.04965113f, -0.04589008f, 0.05938694f, 0.05514708f, 
    -0.02028661f, -0.00139134f, -0.34405661f, -0.12830676f, -0.02125082f, -0.08737884f, -0.06503939f, -0.29579648f, 
    -0.15296847f, -0.10788607f, -0.02685254f, 0.08072598f, 0.09764238f, 0.07421711f, 0.00299235f, 0.15778999f, 
    0.08070436f, 0.06414175f, -0.07663309f, 0.26958096f, 0.08394410f, 0.18509021f, 0.01423258f, 0.16832642f, 
    0.20158416f, 0.33189940f, 0.18488438f, 0.08292751f, 0.17474081f, 0.10831605f, 0.04278774f, 0.01141695f, 
    0.18353759f, -0.03193427f, 0.02123371f, 0.09316764f, 0.33289278f, 0.29521647f, 0.09243919f, 0.07091334f, 
    0.06121113f, 0.14398691f, -0.02832211f, 0.07601023f, 0.00026909f, -0.09368900f, 0.04920396f, 0.13204624f, 
    0.62309730f, 0.09015324f, 0.12784006f, -0.11938227f, 0.11096812f, -0.06616213f, -0.00036969f, 0.15910605f, 
    0.12013286f, 0.17189252f, -0.15436180f, 0.00517276f, -0.24436928f, -0.19015959f, -0.06895392f, 0.16548477f, 
    0.04935549f, -0.05108054f, -0.06780326f, -0.10148387f, 0.24067484f, -0.06296291f, 0.07443573f, 0.10528239f, 
    -0.17680013f, -0.00852330f, 0.15769872f, 0.23917475f, 0.11612057f, 0.04267498f, 0.12520584f, 0.00197193f, 
    -0.05431028f, -0.02686333f, -0.08044264f, 0.04560396f, 0.11868273f, -0.18254679f, 0.06825679f, -0.14224081f, 
    -0.08810166f, -0.04235832f, -0.00171857f, -0.18356533f, 0.18753079f, 0.17768714f, 0.00505824f, 0.18605281f, 
    0.14271319f, 0.10937031f, 0.15775129f, 0.15798560f, -0.12009331f, -0.00839317f, -0.05269494f, -0.03367402f, 
    0.03330008f, 0.13989098f, 0.01899627f, 0.02066576f, 0.08959453f, 0.06113698f, -0.02081750f, -0.00780058f, 
    0.09944616f, 0.06525906f, -0.03768525f, 0.03666088f, 0.03221120f, 0.08271915f, 0.05805532f, 0.13652210f, 
    -0.04314905f, 0.03539309f, 0.11320025f, -0.02636648f, 0.17576268f, 0.12904970f, 0.06308465f, 0.05041522f, 
    -0.01719020f, -0.04636999f, 0.11543248f, 0.18633771f, 0.06010799f, 0.22103505f, 0.02018569f, 0.20785521f, 
    -0.13156137f, -0.14444281f, -0.10045526f, -0.01855959f, 0.01838803f, -0.03939790f, 0.00922900f, 0.00957525f, 
    -0.12065644f, -0.03199909f, -0.13526671f, -0.05804167f, 0.02459376f, -0.02356988f, -0.08672656f, -0.06400707f, 
    0.17008370f, -0.08323610f, -0.02146509f, -0.05840619f, -0.09418427f, -0.00829438f, -0.26812109f, -0.24334027f, 
    0.02756215f, -0.09001376f, 0.16867608f, 0.00012661f, 0.04409098f, 0.00495847f, 0.02103819f, -0.03184044f, 
    0.25585476f, 0.18363802f, -0.04553217f, -0.07302239f, 0.10444333f, 0.04537065f, 0.02166765f, 0.02649147f, 
    0.30285326f, 0.20265864f, 0.16847709f, 0.13589397f, -0.23855045f, -0.07465973f, -0.09295452f, 0.08288027f, 
    -0.10886204f, -0.16481754f, -0.13340440f, -0.14262198f, -0.01915397f, -0.08001603f, -0.09330997f, -0.19723286f, 
    -0.28739616f, 0.06690013f, 0.22898369f, 0.20859310f, 0.13176696f, -0.05456651f, -0.01143817f, 0.21355113f, 
    0.13076751f, -0.03435702f, 0.02360094f, 0.10881262f, -0.14200170f, -0.07901061f, -0.08477309f, 0.08233356f, 
    0.05484282f, -0.12735900f, -0.03554584f, -0.06309394f, -0.04870791f, 0.00723172f, 0.06174492f, -0.04344162f, 
    0.34832168f, 0.00058260f, -0.00911635f, -0.16898975f, 0.15945859f, 0.10832600f, -0.06539425f, -0.03389105f, 
    0.30891603f, -0.05990211f, -0.02441233f, 0.17351106f, 0.01112373f, 0.10837490f, 0.08691309f, 0.03998664f, 
    0.12453648f, -0.00631343f, 0.07221396f, 0.26712632f, 0.00082206f, 0.10818934f, 0.07220075f, -0.17032602f, 
    -0.13671851f, 0.06491142f, 0.28911865f, 0.05269722f, 0.08309443f, -0.01617894f, -0.05330109f, -0.04926184f, 
    0.09364626f, 0.01368499f, -0.06608787f, 0.15577772f, -0.00633389f, 0.29028538f, 0.36763909f, 0.14157395f, 
    0.08372100f, 0.03770088f, -0.00802974f, 0.22997303f, 0.11865559f, 0.03185743f, 0.06440983f, 0.00121798f, 
    -0.10289655f, 0.19198814f, 0.13500398f, 0.15759005f, 0.04964153f, 0.13898394f, 0.11778726f, 0.01790809f, 
    -0.07748611f, -0.08099633f, -0.08398681f, -0.11745349f, -0.29805660f, -0.01860916f, 0.20697434f, 0.06127859f, 
    0.03904472f, -0.08226077f, 0.04321876f, 0.02808713f, 0.03241856f, -0.02168673f, 0.11213763f, 0.07717143f, 
    0.00807813f, -0.02359262f, -0.29049778f, 0.01922213f, 0.15104783f, 0.04750637f, -0.09718392f, -0.01826835f, 
    0.06977393f, 0.08018763f, 0.23797320f, 0.16306357f, 0.16152105f, 0.09282774f, -0.00692184f, 0.00666533f, 
    0.23384827f, 0.15348698f, 0.13639592f, 0.02248705f, 0.11666021f, -0.01186538f, 0.01661828f, -0.27745220f, 
    -0.03827973f, -0.01730982f, 0.27249834f, -0.08206885f, 0.09012394f, 0.16677429f, 0.02673591f, 0.19271486f, 
    0.10545676f, 0.06291161f, -0.05826456f, -0.03338655f, -0.33478814f, -0.10622573f, -0.07657783f, 0.04364327f, 
    -0.12320680f, -0.10938418f, -0.12248056f, 0.01746954f, -0.01304922f, 0.03218132f, 0.10510120f, -0.08236881f, 
    0.01973914f, 0.12745777f, -0.07696401f, 0.10668238f, -0.11631352f, -0.08876578f, -0.05443193f, -0.19065307f, 
    0.09332885f, -0.00857397f, 0.07701835f, -0.02105155f, -0.06722511f, -0.08619449f, 0.12463718f, 0.11267463f, 
    0.34585828f, 0.05065722f, 0.03998996f, 0.13477081f, 0.07639126f, 0.12267926f, -0.02910865f, 0.08284868f, 
    0.09664642f, -0.17961101f, -0.11178319f, 0.05673914f, -0.11975887f, -0.06529567f, -0.09481848f, -0.17852014f, 
    0.10088293f, 0.16017507f, 0.06837168f, 0.06698729f, 0.16843238f, 0.23739249f, 0.01395875f, -0.06801809f, 
    0.12135794f, -0.00070236f, 0.09161233f, 0.17569870f, -0.00491209f, 0.01351066f, -0.00710783f, 0.11749618f, 
    0.38818425f, -0.10947083f, 0.05078939f, -0.02038343f, -0.15788379f, -0.03200590f, 0.00980633f, -0.07555735f, 
    0.10191405f, 0.05380928f, 0.03273549f, 0.29559064f, 0.15053035f, 0.08668912f, 0.14156261f, -0.05819484f, 
    0.04808284f, 0.10936493f, -0.02953527f, 0.06045960f, 0.00252917f, 0.07306161f, 0.10327223f, -0.01215613f, 
    -0.35769638f, 0.03295185f, -0.00709480f, 0.26044434f, -0.04910912f, -0.06853461f, -0.03368844f, 0.10782918f, 
    0.18443711f, -0.14567234f, -0.00746321f, -0.02356270f, -0.18987432f, -0.06593164f, 0.01603883f, -0.07358719f, 
    0.17098820f, 0.07246375f, 0.03077114f, 0.08335592f, 0.03539333f, -0.01258447f, 0.09895834f, 0.01877835f, 
    -0.07893889f, -0.13706881f, -0.01857592f, 0.05323255f, -0.07092988f, -0.17210442f, -0.13904056f, 0.01472160f, 
    -0.00363744f, 0.01155415f, -0.04733241f, -0.05748603f, -0.17719418f, -0.13739885f, 0.01774200f, -0.10848502f, 
    0.04783161f, 0.05228594f, -0.07326128f, 0.06011991f, 0.07516787f, 0.09905711f, 0.08062290f, 0.09536421f, 
    -0.09054484f, 0.07420439f, 0.02018941f, 0.03633936f, -0.02671538f, 0.08273675f, 0.04762958f, 0.15503506f, 
    0.00009484f, 0.09402870f, -0.05810349f, 0.06079627f, -0.54377252f, -0.14672348f, 0.05657737f, 0.18868703f, 
    0.03712434f, -0.15145735f, -0.10136138f, -0.14949140f, 0.05159216f, 0.04321491f, 0.09288664f, 0.03881354f, 
    0.12008548f, 0.07162436f, 0.01215679f, -0.20398411f, -0.20410240f, 0.04266727f, 0.12446621f, 0.06396387f, 
    0.19513494f, 0.04234989f, 0.08791843f, 0.11582732f, 0.04530963f, 0.15544225f, 0.13132215f, 0.04079066f, 
    0.28571591f, 0.04160359f, 0.10453403f, 0.20838772f, 0.18023382f, 0.15701617f, -0.00853419f, 0.14796117f, 
    0.13957977f, -0.06910926f, -0.03234132f, 0.04899239f, -0.01919381f, -0.05095691f, -0.05218627f, 0.12064867f, 
    0.16279167f, 0.08084736f, -0.06932835f, 0.04906413f, -0.09287388f, -0.05876423f, -0.02204691f, -0.01016449f, 
    0.10266212f, 0.05989259f, -0.03992141f, -0.12825848f, -0.05644813f, -0.11046823f, 0.00175920f, 0.05404865f, 
    -0.17117934f, 0.08186088f, 0.15955874f, 0.10878670f, -0.06042119f, -0.06713098f, -0.16694896f, -0.09705371f, 
    0.25091541f, -0.02563899f, 0.06033674f, -0.01960110f, -0.19452339f, -0.19841023f, 0.14538698f, 0.06397197f, 
    0.02926940f, -0.12985027f, -0.03451281f, 0.10609346f, -0.11715345f, -0.05304400f, -0.02304034f, 0.02530164f, 
    -0.26430321f, -0.07682618f, -0.05050818f, 0.16877912f, 0.08833726f, -0.04351835f, 0.11975049f, 0.06781042f, 
    0.11871802f, -0.00628239f, 0.07600366f, -0.01602551f, -0.01346857f, 0.07752053f, -0.17114370f, -0.06830093f, 
    -0.08780546f, 0.01536488f, -0.17544228f, -0.11816159f, 0.01329532f, -0.01369044f, 0.00703036f, -0.09123662f, 
    0.00016542f, -0.09025903f, 0.14896233f, -0.13418141f, 0.15164712f, 0.05039370f, 0.02920688f, 0.04075391f, 
    0.19374022f, 0.10693239f, -0.04809427f, 0.10993148f, -0.06040858f, -0.03868574f, 0.32549661f, 0.08673760f, 
    0.11545862f, 0.01858518f, 0.15423222f, 0.04592991f, 0.10981274f, 0.04937206f, -0.07160014f, 0.03252764f, 
    -0.23072755f, 0.05077016f, 0.07670150f, 0.04573347f, 0.07425270f, 0.01520112f, 0.09821138f, -0.18515830f, 
    -0.14358799f, -0.05734150f, -0.03301153f, -0.04922645f, -0.25556558f, -0.12092038f, -0.16699964f, 0.06447138f, 
    0.05030348f, -0.04776578f, -0.17179458f, -0.06048804f, 0.02206318f, -0.13468289f, 0.16298592f, 0.08885563f, 
    0.18096611f, -0.08378744f, 0.04355030f, -0.02617576f, 0.03026136f, 0.06926024f, 0.01481648f, 0.04135245f, 
    0.12758635f, -0.12915820f, -0.01610168f, -0.14098431f, -0.03311406f, -0.04891588f, 0.13600129f, 0.11013417f, 
    0.02276735f, 0.03089953f, -0.10318601f, 0.00324633f, 0.05780844f, -0.01215509f, 0.12928738f, -0.02180935f, 
    -0.02503856f, -0.19099876f, 0.03876646f, -0.17291422f, 0.23893052f, 0.09703230f, 0.13840240f, 0.04601285f, 
    0.09042045f, -0.03261700f, -0.14405368f, -0.02392182f, -0.15891676f, 0.32506642f, -0.06154331f, -0.06291837f, 
    -0.13972870f, -0.07973281f, -0.00450066f, -0.07013274f, 0.00534507f, 0.03961572f, -0.00528326f, -0.19925408f, 
    0.11554490f, 0.07106569f, 0.35031548f, -0.19520749f, -0.00363723f, 0.05315409f, 0.19121601f, 0.07415987f, 
    0.17977762f, -0.04620927f, 0.02089565f, 0.21961775f, -0.05270658f, -0.03304415f, -0.00135674f, 0.11328430f, 
    0.00378131f, -0.01989414f, -0.00820399f, 0.07719173f, 0.23181453f, 0.16911124f, 0.11457534f, -0.05765681f, 
    -0.05920868f, -0.17818969f, 0.05735220f, -0.12803383f, 0.17809524f, 0.06717703f, 0.10330970f, 0.10426398f, 
    0.08315297f, 0.07597858f, 0.06223915f, 0.11607537f, -0.35221809f, -0.01915155f, 0.01081142f, 0.17727277f, 
    -0.02571713f, -0.09754834f, -0.07347919f, -0.07013825f, 0.11382752f, 0.26679829f, -0.02800028f, 0.04599613f, 
    0.04551262f, -0.22472391f, -0.14960936f, -0.33540225f, -0.08722532f, -0.11966009f, 0.15740436f, -0.01200907f, 
    -0.09853017f, -0.06685726f, -0.02756861f, 0.03840242f, 0.27304536f, -0.02483796f, 0.04578186f, -0.02116197f, 
    0.03093234f, -0.07766349f, 0.08295649f, 0.00864398f, 0.00949802f, -0.01552599f, -0.00606017f, 0.07115699f, 
    0.07203905f, -0.34376737f, 0.00647028f, -0.13048965f, -0.01948910f, -0.11915714f, -0.02160700f, 0.03188641f, 
    0.02913532f, -0.00616209f, 0.06705333f, 0.03551029f, -0.05245414f, 0.13338418f, 0.08360455f, 0.02492140f, 
    0.06912801f, 0.18267012f, -0.04403961f, 0.10720073f, 0.00473183f, 0.13628830f, -0.06149396f, 0.00252618f, 
    -0.06108181f, 0.11414275f, -0.09293036f, -0.53327173f, 0.02340176f, 0.04550524f, 0.02853687f, -0.10331248f, 
    0.01632498f, 0.08453355f, -0.03626307f, 0.04870516f, -0.13203190f, -0.11713567f, 0.29867584f, -0.28860891f, 
    0.09127070f, 0.04754310f, 0.11706200f, -0.03463057f, -0.03339075f, 0.01800417f, 0.00419113f, 0.07529022f, 
    0.14711614f, 0.12052163f, -0.00304809f, -0.02162305f, -0.00885810f, 0.02908358f, 0.03995628f, 0.03222443f, 
    0.02032848f, -0.00679227f, -0.05520756f, -0.05419090f, 0.18034488f, 0.18254137f, 0.04106816f, -0.03178704f, 
    0.00769424f, 0.07910929f, 0.04882844f, -0.01899294f, 0.03121413f, 0.09682389f, -0.06208855f, -0.00973093f, 
    -0.09363146f, -0.37514040f, 0.32919890f, -0.09484977f, -0.00532171f, 0.16443904f, -0.01688207f, -0.03424915f, 
    0.02700850f, 0.08457893f, 0.05173665f, 0.09618851f, -0.20522472f, -0.52612859f, 0.02832793f, 0.06606732f, 
    -0.00652962f, -0.08415964f, 0.00825504f, 0.03330186f, 0.07592506f, 0.00075073f, -0.01869618f, 0.03145475f, 
    0.18516873f, 0.16649404f, 0.10239300f, -0.00784552f, -0.06381835f, -0.01476486f, 0.10518563f, -0.06623381f, 
    -0.00294065f, -0.02614327f, 0.06410424f, 0.04596799f, 0.41271400f, -0.04589203f, -0.27052605f, -0.12214387f, 
    -0.17523865f, -0.04221088f, 0.10600382f, 0.08683079f, -0.10403230f, 0.01232359f, 0.00698751f, -0.02683591f, 
    -0.00152303f, -0.43565899f, -0.11245403f, -0.02348671f, -0.08959997f, 0.00537223f, -0.05662449f, 0.03061092f, 
    -0.03255731f, -0.03293769f, 0.00398339f, -0.02511349f, 0.16713549f, 0.15236707f, -0.05128359f, -0.05653986f, 
    -0.01621203f, -0.07723489f, -0.01703037f, 0.00039935f, -0.08619002f, 0.04453148f, 0.05029856f, 0.06475930f, 
    0.13713858f, 0.16919899f, 0.02535195f, 0.03615031f, -0.13631383f, -0.01103260f, 0.04809939f, 0.03795540f, 
    -0.02418308f, 0.06927121f, -0.00861857f, 0.03869499f, -0.44535801f, -0.25191334f, -0.22877853f, -0.15970983f, 
    0.06067241f, 0.09656368f, -0.02894839f, 0.06192490f, -0.00754090f, -0.07536681f, 0.06409447f, 0.06842969f, 
    -0.01102051f, -0.02729194f, -0.04381028f, -0.28533891f, -0.03226555f, 0.08172367f, 0.12546921f, -0.02538182f, 
    -0.02177334f, -0.04143653f, 0.10940677f, 0.10420405f, -0.14501658f, -0.01201844f, -0.07141232f, -0.47534809f, 
    -0.07091542f, 0.02384571f, -0.04479696f, 0.07183011f, -0.14151841f, 0.06743310f, -0.11498128f, 0.08280159f, 
    -0.11813523f, -0.21955700f, 0.20113054f, -0.00307144f, 0.00742712f, 0.02684502f, 0.10103165f, -0.03245975f, 
    -0.08511258f, -0.01594144f, -0.00902902f, 0.05339474f, -0.09786186f, 0.03120691f, 0.01412318f, -0.27647635f, 
    0.20655498f, -0.05781829f, 0.10416301f, -0.03634019f, -0.10522658f, -0.06978662f, 0.04522625f, 0.02299576f, 
    0.44427121f, 0.06465925f, -0.02687689f, 0.04960886f, -0.07718032f, 0.03962862f, -0.03907283f, 0.07311489f, 
    0.07121929f, 0.03020053f, 0.04665105f, 0.00441165f, -0.60775328f, -0.02630435f, 0.17426437f, -0.06963865f, 
    0.14886108f, -0.03015492f, -0.11625510f, -0.08402222f, 0.09404550f, -0.06304695f, -0.08109950f, 0.11758866f, 
    0.19304232f, -0.33808875f, 0.11825719f, -0.07392666f, 0.04975954f, 0.00056052f, -0.02231467f, 0.06842298f, 
    -0.02080884f, -0.04283494f, -0.04676112f, 0.06034885f, -0.25347120f, 0.18072774f, -0.12891503f, 0.00326576f, 
    0.00357315f, 0.05758944f, -0.05631820f, -0.02863842f, -0.11492106f, -0.00192025f, -0.03931877f, 0.05974500f, 
    0.28278464f, 0.17830887f, -0.02205906f, 0.02453768f, -0.04832128f, 0.11647665f, 0.04181794f, 0.08412191f, 
    -0.01267571f, -0.01896793f, 0.04392391f, 0.03022270f, 0.04688257f, -0.03131270f, 0.09638502f, 0.01817173f, 
    0.09508023f, 0.14132297f, 0.04738799f, 0.00071198f, 0.04383786f, -0.02256767f, -0.17573708f, -0.08021688f, 
    0.16677544f, 0.22873840f, 0.04441515f, -0.02898426f, 0.11771628f, 0.15230766f, 0.02996837f, 0.03370521f, 
    -0.06637976f, -0.05162285f, -0.15204459f, 0.03394420f, 0.17609653f, 0.11247500f, -0.07867724f, -0.03780494f, 
    -0.03682325f, 0.02426048f, 0.02509374f, 0.04885931f, -0.01832463f, -0.00247135f, -0.02288286f, -0.12042601f, 
    -0.18517762f, 0.06584611f, 0.04920651f, -0.15299377f, 0.05010619f, 0.00191892f, 0.06724574f, 0.10343148f, 
    -0.04178643f, -0.27138352f, -0.13407913f, -0.07344893f, 0.32578179f, 0.05494751f, 0.23453283f, -0.10959762f, 
    -0.07060876f, 0.13555487f, -0.01641500f, -0.01171348f, 0.14535631f, -0.14832972f, -0.00522178f, 0.05802144f, 
    0.15713479f, 0.15430436f, 0.12855878f, -0.01636592f, 0.05681715f, 0.00491418f, 0.02997906f, -0.00210217f, 
    -0.08408885f, -0.00007092f, 0.02732457f, -0.05221875f, 0.22630499f, 0.10237604f, -0.06755649f, -0.04767443f, 
    -0.03314031f, 0.01535464f, -0.01378839f, -0.00894893f, 0.03123275f, 0.06004183f, 0.05474629f, 0.02237259f, 
    -0.39104763f, -0.04544149f, 0.08553858f, -0.24247220f, 0.10391960f, 0.14252925f, 0.02600993f, -0.03026286f, 
    -0.00929412f, 0.05495782f, 0.01159444f, -0.05319439f, -0.27107412f, 0.05711441f, 0.03847237f, -0.09316719f, 
    -0.03940474f, 0.00066726f, -0.05844809f, 0.14000466f, -0.02050151f, -0.04051208f, 0.05503041f, -0.09410504f, 
    -0.08105041f, -0.38022342f, -0.37636176f, -0.37456611f, -0.16078669f, -0.15421626f, 0.09258156f, 0.04589003f, 
    -0.09011854f, -0.03830279f, 0.02324948f, 0.04116462f, -0.05478961f, -0.05751987f, -0.20564686f, -0.00387731f, 
    -0.09309155f, -0.06819329f, 0.16402939f, 0.09781440f, -0.01606778f, -0.01095309f, 0.08101764f, -0.06101255f, 
    -0.03873664f, -0.28399807f, -0.06739490f, -0.03031201f, -0.13399982f, 0.07563204f, 0.00356507f, -0.06236516f, 
    -0.15346195f, -0.05242764f, -0.18543859f, 0.14430393f, 0.16966507f, 0.03714946f, 0.07269042f, -0.08071428f, 
    0.07002063f, -0.06282588f, 0.02397362f, -0.05651129f, -0.03823095f, -0.05508281f, 0.00641330f, 0.16025136f, 
    0.46499118f, -0.09410750f, -0.04218630f, -0.09651211f, 0.07771710f, -0.09719965f, 0.06703377f, 0.01856450f, 
    0.07222763f, -0.00606903f, -0.00767625f, -0.03861623f, -0.13183686f, -0.04836180f, 0.04658011f, -0.07057508f, 
    0.01466466f, 0.05050059f, -0.00600669f, 0.08745432f, -0.11885526f, -0.04617786f, -0.14347519f, -0.04993894f, 
    -0.17716122f, -0.01946032f, -0.13464218f, -0.11684176f, 0.25595513f, 0.01654698f, -0.00784594f, 0.03304306f, 
    -0.09328433f, -0.11808550f, -0.02306903f, 0.00507430f, 0.25105467f, -0.01459556f, -0.00646773f, 0.12014890f, 
    -0.06607848f, -0.00727005f, 0.11380523f, -0.07873984f, 0.03226084f, 0.06044161f, 0.01538471f, 0.06363536f, 
    0.12929259f, 0.15938142f, -0.02149267f, 0.06949294f, -0.02539612f, 0.03402852f, 0.00677552f, 0.08838288f, 
    -0.03693108f, -0.07065789f, -0.11423390f, -0.03504917f, -0.24000184f, 0.06372299f, -0.05286285f, -0.02397676f, 
    -0.06200645f, -0.00591499f, -0.03315085f, 0.03972555f, -0.00462766f, 0.07465873f, 0.02467053f, 0.00914255f, 
    0.01036846f, -0.02803089f, 0.09374251f, -0.00684874f, 0.01993543f, 0.03804284f, 0.10711417f, -0.01523346f, 
    -0.17227110f, 0.00338316f, 0.06248749f, -0.01715433f, -0.07808211f, -0.04141924f, 0.16845484f, -0.03522729f, 
    0.02942338f, -0.04371461f, 0.03694135f, 0.09106587f, -0.00970873f, 0.01704844f, 0.05628029f, -0.07717004f, 
    -0.00803151f, -0.21779718f, -0.30138251f, 0.02332571f, 0.14042309f, 0.02523124f, -0.13195232f, -0.03083899f, 
    -0.08424305f, -0.05567183f, -0.04921733f, -0.08344851f, 0.11598938f, 0.16729702f, 0.04488196f, -0.10291319f, 
    -0.16839738f, -0.12522359f, 0.11032116f, -0.01687400f, 0.00705790f, -0.01356835f, 0.06733209f, 0.05025045f, 
    -0.39875406f, -0.58891004f, -0.00166412f, 0.08552226f, 0.25976565f, -0.02184318f, 0.01328060f, 0.10050908f, 
    0.03471601f, 0.02115604f, 0.09164820f, 0.02251589f, 0.24081348f, 0.07983115f, -0.02111184f, 0.04633873f, 
    -0.02176825f, 0.01968710f, -0.01995565f, 0.04854115f, 0.03950868f, 0.07123294f, -0.00635115f, 0.03897183f, 
    -0.13167953f, 0.09607278f, 0.09868300f, 0.13141339f, -0.12063265f, -0.04147110f, 0.11714172f, -0.04464683f, 
    -0.04661989f, 0.04891579f, -0.00405011f, 0.06181990f, 0.25770259f, -0.18389091f, -0.07528662f, -0.08243723f, 
    -0.03234966f, -0.10948338f, -0.07654620f, -0.04717682f, -0.21932192f, -0.04281360f, -0.05253234f, -0.06850576f, 
    0.17691284f, 0.08010728f, 0.12562390f, -0.01323125f, 0.02650784f, -0.05584451f, -0.07430410f, 0.09175713f, 
    -0.01050140f, -0.04689958f, -0.07439107f, -0.06133292f, 0.26987186f, 0.20327763f, 0.08501584f, 0.02638095f, 
    0.06981612f, -0.00399061f, -0.07399230f, -0.02012309f, -0.04133791f, -0.00990226f, 0.00800415f, -0.06569715f, 
    0.29673141f, 0.13322809f, 0.05850415f, -0.01347902f, -0.09879083f, -0.02899998f, 0.03562383f, 0.15737246f, 
    -0.02351539f, 0.02064123f, -0.03034694f, -0.03594395f, -0.07356476f, -0.11352454f, -0.19231878f, 0.10474209f, 
    -0.11220968f, -0.11867701f, -0.05917044f, 0.11689026f, -0.01577562f, 0.05770551f, -0.00534285f, -0.02834212f, 
    -0.04223869f, 0.01323974f, 0.01132302f, 0.01859693f, 0.11557145f, -0.14392345f, 0.07484064f, -0.03459613f, 
    -0.20202160f, -0.02685313f, 0.08731506f, -0.02164288f, -0.52306396f, -0.17972092f, -0.20954721f, -0.09113790f, 
    0.26021662f, 0.10421850f, 0.01456375f, -0.01125250f, 0.00752134f, -0.01149475f, -0.14266819f, 0.04689100f, 
    0.01404094f, 0.03369787f, -0.02863972f, 0.06362583f, 0.02615578f, -0.00061817f, 0.07903279f, 0.08143793f, 
    0.04431306f, 0.02147631f, 0.07476284f, -0.19217281f, 0.08984244f, -0.01775294f, -0.07068037f, -0.09388869f, 
    0.04829339f, 0.08289476f, 0.01301184f, 0.02591401f, -0.04875728f, -0.00244387f, -0.01048555f, 0.15942436f, 
    0.07789342f, 0.04966578f, 0.05795337f, 0.07790829f, 0.04195800f, 0.07668813f, -0.04867225f, 0.05288303f, 
    -0.00756506f, -0.07672313f, -0.07609877f, -0.03205491f, -0.28680924f, 0.04226170f, -0.01615796f, 0.08105251f, 
    0.04142490f, 0.19218780f, -0.07671228f, -0.02047841f, 0.04235657f, -0.04240059f, -0.11840972f, 0.05473002f, 
    -0.11786349f, -0.12631223f, -0.00533057f, 0.10622137f, 0.01908168f, 0.03249156f, -0.03712263f, 0.14966896f, 
    -0.03747442f, -0.23731193f, -0.05405721f, -0.00919765f, -0.52531338f, -0.24140488f, 0.14182246f, -0.07233204f, 
    0.05220455f, 0.08745306f, -0.05199461f, 0.10251631f, 0.05622862f, 0.11602399f, -0.00054131f, 0.02964647f, 
    -0.03306255f, -0.03226368f, 0.00319290f, 0.00158903f, -0.04206901f, 0.01045861f, -0.03277086f, -0.00265717f, 
    0.00447703f, -0.02457911f, -0.03057450f, -0.02978178f, -0.03757372f, -0.03323605f, 0.00514673f, -0.03072599f, 
    -0.01233984f, 0.02821440f, -0.01497393f, 0.02495402f, -0.03234040f, -0.02628750f, -0.01950085f, 0.02728023f, 
    -0.01479981f, 0.01391587f, 0.00600313f, -0.03256674f, 0.02370049f, 0.01181318f, 0.02818009f, 0.02289131f, 
    -0.01633657f, -0.02428687f, -0.02882139f, -0.03026913f, 0.01889412f, -0.03941632f, 0.00300899f, 0.02111313f, 
    -0.02083049f, -0.01115856f, -0.00736473f, 0.00363761f, 0.01644353f, -0.00978402f, -0.01244986f, -0.00238576f, 
    -0.01966842f, -0.02175006f, -0.02844452f, 0.02728657f, 0.02271320f, 0.00291039f, -0.01861293f, -0.01088192f, 
    -0.00955670f, -0.01201807f, 0.00151847f, -0.04111113f, -0.01552406f, 0.01674009f, -0.00351855f, -0.03271234f, 
    0.00859614f, -0.02717367f, -0.01869818f, -0.00384177f, -0.02664952f, 0.00438298f, 0.02093803f, 0.01677330f, 
    -0.03785301f, -0.00783022f, 0.02265663f, -0.04143161f, -0.02827021f, -0.03088767f, -0.04043413f, -0.00465063f, 
    -0.02145085f, 0.00086027f, 0.01261770f, -0.00499540f, -0.04026463f, -0.00833304f, 0.00383353f, 0.00023242f, 
    0.00155097f, -0.02262472f, -0.02844327f, 0.01057103f, -0.03420113f, -0.03910072f, -0.02348742f, -0.01088531f, 
    0.01805500f, 0.01352343f, -0.03731132f, 0.02680299f, 0.01685619f, 0.00210700f, 0.00903269f, 0.00277147f, 
    0.00487726f, 0.00592674f, -0.02442933f, -0.02150378f, 0.01076768f, -0.02447698f, 0.02940692f, -0.00938241f, 
    -0.01522245f, 0.02728278f, -0.01917216f, -0.00332524f, -0.03262141f, 0.00044755f, -0.02099193f, 0.02988758f, 
    -0.01575547f, -0.02235994f, 0.00576995f, -0.01794926f, -0.00455340f, -0.02577412f, -0.00503256f, 0.00882613f, 
    0.02230165f, -0.03148722f, -0.03587422f, -0.01956653f, -0.01667776f, -0.03325095f, -0.00172579f, 0.00601801f, 
    0.00467620f, -0.00592701f, -0.03784516f, -0.00868178f, -0.00356323f, -0.03668580f, -0.02588823f, -0.01958933f, 
    -0.00710988f, 0.00207024f, -0.03110645f, -0.02377457f, 0.00358263f, 0.00229691f, -0.00899593f, 0.00865140f, 
    -0.01990498f, -0.00957830f, -0.03783502f, 0.02948292f, -0.03458386f, -0.00739418f, -0.00429101f, 0.00353811f, 
    0.00504088f, -0.03472307f, -0.02167724f, 0.01123877f, 0.00481975f, -0.02985742f, 0.02143843f, -0.00907229f, 
    0.02726607f, -0.02628151f, 0.01889966f, 0.00560968f, 0.01054523f, 0.02732611f, -0.02543052f, -0.02343944f, 
    0.01488184f, 0.00196614f, 0.02699043f, -0.03347924f, 0.01398545f, 0.01668410f, 0.01597159f, -0.02586418f, 
    0.00980819f, 0.02577930f, -0.01797766f, 0.01561082f, 0.00863669f, -0.02026353f, -0.00143794f, -0.02223049f, 
    0.01869235f, -0.01076777f, 0.00405603f, -0.02825737f, 0.02969826f, 0.02413701f, 0.01040610f, -0.01241160f, 
    0.01457231f, 0.01009986f, -0.00948974f, 0.01566693f, 0.00962571f, -0.02326982f, 0.01912681f, -0.00364213f, 
    -0.02979180f, -0.03715738f, 0.00058283f, 0.02718750f, -0.01742431f, 0.01236274f, 0.01716057f, -0.00946778f, 
    -0.00107050f, 0.01911925f, 0.02900899f, -0.04101008f, 0.02139875f, 0.02903409f, 0.01859324f, -0.02538552f, 
    -0.00638474f, -0.03311725f, 0.01767264f, -0.01987511f, -0.02275292f, 0.02203519f, 0.00441249f, -0.02411336f, 
    0.02934050f, 0.01421760f, -0.03894460f, -0.00847745f, 0.00138641f, 0.02030063f, 0.01326031f, 0.01696097f, 
    0.00661128f, -0.00298758f, -0.04104419f, 0.02992767f, -0.01452873f, 0.02874618f, -0.00300472f, 0.00255829f, 
    -0.01197286f, 0.01875085f, 0.01549518f, 0.01494141f, 0.01002595f, -0.01152088f, 0.02135885f, 0.01736965f, 
    -0.04081070f, -0.00273461f, 0.00446649f, -0.03640078f, -0.03427891f, 0.01306416f, -0.03674097f, -0.03667447f, 
    0.01905332f, 0.02373262f, 0.02179910f, -0.03628995f, -0.01038887f, -0.01471916f, -0.02380605f, 0.00888524f, 
    -0.03865911f, -0.01460371f, -0.03773392f, -0.02086023f, -0.00433553f, -0.03608650f, -0.02488522f, -0.00229305f, 
    0.01667156f, -0.00665939f, 0.01900916f, -0.04042168f, -0.02864457f, -0.03739918f, -0.01750255f, -0.01585257f, 
    -0.01398108f, -0.03632940f, -0.00471117f, -0.04107507f, 0.02589217f, -0.01873440f, 0.02505693f, -0.00132579f, 
    -0.01016218f, 0.02282110f, 0.00742399f, -0.03208997f, -0.04144166f, -0.03673732f, 0.01186340f, -0.00196435f, 
    0.01566355f, 0.01522354f, 0.02952259f, -0.03774437f, 0.02758637f, -0.01105266f, -0.01072684f, -0.03073873f, 
    0.00901420f, 0.00313313f, -0.03711565f, -0.03269726f, -0.01430746f, 0.02683571f, -0.03598296f, -0.00171753f, 
    -0.01269023f, -0.01593060f, -0.02331909f, -0.00326354f, -0.03509706f, -0.01940928f, 0.00755348f, 0.02942872f, 
    -0.03844275f, 0.00131409f, -0.03588213f, -0.03426233f, -0.01044113f, -0.02766921f, 0.01582430f, -0.00450430f, 
    0.00346443f, 0.01461010f, 0.00472339f, -0.03385904f, -0.02068899f, -0.03869390f, 0.00941736f, 0.02220849f, 
    -0.01961256f, 0.01913291f, -0.03207459f, -0.01982468f, 0.01649379f, 0.02632773f, -0.00957432f, -0.02751673f, 
    -0.03467561f, 0.02330441f, -0.02848518f, 0.00101397f, 0.02079660f, 0.00406559f, -0.01202826f, 0.01793569f, 
    0.01836746f, -0.04018797f, -0.01850375f, -0.00917906f, 0.01209034f, 0.00208104f, -0.00591910f, -0.01194102f, 
    -0.00900295f, 0.02657229f, 0.02312031f, -0.03690875f, -0.01875632f, 0.00240355f, 0.00045590f, -0.03032627f, 
    0.02486140f, -0.01360173f, -0.03108303f, -0.04065138f, -0.03170105f, -0.00932449f, 0.00817864f, 0.01149834f, 
    0.01920601f, 0.00607772f, 0.00602844f, -0.03146057f, -0.00946114f, 0.00693468f, -0.02991393f, -0.01796667f, 
    0.00550607f, 0.00386813f, -0.02758464f, 0.00909148f, -0.03634293f, 0.02327803f, 0.00420198f, -0.00702007f, 
    0.02132875f, 0.01650522f, -0.03455772f, -0.02837709f, -0.02719261f, -0.01040962f, -0.03338851f, -0.01869763f, 
    0.01832822f, -0.04149192f, -0.00801108f, 0.01635004f, 0.01062512f, 0.02680058f, -0.02758968f, 0.00384741f, 
    0.01951227f, -0.02477716f, -0.00883780f, -0.02442033f, -0.01831741f, 0.00211556f, -0.01562918f, 0.01977652f, 
    -0.00242415f, 0.01400853f, -0.02768349f, -0.02815883f, 0.00107756f, 0.01699161f, -0.03149645f, 0.02796763f, 
    -0.00010452f, -0.02722784f, -0.04040703f, -0.00160933f, 0.01277899f, -0.02358992f, -0.03579953f, 0.01086679f, 
    0.01026454f, -0.02876326f, 0.02511025f, -0.02380608f, -0.00310590f, -0.01655493f, 0.02576932f, 0.00114465f, 
    -0.01738198f, 0.01207726f, -0.03274272f, -0.01962192f, 0.01026478f, -0.01088573f, 0.02415000f, -0.01420877f, 
    0.02510693f, -0.01476975f, 0.01950620f, -0.01740559f, 0.02897698f, -0.02630782f, -0.02032522f, 0.02553952f, 
    0.02604155f, -0.00779025f, -0.02957331f, -0.02794625f, -0.00636519f, 0.00680189f, -0.01653738f, 0.02142121f, 
    -0.03625447f, -0.04127476f, -0.01600161f, -0.00063757f, 0.01569831f, 0.00353921f, -0.00474541f, 0.02167177f, 
    0.00383068f, -0.02516917f, -0.04155071f, -0.00205760f, -0.03327835f, 0.00540096f, 0.00452905f, -0.02158107f, 
    0.00858734f, 0.01977546f, 0.00744213f, 0.00583422f, 0.01355381f, -0.03066168f, -0.02205711f, 0.01558959f, 
    0.01693780f, 0.00166943f, 0.00024706f, -0.02416763f, 0.01162765f, -0.01801226f, -0.01347830f, -0.02110906f, 
    0.02765651f, -0.00026505f, -0.02753256f, 0.01086976f, -0.01754930f, -0.01484722f, -0.00467466f, -0.04137230f, 
    -0.00076563f, 0.00248916f, -0.01999070f, -0.02810513f, -0.00866894f, 0.02642386f, -0.01774269f, 0.02282512f, 
    -0.01151243f, -0.00530161f, -0.01749237f, 0.02008727f, -0.02508313f, 0.00901080f, 0.00869392f, -0.03835933f, 
    0.00864602f, -0.03066983f, 0.02798631f, 0.01591948f, -0.00421481f, 0.02309138f, -0.03092020f, 0.02406712f, 
    -0.00720113f, -0.00521034f, -0.02068679f, 0.01256077f, 0.00902046f, -0.01633919f, -0.03982749f, 0.02224225f, 
    -0.03367442f, 0.00002532f, -0.01407441f, 0.02515520f, 0.01076047f, 0.02735569f, 0.00995767f, -0.02036110f, 
    0.01415380f, 0.02196471f, -0.01649975f, 0.01890364f, -0.01579363f, -0.00595426f, 0.02161118f, -0.03588556f, 
    -0.01729351f, -0.04167191f, -0.01027182f, 0.00020795f, -0.02721297f, 0.01258543f, 0.01943330f, -0.01938259f, 
    -0.02840767f, -0.02154037f, -0.00696262f, -0.04064881f, 0.01911324f, -0.02180958f, -0.02880377f, -0.01817019f, 
    -0.01089784f, 0.01202180f, -0.00483423f, -0.01572664f, -0.01654440f, -0.02661197f, 0.01192235f, 0.02973298f, 
    0.02653929f, -0.03225954f, 0.00637274f, -0.01734621f, 0.00632591f, -0.00907282f, 0.02140284f, -0.02284053f, 
    0.02003527f, 0.01136272f, -0.03749827f, 0.00316573f, 0.00202293f, -0.01991979f, -0.02650168f, 0.01931172f, 
    -0.00717961f, -0.00680285f, -0.01568784f, -0.01336055f, -0.02983345f, 0.03157362f, -0.01637377f, -0.00290655f, 
    -0.00692166f, 0.00789331f, -0.03906185f, 0.02998417f, 0.02759559f, 0.00101093f, 0.00035820f, -0.01522360f, 
    0.01327806f, -0.01202382f, -0.02101037f, -0.03141005f, -0.03390414f, -0.00341374f, -0.00804158f, -0.00135154f, 
    0.00417161f, -0.00110541f, -0.02400842f, 0.02817811f, 0.02844609f, 0.01847811f, 0.01423497f, -0.00138089f, 
    -0.02387828f, 0.02709913f, -0.03428093f, 0.00024286f, -0.01705107f, 0.01473686f, 0.02638602f, -0.01394785f, 
    0.00318618f, 0.02053284f, 0.01477360f, -0.03203444f, 0.01237157f, 0.02506400f, -0.02372342f, 0.00165034f, 
    -0.03466497f, -0.00506208f, 0.01257136f, -0.00707412f, -0.01019451f, -0.00877811f, -0.01960738f, -0.00878906f, 
    -0.01575393f, 0.00164035f, 0.00783502f, -0.01561707f, -0.03870394f, -0.03711898f, -0.02372981f, 0.00659402f, 
    -0.03168659f, -0.02948431f, 0.01976606f, 0.01372255f, 0.02924141f, 0.00517603f, 0.01524468f, -0.01034861f, 
    -0.02220077f, 0.01314324f, 0.02800239f, 0.00283229f, 0.02229471f, 0.02353273f, -0.03166275f, -0.00477094f, 
    0.02688806f, 0.02584320f, -0.02376420f, -0.02822950f, 0.02515132f, 0.02171620f, 0.02326954f, -0.02466353f, 
    -0.02570708f, 0.00120510f, -0.03789027f, -0.00726945f, 0.00433030f, 0.02899826f, 0.01417179f, -0.01607180f, 
    0.02701398f, 0.01524174f, -0.01433255f, 0.01181431f, -0.03725638f, 0.02743781f, 0.01387473f, -0.02507184f, 
    0.01110691f, 0.02122852f, 0.01316276f, 0.00167335f, 0.02270992f, -0.04075168f, -0.00763122f, -0.02732877f, 
    -0.01182094f, -0.02673884f, 0.02789168f, -0.02847718f, 0.02601554f, -0.03149876f, 0.01355368f, -0.01428308f, 
    -0.00332111f, 0.02950294f, -0.03715894f, -0.01643688f, -0.00529712f, -0.03951449f, 0.01799580f, -0.03534856f, 
    -0.00360848f, 0.02868973f, -0.02920865f, 0.02598892f, 0.00172660f, 0.02592777f, 0.00928492f, 0.01968763f, 
    -0.02452948f, -0.02179383f, -0.00354785f, -0.03855475f, 0.01572965f, -0.02308906f, 0.00583167f, -0.03564039f, 
    -0.03554133f, -0.00472490f, -0.01167409f, 0.01699241f, -0.01377580f, -0.00449819f, -0.02981317f, -0.00789092f, 
    0.00563711f, -0.01777699f, -0.01786465f, -0.02469898f, 0.00051302f, -0.03690483f, -0.03298878f, -0.01975096f, 
    -0.02095827f, -0.01552497f, -0.03539192f, 0.01014476f, 0.02392860f, 0.02772225f, -0.03605235f, 0.01431915f, 
    -0.03540590f, -0.03087500f, -0.01208166f, 0.00644181f, 0.02591369f, 0.01667806f, 0.02779248f, 0.01888548f, 
    0.00632352f, 0.01973774f, -0.03337766f, -0.00908162f, -0.01570569f, 0.00001563f, -0.02428414f, 0.00072045f, 
    0.02015905f, -0.02260945f, -0.00741269f, 0.01588238f, 0.01777589f, 0.02286924f, -0.03610530f, -0.00341275f, 
    -0.04157555f, -0.00930830f, 0.02489221f, -0.03778248f, 0.02216621f, -0.00345752f, 0.01929485f, 0.01938656f, 
    0.00125566f, -0.02115929f, 0.01080406f, 0.01089625f, -0.03888661f, 0.00407620f, -0.00861088f, -0.02378616f, 
    0.03650628f, -0.01165272f, 0.02323060f, 0.02299470f, -0.00332959f, 0.00027860f, -0.00348848f, 0.00459213f, 
    -0.03020222f, -0.02098215f, -0.02448138f, 0.00851161f, -0.00487510f, -0.02552454f, -0.04159791f, 0.01843856f, 
    0.01427979f, -0.02163400f, 0.00734835f, -0.00740822f, -0.03005571f, 0.03377960f, -0.01154979f, 0.01274815f, 
    0.01757320f, -0.00242994f, -0.02302654f, -0.01801652f, -0.02951170f, -0.02409087f, 0.01010478f, 0.00114550f, 
    -0.01914075f, -0.04026885f, -0.00076844f, 0.00931978f, -0.00621863f, -0.02770981f, -0.02366547f, -0.03260881f, 
    -0.04147976f, -0.03783593f, 0.00671176f, 0.02237206f, -0.02304487f, -0.02180809f, -0.01816727f, -0.00359825f, 
    -0.03703191f, -0.02764273f, 0.02550749f, -0.03639065f, -0.00145748f, 0.00579348f, 0.01325623f, -0.00613504f, 
    0.02146085f, 0.03736400f, -0.00525976f, -0.01040413f, 0.02622173f, 0.00782416f, -0.02801865f, 0.03137782f, 
    -0.01595472f, 0.00825957f, 0.02773988f, 0.01736047f, -0.00039881f, 0.01379167f, -0.03342077f, -0.00186815f, 
    0.01890418f, -0.01701882f, -0.00014786f, -0.03176306f, 0.01000985f, 0.02008585f, -0.03652523f, 0.01244395f, 
    0.00581185f, 0.00803568f, -0.01086923f, -0.01797534f, 0.01089072f, -0.00060372f, -0.00023147f, -0.02169588f, 
    -0.00289977f, 0.02179119f, -0.03854978f, -0.03188296f, -0.00074039f, -0.03298130f, 0.01059868f, 0.02635369f, 
    -0.03729891f, 0.00290783f, -0.02998135f, -0.00759901f, 0.01030672f, -0.01277173f, -0.02438951f, -0.02337871f, 
    0.00413883f, -0.00984868f, 0.02359744f, -0.00473686f, -0.02547996f, -0.03546776f, 0.00873628f, 0.01965666f, 
    -0.02549720f, -0.01883729f, 0.02659946f, -0.00277053f, 0.01803378f, -0.00516150f, 0.02610415f, 0.03428664f, 
    0.00023063f, 0.02317869f, 0.02046634f, -0.02666114f, -0.01247256f, -0.00364599f, -0.02354497f, 0.00120587f, 
    0.02291039f, 0.01006993f, -0.01434991f, -0.01065824f, -0.01479296f, 0.02689937f, -0.03948200f, 0.00866555f, 
    -0.04070847f, 0.00435121f, -0.01496516f, -0.01028768f, 0.01108978f, -0.01419511f, 0.01779323f, 0.00246883f, 
    0.01265531f, -0.00236626f, 0.01759783f, 0.02047455f, 0.02334382f, 0.02389937f, 0.02160018f, 0.00094092f, 
    -0.00479823f, -0.03676404f, 0.00355479f, -0.00357291f, 0.00384661f, 0.01982125f, 0.01224886f, -0.02464881f, 
    0.01608840f, -0.02840456f, -0.01275190f, -0.00092603f, 0.02744935f, 0.01496867f, -0.00794007f, -0.00271888f, 
    0.00454897f, -0.02449335f, 0.02902384f, -0.00356977f, 0.00922533f, -0.00852241f, 0.00033684f, 0.00650870f, 
    -0.03851739f, 0.02904613f, 0.00446846f, 0.01064857f, 0.02367155f, 0.01882125f, -0.02881706f, 0.02183047f, 
    0.01154871f, -0.00212353f, -0.00874309f, -0.03698228f, -0.00109534f, -0.03867535f, 0.02056866f, -0.02836429f, 
    -0.04197028f, 0.02110450f, 0.01621272f, -0.03129114f, -0.04011551f, -0.03503832f, -0.00006123f, -0.02343821f, 
    -0.02033586f, -0.03009653f, -0.01980723f, -0.00761964f, -0.03294745f, -0.01492725f, -0.03054814f, -0.03483726f, 
    0.02249570f, -0.02468035f, 0.00988776f, -0.02960059f, 0.02144340f, -0.01606792f, 0.01946374f, -0.03220422f, 
    -0.00250095f, -0.02426986f, 0.00805826f, -0.02229745f, -0.04193878f, 0.01310268f, -0.01579782f, -0.01222215f, 
    -0.02801819f, -0.02189391f, 0.02126069f, 0.00357232f, 0.01084739f, -0.02802233f, 0.00136546f, -0.04160315f, 
    -0.02179113f, -0.00372620f, 0.01043064f, -0.00624767f, -0.01248475f, -0.04329827f, 0.01424222f, -0.04144569f, 
    0.01008430f, -0.03675970f, -0.01049532f, 0.01258315f, -0.01979708f, -0.03187024f, 0.02281245f, -0.03130777f, 
    -0.02550720f, -0.00508629f, -0.03634717f, -0.00998726f, 0.02166785f, -0.01310751f, 0.00736040f, 0.01486060f, 
    0.01770744f, -0.04056364f, -0.03135243f, 0.02806990f, 0.00230142f, -0.00624189f, -0.04030201f, 0.00131570f, 
    0.00745298f, -0.00660290f, 0.00699143f, 0.01057926f, -0.02382019f, -0.01497213f, -0.00856071f, -0.03854261f, 
    0.02999706f, -0.02853281f, -0.01227894f, 0.00024176f, -0.02349248f, 0.00424611f, -0.01837363f, 0.01275107f, 
    -0.01066596f, -0.03728176f, 0.02005988f, 0.01697864f, -0.03628874f, 0.00839214f, -0.03887450f, -0.01563563f, 
    0.02010324f, -0.02797076f, 0.01859475f, -0.02677787f, -0.04027183f, 0.01499486f, 0.00750642f, -0.02747501f, 
    0.01827335f, -0.00184638f, -0.01448377f, 0.00711336f, 0.00779450f, -0.02747937f, 0.01347288f, -0.01972358f, 
    0.02766238f, 0.00640790f, -0.04163246f, -0.03013303f, 0.00432402f, 0.00779166f, -0.01577078f, -0.00353653f, 
    0.01652304f, -0.02733971f, 0.01000904f, -0.03819515f, 0.02785642f, 0.01620403f, -0.00278453f, 0.00516012f, 
    0.01625196f, 0.00766606f, -0.00752180f, 0.01290841f, -0.02935923f, -0.02941707f, 0.03118125f, 0.01089447f, 
    -0.01894302f, -0.01838691f, -0.02837485f, -0.03977461f, 0.02991195f, -0.03359486f, -0.03020232f, 0.01130456f, 
    -0.04101196f, 0.00916213f, -0.02507576f, -0.03505700f, -0.03619469f, 0.01285251f, -0.03620242f, 0.02216292f, 
    0.00034904f, -0.02621451f, 0.01196469f, -0.00385670f, -0.02843977f, 0.00192777f, -0.03899458f, -0.00573331f, 
    -0.04015483f, -0.00455833f, -0.01778428f, -0.03644512f, 0.02819675f, -0.02115036f, -0.01704357f, 0.02363436f, 
    0.02047629f, -0.01512357f, -0.01500876f, 0.00364198f, 0.00317122f, -0.00206990f, -0.00899205f, 0.02744421f, 
    -0.04013319f, 0.01690994f, -0.00765404f, 0.02654515f, -0.00069385f, -0.02672235f, -0.00336991f, -0.00879438f, 
    0.02224814f, -0.03066677f, -0.00083392f, -0.01504415f, -0.02388227f, -0.03407471f, 0.01272608f, -0.02741903f, 
    0.00705874f, -0.02362875f, -0.02731060f, -0.01089278f, -0.01501239f, -0.01468460f, -0.00369760f, 0.02933630f, 
    -0.01705380f, 0.00702388f, -0.03964962f, -0.00503970f, -0.03891153f, 0.01166256f, -0.00171335f, -0.04154026f, 
    0.02897893f, 0.01301895f, 0.01800195f, -0.01463102f, 0.00918616f, -0.02743024f, -0.03156366f, 0.04158560f, 
    -0.00356113f, -0.00043428f, 0.02178261f, 0.03387915f, 0.01594300f, 0.00748301f, 0.00400180f, 0.00947906f, 
    0.00152611f, 0.01466053f, -0.02780919f, -0.02578784f, -0.01338903f, -0.02696158f, -0.02864128f, 0.02360678f, 
    0.00403334f, 0.00334026f, 0.00520724f, -0.03121649f, 0.00898634f, -0.00286638f, 0.00077339f, -0.01975715f, 
    -0.00495186f, -0.03898684f, 0.02338335f, -0.04189158f, -0.00725083f, -0.01505710f, -0.02505048f, 0.00491617f, 
    -0.00463101f, -0.00783435f, -0.00998976f, 0.02008242f, 0.01462172f, 0.01821231f, -0.02147570f, 0.02509259f, 
    0.01399440f, 0.01532904f, 0.00330970f, -0.00925375f, 0.02704271f, -0.03460854f, -0.03136083f, -0.01671299f, 
    -0.01936263f, -0.01908147f, 0.02112141f, -0.01008642f, -0.01413851f, -0.00163279f, -0.03172448f, -0.03756699f, 
    0.03677594f, 0.01973364f, 0.01144588f, -0.01248984f, -0.03355057f, -0.02100546f, -0.01258053f, 0.02674316f, 
    -0.03179357f, -0.03062258f, -0.03765739f, 0.02233647f, 0.02418227f, -0.01019495f, -0.00684332f, -0.02943894f, 
    0.00090435f, 0.02880772f, 0.00717247f, -0.02579973f, -0.01125828f, 0.01814652f, -0.00712935f, -0.03582650f, 
    -0.00784029f, 0.02484720f, 0.01691270f, -0.01180961f, -0.04047574f, 0.00973546f, -0.03328769f, -0.02438200f, 
    -0.01211218f, -0.00860393f, 0.00577666f, -0.02950260f, -0.01953343f, -0.03605957f, -0.01971084f, 0.00929775f, 
    -0.00325871f, 0.00889945f, 0.00616223f, 0.00879051f, -0.00219187f, -0.02077510f, -0.00753093f, -0.03493001f, 
    -0.03366184f, -0.03256170f, -0.01604400f, -0.03981232f, -0.02425857f, -0.02409240f, 0.00960333f, -0.01306718f, 
    -0.01422138f, 0.01782616f, 0.02230336f, 0.00425747f, 0.00969643f, 0.00948907f, -0.01902441f, 0.00965308f, 
    -0.03763660f, 0.02736318f, 0.02050182f, 0.02047567f, 0.00086815f, -0.01469787f, -0.04224536f, -0.01898791f, 
    0.02528105f, -0.00349430f, 0.00780709f, -0.02334091f, 0.01151383f, 0.01195383f, 0.02577884f, -0.01189717f, 
    -0.03989244f, 0.02377921f, 0.00179299f, 0.00389777f, 0.02172088f, 0.02611443f, -0.00567169f, -0.03302303f, 
    -0.00779273f, 0.01543160f, 0.00632787f, 0.02802627f, -0.00998752f, -0.03049993f, 0.02580694f, -0.00701988f, 
    -0.03071315f, -0.00122040f, -0.03301391f, -0.00510665f, 0.02737783f, 0.01884186f, -0.02259115f, 0.00217127f, 
    -0.01301838f, 0.02387865f, 0.00004648f, -0.04158953f, -0.00687045f, -0.01001818f, 0.02036340f, -0.03088173f, 
    0.01915796f, -0.00980438f, -0.00861200f, 0.00766151f, 0.01898943f, -0.02578029f, -0.00486250f, 0.02804047f, 
    0.00738849f, -0.01452238f, -0.02600234f, -0.00665323f, -0.02682838f, 0.00317400f, -0.01096798f, 0.02063338f, 
    0.00927668f, 0.02835888f, 0.00607593f, 0.02370425f, 0.02530778f, 0.00895805f, -0.03371323f, 0.03378537f, 
    -0.00571543f, -0.01715180f, -0.02058123f, -0.03040853f, 0.02082069f, -0.00222062f, -0.01248467f, 0.00670193f, 
    0.00030694f, 0.02164570f, 0.01128474f, -0.02488254f, -0.01785470f, -0.01800721f, -0.01302549f, -0.01607988f, 
    -0.02811947f, -0.03159266f, -0.00769647f, -0.02038483f, -0.02312494f, 0.01156825f, 0.00702735f, -0.03903938f, 
    0.00212631f, -0.02003735f, 0.01919350f, 0.02938378f, -0.02918287f, -0.03421174f, -0.01988412f, 0.02601410f, 
    0.00746984f, -0.03153886f, -0.03258608f, -0.01233565f, -0.03166650f, -0.02469562f, -0.03212273f, 0.01503613f, 
    0.02393692f, -0.04112585f, -0.01510826f, 0.01363354f, 0.01427613f, 0.00037430f, -0.02125872f, -0.02208202f, 
    -0.01924529f, -0.01069357f, 0.03326798f, -0.01322959f, 0.00272083f, -0.04160004f, 0.00885737f, 0.02357962f, 
    0.00038449f, 0.01234992f, -0.00025012f, -0.01408016f, 0.00673843f, 0.01910577f, 0.01923493f, -0.00114387f, 
    -0.02912828f, -0.02635706f, -0.02965618f, 0.00358442f, -0.02249377f, 0.02431793f, 0.02306538f, 0.02477425f, 
    -0.00374774f, -0.00100397f, 0.01984987f, -0.01369989f, -0.00296479f, 0.02002417f, 0.01070341f, 0.02888327f, 
    0.01206871f, -0.04289538f, -0.03883124f, -0.00494426f, -0.00333259f, -0.01704660f, 0.00905691f, 0.01333651f, 
    -0.02089140f, -0.04124831f, -0.02348575f, -0.01432320f, -0.01390160f, 0.00378426f, 0.01354507f, 0.01082606f, 
    -0.02623101f, 0.00788672f, 0.02699447f, -0.00643181f, 0.01036653f, -0.03416011f, -0.01281205f, -0.03954720f, 
    0.00280663f, -0.03041706f, -0.04279070f, 0.02716512f, 0.00855898f, 0.02776058f, -0.01393983f, -0.00172700f, 
    -0.02232373f, -0.01098197f, -0.02536088f, -0.01679035f, 0.01151954f, 0.00643320f, 0.01968802f, -0.01757421f, 
    0.01103990f, 0.00629509f, -0.03052092f, -0.03573408f, -0.00697162f, -0.03999350f, -0.00421426f, -0.01695142f, 
    -0.01084989f, 0.01037048f, 0.06229843f, -0.08761796f, -0.08656126f, -0.09216318f, -0.18698816f, 0.08052497f, 
    0.15862001f, 0.00429835f, -0.11625732f, 0.17732511f, -0.06923842f, -0.01013614f, 0.11309884f, -0.02859629f, 
    0.04989412f, 0.05351535f, 0.19892755f, -0.03885771f, -0.02994061f, 0.08249515f, 0.08224400f, 0.26601383f, 
    0.22424594f, 0.08438635f, -0.00577307f, -0.24883077f, 0.13005863f, -0.08694778f, 0.14557672f, 0.10882903f, 
    0.15045959f, 0.11980455f, -0.00208288f, -0.07314707f, -0.01026020f, -0.01049687f, 0.01329111f, 0.14761305f, 
    0.13036554f, 0.21878675f, -0.03881408f, -0.07974695f, 0.09213842f, 0.14957447f, 0.19205600f, 0.42634481f, 
    -0.31607723f, 0.10253391f, 0.06700440f, 0.12397414f, 0.11373206f, 0.01664816f, 0.07989317f, 0.04135291f, 
    -0.01193832f, -0.11552035f, -0.10919742f, -0.21128780f, -0.10827518f, -0.08572682f, 0.33641833f, -0.19137686f, 
    -0.08120938f, 0.27268445f, -0.12805963f, -0.02387716f, 0.03758994f, -0.11716466f, -0.07073922f, 0.20595486f, 
    0.15684047f, 0.00607981f, -0.03334708f, -0.07020655f, 0.13945611f, -0.01696989f, -0.01999781f, -0.01958244f, 
    -0.01972843f, 0.09908563f, -0.03493353f, 0.12094187f, -0.04649585f, 0.20871200f, -0.06045353f, -0.17611164f, 
    0.02931652f, -0.01766994f, 0.04482932f, 0.11942760f, 0.02459849f, 0.01795443f, -0.01002362f, 0.17071697f, 
    -0.46075442f, -0.00448956f, 0.22241126f, 0.11139139f, -0.15074041f, 0.23490211f, -0.14932384f, -0.23087409f, 
    0.16104960f, 0.03490882f, -0.08288358f, 0.10571193f, 0.20492104f, -0.05708253f, -0.07453519f, 0.19228418f, 
    -0.02919812f, -0.01968815f, 0.07749815f, 0.00589041f, 0.07958028f, 0.08519115f, -0.12370668f, 0.19332911f, 
    0.16455914f, 0.06859025f, -0.02144812f, -0.13342389f, 0.03373678f, 0.11214004f, 0.12696308f, 0.07204951f, 
    0.04762649f, -0.05156285f, 0.05204468f, -0.09925206f, 0.35596907f, 0.14842178f, -0.29413074f, -0.08798280f, 
    0.02717260f, -0.07068465f, 0.05988231f, 0.04755290f, -0.01394001f, -0.05397094f, -0.04662965f, -0.16705076f, 
    0.14845146f, -0.13747647f, -0.20628846f, -0.03310735f, 0.14623769f, 0.06997326f, -0.10975546f, 0.05267557f, 
    0.01857158f, -0.03254364f, 0.05483695f, 0.04941512f, 0.10226655f, 0.31516567f, 0.00288478f, -0.10191603f, 
    0.10515120f, -0.04732078f, 0.03648916f, 0.26212913f, 0.08166636f, 0.08010554f, 0.01551914f, 0.11182449f, 
    0.13477503f, 0.08838984f, 0.00981194f, -0.03222172f, 0.05144854f, -0.05567414f, 0.15273236f, 0.03870897f, 
    -0.03371978f, -0.04388316f, -0.01700067f, 0.01741511f, -0.18897295f, 0.00768919f, 0.18780123f, -0.02001599f, 
    0.15796781f, -0.00992754f, -0.17312810f, -0.05947721f, -0.03481983f, -0.16121852f, -0.03980273f, -0.02933120f, 
    -0.01615784f, -0.14625695f, 0.14055626f, 0.03231164f, -0.01333525f, -0.02673995f, 0.08674402f, 0.01858309f, 
    0.05315017f, -0.02490662f, -0.01162681f, 0.07177953f, -0.47616383f, 0.18646882f, -0.16331704f, -0.25559005f, 
    0.01513830f, -0.07819802f, -0.13223974f, 0.15152325f, 0.01284656f, 0.04233529f, -0.00222945f, 0.03421563f, 
    -0.37536731f, 0.02884003f, 0.09397364f, -0.40607029f, -0.04675381f, 0.07629362f, -0.15075701f, -0.06685656f, 
    -0.08348416f, 0.08385088f, 0.03821576f, 0.09247837f, -0.23649073f, -0.04549279f, 0.26164171f, 0.14965355f, 
    -0.18452084f, -0.08976603f, -0.04378225f, -0.10823938f, 0.02300696f, -0.06805465f, 0.06031112f, 0.21250695f, 
    0.25069109f, 0.15603131f, 0.25582698f, -0.18094613f, -0.08402896f, 0.12081035f, -0.20760261f, 0.15897724f, 
    0.13805954f, 0.20064305f, -0.01775104f, -0.01873563f, -0.24824697f, -0.01653633f, 0.30900648f, 0.23114999f, 
    -0.00585086f, -0.12402341f, -0.01148626f, -0.09812266f, 0.19589479f, -0.09918401f, -0.04610032f, 0.01633509f, 
    -0.01853740f, 0.00950116f, -0.02988851f, 0.11006436f, 0.01671413f, -0.02609992f, -0.05528235f, -0.11469877f, 
    0.18389469f, 0.10785151f, 0.05297541f, 0.18954113f, 0.01561275f, 0.28818402f, -0.04706485f, -0.09205094f, 
    0.04457304f, 0.13160232f, -0.04153812f, 0.11102409f, 0.00120467f, 0.08749016f, 0.03500620f, 0.04563021f, 
    0.18950307f, 0.17793106f, -0.07738342f, 0.06332419f, 0.18820979f, 0.10963446f, -0.05944376f, 0.27605182f, 
    0.08882096f, 0.01278839f, 0.05527516f, 0.14730746f, 0.19709687f, -0.00769189f, 0.16513972f, 0.14553910f, 
    0.13931710f, 0.08144531f, 0.04860345f, 0.03215535f, 0.06652068f, -0.03594067f, -0.05946696f, -0.02297161f, 
    0.02011536f, 0.17256370f, 0.14506242f, 0.06397524f, 0.17972000f, 0.09963353f, 0.05156223f, 0.03956091f, 
    -0.06575703f, -0.09913151f, -0.08328142f, 0.07242738f, 0.35505518f, 0.04077575f, 0.06035682f, 0.17004001f, 
    -0.02637701f, 0.03619385f, 0.13818035f, -0.00215288f, -0.01746217f, -0.11167751f, -0.12187707f, -0.08729851f, 
    -0.13450655f, 0.13998596f, -0.10868472f, -0.32400993f, 0.04944475f, -0.00776033f, -0.04566570f, 0.15897609f, 
    0.12491365f, -0.10503467f, -0.13391356f, -0.15944305f, 0.07413104f, -0.05209533f, 0.03472130f, -0.28867459f, 
    -0.04636636f, 0.17894661f, 0.10066532f, -0.11394729f, 0.01334834f, 0.04900512f, 0.05478484f, -0.10657706f, 
    0.27384162f, 0.06916495f, 0.22891055f, 0.14050369f, 0.19058029f, 0.12939511f, -0.02675394f, -0.17127053f, 
    -0.15403469f, -0.09494301f, -0.08148988f, 0.00429168f, 0.31608182f, 0.01526672f, 0.27275795f, -0.09889983f, 
    -0.11160286f, -0.06498805f, 0.02590710f, -0.14865877f, 0.03572359f, 0.11315793f, -0.01390486f, 0.07591796f, 
    -0.19806612f, -0.16769783f, 0.14633396f, 0.05221671f, 0.02024936f, 0.01253334f, 0.03613480f, -0.15184090f, 
    -0.26088652f, -0.31399497f, -0.03112925f, -0.19069217f, -0.21879731f, 0.12832059f, 0.03770627f, -0.13514405f, 
    0.10174817f, 0.05030773f, 0.05248130f, 0.17247830f, -0.05374823f, -0.01248474f, -0.18603693f, -0.09138762f, 
    0.14194247f, -0.01378794f, -0.52660888f, -0.09614456f, -0.02961022f, -0.35482451f, -0.00040573f, 0.17869952f, 
    -0.00930249f, 0.03070913f, 0.01705503f, 0.03710318f, -0.06358380f, 0.04690544f, -0.06098230f, -0.19060165f, 
    0.04515280f, 0.08688299f, -0.07754957f, 0.07519981f, 0.12162285f, -0.13088349f, -0.10315033f, -0.01500283f, 
    -0.10452296f, -0.07095145f, -0.19009954f, 0.14927515f, 0.05024197f, -0.09163875f, -0.09141142f, -0.09857295f, 
    -0.08732159f, -0.20013690f, -0.05951767f, -0.05210745f, 0.04975795f, 0.05398170f, -0.03461128f, -0.23828574f, 
    0.17171104f, -0.10074642f, 0.11611921f, 0.05813016f, 0.05415801f, -0.01319346f, 0.06016800f, 0.16195172f, 
    0.17643608f, 0.20384778f, 0.09437711f, -0.06118219f, -0.00544945f, 0.00886408f, 0.02697987f, 0.11552279f, 
    -0.01823437f, 0.08095901f, 0.08555596f, -0.06188410f, 0.25824982f, 0.01942583f, -0.05999140f, -0.11485933f, 
    0.09388719f, 0.00440009f, -0.05432804f, -0.10299581f, -0.09774444f, -0.16134742f, -0.12799454f, 0.03940365f, 
    -0.17722028f, 0.01625965f, 0.10458478f, 0.25667000f, -0.01528991f, -0.03718673f, -0.05502986f, -0.20112920f, 
    0.14306545f, -0.04295275f, -0.05353785f, 0.17487182f, 0.23962769f, -0.20481676f, -0.01540013f, -0.05741529f, 
    0.08180781f, -0.05884680f, -0.03354248f, 0.05104020f, 0.16607144f, 0.02568507f, 0.14901350f, 0.15732963f, 
    0.07311320f, 0.13953957f, -0.13093165f, -0.10648549f, 0.12612477f, 0.10157414f, 0.08076930f, 0.15257160f, 
    -0.05243002f, -0.20874429f, -0.20791250f, -0.03268085f, 0.20889592f, 0.16204648f, -0.04064150f, 0.28334951f, 
    -0.05744592f, -0.00512305f, 0.03563376f, -0.02773497f, -0.00973497f, 0.02937816f, -0.09512046f, 0.02218315f, 
    -0.15093639f, -0.06195355f, 0.10812239f, -0.02449675f, 0.07724860f, 0.03980841f, -0.06419494f, -0.22076890f, 
    -0.10623439f, -0.12539886f, 0.03897114f, -0.09212261f, -0.16327265f, 0.00957735f, 0.27054200f, -0.10124790f, 
    -0.01723555f, 0.22245838f, -0.14530315f, -0.00468066f, -0.05499196f, -0.05192889f, 0.04050534f, 0.02443660f, 
    0.10080941f, -0.06674568f, 0.00269266f, -0.15023662f, 0.11633479f, 0.00914058f, -0.17906016f, -0.02087717f, 
    0.11673366f, 0.00533949f, -0.20159972f, -0.14789608f, 0.24820626f, 0.09733728f, -0.12038658f, -0.04677522f, 
    0.04724865f, 0.03318348f, 0.14355227f, 0.16394304f, 0.07286130f, -0.03258258f, -0.05287416f, -0.06779687f, 
    0.13173652f, 0.03751874f, 0.12230226f, 0.38237381f, 0.16840678f, -0.08861900f, -0.12002595f, -0.04298428f, 
    0.00190160f, 0.03339581f, 0.15191658f, 0.03708796f, 0.34349453f, 0.08219870f, -0.01310702f, 0.16597435f, 
    0.04414013f, 0.02868392f, 0.03356181f, -0.11250593f, 0.16842797f, 0.20363870f, 0.03441287f, 0.15341976f, 
    -0.19201317f, 0.06484339f, 0.18990776f, -0.04985370f, -0.00417213f, 0.03113644f, 0.16110556f, -0.21270685f, 
    -0.33643994f, -0.12215177f, -0.06309813f, -0.13970673f, 0.23351796f, -0.13602762f, 0.09746388f, -0.06866518f, 
    -0.05374332f, -0.10592408f, 0.04747764f, -0.20633532f, 0.17772844f, 0.19923088f, 0.08064042f, 0.08229723f, 
    0.24171363f, -0.06625172f, 0.02478461f, 0.00376590f, 0.11616059f, 0.08639906f, -0.00428761f, -0.00429688f, 
    0.02766954f, -0.00577814f, -0.09526000f, 0.00476092f, 0.12466774f, -0.02741157f, 0.21330000f, 0.03861289f, 
    0.09469999f, 0.18213737f, 0.00808950f, -0.00111256f, -0.09795757f, -0.16668795f, -0.01225343f, -0.11080136f, 
    0.12068988f, 0.01259939f, -0.00482717f, -0.06471895f, 0.06344326f, 0.15094699f, 0.11838940f, 0.08496909f, 
    -0.04291734f, 0.02017967f, 0.07128232f, -0.08290819f, 0.22366616f, -0.13504444f, 0.33717307f, -0.23088549f, 
    -0.06884898f, 0.02451915f, -0.17226225f, 0.11300353f, 0.01048208f, 0.01658008f, -0.13408026f, -0.03259398f, 
    -0.08565190f, -0.04921620f, 0.11150546f, 0.20788915f, -0.06342236f, -0.03276526f, -0.07260349f, -0.19007640f, 
    0.01834906f, 0.02004288f, 0.10534629f, 0.12480227f, -0.04755030f, 0.26714945f, 0.00551613f, 0.13161488f, 
    0.15275063f, -0.19118777f, -0.18530640f, -0.07871407f, 0.01985666f, 0.02145850f, -0.01177370f, 0.16882798f, 
    0.15936245f, -0.15734762f, -0.16937943f, -0.03992882f, 0.14204343f, 0.06985002f, -0.05096158f, -0.09256482f, 
    0.11276998f, -0.14854550f, 0.02983999f, -0.07060449f, 0.11762120f, 0.07300016f, 0.09611686f, 0.13616265f, 
    0.09689176f, -0.06488563f, 0.22412276f, -0.20270193f, -0.01464943f, 0.08994008f, 0.03666583f, 0.19566053f, 
    0.11877090f, 0.08876191f, 0.09493076f, 0.00952275f, 0.18339238f, 0.11598426f, -0.01990618f, 0.13870403f, 
    -0.04656142f, -0.10242034f, -0.04384053f, -0.17453068f, 0.20683610f, -0.13303965f, 0.40843228f, -0.03091566f, 
    0.09673852f, 0.08976585f, -0.16086479f, -0.00161733f, -0.03302939f, -0.12766320f, -0.08249184f, -0.00922713f, 
    -0.03954472f, -0.13063440f, -0.22352213f, -0.12628250f, 0.09477378f, 0.08671555f, 0.03382877f, 0.11624128f, 
    -0.06546004f, -0.32850707f, -0.18286179f, -0.12524030f, -0.16515929f, 0.00445545f, 0.14046903f, 0.10214684f, 
    0.01004778f, 0.03881506f, 0.02042673f, -0.18476415f, -0.03652971f, -0.05064126f, -0.14796363f, -0.01384860f, 
    0.01136705f, -0.11933657f, -0.10715787f, -0.05990495f, 0.11089671f, -0.02734849f, 0.00488376f, -0.05942370f, 
    0.13331190f, -0.01965423f, -0.00633403f, 0.02096228f, 0.03538873f, 0.18420506f, 0.20589106f, -0.01319437f, 
    0.06453326f, 0.08839973f, 0.02290830f, 0.05136256f, -0.04445254f, -0.07010990f, 0.00853385f, 0.05426843f, 
    -0.21831793f, -0.32632807f, 0.36217076f, -0.13150194f, 0.07066151f, 0.12963149f, -0.02751452f, 0.05643759f, 
    -0.02526963f, -0.10347105f, -0.13803913f, 0.07825490f, 0.02326150f, 0.04606711f, 0.13747381f, -0.03128823f, 
    0.06837292f, -0.04635698f, 0.09694099f, 0.00794205f, 0.13395874f, -0.07465962f, 0.08861954f, 0.15235743f, 
    -0.15061767f, -0.10317883f, -0.01314357f, 0.26783919f, -0.01238798f, 0.17660192f, 0.05881139f, 0.21634187f, 
    0.01006805f, -0.10252977f, 0.00531859f, -0.08727288f, -0.02839675f, 0.09111007f, -0.41418239f, 0.00075217f, 
    -0.12952784f, -0.02051596f, -0.05941793f, -0.08293713f, -0.01860179f, 0.02670138f, -0.03530652f, 0.19255820f, 
    0.02002047f, 0.14391139f, 0.21394342f, 0.05889192f, -0.00611584f, 0.02634144f, 0.05469402f, 0.06787245f, 
    -0.04596748f, -0.00896071f, 0.01042360f, 0.04580493f, -0.07044166f, 0.07503878f, 0.13488042f, -0.00754482f, 
    0.08052361f, 0.06123232f, 0.01830288f, 0.07883356f, -0.01831909f, -0.01056680f, 0.05825382f, -0.05614224f, 
    -0.09197262f, 0.35959157f, -0.16003293f, 0.00124545f, -0.06141729f, 0.02483851f, 0.16310918f, -0.20152821f, 
    0.11241915f, -0.02215436f, -0.02570093f, -0.01464881f, -0.03811729f, -0.21169595f, -0.04809849f, 0.06635515f, 
    -0.00544700f, -0.02828445f, -0.12673871f, -0.00460393f, 0.03831664f, 0.13200104f, 0.04939510f, 0.09077436f, 
    -0.06999807f, 0.04737404f, 0.27670741f, 0.22195660f, -0.09389738f, -0.03178544f, -0.06420445f, 0.08810173f, 
    0.14097120f, -0.00496652f, -0.00345873f, 0.07991309f, -0.07649392f, -0.05159370f, -0.09108972f, -0.15724950f, 
    0.05198180f, -0.02371078f, 0.04056285f, -0.02578925f, 0.01189427f, 0.08702363f, 0.07537340f, 0.02433572f, 
    0.07959437f, -0.03778001f, 0.03385158f, -0.06600118f, -0.00984524f, -0.01324031f, -0.02177222f, -0.00020490f, 
    0.05207897f, -0.03563370f, -0.15668671f, 0.09243540f, 0.04264195f, 0.01995074f, 0.20104060f, 0.09528130f, 
    0.06984458f, 0.11390430f, -0.04573670f, 0.13438001f, 0.08617265f, 0.05589019f, -0.01523288f, -0.00530682f, 
    -0.04791728f, 0.07283900f, 0.23137675f, 0.28728080f, -0.00466066f, 0.09274751f, 0.12117016f, 0.00069435f, 
    0.01713405f, 0.02060037f, -0.00792021f, -0.08721086f, -0.23349579f, -0.25683761f, -0.03493107f, 0.04234788f, 
    0.00911798f, 0.05338861f, 0.03791336f, -0.01608864f, -0.03502638f, 0.06377579f, -0.09529544f, -0.03051095f, 
    -0.03886260f, -0.05887613f, -0.00384441f, -0.05188105f, 0.09261212f, 0.04140896f, -0.02562718f, 0.09339323f, 
    0.00287258f, 0.01438537f, 0.06327199f, -0.10882526f, 0.12634256f, -0.03815359f, -0.00780339f, -0.00222306f, 
    0.13775451f, 0.10398517f, -0.03891956f, 0.16135369f, 0.02832777f, -0.03808409f, -0.04473913f, -0.10062790f, 
    0.05478981f, -0.09895939f, -0.16544805f, -0.09198150f, 0.05265835f, -0.02806765f, 0.00373272f, 0.05774515f, 
    0.01555816f, 0.09599545f, -0.11437448f, 0.02928710f, -0.14979263f, -0.21824108f, -0.31638995f, -0.06734361f, 
    0.00981480f, 0.08371341f, 0.05648623f, -0.03998689f, 0.03320529f, -0.04827099f, 0.01362309f, -0.04320288f, 
    -0.34024933f, -0.35862872f, 0.06354427f, 0.18902493f, -0.00996897f, -0.01344458f, 0.04324426f, -0.03242126f, 
    -0.01347047f, 0.03562874f, -0.04518879f, 0.02725776f, 0.10795660f, -0.03343575f, -0.50181651f, 0.19116168f, 
    -0.01686904f, 0.07068419f, -0.01386978f, -0.12804087f, 0.13193655f, -0.12647244f, 0.00883042f, -0.03194083f, 
    0.12378213f, 0.42249835f, 0.04472487f, -0.13420652f, -0.04765811f, -0.05077886f, -0.12157723f, -0.04956901f, 
    -0.05444509f, 0.06275257f, 0.09718966f, -0.11888029f, 0.02538430f, -0.22090504f, -0.06060659f, 0.17831226f, 
    0.04260900f, -0.03689133f, -0.06789180f, -0.03488848f, -0.04714463f, -0.05332510f, -0.02221390f, 0.20425318f, 
    -0.15093866f, -0.10317501f, 0.17427240f, 0.05487615f, 0.01289439f, -0.08032222f, -0.06870884f, -0.01682172f, 
    0.12452507f, 0.07781466f, -0.00384369f, 0.05025050f, -0.21268071f, -0.05967619f, 0.07549705f, 0.14375462f, 
    0.08147690f, 0.07215983f, 0.01036014f, 0.11016618f, 0.18299395f, 0.05105150f, 0.03655053f, 0.07408350f, 
    -0.14423142f, 0.01901910f, 0.19389674f, 0.06381068f, -0.11100537f, -0.05252099f, -0.03548110f, 0.06584687f, 
    0.14823560f, -0.01511912f, 0.05931300f, -0.08070263f, 0.07156871f, 0.32768184f, 0.24389723f, 0.19429661f, 
    -0.00096969f, -0.08510623f, -0.04293035f, 0.06086569f, 0.05123448f, -0.07621083f, -0.01992274f, 0.05365457f, 
    -0.18436749f, -0.07620609f, -0.08481644f, 0.29188505f, 0.01127799f, 0.13541198f, -0.00144262f, -0.01174138f, 
    0.08398442f, 0.00229573f, -0.20594580f, 0.23826326f, -0.14369969f, 0.31089547f, 0.05547198f, 0.17210878f, 
    -0.04248231f, -0.07076817f, -0.00157576f, 0.13359670f, -0.07475238f, -0.01500909f, -0.03812683f, 0.14480230f, 
    0.05755633f, 0.03847581f, 0.04949522f, 0.21481498f, -0.07033364f, -0.09533547f, 0.11745639f, 0.06450739f, 
    0.08754376f, -0.00023415f, 0.05730578f, 0.06365322f, 0.04136141f, 0.11577855f, 0.08760718f, 0.19110020f, 
    -0.12488736f, 0.01444952f, -0.07904080f, 0.02866662f, -0.02133995f, -0.01610357f, -0.04842885f, 0.09135789f, 
    -0.12985179f, -0.27379405f, -0.16633348f, 0.09568111f, -0.09425942f, 0.02888076f, -0.01233540f, 0.09416862f, 
    -0.03904961f, -0.09637394f, 0.06135405f, -0.09497762f, -0.13507424f, -0.11665527f, -0.12021099f, 0.19125810f, 
    -0.06353143f, 0.14632900f, 0.06757168f, 0.08658655f, -0.04427566f, 0.01230849f, -0.00632617f, 0.01962827f, 
    -0.05929330f, -0.04736612f, -0.10006098f, -0.23448214f, 0.06351468f, -0.00344303f, 0.06445441f, -0.09901931f, 
    0.15549642f, 0.01380497f, -0.00040597f, 0.00919654f, 0.15758443f, 0.06750351f, -0.15939446f, 0.10730128f, 
    0.09826809f, 0.01784413f, 0.02045902f, -0.00525575f, -0.00987563f, 0.16501656f, -0.18706422f, -0.05004620f, 
    -0.16794738f, -0.06223980f, -0.26737189f, -0.14699481f, 0.04226919f, -0.03213428f, 0.04297907f, 0.02713687f, 
    0.08908191f, -0.01679270f, -0.00285305f, -0.08222063f, -0.09140071f, 0.11546266f, 0.16454880f, 0.05049882f, 
    0.08267691f, -0.03659252f, -0.00923953f, 0.06888761f, 0.03939271f, 0.05887684f, -0.00433764f, 0.11555363f, 
    -0.17623632f, -0.42770362f, 0.21921970f, 0.27818689f, -0.05878251f, 0.06034507f, -0.06033102f, 0.05410818f, 
    -0.08492361f, 0.14964992f, -0.12185538f, 0.06072633f, 0.02177843f, 0.11762893f, 0.07758067f, -0.00964691f, 
    -0.00335905f, -0.15727732f, 0.10454149f, -0.00611639f, 0.08517160f, 0.00215325f, 0.05079790f, 0.01041605f, 
    -0.20130044f, -0.18544002f, -0.23224063f, -0.03806756f, 0.03686693f, 0.00017322f, -0.02451832f, -0.10623262f, 
    0.07458000f, -0.00613491f, 0.06728679f, -0.00170597f, -0.13345422f, -0.11814457f, 0.21159461f, 0.04425425f, 
    0.00783025f, 0.01895282f, -0.13247027f, 0.23855709f, -0.04407760f, -0.05576548f, -0.04514667f, 0.04480936f, 
    0.03350677f, 0.08982902f, 0.37230468f, 0.16773029f, 0.00505223f, -0.15447526f, 0.02621433f, -0.07189748f, 
    0.10111430f, 0.07552429f, 0.00870357f, 0.03553852f, -0.01151045f, 0.22967274f, 0.03835727f, 0.19925635f, 
    -0.08170225f, -0.09314693f, -0.05434907f, 0.10775900f, 0.11251382f, 0.02584321f, 0.00504762f, 0.04985821f, 
    0.07093321f, -0.01679855f, 0.13217033f, -0.02819972f, -0.01615022f, 0.05507261f, -0.06149267f, 0.12874666f, 
    0.06559812f, -0.04360209f, -0.01584932f, 0.01135364f, -0.08622324f, 0.14888953f, 0.00215295f, 0.23779485f, 
    -0.04068574f, 0.07507303f, 0.06108660f, 0.01076250f, 0.01950119f, 0.05738801f, -0.00595234f, 0.08546977f, 
    0.09327814f, -0.13762009f, 0.05982538f, -0.25643751f, 0.08077570f, -0.05550267f, -0.05598968f, 0.00227499f, 
    -0.03322347f, 0.09886375f, 0.01277537f, 0.02545692f, 0.07275420f, 0.24516580f, 0.32885551f, 0.26503012f, 
    0.03664464f, -0.01017991f, -0.00994805f, 0.01005113f, 0.11540954f, 0.03509487f, 0.00734150f, -0.01844249f, 
    -0.02098412f, -0.19939519f, -0.13138357f, -0.01974253f, -0.03127033f, -0.00632920f, -0.01193434f, 0.02989833f, 
    0.02495700f, 0.08140564f, -0.07220691f, 0.01286328f, -0.02280284f, 0.18433988f, 0.21143647f, 0.24381430f, 
    0.02729991f, -0.02060176f, 0.11502218f, -0.11829502f, 0.06459469f, 0.00425585f, 0.08694800f, 0.04815488f, 
    -0.06426564f, -0.16574520f, 0.01078625f, 0.08941471f, 0.10935222f, 0.13200045f, -0.06093660f, 0.09871288f, 
    -0.07961541f, 0.09465385f, -0.07255332f, -0.09380802f, -0.02189726f, -0.11227349f, -0.05605576f, -0.20575255f, 
    0.06464551f, -0.09191117f, 0.01904000f, -0.03949520f, 0.21515340f, -0.08870496f, 0.08906010f, 0.12056085f, 
    -0.02996957f, 0.18369168f, 0.05559306f, 0.08144901f, 0.03748863f, 0.12667575f, 0.05197169f, 0.04367207f, 
    -0.02804184f, -0.04905237f, 0.00076171f, 0.03645270f, -0.12695807f, 0.11346121f, 0.16001834f, 0.07253238f, 
    -0.11156928f, 0.02390505f, 0.00548722f, 0.13445204f, 0.00985241f, 0.07456912f, -0.03074401f, -0.02578214f, 
    -0.11046040f, 0.15803522f, 0.34151164f, 0.27995756f, -0.08177203f, -0.09118018f, -0.07930063f, 0.05362881f, 
    0.04091084f, 0.08933155f, -0.04818970f, 0.05962551f, 0.10620797f, -0.14351642f, 0.02394627f, -0.15323427f, 
    0.03291786f, -0.01891112f, -0.01214114f, -0.05722425f, 0.03953717f, -0.05158639f, -0.00206176f, -0.01432392f, 
    0.22156006f, -0.08409096f, 0.01430011f, -0.06409679f, 0.02186001f, 0.04760532f, -0.00805722f, -0.01178152f, 
    0.11945150f, 0.08065487f, 0.06587984f, 0.16156033f, 0.05751236f, -0.24028580f, -0.12337103f, 0.11681594f, 
    0.04878933f, -0.02765134f, 0.03784072f, -0.00036044f, 0.11181459f, -0.07920093f, 0.01268008f, -0.07861236f, 
    0.04415157f, 0.00047708f, 0.10426403f, -0.04523757f, -0.02414995f, 0.11652929f, 0.00759142f, 0.04914654f, 
    -0.03035550f, 0.05413949f, 0.03090135f, 0.04766746f, 0.04432483f, 0.31263024f, 0.16666883f, 0.02728773f, 
    -0.06735684f, -0.23613276f, 0.06641190f, 0.10867687f, 0.00820103f, 0.02420913f, -0.01129681f, 0.05619399f, 
    -0.05926441f, -0.02752120f, 0.19425139f, -0.02035982f, -0.01511005f, 0.09951408f, -0.04755239f, 0.04218376f, 
    -0.00695217f, 0.11116730f, -0.03000167f, -0.11283252f, -0.04207920f, -0.14592163f, -0.09164923f, -0.01158542f, 
    0.07296118f, -0.09709729f, -0.00781254f, -0.01089893f, -0.03763123f, 0.07467275f, 0.02563824f, 0.05691949f, 
    0.00281907f, 0.06700931f, 0.08981141f, 0.02432339f, -0.00089419f, 0.02075748f, 0.10239673f, 0.01186584f, 
    0.10063839f, 0.03132305f, 0.05399738f, 0.02699379f, -0.21960191f, 0.15908608f, -0.13754867f, 0.18990631f, 
    -0.01497502f, -0.10608073f, -0.02382496f, -0.03642551f, -0.01409165f, -0.11891954f, -0.01547875f, 0.10544925f, 
    -0.07510323f, -0.18885677f, 0.16528833f, 0.07544856f, -0.16102971f, 0.23657820f, -0.00143143f, 0.01022645f, 
    0.02591303f, -0.01876972f, 0.00057574f, 0.13007525f, -0.16419245f, -0.29684320f, -0.05006503f, 0.06370819f, 
    0.01651978f, 0.02421082f, 0.16992581f, 0.18260022f, -0.06154997f, 0.04489775f, 0.07520128f, 0.03550296f, 
    0.04197873f, 0.24798721f, 0.30157316f, 0.02051903f, 0.17434832f, -0.08525228f, 0.13740298f, 0.02034546f, 
    0.00674880f, 0.10137121f, -0.12089888f, 0.06847083f, -0.06180301f, -0.11289897f, -0.17999741f, -0.08864354f, 
    0.05304691f, 0.22951601f, 0.16378395f, 0.07193425f, 0.09822895f, -0.00378794f, -0.02391782f, 0.16758128f, 
    0.15740602f, -0.16994344f, -0.02588199f, -0.01733172f, 0.09431586f, 0.11983938f, 0.08736911f, 0.20055051f, 
    0.01047289f, -0.15017322f, -0.11719281f, -0.15818937f, 0.23356923f, 0.02824717f, 0.15203597f, 0.08851509f, 
    -0.21977884f, 0.04047170f, -0.00714001f, -0.13689739f, 0.17184174f, -0.05040810f, 0.02529465f, -0.10208824f, 
    -0.05631058f, -0.34930316f, -0.27725804f, -0.15967494f, 0.06907631f, 0.03889723f, 0.08894764f, 0.09584871f, 
    -0.09009246f, 0.03420431f, 0.01972858f, 0.04969610f, -0.10368071f, -0.31786734f, -0.20532224f, -0.08588994f, 
    0.00251842f, -0.01080946f, 0.17446521f, 0.13086124f, -0.04194468f, 0.01465527f, 0.08315330f, 0.11531252f, 
    -0.02788037f, 0.36670804f, -0.28936920f, 0.27350426f, -0.14887853f, -0.06193765f, 0.12239841f, 0.08775005f, 
    0.05062113f, 0.01531917f, 0.09367747f, -0.14605917f, 0.12260281f, 0.28254855f, -0.05162247f, -0.21318823f, 
    -0.09847767f, 0.06282846f, 0.02692096f, -0.04749661f, -0.08803590f, 0.06101898f, 0.10362097f, -0.08484604f, 
    0.13778043f, 0.03904686f, -0.06428241f, -0.14733332f, 0.15710297f, 0.07079110f, 0.11026427f, 0.02452426f, 
    0.10577104f, -0.08020812f, -0.08042879f, -0.10838965f, -0.21081059f, 0.02826171f, -0.12069583f, 0.09228659f, 
    0.03955855f, 0.08976644f, -0.00656282f, 0.01595856f, 0.03378195f, 0.12596527f, 0.01792585f, -0.04370667f, 
    -0.05488513f, -0.03880879f, -0.20804429f, -0.09709145f, 0.14706126f, -0.01325378f, -0.01916778f, -0.09749843f, 
    0.00875069f, 0.02362692f, -0.01814094f, 0.00307777f, -0.06920246f, 0.00498345f, 0.19910851f, 0.11010396f, 
    0.01026637f, 0.06946345f, 0.16442156f, 0.12309095f, 0.04994617f, -0.07242775f, 0.07485264f, 0.12624307f, 
    0.03163531f, -0.01422157f, 0.03702786f, -0.04771293f, 0.12970686f, -0.03532177f, -0.03968929f, 0.00396414f, 
    0.01136702f, -0.08742033f, -0.05503134f, -0.03655825f, 0.06195262f, -0.19699018f, 0.11180270f, -0.18105656f, 
    -0.02422176f, -0.06528515f, -0.03588803f, -0.12860745f, -0.03680205f, -0.08160537f, -0.07737178f, -0.10314318f, 
    -0.05741686f, -0.09606536f, 0.02432290f, -0.09614377f, 0.10644440f, -0.02745819f, 0.13536988f, 0.17300522f, 
    -0.03569873f, 0.15257886f, -0.15172392f, 0.13998772f, 0.12799408f, -0.13567571f, -0.04826835f, 0.09554605f, 
    -0.05181993f, 0.19594039f, 0.01772468f, 0.14044330f, -0.06121119f, -0.05919670f, 0.08486219f, 0.00179172f, 
    0.01336599f, -0.28181592f, -0.01744144f, -0.19281332f, -0.17465615f, 0.06516628f, -0.14916590f, 0.02107147f, 
    -0.07742405f, -0.06049421f, 0.06697722f, -0.14111030f, 0.13920316f, -0.27286819f, -0.01475624f, -0.12425258f, 
    -0.08468323f, 0.07161560f, -0.08567414f, 0.02257540f, 0.01932803f, 0.03267904f, -0.00055438f, 0.07639017f, 
    0.13008550f, 0.13015063f, 0.19442014f, -0.34800661f, -0.02102649f, 0.16712520f, 0.00823763f, 0.09113326f, 
    0.09326989f, 0.09227911f, 0.13670874f, -0.01947124f, -0.01625320f, 0.10167401f, 0.26483414f, 0.06022347f, 
    -0.20112650f, -0.03485016f, 0.02359769f, -0.03409698f, 0.02483763f, 0.12210961f, 0.07154845f, -0.05836911f, 
    -0.22836316f, 0.23876075f, -0.15719600f, 0.17822555f, -0.14123590f, -0.04733594f, 0.10908658f, 0.06641029f, 
    0.01986387f, 0.08641778f, 0.02492822f, 0.07753696f, 0.20681471f, 0.12449572f, 0.22688319f, 0.01094617f, 
    -0.03599111f, 0.26115069f, 0.00544661f, 0.00897077f, 0.08116294f, 0.03820796f, 0.05914159f, 0.17588899f, 
    0.04150066f, 0.13109489f, -0.10530865f, 0.02988286f, 0.18505217f, 0.17574991f, 0.12867253f, 0.19024658f, 
    0.09520802f, 0.02612975f, 0.09734344f, 0.02675813f, 0.29964986f, 0.01303104f, -0.13870710f, 0.07119618f, 
    0.14168517f, -0.10142916f, 0.05885098f, -0.04222536f, -0.06716780f, 0.02281210f, 0.21773572f, 0.04453145f, 
    0.03875737f, -0.16540439f, -0.16649663f, -0.05353877f, 0.09441070f, 0.01165923f, 0.02147721f, 0.10208245f, 
    0.03734902f, -0.01147045f, 0.19957304f, 0.13479494f, 0.32346299f, -0.14856429f, -0.22949825f, -0.13816792f, 
    0.07420114f, 0.04989837f, -0.06627036f, -0.10896192f, 0.05364377f, 0.04000142f, 0.05527355f, 0.04821431f, 
    0.11148486f, 0.10925064f, 0.20626625f, -0.16584730f, 0.15696190f, 0.07773267f, 0.19363888f, 0.04718217f, 
    0.11904033f, 0.01346147f, -0.05898071f, -0.01393095f, 0.03260778f, -0.04368266f, -0.19461758f, -0.19772160f, 
    0.09780592f, 0.12272130f, 0.01841196f, -0.00863529f, -0.13053182f, -0.04966879f, -0.02662473f, 0.14764196f, 
    0.06440456f, -0.01834993f, -0.16743584f, -0.01119928f, 0.11891913f, -0.01905312f, 0.01347206f, -0.04678588f, 
    0.04712773f, 0.00307246f, 0.03075630f, 0.10222068f, 0.27739793f, -0.29517308f, 0.22224140f, -0.32084984f, 
    0.14963664f, 0.05526090f, -0.02154185f, -0.02550497f, 0.02491569f, 0.02614027f, -0.00203202f, 0.02873768f, 
    0.13637425f, -0.19765644f, -0.00297299f, -0.08358001f, 0.10428102f, -0.08893397f, -0.04347857f, -0.06096416f, 
    -0.07695441f, -0.06116788f, -0.30467486f, -0.06362881f, 0.05343900f, 0.05145923f, 0.03989465f, -0.03712227f, 
    -0.03394630f, 0.00074334f, -0.09876348f, -0.08097062f, -0.03347601f, -0.02333118f, -0.08321349f, -0.04384209f, 
    -0.08302596f, -0.00318332f, -0.32529125f, 0.01045910f, -0.06007740f, -0.08428704f, 0.08068221f, 0.07011897f, 
    -0.07060905f, 0.00512262f, 0.09204482f, -0.06437145f, -0.07605639f, -0.05191074f, 0.13354203f, -0.05371257f, 
    -0.18919900f, 0.13338649f, -0.10700004f, -0.15023649f, 0.01780794f, -0.10683127f, -0.04960784f, 0.00803783f, 
    -0.21925749f, 0.15813862f, -0.10916150f, 0.15028678f, 0.13561018f, -0.12635803f, -0.07511181f, 0.06711117f, 
    -0.01660149f, -0.00169290f, 0.13688506f, -0.16289793f, 0.00149499f, 0.10886600f, -0.13756490f, 0.14709216f, 
    0.10995310f, 0.07075515f, 0.17103715f, 0.06741495f, -0.02708203f, -0.00453279f, 0.02801073f, 0.07527997f, 
    0.06438401f, 0.34334093f, 0.25746235f, -0.17854469f, 0.01354906f, 0.11838774f, -0.04640634f, 0.12838775f, 
    0.02079066f, 0.19238830f, 0.07015487f, 0.07135769f, 0.20297924f, -0.13700168f, -0.21695955f, 0.00665380f, 
    0.00736733f, 0.07657055f, 0.03783362f, -0.12875974f, 0.03309736f, 0.02183306f, -0.04530148f, -0.00359295f, 
    -0.05204361f, -0.18115222f, -0.12028368f, -0.02447590f, -0.10588492f, -0.01731854f, 0.09324757f, -0.03934226f, 
    0.06943927f, 0.05999007f, -0.01473902f, 0.00855133f, 0.08185855f, 0.25339431f, -0.15974283f, -0.14654727f, 
    0.06320865f, 0.18926874f, 0.08982070f, 0.09206784f, 0.08241727f, -0.04471952f, 0.10721263f, 0.02890302f, 
    0.09415380f, -0.09420429f, -0.04209362f, -0.03737240f, 0.10431862f, 0.07602886f, 0.17445105f, -0.02637133f, 
    -0.02780757f, -0.11382429f, -0.02529019f, -0.00179870f, 0.34065026f, 0.15022270f, -0.26712829f, -0.13939507f, 
    0.11479730f, 0.13809551f, -0.04021749f, -0.04825057f, 0.07065372f, 0.06024199f, -0.02463879f, 0.04201578f, 
    -0.00177968f, 0.05027009f, 0.12625906f, 0.13444985f, 0.03797815f, -0.15356393f, -0.10493915f, -0.10781455f, 
    -0.09297569f, -0.00483248f, -0.05984752f, -0.25169429f, 0.15032317f, -0.16597624f, 0.09434110f, 0.15021741f, 
    -0.20689899f, 0.06340797f, -0.02064041f, -0.01016359f, -0.03651502f, -0.01031708f, -0.07577845f, -0.14724475f, 
    -0.04945535f, -0.14734775f, -0.07415388f, -0.19763412f, 0.01098339f, -0.08857676f, 0.03983707f, -0.22330661f, 
    0.04481056f, -0.10105701f, -0.04298707f, -0.11985822f, 0.28354475f, 0.23041260f, 0.09249824f, 0.15021510f, 
    0.14460783f, 0.03552700f, 0.12317733f, 0.26590922f, 0.00902996f, -0.00665192f, -0.14486390f, -0.10998100f, 
    0.05295184f, 0.15265751f, -0.06035698f, -0.12040965f, -0.24002689f, 0.07495125f, 0.08769464f, -0.10113654f, 
    -0.15557513f, 0.17228471f, 0.08174715f, 0.18401578f, 0.14222245f, 0.03862488f, 0.13578629f, 0.07046955f, 
    0.01922959f, 0.02843584f, 0.05001800f, 0.03018288f, 0.15818907f, 0.06409190f, 0.03941346f, -0.07483418f, 
    0.18337874f, -0.05670961f, 0.13240984f, -0.34258789f, 0.12270266f, 0.07066653f, -0.02464612f, -0.14258055f, 
    -0.00507233f, -0.01439930f, 0.08642180f, -0.20183182f, -0.12938397f, -0.28610420f, 0.01135476f, -0.09944619f, 
    0.06357173f, -0.03310397f, 0.11750738f, -0.00249036f, 0.18771587f, 0.04662589f, 0.14195466f, -0.03384643f, 
    0.11813198f, 0.05346016f, -0.07240086f, 0.19571003f, 0.07937256f, 0.16142116f, 0.11524261f, 0.05821614f, 
    0.01617103f, -0.01864358f, 0.06225183f, 0.01599726f, 0.13373482f, -0.10733765f, -0.07765067f, -0.08799536f, 
    0.11935603f, 0.14265639f, 0.03333174f, 0.00316221f, -0.05190990f, -0.10428391f, 0.02483137f, 0.02843267f, 
    0.19158864f, -0.11021229f, -0.07488865f, -0.11112885f, 0.19908939f, 0.17362697f, 0.06460219f, 0.13794301f, 
    0.01949663f, -0.04810860f, -0.05282797f, 0.05727564f, 0.14534533f, -0.00178102f, 0.22208531f, -0.40350923f, 
    0.00253338f, 0.24072286f, 0.05496389f, -0.02482190f, 0.19234125f, 0.14595355f, 0.06861928f, 0.02895579f, 
    -0.07471109f, -0.07740973f, 0.03712471f, 0.04578008f, -0.17035264f, -0.00439085f, 0.00924472f, 0.04559442f, 
    0.10333119f, 0.00416095f, 0.07408417f, 0.04501636f, -0.02431451f, 0.23890650f, -0.06046598f, -0.00085578f, 
    -0.13838401f, -0.17634374f, 0.00803956f, -0.04869429f, 0.01630811f, 0.06088671f, 0.10018815f, 0.22452806f, 
    0.09729808f, 0.08096237f, -0.30259177f, -0.21529472f, -0.03487880f, 0.00885420f, -0.01385329f, -0.07480719f, 
    0.01676023f, -0.17607982f, -0.03328080f, 0.08190520f, 0.19637540f, -0.35970354f, -0.09929776f, 0.10519229f, 
    0.22086151f, 0.03678366f, 0.02320044f, -0.03361439f, 0.04298373f, 0.03619839f, 0.05014560f, 0.04743966f, 
    0.08421110f, 0.11514640f, -0.18615969f, 0.08544921f, 0.20973442f, -0.08738953f, 0.05439007f, -0.00617885f, 
    -0.13489184f, 0.10181532f, 0.06724480f, 0.20642407f, 0.04494404f, -0.16610023f, 0.02869331f, -0.21719579f, 
    -0.08122888f, 0.11999522f, 0.01179600f, -0.13321485f, -0.02558417f, -0.04080984f, 0.01186969f, -0.03952213f, 
    -0.06622995f, 0.04462932f, -0.29435250f, -0.03124133f, -0.02782850f, 0.11356561f, 0.00875878f, -0.14027022f, 
    -0.08693137f, -0.02081531f, -0.22636278f, -0.07074712f, 0.19350091f, 0.14448167f, 0.13067918f, 0.09455354f, 
    -0.10669825f, -0.03897992f, -0.06838144f, -0.16469628f, 0.06542072f, 0.07187720f, 0.11006038f, -0.09370530f, 
    -0.24860595f, 0.04435208f, -0.09212483f, 0.14301267f, 0.06289586f, -0.06196091f, -0.03393057f, -0.08190307f, 
    -0.04767956f, 0.03719167f, -0.14162956f, -0.10750106f, 0.00512745f, 0.01216236f, -0.17651877f, 0.11865438f, 
    0.04870600f, 0.12702535f, -0.12965517f, 0.09480590f, 0.01025444f, -0.00459572f, -0.03407786f, -0.01180259f, 
    0.07327785f, 0.41960984f, -0.22135152f, 0.11963743f, -0.17552763f, -0.10540184f, -0.04028409f, 0.00677595f, 
    -0.12870988f, 0.08801169f, -0.10765614f, -0.03914083f, 0.15063979f, 0.10260011f, -0.05357695f, 0.10924722f, 
    0.00818866f, 0.01030661f, 0.08573808f, 0.12920821f, 0.03578866f, -0.03298905f, 0.02602114f, -0.10530206f, 
    -0.15858681f, -0.17470483f, 0.17968470f, 0.13989067f, 0.14884062f, 0.01188743f, -0.05674790f, -0.00590881f, 
    0.04818677f, 0.03874460f, 0.04308013f, 0.05594805f, 0.01224170f, -0.10122838f, 0.06128747f, 0.28459987f, 
    0.06285745f, -0.21665211f, -0.04729649f, -0.01779721f, -0.01932326f, -0.10986263f, 0.04479043f, 0.08323562f, 
    0.10125178f, -0.01724088f, 0.07179765f, 0.07815236f, 0.24452455f, 0.09676746f, 0.02067015f, -0.06800409f, 
    -0.00802276f, 0.00506200f, -0.01200152f, 0.22382098f, 0.23644044f, -0.03778045f, 0.12788384f, 0.15333474f, 
    0.07176738f, 0.13914597f, -0.09066905f, 0.03932606f, -0.02076166f, 0.03997058f, 0.10224865f, 0.16702110f, 
    0.35426342f, -0.31540862f, 0.00810626f, 0.27089784f, 0.12999372f, -0.13159984f, 0.03169278f, 0.01299987f, 
    -0.21808437f, -0.02664716f, 0.00581652f, 0.01688249f, -0.16732600f, -0.04338065f, -0.04130146f, -0.23514350f, 
    0.10070417f, -0.05039746f, 0.03027850f, -0.03329425f, -0.18336457f, -0.03826895f, 0.12933919f, 0.00360783f, 
    0.12650010f, 0.17386131f, -0.05355969f, 0.02109186f, 0.10434189f, 0.06093578f, 0.01538529f, -0.02098417f, 
    0.14254956f, -0.02508198f, -0.02498723f, 0.01328038f, -0.31473252f, 0.02849645f, -0.07099950f, 0.12916441f, 
    0.08111874f, -0.02823145f, -0.14053752f, -0.12632607f, 0.03254199f, -0.08605065f, 0.08091632f, 0.16428031f, 
    -0.30035806f, -0.08597484f, 0.15254277f, 0.01447654f, -0.02795807f, 0.01812501f, -0.00012603f, 0.02063262f, 
    -0.04519282f, -0.09718667f, 0.00485691f, 0.01789923f, 0.10257331f, 0.02874541f, 0.04923703f, 0.16955040f, 
    -0.00997612f, 0.08989765f, -0.01005376f, -0.03682296f, -0.03860927f, 0.02531446f, -0.03033082f, -0.01565695f, 
    0.19810736f, 0.12357035f, 0.19453658f, 0.11663524f, 0.16677129f, 0.15813880f, 0.03412008f, 0.04338307f, 
    0.05515129f, -0.04853875f, 0.03057549f, 0.08135302f, -0.05197535f, -0.00652249f, 0.00741834f, -0.11591507f, 
    -0.04231684f, -0.02241608f, -0.01644354f, 0.04235307f, -0.01477125f, -0.03834110f, -0.00190532f, 0.09340420f, 
    0.02566106f, 0.05267786f, -0.01167631f, 0.09179765f, -0.01361021f, -0.14587495f, -0.07041798f, 0.08450142f, 
    -0.05137348f, 0.29579923f, -0.02344961f, -0.01392746f, -0.08823825f, -0.00902649f, 0.05314179f, 0.23029755f, 
    0.12099949f, 0.10611261f, 0.04548407f, -0.04006573f, 0.11997882f, 0.02531685f, 0.06680021f, -0.01788343f, 
    -0.08819224f, -0.05131806f, -0.11112004f, 0.15665399f, 0.05391226f, -0.03970574f, -0.09115402f, -0.08187864f, 
    0.03592827f, -0.12536344f, 0.03983456f, 0.04241523f, -0.12323330f, 0.07567464f, -0.03094002f, 0.06973112f, 
    0.04031118f, 0.03271748f, -0.05587522f, -0.00606144f, -0.01907716f, 0.04989310f, -0.05126823f, 0.02489001f, 
    -0.34448916f, 0.28329843f, 0.02382972f, -0.00521281f, 0.15122074f, -0.02777055f, 0.27732137f, 0.03191819f, 
    -0.04972516f, 0.04533473f, -0.05198820f, 0.06462947f, 0.28978392f, -0.13627337f, 0.07549929f, 0.00407254f, 
    0.01515771f, -0.06136231f, -0.01273757f, 0.11293364f, -0.07049919f, 0.05519997f, -0.01351846f, -0.00286807f, 
    -0.06276834f, -0.02974910f, -0.03725318f, 0.22039659f, -0.08839878f, 0.10311316f, -0.20940928f, 0.06022594f, 
    -0.21069284f, -0.19371010f, 0.14651333f, 0.03647267f, 0.22353688f, 0.01539668f, 0.28059864f, -0.01464090f, 
    0.09452171f, -0.06802555f, 0.13908498f, 0.07100122f, 0.02396107f, 0.03534168f, -0.09482165f, -0.13424787f, 
    0.01713912f, 0.20650569f, 0.07863582f, 0.06661501f, 0.06624962f, 0.09222502f, 0.16584057f, -0.12884229f, 
    0.03490088f, 0.01437226f, 0.05662997f, 0.02905037f, 0.19718736f, 0.28753227f, 0.01026216f, -0.05265025f, 
    -0.05788988f, -0.04770684f, 0.04278797f, -0.05736155f, 0.12741998f, 0.09003285f, 0.16468333f, 0.05054874f, 
    0.14850982f, 0.05344839f, 0.11247704f, 0.22345020f, -0.02432009f, 0.06592614f, 0.04594777f, -0.07971999f, 
    0.06174774f, 0.04166157f, 0.10994457f, 0.02072296f, -0.41847333f, -0.23165536f, -0.04876833f, -0.02103345f, 
    0.18019678f, 0.17621319f, 0.01943914f, 0.05786264f, 0.11208691f, 0.19372436f, 0.04142638f, 0.00238645f, 
    0.35935646f, -0.18774717f, 0.06641537f, 0.14709213f, 0.03494385f, -0.04909497f, 0.01332363f, 0.13030663f, 
    0.04096058f, 0.09114652f, 0.11431891f, 0.15373574f, -0.06563701f, -0.01847715f, -0.06044336f, 0.33616233f, 
    0.24057166f, 0.06985699f, 0.04436972f, 0.07604710f, -0.00862994f, 0.06581544f, -0.13160880f, -0.11936671f, 
    0.06265861f, 0.13843668f, -0.02710625f, 0.15542831f, 0.03254454f, 0.07521584f, 0.02077611f, 0.10766393f, 
    0.14251597f, -0.03038563f, -0.07317802f, 0.10733276f, -0.18750077f, -0.13933940f, -0.07648472f, 0.04761219f, 
    0.09961841f, 0.02408414f, 0.03148994f, 0.15267451f, 0.06213954f, 0.09860997f, -0.00465910f, -0.03553346f, 
    0.04196572f, -0.05271659f, 0.00339681f, -0.00869205f, -0.02799269f, 0.04727777f, -0.11588633f, 0.03320637f, 
    0.01352710f, 0.09200701f, -0.01612772f, 0.07433525f, 0.08218284f, 0.03241682f, 0.08309796f, -0.07020431f, 
    0.09924777f, -0.06692465f, -0.05184914f, -0.07854817f, 0.07120155f, -0.04380236f, -0.02755176f, 0.02733228f, 
    -0.20576829f, -0.16173467f, 0.09561259f, -0.02438469f, 0.03889147f, 0.10478603f, 0.00143701f, -0.01381839f, 
    -0.11804936f, -0.06308658f, 0.07439283f, 0.06416190f, -0.14851198f, -0.08921753f, 0.11896751f, 0.04040266f, 
    0.02205890f, 0.07926586f, -0.05529034f, -0.01741443f, -0.04734456f, 0.00500009f, -0.08655128f, 0.07244005f, 
    -0.22490688f, -0.10561369f, 0.00470594f, 0.05335379f, 0.05645396f, 0.06284691f, -0.02547204f, 0.03344330f, 
    -0.02520090f, 0.01265426f, 0.07655383f, 0.07058455f, 0.07211421f, 0.23450167f, -0.05220669f, 0.26644906f, 
    0.02670901f, 0.05497454f, 0.02681731f, -0.03750645f, 0.03747702f, 0.09186380f, -0.07732818f, -0.13773167f, 
    -0.30842894f, 0.33484012f, 0.03232592f, 0.02717377f, 0.00331776f, -0.14589597f, 0.14242668f, -0.08945773f, 
    0.01984743f, -0.03799311f, -0.05780369f, 0.08165190f, -0.13385619f, 0.01132669f, -0.01024807f, 0.12052894f, 
    0.05452492f, 0.14628354f, 0.06913074f, -0.02449790f, 0.00540924f, 0.13757515f, 0.16587684f, -0.09137890f, 
    -0.04147922f, -0.00149065f, 0.01686349f, 0.01848633f, 0.05641575f, 0.02843170f, -0.05026458f, -0.04156268f, 
    -0.03561444f, 0.04530242f, 0.01709065f, -0.08847547f, -0.24194257f, 0.14522758f, -0.24174717f, -0.12170033f, 
    0.17599785f, 0.05895992f, 0.20856266f, 0.06923943f, -0.13281132f, 0.11914820f, 0.07636511f, -0.02932226f, 
    0.25414965f, 0.07933124f, 0.20807926f, 0.10763774f, 0.05443246f, 0.18063736f, 0.12804286f, -0.04488835f, 
    -0.03495085f, 0.06310786f, 0.07478575f, -0.03874826f, -0.02947173f, -0.31339318f, 0.01865348f, -0.17920335f, 
    0.10384275f, 0.10210286f, -0.03754791f, 0.13071358f, 0.13192947f, 0.12813240f, -0.03991311f, -0.00453936f, 
    -0.04838739f, 0.09398201f, -0.20122005f, -0.01751630f, -0.14617273f, 0.10035068f, -0.06169593f, 0.07648361f, 
    -0.01116241f, -0.01168543f, 0.04357113f, 0.08270963f, 0.26565588f, 0.05175356f, 0.05713529f, 0.16020733f, 
    -0.04770980f, -0.07022814f, 0.05683342f, 0.07559144f, 0.01253764f, -0.03148231f, 0.00372077f, 0.06871524f, 
    -0.34622809f, 0.05851341f, -0.00481810f, 0.15591794f, 0.05397377f, -0.02904105f, 0.07181032f, 0.07626051f, 
    0.03796939f, -0.01153838f, 0.00709393f, -0.00926633f, 0.25588310f, 0.00250724f, 0.16318476f, 0.10493755f, 
    0.13067104f, 0.18016922f, 0.06045885f, 0.15489775f, 0.01641188f, 0.06431709f, -0.05934826f, -0.01464008f, 
    -0.26736489f, 0.06180158f, 0.04235359f, -0.21924800f, -0.00036247f, -0.06322243f, -0.05469297f, 0.05418761f, 
    -0.13041818f, -0.03992799f, 0.03520007f, 0.08472713f, -0.04622028f, 0.07708267f, 0.05867685f, -0.13125788f, 
    0.10081244f, 0.09811553f, 0.14211680f, 0.14030078f, -0.08853272f, 0.15580106f, -0.05084851f, -0.09975993f, 
    -0.06043833f, 0.16863681f, 0.00977647f, -0.20176558f, 0.06369638f, -0.12708846f, -0.02399281f, 0.07540181f, 
    0.07222026f, 0.04887552f, 0.13412043f, 0.07590237f, -0.25710225f, -0.07859110f, -0.19211338f, 0.03778861f, 
    -0.00644308f, 0.06750874f, -0.02327638f, 0.06882405f, -0.07663394f, -0.06429783f, -0.02154033f, -0.18696041f, 
    0.02940734f, 0.21242797f, -0.05711471f, 0.15956408f, -0.01013560f, -0.07071591f, 0.04528842f, 0.00286522f, 
    0.08016947f, -0.03128693f, 0.03979929f, 0.06978285f, -0.02187003f, 0.06424528f, 0.02606370f, 0.06659550f, 
    0.10768084f, 0.04491499f, 0.10961859f, -0.14346145f, 0.28142607f, 0.00093979f, -0.04179482f, 0.14075011f, 
    0.14375900f, 0.11669473f, -0.04628110f, 0.14199431f, 0.28045747f, 0.20716853f, -0.03806588f, -0.06011415f, 
    0.02370632f, 0.01115713f, -0.02999075f, 0.02311758f, -0.28207260f, 0.02741081f, -0.08637020f, 0.01247791f, 
    0.06673065f, -0.02688201f, 0.04234455f, -0.05748881f, 0.13830352f, 0.03628229f, 0.17828447f, 0.09228458f, 
    -0.01179834f, -0.03972850f, -0.19201064f, 0.05682998f, 0.01446614f, 0.01991206f, 0.02046491f, 0.02213342f, 
    0.10804746f, -0.14378117f, -0.05150908f, -0.06145432f, -0.01376574f, -0.16911498f, 0.29781899f, 0.07702636f, 
    0.06367800f, -0.05958660f, -0.06040579f, 0.05356367f, -0.06898857f, 0.01225637f, 0.21971975f, -0.00382716f, 
    0.02474968f, 0.08704313f, -0.04886710f, -0.05239513f, 0.07913088f, -0.01915221f, -0.04361553f, 0.04830006f, 
    -0.03747369f, -0.09512448f, 0.00655191f, 0.07397684f, 0.17098355f, -0.12925145f, -0.13019370f, 0.18046653f, 
    0.14704143f, 0.10958803f, -0.03385101f, 0.18649282f, 0.08286182f, -0.06236284f, -0.12073684f, -0.15164483f, 
    0.06451273f, 0.23905271f, -0.15652175f, 0.13117573f, 0.09438595f, 0.00509602f, 0.02267708f, -0.02718019f, 
    0.03954633f, 0.00158018f, 0.14566197f, 0.12233932f, -0.16028510f, 0.06114220f, -0.09307844f, -0.08931630f, 
    -0.11511862f, -0.10048928f, 0.04349934f, 0.03900690f, 0.02629702f, 0.15947543f, 0.08332767f, 0.06021125f, 
    0.02821356f, 0.11192249f, 0.03932751f, -0.03622110f, 0.02765016f, 0.09745373f, -0.05848874f, -0.06985086f, 
    0.05718041f, 0.08771089f, -0.00693905f, -0.00871438f, 0.12840208f, -0.04012329f, 0.01468140f, -0.04827923f, 
    -0.04150915f, -0.05202991f, -0.04169198f, 0.04507820f, -0.03279643f, 0.11830602f, -0.02511189f, -0.06698227f, 
    -0.13771714f, 0.18919764f, 0.10675942f, 0.01932995f, -0.09297658f, -0.04736705f, -0.05324146f, -0.09660824f, 
    -0.13377537f, 0.02048918f, -0.07524546f, -0.04624300f, -0.20711474f, -0.05803703f, 0.08690416f, 0.24730150f, 
    0.02448072f, 0.06368283f, 0.20492838f, -0.04868087f, 0.05256949f, 0.07722244f, -0.03837174f, 0.02808662f, 
    0.30038881f, 0.28180751f, -0.00747205f, -0.04226062f, -0.10567167f, 0.04638315f, 0.10131660f, -0.11883815f, 
    0.02403468f, 0.03893491f, 0.00874667f, -0.03231593f, 0.10483351f, -0.09084175f, -0.00865247f, 0.13247773f, 
    0.05637879f, 0.09577356f, 0.06276093f, 0.06370158f, 0.03226340f, -0.02662094f, -0.00691088f, -0.18403681f, 
    -0.16795184f, 0.23907372f, 0.03005293f, -0.06543683f, 0.01386080f, -0.23625685f, -0.08326527f, -0.04442858f, 
    0.05504047f, 0.01317086f, 0.02200696f, 0.03443477f, -0.21423401f, 0.10239769f, 0.21466239f, 0.12964109f, 
    0.25022322f, 0.08394419f, -0.17352821f, 0.07878827f, 0.01321227f, 0.22328596f, 0.10584782f, 0.15686469f, 
    -0.06205679f, -0.12554514f, 0.04780851f, 0.15641421f, -0.04762055f, 0.09740727f, 0.13191289f, 0.00795416f, 
    0.07598115f, -0.02270346f, -0.07054985f, 0.15604843f, -0.09941997f, -0.03059693f, 0.02425196f, 0.21786082f, 
    0.00227532f, 0.00279990f, 0.00419939f, 0.05489862f, 0.01783127f, 0.00857800f, 0.04271489f, 0.06720609f, 
    -0.57289946f, -0.01136005f, 0.01171821f, 0.03665981f, 0.24894452f, 0.12935509f, -0.03437024f, 0.07943261f, 
    -0.14344908f, -0.04643603f, 0.16029331f, 0.24336459f, 0.23305942f, 0.04888377f, -0.10194287f, -0.17019120f, 
    0.01658696f, -0.03911293f, 0.05782537f, -0.13979495f, -0.05634407f, -0.03951824f, -0.00199901f, -0.03606189f, 
    0.09015590f, -0.23315789f, -0.09052166f, 0.00373306f, -0.10940762f, 0.05390861f, 0.11822741f, 0.10664436f, 
    -0.02157734f, 0.11330177f, -0.01007889f, -0.05233386f, -0.27646783f, 0.13578174f, 0.08089230f, 0.06087311f, 
    -0.07958008f, 0.02688203f, -0.04027389f, 0.01707776f, 0.02612361f, -0.19762424f, 0.07346594f, 0.01606778f, 
    -0.13594823f, 0.12179432f, 0.06259386f, 0.05753485f, 0.00631601f, -0.04958588f, -0.00186775f, -0.04407131f, 
    -0.08145884f, 0.03365564f, 0.07889701f, 0.00543737f, -0.20401582f, 0.01607873f, -0.02540662f, -0.18003158f, 
    -0.00584221f, 0.00369367f, 0.01219970f, -0.01289492f, 0.08250104f, 0.03356480f, 0.07972181f, 0.07832921f, 
    0.01587573f, -0.08841658f, -0.05988884f, 0.07276887f, 0.07605891f, -0.04634710f, -0.10599319f, 0.14610958f, 
    0.09975176f, 0.03346778f, -0.04496903f, 0.08703288f, 0.15698333f, 0.18880416f, 0.10900615f, -0.29876402f, 
    -0.03368653f, -0.10448343f, -0.01696979f, -0.04727026f, -0.01439707f, 0.03196967f, 0.08815683f, -0.01452086f, 
    -0.07287101f, 0.00477034f, -0.12092843f, -0.02840637f, -0.04211843f, -0.02664123f, 0.16889307f, -0.03909304f, 
    -0.01906994f, 0.00083077f, 0.00848182f, 0.01074288f, -0.30425027f, 0.16371147f, 0.10252410f, -0.02165199f, 
    0.00397517f, -0.00707753f, -0.06284057f, -0.00044773f, -0.00828654f, -0.13308594f, -0.01389475f, -0.03388719f, 
    -0.21778886f, 0.05997568f, 0.14347675f, -0.03529096f, 0.03037732f, 0.09951893f, -0.06632780f, -0.03203127f, 
    -0.03753519f, -0.05682245f, 0.11704712f, 0.14319967f, 0.12696309f, 0.16303623f, 0.14798430f, -0.15731490f, 
    -0.04412386f, -0.02657861f, -0.06108297f, -0.02682946f, 0.00245699f, -0.07754791f, -0.06472202f, -0.02783247f, 
    0.07432219f, 0.06566479f, 0.01398891f, 0.01615286f, 0.19555146f, -0.03947261f, -0.00053090f, 0.19687085f, 
    0.03669319f, 0.03129378f, 0.10753994f, 0.04009833f, 0.23136477f, 0.08897989f, 0.24068463f, 0.02777108f, 
    0.04426032f, -0.03410928f, -0.07332826f, 0.01112974f, -0.01085972f, -0.03555969f, -0.01144067f, 0.03300320f, 
    -0.40307751f, 0.04300352f, 0.36070764f, 0.20791888f, -0.06617340f, 0.03380918f, 0.20374201f, 0.13116214f, 
    -0.06287424f, -0.03971947f, 0.17368895f, 0.09142484f, 0.18759394f, 0.10019562f, 0.17278661f, 0.08727179f, 
    0.23294871f, -0.02605861f, 0.11529899f, 0.09921989f, 0.01734592f, 0.08314593f, 0.09431927f, -0.01629738f, 
    -0.10684923f, -0.06548149f, -0.01909646f, -0.14721967f, -0.11577924f, -0.05549962f, 0.01019211f, 0.00526841f, 
    0.00072874f, -0.01644607f, -0.05162898f, 0.03919023f, 0.05726887f, -0.13021795f, -0.03930633f, -0.05820079f, 
    0.09335362f, 0.10963028f, 0.17672302f, 0.14135233f, 0.14073877f, 0.06748927f, -0.04051431f, 0.00321318f, 
    0.05925662f, -0.20875315f, -0.02238750f, 0.11744073f, -0.04342943f, 0.05491746f, 0.05862674f, -0.03133143f, 
    -0.01057401f, 0.04420800f, 0.01140070f, 0.02740352f, 0.30536550f, -0.13510211f, -0.04938438f, -0.00611639f, 
    -0.12215443f, -0.00207643f, 0.09744512f, 0.08099122f, 0.05929492f, 0.01466858f, -0.07059295f, 0.00979729f, 
    0.37525421f, 0.04868597f, -0.14084639f, 0.17675959f, 0.06766663f, 0.03852096f, -0.07266043f, -0.06993939f, 
    -0.20844790f, 0.13993180f, 0.11118782f, -0.18485403f, -0.09489531f, -0.14656053f, 0.10171919f, 0.05814566f, 
    0.05856740f, 0.11536597f, 0.21652900f, -0.10129356f, 0.11199085f, -0.04146797f, -0.01614690f, -0.08751933f, 
    -0.18288748f, -0.21058053f, -0.00308082f, -0.13965905f, -0.01418566f, 0.15934987f, -0.02318253f, 0.04800401f, 
    0.17990157f, 0.04960325f, 0.00580966f, 0.13531446f, 0.35180381f, -0.23762840f, -0.08432338f, -0.17470658f, 
    0.00432694f, -0.00435788f, 0.09822601f, 0.03245295f, 0.03179443f, 0.09253508f, 0.03762114f, -0.04544784f, 
    0.18250693f, 0.10798214f, -0.08291592f, 0.00120644f, 0.06515832f, -0.08865322f, -0.01829922f, -0.09847135f, 
    0.06969505f, 0.04579957f, 0.07067502f, 0.01351798f, 0.18391769f, 0.22062968f, -0.03037584f, -0.07704513f, 
    0.11733907f, -0.19004059f, -0.00689489f, -0.03854248f, -0.01300574f, 0.07356186f, 0.05080406f, 0.00303354f, 
    -0.03376102f, 0.12121673f, 0.04768524f, -0.06723506f, -0.07147236f, -0.04286708f, -0.08262274f, 0.02682682f, 
    -0.11552491f, -0.09192429f, -0.03469907f, 0.19320083f, -0.22458725f, -0.00394970f, 0.28916425f, -0.11621932f, 
    0.01505664f, -0.01323779f, -0.00987591f, 0.04670110f, 0.01522171f, -0.11201686f, 0.03127823f, 0.08010761f, 
    -0.13440360f, 0.14880672f, -0.03776285f, -0.04281106f, -0.07073274f, 0.11108533f, -0.02272373f, -0.03765403f, 
    -0.00948354f, -0.03629026f, 0.00263136f, 0.07747943f, -0.05768935f, -0.03315810f, -0.01597095f, 0.07087017f, 
    -0.04405078f, 0.15730996f, 0.09775718f, 0.01192272f, 0.02485407f, -0.01946615f, 0.10355138f, -0.07174654f, 
    0.21242227f, 0.22258787f, -0.10559770f, -0.17453450f, 0.16760740f, -0.09529298f, 0.00772467f, 0.08606823f, 
    -0.01086623f, 0.04688664f, 0.14648050f, 0.02563428f, 0.13123965f, -0.00958096f, -0.05447454f, 0.06900469f, 
    -0.09779467f, -0.08720317f, -0.05700001f, 0.15275355f, -0.00603273f, -0.04132716f, 0.04853933f, 0.07348236f, 
    0.12273561f, 0.18931869f, 0.07209276f, -0.09153709f, 0.00839718f, 0.03323019f, -0.06190701f, -0.09128451f, 
    -0.12616718f, -0.03074059f, -0.05842242f, -0.10467679f, 0.03697240f, -0.02771652f, -0.08464875f, -0.00933567f, 
    -0.05320325f, -0.07379013f, 0.03499110f, 0.04424341f, 0.12682545f, -0.06245913f, 0.01013111f, -0.14943606f, 
    -0.09881125f, -0.31594175f, -0.23137282f, 0.05509960f, 0.00540770f, 0.07881278f, 0.01219587f, 0.15727119f, 
    -0.02645039f, 0.01610145f, 0.02903565f, -0.00611347f, 0.54103369f, -0.23027346f, -0.20891206f, -0.24814135f, 
    -0.04951343f, -0.01696873f, 0.02199019f, -0.04165614f, 0.09789036f, 0.06166670f, 0.06196241f, -0.00216716f, 
    -0.28709602f, -0.15298992f, 0.04993076f, 0.02424665f, 0.08936188f, -0.02077179f, -0.07276861f, -0.06923421f, 
    0.06066620f, -0.02401913f, 0.06236987f, 0.11602172f, -0.01094804f, -0.01540131f, -0.07849401f, 0.09535289f, 
    0.17775780f, -0.08265276f, -0.00806837f, 0.03381390f, 0.10645403f, -0.08638439f, 0.15285194f, 0.24049319f, 
    -0.18465504f, -0.05199704f, 0.14661732f, 0.00263480f, -0.10691316f, 0.09192404f, -0.06136879f, -0.00619633f, 
    -0.03434963f, 0.05146766f, -0.02889585f, 0.03288555f, -0.23652196f, -0.48941743f, -0.19981170f, 0.11985675f, 
    0.04498061f, 0.11776826f, -0.00689850f, 0.00878612f, 0.04880043f, 0.09253030f, 0.02322065f, 0.06369597f, 
    0.18745336f, 0.07066097f, 0.11390730f, 0.01457765f, -0.00076936f, -0.03693960f, 0.02645671f, -0.03345165f, 
    -0.10302227f, -0.00564462f, 0.01989162f, 0.00131335f, -0.04157149f, -0.22908002f, -0.04092310f, 0.02261412f, 
    0.08364598f, 0.08275347f, 0.08956239f, 0.12037609f, -0.04939616f, 0.00462333f, -0.00663426f, -0.05426152f, 
    0.24615644f, 0.01188998f, -0.26037121f, -0.09975865f, 0.02063550f, -0.08089814f, 0.05344082f, -0.01369803f, 
    0.06528097f, 0.07918552f, 0.17920561f, 0.14058171f, -0.09533993f, 0.07563996f, 0.08225791f, 0.02082631f, 
    -0.08571067f, -0.01516628f, -0.05020518f, -0.06029917f, 0.00761054f, 0.03066974f, -0.06006604f, 0.13565350f, 
    -0.28179166f, -0.14008892f, 0.13229457f, -0.15752700f, 0.03305361f, 0.00257839f, 0.08928505f, -0.06037547f, 
    0.15639265f, 0.08191123f, -0.02355039f, -0.02558804f, -0.20341356f, -0.12274960f, 0.07574406f, -0.03520084f, 
    0.02946556f, -0.00583646f, 0.10339845f, -0.00216247f, 0.05912837f, 0.03190374f, -0.03509003f, 0.03503519f, 
    -0.10884792f, -0.12534057f, 0.02815462f, 0.03982642f, 0.01452848f, -0.04228988f, 0.12924998f, -0.00081319f, 
    0.01570725f, -0.04641198f, -0.03167416f, -0.00963083f, 0.07537913f, 0.05565586f, -0.00786414f, -0.04823861f, 
    -0.04557077f, -0.03411546f, -0.04330651f, 0.03428579f, -0.01588008f, 0.01029072f, 0.03438779f, -0.00605240f, 
    -0.09446120f, 0.10429523f, 0.09727702f, 0.10597904f, 0.05963300f, 0.04733748f, -0.01027084f, -0.02630088f, 
    0.21202870f, 0.12557887f, -0.08794743f, -0.12528285f, 0.35911408f, 0.21457677f, -0.08691998f, -0.08585066f, 
    0.09000176f, -0.01407360f, -0.06053155f, -0.05495069f, -0.20332715f, 0.09108528f, 0.11978950f, -0.01747860f, 
    -0.13900533f, -0.06673226f, -0.06434903f, 0.00700104f, -0.08947108f, 0.04539187f, -0.00443397f, 0.07536328f, 
    0.10538457f, 0.02383574f, -0.01614458f, 0.06497751f, 0.04980094f, -0.16181722f, 0.11820938f, -0.04612905f, 
    -0.08967137f, 0.04296634f, 0.12734608f, 0.16945677f, 0.07581859f, -0.05839898f, 0.03674586f, -0.09850916f, 
    -0.07297219f, 0.05993510f, 0.10835508f, 0.00636583f, 0.04251296f, 0.09042691f, 0.12472638f, 0.07435791f, 
    0.07583681f, 0.08781541f, 0.21488489f, 0.12557097f, 0.13577758f, 0.04674255f, -0.06671266f, -0.21167983f, 
    -0.05272257f, -0.00522869f, -0.01202859f, -0.01831102f, 0.01549144f, -0.01823436f, 0.06815252f, 0.06665785f, 
    -0.03190294f, -0.03464232f, -0.02189091f, -0.06166758f, 0.08089772f, -0.03447719f, 0.01115659f, 0.22595713f, 
    -0.02600373f, 0.08300890f, 0.05515090f, 0.05412774f, 0.64483356f, 0.08736886f, -0.22479632f, -0.22316803f, 
    0.11679801f, 0.00060736f, -0.00882252f, -0.05403036f, -0.00085581f, 0.05593649f, 0.11593836f, 0.05945411f, 
    0.25591975f, -0.03920852f, 0.00973050f, -0.12380634f, 0.08078031f, 0.10502194f, 0.04151720f, 0.08544994f, 
    -0.08087058f, -0.11106636f, -0.04676099f, 0.00452483f, 0.34517974f, -0.09373006f, -0.13562803f, -0.19951065f, 
    0.05964173f, 0.05682896f, -0.02650091f, -0.14257208f, 0.07916166f, -0.04705973f, 0.04922473f, -0.08305678f, 
    0.36914358f, -0.08611699f, -0.14801483f, -0.05138294f, 0.03420183f, -0.07992852f, 0.03040901f, -0.01163030f, 
    0.14069243f, 0.21844298f, -0.05844420f, -0.00622329f, -0.29796585f, 0.21728311f, -0.05201387f, -0.15966317f, 
    -0.02748449f, 0.13187949f, -0.04438030f, -0.01282784f, -0.09566410f, -0.05377229f, -0.14993235f, -0.18542892f, 
    0.00884231f, 0.05844083f, -0.19731753f, -0.15098117f, 0.09665982f, 0.09168658f, -0.04931198f, -0.11024641f, 
    0.01775865f, 0.01458794f, -0.02238800f, 0.09542093f, -0.04365750f, -0.01512104f, 0.29248846f, 0.04384193f, 
    0.20672825f, 0.14046538f, -0.14146218f, 0.33887893f, 0.01163277f, 0.02056606f, 0.16408323f, -0.06602833f, 
    -0.09928125f, -0.15054035f, -0.18770804f, -0.02120898f, 0.00042616f, 0.03427356f, -0.01251464f, -0.02331480f, 
    0.16921762f, -0.10653719f, -0.05669685f, 0.13666901f, 0.19926351f, -0.03785336f, -0.24394111f, -0.10982195f, 
    -0.05230929f, 0.02211648f, -0.03934032f, -0.01145236f, 0.03434604f, 0.06552780f, 0.00323224f, 0.07062635f, 
    0.31116608f, -0.05513843f, -0.06039295f, -0.01716674f, 0.06474943f, -0.04546386f, -0.04976179f, 0.13796182f, 
    0.04635268f, 0.02003305f, 0.05450968f, -0.03196083f, 0.08181527f, -0.16817063f, 0.09041885f, 0.20778513f, 
    0.00790389f, -0.00554541f, 0.09777663f, 0.07619632f, 0.13463873f, 0.01169084f, 0.01793610f, 0.11072701f, 
    0.16681749f, 0.00362105f, 0.12469230f, -0.19929291f, 0.12259177f, 0.03541925f, 0.19023737f, -0.00528914f, 
    0.01697265f, -0.02989677f, -0.00226247f, 0.04125456f, 0.05653512f, 0.04091836f, -0.00829404f, 0.01188283f, 
    -0.08865409f, -0.06984248f, 0.01265370f, 0.01615328f, 0.18258856f, -0.03025255f, -0.16341613f, -0.00169962f, 
    0.15917452f, 0.05058824f, -0.02833082f, 0.06815545f, -0.00104559f, -0.01851256f, 0.03906365f, 0.01269116f, 
    -0.03236282f, 0.02675947f, 0.02945583f, 0.02963816f, 0.10096693f, 0.08270998f, -0.08885858f, -0.18765090f, 
    -0.02874583f, -0.04071699f, -0.01585695f, -0.09122773f, 0.00663435f, 0.00139321f, 0.11433087f, -0.04898233f, 
    -0.04008644f, 0.11961770f, -0.15824319f, -0.18549785f, 0.10224972f, -0.01592474f, 0.02353452f, -0.07843570f, 
    0.02575138f, 0.02035231f, -0.02181766f, 0.20455891f, 0.19142458f, 0.08886556f, 0.10477908f, 0.05671196f, 
    0.04035381f, -0.04366613f, -0.00838994f, 0.02635687f, 0.01832693f, 0.00189182f, 0.02211167f, 0.09425271f, 
    0.01000165f, -0.09028471f, -0.02341401f, -0.03790161f, 0.21708702f, -0.04315593f, 0.16183652f, -0.09057318f, 
    0.05519683f, -0.03430053f, -0.06566279f, 0.08136632f, -0.08520174f, 0.02853678f, -0.14329115f, -0.21781251f, 
    0.07568214f, 0.01838070f, -0.01646502f, 0.10899620f, 0.01911911f, -0.07524148f, 0.03342208f, -0.02686297f, 
    0.13648134f, 0.07175646f, 0.15518409f, -0.00095285f, -0.00933885f, 0.01211174f, -0.05190284f, 0.12689596f, 
    0.02263414f, 0.02988721f, 0.12452299f, 0.01098667f, -0.00378590f, -0.01940663f, 0.17650601f, 0.07527459f, 
    0.10626229f, 0.05514602f, 0.05713490f, 0.11456784f, -0.07252540f, -0.04190554f, 0.03058592f, -0.02432936f, 
    0.17309874f, -0.06995165f, 0.19287640f, -0.09186158f, -0.09125852f, 0.01465758f, -0.04714218f, 0.26024947f, 
    0.16486810f, 0.05327393f, 0.01739936f, 0.03566068f, -0.23318832f, 0.16173652f, 0.22278965f, 0.16248281f, 
    0.08355390f, 0.05993702f, -0.05977432f, 0.00555837f, -0.00222249f, 0.13422322f, 0.08512374f, 0.01158270f, 
    0.13234857f, -0.12348002f, -0.19051042f, -0.30580720f, 0.11057240f, 0.03440009f, 0.13346197f, 0.17292045f, 
    0.15153924f, -0.08956125f, -0.15396656f, 0.18280633f, -0.45070541f, 0.22138390f, -0.08558013f, -0.09979311f, 
    -0.01682555f, 0.10601777f, -0.12496623f, 0.14015180f, 0.03387148f, 0.08653998f, 0.11025874f, -0.04977995f, 
    0.06155891f, 0.27359095f, 0.14401709f, -0.19727333f, -0.00383815f, 0.12893389f, 0.05937906f, -0.02986690f, 
    0.05802391f, 0.04658710f, 0.01421553f, -0.16160455f, 0.09031922f, 0.01996423f, 0.16239077f, -0.13520384f, 
    -0.01412426f, -0.02378275f, 0.03734794f, 0.04552395f, -0.05294133f, -0.07874101f, -0.07782895f, -0.09043999f, 
    0.07545889f, 0.08216404f, -0.14704871f, -0.13083023f, 0.06017766f, 0.16239537f, 0.09636874f, 0.03234479f, 
    -0.08926134f, 0.01485237f, -0.03587431f, 0.03709933f, -0.30015454f, -0.17093450f, -0.00222937f, 0.08081170f, 
    -0.06519128f, 0.11740042f, 0.06337553f, -0.07052356f, 0.04352877f, -0.02630543f, 0.07391860f, -0.00667357f, 
    0.19352192f, 0.13075340f, 0.01294569f, -0.06078363f, 0.17786130f, -0.04884768f, 0.05286727f, 0.04427952f, 
    -0.06169542f, -0.13299300f, 0.04573282f, 0.06834105f, 0.35925394f, -0.12045775f, -0.16989261f, -0.47703147f, 
    0.09963749f, 0.12929811f, 0.03955211f, -0.12369500f, 0.24812086f, -0.05392752f, -0.00341887f, 0.10497271f, 
    -0.04442910f, -0.06519225f, 0.10442777f, -0.23212229f, 0.08092614f, 0.08667890f, -0.12236163f, -0.03356700f, 
    0.06577684f, -0.05564770f, -0.04349303f, -0.02720616f, 0.34109911f, -0.25029376f, 0.13726047f, 0.01188140f, 
    -0.03036821f, 0.05910886f, 0.15657498f, 0.07147543f, 0.19146612f, -0.00087392f, 0.12055183f, -0.00872459f, 
    -0.00201618f, -0.02128421f, 0.02233559f, -0.01249191f, 0.08418469f, 0.07269421f, -0.01402572f, -0.00961252f, 
    0.05579351f, 0.08684507f, 0.00513123f, 0.08731730f, -0.02009358f, 0.13146941f, 0.02558253f, 0.01301843f, 
    0.08610405f, 0.10267682f, 0.01999404f, 0.08409940f, 0.08123274f, 0.04173658f, 0.08278393f, 0.00886307f, 
    0.11589832f, -0.00225254f, -0.09694698f, 0.15374769f, -0.02072367f, -0.03082642f, 0.01326011f, 0.06541181f, 
    -0.04080418f, -0.03121523f, -0.05107492f, 0.03362145f, 0.19955850f, 0.17594825f, 0.13539228f, -0.12976600f, 
    0.12158278f, 0.09390733f, 0.00533403f, 0.08189680f, 0.01533250f, -0.05222813f, 0.04396746f, -0.00995672f, 
    0.06122905f, 0.05266389f, -0.04643222f, 0.24765334f, -0.00059666f, -0.02850130f, 0.10463844f, 0.04130002f, 
    0.01522068f, -0.03185347f, -0.03296360f, 0.08460100f, 0.25329652f, -0.10527752f, -0.07930221f, -0.22560139f, 
    -0.03692660f, 0.03323213f, 0.09260928f, -0.11900181f, 0.06280112f, -0.12164613f, 0.01352236f, -0.00861056f, 
    0.49980691f, -0.17274158f, 0.09914961f, -0.12228297f, 0.06157608f, -0.11209331f, 0.00806185f, 0.23649231f, 
    0.25923538f, 0.02678271f, 0.10044512f, -0.13125172f, -0.16295619f, -0.05532265f, 0.00256762f, 0.06167215f, 
    -0.01772256f, 0.17900015f, -0.11689026f, 0.04228390f, 0.01527056f, -0.00046833f, -0.07379302f, 0.07199644f, 
    -0.00289537f, 0.01891476f, 0.16327687f, 0.18439937f, 0.12223919f, 0.03789840f, 0.01478520f, 0.11423430f, 
    -0.12701675f, -0.12383255f, 0.00980957f, 0.06291851f, 0.08023050f, -0.02896983f, -0.09211189f, 0.08293356f, 
    -0.05593827f, 0.07880352f, 0.16949466f, -0.00848005f, 0.21731815f, 0.02273742f, 0.07239611f, 0.02737297f, 
    -0.00970026f, -0.12866551f, -0.22562163f, -0.12416006f, 0.07278174f, 0.14360029f, 0.02767036f, -0.02268910f, 
    -0.05714774f, 0.03143847f, 0.01804726f, 0.03916743f, -0.39993581f, -0.22585167f, -0.00519652f, 0.23763274f, 
    -0.02207616f, 0.03029513f, 0.01673785f, -0.02648966f, 0.03494307f, -0.06515722f, 0.05395518f, 0.07745712f, 
    0.07365608f, 0.00591960f, 0.00506135f, -0.17612991f, 0.01353445f, 0.00027878f, 0.02307625f, -0.01767266f, 
    0.02567651f, 0.11254441f, -0.05124087f, -0.02641463f, 0.10250725f, 0.00494650f, 0.12814856f, -0.06482028f, 
    0.22118267f, -0.01716653f, -0.02733846f, 0.14821517f, 0.04905882f, 0.08601528f, 0.03016970f, -0.06530078f, 
    0.13492286f, -0.11396536f, 0.02180984f, 0.08932615f, 0.07882302f, -0.05353746f, -0.02322163f, 0.08195102f, 
    0.12433754f, -0.02129915f, -0.02301734f, 0.08867750f, 0.12314904f, -0.00516980f, -0.19302328f, -0.19975162f, 
    0.01038337f, -0.03615033f, 0.00311660f, -0.14818475f, -0.05741231f, -0.13446124f, 0.03213439f, 0.02136351f, 
    0.14030676f, -0.02563125f, 0.09592517f, 0.16543095f, 0.03542058f, 0.00096437f, -0.04652771f, 0.07482941f, 
    -0.08208522f, -0.07315101f, 0.03632113f, 0.05942445f, 0.13917471f, -0.03353513f, 0.10787015f, -0.15781611f, 
    -0.05828021f, 0.00758151f, -0.06573253f, 0.07284541f, -0.06137883f, -0.14692518f, -0.00477303f, -0.13070701f, 
    -0.11908532f, -0.10271749f, 0.11920810f, 0.13694708f, -0.01090297f, -0.01405447f, 0.02232197f, 0.00559089f, 
    0.02677844f, 0.01857368f, -0.02029562f, 0.09443856f, 0.10703292f, -0.00992097f, 0.02412870f, 0.10976548f, 
    0.05463023f, 0.09180562f, 0.02460159f, -0.05195043f, 0.05537855f, -0.18817279f, -0.09020169f, -0.02001964f, 
    0.12513651f, -0.17814122f, -0.02300486f, -0.22723821f, 0.04962251f, -0.10238286f, -0.02822763f, -0.02275359f, 
    0.01061542f, -0.05756264f, 0.03474599f, -0.02027580f, 0.24035060f, -0.07804643f, 0.19799276f, -0.11837860f, 
    0.07573567f, 0.06704339f, 0.04350531f, -0.07231057f, 0.01372339f, -0.06432123f, 0.08709002f, 0.03264109f, 
    0.13911568f, 0.11200997f, -0.01227486f, -0.27143297f, 0.03970512f, 0.15219641f, 0.15964355f, -0.00457171f, 
    -0.02409467f, 0.00661801f, 0.01296259f, 0.00341701f, -0.03401926f, -0.04751636f, 0.02625649f, 0.20718543f, 
    -0.09396275f, 0.02210436f, -0.09909958f, 0.07555189f, 0.08592818f, 0.08281235f, 0.04068930f, 0.13228795f, 
    0.18870609f, -0.03688322f, 0.07857202f, 0.11645563f, 0.00056429f, 0.03619995f, 0.09652503f, 0.06320786f, 
    -0.00600696f, -0.03314678f, 0.15780237f, -0.09434938f, -0.18383943f, 0.06687812f, -0.20955077f, 0.22617525f, 
    0.09364918f, 0.08128807f, 0.06790551f, 0.12531929f, -0.00659336f, -0.15158913f, -0.00950475f, 0.04175470f, 
    -0.09863915f, -0.01184923f, -0.03800718f, 0.00595481f, 0.07314663f, -0.00447456f, -0.01109827f, 0.10487009f, 
    0.08744544f, -0.03045132f, 0.07306027f, 0.07244183f, -0.26961568f, -0.09185909f, -0.26428223f, 0.02327663f, 
    -0.04465815f, 0.15033954f, 0.04353897f, -0.12171407f, 0.04021801f, -0.15190707f, -0.03478055f, -0.02470687f, 
    0.02793921f, -0.01229433f, -0.08880862f, -0.23718739f, -0.07683560f, -0.01744271f, 0.18457085f, 0.00975589f, 
    0.10135015f, 0.07025731f, -0.06805787f, 0.13253897f, 0.08563945f, -0.05134316f, 0.06313435f, 0.16410294f, 
    -0.03474645f, 0.07545607f, 0.03903151f, 0.08509123f, -0.02274343f, -0.04803808f, 0.11987037f, 0.03289094f, 
    -0.12228379f, -0.04883808f, -0.06230340f, -0.00511543f, 0.05853177f, -0.00860448f, -0.07626665f, 0.10317077f, 
    0.03200859f, 0.02628944f, -0.10570057f, 0.06554808f, -0.34011894f, -0.09568108f, 0.21483989f, 0.32849738f, 
    -0.00372137f, 0.04697081f, 0.02007604f, 0.04610444f, 0.19674388f, 0.16259940f, 0.08031130f, 0.07166969f, 
    0.11093894f, -0.25472227f, -0.14805540f, -0.11014519f, 0.00213898f, -0.05960438f, -0.00605639f, 0.13861868f, 
    -0.00849721f, -0.01285374f, 0.03598055f, -0.00505534f, 0.22973402f, 0.38551649f, -0.11974178f, -0.13760114f, 
    0.01693593f, -0.08302669f, -0.05927502f, 0.03255143f, 0.04971922f, 0.04367787f, -0.01361974f, 0.06412815f, 
    -0.13352588f, -0.25653127f, -0.14945970f, 0.02685360f, 0.14446233f, 0.01439539f, 0.00259062f, 0.02107583f, 
    0.17416891f, 0.03134565f, 0.14611398f, 0.05667400f, 0.09209964f, 0.13771559f, 0.11763279f, 0.01517083f, 
    0.12251765f, -0.08268145f, -0.03466741f, -0.05983613f, 0.06819158f, 0.19685026f, 0.08692583f, 0.22030175f, 
    -0.11059826f, -0.30111510f, -0.25448883f, -0.15309553f, 0.03752024f, 0.28394878f, 0.16888523f, 0.01166713f, 
    -0.04097993f, -0.03569271f, -0.00540307f, -0.02395298f, 0.32162812f, -0.09749265f, -0.24282342f, -0.25234345f, 
    -0.01042958f, 0.07469335f, 0.08560404f, 0.07498940f, 0.01954038f, 0.04643703f, 0.03284737f, -0.00280893f, 
    0.17206700f, 0.30058858f, 0.07112655f, 0.00853029f, 0.11898974f, -0.04118252f, -0.01523097f, 0.06504297f, 
    0.16539848f, 0.14730506f, 0.09825670f, -0.14419885f, 0.15777878f, 0.21054618f, -0.05456285f, -0.13111715f, 
    0.10165117f, 0.02409638f, 0.01623389f, 0.05117497f, 0.08265372f, 0.02925640f, -0.05627863f, 0.02041200f, 
    0.41866934f, 0.23258972f, -0.13914564f, -0.31976759f, -0.17524479f, -0.02905513f, 0.14382955f, 0.00766706f, 
    0.12285119f, 0.05476212f, -0.11213864f, -0.02509148f, 0.01155800f, -0.02805123f, 0.07427681f, 0.25859702f, 
    0.00938381f, 0.01089133f, -0.02629255f, 0.03774261f, 0.15268622f, -0.00270726f, 0.01793191f, 0.08388484f, 
    -0.20969762f, 0.09514127f, -0.08131840f, 0.00809364f, 0.07277268f, 0.03836780f, -0.01245891f, -0.03002393f, 
    0.00653486f, -0.00463911f, 0.02197324f, 0.04754479f, 0.29112387f, -0.10786584f, 0.03158492f, -0.15155900f, 
    -0.09862540f, -0.01539350f, 0.03263618f, -0.04687722f, 0.05972636f, 0.09860002f, -0.06105249f, 0.02568083f, 
    0.08646284f, -0.07826538f, -0.09492779f, 0.07628075f, 0.00018802f, 0.01956476f, -0.04103265f, 0.06932118f, 
    0.01410636f, -0.02441494f, 0.05090242f, 0.05688266f, 0.12316291f, -0.04173990f, -0.24457619f, -0.04555037f, 
    0.14741282f, 0.11557095f, -0.05570364f, 0.04657061f, -0.03444152f, 0.08605727f, 0.05244062f, 0.01221000f, 
    -0.13347039f, -0.09437364f, -0.08158664f, -0.14354190f, 0.00995476f, -0.01340275f, 0.13073488f, -0.01948103f, 
    -0.00380958f, 0.01235589f, 0.09017508f, -0.00567869f, -0.27253279f, -0.18528076f, -0.07262263f, 0.28928673f, 
    0.01841427f, 0.11804642f, 0.01471278f, 0.02891934f, 0.00197583f, -0.00955073f, -0.06569306f, -0.00129460f, 
    -0.09202275f, -0.08691404f, 0.02158880f, -0.10793151f, 0.00833256f, 0.05062742f, -0.08912133f, -0.10934978f, 
    0.10523727f, -0.03989616f, 0.11063305f, 0.02418965f, 0.00454521f, -0.28000158f, -0.30624914f, -0.15447086f, 
    -0.01108192f, 0.03873551f, 0.12105304f, 0.00589003f, -0.01823229f, 0.05224100f, -0.06261065f, 0.02679945f, 
    0.19214000f, 0.05615458f, -0.21104351f, -0.09342410f, -0.03185516f, 0.01919626f, 0.12223651f, -0.04191372f, 
    0.01804672f, 0.23296651f, 0.02828451f, -0.01369319f, -0.21953556f, -0.18095002f, -0.12239663f, 0.11381716f, 
    -0.04863823f, 0.07930020f, 0.09536145f, -0.00384218f, -0.10462905f, -0.12596394f, -0.03142044f, -0.05020040f, 
    0.12829882f, 0.07134541f, 0.03525821f, -0.07419512f, 0.02633106f, 0.21391436f, -0.11796349f, -0.03396131f, 
    0.10890725f, 0.13686083f, -0.04145253f, -0.01123285f, -0.44503367f, 0.07362593f, -0.22106868f, 0.01799535f, 
    -0.01380826f, 0.09453192f, 0.05437971f, -0.10540465f, -0.00527135f, -0.04226006f, -0.00393667f, 0.06216923f, 
    0.38764378f, -0.04333114f, -0.25678620f, -0.07317273f, 0.12869169f, -0.00335286f, 0.04234817f, -0.07409211f, 
    0.06205578f, -0.05395241f, -0.07127190f, 0.21962768f, -0.21977557f, 0.17317100f, -0.16668423f, -0.10992330f, 
    -0.03251684f, 0.11325216f, -0.11733820f, 0.13149722f, 0.09346517f, 0.03225250f, -0.01911239f, 0.02199981f, 
    0.18700393f, 0.07567191f, -0.03356719f, 0.04328066f, 0.17078744f, 0.09081073f, -0.06147589f, 0.05540000f, 
    0.08181274f, 0.02493829f, -0.04151504f, -0.00186594f, 0.01762532f, 0.16699983f, 0.18791083f, 0.11562473f, 
    0.10098078f, 0.08894362f, -0.00946880f, -0.02724573f, 0.02819575f, -0.04791819f, -0.05485667f, 0.04062404f, 
    -0.13095413f, 0.13478138f, 0.03009759f, -0.00996759f, 0.08464090f, 0.08474505f, -0.04332367f, 0.06973284f, 
    -0.01549553f, -0.01363336f, -0.00418295f, -0.03491966f, -0.05165505f, 0.29436305f, 0.32520032f, 0.09295814f, 
    -0.05573476f, -0.08348885f, -0.08565158f, -0.19362655f, -0.06470851f, -0.00632652f, 0.06622493f, 0.02364701f, 
    -0.27892748f, 0.01953452f, -0.18684082f, -0.20002693f, 0.01908579f, 0.15820505f, 0.00414045f, 0.06686538f, 
    0.13046496f, -0.15541044f, 0.00440344f, -0.01924708f, 0.28868610f, 0.00356583f, 0.02836579f, -0.16768917f, 
    0.06602960f, -0.00535059f, -0.12086955f, 0.16219497f, 0.04777434f, 0.07322878f, 0.05695000f, -0.02948881f, 
    0.13316996f, 0.09230971f, 0.27629375f, -0.08010080f, 0.10493232f, -0.00245518f, 0.01666201f, -0.00576429f, 
    -0.15612717f, 0.06503551f, 0.08028773f, -0.10580368f, -0.05193366f, 0.38362780f, 0.10776172f, 0.00418703f, 
    -0.08503058f, -0.02800583f, -0.16780403f, -0.05662985f, -0.10034918f, 0.15954290f, 0.14686561f, 0.06475296f, 
    -0.29085755f, -0.09785842f, -0.09508463f, 0.03212081f, -0.05848973f, 0.15071976f, 0.11373819f, -0.01972523f, 
    -0.03217561f, -0.10603700f, 0.03810249f, 0.03473391f, -0.26043582f, -0.24456823f, 0.00557048f, 0.06936891f, 
    0.09258359f, 0.18920757f, 0.10689613f, 0.17050387f, 0.07886922f, 0.00542295f, -0.00432356f, 0.07878387f, 
    0.06107989f, -0.03132592f, -0.04741080f, 0.07920211f, -0.00137235f, -0.09069455f, 0.04224565f, -0.00397617f, 
    -0.01694275f, 0.06165691f, -0.03530892f, -0.12054265f, 0.06172585f, -0.04915063f, -0.39205512f, -0.01904560f, 
    0.04997658f, -0.02172399f, 0.20791267f, 0.16136640f, -0.01737734f, 0.09525955f, -0.04535717f, -0.05733683f, 
    0.13337347f, -0.09062072f, -0.02151401f, -0.00226366f, 0.04881234f, -0.04568221f, 0.02044521f, 0.05078671f, 
    -0.03161252f, -0.09896179f, 0.00270056f, 0.03600645f, 0.17725044f, -0.04412918f, 0.07971018f, -0.20124561f, 
    0.11994822f, -0.04365687f, -0.07441128f, -0.01381887f, 0.02413162f, -0.00822805f, 0.04093041f, 0.04219694f, 
    0.02893828f, 0.06904750f, -0.00634751f, 0.09849143f, 0.04026303f, 0.14541584f, -0.05978084f, -0.05369467f, 
    0.20813712f, 0.04255705f, -0.00736232f, -0.10045456f, -0.15139881f, 0.03108135f, 0.19446209f, -0.05965952f, 
    -0.04830112f, -0.04388400f, -0.01995007f, -0.00755909f, 0.03881308f, 0.03612130f, -0.08789089f, 0.05566772f, 
    -0.10804398f, -0.14003122f, -0.13435832f, 0.05652589f, -0.01367642f, 0.02093590f, 0.03132652f, 0.09792539f, 
    0.00184584f, -0.08771238f, -0.03844162f, 0.02267907f, 0.11674932f, -0.09537174f, 0.26531711f, -0.04806145f, 
    -0.01704520f, -0.04427006f, -0.21319197f, -0.02627042f, 0.09680823f, 0.10324693f, 0.07374914f, 0.16712496f, 
    -0.12668297f, 0.19583790f, -0.16894385f, -0.13541557f, 0.05362142f, -0.09949400f, -0.03498865f, -0.05861194f, 
    -0.01472102f, -0.01509096f, -0.07010847f, 0.03637310f, -0.26965541f, 0.53370750f, 0.23787360f, 0.34195498f, 
    -0.02371068f, -0.08752317f, -0.08841816f, -0.04373345f, -0.04433606f, 0.02468778f, 0.09551457f, 0.10869845f, 
    0.13103817f, 0.22610076f, -0.11058713f, -0.13625263f, -0.03363168f, -0.16806358f, 0.18343869f, -0.01058612f, 
    -0.02319213f, 0.04953125f, -0.01461446f, 0.03258602f, 0.04829306f, 0.23920724f, -0.03853215f, -0.26539010f, 
    0.09007949f, 0.07500018f, 0.14388010f, 0.06874578f, -0.01403475f, 0.15405977f, -0.06916129f, 0.01725282f, 
    0.10961274f, -0.09851132f, -0.06622886f, -0.10749698f, 0.07839764f, -0.08733843f, 0.01238839f, 0.01117767f, 
    0.03681550f, -0.02265495f, 0.02534962f, -0.03912709f, 0.02608866f, 0.14889856f, -0.25963411f, -0.19936305f, 
    -0.01254350f, -0.10828565f, 0.03961214f, -0.05116804f, -0.02004010f, -0.02768985f, 0.05239544f, 0.01320164f, 
    0.01028350f, 0.01728710f, 0.07886885f, 0.19128191f, 0.05975100f, -0.00813678f, -0.06673489f, 0.04179577f, 
    -0.01501489f, -0.02449039f, 0.13422130f, -0.03389723f, 0.20564796f, 0.08496954f, -0.04682679f, -0.13997723f, 
    -0.09222478f, -0.03812696f, -0.05071430f, 0.05954406f, -0.01720800f, -0.00218635f, 0.06009517f, 0.16451994f, 
    -0.35690340f, 0.08526202f, 0.22690202f, 0.22160515f, -0.02891447f, 0.01132472f, 0.15218817f, 0.01809646f, 
    0.01967443f, 0.02443787f, -0.01032962f, 0.01358037f, 0.09592863f, 0.10853947f, 0.00406933f, -0.12653074f, 
    0.00352951f, -0.06512481f, -0.04209716f, -0.06890266f, -0.14085647f, -0.05334620f, 0.08080605f, 0.00663454f, 
    0.19419926f, -0.12124965f, -0.00036668f, -0.07332496f, 0.11505162f, 0.04610078f, -0.04414357f, 0.06209520f, 
    0.01929875f, 0.01768729f, 0.02224458f, -0.05907778f, 0.15993288f, -0.04358509f, 0.04754709f, 0.02510061f, 
    0.10201962f, 0.03075818f, -0.08454747f, -0.05706690f, 0.00738180f, 0.05662699f, 0.04347078f, -0.10125146f, 
    -0.14150858f, -0.06574482f, -0.14020732f, -0.12442070f, -0.03446883f, 0.07460785f, 0.06534615f, -0.04930783f, 
    0.01947016f, 0.06261192f, 0.03332406f, 0.01033053f, -0.05100657f, -0.15372251f, 0.10497122f, 0.06375016f, 
    -0.01546017f, -0.10986585f, -0.09961220f, -0.05022749f, -0.03810610f, 0.01471923f, 0.02463393f, 0.09883439f, 
    0.13351773f, 0.05249304f, 0.07270120f, -0.03535162f, -0.02511746f, -0.01030971f, 0.00416610f, -0.01598545f, 
    -0.13714953f, -0.05172316f, 0.04461342f, 0.11321501f, -0.27132848f, -0.10400932f, 0.06698151f, 0.03304651f, 
    -0.02810363f, 0.09061393f, 0.02539020f, 0.14915594f, 0.03012257f, -0.13100047f, -0.07341371f, 0.09665472f, 
    0.11706559f, 0.00025810f, 0.07615650f, 0.05434117f, 0.13234980f, 0.02396584f, 0.11569339f, -0.00386558f, 
    0.09435297f, 0.11341445f, 0.10206120f, -0.07223956f, 0.13032809f, 0.44045481f, -0.05544901f, 0.03488360f, 
    -0.09097055f, -0.11552261f, -0.18715699f, -0.16384454f, -0.06063122f, 0.08463135f, 0.10495649f, 0.11549482f, 
    0.27969715f, -0.11573511f, 0.05691786f, -0.05821673f, 0.09575365f, 0.06308530f, 0.07355238f, 0.01441963f, 
    0.03050220f, -0.08608414f, -0.07545569f, -0.04179535f, -0.11580522f, -0.14838333f, 0.13770539f, 0.16546153f, 
    0.10126898f, 0.04377386f, -0.00129793f, 0.00826409f, 0.02012072f, 0.01754932f, 0.00655111f, 0.11195140f, 
    -0.06790505f, -0.11290292f, 0.00272391f, 0.01943791f, -0.00122823f, 0.04858594f, 0.09247126f, 0.17457885f, 
    0.05329376f, -0.05248113f, 0.00393543f, 0.05368457f, -0.39178878f, -0.01189275f, 0.20572993f, 0.21807164f, 
    -0.12993520f, -0.05025318f, -0.03515444f, -0.02185868f, 0.05288210f, -0.02068478f, -0.05813882f, 0.04445936f, 
    0.25339657f, -0.14659652f, -0.04750738f, -0.05439528f, -0.03926089f, -0.01281863f, 0.03003492f, 0.09943030f, 
    0.07797981f, 0.09645509f, 0.09023304f, -0.01396929f, 0.23389526f, 0.02016633f, 0.05770444f, -0.13760529f, 
    0.02331924f, -0.12007962f, -0.02236810f, 0.03412639f, -0.03609591f, -0.11892389f, -0.05706687f, 0.01495515f, 
    0.04473823f, -0.45040029f, 0.11490309f, -0.04347686f, -0.05421037f, 0.01735548f, 0.04585343f, 0.04255731f, 
    0.06434953f, -0.03378991f, 0.13455322f, 0.02206067f, -0.11009692f, 0.01411319f, 0.02854786f, -0.03570699f, 
    0.02524686f, 0.06703393f, -0.10746957f, -0.06052569f, -0.07043190f, 0.00703983f, -0.04237108f, 0.07084705f, 
    0.13129833f, 0.14133044f, 0.02762138f, 0.01144231f, -0.04033637f, -0.07505835f, -0.03578471f, -0.10029235f, 
    0.03227054f, 0.08283029f, 0.00273163f, 0.00304975f, -0.10348141f, 0.03404583f, 0.08113044f, -0.40362859f, 
    -0.08344451f, 0.14463753f, 0.11203425f, -0.02105411f, 0.01386190f, 0.00323575f, -0.08897041f, -0.13759005f, 
    0.05527333f, 0.07824943f, -0.02232223f, -0.09546969f, 0.05053267f, -0.04682923f, -0.10595474f, 0.05474999f, 
    -0.02537674f, -0.01620554f, 0.03237456f, -0.22614226f, 0.10012979f, 0.15725091f, -0.08483403f, -0.13394472f, 
    -0.02239774f, -0.01515823f, -0.00868766f, -0.04038264f, 0.01777476f, 0.01735051f, -0.09647921f, -0.09180073f, 
    -0.05815689f, -0.18358509f, 0.13566841f, -0.07898019f, -0.20398508f, 0.04867044f, -0.00974377f, -0.06009968f, 
    0.19952199f, 0.04106466f, 0.00314817f, -0.07814144f, -0.06006658f, -0.06511807f, 0.21211492f, 0.22763516f, 
    -0.06963508f, -0.00945617f, -0.05896775f, 0.02207211f, 0.11491673f, 0.05248240f, -0.15613614f, -0.02650384f, 
    0.04914540f, 0.12852485f, 0.08808836f, -0.06073415f, 0.03469685f, 0.02586519f, 0.06081892f, -0.01356580f, 
    -0.03962862f, 0.00301529f, 0.02470676f, 0.02690413f, 0.51184535f, 0.04903174f, -0.07681777f, -0.06089091f, 
    -0.08258640f, 0.05833743f, 0.07999051f, -0.01049081f, 0.04745737f, -0.01984356f, -0.06589050f, 0.04645279f, 
    0.25258660f, 0.02128732f, 0.00333077f, 0.19912940f, -0.01082991f, 0.01292239f, -0.01674470f, -0.04164197f, 
    0.04966252f, 0.01644606f, 0.01707605f, 0.10261376f, 0.13823937f, 0.09544894f, -0.08364705f, -0.04679089f, 
    0.01057779f, -0.07041456f, -0.00588932f, 0.09591220f, 0.02447984f, 0.00320474f, 0.01888112f, -0.09929264f, 
    0.05608360f, 0.20512053f, 0.02733368f, 0.01307923f, -0.06680860f, 0.05036380f, 0.08037261f, 0.07382444f, 
    -0.01718565f, 0.02667542f, 0.04792209f, -0.06998944f, -0.04880568f, -0.06276885f, -0.08899882f, 0.29596031f, 
    -0.02110467f, -0.00634738f, -0.07840882f, 0.01188837f, 0.07303554f, -0.01653045f, 0.02425095f, 0.07152807f, 
    0.07516532f, -0.01334029f, 0.10621743f, -0.09278639f, -0.06250023f, 0.01585318f, -0.05074716f, -0.07079916f, 
    -0.07573141f, -0.14799054f, 0.15481992f, 0.07239084f, 0.13676530f, -0.00541253f, -0.12346251f, -0.06319831f, 
    -0.02201847f, 0.07245941f, -0.01929644f, 0.01358966f, -0.07086950f, 0.10403018f, -0.00906332f, 0.01054840f, 
    0.14751057f, 0.02644749f, 0.00197994f, -0.05655352f, -0.00440815f, -0.01794387f, -0.00649533f, -0.08519121f, 
    0.02768298f, 0.10603877f, -0.05076015f, 0.04824521f, -0.02663510f, -0.01796755f, 0.05537797f, 0.06309554f, 
    0.05870467f, -0.03844944f, -0.05874004f, -0.01664435f, 0.03815794f, -0.00921404f, 0.11132891f, -0.02931399f, 
    0.32802647f, 0.00331359f, -0.09584888f, -0.11071762f, -0.15592866f, -0.01316361f, -0.12252658f, 0.02081697f, 
    0.00520292f, -0.07010327f, -0.04806622f, -0.04027091f, -0.35551798f, 0.16895218f, 0.09543251f, 0.14088826f, 
    -0.01484767f, -0.04083919f, 0.00752712f, -0.07720560f, 0.15011777f, -0.01327622f, -0.04044230f, 0.08214782f, 
    0.38990009f, -0.16426714f, -0.13352334f, -0.03379886f, 0.09938779f, 0.11704866f, -0.01834225f, -0.09542836f, 
    0.07614598f, 0.01825188f, -0.01999767f, 0.07005205f, -0.24977861f, 0.09712754f, -0.23675431f, -0.05856002f, 
    -0.06655303f, -0.01962421f, -0.11419278f, 0.04772103f, -0.06568272f, -0.06021275f, 0.05180825f, 0.05982276f, 
    0.24825916f, 0.10241961f, -0.09416398f, 0.01334977f, 0.03472530f, 0.01267720f, -0.09629471f, 0.16373526f, 
    -0.07537335f, -0.06852777f, -0.05915078f, 0.00995994f, -0.00716494f, -0.02702837f, 0.05026616f, 0.03811447f, 
    -0.04372503f, 0.08422565f, -0.09400748f, 0.00629126f, -0.03115807f, -0.05564660f, -0.15049297f, -0.03187427f, 
    0.15094461f, 0.26205441f, 0.01786347f, -0.13042137f, 0.10907612f, 0.06452753f, 0.06842800f, 0.06056008f, 
    -0.01262288f, 0.00885666f, -0.04488377f, 0.02649076f, 0.19313946f, 0.19744295f, -0.04741362f, -0.08240163f, 
    -0.07255808f, -0.00428094f, -0.02359548f, 0.03066710f, -0.03582310f, -0.04708944f, -0.01817183f, -0.07972293f, 
    -0.23744816f, 0.09726008f, 0.04951871f, -0.14718512f, -0.09410221f, -0.04670324f, 0.12863509f, 0.06246902f, 
    0.07250585f, -0.10131684f, -0.11128994f, 0.11378452f, 0.20717673f, 0.01034124f, 0.10275432f, -0.12652248f, 
    -0.14375384f, 0.12288639f, -0.12837841f, 0.09669559f, -0.00220608f, 0.02164689f, 0.06529978f, 0.09435387f, 
    0.16693521f, 0.15165293f, 0.05524369f, 0.00578383f, 0.07053073f, 0.04846938f, 0.07753722f, 0.05332846f, 
    -0.07777584f, 0.02295934f, 0.02149664f, -0.08504449f, 0.02480340f, 0.17646076f, -0.06141965f, -0.00453678f, 
    -0.03585575f, -0.02064472f, 0.00521506f, -0.04535942f, -0.01590313f, -0.06795295f, 0.04296220f, -0.03057981f, 
    -0.07441378f, 0.11729141f, 0.24749580f, 0.04473101f, -0.03011659f, 0.02248706f, 0.01691386f, 0.00987111f, 
    0.02864344f, -0.01695045f, 0.04749062f, -0.04737819f, -0.18356557f, 0.07918575f, -0.00378159f, 0.07132734f, 
    -0.05533114f, 0.02684051f, 0.02856308f, 0.10690778f, 0.01183487f, -0.03238846f, 0.06181908f, 0.08892042f, 
    0.12424650f, 0.08025408f, -0.07072934f, 0.02614943f, 0.01710533f, 0.00540649f, -0.01791650f, -0.01248116f, 
    0.06533462f, 0.08108538f, -0.00797546f, -0.19075395f, 0.20057884f, 0.06653222f, -0.30732113f, 0.09760794f, 
    -0.03157102f, -0.07422475f, 0.13968301f, 0.09279243f, 0.04356374f, 0.09545445f, 0.10636836f, -0.11079082f, 
    0.12939185f, -0.01978259f, 0.04996052f, 0.11912613f, 0.00590065f, -0.00296260f, 0.03030520f, -0.06165581f, 
    -0.01155487f, 0.07474136f, -0.11348291f, -0.03517819f, 0.11768328f, 0.00436965f, 0.03971908f, -0.19621523f, 
    0.06076807f, -0.08147611f, -0.04577076f, 0.03186124f, -0.07153885f, -0.11587469f, 0.01529846f, 0.18494703f, 
    0.32115546f, -0.17683317f, -0.01490279f, -0.02824767f, -0.20330913f, 0.05358358f, -0.03535726f, -0.06792591f, 
    0.04616687f, -0.06157748f, -0.11249572f, 0.02068649f, 0.00014095f, 0.05276083f, 0.04589060f, -0.14129174f, 
    -0.00559243f, -0.02869445f, -0.06605659f, -0.04100388f, -0.10769507f, -0.06421524f, -0.02050551f, -0.01984759f, 
    -0.02957995f, -0.03218685f, 0.05432188f, 0.13116159f, 0.02996932f, -0.03031061f, -0.01922415f, 0.01026907f, 
    0.03227255f, 0.02316753f, 0.05738844f, 0.07939061f, 0.22052217f, 0.03563600f, 0.10915453f, 0.07121181f, 
    -0.00652674f, -0.02092189f, -0.14516485f, 0.01259072f, -0.07467873f, -0.11566974f, -0.00373900f, 0.06751063f, 
    0.08173759f, 0.25053191f, -0.01792456f, 0.01508681f, 0.00581270f, 0.02989444f, 0.04898213f, 0.13331214f, 
    0.07400648f, 0.01497817f, 0.01247315f, 0.04399193f, -0.25478253f, 0.14231774f, 0.15723975f, 0.09624826f, 
    -0.04742480f, -0.09999412f, -0.01818972f, 0.00536260f, -0.08989428f, -0.04367179f, 0.03262167f, -0.01600346f, 
    0.17470169f, 0.10150769f, 0.11202136f, -0.06366104f, 0.00323451f, 0.08043502f, 0.08864632f, 0.02441438f, 
    -0.03472766f, -0.03764438f, -0.00470267f, 0.00832161f, -0.18561047f, 0.03307321f, 0.13652392f, -0.21944888f, 
    -0.01328005f, 0.06666251f, -0.01294284f, 0.04670356f, -0.00572603f, 0.08401902f, -0.01682426f, -0.16259885f, 
    0.24051833f, 0.06292211f, -0.02939016f, -0.00048379f, -0.01217823f, -0.04875032f, -0.12479779f, -0.03681980f, 
    0.02047232f, 0.05848139f, 0.02554378f, -0.02622026f, 0.05264853f, 0.23717913f, 0.07202092f, -0.03886328f, 
    -0.04759771f, -0.08595227f, 0.08503101f, 0.01220261f, -0.03150000f, 0.02838301f, 0.09313861f, 0.02070104f, 
    0.01027903f, -0.24762012f, 0.07916179f, 0.36380240f, 0.05874205f, -0.05485607f, -0.06388448f, -0.04549539f, 
    0.25989032f, 0.06439731f, -0.04785009f, -0.07438763f, 0.13576777f, 0.08680177f, -0.00476010f, 0.00007265f, 
    -0.00696258f, 0.03711088f, 0.03715563f, -0.03719244f, 0.04984939f, -0.01214879f, 0.02288951f, 0.08039369f, 
    -0.06933203f, 0.11360474f, 0.16868232f, 0.16896006f, -0.04646703f, 0.03794054f, 0.11017623f, 0.04035381f, 
    -0.00857741f, -0.08223830f, -0.20965852f, -0.05809636f, 0.26800448f, 0.04457033f, 0.15990172f, -0.04782033f, 
    -0.00892365f, -0.05327664f, -0.05023425f, 0.03747454f, -0.02459439f, 0.09284963f, -0.01152480f, -0.03952645f, 
    0.23728985f, 0.05745846f, 0.12504122f, -0.03528051f, 0.06177641f, -0.03931541f, 0.00786821f, 0.08892896f, 
    -0.06654520f, 0.00422984f, -0.02285195f, -0.08044560f, 0.19223988f, 0.17519464f, 0.00423780f, 0.00149134f, 
    0.00496108f, 0.01616900f, -0.04935417f, 0.04735767f, -0.06328369f, 0.05064141f, -0.03123890f, -0.13579749f, 
    0.29245299f, 0.22252579f, 0.08169884f, 0.04026710f, -0.10372186f, 0.00437392f, 0.02162897f, 0.07711591f, 
    -0.00629089f, 0.03187426f, 0.06854107f, 0.02922874f, 0.20103666f, 0.00964485f, 0.06531834f, -0.05360031f, 
    -0.08755738f, -0.02313888f, -0.00516815f, 0.03876370f, -0.12422126f, 0.05670042f, -0.06704761f, -0.03721264f, 
    0.03366383f, -0.00853289f, 0.09715892f, -0.07109176f, 0.01609739f, -0.00813313f, -0.01306431f, 0.00278499f, 
    -0.22334720f, -0.09139023f, 0.05943290f, 0.03805215f, -0.13962200f, -0.09540274f, -0.08766132f, 0.14175278f, 
    0.03853001f, 0.03501605f, 0.01908842f, 0.03337447f, 0.05115294f, 0.00062994f, -0.16540703f, -0.02268703f, 
    0.05403022f, -0.04414619f, -0.04998106f, -0.00110509f, 0.02500097f, 0.07672583f, 0.10964811f, -0.04960512f, 
    -0.00197050f, 0.09599758f, -0.00739034f, -0.10304032f, 0.03714067f, -0.07019989f, -0.10084365f, -0.09294472f, 
    0.09211843f, 0.02234596f, -0.07167832f, -0.04946629f, -0.03880895f, 0.02197214f, 0.03107671f, 0.10190362f, 
    0.12192846f, -0.04508035f, -0.00611390f, -0.00015391f, 0.00064732f, 0.16268103f, -0.14762600f, 0.01547773f, 
    0.05551978f, -0.09390394f, -0.17876191f, -0.13185625f, 0.06185764f, -0.00321696f, 0.13469122f, 0.07257851f, 
    -0.02218175f, 0.04346312f, -0.06949367f, 0.02615118f, 0.04339669f, -0.07898372f, -0.09257693f, -0.04363479f, 
    0.02536360f, 0.00468697f, 0.08505042f, 0.04314439f, -0.01690054f, 0.01530960f, 0.03737801f, 0.00775442f, 
    0.04803088f, -0.07957621f, 0.08122082f, -0.02273419f, -0.52757758f, -0.06965786f, 0.17294255f, -0.00215098f, 
    -0.05737264f, -0.02864872f, 0.04768245f, 0.06835609f, 0.05234768f, -0.08260911f, -0.06324492f, 0.00758136f, 
    0.02854556f, -0.02128032f, 0.00150732f, 0.01808778f, 0.01534614f, -0.03238086f, -0.01129415f, 0.01002739f, 
    0.00811614f, 0.02639226f, -0.02931874f, 0.01700854f, 0.02471248f, 0.00043824f, -0.03374997f, 0.04149292f, 
    0.02443772f, 0.01119326f, -0.01412427f, -0.01489453f, -0.02714335f, -0.00266604f, 0.00577629f, 0.00594648f, 
    -0.00339725f, 0.00666276f, 0.00985120f, -0.01438200f, -0.00628000f, 0.00595927f, -0.02469742f, -0.03449582f, 
    0.02785772f, 0.00651340f, -0.00998289f, -0.03421907f, 0.00304609f, -0.03544269f, 0.00623708f, 0.01825982f, 
    0.02972865f, -0.03370975f, -0.01176916f, -0.02516002f, -0.01601708f, -0.01791459f, 0.01685173f, -0.02306477f, 
    -0.04089299f, -0.03779355f, 0.01999545f, -0.03390929f, -0.00200430f, -0.01597774f, -0.02058434f, -0.01059385f, 
    -0.03377599f, -0.00556595f, 0.00020920f, -0.01551535f, -0.03259439f, -0.03458456f, 0.01295615f, 0.01047439f, 
    -0.02824306f, -0.02108454f, -0.01166059f, 0.02890463f, 0.00842227f, -0.04207201f, 0.02563936f, 0.02455673f, 
    0.02531899f, -0.00030906f, 0.01437328f, -0.02911606f, -0.02200009f, -0.01249958f, 0.02819802f, -0.02393315f, 
    -0.02517253f, -0.00968406f, 0.01516132f, -0.03198866f, -0.03854291f, -0.03639795f, 0.02815004f, -0.00300795f, 
    0.01271748f, 0.02695633f, -0.01023196f, -0.00054659f, 0.00749548f, 0.02663982f, -0.01328389f, -0.01190174f, 
    0.00680998f, -0.02028425f, -0.02994121f, 0.02182181f, 0.02991359f, 0.01220080f, 0.01641467f, -0.03429597f, 
    -0.02831377f, -0.03169108f, -0.02398501f, -0.00316350f, 0.01907709f, -0.04154897f, 0.02897718f, -0.02032989f, 
    -0.04102477f, 0.00203297f, -0.02584630f, -0.04137973f, -0.03040741f, -0.00087919f, -0.00192850f, -0.01672452f, 
    0.01687196f, -0.00827218f, 0.02729845f, 0.02998635f, -0.00952753f, -0.00808265f, -0.01408217f, -0.01363113f, 
    0.00544762f, 0.01938010f, -0.01146922f, -0.03145165f, 0.01496443f, -0.03071704f, -0.00996060f, 0.01485495f, 
    0.02755354f, 0.01705383f, -0.03993702f, -0.03224320f, 0.01866467f, -0.00398280f, -0.00366436f, 0.01215180f, 
    0.01631476f, -0.03354114f, -0.02337341f, -0.01854571f, -0.03869944f, -0.02920462f, -0.02702958f, 0.00183283f, 
    0.01480915f, 0.02456349f, -0.03157585f, -0.00904241f, -0.03256230f, -0.00782475f, -0.01364143f, 0.02621089f, 
    -0.02980712f, -0.03942936f, -0.03587784f, 0.01675322f, 0.01610956f, 0.00199119f, -0.00872629f, 0.02316776f, 
    -0.02640107f, -0.02556047f, -0.02120306f, -0.01528203f, -0.00447152f, -0.00624612f, -0.00795883f, 0.00769070f, 
    -0.01918292f, -0.03154846f, -0.02433385f, 0.02162893f, -0.01555065f, -0.02520926f, -0.03925232f, -0.03534172f, 
    -0.00295945f, -0.01389087f, 0.00399551f, -0.00854232f, 0.00655203f, 0.01921914f, -0.01736671f, 0.01298278f, 
    -0.01411089f, 0.02365018f, 0.02557145f, 0.02949916f, 0.00854638f, -0.03385345f, 0.00496867f, -0.02230940f, 
    0.00050813f, -0.03850581f, 0.00906855f, -0.03674755f, 0.01690340f, -0.01882823f, -0.01128642f, -0.03762531f, 
    -0.02846332f, -0.00502598f, -0.04197021f, 0.00892437f, 0.00534822f, -0.03208082f, 0.01005484f, 0.02725514f, 
    -0.03362800f, -0.02653121f, 0.02485418f, -0.03474066f, 0.01916721f, -0.01462243f, 0.02116857f, 0.01656894f, 
    -0.02116502f, -0.00185461f, 0.01000715f, -0.03389134f, -0.00013887f, -0.01406070f, -0.01289767f, -0.04192608f, 
    -0.01516927f, -0.03099464f, 0.00486768f, -0.01990968f, -0.04104118f, 0.00893462f, 0.01916020f, -0.00515730f, 
    0.01876476f, 0.02793029f, 0.00756982f, 0.02734518f, -0.02279821f, 0.01763055f, -0.04084640f, -0.03278609f, 
    -0.01561907f, -0.02922893f, -0.00641955f, -0.00494275f, 0.00771934f, 0.00238545f, -0.02308728f, -0.03499423f, 
    -0.03501883f, 0.01646371f, 0.02610239f, -0.03776472f, -0.01902918f, -0.00884310f, -0.00951402f, -0.02693672f, 
    0.02633501f, -0.03138573f, 0.02281874f, -0.01741911f, 0.02951533f, 0.00812315f, -0.01602038f, -0.02104614f, 
    0.00099685f, -0.00925791f, -0.02347460f, 0.01389290f, -0.00555957f, -0.02190888f, 0.02579617f, -0.01004485f, 
    -0.02193085f, 0.02545639f, -0.02478716f, 0.01954561f, -0.03059482f, 0.01452273f, -0.03756575f, 0.00449620f, 
    0.00870693f, 0.02915043f, 0.01314657f, 0.00675851f, -0.00512905f, 0.00749481f, -0.03235778f, 0.00916504f, 
    -0.03501362f, 0.00474766f, 0.01841155f, 0.00239422f, -0.00481165f, 0.02557036f, 0.00433352f, -0.02835657f, 
    -0.04153199f, 0.02463310f, -0.02610876f, 0.00042793f, -0.01127423f, -0.03420983f, -0.02387162f, -0.02798101f, 
    -0.01156716f, -0.00243289f, -0.00877703f, -0.02926138f, -0.02281849f, 0.00853987f, -0.00324644f, -0.01795213f, 
    -0.02742161f, -0.01435077f, -0.03463577f, -0.01009932f, -0.00077816f, -0.01567101f, -0.00992179f, -0.02717326f, 
    0.01754838f, 0.02523039f, -0.00500875f, -0.01775596f, 0.01789111f, 0.00661774f, -0.03594362f, -0.03763227f, 
    0.02111580f, 0.03007847f, -0.03007833f, -0.01656663f, -0.03763359f, 0.01056908f, -0.03041150f, -0.03181498f, 
    0.01926969f, -0.00458770f, -0.03986444f, -0.02634452f, 0.02832661f, -0.04019370f, 0.01106349f, 0.02745998f, 
    -0.03784468f, 0.02631579f, 0.00538291f, 0.01121570f, 0.01904564f, 0.00791466f, -0.01269004f, 0.01605207f, 
    -0.00743296f, -0.03757520f, -0.02203136f, 0.00336103f, 0.02358178f, -0.02410751f, -0.01984067f, -0.00885174f, 
    0.02485588f, 0.01238847f, 0.00236151f, 0.00699499f, -0.03091009f, -0.01888349f, -0.00515798f, 0.00891622f, 
    0.01025479f, 0.00285461f, 0.00390399f, 0.00031685f, -0.00542424f, -0.01256612f, 0.02638282f, 0.01238087f, 
    -0.00119083f, -0.00637972f, 0.02930385f, 0.00607348f, 0.00676482f, -0.03977150f, -0.01370655f, -0.01673267f, 
    -0.02500230f, -0.04114945f, 0.02660142f, 0.00691233f, 0.02724170f, -0.02583082f, -0.01604559f, 0.01329737f, 
    -0.04056131f, 0.00979301f, 0.01007176f, -0.00975419f, -0.03820638f, -0.01568756f, -0.03120738f, -0.00655834f, 
    -0.03102468f, -0.00634752f, -0.02218142f, 0.02103755f, 0.00807236f, 0.01818827f, -0.01557044f, -0.01209661f, 
    -0.02663317f, -0.02585052f, 0.02764636f, -0.03899737f, 0.00761707f, -0.01054399f, 0.01351354f, -0.00182128f, 
    0.00993427f, 0.01232579f, -0.03480309f, -0.01874776f, -0.03441008f, -0.01527032f, -0.03866108f, -0.03698673f, 
    -0.04162294f, 0.00185248f, -0.02233572f, -0.00379524f, -0.03450651f, -0.01612363f, -0.01403172f, -0.02097059f, 
    -0.01631272f, 0.02195698f, -0.00581666f, 0.01507270f, -0.02794417f, -0.02953752f, 0.02356145f, 0.02854958f, 
    -0.01745885f, -0.03477827f, -0.01279882f, 0.01041156f, -0.00217081f, 0.00023799f, -0.02458799f, -0.01592790f, 
    0.01312898f, 0.02161012f, 0.02935115f, -0.01330455f, -0.04149431f, 0.00419545f, 0.02036965f, -0.01157463f, 
    -0.03784385f, -0.04106163f, -0.00908350f, 0.01380719f, -0.02556766f, 0.02522092f, 0.00491145f, -0.01458967f, 
    -0.01205932f, -0.01579246f, 0.02897698f, -0.00061414f, -0.00870745f, -0.02188680f, -0.00556390f, -0.02046109f, 
    -0.02336762f, 0.01341890f, -0.01401825f, -0.02339314f, -0.03990240f, 0.02265374f, -0.03722515f, 0.00683589f, 
    0.01836991f, 0.01359837f, -0.04031751f, -0.00964553f, -0.01575379f, -0.01532036f, -0.01135412f, 0.01021422f, 
    0.02971182f, 0.01459055f, -0.03173973f, 0.01872389f, -0.02700276f, 0.01775361f, -0.02329196f, 0.00122613f, 
    -0.02431494f, -0.00827866f, -0.01772757f, -0.00145629f, -0.01082427f, -0.00901304f, -0.03595949f, 0.02510007f, 
    0.00158569f, -0.00778128f, -0.00869553f, -0.02461106f, -0.01150353f, -0.03549325f, 0.00140819f, 0.02814762f, 
    -0.00488208f, -0.02754578f, -0.00366130f, -0.02095953f, 0.01296546f, 0.00931255f, 0.01049349f, 0.01266144f, 
    0.00157480f, 0.02678475f, -0.03885438f, -0.03304838f, 0.02878792f, 0.02375901f, -0.03922174f, -0.00981364f, 
    0.02031704f, -0.02555490f, -0.02022516f, 0.00971871f, -0.00906174f, -0.03732958f, -0.02338079f, -0.02210067f, 
    -0.01458067f, 0.02670312f, 0.01230651f, -0.02242933f, 0.01803724f, -0.00027327f, -0.03764768f, -0.04120073f, 
    0.02764287f, -0.01496590f, 0.01216198f, 0.02360551f, 0.00339292f, -0.00151643f, 0.00711210f, -0.03934653f, 
    -0.02933465f, 0.02117549f, 0.01789306f, 0.00033378f, -0.02670278f, -0.01981948f, 0.02593172f, -0.00182112f, 
    -0.02551928f, 0.01603236f, 0.00694132f, 0.00466503f, 0.00844696f, -0.01552323f, 0.00152765f, 0.02660584f, 
    -0.04034634f, 0.01115957f, -0.03732945f, -0.01365784f, -0.01086693f, 0.00741007f, 0.00591104f, -0.01168971f, 
    0.01966781f, -0.01699156f, -0.02793574f, 0.00110950f, 0.02037374f, -0.03489299f, -0.00650606f, -0.00531552f, 
    -0.04163849f, 0.02626798f, 0.00080923f, 0.02305997f, -0.00538643f, 0.02592527f, -0.03617047f, 0.02878747f, 
    -0.03321021f, -0.01521020f, 0.00023743f, -0.01861507f, -0.00462705f, -0.00323930f, 0.00333776f, -0.01710478f, 
    -0.01167939f, -0.01379836f, 0.00907763f, -0.01625376f, -0.01099384f, 0.01350186f, -0.02805937f, -0.01927554f, 
    0.02841674f, 0.02509826f, -0.02453615f, -0.02020203f, 0.02390265f, 0.01034877f, 0.01717017f, -0.03091627f, 
    0.03180293f, 0.01420195f, -0.00774298f, -0.03300875f, -0.02825979f, 0.02193095f, -0.01914633f, -0.00064185f, 
    0.01489152f, -0.02502320f, -0.00373799f, -0.01074266f, -0.00898209f, -0.04199442f, 0.00959505f, -0.02220381f, 
    0.01914707f, -0.03716080f, 0.02117513f, 0.01400458f, 0.02619608f, -0.02131927f, 0.01785648f, -0.03102160f, 
    -0.00750158f, 0.01496310f, -0.01574770f, -0.03592801f, -0.00332882f, -0.04030509f, -0.01426122f, -0.03761475f, 
    0.01587093f, 0.02035482f, -0.04082871f, -0.03670037f, -0.02924781f, -0.02932629f, 0.00801804f, -0.00326475f, 
    -0.02508124f, -0.01831191f, 0.01002659f, -0.00043517f, -0.00355985f, 0.02104213f, 0.01809135f, 0.00709031f, 
    0.02672062f, -0.03027275f, 0.02279358f, 0.00289047f, -0.03000965f, 0.01491632f, -0.01087152f, -0.01862863f, 
    -0.03921136f, 0.02099898f, -0.02996637f, 0.01574086f, 0.00698297f, -0.01348056f, -0.01531308f, 0.02066631f, 
    -0.01364795f, -0.03375975f, -0.01565512f, -0.00210802f, 0.02555828f, -0.01743305f, -0.02087859f, 0.02496343f, 
    0.00705208f, 0.00839658f, 0.01085113f, -0.03326764f, 0.00125142f, 0.01266378f, 0.00720578f, 0.01307113f, 
    0.01870036f, 0.00300615f, 0.02248198f, -0.02963268f, 0.02456959f, -0.03780129f, -0.01139754f, -0.02811784f, 
    -0.03819383f, -0.01684919f, 0.01757257f, 0.02878093f, 0.00150805f, -0.02810604f, -0.03827373f, -0.00606799f, 
    0.02560392f, -0.03872155f, -0.03397097f, 0.02653189f, 0.01754157f, -0.01025427f, 0.02437548f, -0.03366782f, 
    -0.03358108f, -0.03176450f, -0.02614445f, -0.01247931f, 0.02549429f, -0.00836834f, 0.02249629f, 0.02207718f, 
    0.01317613f, 0.01417612f, -0.03927171f, 0.02359806f, -0.01092840f, 0.00402775f, -0.04114128f, 0.00889635f, 
    -0.02094039f, 0.00376738f, 0.01600006f, -0.00932478f, -0.00743492f, 0.01970942f, -0.02184228f, -0.00100587f, 
    -0.02384419f, 0.00881871f, 0.01287821f, -0.03211563f, -0.00897959f, -0.02475704f, -0.00321557f, -0.03072523f, 
    0.00255790f, 0.00151333f, -0.01773917f, 0.00917121f, 0.00861691f, 0.02086887f, 0.00596547f, -0.00370762f, 
    -0.03330708f, 0.02420018f, -0.02453397f, -0.02247700f, -0.01702221f, -0.02882228f, 0.03129603f, 0.03389004f, 
    -0.00816330f, -0.01945612f, -0.01547019f, -0.01242402f, -0.00113484f, 0.00402613f, 0.02770475f, -0.02215008f, 
    -0.02929040f, -0.03424318f, -0.00290103f, -0.03495215f, -0.01487178f, -0.02150118f, -0.00980013f, -0.03091254f, 
    0.00579490f, -0.02797995f, 0.01489604f, -0.01661636f, -0.03339046f, -0.03753092f, -0.00080773f, 0.01113153f, 
    -0.02135805f, -0.00766894f, -0.02938790f, 0.01713680f, 0.00234406f, -0.01064325f, 0.01000902f, -0.02647446f, 
    0.00704286f, -0.00826956f, -0.03520678f, -0.00362278f, -0.00948442f, -0.00799306f, 0.02607561f, 0.00266006f, 
    -0.04376144f, -0.00894328f, -0.01251587f, 0.00027848f, -0.01367314f, 0.03111048f, 0.02842489f, -0.00601991f, 
    0.02188860f, -0.01321792f, -0.03091541f, -0.01154634f, 0.01982947f, -0.02277652f, -0.02143241f, -0.02329468f, 
    -0.02562324f, -0.03811479f, 0.02387910f, 0.02813238f, 0.01474799f, 0.01816171f, -0.02854135f, -0.00857537f, 
    0.02696721f, -0.00080558f, 0.02613772f, -0.01114077f, -0.03554734f, 0.00809231f, 0.02661360f, -0.03426218f, 
    0.00373018f, -0.00274779f, -0.03602346f, -0.02246741f, -0.01238332f, 0.02784026f, 0.02985720f, -0.02523762f, 
    -0.03296590f, -0.03067941f, 0.00746628f, 0.02199408f, -0.01315339f, -0.02580473f, -0.00945538f, 0.02352278f, 
    -0.00746576f, -0.00723086f, -0.00825934f, 0.02250368f, -0.03098501f, -0.00652613f, -0.00943372f, -0.01460825f, 
    -0.01972616f, 0.00557458f, 0.01202414f, -0.00817534f, 0.00943908f, -0.01205145f, -0.02885528f, -0.03210960f, 
    -0.00081306f, -0.03929633f, -0.00572218f, 0.00551271f, -0.00865119f, 0.00681139f, 0.01879122f, 0.02752063f, 
    0.01583365f, -0.01713417f, -0.02059586f, -0.02937793f, -0.01003892f, 0.02852401f, -0.03242838f, -0.02639013f, 
    0.03043626f, 0.02628186f, 0.02661136f, -0.03068581f, 0.00561256f, -0.01460178f, 0.01384158f, -0.01702685f, 
    0.01157538f, -0.00889426f, -0.02854246f, -0.03458221f, -0.01405192f, -0.03697113f, -0.03212570f, -0.01175062f, 
    -0.01593366f, -0.02154545f, 0.01228946f, 0.01981751f, -0.01535313f, -0.02068696f, 0.00797978f, -0.00511330f, 
    -0.00824185f, 0.02662196f, 0.01855636f, 0.02364504f, -0.01745409f, -0.03376296f, -0.02941881f, -0.01445080f, 
    0.00872288f, -0.01175250f, -0.00125831f, 0.01172207f, -0.00053238f, -0.03439023f, -0.03937021f, 0.01724639f, 
    -0.02756157f, -0.00872599f, -0.03498748f, 0.01104420f, 0.01711095f, 0.00996059f, 0.00342120f, -0.00296140f, 
    0.00828929f, -0.00839460f, 0.02100868f, -0.02204645f, -0.01128780f, -0.01351576f, 0.02565045f, -0.01423107f, 
    -0.03612597f, 0.00811973f, -0.02334482f, 0.00287682f, -0.03287523f, -0.01720457f, -0.01070748f, 0.00142971f, 
    -0.00846302f, 0.01309672f, 0.02639071f, -0.02050331f, -0.02191840f, -0.01636536f, 0.02554603f, -0.00946289f, 
    0.00342651f, 0.02549557f, -0.04048299f, 0.02532559f, 0.02719950f, -0.00112475f, 0.02720917f, 0.02357767f, 
    -0.02049188f, 0.02579592f, 0.03315151f, 0.01368434f, -0.03272887f, 0.02194741f, -0.04079626f, -0.01890395f, 
    -0.02613890f, -0.00351111f, -0.02096522f, -0.02591346f, 0.00876212f, 0.02274934f, 0.00673700f, 0.00945154f, 
    -0.01668994f, 0.00883573f, -0.01909356f, -0.01328005f, -0.03091305f, -0.02839390f, -0.03276315f, -0.03202743f, 
    0.02498188f, 0.00107088f, -0.00663980f, -0.01874532f, -0.02772162f, 0.02074146f, 0.01547031f, 0.01859271f, 
    -0.00631822f, 0.01650160f, 0.00137228f, 0.02498585f, -0.02192611f, -0.04275494f, -0.03150108f, -0.02214369f, 
    0.02627914f, -0.02730003f, 0.00312564f, 0.01211698f, 0.00269256f, 0.00473783f, -0.00284529f, -0.02323835f, 
    -0.03631815f, -0.02692225f, -0.02410462f, 0.02346723f, -0.03845888f, -0.01257137f, -0.00551823f, -0.00474658f, 
    -0.03028735f, -0.01559338f, -0.02163757f, -0.02589880f, -0.00684835f, -0.02518498f, 0.02133163f, -0.01233574f, 
    0.02420911f, -0.00549729f, 0.00385449f, 0.03182189f, 0.00845143f, -0.00282938f, 0.01931346f, -0.03138292f, 
    -0.00053169f, 0.01315818f, -0.02623137f, -0.03308294f, 0.00834392f, -0.02045209f, 0.02027184f, 0.00500586f, 
    0.01292129f, -0.01290721f, -0.01795712f, 0.01415404f, -0.02645972f, 0.00767332f, 0.00846628f, -0.01509135f, 
    0.01711808f, -0.03280876f, 0.00132051f, -0.01266588f, 0.03299295f, -0.00504526f, -0.03642966f, 0.02455454f, 
    0.02396560f, 0.00414466f, 0.03149353f, 0.01702125f, 0.00880343f, 0.00635563f, -0.01253517f, 0.00841873f, 
    0.00785443f, -0.01693910f, 0.01569409f, -0.00200282f, -0.00031057f, 0.00166445f, 0.00568910f, 0.00470836f, 
    -0.00846602f, -0.01746066f, -0.00249020f, -0.00243410f, 0.00875523f, 0.01634739f, -0.00540358f, 0.02887452f, 
    -0.03603591f, 0.00578990f, -0.03704282f, -0.03027304f, 0.02853584f, -0.03735869f, 0.00216366f, 0.00161118f, 
    0.02764660f, 0.01628343f, 0.01810925f, 0.01926409f, -0.03615943f, 0.01364756f, 0.00510394f, 0.00965186f, 
    0.02442088f, 0.01015966f, -0.01674194f, -0.00106292f, -0.00080161f, -0.01194499f, 0.01302860f, 0.02226243f, 
    -0.02036437f, -0.02577258f, 0.01329702f, -0.01689689f, 0.02572383f, -0.02641469f, -0.00707141f, -0.03311579f, 
    -0.02587399f, -0.00066785f, 0.01520354f, -0.01864767f, 0.02278687f, 0.02945233f, 0.02120468f, 0.00235272f, 
    0.03180649f, 0.01599669f, -0.00394714f, 0.01704466f, -0.01101190f, 0.00184457f, -0.01121428f, 0.01065659f, 
    0.03174333f, -0.04306116f, -0.01931681f, -0.00689174f, 0.02380924f, 0.01663992f, -0.02236482f, -0.01524789f, 
    -0.01437993f, -0.00082507f, -0.01071761f, 0.00454337f, -0.02625302f, -0.01330971f, -0.04302344f, -0.02464716f, 
    0.00408242f, -0.03534056f, -0.02656262f, 0.02264675f, -0.00079529f, 0.00139630f, -0.00405723f, 0.02500119f, 
    -0.02485899f, 0.03302122f, -0.00923928f, -0.03263880f, -0.02301292f, -0.00949114f, -0.00734760f, -0.00973550f, 
    0.00078375f, -0.00478973f, 0.00100437f, -0.00363972f, -0.00465712f, -0.01410538f, -0.01910888f, 0.02715842f, 
    -0.00643052f, -0.03182657f, -0.02505966f, 0.00703967f, 0.02221124f, 0.02116057f, -0.03464844f, -0.03592345f, 
    -0.01629347f, -0.02468179f, 0.01235628f, -0.01464469f, -0.01273250f, 0.02459096f, 0.02918229f, -0.01277358f, 
    -0.03745054f, -0.01401471f, 0.02064199f, 0.00737403f, 0.01078633f, -0.04215177f, 0.00916115f, 0.01676649f, 
    0.02179295f, -0.00091970f, 0.01279778f, -0.03714357f, 0.02681999f, -0.02839380f, 0.01547064f, -0.02411720f, 
    -0.00961542f, -0.02734946f, 0.04114005f, 0.01297943f, 0.00062118f, -0.03053922f, 0.00610139f, -0.02680394f, 
    -0.01187857f, 0.01685989f, -0.00082179f, -0.00443896f, -0.00163319f, -0.01762792f, 0.01556056f, 0.00276575f, 
    -0.00295574f, -0.03960600f, 0.02126748f, -0.00523041f, 0.02590148f, -0.02198628f, -0.00624117f, 0.00387753f, 
    -0.02640809f, 0.01037622f, 0.02690187f, -0.00139992f, 0.01666200f, 0.01677828f, -0.03102896f, -0.02751795f, 
    -0.02991152f, 0.01558633f, -0.02087189f, 0.01878553f, -0.01032598f, -0.04362811f, -0.00554333f, -0.01363839f, 
    -0.01686133f, 0.02440752f, 0.00400362f, 0.00694813f, -0.00342648f, -0.00370899f, 0.01187768f, 0.00612412f, 
    0.01810325f, -0.02857889f, -0.01621124f, 0.01062862f, -0.03047374f, 0.03237695f, -0.01155182f, 0.00417559f, 
    0.01159486f, 0.01079967f, -0.01295342f, -0.02085683f, -0.03247027f, -0.01352496f, 0.01008854f, 0.02464108f, 
    -0.03252232f, 0.01275833f, 0.01200116f, 0.02221031f, -0.01546270f, 0.03321405f, 0.01581034f, -0.00361540f, 
    -0.02096310f, -0.02622739f, -0.00204377f, -0.03251015f, 0.00569422f, -0.01823735f, 0.00006712f, 0.00697454f, 
    -0.02215404f, -0.01423992f, 0.02259629f, -0.01899693f, 0.00596389f, -0.00390187f, -0.01564776f, 0.01020739f, 
    -0.03379419f, -0.02255799f, -0.01605102f, -0.02823660f, -0.03465838f, -0.03147715f, -0.00464296f, 0.02660686f, 
    0.03217940f, 0.00708703f, -0.01958704f, 0.00779633f, -0.00943725f, 0.02374581f, 0.01595692f, 0.00538871f, 
    0.01653989f, -0.01507784f, -0.00086893f, 0.00412379f, -0.00316873f, 0.00015252f, -0.00816944f, -0.02960944f, 
    -0.00409436f, 0.00941137f, -0.03153937f, -0.03507768f, 0.00039494f, 0.00601945f, -0.03068565f, 0.02661768f, 
    -0.02892019f, 0.01344758f, 0.00993922f, -0.00730698f, -0.03207648f, -0.02952825f, 0.01056478f, 0.00024703f, 
    -0.03680274f, 0.01893324f, -0.03671627f, 0.01244595f, 0.00631892f, 0.00509158f, 0.02776523f, -0.02832196f, 
    -0.00433848f, 0.01214884f, -0.02964702f, -0.03673129f, -0.03404015f, 0.00295197f, 0.00702651f, 0.01169378f, 
    0.00301671f, -0.03238837f, -0.03665862f, 0.02193142f, 0.00307363f, -0.00299461f, -0.02261675f, -0.01518275f, 
    -0.00224640f, -0.02790272f, -0.02962302f, -0.03043816f, 0.03497509f, -0.02902916f, 0.00103014f, 0.00559378f, 
    0.02919620f, -0.02240443f, 0.02960095f, -0.02462050f, -0.00806018f, 0.02352092f, -0.02815328f, 0.01218812f, 
    -0.00952992f, 0.02472122f, 0.02092477f, 0.01369645f, 0.00266150f, -0.00629885f, 0.00810748f, -0.01855039f, 
    0.02224706f, -0.01244207f, -0.02715773f, 0.02116041f, 0.00920032f, 0.02215636f, -0.02615061f, 0.01952717f, 
    0.00469847f, -0.00074768f, 0.01976257f, -0.02606532f, -0.03006516f, -0.01496679f, 0.00025856f, -0.04193442f, 
    -0.02708643f, 0.00478987f, 0.02536923f, 0.04092084f, -0.00599755f, 0.02991580f, 0.00398127f, -0.00729725f, 
    -0.03816629f, 0.02801126f, -0.02818500f, -0.02265796f, 0.02517776f, 0.00761574f, 0.02619549f, -0.00484499f, 
    -0.03588609f, 0.01070825f, 0.01512363f, 0.02309633f, 0.02695643f, -0.02233928f, -0.00760938f, 0.00901497f, 
    -0.00923815f, -0.03760252f, -0.01697395f, 0.01831223f, 0.01715476f, 0.00333581f, -0.02988199f, 0.01693838f, 
    -0.01392207f, -0.01388529f, 0.00432991f, 0.03078873f, 0.01078251f, -0.03663262f, 0.01810313f, -0.00539350f, 
    -0.00209449f, -0.00386394f, -0.03119420f, 0.01949802f, 0.00773861f, -0.00875152f, 0.00467383f, 0.02464454f, 
    0.01418252f, 0.01926519f, -0.03184777f, -0.04335673f, -0.02873709f, 0.01749355f, -0.00323981f, -0.01364101f, 
    -0.02765494f, -0.03954780f, 0.02995363f, -0.00199931f, 0.00007564f, -0.02275871f, -0.03351438f, -0.00451052f, 
    0.02381805f, -0.01378394f, 0.00906173f, -0.00679893f, 0.00470482f, -0.03470455f, -0.03207583f, -0.03538524f, 
    -0.01456666f, -0.03621858f, -0.01143747f, 0.00165390f, -0.03605141f, 0.04165920f, -0.01130904f, -0.02372286f, 
    -0.00489092f, -0.01343892f, -0.00057047f, 0.02029151f, -0.00178898f, -0.01056148f, -0.01896628f, 0.00223582f, 
    0.00477620f, 0.01197943f, -0.00519166f, -0.01883825f, 0.00011600f, 0.02115573f, -0.03964669f, 0.00813005f, 
    -0.03817198f, 0.03137137f, -0.00968258f, 0.00632795f, 0.01944892f, 0.01727082f, -0.02643227f, -0.00811908f, 
    -0.02365516f, 0.01532424f, -0.04116714f, 0.01552334f, -0.03575812f, 0.00005498f, -0.03472540f, -0.02730543f, 
    -0.02990642f, 0.01999385f, -0.02869655f, -0.02139816f, 0.02603758f, 0.01575396f, -0.01529951f, -0.01177111f, 
    -0.03291006f, 0.02915270f, -0.03173009f, -0.00755738f, 0.02864675f, -0.00151054f, -0.00622123f, 0.00398196f, 
    0.15036225f, -0.30518928f, 0.00964628f, -0.06805982f, 0.07711578f, 0.01102672f, -0.03405070f, 0.02009832f, 
    0.04433951f, 0.01135678f, 0.02175472f, 0.08282045f, -0.01983024f, 0.01110024f, 0.21403915f, -0.10152296f, 
    0.05728279f, 0.07283668f, 0.00251034f, 0.14020850f, -0.03329087f, -0.06402795f, 0.04290482f, 0.08545409f, 
    -0.08587834f, -0.55022120f, 0.36799636f, -0.33729917f, 0.08650153f, 0.13030496f, -0.01451432f, 0.03256615f, 
    0.01470643f, -0.01318076f, -0.10709734f, -0.07851861f, -0.09971596f, -0.01447079f, 0.01126777f, -0.09525331f, 
    -0.08791738f, -0.06403576f, 0.02033594f, 0.07685375f, 0.17599255f, -0.01567506f, 0.11992989f, 0.17848177f, 
    -0.20479800f, 0.02903770f, -0.08906360f, 0.24137628f, 0.03108716f, 0.16468993f, 0.04534366f, 0.17764698f, 
    -0.18697944f, -0.12825759f, -0.06863420f, -0.26108575f, -0.11510425f, 0.16585432f, -0.24296904f, -0.14442097f, 
    -0.12783602f, 0.11181314f, -0.01866725f, -0.16410698f, -0.12390833f, 0.04276040f, 0.00524963f, 0.07240854f, 
    0.01970846f, 0.01131050f, 0.01768740f, -0.07697257f, -0.10592217f, -0.06644074f, -0.01558822f, 0.08865374f, 
    0.03269796f, 0.05520434f, 0.02896210f, -0.02129843f, -0.15861303f, -0.05617476f, 0.04613423f, -0.06627821f, 
    -0.02215536f, 0.03055757f, -0.03325766f, 0.05258106f, -0.01855468f, 0.05295384f, 0.01330997f, -0.00086180f, 
    -0.38665915f, 0.25494182f, -0.11961555f, 0.00056165f, -0.02738025f, 0.13875665f, 0.14830337f, -0.08745897f, 
    0.05195478f, -0.06350408f, 0.03923080f, 0.04439597f, 0.16416645f, -0.17513980f, 0.13055569f, 0.16673517f, 
    -0.12665346f, 0.01577887f, -0.11432291f, -0.02926172f, 0.13415731f, 0.17255504f, 0.03600248f, 0.02851073f, 
    -0.00416947f, 0.02144356f, 0.18455724f, -0.04652833f, -0.06013776f, -0.04328693f, 0.01259698f, 0.08898572f, 
    0.10867067f, 0.03190554f, -0.06617227f, 0.07584124f, 0.07970713f, 0.13228218f, 0.00858964f, -0.02313183f, 
    -0.01069962f, -0.07380763f, -0.01932295f, 0.14945613f, -0.00982058f, 0.08774465f, 0.09189799f, -0.05314780f, 
    0.08458597f, -0.02726277f, -0.00999762f, 0.05353025f, 0.02373592f, -0.02734536f, 0.04359072f, -0.00704923f, 
    0.02736990f, -0.07785942f, -0.15510118f, 0.14456941f, 0.00229794f, 0.06505226f, 0.11643153f, 0.03985275f, 
    0.03794464f, 0.05021461f, 0.02795877f, 0.18851504f, 0.06344119f, 0.02349187f, 0.01544159f, -0.01877391f, 
    -0.01985189f, 0.07512134f, 0.14420056f, 0.18954660f, 0.00616443f, 0.10147067f, 0.12984228f, 0.09447239f, 
    -0.07588974f, -0.06385796f, -0.02527688f, -0.10844859f, -0.05958581f, -0.25801620f, 0.15099315f, 0.06257398f, 
    0.10768119f, 0.11041759f, -0.00798436f, -0.08892682f, -0.13107359f, 0.11557173f, -0.03333748f, 0.00662143f, 
    -0.04555815f, -0.19343005f, 0.02986248f, -0.25420955f, 0.20231624f, 0.11559205f, -0.00887283f, 0.09119072f, 
    -0.03693325f, 0.12797683f, 0.08609749f, -0.18773654f, 0.10953215f, 0.03344747f, -0.15381679f, 0.07142612f, 
    0.12032123f, 0.15166144f, -0.09391949f, 0.06067096f, -0.08974419f, 0.07249618f, -0.09488424f, -0.26194933f, 
    -0.03193864f, -0.17049417f, -0.08725504f, -0.09926979f, 0.05985698f, 0.06416073f, 0.02929385f, 0.05608117f, 
    -0.09013207f, 0.05693267f, -0.04983476f, -0.03059572f, -0.00591715f, -0.13565078f, -0.12217257f, -0.14610489f, 
    0.00224562f, 0.09442746f, 0.05215761f, -0.11552872f, 0.04731238f, -0.09539203f, 0.15078190f, 0.12913801f, 
    -0.17740269f, -0.37236583f, 0.00222321f, 0.11953565f, -0.12540324f, -0.02795473f, -0.06856477f, 0.00554201f, 
    0.06607947f, 0.07128403f, -0.01113804f, -0.02584117f, 0.04700187f, 0.08059202f, -0.34229261f, 0.31675515f, 
    0.01208480f, 0.15711841f, 0.04321679f, -0.18179612f, 0.19137801f, -0.15279756f, 0.03294843f, -0.01645426f, 
    -0.04665932f, 0.33870894f, 0.04267077f, -0.04112310f, -0.05024801f, -0.05319939f, -0.03662889f, -0.02480489f, 
    -0.01704688f, 0.01629189f, 0.06041729f, -0.08093739f, -0.11631557f, -0.21112572f, -0.24974887f, 0.10974349f, 
    0.02600343f, -0.04461171f, -0.01125739f, 0.01312392f, 0.01970729f, -0.08298899f, -0.00441160f, 0.13981597f, 
    -0.09110949f, -0.09912404f, 0.04102037f, 0.03263685f, 0.00479772f, -0.08483695f, -0.08118154f, 0.08633548f, 
    0.18496454f, 0.02779471f, 0.06523159f, 0.05468084f, -0.10999440f, -0.17589623f, 0.03963188f, 0.09217481f, 
    -0.02729233f, -0.00691108f, 0.02906875f, 0.03966228f, 0.16417614f, -0.01657036f, -0.03354919f, 0.11573119f, 
    -0.15631095f, -0.05878532f, 0.10526254f, -0.03741665f, -0.10873677f, -0.02639947f, -0.01093975f, 0.11509182f, 
    0.03286220f, -0.08377192f, 0.02592753f, -0.01274229f, 0.29311863f, 0.24917845f, 0.04608745f, 0.07490032f, 
    -0.17130126f, -0.11215910f, -0.15255257f, 0.02269792f, 0.07261082f, -0.00180774f, 0.01003962f, -0.02241718f, 
    -0.14952965f, 0.03547129f, -0.01284904f, 0.14428788f, 0.02539111f, 0.14293242f, 0.10459451f, -0.02330408f, 
    -0.01241023f, -0.05038035f, -0.30207279f, 0.12498694f, -0.10072112f, 0.17166355f, -0.01847190f, 0.05022454f, 
    -0.08995125f, 0.03167741f, -0.00251603f, 0.21570171f, -0.00695318f, -0.06314253f, -0.01032536f, 0.10397413f, 
    0.07378570f, 0.05018907f, -0.05220426f, 0.09246211f, -0.09796977f, -0.08348320f, 0.06453513f, 0.09807260f, 
    0.10517282f, -0.05489970f, -0.01696633f, 0.00946957f, 0.37190080f, 0.08064186f, 0.05536329f, -0.01936027f, 
    -0.25276551f, -0.01493146f, -0.11532072f, -0.11146743f, 0.03152054f, -0.03625752f, -0.06006616f, 0.03132849f, 
    -0.13187158f, -0.21143019f, -0.00312995f, 0.12312840f, 0.06629368f, 0.07105929f, -0.01664713f, 0.05569022f, 
    -0.07814440f, -0.21473664f, 0.08320917f, -0.18536563f, -0.19060737f, -0.01733395f, -0.20585488f, 0.17835712f, 
    0.04133953f, 0.12258782f, 0.08297571f, 0.00247702f, -0.09947620f, -0.10575847f, 0.00374565f, -0.04970158f, 
    0.01988588f, 0.06398902f, -0.17143553f, -0.07427709f, 0.00439457f, 0.00737961f, 0.10258637f, -0.03231383f, 
    0.07309430f, 0.12287344f, 0.01835040f, 0.07856718f, 0.15659778f, 0.06232672f, -0.16342105f, 0.19598626f, 
    0.06818450f, 0.01841591f, -0.05142885f, -0.02114896f, 0.00389339f, 0.16322689f, -0.21538286f, -0.06483110f, 
    -0.23450862f, 0.01858424f, -0.29829895f, 0.05442548f, 0.04497488f, -0.02889853f, 0.07644381f, 0.02268003f, 
    0.03257060f, -0.05497411f, -0.00560496f, -0.11447261f, -0.09832115f, 0.03404939f, 0.05874346f, -0.06746800f, 
    0.08958685f, -0.03311832f, -0.02223760f, 0.13398878f, 0.03727247f, 0.01596756f, -0.02887974f, 0.17849819f, 
    0.11331140f, -0.50380898f, 0.17567842f, 0.13939470f, -0.10343074f, 0.01314903f, -0.02374890f, 0.00696351f, 
    0.05984493f, 0.19320674f, -0.01682964f, 0.00941425f, 0.13548812f, 0.24869035f, 0.09801579f, -0.01410150f, 
    -0.05568598f, -0.17707609f, 0.05556473f, -0.08629364f, 0.03931280f, -0.09118231f, -0.03593604f, -0.04330535f, 
    -0.20910935f, -0.14148363f, -0.12384390f, 0.09549182f, 0.06409664f, 0.09293818f, 0.03377361f, -0.11101180f, 
    0.07893956f, -0.04332913f, 0.17618184f, 0.14937606f, 0.02768111f, -0.17426707f, 0.11986199f, 0.06294120f, 
    -0.15949950f, -0.13061555f, -0.14442369f, 0.12020420f, 0.04491131f, 0.04536689f, -0.00646866f, 0.02317898f, 
    -0.06746433f, 0.03995204f, 0.23146205f, 0.06973093f, 0.04092156f, -0.02434299f, 0.04844522f, 0.01528593f, 
    -0.02482227f, 0.01820369f, 0.03162558f, 0.03438247f, 0.17287579f, 0.26770288f, -0.00969313f, 0.18223786f, 
    -0.23452862f, -0.13272119f, -0.11587331f, 0.05690309f, 0.18111366f, 0.04986850f, -0.08923282f, 0.00237027f, 
    0.07893531f, -0.11086602f, 0.23940958f, -0.00462204f, 0.00413065f, 0.08684029f, -0.10969403f, 0.06434435f, 
    -0.07209097f, -0.08391428f, 0.01455947f, -0.08707378f, -0.20877831f, 0.03913027f, 0.00748569f, 0.09688093f, 
    -0.08567297f, 0.12838933f, 0.04661673f, -0.01719077f, -0.05219162f, 0.07821347f, 0.06344252f, 0.05294216f, 
    0.12470477f, -0.21206661f, 0.13499293f, -0.31555068f, 0.11590770f, -0.01538793f, -0.08086985f, -0.12320331f, 
    -0.09476291f, 0.12835948f, 0.04917828f, -0.01946753f, 0.03932016f, 0.15914771f, 0.18469322f, 0.11040580f, 
    -0.02395345f, -0.01385887f, 0.07125114f, 0.10823664f, 0.03263751f, 0.02286426f, -0.03661502f, -0.07252003f, 
    0.13896285f, -0.26230648f, -0.05853691f, 0.08509292f, -0.05497547f, -0.02345968f, 0.06347805f, 0.09172001f, 
    0.07690129f, 0.06618702f, 0.00809484f, 0.08900827f, -0.01691562f, 0.16833787f, 0.15159164f, 0.00302036f, 
    -0.03188805f, -0.09659983f, 0.09077767f, -0.13749135f, 0.14827476f, 0.04090979f, 0.03626255f, 0.06323627f, 
    0.06101329f, -0.06503776f, 0.19031806f, 0.11069865f, 0.00033420f, 0.14633162f, -0.07405770f, -0.06671469f, 
    -0.02631023f, 0.00633058f, -0.17041449f, -0.19576485f, 0.12235370f, -0.24455085f, 0.05897401f, -0.22607693f, 
    0.10073924f, -0.06784078f, 0.02599724f, 0.05420623f, 0.21479772f, -0.09676977f, 0.01434129f, 0.16088116f, 
    -0.00544012f, 0.18548243f, 0.04715928f, 0.00777406f, 0.09068592f, 0.07025858f, 0.04947636f, 0.12398230f, 
    0.01289918f, -0.04994892f, 0.02659496f, 0.11688886f, -0.09067345f, 0.15829578f, 0.06892545f, -0.08368398f, 
    -0.06055347f, 0.04012773f, 0.02858811f, 0.11611123f, 0.00721701f, 0.01737626f, -0.04509853f, -0.09233861f, 
    -0.05927983f, 0.11565658f, 0.23031621f, 0.07448141f, -0.09477518f, -0.04189217f, -0.05757912f, 0.19069429f, 
    0.12546787f, 0.11253889f, -0.05212056f, -0.05997483f, 0.27907071f, -0.03521017f, 0.25201711f, -0.08110104f, 
    -0.22554766f, -0.00237733f, -0.03716505f, -0.14502634f, 0.07212533f, -0.05884536f, 0.02221097f, -0.05622197f, 
    0.23705187f, -0.01560663f, 0.10164616f, 0.02685268f, 0.06219605f, 0.01008444f, 0.02821865f, -0.08925166f, 
    0.03744959f, 0.10719274f, 0.09281397f, 0.15971686f, 0.09848567f, -0.16484341f, -0.21222225f, 0.24272814f, 
    0.10931363f, 0.01181752f, 0.07373703f, -0.05862626f, 0.11787125f, -0.06980703f, -0.04834413f, 0.02007646f, 
    0.09888622f, 0.09675192f, 0.04432180f, -0.07237472f, -0.02109152f, 0.01725323f, 0.02723899f, 0.12085556f, 
    0.04214022f, 0.08359377f, 0.07650280f, -0.04404951f, 0.17466713f, 0.09446943f, 0.06675530f, -0.09779033f, 
    -0.10114495f, -0.23358808f, 0.01950973f, 0.00041042f, 0.12958767f, 0.03501981f, -0.05762279f, 0.10481384f, 
    -0.10674233f, -0.06516049f, 0.09440448f, -0.00927900f, -0.03230184f, 0.06989053f, -0.04205804f, 0.06323787f, 
    0.03101724f, 0.12737128f, -0.05645221f, -0.03684793f, 0.11693467f, -0.05028981f, 0.09530207f, 0.01169857f, 
    0.07872255f, 0.00213021f, 0.01552050f, -0.04109857f, -0.06710577f, 0.01199756f, 0.00214911f, 0.00177794f, 
    -0.06069371f, 0.07376271f, 0.09402468f, 0.04630145f, 0.06666352f, 0.08106162f, 0.07348654f, -0.02301241f, 
    -0.00745711f, -0.04580389f, -0.07360795f, -0.11880030f, -0.13501000f, 0.22341155f, 0.03716778f, 0.18838526f, 
    -0.10837796f, -0.06604311f, -0.02228806f, -0.02903544f, 0.06038199f, -0.15057711f, 0.06198576f, 0.11492618f, 
    -0.16468130f, -0.05664563f, -0.03564486f, -0.03260094f, -0.08855185f, -0.04751123f, -0.08299687f, 0.02151051f, 
    -0.00779959f, 0.12616710f, -0.02086695f, -0.06297533f, -0.09062085f, 0.01213827f, 0.11474466f, 0.22829762f, 
    -0.03383184f, -0.10517764f, 0.03470170f, -0.11268159f, -0.08810740f, 0.01741074f, -0.09196661f, 0.13701463f, 
    -0.05679994f, -0.04585639f, 0.11464950f, -0.15724839f, 0.07627063f, 0.03821363f, 0.02816739f, 0.04846402f, 
    0.05146311f, -0.12535994f, 0.04989940f, -0.09412600f, 0.13695793f, -0.11200642f, 0.08229611f, 0.19977665f, 
    0.09145350f, -0.00905524f, -0.03580298f, -0.08295740f, -0.01453478f, 0.11272161f, 0.03635845f, 0.13079232f, 
    -0.19481060f, 0.05161009f, 0.08284078f, 0.05559583f, -0.07371920f, -0.07145216f, 0.06373923f, 0.13207214f, 
    0.10592642f, 0.08851808f, 0.02596715f, 0.01253006f, -0.11578916f, 0.04719595f, 0.07113015f, -0.18064183f, 
    0.04549177f, 0.11559973f, -0.02142662f, -0.04595429f, -0.00917353f, 0.15436795f, -0.09166418f, 0.11865994f, 
    0.16933046f, 0.08239565f, 0.11555595f, 0.08639615f, 0.13106963f, 0.00237326f, -0.07612340f, -0.02925200f, 
    -0.11250268f, 0.11110686f, -0.00303074f, -0.10867631f, -0.02831309f, 0.22078174f, 0.10985417f, 0.04052641f, 
    0.00889361f, -0.06933766f, 0.04525565f, 0.01397002f, -0.05277003f, -0.01709344f, -0.01938929f, 0.00334632f, 
    -0.64996260f, 0.04264453f, 0.25103840f, 0.12930654f, -0.05172765f, 0.06945892f, -0.09070823f, -0.13745543f, 
    0.06148875f, 0.08035915f, 0.08430733f, 0.09355871f, 0.06116107f, 0.06744116f, 0.03852755f, 0.02350497f, 
    0.04586309f, -0.01270223f, -0.05349112f, -0.06471729f, -0.14436004f, -0.11122362f, -0.11101021f, -0.06388287f, 
    0.12720284f, 0.08449747f, -0.08316178f, 0.06948860f, -0.05219742f, 0.06874736f, 0.08713317f, 0.11785275f, 
    -0.16417709f, 0.01485492f, 0.00438148f, -0.05494669f, 0.07421677f, 0.00944611f, -0.02789396f, 0.03619379f, 
    0.10497507f, 0.04911596f, 0.08195473f, 0.02109258f, 0.07481328f, 0.00691429f, 0.06887811f, -0.00987428f, 
    0.05180942f, -0.05299664f, -0.09751787f, 0.05900357f, 0.03514775f, 0.03970256f, -0.02068215f, 0.00839335f, 
    0.04450752f, 0.00816090f, 0.05973743f, -0.02770937f, 0.07595336f, 0.13205388f, -0.01382325f, -0.03112522f, 
    0.01412013f, 0.00723662f, -0.04660467f, 0.12660331f, 0.00920327f, 0.01640603f, -0.11257938f, -0.08033908f, 
    0.11295083f, 0.00264596f, 0.09841917f, 0.02737018f, -0.06412310f, 0.02078839f, 0.13837561f, 0.11024209f, 
    0.05598352f, 0.02030052f, 0.00441834f, -0.09111918f, -0.27167711f, -0.04461026f, -0.08578839f, -0.07069520f, 
    0.00101024f, 0.01336793f, -0.03633973f, -0.03389601f, 0.02628987f, -0.01663493f, 0.07180323f, 0.01455135f, 
    0.06832640f, 0.05509553f, 0.07086007f, -0.00343173f, -0.11137081f, 0.11332521f, -0.10811696f, 0.02837684f, 
    0.00237962f, -0.06016617f, 0.16200280f, -0.09731109f, -0.10952588f, 0.12403680f, -0.04290241f, 0.10084701f, 
    -0.08814332f, -0.02671383f, -0.00615547f, 0.04462402f, 0.00899150f, 0.14336979f, 0.00788411f, 0.00897867f, 
    -0.24282494f, 0.05886105f, 0.00331615f, 0.00951119f, 0.00349207f, 0.07463755f, 0.00457512f, -0.09653210f, 
    0.06072222f, 0.19097254f, -0.00593688f, 0.14371227f, -0.11479319f, 0.02066931f, -0.00304298f, -0.13273363f, 
    -0.04022412f, -0.01580114f, -0.01016850f, -0.05058541f, 0.01002162f, 0.03480184f, 0.00511975f, 0.09660176f, 
    0.30602372f, 0.19139929f, -0.07864950f, -0.12544046f, -0.02504857f, -0.12672579f, -0.10258711f, -0.07567911f, 
    -0.05020152f, -0.06916848f, -0.07330498f, -0.07772148f, -0.11492349f, -0.03738226f, -0.12738508f, -0.08405162f, 
    0.00235239f, -0.05361249f, 0.02059730f, -0.00910290f, 0.07968526f, -0.15092658f, -0.07166938f, 0.04247485f, 
    -0.15385298f, -0.18985716f, -0.00722814f, 0.43427899f, -0.05685685f, 0.03940421f, 0.08946885f, -0.24828750f, 
    0.05364224f, 0.00436719f, 0.09650369f, 0.01642153f, 0.28981110f, 0.13846381f, -0.11266234f, 0.00112541f, 
    0.03833940f, -0.12418337f, 0.04374797f, 0.06803967f, -0.05699751f, 0.06682787f, -0.13131340f, -0.14648257f, 
    0.19268179f, 0.02719356f, -0.13268793f, 0.10744533f, 0.02421443f, -0.01974700f, -0.09371946f, 0.10449663f, 
    -0.05769281f, -0.12890644f, -0.10064229f, 0.09466634f, 0.09422971f, 0.04027348f, -0.05260862f, 0.05846608f, 
    -0.04126963f, 0.11525237f, -0.02979671f, -0.01628720f, -0.08125973f, -0.01410517f, -0.31408873f, -0.09601249f, 
    0.27362445f, 0.18475412f, 0.07732998f, 0.07085941f, 0.16193803f, 0.01025991f, -0.01124036f, 0.06520154f, 
    -0.01126508f, 0.00922264f, -0.05577232f, 0.09305333f, 0.42958742f, 0.13182256f, 0.03896341f, 0.07806385f, 
    0.01747659f, 0.02405161f, 0.08248425f, 0.02871971f, -0.00078109f, -0.01329004f, -0.03559581f, 0.07204376f, 
    -0.15662289f, 0.11766524f, -0.16167897f, -0.05874508f, -0.14948042f, 0.17702018f, -0.05332397f, 0.02517743f, 
    -0.13395549f, 0.03601777f, 0.01971808f, -0.16042237f, -0.09721096f, -0.00692789f, 0.27565852f, 0.12732103f, 
    -0.17228545f, -0.09364332f, 0.05749483f, 0.05099829f, -0.10602539f, 0.07881947f, 0.07146216f, -0.18905586f, 
    0.25563356f, 0.09477048f, 0.18921354f, 0.25278652f, 0.05307559f, 0.17033769f, 0.01756971f, -0.05177395f, 
    -0.17992581f, -0.08444717f, -0.05304534f, -0.01789514f, 0.02544813f, 0.33240366f, -0.08042900f, -0.02660594f, 
    0.02246249f, 0.04673630f, -0.06913529f, -0.02981468f, -0.06736389f, 0.03263414f, 0.00028713f, 0.02358225f, 
    -0.23495580f, 0.05323512f, 0.06293901f, 0.09264667f, 0.05434164f, 0.01297379f, -0.00439874f, -0.02525762f, 
    0.03902074f, -0.02214977f, 0.14008784f, 0.06541473f, -0.01665191f, 0.02019832f, 0.00895881f, -0.14743882f, 
    -0.03403369f, -0.09724014f, 0.10611418f, 0.08406826f, 0.05830632f, 0.01475973f, 0.01346772f, 0.00333414f, 
    -0.06929276f, 0.02418889f, -0.01806604f, -0.19505672f, 0.03400268f, 0.06923429f, 0.01990290f, 0.03911186f, 
    -0.03574784f, 0.11566474f, 0.03613578f, 0.10551182f, -0.16718802f, 0.01620318f, -0.33995047f, 0.05528666f, 
    -0.07399029f, -0.09979463f, 0.16534576f, 0.06702027f, -0.00939044f, 0.08357964f, -0.00000784f, -0.03278602f, 
    -0.21375784f, -0.05190420f, -0.00786265f, -0.14075580f, 0.00575342f, 0.10924634f, -0.01307765f, 0.04327567f, 
    0.01272355f, 0.05098334f, 0.06603048f, 0.13807414f, -0.02796396f, 0.08323156f, 0.16912781f, -0.04046658f, 
    0.06263893f, -0.10966223f, -0.04041668f, 0.07743344f, -0.00989302f, -0.06408186f, 0.06245850f, 0.02891150f, 
    -0.04581037f, 0.24167846f, -0.16879441f, -0.02563433f, 0.00431903f, -0.00761029f, -0.01716281f, -0.21951917f, 
    -0.10603439f, -0.20229185f, -0.09962099f, -0.02729957f, 0.21753196f, 0.03710122f, 0.03735052f, -0.07816485f, 
    0.17312299f, 0.06146355f, 0.11331521f, -0.02663074f, 0.09262835f, 0.05442509f, 0.11799811f, 0.18841904f, 
    -0.16097823f, 0.01942497f, 0.02048616f, -0.04636363f, 0.00679591f, -0.00260857f, -0.06086570f, -0.08102947f, 
    0.04240556f, 0.03692573f, -0.01927896f, -0.02034763f, 0.07380366f, -0.06257933f, 0.12096604f, 0.04029215f, 
    0.13487303f, -0.04365142f, -0.14193788f, -0.07611300f, 0.10568034f, 0.04909958f, 0.00632441f, -0.05919627f, 
    0.15222140f, 0.30485621f, 0.02408196f, 0.18196559f, -0.02347315f, 0.03629304f, -0.02092858f, 0.22193567f, 
    0.06363161f, 0.02476660f, 0.02644827f, -0.02321606f, 0.41138026f, 0.24277049f, 0.05374524f, -0.07036868f, 
    0.07583577f, 0.03164567f, 0.01039046f, 0.00371335f, -0.03754823f, 0.04435453f, 0.06464897f, 0.01441087f, 
    -0.26040998f, -0.09084390f, -0.00943315f, 0.20120829f, 0.13327599f, 0.08208346f, 0.06399793f, -0.11095933f, 
    0.04246508f, -0.00409917f, 0.19522385f, 0.19290344f, -0.19582887f, 0.15643419f, 0.04834794f, 0.00877150f, 
    -0.00618845f, 0.04958495f, -0.10130996f, -0.00278762f, -0.02737972f, -0.05005869f, 0.11563464f, 0.13995300f, 
    -0.06337444f, 0.01268876f, 0.02569006f, -0.08722071f, -0.08075952f, 0.06954397f, -0.01231160f, -0.00823372f, 
    -0.00071358f, 0.11365867f, 0.01769851f, -0.03350653f, -0.00386171f, 0.03005263f, -0.02359291f, 0.20733446f, 
    -0.02472778f, 0.09972803f, 0.09495164f, 0.19145767f, -0.00925095f, 0.05630495f, 0.05575072f, 0.02583458f, 
    -0.01515376f, -0.11107630f, -0.00957679f, 0.15163815f, 0.07381866f, 0.02692770f, -0.00036766f, -0.01343533f, 
    0.01772469f, 0.05840158f, -0.04133191f, -0.06536815f, 0.17068443f, 0.15603572f, -0.10991441f, 0.19047493f, 
    0.06498566f, -0.05489729f, 0.02842600f, -0.07903677f, -0.04041553f, 0.00449069f, -0.12814008f, 0.04933849f, 
    0.12828811f, 0.15196081f, -0.00208326f, 0.06330095f, -0.02593110f, 0.10456001f, 0.08022743f, -0.06826294f, 
    0.07343245f, 0.04187619f, 0.11207750f, 0.23206748f, 0.01064696f, 0.02599715f, 0.12612045f, -0.14461882f, 
    0.01691650f, -0.08200783f, -0.05862033f, 0.02125482f, -0.16959128f, 0.13387325f, 0.00852342f, -0.03815069f, 
    0.14405277f, 0.10969993f, 0.18652515f, 0.05036012f, 0.07292464f, -0.03895424f, 0.03565732f, 0.07602613f, 
    -0.08431848f, -0.00020033f, -0.19746205f, -0.08190161f, 0.04418822f, 0.08427167f, -0.02304386f, 0.16575770f, 
    -0.03545646f, -0.01998800f, 0.00555447f, 0.03858435f, -0.12270078f, -0.00976547f, -0.12120027f, -0.06604825f, 
    0.13972184f, 0.07719826f, 0.04282302f, 0.21067560f, -0.13361108f, 0.01323089f, 0.02708573f, 0.11900873f, 
    0.00190086f, 0.04669917f, 0.03993810f, -0.04028979f, 0.12650196f, 0.03573022f, 0.04731384f, -0.06924867f, 
    0.07846955f, 0.01011839f, 0.09139109f, -0.01857822f, -0.05792550f, 0.02624589f, -0.03259293f, 0.04755158f, 
    -0.31964722f, -0.02232455f, 0.05020339f, -0.02443155f, 0.04042450f, -0.04655952f, -0.09807698f, -0.07540652f, 
    -0.15817635f, -0.05084089f, -0.12166913f, -0.05292897f, 0.13863166f, 0.04691330f, -0.05533978f, -0.09625882f, 
    0.02458105f, -0.04356830f, -0.06172271f, -0.13757911f, -0.00085829f, -0.03538978f, -0.13895063f, -0.02839131f, 
    0.05074163f, -0.04992937f, 0.02111365f, 0.11469557f, 0.03405704f, 0.04661767f, 0.04276628f, -0.09829761f, 
    0.11445948f, 0.06961375f, 0.11120468f, -0.02713322f, 0.23383078f, 0.00425036f, 0.18503317f, 0.07038828f, 
    0.16095026f, 0.05299211f, -0.02203838f, 0.00016550f, 0.00034579f, 0.05520482f, 0.07558002f, 0.07372419f, 
    0.23905072f, 0.14697143f, 0.07003663f, 0.28149867f, 0.00597347f, 0.20640106f, -0.19759846f, 0.02250100f, 
    -0.03930007f, -0.18188860f, 0.10273616f, -0.20803040f, 0.07927654f, 0.05683969f, 0.08996206f, -0.13768464f, 
    0.10894311f, 0.07638918f, -0.01650460f, 0.02013179f, 0.06547931f, 0.05007909f, 0.07439011f, 0.20724772f, 
    0.14104740f, 0.00126444f, 0.05019069f, -0.02131439f, -0.04006001f, 0.00620959f, 0.05189973f, 0.06712385f, 
    0.06786338f, -0.00175378f, 0.17174314f, 0.04675873f, 0.29252979f, 0.09824011f, 0.03958153f, -0.25392514f, 
    0.10471867f, 0.04327257f, 0.03292717f, -0.08421618f, -0.07533393f, -0.17689708f, -0.10434595f, 0.03364593f, 
    0.04497310f, 0.11597758f, -0.02730832f, 0.07132574f, -0.04523411f, -0.00077747f, -0.06394295f, -0.00144263f, 
    -0.09488823f, -0.04500168f, 0.01486382f, 0.13287070f, -0.03046713f, 0.27655602f, -0.22106351f, 0.29283088f, 
    -0.00638140f, -0.01328836f, 0.05775515f, -0.10196045f, 0.10407741f, 0.14165159f, -0.02237666f, 0.06605742f, 
    -0.16678947f, 0.01598459f, -0.21050693f, 0.34448755f, 0.08690569f, 0.05985954f, -0.00185691f, -0.01430139f, 
    0.16056390f, -0.12444526f, 0.11538149f, 0.00972398f, 0.23541628f, -0.20586883f, 0.12080798f, 0.27853873f, 
    0.12387909f, -0.03997217f, 0.09354488f, -0.04809391f, -0.08696800f, 0.11608736f, -0.05111223f, -0.04191590f, 
    -0.11893243f, -0.02490088f, 0.05020296f, -0.18847977f, -0.15104771f, 0.15494667f, -0.02117623f, -0.19299051f, 
    -0.09955058f, 0.02598988f, -0.07875417f, 0.03839168f, 0.12490191f, -0.04033533f, -0.00121675f, -0.15431833f, 
    0.09350932f, 0.12025345f, 0.09346365f, -0.09678503f, 0.10030766f, 0.00282028f, 0.12772481f, -0.10755304f, 
    0.05101940f, 0.14954743f, 0.17512548f, 0.16317877f, -0.01005527f, -0.00145229f, 0.17007443f, 0.08183637f, 
    0.08437544f, 0.09343909f, 0.01803648f, -0.13172768f, -0.07529795f, 0.21926120f, 0.09710255f, 0.24069047f, 
    0.08257427f, 0.00636709f, 0.08214352f, -0.09537353f, 0.04894786f, 0.06096913f, -0.04785772f, -0.06954833f, 
    0.18705654f, -0.28495613f, 0.15615608f, -0.10422914f, -0.05702256f, 0.10917466f, 0.02568935f, 0.03097728f, 
    0.05053846f, -0.04454091f, -0.01403169f, 0.09120467f, 0.00429284f, 0.08519060f, 0.03789661f, -0.04163794f, 
    -0.02300852f, 0.04605188f, 0.03561408f, 0.10699677f, 0.10291313f, 0.04631196f, 0.01476329f, 0.11693288f, 
    -0.23888135f, -0.03460005f, -0.20108099f, 0.15981461f, -0.02858753f, -0.00558202f, -0.07099108f, 0.03581549f, 
    -0.07043973f, -0.04722024f, 0.12890428f, -0.00953740f, 0.19027305f, -0.10889249f, 0.18113720f, 0.01255422f, 
    -0.07252246f, -0.12412979f, 0.02125673f, 0.00235905f, 0.02306580f, 0.04894174f, 0.09063029f, 0.06280988f, 
    0.14801303f, 0.20542926f, 0.07733399f, 0.10030398f, -0.06862672f, -0.02785053f, -0.06030364f, 0.05969214f, 
    0.04243609f, -0.00862113f, 0.15899990f, 0.01011819f, -0.02230850f, -0.14875290f, -0.17281877f, -0.02166168f, 
    0.15629619f, -0.00026114f, -0.03543862f, -0.11560665f, 0.01488414f, -0.01041282f, -0.00505053f, 0.02904302f, 
    -0.08700871f, -0.19511992f, -0.12092241f, -0.06131222f, -0.12522401f, -0.01268905f, -0.00190407f, 0.07797983f, 
    -0.07192491f, 0.02971259f, -0.01204065f, -0.00613790f, -0.17762206f, 0.16233070f, -0.16804759f, 0.14924970f, 
    -0.04597617f, 0.05397725f, 0.00523774f, 0.01825286f, 0.02378284f, 0.09609932f, 0.07570402f, 0.02345199f, 
    -0.16592203f, 0.10378032f, -0.04257836f, -0.00110758f, -0.03150385f, 0.11815315f, 0.05910042f, -0.16706564f, 
    0.11340225f, -0.11924710f, -0.04294121f, -0.04081437f, -0.14598955f, -0.05473271f, -0.01759616f, -0.02687831f, 
    -0.01337374f, -0.04865120f, 0.08359031f, -0.15252531f, -0.13002944f, -0.01993058f, -0.16451526f, 0.07064456f, 
    -0.01885596f, 0.19526415f, -0.01592802f, 0.08488601f, 0.03006941f, 0.03872938f, 0.11082450f, -0.02292186f, 
    0.03691990f, 0.09491956f, -0.01773134f, -0.11759792f, -0.20174360f, 0.04277052f, 0.01969504f, 0.00160616f, 
    -0.10145977f, -0.04860472f, 0.06571931f, -0.00883259f, -0.03501171f, 0.03214261f, -0.07953403f, 0.00939717f, 
    0.44473973f, 0.22965898f, -0.17955585f, 0.09414887f, 0.13687354f, 0.06123206f, -0.07955106f, 0.00639546f, 
    -0.00979463f, 0.15174800f, 0.09183533f, -0.10118057f, -0.10003296f, 0.15530099f, 0.02517563f, -0.28093559f, 
    -0.14476775f, 0.05164004f, 0.03283075f, 0.03924306f, -0.11551579f, 0.12813924f, -0.03387240f, 0.08177333f, 
    0.19543090f, -0.31419447f, -0.06045831f, 0.03386090f, 0.07869636f, -0.14454077f, 0.27285799f, -0.03948811f, 
    0.10798533f, 0.11760657f, 0.00813000f, -0.00109164f, 0.18146104f, 0.06154632f, -0.06918811f, 0.07230014f, 
    -0.02265462f, 0.08011687f, 0.00757439f, -0.00844567f, 0.00931254f, 0.04400144f, 0.08620196f, -0.04098020f, 
    0.14909275f, -0.26513076f, -0.11966929f, 0.06040731f, -0.09487413f, -0.11505766f, -0.05074882f, -0.01037949f, 
    -0.10730840f, 0.06071172f, -0.09231468f, -0.05364607f, -0.17298117f, 0.12287344f, -0.10335939f, 0.00997774f, 
    -0.09561132f, 0.13252543f, 0.03995333f, 0.04989643f, -0.03092284f, 0.00932083f, -0.10981982f, 0.05006719f, 
    0.02688252f, -0.00357924f, -0.03641068f, 0.07388765f, 0.09614433f, 0.00948438f, -0.08982678f, -0.02007738f, 
    -0.18260406f, -0.05258442f, -0.08940813f, -0.07763091f, 0.03230876f, 0.17095719f, 0.18076181f, 0.00677695f, 
    -0.03956231f, 0.05751361f, 0.02924680f, 0.05317062f, -0.01059350f, 0.08778318f, -0.00569793f, -0.10128713f, 
    -0.27344081f, 0.30137539f, 0.03898377f, -0.29509458f, -0.11718976f, 0.08842124f, -0.11394355f, -0.13021852f, 
    -0.03966041f, -0.03634530f, 0.10322399f, -0.21903978f, -0.07394329f, -0.01633173f, 0.30726132f, 0.26347917f, 
    -0.13593361f, -0.05315946f, -0.00799481f, 0.07999886f, -0.04198735f, -0.03933233f, -0.00227912f, 0.10753431f, 
    -0.02331114f, -0.06572708f, 0.08743081f, 0.02529416f, -0.09864003f, 0.06416603f, 0.05314909f, 0.03919371f, 
    -0.15072815f, 0.08097448f, 0.05006270f, -0.02334766f, -0.40899989f, 0.53839403f, -0.20330094f, -0.00910085f, 
    -0.04193115f, 0.02872943f, 0.01615476f, 0.00121313f, 0.05147570f, 0.06834999f, 0.06383675f, -0.00207442f, 
    -0.31406608f, 0.23652668f, -0.04582319f, -0.11631106f, -0.19030164f, 0.06290126f, 0.08913996f, -0.00597998f, 
    -0.08455238f, 0.04588721f, 0.03309769f, 0.15834917f, 0.07170866f, -0.05562026f, -0.02853599f, -0.05757257f, 
    -0.08847744f, 0.13672315f, 0.00950923f, 0.03219375f, -0.00283660f, 0.06095608f, -0.00124238f, 0.04736368f, 
    -0.03129450f, 0.22580992f, 0.34140524f, 0.00748474f, -0.06679670f, -0.09068616f, -0.01681902f, -0.02692720f, 
    -0.01388813f, -0.07696064f, -0.01168046f, -0.07001038f, 0.07219324f, -0.09319687f, -0.25058740f, 0.10465059f, 
    0.02682509f, -0.00384322f, 0.02456368f, 0.14503919f, -0.07686216f, 0.01454731f, 0.11465251f, 0.05621510f, 
    0.18086047f, -0.12402261f, 0.26349992f, -0.23310398f, -0.11274470f, -0.00592431f, 0.01815442f, -0.02757620f, 
    -0.08294503f, -0.04698462f, -0.05573884f, 0.01344624f, -0.08826841f, -0.07184627f, 0.20109822f, 0.07667571f, 
    0.02312892f, 0.01789590f, -0.09919606f, -0.09883093f, 0.03301508f, -0.05978769f, -0.04591565f, 0.01771431f, 
    0.16869910f, 0.27135390f, -0.30111435f, -0.02555872f, 0.03939917f, 0.14085563f, 0.01089364f, 0.10224232f, 
    0.08558561f, 0.07945674f, 0.06933023f, -0.05187277f, -0.01165400f, 0.00693701f, 0.18664688f, 0.04112104f, 
    -0.00158306f, -0.04987226f, -0.01844535f, 0.10340413f, -0.15934807f, -0.04331641f, -0.08163348f, -0.03626126f, 
    0.03574688f, -0.08071114f, 0.10236570f, -0.11593472f, -0.06609242f, -0.05774669f, 0.05099596f, 0.00823076f, 
    0.03678406f, -0.05499368f, -0.08676536f, 0.08468029f, 0.13988920f, -0.12169062f, 0.21402830f, 0.07469382f, 
    0.00203909f, 0.05425972f, 0.02102283f, -0.07383240f, -0.04704099f, 0.04815543f, -0.12289031f, -0.07961913f, 
    -0.17457092f, 0.14068922f, -0.12226933f, 0.06817983f, -0.04543900f, -0.10056166f, -0.00004830f, -0.05146296f, 
    -0.16073996f, -0.07857531f, -0.11258905f, -0.02486545f, -0.17175697f, 0.18274790f, 0.12473778f, -0.08049987f, 
    -0.07503878f, 0.05569148f, 0.11327252f, -0.00428840f, -0.04926554f, 0.09378333f, 0.00135546f, 0.07405113f, 
    -0.03376633f, -0.01738098f, -0.23493402f, 0.17065777f, 0.10089154f, -0.08254469f, 0.24552441f, 0.00957009f, 
    0.00366648f, 0.24306656f, 0.08794700f, -0.06287598f, -0.03069578f, -0.00069137f, -0.12335114f, -0.09331998f, 
    0.12343708f, 0.12878934f, 0.11485638f, 0.02097721f, 0.09128852f, 0.00132918f, -0.03975958f, -0.01569773f, 
    -0.00540805f, 0.14368451f, -0.02419280f, 0.09507867f, -0.00740096f, -0.03256685f, 0.02915839f, -0.05457124f, 
    -0.05294359f, -0.04141878f, 0.08364961f, -0.00291104f, -0.31891584f, -0.25823271f, -0.18525049f, -0.04594995f, 
    -0.04954186f, -0.05888264f, -0.03861321f, -0.15221712f, -0.12065012f, -0.03369017f, 0.04101287f, 0.11653887f, 
    0.18174745f, 0.04212087f, 0.00438020f, 0.03023162f, 0.02752965f, 0.03067835f, 0.01025518f, -0.06369238f, 
    0.14233336f, 0.05457937f, -0.00533601f, -0.15416057f, 0.04276836f, -0.12993342f, -0.27952051f, -0.00493138f, 
    -0.02044623f, 0.04286846f, -0.11163282f, 0.10713673f, 0.03000233f, -0.06281614f, -0.06642160f, 0.16259271f, 
    -0.18381298f, 0.07047521f, -0.08752738f, 0.06446338f, -0.17621236f, -0.03679349f, 0.00983130f, 0.08646260f, 
    0.03904978f, 0.06919707f, -0.04022174f, 0.02578872f, -0.02200205f, 0.18076791f, 0.01846164f, -0.02158470f, 
    -0.04016335f, -0.03857663f, -0.00406001f, 0.03353681f, -0.15488355f, 0.22083780f, 0.02707137f, 0.20469256f, 
    -0.08114383f, -0.08553097f, 0.12875462f, 0.00861559f, -0.00866645f, -0.03950825f, -0.01399540f, -0.03298444f, 
    0.00853896f, -0.02772095f, 0.02477592f, 0.00445980f, -0.09889413f, 0.04101833f, -0.19743806f, 0.18364976f, 
    -0.05382945f, -0.03479409f, -0.13408925f, 0.05780054f, -0.06424662f, 0.02332746f, 0.12634358f, -0.08810073f, 
    -0.14884585f, -0.13383433f, -0.26065195f, 0.01732504f, -0.08055537f, -0.12264919f, -0.01647414f, 0.00181356f, 
    -0.01846857f, 0.00776986f, 0.00476318f, -0.03925296f, -0.05888371f, 0.02596461f, -0.15469576f, 0.06966988f, 
    0.02944453f, -0.09856427f, 0.01665402f, 0.01039467f, -0.12784877f, 0.07499776f, -0.02137096f, 0.06812428f, 
    -0.06013395f, 0.22850779f, 0.04582486f, -0.01516468f, 0.02316074f, -0.04878296f, -0.04750958f, 0.01997165f, 
    -0.10516979f, 0.15922815f, -0.10650389f, 0.11566308f, 0.17199990f, -0.01485022f, 0.16922808f, -0.26507846f, 
    -0.21898954f, 0.16834435f, 0.02036331f, -0.02217304f, 0.07096626f, 0.05309320f, -0.22049345f, 0.02477443f, 
    0.01821376f, -0.07578197f, 0.19995122f, 0.18776505f, 0.10955042f, 0.00187885f, 0.01201779f, -0.03624359f, 
    -0.07696133f, 0.13695180f, 0.02196179f, -0.11205167f, -0.13344230f, 0.37854305f, 0.08306202f, 0.11469509f, 
    -0.17091145f, 0.14572425f, -0.01864224f, -0.01170256f, 0.05100451f, 0.17846376f, -0.00771211f, 0.07795470f, 
    0.05130237f, -0.07961886f, 0.11812074f, 0.12809706f, -0.08681531f, -0.05015562f, 0.15911585f, 0.09217706f, 
    0.06842428f, -0.08196282f, 0.00262642f, -0.12745160f, -0.12155584f, 0.03189408f, 0.01157639f, 0.01192930f, 
    -0.00109466f, 0.03563149f, -0.01041909f, 0.04876518f, 0.04607069f, -0.01778504f, 0.01328706f, 0.04669487f, 
    -0.00841460f, -0.04007896f, 0.09288156f, 0.12024786f, 0.08728650f, -0.03183174f, -0.06283158f, 0.04031405f, 
    -0.17262860f, -0.07737821f, 0.06525553f, -0.02105425f, 0.28381127f, 0.03159185f, 0.01971785f, -0.23817931f, 
    -0.04351823f, 0.04194956f, 0.03182868f, 0.01814104f, 0.10488651f, -0.00167115f, 0.09606991f, 0.03131213f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.00073027f, 0.13919814f, -0.02780284f, 0.05749678f, 0.01593841f, -0.02009017f, 0.08036922f, -0.02070127f, 
    0.03933835f, 0.00752684f, 0.11882515f, 0.01788760f, 0.13625188f, 0.07473310f, 0.04722197f, 0.24607897f, 
    -0.05811433f, -0.00771332f, -0.02759150f, 0.03235921f, 0.04346956f, -0.05857353f, -0.02080368f, 0.05700199f, 
    0.07704613f, 0.08471029f, 0.00933148f, 0.00136306f, -0.02448898f, 0.00591644f, -0.06763599f, 0.04593288f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.15252057f, 0.35980284f, -0.08806222f, 0.19138741f, -0.08128335f, -0.03003663f, 0.35399938f, 0.13050948f, 
    -0.10060353f, -0.06622914f, 0.09343995f, 0.10864208f, -0.15989003f, -0.32822531f, 0.20213650f, 0.05529792f, 
    -0.44945765f, 0.05492207f, 0.12686801f, -0.11362156f, 0.14907004f, -0.19361538f, 0.15237345f, 0.12853456f, 
    -0.40070292f, 0.02015176f, -0.23342617f, -0.05665719f, -0.08370055f, -0.04159700f, -0.13091549f, 0.43580726f, 
    -0.02106276f, -0.04862819f, -0.33038828f, 0.14998776f, 0.07090002f, -0.10175328f, 0.22525702f, 0.06968247f, 
    0.14627564f, -0.08207253f, -0.23941424f, -0.15221067f, 0.16014175f, 0.10347873f, -0.02696812f, 0.17831038f, 
    0.12389987f, 0.03438113f, 0.00312694f, -0.18434669f, 0.03373330f, -0.14373101f, -0.13400006f, -0.08913782f, 
    -0.26353148f, 0.18778165f, 0.09981523f, 0.07614446f, 0.05760126f, -0.01326577f, 0.07992421f, 0.18334855f, 
    -0.05503255f, -0.03155481f, -0.15008132f, 0.14832152f, -0.02351301f, -0.12030938f, 0.02508361f, 0.16154483f, 
    -0.01920465f, -0.15963687f, -0.06433054f, -0.09958361f, -0.12703228f, -0.12793133f, -0.03448071f, -0.11696117f, 
    0.15960205f, -0.14040969f, -0.16375969f, 0.10219666f, -0.08329773f, -0.11060217f, -0.14628068f, -0.01954826f, 
    -0.17543468f, 0.12881620f, 0.13041750f, 0.04903347f, 0.02442876f, 0.02808551f, -0.14911702f, 0.10847794f, 
    0.06878979f, 0.32065976f, 0.34523928f, -0.13580471f, -0.03583218f, -0.10655410f, -0.04485030f, 0.10116702f, 
    0.25787285f, 0.15686102f, -0.22362241f, -0.12590319f, -0.26476583f, -0.41799217f, 0.33726174f, -0.00310081f, 
    -0.19830278f, -0.08285806f, -0.00223380f, 0.11059201f, 0.14567210f, 0.06566134f, 0.26322600f, 0.09375658f, 
    -0.20575437f, -0.08548906f, -0.20892587f, 0.02026508f, -0.07838385f, 0.17501053f, -0.01168948f, -0.23073497f, 
    0.04668749f, -0.11152080f, -0.07656520f, 0.41852501f, 0.10400942f, 0.27488345f, 0.14495575f, 0.14452283f, 
    0.12538199f, -0.16459846f, -0.04298475f, -0.06943960f, 0.04199943f, -0.24103118f, -0.10965629f, 0.05891948f, 
    0.20612964f, -0.16457832f, -0.04266288f, 0.28551590f, -0.24377914f, 0.29340324f, 0.01169550f, 0.37942144f, 
    0.13113847f, -0.10072090f, -0.11923206f, -0.08301850f, -0.02986431f, -0.27172804f, 0.20421349f, -0.02768210f, 
    -0.04639252f, -0.06084562f, 0.14789617f, -0.21458828f, 0.16558066f, -0.29589969f, 0.21412590f, -0.17332815f, 
    -0.00278293f, -0.02622587f, -0.06099789f, -0.13626440f, 0.21483792f, 0.02454090f, 0.21369986f, 0.03663830f, 
    0.37955242f, 0.05460246f, 0.15879554f, -0.27302229f, -0.13037112f, 0.38686660f, -0.09052528f, -0.00382282f, 
    0.00606349f, 0.18030094f, -0.04080966f, 0.13705297f, 0.16451225f, 0.09274196f, -0.32057071f, 0.06591459f, 
    0.05962044f, 0.19356330f, -0.20221043f, 0.12952125f, -0.04758406f, -0.31762651f, 0.18502645f, 0.08848249f, 
    0.22931285f, 0.00094774f, 0.02035045f, 0.11981220f, 0.29050294f, -0.03687990f, -0.00724576f, 0.03315138f, 
    -0.24053450f, 0.04433407f, -0.01347281f, -0.30108291f, -0.15686889f, 0.27672818f, -0.08141344f, -0.01662349f, 
    0.12013321f, -0.19983916f, -0.32421905f, -0.14758423f, 0.10662348f, -0.24305493f, -0.16034120f, 0.03004236f, 
    0.13335282f, -0.06016448f, 0.23885040f, -0.10650622f, -0.08201979f, 0.03694494f, 0.10926825f, 0.09971005f, 
    -0.16068798f, -0.14801559f, 0.31684846f, 0.02689278f, -0.15131871f, 0.32007733f, -0.15100490f, 0.18016779f, 
    0.04870493f, -0.04904842f, -0.06618342f, 0.12326105f, 0.21140061f, -0.16096149f, 0.08428578f, 0.15781094f, 
    -0.03804003f, -0.04345601f, -0.04812282f, -0.09984700f, 0.08458446f, 0.36870521f, 0.02658113f, -0.13284864f, 
    0.08305747f, -0.00542426f, 0.03433086f, -0.06058797f, -0.10154536f, -0.10028545f, 0.14621827f, 0.12970959f, 
    -0.03361455f, 0.09752014f, 0.04515623f, -0.01733886f, -0.14731589f, -0.09033730f, 0.10888139f, -0.15370676f, 
    -0.02300549f, 0.17529579f, -0.00299913f, 0.08206787f, -0.05606472f, 0.08704112f, -0.12131910f, -0.22019863f, 
    -0.00136699f, -0.07076953f, -0.04569427f, -0.14689273f, 0.07276460f, -0.15049352f, -0.06805991f, 0.21493576f, 
    0.03973459f, 0.22070187f, -0.26831326f, 0.37950456f, -0.06634617f, 0.13556504f, 0.16269898f, 0.16897389f, 
    0.32785162f, -0.00643796f, 0.32673427f, -0.05400303f, 0.09443063f, 0.11419354f, -0.21570693f, 0.27686194f, 
    0.27844310f, 0.09186592f, -0.16888379f, -0.11998277f, -0.25546783f, -0.37675470f, 0.19675505f, 0.02350210f, 
    0.12979636f, 0.00609929f, -0.02069730f, -0.07411729f, -0.14268579f, -0.32746825f, -0.21710888f, -0.00906835f, 
    -0.07405772f, 0.07009538f, -0.27720368f, 0.07734676f, 0.00802200f, 0.06198124f, 0.22695680f, 0.12485301f, 
    -0.15864253f, 0.16931197f, 0.33000636f, 0.13273288f, 0.17267820f, 0.29196373f, -0.11095376f, -0.15679148f, 
    -0.03673603f, -0.08157236f, -0.04039575f, -0.18424453f, 0.07527182f, 0.33582336f, -0.00991155f, 0.11850680f, 
    -0.17402853f, -0.18222049f, -0.30538696f, -0.10902418f, 0.03864520f, 0.16583711f, -0.00350011f, 0.31980059f, 
    -0.14703763f, -0.08385210f, 0.29299372f, 0.17118025f, -0.07199543f, 0.40276170f, -0.26061597f, 0.04407344f, 
    0.20563169f, 0.11693137f, -0.27308607f, 0.13374393f, -0.02755354f, -0.27958369f, -0.12740435f, 0.24487258f, 
    0.39078113f, 0.14804089f, -0.08297625f, 0.48156640f, 0.38337356f, 0.11103152f, 0.15461658f, -0.29203114f, 
    -0.21078843f, 0.19668142f, 0.13711178f, -0.14934190f, 0.09614679f, 0.39590317f, 0.37153569f, -0.14184776f, 
    -0.15680632f, -0.01288398f, -0.13251702f, 0.18439358f, 0.04543277f, 0.03181590f, -0.16325739f, -0.07439411f, 
    0.27925485f, 0.04168699f, -0.20064548f, -0.08869851f, 0.20281239f, 0.02719457f, 0.17138532f, -0.04988999f, 
    0.18001801f, 0.14851804f, -0.06972593f, -0.11089510f, -0.21136066f, 0.24535297f, -0.16137080f, 0.11280528f, 
    0.10333108f, -0.23311241f, 0.01349281f, -0.10665921f, -0.00068221f, -0.24895731f, -0.12759550f, 0.05907436f, 
    0.02113019f, -0.09147277f, -0.05014609f, -0.04872334f, 0.13383304f, -0.13625222f, -0.11058303f, -0.03667212f, 
    -0.11339319f, -0.09184944f, -0.10299528f, -0.14670108f, 0.02341308f, -0.04844474f, -0.05313271f, 0.06733806f, 
    -0.15474598f, 0.07431820f, 0.07315915f, 0.02039239f, -0.08517153f, 0.01021777f, -0.04111124f, -0.11373197f, 
    -0.07819537f, -0.15985246f, -0.13146962f, -0.12676914f, 0.01096289f, -0.02465634f, 0.00667241f, 0.04429760f, 
    -0.02894167f, 0.01350172f, -0.13553439f, 0.19691552f, -0.02491397f, -0.06082181f, -0.41954771f, 0.16865841f, 
    -0.22039475f, -0.09534426f, 0.36090490f, -0.04385375f, 0.07491329f, -0.02506932f, 0.02874732f, 0.28694218f, 
    -0.07714555f, 0.08921098f, -0.08165036f, -0.04844394f, 0.11364363f, 0.03008318f, 0.06308962f, 0.02141677f, 
    0.11832009f, 0.06168561f, 0.07351888f, 0.14258939f, -0.07912959f, -0.13082355f, -0.17600435f, -0.33463702f, 
    -0.14103080f, 0.09000406f, -0.02088767f, 0.36029428f, -0.06694134f, -0.04502950f, 0.01825374f, -0.06510884f, 
    0.28262097f, -0.04905870f, 0.16342309f, -0.05898969f, -0.05254655f, 0.21548769f, 0.01606607f, 0.18039404f, 
    -0.03002987f, 0.00440297f, 0.05100488f, -0.32038170f, 0.26112598f, -0.48962829f, 0.17749374f, 0.07992402f, 
    -0.02720672f, -0.19869229f, -0.16588405f, -0.06996246f, -0.06813696f, 0.09654918f, -0.02925474f, 0.12135155f, 
    -0.16638660f, 0.26181814f, -0.13992715f, 0.02189419f, 0.16110700f, -0.39243177f, 0.15569912f, -0.17506945f, 
    0.09146577f, -0.14799261f, -0.32399908f, 0.11432544f, 0.04283023f, -0.19262655f, 0.23351525f, 0.16544820f, 
    -0.10543831f, 0.01100937f, -0.03167169f, 0.15525307f, -0.11187688f, -0.07461885f, -0.31219739f, 0.21158788f, 
    0.09688909f, -0.00466106f, -0.02481301f, -0.08428759f, -0.07325224f, 0.34020522f, -0.18809968f, -0.19943550f, 
    -0.06507426f, 0.25766823f, 0.11977952f, 0.02351246f, -0.11016659f, -0.08583510f, -0.12407082f, -0.04702497f, 
    -0.12213270f, 0.00196739f, 0.38908929f, 0.13029087f, -0.06857955f, 0.19086371f, 0.24225263f, 0.11931980f, 
    -0.25602612f, -0.02784900f, 0.15550593f, -0.20553674f, 0.10737113f, 0.25390264f, 0.19447528f, -0.23455894f, 
    -0.08638816f, 0.10394452f, -0.34859160f, -0.11842008f, -0.02897283f, -0.04055662f, -0.22430819f, -0.37627649f, 
    -0.02960568f, 0.01166807f, -0.17214601f, 0.03567804f, -0.06859324f, 0.04728469f, -0.14363377f, -0.04575402f, 
    -0.11309496f, 0.14297397f, -0.18221547f, 0.00905506f, 0.00705006f, 0.12222784f, -0.20495078f, 0.12429157f, 
    -0.07881518f, 0.09439272f, -0.03288753f, 0.11856497f, 0.09633046f, -0.06297334f, -0.20863689f, -0.03801088f, 
    -0.06908271f, -0.04993059f, -0.05329933f, 0.14512062f, -0.15273352f, 0.00455663f, -0.02767889f, -0.05461971f, 
    0.12917864f, 0.34246907f, 0.04750155f, -0.15564467f, -0.14980765f, -0.00684841f, 0.00564204f, 0.12770939f, 
    -0.15035523f, -0.03613537f, 0.06395178f, 0.01895987f, -0.02698170f, -0.51274425f, 0.25934136f, 0.13988273f, 
    -0.24882312f, -0.03210327f, 0.01619663f, 0.21975327f, 0.24195905f, 0.32731268f, -0.15974467f, -0.05612282f, 
    -0.16194420f, -0.07140628f, -0.25485119f, 0.00091129f, 0.17717288f, 0.02900304f, -0.15632388f, 0.15306231f, 
    0.03189782f, -0.03135143f, -0.08042685f, 0.22758064f, 0.15058570f, 0.13044661f, 0.16172306f, 0.02370025f, 
    -0.15742610f, 0.00353204f, 0.28238007f, 0.02459145f, 0.29238066f, -0.27452657f, 0.06687593f, 0.27489844f, 
    -0.20158674f, 0.15365893f, 0.06564258f, -0.12114504f, -0.16593130f, -0.16799073f, 0.23672585f, 0.33438545f, 
    -0.16278858f, 0.00658543f, -0.31121355f, -0.09927525f, -0.08045480f, -0.34926793f, 0.05430020f, 0.17228086f, 
    -0.10708454f, 0.12729745f, 0.30150610f, -0.06723725f, -0.05549186f, -0.14437076f, 0.25727263f, -0.11141186f, 
    0.13914961f, -0.08737946f, 0.02632841f, -0.16507742f, -0.12140065f, 0.06982145f, -0.15019327f, 0.16744889f, 
    0.16336997f, -0.04552053f, -0.11513978f, 0.35090035f, 0.02237173f, 0.37951931f, 0.16186050f, -0.25655031f, 
    -0.04048394f, 0.32701766f, 0.24979216f, 0.13998313f, 0.17232388f, 0.22244710f, -0.08010701f, 0.05788117f, 
    -0.07492079f, 0.11743937f, -0.24584335f, -0.04705093f, 0.03249417f, 0.06320241f, -0.10148653f, 0.15300137f, 
    -0.01050299f, -0.13840206f, -0.10638360f, -0.09864616f, -0.08545863f, -0.12539764f, -0.03480681f, -0.19145221f, 
    0.07129134f, 0.15824175f, 0.04252867f, -0.12746394f, -0.19194596f, -0.20099269f, -0.00419398f, -0.11998801f, 
    0.10431274f, -0.26738083f, 0.11564831f, 0.12569110f, -0.06781695f, -0.13340409f, 0.13911913f, -0.05256055f, 
    0.02029899f, -0.04158047f, 0.16988668f, 0.13866442f, 0.13971631f, -0.07331220f, -0.08892504f, -0.01902829f, 
    0.22932699f, -0.17165604f, -0.07727917f, 0.10226265f, 0.21799688f, 0.24311289f, 0.16370797f, -0.06733245f, 
    -0.25959045f, -0.02447019f, 0.09047648f, -0.22291173f, 0.25985050f, 0.25785789f, 0.00960861f, -0.01351371f, 
    -0.23571928f, -0.13480608f, 0.07877278f, -0.05645786f, -0.08910496f, 0.37864727f, 0.15616897f, -0.28260741f, 
    0.00977504f, -0.15446500f, -0.19809620f, 0.18777888f, -0.13873720f, 0.08663354f, -0.20600927f, -0.06078587f, 
    0.02643272f, 0.18181700f, -0.38197508f, -0.08226473f, 0.38822773f, -0.08086375f, 0.12371794f, 0.05447907f, 
    0.22486284f, 0.11430468f, -0.11549830f, 0.18894249f, 0.10125721f, 0.06664710f, -0.13231936f, 0.24051610f, 
    -0.03296308f, -0.10438453f, 0.13059428f, -0.01325508f, -0.04324801f, 0.33876055f, 0.02706159f, -0.28999782f, 
    0.07386620f, 0.14399962f, -0.17005904f, -0.34780550f, 0.05499937f, -0.02430375f, -0.10169581f, 0.00498797f, 
    -0.25385323f, -0.02363321f, 0.46983206f, 0.09040512f, 0.04463255f, 0.01797787f, 0.24558106f, 0.20415151f, 
    -0.27739376f, 0.10977356f, -0.10487991f, 0.04196570f, 0.12584086f, 0.00146744f, -0.15812239f, 0.26257962f, 
    0.22710815f, 0.26529583f, -0.18472163f, -0.04099518f, 0.01952697f, 0.38265914f, 0.06311838f, 0.02089581f, 
    0.04007931f, 0.03704504f, -0.14847961f, 0.18674272f, 0.14442995f, 0.03504659f, -0.28581890f, 0.01295317f, 
    -0.18818249f, -0.12976313f, 0.25422570f, -0.09781236f, 0.06694562f, 0.25681761f, -0.13263245f, 0.03916171f, 
    -0.32402965f, -0.00324338f, -0.10725913f, 0.13773751f, -0.07519418f, 0.25953868f, 0.22344284f, 0.21086445f, 
    0.06410776f, -0.19590497f, -0.24223915f, 0.17140529f, 0.13594121f, 0.19167025f, -0.17836992f, -0.45004201f, 
    -0.06202174f, 0.01544176f, -0.04478317f, -0.15096848f, -0.12029877f, -0.13042201f, -0.17696302f, -0.14178890f, 
    0.05591630f, -0.13388819f, 0.11095548f, 0.09321497f, -0.10031302f, -0.16832539f, -0.09164621f, 0.04158606f, 
    0.07304256f, -0.14861600f, -0.04087693f, -0.08704972f, -0.02905384f, 0.03617125f, 0.05481106f, -0.16776228f, 
    0.03287459f, -0.00860176f, -0.12482651f, 0.12366872f, -0.16572896f, -0.20252164f, -0.06436107f, -0.00415977f, 
    -0.02836451f, 0.05114766f, -0.46786678f, 0.15424833f, 0.12725976f, -0.04599660f, 0.25748160f, 0.01657331f, 
    -0.20772737f, 0.15432149f, 0.21002164f, -0.12315701f, 0.19743483f, -0.19904405f, -0.11578271f, 0.21476369f, 
    0.15958199f, -0.07749112f, -0.14637043f, 0.06559625f, 0.08992515f, -0.37413314f, -0.11881069f, -0.14070851f, 
    -0.13098872f, 0.15788709f, 0.05388225f, -0.04049280f, 0.03421009f, -0.00073083f, -0.00537645f, 0.50102276f, 
    -0.09418276f, -0.03211276f, 0.01378465f, 0.01299274f, -0.17419338f, 0.05813041f, 0.13163598f, -0.05090551f, 
    -0.14106329f, 0.03310336f, -0.00018108f, 0.11556118f, -0.16895817f, -0.09583774f, 0.01371908f, -0.19536833f, 
    -0.04996094f, 0.05653203f, -0.11139265f, -0.06712035f, -0.10096328f, -0.04158870f, -0.15755142f, -0.07885410f, 
    -0.12203160f, -0.04771281f, -0.20004736f, -0.11807745f, 0.03006644f, -0.16108790f, -0.08599696f, 0.13242960f, 
    0.15877391f, 0.16435236f, 0.04155188f, -0.14463343f, 0.14386867f, -0.23011594f, -0.17564183f, -0.12480402f, 
    0.22707829f, -0.12756607f, 0.08565170f, -0.05924787f, 0.05822746f, 0.26110676f, 0.15615578f, 0.16610168f, 
    0.32136256f, 0.03528769f, 0.05182007f, -0.00565185f, 0.27590013f, -0.18042378f, -0.10127172f, -0.10487431f, 
    0.26600409f, 0.09250972f, 0.24203634f, -0.16585976f, 0.02809709f, 0.26559323f, -0.22401249f, -0.12299169f, 
    -0.05038613f, 0.13734688f, 0.11020482f, -0.19168341f, 0.03025452f, -0.13549958f, 0.07237350f, 0.06692220f, 
    0.00566807f, -0.00096431f, -0.11179230f, 0.12006700f, 0.19000278f, 0.02465136f, -0.11760143f, -0.10409041f, 
    -0.12406547f, 0.16401803f, 0.11719826f, -0.18632434f, -0.11573540f, -0.06470309f, -0.15068354f, -0.03867831f, 
    -0.01539522f, -0.02874915f, 0.03517141f, -0.06619151f, 0.13877627f, 0.02525010f, -0.16138105f, 0.11041120f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.01927231f, -0.02487445f, -0.04037606f, -0.05296404f, -0.15402514f, 0.26714587f, 0.24537684f, 0.14886153f, 
    0.05886349f, -0.06008796f, -0.04906136f, 0.23307061f, -0.14491309f, 0.06133560f, 0.06946946f, 0.18661027f, 
    0.12250147f, 0.17937542f, -0.01014086f, -0.01351340f, 0.24592836f, -0.14774807f, -0.05435043f, 0.10731432f, 
    0.16925628f, 0.23108923f, -0.13793860f, 0.03030794f, 0.16569974f, -0.17774798f, 0.01675232f, 0.16840306f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.42135409f, -0.00787053f, 0.00062084f, -0.07649594f, 0.26307228f, 0.00406134f, -0.18877330f, 0.01313630f, 
    0.09423473f, 0.10027503f, -0.03633167f, 0.26181227f, -0.16314119f, 0.08011487f, -0.48716646f, -0.41611907f, 
    0.20216544f, -0.54603237f, -0.08771466f, -0.50937742f, -0.35269129f, 0.29131389f, 0.03329528f, -0.11902168f, 
    -0.11641559f, -0.36964169f, -0.19050924f, 0.00654089f, 0.00266604f, 0.07659288f, -0.07704320f, -0.20457740f, 
    -0.36253434f, 0.14883968f, 0.16771004f, -0.55944264f, 0.09122676f, 0.31894210f, 0.27920297f, -0.01462206f, 
    -0.10283128f, 0.29078349f, -0.17186430f, 0.16899343f, 0.07961378f, 0.10357823f, 0.12293331f, 0.07268026f, 
    0.25865269f, -0.55065286f, -0.15738849f, -0.34088752f, 0.11229922f, 0.00079067f, -0.04908695f, -0.32237470f, 
    0.06882559f, -0.15811159f, -0.32047510f, -0.13843060f, 0.21726990f, 0.05368932f, 0.08718268f, 0.17058617f, 
    0.29438487f, -0.13888676f, 0.01157097f, -0.12923855f, 0.02993763f, -0.67357194f, -0.44597423f, 0.00250499f, 
    0.14334473f, -0.06540257f, -0.19813898f, 0.02920476f, -0.22324258f, -0.06903279f, 0.10468130f, -0.09121831f, 
    0.23387782f, -0.18145217f, -0.02965329f, 0.33010319f, 0.22888100f, -0.10110543f, 0.05221298f, -0.47532284f, 
    -0.13941896f, 0.32239467f, -0.10160431f, -0.06053156f, 0.35373214f, 0.03254031f, -0.11032763f, -0.11586136f, 
    0.10254227f, -0.13829191f, -0.02250275f, 0.21590064f, 0.13929817f, -0.15507053f, -0.23057574f, -0.01317836f, 
    -0.22453439f, -0.04636177f, 0.13780616f, 0.18703277f, 0.02585455f, -0.01389381f, -0.20234069f, -0.17890976f, 
    -0.12651968f, 0.16827975f, -0.11319162f, 0.27018133f, 0.44625485f, 0.00372479f, -0.28874832f, 0.05682544f, 
    -0.10561036f, -0.22981490f, -0.12765361f, 0.09894597f, -0.26351830f, -0.02637615f, -0.84561014f, -0.11347868f, 
    -0.10380813f, -0.12191932f, -0.00902937f, 0.30988142f, -0.27296922f, -0.13010728f, 0.15283923f, 0.14395960f, 
    -0.05932862f, -0.13620746f, -0.13558438f, 0.23227981f, 0.19057174f, 0.04100859f, -0.21146597f, 0.06715029f, 
    -0.51224399f, -0.11723880f, -0.08503059f, -0.00397851f, -0.42801207f, -0.05246018f, -0.00180456f, 0.27924499f, 
    0.10877379f, -0.09589027f, -0.05422929f, -0.14496137f, -0.01092845f, -0.02472587f, 0.11738081f, -0.11961543f, 
    -0.35367247f, -0.21750131f, -0.16968067f, -0.26366058f, -0.12138783f, -0.19337349f, -0.35116097f, 0.18958455f, 
    -0.14084783f, 0.22728953f, -0.17660025f, 0.07444398f, 0.02692271f, -0.10940289f, 0.25529456f, 0.14044170f, 
    -0.05475520f, 0.36461881f, 0.15305310f, -0.42680356f, 0.00532914f, 0.00862183f, -0.06457271f, 0.06711684f, 
    -0.19844741f, 0.01384443f, 0.36212409f, 0.11193418f, -0.23601572f, -0.15549007f, 0.09596004f, -0.04523726f, 
    0.28025508f, 0.07617651f, -0.05954167f, -0.18503575f, -0.53969765f, 0.19763604f, 0.10967139f, -0.07780729f, 
    0.06960594f, -0.00996968f, 0.23358539f, -0.72561699f, -0.03102815f, 0.07916541f, 0.03744679f, -0.09883064f, 
    -0.02889710f, 0.28473186f, -0.08721556f, 0.07428131f, 0.01885446f, 0.07820949f, -0.05882128f, -0.30782667f, 
    -0.50882232f, 0.20124052f, -0.44278002f, -0.03207780f, 0.23470862f, 0.06312693f, 0.22961640f, -0.20870078f, 
    -0.17633083f, 0.00799158f, 0.13357472f, -0.15893815f, 0.19200525f, 0.05865479f, 0.00706963f, -0.13997228f, 
    -0.14765285f, -0.41684604f, 0.23871666f, -0.15006921f, 0.15564120f, -0.00631796f, 0.19353749f, -0.24860552f, 
    0.08494467f, -0.17137688f, 0.11757874f, 0.08033812f, -0.06008505f, -0.05161963f, -0.12201307f, 0.22923450f, 
    0.25548205f, -0.05429597f, 0.43631420f, 0.16446455f, -0.35143715f, 0.04639131f, -0.14322612f, -0.00877252f, 
    -0.01122336f, -0.16026750f, 0.02201991f, -0.29586098f, 0.28623167f, -0.08900760f, 0.22991660f, 0.02121124f, 
    -0.01847503f, 0.22647926f, 0.28994665f, -0.53615683f, 0.02690655f, 0.18253733f, -0.05200554f, 0.14830513f, 
    -0.15770818f, -0.15488410f, 0.06699222f, -0.39086506f, 0.30882782f, -0.50855726f, -0.26734349f, -0.09993040f, 
    -0.06739005f, 0.03612813f, 0.25108099f, -0.03060373f, -0.01263455f, 0.11605794f, -0.40039283f, -0.04646867f, 
    -0.07629678f, 0.11221678f, -0.02184723f, 0.12226990f, -0.39286825f, -0.00290262f, -0.18389501f, 0.03416432f, 
    -0.28994405f, -0.45536733f, -0.14329737f, 0.02443896f, -0.23856981f, 0.10106119f, 0.10634992f, -0.31215248f, 
    0.26041925f, 0.13737787f, -0.01389429f, 0.21918650f, -0.34864300f, 0.02508588f, -0.60785657f, 0.07174346f, 
    -0.02589966f, 0.23759538f, -0.38632813f, -0.01156711f, -0.18225926f, 0.06223000f, 0.08782978f, 0.09237465f, 
    0.39295024f, 0.50031769f, 0.14916274f, -0.40736094f, -0.11489381f, -0.16885418f, -0.26144955f, 0.01736937f, 
    -0.03364312f, 0.19192678f, 0.27592218f, 0.00241137f, -0.50365329f, -0.04586613f, -0.22415660f, 0.26821259f, 
    -0.21086580f, -0.10477056f, -0.02862824f, -0.32522452f, 0.10829461f, -0.06043631f, -0.25968897f, 0.22614892f, 
    -0.19019020f, -0.14319830f, -0.04442752f, -0.10057098f, 0.31217426f, -0.17269257f, -0.38018784f, 0.03565153f, 
    0.33877063f, -0.02464602f, -0.12367368f, 0.37344465f, -0.15998872f, -0.12983380f, 0.19399296f, -0.55122560f, 
    -0.05680608f, 0.28895652f, -0.31456721f, -0.07526824f, 0.13868402f, -0.06850788f, 0.06164063f, 0.23657474f, 
    0.18394513f, 0.16528668f, -0.12290514f, 0.01125521f, 0.22704272f, -0.25000101f, -0.50408804f, 0.03510410f, 
    -0.18786933f, -0.14909251f, -0.14018126f, 0.15480971f, -0.33418307f, -0.09401540f, -0.15422186f, -0.15964697f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.22451231f, 0.13762502f, 0.13928089f, -0.13308913f, -0.12148179f, -0.00913455f, -0.03516322f, -0.14711165f, 
    0.05315817f, 0.05810448f, -0.03028722f, 0.03845935f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
