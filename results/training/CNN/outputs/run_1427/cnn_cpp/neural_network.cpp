#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -1.17221510f, -1.14452982f, -0.18748216f, -0.05274386f, 0.31942979f, -0.10722754f, -0.11076424f, -1.31101263f, 
    -1.44482863f, -1.24286509f, -0.38572058f, -0.53222978f, 0.42004663f, -0.01173209f, -0.06106148f, -0.18706697f, 
    -0.74983472f, -0.35614595f, -0.23271804f, -0.32421488f, 0.22102754f, -0.17089081f, 0.08857887f, 0.10482566f, 
    0.43211204f, -0.41708347f, -0.04663978f, 0.15752394f, 0.63332975f, 0.45502436f, 1.11204982f, 0.18008301f, 
    0.63987887f, -0.08016577f, 0.30060753f, 0.53297019f, 0.05348962f, -0.03551577f, -0.33231467f, 0.00491641f, 
    0.16919975f, -0.02329805f, 0.07921427f, 0.12763271f, -0.01310491f, -0.03328297f, -0.03550320f, -0.07788263f, 
    0.24449827f, -0.08815895f, 0.63706595f, -0.80468208f, -0.99141699f, -1.15868998f, -1.16250372f, 1.17298877f, 
    -0.02063958f, 0.74976838f, 0.38593993f, -0.10992873f, -0.31160837f, -0.30806395f, -0.05965661f, 0.25002244f, 
    0.25602248f, -0.02141484f, -0.06052295f, 0.20648631f, -0.14414115f, -0.35768193f, -0.11853193f, -0.42081249f, 
    0.15745871f, -0.04907013f, -0.22534813f, -1.56803095f, 0.25216767f, 0.28712255f, 0.78902161f, -0.07607987f, 
    -0.61079371f, -0.28220862f, -0.15620029f, 0.83830690f, 0.45719162f, -0.24915992f, 0.24528877f, 0.20055664f, 
    0.19640650f, -0.49441904f, -0.06002375f, -0.13364010f, 0.01167205f, -0.70455551f, 0.32175353f, -0.04889543f, 
    0.31860530f, 0.13457875f, -0.02393193f, 0.45588785f, 0.72087115f, 1.07756054f, 0.56926125f, -0.45964661f, 
    -1.25937963f, -0.99854517f, -0.28552726f, 0.48233885f, -0.09873980f, 0.75359416f, 0.43887079f, -0.20119323f, 
    0.04103147f, 0.48577923f, -0.09721263f, -0.37458903f, -0.18254915f, -0.03471097f, -0.05487753f, 0.00459754f, 
    0.01696260f, 0.11208122f, -0.28516507f, 0.17549233f, 0.42219448f, -0.40060502f, -0.27353185f, -0.20640513f, 
    0.86371130f, 0.41091108f, 0.31721911f, -0.03371162f, -0.24414732f, 0.07540758f, 0.41208610f, -0.20472248f, 
    0.21831305f, -0.38962659f, -0.18743385f, -0.13608348f, 0.13690177f, -0.27485698f, -0.34908235f, -0.08242883f, 
    -0.25650349f, -0.77367461f, -0.51110905f, -0.44533178f, -0.67288595f, -0.82963544f, -1.01901305f, -0.01469003f, 
    -0.77940500f, -0.68565685f, 0.03676359f, -0.65406036f, -0.62915242f, -0.83198822f, -0.52892327f, -0.20563321f, 
    -0.09305322f, -0.37523851f, -0.10396499f, -0.65177834f, 0.00617143f, 0.45968127f, 0.41239390f, 0.22327021f, 
    0.43630981f, 0.35813349f, 0.14972849f, -0.19585994f, 0.09576341f, 0.06043014f, -0.20660453f, -0.53256774f, 
    1.00262547f, -0.34630030f, -0.90884823f, -0.28571120f, -0.27643421f, -0.30526063f, -0.54251444f, -0.66320884f, 
    0.14731139f, 0.11327945f, -0.21101856f, 0.04433449f, 0.00953482f, 0.25318760f, 0.37523147f, 0.29455787f, 
    -0.17743871f, -0.36154082f, -0.71344870f, -0.12975311f, 0.17428999f, -0.60145944f, -0.47938982f, -0.61290115f, 
    1.00405979f, -0.49675024f, -0.35892802f, 0.64297545f, 0.25726619f, -0.01456699f, 0.07261648f, -0.58827573f, 
    -0.23684284f, 0.57265735f, -0.19300340f, 0.40858525f, -0.79220390f, -0.62892610f, 1.21436441f, -0.03469412f, 
    -0.06243483f, 0.16748625f, 0.57407832f, -0.03563876f, 0.11166497f, -0.54952347f, -0.12887153f, -0.38377094f, 
    -0.61071837f, 1.60821462f, -1.08021784f, -0.55068177f, 0.51332217f, 0.15337653f, 0.23778988f, -0.19304951f, 
    -0.65648395f, -0.26679114f, 0.19126779f, -0.22359473f, 0.11382005f, -0.16532497f, -0.00862073f, -0.36353073f, 
    0.13766062f, -0.10447840f, 0.17533228f, 0.02681544f, -0.09633727f, 0.01630730f, -0.07959858f, -0.04906509f, 
    0.20753460f, 0.24569857f, -1.58570182f, 0.83946824f, 0.14277360f, -0.81743538f, 0.54075933f, -0.38711369f, 
    0.56245697f, 0.15426445f, 0.61027604f, 0.06555504f, -0.63485682f, -0.37209949f, -0.09781528f, 0.35226196f, 
    0.38464209f, 0.03216308f, -0.30705029f, 0.14635664f, 0.04992356f, -0.05373264f, -0.00801475f, -0.04107553f, 
    0.24677527f, -0.08205423f, -0.18757822f, 0.25394952f, 0.97159946f, 0.47316882f, -0.55497587f, 0.76340836f, 
    -0.90308893f, 0.24337232f, -0.40225053f, -0.31499648f, -0.23798960f, -0.33915094f, -0.42893177f, 0.01998940f, 
    0.47385836f, -0.06450427f, 0.47001025f, -0.02672125f, -0.26590100f, 0.21245833f, 0.06921562f, -0.30710834f, 
    0.10910208f, 0.01546443f, 0.43279502f, -0.25448385f, -0.93923348f, -1.25367105f, -0.93566960f, -0.43243375f, 
    -0.17974384f, 0.65528870f, 0.35386702f, 0.37238780f, 0.70555609f, 0.73057491f, 0.35564318f, 0.09242561f, 
    0.16911997f, -0.01872385f, -0.00762552f, -0.33892569f, -0.46140367f, -0.15088353f, 0.20230702f, 0.02338121f, 
    -0.00248691f, 0.00966007f, 0.32231286f, -0.22279480f, 0.37837106f, 0.97689551f, -0.61449647f, -0.01910323f, 
    0.32407436f, 0.33141544f, -0.26208627f, 0.27087539f, 0.82241243f, -0.05388899f, -0.55478650f, -0.34847957f, 
    0.20808670f, 0.12936434f, -0.62075937f, 0.20217356f, -0.17247249f, -0.04791548f, 0.09798582f, -0.05928405f, 
    -0.41828126f, 0.14521243f, -0.23460120f, -0.60053927f, 0.15041132f, 0.38283458f, -0.99705833f, -1.13145351f, 
    -1.16326511f, -0.77306408f, 0.08055110f, 0.14236596f, 0.20746931f, -0.02396221f, -0.44785041f, -0.04819849f, 
    -0.83380997f, -0.59149927f, -0.42699951f, -0.43622482f, 0.19264117f, 0.14864193f, 0.03585765f, -0.40057731f, 
    -0.15647992f, 0.19240803f, 0.16668211f, -0.43339974f, -0.20624244f, -0.10177591f, -0.52084953f, 0.62696815f, 
    0.65573227f, 0.71303117f, 0.38168886f, 0.29229319f, 0.50459737f, -0.07166772f, 0.02223413f, 0.06546568f, 
    -0.19123954f, -0.19655955f, 0.14519908f, -0.08255504f, -0.33961275f, -0.60445160f, -0.27286142f, -0.08658021f, 
    -0.00110543f, -0.08229533f, -0.26380602f, 0.24482594f, 0.31137022f, -0.09181794f, -0.41871208f, -0.31146729f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.12630931f, 0.31998518f, 0.01648339f, 0.42764449f, 0.57699883f, 0.12531763f, -0.12439194f, 0.19062851f, 
    0.28196990f, 0.54160422f, 0.52217835f, 0.19814797f, 0.56232160f, 0.61435181f, 0.02328634f, -0.08195429f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.80662584f, 0.26824304f, -0.51631904f, -0.53802925f, 0.28218469f, 0.04191010f, 0.36093226f, -0.05652780f, 
    -0.11823094f, -0.17918268f, -0.09878825f, -0.16519865f, 0.05866652f, 0.02437357f, 0.03555879f, 0.06861990f, 
    -0.05050592f, 0.00828325f, -0.04052563f, 0.03877307f, -0.28714424f, -0.41650155f, -0.16165826f, -0.11260833f, 
    0.58341742f, -0.52025139f, -0.31037807f, -0.09143969f, 0.14020701f, 0.29725769f, -0.32078981f, -0.07916387f, 
    -0.07986573f, 0.05990100f, -0.01226945f, 0.26377562f, -0.26778710f, 0.24850914f, 0.56610894f, -0.79047972f, 
    -0.19276129f, -0.22364078f, 0.00543433f, -0.04906321f, 0.03458343f, -0.10354631f, -0.01707748f, -0.29449880f, 
    -0.57060599f, -0.97301453f, 0.06867862f, 0.14757614f, 0.05617052f, -0.02205585f, -0.08486281f, -0.08574740f, 
    -0.08092194f, -0.04298966f, -0.06671396f, -0.09124541f, -0.36431393f, -0.14760123f, -0.10796534f, 0.08652496f, 
    -0.02391027f, -0.09769388f, 0.06182249f, 0.05131864f, 0.01588703f, 0.09481821f, 0.10827770f, 0.14445852f, 
    0.48956484f, 0.48637399f, -0.11750849f, -0.06503402f, 0.09921668f, 0.20804472f, -0.00897027f, -0.02383761f, 
    0.01645397f, 0.03860277f, 0.08672846f, 0.06255223f, 0.02351919f, 0.13061827f, -0.40451869f, -0.15251215f, 
    -0.32707185f, 0.13602918f, -0.29381952f, -0.10795687f, -0.19498231f, -0.03042989f, -0.01861229f, 0.09003840f, 
    -0.19065547f, 0.24910331f, 0.10769198f, 0.05542502f, 0.03979184f, -0.25616485f, -0.04126714f, -0.19451350f, 
    -0.28683075f, -0.12060938f, 0.10454126f, -0.15381855f, 0.02867189f, 0.20140547f, -0.43272242f, -0.18918288f, 
    -0.29722717f, -0.05026007f, 0.07679601f, -0.28562918f, -0.16060665f, -0.00741528f, -0.10433593f, 0.03145309f, 
    -0.89839345f, -0.20166223f, 0.09468729f, -0.12117253f, -0.18478657f, 0.11686749f, -0.09395804f, 0.06719059f, 
    -0.10538370f, 0.07331540f, -0.08308557f, -0.09820777f, -0.58215445f, 0.26307610f, 0.10433731f, 0.10924102f, 
    -0.01903350f, 0.00705325f, -0.21112649f, -0.18556888f, 0.01402063f, 0.00093509f, -0.07994787f, 0.05301795f, 
    0.21451254f, 0.07821133f, -0.01466027f, 0.00347486f, 0.20094995f, 0.07627807f, 0.09615435f, -0.04185231f, 
    0.05178151f, 0.03597980f, -0.20194446f, -0.07814790f, -0.81794089f, -1.20799351f, -0.30960250f, -0.01708911f, 
    -0.01782741f, 0.07262228f, 0.00527861f, -0.06969189f, -0.02318928f, 0.02526033f, 0.03320418f, -0.28575757f, 
    0.57150859f, 0.19944344f, -0.08884537f, 0.07507440f, 0.22077951f, 0.39594164f, 0.31309170f, -0.05999826f, 
    -0.05976389f, -0.02785414f, -0.07911086f, -0.10812815f, -0.39940879f, -0.41199037f, -0.29766941f, 0.63772619f, 
    0.13555703f, 0.00741510f, 0.09036402f, 0.11469837f, -0.01856121f, 0.01811016f, 0.00185915f, 0.02544597f, 
    -0.10001391f, -0.10676397f, 0.29206866f, 0.19640462f, -0.18298993f, -0.08124098f, 0.27891791f, -0.08596075f, 
    0.04270489f, -0.04058738f, 0.16693854f, 0.06302930f, 0.19086686f, -0.01417225f, 0.05941493f, 0.26103082f, 
    -0.15717782f, -0.02499645f, 0.04900684f, -0.01092500f, 0.01396821f, 0.13468944f, 0.00575119f, 0.21438900f, 
    0.65490574f, 0.01840385f, 0.16238651f, -0.26995483f, -0.01112310f, 0.20671104f, -0.02079921f, -0.50185388f, 
    -0.08701435f, -0.11672698f, 0.06363645f, -0.37824506f, -0.77708703f, 0.26196769f, -0.03368579f, 0.09508265f, 
    -0.10087980f, 0.27858490f, -0.09884197f, 0.11050777f, -0.03995500f, 0.04950326f, -0.07337959f, 0.19068772f, 
    0.22206315f, -0.25187007f, 0.18402904f, -0.55470818f, -0.00876443f, 0.08059998f, 0.06115567f, 0.26967674f, 
    0.07654415f, -0.11374286f, -0.00456255f, -0.08005739f, 0.09896497f, 0.13029818f, 0.01694041f, 0.10277536f, 
    -0.01875049f, -0.00241209f, 0.01234498f, 0.03550403f, -0.57781988f, -0.33233312f, -0.20870131f, -0.46197966f, 
    0.09283502f, 0.10037793f, 0.05895235f, -0.10042334f, -0.13295266f, -0.08218170f, -0.13885631f, -0.31600681f, 
    -0.05087687f, -0.05507371f, -0.09776678f, -0.01992057f, -0.25049701f, -0.34022689f, 0.20293453f, 0.06623502f, 
    0.25379542f, -0.00644533f, -0.22903956f, 0.18449728f, -0.10807090f, 0.09585648f, -0.20196015f, 0.30803514f, 
    0.14900909f, 0.07287037f, -0.02069241f, -0.10178231f, -0.01831218f, -0.03600727f, -0.20464894f, -0.03442084f, 
    0.15156147f, -0.05808336f, 0.17898075f, -0.40654448f, 0.98955375f, 0.24751920f, -0.70599896f, -0.39512005f, 
    -0.14337690f, -0.09920244f, -0.18456851f, -0.25463387f, -0.09785923f, -0.04846054f, -0.02409729f, 0.22110197f, 
    -1.18531919f, -0.25789219f, 0.15447277f, -0.04362599f, 0.05571024f, -0.03904350f, -0.18651916f, 0.03682514f, 
    0.11847487f, 0.13442443f, 0.05437423f, -0.33395675f, 0.32858646f, -0.43038937f, -0.20860267f, -0.11784136f, 
    -0.08571663f, -0.62492716f, 0.07387272f, 0.04161744f, -0.09392036f, 0.03230796f, 0.11253970f, 0.06181857f, 
    0.05236553f, 0.09776113f, -0.61052841f, -0.13501479f, -0.08706765f, 0.11331847f, 0.09117210f, -0.02845589f, 
    -0.00244308f, -0.01318636f, 0.05188638f, 0.00913185f, 0.90344477f, 0.16495837f, 0.35243753f, 0.22818993f, 
    -0.11441142f, 0.10162371f, -0.04713288f, -0.23758377f, 0.01969232f, 0.00875997f, -0.06008573f, 0.20372917f, 
    0.21622209f, -0.00036775f, 0.42313927f, 0.08123277f, 0.03286161f, -0.22601147f, -0.23284823f, -0.36328351f, 
    0.09977799f, -0.03297360f, -0.23915969f, -0.15345043f, 0.59656197f, 0.37644058f, 0.21457487f, 0.39171687f, 
    -0.10941733f, -0.06880187f, -0.03942448f, 0.06275360f, 0.01043359f, 0.06147806f, -0.01515381f, 0.17829712f, 
    -0.40699035f, -0.47137499f, -0.35783166f, -0.55221945f, 0.02790550f, -0.13934642f, -0.02222058f, 0.15949516f, 
    -0.14060423f, -0.03595264f, -0.04527805f, -0.27098587f, -0.10191749f, 0.01194420f, -0.24644618f, -0.02858965f, 
    0.04634193f, -0.08188858f, 0.13467640f, 0.17161414f, -0.27967137f, -0.14805694f, 0.17622946f, 0.07834493f, 
    -0.69691336f, 0.91106588f, 0.57551861f, 0.13914987f, -0.19239587f, -0.03844975f, 0.39974576f, -0.26194432f, 
    0.05361618f, 0.06648129f, 0.12442847f, 0.00815945f, 0.36664018f, -0.33842418f, -0.92782176f, 0.21578468f, 
    -0.04006629f, 0.05671974f, -0.08917769f, 0.13046144f, -0.05806177f, -0.16950375f, -0.00892914f, 0.02949345f, 
    -0.89111853f, -0.07023836f, 0.08737155f, -0.25543365f, 0.09907994f, 0.02525942f, -0.19560109f, -0.01567099f, 
    0.15632243f, -0.13372423f, -0.05733069f, 0.10772079f, 0.15494052f, -0.02803206f, -0.14125809f, 0.05923781f, 
    0.01913370f, -0.06554232f, 0.05582986f, 0.05599716f, 0.01090065f, 0.12593028f, 0.23960638f, 0.23645808f, 
    -0.68641925f, -0.63375872f, -0.18039647f, -0.38934600f, 0.12043491f, -0.18115208f, 0.02818932f, 0.06073402f, 
    0.00310229f, 0.00701573f, 0.11369523f, -0.01568539f, 0.15588732f, -0.41508269f, 0.22953653f, 0.00686410f, 
    0.36177030f, -0.01795062f, -0.20660783f, -0.30979779f, 0.05207536f, -0.06666736f, -0.04086121f, 0.32935888f, 
    -0.00221719f, -0.20184299f, 0.09474529f, 0.04621690f, 0.00164067f, 0.12303027f, -0.11783360f, -0.00288020f, 
    0.27408382f, 0.08347750f, -0.31973559f, 0.06916796f, -0.64125645f, 0.46625862f, 0.27758786f, 0.25439626f, 
    0.11092373f, -0.01740365f, -0.10782886f, 0.04586127f, 0.00954005f, -0.04632321f, 0.15936175f, -0.09791464f, 
    0.10882653f, -0.15366769f, -0.25830191f, 0.18092461f, 0.04471375f, 0.12762547f, 0.17022485f, 0.03547025f, 
    -0.14995883f, -0.08762331f, 0.08374654f, -0.32577726f, -0.09713158f, -0.64942008f, 0.26640955f, -0.12719804f, 
    -0.08616066f, -0.27455136f, 0.07326797f, 0.14192370f, -0.16237660f, -0.01446055f, -0.00809586f, 0.02244275f, 
    -0.33371100f, 0.43322164f, 0.50150669f, 0.35822913f, -0.05289654f, 0.11118674f, 0.13485134f, 0.08195050f, 
    -0.05634057f, -0.16314667f, 0.15105920f, -0.12702976f, 0.19877025f, 0.17592525f, 0.06531823f, 0.56405437f, 
    -0.20632106f, 0.07845862f, 0.11646264f, -0.00042678f, 0.01726981f, 0.10993469f, -0.03180037f, 0.01838060f, 
    0.00726669f, 0.01199799f, 0.91648203f, 0.45230395f, -0.22463016f, -0.22505401f, -0.03115492f, 0.03896904f, 
    0.11595189f, -0.04050292f, 0.05715758f, -0.27898750f, -0.17103687f, -0.01093777f, -0.06119676f, -0.85405892f, 
    -0.02070088f, -0.14855944f, -0.06752121f, 0.21687962f, 0.04258951f, -0.20261389f, 0.05609326f, 0.00962340f, 
    -0.31097674f, 0.20054588f, -0.23022993f, 0.34253520f, 0.07595125f, 0.29326347f, -0.07923337f, 0.01170032f, 
    -0.28906175f, -0.01125658f, -0.00944863f, -0.08437539f, -0.32864362f, 0.29111502f, -0.08423936f, -1.18301845f, 
    0.33167437f, 0.13151604f, 0.03916601f, 0.08942283f, -0.26583442f, -0.17500879f, -0.06789648f, -0.12240209f, 
    -0.19529137f, -0.31705588f, 0.11873405f, 0.33350956f, 0.32804656f, 0.09747416f, 0.15081148f, -0.06695566f, 
    -0.01473170f, 0.02830372f, 0.13564740f, 0.19694203f, 0.43373334f, 0.11463321f, -0.04807317f, -0.58508331f, 
    -0.10512333f, -0.19440515f, -0.19774650f, -0.09596114f, -0.13977875f, 0.28558230f, -0.35136604f, 0.05517682f, 
    -0.38661581f, 0.41204613f, -0.22617583f, 0.19330509f, -0.08849287f, 0.08057947f, -0.31802019f, -0.16359986f, 
    -0.16419929f, -0.07236437f, -0.10734627f, -0.14039052f, -0.10108870f, 0.67465180f, -0.47033888f, -0.20917833f, 
    -0.08955155f, 0.05940351f, -0.01290092f, 0.00939998f, -0.01189860f, 0.00719545f, 0.03911018f, 0.04435162f, 
    0.30318215f, -0.30267909f, -0.17720397f, 0.15150115f, 0.05667034f, -0.02382408f, 0.10557306f, -0.24196041f, 
    0.07842843f, -0.00549147f, 0.02942991f, 0.19223794f, 0.19529216f, -0.23895328f, 0.14583403f, 0.26350409f, 
    -0.02944127f, 0.03419546f, 0.00902139f, -0.08473687f, -0.03481873f, 0.12748182f, 0.03511263f, 0.09970190f, 
    -0.44511572f, -0.00758138f, -0.53105342f, 0.24381635f, 0.03156107f, -0.01054626f, -0.07341507f, -0.02758178f, 
    0.10192931f, 0.00044385f, 0.02080829f, 0.13776964f, -0.97473425f, 0.17380561f, -0.48339903f, 0.77129430f, 
    -0.10681523f, -0.10973624f, 0.07714270f, -0.68162066f, -0.12483352f, 0.13418823f, -0.06674906f, -0.19524297f, 
    1.79440331f, 0.34456506f, -0.44723997f, -0.31837916f, 0.10117482f, -0.08092414f, 0.01097964f, -0.35491002f, 
    -0.27661809f, -0.40113503f, -0.10907560f, 0.11714361f, 0.32153243f, -0.01204676f, 0.42644048f, 0.21874030f, 
    -0.63191915f, -0.16495873f, -0.03866284f, 0.20964704f, 0.19699007f, -0.14917751f, 0.33832380f, 0.17368855f, 
    -0.12876019f, -0.08803894f, -0.15047753f, 0.12212674f, 0.30013254f, 0.14619415f, 0.05387341f, -0.19208692f, 
    0.14092053f, 0.13720614f, 0.07705279f, 0.08795166f, -0.53990430f, 0.93609464f, -0.14998963f, 0.19945662f, 
    -0.11704364f, -0.30566436f, -0.19426489f, -0.20889916f, -0.09136698f, -0.04793504f, -0.20876996f, -0.06691889f, 
    0.03730261f, 0.20537114f, -0.23981132f, 0.18666840f, 0.07729264f, -0.02995516f, -0.11024024f, -0.05400981f, 
    0.00388419f, 0.05753706f, -0.08030947f, 0.12087608f, -0.61931539f, -0.11192912f, 0.06838534f, -0.25956777f, 
    -0.22782582f, 0.32624397f, -0.18626529f, -0.05277877f, 0.09595233f, 0.19631903f, -0.30790392f, 0.20276561f, 
    0.14041573f, 0.03920845f, 0.29957834f, 0.23827687f, -0.01256268f, 0.09002736f, -0.00571628f, 0.05786613f, 
    -0.10979798f, 0.05054119f, -0.05505274f, -0.00392122f, 0.23232095f, 0.08473342f, -0.02421149f, -0.06603472f, 
    0.17919485f, 0.05488276f, 0.00865113f, 0.02576032f, -0.20237391f, 0.16015129f, -0.14251214f, 0.02201645f, 
    -0.32627904f, 0.35661170f, 0.18653190f, 0.24559803f, -0.15359193f, -0.26173928f, -0.06946258f, -0.00701355f, 
    -0.05337226f, 0.14996339f, -0.08297874f, 0.27447417f, 0.13292050f, -0.12724629f, -0.12282742f, 0.10830678f, 
    -0.30634072f, -0.09216600f, 0.21990882f, -0.22955298f, -0.03571159f, -0.13799067f, -0.25008947f, -0.14214118f, 
    -0.67017591f, 0.08259492f, 0.09149785f, 0.11239013f, -0.01818230f, 0.03230235f, -0.27098116f, -0.06434012f, 
    -0.10028100f, 0.14651379f, -0.10575050f, -0.05171176f, 0.06122096f, -0.28064218f, 0.02727198f, -0.02295329f, 
    0.03860919f, -0.00089775f, -0.07357156f, -0.07786747f, 0.01495917f, 0.41194370f, 0.18694741f, 0.54843414f, 
    -0.03420068f, 0.07641437f, 0.39153489f, 0.35330412f, -0.03087701f, -0.04560956f, -0.27985409f, 0.12837014f, 
    -0.00049353f, 0.01614273f, -0.06795894f, 0.02363779f, 0.29646584f, 0.15134546f, 0.01925734f, 0.08234154f, 
    0.07806744f, -0.05987174f, -0.14302273f, -0.33182696f, 0.21298648f, -0.14707470f, 0.05622851f, 0.10020576f, 
    0.11730088f, 0.07194971f, -0.10019277f, 0.05788871f, -0.08824000f, -0.07939704f, 0.03734468f, -0.11835722f, 
    0.08496755f, -0.12450676f, -0.19215904f, 0.19770929f, -0.00914832f, -0.44722146f, 0.42846984f, -0.72556746f, 
    -0.02999221f, 0.07250989f, -0.10049001f, 0.25957137f, 0.00150707f, -0.01024775f, -0.06401573f, -0.22329715f, 
    -0.44010168f, -0.55063570f, -0.17922732f, -0.23107682f, 0.12507732f, -0.15227260f, -0.05248255f, -0.01471123f, 
    -0.03606734f, -0.22805265f, -0.04863337f, -0.07342636f, 0.03196764f, 0.63998002f, -0.07301226f, 0.30329934f, 
    0.07452224f, 0.43906182f, -0.08644273f, 0.05167904f, 0.16149892f, -0.10637644f, -0.12636942f, -0.09912684f, 
    0.24751994f, 0.29689592f, -0.05872244f, 0.02802076f, -0.09681275f, 0.04084379f, -0.12778148f, 0.14594035f, 
    0.15164663f, -0.15412277f, -0.32767269f, 0.07895601f, -0.23221347f, -0.76141703f, -0.16931388f, -1.06346166f, 
    0.07390239f, 0.08559912f, -0.05407397f, 0.08635879f, -0.14127670f, -0.14224856f, -0.16822754f, -0.16522756f, 
    -0.30229533f, -0.13925032f, -0.04800495f, -0.00304601f, -0.14872420f, 0.20580792f, 0.10068314f, -0.02436230f, 
    0.00009143f, 0.00987079f, 0.10768452f, 0.07662175f, 0.35866091f, -0.27957177f, -0.62726277f, 0.26262736f, 
    0.14872587f, 0.02980462f, 0.14510180f, -0.01763009f, 0.13452153f, 0.04770729f, 0.05821050f, 0.03650475f, 
    0.08024637f, 0.40432590f, 0.22954756f, -0.34028870f, 0.23301001f, 0.10110305f, 0.02289441f, 0.04957096f, 
    0.20487362f, 0.09321765f, -0.02018187f, 0.07950623f, -0.15829523f, -0.02704636f, -0.02031778f, -0.01240619f, 
    0.06887146f, -0.04697240f, -0.20849669f, -0.13394900f, 0.27113074f, -0.10708939f, 0.12735625f, 0.03908079f, 
    -0.17502952f, -0.29363230f, -0.54804194f, -0.74809235f, 0.07639546f, 0.03811337f, -0.19091563f, 0.16950440f, 
    0.12973157f, -0.35261574f, -0.16612145f, -0.43715945f, -0.19022819f, -0.71975279f, 0.49590111f, 0.57405853f, 
    0.16953862f, -0.32305339f, -0.01130425f, 0.15830380f, 0.09644812f, -0.10659359f, 0.21718481f, -0.07800266f, 
    0.28870291f, 0.15386090f, -0.34154230f, 0.46926492f, 0.03090626f, -0.08101732f, -0.24661802f, -0.10451680f, 
    -0.05336483f, 0.23112589f, -0.16054589f, 0.18709560f, -0.08805842f, -0.31028527f, 0.16085978f, -0.10220598f, 
    0.07832546f, -0.03404143f, 0.00682250f, 0.04846052f, -0.07308112f, -0.60131371f, -0.38356256f, -0.63018626f, 
    -0.25186273f, 0.22907940f, 0.21304978f, -0.02355648f, 0.24550851f, 0.14963003f, 0.24414152f, 0.29753509f, 
    -0.05157233f, 0.01774626f, 0.18585491f, 0.15303248f, -0.18833297f, 0.52014053f, 0.22459477f, -0.18828423f, 
    -0.09908786f, -0.09732992f, 0.12856422f, -0.01891950f, -0.11704636f, -0.19897884f, -0.01590522f, -0.30926648f, 
    -0.11555431f, -0.21298337f, 0.19900978f, -0.17261845f, 0.10997611f, -0.26948521f, 0.10817091f, 0.28907672f, 
    -0.17465061f, 0.46201190f, 0.05335408f, -0.21716949f, 0.11643372f, -0.02834241f, 0.43319443f, -0.22160965f, 
    -0.09558987f, 0.02351762f, 0.03886023f, 0.08720087f, 0.29769489f, 0.08894272f, -0.11979585f, -0.00446682f, 
    -0.51108360f, 0.40392101f, 0.41854623f, 0.26534989f, -0.09417622f, -0.10627756f, 0.14823295f, 0.11299814f, 
    0.08678495f, 0.14000651f, -0.22254004f, -0.03927252f, -0.66830343f, -0.20312455f, 0.11164495f, -0.02624519f, 
    0.22687098f, 0.30261174f, -0.16600242f, -0.07463685f, -0.00412327f, -0.06537921f, -0.02876159f, 0.00088709f, 
    -0.51348108f, -0.64758706f, -0.00222825f, -0.28863716f, -0.10111844f, -0.04682436f, -0.08985949f, -0.11568207f, 
    0.07742132f, 0.13668594f, 0.04382698f, 0.08316858f, -0.24484739f, -0.49712756f, -0.21524391f, 0.31429276f, 
    0.23329219f, 0.02420790f, -0.02433259f, 0.10329470f, 0.04241138f, 0.10020710f, 0.26987579f, 0.15710461f, 
    -0.15577196f, 0.29991388f, 0.13148163f, -0.21183966f, 0.09155835f, -0.18451081f, -0.22460343f, 0.16597460f, 
    -0.05915311f, -0.04936477f, -0.05589516f, 0.10174510f, -0.27408519f, -0.23270936f, 0.02931990f, 0.28484434f, 
    0.01550939f, 0.00832842f, -0.01047598f, -0.00927976f, -0.00827846f, -0.18014705f, 0.01187092f, -0.24419783f, 
    -1.57138062f, -1.40445328f, -0.95027554f, 0.26874620f, 0.05848728f, -0.66832530f, -0.24661914f, -0.42985198f, 
    -0.17251058f, 0.04435364f, -0.16324620f, 0.03675071f, -0.02794053f, -0.04486865f, 0.12431584f, 0.12925825f, 
    0.21802562f, -0.06899368f, -0.10738739f, 0.06753530f, 0.05990615f, -0.25214842f, -0.18609226f, -0.22406887f, 
    -0.34703556f, 1.06813371f, -0.12226404f, 0.13448495f, -0.09764972f, 0.17233349f, -0.00093217f, 0.07198744f, 
    0.10740329f, 0.17376298f, 0.08721014f, 0.13756929f, -0.23827350f, -0.11062901f, -0.27478081f, 0.21786501f, 
    -0.18181530f, -0.04733516f, -0.09652214f, 0.08610497f, 0.06573484f, -0.00832863f, 0.05970225f, -0.06842204f, 
    0.98620480f, -0.24615057f, -0.42891124f, 0.14999560f, -0.11148034f, -0.16360049f, 0.34154105f, 0.03736141f, 
    -0.01986620f, 0.09506375f, 0.06292444f, -0.22697121f, -0.06248475f, -0.01847146f, -0.10249034f, -0.02018119f, 
    -0.01658981f, 0.02518708f, -0.00258973f, 0.13717483f, 0.32435486f, 0.31954566f, 0.36717445f, 0.08988517f, 
    -1.16923082f, -0.80702102f, -0.88472074f, -0.11935071f, -0.25564119f, 0.08712525f, -0.06607907f, -0.10303561f, 
    -0.02703041f, 0.06057986f, 0.03029124f, 0.00547365f, -0.09053440f, -0.78300327f, -0.53049994f, -0.30932701f, 
    -0.20796973f, 0.13209748f, 0.20075519f, 0.31675568f, 0.23326065f, 0.24811520f, 0.11315382f, -0.09259505f, 
    0.10371859f, -0.31153420f, -0.29828086f, 0.28801432f, 0.04304099f, 0.22876644f, 0.25468081f, -0.03289427f, 
    0.21222793f, -0.37332281f, 0.23224883f, 0.17589533f, 0.01138969f, -0.57946414f, -0.57152653f, 0.25192332f, 
    0.02869261f, 0.05378958f, 0.13431534f, 0.15649135f, 0.13824865f, 0.23345183f, -0.15495633f, -0.10586765f, 
    -0.10185463f, 0.08614820f, 0.20416769f, -0.12059028f, -0.16031155f, 0.06768112f, -0.05545383f, -0.01515204f, 
    -0.04495344f, -0.01748103f, 0.27259916f, 0.27492076f, -0.35857376f, -0.46636954f, -0.55756605f, 0.12394384f, 
    -0.01884983f, 0.25746328f, 0.09410504f, -0.13830566f, -0.20188850f, -0.00754012f, 0.00519908f, -0.00957126f, 
    -0.87084210f, 0.74039036f, 0.54357690f, 0.46073395f, -0.27236724f, -0.13756746f, -0.14071789f, 0.20496182f, 
    -0.09489951f, 0.12404913f, -0.06518411f, 0.16905829f, -0.05804415f, 0.21810234f, -0.07469337f, -0.31051290f, 
    0.09786360f, -0.09805135f, 0.05975046f, -0.02178243f, -0.13295254f, -0.01618354f, 0.15950416f, 0.01759513f, 
    -0.94407165f, -0.82885683f, -0.47887021f, -0.02411103f, -0.19866048f, 0.21270433f, 0.04342355f, -0.10241355f, 
    0.01105603f, -0.06511422f, 0.14510925f, 0.23072071f, -0.08041742f, -0.10427412f, -0.19987215f, -0.46546504f, 
    0.03348101f, 0.17839228f, -0.09612981f, -0.18501817f, -0.06131672f, 0.02678116f, -0.11996751f, -0.14080930f, 
    -1.01778090f, -0.76836741f, 1.22136819f, 0.03377465f, 0.03367439f, -0.16885284f, -0.13717398f, 0.40982500f, 
    -0.14681034f, 0.04295760f, -0.12405172f, 0.03190331f, 0.19063875f, 0.15030055f, 0.08911116f, -0.25783375f, 
    -0.12278525f, 0.13017510f, 0.08365981f, 0.02423611f, -0.11531354f, -0.23725103f, -0.22658230f, -0.39740571f, 
    -0.38720077f, -0.82132727f, -0.51440215f, -0.22959390f, -0.11031888f, 0.02116419f, 0.12674856f, 0.16931540f, 
    0.04586015f, 0.04883958f, 0.09555707f, -0.02387438f, 0.72296685f, 0.00512837f, 0.01753795f, -0.10453912f, 
    -0.13355140f, 0.19091593f, -0.02165257f, -0.17198284f, -0.16271530f, 0.19316164f, 0.18216148f, -0.26492795f, 
    -0.36178339f, 0.02682977f, -0.07589409f, 0.12684497f, -0.05981125f, 0.08317547f, -0.08940326f, 0.06622706f, 
    0.01040093f, 0.15968961f, 0.09643339f, -0.08654365f, 0.33933997f, -0.07555500f, 0.21066348f, -0.16167043f, 
    -0.05071623f, -0.06550884f, -0.05042909f, -0.04124154f, 0.18180116f, 0.00404440f, 0.03905489f, -0.10655167f, 
    -0.63396674f, -0.48931587f, -0.40753314f, -0.18986540f, 0.21511371f, 0.06030556f, -0.15508284f, 0.22708248f, 
    0.09961850f, -0.04685006f, -0.01908617f, -0.10414314f, -0.41428590f, -0.02849155f, -0.13891535f, 0.38803950f, 
    0.09820161f, 0.14338003f, 0.29164502f, -0.22910097f, -0.07414247f, -0.20786713f, -0.07286337f, -0.12108179f, 
    0.03349332f, -0.16553965f, 0.37684005f, -0.13196832f, 0.05889245f, 0.08359789f, -0.12439278f, -0.16451785f, 
    -0.22989865f, -0.04098742f, 0.16172276f, -0.08598055f, -0.58051318f, -0.24037710f, 0.72820085f, -0.83276606f, 
    0.36285669f, 0.07213307f, 0.25535446f, -0.12123862f, -0.00267021f, 0.01157182f, 0.08422416f, 0.10809436f, 
    0.68798548f, 0.27053443f, -0.47257757f, -0.09876916f, -0.09676054f, 0.03185909f, -0.05277058f, -0.18292837f, 
    -0.15327992f, -0.15394841f, 0.04639480f, 0.09827089f, -0.27774236f, 0.40314826f, -0.17929865f, -0.09258650f, 
    -0.23827116f, 0.08563561f, -0.15710510f, -0.10116538f, 0.04451162f, 0.09471101f, 0.01009971f, -0.00240238f, 
    0.86359489f, -0.80254716f, -0.42477164f, -0.47935721f, -0.01462295f, -0.00606457f, 0.04888552f, -0.16609722f, 
    0.07845389f, -0.06882348f, 0.04801274f, 0.05286773f, 0.14915276f, 0.03572169f, -0.40150133f, -0.04545080f, 
    0.02944195f, -0.16932485f, -0.02533199f, -0.13192751f, -0.03277835f, 0.04660646f, -0.04240272f, -0.10063574f, 
    0.06702997f, -0.79586917f, -0.55831683f, -0.94138539f, 0.04555963f, -0.21161069f, 0.16803859f, 0.27200282f, 
    0.00810566f, -0.00505186f, -0.10670440f, -0.10115253f, 0.07458454f, -0.03964510f, -0.06842437f, -0.18476185f, 
    0.06196610f, -0.02027514f, -0.00553820f, -0.05365786f, 0.14509889f, 0.05876919f, 0.00070657f, -0.05431332f, 
    0.28246221f, -0.77283770f, -0.82470256f, -0.62756854f, -0.19754943f, -0.03928266f, 0.15553886f, -0.01717355f, 
    0.12965131f, 0.13926865f, 0.06855687f, 0.16276358f, -0.01324637f, -0.00927666f, -0.14655502f, -0.25693774f, 
    -0.14890645f, -0.26682284f, -0.04899516f, 0.01198376f, 0.22545037f, 0.06599980f, 0.14532892f, 0.14261316f, 
    -0.44685698f, -1.62872887f, -0.33134609f, 0.50680155f, 0.13034390f, 0.17277415f, 0.10722185f, -0.06015736f, 
    -0.30745980f, -0.01283843f, -0.04770370f, -0.05249682f, 0.72406381f, 0.06310778f, -0.46519783f, -0.50661772f, 
    0.43588883f, -0.10592198f, -0.07525239f, -0.05309400f, 0.13425939f, 0.19143212f, 0.07369027f, 0.48082221f, 
    -0.49385253f, 0.47174755f, 0.17348987f, 0.07889790f, 0.10051756f, -0.03927016f, -0.00941605f, 0.24948567f, 
    0.10101447f, -0.13491014f, 0.36371869f, 0.13726035f, -0.06704535f, -0.03367783f, -0.05815262f, -0.21953107f, 
    0.13250837f, -0.07110258f, 0.06211758f, -0.06558809f, -0.11648428f, 0.09018461f, -0.42088196f, -0.52207488f, 
    0.17178185f, -0.54661548f, -0.52028519f, 0.16231638f, 0.01772152f, 0.35372907f, 0.29575822f, -0.16473632f, 
    0.12623571f, -0.07511623f, 0.04838355f, -0.07574195f, -0.12961878f, -0.20252483f, -0.04744865f, 0.14673808f, 
    0.06661932f, 0.12986310f, 0.22370499f, 0.25969052f, -0.33011812f, 0.13689601f, -0.17951043f, -0.51384461f, 
    -0.21809854f, -0.31993049f, 0.11839329f, -0.22503884f, -0.05124962f, 0.18165790f, -0.02538060f, 0.04140568f, 
    -0.34459060f, -0.36327770f, -0.06065274f, -0.21488705f, 0.36676598f, -0.47511488f, 0.29775319f, 0.29168639f, 
    0.19282721f, 0.12511794f, -0.09776161f, -0.40232417f, 0.18059640f, 0.08210617f, 0.06059948f, 0.26114646f, 
    0.35365617f, -0.09367915f, -0.04596568f, -0.55048645f, -0.09804319f, 0.13768379f, -0.05736756f, 0.16930833f, 
    0.07577067f, 0.21146755f, -0.05388840f, -0.01629367f, -0.38357183f, -0.04487319f, 0.46260861f, 0.00460138f, 
    0.21042889f, -0.12172240f, -0.05387085f, -0.07465760f, 0.07349844f, 0.02061556f, 0.11030032f, 0.18435025f, 
    -0.33666283f, -1.00171065f, -0.51261616f, -0.14252855f, -0.04668601f, 0.13283803f, 0.16379355f, 0.10701641f, 
    0.13579035f, -0.00239397f, -0.04057962f, -0.07837009f, 0.03925724f, -0.10574546f, 0.31524017f, 0.07425489f, 
    -0.04416966f, -0.01182614f, 0.06168243f, -0.01622265f, -0.00653769f, -0.07805261f, -0.05126354f, 0.06819501f, 
    0.65257889f, -0.30302778f, -0.94695604f, 0.00112217f, -0.29772034f, -0.01403683f, 0.26719990f, -0.04325031f, 
    0.07024238f, -0.13238283f, -0.04605318f, -0.10030791f, -0.56491119f, 0.33103019f, 0.27801231f, -0.30354217f, 
    -0.12584880f, -0.20303060f, -0.16499740f, -0.11268692f, -0.36980349f, -0.02972334f, -0.15409212f, 0.07721057f, 
    -0.90134686f, -0.68929219f, 0.37399518f, -0.29610631f, -0.25282255f, 0.28115502f, -0.23483166f, 0.30445918f, 
    0.00494862f, -0.10937263f, -0.01377052f, -0.07370643f, -0.02112436f, -0.25358099f, 0.23270790f, 0.26518974f, 
    -0.03991318f, 0.31507990f, -0.25694397f, 0.13800402f, 0.17183295f, 0.22801299f, 0.30945277f, -0.28897473f, 
    0.40017274f, -0.22710635f, 0.15266228f, -0.60189021f, -0.36882651f, -0.38053232f, -0.31825352f, -0.06593848f, 
    -0.06881401f, -0.03616345f, 0.13266395f, 0.10662343f, -1.10517776f, 0.06363838f, -0.15767045f, 0.21608514f, 
    0.11709958f, 0.08898433f, -0.18855093f, -0.20481214f, 0.09651873f, -0.18468989f, -0.31268683f, -0.08203839f, 
    -0.16378567f, 0.82692146f, -0.86311996f, -0.38038608f, -0.32058594f, 0.00058061f, 0.14321426f, -0.20934518f, 
    0.06304843f, -0.03714389f, -0.11008421f, 0.18480001f, 0.06600182f, -0.21503474f, 0.35266542f, 0.17743440f, 
    -0.00259451f, 0.13937522f, -0.15224850f, -0.08994350f, 0.11773764f, 0.29265842f, 0.38195240f, 0.32806522f, 
    -0.44093880f, -0.14072520f, 0.64571726f, -0.15886696f, -0.46315184f, -0.18066868f, -0.13609859f, 0.09692363f, 
    -0.00142419f, 0.03691806f, 0.03269488f, -0.05114594f, -0.07709979f, 0.54127860f, -0.05600255f, -0.25326127f, 
    -0.15270559f, -0.02322455f, -0.14279667f, -0.11155266f, 0.21548364f, 0.16315497f, 0.04692042f, -0.00108864f, 
    0.39057621f, -0.65640002f, 0.40663812f, -0.66347677f, -0.33413926f, 0.15304564f, -0.11210734f, 0.03432852f, 
    0.02788865f, -0.03954266f, 0.20025104f, 0.17456123f, 0.10835342f, -0.99628854f, 0.25168711f, -0.46132025f, 
    0.15759739f, -0.16482581f, -0.06199866f, 0.14457335f, -0.14979446f, 0.07957187f, -0.16539277f, -0.17614004f, 
    -0.39304027f, 0.31956121f, -0.28007573f, 0.64070904f, 0.10541757f, -0.16256046f, -0.35035628f, -0.33324802f, 
    0.12359642f, -0.22787705f, 0.18251039f, 0.18949117f, -0.50130957f, 0.08796236f, -0.62778383f, -0.55772263f, 
    0.45263261f, -0.08854811f, 0.39002305f, 0.08871745f, 0.07558034f, -0.12930152f, -0.00891765f, -0.11584299f, 
    0.36226705f, 0.01826769f, 0.74403936f, 0.07099773f, 0.28542966f, -0.42059484f, -0.15344532f, -0.23017175f, 
    -0.05918943f, -0.18220004f, -0.01323003f, 0.11594436f, -0.37390065f, -0.19737321f, -0.01399988f, -0.22245310f, 
    0.21506870f, 0.06808787f, 0.00893013f, 0.08856734f, -0.09231640f, -0.11921965f, 0.01469344f, -0.11284448f, 
    -0.16944583f, -0.05960306f, 0.02448449f, 0.36634493f, 0.08457343f, 0.07186650f, 0.12374640f, 0.18334387f, 
    0.09687393f, 0.11650053f, 0.10769225f, 0.01222329f, -0.12126260f, -0.37429720f, 0.12046444f, 0.36615077f, 
    0.22745724f, 0.17430964f, 0.18343890f, -0.00647077f, 0.20807719f, 0.12935869f, 0.08261970f, 0.12159102f, 
    -0.54183215f, -0.04062326f, -0.05465984f, 0.46914625f, -0.30735236f, 0.13111436f, -0.23470987f, 0.09640630f, 
    0.24433140f, 0.11639301f, 0.25467336f, 0.10582006f, -0.36517665f, -0.50738984f, 0.14335330f, 0.34313777f, 
    -0.16529107f, 0.14881939f, -0.33813697f, -0.29415807f, -0.10043500f, 0.02843621f, 0.03067533f, -0.00367800f, 
    -0.12486487f, 0.16328916f, -0.39004248f, 0.67512763f, 0.15786171f, -0.06886460f, -0.03286034f, 0.29678452f, 
    -0.25644416f, -0.01507395f, -0.27392665f, -0.58338833f, -0.13956934f, 0.77436054f, 0.25267705f, -0.23012505f, 
    -0.25932917f, 0.43994233f, 0.15879944f, 0.23707353f, -0.11216371f, 0.12678100f, 0.14132498f, 0.12282210f, 
    0.17157702f, -0.13174212f, -0.10880644f, -0.26153395f, -0.08787582f, 0.01863590f, 0.27035731f, -0.16337641f, 
    0.00065185f, 0.13799374f, 0.06765988f, 0.14153960f, -0.45610186f, 0.31379285f, 0.26461729f, -0.15902869f, 
    -0.04221477f, 0.22153117f, -0.20338297f, -0.09814597f, -0.13521695f, -0.50894088f, -0.77097183f, -0.47479421f, 
    -0.23764680f, -0.36343357f, -0.27018112f, 0.09686348f, 0.02987126f, 0.08968385f, -0.08647481f, 0.12948194f, 
    -0.04383247f, 0.07991499f, 0.06740786f, -0.07485487f, 0.14128195f, -0.10524758f, -0.24070449f, -0.10737617f, 
    -0.16701049f, -0.30312344f, 0.43967086f, 0.12244587f, -0.21974793f, -0.56549180f, -0.29458579f, -0.11776245f, 
    -0.60522652f, 0.72087801f, 0.28597659f, -0.28333265f, 0.00473316f, -0.16578811f, -0.27312467f, 0.05867840f, 
    -0.41656223f, -0.06997518f, -0.22671930f, -0.28394467f, -0.74083638f, 0.58983082f, -0.46186814f, 0.49288377f, 
    -0.19653313f, 0.09611375f, -0.06795117f, 0.38623714f, 0.06073673f, -0.01049648f, 0.22775850f, 0.23158792f, 
    0.60980338f, 0.11544169f, 0.48269087f, -0.19014196f, -0.07318063f, 0.05514093f, 0.17931400f, 0.23151606f, 
    -0.09104231f, 0.22125661f, -0.14442925f, 0.11466038f, 0.02369173f, -0.51115721f, 0.28682908f, -0.04784202f, 
    -0.36147738f, 0.42818168f, 0.19245191f, 0.10279272f, -0.19545574f, 0.21860169f, -0.58900654f, -0.02172413f, 
    0.07813948f, 0.07541022f, -0.11878782f, -0.06123792f, -0.00453489f, -0.04672828f, 0.22643648f, 0.14528668f, 
    -0.09118617f, 0.10855135f, 0.05388572f, 0.09546966f, -0.54700035f, 0.52258056f, 0.19787173f, -0.05291511f, 
    -0.08300363f, -0.03464749f, -0.37956920f, 0.34265193f, 0.20196612f, -0.21535401f, 0.34040222f, 0.00941172f, 
    -0.30190554f, 0.05304615f, -0.39291281f, 0.01233177f, -0.04852533f, 0.13897273f, -0.16303007f, 0.02223262f, 
    -0.13127923f, 0.28567982f, -0.02906477f, -0.37147743f, -0.46324471f, -0.31478152f, -0.58671534f, -0.02915756f, 
    -0.41676232f, -0.51810980f, -0.01063915f, -0.21448115f, -0.14177723f, 0.17797019f, -0.02196096f, 0.05754131f, 
    -0.44285131f, -0.66800934f, 0.02899194f, 0.34962690f, -0.43130606f, -0.12350542f, -0.23094952f, -0.43881446f, 
    0.01978100f, -0.07902067f, 0.01024043f, -0.16034847f, -0.64605480f, 0.13537124f, -0.43221134f, -0.06468715f, 
    0.03386465f, -0.03254662f, 0.35813427f, -0.00049651f, -0.00987813f, 0.14013565f, 0.02765184f, -0.21699744f, 
    -0.30878571f, -0.20658407f, 0.68196428f, -0.22838069f, -0.20745492f, -0.34899494f, 0.11329897f, 0.16345584f, 
    -0.24016124f, -0.12009899f, 0.12416986f, 0.06111162f, -0.25217679f, -0.47546294f, 0.01381635f, -0.14261065f, 
    0.16302578f, -0.01196431f, -0.10484561f, -0.02651694f, 0.02110310f, 0.21645106f, 0.16970822f, -0.32101354f, 
    0.38390774f, -0.46360642f, 0.87704527f, 0.00298981f, 0.21350712f, 0.29169223f, 0.19249862f, 0.04106986f, 
    -0.32952616f, -0.12460013f, -0.06581084f, -0.02425077f, -0.15535793f, 0.16510977f, -0.42133263f, 0.04107487f, 
    -0.02876934f, -0.06168215f, 0.04372090f, 0.02023440f, 0.37384611f, -0.07237490f, 0.06811104f, 0.19121140f, 
    0.36230820f, -0.04273887f, -0.21048951f, -0.35363334f, -0.22102986f, -0.25238177f, 0.04651903f, -0.12262303f, 
    0.00669489f, 0.08280014f, -0.07517070f, -0.22355852f, -0.57744706f, 0.25230503f, -0.18693292f, -0.30704480f, 
    -0.10007229f, 0.10057423f, -0.14490438f, 0.04446894f, 0.16495982f, 0.26265612f, 0.23600839f, -0.18929812f, 
    -0.30159238f, 0.60416931f, -0.89555329f, 0.49482778f, 0.02877483f, 0.01974874f, 0.37685063f, 0.22889817f, 
    0.01750198f, -0.03387338f, -0.22030768f, 0.22608694f, -0.48036087f, 0.14474675f, -0.17458095f, 0.53673857f, 
    -0.13163874f, -0.25658810f, -0.02399419f, 0.52155846f, -0.33802909f, -0.02483586f, -0.09990688f, -0.08100620f, 
    0.00159229f, -0.49130562f, -0.14780103f, 0.08392678f, 0.21969382f, 0.16345321f, 0.27287027f, -0.11718227f, 
    0.08665545f, 0.10805101f, 0.02738927f, 0.24619773f, 1.27199423f, -0.06587663f, 0.47959128f, -0.00230153f, 
    0.07976384f, -0.06172553f, -0.18190113f, 0.08535652f, -0.06612656f, 0.10157642f, -0.06278345f, 0.17119814f, 
    -0.41795546f, -0.11777384f, -0.32810482f, -0.10236518f, 0.00166998f, -0.23105657f, -0.10777085f, -0.05947787f, 
    -0.12133241f, 0.00365644f, 0.00185859f, -0.23838697f, 0.10801136f, 0.17754903f, -0.16341686f, 0.10701574f, 
    -0.04156324f, -0.11089263f, -0.03223482f, 0.19642939f, -0.06550560f, 0.13381830f, -0.13916430f, 0.03214021f, 
    -0.24256109f, -0.16106981f, 0.33224857f, -0.21460667f, -0.21434437f, -0.05125517f, 0.54534733f, 0.08466251f, 
    0.05378668f, 0.26294428f, 0.20388450f, 0.15130463f, 0.12945259f, 0.29642090f, 0.05236645f, -0.11977787f, 
    -0.12977678f, 0.07886795f, -0.04232382f, 0.05745764f, -0.05386158f, 0.06363667f, -0.03900451f, -0.25124675f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.29319522f, 0.03398785f, 0.19505446f, -0.28042221f, -0.06840362f, 0.24471401f, 0.06484415f, -0.18347257f, 
    0.18577591f, -0.04724905f, 0.04706754f, -0.18451031f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
