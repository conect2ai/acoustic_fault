#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -1.31919968f, -1.05570710f, -0.67209500f, -0.13478401f, 0.03282584f, 0.11497855f, 0.52705324f, 0.95218962f, 
    0.26042181f, 1.03796613f, 0.23262505f, 0.40967545f, 0.14680369f, -0.48569646f, 1.01509762f, 0.40770152f, 
    -0.85957909f, -0.32366100f, -1.06316149f, 0.51323938f, 0.16817026f, 1.03324342f, 1.08249748f, 0.99207675f, 
    0.16344720f, 0.29499483f, 0.36732429f, -1.61387110f, 1.74585211f, -0.15966249f, -1.12337530f, -0.83316797f, 
    -0.46186918f, 0.15698731f, 0.04077069f, 0.29496840f, 0.33652654f, -0.28784394f, -1.21791983f, -0.14074381f, 
    -0.92075729f, -1.15551174f, -0.63304573f, -0.49549612f, -0.23744491f, 0.92756969f, -1.05757344f, -0.07539860f, 
    -0.76522171f, -0.32517609f, -0.17730513f, 0.55537236f, 0.49047083f, 0.72595882f, 0.67547977f, 1.31777394f, 
    -1.14003253f, -0.70343763f, 0.63490260f, -0.40468177f, -0.09818678f, -0.47309506f, -0.56317264f, 0.06087641f, 
    0.12810014f, 0.54292285f, -0.29594290f, 0.27364478f, -0.00269304f, -0.60126323f, -0.60891372f, 0.81236094f, 
    0.98263955f, -0.65566182f, 0.20496432f, 0.07436646f, 0.41758022f, 0.63131732f, 0.56901848f, 0.28634346f, 
    0.92146778f, -0.84780347f, 0.88882184f, 0.13415091f, 0.64624369f, 0.17612377f, 0.76150280f, -0.64175177f, 
    -0.41009322f, -0.48143512f, 0.52166855f, 0.55940849f, 0.86817920f, -0.07708400f, -0.77259856f, -0.06079342f, 
    0.31491962f, 0.66089720f, 0.01182311f, 0.65950847f, 0.37514937f, 0.44891194f, 0.63626385f, -0.78072900f, 
    -0.73789227f, -0.41949332f, 0.14198224f, 0.73186398f, -1.00233197f, -0.25925919f, 0.98312312f, 0.91329265f, 
    -0.88699764f, -0.94325519f, 0.12090050f, -1.09642613f, -0.81972659f, -0.75364745f, -1.30569720f, -0.18185766f, 
    -0.92472935f, 0.14834963f, -0.80080682f, 0.01397931f, -0.33158258f, -0.56494790f, -0.77985716f, -1.29545856f, 
    -1.13779914f, 0.25889719f, 1.07144654f, 0.50770283f, -0.74831724f, -0.57860547f, -0.65893370f, -0.42854628f, 
    -0.44665870f, 1.95479751f, -0.64940518f, 0.53694272f, 0.35000700f, 0.20565805f, -0.37665129f, 0.12571676f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    1.14251423f, 0.05262664f, -0.28219017f, 0.50433272f, 0.19365419f, 0.43760332f, -0.09198295f, 1.06845117f, 
    0.03951882f, -0.05941135f, 0.90965307f, 0.48008487f, 0.06514768f, 0.71459877f, 0.31886068f, 0.63153315f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.36329406f, 0.15230006f, 0.32046410f, -0.14820585f, 0.13220210f, 0.06093205f, 0.10890854f, 0.20039241f, 
    0.08569189f, 0.09583960f, -1.15586209f, -0.17208394f, -0.28411934f, -0.22333430f, -0.10002456f, -0.06828110f, 
    -0.26416215f, 0.01245489f, 0.62023193f, 0.71846324f, -0.28779399f, -0.43146652f, 0.06058179f, -0.09936167f, 
    0.38034070f, 0.14343581f, 0.04182299f, -0.10341436f, -0.01345254f, -0.23548260f, -0.13560148f, -0.21643792f, 
    0.34465384f, 0.00191296f, -0.03823612f, 0.09409835f, 0.18830155f, 0.25089017f, 0.57335180f, -0.26041684f, 
    0.13834830f, -0.12391986f, 0.06382176f, 0.14216189f, 0.05802040f, 0.00388618f, 0.02346640f, 0.20634682f, 
    -0.00743423f, -0.02699567f, -0.00604713f, 0.01591237f, -0.18734349f, 0.08928762f, -0.15493104f, 0.26241508f, 
    -0.70576280f, 0.22703901f, -0.23800075f, 0.27258039f, 0.18002266f, 0.08171634f, 0.14735198f, -0.54471540f, 
    -0.32184109f, 0.11349581f, -0.03534831f, 0.16965564f, 0.07838933f, 0.16154541f, -0.17047566f, -0.09757835f, 
    -0.11735293f, -0.06959692f, -0.33349723f, 0.13405123f, 0.14369048f, 0.09912134f, 0.18432200f, 0.06396898f, 
    0.29620075f, 0.30618751f, 0.12875803f, -0.10708984f, -0.15312827f, -0.46798339f, 0.02056354f, 0.12922607f, 
    -0.08348567f, 0.11714670f, 0.03284121f, -0.62669873f, -0.09757789f, -0.24542822f, 0.32029808f, 0.06887285f, 
    -0.05647353f, 0.02700876f, 0.25706655f, 0.02811491f, -0.82256418f, 0.11360085f, 0.03076949f, 0.03600895f, 
    0.17951578f, 0.02937487f, 0.05179414f, 0.02266011f, -0.28695399f, -0.41215333f, -0.42130053f, -0.22502606f, 
    0.02030115f, 0.06615521f, 0.04918049f, 0.02773454f, -0.19980156f, 0.22985440f, 0.04094177f, 0.29399484f, 
    -0.21315151f, 0.16926074f, -0.07276084f, 0.26639798f, 0.14417267f, 0.04121569f, -0.20443094f, -0.26101667f, 
    0.25035235f, -0.18081662f, 0.18209210f, -0.03687592f, 0.19258764f, 0.13197957f, -0.05067516f, -1.73052585f, 
    -0.84438938f, -0.77895892f, -0.13074142f, -0.03126443f, 0.16708857f, -0.11849559f, -0.01413480f, -0.04730926f, 
    -0.05524097f, -0.00976836f, -0.06548586f, 0.06938802f, 0.07263926f, 0.00921826f, 0.03259178f, 0.03053107f, 
    -0.03176360f, 0.03742968f, 0.06573509f, 0.01109663f, -0.07804410f, -0.04326723f, 0.03947441f, 0.03387412f, 
    0.03568573f, -0.08778029f, -0.06162781f, -0.03473932f, -0.01682235f, -0.03164291f, -0.05455998f, -0.01455417f, 
    0.05901441f, 0.02161350f, -0.04035502f, -0.07696986f, 0.01123410f, -0.01169568f, 0.02349950f, -0.05480476f, 
    -0.02586684f, -0.01958593f, -0.03434476f, -0.06839290f, -0.01834976f, 0.06555569f, -0.07685199f, -0.01162271f, 
    0.00320974f, -0.05928011f, -0.05507765f, -0.08222076f, -0.08043368f, -0.04677134f, 0.07435645f, -0.05726347f, 
    -0.05721415f, 0.03509767f, -0.00822354f, -0.08287659f, 0.01376667f, 0.06502359f, 0.01372914f, 0.06361962f, 
    0.05349157f, 0.02659095f, -0.06038494f, 0.01664382f, 0.04048822f, -0.03879657f, -0.02693751f, 0.05265692f, 
    -0.01971287f, -0.03376495f, 0.07112205f, 0.01946850f, 0.06861245f, -0.07059185f, -0.01274879f, -0.02871628f, 
    0.05165795f, 0.00663178f, -0.01704276f, 0.00492217f, 0.07947180f, 0.07423457f, -0.06055210f, 0.05251157f, 
    -0.07997758f, 0.03407787f, 0.02446982f, -0.01347160f, 0.02298399f, -0.06343392f, 0.00558981f, -0.08301984f, 
    0.07113249f, 0.02112859f, -0.02323476f, -0.05829899f, -0.05914208f, -0.04423696f, 0.01660179f, -0.06530056f, 
    0.04061433f, -0.07372487f, -0.06434036f, -0.05013086f, -0.06900530f, 0.04609892f, -0.02584132f, -0.07900598f, 
    -0.05721905f, -0.03083943f, -0.01893070f, 0.02217824f, -0.05862968f, 0.00762883f, -0.06720421f, 0.00435697f, 
    0.01248502f, -0.02084760f, -0.01815932f, 0.03241381f, -0.02732470f, -0.04384636f, -0.07224618f, -0.03742705f, 
    0.01397375f, -0.08662540f, -0.04467450f, 0.00395631f, 0.00259406f, -0.01580780f, -0.01645620f, -0.07142013f, 
    0.02875417f, -0.03351333f, -0.04421394f, 0.00562976f, 0.00835047f, -0.04030738f, 0.06126396f, -0.03866617f, 
    0.03342501f, 0.03769241f, 0.02838138f, -0.05904452f, 0.04357747f, -0.03554881f, 0.02624512f, -0.06250953f, 
    -0.03739069f, -0.01358385f, 0.32140639f, -0.16418444f, -0.10749985f, -0.06460702f, 0.32435051f, 0.09066910f, 
    0.10677395f, -0.42549625f, -0.08654588f, -0.02636504f, 0.01839103f, -0.06468064f, -0.24475759f, -0.00276744f, 
    0.12683126f, 0.05909432f, 0.07620850f, 0.14865035f, -0.18564294f, 0.15300657f, 0.20721839f, 0.03831520f, 
    0.07869165f, 0.13270408f, 0.09671225f, 0.89131385f, 0.13125907f, 0.22502072f, 0.04444332f, -0.17425494f, 
    0.03057131f, 0.04479430f, -0.03787272f, 0.11045879f, 0.14482628f, -0.06184073f, 0.61707681f, -0.16863760f, 
    0.14825296f, -0.11948668f, 0.14090115f, 0.15434712f, 0.00773994f, -0.04004531f, -0.30454388f, -0.06955227f, 
    0.14151086f, -0.02265241f, -0.26159969f, 0.11386186f, 0.28371808f, -0.19317624f, 0.80236655f, -0.12514138f, 
    -0.50816405f, -0.22834565f, -0.07709413f, 0.05049535f, 0.22845100f, -0.02145690f, 0.04997918f, 0.02312835f, 
    -0.00523247f, -0.29112580f, 0.14438617f, 0.03385139f, 0.17837346f, 0.11715522f, 0.17789400f, 0.00113071f, 
    -0.10331248f, -0.12839296f, -0.14465204f, 0.08456314f, 0.01757180f, -0.00201673f, 0.15368803f, 0.41786185f, 
    0.27518561f, 0.50527382f, -0.48558074f, -0.72937328f, -0.00749595f, 0.17696440f, 0.05099108f, -0.01419430f, 
    -0.15713324f, -0.13159792f, 0.13416158f, 0.24568999f, -0.05238583f, -0.17567423f, 0.20415680f, -0.12334157f, 
    0.18986866f, 0.12431625f, -0.09224775f, -0.10424448f, 0.20747252f, 0.27928311f, -0.23035142f, -0.00406315f, 
    0.05144854f, 0.25397632f, -0.07010187f, -0.36371934f, -0.63301146f, 0.09074722f, 1.02435803f, -0.14757839f, 
    0.14693962f, 0.07799955f, 0.27741584f, -0.20029232f, -0.14748597f, -0.21050660f, 0.03696569f, 0.12544882f, 
    -0.08021925f, 0.15731126f, 0.22732186f, -0.07502981f, 0.25888169f, 0.05967342f, -0.60028696f, 0.03187301f, 
    0.18904257f, -0.02522772f, -0.07963702f, -0.06936675f, -0.22848201f, 0.07710053f, 0.24031849f, 0.03696974f, 
    -0.58390230f, -0.70686251f, -0.01399216f, -0.32195526f, 0.04556425f, -0.05273271f, 0.03946133f, 0.03376374f, 
    -0.06831182f, -0.03332801f, -0.06219878f, -0.10940727f, -0.10131728f, 0.05773600f, -0.01127613f, 0.00691252f, 
    -0.00729278f, -0.05214256f, -0.06541412f, 0.02416062f, -0.04839434f, -0.07723881f, -0.04501699f, 0.01895903f, 
    -0.07619976f, -0.01427441f, -0.07268646f, 0.03629026f, -0.07265722f, 0.01461929f, 0.06363519f, 0.03260831f, 
    0.03838267f, 0.02538596f, -0.03086153f, -0.04014953f, 0.05392043f, -0.01521397f, 0.06139712f, -0.00789461f, 
    0.04761844f, -0.06667586f, 0.01433384f, 0.02003218f, -0.03712651f, -0.09665995f, 0.02585265f, -0.02653028f, 
    -0.08183551f, 0.04152515f, -0.00925201f, 0.06529113f, -0.01259255f, -0.06009134f, 0.00993161f, -0.09584018f, 
    -0.02534313f, -0.05204971f, 0.04734777f, -0.02989945f, -0.01010639f, -0.09959093f, -0.08168996f, 0.02780497f, 
    -0.09111932f, -0.03116454f, -0.08937684f, 0.02713965f, 0.05265946f, -0.01376284f, -0.04000887f, 0.02697874f, 
    0.00913414f, -0.05547479f, -0.02177950f, -0.09303616f, -0.02036520f, 0.01213187f, -0.09958185f, -0.02398605f, 
    -0.00770202f, -0.08547069f, -0.09281700f, 0.02280967f, 0.04173679f, 0.01538845f, 0.02625742f, 0.04690292f, 
    -0.01791834f, -0.04842752f, -0.09041631f, -0.09400669f, -0.05672541f, 0.01358556f, 0.00725378f, 0.00238973f, 
    -0.05883067f, -0.04542919f, 0.00067268f, -0.09884937f, -0.03603856f, -0.08933522f, -0.01844712f, 0.01930817f, 
    0.05294339f, -0.02009522f, -0.03973363f, 0.04110112f, -0.02026560f, 0.02477784f, 0.03695296f, 0.00260914f, 
    0.02664177f, -0.08582156f, -0.04895189f, -0.01553969f, -0.00713787f, -0.05902759f, 0.02792030f, 0.04032581f, 
    -0.06062979f, -0.08244693f, -0.07116845f, 0.00137015f, -0.06521200f, 0.05843751f, 0.07196593f, -0.07514247f, 
    -0.00191734f, 0.02562451f, 0.01687143f, 0.06137168f, -0.01812338f, -0.04885691f, -0.01992097f, -0.04899361f, 
    -0.02594831f, -0.06159643f, -0.05220750f, -0.02121483f, 0.03518205f, -0.04776673f, -0.02097751f, 0.04150785f, 
    -0.00432291f, 0.01083440f, -0.05932516f, 0.04157525f, 0.00791744f, -0.09937698f, -0.03016196f, -0.04936740f, 
    -0.04985211f, -0.11423714f, 0.34340131f, 0.18785989f, 0.03165503f, -0.13292798f, 0.16329600f, 0.03714050f, 
    0.25939295f, -0.28294793f, -0.11518842f, 0.02635821f, -0.38324365f, -0.04533895f, 0.12477388f, -0.38278010f, 
    0.36546397f, -0.26150519f, -0.23968872f, 0.36790687f, -0.21342053f, -0.14608726f, -0.01166412f, -0.37019584f, 
    0.06412627f, -0.00599370f, -0.03890195f, -0.25934348f, 0.28461996f, -0.36886790f, -0.25132152f, 0.21915813f, 
    0.09352199f, 0.17423204f, 0.19004129f, 0.12080532f, -0.22451372f, -0.60508925f, 0.16895179f, -0.02520087f, 
    -0.02626746f, -0.11107426f, 0.06888189f, 0.03854291f, -0.13472880f, -0.08800046f, -0.06677823f, 0.50588834f, 
    -0.00322821f, -0.19762990f, 0.28542644f, -0.03126232f, 0.05821591f, 0.35155109f, -0.98737907f, 0.42564404f, 
    0.02250089f, -0.33854321f, 0.07099924f, 0.12722450f, -0.13090272f, 0.20549549f, -0.23162755f, -0.10040698f, 
    0.18575080f, 0.19442379f, 0.22287282f, 0.25256264f, 0.27937141f, 0.51110518f, 0.23000744f, 0.18556064f, 
    -0.08745522f, 0.05874211f, 0.01710042f, -0.05811258f, -0.02101279f, 0.00095974f, 0.13123572f, 0.04577499f, 
    0.51420003f, -0.14889111f, 0.34642783f, -0.10482656f, -0.09887344f, 0.08235562f, 0.03373550f, 0.13874017f, 
    -0.21407612f, 0.09454605f, -0.07994746f, 0.06579420f, -0.17764190f, -0.13322517f, 0.47699782f, 0.02203894f, 
    0.11822354f, 0.20181336f, 0.12896425f, -0.03115855f, -0.17989765f, 0.21634394f, -0.09006657f, 0.06254959f, 
    -0.11375595f, 0.37855658f, 0.13939899f, 0.08877537f, -0.52142078f, -0.43771961f, 0.23060845f, -0.12779096f, 
    0.23266779f, -0.35696626f, 0.02712730f, -0.15325987f, 0.19414598f, -0.15773349f, -0.21320292f, 0.37861237f, 
    0.12570691f, -0.06429810f, -0.04190987f, 0.23257951f, 0.05857061f, 0.12871842f, 0.40003818f, -0.64851260f, 
    -0.42646348f, 0.15014857f, -0.10616263f, 0.01811130f, -0.09030402f, -0.05658720f, -0.06441134f, -0.64005023f, 
    0.38106114f, -0.37376401f, 0.01289380f, 0.28549173f, -0.10474797f, -0.06157126f, 0.28521600f, -0.00708268f, 
    -0.00057726f, 0.54798651f, 0.01537794f, -0.32451469f, -0.10633235f, 0.12189482f, 0.20237188f, 0.02034581f, 
    0.05340413f, 0.25538486f, 0.07723168f, 0.24191484f, 0.01437085f, 0.05673165f, -0.08676289f, 0.11819555f, 
    0.21720894f, 0.23493697f, 0.17931296f, 0.10378575f, -0.16427770f, -0.15688688f, -0.18574108f, -0.47941467f, 
    0.18318763f, -0.03859929f, -0.20626207f, -1.99819803f, -0.46161774f, -0.51849651f, -0.02808655f, 0.11925390f, 
    -0.13478574f, -0.07733754f, -0.13773592f, -0.21254693f, 0.47356257f, -0.38489336f, -0.41724396f, 0.14078242f, 
    0.07002677f, -0.30931881f, -0.08097104f, -0.24888207f, 0.12984535f, 0.42344159f, 0.45151603f, -0.07252388f, 
    -0.01637840f, 0.07946111f, 0.17054334f, 0.06185311f, -0.03501246f, -0.18031640f, 0.34680000f, -0.33586839f, 
    -0.13074780f, -0.11812197f, -0.01319959f, 0.08727390f, 0.21497771f, 0.11736687f, 0.15741807f, 0.09989601f, 
    -0.04891341f, -0.03446981f, 0.19934516f, 0.18007582f, -0.08521736f, 0.34428027f, 0.32753831f, -0.05479700f, 
    0.41404042f, -0.01027713f, -0.25328496f, 0.12807661f, -0.03697130f, -0.24736290f, 0.08699200f, 0.02409185f, 
    -0.22112292f, -0.07312530f, 0.09105463f, 0.10241087f, -0.20766476f, 0.03006716f, -0.47297585f, -0.08842110f, 
    -0.00592531f, 0.24395320f, 0.34446993f, -0.21330748f, 0.15308511f, 0.05070122f, 0.17624752f, 0.05839086f, 
    0.21069711f, -0.05409494f, 0.01092149f, 0.41927516f, 0.15596464f, 0.30419955f, -0.09930886f, -0.01094911f, 
    0.01116148f, 0.16563465f, 0.11947413f, -0.01445406f, 0.14145258f, -0.20481506f, -0.04869454f, 0.12012255f, 
    0.09358016f, -0.10050215f, -0.13016266f, 0.13157098f, 0.21728037f, -0.16163966f, -0.32995668f, -1.16341329f, 
    0.12730817f, 0.15912323f, -0.05928756f, 0.13759376f, -0.10032012f, -0.09045361f, 0.35548449f, -0.38347664f, 
    -0.78824157f, -0.13227634f, 0.04020507f, 0.18794301f, -0.10075783f, 0.00703772f, 0.25257191f, 0.03210940f, 
    0.09783668f, -0.15244062f, -0.01492253f, 0.08836623f, -0.19320975f, 0.21511646f, -0.01424510f, 0.14605294f, 
    0.01092042f, 0.76628107f, 0.72054195f, -0.03085122f, -0.02633296f, -0.08858987f, 0.02801337f, 0.03035767f, 
    0.21842530f, -0.14484684f, -0.00859016f, -0.11043454f, 0.04052683f, 0.06176509f, -0.38448116f, 0.31792805f, 
    0.17055924f, -0.04765331f, 0.15135936f, 0.18528326f, 0.34458780f, -0.63725215f, -0.36789161f, -0.30586624f, 
    0.12564811f, 0.16971990f, 0.29350203f, 0.61654568f, -0.26922247f, -0.99563885f, -0.09268037f, -0.12508233f, 
    -0.51961434f, 0.06548867f, 0.06262153f, -0.04525758f, -0.06827557f, 0.00433390f, -0.16445513f, -0.06737508f, 
    0.01320308f, 0.15997167f, 0.03266465f, 0.04483739f, 0.14397112f, 0.08346684f, 0.04435045f, -0.45251557f, 
    -0.03872150f, 0.05112967f, 0.11578126f, 0.18274993f, -0.01625907f, 0.01660373f, -0.28670278f, -0.14061843f, 
    -0.34411147f, 0.18254705f, -0.05853189f, 0.00562297f, 0.00012060f, 0.07892937f, 0.25765163f, 0.03320671f, 
    0.15934689f, -0.17725180f, 0.21708499f, 0.06364090f, -0.03187171f, 0.09274443f, 0.09944856f, 0.24332413f, 
    0.15009701f, 0.11001491f, -0.07483977f, -0.15175802f, 0.06648442f, -0.10745211f, 0.32178563f, -0.13731134f, 
    0.01971946f, 0.12480842f, -0.18284039f, -0.00858607f, -0.79798114f, -0.23194003f, -0.19258435f, 0.01017247f, 
    0.15115491f, 0.33310252f, 0.01879281f, -0.09700784f, 0.01841045f, 0.15858236f, -0.02940467f, -0.01331767f, 
    0.35945687f, 0.08283176f, -0.18459590f, -0.54144871f, -0.43927294f, 0.36859179f, 0.36170486f, -0.10365140f, 
    -0.05775867f, 0.09547737f, -0.46735448f, -0.21203162f, -0.03687325f, -0.05562229f, -0.46578348f, -0.06525537f, 
    -0.09220582f, -0.42486647f, 0.16841114f, -0.09830324f, 0.21965624f, -0.06661264f, -0.03225771f, -0.06685233f, 
    -0.04407754f, 0.11050770f, -0.10443932f, 0.07006503f, 0.22219007f, -0.18085068f, -0.41188890f, -0.14457582f, 
    0.52073961f, -0.15919921f, -0.01880937f, 0.11107760f, 0.03704984f, 0.11851516f, 0.10081568f, 0.00863740f, 
    -0.12250756f, -0.48100021f, 0.03705709f, -0.06488536f, -0.12411968f, -0.03308205f, -0.16684192f, 0.06225382f, 
    0.11388919f, -0.01151557f, 0.19612949f, 0.20613472f, -0.11469910f, -0.42508891f, 0.35554066f, -0.35878816f, 
    -0.03807506f, -0.04143527f, -0.30680391f, -0.15140171f, 0.26122159f, 0.08452448f, -0.00998119f, 0.37404075f, 
    0.38014767f, -0.02262091f, 0.19641005f, 0.06233652f, 0.24499916f, 0.03348327f, 0.08885949f, 0.02645077f, 
    -0.16402359f, -0.02264451f, -0.26431489f, -0.23330857f, 0.34391266f, 0.21000542f, -0.19627079f, -0.23739323f, 
    -0.01475670f, -0.11399997f, -0.51315778f, -0.11443499f, -0.04279998f, -0.04479951f, 0.30043650f, 0.37225229f, 
    0.26639879f, -0.04255546f, -0.26228756f, -0.19079684f, 0.10823503f, -0.13896403f, 0.26639181f, 0.13652889f, 
    0.12131438f, 0.05042384f, -0.01831600f, -0.12861468f, -0.54387039f, -0.34661120f, 0.15727001f, 0.16305131f, 
    0.40090910f, 0.03638938f, 0.33394915f, 0.03212095f, 0.31991076f, 0.18680130f, 0.05430973f, -0.19647028f, 
    -0.26343250f, 0.02454718f, 0.18791680f, 0.20447001f, 0.03965873f, 0.07704448f, -0.21639809f, 0.20512101f, 
    -0.10863166f, -0.07757920f, 0.13758406f, 0.07951021f, 0.27454576f, 0.09204878f, -0.12737198f, -0.06605627f, 
    -0.29396948f, 0.06131835f, 0.13218677f, -0.14561296f, 0.24770842f, 0.04264319f, 0.16363050f, 0.05920673f, 
    0.09617218f, 0.11423165f, 0.04957033f, 0.08607823f, -0.02816413f, -0.00341111f, 0.02628405f, -0.13249809f, 
    -0.02163632f, -0.10081609f, -0.06694984f, 0.07801308f, 0.03595719f, -0.10933033f, -0.25411218f, 0.21512748f, 
    0.01138202f, -0.05434635f, -0.28349507f, -0.04162747f, 0.06807487f, 0.27491003f, 0.01867480f, -0.31641251f, 
    0.32743055f, 0.22819152f, 0.01267275f, 0.07237685f, 0.01839586f, 0.11497857f, -0.20466892f, -0.19157994f, 
    0.24997161f, 0.07381135f, 0.19514009f, 0.06070758f, 0.03110925f, 0.00807203f, 0.10365054f, -0.18918635f, 
    0.25889984f, 0.01071794f, 0.08084624f, 0.07279059f, 0.02724374f, 0.09244038f, 0.09105740f, 0.26161432f, 
    0.40605587f, -0.05039007f, -0.16193534f, 0.27163386f, 0.20207250f, 0.21590099f, 0.29099104f, 0.20982082f, 
    -0.43033561f, 0.65629065f, 0.50694603f, -0.18329552f, 0.21121542f, -0.18520574f, 0.01447057f, 0.15925659f, 
    -0.12728499f, 0.01826741f, 0.43604031f, 0.22452527f, -0.10026971f, -0.05822822f, -0.12257138f, 0.01667220f, 
    0.00491453f, 0.19313210f, -0.59218764f, -0.27655828f, -0.51131886f, -0.03497837f, -0.03195218f, 0.09784261f, 
    0.00338004f, 0.05462881f, 0.21562269f, -0.68407333f, -1.63253784f, -1.09001708f, 0.00084344f, -0.50344968f, 
    -0.12740114f, 0.12426914f, 0.01772573f, 0.01778459f, -0.11968381f, -0.14674915f, -0.01523375f, 0.04365546f, 
    -0.10381845f, -0.11552586f, 0.03193537f, 0.05129224f, 0.10994849f, 0.36118361f, 0.10275596f, -0.71156275f, 
    -0.18477720f, 0.03207975f, -0.25902101f, 0.27878362f, -0.12213125f, -0.05304080f, 0.43904343f, -0.85991639f, 
    -0.27609578f, -0.08008716f, -0.33117464f, 0.02671841f, 0.04853752f, 0.00132078f, 0.00947862f, 0.08814793f, 
    0.29876664f, 0.10233350f, 0.09563419f, 0.15691274f, 0.18835598f, 0.27520391f, 0.32251021f, 0.17728543f, 
    0.19657344f, 0.11836880f, -0.14802527f, -0.19928327f, -0.13038322f, 0.09307615f, 0.05484827f, 0.05082376f, 
    0.17501183f, -0.71162093f, -0.21771500f, -0.77107066f, -0.15740918f, -0.33634707f, -0.00207842f, -0.06601469f, 
    0.02303710f, -0.18057452f, 0.36434689f, 0.00350686f, 0.27532566f, 0.00435234f, -0.02810470f, -0.06898377f, 
    0.21659718f, 0.01178020f, 0.16718526f, 0.08009698f, 0.09760840f, -0.03235574f, -0.04966073f, -0.10578766f, 
    0.04858347f, 0.17068726f, 0.08838259f, 0.13103871f, -0.24379551f, 0.42621908f, 0.27168149f, -0.21435276f, 
    0.25541642f, -0.09193078f, 0.10644502f, 0.20988233f, 0.06059929f, 0.02808229f, -0.33916056f, 0.05478124f, 
    0.35640386f, 0.39330822f, 0.33173320f, 0.00041264f, -0.06750173f, -0.04266302f, -0.37166703f, 0.27290341f, 
    0.64410740f, -0.38238192f, 0.05512179f, -0.03680024f, 0.08228345f, 0.13117193f, 0.26853067f, 0.61144990f, 
    0.00153297f, -0.09260412f, 0.01162013f, 0.05748143f, 0.02967107f, 0.09658471f, 0.11293195f, -0.02412578f, 
    -0.21917544f, -1.21580768f, -0.48916417f, 0.21697122f, 0.09937574f, 0.41968700f, 0.15306723f, -0.13587028f, 
    -0.19219670f, 0.15368728f, 0.42450121f, 0.14682811f, 0.03395626f, 0.23598696f, -0.18331003f, -0.01379635f, 
    0.01320947f, 0.24567649f, 0.18538176f, -0.16342831f, -0.38047454f, -0.27902257f, 0.09086707f, -0.12548804f, 
    0.16585550f, 0.07069021f, 0.06227419f, -0.48189184f, -0.62897366f, -0.02717722f, -0.06527016f, 0.03158893f, 
    -0.07198796f, 0.02370770f, -0.03231523f, 0.12076110f, -0.33379221f, 0.32460892f, -0.32708609f, -0.12570672f, 
    -0.01777813f, -0.07775539f, 0.18237877f, 0.29315954f, 0.13599135f, -0.10517289f, -0.09546901f, 0.26051423f, 
    -0.02655787f, -0.13436376f, 0.11396749f, 0.01883090f, -0.05614414f, -0.00482573f, 0.12829161f, 0.22049496f, 
    -0.10322084f, 0.07918541f, 0.23023286f, 0.08731268f, -0.01014995f, 0.16238222f, -0.07323727f, 0.29093045f, 
    0.12933293f, 0.04622698f, 0.28793550f, 0.12562773f, -0.08926049f, 0.05644232f, 0.07277230f, -0.03655114f, 
    -0.05488889f, -0.12296108f, -0.21578360f, -0.06852627f, -0.36615705f, -0.28123441f, 0.10593142f, -0.10270318f, 
    0.15924208f, 0.00339568f, -0.00561566f, -0.01466906f, -0.16215217f, 0.16629669f, -0.19295736f, 0.12332927f, 
    -0.20696983f, 0.25869551f, 0.13567019f, 0.47700775f, -0.07770410f, 0.08977276f, -0.05648769f, -0.04892292f, 
    -0.03470635f, 0.14687674f, 0.11770776f, 0.12155462f, 0.61957818f, -0.00919473f, -0.17794168f, -0.06847585f, 
    0.10027888f, 0.15312865f, 0.01595156f, 0.02669565f, -0.23798729f, 0.28152591f, -0.28935993f, -0.31586981f, 
    -0.10128512f, 0.17239179f, 0.14488250f, 0.07359192f, 0.13035916f, 0.78154284f, -0.58286017f, -0.65281069f, 
    -0.16472404f, -0.05221749f, 0.39314666f, 0.02554751f, -0.11102311f, -0.02960050f, -0.73251545f, -1.17077935f, 
    -0.50666368f, 0.04737630f, 0.09011613f, 0.09759165f, -0.19385660f, -0.12085705f, -0.00747337f, 0.39662641f, 
    0.05009276f, -0.38016450f, 0.17008954f, 0.22742696f, 0.05957256f, 0.18284655f, 0.16291475f, 0.15724036f, 
    0.44153282f, -0.25770286f, 0.09985198f, 0.25795770f, 0.13696708f, 0.10106051f, 0.06057128f, 0.03854782f, 
    0.35723767f, -0.67876327f, -0.18081386f, 0.12566690f, 0.20160747f, -0.16901346f, 0.08980552f, 0.08395349f, 
    0.24545656f, 0.27423775f, -0.11852975f, -0.27561477f, 0.10087059f, -0.12806994f, -0.09184725f, -0.01460482f, 
    -0.03238104f, 0.08907636f, 0.02549656f, 0.18583035f, 0.09906064f, -0.07237183f, -0.07707243f, -0.41505092f, 
    0.22540787f, -0.02386480f, -0.06298983f, 0.40143380f, 0.08387068f, -0.26118720f, 0.03277194f, -0.13999055f, 
    0.10815502f, -0.12628888f, -0.00315700f, -0.01071338f, -0.08597904f, 0.31544474f, -0.47223282f, -0.17693835f, 
    -0.08932335f, 0.05450153f, -0.06879681f, 0.02176036f, 0.20642290f, 0.34508631f, -1.05969608f, -0.26955014f, 
    -0.02217674f, -0.20959604f, 0.00384133f, -0.19947459f, -0.04006195f, -0.21004558f, -0.00681407f, -0.42290851f, 
    0.36717388f, -0.46682918f, -0.10322904f, 0.03796287f, -0.11239596f, 0.31096706f, 0.23956601f, -0.10467207f, 
    0.28755099f, -0.16423480f, -0.14089046f, -0.02937958f, -0.11714485f, 0.07597890f, 0.27952278f, 0.05836998f, 
    -0.15826914f, -0.27319258f, -0.47116914f, 0.09280725f, 0.16701002f, -0.00789042f, 0.00419901f, -0.12074979f, 
    -0.17403361f, -0.20538831f, -0.82745665f, 0.05076806f, -0.05886330f, -0.17244440f, -0.21837056f, 0.30725148f, 
    -0.12415901f, 0.09632926f, 0.30412135f, -0.82710856f, 0.02705406f, -0.02895552f, -0.22276472f, -0.20641685f, 
    0.03400678f, 0.10633370f, 0.24445580f, 0.21836768f, 0.75075698f, 0.15617105f, -0.25590533f, -0.33575535f, 
    -0.25149751f, -0.06935943f, 0.24546300f, 0.12754001f, -0.17088392f, 0.45562816f, 0.09988955f, -0.40122512f, 
    0.21626036f, 0.11989737f, 0.04430421f, 0.17024344f, -0.09634529f, -0.21542162f, 0.43140328f, 0.66487372f, 
    0.33850443f, 0.00482041f, 0.14289121f, -0.00735064f, 0.24909157f, -0.02696126f, -0.28354082f, -0.43180066f, 
    -0.60250175f, -0.36111784f, 0.08941947f, -0.09966911f, -0.19122614f, 0.07557019f, 0.19293335f, -0.00314162f, 
    -0.12330335f, -0.22718535f, -0.13786326f, 0.08192480f, 0.07799070f, 0.01178670f, 0.21927057f, 0.18877773f, 
    0.00789874f, 0.31274730f, -0.16273841f, 0.25903943f, -0.13442089f, 0.18008982f, 0.24602260f, 0.16299865f, 
    0.01997398f, -0.01085566f, -0.15586045f, -0.15047881f, -0.17288189f, 0.16039498f, 0.08587472f, 0.04552528f, 
    -0.03183074f, 0.03159118f, 0.07143646f, -0.27404404f, -0.41933709f, 0.30342281f, 0.23021306f, -0.28409937f, 
    0.22591364f, 0.43688089f, 0.19243410f, 0.28446034f, -0.02061516f, 0.06119568f, -0.09922919f, 0.09289679f, 
    -0.03144076f, 0.02944888f, 0.11814696f, 0.21349390f, 0.06573487f, 0.25598922f, 0.04414955f, -0.17128316f, 
    0.15748230f, 0.06289688f, 0.24429390f, 0.22038649f, 0.39689708f, 0.16304028f, 0.28771320f, -0.43422404f, 
    -0.22222945f, -0.08027836f, 0.02805095f, -0.13280843f, -0.28319860f, -0.21527585f, -0.37602788f, 0.13890225f, 
    0.15165791f, 0.44758305f, 0.06744552f, 0.16996312f, 0.15867709f, 0.00998269f, 0.13284516f, -0.05109314f, 
    0.10532402f, 0.11553509f, 0.24782971f, 0.15444534f, 0.25553790f, 0.01060194f, -0.03882298f, 0.22188362f, 
    -0.03733540f, 0.14163171f, -0.10561135f, -0.04186853f, 0.12922019f, -0.19589786f, -0.05839044f, -0.20796229f, 
    -0.33043218f, -0.44226530f, 0.15497683f, 0.21603449f, 0.28922260f, 0.05815225f, 0.01960848f, 0.06632258f, 
    0.02220507f, 0.12546836f, 0.26338881f, 0.13134031f, -0.16627918f, 0.07578020f, 0.19635653f, 0.09501364f, 
    0.04358099f, 0.10695387f, 0.13841005f, 0.05057627f, -0.45370767f, -0.46010378f, 0.09081895f, -0.06693322f, 
    0.16270021f, 0.09324300f, -0.03110244f, -0.02979233f, -0.48174784f, 0.15133977f, 0.24627057f, 0.23123203f, 
    0.05857152f, -0.09369041f, -0.16182669f, -0.02704630f, 0.17717914f, 0.02589272f, -0.50840801f, -0.13511927f, 
    -0.18207861f, -0.00727094f, -0.30155647f, -0.29655313f, -0.51168060f, -0.42349535f, -0.21272734f, 0.11697880f, 
    -0.00113746f, 0.41794541f, 0.08907084f, 0.12308726f, 0.20591927f, -0.02502657f, 0.00307854f, 0.18024677f, 
    -0.07929163f, 0.12387826f, 0.12286224f, 0.25606763f, -0.13890840f, 0.21669742f, 0.11633847f, -0.12451715f, 
    -0.13520624f, 0.42749399f, -0.25736213f, -0.67456746f, 0.26853627f, -0.09296897f, 0.14372316f, 0.07230688f, 
    -0.08804941f, -0.02854092f, -0.39400855f, -0.66364014f, -0.75016004f, 0.03003868f, -0.24995729f, 0.35198328f, 
    0.10189902f, 0.01601025f, 0.31021038f, -0.38001180f, 0.39606053f, -0.16975667f, -0.32606384f, -0.28516111f, 
    -0.18394154f, 0.07917382f, 0.18337896f, -0.04027333f, 0.19332764f, 0.41261157f, 0.19641228f, 0.05651058f, 
    0.02489427f, 0.11725646f, 0.01615537f, -0.15608718f, -0.13915372f, 0.23562993f, 0.52323800f, -0.17708535f, 
    -0.11331088f, 0.12589280f, -0.35585031f, -0.19870158f, -0.07164232f, -0.13878372f, 0.41756207f, 0.11277717f, 
    -0.71682334f, 0.28368837f, -0.33793393f, 0.22194411f, 0.27596393f, -0.14815523f, -0.15970618f, -0.04694602f, 
    -0.62332326f, -0.13787843f, 0.16459641f, 0.17500858f, -0.00167689f, 0.21493125f, 0.01389481f, -0.19921978f, 
    0.21391323f, 0.23111296f, -0.34931064f, 0.00161311f, -0.11715506f, 0.28768572f, 0.03372061f, 0.15555085f, 
    -0.02718455f, -0.28566593f, 0.33872941f, -0.07240740f, -0.02382823f, -0.19315578f, -0.06078275f, 0.10406896f, 
    -0.07501132f, 0.09783893f, -0.11841217f, -0.73544210f, -0.19313875f, -0.14703821f, 0.02236024f, -0.16470623f, 
    -0.17281641f, -0.11199868f, 0.03614394f, -0.03118860f, -0.52702117f, -0.48298284f, -0.18305361f, 0.16944405f, 
    -0.08794995f, 0.09020723f, 0.05277094f, -0.28867882f, 0.29081345f, 0.12365537f, 0.39449388f, -0.21040741f, 
    0.19824252f, 0.06421281f, 0.17830072f, 0.09147028f, 0.18466105f, 0.28845260f, 0.07330158f, 0.35202226f, 
    0.16756414f, -0.18603681f, 0.29874367f, -0.07250374f, -0.16664824f, -0.26831082f, 0.20005456f, -0.32885599f, 
    -0.19442807f, 0.37522265f, -0.03680924f, 0.37339836f, 0.18297026f, 0.24476831f, 0.13370517f, 0.68712616f, 
    -0.76419932f, -0.03432369f, 0.34280923f, -0.25153762f, -0.07115972f, -0.03385818f, 0.01537903f, 0.01316586f, 
    -0.02877347f, -0.07868806f, -0.06747294f, 0.02944216f, -0.07686369f, -0.08320343f, 0.00776106f, -0.00645851f, 
    -0.06678498f, -0.04138915f, -0.03298226f, 0.07028973f, 0.00529208f, 0.02825218f, -0.07354385f, -0.05564689f, 
    0.00177242f, 0.02027899f, -0.05876169f, -0.03639910f, -0.03601877f, -0.04734245f, 0.03794286f, 0.00645792f, 
    -0.06440888f, 0.05203261f, 0.00431192f, 0.04895575f, 0.03807472f, 0.05464590f, 0.04292703f, 0.02433360f, 
    -0.05211902f, -0.00509875f, -0.07131937f, 0.06841788f, -0.02143820f, 0.04470565f, -0.08613303f, 0.03697866f, 
    -0.04540136f, -0.03998058f, 0.02082903f, 0.03494024f, 0.02167176f, 0.03160878f, 0.02635537f, -0.01580309f, 
    -0.06901300f, 0.02754484f, 0.06700821f, -0.00241547f, -0.01876984f, -0.08614672f, -0.06266708f, -0.06982783f, 
    0.00136588f, 0.00582249f, -0.03720468f, -0.01625701f, -0.00646633f, 0.02092081f, 0.01710250f, 0.07121684f, 
    0.03684219f, -0.01103975f, -0.08829590f, -0.03423326f, -0.07499582f, -0.05563029f, 0.07400835f, 0.03506339f, 
    0.07056817f, 0.00085955f, -0.06244420f, -0.05575553f, 0.02430649f, 0.02542837f, 0.05588071f, -0.01148863f, 
    -0.03452502f, -0.01094656f, -0.07263212f, 0.02129422f, 0.03513296f, 0.02367896f, -0.08318909f, -0.04470918f, 
    -0.02277040f, -0.04766147f, 0.03983864f, 0.05748062f, -0.00684929f, 0.04431450f, 0.01515219f, -0.03857663f, 
    -0.08389265f, 0.03997632f, -0.07881369f, 0.05819200f, -0.04969548f, -0.01366667f, -0.05874332f, 0.01125491f, 
    0.02089660f, 0.03312892f, 0.04391580f, -0.03132709f, -0.04193164f, 0.04985295f, -0.07542485f, 0.04084336f, 
    0.06738932f, -0.04228881f, 0.01823410f, -0.09013277f, -0.09141786f, 0.04330923f, -0.03891698f, 0.01606756f, 
    -0.07907105f, -0.07186944f, 0.03724267f, -0.07542980f, -0.06112555f, -0.02627437f, -0.01706353f, -0.08058790f, 
    -0.01492894f, 0.01138530f, -0.03805509f, -0.05520316f, -0.01792963f, -0.01071586f, -0.06326971f, -0.06725321f, 
    0.07174637f, -0.05822258f, -0.05708697f, -0.06974585f, -0.08838365f, -0.03805013f, -0.01219567f, 0.05707482f, 
    0.65281254f, 0.36962187f, -0.06899987f, -0.10463165f, 0.00025904f, -0.17537211f, -0.00476796f, 0.26062870f, 
    0.12975374f, 0.17362292f, -0.07649783f, 0.07085872f, 0.08901244f, -0.11303812f, -0.06368254f, -0.05982490f, 
    0.12864621f, -0.08748520f, 0.25055611f, 0.02547569f, 0.16402268f, -0.29788888f, -0.05794481f, 0.24582306f, 
    -0.02688385f, 0.14640632f, 0.06508712f, -0.09209238f, 0.49456805f, 0.52330101f, 0.01849865f, 0.28018039f, 
    0.64559627f, 0.15930209f, 0.49345210f, -0.01445442f, 0.19361109f, 0.83150196f, -0.18468599f, 0.07194173f, 
    0.09148966f, 0.12800248f, -0.08778470f, -0.19986568f, -0.06536999f, -0.13759804f, -0.20399195f, -0.07689764f, 
    0.12347549f, -0.09442216f, -0.11626334f, 0.03282311f, 0.18008709f, 0.36894599f, 0.19327427f, 0.39571655f, 
    0.40267217f, 0.10037038f, -0.03323021f, 0.39049420f, -0.34693110f, 0.20939161f, -0.36738873f, -0.09465557f, 
    -0.38587901f, 0.02036712f, -0.12452206f, 0.13099147f, -0.02185732f, -0.14914794f, -0.18677334f, 0.08387860f, 
    0.13283904f, -0.08385638f, 0.12667951f, -0.22468475f, -0.02797857f, -0.31208768f, 0.04966567f, 0.04058362f, 
    0.31173739f, -0.19036686f, -0.13662186f, 0.05801597f, 0.33306029f, 0.39271951f, 0.07377177f, -0.20076546f, 
    -0.15745717f, -0.85195768f, -0.39928573f, -0.12499200f, 0.06174256f, 0.11691836f, 0.14782465f, -0.01220137f, 
    -0.13960898f, 0.23073284f, 0.24226941f, 0.04137353f, -0.48246914f, -0.11541168f, -0.04913782f, -0.11366910f, 
    0.06592257f, 0.12291264f, 0.34719905f, 0.17584500f, 0.03108176f, -0.27737185f, -0.60925609f, 0.14034207f, 
    -0.13217621f, -0.03791044f, -0.37940243f, -0.28225866f, -0.12328150f, 0.08099931f, 0.07040308f, -0.05050566f, 
    -0.01361821f, -0.12805077f, 0.11259431f, -0.06202373f, 0.02137758f, -0.06353600f, -0.21194817f, -0.16725069f, 
    -0.40820357f, 0.11051960f, 0.04732182f, -0.22952366f, -0.27009761f, -0.17563286f, -0.40938631f, -0.13776512f, 
    -0.14199485f, 0.23997834f, 0.15261453f, -0.32446799f, 0.11990666f, -0.12022178f, 0.18668005f, -0.05787989f, 
    -0.07449085f, -0.07364413f, -0.01988313f, -0.08775578f, -0.02321457f, -0.07236686f, 0.04828547f, 0.02316716f, 
    0.02868214f, -0.02043256f, 0.01056117f, -0.01183657f, 0.06011546f, 0.00843482f, 0.01401574f, 0.02413329f, 
    -0.02429489f, 0.01479907f, 0.02596798f, -0.00027526f, 0.01749778f, -0.03390907f, 0.04690095f, -0.03230078f, 
    -0.00825353f, 0.06291299f, 0.07037231f, 0.05385830f, -0.01544737f, -0.02173620f, -0.09168144f, -0.00779223f, 
    -0.08222742f, 0.00642357f, 0.06638779f, -0.01935057f, 0.07380565f, 0.03307929f, -0.05772061f, 0.00456107f, 
    -0.03604304f, 0.03723292f, -0.06265210f, -0.00015487f, 0.05914241f, -0.02171030f, -0.06496044f, 0.02831679f, 
    -0.05098856f, -0.06726884f, -0.06313783f, -0.03940589f, -0.08678153f, 0.01270043f, 0.02068426f, 0.04829920f, 
    -0.07517118f, 0.04969487f, -0.00738251f, -0.03504797f, 0.01932809f, -0.01905222f, -0.01006087f, -0.07494878f, 
    -0.02428553f, 0.05196486f, 0.05817836f, 0.02376478f, -0.01319076f, 0.00253957f, -0.03849512f, -0.08208800f, 
    0.01731397f, -0.03011072f, 0.04085126f, 0.02062287f, 0.02647953f, -0.05782357f, -0.06373140f, -0.04333238f, 
    -0.06458367f, -0.08221181f, 0.02158886f, 0.05324771f, -0.08658125f, -0.02797853f, 0.03779092f, -0.01315773f, 
    -0.05484635f, -0.06209326f, -0.08695602f, -0.08447225f, 0.00074935f, 0.03984851f, -0.01795948f, -0.02473350f, 
    -0.06928105f, -0.08973073f, -0.07868437f, -0.03427896f, -0.07718182f, 0.06364531f, -0.08157547f, 0.00039320f, 
    -0.04233908f, -0.03156995f, -0.00667356f, -0.08502977f, -0.04224623f, -0.07726087f, 0.05160186f, -0.08969945f, 
    -0.04940398f, 0.05012875f, -0.07447555f, -0.05084930f, -0.01465126f, -0.06031728f, -0.05794394f, 0.01063917f, 
    0.06779033f, 0.00606531f, 0.05989282f, 0.02327202f, -0.07982891f, -0.07166349f, 0.02782779f, 0.00827871f, 
    0.03009371f, -0.05225014f, 0.00640240f, 0.03354953f, -0.08938685f, -0.07028942f, 0.02841260f, -0.05487711f, 
    -0.04450604f, -0.03632215f, -0.05580691f, -0.05741571f, 0.05586175f, 0.07568828f, -0.08771431f, -0.02970469f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.19619453f, -0.06601574f, 0.36385521f, -0.05246596f, 0.48666176f, 0.20870352f, 0.48848295f, -0.20352568f, 
    0.63773042f, 0.03930681f, 0.04501662f, 0.26971760f, -0.10161425f, -0.00206109f, -0.23353764f, 0.04956596f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.11085750f, 0.05589234f, -0.83572209f, 0.10518923f, -0.49421284f, 0.23867634f, 0.26894924f, 0.11498135f, 
    -0.50868285f, -0.37843487f, 0.54048455f, -0.36670628f, 0.66518563f, -0.17941771f, 0.49365649f, -0.18120678f, 
    0.13460436f, 0.18707371f, -0.33788148f, 0.05031389f, -0.06863160f, 0.31987146f, -0.42582163f, -0.47267532f, 
    0.11017787f, 0.08186559f, 0.68794584f, 0.30535609f, 0.13717635f, -0.02213013f, -0.00552181f, 0.12665592f, 
    -1.28378499f, 0.18729512f, -0.12655869f, -0.04879791f, -0.37050205f, -0.54081774f, 0.57150543f, 0.33609387f, 
    0.67896724f, -0.34729090f, 0.32302862f, 0.03627753f, -0.33941093f, 0.09329310f, -0.21782270f, 0.00753588f, 
    -0.67532599f, -0.23766679f, 0.30700859f, -0.08541355f, -0.01966049f, -0.18857484f, 0.33870858f, 0.38359547f, 
    -1.14956927f, -0.18000212f, 0.63726360f, -0.32458413f, 0.00123978f, -0.03964908f, -0.26662222f, -0.13565521f, 
    1.00030625f, 0.15408699f, 0.17691210f, 0.16570428f, -0.17079715f, 0.14407337f, 0.18637696f, 0.12650919f, 
    -1.04890180f, -0.08981122f, -0.18044737f, -0.24486989f, -0.05102479f, 0.00103091f, 0.02311792f, -0.20347427f, 
    0.20703305f, -0.12206849f, 0.17192480f, 0.09786607f, -0.06465171f, -0.18716291f, -0.41544259f, -0.30639327f, 
    -0.19879188f, -0.32666939f, -0.24911965f, 0.31440884f, 0.39933386f, -0.12930730f, 0.26302013f, 0.04366192f, 
    -0.78301990f, -0.06791326f, -0.06413338f, -0.18592505f, -0.02985333f, 0.69478500f, 0.30034342f, -0.12819305f, 
    1.04945576f, -0.50730121f, -1.00054812f, -0.41580385f, -0.82146168f, 0.11671965f, -0.42914253f, -0.08682194f, 
    -0.49853972f, 0.10315198f, -0.19844292f, 0.12270356f, 0.34014744f, 0.08919495f, -0.16508090f, -0.03538808f, 
    -0.78534818f, 0.74791753f, -0.39837733f, -0.40324345f, 0.24701905f, -0.21024497f, -0.01645980f, -0.10763066f, 
    -1.14214206f, 0.03388637f, 0.25506744f, 0.13104180f, 0.19621615f, -0.71529794f, -0.04758009f, -0.84245074f, 
    -0.07515366f, 0.65155828f, 0.36543602f, 0.22508663f, -0.63536006f, -0.05532366f, 0.23782405f, -0.05309921f, 
    0.40077484f, -0.02384668f, 0.05612556f, 0.11005693f, 0.41291893f, -0.00261662f, 0.69247741f, 0.22707832f, 
    -0.22845340f, -0.21252382f, -0.72197104f, -0.27964988f, -0.12743340f, -0.12273181f, -0.72985435f, -0.23915103f, 
    0.01947379f, 0.23236689f, -0.22843874f, 0.11110936f, 0.81434286f, -0.65302968f, -0.44025290f, -0.15870912f, 
    -0.73850536f, -1.00425541f, -0.05686057f, -0.06279325f, -0.92283177f, 0.13414527f, 0.54975945f, 0.13047218f, 
    -0.35590714f, -0.00163717f, 0.19925728f, 0.20754744f, 0.06681497f, -0.24308123f, -1.01050365f, 0.15185003f, 
    0.70283061f, -0.19131349f, -0.52401316f, 0.26608413f, -0.90347213f, -0.12009166f, -0.41071799f, 0.14916025f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.59441340f, 0.21566764f, -0.14360175f, -0.01320871f, -0.04656078f, -0.18526171f, -0.15778713f, -0.60732019f, 
    0.09493718f, 0.44258833f, 0.06813489f, 0.12659708f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
