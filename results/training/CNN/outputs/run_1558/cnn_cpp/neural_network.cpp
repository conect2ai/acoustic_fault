#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.94072676f, 0.75642145f, 0.17368247f, -0.48477611f, -0.36873049f, 0.49325669f, 0.25441679f, -0.09311369f, 
    0.19367757f, -0.30319488f, 0.09613207f, 0.36174491f, 0.31289873f, -0.00606063f, 0.53242677f, -0.13513957f, 
    0.32677492f, -0.48951882f, 0.27911231f, -0.39130938f, 0.51668829f, 0.30451238f, -0.00704241f, 0.49707517f, 
    0.32545164f, -0.18139683f, -0.63738596f, 0.08693717f, -0.17768404f, 0.05420863f, 0.11496234f, 0.63795382f, 
    0.09362888f, 0.45797619f, -0.66950250f, 0.10826746f, -0.41655451f, 0.52776235f, -0.25440508f, 0.07252831f, 
    0.24160334f, 0.40053970f, 0.15610315f, -0.29364821f, -0.40046388f, 0.95452267f, 1.07232988f, -0.28334886f, 
    -0.63000643f, -0.19114216f, -0.15945941f, 0.04901438f, -0.14322799f, -0.07293051f, 0.25012031f, -0.15928929f, 
    0.15894359f, -0.77630860f, -0.10193433f, 0.86807179f, -0.11932330f, 0.23290367f, -0.11399092f, 0.54341036f, 
    0.32187599f, 0.48588595f, 0.33436701f, -0.23808552f, -0.09532554f, -0.01774251f, -0.00026755f, 0.17157166f, 
    -0.30978113f, 0.02263076f, 0.06905493f, -0.09818856f, -0.42473966f, -0.65895814f, 0.52771091f, 0.01479644f, 
    0.44194454f, -0.18003471f, 0.76993173f, -0.56529748f, 0.10877279f, 0.31848425f, 0.06757999f, 0.25398675f, 
    -0.06238704f, 0.32381389f, 0.10794738f, 0.76146936f, -0.61811435f, -0.32380250f, -0.12340281f, 0.04232994f, 
    0.17507324f, 0.31819662f, 0.33942625f, -0.54739195f, -0.39043999f, -0.37347582f, -0.01145628f, 0.02752098f, 
    -0.05783046f, -0.00854258f, -0.26357517f, -0.53886384f, -0.71385401f, -0.43505335f, -0.53712797f, 0.49853733f, 
    0.51831180f, 0.72078061f, -0.25325143f, 0.01203058f, 0.25562569f, 0.30223924f, 0.00956983f, 0.15547355f, 
    0.30942035f, -0.24093810f, 0.30081534f, -0.20930952f, -0.13383216f, 0.38029966f, 0.05914869f, 0.32376075f, 
    0.44581628f, -0.18963408f, 0.26150194f, -0.19201426f, -0.15559031f, -0.45974112f, -0.11227382f, 0.46071658f, 
    0.33146235f, -0.42190909f, 0.59051746f, -0.49735415f, -0.40866020f, 0.39821309f, 0.34777427f, -0.33828634f, 
    0.34022015f, 0.11359474f, 0.53965437f, -0.21584362f, -0.40091652f, -0.69853669f, 0.18968213f, -0.06304672f, 
    0.66849351f, 0.09180667f, 0.70259643f, -0.40759766f, 0.08332322f, -0.24591030f, -0.13386114f, -0.08573051f, 
    0.28177434f, 0.23328838f, 0.04815614f, -0.10166199f, 0.36235148f, -0.10488720f, -0.38240817f, 0.41248924f, 
    0.70787460f, -0.50695592f, -0.18209769f, 0.60702741f, -0.07177016f, 0.66586185f, -0.62721670f, -0.22606444f, 
    -0.15308084f, 0.33141211f, -0.01743889f, -0.37689808f, -1.05617464f, 1.08056271f, -0.70562279f, 0.47633255f, 
    0.10255340f, -0.51053202f, -0.16668046f, -0.09769751f, 0.07743725f, -0.24308661f, -0.07340864f, -0.29587546f, 
    -0.53221589f, -0.61126161f, -0.69183725f, 0.48009801f, 0.28261155f, 0.12778151f, 0.20607084f, -0.13785695f, 
    -0.54006159f, -0.27049190f, -0.02615682f, 0.55701780f, -0.32977241f, -0.08535136f, -0.25274393f, 0.01459264f, 
    -0.09578766f, -0.33108211f, -0.52789974f, -0.46771833f, -0.20056565f, -0.33723250f, -0.56832778f, 0.47783497f, 
    -0.24738888f, 0.43095452f, 0.09185857f, 0.42702237f, 0.49538916f, 0.38933247f, 0.18768878f, 0.37602267f, 
    0.15530451f, -0.61274314f, -0.32196462f, -0.34966844f, 0.71250796f, -0.10031878f, -0.55043125f, 0.09630954f, 
    0.19534762f, 0.30747214f, -0.38321316f, -0.41154772f, -0.07999434f, -0.32055789f, 0.18834732f, -0.59429640f, 
    0.09595276f, -0.21512701f, 0.28565180f, -0.95258480f, -0.23050249f, 0.61151296f, 0.48381689f, 0.20287947f, 
    0.20757265f, 0.16711451f, 0.18785839f, 0.26192066f, 0.17749637f, 0.42890280f, -0.81762975f, -0.08117003f, 
    0.11970890f, 0.34352636f, -0.28567642f, -0.46109077f, 0.00777416f, 0.89443332f, 0.04598852f, -0.26559886f, 
    -0.13024110f, 0.37520409f, 0.19750690f, -0.24577378f, 0.67118186f, -0.54435867f, -0.76165843f, -0.35984066f, 
    0.08669711f, 0.98056525f, -0.35093889f, -0.38273054f, -0.25541237f, -0.18708165f, -0.48155585f, 0.51811188f, 
    -0.91112959f, -0.66373438f, 0.68817472f, 0.23702306f, 0.32559004f, 0.14021388f, -0.23120245f, -0.35096735f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.15867208f, 0.25466338f, -0.36818621f, -0.30464020f, 0.04215150f, 0.01310487f, 0.02034285f, 0.22611201f, 
    0.33106411f, -0.25534409f, -0.19071452f, -0.06660245f, -0.13847791f, 0.26207051f, 0.20234469f, 0.25077257f, 
    -0.14750470f, 0.11279795f, -0.11849825f, -0.06744906f, -0.18370710f, -0.24338029f, 0.10497966f, -0.30738348f, 
    -0.48598433f, 0.12760349f, -0.25530300f, -0.35446540f, -0.18498191f, -0.32708880f, -0.20247000f, 0.13908593f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.74468720f, 0.18048976f, 0.08315048f, 0.01199287f, -0.02181758f, -0.13778074f, 0.03763277f, 0.01092091f, 
    -0.03320087f, 0.09400770f, 0.13261704f, 0.18226059f, -0.07581785f, 0.02162991f, -0.20745777f, -0.02171177f, 
    -0.11793273f, -0.07455369f, 0.16633494f, 0.11245547f, 0.08464506f, 0.04616553f, -0.00580134f, -0.09046271f, 
    -0.03919947f, -0.19726101f, -0.10492512f, 0.00490491f, 0.13953905f, 0.04709903f, -0.18133761f, -0.01074019f, 
    -0.19194722f, -0.10114816f, -0.01673299f, -0.11143648f, 0.05442812f, 0.22191972f, 0.07330310f, 0.03981036f, 
    -0.12375319f, -0.14415814f, 0.03171041f, -0.14399920f, 0.03388746f, -0.32596886f, -0.09241807f, -0.04162840f, 
    -0.02626761f, -0.00349574f, 0.05178474f, 0.17159021f, 0.05952717f, 0.07892048f, 0.16979907f, -0.05476162f, 
    -0.18238057f, -0.02525188f, 0.05174531f, 0.24793592f, -0.10501487f, 0.06085270f, 0.00873541f, 0.01034226f, 
    0.05370372f, 0.09871358f, 0.02028461f, 0.02809837f, -0.09878235f, -0.00309440f, -0.09392584f, 0.02856293f, 
    -0.00648800f, -0.40053988f, 0.13777053f, 0.02268458f, 0.03805877f, 0.04817177f, -0.02989049f, -0.02313405f, 
    0.00071692f, 0.24982408f, -0.04018456f, -0.08485278f, -0.03856297f, -0.25002456f, 0.00629692f, 0.14904183f, 
    -0.03995913f, 0.05303983f, 0.01754387f, -0.08472117f, -0.08763323f, 0.10909452f, -0.05326063f, 0.00657090f, 
    0.00718819f, -0.18205813f, 0.15746602f, 0.31649509f, -0.00341961f, -0.69600987f, -0.14946747f, -0.18706068f, 
    -0.21494766f, 0.05610108f, 0.14539599f, 0.00916422f, 0.26202631f, -0.22385429f, -0.51450330f, -0.09570701f, 
    -0.01746622f, -0.06571908f, 0.10723872f, 0.03796301f, -0.08107443f, 0.05808490f, 0.10678072f, 0.02157764f, 
    0.00910059f, -0.06889857f, -0.09616929f, -0.12585260f, -0.04175391f, 0.04498233f, -0.03418640f, 0.13843337f, 
    0.05491478f, 0.03989724f, 0.00853126f, -0.06480675f, -0.00109431f, 0.06083632f, -0.10208595f, -0.03285773f, 
    -0.12275801f, 0.17878179f, -0.01322830f, 0.10099735f, -0.00116164f, 0.02160900f, 0.06621973f, 0.11408155f, 
    -0.32487610f, -0.13900040f, 0.30350074f, 0.03868100f, 0.13165906f, -0.00369394f, -0.00665690f, 0.18429703f, 
    0.14607723f, -0.12100807f, -0.05356039f, 0.09479821f, -0.03632498f, -0.00656907f, 0.07911073f, -0.10689703f, 
    -0.00627770f, 0.10062768f, 0.07789447f, 0.09262081f, 0.08305402f, -0.08159718f, 0.07703366f, -0.07133705f, 
    -0.11572696f, 0.20491542f, -0.01869297f, -0.03237800f, -0.44307205f, -0.07502128f, 0.05016834f, 0.04380981f, 
    0.08248548f, 0.09306586f, 0.10916847f, 0.02838553f, 0.60229230f, -0.06308370f, -0.13644741f, -0.20163019f, 
    -0.01704357f, 0.05880589f, 0.12145174f, -0.06088676f, -0.06885443f, -0.10658566f, -0.37078935f, 0.03383414f, 
    0.04807876f, 0.05612355f, 0.05331035f, 0.05894148f, -0.02286322f, -0.00098464f, -0.15808809f, -0.17561796f, 
    -0.31952038f, -0.04789501f, 0.00377254f, 0.08212627f, -0.09869637f, -0.00926794f, 0.02425421f, -0.05114178f, 
    -0.49223405f, -0.15403670f, 0.03018248f, 0.10498092f, -0.11395124f, 0.00612163f, 0.05961524f, -0.10651683f, 
    0.21910150f, 0.18123411f, 0.07716522f, -0.07833482f, -0.26942024f, -0.21438225f, 0.07942927f, -0.19149435f, 
    -0.05399478f, 0.49226546f, 0.03639263f, -0.12394917f, -0.26933405f, -0.02548283f, 0.04356162f, 0.10189268f, 
    0.08342907f, -0.02362517f, 0.29864007f, 0.37842059f, -0.55214751f, -0.13102746f, -0.02978199f, 0.05785441f, 
    0.05404988f, -0.02024517f, -0.09379973f, 0.30812660f, 0.25577509f, -0.03036258f, -0.17952539f, -0.09483504f, 
    0.05243770f, 0.18626423f, -0.05239442f, -0.02554027f, -0.24765609f, 0.04196967f, -0.02455363f, 0.08254278f, 
    0.02454892f, -0.01047761f, -0.15286176f, -0.04718539f, 0.08881933f, 0.12887403f, 0.01369876f, 0.21683694f, 
    -0.08499630f, -0.18867552f, 0.02457527f, 0.21728371f, -0.09441093f, 0.03343001f, -0.20949475f, -0.48549607f, 
    0.36890846f, -0.08750056f, -0.01273682f, -0.17474917f, -0.01663267f, 0.04898714f, 0.05368045f, 0.24560021f, 
    -0.37573352f, -0.44361636f, -0.26546097f, 0.17256472f, 0.15799068f, -0.03628537f, 0.02405746f, -0.08579734f, 
    -0.01861806f, 0.25863141f, 0.35083750f, -0.35703960f, 0.15831156f, -0.08201718f, -0.01876879f, -0.10869806f, 
    0.07064953f, 0.15920340f, 0.03022516f, -0.04073172f, -0.05426923f, -0.26291814f, -0.09716269f, 0.08490895f, 
    -0.07609587f, 0.06917387f, -0.00600371f, -0.05762073f, -0.11219562f, -0.00870230f, -0.05659448f, -0.22028492f, 
    0.18902349f, 0.02910365f, 0.10943574f, 0.03972824f, 0.03192407f, 0.09367783f, -0.12013521f, -0.31527120f, 
    -0.09465947f, -0.05373214f, 0.06537347f, 0.04997121f, 0.18283489f, -0.06264710f, -0.06098752f, -0.10865119f, 
    -0.03130614f, 0.01616227f, 0.08653283f, -0.09960735f, 0.12616336f, 0.02053672f, -0.08169922f, 0.13368034f, 
    0.16114236f, 0.02523499f, -0.07445540f, 0.16538855f, 0.05619441f, -0.11451146f, -0.35284629f, -0.15356518f, 
    -0.00252942f, -0.06149856f, -0.17238849f, -0.18880656f, 0.18563466f, 0.01813795f, -0.06021352f, -0.04100521f, 
    -0.13363941f, 0.15145467f, 0.11733453f, -0.02045057f, -0.02613974f, -0.12637907f, 0.03383303f, -0.07463667f, 
    0.21804722f, 0.19911881f, 0.01572119f, -0.07411219f, -0.15012810f, 0.03037675f, -0.02496637f, 0.06040293f, 
    -0.04651163f, 0.03704072f, -0.06827925f, -0.01337673f, 0.13299562f, -0.12916887f, -0.17085426f, -0.09601306f, 
    0.06063519f, 0.13121258f, 0.12011873f, 0.00918173f, -0.00371029f, 0.06389145f, 0.21954055f, -0.02860814f, 
    -0.10773405f, 0.06594253f, -0.04025849f, 0.07801829f, -0.12136731f, -0.08080251f, -0.03379011f, -0.04634391f, 
    0.07478146f, -0.00311646f, 0.04289805f, -0.01335904f, 0.19008839f, -0.21538605f, -0.15332650f, -0.02321569f, 
    -0.05880287f, -0.00277984f, 0.06309050f, 0.08458676f, 0.10189099f, -0.02124033f, 0.01963710f, 0.03190891f, 
    0.16782695f, -0.10748592f, -0.10001577f, -0.03727057f, 0.14001296f, -0.04370914f, 0.00508615f, -0.05252388f, 
    0.17716986f, 0.16050968f, -0.02149663f, 0.02761183f, 0.02657380f, 0.03220927f, 0.09909084f, 0.19340450f, 
    -0.08365948f, -0.00160794f, 0.01639769f, 0.01857851f, 0.10545946f, 0.10305861f, 0.04657058f, 0.07179686f, 
    -0.07039402f, -0.05517276f, 0.24373411f, -0.06475129f, -0.00587806f, 0.18411060f, 0.02725835f, 0.08016372f, 
    -0.24252649f, -0.02131462f, 0.02767164f, -0.02521062f, 0.11389868f, -0.06479058f, 0.04131828f, 0.01410378f, 
    0.01827317f, -0.06022881f, -0.09572435f, 0.02756220f, -0.04941532f, 0.03407114f, -0.10843149f, -0.17044307f, 
    -0.06762357f, -0.15684789f, 0.12428326f, -0.30019492f, 0.00182353f, 0.36393967f, -0.02677314f, -0.07737173f, 
    0.08064249f, 0.06168648f, 0.08111367f, 0.02638719f, -0.10264488f, -0.03637763f, -0.38023657f, 0.01699174f, 
    -0.08737656f, 0.02094606f, -0.06456789f, 0.03865972f, 0.00335558f, 0.28690156f, 0.13903601f, 0.14348052f, 
    -0.11392746f, -0.12032488f, -0.00635848f, 0.01555184f, 0.07195747f, 0.05994030f, -0.18521440f, -0.01245350f, 
    -0.16263233f, -0.15001312f, 0.11962418f, 0.00702292f, 0.15878347f, -0.09422414f, 0.06185951f, 0.09466079f, 
    0.16968279f, 0.14769264f, -0.11223482f, -0.02900102f, 0.10507492f, 0.01655637f, -0.02373587f, 0.13705245f, 
    0.06309204f, -0.04255619f, -0.07332367f, -0.11490135f, -0.24607742f, -0.06237131f, 0.09039509f, 0.19315906f, 
    0.09574232f, -0.05144120f, 0.15403840f, -0.25256938f, 0.12378200f, -0.10880720f, 0.07339318f, -0.04977848f, 
    0.05895162f, 0.06358354f, 0.22055258f, 0.16150415f, 0.04119955f, 0.03975480f, -0.13533299f, 0.03625320f, 
    -0.12833415f, -0.05830871f, -0.03641896f, 0.14651793f, -0.10081568f, -0.12961085f, -0.10307970f, -0.13319603f, 
    0.02961497f, 0.06720494f, 0.04146613f, -0.07451699f, -0.00749620f, 0.00248896f, -0.26276395f, -0.14376639f, 
    0.17923595f, -0.10212204f, 0.19486882f, -0.17391387f, 0.04010667f, -0.11922050f, 0.08799372f, -0.36044204f, 
    0.11353575f, -0.18695959f, -0.07768895f, 0.31867296f, -0.09355442f, -0.11043363f, 0.06614613f, 0.21630722f, 
    -0.21645640f, -0.08328629f, -0.12308483f, 0.16270053f, -0.09645890f, -0.00581871f, -0.08121426f, 0.08573625f, 
    -0.17010246f, -0.33243117f, 0.01599383f, 0.08904823f, 0.02962410f, 0.11994302f, -0.06435844f, -0.05091672f, 
    0.34125930f, 0.13959092f, -0.31015137f, 0.17885356f, 0.00947852f, 0.25010803f, 0.02425643f, 0.13144787f, 
    -0.04530034f, -0.10022213f, 0.13991249f, 0.03432468f, 0.09579417f, 0.10063859f, -0.17700922f, -0.11477665f, 
    0.00518574f, -0.04214585f, -0.13014103f, 0.03662242f, 0.30606583f, -0.03402849f, -0.08541027f, -0.12099797f, 
    -0.05712653f, 0.10316694f, 0.08132912f, 0.08988144f, -0.05479078f, 0.00590865f, -0.02116339f, -0.08640233f, 
    -0.13295917f, -0.02447524f, 0.02639658f, 0.14922242f, 0.02501143f, 0.07818036f, 0.08064914f, 0.02734517f, 
    -0.11154495f, 0.03052075f, -0.17108127f, 0.22414683f, 0.23535256f, 0.03926110f, 0.16073212f, 0.06923065f, 
    -0.07503452f, -0.19514304f, -0.14871594f, 0.09710839f, 0.09269225f, 0.00924825f, -0.06544779f, 0.04238368f, 
    -0.22016571f, 0.02208535f, -0.24264929f, 0.01362732f, -0.07753151f, 0.13947855f, 0.06891368f, 0.00440479f, 
    0.16705553f, 0.06955282f, -0.06807958f, 0.00814813f, -0.12815578f, 0.03018720f, 0.06039122f, -0.04795696f, 
    -0.29651538f, -0.18914060f, 0.06637513f, 0.13113005f, 0.04486994f, -0.22741024f, 0.11878479f, 0.18624319f, 
    0.07809696f, 0.05607982f, 0.29772556f, -0.13913818f, -0.07871461f, -0.02985150f, 0.16930962f, -0.00684096f, 
    0.02809574f, -0.04502191f, 0.09227040f, 0.17839789f, -0.13070400f, -0.00821452f, 0.07335233f, 0.08132165f, 
    0.20333311f, 0.34788918f, 0.00467435f, 0.19259951f, -0.29459453f, -0.31027508f, 0.08573325f, -0.03101059f, 
    -0.03011012f, -0.08695264f, 0.10967796f, 0.02422368f, 0.37329635f, -0.07980543f, -0.57113588f, -0.00312738f, 
    -0.16853106f, -0.09689088f, -0.16020976f, -0.15042660f, -0.11916227f, 0.02782253f, 0.04483550f, -0.01295801f, 
    0.02433714f, -0.01627211f, -0.01381538f, -0.03995177f, -0.01219657f, 0.02866133f, -0.14642283f, 0.08000233f, 
    0.04682503f, -0.12272394f, -0.15343939f, -0.12772612f, 0.04555126f, 0.04275034f, -0.05586386f, -0.02342129f, 
    0.02339801f, 0.20493457f, -0.10015137f, 0.18238789f, 0.10120892f, 0.01842649f, 0.15297560f, 0.02598363f, 
    -0.06337152f, 0.18318765f, 0.11111204f, -0.05201774f, 0.00865776f, -0.08146300f, 0.21303926f, 0.17388132f, 
    0.04728829f, 0.02186075f, 0.23633498f, 0.07928538f, -0.08322225f, 0.11199488f, 0.01751843f, 0.17804465f, 
    0.25968856f, -0.06484535f, -0.01238978f, 0.15439026f, 0.41227835f, -0.17401074f, -0.06573156f, -0.07942440f, 
    -0.08051394f, 0.08727425f, -0.04349580f, -0.10451175f, 0.19024937f, 0.29553029f, -0.21334475f, 0.01678009f, 
    -0.25622931f, 0.14239471f, 0.03921137f, -0.08128515f, 0.02788684f, 0.22228676f, 0.17411289f, -0.05747041f, 
    0.14493653f, -0.01339295f, 0.17440522f, 0.12349211f, -0.10101858f, -0.25710180f, -0.15944070f, 0.11825176f, 
    -0.00735581f, -0.00902629f, -0.16179119f, 0.04774049f, 0.14032634f, 0.09233077f, -0.11585203f, -0.14499629f, 
    -0.25680813f, 0.04092498f, -0.12300136f, 0.14959672f, -0.21071601f, -0.03735186f, -0.00567444f, 0.17017499f, 
    0.18874712f, 0.12828460f, -0.11521745f, -0.12670821f, 0.02359728f, 0.00192016f, -0.01404436f, 0.01388366f, 
    0.09601156f, 0.17578951f, -0.17980836f, 0.00114698f, -0.08895719f, 0.01145413f, -0.09161504f, -0.07952809f, 
    0.04524963f, 0.01104247f, -0.23087849f, 0.16178831f, 0.00195816f, 0.07757266f, -0.19220953f, 0.09497067f, 
    -0.00285130f, -0.14244486f, -0.01741775f, -0.08385880f, 0.00783424f, 0.13689607f, -0.00432023f, -0.15939474f, 
    0.02495738f, -0.00756327f, 0.00498992f, -0.02695426f, 0.16056421f, -0.08690432f, -0.02450302f, -0.07063434f, 
    -0.30263513f, -0.16921262f, -0.01412478f, 0.03181438f, 0.11132082f, 0.17911454f, -0.10574189f, 0.00723394f, 
    0.12050319f, 0.03438632f, 0.00090495f, 0.04412798f, -0.04449390f, 0.07735638f, -0.13439788f, 0.24977128f, 
    0.07372986f, 0.00729686f, 0.21706948f, 0.31660986f, 0.00729777f, 0.19138172f, 0.12442283f, -0.04693341f, 
    0.20218098f, -0.00325127f, 0.11295322f, -0.33469141f, -0.07571274f, -0.06314841f, -0.08708905f, 0.03502736f, 
    -0.61904371f, -0.05834907f, -0.02577145f, 0.02668997f, 0.18160887f, -0.12781167f, 0.02324879f, -0.00415994f, 
    0.30247134f, 0.52969497f, 0.31555501f, 0.02065105f, -0.07523755f, 0.00412191f, 0.24139056f, 0.20773283f, 
    -0.17922610f, 0.07632853f, 0.15851371f, 0.17859583f, -0.14030324f, 0.05274881f, -0.01113200f, -0.02381319f, 
    -0.08714492f, -0.12585156f, 0.08088230f, 0.04972374f, 0.11858924f, -0.01784101f, 0.06992041f, -0.16924456f, 
    0.01395672f, -0.19376041f, -0.18357521f, -0.08817694f, 0.04687586f, 0.25410253f, -0.25204986f, -0.08279210f, 
    -0.01345082f, -0.08626016f, -0.05398891f, -0.06405936f, 0.11417139f, 0.13565204f, 0.11294048f, 0.00438855f, 
    -0.02654005f, 0.02238544f, -0.01576734f, -0.05961661f, -0.09761696f, -0.12643874f, -0.23394024f, 0.01437532f, 
    -0.01989664f, 0.02822700f, 0.08152001f, 0.04381340f, -0.06669759f, -0.04713194f, -0.06493328f, -0.25840786f, 
    -0.04135987f, -0.02058373f, -0.16713363f, -0.06330428f, -0.02650522f, 0.08747554f, -0.15760218f, -0.14267100f, 
    -0.02892076f, 0.02980241f, -0.03242422f, -0.05870652f, -0.08720466f, -0.06380547f, -0.12857856f, -0.00623578f, 
    0.06336283f, 0.16332790f, 0.02839214f, 0.06285822f, -0.01754718f, 0.10560033f, -0.01937571f, 0.05953946f, 
    0.09319502f, 0.03431041f, 0.09056525f, -0.06241265f, -0.08828349f, -0.14028721f, 0.00281921f, 0.15813811f, 
    0.18765730f, -0.02389014f, -0.16312738f, 0.32905942f, -0.04357929f, -0.09694434f, 0.13471428f, -0.05562360f, 
    0.10275690f, 0.12759933f, 0.20486510f, 0.27441651f, 0.03845745f, -0.28086069f, -0.03168996f, -0.12426267f, 
    -0.06945599f, -0.03244278f, 0.06213373f, -0.03113751f, 0.32819054f, -0.30548522f, -0.28275889f, -0.07206237f, 
    -0.05230115f, -0.18843986f, 0.10720658f, -0.08264495f, 0.00956599f, -0.03228818f, -0.07054097f, 0.04618805f, 
    -0.05809153f, -0.12001058f, -0.07706588f, -0.07009361f, -0.02781354f, 0.06632654f, -0.08811961f, -0.06800113f, 
    0.06363158f, -0.09244449f, 0.04100594f, -0.02504095f, -0.05534061f, -0.28689474f, -0.19406712f, -0.21360637f, 
    0.19374326f, 0.07959813f, -0.14301598f, 0.11004211f, -0.03324087f, -0.07008521f, 0.20127453f, -0.00699084f, 
    -0.05417652f, 0.27373588f, 0.29615054f, -0.04091912f, 0.08929198f, 0.08060919f, 0.13470693f, 0.05153112f, 
    0.22183898f, -0.00520629f, 0.20155405f, 0.08282108f, -0.18557635f, 0.14860700f, -0.13038902f, -0.07751256f, 
    0.12145747f, 0.15395513f, 0.09504952f, 0.03887447f, 0.09968649f, -0.02038082f, -0.10312600f, 0.02567916f, 
    0.07602308f, -0.12158207f, -0.02170737f, 0.01727317f, -0.02967971f, 0.02468842f, -0.07259819f, 0.16030104f, 
    0.00494160f, -0.13204384f, -0.04199463f, 0.15346497f, 0.20897996f, 0.22618489f, -0.06486176f, -0.22147384f, 
    0.09631190f, 0.13412265f, 0.02846040f, 0.23714021f, -0.14132713f, 0.11071897f, 0.17345130f, -0.03743054f, 
    0.02626862f, 0.05900230f, 0.08392929f, -0.05410373f, -0.06783371f, 0.20494214f, 0.06156174f, -0.16859262f, 
    -0.19481088f, 0.03530799f, -0.02197050f, -0.02771631f, -0.08148976f, 0.10860769f, -0.11059275f, 0.26106361f, 
    0.12522002f, 0.08824201f, 0.09804040f, 0.05093681f, 0.03424167f, -0.05705286f, -0.09767944f, -0.04859582f, 
    0.17892358f, 0.01852825f, -0.01573565f, -0.00495544f, -0.21667655f, -0.16745503f, 0.08035655f, 0.09077054f, 
    -0.06065022f, 0.27262998f, 0.03567393f, -0.41563633f, -0.07391954f, 0.06416388f, -0.10770603f, -0.00436560f, 
    0.10436946f, 0.09853876f, 0.23532753f, 0.24628799f, -0.13588803f, 0.00887019f, -0.00953563f, 0.04265549f, 
    -0.08030023f, 0.01680856f, -0.06999392f, 0.22652455f, -0.00364149f, -0.11571248f, -0.29324126f, -0.08692075f, 
    -0.05944018f, -0.02729617f, 0.07350672f, 0.02648732f, 0.11693566f, 0.02823280f, -0.02821919f, 0.10449915f, 
    0.02242384f, 0.00201281f, 0.09088993f, -0.00504116f, -0.07655267f, -0.02964311f, 0.18116076f, 0.07080027f, 
    -0.01955771f, -0.03460895f, -0.13637359f, -0.00087407f, 0.07481338f, -0.01905484f, 0.13414681f, 0.16739699f, 
    -0.14453819f, -0.07948152f, 0.00828895f, -0.09034333f, 0.00555647f, 0.00018875f, -0.01270329f, 0.11795438f, 
    -0.22384170f, -0.31898996f, -0.06127221f, -0.00642777f, 0.04111826f, 0.00392258f, -0.12107494f, -0.16784805f, 
    0.09198986f, -0.00595771f, 0.10864817f, 0.04114868f, 0.00193134f, 0.15511611f, -0.00581215f, 0.23878792f, 
    -0.04246406f, -0.06533040f, 0.14685717f, -0.03118036f, 0.02163429f, -0.01471663f, -0.07422751f, -0.10111599f, 
    0.04427332f, 0.16682024f, -0.29825869f, 0.11319944f, -0.16179663f, 0.04951488f, 0.05442129f, -0.11584608f, 
    -0.10795645f, 0.03219792f, 0.03781714f, -0.28650409f, 0.11107703f, -0.09976323f, 0.04649586f, -0.14382011f, 
    0.02850718f, -0.08719006f, 0.06786645f, 0.13096361f, 0.08943076f, 0.01971000f, -0.07347338f, 0.10966583f, 
    -0.13995740f, 0.20546587f, -0.17477712f, 0.19268878f, 0.15845209f, -0.18522923f, -0.47119787f, -0.00283085f, 
    0.01779926f, -0.15757433f, -0.02368620f, 0.12936349f, -0.06764913f, 0.06466218f, 0.18184662f, -0.13896692f, 
    0.04716780f, -0.09222391f, -0.18013968f, -0.33786395f, 0.01016238f, 0.12349540f, -0.08733525f, -0.18555869f, 
    -0.17828232f, 0.01997330f, -0.02357350f, 0.22074044f, 0.00402340f, -0.04529686f, 0.08753849f, -0.02676580f, 
    0.14440614f, 0.21814084f, 0.13697255f, -0.04763918f, -0.06468765f, 0.15647392f, -0.05535394f, 0.04115499f, 
    0.04289137f, -0.00952293f, -0.14961816f, -0.37065613f, -0.01525447f, -0.11699353f, 0.05111476f, -0.14773187f, 
    0.17550334f, -0.01015370f, 0.09350888f, 0.15830654f, -0.33874905f, -0.11385281f, -0.00120500f, 0.12715453f, 
    0.03373448f, 0.01561415f, -0.04667130f, 0.00981033f, 0.12086494f, -0.03450814f, -0.03731063f, 0.05976662f, 
    0.05058915f, 0.14169478f, -0.09188046f, 0.14078152f, -0.13538405f, -0.49132431f, -0.49131250f, 0.18172885f, 
    -0.02882666f, 0.05185886f, 0.04344031f, -0.02729256f, 0.20023051f, -0.01759904f, 0.01811144f, -0.17608467f, 
    0.09320809f, 0.20166977f, -0.07487762f, 0.08086958f, 0.03833725f, 0.08551352f, -0.14572725f, -0.08281939f, 
    0.06259312f, 0.08505066f, 0.07913197f, 0.11240902f, -0.15323281f, -0.14476116f, 0.06680928f, -0.03541349f, 
    0.10337838f, -0.02399406f, -0.03233674f, 0.08160671f, 0.02338488f, 0.13202918f, -0.03570505f, 0.16181892f, 
    -0.03739116f, 0.24379703f, -0.17743024f, -0.28443143f, -0.06448732f, 0.14061934f, -0.00891914f, 0.13237801f, 
    -0.09227697f, 0.06044600f, 0.17354904f, -0.10844230f, -0.13776237f, 0.10314588f, -0.01400318f, -0.08076168f, 
    0.14043449f, -0.04346975f, -0.03643652f, 0.13902333f, -0.11987761f, 0.17076443f, 0.16811159f, -0.27830079f, 
    0.00065310f, 0.23424760f, -0.01340541f, -0.51969063f, -0.17556238f, 0.14739534f, 0.03244898f, -0.01190655f, 
    -0.10220766f, -0.04707712f, -0.08405150f, 0.15854704f, -0.03253294f, 0.13944353f, -0.13806930f, -0.02579535f, 
    0.06781346f, 0.03642079f, -0.11711634f, 0.17650118f, -0.04321162f, 0.17179097f, 0.26209548f, 0.16932315f, 
    -0.01095577f, -0.03459906f, 0.07883902f, -0.06994274f, -0.30946299f, 0.00616306f, 0.16274111f, 0.02084217f, 
    -0.04265117f, -0.00967918f, 0.15096432f, 0.11883263f, 0.00568421f, 0.08536477f, -0.08183816f, 0.18733363f, 
    0.09295412f, -0.12502725f, 0.11585188f, -0.10092305f, -0.13835844f, 0.05858197f, -0.03939364f, -0.14224452f, 
    0.03773709f, -0.24891166f, -0.06020367f, 0.00759856f, -0.11172074f, 0.02521865f, -0.09936143f, 0.00708314f, 
    0.05889315f, -0.17696095f, 0.05888911f, -0.10783213f, 0.07915720f, 0.11019138f, 0.08248528f, 0.00029554f, 
    -0.07746793f, 0.12568654f, -0.00699119f, 0.05217400f, 0.09122452f, -0.01950588f, 0.09808003f, 0.14762966f, 
    -0.00008935f, -0.01099284f, 0.01205611f, -0.01945810f, -0.11148005f, 0.14325614f, -0.03628724f, -0.19366601f, 
    -0.16523333f, 0.08801996f, -0.09141602f, -0.00220470f, 0.43427536f, -0.00316096f, -0.25682041f, 0.10711637f, 
    0.03418424f, -0.06786480f, -0.10966808f, 0.23208691f, -0.01020169f, -0.11918416f, -0.01890717f, -0.21744893f, 
    0.12127297f, 0.03234777f, -0.13917032f, 0.11784520f, 0.19482827f, 0.16056393f, -0.00838349f, 0.33570874f, 
    -0.10573069f, 0.04746179f, -0.12803611f, 0.14560884f, 0.08716291f, -0.10432415f, -0.08814263f, 0.05209298f, 
    -0.04946156f, -0.17711836f, -0.06232433f, 0.18012325f, 0.07067843f, 0.01896403f, -0.00296911f, 0.10658573f, 
    0.00197432f, 0.04277188f, 0.00638644f, -0.00621657f, -0.03119257f, -0.03670554f, -0.02798838f, 0.02999234f, 
    0.01410778f, -0.03622378f, 0.00539749f, -0.01265864f, -0.07053728f, 0.00746626f, -0.07665460f, -0.06377177f, 
    -0.04907621f, -0.01313157f, -0.00634493f, 0.02860768f, 0.06022083f, 0.02219409f, 0.04567734f, 0.01172969f, 
    0.01881008f, 0.03707798f, -0.06845763f, 0.00867311f, -0.04269441f, -0.03409424f, -0.00103875f, -0.03576273f, 
    -0.01419083f, -0.02537761f, -0.01294927f, 0.00394305f, 0.00577090f, -0.02023268f, 0.03765488f, 0.01747412f, 
    -0.02439022f, -0.01268780f, -0.02843677f, -0.08095427f, -0.00906784f, -0.06901778f, -0.02112863f, -0.06264742f, 
    0.02801973f, -0.02474440f, 0.04857413f, -0.04814460f, -0.00978937f, -0.00927976f, -0.04440554f, 0.02025066f, 
    -0.05167828f, 0.04787808f, 0.01206246f, -0.01222516f, -0.00566867f, -0.04562981f, -0.06981659f, 0.04045375f, 
    0.04348715f, 0.00252345f, 0.03045695f, 0.00845798f, -0.02202512f, -0.01807180f, 0.02610210f, -0.00802627f, 
    -0.00823743f, -0.00037076f, 0.03025235f, 0.03170698f, -0.03400197f, 0.03636519f, 0.05660162f, -0.00036286f, 
    0.00676538f, 0.00002114f, 0.01273041f, 0.06973594f, 0.02604871f, 0.01920306f, -0.08082438f, 0.03883852f, 
    -0.02169851f, -0.02223265f, 0.00723374f, -0.03738904f, -0.05700026f, -0.06931642f, -0.00760574f, -0.05216866f, 
    0.05295979f, 0.02239197f, 0.02549510f, -0.00529228f, -0.02678313f, -0.03396524f, -0.02464310f, -0.00501164f, 
    0.03541525f, -0.04675100f, 0.04898428f, -0.03032679f, -0.03837207f, -0.05466405f, 0.02092090f, 0.02444101f, 
    -0.02229054f, 0.01797417f, -0.04853036f, -0.05083536f, 0.00659264f, 0.03169189f, -0.05781019f, 0.00769610f, 
    -0.06931227f, -0.02999900f, -0.00165096f, -0.06622458f, -0.03251423f, -0.02314218f, -0.02095497f, -0.02909745f, 
    -0.01889914f, 0.05174975f, 0.00156124f, 0.04077195f, -0.05046429f, 0.03048633f, 0.01446547f, 0.03756628f, 
    -0.04055326f, -0.05986803f, -0.00441351f, -0.06057472f, -0.00633568f, -0.05433006f, -0.06033758f, -0.01903776f, 
    -0.06222779f, -0.00139001f, -0.08997599f, 0.00720737f, -0.02040317f, -0.01127321f, -0.03969381f, 0.01871939f, 
    -0.04879742f, -0.01607125f, -0.01085381f, 0.02600907f, -0.01187972f, -0.06774694f, -0.06314233f, 0.03077385f, 
    -0.03289003f, -0.02251089f, -0.04124128f, 0.01304791f, -0.02346960f, -0.03607741f, -0.00806626f, -0.04852296f, 
    -0.07621114f, -0.01167659f, 0.04445864f, 0.00046217f, -0.03038272f, -0.06717493f, 0.03293462f, -0.01280530f, 
    0.02343158f, -0.00596453f, -0.06437945f, -0.02667564f, -0.01325062f, 0.00517503f, -0.00467944f, 0.04425054f, 
    0.01579308f, -0.02655183f, 0.01388775f, 0.05308082f, -0.03550384f, -0.05371588f, -0.03095537f, 0.03318040f, 
    -0.02890182f, -0.01339925f, 0.02268355f, -0.00836496f, 0.02315588f, 0.02127254f, -0.05279585f, 0.00832597f, 
    0.02124340f, -0.02334226f, -0.00926190f, -0.05534008f, -0.06025491f, -0.01515135f, -0.04252355f, 0.03505037f, 
    0.03646773f, -0.03549102f, -0.00125100f, 0.06799997f, 0.03964486f, 0.01926762f, 0.02613392f, 0.03861556f, 
    -0.02395698f, -0.02128590f, -0.03681805f, -0.01227512f, -0.05319601f, -0.06683078f, 0.01171715f, -0.00776680f, 
    -0.01814211f, -0.03205509f, 0.00481566f, -0.06505477f, -0.01209484f, -0.04031909f, 0.01867229f, -0.02440498f, 
    -0.03627238f, -0.03097263f, -0.03865617f, -0.01847888f, 0.03609107f, -0.00270206f, -0.00956006f, -0.04430743f, 
    -0.02021652f, 0.00808499f, 0.01778743f, -0.04172691f, 0.00382495f, 0.03794656f, -0.06641834f, -0.02487252f, 
    -0.06578910f, 0.00838726f, 0.03024381f, -0.04643897f, 0.00152793f, 0.00688467f, -0.04149719f, -0.02949776f, 
    0.01270092f, 0.03524311f, -0.03789178f, -0.01173917f, -0.01871258f, -0.02041390f, 0.00960676f, 0.04819979f, 
    0.03095216f, -0.00602077f, -0.04917279f, 0.05255691f, 0.02596970f, -0.01692975f, 0.02012500f, -0.06399274f, 
    0.02514310f, 0.00168223f, 0.04772561f, 0.02093739f, -0.05397762f, -0.03169609f, -0.08179141f, 0.00208240f, 
    -0.03353523f, 0.00984937f, -0.05638678f, 0.04252158f, -0.04218179f, 0.02964633f, -0.03046351f, 0.02734368f, 
    -0.18841125f, 0.25174966f, 0.14095548f, 0.12735893f, 0.09425447f, -0.00652771f, -0.10033257f, 0.13664757f, 
    -0.00631855f, -0.19701211f, 0.05172768f, 0.04822570f, 0.03217100f, 0.19420084f, -0.01067127f, -0.15061729f, 
    0.01000121f, 0.00553548f, -0.17665894f, -0.02625389f, 0.15210335f, -0.05718132f, 0.10230596f, 0.04610313f, 
    -0.03043031f, 0.02062075f, -0.11490778f, 0.02160753f, -0.06860493f, 0.22081159f, -0.08745781f, -0.03692716f, 
    0.06074176f, -0.02155314f, 0.00070691f, 0.06630252f, -0.06392118f, 0.03350101f, -0.13459644f, 0.07192770f, 
    0.10187719f, 0.04693099f, -0.19847308f, 0.10150224f, -0.01282635f, -0.11845553f, -0.21623611f, -0.16393828f, 
    0.02106655f, 0.04730785f, 0.04154529f, -0.10592340f, -0.08948235f, 0.04649690f, -0.27668270f, 0.06576356f, 
    0.09064627f, -0.03578222f, 0.02592541f, -0.01578445f, -0.21267496f, 0.17804950f, 0.09986096f, -0.01822867f, 
    -0.12198195f, 0.16088665f, 0.06855731f, 0.17053452f, -0.02396840f, 0.01229766f, -0.11009283f, 0.10107139f, 
    0.08202232f, 0.09148140f, -0.03545963f, -0.06387257f, 0.05051060f, -0.00510922f, 0.09415919f, 0.17899187f, 
    0.01973251f, -0.10056376f, 0.12271301f, 0.08911877f, 0.08049688f, 0.11205870f, 0.14003114f, -0.14853758f, 
    0.00835908f, 0.10378250f, -0.01100363f, 0.18657421f, 0.06111961f, 0.06272129f, 0.21593899f, -0.03496221f, 
    -0.13739505f, 0.06786684f, 0.08611518f, 0.10589423f, -0.18736008f, 0.09841114f, 0.08168752f, -0.03808412f, 
    -0.10551651f, 0.01837425f, -0.02519825f, 0.01406211f, -0.27966881f, -0.14176017f, -0.46940741f, -0.10183483f, 
    -0.17212395f, -0.08113819f, -0.02806418f, -0.14846495f, -0.00007426f, -0.10678154f, 0.05689583f, 0.22206254f, 
    0.05284055f, -0.04523999f, 0.06694942f, 0.08612339f, -0.22009471f, 0.18722115f, -0.14610472f, 0.07270266f, 
    -0.01710301f, 0.10567715f, -0.04444318f, 0.08219022f, 0.00909275f, 0.00276032f, -0.03921036f, 0.04585451f, 
    0.09624886f, 0.13477191f, 0.02583465f, 0.18123917f, 0.03664435f, 0.01784174f, 0.14139666f, -0.06354065f, 
    0.09520731f, 0.07466836f, -0.20744161f, -0.06421801f, 0.12827207f, -0.00651707f, 0.02061038f, 0.06277498f, 
    0.18284956f, 0.03771504f, 0.04060087f, 0.03453081f, 0.18571496f, 0.10443858f, -0.05187824f, 0.02959540f, 
    0.13549069f, 0.17362045f, -0.24988353f, -0.03975702f, 0.33660945f, 0.06680784f, 0.06704847f, -0.12972784f, 
    -0.18062650f, -0.05406124f, 0.11918377f, -0.19197176f, -0.09911498f, 0.01363301f, -0.02788955f, 0.21146388f, 
    0.06043518f, -0.01417988f, -0.08718152f, -0.12984206f, -0.29725465f, 0.20208116f, 0.00803499f, -0.01287581f, 
    0.27978262f, -0.04928246f, -0.03263194f, 0.06986304f, -0.11074295f, -0.04198043f, -0.02722981f, 0.06094830f, 
    -0.25112796f, 0.08525287f, 0.03472029f, 0.15921360f, 0.18379638f, 0.02248801f, 0.06181908f, -0.07294000f, 
    0.01140640f, 0.01997062f, -0.04503316f, -0.01938892f, -0.05375398f, -0.05845607f, -0.08429185f, -0.05684239f, 
    0.07550756f, -0.00857036f, 0.07665622f, 0.04105103f, 0.07504997f, 0.10777187f, 0.00510334f, 0.06890671f, 
    -0.06434136f, -0.08161032f, 0.00339585f, -0.00914541f, -0.05414728f, 0.05466885f, -0.04037345f, 0.00227214f, 
    0.02410753f, -0.03074806f, 0.06086205f, -0.07104634f, -0.05903045f, 0.17330363f, -0.00269332f, 0.17985277f, 
    0.07714872f, 0.00563826f, -0.17745861f, 0.07542518f, 0.04984935f, 0.01295098f, 0.07796492f, 0.02784225f, 
    0.03482089f, 0.13149801f, -0.05935629f, -0.11744864f, -0.04584305f, -0.05991559f, -0.07855603f, 0.03851727f, 
    -0.02528370f, -0.03179834f, 0.00634093f, -0.15724827f, 0.00996352f, 0.02320748f, -0.14557113f, 0.02009936f, 
    0.12895197f, -0.01495542f, -0.09495398f, -0.22578381f, 0.01002809f, 0.01176655f, 0.17374572f, 0.02710691f, 
    -0.11535864f, -0.01702456f, 0.11627609f, 0.02370491f, 0.15044414f, -0.14758801f, -0.00433665f, -0.20839320f, 
    0.06220028f, 0.11112039f, 0.14655262f, -0.12502101f, -0.08770291f, -0.17229021f, -0.07284519f, 0.16590132f, 
    -0.41236126f, -0.12474504f, 0.09351438f, -0.13764611f, -0.05148827f, -0.05375699f, -0.03798113f, -0.17908379f, 
    -0.59200186f, -0.20286898f, -0.10470692f, 0.24231033f, -0.10949364f, 0.21300712f, -0.08102390f, 0.06383497f, 
    -0.09102406f, -0.08196189f, 0.13319407f, 0.06229594f, 0.05988866f, 0.00648366f, 0.00180057f, -0.11362237f, 
    -0.04507273f, 0.18414861f, -0.01423808f, 0.19673340f, 0.07694253f, 0.08823259f, -0.00532615f, -0.08979469f, 
    -0.14984412f, 0.00298698f, 0.14036205f, -0.06882978f, 0.01985094f, 0.00696463f, 0.00576631f, -0.09239393f, 
    -0.02654836f, -0.00108118f, 0.01398482f, 0.05202385f, 0.00078137f, 0.19795945f, -0.06592273f, 0.19039591f, 
    -0.17379108f, 0.04416561f, -0.13671172f, 0.08135584f, 0.15945274f, 0.52936006f, -0.18959042f, 0.05034323f, 
    -0.13368131f, -0.06773446f, 0.15337801f, -0.01282759f, 0.10046548f, 0.04329728f, 0.18903007f, 0.18481718f, 
    0.06963035f, -0.06551779f, -0.08318114f, 0.11501584f, -0.00225275f, 0.09978517f, 0.07302429f, 0.27725148f, 
    0.12012558f, 0.10960527f, 0.06545541f, -0.01052420f, 0.05673375f, 0.08516170f, 0.11766388f, 0.02902389f, 
    -0.30639410f, 0.08407074f, 0.04269613f, 0.01070284f, 0.02699904f, -0.09509826f, -0.02059976f, 0.00079893f, 
    0.01248653f, -0.00037267f, -0.17882885f, -0.09886974f, -0.01627348f, -0.00666164f, 0.08552299f, -0.03738612f, 
    0.04155127f, -0.14523801f, 0.15772751f, -0.15390319f, -0.11683056f, 0.01071097f, 0.11872933f, 0.10726237f, 
    -0.03316042f, -0.01872460f, 0.06746922f, 0.08270495f, 0.19588906f, -0.11961868f, -0.06542005f, 0.02422282f, 
    -0.19981065f, -0.03342052f, 0.03156393f, -0.03063215f, -0.53440380f, -0.06202604f, -0.15421887f, -0.09669105f, 
    0.02672213f, -0.21969870f, -0.09767645f, -0.03034471f, -0.02914650f, 0.16677596f, 0.11180060f, 0.16486271f, 
    -0.01321998f, -0.00446023f, 0.10744698f, 0.12809919f, -0.09793150f, -0.14082809f, -0.04061653f, -0.04387291f, 
    0.09654147f, 0.04757191f, 0.11769291f, -0.12894116f, 0.09794208f, 0.12732530f, 0.09040761f, 0.14877403f, 
    0.13896655f, 0.10387886f, 0.02810082f, 0.06080388f, 0.02643421f, 0.01733360f, 0.15214531f, 0.05473750f, 
    0.09632391f, 0.02809845f, -0.08487435f, 0.07605579f, -0.08836007f, 0.00873733f, 0.17371757f, -0.01455023f, 
    0.02081110f, 0.11843541f, 0.01020229f, 0.03706298f, 0.07035742f, 0.14742388f, 0.13028142f, 0.07781406f, 
    0.01989093f, 0.00233487f, 0.07032852f, 0.19613679f, 0.15542354f, 0.12353978f, 0.01144493f, -0.09926608f, 
    0.04288643f, 0.11045045f, -0.09632646f, 0.13797732f, -0.08733892f, -0.00548898f, 0.01820075f, -0.04466061f, 
    -0.23418024f, 0.01132279f, -0.00471083f, -0.13558060f, -0.28255215f, -0.32295623f, -0.18970199f, -0.15433994f, 
    -0.07206139f, -0.07365625f, 0.19685461f, -0.05858187f, -0.06352893f, -0.35998386f, 0.10128897f, -0.10508681f, 
    -0.10273807f, 0.06544061f, -0.22413833f, 0.03838120f, 0.09732171f, -0.02873572f, -0.06662581f, 0.18941297f, 
    -0.06502539f, -0.00656293f, 0.08291339f, -0.09554484f, -0.02109393f, -0.01150083f, -0.07611050f, -0.30940282f, 
    -0.01105256f, -0.28579617f, -0.26710618f, -0.03200472f, -0.05863970f, 0.12436872f, 0.07343236f, 0.06502904f, 
    -0.04474144f, -0.05736700f, -0.08389138f, -0.13213992f, -0.07462551f, 0.07586976f, 0.04799960f, -0.11745734f, 
    0.09020502f, -0.07840491f, 0.21242595f, 0.13522072f, -0.00615406f, -0.06144274f, -0.21094823f, 0.07383701f, 
    -0.03065232f, -0.05967895f, -0.25207746f, 0.11271492f, -0.03381105f, -0.08523633f, -0.03283883f, -0.24361978f, 
    0.00985530f, 0.04034463f, -0.09579950f, -0.22224179f, -0.20311546f, -0.17141783f, -0.17941824f, 0.12734079f, 
    0.09986844f, -0.04986057f, -0.00320514f, 0.20098341f, -0.24957857f, -0.03566395f, -0.15418991f, 0.02854789f, 
    -0.02867501f, 0.02610917f, 0.02847019f, 0.06860519f, 0.04642768f, 0.23105694f, -0.19774443f, 0.19057350f, 
    -0.12450688f, -0.00298105f, 0.14673564f, -0.17669521f, 0.12058283f, 0.10162544f, 0.11505784f, -0.07422478f, 
    0.18519168f, -0.02030772f, -0.10156825f, -0.12044413f, -0.04848700f, 0.11070757f, -0.05215802f, -0.24568273f, 
    0.15105587f, -0.05076377f, 0.12821618f, 0.12128792f, -0.07311311f, 0.01331812f, 0.15572920f, 0.13640890f, 
    -0.71888506f, -0.05373713f, 0.45633081f, 0.01896539f, -0.00614083f, -0.09363755f, 0.19059063f, 0.07707096f, 
    -0.01421094f, -0.14757347f, -0.32960120f, 0.05624841f, -0.26349607f, -0.15155986f, -0.07144368f, 0.05730724f, 
    -0.01013759f, 0.03377227f, 0.14624444f, -0.15247916f, -0.46198344f, -0.23267680f, -0.27566376f, -0.09346316f, 
    0.11208029f, -0.05658248f, -0.03411976f, -0.12929012f, 0.14084743f, 0.13340019f, -0.03663706f, -0.05654178f, 
    -0.12024470f, 0.03256478f, 0.08074456f, -0.01124372f, -0.39566109f, 0.09438013f, 0.11738668f, -0.04214963f, 
    -0.20832302f, -0.08986640f, 0.02242766f, 0.00907851f, 0.07847359f, 0.01461123f, -0.20869824f, -0.52280617f, 
    0.17472048f, 0.05790969f, 0.00632760f, 0.03562487f, -0.02805773f, 0.05890489f, -0.45033991f, -0.07531731f, 
    0.19173989f, 0.05894269f, -0.05010180f, 0.09859578f, -0.08859468f, -0.05503737f, 0.00062579f, -0.12518868f, 
    -0.03771263f, 0.19735059f, 0.06197153f, -0.03826737f, -0.04340459f, 0.03799180f, 0.07636898f, 0.07101360f, 
    0.02726577f, 0.18080933f, 0.18823536f, 0.03200693f, 0.03916866f, -0.00464940f, -0.04557179f, 0.02513940f, 
    0.09992890f, -0.00235887f, 0.04788975f, -0.37442362f, -0.13616055f, -0.22980377f, 0.00701258f, 0.15260772f, 
    0.02022504f, -0.04064339f, -0.03670223f, -0.06592030f, -0.91106939f, -0.04781541f, -0.00179036f, 0.24568738f, 
    0.12762165f, 0.05066140f, 0.10358816f, 0.02044633f, -0.04819238f, 0.10253567f, 0.06597356f, 0.02188661f, 
    0.06620030f, 0.02016748f, -0.03259604f, -0.05556050f, -0.02372211f, -0.34236950f, -0.25360572f, -0.15230818f, 
    -0.01809469f, -0.04195411f, 0.01915347f, -0.04696026f, 0.02141299f, 0.03459982f, -0.12922317f, 0.04632474f, 
    -0.06326351f, -0.13163620f, -0.03142458f, 0.11392420f, -0.01037704f, -0.04628638f, -0.06564242f, -0.13660274f, 
    -0.17482878f, 0.12687375f, -0.10992400f, -0.03603056f, 0.04634445f, -0.02201181f, -0.19395706f, 0.07043608f, 
    -0.25957200f, -0.35699242f, 0.16231105f, 0.06998310f, 0.05455856f, 0.16913223f, 0.09656796f, 0.09884253f, 
    -0.44875959f, -0.34280014f, 0.11781849f, 0.07566262f, 0.10539998f, -0.11616649f, 0.01058497f, -0.00059388f, 
    0.07832351f, 0.02241769f, -0.36949179f, -0.50898802f, 0.01720805f, -0.09814318f, 0.04697629f, 0.07990389f, 
    0.08476286f, 0.09000615f, -0.36959472f, -0.25752687f, 0.13422839f, -0.07745626f, -0.10957710f, -0.20655438f, 
    -0.08963919f, -0.00829353f, 0.02900422f, -0.10035965f, 0.32894194f, 0.06147829f, -0.04824022f, -0.10484289f, 
    -0.07668369f, -0.16194440f, -0.05605140f, -0.11389763f, -0.20210291f, 0.24610691f, -0.25370702f, -0.13355902f, 
    -0.31319058f, 0.10704840f, 0.14612056f, 0.10857929f, 0.07842527f, 0.14792436f, 0.20535053f, 0.23370518f, 
    -0.02684559f, -0.03071462f, -0.01865398f, 0.12921856f, 0.10621237f, -0.03005689f, 0.00484269f, 0.00425742f, 
    0.07122840f, 0.04794062f, 0.03865179f, 0.10374454f, 0.09899126f, -0.00856970f, 0.06756122f, 0.06583131f, 
    0.22141202f, 0.19090861f, 0.08421482f, 0.10201209f, -0.07835245f, 0.03366187f, 0.01362956f, -0.06419879f, 
    0.22367157f, -0.01264057f, -0.20789531f, -0.23302796f, 0.04865966f, 0.19277157f, 0.08553451f, 0.00128501f, 
    0.17520948f, 0.21478046f, 0.13771252f, 0.07069801f, -0.07334729f, -0.10092437f, 0.04925680f, 0.06253120f, 
    -0.11135259f, 0.04625725f, 0.16665570f, 0.21755977f, 0.10234899f, -0.06719210f, -0.03051660f, 0.02764050f, 
    0.08526499f, 0.08689296f, -0.05582549f, -0.09591839f, -0.09059066f, -0.55017322f, -0.17379914f, -0.09403142f, 
    0.14974710f, 0.15878394f, -0.11604660f, 0.01850797f, -0.21077397f, 0.16368786f, -0.02268290f, 0.06388882f, 
    0.06057386f, -0.03051305f, 0.06930253f, -0.13548097f, -0.02390814f, 0.41551441f, -0.31278676f, -0.42649072f, 
    0.08613483f, -0.25194329f, 0.10047930f, 0.10882025f, 0.15148658f, -0.13581887f, -0.06285311f, 0.00686335f, 
    -0.06335826f, -0.03755669f, -0.01387813f, 0.05018110f, 0.15317985f, -0.07162669f, -0.03133970f, 0.13905832f, 
    -0.36433542f, -0.29217237f, -0.02258385f, -0.01985096f, 0.06284963f, 0.16538131f, -0.02910639f, -0.09426606f, 
    -0.26821256f, -0.09602250f, 0.23599751f, -0.03409414f, -0.08986358f, 0.22256218f, 0.06976935f, 0.15977935f, 
    0.14141735f, -0.02834459f, -0.02141760f, -0.06859734f, 0.01831994f, -0.05622456f, -0.11374334f, -0.06938329f, 
    -0.01349505f, 0.03619475f, -0.07395554f, -0.11243739f, -0.06457990f, 0.02896961f, 0.10378876f, -0.02361096f, 
    -0.02818260f, 0.00558715f, 0.07307752f, -0.10916813f, 0.15169846f, -0.12920639f, -0.13210529f, -0.17651989f, 
    0.18665449f, -0.10242457f, 0.07603171f, -0.00914491f, -0.03919468f, -0.08512908f, 0.07382785f, -0.01921009f, 
    -0.19693750f, 0.08745320f, -0.07553609f, 0.04769334f, 0.02224067f, -0.19442883f, -0.23045006f, -0.13103619f, 
    0.07223262f, -0.07914449f, -0.08216720f, -0.01986583f, 0.04078165f, 0.01451458f, -0.05832139f, 0.04106732f, 
    -0.02220723f, 0.13906993f, 0.04966008f, -0.15447527f, 0.13314815f, 0.03282001f, 0.08934884f, -0.08413052f, 
    -0.08610597f, -0.08638559f, 0.09194805f, 0.09539119f, -0.00809822f, 0.06730232f, 0.02888078f, -0.02958312f, 
    0.11615363f, 0.30862319f, 0.15752883f, -0.02987061f, -0.08483364f, -0.08874196f, -0.19677773f, -0.08618527f, 
    -0.02577761f, -0.08442432f, -0.12126431f, -0.14100195f, 0.01158923f, -0.08603831f, 0.16351797f, -0.02447553f, 
    0.08258998f, -0.07685747f, 0.21263504f, 0.06937959f, -0.26552573f, -0.02113084f, 0.02877795f, 0.06765512f, 
    -0.09869739f, -0.06405420f, 0.00614032f, 0.21006511f, 0.05042570f, 0.14780048f, 0.01522865f, 0.02126181f, 
    0.05898681f, 0.08442171f, -0.00018214f, -0.01891282f, 0.11325215f, -0.08232734f, 0.01761263f, 0.20312345f, 
    0.09329984f, 0.07037474f, 0.10971981f, 0.04180767f, 0.01064869f, 0.08506565f, -0.08777278f, -0.19100153f, 
    -0.01040442f, 0.11317833f, -0.03953717f, -0.00536318f, 0.10379113f, 0.00985711f, -0.20065850f, -0.06303579f, 
    -0.10371289f, 0.09897421f, -0.07170770f, -0.04670843f, 0.11734975f, -0.11195404f, 0.01680666f, -0.00080284f, 
    -0.04134188f, -0.16474777f, -0.06245408f, 0.16490495f, 0.02707649f, -0.14309645f, -0.02344733f, 0.17922401f, 
    0.03760761f, -0.00246292f, 0.04279369f, -0.16018653f, -0.09340001f, -0.10623200f, -0.05419588f, 0.07568555f, 
    -0.02278502f, 0.01426811f, -0.10342410f, -0.25530636f, -0.05222672f, -0.03215388f, 0.01385491f, -0.16241182f, 
    -0.00639251f, 0.00603659f, -0.36165109f, 0.02618072f, -0.07699748f, -0.01679105f, -0.14603490f, -0.02051859f, 
    0.00329336f, 0.03110032f, -0.11176049f, -0.29609996f, 0.06949820f, 0.08679074f, -0.02993453f, -0.06198584f, 
    -0.23414873f, -0.07141937f, -0.07346268f, -0.04767411f, -0.13657807f, 0.05868844f, -0.10802083f, -0.04870764f, 
    -0.03019734f, 0.04298322f, -0.00896546f, 0.07344244f, -0.04267834f, 0.13379319f, 0.32527834f, 0.21528068f, 
    0.03408789f, -0.01281928f, 0.06707715f, -0.03577679f, 0.03707821f, 0.06339337f, 0.18114068f, 0.09382632f, 
    -0.02808559f, 0.01716729f, 0.08903930f, 0.11067563f, 0.03615040f, -0.02277984f, -0.11009138f, 0.00236133f, 
    0.25294831f, 0.11820771f, 0.07208026f, 0.05714063f, -0.08833908f, 0.14347419f, -0.05697540f, 0.02377756f, 
    0.04742766f, -0.10072622f, -0.12253569f, -0.02342167f, -0.05763888f, 0.08456921f, -0.03589576f, -0.02150235f, 
    -0.01300278f, 0.15160692f, 0.11285152f, 0.22869308f, 0.12845618f, 0.11534020f, 0.11921205f, 0.02927573f, 
    -0.12564620f, 0.02321191f, 0.12844190f, 0.26291281f, 0.18461305f, -0.07349987f, 0.18984225f, 0.06584340f, 
    0.09084163f, 0.05658698f, -0.08048744f, -0.02079623f, -0.11072654f, -0.04382911f, -0.09684456f, -0.03745161f, 
    0.13792142f, -0.06270371f, 0.10116477f, 0.04378090f, 0.03131227f, 0.16260661f, 0.10528296f, 0.06804465f, 
    -0.15768588f, 0.12526146f, 0.05358472f, 0.06112287f, -0.15395667f, 0.10082385f, -0.05218516f, -0.25357583f, 
    -0.02370541f, -0.04602843f, 0.13690661f, 0.10081470f, 0.10941787f, 0.00160744f, 0.24818806f, 0.07634037f, 
    -0.00561176f, -0.07409189f, 0.07398315f, 0.03979078f, 0.02402604f, -0.01172549f, 0.04251705f, 0.32999536f, 
    -0.07657325f, -0.20477509f, 0.10235389f, 0.10117316f, -0.08824165f, -0.06387170f, -0.07047235f, -0.05205203f, 
    -0.50682038f, 0.12117168f, -0.05209114f, -0.00240680f, -0.01268777f, -0.06376192f, 0.11712178f, 0.07935538f, 
    0.20219694f, -0.25458026f, 0.09128056f, 0.06723104f, -0.04686385f, 0.04163223f, -0.15712745f, -0.13701248f, 
    0.00194954f, 0.08065261f, -0.29274675f, -0.09745030f, -0.10425064f, -0.06549037f, 0.16833404f, -0.06388590f, 
    -0.02292990f, -0.04508303f, -0.05458903f, 0.05803864f, -0.18619055f, 0.15822193f, -0.15489693f, 0.11177113f, 
    0.06591927f, -0.21776369f, -0.04661594f, 0.02693672f, -0.23198181f, 0.16943420f, 0.09071083f, 0.04312320f, 
    -0.00029568f, -0.16058597f, -0.05611792f, -0.04535322f, 0.16620475f, -0.42480740f, -0.35432842f, -0.19844739f, 
    0.00964083f, -0.12154788f, 0.08606913f, 0.05073876f, -0.06715409f, 0.08146750f, -0.10979878f, 0.23178349f, 
    -0.15153806f, 0.12056700f, -0.08137802f, -0.09617392f, -0.22770764f, 0.18073694f, 0.02091983f, -0.16409118f, 
    -0.13673308f, -0.11243399f, 0.03428392f, -0.00654171f, 0.14927821f, 0.15636303f, 0.03191087f, 0.01294820f, 
    0.10976042f, 0.15468061f, 0.30998620f, 0.04514154f, 0.08580436f, -0.01027128f, 0.00272823f, 0.14381434f, 
    0.21705055f, -0.11089303f, -0.02537808f, 0.03098316f, 0.05376858f, -0.07941353f, -0.06832944f, 0.02544594f, 
    0.09283680f, 0.02992234f, -0.25782445f, 0.01254915f, 0.02590156f, 0.17455034f, -0.06440346f, 0.13376363f, 
    0.14054894f, 0.05922632f, 0.23073141f, 0.09581173f, 0.16785198f, 0.22120024f, 0.02485066f, -0.00169706f, 
    0.05951691f, 0.01098934f, -0.07640085f, -0.08860875f, 0.01001154f, -0.01800880f, 0.02594131f, -0.00907046f, 
    -0.22079650f, 0.00828563f, 0.10337322f, 0.04520949f, 0.05304055f, -0.10936177f, -0.01693240f, -0.07168760f, 
    0.04956371f, 0.00762894f, 0.06479397f, 0.09833694f, 0.03303176f, -0.01235037f, -0.28665361f, -0.24474771f, 
    -0.07949378f, -0.05334838f, -0.06001108f, 0.08132823f, 0.09166703f, -0.01339736f, -0.02794752f, -0.15223713f, 
    0.04183483f, 0.16044666f, 0.07486778f, 0.00251360f, 0.08983110f, 0.20347707f, 0.18293320f, 0.11651395f, 
    -0.00997922f, 0.10259816f, -0.04738746f, 0.14276952f, 0.00888042f, -0.01529470f, -0.10617211f, 0.16344099f, 
    0.07017706f, -0.22140674f, -0.15643390f, 0.05110422f, 0.08002012f, 0.01355059f, 0.00095532f, -0.05788951f, 
    0.07995889f, 0.02644243f, -0.20343441f, -0.03559381f, -0.13885765f, -0.00593818f, 0.17525423f, 0.03590815f, 
    0.02302107f, 0.12551408f, -0.03088188f, 0.06673326f, -0.24495953f, -0.09112072f, -0.05782054f, 0.07554557f, 
    -0.02964693f, 0.01302903f, -0.02231609f, -0.05696848f, -0.09410116f, 0.00272873f, -0.13205828f, 0.00630981f, 
    0.07029592f, 0.04394471f, -0.12832102f, 0.05615112f, -0.22539560f, 0.06204702f, 0.03153212f, 0.27463973f, 
    0.00246877f, 0.04465769f, 0.04458285f, 0.07327085f, 0.03942906f, 0.09754629f, 0.12120973f, 0.15057655f, 
    0.15303434f, 0.05896517f, 0.00059423f, 0.11052526f, 0.03375712f, -0.01106745f, -0.00492377f, -0.06548323f, 
    0.23022492f, 0.02263206f, 0.06726108f, 0.17534707f, 0.01062532f, 0.08619298f, 0.06602883f, -0.17808819f, 
    -0.12296579f, -0.10436159f, -0.02999633f, -0.01530754f, -0.04588204f, -0.00899227f, 0.04543417f, -0.09701205f, 
    0.05812580f, 0.20126978f, 0.09853648f, 0.25394294f, -0.09026546f, 0.11140200f, -0.00477232f, 0.00338800f, 
    0.29934332f, 0.11168805f, -0.00550664f, 0.10229331f, 0.22199787f, -0.21221787f, 0.14716795f, -0.04975925f, 
    -0.00608137f, 0.13097467f, -0.12657602f, -0.05425049f, -0.21284662f, -0.07022276f, -0.15182737f, 0.08722427f, 
    -0.00108976f, 0.02085303f, 0.05254349f, 0.17595927f, -0.00280050f, 0.13665485f, 0.07593731f, -0.07420503f, 
    -0.08519073f, 0.05172084f, -0.02151704f, -0.07375911f, 0.04672591f, -0.21841477f, -0.01630884f, -0.04024409f, 
    -0.02726762f, -0.14190954f, 0.01819213f, 0.00312234f, 0.26238626f, -0.00860589f, 0.07746375f, 0.07278699f, 
    0.21241014f, -0.01318416f, -0.04679965f, 0.03462974f, -0.05081198f, -0.17234279f, -0.14878373f, 0.11995325f, 
    -0.02780222f, 0.08777008f, 0.03645449f, -0.17811756f, -0.05528406f, -0.05740178f, 0.05263730f, -0.08921324f, 
    -0.31341147f, -0.26729512f, 0.47853363f, -0.20109221f, -0.08441750f, -0.14892231f, 0.03244312f, 0.15757324f, 
    -0.04250344f, -0.02274385f, -0.39297143f, -0.10557684f, -0.05525377f, -0.10381148f, -0.05369980f, -0.05567639f, 
    -0.08454902f, 0.10143086f, 0.07356536f, -0.20982705f, -0.15756780f, -0.03622971f, -0.19184409f, -0.18268394f, 
    0.07103474f, 0.13843222f, 0.04919948f, -0.03479101f, 0.05828548f, 0.33117101f, -0.12994027f, -0.11875341f, 
    -0.01032332f, -0.06450105f, 0.11210091f, 0.05805268f, -0.26243448f, -0.14102009f, 0.15355374f, -0.01742578f, 
    -0.17321923f, -0.13069084f, 0.04398360f, 0.04168254f, 0.12575905f, 0.05993387f, -0.21033137f, -0.38026839f, 
    0.10549388f, -0.01950128f, -0.11504766f, -0.06784201f, 0.12166794f, 0.03129686f, -0.52895463f, -0.15524951f, 
    -0.17213605f, 0.04685961f, 0.02733254f, 0.13094603f, 0.04754295f, 0.20370339f, 0.02704216f, 0.01696036f, 
    -0.29590818f, 0.05766132f, 0.06399345f, -0.08319991f, -0.11895428f, -0.09848088f, 0.02650004f, -0.02677841f, 
    0.08279225f, 0.20921127f, 0.16136804f, -0.03073442f, 0.00422696f, -0.06997684f, -0.06428189f, 0.02906102f, 
    0.04093321f, -0.27006778f, 0.01897781f, -0.27622345f, -0.02665275f, -0.33951283f, -0.14029787f, 0.11707719f, 
    -0.00177202f, -0.03038853f, 0.03157740f, 0.33578399f, -0.27077359f, 0.10704407f, -0.05244825f, -0.11013452f, 
    -0.08247190f, -0.00429274f, -0.09158190f, 0.19291312f, -0.01268761f, 0.29268238f, 0.09090773f, -0.02572838f, 
    0.00869064f, 0.07588060f, 0.07748941f, 0.06101469f, 0.28668427f, -0.17565520f, 0.07469909f, -0.09924278f, 
    0.02322309f, 0.27117708f, 0.09636202f, -0.06815279f, -0.04202017f, 0.07694140f, -0.04801027f, -0.11980347f, 
    0.03129717f, 0.01903634f, 0.00892029f, 0.02709805f, 0.02238010f, -0.18595086f, -0.04938675f, -0.24820869f, 
    -0.10612371f, 0.07299775f, -0.03958599f, -0.02037583f, 0.15820485f, 0.02727986f, -0.06215715f, -0.00868429f, 
    -0.21615405f, -0.13091169f, -0.02261909f, 0.02135268f, -0.00399429f, -0.01071643f, -0.02573074f, 0.05519435f, 
    0.21187694f, -0.44089371f, 0.30384639f, 0.03341493f, 0.03605850f, -0.08858536f, -0.03005870f, 0.00448651f, 
    0.00929506f, 0.00896448f, -0.31925341f, -0.24985151f, -0.00829393f, -0.09169248f, -0.09808329f, -0.15110792f, 
    0.00380194f, 0.01738204f, -0.28747371f, -0.36858562f, 0.08262426f, -0.24932477f, -0.09046391f, -0.01489586f, 
    -0.02670800f, 0.05375043f, -0.09504467f, 0.04771806f, 0.28557438f, -0.01004205f, -0.15763232f, -0.04042191f, 
    -0.03301107f, 0.03119672f, -0.11245084f, 0.00453122f, -0.23114869f, 0.05708246f, -0.18485993f, -0.15912303f, 
    -0.13814378f, -0.14048091f, 0.23394914f, 0.13297822f, 0.14140581f, 0.14352380f, 0.27641609f, 0.30522919f, 
    -0.08771454f, 0.02374320f, 0.00592827f, 0.05832919f, 0.09669009f, -0.01331041f, -0.00687687f, 0.02164539f, 
    0.09920754f, 0.04057769f, -0.00763282f, 0.20772628f, 0.10082785f, 0.14241022f, -0.03761133f, 0.05120688f, 
    0.11092436f, 0.22195902f, -0.08923162f, -0.02410634f, -0.02698199f, 0.06988914f, -0.03924339f, 0.08956829f, 
    -0.15322591f, -0.14779668f, -0.21561916f, -0.16321838f, -0.17623188f, 0.20403762f, 0.06121832f, 0.03959666f, 
    0.11282614f, 0.22129652f, 0.17695539f, 0.05810243f, -0.05241830f, 0.04589901f, 0.13419692f, 0.02092670f, 
    -0.01890802f, 0.11557180f, 0.27202699f, 0.20038792f, 0.07892674f, -0.06424823f, 0.00280800f, 0.05923337f, 
    0.05047899f, 0.04865552f, 0.02613359f, -0.16205381f, 0.07635591f, -0.30063134f, 0.05091881f, -0.05880051f, 
    0.17296042f, 0.02045931f, 0.06175739f, -0.08933373f, -0.12420144f, 0.11430828f, 0.13620253f, -0.07289342f, 
    -0.10606687f, 0.07613995f, 0.01959414f, 0.00483912f, -0.06824168f, 0.09053303f, 0.26444247f, -0.31234378f, 
    0.02080918f, -0.07054003f, 0.06492244f, 0.02468179f, -0.03451103f, -0.11715619f, 0.11248820f, 0.05385289f, 
    -0.02012627f, -0.15597579f, 0.02248194f, 0.04889077f, 0.09082976f, 0.08362880f, 0.07142261f, 0.35286379f, 
    -0.21738333f, -0.18494834f, 0.04737169f, -0.08100554f, 0.06604157f, 0.03580330f, 0.09281879f, -0.04257718f, 
    -0.12844564f, -0.44809708f, -0.29262206f, -0.08217898f, -0.02296387f, 0.05888572f, 0.06028462f, 0.01735601f, 
    -0.00890015f, 0.00712228f, 0.18734771f, -0.01969015f, 0.00246650f, 0.14733778f, 0.01561854f, -0.02880644f, 
    0.06419238f, 0.10815113f, 0.10433446f, 0.19095555f, -0.13643414f, 0.11143072f, -0.06086444f, -0.03617541f, 
    -0.00228393f, 0.05683360f, 0.26400420f, -0.16300635f, 0.09756058f, 0.16446279f, 0.00476551f, -0.13822731f, 
    0.06415536f, -0.01918766f, 0.05128989f, 0.01894365f, 0.03577339f, 0.19119707f, -0.02522322f, 0.04064532f, 
    -0.06864554f, 0.09692463f, 0.03253148f, -0.00598502f, 0.28537485f, 0.38295960f, -0.04613222f, -0.06222950f, 
    0.10027660f, -0.05448575f, 0.18031503f, 0.07621121f, 0.06909385f, -0.02821775f, 0.27222794f, 0.17861180f, 
    -0.15888524f, 0.08460442f, 0.07160822f, 0.06351531f, 0.09845095f, 0.05985389f, 0.03478505f, 0.14666772f, 
    0.07073709f, 0.14689749f, -0.03579473f, 0.01824077f, -0.04438343f, -0.00945407f, -0.08830959f, -0.00505807f, 
    -0.22677030f, -0.04630949f, 0.05473321f, -0.01512435f, 0.03361106f, 0.00268896f, 0.04981767f, -0.00419666f, 
    0.02088164f, 0.07960947f, -0.07999206f, -0.15717733f, -0.19483042f, -0.18859380f, -0.03820666f, 0.09542798f, 
    -0.01926337f, -0.03321396f, 0.21661325f, -0.08591253f, -0.36495960f, -0.13700762f, -0.26491043f, 0.04568746f, 
    -0.03785724f, -0.13716109f, 0.03713750f, 0.16321371f, -0.73394597f, -0.75310779f, -0.16097961f, -0.07770308f, 
    0.06459938f, -0.07976986f, -0.05752497f, 0.15801801f, -0.56454718f, -0.08823027f, -0.14523461f, 0.15916654f, 
    0.10529146f, 0.13293973f, -0.14642151f, -0.06409857f, -0.14162754f, 0.01558718f, 0.15102497f, 0.22789238f, 
    -0.01637263f, 0.00085982f, 0.09872084f, 0.05013419f, -0.03748143f, -0.05296856f, 0.01753771f, 0.12675720f, 
    0.06590503f, -0.03566155f, 0.01215864f, -0.04305621f, 0.02827706f, 0.10455957f, 0.22576317f, 0.16601765f, 
    0.02280169f, -0.11106327f, 0.15740398f, 0.03688266f, 0.00884851f, 0.06857468f, 0.04444773f, 0.07725354f, 
    0.15462497f, -0.16059247f, -0.01866911f, -0.03113601f, -0.06972228f, -0.11755986f, 0.09172574f, -0.05380350f, 
    -0.08425041f, 0.00866987f, 0.13461339f, -0.15425643f, 0.07140789f, -0.11283074f, 0.16599314f, 0.00801523f, 
    -0.12988126f, 0.04445649f, 0.18393466f, 0.00903103f, -0.04677460f, 0.10908651f, 0.15439698f, -0.13879965f, 
    0.04347765f, 0.21664099f, 0.13639143f, 0.47514749f, -0.45314541f, -0.39809588f, 0.09131605f, 0.01387550f, 
    -0.04105266f, -0.01098470f, 0.04474560f, -0.13060288f, -0.41518217f, -0.65446186f, -0.61942363f, -0.04533704f, 
    0.05977969f, 0.06859560f, 0.18438582f, 0.01546504f, -0.03406209f, -0.50320756f, -0.15094247f, -0.13888580f, 
    -0.05421023f, 0.25154105f, -0.15008478f, -0.06556656f, -0.02433852f, 0.05656249f, -0.46449548f, -0.04698804f, 
    -0.06109208f, 0.01533105f, 0.15316048f, -0.04448998f, 0.05600378f, 0.02614050f, 0.05970715f, -0.24386904f, 
    -0.39167503f, -0.31539443f, -0.05519843f, 0.07424538f, -0.14330193f, 0.02896639f, 0.08582211f, -0.06085015f, 
    0.02838975f, 0.08747657f, -0.05411652f, -0.09427021f, -0.16457170f, -0.06052840f, 0.10497076f, 0.03198493f, 
    0.02647224f, -0.33938456f, -0.15776145f, 0.16488880f, 0.10814627f, -0.04870560f, -0.12987001f, 0.10269251f, 
    0.04216998f, -0.05739143f, -0.24146399f, -0.51410156f, -0.05973868f, 0.11304961f, 0.07262891f, -0.08882997f, 
    -0.00079085f, 0.02925964f, -0.10068582f, -0.21236892f, -0.15274949f, 0.01242100f, -0.14683123f, -0.17920028f, 
    0.04491387f, 0.15086457f, -0.02267586f, 0.03568736f, -0.45577243f, 0.08600341f, -0.04755808f, 0.00189066f, 
    -0.08591868f, -0.19135419f, -0.08600902f, 0.14582045f, 0.12100326f, -0.06807981f, 0.36998412f, -0.12563248f, 
    -0.01406672f, -0.34785265f, 0.04221724f, 0.03114010f, 0.07043127f, 0.06517867f, 0.45421574f, -0.58535457f, 
    -0.23907739f, -0.16384578f, -0.08473250f, -0.09397897f, 0.00785816f, 0.03162978f, 0.11265347f, -0.43328917f, 
    -0.04828909f, -0.06459510f, -0.03807019f, 0.04496364f, 0.19566193f, -0.05255834f, -0.04283661f, 0.15950206f, 
    0.39046165f, 0.18518920f, -0.47805759f, -0.31899726f, 0.05111279f, 0.04571933f, 0.12441591f, 0.11859175f, 
    0.02211990f, 0.27085954f, 0.07881799f, -0.08455293f, -0.04097585f, 0.16667920f, -0.02168389f, -0.04683342f, 
    0.03094343f, 0.12343948f, -0.15010777f, -0.27371344f, -0.01908745f, -0.00018088f, 0.13818775f, 0.09426048f, 
    -0.05638367f, -0.18083754f, 0.02726768f, -0.17058079f, -0.27927071f, 0.31536713f, -0.09799588f, -0.10082299f, 
    0.08189122f, 0.02689439f, -0.05226993f, 0.12168267f, -0.03794954f, 0.04640975f, 0.03743345f, 0.00091764f, 
    -0.02666012f, 0.10828073f, -0.08431205f, -0.13798127f, 0.06802920f, -0.63354355f, -0.02844898f, 0.19996122f, 
    -0.28519881f, -0.12849976f, -0.12546359f, 0.02581894f, -0.05833839f, 0.02345916f, 0.08803750f, 0.17247888f, 
    0.01147289f, 0.09007109f, -0.18548857f, -0.27378449f, 0.16345990f, 0.00504309f, -0.16958471f, -0.38488922f, 
    -0.28799990f, 0.18474162f, 0.02853168f, -0.17616762f, 0.16104457f, 0.08409458f, 0.08251736f, -0.00476615f, 
    0.27256748f, 0.00805599f, -0.01486572f, -0.06530216f, 0.04460559f, -0.01735346f, -0.01415544f, 0.18343416f, 
    0.13362513f, -0.07796987f, -0.36846152f, -0.05674059f, 0.13074157f, -0.17220812f, 0.09222679f, 0.23082480f, 
    0.07216655f, 0.07317015f, -0.03448252f, -0.29771671f, -0.17001227f, 0.04044155f, -0.10301293f, 0.10711356f, 
    0.07220452f, -0.08540376f, 0.02459790f, 0.12982909f, -0.11023320f, -0.02880560f, 0.22599098f, 0.09056398f, 
    -0.00145502f, 0.00758883f, 0.09230015f, -0.16659513f, -0.34691390f, -0.07136922f, 0.11686815f, 0.10115001f, 
    0.10065244f, 0.01440721f, 0.09992614f, -0.06488737f, -0.02648384f, 0.02112770f, 0.03374251f, -0.04973818f, 
    0.16996951f, -0.00506182f, 0.03011333f, 0.09047610f, 0.34017655f, 0.08292045f, -0.07642199f, 0.05280428f, 
    0.10934087f, -0.22558580f, -0.12280128f, -0.01501128f, 0.05603107f, 0.16588463f, -0.09166429f, -0.27893451f, 
    -0.11653803f, 0.40861988f, -0.05543141f, 0.00749970f, 0.05078759f, 0.08356873f, -0.17107753f, 0.07748998f, 
    0.04187792f, -0.14505193f, -0.07142916f, -0.10257528f, -0.00045349f, -0.08507337f, -0.04008402f, 0.17514394f, 
    0.12954129f, -0.07892547f, 0.04495503f, 0.14710781f, -0.09270851f, -0.01165363f, 0.17977710f, 0.13397405f, 
    -0.07220993f, 0.08966449f, -0.14721489f, -0.03908504f, -0.08394253f, 0.00052897f, 0.12900828f, -0.07244110f, 
    0.22834283f, -0.04662224f, 0.06181078f, -0.31174314f, -0.14016217f, -0.15091695f, -0.26398516f, -0.02990419f, 
    -0.08009379f, 0.02869425f, -0.22378643f, 0.17122303f, 0.21354832f, -0.27909216f, 0.08828326f, 0.15778248f, 
    0.02330748f, -0.08643206f, -0.12268190f, 0.00645428f, -0.11932772f, 0.29748181f, -0.10755456f, -0.12573232f, 
    -0.03934823f, -0.05011262f, 0.01367282f, 0.06726090f, 0.05881916f, -0.14807263f, 0.22489211f, 0.07514752f, 
    0.06890267f, 0.14049247f, -0.09130830f, 0.08550138f, 0.10050026f, 0.05645952f, -0.12038885f, 0.13625443f, 
    -0.13297841f, -0.03904793f, -0.03970157f, -0.03638800f, -0.17703386f, 0.08238012f, 0.04522615f, -0.15326589f, 
    -0.21268339f, -0.01349723f, -0.19424039f, 0.02904055f, -0.05621577f, -0.07371983f, 0.19233558f, -0.07922795f, 
    -0.11644456f, 0.11398711f, -0.10274696f, -0.01306360f, 0.11728629f, 0.06173740f, 0.01112615f, 0.09893815f, 
    0.01952798f, 0.09772155f, 0.26837489f, -0.08537620f, 0.03895858f, 0.16693762f, 0.06662092f, 0.07952906f, 
    0.14878260f, -0.02876942f, -0.14714170f, 0.17424774f, -0.20282772f, -0.29133317f, -0.18220888f, 0.08077099f, 
    -0.09607864f, 0.07617129f, 0.03244226f, 0.00550954f, 0.14853284f, 0.04019166f, 0.18469244f, -0.01493216f, 
    -0.04047691f, -0.10206970f, 0.03774334f, -0.11692913f, -0.02474017f, 0.10390809f, -0.10783090f, 0.15557139f, 
    -0.29992017f, -0.11451173f, -0.18158282f, 0.35465780f, -0.14823051f, 0.25884026f, 0.41485593f, -0.03034837f, 
    -0.14027567f, 0.04543403f, 0.05823561f, -0.21896835f, -0.06025597f, 0.13401447f, -0.21639331f, 0.19505507f, 
    -0.01147705f, 0.17819308f, 0.03032516f, -0.17681192f, -0.04078953f, 0.00533726f, 0.02384375f, 0.00093821f, 
    0.19404176f, -0.34180588f, -0.81154418f, -0.13017261f, -0.06928539f, -0.03962525f, 0.06066830f, -0.03053742f, 
    0.12778869f, 0.10627669f, 0.02313968f, -0.03499812f, 0.20347539f, 0.04072615f, 0.09770170f, 0.02220875f, 
    -0.06631811f, 0.16788648f, -0.11566572f, 0.06011161f, -0.10121731f, -0.07883799f, -0.22132170f, -0.27057952f, 
    0.06285997f, 0.02972329f, 0.12358265f, -0.11395305f, -0.00978336f, -0.06871600f, 0.03162331f, -0.28837246f, 
    -0.11546862f, 0.21851924f, -0.01134076f, 0.04832264f, 0.18729693f, -0.07636661f, 0.00191174f, 0.08114940f, 
    -0.15659291f, -0.05824932f, 0.21898627f, 0.05560984f, 0.09619185f, -0.10177944f, -0.12810290f, -0.07718710f, 
    -0.05982416f, -0.05199369f, -0.01884795f, -0.03355287f, 0.00639276f, 0.06150037f, 0.13390991f, -0.01931088f, 
    -0.16885695f, -0.18436208f, 0.08905017f, 0.03208668f, -0.00517128f, 0.08146167f, 0.16540502f, -0.00430924f, 
    0.16424033f, 0.18681979f, 0.08056857f, 0.02182681f, -0.05970153f, 0.04921827f, 0.03721822f, 0.18329336f, 
    0.02280847f, -0.20541644f, -0.03248718f, 0.18121064f, 0.11712441f, -0.06004803f, 0.12723076f, 0.04581750f, 
    -0.08660349f, 0.16414520f, -0.22436252f, 0.00140952f, -0.04832954f, -0.38005087f, -0.09605403f, -0.01334822f, 
    -0.06210824f, 0.09807933f, 0.28152090f, -0.66234696f, -0.59999263f, -0.01603802f, -0.24326245f, -0.05653301f, 
    -0.16582228f, 0.08686094f, -0.02135135f, -0.13814630f, -0.06209980f, 0.09364832f, -0.14171983f, 0.04217039f, 
    0.02359365f, -0.07248636f, 0.07184981f, 0.03848773f, -0.23403898f, 0.19044168f, 0.37134904f, -0.05601685f, 
    -0.02704567f, -0.00512115f, -0.05543239f, -0.18757683f, 0.15671213f, -0.00406262f, 0.32309151f, 0.14741737f, 
    0.07991108f, 0.13748042f, 0.14720498f, 0.02785773f, 0.03602675f, 0.21101049f, -0.02790185f, 0.08434187f, 
    0.21237357f, 0.05924918f, -0.01360996f, -0.01854778f, -0.02087471f, -0.02281656f, 0.13480932f, -0.03791114f, 
    0.22903600f, -0.06672657f, 0.10813788f, -0.02349991f, 0.03338088f, 0.11508080f, 0.16659315f, 0.14470334f, 
    -0.22147939f, -0.63541132f, -0.09753984f, 0.06555372f, -0.03382526f, -0.09741858f, -0.00423103f, -0.03975395f, 
    0.08487582f, 0.14224637f, -0.07252198f, 0.02249796f, 0.19996877f, -0.05763407f, 0.14629713f, 0.08227993f, 
    0.01858164f, 0.01623847f, -0.03089732f, 0.04624350f, -0.39106783f, 0.07687816f, -0.01798293f, 0.12196874f, 
    0.09038331f, 0.21050830f, 0.01584592f, -0.31093347f, -0.21627973f, -0.32511723f, -0.21111684f, -0.03227316f, 
    -0.15155889f, 0.09912352f, -0.04276634f, -0.03052528f, 0.37357849f, -0.11226849f, -0.07139208f, -0.02425713f, 
    -0.20383041f, -0.06589240f, 0.01684489f, 0.02815934f, 0.11989236f, -0.30003205f, -0.22682996f, -0.26094231f, 
    0.06108620f, -0.00046926f, -0.14741640f, -0.03012579f, -0.02116719f, -0.00318639f, 0.06866484f, 0.10095342f, 
    0.16659656f, -0.01773794f, -0.02385304f, 0.05972038f, 0.00309777f, 0.05891578f, 0.13453993f, -0.11472771f, 
    -0.33282200f, -0.19295646f, -0.08348614f, -0.07251688f, 0.01192014f, 0.02450669f, 0.15696339f, 0.10118682f, 
    -0.27370167f, -0.21555597f, -0.17196964f, -0.13605052f, -0.30201286f, -0.11002903f, 0.03686555f, -0.01488610f, 
    0.00120942f, -0.02907526f, 0.02661708f, 0.32995844f, 0.05620936f, -0.00115078f, -0.12694927f, -0.00893475f, 
    0.06896192f, -0.03558818f, -0.07594531f, -0.21949188f, 0.02791145f, 0.22976936f, -0.01743863f, -0.16009781f, 
    -0.11540041f, -0.14275539f, 0.06121807f, 0.02867481f, -0.12916072f, -0.01087624f, -0.03834260f, -0.22451343f, 
    -0.11175232f, -0.05217879f, -0.05582832f, 0.00900599f, 0.17762725f, -0.13303740f, -0.02240144f, -0.19584425f, 
    -0.04930709f, -0.05933794f, 0.07731833f, 0.09705152f, -0.03112193f, -0.07571413f, -0.18449049f, -0.28827083f, 
    -0.29905239f, -0.03944983f, -0.15128084f, -0.18893029f, 0.13627206f, 0.10001634f, 0.05181465f, -0.03704191f, 
    -0.01026407f, -0.06627136f, 0.03560363f, -0.09043632f, 0.07154953f, 0.07121374f, 0.01089968f, 0.03807408f, 
    0.26524484f, 0.37001726f, -0.01721861f, 0.12463319f, 0.06677462f, -0.05416369f, -0.00507854f, 0.08036712f, 
    0.40383136f, -0.09089962f, -0.31228083f, 0.06512918f, -0.06823212f, -0.12102588f, -0.10939450f, 0.00272311f, 
    0.02947615f, 0.15167257f, 0.03082125f, -0.13121362f, -0.11350162f, -0.02279665f, -0.25963539f, -0.03911065f, 
    0.04198767f, 0.12521318f, -0.16634306f, 0.00686653f, -0.09598248f, -0.01485913f, -0.14140765f, -0.13616888f, 
    -0.01083617f, 0.11851605f, 0.16760197f, -0.09244838f, 0.04087990f, -0.11716840f, -0.14141299f, 0.01009726f, 
    -0.22917694f, -0.09291147f, 0.04931645f, -0.03598087f, 0.01650856f, -0.02414214f, -0.19885939f, -0.15289289f, 
    0.13744989f, -0.12569530f, 0.03477351f, 0.01375652f, 0.03914514f, 0.25635499f, 0.31609225f, 0.23948549f, 
    0.03397134f, 0.00972987f, -0.05994886f, -0.00821440f, 0.00797573f, -0.10084715f, -0.03448300f, -0.03794062f, 
    -0.18075065f, 0.04976242f, -0.03709584f, -0.17115548f, -0.03910108f, 0.01626534f, -0.20307915f, 0.02654897f, 
    0.14890139f, 0.04019155f, -0.13987668f, 0.01163522f, -0.35824203f, 0.06247126f, -0.08089116f, -0.16867572f, 
    0.09693620f, -0.05671110f, 0.10362649f, 0.18419521f, 0.02872008f, -0.08534229f, -0.00277506f, -0.03653256f, 
    -0.03932631f, 0.13234200f, 0.00472387f, -0.09488136f, -0.02960042f, -0.31136897f, -0.17307772f, 0.09755655f, 
    -0.04709343f, -0.07328919f, 0.08688699f, -0.01518034f, -0.11897348f, -0.02825846f, -0.04754846f, 0.03300705f, 
    -0.02706496f, -0.03982039f, -0.26124698f, -0.01333185f, -0.00117879f, 0.23234197f, 0.14021693f, 0.00977056f, 
    0.00327087f, 0.07530284f, -0.06504957f, 0.13771231f, -0.05430875f, 0.19227147f, 0.44374406f, -0.07154240f, 
    -0.19914436f, -0.13784440f, -0.14113252f, 0.05979581f, 0.03537137f, 0.09322822f, -0.05871842f, -0.03515543f, 
    -0.19969183f, -0.17121077f, -0.24007304f, 0.05204935f, 0.06872972f, 0.02309971f, 0.03446192f, 0.07856628f, 
    -0.07186331f, 0.06924004f, -0.01412641f, -0.00419913f, 0.16263032f, 0.03122616f, 0.07451237f, -0.09630475f, 
    0.19358067f, -0.04061496f, -0.03895590f, 0.13913429f, 0.03575694f, 0.04622732f, -0.14135297f, -0.06852292f, 
    0.06642294f, 0.01344801f, 0.00834119f, 0.00543307f, 0.11159344f, -0.14528598f, -0.17202619f, -0.09713251f, 
    -0.34291902f, 0.16774243f, 0.27444419f, -0.04950345f, 0.05250648f, -0.05588573f, -0.09654941f, -0.12112150f, 
    -0.10274990f, -0.08782467f, -0.18158577f, 0.21548896f, -0.15490828f, 0.09662074f, -0.13725568f, -0.05507431f, 
    0.08986605f, -0.05309224f, 0.13083093f, -0.26279917f, -0.03637501f, 0.30933434f, 0.09674770f, -0.14218841f, 
    0.04049423f, 0.01170251f, 0.00637889f, -0.12322067f, -0.04945230f, -0.14745913f, 0.05884295f, 0.02898612f, 
    -0.23676030f, -0.15218759f, 0.09909277f, -0.02348994f, -0.05680512f, 0.14700824f, 0.08915581f, 0.30569467f, 
    0.01142053f, 0.03808627f, 0.00782293f, -0.03249716f, -0.12169984f, 0.01572224f, -0.01606880f, -0.03331588f, 
    0.01556082f, -0.04017340f, 0.09681079f, -0.01503355f, 0.09780622f, -0.06616599f, -0.00384537f, 0.21793507f, 
    0.12536418f, 0.24776408f, 0.04679261f, -0.09182022f, 0.03970808f, 0.18166994f, -0.01291351f, 0.11092683f, 
    0.09564642f, 0.04513350f, -0.03582291f, -0.04109854f, -0.21035162f, -0.00166126f, -0.01781742f, -0.10440888f, 
    -0.01808212f, -0.21486828f, -0.06915566f, 0.16656074f, 0.09684655f, -0.02776633f, -0.01355055f, -0.05885064f, 
    -0.01258282f, 0.01640680f, -0.02298321f, 0.05228699f, 0.18950589f, 0.04993553f, -0.02378670f, -0.13811332f, 
    -0.03179564f, -0.13131262f, -0.01924989f, 0.11953192f, 0.01772809f, 0.01208399f, 0.14246209f, 0.09122825f, 
    0.09144284f, -0.12695436f, -0.06751102f, 0.11856192f, -0.06402639f, -0.08425934f, 0.00411010f, -0.30429047f, 
    0.04439832f, -0.10796083f, 0.19600892f, 0.05906328f, -0.02023323f, -0.32646748f, 0.07822473f, -0.10328255f, 
    -0.19026259f, -0.07346157f, -0.15290990f, 0.05477068f, 0.06631964f, 0.11192485f, -0.10153368f, 0.02473880f, 
    0.15714338f, -0.01783946f, -0.00491305f, 0.02667396f, 0.08993021f, 0.04741930f, 0.09421293f, -0.17671795f, 
    0.18969215f, 0.26031393f, -0.14561050f, 0.04867756f, 0.01652273f, -0.01115311f, 0.00507040f, 0.18464722f, 
    0.03211961f, -0.02691458f, 0.02377704f, -0.03069060f, 0.03861654f, -0.00235989f, -0.01073173f, 0.00960387f, 
    0.03205931f, 0.02678243f, -0.04522603f, -0.04860829f, -0.04746018f, -0.03551982f, -0.04697267f, -0.06481509f, 
    -0.05517455f, -0.05017399f, -0.00423513f, -0.05404666f, -0.00004940f, 0.03964780f, 0.00455701f, 0.02344274f, 
    -0.00499029f, -0.01541698f, 0.04549935f, -0.04308943f, -0.00686384f, -0.01088648f, -0.00769435f, -0.00083207f, 
    -0.00209364f, -0.00356382f, -0.03438842f, 0.00727162f, 0.01861575f, -0.00679866f, -0.04628152f, -0.01200535f, 
    0.03315097f, -0.05623510f, -0.04456902f, 0.02224083f, -0.04651299f, 0.04365237f, 0.03059816f, -0.01888033f, 
    -0.06635225f, -0.04082972f, -0.05475293f, -0.02132476f, -0.04865260f, -0.00356326f, -0.03520033f, 0.02455973f, 
    0.03032410f, -0.00534648f, -0.00455572f, 0.02709800f, -0.05031227f, -0.01704096f, -0.00668761f, -0.02769462f, 
    -0.02419336f, -0.04673183f, 0.00262219f, 0.02290077f, -0.05110496f, 0.04143755f, 0.01800663f, -0.04097928f, 
    -0.02989397f, 0.02893213f, 0.00199240f, 0.04679585f, -0.00354004f, -0.00484242f, 0.02119643f, -0.04683885f, 
    -0.05611747f, 0.04465007f, -0.04480532f, 0.03999690f, 0.02991048f, 0.03293463f, -0.06004743f, -0.03266173f, 
    0.01024679f, 0.00836497f, 0.01204488f, 0.06335014f, -0.05005012f, 0.04729998f, -0.06381264f, 0.04102135f, 
    0.02380671f, 0.03194532f, -0.05950354f, -0.04781329f, -0.02036324f, -0.01263569f, 0.03197198f, -0.06904072f, 
    -0.04505575f, 0.02428181f, -0.03154447f, 0.02694693f, 0.05144946f, 0.02559002f, 0.03327042f, 0.02332133f, 
    -0.04276104f, 0.04993398f, -0.01483201f, -0.04014011f, 0.04208410f, 0.00237047f, 0.02279666f, -0.05617763f, 
    0.02573074f, 0.03800536f, -0.02989208f, -0.05315954f, 0.03134640f, 0.02145835f, -0.02927822f, 0.04461006f, 
    0.04570606f, 0.01275623f, -0.00910008f, -0.01429307f, 0.02327057f, -0.04591498f, 0.02437410f, -0.01362504f, 
    -0.03226690f, -0.05654914f, 0.04199384f, -0.05577661f, -0.02406456f, 0.03308589f, 0.02453285f, 0.03646460f, 
    -0.05075255f, 0.05789048f, 0.05060475f, 0.01387944f, 0.02912083f, -0.00674636f, 0.02438438f, 0.02925771f, 
    -0.05018001f, -0.00648851f, 0.03582762f, -0.05069250f, 0.01612687f, -0.00392153f, 0.02446632f, -0.02287744f, 
    -0.01469708f, -0.05854439f, 0.02041023f, -0.02600779f, -0.04905474f, 0.03125703f, -0.02306503f, 0.02819412f, 
    -0.06343058f, 0.01055782f, 0.02737090f, -0.00607835f, 0.05353921f, -0.05324292f, 0.00064515f, -0.01972939f, 
    -0.02479759f, 0.03438864f, 0.00145575f, -0.00982834f, 0.03510860f, 0.01364712f, 0.02890535f, -0.05322040f, 
    -0.04234234f, -0.06724922f, -0.02994837f, -0.00448721f, 0.00599994f, -0.03097457f, -0.00160734f, -0.01893917f, 
    -0.02019126f, 0.06270331f, 0.02843296f, 0.01011813f, 0.02643686f, 0.03377852f, -0.02790176f, -0.04538647f, 
    0.02188539f, -0.03145454f, -0.06378936f, -0.02578271f, 0.01413103f, -0.04555327f, 0.01555048f, -0.00037174f, 
    0.01826248f, 0.04797576f, -0.01397124f, -0.00941212f, -0.03387299f, 0.03082385f, 0.03584926f, -0.03355860f, 
    0.01389324f, -0.00218749f, -0.01771171f, -0.05274828f, 0.00076600f, -0.03306312f, -0.03994474f, 0.00799337f, 
    -0.03137760f, 0.02418914f, -0.06397025f, -0.01723528f, -0.03767608f, 0.03476601f, -0.05806614f, 0.01323374f, 
    -0.05769990f, -0.05859121f, -0.03868825f, 0.02764826f, -0.01774547f, 0.03462020f, 0.00149532f, -0.02946338f, 
    -0.06019478f, -0.06120740f, -0.05168601f, -0.03808821f, 0.04122575f, -0.03025308f, 0.02798151f, -0.00009287f, 
    -0.04634921f, 0.00764003f, -0.01769470f, -0.03333179f, 0.00408773f, 0.04124873f, -0.04276315f, 0.06675243f, 
    -0.03709797f, -0.05923450f, 0.05178360f, -0.00102218f, -0.04691026f, -0.03984743f, -0.01889484f, -0.00847252f, 
    -0.05868207f, -0.03779842f, 0.04047485f, 0.02547110f, 0.03862311f, 0.05326238f, -0.01080391f, 0.02065325f, 
    0.01924524f, -0.00007312f, -0.04822135f, 0.03304921f, -0.04324748f, -0.03620870f, -0.03079207f, -0.00260842f, 
    0.01397228f, 0.05356525f, 0.04366252f, -0.02640392f, -0.06086996f, 0.00325994f, -0.02230882f, 0.05528875f, 
    0.01510810f, -0.01428891f, -0.04604378f, -0.06023395f, -0.08116764f, -0.00568020f, -0.01537320f, 0.02110466f, 
    -0.02746091f, -0.02077859f, -0.07829879f, -0.05545119f, -0.04042634f, -0.00332195f, -0.00374906f, -0.03848436f, 
    -0.08190301f, -0.07773784f, 0.00606757f, -0.06829097f, 0.01007800f, -0.02953479f, -0.00498634f, -0.05537264f, 
    -0.04505511f, 0.01104425f, -0.07414728f, 0.01828373f, 0.01573110f, -0.01664972f, 0.00327520f, 0.01802312f, 
    -0.08957805f, -0.02408671f, -0.01358642f, 0.03753170f, -0.06760202f, -0.02896346f, -0.08193129f, -0.01625747f, 
    -0.00588857f, 0.00426750f, -0.00731641f, -0.08740541f, -0.01202821f, -0.07637101f, -0.09164437f, -0.00558266f, 
    -0.00523663f, -0.00820922f, 0.00684592f, -0.01718915f, -0.00997405f, 0.02484642f, 0.00931716f, 0.00728040f, 
    -0.08516118f, -0.00882788f, 0.00903471f, -0.03805101f, -0.02719125f, 0.01873353f, 0.00144812f, -0.09084626f, 
    -0.06208573f, -0.06745657f, -0.00221044f, -0.01524043f, -0.05760640f, 0.00191651f, -0.06550331f, 0.02283240f, 
    -0.03519398f, -0.08383146f, 0.02197245f, -0.06417908f, 0.04687528f, -0.04307431f, -0.08385193f, -0.04421039f, 
    -0.05864319f, -0.07124649f, -0.03165218f, -0.01529067f, -0.00289288f, -0.01799550f, -0.08177216f, 0.06914640f, 
    -0.01343033f, 0.04752153f, -0.07389087f, 0.02678052f, -0.01613702f, 0.02234021f, -0.02097758f, -0.04412900f, 
    0.06714314f, -0.00699583f, -0.04005607f, -0.02803051f, 0.04746446f, -0.01236120f, 0.01514405f, -0.04175677f, 
    -0.06487922f, 0.00068983f, -0.03870982f, -0.07815027f, -0.01648179f, 0.02766509f, -0.00196490f, 0.00897142f, 
    -0.01916081f, -0.05675238f, 0.01597334f, -0.01940585f, 0.01408972f, -0.06016775f, 0.01957088f, -0.00890125f, 
    -0.07273342f, -0.04446421f, -0.00991227f, -0.08797260f, 0.01627924f, -0.03165628f, 0.04310771f, 0.05209368f, 
    -0.09151896f, -0.00871707f, 0.00481375f, -0.01428578f, -0.01651176f, -0.06887454f, 0.01860714f, -0.07841994f, 
    0.00074134f, -0.08098792f, -0.05091089f, -0.09033374f, -0.08284157f, 0.01733890f, -0.07953802f, -0.00605744f, 
    0.00512337f, -0.08841202f, -0.00197265f, -0.02134526f, -0.00913662f, -0.06815871f, -0.07250390f, -0.03762702f, 
    -0.02173075f, -0.04096517f, -0.08776315f, -0.09302872f, 0.00044550f, -0.08363003f, -0.07601195f, 0.00626090f, 
    0.00312795f, -0.08851038f, -0.03440587f, -0.08002330f, 0.02274192f, -0.04146691f, -0.01835967f, 0.00348066f, 
    -0.01549416f, 0.00364657f, -0.04496790f, -0.02891287f, -0.08686946f, 0.01606043f, -0.03715606f, 0.08644114f, 
    0.08005080f, -0.06998296f, -0.02807436f, -0.07020696f, -0.02770947f, -0.04899717f, 0.01461624f, -0.02429938f, 
    0.02279730f, 0.02663592f, -0.00596983f, -0.03193710f, -0.08551876f, 0.04751030f, -0.04195849f, -0.04986334f, 
    0.04770004f, -0.02266211f, 0.02791801f, -0.08586502f, -0.06104914f, -0.07028235f, 0.00509805f, 0.03803282f, 
    -0.00176832f, -0.00824219f, -0.00116223f, -0.06817582f, -0.01595991f, -0.03349577f, -0.08423865f, -0.04747185f, 
    0.00941505f, 0.04208579f, -0.01324856f, 0.04221158f, 0.01083627f, -0.04761565f, -0.08486979f, -0.04307997f, 
    -0.08081789f, -0.05321132f, -0.05654530f, 0.00194683f, -0.03115588f, -0.01716306f, 0.06262615f, 0.02688341f, 
    0.06944909f, -0.06773815f, 0.03022437f, 0.03533560f, 0.05328315f, -0.02029647f, 0.01143118f, 0.01359110f, 
    -0.04749525f, -0.00304473f, 0.05320178f, 0.03018251f, -0.02166624f, -0.01740137f, 0.00876024f, -0.03625224f, 
    -0.06479753f, -0.01328697f, -0.04351164f, -0.03110878f, -0.08596548f, -0.03921070f, 0.01488549f, -0.00034425f, 
    -0.02152985f, 0.02242451f, 0.00653142f, 0.01615597f, -0.02900031f, 0.01164898f, -0.05649299f, -0.09165552f, 
    0.00665094f, -0.04066201f, -0.09204558f, -0.09107811f, -0.08256035f, -0.03716209f, -0.06313273f, -0.04932084f, 
    -0.06030010f, 0.01781384f, -0.03751299f, 0.02282541f, -0.04875316f, -0.02375805f, -0.02394195f, 0.03379074f, 
    -0.04530593f, -0.05335017f, 0.00355889f, 0.03084800f, 0.01399855f, -0.03872752f, -0.07831713f, -0.07711097f, 
    -0.01030341f, 0.00731218f, 0.00798553f, -0.07389034f, 0.02090708f, -0.03297526f, -0.04943690f, 0.01226254f, 
    -0.55751628f, 0.04920433f, -0.29823774f, 0.03550957f, -0.03017584f, -0.09079012f, 0.02467316f, 0.01201277f, 
    0.12499408f, 0.17834845f, 0.24601588f, 0.14192595f, -0.04431248f, 0.04329873f, 0.03344040f, 0.15167558f, 
    0.01918089f, 0.02088638f, -0.03317529f, 0.00205281f, -0.04188128f, -0.03860373f, -0.06358415f, -0.12602204f, 
    -0.15130797f, -0.04635661f, 0.20117345f, 0.04539426f, 0.07274999f, 0.10763496f, -0.11929256f, -0.08689602f, 
    -0.02214792f, -0.03113561f, -0.02863388f, 0.11347558f, 0.06231413f, 0.14305204f, 0.22511122f, 0.10122658f, 
    0.03746775f, 0.00722788f, -0.04859611f, 0.11618380f, 0.11026898f, 0.25792265f, -0.11170425f, -0.65038508f, 
    0.03806678f, 0.01835089f, 0.15231685f, 0.13694112f, -0.02176773f, -0.04514813f, -0.59095007f, -0.44411373f, 
    -0.37789211f, 0.14399187f, 0.02569307f, 0.06083304f, -0.00597483f, 0.08874970f, 0.12547962f, 0.16687231f, 
    -0.25661406f, -0.03053307f, 0.06556485f, 0.09663168f, 0.10344199f, 0.06126789f, -0.03949159f, 0.02043636f, 
    0.20068933f, 0.11630985f, -0.02934805f, -0.09588528f, 0.00323406f, -0.12864321f, -0.02318487f, 0.06730347f, 
    0.15399142f, -0.09173808f, 0.07265492f, 0.02890183f, -0.17246751f, -0.11787686f, -0.06132584f, 0.21669579f, 
    -0.08286234f, -0.05315991f, -0.01295692f, 0.22486147f, -0.31481674f, -0.00421610f, 0.04398985f, 0.14369512f, 
    0.11525693f, 0.05461265f, -0.04592356f, 0.21609694f, -0.09463883f, 0.08554057f, -0.01034529f, -0.06463989f, 
    0.00150814f, 0.11538079f, -0.16030030f, 0.05824677f, 0.32136407f, 0.24287423f, 0.14275555f, 0.09678727f, 
    -0.07012316f, -0.08656453f, -0.05751297f, 0.02250146f, -0.09331411f, 0.08082860f, -0.07096831f, 0.04513611f, 
    0.09363288f, 0.08917263f, 0.05863290f, 0.01251202f, 0.09684146f, 0.00999555f, -0.00406354f, -0.12419458f, 
    0.00280184f, 0.10325626f, 0.09425142f, 0.02164697f, 0.02502783f, -0.04366555f, 0.13086784f, 0.32907861f, 
    -0.22209013f, -0.20328468f, 0.02142308f, 0.10557257f, 0.15946794f, 0.11070117f, -0.02711444f, 0.12333193f, 
    0.24773838f, -0.27999017f, -0.22527047f, 0.04942979f, 0.15260871f, 0.10813526f, -0.02766789f, -0.04460053f, 
    -0.23660782f, 0.04674827f, 0.25300497f, -0.28369781f, -0.02500751f, 0.04543174f, 0.20017006f, 0.06764327f, 
    0.13281648f, -0.09968864f, -0.15342848f, -0.22087076f, -0.12505671f, 0.18547596f, 0.01388779f, 0.13231187f, 
    0.07728112f, 0.27256018f, -0.01217217f, 0.30440006f, -0.48352939f, -0.64440882f, 0.11892962f, -0.05921574f, 
    0.07250928f, 0.16064030f, 0.12748268f, -0.08538546f, -0.57892609f, -0.92515773f, -0.44329622f, -0.05089604f, 
    0.00296235f, 0.07646787f, 0.02812701f, 0.05291080f, 0.06444273f, 0.13517895f, 0.23976481f, 0.04203149f, 
    -0.22762962f, -0.23325899f, -0.18198097f, -0.10090718f, 0.03042081f, 0.15628640f, -0.01957464f, -0.37150013f, 
    -0.24849419f, -0.00178412f, -0.12310199f, 0.19869652f, 0.05342374f, 0.04744543f, 0.13306549f, -0.17931543f, 
    -0.15599360f, -0.55990982f, -0.20257021f, -0.19700420f, -0.06671773f, -0.03646511f, 0.05191010f, 0.03711600f, 
    -0.04811514f, 0.05148678f, 0.10336908f, -0.23482183f, -0.23572232f, -0.07639528f, 0.25252008f, 0.00189296f, 
    0.07593692f, -0.09701982f, -0.26954901f, -0.10572170f, -0.19499283f, 0.02455866f, -0.14773518f, -0.05843722f, 
    0.14733183f, 0.00406665f, -0.16502941f, -0.28793642f, -0.07914718f, -0.19717531f, -0.13102505f, -0.12331247f, 
    -0.06835752f, 0.08126451f, -0.07947636f, -0.22206239f, 0.05445352f, 0.02389763f, -0.10712489f, -0.11090726f, 
    -0.10172992f, 0.16081426f, -0.02860381f, -0.05998482f, 0.13338469f, -0.26956531f, -0.21829177f, -0.04027905f, 
    -0.05454893f, 0.16018823f, -0.04548160f, 0.21457151f, -0.14710332f, 0.05128662f, -0.14863370f, -0.15321943f, 
    -0.00972009f, -0.15570931f, -0.09743380f, 0.18758543f, 0.10767461f, -0.00465628f, 0.03665626f, -0.15528369f, 
    -0.17104197f, -0.22326127f, -0.05299123f, -0.06910995f, 0.10676274f, -0.01167857f, 0.12204447f, 0.29776859f, 
    0.01214883f, 0.04926456f, -0.06282966f, -0.08285787f, 0.00868091f, 0.08424271f, -0.01761005f, 0.11829428f, 
    -0.17749257f, 0.04620422f, 0.08109770f, 0.03683760f, -0.08853892f, -0.00658078f, 0.08354735f, 0.17592232f, 
    0.01523819f, 0.03323206f, 0.14193878f, 0.06180769f, 0.10725223f, -0.06029326f, 0.18835837f, -0.03705488f, 
    -0.03963463f, 0.07795513f, -0.05362183f, -0.05381038f, -0.02204478f, -0.13461038f, -0.12729108f, 0.29182360f, 
    -0.03639736f, -0.10609835f, -0.05309200f, -0.21468343f, -0.01989124f, -0.06434394f, 0.01189892f, 0.05749677f, 
    0.06091045f, 0.02736473f, -0.07768301f, -0.08096305f, -0.07366560f, 0.07883760f, -0.07324094f, 0.02726582f, 
    -0.09013060f, 0.06802731f, -0.10886741f, 0.01703986f, -0.07416465f, 0.01752971f, -0.26360410f, 0.05017147f, 
    -0.07481297f, 0.09151193f, 0.00451581f, -0.05958270f, 0.08327518f, -0.20198353f, 0.20718521f, -0.00593804f, 
    0.14981309f, 0.05776904f, 0.07749538f, 0.16032630f, -0.03186975f, -0.00279867f, 0.06623700f, -0.16080768f, 
    -0.03141618f, 0.23676303f, 0.02825162f, 0.03455888f, 0.03813252f, 0.03338313f, 0.12794644f, 0.05095084f, 
    -0.07114381f, -0.03667256f, -0.12523164f, 0.00545939f, 0.08923137f, 0.05622126f, 0.14993498f, 0.30976862f, 
    0.16486651f, -0.12810282f, 0.01466687f, -0.01085396f, 0.14991599f, 0.00349976f, 0.05963127f, -0.09268073f, 
    -0.03867641f, 0.02633987f, 0.08848398f, -0.30937871f, 0.10377342f, 0.02401793f, 0.08430741f, -0.04766404f, 
    0.10017748f, 0.18172815f, 0.17988585f, -0.16757810f, -0.10984072f, 0.12074009f, -0.08428059f, -0.10522123f, 
    -0.08864996f, -0.02411641f, -0.06355117f, -0.16548012f, -0.21433677f, -0.02961040f, 0.03313014f, 0.06764522f, 
    -0.04597840f, -0.06439938f, -0.05677624f, -0.09066861f, -0.06162231f, 0.04822000f, 0.06982366f, 0.33284849f, 
    0.10926844f, 0.10627286f, -0.06660545f, 0.04685973f, -0.01342194f, 0.09680212f, -0.07088123f, 0.11383487f, 
    0.15159969f, -0.05457688f, 0.02307330f, 0.05980190f, 0.02472836f, -0.00723634f, -0.24482162f, -0.05499103f, 
    0.08433191f, -0.04114706f, 0.04724329f, 0.21362197f, 0.03461676f, -0.05251990f, 0.13095561f, 0.07248133f, 
    -0.02484536f, -0.24359201f, -0.01309491f, -0.04964443f, 0.13393436f, -0.02449779f, 0.03065104f, 0.34466967f, 
    0.37879109f, 0.08942974f, -0.21003947f, 0.10713486f, 0.00858637f, 0.05592725f, 0.08040071f, 0.18597654f, 
    0.25373295f, 0.23212038f, 0.04392155f, 0.18696216f, 0.17840753f, -0.04021295f, 0.12798750f, 0.05516141f, 
    -0.09393255f, -0.22417939f, 0.24488476f, 0.00602941f, -0.10078324f, -0.14166345f, 0.06067047f, 0.03952366f, 
    0.12213860f, -0.20649810f, 0.05609938f, -0.06240812f, -0.13498479f, 0.20976126f, 0.12468090f, 0.21953739f, 
    0.01701782f, -0.00475319f, -0.00583711f, -0.00544981f, -0.03000991f, -0.17832956f, -0.17376068f, -0.33662421f, 
    -0.08754542f, 0.07026191f, -0.00776195f, 0.12539294f, 0.12588777f, 0.07232976f, 0.09808789f, 0.09741148f, 
    0.20370880f, -0.02720427f, -0.02547895f, -0.05578869f, 0.15533336f, 0.02639317f, 0.02442997f, -0.09937847f, 
    -0.20418935f, -0.29792261f, 0.08389579f, 0.15408003f, 0.02441762f, 0.27952430f, -0.04067795f, -0.14584422f, 
    -0.15147097f, -0.06475697f, -0.05388172f, 0.22147965f, 0.07152119f, -0.18391824f, -0.10680047f, -0.04892588f, 
    0.05047307f, -0.09170843f, -0.07294793f, 0.14992523f, 0.07268234f, 0.02940996f, -0.18588147f, 0.08593073f, 
    -0.06068654f, 0.08818698f, -0.10597849f, -0.22028773f, 0.02460208f, -0.02125148f, 0.05211248f, -0.05196914f, 
    0.15855020f, 0.13915280f, 0.02889617f, -0.03463778f, -0.12248249f, -0.05214975f, 0.02928287f, -0.03796177f, 
    -0.10968279f, -0.20217042f, 0.04076222f, 0.06438749f, -0.14553586f, 0.15228431f, -0.04318035f, 0.12330402f, 
    -0.02400817f, -0.05461715f, -0.07121054f, -0.10629688f, -0.19146572f, 0.19850549f, 0.05880446f, 0.00270544f, 
    -0.07701804f, 0.10668050f, 0.12480897f, -0.21493265f, -0.09352889f, -0.09911601f, -0.06145502f, -0.32511172f, 
    -0.04068402f, 0.09571681f, 0.06260165f, 0.03300321f, -0.06089322f, -0.17718317f, -0.18199427f, -0.01799386f, 
    0.17933433f, 0.03584324f, 0.00427955f, 0.04512380f, -0.08094041f, -0.13201003f, -0.07421797f, -0.12331002f, 
    0.20456247f, 0.04432086f, -0.56409568f, 0.04177393f, -0.33149302f, -0.09865944f, 0.21042623f, -0.11359471f, 
    0.14999780f, -0.04575060f, -0.07055701f, -0.42480248f, 0.06860319f, 0.00447817f, 0.10724743f, 0.03894340f, 
    -0.04469198f, 0.12231831f, -0.15396802f, -0.09197057f, 0.03314810f, -0.08713758f, -0.09436770f, 0.09501880f, 
    -0.06465661f, 0.08619576f, 0.09005192f, -0.08590128f, -0.11960904f, -0.10302190f, 0.01149058f, 0.04257774f, 
    -0.00937519f, 0.13037395f, 0.00823953f, 0.14410445f, 0.15012588f, -0.24482284f, -0.10627750f, 0.05684808f, 
    0.12175190f, -0.08475681f, 0.17984885f, 0.04802359f, 0.15378490f, 0.08400571f, -0.09185483f, 0.07148708f, 
    -0.05775298f, -0.03291950f, -0.07293984f, -0.05061951f, -0.08969885f, -0.04873167f, 0.16630983f, -0.12729269f, 
    -0.02903999f, -0.08601329f, 0.04319220f, 0.03530149f, 0.14176808f, -0.03050248f, -0.05125249f, -0.05141900f, 
    0.11800000f, -0.03764460f, -0.01825864f, 0.04031644f, -0.07020322f, 0.06820786f, -0.01780159f, 0.06685098f, 
    0.04747831f, 0.00876911f, -0.00031200f, 0.06452817f, -0.05810140f, 0.03702874f, 0.01972148f, 0.05864343f, 
    0.02346279f, 0.01993703f, -0.07260375f, -0.01746869f, 0.02815209f, -0.03259838f, -0.19005044f, 0.15725829f, 
    0.12543496f, -0.04034607f, -0.17374536f, 0.03445056f, 0.07107394f, 0.03389708f, -0.21925360f, -0.08360706f, 
    0.21368513f, 0.11931438f, -0.06535676f, -0.05558677f, 0.17453329f, 0.10905611f, 0.06226057f, 0.17120425f, 
    0.15119243f, 0.02385073f, -0.00182106f, 0.02416070f, -0.47336745f, -0.61751425f, 0.10075407f, -0.06640954f, 
    0.01713942f, 0.15045899f, 0.12573685f, 0.01455543f, -0.12329285f, 0.01194769f, 0.02692680f, 0.09690572f, 
    0.03191263f, 0.13279861f, 0.03340076f, 0.12322077f, 0.05200937f, 0.04674166f, 0.15675303f, 0.08376162f, 
    0.09045701f, -0.08458146f, -0.02499256f, -0.01922451f, 0.06789831f, -0.00827152f, 0.05404117f, -0.02475083f, 
    0.12222204f, -0.08377992f, 0.01846727f, 0.01709848f, 0.03641113f, 0.17183025f, -0.05209176f, 0.11330576f, 
    -0.01484949f, 0.10550813f, 0.00757675f, -0.16540325f, 0.07474112f, -0.00849042f, -0.11407420f, -0.06593797f, 
    0.09764970f, 0.01583238f, 0.15363538f, 0.24360947f, 0.08858060f, 0.00590246f, -0.10335223f, 0.09543978f, 
    -0.03194690f, 0.04357802f, -0.08713052f, 0.02633807f, -0.15919535f, -0.09073313f, -0.08588725f, 0.11087150f, 
    0.15987504f, 0.14372414f, 0.11235233f, -0.02805574f, -0.20557050f, -0.16426851f, -0.05294679f, -0.11804877f, 
    0.06060534f, -0.05428455f, -0.02495523f, 0.07460839f, 0.31649566f, -0.12930681f, 0.39873701f, 0.13715847f, 
    0.15189959f, -0.12605602f, 0.07859397f, -0.10881028f, -0.02694361f, -0.06355537f, 0.06299090f, 0.21605469f, 
    0.02688339f, -0.04479603f, 0.03795616f, 0.13769744f, -0.01341655f, -0.01181256f, 0.03582942f, -0.02190701f, 
    0.18486506f, -0.04502065f, 0.05280158f, -0.01640896f, -0.00189927f, -0.02599037f, 0.08148398f, 0.06336419f, 
    -0.04011076f, 0.17885107f, 0.00357996f, 0.02358252f, 0.10121021f, 0.07046509f, 0.03639506f, 0.03100486f, 
    -0.00248451f, -0.06956659f, -0.07950521f, -0.00649322f, -0.00653144f, -0.17353615f, 0.20185009f, 0.07432075f, 
    -0.05106519f, -0.11053151f, -0.02929291f, 0.18895875f, 0.00127382f, 0.04306920f, -0.00132115f, -0.03591964f, 
    -0.02178665f, -0.07882603f, -0.01155749f, 0.00364249f, 0.16743223f, 0.05684119f, 0.14858669f, 0.02468316f, 
    -0.04206529f, 0.09919505f, -0.07527931f, 0.04811748f, -0.11115633f, -0.23714346f, -0.04458767f, -0.14213185f, 
    0.02406760f, 0.09641860f, 0.07567167f, -0.02816408f, 0.16558845f, -0.13467947f, -0.04874051f, -0.11086095f, 
    0.09821625f, -0.06563629f, 0.06931962f, 0.18420036f, 0.06859761f, 0.05896688f, -0.14893949f, -0.02407838f, 
    -0.00253286f, -0.13611829f, -0.17104866f, 0.16111390f, -0.10383399f, 0.04290113f, -0.15981421f, 0.15909210f, 
    0.19402480f, 0.11023142f, -0.02475424f, 0.09341760f, 0.06674587f, 0.11299175f, 0.13433330f, -0.14817679f, 
    0.20953760f, 0.33595365f, 0.03751203f, 0.22449288f, 0.09691926f, 0.20650153f, 0.03404780f, 0.14577235f, 
    0.02693878f, -0.02695572f, 0.02637245f, -0.05662268f, -0.00170852f, -0.00854119f, -0.05977210f, -0.04185406f, 
    0.01773317f, -0.04252881f, 0.00629676f, 0.00924672f, 0.03016069f, 0.01109201f, -0.01977840f, -0.02058408f, 
    -0.05015443f, -0.03336388f, 0.04799511f, -0.05030613f, 0.03498993f, 0.02885777f, -0.01852150f, 0.02732711f, 
    0.04896513f, -0.03842883f, -0.02193244f, -0.01848898f, -0.00088703f, -0.02461770f, -0.06049718f, -0.05437171f, 
    0.00841838f, -0.02468773f, 0.02959036f, -0.03661407f, -0.03775021f, -0.04872084f, -0.03201723f, -0.00796380f, 
    -0.01656193f, 0.04332583f, 0.00787718f, 0.00051561f, -0.04764457f, 0.02102694f, -0.01484604f, -0.05286835f, 
    0.01439510f, -0.03365199f, -0.04586401f, -0.03533142f, 0.02156327f, -0.00068236f, -0.04848665f, -0.04987163f, 
    -0.03673477f, -0.03688195f, -0.04426771f, -0.04961400f, -0.06211162f, -0.01552329f, -0.02886111f, -0.06723727f, 
    0.03361001f, -0.01353770f, 0.04811195f, 0.02805590f, -0.04175197f, -0.03805621f, -0.03865959f, 0.03096005f, 
    -0.02185971f, -0.03501487f, -0.02800923f, 0.04350844f, -0.01651904f, -0.02225115f, 0.04404446f, 0.03596807f, 
    -0.04953822f, -0.03890119f, -0.01820356f, -0.04403760f, -0.06354162f, -0.03194015f, -0.01190097f, 0.01012444f, 
    0.00764596f, -0.02517754f, -0.04424612f, 0.03324775f, -0.02692511f, 0.01533812f, -0.02963415f, 0.04505098f, 
    -0.03668915f, -0.06164693f, 0.01895580f, -0.04765916f, 0.00050366f, 0.04380265f, 0.01304709f, 0.02333101f, 
    0.04000729f, 0.00341932f, -0.01536701f, -0.01409066f, 0.04156023f, 0.01968138f, -0.04601319f, -0.04410107f, 
    -0.03541987f, 0.01720101f, -0.02679489f, -0.03789179f, -0.01689458f, -0.02373859f, 0.01570503f, 0.04063668f, 
    0.00576519f, -0.06476486f, 0.04147154f, -0.05872051f, 0.03440924f, -0.00693698f, -0.03709391f, -0.01350594f, 
    -0.04405224f, 0.00127573f, -0.01936189f, -0.05473772f, 0.01359701f, 0.02303839f, 0.01527835f, 0.04215730f, 
    0.03059273f, -0.03990788f, -0.02958244f, 0.04431663f, -0.05813115f, -0.02297894f, 0.04831339f, -0.05611908f, 
    -0.00617360f, -0.03301767f, -0.02875990f, 0.02415038f, -0.01114358f, -0.00088758f, 0.01675253f, -0.01717155f, 
    0.00307281f, -0.04166369f, 0.03117132f, -0.01978199f, 0.00332234f, -0.06135490f, -0.00474153f, -0.03800195f, 
    0.03958684f, 0.00699767f, -0.04180373f, -0.03252636f, 0.03402261f, -0.05276449f, 0.04685461f, -0.04670702f, 
    0.01561210f, 0.01270033f, 0.03806584f, 0.03442790f, -0.02571006f, 0.00640099f, -0.04602699f, 0.01441549f, 
    -0.02521383f, -0.04565081f, -0.04835167f, -0.03676642f, -0.02479244f, -0.02747335f, -0.06479870f, -0.02499666f, 
    -0.04191509f, -0.05370839f, -0.02847541f, 0.02209876f, 0.00373697f, 0.01575186f, -0.04072258f, -0.05552944f, 
    -0.01140136f, 0.01460956f, -0.03286802f, 0.02785484f, 0.02626590f, 0.01926565f, -0.00256615f, -0.06981371f, 
    -0.00239043f, -0.00323574f, -0.00687387f, 0.03396382f, -0.04035615f, -0.01327694f, 0.02605547f, -0.04161068f, 
    -0.04618796f, -0.05352841f, 0.04282619f, 0.02531589f, 0.04567026f, 0.03548411f, 0.01075658f, 0.03070226f, 
    -0.03522544f, 0.01142679f, 0.03947094f, 0.00507909f, -0.01144806f, -0.06337281f, 0.04579150f, -0.00178061f, 
    -0.05429648f, 0.00393626f, -0.02830130f, -0.02556033f, -0.01001862f, 0.02046437f, -0.02870942f, 0.04728038f, 
    -0.06097467f, 0.01725891f, 0.04102297f, -0.05734608f, 0.05288517f, 0.03863426f, -0.04691064f, 0.03710690f, 
    0.00582146f, -0.03328190f, 0.04079204f, -0.04266193f, 0.02399230f, -0.00835397f, -0.05964081f, -0.04412432f, 
    0.04764853f, 0.04769266f, -0.01229624f, -0.03373589f, -0.03245206f, 0.04843367f, -0.04994950f, -0.00644249f, 
    -0.06471265f, -0.02986728f, 0.01906583f, 0.02077370f, -0.00504088f, -0.03189873f, -0.00340363f, 0.01577113f, 
    -0.00359383f, 0.04848240f, -0.00981703f, -0.01571574f, -0.05533756f, 0.04875417f, -0.06641894f, -0.01904337f, 
    0.02651161f, -0.04961829f, -0.03581642f, -0.01900705f, -0.01409173f, -0.03516037f, -0.05815289f, -0.03357269f, 
    0.02177931f, -0.05701143f, -0.06084937f, -0.01661974f, -0.05665348f, -0.05632772f, -0.03624018f, 0.04515541f, 
    0.09176565f, -0.39546734f, -0.03804671f, 0.17456627f, -0.02689069f, -0.04195349f, 0.15358178f, 0.03443826f, 
    0.16670950f, -0.00538850f, -0.11725295f, -0.00540674f, 0.21253549f, -0.01130872f, -0.02279350f, -0.03415396f, 
    0.00411489f, -0.21587844f, -0.01224281f, -0.13358064f, -0.14590275f, -0.38944975f, 0.11065212f, -0.14105222f, 
    -0.10912523f, -0.02616262f, -0.15748413f, -0.01634140f, -0.09400331f, -0.11131876f, -0.21192160f, 0.13895243f, 
    -0.18461558f, -0.04383657f, 0.08438419f, -0.18024550f, 0.15091215f, 0.21194910f, -0.03192286f, -0.06449877f, 
    -0.06268141f, -0.01645595f, 0.00801006f, -0.01183660f, -0.09246302f, 0.21576016f, -0.65335840f, -0.46808383f, 
    0.01256414f, 0.05918074f, 0.00807917f, -0.02841897f, 0.01315093f, 0.06412507f, 0.30001065f, -0.19571552f, 
    0.12239348f, 0.18105240f, 0.00811324f, 0.08412313f, -0.01094417f, -0.07345358f, 0.13452682f, -0.17253120f, 
    -0.33854723f, -0.09089816f, -0.08379195f, 0.02104162f, -0.05117489f, 0.03448832f, -0.09858613f, -0.00874380f, 
    -0.04712125f, 0.07999042f, 0.10224172f, 0.07583921f, -0.02780061f, 0.14277658f, 0.22233509f, 0.11116702f, 
    0.11852778f, -0.03828973f, -0.21112716f, -0.16881157f, 0.21269855f, -0.01995982f, -0.13983466f, -0.02603993f, 
    0.02964692f, 0.06232526f, -0.02267542f, -0.33708170f, -0.26289570f, -0.04373860f, -0.08366591f, 0.05112841f, 
    0.01864629f, 0.19245322f, 0.05962142f, -0.14877659f, 0.02269547f, 0.08170650f, 0.09496895f, -0.05113867f, 
    -0.03988032f, -0.03839250f, 0.02693571f, -0.23056033f, 0.02911587f, -0.01753910f, -0.03270493f, 0.05770863f, 
    -0.19210011f, -0.08759890f, 0.01465749f, -0.02116477f, -0.03926893f, 0.05468133f, -0.07412763f, 0.05837734f, 
    0.00695971f, 0.00953727f, 0.09895019f, 0.11367954f, -0.04722948f, -0.00888371f, -0.02267598f, -0.39222041f, 
    -0.22179227f, -0.01107843f, 0.06770054f, -0.00259367f, -0.04191817f, -0.09821810f, 0.05608935f, -0.00541977f, 
    -0.03875052f, -0.10697052f, -0.12173272f, 0.13865705f, -0.12010556f, 0.15371402f, 0.16922665f, 0.03120698f, 
    -0.26448715f, -0.14025280f, -0.45300803f, -0.00217146f, 0.14029509f, -0.18470924f, 0.16704762f, 0.10554434f, 
    -0.08922753f, 0.18693738f, -0.09652563f, -0.18356071f, -0.16543488f, 0.01869591f, 0.10765392f, 0.12209756f, 
    0.13842086f, 0.08466160f, 0.01145577f, 0.12704526f, 0.02086496f, 0.00876091f, 0.07756642f, 0.11654323f, 
    0.20183209f, -0.20086426f, 0.02870226f, -0.18552293f, -0.26473856f, -0.28868642f, 0.16726409f, -0.02757331f, 
    0.13158543f, -0.01536578f, 0.08833861f, -0.22182514f, -0.09171817f, 0.32528022f, -0.08036944f, 0.07586382f, 
    -0.10566716f, -0.10811443f, 0.16356127f, -0.21694106f, -0.04905197f, -0.10130850f, 0.08205262f, 0.02882744f, 
    -0.06393242f, -0.18215711f, 0.18254954f, 0.07905978f, 0.09042983f, -0.00016496f, 0.07973392f, -0.01061515f, 
    0.05860562f, 0.00532300f, -0.05488069f, 0.08493697f, -0.00199361f, 0.00574259f, 0.03939435f, 0.03384863f, 
    -0.07549716f, -0.08560133f, 0.18635491f, 0.04719551f, -0.01083157f, 0.12510444f, 0.03477811f, -0.16283017f, 
    -0.18134215f, -0.12666532f, -0.08896884f, 0.14340012f, 0.07782429f, -0.08169384f, 0.07940660f, 0.18093985f, 
    0.06589959f, 0.00226778f, 0.15045729f, 0.10812754f, -0.09696393f, 0.04366997f, 0.02384836f, 0.13751425f, 
    0.02026260f, 0.16809422f, -0.13060744f, 0.17161782f, 0.10123041f, 0.08301146f, -0.07026460f, 0.01770356f, 
    0.09813979f, 0.00271289f, 0.13389653f, -0.20984437f, -0.14450325f, 0.02112090f, 0.29163066f, -0.10831130f, 
    -0.08811446f, 0.02802883f, 0.01637663f, 0.12311575f, 0.25611886f, 0.08782506f, -0.07213781f, 0.00730699f, 
    -0.19480409f, 0.05927930f, -0.07659095f, -0.02376612f, -0.08978318f, -0.16872340f, -0.29992872f, -0.58645719f, 
    0.11991651f, 0.15714602f, 0.04130315f, 0.06686737f, -0.20230445f, 0.06731986f, -0.30641389f, -0.11498646f, 
    0.11898801f, 0.12787244f, -0.01745801f, -0.03244036f, -0.04275902f, -0.09075027f, -0.30055743f, -0.03053197f, 
    0.20795186f, 0.05128299f, -0.16509795f, 0.11837158f, -0.02424959f, -0.10778038f, 0.00312045f, -0.13565864f, 
    -0.06562986f, 0.16021557f, -0.06420693f, 0.02660374f, 0.04590081f, 0.14412549f, 0.05189157f, -0.06155735f, 
    -0.07658812f, 0.03125728f, 0.05506788f, -0.08261174f, -0.02264966f, 0.10273063f, -0.04793052f, 0.04336122f, 
    0.13605085f, -0.21091388f, 0.08414318f, 0.00254892f, -0.02001315f, -0.03559175f, 0.12912036f, -0.08178816f, 
    -0.01282464f, -0.01914755f, -0.27071309f, 0.21065702f, -0.02434925f, 0.12139813f, -0.08472744f, 0.25978166f, 
    -0.00737063f, 0.11301885f, 0.01333312f, -0.06057171f, -0.03599548f, -0.06371998f, 0.12717912f, -0.13014960f, 
    0.07243654f, 0.01369021f, 0.09254203f, 0.01612017f, 0.13777594f, -0.01312339f, 0.32067877f, 0.17950337f, 
    -0.02285591f, -0.21526550f, 0.05355487f, -0.07469998f, 0.08582320f, -0.00024651f, -0.08426032f, 0.27176812f, 
    0.14144759f, 0.09278858f, 0.05331222f, -0.04761831f, 0.05659790f, 0.03419859f, -0.02121209f, 0.12879553f, 
    0.00861124f, -0.11938085f, -0.14523964f, -0.09313129f, -0.00172281f, -0.07071345f, 0.08816493f, -0.31311870f, 
    0.03354790f, -0.09946176f, -0.11911798f, 0.03268199f, 0.00036213f, 0.01312540f, -0.12996472f, -0.13029587f, 
    -0.20774786f, -0.12884457f, 0.01844233f, 0.06416830f, 0.00708880f, 0.07269119f, 0.01247406f, -0.19160073f, 
    -0.12708297f, -0.08452271f, -0.15496157f, 0.16577476f, 0.02067083f, 0.09772511f, 0.00003298f, -0.11176252f, 
    -0.24502255f, -0.19683084f, -0.25284532f, 0.13077307f, -0.01756345f, -0.09354044f, 0.04197354f, -0.01557486f, 
    0.12029925f, -0.01258082f, 0.03994394f, 0.37946934f, 0.13463588f, -0.02376288f, 0.06301049f, -0.14207584f, 
    0.07085259f, -0.00421444f, -0.24892978f, -0.01914468f, -0.26632482f, -0.00169119f, -0.01634393f, -0.01213127f, 
    -0.02068043f, 0.01152511f, 0.04290829f, -0.05424264f, -0.00009470f, -0.11064104f, -0.02741897f, 0.14367853f, 
    0.01444149f, -0.14356485f, 0.05563258f, -0.08577713f, 0.13601458f, -0.07743245f, -0.05880665f, 0.21525714f, 
    0.10184869f, 0.05413311f, -0.01756584f, -0.15948299f, 0.24880737f, -0.05906124f, 0.10186596f, -0.14465851f, 
    0.07601812f, 0.18492383f, -0.17271216f, 0.13563764f, 0.06824484f, 0.02090890f, -0.08500180f, 0.06233185f, 
    -0.31715894f, 0.09460088f, 0.11659114f, 0.01385446f, 0.17987418f, -0.13086642f, 0.00738452f, -0.01935727f, 
    -0.01972764f, -0.22960052f, 0.29684049f, 0.22753273f, 0.11135601f, -0.09535568f, 0.18034597f, -0.13096099f, 
    -0.09036928f, 0.13155401f, -0.07081299f, 0.15533382f, 0.28904659f, 0.16264534f, -0.13366194f, -0.21325624f, 
    0.07981103f, 0.04455348f, 0.17674579f, -0.04676285f, 0.19463184f, 0.01514695f, 0.16751213f, 0.25810876f, 
    0.06132919f, 0.12699986f, -0.01493186f, 0.09699382f, 0.24578252f, -0.01992811f, -0.17706434f, -0.14741509f, 
    0.03312953f, 0.07426062f, -0.00665357f, -0.11734545f, -0.03670903f, -0.06966393f, 0.01813500f, 0.02484237f, 
    0.02569372f, 0.04148714f, -0.06435704f, 0.07372142f, 0.17985703f, 0.21296164f, 0.21420291f, -0.02243235f, 
    0.04714112f, 0.16680437f, 0.05279831f, -0.04637707f, 0.06253002f, -0.02091329f, -0.10844933f, -0.00069384f, 
    -0.04472681f, -0.19174638f, -0.00109836f, 0.03044084f, -0.02566817f, -0.07758701f, -0.08280264f, -0.30032253f, 
    -0.21135658f, 0.03752234f, -0.10397129f, 0.01527051f, 0.02112953f, -0.06104355f, -0.01224173f, 0.07591762f, 
    -0.08604204f, 0.11615467f, 0.12972891f, -0.07097248f, -0.10214761f, 0.00226906f, 0.05047238f, -0.15894201f, 
    0.05396311f, -0.02736407f, -0.00623642f, 0.03276485f, -0.01564036f, 0.06425050f, -0.11022066f, 0.03256213f, 
    -0.01182739f, 0.04457713f, -0.03082157f, -0.42911622f, -0.12046918f, -0.19629702f, 0.19670714f, 0.02227542f, 
    0.22219570f, 0.07256845f, 0.20796390f, 0.30368373f, 0.14057025f, 0.08503709f, 0.07908988f, -0.07002832f, 
    0.00810826f, -0.04917647f, 0.24229379f, 0.14694268f, 0.11216201f, -0.10818800f, 0.09070697f, 0.18238229f, 
    -0.09574340f, -0.02048872f, 0.00942712f, 0.12933610f, 0.05233765f, 0.14550146f, 0.37529707f, 0.01892803f, 
    0.08418053f, -0.05977122f, 0.03412810f, 0.16125068f, 0.12163643f, -0.05615152f, 0.27521303f, 0.19435263f, 
    -0.37972182f, 0.09860767f, 0.05078977f, 0.01886138f, -0.29661560f, 0.03800706f, -0.32280281f, -0.09828686f, 
    -0.05143566f, -0.00678954f, 0.15843712f, 0.14956583f, -0.04686856f, -0.08602987f, 0.05445974f, 0.06646123f, 
    0.05020049f, -0.04425924f, 0.15271948f, 0.11962650f, 0.18072093f, -0.02381139f, 0.02233811f, 0.08912415f, 
    -0.03184743f, -0.00170346f, 0.07852474f, 0.04300926f, 0.04597016f, 0.22365016f, -0.05856718f, -0.00993326f, 
    -0.03477877f, -0.05509343f, 0.15597577f, 0.12266534f, 0.06131016f, -0.03379891f, 0.02344373f, -0.08611093f, 
    -0.06958754f, 0.00971216f, -0.13022161f, -0.18900642f, 0.02803697f, -0.03868404f, -0.08313524f, -0.01299102f, 
    0.02811091f, 0.31768999f, 0.09124563f, 0.07768923f, -0.00740877f, 0.10086533f, -0.10954653f, -0.02102249f, 
    0.08184414f, -0.17823051f, 0.16704571f, 0.05804152f, -0.07343191f, 0.08270371f, -0.11020792f, 0.01113703f, 
    -0.06582063f, 0.13310063f, 0.06510596f, 0.17015839f, 0.10217895f, 0.00053600f, 0.00693358f, 0.04563547f, 
    0.05814725f, -0.03798655f, -0.14839937f, -0.15405175f, -0.05411006f, -0.33037522f, -0.12026650f, -0.04157569f, 
    0.03300091f, 0.00675669f, 0.18477109f, 0.22437091f, 0.04910787f, 0.04557357f, 0.05117204f, 0.06719590f, 
    0.02938233f, -0.18114279f, -0.02553897f, 0.19122893f, 0.07565639f, 0.22612022f, -0.05785023f, 0.08342413f, 
    -0.14640878f, 0.06942225f, -0.04731202f, -0.07859275f, 0.03070228f, -0.09739415f, -0.18581574f, -0.05778278f, 
    -0.18561569f, 0.08473518f, 0.18845665f, 0.08466941f, -0.11046977f, 0.25096166f, 0.37334093f, -0.01720141f, 
    0.07284081f, -0.16837120f, 0.01695505f, 0.15704428f, -0.13563681f, 0.15707582f, 0.08914538f, 0.19578266f, 
    0.03073308f, 0.00367536f, 0.07795449f, -0.03427823f, -0.02395211f, -0.11543575f, 0.15790640f, 0.04008506f, 
    -0.00337464f, 0.16501157f, 0.18984045f, 0.06094744f, 0.00533766f, -0.01381859f, 0.08393753f, -0.11131019f, 
    -0.16254219f, -0.16936679f, 0.00602080f, 0.01374174f, -0.02903461f, -0.02250250f, -0.00197412f, -0.16794324f, 
    0.02728140f, 0.04158092f, 0.05691214f, 0.12789162f, 0.09638749f, 0.00755936f, 0.04612038f, -0.04595565f, 
    -0.08893923f, -0.03675968f, 0.07741003f, -0.01260339f, 0.04891456f, -0.15482190f, 0.07567230f, -0.08880051f, 
    -0.15109228f, -0.09008843f, -0.04495734f, 0.01786995f, 0.19602805f, -0.15990387f, -0.05773081f, -0.02322669f, 
    0.09397859f, 0.02488770f, 0.07328541f, -0.20354925f, -0.23557587f, -0.04779595f, 0.07274453f, 0.34565154f, 
    0.07097450f, 0.06374664f, 0.01284840f, 0.05236318f, -0.64529777f, -0.23613361f, -0.49013051f, -0.33000678f, 
    -0.09971135f, -0.40735063f, -0.00037460f, 0.05740853f, -0.08534577f, -0.18270527f, 0.10382498f, -0.17455153f, 
    -0.11251251f, -0.19615388f, -0.23737082f, -0.01423956f, 0.06182544f, 0.06808847f, 0.01731272f, -0.09312330f, 
    -0.04629108f, -0.08765084f, -0.11236387f, -0.19693810f, 0.05007268f, -0.00904421f, -0.10334431f, 0.19305435f, 
    -0.14074440f, -0.36226639f, -0.49362028f, -0.38160864f, -0.53730208f, -0.01024797f, 0.11414967f, 0.01595477f, 
    0.00571578f, 0.14962380f, 0.18812490f, 0.02954279f, 0.01272644f, 0.05035232f, 0.11047134f, 0.16113885f, 
    0.10766505f, -0.18305551f, -0.26632553f, -0.24429286f, -0.25075194f, -0.08366275f, -0.21391957f, 0.13374864f, 
    0.08415677f, 0.04982793f, 0.04011339f, -0.17891717f, -0.15210067f, -0.23208697f, -0.05416710f, -0.34360388f, 
    0.03979788f, 0.02318886f, 0.03125636f, -0.00451921f, 0.11402147f, 0.31566787f, 0.00035650f, 0.12256470f, 
    0.07624459f, -0.04581112f, -0.10342287f, -0.00734042f, 0.12978856f, -0.15210588f, -0.06133322f, -0.18908277f, 
    0.01338089f, -0.13257547f, -0.05417110f, 0.13365166f, -0.07660799f, 0.16748317f, 0.08709203f, 0.09480917f, 
    -0.03015680f, 0.12337147f, 0.03437745f, -0.07381984f, -0.06042323f, -0.04170560f, -0.26374224f, 0.04708593f, 
    0.10785722f, -0.02720312f, -0.00128304f, -0.05895754f, 0.14555417f, 0.13104497f, 0.03753611f, -0.12346818f, 
    0.10455455f, -0.06024301f, 0.06690680f, -0.26429620f, -0.39727145f, 0.17143369f, -0.09555124f, -0.09543552f, 
    0.20003434f, 0.12008380f, -0.10366263f, 0.16769178f, -0.13906783f, -0.26499680f, 0.05426163f, 0.02384591f, 
    0.27256426f, 0.00883726f, -0.05185189f, -0.08256292f, 0.06801851f, 0.17264013f, -0.01470032f, 0.12314089f, 
    -0.04024096f, -0.08424746f, -0.18252391f, -0.06557858f, -0.00309948f, -0.19630061f, 0.07219344f, 0.06768447f, 
    -0.11422797f, 0.01395788f, -0.04739926f, -0.16237323f, -0.08697687f, 0.01475399f, 0.05378653f, -0.06456956f, 
    0.07754645f, 0.18412955f, -0.03570824f, -0.17066820f, -0.00896489f, 0.02882882f, 0.05297770f, 0.15782601f, 
    0.12407029f, -0.04254584f, -0.01024163f, -0.08310042f, -0.17945565f, -0.19799562f, -0.10863718f, 0.09884489f, 
    -0.06834381f, 0.11072288f, -0.08272835f, -0.08911806f, -0.04986879f, -0.14530174f, 0.11632853f, 0.08943705f, 
    -0.20936435f, 0.00760360f, 0.05715792f, 0.14470151f, 0.04645391f, -0.32852748f, -0.07066116f, -0.11097658f, 
    -0.03191888f, -0.15398419f, -0.06786630f, 0.03764249f, 0.01221550f, -0.10205857f, 0.08881930f, -0.23865095f, 
    0.10606843f, 0.12984087f, 0.05007657f, 0.00332991f, -0.09605271f, 0.02489540f, 0.07682687f, 0.07348843f, 
    0.17123725f, -0.06165590f, 0.12236978f, 0.06908715f, 0.07692423f, -0.01434401f, -0.13544914f, -0.09211597f, 
    0.10317326f, 0.08578649f, 0.00493403f, -0.03730663f, 0.03223503f, -0.01894290f, -0.05137713f, -0.11122946f, 
    -0.09858464f, 0.27080646f, 0.03159325f, -0.10383911f, -0.09041613f, 0.09148209f, -0.07934798f, 0.03395804f, 
    -0.03108960f, 0.01264103f, 0.13879418f, 0.06340271f, -0.15177079f, 0.02663459f, 0.14529559f, 0.11047946f, 
    -0.03184292f, -0.15660244f, -0.01991292f, -0.11132341f, 0.06051992f, -0.16042779f, 0.07256585f, -0.07353670f, 
    0.02736655f, 0.06315381f, 0.01080575f, -0.06671239f, 0.14339374f, 0.04957210f, -0.21223058f, -0.06634188f, 
    -0.13444957f, -0.12527139f, 0.00994577f, 0.03890602f, -0.06245701f, -0.07767300f, -0.16161053f, -0.09907659f, 
    0.17826934f, 0.22710128f, 0.03150530f, -0.05903802f, 0.16646475f, 0.05901475f, 0.23187143f, 0.00998585f, 
    -0.10269602f, 0.10962696f, -0.18290970f, 0.11148480f, 0.01168768f, 0.03412565f, -0.00824468f, -0.00174673f, 
    0.04733216f, 0.01719823f, 0.08061363f, -0.09997401f, 0.13358659f, -0.08762533f, -0.01563425f, 0.02015930f, 
    0.20973885f, -0.04638780f, 0.08031446f, 0.04005186f, 0.05556687f, -0.02509712f, 0.06422623f, 0.03933779f, 
    -0.10288092f, 0.11582585f, 0.02493153f, -0.19157258f, -0.11783371f, -0.08096678f, -0.03685154f, 0.15480164f, 
    -0.05479094f, -0.07974149f, 0.03290581f, -0.07000215f, -0.06217176f, 0.39740288f, 0.48497587f, 0.26658538f, 
    -0.02823964f, -0.04894295f, -0.11242510f, 0.14869866f, -0.00393736f, -0.09395758f, -0.14762002f, 0.10511950f, 
    -0.06993576f, 0.00435660f, 0.02151128f, 0.06240707f, 0.02743228f, 0.14853288f, 0.15062433f, 0.14393197f, 
    0.12971535f, 0.04283305f, -0.11481827f, 0.10368520f, 0.10469670f, 0.06736038f, 0.00636819f, -0.21007557f, 
    -0.22310975f, 0.16902080f, -0.01855353f, -0.02828669f, 0.04968502f, -0.01146313f, 0.16543411f, 0.20779067f, 
    -0.15747289f, 0.04702364f, -0.10535452f, 0.01501315f, 0.11211482f, -0.18408306f, -0.06261829f, 0.03400936f, 
    -0.06609656f, -0.10579088f, 0.14290141f, 0.08591212f, 0.08576758f, -0.00020820f, 0.04959830f, 0.02220457f, 
    0.06498383f, 0.04714153f, -0.22639956f, -0.07234634f, 0.16057293f, -0.04906496f, -0.03618796f, 0.10046519f, 
    0.00487197f, 0.12230292f, 0.15827623f, -0.17953828f, 0.00583522f, -0.20315047f, 0.08757843f, 0.08922721f, 
    -0.20948708f, -0.03285629f, 0.00300011f, 0.05676446f, -0.01975230f, 0.10623246f, 0.05955746f, 0.06960246f, 
    -0.06799385f, 0.02370814f, 0.10751703f, 0.10482301f, -0.18195112f, -0.02669503f, -0.03791273f, -0.21774915f, 
    -0.09549425f, 0.08096149f, 0.03384504f, -0.01105085f, -0.09222610f, -0.02094689f, -0.11940316f, -0.10715432f, 
    0.13849802f, 0.04878065f, 0.03556194f, -0.05187146f, -0.03110059f, 0.12187421f, -0.12231003f, 0.09842063f, 
    0.08390179f, 0.35619605f, -0.02159315f, 0.01250339f, 0.16441570f, 0.02326543f, -0.00519963f, -0.03973352f, 
    -0.64460534f, 0.08944023f, -0.17250180f, 0.10831580f, -0.15748519f, -0.13403094f, 0.17233036f, -0.00115724f, 
    -0.27439669f, 0.15903601f, 0.11522683f, 0.24218258f, -0.01951184f, -0.11077417f, 0.18216510f, 0.06492280f, 
    -0.12709895f, -0.03165581f, 0.17292511f, -0.07602172f, 0.21397777f, -0.10301901f, -0.02181297f, 0.04234708f, 
    -0.06230779f, -0.01715337f, 0.00327863f, 0.15156798f, -0.14433044f, 0.18390135f, -0.11717128f, 0.09918994f, 
    -0.06683054f, -0.10114475f, -0.12464237f, 0.11868734f, 0.08228888f, -0.07915541f, 0.14586583f, -0.01982429f, 
    0.01521444f, 0.01864727f, -0.08807976f, 0.15173532f, -0.01277079f, 0.32978550f, 0.22056040f, 0.28369650f, 
    0.04034165f, -0.09301068f, -0.07406162f, 0.00895879f, 0.01223134f, -0.09471212f, -0.25837317f, 0.08847017f, 
    0.38737267f, 0.24324591f, -0.01663722f, 0.14801948f, 0.00925072f, -0.07160298f, -0.17827246f, 0.28561753f, 
    0.11557975f, 0.10861881f, -0.00058334f, -0.04332561f, 0.02509475f, 0.10216520f, 0.03421554f, 0.04899330f, 
    -0.08657426f, -0.08927242f, -0.19166021f, 0.13567069f, 0.05499424f, 0.08345651f, 0.00669146f, -0.09850933f, 
    0.07114678f, -0.02734515f, 0.05605290f, 0.09306575f, -0.09022384f, -0.03653084f, -0.07544784f, -0.06984032f, 
    0.01751540f, 0.02209551f, -0.12330674f, -0.00281636f, -0.07965720f, 0.04416588f, 0.05195536f, 0.06857722f, 
    0.04777142f, 0.01936960f, -0.16456823f, 0.06260430f, -0.03499514f, -0.09482942f, -0.03309730f, -0.12352812f, 
    -0.02655389f, 0.23771535f, 0.01140576f, 0.12211374f, -0.18757705f, -0.48678634f, -0.21741326f, -0.11850902f, 
    -0.23454909f, -0.24160980f, -0.10901409f, -0.02211592f, -0.01520055f, 0.28004792f, 0.12132176f, 0.08839293f, 
    0.03068675f, 0.02294206f, 0.02472176f, 0.10276260f, -0.00529667f, 0.00738011f, 0.32711941f, 0.20637968f, 
    0.29163510f, -0.00280084f, 0.00427203f, 0.06948948f, 0.02018219f, 0.01153116f, 0.26097488f, 0.11436032f, 
    0.00766718f, -0.06706201f, -0.08281827f, 0.01581506f, -0.05555285f, 0.11946594f, 0.17633624f, -0.01969979f, 
    0.19604696f, 0.16430177f, -0.05582322f, -0.05230149f, -0.04230314f, -0.12416709f, -0.00322049f, -0.13475300f, 
    -0.05919652f, 0.12104606f, 0.03665096f, 0.10206599f, -0.03230298f, 0.05083332f, 0.08459282f, 0.01853307f, 
    -0.08876898f, -0.11218942f, -0.12482334f, -0.08873666f, 0.24129197f, 0.01788651f, -0.11514395f, -0.07255295f, 
    -0.03559627f, 0.09983066f, -0.01780378f, 0.15704198f, 0.43977803f, 0.45518801f, -0.02237551f, -0.04647683f, 
    0.00652426f, -0.10625181f, 0.05890333f, -0.05393032f, -0.31133384f, -0.03741887f, -0.13243473f, -0.20055997f, 
    -0.09853622f, -0.19902138f, 0.15804730f, -0.16986835f, 0.02811470f, 0.10917138f, -0.03056631f, 0.02545976f, 
    0.17797309f, -0.16199793f, -0.11154391f, -0.10073073f, -0.14208560f, 0.03230535f, -0.02576187f, -0.14283499f, 
    -0.07951695f, 0.06191875f, -0.04317993f, 0.08784236f, -0.07091623f, 0.03023865f, -0.09307622f, 0.16295433f, 
    -0.15058362f, -0.07912118f, 0.07829834f, -0.20803811f, -0.07025690f, 0.02166390f, -0.11180141f, 0.06035022f, 
    0.03627235f, 0.00030854f, 0.01793918f, -0.06080028f, -0.14098279f, -0.05577651f, -0.08258987f, -0.00768017f, 
    0.06649990f, -0.08822409f, -0.30359909f, -0.02774285f, -0.19241947f, -0.06249028f, -0.13595571f, 0.13000759f, 
    0.00954887f, 0.00215505f, -0.22131467f, -0.01096529f, 0.21121135f, -0.02398234f, -0.21213083f, -0.18093342f, 
    -0.03410555f, -0.02982049f, 0.00442576f, 0.08411966f, -0.08695012f, 0.15791661f, -0.13677417f, -0.15625010f, 
    -0.12522036f, -0.01808573f, -0.09286745f, -0.06849341f, 0.05012773f, -0.35686955f, -0.08910199f, -0.03282901f, 
    -0.06476640f, -0.06942496f, -0.14369346f, -0.04001882f, -0.20910339f, 0.29220280f, 0.09787557f, 0.19275209f, 
    0.11360327f, 0.07572497f, -0.17060155f, -0.03833722f, -0.12208403f, -0.02342243f, -0.35829690f, 0.04635433f, 
    -0.13461930f, -0.09559462f, 0.03452158f, 0.00489486f, 0.11824147f, 0.08153299f, 0.02354443f, 0.53574228f, 
    -0.30451193f, -0.37010717f, -0.13982694f, -0.08524756f, -0.04058218f, -0.04196346f, -0.05514831f, -0.00331811f, 
    0.18331115f, 0.05657355f, 0.09711950f, -0.17878215f, 0.22258981f, -0.05222287f, -0.10730165f, 0.10594058f, 
    0.02574282f, 0.07854898f, 0.24308634f, 0.02399550f, -0.24118008f, -0.11443105f, -0.16745953f, 0.09160905f, 
    0.13674630f, 0.01402142f, 0.08176251f, -0.03775462f, -0.06073928f, -0.16497700f, -0.07822100f, -0.09652445f, 
    0.14825322f, 0.04287839f, 0.02130502f, 0.01581071f, 0.06852456f, 0.31950593f, -0.22326274f, -0.07254131f, 
    -0.02798276f, 0.07620866f, -0.04945322f, 0.18041584f, -0.20679864f, 0.02268722f, 0.07570497f, -0.13617681f, 
    0.03392398f, 0.09126156f, -0.02521341f, 0.12584040f, 0.13405250f, -0.15551041f, -0.32319593f, -0.03741513f, 
    0.03402637f, 0.14482544f, 0.05606164f, -0.06329814f, 0.11483570f, -0.00204357f, -0.18315439f, -0.00600565f, 
    -0.59634531f, -0.08094620f, -0.13580422f, 0.03416955f, -0.19509611f, 0.25404587f, 0.14891587f, -0.00211899f, 
    -0.08172711f, 0.07072515f, 0.08862001f, 0.07920937f, -0.06737333f, -0.00648344f, 0.04339178f, 0.12798360f, 
    0.03179207f, 0.04543636f, 0.24241930f, -0.01809836f, -0.02475784f, -0.12154634f, 0.09703176f, -0.04640049f, 
    0.06211095f, 0.07126962f, 0.00280988f, -0.08112423f, -0.13662937f, 0.12028349f, -0.06949751f, 0.16524459f, 
    0.07940005f, -0.09225862f, 0.06885358f, -0.00586289f, -0.16431184f, 0.01515661f, 0.30455258f, 0.16102463f, 
    0.04848529f, 0.05918028f, -0.24531141f, -0.05917831f, -0.13268630f, 0.02412353f, -0.08669698f, -0.05423877f, 
    -0.15082096f, 0.13673626f, -0.10334175f, 0.02595876f, 0.00141928f, 0.49441636f, 0.12788750f, -0.02399229f, 
    -0.18163243f, -0.19496016f, 0.07034929f, -0.06941174f, 0.04115979f, -0.04825331f, 0.05984520f, 0.14150164f, 
    -0.08816983f, 0.01233250f, -0.07396393f, 0.08282945f, 0.03215368f, 0.09925928f, 0.01159466f, 0.12147443f, 
    -0.12907568f, 0.07184616f, 0.08144797f, -0.01312793f, -0.02496680f, -0.06045422f, 0.20615616f, 0.16533944f, 
    -0.18404038f, 0.12234744f, 0.02385249f, 0.14759412f, 0.00716998f, -0.10800030f, 0.01038705f, -0.05381338f, 
    -0.38330594f, 0.06061197f, 0.21580938f, 0.03951683f, 0.11109892f, -0.00463671f, 0.05091373f, -0.19432645f, 
    -0.13187662f, -0.01339696f, -0.00628317f, -0.01736473f, 0.02784800f, 0.08858833f, 0.06835549f, 0.09127662f, 
    0.04526220f, -0.16319010f, -0.02121460f, 0.03157313f, 0.21990605f, 0.08507036f, -0.06384129f, -0.12404910f, 
    -0.02799544f, 0.03066789f, -0.00416839f, -0.08499018f, -0.62604898f, -0.14008731f, 0.00124253f, 0.01581742f, 
    0.01951023f, -0.00889394f, -0.01337403f, -0.08655141f, -0.49327740f, -0.22499689f, -0.23924240f, -0.19788960f, 
    0.31351957f, 0.11292114f, 0.00987123f, 0.13981862f, -0.06243954f, 0.08836985f, 0.17078997f, 0.27976015f, 
    -0.19316992f, -0.12699397f, -0.09412659f, 0.05008519f, 0.01160211f, -0.02223037f, -0.16337848f, -0.06511801f, 
    -0.15774137f, 0.02572193f, -0.08864406f, -0.02917350f, -0.02833685f, 0.01606793f, 0.01511917f, 0.04641362f, 
    0.39307478f, 0.15031631f, -0.06936644f, -0.08188660f, -0.07055435f, -0.03642761f, -0.03862207f, 0.12020111f, 
    0.02237028f, 0.02543247f, -0.04957632f, -0.27102312f, -0.17359541f, -0.09311644f, 0.05756582f, 0.06489733f, 
    -0.02113226f, 0.06547860f, 0.06039853f, 0.01367680f, 0.00344822f, -0.00724865f, -0.07207544f, 0.00510137f, 
    0.15920368f, 0.07378812f, 0.08751573f, 0.16981497f, 0.30487454f, 0.04466834f, -0.13809174f, -0.22816516f, 
    0.10847874f, -0.02582929f, 0.01366884f, 0.04491623f, 0.19825502f, -0.10837630f, -0.21901643f, 0.19361489f, 
    -0.12308271f, 0.04811202f, 0.02062180f, -0.03840612f, -0.30717614f, -0.08985841f, -0.13449223f, 0.12805286f, 
    -0.02391150f, 0.09218361f, 0.11294777f, -0.00225246f, -0.00168873f, -0.00923421f, 0.24249192f, -0.15143311f, 
    -0.03986159f, -0.15847187f, -0.41117334f, 0.19222151f, 0.21231109f, -0.19776283f, -0.22463857f, -0.14880700f, 
    0.13949800f, -0.19073337f, -0.00237789f, -0.33971131f, 0.07817578f, 0.02707829f, 0.00096736f, -0.11867311f, 
    -0.10799906f, 0.19292477f, 0.10717007f, -0.24662279f, 0.03153864f, 0.04863909f, -0.07129434f, 0.12967607f, 
    -0.10208619f, -0.06586494f, -0.04737287f, -0.15644154f, -0.02567286f, 0.12994151f, -0.03866071f, -0.10811394f, 
    0.04633069f, -0.38079658f, 0.00934340f, -0.05101178f, -0.04042679f, 0.05696331f, -0.14610018f, -0.09549169f, 
    -0.02090484f, -0.01555500f, -0.21371177f, 0.01950554f, 0.21374664f, 0.02775075f, -0.19814685f, 0.10101660f, 
    0.00935389f, 0.02941525f, -0.10170744f, 0.05487867f, -0.41020924f, 0.07368055f, 0.11485777f, -0.17848125f, 
    -0.15960674f, 0.04306529f, 0.02018442f, 0.13641465f, 0.11451106f, 0.04147861f, -0.23064896f, -0.05409549f, 
    -0.02453149f, 0.05503513f, 0.00417644f, 0.05710134f, -0.01843243f, 0.65165359f, 0.06537538f, -0.41504729f, 
    -0.06964621f, -0.01173256f, -0.12308329f, 0.06813926f, 0.04633641f, 0.07838033f, -0.44176558f, -0.06387881f, 
    -0.15685014f, -0.06677426f, -0.15088443f, -0.06354108f, 0.00213676f, -0.04990196f, 0.15404618f, 0.04317568f, 
    0.09493779f, 0.05956821f, -0.13476181f, 0.05982191f, -0.08226950f, 0.06762335f, 0.06982353f, -0.01449420f, 
    0.07865973f, 0.07434087f, 0.28791523f, -0.03218856f, 0.03429642f, -0.07251248f, 0.11045864f, -0.00101734f, 
    -0.05350437f, -0.13851669f, -0.09208555f, -0.02171886f, 0.01388851f, -0.01707511f, 0.06379656f, 0.13602571f, 
    -0.00355754f, 0.08851316f, -0.01350599f, 0.10684773f, -0.19718750f, -0.03515778f, 0.02889654f, 0.09876932f, 
    -0.08417524f, -0.10966943f, -0.10989618f, -0.16406190f, -0.08850212f, 0.02096316f, -0.06427353f, 0.01140421f, 
    0.01398074f, 0.06986661f, -0.01652885f, 0.01600555f, -0.49069065f, 0.40371510f, -0.26422811f, -0.06610216f, 
    -0.20453495f, -0.01659071f, 0.00355602f, -0.02045909f, 0.06723069f, -0.23553509f, -0.01817770f, -0.03665317f, 
    -0.08207365f, 0.03905996f, 0.03666796f, 0.09630295f, -0.13116984f, -0.04532409f, 0.11766821f, -0.08974965f, 
    0.29424658f, 0.09966490f, 0.05282427f, -0.02972751f, 0.02378718f, -0.12479592f, 0.05524105f, 0.10837281f, 
    -0.15378962f, -0.02009087f, 0.03859711f, 0.12001193f, -0.06617498f, -0.06349746f, 0.15507433f, 0.01115664f, 
    -0.21242969f, 0.22643654f, 0.13257340f, -0.07452838f, -0.00070215f, -0.08729560f, -0.11663575f, -0.02386225f, 
    -0.05457231f, 0.16113450f, 0.06569950f, -0.12565179f, -0.06634838f, 0.02635712f, -0.03841089f, -0.01704205f, 
    -0.03252234f, 0.02712925f, -0.12854664f, -0.00022311f, 0.52752244f, -0.06199405f, -0.26144731f, -0.04100969f, 
    -0.11755186f, 0.01227012f, 0.06412555f, 0.14564535f, 0.00623349f, 0.32363984f, -0.09309594f, 0.08562280f, 
    0.13200687f, 0.01718549f, 0.02006809f, -0.01813577f, -0.09972475f, -0.03129590f, -0.00278062f, -0.16239524f, 
    0.08491833f, 0.18537056f, 0.00717774f, -0.00032223f, 0.03451562f, 0.05838485f, 0.21218252f, 0.16210920f, 
    0.05897000f, 0.10882884f, -0.12924044f, 0.02494277f, -0.07467096f, -0.05470765f, -0.26353690f, 0.09669061f, 
    -0.13921592f, 0.08684231f, 0.00148735f, 0.04051454f, -0.06527279f, 0.00135865f, 0.18727292f, 0.04560427f, 
    0.33166856f, 0.12227701f, 0.05350977f, 0.02281811f, 0.03733098f, 0.07296014f, 0.10728634f, 0.04328370f, 
    -0.08519887f, -0.19811806f, -0.08018117f, 0.01741240f, -0.06467551f, 0.02227376f, 0.20952225f, 0.05036503f, 
    0.06045180f, -0.13711961f, 0.12053145f, 0.15929961f, -0.05814132f, 0.02682379f, -0.18972994f, 0.13336866f, 
    0.00558508f, 0.03114040f, 0.00655661f, 0.07905664f, 0.23241907f, -0.11649632f, -0.00174384f, -0.20824514f, 
    -0.03068409f, 0.08967207f, 0.01227511f, -0.16687822f, -0.22705832f, 0.14748378f, -0.09727965f, 0.24485280f, 
    -0.10119822f, 0.23542833f, -0.08064804f, -0.04084041f, 0.13726127f, 0.10792923f, -0.57695240f, 0.05800816f, 
    -0.01302371f, 0.11230767f, 0.05369495f, 0.02171877f, 0.10145420f, -0.48380139f, -0.47520697f, 0.45165646f, 
    -0.02260777f, -0.05915862f, 0.00356088f, 0.07261457f, 0.07491250f, -0.08227614f, -0.70737189f, -0.11179316f, 
    0.35637310f, 0.03442612f, -0.03130494f, -0.15068179f, -0.01293483f, 0.01379730f, 0.09280296f, -0.28587008f, 
    -0.18602990f, -0.07547852f, 0.08639932f, -0.05936554f, 0.17497966f, -0.07365066f, -0.01946973f, 0.06922717f, 
    0.19604410f, -0.14523405f, 0.32836810f, -0.14508641f, -0.06283359f, -0.08048480f, -0.03054124f, 0.17990604f, 
    -0.00275363f, -0.00815173f, -0.14274906f, 0.10539032f, 0.12511259f, 0.05988237f, 0.06814025f, -0.06838950f, 
    0.12723055f, 0.02258754f, -0.10874605f, -0.13179384f, 0.07767640f, -0.01375991f, -0.08664004f, 0.08981512f, 
    -0.17126247f, 0.05282109f, -0.00566834f, -0.03630904f, -0.26460716f, -0.13108543f, 0.05099406f, 0.01320005f, 
    0.13424845f, 0.05888771f, 0.06453361f, -0.05101104f, -0.00747524f, -0.12597206f, 0.06870445f, 0.07698702f, 
    -0.07783283f, 0.02901396f, -0.10924993f, 0.05233353f, -0.09878460f, 0.05198587f, -0.16534634f, -0.22914988f, 
    0.02928596f, 0.04320836f, 0.00705500f, 0.01915861f, -0.04074883f, -0.14075345f, 0.08054131f, -0.19804601f, 
    0.08814406f, 0.05012146f, 0.10868489f, 0.19051082f, 0.11068688f, -0.04574563f, -0.02833033f, -0.04533014f, 
    -0.21805950f, -0.16132645f, -0.00308644f, 0.05790910f, 0.03998279f, -0.03418757f, -0.00625860f, -0.11494634f, 
    0.03512149f, 0.10985105f, 0.07847748f, 0.15331349f, 0.01378308f, 0.01398699f, 0.05908192f, 0.13123305f, 
    0.16235873f, 0.10319090f, -0.11135731f, 0.15365204f, -0.07420373f, 0.05525867f, -0.06204799f, 0.04065579f, 
    0.14982651f, 0.29831877f, 0.04341922f, -0.09179321f, 0.09893619f, -0.06562840f, -0.20752743f, -0.03616145f, 
    0.20224085f, 0.06854616f, 0.04813043f, -0.10185982f, 0.14131580f, -0.08203994f, -0.07881261f, -0.10247362f, 
    0.03517415f, -0.03493901f, -0.08031695f, -0.23856458f, -0.04591819f, 0.13730405f, 0.11705098f, 0.18351758f, 
    0.14646943f, -0.05108561f, -0.03576279f, -0.19602023f, -0.11459257f, -0.02969124f, -0.08659092f, -0.08638690f, 
    0.08455836f, -0.00065868f, -0.05790533f, 0.03285140f, 0.01661631f, 0.09022088f, 0.00056044f, -0.27437204f, 
    0.05315332f, -0.12628293f, -0.14438456f, -0.03580913f, -0.19095391f, -0.14204122f, -0.19198006f, 0.03768387f, 
    0.09706118f, 0.01822291f, 0.16628867f, -0.22233585f, 0.02486757f, 0.08633883f, 0.10278513f, 0.21212699f, 
    -0.15838705f, -0.03420221f, -0.09577549f, 0.16401507f, 0.06936666f, -0.01349108f, -0.03018671f, 0.17006491f, 
    -0.00933643f, 0.03030271f, 0.00283346f, 0.20056863f, 0.10649627f, -0.18275723f, 0.02568474f, 0.16872355f, 
    0.16310704f, 0.08110458f, -0.03657097f, -0.20476836f, 0.20010303f, 0.05183270f, -0.10013250f, 0.14180849f, 
    -0.06331658f, 0.04133296f, 0.06848837f, 0.06393518f, -0.18116151f, -0.10827298f, 0.07262185f, 0.14238872f, 
    0.01568269f, -0.15304293f, 0.05864602f, -0.15438831f, 0.23005828f, 0.10707525f, 0.58616108f, -0.01862750f, 
    -0.06518568f, -0.15579759f, 0.01268178f, -0.08097108f, 0.04708029f, -0.17911857f, -0.06114531f, -0.24348268f, 
    -0.00208856f, 0.05378006f, -0.04038620f, 0.08768924f, 0.03482658f, 0.00575852f, 0.09048899f, 0.18282078f, 
    -0.01735779f, 0.01623108f, 0.02999209f, 0.00514250f, 0.02663814f, -0.06038569f, -0.05048626f, -0.02967220f, 
    -0.29725799f, -0.00310316f, 0.02279981f, 0.05052602f, 0.11793884f, 0.03693802f, -0.04031755f, -0.08945712f, 
    -0.08824451f, -0.13201517f, -0.02758249f, 0.06823567f, 0.08047816f, 0.09294617f, -0.05506548f, 0.15846547f, 
    0.09333958f, 0.10969348f, 0.08022709f, 0.01856903f, -0.18427309f, 0.15260392f, 0.04829849f, 0.04437466f, 
    -0.07284713f, 0.07678922f, -0.17299403f, 0.00775800f, -0.10788053f, -0.01166305f, -0.18027730f, 0.07300587f, 
    0.04764933f, 0.03207719f, 0.16151419f, -0.08887143f, -0.09844696f, -0.09406251f, 0.18001951f, -0.06124257f, 
    0.13580391f, -0.11235496f, 0.09297593f, 0.03662649f, 0.11742317f, 0.05918298f, 0.04445035f, 0.14441395f, 
    0.06422605f, -0.16069229f, -0.06893602f, -0.13781799f, -0.00708917f, -0.02320761f, -0.07282633f, -0.22605152f, 
    -0.12503871f, 0.15036808f, 0.15393367f, -0.08775946f, -0.11648463f, 0.23457117f, 0.08267067f, 0.01335776f, 
    -0.02869657f, 0.00994927f, -0.11017650f, 0.12617607f, -0.10507123f, -0.06725759f, -0.24099691f, 0.00017983f, 
    0.26090217f, -0.04816256f, 0.12244861f, 0.03498069f, 0.10468697f, -0.07703263f, -0.12418425f, -0.20500389f, 
    0.09672516f, 0.14490253f, -0.13283740f, -0.02726659f, -0.02601769f, 0.09818283f, 0.03694292f, -0.06389643f, 
    0.03843373f, 0.03905461f, -0.13192035f, -0.13829610f, 0.01438479f, 0.01579200f, 0.06624405f, -0.01831562f, 
    -0.01359209f, 0.04571247f, 0.11929927f, -0.03064073f, -0.14350396f, 0.13680699f, 0.04516765f, 0.06701816f, 
    0.01683823f, 0.04130755f, 0.06641884f, 0.09252528f, -0.04545365f, -0.16883466f, 0.08361369f, 0.13628750f, 
    0.09560758f, -0.06930438f, 0.07729337f, -0.10559251f, 0.06567626f, 0.06311183f, -0.29153705f, 0.08214585f, 
    0.12668209f, -0.01622626f, -0.07921606f, 0.06562106f, 0.08078822f, -0.06285574f, 0.25036088f, 0.05718994f, 
    0.22307022f, -0.05213188f, 0.06442400f, -0.00885395f, 0.03390585f, 0.11831348f, -0.03638249f, 0.17072411f, 
    -0.37240240f, 0.05688796f, 0.03063659f, -0.01248089f, -0.09137425f, 0.00135408f, 0.00352644f, 0.07257886f, 
    0.00071018f, -0.20701770f, -0.07016703f, -0.07630502f, -0.05709039f, 0.02981470f, -0.05420784f, -0.11163487f, 
    0.13708927f, -0.09051923f, -0.04389095f, 0.19102024f, 0.01088483f, 0.02709982f, -0.10128627f, -0.07003082f, 
    -0.30541834f, -0.03754774f, -0.13983740f, -0.14020452f, 0.06276579f, 0.14290951f, -0.00042432f, -0.29278734f, 
    -0.18065237f, -0.16483366f, -0.12844668f, -0.01243570f, -0.02600257f, -0.03776843f, -0.01571542f, -0.06429879f, 
    -0.03030477f, -0.29915172f, -0.16307604f, 0.00138844f, -0.11825223f, -0.02683136f, 0.15022679f, 0.04462815f, 
    -0.00119857f, 0.08601463f, -0.07222617f, 0.21482635f, -0.31162223f, -0.33962587f, -0.08871953f, 0.13934253f, 
    0.14557087f, 0.34815890f, -0.05458759f, 0.07242234f, -0.00847518f, -0.06183471f, 0.03148227f, -0.13652325f, 
    -0.02179565f, -0.03764157f, 0.10872663f, -0.00510107f, -0.08456983f, -0.10088596f, 0.12301996f, 0.05093327f, 
    0.14932671f, 0.05884353f, -0.09095079f, 0.06948277f, 0.02113024f, 0.08580388f, 0.06616480f, 0.12470213f, 
    -0.09618941f, -0.15772551f, -0.16062766f, -0.05797769f, 0.07904867f, 0.12666786f, -0.07846230f, -0.03884692f, 
    0.20876600f, 0.01960731f, -0.11061806f, 0.06520521f, -0.04668747f, 0.07419837f, 0.15594053f, 0.10065538f, 
    -0.19818592f, 0.02690809f, 0.03040516f, -0.03183607f, 0.04181250f, -0.06404464f, -0.00471725f, 0.03651891f, 
    -0.11078653f, -0.15209575f, 0.23337582f, 0.08817721f, -0.13419482f, 0.03928725f, -0.01184795f, -0.02445532f, 
    0.06992724f, 0.16243447f, -0.18485260f, -0.00286681f, 0.09417035f, -0.18816949f, 0.13271201f, -0.17358623f, 
    0.17210507f, 0.14996104f, 0.09357066f, 0.12474616f, 0.29339370f, -0.08874620f, -0.15898344f, 0.02879937f, 
    -0.02087957f, 0.00027422f, 0.11840406f, -0.13623117f, 0.14037648f, 0.13044971f, -0.07459874f, -0.06517352f, 
    0.26804483f, 0.11087629f, -0.00576074f, -0.01550491f, -0.13844056f, -0.17804001f, -0.04811945f, -0.03048720f, 
    -0.15319647f, 0.09893858f, 0.20663939f, 0.14187415f, 0.01327615f, -0.01304337f, 0.20441149f, 0.13146938f, 
    0.04843319f, 0.06412888f, 0.25574017f, -0.01101539f, 0.05362766f, -0.20809114f, -0.00191775f, -0.07135140f, 
    -0.13286634f, -0.11482409f, -0.08840460f, 0.03436217f, 0.18159591f, 0.08742779f, -0.11036121f, -0.12603430f, 
    -0.24719433f, 0.00837709f, -0.17900658f, -0.09921896f, 0.06073806f, 0.02026355f, -0.03194162f, 0.04166057f, 
    -0.03583309f, -0.05406842f, 0.13062218f, -0.08497397f, -0.16333738f, 0.31647271f, -0.05371980f, -0.08353917f, 
    -0.00329973f, -0.03936490f, -0.17007917f, -0.06698319f, -0.20305859f, -0.04173059f, 0.06272657f, 0.15485105f, 
    0.06198607f, -0.00009098f, -0.17490290f, -0.27724081f, -0.05871829f, 0.08252127f, -0.18146417f, 0.10612187f, 
    0.14304981f, 0.10946898f, -0.14374599f, 0.13127986f, 0.08486666f, -0.11996378f, 0.04074497f, -0.18141744f, 
    -0.01467365f, -0.04349080f, 0.22928749f, 0.03185939f, -0.00915750f, 0.00034428f, 0.00824773f, 0.01692087f, 
    0.04518012f, -0.11105898f, 0.02192675f, -0.04539642f, -0.02582328f, 0.01801467f, 0.19872028f, -0.21700394f, 
    0.02214715f, 0.05920322f, -0.03606429f, 0.09707373f, 0.05572127f, 0.02778933f, 0.19919336f, 0.08967525f, 
    -0.04195761f, -0.10175220f, -0.20262681f, 0.09570603f, -0.16189720f, 0.05748932f, 0.08569875f, 0.11268972f, 
    -0.06055192f, -0.03370375f, 0.00280076f, -0.20100644f, 0.01129087f, 0.06888164f, 0.06614809f, -0.00868692f, 
    -0.01253123f, 0.06012180f, -0.09869320f, -0.07167764f, -0.11835139f, -0.09032683f, 0.14350271f, -0.04963222f, 
    0.01740174f, -0.07795136f, 0.16797225f, 0.02260689f, -0.04029185f, -0.16669881f, -0.10096908f, 0.09418418f, 
    0.03932146f, 0.04387957f, 0.04302781f, 0.09635519f, -0.11251877f, -0.01569756f, -0.07823844f, 0.01381146f, 
    0.02826604f, -0.03504926f, -0.05967749f, 0.06858470f, 0.16410530f, 0.51596880f, 0.25301659f, -0.09997338f, 
    0.09448601f, -0.06491193f, -0.13483556f, -0.15273029f, -0.01550901f, 0.04778797f, 0.21539389f, -0.04573565f, 
    0.19903718f, 0.26871729f, 0.15269962f, -0.13617747f, -0.06702043f, 0.13498384f, -0.28611094f, 0.16760182f, 
    0.24881247f, 0.03680883f, -0.09725276f, 0.10650652f, -0.07601013f, -0.06241572f, 0.04033191f, -0.01229979f, 
    -0.10676155f, -0.07985558f, 0.10973934f, 0.05010204f, 0.05521393f, 0.01351859f, 0.10171915f, 0.00087438f, 
    -0.16540489f, 0.15276478f, -0.12020828f, -0.09558475f, -0.02839859f, -0.09284353f, -0.03532449f, -0.02172362f, 
    -0.03208478f, -0.07193101f, 0.05407844f, -0.06517136f, -0.15859678f, -0.01370960f, -0.03201863f, 0.10013589f, 
    0.02497536f, -0.12969850f, -0.21753079f, 0.00480817f, -0.04960794f, -0.10147518f, -0.04208806f, -0.05669472f, 
    -0.05779542f, 0.01808066f, -0.01479724f, 0.21715294f, -0.09720046f, -0.07703605f, -0.15457328f, -0.19348618f, 
    0.19736524f, 0.01474049f, -0.16888835f, -0.11754949f, -0.29818425f, 0.10482644f, 0.14124998f, -0.04437518f, 
    0.04434817f, 0.16869915f, 0.05990307f, -0.03847595f, -0.00988560f, -0.12633069f, 0.27332991f, 0.13254818f, 
    0.07588886f, 0.00149748f, 0.00756990f, -0.03530987f, 0.03408793f, 0.12406948f, 0.00209367f, 0.08736809f, 
    0.14152773f, 0.00784954f, -0.02781125f, -0.03230375f, 0.07327805f, 0.16725680f, -0.03733292f, 0.07468294f, 
    0.17445067f, 0.10027783f, -0.00344887f, 0.10752513f, 0.15514459f, -0.04570510f, 0.03531762f, -0.16620654f, 
    -0.13192202f, 0.10219410f, 0.08589568f, -0.01110059f, -0.07126712f, 0.07826065f, 0.07456456f, -0.08411606f, 
    -0.07063027f, -0.09812912f, 0.05980521f, 0.17389920f, 0.22846496f, 0.00875042f, -0.05285313f, -0.02388054f, 
    -0.13162726f, 0.19813657f, 0.17052756f, 0.10960092f, 0.09657242f, 0.26707041f, 0.05622359f, -0.04883389f, 
    -0.14968248f, -0.03392021f, 0.00173570f, 0.04562575f, -0.14463495f, -0.29518148f, -0.07124805f, 0.10319423f, 
    -0.04754983f, -0.21888460f, 0.00939295f, 0.01912114f, -0.10598425f, 0.04211556f, -0.11554498f, -0.01969927f, 
    -0.01560812f, -0.00804542f, -0.12066937f, 0.04560532f, 0.03183101f, -0.05167997f, -0.02191037f, -0.02557211f, 
    0.07825571f, -0.05104326f, 0.11152265f, -0.02644840f, -0.05265612f, 0.00724145f, 0.13584368f, 0.07198083f, 
    -0.02018885f, -0.02444281f, 0.15037394f, 0.06291321f, -0.23469037f, -0.06906498f, 0.02328095f, 0.06221812f, 
    0.00445753f, -0.10539451f, -0.18866204f, -0.14929387f, 0.10934407f, 0.01865279f, -0.19264165f, 0.04245323f, 
    0.16034730f, -0.20145096f, -0.06872767f, 0.18935831f, -0.04694499f, -0.03905585f, -0.12800778f, -0.05077622f, 
    -0.03156803f, -0.01970777f, -0.05983556f, -0.35973448f, -0.09451504f, 0.07324852f, 0.10387496f, -0.25360304f, 
    -0.17844495f, -0.03100527f, -0.02493647f, -0.11005719f, -0.07049552f, -0.07607572f, -0.07070702f, 0.09604790f, 
    0.07743175f, -0.14504899f, 0.02438998f, -0.24204536f, -0.00537571f, -0.11035565f, -0.11876012f, -0.13314041f, 
    0.13975279f, -0.18387830f, 0.09400927f, 0.07320941f, 0.13783313f, 0.05150335f, -0.26606211f, 0.02950900f, 
    -0.03333124f, 0.02759670f, -0.00552214f, -0.01580183f, 0.17153227f, 0.19294374f, -0.14409651f, 0.09698035f, 
    0.19058771f, 0.04225120f, -0.29494724f, -0.02393579f, -0.03107291f, 0.05299509f, 0.23491526f, -0.13524966f, 
    0.02846768f, 0.01344106f, -0.12038043f, 0.09531321f, 0.31171757f, 0.11912493f, -0.02463821f, 0.21136713f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.04725830f, 0.06702033f, -0.04905066f, -0.05958165f, 0.15177433f, -0.06118448f, 0.13804492f, 0.09811797f, 
    0.01772421f, -0.02643183f, 0.08843668f, -0.09814975f, 0.08252625f, 0.06363501f, 0.18111145f, 0.03696201f, 
    -0.02196856f, -0.04024427f, 0.12582174f, 0.18921013f, 0.14874385f, 0.04428973f, 0.22751357f, -0.00460780f, 
    -0.11655287f, 0.18228461f, 0.18494663f, 0.06308882f, 0.08082992f, 0.07190298f, -0.07680741f, 0.13692175f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.10004091f, 0.04583107f, -0.02340436f, -0.02342642f, -0.34485123f, -0.05176807f, 0.07815400f, 0.01678413f, 
    -0.15891705f, -0.09203994f, -0.34256017f, -0.12104499f, 0.12333989f, -0.21176223f, -0.10233650f, 0.19887076f, 
    -0.05332107f, 0.02363818f, -0.32230091f, -0.20430133f, -0.00186220f, -0.01279725f, -0.43935838f, 0.22202283f, 
    -0.00288227f, 0.10290366f, -0.06143171f, -0.10223925f, 0.09117834f, -0.08032674f, -0.06392774f, -0.12160283f, 
    0.10071655f, 0.03656866f, -0.18796393f, -0.12711784f, -0.00544391f, -0.07359824f, -0.11064181f, -0.01673353f, 
    0.02766703f, -0.19053517f, 0.05585806f, -0.16703232f, 0.11941878f, 0.05628334f, -0.11501473f, 0.04733175f, 
    -0.08787082f, 0.05084484f, -0.01958483f, -0.04077941f, -0.05090000f, 0.10799639f, 0.03980774f, 0.09109161f, 
    0.05056038f, -0.08791177f, -0.16612421f, -0.16570742f, -0.17270039f, -0.23898913f, -0.08148963f, -0.04429705f, 
    -0.81902808f, 0.10628314f, 0.22066987f, -0.04819358f, 0.05774073f, -0.00613185f, -0.20314440f, -0.10640600f, 
    0.11096969f, -0.02309053f, -0.07097168f, -0.15124644f, -0.54016680f, 0.08204544f, 0.39697602f, 0.02382009f, 
    0.16198891f, -0.15568429f, -0.09197110f, -0.13623354f, 0.04155343f, 0.13935255f, -0.17618443f, 0.27597803f, 
    0.00087032f, -0.06961318f, -0.11315683f, 0.27542666f, 0.69104236f, 0.02209071f, 0.03756470f, 0.38192630f, 
    -0.08568794f, 0.18073782f, 0.00739046f, -0.30322680f, 0.19886728f, -0.13601261f, -0.04615042f, -0.08654474f, 
    0.04202570f, -0.11653214f, -0.13235869f, -0.14200959f, -0.03999444f, -0.25881806f, 0.13966745f, 0.20996070f, 
    0.08631550f, 0.14425655f, 0.06055903f, 0.03602032f, 0.06811671f, -0.03333092f, 0.24154414f, -0.08202770f, 
    -0.06677768f, -0.04326638f, 0.06244893f, 0.05875906f, -0.08825158f, -0.17696366f, 0.09893548f, 0.17035338f, 
    -0.23483419f, -0.03887772f, 0.02621917f, -0.12103295f, -0.08050326f, 0.08736496f, 0.09662982f, -0.00033542f, 
    -0.00070999f, 0.02893148f, -0.15641981f, -0.13484895f, -0.24006128f, 0.03710761f, 0.14148740f, 0.05783079f, 
    0.07601599f, -0.06636446f, 0.11123227f, -0.14896540f, 0.03291646f, 0.12012834f, 0.01630218f, 0.14034294f, 
    0.14051886f, 0.09344035f, -0.15735516f, 0.21212456f, 0.43816009f, 0.02534840f, 0.07183252f, -0.19961731f, 
    -0.15254374f, 0.32669520f, 0.37594137f, -0.12974292f, 0.12937696f, -0.03465461f, 0.13074923f, -0.21581407f, 
    0.21714510f, 0.04988400f, 0.10985933f, 0.21914540f, -0.11018970f, -0.18216054f, -0.40166217f, -0.08133779f, 
    0.15958723f, 0.04646419f, 0.12825117f, -0.11304997f, 0.12835002f, 0.06510376f, -0.33913171f, -0.04072216f, 
    -0.04706617f, 0.03717481f, 0.08317304f, 0.17840455f, 0.09117406f, -0.19624832f, 0.07927239f, 0.11507041f, 
    -0.27020064f, -0.26638299f, 0.00410240f, -0.24822576f, -0.01796822f, -0.06742156f, -0.01913792f, 0.34715113f, 
    0.21312730f, 0.04765511f, 0.14724164f, -0.12923941f, 0.22750326f, -0.13166259f, 0.33030802f, -0.30623278f, 
    -0.07869449f, 0.17280732f, 0.02458579f, 0.36672398f, -0.01888912f, 0.03262868f, -0.02318772f, 0.05735669f, 
    -0.21696404f, 0.07043336f, 0.24774866f, -0.42702940f, 0.16801979f, 0.23451251f, -0.02907976f, 0.27806696f, 
    0.20557091f, 0.21223958f, 0.21703504f, 0.02691079f, -0.09217667f, 0.13068426f, -0.07575138f, 0.01471396f, 
    -0.04136222f, -0.08688929f, 0.04122649f, -0.06401780f, -0.04453678f, -0.01438657f, -0.08899938f, 0.14668418f, 
    0.15417424f, -0.10259927f, 0.04744035f, -0.12292796f, -0.00371653f, -0.01047792f, -0.26333919f, -0.14941284f, 
    -0.07803959f, -0.20441078f, 0.01396266f, 0.05702408f, 0.00245198f, -0.04952546f, -0.02726462f, 0.16343541f, 
    0.44620338f, 0.01518415f, 0.03261660f, 0.20151116f, 0.16280690f, 0.08682486f, -0.08749525f, 0.13380229f, 
    0.38763523f, 0.37001508f, 0.38038969f, 0.46768954f, 0.18886293f, 0.27642271f, -0.51302612f, -0.26874071f, 
    0.10126955f, -0.14713821f, -0.23441458f, -0.23139626f, 0.14783715f, -0.10706260f, -0.05656905f, -0.07657921f, 
    -0.29819432f, 0.05526738f, 0.11070976f, -0.21379617f, -0.25719431f, -0.10445436f, -0.15288317f, -0.10681127f, 
    -0.18124132f, 0.05676752f, 0.13874838f, 0.07428316f, 0.11826699f, 0.04569607f, -0.01491549f, -0.07022566f, 
    -0.11284155f, -0.20831999f, -0.20148736f, -0.23410881f, 0.21025935f, -0.17382516f, 0.18389523f, 0.44490004f, 
    0.14755158f, 0.04912848f, 0.20975052f, -0.20192923f, 0.27295688f, 0.18500639f, 0.40582383f, 0.09964857f, 
    -0.32769808f, 0.01880953f, -0.54592073f, 0.07387520f, 0.31837457f, 0.14738877f, 0.23509142f, 0.08686305f, 
    -0.04589503f, -0.36588827f, -0.28707758f, -0.34151879f, -0.13230541f, -0.17456144f, 0.11276326f, 0.32018706f, 
    0.02429930f, -0.12704971f, 0.17980087f, 0.18163525f, 0.25013974f, -0.04762888f, 0.25463152f, -0.16284370f, 
    -0.01835171f, 0.06838346f, 0.16823268f, -0.01404315f, 0.28994811f, 0.18295866f, -0.03098577f, 0.04644084f, 
    -0.02661657f, 0.11201210f, 0.30896300f, -0.01352863f, 0.00422316f, -0.13750820f, -0.05552401f, 0.10030060f, 
    0.07494819f, 0.28214309f, 0.22043507f, 0.14418797f, -0.17124799f, 0.11767230f, -0.01106363f, -0.30671561f, 
    0.23117225f, 0.17228073f, 0.03769729f, 0.06008773f, -0.16385423f, 0.04668263f, -0.14311516f, 0.37754875f, 
    0.15862586f, 0.17415556f, -0.05282805f, -0.77019233f, 0.01088357f, 0.14772445f, -0.24384820f, 0.37485620f, 
    -0.30899885f, -0.07977813f, 0.00808645f, 0.30337408f, 0.19018567f, -0.21187411f, 0.22115985f, -0.01306562f, 
    0.01767964f, 0.00271498f, 0.19828820f, 0.03058826f, 0.04953415f, -0.12963504f, 0.18806313f, 0.07161582f, 
    0.35755202f, 0.15992945f, 0.11260089f, 0.26120993f, -0.07327145f, -0.18090034f, -0.12945777f, 0.10960185f, 
    0.15217389f, -0.02156600f, -0.03456551f, 0.12064844f, -0.04656766f, 0.00113010f, 0.36004651f, -0.22286414f, 
    -0.05557274f, -0.01362528f, 0.06916281f, -0.14006256f, 0.41091478f, -0.05108980f, 0.07851081f, 0.28629285f, 
    -0.56767070f, 0.11403505f, -0.01777990f, -0.19286193f, 0.25626692f, -0.17701767f, -0.33697611f, -0.20629278f, 
    0.09977361f, 0.02860599f, -0.08114799f, -0.00345334f, -0.44234571f, -0.02212639f, 0.26346073f, 0.59414184f, 
    0.17868610f, -0.18312557f, 0.24755891f, -0.05974308f, 0.04653249f, 0.13222833f, 0.11668902f, 0.18918748f, 
    0.15080120f, 0.06443974f, 0.28141642f, -0.10199073f, 0.14983393f, -0.13160656f, 0.25275216f, 0.26915917f, 
    -0.00731290f, 0.00003275f, -0.18711022f, -0.12036292f, 0.09915424f, -0.11900932f, -0.18697982f, -0.15068702f, 
    0.05249936f, -0.13400754f, -0.10215497f, 0.01948177f, 0.11516023f, 0.14239360f, 0.03251867f, 0.04102022f, 
    0.09517907f, 0.03570116f, 0.00912686f, 0.10674049f, -0.03626934f, 0.02774580f, -0.07658622f, -0.15339597f, 
    0.04569385f, -0.16532265f, -0.01032564f, -0.02106769f, -0.06974106f, -0.00752288f, -0.06765039f, -0.02582718f, 
    -0.14720601f, -0.05827724f, 0.11784563f, -0.08315473f, -0.00398050f, -0.06056156f, 0.14335702f, -0.13906761f, 
    -0.11884326f, -0.11021594f, -0.04739064f, 0.03570483f, -0.14261015f, -0.11819099f, -0.17709111f, -0.12564944f, 
    -0.15544364f, -0.10885686f, 0.06981654f, -0.03920341f, 0.10774651f, 0.01839982f, -0.17971070f, 0.02171191f, 
    -0.03434122f, -0.05844883f, 0.12175207f, -0.16606262f, -0.11519132f, -0.06680379f, -0.16882426f, -0.20416228f, 
    -0.15845519f, -0.12731872f, 0.30931959f, 0.08641261f, -0.05529758f, 0.08370128f, -0.08516340f, 0.18757862f, 
    -0.23444884f, -0.14188401f, -0.13755983f, 0.02177882f, 0.10250024f, -0.07550577f, 0.11031276f, 0.16648106f, 
    -0.04917955f, 0.00939932f, -0.44783306f, 0.22121261f, 0.06307887f, -0.08167309f, 0.18657972f, -0.15602985f, 
    -0.23550896f, -0.02851096f, -0.45309883f, -0.03797268f, 0.45509645f, 0.18516591f, 0.12100791f, 0.35085028f, 
    -0.09111206f, 0.17765848f, 0.36227158f, 0.14189248f, 0.33668190f, -0.13591263f, 0.05869465f, -0.04400644f, 
    -0.02388134f, -0.16904448f, 0.05159442f, -0.28069896f, -0.21540326f, 0.33885452f, -0.07357811f, 0.06399535f, 
    -0.05175781f, -0.04723641f, -0.22469003f, 0.13907844f, 0.01296168f, -0.09838098f, 0.14878999f, -0.17710727f, 
    -0.26383275f, 0.11552569f, 0.39532462f, -0.49830776f, 0.21609460f, 0.09407749f, 0.13845263f, 0.23125198f, 
    -0.15351278f, -0.14368871f, 0.07944235f, -0.25843346f, -0.00627310f, 0.10716829f, 0.19670333f, 0.21649009f, 
    -0.05916248f, 0.16354361f, -0.06828063f, -0.11687843f, 0.09689478f, -0.37240139f, 0.10432115f, -0.14303520f, 
    -0.09954441f, -0.11586820f, -0.17455353f, 0.23380318f, 0.25714484f, 0.12915806f, 0.40129671f, -0.04055819f, 
    0.06965981f, 0.21033776f, -0.20271610f, -0.06401435f, 0.10897080f, 0.19170554f, -0.01729646f, 0.27533641f, 
    -0.07360683f, 0.05123273f, 0.44274476f, 0.21515280f, 0.19928296f, -0.16603547f, 0.28509399f, 0.21544148f, 
    0.35359707f, 0.16405596f, 0.01190338f, 0.02398684f, -0.09343571f, -0.23358861f, -0.12505411f, -0.20735386f, 
    -0.06361568f, -0.12604551f, -0.39799672f, -0.02842338f, -0.05198334f, 0.11929745f, -0.02492824f, -0.13547543f, 
    -0.20660932f, -0.12948574f, 0.12341218f, -0.12506610f, 0.46921617f, 0.16695894f, -0.24397837f, 0.15804864f, 
    -0.53125185f, 0.08951473f, 0.17979881f, -0.12127897f, 0.19245471f, -0.12407298f, -0.30728403f, -0.13124648f, 
    -0.14532606f, 0.03463786f, -0.03596640f, -0.22478762f, -0.50733417f, 0.02533064f, 0.41521075f, 0.27072459f, 
    -0.07777277f, 0.05389630f, -0.68649507f, -0.08640215f, -0.05029487f, 0.10316891f, -0.18997879f, 0.22513305f, 
    -0.21242866f, 0.02858482f, 0.01782979f, -0.30440918f, 0.40175858f, 0.17519923f, 0.09441479f, 0.13104379f, 
    0.03523500f, 0.07759853f, 0.23823723f, 0.14552926f, 0.19333069f, -0.00258762f, 0.00797914f, 0.16050829f, 
    -0.01998404f, -0.01528462f, -0.12434798f, 0.11657721f, -0.21708336f, 0.05107946f, -0.16816467f, 0.02378279f, 
    -0.14073209f, 0.07587282f, -0.11979043f, -0.16386981f, 0.11828496f, 0.03415062f, -0.35046309f, 0.14222744f, 
    -0.05901423f, -0.05180681f, -0.03924505f, 0.28901717f, 0.35959241f, -0.03293391f, -0.11861790f, -0.07584087f, 
    0.17131642f, 0.15661192f, -0.08477853f, 0.00082449f, 0.13380037f, -0.07337788f, -0.07868600f, 0.10981409f, 
    -0.15365052f, 0.14930709f, -0.00786919f, 0.34309018f, 0.04246487f, 0.44430384f, -0.10026047f, 0.16896051f, 
    0.08560388f, 0.00644832f, 0.09546504f, -0.15998049f, -0.06096007f, -0.15106755f, -0.04233759f, -0.04801089f, 
    -0.03250697f, -0.14226931f, 0.03288561f, 0.13317105f, -0.41051355f, -0.13627847f, 0.16700995f, 0.17074372f, 
    -0.08768216f, 0.21360472f, -0.06256650f, 0.17223293f, 0.18420865f, 0.12425077f, -0.25788870f, -0.53456980f, 
    0.12275113f, 0.27183175f, 0.15927014f, 0.20154342f, -0.05398627f, 0.14069833f, 0.01890420f, 0.06966589f, 
    -0.17846662f, -0.01157641f, -0.18235120f, -0.11464190f, -0.08352559f, -0.17344870f, -0.25535476f, -0.14661634f, 
    0.25124058f, -0.18517451f, -0.16311064f, -0.38558963f, -0.01866315f, -0.15837517f, -0.17165135f, -0.29039872f, 
    0.29686412f, -0.05778747f, -0.03260326f, 0.02298266f, 0.07523613f, 0.14335054f, 0.03880479f, -0.01466524f, 
    -0.08530100f, -0.09170800f, 0.10811048f, -0.36694914f, 0.29098162f, 0.17807493f, 0.58837849f, -0.18252541f, 
    -0.08228505f, 0.11285091f, -0.19244975f, 0.17628725f, -0.09907607f, 0.16487248f, 0.10981733f, 0.09738919f, 
    -0.34502709f, 0.32780102f, -0.21398947f, 0.11884435f, -0.40536723f, 0.10732338f, -0.21676315f, -0.03228038f, 
    0.11588354f, 0.13550933f, -0.05776675f, 0.10515537f, -0.01368373f, -0.01543447f, -0.10798980f, 0.16019778f, 
    0.09695791f, -0.09267797f, -0.21879429f, -0.32420498f, 0.21041848f, 0.03882993f, 0.23301539f, 0.00873863f, 
    -0.09341004f, 0.00972130f, 0.11216824f, -0.00973518f, -0.11268999f, -0.09766366f, -0.50901634f, 0.11719800f, 
    -0.02975112f, 0.00971172f, -0.04009803f, 0.21268344f, -0.19806956f, -0.17435203f, 0.18366580f, 0.19314283f, 
    0.06875613f, 0.29815263f, -0.07459708f, 0.02205139f, 0.19087026f, -0.11067941f, 0.29819843f, -0.13513210f, 
    0.28969941f, 0.15935650f, 0.32218835f, -0.02798421f, -0.01655315f, 0.22363405f, -0.01379335f, 0.08377513f, 
    0.10100205f, 0.05136271f, -0.48457944f, 0.09098606f, 0.18620200f, -0.08135232f, 0.16056478f, -0.12687227f, 
    -0.50012535f, -0.10397310f, 0.28621557f, -0.38784778f, -0.21551697f, 0.21068704f, 0.06323469f, -0.15687348f, 
    0.07307730f, 0.18433262f, -0.31204244f, -0.28708407f, 0.32679525f, -0.02949303f, -0.15394326f, -0.18415853f, 
    0.41421354f, 0.10521677f, 0.19822064f, 0.14411040f, 0.07691463f, 0.16032353f, 0.44697413f, -0.18179645f, 
    0.18334587f, -0.04794356f, -0.25856012f, 0.18337847f, 0.09394877f, -0.01511200f, 0.42741415f, -0.11420495f, 
    -0.15939453f, -0.07916307f, -0.02767724f, -0.60078788f, -0.00987157f, 0.12919956f, -0.15568405f, 0.05716794f, 
    -0.06203060f, 0.22814289f, -0.00192720f, 0.07115260f, 0.36649173f, 0.13103190f, -0.04371724f, -0.27442697f, 
    -0.02557038f, 0.14841704f, 0.35008451f, -0.10942049f, -0.14212278f, 0.47912130f, -0.00915172f, 0.32491854f, 
    -0.14918554f, -0.12734893f, 0.09768499f, 0.19959138f, 0.25417337f, -0.09231102f, 0.30505264f, -0.29172817f, 
    -0.34106767f, 0.05843813f, 0.40514189f, -0.11587579f, -0.25740135f, 0.01021628f, 0.07327540f, -0.11965408f, 
    -0.20303610f, 0.19071165f, 0.03880574f, -0.15514989f, 0.41705298f, -0.01622997f, 0.00957760f, -0.08919767f, 
    0.31457156f, 0.21538301f, 0.23472650f, 0.44008929f, -0.49121961f, 0.37049365f, -0.32573417f, -0.03330491f, 
    -0.12769689f, 0.07200632f, 0.29118735f, -0.09741337f, 0.05171234f, 0.16400422f, -0.25847048f, 0.18227683f, 
    -0.01264066f, -0.07399184f, 0.22801168f, 0.05895828f, -0.22248839f, 0.03143221f, 0.01499556f, -0.16244237f, 
    0.31752855f, 0.10231750f, -0.07065354f, 0.11621168f, 0.03165501f, -0.08034066f, -0.05976163f, -0.02113383f, 
    0.35143417f, 0.18293567f, 0.29461938f, 0.21613872f, 0.10590635f, -0.05260688f, -0.10789084f, 0.09881962f, 
    -0.06557571f, 0.02436476f, 0.01039044f, 0.02402219f, -0.19820365f, -0.13935004f, -0.11231178f, -0.09381725f, 
    -0.07741086f, -0.15138271f, 0.39483801f, 0.07787438f, 0.01007513f, -0.11184649f, 0.00581336f, 0.08655217f, 
    -0.09231929f, -0.15972829f, -0.06588425f, -0.01114853f, -0.07972133f, -0.13489065f, 0.14280705f, 0.11899723f, 
    -0.14315346f, 0.14905243f, -0.02717113f, -0.13777785f, -0.01422751f, 0.29078117f, 0.13999496f, -0.11088285f, 
    0.13746177f, -0.09589285f, -0.44935268f, 0.20365661f, 0.21799274f, 0.17054264f, 0.05547740f, -0.04992611f, 
    -0.19004600f, 0.09614559f, 0.22902267f, -0.22228228f, -0.17210338f, 0.03018119f, -0.35200608f, -0.00583725f, 
    0.22980729f, 0.01410790f, 0.18889579f, 0.11168265f, 0.04477289f, -0.04015063f, 0.11895188f, 0.17155550f, 
    0.24632125f, 0.26218519f, 0.20801897f, 0.24681342f, 0.14439243f, 0.27761301f, -0.49846134f, -0.22480428f, 
    -0.18238357f, 0.12562965f, -0.06498244f, 0.00590714f, -0.20061661f, -0.05709539f, -0.32640854f, -0.00559628f, 
    -0.26336136f, 0.14465234f, 0.00831545f, 0.00025018f, -0.24641837f, 0.05244148f, -0.13281216f, -0.00079083f, 
    -0.24140969f, 0.03544174f, -0.05768003f, -0.08960398f, -0.36002925f, -0.00159672f, 0.07132752f, -0.04898111f, 
    -0.22561492f, -0.12304712f, -0.27912101f, -0.24562036f, -0.04292701f, -0.05483757f, 0.46105179f, -0.27586207f, 
    0.12554559f, -0.00349909f, -0.05732559f, 0.03176862f, 0.22060575f, -0.08913389f, -0.10965578f, 0.23989604f, 
    0.14847445f, 0.24773668f, -0.11438743f, 0.00055660f, -0.14251931f, 0.19218487f, -0.08287436f, 0.02547714f, 
    -0.04760937f, 0.37350875f, -0.14303829f, 0.02711378f, 0.40999022f, -0.09234718f, -0.20174323f, -0.32539999f, 
    0.04981721f, 0.12932231f, -0.18125260f, 0.12901820f, -0.62660444f, 0.19172043f, 0.26436520f, 0.50162470f, 
    0.08607966f, 0.10446808f, -0.01185065f, -0.07187047f, 0.13442288f, 0.03391115f, 0.10935493f, -0.04757816f, 
    0.09598391f, -0.25430885f, 0.39818749f, -0.07155000f, 0.62089902f, 0.00263529f, 0.28771678f, 0.29096326f, 
    -0.13636880f, -0.00908228f, 0.14975333f, -0.15518676f, -0.18220067f, -0.01339416f, 0.07000346f, -0.13738981f, 
    -0.10170376f, -0.10788549f, -0.05308000f, 0.17226522f, 0.02153358f, -0.08933514f, 0.02209902f, 0.15637937f, 
    -0.10493427f, 0.11565788f, 0.04656463f, -0.03706274f, 0.09415023f, 0.14939618f, 0.11309026f, -0.17419392f, 
    -0.15849546f, -0.02729997f, 0.03292833f, -0.17161977f, -0.15700157f, -0.16515447f, -0.03947507f, 0.04895770f, 
    -0.02106785f, -0.02612194f, -0.13732216f, -0.03618571f, 0.01114389f, -0.14900656f, 0.05050588f, 0.03591415f, 
    -0.24374589f, 0.12668961f, -0.02822107f, -0.08974351f, -0.27585497f, 0.04934761f, -0.29194000f, -0.07105062f, 
    0.12299959f, 0.04688545f, -0.03783125f, -0.00829358f, 0.09727286f, 0.12542212f, -0.14528960f, -0.33689696f, 
    0.03296134f, -0.31334999f, -0.19317944f, 0.07197540f, 0.14449835f, 0.07154763f, -0.19587544f, -0.04682110f, 
    -0.13314429f, 0.09361605f, -0.18695189f, 0.08719239f, -0.09178234f, 0.01170469f, -0.20082659f, 0.10390393f, 
    0.05823213f, -0.23444115f, -0.23520720f, -0.04869189f, -0.19039533f, 0.03160867f, 0.04748376f, 0.21205382f, 
    -0.17487058f, -0.09117716f, -0.18231291f, -0.01215436f, -0.10822888f, 0.15408240f, -0.14867955f, 0.03561354f, 
    0.10751287f, -0.12229224f, -0.21240214f, -0.05088536f, -0.04453784f, -0.05336364f, -0.10989953f, -0.03603222f, 
    -0.47051951f, -0.03108865f, -0.19127983f, -0.39789113f, 0.15984026f, -0.07019942f, -0.11516015f, -0.18583816f, 
    0.01695023f, 0.03050074f, 0.13070680f, -0.01295293f, -0.61283004f, 0.15953977f, 0.46928972f, 0.24711734f, 
    -0.14457294f, 0.10558967f, 0.20661856f, -0.04582734f, 0.08726757f, 0.08209583f, 0.17572109f, 0.12811746f, 
    -0.17165543f, -0.05975621f, -0.45442578f, 0.35642147f, -0.04957953f, -0.14270788f, 0.14152622f, 0.11690686f, 
    0.09636743f, 0.19668187f, 0.06923398f, -0.17361046f, -0.02123613f, -0.00640744f, -0.23141965f, 0.10421315f, 
    0.18597625f, 0.03899339f, 0.20057052f, 0.28527454f, -0.06325888f, -0.01792253f, 0.16116187f, 0.03809929f, 
    -0.06544080f, -0.05204859f, 0.25411740f, -0.18214123f, -0.15301928f, 0.01604415f, 0.43866122f, -0.08877442f, 
    0.04633549f, 0.08374284f, 0.31818318f, -0.05640934f, 0.04947130f, -0.10705232f, 0.25901747f, 0.21630140f, 
    -0.28516638f, -0.24881275f, 0.14129229f, -0.19004402f, 0.14270429f, 0.03657877f, 0.03205102f, 0.08799385f, 
    0.24230918f, -0.14268073f, 0.08609489f, -0.14195746f, -0.29426560f, -0.13265733f, -0.16065426f, -0.03378439f, 
    -0.14643238f, 0.06206892f, 0.04174633f, 0.11633825f, 0.00734364f, 0.11093485f, 0.20640868f, 0.09644368f, 
    0.01574101f, -0.11253919f, 0.37758699f, -0.00291088f, 0.36027724f, 0.01486196f, -0.00802599f, 0.17552787f, 
    -0.18504201f, 0.08851425f, -0.08698504f, -0.17006232f, -0.18084630f, 0.14331676f, -0.09662648f, -0.14773200f, 
    0.21874857f, -0.09206968f, 0.05298777f, 0.09472061f, 0.10405019f, -0.21488459f, 0.46597734f, -0.03105159f, 
    0.02782864f, -0.00898026f, 0.13985504f, -0.01485879f, 0.01536776f, 0.09401542f, 0.13790509f, 0.09191927f, 
    0.16785815f, 0.17076249f, -0.03550288f, 0.32229903f, -0.22609191f, 0.00994576f, 0.03152370f, -0.09454084f, 
    -0.10667786f, -0.07167464f, 0.07825373f, -0.24030824f, 0.19970232f, -0.05716696f, 0.12475251f, 0.07705519f, 
    -0.05838319f, 0.01179841f, -0.10931510f, -0.26020062f, -0.28742057f, -0.28463739f, 0.13668337f, 0.38167575f, 
    -0.03510866f, -0.03895494f, -0.04289445f, 0.00640634f, 0.23075452f, 0.05476212f, 0.08732837f, 0.20232256f, 
    -0.02198787f, -0.06815984f, -0.12588342f, 0.11501756f, 0.74933052f, -0.14111365f, 0.12205860f, -0.00273958f, 
    -0.04654390f, 0.08967680f, -0.09884820f, 0.01353304f, 0.10733899f, 0.13088506f, 0.06737012f, -0.18205135f, 
    -0.10502225f, -0.10675290f, -0.02315563f, -0.13823128f, 0.00013990f, -0.09463262f, 0.14613871f, 0.12935635f, 
    -0.16652694f, 0.12289199f, -0.08661005f, -0.18780454f, -0.05777627f, -0.09785161f, -0.15700296f, -0.12116408f, 
    -0.12342454f, 0.10976182f, 0.01591185f, 0.15247041f, -0.03186685f, -0.08144221f, -0.15833056f, -0.07521375f, 
    0.00894855f, -0.06080481f, 0.09433827f, -0.48805171f, 0.06906477f, -0.09134159f, -0.39455941f, -0.02440752f, 
    -0.48375410f, -0.07933040f, -0.02288215f, -0.02392064f, 0.41913468f, 0.23733884f, 0.10404155f, 0.49298176f, 
    -0.09160487f, 0.05984451f, 0.28615203f, -0.36647037f, 0.23892197f, -0.05635915f, -0.16530862f, 0.25795349f, 
    -0.05268075f, -0.02965907f, -0.18811126f, 0.20135176f, -0.33711496f, -0.15649770f, 0.10452480f, 0.15118040f, 
    -0.11514718f, -0.18964195f, -0.11865152f, -0.00969962f, -0.07629488f, -0.00817885f, -0.23416109f, -0.23165783f, 
    -0.14278287f, 0.08695601f, 0.01736061f, 0.08584867f, -0.07901486f, -0.04347898f, -0.14919686f, 0.06772458f, 
    0.09232946f, -0.14468046f, -0.08846347f, -0.02602581f, -0.17194071f, -0.02960030f, -0.09163233f, -0.05699183f, 
    0.10044675f, -0.12138099f, -0.10124234f, -0.10848053f, 0.10870092f, -0.14949636f, 0.03773002f, 0.01371106f, 
    0.02205367f, -0.24377584f, 0.21671332f, -0.23878573f, 0.10330762f, 0.05912504f, -0.12017409f, 0.19679506f, 
    -0.38951269f, -0.15622465f, 0.09824615f, -0.29190159f, 0.13438590f, -0.00835474f, 0.50403428f, 0.35380399f, 
    0.10659566f, 0.11139566f, -0.10830305f, -0.13138826f, 0.19770481f, -0.09418084f, 0.44166857f, 0.09450953f, 
    -0.44787756f, 0.28311929f, -0.50998175f, -0.00608495f, 0.22974053f, 0.25855845f, -0.04326395f, 0.21290429f, 
    -0.13249479f, -0.14657699f, -0.09607986f, 0.04459457f, 0.02340066f, 0.02587423f, 0.07175955f, -0.13742615f, 
    -0.37941107f, 0.12006605f, 0.05181166f, -0.29562524f, 0.20530468f, 0.32825702f, 0.12741092f, -0.04386874f, 
    0.17107753f, -0.00459243f, -0.22686334f, 0.04118406f, 0.15222588f, -0.11293387f, -0.25544631f, -0.04791989f, 
    -0.03653258f, 0.26896766f, -0.26932162f, 0.01974482f, -0.45126405f, 0.15280776f, 0.14039679f, -0.34109151f, 
    -0.28294638f, -0.07512101f, -0.30959198f, -0.12465764f, -0.13366850f, 0.16594772f, 0.05345722f, 0.06660993f, 
    -0.17719221f, 0.05013428f, 0.03382397f, -0.26335898f, -0.07615935f, 0.01503312f, 0.48984426f, -0.23557781f, 
    -0.10236985f, -0.02860871f, -0.44074398f, 0.41677138f, 0.13204467f, 0.07594308f, -0.03658829f, 0.14902747f, 
    -0.07456341f, 0.08894582f, -0.54237312f, -0.05957450f, -0.15637584f, 0.21107167f, -0.06750302f, -0.19713804f, 
    -0.22881448f, 0.19058025f, 0.03303656f, 0.02531436f, 0.16866569f, 0.15418574f, 0.15334420f, 0.01866578f, 
    0.10075185f, -0.01996674f, -0.25524041f, 0.18023044f, -0.10699235f, -0.10206847f, -0.18348655f, 0.13908288f, 
    0.16514631f, -0.06817967f, -0.04509379f, -0.23407981f, -0.04104923f, -0.07713010f, 0.02208543f, -0.07979137f, 
    0.12708400f, 0.12150145f, 0.07926779f, 0.14287387f, 0.48654813f, 0.01092605f, 0.29680130f, 0.04958323f, 
    -0.02499751f, -0.21158026f, -0.02099445f, -0.11378840f, 0.08981980f, 0.15013255f, -0.08814045f, 0.06817330f, 
    0.07242155f, 0.01129796f, -0.06736071f, -0.38871580f, 0.20918459f, 0.23207909f, 0.15322323f, -0.11680561f, 
    -0.06145898f, -0.06042843f, 0.10060834f, -0.06643603f, -0.09444153f, 0.02496339f, -0.00434212f, -0.17291099f, 
    -0.08443446f, -0.18615912f, 0.41135907f, -0.22742359f, 0.14614671f, 0.03041371f, -0.16334088f, 0.07897978f, 
    0.05836673f, -0.32575983f, 0.24293655f, -0.05304726f, 0.02525692f, 0.02133691f, -0.23339052f, 0.21635501f, 
    -0.34187084f, -0.06737193f, -0.09721098f, -0.21622634f, 0.41631821f, 0.03797655f, -0.15151238f, -0.06865218f, 
    -0.14419423f, 0.03550660f, 0.02736543f, -0.15906504f, 0.00267893f, 0.09510103f, -0.17462827f, 0.19711509f, 
    -0.22192790f, -0.02639992f, 0.00975044f, -0.07768190f, 0.63404965f, -0.21790017f, -0.14848801f, 0.30998421f, 
    0.30768856f, -0.16653952f, -0.04949049f, 0.03341753f, 0.03396823f, 0.12867852f, -0.00101658f, 0.05488197f, 
    -0.01811541f, -0.04853759f, 0.12574950f, -0.02043221f, 0.36693543f, 0.34420839f, 0.22467940f, -0.20988962f, 
    -0.02644227f, 0.13061215f, -0.08110996f, 0.25195575f, 0.09252858f, -0.00515842f, -0.09849338f, -0.13659441f, 
    -0.34442943f, 0.05586564f, -0.17002206f, 0.15724507f, -0.54112858f, 0.18295763f, -0.12159870f, -0.12077066f, 
    -0.20080750f, -0.01861753f, 0.19176015f, 0.22220679f, 0.07936204f, 0.01208678f, 0.21997868f, -0.31667328f, 
    -0.29954433f, 0.11948428f, 0.18022306f, -0.32990408f, 0.13884030f, 0.43188050f, -0.12282621f, -0.08699182f, 
    -0.07798908f, -0.03528989f, -0.34167826f, 0.13404414f, 0.07276077f, 0.05182911f, -0.17493741f, -0.15975544f, 
    -0.34810659f, 0.31802300f, -0.38387352f, 0.00809930f, -0.40131572f, 0.32319155f, -0.15222050f, -0.30704331f, 
    -0.22072001f, 0.25549582f, -0.05191379f, -0.01676736f, 0.39334807f, 0.08634270f, 0.00627252f, -0.23078839f, 
    0.67967665f, 0.24174650f, 0.07286863f, 0.52283460f, -0.43882334f, -0.04425870f, -0.04558494f, -0.21212608f, 
    0.17168112f, -0.04056057f, 0.29742670f, -0.00247033f, 0.19130699f, -0.07804761f, 0.01582127f, -0.02773629f, 
    -0.12930211f, 0.18251447f, -0.05733210f, 0.06619196f, 0.14632109f, -0.00980846f, -0.11078266f, -0.25514168f, 
    0.04447468f, -0.12360994f, -0.06092112f, 0.02957316f, -0.15899871f, -0.13537940f, -0.11921533f, -0.09820578f, 
    -0.12646542f, -0.10245775f, -0.14038792f, 0.15628497f, -0.16001172f, 0.01602288f, -0.01293362f, -0.16886272f, 
    -0.15261076f, -0.11894193f, 0.06993915f, -0.16823837f, -0.09719826f, -0.16236833f, -0.08436969f, -0.04481542f, 
    0.09843796f, 0.09690481f, 0.01186200f, -0.07749176f, -0.07188659f, -0.17111377f, -0.08513362f, -0.11282724f, 
    0.04966281f, 0.20993693f, 0.28311604f, 0.13974060f, 0.13598049f, 0.03370886f, 0.06326504f, -0.03763623f, 
    -0.05743989f, 0.27895620f, 0.28287959f, 0.04780315f, -0.18802059f, -0.23546532f, -0.39203310f, 0.09334482f, 
    0.13110438f, 0.09749143f, 0.09589855f, -0.16841748f, 0.19173904f, -0.01859436f, 0.11435629f, -0.01142098f, 
    -0.03773831f, -0.10074928f, 0.16694337f, -0.03902035f, 0.41891328f, -0.13766752f, -0.23582421f, 0.20013256f, 
    -0.10164669f, 0.01828910f, -0.14415149f, -0.22103329f, -0.11052423f, -0.04229975f, -0.18514982f, 0.00957682f, 
    -0.07598519f, 0.19829138f, 0.21545635f, -0.26175037f, 0.01091895f, 0.02290775f, 0.00545050f, 0.06682707f, 
    -0.16946714f, -0.08459623f, 0.09626608f, -0.20546427f, -0.11677025f, 0.17179772f, 0.02502963f, -0.18005320f, 
    0.05072973f, -0.13656358f, 0.29923779f, 0.00407650f, -0.24778217f, 0.00876923f, 0.07407673f, 0.07543491f, 
    0.05759415f, -0.13090950f, -0.00123115f, -0.37388030f, 0.10065175f, 0.09910893f, -0.27139831f, 0.16949639f, 
    -0.23693356f, 0.04226482f, 0.22460660f, -0.05276103f, 0.06977390f, 0.02385066f, 0.26251417f, 0.23648863f, 
    -0.13069111f, -0.09428640f, -0.15977365f, 0.12593535f, 0.22915143f, -0.01219724f, 0.32117212f, -0.05226275f, 
    0.05330871f, 0.04743551f, 0.24851964f, -0.36085445f, -0.18112095f, -0.17248757f, -0.08225917f, 0.31637591f, 
    -0.32163644f, -0.22028758f, 0.16217148f, -0.17199658f, 0.02772772f, -0.17953649f, 0.06913288f, -0.01669765f, 
    -0.26410100f, 0.25254634f, 0.07392641f, -0.18263566f, -0.17471212f, 0.14975496f, -0.05810256f, -0.21520635f, 
    -0.14561245f, -0.14938800f, 0.20393917f, 0.07890183f, 0.26415843f, 0.17170784f, -0.51107407f, 0.23707478f, 
    -0.06553537f, -0.09058801f, 0.22577566f, 0.04841692f, -0.23256060f, -0.21739297f, -0.34372297f, 0.13893987f, 
    0.05357921f, -0.13947211f, 0.22638872f, -0.14043990f, 0.14454043f, -0.03398254f, -0.19648841f, -0.09461316f, 
    -0.04388335f, -0.14040914f, -0.22316238f, -0.11527726f, 0.14645904f, -0.29262036f, -0.01772194f, 0.12336721f, 
    -0.14196908f, 0.00798934f, -0.22167943f, -0.13053244f, 0.16491096f, 0.08466116f, 0.07312878f, 0.16176642f, 
    0.13170592f, -0.09201479f, 0.19651419f, -0.09948131f, -0.01975108f, -0.26863557f, -0.01591311f, 0.08419214f, 
    0.03977218f, 0.00051109f, -0.13619690f, -0.09094953f, -0.14831665f, -0.05571100f, 0.04046868f, -0.01407986f, 
    -0.04484044f, -0.19058895f, 0.11179798f, -0.09782530f, -0.06158027f, -0.17622434f, 0.04650241f, -0.00703251f, 
    -0.05970183f, -0.07921582f, 0.11519288f, -0.09425747f, -0.01750577f, -0.02291151f, 0.01631268f, -0.00209896f, 
    -0.17974715f, 0.00384157f, -0.16942954f, -0.07989084f, 0.14273162f, -0.20191464f, 0.01810055f, -0.05694532f, 
    0.00358969f, -0.15325265f, -0.10550824f, 0.15587381f, 0.13675675f, 0.11117852f, -0.17543478f, -0.19495443f, 
    -0.25772449f, -0.26439044f, 0.02769938f, -0.28257081f, 0.15999520f, 0.13749905f, -0.07515331f, 0.01190351f, 
    0.01252632f, -0.00826610f, 0.15218180f, 0.05509200f, -0.22878070f, -0.00685438f, 0.43574548f, -0.06936069f, 
    -0.07643493f, 0.17647590f, 0.21121116f, 0.00660496f, -0.45079893f, 0.06693144f, 0.13542625f, 0.07401910f, 
    0.09815270f, -0.10728396f, -0.22435746f, -0.16266042f, 0.23025410f, 0.15888971f, -0.06012108f, -0.14475234f, 
    0.18386531f, 0.24166268f, 0.13050084f, 0.14678022f, -0.36567140f, 0.12717609f, -0.11896326f, -0.12024328f, 
    0.16004315f, -0.16782430f, -0.26471612f, 0.30560145f, 0.01091338f, -0.10661964f, 0.02994905f, -0.12243305f, 
    -0.21625240f, 0.08115149f, -0.17281154f, -0.19857773f, -0.40128571f, 0.13943113f, -0.45127520f, -0.05736860f, 
    0.01566187f, 0.28216299f, 0.17764574f, -0.19670944f, 0.09757243f, -0.03804804f, -0.04932342f, 0.16267779f, 
    -0.04102699f, -0.08885579f, -0.17726213f, -0.04532816f, 0.21984188f, -0.22239245f, 0.36957783f, 0.39520639f, 
    0.09762751f, -0.08384229f, 0.12534192f, -0.16497020f, 0.23866743f, -0.14721884f, 0.10062780f, 0.07866683f, 
    0.09391864f, -0.16521665f, -0.10295258f, 0.04040647f, 0.18204394f, -0.06226519f, 0.14032266f, -0.17232275f, 
    0.06648725f, 0.07955195f, -0.12650312f, 0.10829586f, 0.06564598f, 0.09389104f, 0.02739721f, -0.17711778f, 
    -0.07929827f, -0.16840626f, -0.09979978f, -0.08200013f, 0.04875189f, 0.13491774f, -0.19887151f, -0.04509849f, 
    0.01714983f, -0.06881069f, -0.19464625f, -0.13742761f, -0.15900265f, -0.11782607f, 0.09625622f, 0.11177229f, 
    -0.09742744f, 0.12123573f, -0.15552397f, -0.03287438f, 0.08165278f, -0.12547413f, -0.09745690f, -0.15719217f, 
    -0.10162137f, -0.06365304f, -0.04679112f, -0.02730907f, -0.15284440f, -0.00755276f, -0.24884543f, -0.21119504f, 
    0.03999976f, -0.21045455f, -0.25737041f, -0.14669427f, -0.11833914f, -0.13249585f, -0.02199925f, -0.05064913f, 
    -0.12717329f, 0.07959156f, 0.09138893f, 0.08742850f, -0.06648198f, 0.07946961f, 0.06057686f, -0.29126748f, 
    0.14213771f, -0.21953452f, 0.01506896f, -0.02830887f, -0.02901454f, 0.05491648f, -0.04076771f, -0.12549438f, 
    0.19830140f, 0.29351535f, 0.14277819f, 0.24742052f, 0.23798348f, -0.17350373f, -0.09420734f, -0.31993803f, 
    -0.00430925f, 0.10921856f, -0.00930391f, 0.14197008f, -0.16831492f, 0.03075133f, -0.25691888f, 0.04781616f, 
    0.08005027f, 0.06788081f, 0.28437179f, -0.36938170f, 0.20435452f, -0.06167743f, -0.09851688f, 0.12553406f, 
    -0.24640548f, 0.19602589f, -0.04836827f, 0.27157572f, -0.29071897f, -0.19684426f, 0.10814224f, -0.09901486f, 
    -0.20690230f, -0.17150113f, 0.34772784f, -0.01712767f, -0.05231543f, -0.01283150f, 0.00592495f, 0.25284997f, 
    -0.22257127f, -0.28823084f, 0.05959318f, -0.16647761f, 0.01979991f, 0.03178701f, 0.33454648f, 0.14406137f, 
    -0.14008236f, 0.15176019f, -0.35337991f, 0.29766393f, -0.02718061f, -0.09690035f, 0.09818380f, 0.04238670f, 
    -0.19075191f, 0.24150324f, -0.25776580f, 0.06207190f, -0.06464435f, 0.25217694f, -0.07267791f, 0.05495565f, 
    0.22540468f, -0.13179590f, 0.22366111f, -0.01050181f, 0.16350392f, 0.01439093f, -0.32771090f, 0.14566587f, 
    -0.34986094f, 0.01190972f, 0.04464280f, -0.15355542f, 0.24145374f, -0.11116352f, 0.00115617f, 0.25618714f, 
    -0.14973836f, -0.11011118f, -0.15504235f, 0.04589441f, 0.27726236f, -0.14602321f, 0.52898973f, 0.08661807f, 
    -0.33394545f, 0.03508186f, -0.27128267f, -0.41933721f, 0.03627352f, -0.09446792f, 0.06310960f, 0.38553756f, 
    -0.17769268f, -0.00890328f, 0.02996600f, -0.28601632f, -0.07078162f, -0.02915076f, -0.07052260f, 0.21376108f, 
    0.06392955f, 0.05333463f, 0.04442367f, -0.14695249f, -0.04480562f, -0.38917014f, 0.29668412f, 0.09987947f, 
    -0.13192561f, -0.07394125f, 0.07799621f, 0.04999334f, 0.13592230f, 0.12157331f, 0.40605813f, -0.12654170f, 
    -0.24865443f, 0.08575939f, -0.31269339f, 0.17584325f, 0.58875233f, -0.10179704f, 0.00298608f, 0.32315600f, 
    -0.02174799f, 0.12572204f, 0.10046974f, 0.04653658f, -0.17153092f, -0.01938894f, -0.14496921f, -0.14474373f, 
    -0.04856957f, -0.07528945f, -0.11199772f, 0.14340451f, -0.19349048f, 0.11570520f, 0.07031813f, 0.00870661f, 
    -0.08830692f, -0.09057124f, 0.13885109f, -0.02569247f, -0.03435875f, 0.10777678f, -0.17044947f, -0.18035036f, 
    -0.07120311f, -0.04852230f, 0.09699102f, -0.09651059f, 0.11813039f, -0.10030522f, -0.15774418f, -0.11629035f, 
    0.00552858f, 0.19265717f, -0.22703797f, 0.04507727f, 0.02387764f, 0.14001244f, 0.13132356f, -0.00653943f, 
    -0.23104639f, -0.32924467f, 0.35178232f, -0.80558497f, -0.15498129f, 0.18688755f, 0.23625202f, 0.08673869f, 
    -0.11454839f, -0.02508433f, 0.10795064f, -0.17351289f, 0.00307281f, -0.15206999f, -0.06424601f, -0.04947077f, 
    0.09915248f, -0.16429012f, 0.34252560f, 0.24254301f, -0.18304573f, -0.21201661f, 0.09315921f, 0.24958958f, 
    -0.19662915f, -0.27612305f, 0.16349651f, -0.16927515f, 0.28488711f, 0.00735791f, -0.09594162f, 0.13575427f, 
    -0.22718264f, -0.02840450f, -0.09540750f, -0.30678383f, 0.10670295f, 0.22958924f, 0.38840646f, -0.05229174f, 
    0.13098177f, 0.03330053f, -0.60453856f, 0.26539657f, 0.21682182f, 0.13288318f, -0.02564637f, 0.08608195f, 
    -0.06507098f, 0.26695445f, -0.06204290f, -0.43867829f, -0.10480102f, 0.14332615f, -0.24827634f, -0.12300851f, 
    -0.07194225f, -0.08425825f, 0.03669981f, -0.06140210f, -0.07920402f, -0.16468731f, 0.06493569f, -0.11056471f, 
    0.01678528f, -0.14852332f, -0.11412410f, -0.12812559f, 0.07510155f, -0.12217028f, -0.01474480f, 0.13482319f, 
    0.08905675f, 0.10055890f, -0.11328472f, -0.04981209f, -0.00451285f, -0.12721781f, -0.01922819f, -0.12076598f, 
    0.00044290f, -0.02049454f, -0.06828000f, 0.07429387f, -0.06027821f, 0.08468939f, 0.06301820f, -0.14167048f, 
    0.04852713f, -0.01284319f, -0.20479454f, -0.29471216f, 0.12616727f, 0.02457445f, -0.09404694f, 0.25187269f, 
    -0.07146593f, -0.09036852f, 0.02872936f, -0.03941828f, 0.10056386f, -0.10258731f, 0.34431976f, -0.15098156f, 
    0.17040324f, 0.03167011f, -0.28192687f, 0.01226384f, 0.05188711f, 0.12833330f, 0.20894146f, -0.20388359f, 
    -0.00375145f, 0.05728540f, -0.03959951f, 0.07223698f, 0.51264256f, 0.10136894f, -0.15639760f, 0.21873535f, 
    0.07521653f, 0.15831199f, -0.02408666f, 0.18046050f, 0.00182044f, 0.07825764f, -0.02924959f, -0.23667662f, 
    0.01309705f, 0.16865629f, 0.21627121f, 0.05302631f, -0.12983125f, 0.49743691f, 0.16545497f, 0.28955549f, 
    0.15837260f, -0.13732933f, 0.24235713f, -0.01179379f, 0.07708012f, 0.04842616f, -0.48543906f, -0.00874052f, 
    -0.11280426f, -0.08368474f, 0.14436381f, 0.06855215f, -0.47581205f, 0.00927247f, 0.23892760f, -0.10170241f, 
    -0.19678225f, -0.18406674f, -0.11689118f, -0.00560258f, -0.18678021f, 0.12630588f, -0.19809018f, -0.03466654f, 
    -0.07586173f, 0.07638082f, -0.14989661f, 0.13456732f, -0.08388360f, -0.17189263f, 0.03958101f, -0.16824239f, 
    0.13589641f, -0.01068880f, -0.17122670f, -0.07278517f, 0.08875305f, -0.07828752f, -0.09016992f, 0.01793734f, 
    0.08689716f, -0.15474986f, -0.02396107f, 0.04649327f, -0.06674623f, -0.09177478f, -0.08918881f, -0.08571450f, 
    0.32356712f, 0.25875852f, -0.26463097f, 0.06335776f, -0.08454646f, -0.08335777f, -0.26835051f, 0.03471323f, 
    -0.03184328f, 0.26202074f, 0.18596451f, 0.18085110f, 0.33992842f, 0.39565927f, -0.01342836f, 0.02775649f, 
    -0.06150474f, 0.00457526f, 0.00913245f, -0.25538790f, -0.07143428f, 0.14196253f, -0.28050837f, 0.11521107f, 
    -0.08181562f, -0.01191328f, 0.01410854f, -0.07314929f, -0.28410074f, 0.01371673f, 0.15424651f, -0.05290550f, 
    -0.44500744f, 0.05358960f, 0.04234947f, -0.02413834f, 0.23424129f, -0.01058048f, 0.22681732f, -0.23465149f, 
    0.29814118f, 0.06099138f, 0.29615295f, -0.09608957f, -0.28321904f, 0.23596196f, 0.23659648f, -0.12600774f, 
    -0.12113928f, -0.06646250f, -0.21293008f, 0.22504215f, 0.03336088f, 0.07994374f, 0.36215344f, -0.22202577f, 
    -0.42016938f, 0.19397181f, 0.14394960f, -0.44785532f, -0.09168556f, 0.27678165f, 0.09144302f, 0.12112560f, 
    0.09784323f, 0.09664422f, -0.14131142f, 0.06744359f, -0.01583034f, -0.04117908f, 0.04458466f, -0.30070549f, 
    -0.05136459f, 0.00294882f, 0.09904417f, 0.00307680f, -0.03386515f, 0.06859003f, 0.12594071f, -0.46934563f, 
    0.08413594f, -0.00251557f, 0.12670635f, 0.05785140f, -0.04735662f, 0.00690637f, 0.35063440f, -0.05830682f, 
    0.11603625f, -0.18030025f, 0.34445152f, -0.15016350f, 0.07492721f, 0.07713223f, -0.09779806f, -0.38304502f, 
    0.05621277f, -0.33598348f, -0.23855208f, 0.03625550f, 0.19788510f, 0.16575967f, -0.22649817f, -0.05330817f, 
    -0.10153642f, 0.14676422f, 0.01886184f, -0.11919667f, -0.17703117f, 0.22403468f, 0.00472096f, -0.50628424f, 
    -0.06723301f, -0.16429441f, 0.35007009f, 0.05935417f, -0.15081751f, -0.14846221f, 0.15632224f, -0.24047659f, 
    0.01410573f, -0.16184735f, -0.33215865f, 0.15697977f, -0.44728172f, 0.09462219f, 0.17338969f, -0.28902593f, 
    0.08125434f, -0.21445619f, -0.17925645f, -0.01219762f, 0.21726418f, 0.10823682f, 0.02017820f, -0.19877747f, 
    0.14604869f, 0.01843876f, -0.01419303f, 0.16918306f, 0.17068972f, 0.26968729f, 0.16550262f, -0.05862151f, 
    0.01440295f, -0.10051941f, 0.08681490f, 0.09176425f, 0.09038657f, 0.18252203f, 0.36388493f, -0.23096906f, 
    0.06450374f, 0.05854223f, 0.19011310f, -0.43677643f, -0.32697335f, 0.09225221f, -0.03834882f, 0.06542844f, 
    -0.06947526f, -0.04513729f, 0.19628257f, 0.05391136f, -0.28854299f, 0.11500371f, 0.01071024f, 0.06777636f, 
    -0.05587627f, 0.16968478f, -0.03737077f, 0.01686066f, 0.25320989f, 0.31289604f, -0.18653074f, -0.26291832f, 
    0.00759808f, 0.05317738f, -0.07086513f, -0.08093368f, 0.12843321f, 0.01117586f, -0.14682448f, 0.18456873f, 
    -0.25125316f, 0.24239163f, -0.08039833f, 0.32154337f, -0.37735882f, 0.01026687f, 0.03064442f, -0.24312803f, 
    0.16582195f, 0.08802536f, 0.01113560f, -0.03431619f, 0.00555386f, 0.02816532f, -0.12722391f, -0.09267067f, 
    -0.18312988f, -0.03853836f, -0.06814823f, -0.32205462f, 0.16960666f, -0.00237227f, 0.59706610f, 0.21948914f, 
    0.15896301f, -0.02398764f, -0.35265452f, 0.14689785f, -0.07138177f, -0.04333758f, 0.43235543f, -0.00155334f, 
    -0.31711885f, 0.23225577f, -0.30362174f, -0.07312422f, 0.23363608f, 0.22773570f, 0.08502857f, 0.22498830f, 
    0.02123215f, 0.35134053f, 0.09756125f, 0.13327129f, 0.06198872f, 0.13957280f, 0.16869596f, -0.34716079f, 
    0.44716647f, 0.32236886f, 0.41145492f, 0.24544369f, -0.00409804f, 0.32035020f, -0.22677159f, -0.19415408f, 
    0.12942633f, 0.01432825f, 0.13508582f, 0.01761224f, 0.06392995f, 0.14025863f, 0.00882186f, 0.04383004f, 
    -0.26168826f, -0.06245060f, 0.22034946f, 0.08213117f, -0.20801184f, 0.07909172f, -0.02599234f, -0.26628444f, 
    -0.03487215f, -0.01375291f, 0.28479522f, 0.30569315f, 0.21798250f, -0.07624152f, -0.00410043f, -0.30617085f, 
    -0.23017798f, -0.00937141f, 0.08497820f, -0.27502722f, -0.29549760f, 0.08450109f, -0.16282627f, 0.01826925f, 
    0.04511865f, -0.14847155f, 0.16672644f, 0.20986223f, -0.01991205f, 0.16238914f, -0.00756059f, 0.06500714f, 
    -0.16802041f, 0.16433868f, -0.17402546f, 0.05878900f, -0.01041208f, 0.08837958f, -0.08487216f, -0.08988107f, 
    -0.38816983f, -0.30246040f, -0.19378039f, -0.09281228f, 0.11596073f, -0.02741043f, -0.27398068f, 0.19418186f, 
    -0.37159187f, -0.04493937f, -0.28599665f, -0.08553294f, 0.11081722f, 0.24640583f, 0.37936848f, 0.03130957f, 
    -0.06835604f, 0.08923584f, -0.08007829f, 0.22947182f, 0.26289928f, 0.03439357f, -0.34213823f, 0.13712984f, 
    0.02142713f, 0.03834544f, -0.38650230f, 0.06252456f, 0.20053692f, 0.01738736f, 0.01236388f, 0.01405638f, 
    0.23748313f, -0.15830012f, 0.20066321f, -0.04941032f, 0.28294343f, 0.13000898f, -0.01081665f, -0.03721800f, 
    0.21878743f, 0.26231906f, 0.01111251f, 0.04380358f, -0.02823885f, 0.06393135f, -0.10710134f, -0.02660463f, 
    0.15850349f, 0.03063174f, -0.40846393f, 0.11693825f, -0.07181882f, 0.05021563f, -0.06141165f, -0.00006519f, 
    0.03730873f, -0.00992523f, 0.23790929f, -0.45200685f, 0.14702538f, 0.10361965f, -0.12250590f, 0.08867256f, 
    -0.06301196f, 0.17545918f, -0.26089621f, 0.04164708f, 0.25513822f, 0.00412131f, -0.21020865f, 0.00087798f, 
    0.44990376f, 0.36987036f, 0.15628107f, 0.20435929f, 0.37143940f, 0.04479787f, -0.21047823f, -0.22112349f, 
    -0.16663758f, -0.01964601f, 0.06495901f, 0.07755991f, 0.12123992f, -0.09967761f, 0.38144600f, -0.29542390f, 
    -0.35781953f, 0.18672451f, 0.43952698f, -0.68627578f, 0.05077605f, 0.02261717f, -0.11282153f, 0.02996326f, 
    -0.20321792f, -0.05339180f, -0.28314319f, -0.21411608f, -0.24163622f, 0.09702758f, 0.09531245f, 0.13071573f, 
    0.22374173f, -0.07602619f, 0.17120565f, 0.12714235f, -0.30489957f, 0.09244534f, 0.22079389f, -0.26971886f, 
    0.03346719f, 0.07180642f, 0.10040066f, 0.07353452f, -0.01146730f, 0.10895500f, -0.02113090f, 0.09544029f, 
    0.17200275f, 0.15520781f, 0.20933023f, 0.11252128f, -0.32107541f, -0.01083734f, 0.12985696f, -0.12765813f, 
    -0.47451216f, 0.33778876f, 0.19712363f, 0.19576259f, 0.38820118f, -0.14153366f, 0.15333125f, -0.01985608f, 
    0.31931394f, -0.14317988f, -0.05497669f, -0.03102092f, -0.19566688f, -0.12643224f, -0.18845080f, -0.22246021f, 
    0.00426257f, 0.15443426f, 0.23875976f, 0.13644655f, -0.08739472f, -0.09108002f, 0.34481215f, 0.11941230f, 
    -0.29290169f, -0.10074414f, 0.21606146f, -0.31517455f, 0.49134138f, 0.09048244f, -0.05615032f, 0.18416274f, 
    -0.20538361f, -0.10457977f, -0.19601189f, -0.20188524f, -0.21202275f, -0.07115658f, 0.01758268f, -0.06378299f, 
    -0.43971527f, 0.03837428f, -0.08127894f, -0.28731737f, 0.24215837f, 0.24558848f, 0.30627280f, 0.08800883f, 
    -0.09466984f, -0.00881737f, 0.10259646f, 0.04116302f, 0.28281233f, -0.06112288f, 0.43181074f, 0.15215437f, 
    0.22800964f, 0.06029145f, 0.03201529f, -0.33215374f, -0.46536162f, 0.03140662f, 0.19778498f, 0.08504978f, 
    -0.00886195f, 0.07370653f, 0.23671584f, 0.07249168f, -0.15211669f, -0.04439431f, 0.05541002f, 0.12515526f, 
    -0.17223999f, 0.08080464f, 0.23626807f, -0.01456049f, 0.21803193f, 0.08961971f, -0.07362595f, -0.58302104f, 
    -0.18829218f, -0.06478123f, 0.15992588f, 0.13387412f, -0.15836100f, 0.05995644f, 0.19081777f, -0.11755537f, 
    -0.20983395f, 0.25910291f, 0.04046846f, 0.27492905f, -0.34973574f, 0.00580940f, -0.30689004f, -0.21288224f, 
    -0.11232594f, -0.05417823f, 0.23612265f, 0.10001706f, 0.31474084f, 0.01401314f, 0.29446378f, -0.35622910f, 
    -0.14307621f, -0.01960158f, 0.16107731f, -0.06586805f, -0.33193916f, 0.01760981f, 0.09736291f, -0.13612957f, 
    0.01867538f, -0.05895503f, -0.13214125f, 0.20562941f, 0.19418083f, 0.14711070f, 0.34433308f, -0.34965566f, 
    -0.38600439f, 0.25157428f, -0.04134948f, -0.23335445f, 0.26257125f, 0.07646685f, -0.44637701f, -0.32794172f, 
    -0.52563792f, -0.12914757f, 0.07703720f, -0.35341787f, -0.07317296f, 0.14966443f, 0.20719351f, 0.15919544f, 
    0.15100946f, 0.02288550f, 0.29499161f, -0.26011658f, -0.41393262f, -0.18928504f, 0.27550706f, 0.02119002f, 
    -0.03371550f, 0.01792120f, -0.33943522f, 0.09122733f, 0.16863681f, 0.11016838f, 0.21422306f, -0.12968272f, 
    -0.13265786f, 0.14961638f, 0.11790790f, 0.18943666f, 0.28661886f, 0.13718379f, -0.31332639f, -0.07599721f, 
    0.19953015f, -0.06401624f, -0.01888792f, -0.09503973f, -0.17070019f, -0.13886961f, 0.00486979f, -0.05653293f, 
    -0.12911746f, -0.41991878f, -0.37660486f, -0.10371339f, 0.02948675f, -0.15227254f, -0.13385656f, -0.39526317f, 
    -0.07380234f, 0.07824625f, 0.12566236f, 0.09163901f, -0.32220119f, -0.08121054f, -0.14556469f, 0.06383654f, 
    0.21270001f, -0.18767652f, -0.01143077f, -0.10168222f, 0.07128935f, -0.17227332f, -0.12992558f, 0.04313478f, 
    -0.18732306f, 0.00990543f, 0.00869629f, -0.03668314f, -0.09642099f, -0.05364109f, -0.11358463f, 0.21443065f, 
    0.24704193f, 0.20837003f, -0.17240247f, 0.19419602f, 0.04501690f, -0.20169830f, 0.03977351f, -0.33179793f, 
    0.00668557f, 0.11582382f, -0.17389230f, 0.12344632f, -0.05019034f, -0.12341743f, 0.30484468f, 0.10752283f, 
    0.00350876f, 0.12673022f, 0.13151987f, -0.25077888f, 0.37479565f, 0.22109863f, -0.03543916f, 0.03295042f, 
    -0.46891740f, 0.09769140f, 0.12277096f, -0.03141614f, 0.03093337f, 0.06616256f, 0.13470332f, -0.27325469f, 
    -0.17072454f, -0.09123150f, 0.33379713f, -0.23742048f, -0.58883977f, 0.22711180f, -0.19994128f, 0.18980381f, 
    -0.17194514f, 0.01604296f, -0.00778215f, -0.12423340f, 0.09513679f, -0.14285512f, -0.36222801f, 0.05216514f, 
    0.13100429f, 0.19457965f, 0.18829556f, 0.34802487f, 0.27405885f, 0.12963450f, -0.03882879f, 0.06992736f, 
    -0.02350084f, -0.21365835f, 0.07042045f, -0.18156499f, -0.26870519f, -0.01270057f, 0.02110902f, 0.01553870f, 
    0.07522090f, -0.13380501f, -0.21614064f, -0.04278200f, -0.06273406f, -0.06223289f, 0.06238570f, -0.00548421f, 
    0.07874475f, 0.02332411f, -0.07681842f, 0.07594237f, -0.10892506f, -0.16210976f, -0.17450586f, -0.09669273f, 
    0.06682494f, -0.08453846f, 0.21210502f, -0.10848850f, 0.19868797f, -0.03313386f, -0.02805784f, 0.20921396f, 
    0.09694427f, 0.05004495f, -0.14007244f, 0.01605699f, -0.16853960f, -0.00241596f, -0.22393438f, -0.16508332f, 
    -0.04745341f, -0.00853453f, -0.03789262f, 0.02094702f, -0.04324037f, -0.07853135f, -0.16888826f, -0.01953763f, 
    -0.13142981f, 0.07886457f, -0.11797229f, 0.07874835f, -0.14855602f, 0.06560087f, -0.04848693f, -0.06222185f, 
    -0.00870132f, -0.19047080f, 0.00301988f, 0.09735551f, 0.11521393f, -0.01424250f, -0.12947647f, -0.10032358f, 
    0.08076853f, -0.03731347f, 0.24416302f, 0.15201090f, 0.11937780f, 0.07230098f, 0.04401037f, 0.07717161f, 
    0.32275328f, 0.00209812f, 0.19047129f, 0.19535980f, 0.21863039f, -0.05327110f, -0.25093988f, -0.06763211f, 
    0.16515541f, 0.15264198f, -0.12544027f, -0.13335794f, -0.20221092f, 0.01303135f, 0.29068828f, -0.30195048f, 
    -0.04682192f, 0.14261922f, 0.13627444f, -0.16614406f, 0.04685978f, 0.09227090f, -0.09663104f, 0.18817724f, 
    -0.14048924f, -0.06989279f, 0.00075137f, -0.10797046f, -0.31006515f, -0.00639573f, -0.05317493f, -0.10632180f, 
    -0.06138448f, -0.49107340f, -0.00684355f, 0.02881151f, 0.15795542f, 0.17855594f, -0.15730800f, 0.15121983f, 
    -0.00094693f, -0.12753795f, 0.22135742f, 0.01624504f, -0.18861067f, 0.05326462f, -0.18788448f, -0.23968209f, 
    0.11896733f, -0.35161689f, -0.04401818f, 0.16454299f, -0.11414152f, 0.07076338f, -0.32592013f, -0.02478252f, 
    0.06535795f, 0.19073765f, -0.06835936f, 0.17845334f, 0.10988530f, 0.17262234f, 0.04532638f, -0.07423752f, 
    0.20134576f, 0.11159506f, -0.24666132f, 0.13171953f, 0.20713696f, -0.13803408f, 0.19081722f, 0.29819804f, 
    0.06114557f, 0.17400487f, 0.33197129f, -0.23594032f, 0.13037790f, -0.00321921f, 0.09609825f, 0.15815385f, 
    -0.07848624f, -0.01318026f, -0.10460109f, 0.26958159f, 0.32008019f, -0.19466010f, -0.01884071f, 0.06070229f, 
    0.13633981f, 0.01948844f, 0.28574094f, -0.12006248f, 0.00081917f, 0.13884048f, -0.52159971f, 0.10628978f, 
    -0.16775569f, 0.01226468f, -0.18471798f, -0.12339535f, 0.14405061f, 0.36123249f, 0.21869922f, 0.48730800f, 
    0.03385349f, -0.09918615f, -0.70151132f, -0.25541550f, -0.01878679f, 0.03301117f, -0.37145171f, 0.26001236f, 
    -0.13898595f, 0.13785405f, -0.25676632f, -0.13316247f, -0.29758203f, 0.03444708f, 0.18760324f, 0.33186218f, 
    -0.38565972f, -0.11046153f, -0.17207249f, -0.09757768f, -0.26029414f, 0.03291278f, -0.23398173f, 0.01840959f, 
    -0.28455916f, -0.14706933f, 0.06719370f, 0.00537265f, 0.09209016f, 0.34606835f, 0.40570149f, 0.00798332f, 
    -0.07487771f, -0.17647384f, 0.39968204f, 0.08569168f, 0.29357734f, -0.02800075f, -0.14499368f, 0.33523741f, 
    -0.17529619f, 0.17245853f, -0.61951739f, 0.23689930f, -0.32395107f, -0.13614170f, 0.09438311f, -0.09229612f, 
    -0.29347429f, 0.18037367f, 0.12398725f, -0.15241867f, 0.18031278f, 0.13024724f, 0.13547331f, -0.14679623f, 
    -0.15927894f, -0.22550993f, -0.19849020f, -0.15385152f, 0.16177443f, 0.03333227f, 0.09603818f, 0.00205609f, 
    0.07352734f, -0.03960988f, 0.15448356f, 0.05924537f, 0.05936215f, -0.08423090f, 0.31821677f, 0.06124728f, 
    0.01055436f, 0.02174936f, 0.18541940f, -0.45248410f, 0.01919028f, 0.14927165f, 0.07041099f, 0.17649043f, 
    -0.21428816f, -0.19685413f, -0.19886872f, -0.39760968f, 0.01656058f, 0.09706085f, 0.00237953f, -0.04207632f, 
    -0.39688018f, -0.19264454f, 0.09036221f, -0.19913208f, -0.15883152f, 0.36611074f, 0.37127972f, 0.01663214f, 
    0.08053356f, -0.00651879f, -0.61756402f, -0.10255439f, 0.24123664f, 0.03564480f, -0.10588416f, 0.12377070f, 
    0.05752485f, 0.21461406f, -0.09079063f, -0.09286211f, 0.01089906f, 0.09786311f, 0.00234959f, -0.02448028f, 
    0.19305885f, -0.19384369f, -0.13903722f, -0.13974868f, 0.03948652f, 0.00439754f, 0.14041705f, 0.27148342f, 
    0.41544193f, 0.08805177f, -0.09848090f, 0.35258773f, 0.15649433f, -0.11394084f, 0.27920797f, -0.22316352f, 
    -0.09167492f, 0.01697255f, -0.30425465f, -0.01357013f, -0.10735155f, 0.17596723f, 0.10329285f, -0.06628056f, 
    0.05104557f, -0.08362479f, 0.02881383f, -0.00393732f, 0.38267216f, 0.21187706f, 0.23967591f, 0.34318274f, 
    -0.00596773f, -0.24357504f, 0.16762674f, -0.25481355f, 0.02650277f, 0.15628716f, 0.31789753f, 0.20850585f, 
    0.15567458f, 0.10674774f, 0.25492981f, 0.00165453f, -0.03058405f, -0.32111907f, -0.28569612f, -0.45811111f, 
    -0.02831702f, -0.05898688f, -0.02021779f, -0.00497116f, 0.19939551f, 0.14175856f, 0.04714166f, -0.10804117f, 
    -0.09176674f, 0.05310200f, 0.26702058f, 0.03094858f, 0.41204801f, 0.03528873f, -0.22710866f, 0.13535067f, 
    -0.00430543f, -0.11556322f, 0.09874711f, -0.02173059f, -0.10288759f, 0.09695220f, -0.15857019f, 0.05467602f, 
    -0.08639345f, -0.01765617f, -0.06939229f, 0.00524811f, -0.21389334f, 0.08864514f, -0.12865737f, -0.08381651f, 
    -0.14408720f, -0.09356353f, -0.04883671f, -0.08682502f, 0.04212600f, 0.17104869f, -0.00835982f, -0.20970237f, 
    -0.01831796f, -0.04622203f, -0.13091667f, 0.09299267f, -0.15813977f, -0.17070231f, -0.15431601f, -0.06748871f, 
    -0.03156385f, -0.30764890f, 0.17879783f, 0.05112929f, -0.20375402f, 0.17401168f, -0.28183115f, 0.21720666f, 
    -0.74051780f, -0.09178746f, -0.18859340f, -0.30851144f, 0.52960116f, 0.07005754f, 0.12088559f, -0.25875688f, 
    0.03116524f, 0.11884502f, 0.09496967f, -0.00993965f, 0.18745039f, 0.09781290f, 0.05938317f, 0.16178958f, 
    -0.15174091f, 0.20540623f, 0.03564738f, -0.21013218f, 0.49918786f, -0.16380531f, -0.08562724f, 0.29933742f, 
    -0.29361993f, -0.08725113f, 0.07480588f, -0.22223003f, -0.10257475f, -0.11306867f, -0.27911824f, 0.03767676f, 
    0.05295626f, -0.23490722f, 0.02950198f, 0.04184988f, 0.04974584f, -0.43447831f, -0.00267817f, 0.02173582f, 
    0.00063782f, -0.08962420f, 0.08751687f, -0.30060610f, 0.18383914f, 0.00630283f, 0.35772812f, 0.20733596f, 
    -0.18511143f, 0.09676298f, -0.18425013f, -0.09855142f, 0.56990033f, 0.13322012f, 0.02429458f, 0.35091516f, 
    -0.01341109f, 0.11724039f, 0.06064800f, 0.01497045f, -0.04290466f, 0.00459788f, -0.03426662f, 0.15083280f, 
    0.02506061f, -0.07716107f, -0.01863881f, -0.03605361f, -0.14044635f, 0.02102957f, -0.12231398f, -0.04228527f, 
    -0.00676063f, -0.12272317f, -0.10650887f, -0.09367643f, 0.01970567f, -0.16677350f, 0.11532046f, -0.13533251f, 
    -0.13716765f, 0.04345012f, -0.07710604f, 0.09612539f, -0.12717323f, -0.17539196f, -0.02511380f, 0.00370575f, 
    -0.14113380f, -0.36530039f, 0.18494660f, -0.13955326f, -0.22022159f, 0.14075680f, 0.08016095f, -0.08986500f, 
    -0.12130803f, -0.06509641f, -0.11758368f, -0.02889191f, -0.07807758f, 0.14577731f, -0.17310627f, 0.32037431f, 
    0.15920259f, -0.12743816f, 0.11366950f, -0.09135025f, -0.17469506f, 0.09885170f, 0.03716136f, -0.16037232f, 
    0.12704335f, -0.25121760f, 0.25466129f, -0.14982846f, 0.09212586f, -0.17381836f, -0.36852741f, 0.02646750f, 
    0.07980590f, -0.33571625f, 0.21797164f, -0.31511047f, 0.02559303f, 0.04791107f, 0.13626331f, 0.16680321f, 
    0.29067975f, 0.27912587f, 0.32173747f, 0.06972514f, -0.07778242f, 0.00253412f, -0.28090125f, -0.24581197f, 
    -0.11970223f, 0.04477476f, -0.17781951f, -0.03041545f, -0.03412647f, -0.09357002f, -0.18854655f, -0.04510581f, 
    0.04973151f, -0.12104381f, 0.25263080f, -0.15142050f, 0.45292473f, -0.03490928f, -0.28004068f, 0.19678362f, 
    0.17125219f, 0.28086576f, 0.10087404f, -0.11689165f, 0.37488288f, 0.03425014f, -0.35618156f, -0.34955108f, 
    0.15716937f, 0.26993781f, -0.23229744f, 0.31427306f, -0.16081192f, 0.02148661f, -0.03706168f, 0.27580482f, 
    0.14101273f, -0.07412885f, 0.15177950f, -0.25818965f, 0.08828188f, 0.08515529f, -0.11281350f, 0.11684955f, 
    0.00891489f, -0.11755370f, -0.00445270f, 0.15123677f, 0.40122765f, -0.00858476f, 0.06581578f, 0.07596125f, 
    -0.11439252f, -0.13698651f, -0.18680404f, -0.48181653f, 0.13595319f, -0.12217379f, -0.18996045f, -0.18792127f, 
    0.08227196f, 0.13682322f, 0.14617449f, 0.03669010f, -0.57811081f, 0.27359813f, 0.23807412f, 0.14472090f, 
    -0.11594944f, 0.08531996f, 0.08086278f, -0.19260159f, 0.14172648f, 0.02110312f, -0.26921245f, 0.17257777f, 
    -0.22945932f, 0.20052870f, 0.00770113f, -0.03493115f, -0.61530930f, 0.04420243f, -0.01391739f, -0.00825792f, 
    -0.13885550f, 0.03960749f, 0.52424580f, -0.11970492f, -0.15873879f, 0.18211798f, -0.16222045f, -0.08051487f, 
    -0.19355910f, -0.22516221f, -0.06686942f, -0.26881036f, 0.03283544f, -0.02729751f, 0.33388183f, 0.33619413f, 
    0.14990193f, -0.00190018f, -0.60013437f, 0.02466573f, 0.24250051f, 0.12047173f, 0.07406840f, 0.24193414f, 
    -0.14820166f, 0.13448444f, -0.47433910f, 0.03308991f, 0.40017420f, -0.00648188f, 0.19699189f, 0.27523428f, 
    -0.16487710f, -0.12572552f, 0.38691288f, -0.03085824f, -0.01264291f, -0.05386079f, 0.03149607f, 0.09613807f, 
    -0.13580194f, -0.00843989f, 0.02960658f, -0.17229412f, 0.04538228f, 0.00993145f, 0.16160882f, 0.22883137f, 
    -0.10947736f, 0.03981087f, -0.07772407f, -0.04025539f, 0.06862432f, 0.05769008f, 0.29513210f, 0.06002088f, 
    0.12621644f, 0.08514840f, 0.03516750f, -0.13385022f, 0.46697307f, 0.13887101f, -0.07025284f, -0.09390220f, 
    0.10710363f, -0.02765606f, 0.21826006f, 0.18906780f, -0.11151695f, 0.01339917f, -0.10209937f, 0.27362719f, 
    0.02176575f, 0.07421444f, -0.31204969f, -0.42075902f, 0.23558053f, -0.36181179f, -0.08132789f, 0.36144561f, 
    -0.05266871f, -0.03535631f, -0.16793039f, 0.05284468f, -0.09781766f, -0.04966249f, -0.46726865f, 0.23556714f, 
    -0.13428482f, -0.11603156f, 0.02180330f, -0.00901892f, 0.05857029f, -0.13498695f, 0.25305572f, 0.11794051f, 
    0.01637657f, -0.07461654f, 0.10001489f, -0.20388846f, -0.11868618f, 0.12730956f, -0.22581530f, 0.06340334f, 
    -0.15437520f, 0.03100201f, 0.11025051f, -0.05276840f, 0.19992000f, -0.06404343f, -0.04355445f, 0.39305636f, 
    -0.11667088f, -0.13597015f, 0.32759297f, -0.48245254f, 0.09260127f, -0.16669439f, -0.16816558f, 0.27443388f, 
    -0.21771188f, -0.09981489f, 0.09480327f, 0.38533783f, 0.33236545f, -0.36281770f, 0.15611216f, 0.28315628f, 
    -0.53232461f, -0.07185103f, -0.04969617f, -0.19816545f, -0.08756903f, 0.15901098f, 0.01428497f, -0.24494624f, 
    -0.23658204f, -0.20173512f, 0.07096790f, -0.33283374f, -0.22141826f, 0.17645819f, 0.37966648f, 0.22315986f, 
    0.02119960f, -0.02357445f, 0.20717114f, -0.26478150f, 0.24116901f, -0.06783319f, 0.27256584f, 0.19305791f, 
    0.14814532f, 0.11922662f, -0.04599058f, -0.05454624f, 0.28063378f, 0.00936183f, 0.20107041f, 0.01956285f, 
    0.09044374f, -0.15383665f, -0.15670307f, -0.02191965f, -0.13138692f, 0.02087169f, -0.13381642f, -0.18353039f, 
    -0.06048412f, -0.05068892f, 0.07008123f, -0.11217020f, -0.07500191f, -0.10561208f, -0.09162587f, -0.12120238f, 
    -0.14439483f, -0.07806657f, -0.14454617f, -0.21518032f, 0.02622107f, 0.13466989f, -0.08168042f, -0.01404523f, 
    0.13078414f, -0.19580702f, -0.18380278f, -0.06737322f, -0.04814033f, 0.08309751f, -0.17787655f, 0.02618925f, 
    0.05825361f, -0.10964536f, -0.04272769f, 0.08322086f, -0.01953417f, -0.08156311f, 0.05395209f, 0.02476103f, 
    0.02004393f, 0.09348823f, 0.12157384f, -0.07297668f, -0.15107720f, -0.08958867f, 0.05143789f, 0.15547113f, 
    -0.03797559f, -0.12844904f, -0.02690592f, -0.11198252f, 0.11825991f, -0.04442292f, -0.07397804f, -0.14553726f, 
    -0.19842175f, 0.00623262f, 0.09562758f, -0.09598903f, 0.07102526f, 0.00258894f, -0.11668775f, -0.12679045f, 
    -0.42177114f, 0.30241394f, -0.15033740f, -0.22023797f, 0.37104049f, 0.08775917f, -0.05826415f, -0.16033988f, 
    -0.00509769f, 0.02742977f, -0.19070515f, 0.04359513f, -0.43381453f, 0.09739903f, 0.24639229f, 0.35861695f, 
    -0.04182056f, -0.15648907f, 0.22905840f, 0.04676800f, 0.24245891f, 0.09586038f, -0.10750140f, 0.14954780f, 
    0.07111805f, -0.16365886f, 0.13615648f, 0.15839855f, 0.47301659f, 0.10478317f, 0.33836040f, 0.08432432f, 
    -0.08835699f, 0.16566181f, -0.12777819f, -0.16485934f, -0.12986170f, 0.12816803f, 0.07509538f, -0.04505000f, 
    -0.08625238f, -0.05593224f, -0.05119934f, -0.08748520f, -0.14392033f, 0.02874021f, 0.09116606f, -0.17459780f, 
    -0.02173481f, -0.11636323f, -0.07288046f, -0.06623774f, 0.13940376f, 0.11528073f, 0.06712702f, -0.06232654f, 
    -0.05930833f, 0.02938180f, 0.02166925f, -0.05591622f, -0.01856242f, -0.14568417f, -0.08772130f, -0.01256213f, 
    -0.62793428f, -0.14873736f, 0.07795995f, -0.33516404f, -0.19090338f, -0.02867225f, 0.00244853f, -0.13863315f, 
    0.14190343f, 0.06745645f, -0.12253607f, 0.07776615f, -0.30661902f, -0.14044018f, 0.20524119f, 0.25764960f, 
    -0.02739405f, 0.02402011f, 0.45289752f, -0.31001577f, 0.22420353f, 0.10964660f, 0.05529291f, 0.22001135f, 
    -0.10240106f, -0.12108224f, 0.12182854f, 0.67638499f, 0.44597232f, 0.08305036f, 0.05888397f, 0.28137356f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.01398489f, -0.20839323f, 0.20061924f, -0.00409475f, 0.25799426f, -0.06569502f, 0.36115786f, 0.05602528f, 
    -0.05777126f, 0.16743758f, 0.25223777f, 0.00804803f, -0.12517527f, 0.14367761f, -0.19080612f, -0.03612145f, 
    0.01500802f, 0.18751773f, 0.19458285f, 0.04987352f, 0.24847898f, -0.25157708f, 0.04096502f, -0.02924302f, 
    0.36488938f, 0.02439993f, 0.32330453f, 0.31381589f, 0.18663122f, 0.08151798f, -0.17641087f, 0.26321366f, 
    -0.00694219f, 0.25624996f, -0.09342120f, -0.15844366f, 0.04315053f, -0.22524932f, -0.06284297f, 0.01074035f, 
    0.00428249f, 0.18626145f, 0.01936263f, 0.05809737f, 0.04947501f, -0.13650577f, 0.20801237f, 0.09486709f, 
    0.11695848f, 0.07514824f, 0.23435117f, 0.16180395f, 0.08353912f, 0.19101383f, 0.07325655f, -0.03333390f, 
    0.08429301f, -0.04800626f, -0.00910376f, -0.03087962f, -0.05588716f, 0.01943296f, -0.18783320f, -0.07894016f, 
    0.04437090f, -0.14455345f, 0.03955994f, -0.12761021f, 0.09938379f, 0.01820089f, -0.01101565f, 0.01274054f, 
    0.31560510f, 0.33864829f, -0.12652108f, 0.03157846f, 0.07068869f, 0.08188203f, 0.01033269f, 0.37512717f, 
    -0.22473527f, -0.30030906f, -0.11355385f, 0.10008171f, 0.06960580f, 0.10371226f, 0.04449614f, 0.12022938f, 
    0.01650124f, 0.11983110f, 0.19611676f, 0.18370458f, 0.13910624f, 0.16076857f, -0.01909927f, 0.22506490f, 
    -0.15035346f, 0.23529455f, 0.03964493f, 0.00627446f, 0.00635230f, 0.16403852f, 0.01740247f, -0.13812512f, 
    0.03992246f, 0.14127411f, 0.11235529f, 0.18199115f, 0.11583866f, -0.02991018f, -0.02321713f, 0.09423797f, 
    0.12523220f, -0.16548073f, 0.04474129f, 0.22599266f, -0.15406905f, -0.03182254f, -0.06384845f, 0.05274240f, 
    -0.10913877f, 0.11899257f, 0.24783807f, -0.13908923f, -0.17002016f, 0.22710489f, -0.07183851f, -0.01285133f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.16740546f, 0.06689058f, 0.03037428f, -0.13074178f, -0.10929207f, 0.14933391f, -0.21847488f, -0.08781341f, 
    0.22829166f, -0.56914538f, -0.41134393f, 0.26848269f, 0.06245509f, 0.01945183f, -0.02823620f, -0.03765958f, 
    -0.23755760f, -0.03556175f, -0.35356787f, 0.09820473f, 0.01839188f, 0.02318517f, 0.15320136f, 0.33808392f, 
    -0.24131143f, 0.06082912f, 0.12752247f, 0.06700166f, -0.02905046f, 0.15404749f, 0.11560379f, -0.17475028f, 
    0.18307044f, -0.10025214f, 0.00754494f, 0.03251395f, -0.13315395f, 0.03889351f, -0.04481024f, 0.04907941f, 
    -0.29281119f, -0.03819988f, -0.36191159f, 0.05990775f, -0.36145812f, -0.10859045f, -0.81322384f, -0.34131196f, 
    -0.15508170f, 0.01139598f, -0.29835364f, -0.21899973f, -0.00054263f, -0.08966985f, 0.20396443f, 0.04326142f, 
    -0.08094154f, -0.19538511f, -0.46050134f, -0.05405525f, -0.06308912f, 0.04137198f, 0.16933422f, 0.07222565f, 
    -0.22446004f, -0.05813370f, -0.12425356f, 0.10574435f, -0.24600209f, -0.34532312f, -0.54064780f, 0.02506849f, 
    0.06431468f, -0.56287420f, -0.03868347f, -0.26113018f, 0.14892550f, -0.08885819f, 0.24145657f, 0.07042271f, 
    0.08903853f, 0.10529149f, 0.07183936f, 0.16981795f, -0.56399506f, 0.20902157f, -0.02246024f, -0.34615502f, 
    0.04873660f, 0.14469458f, 0.05428237f, 0.06676343f, -0.26968962f, -0.10381274f, -0.41420394f, -0.35447603f, 
    -0.00553150f, -0.05499377f, -0.10680228f, 0.02910456f, -0.03129043f, -0.00237933f, -0.14562312f, 0.03563433f, 
    0.04048203f, -0.03786554f, -0.32882091f, -0.39989090f, -0.00668100f, -0.25139925f, -0.04122370f, -0.21736403f, 
    -0.47302473f, -0.03123917f, -0.05089743f, -0.00155934f, 0.05694564f, 0.09076833f, -0.53482467f, -0.39048842f, 
    -0.08475894f, -0.36801463f, -0.65060055f, -0.03161455f, -0.12503111f, 0.00321439f, -0.03730145f, -0.11169192f, 
    -0.15810256f, 0.02565208f, -0.54529691f, -0.03883173f, -0.05320450f, -0.08551580f, 0.19385721f, -0.01598505f, 
    0.19662699f, -0.52917880f, 0.23771420f, -0.80541039f, 0.02654252f, -0.24183044f, 0.01341411f, -0.03962877f, 
    -0.43812919f, 0.05728071f, 0.03545624f, -0.02158276f, -0.33594456f, -0.00320461f, 0.05505871f, -0.44204623f, 
    0.06584901f, 0.09405430f, 0.18400460f, 0.21525444f, 0.17824915f, 0.07352570f, 0.06448255f, 0.14074814f, 
    0.06164052f, -0.12401266f, -0.23655705f, -0.08123004f, -0.04582435f, -0.01680290f, -0.04239894f, -0.04068478f, 
    0.04770818f, 0.01311518f, -0.17350954f, -0.04217105f, -0.04381524f, -0.06476024f, -0.18990473f, 0.09761344f, 
    0.02050017f, -0.10291256f, 0.20236854f, 0.18681230f, 0.16416113f, 0.11947078f, 0.13981014f, -0.02609766f, 
    0.01150715f, -0.10453504f, 0.20510717f, 0.22736849f, -0.05000722f, -0.01793718f, -0.08922471f, 0.29793012f, 
    -0.10756186f, -0.06177467f, -0.05681445f, -0.08530840f, -0.11358664f, -0.03643215f, -0.22482227f, -0.03246973f, 
    0.16323406f, 0.09009416f, -0.01670099f, 0.00838007f, -0.00290234f, 0.03140697f, 0.01992874f, 0.08753420f, 
    -0.06024483f, 0.04776536f, 0.04099381f, -0.02281375f, -0.22753689f, 0.09451066f, -0.05954151f, -0.05439780f, 
    0.15205869f, 0.29772028f, 0.08860300f, -0.06894881f, -0.08296978f, 0.06984873f, 0.19224016f, 0.13474111f, 
    -0.01119443f, 0.00118377f, -0.13886589f, 0.04319979f, -0.07828924f, 0.05031188f, 0.08282825f, -0.06360207f, 
    -0.42999724f, -0.29151699f, -0.05248350f, 0.00497880f, 0.01923312f, 0.15289102f, -0.07629199f, 0.03464508f, 
    -0.45860654f, -0.05596895f, 0.18302642f, 0.26038659f, -0.20657599f, 0.26689824f, -0.75273591f, -0.06300226f, 
    0.04002894f, 0.18011467f, -0.28938875f, -0.01010959f, 0.03585161f, -0.15889402f, 0.00779564f, -0.49145889f, 
    -0.14964819f, -0.10972352f, 0.30271754f, -0.15972456f, -0.00481376f, -0.38572896f, 0.07569437f, 0.01565291f, 
    -0.66914946f, -0.07379591f, 0.02365758f, -0.40744001f, -0.15281633f, 0.10838713f, -0.00304691f, -0.00476548f, 
    0.03435664f, -0.19659008f, -0.05918273f, -0.38676131f, 0.43324605f, -0.18315099f, -0.00005190f, -0.26560941f, 
    0.23526536f, -0.04024024f, -0.02059072f, 0.25909820f, -0.08133502f, -0.24163461f, 0.07725006f, 0.03490978f, 
    -0.42827001f, 0.01630914f, 0.07141250f, 0.03619069f, 0.02863824f, -0.05365789f, 0.31056571f, 0.10781570f, 
    -0.04955836f, 0.12562379f, 0.00526262f, 0.02582273f, 0.12748659f, -0.07764360f, 0.10561039f, 0.09754129f, 
    0.31990907f, -0.02754233f, -0.16061519f, -0.52196121f, -0.07084421f, -0.11453870f, -0.44633284f, -0.01260913f, 
    -0.26677957f, -0.02465905f, 0.14403023f, -0.06397416f, -0.04350062f, 0.01927599f, 0.10687922f, -0.18394192f, 
    0.01013277f, 0.05569415f, -0.01033185f, -0.51065975f, 0.12399236f, -0.08543482f, 0.04048673f, 0.04866160f, 
    0.16636944f, 0.20483744f, -0.07337209f, 0.12418479f, 0.05120796f, 0.02768326f, 0.04276130f, 0.05947166f, 
    0.16945502f, -0.02698047f, 0.09459496f, -0.14759167f, 0.18759654f, -0.25470626f, -0.17354240f, 0.31617999f, 
    -0.20462357f, -0.47804320f, 0.13732609f, -0.70045298f, 0.17170353f, -0.17694494f, -0.58190650f, 0.16892463f, 
    0.07761469f, -0.01342763f, 0.01698911f, -0.11770805f, -0.02826505f, -0.13372374f, 0.08040535f, -0.13126996f, 
    0.33210376f, 0.15994008f, -0.11264561f, 0.35220042f, 0.00517321f, -0.36965239f, 0.01334747f, -0.28070265f, 
    -0.13126710f, -0.06082076f, -0.25107011f, -0.34170079f, -0.16369009f, 0.33104262f, 0.12384602f, -0.01339235f, 
    -0.34870988f, -0.16545026f, 0.12631616f, 0.00846429f, 0.07592337f, 0.10380507f, -0.01045326f, -0.06411169f, 
    -0.14365321f, 0.03696688f, 0.03030806f, -0.12265414f, -0.01689264f, 0.04157926f, -0.58418775f, -0.07933327f, 
    -0.03782037f, 0.04737845f, -0.37941039f, 0.19821623f, -0.15246838f, 0.15468419f, 0.02600230f, 0.01134794f, 
    -0.08630813f, 0.18279281f, -0.26492077f, -0.27823883f, 0.22538418f, 0.06097037f, 0.15019922f, 0.07756265f, 
    -0.03994837f, -0.37961414f, -0.01356682f, -0.03424478f, 0.16546834f, 0.04194656f, -0.18002613f, -0.02860435f, 
    -0.00555085f, -0.16026099f, 0.07933494f, 0.00988472f, 0.02154907f, -0.05325400f, 0.01897381f, -0.15915488f, 
    -0.18690799f, -0.35906219f, 0.00713050f, -0.01188459f, 0.16876829f, -0.05160385f, -0.07854903f, 0.29234022f, 
    -0.08329710f, -0.00057161f, -0.47696340f, -0.18828963f, -0.05720124f, 0.26595888f, -0.00512730f, -0.05611206f, 
    0.04267124f, -0.02687025f, -0.03931847f, 0.10131167f, 0.04167817f, -0.10577907f, 0.38182521f, -0.06770536f, 
    -0.07932834f, -0.04554567f, -0.09782493f, 0.12344719f, -0.12215086f, -0.02644340f, -0.48055303f, -0.02139446f, 
    -0.13362511f, 0.05148671f, -0.08161383f, -0.37239140f, 0.17964128f, 0.03170598f, 0.10365114f, 0.00304950f, 
    0.16960053f, 0.45670554f, 0.08291283f, 0.08915457f, -0.06857391f, 0.08709065f, 0.12352201f, 0.08660308f, 
    -0.02085145f, -0.02813939f, -0.11039927f, -0.22653799f, 0.17687234f, 0.03616147f, 0.07185561f, -0.15245287f, 
    -0.54193199f, -0.40690693f, 0.15021132f, 0.00353613f, -0.00316398f, -0.08286165f, -0.19664231f, -0.02545765f, 
    0.36655116f, 0.04252163f, 0.11955916f, 0.17205498f, -0.61028433f, -0.49248710f, 0.03960768f, -0.34844765f, 
    -0.27992266f, 0.01610958f, -0.14415844f, -0.25015998f, 0.08338677f, 0.16685952f, 0.06764399f, 0.05773428f, 
    -0.43565392f, 0.05497245f, 0.15231355f, -0.00752592f, -0.06533988f, 0.11521538f, -0.01713451f, -0.10982808f, 
    -0.00832151f, 0.03979356f, 0.17363633f, -0.05866420f, 0.05143460f, 0.13973944f, -0.41456404f, 0.05361789f, 
    -0.00755906f, -0.09198046f, 0.04325512f, 0.27553213f, 0.16391464f, 0.04445053f, -0.01928991f, -0.08131094f, 
    -0.16740958f, -0.24327573f, -0.00575567f, 0.05858302f, -0.03670625f, 0.08369555f, 0.02315062f, -0.46694186f, 
    -0.33437392f, 0.02255497f, -0.04147738f, -0.05901168f, 0.03172418f, 0.07205967f, 0.07145607f, -0.32920796f, 
    0.03490131f, -0.17813163f, 0.03400023f, -0.07598463f, 0.00797902f, -0.17829114f, 0.12168209f, 0.10116101f, 
    0.03673379f, -0.04971908f, 0.13592871f, -0.01981561f, -0.15434311f, -0.07673325f, -0.20397139f, -0.29362318f, 
    -0.08812859f, 0.09253432f, -0.02266173f, -0.25016344f, -0.36274543f, -0.32200518f, 0.15351233f, 0.08317571f, 
    0.19715236f, 0.11594936f, -0.19997241f, -0.08903120f, -0.44455823f, 0.02781496f, -0.08683045f, -0.18544497f, 
    0.03229032f, -0.04991605f, -0.15702517f, -0.00440545f, -0.34523314f, -0.26972649f, 0.12694333f, 0.05700225f, 
    -0.12155600f, -0.57649285f, 0.00523908f, -0.02782268f, -0.03569173f, -0.05823784f, -0.12548205f, -0.10274386f, 
    0.01782509f, -0.17110547f, -0.11958116f, -0.03990895f, -0.23543048f, 0.14234011f, -0.09073802f, -0.19217190f, 
    -0.02663526f, -0.06763474f, 0.06116018f, -0.15124509f, -0.32396591f, 0.00476206f, -0.22833709f, 0.09704962f, 
    0.12590925f, 0.07506698f, 0.17034744f, -0.12572794f, -0.01144555f, 0.03263602f, -0.12700722f, 0.14884280f, 
    -0.25894713f, -0.26273745f, -0.41761640f, 0.03344031f, 0.03660050f, 0.17232339f, -0.10855845f, -0.93695790f, 
    0.11353773f, 0.07548605f, -0.07386010f, 0.10501864f, 0.08166485f, 0.06125485f, -0.07850982f, 0.05567985f, 
    0.04208266f, 0.27827489f, 0.00523232f, 0.03734671f, -0.09612168f, 0.11185408f, -0.04245371f, 0.33919376f, 
    0.20115732f, -0.00470858f, 0.05083351f, 0.04559142f, -0.01113696f, -0.07809070f, 0.05306065f, -0.05855043f, 
    -0.14698663f, 0.09297996f, -0.23923956f, -0.20681158f, 0.11335529f, 0.12516093f, 0.01087429f, 0.06411677f, 
    0.09621163f, 0.21576329f, 0.09461864f, 0.21078096f, 0.13400970f, -0.00742809f, -0.08280050f, 0.17066194f, 
    -0.03748661f, 0.11366072f, 0.08560176f, 0.22794853f, 0.08648004f, -0.11542986f, -0.05332751f, -0.04957196f, 
    -0.13290736f, -0.03920954f, 0.17963599f, -0.08878922f, -0.16776642f, 0.05697588f, -0.00053466f, -0.09198195f, 
    0.09046429f, -0.14791845f, 0.11992180f, -0.06206831f, -0.68045419f, -0.04337726f, -0.06896371f, -0.19297566f, 
    0.01203745f, 0.07711661f, -0.26864332f, -0.33463195f, -0.08640052f, -0.03618458f, 0.16274366f, 0.04351285f, 
    -0.00050933f, -0.05807849f, -0.08372797f, -0.31973884f, -0.17352481f, 0.03705863f, -0.05614212f, 0.06794809f, 
    -0.00644510f, 0.02713291f, -0.14010131f, -0.11941130f, -0.00634290f, -0.03628700f, 0.12759331f, -0.07979376f, 
    -0.11727852f, -0.00603389f, -0.03629909f, 0.05214050f, -0.11988868f, 0.02713260f, -0.29230914f, 0.12818167f, 
    -0.10963764f, 0.00855613f, 0.04869876f, -0.30301723f, 0.08182756f, -0.03623985f, -0.00926393f, -0.07883675f, 
    0.14011295f, 0.17670447f, -0.06835672f, 0.37313676f, -0.12788989f, -0.25356504f, 0.27851033f, 0.09207081f, 
    -0.06594131f, 0.11029863f, -0.12055046f, -0.14295557f, -0.04632100f, 0.07056040f, -0.10270043f, 0.02323947f, 
    -0.48513952f, -0.62975150f, 0.26537696f, -0.11011235f, 0.11230142f, -0.06800112f, 0.03832198f, -0.45739314f, 
    0.02238304f, -0.07507256f, -0.31516364f, -0.07421181f, 0.01240095f, -0.12457026f, -0.05065461f, 0.08465658f, 
    0.28510183f, -0.69567382f, -0.07170134f, -0.09779840f, 0.00648590f, 0.17283358f, -0.06984571f, -0.11339396f, 
    -0.00038817f, -0.06859425f, -0.07167635f, 0.00332769f, 0.08399923f, -0.18410923f, 0.09690639f, -0.12238507f, 
    -0.40609375f, 0.20504837f, 0.18042101f, -0.07153858f, -0.41303489f, -0.06173478f, -0.07595392f, -0.06512679f, 
    0.07584399f, -0.84047186f, 0.07844613f, -0.38667744f, -0.48520356f, -0.06102956f, -0.00618622f, -0.12298173f, 
    0.27426410f, 0.13874833f, -0.79498023f, -0.55168748f, -0.64627421f, -0.83480734f, -0.23701926f, -0.14940281f, 
    -0.17366950f, 0.18239515f, -0.46975550f, -0.04084081f, -0.10892709f, 0.00939670f, -0.17268890f, -0.13902982f, 
    -0.17874223f, 0.09789564f, 0.04011859f, 0.02848060f, 0.33690950f, 0.01965296f, 0.17249471f, -0.02132768f, 
    0.04643863f, -0.01035146f, -0.10877991f, 0.16758716f, 0.11043928f, -0.13839459f, -0.84698188f, 0.08704970f, 
    -0.28239316f, -0.33250710f, -0.03247475f, 0.12528135f, -0.01265651f, 0.01021387f, -0.11030367f, -0.31969211f, 
    0.17260754f, 0.04954356f, -0.01295695f, -0.05031165f, -0.02124968f, 0.07878467f, 0.05811643f, 0.03639914f, 
    -0.22961998f, -0.06309795f, 0.04442371f, -0.04859244f, -0.21326381f, -0.09939859f, 0.08010668f, -0.76058948f, 
    0.04198203f, -0.11342081f, -0.17554432f, 0.23502697f, 0.14461327f, -0.50954419f, -0.26501054f, 0.44442225f, 
    -0.29393259f, -0.49550539f, 0.09139666f, -0.51781422f, 0.21825446f, -0.19049011f, -0.28418139f, -0.44928306f, 
    0.08688023f, 0.11967402f, -0.55933017f, -0.08190407f, -0.12671305f, -0.23225667f, -0.10354961f, 0.12715816f, 
    0.17503537f, 0.52883333f, -0.00814120f, -0.03181357f, 0.02276226f, -0.18721840f, -0.03304753f, 0.27809721f, 
    0.19418438f, 0.02478066f, -0.18856886f, -0.40775117f, -0.04597352f, -0.37860629f, 0.14789753f, 0.00023517f, 
    0.05138173f, 0.22130765f, 0.10369980f, -0.05429448f, -0.14593516f, -0.04378818f, -0.06806648f, 0.13808535f, 
    -0.04011192f, 0.05464985f, -0.39066300f, -0.10625228f, -0.20889504f, 0.05493635f, -0.57034647f, 0.11712221f, 
    0.23845595f, 0.14280237f, -0.13578169f, 0.54653227f, 0.06909565f, -0.30072638f, 0.07538504f, 0.03066911f, 
    0.07942120f, -0.08415011f, 0.00804509f, 0.23062150f, -0.02938643f, 0.09464269f, 0.09621310f, -0.12694933f, 
    0.28630966f, 0.04320618f, 0.03580285f, -0.12725079f, -0.21284090f, -0.50168192f, 0.07440732f, -0.06623801f, 
    0.28859708f, -0.25585714f, 0.10186915f, 0.05935477f, -0.07965738f, -0.03315775f, -0.18172726f, 0.00888404f, 
    -0.27839348f, -0.11763337f, 0.06620187f, 0.02344968f, 0.16053198f, -0.05123452f, 0.23595925f, -0.31092522f, 
    -0.44595107f, -0.13720454f, -0.18859017f, 0.14241551f, 0.27906367f, -0.34917122f, -0.34051448f, 0.07978994f, 
    0.13048187f, -0.31543013f, -0.07773973f, -0.37147784f, -0.15252489f, -0.05915080f, -0.06144647f, -0.27385399f, 
    0.09077075f, 0.04135600f, -0.05496462f, 0.18774210f, 0.08473658f, 0.24181998f, 0.17271887f, -0.05194894f, 
    -0.16332290f, -0.03910618f, -0.08167449f, 0.07285389f, -0.09588458f, 0.07843289f, 0.05200588f, -0.39826155f, 
    -0.08239257f, -0.19995464f, -0.02612419f, -0.01841190f, 0.17993912f, 0.00912749f, -0.10086032f, -0.70669073f, 
    0.06156359f, -0.34698239f, -0.20310599f, -0.32990587f, -0.39729726f, 0.18729056f, -0.13918844f, -0.32411802f, 
    -0.00818386f, -0.13888131f, -0.29493055f, -0.13341154f, -0.11196596f, 0.16606033f, 0.08015118f, 0.04870196f, 
    0.31991059f, -0.46979839f, -0.32623899f, -0.29463488f, 0.01536069f, 0.06497424f, 0.00635492f, -0.05661806f, 
    0.12640794f, -0.04560881f, -0.17258130f, 0.07530718f, 0.26713583f, -0.14582661f, 0.24196364f, 0.03968344f, 
    0.10015937f, 0.11556832f, -0.55410427f, -0.07305053f, 0.02762939f, -0.41462523f, 0.00457268f, -0.26351923f, 
    -0.07733138f, 0.05891207f, -0.64381081f, -0.21950927f, -0.03730067f, -0.27929917f, 0.22666095f, -0.04408348f, 
    0.06447500f, 0.13506947f, 0.00536196f, -0.45155239f, 0.08303347f, -0.41524360f, 0.04384062f, -0.01514220f, 
    0.19132665f, 0.17089899f, 0.16757205f, -0.04591424f, -0.45973626f, -0.38798937f, -0.05706509f, -0.14838184f, 
    0.39182696f, -0.04882480f, 0.13050607f, 0.01151079f, 0.06328719f, -0.69438976f, -0.16327609f, 0.11658433f, 
    0.12003390f, 0.08997300f, -0.79802394f, 0.05096369f, -0.11590144f, 0.00832634f, -0.39684877f, 0.00564911f, 
    -0.07093104f, 0.05782658f, -0.40378031f, -0.03289326f, -0.07579121f, -0.05233456f, 0.19483340f, 0.18830146f, 
    0.10467860f, -0.07641613f, 0.00312044f, -0.02944713f, 0.31586748f, 0.27057841f, -0.65877616f, 0.07438552f, 
    -0.24764968f, -0.12527026f, 0.07170057f, -0.43776768f, -0.05022302f, 0.06626140f, 0.10995559f, -0.39625418f, 
    -0.13505140f, 0.06665034f, 0.02415415f, -0.18283349f, 0.15229625f, 0.19674009f, -0.00408649f, 0.03643269f, 
    -0.26849866f, 0.06494839f, 0.08571668f, 0.00712132f, -0.06607167f, -0.01849445f, 0.10221011f, 0.10455286f, 
    -0.13557978f, -0.15392889f, 0.04816716f, 0.18153474f, 0.25818431f, 0.02692192f, 0.02172295f, -0.19573538f, 
    -0.01384851f, 0.20983773f, 0.06858537f, -0.13096730f, 0.19782822f, 0.18132237f, -0.05520424f, -0.06307004f, 
    0.00646579f, 0.12808503f, -0.30210230f, -0.05604141f, -0.14821872f, 0.10818604f, 0.08379038f, -0.17752452f, 
    0.03832718f, -0.02927328f, 0.15262187f, 0.02249478f, 0.02194645f, 0.00698534f, -0.03283836f, 0.17380857f, 
    0.10914064f, -0.06877704f, 0.16746415f, -0.10475927f, -0.55987328f, -0.38777614f, 0.00630463f, 0.09333167f, 
    -0.17993364f, -0.27567196f, 0.05209060f, -0.04983100f, 0.02723994f, -0.54943120f, 0.01520723f, -0.73918557f, 
    -0.30671194f, -0.04841501f, 0.13165268f, 0.11942418f, 0.01348276f, 0.17799346f, -0.14097114f, 0.14576524f, 
    -0.53918105f, 0.15465721f, 0.10029112f, -0.00523499f, -0.05165929f, 0.24207751f, -0.01384801f, 0.02414545f, 
    -0.17642216f, -0.26735952f, 0.07999028f, -0.41752657f, -0.26623031f, -0.09881855f, 0.01213939f, -0.53363514f, 
    -0.24958277f, -0.01285504f, -0.36149552f, -0.20722380f, -0.09337382f, 0.09402043f, -0.13768774f, -0.27419353f, 
    -0.41480547f, 0.00061296f, -0.04844581f, 0.03740759f, 0.10318482f, -0.02328495f, 0.23229368f, 0.16784784f, 
    0.09246031f, 0.12718607f, 0.08727881f, -0.07851833f, 0.23814535f, -0.00689748f, 0.04097334f, -0.23336132f, 
    -0.10547669f, -0.04668137f, 0.20343731f, -0.05838447f, -0.49182427f, -0.59085476f, 0.01520847f, 0.05314808f, 
    0.12505174f, 0.05111218f, 0.08427556f, 0.18718608f, 0.02051347f, -0.00416377f, 0.04084850f, -0.25425026f, 
    0.11850602f, -0.04436598f, -0.19043508f, 0.09766161f, -0.05367286f, 0.05854096f, 0.04037510f, -0.03806207f, 
    0.36459219f, -0.42882857f, 0.07224245f, -0.09705176f, -0.02682610f, -0.05981971f, -0.26808840f, -0.15801524f, 
    0.03458804f, -0.63681257f, -0.09423369f, -0.16804431f, -0.12232863f, -0.10171293f, 0.01318007f, -0.09707226f, 
    -0.41649368f, -0.21936448f, 0.09472667f, 0.13875730f, 0.14326309f, 0.10082576f, -0.21493968f, -0.18279417f, 
    -0.54727596f, -0.13776036f, 0.11700609f, -0.05073253f, -0.04674172f, -0.12181791f, -0.53255796f, 0.13516442f, 
    -0.29716617f, 0.21104002f, 0.08196617f, -0.22603524f, -0.29572439f, -0.05178100f, 0.06897004f, -0.20789598f, 
    0.11214354f, 0.00763158f, -0.13046962f, -0.12007973f, 0.01002890f, 0.10539006f, -0.04855620f, -0.02984212f, 
    -0.18260764f, 0.25784773f, 0.24284428f, -0.02948807f, -0.01857667f, 0.21236295f, 0.02432007f, 0.43263280f, 
    -0.06036176f, -0.05946529f, -0.09228500f, -0.05880058f, 0.18068786f, 0.15996481f, 0.03399526f, -0.10155828f, 
    -0.27744627f, -0.07136468f, -0.19917558f, -0.11737841f, -0.08549994f, -0.66892713f, 0.02000804f, -0.09966137f, 
    0.01392426f, 0.05327014f, 0.00176617f, 0.24075200f, -0.19968340f, 0.14627218f, -0.43354782f, -0.18244939f, 
    0.26127216f, -0.37081397f, 0.07433433f, -0.24709496f, 0.04346251f, -0.04393806f, -0.27242351f, 0.19759670f, 
    0.10599648f, 0.13657469f, -0.63368750f, 0.05945690f, -0.00012942f, -0.03843854f, -0.19293289f, -0.62928814f, 
    0.07673491f, 0.13844518f, 0.03565758f, -0.05261654f, -0.27648121f, 0.04056071f, 0.06917854f, 0.18652114f, 
    0.17407255f, 0.01840884f, -0.34857923f, -0.47518441f, 0.21378183f, 0.40316772f, -0.08955362f, 0.00517588f, 
    -0.03555115f, -0.20904818f, -0.49267739f, 0.34537065f, -0.11797772f, 0.01907236f, -0.31728780f, 0.04078460f, 
    -0.21639876f, 0.01122984f, -0.02326441f, -0.01840874f, 0.20741153f, -0.33296779f, -0.06937903f, 0.00629896f, 
    -0.26530781f, 0.13597780f, 0.01451276f, -0.06731071f, 0.01841561f, 0.02294620f, -0.63071370f, 0.06086491f, 
    -0.18585105f, -0.10461507f, -0.24890144f, 0.32611203f, -0.00668218f, 0.14492729f, 0.18630138f, -0.02080289f, 
    -0.07955985f, -0.60165805f, 0.03827867f, 0.01920279f, -0.39624897f, 0.30060387f, 0.34388396f, 0.35740477f, 
    -0.16468115f, -0.04327193f, 0.30268896f, -0.07552943f, 0.05551173f, -0.13542540f, -0.24241932f, -0.14383779f, 
    -0.18091758f, 0.06016223f, -0.08266791f, 0.01869302f, -0.30876729f, 0.15386158f, -0.09971638f, -0.37661323f, 
    -0.32996449f, -0.00132996f, -0.02765417f, 0.08818476f, -0.39006376f, -0.25607580f, 0.04706367f, 0.03090686f, 
    -0.42672408f, -0.29129437f, -0.10522230f, -0.05126834f, 0.07391103f, -0.08560534f, 0.07090942f, -0.08106446f, 
    0.18199892f, -0.03723001f, 0.24322855f, 0.13607500f, -0.01593702f, 0.04057930f, 0.14954293f, -0.02501323f, 
    -0.33894995f, -0.04311151f, 0.00857458f, -0.31572697f, 0.06808978f, -0.07475212f, -0.03308739f, -0.01954130f, 
    0.24966130f, 0.13149928f, 0.13667130f, 0.24880284f, 0.13426942f, 0.00273452f, -0.28045970f, 0.07175957f, 
    -0.36650616f, -0.20098974f, -0.34329793f, -0.46117321f, -0.41056126f, -0.18743140f, -0.38564727f, 0.10648332f, 
    -0.11900704f, 0.02687111f, -0.13316080f, -0.08715697f, -0.06011000f, 0.03945145f, -0.28412059f, -0.18036422f, 
    0.20624307f, -0.23631527f, 0.14686200f, -0.01502146f, -0.02135825f, 0.03159637f, 0.13552921f, -0.33434844f, 
    -0.09801197f, 0.00715091f, -0.24261293f, 0.15959632f, -0.39666650f, -0.22116548f, -0.46165892f, 0.08237712f, 
    0.05497343f, 0.00666720f, 0.08180881f, 0.22979508f, 0.18141019f, -0.04575104f, -0.36964989f, -0.22966398f, 
    -0.08523820f, -0.02881753f, -0.09301079f, -0.45254192f, 0.14529333f, 0.19437176f, 0.17304915f, -0.03075729f, 
    -0.56700480f, 0.26978961f, -0.05001330f, 0.09530418f, -0.58992589f, -0.04694789f, -0.73922735f, -0.16701987f, 
    -0.05213024f, -0.05084112f, -0.17118943f, -0.00109439f, -0.08079196f, -0.47014895f, -0.17255174f, 0.20899153f, 
    0.15923503f, -0.25731626f, -0.03860565f, 0.13867368f, 0.07169145f, -0.24279232f, -0.10531155f, 0.14452305f, 
    -0.41081250f, 0.11915462f, 0.15838248f, -0.24798995f, 0.06231359f, -0.03897758f, -0.32882091f, -0.39805174f, 
    0.02691336f, -0.21161078f, 0.07554726f, 0.01464671f, -0.01135406f, 0.25670466f, 0.05582023f, 0.25917622f, 
    0.28329998f, -0.00542490f, -0.28166878f, 0.33513829f, -0.14871158f, -0.51339835f, 0.18721282f, 0.17134699f, 
    -0.02787710f, 0.04814520f, -0.00912650f, 0.08031727f, -0.09938903f, -0.04595164f, -0.05966756f, 0.01204410f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.18416943f, 0.11829581f, 0.08073318f, -0.15180874f, -0.07313713f, -0.01590756f, 0.06186638f, -0.01978929f, 
    0.00474000f, 0.17194666f, 0.10807832f, -0.15450518f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
