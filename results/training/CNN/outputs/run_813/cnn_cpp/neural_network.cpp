#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.64415234f, -1.13693631f, -0.20093040f, -0.53798038f, -0.33123773f, 0.10076154f, -0.83410114f, -0.20635870f, 
    0.45735812f, -0.27232635f, 0.21137208f, -0.19247116f, -0.26160043f, 0.44229233f, -0.35466725f, -0.00015649f, 
    0.50221556f, -0.15596563f, 0.49708980f, 0.10710948f, 0.51181746f, -0.18067218f, 0.06486776f, -0.12807387f, 
    0.33975452f, -0.13045083f, -0.07801833f, -1.02440393f, -0.39289957f, -0.61826289f, 0.87394637f, 0.18981670f, 
    0.49226210f, 0.78687179f, -0.20894757f, -0.32755363f, -0.31739298f, 0.27784017f, -0.32713661f, -0.05035272f, 
    -0.27025515f, -0.19462720f, 0.13390838f, -0.06884976f, -0.24769752f, -0.02578292f, 0.32363582f, -0.08910520f, 
    0.41495553f, 0.22434381f, -0.27187973f, -0.63139749f, -0.90265042f, -0.44608173f, -0.22988485f, 0.62363356f, 
    0.34377664f, 0.38145226f, 0.31324095f, 0.68412060f, 0.08099761f, -0.06777980f, -0.12132666f, 0.14674401f, 
    0.20816413f, 0.05174492f, 0.31225264f, 0.04332612f, 0.43898326f, 0.45481351f, -0.30404526f, -0.54325682f, 
    -0.40518928f, -0.47205481f, -0.42657232f, 0.71749878f, 0.98925090f, 0.38755184f, 0.95237267f, 0.29531273f, 
    -0.84371054f, -0.57365483f, 0.14575909f, -0.16146085f, -0.00860112f, 0.15711160f, 0.37290356f, -0.32116389f, 
    0.49277014f, 0.34617117f, 0.11315522f, -0.04361512f, 0.68574619f, -0.29938367f, 0.04148778f, 0.18392161f, 
    0.42072326f, -0.01253932f, 0.14153366f, 0.02445834f, -0.17602810f, -1.32349515f, -0.93188161f, 0.01595395f, 
    0.60544229f, -1.01952529f, 0.40650818f, 0.51909804f, 0.30551010f, -0.29582429f, 0.25987205f, -0.00292026f, 
    -0.07363862f, 0.09736801f, -0.08792535f, -0.03538939f, 0.00695635f, -0.51646674f, -0.22302514f, -0.01419294f, 
    -0.01187919f, -0.22209002f, 0.34735969f, 0.21165973f, 0.39404190f, -0.29984081f, -0.48170456f, -0.83246303f, 
    -0.82367849f, -0.42222768f, 0.00656367f, 0.85550112f, 0.37757310f, 0.25674763f, 0.62298518f, 0.35174191f, 
    -0.48194373f, -0.06954421f, -0.09568173f, -0.06195740f, 0.13202943f, 0.27771971f, 0.11465248f, 0.07368755f, 
    -0.32487744f, -0.06590240f, 0.19108666f, 0.09127990f, -0.14522320f, 0.05754884f, -0.51333064f, 1.24863994f, 
    0.65777838f, -0.70605677f, 0.67134684f, 0.53188306f, -0.91166270f, -0.25587288f, -0.41789258f, -0.40858966f, 
    -0.36296049f, -0.47120878f, -0.44258317f, -0.11703263f, -0.38009045f, -0.39290273f, -0.33152381f, -0.48729566f, 
    -0.48843431f, -0.45285493f, 0.03222914f, 0.20530063f, 0.10232912f, -0.04316171f, -0.19618262f, 0.21325038f, 
    -0.39887211f, 0.44326141f, 0.56560248f, 0.91722482f, -0.65713036f, -0.12783679f, -0.32762513f, -0.52474767f, 
    -0.02064844f, 0.38559783f, -0.27616271f, -0.53034002f, -0.02784533f, 0.26243246f, 0.00972541f, -0.67866349f, 
    -0.58646554f, -0.02605369f, -0.12497175f, -0.13811240f, -0.06538107f, -0.45140427f, -0.19690597f, -0.36227685f, 
    1.30336940f, -0.76763403f, 0.65615648f, -0.26222986f, 0.10746261f, -0.22106996f, 0.54826897f, 0.70340180f, 
    0.71509582f, 0.29919118f, -0.50032294f, 0.17061174f, -0.36712074f, 0.13529564f, -0.37521175f, 0.29845563f, 
    0.17859723f, -0.31699699f, 0.14937450f, 0.11142834f, -0.09755208f, 0.18921006f, 0.08799636f, 0.27982295f, 
    0.06101463f, 0.00404567f, 0.49650547f, 1.05270791f, -1.08687520f, 0.10416542f, 0.16685015f, 0.40728447f, 
    -0.67847055f, -0.96059710f, 0.16509160f, 0.29375294f, 0.68647635f, -0.13355364f, -0.12405815f, 0.23080721f, 
    0.17094123f, -0.44792289f, 0.03114945f, -0.19917580f, -0.23303691f, 0.10958659f, 0.03420498f, -0.06047755f, 
    0.02329647f, 0.17110990f, -0.46401003f, -1.13037455f, 0.43168363f, 0.76793927f, -0.97685903f, 0.43372399f, 
    -0.34348851f, 0.48346499f, -0.61538881f, 0.02914716f, 0.24795274f, -0.46593183f, -0.15359154f, 0.03882856f, 
    0.26939756f, -0.03357792f, 0.08810592f, -0.06629629f, -0.24626783f, 0.19087352f, 0.32029703f, 0.40788561f, 
    0.19828261f, 0.46472570f, -0.05764141f, 0.63008535f, 0.67128837f, 0.23297657f, 0.13389561f, 1.37046075f, 
    -0.24247643f, 0.45787311f, 0.86251718f, 0.43680778f, 0.35185441f, -0.04144108f, -0.01761083f, -0.40535784f, 
    -0.25658461f, 0.11050803f, 0.09403464f, -0.34953365f, -0.26681834f, 0.51860267f, 0.24840523f, -0.12954068f, 
    -0.20467281f, -0.23253115f, -0.26570100f, 0.28980300f, 1.29763162f, 0.47310770f, -0.86386544f, 1.07962441f, 
    -0.11603032f, 0.34400827f, 0.27045879f, -0.37329522f, 0.72062260f, 0.20394517f, 0.15984792f, 0.32857996f, 
    -0.18364558f, 0.09660089f, -0.15160868f, 0.13199195f, -0.30336002f, -0.17136468f, -0.10131153f, -0.23910590f, 
    -0.19046982f, 0.10922500f, 0.02309792f, 0.05592342f, -0.06011513f, -1.60784435f, 0.57176083f, 1.02833819f, 
    -0.01832561f, -0.09482629f, 1.26920819f, 0.34610784f, -0.09588844f, 0.86603785f, 0.23913743f, 0.38080510f, 
    -0.62967759f, 0.50003755f, -0.05188875f, -0.29122657f, -0.02185876f, -0.19950277f, -0.17634569f, -0.33943203f, 
    -0.07625013f, -0.25671288f, -0.00732382f, 0.16000333f, 0.18741211f, -0.09701557f, 1.30128646f, 0.98778826f, 
    0.22157787f, 0.35529485f, 0.49784374f, 0.11030323f, -0.16215517f, -0.40679923f, 0.15839778f, 0.51304615f, 
    -0.10470319f, -0.22918183f, -0.38247985f, 0.04197022f, 0.16442099f, 0.14482778f, 0.08035869f, 0.59840137f, 
    0.19001654f, -0.16879222f, 0.13456367f, -0.11483964f, -0.17152557f, -0.12176163f, 0.65425110f, -0.03566970f, 
    0.76900172f, 0.48010430f, 0.38236165f, 0.43886322f, 0.28684109f, -0.91604328f, -1.26329315f, -0.55207670f, 
    -0.68107408f, 0.42708546f, 0.10383829f, 0.18056644f, 0.25471044f, 0.09369152f, 0.27586731f, -0.43972668f, 
    0.22159560f, -0.18343098f, 0.17543150f, -0.34839642f, -0.03711403f, 0.13905753f, 0.16967891f, -0.34915283f, 
    0.32046422f, 0.53926069f, 0.81360376f, -0.43446746f, 0.34778315f, 0.45042276f, 0.29642674f, 0.57458770f, 
    0.53916663f, 0.49071470f, 0.09608108f, 0.19932422f, 0.29139993f, 0.47286245f, 0.22246300f, -0.22625451f, 
    0.03623440f, -0.04586551f, 0.21671525f, 0.25455490f, -0.56367528f, 0.12003167f, -0.03181752f, -0.03481134f, 
    0.39824283f, -1.00573361f, 0.91212469f, -0.22573639f, -0.43715817f, 0.73095369f, -0.10408268f, 0.07351144f, 
    -0.61259127f, -1.04263651f, -0.77646422f, -0.29623929f, 0.13316937f, 0.79306668f, -0.00259103f, 0.04691700f, 
    0.21819220f, 0.32811072f, 0.18634948f, 0.44254518f, -0.09698613f, -0.06828884f, 0.11522097f, 0.03763215f, 
    -0.20426206f, 0.18938653f, 1.35214794f, -0.18984500f, 1.04271603f, -0.36779198f, -0.65526748f, 0.70612466f, 
    -0.29908061f, 0.26484248f, -0.42988679f, 0.38557932f, 0.39536688f, 0.01322906f, 0.16076651f, 0.14337853f, 
    -0.24723130f, -0.01235639f, -0.21273324f, 0.18230747f, -0.03690742f, -0.13071293f, 0.06020091f, 0.27204224f, 
    -0.09678254f, 0.06852386f, -0.14666349f, -0.57430679f, -1.29914010f, -0.55241305f, 0.25626478f, 0.55665386f, 
    0.76856065f, 0.92608052f, -0.59771734f, 0.33614528f, 0.37803003f, 0.00743534f, -0.04384428f, 0.33345601f, 
    -0.05102947f, -0.11179099f, -0.55859011f, 0.18372130f, 0.43403140f, 0.21686165f, -0.56898522f, -0.08884063f, 
    -0.17176299f, -0.23322015f, -0.14198895f, -0.01471228f, -0.37703693f, -0.09492505f, 0.11180016f, 0.26466408f, 
    1.20314980f, 1.16205001f, 0.61584383f, -0.73716068f, -0.16478255f, -0.26551741f, -0.24440873f, 0.44074750f, 
    0.21315713f, 0.47712615f, 0.08340818f, -0.14752235f, -0.13856724f, -0.22088730f, -0.16448577f, 0.40435195f, 
    0.28316924f, -0.07696535f, -0.15034683f, -0.45092845f, -0.05018658f, -0.79546648f, 0.21097013f, 0.87137640f, 
    -0.01417216f, -1.09475291f, -0.54796737f, -0.21751422f, -0.11696837f, -0.63190258f, -0.64194202f, -0.23784648f, 
    0.01539773f, -0.13650812f, -0.19201529f, 0.51528716f, -0.56932670f, 0.07940911f, 0.03241133f, 0.22063120f, 
    0.01354431f, -0.11022464f, 0.20668876f, 0.32417551f, 0.19673075f, -0.24694221f, -0.92138892f, 0.58164132f, 
    -0.43017301f, -1.07445943f, -0.54572034f, -0.13072935f, 0.39952341f, 0.09698994f, 0.18197615f, -0.10734823f, 
    -0.27822191f, 0.24819082f, -0.55197823f, 0.52076131f, -0.10048173f, 0.13013647f, 0.24895279f, 0.27172258f, 
    0.00801992f, 0.25687611f, -0.28584817f, -0.07378877f, 0.02239668f, 0.11618175f, 0.37325233f, -0.45212689f, 
    -1.55387390f, -0.14878792f, 0.78668773f, 0.11930008f, -0.73931020f, 1.15898240f, 0.44923443f, -0.43202943f, 
    0.23150247f, 0.06734547f, 0.09989555f, -0.34977010f, -0.19777381f, 0.15490818f, -0.07292006f, 0.13249876f, 
    0.06772420f, -0.38123262f, -0.13463002f, -0.15236387f, 0.03702143f, -0.02156592f, 0.00232839f, -0.07960981f, 
    -0.24760078f, 0.61614567f, 0.60536957f, -0.12401396f, -0.49248955f, -0.35032666f, 1.06222391f, -0.09121738f, 
    -0.01003672f, 0.63471216f, -0.16690053f, 0.39446282f, -0.11770233f, -0.36983520f, -0.67977411f, 0.16087027f, 
    -0.42296413f, -0.45258752f, -0.16083334f, 0.04044277f, 0.04025808f, -0.02921583f, -0.13955432f, -0.28919598f, 
    -0.49513891f, 1.12674499f, 1.13198972f, 0.62798184f, -0.71105850f, -0.44360921f, -0.24416584f, -0.57753569f, 
    0.42721930f, 0.01212252f, 0.38163379f, 0.09647097f, 0.28524396f, -0.29119512f, -0.11751008f, 0.43758139f, 
    0.02460278f, 0.10317007f, -0.64519519f, -0.33888522f, 0.24258204f, 0.09999720f, 0.25970876f, -0.40798894f, 
    -0.02015171f, -0.16822252f, -0.63387543f, -0.60129976f, -0.97920436f, -0.69663841f, -0.42792788f, -0.27641654f, 
    0.15347442f, 0.39028972f, 0.02729696f, -0.35273686f, 0.58792740f, 0.15513298f, 0.40196675f, 0.51850045f, 
    -0.03333133f, -0.23901397f, -0.21460089f, -0.17135219f, -0.77758241f, -0.11785057f, 0.19960886f, 0.19866742f, 
    -0.16017489f, -0.05855816f, 0.01939015f, -0.76483059f, -0.72448945f, -0.74831796f, -0.39580345f, -0.25131544f, 
    -0.43189341f, 0.38792568f, 0.59561217f, 0.06491262f, 0.84229654f, -0.66534728f, 0.21731463f, 0.03231068f, 
    -0.47359142f, -0.70192671f, -0.36023435f, -0.06165381f, 0.36704943f, -0.09252404f, -0.13980256f, -0.12463922f, 
    0.23119470f, -0.43835390f, -0.02294126f, 0.11433582f, 1.30056870f, -0.42927375f, -0.73992372f, -1.08415079f, 
    0.13058807f, 0.85297829f, 0.17441605f, -0.49310589f, -0.08851880f, -0.10836396f, -0.33656913f, 0.06048764f, 
    0.16179392f, 0.37143958f, -0.06295087f, -0.06416986f, 0.14747116f, -0.07582504f, -0.00546850f, -0.10636504f, 
    0.10254084f, -0.01437164f, 0.03533953f, 0.13116740f, -0.07174882f, 1.28663254f, 0.67964846f, 0.90713239f, 
    1.17161405f, 1.19218540f, 0.40251011f, 0.14328766f, -0.16092315f, -0.09451941f, -0.62321085f, 0.18164256f, 
    0.06979426f, 0.12015198f, 0.23112507f, -0.25668630f, -0.00689916f, 0.19535071f, 0.20444237f, -0.10871782f, 
    0.23724245f, -0.25871953f, 0.15096484f, 0.19928351f, 0.05856603f, 0.20762798f, 0.84834468f, 0.09793931f, 
    0.65065491f, 0.81660020f, -0.30456656f, 0.07894681f, -0.92339057f, -0.21026589f, 0.10126556f, 0.31424466f, 
    -0.24876939f, 0.08175693f, 0.34930646f, -0.42956793f, 0.26713148f, 0.17353694f, -0.17233668f, 0.39794788f, 
    -0.01749267f, 0.43634796f, 0.31275007f, 0.49667919f, 0.44308320f, 0.03936442f, 0.20287399f, 0.58573639f, 
    0.87314457f, -0.67863452f, -0.91895300f, 0.28015351f, 0.64518034f, -0.17673337f, -0.49001980f, -0.26457366f, 
    0.20152332f, 0.53378946f, -0.24183446f, -0.37144360f, -0.28530815f, -0.25170553f, 0.02147797f, 0.13180071f, 
    0.06446470f, 0.04830509f, 0.08733690f, 0.03404164f, 0.00094006f, 0.42650625f, 0.58816707f, 0.22182786f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.16110440f, 0.03758746f, 0.16888754f, 0.11296597f, 0.31477073f, 0.12556911f, 0.15025559f, 0.06709364f, 
    0.15014561f, 0.02886378f, 0.33560097f, 0.44895846f, 0.37369397f, 0.36921939f, 0.17861243f, 0.21562274f, 
    0.33550552f, 0.19434975f, 0.22216925f, 0.35694498f, 0.16003536f, 0.39467204f, 0.31317899f, 0.05918675f, 
    -0.04523201f, 0.35667390f, 0.32808709f, 0.16442344f, 0.32120368f, 0.08140820f, 0.22039251f, 0.06495641f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.15482536f, -0.29798344f, -0.11235768f, -0.07903054f, -0.03115112f, 0.00117769f, 0.06695317f, 0.06830099f, 
    -0.04529756f, 0.05027590f, 0.03936834f, -0.06860188f, 0.33003551f, 0.09314137f, -0.21323796f, -0.33272025f, 
    0.22288668f, -0.01028610f, 0.23125950f, 0.01821908f, 0.08164496f, -0.00680722f, 0.00235416f, 0.09101614f, 
    0.31156725f, -0.05326486f, -0.03535705f, -0.28816551f, 0.13705949f, 0.10680411f, 0.01215213f, -0.01999709f, 
    0.11809511f, -0.14490548f, -0.11388662f, 0.05792840f, 0.34202039f, 0.24040931f, -0.06210522f, -0.00924944f, 
    -0.21884911f, -0.09316673f, -0.05272724f, 0.04307935f, -0.10309110f, 0.01870745f, -0.08570182f, -0.00944582f, 
    -0.44216892f, 0.48811215f, -0.27843544f, 0.01726662f, -0.13258253f, 0.08190209f, 0.11153539f, -0.05264217f, 
    0.02123349f, 0.04023770f, -0.12201778f, -0.27770892f, 0.08801877f, 0.15992385f, 0.08761851f, -0.53437316f, 
    0.21415672f, 0.09175459f, 0.05155443f, -0.11374564f, -0.02420806f, 0.07455002f, 0.00553854f, 0.03852252f, 
    -0.28220829f, 0.03400272f, 0.34505427f, -0.30962735f, -0.01860417f, -0.03497766f, 0.01082090f, -0.10946170f, 
    -0.01179135f, -0.09429059f, 0.05777051f, 0.03081165f, 0.38032773f, 0.03783501f, -0.21489716f, 0.33849791f, 
    -0.17010872f, 0.03133568f, 0.01405121f, -0.00221577f, -0.13333096f, -0.01115319f, 0.11901097f, 0.01076362f, 
    0.43507707f, -0.02632061f, -0.20148408f, -0.00633827f, 0.06343675f, -0.03585715f, 0.03144258f, 0.05596264f, 
    -0.21318412f, 0.06417067f, 0.04901138f, -0.33926332f, -0.69740826f, 0.22276752f, 0.31594399f, -0.28188267f, 
    0.01911376f, 0.02856231f, 0.14383531f, -0.01150310f, -0.05548988f, -0.04120624f, 0.15831044f, 0.02343225f, 
    -0.27029994f, -0.12832941f, -0.27522328f, 0.13252141f, -0.07770503f, 0.17338036f, -0.11467300f, -0.06207851f, 
    0.04866731f, -0.04681707f, -0.01194330f, -0.00725646f, -0.01440672f, -0.08280474f, 0.23772667f, -0.11881248f, 
    -0.26753193f, 0.02307534f, 0.09650344f, 0.14080516f, 0.08351026f, 0.01540717f, 0.01528947f, 0.00491438f, 
    0.13986482f, -0.03710166f, -0.17490296f, 0.33847472f, -0.21083964f, -0.05020901f, -0.10206658f, 0.00488794f, 
    -0.05875060f, -0.05212640f, 0.02939883f, -0.08921915f, 0.51165450f, -0.20784843f, 0.02012314f, 0.20660250f, 
    -0.15583935f, 0.00987833f, -0.00767336f, -0.12702693f, -0.05295542f, -0.06323236f, 0.15527651f, 0.01370817f, 
    0.32696736f, -0.22408321f, 0.16599438f, 0.17033416f, -0.15173998f, -0.04851547f, 0.04633731f, 0.10928547f, 
    0.02802822f, 0.16286768f, -0.02330634f, -0.01211536f, 0.02429664f, 0.17541713f, 0.12611768f, -0.08610813f, 
    -0.15464374f, -0.14195168f, -0.00665480f, 0.08402734f, 0.06759071f, 0.02801121f, -0.20535421f, -0.07572567f, 
    0.10630720f, -0.20249619f, -0.05754062f, -0.03453438f, 0.02186422f, -0.05304529f, -0.00129140f, -0.02749918f, 
    0.02558196f, -0.02062603f, 0.05938270f, 0.10315183f, -0.60690731f, 0.05738041f, 0.09348352f, -0.08328559f, 
    -0.07332038f, -0.07072192f, -0.01681603f, -0.06316330f, 0.12973221f, -0.13991302f, -0.09860066f, 0.05107882f, 
    0.10631284f, -0.29076353f, -0.03879967f, -0.27042237f, -0.12646343f, -0.07363846f, -0.01122945f, -0.08090273f, 
    -0.26345259f, 0.13214123f, -0.15940158f, 0.07569877f, -0.24499184f, 0.03082890f, 0.10206971f, 0.20777901f, 
    0.02109506f, 0.02510164f, 0.08191559f, -0.04329353f, -0.04590263f, 0.06916697f, -0.07466921f, 0.01508696f, 
    -0.48871702f, -0.24694587f, 0.20237271f, -0.06159147f, -0.02748623f, -0.11454906f, 0.12500769f, -0.23207384f, 
    0.03943177f, 0.07172173f, 0.18609798f, 0.09355038f, -0.54211324f, 0.33326125f, -0.23625813f, 0.32209158f, 
    0.14553273f, 0.13002698f, -0.05455322f, 0.03843535f, -0.04687066f, 0.06833944f, -0.01852184f, 0.04443044f, 
    0.13775088f, 0.08743957f, -0.07303963f, -0.47138608f, 0.06382105f, 0.13252300f, 0.03661738f, 0.05005480f, 
    -0.15363179f, 0.04453813f, -0.07680865f, -0.08439854f, -0.37255082f, 0.15495674f, -0.10600185f, 0.26051730f, 
    0.04618537f, 0.09572691f, -0.15404324f, -0.02649784f, 0.09042586f, -0.09741811f, 0.07416748f, 0.01515715f, 
    0.16265115f, 0.06056547f, 0.17058450f, 0.06839749f, 0.07811549f, 0.07187290f, -0.04140488f, -0.20416249f, 
    0.05649234f, 0.11652859f, 0.07991205f, -0.15668020f, -0.01864902f, 0.16636653f, -0.08053001f, -0.26593196f, 
    0.06007611f, -0.11680618f, 0.10004685f, 0.05927103f, 0.11149026f, -0.16571283f, 0.00434989f, 0.14722337f, 
    -0.47512388f, -0.18190028f, -0.16365947f, -0.04939945f, -0.14078480f, 0.02274259f, -0.05068122f, -0.01255581f, 
    0.02361651f, -0.02395377f, -0.10168419f, 0.21672083f, -0.02069447f, 0.20346895f, -0.15435103f, -0.35722396f, 
    0.02927020f, 0.03261201f, 0.01491304f, 0.01140634f, -0.09025960f, -0.07377982f, -0.07305345f, 0.03046534f, 
    0.07275694f, -0.20938982f, 0.26808596f, -0.42496306f, -0.07054106f, -0.09295672f, -0.06015066f, 0.06317367f, 
    -0.17717206f, 0.01534986f, 0.03096854f, 0.03997217f, 0.31617922f, -0.01256957f, -0.15440837f, 0.24502946f, 
    -0.31984419f, -0.04276631f, -0.03174517f, 0.16780359f, 0.00201844f, -0.00132259f, -0.13038883f, 0.01282665f, 
    0.23918416f, -0.13018918f, -0.32652542f, 0.11917156f, 0.10452593f, 0.00337680f, -0.17875884f, 0.04543773f, 
    -0.20704381f, 0.03346730f, -0.13221242f, 0.18834572f, 0.03982039f, -0.03251508f, 0.30812335f, -0.30630222f, 
    0.02767959f, 0.05499647f, 0.08610246f, 0.19134988f, 0.07468326f, -0.11628988f, -0.06534892f, -0.00979818f, 
    -0.10105589f, 0.10619513f, 0.23854254f, 0.06396040f, 0.04276655f, 0.15449551f, 0.07903829f, 0.27377129f, 
    0.00273923f, 0.10433236f, 0.14173536f, 0.19443688f, -0.10880250f, -0.20658617f, -0.04785823f, -0.10346968f, 
    -0.04809632f, -0.06901190f, -0.19721217f, -0.07194721f, 0.10903545f, -0.18574531f, -0.05999631f, -0.03509518f, 
    0.10002164f, 0.01662224f, 0.09035880f, -0.03418160f, 0.13816874f, -0.00786261f, -0.09166090f, 0.00376396f, 
    -0.06122804f, 0.10097869f, 0.03145174f, 0.00439039f, 0.00127786f, -0.05796117f, -0.01593634f, 0.34518948f, 
    0.09949256f, -0.12528522f, -0.02491147f, -0.02663616f, 0.09243129f, 0.05503969f, -0.06117664f, 0.30550441f, 
    0.29797351f, -0.41335157f, 0.08522118f, 0.08512025f, 0.00079790f, 0.16775170f, -0.19654635f, 0.14229645f, 
    -0.00640706f, -0.10460312f, 0.00931293f, 0.08110535f, 0.22724299f, -0.13893135f, -0.19647972f, -0.20048499f, 
    -0.02856891f, -0.08458909f, -0.01934082f, 0.16084293f, 0.19717613f, 0.01224906f, -0.07145219f, -0.04365484f, 
    0.25336799f, -0.07766195f, -0.27563664f, -0.22304145f, -0.06244795f, 0.00913038f, 0.14596421f, 0.00826190f, 
    -0.07226495f, -0.00673516f, -0.17649080f, -0.10096611f, -0.18614177f, -0.27100286f, 0.03839993f, -0.04068927f, 
    -0.02283704f, -0.04057604f, -0.07219284f, -0.10426542f, -0.00099038f, -0.00143095f, -0.40906015f, -0.09036253f, 
    0.35803914f, -0.10114751f, 0.09768628f, 0.16613837f, 0.05390231f, -0.03650174f, 0.00201869f, -0.10312981f, 
    0.05721382f, -0.00341686f, -0.15766068f, -0.05903915f, -0.20571914f, 0.15253951f, -0.25968194f, -0.38294846f, 
    -0.03629493f, 0.08162680f, -0.05337228f, 0.11021765f, 0.18035503f, -0.15229984f, -0.21034656f, -0.05590336f, 
    -0.47793779f, 0.20098381f, -0.22842130f, 0.45346758f, -0.02299895f, -0.03156691f, 0.08502015f, 0.07137254f, 
    0.08105110f, 0.03513729f, -0.02140982f, 0.13824755f, 0.26694900f, 0.17020558f, -0.01212669f, 0.26877299f, 
    0.07330472f, 0.00435154f, 0.06107426f, 0.09245214f, 0.03290063f, 0.04032908f, -0.19463117f, -0.01232455f, 
    0.35554790f, -0.28446940f, 0.06349160f, 0.14495462f, 0.02717476f, -0.18208450f, -0.02644202f, 0.03777992f, 
    0.02797787f, 0.06808298f, -0.19351728f, 0.10037591f, -0.59429091f, 0.24135341f, 0.16498859f, -0.00417326f, 
    0.10009981f, 0.05499190f, 0.14345710f, -0.10713448f, -0.04923630f, 0.03373718f, -0.01597745f, -0.03255227f, 
    0.35358605f, -0.05311549f, -0.01789754f, 0.05959020f, -0.10594231f, -0.15489595f, -0.02798091f, -0.01331080f, 
    -0.08023921f, -0.13740231f, -0.08529788f, -0.13615969f, -0.13369979f, -0.21179016f, -0.10953719f, -0.09774454f, 
    0.02118072f, 0.11440944f, 0.08113486f, -0.08429091f, -0.01019951f, 0.12840854f, 0.01659039f, 0.12155108f, 
    0.06223124f, 0.17550960f, 0.06720968f, 0.01560833f, -0.23890571f, -0.06250676f, 0.10469030f, -0.11055254f, 
    -0.15267737f, 0.05178788f, -0.02074161f, -0.02910307f, 0.11470877f, 0.11763593f, -0.11167961f, -0.51455677f, 
    0.03293017f, 0.12267847f, 0.17330906f, -0.08116736f, 0.08221007f, 0.12851185f, 0.06003863f, 0.04956472f, 
    0.08826274f, 0.22147286f, -0.01322487f, -0.02993928f, 0.00675596f, -0.10215551f, 0.06496423f, -0.03512221f, 
    0.23714331f, 0.00046065f, 0.14760041f, -0.06701764f, 0.33604014f, -0.01200320f, -0.24360132f, -0.07038418f, 
    0.17550062f, -0.10104318f, -0.28470001f, 0.13575236f, -0.03223266f, -0.11854818f, 0.15842529f, -0.02049715f, 
    0.24730474f, -0.07202898f, -0.11740124f, -0.00591055f, -0.19530927f, -0.04890651f, -0.12127831f, -0.02470231f, 
    -0.19848041f, 0.11565799f, -0.02487268f, -0.16632277f, -0.40399322f, -0.21299456f, -0.12268389f, -0.08369377f, 
    -0.01269144f, -0.03507699f, -0.09754909f, -0.08257587f, -0.03124417f, 0.00889867f, -0.03289478f, -0.00215456f, 
    -0.41241831f, -0.00206473f, -0.18627664f, -0.40090814f, 0.03187663f, 0.08390398f, 0.03657419f, 0.14001235f, 
    0.07372671f, 0.12250503f, 0.07129266f, -0.03149505f, 0.05699633f, -0.27063304f, -0.20598456f, 0.11506217f, 
    -0.22115473f, 0.10414942f, -0.00328194f, 0.01547858f, -0.01847247f, -0.07374164f, 0.10338608f, -0.00589818f, 
    -0.30153266f, 0.11915960f, 0.02845960f, 0.01756763f, -0.06911128f, -0.14075859f, -0.01431760f, -0.19494365f, 
    -0.04982520f, -0.16261177f, 0.05816974f, 0.07588448f, 0.01260587f, 0.12564179f, 0.07490312f, -0.07325584f, 
    -0.00655949f, -0.18827790f, 0.05092938f, 0.05934752f, -0.14730529f, 0.07190706f, 0.04852397f, 0.07947894f, 
    0.15237843f, -0.08306569f, -0.14108941f, -0.04769889f, -0.14123759f, 0.13503355f, -0.04007988f, 0.19066378f, 
    -0.03266330f, -0.15705727f, -0.07358409f, -0.17892227f, 0.09855373f, -0.17333850f, 0.04232044f, -0.17049508f, 
    0.10615357f, -0.05640014f, -0.10913268f, -0.03953400f, 0.10888246f, -0.27179226f, -0.06512097f, -0.03567166f, 
    0.31779936f, -0.56964487f, 0.06934820f, -0.35027212f, 0.05848359f, 0.08126029f, 0.00441353f, 0.04244591f, 
    0.03667982f, -0.10404520f, -0.01785884f, 0.01040164f, 0.19307506f, 0.03030167f, 0.31234178f, 0.41487890f, 
    -0.06558057f, -0.02582551f, -0.01109737f, -0.05817481f, -0.01866103f, -0.00853525f, 0.12906338f, -0.00155476f, 
    -0.00118627f, 0.07389398f, 0.11048140f, 0.32650414f, -0.22579005f, -0.09662948f, 0.14758128f, 0.05022887f, 
    0.03653136f, -0.05265130f, 0.10265721f, -0.02924212f, 0.08925037f, -0.21195188f, 0.06362903f, -0.60649455f, 
    -0.21725389f, -0.04600978f, 0.07559360f, -0.13936374f, -0.04161278f, -0.09120620f, 0.12976876f, 0.06363879f, 
    -0.56615597f, -0.35570773f, -0.18536922f, 0.02831351f, -0.06841110f, -0.06602180f, -0.17357534f, 0.05463051f, 
    -0.04272448f, -0.09639141f, 0.00150294f, -0.09778687f, 0.00084300f, 0.26387194f, -0.02788998f, 0.37055022f, 
    -0.20770389f, -0.14932173f, 0.05045103f, -0.00831014f, -0.10906684f, -0.15051295f, -0.06407195f, 0.04894296f, 
    0.25794756f, 0.19080636f, 0.08561777f, 0.11779504f, -0.10082077f, -0.01439715f, 0.06736025f, 0.18383919f, 
    -0.14814609f, -0.12871380f, -0.12251593f, -0.09032616f, -0.02719905f, 0.06662445f, -0.01795501f, -0.10668164f, 
    0.10567871f, 0.01089569f, 0.04897802f, -0.14024824f, 0.04364414f, 0.07860459f, -0.08705400f, -0.03772102f, 
    0.55080456f, -0.20144221f, -0.02499395f, -0.02119719f, -0.16345382f, 0.02856501f, -0.10651421f, -0.08744299f, 
    0.02761089f, -0.03441739f, 0.14317113f, -0.00765377f, 0.15263803f, 0.08566093f, 0.25558186f, 0.33915350f, 
    -0.15806496f, -0.17081682f, 0.05964923f, 0.03714854f, -0.06017197f, -0.00506101f, 0.05459708f, 0.03460468f, 
    -0.03165096f, 0.01974596f, -0.14519858f, -0.18677269f, 0.15242250f, -0.02250776f, -0.03819574f, -0.15191384f, 
    0.00570275f, 0.20832889f, 0.06166823f, 0.19756970f, 0.27776754f, 0.07910581f, -0.13656366f, -0.04458336f, 
    0.22289571f, 0.05411237f, -0.05163371f, -0.17687352f, 0.10753776f, -0.03411477f, 0.15383305f, -0.12796912f, 
    -0.29084405f, 0.27034354f, -0.09879062f, 0.10412396f, 0.02097349f, -0.16572745f, 0.13205458f, 0.11214687f, 
    -0.09655857f, -0.05527494f, -0.07625870f, -0.04984227f, 0.19938654f, -0.23848455f, -0.25080475f, -0.37322530f, 
    0.01881530f, -0.00129265f, -0.01423507f, 0.03414623f, -0.02867487f, 0.06834338f, 0.00852676f, -0.16397755f, 
    -0.02307189f, -0.23988333f, 0.03165501f, -0.33109751f, -0.24522874f, 0.04263253f, -0.20761035f, -0.11901860f, 
    0.17429142f, -0.06468970f, 0.06564780f, -0.08902454f, -0.03810588f, 0.04929982f, -0.07516793f, -0.01896033f, 
    0.12780848f, 0.13945954f, 0.07014614f, -0.06361554f, 0.14310510f, -0.04763852f, 0.07228286f, 0.01161592f, 
    0.31386834f, -0.10541914f, -0.06186302f, -0.03301816f, 0.07640658f, 0.01039660f, 0.04761728f, 0.05876383f, 
    -0.04978625f, 0.10729107f, 0.06103250f, -0.08903269f, 0.42275614f, 0.22881766f, -0.00973794f, 0.01575322f, 
    -0.02524211f, 0.11407471f, -0.17189363f, -0.06094592f, -0.12960495f, 0.11594846f, -0.00801381f, 0.05061977f, 
    0.14168951f, -0.20989291f, 0.04229991f, -0.06530270f, 0.15629840f, 0.03719264f, 0.10846682f, 0.04617814f, 
    -0.00666793f, 0.09323657f, -0.03020670f, -0.01691792f, 0.11568773f, 0.10030742f, -0.15531538f, 0.00095649f, 
    0.08672510f, 0.09132301f, -0.05849778f, -0.15293993f, -0.03860746f, -0.12463765f, -0.10813204f, -0.23409577f, 
    0.03667157f, 0.05829930f, -0.07798034f, 0.07730646f, 0.01179408f, 0.01289238f, -0.05142096f, 0.01999308f, 
    -0.07356753f, 0.01400217f, -0.18125857f, -0.01659903f, -0.15373774f, -0.09849976f, 0.02006150f, -0.25555995f, 
    0.12949352f, -0.08535928f, -0.02106304f, -0.14454757f, -0.14982431f, -0.10851970f, -0.18834327f, 0.00353426f, 
    -0.46672252f, 0.02575672f, 0.08366463f, -0.21874955f, -0.08775089f, 0.08777320f, 0.05277891f, -0.07072854f, 
    -0.00294505f, -0.03504387f, -0.03169823f, -0.05205262f, 0.27822334f, -0.36018604f, 0.37498644f, -0.02702668f, 
    -0.12354986f, -0.07695232f, -0.05092047f, 0.04943800f, -0.00596030f, -0.01892796f, -0.17936742f, 0.02944676f, 
    0.18151398f, -0.42269850f, 0.13556190f, -0.08419483f, 0.01762157f, -0.04835225f, 0.00514086f, -0.09738760f, 
    -0.00436719f, 0.01880542f, -0.02759911f, 0.10787571f, -0.15619470f, 0.05885585f, -0.61467844f, -0.48844662f, 
    -0.23146483f, -0.02511243f, -0.09183987f, -0.04066367f, 0.06621613f, -0.10223836f, -0.03265657f, 0.00663566f, 
    0.16019730f, 0.16259529f, -0.18513621f, 0.04653790f, -0.03910522f, -0.09016747f, -0.04045734f, -0.05073097f, 
    -0.14219639f, -0.09921930f, 0.05741202f, -0.04531808f, 0.83974683f, -0.33782005f, 0.03227421f, 0.04535319f, 
    -0.11903490f, 0.08448621f, -0.01296360f, 0.14772183f, -0.00113876f, -0.07737053f, 0.14814885f, -0.07186286f, 
    0.39333397f, -0.00018427f, -0.00722858f, -0.26596469f, -0.06799915f, 0.02077296f, 0.12356951f, -0.00309578f, 
    -0.01489592f, -0.01302006f, 0.12726229f, -0.21640064f, -0.12409946f, 0.12465309f, 0.00931502f, -0.23097529f, 
    0.00645347f, -0.18017896f, 0.14341125f, 0.05077039f, 0.06013425f, -0.02644501f, -0.04152985f, -0.05247744f, 
    0.13578470f, 0.12473766f, 0.04426098f, -0.07253141f, -0.30369937f, -0.11429561f, 0.06746247f, -0.00029875f, 
    0.02482840f, -0.10781801f, -0.04170484f, -0.16570485f, 0.46534991f, -0.07774258f, -0.03886513f, 0.32990193f, 
    -0.15657364f, -0.14922179f, 0.11714678f, 0.09000806f, -0.01551417f, 0.12540239f, 0.00965002f, 0.14797643f, 
    -0.36762974f, -0.07959595f, 0.01012681f, -0.24999456f, 0.03265955f, -0.02516688f, 0.07699773f, -0.08334661f, 
    -0.09379129f, -0.00429213f, -0.11832622f, 0.00835858f, 0.02373895f, -0.06604354f, -0.10145988f, 0.07590817f, 
    0.20035155f, -0.00540188f, 0.00422106f, -0.07443422f, 0.06225823f, 0.13163629f, -0.06666158f, -0.04689790f, 
    -0.28259355f, 0.00759776f, 0.00754860f, -0.15278243f, -0.06441421f, 0.06810880f, -0.08142788f, 0.01763507f, 
    0.01034334f, 0.04801806f, -0.09363062f, 0.03787318f, 0.11312248f, -0.14801288f, 0.14157797f, -0.23342024f, 
    0.05511837f, -0.06501216f, -0.01604487f, -0.12581329f, -0.01684881f, -0.00954980f, 0.13069715f, -0.03219787f, 
    0.19759160f, 0.00607669f, 0.06802433f, -0.10064790f, -0.13640104f, -0.10110799f, 0.01479227f, -0.01777060f, 
    0.08720761f, 0.07883107f, 0.07670022f, -0.04955862f, -0.07919012f, -0.01045479f, -0.00903349f, -0.08588295f, 
    -0.07486866f, 0.02129940f, 0.16535179f, -0.04678820f, -0.21133521f, 0.08410758f, -0.09535114f, 0.02289823f, 
    -0.23756173f, -0.02088750f, -0.08015655f, -0.26177219f, -0.18119845f, -0.04504209f, -0.14328448f, -0.04252053f, 
    0.11130028f, -0.06760706f, 0.14902049f, 0.03137029f, -0.39938802f, -0.52631760f, -0.19350742f, 0.21288525f, 
    -0.03097178f, -0.01403674f, 0.08788438f, -0.05171524f, 0.01646004f, -0.14737201f, 0.06814161f, -0.20838070f, 
    0.23137924f, 0.17026246f, 0.13939610f, 0.22403054f, -0.06933084f, -0.08253102f, 0.09129735f, -0.02331697f, 
    -0.12415317f, 0.07637611f, -0.03424779f, -0.02320660f, -0.15247510f, -0.02948111f, -0.10676529f, -0.24858287f, 
    -0.10600089f, -0.09544545f, -0.02361325f, -0.07735988f, 0.01198623f, -0.06958839f, -0.13549580f, 0.03066146f, 
    0.46398884f, -0.15768051f, -0.23764957f, 0.00246078f, -0.02572136f, -0.08467120f, -0.09770089f, -0.02748372f, 
    0.01566060f, 0.11309601f, -0.01793573f, 0.04817838f, -0.32461777f, -0.01374464f, 0.19901751f, 0.21681683f, 
    0.03474442f, 0.33244824f, 0.07709000f, -0.05742304f, 0.11159166f, 0.05681080f, 0.21421289f, -0.08719420f, 
    -0.23284750f, 0.01076423f, -0.21886475f, 0.00013154f, -0.03793649f, 0.02714376f, -0.02731139f, -0.01808069f, 
    -0.07848831f, 0.07771020f, -0.02942306f, -0.02422074f, 0.10903881f, 0.22576000f, 0.21874072f, 0.24900921f, 
    0.19615550f, -0.08806478f, 0.12778376f, 0.02252683f, -0.07095490f, 0.00410778f, -0.03347576f, -0.06310897f, 
    0.45257187f, 0.03865452f, 0.21450472f, -0.25651592f, 0.06132033f, 0.04222498f, -0.00961508f, 0.10528653f, 
    -0.04808514f, -0.07972108f, 0.05348993f, -0.09900133f, -0.63163459f, -0.13703728f, -0.03571201f, -0.23959669f, 
    -0.07931659f, 0.11871425f, 0.06208651f, -0.04850146f, 0.02088985f, -0.03573420f, 0.14287519f, -0.02721808f, 
    0.41341150f, -0.44612634f, -0.48303717f, -0.00553287f, -0.05066456f, 0.03144864f, 0.06841756f, -0.08497916f, 
    0.12016110f, 0.03201898f, -0.02563990f, -0.14548056f, -0.03849739f, 0.22601157f, -0.18111351f, -0.17515105f, 
    -0.00249629f, -0.09622592f, -0.06359584f, 0.15710749f, 0.15234466f, -0.05884511f, 0.07825491f, -0.01434665f, 
    -0.45085174f, -0.38718396f, -0.44461527f, -0.03230557f, -0.18956320f, -0.01311808f, -0.07328946f, -0.04001635f, 
    0.02787739f, -0.17153139f, 0.04497330f, 0.10818777f, 0.32990780f, -0.03419803f, -0.08884607f, 0.32961670f, 
    0.18119164f, -0.03705774f, -0.02462199f, 0.11623962f, -0.00108959f, 0.08392054f, -0.04395872f, -0.25141597f, 
    -0.56075877f, -0.34688866f, -0.11247255f, -0.53387815f, -0.06695545f, -0.22886527f, 0.01505176f, 0.03319730f, 
    0.03334930f, -0.06148460f, 0.07759760f, -0.05253531f, 0.45342284f, 0.04995174f, 0.34425017f, 0.08324892f, 
    -0.02733636f, 0.10046918f, -0.12469923f, 0.08385662f, -0.01090749f, 0.05257786f, -0.18441211f, 0.08955065f, 
    -0.20994973f, -0.41355014f, -0.13234425f, 0.18757315f, -0.11614551f, 0.06523360f, 0.03747427f, 0.14571854f, 
    -0.00698491f, -0.02509423f, -0.05200895f, -0.03388944f, -0.07986686f, 0.16170926f, -0.14794971f, 0.02759455f, 
    -0.24967483f, -0.05719626f, 0.09810109f, 0.04465228f, 0.02342409f, 0.00160208f, 0.06347416f, 0.10629041f, 
    0.47714674f, -0.13659929f, 0.12486304f, 0.20778127f, 0.10787220f, 0.09174685f, -0.02360925f, 0.03738565f, 
    -0.04916715f, -0.09797529f, -0.03296140f, -0.07030743f, 0.06697836f, 0.25508082f, 0.12801604f, -0.10456870f, 
    -0.10324117f, -0.01829702f, -0.18680137f, 0.08528143f, 0.02986063f, -0.00363900f, -0.02491101f, 0.02283968f, 
    -0.06216319f, 0.13441196f, 0.09949946f, -0.11422387f, -0.12599798f, -0.03161689f, 0.00422781f, 0.05500652f, 
    0.06479185f, 0.03112202f, 0.05389845f, 0.11303324f, -0.02381138f, 0.15720597f, 0.15068069f, 0.16394278f, 
    0.00074883f, 0.02348286f, 0.12635304f, 0.09436166f, -0.06095365f, 0.12392820f, -0.08540936f, 0.01659052f, 
    -0.71391374f, 0.36538193f, 0.01135464f, 0.09706108f, -0.05993981f, 0.11837335f, -0.01492630f, 0.08395866f, 
    0.00994022f, -0.02111310f, 0.10282442f, 0.16229068f, -0.14788106f, -0.46684930f, -0.21304798f, -0.00880903f, 
    -0.21493150f, 0.01089038f, 0.01454720f, 0.09265080f, 0.01540942f, 0.00385293f, -0.01816064f, -0.04255752f, 
    0.20537831f, 0.03502657f, -0.10194154f, -0.05052614f, -0.12511934f, -0.17209928f, 0.09449826f, -0.13231775f, 
    -0.06323443f, 0.08889764f, 0.08372534f, 0.08465748f, -0.07549220f, 0.03658869f, 0.10396348f, -0.23827852f, 
    -0.02134051f, -0.02791526f, -0.01579525f, 0.08618464f, -0.16911711f, 0.07482515f, -0.07107011f, 0.14766534f, 
    -0.12582262f, 0.03518552f, 0.04030017f, 0.21465142f, 0.03066980f, 0.01213415f, 0.04543529f, 0.13194524f, 
    -0.13240418f, 0.05526981f, 0.04988650f, 0.07394881f, -0.34245798f, -0.54156071f, 0.07958178f, 0.20487997f, 
    -0.22025730f, 0.01498191f, 0.01521019f, -0.01174853f, -0.08293358f, -0.07765868f, 0.10694950f, -0.00489106f, 
    0.32340556f, -0.49868178f, -0.11667343f, 0.08357893f, 0.21720485f, 0.08537819f, -0.07747206f, -0.09116138f, 
    -0.03522903f, -0.06982399f, -0.09346899f, 0.00013173f, 0.09440469f, 0.21799621f, -0.12627980f, 0.05912040f, 
    -0.13114032f, 0.00333580f, -0.03137403f, 0.03923037f, -0.08928431f, -0.07170651f, -0.06840044f, -0.01452104f, 
    0.28236598f, 0.22260207f, -0.21073094f, 0.15257351f, -0.07127501f, -0.06053646f, 0.01607407f, 0.10710754f, 
    -0.09395697f, -0.11029916f, -0.03681622f, -0.02083272f, -0.27110884f, -0.16341010f, -0.12803602f, 0.06776346f, 
    0.15747112f, 0.00794296f, 0.06135600f, -0.12253263f, -0.12179127f, 0.12575829f, 0.04202337f, -0.05280051f, 
    -0.21012652f, 0.06237800f, -0.05520135f, 0.40792707f, -0.04469549f, 0.04615957f, 0.09682921f, 0.04114539f, 
    0.04277031f, 0.10822644f, -0.00344822f, 0.02505528f, -0.19669771f, -0.19997807f, 0.17822438f, 0.19699186f, 
    -0.16498198f, -0.00295837f, 0.02792369f, -0.05878183f, 0.15682988f, -0.04159161f, -0.01188321f, -0.19040437f, 
    -0.35763565f, 0.02344028f, -0.25297907f, 0.01454420f, 0.07183135f, -0.13770305f, 0.02992930f, 0.13743968f, 
    -0.04376747f, -0.08297664f, 0.04491832f, 0.00785630f, -0.39043882f, -0.10247234f, 0.11918629f, 0.22876267f, 
    0.01605588f, 0.07019752f, 0.11680010f, 0.08819021f, 0.02391441f, -0.03336544f, 0.07702828f, 0.05167070f, 
    0.50254905f, 0.20993190f, 0.02688674f, 0.15961917f, -0.04084114f, 0.04827957f, -0.03433535f, 0.02647754f, 
    -0.07397741f, 0.02526107f, 0.03554286f, 0.07774114f, -0.21500303f, 0.10667592f, -0.00344361f, 0.18762347f, 
    0.22232842f, -0.05971863f, 0.14077492f, -0.01798976f, 0.16349034f, 0.04273353f, 0.00465174f, -0.00770645f, 
    -0.34288755f, 0.22909991f, 0.20605336f, -0.00650542f, -0.03229952f, -0.02720687f, -0.09053516f, -0.12541093f, 
    0.07954642f, -0.01574334f, 0.13457558f, 0.03810815f, -0.26577491f, -0.10915178f, 0.02454234f, -0.13634370f, 
    -0.11842781f, -0.05450357f, -0.14664051f, -0.10732228f, -0.01228208f, -0.04916054f, -0.02904544f, -0.00049992f, 
    -0.17427614f, -0.21452588f, 0.07246572f, -0.37088293f, 0.04202974f, 0.05311506f, -0.23046726f, 0.01433590f, 
    -0.07762453f, -0.11578566f, -0.05847499f, 0.08891761f, 0.23235270f, -0.10123353f, -0.19977547f, 0.01891438f, 
    -0.06223125f, -0.21786994f, 0.10821806f, 0.03050006f, -0.01607624f, 0.04137473f, 0.16591039f, -0.01749669f, 
    0.15401262f, 0.13970615f, -0.02734001f, -0.00474867f, -0.11038420f, 0.13598008f, 0.09116168f, -0.03187350f, 
    0.03845712f, -0.17080468f, -0.07809120f, 0.04259696f, 0.20673905f, 0.57745248f, -0.33514172f, -0.18515030f, 
    0.13312541f, 0.03615355f, -0.06726202f, 0.15794732f, 0.01577274f, -0.08714788f, -0.04137304f, -0.08856664f, 
    -0.06135057f, -0.13708119f, 0.13286278f, 0.14917536f, -0.14842108f, -0.09443984f, 0.09165617f, 0.06432822f, 
    0.06169405f, 0.04060548f, -0.10218351f, -0.01451252f, -0.58676666f, 0.07215218f, 0.31033105f, 0.01874469f, 
    -0.09928190f, 0.06104001f, -0.18317358f, -0.05832797f, -0.08186286f, -0.22894104f, 0.11854014f, 0.00403696f, 
    -0.11922906f, -0.03122691f, -0.23054717f, 0.00010468f, 0.04330111f, -0.05410969f, -0.12594895f, 0.08495493f, 
    -0.07176152f, -0.07102999f, 0.00309866f, 0.04102779f, -0.26081350f, 0.22413029f, 0.30752385f, -0.04338424f, 
    0.00515121f, -0.01475151f, 0.03760232f, 0.07326923f, 0.01600071f, -0.03022193f, -0.09555665f, 0.03035515f, 
    -0.28975347f, 0.09748203f, 0.20484610f, -0.42418939f, 0.15399560f, 0.10735942f, -0.21268192f, 0.19514298f, 
    -0.00934226f, -0.04867110f, -0.02102877f, -0.08549322f, -0.66906786f, 0.18053588f, -0.06187197f, -0.11757145f, 
    -0.06147556f, -0.02771673f, 0.12864304f, -0.16053762f, 0.12987323f, 0.14342359f, 0.01298338f, 0.01662804f, 
    -0.43152425f, 0.24236919f, -0.29449782f, -0.33688799f, 0.00390725f, -0.01779559f, 0.08933281f, 0.01803952f, 
    -0.04810451f, -0.12676871f, -0.07785935f, 0.09164986f, 0.06430103f, -0.11966817f, 0.10499310f, -0.21016583f, 
    0.05255174f, 0.01104420f, 0.00613900f, 0.00106655f, 0.01245279f, -0.05871890f, 0.04072351f, 0.02184057f, 
    0.41367650f, 0.06982611f, 0.14605390f, 0.10851128f, -0.01602267f, -0.11213204f, 0.10316030f, 0.05140990f, 
    0.07788360f, -0.05031094f, -0.03466830f, 0.06274337f, -0.93032658f, 0.10246709f, -0.04295711f, -0.06081208f, 
    0.03037728f, 0.00147380f, -0.07604364f, -0.00150907f, -0.03891774f, 0.03529596f, -0.06128955f, 0.09153396f, 
    -0.57979703f, -0.01588155f, 0.19866128f, 0.23306726f, -0.03343857f, 0.06516515f, 0.11244365f, 0.18263602f, 
    -0.05174295f, 0.19995975f, 0.10068475f, -0.03130987f, -0.03275042f, -0.51072252f, 0.10273895f, -0.10776064f, 
    -0.20935877f, 0.14655824f, 0.09971721f, -0.15336096f, 0.05948257f, 0.09122516f, 0.05169903f, -0.00093564f, 
    0.03021136f, 0.19175577f, -0.08072587f, -0.10303996f, 0.29633704f, -0.02218788f, 0.14082395f, 0.10380293f, 
    -0.03349356f, 0.01379985f, 0.04825114f, 0.03718005f, -0.35953221f, -0.05138978f, 0.12700200f, 0.29669952f, 
    0.03979864f, -0.06752528f, -0.09132083f, 0.05775476f, -0.07724152f, 0.20702012f, 0.19494687f, 0.11357114f, 
    -0.11917699f, -0.06599320f, 0.10221668f, 0.13794662f, -0.02223400f, -0.05265866f, -0.03364476f, 0.09624074f, 
    0.09178443f, -0.03754413f, -0.08282278f, -0.05605989f, 0.31828517f, 0.12592015f, -0.00879796f, -0.13574353f, 
    0.06063812f, 0.00149673f, 0.01730651f, 0.16529225f, -0.02694125f, -0.06596502f, 0.03929076f, -0.04326193f, 
    -0.14442156f, -0.10904395f, 0.09192990f, 0.04790466f, -0.15088105f, 0.05838629f, -0.10668832f, -0.08963215f, 
    0.22549178f, -0.10302535f, -0.03004180f, -0.06514846f, -0.02338880f, -0.30332008f, -0.22665803f, 0.17238575f, 
    0.07424069f, -0.07613609f, -0.01151679f, 0.04997433f, -0.11653256f, -0.01878606f, 0.03133519f, -0.13498226f, 
    -0.14505933f, -0.26623195f, -0.22447559f, 0.11995918f, 0.31892577f, -0.06180181f, 0.01811917f, -0.23764966f, 
    0.13082944f, 0.04208833f, -0.17994493f, 0.13425352f, 0.03228330f, 0.03459657f, -0.25237739f, -0.22616927f, 
    0.03886694f, 0.26103881f, -0.03365088f, 0.01241156f, -0.02269424f, -0.02634109f, -0.06797741f, -0.09568057f, 
    -0.18883079f, 0.10066764f, -0.35352990f, -0.04867058f, 0.08354902f, -0.05056364f, -0.23204099f, -0.22115281f, 
    -0.06779724f, 0.03868302f, -0.03300746f, -0.05185453f, 0.20944954f, 0.19744867f, -0.05209201f, -0.11452973f, 
    -0.09416053f, 0.07262278f, -0.09491763f, 0.21374339f, -0.19968483f, 0.01063519f, 0.19215526f, 0.07811250f, 
    -0.45297688f, -0.09771613f, -0.02520659f, -0.31402817f, 0.08070585f, 0.04316005f, -0.01947255f, -0.08647607f, 
    0.10857886f, -0.01682994f, -0.06543175f, 0.24804783f, -0.17098014f, -0.20646049f, -0.17963362f, -0.06641781f, 
    0.13212787f, 0.11345171f, -0.08852866f, -0.10483765f, 0.08446036f, -0.09519006f, -0.07871909f, 0.13257308f, 
    -0.31000474f, -0.13923874f, 0.27729839f, 0.56523782f, -0.15907389f, -0.08497407f, 0.18143311f, 0.17120272f, 
    0.01810225f, -0.08916379f, -0.16680630f, -0.28596455f, 0.03374812f, 0.08414290f, 0.10736743f, -0.23847175f, 
    0.08852889f, 0.07984153f, -0.01950963f, 0.06346667f, -0.22905688f, 0.05833534f, -0.05466623f, 0.05760412f, 
    -0.20682165f, -0.00063612f, 0.18016164f, -0.16915445f, -0.19175410f, 0.19063091f, 0.05899606f, -0.05673922f, 
    0.13384521f, -0.03611529f, -0.10039757f, -0.00829774f, -0.19580133f, -0.07937851f, 0.27892715f, 0.06035153f, 
    -0.12640066f, -0.06952541f, 0.00231018f, 0.04465142f, -0.20997518f, 0.17585868f, -0.02094522f, 0.04382674f, 
    -0.02364103f, -0.14828783f, -0.20029898f, -0.00756735f, 0.12824573f, -0.12065629f, 0.18433762f, 0.02706057f, 
    -0.04044480f, 0.16669346f, 0.05442948f, -0.12110507f, 0.16853237f, 0.07945883f, 0.34150878f, -0.26607892f, 
    -0.16988267f, 0.02589672f, -0.23171262f, -0.26261052f, -0.14793226f, 0.05316715f, -0.01341762f, 0.14374736f, 
    -0.10568904f, -0.09776879f, -0.03570081f, -0.38130921f, 0.03825852f, -0.14477876f, -0.03869505f, -0.13076548f, 
    -0.17263255f, -0.14655942f, -0.02688719f, -0.01257897f, -0.36542079f, -0.30596057f, 0.28272909f, 0.17813025f, 
    -0.12562981f, -0.17996456f, 0.12257556f, -0.12553437f, 0.05140420f, -0.02978673f, -0.21476936f, -0.04425897f, 
    -0.09814811f, -0.07367781f, 0.04139188f, -0.11235136f, 0.07488688f, 0.25544178f, -0.09027664f, -0.12036251f, 
    -0.06161591f, 0.00500080f, 0.17985873f, 0.16449954f, 0.11099072f, 0.04417105f, 0.08880430f, 0.30410159f, 
    -0.28287598f, -0.03720751f, -0.03798535f, -0.07574425f, -0.13633613f, -0.01258402f, 0.08149325f, 0.17413232f, 
    0.22206852f, 0.21157280f, 0.17046961f, -0.06753901f, 0.03346606f, 0.06370930f, -0.04720387f, -0.18085761f, 
    -0.11374795f, -0.16011193f, 0.08377291f, 0.06340634f, -0.02919954f, -0.13250206f, -0.07336479f, 0.28877527f, 
    -0.03398687f, -0.00747928f, 0.09208260f, -0.11478698f, -0.09483159f, 0.10916463f, 0.39548689f, 0.19801860f, 
    0.03994753f, -0.06647369f, 0.15164091f, 0.19350684f, 0.02540519f, -0.04230828f, -0.07641764f, 0.06103394f, 
    0.04884503f, -0.09382686f, -0.00456882f, -0.02487982f, -0.43139398f, 0.11040257f, -0.19894344f, -0.22282365f, 
    0.05960369f, 0.22527143f, -0.03798030f, -0.18635730f, -0.00686443f, -0.19243972f, 0.22469595f, -0.15113091f, 
    -0.30385089f, 0.05033352f, 0.32793996f, -0.20672247f, 0.16182891f, 0.19328365f, 0.01025563f, 0.21681410f, 
    -0.01120150f, 0.12256971f, 0.01285049f, 0.05614657f, 0.12641114f, 0.18242690f, 0.03989480f, 0.19956805f, 
    -0.03586072f, -0.10748193f, 0.26839045f, 0.17012714f, -0.03088861f, 0.03485494f, -0.05049480f, -0.07497052f, 
    0.13403289f, -0.30987680f, 0.03717900f, 0.15634523f, 0.14509331f, 0.02508822f, 0.03251310f, -0.13964264f, 
    0.13798460f, -0.03072897f, -0.01459078f, 0.03617049f, -0.60667896f, 0.43944639f, -0.14799827f, -0.30791909f, 
    0.19796383f, -0.01133406f, 0.10395511f, 0.06223232f, 0.02541938f, -0.02626556f, -0.12028773f, -0.05453503f, 
    0.24338438f, -0.11842647f, -0.28783274f, -0.08612055f, 0.04625928f, -0.39588991f, -0.12409603f, 0.07188939f, 
    0.14113671f, 0.07039472f, -0.22468394f, 0.03155342f, 0.06486278f, 0.07922731f, 0.03685281f, 0.18679902f, 
    0.09969262f, -0.14871567f, -0.11339064f, -0.11499020f, -0.12512487f, 0.07776701f, -0.13301210f, -0.12327730f, 
    -0.65858132f, -0.35532552f, -0.15586618f, 0.14522430f, 0.08251528f, -0.09044591f, 0.06287936f, 0.01490400f, 
    0.04694241f, 0.27505466f, 0.00255746f, 0.09008870f, 0.02173995f, 0.08951655f, -0.43730432f, 0.01999009f, 
    0.13657337f, 0.21142393f, 0.03117552f, 0.03427916f, 0.07594820f, -0.31917712f, 0.04176550f, -0.15693061f, 
    -0.01285388f, -0.02007293f, 0.03043870f, 0.04636663f, -0.09708381f, -0.01873065f, 0.00527397f, -0.01987707f, 
    0.26123875f, 0.07316326f, 0.11394973f, -0.00514807f, 0.00693946f, 0.02674382f, 0.14224209f, 0.03094059f, 
    -0.06542252f, 0.13047616f, 0.17570534f, -0.13249198f, 0.06205858f, 0.00268282f, 0.05144082f, 0.30554435f, 
    0.14709675f, -0.03141560f, 0.00362977f, -0.05576567f, -0.07086726f, -0.10500693f, 0.05938984f, 0.17828085f, 
    -0.01737943f, 0.10407449f, 0.05225662f, 0.06195017f, 0.04434593f, -0.08197119f, -0.06478404f, 0.07612059f, 
    -0.00701511f, 0.07267783f, 0.02364359f, 0.11433160f, 0.15266611f, -0.09904589f, -0.17547597f, -0.03779518f, 
    -0.35601828f, 0.30334067f, -0.02250442f, -0.33964136f, -0.07412250f, -0.13248028f, -0.04830274f, -0.12054272f, 
    -0.15584232f, 0.06141424f, -0.06949234f, -0.16776741f, 0.07637752f, 0.03017564f, 0.04489266f, -0.00996095f, 
    -0.13325994f, 0.06830934f, -0.05209863f, -0.06215763f, 0.09016838f, -0.04652195f, 0.01053883f, 0.21244165f, 
    -0.51661390f, -0.25653714f, -0.10424382f, -0.14514524f, -0.01347887f, 0.01831551f, 0.09727578f, 0.18238413f, 
    0.04617926f, -0.03384908f, 0.04483670f, 0.01485099f, -0.07749756f, 0.31584531f, 0.10805739f, -0.26650950f, 
    0.10371956f, 0.15300196f, 0.01791002f, -0.12836701f, -0.03389751f, -0.11349133f, -0.08110423f, -0.02417917f, 
    0.32596868f, 0.07221410f, 0.01524255f, -0.16785963f, -0.01988054f, -0.13508655f, 0.03539165f, -0.18002996f, 
    0.08757012f, -0.06961578f, 0.14688240f, -0.21267392f, -0.49938574f, -0.19911376f, -0.17295305f, -0.11680650f, 
    -0.07796792f, 0.01053881f, -0.00354142f, -0.04466994f, 0.07418709f, 0.04231946f, 0.14876492f, -0.04725654f, 
    -0.10755880f, 0.24869615f, -0.12138902f, -0.16722299f, -0.01683714f, -0.02312626f, -0.02650833f, 0.01269768f, 
    -0.06842980f, 0.10520141f, 0.02690139f, 0.15101020f, 0.37234783f, 0.24573742f, 0.08274172f, -0.38554031f, 
    -0.24904899f, -0.02186856f, 0.02198398f, 0.19513717f, 0.05851267f, -0.02545064f, 0.04612753f, 0.05173866f, 
    0.01811746f, 0.04998580f, 0.15082054f, 0.17481188f, -0.00368458f, -0.06085290f, -0.02779550f, -0.02991246f, 
    -0.03190172f, 0.14002357f, 0.14214867f, 0.10715739f, 0.09633017f, 0.05292990f, -0.19715825f, 0.34346008f, 
    0.06382836f, 0.01750427f, 0.05197473f, -0.03273196f, -0.10657334f, -0.08534105f, -0.09146409f, 0.03109705f, 
    0.03875206f, -0.10509832f, 0.16607408f, -0.43572474f, -0.02944711f, -0.03861319f, 0.10885230f, -0.05091223f, 
    -0.06364790f, 0.01410919f, 0.05927654f, -0.05373589f, -0.22834411f, 0.04951674f, 0.19821003f, -0.06693673f, 
    0.02726615f, -0.06782765f, 0.12762283f, 0.11340288f, 0.01975041f, -0.05526608f, 0.03714023f, 0.05121689f, 
    -0.34707829f, 0.12563738f, 0.04618499f, 0.24894948f, -0.02392482f, 0.16187517f, -0.06738106f, 0.18375662f, 
    0.14198852f, 0.09621354f, 0.03640348f, -0.01754136f, 0.59665340f, -0.49631155f, 0.02835708f, 0.00350372f, 
    -0.17050047f, 0.08384950f, -0.01068821f, 0.08444312f, -0.11631635f, 0.17138954f, 0.02779803f, 0.17723988f, 
    -0.17616069f, 0.40284488f, 0.07392973f, -0.15053147f, -0.05440450f, -0.02068377f, 0.08712183f, 0.05620393f, 
    0.25618407f, -0.12589565f, -0.04551190f, -0.07889520f, 0.15087573f, 0.08959927f, 0.03625157f, -0.28270939f, 
    0.08257326f, -0.01960368f, 0.09927542f, 0.14585122f, 0.00595987f, -0.00693289f, -0.07946719f, -0.08368713f, 
    -0.26875007f, 0.07273664f, -0.08259256f, 0.24218027f, -0.09654171f, -0.03669458f, 0.03465867f, 0.02892934f, 
    0.05726273f, -0.03455974f, -0.20954378f, -0.22445069f, 0.00882471f, -0.05056344f, 0.02516662f, 0.19396032f, 
    -0.04882511f, 0.08330867f, -0.06918082f, 0.10827871f, -0.01019631f, -0.16863711f, -0.22483249f, -0.11087607f, 
    -0.22926137f, 0.07163341f, -0.08450684f, 0.44156724f, -0.00119491f, 0.04711176f, -0.06703835f, -0.16367729f, 
    -0.17969324f, -0.00455145f, -0.06989998f, 0.03073089f, 0.26745692f, -0.34944764f, -0.25127518f, -0.23307395f, 
    -0.14887190f, 0.08207660f, -0.03553424f, -0.02131345f, 0.10557604f, 0.15870374f, -0.14567381f, 0.25926298f, 
    0.06819822f, -0.60555816f, -0.21030618f, 0.14983685f, -0.02208727f, -0.01401915f, 0.01044472f, 0.03023290f, 
    0.02999436f, -0.32752353f, -0.04310267f, -0.13359466f, 0.08222914f, -0.22546673f, 0.11702601f, -0.13264813f, 
    -0.00187649f, -0.11052604f, -0.04023465f, 0.11301383f, 0.05270534f, 0.03484617f, -0.06783395f, -0.07787829f, 
    -0.04694440f, -0.07439350f, -0.19150819f, 0.21363896f, -0.08874106f, -0.04536354f, 0.11866762f, -0.15263845f, 
    0.01019354f, 0.02918177f, -0.02154311f, -0.14124793f, 0.62488914f, -0.60401630f, 0.16232969f, -0.25017032f, 
    0.05665874f, 0.12442502f, 0.04034589f, -0.04318502f, -0.09465944f, 0.10585079f, 0.21303445f, 0.05770478f, 
    -0.09117469f, -0.16032693f, 0.08038782f, 0.16259164f, -0.00711221f, 0.13155904f, 0.05131657f, 0.03822963f, 
    -0.05973235f, -0.05442616f, 0.00874024f, 0.12496159f, -0.63732868f, 0.25289264f, -0.14966071f, 0.39757898f, 
    0.03985206f, 0.06587701f, -0.01280236f, 0.17858544f, 0.03321512f, 0.00280864f, 0.19613278f, -0.09940018f, 
    -0.06839701f, 0.08011986f, 0.00751028f, -0.02857446f, -0.06985860f, -0.02219935f, -0.13818535f, -0.25531340f, 
    -0.05423265f, -0.15310128f, 0.01708846f, 0.04510648f, -0.35148349f, -0.26305160f, 0.02929324f, -0.32681456f, 
    -0.04547116f, 0.04637773f, 0.06997769f, -0.18230906f, -0.08895383f, 0.09885754f, 0.16817239f, 0.19145738f, 
    0.13100959f, -0.05583664f, -0.26966754f, 0.02182644f, -0.06163812f, 0.02187477f, 0.03579931f, -0.12241730f, 
    0.03892599f, 0.06627574f, -0.03746301f, 0.00784760f, -0.04684918f, 0.29193985f, 0.16216590f, -0.51442516f, 
    -0.18914554f, -0.08186144f, -0.03348871f, 0.03142277f, 0.08983451f, 0.01841574f, 0.06126835f, -0.25906187f, 
    -0.22151238f, 0.20833881f, 0.14075476f, 0.04975285f, 0.04949776f, 0.19766937f, 0.02868152f, 0.08277009f, 
    -0.02629346f, 0.02182385f, -0.09035335f, -0.15731949f, -0.13784504f, 0.08575566f, -0.19481352f, 0.22169271f, 
    0.07468841f, 0.03509789f, -0.09944265f, 0.00236799f, -0.03297232f, 0.10589514f, 0.02244390f, -0.10829049f, 
    0.00326150f, 0.31583625f, 0.11559639f, 0.30678844f, 0.13988046f, 0.10151497f, 0.06415221f, -0.09596199f, 
    -0.05747811f, 0.01824271f, -0.05170628f, -0.10388744f, 0.25484923f, 0.13741419f, 0.07640631f, 0.23261926f, 
    0.10745360f, 0.00890326f, 0.20227504f, 0.09456380f, -0.02236365f, 0.10883854f, -0.05906839f, 0.02029434f, 
    -0.01468408f, 0.11412591f, -0.06947406f, 0.04403698f, 0.03951869f, 0.01565657f, 0.06061849f, -0.02977205f, 
    0.00463927f, 0.01159859f, -0.04479147f, -0.11806382f, -0.15835783f, -0.05080252f, -0.25524279f, -0.44468623f, 
    0.10364521f, -0.08940563f, -0.01835649f, -0.06062308f, -0.02102618f, 0.00272500f, 0.00930199f, -0.12965550f, 
    0.23987302f, -0.13453647f, 0.11321983f, -0.07406402f, -0.01028940f, 0.10164708f, -0.02493485f, 0.00044325f, 
    -0.07604287f, 0.06881920f, 0.01197604f, 0.04066954f, -0.16961673f, 0.34124568f, 0.18610874f, 0.21614234f, 
    0.05133348f, 0.15667930f, 0.11137290f, -0.04108454f, 0.08377510f, 0.08494271f, 0.08674205f, 0.03312546f, 
    0.02234269f, 0.07869770f, -0.03564274f, 0.21125069f, -0.02177247f, -0.05437818f, -0.05731656f, -0.10309437f, 
    -0.16877623f, 0.05034163f, -0.03968325f, 0.04599524f, 0.03420880f, -0.22980209f, -0.08201138f, 0.02665984f, 
    -0.20267382f, -0.03269143f, 0.02028302f, -0.06263946f, -0.12282645f, -0.04140827f, 0.01264034f, -0.09883852f, 
    0.00201097f, -0.22021131f, -0.17229261f, 0.00556759f, -0.05268298f, -0.03107538f, -0.05840975f, -0.04996449f, 
    -0.06095426f, -0.04061010f, -0.00662768f, -0.00253313f, 0.38119864f, -0.21380502f, -0.02079497f, 0.34244087f, 
    0.00993170f, -0.00386361f, 0.05457888f, -0.03055895f, -0.01153168f, -0.10171081f, -0.10909796f, -0.02452726f, 
    0.27541181f, 0.09704595f, 0.14534102f, 0.23431949f, 0.09030271f, 0.00751232f, 0.04791424f, 0.01744183f, 
    -0.00315416f, 0.00284142f, -0.03313064f, -0.06449495f, 0.00837395f, -0.02740313f, -0.07576596f, 0.03487899f, 
    -0.02760746f, -0.03014120f, -0.05080050f, -0.11309490f, 0.00268456f, -0.14942941f, -0.03287465f, -0.15605471f, 
    -0.47486418f, 0.37922430f, -0.18557209f, -0.11034118f, -0.23768629f, 0.00460587f, -0.02008460f, -0.09497745f, 
    -0.14124879f, -0.05237132f, 0.00412783f, -0.17455506f, -0.13545378f, 0.00026057f, -0.02461424f, -0.12210901f, 
    0.13322806f, -0.08194523f, -0.07066495f, -0.02645364f, -0.10120957f, 0.05762438f, 0.06239578f, -0.07430661f, 
    -0.40685549f, 0.16269551f, -0.21225895f, -0.09447002f, 0.11833172f, -0.00774417f, -0.01787664f, 0.00713022f, 
    -0.09492753f, 0.02025384f, 0.00501283f, 0.02073377f, -0.48893398f, -0.02726642f, -0.20523232f, 0.22894897f, 
    -0.18174382f, -0.18470424f, -0.04980928f, 0.03618971f, -0.01249180f, 0.05347012f, 0.04648292f, -0.06844386f, 
    0.10252602f, 0.02460823f, 0.00140575f, -0.08496064f, 0.01014856f, 0.04840779f, 0.01121129f, -0.13283193f, 
    0.03258144f, -0.09905688f, -0.06289247f, -0.11206250f, -0.02964956f, -0.01954523f, 0.03758060f, 0.35052279f, 
    -0.11654875f, -0.21603267f, -0.10939050f, 0.01988741f, 0.02983233f, 0.02365301f, -0.01271517f, -0.13957725f, 
    -0.21704020f, -0.14876601f, -0.28948623f, -0.23599723f, -0.04473072f, -0.12254585f, 0.06530555f, 0.03927003f, 
    -0.05653867f, -0.03696708f, -0.05533517f, -0.05364117f, -0.44635671f, 0.09685563f, 0.22010756f, -0.19571455f, 
    -0.00865441f, 0.04354056f, 0.02403066f, -0.16216496f, -0.09551215f, 0.06893578f, -0.08651182f, -0.04748278f, 
    -0.29191780f, 0.25540128f, -0.01363258f, -0.24892190f, 0.04646028f, 0.00350474f, 0.04500594f, -0.14572269f, 
    -0.01838306f, -0.00587390f, -0.09473220f, -0.04673871f, 0.29821089f, -0.06319728f, 0.06199551f, 0.25904137f, 
    0.15019561f, -0.18705466f, -0.02930909f, -0.11959117f, -0.05237051f, -0.07351569f, -0.06925790f, -0.08216663f, 
    0.06954355f, 0.15032001f, 0.09930028f, 0.28215471f, 0.19466101f, 0.09906349f, 0.05387265f, -0.03863509f, 
    -0.04084358f, -0.07190651f, -0.01007670f, -0.11199590f, 0.44656175f, 0.03343352f, 0.29305443f, -0.20927301f, 
    0.07535268f, 0.06008453f, -0.00710446f, 0.12215217f, -0.05866055f, 0.14740679f, -0.01936133f, -0.01578832f, 
    0.18107069f, -0.23049746f, -0.03161577f, -0.13701312f, 0.11536884f, 0.07494849f, -0.04191658f, -0.08945364f, 
    -0.00437164f, -0.17029953f, -0.03258898f, 0.09683588f, -0.28535980f, -0.23617646f, -0.24564807f, -0.14617915f, 
    0.10316832f, 0.04029575f, 0.00036084f, -0.02442483f, -0.08128535f, -0.07284975f, -0.08643673f, -0.14498921f, 
    0.11571379f, 0.13685362f, 0.18800160f, 0.25019157f, 0.05254658f, 0.01743168f, -0.04984515f, -0.05308719f, 
    -0.02151300f, 0.02124912f, 0.00112702f, 0.03624780f, 0.26675826f, 0.07792781f, 0.29114673f, 0.09810904f, 
    0.15293486f, 0.09840062f, 0.15852760f, -0.12964272f, -0.06010024f, 0.13560957f, -0.07590247f, -0.02007262f, 
    -0.00853187f, 0.07359856f, -0.43853644f, -0.01668231f, -0.08620208f, -0.03424881f, -0.10802288f, -0.08419870f, 
    -0.07782346f, 0.02341672f, 0.05369598f, -0.06491791f, -0.53925979f, 0.08876792f, -0.08283620f, -0.18358529f, 
    -0.00404515f, 0.06633751f, -0.02061519f, -0.06773951f, -0.00041788f, -0.01191867f, 0.04169187f, 0.01518078f, 
    -0.06461565f, 0.19387068f, -0.27671930f, -0.25046432f, -0.00555567f, -0.10400636f, -0.15347919f, -0.11183439f, 
    -0.07236592f, 0.03224791f, 0.02211251f, -0.06518118f, -0.38701382f, 0.15929137f, -0.11045386f, 0.06991414f, 
    0.04719203f, -0.12059288f, -0.12964062f, 0.00153260f, 0.10870136f, 0.03611566f, -0.03617465f, -0.14894117f, 
    -0.34115729f, -0.26713416f, 0.36500800f, -0.14933659f, -0.16248590f, 0.06111133f, -0.15694897f, -0.11899254f, 
    0.00503387f, -0.05188450f, 0.05236436f, -0.06062350f, -0.02762918f, 0.20850524f, 0.13729638f, 0.00395502f, 
    -0.14154641f, -0.00922059f, 0.06778394f, 0.13087054f, -0.01460263f, -0.03562689f, 0.08843252f, -0.18280329f, 
    -0.21890606f, 0.02470860f, 0.17152247f, 0.04998391f, -0.06939994f, 0.01903077f, -0.13635905f, -0.01674403f, 
    -0.08897711f, -0.02816776f, 0.06649349f, -0.05864613f, -0.02845596f, -0.34878111f, -0.13678329f, 0.04214808f, 
    0.18117025f, -0.08776174f, -0.00707265f, 0.11907333f, 0.17994219f, 0.04773738f, 0.06946635f, 0.02932092f, 
    -0.42095304f, -0.00807067f, 0.15330444f, -0.27203414f, 0.14835604f, 0.02127263f, 0.06303602f, -0.16599397f, 
    0.00527857f, -0.03479224f, -0.06953579f, 0.09485765f, -0.14697962f, 0.16138658f, 0.20356371f, 0.11272334f, 
    0.02656177f, -0.03581162f, -0.00554401f, -0.06289712f, -0.01715827f, -0.05745592f, -0.03079549f, 0.01078229f, 
    -0.22722568f, -0.02546535f, -0.03875585f, -0.08537007f, 0.14182383f, -0.09905962f, -0.18906838f, 0.04681452f, 
    0.12120166f, -0.02736840f, -0.07594131f, -0.21004169f, -0.29539973f, -0.17249475f, 0.04426503f, 0.26216522f, 
    0.03195328f, -0.10689852f, -0.08730725f, 0.04323562f, -0.02017647f, 0.09108020f, -0.06714509f, -0.00810672f, 
    0.15634762f, 0.04390638f, -0.01526166f, 0.01076763f, -0.12336868f, 0.05401620f, -0.02832621f, -0.06841651f, 
    0.10710060f, -0.02113063f, -0.02682977f, 0.11431724f, 0.16241275f, 0.19402368f, -0.49397629f, 0.06577147f, 
    0.02827145f, -0.08930982f, 0.08488628f, -0.06784074f, -0.03751669f, 0.03100806f, -0.05319856f, 0.11381686f, 
    -0.34366554f, -0.16469805f, 0.16320863f, -0.46079302f, -0.09418082f, -0.22169435f, 0.22050133f, -0.02130643f, 
    -0.05853518f, 0.13466239f, -0.03316271f, 0.10941249f, 0.31221387f, 0.05733886f, 0.02603755f, 0.25663877f, 
    0.05400017f, -0.08324689f, -0.09615024f, -0.09607564f, -0.15171538f, 0.11005816f, -0.08895583f, -0.03192919f, 
    0.21704599f, -0.01811191f, 0.19995339f, 0.11096860f, -0.01901645f, -0.10437587f, -0.07401656f, 0.00074671f, 
    -0.01245707f, -0.00681714f, 0.05310971f, -0.05369374f, 0.08437376f, -0.22179633f, -0.00028135f, 0.04661994f, 
    -0.02881611f, -0.13295972f, -0.09917486f, -0.00572047f, 0.05157402f, -0.04642159f, 0.14584778f, -0.06326303f, 
    -0.08712171f, 0.01335160f, -0.04437358f, 0.22750685f, 0.17467777f, 0.17291737f, -0.13196187f, -0.06211425f, 
    -0.08201820f, -0.04959393f, 0.10937615f, 0.05030987f, -0.14410630f, -0.27997643f, -0.32523301f, -0.11739676f, 
    0.09961727f, -0.07626457f, -0.05051278f, 0.01777961f, 0.12258621f, 0.16034353f, 0.07441185f, 0.02708166f, 
    0.24524175f, 0.00776086f, -0.01510234f, 0.16392671f, 0.04935286f, 0.00434347f, -0.12667516f, -0.06842298f, 
    -0.01803103f, -0.02560918f, 0.05433571f, -0.01415612f, -0.17828971f, -0.09431520f, -0.25819609f, -0.18560143f, 
    0.04294077f, -0.11800849f, -0.21874382f, -0.14323005f, 0.07973971f, -0.01910804f, 0.16115692f, -0.10490189f, 
    0.21301399f, 0.31174719f, -0.25143906f, -0.01284648f, -0.02512620f, 0.06408156f, -0.14628406f, -0.18685557f, 
    0.17197019f, 0.13849069f, 0.07493190f, 0.03934662f, -0.18796074f, -0.16541199f, 0.15356079f, 0.10427037f, 
    -0.14281426f, -0.02447288f, -0.07922121f, -0.13746575f, -0.00401878f, -0.19315954f, 0.04171529f, -0.03601753f, 
    0.22487827f, -0.00087981f, -0.06128510f, 0.06858648f, -0.15256347f, -0.16125041f, -0.15313917f, -0.02858094f, 
    0.05184655f, -0.05529388f, 0.03256166f, -0.09904955f, 0.01680650f, -0.37065151f, -0.16902782f, -0.43562949f, 
    -0.06070256f, -0.15938367f, 0.06691504f, -0.12414552f, 0.13729323f, 0.06900264f, 0.03116184f, 0.05898559f, 
    -0.05003965f, 0.00362044f, -0.06077344f, -0.06917804f, -0.05407972f, -0.00453197f, -0.06309798f, -0.18038297f, 
    0.05566175f, -0.03998365f, 0.02279779f, -0.02882556f, -0.24179219f, -0.04768760f, 0.09657318f, -0.05735636f, 
    -0.06051988f, -0.11832985f, 0.06236690f, -0.22387418f, 0.08660024f, 0.01841580f, -0.33699036f, -0.01983337f, 
    0.39161211f, -0.01052594f, -0.18321247f, 0.19870801f, 0.08295687f, -0.08939130f, -0.04212898f, 0.00180014f, 
    -0.18118249f, 0.04096264f, -0.24644738f, 0.15073749f, 0.23294252f, 0.19604339f, -0.25362024f, -0.13742711f, 
    -0.00470618f, 0.09796446f, -0.17428553f, 0.03748785f, 0.04710201f, 0.04261023f, -0.22629979f, 0.05415239f, 
    -0.11210233f, 0.14036450f, 0.12830521f, -0.21168351f, 0.21456242f, -0.01945529f, -0.07215159f, -0.01277355f, 
    -0.01437223f, 0.01360568f, 0.14479430f, 0.10209690f, -0.19907507f, -0.02116477f, 0.26134527f, 0.09900259f, 
    -0.02811073f, 0.05471750f, -0.27617723f, 0.07150333f, 0.16655193f, -0.11202208f, -0.20301573f, -0.15218738f, 
    -0.11880018f, 0.19846994f, 0.04410055f, -0.14396465f, -0.17137480f, -0.01262422f, 0.02279227f, -0.07473318f, 
    0.03689084f, -0.00266248f, -0.01312457f, 0.02753769f, 0.00052829f, -0.12387089f, 0.11968898f, 0.38968194f, 
    0.18855001f, 0.03718392f, -0.07075020f, -0.15148468f, -0.02591311f, -0.04280982f, 0.06446179f, 0.13722986f, 
    0.05995117f, -0.20031348f, 0.05640061f, -0.01010024f, 0.09896593f, -0.04601102f, 0.10053752f, -0.00223845f, 
    0.13220842f, 0.15351166f, 0.11460204f, -0.00140747f, -0.02798615f, 0.34042850f, -0.17241096f, 0.05354318f, 
    0.12783013f, 0.03846140f, 0.06277026f, -0.05504797f, -0.00819234f, -0.04847421f, -0.04949760f, 0.20606782f, 
    0.21909195f, -0.40148962f, -0.31218237f, -0.04072223f, 0.08812384f, -0.01280415f, 0.12455207f, -0.01042515f, 
    0.07234344f, -0.00734701f, 0.12613431f, 0.14375241f, -0.67439276f, -0.08360904f, 0.38351026f, 0.01370037f, 
    0.13588972f, -0.16164835f, -0.03306710f, 0.24553995f, 0.00917404f, 0.06680510f, 0.10157100f, 0.16700603f, 
    0.13508278f, -0.21900511f, 0.07119069f, -0.18892740f, 0.04984511f, 0.12894630f, 0.13940205f, 0.10865400f, 
    -0.04706325f, -0.11319008f, 0.08857293f, -0.05525222f, -0.04731036f, -0.11199458f, 0.24758042f, -0.13176981f, 
    -0.12101028f, 0.15170848f, -0.02590529f, -0.23035690f, -0.12317218f, 0.06265415f, -0.11870445f, -0.27648920f, 
    -0.03886266f, -0.20763132f, -0.06581117f, 0.32023212f, -0.06505323f, -0.01963671f, -0.05103547f, 0.08599618f, 
    -0.15831536f, 0.09196475f, 0.07228824f, 0.03234499f, -0.02213231f, -0.35045773f, -0.04488894f, -0.00089312f, 
    0.06229188f, -0.09992908f, -0.07238586f, 0.17271239f, -0.15351202f, 0.07703304f, 0.08748617f, 0.05262133f, 
    -0.30478272f, -0.29616976f, -0.05690727f, -0.30802161f, -0.07033365f, 0.07829212f, -0.14521180f, -0.04980002f, 
    -0.02865555f, -0.07972582f, 0.19220942f, 0.15857264f, -0.24868703f, -0.04043338f, -0.10022162f, -0.30551273f, 
    -0.09199528f, 0.12980789f, 0.16196881f, -0.05865308f, 0.22740501f, 0.03592722f, 0.21586670f, 0.13122590f, 
    0.35048380f, -0.18216279f, -0.10778677f, 0.00923517f, 0.13461500f, 0.02760808f, -0.11059778f, 0.19639046f, 
    -0.18320444f, -0.17101595f, 0.03898761f, 0.16467778f, -0.08457275f, -0.02596440f, 0.15130663f, -0.23975529f, 
    0.03588561f, -0.05992737f, -0.04514503f, -0.06834828f, -0.11121913f, -0.00823409f, 0.02957154f, -0.00013788f, 
    0.31582201f, 0.33497593f, -0.32130390f, -0.09602454f, 0.09588034f, -0.02081154f, -0.03217006f, 0.00572028f, 
    -0.15267850f, 0.06378511f, 0.04351797f, -0.03183446f, 0.01271373f, -0.03736071f, -0.12566212f, 0.11857916f, 
    0.19431877f, -0.00335199f, -0.10082893f, -0.02927341f, -0.00435352f, 0.00010459f, 0.05484624f, -0.14792852f, 
    -0.63274020f, 0.46590918f, 0.10306988f, -0.28714079f, 0.02043215f, 0.03572042f, 0.12624781f, -0.11239881f, 
    0.09024370f, 0.09554144f, 0.13009425f, 0.04721398f, -0.27892134f, -0.10649785f, -0.00223981f, -0.25770089f, 
    -0.06973287f, -0.11594016f, -0.03965831f, 0.04218511f, 0.08364877f, -0.00500656f, 0.12434182f, 0.08292399f, 
    -0.34255850f, 0.34704107f, 0.18677998f, -0.07346144f, -0.01536993f, -0.11462007f, -0.16725886f, -0.09528263f, 
    -0.24995849f, 0.14143901f, -0.11203355f, -0.09611794f, -0.25646949f, 0.16843103f, -0.05366738f, -0.56673670f, 
    0.17405345f, 0.05569604f, -0.03411819f, -0.00132511f, 0.12824555f, -0.02964750f, -0.05406424f, -0.13285877f, 
    0.12062601f, -0.18103945f, 0.09059422f, -0.28885904f, 0.15462357f, -0.00377654f, 0.05996338f, 0.10991651f, 
    0.18647018f, 0.10649025f, 0.02716922f, 0.11199136f, 0.56124562f, -0.27021390f, -0.31435502f, -0.28194019f, 
    -0.13113925f, 0.04814022f, 0.08718240f, 0.12189277f, -0.08992090f, 0.07790247f, -0.29328406f, -0.04831645f, 
    0.65537560f, 0.15668832f, 0.00705723f, -0.02968339f, -0.07239275f, 0.16325979f, 0.09404096f, -0.08598240f, 
    -0.12941583f, -0.00331595f, 0.03640041f, -0.02610429f, -0.15032034f, -0.16413410f, 0.13301513f, 0.13920642f, 
    0.21524477f, 0.02665428f, -0.00484747f, 0.10386530f, -0.09677050f, 0.16970117f, -0.11621033f, 0.01212008f, 
    -0.12582244f, 0.68793339f, -0.33232120f, 0.05892512f, 0.16458635f, -0.06691376f, -0.04443591f, -0.05834756f, 
    0.16136867f, 0.03705172f, -0.01178109f, -0.10879914f, 0.05888014f, 0.03705636f, -0.00016378f, 0.00693265f, 
    0.04568161f, 0.11504201f, -0.04875432f, -0.01274920f, -0.09074897f, -0.09180443f, 0.08141299f, 0.12851624f, 
    -0.32259014f, -0.45870104f, 0.17307946f, 0.02527171f, 0.02108005f, 0.07898474f, -0.05526427f, 0.14047660f, 
    -0.13144553f, -0.08801554f, 0.06210289f, 0.04618236f, 0.00482913f, -0.16373110f, -0.00935271f, 0.09845192f, 
    -0.07479674f, 0.00314882f, 0.01216666f, -0.08762332f, -0.02390137f, 0.07338633f, 0.06189868f, 0.02377688f, 
    0.33912036f, -0.12843871f, 0.21492425f, -0.06599831f, 0.00322965f, 0.06870742f, 0.05438398f, -0.09107812f, 
    0.08691829f, 0.05859466f, -0.04751474f, 0.08124574f, 0.45822233f, -0.02636445f, 0.34405202f, 0.08251305f, 
    0.01261734f, 0.10087539f, 0.05722287f, -0.09384258f, -0.10316563f, -0.11797199f, 0.02786750f, -0.09943992f, 
    -0.08143312f, -0.34458068f, 0.07020951f, 0.26770622f, -0.12064850f, -0.00095717f, -0.03728097f, 0.03002366f, 
    0.05405370f, 0.08602076f, -0.09678626f, -0.16955613f, 0.15871389f, -0.64956415f, -0.05629296f, 0.01083409f, 
    -0.12451001f, 0.07876020f, 0.07535005f, 0.03184681f, -0.11667077f, 0.15619263f, 0.02174826f, -0.04749195f, 
    -0.26923200f, 0.67221171f, -0.04716413f, 0.43551031f, 0.23872496f, 0.11060142f, -0.15516943f, 0.09630357f, 
    -0.00943845f, 0.03473652f, 0.06295370f, -0.01896878f, -0.32555914f, 0.20287181f, -0.30159941f, -0.41224921f, 
    0.19573857f, -0.06581094f, -0.05293059f, 0.03639655f, -0.11576501f, -0.10461288f, -0.12857249f, -0.17410514f, 
    -0.08851922f, 0.12191818f, -0.00741630f, -0.47102869f, 0.04200653f, -0.00501127f, 0.01449698f, -0.16619189f, 
    -0.14105429f, -0.03419092f, -0.10663084f, -0.21585102f, -0.02954530f, 0.21411771f, 0.16978627f, -0.03925515f, 
    -0.17960417f, -0.00604960f, -0.12612124f, 0.06253991f, -0.10880520f, 0.05708518f, 0.02618065f, 0.05414684f, 
    0.09203783f, 0.09439398f, 0.07422379f, -0.08667082f, 0.19209643f, 0.11992757f, 0.01005458f, 0.12392885f, 
    0.05388270f, 0.08435469f, 0.01237025f, 0.01748949f, 0.34736285f, -0.09933849f, 0.08147755f, -0.09111147f, 
    -0.13855191f, -0.07866237f, 0.01350143f, 0.02588843f, 0.14102747f, 0.09919691f, -0.04148221f, -0.18412602f, 
    0.23120515f, 0.01181799f, -0.02616774f, 0.02625902f, -0.12664869f, -0.06234059f, 0.03408138f, -0.02151369f, 
    -0.12983236f, 0.02703404f, -0.09057856f, 0.08946063f, -0.42907348f, 0.13600740f, -0.08386026f, -0.13223732f, 
    0.10656636f, -0.10130910f, -0.02736435f, 0.03761277f, -0.02776470f, 0.13147496f, 0.09651186f, 0.21075180f, 
    0.21751478f, -0.12139720f, -0.00458597f, 0.07470781f, 0.02413001f, 0.15805602f, -0.02066828f, 0.06295264f, 
    0.08347710f, 0.06756119f, -0.10253191f, 0.02153447f, 0.29685092f, 0.01838895f, -0.02261677f, -0.06571218f, 
    -0.16362789f, -0.04799824f, 0.08227354f, -0.05576454f, -0.06145667f, 0.00780895f, 0.02215758f, -0.03894180f, 
    -0.58404934f, 0.17436762f, 0.06358712f, -0.36123797f, 0.24003173f, 0.09212673f, 0.03044058f, 0.09752521f, 
    0.08253863f, -0.16500108f, -0.16257840f, -0.13373430f, -0.03434205f, 0.19619273f, 0.04695497f, -0.04887909f, 
    -0.03101654f, -0.30120856f, -0.13801602f, 0.06214662f, -0.08857503f, -0.24952881f, -0.38391280f, 0.02967381f, 
    -0.20804058f, -0.43655953f, 0.14177451f, -0.06322261f, -0.05802113f, 0.10410565f, 0.11401093f, -0.04745429f, 
    0.17233990f, -0.04440786f, 0.04403273f, -0.03371374f, -0.14531861f, 0.01262193f, -0.09919177f, -0.13071468f, 
    -0.02031230f, 0.04628771f, -0.11463030f, 0.03681644f, 0.23202185f, -0.10969301f, 0.06629352f, -0.04845508f, 
    0.08998319f, 0.01046662f, -0.00577091f, 0.38721418f, 0.06448418f, -0.05971601f, 0.05938315f, -0.07382428f, 
    -0.01373202f, 0.09886730f, 0.06150868f, 0.17019106f, -0.03622280f, -0.17120458f, -0.11830860f, -0.22243163f, 
    -0.00575974f, -0.06930527f, -0.05623258f, 0.03228903f, -0.10210435f, 0.06260975f, -0.20350580f, 0.14061023f, 
    -0.75171536f, -0.60336614f, 0.08285266f, -0.01323109f, 0.10910492f, 0.02015965f, -0.02065147f, 0.00657272f, 
    0.19086508f, -0.01937717f, -0.05109328f, 0.17395003f, -0.19384061f, 0.08501047f, -0.20492089f, -0.10188375f, 
    0.10544681f, -0.03995621f, -0.03238478f, -0.13396193f, 0.05006196f, -0.12758349f, 0.05491005f, 0.00852323f, 
    -0.86654925f, -0.51374424f, 0.02686421f, 0.02887942f, 0.10507509f, 0.07673293f, 0.04675444f, -0.07262307f, 
    0.05483869f, -0.00480410f, 0.06135368f, 0.14586221f, 0.16897200f, 0.01505616f, 0.10808486f, -0.18908681f, 
    0.05685019f, -0.04327710f, -0.00295465f, 0.03040166f, -0.02635141f, 0.09622317f, 0.00567980f, 0.03210564f, 
    -0.17015906f, -0.10723748f, -0.04354011f, 0.04505781f, 0.01090768f, 0.09500396f, -0.01893812f, -0.09660874f, 
    0.07786622f, 0.27486876f, -0.02789562f, 0.03504131f, 0.22327584f, 0.16656563f, -0.38104853f, -0.00682493f, 
    0.16768192f, 0.02840477f, 0.04102119f, -0.13024282f, 0.04752698f, 0.18328591f, 0.13342462f, 0.00073944f, 
    -0.60703629f, -0.40750822f, 0.11093359f, 0.25091070f, 0.13529001f, -0.06884739f, 0.08600067f, -0.03705473f, 
    0.01991557f, 0.03088713f, 0.06519601f, 0.08735450f, 0.43586427f, 0.20287587f, -0.14906548f, 0.20990820f, 
    -0.08865075f, -0.09972990f, 0.01064919f, 0.13848491f, -0.01230197f, -0.05131161f, 0.10549717f, -0.05077789f, 
    0.10496277f, 0.09074601f, -0.10628901f, -0.06244290f, -0.07326407f, -0.19042355f, 0.05726010f, 0.09524768f, 
    0.07172544f, -0.01476789f, 0.00633387f, 0.03108902f, -0.05768446f, 0.20256208f, -0.02342485f, 0.22095624f, 
    0.15450582f, 0.04360511f, 0.21239172f, 0.10442526f, 0.03882064f, 0.12370094f, 0.00251233f, 0.08993505f, 
    0.02896117f, -0.02459951f, -0.03935947f, -0.08692924f, -0.10062284f, 0.17005344f, -0.00519240f, -0.01787533f, 
    -0.06250621f, 0.05301123f, 0.02214872f, -0.06899662f, 0.19101186f, -0.17258863f, -0.20539320f, 0.07645950f, 
    -0.02240053f, -0.17179379f, -0.02723812f, -0.01208308f, -0.02514335f, -0.02359898f, -0.09925367f, -0.02802480f, 
    -0.17939736f, -0.06932570f, -0.39527944f, -0.16487052f, -0.04743963f, -0.00450677f, -0.08251790f, -0.09560489f, 
    -0.05043164f, -0.10259208f, -0.34849814f, -0.16756319f, -0.49741057f, -0.02161175f, 0.08556394f, 0.11714205f, 
    0.15382883f, -0.00961608f, -0.10186392f, -0.06726761f, 0.07328925f, 0.04835542f, -0.04575612f, 0.18722105f, 
    0.23483674f, 0.00434932f, 0.08214872f, -0.15562159f, -0.01964874f, 0.07469822f, 0.09382491f, 0.13441111f, 
    0.04049008f, -0.02081369f, 0.01670309f, -0.02967004f, 0.15310626f, 0.12985466f, -0.08730674f, -0.00138817f, 
    -0.15049087f, -0.12902132f, 0.04219050f, 0.09328721f, 0.09801203f, -0.17536199f, -0.03517275f, -0.14877868f, 
    -0.18500669f, -0.06203726f, -0.01968896f, 0.11617617f, -0.00125587f, -0.02859535f, 0.12911215f, -0.12513095f, 
    0.14796792f, -0.03076679f, 0.05917612f, -0.01435313f, -0.78519112f, -0.63616747f, -0.33962443f, -0.62911779f, 
    0.02590658f, -0.01649678f, -0.03982377f, 0.03243699f, 0.09752175f, 0.09711247f, 0.01056216f, -0.00638303f, 
    -0.42229283f, -0.17206511f, 0.03596878f, -0.06945972f, -0.05522622f, -0.12667006f, 0.10341810f, 0.02178514f, 
    -0.06325769f, 0.22027297f, 0.15594661f, 0.16252936f, -0.43146014f, -0.21625383f, -0.00107177f, 0.14352334f, 
    0.10168333f, 0.10559279f, 0.10858213f, -0.02833299f, 0.27008390f, 0.24150047f, -0.02842369f, 0.03063406f, 
    0.25864291f, -0.02084400f, -0.04691264f, -0.08023617f, -0.32083821f, 0.14842603f, 0.04461088f, -0.11527861f, 
    -0.06343690f, -0.12139973f, -0.06871144f, -0.19010602f, -0.13347857f, -0.25305852f, 0.10278235f, 0.18314649f, 
    0.09879545f, 0.01714476f, -0.08794907f, -0.12880716f, -0.00204916f, -0.04034332f, 0.18424059f, -0.12672216f, 
    0.12757127f, -0.08449728f, 0.05321719f, 0.02111344f, -0.09384177f, -0.06357589f, 0.14871579f, -0.12413115f, 
    0.01524156f, -0.07769882f, -0.06427742f, -0.15164511f, 0.36513978f, 0.28054705f, -0.16649261f, -0.21741420f, 
    0.00075254f, 0.07415213f, 0.05118806f, 0.11246163f, 0.08079781f, -0.07320137f, -0.22739743f, -0.07746232f, 
    -0.24897043f, 0.18434159f, 0.06987268f, -0.25346932f, 0.09930747f, -0.14110380f, 0.07246463f, 0.08254322f, 
    0.07914221f, 0.09826656f, 0.05042409f, -0.10980583f, 0.04697172f, 0.03441092f, -0.01036555f, 0.08728544f, 
    0.08776536f, -0.05214950f, 0.04551584f, -0.02947596f, -0.13398926f, 0.06820676f, 0.06051568f, -0.17354019f, 
    0.09019002f, -0.04056000f, 0.04174167f, 0.13944867f, -0.17707659f, -0.01630328f, -0.09567914f, 0.03548279f, 
    0.14878699f, 0.09155062f, 0.12977378f, 0.13151984f, 0.28546375f, -0.12428444f, -0.20471768f, -0.13727535f, 
    -0.03525190f, -0.13760619f, 0.08260629f, 0.01729911f, -0.00535674f, -0.07768215f, 0.10235073f, 0.10864665f, 
    -0.68654412f, 0.28399882f, -0.31205714f, -0.24023554f, -0.01576330f, -0.14736535f, -0.05487266f, 0.26597357f, 
    -0.01288095f, 0.02163319f, -0.03141441f, -0.10020863f, 0.54223156f, -0.31939712f, -0.29257771f, 0.40016776f, 
    -0.18031015f, -0.00404790f, 0.03602225f, 0.12197216f, 0.12998682f, 0.10250837f, 0.06509986f, 0.00388199f, 
    -0.25855336f, -0.04936306f, 0.11085810f, 0.20420365f, -0.23117694f, -0.00285377f, -0.22042461f, -0.09399133f, 
    0.10441117f, -0.08889670f, 0.08636179f, -0.08674657f, -0.32959038f, -0.02884482f, -0.35796010f, -0.00889101f, 
    0.08107480f, 0.06405582f, 0.09301787f, 0.05901423f, 0.15777232f, 0.03643048f, -0.05358353f, 0.00803885f, 
    -0.11172260f, -0.10858325f, 0.09867573f, -0.22585830f, 0.05283410f, 0.09662087f, -0.01437487f, 0.00360458f, 
    0.03445731f, 0.12386157f, 0.11961628f, -0.01450751f, -0.35071716f, -0.36284438f, -0.04346551f, -0.09297913f, 
    -0.01584685f, 0.13304304f, -0.15526745f, 0.10057819f, -0.16059649f, 0.04512947f, -0.14810310f, 0.06892763f, 
    0.48682079f, 0.18848212f, -0.29454255f, -0.04785826f, 0.13669364f, -0.05619410f, 0.13651422f, 0.07076899f, 
    -0.08308700f, 0.01758159f, -0.07401514f, -0.11778449f, 0.30575502f, -0.36897978f, -0.15648058f, 0.26315039f, 
    0.01584853f, -0.10042325f, 0.11861786f, -0.06543694f, 0.16625746f, -0.05676662f, 0.11082755f, -0.00288103f, 
    -0.31621441f, -0.34519801f, -0.17734605f, 0.03300663f, 0.02882635f, 0.06117146f, 0.00123982f, 0.25507727f, 
    0.07905826f, -0.04436038f, -0.07545298f, 0.03115027f, -0.30117932f, -0.00837250f, 0.00027354f, 0.25893146f, 
    0.03845527f, 0.01825784f, 0.05676170f, 0.08133712f, -0.02541320f, -0.23088619f, 0.08833882f, -0.09631679f, 
    0.24000527f, -0.21308260f, 0.02173655f, -0.11656120f, 0.09367613f, -0.22314964f, -0.06481667f, -0.02958564f, 
    -0.00315444f, 0.03706524f, 0.05230055f, 0.12231652f, 0.23932679f, -0.17020024f, 0.11978040f, 0.13610750f, 
    0.07598277f, -0.01417611f, 0.20610668f, 0.15686452f, -0.01512715f, -0.10007164f, -0.12036721f, 0.04731118f, 
    0.30089921f, -0.13544881f, 0.22679406f, 0.35016304f, -0.04551388f, 0.11118540f, 0.08510017f, -0.17795034f, 
    0.00381953f, 0.00617025f, 0.06103037f, 0.13993751f, 0.12902756f, -0.09065486f, 0.08332549f, 0.23298636f, 
    -0.25889015f, 0.08858740f, -0.07290912f, -0.07373944f, 0.12862083f, -0.06780781f, -0.04006416f, -0.09474588f, 
    -0.05463985f, 0.10709778f, -0.00439270f, 0.12752922f, -0.20048276f, -0.07163718f, -0.16044913f, -0.02936461f, 
    -0.08988959f, 0.06091546f, -0.01379786f, -0.05720535f, -0.35465109f, 0.31786266f, -0.10895741f, 0.01266893f, 
    0.01611051f, -0.13187298f, -0.07106105f, -0.06292813f, 0.00537100f, 0.03596538f, 0.09458423f, -0.13356645f, 
    -0.03022362f, 0.11116519f, 0.01143599f, -0.08045593f, 0.09334496f, 0.11587787f, -0.03842363f, 0.03740061f, 
    -0.07927397f, 0.02214670f, 0.18695055f, -0.05726823f, 0.39550945f, 0.21054950f, 0.05283062f, -0.12781915f, 
    -0.10271119f, 0.09119627f, -0.11602062f, -0.02444225f, 0.14053397f, -0.11237154f, 0.16115397f, 0.01218641f, 
    -0.06883161f, -0.00564909f, 0.10306179f, -0.06491871f, -0.00053141f, 0.09628700f, 0.01979701f, -0.32452926f, 
    -0.01053981f, -0.00031423f, 0.02990167f, 0.01465832f, -0.29892373f, 0.25863409f, -0.24649766f, -0.01707825f, 
    -0.16369539f, -0.08489871f, -0.07637276f, -0.10533568f, 0.18758319f, 0.11171880f, 0.03338708f, -0.13036102f, 
    0.08338650f, -0.14401585f, -0.46745181f, 0.13067317f, -0.05696716f, -0.05960126f, -0.00529594f, -0.14813063f, 
    -0.06200260f, 0.03162278f, -0.04692635f, 0.04961482f, 0.16986233f, -0.42952976f, -0.33795801f, -0.10824233f, 
    0.05949641f, -0.13841863f, -0.15239455f, -0.12822172f, -0.03068038f, 0.05392384f, -0.10772280f, -0.09009898f, 
    0.10951024f, 0.16827308f, -0.08097093f, -0.18830390f, 0.17261370f, -0.02063493f, -0.12857790f, 0.08393354f, 
    0.11383092f, -0.21483713f, -0.00463592f, 0.10473035f, 0.34109870f, -0.14294210f, -0.10942458f, 0.43738186f, 
    0.04103133f, -0.06652048f, -0.02695556f, 0.01264729f, -0.15576875f, 0.13193709f, -0.01776090f, -0.14658874f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.07795262f, 0.05298629f, -0.09100349f, -0.02508937f, 0.02421543f, 0.02967342f, -0.01619896f, -0.08239045f, 
    -0.04508697f, -0.03098680f, 0.13782109f, 0.06036931f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
