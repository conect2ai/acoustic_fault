#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.62694287f, -1.00721312f, -0.68449348f, 0.85796386f, -0.21237111f, 0.52735811f, 0.28976366f, -0.12696946f, 
    0.06666525f, 0.13010535f, 0.64131480f, 0.57898825f, -0.81829250f, -0.82467461f, -0.30675966f, 0.26856542f, 
    -0.07594036f, 0.56491262f, -0.13078649f, -0.53721654f, -0.50497526f, -0.57838064f, -0.51298505f, -0.80388206f, 
    0.60175943f, 0.28479567f, 0.15608180f, -0.33935305f, -0.28908333f, 0.73816186f, -0.45063058f, 0.10036174f, 
    0.24084492f, -0.32412499f, -0.31541964f, 0.69483536f, 0.38889527f, 0.48013911f, -0.79119194f, -0.49082357f, 
    -0.22311188f, -0.48251632f, -0.35202253f, -0.50586063f, -0.59285438f, 0.25088766f, 1.08106422f, -0.58445954f, 
    -0.12192499f, 0.02775512f, 0.10257863f, -0.45079613f, 0.19932196f, 0.16934925f, -0.67607611f, 0.31841242f, 
    -0.61418557f, -0.10594329f, 0.63727683f, 0.15968314f, 0.22804406f, -0.47000214f, -0.76991153f, -0.93842494f, 
    -0.74088311f, -0.29110777f, 0.89572996f, 0.47638026f, -0.49517414f, -0.05450903f, -0.53894377f, -0.43779966f, 
    -0.15209088f, 0.26943544f, 0.46528074f, 0.07890041f, -0.04754582f, -0.19409516f, -0.33523786f, 0.30286899f, 
    0.47047547f, 0.56861424f, 0.56292045f, 0.24255356f, 0.32203498f, 0.53443366f, 0.08281857f, -0.26073113f, 
    0.34077355f, 0.20851724f, 0.37922102f, 0.92309976f, 0.74123085f, -0.82403404f, -0.72586089f, -0.04261718f, 
    0.02261021f, 0.04183227f, -0.44207886f, -0.54009509f, -0.36421919f, -0.19141366f, -0.49902788f, -0.28379706f, 
    -0.56956625f, -0.08955188f, -0.54536742f, -0.50464427f, -0.31519219f, -0.83061105f, 0.80173576f, 0.46129662f, 
    -0.65104181f, 0.53873265f, -0.02379593f, 0.00301485f, -0.09038965f, -0.32562080f, -0.00345916f, 0.35751384f, 
    1.00246286f, -0.73988861f, -0.41222066f, 0.21916406f, 0.15725313f, 0.10895717f, 0.52942038f, 0.77046239f, 
    -0.68930113f, 0.24035972f, 0.04867282f, -0.42438143f, 0.36154151f, -0.57210672f, 0.51572788f, 0.39865100f, 
    -0.89716959f, -0.29658109f, -0.74288726f, -0.68490064f, -0.00603036f, 0.02657132f, -0.23415577f, -0.13594669f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.26811439f, 0.07200931f, -0.04668672f, 0.20432109f, -0.11449222f, 0.40971497f, 0.34534547f, -0.09013798f, 
    0.38334307f, 0.06043268f, 0.24379078f, -0.02299882f, 0.31632012f, 0.08479232f, 0.04580416f, 0.06446753f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.42034489f, 0.35949361f, 0.46086091f, 0.24477579f, 0.26833108f, 0.05819916f, -0.18289050f, -0.19636331f, 
    -0.14517638f, -0.11499189f, -0.14725755f, 0.05104099f, 0.05644727f, 0.10286728f, 0.05433160f, 0.11496206f, 
    0.07087807f, 0.03976471f, 0.09182979f, -0.01426014f, 0.23248348f, -0.17066205f, -0.04473407f, -0.23518667f, 
    0.22796749f, 0.02199719f, 0.18831491f, 0.14149396f, 0.04524777f, 0.02229290f, -0.01383112f, -0.01098525f, 
    -0.07546477f, 0.03425810f, 0.02515450f, -0.01544185f, -0.02228748f, 0.02665459f, 0.06699146f, -0.09032280f, 
    -0.22558576f, -0.24973735f, -0.20442493f, 0.10843683f, 0.02426304f, -0.01423397f, -0.05170313f, -0.11874042f, 
    0.13207360f, 0.06354998f, 0.00898493f, 0.06019664f, -0.00802027f, 0.02877317f, -0.03349649f, 0.01017591f, 
    0.01020798f, -0.05501974f, -0.02108053f, -0.13131618f, 0.04500886f, 0.07646487f, -0.20340559f, -0.18759347f, 
    0.07662619f, -0.01146191f, -0.03425977f, -0.14305328f, 0.02296435f, 0.04901283f, -0.07813823f, -0.01844294f, 
    -0.00569019f, 0.01252586f, 0.11623619f, -0.03502426f, 0.06219369f, -0.21974428f, 0.09391978f, -0.12001023f, 
    -0.08329319f, -0.30890912f, -0.25334111f, 0.31146961f, 0.30093497f, 0.01851513f, 0.15389475f, 0.07910026f, 
    0.12291807f, 0.05360465f, -0.01220638f, 0.00305829f, 0.05888210f, -0.03313160f, -0.06274842f, 0.20738700f, 
    0.10444601f, 0.11943454f, 0.03010705f, 0.30827597f, -0.14521013f, 0.17205711f, 0.44810694f, -0.21096838f, 
    0.17116965f, 0.05694858f, 0.06419529f, -0.08876015f, 0.13000257f, -0.07669359f, 0.00349511f, 0.10034968f, 
    -0.01773496f, 0.04506551f, -0.05883849f, 0.00667946f, 0.09372279f, 0.16001309f, -0.00980275f, 0.09349608f, 
    0.09610054f, -0.00753588f, -0.04119053f, 0.19292486f, 0.14678983f, 0.04324408f, 0.10738841f, 0.06958213f, 
    0.07260311f, 0.02636092f, 0.00641598f, 0.03037017f, 0.23791702f, -0.07803588f, -0.01422157f, 0.00426190f, 
    0.19995683f, -0.01528806f, 0.13301474f, 0.10097419f, -0.41944671f, 0.01592699f, 0.14410657f, 0.30362126f, 
    0.19185452f, 0.09119329f, 0.10453276f, -0.05338998f, -0.24446186f, -0.06268858f, -0.04466547f, 0.06564768f, 
    0.15970032f, 0.09187490f, 0.07489707f, 0.10682196f, 0.14673953f, 0.11082878f, 0.04873842f, 0.03300959f, 
    0.01321475f, -0.05795570f, 0.08858628f, -0.22424065f, 0.03778951f, 0.01109849f, 0.03911473f, 0.00944164f, 
    -0.05570650f, -0.01315481f, 0.01753049f, -0.09211196f, -0.16112165f, -0.00391461f, 0.15656708f, 0.03062199f, 
    -0.02352900f, -0.03449223f, -0.04648945f, -0.03423430f, -0.05904856f, -0.13178283f, 0.01728802f, -0.18506292f, 
    -0.03662986f, -0.06741174f, -0.02005176f, 0.01276125f, -0.02545179f, 0.04340252f, -0.15422513f, -0.03110674f, 
    -0.05789896f, -0.04750773f, -0.01877671f, 0.07306322f, -0.01915789f, -0.03189324f, -0.10071450f, -0.03142300f, 
    0.17070985f, -0.35130343f, 0.08052964f, -0.17478959f, 0.28410929f, -0.05290490f, 0.18782498f, 0.24653813f, 
    -0.01872899f, 0.12036186f, -0.00000262f, -0.01027966f, 0.00639976f, -0.02277257f, -0.00424787f, -0.13288352f, 
    0.00974976f, 0.00948744f, -0.04893699f, 0.10905820f, -0.19838187f, -0.13601753f, -0.30185482f, 0.16648887f, 
    0.07746027f, -0.07448310f, 0.07910575f, 0.01609749f, -0.02497375f, 0.04714080f, -0.01138912f, 0.05737249f, 
    -0.01420534f, 0.03095316f, -0.00083978f, 0.03098347f, 0.09446689f, 0.06189861f, -0.02772008f, 0.18932848f, 
    -0.11122775f, 0.27627984f, -0.14516665f, 0.32089081f, -0.17983931f, 0.12254266f, -0.14772077f, -0.04981919f, 
    -0.05844222f, -0.02703378f, -0.25861675f, 0.06869338f, 0.00171317f, -0.00449378f, 0.07354093f, 0.11308932f, 
    0.03325536f, -0.03118880f, 0.00738715f, 0.07181482f, -0.05531733f, -0.11991639f, -0.12264542f, 0.21127903f, 
    -0.08669698f, 0.04279582f, -0.00442034f, 0.01470076f, -0.08002871f, 0.04123821f, -0.12421741f, -0.06867331f, 
    -0.10330388f, 0.09046142f, -0.08887524f, -0.01923465f, -0.02834315f, -0.00639447f, -0.03065043f, -0.16745214f, 
    -0.04967068f, -0.17596714f, 0.09588663f, 0.02030629f, -0.10380306f, -0.01480997f, 0.02079326f, 0.07558106f, 
    -0.14108942f, 0.02203153f, 0.10262010f, 0.01366865f, -0.01582336f, -0.14758340f, -0.01768527f, 0.04129662f, 
    0.02717033f, 0.04005066f, -0.07573806f, 0.01285226f, -0.21578276f, -0.14876857f, -0.14795724f, 0.07618406f, 
    0.01251512f, -0.08789912f, 0.05302005f, -0.09747523f, 0.12070187f, -0.05621424f, 0.01863968f, 0.09852175f, 
    0.01805383f, 0.01922172f, 0.08211400f, 0.03552201f, 0.03390568f, 0.03487633f, -0.09796905f, 0.00178947f, 
    -0.16106109f, 0.24693274f, -0.08774482f, 0.10270459f, 0.17054839f, 0.02990220f, 0.01199371f, 0.09930123f, 
    0.00533525f, 0.11758541f, -0.06214076f, 0.06557609f, -0.11491121f, -0.00633858f, 0.06784696f, 0.12337038f, 
    -0.10141709f, -0.01713823f, 0.13181327f, -0.01444458f, -0.42194271f, -0.17258781f, 0.23928508f, -0.13143048f, 
    -0.44659701f, -0.04529322f, -0.12722188f, -0.02454984f, 0.01020503f, 0.21883076f, -0.02958795f, 0.07667406f, 
    0.04166634f, 0.20315786f, -0.03574481f, 0.11131080f, 0.19183557f, 0.02952777f, 0.01112247f, 0.28602907f, 
    0.08626229f, -0.11683500f, -0.34119233f, 0.04416347f, -0.10117780f, 0.14121827f, 0.04989253f, 0.07617930f, 
    0.16488805f, -0.02900283f, -0.23968339f, -0.09831155f, -0.01662938f, 0.07809095f, -0.01089722f, 0.12540278f, 
    0.13056774f, 0.20700289f, 0.10271426f, 0.37009439f, 0.37148598f, -0.03598113f, 0.34539610f, 0.01100474f, 
    0.11645508f, 0.05851864f, -0.02132493f, -0.03476473f, 0.21959391f, 0.09752028f, 0.15383674f, 0.14390339f, 
    0.06319974f, -0.01109100f, 0.02293491f, 0.22163913f, 0.18076542f, 0.04050267f, 0.19235688f, 0.35005587f, 
    0.13215013f, 0.00472001f, 0.17397524f, 0.12108964f, -0.08508343f, 0.07996690f, -0.10108671f, 0.12282071f, 
    -0.17178641f, 0.07491982f, 0.15221933f, -0.02556618f, -0.00245717f, 0.01188399f, -0.00267904f, -0.08352405f, 
    -0.09572900f, -0.14763969f, -0.21838869f, -0.18751624f, -0.06222674f, -0.14256941f, -0.03284896f, 0.04985016f, 
    -0.05879234f, -0.04966545f, 0.10188983f, 0.08780721f, -0.19525434f, -0.01511232f, 0.06009304f, -0.12256469f, 
    0.04217336f, 0.08172989f, 0.07967874f, -0.08631194f, -0.05421636f, -0.01503791f, 0.06940590f, 0.00090585f, 
    0.31837323f, 0.23121384f, 0.12301621f, 0.30944148f, 0.24562044f, -0.01441595f, 0.01771256f, 0.17039743f, 
    0.04546362f, -0.03860759f, 0.11970012f, -0.00116112f, 0.04905378f, 0.05575850f, -0.00395216f, 0.04918122f, 
    -0.08200154f, 0.15899836f, -0.15119174f, -0.19477640f, 0.05579435f, 0.33594382f, 0.19142614f, 0.07016080f, 
    0.22913517f, 0.09274866f, -0.08057862f, 0.07051093f, -0.02166227f, -0.03795474f, -0.02117142f, 0.04550359f, 
    -0.03437252f, -0.11809572f, 0.17120339f, 0.18201682f, -0.09550648f, 0.01015458f, -0.05670387f, -0.07859151f, 
    -0.18125474f, -0.14862721f, 0.02660204f, -0.03354088f, -0.20363896f, -0.10552409f, -0.09096923f, -0.16458942f, 
    0.00812864f, -0.00608519f, -0.01417974f, 0.05336643f, 0.04239440f, 0.04393930f, 0.15968029f, 0.06097297f, 
    0.24935989f, 0.11456206f, 0.12080131f, 0.15874116f, -0.41502675f, -0.29639718f, -0.11865443f, -0.29558316f, 
    -0.36109734f, -0.24310914f, -0.28978774f, -0.20093785f, -0.06049481f, -0.19711055f, -0.06150298f, -0.03550993f, 
    -0.13810131f, -0.05971528f, 0.02109107f, -0.01670322f, 0.05604063f, 0.08729427f, 0.03178711f, -0.01615386f, 
    -0.65202940f, -0.25443497f, 0.25931150f, -0.11642775f, -0.19087976f, -0.09772683f, -0.22044598f, -0.15712152f, 
    0.01625353f, 0.04459287f, -0.05950022f, 0.09477703f, -0.01232509f, 0.06438314f, 0.04199105f, -0.06338680f, 
    -0.15088493f, 0.11333487f, -0.07577655f, -0.04756212f, 0.00765661f, 0.04885735f, 0.12700383f, 0.01462360f, 
    0.03364627f, 0.07318106f, 0.01721047f, -0.09159705f, 0.14311661f, 0.06914880f, -0.02951069f, -0.02452043f, 
    -0.05197111f, -0.15182009f, -0.04323716f, 0.15355000f, -0.07093370f, -0.13913921f, -0.07628248f, -0.16072562f, 
    0.19800499f, 0.19811222f, 0.08348536f, 0.11704534f, 0.12269678f, 0.03971190f, 0.01899716f, 0.05894439f, 
    -0.00103305f, 0.11717924f, 0.01954709f, -0.04976659f, -0.06892190f, 0.13597232f, 0.20144671f, 0.10464560f, 
    -0.06836279f, 0.02382483f, 0.07909907f, -0.04703874f, -0.07512973f, -0.01641060f, -0.23990969f, 0.05736219f, 
    0.05525101f, 0.00224594f, 0.05360432f, 0.06583016f, 0.03005731f, -0.03294693f, -0.20431080f, 0.03607800f, 
    0.03950823f, 0.04694630f, 0.18163531f, 0.15902108f, 0.11704667f, -0.03870282f, 0.34103641f, 0.20147252f, 
    -0.20380311f, -0.33005598f, -0.20992799f, 0.14846192f, -0.00760814f, -0.13201918f, -0.17713438f, 0.20258567f, 
    -0.16770533f, -0.05014129f, 0.01045751f, -0.17830165f, -0.08004411f, 0.07318111f, 0.09003768f, -0.02344158f, 
    0.06747705f, 0.17285401f, 0.06954867f, 0.31976417f, 0.12817125f, 0.10529093f, -0.18756065f, 0.07406898f, 
    -0.13944164f, 0.01369751f, 0.00260975f, -0.05174581f, 0.13043766f, 0.18264881f, -0.01119536f, -0.04678705f, 
    -0.08764348f, 0.01962682f, 0.00517842f, 0.09499317f, -0.09455927f, -0.06676675f, -0.03600047f, -0.03520253f, 
    0.32457730f, 0.23646946f, 0.37882262f, 0.37653276f, 0.20749742f, 0.13895659f, 0.15342419f, -0.03395601f, 
    -0.05307050f, 0.04202236f, -0.14591716f, 0.20249338f, -0.19970435f, -0.04996577f, 0.04939514f, 0.06997740f, 
    -0.03847953f, 0.00587708f, -0.00189179f, -0.00955537f, -0.36283597f, 0.00391855f, 0.22382762f, 0.36583510f, 
    0.14427848f, 0.05642569f, 0.27585825f, 0.02422310f, 0.12923458f, 0.29925790f, 0.04618135f, -0.01402226f, 
    0.04693647f, -0.04603909f, 0.09329759f, 0.05379840f, -0.07173273f, -0.01944296f, 0.04768229f, -0.04667129f, 
    0.22100110f, 0.38296190f, 0.27794781f, 0.13469769f, 0.27425441f, 0.13199610f, 0.17457448f, 0.09291441f, 
    0.06891730f, 0.17362219f, 0.11509362f, 0.16490158f, 0.00265364f, -0.03039503f, -0.00866789f, -0.04064058f, 
    -0.10599314f, -0.27112487f, 0.08595767f, 0.05314187f, -0.34650448f, -0.21639614f, 0.24380423f, -0.01792771f, 
    -0.16233844f, -0.12646945f, 0.04581930f, -0.14792432f, 0.00158333f, -0.11715121f, -0.04706852f, -0.05913636f, 
    -0.09904356f, 0.11982755f, 0.16761531f, -0.08993248f, -0.01879450f, 0.00716096f, 0.13647740f, 0.02906114f, 
    -0.05367876f, 0.30472228f, 0.05957109f, 0.20820051f, 0.13012001f, 0.10352487f, 0.20300335f, -0.02622500f, 
    0.15192220f, 0.12998469f, 0.01641608f, 0.14701867f, -0.07428040f, 0.04194880f, -0.14335813f, 0.09221957f, 
    0.08367734f, 0.13029572f, -0.10062169f, 0.26021996f, -0.03806650f, -0.12178312f, -0.44988847f, -0.18474761f, 
    -0.18460335f, -0.16930525f, 0.04236048f, 0.10438163f, -0.12216853f, 0.06286951f, 0.06625611f, -0.08365300f, 
    0.09972686f, -0.11958066f, -0.02785601f, 0.01724810f, 0.01245455f, 0.30132377f, 0.05981848f, -0.05899463f, 
    0.09485682f, 0.03337634f, -0.06601051f, 0.09593730f, 0.07096935f, 0.11459101f, -0.16756395f, 0.05317322f, 
    0.08120337f, 0.03071335f, -0.00380704f, -0.05070955f, -0.04052802f, 0.01289811f, -0.06739946f, -0.15305349f, 
    0.19277260f, 0.16174521f, -0.11352793f, 0.17849240f, 0.00791693f, 0.03210017f, -0.10462733f, 0.01480757f, 
    0.20404099f, 0.13830805f, 0.07375633f, 0.00720889f, -0.15276302f, 0.14492123f, -0.07168713f, 0.08187907f, 
    -0.02091329f, 0.03916623f, 0.11771008f, -0.12200953f, 0.16011329f, 0.09721988f, 0.00988545f, 0.07570399f, 
    -0.33595923f, -0.30796847f, -0.15274003f, -0.24924821f, -0.15115079f, 0.07074729f, -0.01613075f, 0.04032679f, 
    -0.06161084f, -0.01295951f, 0.05866106f, 0.03293837f, 0.09970721f, 0.08754824f, 0.16443820f, 0.07739630f, 
    -0.14998934f, -0.01392037f, -0.06796011f, -0.03560742f, -0.15783079f, -0.38913950f, -0.42366835f, -0.26587600f, 
    -0.14001590f, 0.08395438f, 0.10705664f, 0.09462985f, -0.04301075f, 0.02078107f, -0.01542789f, 0.02263994f, 
    0.20867099f, -0.00327010f, 0.19444089f, 0.00320257f, 0.06148258f, 0.18932636f, -0.00579191f, -0.09793604f, 
    -0.05913477f, -0.07232692f, -0.20179255f, 0.27515545f, 0.15495734f, -0.06310749f, 0.06571589f, -0.04794631f, 
    -0.12568294f, 0.07484210f, 0.00593931f, -0.06055776f, -0.03965105f, -0.08312308f, 0.06444791f, -0.03820268f, 
    -0.05174101f, 0.04538157f, -0.00496955f, 0.12271076f, -0.06957030f, 0.07273724f, 0.05577078f, 0.12327589f, 
    0.13507760f, -0.01346076f, 0.13349041f, 0.02865271f, -0.04553802f, 0.08181987f, -0.03971791f, 0.10469420f, 
    -0.01857822f, 0.05575320f, -0.02641139f, 0.17445584f, 0.03970949f, -0.21573780f, 0.02207726f, 0.04907838f, 
    -0.09564282f, 0.03563743f, 0.41546306f, 0.35524440f, -0.17372894f, 0.05981173f, -0.06982396f, 0.09672138f, 
    -0.14738999f, 0.00808635f, -0.14109597f, 0.05398819f, -0.05861147f, -0.01052384f, 0.04512752f, 0.15588436f, 
    -0.11131728f, 0.13737479f, 0.07007431f, 0.09167515f, -0.11174025f, 0.13430633f, -0.37447318f, 0.13365367f, 
    -0.16420127f, 0.17075919f, -0.12798382f, 0.08336154f, -0.30318218f, 0.03702483f, -0.13327605f, -0.07928995f, 
    -0.09883871f, 0.15225668f, -0.02605509f, 0.03678454f, -0.03135429f, -0.09523796f, 0.01007002f, -0.00411160f, 
    0.13082309f, -0.25439215f, -0.10303874f, 0.27086389f, -0.22938515f, -0.01993401f, 0.26961359f, 0.13426673f, 
    -0.27474421f, 0.05503900f, 0.02635480f, -0.08399592f, 0.09026261f, -0.00894150f, 0.18608727f, 0.07826668f, 
    0.27426055f, 0.06564833f, 0.12047822f, -0.04595111f, 0.07107597f, 0.02507203f, 0.18200141f, -0.05134581f, 
    0.14458717f, 0.02610044f, 0.12770589f, -0.08225642f, 0.13137771f, 0.11383168f, 0.03957939f, 0.05672759f, 
    -0.07406152f, 0.05044807f, -0.01181924f, -0.03473945f, 0.00832766f, -0.23492283f, 0.04347617f, 0.10573511f, 
    0.33350071f, 0.01154610f, -0.05557628f, 0.08466028f, -0.40663216f, -0.24881658f, -0.02381638f, -0.06517202f, 
    0.06801904f, -0.19404100f, 0.13507253f, 0.01562950f, 0.16528654f, 0.06720959f, 0.16168414f, 0.13618383f, 
    -0.01525221f, 0.07073215f, -0.01901029f, -0.06706021f, -0.47249106f, 0.45564839f, -0.20258161f, 0.17545868f, 
    -0.24144398f, 0.12728673f, -0.05260650f, -0.07304454f, -0.02314598f, 0.15152560f, -0.08785166f, -0.10193104f, 
    0.01045104f, 0.08646072f, -0.08833103f, 0.04458428f, -0.01308258f, -0.19342850f, -0.04607685f, 0.06962510f, 
    -0.17879207f, 0.04097001f, 0.33909327f, 0.33948985f, -0.05984061f, -0.05187273f, 0.07878821f, 0.07059184f, 
    0.09259337f, 0.24847174f, 0.05683511f, -0.11941649f, 0.06758168f, 0.00641629f, -0.03644634f, -0.02112245f, 
    0.08246636f, -0.09575552f, -0.30311689f, -0.08719065f, -0.12057368f, 0.39194974f, -0.25942802f, 0.37025952f, 
    0.06488294f, 0.19054061f, -0.02741999f, 0.14674413f, -0.11760040f, 0.01880477f, 0.08478043f, 0.15957503f, 
    0.08702911f, -0.12500171f, -0.09054491f, 0.10705563f, -0.02435978f, 0.21416362f, -0.06622209f, 0.16640186f, 
    0.01037900f, 0.17648856f, 0.09513014f, -0.19120692f, -0.13301858f, 0.12235950f, -0.09256303f, -0.02710120f, 
    -0.03762945f, 0.44067436f, 0.02130519f, 0.09540472f, -0.05259200f, -0.01691356f, -0.03535614f, -0.12381565f, 
    0.07291393f, -0.18898924f, 0.11458024f, -0.03122826f, 0.40027270f, -0.03592579f, -0.38859269f, 0.00953233f, 
    -0.03557427f, -0.07957677f, -0.07939997f, -0.08630544f, -0.12783386f, 0.06620196f, -0.02226809f, -0.03414577f, 
    0.03910453f, -0.01646148f, 0.04681363f, 0.04760455f, 0.04705293f, -0.07884381f, 0.11794087f, 0.19947100f, 
    -0.20541739f, 0.15239275f, 0.37404114f, -0.02018704f, -0.02940988f, 0.09636696f, 0.00214284f, 0.13287036f, 
    -0.20927450f, 0.09686872f, 0.04168694f, 0.06281537f, -0.21746713f, -0.01567988f, 0.14376082f, 0.26313496f, 
    -0.07400690f, -0.00517031f, 0.12513956f, 0.02216728f, 0.22350414f, -0.09949519f, 0.70636994f, 0.19892754f, 
    -0.07698867f, -0.08426857f, 0.04384867f, -0.15789586f, 0.16145918f, -0.27523321f, 0.23363736f, -0.04389381f, 
    -0.08863888f, -0.17637399f, -0.03421371f, 0.07841776f, -0.01546298f, -0.16774905f, -0.03290687f, -0.07649732f, 
    0.05224695f, 0.11807837f, -0.12027524f, 0.10683517f, 0.05393683f, 0.05439630f, -0.04242860f, -0.00107042f, 
    -0.06394544f, -0.09397335f, -0.02733684f, -0.00602237f, 0.11254482f, 0.02789932f, -0.09308252f, 0.07380692f, 
    -0.00107711f, 0.10896777f, 0.06955179f, 0.09843463f, 0.06774233f, -0.21575812f, -0.17489336f, 0.00300871f, 
    0.26432049f, -0.10220558f, -0.18863679f, -0.18638310f, -0.05878768f, -0.15221354f, 0.18472913f, 0.09339745f, 
    0.07752558f, -0.01734074f, -0.03875586f, 0.04068978f, 0.07748830f, 0.02399278f, 0.04392708f, -0.00435705f, 
    -0.17470837f, -0.07815093f, -0.07547242f, 0.28115579f, -0.18122955f, 0.04050845f, -0.13235889f, -0.16425960f, 
    0.21092181f, 0.14067970f, -0.03753382f, -0.05154612f, -0.13220252f, 0.02176494f, -0.06446835f, 0.00321246f, 
    0.07325516f, 0.04900778f, 0.17309774f, -0.03668856f, -0.10693564f, -0.01954597f, 0.40169844f, 0.31348425f, 
    -0.00208998f, 0.11037360f, -0.13842824f, 0.00041928f, 0.18141645f, 0.25917977f, 0.13563021f, -0.02349131f, 
    0.04398990f, -0.09892501f, 0.10380239f, -0.07312232f, 0.16751499f, 0.07706022f, -0.11162026f, 0.05325842f, 
    0.20661554f, -0.06373141f, -0.41957048f, -0.05791400f, 0.12091070f, -0.08578180f, 0.04781464f, -0.16187839f, 
    0.05524677f, -0.05158070f, 0.06625443f, -0.02451911f, -0.04786218f, 0.11299274f, 0.03612107f, 0.01172991f, 
    0.27170414f, 0.08115111f, 0.09030728f, 0.11373018f, 0.09801634f, 0.15095210f, -0.14431898f, -0.19087157f, 
    0.14596926f, 0.10498972f, -0.04628453f, -0.07832247f, 0.01979641f, -0.17808560f, 0.03597190f, -0.02388546f, 
    0.16071993f, -0.09842250f, 0.07008996f, 0.13539022f, -0.10003490f, 0.07501682f, 0.11753246f, -0.08564953f, 
    0.20964779f, 0.09713609f, -0.09812676f, -0.32596356f, 0.11712338f, -0.12638523f, -0.03303809f, -0.23017213f, 
    0.03439175f, -0.10284642f, -0.04899513f, -0.04534990f, 0.03170888f, 0.07686580f, 0.10354868f, 0.16077988f, 
    0.10367693f, -0.03369632f, 0.04405829f, 0.11061784f, -0.12783234f, 0.17428985f, 0.17652355f, 0.38378817f, 
    0.06279474f, 0.04528519f, -0.08746962f, 0.01609406f, -0.15650402f, 0.35486922f, -0.01227205f, 0.06149876f, 
    0.05136228f, 0.01147253f, -0.06907330f, 0.03778953f, 0.01643044f, -0.04118833f, -0.11187056f, 0.01514562f, 
    0.27646837f, 0.22586706f, 0.07320055f, -0.06376148f, 0.08996803f, 0.14406548f, 0.17659478f, 0.23640674f, 
    0.02875554f, -0.00898131f, 0.00067829f, 0.02927985f, 0.11082339f, 0.01484677f, 0.12008715f, 0.02066799f, 
    0.04990276f, 0.00983962f, -0.03141947f, -0.02840248f, 0.11500100f, 0.11035939f, 0.04776414f, -0.00522052f, 
    0.08415404f, -0.01272831f, 0.16725279f, -0.00718073f, 0.19176017f, 0.19185250f, 0.11300290f, 0.06045423f, 
    0.05619644f, 0.02041196f, 0.08694351f, -0.14474651f, -0.10228721f, -0.03510887f, 0.13074942f, 0.09083106f, 
    0.25537035f, 0.40258843f, 0.17649943f, -0.02832305f, 0.19169061f, 0.06031499f, 0.04069777f, -0.05368425f, 
    0.00041986f, 0.04265549f, 0.18009809f, 0.10328187f, 0.11536451f, 0.02728007f, -0.00139330f, -0.04710517f, 
    -0.06448003f, -0.01882366f, 0.03569348f, 0.00952584f, -0.27697682f, 0.25286469f, -0.02398189f, -0.06794178f, 
    0.26082435f, 0.07956639f, 0.22033484f, -0.01864119f, -0.08549032f, 0.02238466f, 0.07991773f, 0.08807516f, 
    -0.07668547f, -0.04687157f, -0.02692880f, -0.08294808f, -0.08114196f, -0.01208400f, -0.09226089f, -0.10740047f, 
    0.00309639f, 0.14302710f, 0.21478572f, -0.17252208f, -0.28366947f, -0.08059209f, -0.02907639f, 0.02437972f, 
    0.05054055f, 0.03211667f, -0.01313558f, 0.02984457f, 0.01984402f, 0.02083589f, -0.00196511f, -0.14672673f, 
    -0.03418049f, 0.09548263f, 0.10513016f, 0.07566363f, -0.33987924f, -0.59643608f, -0.48091343f, -0.07761977f, 
    -0.43279904f, 0.00537811f, -0.05139012f, -0.16193348f, -0.06248625f, 0.02427921f, 0.04029801f, 0.06962060f, 
    -0.07277284f, -0.00850755f, 0.06476552f, -0.10532341f, -0.00796261f, -0.12690486f, 0.02111801f, 0.00427562f, 
    0.06780814f, 0.01446986f, 0.06604888f, -0.07043925f, -0.01562834f, 0.16306271f, 0.07795792f, 0.08881655f, 
    0.07279173f, 0.12311523f, -0.03133047f, -0.07893334f, 0.11699428f, -0.00623000f, 0.11616906f, 0.04327298f, 
    -0.02875411f, -0.14817110f, -0.11334877f, 0.07750139f, 0.45834512f, 0.21039918f, 0.19065396f, -0.13378878f, 
    0.08348457f, 0.13878767f, 0.08164337f, 0.13508862f, 0.09388026f, 0.02272052f, -0.03341068f, 0.08051077f, 
    0.05356868f, -0.04569146f, 0.07624497f, -0.07180614f, 0.08220618f, 0.06439862f, -0.08087837f, -0.04077290f, 
    -0.15580469f, -0.07213847f, -0.28314051f, -0.06891508f, -0.12807178f, 0.10208338f, 0.07429433f, -0.01932333f, 
    -0.04454230f, 0.08035237f, 0.09837753f, 0.18528166f, -0.09393811f, -0.09353084f, -0.07592559f, -0.11849187f, 
    -0.02227454f, -0.04706519f, 0.07829901f, 0.01782252f, -0.13385545f, -0.28521389f, -0.46265265f, -0.13851351f, 
    -0.18573397f, 0.12749816f, 0.21930461f, 0.16591685f, -0.00209944f, 0.12551612f, 0.02149498f, 0.07019176f, 
    0.14507742f, -0.04301678f, 0.06412710f, 0.01954820f, 0.20813046f, -0.02478860f, -0.12044203f, 0.02641673f, 
    -0.23236378f, -0.31290746f, -0.17266467f, -0.14269714f, -0.10950381f, -0.09964557f, 0.12730579f, -0.12535337f, 
    0.06778424f, 0.03007414f, 0.14178203f, 0.03020941f, 0.11225253f, -0.02076361f, -0.02429872f, -0.07133983f, 
    0.02454592f, 0.00478741f, 0.11673884f, 0.05313311f, 0.25328645f, 0.20291932f, 0.27575469f, -0.07943556f, 
    0.09148195f, 0.08581156f, 0.02606703f, 0.00904796f, -0.08038509f, 0.00185251f, -0.02036505f, 0.01668091f, 
    0.00823902f, -0.02353687f, 0.03282594f, -0.17366776f, -0.06430893f, 0.10225847f, 0.05721311f, 0.07386075f, 
    -0.50715989f, -0.07330553f, 0.25424483f, -0.38911149f, 0.00382202f, -0.02205398f, 0.15064473f, 0.01815719f, 
    0.02989427f, 0.00891434f, 0.15785415f, 0.14933328f, -0.11359581f, 0.02392749f, -0.12519197f, -0.11035956f, 
    0.14874238f, -0.19185379f, -0.00597674f, -0.16321990f, -0.38647974f, 0.28809530f, -0.01912513f, -0.26708144f, 
    0.05386119f, 0.02621495f, 0.05571879f, 0.12050796f, 0.01008606f, -0.06292813f, -0.00970204f, -0.06728113f, 
    -0.08638991f, 0.10476872f, 0.03394506f, -0.18511954f, -0.16559599f, -0.07604620f, -0.05663069f, -0.14338483f, 
    -0.45947063f, -0.22122471f, -0.27195212f, -0.10928263f, -0.29852149f, -0.11321770f, -0.09809859f, -0.03456819f, 
    0.06506133f, 0.01099937f, 0.04249132f, 0.14334036f, 0.05761255f, 0.19932407f, 0.01830447f, -0.05207433f, 
    0.16019750f, -0.00230539f, 0.00491003f, -0.18170999f, 0.02787327f, 0.30452955f, 0.25372452f, -0.08334297f, 
    0.11493595f, -0.03598954f, -0.08556979f, -0.07766888f, -0.17501399f, -0.06929904f, -0.02747946f, -0.04855013f, 
    0.03590152f, -0.01845604f, -0.00075312f, 0.00049951f, -0.07104279f, -0.05061679f, 0.02912456f, -0.02072727f, 
    0.04473684f, 0.11927402f, -0.03731947f, 0.17911425f, -0.32776940f, -0.20570004f, 0.14197089f, 0.02359091f, 
    -0.21270725f, 0.13866822f, -0.02692943f, 0.05165505f, -0.10101392f, -0.17157267f, -0.06730272f, 0.02832528f, 
    -0.00276749f, -0.08351098f, 0.09489068f, 0.00909012f, -0.23904330f, -0.10050195f, 0.25155103f, 0.01102595f, 
    0.03995884f, 0.02453350f, 0.06068261f, -0.03730302f, 0.03009480f, 0.00483709f, -0.11072934f, -0.00806633f, 
    0.06546634f, 0.04366259f, 0.03912028f, 0.06422821f, 0.00748480f, -0.05486269f, 0.00184971f, -0.02265171f, 
    -0.02181864f, 0.40242139f, 0.13144276f, 0.21518403f, -0.04041177f, -0.09245863f, 0.04169097f, -0.05843352f, 
    -0.03651681f, 0.04172362f, 0.03848751f, 0.05900212f, 0.05275333f, 0.11577304f, 0.06507225f, -0.02622056f, 
    -0.02772817f, -0.08435232f, 0.02556759f, 0.19234431f, -0.49475068f, -0.29660937f, 0.52896827f, 0.13885930f, 
    0.24385121f, -0.05648410f, -0.07125159f, 0.08295131f, 0.17884368f, -0.05417684f, 0.00042714f, -0.06018522f, 
    0.03265525f, 0.10446715f, -0.01289298f, -0.08162894f, -0.00168689f, 0.17794180f, 0.02108509f, 0.04058113f, 
    0.01115179f, 0.45379525f, 0.20628791f, -0.01530693f, -0.34058154f, 0.08643641f, -0.02917823f, -0.03227656f, 
    -0.15720561f, -0.14129250f, 0.06143160f, 0.06684145f, 0.04867837f, 0.02829529f, 0.04470234f, -0.03277332f, 
    -0.20128497f, -0.06771784f, -0.12970971f, -0.08245911f, 0.37915054f, -0.24706179f, -0.44673085f, 0.16761056f, 
    0.00823010f, 0.05361608f, 0.03689773f, 0.03122561f, -0.09436180f, 0.05742716f, -0.07824808f, 0.01957879f, 
    0.01607726f, -0.00903317f, -0.10246352f, -0.03099791f, -0.01407751f, 0.03876405f, 0.03509908f, -0.00494806f, 
    -0.16821688f, 0.08876409f, 0.12893064f, -0.01207345f, -0.07188419f, -0.06290516f, -0.13008890f, 0.09937579f, 
    -0.07486440f, 0.00749309f, 0.11636516f, 0.06305401f, -0.21710695f, 0.06732863f, -0.00983690f, -0.01488808f, 
    -0.07172894f, 0.17018193f, -0.09766989f, -0.07053305f, 0.25578392f, -0.00883578f, 0.15419988f, -0.03504363f, 
    -0.11086457f, -0.04951883f, -0.08582597f, 0.06568423f, -0.04971204f, -0.12106740f, 0.11172323f, 0.15005234f, 
    -0.07244898f, -0.04791018f, -0.07412688f, -0.04494043f, -0.09529519f, -0.05016284f, -0.03978228f, -0.03944770f, 
    0.03093545f, -0.20101584f, 0.04971513f, 0.10366838f, 0.08934914f, 0.12295890f, 0.02082805f, 0.00844423f, 
    0.06369488f, -0.04006274f, -0.01089053f, 0.10817470f, 0.14036895f, -0.04812556f, -0.03090015f, -0.03223140f, 
    -0.03605159f, 0.05126235f, 0.09811128f, 0.00109370f, 0.24313396f, -0.14196134f, -0.13978061f, 0.01330306f, 
    0.05043082f, 0.05703535f, 0.00817844f, -0.06519767f, -0.03037191f, -0.00977072f, 0.04788139f, 0.02922583f, 
    0.10638610f, -0.09177115f, -0.02338628f, -0.00891855f, -0.04524629f, -0.00967852f, 0.07134482f, -0.02163951f, 
    0.06261907f, -0.07501174f, -0.03306783f, 0.12101729f, 0.05221248f, 0.11944675f, -0.16601595f, -0.07963818f, 
    -0.01544719f, -0.03735000f, -0.02077396f, 0.01065861f, -0.02927184f, 0.02495780f, 0.09739827f, 0.07225402f, 
    -0.05352978f, 0.02771269f, 0.03453585f, -0.04418644f, -0.09771626f, 0.20108952f, 0.20169856f, 0.11596241f, 
    0.09935448f, 0.05974738f, -0.01000383f, 0.06462122f, 0.04012933f, -0.02221284f, 0.08200525f, 0.02323153f, 
    0.02147454f, -0.01717737f, 0.08428412f, 0.01785460f, -0.07931847f, -0.16226935f, -0.06347255f, 0.07617886f, 
    -0.10164459f, -0.35120711f, 0.35065141f, 0.32998663f, 0.01705131f, -0.06953377f, 0.03300423f, 0.15535858f, 
    -0.02217265f, 0.19354153f, -0.08630306f, -0.07303107f, -0.13908629f, 0.02538988f, 0.02866014f, 0.05633061f, 
    -0.07531125f, 0.06552385f, 0.09941443f, 0.06300052f, -0.09144538f, 0.13900365f, -0.19148257f, 0.26400071f, 
    -0.10140037f, 0.10438892f, -0.03036297f, 0.12378453f, -0.11172570f, -0.10941019f, 0.02842645f, -0.10953248f, 
    0.13199538f, 0.04171154f, 0.14393416f, -0.02857457f, -0.07537118f, -0.08111729f, 0.03441257f, 0.03604843f, 
    0.34539196f, -0.09029587f, -0.14168477f, 0.26609278f, -0.04279739f, -0.04773866f, 0.10460103f, 0.04989008f, 
    -0.04037822f, -0.05884195f, -0.10638046f, -0.03890103f, 0.07839902f, 0.13661683f, 0.01374074f, 0.02976485f, 
    0.13623658f, 0.06667123f, -0.02149409f, 0.02131246f, -0.06347545f, 0.19165945f, 0.13222793f, -0.06918973f, 
    -0.03756188f, 0.10550018f, -0.00196645f, -0.04270109f, 0.10230098f, 0.11957961f, 0.02710466f, -0.04956929f, 
    0.03765254f, 0.02311854f, 0.08506500f, 0.05827089f, 0.01330060f, -0.10124900f, 0.10665343f, 0.04865328f, 
    0.58289868f, -0.44164026f, 0.13401775f, -0.00874995f, 0.09470278f, 0.04201596f, -0.14893441f, -0.15305702f, 
    0.12538765f, -0.20377864f, 0.01084578f, -0.11839399f, -0.07076713f, 0.17368239f, 0.04664629f, 0.05749265f, 
    0.09700040f, 0.02154861f, -0.05570668f, 0.01418178f, -0.08676051f, 0.19286670f, -0.11566434f, 0.22486952f, 
    -0.02515978f, 0.01030366f, 0.04765653f, 0.10057249f, -0.01872038f, 0.20738210f, 0.14506750f, -0.01891006f, 
    -0.05888963f, -0.06643005f, -0.02798430f, 0.06360093f, 0.05270922f, 0.04786021f, 0.12928791f, -0.13134968f, 
    0.26156682f, 0.00539815f, -0.02633710f, -0.01681192f, 0.18431441f, 0.00748718f, -0.11351604f, 0.10448107f, 
    0.17447935f, 0.27787748f, 0.06585912f, -0.00491043f, 0.03886693f, -0.00492332f, 0.00432463f, 0.08661529f, 
    -0.02590771f, -0.08778330f, -0.04167643f, -0.07662504f, 0.14525387f, 0.21924450f, -0.27603012f, -0.14224014f, 
    -0.36956391f, -0.02991404f, 0.03658731f, 0.11275712f, -0.06835313f, -0.03830928f, 0.04967065f, -0.10571566f, 
    0.08330980f, -0.19401398f, 0.01312605f, -0.07875863f, -0.14446039f, 0.05669741f, -0.13409169f, -0.22745825f, 
    -0.13078335f, -0.20359227f, -0.11146224f, -0.06702982f, 0.28417784f, -0.02507618f, -0.08596617f, 0.05740575f, 
    0.22085403f, 0.17353745f, -0.07154439f, -0.00046506f, -0.03978263f, 0.02178987f, -0.07869971f, 0.03426915f, 
    0.15487330f, 0.14819400f, -0.04849114f, 0.20727541f, -0.41096759f, 0.23787411f, 0.03585171f, 0.05064015f, 
    -0.17305928f, -0.00992220f, -0.09406132f, 0.00129159f, 0.04718884f, -0.01727907f, 0.05213756f, -0.01253725f, 
    0.03321833f, 0.03847077f, 0.11828234f, 0.02452465f, 0.06775507f, -0.02625192f, -0.12054909f, -0.08712451f, 
    0.10069981f, -0.35808763f, -0.07318024f, -0.05613458f, -0.12786692f, 0.01653083f, -0.01862572f, -0.08031358f, 
    0.01947011f, 0.08294780f, -0.03805805f, -0.01975292f, 0.00972502f, 0.00988987f, -0.03542561f, -0.09769306f, 
    0.04592062f, 0.01085371f, 0.03287654f, 0.18785629f, 0.18788457f, -0.07214906f, -0.34762684f, 0.04095045f, 
    0.04580102f, -0.10162552f, 0.05227619f, -0.17436722f, 0.12581384f, 0.02917915f, -0.04297170f, -0.00372732f, 
    0.04030776f, 0.10125414f, 0.01039593f, -0.05113655f, 0.11272465f, -0.00640564f, 0.12142536f, 0.06993621f, 
    -0.12615463f, 0.20618489f, 0.01521061f, -0.01365737f, -0.13699558f, -0.03951140f, 0.03999400f, 0.09157065f, 
    -0.05901163f, -0.03426431f, 0.08005258f, -0.02275129f, -0.02621991f, -0.00719262f, 0.02655216f, 0.10309789f, 
    0.01209289f, 0.12156787f, -0.06321060f, -0.06298357f, -0.07624965f, 0.21726921f, 0.07074073f, 0.07239810f, 
    -0.04201473f, 0.02517657f, -0.01011396f, 0.05040285f, 0.03534412f, 0.00825093f, 0.13835859f, 0.15110488f, 
    0.03159578f, -0.02946033f, 0.10056730f, 0.04503057f, 0.12881307f, 0.02751758f, 0.01344626f, 0.09928379f, 
    -0.05154311f, 0.43215820f, -0.12847196f, 0.22728431f, 0.01654005f, -0.09226230f, -0.01166435f, 0.03997304f, 
    -0.02532047f, -0.11259977f, 0.16361469f, -0.00077153f, 0.06442186f, 0.07306062f, 0.03999932f, 0.09180021f, 
    0.06920397f, -0.04910499f, -0.09088466f, -0.05528054f, 0.16343616f, -0.07843976f, -0.11202176f, -0.11719757f, 
    0.01902498f, -0.01093576f, 0.01075214f, -0.14286657f, -0.04146095f, 0.08227464f, 0.05331584f, 0.01746906f, 
    -0.04182433f, -0.01778213f, -0.07456407f, 0.02243569f, 0.06091073f, 0.02858860f, 0.06235892f, 0.04596284f, 
    0.16859187f, 0.20446952f, -0.04942800f, -0.33985782f, -0.01703785f, 0.00253891f, -0.13610375f, 0.00119727f, 
    0.00017525f, -0.25818864f, 0.06943144f, 0.09464820f, 0.02242551f, -0.12473516f, 0.01012263f, -0.04400337f, 
    -0.02998245f, 0.03711827f, 0.00014865f, -0.08515316f, 0.15399724f, -0.06151299f, 0.12514915f, -0.22356527f, 
    0.09740556f, -0.00445951f, 0.06873587f, 0.03071713f, -0.01566828f, 0.07299194f, -0.11312000f, 0.14237735f, 
    -0.05663673f, -0.00304519f, -0.06634929f, 0.07391614f, 0.01591142f, 0.05522883f, -0.12251965f, -0.07320452f, 
    -0.33175650f, 0.15890764f, 0.18913968f, -0.02703772f, -0.02394678f, 0.04871115f, 0.07258513f, -0.08213051f, 
    0.06747016f, 0.10144980f, 0.03890020f, 0.19355328f, 0.03137470f, -0.10921579f, -0.04938917f, -0.02153060f, 
    -0.07824628f, 0.09806557f, 0.05125731f, 0.03529740f, 0.02258622f, -0.03502676f, 0.13913973f, 0.08719496f, 
    0.25189167f, 0.00793952f, -0.14691918f, 0.14440472f, -0.02225277f, 0.07852057f, -0.03599933f, -0.01104258f, 
    -0.07031772f, -0.03884089f, -0.08512689f, 0.06573592f, 0.09910642f, -0.00684390f, -0.08704527f, -0.05927301f, 
    0.14701040f, 0.37294534f, 0.57914126f, 0.17645137f, 0.03442162f, -0.14618121f, -0.13792369f, -0.27669474f, 
    0.03366733f, -0.01675663f, 0.07953582f, -0.00352405f, 0.00155510f, 0.09705594f, 0.09961123f, -0.12054635f, 
    -0.00487633f, 0.12077315f, 0.04903214f, 0.02341531f, -0.37023056f, -0.16233404f, -0.51526874f, 0.18406324f, 
    0.21431489f, 0.03599524f, 0.15406305f, 0.14209364f, -0.06704898f, 0.06895425f, -0.00201496f, -0.17471182f, 
    -0.04695008f, -0.08931268f, -0.01967110f, -0.05415718f, -0.13771874f, -0.03815046f, -0.11253942f, -0.11659945f, 
    -0.12151250f, -0.08880947f, 0.37998050f, 0.05679065f, 0.01095531f, -0.02609690f, 0.16021548f, -0.08921864f, 
    -0.12279411f, -0.11469806f, 0.03150649f, -0.00657972f, -0.09171511f, -0.14962587f, -0.05885212f, -0.06977949f, 
    -0.01212036f, -0.08838861f, -0.00932399f, -0.16878569f, -0.03015526f, 0.22801809f, -0.51658994f, -0.00092294f, 
    -0.03081714f, -0.05592291f, 0.01605900f, -0.03058512f, -0.12243376f, 0.13809922f, -0.07773739f, -0.02396606f, 
    -0.11575577f, 0.02897873f, 0.09583846f, -0.06928310f, 0.10669135f, -0.01493970f, 0.08345224f, 0.19461034f, 
    0.00692778f, -0.00736056f, 0.01585299f, 0.11085424f, -0.00422540f, 0.09378296f, 0.01696705f, -0.17434224f, 
    0.02509955f, 0.04697077f, -0.08910188f, -0.00213868f, -0.03354146f, -0.07710942f, -0.11745936f, 0.10781945f, 
    0.13945775f, 0.12339509f, 0.10644422f, 0.22755803f, 0.32651702f, 0.22182384f, -0.08477910f, -0.17705123f, 
    0.11102910f, -0.01252815f, -0.14394529f, 0.09672812f, -0.06767120f, -0.00098307f, 0.07480040f, 0.05655452f, 
    0.20340164f, -0.05912699f, 0.02322738f, 0.17499961f, 0.08314332f, 0.16184732f, 0.11743290f, 0.02418770f, 
    -0.17378278f, 0.13627659f, 0.11139052f, -0.01007493f, 0.12463959f, -0.03161451f, -0.09605177f, 0.06738707f, 
    0.09194913f, 0.00724834f, 0.03268563f, 0.01704050f, 0.05825463f, 0.01904107f, 0.04557164f, 0.02129990f, 
    0.13760597f, 0.05124200f, 0.14195628f, 0.12174644f, -0.32992235f, -0.37353218f, 0.54350954f, 0.22162825f, 
    0.08064518f, -0.11659097f, -0.01225593f, -0.20809276f, 0.07746969f, -0.04682814f, -0.03898813f, -0.00501225f, 
    -0.05626085f, 0.00373906f, 0.00883991f, -0.04227386f, 0.08327825f, -0.02403557f, 0.01462995f, 0.01404279f, 
    -0.04091398f, -0.02025511f, -0.24226759f, 0.10578955f, 0.17275782f, 0.04666038f, 0.06763155f, 0.13530479f, 
    0.09015603f, 0.09650028f, -0.03602575f, -0.03283763f, 0.11754911f, 0.07653901f, 0.03525756f, 0.17002735f, 
    -0.16794723f, -0.06525100f, -0.17075945f, -0.08365332f, 0.03664113f, -0.16035087f, -0.04223969f, -0.12004521f, 
    0.18592244f, 0.09045258f, -0.13693942f, 0.05924213f, -0.02629862f, 0.00430274f, 0.12533659f, 0.05242554f, 
    0.12621039f, 0.13131055f, -0.00917566f, 0.07463432f, -0.16131377f, 0.02116899f, -0.03149197f, -0.09799308f, 
    -0.07509949f, 0.01046698f, -0.41443968f, 0.25553066f, 0.07667954f, -0.05915704f, 0.19926392f, 0.12128127f, 
    0.10545758f, 0.28767613f, 0.00483742f, -0.14967950f, -0.15675171f, -0.11440523f, -0.01774037f, 0.08458575f, 
    -0.02033660f, 0.06533127f, 0.08419079f, 0.07004982f, -0.25532776f, -0.11037285f, 0.11778293f, 0.30719820f, 
    -0.10819405f, -0.06897994f, 0.13296393f, 0.05125423f, 0.05762497f, 0.01285891f, -0.13282515f, -0.07739209f, 
    -0.09130664f, 0.10197396f, 0.16915840f, 0.09354153f, 0.16385268f, 0.12836164f, 0.09971062f, 0.14041476f, 
    0.42945680f, 0.20259225f, -0.33536166f, 0.15451764f, -0.07581680f, 0.01162373f, 0.07192661f, -0.17370556f, 
    -0.03159115f, 0.09784131f, -0.04301905f, 0.02512589f, 0.13264826f, 0.07486071f, 0.01618376f, 0.05018078f, 
    -0.02798621f, 0.06711711f, 0.07324617f, 0.19380687f, 0.19384879f, -0.38341519f, 0.02064777f, 0.01820484f, 
    -0.03510814f, 0.15694441f, -0.09798181f, -0.26436582f, 0.09099437f, -0.02083917f, 0.12413699f, 0.03291992f, 
    0.16047850f, -0.02296462f, -0.07128318f, 0.11058369f, -0.11228044f, -0.08704382f, -0.16576017f, -0.10411299f, 
    0.56119514f, 0.07653111f, -0.05553985f, -0.36537287f, 0.10860219f, 0.12593454f, -0.02789625f, -0.08502649f, 
    -0.05193113f, -0.04893973f, 0.08206920f, 0.02426869f, 0.06674215f, -0.04992310f, 0.14621098f, 0.09129035f, 
    -0.12889546f, -0.21312387f, -0.04524994f, -0.06923707f, -0.00763508f, -0.10166826f, 0.11705980f, 0.15094405f, 
    -0.15557961f, -0.09723275f, 0.20090732f, -0.03264945f, -0.04096277f, 0.17229946f, 0.14643866f, 0.00447227f, 
    -0.02326174f, -0.03617975f, -0.00245507f, -0.00648518f, 0.05393192f, 0.09179336f, 0.14702535f, 0.13448869f, 
    -0.47848034f, 0.63569111f, 0.16522628f, 0.17620637f, 0.38649273f, 0.03469043f, 0.14359976f, 0.14802551f, 
    -0.13853072f, 0.13393094f, -0.08098724f, 0.11420435f, 0.05999978f, -0.10968094f, -0.00856760f, -0.03868773f, 
    0.00525544f, 0.05383689f, -0.08222014f, -0.00622352f, 0.05719959f, -0.25561708f, 0.27108496f, -0.34013164f, 
    0.38000655f, 0.03241087f, 0.17126104f, -0.14991224f, -0.11328541f, -0.02915627f, -0.06578191f, -0.07145485f, 
    -0.03800156f, 0.06239498f, 0.13008444f, 0.00885887f, 0.00620424f, -0.00178836f, -0.02183251f, 0.05178165f, 
    -0.41571763f, -0.04198350f, -0.33459207f, 0.29751024f, 0.23061408f, 0.01623616f, 0.10163203f, -0.09507927f, 
    0.05053462f, -0.23396882f, 0.07395542f, 0.01552777f, -0.09147150f, 0.07268887f, 0.03935103f, -0.02453772f, 
    -0.05219667f, 0.00853016f, -0.01377675f, -0.05623011f, -0.17885149f, 0.14960957f, 0.09486764f, -0.15053360f, 
    0.46828318f, -0.25962865f, 0.03443699f, 0.01938108f, -0.05643577f, -0.03291452f, 0.05599547f, -0.01716368f, 
    0.00843423f, 0.05707168f, 0.14937483f, 0.04170958f, 0.11633679f, -0.01647500f, 0.04615298f, 0.01744659f, 
    -0.27406907f, 0.07442547f, 0.01053581f, 0.13634223f, -0.30208760f, 0.05248473f, 0.12263145f, -0.04990302f, 
    -0.13646063f, -0.08281474f, -0.00571806f, 0.00624585f, -0.00927625f, 0.06463034f, 0.02205277f, -0.02024302f, 
    -0.08445865f, -0.00702743f, 0.25427133f, 0.08037096f, 0.22450006f, -0.22578919f, 0.22270627f, -0.20121458f, 
    0.16715802f, 0.05228451f, 0.08536210f, -0.05628376f, 0.05760104f, -0.01314226f, -0.02534675f, 0.01295930f, 
    0.09770042f, -0.01432269f, -0.06685767f, -0.02431850f, -0.00320914f, -0.00195298f, 0.09165614f, 0.02952297f, 
    -0.04148444f, 0.04804765f, 0.08504394f, -0.08611619f, 0.11610238f, 0.13634716f, -0.05670325f, 0.13381034f, 
    -0.13269562f, 0.02209335f, 0.08525255f, -0.03773135f, 0.14926192f, 0.01292816f, -0.08118681f, 0.10862802f, 
    0.02861791f, -0.00158274f, 0.03202501f, 0.01728077f, -0.01480689f, 0.10732574f, 0.51659060f, 0.12528323f, 
    0.40441927f, 0.23013993f, -0.05981078f, 0.04003625f, -0.03649394f, -0.12741764f, -0.05082567f, 0.06791390f, 
    0.10517778f, -0.19907454f, -0.03543873f, 0.07031664f, -0.00241016f, 0.03732092f, -0.03161312f, -0.05869379f, 
    0.03640668f, -0.04558112f, 0.02314737f, -0.12809354f, 0.19181885f, 0.09703440f, -0.06048385f, -0.03427032f, 
    -0.01367500f, 0.11596558f, 0.05894555f, 0.04219921f, 0.05145545f, -0.01264825f, 0.10674489f, -0.10112131f, 
    0.07871439f, 0.01673364f, -0.00024011f, -0.04942375f, 0.17923251f, -0.09614574f, 0.05518126f, -0.01235293f, 
    0.06775858f, -0.00269058f, 0.04445431f, -0.07836811f, -0.04272055f, 0.12780461f, -0.08498137f, 0.06898402f, 
    -0.01733565f, -0.00163482f, 0.02012131f, -0.01335214f, -0.02123420f, -0.10274883f, -0.02138524f, -0.03555157f, 
    0.42483985f, -0.48403478f, 0.47344899f, -0.22164057f, 0.17028205f, -0.05955815f, -0.02319225f, 0.08899953f, 
    0.05171024f, 0.04715604f, -0.04613664f, 0.01537123f, -0.04097126f, -0.01712854f, 0.06681515f, 0.02925252f, 
    0.07512275f, 0.04473889f, 0.09048013f, 0.11284099f, -0.24596414f, 0.01748860f, -0.04341425f, 0.10593752f, 
    0.25121811f, -0.10046674f, 0.09424603f, 0.06734461f, -0.05231483f, -0.03614774f, -0.05498177f, 0.01531277f, 
    0.01131630f, -0.05091435f, -0.03743105f, -0.07768148f, -0.07520399f, 0.06987549f, -0.03093312f, 0.24839674f, 
    -0.14894457f, -0.06464104f, -0.03910458f, 0.19437501f, -0.02523281f, -0.07160541f, 0.04613285f, 0.02825832f, 
    -0.01478214f, 0.11776306f, -0.07995235f, 0.02688360f, -0.11196798f, 0.05015851f, -0.12486416f, -0.08022303f, 
    0.04581171f, 0.03898809f, -0.04723905f, 0.01319020f, -0.15934263f, 0.21744521f, -0.14039668f, 0.21312366f, 
    -0.03208018f, 0.30235320f, -0.17805369f, 0.02167873f, 0.06703591f, 0.04865795f, 0.02168885f, 0.00206378f, 
    -0.05278165f, 0.14435178f, -0.05562839f, -0.15395787f, -0.18638386f, 0.04066245f, 0.11360945f, -0.10241498f, 
    0.09724639f, -0.11023991f, -0.05499395f, 0.02983383f, -0.04506109f, 0.00357275f, -0.14608189f, -0.00979841f, 
    -0.06517602f, -0.11940706f, 0.11628032f, -0.08032234f, 0.16906334f, 0.08948414f, 0.00781564f, 0.03930235f, 
    0.06613214f, -0.08618682f, -0.11191050f, -0.06943349f, -0.54978740f, 0.25900549f, -0.31149876f, 0.10476796f, 
    0.09514694f, -0.12057497f, 0.16453204f, -0.18557632f, -0.07622291f, -0.15229078f, -0.00411968f, -0.03376792f, 
    0.01385848f, -0.01714333f, 0.13056007f, -0.02726312f, -0.05096479f, -0.02229027f, -0.04358032f, 0.07856171f, 
    0.11241872f, -0.15363105f, -0.21709816f, 0.19170174f, -0.62467271f, -0.16738187f, 0.03953547f, -0.05469368f, 
    -0.27039379f, 0.13261281f, 0.09763733f, -0.09162612f, -0.02414021f, -0.00116065f, -0.10476389f, -0.06482277f, 
    -0.01401458f, -0.05848297f, -0.08948988f, -0.03319753f, -0.05333812f, 0.30493560f, 0.34563923f, -0.01428547f, 
    -0.21040963f, 0.09938010f, -0.04171456f, -0.06431980f, 0.15557101f, -0.00791035f, -0.16345781f, -0.02121827f, 
    0.00018934f, -0.00003172f, -0.06419935f, 0.04743854f, 0.09826765f, -0.02704483f, -0.04608721f, 0.22424413f, 
    0.14551309f, 0.12044574f, 0.38537106f, 0.19948763f, -0.07548000f, 0.00138219f, -0.03194739f, 0.01120791f, 
    -0.11994773f, 0.15969378f, -0.10676902f, -0.07854318f, -0.02105094f, 0.04460950f, -0.05483147f, -0.14462991f, 
    0.01938513f, -0.10905223f, -0.08837757f, 0.01629583f, -0.34934273f, -0.16675334f, 0.47119367f, 0.27230898f, 
    0.21349549f, 0.27062809f, -0.06821018f, 0.05102612f, 0.13874461f, 0.00725405f, 0.07642557f, 0.00354954f, 
    -0.07031538f, 0.04628731f, 0.05426647f, 0.01977824f, 0.05961764f, 0.16749562f, -0.10574917f, 0.31853449f, 
    0.19904412f, 0.29671955f, 0.06178680f, -0.07395834f, -0.10344663f, 0.12836304f, 0.00900122f, -0.00070187f, 
    -0.01359762f, 0.14948991f, 0.02335821f, 0.16098124f, -0.03458488f, -0.00799683f, 0.01897419f, 0.04729865f, 
    -0.10982092f, -0.27155808f, 0.00409468f, -0.09853903f, 0.41807589f, -0.10719832f, -0.24661152f, 0.10169697f, 
    0.01894582f, -0.10374869f, 0.07417554f, -0.08522633f, -0.00807566f, 0.12679008f, -0.06468784f, 0.00966570f, 
    0.01098234f, -0.03151521f, -0.06074188f, 0.07662775f, 0.06386358f, -0.06576543f, 0.11438474f, 0.04388797f, 
    -0.29423138f, 0.29120690f, -0.12137520f, 0.12782325f, -0.01311687f, -0.05627632f, -0.03456555f, 0.05651719f, 
    -0.09409812f, 0.12531801f, 0.03109309f, -0.01183255f, -0.15104385f, 0.08522204f, 0.03723586f, 0.04792403f, 
    -0.06061461f, 0.17510766f, 0.03490105f, -0.12539834f, -0.11814120f, 0.10743601f, -0.16428593f, -0.01561299f, 
    -0.25792399f, -0.05547004f, 0.03070804f, 0.10245509f, -0.15616362f, 0.01536573f, 0.05120933f, -0.03476209f, 
    -0.09730049f, 0.00628400f, -0.01841524f, -0.04947005f, -0.08951521f, -0.06931297f, 0.02716797f, -0.10057613f, 
    0.02334522f, -0.07542704f, 0.08998743f, 0.17499301f, 0.07973628f, 0.11381096f, 0.00182032f, -0.00791863f, 
    -0.03402675f, -0.00832748f, -0.04922285f, 0.08411199f, 0.14390649f, 0.05158684f, -0.01203060f, 0.05954461f, 
    0.05283591f, -0.00607725f, 0.04483353f, 0.07672691f, 0.06417605f, -0.06877328f, -0.07172073f, 0.08466237f, 
    0.08096898f, -0.00841451f, 0.08216384f, -0.03631150f, -0.03093512f, -0.06502964f, 0.07105951f, 0.03582766f, 
    0.06416593f, 0.05928504f, -0.04256784f, 0.00105785f, -0.02303386f, 0.04326517f, -0.06784201f, -0.13048714f, 
    0.30760124f, 0.14874372f, 0.06402309f, 0.19514461f, -0.03690610f, 0.18201245f, -0.09502324f, -0.11360076f, 
    0.13018745f, 0.06924646f, -0.12294005f, -0.04297693f, -0.05520587f, -0.01539451f, 0.01093847f, 0.09830142f, 
    0.03117474f, 0.19428211f, 0.01450112f, 0.04780700f, -0.07651476f, 0.14446868f, 0.37309897f, 0.08549528f, 
    0.04095901f, 0.11688569f, -0.02725750f, 0.10387050f, -0.01341153f, -0.01282351f, 0.06268761f, 0.04522178f, 
    0.05654885f, -0.09787885f, -0.00772246f, -0.05203352f, -0.01065231f, -0.13905719f, -0.06936105f, -0.07541370f, 
    0.02908057f, -0.28585845f, 0.20250164f, 0.38919392f, -0.05884272f, 0.03300546f, 0.02214196f, 0.11650565f, 
    -0.11763725f, 0.10648248f, 0.07784493f, -0.05670321f, -0.06972973f, 0.09587168f, -0.00670337f, 0.07728365f, 
    -0.00083156f, 0.05538637f, 0.01181884f, 0.05481865f, 0.00927004f, 0.17580169f, -0.24705555f, 0.12338094f, 
    -0.10996161f, 0.00770477f, -0.05897613f, -0.04818095f, -0.10494143f, -0.01626086f, 0.05111719f, 0.00169898f, 
    0.04297077f, -0.06202686f, 0.14157429f, 0.13416426f, 0.08854803f, -0.01568585f, 0.11566623f, 0.04791682f, 
    0.29294357f, -0.05336966f, -0.01545074f, 0.16731016f, -0.04186355f, -0.01874685f, 0.10848110f, -0.05059930f, 
    0.00504440f, 0.01985781f, -0.17145681f, -0.11387132f, -0.16648866f, 0.02954213f, 0.01059125f, 0.11567799f, 
    0.15166467f, 0.05854874f, 0.08451971f, -0.02141403f, 0.28854868f, -0.04553268f, 0.27433085f, 0.01262588f, 
    -0.06480736f, 0.19878504f, -0.09693529f, -0.05496389f, 0.18073113f, 0.11355016f, -0.00225989f, -0.03715168f, 
    0.08818463f, 0.07020353f, -0.04399711f, -0.07105079f, -0.05632959f, -0.13830221f, 0.02460132f, 0.02231620f, 
    0.01656799f, -0.01037929f, -0.01211012f, 0.01257324f, -0.05090105f, -0.05447194f, -0.03725037f, -0.04705226f, 
    0.02911840f, -0.05314317f, 0.00279633f, -0.00540732f, -0.05545283f, 0.01433262f, 0.04308539f, -0.01495746f, 
    0.02364548f, -0.03382483f, 0.06474885f, 0.03924526f, 0.01588732f, -0.00593458f, -0.00088562f, -0.03168646f, 
    0.03559300f, 0.04373968f, -0.03810433f, 0.01291548f, 0.00201737f, -0.03171846f, -0.02335827f, -0.01964162f, 
    -0.00346474f, 0.03503589f, 0.02677559f, 0.02143797f, -0.01963239f, 0.01533203f, -0.04720166f, -0.04129929f, 
    0.04611258f, 0.01749215f, 0.04667224f, -0.04013002f, -0.00962559f, 0.04340217f, 0.02502984f, 0.00404907f, 
    -0.05036686f, 0.04707215f, -0.04125823f, -0.01381853f, 0.00752323f, 0.03037789f, 0.00563674f, -0.04476500f, 
    -0.01171901f, 0.00435283f, -0.03191018f, 0.00903264f, -0.01229324f, -0.02928739f, -0.00766636f, -0.05900564f, 
    -0.01366558f, 0.00747724f, -0.00544460f, 0.03164330f, -0.01352724f, -0.04745638f, -0.04197323f, -0.00689459f, 
    0.03011053f, -0.00844052f, -0.05326705f, -0.06196866f, 0.01783131f, -0.00272503f, -0.03195519f, -0.04026176f, 
    0.05444342f, -0.00536436f, -0.00942838f, -0.03751857f, 0.01848932f, 0.04326960f, -0.01381619f, 0.02886743f, 
    0.03127917f, -0.03730198f, -0.01072052f, -0.04444687f, -0.02246340f, 0.00031875f, 0.04173294f, 0.00497700f, 
    -0.05696655f, 0.04014958f, 0.02845043f, 0.04110809f, -0.03386960f, -0.03995062f, 0.02781981f, 0.02478027f, 
    -0.01144486f, 0.04334120f, -0.05619210f, -0.04826489f, -0.00914792f, -0.02637808f, -0.02875810f, -0.00000729f, 
    -0.01255461f, 0.02182098f, -0.03384529f, 0.03522789f, -0.06599038f, 0.04943521f, 0.02483193f, -0.01657963f, 
    0.02767909f, -0.02851794f, 0.01474010f, 0.02077547f, -0.01712411f, 0.03390547f, 0.04778802f, -0.06131990f, 
    0.02973213f, 0.00462389f, -0.02125460f, -0.05063863f, 0.03774506f, 0.02420680f, 0.02454748f, 0.01291156f, 
    0.01407589f, 0.00392574f, -0.04549045f, -0.05723469f, 0.02027260f, -0.01682311f, 0.04507077f, 0.05700967f, 
    -0.01524455f, -0.02793294f, 0.01782901f, -0.05965796f, -0.02327033f, -0.04734864f, -0.00722759f, 0.05460545f, 
    -0.02741408f, -0.03511317f, -0.00964714f, -0.00425971f, 0.00876783f, -0.02759544f, -0.04225002f, 0.02365738f, 
    -0.00133239f, -0.04155669f, 0.04588720f, -0.01433870f, -0.00303591f, 0.03803150f, -0.02909255f, 0.00840277f, 
    -0.01447096f, -0.01262144f, 0.02545569f, -0.02216433f, 0.04292819f, -0.05145127f, 0.04397525f, -0.01952064f, 
    0.00204616f, 0.00433439f, -0.03946812f, 0.04419507f, 0.00511222f, -0.00867230f, -0.01509469f, -0.02620088f, 
    -0.06249966f, -0.01632770f, 0.00833114f, 0.00127372f, -0.04020176f, 0.00304232f, 0.04040434f, -0.00263299f, 
    0.02976531f, 0.00191072f, 0.01415677f, -0.04840183f, 0.04301686f, 0.00949336f, -0.03174916f, -0.00621460f, 
    -0.03363451f, 0.00520438f, -0.02425854f, -0.01289622f, 0.03184902f, 0.02004077f, 0.03644798f, -0.05184340f, 
    -0.02602332f, -0.05833729f, -0.01445907f, 0.04501999f, -0.01405407f, -0.05359782f, 0.00638505f, -0.00929865f, 
    0.01923282f, -0.05487078f, -0.05729440f, -0.03053718f, 0.00374779f, -0.02157744f, -0.04228088f, -0.00426994f, 
    0.02232981f, 0.03243232f, -0.02636212f, -0.05979213f, 0.01561385f, 0.02927493f, 0.02741324f, -0.01018465f, 
    0.00109033f, -0.05238483f, 0.03737848f, -0.04871320f, 0.00233564f, -0.02723245f, 0.00163615f, -0.04406851f, 
    -0.04864560f, 0.01288276f, 0.00622391f, 0.00451919f, 0.01636229f, 0.00579586f, 0.04008780f, -0.02709442f, 
    -0.02155740f, 0.03549524f, 0.03320219f, 0.02234180f, -0.02860274f, -0.04771382f, -0.03813799f, 0.01093123f, 
    -0.01827198f, 0.03231425f, -0.04211710f, -0.01280196f, -0.02597471f, -0.03341321f, 0.03771232f, 0.05363378f, 
    -0.00297288f, -0.03038098f, -0.05693999f, -0.00179101f, -0.01977178f, 0.02984877f, -0.04658249f, 0.04005434f, 
    -0.00522601f, 0.03807465f, 0.02652405f, 0.01124548f, -0.04828265f, -0.04517233f, 0.03488570f, -0.03703021f, 
    0.00011837f, 0.01209270f, -0.04496166f, -0.03240420f, 0.02378614f, 0.00339503f, -0.05012783f, 0.04507972f, 
    -0.03553289f, 0.03188928f, -0.03432712f, 0.01692667f, -0.02055702f, -0.02307292f, -0.04493824f, -0.05499764f, 
    -0.04468395f, -0.02599664f, 0.02506543f, 0.04018723f, -0.05264916f, 0.04797127f, -0.03320354f, -0.00113221f, 
    -0.05943783f, -0.00321799f, 0.00355136f, -0.06757262f, -0.01691014f, 0.03009352f, 0.02713990f, 0.05048508f, 
    0.01841281f, 0.02081614f, -0.00777087f, 0.04456175f, -0.00496276f, -0.02471417f, 0.00458977f, -0.04205966f, 
    -0.64925581f, 0.14957695f, -0.08573555f, 0.01460769f, 0.20539270f, 0.20330599f, -0.03804790f, 0.08922020f, 
    -0.02596793f, 0.24602598f, -0.05859653f, -0.00211097f, 0.00130998f, 0.01255842f, -0.02276862f, -0.22391959f, 
    -0.12666166f, 0.00687067f, 0.00120665f, -0.04601871f, 0.37160394f, -0.07942733f, -0.02008728f, -0.11131897f, 
    0.20907584f, -0.03859372f, 0.09255917f, 0.06836025f, 0.02337207f, -0.21003084f, 0.01771511f, 0.07577825f, 
    -0.02421119f, -0.07776664f, -0.02749421f, -0.08954561f, -0.04902625f, 0.19786531f, -0.03429232f, 0.04984948f, 
    -0.17197314f, -0.32997799f, -0.15541705f, 0.06361894f, -0.00486362f, 0.08186790f, 0.05479855f, 0.00146817f, 
    0.00104816f, -0.13359798f, -0.18977349f, -0.11182380f, -0.19474834f, -0.16788222f, -0.01511871f, 0.01841392f, 
    -0.07538576f, 0.05393763f, -0.00002569f, 0.09727225f, 0.46935323f, -0.06992859f, -0.02186520f, -0.00544221f, 
    0.05888686f, -0.00278799f, 0.00156096f, -0.01986801f, 0.08164217f, 0.22791262f, 0.11648127f, 0.13229597f, 
    0.03695883f, 0.06230032f, 0.14197831f, 0.16415070f, 0.18758589f, -0.08345016f, 0.08136369f, 0.10084134f, 
    0.11224514f, -0.27943364f, -0.11492536f, 0.22128369f, 0.34353665f, 0.06059365f, -0.02333194f, 0.05265562f, 
    -0.09666257f, -0.26222837f, -0.03678039f, -0.02133143f, 0.02070414f, -0.10337991f, 0.02608733f, 0.02611143f, 
    -0.06452974f, -0.09549011f, -0.02471481f, -0.18342668f, 0.13062400f, 0.21534686f, 0.58444351f, 0.01183624f, 
    0.34878021f, 0.06363377f, 0.11449144f, -0.06917144f, 0.10897564f, -0.04222043f, 0.04468057f, 0.04964718f, 
    0.11191601f, 0.05335600f, 0.03502412f, 0.09693443f, 0.08283039f, 0.22055276f, 0.04978886f, -0.00077801f, 
    0.16670650f, 0.15635341f, -0.14393321f, 0.18428890f, 0.22800493f, 0.02629876f, 0.10283188f, 0.18227479f, 
    0.01773680f, 0.02460419f, -0.02131664f, 0.00945861f, 0.16346303f, -0.01416574f, 0.13222122f, -0.08231217f, 
    -0.05400927f, 0.07642721f, 0.05761254f, -0.17451188f, -0.41081640f, 0.19178836f, -0.08247051f, 0.02409918f, 
    0.09005148f, 0.23974213f, 0.02358140f, 0.11830528f, -0.13422327f, 0.11186425f, -0.15031770f, -0.08331080f, 
    0.00327182f, 0.11455189f, 0.11322580f, 0.05032792f, -0.22266111f, -0.00589753f, -0.01957289f, 0.02776323f, 
    0.11148653f, 0.05894823f, 0.21006544f, -0.05167940f, 0.09280857f, 0.01987073f, 0.06159081f, -0.08851393f, 
    -0.01301744f, 0.02683693f, -0.02579612f, -0.06413311f, 0.07616747f, 0.16575272f, 0.10839090f, -0.00958982f, 
    0.22800948f, -0.04437140f, -0.03550782f, -0.03597058f, -0.07147606f, -0.05167685f, 0.15418194f, 0.02771253f, 
    -0.02077208f, -0.03741371f, 0.01229504f, 0.06608453f, 0.04140854f, -0.05610584f, -0.03747529f, 0.02859581f, 
    -0.05670292f, 0.06976109f, 0.06752815f, 0.06838476f, 0.06358597f, 0.06784954f, -0.03948896f, -0.06152374f, 
    0.10899240f, -0.36198968f, 0.34286091f, -0.15748776f, 0.25442407f, -0.01878106f, 0.00970290f, 0.09365357f, 
    0.02861910f, 0.01395245f, -0.06272411f, 0.08719689f, -0.04064832f, -0.01783701f, -0.05544645f, -0.02484239f, 
    -0.00423092f, -0.00420120f, -0.11328179f, -0.10825855f, -0.13760297f, -0.05257079f, -0.13312404f, 0.12587610f, 
    0.09155782f, -0.01457218f, 0.05959930f, 0.00869590f, 0.08980971f, -0.04150761f, -0.08173024f, -0.10818107f, 
    -0.08037126f, 0.02916045f, -0.02110013f, 0.05236286f, 0.02876988f, 0.00687424f, -0.04275407f, -0.14263047f, 
    0.05481967f, 0.26499754f, -0.16465268f, 0.19276658f, -0.08257541f, 0.18280159f, -0.00064951f, 0.06652349f, 
    0.03672455f, 0.09805980f, 0.00666124f, 0.07526513f, 0.06025262f, 0.11496634f, 0.12764837f, 0.06799219f, 
    -0.07896278f, 0.02021637f, -0.01326164f, -0.02903066f, -0.05026425f, -0.15601909f, 0.18612222f, 0.04206934f, 
    0.05893067f, 0.01184573f, 0.14207134f, -0.01705291f, 0.01832008f, 0.14629516f, 0.11204029f, -0.00392068f, 
    0.03174132f, 0.03551328f, 0.06614067f, 0.00416269f, -0.03137368f, 0.13261579f, 0.01950199f, 0.17448439f, 
    -0.02848670f, 0.03533576f, -0.03264286f, -0.03285633f, 0.12275091f, 0.04929401f, -0.00348369f, 0.11028799f, 
    0.05284908f, -0.03459892f, 0.14280686f, 0.01421474f, 0.10651142f, -0.08385024f, 0.00514095f, 0.09439509f, 
    0.03239631f, 0.12148550f, -0.04497444f, 0.23871209f, -0.03664395f, -0.09114632f, -0.16762654f, 0.19191961f, 
    0.03863652f, 0.07075834f, 0.05831168f, -0.04464522f, 0.12446272f, -0.06083068f, 0.06811191f, 0.00705113f, 
    -0.08885869f, -0.01020452f, 0.06194746f, -0.06110798f, 0.03815679f, 0.08433910f, -0.01316765f, -0.03779834f, 
    0.36876497f, -0.06530265f, -0.06279763f, -0.24026982f, -0.55869216f, -0.10193506f, 0.03780293f, -0.12712653f, 
    -0.04883081f, -0.02090135f, 0.06397308f, 0.00173559f, 0.16205145f, 0.01234709f, 0.03252287f, -0.02119126f, 
    -0.06218088f, 0.01336943f, 0.12500218f, 0.10456338f, -0.10228666f, 0.16433036f, -0.40111840f, 0.18410659f, 
    -0.10227688f, 0.01684567f, 0.06548981f, 0.08156119f, 0.14549972f, 0.02436486f, -0.01201991f, 0.00527297f, 
    0.06125979f, -0.02294016f, -0.08051977f, 0.04725492f, 0.12219681f, -0.02195211f, -0.00928821f, -0.03766244f, 
    0.04529647f, 0.12638709f, 0.54200941f, -0.18658637f, -0.25542814f, -0.01895135f, 0.14499472f, 0.04744813f, 
    -0.12005109f, 0.00946616f, -0.00181716f, -0.10800583f, -0.00981782f, -0.05062908f, -0.04921718f, -0.07694802f, 
    0.02833606f, -0.07529654f, -0.11052764f, -0.13246383f, -0.08891903f, -0.00503026f, -0.05334596f, 0.20999315f, 
    0.05895726f, 0.25151581f, 0.10562030f, 0.03308665f, -0.03599647f, 0.11720232f, 0.01694065f, 0.10947558f, 
    0.03090615f, 0.07931545f, -0.13286573f, 0.07492512f, 0.04995994f, 0.16470221f, 0.06106111f, 0.20778731f, 
    0.31323728f, 0.15273483f, 0.09601786f, -0.16278505f, -0.05913939f, 0.06978191f, -0.12956320f, -0.10876627f, 
    0.03516518f, 0.01190277f, 0.02290217f, -0.01092500f, 0.00421628f, 0.00112867f, 0.01304676f, -0.02058172f, 
    0.01618723f, -0.02834820f, 0.04070939f, -0.10086462f, 0.40447935f, 0.12545826f, -0.31529921f, 0.12407474f, 
    0.04744374f, -0.06905990f, -0.09908421f, -0.00300015f, -0.05305899f, 0.07135366f, 0.04068655f, -0.01617865f, 
    -0.06183545f, 0.05603675f, -0.07322830f, 0.04611228f, 0.00067092f, 0.03765957f, 0.00893355f, 0.11656769f, 
    -0.20296203f, 0.25281653f, 0.07880556f, -0.00682897f, -0.08875496f, -0.13069376f, -0.00560933f, 0.04255970f, 
    0.06123466f, -0.05816444f, -0.04446457f, 0.07677758f, -0.07064245f, -0.00868084f, 0.16946507f, -0.01893544f, 
    -0.02771107f, 0.14676249f, 0.22335374f, -0.14343403f, -0.03262808f, -0.07158889f, 0.02688751f, -0.23575069f, 
    -0.30608076f, -0.22709952f, 0.08735003f, 0.04786746f, 0.13611080f, -0.02851249f, 0.09257677f, -0.04695471f, 
    -0.01032020f, 0.05812293f, -0.00600964f, -0.11716146f, -0.11082172f, -0.13075700f, 0.10812262f, -0.04908526f, 
    -0.03881437f, -0.01135550f, -0.08653216f, 0.29152432f, 0.12709299f, -0.01271550f, 0.11299391f, -0.02778339f, 
    -0.03807843f, -0.05817114f, 0.02043544f, 0.00529168f, 0.17329456f, 0.03648873f, -0.14124958f, 0.10869629f, 
    -0.14110038f, 0.02464320f, -0.02654260f, 0.09629864f, 0.17702733f, -0.00741301f, -0.04740360f, 0.08005464f, 
    0.10710027f, 0.00403628f, -0.01345414f, -0.01201120f, -0.09112017f, -0.10146935f, 0.13488384f, 0.00306763f, 
    -0.05125023f, -0.01382470f, -0.07477966f, -0.11226952f, -0.19865207f, 0.08625073f, -0.01234026f, -0.01956168f, 
    0.12518503f, 0.33101290f, -0.41575778f, 0.21260251f, -0.15233232f, 0.07144318f, -0.00925733f, -0.09037630f, 
    0.03037368f, 0.17305471f, -0.06977945f, -0.00650487f, -0.07444175f, -0.06886570f, -0.06653995f, 0.13630858f, 
    0.12616427f, 0.09299769f, 0.22640687f, 0.05028203f, 0.04064563f, 0.07766455f, 0.35217291f, 0.10519876f, 
    -0.11709260f, 0.14805800f, -0.05828323f, 0.07771809f, 0.11672182f, -0.03843468f, -0.03048988f, -0.03766136f, 
    -0.03689618f, -0.06232440f, 0.15326011f, -0.08662174f, 0.04799374f, -0.10130146f, 0.18590137f, -0.03502817f, 
    0.12004643f, -0.14186105f, 0.00716715f, 0.01756422f, 0.05270692f, 0.06374482f, 0.20835042f, -0.12296410f, 
    0.03471441f, 0.15226388f, 0.06399264f, -0.01639498f, 0.13164486f, 0.00043386f, 0.15507488f, 0.04308215f, 
    0.02134879f, 0.12774910f, 0.03149870f, 0.07018150f, -0.07035531f, -0.13231301f, 0.20138021f, -0.11600690f, 
    0.05884349f, -0.08526291f, 0.09523530f, -0.03049248f, -0.01138856f, -0.06860829f, 0.33027506f, 0.04645648f, 
    0.22388135f, -0.06583975f, 0.01195602f, 0.18769185f, 0.01420616f, -0.02414561f, -0.09081186f, -0.00543877f, 
    0.38478461f, 0.20602487f, -0.07012138f, -0.19551985f, 0.18570381f, 0.02473214f, 0.04851837f, -0.05287718f, 
    0.00694701f, 0.03272877f, -0.08670656f, -0.05006780f, -0.04682187f, -0.04741149f, 0.05294093f, -0.01955742f, 
    -0.00383982f, 0.02641194f, -0.01242027f, 0.01755347f, 0.31285942f, -0.11652173f, 0.31440273f, -0.07208744f, 
    -0.22531296f, 0.14489514f, 0.03782953f, 0.10144477f, -0.05046974f, 0.19219361f, 0.08754610f, -0.02223368f, 
    -0.00256386f, -0.03587388f, -0.06877447f, -0.02957162f, 0.04865656f, 0.08016131f, 0.17253646f, 0.10868639f, 
    0.07939371f, -0.13276820f, 0.17251214f, 0.27338815f, -0.22004877f, 0.09944277f, -0.03534393f, -0.02900770f, 
    -0.06144327f, 0.15571772f, -0.00959715f, -0.12733637f, 0.01009766f, 0.09311660f, -0.06976456f, 0.00463198f, 
    0.01751922f, 0.00570895f, -0.07314616f, -0.04234159f, 0.38565591f, 0.28117055f, 0.50936800f, -0.04796439f, 
    -0.10725457f, 0.12658672f, 0.03107358f, -0.04903113f, 0.22600165f, -0.03649662f, 0.06700365f, 0.07762264f, 
    -0.00147345f, -0.06676228f, 0.01301459f, -0.05716417f, -0.00113038f, 0.06432743f, -0.04729050f, 0.19090228f, 
    0.48399696f, 0.29512113f, 0.24283488f, 0.12648404f, 0.11237966f, -0.06406618f, -0.21599300f, 0.12419662f, 
    0.07958140f, 0.07137964f, -0.02783049f, 0.02972925f, 0.01878310f, -0.07703624f, -0.08888849f, -0.03769759f, 
    -0.07983139f, -0.06217804f, 0.16086502f, 0.02760394f, -0.02949393f, -0.27086061f, 0.46158457f, 0.06375343f, 
    0.11280581f, 0.31944114f, -0.00025310f, 0.05152746f, 0.24640180f, -0.09932241f, 0.06231579f, 0.03964898f, 
    0.02677492f, -0.02822861f, 0.15628503f, -0.13952948f, -0.06149679f, -0.07010336f, 0.08293549f, 0.12482075f, 
    0.21470940f, 0.28296265f, 0.04455086f, 0.31627932f, 0.26981422f, 0.09790096f, 0.02435618f, -0.08110984f, 
    -0.00437097f, -0.10465578f, -0.08729194f, 0.02243622f, -0.07794595f, -0.03560394f, -0.04525132f, 0.37877327f, 
    0.09202763f, 0.18961191f, 0.08131327f, 0.11411352f, -0.01487662f, -0.13557300f, -0.01371470f, 0.00395357f, 
    0.01035406f, 0.04857142f, 0.10205138f, -0.11499797f, 0.10807035f, 0.07657187f, -0.02837640f, 0.13215369f, 
    -0.02046480f, -0.04320304f, 0.09239511f, 0.19449970f, 0.07078096f, -0.01844368f, 0.02027629f, -0.08162948f, 
    0.16907468f, 0.35754079f, -0.24844040f, 0.24383736f, 0.00059245f, -0.10466528f, 0.02806783f, -0.04638160f, 
    0.11951133f, 0.04855293f, 0.05129314f, -0.06138638f, -0.05054212f, 0.12631802f, 0.13122244f, -0.09305254f, 
    0.06476766f, 0.17937444f, -0.07734831f, 0.09301396f, -0.29133075f, 0.27134725f, -0.55033612f, 0.19149172f, 
    -0.07633609f, 0.03603498f, 0.10171884f, 0.19117397f, -0.30754954f, 0.22263782f, -0.05277268f, -0.06237245f, 
    0.06241389f, 0.25621176f, 0.09370343f, -0.08059779f, 0.13970944f, 0.26414922f, 0.02070644f, 0.05565451f, 
    -0.02566740f, -0.08777229f, 0.02859944f, -0.13755521f, -0.11501115f, 0.01690197f, 0.15442286f, 0.03414382f, 
    -0.05781906f, -0.06550950f, -0.05123877f, 0.19065093f, -0.04120504f, 0.06213253f, 0.14956687f, 0.10336059f, 
    -0.02527259f, -0.10905308f, -0.04151738f, 0.01209212f, -0.13574342f, -0.06310532f, -0.10233492f, -0.10813676f, 
    -0.12731312f, -0.01121332f, 0.09146297f, 0.06147793f, -0.03382893f, -0.01138931f, -0.23267090f, 0.09808762f, 
    0.05448503f, 0.07857874f, 0.08802543f, 0.15174015f, 0.17047682f, 0.13268621f, -0.19173792f, -0.05280496f, 
    0.36396110f, 0.33581689f, 0.26283988f, 0.18077786f, -0.11197656f, -0.00961404f, -0.06482618f, 0.00180431f, 
    0.01926292f, 0.10044772f, 0.01628210f, 0.02993614f, 0.00804444f, -0.01366447f, -0.05000623f, -0.06070636f, 
    0.12260454f, 0.21031602f, -0.06137424f, 0.19757766f, 0.11646982f, 0.09858510f, 0.24935611f, 0.04550822f, 
    0.12273096f, -0.00738421f, -0.00258059f, 0.01769543f, -0.12356894f, 0.00762042f, -0.06043020f, 0.01647001f, 
    0.00421416f, 0.03911766f, -0.10052141f, 0.08156949f, 0.03942531f, -0.08752333f, 0.17250322f, 0.04843803f, 
    -0.34450904f, -0.22697745f, 0.39535606f, 0.25619447f, -0.16717458f, 0.18490849f, -0.09883220f, 0.21827714f, 
    -0.10302790f, 0.10804595f, 0.13838109f, -0.02561107f, 0.04409932f, -0.06024374f, 0.08666186f, -0.00565403f, 
    -0.14521146f, 0.03629118f, -0.02781279f, 0.01626822f, -0.13324751f, 0.06508161f, -0.07787606f, 0.24791116f, 
    -0.25815293f, -0.09117557f, -0.00088522f, 0.16741355f, -0.30074981f, 0.10303394f, -0.17560530f, -0.08087448f, 
    -0.08973180f, 0.04019650f, -0.00219625f, 0.09223535f, 0.07827879f, -0.10317894f, -0.07588170f, -0.04450560f, 
    -0.13511878f, -0.25710866f, 0.10781710f, 0.21046214f, -0.23715915f, -0.02874385f, 0.23201467f, 0.11579869f, 
    0.03449151f, 0.06343245f, -0.22724047f, 0.00822685f, 0.00805852f, 0.08214319f, 0.18315798f, -0.10628693f, 
    0.19174151f, 0.03855184f, 0.05126962f, -0.14028290f, 0.57359505f, 0.00996886f, 0.47838843f, -0.07433800f, 
    0.16181195f, 0.13773012f, -0.16736563f, -0.04718783f, 0.31334847f, -0.16426386f, -0.02250271f, -0.06069929f, 
    0.02694081f, 0.01975846f, 0.02793738f, 0.01980831f, -0.09227456f, -0.02714562f, 0.18112110f, -0.01173008f, 
    -0.00376276f, 0.00469984f, -0.02799331f, 0.03315955f, 0.05560998f, -0.01575317f, -0.04196233f, -0.05104030f, 
    0.00130188f, -0.02943146f, 0.02745742f, -0.03230261f, -0.04171889f, -0.01267135f, 0.02122740f, -0.05417105f, 
    -0.04340854f, -0.02707128f, 0.03617456f, -0.03796511f, -0.04183308f, -0.03255089f, -0.05448651f, 0.00419125f, 
    -0.03051834f, -0.00438642f, -0.02902961f, -0.03142691f, 0.02918422f, -0.00440457f, -0.03640867f, 0.00546997f, 
    0.04587802f, 0.04111676f, -0.02816877f, -0.03976584f, 0.05106849f, 0.03664802f, -0.04417161f, 0.05166847f, 
    -0.02165948f, -0.00163706f, -0.01122898f, -0.01218337f, -0.03390636f, -0.01690004f, -0.01188827f, -0.05452418f, 
    0.03302916f, 0.00003193f, 0.04780766f, -0.03934210f, -0.02350012f, -0.01567854f, 0.02807652f, -0.03638669f, 
    0.00859692f, 0.05031056f, 0.01614293f, -0.00182554f, 0.04749531f, 0.02990691f, -0.05376536f, -0.04857755f, 
    -0.04754108f, -0.03632841f, 0.01573868f, -0.02204848f, 0.01849550f, -0.01055768f, 0.02282504f, -0.00217218f, 
    0.03581897f, -0.04231181f, -0.00504512f, -0.02328987f, 0.05380778f, -0.00510921f, 0.02858479f, -0.02687163f, 
    0.03264829f, -0.01551402f, -0.03438287f, 0.02890247f, -0.05095299f, 0.00558852f, 0.04317437f, -0.03824950f, 
    -0.00522372f, -0.04928984f, 0.03751819f, 0.03572769f, 0.01098924f, 0.01899555f, 0.04647532f, 0.04093198f, 
    -0.05269156f, -0.02906867f, -0.04148504f, 0.04000034f, 0.01649045f, 0.00998684f, -0.01984517f, 0.02688141f, 
    -0.03791034f, -0.00361513f, 0.00801265f, 0.02510497f, -0.01706760f, 0.04114820f, -0.00702850f, 0.05519070f, 
    0.02802102f, -0.05590127f, -0.02213002f, 0.00691613f, -0.03788660f, 0.00701690f, 0.03337645f, 0.02655782f, 
    -0.03331508f, -0.00318488f, 0.04608462f, 0.02290387f, 0.04346528f, -0.03210580f, -0.02099583f, 0.03499543f, 
    -0.03459950f, 0.03769696f, -0.03626962f, -0.01299239f, -0.04437539f, 0.05146572f, -0.01852103f, 0.00185977f, 
    -0.05200112f, 0.04389712f, 0.05057250f, -0.04192704f, 0.04095897f, 0.02690791f, 0.02625955f, -0.00512290f, 
    -0.04965573f, -0.00584111f, -0.03068432f, -0.00066641f, 0.03827366f, -0.01222183f, -0.04134485f, -0.03565150f, 
    0.00684204f, -0.00124454f, -0.05390713f, 0.00791868f, -0.05084603f, -0.02485218f, 0.01674744f, 0.02549016f, 
    0.03916686f, -0.03415698f, -0.04374873f, 0.05547917f, 0.03278872f, -0.04459072f, 0.03515476f, -0.04131608f, 
    0.02335004f, 0.02659526f, 0.01644932f, -0.02627117f, -0.04245843f, 0.04548090f, 0.04443951f, -0.03306863f, 
    -0.00106364f, 0.01381781f, -0.02756740f, 0.04856193f, 0.01746400f, -0.04773304f, -0.02827516f, 0.02465908f, 
    0.00387251f, -0.02651849f, 0.01769258f, -0.04629824f, -0.01696110f, -0.02105279f, -0.04430028f, -0.02107280f, 
    -0.01233427f, 0.00922968f, -0.02721543f, -0.02223356f, -0.00800296f, -0.01329359f, 0.01554479f, 0.02539097f, 
    -0.05330668f, 0.02507090f, 0.02308822f, -0.03297857f, 0.00597426f, -0.03992629f, -0.03005995f, -0.03507027f, 
    -0.03079341f, -0.02847579f, -0.00570448f, -0.04606681f, -0.02866001f, -0.01418573f, -0.03181255f, 0.01514665f, 
    -0.00308942f, -0.03845188f, 0.03063502f, 0.00885260f, -0.01009665f, -0.03919781f, -0.05506332f, 0.00033363f, 
    -0.00149765f, 0.02708516f, 0.05044603f, -0.01798198f, -0.02164478f, 0.03577919f, -0.01043303f, -0.03842759f, 
    -0.04929155f, -0.00985982f, -0.04134372f, 0.03042143f, -0.03871862f, 0.01874646f, -0.04135609f, 0.04092834f, 
    -0.03158952f, -0.04200213f, -0.02137397f, 0.00814785f, -0.02310591f, -0.04257527f, -0.04183426f, -0.05379483f, 
    -0.03025670f, 0.01198326f, -0.01643144f, 0.04173536f, -0.05398812f, -0.04112084f, -0.04034614f, 0.04321850f, 
    0.05178438f, 0.04597150f, -0.04842640f, 0.00168830f, -0.04198459f, -0.04692701f, 0.03525218f, 0.02898178f, 
    0.05434871f, 0.00535219f, -0.00504569f, 0.02963841f, 0.04475700f, -0.03537795f, -0.00354145f, -0.03661554f, 
    0.02961997f, 0.03109887f, -0.04581543f, -0.00306167f, -0.03653417f, -0.02887651f, 0.03202584f, 0.02212416f, 
    0.01157256f, -0.00000582f, -0.00016425f, -0.04012427f, 0.03266418f, 0.02117073f, 0.04019497f, -0.00326410f, 
    -0.01790003f, 0.02544877f, -0.05452821f, -0.02432408f, -0.02492431f, 0.01531804f, -0.01754177f, 0.01862092f, 
    -0.00330490f, -0.02599353f, -0.03815512f, -0.02021112f, 0.05233462f, -0.05454142f, -0.01483898f, -0.00313141f, 
    0.02313200f, -0.03040020f, -0.05513404f, -0.02802752f, 0.01348669f, 0.04812593f, -0.04825968f, -0.03633548f, 
    0.01934116f, -0.04814262f, 0.01499049f, -0.02981790f, 0.03186845f, -0.01504836f, 0.01015363f, -0.05172321f, 
    -0.43629742f, 0.10872278f, 0.38609281f, 0.29551986f, 0.01390473f, 0.19081099f, -0.08422167f, 0.01188343f, 
    -0.07147591f, -0.06322776f, 0.01352615f, -0.09959878f, 0.15229502f, 0.08299421f, -0.03129642f, -0.12064727f, 
    -0.00906555f, 0.09627561f, -0.07563198f, -0.06792405f, 0.41224876f, 0.33931768f, 0.36359927f, -0.20670332f, 
    0.04226201f, 0.20405453f, -0.05899935f, -0.19014594f, 0.11468996f, 0.10127117f, 0.10263126f, 0.00051096f, 
    0.02562410f, -0.04700493f, 0.09831648f, -0.15147761f, -0.08157093f, -0.02206482f, -0.13375221f, 0.14316007f, 
    -0.03911468f, -0.36543605f, 0.07182741f, 0.36461487f, 0.13704371f, -0.00021310f, -0.17607127f, 0.03458844f, 
    0.00383185f, -0.07110360f, -0.01086741f, 0.07462250f, -0.00394987f, -0.19281909f, 0.00964735f, 0.05285348f, 
    -0.03187721f, -0.08589549f, -0.20184970f, -0.20104310f, 0.29575682f, 0.15151481f, -0.23820257f, -0.03929120f, 
    0.20449919f, 0.05103253f, -0.11279834f, -0.07500678f, -0.01668101f, -0.01518634f, -0.00676273f, 0.10301518f, 
    0.01627942f, -0.15714316f, 0.24534069f, 0.07796089f, 0.01473653f, -0.16676080f, -0.15755162f, 0.22149512f, 
    0.03744749f, -0.16564111f, -0.18981679f, 0.24879630f, 0.31813335f, 0.04428649f, 0.08070722f, -0.15115109f, 
    0.02227514f, 0.02788672f, -0.06984808f, 0.05175884f, 0.05728383f, -0.16866848f, -0.05532092f, 0.18203987f, 
    0.11454937f, -0.11880453f, 0.19921950f, 0.07259537f, 0.30116391f, -0.08498020f, 0.38930386f, -0.24628165f, 
    0.28408295f, 0.09137224f, 0.05382269f, -0.43243891f, 0.18235074f, -0.04029694f, -0.04557242f, 0.16607560f, 
    0.03016191f, 0.00319551f, -0.00323860f, 0.11162075f, 0.02832012f, 0.06398404f, 0.03793470f, 0.06591194f, 
    0.04740407f, 0.32397375f, -0.18225126f, 0.16094719f, 0.13135812f, 0.08923717f, 0.08219739f, 0.06471889f, 
    -0.04902120f, 0.22799119f, -0.08110765f, -0.04554606f, 0.11922541f, -0.05024039f, 0.09037585f, 0.01532638f, 
    0.11469204f, 0.00452499f, 0.21529441f, 0.10202336f, -0.53755754f, 0.20988040f, 0.29203546f, 0.41895956f, 
    0.13382287f, 0.18575610f, 0.11974069f, 0.18667716f, -0.35612565f, 0.03429132f, -0.03284571f, -0.03193787f, 
    0.14237234f, 0.13383061f, 0.06415828f, 0.08827031f, 0.07962521f, 0.05869220f, 0.06596347f, 0.06853805f, 
    0.07171840f, 0.12974003f, 0.02034880f, -0.24462897f, 0.10157595f, 0.08522803f, 0.09317882f, -0.05448633f, 
    0.00695984f, 0.11663337f, -0.13239686f, 0.03179853f, 0.03659789f, 0.11523262f, 0.23568127f, 0.04835372f, 
    -0.03736394f, -0.04341700f, -0.26028067f, -0.00103150f, 0.03448952f, -0.12033312f, -0.07339179f, -0.11183961f, 
    0.07534049f, -0.04262988f, 0.05092042f, -0.05504989f, -0.06634326f, 0.07946646f, -0.08507964f, 0.09685443f, 
    0.09844208f, 0.06631088f, 0.07768863f, 0.11080168f, 0.04881286f, 0.06400061f, -0.14455010f, -0.18207997f, 
    0.45500094f, -0.29538101f, 0.57690597f, 0.01175350f, -0.05244844f, -0.08776543f, -0.09661654f, -0.11964531f, 
    0.10014220f, 0.17952088f, 0.00811770f, -0.02985038f, -0.07117391f, -0.02682688f, -0.00715605f, -0.15676181f, 
    0.11905005f, 0.15385036f, 0.05055259f, 0.21015605f, -0.11619582f, -0.04409938f, 0.07962038f, 0.36350852f, 
    0.07720844f, -0.17191838f, -0.05332964f, -0.05435070f, -0.09317627f, 0.00021212f, 0.03953743f, 0.05337954f, 
    0.10862095f, 0.00443590f, -0.01924998f, 0.11242486f, 0.12814681f, 0.20584403f, -0.02159054f, 0.10038926f, 
    -0.14924118f, 0.00449354f, -0.35413158f, 0.35606202f, -0.13955812f, 0.28728348f, -0.12638268f, 0.10090821f, 
    -0.16879894f, -0.10669151f, -0.11520153f, -0.09752578f, -0.03881894f, 0.00026708f, 0.00005779f, 0.01320846f, 
    0.04302587f, 0.01354699f, -0.17767718f, -0.15122530f, -0.08802789f, 0.06020714f, -0.13991147f, 0.07677855f, 
    -0.05618675f, 0.15721360f, -0.10147478f, 0.09097629f, -0.11353689f, 0.04024559f, -0.18460834f, -0.10025745f, 
    -0.16102278f, 0.06287019f, -0.14951754f, -0.06034106f, -0.20393920f, -0.03706004f, -0.09574603f, -0.42990881f, 
    -0.08158249f, -0.15081523f, 0.16080812f, -0.30658072f, -0.07694923f, 0.04308506f, 0.07536257f, -0.25391811f, 
    0.00503646f, -0.01738326f, 0.07834249f, -0.01810537f, 0.07536785f, -0.13590744f, 0.03692969f, 0.01723922f, 
    0.11500188f, -0.11056416f, -0.00196039f, -0.09300933f, -0.03657780f, -0.04707065f, 0.18850498f, 0.35555810f, 
    0.07656460f, -0.11153140f, -0.10567114f, -0.18097633f, 0.05544093f, -0.16397700f, -0.01956881f, 0.01274063f, 
    0.13736264f, 0.02605327f, 0.05154786f, -0.07273061f, -0.01924414f, 0.02266115f, 0.05081382f, -0.11010960f, 
    -0.14690699f, 0.21606186f, 0.18038613f, 0.28166309f, 0.04187400f, -0.17752880f, -0.08909243f, 0.03261718f, 
    0.09286270f, 0.11738086f, 0.19413106f, -0.07375792f, 0.04856440f, 0.01604201f, -0.01347024f, -0.03713457f, 
    -0.07783590f, -0.05083639f, 0.05369014f, 0.00824653f, -0.04999361f, -0.09416166f, -0.30827102f, -0.15363918f, 
    -0.14633219f, 0.14448641f, -0.09662665f, 0.05776063f, -0.25102487f, -0.12746313f, -0.09066679f, -0.08038023f, 
    0.02581400f, -0.02536595f, -0.03471847f, -0.03086427f, -0.03667637f, 0.05635294f, -0.05385445f, 0.09031722f, 
    -0.34175035f, -0.29623696f, -0.17502891f, 0.11126594f, -0.18639073f, -0.13946909f, -0.21738853f, -0.08310476f, 
    -0.07063722f, -0.12935340f, 0.00218517f, 0.00010141f, 0.03261809f, -0.05205468f, -0.05200761f, -0.02222317f, 
    0.05425105f, 0.08735632f, -0.02383627f, -0.02456977f, 0.25438204f, 0.30269459f, -0.27979067f, 0.07000468f, 
    0.22391513f, 0.08739522f, 0.19443065f, 0.31843731f, 0.00018761f, 0.17678656f, 0.08353920f, 0.10804205f, 
    0.12101061f, 0.04685533f, 0.05259608f, 0.24750921f, 0.17352347f, 0.12892592f, 0.09041239f, 0.06253228f, 
    -0.20882553f, -0.12992530f, 0.02695253f, -0.26450741f, -0.39995387f, 0.11849000f, 0.02806416f, 0.03796034f, 
    -0.04961387f, 0.07562587f, -0.02650998f, 0.02696398f, -0.04969501f, 0.03463674f, 0.00740142f, -0.20763175f, 
    -0.12221589f, 0.06295224f, 0.05170562f, -0.00461012f, -0.06374354f, -0.04388569f, 0.22448266f, -0.18733852f, 
    0.12019867f, 0.02716725f, -0.03988784f, 0.01760732f, 0.02205220f, 0.03118251f, 0.01494014f, 0.08008540f, 
    0.07937018f, 0.08570831f, 0.04282138f, 0.02771969f, 0.04317752f, -0.00143688f, 0.21095029f, 0.12927809f, 
    -0.08691302f, -0.01368635f, 0.45081785f, 0.13171236f, 0.16501211f, 0.09896614f, 0.14955148f, 0.09332209f, 
    -0.01832370f, 0.00114094f, 0.11850889f, -0.04081260f, 0.09745896f, -0.01326566f, 0.10716339f, 0.24873674f, 
    0.09760348f, -0.06119883f, 0.07420260f, 0.07530495f, 0.10834371f, -0.24431756f, 0.70094252f, 0.41638795f, 
    -0.00980162f, -0.13990507f, -0.11770669f, -0.02274776f, 0.17132922f, -0.24055198f, 0.10572832f, -0.00222376f, 
    -0.09981897f, -0.12900600f, -0.05088633f, 0.16397414f, -0.09538607f, -0.12786874f, -0.11802321f, -0.03012579f, 
    0.11783763f, 0.09189754f, -0.01207930f, 0.00703582f, 0.10987876f, 0.01901847f, 0.00988421f, 0.04869616f, 
    0.05556738f, 0.06291836f, -0.02281484f, -0.10712589f, 0.13273515f, 0.02297906f, 0.05836441f, 0.06330026f, 
    0.21634431f, 0.12263738f, 0.06545851f, 0.05422022f, -0.08257418f, -0.04325691f, 0.11884501f, -0.07251883f, 
    0.05909554f, -0.09955957f, -0.13311833f, 0.01785347f, 0.02399516f, 0.04079362f, 0.06432394f, -0.09036484f, 
    0.00835431f, 0.02166706f, -0.00098631f, 0.09210888f, 0.08845186f, -0.07318144f, 0.13894625f, 0.01184922f, 
    -0.09615935f, -0.10876618f, -0.20495245f, -0.32921425f, -0.12530211f, 0.10266493f, 0.16845509f, 0.13997893f, 
    0.08188132f, -0.04246966f, -0.12754036f, -0.07958432f, -0.03191011f, 0.04840065f, -0.12400017f, 0.08512348f, 
    -0.03689120f, -0.06616360f, 0.02712771f, -0.05922081f, -0.10469532f, -0.00899027f, 0.01723907f, 0.08179313f, 
    -0.04686138f, 0.00462109f, -0.08656356f, 0.07090724f, 0.08814906f, 0.01051535f, -0.00288396f, -0.05347724f, 
    -0.03113899f, 0.02347897f, 0.00426159f, -0.03927348f, -0.00464641f, 0.18819302f, -0.04014092f, 0.09642081f, 
    0.47148702f, 0.03855073f, -0.36969119f, 0.17520238f, 0.15861991f, -0.03699036f, 0.06093810f, -0.11012188f, 
    0.10927252f, 0.00054511f, 0.16169612f, -0.01283875f, 0.29572263f, 0.19231749f, -0.02493177f, 0.02531094f, 
    0.11156060f, 0.01824632f, 0.14225259f, 0.19591370f, 0.18640168f, -0.14883405f, -0.14605972f, 0.05674779f, 
    0.06531283f, 0.05763837f, -0.16323254f, -0.02585138f, 0.13386233f, 0.06619916f, 0.17857786f, 0.15253475f, 
    0.22665879f, 0.03784437f, 0.09734948f, -0.06848995f, 0.04334519f, 0.06984876f, 0.16431430f, 0.27597752f, 
    0.11031242f, -0.04412402f, -0.03976559f, -0.13269980f, 0.02213777f, 0.06194394f, -0.24501364f, 0.02400931f, 
    0.01253472f, -0.10283724f, -0.03938470f, 0.09321807f, -0.03887485f, 0.09837291f, 0.02315895f, 0.13052739f, 
    -0.07033801f, -0.10357492f, -0.02226144f, 0.17208764f, -0.14445154f, 0.13505170f, -0.26350182f, 0.17900853f, 
    -0.17507187f, 0.00963113f, -0.08998867f, 0.04303740f, -0.11208350f, 0.14186838f, 0.02629422f, 0.09601774f, 
    0.05982330f, -0.06263170f, -0.03414362f, 0.02240724f, 0.07628497f, -0.00772122f, -0.08939844f, 0.04703567f, 
    -0.07920362f, -0.71881080f, -0.66060996f, -0.38117898f, -0.24462491f, -0.14215845f, 0.04057192f, 0.02108203f, 
    -0.05519184f, 0.09868769f, -0.12219116f, 0.01983784f, 0.07074217f, -0.04166564f, 0.05927425f, -0.03053851f, 
    0.07722998f, 0.04383242f, 0.04919246f, 0.05477908f, -0.07049730f, -0.22556734f, 0.32571858f, -0.04009063f, 
    0.12011058f, -0.00309227f, 0.02029481f, -0.13837178f, 0.14310980f, 0.01271931f, -0.14441486f, -0.11004756f, 
    -0.04153423f, 0.07355140f, -0.03756068f, -0.00074352f, 0.05890968f, -0.02780088f, 0.04511980f, 0.02495070f, 
    -0.38654307f, -0.09622054f, -0.29678121f, 0.06996114f, -0.25558704f, 0.07050120f, 0.25213450f, 0.02532380f, 
    0.07094771f, 0.15303926f, 0.04677463f, 0.09831607f, -0.05571240f, -0.01666340f, -0.04887603f, -0.05736728f, 
    0.04930645f, -0.04167407f, -0.15539664f, -0.08829850f, -0.18244727f, -0.02253019f, 0.29765713f, 0.09337540f, 
    0.06509630f, -0.03312555f, 0.07792911f, 0.09701686f, -0.16164872f, -0.04010951f, -0.02735202f, 0.02903846f, 
    0.10787015f, 0.06580552f, 0.02432176f, 0.10100378f, 0.13793422f, 0.13294592f, 0.05582175f, -0.01039353f, 
    0.15387501f, 0.15503971f, -0.08382135f, 0.00755599f, 0.16440968f, -0.05463837f, 0.07764684f, 0.00919215f, 
    0.18797450f, 0.11866102f, -0.11922970f, -0.03516493f, 0.06211841f, 0.05630627f, -0.05225708f, 0.07917023f, 
    -0.06664142f, -0.11190227f, 0.11926410f, 0.03790458f, 0.49295205f, 0.07442690f, 0.17664450f, 0.10731834f, 
    0.21726589f, -0.09126577f, -0.06382149f, 0.05492534f, 0.10912804f, -0.04265135f, 0.07693031f, -0.00742293f, 
    -0.02883762f, 0.02555023f, -0.07657894f, -0.01942303f, -0.08433052f, 0.08307178f, 0.01135026f, -0.07604225f, 
    -0.45915827f, -0.38093778f, -0.26561373f, -0.37160534f, -0.15866433f, -0.06783356f, 0.10030845f, 0.01506058f, 
    0.04020981f, 0.07851345f, -0.09916084f, 0.03707637f, 0.11639962f, 0.10702545f, -0.17775322f, 0.04286262f, 
    0.06362426f, -0.01755673f, 0.17613770f, -0.08008005f, 0.13577655f, -0.82806009f, -0.57961023f, -0.37602985f, 
    -0.19559795f, 0.03838179f, 0.11931493f, -0.30258375f, 0.19279678f, 0.12376252f, -0.06170633f, 0.07039931f, 
    0.06294474f, 0.13551667f, -0.07564171f, -0.04757566f, 0.00159035f, -0.06152606f, 0.25263348f, 0.04918954f, 
    0.12047987f, 0.09786879f, 0.14997366f, 0.08824542f, 0.06936334f, -0.05522353f, -0.10043834f, -0.07683589f, 
    -0.00255995f, -0.04660065f, -0.08462914f, 0.05438191f, 0.04217153f, 0.05091831f, -0.10717279f, -0.01055409f, 
    0.02970227f, 0.08669845f, 0.01702998f, -0.15743104f, 0.36020297f, 0.09276851f, 0.13451567f, 0.23457240f, 
    0.15774781f, -0.09115606f, -0.08342123f, -0.05630218f, -0.07035133f, -0.09116487f, 0.03812043f, 0.04650751f, 
    -0.05223503f, 0.02992155f, -0.03718865f, -0.08504210f, -0.09077650f, -0.10575851f, 0.03014368f, -0.07880072f, 
    0.71209460f, 0.17000347f, 0.30960125f, -0.01672291f, 0.11748813f, -0.11858671f, -0.16101672f, -0.12298775f, 
    -0.00046416f, -0.06259011f, -0.10994416f, -0.04618886f, -0.01213983f, 0.10933135f, 0.07824937f, 0.17727788f, 
    0.12439572f, -0.02052892f, 0.07615564f, -0.01537589f, -0.02441246f, -0.30120963f, -0.59236133f, -0.02131904f, 
    0.14486572f, 0.14259909f, 0.03416409f, -0.00376009f, 0.11015627f, 0.09997606f, 0.04004344f, -0.01062487f, 
    0.06909558f, -0.06634688f, -0.03824690f, -0.07891024f, -0.04401485f, -0.05913204f, 0.18945092f, 0.13012524f, 
    0.04692032f, -0.22727302f, 0.29730192f, -0.02079822f, 0.05569018f, -0.03290959f, 0.12962778f, 0.05335031f, 
    0.04890883f, -0.02997335f, -0.06051604f, 0.03226130f, -0.05806536f, 0.03099103f, 0.08280104f, -0.07398866f, 
    0.13654685f, 0.13236576f, -0.19461334f, -0.00515202f, -0.12244266f, 0.19052720f, 0.04822342f, 0.08899629f, 
    -0.04552453f, 0.09782097f, -0.01294656f, 0.12712324f, 0.04462379f, -0.01882197f, 0.10805613f, 0.08785227f, 
    0.09857883f, -0.04391542f, -0.10802830f, -0.02134527f, -0.03968339f, 0.11785836f, -0.07711373f, -0.07627649f, 
    0.30740535f, 0.11169783f, 0.26897806f, 0.05742851f, 0.01828029f, -0.05675547f, -0.00683770f, -0.05505627f, 
    0.07291463f, -0.06847913f, -0.01586723f, -0.07888904f, 0.12849967f, 0.04190283f, -0.15829125f, 0.11251669f, 
    0.05074024f, 0.02396521f, -0.00525335f, -0.10432041f, -0.31284860f, -0.17252345f, -0.43780431f, 0.16805579f, 
    0.00580789f, 0.16284996f, 0.24807075f, 0.05945864f, 0.13427463f, -0.04849716f, -0.02374983f, 0.05100237f, 
    -0.05278099f, -0.03240786f, 0.03916592f, -0.02115449f, 0.11231310f, 0.04382408f, 0.16971254f, 0.06571736f, 
    0.52298510f, -0.04259756f, 0.26473570f, -0.01805836f, -0.02306562f, 0.07881001f, 0.08008748f, -0.03566443f, 
    0.22952482f, -0.22814827f, -0.05020542f, 0.03120226f, 0.11837376f, 0.03164003f, 0.14832360f, 0.03406435f, 
    0.01680467f, -0.02131625f, -0.01908441f, 0.02409924f, -0.18834482f, 0.14617482f, 0.02515581f, 0.30281991f, 
    -0.06449951f, 0.18490766f, 0.11270662f, 0.17431322f, 0.05449990f, 0.17142370f, 0.02008052f, -0.05932826f, 
    0.00233008f, -0.22151583f, -0.22821477f, -0.04058111f, -0.01474906f, -0.14391528f, 0.00778007f, -0.12276093f, 
    0.35853854f, 0.34118903f, 0.25057185f, -0.05595588f, 0.03739031f, 0.06580614f, 0.09995319f, 0.15580292f, 
    0.13670467f, 0.24644785f, 0.13169134f, 0.10790005f, 0.14308555f, -0.13036218f, -0.07284608f, -0.02142282f, 
    -0.25291881f, -0.08637831f, 0.18892810f, -0.15946518f, -0.29015085f, 0.20992431f, -0.04777955f, 0.07238482f, 
    -0.17312798f, 0.03319205f, 0.05573751f, 0.00547347f, -0.03934794f, -0.22283529f, 0.02043307f, 0.05362214f, 
    -0.17476907f, 0.00329519f, 0.01436436f, -0.11609618f, 0.03915370f, -0.03268825f, 0.00534042f, -0.04812448f, 
    -0.02745807f, 0.11367941f, 0.20602669f, -0.03410617f, 0.04861969f, 0.04641570f, -0.00451317f, 0.06374452f, 
    0.25636503f, 0.35303476f, -0.04793687f, -0.03420958f, -0.00899886f, -0.05271938f, -0.12743081f, 0.23456502f, 
    0.19883731f, 0.19547057f, 0.08560277f, 0.28654170f, -0.33104831f, 0.07185766f, -0.33173484f, 0.08762864f, 
    -0.26151326f, -0.00523782f, -0.30671793f, 0.09240569f, -0.12562491f, -0.10538706f, 0.07709845f, -0.01826637f, 
    -0.07369988f, 0.00140964f, 0.07104778f, 0.06134721f, 0.13622420f, -0.05535760f, -0.10317378f, -0.00451601f, 
    0.10438278f, -0.16379289f, 0.14479513f, 0.00935934f, -0.15383749f, 0.09760308f, -0.05825287f, 0.02185416f, 
    -0.00737773f, 0.12298045f, -0.08457050f, -0.10964844f, 0.10509782f, 0.07769287f, -0.00408914f, 0.08511036f, 
    0.17487381f, -0.00271689f, 0.00863345f, 0.33147219f, 0.30852640f, 0.03892679f, 0.00072748f, 0.09022943f, 
    0.06548672f, -0.07941195f, 0.10290765f, -0.05344853f, 0.16149417f, 0.09114026f, -0.01731896f, -0.08325773f, 
    0.11997544f, 0.09149919f, 0.10651409f, 0.12477022f, 0.15193178f, 0.17661870f, 0.12373258f, 0.21236333f, 
    -0.22991824f, 0.01576892f, -0.14277966f, -0.06514893f, -0.11385256f, 0.03797274f, -0.05253398f, 0.00146529f, 
    -0.08174694f, -0.10968953f, 0.05795553f, -0.04725726f, -0.10028457f, -0.08773702f, -0.05239341f, -0.09146256f, 
    -0.13291335f, -0.21586354f, -0.09149400f, -0.13530576f, -0.11337338f, 0.12680747f, -0.12191771f, 0.02295245f, 
    -0.01083246f, 0.10519800f, -0.04620640f, 0.06211061f, -0.00458508f, -0.10345437f, -0.06929735f, -0.01545335f, 
    0.10182925f, 0.01812568f, -0.05711154f, -0.08210974f, -0.09653025f, -0.20235395f, -0.27891371f, -0.03084481f, 
    -0.14217404f, 0.41270590f, -0.15405048f, 0.35419405f, -0.07327901f, 0.11176986f, 0.23995352f, 0.15140234f, 
    -0.23591635f, 0.07204076f, 0.06800136f, -0.20495415f, -0.09466049f, -0.02199896f, -0.14134674f, 0.07852703f, 
    0.18741904f, -0.01175257f, 0.05539837f, 0.20645693f, 0.21749850f, 0.08372602f, 0.16922602f, 0.00253694f, 
    -0.03760654f, 0.06842133f, 0.06085350f, 0.00683854f, -0.00883500f, 0.25709021f, 0.01889585f, -0.07493101f, 
    0.11231247f, 0.11099125f, 0.07836103f, 0.02615062f, -0.01781243f, 0.04666615f, 0.12268096f, 0.17877804f, 
    -0.05445054f, 0.09644423f, 0.30124190f, -0.30943322f, 0.15815729f, -0.09699212f, 0.06190088f, -0.01027913f, 
    0.08063927f, -0.24272543f, 0.15205912f, 0.13742964f, -0.01202537f, 0.05356553f, -0.08244691f, -0.01043760f, 
    0.03014588f, -0.08316581f, -0.06293400f, -0.00507815f, 0.13090934f, 0.09502884f, 0.33499897f, -0.26473781f, 
    -0.06773775f, -0.13947430f, -0.02776060f, -0.04961259f, 0.01444025f, -0.09978853f, -0.00023877f, 0.00328374f, 
    -0.00146545f, 0.03303714f, -0.06938824f, -0.02245882f, -0.19503790f, -0.23918037f, -0.14181909f, -0.20921277f, 
    -0.41184020f, 0.13839486f, 0.24474126f, -0.08552030f, -0.17565727f, -0.00799844f, 0.05511829f, -0.06447833f, 
    -0.10947458f, 0.00347123f, -0.00718445f, 0.09320655f, -0.06181152f, -0.07327893f, 0.11497397f, -0.09152146f, 
    -0.03055178f, -0.10020788f, -0.15535423f, -0.29991242f, 0.09598717f, 0.19445276f, 0.26570266f, -0.12458113f, 
    0.19454060f, 0.06804793f, -0.06853221f, 0.14560427f, 0.11090754f, 0.20473494f, -0.08767009f, -0.00308276f, 
    0.08793525f, -0.00744688f, -0.01092842f, 0.13604073f, 0.06387763f, -0.04487277f, 0.07836540f, 0.05203230f, 
    -0.13396062f, 0.06285524f, -0.01565740f, -0.04323227f, 0.06241963f, 0.01109804f, -0.02854689f, 0.08382686f, 
    -0.02831641f, 0.02469584f, -0.05233011f, 0.02634296f, -0.09955645f, -0.10055795f, 0.01374402f, -0.14074098f, 
    -0.03199172f, -0.04287060f, -0.03932674f, 0.00454246f, 0.24524130f, -0.24508232f, 0.33681145f, -0.28372079f, 
    0.13320801f, -0.01517838f, 0.06495269f, -0.08696893f, 0.00593590f, 0.06305439f, 0.02329277f, -0.02418332f, 
    -0.19568127f, 0.03049672f, -0.04891913f, -0.03568727f, -0.00228207f, -0.11362077f, 0.25646251f, 0.06364197f, 
    -0.21747215f, 0.08542272f, -0.49006400f, 0.12745579f, 0.04698476f, -0.07985835f, 0.00081374f, 0.06660794f, 
    0.10907891f, 0.04605820f, 0.08527303f, -0.08427251f, -0.07907476f, -0.06344467f, 0.03210915f, -0.02664434f, 
    -0.10355348f, -0.02306401f, 0.00241945f, -0.15066540f, -0.16271065f, 0.09793393f, 0.18094049f, -0.05926130f, 
    0.30290726f, -0.11308634f, 0.03569592f, 0.04631822f, 0.00826978f, -0.02436504f, 0.15598908f, -0.01533289f, 
    0.08260906f, 0.11589742f, 0.03271861f, 0.03126011f, -0.00058222f, 0.09894405f, 0.12698679f, -0.14380360f, 
    -0.16567534f, -0.05132217f, -0.06830775f, 0.04036746f, -0.30108958f, 0.06773473f, 0.06575130f, 0.01254008f, 
    0.05943754f, 0.08246722f, -0.13948397f, -0.07886130f, 0.04363156f, 0.10484897f, 0.03382902f, 0.08576136f, 
    -0.05488283f, -0.01956461f, 0.06256852f, 0.09664347f, 0.12720059f, 0.00898401f, 0.37965143f, 0.05700540f, 
    0.22072673f, 0.04414357f, -0.04352910f, -0.04755390f, 0.10967582f, -0.04819134f, -0.05685217f, 0.16263030f, 
    -0.01645131f, 0.06917478f, -0.02666568f, -0.03364796f, 0.08718561f, -0.03163489f, -0.00722950f, 0.02797227f, 
    0.09395272f, -0.16184400f, -0.00924516f, -0.06414564f, -0.12296565f, 0.20095237f, 0.10905750f, -0.05714842f, 
    0.07566308f, 0.13684136f, 0.00000163f, -0.09631632f, 0.11476793f, 0.10443328f, -0.08242033f, -0.01285779f, 
    0.03106168f, -0.09223320f, 0.03280878f, 0.22760144f, 0.34339067f, 0.16460118f, -0.03304757f, 0.13825811f, 
    0.04535941f, 0.19074145f, -0.09020904f, 0.03480007f, -0.00171632f, -0.00998818f, -0.02990834f, 0.00263724f, 
    0.07603255f, -0.05468100f, -0.03227097f, -0.01526873f, -0.07814391f, -0.09739360f, 0.08534595f, 0.04442040f, 
    0.15050207f, 0.08671156f, 0.24248727f, -0.15081200f, 0.12842867f, 0.10043095f, 0.03635514f, -0.03844609f, 
    -0.02392111f, 0.06175366f, 0.05856983f, 0.12258305f, -0.06306256f, 0.02622957f, 0.03014844f, -0.14005160f, 
    0.07045878f, 0.00317982f, 0.03530343f, -0.06717509f, 0.18693869f, 0.10073543f, 0.19911224f, 0.06065869f, 
    0.10303862f, 0.01848061f, -0.00292704f, 0.02265933f, -0.01175244f, 0.00715693f, 0.00949123f, 0.11835010f, 
    0.08032871f, 0.00848482f, 0.03519808f, -0.01868800f, 0.00228557f, -0.20208010f, -0.07812265f, -0.06547222f, 
    0.69451565f, -0.13858788f, 0.48551443f, -0.29970330f, 0.17241192f, -0.13239513f, -0.24263361f, -0.09469130f, 
    0.01341380f, -0.11515795f, -0.03478747f, 0.00808089f, -0.00965693f, 0.05127358f, -0.00390573f, 0.05815583f, 
    0.08020502f, -0.14891048f, 0.15215914f, -0.01328541f, 0.09267146f, 0.06094186f, -0.12918524f, -0.17291234f, 
    0.03255095f, -0.00424292f, 0.01950664f, 0.01990828f, 0.04821971f, 0.08485955f, 0.02374956f, -0.10281249f, 
    0.05457847f, -0.03877364f, -0.10956763f, -0.05649255f, -0.08657131f, 0.21522914f, 0.02103775f, 0.15552759f, 
    -0.24573979f, 0.03131026f, 0.34112388f, -0.01381238f, 0.02304994f, -0.07630809f, -0.02161226f, 0.04942041f, 
    0.08482608f, -0.06655397f, 0.15988460f, 0.14936204f, -0.07058235f, 0.03325890f, -0.04569867f, -0.10261733f, 
    0.08993314f, -0.09075624f, 0.05886783f, -0.09156764f, -0.14857881f, 0.28203225f, -0.08875239f, 0.06321845f, 
    0.12183172f, 0.10630644f, 0.07412190f, 0.16618629f, -0.04468999f, -0.05423690f, -0.16098748f, 0.03603333f, 
    -0.06376190f, 0.07334702f, -0.07738441f, -0.29150844f, -0.03461466f, -0.08026867f, 0.02733574f, -0.06839854f, 
    -0.20176530f, -0.02879239f, 0.10347225f, 0.27786243f, -0.14200197f, 0.05200532f, -0.10665327f, 0.15180011f, 
    -0.02800378f, -0.03078332f, -0.05813377f, 0.07547180f, 0.17621589f, 0.22624989f, -0.09719098f, 0.09140370f, 
    0.08678692f, 0.10930534f, -0.14901356f, -0.05061796f, -0.34114698f, 0.22559346f, -0.19833981f, 0.06584171f, 
    0.10689897f, -0.05153983f, 0.01971321f, -0.02447089f, -0.03901858f, -0.13076204f, -0.13539925f, -0.06995167f, 
    0.00805380f, -0.01510438f, 0.06713674f, 0.04159506f, 0.06159732f, -0.02943126f, 0.00609560f, -0.04763642f, 
    -0.46572578f, -0.27722505f, -0.65931016f, -0.52611363f, 0.03151758f, 0.07805447f, 0.09364136f, 0.21984877f, 
    0.16667731f, 0.21624982f, 0.12808675f, -0.04109554f, -0.01998925f, -0.08733526f, -0.02095037f, -0.14585601f, 
    -0.09229471f, -0.06915064f, -0.00908312f, 0.06708903f, 0.21038131f, 0.04862699f, 0.04331960f, 0.07336760f, 
    -0.07132274f, -0.07315041f, -0.12762372f, -0.00709324f, 0.02584822f, -0.10487453f, -0.15968220f, 0.06287554f, 
    0.00790597f, -0.06159787f, -0.17137147f, 0.00121219f, 0.08472518f, 0.16777572f, 0.03251578f, 0.16850127f, 
    -0.04152362f, -0.28661737f, -0.10500365f, -0.23999937f, -0.21228032f, 0.10199252f, 0.14134607f, 0.15858297f, 
    -0.08510560f, -0.13945913f, -0.11966529f, -0.15870091f, -0.13058646f, -0.04669158f, 0.01264777f, -0.03286865f, 
    0.04559946f, 0.15540643f, 0.17089340f, 0.32447109f, 0.60968584f, -0.15692554f, 0.08782572f, 0.28035289f, 
    -0.12523603f, 0.20172097f, 0.05135690f, 0.03260645f, 0.19773701f, 0.19928949f, 0.07841811f, 0.15909185f, 
    -0.00609781f, 0.20292127f, 0.05048235f, 0.25089088f, 0.22237819f, -0.01578811f, 0.27108878f, 0.33144289f, 
    0.23015982f, -0.06471728f, 0.05915409f, 0.01193406f, 0.22464356f, 0.06306430f, 0.06976628f, 0.19132251f, 
    -0.06136876f, -0.10987842f, 0.05384369f, 0.00513767f, 0.09640813f, 0.00374388f, 0.17784791f, 0.14275959f, 
    0.04069940f, -0.16514337f, 0.02558521f, -0.43588990f, 0.18241721f, 0.12365045f, 0.27266774f, 0.35874918f, 
    0.24003802f, -0.12416148f, 0.10977308f, -0.00149675f, -0.08695534f, -0.06726842f, -0.02782733f, -0.09501010f, 
    0.04720334f, 0.08853570f, 0.02553365f, 0.14191739f, 0.02193583f, -0.01105050f, -0.02713311f, -0.01562704f, 
    0.10208257f, 0.26446283f, -0.07898031f, -0.00279533f, 0.27254009f, -0.07950948f, 0.20446883f, 0.10527258f, 
    0.07720695f, 0.04338098f, 0.07262460f, 0.08677422f, 0.09929486f, 0.16700879f, 0.20572971f, 0.07335892f, 
    -0.04881090f, 0.07985116f, 0.22408454f, -0.21496424f, -0.26667875f, 0.19106989f, -0.32636169f, -0.35687432f, 
    -0.05866264f, -0.02200908f, 0.06887922f, 0.25600877f, 0.05253772f, 0.06059688f, 0.03628955f, -0.01266095f, 
    0.01623598f, 0.21780157f, 0.11371646f, -0.02204435f, -0.04701045f, -0.04390842f, 0.05565390f, 0.06919435f, 
    0.08318521f, 0.07362227f, 0.14135718f, 0.29807442f, -0.00320711f, -0.20693603f, -0.07983845f, -0.19129348f, 
    -0.02756303f, -0.06099197f, -0.04279082f, -0.06000130f, 0.04433572f, 0.03569793f, -0.02251401f, 0.09450513f, 
    0.24889508f, -0.04594097f, 0.07636262f, 0.09157986f, -0.03054795f, 0.10190001f, 0.15103751f, 0.14781933f, 
    0.01147144f, -0.17166354f, -0.08660029f, -0.12074229f, -0.13643482f, -0.08584462f, -0.01914293f, -0.08387183f, 
    -0.20842509f, 0.02244963f, -0.05968658f, 0.01677534f, -0.01378489f, -0.08091289f, -0.00567662f, 0.04691814f, 
    -0.00957927f, 0.23945969f, 0.46879196f, 0.10868754f, 0.12876324f, 0.21364403f, -0.05907802f, -0.14349949f, 
    0.01150839f, -0.12873246f, -0.16334435f, -0.00096411f, -0.05661253f, -0.14104097f, -0.07505257f, 0.04916802f, 
    -0.03992567f, 0.13372107f, -0.00832437f, -0.11960497f, 0.12746173f, 0.02076172f, 0.04135202f, -0.07915096f, 
    -0.08061446f, 0.17378396f, 0.02869199f, 0.08442041f, 0.09678998f, -0.10946042f, -0.01670746f, 0.00238379f, 
    -0.07889688f, 0.01232118f, 0.11937449f, 0.10885033f, 0.01318333f, 0.11181073f, -0.01787372f, -0.22228789f, 
    0.34637222f, 0.09487885f, -0.09130821f, 0.03969073f, 0.11982417f, 0.07504217f, 0.12872601f, -0.01519742f, 
    0.15664537f, 0.06616994f, 0.23886034f, 0.07053621f, 0.20099473f, 0.15050976f, 0.11409800f, 0.00929821f, 
    0.03273919f, -0.10257252f, 0.05543338f, -0.01891830f, 0.08737328f, -0.13211273f, 0.19447315f, -0.22803165f, 
    0.08797001f, -0.15520072f, 0.09686605f, -0.20190926f, 0.07046423f, 0.00250275f, 0.27260554f, 0.17572999f, 
    0.08341644f, -0.11576513f, 0.15355451f, 0.07165574f, 0.21365760f, 0.19930650f, 0.20084353f, 0.31930208f, 
    0.03990147f, 0.19552675f, -0.08640409f, 0.05787287f, 0.27549443f, -0.02801371f, 0.01707949f, -0.02433052f, 
    -0.02584307f, -0.04670176f, -0.02138139f, -0.03071013f, -0.07378789f, -0.02474992f, 0.04668354f, 0.13705224f, 
    -0.05245552f, 0.16324209f, -0.04176130f, 0.22203675f, 0.32813072f, -0.11756232f, -0.19570075f, 0.06200936f, 
    -0.18345457f, 0.15943654f, 0.13108681f, 0.19122991f, 0.08749913f, 0.00683380f, 0.07086413f, 0.04432690f, 
    0.04667362f, 0.00854799f, -0.00346199f, 0.06944054f, 0.04091292f, 0.21492390f, 0.03026771f, 0.07595494f, 
    -0.08977063f, 0.26440105f, 0.07945421f, 0.07351625f, 0.09465882f, -0.14462599f, -0.06261460f, 0.17999402f, 
    0.15209341f, 0.24019171f, 0.09939929f, -0.06211208f, 0.10726713f, 0.01639636f, 0.04747292f, 0.06028117f, 
    -0.01598062f, -0.08172931f, -0.09798088f, 0.03845860f, 0.36873934f, -0.30905908f, -0.09701423f, -0.39717060f, 
    -0.02697214f, 0.10308197f, -0.09479269f, -0.02265657f, -0.02602949f, -0.17508574f, -0.01439426f, -0.03405088f, 
    -0.06819790f, 0.09572475f, -0.01843536f, -0.00727700f, -0.03813822f, 0.01592901f, 0.28330261f, 0.13234928f, 
    -0.27141911f, -0.10391378f, -0.34438071f, -0.02268422f, -0.07464316f, -0.22435826f, -0.18749030f, -0.01474604f, 
    -0.03983455f, -0.16949594f, -0.03082088f, -0.03966431f, -0.08708318f, 0.04591897f, 0.04810259f, 0.01318185f, 
    -0.09423913f, 0.16306069f, -0.11719025f, -0.14033465f, -0.13590364f, 0.22851011f, -0.06187790f, -0.10177715f, 
    0.29302511f, 0.08384896f, 0.23481835f, 0.29518473f, -0.03208697f, 0.04727108f, 0.14482956f, 0.09083726f, 
    0.03414431f, 0.16678442f, -0.01060040f, 0.06536455f, 0.17715131f, 0.05332237f, 0.02773261f, -0.27479538f, 
    -0.33881003f, -0.21662518f, -0.15906876f, -0.17101407f, -0.45275003f, -0.05578310f, -0.01719731f, 0.12806772f, 
    -0.01944016f, -0.08417992f, -0.02268811f, -0.08857075f, 0.01980195f, 0.00508354f, 0.08355943f, -0.02677052f, 
    -0.23238647f, 0.20935941f, 0.06263221f, 0.07438098f, -0.23875326f, -0.20840371f, 0.43143687f, -0.21749319f, 
    0.00879833f, 0.09839631f, -0.07517307f, -0.08739921f, 0.15474689f, -0.09878010f, -0.04253297f, 0.09319063f, 
    -0.01900737f, 0.08830813f, -0.00936808f, 0.03455369f, 0.12351662f, -0.07214718f, 0.13996856f, 0.11855847f, 
    0.04755993f, -0.17988394f, 0.24703924f, -0.03128203f, 0.06738798f, 0.15964279f, 0.10790653f, 0.04998674f, 
    0.04641257f, 0.13009809f, 0.10732275f, 0.00737743f, 0.22483809f, 0.07882138f, 0.05543185f, 0.33890012f, 
    0.13676652f, -0.10269457f, 0.05608650f, 0.13103309f, 0.40331480f, -0.02641233f, 0.24491386f, 0.24002707f, 
    -0.00473713f, 0.04587496f, -0.12786251f, 0.04885674f, 0.13430069f, -0.04139913f, 0.10891926f, -0.01137327f, 
    0.04321101f, -0.12470857f, -0.10972850f, 0.24666905f, 0.11263677f, 0.06163313f, 0.02741548f, 0.00545588f, 
    0.17402647f, 0.02701654f, 0.11299784f, -0.13061394f, -0.04474269f, 0.07343818f, 0.04013946f, 0.07727132f, 
    0.05596832f, -0.00442787f, 0.05991104f, 0.04186456f, -0.02863662f, -0.03831272f, -0.03093085f, -0.05977948f, 
    0.23123439f, 0.09367125f, 0.13640833f, 0.01630308f, 0.00720413f, 0.05532786f, 0.08966721f, -0.04532645f, 
    -0.03904285f, -0.03813791f, -0.07764245f, 0.02999615f, 0.03437289f, -0.00297055f, -0.11156137f, 0.04882168f, 
    -0.09819284f, -0.02661462f, -0.03580461f, 0.03983284f, 0.10756151f, -0.14976020f, 0.08134692f, -0.00340539f, 
    0.47816917f, -0.20376788f, -0.05484602f, -0.51136744f, -0.03075985f, 0.00674433f, 0.10155636f, 0.10480563f, 
    -0.01984611f, -0.16563550f, -0.11356614f, -0.09981568f, -0.00609168f, 0.01128172f, -0.10156608f, 0.03534202f, 
    0.13950740f, -0.17953476f, 0.19347262f, 0.10303944f, 0.04390009f, 0.01203669f, -0.22887240f, -0.20400603f, 
    -0.00868445f, -0.06451402f, -0.06428937f, 0.07859198f, -0.03048915f, -0.10485243f, -0.02225754f, -0.03314321f, 
    0.04292559f, -0.04945823f, -0.04997736f, -0.02080612f, -0.06259129f, 0.31111687f, 0.03553137f, 0.09670002f, 
    -0.08777384f, -0.06447522f, -0.05191294f, 0.05109651f, 0.12935814f, -0.05903067f, 0.03353748f, 0.04814811f, 
    0.11406925f, 0.04320446f, 0.14407746f, 0.13524917f, 0.12463962f, 0.14982361f, -0.02081795f, -0.05309981f, 
    0.14238642f, -0.16886997f, 0.00501492f, 0.04699782f, 0.05181527f, -0.14066307f, -0.03344567f, 0.17971008f, 
    0.01615064f, 0.06291927f, -0.14009343f, 0.09738858f, 0.19763030f, -0.09382141f, 0.05306596f, 0.10512383f, 
    0.07458721f, 0.11892897f, 0.02853345f, -0.24181470f, 0.05367271f, 0.08571453f, 0.05892993f, 0.02745778f, 
    -0.09477551f, -0.18583812f, 0.04341202f, 0.00636411f, -0.11606154f, -0.00825001f, -0.26820728f, 0.10126521f, 
    0.13092983f, -0.12962672f, 0.01457431f, 0.17272833f, 0.17954710f, 0.05233889f, -0.05199238f, -0.02927691f, 
    -0.03956366f, -0.02244301f, -0.03346016f, -0.00837073f, -0.31384671f, 0.15483685f, -0.36432630f, -0.02604385f, 
    -0.00705936f, -0.10996417f, -0.11570961f, 0.09098471f, -0.13125776f, -0.22457458f, 0.02104339f, -0.00415807f, 
    -0.00616708f, -0.11380369f, 0.04246663f, 0.04099053f, 0.07556699f, 0.06612476f, 0.02220260f, 0.06531236f, 
    0.16895342f, -0.23269190f, -0.29657987f, -0.33012259f, 0.34433758f, 0.17683780f, 0.02663130f, 0.12513176f, 
    0.24320208f, -0.03143099f, -0.05022914f, -0.01287881f, 0.00129225f, 0.03708628f, 0.11966712f, -0.05136953f, 
    0.04925922f, 0.08081271f, -0.05751535f, -0.00957781f, -0.07805409f, 0.19264120f, -0.00537447f, 0.18847340f, 
    0.00989989f, -0.06785767f, -0.00573436f, 0.04710627f, 0.02339262f, 0.26013967f, 0.08183248f, -0.05255114f, 
    0.03098531f, -0.06119292f, -0.08041377f, -0.01658039f, 0.01856507f, -0.00343205f, 0.02140107f, -0.04455072f, 
    0.05098106f, -0.26466560f, -0.15344085f, -0.08171815f, 0.25625074f, 0.16009243f, 0.08528546f, 0.12291100f, 
    0.19219662f, 0.20768695f, 0.13136451f, 0.01087886f, 0.05339785f, 0.02281599f, -0.03690528f, 0.00755681f, 
    -0.05617180f, 0.05688423f, -0.11108294f, -0.02228494f, 0.47870356f, 0.28003153f, -0.35687143f, -0.14638199f, 
    -0.24747153f, -0.03861749f, 0.04343813f, -0.05175253f, -0.29933971f, 0.12065728f, 0.04137675f, 0.06919745f, 
    0.19918826f, -0.18956356f, -0.01744428f, 0.12970652f, 0.03664348f, 0.11315709f, -0.18872397f, -0.08364744f, 
    -0.00962453f, -0.26934460f, -0.00293717f, -0.00915901f, 0.27437159f, -0.03638549f, -0.01032435f, 0.07382189f, 
    0.16369969f, 0.15408954f, -0.07455188f, -0.07272711f, -0.05141457f, -0.12309196f, -0.03646538f, -0.09384477f, 
    0.15882100f, -0.03402411f, 0.08084497f, -0.11687797f, -0.13427801f, 0.23727250f, 0.36997730f, 0.05928243f, 
    -0.02428518f, -0.16777453f, -0.06937266f, 0.00250036f, -0.08365658f, -0.09988029f, 0.09984104f, 0.00807956f, 
    0.00764137f, 0.10223526f, 0.11466292f, 0.06508544f, -0.01816317f, 0.03191854f, -0.02336784f, -0.00055247f, 
    0.20513487f, -0.18392837f, -0.01581091f, -0.16363333f, -0.06386283f, 0.13784254f, 0.09350151f, 0.01978575f, 
    -0.04152133f, 0.08084423f, -0.10077005f, -0.09498980f, 0.11661346f, 0.01562217f, 0.01912942f, 0.01122062f, 
    -0.03255213f, -0.20059961f, 0.16521809f, 0.04936502f, 0.19173042f, 0.09535985f, -0.10773791f, -0.24080083f, 
    0.21927616f, 0.13376439f, 0.02526311f, 0.09219332f, 0.29635724f, 0.09713216f, -0.03540863f, -0.12409626f, 
    -0.07917988f, 0.07437997f, 0.02782462f, -0.03815340f, -0.05876454f, -0.09669986f, 0.13154215f, 0.08481037f, 
    0.03191675f, 0.28614402f, 0.03160204f, 0.01730996f, -0.10690787f, -0.20870192f, -0.01746500f, -0.02576080f, 
    -0.03827658f, -0.01292735f, -0.02591154f, -0.00122822f, -0.00464184f, 0.02456593f, -0.06471168f, -0.03563269f, 
    0.10814080f, 0.05798145f, -0.03185172f, -0.02604214f, -0.10021767f, 0.22336379f, 0.13426840f, 0.08531923f, 
    -0.03833804f, -0.03250977f, -0.05756386f, -0.09883177f, 0.01467180f, -0.02590711f, 0.07840350f, 0.03198129f, 
    0.01621624f, 0.03310796f, 0.05082398f, -0.05046834f, 0.05562057f, -0.05534404f, 0.06058740f, -0.02158297f, 
    -0.13899139f, 0.13621576f, 0.37965229f, 0.00205649f, 0.09947649f, -0.08990900f, -0.06972646f, -0.24161574f, 
    -0.00740146f, -0.06895078f, 0.13801068f, -0.04964178f, 0.00156101f, 0.06419730f, 0.06572829f, 0.02997752f, 
    0.12108230f, -0.05268271f, 0.03424954f, -0.05819510f, 0.08659475f, -0.07268772f, -0.16023047f, -0.03218738f, 
    0.06387969f, 0.07998710f, 0.00858154f, -0.08341640f, 0.03101753f, 0.17163417f, 0.00990659f, -0.08977491f, 
    -0.11059594f, -0.10041768f, 0.02758925f, -0.04279650f, 0.09729959f, 0.12138841f, -0.09934124f, 0.01365057f, 
    0.19907531f, 0.41756076f, -0.26877317f, -0.51804841f, 0.05393966f, 0.09752131f, 0.01688211f, -0.07878223f, 
    0.01923173f, -0.21640527f, 0.08569486f, 0.11520869f, 0.00266985f, -0.04450856f, -0.06953535f, -0.02753524f, 
    0.09605461f, 0.08239949f, -0.13936062f, -0.18953753f, -0.05585524f, 0.06061476f, 0.30290377f, -0.42903882f, 
    0.23201415f, -0.02975236f, 0.10142410f, -0.00163362f, 0.12895600f, 0.02764646f, 0.08276150f, 0.18705802f, 
    -0.01857048f, -0.03253686f, -0.05408579f, -0.02217693f, -0.05326773f, 0.12648216f, 0.02743397f, -0.14275672f, 
    -0.42985579f, 0.23174064f, 0.14405635f, -0.19398502f, 0.09499498f, -0.14642045f, -0.06396744f, -0.24154325f, 
    0.00932720f, -0.02310846f, 0.26912960f, -0.01120203f, 0.15232204f, -0.16380505f, -0.14748833f, 0.19021584f, 
    -0.06529664f, 0.14059716f, 0.08490585f, 0.03410086f, -0.05251343f, -0.04028806f, -0.11448511f, 0.16999365f, 
    0.22816874f, -0.01818954f, 0.10287067f, 0.12892067f, -0.18190534f, 0.05611053f, 0.02837001f, 0.02821660f, 
    -0.03708301f, -0.02550640f, -0.01705780f, 0.05485268f, -0.00413946f, 0.10756224f, -0.06929153f, -0.04140693f, 
    -0.34594581f, 0.13196003f, 0.16511436f, 0.08921275f, -0.01433078f, 0.03880993f, -0.15535808f, -0.16708511f, 
    0.04226021f, 0.15333641f, 0.02392392f, 0.15498149f, 0.10029016f, 0.10787785f, 0.06834684f, -0.04660295f, 
    -0.00513068f, -0.04842752f, 0.04713704f, 0.02894098f, 0.10931946f, -0.06072091f, -0.42581120f, 0.22645454f, 
    0.20815134f, 0.04103960f, 0.21799077f, 0.25313839f, 0.18035764f, -0.00975691f, 0.01719608f, 0.11012405f, 
    -0.10700639f, -0.07568517f, 0.06382116f, 0.01239607f, 0.01386051f, 0.07538885f, 0.03486138f, 0.00986387f, 
    -0.19156697f, -0.34729028f, 0.18195544f, 0.11936264f, -0.01970984f, 0.01176245f, -0.01854290f, 0.08449122f, 
    0.01346241f, -0.03346938f, -0.02507856f, 0.06130531f, -0.05052815f, -0.10459368f, -0.00960089f, -0.01703155f, 
    0.04273481f, -0.01724438f, 0.09082359f, -0.11764295f, 0.13407840f, -0.05074751f, -0.26483375f, 0.19926816f, 
    -0.10199387f, 0.14870556f, 0.15903820f, -0.19834024f, 0.17312992f, 0.15619861f, -0.02559478f, 0.06113206f, 
    -0.15546025f, 0.18091823f, 0.17958467f, 0.13299479f, 0.15532197f, -0.13752212f, 0.18036167f, 0.15464339f, 
    0.02636097f, -0.21069735f, -0.24441405f, 0.38996017f, 0.51599807f, 0.12158636f, 0.15237497f, 0.13929889f, 
    0.17689168f, 0.00388071f, 0.08296555f, 0.09009282f, 0.02417425f, 0.04752131f, 0.01185815f, 0.10563733f, 
    0.09027687f, 0.07900219f, -0.10522091f, -0.04548198f, 0.22806510f, 0.36663479f, 0.21212052f, 0.03117711f, 
    0.27888811f, 0.04869403f, 0.06133746f, 0.12401172f, 0.03341269f, -0.02727508f, 0.05166315f, -0.00400005f, 
    0.09589912f, 0.02800697f, -0.07756793f, 0.10938239f, 0.00084732f, 0.28809878f, -0.07075057f, 0.04768193f, 
    -0.00489661f, 0.18507801f, -0.08606392f, 0.17403579f, 0.12951650f, 0.01440187f, -0.04019880f, 0.02042407f, 
    0.22469972f, 0.04616491f, 0.03267427f, 0.00043323f, 0.16289993f, 0.05746206f, 0.08128057f, -0.02719760f, 
    0.00402038f, 0.16190228f, 0.15556683f, 0.01612565f, -0.51961088f, -0.13754736f, -0.21081540f, 0.08401071f, 
    0.09748661f, 0.08758905f, 0.02569014f, -0.00281813f, -0.08197537f, 0.15250565f, -0.08185325f, 0.00865309f, 
    0.13122272f, 0.14592703f, 0.07710377f, -0.01779545f, 0.06381182f, -0.00010175f, 0.06849550f, 0.10463259f, 
    -0.00425510f, -0.06208738f, -0.00326962f, 0.07708774f, 0.08743847f, 0.02816855f, 0.16695939f, 0.00028450f, 
    0.00954182f, -0.07055081f, 0.05874176f, -0.06646254f, -0.08329187f, 0.13180465f, 0.02514784f, 0.27931306f, 
    0.00136663f, -0.06867211f, -0.02494399f, 0.02781481f, -0.00726556f, -0.04860925f, 0.02837559f, -0.15637892f, 
    -0.04687865f, -0.04078776f, -0.03071916f, -0.02877255f, -0.11193213f, -0.09926762f, 0.04366400f, -0.06613006f, 
    -0.01970434f, 0.03193013f, -0.07067534f, 0.17211281f, 0.02356946f, 0.13510691f, -0.07133049f, 0.05114380f, 
    0.03737858f, -0.15485539f, -0.30230954f, 0.20853026f, 0.27941582f, 0.13293524f, 0.34616339f, 0.25508630f, 
    0.01104091f, 0.06915434f, -0.06613919f, 0.03972376f, -0.09102605f, -0.06605422f, -0.05822687f, -0.09390608f, 
    -0.10746462f, 0.05238742f, -0.02759268f, 0.06833943f, -0.28163427f, -0.18864611f, -0.11745576f, 0.13597342f, 
    -0.03941249f, -0.10800286f, -0.00953059f, 0.04040991f, 0.02991300f, -0.02402825f, 0.02087635f, -0.02544164f, 
    0.03540179f, 0.13704528f, 0.05907017f, 0.15739164f, 0.09250471f, -0.07475931f, 0.08035567f, -0.03782937f, 
    0.07971668f, 0.22791339f, -0.20870693f, 0.38464373f, -0.16495591f, 0.16391528f, 0.07029767f, -0.06782271f, 
    -0.01753894f, 0.09662808f, -0.10635370f, 0.06075317f, 0.22248794f, 0.14351916f, 0.27942219f, 0.09933790f, 
    0.00905991f, -0.04616951f, 0.27361816f, 0.06425014f, -0.07753580f, -0.21118766f, 0.09200067f, 0.08197301f, 
    -0.06037147f, -0.04614876f, 0.09642283f, 0.00246141f, -0.11167274f, 0.15695299f, 0.05404055f, 0.02187496f, 
    0.08177072f, 0.03638230f, 0.00461393f, 0.14994007f, 0.01010497f, 0.08797838f, 0.00152396f, 0.01779750f, 
    0.18234511f, -0.00563934f, 0.04448417f, -0.03671529f, 0.06869166f, 0.10262669f, 0.20017856f, 0.15321164f, 
    -0.18538111f, -0.03315323f, 0.09088653f, -0.04303652f, -0.05868113f, -0.07110851f, 0.10035450f, -0.07693964f, 
    0.08561793f, 0.21365622f, -0.08177049f, 0.12335113f, 0.06820310f, -0.25996259f, -0.02419666f, 0.16040987f, 
    -0.04552522f, 0.00436322f, 0.01026226f, 0.06185982f, 0.23707415f, 0.01018373f, 0.10712156f, 0.05772879f, 
    -0.05582391f, 0.03262853f, 0.06877506f, -0.03268887f, 0.00878528f, 0.02241323f, 0.04223902f, -0.10777574f, 
    0.43152213f, 0.08322290f, 0.16814590f, 0.08284234f, 0.48026371f, 0.14327651f, 0.15199913f, 0.10480452f, 
    0.05919928f, -0.19504267f, 0.07600270f, 0.21678945f, -0.04538018f, 0.06462972f, 0.15127508f, 0.04335205f, 
    0.04353251f, 0.01997854f, 0.07257762f, 0.00524133f, -0.43300140f, 0.02123011f, -0.14280099f, 0.37985700f, 
    -0.05929136f, -0.00050532f, 0.16134563f, 0.03435867f, -0.14578460f, 0.09703436f, 0.11917227f, 0.06793538f, 
    0.05218294f, 0.00664375f, -0.01574520f, 0.02853985f, -0.03960727f, 0.02587816f, -0.01384175f, -0.04607715f, 
    0.19707145f, 0.17965074f, -0.09093815f, -0.35661003f, -0.05055051f, 0.08327293f, 0.23589773f, 0.08332036f, 
    -0.02947882f, -0.01801386f, 0.02881697f, 0.07681668f, 0.11823768f, 0.02567985f, -0.02685114f, -0.02502754f, 
    -0.03667360f, 0.01571771f, 0.19612442f, 0.17181128f, 0.24552736f, 0.14463878f, -0.26801434f, -0.01513823f, 
    -0.12642346f, -0.07495601f, -0.03794906f, 0.01380992f, -0.10344260f, 0.14151080f, -0.12056115f, 0.03099903f, 
    -0.03898210f, -0.15812787f, -0.00121232f, 0.10325281f, -0.15230292f, -0.02201410f, 0.00666096f, 0.11468168f, 
    -0.00663707f, 0.00534590f, 0.34548512f, -0.14282987f, -0.25656551f, -0.11562111f, 0.04849463f, 0.14314047f, 
    0.05824419f, 0.18463345f, -0.06429456f, -0.10681976f, -0.03356949f, 0.02817391f, -0.09378814f, -0.15948597f, 
    0.11725708f, 0.16728841f, 0.12112522f, 0.06454724f, -0.29058525f, -0.06342461f, -0.24308090f, 0.05280084f, 
    -0.16327281f, 0.01757342f, 0.04719011f, 0.16041960f, -0.13054635f, 0.16543651f, 0.05309944f, -0.14072455f, 
    0.06484890f, 0.06722795f, 0.11838675f, 0.03587008f, 0.05699245f, 0.01960420f, 0.03926578f, 0.00247740f, 
    0.13000953f, -0.12114692f, 0.37374556f, 0.05365898f, 0.11805537f, -0.01824704f, 0.02741543f, 0.07235311f, 
    0.00603466f, -0.12192782f, 0.05135992f, 0.04367860f, 0.04143937f, 0.00899806f, 0.05868025f, 0.00070718f, 
    0.00074663f, -0.01773937f, -0.06869730f, -0.02829887f, 0.29655796f, -0.10688666f, 0.54399347f, 0.03022713f, 
    0.19205800f, -0.08799185f, -0.05059428f, -0.07482735f, 0.24123333f, -0.16208342f, -0.05530556f, -0.00771121f, 
    0.00827001f, -0.08347113f, -0.00436566f, -0.13385996f, 0.01056960f, -0.02143766f, -0.08998512f, -0.03301425f, 
    -0.08810867f, -0.02268679f, -0.10036394f, 0.05433052f, -0.03330944f, -0.03632483f, -0.00908061f, 0.06537659f, 
    0.10079416f, 0.08986919f, 0.18968390f, 0.00747242f, 0.06796323f, -0.05503921f, 0.05963946f, 0.05129372f, 
    0.04423138f, 0.04263935f, 0.10037907f, 0.04420909f, -0.24569620f, -0.05289692f, -0.02822598f, -0.02177903f, 
    0.07228339f, 0.10654579f, -0.01224830f, 0.05642582f, 0.05730193f, 0.10547107f, 0.11594862f, -0.01254266f, 
    0.02662160f, 0.04059132f, 0.01095264f, 0.05878563f, 0.04043097f, 0.02362732f, 0.07834728f, 0.10070600f, 
    -0.61237270f, 0.02257975f, -0.22641599f, 0.13932204f, -0.07561387f, 0.15015793f, 0.22994117f, -0.02418550f, 
    0.06012382f, 0.12277552f, 0.08643840f, 0.01769051f, 0.10904495f, 0.06092962f, -0.02229489f, 0.03116402f, 
    -0.04242291f, 0.05466923f, 0.11032148f, 0.04768870f, 0.07356495f, -0.03563879f, 0.10412265f, -0.07701791f, 
    -0.10501663f, 0.01555281f, 0.16592894f, 0.01239082f, 0.06434810f, 0.09144191f, -0.04778589f, -0.07259817f, 
    -0.03375223f, 0.00157188f, -0.00516593f, -0.10704859f, -0.13374762f, -0.10132398f, 0.01170772f, 0.03893908f, 
    0.44051352f, 0.35164088f, -0.18423466f, -0.20080836f, 0.24040841f, 0.00922184f, 0.01312439f, -0.13359380f, 
    0.12042203f, 0.03432263f, -0.04204333f, 0.10863505f, 0.05909351f, 0.01498003f, 0.02939741f, 0.04550652f, 
    -0.02445430f, 0.03596437f, 0.07912455f, 0.07293678f, 0.20984492f, 0.01122585f, 0.11341791f, -0.26738214f, 
    0.27022016f, 0.07908491f, 0.00930557f, -0.19664848f, 0.10114326f, 0.04592033f, 0.15618202f, 0.05307557f, 
    0.16831596f, -0.04024389f, -0.05842315f, 0.04922384f, 0.07283436f, -0.02893668f, 0.18289959f, 0.11638185f, 
    -0.17138775f, 0.06628408f, -0.08274715f, -0.15391035f, 0.20016143f, -0.03423258f, -0.06531547f, -0.05033744f, 
    -0.12567000f, 0.05386192f, 0.12149722f, 0.07186306f, -0.03792787f, 0.04403834f, 0.11040814f, 0.03705738f, 
    -0.05728912f, -0.26793939f, 0.05932386f, 0.06558966f, -0.01443406f, 0.21180920f, -0.00857980f, -0.12172733f, 
    -0.14127608f, -0.02831283f, 0.15281186f, 0.10273838f, -0.09098126f, 0.21373487f, -0.03279233f, 0.02774431f, 
    -0.03866569f, -0.00244177f, -0.10114487f, -0.06976405f, -0.05822818f, -0.14421932f, 0.10865057f, 0.12562846f, 
    -0.02186018f, 0.01004479f, -0.04470349f, -0.00637823f, -0.03263748f, -0.04686908f, 0.00146339f, -0.03946089f, 
    -0.05042981f, 0.04509278f, -0.01998721f, 0.02313427f, -0.03184264f, 0.02442499f, -0.05359415f, -0.03984280f, 
    -0.02988919f, -0.00387820f, -0.04142603f, 0.04377051f, 0.01248856f, 0.03848064f, -0.01333743f, 0.01118050f, 
    0.03740306f, 0.02778335f, 0.00229707f, -0.05372969f, 0.02216503f, -0.03149932f, -0.04168121f, 0.03708731f, 
    0.04313706f, 0.03481067f, -0.03866080f, -0.06432363f, -0.03452509f, -0.04548869f, -0.00768175f, 0.04705590f, 
    -0.00587318f, 0.00621835f, 0.01626641f, -0.03729137f, 0.03388906f, -0.03442213f, -0.00740868f, 0.00045759f, 
    -0.01274007f, -0.05638789f, 0.02889846f, -0.06504310f, -0.04595565f, 0.03505233f, 0.02818311f, -0.06007360f, 
    0.00313926f, -0.03902316f, -0.05950025f, -0.06125475f, 0.00073315f, 0.04814850f, -0.00093604f, -0.04034419f, 
    0.00791715f, -0.00738598f, -0.04269130f, -0.03101693f, -0.01658142f, 0.02787077f, -0.03850386f, -0.01701928f, 
    -0.01828934f, 0.01251835f, -0.02501986f, 0.00828678f, 0.04185782f, -0.05662289f, -0.06101017f, -0.03233467f, 
    0.01165018f, 0.04350720f, -0.03366220f, 0.03090733f, 0.04373040f, -0.02404841f, -0.01543797f, -0.04457121f, 
    0.02926338f, -0.05733776f, 0.03971929f, -0.05183373f, 0.04442795f, 0.04495978f, 0.01138420f, -0.02331089f, 
    0.03359064f, 0.00124173f, -0.04924867f, 0.02175583f, -0.06278004f, 0.02650717f, -0.01004483f, -0.03677628f, 
    -0.02532914f, -0.02000544f, -0.05323203f, -0.02143948f, -0.03529472f, -0.02830837f, -0.01525032f, 0.01820284f, 
    0.03109469f, -0.04958037f, 0.03853337f, -0.00170863f, -0.01272416f, -0.02771025f, 0.02995285f, -0.03236945f, 
    -0.04441138f, -0.00523890f, 0.02551133f, 0.01711309f, -0.02540312f, -0.01462755f, -0.06137376f, 0.02354786f, 
    -0.01053252f, 0.02599905f, 0.01869665f, -0.03389600f, -0.00801011f, 0.00614933f, -0.06603912f, -0.03681389f, 
    0.01003197f, -0.01931470f, 0.01632795f, 0.03810515f, -0.00536091f, 0.02404431f, -0.01811954f, -0.00004987f, 
    0.01857843f, 0.01614373f, 0.02636830f, 0.00392374f, -0.00141899f, -0.00677727f, -0.01807640f, -0.05232644f, 
    -0.01726345f, 0.00804883f, -0.04355837f, 0.00257147f, -0.05051826f, -0.04745389f, 0.02050955f, -0.05364131f, 
    0.01618097f, 0.02514158f, -0.02231601f, -0.06221939f, -0.01994069f, 0.01096024f, 0.03915635f, 0.02081170f, 
    -0.02055406f, -0.04366663f, -0.01901341f, -0.05365998f, -0.01358908f, -0.02201191f, 0.00682615f, 0.03826652f, 
    -0.03303154f, -0.00019159f, -0.04903786f, 0.04326477f, -0.04201210f, 0.02250441f, -0.01863705f, -0.03889548f, 
    -0.03198218f, -0.02972895f, 0.04679672f, -0.00050552f, -0.02043053f, 0.01192871f, -0.03875099f, 0.02758723f, 
    0.00694042f, 0.00956794f, -0.02878575f, 0.00449304f, -0.05509238f, -0.01795148f, 0.00306996f, -0.03877557f, 
    -0.05369122f, -0.00717123f, 0.01232198f, 0.03535032f, 0.00634169f, 0.00298860f, 0.02984924f, -0.03907110f, 
    -0.00049006f, -0.05261029f, 0.03866077f, 0.02187569f, -0.03903015f, -0.04441809f, -0.05118800f, 0.03577725f, 
    -0.03802247f, 0.02154423f, 0.04147389f, -0.05683641f, -0.05154423f, 0.04587632f, -0.03025562f, 0.04083909f, 
    0.02638519f, -0.01556312f, 0.02411532f, 0.00253560f, 0.02415931f, 0.01845101f, 0.01343575f, -0.02283634f, 
    0.00037386f, -0.03635808f, 0.02774172f, -0.04224813f, -0.05773633f, -0.01723710f, -0.03404709f, -0.02820577f, 
    0.00499361f, -0.00362896f, 0.02079253f, 0.02522594f, 0.02010169f, -0.01201867f, -0.03247488f, 0.02482867f, 
    0.01560525f, 0.02563773f, 0.02413876f, 0.01134596f, 0.04097314f, 0.01251418f, -0.04198301f, 0.03840361f, 
    0.03320428f, -0.05005702f, 0.04408310f, -0.04467444f, -0.05054513f, 0.04317251f, -0.00839595f, 0.04189903f, 
    -0.04367940f, 0.03174504f, -0.05807102f, 0.04907292f, -0.03807160f, 0.03961387f, 0.02862408f, 0.01029208f, 
    0.03525413f, -0.02129702f, 0.01018707f, -0.03984275f, 0.00744027f, 0.00379219f, 0.04349194f, -0.05388875f, 
    -0.00128942f, 0.00537205f, 0.03970615f, -0.03847525f, -0.01751578f, -0.00296091f, -0.02874774f, -0.03057986f, 
    0.00965897f, -0.05931293f, -0.05138719f, 0.03855123f, -0.02442687f, -0.04704533f, -0.05441038f, 0.02336821f, 
    0.00616354f, 0.04803257f, -0.04950397f, 0.00141156f, 0.04060378f, 0.01282765f, -0.01795104f, -0.01813921f, 
    0.01895545f, -0.02015160f, 0.02564434f, -0.01698922f, -0.03287720f, -0.02181961f, -0.03779184f, -0.02653812f, 
    0.03884449f, 0.00384626f, -0.02740775f, 0.04471471f, -0.04725781f, -0.04055531f, -0.00650385f, 0.01327848f, 
    -0.13124527f, 0.04206455f, -0.38108447f, -0.21494912f, -0.03229581f, -0.03760109f, 0.21357608f, 0.20769964f, 
    0.00142281f, 0.02878181f, 0.20904829f, -0.10948019f, -0.07790382f, -0.15848400f, -0.18481307f, -0.03475717f, 
    -0.04271600f, 0.07305749f, 0.00462677f, 0.04848952f, 0.02185910f, 0.19515021f, -0.03945568f, -0.04619963f, 
    -0.13212501f, -0.18612388f, -0.15338017f, -0.16254188f, -0.09835447f, 0.05866295f, 0.01281647f, 0.06989084f, 
    0.04858826f, 0.04506819f, 0.00535192f, -0.02272959f, 0.11612789f, 0.12003990f, -0.14017494f, 0.05958561f, 
    0.29089540f, 0.18801476f, 0.20586474f, -0.14175190f, -0.14898230f, 0.08644875f, 0.03305027f, -0.00558181f, 
    -0.00988036f, -0.06300637f, -0.01123088f, -0.16400051f, -0.00127443f, 0.04818235f, 0.10673109f, 0.00311791f, 
    0.12157354f, 0.14897239f, 0.10272595f, 0.13633066f, 0.21985264f, -0.14807436f, 0.05478033f, 0.11280645f, 
    0.07035603f, 0.24525368f, -0.03169719f, -0.00612403f, 0.01758867f, 0.19494556f, -0.05716847f, 0.22394103f, 
    -0.00757357f, -0.03317465f, 0.08270042f, -0.03095815f, 0.05617590f, 0.04072503f, 0.03224803f, 0.37761545f, 
    0.24999490f, 0.19640492f, 0.20690325f, -0.14426443f, -0.17406721f, 0.09616610f, -0.15641461f, -0.21334538f, 
    -0.20954034f, -0.21298976f, -0.00275715f, 0.06086344f, 0.01581164f, 0.02801848f, 0.08385289f, 0.00545101f, 
    -0.05086129f, -0.11418412f, 0.09283325f, -0.36257944f, 0.10052534f, -0.23709026f, -0.18337265f, 0.08141171f, 
    -0.12297454f, 0.05949080f, 0.09761367f, -0.09307639f, -0.09023257f, 0.04667134f, -0.11436106f, 0.04011115f, 
    0.10594442f, 0.09747838f, 0.06924622f, -0.02511782f, -0.06191335f, -0.25450364f, -0.00446006f, -0.01511987f, 
    -0.05027059f, 0.34188864f, 0.11764214f, 0.01061504f, 0.17516592f, -0.08375935f, -0.09288191f, 0.03452338f, 
    -0.03657159f, -0.03723840f, 0.09441127f, -0.05401843f, -0.05857153f, 0.04168458f, 0.21604082f, 0.05686059f, 
    -0.09275308f, -0.08716574f, 0.04307167f, -0.22325207f, 0.13013239f, 0.35139591f, 0.09462692f, -0.27161899f, 
    -0.04648437f, -0.10044352f, -0.10164433f, 0.22215346f, 0.10756727f, -0.08308001f, 0.14454229f, -0.03289705f, 
    -0.10499038f, -0.00807340f, 0.05906866f, 0.02473833f, -0.12576234f, -0.02089095f, -0.01874004f, -0.14167257f, 
    -0.00073358f, -0.12547104f, -0.12122019f, 0.09719592f, 0.04706905f, -0.05780345f, -0.07504229f, -0.17284548f, 
    0.00764333f, 0.05743929f, -0.12028272f, 0.08523416f, 0.05056524f, 0.05123458f, -0.02213078f, -0.08725052f, 
    0.15167871f, -0.00312147f, 0.05743875f, 0.17235774f, -0.14209253f, -0.14229979f, -0.11249588f, -0.02291007f, 
    -0.06924657f, -0.02897675f, -0.03577649f, -0.08148854f, -0.05309736f, 0.02934749f, -0.09638762f, -0.09466445f, 
    0.08990927f, 0.06944022f, 0.10007883f, -0.06979966f, 0.04077715f, -0.04228043f, -0.02380864f, 0.08466997f, 
    -0.36536977f, 0.08931994f, 0.10315000f, -0.11412684f, -0.53379822f, 0.17274505f, -0.14275335f, -0.25883085f, 
    0.01931481f, 0.00337794f, -0.00871519f, 0.06674963f, 0.03121725f, 0.01624680f, 0.03946830f, -0.07891577f, 
    0.00597274f, 0.24064229f, -0.04363484f, -0.15170172f, 0.23948520f, 0.16834360f, 0.35013422f, -0.03896250f, 
    0.00790464f, 0.23811774f, -0.05671730f, 0.04854173f, 0.15089090f, -0.09454278f, 0.08234478f, -0.05182125f, 
    0.03425039f, 0.01335635f, 0.09161077f, 0.00897037f, -0.01969565f, 0.07217398f, 0.15619336f, -0.12238135f, 
    -0.09947952f, -0.09887865f, -0.10512713f, -0.12809786f, 0.09878890f, 0.01485817f, 0.03462422f, 0.05504885f, 
    -0.02425512f, 0.20539498f, 0.14423682f, -0.03721987f, -0.08455089f, 0.07702038f, 0.01937477f, -0.07081891f, 
    0.05375639f, -0.08545019f, -0.01652485f, 0.04721069f, -0.01517890f, 0.06478254f, 0.02206457f, -0.16424388f, 
    0.01484039f, -0.09061775f, 0.10133412f, -0.02848928f, 0.03890229f, -0.03995323f, 0.22567889f, -0.15575948f, 
    0.10367914f, -0.02707211f, 0.14569332f, 0.04561165f, 0.11738575f, 0.04433414f, -0.00619677f, 0.07121601f, 
    -0.02619546f, -0.05020282f, -0.25889602f, -0.18901041f, 0.03153315f, -0.08075459f, -0.04026191f, -0.03601591f, 
    -0.02296382f, -0.10124560f, -0.09304310f, -0.09397627f, -0.01995757f, 0.19020556f, 0.01445804f, 0.09958545f, 
    -0.15750317f, -0.06364279f, -0.01606541f, 0.10396445f, 0.33144334f, 0.11092008f, 0.05611459f, -0.05663794f, 
    -0.13176353f, 0.15518120f, 0.04046118f, 0.01232287f, -0.04382252f, 0.07746314f, 0.11638448f, 0.01471468f, 
    0.02180941f, 0.07266230f, 0.05084268f, 0.07220312f, -0.01506138f, 0.08495405f, 0.03969538f, 0.11787339f, 
    0.15143631f, -0.20762692f, -0.43866584f, -0.40555647f, 0.17915741f, 0.14421454f, 0.11418238f, 0.32787701f, 
    0.15920481f, -0.05536380f, -0.07612015f, -0.06908120f, -0.07161586f, -0.14942500f, -0.00065562f, -0.00380767f, 
    -0.04486050f, 0.07280240f, -0.08516359f, 0.01631317f, -0.12421918f, 0.15089995f, 0.30207914f, 0.02873881f, 
    -0.11631314f, -0.01472110f, -0.07246323f, -0.15510151f, -0.07195818f, 0.05969140f, 0.02291773f, 0.02833582f, 
    0.05873160f, 0.03012481f, -0.01902207f, 0.05253373f, 0.07169729f, 0.10016721f, -0.05450593f, 0.02857413f, 
    0.15835997f, 0.12390897f, -0.29108679f, -0.14593913f, 0.03726887f, 0.13445805f, 0.15744132f, 0.22067314f, 
    0.13075937f, 0.12097408f, -0.00971052f, 0.05250675f, 0.10579244f, 0.08637161f, -0.04060981f, -0.04136221f, 
    -0.01506980f, 0.01922591f, 0.00119261f, 0.27421474f, 0.40966246f, 0.09169349f, 0.12031179f, -0.03317878f, 
    -0.08570942f, 0.05130353f, -0.05858441f, 0.06832856f, -0.12569553f, 0.00126843f, 0.10947697f, 0.06752095f, 
    0.17979115f, -0.16895162f, -0.07193717f, 0.13722612f, 0.00241342f, 0.17930792f, -0.07316408f, -0.10960682f, 
    0.13795649f, -0.02367779f, 0.20654276f, -0.13471965f, -0.03320132f, -0.07517829f, -0.05081475f, 0.08587538f, 
    -0.02177841f, 0.04940035f, -0.08685539f, -0.04949555f, -0.00219786f, -0.04652947f, 0.02477475f, -0.07313058f, 
    0.01228406f, -0.02848734f, 0.05619938f, -0.19003743f, -0.09140368f, -0.02056939f, 0.18425137f, 0.23467118f, 
    0.02569872f, -0.11940622f, 0.02428624f, -0.02188351f, -0.08114101f, 0.02940051f, -0.02286598f, -0.00407898f, 
    -0.05856595f, 0.10443279f, 0.09555010f, -0.01656470f, -0.02054190f, -0.10786831f, 0.02408637f, -0.14218681f, 
    0.17041078f, -0.14620534f, 0.10542700f, -0.16019727f, -0.07519709f, -0.00446418f, 0.16269690f, 0.00837070f, 
    -0.07519744f, 0.01046898f, -0.00549190f, -0.02480010f, 0.00792251f, 0.15052275f, 0.05611454f, 0.04661110f, 
    -0.04353330f, -0.10426179f, -0.03715638f, -0.04838458f, 0.38184312f, 0.32489192f, -0.01852478f, -0.26348525f, 
    0.01203390f, 0.08620612f, 0.03664845f, 0.20282887f, 0.14449553f, 0.09067695f, 0.01886243f, -0.08864039f, 
    -0.07931817f, 0.03929309f, 0.08584303f, 0.03282119f, -0.05997908f, 0.00527971f, 0.09623423f, 0.01875052f, 
    0.03744316f, 0.09206702f, 0.13722435f, 0.06584175f, -0.02822532f, -0.11276300f, -0.06700198f, -0.05687704f, 
    -0.02177505f, 0.00937115f, 0.04905987f, 0.07235728f, 0.07612091f, -0.00243218f, -0.01264185f, -0.18378685f, 
    0.08553717f, -0.01219371f, 0.09679449f, -0.05633567f, -0.05905680f, 0.16866231f, 0.05537886f, 0.12709042f, 
    0.09192684f, 0.01733878f, -0.09403961f, -0.00842157f, 0.01193253f, -0.05167341f, 0.04379778f, -0.01350320f, 
    0.03016357f, 0.05984637f, 0.04045347f, -0.07323854f, -0.02466864f, -0.08078873f, 0.06318144f, -0.03619011f, 
    -0.20482439f, 0.09597348f, 0.60834432f, -0.05984490f, 0.08811882f, -0.02680236f, -0.13835984f, -0.20329827f, 
    0.00742446f, -0.12660192f, -0.02937489f, 0.02307147f, 0.03251756f, 0.05683699f, -0.01529642f, 0.01589504f, 
    -0.01587719f, 0.00052755f, -0.00155444f, -0.07730865f, 0.18948409f, 0.15708204f, 0.06808192f, -0.24666168f, 
    -0.00069743f, 0.20029178f, 0.04118769f, 0.05570726f, 0.07712304f, 0.15707952f, 0.00687331f, -0.07040733f, 
    0.02109745f, -0.02706850f, -0.03352600f, -0.04000977f, -0.04782894f, 0.14217427f, -0.13833457f, 0.01278916f, 
    0.11103322f, 0.16041449f, 0.00768729f, -0.41808301f, 0.17033660f, -0.00167558f, 0.11705709f, -0.02351195f, 
    0.11337829f, -0.11223168f, 0.05721554f, 0.04412999f, -0.14150217f, 0.00277866f, -0.09223276f, -0.07485804f, 
    0.01529270f, 0.09522161f, -0.16992880f, -0.10448177f, 0.02848618f, 0.24496210f, 0.19634388f, -0.27715841f, 
    0.17308427f, -0.00969141f, 0.09937119f, -0.00617299f, 0.11811262f, -0.07112856f, 0.04282083f, 0.05872697f, 
    -0.07417186f, -0.05210277f, 0.02533455f, -0.15705200f, 0.05121488f, 0.06015546f, 0.07948063f, 0.02870718f, 
    -0.26143438f, 0.15053590f, 0.07873100f, -0.00445177f, 0.10648388f, -0.19372480f, -0.02011150f, -0.21114057f, 
    0.02680882f, -0.00322244f, 0.08964682f, -0.02251845f, 0.06399083f, 0.01672030f, -0.07991429f, 0.09115697f, 
    -0.05633708f, 0.09055139f, 0.07578484f, 0.00652662f, 0.00539712f, 0.12963574f, -0.02425528f, 0.00191389f, 
    0.05373089f, 0.08456317f, 0.02614184f, 0.09334923f, -0.04106188f, 0.10656498f, 0.01533805f, -0.02445911f, 
    0.08321975f, -0.00598003f, -0.07997210f, 0.01597618f, -0.00786042f, 0.07138796f, -0.07288769f, 0.05296897f, 
    -0.00864044f, 0.04065670f, 0.02009255f, 0.03065572f, -0.05414782f, -0.04127041f, -0.02944416f, 0.00417157f, 
    -0.01413607f, -0.02752866f, -0.02759356f, -0.05512524f, 0.00358420f, 0.00794711f, -0.02091542f, -0.01195554f, 
    -0.02950847f, -0.01110370f, 0.04039603f, -0.03176350f, -0.00488347f, 0.01844025f, 0.03192833f, 0.01284973f, 
    -0.03813030f, -0.02056132f, 0.03251906f, 0.01322322f, -0.05377172f, -0.00160161f, -0.01409003f, -0.00893256f, 
    0.01505391f, 0.03374972f, -0.03114204f, -0.04842106f, -0.04402736f, 0.01770140f, -0.01376613f, 0.04265480f, 
    0.04774842f, -0.01407255f, 0.03606723f, -0.03505348f, 0.02587512f, 0.03194802f, 0.02561570f, -0.05912619f, 
    -0.01840186f, 0.04545022f, -0.03724764f, 0.04341535f, 0.00224586f, -0.00307438f, -0.03660870f, -0.00788778f, 
    -0.05498195f, 0.01384335f, -0.05016691f, 0.04796540f, 0.01480088f, -0.01350259f, -0.01312165f, 0.04011631f, 
    0.03672687f, -0.02713592f, 0.00831097f, -0.00594373f, -0.02005927f, 0.00499153f, -0.04873226f, -0.02695001f, 
    -0.02252355f, -0.04392712f, 0.01204165f, -0.04214503f, -0.02925683f, 0.01007882f, 0.04481972f, -0.01117345f, 
    0.02803485f, 0.02773889f, -0.00115026f, -0.02202512f, -0.01765911f, -0.00179906f, -0.01550576f, -0.03377047f, 
    -0.03393985f, 0.04089212f, -0.00554687f, 0.04505229f, 0.01464265f, -0.04879354f, -0.00139793f, -0.01328458f, 
    -0.02578153f, 0.02395957f, -0.02762609f, 0.04051770f, 0.02306276f, -0.03932566f, -0.01609185f, -0.01535761f, 
    0.01867748f, -0.03194391f, 0.00771669f, -0.01447804f, 0.00344480f, -0.00695077f, 0.00777130f, -0.03911456f, 
    0.00991738f, -0.01304807f, 0.00717987f, 0.02567781f, 0.02215729f, 0.05368686f, -0.02457128f, -0.04675783f, 
    0.01093111f, 0.04342751f, -0.03398819f, 0.03045137f, -0.02482889f, 0.02304600f, 0.01653184f, -0.05971866f, 
    0.03858220f, -0.04086818f, -0.06080424f, -0.02070660f, 0.04805730f, -0.02517635f, 0.03596252f, -0.00708708f, 
    -0.04131273f, -0.03344321f, -0.00041065f, -0.05487348f, -0.01823659f, 0.01510349f, 0.00603417f, -0.05673734f, 
    -0.02216379f, 0.04970352f, -0.04326126f, 0.04503094f, -0.04576210f, -0.05375932f, 0.03021405f, 0.04178670f, 
    0.00336175f, 0.01462395f, -0.02250920f, -0.00414570f, -0.00366820f, -0.00087879f, 0.02931506f, 0.03421384f, 
    0.04211995f, 0.01688986f, -0.04523343f, -0.01318973f, -0.05109809f, -0.01141314f, 0.02847938f, -0.05331735f, 
    -0.04561489f, 0.04637403f, -0.04899375f, 0.04585107f, -0.05324221f, -0.02570700f, -0.03905310f, 0.04060880f, 
    0.04722782f, -0.03717417f, -0.03921663f, 0.05266362f, -0.00091672f, -0.04320677f, 0.03886587f, 0.00235691f, 
    -0.05103348f, -0.02510038f, -0.01485402f, 0.03188284f, 0.01960863f, 0.03757109f, 0.03001367f, 0.01393171f, 
    -0.03606804f, 0.05547498f, 0.00563759f, 0.03732280f, -0.02958914f, -0.00164691f, 0.00213091f, -0.00415654f, 
    -0.05359865f, -0.01267483f, -0.05449455f, -0.05056227f, -0.02764724f, -0.01227559f, -0.01832920f, -0.04401142f, 
    -0.00943982f, -0.00149296f, 0.00284606f, -0.03344685f, -0.04536695f, -0.00795218f, -0.00012388f, -0.02676391f, 
    0.02820128f, 0.03952765f, -0.03039341f, -0.00399937f, -0.05692659f, -0.00573002f, 0.02931743f, -0.03991649f, 
    -0.04684259f, 0.00339326f, 0.01634643f, -0.06030662f, -0.03831986f, 0.03166090f, 0.00198273f, -0.04050547f, 
    -0.00940331f, 0.01723184f, -0.01473682f, 0.01996686f, 0.00929587f, -0.05896591f, -0.01270251f, -0.05384128f, 
    0.00121993f, -0.02886919f, 0.04253167f, -0.00530667f, -0.01435948f, -0.01014861f, 0.05020195f, -0.00656228f, 
    -0.03082093f, -0.05082437f, -0.02450682f, -0.01580295f, 0.00137764f, -0.05067170f, -0.01502909f, -0.05476597f, 
    0.03595185f, 0.03926173f, -0.02359872f, 0.00271992f, 0.00119290f, -0.02790674f, 0.01019183f, 0.04329119f, 
    -0.02753660f, -0.02868730f, 0.03673510f, -0.01136989f, -0.01235001f, -0.04048135f, 0.01576128f, -0.00362446f, 
    0.04717125f, 0.05068231f, 0.01880304f, 0.02673804f, -0.02530043f, -0.01203317f, -0.00499875f, -0.04144041f, 
    0.00284955f, 0.05261341f, 0.04913035f, 0.00661653f, 0.00403040f, 0.00107018f, 0.02821287f, -0.03656533f, 
    0.01850539f, -0.01637352f, -0.00520680f, -0.02408371f, -0.04481480f, 0.01382980f, -0.05145283f, -0.00672141f, 
    0.01131526f, -0.01086798f, -0.03792512f, 0.00495351f, -0.03191745f, 0.04060748f, 0.02855326f, -0.04191242f, 
    -0.04988914f, -0.01230359f, -0.05877303f, -0.01725654f, -0.00983173f, 0.02106150f, 0.00758267f, 0.03657298f, 
    0.04430957f, -0.02464266f, -0.04713146f, -0.03913046f, -0.03541395f, -0.04288780f, -0.03332069f, 0.00129940f, 
    -0.03723782f, 0.03619602f, 0.01950422f, -0.00435394f, -0.03104479f, 0.01127918f, -0.04952329f, 0.04203866f, 
    0.00013660f, -0.03404634f, 0.00201533f, 0.01408127f, 0.03713043f, 0.02482663f, -0.01968218f, 0.03774193f, 
    -0.01898453f, -0.01095568f, -0.01345415f, 0.01114350f, 0.02316490f, -0.00087563f, -0.04743348f, -0.05127311f, 
    -0.01500022f, -0.01151046f, -0.03854895f, 0.00565033f, 0.00532314f, -0.03243149f, -0.03437361f, 0.05186905f, 
    -0.02320055f, 0.03167851f, -0.03910284f, -0.00190315f, 0.01444914f, -0.03346312f, -0.02324146f, 0.04245760f, 
    -0.01586892f, -0.03057652f, 0.03946169f, -0.00276955f, -0.04553992f, -0.02919243f, 0.04710939f, -0.04050928f, 
    0.00752870f, -0.02366626f, 0.00925444f, -0.04929661f, 0.03908709f, -0.01645982f, 0.03165825f, -0.00390503f, 
    0.02622483f, -0.04345997f, -0.04923873f, 0.02148079f, 0.02554161f, 0.02783946f, 0.04865846f, 0.04808783f, 
    -0.02686735f, -0.04921529f, -0.03625264f, -0.04410058f, 0.02388120f, 0.04785322f, -0.00752426f, -0.05331223f, 
    0.01745460f, -0.04411040f, -0.01511590f, -0.03245776f, 0.04563642f, -0.03296999f, 0.01905216f, -0.03887304f, 
    -0.01485483f, -0.04412090f, -0.04143456f, 0.02816640f, -0.00474775f, 0.05486102f, 0.05536211f, 0.03459075f, 
    0.03268969f, -0.00717646f, 0.03270989f, 0.05105858f, 0.04863864f, 0.01471096f, -0.05010186f, 0.01498107f, 
    0.01354330f, -0.02882225f, 0.04377247f, 0.02243572f, -0.04434698f, 0.03428122f, -0.00284642f, 0.01576430f, 
    0.00408619f, 0.02152203f, -0.01380223f, -0.05265795f, -0.04292049f, 0.04924073f, 0.04356106f, 0.04895655f, 
    -0.01244993f, 0.03875106f, -0.05494932f, 0.01946220f, 0.01131541f, 0.03211341f, -0.04263242f, 0.01557848f, 
    -0.04546403f, -0.03622682f, 0.00785232f, 0.00046559f, -0.01211692f, 0.01670977f, 0.00007558f, 0.01122511f, 
    -0.00102063f, -0.03355063f, -0.02362061f, -0.05415445f, -0.05547882f, 0.04074678f, 0.03540150f, -0.04539565f, 
    0.03694425f, 0.01552360f, -0.05275387f, -0.00969110f, 0.05497605f, -0.01472255f, 0.04659038f, 0.01110669f, 
    0.04479545f, -0.01688619f, -0.00852155f, -0.03928581f, -0.05197538f, 0.00017968f, -0.05472556f, 0.05041654f, 
    -0.01570427f, -0.03875354f, -0.01178873f, -0.00355395f, 0.03368116f, -0.02906324f, -0.03716913f, 0.04583938f, 
    -0.03303739f, -0.01137836f, 0.02454694f, -0.00545586f, -0.00010353f, -0.05256385f, -0.04919652f, 0.00571504f, 
    -0.05497010f, -0.00114354f, -0.02776979f, -0.04953918f, -0.04564042f, -0.00050892f, -0.04383244f, -0.02673632f, 
    0.00547922f, 0.04234888f, -0.02584231f, -0.02569193f, 0.04472464f, 0.00138502f, 0.05291266f, -0.05452078f, 
    -0.01264786f, 0.05323213f, 0.00585873f, -0.01553481f, -0.01608805f, -0.01735272f, -0.00795980f, 0.02948665f, 
    0.02977500f, 0.05498201f, 0.01211504f, 0.03243015f, 0.01990251f, -0.00440780f, -0.04733512f, -0.02227504f, 
    -0.01193346f, 0.02702882f, -0.05278205f, -0.02772950f, -0.05181461f, 0.00826180f, -0.04118754f, -0.01158897f, 
    -0.00743836f, -0.02111484f, -0.04258424f, -0.03766189f, -0.03050233f, 0.00968935f, 0.01625872f, -0.00750772f, 
    -0.03932397f, -0.03231760f, -0.01782863f, -0.01609653f, 0.02135105f, -0.01464892f, 0.00296413f, 0.03397911f, 
    -0.02760795f, 0.04783092f, -0.01993042f, 0.02744941f, -0.03295135f, -0.02395373f, -0.00470085f, -0.04211231f, 
    -0.05551263f, 0.03213865f, -0.04605045f, -0.00554679f, 0.03986732f, 0.00868582f, 0.05530627f, -0.02732150f, 
    0.00487159f, -0.01558308f, 0.02444462f, -0.03686652f, -0.01470829f, -0.00787751f, -0.01820987f, -0.04567917f, 
    -0.02726036f, 0.02608714f, 0.02574045f, 0.01786830f, -0.01056039f, -0.01219194f, -0.03664383f, 0.04427429f, 
    -0.00433871f, -0.05122800f, -0.01238075f, 0.02990056f, 0.03174059f, -0.03942162f, -0.04801930f, -0.02635033f, 
    -0.03885873f, 0.02789480f, -0.00138761f, -0.05264780f, -0.04012978f, -0.00527896f, 0.05286664f, 0.00207691f, 
    -0.05076674f, 0.02454380f, -0.02274259f, 0.00258663f, -0.05450990f, -0.03458545f, -0.04790585f, 0.00635644f, 
    -0.04827271f, -0.03785669f, 0.01839065f, -0.02015561f, 0.05554334f, 0.01850059f, 0.00942754f, 0.00060162f, 
    0.02536376f, -0.05400134f, 0.01826160f, 0.05041651f, 0.03721167f, -0.00931976f, -0.01679681f, 0.02025891f, 
    -0.00497381f, 0.00885733f, 0.05343017f, 0.01828416f, -0.02843623f, 0.03210100f, -0.03959766f, 0.03922313f, 
    -0.00536479f, 0.02689095f, -0.02513188f, -0.03102831f, -0.02079628f, 0.02574399f, -0.01091492f, -0.03206636f, 
    0.00348071f, 0.02800071f, -0.00067218f, 0.00776941f, -0.04468622f, -0.00957275f, 0.03786764f, 0.01322327f, 
    0.17380485f, -0.17522115f, 0.42994806f, 0.15425400f, -0.48130685f, -0.13520038f, -0.16671731f, -0.28601259f, 
    -0.09739248f, -0.06764644f, 0.06018098f, -0.00633585f, 0.07588797f, 0.11173895f, 0.00139700f, 0.05028152f, 
    0.02936353f, 0.02726062f, 0.10524212f, 0.11111555f, 0.07913846f, 0.11766346f, -0.39697158f, 0.11609165f, 
    0.05250217f, 0.08804093f, 0.11319682f, 0.21384238f, 0.11156258f, 0.02836824f, 0.00519308f, 0.02799023f, 
    -0.03561619f, -0.02643591f, 0.01897985f, 0.09039549f, 0.06408499f, -0.13541004f, 0.04791941f, -0.05868845f, 
    0.01070899f, -0.15917993f, 0.45911169f, 0.00552109f, -0.16544577f, -0.03589690f, -0.16898036f, 0.01931134f, 
    -0.10635018f, -0.10786998f, 0.03516300f, 0.05845769f, -0.05116092f, -0.02125228f, 0.01617818f, -0.00597707f, 
    -0.04360833f, -0.05225970f, -0.02295273f, -0.33861035f, -0.31322417f, -0.13397272f, -0.22820587f, 0.10917997f, 
    -0.04176909f, 0.06352913f, 0.13052015f, -0.00470713f, 0.10361837f, 0.06237065f, 0.01864880f, -0.05735720f, 
    -0.08462200f, 0.02659601f, 0.11230376f, -0.08618402f, -0.00370415f, -0.15826082f, 0.19121031f, 0.00627979f, 
    0.00247321f, 0.08000419f, -0.18399252f, 0.07571634f, 0.13485195f, 0.08263392f, -0.02868233f, -0.07990183f, 
    0.14553417f, 0.00830654f, 0.04404519f, 0.00377760f, -0.00195569f, 0.04704769f, -0.05610494f, 0.17862664f, 
    0.07620504f, 0.13259403f, -0.02132723f, 0.22404283f, 0.28111607f, 0.31785694f, -0.25735119f, 0.01245390f, 
    0.01701777f, 0.11921655f, -0.08140274f, 0.02326347f, 0.04155101f, 0.01871893f, 0.11853059f, -0.00417344f, 
    -0.09499007f, 0.00530872f, -0.10895013f, 0.10241333f, 0.11414501f, 0.01123378f, -0.00415621f, 0.08773230f, 
    -0.19677630f, 0.03587684f, -0.08459231f, 0.08133423f, -0.01119133f, -0.04418745f, 0.01229751f, -0.01994174f, 
    0.06522410f, -0.00191181f, 0.03119710f, 0.01509580f, 0.03942121f, 0.01758413f, 0.08159487f, -0.10922362f, 
    0.05051347f, 0.06313378f, 0.17858991f, 0.18039817f, -0.37895626f, -0.39194769f, -0.04519595f, 0.06090150f, 
    -0.26672760f, -0.19970427f, 0.10856431f, -0.10254861f, -0.09835192f, 0.06697778f, -0.01782133f, -0.05457488f, 
    0.03311160f, 0.12393614f, -0.08000690f, -0.06648582f, 0.04489107f, 0.10887476f, 0.09561627f, 0.06203583f, 
    -0.00881531f, 0.02389743f, -0.09826294f, 0.06211690f, 0.13728592f, 0.01359492f, 0.16123109f, 0.15145555f, 
    -0.00619342f, -0.08016706f, 0.01837634f, -0.03604979f, -0.09430464f, 0.07149632f, -0.05249341f, 0.14519437f, 
    -0.12260540f, -0.07176246f, -0.03630739f, -0.02538334f, 0.15166591f, 0.08816174f, -0.00763843f, -0.09057551f, 
    0.12382634f, 0.06254080f, 0.08702788f, 0.10588163f, -0.00557616f, 0.00946021f, 0.01953816f, 0.04373552f, 
    -0.01886612f, 0.02447201f, -0.14096557f, 0.08205449f, -0.01113122f, 0.08122958f, -0.03053661f, 0.02671962f, 
    0.37724620f, 0.27234182f, -0.66092694f, 0.19405292f, 0.00471007f, 0.02658119f, 0.14111078f, 0.22955392f, 
    0.06462571f, 0.20009118f, 0.06486011f, -0.01379427f, 0.00527716f, -0.00144122f, -0.00301928f, 0.08423294f, 
    0.09050116f, 0.04902969f, 0.12155893f, 0.16856967f, -0.14147110f, -0.08344015f, 0.05550949f, 0.18309784f, 
    -0.16481252f, -0.09187908f, -0.13046281f, -0.02963373f, -0.06980716f, 0.02330103f, 0.02681194f, -0.00882443f, 
    0.02689540f, 0.09331495f, 0.08323070f, 0.03948948f, 0.01102333f, -0.08741531f, 0.21708022f, 0.10643857f, 
    0.03123106f, -0.20402534f, 0.07055163f, 0.33692312f, -0.11442107f, 0.03514210f, 0.05485043f, -0.08307838f, 
    0.00225356f, -0.02753408f, 0.01993998f, -0.02037153f, 0.10905369f, -0.00271149f, 0.13713975f, 0.14817475f, 
    0.02575226f, -0.00712382f, 0.11429798f, 0.06243715f, 0.04178750f, -0.28019974f, -0.07866167f, 0.12512930f, 
    -0.06429118f, -0.03699056f, -0.03280182f, 0.00888967f, -0.06583265f, 0.07362845f, 0.04695741f, 0.04618936f, 
    0.03192696f, 0.07303744f, -0.00437750f, 0.21866480f, -0.06361923f, -0.04969627f, -0.14592107f, -0.12895073f, 
    0.35876182f, 0.05203268f, 0.13064216f, -0.05120844f, 0.00397483f, 0.15632986f, 0.16035756f, 0.07809789f, 
    0.07626848f, -0.00031540f, -0.05199872f, -0.01125857f, -0.14421932f, 0.00098146f, -0.02961057f, -0.08807630f, 
    -0.05424639f, -0.06215274f, -0.01292770f, -0.07615059f, 0.15677993f, -0.26309934f, 0.24983808f, -0.07932947f, 
    -0.11149874f, 0.01903285f, -0.03463487f, 0.02444177f, 0.08133914f, 0.04612803f, 0.08488430f, 0.02518624f, 
    -0.01641364f, 0.02922608f, 0.04976087f, 0.01043783f, -0.05541850f, 0.05107308f, 0.16176416f, -0.04685123f, 
    -0.21639006f, 0.17717662f, -0.12737751f, 0.05239759f, 0.10940064f, 0.03588334f, 0.07348473f, 0.25939888f, 
    0.06288904f, 0.08815578f, 0.02355899f, 0.11943550f, 0.04567858f, -0.08122234f, 0.01643057f, 0.11035419f, 
    -0.00909035f, 0.09885757f, -0.01574545f, -0.01690515f, 0.10793015f, -0.03243437f, 0.40463260f, -0.35111693f, 
    -0.17098022f, 0.00850865f, -0.09771972f, -0.03151610f, 0.06995631f, 0.06705615f, -0.07345620f, 0.00979677f, 
    0.07590641f, 0.05107336f, 0.02114997f, 0.03464826f, -0.01463284f, 0.08942898f, 0.03662167f, 0.15139008f, 
    -0.16400152f, -0.07428852f, -0.62505114f, 0.20381124f, 0.05045053f, 0.09269509f, -0.00227583f, 0.02715446f, 
    0.16332008f, 0.00943981f, -0.03017359f, -0.03532707f, 0.00044538f, 0.07850131f, -0.02679608f, 0.03575347f, 
    -0.02453957f, 0.15976319f, 0.04899311f, 0.32659012f, 0.37612361f, 0.16265039f, 0.18238109f, -0.10847075f, 
    0.25387561f, 0.02496956f, -0.01901540f, 0.17195158f, 0.04470140f, 0.00715273f, 0.14222434f, 0.13315021f, 
    0.19545181f, -0.18574548f, -0.03518244f, 0.15257439f, 0.14932521f, 0.04697578f, -0.06891371f, 0.08267763f, 
    -0.09362452f, -0.03150312f, 0.10028398f, -0.05937501f, -0.22112827f, 0.02581564f, 0.01239669f, 0.14260836f, 
    -0.13320005f, 0.10008524f, 0.00825636f, -0.04949410f, -0.04361007f, -0.04789078f, 0.05565248f, -0.00480791f, 
    -0.10213344f, -0.09472822f, -0.04433600f, -0.07111372f, -0.10353883f, -0.17937440f, 0.34331870f, -0.04632707f, 
    0.06484986f, -0.02494456f, 0.13611346f, -0.19080570f, 0.00706571f, 0.03295787f, -0.08965117f, 0.06776737f, 
    -0.06182942f, 0.00266111f, 0.10347888f, -0.00599627f, 0.02950135f, -0.09361665f, 0.16019347f, -0.03195774f, 
    0.30627441f, 0.04135481f, 0.21627964f, 0.09321487f, 0.17099023f, 0.13553590f, 0.19877690f, 0.11770001f, 
    -0.04853243f, 0.20475096f, 0.17909187f, -0.00095306f, 0.08061072f, 0.02434116f, 0.00074208f, 0.19200996f, 
    -0.01263100f, 0.03710640f, -0.04667182f, 0.03595877f, 0.24497856f, 0.40667316f, 0.29199174f, 0.19061673f, 
    0.20314844f, 0.17075442f, -0.04529454f, 0.17212872f, 0.04013031f, -0.01078505f, 0.08765866f, 0.09261696f, 
    -0.00985884f, -0.10519395f, 0.09294353f, 0.15734538f, -0.07044659f, -0.02951708f, -0.07398286f, -0.00330144f, 
    0.07672901f, 0.06869718f, 0.18862358f, -0.12467956f, -0.10361938f, 0.06918110f, -0.14815335f, -0.09149865f, 
    -0.10361611f, -0.04238567f, -0.03006576f, 0.00110775f, 0.01954778f, -0.04607356f, 0.07715985f, -0.14928970f, 
    0.20540968f, 0.12391469f, 0.05023477f, 0.01102438f, -0.14438394f, -0.10627201f, -0.03251122f, -0.14803705f, 
    -0.10314102f, -0.18171899f, -0.16356342f, -0.24320148f, -0.07013354f, -0.17190313f, -0.03511430f, 0.02302837f, 
    -0.07653318f, -0.06218119f, -0.07634645f, 0.04653417f, 0.20804267f, -0.17243679f, 0.03602807f, -0.10641278f, 
    -0.09260722f, -0.22054720f, 0.67826223f, -0.35157520f, -0.05023580f, -0.01825076f, -0.10049847f, -0.19014372f, 
    0.09356561f, -0.13133918f, -0.03941871f, 0.01272401f, 0.02935266f, 0.02900118f, -0.01352574f, 0.02867339f, 
    -0.09674536f, 0.04186730f, -0.04194711f, -0.13886522f, 0.07239944f, 0.05910627f, 0.03539161f, 0.01877842f, 
    0.10318489f, 0.09723670f, -0.00634829f, 0.09277344f, 0.07997297f, 0.09283686f, 0.03016976f, 0.06025493f, 
    -0.01812176f, -0.07159556f, -0.00479842f, 0.02311976f, -0.02943161f, 0.06671839f, -0.12630560f, 0.04041303f, 
    0.00097148f, 0.04805642f, -0.06491390f, 0.00544007f, 0.07444715f, 0.01280969f, -0.07725531f, 0.04537268f, 
    0.01370903f, -0.05525999f, 0.06214511f, 0.05093595f, -0.09592271f, -0.01997238f, -0.08175735f, -0.03597863f, 
    0.04489679f, -0.07246991f, 0.02025658f, -0.08887312f, -0.14514525f, 0.23554246f, -0.26258609f, 0.11142881f, 
    0.06801881f, 0.01367460f, -0.02108806f, 0.12347151f, 0.04962013f, -0.02253509f, -0.16911533f, 0.07947716f, 
    0.03169366f, 0.06494842f, 0.02945342f, -0.17132621f, 0.10589729f, 0.06752987f, 0.27915421f, 0.09257019f, 
    -0.50471294f, -0.15038195f, -0.08607011f, 0.12940143f, -0.06108899f, -0.29084051f, -0.24483225f, 0.01869993f, 
    -0.07046711f, -0.10148827f, 0.03523592f, 0.05235196f, 0.12876375f, 0.10981566f, -0.14167745f, 0.08890055f, 
    0.07925448f, 0.05584231f, -0.03502227f, 0.05967831f, -0.27439365f, 0.22891888f, -0.24264428f, 0.19741465f, 
    0.04609492f, -0.00573825f, -0.05099355f, -0.07121715f, -0.04951723f, 0.09987164f, -0.06398073f, 0.05529877f, 
    -0.00323389f, 0.06616819f, 0.07791079f, 0.01461045f, 0.02854010f, -0.05013406f, -0.19112904f, 0.01301080f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.01314991f, 0.10270062f, -0.01807738f, 0.21297574f, -0.16696799f, 0.04558922f, -0.08280794f, 0.14865759f, 
    0.09807146f, 0.07208336f, -0.04084269f, 0.07635216f, 0.11369476f, -0.04431757f, -0.04339821f, 0.09613396f, 
    0.29709363f, 0.01541083f, -0.12349921f, 0.05661399f, 0.08678232f, 0.12308808f, 0.02022229f, 0.14056818f, 
    0.05999358f, -0.06067877f, 0.09929983f, -0.00615361f, -0.00639069f, 0.04141245f, 0.07534517f, 0.05539055f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.18881714f, 0.09697810f, -0.10254075f, 0.26983565f, 0.09058706f, 0.12115206f, 0.07387873f, -0.04112003f, 
    0.01814234f, 0.10439387f, 0.00076280f, -0.15578495f, -0.05416221f, -0.06545151f, -0.10414843f, 0.00301596f, 
    0.22658589f, 0.02694462f, -0.03404501f, -0.26745445f, -0.28878421f, 0.02371155f, -0.05524553f, -0.00599473f, 
    -0.04519160f, -0.00480552f, -0.00014961f, -0.25841787f, 0.10450197f, -0.05584617f, -0.04334283f, 0.23352855f, 
    0.26624432f, 0.35339439f, -0.07871070f, -0.42467669f, -0.74527419f, -0.22912407f, 0.07290937f, 0.12703376f, 
    -0.21152145f, -0.22573917f, -0.10097826f, 0.29369551f, 0.00851317f, 0.06886841f, -0.17308144f, -0.14426593f, 
    0.35364157f, -0.57436478f, -0.08516840f, -0.08001765f, 0.26918259f, 0.30346164f, -0.19116989f, 0.23146802f, 
    0.25179094f, 0.02466798f, -0.14310379f, -0.14266062f, 0.13711639f, 0.12929732f, 0.15938203f, 0.10318596f, 
    0.01879354f, 0.37179518f, 0.07680312f, 0.15053280f, 0.08057787f, 0.16809730f, 0.21840540f, -0.32639366f, 
    -0.06733391f, -0.07480270f, -0.05473378f, -0.15829369f, -0.12753454f, -0.11156365f, -0.06373992f, -0.38913581f, 
    0.06615874f, 0.18002060f, -0.12646285f, 0.19247076f, 0.30809897f, -0.02763188f, 0.30153641f, 0.03306399f, 
    0.21184270f, 0.05309256f, 0.26147345f, 0.37116894f, -0.09087075f, -0.00519565f, -0.22382751f, 0.37345156f, 
    -0.15759765f, 0.14889994f, 0.06193848f, 0.12685938f, -0.20816761f, 0.29506451f, -0.07483149f, 0.25735348f, 
    0.14937663f, -0.01988367f, -0.13804454f, -0.03071453f, -0.00441757f, 0.06371236f, 0.07032741f, -0.29323965f, 
    -0.02049917f, 0.04613582f, -0.02009870f, -0.35346580f, -0.03348415f, 0.09658658f, -0.26897877f, 0.29594672f, 
    0.13726640f, 0.05855497f, -0.18224886f, -0.14068358f, -0.03807401f, -0.07703447f, 0.10167895f, -0.11882286f, 
    0.14870496f, 0.03019598f, 0.32953867f, 0.22783849f, 0.32006443f, 0.03717330f, 0.27935690f, -0.13145854f, 
    -0.38331434f, 0.02978312f, 0.10207618f, 0.05560969f, 0.03197179f, 0.17371067f, -0.14646158f, -0.05485776f, 
    -0.00007157f, 0.07361158f, 0.60025758f, 0.09331662f, -0.13197669f, -0.14096859f, 0.10342503f, 0.18928374f, 
    0.07467515f, 0.07150784f, -0.47229493f, -0.20141484f, 0.03872682f, -0.07463414f, -0.02737027f, -0.11886809f, 
    0.10630112f, 0.12321568f, -0.01841615f, 0.09483048f, -0.00385132f, -0.16148144f, -0.06668122f, -0.19866528f, 
    0.02180992f, -0.16259144f, 0.00977973f, -0.05528675f, -0.14817229f, -0.14590155f, -0.03819872f, -0.12730020f, 
    -0.12336794f, -0.08847144f, 0.04060363f, -0.07748520f, 0.05496605f, -0.04460101f, -0.16155931f, -0.10536741f, 
    0.02799480f, -0.14446814f, 0.01030723f, -0.03693273f, -0.07862321f, -0.00236688f, -0.10631230f, 0.07797402f, 
    -0.03012434f, 0.06092916f, -0.12495771f, 0.09023628f, 0.07530007f, -0.05846926f, -0.05040482f, 0.44555253f, 
    0.13794294f, -0.45771724f, -0.16249441f, 0.14220113f, 0.26809803f, -0.21028447f, 0.03295854f, -0.17714338f, 
    0.07401197f, 0.07693264f, 0.12818319f, -0.37700483f, 0.30096090f, -0.10187375f, 0.42725661f, 0.17028303f, 
    0.22574556f, -0.09472494f, 0.14380383f, 0.24671061f, 0.01073125f, 0.08818042f, -0.15504782f, 0.02541631f, 
    0.12120445f, -0.05811092f, -0.14533736f, 0.32172421f, -0.25445324f, -0.39842194f, 0.38458163f, 0.37151033f, 
    -0.22184913f, -0.27044243f, 0.15630522f, 0.08917150f, -0.06040068f, 0.13492863f, 0.15567110f, 0.23224919f, 
    0.34516853f, -0.29380438f, 0.23489669f, -0.03580440f, -0.06092751f, 0.37356022f, 0.35722804f, 0.12251994f, 
    -0.06889229f, -0.07614233f, -0.00094177f, -0.16008361f, -0.17265245f, 0.02718474f, 0.14442980f, 0.10478903f, 
    0.09290861f, -0.06622351f, 0.06295478f, -0.16669811f, -0.13948712f, -0.17502688f, -0.19200453f, 0.10827416f, 
    -0.06646191f, -0.14611472f, 0.15729117f, -0.09152763f, 0.04641992f, -0.11442761f, 0.08162011f, -0.15232410f, 
    -0.11507139f, -0.03988734f, -0.10179292f, 0.10791890f, 0.09649584f, 0.00020951f, -0.15704402f, -0.10730302f, 
    -0.01597725f, 0.04599389f, 0.04902535f, -0.00837706f, -0.08745709f, 0.03557095f, 0.07431096f, 0.09025622f, 
    -0.13687794f, -0.04343574f, -0.16564879f, 0.01606526f, -0.11057641f, -0.13814875f, 0.04711476f, 0.03475574f, 
    -0.02811309f, -0.05602559f, -0.09502618f, 0.01131211f, -0.06134731f, -0.13355470f, -0.06707614f, 0.17236400f, 
    0.01758577f, -0.11607200f, -0.14056954f, -0.17541316f, -0.10332439f, 0.08282167f, 0.05993360f, -0.15487470f, 
    -0.17465945f, 0.03026021f, 0.05844923f, -0.14681140f, 0.16656752f, -0.03072537f, -0.05755049f, -0.10851810f, 
    0.03578813f, 0.10405305f, 0.17390284f, 0.51362348f, -0.10856356f, 0.18522687f, 0.03992495f, 0.35646501f, 
    0.07980447f, 0.09987348f, -0.00952205f, -0.03772170f, -0.14070906f, -0.13615701f, -0.15894134f, 0.19606969f, 
    0.34471133f, -0.39638463f, -0.25862801f, -0.45303580f, -0.05068995f, -0.26696795f, -0.07573896f, 0.10232209f, 
    0.12292296f, -0.03395326f, 0.06976303f, -0.07611938f, -0.13296877f, -0.12876789f, -0.00335367f, 0.01139399f, 
    -0.00372639f, -0.16039400f, 0.35408634f, -0.10568766f, -0.02769876f, -0.01965129f, 0.25638831f, 0.00791978f, 
    -0.20161982f, 0.24867582f, -0.08282786f, -0.16398910f, 0.17113627f, 0.27576405f, 0.05007231f, 0.10984802f, 
    -0.15623060f, 0.01176813f, 0.43096697f, -0.29376066f, 0.08135264f, -0.36568663f, 0.02628085f, 0.20300019f, 
    -0.13414441f, -0.04524675f, 0.01666788f, 0.04013748f, -0.05236906f, -0.10956368f, 0.17762291f, -0.30340436f, 
    0.35025549f, 0.06293699f, 0.28450951f, -0.33241305f, -0.13777180f, -0.17820041f, -0.18712248f, 0.31283706f, 
    0.11257141f, 0.10900334f, -0.03085423f, 0.45164734f, 0.05774054f, 0.25187528f, -0.15052576f, 0.32240683f, 
    -0.05947357f, -0.47781357f, -0.32350698f, -0.16609989f, 0.06119200f, -0.36333576f, 0.01177412f, 0.27868345f, 
    -0.03221477f, 0.11555414f, 0.00979946f, -0.25729892f, 0.15760125f, 0.12698811f, 0.10344047f, -0.22813611f, 
    -0.09635831f, -0.25162962f, -0.16868018f, 0.17634805f, 0.13270506f, -0.16729060f, 0.19576780f, 0.20766345f, 
    0.03414121f, 0.34035787f, -0.11156883f, 0.07347561f, 0.21539702f, -0.16900663f, -0.05291067f, -0.27931702f, 
    0.06453285f, 0.21414249f, -0.37887430f, 0.31582072f, 0.13548504f, -0.11801610f, 0.21436238f, -0.14070173f, 
    -0.14581913f, 0.09165041f, -0.10743125f, 0.16924296f, 0.15021582f, 0.06080741f, 0.14341044f, -0.12626047f, 
    0.21765530f, -0.02179456f, -0.15062521f, -0.36686251f, -0.60114455f, -0.38084933f, -0.20015799f, -0.26646367f, 
    0.10186753f, -0.11108973f, 0.00068384f, 0.40375409f, -0.18121888f, 0.08203051f, 0.05672881f, 0.00294500f, 
    0.25690129f, -0.00020658f, -0.45071232f, 0.32593349f, 0.26622063f, 0.31231403f, 0.06361921f, 0.21175872f, 
    -0.16046028f, 0.13940889f, -0.06158186f, -0.24666421f, 0.14356427f, 0.17127918f, -0.09750891f, 0.05636819f, 
    -0.11178340f, 0.06633905f, 0.20001537f, 0.35520178f, 0.04094303f, -0.15395911f, 0.07546744f, 0.36871547f, 
    -0.18476379f, 0.24369106f, 0.02067293f, -0.28106293f, 0.19783869f, 0.17864707f, -0.14969873f, 0.28369284f, 
    -0.20733647f, -0.33487916f, 0.49003145f, -0.35885221f, 0.06910859f, -0.51157415f, -0.00838034f, -0.04765684f, 
    0.28373018f, 0.16178235f, 0.29913816f, 0.10231210f, -0.04560788f, -0.02362207f, 0.18847606f, -0.25184432f, 
    -0.13121478f, -0.50924909f, 0.15322086f, -0.03109087f, 0.10699350f, 0.07111221f, 0.16885000f, 0.05204521f, 
    -0.17181857f, -0.03521129f, -0.15974633f, 0.18614541f, 0.28365660f, 0.01821993f, 0.14957367f, -0.25519025f, 
    -0.06609642f, 0.43473333f, -0.09252705f, 0.05498609f, 0.29418957f, 0.06282555f, 0.25129429f, 0.19632114f, 
    0.00280972f, -0.06245672f, -0.24074517f, 0.04855631f, -0.13961200f, 0.00478232f, 0.20303237f, -0.47345126f, 
    0.29183573f, -0.20288309f, -0.28151858f, 0.38901228f, 0.08182935f, -0.31141374f, 0.04462398f, 0.05281826f, 
    -0.25498915f, -0.11478682f, -0.08390312f, 0.18879230f, 0.19422242f, 0.02810765f, -0.16615959f, 0.46188805f, 
    0.20901272f, 0.16355376f, 0.02128111f, -0.02459857f, 0.02185361f, 0.05729523f, 0.36233389f, 0.24713707f, 
    -0.03269779f, 0.14466082f, -0.12865056f, 0.14362651f, 0.16864605f, -0.14001720f, 0.20810531f, -0.00545567f, 
    0.44971654f, 0.10111470f, 0.21953122f, -0.24136657f, -0.18159176f, 0.15171432f, 0.07084011f, 0.08249107f, 
    0.55260628f, -0.13878305f, -0.10158356f, 0.15147287f, -0.32180849f, 0.15278536f, -0.08376025f, 0.54446322f, 
    -0.08464766f, 0.12913579f, -0.22615528f, 0.43069932f, -0.22763094f, 0.21924756f, -0.08388533f, 0.27912962f, 
    -0.07384058f, -0.06512813f, -0.37726849f, -0.23413196f, -0.05145967f, -0.17023394f, -0.05675435f, 0.26471454f, 
    0.24833964f, 0.05117571f, 0.10494494f, 0.43095583f, -0.10177232f, 0.06671403f, -0.27878913f, 0.29498777f, 
    0.34517992f, 0.13688788f, 0.02331321f, 0.21447973f, 0.11481757f, -0.18598969f, 0.09565910f, 0.26044759f, 
    0.22814041f, 0.10763148f, -0.38955384f, 0.09631239f, -0.13522156f, 0.04196244f, -0.16875298f, 0.12451588f, 
    -0.01973914f, -0.11210068f, 0.11427593f, -0.30138150f, 0.13591075f, 0.00112635f, -0.04645005f, 0.21471268f, 
    -0.08851136f, 0.28261673f, 0.33234751f, 0.17946041f, 0.41478312f, 0.30834523f, -0.14871888f, -0.16700239f, 
    -0.19866927f, 0.23591980f, -0.11978293f, -0.27918908f, 0.29969037f, 0.27964586f, 0.09870684f, -0.25826526f, 
    -0.05754926f, -0.09211894f, 0.33696353f, -0.13888419f, -0.17106596f, 0.05963428f, -0.36556840f, 0.07378489f, 
    -0.02842363f, 0.00959808f, 0.01919793f, -0.19080895f, 0.06063020f, -0.10270196f, 0.10270350f, 0.05915258f, 
    -0.19792739f, 0.15147914f, -0.25123873f, 0.15066098f, 0.14696835f, 0.13775411f, -0.06323700f, -0.40366185f, 
    -0.07731978f, 0.37898383f, -0.06668737f, 0.11884999f, 0.05479128f, 0.14256319f, 0.07611080f, 0.18074988f, 
    0.22803603f, -0.03058538f, -0.40746143f, -0.03712341f, 0.26479128f, 0.24459480f, -0.18918921f, 0.12824973f, 
    -0.14020458f, 0.03241212f, 0.46107891f, -0.09828512f, -0.10848318f, -0.05151533f, 0.10381694f, -0.09886519f, 
    -0.09123032f, 0.42989144f, 0.10011984f, -0.04463121f, -0.18693486f, 0.19963802f, -0.23101906f, -0.52698356f, 
    -0.04664626f, 0.46075219f, 0.14108562f, 0.32938790f, 0.00258503f, 0.37106556f, -0.03062386f, 0.32274079f, 
    -0.30624723f, 0.34556293f, -0.35549918f, -0.06210476f, 0.40468189f, -0.31225315f, 0.02025716f, 0.06958463f, 
    -0.26079813f, 0.16694897f, 0.07419106f, 0.30862102f, -0.08044899f, 0.07585806f, -0.01088983f, 0.24754182f, 
    -0.12131527f, 0.25651687f, 0.14091453f, 0.30849138f, -0.30849335f, 0.32440546f, -0.34739730f, 0.38658515f, 
    0.03185445f, 0.25911343f, 0.17799577f, 0.07667667f, 0.25686187f, 0.07500768f, 0.07256079f, -0.06359113f, 
    0.22750622f, 0.13246807f, -0.38568044f, -0.51975292f, 0.07654740f, -0.39316213f, -0.37919784f, 0.09510216f, 
    0.09393888f, -0.13355987f, 0.15389714f, -0.25374639f, 0.03766425f, -0.06211946f, 0.11226191f, -0.02189261f, 
    0.16990811f, 0.19385083f, 0.03179581f, 0.13336281f, 0.11899119f, -0.03624891f, -0.44432160f, -0.01925625f, 
    0.59754729f, -0.11150631f, -0.02663152f, 0.30639705f, -0.23809095f, -0.17629604f, -0.13550182f, 0.12686826f, 
    0.24005681f, 0.28237891f, -0.06237495f, 0.38659263f, 0.05956598f, 0.37253973f, 0.13323154f, 0.00984507f, 
    -0.18595174f, 0.10898104f, -0.09347141f, 0.27490413f, -0.08512313f, 0.10653488f, -0.35954633f, 0.32027972f, 
    0.18618858f, 0.19922946f, 0.34705418f, 0.05045828f, 0.23802826f, 0.19115233f, -0.05297641f, -0.27624977f, 
    0.11359952f, 0.04401460f, 0.01697631f, -0.12899572f, -0.25691882f, 0.23208261f, -0.04094337f, -0.20288460f, 
    -0.03788862f, -0.15151165f, 0.28049263f, 0.45242286f, -0.29065531f, 0.04485102f, -0.10315537f, -0.22749919f, 
    0.09696498f, -0.03082918f, 0.10701829f, 0.11228304f, 0.08741591f, 0.02980031f, -0.29902831f, 0.25696677f, 
    0.00071605f, -0.26140508f, 0.11969409f, 0.30780184f, 0.26596317f, 0.30409858f, -0.14793476f, 0.43272465f, 
    0.39083114f, 0.10053141f, 0.01854278f, -0.36046249f, 0.25991470f, 0.09645333f, 0.08420007f, 0.13721006f, 
    0.31620908f, 0.43872684f, 0.17894445f, 0.20015717f, -0.25600088f, 0.20794326f, -0.10067917f, -0.14938565f, 
    0.16805564f, 0.04553666f, -0.11424495f, -0.20310974f, -0.05789431f, -0.08957769f, 0.29836687f, -0.15846963f, 
    0.10511176f, -0.05193303f, -0.11409552f, 0.04286914f, -0.08539588f, -0.16743428f, 0.13821551f, -0.15556785f, 
    -0.15561369f, 0.17107998f, -0.09029176f, 0.03749257f, -0.08242832f, -0.16697134f, 0.12050418f, -0.07914580f, 
    0.04599656f, -0.13785812f, -0.10313580f, -0.16658278f, 0.02320336f, 0.15829191f, -0.13845713f, -0.11125982f, 
    -0.16327438f, 0.15273310f, -0.06712874f, 0.04826678f, -0.08874596f, 0.15863724f, -0.15703818f, -0.16140093f, 
    0.33842620f, -0.38483992f, -0.03188376f, -0.13072702f, -0.00574122f, -0.02008557f, -0.08836300f, -0.14871341f, 
    0.26716548f, -0.03688938f, -0.04020263f, 0.07501715f, 0.10941181f, 0.10882629f, 0.14340521f, 0.14048149f, 
    0.03403159f, 0.23281203f, -0.27494591f, 0.20808029f, 0.11493759f, 0.31006035f, -0.23676008f, 0.17934576f, 
    -0.33803031f, -0.02439997f, -0.00587448f, -0.44665149f, -0.16690762f, -0.05423971f, 0.22454940f, -0.07974285f, 
    0.15506880f, 0.15351655f, 0.25412437f, -0.02071438f, 0.34031335f, -0.11395321f, 0.07910255f, -0.20933773f, 
    0.50626522f, -0.19020824f, -0.01378183f, -0.03240843f, -0.21796319f, 0.27376163f, 0.09442306f, 0.37586132f, 
    -0.13155188f, -0.15815352f, 0.00521282f, 0.51086950f, -0.20698778f, 0.08560403f, 0.16113412f, -0.28988519f, 
    0.27033651f, 0.02743608f, 0.04669942f, 0.37113440f, -0.14283134f, -0.07874700f, -0.26434264f, 0.24840358f, 
    -0.23859997f, 0.14292233f, -0.35659963f, 0.14189713f, -0.01980524f, -0.15564087f, -0.08596671f, -0.31644481f, 
    -0.10967899f, 0.30514345f, 0.05748419f, 0.14535908f, 0.25865513f, 0.15670286f, -0.06007985f, 0.06881125f, 
    0.37389609f, 0.36046979f, -0.23587692f, 0.03699770f, 0.35403097f, 0.24812804f, 0.04057406f, -0.23390199f, 
    0.06438057f, 0.12718888f, 0.29044133f, 0.25234672f, -0.09569851f, 0.08810093f, -0.31416756f, 0.41602719f, 
    -0.03077777f, 0.32875785f, 0.10173219f, 0.34801516f, 0.21769542f, -0.16421425f, -0.02939923f, 0.08833484f, 
    0.22389443f, -0.00602301f, -0.15846805f, 0.20772444f, 0.05182530f, -0.05129460f, -0.03252358f, 0.04184364f, 
    -0.23996511f, -0.18397708f, 0.03560669f, -0.48078179f, 0.09074492f, -0.45373371f, 0.29418311f, 0.11514861f, 
    0.17382942f, 0.03483646f, 0.22667298f, -0.19289368f, 0.12396782f, -0.03143567f, -0.22871052f, 0.02034195f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.08606850f, 0.23138599f, -0.00319778f, 0.16952509f, 0.11152473f, -0.18837519f, 0.05706182f, 0.08124042f, 
    -0.13644637f, -0.11265844f, 0.21093854f, -0.21174666f, -0.12232085f, 0.04450274f, 0.08785685f, -0.00755942f, 
    0.03090032f, 0.16807568f, 0.14007448f, 0.33074531f, 0.06195511f, 0.23796676f, 0.04113183f, -0.01410266f, 
    0.11702365f, -0.12458920f, -0.11334231f, 0.11102516f, 0.11166988f, -0.13235943f, 0.13947637f, 0.18026787f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.20331934f, -0.08425973f, 0.28635889f, 0.05204940f, 0.10337849f, -0.14370395f, -0.01274648f, -0.44959989f, 
    -0.15242338f, 0.09139841f, -0.26331288f, 0.19897942f, -0.55288357f, -0.09029122f, -0.04562493f, 0.25961077f, 
    -0.14689668f, -0.48668143f, -0.43613559f, -0.62692916f, 0.31696630f, -0.24143876f, -0.02611035f, -0.33691895f, 
    -0.05857269f, 0.30186632f, 0.24975243f, 0.03729315f, 0.01820384f, 0.24663253f, -0.00279239f, -0.01175193f, 
    0.07863632f, -0.53730261f, 0.17583381f, -0.15611742f, -0.18002523f, -0.09992649f, -0.02477659f, -0.10001945f, 
    0.16381763f, 0.07755252f, 0.14477105f, -0.43546301f, -0.60030204f, 0.26237613f, -0.06713892f, -0.14673808f, 
    0.09934100f, 0.07288100f, -0.15615529f, 0.33154449f, 0.15454741f, 0.21586849f, -0.02185783f, -0.02179317f, 
    0.29185885f, 0.13953383f, 0.20286284f, -0.16328306f, 0.13583253f, 0.03110090f, 0.27618602f, 0.11129161f, 
    -0.13445424f, 0.19198002f, -0.00734809f, -0.04679520f, -0.20862859f, 0.15991856f, 0.13006608f, 0.27155602f, 
    0.10045514f, -0.11075014f, 0.42074507f, -0.30269045f, -0.09183288f, -0.22752811f, -0.20807643f, 0.04962030f, 
    -0.54363054f, 0.12677851f, 0.14921829f, 0.17890012f, -0.48415607f, -0.26287559f, -0.40935373f, 0.15874837f, 
    0.34027427f, -0.60872489f, 0.16945039f, 0.15114993f, -0.44146538f, 0.09904917f, 0.13559389f, -0.14380674f, 
    -0.28172085f, -0.00561028f, 0.13455588f, -0.90899187f, 0.08906367f, -0.10335936f, 0.16173287f, 0.04642322f, 
    -0.01539225f, 0.15367198f, -0.10149758f, 0.00296813f, 0.17354237f, -0.22015107f, -0.24567716f, 0.01643133f, 
    -0.41797221f, 0.16800541f, 0.27106509f, -0.10575887f, -0.09726325f, -0.35708243f, 0.18184645f, -0.76636821f, 
    0.26176676f, 0.06188794f, -0.27629992f, 0.07056181f, -0.26787597f, 0.29754770f, -0.23414849f, 0.25621346f, 
    0.02291169f, -0.62940127f, -0.02360654f, -0.07271263f, 0.12670939f, 0.00090075f, -0.23253091f, -0.02561636f, 
    -0.01004250f, -0.07540244f, 0.16448465f, 0.31364271f, 0.10771763f, 0.22194777f, -0.22153264f, 0.15079789f, 
    0.27398378f, -0.11377333f, 0.12230213f, -0.05847265f, 0.11355307f, -0.27114397f, -0.05475237f, -0.01530081f, 
    -0.39737391f, 0.01861616f, 0.31705144f, 0.07595452f, -0.31558794f, 0.00197171f, -0.78463471f, 0.17594916f, 
    -0.06718692f, -0.02888611f, 0.01801906f, 0.12413591f, -0.15854570f, -0.03902067f, 0.14480048f, -0.35490930f, 
    -0.09639335f, 0.13137618f, 0.18261099f, 0.12679967f, 0.21956557f, -0.43703538f, -0.42201921f, 0.24174219f, 
    0.03201893f, 0.01273210f, -0.44173753f, 0.10015442f, 0.10855083f, 0.18660595f, 0.33825675f, 0.46459481f, 
    -0.31141016f, -0.32478592f, -0.16938156f, -0.02976463f, -0.08482305f, -0.27750367f, 0.00947693f, 0.25972155f, 
    -0.07144463f, 0.41912776f, -0.40654165f, 0.24742615f, -0.27871725f, -0.14174941f, 0.19892600f, -0.03911701f, 
    -0.04294508f, -0.15196162f, -0.28893006f, -0.16046940f, 0.39943758f, -0.27104691f, 0.31417665f, -0.69362271f, 
    0.08854812f, -0.07893070f, 0.21803051f, 0.24659717f, -0.33250073f, -0.20957689f, -0.68698186f, 0.02593908f, 
    0.07654061f, -0.27747348f, 0.18924408f, 0.06872828f, 0.33688557f, -0.57708400f, -0.37137410f, -0.63236070f, 
    0.01940613f, -0.19812100f, 0.11787169f, 0.05620231f, 0.31192496f, -0.15895338f, 0.34033290f, 0.31867003f, 
    0.00869649f, 0.07059895f, -0.43554038f, 0.17972070f, -0.53813004f, -0.04128489f, -0.17459352f, 0.00153110f, 
    0.32921952f, 0.27575311f, -0.63616586f, -0.36047971f, -0.26355541f, -0.34836233f, -0.27578878f, -0.19115764f, 
    -0.39307666f, -0.14295924f, 0.04261438f, -0.05412300f, -0.32067323f, -0.33637533f, 0.01383480f, 0.06675474f, 
    0.10720342f, 0.46611071f, 0.35324302f, -0.17193945f, -0.20855248f, -0.12539096f, 0.01361890f, 0.23961994f, 
    -0.17346437f, -0.14234562f, -0.24788456f, -0.09278448f, -0.05622688f, -0.15966912f, 0.39370668f, -0.17406088f, 
    -0.12209968f, -0.00064684f, -0.23548132f, -0.26095954f, -0.34011042f, 0.26396435f, 0.19766709f, -0.34929636f, 
    -0.07178848f, -0.19241691f, -0.73681885f, -0.09831586f, -0.17425357f, -0.03536323f, 0.40982556f, 0.03123306f, 
    0.33310097f, 0.26914361f, -0.46884799f, -0.09666020f, 0.30474696f, -0.14003621f, -0.10716247f, 0.34964707f, 
    -0.08202394f, -0.02458756f, 0.15643822f, 0.16788991f, 0.12560505f, 0.13466190f, -0.15147047f, 0.25100580f, 
    -0.08265028f, 0.28586072f, -0.16216987f, 0.10988332f, 0.27858660f, 0.03963183f, -0.53650784f, -0.09814256f, 
    -0.76388597f, -0.60629445f, 0.11683125f, -0.03079908f, 0.01363296f, -0.41091222f, -0.35346442f, -0.28270426f, 
    -0.12677515f, 0.29421189f, 0.26527008f, 0.30250686f, 0.09106208f, -0.19514729f, -0.43765187f, -0.40505922f, 
    0.03160596f, 0.03514493f, 0.11807179f, -0.29230511f, 0.15987654f, -0.36888245f, 0.18792066f, -0.68364304f, 
    -0.34938651f, -0.45564863f, 0.35590619f, 0.21967357f, 0.13594870f, -0.22667371f, 0.26900807f, 0.30993694f, 
    0.23108184f, 0.24806261f, -0.23517092f, 0.14807439f, -0.03203177f, -0.01432931f, -0.23154694f, -0.22364983f, 
    -0.08885660f, -0.13409148f, -0.44632873f, -0.38245720f, -0.11442417f, 0.13800676f, -0.50529653f, -0.07209267f, 
    -0.08437843f, -0.05097111f, -0.54924762f, 0.07337915f, 0.12834656f, -0.41912210f, 0.20105582f, -0.09199133f, 
    -0.17013936f, 0.12071833f, 0.33925840f, 0.07843225f, -0.09195483f, 0.15416892f, 0.39970654f, -0.24555992f, 
    0.12326813f, -0.13773394f, 0.10033554f, 0.09337183f, 0.36750063f, 0.14018252f, 0.19553648f, -0.46755448f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.11174127f, 0.00524444f, 0.00010191f, 0.02556321f, 0.15385759f, -0.13733707f, -0.14162210f, 0.10890008f, 
    0.09517051f, 0.07895514f, 0.10493858f, 0.04762309f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
