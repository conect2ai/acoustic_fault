#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.82990950f, 0.41864216f, 0.35308465f, 0.13853154f, 0.09583415f, -0.28222939f, 0.10204400f, 0.46853024f, 
    0.49132717f, 0.60337204f, -0.99338782f, -0.01235265f, 0.99484611f, 0.38231128f, 0.50019473f, -0.14143765f, 
    -0.52299213f, -0.24770376f, 0.88945419f, 0.15070628f, 0.79974771f, 0.84110677f, -0.62694687f, -0.11816799f, 
    -0.36411190f, -0.26817223f, -0.22284637f, -1.18673909f, 0.46164715f, 0.42584279f, 0.55659485f, -0.36392570f, 
    -0.41170138f, -0.13700292f, 0.33338839f, 0.43818730f, -0.53047174f, -0.63877118f, -0.43235427f, -0.10639498f, 
    0.71831679f, 0.20138313f, 0.40525123f, -0.30616403f, -0.31976154f, -0.62149644f, -0.46247813f, -0.64882660f, 
    -0.55093008f, 0.24498864f, 1.05665696f, -0.23413600f, -0.30500579f, 0.14914967f, 0.73959565f, 0.59286994f, 
    0.43386501f, 0.09977302f, -0.66748989f, 0.06976210f, 0.37599218f, -0.14586879f, 0.38048822f, 0.49712229f, 
    0.68933791f, -0.21152376f, 0.31542453f, -0.16440901f, 0.62893438f, 0.49746090f, 0.37025866f, -0.19111691f, 
    0.14619257f, 0.25950211f, 0.80671209f, 0.65909111f, 0.25511783f, 0.30612108f, 0.38984975f, 0.49541762f, 
    0.26650634f, -0.89260495f, 0.71749389f, -0.62186426f, -0.59140736f, 0.58191228f, -0.17787181f, -0.21083678f, 
    -0.03904627f, -0.00985747f, -0.92866397f, -0.76962298f, -1.00725639f, 0.30937284f, -0.00377248f, 0.12020531f, 
    -0.15948227f, 0.39112797f, 0.24849513f, 0.69560564f, 0.91498542f, 0.75991750f, -0.19356745f, 0.00419315f, 
    0.48548311f, -0.04810949f, 0.11384674f, -0.22986725f, -0.06229601f, 1.08005500f, -0.38922122f, 0.59086180f, 
    -0.23803943f, -0.98758227f, 0.05287776f, -0.03427878f, -0.20128106f, 0.38060105f, -0.14583515f, 0.99073946f, 
    -0.70414513f, -0.16556795f, -0.76928014f, 0.12677804f, 0.03417737f, 0.14189900f, -0.80908519f, 0.12305362f, 
    -0.08663961f, 0.75203568f, 0.69686711f, 0.21392426f, 0.44832912f, -0.11807080f, -0.39812055f, -0.54965419f, 
    -0.33924791f, 1.08422506f, -0.59059447f, 0.03270984f, 0.82859129f, -0.04656739f, -0.28930503f, 0.07225839f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.16353711f, -0.07028064f, 0.14559400f, 0.03138582f, 0.07737242f, 0.07303667f, -0.33502036f, -0.21204518f, 
    0.31299841f, 0.44622797f, 0.04280519f, 0.51549566f, 0.11862302f, 0.01214689f, 0.01575218f, -0.36311969f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.10959120f, 0.22867554f, 0.13802631f, 0.03258369f, 0.04560471f, -0.06231309f, -0.21023509f, 0.21690407f, 
    0.06316070f, 0.27451441f, 0.04785179f, -0.01338486f, -0.10295302f, -0.25636753f, -0.11822582f, 0.17669463f, 
    -0.08828086f, 0.16052373f, -0.25149557f, -0.02037870f, 0.04404714f, -0.15670003f, 0.07543362f, 0.04043178f, 
    0.09184872f, -0.01311063f, 0.03052933f, -0.40145820f, -0.41677162f, 0.03365174f, 0.17579947f, 0.10983911f, 
    0.07948466f, -0.00166577f, -0.05497188f, 0.10846186f, -0.55788952f, -0.08108982f, -0.08333478f, -0.06092400f, 
    0.01877979f, 0.12459739f, 0.18674743f, -0.09081177f, -0.05130526f, -0.23253058f, -0.19462419f, -0.11124932f, 
    0.12748006f, 0.17431113f, -0.06996559f, 0.04060484f, -0.14967929f, 0.11230762f, -0.27396753f, 0.20348205f, 
    0.08408309f, 0.05816938f, -0.02188094f, -0.16577537f, 0.00854751f, 0.02201304f, 0.10940263f, -0.06895846f, 
    -0.05139462f, -0.27536708f, -0.00018928f, 0.15895489f, 0.00212590f, -0.15488340f, -0.17204425f, -0.20575346f, 
    0.03965663f, 0.05092793f, 0.05255140f, -0.12001350f, -0.05565450f, 0.04406375f, -0.10223685f, -0.09931576f, 
    0.03695630f, -0.32881874f, -0.12793621f, 0.19707038f, 0.03852565f, 0.13575621f, 0.05541626f, -0.02168200f, 
    0.18385668f, -0.06735988f, -1.00362527f, -0.18428037f, 0.26668397f, 0.25394526f, 0.14488959f, -0.04912101f, 
    -0.07159822f, 0.13049880f, 0.02721852f, -0.04209279f, 0.21355592f, 0.22700268f, 0.30332917f, 0.11564790f, 
    -0.07391317f, 0.10472912f, 0.00869730f, 0.08806083f, 0.21888018f, -0.00445974f, 0.11377299f, 0.17990842f, 
    -0.00529454f, -0.08895313f, 0.20271587f, 0.03704336f, -0.06073522f, 0.03076347f, 0.24751036f, -0.02200303f, 
    -0.07208101f, 0.26826930f, 0.16931444f, 0.01639400f, -0.05466123f, 0.03763534f, -0.28964150f, 0.14062324f, 
    -0.06315058f, -0.07961126f, -0.11609242f, 0.08542462f, 0.02720435f, -0.13634728f, 0.00591835f, -0.09997524f, 
    -0.53066802f, -0.27078965f, -0.03272186f, -0.02579947f, -0.05850269f, 0.12461060f, 0.13380964f, 0.00849403f, 
    -0.03475247f, -0.47340977f, 0.10010356f, -0.00669378f, 0.16682540f, 0.05836654f, -0.05379837f, 0.06758709f, 
    -0.01017905f, -0.01554485f, 0.03815114f, -0.36899731f, -0.01076234f, 0.09971085f, -0.10519072f, 0.20499155f, 
    0.05626580f, 0.03337064f, -0.11823135f, -0.44756982f, -0.21338545f, 0.06636806f, -0.02938663f, 0.03799807f, 
    0.04030772f, 0.03835945f, 0.13981588f, 0.41563639f, 0.05175443f, 0.20209192f, -0.09288976f, -0.22650947f, 
    -0.00722705f, -0.01125657f, -0.06919497f, -0.03344296f, 0.07468763f, 0.10840578f, 0.11776013f, 0.05281826f, 
    0.11381879f, -0.00161327f, -0.02564376f, 0.13042900f, 0.17122999f, 0.01386013f, 0.04281584f, 0.05240036f, 
    0.15045670f, -0.08714460f, -0.00104122f, 0.11209057f, 0.22535925f, -0.00005557f, -0.06452739f, -0.54209667f, 
    -0.27119574f, -0.04091750f, 0.06960314f, 0.05433306f, 0.15777797f, -0.25013480f, 0.00275453f, 0.11765233f, 
    0.11185987f, 0.06917538f, -0.00771176f, -0.07291202f, -0.04699927f, -0.11287603f, 0.04570813f, -0.13845721f, 
    -0.39297876f, 0.10731528f, -0.05276299f, 0.26222578f, 0.01838971f, 0.13451082f, -0.21374325f, -0.01222781f, 
    -0.15115154f, -0.08957137f, 0.29933932f, 0.06010259f, -0.00572520f, 0.01497064f, -0.01835757f, 0.14654370f, 
    -0.15389615f, -0.13381507f, -0.13003896f, 0.14051735f, -0.11544672f, 0.12839098f, 0.18204567f, 0.18417269f, 
    -0.11371055f, 0.14629139f, 0.11554901f, -0.50420678f, -0.57885814f, 0.10448828f, -0.06563093f, 0.08892455f, 
    -0.00028887f, 0.07748927f, 0.08702546f, -0.13253026f, 0.68816149f, -0.11247039f, -0.15398435f, -0.04915106f, 
    -0.05711446f, -0.03453479f, -0.22114536f, 0.08466402f, -0.09686074f, 0.05295909f, -0.18351942f, 0.35923296f, 
    -0.06729398f, 0.02738934f, 0.04925516f, 0.00737393f, 0.08135620f, 0.20306870f, 0.01642119f, 0.29751363f, 
    0.15879692f, 0.05752517f, 0.02837929f, 0.09398708f, -0.00743052f, 0.07849348f, 0.13720605f, 0.22979939f, 
    -0.08577907f, 0.02499225f, -0.19468121f, -0.17075314f, -0.01592559f, 0.10600062f, -0.08973875f, -0.02007026f, 
    0.01572288f, 0.02169842f, 0.08050328f, 0.12300736f, -0.15423101f, 0.09801034f, 0.03063158f, 0.01784213f, 
    -0.00331557f, 0.31890389f, 0.16410044f, 0.44146559f, -0.09691611f, -0.14743477f, 0.20508376f, -0.20333233f, 
    0.31140012f, 0.04181712f, 0.30675957f, 0.18586963f, -0.25067541f, -0.03211416f, 0.16127798f, 0.21991673f, 
    -0.11794189f, -0.05666736f, -0.05050337f, 0.27166164f, -0.01120116f, -0.14595979f, -0.03183301f, -0.10613349f, 
    -0.05982838f, 0.20210564f, 0.01512857f, 0.23564579f, -0.24255423f, -0.11021264f, 0.28120619f, -0.05113552f, 
    -0.12290470f, 0.02188444f, -0.02428024f, -0.14058654f, 0.01523548f, -0.16196135f, -0.06100928f, 0.28793257f, 
    -0.53695077f, 0.02646674f, -0.15321606f, -0.01201626f, 0.14239328f, 0.03597876f, 0.07580127f, -0.01996947f, 
    0.13164479f, 0.20108117f, 0.03424806f, -0.17062446f, -0.21321462f, 0.04569011f, 0.00898253f, -0.05614754f, 
    -0.04447060f, -0.08910502f, 0.13508081f, 0.23449783f, 0.20068136f, -0.18806344f, 0.00351984f, 0.05821051f, 
    0.31195921f, -0.06593633f, -0.03269892f, 0.00290700f, 0.05917521f, 0.31272677f, -0.14305699f, 0.02772503f, 
    -0.12410580f, -0.08664402f, -0.20196250f, -0.21682036f, -0.03940230f, -0.06172032f, 0.15962516f, 0.00032975f, 
    0.02526001f, 0.09527388f, -0.10932686f, -0.11178543f, 0.63421828f, 0.12145953f, -0.34161878f, -0.15144466f, 
    -0.05419742f, -0.15006278f, -0.24437490f, -0.24320976f, -0.04618492f, 0.10901168f, 0.32057080f, 0.23303561f, 
    0.00442256f, 0.09096111f, 0.08948110f, 0.07792688f, -0.11371736f, -0.18500453f, -0.22623692f, 0.14307892f, 
    -0.09030361f, -0.18566477f, -0.01346631f, -0.04691100f, 0.02120470f, -0.04112290f, -0.00303341f, -0.24476074f, 
    0.13253161f, 0.08630666f, 0.21552891f, -0.22073504f, -0.15837842f, 0.01164670f, 0.35258451f, 0.18718372f, 
    -0.03533226f, -0.07051694f, -0.03473597f, 0.20350593f, -0.13854440f, 0.03720984f, 0.04942032f, 0.10496292f, 
    0.12617010f, -0.20861462f, -0.14066993f, 0.21156353f, 0.00723600f, -0.05472981f, -0.16962938f, 0.12399795f, 
    0.12178005f, -0.04116061f, 0.02242086f, -0.05898507f, -0.14458108f, -0.10921346f, -0.13207814f, 0.07358171f, 
    0.05433639f, -0.34740609f, -0.29365867f, 0.15295184f, -0.12493337f, 0.09275495f, -0.14379072f, 0.22000083f, 
    -0.01589305f, 0.00582036f, 0.17522725f, 0.04441476f, 0.37197262f, -0.00993179f, 0.07638791f, 0.07948352f, 
    -0.10070563f, 0.03026934f, -0.05390483f, 0.13954468f, 0.21530943f, -0.37941748f, -0.02182671f, 0.01096253f, 
    0.02156267f, 0.01724333f, 0.02349352f, -0.16527349f, 0.27232561f, 0.01026599f, 0.07928745f, 0.04242628f, 
    0.12348825f, 0.11463410f, 0.13570715f, -0.01176583f, 0.25669333f, 0.57505840f, -0.04652429f, 0.06768163f, 
    0.06113125f, -0.14548466f, 0.14359304f, -0.06197822f, -0.07163303f, 0.11921258f, 0.02186764f, 0.14600652f, 
    0.21338156f, 0.04549144f, -0.05464520f, -0.01238374f, 0.02109051f, -0.05160661f, -0.04078030f, -0.01342406f, 
    0.14236531f, -0.02465712f, -0.06759065f, 0.06585113f, 0.23809011f, -0.15136765f, -0.13324019f, 0.07173946f, 
    0.21163622f, -0.17779404f, 0.19604249f, -0.18610816f, 0.00893879f, -0.11057962f, -0.01884717f, -0.06318339f, 
    -0.19660202f, 0.15807213f, 0.01809932f, -0.40271413f, 0.07968491f, 0.00200590f, -0.00448980f, -0.28688785f, 
    0.11337322f, -0.11632947f, 0.09079545f, 0.07177838f, 0.11971373f, 0.02652530f, -0.13922529f, -0.00209493f, 
    0.11469270f, 0.09952344f, 0.16075379f, 0.18482964f, 0.14917472f, 0.12207235f, -0.07130557f, -0.05805935f, 
    0.07041556f, 0.23779409f, 0.13712445f, 0.00384344f, -0.05971345f, -0.41280299f, -0.01334102f, -0.13636541f, 
    0.16526359f, -0.08903915f, -0.06960896f, -0.20043004f, -0.00549943f, -0.25164059f, 0.00759400f, -0.23669180f, 
    0.01423204f, -0.02508966f, -0.10948614f, 0.18521486f, -0.07562141f, -0.07654083f, 0.26005876f, -0.00441375f, 
    0.11500395f, -0.05931542f, -0.01891177f, 0.07812010f, -0.09745716f, 0.02099680f, -0.21630140f, -0.38969526f, 
    -0.02074726f, -0.44150624f, -0.37720454f, -0.00485789f, -0.15960830f, -0.13364288f, -0.02673818f, -0.03226849f, 
    -0.02468871f, 0.02550723f, 0.05259819f, 0.03659172f, 0.02528600f, -0.02654425f, 0.01811196f, 0.05824105f, 
    -0.02599774f, -0.06268737f, -0.02857716f, -0.07036537f, 0.00195636f, -0.00765935f, 0.06795926f, -0.00654832f, 
    -0.07802210f, 0.04830965f, -0.01036046f, -0.06881797f, -0.07952727f, -0.04657760f, -0.08362979f, -0.04249241f, 
    -0.07828444f, -0.03601111f, -0.08510801f, 0.02797135f, 0.04903375f, 0.05214856f, -0.02087349f, 0.03561243f, 
    -0.04338113f, -0.07096148f, -0.02536558f, 0.02569082f, 0.03781343f, 0.01076873f, -0.02556323f, 0.06076135f, 
    -0.02874529f, 0.01687575f, -0.01578948f, 0.06018388f, 0.02433849f, -0.05040127f, -0.03114047f, 0.03871011f, 
    0.00425037f, 0.01782067f, 0.06715513f, -0.06899046f, 0.01883297f, 0.04761559f, 0.01843142f, 0.01988152f, 
    0.00514233f, 0.01772670f, -0.00438579f, 0.02554011f, -0.01901082f, -0.03364171f, -0.08395798f, -0.06420775f, 
    0.00281492f, -0.03929306f, 0.04820957f, -0.01540488f, -0.08065052f, -0.03036925f, -0.04204651f, -0.03874508f, 
    0.04619358f, 0.02919060f, -0.05019286f, -0.02459928f, 0.02746394f, 0.03244938f, 0.03138588f, -0.04226945f, 
    0.02048906f, -0.07562876f, -0.09292711f, 0.01148051f, -0.00811751f, -0.09808151f, -0.05798138f, -0.08176461f, 
    0.00452500f, -0.02712748f, 0.04506394f, 0.02535477f, 0.02440027f, -0.03099795f, -0.09030395f, -0.02217370f, 
    0.03998684f, -0.02725786f, -0.05155686f, 0.03686710f, -0.00102160f, -0.04784202f, 0.03768088f, 0.03889136f, 
    0.02386918f, -0.08600494f, -0.04338269f, -0.08673709f, -0.04578437f, -0.03255739f, -0.06108322f, 0.04008157f, 
    -0.00552970f, -0.09283682f, -0.05824290f, 0.05863947f, 0.04651853f, -0.00166617f, -0.01296633f, 0.00982388f, 
    0.00660474f, -0.01514106f, -0.06048573f, 0.02875696f, -0.02004366f, 0.00924095f, 0.03279882f, -0.06497840f, 
    0.05054898f, -0.01084896f, -0.03850044f, 0.02828208f, 0.00139766f, 0.06039669f, 0.01233315f, -0.05963937f, 
    0.00093549f, -0.07045867f, -0.04113697f, 0.06891172f, 0.04326487f, 0.06212131f, 0.03588635f, -0.05724318f, 
    0.12951824f, 0.13337488f, -0.16591851f, 0.11441690f, 0.02395147f, -0.20208262f, 0.08741678f, 0.03285992f, 
    -0.18759081f, -0.27255869f, -0.24170767f, -0.05079973f, 0.11558513f, -0.09854233f, 0.21274351f, -0.11210165f, 
    -0.24486588f, -0.15392657f, 0.32810077f, -0.06546222f, -0.22046840f, -0.01454610f, 0.13959685f, -0.12622686f, 
    0.02517421f, 0.09964637f, -0.07614655f, -0.03842643f, 0.04126643f, -0.14638616f, 0.10020337f, 0.05398740f, 
    0.00494285f, 0.02864110f, -0.14089678f, -0.01635665f, -0.34806776f, 0.03135860f, 0.17649418f, -0.20639804f, 
    0.10172629f, 0.07684141f, -0.17532392f, 0.24741738f, 0.13323003f, -0.21406139f, 0.13805366f, 0.11695992f, 
    0.12105450f, -0.01255713f, -0.07944080f, -0.14214292f, -0.09418602f, 0.06757758f, 0.50460130f, 0.02014582f, 
    -0.06464461f, 0.14772502f, -0.01409387f, -0.10195410f, 0.22902010f, 0.06126126f, -0.12125799f, -0.18610004f, 
    -0.17076592f, 0.08991591f, 0.20980062f, -0.02051109f, 0.18309127f, 0.08028530f, -0.03743978f, -0.08218428f, 
    0.17180295f, -0.25010568f, -0.08127732f, -0.11386515f, 0.10634205f, -0.03395979f, -0.08339461f, 0.00249916f, 
    -0.12718184f, 0.02121875f, 0.18622670f, 0.03851624f, -0.29601330f, 0.00029657f, -0.08754665f, -0.05696079f, 
    -0.00995089f, 0.00546443f, 0.24521476f, 0.13452880f, -0.06632969f, -0.15418477f, -0.05128692f, 0.02174154f, 
    -0.08392473f, 0.08329703f, 0.00191311f, 0.43225381f, 0.06964060f, 0.11153051f, 0.04592220f, -0.04987818f, 
    0.14816229f, 0.13382985f, -0.07621129f, 0.13421877f, 0.30251193f, -0.29164657f, -0.07064091f, 0.10055507f, 
    0.01487824f, 0.01154098f, 0.10351574f, -0.12301147f, 0.02348524f, 0.34632549f, 0.28058299f, -0.20166138f, 
    0.09399878f, 0.07702986f, -0.09222878f, 0.28684819f, -0.10164618f, 0.27633664f, -0.29248318f, -0.17159462f, 
    -0.02556265f, -0.00225294f, 0.00307230f, 0.25738192f, -0.13187224f, 0.29290479f, 0.21607138f, -0.36356348f, 
    0.16519196f, 0.05869517f, 0.08425458f, 0.07829761f, -0.14134392f, 0.03611490f, 0.06399431f, -0.08237440f, 
    0.11584800f, -0.33299839f, 0.16355553f, -0.04804906f, 0.06512708f, -0.16954611f, 0.05143598f, 0.18316966f, 
    -0.02837101f, 0.38491666f, 0.02266561f, 0.09364558f, -0.09375042f, 0.26519513f, -0.06722255f, -0.02013050f, 
    0.04323015f, -0.20085600f, -0.05680264f, -0.09915648f, 0.12793599f, 0.13927385f, -0.09513462f, -0.13742769f, 
    -0.03502958f, -0.18123049f, 0.27560994f, -0.67329139f, -0.02394920f, -0.23868515f, -0.03829945f, -0.17777810f, 
    -0.00187996f, -0.09669592f, 0.10064310f, -0.04702768f, -0.15477361f, 0.34828889f, -0.00807172f, 0.16250651f, 
    -0.01592971f, -0.12312312f, 0.10895285f, -0.16634396f, -0.15515116f, -0.17931733f, 0.43011308f, -0.02471364f, 
    -0.08225520f, -0.04023616f, -0.15754017f, -0.14764747f, 0.11315534f, 0.03031601f, 0.15684490f, -0.44630870f, 
    0.23262192f, 0.04503291f, -0.00708276f, -0.01266070f, 0.24658395f, -0.18922207f, -0.24199103f, 0.35301220f, 
    -0.45423022f, 0.09270567f, 0.04637808f, -0.10737365f, 0.05279479f, -0.23360626f, -0.16569519f, 0.07354708f, 
    0.17187786f, 0.09595424f, 0.14524437f, -0.06848790f, 0.00522866f, -0.05563531f, 0.15027709f, 0.14925933f, 
    0.00928357f, 0.19764102f, -0.24180681f, -0.28905004f, -0.02377342f, -0.21178444f, -0.10858615f, 0.17213540f, 
    0.07980406f, 0.12537327f, -0.00545755f, 0.47140661f, 0.15505230f, 0.23632284f, -0.20984116f, 0.11174045f, 
    0.04021329f, 0.08064651f, 0.04584670f, -0.17020352f, -0.16727652f, 0.08751007f, 0.30546409f, -0.19683631f, 
    -0.12992817f, 0.04761674f, -0.21076493f, 0.08845834f, -0.09456863f, -0.32008433f, -0.08433716f, -0.14467029f, 
    -0.12203099f, 0.23181573f, -0.32831272f, 0.15783633f, 0.04081025f, -0.18720105f, -0.53093910f, -0.36693805f, 
    0.22854756f, 0.16382353f, -0.22720093f, -0.11155188f, 0.04170190f, 0.17660628f, 0.02661464f, 0.05219719f, 
    0.30161488f, -0.18051301f, 0.09896096f, 0.05727449f, 0.13166480f, 0.05178117f, 0.20601115f, -0.23479140f, 
    0.47311884f, 0.09167524f, 0.10009051f, -0.19555019f, -0.17904139f, 0.13436177f, 0.20761847f, -0.06234246f, 
    0.19307944f, 0.36364061f, 0.05056579f, 0.16026254f, 0.01158028f, -0.21755001f, 0.07856116f, 0.06096474f, 
    0.06289133f, 0.21938096f, 0.15467255f, 0.18160622f, -0.10901359f, -0.05686976f, -0.11052117f, 0.15703633f, 
    -0.08196372f, 0.06508799f, 0.14356545f, -0.16789016f, -0.10692749f, 0.13629989f, 0.08937552f, -0.11956763f, 
    -0.27450240f, 0.21292016f, 0.07444133f, 0.15313587f, -0.15108056f, -0.16669904f, 0.03071694f, -0.01407628f, 
    -0.02433543f, 0.04922843f, -0.02787019f, 0.23766473f, -0.02276063f, 0.03652012f, -0.20089301f, -0.23617955f, 
    0.18138258f, -0.00435967f, 0.17011681f, -0.10709475f, 0.07382596f, 0.13883816f, 0.24298638f, 0.08944558f, 
    -0.26356524f, 0.18356590f, -0.15307845f, 0.07804592f, -0.02507964f, 0.11894450f, -0.33866978f, 0.25115103f, 
    -0.38027987f, 0.19285558f, -0.25958806f, -0.23343422f, 0.04846906f, -0.04954090f, -0.12940915f, 0.14755000f, 
    -0.14507930f, 0.05852507f, -0.01378537f, 0.06482843f, -0.10347686f, -0.04632218f, 0.15248598f, 0.12995395f, 
    0.33048204f, 0.18864585f, -0.12177296f, 0.04340208f, -0.04028707f, 0.05012322f, 0.09273729f, 0.18087241f, 
    0.05850710f, -0.16905083f, 0.18046963f, -0.17819186f, 0.04764201f, 0.05452382f, -0.01050709f, -0.03500365f, 
    -0.14379750f, -0.00593665f, 0.01756712f, -0.08379766f, 0.31328708f, -0.08941296f, -0.10016640f, 0.22502741f, 
    -0.06027405f, -0.00664915f, -0.21178544f, -0.20783299f, 0.20166716f, -0.14638010f, 0.03717202f, -0.02847265f, 
    0.01535839f, 0.02834538f, 0.20810759f, 0.15555146f, -0.16120307f, 0.03089000f, -0.00704980f, 0.37285790f, 
    0.00695534f, 0.17345402f, 0.01931426f, -0.00814184f, 0.30561689f, -0.00367255f, -0.14104840f, -0.49153933f, 
    0.06214856f, 0.19142930f, 0.26089749f, 0.05420601f, 0.13082048f, -0.18911903f, 0.30135632f, -0.09527920f, 
    0.01840738f, -0.01482358f, -0.08872525f, -0.10709982f, 0.15514886f, -0.12614669f, -0.07057314f, 0.03804126f, 
    -0.08697340f, -0.30730274f, -0.20019998f, -0.10206416f, 0.12497067f, 0.09575760f, -0.16470240f, 0.17675491f, 
    -0.07291236f, 0.06742365f, -0.17544878f, -0.26591274f, -0.10206214f, -0.37252182f, 0.15923625f, -0.07457163f, 
    -0.07305797f, -0.10262581f, 0.04772239f, -0.10658285f, -0.23654255f, -0.00865880f, 0.11873105f, -0.09001844f, 
    0.08853544f, -0.45825189f, -0.03260637f, 0.06465942f, -0.18758044f, -0.02968835f, 0.06080834f, 0.04026010f, 
    -0.15374126f, -0.12371328f, -0.06464840f, -0.07124620f, 0.24929380f, -0.21808389f, -0.20686816f, -0.09250225f, 
    -0.01309673f, 0.27159432f, 0.04836539f, -0.10039828f, -0.01529009f, 0.09209935f, 0.34187374f, 0.01044822f, 
    0.04411539f, 0.07417777f, -0.12189108f, 0.03573114f, 0.23223808f, 0.03958206f, 0.09259145f, 0.08911695f, 
    0.07569935f, 0.10050886f, 0.25619051f, 0.00790533f, 0.14151751f, 0.07461744f, -0.16262600f, 0.09932362f, 
    -0.38126978f, 0.02721775f, 0.17475337f, -0.40702048f, -0.08017537f, -0.05433258f, -0.10751650f, -0.50143385f, 
    0.06056871f, -0.07026169f, -0.19102027f, 0.05286586f, 0.04581385f, -0.27433664f, 0.06958293f, -0.05167578f, 
    -0.03563052f, -0.12746139f, -0.26756251f, -0.03586573f, 0.21825671f, 0.01307113f, 0.13188465f, -0.21883960f, 
    -0.18615195f, 0.08176039f, 0.25228649f, 0.07671944f, -0.06282458f, 0.05511827f, -0.09563769f, 0.20367597f, 
    0.16772492f, 0.28101271f, -0.00650405f, -0.11034185f, 0.22320795f, 0.10684786f, -0.09825092f, 0.23733491f, 
    0.06506540f, 0.04701805f, 0.12926823f, 0.14859655f, 0.36052868f, -0.06770569f, -0.20051186f, 0.05964739f, 
    -0.00532761f, 0.04270355f, 0.00880075f, -0.21804254f, 0.09609888f, 0.35083008f, 0.00813151f, 0.05390547f, 
    -0.00854744f, 0.03488686f, 0.11160196f, -0.03107307f, 0.25900975f, -0.03883938f, -0.18493028f, 0.02394653f, 
    0.12091120f, -0.05811401f, -0.02492679f, 0.01892444f, 0.14816639f, 0.04660145f, 0.04520233f, 0.10822554f, 
    0.03161654f, 0.11345560f, -0.01594033f, 0.24208908f, -0.01258331f, 0.05030194f, -0.10568665f, 0.11131407f, 
    -0.33876839f, -0.25856411f, -0.21569173f, 0.18830006f, 0.27010953f, 0.11703011f, -0.23876740f, -0.37351948f, 
    0.38424355f, 0.19526632f, 0.06392808f, -0.07083347f, 0.08873000f, -0.05083980f, 0.00995464f, 0.01103992f, 
    -0.08492644f, 0.05375528f, 0.22754493f, -0.09140088f, -0.29092929f, 0.05971072f, 0.06768894f, -0.11405490f, 
    -0.12925202f, 0.07812729f, 0.02063819f, -0.25857091f, 0.15963688f, 0.05883493f, 0.05405512f, 0.11241823f, 
    0.01157855f, 0.08111535f, 0.13458864f, -0.20563911f, -0.25396830f, 0.17999774f, 0.21562271f, -0.23522893f, 
    -0.06756246f, 0.01004189f, 0.16060452f, 0.11011148f, -0.36840534f, 0.33415782f, 0.05516858f, 0.07154232f, 
    -0.01049161f, 0.30012339f, -0.11352901f, -0.19182630f, -0.13632280f, -0.46064144f, 0.39128432f, -0.58770013f, 
    0.08649002f, 0.08363419f, 0.10130840f, 0.07844882f, 0.08599523f, 0.19770215f, 0.42976826f, 0.02853493f, 
    -0.13669567f, 0.13318329f, 0.07935968f, 0.07260978f, -0.06530349f, 0.02087511f, -0.02562716f, 0.26862442f, 
    0.24400668f, 0.14488207f, -0.01874571f, -0.10553489f, 0.14354652f, -0.31191349f, -0.02997506f, 0.00857671f, 
    -0.17522433f, 0.05429466f, 0.49810761f, 0.06608727f, 0.07601099f, -0.09500165f, 0.04872719f, -0.00280171f, 
    0.23689410f, 0.11266385f, 0.11957422f, 0.15015915f, 0.00974686f, 0.06816474f, -0.09987926f, 0.05592176f, 
    0.04565641f, -0.01398167f, -0.03261433f, 0.02548498f, -0.41308427f, -0.12648289f, 0.10707098f, 0.06322882f, 
    0.01271087f, -0.07077466f, -0.19566481f, 0.58296567f, 0.27931002f, -0.03695749f, -0.02612949f, -0.20701644f, 
    -0.10879420f, -0.03252530f, 0.10884986f, -0.05881874f, 0.19085637f, -0.21796092f, 0.09219421f, 0.08832987f, 
    -0.02963891f, -0.18179472f, 0.19823512f, 0.13716365f, -0.15772291f, 0.40000498f, -0.08796944f, -0.28244272f, 
    -0.04161840f, -0.19719867f, 0.03159452f, 0.06057938f, 0.22013940f, -0.14067468f, 0.09738879f, 0.16898312f, 
    0.25020629f, -0.04811288f, -0.15461724f, -0.07128830f, -0.11913382f, -0.07189827f, -0.03993162f, -0.55503404f, 
    -0.19607402f, -0.21304493f, -0.12077742f, -0.07845911f, -0.01640091f, 0.06801290f, 0.02778304f, 0.12323862f, 
    -0.30724129f, -0.01755792f, 0.09057898f, 0.04827829f, 0.02749413f, 0.00415425f, 0.14997543f, -0.14297400f, 
    0.04302179f, -0.00943636f, 0.27922952f, 0.20118237f, 0.20138109f, 0.02506676f, -0.10560516f, 0.07140567f, 
    0.12161624f, -0.07046558f, -0.72490889f, -0.17018227f, 0.14970252f, 0.19546528f, 0.19233771f, 0.02575144f, 
    -0.19840077f, -0.11407225f, 0.22086076f, 0.13824950f, 0.09766427f, -0.25780225f, -0.12023208f, -0.24822645f, 
    -0.03207481f, 0.10245517f, 0.07537684f, 0.05761686f, 0.27657387f, -0.09476996f, 0.06716652f, -0.00042939f, 
    -0.00306023f, -0.15377584f, 0.08003173f, 0.06993795f, -0.01641189f, 0.47498649f, -0.02765933f, -0.15658459f, 
    0.06500750f, 0.01954315f, -0.11280672f, 0.00248928f, -0.00087269f, 0.17006283f, -0.29280123f, -0.03796001f, 
    -0.17438461f, 0.11513627f, 0.02406711f, 0.05463734f, -0.14161548f, -0.05878902f, 0.04291697f, -0.27907750f, 
    -0.26934427f, -0.21699502f, -0.07802419f, 0.02698502f, 0.07218039f, -0.00666698f, -0.00730318f, -0.19908451f, 
    -0.28818026f, -0.05292932f, -0.01628838f, -0.02623655f, 0.20259959f, -0.10259936f, 0.07107931f, -0.03041636f, 
    0.28594673f, -0.24901336f, -0.07036978f, -0.31830171f, 0.11499842f, -0.03078855f, -0.00105614f, -0.00758133f, 
    -0.09962238f, -0.06359123f, 0.31687036f, 0.11768895f, 0.03943056f, -0.26029590f, -0.15131372f, -0.09257036f, 
    -0.00156559f, 0.15150468f, -0.07204517f, -0.19823895f, 0.00907527f, -0.26808771f, 0.03134549f, 0.15223145f, 
    0.21076629f, -0.07545678f, -0.09043730f, -0.05836077f, 0.30477664f, -0.24060719f, -0.03980242f, -0.08201104f, 
    0.04438961f, 0.12772065f, -0.09658338f, 0.00559918f, 0.02936918f, -0.06446351f, 0.23682290f, 0.09210839f, 
    0.17516924f, 0.15152557f, 0.20002379f, -0.19126648f, 0.07681623f, -0.16674818f, 0.52126580f, 0.10359777f, 
    -0.09913865f, 0.05767207f, -0.09961759f, 0.01167283f, 0.21230757f, 0.18364854f, 0.05968226f, -0.31127331f, 
    0.04486629f, 0.11746481f, -0.15166125f, -0.09587969f, 0.10228150f, 0.08086567f, -0.02143229f, 0.10450891f, 
    -0.33738112f, 0.14468944f, 0.17305493f, -0.16267960f, 0.00836540f, -0.07830597f, 0.11266779f, 0.11137531f, 
    -0.03236327f, 0.04653060f, -0.48348361f, -0.15229104f, 0.23394054f, 0.10149457f, 0.20353577f, -0.13373083f, 
    0.12333389f, -0.03909568f, -0.34716809f, 0.21662135f, 0.21611178f, 0.03985943f, 0.09761567f, -0.09449390f, 
    0.07398164f, 0.03999182f, 0.01713193f, 0.39518952f, -0.25058734f, -0.03487117f, -0.04834109f, -0.14112605f, 
    0.02152228f, 0.14502595f, 0.23969349f, 0.03252524f, -0.01238982f, -0.11161187f, -0.36923152f, -0.14007720f, 
    -0.03667349f, 0.00447632f, -0.17373466f, -0.02349051f, -0.06421955f, -0.33128196f, -0.26689455f, -0.06025413f, 
    0.13114564f, 0.04806100f, 0.07365929f, -0.04491548f, -0.13433619f, 0.05142289f, -0.00281213f, -0.07632869f, 
    0.29491168f, 0.01424176f, -0.22429518f, 0.06985799f, 0.03477926f, 0.06733885f, -0.14175327f, -0.59439671f, 
    -0.03676080f, -0.13582756f, -0.12713754f, -0.02542330f, -0.04873099f, -0.10814387f, 0.02607923f, 0.02691519f, 
    -0.11986582f, -0.12561634f, 0.16863070f, 0.13259417f, -0.25712684f, 0.04178950f, -0.03592681f, 0.15288863f, 
    0.13115363f, -0.25946829f, -0.02192578f, -0.04890408f, 0.05070889f, 0.17008981f, -0.01466544f, 0.02798319f, 
    0.05329862f, 0.18217684f, 0.01904225f, 0.13907319f, -0.26281053f, -0.01708466f, 0.08618896f, 0.01572331f, 
    0.04855458f, 0.05482936f, 0.00202715f, -0.22634917f, 0.42394528f, 0.28575864f, 0.04270007f, 0.11015149f, 
    0.03160961f, 0.23208010f, 0.09323060f, 0.00305855f, 0.08990552f, -0.08767384f, -0.12199994f, -0.01848610f, 
    -0.01916518f, 0.12591167f, 0.19384040f, 0.00816396f, 0.21784687f, 0.08548508f, 0.02189345f, 0.22507951f, 
    -0.05789119f, -0.02490800f, -0.00173236f, 0.10178419f, -0.03761977f, -0.07289911f, 0.34737408f, -0.04857502f, 
    0.07349142f, 0.04399685f, 0.04231177f, 0.09317365f, -0.03008661f, 0.09187227f, -0.07277413f, 0.03706765f, 
    -0.59375763f, -0.07717687f, 0.04071758f, -0.06496610f, -0.02387822f, -0.21829346f, -0.16037467f, 0.10020405f, 
    0.07947259f, 0.36079797f, 0.22388749f, -0.05413958f, 0.04684421f, 0.02366965f, 0.09422405f, -0.08613724f, 
    -0.12100250f, 0.71748447f, -0.10044513f, -0.45947126f, 0.19517033f, 0.20363578f, 0.12292297f, 0.13897216f, 
    -0.07115479f, 0.10725169f, 0.23387544f, 0.15337098f, 0.10501216f, -0.29840925f, -0.05288883f, -0.07156584f, 
    0.14461444f, 0.18386959f, -0.09435163f, 0.01482161f, -0.40344721f, -0.00545965f, 0.03961492f, -0.17222910f, 
    -0.00221282f, -0.04357158f, 0.03040816f, 0.11145367f, -0.05710131f, -0.06833576f, -0.27318093f, 0.13197063f, 
    0.22461906f, 0.10540817f, -0.14565927f, -0.02997884f, -0.07029006f, 0.13242209f, 0.24801397f, -0.29485631f, 
    0.09277057f, -0.06642101f, 0.14488505f, -0.15213472f, 0.17495155f, 0.07715084f, -0.06206294f, 0.11980168f, 
    0.07867540f, -0.34366283f, -0.17526975f, -0.16853051f, -0.07189857f, -0.08712807f, -0.15434371f, -0.32340068f, 
    0.03181458f, 0.14793095f, -0.07888357f, -0.03975178f, 0.06004291f, 0.04226596f, 0.00187223f, -0.00105341f, 
    -0.11361440f, 0.04157155f, 0.21887860f, -0.05661301f, 0.16487430f, 0.06631191f, -0.05755156f, 0.06794968f, 
    -0.37485644f, 0.48196930f, -0.46490863f, -0.08551157f, -0.24869706f, -0.00776766f, -0.15013945f, -0.08351093f, 
    0.10255274f, -0.03969676f, -0.19423588f, -0.12437722f, -0.34479553f, 0.14112836f, 0.17546041f, -0.16356692f, 
    0.19275841f, -0.15628004f, 0.01616533f, 0.18676257f, 0.16762462f, 0.38303885f, -0.01071593f, -0.15929894f, 
    -0.18865828f, 0.00155458f, 0.10299311f, 0.10573153f, -0.13654473f, 0.13610032f, 0.18432601f, -0.01564527f, 
    0.05666819f, -0.09502579f, 0.03540118f, -0.02562698f, 0.17420705f, 0.22444043f, 0.07782734f, 0.01458550f, 
    -0.18805815f, 0.09305081f, -0.11988406f, -0.18060495f, 0.26481810f, 0.19992152f, -0.06916417f, -0.15368240f, 
    -0.13385440f, 0.09614792f, 0.29300037f, 0.11111126f, 0.04815429f, -0.13092831f, -0.09742769f, 0.01482638f, 
    -0.28050396f, 0.22338380f, -0.33559501f, 0.01577048f, -0.11681791f, 0.08188597f, -0.05023204f, -0.04153186f, 
    -0.04942605f, -0.08951689f, -0.07689769f, 0.04355621f, -0.00075639f, -0.06250468f, -0.01662034f, 0.05427077f, 
    0.05476791f, -0.07850194f, -0.04445247f, -0.08138481f, 0.00309854f, -0.04250187f, -0.04367998f, -0.10770215f, 
    0.04622777f, -0.03394888f, -0.02998925f, 0.01665569f, -0.00009160f, -0.03108858f, -0.03229218f, -0.10110694f, 
    -0.06216084f, 0.02830351f, 0.01267254f, -0.10232089f, 0.03240501f, -0.09740798f, -0.14676137f, -0.02730775f, 
    -0.09519201f, -0.00239928f, -0.04701285f, 0.04965775f, -0.07073145f, -0.05863341f, -0.15537718f, -0.02581842f, 
    -0.06182975f, -0.00200704f, -0.05710966f, -0.02515287f, -0.04196842f, -0.05135982f, -0.01872800f, 0.00240186f, 
    -0.12733541f, -0.06863546f, -0.08821584f, -0.05198687f, 0.01884038f, 0.01559569f, 0.01380880f, 0.01162355f, 
    -0.02356845f, -0.01137746f, 0.00610736f, 0.05338549f, 0.01299059f, 0.04203625f, 0.04814762f, -0.11838052f, 
    0.01069536f, -0.06780108f, -0.01434036f, -0.07387599f, 0.06070618f, -0.00039984f, -0.04741976f, -0.05808178f, 
    0.03930556f, 0.05999462f, 0.00032142f, -0.02883638f, -0.05799853f, 0.08389035f, -0.01196601f, -0.07843405f, 
    0.03410914f, -0.05732397f, -0.08315749f, -0.07125020f, -0.08493046f, -0.02302772f, -0.04864718f, -0.15798250f, 
    0.02331390f, -0.12745288f, -0.11308714f, -0.00963583f, 0.00508712f, -0.00027662f, -0.10589007f, 0.04360694f, 
    -0.09004407f, -0.10244953f, -0.07657596f, -0.12076432f, 0.04495578f, 0.00169970f, 0.04777902f, -0.00416595f, 
    -0.05355267f, -0.09078397f, 0.04479202f, -0.08997063f, -0.10241599f, 0.06146028f, -0.01698569f, -0.02557789f, 
    0.01818689f, -0.03556159f, -0.06667426f, -0.08331212f, -0.08798999f, -0.08225958f, -0.00388725f, -0.01038773f, 
    0.00137638f, -0.11502443f, -0.11837000f, -0.00541271f, 0.00805676f, -0.06117957f, -0.02224667f, -0.03272602f, 
    0.01490605f, 0.01977930f, -0.00508884f, 0.04935386f, -0.05030560f, -0.06829344f, -0.02094994f, -0.00906828f, 
    -0.04932632f, -0.04613661f, 0.03146329f, -0.05328266f, -0.06482884f, -0.00408152f, -0.02755703f, 0.04430014f, 
    0.07598279f, 0.07378609f, 0.12575650f, 0.00875959f, 0.00090204f, -0.28525975f, 0.00892593f, -0.03595584f, 
    0.13776192f, 0.19416592f, -0.02836562f, 0.10666754f, 0.01588614f, 0.22308873f, -0.33211407f, 0.15371512f, 
    -0.01085555f, -0.06299692f, -0.16013688f, 0.24803086f, 0.24150385f, -0.14739060f, -0.01158215f, 0.01792129f, 
    -0.11455124f, 0.03077512f, 0.09985854f, -0.35233301f, -0.17248681f, -0.05946267f, 0.09843614f, 0.13760193f, 
    0.16431087f, 0.12429166f, 0.04521762f, 0.07892649f, 0.42850563f, -0.17067072f, -0.29040086f, 0.06406765f, 
    -0.01220444f, 0.04669200f, 0.00236657f, -0.00257625f, -0.17640671f, 0.34735215f, -0.00217965f, 0.06156060f, 
    -0.04756238f, -0.05580125f, -0.06292000f, 0.06776907f, -0.03862504f, 0.02416342f, -0.21351351f, 0.31610733f, 
    0.13265255f, -0.01279134f, -0.30606732f, -0.07115252f, -0.02149930f, -0.18733867f, 0.07042066f, 0.05108839f, 
    -0.18075159f, 0.02147189f, -0.10647604f, -0.16696987f, 0.05048514f, -0.03926321f, -0.17509055f, -0.03752163f, 
    0.03980209f, 0.12535210f, 0.12943187f, -0.12720972f, 0.04210412f, -0.16970435f, -0.05699505f, -0.07639393f, 
    0.16186856f, -0.03274067f, -0.15371004f, -0.51558435f, 0.19672303f, 0.26193318f, 0.22904718f, 0.14421105f, 
    0.05505197f, 0.02869085f, -0.06219195f, 0.10495605f, -0.09474864f, 0.19025145f, 0.00676051f, -0.00781997f, 
    -0.06230194f, 0.02475728f, 0.13891263f, 0.17854974f, 0.13602829f, -0.20798858f, 0.07925314f, -0.17291403f, 
    0.10253707f, 0.00128178f, 0.10871668f, -0.02125725f, -0.01143900f, -0.47730029f, -0.16691962f, 0.01814335f, 
    0.16578260f, -0.01011339f, -0.01468599f, 0.06552226f, -0.00992434f, -0.16721983f, -0.23776193f, -0.17943670f, 
    0.11445444f, -0.04893999f, 0.14971571f, 0.07295354f, 0.01204546f, 0.09398849f, -0.17904247f, -0.04875331f, 
    -0.19599181f, -0.03214941f, -0.11208665f, -0.13964872f, 0.11173388f, 0.07294735f, 0.03842960f, -0.84703201f, 
    0.01556326f, -0.23026069f, 0.11279612f, -0.00442081f, -0.21158336f, 0.09452018f, -0.05673050f, 0.08814006f, 
    -0.34595019f, 0.14854220f, 0.21863091f, 0.10588218f, -0.13591097f, 0.02359655f, 0.13680093f, 0.03098483f, 
    0.00463226f, 0.06352602f, -0.20132530f, -0.19552912f, -0.17904635f, 0.21526878f, -0.18958552f, 0.00176373f, 
    0.05349319f, 0.06956883f, 0.39230597f, 0.30930367f, -0.16029994f, -0.14913636f, 0.13279313f, 0.11785997f, 
    -0.02749536f, 0.05624408f, -0.20650430f, 0.04584299f, 0.03379189f, -0.10756429f, 0.01398076f, -0.17451295f, 
    0.04291217f, -0.03734840f, 0.09392262f, -0.05437918f, 0.42649740f, 0.21360078f, 0.43316418f, -0.02098671f, 
    0.10325581f, -0.03177495f, 0.05692333f, 0.00847892f, 0.04911496f, 0.30983797f, -0.23721765f, 0.22579584f, 
    0.11250862f, 0.18424095f, -0.09508631f, -0.16398002f, 0.04938408f, -0.08286609f, -0.52517635f, 0.07467835f, 
    -0.23713617f, 0.16799334f, -0.05944749f, -0.09178635f, -0.07453380f, -0.15976673f, 0.22770835f, -0.35403359f, 
    0.10044459f, 0.19714902f, 0.15485309f, 0.16178258f, -0.18615076f, 0.24163108f, 0.03693724f, -0.04119118f, 
    0.06335464f, 0.18919283f, -0.04488811f, 0.05369832f, 0.03696610f, -0.15498622f, 0.23392324f, -0.01338021f, 
    -0.04578131f, -0.05969146f, -0.09189805f, 0.26694387f, 0.08442139f, -0.14600521f, 0.03572704f, -0.18133779f, 
    -0.08532870f, -0.42989254f, 0.29110751f, 0.27050245f, 0.42041633f, 0.25869867f, 0.12403737f, 0.34663579f, 
    -0.09186035f, 0.16255602f, -0.10670660f, 0.05951559f, -0.19587246f, -0.02326129f, -0.13395247f, -0.15412144f, 
    0.05300507f, -0.20158263f, 0.03981979f, -0.01987831f, -0.52092373f, 0.00068676f, 0.18771392f, -0.06034707f, 
    -0.09650806f, 0.02254838f, 0.03388970f, 0.09082389f, -0.21000980f, 0.11265528f, -0.10743171f, -0.04529920f, 
    -0.26104239f, -0.14535905f, 0.02079613f, -0.13157028f, -0.24989566f, 0.10970207f, 0.16903584f, 0.34853399f, 
    0.23566674f, -0.09330913f, -0.00523101f, 0.37976712f, 0.10708269f, 0.10823812f, 0.28351226f, -0.09228712f, 
    -0.21818860f, -0.02484857f, -0.23002642f, -0.05061228f, -0.08280113f, 0.04141462f, 0.11990917f, 0.04868965f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.14743724f, -0.01747674f, -0.01016094f, 0.00622899f, -0.09405859f, 0.07787348f, 0.19004245f, 0.33537903f, 
    0.13972890f, 0.05131232f, 0.17158338f, 0.15487406f, 0.05419056f, -0.06555722f, 0.22893979f, -0.15228489f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.18263355f, 0.24421242f, 0.23105788f, -0.05101526f, 0.03131859f, 0.41438809f, -0.20554431f, -0.36399400f, 
    -0.12306421f, 0.32061046f, 0.32330906f, 0.33648431f, 0.01147395f, 0.08161043f, -0.50168735f, -0.02427415f, 
    0.19865333f, 0.01472648f, -0.35724491f, 0.35100514f, 0.21566108f, 0.14622363f, 0.32092050f, -0.02485236f, 
    0.49623066f, -0.48026782f, 0.03191961f, 0.18109657f, -0.27614370f, -0.09376249f, -0.27546859f, 0.06970011f, 
    -0.48651794f, 0.39082503f, 0.10070312f, -0.43207398f, -0.19167520f, 0.14084576f, 0.59323186f, -0.20703264f, 
    0.02261567f, 0.22408684f, 0.14230879f, -0.25120148f, -0.19997811f, 0.04834922f, 0.20663334f, 0.34165043f, 
    -0.45110351f, 0.32722157f, 0.05492082f, 0.01288238f, -0.19965114f, -0.11657038f, -0.23953091f, 0.30417198f, 
    0.10886861f, 0.10505765f, 0.46287885f, -0.02747745f, -0.33494151f, 0.10088497f, 0.46870640f, -0.13831545f, 
    -0.23819439f, 0.58542371f, -0.09168412f, -0.13684888f, -0.02971012f, 0.12452479f, -0.22380699f, -0.12109478f, 
    0.21941575f, 0.10889051f, 0.09136962f, 0.58120215f, -0.19455311f, 0.02304705f, -0.32314461f, 0.34116909f, 
    -0.10594334f, -0.49360406f, -0.08314350f, 0.06824768f, -0.10867848f, -0.38249981f, -0.08527710f, 0.51025093f, 
    0.01579640f, -0.09283362f, -0.06271206f, 0.00060402f, 0.38802874f, 0.19766313f, 0.35071561f, 0.42643383f, 
    0.47132137f, -0.23226853f, -0.00652258f, -0.35203066f, 0.07670745f, -0.02267834f, -0.19494036f, 0.35947743f, 
    -0.62129128f, 0.16391297f, 0.26935548f, 0.08835779f, -0.05837814f, -0.10093789f, 0.12879254f, -0.29104748f, 
    -0.19270903f, -0.12936889f, 0.54177409f, -0.37405524f, 0.17051816f, -0.14374648f, -0.36811709f, 0.36911660f, 
    0.11496644f, 0.19831616f, -0.49099690f, -0.15158993f, -0.36168694f, 0.04128304f, 0.01172048f, 0.08028152f, 
    0.28339148f, 0.36059245f, -0.03391782f, -0.45636293f, -0.10808842f, 0.05224041f, 0.72237772f, -0.18166575f, 
    -0.11456584f, -0.19769010f, 0.07595411f, -0.00109777f, 0.04035019f, -0.09346055f, 0.67207730f, 0.56634754f, 
    -0.25038561f, -0.11567557f, -0.17531802f, -0.48914936f, -0.16243455f, 0.47730827f, -0.39306074f, 0.08321001f, 
    0.01302186f, 0.23961754f, -0.20398246f, 0.27531794f, 0.21030337f, 0.03801324f, 0.07904717f, -0.31961465f, 
    -0.02723473f, -0.02927531f, -0.35772222f, 0.02184680f, -0.03908220f, 0.10889176f, -0.19248971f, -0.29909834f, 
    0.11391605f, 0.11897738f, 0.05352652f, -0.46731475f, 0.46266896f, -0.04978101f, -0.20035209f, 0.51178664f, 
    0.01147201f, 0.00285269f, 0.04490759f, -0.17933400f, 0.22574359f, -0.11468398f, 0.11240338f, -0.08215293f, 
    -0.24233577f, -0.21061985f, -0.09067190f, 0.16286437f, -0.00576841f, 0.05948887f, -0.10944061f, -0.18926798f, 
    -0.05852433f, 0.09830194f, -0.19613217f, 0.28544068f, -0.15691355f, -0.32334763f, -0.35359603f, -0.10669167f, 
    0.08538388f, 0.37553787f, 0.23693196f, 0.57644689f, -0.08380145f, 0.11196453f, -0.18756200f, 0.23127691f, 
    -0.35132012f, -0.08750453f, -0.21593782f, -0.03558257f, -0.11200746f, 0.22997908f, -0.29077110f, 0.12711164f, 
    -0.05654836f, 0.39214408f, 0.29650095f, 0.64250523f, 0.01090380f, -0.03360254f, 0.49886209f, -0.14314108f, 
    -0.28333053f, -0.19586612f, 0.33090967f, 0.46722695f, 0.21615067f, 0.38611358f, -0.19304056f, 0.11446090f, 
    0.11285159f, -0.22874928f, 0.44535685f, -0.26787129f, -0.08449130f, 0.17289168f, 0.54009670f, -0.06718092f, 
    -0.21769431f, 0.46720353f, -0.11706840f, -0.18070668f, 0.19219257f, 0.09725288f, -0.04277588f, -0.08412869f, 
    0.30450705f, 0.45265234f, -0.15702461f, 0.30497167f, -0.14275099f, -0.03240360f, -0.27793473f, 0.01396026f, 
    0.06226980f, -0.08595437f, -0.01057814f, -0.57409412f, -0.03764247f, -0.08288853f, 0.45220062f, 0.19640215f, 
    0.02537338f, 0.35952410f, 0.08275580f, -0.31249636f, 0.03772992f, 0.17219086f, -0.07047401f, -0.01859825f, 
    -0.36329684f, -0.10731164f, 0.35401815f, 0.13283285f, -0.05549742f, 0.22338162f, 0.27283520f, 0.35123911f, 
    0.25744876f, -0.08310375f, -0.45241120f, -0.53977811f, 0.22376028f, 0.13721085f, 0.00835546f, -0.18330160f, 
    -0.26143205f, 0.04988150f, 0.34167942f, -0.15657495f, -0.24467155f, -0.32817546f, -0.28946680f, 0.45840380f, 
    0.35152802f, -0.04913331f, 0.52569169f, -0.65279764f, 0.12676464f, 0.12911278f, 0.22485574f, 0.17359170f, 
    -0.13301180f, 0.48297760f, 0.27693424f, 0.14046089f, -0.00864951f, -0.07371725f, 0.33967510f, -0.11499966f, 
    -0.41199425f, -0.37819973f, -0.16571511f, -0.28782389f, 0.18642749f, 0.10603689f, 0.45446563f, 0.47939062f, 
    0.01246974f, 0.08341599f, 0.19369100f, 0.19643253f, -0.05888931f, 0.39790490f, 0.37615061f, 0.01207948f, 
    0.41694039f, -0.10558199f, 0.27557752f, 0.37423757f, -0.35127911f, -0.09287696f, -0.16685408f, -0.19121994f, 
    0.45835823f, -0.08482032f, -0.02731726f, 0.00061484f, -0.06790402f, -0.18021229f, 0.73187971f, 0.03826302f, 
    -0.22873241f, 0.04063494f, -0.55585462f, 0.47503957f, 0.47736451f, -0.06060113f, 0.30287760f, 0.12563886f, 
    -0.26323530f, 0.29375988f, 0.15298162f, -0.29715127f, 0.13157851f, 0.51084584f, 0.11768638f, -0.21641207f, 
    0.32668114f, 0.45232973f, -0.05679730f, 0.05657975f, -0.07900351f, 0.04540558f, -0.51905793f, -0.22088529f, 
    0.09172482f, -0.65497297f, 0.10112998f, -0.30908096f, -0.00261882f, -0.27331236f, 0.52407306f, 0.49375474f, 
    0.10245145f, 0.33243838f, -0.74410439f, 0.16756625f, 0.07981097f, -0.04624624f, 0.11815321f, -0.14555608f, 
    -0.27988023f, 0.04034937f, -0.25910327f, 0.77176279f, 0.21355484f, -0.24011390f, -0.06996636f, -0.18586776f, 
    -0.12518476f, 0.49844295f, -0.32149521f, 0.01317553f, 0.27742341f, -0.03580080f, 0.35787082f, 0.52076524f, 
    -0.27172112f, -0.04552624f, -0.15975928f, 0.23746054f, 0.13850735f, 0.41171649f, -0.04582297f, -0.04046913f, 
    0.19845337f, 0.20854820f, -0.43980277f, 0.10150607f, 0.56296206f, -0.02604297f, -0.39483395f, 0.02341489f, 
    0.39550114f, -0.23282409f, -0.03613399f, 0.30586755f, 0.08303025f, 0.34113029f, 0.58074951f, -0.06941030f, 
    -0.58085036f, 0.19677290f, -0.24108769f, 0.37731412f, -0.09769564f, -0.22655189f, 0.27500954f, 0.19787757f, 
    0.21469332f, -0.17110045f, -0.14211859f, -0.17865109f, 0.11254390f, 0.27644044f, 0.43322587f, 0.28875148f, 
    -0.05824034f, 0.34825939f, 0.15325680f, -0.03200049f, 0.19497462f, 0.08888651f, 0.74205452f, -0.28526765f, 
    0.19499159f, 0.68856949f, -0.04624676f, -0.49786893f, -0.24659130f, 0.35740855f, -0.27573141f, 0.03872930f, 
    0.21969561f, 0.08377151f, 0.03459409f, 0.10080843f, 0.13435666f, -0.16609001f, -0.46346518f, -0.01550027f, 
    0.06657910f, -0.19493592f, 0.19074070f, 0.05480222f, 0.02307081f, 0.15900844f, -0.17994981f, -0.20855683f, 
    -0.09695374f, -0.10096397f, 0.09431827f, -0.09402516f, -0.22383682f, 0.01770746f, -0.20537914f, -0.26474130f, 
    -0.23246574f, 0.00312003f, -0.17506891f, -0.26555490f, -0.06019574f, -0.18133312f, 0.15765367f, -0.23350909f, 
    0.12442551f, 0.10739168f, -0.01478690f, -0.17686729f, -0.06743724f, 0.11706710f, -0.26454607f, -0.07772920f, 
    0.00150800f, -0.19310322f, -0.25862059f, -0.19596058f, 0.08402630f, -0.24569233f, 0.15172127f, 0.16401961f, 
    -0.24674250f, 0.08720160f, -0.17922938f, 0.00489771f, -0.06393297f, 0.25139758f, -0.04986022f, -0.23187058f, 
    -0.20397241f, -0.05220225f, -0.30646080f, -0.08862965f, 0.20362905f, 0.11883374f, -0.06195446f, 0.13296553f, 
    -0.09745885f, -0.31270361f, -0.07629260f, 0.11787237f, 0.03751294f, -0.09332450f, -0.19881304f, -0.20384562f, 
    -0.24519484f, -0.16978478f, -0.09020619f, -0.17978150f, 0.10144050f, -0.13222897f, 0.02247354f, -0.00176966f, 
    0.19554685f, 0.02880667f, -0.11755709f, -0.01749758f, -0.19818284f, 0.25827557f, 0.00735494f, -0.01007528f, 
    -0.09087750f, -0.23079905f, 0.14312321f, -0.11614393f, -0.19364975f, 0.56546795f, 0.59235156f, 0.27254230f, 
    -0.83151579f, 0.00883996f, 0.16179465f, 0.12796797f, -0.45744967f, 0.06277172f, 0.11161715f, 0.14426748f, 
    0.26130369f, 0.50486249f, 0.38866487f, -0.08922334f, 0.14008194f, -0.06871904f, -0.31216979f, -0.30150321f, 
    0.31155661f, -0.58117694f, 0.08758475f, 0.04062460f, -0.07920830f, 0.07356051f, -0.24402864f, 0.53846771f, 
    -0.20579574f, -0.06042257f, -0.11916187f, 0.11318195f, -0.04662952f, 0.03670022f, -0.17407462f, -0.21905190f, 
    -0.10737342f, -0.19770873f, -0.01875582f, -0.13541308f, 0.09000814f, 0.01321104f, -0.14107308f, 0.12030032f, 
    -0.14660402f, 0.47958872f, -0.02752575f, -0.08002594f, -0.16598412f, -0.42097756f, 0.25826824f, -0.34852946f, 
    0.18157496f, 0.14725979f, -0.24407366f, -0.02660679f, 0.51551723f, 0.09319688f, -0.40894824f, 0.45638368f, 
    0.05490357f, 0.35436660f, -0.10448159f, 0.08109825f, -0.17166996f, -0.02810206f, -0.26632756f, -0.08585475f, 
    -0.18158992f, 0.00508155f, 0.26193666f, 0.04365121f, -0.14902163f, 0.10305247f, -0.08884474f, -0.08461159f, 
    -0.47912374f, -0.11038811f, -0.15793964f, -0.30217582f, 0.06220917f, -0.04193633f, 0.52959877f, -0.00539035f, 
    0.12067324f, 0.32538202f, -0.04896680f, -0.38195506f, -0.14786465f, 0.00003140f, 0.60281062f, 0.56072402f, 
    -0.29029521f, -0.23368193f, 0.26485750f, 0.33932349f, 0.19466855f, 0.53322947f, -0.44311926f, 0.27932969f, 
    0.25672829f, 0.30320358f, 0.11736078f, 0.32329538f, 0.13013269f, 0.07094421f, -0.10790721f, -0.32338759f, 
    -0.46514484f, -0.06263436f, 0.17413661f, 0.42152408f, 0.11027539f, 0.21605998f, 0.29805797f, 0.27336285f, 
    0.12637261f, 0.03279414f, 0.57302547f, -0.44988590f, -0.09368470f, -0.03282769f, 0.60755843f, 0.05564851f, 
    0.47188988f, 0.11614922f, 0.27743977f, 0.23508058f, -0.17729549f, -0.21135572f, 0.40190357f, 0.24398878f, 
    0.10083616f, -0.39551130f, -0.37181297f, -0.29781047f, 0.46565267f, -0.09446269f, -0.11057737f, 0.07529910f, 
    -0.19766913f, -0.22557579f, -0.10424859f, -0.09645771f, -0.20189628f, -0.02148090f, -0.07438636f, 0.12558536f, 
    -0.16610098f, 0.02375014f, 0.05936185f, 0.11568402f, -0.08229489f, -0.20730641f, -0.13269497f, -0.18395239f, 
    -0.20267360f, -0.26982638f, -0.25014001f, -0.28418103f, 0.07647077f, -0.11636847f, -0.17797779f, -0.15604857f, 
    -0.12443109f, 0.01545479f, 0.14710400f, 0.02520533f, 0.00923353f, -0.18516020f, 0.17400530f, 0.14803204f, 
    0.24330257f, -0.27211687f, 0.45522904f, 0.56724501f, -0.06004708f, 0.24561769f, -0.12197857f, 0.24004140f, 
    0.28699315f, -0.12056826f, -0.15866087f, -0.24647471f, 0.25426126f, 0.07862172f, -0.50524080f, -0.18748926f, 
    -0.32903084f, 0.37490547f, -0.28819749f, -0.35867104f, 0.04822523f, -0.06347762f, -0.07753245f, 0.13313790f, 
    0.37640119f, -0.16151609f, 0.07613444f, 0.19431041f, 0.18791567f, 0.10503906f, -0.14590394f, 0.33051968f, 
    0.21131775f, -0.04606825f, -0.19641818f, 0.10976294f, -0.20297329f, 0.10979100f, -0.19553144f, 0.15520389f, 
    -0.48266697f, -0.23090787f, 0.18364263f, -0.10870878f, -0.09118710f, -0.13696352f, 0.23065831f, -0.27966103f, 
    -0.34765729f, -0.05716030f, 0.30877650f, 0.01860451f, 0.20724358f, -0.10131977f, 0.02363675f, -0.17588182f, 
    0.33333647f, 0.33880794f, 0.45761144f, -0.33710834f, -0.10998398f, -0.00375948f, -0.30496278f, 0.17776814f, 
    -0.22571637f, 0.04337038f, 0.09962286f, 0.04471091f, 0.22401014f, 0.30028096f, -0.67749077f, -0.11644356f, 
    0.06088066f, 0.25376102f, -0.50578368f, 0.43864626f, 0.59877360f, -0.13140056f, 0.01456732f, -0.12494086f, 
    -0.09948969f, -0.11732059f, 0.43828231f, 0.14793350f, -0.23621932f, 0.47231007f, -0.02640559f, -0.02743766f, 
    0.39355451f, 0.12040212f, 0.56713414f, -0.18951188f, -0.09822605f, -0.13973315f, -0.42630526f, -0.40246084f, 
    0.32006064f, -0.36245945f, -0.09547172f, -0.29912657f, 0.13962771f, -0.08042180f, -0.68354493f, 0.30082834f, 
    0.20971146f, -0.27201098f, -0.23031771f, 0.03004733f, 0.57960457f, -0.19532791f, 0.28140280f, -0.05831626f, 
    -0.04626921f, 0.46813351f, 0.02453375f, -0.14566469f, 0.13406861f, -0.38787022f, -0.13959098f, 0.25171128f, 
    -0.01637957f, 0.26852128f, 0.00014342f, -0.25789243f, 0.26086143f, -0.09643538f, -0.45772883f, -0.17684314f, 
    0.16613244f, -0.21370839f, -0.42389414f, 0.40248013f, 0.00211870f, -0.23170403f, 0.32039872f, 0.22800140f, 
    -0.41866386f, 0.19391856f, 0.34820944f, 0.34669533f, -0.06276768f, -0.30508485f, 0.59920514f, -0.17467371f, 
    0.16008726f, -0.48696867f, 0.19211903f, -0.05048024f, 0.17409042f, 0.18662716f, 0.10105240f, 0.20521779f, 
    0.10190877f, -0.45476258f, -0.40404522f, 0.28629678f, 0.33833084f, 0.10342602f, 0.39658132f, 0.09599484f, 
    0.62130135f, 0.30724528f, 0.11720033f, -0.15981086f, 0.05370012f, 0.15787566f, 0.52862906f, 0.02291290f, 
    0.04729362f, -0.32313761f, -0.21451364f, -0.07906041f, 0.33101043f, 0.08431242f, -0.01315944f, -0.19167159f, 
    0.11391671f, 0.30548716f, 0.17471477f, -0.40962717f, 0.05556594f, -0.06304958f, -0.32204324f, -0.14706860f, 
    0.28963277f, -0.30256647f, -0.21590978f, 0.58293885f, 0.14658497f, -0.13179113f, -0.51278961f, 0.26576084f, 
    0.16983190f, -0.32672086f, -0.16096950f, 0.23655483f, -0.15288867f, -0.54082423f, -0.29250681f, 0.41155475f, 
    0.16507800f, 0.12501630f, 0.24107176f, 0.08406211f, -0.01308424f, 0.11482489f, 0.43954873f, 0.45865792f, 
    0.59952354f, -0.52114516f, 0.13269907f, 0.02280090f, -0.00031702f, 0.37254757f, -0.84164894f, 0.52104306f, 
    0.02083435f, 0.03617754f, -0.52298760f, -0.08855375f, -0.15784645f, -0.08776334f, 0.19589174f, -0.47194988f, 
    0.42964530f, -0.27703407f, 0.02063342f, 0.44034988f, -0.04441135f, -0.16797097f, 0.04717183f, 0.39334756f, 
    -0.14745817f, 0.24303940f, 0.11802758f, 0.13013355f, 0.01322072f, -0.15438759f, 0.36898920f, -0.12041949f, 
    0.16286400f, -0.24595839f, -0.40234363f, 0.23520869f, 0.23598303f, -0.26107427f, 0.06368104f, 0.30269492f, 
    -0.30543897f, 0.17501011f, 0.27419248f, -0.43260336f, 0.35863429f, 0.10661966f, 0.17673446f, 0.20639694f, 
    -0.20145032f, 0.12804805f, 0.37040618f, -0.19067974f, 0.21271807f, -0.41017774f, -0.16496259f, 0.20356311f, 
    0.47219026f, -0.27024943f, 0.09132142f, 0.03803715f, -0.10911558f, -0.09912321f, -0.13697091f, 0.56711400f, 
    0.37553668f, 0.23379256f, -0.02937723f, 0.17883942f, 0.17179337f, -0.38250932f, 0.07002735f, 0.11628325f, 
    -0.15155402f, -0.33622682f, 0.30494803f, 0.00125233f, 0.04501726f, -0.00149402f, -0.24469152f, -0.21268241f, 
    0.01637789f, -0.13185936f, 0.12477961f, -0.25106505f, -0.06893182f, -0.09898644f, -0.60335231f, 0.47239938f, 
    -0.12476735f, 0.28528240f, 0.43909597f, -0.36904469f, -0.36042631f, 0.02764893f, -0.30874547f, 0.05442250f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.32555386f, -0.06809849f, -0.11302833f, -0.16449903f, 0.28557009f, 0.51547903f, 0.33487764f, -0.04819632f, 
    -0.03694976f, 0.19643497f, -0.29006737f, 0.07079916f, 0.11705668f, 0.28927270f, 0.20306490f, 0.14579853f, 
    0.28968284f, 0.01115029f, -0.23894364f, -0.35239929f, -0.24528308f, 0.24173242f, 0.30131564f, 0.24076302f, 
    -0.52493030f, 0.10160471f, -0.11260410f, 0.60728437f, -0.01810173f, 0.00585658f, -0.17313160f, 0.11878996f, 
    -0.30056295f, -0.26484010f, 0.30892125f, 0.15642168f, -0.08859825f, -0.31538635f, 0.01470196f, -0.04337787f, 
    0.48164481f, -0.25358468f, 0.23520313f, 0.14628813f, 0.05473707f, -0.27665961f, 0.28243926f, 0.12433699f, 
    -0.34099978f, 0.07415980f, 0.34813717f, 0.35066739f, -0.22544552f, -0.00747643f, 0.57515126f, -0.01954948f, 
    0.39468983f, -0.03924497f, 0.33332235f, 0.21742868f, 0.28844666f, -0.03994504f, -0.20455743f, 0.24067858f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.07216750f, 0.12448454f, -0.16504702f, -0.07220542f, -0.01970555f, 0.08331846f, -0.39309460f, -0.38295034f, 
    -0.23608552f, 0.31429943f, -0.00758019f, 0.03971646f, 0.20857874f, 0.08125144f, -0.42470035f, 0.28139126f, 
    0.25905067f, 0.01090949f, -0.11772266f, -0.17009141f, -0.16646025f, 0.13203759f, 0.08599883f, 0.43384895f, 
    0.45914844f, 0.32531312f, -0.22799903f, 0.08608100f, -0.02606523f, 0.10290341f, 0.09712397f, -0.07550614f, 
    -0.11867274f, -0.01674949f, -0.67268747f, -0.65236342f, 0.06589335f, 0.36874053f, -0.08451662f, 0.42069581f, 
    0.02193824f, 0.05047090f, -0.18146913f, -0.20008104f, -0.05197670f, -0.23886278f, 0.10428483f, 0.01910240f, 
    0.16399941f, 0.13505675f, -0.17339322f, -0.20976150f, 0.32449454f, 0.02514947f, -0.19158007f, -0.43416819f, 
    -0.20523486f, 0.17323853f, -0.98239583f, -0.05801382f, 0.20666373f, -0.17565410f, 0.43563372f, -0.03486328f, 
    -0.24439326f, -0.09053619f, 0.05031711f, 0.12682982f, -0.21890974f, 0.29208240f, 0.32463473f, -0.18732864f, 
    0.04330972f, -0.16077641f, -0.50803083f, -0.07328060f, 0.02061877f, 0.25549382f, 0.29537272f, -0.49842414f, 
    -0.22322413f, -0.05932970f, -0.04273120f, 0.23817649f, -0.16562802f, 0.09398203f, -0.72243309f, 0.02786234f, 
    0.33920792f, -0.07869006f, 0.17934203f, 0.13042833f, -0.45427048f, -0.05465415f, -0.05359615f, -0.02245451f, 
    0.05849875f, -0.13398109f, 0.24085219f, -0.32385883f, -0.08538291f, -0.29250589f, -0.16190015f, 0.49027336f, 
    -0.02451198f, 0.27375075f, -0.13684443f, -0.13318558f, -0.01484060f, -0.23777330f, -0.01977162f, 0.18442459f, 
    -0.05771555f, -0.01228657f, -0.40018994f, 0.12648198f, -0.30476320f, 0.33849937f, 0.14536054f, -0.18913947f, 
    -0.37990788f, 0.30720338f, 0.13560827f, 0.16258052f, 0.11375992f, -0.22247727f, -0.04971737f, -0.61903691f, 
    0.08641215f, 0.32658178f, -0.96823245f, 0.09051777f, -0.39141497f, 0.06675343f, -0.14107783f, -0.40248975f, 
    -1.16071808f, -0.24745537f, -0.66013241f, 0.05894880f, -0.12610848f, -0.03392164f, 0.49801853f, -0.72350687f, 
    -0.17557757f, 0.18365759f, 0.59014660f, -0.22870035f, 0.03778683f, -0.37339780f, -0.26627770f, -0.82538539f, 
    -0.02105968f, -0.03034145f, -0.22971857f, -0.03635272f, -0.25864232f, -0.03628590f, -0.10424283f, -0.00293095f, 
    -0.09565531f, -0.05059473f, -0.19978909f, -0.00719410f, 0.06398579f, -0.84841704f, -0.47661662f, -0.82807243f, 
    0.29561993f, 0.37264025f, -0.10879788f, 0.04783592f, -0.09642902f, 0.45168367f, -0.27068317f, -0.03903979f, 
    0.37889460f, 0.01594377f, 0.32568824f, 0.00499351f, -0.07039999f, -0.06682101f, -0.05211470f, -0.38474706f, 
    -0.36640412f, 0.14774641f, -0.00387500f, 0.14860600f, 0.19763224f, -0.00450161f, -0.47630325f, 0.45381740f, 
    0.25762236f, 0.53891730f, 0.15078875f, 0.34060004f, 0.26809078f, -0.76691508f, 0.34212047f, -0.31788906f, 
    -0.01749576f, -1.34095514f, -0.58755827f, -0.06414260f, 0.15890761f, 0.16440314f, -0.05226306f, 0.36114421f, 
    -0.15844892f, 0.03260090f, -0.12343604f, 0.08402897f, 0.25380719f, -0.29098025f, 0.31128678f, -0.75010133f, 
    -0.44991341f, -0.09240191f, -0.18059760f, -0.10190018f, 0.37415868f, 0.01256101f, 0.00881321f, 0.11935475f, 
    -0.09430534f, -0.08807963f, -0.31050158f, 0.17601046f, -0.09072562f, -0.05279156f, 0.11705112f, -0.38541046f, 
    0.06423722f, 0.07577255f, -0.40369317f, -0.04480143f, -0.09730039f, -0.20714594f, 0.15079802f, -0.01146604f, 
    0.03495496f, 0.16409318f, 0.11784212f, -1.28750455f, 0.45992517f, 0.02554292f, -0.78729481f, 0.01541982f, 
    0.09371029f, -0.41384947f, -1.68899012f, -0.17451930f, -0.49973565f, -0.12282050f, -0.09196074f, -0.32060319f, 
    -0.00124828f, 0.40557209f, -0.73979580f, -0.17500231f, 0.05737251f, 0.02941167f, -0.48928902f, 0.62592965f, 
    -0.04367888f, -0.60226083f, -0.57120216f, -0.07071682f, 0.03442496f, -0.17270195f, 0.13299596f, -0.04266280f, 
    -0.31709024f, 0.00649668f, -0.22648574f, 0.19891593f, 0.27204314f, 0.06998443f, -0.08341533f, 0.21830976f, 
    -0.12598331f, 0.02547386f, -0.14032064f, -0.13217825f, 0.02392226f, 0.11246970f, -0.11174745f, 0.06120616f, 
    -0.08988787f, 0.10443419f, -0.03487094f, 0.56121904f, -0.02879077f, -0.09840172f, -0.22806941f, -0.97059929f, 
    0.16224980f, -0.09397337f, 0.22349268f, -0.10950051f, -0.01211239f, 0.19366476f, 0.13837826f, -0.01124918f, 
    -0.18865658f, -0.08117142f, 0.06101878f, -0.01321727f, -0.37131250f, -0.39755654f, 0.25917241f, 0.06601280f, 
    0.30179271f, 0.10105333f, -0.10339120f, -0.01235280f, -0.73343343f, 0.44517520f, 0.05704395f, -0.38414592f, 
    -0.19063659f, -0.37726912f, 0.07308214f, -0.26769733f, 0.00195157f, 0.22323149f, 0.35739645f, -0.02519457f, 
    0.15122862f, -0.31670183f, 0.52931553f, 0.00925415f, -0.01943439f, 0.01213236f, -0.49013382f, -0.14701813f, 
    0.02476128f, -0.48683336f, -0.36162850f, 0.08256046f, -0.26153964f, 0.16189432f, -0.48642853f, 0.03756745f, 
    0.19115844f, 0.03727096f, 0.17646901f, 0.05224880f, 0.08690609f, -0.03307629f, -0.08257526f, 0.07181038f, 
    -0.09540293f, 0.05067551f, 0.36845735f, -0.11924701f, -0.07485819f, 0.14801469f, 0.05273418f, -0.01222768f, 
    -0.09666934f, -0.26941961f, 0.06543836f, -0.05071425f, -0.06439083f, -0.18750177f, 0.21238202f, -0.09087247f, 
    -0.35463643f, -0.05888588f, -0.52337545f, 0.24807607f, 0.01955395f, 0.04852103f, 0.00540419f, 0.05149306f, 
    0.04994756f, 0.25612950f, 0.68398154f, 0.13115345f, 0.41944331f, -0.06070267f, -0.34945539f, 0.40791279f, 
    0.32407331f, -0.16232371f, -0.59301853f, -0.24417686f, 0.12069115f, -0.06749622f, -0.22974637f, -1.29149771f, 
    -0.22585630f, 0.23346029f, -0.38003233f, -0.06982682f, 0.37063256f, 0.33182970f, -0.38890451f, 0.22736272f, 
    -0.02056403f, -0.50512993f, -0.77635020f, -0.73362869f, 0.03156792f, 0.19094391f, 0.14144848f, -0.06230863f, 
    0.20191202f, 0.33163202f, 0.22709942f, 0.05415256f, 0.09000734f, 0.04498731f, -0.10283808f, -0.08750349f, 
    -0.00950345f, -0.05756103f, -0.27670029f, -0.40792733f, 0.12445270f, 0.03533683f, -0.03763471f, -0.65985304f, 
    0.25509146f, -0.55205053f, -0.30989802f, 0.13621025f, -0.11838126f, 0.00088139f, 0.06049162f, 0.00634252f, 
    -0.15733263f, 0.44910669f, -0.12583333f, 0.06840292f, -0.01843274f, -0.00099982f, 0.03624357f, -0.18198279f, 
    0.27119243f, -0.03149563f, -0.51647520f, 0.19338898f, -0.06869303f, -0.48032916f, -0.84108800f, -0.26916090f, 
    0.08167650f, -0.03105154f, 0.36423180f, -0.07971376f, 0.06512029f, -0.19806284f, -0.87181503f, 0.68704468f, 
    0.28963247f, -0.89000344f, 0.29204118f, -0.02095266f, -0.02430992f, -0.69763315f, -0.18046622f, -0.07130299f, 
    -0.10369422f, -0.03570520f, 0.34726903f, 0.38714549f, -0.21894681f, -0.21676531f, -0.33084625f, 0.26494810f, 
    0.46289498f, -0.26687887f, -0.12278366f, -0.61404634f, 0.00580089f, 0.06831792f, -0.04666173f, 0.02199164f, 
    0.07887156f, -0.06985384f, -0.46989533f, 0.44349700f, -0.11407296f, 0.53742999f, 0.12513602f, 0.35547313f, 
    -0.58551103f, 0.00853721f, 0.09410101f, -0.05454002f, 0.03546552f, -0.25822976f, 0.09379466f, 0.00260554f, 
    0.39634365f, -0.52836192f, -0.40581924f, -0.31055105f, -0.14645892f, -0.19793120f, -0.25002134f, -0.25665474f, 
    0.12667161f, 0.03449404f, -0.04546627f, -0.45657614f, -0.04676972f, 0.49504280f, 0.04361197f, -0.10706205f, 
    -0.09005184f, 0.08888840f, 0.02949964f, -0.30439207f, -0.60428780f, -0.20819123f, 0.06276496f, 0.00326768f, 
    0.29893172f, -0.34040302f, 0.35485703f, -0.11295654f, -0.47372785f, -0.42674127f, -0.09224261f, -0.29297385f, 
    0.27323568f, 0.38924202f, -0.20125155f, 0.09931484f, 0.19402486f, 0.32322153f, 0.07286941f, 0.42925394f, 
    -0.43219721f, -0.32949638f, 0.37417707f, 0.25593215f, -0.35380241f, 0.02595371f, 0.05848804f, -0.05297159f, 
    -0.07812098f, -0.02947925f, 0.22519988f, -0.31691149f, -0.10295728f, -0.15014486f, -0.21460131f, 0.16719815f, 
    -0.17055491f, 0.07651375f, 0.51194537f, -0.05037922f, 0.08621840f, 0.10628539f, -0.68495303f, -0.25228104f, 
    -0.00323485f, -0.77275640f, 0.02625694f, -0.21728362f, 0.07262760f, 0.17495947f, 0.03400800f, 0.58380872f, 
    -0.73877060f, -0.20577818f, -0.48023993f, 0.22267166f, 0.06838699f, -0.60328680f, 0.02217799f, -0.02015561f, 
    -0.16409777f, -0.86346167f, -0.14864106f, -0.55641222f, -0.20355290f, 0.13701504f, -0.46861911f, 0.15299661f, 
    0.04709370f, 0.36587328f, 0.31284991f, -0.04908419f, -0.35286644f, -0.28556773f, -0.11564276f, -0.30035704f, 
    0.08117639f, 0.29040176f, 0.08329701f, 0.27437904f, -0.29878604f, 0.11890431f, -0.06388424f, 0.12438992f, 
    -0.60967106f, 0.18726079f, -0.40801936f, 0.02092511f, 0.22511442f, 0.08136316f, -0.02268167f, -0.09790823f, 
    0.05463289f, -0.15173455f, -0.39670423f, 0.27303556f, 0.04787353f, 0.10392290f, -0.12180904f, -0.32472557f, 
    -0.02967483f, -0.35009775f, 0.54011720f, 0.03586619f, 0.09927290f, 0.09216657f, 0.13285828f, -0.32262924f, 
    -0.35045910f, 0.28530383f, -0.01096144f, 0.54659587f, 0.15864630f, -0.89180648f, 0.27439615f, 0.40967301f, 
    0.29978022f, -0.14007957f, 0.62776434f, -0.13558048f, 0.11343975f, -0.06917349f, 0.40872732f, -0.29580477f, 
    0.05808268f, -0.11180355f, 0.21465914f, 0.26922870f, 0.12034073f, -0.06308427f, 0.36172599f, 0.31322131f, 
    0.16615480f, -0.12926635f, -0.20923905f, -0.08303554f, 0.14432043f, 0.32107207f, 0.18744984f, 0.06637750f, 
    0.20224507f, -0.65568763f, 0.21302716f, -0.54780728f, 0.09800173f, -0.33452240f, 0.03009962f, -0.80641770f, 
    -0.95202899f, -0.65426564f, -0.21637824f, 0.12948255f, 0.01915808f, 0.08955670f, -0.15835209f, -0.07875276f, 
    0.02492421f, 0.09701529f, 0.33107919f, -0.19366805f, -0.03253308f, -0.76358289f, -0.12688680f, 0.32942414f, 
    0.07217404f, 0.13452362f, -0.75628322f, -0.09132555f, 0.03700951f, -0.52237022f, 0.21831678f, 0.07098580f, 
    0.17451243f, -0.72505307f, 0.21742129f, -0.78258187f, -0.26445815f, 0.47439224f, -0.28019240f, -0.57797033f, 
    0.00284560f, 0.26298463f, -2.03065634f, 0.01122178f, 0.22819477f, 0.12345012f, 0.24924141f, 0.66636860f, 
    0.30440444f, -0.74575949f, 0.16726705f, -0.07526436f, 0.00868414f, -0.42974177f, -0.55410659f, 0.07025851f, 
    0.02842426f, 0.54407328f, 0.27906606f, -0.07892065f, -0.22935399f, 0.19696116f, 0.33291507f, 0.16980986f, 
    -0.05515635f, 0.17452283f, -0.25336158f, -0.08644714f, 0.14026217f, -0.00252513f, 0.28729409f, -0.71590835f, 
    0.02789578f, 0.29064491f, 0.21665075f, 0.12911297f, 0.14458352f, -0.05047668f, 0.00257285f, -0.04063759f, 
    0.03340926f, -0.03680004f, 0.36976510f, -0.36264670f, 0.08362477f, -0.41059014f, -0.41258496f, 0.06352163f, 
    0.21383585f, 0.25146967f, -0.71483648f, -0.04761441f, -0.02662421f, -0.08293284f, -0.04431135f, 0.01861051f, 
    0.19764024f, 0.20499937f, 0.17013820f, -0.73090619f, -0.59752136f, -0.20968162f, -0.10542643f, -0.07915884f, 
    -0.19403191f, -0.49741080f, -0.42104214f, -0.22708799f, -0.62561208f, -0.35593051f, -0.17159237f, -0.23623487f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.02080936f, 0.13893992f, -0.21536158f, -0.05069118f, 0.10613938f, 0.06283122f, -0.14525202f, -0.61828303f, 
    -0.19727165f, 0.27550802f, 0.26414824f, 0.13941401f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
