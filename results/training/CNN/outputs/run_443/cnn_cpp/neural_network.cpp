#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.49318901f, 0.57834101f, -0.34745109f, 0.87879676f, -0.31092280f, -0.56313759f, -0.01669389f, -0.13203709f, 
    -0.08244547f, 0.68032730f, 0.26964450f, 0.64469224f, 0.20965761f, -0.52070451f, 0.50553489f, -0.25447303f, 
    -0.05527218f, 0.13930286f, 0.37825561f, 0.69540113f, -0.02642592f, -0.49258828f, -0.66491431f, -0.64526379f, 
    0.17694049f, 0.06761520f, 0.48019964f, -0.24746585f, -0.80062777f, -0.67137504f, 0.21296453f, 0.49583754f, 
    0.33609220f, -0.27441648f, -0.03353764f, -0.09767053f, -0.60895920f, -0.31851238f, -0.68316853f, -0.07802016f, 
    -0.33235696f, 0.67215472f, -0.39932224f, -0.10908199f, -0.12747507f, 0.36053187f, -0.60675722f, -0.15466551f, 
    -0.77749330f, -0.54925656f, -0.25433603f, -0.21727765f, -0.18383038f, 0.28491506f, -0.67269927f, -0.00739903f, 
    0.01201307f, 0.53129303f, 0.95797521f, 0.54961854f, 0.11422890f, -0.20172538f, -0.05584756f, 0.60960966f, 
    0.53455997f, 0.84171677f, -0.54427922f, 0.03090251f, -0.38059145f, 0.08487091f, -0.26509839f, -0.55638200f, 
    0.59274489f, 0.65019548f, 0.31847546f, -0.76351285f, 0.53558135f, -0.21913782f, 0.02890378f, 0.21855409f, 
    0.24633251f, -0.14630368f, -0.07596995f, 0.35843030f, -0.66713661f, -0.81158221f, 0.24446745f, 0.22926410f, 
    0.24770330f, 0.09428097f, -0.87014729f, 0.20437835f, -0.31384394f, 0.13173081f, 0.24422936f, -0.42696792f, 
    -0.20962603f, 0.19875057f, -0.07254457f, 0.66862941f, 0.45281953f, 0.30906329f, 0.16032392f, -0.41864604f, 
    0.19282995f, 0.31227306f, 0.54136133f, -0.28543350f, 0.80331564f, 0.36780348f, -0.06153524f, 0.70571446f, 
    0.25765032f, -0.25695047f, 0.24566042f, 0.22872208f, -0.33085293f, 0.40128163f, 0.16717701f, 0.53135020f, 
    0.46647215f, 0.13273457f, 0.39125556f, 0.09487522f, -0.55938071f, -0.24430238f, -0.88979894f, -0.86326563f, 
    -0.36881793f, -0.27049831f, -0.46197030f, -0.22352943f, 0.19831786f, 0.15498033f, 0.10804028f, -0.01175639f, 
    -0.14122719f, -0.36952683f, 0.04418270f, 0.35051262f, -0.56086189f, -0.47586212f, -0.58288080f, -0.47022650f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.59967327f, 0.19663297f, -0.23549044f, 0.16392577f, -0.18185179f, 0.25402614f, -0.01284289f, -0.32959959f, 
    -0.25693914f, -0.05044440f, 0.19977269f, -0.16675635f, -0.29553732f, -0.07076497f, 0.16631839f, -0.28616205f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.58157188f, -0.09029262f, 0.10751270f, 0.11241744f, -0.06767780f, 0.04815719f, 0.01112940f, -0.04735945f, 
    -0.11666658f, 0.12155955f, -0.29644242f, 0.01909253f, 0.04363453f, 0.03134572f, 0.02264537f, 0.13485877f, 
    -0.04854324f, -0.03594998f, 0.38259771f, -0.44349653f, 0.01266859f, -0.06919951f, 0.12196371f, -0.03437338f, 
    -0.07645956f, -0.01547132f, 0.01978234f, 0.09759193f, 0.00474438f, -0.01228882f, -0.01634866f, 0.09867256f, 
    0.01007072f, 0.02925928f, 0.21723951f, 0.08257396f, -0.08501225f, 0.07260890f, 0.20969318f, 0.06704095f, 
    0.06400516f, 0.01932634f, -0.08341677f, 0.09734130f, -0.07543742f, 0.25880077f, 0.23251681f, 0.00532499f, 
    -0.03467220f, -0.06908545f, -0.31726983f, 0.15196885f, 0.04973607f, 0.04418243f, -0.41720492f, 0.18902142f, 
    0.04730219f, 0.08961892f, -0.05307619f, -0.01992535f, 0.08440748f, 0.04501890f, 0.22299594f, -0.21586584f, 
    -0.21144502f, -0.05462482f, 0.10878384f, 0.07730764f, -0.05080618f, 0.09484057f, -0.08506044f, 0.14942048f, 
    -0.02115250f, -0.14160521f, 0.07839848f, 0.08701269f, -0.05909604f, -0.02538184f, 0.04619038f, 0.09969971f, 
    -0.00070199f, 0.02183184f, -0.26424584f, 0.02247344f, 0.10071135f, 0.10489187f, 0.03410727f, -0.00194314f, 
    -0.09528624f, -0.20585261f, 0.27932489f, 0.33758506f, 0.21743327f, -0.04232304f, 0.08679519f, 0.07733278f, 
    -0.14370753f, -0.07350817f, 0.00457422f, -0.58667737f, -0.46607554f, -0.31819719f, -0.00472295f, 0.09770444f, 
    -0.02101149f, -0.05072998f, 0.05205531f, -0.28316247f, -0.17215559f, 0.06869615f, -0.32166228f, 0.00288556f, 
    -0.06906914f, -0.18450332f, -0.09333929f, 0.05638301f, 0.10026694f, -0.30325481f, -0.15565737f, 0.06235501f, 
    0.08343214f, -0.04550519f, 0.25124848f, 0.05450903f, 0.16417019f, -0.15890560f, -0.10012385f, 0.15893398f, 
    0.06909336f, -0.28391817f, -0.16198786f, -0.25422317f, -0.00214052f, -0.11018703f, 0.07714040f, 0.12188895f, 
    -0.01962643f, 0.04252622f, -0.17861481f, 0.21910356f, 0.25645342f, -0.08710703f, -0.05806802f, 0.06455994f, 
    0.25895283f, 0.02779375f, 0.10217740f, -0.19159958f, -0.20224935f, -0.13281123f, -0.14841099f, 0.11492367f, 
    0.05798405f, 0.06470750f, -0.01795846f, -0.13378398f, -0.11137088f, 0.04993601f, 0.05729089f, -0.01243764f, 
    -0.15362851f, -0.05150884f, -0.36831811f, 0.16088772f, -0.05324138f, -0.40517864f, 0.07620627f, -0.15719555f, 
    -0.01891386f, 0.07505516f, -0.00863379f, 0.22273730f, 0.13129853f, -0.08685524f, -0.02979513f, 0.19437885f, 
    0.03330135f, -0.02347215f, 0.09757848f, -0.04219085f, 0.24253693f, 0.37562463f, 0.00187900f, 0.25882620f, 
    -0.16757032f, 0.00342733f, 0.18878385f, -0.04671801f, 0.17209320f, 0.09052111f, -0.24845055f, -0.16775602f, 
    -0.01590737f, 0.24857375f, -0.08176570f, 0.03707987f, -0.07073136f, -0.07557253f, 0.43062252f, 0.45267457f, 
    0.12974469f, 0.12822455f, 0.06922107f, 0.01911630f, 0.12962542f, -0.04080615f, 0.27778345f, 0.05808243f, 
    0.20806062f, -0.09770701f, -0.13830310f, -0.11111174f, 0.06671353f, 0.12633567f, -0.01865278f, 0.03520862f, 
    -0.05969654f, -0.05514703f, -0.33355746f, -0.09945727f, 0.19065769f, -0.11750209f, -0.22078478f, 0.03578448f, 
    -0.04288420f, -0.15288991f, -0.39980307f, -0.35301563f, -0.04783306f, -0.18828616f, -0.12751593f, -0.10391802f, 
    0.08787502f, 0.03681390f, 0.37318024f, 0.07866049f, 0.03178719f, 0.03393907f, -0.17714334f, 0.11634515f, 
    -0.02529632f, -0.10868169f, 0.00846528f, 0.05366902f, -0.04657887f, -0.05499711f, -0.04156981f, -0.02012698f, 
    -0.11627785f, 0.04622557f, 0.01820246f, -0.00976938f, 0.04739895f, -0.07805692f, -0.01397274f, 0.07214321f, 
    0.06529734f, -0.02109444f, 0.24113715f, -0.00533153f, 0.00341272f, 0.03960726f, -0.04233948f, -0.15934587f, 
    0.14746861f, 0.10594459f, 0.03730414f, 0.13813020f, 0.00956194f, -0.09894799f, -0.26778141f, -0.11600650f, 
    0.08640244f, 0.07326012f, -0.04971585f, -0.06349577f, 0.01950468f, -0.00292679f, -0.06319881f, 0.05802916f, 
    -0.14126004f, 0.36454201f, -0.16480757f, -0.08447018f, -0.06319872f, -0.04931615f, 0.21239153f, -0.01522115f, 
    -0.32027864f, -0.15131295f, -0.46184823f, 0.02910481f, -0.07387695f, -0.03169441f, -0.04499294f, -0.18716604f, 
    -0.02285801f, 0.04452215f, 0.05364749f, -0.12143516f, 0.21091042f, 0.16786301f, 0.08166768f, 0.15544358f, 
    0.04300283f, 0.08625812f, 0.24370117f, 0.26731843f, -0.23598784f, -0.11907794f, 0.09312398f, -0.03179342f, 
    -0.06958576f, -0.04646064f, -0.08111060f, -0.10556664f, -0.16656710f, 0.46984369f, -0.07413679f, -0.09812513f, 
    -0.10083065f, -0.08856910f, -0.04979702f, 0.04486281f, -0.16957729f, -0.28987128f, 0.20507205f, -0.01418733f, 
    0.24747443f, 0.12481293f, -0.09215739f, 0.05682687f, 0.01059697f, -0.04663758f, -0.08367626f, 0.02007384f, 
    0.06192391f, -0.20573342f, 0.07170931f, 0.09617775f, 0.12377276f, -0.00805954f, -0.06361689f, -0.08652726f, 
    0.14272812f, -0.00709625f, -0.18998879f, 0.15453830f, 0.07327707f, 0.11403702f, -0.00430466f, -0.38488728f, 
    0.29134756f, -0.20148690f, 0.16304044f, -0.01016763f, 0.03758509f, 0.00621239f, 0.15445824f, 0.16140556f, 
    -0.17223927f, 0.09726061f, -0.27938592f, 0.00199629f, 0.00917356f, 0.03366207f, -0.06626403f, -0.10362257f, 
    0.09498931f, 0.00596554f, -0.07692603f, -0.37882045f, 0.02890138f, -0.01143218f, -0.00552946f, 0.11326765f, 
    0.05696468f, 0.03192678f, -0.42976615f, 0.06919157f, 0.30288613f, -0.07924011f, -0.00815829f, -0.11518066f, 
    -0.05559981f, -0.06974372f, -0.02064543f, 0.12123728f, -0.01547486f, -0.02665514f, 0.11602412f, 0.28210124f, 
    0.03678618f, 0.04224831f, 0.09103424f, -0.21644098f, 0.70670128f, 0.11542232f, 0.11714680f, 0.06362513f, 
    0.02841748f, -0.12972108f, 0.08056826f, 0.05511843f, 0.04255541f, -0.01590177f, -0.09010527f, 0.09272128f, 
    -0.09463360f, 0.01568327f, 0.02353301f, -0.03428784f, -0.01225152f, -0.04763417f, -0.24834915f, -0.34259382f, 
    0.26471052f, 0.01747721f, 0.05996412f, -0.21477507f, -0.05565318f, 0.14616719f, -0.07080190f, 0.43069050f, 
    -0.02960897f, -0.02224002f, 0.05381838f, 0.04355835f, 0.12197205f, 0.03694939f, 0.07346931f, 0.07086413f, 
    0.01403688f, 0.07559831f, -0.06660804f, -0.04023598f, 0.07702786f, -0.08122383f, 0.07318719f, 0.02509599f, 
    -0.03001445f, -0.08581680f, 0.00004409f, 0.04005051f, -0.02148350f, 0.04827178f, -0.06510368f, 0.05796458f, 
    -0.04167296f, -0.06309744f, -0.03021365f, -0.05140310f, 0.03321591f, 0.05556768f, -0.08231089f, 0.00236132f, 
    -0.02857054f, 0.06611971f, -0.03912581f, -0.07083186f, -0.06794515f, 0.02734798f, -0.07781362f, -0.07782953f, 
    0.01977952f, 0.01379281f, 0.00624481f, 0.04598056f, -0.01857537f, 0.06028512f, -0.05737446f, 0.04164540f, 
    0.01113888f, -0.06281164f, -0.03464065f, 0.00114987f, -0.05878054f, -0.01626457f, 0.05729613f, -0.07689350f, 
    -0.08042025f, 0.01075223f, -0.03267588f, -0.00815018f, 0.02318460f, -0.04160606f, 0.05144012f, -0.05138575f, 
    0.00934585f, 0.05654436f, 0.06066518f, 0.05085758f, -0.01170745f, 0.04221729f, 0.01593367f, 0.01969576f, 
    0.04528746f, 0.02067444f, -0.01599270f, 0.01882075f, -0.07159261f, 0.07599281f, -0.03757183f, -0.01957148f, 
    -0.01189945f, -0.04957334f, -0.07411071f, -0.07351044f, -0.01456312f, 0.07767976f, -0.03140970f, -0.05204981f, 
    0.05328564f, -0.01716470f, 0.02831281f, 0.06252798f, 0.04057540f, 0.00559381f, -0.04005554f, -0.07963617f, 
    -0.04276320f, -0.05405189f, -0.01609086f, 0.04433664f, 0.05282088f, -0.03309579f, 0.00007004f, -0.03965875f, 
    -0.08467735f, -0.06892992f, -0.06860439f, 0.00120578f, -0.07487080f, -0.01854997f, -0.04030861f, -0.04212778f, 
    -0.03607877f, -0.02632065f, -0.01913304f, -0.03952873f, 0.05519418f, 0.02595101f, 0.07571089f, 0.01889252f, 
    -0.02201904f, -0.04432587f, 0.05085011f, 0.00986579f, -0.07242365f, -0.05346679f, 0.02504639f, -0.07092366f, 
    0.01921791f, -0.07271042f, -0.04619510f, -0.08139830f, 0.02822358f, -0.01907650f, 0.04850708f, -0.03371917f, 
    -0.05265264f, 0.00753112f, -0.02995157f, -0.06307485f, -0.06518810f, -0.03113269f, -0.07773498f, 0.04714657f, 
    0.03361637f, -0.03190371f, -0.03769536f, -0.06348400f, -0.02429568f, -0.06474768f, 0.00671799f, 0.05041237f, 
    -0.22436666f, -0.31578502f, -0.55640244f, -0.03623980f, -0.05644445f, -0.10285359f, 0.08945012f, -0.04501041f, 
    0.00760081f, 0.02398632f, 0.11305594f, 0.18400697f, 0.10937323f, 0.07273194f, 0.16506705f, -0.01075005f, 
    0.00961943f, 0.02256223f, -0.20316152f, -0.02420421f, -0.19671544f, -0.04408042f, 0.13558018f, -0.20709112f, 
    -0.01248463f, 0.08473852f, -0.03756459f, -0.07933797f, 0.24402030f, 0.27055016f, 0.11011788f, 0.02525077f, 
    0.01675573f, 0.04383044f, 0.11688897f, -0.03800534f, -0.09317925f, 0.18449996f, 0.23914947f, -0.17215362f, 
    -0.11725537f, 0.13494648f, -0.03064244f, 0.16926290f, -0.19670269f, -0.40082976f, -0.08001295f, -0.12437825f, 
    0.03201671f, 0.15408698f, 0.17333812f, 0.00465455f, 0.00109673f, 0.01335186f, 0.27325156f, 0.04071814f, 
    0.17135277f, -0.10876197f, -0.01330085f, -0.07980797f, 0.13235725f, 0.05546992f, -0.05597630f, -0.06473797f, 
    -0.37930650f, 0.23193203f, 0.12433742f, -0.03048577f, -0.02548391f, 0.13836652f, -0.01834241f, 0.06989586f, 
    0.33421305f, -0.14689641f, -0.21689938f, 0.07804989f, 0.02875901f, 0.05942533f, -0.03952152f, -0.08718099f, 
    0.01383314f, 0.07252094f, -0.36073318f, -0.16654687f, 0.00875484f, -0.09192253f, -0.12186513f, 0.19187786f, 
    -0.05017776f, 0.11333731f, -0.43556821f, -0.30541795f, -0.45886993f, -0.03025519f, -0.04247743f, -0.07361244f, 
    -0.05651821f, 0.00542786f, -0.12677786f, 0.00083092f, 0.13808402f, 0.12359984f, 0.03733116f, 0.03112254f, 
    0.05647326f, 0.04950667f, 0.02843008f, -0.04346933f, -0.24992776f, 0.26400128f, -0.18446520f, 0.07625219f, 
    -0.03471667f, -0.08144188f, -0.04750098f, -0.15537085f, 0.23558272f, 0.29571354f, 0.16470101f, 0.32493809f, 
    0.07302456f, -0.01925630f, -0.04194618f, 0.13894466f, 0.17510647f, 0.03918043f, -0.30895111f, 0.19036865f, 
    0.34646031f, 0.06384787f, -0.13853256f, 0.05454018f, -0.01797413f, -0.05291223f, 0.22299044f, -0.05926940f, 
    -0.09026445f, -0.26048103f, 0.02153365f, 0.01653332f, 0.04258979f, 0.10923897f, -0.09051381f, -0.09195206f, 
    0.18627320f, -0.18480065f, -0.03838715f, 0.10094749f, -0.14480664f, -0.37655893f, 0.00368294f, 0.08456099f, 
    0.11998980f, -0.30267143f, 0.13213567f, 0.11142617f, 0.08674516f, 0.25009310f, 0.11498666f, 0.20677848f, 
    -0.10375600f, 0.04038898f, 0.14303747f, 0.23714255f, -0.03655633f, -0.03247564f, -0.06186669f, -0.10539304f, 
    -0.04362057f, 0.01436001f, 0.10375705f, -0.00122788f, -0.27546138f, -0.08822440f, 0.11769415f, -0.01502687f, 
    -0.00870378f, -0.10322350f, -0.05544713f, -0.03715532f, -0.45279184f, -0.29376471f, -0.23033035f, 0.06842092f, 
    0.22716209f, 0.16644652f, 0.00198056f, -0.24966286f, 0.09430987f, 0.10450267f, 0.11239200f, -0.48786876f, 
    -0.16649210f, -0.05749044f, -0.01533931f, 0.19177896f, -0.05477431f, 0.17498888f, -0.15326582f, -0.08303823f, 
    -0.09620558f, 0.27938044f, 0.18983583f, 0.16427697f, 0.00133653f, -0.10711055f, 0.15992859f, -0.19593978f, 
    0.21112210f, 0.35540867f, -0.14196344f, -0.01214188f, 0.05319621f, -0.04826687f, 0.06251643f, 0.07798143f, 
    0.06015710f, 0.36823240f, 0.35500050f, -0.04791586f, -0.06671903f, 0.15018283f, 0.05160258f, -0.06058177f, 
    -0.00943888f, -0.02941442f, -0.17986503f, -0.03023337f, 0.02382821f, 0.03114648f, 0.13825402f, -0.00717063f, 
    0.02844584f, -0.02040293f, -0.16905262f, -0.24474783f, -0.24834354f, -0.02284647f, 0.16489601f, -0.09083569f, 
    0.10634682f, -0.00722594f, -0.07490581f, -0.05577859f, 0.02378659f, 0.05649382f, 0.03511309f, 0.14610583f, 
    -0.15711571f, 0.19101456f, 0.09491076f, -0.14892320f, -0.44434685f, -0.00105242f, -0.33784705f, 0.00565025f, 
    0.05687505f, -0.09419883f, 0.02572449f, -0.16501738f, -0.08424685f, -0.13175634f, 0.13680866f, 0.04114041f, 
    0.21168950f, 0.14766149f, 0.26920381f, -0.01763830f, 0.00356708f, 0.00238219f, -0.13818586f, -0.11734139f, 
    -0.34428588f, 0.22938506f, 0.03940569f, -0.01361677f, 0.13161884f, -0.11634677f, 0.07026872f, 0.00094133f, 
    -0.14092779f, 0.04628588f, -0.09019732f, -0.00475484f, -0.03872378f, -0.06278502f, -0.05156704f, 0.10083536f, 
    -0.03782919f, -0.40883064f, 0.07257411f, 0.02594379f, -0.25350952f, -0.21916339f, -0.19189708f, -0.12911958f, 
    -0.21558617f, 0.12268442f, -0.13051100f, -0.13578865f, -0.00659929f, 0.10152756f, -0.01847349f, 0.10826429f, 
    -0.01479536f, 0.00009938f, 0.28593987f, -0.13734560f, 0.45133683f, -0.05663858f, -0.29132065f, -0.09056383f, 
    -0.09043484f, 0.13386986f, 0.06675066f, 0.01594797f, 0.06028169f, -0.04278155f, -0.02893709f, 0.02601568f, 
    0.06608939f, 0.14562364f, 0.04072937f, -0.05982514f, 0.26437628f, -0.07316110f, -0.27855432f, -0.11151465f, 
    0.06738657f, -0.00018771f, 0.12709679f, -0.07169842f, -0.09544893f, 0.02053908f, -0.19527014f, 0.22641434f, 
    -0.15976936f, -0.02983971f, 0.17381746f, 0.05341608f, 0.07911369f, 0.14943448f, -0.01949066f, 0.06004728f, 
    -0.04100091f, 0.13260600f, 0.05704747f, -0.04114782f, 0.02977502f, 0.30747470f, 0.02490210f, 0.07621680f, 
    0.10274447f, -0.28527257f, 0.08524171f, 0.03068053f, 0.12935224f, 0.18648517f, -0.07288222f, -0.02158162f, 
    -0.28168634f, -0.18635148f, 0.03692940f, 0.00392487f, -0.07224320f, 0.20921277f, 0.15570508f, 0.09896167f, 
    0.16386212f, 0.12259632f, -0.31626788f, -0.19334935f, -0.02621611f, -0.16099349f, -0.03860747f, 0.00992588f, 
    0.26976943f, 0.05577948f, -0.06207288f, 0.17288850f, 0.08889483f, 0.03134457f, 0.16320223f, -0.00002671f, 
    -0.00626121f, 0.03335479f, 0.09148847f, -0.31396753f, -0.16202414f, 0.07966479f, 0.07407014f, 0.03579796f, 
    -0.06223716f, 0.12603632f, -0.18991780f, 0.04529133f, -0.46932259f, 0.10704218f, -0.28524581f, -0.07445282f, 
    0.18332572f, -0.18666080f, 0.15401928f, -0.00187569f, 0.05845111f, -0.39416602f, -0.15746693f, -0.13763769f, 
    0.20658627f, 0.23185068f, 0.23914579f, 0.11633315f, 0.02472970f, 0.07173797f, 0.10568102f, 0.20096163f, 
    -0.05582364f, -0.09655491f, -0.01718543f, 0.11334106f, -0.08420889f, 0.08829203f, 0.01876501f, -0.48978114f, 
    0.19125308f, 0.18331885f, 0.18862535f, 0.11485499f, -0.07115124f, -0.01388757f, -0.02135308f, 0.05497492f, 
    -0.23316218f, -0.34712896f, -0.01756301f, 0.10569263f, 0.06808240f, 0.10403997f, -0.01116731f, -0.30185533f, 
    0.13859352f, -0.04700413f, 0.15743662f, 0.33991718f, -0.00063995f, -0.02429433f, 0.21071346f, -0.00167515f, 
    0.17546013f, 0.05603909f, 0.20138960f, 0.08335750f, -0.04400749f, 0.02965179f, -0.02891483f, 0.22360949f, 
    -0.08963500f, -0.07632190f, 0.04476454f, -0.05807889f, -0.19114085f, -0.33788854f, -0.11996781f, -0.06408188f, 
    0.11044814f, 0.10409794f, -0.18108225f, -0.00558665f, 0.08090390f, 0.36313492f, -0.23846413f, 0.12962574f, 
    -0.01774352f, -0.12131859f, -0.08524240f, 0.00783471f, -0.15784918f, -0.04030551f, -0.07178531f, 0.07699028f, 
    0.03546215f, 0.10612760f, 0.21378036f, -0.17673534f, 0.25504261f, 0.00571704f, 0.31342846f, 0.26857981f, 
    -0.17064194f, -0.02552827f, -0.17045602f, -0.29324239f, 0.02282383f, -0.09024134f, -0.08041869f, 0.20670632f, 
    -0.14304177f, -0.24225302f, -0.02152198f, -0.06194112f, 0.08586479f, 0.00857209f, -0.03849605f, -0.12823138f, 
    0.36178753f, 0.15185294f, -0.07530135f, -0.13629651f, 0.06254518f, -0.16426411f, -0.28988624f, 0.01546144f, 
    0.15653935f, 0.01909990f, 0.05586370f, 0.03437230f, 0.02765475f, -0.08193478f, 0.01868107f, 0.00190218f, 
    0.02896150f, 0.20047997f, -0.12246747f, -0.02327010f, 0.11893763f, -0.00659248f, -0.15675400f, -0.02143759f, 
    0.08423326f, 0.02371063f, -0.21893361f, 0.30611485f, 0.31600738f, 0.02140390f, 0.14980671f, 0.00038062f, 
    0.05575891f, 0.02988178f, 0.28915125f, 0.21740046f, 0.24444050f, -0.08787183f, -0.08361997f, -0.06211160f, 
    0.15500075f, -0.26621145f, -0.09299739f, 0.25126311f, 0.01470609f, -0.07347679f, 0.05681612f, 0.07284364f, 
    -0.06755012f, 0.17237598f, -0.06226834f, 0.06053976f, -0.01246545f, 0.09482168f, -0.34117943f, -0.07908273f, 
    -0.11670525f, -0.13624710f, 0.11782794f, 0.09780535f, 0.04194037f, -0.08591668f, -0.20504481f, 0.09924594f, 
    -0.06342618f, -0.10481244f, 0.23557208f, 0.06382624f, 0.09052037f, 0.17270842f, -0.16276966f, -0.11071762f, 
    0.28816119f, -0.16578992f, 0.19374034f, -0.19341132f, 0.22189835f, 0.24352306f, -0.18807364f, 0.11723964f, 
    -0.14075895f, 0.04925357f, 0.16893642f, -0.06059392f, -0.05314315f, 0.26272294f, 0.15212327f, -0.08351590f, 
    -0.07908023f, -0.02050421f, -0.18446939f, 0.26247206f, 0.00431909f, 0.17130685f, 0.25337282f, -0.23450872f, 
    -0.29922903f, 0.17236702f, 0.07188679f, -0.03817638f, -0.19014524f, 0.24459210f, -0.16105077f, 0.00000464f, 
    0.11469498f, 0.15229107f, -0.13799761f, 0.02358256f, 0.19159837f, -0.03481237f, 0.18511117f, -0.07751201f, 
    -0.05373715f, 0.07953083f, -0.20438288f, -0.16469419f, 0.14753337f, 0.36682215f, -0.02602359f, 0.06562146f, 
    0.11483412f, 0.16697700f, 0.03611338f, -0.04285052f, -0.11787696f, -0.10124144f, 0.22680251f, 0.05260643f, 
    0.05568471f, -0.04339486f, -0.19129905f, -0.14078695f, -0.02795155f, -0.13744915f, 0.09134158f, -0.21361464f, 
    0.23110239f, 0.13049294f, 0.18960698f, -0.07022725f, 0.03941780f, 0.04980579f, 0.02285656f, -0.00604257f, 
    -0.28648090f, 0.41217616f, -0.19511662f, 0.07242768f, -0.06487519f, 0.09351175f, -0.06522661f, -0.16619419f, 
    -0.00362076f, 0.25138444f, -0.06246815f, 0.04540752f, 0.07175126f, 0.04615659f, -0.07689000f, 0.10586285f, 
    0.03754345f, -0.15914609f, 0.34713262f, -0.09505770f, -0.13030553f, -0.13751034f, 0.07340696f, 0.00048332f, 
    -0.03813977f, 0.01666874f, 0.21232493f, -0.31666043f, -0.15730344f, 0.12298385f, 0.09314781f, 0.03767473f, 
    0.03565469f, 0.08627525f, 0.20860074f, -0.17521885f, 0.03837018f, -0.17990568f, 0.01264026f, 0.02167598f, 
    -0.07197943f, 0.15651758f, -0.13325264f, 0.02795320f, -0.12906322f, -0.20172654f, -0.18373288f, -0.15808570f, 
    -0.07573402f, 0.07510760f, 0.21837136f, -0.02407681f, 0.06237642f, -0.08604615f, 0.07931492f, -0.25262594f, 
    0.04894328f, -0.17801794f, 0.12067267f, -0.21793380f, -0.04361706f, 0.04245425f, 0.04696028f, 0.05982516f, 
    0.04139747f, 0.33127353f, 0.08787305f, -0.13792250f, 0.08270822f, 0.17675725f, -0.05311958f, 0.12610497f, 
    -0.59808689f, -0.57263130f, -0.31931704f, 0.05710338f, 0.07989760f, -0.15854339f, -0.02610183f, -0.23133378f, 
    -0.09527197f, 0.02822651f, 0.25561309f, 0.16770069f, -0.00204218f, 0.05041274f, -0.03543502f, -0.01452913f, 
    0.01897620f, 0.06292056f, -0.13952103f, 0.08936368f, 0.20247632f, -0.07230316f, -0.17504235f, 0.00184997f, 
    -0.15889007f, 0.24337436f, -0.14657925f, -0.08293663f, -0.33633450f, -0.28901327f, 0.12374317f, 0.18460311f, 
    0.19694838f, 0.10561259f, -0.16238317f, 0.00598591f, -0.05613215f, -0.13798173f, -0.17289500f, 0.08535796f, 
    -0.09125776f, 0.02471548f, -0.07991405f, -0.17035200f, -0.01457402f, 0.01538999f, -0.25472149f, 0.09743540f, 
    0.08385729f, 0.30296120f, 0.30512875f, -0.00778416f, -0.06887481f, 0.06685124f, 0.20829104f, -0.19935742f, 
    -0.50327474f, -0.01066410f, 0.07896935f, -0.10101506f, 0.17090811f, -0.15168473f, -0.09397731f, 0.07503130f, 
    0.04649294f, 0.29592332f, 0.03825569f, -0.04354713f, 0.05002458f, 0.05114027f, 0.13291407f, 0.02877753f, 
    -0.04776026f, 0.23273665f, 0.09154749f, -0.05730333f, -0.04216462f, -0.08127266f, 0.01817711f, -0.02731689f, 
    0.13691969f, -0.13483192f, -0.04469836f, -0.20428617f, 0.08499697f, 0.01617390f, 0.01549244f, 0.13634011f, 
    0.29281583f, 0.20177606f, -0.10109866f, -0.54591209f, -0.03325957f, 0.01233137f, -0.13456221f, 0.05358188f, 
    -0.01599360f, -0.02658563f, 0.23401268f, 0.15082707f, 0.27849752f, 0.08453365f, -0.36324081f, 0.03549251f, 
    0.00629810f, -0.03978436f, 0.25404859f, 0.11371426f, -0.19251215f, 0.09561375f, -0.00594815f, 0.13680388f, 
    -0.27217185f, -0.20684089f, -0.03485255f, 0.03283153f, -0.07704157f, 0.30362448f, 0.06308223f, -0.11185520f, 
    -0.12754922f, -0.10317318f, -0.08437007f, 0.34436882f, 0.06423085f, 0.10338210f, -0.39824462f, -0.22730605f, 
    0.13561046f, 0.35222486f, 0.19781432f, 0.14502478f, -0.02356934f, -0.02239694f, -0.06094908f, -0.17862731f, 
    -0.01460475f, -0.16339913f, 0.07053203f, 0.09004080f, 0.05236826f, 0.25030711f, 0.24238437f, 0.12709564f, 
    0.31175286f, -0.18728602f, -0.17565899f, -0.15162751f, 0.04857331f, -0.04602708f, -0.02196225f, -0.02204125f, 
    0.07182261f, -0.35570264f, -0.35369211f, -0.04308067f, 0.11121812f, 0.14991555f, 0.15362301f, -0.03618102f, 
    0.01132922f, 0.04368648f, 0.13315476f, -0.13995315f, 0.02817362f, 0.17971006f, -0.04200837f, 0.17954746f, 
    -0.04640435f, -0.05660971f, 0.09387407f, 0.32553759f, 0.15983492f, 0.13951637f, -0.17039150f, 0.02642971f, 
    -0.20855832f, -0.09963301f, 0.17608756f, 0.04305954f, 0.12343036f, 0.10829321f, 0.03574684f, -0.18012893f, 
    -0.19081970f, -0.07888788f, -0.05642532f, 0.03562001f, -0.09539340f, 0.33421960f, 0.05406710f, -0.04362988f, 
    0.07124531f, -0.03747727f, 0.04109884f, 0.17872691f, -0.06356200f, -0.23261222f, 0.19228269f, 0.08864415f, 
    0.01171245f, 0.13199563f, -0.03080092f, -0.21923794f, 0.19748156f, 0.07520732f, -0.01749919f, 0.16890281f, 
    0.07105367f, 0.07935841f, 0.11842404f, 0.26718158f, 0.23377411f, -0.24982949f, -0.03794123f, -0.16315901f, 
    -0.54140151f, -0.21868134f, 0.01291317f, 0.14070523f, 0.13350563f, -0.03004777f, 0.06315504f, -0.22682002f, 
    0.03705945f, 0.20933011f, 0.29004952f, -0.02800372f, -0.03990795f, -0.05377921f, -0.05448238f, 0.04486554f, 
    0.14144678f, 0.20833355f, 0.05865992f, -0.01927835f, -0.00336336f, -0.11956777f, -0.02259211f, -0.03622255f, 
    -0.10189945f, -0.03890171f, -0.07611930f, -0.37310606f, -0.33670607f, -0.00538945f, 0.08107530f, 0.09718709f, 
    0.03253707f, -0.00032388f, 0.14111187f, 0.05956184f, -0.38839611f, -0.38003659f, -0.22639398f, -0.17982227f, 
    0.00903437f, 0.04180209f, 0.13463834f, 0.01225023f, 0.21879895f, -0.03829250f, -0.24404189f, -0.18638046f, 
    0.19546483f, -0.10866485f, -0.10014834f, -0.02947780f, 0.06584316f, 0.13279581f, -0.10454539f, 0.21891508f, 
    -0.03358091f, -0.02946392f, -0.07223153f, -0.00282830f, -0.03321286f, 0.07427689f, 0.04849917f, -0.21432783f, 
    0.23439625f, -0.02329078f, -0.04606283f, 0.23459183f, 0.10270054f, -0.31154156f, -0.26962143f, -0.20656066f, 
    -0.06280924f, -0.16819586f, -0.14819945f, 0.12165289f, -0.10559872f, -0.06878584f, -0.00019714f, -0.17220111f, 
    0.06025314f, 0.21226709f, 0.09745127f, 0.08329123f, 0.07490366f, 0.07918181f, 0.15402462f, -0.04150674f, 
    -0.02242965f, 0.01489055f, 0.38133201f, 0.12602805f, -0.35523027f, 0.08177581f, -0.02781642f, -0.10557459f, 
    0.12386344f, 0.12761188f, -0.11234909f, -0.11475851f, 0.04904481f, 0.30388892f, 0.08190297f, 0.19559391f, 
    -0.06598952f, 0.15108362f, -0.08043276f, 0.08936120f, -0.17565487f, 0.10720658f, 0.13352837f, -0.17331079f, 
    -0.09871829f, 0.16542904f, -0.16066450f, -0.04496897f, 0.06823469f, 0.08439360f, 0.07168445f, -0.28592876f, 
    0.07770634f, -0.10423397f, -0.03827838f, 0.08279987f, 0.00604320f, -0.03421399f, -0.59374022f, -0.39447647f, 
    0.04288290f, 0.00502697f, 0.08544636f, 0.10642874f, -0.17049281f, 0.17931186f, -0.09740068f, 0.63871396f, 
    0.23141330f, 0.01559909f, -0.09172550f, -0.08206278f, -0.24884258f, -0.09857395f, -0.08206050f, 0.13033707f, 
    0.26428792f, 0.11672679f, 0.13408871f, 0.20801023f, -0.11666019f, 0.11196741f, -0.17457005f, 0.10011402f, 
    -0.19862956f, -0.11822445f, -0.14527214f, 0.02857276f, 0.04727863f, 0.04304007f, -0.16898897f, 0.18690765f, 
    -0.00362875f, -0.06720463f, -0.01189971f, -0.04620483f, 0.09840941f, -0.05497804f, 0.02432712f, -0.00666684f, 
    -0.08247871f, -0.16311908f, 0.00766934f, 0.27201155f, -0.09217213f, -0.01655544f, -0.00955502f, 0.02737482f, 
    -0.09535926f, 0.16262709f, 0.09633074f, -0.13000640f, 0.35883808f, -0.16534145f, -0.09185895f, 0.05080765f, 
    -0.13218756f, 0.01647633f, -0.01384990f, 0.05180946f, -0.01806023f, 0.04837187f, -0.10524268f, -0.12132503f, 
    0.28147125f, 0.04582620f, -0.02421571f, 0.11390474f, -0.04705923f, -0.22309250f, 0.37967759f, 0.20813426f, 
    -0.16848683f, -0.30761620f, -0.01727802f, 0.12163103f, -0.02637052f, -0.12791841f, -0.00166410f, -0.15580602f, 
    -0.11815638f, -0.05252790f, 0.08013206f, 0.00201573f, -0.00614653f, -0.11231563f, 0.03303897f, 0.24555467f, 
    0.07891398f, 0.01474903f, -0.05638747f, -0.08729257f, -0.06894371f, -0.08372661f, 0.05527231f, 0.04007013f, 
    -0.07475301f, -0.03061856f, -0.06552338f, 0.06732899f, 0.04379079f, -0.04085511f, -0.03562349f, -0.03199629f, 
    0.03665207f, 0.05132015f, 0.04881199f, -0.02802132f, -0.04799757f, 0.01982680f, -0.08573795f, -0.07558724f, 
    -0.04413092f, -0.07475945f, -0.08907343f, -0.06686635f, -0.06842866f, 0.01928283f, 0.00484716f, 0.06648955f, 
    0.00911676f, -0.02876917f, -0.01275754f, -0.02669921f, 0.02440175f, -0.07390993f, 0.05229738f, 0.00292056f, 
    0.04719516f, -0.08516650f, -0.08745981f, -0.05333185f, 0.02023822f, 0.04078377f, -0.01617734f, 0.03303366f, 
    -0.06398387f, -0.00587867f, 0.04472344f, -0.01224012f, 0.02339969f, 0.01389999f, -0.00282895f, -0.04802283f, 
    -0.02674683f, 0.00356690f, -0.06592335f, -0.02526528f, -0.04428980f, 0.03781822f, 0.06449876f, 0.05167824f, 
    0.01707941f, 0.06116654f, -0.03593709f, 0.03231189f, 0.01098337f, 0.02735112f, 0.04223172f, -0.01331580f, 
    -0.02959521f, -0.02863340f, 0.08162665f, 0.02167114f, 0.00849112f, -0.00283659f, -0.09825279f, 0.05422886f, 
    -0.07297664f, -0.01880974f, 0.03359159f, -0.07772168f, -0.07697289f, -0.01635647f, 0.05147290f, -0.03359509f, 
    0.06700274f, -0.04123363f, -0.04940101f, -0.04062878f, -0.05912279f, 0.07777864f, -0.05943207f, 0.06370778f, 
    -0.03842472f, -0.00281106f, 0.04125276f, -0.06493920f, -0.01519490f, -0.02012766f, 0.02495094f, -0.06743127f, 
    0.04895413f, -0.00015582f, -0.06934240f, 0.03856767f, 0.01203492f, 0.03307203f, -0.09215014f, -0.03335529f, 
    -0.02258889f, 0.00464410f, -0.02256008f, 0.05499864f, 0.00192749f, -0.05129877f, -0.05054476f, -0.05320603f, 
    0.06662965f, 0.00182447f, -0.03218995f, -0.02103524f, -0.05507160f, 0.02999934f, 0.06417888f, -0.09012619f, 
    -0.05193073f, -0.04601711f, -0.08415246f, -0.06859363f, -0.00972063f, -0.08408241f, -0.08459661f, 0.02352954f, 
    -0.06156743f, 0.04878371f, -0.00056718f, 0.00863509f, -0.01605952f, 0.05623107f, 0.00439225f, -0.08805504f, 
    -0.08063721f, 0.06145018f, -0.04368729f, 0.02085398f, -0.07087828f, -0.05853475f, -0.06970714f, 0.05302785f, 
    0.05940223f, -0.05882223f, -0.07045971f, 0.00401290f, 0.01318675f, -0.06964671f, -0.02448287f, -0.01365114f, 
    -0.01748423f, 0.00495776f, 0.05187518f, -0.01947973f, -0.06523479f, 0.03704602f, -0.00430758f, -0.08767189f, 
    -0.02020313f, -0.00642188f, -0.06523436f, 0.07403871f, -0.00936841f, -0.06800565f, 0.04488484f, -0.03952593f, 
    0.06915464f, 0.04245763f, 0.00797332f, -0.05852277f, -0.07119369f, -0.05445717f, 0.05569514f, -0.01432692f, 
    0.05461788f, -0.00625375f, -0.05463127f, 0.00646703f, -0.01666750f, 0.02119024f, -0.08255230f, -0.07062938f, 
    -0.02132273f, 0.04729448f, 0.05057973f, 0.06034126f, 0.01952832f, -0.00551570f, -0.05495652f, -0.00911896f, 
    -0.06169289f, -0.07938058f, 0.00627206f, 0.06438601f, -0.06610903f, 0.05772902f, -0.01639553f, -0.02950200f, 
    -0.05735240f, -0.03481001f, -0.01350528f, -0.03271327f, 0.02137079f, -0.04125175f, -0.05961616f, -0.05254718f, 
    -0.07237847f, 0.06768537f, 0.02969681f, 0.07087222f, -0.06927378f, 0.01491322f, 0.01198075f, -0.02288385f, 
    0.04149226f, -0.08035284f, -0.00072484f, -0.06362451f, -0.07589043f, 0.03540485f, 0.03916005f, -0.03689256f, 
    0.01986494f, -0.02176232f, -0.08533172f, 0.02989703f, 0.07330403f, -0.03789314f, -0.03949454f, -0.00821724f, 
    0.02169979f, -0.00246168f, -0.06368431f, -0.07177621f, 0.01364071f, -0.05588337f, -0.02865420f, -0.06870309f, 
    0.05011553f, -0.07441691f, 0.05999773f, 0.06610091f, -0.02495209f, -0.05932547f, 0.01865447f, -0.04204383f, 
    -0.04645274f, 0.02667914f, -0.06837624f, 0.06778114f, -0.06875053f, 0.00809184f, -0.01513811f, -0.04180346f, 
    0.05528173f, 0.06893779f, 0.01625776f, -0.03166742f, -0.03765199f, 0.01620415f, -0.01175465f, 0.03838065f, 
    -0.04809809f, 0.02461058f, -0.05426504f, 0.04945431f, -0.03059995f, -0.00046167f, -0.01909641f, -0.04337562f, 
    -0.08299673f, -0.08265743f, 0.03247845f, 0.07231702f, 0.03962590f, 0.02049335f, 0.07450061f, -0.04820868f, 
    0.27252072f, 0.16135043f, 0.07500294f, -0.04555912f, 0.04070674f, 0.02390217f, 0.00327564f, 0.02866143f, 
    -0.12324976f, 0.32511768f, 0.09384751f, 0.03708154f, -0.02839940f, 0.11826081f, -0.16057099f, -0.12625131f, 
    0.14403211f, -0.07179618f, -0.06041067f, 0.04767174f, 0.02490595f, -0.19657226f, -0.09051264f, -0.00166093f, 
    -0.22616787f, -0.02510560f, -0.14432482f, -0.02545625f, 0.23932995f, -0.02891448f, 0.22710930f, 0.00967008f, 
    -0.17288961f, -0.01074149f, 0.18636884f, -0.11353564f, 0.23766619f, 0.35560298f, 0.25841492f, 0.26243773f, 
    0.14689013f, -0.04016351f, 0.01651746f, -0.14901358f, 0.13108832f, 0.13199170f, 0.08869214f, -0.20701426f, 
    -0.32398453f, -0.14402734f, -0.11729275f, -0.02473655f, -0.04429821f, -0.10875631f, 0.07518611f, -0.00738283f, 
    -0.04810055f, 0.17263623f, -0.00388157f, 0.12085026f, 0.02130776f, 0.11661450f, 0.09945261f, -0.15900743f, 
    -0.25381297f, 0.27173951f, 0.01098461f, 0.18468644f, -0.07069129f, -0.16467333f, -0.04216428f, 0.05657602f, 
    -0.53094620f, 0.05645272f, 0.11077873f, -0.13553798f, -0.07800113f, 0.18272339f, 0.10787687f, 0.11951985f, 
    -0.04165111f, 0.10997591f, -0.33449903f, -0.34359962f, -0.09652783f, -0.03011370f, 0.01615866f, 0.15188849f, 
    0.05196696f, -0.01514465f, 0.12133740f, 0.11112822f, 0.08059266f, 0.00586932f, -0.10337458f, 0.03159301f, 
    -0.00373730f, 0.05349569f, -0.13058160f, -0.11407114f, -0.06493586f, -0.10537529f, 0.04671928f, 0.06140221f, 
    -0.14104155f, -0.14768097f, 0.10099422f, -0.01590335f, -0.03062319f, 0.04883403f, 0.04618887f, 0.00686690f, 
    -0.19531482f, -0.22743753f, 0.03667782f, 0.19541878f, 0.04591257f, 0.03521420f, 0.07368542f, -0.16787250f, 
    0.02343825f, 0.01990717f, -0.04026227f, 0.10811367f, -0.13625464f, 0.17488047f, -0.13190785f, 0.22176996f, 
    0.28936121f, 0.03901240f, -0.09318938f, -0.11341664f, -0.04569050f, 0.08100927f, -0.00536443f, 0.02800712f, 
    0.21077190f, 0.17508547f, -0.14724919f, 0.03255223f, 0.05326936f, 0.05542020f, -0.04182839f, -0.06742039f, 
    -0.51379728f, 0.17112854f, -0.02064807f, 0.18739837f, -0.04688247f, 0.12478673f, 0.00825992f, 0.09391853f, 
    -0.16732378f, 0.47075433f, 0.09052718f, -0.04858447f, 0.00294998f, -0.10276108f, 0.04631552f, -0.07289472f, 
    0.00648818f, 0.08603124f, -0.04429517f, -0.03353428f, 0.09391166f, -0.15141331f, 0.03843663f, 0.01546448f, 
    -0.06790403f, 0.06080286f, -0.26525393f, 0.17018579f, 0.05010067f, 0.24345875f, -0.16475965f, 0.17410749f, 
    -0.25455880f, 0.02260489f, 0.05981962f, 0.11886623f, 0.45181555f, 0.17441365f, 0.11677288f, 0.26803133f, 
    0.07598839f, -0.16144653f, -0.06367273f, 0.23107839f, -0.00095101f, 0.31009436f, -0.07535491f, -0.19608293f, 
    -0.13170072f, -0.09698211f, 0.02603037f, -0.34836614f, -0.01974516f, -0.16100767f, -0.24745502f, -0.02316703f, 
    0.00515579f, 0.04701262f, 0.13655962f, -0.14223962f, 0.04320401f, 0.15571377f, -0.03294106f, 0.01838639f, 
    -0.26471719f, -0.02193733f, 0.08820669f, -0.18310586f, 0.08353452f, -0.05703601f, 0.13165157f, 0.02207167f, 
    -0.06002066f, -0.29830360f, 0.02100050f, 0.05714305f, 0.06479521f, 0.10914762f, 0.15274575f, -0.10523903f, 
    0.23117447f, -0.00462780f, -0.18086298f, -0.48993024f, 0.01114287f, -0.14219342f, 0.15937930f, 0.06069172f, 
    -0.02290234f, -0.19090153f, -0.00583541f, 0.26412997f, -0.04067533f, 0.00677893f, 0.11316729f, -0.09114004f, 
    -0.17764024f, 0.08527000f, 0.02750719f, 0.20785914f, -0.11847366f, -0.03111086f, 0.15512940f, -0.04787768f, 
    0.00423272f, 0.19469424f, -0.16363059f, 0.06865479f, 0.08262838f, -0.13353704f, -0.01676381f, -0.12982795f, 
    -0.26737902f, -0.09923997f, 0.12251516f, -0.02836033f, 0.07361184f, -0.00699630f, -0.23987626f, -0.20685662f, 
    -0.01505711f, -0.01586765f, -0.24478285f, 0.10875094f, 0.02654220f, 0.17003074f, 0.23256224f, 0.35242188f, 
    -0.08735791f, 0.06476449f, -0.13170743f, 0.19741417f, -0.02765928f, -0.05920826f, 0.00845272f, -0.17846227f, 
    0.01557048f, 0.17400843f, 0.25660762f, 0.23174340f, 0.07722774f, -0.24829839f, -0.10106700f, -0.07826086f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.14884463f, -0.08703190f, -0.02111736f, 0.04100922f, -0.05311766f, 0.24573880f, 0.25493574f, 0.03709399f, 
    0.04290110f, 0.19345327f, 0.14449610f, 0.03447178f, 0.01699176f, -0.07504054f, -0.15728781f, 0.04083773f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.07233429f, -0.41323295f, -0.46981907f, 0.12457422f, 0.23387352f, 0.39589977f, 0.34287626f, -0.04386912f, 
    0.04763170f, 0.33167917f, -0.21269856f, -0.28810552f, 0.08916897f, 0.10341641f, -0.06556309f, -0.01782923f, 
    -0.15681005f, 0.24048845f, -0.15301833f, -0.17504933f, -0.18179628f, 0.28875440f, 0.39338842f, 0.45733935f, 
    -0.27013922f, -0.44770113f, -0.23543613f, 0.06246278f, 0.01607732f, 0.21607411f, -0.27775982f, 0.45635915f, 
    0.04575019f, -0.29237589f, -0.15646346f, 0.20699185f, -0.17000283f, 0.37029698f, 0.23713735f, -0.01967134f, 
    -0.04888700f, 0.27995285f, 0.15260899f, -0.09013817f, 0.02900914f, -0.12276837f, 0.31070629f, -0.25178471f, 
    0.46204931f, -0.48620689f, 0.07666906f, 0.03995556f, 0.25058308f, -0.20957053f, 0.36184403f, 0.28105533f, 
    -0.04255347f, -0.40167278f, 0.47231302f, -0.25454628f, -0.18769769f, 0.16256946f, 0.01053784f, -0.11102136f, 
    -0.22917297f, 0.09764688f, 0.58616316f, -0.08103567f, 0.23447153f, 0.35021618f, -0.15389976f, -0.38347203f, 
    0.05560410f, 0.37396258f, -0.39720762f, 0.18010180f, -0.15229687f, 0.22357625f, 0.44730967f, -0.07858131f, 
    0.41671437f, 0.45067593f, -0.16267271f, -0.02718958f, -0.23730399f, -0.28633869f, 0.19878125f, -0.14825374f, 
    -0.07346799f, 0.18744351f, 0.17323488f, -0.36412385f, -0.05281189f, 0.13151073f, 0.68020856f, -0.08742922f, 
    -0.08277345f, 0.67356974f, -0.44550064f, 0.21040100f, 0.44762179f, -0.18983053f, -0.25370425f, 0.26410201f, 
    0.35987899f, 0.04436978f, -0.00846878f, -0.11220268f, 0.13696393f, -0.17242554f, -0.21389762f, -0.29232034f, 
    -0.81983924f, -0.19833176f, 0.32800964f, -0.24201825f, 0.19883278f, -0.16884480f, -0.32302195f, 0.18011966f, 
    0.10759391f, -0.11434596f, 0.54582322f, 0.23649611f, -0.07104960f, 0.09439582f, -0.35064405f, -0.09298625f, 
    0.49142414f, 0.11109958f, 0.18444324f, 0.13066608f, -0.32186198f, 0.25748846f, -0.10375941f, 0.04520763f, 
    -0.19709185f, 0.24207932f, -0.30567122f, 0.06053894f, 0.17636086f, 0.18613094f, 0.13318138f, 0.12803057f, 
    -0.46691898f, -0.07949225f, 0.36034220f, -0.09403155f, 0.14300688f, -0.31986949f, 0.22268976f, 0.09304865f, 
    0.14992711f, -0.22403103f, 0.35050130f, 0.14694852f, 0.16517594f, -0.22512805f, -0.49747643f, 0.25746101f, 
    0.11093201f, 0.25238529f, 0.02500929f, 0.12237034f, 0.54814905f, 0.01861514f, -0.44610703f, -0.55260295f, 
    0.47801131f, -0.20768394f, 0.30609342f, 0.24560781f, -0.12546162f, -0.13045006f, -0.23174219f, 0.13105986f, 
    -0.14630468f, -0.32579976f, 0.40190661f, 0.04223163f, -0.32820964f, 0.28941664f, -0.11288877f, 0.09329910f, 
    -0.33606863f, 0.20842260f, 0.30826607f, 0.49024826f, 0.00229174f, 0.06284247f, -0.23085760f, 0.10374972f, 
    0.10552017f, 0.62120545f, 0.25546756f, -0.12846221f, -0.03446204f, -0.40463683f, 0.12088481f, -0.01083899f, 
    0.41295534f, 0.09935512f, -0.35151252f, -0.13460685f, 0.11275694f, -0.13828245f, -0.20021637f, -0.55935568f, 
    -0.04436595f, 0.21181957f, 0.09417817f, -0.09369557f, -0.57419181f, 0.42909500f, 0.01850123f, -0.03363693f, 
    0.55618948f, 0.08947018f, -0.51485240f, 0.28663826f, 0.22765931f, -0.23674920f, -0.16749981f, -0.19695416f, 
    0.54924947f, 0.38866031f, -0.21176854f, -0.04940048f, -0.40767008f, 0.13269037f, -0.36045742f, -0.38364977f, 
    -0.00204674f, 0.00090600f, 0.46848702f, -0.41497177f, -0.15138197f, -0.12490130f, 0.53985924f, 0.24327864f, 
    0.18728651f, 0.17628819f, 0.37162969f, 0.22377191f, 0.08838230f, -0.25608242f, -0.17666049f, 0.08831572f, 
    0.02269243f, -0.16356048f, 0.40113345f, 0.46440652f, -0.13925134f, 0.09935312f, -0.21911335f, -0.30595204f, 
    -0.18221535f, 0.27597740f, 0.22348903f, 0.04467472f, 0.22666888f, -0.22502208f, 0.01568877f, -0.02726383f, 
    -0.15245846f, 0.38552895f, -0.14635296f, -0.39884645f, 0.25154281f, -0.15398741f, 0.39778009f, 0.22804818f, 
    -0.00003338f, 0.04111284f, -0.02280483f, 0.20031470f, -0.05164704f, -0.06575885f, 0.12277403f, -0.03816676f, 
    -0.12359428f, -0.14204374f, -0.09138075f, -0.10154259f, -0.21230906f, -0.15940198f, -0.13050121f, -0.23719805f, 
    0.19212395f, 0.23357613f, -0.17179994f, 0.00107767f, -0.33760762f, -0.08886763f, 0.49703291f, 0.20602663f, 
    0.09756016f, -0.07659731f, -0.14331670f, 0.21934795f, -0.06507868f, 0.00231133f, -0.11890749f, -0.26486906f, 
    0.28988972f, 0.17864846f, 0.07091957f, 0.00404127f, 0.29861858f, 0.12913132f, -0.18429351f, 0.21850279f, 
    -0.45228475f, 0.42111331f, -0.12929623f, -0.30333304f, -0.20933792f, -0.04440419f, 0.50191367f, 0.42542669f, 
    0.09916708f, -0.19203395f, 0.31795627f, 0.04133022f, 0.46109799f, 0.08760336f, -0.37451798f, 0.02857455f, 
    -0.43657565f, 0.30986053f, -0.18668728f, 0.33449715f, 0.20438287f, 0.12267137f, -0.05438406f, 0.36071572f, 
    -0.27882570f, 0.68768090f, -0.29689908f, -0.16490778f, 0.33445895f, -0.21109982f, -0.15517096f, 0.11445028f, 
    0.31240165f, -0.03500209f, -0.13071133f, -0.30398494f, -0.25310433f, 0.16239646f, 0.33210468f, -0.03777635f, 
    -0.23247653f, 0.30645990f, -0.38984987f, -0.11354730f, 0.05304380f, 0.19852288f, 0.33128557f, 0.10451575f, 
    0.31615484f, -0.25982204f, -0.13593276f, -0.19419108f, -0.20003381f, -0.19081329f, 0.13932030f, 0.11090469f, 
    0.37545088f, -0.09190509f, -0.14890206f, 0.21006948f, 0.39702556f, -0.08492482f, 0.26072660f, 0.01177896f, 
    -0.21570954f, 0.10983584f, -0.17272799f, -0.21252756f, 0.06235901f, 0.15445584f, -0.12538494f, -0.36494875f, 
    0.13580433f, -0.17857850f, -0.43501657f, -0.13235788f, 0.28827724f, -0.10430936f, 0.43275726f, 0.32501557f, 
    0.07873967f, -0.31662649f, 0.44416848f, 0.25122166f, 0.11090459f, -0.05262545f, -0.40415004f, 0.18532112f, 
    -0.01480288f, 0.13490646f, -0.43574214f, -0.10861904f, -0.18150385f, 0.32975772f, 0.16803291f, 0.04202437f, 
    -0.02364895f, 0.28408638f, -0.12647243f, -0.31104839f, -0.08022337f, -0.00504360f, 0.43910065f, -0.03520619f, 
    0.35657108f, 0.20781156f, 0.33447847f, -0.00511049f, -0.31279862f, -0.21665968f, 0.02699220f, 0.00075216f, 
    0.53490955f, -0.08007817f, -0.16628642f, 0.37455162f, -0.11247628f, 0.11907148f, -0.11848374f, -0.41042563f, 
    -0.48923510f, 0.45217809f, 0.06613334f, -0.04051489f, -0.15579386f, 0.29307896f, -0.31310171f, 0.04655008f, 
    0.13601388f, -0.37155584f, 0.00455967f, 0.08336329f, 0.17364654f, 0.10171446f, 0.28912067f, -0.07757717f, 
    -0.01924139f, -0.55988443f, -0.05336415f, 0.05037969f, -0.24481349f, 0.19333139f, 0.45307744f, 0.17558897f, 
    0.13233221f, -0.33988962f, 0.48081657f, 0.36874101f, 0.11346757f, -0.11143956f, -0.19495702f, -0.14480336f, 
    0.37822527f, 0.56692630f, 0.23996530f, -0.20970590f, -0.29476792f, -0.14620663f, 0.32213208f, -0.33804819f, 
    0.11994343f, -0.09948584f, -0.10988144f, -0.43121621f, -0.09228253f, 0.22353579f, 0.50153691f, -0.07235237f, 
    0.23627520f, 0.02792753f, 0.63021910f, 0.00050849f, -0.28440160f, 0.07027385f, -0.09881093f, -0.07938287f, 
    0.44687787f, 0.04611944f, -0.19096208f, 0.29994509f, -0.19974282f, -0.00079995f, -0.50408077f, -0.18305603f, 
    0.07012139f, 0.33097863f, 0.43927032f, 0.08938105f, -0.28003505f, -0.07913742f, 0.23157592f, -0.10206641f, 
    0.47957933f, -0.17087549f, -0.01002904f, 0.16540512f, -0.17486404f, 0.17640439f, -0.03675206f, -0.45609722f, 
    0.13038687f, -0.04071658f, 0.07105406f, 0.22918987f, 0.00944274f, -0.12170925f, 0.10822976f, -0.15335517f, 
    -0.22113879f, -0.21442379f, -0.21254818f, -0.18633503f, -0.16017488f, -0.07246183f, -0.28078622f, 0.01690966f, 
    -0.14872903f, 0.26942942f, -0.38951865f, -0.04711064f, 0.10034591f, 0.20669758f, 0.19837464f, 0.04839693f, 
    -0.09076107f, 0.38363796f, -0.17334877f, -0.35474855f, 0.11849475f, 0.08656199f, 0.16447267f, 0.54881626f, 
    0.47404093f, -0.32446754f, 0.23733249f, 0.17210573f, 0.10225126f, -0.17568654f, -0.11485123f, -0.48353845f, 
    0.04552258f, -0.23361658f, 0.38219807f, 0.07449473f, 0.04476568f, -0.24932802f, 0.24862313f, 0.17201710f, 
    -0.24628836f, -0.02154249f, 0.07511029f, 0.10366985f, -0.18366817f, 0.11329404f, 0.04980186f, -0.15445280f, 
    -0.14749199f, -0.11691141f, -0.00880131f, 0.09947371f, -0.03162736f, -0.17435157f, -0.18548411f, -0.21260068f, 
    -0.20272726f, 0.02423298f, -0.10544339f, 0.10812962f, 0.16826940f, -0.15199937f, 0.11973624f, -0.18613376f, 
    0.16057219f, -0.08711316f, 0.03034548f, -0.22772186f, -0.05544567f, 0.04932934f, 0.00215622f, -0.07388246f, 
    0.14232868f, 0.49332768f, -0.37756500f, 0.07907325f, 0.16011766f, -0.24664624f, 0.13017292f, 0.09787938f, 
    0.50418454f, 0.25534251f, -0.18774913f, -0.43476295f, -0.12408708f, -0.10516658f, 0.53013414f, -0.28783631f, 
    -0.17791893f, 0.51514608f, 0.54871452f, 0.03426770f, -0.05115704f, -0.14498608f, -0.17410269f, 0.21876875f, 
    -0.18973336f, 0.21467192f, -0.20305850f, -0.29735747f, -0.10856098f, 0.02975535f, -0.02476916f, 0.11819720f, 
    0.21524915f, 0.01216750f, 0.12856802f, -0.11721441f, 0.04294349f, 0.17642432f, -0.02771769f, -0.55906647f, 
    0.26294857f, -0.41147673f, 0.09306715f, 0.09588231f, -0.22791630f, -0.08686459f, 0.37763724f, -0.25675353f, 
    0.09370727f, 0.07697972f, -0.18587796f, 0.10734013f, 0.26217416f, -0.16105150f, 0.32909667f, 0.37951979f, 
    -0.32100794f, -0.10747872f, 0.23262589f, 0.00686671f, 0.08108377f, -0.06006563f, -0.12728137f, 0.29668504f, 
    -0.05614110f, 0.16347064f, -0.09669308f, 0.15759172f, 0.14405173f, -0.09029961f, -0.07882415f, 0.24353856f, 
    -0.28604451f, 0.15595925f, -0.19103509f, 0.42952025f, 0.06335356f, 0.19659655f, -0.09829251f, 0.64373177f, 
    -0.22088467f, -0.18924031f, 0.13071565f, -0.03752611f, -0.49074391f, 0.32476756f, 0.51591194f, 0.05821611f, 
    0.01044188f, -0.19777454f, 0.07650004f, -0.01057907f, 0.21454681f, 0.19326913f, 0.15584750f, -0.04899187f, 
    -0.09482235f, -0.38035837f, 0.08514846f, 0.20744538f, 0.10549271f, -0.06050708f, -0.27449620f, 0.08644786f, 
    0.14223580f, 0.57497156f, -0.49313009f, 0.38972846f, 0.08651622f, 0.24532095f, -0.12089379f, -0.25375578f, 
    -0.14618188f, 0.09709513f, -0.42056042f, 0.20923138f, -0.05790979f, 0.33445141f, 0.36559787f, -0.13533062f, 
    0.06539967f, -0.45681521f, 0.01043966f, -0.45016035f, 0.12514868f, -0.21467784f, 0.58020067f, 0.19066748f, 
    0.37256935f, 0.58293557f, 0.09287033f, -0.14822036f, -0.38172048f, 0.13531755f, 0.31134862f, -0.37220293f, 
    -0.45502540f, 0.23545416f, -0.09173865f, -0.09027715f, -0.09989154f, -0.19612405f, 0.48128533f, -0.23930369f, 
    -0.17713423f, -0.00225388f, -0.05728694f, -0.18261728f, -0.03870706f, -0.09384584f, 0.00635099f, -0.18847001f, 
    0.10889178f, -0.21957350f, -0.00703230f, 0.02203212f, 0.06421757f, -0.08453438f, -0.05788831f, -0.07231521f, 
    0.49588859f, -0.12326344f, -0.18328740f, -0.16801640f, -0.22649716f, 0.26161191f, 0.53986597f, -0.04572067f, 
    -0.11007522f, -0.08506774f, -0.08698232f, 0.33650076f, 0.12882115f, -0.18478197f, 0.51888275f, -0.03649791f, 
    0.10617864f, 0.29774931f, -0.28455549f, -0.06186506f, 0.48572937f, -0.06327894f, -0.19234258f, 0.16694298f, 
    -0.48800755f, 0.48312688f, -0.07505054f, -0.38003421f, -0.17938966f, 0.23827690f, -0.13313468f, 0.05378922f, 
    -0.29096520f, 0.17962427f, -0.22549665f, -0.15436001f, -0.34481075f, 0.16115654f, 0.38692001f, 0.10787564f, 
    -0.11116861f, -0.21448064f, 0.19880675f, 0.42701638f, 0.12843214f, 0.04316880f, -0.26977301f, 0.06662287f, 
    -0.04343482f, -0.14153881f, 0.14616251f, -0.09958422f, 0.04287440f, -0.16509360f, -0.18099280f, -0.13007712f, 
    0.08757143f, -0.01101145f, -0.09942564f, -0.21365869f, 0.21180934f, -0.21256980f, 0.12897114f, -0.07496434f, 
    -0.00519024f, 0.29515275f, 0.41765642f, 0.01112089f, -0.38230744f, -0.07535790f, 0.15599434f, 0.16361715f, 
    -0.01086101f, 0.16028780f, -0.25557092f, -0.26024386f, 0.05949516f, -0.16183576f, -0.30931303f, 0.09180763f, 
    0.28734571f, 0.25178888f, -0.31536204f, 0.22214398f, -0.37899408f, -0.37643418f, 0.03322824f, -0.27719149f, 
    0.31994256f, -0.88701367f, 0.01826540f, -0.14002341f, 0.08651292f, -0.08061516f, 0.51915860f, 0.23459506f, 
    -0.30144200f, 0.11107535f, -0.23395142f, -0.21105249f, -0.13602136f, -0.19917406f, 0.30811009f, 0.43342692f, 
    -0.00789281f, 0.36617920f, -0.11699194f, -0.18323673f, -0.18332215f, 0.24903229f, 0.19278789f, 0.07005686f, 
    -0.04505339f, 0.39562702f, 0.17933226f, -0.07209954f, 0.23206300f, 0.29256201f, -0.18439382f, 0.00415803f, 
    -0.06111050f, -0.36726341f, -0.02639523f, -0.49279061f, 0.06340304f, 0.23316354f, -0.36388719f, 0.21405375f, 
    0.26190194f, -0.42463788f, 0.30833364f, -0.14701393f, 0.11874748f, 0.19055161f, -0.34815741f, 0.29316476f, 
    -0.22321931f, 0.11696974f, 0.18896598f, 0.41448122f, 0.14815649f, 0.07906516f, -0.14858750f, -0.17663687f, 
    0.30921406f, 0.24339658f, -0.05746949f, -0.01922636f, -0.02519637f, 0.20871842f, -0.25611573f, -0.20839863f, 
    -0.10329608f, -0.42096460f, 0.36565515f, -0.12814441f, -0.11746368f, 0.17241484f, 0.44525063f, 0.45090404f, 
    0.10758883f, -0.17818919f, 0.69053119f, -0.25062695f, -0.06499581f, -0.33297864f, 0.19957285f, 0.08387788f, 
    -0.58805901f, 0.19464572f, 0.04452480f, 0.19918828f, 0.05163652f, 0.23574147f, -0.00087201f, 0.26923263f, 
    0.22850579f, 0.32315409f, -0.46691084f, -0.19682691f, 0.25606826f, -0.24726550f, -0.02662894f, 0.01654911f, 
    0.41322610f, -0.08974886f, 0.02330825f, 0.39029041f, 0.14975642f, -0.19322084f, -0.34465736f, 0.13315548f, 
    -0.44412088f, 0.52054256f, 0.41599616f, 0.16856658f, 0.29731914f, -0.47798589f, -0.23649630f, 0.12019328f, 
    0.11115874f, 0.06089417f, -0.37542072f, 0.06546780f, -0.03541138f, -0.12299329f, 0.12224414f, -0.08563170f, 
    -0.45179570f, 0.36394790f, -0.02939225f, -0.11842974f, 0.68002570f, 0.23100089f, -0.23848705f, 0.05036368f, 
    -0.00213075f, -0.49384755f, -0.28251219f, 0.48647845f, 0.19693679f, -0.05049202f, 0.40346181f, 0.49165168f, 
    0.11374912f, 0.33301792f, -0.43399632f, -0.15375370f, -0.51889664f, 0.35948047f, -0.07108539f, 0.30540115f, 
    0.12727724f, 0.26105151f, -0.42505467f, 0.20942016f, 0.07778823f, -0.16977902f, -0.28856462f, 0.18232371f, 
    0.11664791f, 0.32337967f, -0.09164387f, -0.16963163f, 0.10917879f, -0.24557047f, 0.03933248f, 0.21576296f, 
    0.13343720f, -0.20232503f, 0.14359926f, -0.05423393f, 0.05096208f, 0.20608121f, -0.37283823f, 0.35479817f, 
    -0.15134464f, -0.27453926f, -0.23768504f, -0.17508771f, -0.42948937f, 0.33887208f, -0.08784683f, 0.24718498f, 
    -0.32237679f, 0.37779859f, 0.04352715f, 0.21372792f, -0.09149587f, -0.02429958f, 0.20950313f, 0.41422668f, 
    0.29499429f, 0.08153897f, 0.09583383f, -0.24774545f, -0.36656129f, 0.37722865f, -0.01227294f, -0.61539298f, 
    0.16960013f, -0.09783504f, -0.12060934f, 0.28637150f, -0.09687204f, 0.17015879f, 0.19295844f, 0.25915194f, 
    0.05738844f, -0.61426127f, 0.21307507f, -0.05248397f, 0.21752068f, -0.39299697f, 0.34189031f, 0.24692026f, 
    -0.44419438f, 0.16992643f, 0.49226728f, -0.04598913f, -0.09570745f, -0.05369653f, -0.18431398f, -0.06757499f, 
    -0.16478524f, -0.07186142f, 0.02230147f, -0.21691886f, 0.06955437f, 0.00853815f, -0.17617373f, 0.12550157f, 
    -0.10826778f, -0.20642576f, -0.03404380f, -0.26534706f, 0.00147700f, 0.01511219f, -0.02315022f, -0.05887072f, 
    0.16646253f, 0.15531199f, 0.05993982f, -0.09158205f, -0.16501787f, -0.20451745f, 0.39707097f, -0.23804545f, 
    0.48736721f, -0.50717443f, 0.41315031f, 0.08496118f, 0.13695817f, 0.20230682f, -0.19076295f, 0.21540567f, 
    0.18232483f, -0.29506028f, 0.43734753f, 0.23618315f, 0.39131814f, -0.12955302f, 0.45398703f, -0.24110456f, 
    -0.20960152f, -0.37265584f, 0.33948928f, 0.19158754f, 0.21416944f, 0.19598825f, -0.11441335f, 0.20742144f, 
    -0.22943331f, -0.01118650f, -0.18304937f, 0.12868340f, -0.31849635f, 0.24684581f, 0.24514230f, 0.20701274f, 
    0.25034204f, 0.22415926f, -0.12440844f, 0.04432892f, -0.03683610f, 0.10960288f, -0.15761651f, 0.09738833f, 
    0.07274126f, -0.15899836f, 0.44601426f, 0.06488138f, -0.70983315f, 0.04823995f, -0.06572177f, 0.08455306f, 
    -0.15097286f, 0.56916142f, -0.29118189f, 0.03954461f, -0.18550967f, 0.06254870f, -0.13951474f, 0.42525795f, 
    -0.07756803f, 0.14365818f, 0.39767835f, 0.20934530f, 0.23221420f, 0.41574943f, -0.26005596f, 0.15185998f, 
    -0.06266142f, 0.34285966f, -0.25579822f, -0.12226457f, -0.15365207f, -0.17746468f, 0.33082274f, 0.00685191f, 
    0.07689509f, -0.22612283f, -0.10043621f, 0.09153464f, -0.17822415f, 0.12840867f, 0.04303920f, -0.12005505f, 
    -0.11484957f, -0.10733286f, 0.02963537f, -0.19095424f, -0.12117231f, -0.19900090f, -0.11099583f, -0.24998239f, 
    0.03266792f, -0.17382450f, -0.17972785f, -0.13275662f, 0.11112934f, 0.03611385f, -0.16254658f, -0.12277824f, 
    -0.24226394f, -0.03053964f, -0.05627180f, 0.12661771f, 0.03669450f, -0.02030963f, -0.27008733f, -0.01511618f, 
    -0.53620476f, -0.24903524f, -0.29501912f, 0.21520641f, 0.74755508f, 0.04881791f, -0.14285620f, 0.20394994f, 
    -0.27780873f, 0.26025838f, 0.36112604f, -0.03226582f, -0.21596588f, 0.17832872f, -0.11391113f, 0.48249498f, 
    -0.44628310f, -0.18474767f, 0.11912756f, 0.05293205f, 0.34578708f, -0.13617392f, -0.05172309f, 0.29046342f, 
    -0.07527964f, -0.15072030f, 0.41767526f, 0.22577648f, -0.20719942f, 0.19967747f, -0.26222980f, 0.46149397f, 
    -0.21267377f, 0.09268569f, -0.01401873f, 0.09693834f, 0.26426283f, 0.13979702f, 0.09245878f, -0.47579959f, 
    -0.11626957f, -0.34768248f, 0.25591508f, 0.03331193f, 0.06059448f, -0.17719433f, 0.46364069f, 0.54694146f, 
    -0.21328443f, -0.12754670f, 0.43775812f, -0.07177371f, 0.12444042f, -0.09588398f, 0.61815637f, 0.11928314f, 
    -0.43388900f, -0.21015933f, -0.20193559f, 0.06480782f, 0.18028268f, -0.07194704f, 0.13456410f, -0.37743053f, 
    0.24670008f, 0.07193901f, 0.38781279f, -0.16265419f, -0.57539308f, -0.06268340f, 0.41589478f, -0.17344250f, 
    -0.17405182f, 0.22535145f, -0.37117061f, 0.13281487f, -0.22445096f, 0.25328895f, -0.48790622f, 0.18982738f, 
    -0.13598418f, -0.38330522f, 0.33239019f, 0.15678704f, -0.23983468f, 0.42508480f, 0.10307344f, -0.27841818f, 
    0.07122292f, -0.20713535f, 0.16324691f, 0.46801537f, 0.18809897f, 0.17824781f, -0.03874398f, 0.02114797f, 
    -0.14107549f, 0.15974291f, -0.11424369f, -0.05617902f, 0.06765177f, 0.02365801f, -0.25584719f, -0.26355806f, 
    -0.19641425f, -0.21084684f, -0.22216907f, 0.09821860f, -0.07750088f, 0.18678448f, 0.17560355f, -0.11952927f, 
    -0.33565539f, -0.06181705f, 0.18648942f, 0.16985482f, 0.25858498f, -0.19790508f, -0.47789404f, 0.18926620f, 
    0.43023518f, 0.31341860f, 0.25840363f, 0.01020327f, 0.17448950f, -0.04645368f, 0.01941171f, -0.34124556f, 
    -0.26199827f, -0.00084607f, -0.08304469f, -0.05070662f, -0.12329155f, 0.01915960f, 0.17911485f, -0.26404291f, 
    -0.10458689f, -0.22907242f, 0.08914392f, 0.08392648f, 0.04466259f, 0.02340901f, -0.09326799f, -0.11553480f, 
    0.54667908f, -0.32878646f, 0.25775930f, 0.24364951f, 0.30918390f, -0.11039178f, -0.09256759f, 0.04049416f, 
    0.04966708f, -0.67487484f, -0.10730484f, 0.27566564f, -0.10881618f, 0.16293752f, 0.10414919f, -0.27740958f, 
    -0.12470355f, -0.04516555f, 0.04308889f, -0.07866985f, -0.18215121f, 0.16809274f, 0.13018905f, -0.15925655f, 
    -0.27804428f, -0.18663456f, -0.12297443f, 0.00563897f, 0.08878998f, 0.07339656f, -0.10786787f, -0.21249713f, 
    0.18382484f, -0.12118018f, -0.09044303f, -0.11541900f, -0.47272500f, 0.47558099f, -0.07451912f, 0.15320536f, 
    0.35872650f, -0.38064277f, 0.30426523f, 0.29830536f, 0.01998282f, 0.00499800f, 0.09520898f, -0.17895590f, 
    0.13226362f, -0.33007884f, 0.07254575f, 0.17922920f, -0.20126176f, -0.03023687f, 0.02900492f, -0.33459586f, 
    -0.02871294f, 0.16838917f, 0.34555230f, 0.30963773f, -0.22626349f, -0.05384997f, 0.14441629f, -0.47890839f, 
    -0.75950450f, 0.07167845f, 0.35464644f, 0.09420717f, 0.27595431f, 0.41380057f, -0.43141022f, 0.29078031f, 
    -0.07717741f, 0.20518617f, -0.36527288f, 0.21249366f, -0.19199835f, 0.19331881f, -0.28312257f, 0.08546966f, 
    0.01752112f, -0.10393391f, -0.03580268f, -0.15678558f, 0.02868894f, -0.03872785f, 0.11574496f, 0.32677841f, 
    -0.46218950f, 0.26488188f, 0.08047531f, 0.05054297f, 0.05269040f, -0.09974727f, -0.11810467f, 0.32999012f, 
    0.44262642f, 0.48893616f, -0.04063127f, 0.15248971f, 0.00961399f, -0.24968952f, 0.07363836f, -0.22970070f, 
    0.46983483f, -0.22125290f, 0.32376501f, -0.08592340f, -0.23871064f, 0.24691617f, -0.24513741f, 0.28980696f, 
    0.49176130f, -0.18006782f, 0.32026824f, 0.23327881f, 0.26171356f, 0.17034005f, -0.10519516f, -0.52618629f, 
    0.11410435f, -0.09019253f, 0.04504457f, 0.37168261f, 0.18833683f, -0.02943977f, -0.08461261f, -0.07391746f, 
    0.03293762f, -0.07409887f, 0.18095532f, -0.08957946f, -0.11950006f, 0.06100226f, -0.13578032f, 0.02184775f, 
    -0.18480507f, -0.03856928f, 0.17116447f, -0.23551865f, 0.19412184f, 0.13889840f, -0.19884285f, -0.18990172f, 
    0.39116234f, 0.15233797f, 0.59651667f, 0.07933558f, -0.31588113f, 0.01233806f, -0.09146370f, -0.01108567f, 
    0.14956373f, -0.11156739f, 0.18563087f, 0.26966962f, -0.05056673f, 0.11619760f, -0.14814405f, -0.37960058f, 
    0.35364893f, 0.11314560f, -0.15720524f, -0.18011290f, -0.29727912f, 0.03924951f, -0.16564317f, -0.33338752f, 
    0.09295660f, -0.19110139f, 0.52981526f, -0.08079042f, -0.03376556f, -0.04481429f, 0.41605696f, 0.14765088f, 
    0.09913925f, 0.51832086f, -0.68554258f, 0.10919260f, -0.51047093f, -0.09131582f, -0.22379750f, -0.16554773f, 
    0.09176202f, 0.25830761f, 0.13166693f, -0.33269826f, 0.20010677f, -0.25274783f, 0.29642802f, 0.26375040f, 
    -0.16574596f, 0.18788189f, 0.57450151f, 0.01880451f, -0.32986003f, -0.11701009f, 0.44353181f, 0.29615170f, 
    -0.15904126f, -0.25828803f, 0.18776557f, 0.26334134f, -0.02588021f, -0.06350514f, -0.09383941f, -0.10231518f, 
    -0.64363599f, 0.64292157f, -0.15291893f, 0.07290182f, 0.12377725f, 0.16420615f, 0.13875480f, 0.35495511f, 
    0.28895426f, 0.10882218f, -0.56094503f, -0.32269579f, -0.06286716f, 0.18545923f, -0.19978845f, -0.16395965f, 
    0.48034474f, -0.02870761f, -0.00516761f, -0.09465121f, -0.09032690f, 0.23350039f, 0.34635693f, -0.08788320f, 
    0.04619217f, -0.09113992f, -0.27480215f, 0.07981835f, -0.02356424f, 0.10483644f, 0.31613818f, -0.06747647f, 
    -0.41803414f, -0.21246935f, -0.32089511f, -0.01818505f, -0.43288663f, 0.54093939f, 0.04303055f, 0.35239139f, 
    -0.12712727f, 0.31414083f, -0.09685407f, -0.32725769f, 0.21126558f, 0.19592625f, 0.21872407f, 0.12885611f, 
    0.06559811f, 0.36425561f, -0.01384506f, 0.12719198f, 0.21803609f, -0.51829833f, 0.05837663f, 0.02837646f, 
    -0.09025544f, -0.96743286f, -0.09934372f, 0.10083851f, -0.24039054f, -0.11296139f, 0.35008574f, 0.53296876f, 
    -0.30044484f, 0.20774589f, -0.10191934f, 0.06740347f, -0.27947387f, 0.07380992f, 0.13088401f, 0.11213818f, 
    -0.08233494f, 0.53808022f, -0.25114590f, 0.16353989f, -0.05952093f, 0.10277474f, -0.06204442f, 0.10178171f, 
    -0.25143275f, 0.31612906f, 0.07373129f, 0.16295174f, -0.18769315f, 0.32920399f, -0.25767529f, -0.16479771f, 
    0.05325473f, 0.62090909f, -0.41130939f, -0.05200203f, 0.12829673f, 0.05656281f, 0.56194848f, 0.03961696f, 
    0.16755965f, 0.20723097f, 0.35448939f, 0.19269139f, -0.63167167f, 0.03317146f, 0.08963641f, -0.27527487f, 
    0.07334724f, 0.25652382f, -0.60080129f, 0.22280610f, -0.25340521f, 0.06597108f, 0.18392046f, -0.04764689f, 
    0.03577828f, -0.28735107f, 0.01987841f, 0.23440304f, -0.15785006f, -0.14769801f, 0.04747482f, -0.19615781f, 
    0.11021966f, -0.07333212f, -0.05793075f, -0.06915706f, 0.20476431f, 0.16998678f, -0.28382853f, -0.09992699f, 
    -0.29042873f, -0.49970302f, -0.12637661f, 0.03145149f, 0.69255644f, 0.18110718f, 0.11316162f, -0.01209213f, 
    -0.19977689f, 0.20958555f, 0.36758134f, 0.14306776f, -0.04363682f, 0.13049671f, -0.22717705f, 0.27078232f, 
    0.56740278f, -0.31052041f, -0.46061957f, 0.18852860f, -0.02721486f, 0.25912613f, -0.28125915f, -0.06874835f, 
    0.35758185f, 0.25720015f, -0.16019267f, 0.20015939f, 0.12212730f, 0.18539393f, 0.42771748f, -0.24316053f, 
    -0.01189026f, -0.16415818f, 0.10908523f, -0.18106395f, -0.21652204f, 0.09387579f, -0.04033674f, 0.24380518f, 
    -0.03068010f, 0.16789006f, -0.29621676f, 0.29613206f, 0.19693050f, 0.14328034f, -0.37066701f, 0.20549707f, 
    -0.10456108f, -0.41527653f, -0.62714285f, -0.02621935f, -0.27639666f, 0.50229675f, 0.09402739f, 0.25867078f, 
    -0.15982498f, 0.25578490f, -0.29203886f, 0.16348676f, 0.01550679f, -0.18357913f, 0.13937525f, -0.06869728f, 
    0.07625585f, -0.03470477f, 0.45804721f, 0.09285203f, -0.24423639f, 0.36505285f, -0.14123827f, -0.22004811f, 
    -0.07009605f, 0.14331080f, 0.07175127f, 0.02189561f, -0.16661903f, -0.07121348f, 0.60782009f, -0.26468259f, 
    -0.06066800f, -0.17798068f, 0.17429213f, -0.14415574f, 0.04491053f, -0.12419353f, -0.27072698f, -0.22898334f, 
    -0.03991809f, 0.15650924f, -0.13585983f, -0.19147131f, -0.16007176f, -0.20572010f, 0.04393613f, -0.28609356f, 
    0.10215843f, 0.00113229f, 0.19759965f, -0.19325906f, 0.44151172f, -0.14566343f, 0.07549697f, 0.01471581f, 
    -0.11893310f, 0.45591483f, -0.46498266f, -0.41501352f, 0.26293206f, 0.16430977f, 0.44749594f, 0.19694255f, 
    -0.29746956f, -0.01322222f, -0.15813620f, 0.11849102f, -0.33585265f, 0.29743695f, -0.07812969f, 0.23151504f, 
    0.30453303f, -0.07192028f, -0.12571152f, -0.13372090f, -0.21979791f, -0.01498070f, 0.28534660f, -0.34479809f, 
    0.00519089f, -0.26749519f, -0.17178880f, 0.17479649f, 0.52965921f, -0.32576358f, 0.32682160f, -0.11800350f, 
    -0.26436749f, -0.22578388f, 0.32401836f, 0.47097144f, 0.04217613f, -0.09636009f, -0.31360039f, 0.50555849f, 
    -0.22124006f, -0.09394135f, 0.07184618f, -0.00048453f, -0.28296596f, -0.12776069f, 0.05583274f, 0.08883587f, 
    -0.04013962f, 0.00239934f, -0.19470896f, -0.13658080f, 0.16554067f, 0.12113434f, 0.14405997f, -0.05009681f, 
    -0.52504605f, 0.05707244f, 0.27616724f, -0.06217051f, -0.13647297f, -0.36649922f, 0.30979243f, -0.21790144f, 
    0.27299359f, 0.15983565f, 0.17419121f, 0.12850097f, -0.19432555f, 0.10916388f, 0.31288356f, -0.44266629f, 
    0.21035199f, 0.37719440f, -0.30130774f, 0.00590077f, 0.31705821f, -0.18515073f, -0.30843824f, 0.46868452f, 
    -0.08232939f, 0.15422913f, 0.07716191f, -0.03216165f, 0.18243054f, -0.02182990f, 0.04795212f, 0.42644668f, 
    0.44705951f, -0.10582068f, 0.01951357f, -0.00590402f, -0.12171090f, 0.43790448f, -0.08968329f, -0.12516400f, 
    0.07451691f, 0.12952010f, 0.03506023f, 0.03054130f, 0.00731176f, 0.09729546f, 0.01253207f, 0.03180020f, 
    -0.49272108f, -0.07048462f, 0.06344403f, 0.21842688f, -0.31734243f, 0.53471285f, 0.41933227f, 0.09129965f, 
    0.05143830f, -0.08500426f, -0.44123688f, 0.26398429f, -0.04475345f, -0.15036511f, 0.19658816f, 0.07090123f, 
    0.19551371f, -0.14569700f, -0.17282528f, -0.12510523f, -0.31465316f, 0.40009719f, 0.08414376f, 0.30054766f, 
    0.46399531f, -0.09718563f, -0.24241687f, -0.02262165f, 0.17259492f, -0.06420058f, -0.21911284f, -0.25673553f, 
    -0.29368883f, 0.06413919f, 0.26559338f, -0.08821163f, 0.34622520f, 0.36286023f, -0.18350568f, -0.13842408f, 
    -0.04299663f, 0.50660479f, -0.19225836f, -0.23872590f, -0.25776273f, -0.03460082f, 0.19535564f, 0.11673715f, 
    0.04720550f, -0.15096065f, -0.05011121f, -0.20658350f, 0.19030187f, -0.00536805f, -0.04770663f, -0.20247439f, 
    -0.03436711f, -0.16539580f, -0.03216149f, 0.04559243f, -0.01131972f, -0.12632099f, -0.01829729f, -0.18349180f, 
    -0.29876968f, -0.13497762f, -0.01722999f, -0.05437413f, -0.39574030f, 0.10517361f, 0.23129821f, -0.40597710f, 
    0.35677364f, 0.12033359f, -0.30760711f, 0.46529973f, -0.03148821f, -0.02449745f, 0.09991805f, -0.18716986f, 
    0.15780185f, 0.48205656f, -0.11275216f, 0.09776006f, 0.09408198f, -0.19034930f, -0.06987751f, -0.25371629f, 
    0.39446837f, 0.06938397f, -0.24266277f, -0.05343123f, 0.17074057f, 0.11066644f, 0.32732052f, 0.02506249f, 
    0.32480869f, 0.10250241f, 0.28533927f, 0.09226967f, -0.77755809f, 0.35310078f, 0.23081705f, 0.08195780f, 
    -0.28674901f, 0.22701134f, -0.53147781f, 0.17409268f, 0.04183401f, 0.23087944f, 0.01863363f, 0.01883158f, 
    -0.17757469f, -0.11727679f, -0.22534376f, 0.22421792f, 0.13560700f, -0.18097976f, -0.06113556f, -0.06607786f, 
    -0.16558045f, 0.14600837f, 0.05198187f, -0.05919364f, 0.03979239f, 0.09848139f, -0.18033460f, -0.23959377f, 
    0.10910859f, -0.35137862f, -0.26524064f, -0.19916454f, -0.25346422f, -0.26264381f, 0.45251060f, 0.42391440f, 
    0.40778798f, -0.42574927f, 0.51364452f, 0.29818454f, 0.10531734f, -0.11619326f, -0.49225742f, -0.21837480f, 
    0.34997043f, 0.11116372f, -0.03274077f, -0.00733658f, -0.29176345f, 0.13031720f, 0.19365451f, -0.27414227f, 
    0.22217304f, 0.08778566f, -0.25119638f, 0.28526810f, 0.22537199f, 0.19771837f, 0.32177803f, -0.26824063f, 
    -0.21947761f, 0.17639855f, 0.22016075f, 0.00387434f, -0.37147731f, -0.09882719f, -0.09967834f, 0.12595801f, 
    0.26844421f, 0.09761193f, 0.39530164f, 0.05634143f, 0.12982021f, 0.24165504f, -0.30705464f, -0.08970735f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.35591972f, 0.32552958f, 0.18206231f, -0.24582723f, 0.12194688f, 0.05792035f, 0.11561185f, 0.27699181f, 
    -0.57784027f, 0.37972283f, -0.07211018f, 0.38176847f, 0.44388083f, 0.46745583f, -0.30910242f, -0.03991871f, 
    0.06008133f, -0.16491136f, 0.46622029f, -0.43292829f, -0.24010913f, -0.09067477f, 0.42906967f, -0.23993565f, 
    0.03551040f, 0.09037128f, 0.16671941f, -0.32782200f, -0.14147936f, 0.03660653f, 0.36481756f, 0.15545465f, 
    0.16848676f, 0.00835403f, -0.04941902f, -0.11244971f, 0.08527948f, -0.07525618f, 0.33043152f, 0.26673025f, 
    -0.26228413f, -0.32551944f, 0.36475590f, 0.33482760f, 0.02668840f, -0.10396587f, 0.02460424f, 0.21912533f, 
    -0.20169151f, 0.04905878f, -0.25121039f, 0.12738301f, -0.38406426f, 0.53587794f, 0.39705715f, 0.17837638f, 
    -0.18011947f, -0.34614918f, -0.27090979f, 0.30446121f, -0.00307265f, 0.31901991f, -0.21355788f, 0.29548767f, 
    0.15619826f, 0.51516372f, 0.01937682f, -0.11643383f, 0.26093233f, 0.95868015f, 0.39813450f, 0.09902646f, 
    0.05691919f, -0.11932725f, 0.00283508f, 0.38090262f, -0.27653578f, -0.02495346f, 0.10160133f, 0.51280147f, 
    -0.16011758f, -0.00970658f, -0.24918212f, 0.34791708f, -0.02004571f, -0.44758499f, 0.36748022f, 0.27414247f, 
    -0.17410085f, -0.19037613f, -0.10018416f, -0.15494482f, -0.17502861f, -0.01498819f, -0.07336109f, 0.19133358f, 
    0.36524048f, -0.39531597f, 0.04444236f, 0.35909438f, 0.44147357f, 0.48079646f, 0.38559413f, -0.06453072f, 
    0.07477443f, -0.30064893f, 0.29154161f, 0.23874305f, 0.29993182f, -0.12447358f, -0.23248617f, -0.21594933f, 
    -0.21306905f, -0.26007098f, 0.15639725f, -0.29305357f, -0.47692767f, 0.29416242f, 0.52861232f, -0.08738664f, 
    0.07244824f, 0.24415760f, -0.32740599f, 0.05954826f, -0.07898274f, 0.24442919f, 0.28858882f, 0.34470734f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.12182964f, 0.40542942f, -0.07704915f, -0.03484385f, -0.32107481f, 0.17599896f, 0.49104106f, -0.56869417f, 
    0.08857409f, -0.47267804f, -0.10327365f, -0.34652957f, 0.43591157f, -0.03463964f, -0.29046357f, -0.21496603f, 
    0.19811037f, -0.05922461f, 0.14892527f, 0.15625720f, -0.58191162f, 0.43072471f, 0.16824462f, -0.60816365f, 
    -0.03300022f, 0.14410992f, 0.07696275f, 0.25584462f, -0.36538643f, 0.26793566f, -0.11491525f, 0.00075063f, 
    0.05942756f, 0.19128844f, -0.16444652f, 0.07405063f, -0.02806203f, 0.33966836f, 0.33870664f, -0.38435435f, 
    0.08635753f, 0.03584387f, -0.07469441f, -0.94880736f, -0.47843444f, 0.11955630f, -0.05749440f, 0.10598483f, 
    -0.49031115f, -0.14097172f, -0.03025180f, 0.19504672f, -1.49331105f, 0.19989707f, 0.54613924f, -0.33711496f, 
    -0.26660925f, -0.05929407f, 0.07445871f, 0.23937909f, -0.03245128f, 0.13172051f, 0.10742988f, -0.23238619f, 
    -0.43834999f, -0.07720329f, -0.00567071f, -0.19550331f, -0.28860921f, 0.05525485f, -0.13364728f, -0.07613887f, 
    0.00281769f, 0.00390988f, -0.52472055f, -0.44365370f, -0.26330212f, 0.10834108f, 0.20603903f, -0.32833022f, 
    -0.03348713f, -0.06797503f, -0.02158461f, -0.54405606f, -0.07503843f, -0.25295186f, 0.65183300f, -0.49162385f, 
    0.05120135f, 0.03529652f, -0.21663864f, 0.05494379f, -0.03296265f, -0.40937048f, 0.14803539f, 0.01968155f, 
    0.34187809f, 0.08094750f, -0.21135812f, -0.39425072f, 0.00935007f, 0.07349542f, -0.10945919f, 0.06840421f, 
    -0.41758752f, 0.08393365f, -0.19063123f, 0.13894725f, -0.26768562f, 0.01772061f, 0.23379880f, -0.25019908f, 
    -0.32444558f, 0.04757007f, -0.08261864f, 0.15731613f, -0.12690383f, -0.18491375f, 0.12509403f, -0.29499170f, 
    0.00254754f, -0.52722943f, 0.27146456f, 0.08390589f, 0.05395044f, -0.10441588f, 0.06885456f, -0.09030771f, 
    0.19465119f, 0.10657810f, -0.04959120f, -0.23651312f, -0.08399001f, -0.17565736f, 0.02234062f, -1.17744374f, 
    0.05429007f, -0.15522937f, 0.04238056f, -0.05322695f, -0.18559040f, -0.12194968f, 0.11079133f, -0.37149245f, 
    0.09064480f, 0.07849319f, -0.12944564f, 0.18606071f, 0.17109443f, 0.05212888f, -0.03349262f, 0.09520583f, 
    0.11164000f, 0.04198259f, -0.44528648f, -0.22041781f, -0.63120091f, -0.31592831f, -0.14895548f, -0.47164348f, 
    -0.01526243f, 0.22928135f, 0.34372678f, -0.01177204f, 0.00287067f, 0.01140206f, -0.20307378f, -0.32528305f, 
    0.11801658f, 0.24949326f, -0.50147420f, 0.33603448f, -0.22937813f, -0.85323066f, 0.02450212f, -0.09821992f, 
    -0.02748221f, 0.03015934f, 0.08225279f, -0.07227523f, -0.05391175f, 0.11921080f, -0.09008667f, 0.10719976f, 
    -0.00202862f, -0.30604556f, 0.23576514f, -0.29064602f, 0.18126032f, 0.20190956f, 0.09913590f, 0.29116949f, 
    -0.18739855f, 0.03013803f, -0.08814801f, 0.20837635f, -0.10221995f, 0.07820008f, -0.07103393f, 0.13409224f, 
    0.00213753f, -0.00826101f, 0.35469928f, 0.09767018f, 0.04139692f, 0.07812048f, -0.91344208f, -0.36340690f, 
    -0.01145656f, 0.01075518f, 0.06396874f, 0.05407534f, 0.02200628f, -0.34630537f, -0.03617353f, 0.12647265f, 
    0.22140764f, 0.12940690f, -0.08443169f, -0.00706093f, -0.24356095f, 0.25828055f, 0.07943214f, -0.25490406f, 
    0.21843106f, -0.14361884f, 0.23295844f, 0.65525514f, 0.19832781f, 0.11276367f, -0.73958707f, 0.07999466f, 
    0.16070955f, 0.25919783f, 0.12698840f, 0.41594759f, -0.37822312f, 0.00728998f, 0.13604365f, 0.08876520f, 
    0.34645551f, -0.06923836f, -0.26587915f, 0.17596513f, 0.03966782f, -0.04572747f, -0.10892184f, 0.10962835f, 
    -0.09278885f, -0.33175299f, 0.08237536f, -0.33790115f, 0.05695063f, -0.51348525f, -0.09797961f, -0.12364914f, 
    -0.43493018f, -0.09139884f, -0.58064079f, -0.46418843f, -0.02261826f, -0.87674928f, 0.54449695f, 0.39760634f, 
    -0.43714216f, 0.15803970f, 0.39968389f, -0.05260768f, 0.38221622f, 0.21539758f, -0.55143994f, 0.20342930f, 
    -0.06892214f, 0.01969542f, -0.15823160f, -0.30332139f, 0.00826777f, 0.42009300f, 0.00327111f, 0.06129904f, 
    -0.00110067f, -0.50459707f, 0.23532461f, -0.09822465f, 0.19193973f, -0.50765073f, 0.18050694f, 0.14187546f, 
    -0.00975155f, -0.13542649f, -0.84602964f, 0.02225027f, 0.01812186f, 0.10485399f, 0.10481755f, -0.30848545f, 
    -0.27062491f, 0.05181810f, -0.11039213f, 0.21082661f, -0.34252647f, -1.12606943f, 0.05292447f, -0.61523849f, 
    0.63118279f, 0.05781475f, -0.06661871f, -0.09839502f, -0.42956111f, 0.00353237f, 0.63717401f, -0.03870587f, 
    -0.69439369f, -1.26366377f, 0.39046556f, 0.18166006f, 0.11786242f, 0.07988254f, 0.23002723f, -0.26136720f, 
    -0.14355356f, -0.84693766f, 0.00851468f, 0.25482678f, -0.37071365f, 0.08447003f, -0.33929771f, 0.03955819f, 
    0.08579335f, -0.06283006f, 0.03023229f, 0.19298849f, -0.57104152f, -0.95565158f, -0.49905476f, -0.13330136f, 
    0.05757644f, 0.41023237f, -0.01901187f, -0.06618083f, -0.05893033f, 0.22052127f, -0.32802716f, 0.18618584f, 
    -0.17380531f, 0.16039884f, -0.09615786f, 0.04843787f, 0.03669604f, -0.44407737f, -0.40188783f, -0.00016764f, 
    0.18793023f, -0.45514813f, -0.72334760f, -1.63876164f, 0.00193241f, -0.00485595f, -0.14952655f, 0.02654344f, 
    -0.04258785f, -0.17073436f, 0.06238298f, -0.50796890f, -0.37419608f, 0.01030427f, -0.33334371f, -0.55356532f, 
    -0.23023751f, 0.02320115f, 0.13700338f, 0.15500432f, -0.38012072f, -0.37089011f, 0.08181363f, 0.00511192f, 
    -0.00695716f, 0.24245305f, 0.22620231f, -0.87641740f, 0.08646008f, 0.56407934f, -0.19288072f, 0.24807182f, 
    -0.07862692f, -0.57554084f, -0.01652772f, 0.21620922f, -0.21261162f, -0.06945982f, 0.07654346f, -0.58255571f, 
    0.15793693f, -0.18877003f, 0.31236732f, -0.24712984f, -0.00602689f, -0.02060096f, 0.06652785f, 0.20819801f, 
    -0.44414812f, 0.08360960f, 0.07063516f, -0.18912977f, -0.54855096f, -0.53337318f, -0.07594409f, 0.02509851f, 
    0.13061522f, -0.16076729f, 0.29219368f, -0.81112599f, 0.10048717f, 0.18135950f, 0.22489011f, 0.18414618f, 
    -0.01850884f, -0.62054181f, 0.24167182f, -0.08340567f, 0.01379360f, 0.08229329f, -0.34535679f, 0.29477119f, 
    -0.01702983f, -0.54238188f, -0.11323532f, -0.48388746f, -0.51564491f, 0.08896481f, 0.02972137f, 0.07744443f, 
    -0.92740935f, -0.32250983f, -0.01170668f, -0.23122819f, -0.09041569f, -0.44907287f, -0.64226192f, 0.03800173f, 
    0.04079983f, -0.44944453f, 0.25876135f, -0.48150313f, -1.34763479f, -0.26946330f, 0.02385661f, -0.49260989f, 
    0.10899431f, -0.15442298f, -0.07591948f, 0.25053877f, 0.12791795f, -0.29609728f, -1.08241975f, 0.11408732f, 
    0.06665440f, 0.00404281f, 0.10219310f, -0.31584021f, -0.34668624f, -0.34825331f, 0.13906236f, 0.01327855f, 
    0.03979645f, 0.28548014f, 0.00540942f, 0.17338209f, -0.06066971f, 0.25305468f, 0.15760408f, -1.28049517f, 
    -0.27822450f, 0.25353149f, 0.40213418f, 0.03210891f, 0.26559141f, 0.12499505f, -0.48191896f, -0.04083207f, 
    -1.00127709f, 0.15232757f, -0.01468015f, -0.27268779f, -0.95949036f, -1.04515386f, -0.07495533f, 0.01336612f, 
    -0.02101981f, 0.24805951f, -0.69198072f, -0.18915425f, -0.08105040f, -0.01714804f, -0.25950047f, -0.01961106f, 
    -0.10377035f, -0.03103351f, -0.06148648f, -0.18267274f, 0.17024404f, -1.02670240f, 0.20942000f, -0.17211199f, 
    -0.04339641f, -0.53644371f, 0.03158058f, -0.05846335f, -0.01665105f, 0.16677758f, 0.08616521f, 0.09768402f, 
    0.24132465f, -0.26932386f, 0.05724266f, -0.45644832f, 0.37277693f, -0.04565999f, -0.07362178f, -0.63672042f, 
    -0.14479837f, -0.23115572f, 0.20079790f, -0.26265398f, 0.25126871f, 0.15265465f, 0.15873079f, -0.22696865f, 
    0.15773650f, 0.06649055f, 0.01797784f, -0.10036225f, -0.15152223f, -0.13416739f, 0.11908313f, 0.12366733f, 
    -0.25241682f, 0.13099609f, 0.04077471f, -0.30016771f, -0.12126260f, 0.13626955f, 0.07899392f, 0.15785952f, 
    0.02416386f, 0.04123197f, 0.10391461f, -0.02954689f, -0.13387473f, 0.13868999f, -0.17218962f, 0.44841802f, 
    -0.33794466f, -0.30859429f, -0.02959836f, 0.18383147f, -0.18567778f, 0.28837514f, 0.07890217f, 0.11354355f, 
    0.47731009f, -0.14774087f, 0.05595347f, 0.04145637f, -0.80029261f, -0.10034262f, 0.33500555f, -0.21016717f, 
    0.08703894f, -0.16666637f, -0.13834770f, 0.06925852f, 0.09762655f, -0.15770993f, -0.42339674f, -0.33468238f, 
    0.36205873f, -0.25101385f, -0.02097787f, -0.17673916f, 0.04282496f, 0.08060675f, -0.07111018f, 0.08769055f, 
    0.05537314f, -0.12518182f, -0.21277109f, -0.22798544f, 0.27283725f, 0.28988007f, 0.11348448f, 0.23820505f, 
    -0.04574651f, -0.15191683f, 0.00550614f, 0.12179864f, -0.04489823f, -0.23467065f, 0.18410181f, -0.16107211f, 
    -0.31074449f, -0.11136182f, 0.27451554f, -0.06337894f, -0.02569089f, 0.12145996f, 0.06228876f, -0.08548935f, 
    -0.23341179f, 0.04327189f, -0.55454952f, -0.57139099f, -0.02334783f, 0.17859000f, 0.22804965f, -0.01099115f, 
    0.03844113f, 0.00041335f, -0.26423720f, -0.56228799f, 0.25456521f, -0.23687874f, 0.22792490f, -0.45777050f, 
    -0.05956836f, -0.02695659f, 0.28860384f, -0.44281313f, 0.01418737f, 0.21701695f, 0.06213661f, 0.14688043f, 
    -0.06331441f, 0.52948231f, 0.12485874f, -0.09251942f, 0.08534956f, -0.50891656f, 0.21361493f, -0.08935902f, 
    0.16056518f, 0.15785424f, 0.05119822f, -0.13426873f, -0.03657006f, 0.20223074f, -0.41505045f, 0.50875288f, 
    -0.02180234f, 0.26673755f, -0.57333833f, 0.03269942f, -0.18221582f, 0.06808635f, 0.47607860f, -0.47464812f, 
    0.07234649f, -0.01866120f, -0.07514534f, 0.07204902f, -0.04525868f, -0.11530679f, 0.12140629f, -0.08440655f, 
    -0.12873118f, 0.23204575f, -0.47367886f, -0.66956514f, -0.23569968f, -0.08756877f, -0.07777884f, -0.33746493f, 
    0.02734222f, 0.24921668f, -0.16304113f, 0.07771803f, -0.19674307f, -0.03696818f, 0.05204658f, 0.02255682f, 
    -0.03190683f, -0.08172563f, 0.07993473f, 0.18164912f, 0.39583397f, 0.08050404f, -0.04826722f, -0.02268723f, 
    -0.45538670f, -0.13019286f, 0.06694927f, 0.16219938f, 0.27000585f, 0.08983133f, -0.21003944f, -0.03778565f, 
    0.17499879f, -0.26561749f, -0.38448745f, -0.29546055f, 0.09866478f, 0.15913196f, -0.24802044f, 0.23415199f, 
    -0.16364670f, -0.13347481f, 0.01759534f, -0.25205770f, -0.15545331f, 0.23384629f, 0.26783374f, 0.14521833f, 
    0.05208964f, 0.03910347f, 0.13297595f, 0.11216193f, -0.01653155f, 0.35493287f, -0.05823623f, -0.06359027f, 
    -0.06387214f, -0.23780906f, -0.00376355f, -0.86649472f, -0.02187749f, 0.06320870f, -0.57402599f, 0.19773088f, 
    0.05103942f, -0.27992463f, -0.61509246f, 0.06630743f, -0.25145188f, 0.27997985f, 0.57315648f, -0.02116265f, 
    -0.00407843f, -0.09244373f, 0.34117967f, 0.43700340f, 0.12519246f, 0.19713753f, -0.08923614f, 0.03952760f, 
    0.12603492f, -0.01562898f, 0.04434085f, 0.13656788f, -0.08489120f, -0.09634089f, 0.04171364f, -0.25631899f, 
    -0.50541395f, -0.01387634f, 0.06964302f, -0.04283867f, -0.04191383f, 0.25459474f, 0.08603662f, 0.05271866f, 
    0.04204644f, -0.83359224f, -0.19298942f, 0.16341287f, 0.08423401f, -0.38565853f, -0.09704595f, 0.07517628f, 
    0.09072796f, -0.08370990f, 0.02336122f, 0.06548342f, 0.01241724f, -0.41982400f, -0.38244629f, -0.27030882f, 
    0.24231260f, -0.36311731f, -0.73112702f, 0.23323618f, -0.39694795f, 0.28916267f, -0.76094413f, -0.02871540f, 
    -0.41052827f, -0.07931361f, 0.10848324f, -0.08354101f, -0.02019151f, -0.19509359f, -0.07751773f, -0.09600093f, 
    -0.02531352f, 0.17548810f, 0.07534900f, 0.64759952f, 0.20370376f, -0.61773700f, 0.04176976f, -0.05969054f, 
    -0.04069905f, -0.09828193f, 0.12359316f, -0.03235649f, -0.00349199f, -0.15252765f, -0.20245342f, -1.03604019f, 
    -0.15251552f, -0.01581419f, 0.12302065f, 0.07592405f, -0.51065916f, -0.28113556f, 0.02736655f, 0.24937746f, 
    -1.41907811f, 0.17804998f, -0.06477882f, -0.10595754f, -1.16329491f, -0.01217541f, -0.38026720f, 0.22708425f, 
    -0.47893125f, 0.12549506f, -0.07881843f, -0.61203617f, -0.14818980f, 0.21401517f, -0.32986316f, 0.26481530f, 
    0.20983674f, 0.06321555f, 0.04301779f, -0.67365897f, -0.29549000f, 0.12261078f, 0.16086276f, 0.02941193f, 
    0.07813272f, -0.06572042f, -0.48481229f, -0.19084358f, -0.83475369f, -1.13131154f, -0.01247131f, 0.23872490f, 
    -0.02390744f, -0.23463233f, 0.04439005f, 0.67072153f, -0.01716284f, 0.34255445f, 0.25306243f, 0.14307708f, 
    -0.04483656f, -0.63658279f, 0.03224576f, -0.10183285f, 0.18993734f, -0.37577760f, -0.90086538f, 0.09546897f, 
    0.02357086f, 0.13803378f, 0.40512255f, -0.84499460f, 0.00422864f, 0.21482170f, 0.29278457f, -0.07385182f, 
    -0.11131936f, 0.34071040f, 0.12045859f, 0.30730355f, 0.24792062f, -0.14826399f, -0.32071668f, 0.49593166f, 
    -0.23882686f, 0.01173750f, -0.16109958f, -0.11399239f, 0.11649837f, 0.24673754f, 0.33810163f, -0.05333292f, 
    0.07311281f, 0.08680501f, -0.28898001f, 0.27299529f, 0.07188544f, 0.19640929f, 0.18318990f, 0.03589181f, 
    -0.21527931f, -0.58571017f, 0.06635239f, -0.02105994f, 0.07795776f, 0.14542907f, 0.03855162f, -1.62790215f, 
    0.09385109f, -0.91957295f, 0.15221095f, -0.45388004f, -0.48729533f, -0.51699847f, 0.29955387f, -0.29113963f, 
    0.20117030f, 0.05670870f, -0.19360358f, 0.30537859f, 0.12112100f, 0.29353797f, -0.06068437f, -0.68151665f, 
    -0.29060057f, 0.15311530f, -0.36895350f, -0.05942799f, -0.17953692f, 0.16529231f, -0.88394964f, -0.17313975f, 
    0.05513265f, 0.00630540f, 0.24396887f, 0.04515442f, -0.08228444f, 0.23798287f, 0.38816157f, 0.24912651f, 
    -0.10480668f, -0.14802009f, -0.13883448f, -0.25460517f, -0.03681761f, 0.01530981f, -0.08695485f, 0.00080649f, 
    0.61464649f, -0.72589123f, -0.02816757f, -0.18761946f, 0.42121020f, -0.32242730f, 0.24094954f, -0.51084971f, 
    0.15005082f, 0.38442472f, -0.14810210f, 0.46000573f, 0.06034863f, -0.50641704f, -0.05565592f, -0.25759178f, 
    0.08354770f, -0.50482064f, 0.01664723f, 0.13475056f, -0.10151625f, -0.64419085f, -0.37983951f, 0.13712965f, 
    -0.06251816f, -0.02109143f, 0.01584070f, -0.44305989f, 0.27820531f, -1.20836020f, -0.56726402f, -0.79146427f, 
    -0.11533891f, 0.13490485f, 0.03384379f, -0.01895440f, 0.00659034f, 0.09560454f, -0.57568538f, 0.53041112f, 
    -0.06233108f, 0.14453407f, -0.15727033f, -0.04458372f, -0.04603270f, 0.19967069f, 0.24696840f, -0.41689107f, 
    0.33627406f, 0.04782612f, 0.13589926f, 0.25714466f, -0.14678314f, 0.06224103f, 0.00617330f, -0.04992638f, 
    -0.36148220f, 0.15670653f, -0.10325412f, -0.45010716f, 0.00019913f, -0.00688837f, 0.35182747f, -0.41665354f, 
    -0.19550000f, -0.10351360f, -0.24228406f, 0.20355421f, 0.12424447f, -0.66921133f, -0.43225136f, 0.40040693f, 
    -0.03666911f, -0.36244923f, 0.26617622f, -0.12526360f, 0.07871699f, -0.48071647f, -0.06703018f, -0.31581479f, 
    0.00527440f, -0.12106054f, -0.16460586f, 0.11085810f, 0.03579466f, 0.09033878f, -0.18562075f, 0.61357927f, 
    -0.08159477f, 0.12529761f, 0.21423596f, 0.17064875f, -0.52513158f, -0.95622814f, 0.04975809f, 0.13175847f, 
    0.15475571f, 0.02832349f, -0.67779297f, 0.32712591f, 0.28579855f, -0.14012603f, -0.44724777f, -0.09691129f, 
    -0.05909283f, 0.11120155f, -0.44613722f, 0.27572283f, -0.23846342f, -0.04200106f, -0.16216445f, -0.67970037f, 
    0.06290954f, 0.03567097f, -0.40561414f, -0.00116729f, 0.10068732f, -0.41959691f, 0.06377811f, -0.73381197f, 
    0.21812183f, 0.25191346f, -0.19832028f, -0.30888212f, -0.25727889f, 0.37455156f, -0.08325302f, -0.25899199f, 
    0.39325541f, -0.42973346f, 0.03456089f, -0.17784095f, -0.52814656f, -0.05900798f, -0.26023310f, 0.20325133f, 
    0.09024747f, 0.44754532f, -0.14425604f, 0.13027337f, 0.33235228f, -0.38425532f, 0.11856189f, 0.05333148f, 
    -0.32996514f, 0.27750880f, -0.05591672f, -0.30523440f, 0.23958734f, -0.28242284f, 0.06982300f, 0.08513884f, 
    -0.07496633f, 0.01506990f, 0.43913141f, 0.24311873f, 0.23186481f, -0.43581966f, 0.00413910f, -0.00490865f, 
    0.01512219f, -0.02277403f, -0.09472466f, 0.75736213f, 0.04629708f, -0.50464666f, -0.60561138f, 0.08547834f, 
    0.20249426f, -0.18590498f, 0.19678091f, -0.03576774f, -0.08219144f, -0.20132117f, 0.09473271f, 0.07154906f, 
    -0.49358550f, -0.09153395f, 0.11799309f, 0.24004029f, 0.00522430f, -0.05958372f, -0.44031367f, -0.06631749f, 
    0.28887591f, -0.74981016f, 0.02184121f, -0.47987425f, -0.00255273f, -0.03226285f, 0.19280651f, -1.21039271f, 
    0.36235467f, 0.02189008f, -0.44200662f, 0.20611076f, -0.18508102f, -0.43565872f, -1.09365988f, 0.18395071f, 
    -0.05879111f, -0.05426533f, -0.44965476f, 0.00764181f, 0.01553337f, -0.50561082f, -0.45034125f, -0.10226187f, 
    -0.47413194f, -0.24179828f, -0.17982309f, -0.53223020f, 0.25679821f, 0.10204800f, -0.52390504f, -0.14735332f, 
    0.19320884f, 0.04404778f, -0.18498853f, 0.19635305f, 0.24395093f, 0.12217172f, 0.25624031f, 0.05752937f, 
    0.09645031f, -0.08779018f, -0.05088539f, -0.08202969f, 0.13872857f, -0.35821688f, -0.36674228f, 0.10872619f, 
    -0.60729438f, -0.24265610f, 0.20594206f, 0.36556381f, -0.34382617f, 0.30037099f, 0.17783368f, 0.21391247f, 
    -0.02414812f, -0.21298379f, -0.26455089f, -0.01264843f, 0.00144599f, -0.25106382f, 0.35862359f, -0.21646622f, 
    -0.31065857f, -0.03050508f, 0.06451075f, 0.17580181f, 0.69702893f, 0.40135497f, -0.03304948f, -0.12827489f, 
    -0.53305793f, 0.01621055f, 0.06407171f, 0.26424176f, 0.29925686f, -0.06171052f, -0.73282188f, 0.14664133f, 
    0.15381329f, 0.52684575f, -0.21841639f, 0.33265603f, -0.10463367f, -0.07918967f, -0.23591165f, 0.06942420f, 
    0.19124642f, 0.01680671f, 0.04080211f, -0.12801817f, -0.06939677f, -0.02128842f, 0.39259857f, 0.14805430f, 
    0.03867797f, -0.06861992f, -0.54394364f, -0.30986053f, 0.19752398f, -0.19802262f, 0.36961123f, 0.04819090f, 
    -0.08538000f, 0.03990817f, -0.05658656f, -1.40765643f, -0.00220131f, 0.06319895f, -0.05978379f, 0.10829861f, 
    0.09968124f, -0.09245139f, 0.06446580f, 0.06655496f, 0.20718613f, 0.05886181f, 0.00783660f, 0.22727601f, 
    -0.03006292f, -0.08392776f, -0.52190197f, -0.45257244f, 0.07581785f, 0.12018367f, 0.28287441f, -0.10516474f, 
    -0.13960819f, -0.37873751f, 0.10828751f, -0.09305234f, 0.17457265f, -0.03168449f, 0.01274638f, 0.32218930f, 
    -0.45339584f, -0.05635500f, 0.31837642f, -0.31138593f, -0.00767303f, 0.00384404f, -0.11320080f, 0.01837329f, 
    0.03200562f, -0.02031223f, 0.08258805f, 0.26898286f, 0.07600004f, -0.42885613f, 0.05000524f, 0.11433030f, 
    0.24550062f, 0.08882645f, 0.06609888f, 0.19475392f, -0.93527257f, -0.09619899f, -0.00950971f, 0.64127046f, 
    -0.83213431f, 0.33392209f, -0.29818204f, 0.21528280f, -0.04160172f, -0.35057053f, -0.44967204f, 0.11738884f, 
    -0.07967205f, -0.03793976f, 0.19305351f, -0.50078911f, -0.41255078f, 0.20528790f, 0.05318690f, 0.32639220f, 
    0.28245154f, -0.00960631f, -0.09042094f, 0.11534239f, 0.22636491f, 0.06977460f, -0.07107098f, 0.09424514f, 
    0.05483578f, -0.20594487f, -0.00649096f, 0.05218679f, -0.04130448f, -0.07007974f, -0.34697735f, 0.08845811f, 
    0.13217303f, -0.28715512f, 0.32774878f, 0.33588460f, 0.49129254f, -0.41451454f, 0.05424159f, 0.08326682f, 
    -0.11173286f, 0.20163633f, 0.01765278f, -0.32728639f, -0.01101475f, 0.28963384f, -0.10037570f, 0.04705547f, 
    -0.10787131f, 0.11473927f, -0.14506543f, -0.04834380f, -0.79547006f, -0.32874370f, 0.02991985f, 0.18343382f, 
    -0.26663634f, 0.49670523f, 0.07236845f, 0.18067037f, 0.22116385f, 0.11687326f, -0.42244774f, -0.66103756f, 
    0.00893257f, -0.03364177f, 0.10330897f, 0.28788117f, -0.09885502f, 0.10864506f, -0.27068213f, 0.13318454f, 
    -0.00973382f, -0.00211169f, -0.05596633f, 0.22343026f, -0.03522580f, -0.07608758f, 0.06890041f, -0.65177441f, 
    0.07439809f, -0.01287132f, -0.21854851f, -0.04024343f, 0.02069818f, 0.00932759f, -0.17566948f, 0.29942954f, 
    -1.25459850f, -0.12362648f, -0.18974154f, 0.29174721f, -0.13962844f, -1.15543664f, -0.14283210f, 0.01169605f, 
    0.12877451f, -0.42128563f, -0.24394792f, 0.05670318f, -0.28193018f, 0.06332485f, -0.46579239f, 0.00368249f, 
    0.15684326f, 0.02936527f, 0.31261936f, -0.19273719f, -0.26654577f, -0.06626610f, 0.00745100f, -0.35332599f, 
    0.01859717f, -0.11116055f, -0.26592660f, -0.48885071f, 0.08769707f, 0.49854913f, -0.07597212f, 0.16092697f, 
    -0.13971324f, 0.45736867f, -0.11673580f, 0.18429196f, -0.21052419f, -0.71336639f, -0.15532498f, -0.71316081f, 
    -0.00827406f, 0.09769023f, 0.11135058f, 0.08236992f, -0.11427711f, 0.26597431f, -0.49968657f, 0.18171129f, 
    -0.37516874f, 0.01407734f, 0.12405099f, -0.28592521f, -0.00105954f, -0.36078212f, 0.11108799f, -0.25353447f, 
    0.26103485f, -0.21159099f, -0.05433496f, -0.84106582f, 0.24510843f, -0.52257222f, 0.01939938f, -0.02027445f, 
    -0.01608295f, -0.10060489f, -0.09386155f, -0.01848534f, -0.08064164f, -0.43518096f, -0.42862239f, -0.42415026f, 
    0.22854897f, 0.25868827f, 0.13140449f, -0.40859905f, -0.66381061f, -0.47780219f, 0.00435306f, 0.16192681f, 
    0.10246325f, 0.40351075f, 0.05681478f, 0.32353109f, 0.20884569f, -0.21509786f, -0.70738894f, -0.01809144f, 
    0.04450661f, 0.27014753f, 0.16747315f, -0.19591966f, 0.10625400f, 0.13354273f, 0.20767669f, -0.01428402f, 
    0.29655442f, -0.05434563f, -0.00127253f, 0.11222589f, 0.20311509f, -0.05347024f, 0.09047532f, -0.25235733f, 
    0.07403502f, -0.06749525f, -0.06480367f, 0.03314331f, 0.18829978f, 0.31101957f, 0.26707047f, 0.21959911f, 
    0.02459336f, -1.00616086f, -0.03117995f, -0.24877338f, 0.04490813f, 0.08122087f, -0.63675463f, -0.52183783f, 
    0.10843260f, -0.02652135f, 0.08216169f, -0.02382009f, 0.03220541f, -0.38932595f, -0.82626927f, 0.22162069f, 
    -0.23776595f, 0.09725644f, -0.27599216f, 0.06689797f, 0.03375142f, -0.58006519f, 0.12676230f, 0.01354200f, 
    0.08761382f, -0.18811575f, 0.22540766f, 0.11711448f, -0.63510358f, -0.03910287f, -0.42150557f, -0.36942634f, 
    0.46566376f, 0.03910325f, -0.45833734f, -0.09275118f, 0.05487411f, 0.24373797f, 0.12049475f, -0.63744140f, 
    0.03359094f, -0.16675754f, -0.18316819f, 0.29472393f, -0.06670234f, 0.28826776f, -0.03435355f, -0.15066493f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.00787991f, -0.12060623f, -0.03854061f, -0.20189284f, 0.15974011f, 0.19726947f, -0.09566297f, -0.49971205f, 
    -0.16715342f, -0.09046233f, 0.38734099f, -0.18343315f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
