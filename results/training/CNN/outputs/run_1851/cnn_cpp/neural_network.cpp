#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.18177122f, 0.55098289f, 0.04104849f, 0.36481789f, 0.47216940f, 0.33731592f, -0.12870607f, -0.32606760f, 
    0.22762875f, 1.01907670f, 0.58427143f, -0.28927964f, -0.61705923f, -0.09971371f, -0.20414531f, -0.00851493f, 
    0.24341145f, 0.09485672f, -0.70658708f, -0.42627600f, -0.32855174f, 0.28160709f, -0.06090904f, 0.65999705f, 
    0.14936739f, -0.13393502f, 0.02684439f, -0.28621837f, -0.22275658f, 0.23503660f, -0.44022453f, -0.68747252f, 
    -0.64813149f, 0.34311751f, 0.07028575f, 0.07847382f, 0.67408466f, -0.11868037f, 0.91777700f, -0.12496419f, 
    -0.00066361f, 0.67174083f, 0.30299312f, 0.09322214f, -0.23239461f, -0.13882078f, 0.10333259f, -0.36767644f, 
    -0.36013210f, -0.16783637f, 0.00521222f, 0.02794608f, 0.39080217f, 0.75339633f, -0.14004938f, -0.41717121f, 
    -0.48890412f, 0.25213742f, 0.58959532f, -0.30677614f, -0.12310028f, -0.38309908f, -0.27253789f, -0.58322161f, 
    -0.26206318f, -0.07575857f, 0.66458410f, -0.33374053f, -0.69117969f, -0.09326900f, -0.17916591f, -0.07755253f, 
    0.61476743f, -0.43075418f, 0.65892166f, -0.53354514f, 0.15356326f, 0.39396998f, 0.06229733f, 0.43133682f, 
    -0.05253884f, 0.38268903f, -0.17276090f, 0.05849513f, 0.39464578f, 0.88752615f, -0.76302564f, -0.01309963f, 
    0.11204275f, 0.13282989f, -0.19275314f, 0.16066028f, -0.02816963f, 0.57580703f, 0.21830636f, -0.02313962f, 
    0.61476767f, -0.20533328f, 0.32113004f, -0.29033551f, 0.21989128f, 0.52676982f, 0.46615708f, 0.16947743f, 
    -0.08201158f, 0.11894032f, -0.45330662f, -0.56238526f, 0.69496644f, -0.24229275f, -0.42174852f, -0.10551397f, 
    0.03052327f, -0.67644471f, -0.47504449f, -0.26763788f, -0.19948089f, 0.13663079f, 0.15931070f, 0.57585448f, 
    -0.26229098f, 0.35303849f, -0.43112063f, 0.54014999f, 0.17496206f, 0.47805917f, -0.04807187f, 0.07693256f, 
    -0.07178856f, -0.41413289f, -0.51983929f, -0.24282341f, -0.28017065f, 0.88206249f, -0.50732243f, 0.00433419f, 
    -0.11147527f, 0.01707176f, 0.95116818f, -1.01821566f, 0.14900844f, -0.27581710f, 0.03595500f, -0.15851267f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.16471830f, 0.19318534f, -0.25053158f, 0.03104558f, -0.26054770f, 0.43253574f, -0.02200951f, -0.35543141f, 
    0.26099819f, -0.27435455f, 0.41031948f, 0.30003542f, -0.17635542f, -0.20298713f, 0.25163543f, 0.16197757f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.00997724f, 0.09976091f, 0.42787951f, 0.01338524f, 0.01006457f, 0.04883570f, 0.00221798f, -0.14617591f, 
    0.02826658f, -0.26992452f, -0.53712142f, -0.59216088f, 0.06239019f, 0.07925936f, 0.13949782f, -0.01257219f, 
    0.01696625f, 0.10684378f, 0.20572551f, 0.20647708f, 0.08207551f, -0.05683662f, -0.17775080f, 0.04318395f, 
    0.03629221f, -0.23174858f, 0.12334123f, 0.08531966f, 0.26175258f, 0.20920150f, -0.05858178f, 0.03208037f, 
    -0.11839236f, 0.06716381f, -0.00764886f, 0.07877486f, -0.49920267f, -0.10255382f, -0.24283230f, 0.09250040f, 
    0.09995598f, -0.03714592f, 0.12136754f, -0.00512425f, 0.05510879f, 0.13402317f, 0.20766416f, 0.06469391f, 
    0.08705480f, 0.02946038f, 0.05109324f, 0.19127297f, 0.01078417f, 0.07798413f, -0.00241259f, -0.07594080f, 
    -0.05584969f, -0.05972977f, -0.16234459f, 0.06107175f, 0.01747888f, -0.07472361f, -0.07480334f, 0.09206647f, 
    -0.04162954f, -0.02753814f, -0.08553829f, -0.04379264f, -0.17552570f, -0.02637601f, 0.01648910f, -0.17296202f, 
    -0.14846367f, -0.03574875f, -0.22506748f, -0.08585822f, 0.04116390f, -0.00844421f, 0.02738856f, 0.03042145f, 
    0.01192480f, 0.05359854f, 0.40831706f, -0.49948192f, -0.21732937f, -0.17973532f, -0.23755643f, 0.01899249f, 
    0.18498302f, 0.22000122f, -0.05583461f, -0.14708914f, 0.12337189f, 0.16241193f, -0.02641424f, -0.25088742f, 
    -0.00478989f, -0.01213401f, 0.18241161f, -0.58002436f, -0.24383633f, 0.24243437f, 0.13362096f, 0.02563509f, 
    -0.02734312f, 0.09070078f, -0.13806202f, 0.02165460f, 0.12603197f, 0.43309993f, -0.07033207f, 0.14131503f, 
    0.07213400f, -0.05897922f, -0.03322507f, -0.10369607f, 0.04958038f, 0.30652821f, 0.09906428f, -0.20663786f, 
    -0.07879341f, 0.11977774f, -0.16762958f, -0.02686561f, 0.01017805f, -0.05311251f, 0.11436553f, 0.30483538f, 
    0.17397231f, 0.00505719f, 0.16152830f, 0.14272667f, -0.06232614f, 0.18991475f, -0.22990823f, -0.24511476f, 
    0.03529976f, 0.33559752f, 0.10069976f, -0.02228474f, -0.17669719f, 0.20938352f, -0.05028982f, -0.08684931f, 
    0.00834132f, 0.32471091f, 0.12916493f, -0.03000060f, -0.29210651f, 0.13496546f, -0.01843722f, -0.03693372f, 
    0.08551669f, 0.40042982f, 0.01975521f, -0.25266886f, 0.02493447f, 0.21914013f, 0.04930148f, -0.02390550f, 
    0.04002741f, -0.11258836f, 0.42431006f, 0.15688044f, 0.22566572f, -0.21704602f, -0.16123189f, -0.42900279f, 
    -0.12826307f, -0.08935360f, 0.03400051f, 0.05981357f, 0.38442373f, -0.04344847f, -0.12456551f, -0.20070770f, 
    -0.17754577f, -0.06289358f, 0.05339505f, 0.04445109f, 0.08257693f, -0.35452569f, 0.12078878f, -0.18384627f, 
    -0.09167168f, -0.04763382f, 0.17148373f, 0.02715803f, -0.12543760f, 0.07872853f, 0.23205192f, -0.10628618f, 
    0.06969023f, 0.11441827f, -0.01378362f, 0.09247376f, 0.02881845f, -0.31173545f, -0.02047800f, -0.31952319f, 
    -0.23005089f, 0.12083565f, 0.01275453f, 0.08454169f, 0.03214452f, 0.03494038f, 0.37211204f, -0.33778971f, 
    -0.30076963f, 0.14620717f, -0.33287990f, 0.16492006f, -0.24809000f, 0.12871005f, 0.09013195f, 0.36128369f, 
    -0.00953859f, -0.19038928f, 0.04073924f, 0.02604026f, -0.02923523f, 0.18559420f, -0.14989628f, -0.06131176f, 
    -0.07808065f, -0.05690562f, 0.04013086f, 0.28257531f, 0.11491759f, -0.16817226f, -0.18383968f, 0.06198215f, 
    0.02975655f, -0.02788154f, 0.13252750f, -0.00127993f, 0.20445444f, 0.07583194f, -0.09765490f, 0.07625756f, 
    -0.09167580f, -0.07836898f, -0.04605086f, 0.05005213f, 0.03461977f, 0.16174313f, -0.00892500f, 0.22224806f, 
    -0.13125350f, 0.02559053f, 0.15422066f, 0.17425212f, 0.10537435f, -0.41067216f, 0.19650361f, 0.05453175f, 
    -0.05062176f, 0.05077556f, 0.12486554f, -0.03488163f, 0.03993464f, -0.07255951f, -0.16341576f, 0.03290429f, 
    0.10046143f, 0.18242945f, 0.13647979f, 0.02318492f, -0.20849828f, -0.16142963f, -0.39881465f, -0.08635385f, 
    0.08311470f, 0.06796329f, -0.03476837f, 0.01148519f, -0.01416765f, -0.05566185f, -0.04231124f, 0.00150081f, 
    -0.13955161f, 0.50813168f, -0.08166851f, -0.13616496f, 0.06283094f, 0.12350065f, 0.04061678f, -0.04238345f, 
    0.02958953f, 0.18557699f, 0.22521269f, -0.23259677f, -0.21034825f, -0.12446743f, 0.00081648f, 0.02698990f, 
    -0.21214475f, -0.08024531f, -0.01464271f, 0.04181008f, 0.08066273f, 0.02603676f, 0.10786939f, 0.03572547f, 
    0.05159241f, 0.18690147f, 0.70197690f, -0.25359547f, -0.87009633f, -0.09026368f, 0.12381875f, -0.31576371f, 
    -0.04145503f, 0.10919380f, -0.33287695f, -0.28780457f, 0.08332998f, 0.07336053f, -0.02388518f, -0.12640129f, 
    0.09867648f, -0.01821393f, 0.06576185f, 0.25368729f, 0.16416672f, -0.10951348f, 0.06830664f, -0.16851871f, 
    -0.19969986f, 0.19648124f, -0.08703839f, -0.02445578f, 0.00096824f, 0.07600481f, -0.40007639f, -0.15692317f, 
    0.08422402f, -0.00402192f, 0.21721742f, 0.04022060f, -0.02140680f, 0.09691161f, 0.03258190f, -0.35572073f, 
    -0.43769586f, 0.05422117f, -0.05289814f, -0.00253343f, -0.04746598f, -0.05646393f, -0.15655842f, -0.18848260f, 
    -0.44253194f, 0.31527442f, 0.05976746f, 0.24499673f, -0.04549176f, 0.05254785f, -0.16921143f, -0.13558075f, 
    0.25484234f, 0.05921814f, 0.19227830f, 0.08034055f, -0.00652146f, 0.04929558f, -0.00199693f, 0.04760098f, 
    0.00250993f, 0.09668840f, 0.10671836f, 0.22741938f, -0.00993258f, -0.03317257f, -0.11076844f, 0.23361595f, 
    -0.03251019f, 0.07084096f, 0.11677644f, 0.09854242f, -0.00220890f, -0.26615217f, 0.06347509f, 0.05348926f, 
    0.27391765f, -0.00729763f, -0.10544641f, 0.15313579f, -0.06389891f, 0.12363522f, -0.08817802f, 0.03505946f, 
    0.06154137f, -0.13323589f, -0.04373087f, 0.23408292f, -0.29317093f, -0.34825015f, 0.19864434f, -0.06859638f, 
    -0.22968289f, 0.38730481f, -0.00304938f, -0.21415201f, 0.04891698f, -0.02537175f, 0.18580900f, 0.44274560f, 
    0.19651292f, 0.01359626f, 0.10245987f, 0.01328305f, -0.04415883f, 0.17162484f, 0.09015653f, -0.12634841f, 
    -0.30871451f, 0.10389286f, -0.07894762f, -0.05065742f, -0.00423488f, 0.03852946f, -0.04979760f, -0.08233637f, 
    -0.45452788f, 0.48387393f, -0.14571556f, 0.18110947f, -0.03124794f, 0.05902317f, 0.08666904f, 0.12680462f, 
    -0.44498217f, -0.06644834f, -0.27834311f, 0.09571519f, -0.01767789f, 0.21667610f, -0.04633420f, 0.09763930f, 
    0.10163943f, -0.09655558f, 0.42283630f, 0.06677524f, 0.00150414f, -0.02224442f, -0.22980545f, -0.01868086f, 
    -0.01657535f, 0.01190480f, -0.04724644f, -0.42641318f, 0.12793751f, 0.03577910f, 0.13739140f, 0.12212118f, 
    0.03077747f, 0.00315416f, -0.01392888f, -0.03320123f, 0.03052712f, -0.03616121f, 0.20376492f, 0.23361921f, 
    -0.11058401f, -0.13730811f, 0.08712538f, 0.02524702f, 0.52894437f, 0.18269828f, -0.12091718f, -0.04197748f, 
    0.35406303f, -0.16190666f, 0.09743934f, -0.06013408f, 0.01356159f, -0.14359735f, -0.01203438f, 0.00871321f, 
    0.05604779f, 0.05470989f, -0.08190259f, -0.17519926f, -0.19101663f, -0.44066945f, -0.10448941f, -0.18820372f, 
    0.02329153f, -0.08815076f, -0.02014769f, 0.00071550f, 0.01444731f, 0.11764114f, 0.27057952f, 0.27422905f, 
    -0.22634335f, -0.11832514f, 0.04137963f, -0.16962352f, 0.21156235f, 0.05772222f, 0.10834223f, 0.00197317f, 
    0.08337649f, 0.14378184f, -0.14227073f, 0.04649265f, -0.02315272f, -0.04181371f, 0.00925890f, -0.11239371f, 
    -0.03611562f, 0.00779545f, -0.27492797f, 0.00647335f, 0.02037907f, 0.13809507f, 0.29884624f, 0.07635876f, 
    -0.06435713f, -0.03577222f, -0.14935383f, 0.00558240f, -0.07861537f, 0.20568864f, -0.07637409f, -0.01571339f, 
    -0.03313805f, 0.04427754f, -0.33106640f, 0.01893186f, -0.13429584f, -0.03625154f, -0.11266667f, 0.03509118f, 
    -0.01926299f, 0.22252555f, -0.09871215f, -0.03501454f, 0.02181681f, 0.31388846f, 0.29593349f, 0.14570194f, 
    0.18760145f, 0.02652614f, 0.01212880f, -0.05368930f, -0.00553630f, 0.25021413f, 0.01591120f, -0.09059791f, 
    -0.04369729f, -0.00911743f, 0.18934271f, -0.09086136f, -0.18639396f, -0.20901218f, 0.09787706f, 0.15173939f, 
    0.00985148f, 0.10021333f, 0.12227424f, 0.08849801f, 0.11651820f, -0.14943424f, -0.01234861f, 0.15928894f, 
    0.02451785f, -0.02489915f, -0.10094504f, 0.08073705f, 0.03611765f, 0.16999111f, 0.13089634f, -0.23349437f, 
    -0.14377202f, -0.26576388f, -0.16141951f, 0.11126556f, 0.16525859f, 0.06911252f, -0.05123116f, 0.25419524f, 
    0.01670875f, -0.00277079f, 0.25701201f, 0.24176607f, -0.16565137f, -0.04696399f, -0.06444113f, 0.08210840f, 
    -0.06680644f, -0.21632321f, -0.16490072f, -0.25506544f, 0.11480255f, 0.18677524f, 0.01264073f, 0.00685809f, 
    -0.22517554f, 0.15225692f, -0.13079143f, 0.17858647f, -0.11293258f, 0.14311396f, 0.24097219f, 0.25076056f, 
    0.10753429f, 0.07727093f, 0.02783809f, -0.40762526f, 0.13444498f, 0.01586631f, -0.01460569f, 0.00415732f, 
    0.05109169f, -0.08613879f, -0.02902889f, 0.12800369f, 0.03300394f, -0.05661736f, 0.16631059f, 0.05527134f, 
    0.06621560f, 0.08086329f, -0.01519769f, 0.22860822f, 0.05409864f, -0.30949280f, -0.15340011f, 0.03574154f, 
    0.00557272f, -0.03928931f, -0.05016566f, -0.19768611f, 0.02477806f, 0.05130753f, 0.21896410f, -0.25630507f, 
    0.21577834f, 0.05541557f, 0.35204384f, -0.25642371f, 0.02638140f, 0.00448393f, 0.07494881f, 0.23839349f, 
    -0.13489348f, 0.06588472f, -0.29025981f, 0.04926858f, -0.23802875f, 0.12981492f, 0.04120193f, 0.06784285f, 
    0.07402676f, 0.21760035f, 0.09842543f, 0.20037784f, 0.17391869f, -0.07781748f, -0.22010097f, -0.03032416f, 
    -0.20080769f, 0.11680117f, 0.06691269f, 0.06726097f, 0.15222675f, 0.11990897f, 0.19506979f, 0.00588670f, 
    0.06657755f, 0.03977142f, 0.00969864f, -0.00059437f, 0.09887343f, 0.00526158f, 0.07468322f, 0.09152590f, 
    0.21308558f, 0.28004685f, 0.12831122f, 0.23333223f, -0.16913858f, 0.10404603f, 0.33176970f, -0.11566716f, 
    0.07094486f, -0.10420211f, 0.11083604f, 0.08949614f, 0.23535845f, -0.10778759f, 0.04900888f, 0.05605697f, 
    -0.05093620f, -0.09908174f, 0.12278263f, 0.08073575f, -0.08911908f, 0.08447618f, 0.28412551f, 0.32247388f, 
    0.24075842f, -0.16709101f, 0.02740436f, 0.04894194f, 0.06161982f, -0.15380706f, 0.10184593f, 0.08744582f, 
    0.07760732f, 0.15071131f, 0.13842979f, 0.00749674f, 0.11055594f, 0.18649605f, 0.08231897f, 0.28151023f, 
    -0.23304181f, -0.07972232f, -0.36007765f, 0.11494397f, -0.26539207f, -0.22116040f, 0.04288498f, -0.21678081f, 
    -0.02616675f, -0.25927565f, -0.30156142f, 0.07838069f, 0.07189787f, -0.05044078f, 0.10514736f, -0.10678460f, 
    -0.14315082f, 0.28911528f, -0.16954902f, -0.17237931f, -0.39173219f, -0.06537314f, -0.33070472f, -0.21452956f, 
    0.28740028f, 0.09498928f, -0.14413457f, -0.21383172f, -0.02357376f, 0.03827563f, 0.03167591f, 0.01329821f, 
    0.20013359f, -0.06884897f, 0.02144893f, -0.10743719f, -0.52426195f, -0.17227803f, -0.05517335f, -0.10165365f, 
    -0.14336358f, -0.02133833f, -0.14944980f, 0.11042611f, -0.06436554f, 0.09687880f, -0.04928404f, 0.35854718f, 
    -0.03197567f, 0.18684353f, 0.04689639f, 0.10272001f, -0.34520781f, 0.13461965f, 0.08641051f, 0.29707238f, 
    0.05869291f, 0.05992213f, 0.03329131f, -0.13945429f, 0.06792480f, -0.23229434f, -0.05475176f, -0.07705339f, 
    0.35791636f, 0.12692870f, -0.04915360f, 0.15762432f, 0.07030635f, 0.07908665f, 0.01402170f, -0.14006238f, 
    0.15355480f, 0.05186069f, -0.03754104f, -0.00001355f, 0.12476635f, -0.14571951f, 0.14272769f, 0.11170084f, 
    0.12125340f, -0.31192729f, -0.02303129f, -0.27473181f, -0.13560115f, -0.17554784f, 0.21117899f, 0.11687050f, 
    0.27567816f, -0.04086525f, -0.21130176f, -0.00920809f, -0.20202018f, -0.05665082f, 0.10286325f, 0.12669009f, 
    0.16827779f, 0.18665545f, 0.22375908f, -0.07060101f, 0.17888960f, -0.13693930f, 0.00304207f, -0.12713003f, 
    0.00519149f, 0.15108898f, -0.11406808f, -0.15002167f, -0.03543223f, -0.01297594f, 0.15309684f, 0.09889518f, 
    0.19102105f, -0.00208630f, 0.19639346f, -0.11792242f, -0.17274076f, 0.01337649f, -0.13898429f, 0.11403353f, 
    -0.14615947f, 0.11577156f, -0.20364609f, -0.42296600f, 0.13983005f, 0.08945237f, 0.07642556f, -0.22468245f, 
    0.07512091f, -0.04285477f, -0.01416133f, 0.05191343f, -0.00831292f, -0.00579135f, 0.16908425f, 0.20917124f, 
    0.14376406f, 0.34250173f, -0.03301688f, 0.16426344f, 0.02449953f, 0.09357963f, -0.00884222f, 0.17069662f, 
    0.00020638f, 0.01927664f, -0.07149152f, -0.05692238f, 0.00304930f, -0.11164714f, 0.05144689f, 0.05261115f, 
    -0.13497180f, 0.75194621f, 0.02656781f, -0.02110068f, 0.07079396f, -0.02102733f, -0.04325391f, 0.00270653f, 
    0.30001262f, -0.10551441f, -0.60340017f, -0.11095399f, -0.07037012f, 0.03997774f, -0.17010251f, 0.19193114f, 
    -0.24733372f, -0.00224994f, -0.03518203f, -0.21752732f, 0.23845659f, -0.10015394f, -0.12718967f, 0.10321645f, 
    -0.07632076f, 0.07645887f, 0.06219299f, -0.16782402f, 0.38806218f, 0.37765321f, 0.13218422f, -0.28670788f, 
    0.05639843f, 0.14860953f, -0.11336878f, -0.08603054f, 0.00751750f, -0.09541063f, -0.13240604f, 0.03365184f, 
    0.07406345f, 0.16106048f, 0.10599557f, 0.14673828f, -0.05978340f, 0.01148173f, -0.20864981f, 0.01542443f, 
    -0.18812734f, 0.00627743f, 0.28027135f, -0.08861212f, -0.20414521f, -0.09274679f, 0.12189554f, 0.05348051f, 
    0.08303967f, 0.05590587f, -0.06918535f, 0.05602937f, 0.05259601f, 0.10303567f, 0.15097940f, -0.09401941f, 
    0.57341599f, 0.14495622f, 0.03624040f, -0.11935280f, 0.03177027f, 0.09320623f, -0.00157325f, 0.16290903f, 
    0.13132291f, -0.48949760f, -0.42895889f, -0.08716226f, -0.25542447f, 0.05586351f, 0.11775816f, 0.09162406f, 
    0.05534657f, 0.02089204f, -0.00821693f, -0.12725221f, 0.26842546f, 0.01743843f, 0.07035638f, 0.15679848f, 
    0.20183288f, 0.00897492f, 0.15053044f, -0.18276715f, -0.00975740f, 0.00715147f, 0.14249389f, -0.02864696f, 
    -0.12995364f, -0.04975450f, 0.01213613f, 0.29243240f, -0.03036788f, -0.01288866f, -0.30960140f, -0.02955793f, 
    0.13085650f, 0.21011287f, -0.00263139f, 0.00230276f, -0.17561813f, 0.16216658f, -0.21964914f, -0.10044903f, 
    0.06386232f, 0.07051913f, -0.20056950f, -0.09559178f, 0.03841443f, 0.04618054f, -0.05977065f, -0.18835346f, 
    -0.11615147f, 0.01946772f, -0.05670680f, -0.29560232f, 0.00683091f, -0.11714431f, 0.21447653f, -0.33599597f, 
    -0.21974725f, 0.10146475f, 0.04987939f, 0.20411789f, -0.03585897f, 0.04006204f, -0.07941929f, -0.14634322f, 
    -0.20850548f, -0.02190666f, -0.03978832f, 0.03888278f, -0.27600440f, -0.36751398f, 0.05067335f, 0.22032288f, 
    0.16318704f, -0.16650152f, -0.47585228f, -0.55855721f, -0.10551552f, -0.22892289f, -0.20579475f, 0.03629003f, 
    0.08428221f, 0.12868997f, 0.13769564f, -0.12146155f, 0.10344600f, -0.19434911f, 0.11674817f, 0.31524792f, 
    -0.03164672f, -0.00428242f, -0.02042747f, 0.09992640f, 0.32671067f, 0.31241500f, -0.29914340f, -0.05750696f, 
    -0.18985316f, 0.02802431f, 0.03899677f, 0.00730429f, 0.21347833f, -0.73329860f, -0.71396613f, 0.21845154f, 
    0.23667073f, -0.25386783f, -0.16027920f, -0.06199894f, -0.05644580f, -0.01598507f, 0.23720644f, -0.18706885f, 
    0.02213692f, 0.05827559f, 0.03884298f, 0.16185720f, -0.03432333f, 0.09801810f, 0.28411531f, -0.07839376f, 
    -0.00577925f, 0.08937224f, 0.04730953f, 0.25273457f, 0.17822957f, 0.07254476f, -0.03505392f, 0.57689768f, 
    0.45469382f, -0.11906847f, -0.16215359f, 0.04852635f, 0.12044076f, 0.14888228f, 0.08831941f, 0.24344315f, 
    -0.31370127f, -0.47096255f, 0.15548973f, -0.20254751f, 0.30982766f, -0.14210463f, 0.08356308f, -0.04624224f, 
    -0.04552049f, -0.38224635f, -0.49081692f, -0.23031628f, -0.00891224f, -0.25216085f, -0.04118105f, 0.00418429f, 
    -0.04282812f, 0.01454117f, -0.04977633f, 0.04962938f, -0.30467528f, 0.02397094f, 0.05125356f, 0.06295761f, 
    -0.12309826f, 0.17814814f, 0.02916595f, 0.03067694f, 0.07331681f, 0.11481246f, -0.00462124f, -0.15176030f, 
    -0.03062937f, -0.07647312f, -0.00942639f, -0.10909379f, 0.18711242f, -0.05718766f, -0.01868505f, 0.08038682f, 
    -0.07930639f, -0.03957842f, 0.08545645f, 0.11162370f, -0.07636741f, 0.12567881f, 0.11474463f, 0.23460306f, 
    -0.11433466f, -0.06042848f, -0.14881888f, 0.19309524f, -0.03657617f, 0.13792497f, -0.09976971f, 0.12536891f, 
    0.22837992f, -0.08326044f, -0.02665788f, -0.14649738f, -0.08185759f, -0.03211852f, 0.01504511f, -0.03425730f, 
    0.18250570f, 0.02650052f, -0.33650330f, -0.10410783f, 0.01294632f, 0.01073389f, 0.00277244f, 0.14665045f, 
    0.06173978f, -0.05344246f, 0.00113350f, -0.05474457f, -0.07508458f, 0.05546708f, 0.00376021f, 0.01118579f, 
    -0.03045635f, -0.03470075f, 0.00705652f, -0.03144541f, -0.01560678f, -0.01626662f, 0.06045145f, 0.00195485f, 
    -0.05712501f, -0.07152706f, 0.04476403f, 0.03434041f, 0.00006172f, 0.01227803f, 0.00560148f, 0.04926533f, 
    -0.02976185f, -0.01771506f, -0.03854892f, -0.08290225f, -0.04444829f, -0.05796795f, 0.02086595f, -0.05455840f, 
    -0.02667732f, 0.03928365f, -0.08003980f, 0.00258758f, -0.08464864f, -0.05435336f, -0.06425595f, -0.07781088f, 
    -0.03119502f, 0.06248753f, 0.01848905f, 0.00203904f, -0.02992393f, -0.04832981f, -0.02244501f, 0.06681506f, 
    0.00864733f, -0.00510321f, -0.00776094f, -0.00485632f, -0.06236277f, 0.05566668f, 0.06036266f, -0.08984318f, 
    0.01996993f, -0.01232838f, -0.05141846f, -0.03246019f, 0.03851031f, 0.04024468f, 0.01004295f, -0.07227343f, 
    -0.07026089f, 0.04878471f, -0.02356401f, -0.05455136f, 0.03350161f, -0.06352674f, -0.07633937f, -0.02514755f, 
    -0.03952882f, -0.08189280f, 0.02722486f, -0.09063274f, -0.02972129f, 0.06652534f, 0.03151833f, -0.02712758f, 
    -0.03828675f, -0.00496175f, -0.06520914f, -0.05862442f, 0.05947904f, -0.03899873f, -0.07616537f, -0.01335765f, 
    0.06447759f, -0.04147575f, -0.04996294f, 0.01295014f, 0.01466046f, 0.06288560f, -0.09160633f, -0.02373915f, 
    0.03611875f, 0.02319094f, -0.01595835f, 0.03639095f, -0.09129383f, -0.04061307f, -0.08854029f, 0.02482517f, 
    -0.06381269f, 0.02992569f, -0.04517602f, -0.07712650f, -0.08510139f, 0.00507949f, 0.03071156f, -0.01859183f, 
    0.06279288f, -0.05584208f, 0.03979888f, -0.01266694f, 0.03294728f, -0.05041320f, -0.02139764f, 0.02760970f, 
    -0.05125167f, 0.05688202f, 0.03472748f, -0.00855846f, 0.02196304f, -0.02409207f, -0.06243294f, 0.05877062f, 
    0.04537266f, -0.04749674f, -0.01670846f, -0.06089158f, -0.04833240f, 0.02869313f, -0.02421685f, -0.04549010f, 
    -0.04829701f, -0.03717998f, 0.04347651f, -0.06421349f, 0.04271229f, 0.06385651f, -0.00655510f, -0.02931264f, 
    0.03128569f, 0.17387252f, 0.10844951f, 0.01127472f, 0.02269682f, 0.14851831f, 0.02902926f, -0.12761304f, 
    -0.12950996f, -0.03231006f, 0.03456898f, 0.11057813f, 0.04495178f, -0.02382830f, -0.07774308f, 0.07896993f, 
    -0.04607600f, 0.05586094f, -0.19213124f, 0.11249505f, 0.25158161f, 0.14552709f, -0.30884007f, -0.05507962f, 
    0.12734243f, 0.14877936f, -0.02254160f, -0.01006407f, 0.13052936f, -0.05689098f, -0.02755672f, 0.00210673f, 
    0.15412928f, 0.05836352f, 0.10478123f, -0.03080887f, 0.03404450f, 0.20973426f, 0.45178780f, 0.05126074f, 
    -0.03143238f, 0.11941764f, -0.04188329f, -0.20851398f, -0.08677094f, 0.01116194f, -0.12830266f, -0.15980168f, 
    0.03933024f, 0.04487264f, -0.04621667f, 0.34683359f, 0.01541947f, 0.36126414f, 0.06536715f, -0.05182941f, 
    -0.12305491f, 0.01893931f, 0.06372093f, -0.05135961f, -0.02783902f, -0.52478027f, -0.41831666f, -0.01984594f, 
    0.26994255f, 0.02292332f, -0.08202815f, 0.02504158f, 0.15447871f, -0.03977069f, -0.14874355f, -0.01325284f, 
    0.18378212f, 0.26593667f, 0.39229059f, 0.05417809f, -0.00299189f, -0.02571330f, 0.02447842f, 0.02109274f, 
    0.10591993f, 0.17265324f, 0.04749506f, -0.08293522f, 0.02165305f, 0.00473963f, -0.19899765f, 0.05766022f, 
    0.16687216f, 0.16281620f, 0.05764188f, 0.12454320f, 0.11780931f, -0.10449321f, -0.05570773f, 0.11669205f, 
    -0.05827755f, 0.06746098f, -0.06896283f, -0.16024089f, -0.19057137f, 0.02816263f, 0.08846886f, -0.05112765f, 
    0.13301066f, -0.34024096f, -0.35879126f, -0.10453259f, 0.02508655f, -0.10329589f, -0.23861940f, 0.13951790f, 
    0.16095042f, -0.06414729f, 0.04837427f, 0.16831452f, 0.18181901f, 0.15114909f, -0.06292501f, 0.12078131f, 
    -0.05504199f, 0.05844640f, 0.02998458f, -0.03830467f, 0.13609244f, 0.14762069f, 0.00537020f, -0.13129337f, 
    -0.18305220f, 0.03861456f, 0.10238833f, 0.13100247f, 0.00971063f, -0.02149768f, 0.12332141f, -0.01097769f, 
    0.01017304f, -0.16655789f, -0.08452575f, -0.02434859f, 0.07364915f, 0.02266076f, -0.13075684f, -0.10586077f, 
    0.09412102f, -0.00313563f, -0.09485444f, 0.05092711f, -0.02994567f, 0.05214913f, -0.10373292f, 0.15782021f, 
    0.04870841f, -0.26762626f, 0.00453752f, -0.20038806f, 0.11040950f, -0.12893978f, 0.04035863f, -0.03127978f, 
    0.06927574f, -0.19738606f, 0.26712984f, -0.10378064f, 0.43443832f, -0.03859583f, 0.20273975f, 0.22005831f, 
    0.10751096f, 0.10171679f, 0.25059050f, 0.26303115f, 0.04598412f, 0.07383206f, -0.06009824f, -0.20325227f, 
    -0.15350275f, -0.11928245f, 0.12511362f, -0.08697530f, 0.12113811f, -0.49311522f, -0.17529176f, 0.05534442f, 
    -0.12469810f, -0.11748394f, -0.07547969f, 0.08930696f, 0.34184596f, 0.11413608f, 0.10818890f, -0.01903035f, 
    0.10796110f, 0.05131150f, 0.01529597f, -0.07012757f, -0.03936272f, -0.02294444f, 0.14522912f, -0.02812250f, 
    0.16038033f, 0.00505609f, -0.04114796f, 0.06940869f, -0.03684419f, -0.08924749f, 0.07832012f, 0.35494915f, 
    0.07151407f, -0.07409135f, 0.00101562f, -0.09091214f, -0.14912844f, -0.20458429f, -0.00819593f, 0.08785311f, 
    -0.01141359f, -0.19122274f, -0.17433257f, 0.23570850f, -0.24711570f, -0.11707813f, 0.01906271f, 0.07997717f, 
    0.20504309f, -0.18888006f, -0.42646936f, 0.02275114f, 0.14611135f, 0.03355609f, -0.25481862f, 0.17796774f, 
    -0.12456033f, 0.10228206f, -0.04766734f, -0.05275245f, -0.01329226f, -0.06140220f, 0.02595662f, 0.07995824f, 
    0.05578094f, 0.11683627f, 0.04529581f, 0.10132582f, 0.09408936f, 0.14170064f, 0.06857497f, 0.03966793f, 
    0.12340891f, 0.15074483f, -0.08317448f, 0.01826281f, -0.16168639f, -0.04900381f, 0.02418424f, -0.02281627f, 
    -0.09812687f, -0.08294926f, 0.01731928f, -0.03965489f, 0.00540937f, 0.21294430f, 0.19652568f, 0.10492787f, 
    0.05006953f, -0.04344021f, 0.01334335f, -0.10280327f, -0.22677355f, -0.08103600f, 0.06799203f, 0.10868705f, 
    0.15290834f, 0.07616269f, -0.17183909f, -0.00756314f, 0.02674013f, -0.10492241f, -0.02906748f, -0.13069566f, 
    0.10964479f, 0.01021484f, -0.16262779f, 0.04873626f, 0.04078005f, -0.04048235f, -0.07978705f, 0.11886865f, 
    -0.02158101f, -0.03205147f, 0.02577502f, -0.05497055f, -0.00182234f, 0.07755256f, -0.02360637f, -0.00832188f, 
    0.01654514f, 0.06403223f, -0.00926836f, 0.02649357f, -0.01128217f, -0.05797165f, -0.07301721f, -0.00035384f, 
    0.02948626f, 0.01849814f, 0.01994942f, 0.00431224f, 0.02643920f, -0.00543144f, -0.07204951f, -0.05481300f, 
    -0.01689773f, -0.03264002f, 0.02403361f, -0.03303193f, 0.02761248f, -0.04845053f, -0.01747432f, 0.02433792f, 
    -0.04900122f, -0.03430538f, -0.05251364f, -0.01368656f, -0.07609217f, -0.01223062f, 0.08175247f, 0.04373512f, 
    0.05720346f, 0.07366413f, 0.05221832f, 0.04351100f, 0.02162312f, 0.05069700f, 0.04462698f, -0.07154274f, 
    -0.00593566f, -0.04784976f, -0.02593101f, 0.06648988f, -0.05450852f, -0.06000674f, -0.04880515f, -0.05661849f, 
    -0.03666586f, -0.06376243f, -0.05010951f, -0.02027157f, -0.01744456f, 0.00524855f, 0.02156022f, 0.04117227f, 
    -0.03648536f, -0.06572489f, -0.06810742f, -0.08889234f, -0.03006131f, -0.04501509f, 0.08654159f, -0.06541515f, 
    0.06782042f, -0.03083172f, -0.03859648f, -0.05122181f, -0.04145986f, 0.02401904f, -0.08853803f, -0.07602988f, 
    0.03976570f, 0.04194144f, -0.02793330f, 0.01591630f, 0.02940266f, -0.08440677f, 0.05286853f, 0.03388255f, 
    -0.05796486f, -0.03718691f, -0.06597500f, -0.07660743f, -0.03445114f, -0.07548830f, -0.03961232f, 0.05435187f, 
    0.04104442f, -0.01988471f, 0.03466862f, -0.07477772f, -0.05225052f, -0.07967958f, -0.07597911f, -0.00338452f, 
    0.07614070f, -0.06796324f, -0.07061818f, -0.01319498f, -0.06553947f, -0.03226384f, 0.06915622f, 0.00614893f, 
    -0.02574627f, 0.01201417f, -0.06633515f, 0.05620507f, -0.02202740f, -0.07877073f, 0.01398157f, -0.06990861f, 
    0.06108721f, -0.06723655f, -0.04594161f, -0.01045715f, 0.06122024f, -0.02553567f, 0.04071799f, -0.07555696f, 
    0.06131378f, 0.02587926f, 0.03623719f, 0.06346304f, -0.04301062f, -0.06396099f, -0.07353158f, 0.04584795f, 
    0.01606052f, 0.03090634f, -0.03756157f, 0.05977490f, -0.03175818f, 0.06240221f, -0.00211701f, -0.07976141f, 
    -0.16854766f, 0.07234810f, -0.15923426f, 0.11231986f, 0.05354620f, -0.05260913f, -0.04180860f, -0.13480893f, 
    0.07288607f, 0.03540964f, -0.20651379f, 0.13383231f, 0.02974753f, -0.08928705f, -0.07639453f, -0.13546763f, 
    -0.05003963f, 0.09015430f, -0.50504822f, 0.27935824f, -0.39270023f, -0.18425758f, -0.16266865f, -0.24014784f, 
    0.05443380f, -0.01377632f, -0.00961802f, -0.16324636f, -0.08767536f, 0.25285652f, -0.15913314f, 0.02644578f, 
    -0.23664567f, 0.06391636f, 0.03208902f, 0.11154336f, 0.03357658f, 0.35330772f, 0.22233403f, -0.10914304f, 
    0.02107332f, 0.01723045f, 0.10011300f, 0.13723671f, -0.11107237f, -0.21036346f, 0.06957154f, -0.05781811f, 
    0.13064985f, -0.01912882f, 0.00199206f, 0.24609840f, -0.12129105f, 0.04537806f, 0.05930537f, -0.10778008f, 
    0.12537532f, -0.03437243f, 0.08433957f, -0.03294250f, -0.21099606f, -0.02037793f, 0.03797176f, -0.24788089f, 
    -0.25740904f, 0.16751897f, -0.17630669f, 0.03088664f, -0.08519846f, 0.08063897f, 0.06932657f, 0.03833777f, 
    -0.15566655f, -0.14616750f, 0.00436217f, 0.02114446f, 0.01531818f, 0.05893259f, 0.08140583f, 0.04143069f, 
    0.03228572f, 0.44886833f, -0.02150919f, -0.05160056f, -0.12968780f, -0.34305581f, 0.02632950f, 0.09217644f, 
    -0.06556576f, 0.05603506f, -0.01188412f, -0.17808776f, 0.21277319f, 0.06090806f, -0.03179385f, -0.11019521f, 
    0.03153916f, -0.09169140f, 0.13417232f, -0.18787542f, 0.05154923f, -0.01715086f, 0.05558296f, 0.03144894f, 
    -0.20922835f, 0.06995071f, 0.00434306f, 0.01901965f, 0.38988444f, 0.25944284f, 0.11239382f, 0.05634561f, 
    -0.13980965f, 0.14858072f, 0.06626707f, -0.07237941f, 0.18084936f, 0.08988526f, 0.06092803f, -0.16570751f, 
    0.12080162f, 0.11528173f, -0.00712117f, -0.07803937f, -0.02354576f, 0.00212504f, 0.01529162f, 0.42822856f, 
    0.45584053f, -0.14131108f, -0.08890039f, -0.25847623f, 0.03670252f, 0.23890722f, 0.00814658f, -0.38006485f, 
    -0.09397128f, 0.56486732f, -0.08796302f, 0.02572263f, -0.11933399f, -0.14016160f, -0.20592378f, -0.13651635f, 
    -0.01552885f, -0.07982721f, -0.06679213f, -0.06113312f, 0.00951348f, 0.00665593f, -0.07494792f, 0.03863939f, 
    -0.07372470f, 0.05223333f, -0.03951625f, 0.03876606f, 0.02805796f, 0.01678048f, -0.06483633f, 0.06893223f, 
    0.01806158f, 0.04771445f, -0.05971893f, 0.06265807f, 0.03118196f, -0.03254298f, 0.01713209f, -0.04264825f, 
    0.05069059f, -0.05761427f, 0.01073283f, -0.01844344f, 0.06443191f, -0.03733111f, 0.06861567f, -0.04664906f, 
    0.02895302f, -0.07687108f, -0.02188385f, -0.05050761f, -0.06737195f, -0.01781910f, 0.04540279f, -0.07545028f, 
    -0.04678552f, 0.04012026f, -0.03592631f, -0.01588681f, -0.02641085f, -0.02328938f, -0.02405273f, -0.00882636f, 
    0.03012368f, 0.05689832f, -0.08594763f, 0.07523128f, 0.00357257f, 0.02628608f, -0.01615686f, -0.04368882f, 
    -0.04245286f, 0.00567148f, -0.08362834f, -0.02065381f, -0.02477307f, -0.04026916f, -0.06993547f, -0.05749367f, 
    -0.06313343f, -0.00136164f, 0.02788843f, -0.05753327f, 0.07930305f, -0.09239569f, -0.03434477f, 0.04358974f, 
    0.06765321f, -0.04920900f, -0.01970933f, -0.02201286f, 0.00556320f, -0.09512793f, -0.02142253f, 0.05790929f, 
    0.00009878f, 0.02707236f, -0.00258707f, 0.04500691f, -0.00737292f, 0.00429003f, 0.03885392f, 0.04154297f, 
    -0.06396578f, -0.07284579f, -0.03212913f, -0.06409298f, 0.01112635f, -0.08433610f, -0.06413296f, 0.00538562f, 
    -0.05659400f, -0.03299264f, -0.08842679f, 0.06427653f, 0.06560878f, 0.01660551f, -0.03517712f, -0.03230561f, 
    0.05192431f, 0.00709288f, 0.05130193f, 0.05560129f, 0.03773028f, -0.00435812f, 0.00331124f, -0.07029337f, 
    0.01202269f, -0.01721705f, 0.01706934f, -0.07875701f, 0.00120734f, 0.03024074f, -0.08071212f, -0.07132322f, 
    -0.00065025f, -0.01267942f, -0.01143711f, -0.08310448f, 0.01277377f, -0.04983317f, -0.06275935f, -0.01873635f, 
    0.05864727f, 0.04976637f, 0.03183874f, -0.04341144f, -0.07080148f, -0.02089987f, -0.05775494f, -0.03560064f, 
    0.01913744f, -0.07798807f, 0.02937830f, -0.09307120f, 0.03854898f, -0.08943908f, -0.07669539f, -0.00308712f, 
    -0.00820912f, -0.00549173f, -0.34892443f, -0.11258300f, 0.03021918f, 0.07258603f, 0.04001565f, -0.11837823f, 
    0.12340341f, 0.02515572f, -0.11007194f, -0.15127443f, 0.10238054f, 0.20589031f, -0.03353663f, 0.06447792f, 
    0.18768941f, -0.12145133f, -0.19231296f, 0.07184217f, 0.32834491f, 0.04010564f, -0.11987279f, 0.10385754f, 
    -0.08110845f, -0.14159501f, -0.03866926f, -0.30651826f, -0.37744662f, -0.56830114f, 0.08958884f, -0.06444204f, 
    -0.07677827f, 0.09425889f, 0.08662001f, -0.02654351f, 0.06367480f, -0.08560936f, -0.30334920f, -0.11759550f, 
    -0.12288709f, -0.03054836f, 0.04295196f, -0.15591468f, 0.04796395f, -0.00885821f, -0.15940040f, -0.04006436f, 
    0.02737764f, 0.07673562f, 0.01963223f, 0.26163691f, -0.04802751f, 0.19865063f, -0.28258085f, -0.08251796f, 
    0.52703089f, -0.09941129f, 0.10040512f, 0.01579500f, -0.22594203f, 0.05567577f, 0.01897642f, -0.23460075f, 
    -0.10865954f, -0.11368605f, -0.13754988f, -0.20464301f, -0.01202928f, -0.00799867f, 0.05305190f, -0.10465307f, 
    0.17135286f, 0.06447255f, -0.39827496f, 0.15219294f, 0.15727697f, 0.16261889f, 0.04692852f, -0.10533247f, 
    0.19811277f, -0.49866483f, -0.29777220f, 0.05213824f, 0.08705044f, 0.06803019f, -0.12573701f, 0.13456735f, 
    -0.04703799f, 0.16119836f, 0.04428706f, 0.25073731f, 0.29808059f, -0.00272173f, 0.10772595f, 0.29654974f, 
    0.04938690f, 0.12671991f, 0.35186347f, 0.07479102f, 0.22791021f, 0.04303693f, -0.05340175f, -0.02404864f, 
    0.17858049f, -0.16602634f, 0.00830028f, 0.02488128f, -0.49623549f, 0.02670472f, -0.31604254f, 0.06402463f, 
    0.11365246f, -0.08426448f, 0.04074658f, 0.02121149f, 0.08158461f, 0.05760352f, -0.36291504f, -0.01074365f, 
    -0.11216266f, -0.19763702f, -0.11467770f, 0.11670586f, 0.14511345f, -0.00164053f, -0.18639107f, -0.35303441f, 
    -0.13341618f, 0.03876382f, -0.03362254f, 0.07918613f, 0.19307835f, 0.06159105f, 0.12968582f, 0.16583663f, 
    -0.04372211f, 0.10777494f, -0.06683361f, 0.07676057f, -0.00538129f, 0.19636986f, -0.01433514f, 0.15278095f, 
    -0.30965847f, -0.08524403f, 0.11932556f, -0.01619854f, 0.07687815f, -0.11387136f, -0.03984863f, -0.22906722f, 
    -0.17942193f, -0.27601895f, -0.10760720f, 0.05048937f, 0.10368589f, 0.11937404f, 0.29192561f, 0.11081331f, 
    -0.01703674f, 0.20694986f, -0.01691842f, 0.09508685f, -0.27315697f, -0.01857546f, -0.30207950f, -0.12924175f, 
    -0.03958436f, 0.06426118f, -0.15473448f, 0.14071578f, -0.00960702f, 0.29044619f, -0.01645580f, 0.22374970f, 
    0.26755971f, 0.05275251f, 0.21090764f, -0.13273352f, -0.39830589f, -0.46835098f, -0.16869298f, 0.03427644f, 
    -0.10991377f, 0.10204848f, -0.17646590f, -0.08924706f, -0.18779345f, 0.16406825f, 0.09511628f, 0.29619119f, 
    0.07094431f, 0.15898457f, -0.07416657f, 0.22505328f, 0.09662349f, 0.02364948f, 0.01849804f, 0.07527080f, 
    0.10009040f, -0.14721140f, 0.19673038f, -0.25674707f, -0.17987980f, -0.05048558f, -0.17610864f, 0.29315498f, 
    0.02610966f, 0.04735919f, 0.00449989f, 0.12376360f, 0.04729155f, -0.09653942f, -0.01733393f, -0.04108300f, 
    0.02453092f, -0.29088536f, -0.07514167f, 0.09823267f, 0.04192114f, 0.11257920f, -0.11803214f, 0.06430285f, 
    0.19759375f, 0.01357295f, 0.17208406f, -0.20900829f, 0.08616250f, 0.17210324f, 0.31994078f, 0.00871766f, 
    -0.20063137f, 0.10352489f, 0.05511840f, 0.13643199f, -0.02310057f, 0.18792588f, -0.05382007f, -0.07290919f, 
    0.02440710f, 0.13817909f, 0.08524769f, -0.09528267f, 0.07007986f, 0.14042701f, -0.01989843f, 0.24851494f, 
    0.11271338f, 0.12528060f, 0.09934288f, 0.06185078f, -0.16137478f, -0.05669582f, 0.11024042f, 0.00699281f, 
    0.03077315f, 0.13374622f, -0.11206634f, -0.01300079f, 0.15703838f, -0.01888730f, -0.29110390f, -0.16222005f, 
    0.02025769f, 0.18691614f, -0.05836181f, -0.09037761f, 0.17261323f, 0.06868181f, 0.16058189f, 0.16378377f, 
    0.09356013f, 0.01316510f, 0.02804887f, -0.00733403f, 0.03032545f, 0.11949448f, 0.01636881f, 0.52054763f, 
    0.14256568f, 0.09954152f, 0.13328978f, -0.01246253f, 0.20702757f, 0.11575706f, 0.13492899f, -0.06157515f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.04494729f, 0.08291698f, -0.00313257f, 0.05188800f, 0.17394085f, 0.24981444f, 0.13153067f, -0.08080617f, 
    -0.01492758f, -0.12416694f, -0.10420746f, 0.05801644f, -0.06277000f, -0.01689733f, 0.38783938f, 0.14529000f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.24422789f, -0.17110851f, -0.16382456f, -0.24376431f, -0.14445791f, 0.14098945f, -0.09392032f, 0.12334448f, 
    -0.24967283f, -0.24889374f, 0.01335195f, 0.04052052f, 0.17698988f, 0.23150745f, -0.19882935f, -0.15786582f, 
    0.01683942f, 0.31839120f, -0.30250314f, 0.21812053f, 0.36083415f, 0.01624476f, -0.21924286f, -0.10202681f, 
    -0.10800882f, 0.01383710f, 0.44774908f, -0.15201586f, 0.26981252f, -0.24524021f, -0.10673457f, -0.24880114f, 
    -0.11927190f, -0.37157914f, -0.30074796f, 0.10715946f, 0.26423687f, 0.23947762f, -0.47831771f, -0.28354552f, 
    0.18768018f, 0.24908790f, -0.00469079f, 0.14856203f, 0.40308934f, -0.05360144f, 0.09770183f, -0.01587138f, 
    -0.73033416f, 0.03892354f, 0.53420377f, 0.16169320f, 0.01932288f, 0.03975803f, 0.37412667f, -0.42086431f, 
    0.16419926f, -0.17396967f, -0.00710546f, -0.17530444f, 0.53786063f, 0.19655527f, -0.27730572f, 0.19532570f, 
    0.06422861f, 0.24722850f, -0.29424724f, 0.04590727f, -0.22172661f, 0.18013543f, 0.39520136f, 0.49925223f, 
    -0.21712194f, 0.29918712f, -0.21643290f, -0.02503363f, 0.29119077f, -0.15534896f, 0.05648688f, -0.07674491f, 
    -0.14890718f, -0.05186543f, -0.14065295f, 0.01915792f, -0.24947777f, -0.19617906f, 0.15683714f, 0.01882800f, 
    -0.22124469f, -0.05262098f, 0.11667910f, 0.02055600f, -0.01017648f, -0.21284500f, 0.04634702f, -0.16393971f, 
    0.41118878f, -0.17159207f, 0.12458912f, -0.14373174f, -0.06377238f, 0.24350840f, 0.00317879f, -0.25181568f, 
    0.07742467f, 0.18062539f, -0.23220980f, 0.24004830f, 0.54441071f, 0.06988249f, -0.16962567f, 0.18324229f, 
    0.12419594f, 0.08940203f, 0.04315941f, -0.01756542f, -0.22596550f, -0.04651642f, -0.00664920f, 0.01107901f, 
    -0.16951483f, -0.07932944f, -0.15980354f, -0.16312504f, -0.22854328f, 0.03033577f, -0.14415836f, -0.25152373f, 
    0.08157418f, -0.18756229f, -0.02479703f, 0.08196253f, -0.13403887f, 0.11703097f, 0.22366090f, -0.10246514f, 
    -0.23078191f, -0.23570007f, 0.23082832f, -0.16303068f, -0.12806973f, -0.18938231f, 0.05157346f, -0.19290693f, 
    -0.00774476f, -0.33369297f, 0.13037810f, 0.07769246f, -0.00271235f, 0.23021005f, -0.19530798f, 0.07664759f, 
    0.13529754f, 0.22447890f, 0.31006727f, 0.01830247f, -0.79632795f, -0.05117183f, 0.23182119f, 0.18355465f, 
    0.05285736f, -0.13400061f, -0.14254944f, 0.06538916f, 0.05188055f, 0.16467313f, 0.38853410f, -0.45930567f, 
    0.23304558f, 0.10996310f, -0.18008278f, -0.13189210f, -0.09607685f, -0.17470945f, 0.18785730f, 0.27402273f, 
    0.36424512f, -0.30549097f, -0.21687935f, -0.42642969f, 0.01498566f, 0.44561011f, -0.00223148f, 0.26879537f, 
    0.18251385f, -0.28244716f, -0.22381057f, -0.02401990f, 0.29214290f, 0.21751596f, 0.25441623f, 0.01088691f, 
    -0.36051852f, 0.45252016f, 0.09480146f, 0.14937308f, 0.21725769f, 0.09074683f, 0.15252712f, 0.35890239f, 
    -0.20695865f, -0.36470971f, 0.05333780f, 0.14952610f, -0.33651125f, -0.01925192f, 0.31819266f, -0.05877315f, 
    0.11878584f, 0.31072983f, 0.61617392f, -0.12681012f, -0.12568022f, 0.10651226f, -0.28372473f, 0.04878892f, 
    0.11582683f, -0.09583588f, 0.32194537f, 0.10544285f, 0.09943513f, -0.09771030f, -0.18634494f, 0.07842927f, 
    -0.08219457f, 0.48245600f, -0.39041856f, 0.51614249f, 0.12207066f, -0.04393257f, 0.06190334f, 0.54721218f, 
    0.22583176f, -0.45247069f, 0.30920580f, -0.14280206f, -0.21536714f, -0.01569969f, -0.29647312f, 0.17532569f, 
    -0.16444613f, 0.28033283f, -0.27539292f, 0.37342727f, 0.25414222f, -0.05922666f, -0.07763635f, -0.34224236f, 
    -0.05672688f, -0.14300179f, -0.30632344f, 0.08101099f, -0.08974073f, 0.01400693f, 0.15793933f, 0.18263815f, 
    0.18407524f, -0.14034650f, 0.09854224f, 0.00194353f, -0.22009096f, -0.02102837f, 0.10929710f, -0.11783415f, 
    0.22622421f, -0.15447906f, -0.10860014f, -0.05188110f, 0.12545040f, -0.13848290f, -0.22537166f, -0.13430074f, 
    -0.10320838f, 0.20747310f, 0.21813753f, -0.25802153f, -0.16796254f, -0.10486285f, 0.10240991f, -0.12806372f, 
    -0.15011340f, 0.07510819f, -0.42153573f, 0.17239866f, -0.07422267f, -0.21418431f, -0.51926142f, -0.21207796f, 
    -0.19848892f, 0.03936924f, 0.13641526f, -0.09330715f, -0.00164172f, 0.32696328f, 0.23892120f, -0.13185053f, 
    -0.07789314f, 0.12073340f, -0.18737788f, -0.21553946f, 0.04057912f, 0.17922650f, 0.07803971f, -0.00060729f, 
    -0.04585059f, -0.00309086f, -0.34816131f, -0.01741453f, -0.06597070f, 0.34198448f, -0.44210738f, -0.21673463f, 
    -0.18198648f, 0.34232780f, -0.04537891f, -0.18034376f, -0.45957929f, 0.14450024f, 0.28771693f, 0.25200927f, 
    0.19937572f, -0.17971036f, 0.37933204f, 0.04567771f, -0.26511505f, 0.16976073f, 0.21632895f, 0.42791617f, 
    -0.08834995f, 0.26964664f, -0.06753822f, -0.20828043f, -0.18289068f, 0.01385629f, -0.33322579f, 0.37156966f, 
    0.19099675f, -0.03580429f, -0.35813573f, 0.25438955f, 0.27217817f, -0.22770977f, -0.65689957f, 0.31990993f, 
    0.22291054f, 0.32693100f, 0.30934304f, -0.22573841f, -0.25999919f, -0.01696416f, 0.19073980f, 0.17746191f, 
    -0.11634546f, -0.35749879f, 0.30248690f, -0.39036191f, -0.20236191f, 0.40791273f, 0.38011411f, -0.24384665f, 
    -0.20073597f, 0.06019766f, -0.15421867f, -0.22629037f, 0.25951073f, 0.22174092f, -0.05152180f, 0.41551107f, 
    0.08467630f, -0.33434448f, -0.15678808f, 0.20185417f, -0.03708338f, 0.05869907f, 0.13377057f, -0.30988777f, 
    -0.21038491f, 0.20183598f, -0.27849802f, 0.14317599f, 0.27899027f, -0.19017763f, 0.32733542f, 0.16329814f, 
    0.16846971f, -0.05172513f, -0.05976388f, -0.03192070f, -0.10834348f, -0.16743040f, 0.03300655f, 0.05311631f, 
    -0.17877176f, -0.21135628f, -0.21542822f, 0.17682624f, 0.00339826f, -0.02949032f, -0.16223364f, -0.13320671f, 
    -0.17827514f, -0.17881495f, -0.23924971f, -0.05377933f, -0.20987284f, -0.21690419f, -0.21380535f, -0.17559654f, 
    -0.23980215f, 0.09908491f, -0.05809832f, 0.12200680f, 0.13216308f, 0.02858266f, -0.22894001f, 0.12165099f, 
    0.01147544f, -0.13770992f, -0.02996320f, 0.05954916f, -0.20761847f, -0.02774860f, -0.09347810f, 0.17364396f, 
    -0.15227629f, 0.01926022f, -0.05482879f, -0.20334083f, 0.21741024f, 0.10177448f, -0.18134928f, -0.10758458f, 
    0.15738645f, 0.43786415f, 0.28523642f, 0.03564607f, 0.04705735f, -0.25216573f, -0.27741450f, 0.31625041f, 
    0.15958802f, -0.16710149f, 0.33292675f, 0.05384099f, -0.40771323f, -0.18424335f, -0.36390233f, -0.02209305f, 
    -0.08689743f, -0.25437292f, -0.22957595f, -0.29563057f, 0.20514457f, 0.29693398f, -0.07859658f, 0.21771175f, 
    0.23586974f, 0.08759554f, 0.17010058f, 0.20046611f, 0.26333931f, 0.13612936f, -0.16610827f, 0.19373332f, 
    -0.14440748f, 0.42246830f, -0.54212099f, 0.38864011f, 0.31586882f, -0.08010487f, -0.17619245f, -0.06330044f, 
    -0.22499736f, -0.38939473f, -0.30457461f, 0.01696591f, 0.05774193f, -0.12442996f, 0.54998571f, 0.02470754f, 
    0.29501981f, 0.28460333f, -0.03667971f, -0.30189249f, 0.09628316f, 0.14504766f, -0.22499508f, 0.51507944f, 
    -0.22113921f, 0.06102329f, 0.29111618f, 0.13841754f, -0.11003104f, 0.19073202f, -0.08757587f, -0.14575894f, 
    0.60249078f, -0.27640700f, 0.36365467f, 0.32379052f, -0.21926080f, -0.31925753f, 0.31295365f, -0.81646693f, 
    -0.06193373f, 0.56964064f, 0.13837811f, 0.05002156f, -0.46494037f, -0.20513900f, -0.27190256f, 0.12521309f, 
    -0.07506390f, -0.21830179f, 0.41942567f, 0.44921961f, 0.28619596f, 0.11171892f, -0.27326718f, 0.36594605f, 
    0.16984411f, -0.63141286f, 0.09436248f, 0.01245242f, 0.28207108f, 0.12429582f, -0.43453974f, -0.16329104f, 
    0.12200685f, 0.06517880f, -0.12582530f, 0.09229838f, 0.03736822f, -0.07627308f, -0.01574225f, 0.09364516f, 
    0.23231590f, 0.19484301f, -0.60322362f, 0.00764418f, -0.15250149f, 0.18304662f, -0.41712159f, -0.39859232f, 
    0.12516129f, 0.22767721f, 0.25752780f, 0.23333322f, 0.10949059f, 0.34095177f, -0.46375865f, 0.68167967f, 
    -0.06952868f, -0.28395420f, 0.36521986f, -0.07860807f, -0.26508042f, -0.09913968f, 0.11325244f, -0.07466017f, 
    0.38248885f, 0.04425709f, -0.13873567f, -0.10095163f, 0.29340929f, 0.12322556f, -0.02057960f, -0.19748497f, 
    -0.00291407f, 0.15243569f, 0.23177707f, 0.12995659f, 0.59883416f, 0.12592576f, -0.38108191f, -0.27342018f, 
    0.36556405f, 0.33089864f, 0.28746706f, -0.20327166f, 0.13745362f, -0.30187136f, 0.39825362f, -0.09696864f, 
    0.18536776f, -0.32687914f, -0.12781002f, 0.03291314f, 0.60876954f, -0.04449909f, -0.39331752f, -0.09723225f, 
    0.31300253f, -0.05468395f, 0.39522508f, 0.16349524f, -0.07552602f, -0.02707769f, 0.10629325f, 0.36374199f, 
    0.03874215f, 0.09513782f, 0.20420225f, -0.17343922f, -0.03735993f, -0.16456743f, -0.31303304f, 0.03690759f, 
    -0.46226197f, 0.02841989f, 0.25290737f, -0.09796973f, 0.06953169f, 0.52345741f, 0.31738952f, 0.36185512f, 
    0.12381073f, -0.26470995f, 0.36019486f, 0.20904027f, -0.31876206f, 0.13223696f, -0.28454706f, 0.23062818f, 
    0.24308041f, 0.40834376f, 0.11309954f, 0.12998420f, 0.15606681f, -0.08156098f, 0.16935526f, 0.01786621f, 
    0.01971609f, -0.29482707f, -0.20806794f, 0.21079727f, 0.61856765f, -0.08640553f, 0.14307667f, -0.32319906f, 
    0.35695016f, 0.11644567f, 0.22745472f, 0.38989598f, -0.12102069f, 0.23414725f, -0.26167887f, 0.76988971f, 
    -0.06500157f, 0.11196990f, 0.11439577f, -0.11005879f, -0.66194737f, -0.07323693f, 0.04160756f, 0.09233212f, 
    -0.02395768f, 0.18982798f, 0.04517146f, 0.34951350f, 0.16431336f, 0.33922786f, 0.02485834f, -0.21672678f, 
    0.10268442f, -0.07372794f, -0.21402928f, -0.20637722f, -0.47561607f, -0.01231490f, 0.37160209f, -0.01905494f, 
    -0.34564495f, -0.41371763f, -0.04457096f, -0.35779035f, 0.01539874f, 0.54982841f, 0.14539430f, 0.28214678f, 
    0.02104403f, 0.02874695f, -0.12767521f, -0.13092268f, -0.36096251f, -0.23182572f, 0.18203765f, 0.29244423f, 
    -0.40104333f, -0.21316478f, -0.44580925f, -0.22934301f, 0.37158427f, -0.05238794f, 0.35549253f, -0.25501519f, 
    -0.04268353f, -0.37843993f, 0.00826071f, 0.12787487f, 0.14035486f, -0.03907022f, 0.26930025f, 0.31879589f, 
    0.07008343f, -0.25146580f, -0.63433957f, 0.12831776f, 0.29545751f, -0.18557408f, 0.09730684f, -0.02426268f, 
    -0.08192441f, -0.10562561f, -0.18282926f, -0.23848899f, 0.53137904f, 0.00009015f, 0.05509493f, 0.36883488f, 
    -0.50196362f, -0.14737500f, -0.45300442f, 0.01413091f, 0.30416381f, 0.20208128f, -0.43099192f, 0.04317017f, 
    -0.22237289f, -0.15278548f, 0.24736750f, -0.23180498f, 0.00273178f, -0.05804084f, -0.04591025f, 0.06231445f, 
    0.55806363f, -0.17524844f, 0.03235897f, -0.28084704f, -0.07776298f, 0.37283537f, -0.02753309f, -0.19287357f, 
    0.23010771f, 0.17051204f, -0.19400163f, 0.04187852f, 0.21808696f, -0.04725480f, -0.25057217f, 0.44273022f, 
    -0.02027071f, -0.00827232f, -0.20669606f, -0.06655773f, -0.22374973f, -0.21287718f, 0.06013821f, -0.10131523f, 
    -0.00783497f, -0.03542961f, 0.16571420f, -0.01703888f, 0.09709848f, -0.01337200f, -0.23519143f, -0.03701831f, 
    0.23797715f, 0.46524847f, -0.17349052f, -0.01516856f, 0.11093152f, 0.23452322f, 0.67828989f, -0.24558112f, 
    0.09505811f, -0.29503185f, -0.27789608f, 0.06356237f, 0.38319346f, 0.13478449f, -0.10107000f, -0.03288109f, 
    0.50574630f, -0.36412266f, -0.54436880f, -0.10715494f, -0.25957906f, 0.17804044f, 0.25587299f, 0.11725578f, 
    0.15651815f, 0.20248049f, 0.08173659f, 0.03282568f, -0.10224278f, -0.14688750f, 0.14819719f, 0.02571613f, 
    -0.31487417f, -0.36157814f, 0.31223014f, -0.23921815f, 0.07027084f, 0.25616232f, -0.96399182f, 0.29420933f, 
    0.06939115f, -0.12033038f, 0.40056947f, 0.16536906f, -0.26440653f, -0.05093085f, -0.14841217f, 0.07868765f, 
    0.12210513f, -0.14372648f, -0.59002572f, -0.31241789f, 0.17791274f, 0.20857832f, -0.29756379f, -0.55525112f, 
    -0.01745212f, -0.21781230f, -0.01124037f, -0.20871174f, 0.56489724f, -0.14482640f, 0.28998515f, 0.27318427f, 
    0.10629794f, 0.47848564f, 0.23934755f, 0.04593995f, -0.07996375f, -0.37495854f, 0.16689551f, -0.22412820f, 
    -0.21316935f, -0.12482320f, -0.15560058f, -0.11031972f, -0.56188273f, -0.09093142f, 0.40001452f, 0.00082416f, 
    0.04445373f, -0.19451076f, -0.18095207f, -0.00136264f, -0.09307276f, -0.22140476f, -0.20870933f, 0.02289523f, 
    -0.12988892f, -0.18955673f, -0.21498731f, -0.02661633f, -0.22896898f, 0.18583858f, 0.08891664f, 0.14848691f, 
    -0.36521038f, -0.14130895f, -0.14208336f, -0.40357247f, -0.05712945f, 0.57264930f, 0.43379045f, 0.16807440f, 
    0.19085830f, -0.16402866f, -0.37621641f, 0.24272652f, 0.17052437f, -0.21223123f, 0.35873166f, 0.35469273f, 
    -0.33507189f, 0.15818797f, 0.18778311f, 0.29095942f, 0.19573691f, -0.08830309f, -0.06518630f, -0.15195510f, 
    0.09209487f, -0.24898265f, 0.42733791f, -0.01400194f, -0.23319538f, 0.04423735f, 0.17123435f, -0.03989423f, 
    0.29003361f, -0.28941923f, 0.41871443f, 0.43190345f, -0.10912025f, -0.06113205f, 0.02687309f, 0.09614151f, 
    0.06221307f, -0.69080323f, 0.17199157f, -0.20643011f, -0.05774647f, 0.05841380f, -0.42637631f, 0.04953811f, 
    -0.13544112f, -0.08688803f, -0.43557471f, 0.10754989f, -0.01525964f, 0.40652621f, -0.10040414f, -0.19402580f, 
    -0.18294398f, -0.16994798f, 0.12455676f, -0.06585753f, -0.01553561f, -0.05112509f, 0.47779199f, 0.29246092f, 
    -0.41203809f, 0.04543791f, -0.41003841f, -0.15669353f, 0.25675008f, 0.11071877f, 0.53553611f, 0.13435613f, 
    0.21238339f, -0.37902626f, 0.20266235f, 0.20043297f, 0.14000915f, 0.20598915f, 0.45755997f, -0.12735310f, 
    -0.66990125f, 0.40238243f, -0.11888906f, -0.18828851f, 0.24405892f, -0.28058320f, 0.24050082f, 0.23382400f, 
    0.01942219f, 0.27983937f, -0.09038609f, -0.08132601f, 0.56797886f, -0.04579116f, 0.01137073f, -0.11380316f, 
    0.40246618f, 0.05202323f, 0.11790749f, -0.61698967f, -0.12008242f, 0.37786409f, -0.39908728f, -0.23880115f, 
    -0.06119392f, 0.13682859f, 0.25663954f, -0.00718012f, 0.39404389f, -0.05642834f, 0.04391200f, -0.04195959f, 
    0.48973209f, -0.24177989f, -0.27307907f, 0.15581779f, -0.11917582f, 0.31558299f, 0.30456904f, 0.43527636f, 
    0.02207271f, -0.05324101f, 0.24696285f, 0.12785588f, 0.18597707f, 0.15127450f, 0.28738305f, -0.29986057f, 
    0.26234952f, -0.15049982f, -0.02444502f, -0.39145854f, -0.01308897f, 0.46653140f, -0.00378910f, 0.57898241f, 
    -0.19275340f, 0.23786227f, 0.07925599f, -0.03374745f, 0.13187084f, -0.17004511f, 0.07607769f, -0.25288773f, 
    -0.29886180f, -0.09893029f, 0.04694486f, 0.26502249f, 0.32159999f, 0.27059054f, -0.24262770f, 0.71328676f, 
    0.15095119f, -0.17885706f, 0.42983055f, -0.01268544f, 0.27379727f, 0.11016598f, -0.26808667f, 0.07548764f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.12257358f, 0.44054377f, 0.27100420f, -0.10891949f, 0.20078185f, -0.15441525f, 0.09510966f, 0.18528825f, 
    -0.03733384f, -0.15781797f, 0.01550186f, 0.39895275f, 0.22764690f, -0.09489010f, -0.17616342f, 0.34448037f, 
    -0.19052556f, 0.24985340f, 0.18375635f, 0.36377323f, -0.18339743f, 0.48800534f, 0.20481676f, 0.30056074f, 
    0.05124561f, -0.03562647f, 0.15964280f, 0.16921423f, 0.31649050f, 0.04410659f, -0.28017184f, -0.16298510f, 
    0.05068829f, 0.37694436f, -0.00438868f, 0.29549482f, 0.11923300f, -0.09430878f, 0.33141172f, 0.27228528f, 
    0.20378657f, 0.22155041f, -0.00305235f, 0.37338433f, 0.54496801f, 0.40507600f, -0.02814068f, 0.08712087f, 
    0.51862836f, 0.04574959f, -0.30509761f, 0.23559344f, 0.27046549f, -0.16248716f, -0.06435020f, -0.12812240f, 
    0.15908603f, 0.45408520f, 0.23188829f, -0.71893901f, 0.20780967f, -0.04187858f, 0.18162698f, -0.23696281f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.01634294f, 0.04040384f, -0.10748470f, -0.08218604f, -0.12785596f, 0.03975426f, 0.01316644f, 0.10404329f, 
    0.10105988f, -0.00008023f, -0.06313777f, -0.06526182f, -0.12901026f, 0.05954132f, -0.09852435f, -0.11183020f, 
    0.08056848f, 0.06511910f, 0.08909121f, -0.04301343f, -0.03012447f, -0.16240522f, -0.11605607f, 0.07608627f, 
    0.03270991f, -0.08816993f, 0.02619554f, -0.00276918f, -0.15565968f, -0.14836569f, -0.13876021f, 0.10437198f, 
    0.06190106f, 0.14139584f, -0.00531209f, -0.05451130f, 0.10678206f, -0.06606693f, -0.13842225f, -0.08866113f, 
    -0.06779458f, -0.10900029f, 0.07437404f, 0.01832008f, 0.05199163f, 0.01083395f, -0.06723469f, 0.09871791f, 
    0.00120526f, -0.05075154f, 0.07909364f, -0.01778356f, 0.02582540f, -0.03519213f, -0.07509015f, -0.11887402f, 
    0.02392875f, -0.15467517f, -0.07753637f, -0.01086307f, -0.01747629f, -0.11736219f, 0.04436967f, -0.07649293f, 
    -0.04850599f, 0.01716837f, 0.05633912f, 0.05900530f, 0.04629092f, 0.06104706f, -0.02198316f, 0.11419451f, 
    0.10783525f, -0.10549011f, 0.02021504f, -0.06315800f, -0.07624731f, 0.04033256f, -0.08339207f, -0.07729462f, 
    0.07983163f, -0.03987452f, -0.05762934f, -0.02299158f, -0.07061708f, -0.01273353f, -0.11403007f, 0.00440070f, 
    -0.09022768f, -0.05906594f, 0.04739456f, -0.07913305f, -0.02808663f, -0.00370472f, 0.08506192f, 0.05236813f, 
    0.00695495f, -0.08040696f, -0.07776412f, -0.15570012f, -0.13105372f, -0.14740802f, -0.01960714f, -0.02426925f, 
    0.06274460f, 0.07782573f, 0.11589789f, -0.09232240f, -0.02965489f, -0.11674893f, -0.13582548f, 0.05710629f, 
    -0.07702012f, 0.05449459f, -0.10392172f, -0.06106195f, -0.08356348f, -0.06177600f, 0.02150930f, 0.04647810f, 
    -0.01086277f, -0.01133363f, -0.02864637f, -0.13572842f, 0.12199450f, -0.04843730f, -0.03989994f, -0.14692478f, 
    -0.04114000f, 0.02425967f, 0.20260739f, 0.11381061f, 0.27794677f, -0.06748410f, -0.04242688f, -0.05530101f, 
    -0.07208687f, 0.03637077f, 0.16807771f, 0.04737341f, 0.16141887f, -0.22153398f, 0.00223483f, 0.10711857f, 
    -0.02863616f, 0.15762627f, -0.06416100f, 0.07710978f, -0.01844201f, 0.09543556f, 0.00659152f, 0.28107670f, 
    0.01027141f, 0.05573545f, -0.09688223f, -0.29087463f, -0.14635018f, -0.04522344f, -0.09178673f, -0.11435169f, 
    -0.33744061f, 0.20357066f, -0.02020478f, 0.08494129f, -0.18770404f, -0.01889760f, 0.03973841f, 0.10797337f, 
    -0.04737704f, 0.21580033f, 0.02929411f, 0.07778784f, -0.03253939f, -0.19179131f, 0.01516911f, 0.01363964f, 
    0.43119925f, 0.33491260f, -0.91326940f, -0.05114247f, 0.07048535f, 0.01717454f, 0.25432500f, -0.13266495f, 
    -0.21306649f, 0.19274308f, 0.08279019f, 0.07234451f, -0.08869591f, 0.41219771f, 0.16473472f, 0.09630480f, 
    -0.00313559f, -0.01656086f, 0.10952983f, -0.28068432f, 0.14947350f, 0.06808412f, 0.22269627f, -0.13772801f, 
    -0.11029481f, 0.03687916f, 0.10702349f, 0.21736623f, 0.01374881f, -0.27312294f, -0.25029004f, 0.08325667f, 
    -0.09897819f, 0.17121191f, -0.00080006f, 0.30681458f, -0.04147636f, 0.00805196f, 0.00412048f, 0.32392129f, 
    0.11746900f, -0.08993669f, -0.12875150f, -0.28476918f, -0.08003834f, 0.24718973f, 0.00343170f, 0.05476380f, 
    0.08480205f, -0.09170352f, -0.03003433f, -0.02936129f, -0.18350796f, -0.21523605f, -0.12153345f, -0.01848578f, 
    0.12207398f, 0.16555837f, 0.16790168f, 0.18883188f, 0.11180045f, 0.00531731f, 0.16889609f, -0.02523509f, 
    -0.00900091f, 0.10898978f, -0.05434258f, 0.48198959f, -0.02258753f, 0.01232991f, 0.21266411f, -0.13388267f, 
    -0.37206554f, 0.26004273f, 0.16655256f, -0.31772721f, 0.10096470f, -0.12595664f, -0.03281249f, -0.06244157f, 
    0.11805852f, -0.08300269f, 0.05425012f, 0.13327929f, 0.12089565f, 0.06452154f, 0.00068632f, 0.12376422f, 
    -0.01969409f, -0.04035489f, 0.20581277f, 0.17662555f, 0.15156163f, -0.28558734f, 0.03282322f, 0.19997057f, 
    0.09518075f, 0.04146485f, 0.02765493f, -0.05157893f, 0.02756088f, 0.16041225f, -0.11164822f, 0.04221535f, 
    0.01292822f, -0.02346298f, -0.08777473f, -0.33787218f, -0.00240637f, 0.14140947f, -0.13151559f, -0.05796495f, 
    -0.42863950f, -0.02670489f, -0.05718576f, -0.07173356f, -0.01994447f, -0.01627355f, 0.10668913f, 0.02020476f, 
    0.13160159f, 0.19388570f, 0.18723245f, 0.13934594f, 0.14643805f, -0.22789970f, 0.00560076f, -0.09144325f, 
    0.43391138f, 0.57349789f, -0.89340305f, 0.10911258f, -0.05625300f, -0.13614374f, 0.41711983f, 0.08749764f, 
    -0.24931423f, 0.06279647f, 0.34383795f, -0.02939816f, -0.50130075f, 0.39849892f, 0.05201323f, -0.06325237f, 
    0.09261483f, -0.08734770f, -0.42647699f, 0.16413888f, -0.19164792f, -0.09905794f, -0.12026846f, -0.02899075f, 
    -0.06817185f, -0.29263961f, 0.16800107f, -0.43529946f, 0.18155754f, 0.01749675f, 0.48078656f, 0.21404400f, 
    0.02336894f, -0.60432196f, -0.01767909f, -0.40362573f, 0.13028450f, -0.35916200f, 0.13553178f, -0.05420284f, 
    0.00862643f, 0.04107517f, 0.07167906f, 0.19494233f, 0.01199442f, 0.01278300f, -0.37801632f, -0.29871991f, 
    0.07261202f, 0.03261932f, -0.29442766f, -0.14279045f, 0.30288601f, 0.08778439f, 0.31179589f, 0.12176587f, 
    -0.13565312f, 0.09737029f, -0.21348608f, 0.28187525f, 0.13889322f, -0.55764949f, 0.02974633f, -0.08395157f, 
    0.27631673f, -0.28018060f, -0.32400346f, -0.20152146f, 0.10183392f, -0.03975707f, 0.25170711f, 0.21602744f, 
    0.20892876f, -0.01898216f, 0.21593273f, 0.17498675f, -0.35208353f, -0.63416755f, -0.57786411f, 0.20790005f, 
    -0.00342406f, -0.01547807f, -0.11428502f, -0.12285185f, -0.07819472f, 0.06506659f, 0.11011079f, 0.00601253f, 
    0.09027323f, -0.06035531f, -0.03071697f, -0.06911603f, -0.00987041f, -0.04131046f, -0.03149278f, -0.07019238f, 
    0.01198627f, -0.09773602f, 0.00707363f, 0.10156615f, -0.06632401f, 0.07182178f, -0.12300292f, 0.05044535f, 
    -0.04843451f, -0.08373906f, -0.10100058f, -0.10384221f, -0.00712503f, -0.05617066f, 0.08761504f, -0.12158623f, 
    -0.05100060f, -0.09563747f, 0.04465482f, -0.08310874f, 0.06574187f, 0.05876982f, -0.10480303f, 0.05076240f, 
    -0.10551463f, -0.04115780f, -0.03208105f, -0.08701372f, 0.00530350f, -0.07992101f, -0.04334326f, -0.07312921f, 
    -0.09334777f, 0.01220079f, 0.04299337f, -0.05913614f, -0.06475134f, -0.04404685f, -0.10468294f, -0.04144070f, 
    -0.03355560f, -0.09651437f, 0.05759351f, 0.04082130f, -0.04741782f, 0.04708031f, -0.10948561f, 0.00004707f, 
    -0.06545590f, 0.03055537f, 0.16484210f, 0.16199206f, 0.16362232f, 0.10073149f, 0.17667964f, -0.06656333f, 
    -0.04521613f, -0.17502548f, 0.12101983f, 0.33927876f, -0.22019900f, -0.25970766f, -0.09454963f, -0.06647475f, 
    -0.01223607f, 0.04724575f, 0.10671092f, 0.01360368f, 0.05492195f, -0.08574838f, 0.23315845f, 0.20413648f, 
    -0.05109747f, -0.04241823f, -0.04598969f, -0.56435770f, 0.22265510f, -0.18967210f, -0.14397691f, -0.16578561f, 
    -0.23884593f, 0.01700080f, -0.11212195f, 0.34995553f, 0.36805561f, 0.12682061f, 0.01477351f, 0.22716200f, 
    -0.13547733f, -0.05047451f, 0.42006972f, 0.10584731f, 0.07894008f, -0.24434112f, 0.31019861f, -0.02286176f, 
    0.20280607f, 0.33167946f, -1.12556052f, 0.20251663f, -0.47459605f, -0.07167907f, 0.51031452f, -0.16247126f, 
    -0.29939988f, 0.04898398f, 0.03312498f, 0.04404301f, 0.00424358f, 0.13287532f, 0.16633599f, 0.13102168f, 
    0.02662331f, -0.08457940f, -0.16724084f, 0.05616940f, 0.19826525f, -0.09796745f, -0.12657599f, -0.06395568f, 
    0.09621160f, 0.08955103f, 0.15317859f, 0.07740006f, 0.27729416f, -0.27648371f, 0.02563038f, 0.23901206f, 
    0.03332679f, 0.17176656f, 0.10356484f, 0.17733547f, -0.03896423f, 0.01019663f, 0.04253479f, 0.10821157f, 
    -0.08829540f, 0.06506081f, -0.01301992f, -0.35591361f, -0.08109395f, 0.25257820f, -0.16327226f, 0.05571260f, 
    -0.67831105f, -0.16770282f, -0.07017881f, -0.18100841f, 0.02066446f, -0.10376705f, 0.35408416f, 0.05079759f, 
    0.10376662f, 0.11510209f, 0.16898802f, 0.39449924f, 0.27005932f, -0.06686579f, -0.05046120f, 0.01360443f, 
    0.44595337f, 0.42895576f, -0.62400556f, 0.18788250f, 0.09532133f, 0.05008445f, 0.48873118f, 0.12668121f, 
    -0.75523019f, 0.23183256f, 0.40024233f, 0.10642354f, -0.60181600f, 0.30005360f, -0.17130989f, -0.08847710f, 
    -0.00416046f, 0.09970007f, 0.03359504f, -0.03735377f, -0.12013725f, 0.00043619f, 0.02888885f, -0.09999040f, 
    0.10288879f, -0.01113086f, 0.08621681f, -0.15079781f, -0.03407465f, -0.04068352f, 0.05100051f, 0.00998062f, 
    0.04278910f, 0.05964908f, 0.06471128f, 0.07500158f, -0.06399730f, 0.06884179f, -0.07746784f, -0.07034633f, 
    0.00485071f, 0.02723999f, 0.05498247f, -0.11179533f, -0.10775433f, 0.02095022f, 0.01501917f, 0.02029030f, 
    0.08654058f, -0.11169659f, 0.06547097f, 0.08639234f, -0.01857369f, -0.12224937f, -0.08372726f, 0.01486406f, 
    -0.04298145f, -0.13534753f, -0.02303042f, 0.08590033f, -0.11482672f, -0.04870441f, -0.02510767f, -0.08505921f, 
    0.05687887f, 0.02155761f, -0.06596258f, -0.01605818f, -0.06948639f, 0.10123862f, -0.09240108f, -0.13704498f, 
    -0.02838037f, -0.05682907f, 0.02398355f, -0.09038441f, -0.12276189f, 0.01523377f, 0.05196648f, -0.07839462f, 
    0.12371767f, -0.07831979f, 0.19882333f, -0.42435470f, -0.04875960f, 0.03689110f, 0.11762646f, 0.11839366f, 
    -0.14302181f, 0.24666362f, 0.31489623f, 0.04171013f, -0.09996399f, -0.21823320f, -0.16904882f, 0.22770900f, 
    0.09713328f, 0.10238665f, -0.06331968f, 0.26191288f, -0.18982568f, 0.14933713f, 0.38539267f, 0.16884872f, 
    0.04711739f, 0.02814950f, -0.02245783f, -0.00460143f, -0.09758054f, 0.14732321f, -0.23217180f, 0.21012482f, 
    0.01079626f, 0.12784836f, -0.03586335f, -0.09433069f, -0.32270309f, -0.21323304f, 0.07656412f, -0.28724262f, 
    -0.01034636f, 0.16314524f, 0.43291563f, 0.48593140f, 0.24965049f, 0.16455312f, 0.10546716f, 0.07299209f, 
    -0.02090912f, -0.22764552f, 0.30501655f, 0.44846386f, 0.09833978f, 0.01042084f, 0.35795546f, -0.06260749f, 
    -0.34397152f, 0.30185074f, 0.13083234f, -0.58394945f, -0.00404762f, -0.25929818f, -0.04757302f, -0.19191276f, 
    -0.04956152f, -0.19017440f, 0.14380944f, -0.57456172f, 0.06382424f, 0.01768816f, 0.05323600f, -0.06890715f, 
    0.01566482f, 0.00988457f, 0.26210734f, 0.02834533f, 0.07188550f, -0.22849241f, -0.16295260f, 0.20239450f, 
    0.00983933f, -0.06062860f, -0.02544963f, 0.36152306f, 0.01545586f, 0.20549737f, 0.13751048f, 0.18818636f, 
    0.12492242f, 0.06714718f, 0.09292086f, -0.11461656f, -0.05594438f, 0.46670175f, -0.30958512f, 0.18125571f, 
    0.17805733f, 0.06046966f, -0.00683567f, -0.13204004f, -0.04150778f, -0.01912848f, -0.19188377f, -0.01290144f, 
    0.00978646f, 0.20137286f, -0.02682705f, 0.28462717f, 0.28945243f, -0.00379858f, 0.23842330f, -0.05814377f, 
    -0.02347162f, -0.10285702f, 0.10717943f, 0.24251002f, 0.19213437f, -0.02288621f, -0.07070879f, 0.00922526f, 
    0.00980043f, 0.10585720f, -0.12890190f, -0.51268536f, -0.44502571f, -0.55812466f, -0.37584782f, -0.29830995f, 
    0.06643181f, -0.01088065f, -0.04005838f, 0.26206803f, 0.00856872f, -0.03390427f, 0.06520105f, 0.12000381f, 
    0.02019170f, -0.15158761f, 0.02027001f, 0.02903362f, 0.07467388f, 0.13944177f, 0.16278754f, -0.08477499f, 
    -0.02002496f, 0.36740592f, -0.10885002f, 0.02857945f, 0.14596330f, -0.04459851f, 0.35876393f, -0.23547573f, 
    -0.01165956f, 0.03916249f, -0.11037899f, -0.01723834f, 0.34794235f, -0.25014299f, 0.18106855f, -0.48476654f, 
    -0.60843885f, 0.08391823f, 0.05156646f, 0.03263241f, 0.14361845f, 0.05279272f, 0.46310651f, -0.13362382f, 
    -0.01314003f, 0.04150642f, 0.37664935f, -0.02640163f, 0.09056558f, -0.02878866f, 0.16248451f, 0.02350266f, 
    0.03690985f, -0.09481485f, 0.69002777f, -0.08813692f, -0.18109345f, 0.02231805f, 0.36145777f, -0.19981965f, 
    -0.40891087f, 0.08205667f, 0.04044844f, -0.05757353f, 0.19593397f, -0.11092066f, 0.15080895f, 0.22693683f, 
    0.07415597f, -0.10750867f, 0.00916671f, -0.01610185f, -0.05048072f, 0.03793719f, -0.05116735f, -0.05286013f, 
    0.07634646f, -0.02098510f, -0.07186038f, -0.02249591f, -0.03255611f, 0.04253276f, 0.06032794f, -0.09519443f, 
    -0.05495715f, -0.02257785f, 0.03557859f, -0.00528753f, -0.11839058f, -0.06760865f, 0.01422123f, 0.03191705f, 
    0.10560770f, 0.01655626f, 0.12207282f, 0.07851609f, -0.06144167f, 0.07496695f, -0.12320796f, -0.00087135f, 
    -0.11537440f, 0.05168518f, -0.03537045f, 0.09578634f, -0.06378277f, 0.04718566f, -0.10793537f, -0.11092086f, 
    -0.05202831f, -0.09446188f, -0.00190908f, -0.10888621f, -0.03502695f, -0.12231553f, -0.13094762f, 0.10053940f, 
    -0.08723844f, 0.02115338f, -0.12425330f, -0.10840814f, -0.10327001f, 0.11395881f, -0.04597519f, 0.04663633f, 
    0.05478220f, 0.05818811f, -0.01285558f, 0.01125723f, 0.00849964f, 0.05060242f, -0.05439621f, -0.03291756f, 
    0.07496975f, -0.00323228f, 0.05495463f, -0.01522064f, -0.09300063f, -0.11310725f, 0.05467818f, 0.08701948f, 
    0.08469428f, -0.07901652f, 0.00140282f, 0.00986654f, 0.07693991f, -0.06248446f, 0.03872856f, -0.12949026f, 
    0.04672053f, -0.03631720f, -0.06622585f, -0.06293109f, -0.04043960f, -0.09514624f, -0.08239841f, 0.03310117f, 
    0.04933417f, 0.11142729f, -0.10170233f, 0.07258835f, 0.04345147f, -0.02230761f, 0.07745606f, -0.06326702f, 
    0.02373537f, 0.01992501f, -0.01067758f, -0.11045381f, -0.07573291f, -0.01292686f, 0.02961961f, 0.00226448f, 
    0.04121757f, -0.08137181f, -0.05708185f, -0.01726755f, 0.01487743f, -0.03377708f, -0.01242336f, 0.10529397f, 
    -0.11365294f, -0.03313776f, -0.11873625f, 0.09150145f, -0.09910210f, -0.07152259f, -0.07530887f, -0.03043863f, 
    -0.00774818f, -0.09632318f, -0.07631391f, 0.03265640f, 0.05164249f, -0.00195848f, 0.04354026f, -0.07321654f, 
    -0.01711865f, 0.01265895f, -0.02897280f, 0.07398885f, -0.08852682f, 0.02846728f, -0.13204640f, 0.08591862f, 
    -0.01356208f, -0.10303139f, 0.01211092f, -0.12454472f, -0.00845328f, 0.07869942f, -0.09472248f, 0.03825839f, 
    0.09484917f, -0.01012897f, -0.13637821f, 0.07345686f, -0.06624092f, -0.08402203f, 0.00958189f, 0.02683368f, 
    0.00051345f, -0.09395459f, -0.09042555f, -0.13600823f, -0.05343779f, -0.09604442f, -0.06126659f, 0.04171564f, 
    -0.02880905f, 0.07288575f, 0.08899442f, -0.05644623f, -0.03818315f, -0.02797789f, 0.08445204f, -0.01114861f, 
    0.03644691f, 0.04484592f, -0.10545614f, -0.09011725f, -0.10732155f, 0.04041461f, 0.04590896f, -0.09929404f, 
    -0.07861496f, 0.02004601f, -0.15436183f, 0.03616256f, -0.09715084f, 0.02124004f, -0.03113029f, -0.06910806f, 
    -0.04360731f, -0.03803844f, -0.08663975f, -0.07637095f, -0.05379583f, -0.00714858f, -0.00980871f, -0.03771614f, 
    -0.10124123f, -0.03071727f, 0.02490283f, -0.06948125f, 0.07521798f, 0.08163829f, 0.03972780f, -0.00567837f, 
    -0.00806296f, -0.00013507f, -0.11727013f, -0.01695471f, 0.06745826f, 0.10120501f, 0.05061501f, -0.12571791f, 
    0.02715126f, -0.08843717f, 0.03547931f, 0.05861636f, 0.01127676f, -0.04666079f, -0.06198883f, 0.09785813f, 
    -0.01485716f, 0.11961135f, -0.07668388f, -0.01515049f, -0.00893834f, 0.04224911f, 0.04609399f, -0.05402492f, 
    -0.07213278f, 0.08454995f, -0.08156592f, -0.03612907f, 0.11862088f, 0.07634717f, 0.10545325f, -0.00958987f, 
    -0.12285586f, -0.06925902f, -0.08420671f, -0.14422478f, -0.00118426f, 0.00959758f, 0.09730259f, -0.07875703f, 
    -0.09421712f, 0.02848065f, -0.11431028f, -0.02749394f, 0.01412572f, -0.04764549f, 0.04120766f, -0.04573999f, 
    -0.01216067f, -0.08993568f, -0.02677374f, -0.09414037f, -0.14581744f, -0.14096297f, -0.04914675f, -0.08507529f, 
    0.11067688f, 0.06951759f, 0.18098870f, 0.03027354f, 0.00028772f, 0.10827601f, 0.13802555f, 0.06344818f, 
    0.00958029f, 0.07073071f, 0.11877991f, -0.13118789f, -0.07890572f, -0.01239079f, -0.02836931f, 0.11971098f, 
    0.06454030f, -0.17970277f, -0.09038478f, 0.36202696f, 0.17796591f, 0.10624019f, 0.44660926f, 0.11381879f, 
    -0.08057603f, 0.12127297f, 0.05863052f, -0.11266521f, 0.25360724f, -0.21944813f, -0.10170618f, -0.34577125f, 
    -0.27186367f, 0.02662121f, 0.05085545f, 0.10145026f, -0.31112748f, -0.20081951f, 0.17923239f, -0.20305420f, 
    0.08583330f, 0.02918915f, 0.54540998f, 0.01601797f, 0.16675954f, 0.07529322f, 0.37631616f, 0.07065225f, 
    0.16224732f, -0.02324715f, 0.55700839f, 0.14850178f, -0.32665309f, 0.11547582f, 0.35304573f, -0.04100240f, 
    -0.28940204f, 0.13518341f, -0.06042492f, -0.31875065f, 0.30982864f, -0.26554623f, 0.01032044f, 0.04817433f, 
    0.00389320f, -0.03096318f, -0.03752525f, 0.04044126f, 0.02688811f, -0.07871313f, -0.14755163f, -0.10758184f, 
    -0.01690005f, -0.02121518f, -0.02294320f, -0.02435410f, 0.03048448f, 0.05826627f, -0.05285414f, -0.08795822f, 
    0.01302727f, 0.03196783f, -0.16006675f, 0.01784311f, -0.09429147f, 0.07144795f, 0.00240219f, -0.10040596f, 
    0.04362461f, -0.04824463f, -0.07265325f, 0.03985002f, 0.05401886f, 0.06106995f, -0.00361075f, -0.10983154f, 
    0.02880868f, 0.02515649f, 0.03749615f, -0.08078586f, -0.03610707f, 0.01771362f, 0.07457659f, -0.12546754f, 
    -0.06711692f, -0.09991948f, -0.01846284f, 0.04118910f, -0.10290936f, 0.07998401f, -0.00415553f, -0.02889898f, 
    -0.04935340f, -0.10437004f, 0.10155077f, -0.03883161f, 0.00961000f, -0.01642627f, -0.15385142f, -0.08622735f, 
    0.05831076f, -0.02821274f, -0.13215680f, 0.02441247f, 0.05989531f, -0.10101333f, -0.05854970f, 0.11941658f, 
    0.09117335f, 0.18809916f, -0.09874948f, 0.06297365f, 0.01571657f, -0.04245189f, 0.01541860f, 0.10558394f, 
    -0.07556558f, -0.48352158f, 0.00696076f, 0.24796969f, 0.15027748f, -0.08491384f, 0.16094431f, -0.08408606f, 
    -0.07333823f, -0.10463225f, -0.16010249f, -0.26864192f, -0.25714746f, -0.10296444f, 0.02793812f, 0.00802293f, 
    0.12056637f, -0.02376057f, -0.02211504f, -0.11271791f, 0.10030341f, 0.28022218f, -0.09795672f, -0.38495132f, 
    0.15707354f, -0.18526252f, -0.13682540f, 0.29107970f, 0.40667343f, -0.08845230f, 0.04020221f, 0.22717781f, 
    -0.20484516f, -0.15591905f, -0.28277802f, 0.27686149f, 0.17809531f, -0.01656869f, -0.10130969f, -0.09547539f, 
    0.35245359f, 0.16005248f, -0.66333288f, 0.47118089f, -0.09247087f, 0.10150762f, 0.28020269f, 0.00135438f, 
    0.09623705f, -0.00466265f, 0.21094418f, 0.34667143f, 0.48377624f, 0.06325750f, -0.13406242f, 0.00850045f, 
    -0.10562319f, 0.03799963f, -0.03025110f, -0.06828558f, -0.10532051f, -0.00704956f, -0.02064093f, -0.09399241f, 
    0.08993037f, -0.10022001f, 0.01085958f, 0.07272442f, -0.06719938f, 0.02868873f, 0.00781772f, 0.04889344f, 
    0.03873841f, -0.09018876f, -0.08210972f, -0.03599438f, 0.00375853f, -0.11073037f, -0.10356102f, -0.00839785f, 
    0.00816309f, -0.05883615f, 0.03125945f, -0.04536505f, 0.02678694f, 0.05630025f, -0.13635002f, 0.09338974f, 
    -0.12680458f, -0.03494117f, -0.01688784f, -0.00312751f, -0.14176345f, -0.04567746f, 0.03074870f, -0.08443210f, 
    -0.08455002f, -0.02780882f, -0.00318703f, -0.01445306f, -0.13081148f, 0.04540242f, -0.01048788f, 0.04243037f, 
    0.09002370f, -0.08268906f, 0.01554073f, -0.12867087f, -0.06866959f, 0.10285644f, -0.13045579f, 0.00814351f, 
    0.07040183f, -0.04269252f, 0.03107698f, -0.05123584f, -0.11310855f, -0.09998040f, -0.09653178f, 0.00004104f, 
    -0.04087074f, -0.08731329f, -0.10279240f, -0.12218174f, -0.11432902f, 0.05618180f, -0.07728788f, -0.08767793f, 
    -0.11919397f, -0.10835264f, -0.12403761f, 0.01329361f, -0.09997778f, 0.08294083f, -0.06338212f, 0.07482853f, 
    -0.08229703f, -0.09160417f, 0.09597111f, -0.05242023f, -0.08876698f, 0.09337006f, -0.04518293f, 0.02726577f, 
    0.03569871f, 0.08803697f, -0.06385526f, 0.05708763f, 0.04308683f, 0.02165124f, -0.09983481f, -0.08103517f, 
    0.05173258f, 0.09541729f, -0.03836910f, 0.06008736f, -0.01500377f, -0.01811466f, 0.00373957f, -0.12053524f, 
    0.02946916f, -0.07877938f, -0.09192465f, -0.00826244f, -0.04577227f, 0.09399046f, -0.03531680f, 0.00198112f, 
    -0.12755913f, 0.04898734f, 0.02061036f, -0.03535093f, 0.06673811f, -0.00722690f, -0.08749749f, -0.07664161f, 
    0.02247049f, -0.07637854f, -0.02675869f, 0.08215619f, 0.11263496f, 0.07528850f, -0.12434909f, -0.06618346f, 
    0.04604451f, -0.30785185f, -0.05196612f, 0.19596744f, -0.08678409f, -0.05803382f, 0.05598839f, 0.07838586f, 
    -0.02932420f, -0.36921746f, -0.12724037f, 0.16518879f, 0.30713412f, 0.05543426f, -0.46869412f, -0.08606958f, 
    -0.05835779f, 0.45158044f, 0.15381700f, -0.38765046f, 0.08331928f, -0.49924815f, 0.17609544f, -0.11437163f, 
    0.08973788f, -0.07846719f, -0.11942761f, 0.06846626f, 0.05019402f, -0.44546205f, -0.08510694f, 0.07090040f, 
    -1.62651968f, 0.05671662f, -0.53424877f, -0.08517596f, 0.40210846f, 0.11140474f, 0.41373512f, 0.07313778f, 
    -0.25219396f, -0.10066157f, -0.11701481f, 0.14698237f, 0.06795699f, -0.14515580f, -0.09399119f, 0.05120063f, 
    0.36525398f, 0.01217348f, 0.06475003f, 0.20688798f, 0.06868558f, -0.05457251f, 0.17641914f, -0.02183247f, 
    -0.33853185f, -0.00209417f, 0.24962415f, 0.11580167f, -0.04738658f, 0.36900073f, -0.07894947f, -0.42956796f, 
    0.06867346f, 0.32861993f, 0.08780777f, -0.39173013f, -0.11050487f, 0.11511093f, -0.13120745f, 0.02679419f, 
    0.00270481f, -0.19634484f, -0.03707949f, -0.05706419f, 0.47275376f, -0.25446871f, 0.18806903f, 0.33893457f, 
    -0.02589718f, 0.07816903f, -0.00822041f, 0.00797351f, -0.78638297f, 0.16997698f, -0.57196343f, -0.12832312f, 
    -0.04977844f, 0.01341897f, -0.06237794f, 0.18741392f, -0.18504585f, 0.48991117f, -0.07405891f, -0.52317876f, 
    0.37813756f, -0.16048150f, 0.26740551f, -0.07448725f, 0.16271476f, -0.22120483f, 0.04071081f, 0.26796350f, 
    0.04873446f, 0.33112669f, -0.26226646f, 0.27986509f, 0.02496327f, 0.29626891f, -0.51069218f, -0.12009416f, 
    0.29191861f, -0.34871948f, 0.34096941f, 0.05214949f, 0.32563475f, 0.06205102f, -0.28526184f, 0.38759553f, 
    0.22616518f, 0.21025342f, 0.35242471f, -0.07533773f, -0.11673688f, -0.18926002f, -0.24924177f, 0.11291665f, 
    -0.04804434f, 0.15489843f, -0.37754720f, 0.13391031f, 0.36747846f, 0.08383217f, 0.04720558f, 0.07023175f, 
    0.12912406f, -0.12690616f, 0.14424235f, -0.06789984f, 0.05153769f, 0.03001780f, 0.23876154f, 0.08884691f, 
    0.04247798f, -0.51690811f, 0.10524119f, -0.27968624f, 0.01662540f, -0.01315808f, 0.03705035f, 0.09563691f, 
    0.07669835f, -0.06139195f, -0.06192069f, 0.23929548f, -0.08256744f, 0.00871697f, 0.12967902f, -0.13184628f, 
    -0.09836438f, 0.29322660f, 0.18445724f, -0.00370998f, -0.03984583f, 0.08424084f, 0.21628141f, 0.08729104f, 
    0.13440223f, 0.03675946f, -0.14105915f, 0.09548928f, -0.00845022f, -0.29002947f, -0.25688663f, 0.04271645f, 
    0.21840207f, 0.49317309f, -0.09849904f, -0.37977126f, 0.21103165f, -0.05907576f, 0.04860735f, -0.04383770f, 
    0.11535597f, 0.01743776f, 0.17584068f, 0.05218842f, -0.27641141f, 0.47842687f, 0.00020626f, 0.07013211f, 
    -0.11910467f, 0.22595051f, 0.16629234f, 0.00518615f, -0.06922235f, -0.00133602f, -0.07742696f, 0.08629909f, 
    -0.04043505f, 0.10840446f, 0.01536750f, 0.09645846f, 0.28502288f, 0.20342319f, 0.04118362f, -0.02971432f, 
    0.08345778f, -0.09445941f, -0.00976369f, 0.15012516f, -0.08011144f, 0.08128911f, -0.20446786f, -0.21787831f, 
    0.09950988f, 0.06293249f, -0.09506150f, 0.14367303f, -0.01003469f, 0.06796808f, 0.23629490f, -0.16791865f, 
    -0.13971698f, -0.12582007f, 0.33947858f, -0.07580716f, -0.04828333f, 0.04579580f, 0.21998413f, 0.08646530f, 
    0.24589764f, 0.15595508f, 0.30384120f, -0.20012736f, -0.10922867f, 0.03002866f, -0.22966412f, -0.10305311f, 
    -0.02682857f, 0.17324838f, -1.13533700f, -0.33801410f, 0.00361528f, -0.13080139f, -0.17960733f, 0.23421836f, 
    -0.16639417f, -0.04388379f, 0.10497075f, -0.26813474f, -0.31060714f, 0.48546222f, 0.37410375f, 0.28300253f, 
    -0.00075139f, 0.02569672f, 0.05511242f, -0.11746992f, 0.08871746f, 0.01791908f, -0.06320903f, -0.09909664f, 
    -0.10667861f, -0.05338917f, 0.06774440f, 0.21819411f, 0.18186548f, 0.07219215f, 0.15724890f, 0.25681198f, 
    -0.00016905f, -0.18458180f, -0.01580960f, 0.13139357f, -0.14947994f, 0.18548194f, -0.39192143f, 0.08616836f, 
    -0.03897684f, -0.01629111f, -0.08312600f, -0.04079519f, -0.14553721f, 0.30403012f, 0.06197712f, -0.03810374f, 
    -0.20067464f, 0.14907345f, 0.20192514f, -0.00417679f, 0.12240979f, 0.11929978f, -0.05609776f, 0.17915258f, 
    0.08462312f, 0.25331491f, -0.32645699f, -0.18480466f, -0.02885729f, -0.29057485f, -0.05632730f, 0.10533498f, 
    0.21785600f, 0.45861796f, -0.73011297f, 0.02331693f, 0.48298404f, 0.03192964f, -0.23788607f, 0.05675492f, 
    -0.08779096f, 0.11963592f, -0.04299810f, -0.15574118f, -0.44722563f, 0.32541439f, -0.13515066f, -0.19901292f, 
    -0.03382058f, 0.30287683f, 0.08698672f, -0.01424211f, -0.18238138f, -0.11412153f, -0.14035322f, -0.08921192f, 
    0.14140542f, -0.17597781f, -0.06150362f, 0.05803081f, 0.20968245f, 0.37773341f, 0.29587463f, 0.04063518f, 
    -0.06080830f, -0.49979213f, -0.21249309f, -0.25660351f, -0.21621548f, 0.12371770f, -0.70547730f, -0.29682395f, 
    0.10110635f, -0.01814558f, 0.04621562f, 0.64420354f, -0.14289844f, 0.15081009f, 0.09370258f, -0.10523609f, 
    1.05182302f, -0.02401018f, 0.38129097f, 0.24564777f, 0.50928706f, 0.15208779f, -0.07615733f, 0.45956540f, 
    0.12980218f, 0.03136654f, -0.31643498f, -0.38292563f, 0.04943084f, 0.04174761f, -0.10518051f, -0.05663409f, 
    0.12898605f, -0.17566621f, -0.42821866f, -0.28467917f, 0.48787373f, 0.02819889f, -0.65224522f, 0.07365663f, 
    0.66259372f, -0.16088505f, -0.19232273f, -0.02161339f, -0.11472205f, 0.26772311f, -0.08529250f, 0.15059805f, 
    -0.05535138f, 0.33261263f, 0.34635267f, -0.23214433f, -0.09682350f, 0.05986445f, 0.08279313f, -0.05076784f, 
    0.06390934f, -0.04185741f, -0.06103313f, 0.35571694f, -0.17898133f, 0.13750865f, 0.00474210f, 0.08322348f, 
    0.00677800f, -0.30207342f, 0.07113253f, 0.07588051f, 0.14267461f, 0.27961874f, -0.21500900f, 0.02035922f, 
    -0.09243682f, 0.05243623f, 0.14952964f, 0.21749049f, 0.14892603f, -0.06410442f, 0.44390017f, -0.19371536f, 
    0.02637404f, -0.12583026f, 0.04925437f, 0.19358088f, 0.10819191f, 0.01793540f, 0.04399410f, -0.00000149f, 
    0.13524245f, -0.11884931f, -0.05316410f, -0.08390508f, 0.17020699f, -0.04665830f, 0.14939398f, 0.02063888f, 
    -0.00265366f, 0.04275404f, -0.63819969f, -0.08154298f, -0.23153815f, 0.06546398f, 0.04123621f, -0.07390068f, 
    0.35323700f, 0.01191546f, 0.05954788f, -0.05765710f, 0.28682730f, 0.02539076f, 0.34916794f, 0.19736423f, 
    -0.11098680f, 0.18940049f, 0.39413241f, 0.16298908f, -0.03414408f, 0.07406181f, -0.00530039f, 0.09975842f, 
    -0.01842162f, 0.10137173f, 0.19285496f, 0.18914075f, 0.14826274f, -0.52247190f, -0.09255117f, 0.19882834f, 
    -0.11388159f, -0.33425531f, 0.13174668f, 0.10494310f, -0.25736681f, 0.02974023f, -0.07935347f, 0.17615089f, 
    0.08941355f, -0.02976327f, -0.02432126f, -0.23131531f, 0.25605446f, 0.07112361f, -0.17848574f, 0.07516038f, 
    -0.14680153f, -0.05853666f, -0.22548556f, 0.15361963f, -0.17853828f, -0.20391926f, 0.14074187f, -0.03706728f, 
    -0.12588064f, 0.02888092f, 0.33830357f, 0.57694936f, 0.20434049f, 0.24431488f, -0.17592739f, -0.04807799f, 
    0.27718303f, -0.01373793f, -0.10464504f, 0.29321769f, -0.09743399f, 0.09621934f, 0.44613436f, 0.12324564f, 
    -0.45922256f, 0.20469643f, 0.42091712f, 0.11503882f, 0.10750263f, -0.08566285f, -0.06912115f, 0.06739113f, 
    0.05281727f, 0.02480282f, -0.05790187f, -0.12348776f, -0.09781916f, 0.05778694f, 0.15492722f, 0.13229327f, 
    -0.03719313f, 0.21795058f, -0.27519917f, 0.02520017f, -0.16979790f, 0.10006008f, 0.46775606f, -0.12383208f, 
    0.01471390f, -0.35974625f, -0.25769329f, 0.06425288f, 0.37027308f, 0.32702929f, -0.18638286f, -0.25902459f, 
    0.06666758f, 0.06069489f, -0.03406411f, 0.43589717f, 0.32532579f, -0.26983961f, 0.45313361f, 0.10051268f, 
    0.24481493f, 0.14902000f, 0.25509512f, 0.09992960f, -0.11943802f, 0.23905472f, 0.08452269f, -0.29137281f, 
    0.18147448f, -0.34467992f, 0.16095692f, -0.07340934f, 0.34686884f, 0.26443288f, 0.34492385f, 0.06612910f, 
    -0.11803134f, 0.05359419f, 0.99981219f, -0.12460378f, -0.30394655f, -0.00094302f, -0.22336261f, -0.25866231f, 
    0.36635834f, 0.06733253f, 0.02258456f, -0.02258249f, -0.07737698f, 0.00114019f, 0.10867162f, 0.35168889f, 
    -0.10811594f, 0.25342044f, 0.22446875f, -0.53473204f, -0.02493981f, 0.04607841f, -0.24089994f, -0.09523696f, 
    0.04077916f, 0.27272591f, -0.30914015f, 0.21168670f, 0.25336611f, -0.31939983f, 0.22204235f, -0.14194320f, 
    0.07682979f, -0.00391856f, -0.12796648f, 0.37119436f, -0.25965613f, 0.21758574f, -0.34280595f, -0.09414911f, 
    0.11519428f, 0.05662960f, -0.07249830f, 0.27408281f, 0.23775524f, 0.13332105f, 0.45981789f, -0.77754974f, 
    -0.04973619f, 0.07616768f, 0.49861300f, 0.01874919f, -0.47956029f, -0.11544362f, 0.22982952f, -0.21800970f, 
    0.17423247f, -0.11223996f, 0.36374655f, 0.09805910f, 0.06742433f, 0.76724607f, -0.07207320f, 0.07549695f, 
    -0.32661712f, 0.17646408f, 0.34984535f, -0.04661530f, -0.26791584f, -0.08944331f, 0.11018569f, -0.02354163f, 
    0.07319944f, 0.10053128f, 0.13738824f, -0.18151636f, -0.03241752f, 0.43080139f, 0.48444867f, 0.24320352f, 
    -0.01705730f, -0.04348802f, -0.05197131f, -0.12622003f, -0.02842498f, 0.04824258f, -0.00533617f, 0.06269208f, 
    -0.01436429f, -0.00025619f, -0.11215942f, 0.00434009f, -0.07586680f, -0.12780735f, -0.02832864f, -0.00559407f, 
    0.02534553f, 0.10479752f, -0.15760195f, 0.08733451f, -0.03809633f, -0.13827652f, -0.07776328f, 0.01653706f, 
    -0.05072038f, -0.06013817f, 0.10519676f, 0.05382010f, -0.02363683f, -0.01922135f, 0.04231130f, -0.00032951f, 
    0.11992434f, 0.00831752f, -0.11460204f, -0.13379693f, 0.03298848f, 0.07238223f, 0.02685194f, 0.07243893f, 
    0.04099010f, -0.03409033f, -0.07670794f, -0.11461290f, 0.08839582f, -0.03875154f, -0.13604133f, 0.09096883f, 
    -0.08474799f, -0.08083150f, 0.01142223f, 0.09223218f, 0.04999850f, -0.01541176f, 0.00040282f, -0.05411469f, 
    -0.10165256f, -0.00076943f, -0.11494859f, 0.04105636f, -0.00570305f, 0.02501850f, -0.06831199f, -0.02666044f, 
    -0.09002534f, 0.06671154f, 0.14989321f, -0.91093612f, -0.05202261f, -0.04216394f, -0.14310050f, -0.12364532f, 
    -0.00323019f, 0.39790541f, -0.09249020f, -0.04941053f, 0.20599118f, -0.43733519f, -0.06652935f, -0.05694498f, 
    -0.07351620f, 0.02001899f, -0.23631725f, 0.25071052f, -0.06201573f, -0.03889744f, -0.16521806f, 0.00490899f, 
    -0.10081534f, -0.08554493f, -0.07132535f, -0.11263566f, -0.02777313f, 0.15974897f, 0.09465851f, 0.23599918f, 
    0.20473447f, 0.01092765f, 0.13789137f, -0.21540663f, -0.43986475f, -0.01456814f, 0.28104427f, -0.25519171f, 
    0.08146184f, 0.01461573f, 0.22414887f, 0.14442383f, 0.01425789f, 0.26311859f, -0.00783101f, 0.08453709f, 
    -0.04283316f, 0.30819535f, 0.56818485f, 0.00045954f, 0.06960312f, 0.03253562f, 0.09893037f, 0.13231793f, 
    -0.05869460f, 0.24327366f, 0.26242632f, -0.58075100f, 0.01976883f, 0.18310815f, -0.06679440f, 0.07006492f, 
    -0.08523940f, 0.30496123f, 0.44364944f, -0.21994668f, -0.01036698f, -0.02470800f, 0.15988322f, -0.01288480f, 
    -0.00812697f, -0.17439039f, 0.01537447f, 0.11988916f, -0.19353770f, 0.05459729f, -0.04659549f, 0.02251587f, 
    -0.04390366f, -0.12859198f, 0.00962982f, 0.16325131f, -0.30389234f, 0.31322208f, -0.42783207f, -0.01422431f, 
    -0.03554213f, 0.06680581f, -0.02689089f, 0.11208770f, 0.03005419f, 0.18013535f, 0.20965575f, -0.04001851f, 
    -0.06716947f, -0.28796679f, 0.18448725f, 0.28755438f, 0.02392925f, -0.01258058f, -0.40047199f, 0.21572860f, 
    0.12224744f, 0.09046460f, -0.43919772f, -0.20849156f, 0.11294844f, -0.07703920f, -0.00669684f, -0.03862552f, 
    0.14470682f, 0.04401399f, -0.93403351f, 0.09958719f, -0.10058955f, 0.00524033f, -0.34218603f, -0.08264905f, 
    0.30391800f, -0.09850665f, -0.17263336f, 0.01698091f, 0.40419385f, 0.17731829f, 0.17144300f, 0.17481367f, 
    0.08457708f, -0.07354626f, 0.05007462f, -0.02395237f, 0.05870139f, 0.06825568f, -0.06122590f, 0.02146432f, 
    0.00989437f, -0.05416796f, 0.04262380f, 0.06478964f, 0.02437665f, -0.03089680f, -0.05395297f, 0.00786004f, 
    0.03673099f, -0.06476016f, -0.11654872f, -0.12628758f, -0.05769018f, 0.10122888f, -0.05731070f, 0.00124079f, 
    0.08784063f, 0.05725543f, -0.11305487f, -0.11454308f, 0.12006824f, -0.04208333f, 0.00999308f, 0.08595603f, 
    -0.06554411f, -0.04136457f, 0.00041654f, -0.11528524f, 0.02075561f, 0.04531611f, -0.14455412f, -0.14584570f, 
    -0.07534866f, -0.12251856f, -0.11338925f, -0.13270316f, -0.07033682f, -0.06815781f, 0.06205845f, 0.10422981f, 
    -0.06236021f, -0.13217279f, 0.11543408f, -0.04041310f, 0.00934736f, 0.03335287f, -0.12434816f, 0.05074937f, 
    0.12102388f, 0.07322971f, 0.05902177f, -0.08948962f, 0.05214581f, -0.08706059f, -0.10456854f, -0.01407157f, 
    0.03724869f, 0.21653488f, -0.61284155f, 0.04047279f, 0.06664225f, -0.10761215f, -0.08147783f, -0.10241677f, 
    0.08798531f, -0.65041214f, -0.14303291f, -0.10278691f, 0.05575590f, 0.03726989f, 0.13486633f, 0.00019181f, 
    0.06829119f, 0.78477341f, 0.10739104f, -0.01103635f, -0.09693132f, -0.22397697f, -0.05520904f, -0.24883182f, 
    -0.02067891f, 0.06773999f, -0.09994669f, 0.57045031f, -0.15942353f, -0.21551885f, -0.21680291f, 0.05656057f, 
    -1.16487277f, 0.05808129f, -0.52283466f, -0.07168362f, 0.29665220f, 0.02668326f, 0.31088004f, 0.00609965f, 
    -0.13566975f, -0.17481263f, 0.79719371f, -0.29934925f, -0.67037803f, 0.00113162f, 0.04756616f, -0.03523441f, 
    0.42251375f, -0.12010463f, -0.02590536f, -0.06613965f, 0.06233864f, 0.01446319f, 0.21626861f, -0.22112094f, 
    -0.38309264f, -0.23143671f, -0.58638388f, -0.02313778f, -0.38504580f, -0.11427357f, -0.02571258f, -0.31238592f, 
    -0.05227524f, 0.13425462f, 0.36950448f, -0.08431230f, -0.08787968f, -0.04862514f, 0.14432830f, 0.01269107f, 
    -0.10941614f, -0.14843144f, 0.20131788f, -0.06905254f, -0.17606258f, 0.00385707f, -0.11888591f, 0.24116200f, 
    -0.02854013f, -0.08634273f, -0.12920275f, 0.10764149f, -0.12045298f, 0.08486530f, 0.05894254f, 0.09829549f, 
    0.09504990f, 0.04074357f, -0.05390508f, -0.08643208f, 0.10479578f, 0.15517473f, -0.05315941f, 0.23735087f, 
    0.27876592f, -0.39956632f, -0.20217335f, 0.23123382f, 0.41754726f, -0.06106287f, 0.09726927f, 0.06807725f, 
    -0.15674819f, -0.04892704f, -0.13467512f, 0.40617642f, 0.15302099f, 0.15487295f, 0.27440539f, 0.01164821f, 
    0.12269630f, -0.13759850f, -0.03124849f, 0.59109062f, -0.18010725f, 0.10694906f, -0.00393141f, 0.06798494f, 
    -0.08623581f, 0.13312741f, -0.05606884f, 0.02816202f, 0.40316170f, -0.14817296f, -0.12631617f, -0.04946107f, 
    0.11102806f, -0.10531294f, -0.02324942f, 0.04005073f, -0.00923107f, -0.04707600f, -0.05401596f, -0.05238415f, 
    0.04810557f, -0.04712854f, -0.12854841f, -0.13492554f, -0.06585937f, 0.04845111f, -0.07202217f, 0.05440485f, 
    -0.04646823f, 0.06177377f, -0.07180703f, -0.07560506f, 0.03850074f, -0.04103589f, 0.01234811f, 0.09015604f, 
    -0.04647461f, -0.08589810f, 0.05356510f, 0.01072706f, -0.00567285f, -0.04196747f, -0.02355634f, -0.08981719f, 
    0.02837941f, 0.08419944f, -0.13150346f, -0.01358648f, 0.09409402f, 0.10664899f, 0.04048036f, -0.09197430f, 
    -0.01593929f, -0.10468047f, 0.06411208f, -0.05102734f, 0.02313440f, -0.06084518f, 0.03458893f, 0.03093255f, 
    -0.12662458f, 0.06313721f, -0.07853954f, -0.01757323f, -0.00549383f, 0.03207484f, -0.06368450f, 0.01825128f, 
    0.05096356f, 0.09251032f, -0.02628295f, -0.11127429f, -0.07113554f, -0.09651966f, -0.05479037f, -0.06609055f, 
    -0.03088275f, -0.06357101f, -0.08381647f, -0.01546766f, -0.10606290f, -0.10823931f, -0.03266558f, -0.11511403f, 
    -0.02260408f, -0.06970344f, -0.10892302f, -0.05820635f, -0.05099403f, -0.03988323f, 0.05945995f, -0.03142025f, 
    -0.04254273f, -0.01987635f, -0.13600154f, 0.07016933f, -0.05492486f, 0.04346297f, -0.10601570f, -0.12407850f, 
    -0.05764635f, -0.12247013f, 0.00220426f, 0.07663357f, 0.03803686f, -0.12388707f, 0.03230493f, -0.03133227f, 
    0.06651484f, 0.05019252f, 0.04147954f, -0.07386281f, -0.13104668f, 0.02668132f, 0.08706445f, -0.11778355f, 
    0.05332796f, -0.16062953f, -0.03428480f, 0.02267576f, -0.10462750f, 0.02035467f, -0.12411259f, -0.04096532f, 
    -0.15609561f, -0.14673634f, -0.07924643f, 0.01923236f, 0.09013470f, -0.08046857f, 0.07245399f, -0.06861730f, 
    0.00959624f, -0.13823207f, -0.10537588f, -0.05540862f, -0.04062662f, -0.13303116f, -0.06221398f, -0.09765543f, 
    0.08921102f, -0.02698338f, 0.31008822f, 0.10265671f, 0.02438685f, -0.05079831f, 0.17342880f, 0.06452672f, 
    0.12950180f, -0.03866624f, 0.15402988f, 0.26796791f, -0.19553177f, -0.08111513f, 0.02286517f, 0.08568873f, 
    -0.00449684f, -0.19504559f, -0.17095065f, 0.09409735f, 0.11120065f, 0.03435459f, 0.13032426f, 0.06503437f, 
    -0.12802707f, -0.04147035f, -0.00934284f, 0.02867870f, 0.32166401f, -0.25037143f, -0.23527054f, -0.07726040f, 
    0.15573387f, 0.26019269f, 0.05928268f, 0.22574702f, 0.11714964f, 0.17152172f, 0.23719910f, 0.06897916f, 
    -0.03256401f, -0.16404356f, 0.37737507f, 0.20930462f, 0.29306045f, -0.04445293f, 0.32955584f, -0.01628828f, 
    0.16255903f, 0.09363838f, -1.03863263f, -0.06052171f, -0.32402444f, -0.08036526f, 0.24958062f, -0.06704204f, 
    -0.18832064f, 0.02649349f, -0.15682985f, -0.17062838f, -0.62314856f, 0.17559339f, 0.09784231f, 0.35993314f, 
    0.10301068f, 0.17398000f, 0.01278313f, -0.30284795f, 0.33638811f, -0.12171556f, 0.10604773f, -0.10394157f, 
    0.08846548f, -0.32512832f, -0.09891780f, 0.17384467f, -0.07271609f, -0.30607554f, 0.01707601f, 0.15729527f, 
    -0.05014047f, -0.33923614f, 0.07847229f, -0.17383929f, -0.17319497f, -0.00591338f, -0.27112752f, 0.03885530f, 
    -0.05292485f, 0.02449793f, 0.07370551f, -0.21044272f, -0.04409122f, 0.10980251f, 0.15791100f, -0.27176219f, 
    0.12202000f, -0.23462641f, -0.03569934f, 0.05926874f, 0.24806657f, 0.07232458f, -0.29723504f, 0.42059928f, 
    0.08667605f, 0.01821137f, -0.30206713f, 0.06523489f, 0.07570684f, -0.16899703f, 0.11430695f, 0.04630157f, 
    0.39315388f, 0.13708313f, -0.89065075f, 0.21640846f, -0.00308710f, 0.09828064f, 0.02702381f, -0.16132623f, 
    0.03036933f, 0.03416160f, 0.18492152f, -0.05661570f, 0.12287559f, 0.21372013f, 0.22088000f, -0.13830656f, 
    0.06188439f, 0.03325581f, -0.07722985f, 0.37861207f, 0.19112378f, 0.10413264f, -0.01182262f, -0.06509346f, 
    -0.03761012f, 0.05084910f, -0.57051623f, 0.08507159f, -0.06445711f, 0.03166312f, 0.14700513f, -0.62633872f, 
    0.02465849f, -0.11196403f, -0.74765182f, -0.02185582f, 0.03020285f, 0.10221410f, -0.17726526f, -0.69700527f, 
    -0.03449176f, -0.03122588f, 0.09969324f, 0.18531945f, 0.10785710f, -0.15691899f, 0.10167320f, -0.14973290f, 
    -0.04811824f, 0.01895070f, 0.14460517f, -0.05013329f, -0.24576789f, 0.01301028f, 0.11192286f, -0.33985525f, 
    0.03213448f, -0.62954491f, 0.24152319f, -0.08736472f, -0.08634765f, -0.04640094f, 0.01208278f, -0.09309578f, 
    -0.40505239f, 0.06602721f, 0.87809354f, -0.27893758f, -0.19807675f, 0.08586369f, 0.19483772f, -0.11534900f, 
    0.00370110f, -0.09151971f, 0.17622802f, 0.70944953f, 0.03792778f, 0.11626581f, 0.21799129f, 0.13192099f, 
    -0.02388839f, 0.03681401f, 0.09426171f, 0.36848655f, -0.13213272f, -0.06704721f, -0.09883048f, 0.02728818f, 
    -0.05909243f, 0.22664048f, -0.20398864f, 0.03505566f, 0.34473905f, 0.10692269f, 0.33035037f, -0.01324029f, 
    0.04738593f, -0.23606606f, -0.19028378f, -0.03248598f, 0.22134773f, 0.20221907f, -0.09989030f, -0.18531425f, 
    0.04870633f, -0.10980029f, 0.14807510f, 0.45773256f, 0.15453103f, -0.31457797f, 0.26598427f, -0.23037195f, 
    0.12427304f, -0.10837904f, 0.46769667f, -0.13654542f, -0.51415396f, 0.11621986f, 0.42880842f, -0.43136686f, 
    0.28558129f, 0.02293567f, 0.41323245f, 0.01613347f, -0.09751119f, 0.34510189f, -0.14557494f, 0.12039343f, 
    -0.28529906f, 0.02087319f, 0.99471921f, -0.31252444f, -0.25923952f, -0.12372756f, 0.13822114f, 0.33406705f, 
    -0.05849728f, 0.11009715f, -0.01506728f, -0.22916454f, -0.22409755f, 0.16178092f, 0.21809025f, 0.50863016f, 
    0.01081072f, -0.01694569f, -0.18608247f, -0.28456402f, 0.19524781f, -0.02287164f, -0.14537279f, 0.04940945f, 
    0.00170541f, -0.04964497f, 0.08025399f, 0.30848181f, 0.20211278f, -0.29774293f, 0.10631216f, 0.09610344f, 
    0.07502773f, -0.40965244f, 0.02988508f, 0.11625403f, 0.01693488f, -0.02306696f, -0.13499404f, 0.12433964f, 
    -0.05866776f, -0.10803372f, 0.10177363f, 0.19608833f, -0.19216987f, 0.12721337f, 0.10612772f, -0.18516326f, 
    -0.16284995f, -0.08102909f, -0.00545466f, -0.12160596f, 0.14543003f, 0.07508728f, -0.03536404f, 0.21400523f, 
    0.28621241f, 0.15361597f, -0.22428004f, -0.08008851f, 0.07352012f, -0.35869575f, -0.05313241f, 0.07841635f, 
    0.26198110f, 0.69472313f, -0.42300937f, -0.13498238f, 0.33295783f, -0.03477316f, -0.07090789f, -0.05425617f, 
    0.23892525f, 0.18381968f, 0.05490467f, -0.12502649f, -0.41050652f, 0.28828925f, 0.04757234f, -0.19339354f, 
    0.03214021f, -0.00383719f, 0.02906187f, 0.06117089f, -0.07100170f, 0.11575519f, 0.01534831f, -0.08398725f, 
    -0.02248295f, -0.03916451f, 0.10652078f, 0.26132584f, 0.02535714f, 0.19427831f, -0.15657955f, -0.10281795f, 
    -0.10640001f, 0.21133530f, 0.03218637f, -0.11521593f, -0.14104591f, -0.17099828f, 0.27488884f, -0.00393484f, 
    -0.11419524f, 0.04057585f, 0.04046530f, -0.23118773f, 0.05857350f, -0.06650268f, -0.09930193f, -0.40458521f, 
    -0.16121502f, -0.00736341f, 0.10359387f, -0.03488519f, 0.13434088f, -0.03873850f, 0.13385379f, 0.21883552f, 
    0.08931556f, -0.01872065f, 0.28051475f, -0.01726812f, -0.11450040f, -0.11626800f, 0.08018550f, 0.11732006f, 
    0.27853104f, 0.25315395f, -0.91022193f, 0.06402957f, -0.09427515f, 0.04806305f, 0.55908877f, -0.13356790f, 
    -0.04531446f, 0.04858029f, 0.28442666f, -0.13724226f, 0.27314585f, 0.46747008f, 0.30175954f, 0.00875296f, 
    0.08040333f, -0.01991698f, 0.11910579f, 0.19437134f, 0.00749020f, -0.11178082f, 0.32767284f, 0.01423244f, 
    0.08125833f, -0.26271293f, -0.09936672f, 0.31900725f, -0.15291387f, 0.09481336f, -0.10312713f, -0.09619366f, 
    -0.09829941f, -0.41567704f, 0.00708325f, -0.17601226f, 0.04185086f, -0.27615511f, 0.48211798f, 0.06985217f, 
    -0.04900542f, 0.01072785f, 0.09451619f, -0.21338178f, 0.02871780f, -0.07385307f, -0.01046244f, -0.22942600f, 
    0.23064505f, 0.25151849f, 0.10381405f, 0.11213576f, 0.38950408f, 0.13152798f, -0.00666009f, 0.26310465f, 
    -0.25413841f, -0.04620406f, 0.17835873f, 0.23670229f, -0.03244843f, -0.06011726f, 0.25328952f, 0.05173383f, 
    0.15828243f, 0.16851740f, -0.70489085f, 0.14562219f, -0.24577151f, -0.02287900f, 0.32558334f, -0.16742872f, 
    -0.07165214f, 0.05112849f, -0.08237967f, -0.05492659f, 0.40221924f, 0.16783024f, 0.19822423f, 0.02052375f, 
    0.01620260f, 0.24332887f, -0.39568245f, 0.24993017f, 0.08867377f, 0.04269642f, 0.05599955f, -0.07948325f, 
    0.13387214f, -0.04338779f, 0.06237021f, -0.00757351f, 0.26810738f, 0.15726741f, 0.43946865f, 0.04289746f, 
    -0.10662821f, -0.48246413f, -0.02394764f, -0.32064974f, -0.02160902f, -0.09942925f, -0.00864608f, -0.03017220f, 
    -0.03968960f, -0.07415320f, -0.00293217f, 0.41356668f, -0.12050325f, 0.24269736f, 0.22191724f, 0.01555201f, 
    0.27454352f, -0.03575972f, 0.06466261f, 0.18246733f, 0.16659650f, 0.18091679f, 0.08870059f, 0.22275968f, 
    -0.03040182f, 0.14301661f, -0.53664631f, 0.00875077f, -0.00184192f, -0.00523107f, -0.22412944f, -0.08198974f, 
    0.03542036f, -0.09945882f, -0.42432281f, -0.40470833f, 0.29718813f, 0.04580853f, -0.36491558f, 0.27969876f, 
    0.36469769f, -0.11945435f, 0.20665461f, 0.18141225f, -0.54461253f, 0.22267376f, 0.09319389f, 0.13056910f, 
    0.01824553f, 0.27767238f, 0.28836265f, -0.47459501f, 0.13279839f, 0.10247257f, -0.04563525f, -0.09213827f, 
    -0.05797035f, -0.30308497f, -0.02636684f, 0.21686764f, 0.25825453f, -0.53336012f, 0.19359681f, 0.20623533f, 
    0.12194231f, 0.26915917f, -0.19456705f, 0.02777018f, -0.64585578f, 0.15219659f, -0.50593293f, 0.07111572f, 
    -0.01384499f, 0.12184665f, 0.03649089f, -0.28640419f, 0.06602496f, 0.64832050f, -0.03901076f, -0.58247638f, 
    0.30485305f, 0.18399177f, 0.10036093f, 0.13047367f, 0.33401480f, -0.33314213f, -0.33099383f, 0.35209614f, 
    -0.13254863f, -0.06780284f, 0.04190835f, 0.33599684f, 0.36263186f, 0.30772907f, -0.11520038f, -0.07474951f, 
    0.41037229f, -0.33201137f, -0.14560585f, 0.45598376f, -0.06745582f, 0.10692678f, -0.01936807f, -0.03332612f, 
    0.06722388f, 0.24108468f, 0.25698176f, 0.15963969f, -0.00512012f, -0.11199170f, -0.18324088f, 0.16728525f, 
    -0.00788116f, 0.41317782f, 0.24557778f, -0.62380767f, -0.22867244f, 0.03666849f, -0.04511554f, -0.00332503f, 
    -0.01208998f, -0.03800368f, -0.09333344f, 0.00682542f, -0.06941178f, -0.11993060f, 0.14715001f, 0.16061446f, 
    -0.01440173f, -0.03078387f, -0.10937504f, 0.19422178f, -0.20097406f, 0.29391283f, -0.14168885f, -0.10363802f, 
    0.08329914f, -0.09599762f, -0.04977480f, 0.49247560f, 0.26779154f, -0.03662192f, 0.03541354f, 0.30281371f, 
    0.47964716f, 0.14321537f, -0.04323677f, 0.29563904f, 0.16077557f, 0.04240999f, 0.02756643f, -0.12641604f, 
    0.00271011f, -0.07445891f, -0.30124527f, 0.22240295f, 0.17658629f, 0.56132007f, 0.21088834f, -0.03314947f, 
    0.12974314f, -0.24826589f, 0.62346905f, 0.30620104f, -0.07216927f, 0.05786311f, -0.52402431f, -0.09543850f, 
    0.37333572f, -0.00391428f, -0.14058204f, -0.19155736f, 0.04740994f, -0.48811758f, -0.24089611f, -0.00274454f, 
    -0.08155558f, -0.13849604f, 0.15554637f, 0.25554368f, -0.01823844f, 0.11588654f, 0.09230860f, 0.04982039f, 
    0.03141896f, -0.04096230f, -0.05528919f, 0.15862252f, 0.25773332f, -0.11137251f, -0.16291484f, 0.16144079f, 
    0.11816116f, 0.51207912f, 0.11867999f, 0.27615020f, 0.04133612f, -0.02714472f, 0.25431901f, 0.03434028f, 
    0.03136868f, -0.06304090f, -0.13832583f, -0.17555335f, 0.09781577f, -0.14066091f, -0.04296866f, -0.15518759f, 
    -0.58239412f, 0.12327322f, 0.13457027f, 0.04677683f, -0.17840488f, -0.20809256f, 0.29733199f, 0.09206413f, 
    0.07065793f, 0.15949965f, 0.23132947f, 0.06277113f, 0.06189392f, 0.06817553f, -0.09985714f, 0.02924578f, 
    0.32818615f, 0.10142592f, -0.22618592f, -0.11772840f, -0.03377438f, 0.10592294f, 0.37364393f, -0.08499747f, 
    -0.46203277f, 0.00980123f, 0.06759217f, -0.31565526f, -0.01665574f, 0.09172588f, -0.01943217f, 0.04533812f, 
    0.11020945f, 0.12696947f, 0.13243206f, 0.09917956f, 0.03608795f, 0.01779093f, 0.09256112f, -0.07962293f, 
    -0.01585007f, 0.11199810f, -0.11266446f, -0.10976639f, -0.07011663f, 0.25606620f, 0.06101830f, -0.10870481f, 
    0.09933938f, 0.41186205f, -0.07779903f, 0.14835049f, 0.01691740f, 0.17363140f, 0.08818813f, -0.04818154f, 
    -0.06237056f, -0.05241969f, -0.01532590f, 0.55718428f, 0.21513638f, -0.21614236f, 0.26102754f, -0.08393485f, 
    0.28591695f, 0.66675526f, 0.41090864f, 0.08200260f, -0.18147323f, 0.14083201f, 0.17027681f, 0.15346235f, 
    0.26988932f, 0.14439781f, 0.07106392f, -0.23313253f, 0.02231958f, 0.20987765f, 0.02090362f, 0.07024211f, 
    -0.13577400f, -0.14690103f, 0.35494143f, -0.27265030f, 0.07900675f, -0.00251513f, -0.17410398f, 0.10123026f, 
    0.49230486f, -0.02306516f, -0.07251325f, -0.05475663f, 0.12201250f, 0.35503194f, 0.21312545f, 0.22315742f, 
    -0.00551787f, 0.35014436f, -0.08160666f, -0.12466092f, -0.32467669f, 0.09732643f, -0.20223314f, 0.05437209f, 
    -0.10047957f, -0.15202905f, -0.11103259f, -0.29151413f, 0.47836450f, 0.12054099f, 0.20301419f, 0.30139115f, 
    0.00910082f, 0.45680499f, -0.02861429f, 0.06328113f, -0.57095498f, -0.04160156f, -0.32489893f, -0.07991654f, 
    0.01278511f, 0.04145354f, 0.05222222f, 0.10150163f, -0.12029698f, 0.51093030f, -0.05086633f, -0.65061069f, 
    0.23445228f, -0.11301468f, 0.03195631f, -0.07175282f, 0.04645291f, -0.18636662f, 0.23847184f, 0.16092390f, 
    -0.00382040f, 0.11234387f, -0.26049253f, 0.35451472f, 0.05751443f, 0.38362828f, -0.48594740f, 0.06930202f, 
    0.14077576f, -0.31970003f, 0.90730721f, -0.02114628f, 0.22395445f, 0.02183629f, -0.21136412f, 0.35262445f, 
    0.30937690f, 0.09639701f, 0.25731903f, 0.30512413f, 0.01810569f, -0.27403858f, -0.20056619f, 0.11862250f, 
    -0.02611727f, 0.12912132f, 0.27504003f, 0.07555483f, 0.09160384f, -0.07899742f, 0.15507954f, 0.04576756f, 
    -0.11338396f, -0.08176505f, -0.01150682f, 0.01245708f, -0.23006555f, 0.11460253f, -0.30996516f, 0.02419201f, 
    -0.03286739f, 0.28724459f, -0.00146053f, 0.01746233f, 0.03738240f, 0.13414441f, 0.14279987f, 0.06301452f, 
    -0.07231747f, -0.11123098f, 0.01118928f, 0.16853340f, 0.12279628f, -0.51184529f, 0.13673493f, -0.08192359f, 
    0.08750802f, 0.31452826f, 0.18086250f, 0.22027428f, -0.11768550f, 0.04259795f, 0.03633412f, -0.04023698f, 
    -0.07210810f, 0.04093190f, 0.08118690f, -0.24867526f, 0.01044757f, -0.08581024f, 0.22891183f, 0.06629749f, 
    0.15471424f, -0.04628282f, 0.34862098f, -0.11361405f, -0.27113461f, -0.01075148f, 0.12347542f, -0.17056914f, 
    0.36264420f, 0.02012185f, -0.15743995f, 0.12250800f, 0.61568522f, 0.03719715f, 0.27035558f, 0.31328750f, 
    -0.11432475f, 0.04410025f, 0.04355535f, 0.07551794f, -0.13173066f, -0.04104358f, -0.12051845f, -0.01817743f, 
    0.05454853f, -0.13300341f, 0.02611699f, 0.02461526f, -0.05292273f, 0.06889211f, -0.03888471f, -0.01059482f, 
    0.11192742f, -0.09506398f, -0.05041650f, -0.10587523f, -0.13453259f, -0.01800331f, 0.07768120f, -0.04946814f, 
    -0.02078395f, 0.01432826f, -0.06975757f, 0.00903851f, -0.00480873f, -0.10582881f, 0.03848766f, 0.04637993f, 
    -0.04367460f, 0.07751358f, -0.13345702f, -0.10364540f, -0.10833301f, -0.15664174f, -0.06073039f, -0.04260549f, 
    -0.13464487f, -0.14642964f, -0.05410801f, 0.05765656f, -0.03468273f, 0.08434962f, -0.00445222f, 0.06303263f, 
    -0.15496902f, 0.02214508f, 0.10631628f, -0.15656199f, -0.09359191f, -0.01033644f, -0.08600119f, -0.09678180f, 
    0.10751009f, 0.02412423f, -0.03904772f, -0.09253021f, 0.00153360f, 0.01096205f, -0.12453564f, 0.06117481f, 
    -0.01034282f, -0.11940703f, -0.04370232f, 0.00689000f, -0.06339807f, 0.11924180f, -0.16691184f, 0.00889249f, 
    0.08060975f, 0.37130934f, 0.03772998f, 0.06302105f, 0.30170295f, -0.16598299f, -0.08331558f, -0.04569758f, 
    0.00761645f, 0.25494406f, 0.04884781f, 0.09720360f, 0.19499803f, -0.03225170f, 0.12972568f, 0.07634494f, 
    -0.01601504f, 0.12376313f, -0.02765095f, -0.15647362f, 0.00763082f, -0.10198351f, -0.04647946f, 0.08629195f, 
    -0.51115662f, -0.02410237f, 0.36338827f, -0.22406285f, -0.48756272f, 0.01313988f, 0.23268129f, -0.34447125f, 
    0.28076887f, 0.23691976f, 0.52795887f, 0.09276272f, -0.16539626f, 0.23039384f, -0.15054910f, -0.06643464f, 
    -0.11056561f, 0.31231740f, 0.41810748f, -0.21640955f, 0.08391415f, 0.11522990f, 0.47855562f, 0.08134677f, 
    -0.49227878f, 0.20778440f, 0.16079463f, -0.26813337f, -0.27524814f, 0.45210752f, 0.04789450f, 0.05500688f, 
    -0.08088742f, -0.09143969f, 0.06689119f, 0.05547789f, -0.03943229f, 0.03025798f, -0.08878731f, -0.05158894f, 
    -0.05473420f, -0.03645313f, -0.07055197f, -0.06130211f, 0.00439367f, -0.04230377f, -0.12881634f, 0.04877361f, 
    0.08171624f, 0.10854659f, 0.01528259f, 0.09914725f, 0.00454856f, -0.12834521f, 0.10765064f, 0.07826007f, 
    0.01595725f, 0.06361476f, 0.01075033f, 0.01285337f, 0.09591225f, -0.04966648f, -0.11613105f, -0.00361563f, 
    -0.00684753f, 0.06266584f, -0.10059644f, -0.01880425f, -0.06692030f, -0.12652658f, 0.02943900f, 0.05558882f, 
    -0.08947025f, -0.02693383f, 0.06122258f, -0.11827188f, 0.04740499f, -0.02549441f, 0.02916435f, -0.10963374f, 
    -0.06327413f, -0.06488352f, -0.02638352f, -0.08427183f, -0.00573970f, 0.10988769f, -0.03097454f, -0.03801161f, 
    0.06537644f, 0.02480143f, 0.05278721f, -0.04912796f, -0.07151573f, 0.02792031f, 0.02027226f, 0.08693162f, 
    -0.12022482f, 0.10180598f, 0.19887057f, 0.01779240f, -0.36566594f, 0.08103123f, 0.05217137f, -0.02857614f, 
    0.11725843f, 0.20581686f, -0.09853343f, 0.06272662f, 0.19497174f, 0.44674295f, 0.16549070f, 0.08323870f, 
    0.06136009f, -0.24080832f, -0.17731810f, 0.16957574f, -0.06797665f, 0.22029114f, -0.17354064f, -0.20796770f, 
    -0.03826466f, 0.06296326f, 0.12695596f, 0.76360518f, 0.12099253f, -0.12410334f, 0.32455388f, -0.31950325f, 
    0.47803164f, 0.08154660f, 0.42836580f, 0.11875667f, 0.21173920f, 0.01208823f, 0.18215509f, 0.01868164f, 
    0.22137591f, 0.07971087f, -0.14828886f, -0.25424224f, 0.05312273f, 0.05589788f, 0.07186808f, 0.03773059f, 
    0.05759345f, 0.04921759f, -0.60495943f, -0.30615738f, 0.09411082f, -0.00612834f, -0.31674001f, 0.12010390f, 
    0.62972391f, -0.08127981f, -0.18564060f, -0.31844446f, -0.27737445f, 0.21507652f, 0.07677876f, 0.26377702f, 
    -0.00006281f, 0.07255761f, -0.06720170f, -0.12039472f, -0.06864864f, -0.05091916f, 0.06903523f, 0.04485750f, 
    -0.01949665f, -0.11282644f, -0.00401361f, -0.01570531f, 0.02031348f, -0.12110014f, 0.00673507f, -0.02847417f, 
    -0.10300416f, 0.01521958f, 0.01665880f, 0.02679654f, 0.08814470f, 0.08452155f, -0.05622533f, -0.01642951f, 
    -0.00517139f, 0.05058409f, 0.01061010f, -0.13624720f, -0.03162143f, 0.01733948f, 0.07854056f, -0.05585606f, 
    -0.10123537f, 0.01098869f, -0.10971669f, -0.09264118f, -0.01961124f, 0.05360144f, 0.05839862f, -0.01726459f, 
    -0.07652494f, 0.02732448f, -0.12322839f, -0.10767182f, -0.15614331f, 0.09284399f, -0.12868798f, -0.05527893f, 
    -0.01481566f, -0.05446920f, 0.08757216f, -0.04815775f, -0.01995172f, -0.11314774f, 0.02063885f, -0.01451938f, 
    -0.10427447f, -0.09657039f, -0.13481921f, -0.12809338f, -0.09598325f, -0.01419408f, -0.07495768f, 0.05696903f, 
    -0.05003919f, -0.04873281f, 0.03613290f, 0.05484414f, -0.12146173f, -0.03935203f, 0.07335278f, -0.10600153f, 
    0.09201425f, -0.01374508f, -0.11092835f, 0.09303465f, -0.11248555f, 0.01396387f, -0.02952009f, 0.04945647f, 
    0.04459526f, -0.01867661f, -0.00484020f, 0.07343977f, 0.00699288f, -0.11208956f, 0.01749832f, 0.03227254f, 
    0.07999861f, -0.05195731f, 0.09805843f, -0.09246907f, 0.09689796f, 0.08151992f, -0.13886340f, -0.01454885f, 
    0.00011086f, 0.02443404f, -0.10963169f, -0.04657203f, -0.02641128f, 0.01829507f, -0.04084682f, -0.00994394f, 
    0.06714285f, 0.02943580f, 0.04655115f, -0.13343796f, -0.13151707f, -0.05080980f, -0.06654170f, 0.02830717f, 
    -0.15140206f, 0.08914918f, -0.04942800f, 0.07626714f, -0.05329230f, -0.00343074f, 0.04716637f, -0.01980628f, 
    -0.05152962f, -0.15377635f, -0.01543119f, -0.12277818f, 0.08856454f, -0.06198336f, 0.08441266f, 0.06958819f, 
    0.08422415f, 0.25071898f, 0.28118628f, -0.25973037f, -0.40517500f, -0.03511745f, -0.22725286f, -0.00683945f, 
    -0.03278631f, -0.18644170f, -0.15708509f, 0.05699307f, 0.21924309f, -0.54951590f, 0.17892432f, 0.12932879f, 
    0.01689813f, -0.00112648f, -0.22619303f, -0.02882382f, -0.56867605f, 0.05024668f, -0.18185638f, -0.19931380f, 
    0.10813818f, 0.10453029f, -0.12894739f, -0.06384795f, 0.25607467f, 0.33192736f, -0.19116589f, -1.04454780f, 
    0.21237566f, -0.02103876f, -0.08576147f, 0.03145185f, 0.09742894f, -0.46229982f, 0.13591172f, 0.13541876f, 
    -0.33611590f, 0.02787320f, 0.11844444f, 0.47354990f, 0.28706411f, 0.50941879f, -0.23584916f, -0.04389611f, 
    0.20155866f, -0.14362717f, 0.18755710f, 0.47877875f, -0.02941985f, 0.09734318f, 0.12108903f, 0.23745695f, 
    -0.04720742f, 0.08614045f, 0.43307236f, 0.01428689f, 0.08732605f, -0.13162360f, -0.19190198f, 0.05814927f, 
    0.05089185f, 0.00120964f, -0.28120849f, 0.22235964f, 0.10707433f, 0.04595549f, -0.10630152f, -0.11590296f, 
    -0.02954675f, -0.58619809f, 0.08703233f, -0.67720425f, 0.47434086f, 0.16390949f, 0.39054987f, 0.21137239f, 
    -0.03465547f, 0.38166818f, 0.21119289f, -0.19310459f, -0.20924565f, -0.09418558f, 0.16707392f, -0.03417719f, 
    0.04787079f, -0.00132807f, -0.04471485f, -0.11731383f, -0.47981527f, 0.25267294f, -0.13480744f, -0.28612000f, 
    -0.28279525f, 0.56683004f, 0.15863431f, -0.05130996f, 0.34400040f, -0.05117025f, 0.16903652f, 0.30368045f, 
    -0.11994254f, 0.16191773f, -0.46150583f, 0.12267815f, -0.13796777f, -0.48171040f, -0.16464163f, -0.12386202f, 
    0.45689279f, -0.54507405f, 0.00816130f, -0.18644530f, 0.28354782f, 0.08552007f, 0.28828239f, 0.23154297f, 
    -0.10863944f, 0.14443249f, 0.15186363f, 0.17107782f, -0.91435391f, -0.26040772f, -0.23747087f, -0.05156239f, 
    -0.12347957f, 0.13260598f, 0.13666011f, -0.56600851f, 0.22690935f, -0.10792945f, -0.23642717f, 0.12590726f, 
    0.03467994f, 0.19652264f, -0.09093025f, -0.09209719f, 0.18865740f, -0.37688330f, -0.02574455f, 0.18450646f, 
    -0.04489253f, 0.11164401f, 0.00178156f, 0.18703382f, -0.42762429f, 0.08725318f, -0.43509623f, 0.16300066f, 
    -0.10902678f, 0.11805278f, -0.10289714f, -0.01278203f, -0.07284679f, 0.39533326f, 0.02528134f, -0.19573800f, 
    0.32867604f, 0.15628199f, 0.17509139f, 0.05828971f, -0.35829777f, -0.19994764f, -0.21988180f, 0.19928619f, 
    -0.06289905f, 0.21592492f, 0.03139720f, -0.08473214f, 0.09005075f, 0.21712993f, -0.15730539f, -0.11780863f, 
    -0.15079021f, -0.14846072f, 0.85352969f, 0.10995651f, 0.23345260f, -0.09984341f, -0.13617061f, 0.17905986f, 
    0.07089918f, 0.13001388f, 0.23429458f, 0.11510108f, -0.07134915f, 0.09118356f, -0.11052710f, -0.04450278f, 
    -0.02835646f, 0.15668778f, 0.04463225f, 0.11625843f, 0.06080971f, -0.09035894f, -0.05667464f, -0.03798088f, 
    0.04323842f, -0.05475128f, 0.03109288f, 0.19653800f, -0.09342889f, -0.13133283f, 0.19510031f, -0.09348217f, 
    -0.03168549f, 0.46874255f, 0.01230979f, 0.26412368f, 0.17349815f, 0.12666367f, 0.13892978f, -0.03340973f, 
    0.10841444f, 0.03032881f, -0.00837313f, 0.01610049f, 0.37065434f, -0.35617363f, 0.11223199f, -0.26458356f, 
    -0.49078503f, 0.34870240f, 0.05898120f, 0.10293881f, 0.05698105f, -0.09157129f, 0.53330815f, -0.18564616f, 
    0.01853601f, -0.15708022f, 0.38734812f, 0.02177168f, 0.18749450f, 0.11145334f, 0.34009114f, 0.07143933f, 
    0.23646475f, 0.13078107f, 0.71278852f, -0.13047180f, -0.31539553f, 0.01613867f, 0.42484710f, -0.16518340f, 
    0.06753087f, 0.14594771f, 0.06437074f, -0.12138487f, 0.21604927f, -0.11700665f, 0.15275881f, 0.20061772f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.09541053f, -0.01014242f, 0.09505834f, 0.04709798f, 0.03567754f, -0.15826289f, -0.04006796f, -0.01073260f, 
    -0.07168475f, -0.14238392f, 0.27019715f, 0.34717083f, 0.10819361f, -0.07069606f, 0.05102414f, 0.02830503f, 
    -0.10462758f, 0.34664363f, -0.05771403f, -0.05031054f, -0.08248874f, -0.08687502f, 0.28667483f, 0.32004797f, 
    0.00248260f, 0.03564955f, 0.14577320f, 0.20901982f, 0.37385571f, 0.26280472f, -0.07428305f, 0.24584271f, 
    -0.12327610f, -0.03961568f, 0.20994066f, -0.05355267f, 0.57927728f, -0.01722852f, 0.10194129f, -0.14630319f, 
    0.22793067f, 0.12400786f, -0.43755993f, 0.16028696f, 0.12996070f, 0.05868701f, 0.09720099f, -0.14425361f, 
    0.05075895f, 0.47030526f, 0.40187895f, 0.24023056f, 0.14435197f, 0.35441646f, -0.01317990f, 0.07303973f, 
    -0.11088984f, 0.02928912f, -0.01343063f, -0.09739541f, 0.15438437f, 0.20668447f, 0.12456745f, 0.48979241f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.01150687f, 0.03335080f, -0.37864679f, -0.62487370f, -0.22196949f, -0.34357092f, -0.05679877f, -0.13980317f, 
    -0.02495672f, -0.05160488f, -0.73687905f, -0.57062811f, 0.06655842f, -0.14375928f, 0.00029056f, -0.00995908f, 
    0.08793738f, -0.10779944f, -0.06865459f, -0.59428203f, -0.03678181f, 0.09341717f, -0.18799378f, -0.21687579f, 
    0.15730087f, -0.08415227f, -0.17929626f, 0.13904759f, 0.15018530f, -0.77083558f, 0.23087406f, 0.15516792f, 
    -0.06576482f, -0.00051937f, 0.02217762f, 0.05591160f, -0.15311040f, -0.56933153f, -0.01434994f, -0.12628663f, 
    0.01078047f, 0.00667775f, 0.47571465f, 0.21830757f, 0.27367216f, -0.13170791f, -0.16821992f, 0.14506704f, 
    -0.51463079f, 0.11448652f, -0.37197939f, 0.17644934f, -0.08018693f, 0.06783199f, -0.09434859f, -0.01450271f, 
    0.06020895f, 0.11582560f, -0.03970998f, -0.07184950f, -0.55536586f, -0.54422456f, 0.05990589f, 0.12938070f, 
    0.07036074f, -0.01871138f, 0.16120844f, -0.14504816f, 0.06508575f, 0.00678472f, -0.10661039f, 0.11483616f, 
    0.06008331f, 0.07807671f, -0.12933558f, -0.60796589f, 0.30376461f, 0.02771781f, 0.07181814f, -0.08837657f, 
    0.09425586f, 0.26814198f, 0.02413531f, -0.25077480f, -0.00781479f, 0.12338001f, -0.08377799f, -0.72836304f, 
    0.04623838f, 0.12672153f, -0.28283161f, -1.17433262f, 0.04457731f, 0.03950776f, 0.12521839f, 0.10655377f, 
    -0.03882299f, 0.08271433f, -0.12365951f, -0.06777848f, 0.45434332f, -0.20805588f, -0.10948672f, -0.00559772f, 
    0.08567040f, -0.36757141f, -0.60751504f, 0.32934511f, -0.15849039f, 0.29387191f, 0.06620652f, -0.23552220f, 
    -0.79818255f, -0.23929515f, 0.30298334f, 0.08074915f, -0.41057104f, 0.11799194f, 0.05609722f, 0.23543186f, 
    0.09171866f, -0.02692904f, -0.01278341f, -0.02364666f, -0.40297303f, 0.34564358f, -0.32789603f, 0.18352607f, 
    -0.11627153f, 0.05457653f, -0.17876478f, 0.14464724f, -0.09845168f, -0.80421877f, 0.00520954f, -0.21222082f, 
    0.11266960f, 0.06803436f, 0.18402660f, 0.26136014f, -0.31245509f, -0.05734570f, -0.06239095f, -0.09297752f, 
    -0.11567154f, -0.19262992f, -0.04768891f, 0.03290709f, -0.10077266f, -0.04585207f, 0.46067247f, 0.32971570f, 
    -0.18953621f, -0.19663069f, -0.07533480f, -0.74305755f, -0.25162587f, 0.14415775f, -0.56675500f, 0.15071382f, 
    -0.10279354f, 0.33970755f, -0.14938180f, -0.11145303f, -0.13487875f, 0.06663947f, -0.11016530f, 0.05782472f, 
    -0.20608489f, -0.02878148f, -0.09364989f, -0.15628792f, -0.22061494f, -0.12914298f, -0.14958195f, -0.01789202f, 
    0.24253167f, 0.23808998f, 0.04903678f, 0.02895109f, 0.13250071f, -0.21929601f, -0.03985338f, 0.32725185f, 
    -0.08689409f, -0.44991237f, 0.06678226f, 0.06969415f, 0.56641614f, -0.44403806f, 0.28255773f, -0.20625164f, 
    -0.10222705f, -0.03287401f, -0.32850111f, -0.04845987f, -0.35578796f, -0.12944114f, -0.02758007f, -0.27803266f, 
    -0.29113176f, 0.04855718f, 0.23647496f, 0.24969418f, 0.00757305f, 0.05918813f, -0.10485568f, 0.05317169f, 
    0.03694906f, 0.15931243f, -0.04265006f, -0.03615271f, -0.13029499f, -0.00636591f, -1.85565400f, 0.11448828f, 
    -0.42633760f, -0.18570536f, -0.38069183f, 0.13346906f, -0.03078932f, 0.06216785f, 0.19122133f, 0.03521317f, 
    -0.04988546f, 0.22733118f, -0.10441061f, 0.02440482f, -1.06650519f, 0.21895634f, -0.06093984f, -0.05859102f, 
    0.01959405f, -0.40307865f, 0.30416936f, 0.17528643f, -0.52537894f, -0.33795050f, -0.19311847f, -0.19664843f, 
    0.11020029f, 0.23031101f, -0.22876075f, 0.09684896f, 0.21745996f, 0.02444701f, 0.07056341f, -0.02904795f, 
    -0.02152029f, 0.01245481f, 0.08670820f, 0.08753294f, 0.33546391f, -0.80648196f, 0.20587680f, 0.04108711f, 
    0.02888202f, 0.04543812f, -0.05960893f, -0.23634556f, -0.14036395f, -0.26012659f, 0.04096422f, -0.03005047f, 
    -0.44368446f, 0.05417220f, -0.54226673f, -0.78565961f, -0.22095807f, 0.09039629f, -0.08453881f, -0.07853478f, 
    -0.15368271f, -0.22845426f, -0.10041030f, 0.21358983f, 0.06642286f, 0.06807392f, -0.04947535f, -0.14619444f, 
    0.00028862f, 0.08149806f, 0.00425597f, 0.33116928f, 0.20829330f, -0.17645350f, 0.06238357f, -0.01303521f, 
    0.08955100f, -0.10789421f, 0.25382662f, -0.00331598f, -0.51672959f, 0.00223950f, -0.01299050f, -0.13269432f, 
    0.08306099f, 0.30469963f, -0.75363612f, 0.00477833f, 0.05032474f, 0.06147399f, 0.11153504f, 0.20984891f, 
    0.03730051f, 0.11426758f, -0.44229701f, 0.13709286f, -0.35310483f, 0.04668450f, 0.09277803f, -0.24649398f, 
    0.03656963f, 0.19867086f, -0.03678079f, -0.07699769f, -0.08857571f, -0.67257804f, -0.24599344f, -0.08632433f, 
    0.05608380f, -0.08902778f, 0.05901041f, 0.05930571f, 0.13869832f, 0.07703637f, -0.01791939f, 0.22681873f, 
    0.02167353f, -0.07541634f, -0.03856704f, -0.06664369f, 0.03751518f, 0.08826319f, 0.08547264f, -0.14553984f, 
    -0.09735412f, -0.00747591f, -0.06318957f, -0.09538952f, 0.01794714f, -0.07563694f, -1.54799378f, -0.44686082f, 
    0.02362423f, 0.10542171f, -0.04636968f, -0.10707804f, 0.10107715f, 0.23651558f, 0.07936607f, 0.07556118f, 
    0.02526967f, 0.03466518f, 0.00800104f, -0.00307514f, -0.70409495f, -0.03609134f, -0.05891274f, -0.05795848f, 
    0.19321167f, 0.18265580f, 0.14279573f, 0.14733917f, -0.07925279f, 0.14153738f, 0.06210969f, 0.04064523f, 
    -0.16108878f, -0.11984073f, 0.09304218f, -0.03433021f, -0.79082412f, -0.06313268f, -0.03050544f, 0.01984465f, 
    -0.21222369f, -0.04062245f, -0.02543089f, 0.00214332f, -0.09937480f, -0.28880718f, -0.01160976f, 0.03890004f, 
    -0.17479748f, -0.06553677f, 0.10152342f, 0.14266045f, 0.10760325f, 0.10534837f, -0.01885645f, -0.34253368f, 
    0.23690884f, 0.03773775f, 0.02020910f, 0.02002723f, -0.84290123f, 0.09866915f, -0.02428814f, -0.01124814f, 
    0.03640584f, -0.78664964f, -0.06842546f, 0.25041491f, -0.09640350f, -0.04349873f, -0.47176564f, 0.28639358f, 
    0.18990622f, -0.13096817f, 0.05060355f, -0.17355774f, -0.82026923f, -0.03639645f, -0.45149285f, -0.87619638f, 
    0.12123688f, -0.03459127f, -0.60063994f, -0.05011914f, 0.41575938f, -0.21574646f, -0.09571985f, 0.08667842f, 
    -0.70060700f, 0.06159939f, -0.08158447f, -0.61217749f, 0.16035505f, -0.13350385f, -0.47270337f, 0.19290955f, 
    0.34761593f, -1.09821284f, -0.10081925f, -0.28221062f, 0.35628349f, 0.07311244f, -0.06587563f, 0.08685928f, 
    -0.06448430f, -0.55692518f, 0.09141216f, 0.04542133f, 0.40749866f, 0.24394174f, 0.22665492f, -0.92310429f, 
    0.00724321f, 0.01216882f, -0.10864397f, -0.24188256f, -0.20855699f, -0.01698681f, 0.01337543f, 0.20639212f, 
    -0.22882895f, -0.07107732f, -0.20408711f, 0.14287420f, -0.05751707f, 0.02906013f, -0.00939229f, -0.05372389f, 
    0.00811795f, -0.46665353f, 0.15654640f, -0.10402727f, 0.02482000f, 0.02852441f, -0.16556418f, 0.28588089f, 
    0.03115516f, 0.23700847f, 0.04191782f, 0.44923985f, -0.19512026f, -0.97630286f, -0.77472919f, -0.44939670f, 
    -0.10818999f, -0.16064021f, -0.01416384f, -0.12779275f, -0.56468856f, -0.07234634f, -0.02440361f, -0.02510990f, 
    0.12838097f, -0.26084507f, 0.03388871f, 0.38752607f, -0.06196910f, 0.35150671f, 0.42593855f, 0.13811867f, 
    -0.55981475f, -0.85286891f, -0.10819800f, 0.05567261f, 0.36922637f, -0.01499065f, 0.08486244f, -0.17055820f, 
    -0.02438505f, 0.60916030f, -0.04103890f, 0.00895528f, -0.52590317f, 0.10527675f, -0.13585849f, -0.46658704f, 
    -0.19632475f, 0.02777252f, 0.14831164f, 0.37478083f, 0.20787047f, 0.12787880f, -0.11702430f, 0.21596834f, 
    0.19438936f, 0.04440826f, 0.42471361f, 0.52935803f, -0.02953556f, -0.08196589f, -0.05003118f, -0.14051643f, 
    0.10429315f, 0.22673054f, -0.11092771f, -0.31472918f, 0.05288706f, -0.06480132f, 0.22462308f, -0.76035118f, 
    -0.22019981f, -0.50725347f, 0.20734471f, 0.13808554f, -0.15768357f, 0.11321519f, -0.07934677f, -0.93972254f, 
    -0.06642162f, 0.14288105f, -0.22126965f, 0.05480291f, 0.07050672f, 0.23759481f, 0.08355408f, 0.10361740f, 
    0.20662369f, -0.45212156f, 0.07427733f, -0.53323853f, 0.32329431f, -0.08063342f, 0.16071270f, -0.48974416f, 
    -1.12348437f, -0.15653062f, 0.14983140f, -0.39981905f, -0.63834906f, -0.09831393f, 0.07266305f, 0.04750846f, 
    -0.05391118f, -0.39781764f, -0.07258983f, -0.05181247f, -0.62388045f, -0.20155561f, -0.14122969f, 0.02342346f, 
    -0.18260908f, -0.05093856f, 0.04395573f, -0.02144535f, 0.01907580f, -0.14089578f, -0.11999978f, -0.63239521f, 
    0.00227158f, 0.07753052f, -0.11980125f, 0.18457979f, -0.16045119f, -0.06910355f, 0.03633576f, -0.12209839f, 
    0.06574823f, -0.27891278f, -0.05397219f, -0.15607013f, 0.01247733f, -0.09609371f, 0.20411702f, 0.29116282f, 
    0.04279380f, 0.18847041f, 0.22072160f, 0.14511292f, -0.12774462f, -0.16625690f, -0.24996068f, 0.00678348f, 
    -0.08966026f, 0.04544786f, 0.27573535f, -0.00574955f, -0.03880594f, -0.10013637f, -0.09237960f, -0.10405710f, 
    -0.37156993f, 0.19633749f, -0.06635945f, -0.32587549f, 0.35038966f, -0.56021005f, -0.53662652f, 0.15848008f, 
    0.22083652f, 0.09701031f, 0.04508660f, -0.02256698f, 0.18048376f, -0.45206228f, 0.06335280f, -0.10948680f, 
    -0.00280960f, 0.00017252f, 0.11190695f, -0.09684949f, -0.08311571f, 0.10458720f, 0.15516672f, -0.27153477f, 
    0.03198686f, -0.01520437f, -0.02774959f, 0.20743647f, -0.16124947f, -0.48431423f, 0.10618582f, 0.31426466f, 
    -0.25381327f, 0.05482975f, 0.04817720f, -0.06531625f, 0.10842402f, 0.03711151f, 0.09054150f, 0.07477669f, 
    -0.13401936f, 0.17055589f, 0.09074533f, 0.25775418f, -0.00761653f, -0.08056918f, -1.18042314f, -0.46576899f, 
    -0.55574822f, -0.58755869f, -0.24738839f, -0.00951491f, 0.29882875f, 0.04660325f, -0.19223358f, -0.49510747f, 
    -0.13044700f, -0.70337641f, 0.26888153f, 0.02449496f, -0.66607916f, 0.27950239f, 0.02141623f, 0.08809576f, 
    0.05218472f, 0.32668567f, -0.23140410f, -0.74326873f, -0.12688258f, 0.19981104f, 0.42291075f, -0.56267071f, 
    -0.03101607f, 0.02381790f, -0.04493061f, -0.09477042f, -0.51356828f, 0.31404048f, 0.02986897f, -0.48486412f, 
    0.04861604f, -0.33008590f, -0.06564709f, -0.07815287f, -0.31883237f, -0.35749811f, -0.29076451f, 0.10882976f, 
    -0.11589296f, -0.08163920f, -0.05423667f, -0.22236927f, 0.05423446f, 0.38912323f, 0.10533930f, 0.06957855f, 
    0.15057045f, 0.09045072f, -0.15095063f, -0.20769626f, 0.17940564f, -0.09152575f, -0.14007863f, -0.11264590f, 
    0.00838598f, -0.10255951f, 0.00900575f, 0.46439853f, -0.11483016f, -0.04757963f, -0.03459962f, -0.15732712f, 
    0.06285647f, -0.59167486f, -0.13416202f, -0.67474723f, -0.19791839f, 0.11420318f, 0.28157693f, -0.59374392f, 
    -0.00509831f, -0.20595789f, -0.37309912f, -0.04132677f, -0.72007537f, 0.21132043f, 0.00635502f, -0.08066415f, 
    -0.02896467f, 0.08347578f, -0.07230578f, -0.24040931f, -0.12840223f, -0.10796801f, 0.14054349f, 0.16067094f, 
    0.18033713f, 0.27661133f, -0.02851373f, -0.47495255f, -0.00535305f, -0.38608861f, 0.11470658f, -0.61357260f, 
    0.07145206f, -0.45623556f, 0.02657030f, -0.09052742f, 0.30963901f, 0.28382885f, -0.66587394f, -0.07305029f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.32785702f, 0.31257597f, 0.08621786f, 0.09114043f, -0.04433858f, -0.11870195f, -0.12183185f, 0.02293746f, 
    0.03269546f, 0.38405499f, 0.02710781f, -0.18173455f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
