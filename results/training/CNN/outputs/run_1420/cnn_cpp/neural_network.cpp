#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.39016291f, -0.30363739f, -0.18699625f, -0.52351594f, -0.29953718f, -0.23524334f, -0.15356579f, 0.02792453f, 
    -0.49932048f, 0.45445871f, 0.07668282f, 0.64757437f, -0.15176189f, 0.04534693f, 0.32621223f, 0.06685372f, 
    0.01328796f, 0.42093673f, -0.05418252f, 0.21040638f, -0.31687656f, 0.40991226f, -0.44096771f, -0.19244121f, 
    0.25310594f, 0.55367351f, 0.23627229f, 0.27126974f, 0.43303329f, -0.64375317f, -0.18901464f, -0.27133486f, 
    0.55821770f, -0.24258959f, -0.13234031f, -0.16650629f, 0.22146383f, -0.37844527f, -0.82499295f, 0.27203181f, 
    0.15116091f, 0.03021817f, 0.39822730f, -0.02136073f, 0.00423550f, 0.65337932f, 0.66300720f, -0.10400739f, 
    -0.35177404f, 0.24165080f, -0.46625444f, 0.03178709f, -0.06175146f, 0.04711201f, -0.36250955f, 0.38086122f, 
    0.11547249f, 0.44978398f, 0.72488421f, 0.17393620f, 0.05531112f, 0.29576746f, -0.37906286f, 0.02119502f, 
    -0.43473908f, -0.59234780f, 0.58924377f, -0.12186087f, 0.61756366f, -0.10072464f, 0.18014449f, 0.17133197f, 
    0.21374930f, -0.36504096f, 0.72021800f, 0.47504893f, 0.01235153f, -0.20854281f, -0.28950724f, 0.32556146f, 
    -0.21458669f, -0.48543605f, -0.21475017f, -0.00175646f, -0.39382017f, -0.50004250f, -0.51310945f, 0.11768287f, 
    0.38755131f, 0.15215540f, -0.66281098f, -0.50371581f, -0.22797814f, 0.11325860f, -0.26071203f, -0.21497555f, 
    0.21034338f, -0.06304296f, -0.24421471f, 0.41123322f, -0.58460259f, -0.22712426f, 0.44282880f, 0.25650990f, 
    -0.03187473f, -0.22027168f, -0.28318918f, -0.18637718f, 0.13297294f, 0.22447300f, 0.00553422f, -0.40133178f, 
    -0.21823511f, -0.33476689f, 0.41622984f, -0.20444116f, 0.35831678f, 0.61432958f, 0.19108352f, 0.36492330f, 
    -0.13055308f, 0.36492550f, -0.18804768f, -0.24247663f, -0.02066328f, -0.24291952f, 0.29018998f, -0.59269840f, 
    0.49496451f, -0.46469787f, -0.02909385f, 0.29245546f, 0.34046385f, -0.15523219f, -0.13084425f, 0.34922490f, 
    -0.29306901f, -0.08477184f, 0.42786732f, -0.48952585f, 0.56556600f, -0.07053598f, 0.20929378f, -0.49735191f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.28997231f, 0.22329611f, -0.17480233f, 0.12483057f, 0.08269300f, 0.16067129f, -0.50166756f, -0.17966814f, 
    -0.05642659f, -0.16222145f, -0.08132610f, -0.09372262f, 0.03403611f, -0.12850736f, 0.00643172f, -0.18299471f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.05324724f, -0.09835409f, -0.16237615f, -0.07963885f, -0.05185558f, -0.01210613f, 0.01046400f, -0.03093710f, 
    -0.01453896f, 0.35741249f, 0.25913531f, 0.27676338f, -0.03474968f, 0.10390108f, 0.03455472f, 0.08353142f, 
    -0.03774575f, 0.01732820f, -0.26916182f, -0.14734076f, -0.16686615f, -0.22023006f, -0.07110261f, -0.04955463f, 
    0.24547854f, 0.19024602f, -0.01247800f, 0.06651686f, -0.45670569f, 0.02199922f, 0.07819422f, 0.05647155f, 
    -0.13280357f, 0.02012983f, 0.03035535f, -0.03077168f, -0.19734965f, -0.39619252f, -0.04714402f, -0.00394881f, 
    0.28494781f, 0.15746158f, -0.08963824f, 0.05582092f, 0.00177469f, 0.32633749f, 0.01708905f, 0.02090775f, 
    0.09818063f, 0.00513181f, -0.09314781f, -0.00114129f, 0.12375975f, 0.06537246f, -0.11267304f, 0.23770086f, 
    -0.17138112f, -0.05435337f, 0.00782366f, -0.16625963f, -0.09730639f, 0.06154459f, 0.03594742f, -0.35474604f, 
    -0.41835997f, -0.01064904f, -0.06099200f, -0.06955194f, -0.13318481f, 0.05404015f, -0.16778119f, -0.04956120f, 
    -0.06200027f, -0.10915177f, -0.14927945f, 0.06643865f, -0.05742021f, 0.03216288f, 0.08411071f, -0.06121802f, 
    -0.06902048f, -0.15767850f, 0.09770005f, 0.07023553f, -0.01111097f, -0.15924509f, -0.10620219f, 0.05463463f, 
    -0.00382011f, 0.14369923f, 0.15981106f, 0.17670445f, 0.17002673f, -0.16423987f, 0.04020591f, 0.05589655f, 
    0.01416280f, -0.05410424f, 0.03279596f, -0.23282446f, -0.27450466f, -0.28380829f, -0.11952961f, 0.11412240f, 
    -0.02455072f, 0.00143421f, -0.20649433f, 0.13291276f, -0.05214205f, -0.04366971f, 0.24928309f, -0.02548478f, 
    0.03299896f, -0.01449596f, 0.05869458f, 0.09974849f, 0.07926402f, 0.36308923f, 0.13953117f, 0.02083879f, 
    -0.02183074f, 0.01145354f, -0.19939247f, -0.08362625f, 0.01992407f, 0.22221194f, 0.00490649f, -0.20495646f, 
    0.06440850f, -0.18014069f, -0.04479527f, 0.03515898f, -0.10650805f, 0.05893591f, 0.06690753f, -0.02799660f, 
    -0.24304231f, 0.17038864f, -0.09512397f, 0.06633303f, -0.23578478f, -0.21204185f, -0.04883988f, 0.09932043f, 
    0.32510331f, -0.48228312f, -0.25926846f, -0.10253610f, -0.28262204f, 0.00758150f, 0.07238954f, 0.08110879f, 
    0.08494286f, 0.05509886f, 0.10586628f, 0.12876396f, -0.12342057f, 0.04358953f, -0.04899632f, 0.05042807f, 
    -0.00638065f, 0.05255819f, -0.22688083f, -0.14536424f, -0.08793472f, -0.02463026f, -0.11897293f, 0.00193841f, 
    0.01802292f, 0.20030224f, 0.07513254f, -0.28914729f, -0.02567291f, -0.12193429f, 0.02084285f, 0.18717375f, 
    0.24937557f, 0.12835591f, -0.07414270f, 0.04575285f, 0.15973337f, -0.38624790f, -0.47058663f, -0.10938513f, 
    0.00803418f, 0.14731047f, 0.22034878f, 0.00462454f, 0.00589594f, -0.09766351f, -0.05146657f, 0.05381137f, 
    0.01288895f, 0.06371631f, 0.08181021f, -0.07176334f, -0.01279959f, 0.02305247f, 0.13706233f, -0.02907806f, 
    0.25512981f, -0.21311641f, 0.06803115f, -0.15930092f, 0.08215824f, 0.04600570f, 0.08086006f, 0.19287711f, 
    -0.53561944f, -0.59329367f, -0.00494602f, -0.03038075f, -0.08267403f, -0.08402342f, -0.15576653f, -0.03512622f, 
    0.31798923f, -0.03299949f, 0.21817406f, -0.00823552f, 0.09164001f, 0.00786887f, 0.05578761f, 0.04985124f, 
    -0.01809721f, 0.21907085f, -0.26115218f, -0.14747164f, -0.06207299f, 0.02082508f, -0.05534219f, -0.06540802f, 
    -0.08754619f, 0.02360919f, 0.17023161f, 0.01060288f, -0.72912234f, -0.10286535f, -0.06483355f, 0.05113436f, 
    -0.02559280f, -0.06150842f, 0.04751063f, 0.21709667f, -0.39199007f, -0.02502952f, -0.14500058f, -0.00815222f, 
    0.05686339f, 0.08682270f, -0.10599830f, -0.08279896f, -0.28245798f, -0.13158584f, -0.24896275f, 0.04953263f, 
    0.02238294f, -0.04134572f, -0.04723648f, 0.11811081f, 0.03764307f, 0.14283277f, 0.14854643f, 0.12281617f, 
    0.04047300f, -0.01535423f, 0.12235915f, -0.04396298f, -0.02953866f, 0.00679607f, 0.31744200f, -0.28188512f, 
    -0.10839112f, -0.15590701f, 0.09234923f, 0.20269036f, 0.01717669f, 0.13928948f, -0.01153805f, 0.29719922f, 
    -0.36083850f, 0.26863962f, 0.04183748f, 0.06688789f, 0.03439914f, 0.09758089f, 0.05180238f, 0.13734969f, 
    -0.07277907f, 0.05859463f, 0.00589962f, -0.08353193f, -0.07091583f, -0.09673253f, -0.01667066f, -0.03400942f, 
    0.00593497f, -0.04387911f, 0.00976341f, -0.02779225f, -0.00794011f, -0.07877269f, 0.00285397f, -0.03714287f, 
    0.02353639f, -0.08662533f, 0.05688087f, -0.03956866f, -0.00639918f, -0.02838756f, -0.01959320f, -0.02222199f, 
    -0.03799964f, 0.06799717f, 0.04474956f, -0.01774093f, 0.00489848f, 0.03295706f, -0.06116856f, 0.01900943f, 
    -0.02395650f, -0.01659728f, -0.05032244f, 0.07042356f, -0.06547473f, -0.05018197f, 0.06422421f, 0.04300295f, 
    -0.07056713f, -0.07292105f, 0.04605896f, -0.02900353f, 0.03169112f, 0.05295252f, -0.07854930f, -0.01128697f, 
    -0.08504561f, 0.03692196f, -0.05174986f, 0.04608102f, 0.01034623f, -0.05961737f, 0.04964319f, 0.05646361f, 
    -0.00361825f, -0.05260676f, 0.05928276f, -0.05719044f, 0.03524720f, -0.06312130f, 0.04548854f, 0.05490964f, 
    -0.06998235f, -0.03699166f, -0.02941326f, -0.07721262f, -0.03911850f, 0.07416638f, -0.02167708f, 0.06522592f, 
    0.04865599f, 0.03468818f, 0.01955181f, -0.05173560f, -0.01230131f, 0.04793549f, -0.05285384f, 0.00647892f, 
    -0.03693782f, 0.05315248f, 0.00910477f, -0.00960410f, -0.03008720f, -0.03744148f, -0.07739027f, -0.04869711f, 
    -0.08006090f, 0.01449079f, -0.09313010f, 0.05251797f, 0.00159091f, -0.05278392f, 0.01654071f, -0.07915317f, 
    0.05549120f, 0.03259500f, -0.08471622f, 0.04624399f, -0.01801582f, 0.04408285f, 0.05594200f, -0.00384405f, 
    0.04257165f, -0.00143581f, 0.06943101f, 0.05005740f, 0.05348491f, 0.07240440f, -0.09028713f, -0.05388232f, 
    -0.07121943f, -0.07073769f, 0.02270020f, 0.00826198f, -0.02564962f, -0.03235355f, 0.00661924f, 0.02993220f, 
    0.06723150f, -0.05846567f, 0.06479977f, 0.04332317f, 0.01928294f, 0.05659195f, -0.04007945f, -0.04344309f, 
    -0.09479938f, 0.01004882f, 0.03683811f, -0.08549506f, -0.03073100f, -0.09739604f, -0.01318779f, -0.07043222f, 
    -0.07337621f, 0.00160973f, 0.03854098f, -0.01500242f, -0.02885526f, 0.06420870f, -0.06113110f, 0.02418702f, 
    -0.02331909f, 0.07533813f, 0.04277111f, 0.08247019f, -0.07796299f, -0.14341065f, -0.00008544f, 0.10933024f, 
    0.22919498f, 0.12462951f, 0.05008085f, -0.01705332f, -0.18647821f, 0.14969559f, 0.01615544f, 0.00246246f, 
    0.07073475f, -0.11502454f, -0.06611661f, -0.04597099f, 0.05284255f, 0.11024605f, 0.02020146f, -0.07616987f, 
    -0.23698419f, -0.21628802f, -0.24049231f, -0.04437980f, -0.04963785f, 0.15870175f, 0.11297243f, -0.02779458f, 
    0.11561006f, 0.11399908f, 0.10436609f, -0.01426257f, -0.00484488f, -0.13693166f, 0.09070557f, -0.05175220f, 
    -0.00712402f, 0.06698512f, 0.10171682f, -0.00516789f, 0.03326010f, 0.12341386f, 0.24954262f, 0.11659890f, 
    -0.02784795f, 0.04853799f, 0.00727290f, -0.01024019f, 0.11053445f, 0.01307358f, -0.08836165f, 0.12091475f, 
    0.08561486f, 0.13110337f, 0.10560847f, 0.00229560f, -0.03620817f, -0.16618294f, 0.09175562f, -0.10043795f, 
    0.15572381f, 0.07761716f, -0.12935749f, 0.02357028f, 0.09262674f, 0.06816574f, -0.02521526f, -0.08578261f, 
    -0.01025789f, 0.07038396f, -0.01386396f, -0.02059851f, 0.01007650f, 0.18584166f, 0.02768113f, 0.04226846f, 
    -0.06445312f, -0.23285952f, 0.05822431f, 0.01738024f, 0.14998230f, -0.01871989f, -0.05049772f, 0.04082127f, 
    0.03867656f, -0.16389371f, 0.07537562f, 0.04650340f, -0.02553711f, 0.09466922f, 0.03043760f, -0.01837310f, 
    -0.03595949f, 0.03098328f, 0.18061462f, 0.02169450f, -0.20622493f, 0.20533526f, 0.10830799f, 0.06149731f, 
    0.15907100f, -0.07868958f, 0.04463954f, 0.20268410f, -0.01413420f, 0.09174092f, 0.02475570f, 0.07235070f, 
    0.11315101f, -0.13977401f, -0.13838589f, -0.01170700f, -0.18414204f, -0.10747090f, 0.03102497f, 0.04337950f, 
    0.09287543f, -0.02859397f, 0.10463390f, 0.09574152f, -0.03776081f, -0.05722786f, 0.00590798f, 0.05293490f, 
    0.13383955f, -0.15390950f, 0.09910024f, -0.04475579f, 0.06074157f, 0.33095255f, 0.11074846f, 0.10765491f, 
    0.07115296f, 0.14411765f, -0.00020520f, 0.07722182f, 0.16903500f, 0.07380352f, 0.18660772f, 0.12401125f, 
    0.06467269f, -0.01325583f, -0.05009901f, -0.01945548f, 0.03027046f, 0.01907502f, -0.05725772f, 0.03312031f, 
    -0.00728293f, -0.08518741f, 0.01904824f, 0.07325087f, -0.01850266f, -0.07131737f, -0.07296832f, -0.01573543f, 
    0.06949482f, -0.07985109f, 0.00331583f, -0.01656868f, -0.08566778f, -0.00090596f, 0.04436884f, -0.08325666f, 
    0.06164139f, -0.00110649f, 0.05949600f, -0.01065449f, -0.01792300f, 0.04960201f, 0.04556911f, -0.05945272f, 
    -0.01161812f, -0.02055599f, 0.06156421f, -0.08372805f, 0.01609126f, -0.03360535f, -0.00064306f, 0.03573761f, 
    -0.06994532f, -0.03517495f, 0.06546457f, -0.06563164f, 0.03900135f, -0.02829002f, -0.03536182f, 0.01964340f, 
    -0.07742582f, 0.02280685f, 0.03743757f, -0.01665859f, -0.02239183f, -0.04705888f, -0.02826606f, -0.07051347f, 
    -0.05958657f, -0.07174408f, 0.02825462f, -0.04118785f, 0.00575270f, -0.05771757f, 0.07119028f, -0.06414691f, 
    -0.08333213f, 0.04855983f, 0.04988343f, -0.07711592f, 0.02757602f, -0.00023500f, -0.06166875f, -0.06962239f, 
    0.03503886f, 0.02066431f, 0.06360400f, -0.03319222f, 0.04539008f, -0.02639837f, 0.02813131f, -0.07783260f, 
    -0.02486975f, 0.02209369f, -0.04975682f, -0.04861592f, 0.04376461f, -0.08542743f, -0.05266839f, -0.01550262f, 
    0.06104464f, -0.07612348f, -0.06582826f, -0.04513858f, 0.06947670f, 0.03532236f, -0.04226988f, -0.00604472f, 
    0.01287833f, -0.06616833f, -0.07969417f, -0.00773498f, -0.02158114f, -0.07690448f, -0.03818995f, 0.07247922f, 
    -0.02032157f, 0.04720927f, 0.02431209f, -0.01400475f, -0.02740246f, -0.04265830f, -0.05984900f, -0.03701288f, 
    -0.01546517f, -0.03184768f, -0.02967623f, -0.04959963f, -0.05267541f, -0.03499862f, 0.03552387f, 0.05214040f, 
    -0.02710197f, -0.03888412f, -0.06551068f, -0.00873005f, -0.06965639f, 0.00473652f, -0.02525920f, 0.04774425f, 
    0.00492111f, -0.02435654f, -0.00877208f, -0.03526482f, -0.07734516f, -0.07178631f, 0.04221071f, 0.00126710f, 
    0.04504878f, -0.02527926f, 0.02988334f, 0.01706391f, -0.07757047f, -0.07271114f, -0.00966780f, 0.02575953f, 
    0.12123983f, -0.14028929f, 0.29705274f, -0.22080250f, -0.10337939f, 0.01602084f, 0.01475785f, -0.05676329f, 
    0.13881372f, 0.08134087f, -0.08754041f, -0.15905178f, -0.02466423f, -0.08454379f, -0.02484948f, 0.05087979f, 
    -0.05966858f, -0.07356031f, 0.09554302f, -0.14256805f, -0.21236482f, -0.04029783f, -0.05310173f, 0.09626159f, 
    -0.02553229f, -0.18434474f, -0.20860316f, 0.56997037f, -0.29440171f, -0.19496077f, 0.12004744f, 0.18591566f, 
    0.01240736f, 0.26670295f, 0.18664272f, 0.10269499f, -0.24619088f, -0.14733100f, 0.07540493f, -0.04324506f, 
    -0.06292236f, 0.05837632f, -0.01880329f, 0.07706904f, 0.07101603f, 0.23304594f, 0.27310944f, 0.15811355f, 
    0.01869960f, -0.08096018f, -0.13945685f, 0.03224000f, -0.02006293f, -0.00057116f, -0.28146875f, 0.21902247f, 
    0.08629951f, 0.21829091f, 0.08347105f, 0.09638394f, 0.14846297f, 0.13630499f, 0.20985053f, -0.53645444f, 
    -0.24216191f, -0.25913027f, 0.19373322f, 0.09007718f, 0.04592582f, -0.06137445f, 0.07619354f, 0.03947323f, 
    0.13860245f, -0.05766204f, -0.41110748f, -0.12267771f, 0.20382614f, -0.14963707f, -0.02286413f, -0.11247640f, 
    0.03609925f, 0.24912965f, -0.01948406f, 0.23970737f, 0.20495915f, 0.16361690f, 0.05508995f, 0.00580805f, 
    0.05119392f, -0.07933258f, -0.29606476f, -0.01560313f, 0.12932575f, 0.12573358f, 0.00461338f, 0.08577646f, 
    0.09853855f, -0.02579186f, 0.09053735f, -0.08171753f, 0.19869497f, -0.20266232f, -0.15316825f, 0.04844853f, 
    0.14503042f, 0.07393501f, 0.19296396f, -0.01898725f, -0.01643777f, 0.15758228f, -0.09888536f, -0.06598509f, 
    0.02310197f, 0.14531317f, 0.05050087f, 0.02800783f, -0.10766838f, -0.16270287f, 0.03080537f, 0.12464260f, 
    0.00528545f, -0.14169136f, 0.09343432f, 0.01399802f, -0.08536375f, 0.02059367f, 0.51092333f, -0.12355854f, 
    -0.15143624f, 0.10091651f, 0.00823006f, -0.09838273f, 0.15895225f, -0.06637738f, 0.04472738f, -0.25965479f, 
    -0.01795988f, -0.28107920f, 0.07990154f, 0.01570717f, -0.01134110f, 0.22710997f, -0.13099074f, 0.07787608f, 
    0.06453243f, 0.08890971f, 0.11544737f, 0.10689955f, 0.08615538f, 0.06379373f, 0.06566571f, -0.01430359f, 
    0.15708376f, 0.15409270f, 0.02640113f, 0.15011734f, 0.14108782f, -0.04035313f, 0.02545796f, 0.02363830f, 
    0.09280974f, -0.15317295f, 0.01318054f, 0.03917875f, 0.06694566f, 0.06349972f, -0.08627947f, 0.04409089f, 
    -0.00993963f, -0.00449006f, -0.01774354f, 0.17211658f, -0.42108518f, 0.27910286f, -0.10678503f, 0.14249271f, 
    0.11015938f, 0.00454645f, 0.05010570f, -0.09389473f, 0.26681441f, -0.28411871f, -0.04134920f, -0.02796676f, 
    0.05196884f, -0.15409565f, -0.02969051f, -0.11548890f, -0.01129317f, 0.23230973f, 0.26848307f, 0.16804107f, 
    -0.11451828f, 0.06087849f, 0.04203309f, -0.00453070f, 0.08635632f, 0.05340635f, -0.05486357f, 0.33518893f, 
    -0.07742481f, 0.06087673f, -0.02359869f, 0.06146919f, 0.14893872f, -0.06709110f, -0.18486482f, 0.10109639f, 
    -0.28512588f, -0.11044737f, -0.04079979f, -0.01773999f, -0.01493971f, -0.03243750f, 0.00692751f, -0.02745435f, 
    -0.00263739f, 0.39746588f, -0.21374111f, 0.11859521f, -0.04508289f, -0.17346588f, -0.13274449f, -0.05256495f, 
    -0.04906718f, -0.03178920f, -0.10844599f, 0.03096599f, -0.03684114f, -0.02574881f, 0.02875494f, -0.02415113f, 
    -0.00742618f, -0.05145146f, 0.15249091f, 0.13505824f, -0.26359996f, 0.11778336f, 0.03869789f, 0.06060564f, 
    0.12097111f, -0.04592931f, -0.06612005f, -0.26784155f, -0.20807134f, -0.05107360f, 0.05719331f, 0.00964448f, 
    0.10326182f, 0.04969226f, -0.05183994f, 0.04617622f, 0.10447290f, -0.16660163f, 0.19515756f, 0.00194179f, 
    0.02124695f, -0.14601742f, -0.13584396f, -0.01665474f, -0.09115580f, 0.19715966f, 0.16782771f, 0.16717334f, 
    -0.09737568f, 0.03185639f, 0.05060517f, 0.07297768f, -0.10157664f, 0.07835342f, 0.00440609f, 0.20970960f, 
    0.13578326f, -0.02750066f, 0.16305110f, -0.06004868f, 0.06892063f, -0.18353748f, -0.07716522f, -0.00594446f, 
    0.15478414f, -0.12394534f, -0.10583331f, 0.15406579f, 0.02255736f, 0.09394034f, -0.08269423f, 0.00670286f, 
    -0.01421651f, 0.13128842f, -0.01911884f, -0.19938122f, -0.01529123f, -0.07104093f, 0.02805581f, -0.07365178f, 
    0.01490512f, 0.29087254f, 0.03658774f, -0.00539331f, -0.00021501f, 0.09403595f, 0.00660569f, 0.10876564f, 
    -0.02930511f, 0.13211158f, 0.04450572f, -0.09656601f, -0.20269653f, 0.11521919f, -0.16216879f, 0.11063730f, 
    -0.09765276f, 0.11256065f, 0.02420495f, -0.03089237f, 0.09664589f, 0.14061500f, -0.06756797f, 0.05594871f, 
    0.00539777f, 0.04785905f, 0.08161272f, 0.00535895f, 0.03100637f, 0.09183734f, -0.38117743f, 0.00658022f, 
    -0.04165552f, 0.16715752f, 0.10646117f, 0.01230569f, -0.04231601f, -0.44763049f, -0.47148490f, -0.25961789f, 
    -0.13665073f, -0.12094235f, 0.04268615f, -0.06913770f, 0.06488870f, -0.10495234f, -0.04475818f, -0.47741202f, 
    -0.66393089f, 0.05034746f, -0.26273242f, -0.02291920f, -0.14495888f, -0.02297708f, 0.09781465f, 0.30587649f, 
    -0.28639215f, -0.50370204f, -0.10108111f, 0.03103957f, 0.04838285f, -0.08716540f, 0.01242265f, 0.05226856f, 
    -0.14143841f, -0.25350499f, -0.30317464f, -0.12093772f, -0.17992267f, 0.00138146f, -0.03414737f, 0.08281615f, 
    -0.00756804f, 0.20631759f, 0.30791122f, -0.00531061f, 0.03651368f, -0.07069491f, -0.10127164f, 0.12921739f, 
    -0.04011304f, -0.04963363f, 0.36551556f, 0.19114493f, 0.15872940f, 0.04360246f, 0.06753768f, -0.00150657f, 
    -0.00256996f, 0.02947867f, 0.07664784f, 0.30747506f, -0.10946066f, -0.06633426f, 0.00193852f, -0.01946236f, 
    0.10340975f, 0.20717986f, 0.05249791f, -0.01577111f, 0.05722436f, 0.15736343f, 0.05753997f, -0.03612543f, 
    -0.04217662f, -0.06006024f, -0.02039440f, 0.03615333f, 0.09176582f, 0.11721861f, 0.06016122f, -0.61614001f, 
    0.23856941f, 0.04007759f, 0.02365257f, -0.05502097f, -0.06384239f, -0.06851234f, -0.36146888f, -0.22738983f, 
    -0.08116882f, -0.12619509f, 0.06049587f, 0.04518759f, 0.00531086f, -0.04654527f, -0.03525401f, 0.61400592f, 
    -0.42685959f, 0.04234970f, -0.18640605f, -0.04797842f, 0.02642755f, 0.19804019f, -0.15870608f, 0.03508162f, 
    0.09833249f, 0.01671998f, -0.03511131f, -0.04452771f, 0.11432721f, 0.11582743f, 0.09802097f, -0.10164937f, 
    -0.01090740f, -0.25214413f, -0.12457253f, -0.02796408f, 0.02646807f, -0.03744657f, -0.14432739f, 0.00867984f, 
    0.03921736f, 0.21102478f, 0.18986252f, -0.14215873f, 0.08872347f, -0.15182203f, 0.00936090f, -0.06519725f, 
    0.06726893f, -0.01917315f, 0.21419355f, 0.02274627f, 0.07967121f, -0.21209733f, 0.03023713f, 0.04938952f, 
    0.01228245f, 0.04325945f, 0.02892005f, 0.05039582f, 0.16381492f, -0.17242318f, -0.04110605f, -0.07107601f, 
    -0.05117618f, 0.11388698f, 0.00528259f, -0.05187449f, -0.00817358f, 0.59862274f, -0.63940173f, -0.56942779f, 
    0.09981439f, 0.04406529f, -0.02552504f, 0.12062296f, -0.00285293f, 0.05964396f, -0.22291031f, 0.36601537f, 
    -0.07099295f, -0.07943600f, -0.45737508f, 0.15081170f, 0.09978925f, 0.08979585f, 0.01909602f, 0.00819366f, 
    0.13089834f, 0.10436613f, -0.39707443f, -0.09168606f, -0.09269879f, 0.05370575f, -0.02366282f, 0.02728243f, 
    -0.79394215f, 0.23860262f, 0.09610974f, -0.06363714f, 0.09481259f, -0.11073467f, 0.10516129f, -0.02072538f, 
    -0.03871738f, 0.03762347f, 0.21542737f, 0.22711711f, 0.00658247f, -0.07358203f, -0.13152376f, -0.07422360f, 
    0.00347844f, -0.04254576f, -0.10857347f, 0.00781406f, 0.24661948f, -0.08752463f, 0.02934873f, -0.01489510f, 
    0.05265320f, 0.08536633f, -0.01801999f, -0.05604564f, -0.26821384f, -0.09114019f, 0.13655040f, -0.09385183f, 
    0.04487126f, 0.04540246f, 0.00116878f, 0.02197222f, -0.03487882f, 0.04751581f, 0.01708028f, -0.09316698f, 
    -0.12299434f, 0.04550411f, 0.12025510f, 0.03085781f, 0.04909215f, -0.00926814f, -0.81288213f, 0.20821875f, 
    -0.06126276f, -0.02350722f, -0.15328522f, 0.00531265f, 0.07165791f, -0.02379561f, -0.20823860f, -0.36216378f, 
    0.15974288f, -0.12114898f, 0.02497561f, 0.14720568f, -0.01645387f, 0.03234443f, 0.01286453f, -0.03714436f, 
    -0.20942527f, 0.24502644f, -0.09128537f, -0.08013210f, -0.00916955f, -0.12232549f, -0.04545275f, -0.05561364f, 
    -0.18227071f, -0.32549971f, -0.31601447f, 0.10223661f, -0.01330127f, -0.02782499f, 0.05600245f, -0.08480930f, 
    0.05047898f, 0.37629598f, 0.01008112f, -0.03024008f, -0.24448819f, 0.03949141f, 0.14342272f, -0.12194147f, 
    0.00188769f, 0.15149079f, -0.09852415f, -0.10462944f, -0.40170407f, 0.01061771f, -0.07795918f, -0.12365624f, 
    0.10458671f, 0.03708897f, -0.01440109f, 0.04165542f, 0.12490416f, 0.16874222f, -0.03058574f, -0.05231978f, 
    -0.01035010f, 0.07111353f, 0.06987180f, 0.11202161f, -0.11032264f, 0.39693490f, 0.20192263f, 0.06542215f, 
    0.22393508f, 0.07013074f, 0.01222255f, 0.11045402f, 0.06642208f, 0.08028746f, -0.26576194f, 0.06683234f, 
    0.12598233f, 0.17150560f, 0.11080115f, -0.04454982f, 0.16628854f, 0.02631462f, -0.05026012f, -0.03079986f, 
    -0.17178209f, 0.07679066f, -0.09979807f, -0.16774923f, 0.11628403f, -0.12570219f, -0.00177393f, -0.50827211f, 
    0.12384348f, 0.16596982f, -0.06322403f, 0.13287713f, -0.15074529f, -0.10205469f, -0.00518421f, -0.03176284f, 
    0.16392057f, -0.10269585f, -0.13353050f, -0.00318006f, 0.03795175f, 0.17322673f, 0.00677034f, -0.05284769f, 
    -0.14447774f, -0.07913757f, -0.20150368f, -0.30238053f, 0.05056918f, -0.03862955f, 0.01986902f, 0.09868893f, 
    0.05879053f, 0.07968377f, -0.17044716f, -0.16375962f, 0.08616276f, -0.04316067f, 0.13046741f, -0.01779029f, 
    -0.13257241f, -0.01027095f, 0.06660643f, -0.14753877f, 0.02056341f, 0.05305865f, -0.13978788f, -0.00696626f, 
    -0.02726031f, 0.14927061f, -0.04193417f, 0.07007993f, -0.02702912f, -0.38790390f, -0.16299772f, 0.07474812f, 
    -0.06586301f, 0.07147349f, 0.10752686f, 0.09317773f, -0.01106553f, -0.21513699f, -0.18774050f, -0.01806924f, 
    -0.12053216f, 0.05064903f, -0.08665351f, -0.00346654f, 0.03884124f, 0.06409374f, 0.30373466f, -0.08103683f, 
    -0.04281446f, -0.04078169f, 0.12326248f, 0.11454568f, 0.11842356f, 0.07933950f, 0.21466286f, -0.19266151f, 
    -0.17633493f, 0.15254749f, 0.09010766f, -0.19125324f, 0.02517811f, 0.10900278f, -0.12806410f, 0.08220555f, 
    0.07445391f, 0.03581448f, 0.02901073f, -0.04106615f, 0.04086634f, -0.04742194f, -0.07348474f, -0.06525534f, 
    0.02039164f, -0.03140648f, 0.00424492f, -0.07979518f, -0.00732761f, 0.00822313f, -0.02370589f, -0.04317223f, 
    -0.06635229f, -0.06274158f, 0.05758306f, 0.06737381f, 0.03470237f, -0.02905636f, -0.02539111f, 0.01961294f, 
    -0.07758495f, -0.05116410f, -0.03859870f, 0.03093800f, 0.03438828f, 0.01196676f, -0.05216933f, -0.04143470f, 
    -0.00913569f, 0.05726533f, -0.06772636f, 0.03798043f, -0.08097280f, -0.03923762f, 0.00407488f, -0.09012780f, 
    0.03109176f, -0.04420147f, 0.02135134f, -0.08536628f, 0.06978050f, -0.05172406f, -0.04656165f, 0.01027237f, 
    -0.05109512f, -0.07823540f, -0.02817827f, 0.03773770f, 0.04604241f, -0.08426686f, 0.01903241f, -0.02066532f, 
    0.02709370f, -0.01684679f, -0.07722379f, 0.05867808f, -0.05161871f, -0.07840195f, 0.05158577f, -0.02392585f, 
    0.06930226f, 0.01426680f, 0.07334251f, -0.07879334f, -0.03539786f, 0.04982806f, -0.02635488f, -0.01473239f, 
    0.06206849f, 0.00908335f, 0.02258987f, -0.01243332f, 0.01055124f, -0.07028835f, -0.06703532f, -0.05696863f, 
    0.01862383f, -0.00402223f, -0.02887114f, 0.00143963f, -0.06551539f, -0.06312583f, 0.06387745f, 0.00577366f, 
    0.01761493f, -0.05204243f, -0.00948519f, -0.06393389f, -0.04190729f, -0.03971932f, 0.00378490f, 0.00162887f, 
    0.02995724f, -0.05799526f, 0.05275141f, -0.08581284f, 0.00425293f, -0.07665035f, -0.05971153f, -0.00488690f, 
    -0.07125377f, -0.01840509f, -0.04559221f, -0.08899168f, -0.02682135f, 0.04664494f, -0.07686337f, 0.04026318f, 
    0.06540924f, 0.06686602f, 0.01010911f, 0.01617689f, 0.01929551f, 0.04422240f, -0.03618720f, 0.01907869f, 
    -0.05448153f, -0.00502167f, -0.01601127f, 0.05534260f, -0.08553560f, -0.07762168f, -0.05314083f, -0.02630271f, 
    -0.03728732f, 0.06319921f, 0.02924429f, 0.01909757f, 0.00981532f, 0.03242398f, -0.05147232f, -0.06148662f, 
    -0.05019197f, -0.02648473f, 0.01466923f, -0.06109599f, -0.06547217f, 0.05276124f, -0.01672463f, -0.01055270f, 
    0.13685392f, -0.34096619f, -0.10361224f, -0.12121337f, -0.07598133f, 0.17754929f, -0.06199491f, 0.21882297f, 
    -0.01228870f, -0.00596799f, 0.14588529f, 0.31921926f, 0.05586126f, 0.08888542f, 0.15016446f, -0.01863957f, 
    -0.01119461f, -0.04877738f, 0.16045076f, -0.22968271f, -0.18764251f, -0.22615604f, 0.00659071f, -0.18588358f, 
    0.03999757f, -0.02917103f, -0.19174370f, 0.09146350f, -0.17271022f, -0.06392968f, 0.01733604f, -0.16071570f, 
    -0.04645826f, 0.11219459f, -0.19515498f, -0.02417938f, -0.20883709f, -0.04802425f, -0.18444642f, -0.00515327f, 
    -0.14182301f, 0.07998458f, -0.15100506f, 0.02902756f, 0.04281408f, 0.15132625f, -0.10229252f, 0.20162055f, 
    0.08235262f, 0.00899276f, -0.03945467f, -0.32706335f, 0.00789534f, 0.07620555f, -0.08564125f, 0.03231009f, 
    0.08978101f, 0.24352340f, 0.07634664f, 0.24257311f, -0.07010904f, 0.21579456f, -0.04391303f, -0.17538275f, 
    -0.17489922f, 0.28726810f, -0.08529558f, 0.09255002f, -0.01519339f, 0.02657591f, -0.16540739f, 0.12803508f, 
    -0.13543354f, 0.13849862f, 0.13169576f, 0.06011787f, 0.16327864f, 0.25124472f, -0.06671221f, 0.11674529f, 
    -0.11984345f, 0.04082375f, -0.31032354f, -0.23894896f, -0.06003038f, -0.18820855f, 0.03784419f, -0.00072422f, 
    -0.21594515f, 0.00395307f, -0.38793206f, -0.33262843f, -0.21729545f, -0.50199389f, -0.11520506f, 0.04294603f, 
    -0.11738911f, 0.14626674f, -0.00529013f, 0.06274056f, 0.13821064f, 0.13128035f, 0.01481709f, -0.22683311f, 
    -0.19311786f, 0.02427975f, -0.12543477f, -0.05889599f, 0.32744533f, -0.03390444f, -0.03406698f, 0.05079846f, 
    -0.05124043f, -0.02383013f, -0.21112095f, -0.00180521f, -0.07604164f, -0.03030045f, -0.19377398f, 0.18850692f, 
    0.06692823f, -0.11243004f, -0.06209650f, -0.11865146f, 0.01095734f, -0.13806000f, 0.19765554f, 0.23043562f, 
    0.04612724f, 0.01282190f, -0.00310170f, 0.34793681f, -0.16876407f, 0.00148248f, -0.24637602f, -0.08253361f, 
    -0.11591424f, 0.48854777f, 0.18203489f, -0.01583460f, -0.08711279f, 0.12750143f, -0.13660137f, 0.23359677f, 
    0.01894453f, 0.19452086f, -0.49662733f, 0.05534706f, 0.14855108f, 0.03702918f, 0.00993270f, -0.06120415f, 
    -0.10929218f, -0.00387988f, -0.08297160f, -0.12551358f, 0.02431658f, -0.00770565f, -0.02178693f, -0.02319285f, 
    0.09724822f, 0.03011033f, 0.04415515f, 0.04210056f, 0.11597788f, -0.12918875f, -0.19641447f, -0.03577169f, 
    0.23647709f, 0.25795206f, 0.36712489f, 0.11354501f, -0.02887749f, 0.08566898f, -0.12987126f, -0.09538087f, 
    -0.03837031f, -0.05708241f, -0.04821391f, -0.01352879f, 0.21060024f, 0.21413870f, 0.06114517f, -0.12756552f, 
    -0.01906086f, -0.08760823f, -0.01737533f, -0.01979511f, -0.00211263f, -0.03176452f, -0.28795785f, -0.03869157f, 
    -0.01827777f, 0.04955285f, 0.05884155f, 0.06135020f, 0.01368414f, -0.05211970f, 0.10597499f, -0.08446387f, 
    0.02399713f, 0.31331381f, 0.25570756f, -0.00537837f, -0.20161983f, 0.09086665f, -0.04831417f, 0.11398117f, 
    0.23680952f, 0.17648682f, 0.07285399f, -0.16980915f, 0.06541257f, 0.05560296f, -0.04072181f, 0.09202545f, 
    0.07414000f, 0.01875538f, 0.31893930f, 0.09064288f, 0.01180169f, 0.13449319f, -0.22128509f, 0.10302354f, 
    0.04536240f, -0.12535822f, 0.17980279f, 0.01603888f, 0.07128613f, 0.15121718f, -0.01389182f, 0.11674330f, 
    0.02773706f, -0.02814708f, 0.08781493f, 0.16518867f, -0.21664716f, 0.00545894f, -0.05698545f, 0.01188459f, 
    0.00533249f, -0.00290619f, -0.04469470f, 0.19913237f, 0.10735244f, -0.09945180f, 0.03638956f, 0.07209779f, 
    0.02118818f, -0.12705530f, -0.29828346f, -0.31928477f, -0.09649774f, 0.09298374f, -0.06314246f, -0.00278426f, 
    -0.01366263f, 0.12545563f, 0.04469839f, 0.19383469f, 0.14543761f, 0.12311301f, -0.01939267f, 0.01022698f, 
    0.08752937f, 0.07055812f, -0.09217744f, -0.18187314f, 0.15344103f, -0.10796034f, 0.23766440f, 0.19204222f, 
    -0.00936751f, 0.13729732f, 0.01916621f, 0.02825298f, -0.02194396f, 0.00849732f, 0.01559830f, -0.12742521f, 
    0.21002495f, 0.01963591f, 0.18003169f, 0.19306621f, -0.07867066f, -0.08760464f, -0.06891052f, -0.30812171f, 
    -0.09200629f, -0.04296519f, -0.04270409f, 0.04488225f, 0.09058126f, 0.08990770f, 0.18742557f, -0.07095819f, 
    -0.29152671f, -0.24323450f, -0.13709052f, 0.10177677f, 0.12626976f, 0.16882613f, -0.04590338f, 0.00500998f, 
    0.24909358f, 0.23055127f, -0.10844679f, -0.22578576f, -0.02989963f, -0.08341695f, 0.03378486f, 0.16192269f, 
    0.06422280f, 0.02487295f, 0.12155318f, 0.38865197f, 0.14968364f, 0.16245611f, 0.02596423f, 0.03765313f, 
    -0.17970265f, -0.05722120f, 0.01018421f, 0.17451680f, -0.17048819f, 0.09623080f, 0.09176426f, -0.04143823f, 
    -0.00926679f, -0.08709728f, 0.06990413f, 0.05723843f, 0.22886302f, -0.33885604f, -0.03526918f, -0.11827142f, 
    -0.09489153f, 0.05310143f, 0.09600745f, -0.04749413f, -0.05175829f, -0.02434481f, -0.06767502f, -0.41111475f, 
    0.10269599f, 0.16372609f, 0.16958041f, -0.27589440f, 0.04993188f, -0.10224365f, -0.07430888f, -0.09403171f, 
    -0.12537965f, -0.15073828f, -0.03373238f, 0.10337524f, -0.02208196f, 0.01414956f, 0.15614037f, -0.12318593f, 
    -0.10504024f, -0.18591362f, 0.02715514f, 0.06366294f, 0.02811376f, 0.12564945f, -0.06891943f, 0.11051908f, 
    -0.01687939f, -0.04871751f, -0.14990005f, -0.00045830f, 0.04635097f, -0.12961338f, 0.05931108f, 0.11997140f, 
    -0.05667314f, -0.11616371f, 0.13530359f, -0.09613298f, -0.07372004f, 0.06367204f, 0.04205864f, 0.16224214f, 
    -0.09690510f, 0.02578136f, -0.20155057f, 0.16339502f, 0.18296106f, -0.04746973f, 0.01842061f, -0.04451264f, 
    -0.19909942f, 0.26983592f, -0.29539821f, 0.00208480f, 0.06842864f, 0.09924801f, 0.09180948f, -0.14754811f, 
    0.05237236f, 0.02732879f, 0.02060189f, 0.00276118f, 0.17434838f, -0.15988545f, 0.07163224f, -0.15188906f, 
    0.03023869f, 0.01156192f, -0.08571518f, -0.07101091f, -0.02782039f, -0.00260663f, 0.19542846f, 0.08654246f, 
    0.17269215f, -0.02751290f, 0.23110105f, 0.14967375f, -0.15460299f, -0.01577091f, 0.03249383f, -0.04217197f, 
    -0.00165295f, -0.18274938f, 0.02785454f, -0.04636685f, -0.07958485f, -0.09531263f, -0.04551011f, 0.01445682f, 
    0.13179956f, 0.12575801f, 0.41352654f, 0.06791294f, -0.11477258f, 0.01269350f, 0.01071014f, 0.11218348f, 
    0.03486139f, -0.20234062f, 0.20926444f, -0.16559841f, -0.00924181f, 0.08650730f, -0.08846091f, -0.07802264f, 
    0.13853069f, 0.07719290f, 0.10515295f, 0.03226885f, -0.02644686f, -0.02510570f, -0.16872269f, -0.04856535f, 
    -0.01847712f, 0.00699770f, -0.03955725f, -0.22593841f, -0.06439188f, -0.08225048f, -0.02041572f, 0.08759245f, 
    0.08709411f, -0.04310292f, 0.04219135f, 0.09359426f, -0.05766389f, -0.02017082f, 0.35512507f, -0.11051843f, 
    0.00554340f, -0.05459533f, -0.06529228f, 0.01058150f, 0.11764940f, -0.49688372f, 0.20022826f, 0.03907086f, 
    -0.11046647f, -0.05315860f, 0.14127992f, 0.06428809f, 0.10598159f, -0.05155514f, -0.15730210f, 0.31270212f, 
    -0.11978918f, -0.11910386f, -0.15540421f, -0.22266601f, 0.05086369f, 0.02461428f, -0.00185013f, -0.24096130f, 
    0.04357256f, 0.19930834f, -0.00084318f, -0.07813168f, -0.16143966f, 0.08552744f, -0.03343925f, 0.02955841f, 
    0.00085020f, -0.09758899f, 0.09304328f, -0.14223704f, 0.12513737f, -0.14302716f, 0.07789411f, 0.10585719f, 
    0.01279005f, 0.23967083f, -0.14808984f, 0.30129969f, 0.07178257f, -0.02472585f, -0.07376434f, 0.10457528f, 
    0.01979838f, 0.05132640f, 0.04314297f, -0.25937992f, 0.16049370f, -0.09103526f, 0.02254886f, -0.00994075f, 
    -0.01028660f, -0.02723818f, -0.03587586f, 0.40227354f, 0.04548654f, -0.00525199f, -0.07880178f, -0.05767101f, 
    0.07113577f, -0.03298051f, -0.01773644f, -0.13609920f, -0.04667161f, 0.15608191f, 0.23430939f, 0.01482465f, 
    0.06260671f, -0.04007908f, 0.05902014f, 0.07985083f, 0.12172460f, -0.51325566f, 0.12046239f, 0.13858443f, 
    0.07037434f, -0.04963626f, -0.05523896f, 0.03061740f, -0.05183026f, -0.07159984f, -0.09100505f, 0.09393784f, 
    -0.13238578f, -0.06045577f, -0.10311192f, 0.16904849f, 0.09576701f, 0.07972091f, 0.11837640f, -0.15622605f, 
    0.14035079f, 0.12647860f, -0.01016364f, -0.18931784f, -0.06686547f, 0.03654602f, 0.04339763f, -0.07120248f, 
    0.07926714f, 0.15488738f, 0.24210881f, 0.01884997f, 0.10976025f, 0.06237105f, 0.24194461f, -0.29553050f, 
    -0.09425503f, -0.07816521f, -0.20689692f, -0.16428991f, 0.00093082f, 0.10464326f, -0.07820098f, -0.03823043f, 
    0.10808782f, 0.05235489f, 0.15639956f, 0.10510769f, -0.02821585f, -0.00458394f, 0.02092672f, 0.04013650f, 
    0.01381299f, 0.04616279f, -0.03007454f, 0.06056634f, 0.24369085f, -0.03503232f, 0.13202053f, 0.04294698f, 
    0.01826157f, 0.05590471f, -0.03395096f, -0.05197081f, 0.02590000f, -0.08677591f, -0.15984324f, -0.07465784f, 
    0.12758118f, -0.01531980f, 0.04074921f, -0.01403184f, -0.09754421f, -0.09444693f, -0.29977447f, -0.10343383f, 
    0.07186604f, -0.06472830f, 0.01029682f, 0.09317075f, 0.11197204f, 0.08878677f, 0.10724541f, -0.17738044f, 
    -0.08705057f, 0.01973924f, -0.02116918f, -0.06655368f, -0.02608150f, -0.02488745f, 0.02140178f, -0.13749766f, 
    -0.09620418f, -0.16186343f, -0.09281526f, -0.00094434f, 0.02293733f, 0.08069921f, 0.03981891f, 0.11570491f, 
    -0.12435357f, -0.23218936f, -0.02603350f, 0.04919505f, 0.08196135f, 0.03774260f, 0.08018932f, 0.08800799f, 
    -0.11249174f, -0.07490405f, 0.15591682f, 0.37263891f, -0.11480358f, 0.05748537f, -0.01716721f, 0.16042477f, 
    -0.02095740f, 0.10276978f, 0.10900909f, 0.07835744f, 0.04125063f, 0.00079406f, 0.01936588f, 0.03567222f, 
    0.08585165f, -0.06462342f, 0.05212736f, 0.13230020f, -0.11074120f, 0.10595068f, -0.01953784f, -0.04984624f, 
    -0.14762883f, 0.02563148f, -0.08011613f, 0.04983420f, 0.14127821f, 0.28558800f, 0.21323748f, -0.00591524f, 
    0.18795967f, -0.03886721f, -0.14214294f, -0.02585055f, 0.06693197f, -0.24335483f, -0.39523450f, 0.06546799f, 
    0.02564233f, 0.01167094f, -0.01448099f, 0.00307947f, -0.05885290f, -0.11200062f, -0.11041743f, 0.16325749f, 
    0.12573414f, -0.07396600f, 0.13100737f, 0.09709080f, 0.00670037f, 0.17435689f, -0.07439856f, -0.15644675f, 
    -0.05746500f, -0.07284079f, -0.00095707f, 0.13283257f, -0.08433060f, -0.02438484f, 0.12397563f, -0.06696926f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.17556474f, 0.18393292f, 0.00195210f, -0.09012575f, -0.02295052f, 0.15273130f, -0.03033593f, -0.19475806f, 
    0.08220705f, 0.25413898f, -0.01414571f, -0.04512834f, -0.10926571f, 0.16510057f, -0.01660176f, 0.05384497f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.05111020f, -0.30162761f, 0.13785797f, -0.23071456f, 0.01345755f, -0.06331917f, -0.30506569f, 0.40696338f, 
    0.37127843f, 0.00564415f, 0.14378214f, -0.55213118f, 0.15655448f, 0.14939184f, -0.19168057f, 0.37263468f, 
    0.28934035f, 0.26295710f, 0.14884409f, -0.25743324f, -0.07861095f, -0.04546129f, -0.15192543f, 0.24162148f, 
    0.23313144f, -0.12898803f, -0.08286013f, -0.03819413f, 0.16236386f, 0.16905561f, -0.26569930f, 0.29005486f, 
    0.21214500f, -0.27956399f, -0.04727714f, 0.20078903f, -0.00345707f, 0.10660957f, 0.20065840f, -0.39399099f, 
    0.57746994f, -0.00348129f, -0.20039468f, 0.39095822f, -0.32569370f, -0.30297160f, -0.09263896f, 0.25675672f, 
    -0.25329313f, -0.27533558f, 0.10760233f, 0.23058693f, -0.04899989f, 0.04840923f, -0.12133749f, -0.11761244f, 
    -0.13993540f, 0.29595616f, 0.11073817f, 0.40275449f, -0.09576437f, 0.29015002f, 0.11124985f, -0.21890271f, 
    -0.77191085f, 0.07629690f, 0.03828472f, 0.06047562f, 0.08911544f, -0.10226060f, -0.19729857f, 0.52918488f, 
    -0.32411957f, -0.16214475f, -0.11861581f, -0.08346072f, 0.25259599f, 0.17727652f, 0.07581752f, -0.05236229f, 
    0.31808275f, 0.08613028f, -0.18459243f, -0.12384109f, 0.06246556f, 0.13229527f, -0.09308103f, 0.11634957f, 
    0.55460858f, -0.11282851f, -0.07825062f, -0.22626638f, 0.01440779f, 0.02788033f, -0.00048422f, 0.17447726f, 
    -0.22828782f, -0.25980511f, 0.22616002f, 0.09181058f, -0.08360412f, 0.11520313f, -0.22915608f, -0.26754373f, 
    -0.34784892f, 0.49319828f, 0.20731658f, 0.25282151f, 0.21307173f, 0.32363167f, -0.02746384f, -0.07446625f, 
    -0.44694290f, 0.43450594f, 0.11938469f, 0.06879584f, 0.13520037f, -0.06703535f, -0.21017691f, 0.09688545f, 
    -0.82447213f, -0.02713992f, -0.04871604f, 0.19652019f, -0.10815551f, 0.13328262f, 0.42877075f, 0.01110581f, 
    -0.00990955f, -0.19646475f, -0.00562947f, -0.05909799f, 0.20144159f, -0.11714364f, 0.10927001f, -0.22937937f, 
    -0.55328006f, -0.08601756f, 0.11150009f, 0.25441983f, 0.18355830f, 0.38576475f, 0.47561955f, -0.04097326f, 
    0.19223274f, 0.29213789f, -0.11706904f, -0.12881353f, 0.21708085f, -0.01864134f, 0.27685434f, 0.51061338f, 
    -0.16292015f, -0.34847635f, 0.10626571f, 0.07305937f, 0.12266061f, 0.06886608f, -0.21158987f, 0.33933955f, 
    -0.56704241f, 0.38439161f, -0.23720928f, -0.16296162f, -0.20583338f, 0.33032036f, -0.11383741f, -0.18822150f, 
    -0.45959687f, 0.41279480f, -0.15870973f, -0.42030197f, 0.23042428f, 0.05678353f, 0.27616432f, -0.09840494f, 
    0.13426000f, 0.19327331f, -0.20958364f, -0.13064805f, 0.06959760f, 0.12548171f, 0.00809305f, -0.08561920f, 
    0.11147501f, -0.24061467f, -0.05270934f, 0.08516744f, 0.37795350f, 0.06960920f, -0.31866002f, 0.19947797f, 
    -0.23368177f, -0.04457304f, 0.19839892f, -0.23051053f, 0.00192326f, -0.04127109f, -0.22216934f, -0.06951371f, 
    0.06592050f, -0.03085285f, 0.12824214f, -0.09814906f, -0.21016347f, -0.17619985f, -0.23262438f, -0.24081689f, 
    0.46309194f, -0.29398236f, -0.02121404f, 0.19718242f, 0.15053773f, 0.17645960f, 0.34555602f, 0.30707997f, 
    0.46869010f, -0.25492352f, 0.15664765f, 0.18723457f, -0.20909166f, 0.16732091f, -0.18373591f, 0.11945540f, 
    -0.17672209f, -0.32573548f, 0.19605426f, 0.26713249f, 0.07706687f, -0.03865650f, -0.40611833f, 0.22282800f, 
    -0.32435226f, 0.00647438f, 0.03593609f, 0.13015778f, 0.12755430f, 0.28411102f, -0.21848372f, -0.10425023f, 
    0.07809049f, -0.04187518f, -0.00369220f, 0.29151025f, 0.18213439f, -0.17014739f, 0.11268643f, 0.35028574f, 
    -0.47420985f, 0.36547047f, -0.08660606f, 0.59442782f, -0.42995533f, -0.43773553f, -0.21835335f, -0.16520679f, 
    -0.24882060f, 0.50424898f, -0.04179652f, -0.20301242f, 0.06826475f, -0.21888025f, 0.04931324f, 0.25319132f, 
    0.08374240f, -0.15829316f, -0.09618211f, 0.18423671f, 0.15382396f, 0.04898772f, -0.22218265f, 0.28470975f, 
    -0.25130644f, -0.21741819f, -0.10013874f, 0.16163532f, 0.06827718f, -0.28464466f, -0.28318837f, -0.13130024f, 
    -0.14654383f, -0.05907213f, -0.20781529f, -0.15658961f, 0.01836981f, -0.27694771f, -0.21836007f, 0.02480887f, 
    0.24070455f, 0.08483496f, 0.07963750f, -0.04265924f, -0.24563709f, -0.09597468f, 0.01544040f, -0.19682536f, 
    -0.24740410f, -0.13773701f, -0.02895793f, 0.63729221f, -0.16483451f, -0.14039454f, -0.55352390f, 0.22103369f, 
    0.25341073f, -0.19730355f, 0.12281844f, 0.14449127f, 0.09289896f, 0.18208158f, 0.13055249f, -0.39779857f, 
    0.04865757f, -0.12741980f, 0.00283184f, -0.24805067f, 0.03391318f, -0.00024862f, -0.36166570f, 0.08469174f, 
    -0.04335316f, -0.45903209f, 0.15144524f, 0.31875625f, -0.04583523f, 0.19824606f, 0.05262847f, -0.07345553f, 
    0.18778631f, 0.40565252f, -0.06863308f, 0.16427256f, -0.36847663f, -0.24422906f, -0.24877457f, -0.22941777f, 
    0.03733367f, -0.20447458f, -0.12765850f, 0.31374577f, 0.12321624f, -0.27508554f, -0.04255921f, 0.56758767f, 
    -0.26452458f, -0.19644405f, -0.08123481f, -0.05405550f, 0.46096599f, 0.12759809f, -0.29626903f, -0.14813231f, 
    -0.16636917f, 0.04606557f, -0.24039094f, -0.17521942f, -0.05262578f, -0.20395759f, -0.14726335f, 0.00764304f, 
    -0.09589607f, -0.00621763f, 0.04834259f, 0.18604162f, -0.17309879f, -0.13225506f, -0.01415576f, 0.03340407f, 
    0.08843897f, -0.19564441f, 0.00815725f, 0.11862171f, -0.03876030f, -0.20687594f, -0.13559432f, -0.11581579f, 
    -0.13586807f, -0.23357533f, -0.24610400f, -0.10270556f, 0.03357484f, -0.19483553f, -0.07733035f, 0.04130864f, 
    -0.05289840f, 0.08006536f, -0.22383687f, -0.13479951f, -0.17425945f, 0.16553652f, 0.36394209f, 0.13125180f, 
    0.10598119f, 0.05423537f, 0.23290378f, 0.66312897f, -0.22623387f, -0.06681637f, -0.82214612f, -0.52510905f, 
    -0.17278002f, 0.13076533f, -0.18909806f, -0.09444510f, 0.11136454f, -0.11469120f, -0.28151244f, 0.12202980f, 
    0.12594713f, -0.06545315f, 0.07068571f, 0.05344734f, -0.00560569f, -0.14964914f, -0.00327593f, -0.06773958f, 
    0.58764857f, 0.02594906f, 0.14212273f, 0.05588236f, -0.21822515f, 0.06756122f, 0.02835507f, 0.20035011f, 
    0.28763342f, -0.16448213f, -0.10151047f, 0.09769815f, -0.30168128f, 0.06930400f, 0.01867312f, 0.07878531f, 
    -0.17317313f, 0.39333478f, -0.12358699f, 0.14018601f, -0.09475677f, -0.02800983f, 0.38629851f, 0.42940316f, 
    0.02209228f, -0.13736345f, 0.05665937f, 0.07058480f, 0.27606699f, 0.10690733f, -0.47226200f, -0.19633697f, 
    -0.42551807f, -0.03011492f, 0.09887376f, 0.26040486f, 0.09626544f, -0.22179171f, 0.12291037f, -0.12290621f, 
    0.39510861f, 0.06517740f, -0.12384325f, 0.40496823f, -0.26522419f, -0.05328513f, -0.01532457f, 0.03522749f, 
    0.01691274f, 0.05789325f, 0.13418558f, -0.19438538f, 0.23160496f, -0.23696578f, -0.21918948f, -0.14792168f, 
    0.05515572f, 0.22142272f, -0.15403187f, -0.21893987f, -0.07515976f, 0.15154786f, 0.12540722f, -0.23092493f, 
    0.16769461f, 0.08737174f, -0.19578965f, 0.00353187f, -0.09900613f, 0.08857822f, 0.00631334f, -0.07930867f, 
    0.00554508f, 0.31010890f, -0.03518507f, 0.25874159f, -0.11065533f, 0.28262666f, -0.01457485f, -0.16995113f, 
    0.35520688f, -0.32108143f, 0.10381424f, -0.00529190f, -0.19910870f, -0.16929908f, -0.04147477f, -0.33088326f, 
    0.23597269f, 0.28613892f, 0.21036154f, 0.26153409f, 0.21449646f, -0.22591256f, -0.00636240f, 0.25802657f, 
    -0.19250418f, -0.02181014f, -0.03709514f, 0.13933292f, 0.22171819f, 0.24225566f, 0.40038258f, 0.28879538f, 
    0.00208693f, -0.42738247f, -0.08314687f, -0.52190661f, -0.34091902f, -0.14038460f, 0.36445993f, 0.31344068f, 
    0.10699765f, -0.41239959f, 0.16151470f, 0.10645971f, 0.00739878f, 0.24484298f, 0.21395741f, -0.08056146f, 
    0.05036977f, 0.15015090f, 0.10256144f, -0.00417078f, -0.28820765f, -0.24454080f, 0.01107380f, 0.01295352f, 
    0.38659874f, -0.80524576f, 0.01878738f, 0.36279008f, 0.22046693f, 0.10258489f, -0.19603045f, -0.34289306f, 
    -0.15312663f, -0.07639546f, 0.10226625f, -0.03162933f, -0.31841764f, 0.12281594f, -0.02237874f, 0.37185541f, 
    -0.33714485f, -0.23154518f, 0.02644262f, -0.03827687f, 0.12014103f, 0.33934358f, -0.03333648f, 0.26386872f, 
    0.14411606f, 0.59300923f, 0.15226297f, -0.12205306f, -0.15033919f, -0.13204698f, -0.22277628f, -0.27991679f, 
    -0.40034667f, 0.17921098f, 0.08585120f, -0.13491593f, -0.20627069f, 0.00674492f, -0.19827570f, 0.03495385f, 
    -0.52415961f, 0.18156576f, -0.19644484f, -0.37493891f, 0.00592300f, 0.29783615f, 0.37315717f, 0.25950909f, 
    -0.34400260f, -0.32504568f, -0.03761069f, -0.15658347f, -0.15543956f, 0.25557610f, -0.38956764f, -0.09843652f, 
    -0.27828652f, 0.25814569f, -0.06238566f, -0.05114900f, -0.30519822f, 0.14053552f, 0.31456646f, 0.09834676f, 
    -0.27481025f, 0.51901525f, -0.16074333f, 0.14543864f, 0.16037732f, 0.06346969f, -0.16755857f, 0.46374646f, 
    -0.34996271f, -0.02029590f, -0.12303019f, -0.36401919f, 0.41476545f, -0.02387384f, -0.39228046f, -0.26176006f, 
    -0.43455404f, -0.29154015f, 0.17418659f, 0.00941841f, -0.00485889f, -0.03503029f, 0.16948454f, 0.53244257f, 
    -0.18238671f, -0.34903657f, -0.03622260f, -0.26114094f, 0.16518085f, -0.05649519f, 0.15100078f, 0.27839220f, 
    -0.26684189f, -0.05046313f, 0.14569673f, 0.10248771f, 0.14886984f, -0.17106874f, -0.42193857f, 0.23100129f, 
    -0.04869970f, 0.14146179f, -0.12507665f, -0.06709097f, 0.14109099f, -0.07369262f, 0.36153334f, 0.34440061f, 
    0.28702167f, -0.24274121f, -0.14249797f, -0.21513315f, 0.11745573f, 0.16680869f, -0.05344120f, -0.41284075f, 
    0.08072476f, -0.02021862f, -0.05919972f, 0.54419404f, -0.05344315f, 0.46577927f, 0.05842929f, 0.37186450f, 
    -0.05564464f, -0.38895267f, 0.21668829f, 0.04243967f, -0.04398319f, -0.10342731f, -0.21959125f, 0.27481011f, 
    0.30207503f, 0.03857230f, 0.20083737f, -0.16002192f, -0.01428445f, 0.21669577f, 0.32107380f, 0.13497676f, 
    0.18979532f, -0.43443933f, 0.06282497f, -0.05395406f, -0.04656985f, 0.14725462f, -0.20223026f, 0.44957936f, 
    -0.24228057f, 0.38810349f, 0.00840417f, -0.33915144f, -0.06770752f, 0.32586417f, -0.25005323f, 0.19552319f, 
    0.18634997f, -0.18273373f, -0.15839466f, -0.11769012f, -0.19804370f, 0.13322313f, -0.51106036f, -0.41667855f, 
    0.02710295f, 0.22472970f, -0.22197060f, -0.87538838f, -0.02898813f, 0.40047678f, 0.17475538f, 0.24399468f, 
    0.20690544f, -0.26766527f, -0.18598811f, 0.01578027f, -0.22238065f, 0.10539611f, -0.07583628f, -0.04206880f, 
    -0.09830543f, 0.44597086f, 0.03856632f, -0.08195245f, -0.11406893f, 0.07301612f, -0.17590080f, 0.02003419f, 
    -0.30653819f, -0.24036691f, 0.03501977f, -0.08074825f, 0.12197071f, 0.07461814f, 0.13020864f, -0.03695663f, 
    0.11511269f, -0.05029954f, 0.04403341f, 0.16573370f, 0.06855348f, 0.02295260f, 0.43124893f, 0.19030127f, 
    -0.11360641f, -0.09625605f, -0.04179748f, -0.21999945f, -0.09287591f, 0.10509836f, 0.15515858f, -0.29067090f, 
    0.42537820f, -0.02774061f, -0.24965589f, -0.08885157f, 0.27688670f, -0.24494240f, 0.17064312f, 0.20295174f, 
    -0.12710388f, 0.06949486f, -0.23342583f, -0.09914887f, 0.21999663f, -0.12588227f, 0.28261569f, -0.00004458f, 
    -0.15762395f, 0.33961335f, -0.22597864f, -0.31858194f, -0.17341985f, 0.15985644f, -0.37047824f, -0.02488779f, 
    0.21713568f, -0.34586936f, -0.21501774f, 0.01889532f, 0.15828376f, 0.10220405f, -0.31378338f, -0.05643838f, 
    -0.48376998f, 0.39024273f, -0.22394451f, 0.29226387f, 0.09670595f, 0.17600586f, 0.37892917f, -0.09016492f, 
    -0.03831556f, 0.16317797f, -0.21757776f, 0.06281710f, -0.21628523f, -0.26672557f, -0.23338814f, -0.13717230f, 
    0.07612079f, 0.27730229f, 0.16338491f, -0.06254414f, 0.26595169f, 0.13011193f, 0.28178239f, -0.09302974f, 
    -0.08714339f, -0.15210755f, 0.14171055f, 0.11524376f, -0.16669470f, -0.12806201f, -0.13540863f, 0.22328426f, 
    -0.19803590f, -0.13297538f, 0.13470736f, 0.16229446f, -0.20091939f, 0.03339965f, 0.03647939f, -0.27428794f, 
    0.26639491f, -0.08162069f, -0.22602634f, 0.20573986f, 0.02479008f, 0.08364929f, 0.36415932f, -0.17603387f, 
    0.76592821f, -0.06667442f, -0.13177216f, 0.07779787f, -0.21319130f, -0.00373626f, -0.09600346f, -0.31722632f, 
    -0.11581127f, 0.02886538f, 0.06029665f, -0.21774291f, -0.11352426f, -0.22828466f, -0.25777429f, -0.02032370f, 
    0.16436075f, 0.15227084f, -0.12265342f, -0.22244844f, -0.03390341f, 0.17648484f, -0.18739434f, -0.15496622f, 
    0.37166062f, 0.09735851f, 0.20408569f, -0.12879348f, 0.01927728f, 0.09805433f, 0.20900562f, -0.27790195f, 
    -0.54256278f, 0.36383209f, 0.07549258f, -0.06568561f, -0.15447620f, -0.15111104f, 0.16744547f, -0.03624343f, 
    -0.07162948f, 0.04359967f, 0.21587883f, -0.29225692f, -0.02304585f, 0.16158859f, -0.24419758f, -0.16115797f, 
    -0.13082826f, 0.08879548f, -0.23584148f, -0.17872724f, 0.04890680f, 0.45067620f, -0.01777013f, 0.12994786f, 
    0.45065615f, 0.27493975f, -0.18025856f, -0.06487568f, 0.18919630f, 0.36733752f, 0.27730593f, 0.38905632f, 
    0.02294572f, -0.02881886f, 0.17229083f, -0.27260995f, -0.11381266f, -0.15660027f, -0.19681917f, -0.12244204f, 
    -0.21393932f, -0.13838144f, -0.14519247f, -0.13690414f, 0.14661974f, 0.17473328f, -0.07662997f, -0.36546513f, 
    0.31537670f, -0.17292143f, 0.22969393f, 0.11853687f, 0.25744992f, -0.17474701f, 0.14365613f, 0.44819334f, 
    -0.00106460f, 0.31460658f, 0.10367573f, -0.11397655f, -0.22153375f, -0.12548247f, -0.05014339f, -0.00317231f, 
    -0.10297097f, 0.19501722f, -0.18566263f, 0.33914235f, -0.00571999f, 0.08400058f, 0.29747349f, 0.04666115f, 
    -0.12114983f, -0.01844001f, -0.16072851f, 0.14776546f, -0.05540258f, 0.14325204f, -0.19444425f, 0.15777168f, 
    -0.52135462f, -0.05349136f, -0.08206048f, 0.44649357f, -0.21747795f, 0.33020371f, 0.40094486f, 0.23369604f, 
    0.53682733f, -0.49731073f, -0.18249272f, 0.34233499f, 0.22019318f, -0.11350167f, 0.05813095f, 0.47336790f, 
    -0.11446658f, 0.24789467f, 0.06216344f, 0.06320302f, -0.28257775f, -0.01770374f, -0.08349513f, -0.28741625f, 
    0.41574988f, -0.13427198f, -0.22688612f, -0.06860470f, -0.23063298f, 0.22614904f, 0.00674664f, -0.21677881f, 
    0.35011780f, -0.17718455f, -0.22157709f, -0.48624861f, 0.00332506f, -0.22971073f, 0.29635605f, 0.16673422f, 
    -0.26051441f, 0.19599082f, 0.19516101f, 0.15957330f, -0.23908494f, -0.11703733f, -0.11493728f, -0.01367639f, 
    -0.10302848f, 0.12431528f, -0.02305162f, 0.28493717f, -0.06960899f, 0.30551261f, -0.05785267f, -0.11034404f, 
    -0.29727504f, 0.25685036f, 0.04799849f, 0.05783318f, -0.06669608f, 0.38049778f, 0.35744429f, 0.22089580f, 
    -0.09144563f, -0.00238685f, -0.16182905f, -0.58466315f, -0.39822221f, -0.06733868f, -0.06282283f, -0.00886369f, 
    -0.22751437f, 0.26497844f, 0.04078531f, 0.22763978f, -0.03586364f, 0.27556109f, -0.17680176f, 0.01107571f, 
    0.79164135f, -0.15152439f, -0.15353540f, 0.32891792f, 0.15719624f, 0.10510109f, -0.39027300f, -0.45458898f, 
    0.18812807f, -0.12576249f, -0.04349543f, 0.02206391f, 0.00190121f, -0.02292742f, -0.25918618f, -0.17401750f, 
    0.08370752f, 0.32692882f, 0.19621994f, -0.12331074f, 0.23030953f, 0.07051203f, -0.07276317f, -0.06742455f, 
    -0.19338797f, -0.08154237f, 0.04264704f, -0.03261298f, -0.06115696f, 0.32751623f, -0.13308160f, 0.24772295f, 
    -0.70750684f, -0.30108988f, -0.22874539f, 0.46990198f, -0.01205258f, 0.24265546f, 0.32917228f, 0.32364404f, 
    -0.79802710f, 0.05081497f, 0.17029217f, 0.03925769f, 0.09719360f, -0.29089683f, -0.14602457f, 0.42757928f, 
    0.02785001f, 0.14576794f, 0.04908764f, 0.07483295f, 0.16307476f, 0.07116943f, -0.16385286f, 0.08686148f, 
    0.26929104f, 0.19826074f, -0.09281591f, -0.13765658f, 0.02388563f, 0.31527513f, -0.14966162f, -0.15272914f, 
    0.35432845f, -0.24946840f, 0.09651936f, -0.06401914f, -0.01212598f, -0.14291953f, -0.01424218f, 0.41117680f, 
    0.34548870f, -0.10614486f, -0.01371128f, -0.15261620f, -0.18413898f, -0.16434817f, 0.53272206f, 0.45702741f, 
    0.40909988f, 0.00578481f, 0.06018903f, -0.54172760f, -0.16529842f, -0.32796252f, 0.27035207f, 0.24833992f, 
    0.09851706f, -0.10283843f, 0.04810467f, -0.15179543f, -0.03079238f, -0.25977689f, 0.05167164f, 0.09965755f, 
    -0.08478704f, 0.07063524f, -0.21048081f, 0.09028408f, -0.21443859f, 0.20036733f, -0.10738389f, -0.06810398f, 
    -0.34227630f, -0.33375314f, -0.20428771f, 0.02202889f, 0.05158028f, 0.35660285f, -0.10115644f, 0.31497902f, 
    -0.27157220f, 0.05193418f, -0.20526493f, 0.06107787f, 0.00667501f, 0.24140392f, 0.12505567f, -0.07253896f, 
    -0.00333205f, -0.02459534f, 0.08389413f, 0.02956583f, 0.05813223f, 0.32093215f, -0.27134594f, -0.56933475f, 
    -0.23644184f, 0.41940030f, 0.03222173f, -0.32221398f, 0.25871810f, -0.15599796f, -0.36388177f, -0.35044202f, 
    -0.27949521f, -0.40161800f, 0.23753141f, 0.17217916f, -0.24688753f, 0.37027076f, 0.24752164f, 0.05306333f, 
    -0.06768724f, 0.17098880f, 0.18356481f, 0.04365324f, -0.18874449f, 0.01889100f, -0.14621787f, -0.27352828f, 
    0.26557040f, 0.10806315f, -0.11757279f, -0.13472746f, -0.04693282f, 0.12764762f, -0.08064924f, -0.33738258f, 
    0.14984475f, 0.16054742f, -0.19703642f, -0.23723212f, 0.08249550f, 0.26748860f, 0.16304410f, -0.14175713f, 
    0.47142586f, -0.21556818f, -0.08490190f, -0.01996066f, -0.17710412f, 0.13989629f, 0.20526075f, -0.22611402f, 
    0.16619852f, -0.21107872f, -0.15871453f, 0.23866116f, -0.16046369f, -0.18221453f, 0.40839246f, 0.11351681f, 
    -0.18373556f, 0.12571137f, 0.13558617f, -0.02668893f, 0.04170259f, 0.42048982f, -0.11628469f, -0.20461114f, 
    -0.27127674f, 0.00561499f, -0.15389739f, 0.02017393f, 0.13000382f, -0.19476408f, -0.27139881f, 0.16262409f, 
    0.21417974f, 0.14910948f, 0.08923260f, 0.11137604f, -0.00602052f, 0.21958384f, 0.19503738f, -0.33110633f, 
    0.25762561f, 0.35374790f, -0.12565227f, -0.68354082f, -0.24533436f, -0.13107607f, 0.01408644f, 0.03621795f, 
    -0.05959940f, -0.05241480f, -0.24860439f, -0.23560429f, -0.09484497f, -0.12675941f, 0.08064654f, -0.05679327f, 
    -0.17291811f, -0.02558035f, -0.19817233f, -0.20063695f, -0.06529370f, -0.00454208f, -0.06445438f, -0.21641800f, 
    0.17492215f, 0.45823926f, 0.10298136f, -0.08905894f, -0.15832889f, -0.24045180f, -0.08905343f, 0.28938526f, 
    -0.02551631f, 0.23680966f, -0.13083315f, 0.18100928f, -0.13877913f, 0.33199582f, 0.19107595f, 0.09598550f, 
    0.07759032f, -0.24001583f, -0.04740441f, -0.01627740f, -0.12508318f, -0.19594413f, -0.09674236f, 0.03461713f, 
    -0.00992799f, 0.10159153f, 0.09204978f, -0.23824108f, -0.09412247f, -0.24948820f, -0.14134431f, 0.09477097f, 
    -0.04807337f, 0.17833959f, 0.18070614f, -0.19446348f, 0.19945690f, 0.30670032f, 0.04350771f, -0.17383920f, 
    -0.00505051f, 0.22057527f, -0.04803176f, -0.19471762f, 0.07796776f, -0.05826465f, -0.24187671f, 0.02795918f, 
    -0.56016076f, 0.28386891f, -0.18424484f, 0.09967960f, -0.24496213f, -0.22041683f, -0.07548960f, 0.12037756f, 
    -0.28738186f, -0.04171147f, -0.12865764f, 0.38139388f, 0.25278497f, 0.38559520f, 0.35853156f, -0.17584230f, 
    0.18228035f, 0.02555140f, 0.07562755f, -0.11173958f, -0.04609558f, -0.09813927f, 0.41013765f, 0.51946038f, 
    0.12760474f, 0.05307480f, 0.21372536f, -0.15041712f, 0.27363074f, -0.18784206f, -0.16719410f, 0.01567560f, 
    0.39624956f, -0.30202898f, 0.04760125f, 0.11929800f, 0.19263658f, 0.00462682f, 0.26602080f, -0.14355738f, 
    -0.37666488f, -0.44727743f, -0.18022677f, -0.01046651f, 0.22410288f, -0.14573206f, 0.47193915f, -0.03295065f, 
    -0.35549048f, -0.38201261f, -0.03134186f, 0.34934950f, -0.00743026f, 0.03339012f, 0.29845011f, -0.04753388f, 
    -0.17761436f, 0.18229489f, 0.19420663f, -0.33720011f, -0.32837623f, 0.16606870f, -0.10472190f, 0.05858548f, 
    0.28446507f, -0.01056063f, -0.13448729f, 0.20201366f, -0.23253714f, -0.04322750f, -0.11175101f, -0.04365860f, 
    0.23366538f, 0.14602083f, -0.20031931f, 0.09850703f, 0.05978981f, -0.09421881f, -0.36369669f, 0.14122185f, 
    0.24920417f, 0.21508326f, 0.07759679f, -0.26181522f, 0.09384993f, -0.00755446f, 0.18717274f, -0.27858165f, 
    0.55389702f, 0.13774922f, 0.07747641f, -0.64044261f, 0.03010395f, 0.03569480f, 0.31633210f, 0.11447902f, 
    0.32560542f, -0.11910023f, -0.21086594f, 0.30145293f, -0.01528527f, -0.06018113f, -0.00829267f, -0.23614612f, 
    0.00641000f, 0.40926898f, -0.04815242f, -0.08694156f, -0.34312496f, -0.06092418f, 0.45604044f, -0.18584353f, 
    0.13850942f, -0.26729268f, 0.06970289f, 0.31816930f, 0.02363306f, 0.23780747f, 0.17138535f, -0.28368622f, 
    0.11070207f, 0.00096689f, -0.02634982f, 0.16518632f, -0.13749854f, -0.13968615f, -0.03128190f, -0.02724790f, 
    0.39545667f, -0.14458220f, 0.10071032f, 0.01700133f, -0.07137330f, -0.03358309f, -0.37122285f, 0.18016817f, 
    -0.24415140f, 0.44100198f, 0.21782085f, -0.35198095f, 0.12582053f, -0.04353628f, -0.00990618f, -0.06495254f, 
    0.18255387f, -0.33638915f, -0.11013094f, 0.18542385f, -0.08197074f, 0.07349300f, -0.30229217f, -0.08992342f, 
    -0.27570289f, 0.28100708f, 0.22671217f, 0.06577114f, 0.30517763f, -0.06008292f, -0.27931368f, -0.10412368f, 
    0.39577332f, -0.13789503f, 0.15029469f, 0.22348295f, 0.12708163f, 0.17150612f, 0.09379551f, -0.08856740f, 
    -0.08141423f, -0.06249719f, -0.22065201f, 0.10700188f, -0.14197853f, -0.20445383f, 0.08044679f, -0.25408286f, 
    0.12197252f, -0.19654198f, -0.09688479f, 0.19826175f, -0.24170551f, -0.06830384f, -0.29563403f, -0.20296437f, 
    -0.29216430f, 0.25945333f, -0.16645031f, 0.23047322f, 0.03507943f, 0.00980966f, -0.22443953f, 0.08469635f, 
    -0.22855814f, -0.16822664f, -0.24229465f, 0.22332227f, 0.03745741f, 0.13566640f, -0.12221982f, -0.04470788f, 
    -0.11258575f, 0.14295724f, -0.16275135f, 0.16909069f, -0.32894883f, 0.30245924f, -0.19461606f, 0.11343971f, 
    0.31580636f, -0.26613498f, 0.04733351f, -0.19819725f, -0.10614068f, -0.00292918f, -0.12468602f, -0.00459370f, 
    -0.04165805f, 0.07553513f, -0.22881357f, -0.40381643f, 0.19119233f, 0.29563990f, -0.21268003f, 0.27529714f, 
    0.14387760f, 0.00529148f, 0.15632799f, -0.17543781f, -0.12270308f, 0.25342387f, 0.06136102f, -0.27833447f, 
    0.32616344f, -0.28121170f, -0.10495729f, -0.17279215f, 0.12207725f, -0.11400539f, 0.44023383f, 0.37566558f, 
    0.07890213f, 0.19938754f, -0.02444805f, 0.03814284f, 0.01847373f, 0.10176582f, 0.17889474f, -0.05849063f, 
    -0.33927980f, -0.32112849f, -0.21529999f, -0.42567354f, -0.26019087f, 0.14275567f, 0.53482234f, -0.05408162f, 
    0.05444220f, -0.15816066f, 0.15751117f, 0.11685001f, 0.22891971f, -0.38623986f, 0.09994083f, -0.72398210f, 
    -0.62032348f, 0.36450326f, -0.12779227f, -0.14454016f, 0.14333528f, 0.24305803f, -0.20004232f, -0.13451344f, 
    0.18732731f, 0.42878699f, 0.07638837f, -0.12881932f, -0.20592223f, -0.13669844f, 0.12061250f, 0.28632769f, 
    -0.08982822f, 0.04966860f, -0.11420089f, -0.50555038f, -0.18971206f, 0.34261104f, 0.16287100f, 0.29605019f, 
    -0.16735022f, 0.13239501f, -0.03505239f, 0.02649280f, -0.09454776f, 0.24303073f, 0.25030702f, 0.30755720f, 
    -0.07336296f, -0.14199908f, -0.23100163f, -0.16412649f, -0.03231084f, 0.14355382f, -0.28373143f, -0.23702776f, 
    0.08764005f, -0.63918406f, 0.05597329f, -0.00181536f, -0.15749244f, 0.01613330f, 0.13462237f, -0.43620902f, 
    0.36096027f, -0.03625362f, 0.14258772f, -0.07752486f, -0.13637765f, 0.41447470f, 0.03994875f, 0.28556770f, 
    0.05771562f, -0.01576041f, -0.11266139f, 0.14064534f, -0.03139600f, -0.20479435f, -0.28544685f, 0.26312816f, 
    0.08829180f, -0.04538407f, -0.10076240f, 0.25083530f, -0.23904876f, 0.02045468f, -0.14230393f, 0.01806077f, 
    0.55714357f, -0.04071326f, 0.15463032f, -0.28363031f, 0.16692987f, 0.09213265f, -0.12042224f, -0.20891552f, 
    0.07990219f, 0.16412517f, -0.10128185f, -0.06353277f, -0.03621224f, 0.16668452f, -0.27700108f, 0.35760081f, 
    -0.38338733f, -0.32394537f, 0.23791672f, 0.17888007f, -0.12919120f, -0.07240841f, -0.01854823f, -0.26427582f, 
    -0.07755686f, -0.01399474f, -0.07962545f, -0.08516171f, 0.02060541f, 0.39455795f, 0.11483672f, -0.11433326f, 
    -0.48862225f, -0.70568353f, 0.11950308f, -0.30364880f, 0.04855028f, -0.15319245f, -0.36899224f, 0.54920089f, 
    0.15951657f, 0.15846954f, -0.19963187f, -0.38979456f, 0.24653976f, 0.30979311f, 0.02796807f, -0.02984864f, 
    -0.01310050f, -0.05206233f, 0.14040247f, -0.13292268f, 0.01512498f, 0.09108320f, -0.08153623f, -0.23298818f, 
    -0.17348260f, 0.16705966f, -0.08393064f, 0.01723704f, -0.20654431f, -0.04001096f, -0.06908405f, -0.11194095f, 
    -0.12802690f, -0.07044370f, -0.14221773f, -0.11172139f, 0.24874669f, -0.21040076f, 0.05066827f, -0.21662334f, 
    -0.03367355f, 0.14677571f, -0.12086508f, -0.01894806f, 0.03058614f, -0.08480122f, -0.11832234f, -0.02969658f, 
    -0.38270620f, 0.04106781f, 0.00945237f, 0.32101190f, 0.06135350f, 0.01220003f, 0.17412260f, -0.09549208f, 
    -0.21366701f, -0.22432186f, 0.17159578f, -0.34337196f, -0.21291709f, 0.25260764f, 0.28438404f, -0.22362067f, 
    0.15270697f, 0.14247370f, 0.04770842f, -0.05293389f, -0.03064105f, 0.12737849f, 0.01207268f, 0.17436296f, 
    0.42181060f, -0.35836706f, -0.06750701f, -0.20384926f, 0.22345026f, -0.00506696f, 0.15628082f, 0.20113431f, 
    -0.29632485f, 0.00011449f, 0.18197599f, 0.23757736f, 0.14204691f, 0.02535849f, 0.04157491f, 0.07313625f, 
    0.14493136f, -0.20890959f, 0.19093871f, 0.02312186f, -0.02357236f, 0.25183618f, 0.09095982f, -0.38747847f, 
    0.11519658f, -0.31184512f, 0.20622548f, -0.01398925f, 0.04715937f, 0.09989405f, -0.00633166f, -0.23208459f, 
    -0.21861236f, 0.13737094f, -0.18941164f, 0.43613642f, -0.37688196f, -0.21086125f, 0.46439102f, 0.21019852f, 
    -0.16797605f, -0.20628563f, 0.16305989f, 0.00294787f, -0.21038905f, -0.08225943f, -0.06356417f, -0.10585311f, 
    -0.12752497f, -0.16869701f, 0.00965077f, -0.22001606f, 0.00390905f, -0.11030965f, -0.05342701f, 0.10943881f, 
    0.24565889f, 0.06125642f, -0.22562420f, 0.12215175f, 0.14723632f, -0.30409953f, 0.27627712f, -0.13747835f, 
    0.57723528f, 0.04937812f, 0.00031314f, 0.16213500f, -0.06709743f, -0.19112404f, 0.28524974f, 0.35422057f, 
    0.14394251f, 0.33326215f, -0.17574474f, -0.13613302f, 0.08712262f, -0.14513408f, 0.21313457f, -0.33972028f, 
    -0.29702413f, 0.07098441f, -0.12736735f, -0.26175106f, -0.26538855f, 0.09843205f, 0.51818091f, 0.00715548f, 
    0.38099229f, 0.41472626f, 0.21812180f, 0.15910108f, 0.09229182f, -0.04758783f, -0.18173356f, -0.03215668f, 
    0.28035212f, -0.25990355f, -0.15454486f, -0.53857970f, -0.20297186f, -0.27132985f, 0.35195234f, 0.38806692f, 
    0.04476687f, -0.23087502f, -0.16840044f, 0.06696574f, 0.12004086f, 0.29621834f, 0.26650587f, -0.40062112f, 
    0.10645413f, -0.14164786f, -0.05558692f, 0.15313883f, -0.10294538f, 0.23213512f, -0.01990512f, -0.19513118f, 
    -0.01161375f, 0.03360145f, -0.21125712f, 0.16852930f, 0.03567380f, -0.08327404f, -0.21855274f, -0.50830185f, 
    0.01290463f, -0.09873638f, 0.18500794f, 0.32996210f, -0.20403536f, 0.38470218f, 0.60067487f, 0.24181101f, 
    0.41002557f, -0.04100220f, 0.10003746f, -0.27621874f, -0.14538014f, 0.11905376f, -0.27663976f, 0.13767637f, 
    0.11252734f, 0.39954534f, 0.17845914f, 0.09926832f, 0.02376699f, -0.12654528f, -0.05054567f, 0.09631219f, 
    0.04929569f, -0.46527037f, 0.22574283f, 0.26564926f, 0.10404366f, 0.37915125f, 0.29317036f, 0.33456755f, 
    0.30203894f, -0.03561942f, -0.09975257f, -0.24485487f, -0.35208961f, -0.23808444f, -0.30285996f, 0.22707170f, 
    -0.40427259f, -0.05122918f, -0.05554792f, 0.19934328f, 0.05179986f, -0.34023586f, 0.12294284f, -0.27422971f, 
    0.16864985f, 0.12862965f, 0.05892020f, 0.39494005f, -0.22477208f, 0.21091364f, 0.35333818f, 0.06476130f, 
    0.32919922f, -0.02990677f, 0.17500097f, 0.16674508f, 0.01288515f, -0.15230797f, 0.34066576f, 0.37843540f, 
    0.29895046f, 0.04283604f, 0.24802884f, 0.07693711f, 0.01825821f, -0.33495048f, -0.15378965f, 0.18598787f, 
    0.22471608f, -0.01455183f, -0.08594441f, 0.07396660f, -0.01537818f, -0.36017403f, -0.21596467f, -0.29915741f, 
    0.16567971f, 0.27209783f, -0.06200591f, 0.39506647f, 0.13033049f, 0.23428930f, 0.26611531f, 0.03876001f, 
    0.31496331f, 0.33511412f, 0.11631466f, 0.13870032f, -0.07256208f, 0.05588950f, -0.29611686f, -0.26375109f, 
    -0.59922767f, 0.33983314f, 0.23855029f, 0.30977526f, -0.08113832f, -0.25125852f, -0.12631454f, 0.12137547f, 
    -0.45678699f, 0.15181032f, 0.17066324f, -0.20694025f, -0.14250064f, 0.21268639f, -0.36723754f, 0.23133884f, 
    -0.57194310f, 0.42391858f, -0.12079596f, -0.20679352f, 0.04232464f, 0.15628065f, 0.12307405f, 0.28003514f, 
    -0.29272917f, -0.28266436f, 0.23515861f, -0.10834037f, -0.14165893f, 0.10312472f, 0.38981149f, 0.08146850f, 
    1.10866690f, 0.37808651f, -0.08204928f, -0.26013109f, -0.07881562f, -0.18366955f, -0.05000465f, -0.19489373f, 
    0.40795797f, 0.33335969f, -0.17433524f, -0.21038495f, -0.03743144f, 0.23639531f, -0.15285660f, -0.32026482f, 
    0.02028804f, 0.06970894f, 0.09270951f, 0.10609377f, 0.03612629f, 0.18022391f, -0.35774419f, 0.24181136f, 
    -0.16717848f, 0.42820120f, 0.02298100f, 0.08133105f, 0.16049419f, -0.09819331f, -0.08011606f, 0.23289482f, 
    -0.74459422f, -0.21830633f, -0.06961734f, -0.08283119f, -0.06577535f, 0.33567432f, 0.18964227f, -0.04822855f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.05590426f, 0.23484403f, 0.31129235f, 0.47006780f, -0.31541297f, 0.17727011f, 0.26368469f, 0.33833477f, 
    0.17507413f, -0.00437544f, -0.19468044f, -0.11864749f, 0.04633006f, -0.28935048f, 0.32744446f, 0.06195958f, 
    0.08817104f, 0.11319830f, 0.02219789f, 0.08071424f, 0.01975522f, -0.29972905f, 0.19648421f, -0.10644592f, 
    -0.11668304f, -0.10741530f, -0.27650362f, 0.10573463f, -0.02808359f, -0.01563815f, 0.39474592f, 0.18550776f, 
    -0.30417770f, 0.26635435f, 0.31098866f, 0.07786839f, 0.10297884f, 0.29829684f, -0.11580290f, 0.02998637f, 
    -0.16954714f, 0.41413274f, 0.05111188f, -0.26989356f, 0.16083193f, 0.53532338f, -0.26526409f, 0.05725794f, 
    -0.13848525f, 0.10249604f, -0.20114082f, -0.19776113f, -0.11292046f, 0.02389646f, -0.08564657f, 0.50518841f, 
    -0.24530053f, 0.04742692f, -0.26734135f, -0.02642594f, 0.09624346f, 0.04700723f, 0.36971232f, -0.04741416f, 
    -0.26680484f, 0.33879825f, -0.03544006f, -0.01244485f, 0.33298621f, 0.10748457f, 0.20966499f, -0.07601920f, 
    -0.29422611f, 0.13096671f, 0.52508026f, 0.16893753f, 0.06584518f, 0.06487476f, -0.11401406f, 0.29250807f, 
    0.02706772f, 0.20262864f, -0.26310024f, -0.10017666f, -0.30613101f, 0.10176404f, -0.21313305f, -0.12840782f, 
    0.23940574f, -0.18058905f, 0.28765649f, 0.31446877f, -0.30982393f, 0.46588078f, 0.37722766f, 0.53689015f, 
    -0.02265806f, -0.20421414f, -0.04873127f, 0.14494058f, 0.24937898f, 0.50576514f, -0.22570190f, 0.05703481f, 
    0.42455798f, -0.08519616f, -0.23704004f, -0.17569754f, -0.05150527f, -0.25965708f, 0.15562396f, -0.11061496f, 
    -0.27171910f, -0.14091600f, -0.10566349f, -0.05765568f, 0.37988430f, 0.28195462f, 0.30614740f, 0.05279793f, 
    -0.06847955f, -0.30586740f, -0.11979397f, 0.02834245f, 0.29763499f, 0.12582596f, -0.21305344f, 0.26202279f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.05053701f, -0.20865358f, 0.10575545f, -0.18315201f, 0.12328652f, 0.00586500f, -0.15523303f, -0.24588621f, 
    0.08370770f, 0.10430144f, -0.10178161f, -0.15109195f, -0.03462663f, 0.23645502f, -0.29255787f, -0.01296050f, 
    -0.30341181f, -0.03312773f, -0.14069864f, 0.02095050f, 0.04585703f, -0.32032686f, 0.02827272f, 0.08083042f, 
    -0.31118789f, -0.05925103f, 0.09820161f, 0.17375408f, -0.08794982f, 0.00870465f, -0.00015270f, -0.11881389f, 
    0.36144984f, 0.16387330f, -0.00741193f, 0.25265065f, -0.03369933f, 0.08099766f, -0.08175586f, 0.28439370f, 
    0.03795300f, -0.16041884f, 0.06175993f, 0.10812602f, -0.36688033f, -0.12131675f, 0.20022008f, 0.26344681f, 
    -0.09903631f, -0.01678729f, -0.21986988f, -0.03739056f, 0.23911469f, -0.00697422f, 0.11008569f, -0.23426436f, 
    0.12763289f, 0.14549237f, -0.16159223f, 0.02993116f, 0.06225699f, 0.08068094f, -0.14676201f, 0.37197068f, 
    -0.16620912f, -0.24145062f, 0.00892436f, -0.22305892f, -0.02268684f, 0.37362915f, 0.01197920f, 0.17816474f, 
    -0.25220039f, 0.11360244f, -0.07555822f, 0.10992440f, -0.19490232f, 0.12058305f, -0.01907863f, -0.31264147f, 
    -0.01159494f, -0.04522299f, -0.42077604f, 0.27881745f, 0.26187059f, 0.20919898f, -0.09419108f, 0.05906381f, 
    0.06755710f, 0.01430507f, -0.50163972f, -0.19890355f, 0.17821684f, -0.45727652f, 0.04079540f, -0.16629693f, 
    0.22895269f, 0.15545487f, -0.41408136f, 0.01463810f, 0.07904131f, 0.06620090f, 0.10258129f, -0.49993393f, 
    -0.01184963f, -0.14082980f, 0.04249733f, -0.04464484f, 0.23177201f, 0.03151281f, 0.04003860f, 0.11358493f, 
    0.01424388f, 0.08800486f, 0.05933210f, -0.08127399f, 0.14883354f, -0.00117406f, -0.52704769f, 0.15705945f, 
    0.06952795f, 0.20890674f, -0.36718974f, -0.25379026f, -0.07518449f, 0.31897125f, -0.36843884f, -0.19273272f, 
    -0.42824045f, -0.69342244f, 0.06426947f, 0.39476264f, 0.54055369f, -0.09908254f, 0.19732288f, 0.25946033f, 
    0.13675226f, -0.29380140f, -0.13500354f, -0.23073617f, -0.04030026f, 0.17603385f, 0.15755886f, -0.06546677f, 
    -0.28552210f, 0.09431574f, 0.04601551f, 0.00312053f, 0.54037786f, 0.12223794f, -0.05670678f, 0.01707676f, 
    0.39252183f, 0.04244874f, 0.09014717f, -0.08078159f, -0.08978675f, -0.02309072f, 0.12756582f, -0.01183187f, 
    -0.08463006f, 0.40814099f, 0.33355668f, 0.48070908f, -0.00370610f, 0.19469862f, -0.31591263f, -0.00796939f, 
    0.05678831f, 0.13999249f, 0.12112263f, 0.07083919f, 0.18022774f, 0.31097773f, 0.03877582f, -0.36144456f, 
    0.02365239f, 0.16214931f, 0.01390910f, -0.05392305f, 0.01162438f, 0.06820399f, -0.13022633f, -0.10090256f, 
    -0.08224507f, -0.14689130f, 0.02850313f, 0.17280178f, 0.34989813f, 0.01699791f, -0.02490626f, -0.01032915f, 
    -0.03586165f, 0.01072057f, 0.11408293f, 0.08700131f, -0.17579082f, -0.09513333f, 0.02482503f, 0.10997681f, 
    0.17193963f, 0.15777808f, 0.00439526f, 0.12844139f, -0.14323020f, -0.00007185f, -0.05301841f, -0.19203345f, 
    0.07656846f, -0.16523671f, 0.20265007f, -0.22930022f, 0.06749805f, 0.36007330f, -0.07594537f, -0.24488144f, 
    0.22686948f, 0.17478046f, 0.34374273f, 0.15122378f, 0.21328440f, 0.23900050f, 0.12704408f, -0.09795884f, 
    -0.19308971f, 0.03361244f, 0.17401202f, -0.22704548f, -0.12477466f, 0.06676558f, -0.02605437f, -0.00280278f, 
    0.16420196f, -0.14200029f, -0.05269320f, -0.04656776f, 0.24074355f, -0.17198658f, 0.20531757f, 0.31142253f, 
    -0.02644498f, -0.18124117f, -0.31912106f, -0.12941137f, 0.08413757f, 0.20476939f, 0.16680370f, 0.18796179f, 
    0.06944685f, -0.21272482f, 0.05379974f, -0.04709630f, -0.00235636f, -0.37663722f, -0.09745723f, 0.02754213f, 
    0.03725886f, 0.12218276f, 0.07056853f, 0.08409905f, -0.53947222f, 0.12449650f, -0.07492079f, -0.01017792f, 
    0.09754852f, 0.10228739f, -0.39594072f, -0.09630010f, 0.03653705f, 0.05865175f, 0.06447206f, -0.00783381f, 
    0.31481341f, -0.11398242f, -0.31153992f, -0.03782003f, -0.03300355f, -0.01679805f, 0.07845981f, 0.03624754f, 
    0.04038674f, -0.00706134f, -0.01997668f, -0.00277574f, 0.04222205f, 0.06243297f, 0.14189275f, 0.25972918f, 
    -0.00700442f, -0.10239732f, 0.05773163f, -0.48321322f, -0.04977213f, -0.21905062f, -0.06208200f, -0.16064987f, 
    0.01639581f, 0.13612504f, 0.03987647f, -0.21214052f, -0.07022018f, 0.03481780f, 0.01715450f, 0.05890083f, 
    -0.17303579f, 0.01085338f, 0.08720820f, -0.05495817f, 0.21785975f, 0.11465951f, 0.22821172f, -0.08173471f, 
    -0.11402400f, -0.02942417f, 0.18598154f, -0.01513878f, 0.29575127f, 0.00595272f, 0.17077495f, -0.26874816f, 
    -0.15739711f, 0.05508785f, -0.17969948f, 0.18386291f, 0.11286350f, 0.13493174f, -0.02329270f, -0.21347003f, 
    -0.50343406f, -0.23789234f, 0.12910563f, 0.05514240f, -0.18547478f, 0.02776542f, -0.07272052f, 0.30216378f, 
    0.08372901f, -0.08240201f, 0.06234172f, 0.00391584f, -0.03891255f, -0.12265964f, 0.15409338f, 0.33291808f, 
    0.17057452f, 0.03764787f, 0.07091914f, 0.07571042f, 0.04691397f, 0.06284130f, 0.00709220f, 0.28284976f, 
    -0.09490912f, -0.01829963f, 0.09056106f, 0.19098011f, -0.13447784f, 0.14114346f, -0.06682352f, 0.18919601f, 
    0.15168516f, 0.15596588f, 0.00624857f, 0.02049793f, -0.13174374f, 0.07553993f, -0.02532981f, -0.03645663f, 
    0.01974392f, 0.22506933f, 0.44679865f, 0.18753347f, -0.00917628f, 0.20648386f, 0.09824745f, -0.00820549f, 
    0.31755376f, 0.19984929f, 0.37927824f, 0.07529885f, -0.18387166f, 0.25231701f, 0.04275012f, 0.26370436f, 
    -0.09128071f, -0.03164240f, 0.17146112f, 0.14312753f, -0.62902528f, 0.03342314f, 0.19962882f, -0.41500777f, 
    0.06071028f, -0.13703877f, 0.05821780f, -0.00974210f, -0.04753014f, 0.05134154f, -0.20625468f, 0.51879638f, 
    -0.75397509f, -0.03103253f, -0.19125704f, 0.02924217f, 0.39929414f, -0.33555439f, -0.04000729f, -0.03535292f, 
    0.17022404f, -0.07786262f, 0.11392826f, -0.12674853f, 0.32129803f, -0.05740848f, 0.24405451f, 0.14701885f, 
    -0.24393216f, 0.22852185f, -0.04172217f, -0.05440695f, -0.05830060f, -0.05693369f, -0.33080360f, -0.11408202f, 
    -0.28808793f, 0.15537362f, -0.12893164f, 0.02721783f, 0.12273685f, 0.25281942f, 0.00520175f, 0.19161621f, 
    -0.27970463f, 0.12637250f, -0.07295881f, 0.01271969f, 0.20035930f, 0.02264610f, 0.17394054f, 0.11259833f, 
    -0.00008860f, 0.03312768f, -0.04654575f, -0.03246294f, 0.09746428f, 0.04079871f, -0.01967687f, -0.11117323f, 
    -0.18349595f, 0.14001456f, -0.04685601f, -0.80421060f, 0.08932961f, -0.16375145f, 0.00355711f, 0.02857159f, 
    -0.24853908f, 0.32995975f, 0.24757281f, 0.11673728f, 0.19544129f, 0.18616199f, -0.02917390f, -0.30658996f, 
    -0.05651290f, 0.26051167f, -0.17359588f, -0.19052325f, 0.20043540f, -0.01430653f, -0.04285727f, 0.05087394f, 
    0.09519455f, 0.26153418f, 0.06219717f, 0.23942958f, 0.18839733f, 0.23339304f, -0.11653410f, 0.10296446f, 
    0.13395646f, -0.21197869f, -0.59194547f, -0.19894502f, 0.17520756f, 0.14144342f, 0.02160448f, 0.42994788f, 
    0.12885785f, -0.34524906f, 0.03970183f, 0.02666042f, -0.06365789f, 0.02516988f, -0.02909867f, -0.23932351f, 
    0.07016494f, -0.05295984f, -0.26576555f, -0.23984298f, 0.14842340f, -0.04237416f, 0.34997067f, 0.08670169f, 
    -0.01696775f, -0.19200598f, 0.00510018f, 0.08705599f, -0.08091844f, -0.12700355f, 0.19092688f, -0.28007182f, 
    -0.36558449f, -0.53981733f, 0.07688083f, 0.40569967f, 0.21294072f, -0.11695780f, 0.24427085f, 0.13601361f, 
    -0.10527372f, -0.17501092f, -0.00235019f, -0.11955407f, 0.08357797f, 0.15262693f, -0.00391573f, 0.13808483f, 
    -0.15936075f, -0.04171788f, 0.37216806f, 0.04102232f, 0.49628457f, -0.04309882f, -0.04286116f, 0.02254579f, 
    0.39014742f, 0.02134125f, 0.07930885f, -0.08411273f, -0.02258213f, 0.05051114f, 0.19316185f, -0.05121979f, 
    -0.09124555f, 0.30031359f, 0.14474802f, 0.71007359f, -0.06665032f, -0.00429533f, -0.09113351f, -0.05465922f, 
    -0.18867952f, 0.06657094f, -0.15579791f, 0.05826931f, -0.03277438f, 0.40752581f, -0.09919550f, -0.22453338f, 
    0.12233520f, 0.09871839f, -0.19110632f, 0.12574667f, 0.17940262f, 0.06943370f, 0.07206962f, 0.09286057f, 
    0.19166452f, -0.12189674f, -0.01813790f, 0.06613108f, 0.35010591f, -0.04106893f, 0.00313731f, 0.17188950f, 
    0.07380348f, -0.06475571f, -0.00751930f, -0.25454623f, -0.03423950f, -0.03371052f, 0.08593441f, 0.11353633f, 
    0.40133387f, 0.41919777f, 0.00725409f, 0.02575545f, 0.10254844f, 0.17284976f, -0.03351319f, 0.01056213f, 
    -0.02179725f, 0.24133840f, -0.13191299f, -0.19444716f, -0.07017651f, 0.28026909f, 0.00008623f, -0.21947135f, 
    0.07621878f, 0.21188515f, 0.26563406f, 0.21231887f, 0.30236000f, 0.21314126f, 0.15207715f, -0.05428405f, 
    -0.15475643f, -0.18831703f, -0.06117948f, -0.17847641f, 0.17966208f, 0.07877924f, 0.07543927f, -0.02575060f, 
    0.19525047f, -0.03269066f, -0.08163796f, 0.07996438f, 0.11142819f, -0.27460578f, 0.06581835f, 0.15548539f, 
    0.05775034f, -0.14444958f, -0.20213544f, -0.25041363f, 0.17543860f, 0.04210152f, 0.24317625f, 0.21832326f, 
    0.06941246f, -0.06670760f, -0.15587251f, 0.11256745f, 0.08752152f, 0.02621936f, 0.08817375f, 0.03895317f, 
    -0.03997568f, -0.21356119f, 0.00021002f, 0.04527863f, -0.42464188f, 0.14523575f, 0.12083191f, 0.08757572f, 
    0.22895280f, -0.05041942f, 0.07427301f, -0.02185039f, 0.02631581f, -0.04708844f, -0.21198778f, 0.20326298f, 
    -0.09514332f, -0.07432923f, -0.17014110f, -0.08115279f, -0.13689941f, -0.11669782f, -0.03985385f, -0.04596431f, 
    0.19650757f, -0.00404822f, 0.09726401f, -0.00053204f, 0.15499865f, 0.01403052f, 0.09969971f, 0.28660470f, 
    -0.07713225f, -0.12758061f, 0.08135195f, -0.61711115f, 0.08945920f, -0.26361454f, -0.23333967f, -0.22299816f, 
    -0.10240293f, 0.19932882f, 0.01270894f, -0.49961650f, -0.02506253f, 0.07350874f, 0.16191867f, 0.24601032f, 
    -0.03794979f, 0.17610574f, 0.26220757f, 0.02878929f, -0.02631103f, 0.07903787f, 0.18943095f, 0.04291811f, 
    -0.09080702f, 0.16542128f, 0.12597348f, 0.03659368f, 0.21072115f, 0.18498625f, 0.00979086f, -0.42781076f, 
    -0.15149042f, 0.08132931f, -0.09080853f, 0.24402460f, 0.11178719f, -0.02909474f, -0.02335391f, -0.09907081f, 
    -0.18623237f, -0.05995765f, 0.06132036f, 0.17239799f, -0.08441092f, 0.13319971f, 0.04226389f, 0.23050925f, 
    0.08769498f, -0.02340986f, 0.10833340f, -0.01011599f, 0.07035229f, -0.31407890f, -0.01681477f, 0.30918005f, 
    0.23397416f, 0.12845936f, -0.07662823f, 0.09570682f, 0.20615047f, 0.03740507f, -0.10730340f, 0.17128299f, 
    0.22887117f, 0.20531188f, 0.23644441f, 0.15591717f, -0.15723354f, 0.06576990f, -0.00053186f, 0.18680474f, 
    0.08115422f, -0.15734610f, -0.02288225f, -0.01675384f, -0.01187407f, -0.03902220f, -0.02065405f, 0.03865057f, 
    -0.05500408f, 0.25737286f, 0.52800316f, 0.21763943f, -0.02378736f, 0.25512308f, 0.02546241f, -0.24083488f, 
    0.33345425f, 0.03406569f, 0.30274349f, -0.03246029f, -0.16209877f, -0.06212872f, -0.08068826f, -0.04984026f, 
    -0.20212759f, -0.28186518f, 0.01771877f, 0.19239682f, -0.08836674f, 0.05415930f, 0.26010621f, 0.08648959f, 
    0.20487402f, -0.12341487f, 0.16227949f, -0.05629136f, 0.03352252f, -0.14042304f, 0.09371102f, 0.32052922f, 
    -0.34603101f, 0.09203143f, 0.03176142f, 0.05654147f, 0.00328867f, -0.15070382f, -0.05424653f, 0.04018735f, 
    0.27572891f, -0.04242183f, 0.15379077f, -0.10992436f, 0.25572997f, -0.05395138f, -0.00650021f, 0.18903659f, 
    -0.00647585f, 0.01785136f, -0.05771722f, -0.45202124f, 0.05181507f, -0.01500444f, -0.08077721f, 0.02071402f, 
    0.17480753f, 0.10836437f, 0.03876806f, -0.25770414f, 0.18207937f, 0.01442649f, 0.20507868f, 0.12204366f, 
    -0.06804581f, 0.21389242f, 0.07408832f, 0.04089439f, -0.10095510f, 0.09697752f, -0.01943215f, 0.07178147f, 
    -0.13224530f, 0.18653674f, 0.04937710f, 0.16313660f, 0.07501845f, 0.13181849f, 0.06773832f, -0.15354827f, 
    -0.12210523f, 0.03591443f, 0.08948533f, -0.15432793f, 0.12426102f, -0.18436480f, 0.06502140f, 0.16273436f, 
    0.12199654f, 0.09294830f, 0.09863626f, 0.14446251f, 0.14113705f, 0.07986297f, 0.08043585f, -0.05289182f, 
    0.01501260f, 0.08474284f, 0.06867056f, -0.24357373f, 0.02057264f, -0.18413089f, 0.02037611f, 0.18950422f, 
    0.10790452f, 0.08883340f, 0.08199657f, 0.11069597f, 0.09694711f, 0.24766836f, -0.09977922f, -0.02957367f, 
    0.16234232f, 0.13207953f, 0.00524950f, -0.11453043f, -0.09901004f, 0.05524663f, -0.00456349f, -0.06437434f, 
    0.23883229f, -0.34109250f, 0.04146252f, -0.04470313f, 0.19908980f, 0.00004851f, 0.00376536f, 0.11305490f, 
    -0.00655243f, 0.06583659f, 0.01981202f, 0.21298262f, 0.15330765f, 0.20587774f, 0.22588985f, -0.16753964f, 
    0.05162494f, -0.18993969f, 0.19068071f, -0.02093916f, 0.09840132f, -0.29646897f, -0.06866532f, -0.19761273f, 
    0.00810658f, -0.00552192f, 0.06041925f, 0.06294025f, -0.08269486f, -0.07440421f, -0.00208742f, -0.04309390f, 
    0.03037919f, -0.09773373f, 0.00197975f, 0.06064009f, -0.08017202f, 0.01294453f, -0.02486077f, -0.08176266f, 
    -0.03604375f, -0.06347828f, -0.02542034f, -0.09615593f, -0.06083919f, 0.06736461f, 0.04300439f, -0.04430376f, 
    -0.00041322f, 0.02312089f, -0.00039299f, -0.08034249f, -0.08671323f, -0.00564663f, -0.02229670f, -0.02841038f, 
    -0.05349131f, -0.00882370f, 0.03138730f, -0.05618614f, 0.03561027f, -0.07082095f, 0.04726857f, -0.03538228f, 
    0.02289009f, -0.04481868f, 0.05513161f, 0.04582344f, -0.00160725f, -0.01803449f, 0.02086199f, -0.04822675f, 
    -0.00858445f, -0.06573331f, -0.03438558f, -0.03767946f, 0.05052752f, 0.08534297f, -0.02145192f, 0.00910613f, 
    -0.01499021f, -0.08348200f, -0.05218827f, -0.02411607f, -0.01452766f, 0.07138623f, -0.01079151f, -0.08017555f, 
    -0.00468830f, 0.00270861f, -0.03623753f, -0.02094344f, -0.04293626f, 0.07886564f, 0.05932274f, -0.05237520f, 
    -0.08427601f, -0.03153259f, -0.01824470f, 0.07371350f, -0.03405130f, -0.01434202f, -0.08465610f, -0.05623857f, 
    0.07773136f, 0.01718097f, -0.05865103f, -0.02335570f, 0.05776573f, 0.00167264f, -0.03548591f, -0.03372044f, 
    -0.04371194f, -0.06272569f, 0.04620592f, 0.04625030f, -0.01668922f, 0.06287438f, -0.01079238f, -0.05424114f, 
    0.03959228f, 0.03800623f, 0.04863615f, -0.09152159f, 0.07573234f, 0.03753148f, -0.00710256f, -0.06422286f, 
    -0.03935006f, 0.01954260f, -0.00866536f, 0.06930655f, 0.02402009f, -0.07533214f, -0.07766989f, 0.04066824f, 
    -0.08173372f, -0.01807282f, -0.06028706f, -0.08397750f, 0.01107517f, -0.09167641f, 0.06712230f, 0.01253554f, 
    -0.07747585f, 0.01756544f, 0.00884966f, -0.06021109f, -0.00517984f, -0.04946039f, 0.06858112f, -0.01926005f, 
    0.11133996f, 0.13804986f, 0.04658671f, 0.02560826f, 0.03789989f, 0.05450722f, 0.01811586f, 0.12985486f, 
    0.05355397f, 0.08393383f, 0.26113784f, 0.01847749f, -0.04349959f, -0.20785217f, -0.55215913f, 0.27072218f, 
    -0.06344403f, 0.06639650f, 0.48168689f, 0.04486541f, 0.02339702f, -0.19208087f, 0.00131733f, -0.09505378f, 
    0.26524702f, 0.02458312f, -0.02840722f, 0.02273167f, -0.00763601f, 0.07369588f, 0.05707465f, 0.09113953f, 
    -0.10627420f, -0.02626852f, -0.59653789f, 0.44156772f, 0.34509310f, 0.05812310f, -0.03672655f, -0.10385802f, 
    -0.07007185f, -0.04787463f, -0.22637582f, -0.10633891f, 0.04934890f, 0.08433954f, 0.13676189f, 0.29430905f, 
    -0.43270269f, 0.10797339f, 0.02417584f, 0.12884147f, -0.12824762f, 0.09729553f, 0.00997693f, 0.25919479f, 
    -0.01017757f, 0.28045139f, 0.05717010f, -0.11815952f, 0.04916952f, 0.10201224f, -0.03574343f, -0.07700309f, 
    0.00547654f, 0.04237594f, -0.09180138f, 0.07441032f, 0.13173060f, -0.01109279f, -0.09703092f, 0.15459640f, 
    0.43491703f, 0.06983014f, 0.08011450f, 0.14165446f, 0.16699062f, 0.01608466f, 0.06876687f, 0.01104764f, 
    -0.07356645f, 0.23304698f, 0.01011388f, 0.08371726f, -0.09085236f, -0.24008510f, -0.03595142f, -0.00044007f, 
    -0.12488391f, 0.04176566f, 0.16626368f, 0.09605814f, 0.10087417f, 0.13503104f, -0.11612970f, 0.01197153f, 
    0.18459009f, -0.04915799f, -0.14989939f, -0.09014750f, 0.01060902f, -0.17422678f, -0.05246301f, 0.12260001f, 
    -0.14200152f, -0.26908728f, 0.00728207f, 0.05681875f, -0.43473998f, 0.02673664f, -0.12252106f, -0.22167845f, 
    -0.07242452f, 0.04708330f, -0.09147757f, -0.07689288f, -0.08694775f, -0.16175736f, 0.31123814f, -0.04311139f, 
    -0.05161458f, -0.07843187f, 0.04797284f, 0.05617197f, 0.42549020f, 0.39106101f, 0.09701534f, -0.17456624f, 
    -0.09246477f, -0.09858947f, 0.10108573f, 0.30948925f, -0.30890375f, -0.01728241f, 0.33267409f, -0.08059682f, 
    0.22443005f, -0.06603654f, 0.17585151f, 0.01119680f, 0.05838224f, -0.14313672f, 0.15722810f, -0.02588712f, 
    -0.21731228f, 0.04078637f, 0.37460580f, 0.10416082f, -0.29326680f, -0.12185014f, 0.02919622f, 0.02580148f, 
    0.12685926f, 0.03012252f, -0.06755347f, -0.09358574f, 0.26307341f, 0.08579307f, 0.19335918f, 0.15701987f, 
    -0.10520227f, -0.07127447f, -0.11805439f, 0.26584470f, 0.17257796f, 0.16063124f, -0.02403054f, -0.10479992f, 
    0.02398139f, 0.20504111f, -0.01093418f, -0.17315705f, 0.12759019f, 0.04628072f, 0.14998159f, 0.05252316f, 
    -0.32790926f, 0.18392077f, 0.07210140f, -0.05671614f, -0.05198788f, -0.03270409f, -0.18013532f, 0.27782544f, 
    -0.17256890f, 0.12075277f, 0.04472600f, 0.02187889f, -0.40793768f, -0.06813470f, 0.07873796f, 0.09449019f, 
    -0.00233541f, 0.07483999f, 0.13850968f, -0.40117905f, 0.10885222f, -0.22389942f, 0.04010876f, 0.20594616f, 
    0.31317189f, 0.09008588f, 0.15520576f, 0.00520957f, 0.04531515f, -0.05438251f, 0.06508578f, 0.11436505f, 
    -0.05422691f, 0.16098922f, 0.08038868f, -0.10553943f, -0.07618501f, 0.04337029f, 0.03169579f, 0.04081322f, 
    -0.00721176f, 0.14143881f, -0.07757727f, 0.14180197f, -0.27265674f, 0.24403927f, 0.11772527f, 0.04941154f, 
    0.09854397f, 0.07160796f, 0.11487819f, -0.10884936f, -0.02557772f, 0.12962788f, -0.04018255f, -0.16832708f, 
    0.29405022f, -0.15373251f, -0.05159028f, -0.05809660f, 0.21057267f, -0.02110914f, 0.08092357f, -0.01577382f, 
    0.03860112f, -0.00560455f, -0.12515362f, -0.06297880f, 0.21082562f, 0.21557882f, 0.07671148f, -0.20742092f, 
    0.25425464f, -0.19231302f, 0.07827245f, -0.02037530f, 0.23965235f, 0.23445800f, -0.03182780f, -0.11519473f, 
    0.20715412f, 0.12548122f, -0.05235213f, -0.08992843f, 0.20668477f, 0.10723456f, -0.07965659f, -0.12024557f, 
    -0.07798228f, 0.20932896f, 0.10381576f, 0.03736784f, -0.05564218f, 0.26543945f, 0.30957824f, -0.37569210f, 
    -0.14371592f, -0.05989092f, -0.71862924f, 0.04950671f, -0.23884536f, -0.06209673f, 0.05270714f, 0.01246827f, 
    -0.55990165f, -0.09775684f, 0.11028402f, 0.02558882f, -0.21374838f, -0.03738976f, 0.05074107f, -0.25745097f, 
    0.19189505f, -0.04797380f, 0.06547468f, -0.62607199f, -0.05122804f, -0.15020894f, 0.00279740f, 0.23152532f, 
    0.01761160f, 0.04138027f, -0.00556468f, 0.33393532f, 0.13135371f, -0.11639792f, 0.08294922f, -0.17182608f, 
    0.25969303f, 0.11424462f, -0.24289992f, -0.06723706f, -0.05038531f, -0.03170871f, -0.13159736f, 0.19340083f, 
    0.20448741f, -0.02334788f, -0.17660734f, 0.12829314f, -0.19298725f, 0.13849381f, -0.06562565f, 0.26803744f, 
    0.10616314f, -0.11787448f, 0.31110519f, 0.01066380f, 0.20971790f, -0.00239070f, -0.06445307f, 0.11434974f, 
    0.09665588f, 0.11639318f, 0.04039287f, 0.07156361f, 0.08019447f, 0.05567389f, -0.05564758f, -0.12219574f, 
    0.00204783f, 0.05937539f, -0.21370807f, -0.05590617f, 0.06827573f, -0.10415772f, 0.03116621f, -0.16167630f, 
    -0.17731673f, 0.15505867f, 0.01882597f, -0.07796928f, 0.08085195f, -0.05416993f, 0.15222827f, 0.19608048f, 
    0.11916004f, 0.17832318f, -0.10357428f, 0.14154324f, 0.15559807f, -0.10221158f, 0.03191669f, 0.22201216f, 
    -0.11650514f, 0.48684123f, -0.06214221f, -0.01087684f, 0.11522661f, 0.12199347f, 0.14961033f, -0.20021717f, 
    0.07278545f, -0.10225319f, -0.10153231f, 0.02907468f, 0.15422291f, 0.02882797f, -0.12380854f, 0.10824685f, 
    -0.34634617f, -0.01632870f, -0.32385170f, -0.13086954f, 0.02929253f, -0.37373522f, 0.13952000f, 0.13053317f, 
    0.13994525f, 0.00027516f, 0.12367663f, 0.09639372f, -0.14492573f, 0.00389294f, 0.15422019f, -0.33632451f, 
    -0.05204342f, 0.01335283f, -0.04543580f, 0.05988600f, -0.07466637f, 0.03262936f, 0.13969313f, 0.38127595f, 
    -0.19493887f, 0.00853904f, 0.41385770f, 0.19419128f, 0.21291342f, -0.42493284f, 0.07399379f, -0.08309482f, 
    0.47187376f, 0.08538304f, -0.00434302f, -0.06880797f, -0.11358789f, -0.08362397f, 0.16193774f, -0.03055760f, 
    -0.10877826f, 0.26890457f, 0.22945386f, 0.02573709f, -0.04318131f, 0.15176487f, -0.24501735f, -0.11636452f, 
    -0.26318952f, 0.22150891f, -0.10576574f, 0.11613546f, 0.15389858f, 0.22630240f, -0.06200122f, -0.10840239f, 
    -0.03645136f, 0.02603674f, -0.32962006f, 0.00159192f, 0.22753254f, 0.03882427f, 0.21666689f, 0.17547618f, 
    0.11619569f, -0.10258632f, -0.11299124f, -0.07109697f, -0.19524243f, 0.06155338f, -0.01352863f, 0.03199855f, 
    0.16483517f, -0.08199503f, -0.00210328f, -0.27546969f, 0.11071033f, -0.19993512f, 0.05957692f, -0.03257788f, 
    -0.14309935f, 0.16928963f, 0.00253270f, 0.00681236f, 0.31551078f, 0.08895589f, -0.08719406f, -0.09768680f, 
    0.00746458f, 0.32866326f, -0.34464160f, -0.15639904f, -0.09444666f, 0.07070395f, -0.07513763f, -0.05464667f, 
    -0.11932742f, 0.14714453f, 0.08057550f, 0.19195458f, 0.17175184f, 0.15092401f, 0.10419702f, 0.15582472f, 
    0.01286456f, -0.26098660f, -0.36687782f, -0.12178412f, 0.22397228f, 0.17648333f, -0.00129887f, 0.46931130f, 
    0.08292447f, 0.19626147f, -0.03303666f, 0.01179454f, -0.19827074f, -0.09639566f, 0.02899672f, -0.17703478f, 
    0.08770223f, -0.24140669f, -0.28594807f, -0.18354753f, 0.21410279f, -0.13609742f, 0.25708488f, 0.15545592f, 
    -0.23744105f, -0.21260346f, -0.19462968f, 0.10938069f, 0.00012172f, -0.11996949f, 0.25584230f, -0.28483135f, 
    0.02542486f, 0.01518026f, 0.04392489f, -0.19605421f, 0.32727379f, 0.01599678f, -0.31569144f, -0.33264652f, 
    -0.18596092f, 0.10068742f, -0.27113608f, -0.08229964f, -0.03344551f, 0.20577285f, -0.24598670f, -0.09438147f, 
    -0.30648273f, 0.07238625f, -0.27054530f, -0.00550486f, 0.21781704f, -0.38700739f, -0.05059407f, 0.00525477f, 
    -0.17301984f, -0.01693474f, 0.27559736f, 0.04655714f, -0.07864004f, 0.06032195f, -0.09248645f, -0.07501338f, 
    0.21564183f, 0.26082602f, 0.05988607f, 0.33028844f, 0.01628965f, 0.05062418f, -0.01808582f, 0.15636794f, 
    0.09257785f, -0.14249218f, 0.14904517f, 0.13693139f, -0.20579463f, -0.03292841f, 0.08302934f, 0.02835574f, 
    0.16544443f, -0.07202724f, -0.12505548f, 0.02906596f, 0.26439813f, -0.02240498f, 0.01103392f, -0.31429917f, 
    0.21081580f, -0.02547442f, -0.16560186f, -0.13285299f, 0.19000846f, 0.11872462f, -0.11352804f, 0.19150770f, 
    0.05902090f, -0.17915614f, -0.08827248f, 0.02595604f, 0.02494632f, 0.32318333f, -0.11015958f, 0.08326130f, 
    -0.58379078f, 0.20535134f, -0.07827665f, 0.12075587f, -0.10638792f, 0.11946128f, -0.05906596f, -0.07808468f, 
    0.00364177f, -0.03198518f, -0.33712971f, 0.00879202f, 0.02708273f, 0.21514125f, -0.06098801f, 0.07090297f, 
    0.05574030f, 0.07663690f, -0.41529608f, -0.10303811f, 0.13889830f, -0.44678968f, 0.03082156f, -0.21066204f, 
    -0.01262619f, 0.08327963f, -0.54682434f, 0.12780738f, 0.18906090f, 0.04633886f, 0.14342457f, -0.17408618f, 
    -0.04445305f, 0.01741861f, 0.01558409f, 0.08675572f, 0.19861455f, 0.10613463f, 0.09247131f, -0.03656622f, 
    0.07158522f, 0.05904945f, 0.10752504f, 0.05056546f, 0.06611551f, -0.15628839f, -0.46843168f, 0.18782632f, 
    -0.03207326f, 0.24328460f, -0.35488001f, -0.11321559f, -0.06102549f, 0.46262148f, -0.21195950f, -0.12967992f, 
    -0.59591913f, -0.31319425f, -0.04983963f, 0.27771789f, -0.07496545f, 0.07935721f, 0.09795797f, 0.00307549f, 
    0.06992469f, -0.23757327f, 0.22855167f, -0.15512618f, -0.01219606f, -0.16497079f, -0.25614432f, 0.40978402f, 
    -0.35887441f, 0.00913218f, -0.50658476f, -0.03049466f, 0.41209322f, -0.10703834f, -0.05589527f, -0.03225365f, 
    -0.05496516f, -0.06089349f, 0.06617475f, -0.05358067f, 0.13286483f, 0.08002816f, 0.23960857f, 0.11745359f, 
    -0.09883990f, 0.13851635f, 0.07167716f, 0.33192849f, -0.01997380f, 0.02978791f, -0.00855252f, -0.29914761f, 
    -0.27722856f, -0.09770148f, -0.13541164f, -0.24862015f, 0.01269311f, 0.28997171f, 0.06214546f, 0.01872596f, 
    0.06448694f, 0.06138875f, 0.07134341f, 0.02043360f, 0.07767268f, -0.00554272f, -0.08694159f, 0.06758309f, 
    -0.07432759f, -0.03752390f, 0.01713895f, 0.04131179f, 0.40454528f, 0.04603662f, 0.02148815f, 0.05017181f, 
    -0.28643358f, 0.23239383f, -0.08109505f, -0.03933978f, -0.06268379f, -0.06650341f, -0.03766014f, -0.07194757f, 
    0.01542788f, 0.17752382f, 0.24169160f, -0.02092623f, -0.00570585f, 0.25337178f, 0.07176381f, 0.08301109f, 
    -0.01095483f, 0.17721191f, -0.01300527f, 0.04099717f, 0.05603192f, -0.05921644f, -0.08498897f, 0.15891181f, 
    0.31031540f, 0.10255307f, 0.10601112f, 0.19949234f, 0.03974093f, 0.19504014f, 0.03009452f, 0.01201181f, 
    -0.06537571f, 0.09972481f, 0.16021426f, 0.16400233f, 0.07646015f, 0.04608683f, 0.05997932f, 0.10156361f, 
    0.19559801f, -0.41008303f, -0.08424668f, -0.01989501f, 0.17764276f, -0.16685951f, 0.03741083f, -0.07467674f, 
    -0.05252441f, 0.09598217f, 0.11211075f, 0.00755271f, 0.15304823f, 0.17206550f, 0.30935079f, -0.12890725f, 
    0.23467198f, -0.05493874f, 0.09673178f, -0.05874459f, 0.06502470f, 0.06658959f, -0.08502569f, -0.05718255f, 
    -0.44793445f, 0.21649916f, -0.07673401f, 0.02374824f, -0.23799035f, -0.03384063f, 0.13909484f, 0.44647539f, 
    0.02022379f, 0.04131584f, 0.13036688f, 0.08936467f, -0.02815549f, -0.41888681f, 0.10742715f, 0.13520312f, 
    -0.00221721f, 0.05164243f, 0.45686772f, -0.13913040f, 0.06439420f, -0.05449007f, 0.04423042f, -0.03110279f, 
    0.22739954f, -0.08860804f, -0.23031726f, 0.00393952f, 0.12661418f, -0.02067292f, 0.07266945f, 0.21513622f, 
    -0.02052447f, -0.16680571f, -0.10611291f, 0.09838889f, 0.56555772f, 0.18229809f, 0.02808387f, -0.07066526f, 
    0.40836540f, 0.02285564f, -0.01098900f, -0.13775125f, 0.12817928f, 0.25685650f, -0.03420271f, 0.04789432f, 
    -0.15280153f, 0.14939894f, 0.10720720f, 0.05538391f, -0.22904746f, -0.00006169f, 0.00933024f, 0.19436893f, 
    -0.27044931f, 0.02707497f, 0.05325717f, -0.00078390f, 0.04519936f, -0.06634499f, -0.01312331f, -0.20645645f, 
    -0.12942193f, 0.02093004f, 0.12247234f, -0.32132825f, 0.16789185f, -0.09528065f, -0.08156307f, 0.04407396f, 
    0.10248838f, -0.12608294f, 0.08288002f, -0.00331442f, 0.17116600f, 0.01876734f, 0.04377317f, 0.24729055f, 
    -0.06264535f, 0.03082063f, 0.03044314f, -0.10728608f, -0.14226958f, 0.08301331f, -0.00262004f, -0.10608353f, 
    0.16622171f, -0.11482590f, 0.40102094f, 0.05711278f, -0.26686475f, 0.30241787f, 0.01543840f, 0.08373549f, 
    0.05712754f, 0.01161257f, -0.24231815f, 0.06759682f, -0.11223900f, 0.01206741f, -0.01699313f, 0.12216964f, 
    -0.03099013f, -0.75859821f, 0.03829628f, -0.00188209f, -0.28490612f, -0.06689274f, -0.35031724f, 0.25283578f, 
    0.00173336f, -0.06812178f, -0.05268647f, 0.09028424f, -0.20050120f, 0.07884608f, 0.08778431f, -0.16147014f, 
    0.05228400f, -0.05451718f, 0.15656617f, 0.29450917f, 0.44965020f, -0.39002955f, 0.09151132f, 0.15214746f, 
    -0.05040993f, 0.04451689f, 0.02721849f, 0.02820043f, 0.03725873f, -0.05024530f, -0.04647500f, -0.03412355f, 
    0.04208508f, 0.00347018f, -0.00379023f, 0.05590450f, -0.02430425f, 0.05441077f, -0.05368342f, -0.09287862f, 
    -0.03031164f, -0.04413699f, 0.02769538f, -0.08656448f, -0.06061315f, -0.06416173f, 0.07705173f, 0.06799399f, 
    -0.00554626f, 0.00920071f, -0.07193480f, 0.00774798f, -0.06000717f, 0.03057704f, -0.10423152f, -0.06594375f, 
    0.05783133f, -0.10295926f, 0.00986519f, -0.05311153f, 0.08069431f, -0.03261451f, 0.00965075f, 0.04479723f, 
    -0.07630973f, 0.00091713f, -0.08400717f, -0.02474125f, 0.06624536f, -0.00625827f, 0.03376246f, -0.01269773f, 
    0.04434863f, -0.08120731f, -0.09454907f, -0.07301573f, 0.07189301f, 0.06646215f, 0.02207982f, -0.03311636f, 
    -0.05852305f, 0.08705675f, 0.01623292f, -0.07375046f, 0.00781808f, 0.00378923f, -0.08000509f, -0.01496780f, 
    -0.02206942f, -0.02870830f, -0.05800161f, 0.01093694f, -0.05123004f, 0.02918179f, 0.00701521f, -0.00927048f, 
    0.07127250f, 0.01334157f, -0.09312192f, -0.09239659f, -0.07138825f, -0.06264628f, 0.00848802f, -0.02273062f, 
    0.03525355f, 0.01323964f, -0.07476699f, -0.09714969f, -0.03779104f, 0.06723685f, 0.01016380f, 0.06837907f, 
    -0.02137751f, 0.07169532f, 0.03717364f, -0.04372153f, -0.05736111f, -0.06707415f, 0.07170505f, 0.02783435f, 
    -0.06670140f, -0.09606751f, -0.04195603f, -0.04973152f, 0.06450833f, -0.03345661f, -0.01934300f, -0.01367384f, 
    -0.05078509f, 0.03646736f, 0.05001064f, -0.06091527f, 0.01467078f, -0.04504200f, 0.04320246f, 0.04970057f, 
    -0.01339620f, 0.04753608f, 0.05373599f, -0.02437225f, -0.04281706f, 0.05993294f, 0.02280848f, -0.03343012f, 
    0.02431449f, -0.03462091f, 0.02932695f, 0.04593929f, 0.04041846f, -0.02321565f, 0.03847760f, -0.10054528f, 
    -0.08713846f, -0.21103485f, 0.21065430f, 0.24265565f, -0.38122809f, 0.01583049f, -0.01373471f, 0.08415328f, 
    -0.28701690f, -0.18135752f, -0.03321292f, -0.46591467f, 0.05928211f, -0.08304662f, -0.14198762f, -0.00382490f, 
    -0.23331340f, 0.08370210f, -0.14715961f, -0.06017203f, 0.35852095f, -0.80525333f, -0.06676727f, 0.06157599f, 
    -0.00695799f, -0.06282070f, -0.23054454f, 0.03553166f, 0.54930657f, -0.06340580f, 0.06272812f, -0.12454892f, 
    0.15643269f, 0.25552699f, 0.01157393f, 0.69490552f, 0.09661607f, 0.28260249f, -0.06606289f, 0.06232988f, 
    0.15707736f, -0.13807583f, -0.02176049f, -0.04145723f, 0.07753685f, 0.21818507f, 0.07691997f, -0.02192867f, 
    0.13965425f, -0.10614362f, 0.01079305f, 0.06571594f, 0.00506391f, -0.07040092f, -0.17499897f, -0.03982636f, 
    -0.04943497f, -0.10194484f, -0.26952282f, 0.03943423f, -0.00610575f, -0.08828031f, 0.13194312f, 0.41660234f, 
    0.04736827f, 0.02622752f, -0.12987138f, -0.24793795f, -0.10367255f, 0.09912906f, -0.02774074f, 0.00790430f, 
    0.19104923f, 0.16188598f, 0.02116821f, -0.14365181f, -0.09745272f, 0.21413596f, 0.06155294f, -0.13623330f, 
    -0.07085161f, 0.09415092f, -0.31269994f, -0.19734113f, -0.47449681f, 0.45038351f, -0.10902028f, -0.13148513f, 
    0.11035985f, -0.01494338f, -0.05507679f, -0.12448181f, -0.24940245f, 0.00440649f, 0.27222210f, -0.15593234f, 
    -0.00205191f, -0.04121406f, -0.07329138f, 0.04308813f, 0.12477505f, 0.14526995f, 0.08113652f, -0.14229350f, 
    0.14068000f, -0.48332834f, -0.00746898f, -0.07359569f, 0.24034107f, -0.09610606f, 0.10981065f, 0.22208305f, 
    -0.05546326f, -0.03033145f, -0.29754975f, 0.13241075f, -0.09747597f, 0.00332625f, -0.10096779f, 0.32821158f, 
    0.31483006f, -0.00385590f, -0.09595640f, -0.03968209f, 0.23725691f, 0.46492231f, -0.18736209f, 0.06570678f, 
    0.06904592f, -0.08225122f, 0.22060972f, -0.00987975f, -0.56999791f, 0.07127074f, -0.01488255f, -0.63466966f, 
    -0.29358876f, -0.15527339f, -0.25667718f, -0.11535531f, -0.07584183f, 0.09092969f, -0.14405988f, 0.38482040f, 
    -0.41192746f, -0.03507844f, -0.07121937f, -0.01351840f, 0.27928016f, -0.30969214f, 0.06718633f, -0.00350453f, 
    0.37255570f, 0.06820539f, 0.06805131f, -0.18373989f, 0.23727323f, -0.02495312f, 0.07526869f, 0.25375992f, 
    0.05629117f, 0.33567110f, 0.28669709f, 0.20144811f, -0.18205096f, 0.00528291f, -0.38297164f, 0.04336182f, 
    -0.02342691f, 0.06737925f, 0.06848364f, -0.04051563f, 0.08039970f, 0.25494370f, 0.03034555f, 0.08983847f, 
    0.04705401f, 0.01792712f, -0.12219102f, -0.09319090f, 0.17696401f, -0.03553776f, 0.12110595f, 0.03873622f, 
    0.00679429f, 0.03315361f, -0.09845331f, -0.01617115f, 0.04974625f, 0.14508969f, -0.15175208f, -0.04660995f, 
    0.04611187f, 0.09479472f, -0.09531109f, -0.25775802f, 0.17032351f, 0.06378377f, 0.04301628f, 0.03158250f, 
    -0.30248687f, 0.10516592f, 0.04297971f, 0.14326026f, 0.02776591f, 0.18389130f, 0.06119072f, -0.22805324f, 
    -0.04919835f, 0.06750298f, -0.29725844f, -0.08189481f, -0.13290671f, 0.05515396f, 0.06509817f, 0.12222406f, 
    0.13173190f, 0.13136771f, 0.11987513f, 0.05885519f, 0.13310711f, 0.13198319f, -0.02084290f, 0.10420981f, 
    0.14042099f, -0.16783954f, -0.63284439f, -0.13519733f, -0.19358094f, 0.11762806f, -0.14678027f, 0.22400159f, 
    -0.00026057f, -0.01684559f, -0.02336500f, 0.00375947f, -0.03553753f, -0.07070571f, -0.05664635f, 0.08643132f, 
    -0.03540171f, 0.08938830f, -0.31152257f, 0.06969064f, 0.12910141f, -0.06476215f, 0.32294616f, 0.21111590f, 
    -0.12947989f, -0.02293003f, 0.03998829f, -0.04407465f, -0.03047707f, 0.47476545f, 0.03181582f, -0.53993982f, 
    0.07946479f, 0.11776175f, -0.06323527f, -0.08668575f, 0.31527889f, 0.10360517f, 0.09438730f, 0.33723891f, 
    0.24858454f, 0.07740608f, 0.09780732f, 0.14613430f, -0.06772912f, 0.03762135f, -0.15831144f, -0.53986806f, 
    0.06603827f, 0.00985886f, -0.57528377f, -0.18434919f, -0.17050953f, -0.04411034f, -0.07096449f, -0.03647901f, 
    -0.69822347f, -0.01668555f, -0.20771423f, 0.02362092f, -0.29663855f, -0.05441815f, -0.30394310f, 0.10038990f, 
    0.29083860f, -0.03021550f, 0.10029418f, -0.57456666f, 0.15711802f, -0.00043619f, 0.10674779f, 0.37795892f, 
    0.25255066f, 0.19188520f, 0.13049017f, 0.17732786f, 0.18147378f, -0.17419524f, 0.15459451f, 0.15754409f, 
    -0.14307852f, 0.04234429f, 0.11086310f, 0.11551587f, -0.45207131f, 0.08707242f, -0.61335105f, 0.21064551f, 
    -0.27058953f, 0.31343180f, 0.00830269f, 0.28723067f, -0.55527920f, 0.11097706f, -0.17684396f, -0.03663427f, 
    -0.01925387f, -0.12381535f, 0.40421212f, 0.12385699f, 0.21898428f, 0.00173888f, -0.09167303f, 0.27753815f, 
    -0.00449247f, 0.05968221f, -0.13082182f, -0.00377676f, 0.05725952f, -0.08938058f, -0.03912212f, -0.22062850f, 
    0.01741508f, -0.16177143f, 0.09299021f, 0.04128445f, 0.14388809f, 0.15077741f, -0.13562301f, 0.01217157f, 
    -0.06891214f, -0.23746395f, -0.29536095f, 0.00212727f, -0.32851297f, -0.07871322f, 0.09802520f, 0.03009560f, 
    0.27464223f, 0.20377649f, -0.11007694f, 0.05063273f, -0.19103687f, 0.03886393f, 0.03184672f, -0.34691522f, 
    -0.05192178f, 0.06018868f, 0.00843937f, 0.06315615f, -0.29252505f, 0.27892074f, -0.14613535f, 0.16246814f, 
    -0.07790063f, 0.07048088f, -0.33225644f, 0.18571667f, -0.16714670f, 0.14933382f, -0.26511911f, 0.09593879f, 
    -0.09893396f, -0.20343269f, 0.03278924f, -0.14990598f, 0.21784629f, -0.40644583f, -0.11920238f, -0.03438796f, 
    0.24906337f, 0.38825670f, -0.06646927f, 0.14210574f, -0.00115872f, 0.09724788f, 0.03693505f, 0.04662029f, 
    0.22409739f, 0.23959534f, -0.22818652f, 0.05318278f, -0.00348017f, 0.01555907f, 0.16733731f, -0.44973671f, 
    0.37932098f, -0.04343495f, -0.34016117f, 0.01830646f, -0.14243227f, -0.05169370f, 0.10941944f, 0.00684532f, 
    -0.20233096f, -0.06148941f, -0.19277772f, -0.09866183f, -0.42942110f, -0.04783952f, 0.04669269f, 0.05492318f, 
    0.06102189f, 0.05236706f, 0.43094566f, -0.28065860f, 0.22365041f, 0.22301625f, -0.23957784f, 0.22764918f, 
    -0.06347481f, 0.45768118f, 0.22111306f, 0.45516202f, 0.18935792f, 0.23416233f, 0.08452103f, 0.11174907f, 
    -0.21431351f, -0.00456905f, -0.17053190f, -0.10059093f, -0.22874130f, -0.10257962f, -0.09012054f, 0.45376712f, 
    -0.06780447f, 0.15391737f, -0.26041877f, 0.13188934f, -0.10508321f, -0.00895445f, 0.01802223f, -0.09430272f, 
    -0.32741198f, 0.03998517f, 0.13321672f, -0.11646026f, 0.17514031f, 0.20039876f, -0.04420830f, 0.12985620f, 
    -0.33623308f, 0.05768601f, 0.15097028f, 0.16373286f, -0.01629017f, -0.13426575f, -0.07153560f, 0.18781212f, 
    0.08276991f, -0.04754800f, -0.29561636f, -0.03853614f, 0.06942932f, 0.08506025f, -0.03667073f, -0.19095232f, 
    -0.02507296f, -0.08899713f, -0.05552666f, 0.03748784f, -0.21238060f, 0.16517900f, 0.07935674f, 0.58528787f, 
    0.05967137f, -0.13172115f, -0.45114720f, 0.25330284f, -0.02993803f, 0.37270805f, -0.15037811f, 0.28950500f, 
    0.07023272f, 0.52349645f, 0.05496209f, 0.07498468f, -0.08264363f, -0.09100574f, -0.13335134f, -0.08749577f, 
    -0.03754786f, -0.06133440f, -0.11728810f, -0.22618499f, 0.09633286f, 0.14608932f, 0.14084978f, 0.09861551f, 
    -0.34771815f, -0.26264545f, -0.20480309f, -0.03612653f, 0.09524667f, -0.30860981f, 0.08807853f, 0.11429512f, 
    0.26076522f, 0.25672993f, 0.05768066f, -0.08094661f, 0.37095979f, 0.12992357f, -0.19452964f, -0.03402613f, 
    -0.13215505f, 0.27017599f, -0.09151126f, 0.19923240f, 0.04650613f, 0.18200660f, 0.31996822f, -0.26464960f, 
    0.16423491f, -0.00368533f, -0.02626539f, 0.04053499f, -0.07885502f, 0.14804758f, -0.02222580f, -0.05831517f, 
    -0.41090822f, -0.00824378f, 0.02355377f, 0.18211396f, 0.00091978f, -0.08040535f, 0.09267127f, -0.34787115f, 
    0.29933026f, 0.10085439f, -0.10426809f, 0.16545564f, -0.12153005f, -0.07045561f, 0.14795777f, 0.17966183f, 
    0.03281315f, 0.02154041f, 0.08791512f, 0.21881227f, -0.12683389f, -0.08321673f, -0.10767025f, -0.02762676f, 
    0.16403045f, -0.10125683f, -0.18235654f, -0.04111473f, 0.04973403f, 0.03434643f, 0.02962204f, 0.13752078f, 
    0.30199054f, -0.00214856f, -0.17485285f, -0.05943396f, -0.15828276f, -0.00155688f, 0.11214516f, 0.49704865f, 
    0.26190111f, -0.12992993f, 0.10545064f, 0.08156600f, 0.09826891f, 0.09027559f, -0.10771958f, 0.16087897f, 
    -0.07678913f, 0.16747355f, 0.16533387f, -0.01156850f, 0.08562268f, -0.01023753f, -0.01685009f, -0.12949790f, 
    0.03295825f, 0.12411700f, -0.01175878f, -0.11905222f, 0.00716964f, 0.12294140f, -0.05185736f, -0.16386393f, 
    -0.17277050f, 0.03076557f, -0.28422311f, -0.10697005f, -0.03900633f, -0.21184841f, 0.27020022f, 0.02946662f, 
    0.18270504f, 0.14152761f, -0.41351485f, 0.13006553f, 0.16712712f, -0.04574533f, -0.00665245f, -0.07123107f, 
    0.02274747f, 0.50819075f, 0.05418983f, 0.10521038f, 0.13114427f, 0.11391645f, 0.30616847f, -0.03575128f, 
    -0.10450681f, -0.16634095f, -0.14105438f, -0.06027786f, 0.06517574f, -0.03706518f, -0.36177251f, 0.19279800f, 
    -0.24417353f, -0.08782255f, -0.22049843f, -0.03122716f, 0.04359517f, -0.01807828f, 0.13608503f, 0.25386989f, 
    0.01742372f, -0.03981272f, -0.03550554f, -0.10185130f, 0.06935216f, -0.07144486f, 0.03027446f, 0.01691695f, 
    -0.02252522f, -0.00067589f, 0.01877902f, -0.11800257f, -0.02379209f, 0.05368198f, -0.08373497f, -0.08106908f, 
    -0.02291383f, -0.07158818f, -0.05688985f, -0.10161886f, -0.11286189f, -0.00727259f, -0.01483789f, -0.01775115f, 
    -0.00122093f, 0.05693654f, -0.11009697f, -0.00214363f, 0.09023920f, -0.08045911f, -0.10764115f, -0.05874032f, 
    -0.08124276f, -0.11823226f, -0.12211716f, -0.05203062f, 0.04624258f, 0.05511393f, -0.02639241f, 0.05383928f, 
    -0.03664814f, -0.06507196f, 0.04850078f, 0.04842919f, -0.02527917f, -0.03710616f, -0.07185139f, -0.10108965f, 
    -0.04660545f, -0.04830032f, -0.06411338f, -0.06022937f, -0.00702551f, -0.05165165f, -0.07880254f, 0.03857974f, 
    -0.06602307f, -0.10649838f, 0.01320437f, 0.04071890f, 0.05587403f, -0.01764285f, -0.12844996f, 0.01778596f, 
    -0.09887727f, -0.00609522f, -0.00314257f, -0.06461251f, -0.07103879f, -0.03763831f, 0.07864097f, -0.11498067f, 
    0.02387902f, -0.07149309f, 0.01530249f, -0.03144556f, 0.01837527f, -0.08354993f, -0.02213320f, -0.01406792f, 
    -0.07727278f, -0.09383511f, 0.05463202f, 0.06395589f, -0.09672439f, 0.00586920f, -0.07738153f, 0.01085183f, 
    0.01848284f, -0.06786831f, 0.05685398f, -0.11712492f, -0.09159947f, -0.03873548f, -0.08299911f, 0.02773648f, 
    0.01518372f, -0.11359563f, 0.00092436f, -0.01323821f, -0.08609351f, 0.01252451f, -0.00726688f, 0.04978956f, 
    -0.03683925f, 0.08131272f, -0.05670145f, 0.05692528f, -0.00515493f, -0.00565705f, -0.05458383f, 0.04320104f, 
    0.06249646f, -0.04799378f, -0.02249167f, -0.10615495f, -0.10232148f, -0.08881105f, -0.06371169f, 0.05564767f, 
    -0.04083023f, 0.00222987f, 0.03666282f, -0.07582929f, -0.07089462f, 0.06667916f, -0.00670034f, -0.07223316f, 
    0.19692117f, 0.08289587f, -0.01946365f, -0.10571313f, -0.41397333f, 0.01330187f, 0.07629845f, -0.44406947f, 
    0.06001075f, 0.03920565f, 0.11934550f, 0.00032702f, -0.07053052f, -0.03501546f, -0.23627396f, 0.07141756f, 
    -0.18832494f, 0.01509539f, -0.00172878f, 0.08434983f, -0.27535737f, -0.25175226f, -0.07359830f, 0.04856051f, 
    -0.37365663f, 0.04797515f, 0.01948997f, 0.02424361f, 0.00667499f, 0.02710916f, 0.01484289f, 0.15996896f, 
    -0.13277760f, -0.09171896f, -0.13458084f, -0.27063632f, 0.04572773f, -0.02295582f, -0.15953450f, -0.00075738f, 
    -0.21891789f, 0.09677299f, -0.00821108f, 0.24229263f, 0.19011782f, 0.11771245f, 0.09354135f, 0.25305381f, 
    -0.23930793f, -0.06100347f, 0.05578304f, -0.01685391f, 0.04688378f, -0.01180811f, 0.23456967f, 0.07826555f, 
    0.13077301f, 0.15522210f, 0.01630885f, -0.10789020f, -0.22124420f, 0.08253761f, -0.17332353f, -0.10635860f, 
    -0.22120079f, 0.11742128f, 0.06335797f, -0.19896151f, 0.15016101f, 0.01453426f, -0.06291334f, 0.01092121f, 
    0.09236789f, 0.00341845f, 0.17613934f, 0.18054062f, 0.07402292f, 0.06141758f, -0.05948082f, 0.04999157f, 
    0.06380880f, 0.29019767f, -0.29334104f, 0.05896254f, 0.11618898f, -0.30276161f, 0.01677338f, 0.30271652f, 
    -0.08774357f, 0.00570376f, 0.08568458f, 0.03513000f, 0.08182643f, -0.16692619f, -0.02253225f, 0.22415034f, 
    0.11356735f, -0.23415147f, 0.19301073f, 0.07705679f, 0.12244111f, -0.01803864f, -0.00041187f, 0.48868677f, 
    -0.17778552f, 0.20357414f, -0.05721734f, -0.06939403f, -0.24958889f, 0.02101314f, -0.25674069f, -0.36410677f, 
    0.10946450f, 0.03157763f, 0.21595719f, -0.08222921f, 0.10941152f, -0.08829677f, 0.37149876f, 0.07107932f, 
    -0.28107598f, 0.19814308f, -0.08185973f, 0.05360604f, 0.00738902f, 0.22122009f, 0.18112464f, -0.50802296f, 
    -0.62887174f, -0.40570578f, 0.02873267f, 0.30074579f, 0.10884560f, 0.03368616f, 0.18117774f, 0.06640805f, 
    0.09538424f, -0.22899251f, -0.00796476f, -0.14429170f, -0.00698840f, -0.03822378f, -0.14067851f, 0.28503940f, 
    -0.11300834f, 0.03006860f, -0.01984053f, -0.00480950f, 0.33926713f, -0.02400210f, 0.03996825f, -0.02123147f, 
    0.26025826f, 0.01166439f, 0.10875163f, -0.09901916f, 0.06198892f, -0.05073103f, 0.11540510f, 0.01262856f, 
    -0.04571483f, 0.17354032f, 0.22964217f, 0.19585350f, 0.12432494f, 0.23717938f, -0.10730859f, -0.25131208f, 
    -0.03901944f, 0.12668815f, -0.03914537f, -0.19578198f, -0.04784388f, 0.19992442f, 0.06670295f, -0.07429273f, 
    -0.10344108f, 0.14543943f, 0.06470235f, 0.03748120f, -0.00922565f, 0.01825517f, -0.13748525f, 0.02528681f, 
    -0.12710793f, -0.03165336f, 0.00197576f, 0.04421839f, 0.38578859f, -0.03844646f, -0.04687940f, -0.11749183f, 
    -0.10286863f, 0.07004861f, 0.10661528f, -0.07851462f, -0.06104673f, -0.02784885f, 0.01398593f, 0.03317045f, 
    0.07833694f, 0.25944862f, 0.01987506f, 0.12409494f, -0.16046464f, 0.10442049f, -0.06325206f, -0.08586271f, 
    0.00315686f, 0.03228213f, 0.11987267f, -0.00129302f, 0.09248400f, 0.09974043f, -0.05555090f, 0.09614264f, 
    0.28629637f, 0.04873228f, 0.31527326f, 0.00846018f, -0.02530805f, 0.12948285f, 0.06022689f, -0.00439769f, 
    -0.07705112f, 0.17775457f, 0.00605604f, 0.00081242f, 0.00649644f, 0.13517329f, -0.07090771f, -0.02146830f, 
    0.02540188f, -0.53837842f, 0.06443867f, 0.01847638f, 0.18875626f, -0.15429688f, -0.02159388f, 0.12425437f, 
    0.06592775f, -0.02105054f, 0.01338986f, -0.00881355f, 0.09291753f, 0.18396837f, 0.31731206f, -0.03933425f, 
    0.14485985f, -0.06924513f, 0.01731338f, -0.06980814f, 0.09040954f, -0.26618066f, -0.17527832f, -0.14174460f, 
    -0.42484930f, -0.55072463f, 0.05191527f, 0.27590454f, 0.13605639f, -0.08953494f, 0.05682931f, 0.30286175f, 
    -0.13019909f, -0.16894430f, 0.12444659f, -0.39393476f, -0.06577951f, -0.04663356f, 0.05834324f, -0.01694957f, 
    0.20210123f, -0.01877498f, -0.44768843f, -0.00977400f, 0.43860999f, -0.39685491f, -0.09150367f, 0.02699528f, 
    0.39724249f, 0.03132158f, -0.01944073f, -0.01658219f, 0.00609432f, 0.00564349f, 0.27995872f, -0.10338388f, 
    -0.05007331f, 0.25672200f, 0.22058357f, 0.52903891f, 0.00693736f, 0.22245942f, 0.00581462f, -0.13379321f, 
    -0.19683821f, -0.13285458f, -0.13246721f, 0.05853879f, 0.06205783f, 0.48493046f, -0.00309243f, -0.29939008f, 
    0.35252091f, 0.18883482f, -0.06037910f, -0.01629359f, -0.03647055f, 0.06794547f, 0.16216215f, -0.04266227f, 
    0.14875343f, -0.21044949f, 0.04353026f, 0.01442167f, 0.44847560f, 0.01612248f, 0.01786244f, 0.36040893f, 
    -0.12614751f, -0.00357566f, -0.05931791f, 0.19429548f, 0.03519958f, 0.13609587f, 0.06108470f, 0.04005542f, 
    -0.09256715f, 0.35315034f, 0.12331390f, -0.01192720f, -0.02924087f, 0.30309644f, 0.04098002f, 0.07648247f, 
    -0.00433605f, 0.05920762f, -0.09723972f, -0.16893204f, -0.24442481f, 0.19934183f, 0.01404253f, -0.09775590f, 
    0.33515564f, 0.03716622f, 0.29774013f, 0.09510450f, -0.04738525f, 0.18268901f, 0.23098041f, -0.14703904f, 
    -0.09261432f, -0.10854047f, 0.10992562f, -0.04878897f, 0.07859807f, 0.00901689f, -0.06893149f, -0.09783304f, 
    0.05102899f, 0.18282914f, 0.04514473f, -0.03678338f, 0.09337945f, -0.31639177f, -0.17810829f, 0.19014768f, 
    -0.04091233f, -0.08838889f, 0.02806013f, -0.00995464f, -0.03781679f, 0.00597151f, 0.13133942f, 0.11932524f, 
    0.02680617f, -0.06950007f, -0.24215862f, 0.25117648f, 0.12212224f, 0.01072477f, -0.02065307f, 0.27393001f, 
    -0.08485788f, 0.02333365f, 0.06586996f, 0.09721762f, -0.76349342f, 0.04973025f, 0.08053253f, -0.10307766f, 
    -0.01016179f, 0.07188353f, 0.21554300f, 0.09540115f, 0.01818140f, -0.07145815f, -0.19485492f, -0.14216132f, 
    -0.38653007f, 0.05649221f, 0.28916004f, 0.09900151f, -0.28425598f, -0.29142290f, 0.05296226f, -0.04781392f, 
    0.05661336f, -0.04734118f, 0.03301120f, -0.11712812f, 0.32238105f, -0.08119072f, -0.04649389f, -0.03771207f, 
    0.04022517f, -0.06672876f, -0.05908531f, 0.09335820f, 0.19627720f, 0.20816776f, -0.23957257f, -0.01532840f, 
    0.09437700f, 0.22960024f, 0.01144343f, 0.02257084f, 0.10226574f, -0.00976854f, 0.01684383f, 0.14033829f, 
    -0.34960115f, 0.03921941f, 0.09695224f, -0.03716021f, -0.18216890f, 0.09997883f, -0.10082350f, 0.32093552f, 
    -0.07195330f, 0.12453885f, 0.01198189f, -0.03261415f, -0.70330811f, 0.00628452f, 0.00057152f, -0.05287182f, 
    -0.18003863f, 0.07009921f, 0.15948945f, -0.56305069f, 0.02707122f, -0.09230670f, 0.07401487f, 0.03582697f, 
    -0.01628436f, -0.09825809f, 0.01448205f, 0.00865160f, 0.15577771f, 0.01809857f, -0.01617472f, 0.10516485f, 
    0.04556113f, 0.22376117f, 0.02551579f, 0.00755677f, -0.11271907f, 0.06952985f, -0.06150645f, 0.25356606f, 
    -0.01173356f, -0.07978428f, -0.07067787f, -0.13663861f, -0.43384930f, -0.01143703f, 0.07915770f, 0.17281528f, 
    0.12022130f, -0.06315593f, -0.10954835f, 0.16158609f, -0.01511553f, 0.12329949f, 0.01262239f, 0.30640596f, 
    0.05127055f, -0.41905245f, 0.06502047f, -0.04505086f, 0.11573143f, -0.03103867f, -0.15733564f, -0.02366210f, 
    0.08475336f, 0.03040243f, 0.16394275f, -0.10078966f, -0.00838883f, 0.14599679f, 0.18779646f, -0.06148018f, 
    0.21290287f, -0.15006222f, 0.12011997f, -0.18810868f, 0.08832083f, 0.08585570f, 0.12536103f, -0.12398088f, 
    -0.03404540f, 0.00682007f, -0.03896603f, 0.02796536f, 0.05559238f, -0.08522154f, -0.00780354f, 0.00351416f, 
    -0.12059917f, -0.05293067f, 0.05444564f, -0.07913522f, -0.05674000f, -0.09276687f, -0.02580118f, 0.00416311f, 
    0.00397297f, 0.01470994f, 0.07954205f, -0.09125412f, -0.06429410f, -0.03341756f, 0.01744613f, 0.02435637f, 
    -0.08790643f, -0.00435688f, 0.02734722f, -0.05003476f, 0.01503482f, 0.00401752f, -0.03812338f, -0.02039140f, 
    0.03811501f, -0.01222819f, 0.05300052f, -0.05238460f, -0.05093756f, -0.04731937f, 0.03111750f, -0.03865641f, 
    -0.02281844f, -0.07687405f, -0.02930708f, -0.04577402f, 0.04977040f, 0.02279862f, -0.04331855f, -0.11217332f, 
    -0.05200609f, -0.08779460f, -0.02096606f, -0.06021169f, 0.00390567f, 0.01707341f, -0.04682147f, -0.05506425f, 
    -0.03858657f, -0.01290873f, 0.03019329f, -0.07673871f, 0.00023989f, 0.00508919f, -0.08288135f, 0.01598457f, 
    -0.08428381f, 0.03172387f, -0.04727865f, 0.00870144f, 0.02662295f, 0.04517873f, -0.02502203f, 0.00044630f, 
    -0.09324839f, -0.10938396f, 0.01931180f, -0.07327663f, 0.05110400f, -0.02337497f, -0.08746029f, -0.01038444f, 
    0.06303923f, -0.07558041f, -0.04854821f, 0.05140346f, 0.05594574f, -0.08062432f, -0.08516719f, -0.00915997f, 
    0.04915217f, 0.05078634f, -0.09986571f, -0.03468946f, -0.04755916f, -0.04261772f, -0.10204706f, -0.09819777f, 
    -0.01811665f, 0.06155573f, -0.05593627f, -0.11247817f, 0.02381968f, 0.06447662f, 0.04846856f, 0.06255948f, 
    0.02895058f, -0.01679739f, -0.08412147f, 0.05744432f, -0.00059926f, -0.06991747f, -0.11465861f, 0.02115384f, 
    0.04960012f, -0.10037628f, -0.08094829f, 0.02079569f, -0.00922054f, -0.12083270f, -0.08256169f, -0.07302594f, 
    -0.05649855f, -0.08900482f, -0.03547061f, -0.05904870f, 0.05394214f, -0.09949835f, -0.01673168f, -0.06882519f, 
    0.03695258f, 0.02800326f, 0.04550766f, 0.04422487f, 0.03397730f, 0.03324829f, -0.09844119f, -0.06249511f, 
    -0.10918345f, 0.04921044f, 0.06931370f, 0.02121839f, -0.03907427f, 0.02514745f, -0.05180888f, -0.03630009f, 
    -0.09814578f, 0.04585915f, 0.01905073f, -0.03391545f, -0.06901980f, -0.04067088f, 0.00775212f, -0.00191278f, 
    -0.01241101f, -0.06160445f, -0.08109110f, 0.01776986f, 0.06241256f, -0.08080944f, -0.01642234f, -0.08803472f, 
    -0.06834245f, 0.04804341f, -0.03046528f, 0.03868587f, -0.06358676f, -0.09012184f, 0.01169538f, -0.04774241f, 
    -0.01859715f, 0.07377100f, -0.00869167f, 0.04262676f, -0.06344386f, 0.01002016f, -0.01212455f, 0.05771585f, 
    -0.08095331f, -0.10209958f, 0.03477846f, -0.04929082f, -0.07435130f, 0.01029228f, -0.04843445f, -0.00837270f, 
    -0.07452372f, -0.03383237f, -0.07103872f, -0.07626175f, 0.06895411f, -0.06782176f, 0.00579420f, 0.04726478f, 
    -0.02458700f, 0.06667505f, -0.03268278f, 0.03535011f, -0.00122238f, 0.03420514f, -0.07966477f, 0.00099416f, 
    0.01336195f, -0.10260756f, -0.00150449f, 0.01936501f, 0.00942224f, -0.05756434f, -0.08205526f, -0.02430086f, 
    0.01245029f, -0.02268593f, 0.05077411f, -0.02759418f, 0.02666487f, -0.00466955f, -0.09215239f, -0.08141035f, 
    0.06359103f, 0.02951183f, -0.05808467f, -0.06662631f, -0.07256513f, 0.03705693f, -0.08050235f, 0.03534431f, 
    -0.03133995f, 0.02142881f, 0.07401166f, 0.02643484f, 0.03833641f, -0.04276464f, -0.05812334f, 0.00795057f, 
    -0.08273445f, -0.06548174f, 0.00533245f, -0.06124327f, 0.00251226f, -0.05964620f, 0.02881627f, -0.09486326f, 
    0.05562692f, -0.09312649f, -0.09432842f, 0.00774519f, 0.00885006f, -0.00471050f, 0.03395791f, 0.06531899f, 
    0.02028615f, -0.12077681f, -0.03824597f, -0.07606395f, 0.00548068f, -0.02069658f, -0.09461688f, 0.03409557f, 
    -0.05948696f, -0.03752706f, 0.02795144f, -0.08333375f, -0.05853048f, -0.07943539f, -0.03199718f, -0.11658195f, 
    0.03778499f, 0.00502652f, -0.01487737f, -0.00574116f, -0.03522220f, -0.02770037f, -0.03840357f, 0.05063377f, 
    0.01811346f, -0.07902607f, 0.02560038f, 0.03764323f, -0.03014558f, 0.07113457f, 0.08709183f, 0.06147625f, 
    0.13034216f, -0.03897507f, -0.11518706f, -0.07144597f, -0.06067197f, 0.01443653f, -0.05537323f, -0.10230556f, 
    -0.03785879f, -0.07854750f, -0.03048950f, -0.05765369f, -0.02562158f, 0.04898854f, -0.03700324f, -0.03136227f, 
    -0.04091882f, -0.04430952f, -0.11913337f, -0.01479162f, 0.00274773f, -0.00175697f, -0.07229625f, 0.07840171f, 
    -0.07537456f, -0.07701577f, 0.06031452f, -0.01525699f, -0.05284719f, -0.07555018f, -0.11197327f, 0.02871911f, 
    -0.10638499f, -0.09902490f, -0.03145882f, -0.02454553f, 0.06576750f, 0.02949815f, -0.02401292f, -0.00230035f, 
    -0.03462146f, -0.10579449f, 0.00244971f, 0.07469049f, -0.03839564f, -0.09574347f, 0.04501403f, -0.01397798f, 
    0.08019142f, 0.05009749f, -0.01230347f, 0.03893172f, -0.08929802f, -0.07367412f, 0.05021216f, -0.08147031f, 
    0.08255976f, -0.08673384f, 0.02582287f, 0.06351429f, -0.05142282f, -0.08996726f, -0.06403127f, 0.04231614f, 
    -0.03585153f, 0.07260156f, 0.01108457f, -0.02928308f, -0.07854035f, -0.11405648f, -0.11043744f, 0.03363159f, 
    -0.06096023f, -0.02732089f, 0.02163682f, 0.01466455f, -0.06942689f, -0.10623576f, 0.01475412f, -0.07992060f, 
    -0.07885107f, -0.04514253f, 0.01318960f, -0.01947482f, 0.05330165f, 0.04587546f, 0.08230685f, 0.00863216f, 
    0.08631846f, 0.01976780f, -0.07905649f, 0.02724151f, 0.02743730f, -0.02163362f, 0.01779312f, -0.13737960f, 
    -0.05734172f, 0.02553678f, -0.00558074f, -0.04565749f, -0.10243908f, 0.05237610f, -0.10247128f, -0.10932641f, 
    0.04922363f, 0.07120448f, 0.00862919f, -0.01527684f, -0.08122101f, -0.10872523f, 0.03119413f, -0.02928151f, 
    0.05170373f, -0.08006993f, -0.05489126f, -0.08404689f, 0.06400545f, -0.04758294f, -0.08634567f, -0.07791132f, 
    0.10367645f, -0.06579156f, 0.03344251f, -0.01380836f, -0.04212900f, 0.06805739f, 0.01468740f, -0.08255655f, 
    0.07574945f, 0.04903995f, -0.02817760f, 0.03809020f, 0.02041508f, 0.08723136f, 0.00475948f, -0.09272378f, 
    -0.07770138f, -0.05241292f, -0.01792252f, -0.04215563f, -0.03634952f, -0.00622985f, -0.06934816f, -0.03524828f, 
    -0.01657509f, -0.01788752f, -0.08296249f, 0.08324448f, -0.04533863f, -0.12994106f, -0.09705867f, -0.11484875f, 
    -0.07714365f, -0.06067520f, 0.08662169f, 0.01006621f, -0.07098681f, -0.04471554f, 0.02806907f, -0.05702883f, 
    -0.08564823f, -0.10869657f, 0.06672779f, -0.06043117f, -0.08442897f, -0.00853499f, -0.05951221f, -0.08765402f, 
    0.01550338f, -0.03060751f, -0.01786891f, 0.04031336f, -0.09823907f, -0.10169039f, 0.02990125f, -0.13895388f, 
    -0.03327814f, 0.01105366f, -0.05934822f, -0.06252953f, -0.12121815f, -0.06032787f, 0.07196929f, -0.00339424f, 
    -0.08526040f, -0.05971691f, -0.07111331f, -0.02086872f, 0.00657902f, -0.07205963f, 0.06187466f, -0.04569076f, 
    -0.11333837f, -0.00659999f, -0.08290436f, -0.04203449f, -0.04353542f, -0.09499899f, -0.06790376f, 0.01499157f, 
    -0.01201062f, 0.01789975f, -0.01508347f, -0.04724605f, -0.03419096f, 0.01204104f, 0.04614063f, -0.08489280f, 
    -0.07764684f, 0.04559794f, 0.05783669f, -0.07157477f, 0.03386471f, -0.08401188f, 0.06897485f, -0.08156983f, 
    -0.08590320f, -0.09739611f, -0.05686121f, 0.00213190f, -0.03698464f, -0.04554116f, -0.05083030f, 0.00311000f, 
    -0.00145981f, -0.02672048f, -0.00922051f, -0.08104296f, -0.07052678f, -0.09363821f, -0.11467896f, -0.01613339f, 
    -0.15851653f, -0.14301056f, 0.00593112f, -0.20631130f, 0.27323160f, 0.03804964f, -0.25790247f, 0.35522905f, 
    -0.02008215f, 0.09768126f, -0.04136969f, -0.39254954f, -0.05004902f, 0.15826981f, -0.31366488f, -0.28153718f, 
    -0.15450577f, -0.06296660f, -0.20063494f, -0.13243996f, 0.09867828f, -0.46246639f, -0.02162266f, -0.01790264f, 
    -0.13558096f, 0.01991263f, 0.19221036f, -0.55564123f, -0.12974101f, 0.01342532f, -0.16863585f, -0.52791762f, 
    0.38067880f, 0.21300638f, 0.17011032f, -0.15718694f, 0.12200712f, 0.13750347f, 0.05586734f, 0.14661245f, 
    0.21428877f, 0.02442175f, 0.07234640f, 0.13135935f, 0.14848977f, -0.18457970f, 0.17723364f, 0.04450019f, 
    0.25576815f, 0.08804671f, -0.30536705f, 0.02131554f, -0.14978752f, 0.03342202f, -0.20864618f, -0.02891138f, 
    0.24608670f, 0.03441799f, 0.14824237f, 0.17462197f, -0.13338052f, 0.11385623f, -0.29394388f, 0.40646142f, 
    -0.15395176f, -0.38655996f, 0.22428896f, -0.20686577f, 0.07071538f, 0.11231446f, -0.09285739f, 0.11581776f, 
    -0.32276401f, 0.10338046f, -0.15604217f, 0.09974817f, -0.04505304f, 0.10512773f, 0.03011459f, -0.09179008f, 
    -0.00153521f, -0.18526039f, -0.18294330f, -0.24470499f, 0.29358143f, 0.09904210f, -0.28909519f, 0.04481028f, 
    0.15495913f, 0.09625106f, -0.19328392f, -0.41344592f, 0.13542579f, -0.31293193f, 0.06949171f, -0.09268584f, 
    0.22988030f, 0.41119063f, -0.12486841f, 0.11642850f, -0.16371250f, -0.02464401f, 0.03199932f, -0.10675829f, 
    -0.05892647f, -0.20265037f, 0.06881380f, 0.07799410f, 0.24986255f, 0.13700436f, -0.25547463f, 0.49271896f, 
    0.07372945f, -0.06506378f, -0.06609959f, 0.33441722f, -0.16628346f, 0.09275443f, -0.12957639f, 0.21055295f, 
    0.00241951f, -0.00414709f, -0.50081247f, -0.16019922f, 0.13137691f, -0.35034004f, -0.11607397f, 0.28592935f, 
    -0.25925320f, -0.23761266f, 0.10050668f, 0.09516683f, -0.47151548f, -0.02152518f, -0.07872321f, 0.23825115f, 
    0.08842423f, -0.24231160f, -0.05565317f, -0.53695005f, -0.02277428f, 0.05969341f, -0.25603080f, -0.16957912f, 
    -0.42346263f, -0.03678773f, -0.25995147f, -0.08830557f, 0.04443659f, -0.75607955f, -0.01076026f, -0.03488542f, 
    -0.28848359f, -0.01303397f, -0.17035945f, -0.18855509f, 0.27061740f, 0.05149048f, -0.01069426f, -0.10023223f, 
    0.25409222f, 0.29029673f, 0.04843531f, 0.13303059f, 0.12818818f, 0.32413247f, -0.50925857f, -0.19385169f, 
    0.06192464f, 0.06306994f, 0.00235729f, -0.22483960f, 0.15277873f, 0.00253636f, 0.06667373f, -0.04675181f, 
    0.08155787f, -0.05285222f, -0.11508867f, 0.00066548f, 0.01014847f, -0.07586093f, -0.09636468f, 0.02772235f, 
    -0.07171319f, 0.04597893f, -0.02108125f, 0.03340163f, -0.13323773f, 0.08932623f, 0.03789349f, 0.27334830f, 
    -0.26721624f, -0.20243891f, 0.02459747f, -0.49946275f, 0.01009863f, 0.05298032f, 0.07690621f, -0.00292910f, 
    -0.09507378f, 0.08079027f, 0.07705955f, 0.20729481f, -0.06479468f, 0.19583708f, -0.06294137f, -0.04212388f, 
    -0.01272521f, 0.04807198f, -0.04155037f, -0.38195407f, -0.07945982f, 0.22986528f, -0.21673909f, 0.17050634f, 
    0.23642592f, 0.08124822f, -0.21370800f, -0.28975388f, 0.05316692f, -0.20760785f, 0.11468008f, -0.20627744f, 
    0.04364314f, 0.37712014f, -0.62470102f, 0.04429185f, 0.05282640f, 0.12544271f, -0.02968042f, -0.28954533f, 
    0.09762488f, -0.31868973f, 0.05629911f, 0.07318357f, 0.33772790f, -0.01195671f, 0.15973672f, 0.26538640f, 
    -0.07395966f, 0.10000676f, 0.06551716f, 0.09132766f, 0.18720664f, 0.15888722f, -0.14422244f, 0.07683457f, 
    0.25596493f, -0.18430126f, 0.01693538f, -0.13044290f, -0.02701131f, 0.04078956f, -0.39131549f, 0.14914247f, 
    -0.28233108f, -0.29779482f, 0.04529401f, 0.28998348f, -0.30043995f, -0.10165006f, 0.11508141f, 0.08490407f, 
    0.19100644f, -0.24201742f, -0.12945442f, -0.29790521f, -0.06189424f, -0.03636333f, -0.00340036f, -0.19314779f, 
    -0.23705727f, -0.01805388f, -0.04546791f, -0.12105201f, 0.16014484f, -0.19550252f, -0.04072786f, 0.07316174f, 
    -0.04217467f, 0.00768645f, -0.16366826f, -0.18626381f, 0.30891511f, -0.01533288f, 0.13069926f, -0.08048324f, 
    0.12831336f, 0.23457088f, 0.11209124f, 0.41824421f, 0.11682054f, 0.17171465f, -0.31079206f, -0.03423241f, 
    0.00723834f, 0.07695358f, 0.01353876f, -0.29545382f, 0.06407560f, 0.00582195f, 0.08248416f, -0.11766137f, 
    0.02616591f, -0.01773800f, 0.03261572f, 0.01343109f, 0.16999860f, -0.05805943f, -0.40504560f, 0.06205673f, 
    -0.33619145f, -0.02261890f, -0.04687627f, 0.04729201f, -0.09873777f, 0.03380962f, 0.07867751f, 0.16181690f, 
    -0.14849615f, -0.16245490f, 0.07850228f, -0.11859395f, -0.01387844f, 0.04283649f, 0.01028121f, 0.07979279f, 
    0.01018273f, 0.16803734f, 0.09216181f, 0.09029953f, -0.14287472f, 0.08044414f, 0.03599660f, 0.07082141f, 
    -0.05236657f, -0.17782576f, 0.18283670f, -0.43838072f, 0.00309356f, 0.31818524f, -0.20379454f, -0.00805311f, 
    0.18851151f, 0.06458329f, -0.25435513f, -0.19984949f, -0.02146284f, 0.01942035f, 0.10228445f, -0.16243149f, 
    -0.06125913f, 0.29927021f, 0.13698423f, -0.06238483f, -0.06781400f, 0.23876515f, -0.07044899f, -0.40659338f, 
    0.28354508f, -0.44053122f, -0.00268178f, -0.08323674f, 0.50424719f, -0.08048363f, 0.39928463f, 0.26965284f, 
    -0.02159151f, 0.05698113f, -0.12754488f, 0.04994800f, 0.23685434f, 0.26033670f, -0.32885352f, 0.02054489f, 
    0.53683645f, -0.27117953f, 0.07465224f, -0.27764243f, 0.02113030f, 0.24093916f, -0.37574109f, 0.18999417f, 
    -0.02939625f, -0.08235907f, -0.01281885f, -0.06527776f, 0.01083363f, -0.04520437f, -0.10122154f, 0.04050365f, 
    0.01719289f, 0.03209657f, -0.03093745f, 0.00853203f, 0.05365693f, -0.06771383f, -0.06582882f, -0.08436788f, 
    0.05358276f, 0.04336939f, 0.08374943f, -0.05603854f, -0.04708376f, -0.03447604f, 0.00122863f, -0.02705084f, 
    0.09029180f, 0.00447335f, -0.00480400f, -0.03023086f, 0.05614294f, -0.07680736f, -0.02843644f, -0.10968719f, 
    -0.09096022f, -0.10033255f, 0.00147884f, -0.11798993f, -0.04932573f, 0.05465505f, -0.02493776f, -0.02007029f, 
    -0.10550500f, -0.00366267f, -0.00758598f, 0.00537587f, 0.02941197f, -0.03649106f, -0.05312664f, 0.02581648f, 
    0.04402625f, -0.07776085f, 0.01129150f, 0.06692422f, -0.02347761f, -0.07626283f, -0.02584088f, 0.03517301f, 
    -0.03757975f, -0.05705470f, -0.01753675f, -0.07338843f, -0.00642409f, 0.02320377f, 0.01191178f, 0.03641146f, 
    0.01528773f, -0.07968800f, -0.07833575f, -0.04765857f, -0.09389775f, -0.06732736f, 0.06846759f, -0.06701971f, 
    0.01010753f, 0.01812918f, -0.10126752f, 0.02707179f, 0.01401946f, 0.02474895f, 0.03889542f, -0.07318798f, 
    -0.05862936f, -0.06052384f, -0.05107831f, 0.01588762f, -0.06727441f, -0.15017258f, -0.00183440f, 0.03528266f, 
    0.00772984f, -0.01529502f, -0.12805131f, 0.01120198f, -0.05744864f, -0.04391488f, 0.01285002f, -0.07819000f, 
    0.00909523f, -0.09552482f, 0.04622416f, 0.02702557f, -0.08317181f, -0.00228798f, 0.07903749f, -0.02076861f, 
    -0.11906477f, 0.04369440f, 0.07719832f, 0.02158771f, 0.02068511f, -0.06803678f, -0.00770185f, -0.04232880f, 
    0.07543867f, -0.09395166f, 0.03810534f, 0.03561706f, -0.10372057f, -0.00890247f, 0.04922687f, -0.11674903f, 
    0.11254743f, -0.06735898f, 0.04850010f, -0.03946420f, -0.00150775f, -0.09970833f, -0.03503297f, 0.00672025f, 
    -0.04939206f, -0.12066248f, -0.03101203f, 0.39347288f, 0.15122373f, 0.12794331f, 0.17052360f, 0.23612137f, 
    -0.04605094f, -0.15448764f, 0.18499584f, -0.19647336f, -0.05651386f, -0.10796908f, 0.18970279f, 0.15511896f, 
    -0.22797322f, 0.08274198f, -0.50582159f, -0.10358111f, 0.25808248f, -0.12730521f, -0.00922953f, -0.01786329f, 
    0.16355023f, -0.03839060f, 0.08022280f, -0.15145403f, -0.08972893f, 0.00437177f, 0.08736710f, -0.08044861f, 
    0.01376076f, 0.18399607f, 0.19338034f, 0.15768665f, 0.05559249f, 0.19476974f, -0.06804327f, -0.09307937f, 
    -0.04581746f, 0.10673041f, 0.00301164f, 0.21294698f, 0.13880432f, 0.28756237f, 0.01817975f, -0.14657488f, 
    0.15607667f, 0.24548250f, 0.00490745f, -0.04086821f, -0.07100584f, -0.04548542f, 0.05444841f, 0.34512889f, 
    -0.11660591f, -0.02769313f, -0.08375704f, 0.19362406f, 0.04217892f, 0.06929403f, 0.10938528f, 0.06452179f, 
    -0.00545093f, 0.06973212f, 0.05552097f, -0.22062553f, 0.02677997f, -0.15988785f, -0.00506054f, 0.13643795f, 
    0.04903061f, 0.22660011f, 0.11545515f, -0.04645032f, 0.01131224f, 0.02681421f, -0.01435027f, 0.03860758f, 
    0.00544294f, 0.09804853f, -0.02094899f, -0.27317154f, -0.20600408f, 0.12258455f, 0.02682893f, -0.16713618f, 
    0.21008573f, 0.00961413f, 0.27845472f, 0.14938298f, -0.09627353f, 0.34444591f, 0.22403395f, 0.14471781f, 
    -0.00353101f, -0.12680885f, 0.21484479f, -0.06588752f, -0.05467237f, 0.04859677f, -0.05979843f, 0.12319805f, 
    0.07780426f, 0.19381559f, 0.08641778f, -0.08289319f, 0.01484171f, -0.11414401f, 0.05495675f, 0.01686434f, 
    -0.07112707f, -0.18461469f, -0.17606635f, -0.06611256f, 0.03172901f, 0.06985202f, 0.32131878f, 0.12193397f, 
    -0.00521904f, -0.22490829f, -0.08840344f, 0.16804883f, 0.25125897f, -0.18285818f, 0.01028550f, 0.05547669f, 
    0.21789986f, 0.37283987f, 0.03023315f, -0.21181202f, -0.30742553f, 0.11461597f, -0.01313456f, -0.18973675f, 
    -0.01572686f, -0.00541742f, -0.05376971f, -0.00990314f, 0.00556250f, -0.01239240f, -0.07701851f, 0.27052751f, 
    -0.13950373f, 0.03913730f, 0.17385282f, -0.03897087f, -0.24912739f, -0.49715281f, 0.02962268f, -0.02549659f, 
    0.03618195f, 0.09696820f, 0.21594909f, -0.13088225f, -0.04118238f, -0.00423277f, 0.11740933f, 0.12327480f, 
    -0.17341024f, -0.29665011f, -0.07691132f, -0.40203652f, 0.15322325f, -0.09200250f, -0.47322896f, -0.11154132f, 
    -0.04366168f, 0.13746423f, 0.12582061f, 0.24224184f, 0.23978515f, 0.17132041f, -0.02064714f, -0.02984403f, 
    -0.13005753f, 0.14219980f, 0.01123433f, -0.06166887f, -0.16528225f, -0.01387437f, 0.19441664f, 0.18857099f, 
    0.12467173f, -0.01340737f, 0.13047878f, 0.09632327f, -0.01001021f, 0.05775337f, -0.00520236f, -0.26743579f, 
    -0.35015324f, 0.12140013f, 0.04231120f, 0.15165381f, 0.18839207f, 0.15812048f, -0.13424434f, -0.05342742f, 
    -0.16625558f, -0.29826796f, 0.15145774f, 0.03958902f, -0.02611851f, 0.02406077f, 0.05959022f, 0.39455786f, 
    0.06235627f, 0.10838166f, -0.17553052f, -0.06816009f, -0.26141360f, -0.34327656f, -0.02634531f, 0.33005372f, 
    -0.00879609f, -0.11488509f, 0.22070108f, -0.12210379f, 0.05778060f, 0.09197097f, -0.05396246f, 0.34959021f, 
    0.06400517f, -0.10608048f, -0.14191273f, 0.27514073f, -0.21835746f, 0.00173013f, 0.00577718f, 0.58057868f, 
    -0.17800084f, 0.18100041f, 0.00091287f, 0.05923480f, -0.43948898f, -0.07186636f, -0.42724282f, -0.26597297f, 
    0.03839775f, 0.10791449f, 0.38265717f, 0.28374934f, -0.14439556f, 0.16095911f, 0.50189513f, -0.18677364f, 
    -0.02547413f, -0.06814490f, 0.11550047f, 0.15218788f, 0.14563532f, -0.14385132f, 0.31685150f, -0.13496360f, 
    0.01697193f, 0.01460338f, 0.08625894f, 0.23286298f, 0.04980230f, 0.10390913f, 0.16672371f, 0.08951426f, 
    -0.07424256f, -0.26263794f, 0.47660229f, -0.05084387f, 0.07728751f, -0.27164817f, 0.18717711f, -0.02109022f, 
    -0.22158867f, 0.04529934f, -0.39866245f, -0.02413860f, 0.30505139f, -0.44201204f, -0.06622445f, -0.04974799f, 
    -0.56427079f, 0.02157579f, -0.66630787f, 0.10439780f, 0.19662666f, -0.06959948f, 0.06889129f, -0.18336123f, 
    0.08830897f, 0.25904584f, -0.15030582f, 0.65998560f, 0.36747152f, 0.36243248f, 0.33619100f, 0.11315528f, 
    0.27843305f, -0.02654411f, 0.05431099f, 0.00313487f, 0.21650726f, 0.09632043f, 0.03009980f, -0.00242367f, 
    -0.13963492f, -0.01474085f, -0.01634005f, -0.02115643f, -0.12049589f, 0.06353822f, 0.03281924f, 0.26570284f, 
    -0.06062019f, 0.18648636f, -0.19470987f, -0.03319709f, -0.31632733f, 0.02645399f, 0.03482956f, 0.30130616f, 
    0.31180897f, 0.12592061f, -0.02786322f, 0.05785975f, 0.14296041f, -0.17039637f, -0.00875764f, 0.06422512f, 
    0.56283432f, 0.32542372f, 0.17344522f, -0.01305266f, 0.32467598f, 0.14181189f, -0.02197649f, -0.17480950f, 
    0.04298067f, 0.32693878f, -0.13859794f, -0.22793449f, -0.50461805f, 0.18370144f, 0.01875486f, -0.15714014f, 
    0.02422890f, 0.02325396f, 0.08304824f, 0.05557467f, -0.13623327f, 0.08520379f, 0.15644327f, -0.04604940f, 
    0.07748024f, -0.02773658f, -0.18196818f, -0.11378027f, 0.21970956f, 0.05220057f, -0.03692813f, -0.10063137f, 
    0.13216515f, 0.08706354f, -0.00659003f, -0.05949212f, 0.22577436f, -0.12716125f, 0.34469357f, 0.11706490f, 
    0.01112051f, -0.26195580f, -0.43530989f, -0.15525854f, 0.13050714f, 0.02505765f, 0.09021936f, 0.04223885f, 
    0.11185890f, -0.38125822f, -0.28977606f, -0.00377254f, 0.34263778f, 0.35185492f, 0.02429293f, -0.21102002f, 
    -0.14668304f, 0.10620037f, 0.04198704f, 0.03307971f, -0.48194024f, 0.03775843f, 0.07237565f, 0.12237658f, 
    0.06459554f, -0.00811184f, 0.25162646f, -0.04429140f, -0.06422971f, -0.23445298f, 0.10301524f, -0.01934235f, 
    -0.13067743f, -0.05470683f, -0.21716587f, 0.05836452f, -0.39624694f, -0.21385480f, -0.06410053f, 0.05663899f, 
    -0.23845661f, -0.06735802f, 0.00419662f, -0.10244596f, -0.08804569f, 0.03712242f, 0.13193350f, 0.02559273f, 
    0.02476468f, -0.31766257f, -0.10866702f, -0.68347985f, 0.04657430f, -0.07774020f, 0.07273877f, -0.20136639f, 
    -0.03857780f, 0.00706925f, -0.00116751f, -0.37331909f, 0.10147567f, -0.05980200f, 0.13685988f, 0.06655493f, 
    0.02292451f, 0.14984588f, 0.25929981f, -0.09777111f, -0.07501543f, -0.03570478f, 0.08917455f, 0.24204254f, 
    0.06436734f, 0.05231322f, 0.16630456f, -0.01168481f, -0.11842142f, 0.10810956f, 0.21007884f, 0.04732810f, 
    -0.16349246f, 0.03664172f, -0.08455423f, 0.05482930f, 0.09138237f, -0.09378416f, 0.01430779f, -0.04111713f, 
    -0.23239997f, -0.24224044f, 0.34912893f, 0.06468558f, 0.05977928f, 0.23137344f, -0.02610332f, 0.34660441f, 
    0.01164679f, 0.16687082f, -0.00620841f, -0.13479480f, -0.16556746f, -0.19827554f, 0.01747649f, 0.44804046f, 
    0.25028163f, -0.04160575f, -0.02742994f, -0.11307760f, -0.13150991f, -0.14983734f, -0.02967756f, 0.14515531f, 
    0.16712515f, 0.23812096f, -0.10098667f, 0.37244400f, -0.07208610f, 0.09833658f, -0.07430235f, 0.01655996f, 
    0.21350501f, -0.04517587f, -0.06352048f, 0.01252274f, 0.32798430f, 0.04850476f, -0.15724218f, -0.16229607f, 
    -0.01961817f, 0.21182215f, 0.55329967f, 0.15271436f, 0.05361862f, 0.30774748f, -0.18737417f, -0.23759736f, 
    0.09758691f, -0.16248246f, 0.15346041f, 0.07023534f, 0.00448740f, -0.09292167f, 0.20586944f, 0.28694668f, 
    -0.00618873f, 0.04376154f, -0.05928563f, -0.11933789f, -0.01327698f, -0.00150864f, -0.11694711f, 0.05762774f, 
    -0.09711818f, -0.10126314f, -0.06777890f, -0.10068277f, 0.02673410f, 0.03658101f, 0.01290742f, -0.03232544f, 
    0.05434572f, -0.07004414f, -0.09039669f, 0.04563248f, -0.04653353f, 0.02925939f, 0.05359179f, -0.01451209f, 
    0.00148988f, 0.06409045f, 0.07777309f, -0.03750119f, -0.04559923f, -0.06539571f, -0.08760106f, -0.02847267f, 
    0.02648062f, 0.00556624f, -0.05971125f, 0.07592813f, -0.03362804f, -0.02263662f, 0.03471518f, -0.01650287f, 
    -0.06035503f, 0.07631897f, 0.04822758f, -0.05868719f, 0.06123460f, -0.03764717f, 0.07354311f, -0.06573856f, 
    -0.04943642f, -0.05738056f, -0.04470719f, 0.02463675f, -0.12219014f, 0.00453835f, -0.03373763f, 0.01465236f, 
    -0.03471424f, -0.08932966f, -0.08297634f, -0.04403181f, 0.05244776f, -0.08486324f, -0.02675507f, -0.08547977f, 
    0.04060041f, -0.00487383f, -0.01403546f, -0.02098758f, -0.09607665f, 0.00807914f, 0.07475517f, 0.04038494f, 
    0.01838236f, 0.02251019f, -0.11690199f, -0.02212847f, -0.08061717f, -0.08426488f, 0.03716200f, 0.04653970f, 
    0.00879362f, 0.00285392f, -0.10941064f, -0.10258079f, 0.05139221f, -0.04408605f, -0.04408491f, -0.01381708f, 
    0.03000477f, -0.08850238f, -0.02008364f, -0.00910378f, -0.05734726f, 0.00451958f, -0.06037031f, 0.01233619f, 
    -0.09434608f, -0.08701895f, -0.02458356f, -0.05886043f, -0.06803185f, -0.05574839f, 0.01276696f, -0.08116740f, 
    -0.06938328f, 0.07711910f, -0.06929854f, 0.03213917f, -0.08263722f, -0.08049013f, 0.04258078f, 0.04302254f, 
    -0.00737714f, -0.09553527f, -0.05083526f, 0.04582740f, 0.04904408f, 0.08119241f, 0.02585569f, -0.00584820f, 
    -0.07145234f, -0.05569709f, 0.04533281f, -0.12127333f, -0.06141434f, -0.02416957f, -0.04689068f, -0.04969548f, 
    0.03740641f, 0.04844843f, -0.06842437f, 0.07922663f, -0.03844825f, 0.00172243f, 0.03914861f, 0.01421739f, 
    -0.03060678f, -0.10780525f, 0.04595866f, 0.03034810f, -0.07941348f, -0.02355216f, -0.07775502f, 0.08680189f, 
    -0.00375002f, 0.09587077f, -0.06622127f, 0.06728626f, 0.02249922f, -0.01548738f, -0.01637914f, -0.01832905f, 
    -0.01739236f, 0.02062257f, -0.03293530f, -0.01478601f, -0.02232158f, -0.01878018f, -0.08471979f, 0.04058547f, 
    0.05379026f, -0.01530441f, 0.00188764f, 0.01333796f, 0.01143845f, -0.03087968f, 0.02438030f, 0.08361857f, 
    -0.05957599f, 0.07791755f, -0.08146942f, 0.02896215f, 0.03155306f, 0.03736766f, 0.02867207f, 0.04906410f, 
    -0.04355600f, -0.03458941f, -0.02989891f, 0.03560512f, 0.02866226f, -0.00785752f, -0.06343575f, -0.07581771f, 
    -0.09723582f, -0.09324647f, -0.03773165f, -0.07638395f, -0.08283198f, -0.07545561f, 0.02614960f, -0.07727472f, 
    0.00995624f, -0.06642214f, -0.03461756f, 0.08407810f, 0.06204644f, -0.04613699f, 0.08127657f, 0.04997539f, 
    -0.02452485f, -0.03518559f, -0.00839922f, 0.06435010f, -0.04044273f, -0.02212545f, -0.00959744f, -0.06397354f, 
    0.05701528f, -0.05461019f, 0.02283083f, -0.00141374f, -0.06856528f, 0.02302586f, -0.10636561f, 0.06880597f, 
    0.02605493f, -0.00341583f, 0.01252478f, -0.08315942f, 0.05311308f, -0.02895972f, -0.08024708f, 0.01365232f, 
    -0.07426380f, -0.02228696f, -0.05944789f, 0.06056670f, -0.00284075f, 0.06593526f, -0.03213095f, -0.06242603f, 
    -0.06357712f, -0.05553365f, -0.06272387f, 0.04543211f, 0.04505749f, 0.01426214f, 0.02730037f, -0.00457657f, 
    -0.01055614f, -0.03823067f, 0.04110028f, -0.06360587f, -0.03043980f, -0.01913133f, 0.02768359f, -0.04873179f, 
    0.04788450f, 0.02359235f, 0.02915185f, 0.01451412f, 0.00266673f, 0.00049658f, 0.05685284f, 0.05353727f, 
    -0.09409650f, -0.32656622f, 0.19823539f, 0.37470233f, 0.02903218f, 0.08279286f, 0.24001808f, -0.21904302f, 
    -0.03195528f, -0.34669963f, -0.10700502f, -0.28180853f, 0.03274136f, 0.11356850f, 0.09929570f, 0.14428672f, 
    -0.45337802f, 0.11591890f, -0.19729818f, 0.15292735f, 0.41546980f, -0.24552025f, -0.03779632f, 0.03090337f, 
    -0.00987524f, -0.00815989f, 0.03286090f, -0.19798602f, 0.35421324f, -0.08315843f, 0.10489979f, 0.00228505f, 
    0.09883682f, 0.52465689f, 0.46098307f, 0.31399682f, -0.05616761f, 0.24048479f, -0.52757877f, 0.08250276f, 
    0.02606209f, 0.11321807f, 0.01601087f, 0.17833114f, 0.20962624f, 0.19478287f, -0.02852528f, -0.11932078f, 
    -0.03737427f, 0.08806206f, -0.18288851f, -0.00592318f, 0.09794082f, -0.00478896f, -0.05566782f, 0.21957065f, 
    -0.10646349f, 0.00266251f, -0.12452397f, 0.14182359f, 0.21524368f, 0.05852693f, -0.02900492f, 0.09000629f, 
    -0.28306723f, 0.05931176f, 0.10566558f, -0.33561337f, -0.01282260f, -0.11005066f, 0.00737822f, 0.16265136f, 
    -0.14933865f, 0.31834209f, 0.10450066f, 0.17185442f, 0.05886357f, 0.13297839f, 0.01718983f, -0.28187138f, 
    -0.08818186f, -0.03293687f, -0.14604206f, -0.33809870f, 0.04642132f, 0.25302494f, -0.01022258f, -0.08750182f, 
    0.20458461f, 0.18102328f, 0.13833939f, 0.08260791f, 0.17276795f, 0.26091328f, 0.18809406f, 0.16690005f, 
    0.06268433f, -0.14586726f, 0.17418440f, -0.26768923f, -0.01440793f, 0.24504362f, -0.07258202f, 0.06968995f, 
    0.26724076f, -0.03095471f, 0.05817799f, 0.00960080f, 0.40398037f, -0.16453938f, 0.23899481f, 0.03437070f, 
    -0.01430223f, -0.12805378f, -0.46014252f, -0.05249352f, 0.22977383f, 0.12732047f, 0.07783812f, 0.15016074f, 
    0.33946022f, -0.23599076f, -0.02189481f, -0.06999157f, 0.07246483f, 0.01682380f, -0.03340794f, -0.30411705f, 
    -0.08844227f, -0.02402926f, 0.06018247f, 0.30022937f, -0.08227934f, -0.00407112f, 0.19152902f, 0.06108445f, 
    -0.06410988f, -0.15621072f, 0.36397719f, -0.13397251f, 0.05882433f, -0.11616146f, -0.07183354f, 0.12300292f, 
    -0.35055661f, 0.07988384f, -0.20384668f, 0.06137418f, 0.18926567f, -0.26811865f, -0.05372641f, 0.06364691f, 
    0.08701584f, -0.02966774f, -0.10551117f, -0.12703000f, 0.23528051f, -0.02119727f, 0.11773280f, -0.17507301f, 
    -0.00081949f, 0.12937155f, 0.16028254f, 0.19892268f, 0.19048464f, 0.22233322f, 0.02116704f, -0.10939126f, 
    0.06017356f, 0.15353224f, 0.11283410f, 0.06957034f, 0.34481448f, 0.12999502f, 0.11383431f, 0.04401163f, 
    0.05659037f, 0.02243821f, -0.09316602f, 0.03085547f, -0.15514724f, -0.07402169f, -0.07725923f, 0.36304700f, 
    -0.19475736f, 0.04103547f, -0.04204871f, 0.09090436f, -0.28486273f, 0.11289994f, 0.04852232f, 0.14342715f, 
    -0.14828950f, 0.07559789f, 0.11386485f, -0.37305757f, 0.17299508f, -0.14468835f, 0.13174637f, 0.18993036f, 
    0.23424643f, 0.20598929f, 0.05357670f, 0.05370308f, 0.23472704f, 0.04524223f, -0.03575865f, -0.03933679f, 
    -0.00675728f, 0.26522291f, -0.05973193f, -0.20812602f, -0.14209092f, 0.11050364f, -0.12986305f, 0.00770610f, 
    0.16176619f, 0.06482826f, 0.16975762f, 0.06701020f, -0.24094932f, 0.16153127f, 0.04337774f, 0.01394008f, 
    0.01129291f, -0.02396917f, -0.15513486f, -0.13327459f, 0.05138012f, 0.06905449f, -0.01024176f, 0.11581858f, 
    0.09914834f, -0.08555686f, 0.00976840f, -0.05021675f, 0.28947428f, -0.03729945f, 0.06211444f, 0.05034499f, 
    -0.03744005f, -0.07544491f, -0.17255278f, 0.05980192f, 0.11897791f, 0.20233233f, 0.33822837f, 0.05945218f, 
    0.10216552f, -0.35258153f, -0.19609658f, -0.01650734f, 0.21098061f, -0.12843841f, 0.04152893f, -0.08943620f, 
    -0.11492942f, -0.10082289f, 0.17788026f, 0.13136870f, -0.44575566f, -0.00657422f, 0.08418357f, -0.44193223f, 
    0.21100099f, -0.09747700f, -0.29018101f, -0.00858917f, -0.02200868f, 0.17994931f, -0.18827538f, 0.16707134f, 
    -0.33561859f, -0.09303304f, 0.19792689f, -0.00629381f, 0.10833085f, -0.19000056f, -0.09698763f, 0.03816884f, 
    0.25690210f, 0.05783028f, 0.00480917f, -0.15806051f, 0.20072921f, -0.02015078f, 0.18521816f, 0.26298517f, 
    -0.12977049f, 0.11998900f, 0.06624627f, -0.14876513f, -0.12129825f, 0.09483462f, -0.50872624f, -0.16393477f, 
    -0.16633430f, 0.29936525f, 0.00228789f, -0.11178697f, 0.01930258f, 0.13458833f, -0.02892103f, 0.23022404f, 
    -0.25863779f, 0.14366557f, -0.10812087f, -0.03255409f, 0.01366944f, 0.08967042f, 0.15005475f, 0.04305765f, 
    -0.12387862f, 0.10426827f, 0.01434331f, 0.04923465f, 0.11790173f, 0.11532193f, -0.03613825f, -0.06420261f, 
    -0.06399389f, -0.01828282f, -0.00722136f, -0.40848106f, 0.13420390f, 0.05703763f, -0.02040589f, -0.08898441f, 
    -0.26727298f, 0.06928000f, -0.03316184f, 0.18003768f, 0.05883052f, 0.02334329f, -0.05470644f, -0.26115176f, 
    -0.08378082f, 0.05823781f, -0.04372527f, -0.07409511f, 0.15620284f, -0.16040592f, -0.04564568f, 0.13458931f, 
    0.04367520f, 0.07941988f, 0.08103384f, 0.11263245f, -0.02388242f, 0.10959429f, -0.01612627f, 0.12155475f, 
    0.16344635f, -0.01949215f, -0.14278266f, -0.09622555f, -0.01490107f, 0.13119937f, -0.02039831f, 0.17983432f, 
    0.10480665f, -0.11279019f, -0.05125450f, -0.07204322f, 0.01940507f, -0.05823573f, -0.13546963f, -0.08757536f, 
    -0.02158476f, 0.00739616f, -0.01831725f, 0.11423651f, 0.23616429f, 0.13579780f, 0.30718061f, -0.01400838f, 
    -0.06444392f, 0.01978826f, 0.15356968f, 0.04490310f, -0.11567056f, 0.15713075f, 0.02449866f, -0.34735402f, 
    -0.09873088f, 0.00490917f, 0.10789273f, -0.11175322f, -0.63346934f, 0.15827383f, 0.09702829f, -0.08147415f, 
    0.07209206f, -0.14770404f, 0.04905123f, -0.10192769f, 0.03715393f, -0.08886502f, -0.11470239f, 0.12205484f, 
    -0.57254809f, 0.01779216f, 0.02238066f, 0.15450142f, -0.37654957f, -0.30096215f, 0.04368895f, 0.07828265f, 
    -0.09501611f, -0.07972438f, 0.21655130f, -0.23388471f, -0.14065112f, -0.04123833f, 0.04350670f, 0.19378346f, 
    -0.06492812f, -0.14986530f, -0.03366940f, -0.62681121f, 0.04535505f, 0.04809149f, -0.05565538f, -0.08924244f, 
    -0.01144829f, 0.12929872f, -0.00010026f, -0.14826661f, 0.15443252f, -0.04914504f, 0.06909573f, 0.23804274f, 
    -0.11843033f, 0.02907473f, 0.19200900f, -0.01830790f, -0.07448908f, -0.01623164f, 0.01982107f, 0.17836957f, 
    -0.04569896f, 0.23565748f, 0.05746818f, 0.08864921f, -0.13907355f, 0.22191685f, 0.01761214f, -0.23170662f, 
    -0.42482114f, 0.14905621f, -0.03908440f, -0.45869192f, 0.06108674f, -0.09250816f, -0.09185543f, -0.05059423f, 
    0.07099652f, -0.15296187f, 0.22271563f, 0.08619034f, 0.07981017f, 0.18084335f, 0.05901115f, 0.01579958f, 
    0.08760768f, 0.14243531f, -0.12038036f, -0.23316406f, 0.04868263f, -0.25919661f, 0.03713101f, 0.30548158f, 
    0.15361759f, 0.08733448f, 0.10160954f, 0.00628710f, -0.07673684f, 0.05550824f, -0.04891409f, 0.24135743f, 
    0.25342819f, 0.11278582f, -0.07382920f, 0.16369061f, -0.11185607f, 0.05282473f, -0.05133725f, 0.16976106f, 
    0.10989819f, -0.44190657f, 0.05587592f, 0.05591043f, 0.01784631f, 0.09407868f, -0.22496526f, -0.04551303f, 
    -0.05218511f, 0.18663993f, 0.25645766f, 0.33777311f, 0.03771365f, 0.30914778f, 0.31551924f, -0.13176902f, 
    -0.00705999f, -0.07785168f, 0.11216306f, 0.13501811f, 0.08361641f, -0.25571936f, 0.14398874f, -0.08765361f, 
    -0.05423469f, 0.03720403f, -0.01374978f, -0.15497804f, 0.25864443f, 0.18178049f, -0.00614547f, 0.54692948f, 
    0.07941260f, 0.17891037f, 0.02625520f, 0.04032075f, -0.07093960f, -0.02636223f, -0.12169980f, -0.05293614f, 
    0.04226351f, 0.03494783f, 0.02532825f, -0.09291884f, -0.28658876f, -0.15871666f, 0.08949619f, -0.02387237f, 
    -0.12260461f, 0.05969795f, -0.07455742f, -0.02763178f, 0.07454168f, 0.00293511f, 0.03826886f, 0.10007112f, 
    0.19025274f, -0.23649144f, -0.33205289f, -0.18399699f, 0.31104898f, -0.03103717f, 0.03588359f, 0.11383606f, 
    0.25098184f, 0.05800402f, 0.14134093f, -0.20772001f, 0.06196193f, -0.11837240f, 0.10810117f, 0.15598306f, 
    -0.18056522f, 0.01992803f, 0.08718922f, 0.04618141f, -0.06338028f, -0.05295469f, 0.22209518f, 0.04615324f, 
    0.01168951f, 0.19709843f, 0.12652580f, 0.11386877f, -0.01018236f, 0.23180343f, 0.05086235f, -0.01828434f, 
    -0.04290056f, 0.05346824f, 0.10487615f, 0.09339348f, 0.13646622f, 0.24550243f, -0.04316112f, 0.14066301f, 
    -0.07189906f, -0.16491471f, 0.04488964f, 0.09893852f, -0.01490871f, 0.09633030f, -0.05157510f, 0.17611352f, 
    0.02658812f, 0.02279594f, 0.05824095f, -0.03898104f, 0.08411124f, -0.26297322f, -0.08346491f, 0.27885219f, 
    0.01345860f, 0.03445649f, -0.07018548f, -0.09974133f, -0.02856962f, -0.17359577f, 0.04706062f, 0.19614254f, 
    0.34798577f, 0.36079887f, -0.03509026f, 0.46779755f, -0.08473219f, -0.03858887f, 0.03865190f, -0.00343266f, 
    0.00484000f, 0.05676343f, -0.00226881f, 0.06006493f, -0.06600983f, 0.00565504f, -0.09466225f, -0.01002342f, 
    -0.08920398f, 0.19988935f, 0.29856884f, 0.32043794f, -0.02458580f, 0.20525041f, -0.07545066f, -0.12421624f, 
    0.08827355f, 0.08725088f, 0.07673910f, 0.03847089f, 0.17868115f, -0.09769810f, -0.09826042f, 0.22716500f, 
    -0.25916550f, 0.06074194f, 0.28972983f, 0.02192828f, -0.06948424f, -0.19813456f, 0.11968287f, 0.07275274f, 
    -0.04484988f, 0.07553004f, 0.07095221f, 0.09624926f, -0.02313290f, 0.25708762f, -0.14788370f, 0.13316113f, 
    -0.19904852f, -0.04858174f, 0.10802767f, 0.18492208f, 0.09108302f, -0.00121619f, -0.02283690f, 0.05958985f, 
    -0.03584168f, 0.03291651f, 0.08548754f, 0.07272895f, 0.33905143f, -0.07336036f, 0.08944251f, -0.07592033f, 
    0.14049570f, 0.23673594f, 0.05459048f, 0.20896976f, -0.36856613f, -0.24046867f, 0.01820744f, 0.20885798f, 
    -0.45679361f, -0.08330469f, -0.54869515f, -0.39840290f, -0.40184495f, -0.04275210f, -0.08842937f, -0.09478187f, 
    0.31238660f, -0.16316557f, 0.01318702f, 0.03675148f, 0.13834241f, -0.00959044f, 0.17370506f, -0.02826943f, 
    0.28318620f, -0.04124359f, -0.06867793f, 0.12582090f, -0.20387201f, -0.14905879f, 0.08827413f, 0.29750544f, 
    0.15864615f, 0.01111904f, 0.08433820f, -0.26036215f, 0.03987080f, -0.34638259f, -0.05552883f, -0.01285175f, 
    0.32227886f, 0.22187884f, 0.18961911f, 0.06747375f, 0.05830463f, 0.02774348f, -0.01196855f, -0.10904881f, 
    -0.06510717f, 0.13835002f, -0.07078846f, 0.06726911f, 0.03997121f, 0.24951041f, 0.10010209f, -0.17341147f, 
    0.04205108f, 0.10330756f, -0.17349520f, 0.02120813f, 0.10115744f, 0.11504822f, 0.18253371f, -0.37179339f, 
    0.01892610f, -0.00053896f, -0.03144119f, -0.26850775f, 0.16626157f, -0.05130996f, 0.03324606f, 0.06193850f, 
    -0.03683692f, -0.51548594f, 0.01941369f, -0.00952920f, 0.31103745f, -0.00954481f, 0.15395072f, -0.04271856f, 
    -0.05453672f, -0.11274337f, -0.05749713f, -0.26170003f, 0.25261512f, 0.00627797f, -0.17305253f, 0.26228806f, 
    0.24216984f, 0.09821439f, 0.01836690f, 0.08175893f, -0.21466333f, -0.09715740f, 0.13304985f, -0.01174346f, 
    -0.08833726f, 0.06927335f, -0.07508461f, -0.04406748f, -0.03211697f, -0.02165587f, -0.08424690f, -0.00862943f, 
    0.04847805f, -0.05469230f, -0.06494318f, 0.06346655f, -0.00119994f, -0.01028562f, -0.01163763f, -0.01061191f, 
    -0.04279498f, -0.04158534f, -0.07381929f, -0.00510219f, -0.07125366f, -0.04392142f, -0.04483407f, 0.00652745f, 
    0.06707589f, 0.04452877f, 0.03243647f, 0.01524368f, -0.00440638f, 0.04485004f, 0.05900992f, -0.02223686f, 
    -0.03299310f, -0.03332839f, -0.05152315f, -0.02982241f, -0.03937326f, -0.08131085f, 0.06353416f, 0.06069624f, 
    -0.00426053f, 0.04173656f, 0.02682044f, 0.05414993f, -0.06906704f, -0.03305290f, -0.01224763f, -0.08510169f, 
    -0.00654550f, 0.05983446f, -0.00887720f, 0.00240812f, -0.05580650f, 0.06098012f, -0.07126307f, -0.06049112f, 
    -0.06145424f, -0.08107065f, 0.06411179f, -0.03455089f, 0.01522086f, -0.03176825f, -0.07035467f, 0.03404289f, 
    0.06096381f, -0.07420026f, 0.01989531f, 0.04813321f, 0.01033887f, 0.07912174f, -0.02858737f, -0.08836010f, 
    -0.00145733f, -0.00462749f, -0.07677074f, 0.06099880f, 0.06969502f, -0.07769112f, -0.04392331f, 0.03480230f, 
    -0.06630567f, -0.00099400f, -0.00785935f, -0.03121123f, -0.03626471f, 0.07573652f, -0.05326301f, 0.03735654f, 
    -0.09316783f, 0.05304919f, 0.03868100f, -0.03926228f, 0.08291791f, 0.06094638f, -0.01491375f, -0.04578992f, 
    -0.09220663f, -0.04871888f, -0.02585074f, -0.02131861f, -0.07097674f, -0.01476573f, 0.05821345f, -0.01758801f, 
    0.04452914f, 0.06473025f, -0.04934588f, 0.08330040f, -0.03428882f, -0.06994562f, 0.01853579f, 0.06902537f, 
    0.01175416f, -0.07804654f, -0.07971109f, 0.03981081f, 0.02294043f, -0.01150578f, -0.05614073f, -0.05596618f, 
    0.01585696f, -0.04872481f, 0.03548722f, 0.01680842f, 0.02352676f, 0.06182087f, -0.06952428f, 0.05267084f, 
    -0.00687719f, 0.05375173f, 0.00121707f, -0.06408561f, 0.06836147f, -0.01760137f, 0.07239620f, 0.00193606f, 
    -0.09285600f, 0.01091660f, -0.01340594f, 0.05845592f, 0.00971412f, 0.05294878f, 0.05944424f, -0.05694563f, 
    0.06640385f, 0.07578206f, 0.06371518f, -0.01493398f, 0.08593258f, -0.10071260f, -0.03045118f, -0.01867020f, 
    -0.00469473f, 0.05787401f, -0.04097260f, 0.03947511f, -0.02026224f, -0.07412159f, -0.04471847f, -0.05124892f, 
    0.04400918f, -0.05909256f, 0.00463610f, 0.06124907f, -0.00072339f, -0.06968299f, 0.02983420f, -0.03482765f, 
    -0.03803609f, -0.03680083f, -0.07679708f, -0.04128347f, -0.04482859f, 0.01680318f, 0.03293314f, -0.09958852f, 
    0.01961495f, 0.01609588f, -0.05822377f, -0.00477353f, -0.09312833f, 0.08476413f, 0.01843183f, -0.01705764f, 
    -0.10408406f, -0.06697522f, 0.04190848f, 0.02431255f, 0.07795323f, 0.03215048f, -0.01164183f, 0.01234795f, 
    -0.04740141f, 0.00883269f, -0.03579771f, 0.05353464f, 0.00113130f, 0.04099083f, 0.05760381f, -0.04760281f, 
    -0.04410081f, -0.08194754f, -0.11160453f, -0.04838677f, -0.03555823f, 0.05188117f, 0.06177535f, -0.09404790f, 
    -0.04689485f, -0.02934293f, -0.00844582f, 0.01100439f, 0.05486421f, 0.03631715f, 0.01145347f, 0.01085165f, 
    -0.00030765f, -0.01968254f, 0.04378717f, -0.04576038f, -0.01608057f, 0.03995552f, 0.01346084f, -0.09172339f, 
    -0.08626072f, -0.05757173f, -0.05133551f, -0.00197610f, -0.06630915f, 0.07043308f, 0.07338418f, 0.02838662f, 
    0.06620779f, -0.06163093f, -0.00805899f, -0.04237702f, 0.02581139f, -0.04872413f, -0.10391933f, 0.02424850f, 
    0.00263419f, -0.02205819f, -0.01562384f, -0.00297245f, -0.08558370f, -0.03614191f, -0.04782885f, 0.03349522f, 
    0.03774500f, 0.00307156f, 0.01606230f, -0.07157739f, -0.04922721f, -0.03235323f, -0.06387766f, 0.06237957f, 
    -0.01588612f, -0.17730455f, 0.19552751f, -0.17997399f, -0.62733388f, 0.17824718f, -0.24813050f, -0.39772031f, 
    -0.20780584f, -0.07745456f, -0.28969267f, -0.10483110f, 0.01561905f, 0.21490756f, -0.17133066f, 0.09966069f, 
    -0.50510919f, 0.05332123f, -0.35537654f, 0.00138178f, 0.20992327f, -0.25963655f, -0.06320967f, -0.06542189f, 
    0.06454907f, -0.05413466f, 0.18980585f, -0.15203986f, 0.01009975f, -0.06312574f, 0.10424713f, 0.29401639f, 
    0.12794593f, 0.30350488f, 0.32444787f, -0.06908035f, -0.23584716f, -0.19755916f, -0.21284653f, -0.09653261f, 
    0.01250374f, -0.09987059f, 0.10459340f, -0.17035095f, -0.02057112f, 0.07060450f, -0.00865621f, 0.12453464f, 
    0.06182042f, -0.02174298f, 0.12016956f, -0.00467697f, 0.12000773f, 0.06998353f, 0.18028276f, -0.38272876f, 
    0.00687148f, 0.04956989f, -0.09111457f, -0.13917066f, 0.32236606f, 0.26133201f, -0.14655702f, 0.06903376f, 
    -0.07655866f, 0.10275432f, -0.07507034f, -0.35653263f, 0.06057374f, 0.18920781f, 0.13077915f, -0.15157151f, 
    -0.51116306f, -0.02580210f, 0.07188857f, 0.18500511f, -0.17706718f, 0.14599743f, 0.04603871f, -0.22884460f, 
    0.06961066f, -0.13839413f, -0.47345579f, -0.16845377f, 0.10207781f, 0.01042030f, 0.13589026f, 0.31271890f, 
    0.14348079f, 0.05544078f, -0.03171126f, 0.02641523f, 0.04123147f, -0.03819790f, -0.03552098f, -0.13996941f, 
    0.16913117f, 0.07649405f, -0.46818542f, -0.10145827f, -0.02862786f, 0.00874115f, -0.00893277f, -0.08489095f, 
    0.00357573f, -0.49898154f, -0.05739725f, -0.04169790f, 0.04416258f, 0.01997554f, -0.19378631f, 0.24842209f, 
    0.07448368f, 0.18079774f, 0.02633188f, 0.35303211f, 0.05590040f, -0.02002911f, -0.08590179f, 0.23400216f, 
    -0.04417731f, 0.15069814f, 0.17926276f, 0.04537398f, -0.18838149f, 0.36676139f, -0.15126650f, -0.08216006f, 
    0.05015212f, -0.00580699f, -0.07816997f, -0.26542303f, -0.02625158f, 0.14872080f, -0.08007662f, 0.05579471f, 
    -0.02157004f, 0.16209546f, -0.08227073f, 0.14231817f, -0.03824170f, -0.06388815f, 0.25274172f, -0.15472840f, 
    -0.04602231f, 0.04921885f, -0.13279672f, 0.03661550f, -0.24079007f, -0.02187264f, -0.05975361f, -0.03203988f, 
    0.01873104f, 0.04117567f, 0.13219002f, 0.13338582f, -0.19151652f, -0.04197133f, -0.00480720f, 0.00628873f, 
    0.08455147f, -0.13334940f, -0.13228354f, -0.24266982f, -0.09993023f, -0.10266535f, 0.11806831f, 0.07655038f, 
    0.14604956f, -0.27787676f, 0.10220090f, 0.17712021f, -0.01664676f, -0.71480536f, 0.03277931f, -0.03773525f, 
    0.07764047f, 0.20977964f, 0.06186677f, 0.03346050f, 0.24788299f, 0.04459171f, 0.00602094f, 0.00432926f, 
    0.24693006f, 0.06619451f, -0.00525898f, 0.09365103f, -0.06458117f, -0.03404693f, -0.00193120f, 0.17150846f, 
    0.14268963f, -0.09711696f, 0.15315677f, -0.12738085f, 0.07313158f, -0.31916964f, -0.01651750f, 0.24547802f, 
    -0.15634499f, -0.06695651f, 0.03156199f, -0.00302539f, 0.09160044f, -0.16738406f, -0.04487396f, 0.08506732f, 
    -0.05727336f, -0.10616649f, 0.10880444f, 0.09812739f, 0.06399828f, -0.09156037f, 0.14330381f, -0.21219593f, 
    0.08323537f, 0.13920984f, 0.22876485f, 0.07950697f, 0.23806076f, -0.15806980f, -0.17924426f, 0.01813166f, 
    0.06349796f, 0.23817766f, -0.26645371f, 0.24564929f, 0.11856946f, -0.31579047f, -0.00135208f, -0.42592761f, 
    0.10684936f, 0.17066826f, -0.02136381f, -0.10662506f, 0.26235819f, 0.17010945f, 0.04083721f, 0.06534380f, 
    0.07091260f, 0.14439411f, 0.15701950f, -0.02196133f, 0.03521549f, -0.15560225f, -0.62150759f, -0.06364380f, 
    -0.43911371f, 0.14308904f, -0.09590007f, 0.05468936f, 0.17430456f, -0.21008091f, 0.11563696f, 0.09593838f, 
    0.02911208f, -0.09389094f, -0.02552936f, -0.01434750f, -0.00076818f, -0.04668807f, 0.01072809f, 0.07595808f, 
    -0.07166684f, -0.05379503f, 0.05820500f, -0.06130168f, -0.01119015f, 0.06585440f, -0.08643221f, -0.03036079f, 
    0.08685262f, -0.02617597f, 0.02265601f, 0.02882214f, -0.03724371f, 0.05284284f, 0.04306059f, -0.05774193f, 
    0.05716918f, -0.01066867f, -0.02573939f, -0.04987891f, 0.01782285f, -0.03486221f, 0.00369829f, -0.05469185f, 
    -0.02627700f, -0.06897464f, 0.02588708f, 0.02446772f, 0.02097174f, -0.09077832f, 0.01741338f, -0.03643880f, 
    -0.06825896f, -0.07602936f, -0.06223318f, 0.03902176f, -0.03102112f, -0.00924570f, -0.09495694f, 0.00221779f, 
    0.09274758f, -0.06423916f, 0.03994559f, 0.07326388f, 0.01402461f, -0.04631612f, -0.00009555f, 0.03626424f, 
    -0.08892862f, -0.03297268f, 0.07011519f, -0.04887954f, 0.05018479f, -0.00897284f, 0.01639166f, -0.02819089f, 
    -0.07876944f, -0.07248426f, -0.08076667f, -0.05055745f, -0.03348695f, -0.03059063f, 0.02466386f, -0.08286323f, 
    0.01729752f, 0.06154018f, 0.06595124f, 0.05816421f, -0.03417851f, 0.04532354f, -0.00630153f, 0.02174334f, 
    0.01656669f, -0.02393558f, 0.02502378f, 0.05688447f, -0.01566061f, -0.11052216f, -0.08413695f, -0.00597657f, 
    0.02416079f, -0.09644040f, -0.06530172f, -0.01400643f, 0.02555646f, -0.07685110f, 0.05628651f, -0.06285189f, 
    0.07109947f, 0.00941379f, 0.05686592f, -0.02316071f, -0.10733610f, -0.09443804f, -0.06527086f, 0.07398250f, 
    0.02291609f, -0.01589346f, 0.03025340f, -0.00215670f, -0.09073491f, -0.01921244f, 0.02226759f, 0.03303407f, 
    -0.02591419f, -0.06800088f, 0.06098882f, -0.06505305f, -0.07573604f, -0.08564862f, 0.00588768f, -0.05510126f, 
    -0.01562754f, -0.01655548f, -0.09203932f, -0.04506092f, -0.06600376f, -0.01360337f, -0.01354688f, 0.00094337f, 
    -0.22092578f, -0.20905453f, 0.20701472f, 0.05093364f, -0.58065981f, 0.01948711f, -0.07174338f, 0.05431889f, 
    -0.19640703f, -0.15670691f, -0.13553514f, -0.21209949f, -0.00395752f, 0.09769309f, 0.24472249f, 0.06674210f, 
    0.00465213f, -0.03275451f, -0.10336758f, 0.16768417f, 0.47623554f, 0.01957775f, -0.03631473f, -0.07309247f, 
    0.22238730f, 0.06423851f, 0.03654068f, -0.17457066f, 0.14223099f, 0.01115830f, 0.05382861f, 0.01235236f, 
    0.16774952f, 0.40773219f, 0.55202419f, -0.00609622f, -0.08018798f, 0.04454391f, -0.03834696f, 0.05656202f, 
    0.10499375f, 0.00705362f, -0.01424200f, 0.04972293f, 0.07481579f, 0.31609017f, -0.05864516f, -0.32973373f, 
    0.32489932f, 0.08823435f, -0.19581945f, 0.04136879f, -0.00479496f, -0.05761306f, 0.15695062f, -0.11486988f, 
    0.08377203f, -0.17511259f, -0.23086204f, 0.03537170f, 0.31550473f, 0.13657163f, -0.06106373f, 0.23776479f, 
    -0.09654823f, -0.07317922f, -0.02907211f, -0.39877748f, 0.11739755f, 0.10343894f, 0.05096151f, 0.00989411f, 
    -0.12485929f, 0.13792400f, -0.03179382f, 0.15204544f, 0.19698080f, 0.31965336f, 0.00454873f, -0.29890803f, 
    0.00957561f, 0.04680005f, -0.45366427f, -0.23648170f, -0.02180370f, 0.34839880f, 0.08896610f, -0.15833451f, 
    0.27417591f, 0.24486300f, 0.25196069f, 0.02013792f, 0.24538131f, 0.15350312f, 0.07960606f, 0.07630382f, 
    -0.00322169f, 0.12475972f, 0.26857767f, 0.02465580f, -0.07416109f, -0.00407752f, -0.10171227f, 0.16672018f, 
    0.07108998f, -0.72280800f, -0.02696562f, 0.02959299f, 0.30279189f, -0.18617377f, -0.24184711f, 0.41581354f, 
    -0.07980993f, 0.01978976f, -0.05428363f, 0.20109624f, -0.03053888f, -0.00027508f, -0.00764690f, 0.31015801f, 
    -0.14485544f, 0.06620863f, -0.11443608f, 0.15640752f, 0.01295195f, -0.22579154f, -0.05131046f, 0.10725830f, 
    0.24872135f, 0.15483098f, 0.09078231f, -0.13220809f, 0.34921733f, 0.05363812f, -0.24072425f, 0.21857604f, 
    -0.14155672f, 0.08676202f, 0.06658945f, -0.09708003f, 0.04090523f, 0.09932147f, 0.21518646f, -0.23381792f, 
    0.34545758f, -0.00864282f, -0.38313437f, -0.18064471f, -0.02967048f, 0.00785721f, 0.04494800f, 0.03729067f, 
    -0.58306932f, 0.04705220f, 0.03144413f, -0.06417779f, -0.34930509f, -0.02784989f, -0.06640080f, -0.27091339f, 
    0.47260451f, -0.05611484f, -0.00632676f, -0.14360707f, -0.04395087f, -0.06099164f, 0.02856224f, 0.29061052f, 
    0.13318793f, -0.02175412f, 0.29708466f, 0.05323296f, -0.20916218f, -0.24520686f, 0.11602104f, -0.09343120f, 
    0.20093231f, 0.00052533f, -0.22302417f, 0.09568586f, -0.05548723f, 0.01404239f, 0.06730337f, -0.16726169f, 
    0.11018864f, 0.00847160f, -0.09142717f, 0.20500803f, -0.11170168f, 0.10587698f, -0.13421631f, 0.34712493f, 
    -0.19416606f, -0.23382102f, 0.25344905f, 0.36730576f, 0.20963843f, 0.28538963f, -0.02205217f, 0.11013934f, 
    -0.13321142f, -0.03425443f, -0.11054887f, 0.12606125f, 0.05494334f, 0.07501855f, 0.04519992f, 0.02302910f, 
    -0.05451367f, 0.04753538f, -0.17381421f, -0.03811873f, -0.16251890f, -0.02488157f, -0.12759572f, 0.03007893f, 
    0.01043561f, 0.07851698f, -0.19610424f, -0.27884117f, 0.16923317f, -0.23108095f, 0.09650929f, 0.03457215f, 
    0.21597520f, 0.20971082f, -0.37985939f, 0.19377658f, -0.06569944f, -0.02352242f, -0.05845725f, -0.02705974f, 
    -0.01640599f, 0.37472829f, 0.05336519f, -0.00179836f, 0.15652490f, 0.12907426f, -0.15950213f, 0.22884847f, 
    0.01163965f, 0.10720209f, 0.14724743f, 0.30123284f, -0.03394616f, 0.06802588f, -0.19116282f, 0.13826750f, 
    0.07847532f, -0.02460351f, -0.25242031f, -0.02733833f, -0.12787844f, -0.01858192f, -0.03162351f, 0.12795331f, 
    -0.16255134f, -0.01447453f, -0.00439516f, 0.48316786f, -0.09270000f, 0.01522350f, 0.31632510f, 0.22224490f, 
    0.22635075f, -0.20045698f, 0.34906524f, -0.01220033f, 0.08567763f, -0.24206765f, 0.11766951f, -0.23515864f, 
    -0.09063467f, 0.09054095f, -0.10628229f, -0.05325054f, -0.15222318f, -0.29375127f, 0.06422310f, -0.06667783f, 
    -0.25436532f, 0.09303799f, -0.27474126f, -0.14965898f, 0.07436626f, 0.02054548f, 0.18872236f, -0.12035155f, 
    -0.05172682f, -0.05498194f, -0.13850465f, -0.16636321f, 0.15620619f, 0.07048535f, -0.17486875f, -0.00712987f, 
    -0.05878278f, 0.12075847f, 0.01443096f, -0.10796807f, 0.17483829f, 0.20409885f, 0.13035260f, 0.08718017f, 
    -0.21247703f, 0.18669495f, -0.02838106f, 0.01787138f, -0.14461875f, 0.05555959f, 0.08094667f, 0.46947300f, 
    -0.25603983f, 0.08144911f, -0.02631663f, 0.13377334f, -0.41971585f, 0.01624884f, 0.07727857f, 0.00848701f, 
    -0.34911197f, 0.08746944f, 0.15213424f, 0.09225933f, 0.01870215f, -0.17450546f, -0.04256846f, 0.04813934f, 
    -0.13965416f, 0.13561471f, 0.27828965f, 0.04449409f, 0.19542411f, 0.14225027f, 0.03957988f, 0.05584068f, 
    -0.08257867f, 0.13738623f, 0.00321564f, -0.24780616f, -0.15291391f, 0.14587486f, -0.17615235f, 0.15173542f, 
    0.18901388f, -0.11839215f, -0.02160189f, -0.02020995f, -0.16287749f, 0.01593365f, 0.05694092f, 0.12306791f, 
    0.07010636f, 0.02992214f, -0.22002582f, 0.05456932f, 0.03483837f, 0.26181361f, -0.08426424f, -0.07676186f, 
    0.29326123f, 0.18505335f, -0.02089856f, -0.03796606f, 0.34957877f, -0.08827797f, 0.16407207f, -0.03440900f, 
    0.04841041f, -0.11736803f, -0.02852377f, -0.12251285f, 0.24697497f, 0.29923806f, 0.20586781f, -0.09628541f, 
    0.08251058f, -0.40003392f, 0.02248791f, -0.12235221f, 0.18379413f, 0.07308961f, 0.01928589f, 0.09747075f, 
    0.04158037f, -0.12558314f, 0.06375603f, 0.20256403f, 0.13525289f, -0.04756780f, 0.14646310f, 0.35136330f, 
    -0.05273577f, 0.00273880f, 0.04573456f, -0.20809712f, 0.05488663f, -0.07176746f, -0.03675824f, 0.57055080f, 
    -0.06304523f, 0.02329519f, 0.37918684f, -0.04459975f, 0.09732789f, -0.16939615f, -0.08088902f, 0.04871878f, 
    0.56356412f, -0.05991729f, -0.08062866f, -0.06603067f, -0.07084676f, -0.04270588f, 0.22451256f, 0.06803097f, 
    -0.00976725f, -0.24456063f, -0.15271154f, 0.00069225f, 0.10423325f, -0.02694992f, -0.15183392f, -0.06335033f, 
    -0.05770332f, -0.09146350f, 0.00083624f, 0.11158196f, -0.10664616f, 0.23467644f, -0.05303037f, -0.07338222f, 
    0.29204795f, 0.10373276f, -0.15439495f, 0.00080749f, 0.02860448f, 0.04370816f, 0.25408778f, 0.13532798f, 
    0.19658743f, -0.11614589f, 0.06620527f, 0.04457892f, 0.41493115f, -0.01051346f, 0.08127619f, 0.08187182f, 
    0.01432255f, 0.03942383f, -0.04805979f, 0.25682747f, 0.00466335f, -0.02783595f, -0.03629293f, 0.09114099f, 
    0.16799548f, 0.05654033f, 0.06191265f, 0.12503088f, -0.00792682f, 0.12963279f, 0.02319722f, 0.33249629f, 
    -0.08241314f, 0.04417805f, -0.13439758f, 0.01962071f, -0.08658864f, -0.04922977f, 0.03480294f, -0.13765652f, 
    0.20776816f, 0.03631509f, 0.28873464f, 0.00407050f, 0.33651248f, 0.30353382f, 0.03834265f, 0.11645105f, 
    -0.07900765f, 0.16198383f, -0.04143371f, 0.15828623f, 0.00596701f, -0.04533131f, 0.04694542f, -0.10046531f, 
    0.02615136f, 0.54408109f, -0.00191502f, -0.02804556f, -0.10504518f, -0.03286550f, -0.07417430f, -0.19557217f, 
    0.00133194f, -0.05244996f, 0.37885153f, 0.00281186f, 0.09728907f, 0.03980911f, 0.03831331f, -0.14602093f, 
    0.19043183f, 0.05962417f, -0.06504588f, 0.31787208f, 0.17376980f, -0.00955452f, -0.09094773f, 0.02796586f, 
    -0.04310674f, 0.03470857f, 0.00585719f, 0.00616107f, -0.01086414f, -0.10752384f, 0.03253498f, -0.04393918f, 
    -0.06701352f, 0.01150506f, 0.05634922f, -0.02464349f, -0.08613766f, 0.00628065f, 0.03994360f, -0.00451727f, 
    -0.04312661f, 0.04682805f, -0.01532826f, -0.09164703f, 0.03069069f, -0.06458419f, 0.02094160f, 0.07289702f, 
    -0.05975638f, 0.03754845f, 0.01450639f, -0.05520232f, -0.07211716f, -0.02965476f, -0.10489331f, 0.03156629f, 
    -0.10551879f, -0.02178920f, -0.04480948f, -0.03635665f, 0.05687020f, -0.01126776f, -0.08609845f, -0.09478889f, 
    -0.02953061f, -0.07143580f, -0.09796467f, -0.08085983f, -0.06777479f, -0.10929258f, -0.03193126f, -0.06156781f, 
    -0.08581574f, -0.05126182f, -0.05082214f, -0.04212271f, 0.01287718f, 0.06157036f, -0.03142617f, -0.05927300f, 
    0.04148703f, 0.06089577f, -0.06772907f, 0.00394604f, 0.00340891f, -0.07931685f, -0.08611891f, 0.02710819f, 
    0.01053029f, 0.05028810f, -0.06596319f, 0.04467661f, -0.09317923f, 0.05606664f, 0.06484916f, 0.02289968f, 
    -0.00179597f, -0.02932660f, -0.09325340f, -0.06504331f, 0.01367373f, 0.00395431f, -0.00702871f, -0.08520994f, 
    -0.01796894f, -0.04988275f, -0.06400029f, -0.04119685f, -0.08718722f, 0.02368982f, -0.09384327f, 0.03570131f, 
    -0.06379402f, -0.08688512f, -0.04991937f, -0.08597135f, -0.06033559f, 0.03238146f, -0.02849627f, 0.06290313f, 
    -0.00481249f, 0.01331770f, -0.01808831f, 0.01496207f, -0.08512304f, -0.01391542f, 0.08020661f, -0.07024048f, 
    -0.00880968f, -0.05796733f, 0.01623266f, -0.03414156f, -0.09759541f, -0.02898819f, -0.06338746f, -0.07939890f, 
    0.02830781f, 0.01532276f, 0.01987915f, 0.01657990f, -0.03166341f, 0.03833263f, -0.08806169f, -0.10793640f, 
    -0.07785101f, 0.05074632f, -0.03644678f, 0.05795253f, -0.03588850f, 0.01971461f, -0.00414743f, -0.02818673f, 
    -0.96348906f, -0.10813597f, 0.10241442f, 0.21097173f, 0.07451745f, -0.03790784f, 0.20179810f, -0.09663048f, 
    0.02689856f, -0.13304533f, 0.14461409f, 0.00181424f, 0.05438873f, -0.13906071f, -0.25593999f, 0.33733177f, 
    0.06759402f, -0.07434212f, -0.05851547f, 0.15196608f, 0.37446639f, 0.14301458f, -0.07304777f, 0.01283427f, 
    0.32711557f, -0.12605354f, -0.15797797f, 0.07871824f, 0.09844222f, 0.06908517f, 0.19532144f, 0.19836630f, 
    -0.26562762f, 0.22138952f, 0.02474171f, 0.26272693f, -0.06514989f, -0.09756014f, 0.09205821f, -0.46342915f, 
    -0.42632899f, -0.06130345f, -0.53398418f, -0.44865638f, -0.16040654f, 0.40173399f, -0.10014620f, -0.06282412f, 
    0.18027717f, 0.16216709f, 0.05890362f, 0.00113571f, 0.05961410f, -0.00960251f, 0.12151008f, -0.09345357f, 
    -0.01672645f, -0.14625059f, 0.12092356f, -0.13401459f, 0.41894254f, 0.07871620f, 0.15364097f, 0.01109874f, 
    0.02451602f, 0.10514089f, -0.23553190f, -0.01616120f, -0.11963610f, -0.00060829f, -0.02913829f, -0.05237344f, 
    0.06261089f, 0.19717473f, 0.10884356f, 0.01893544f, 0.06582779f, 0.19531576f, -0.01007813f, 0.17637247f, 
    -0.05162787f, 0.21006504f, 0.04292816f, -0.01248535f, -0.08999905f, 0.03890246f, 0.13594241f, 0.11673424f, 
    0.19983348f, 0.13968223f, 0.23448613f, 0.16132765f, -0.14968546f, 0.16501781f, 0.09781020f, 0.10011340f, 
    -0.05972584f, 0.03957316f, 0.08423764f, 0.09278949f, 0.00736258f, -0.01266088f, -0.02836863f, 0.14301978f, 
    0.03373739f, -0.44543684f, -0.00089158f, 0.06694595f, -0.00479804f, -0.13322811f, -0.03492966f, -0.03933695f, 
    0.05154268f, 0.02833175f, 0.28323644f, -0.04671241f, 0.10992608f, -0.04701975f, 0.31059763f, 0.01626595f, 
    -0.05702318f, -0.03443486f, -0.00350820f, 0.15850550f, 0.04581787f, 0.24003707f, 0.15863650f, 0.12169463f, 
    -0.28398088f, -0.27108350f, -0.00396357f, 0.26460493f, -0.06220783f, -0.11955456f, 0.02708646f, 0.27215734f, 
    0.08802211f, -0.14490692f, -0.16888431f, -0.22023018f, -0.03977389f, -0.08677122f, 0.11771517f, 0.22163473f, 
    -0.00076897f, 0.08998580f, -0.45992839f, -0.06437351f, 0.15034515f, -0.19435178f, -0.02570813f, 0.08713971f, 
    0.34778857f, -0.04827220f, 0.04885785f, -0.22526567f, -0.13764422f, 0.07729930f, 0.15056677f, -0.05757733f, 
    -0.07742100f, 0.10112825f, 0.09790805f, 0.00454775f, -0.13227516f, 0.02780217f, -0.09149772f, -0.07235995f, 
    0.04076020f, 0.12401137f, 0.02809248f, -0.13414283f, -0.02448809f, 0.11067085f, -0.13861510f, -0.37810534f, 
    0.30163291f, 0.15184128f, 0.03031703f, -0.09832707f, -0.10248532f, 0.02351759f, 0.18657684f, -0.03804868f, 
    -0.13019383f, -0.17226177f, 0.02606190f, 0.00542694f, 0.26142547f, -0.07507452f, 0.11938114f, -0.00170710f, 
    -0.14568885f, 0.05493080f, 0.05301017f, -0.12517895f, -0.04160237f, -0.03946586f, 0.11123746f, -0.07726015f, 
    -0.12303840f, 0.15985979f, -0.03961371f, 0.08258763f, 0.05717782f, -0.01056506f, -0.07032835f, -0.01051386f, 
    0.00371578f, -0.03968027f, -0.04402954f, -0.35052666f, -0.25693452f, 0.11126716f, -0.07868450f, -0.31371891f, 
    0.26759002f, 0.10449889f, 0.22821838f, 0.04611733f, -0.01183319f, 0.24807970f, 0.09380149f, 0.01295822f, 
    -0.17699157f, 0.06340927f, 0.36790493f, -0.02947077f, -0.14520985f, -0.04240436f, 0.09445729f, -0.03628125f, 
    0.14160646f, 0.01442339f, 0.04198873f, 0.06774512f, 0.06258958f, -0.20857197f, -0.05488431f, 0.04929422f, 
    -0.03144748f, -0.05792925f, -0.00421668f, -0.03185122f, -0.08364456f, 0.13230556f, 0.09090091f, 0.08228942f, 
    0.15254988f, -0.22301073f, 0.06926083f, 0.26295507f, -0.10817529f, -0.31417072f, 0.10449027f, 0.09325616f, 
    0.24227095f, 0.29197124f, -0.08891544f, -0.19990632f, 0.50434721f, 0.17454799f, -0.14292830f, 0.00160187f, 
    -0.10322884f, 0.18668683f, 0.12414812f, 0.07876489f, 0.08145675f, 0.10111680f, -0.20424467f, -0.05385471f, 
    -0.00609477f, 0.13982829f, -0.41485238f, 0.06905200f, -0.14497884f, -0.12113586f, -0.05716806f, -0.04382690f, 
    -0.79360294f, 0.03566665f, 0.04815557f, 0.03206943f, -0.37904859f, -0.04806249f, 0.12523480f, -0.17523250f, 
    0.10261375f, -0.07083216f, -0.22913651f, -0.23662142f, 0.02613291f, -0.21134450f, -0.00448351f, 0.02403751f, 
    -0.07688020f, 0.00218034f, -0.01773622f, 0.25147161f, -0.05621786f, -0.03343972f, 0.04578999f, 0.03974956f, 
    0.00447317f, -0.01212840f, -0.03054849f, -0.02498101f, -0.10332057f, -0.04404359f, 0.13427664f, 0.06798863f, 
    0.22230665f, -0.00959072f, -0.06298422f, 0.10551258f, 0.02509059f, 0.21454749f, -0.07379227f, 0.34010693f, 
    -0.12075357f, 0.10927930f, 0.05317441f, 0.19852205f, 0.13263610f, 0.27300692f, 0.01676910f, -0.02877009f, 
    -0.14268544f, -0.03476960f, 0.22063266f, 0.09316537f, 0.05261791f, 0.18663649f, -0.02058314f, 0.15951306f, 
    -0.04227439f, 0.22048384f, -0.14699574f, 0.03194189f, -0.04029641f, -0.07025877f, -0.11320046f, 0.24103238f, 
    0.00416825f, -0.11345163f, 0.04518092f, -0.04794493f, -0.02161909f, -0.38905317f, -0.04122953f, 0.13244064f, 
    0.21134099f, 0.09834946f, -0.01428719f, 0.25110525f, 0.20293124f, -0.14230564f, 0.06204148f, 0.17704365f, 
    0.01245540f, 0.62535495f, -0.06890900f, 0.08643688f, -0.15636547f, 0.10168520f, 0.00001852f, -0.27336821f, 
    -0.07650628f, -0.05727661f, 0.17275713f, 0.05654595f, 0.10813314f, -0.01567809f, 0.05651649f, 0.09893321f, 
    -0.40258110f, -0.02522120f, -0.14983715f, -0.14597659f, 0.13554908f, 0.07128393f, 0.06071027f, 0.17097643f, 
    -0.11038154f, -0.01818981f, 0.09046188f, -0.07341695f, 0.17377242f, 0.13571270f, -0.01102968f, 0.07960679f, 
    0.33746535f, 0.09901264f, 0.17089660f, 0.08003531f, -0.04076655f, 0.08909340f, -0.00398394f, -0.25581136f, 
    -0.17219533f, -0.06240383f, 0.07489993f, -0.10068470f, -0.22532077f, -0.24383844f, 0.03769885f, 0.01951111f, 
    -0.35220796f, 0.00070809f, 0.18155308f, -0.08739306f, -0.09778110f, 0.01147177f, -0.02145495f, -0.12191837f, 
    0.27195123f, -0.04140949f, -0.07834931f, -0.14199114f, 0.02466606f, 0.13683882f, -0.04527513f, 0.03355425f, 
    -0.01229179f, 0.19174448f, 0.00236413f, -0.08533730f, 0.01914708f, -0.17521565f, 0.19724359f, 0.29924762f, 
    -0.06730612f, 0.16198474f, -0.11654775f, -0.01287306f, 0.12382630f, 0.02203851f, 0.06027270f, 0.12785836f, 
    0.02544867f, 0.23661549f, 0.07004580f, 0.10025086f, -0.26178935f, 0.22112665f, 0.06230940f, 0.14466897f, 
    -0.22556296f, -0.16665129f, 0.23310868f, -0.41074851f, 0.00317751f, 0.06144601f, 0.01604449f, 0.11568365f, 
    -0.22201036f, 0.02334850f, 0.13908532f, 0.15936820f, 0.07242866f, 0.14004324f, -0.04195880f, -0.13791427f, 
    0.03176956f, 0.06200911f, 0.06638317f, 0.02969741f, 0.31486750f, 0.00941283f, -0.05592242f, 0.37319961f, 
    0.09309387f, 0.01986329f, -0.24799769f, -0.22188701f, 0.04009555f, -0.36526877f, -0.03560909f, -0.05837566f, 
    0.28338310f, 0.35862023f, -0.33510795f, 0.10896020f, 0.12030547f, 0.07523857f, 0.06280018f, -0.15131746f, 
    0.01652449f, -0.48315725f, -0.02987795f, -0.00051103f, 0.25788733f, 0.13498750f, -0.01721868f, 0.21096592f, 
    -0.02885494f, 0.00414229f, 0.24745174f, -0.01457669f, 0.21198669f, 0.07722285f, -0.31533062f, 0.04605488f, 
    -0.08822864f, -0.14286931f, -0.06552028f, -0.27985346f, 0.05027907f, 0.13409647f, 0.10347164f, 0.19785552f, 
    -0.04726440f, -0.03717436f, 0.02859967f, 0.08793595f, -0.01793148f, -0.05671920f, -0.08316094f, 0.00015962f, 
    -0.00424054f, -0.03962508f, -0.06214106f, 0.00295720f, 0.05016563f, 0.01316805f, -0.02156749f, 0.02010272f, 
    -0.02465308f, -0.07148348f, 0.01381645f, -0.08557088f, 0.06324431f, 0.03654237f, 0.07018446f, -0.01504247f, 
    0.02272476f, 0.01016964f, -0.09933279f, 0.01623210f, -0.01693472f, -0.00288751f, 0.02008437f, -0.04275123f, 
    -0.09813739f, -0.04796182f, 0.02887807f, -0.04266110f, 0.03960989f, 0.01368028f, 0.06348039f, -0.04817385f, 
    0.00763792f, 0.05111119f, 0.02026188f, 0.02780002f, 0.06325342f, 0.04666648f, 0.04494168f, -0.07100153f, 
    0.03975655f, -0.05662953f, -0.03249059f, -0.02168710f, -0.05234839f, -0.01244221f, 0.01770404f, -0.08008568f, 
    0.06233360f, -0.01345010f, -0.04028856f, -0.05879794f, -0.07536639f, 0.05954642f, -0.01590765f, 0.05756539f, 
    0.02019416f, 0.02695566f, 0.01841219f, 0.00612101f, -0.02227709f, 0.06326403f, 0.02234491f, -0.06545700f, 
    0.05938409f, -0.06234398f, -0.08973003f, -0.03564284f, -0.05932032f, 0.05443614f, 0.07575915f, 0.06281260f, 
    0.05439420f, -0.05547964f, 0.05969724f, -0.05064999f, 0.00103885f, 0.02219727f, 0.01241682f, -0.03736483f, 
    -0.00902608f, 0.00000541f, -0.02801529f, 0.01597028f, -0.01975348f, 0.03430128f, -0.05389943f, 0.07645537f, 
    0.01624411f, 0.05262955f, 0.05743276f, -0.04472378f, -0.06252284f, -0.07874254f, 0.08745857f, -0.08049784f, 
    0.03530739f, -0.03961948f, 0.07982357f, -0.02355818f, 0.05316193f, -0.00920530f, -0.07159017f, 0.04911960f, 
    0.04581297f, -0.07870425f, -0.02495273f, 0.01826896f, -0.09056413f, 0.03958026f, 0.05956484f, 0.00892121f, 
    -0.00715227f, -0.04143253f, -0.02339200f, 0.00815535f, -0.03180501f, 0.01878367f, -0.02390923f, 0.03699657f, 
    -0.08121328f, -0.02314080f, 0.04562282f, -0.08154875f, 0.06658308f, -0.10051996f, 0.00075959f, -0.07661943f, 
    -0.08609778f, -0.07929472f, -0.07957716f, -0.02014224f, -0.07716062f, 0.07528328f, -0.03386239f, -0.03388662f, 
    -0.09247047f, -0.03636350f, 0.02619517f, 0.04506412f, -0.00575125f, 0.01574853f, 0.07026969f, -0.03896173f, 
    -0.05447950f, 0.03018177f, 0.04845227f, -0.01110477f, 0.00058271f, -0.00815118f, -0.10516839f, -0.03195384f, 
    -0.05875515f, -0.02371246f, 0.08182146f, -0.08334738f, 0.02467754f, 0.03447469f, 0.04928589f, -0.00820201f, 
    0.00225380f, 0.00984321f, -0.04133721f, 0.00401593f, -0.07881252f, -0.05978015f, 0.06127997f, 0.00154909f, 
    -0.02400728f, 0.04260145f, 0.02061199f, 0.07415268f, -0.02548822f, -0.06149904f, -0.06314711f, 0.06598922f, 
    -0.03849180f, -0.00013855f, -0.03080994f, -0.04398321f, 0.03323704f, 0.01681977f, -0.08264828f, 0.04205175f, 
    0.06111632f, -0.03522167f, -0.03297563f, -0.04293714f, 0.06387965f, -0.05400803f, 0.06410321f, -0.02045338f, 
    -0.02014897f, -0.07822525f, -0.07082123f, 0.04361847f, 0.01232574f, -0.01429181f, -0.07132164f, 0.02592171f, 
    0.01452031f, -0.05951232f, -0.08315580f, 0.04257064f, 0.06279231f, -0.03245204f, -0.10568280f, -0.08444479f, 
    -0.08892454f, -0.03386843f, 0.03154057f, -0.00348505f, -0.02591140f, -0.05620616f, -0.03106677f, 0.03958211f, 
    -0.10991175f, -0.10113661f, 0.00768452f, -0.00876072f, -0.00386517f, -0.08321034f, 0.05479950f, -0.01780807f, 
    -0.04692114f, 0.05975451f, -0.05728573f, 0.01072878f, 0.00328525f, -0.04263100f, 0.00581411f, 0.04450046f, 
    -0.07943547f, -0.06294240f, -0.08447379f, -0.03795274f, 0.02976247f, 0.05309913f, -0.01192192f, -0.07912131f, 
    -0.02418299f, 0.06652975f, -0.10686190f, -0.09224290f, -0.08245699f, 0.02106140f, -0.09608024f, 0.03722434f, 
    0.31721491f, 0.12009576f, 0.13171004f, -0.08138262f, -0.31638455f, 0.12843885f, -0.00883391f, -0.27080086f, 
    -0.01917017f, 0.10949094f, -0.06030189f, 0.07251057f, 0.03128251f, 0.21955091f, -0.04381587f, -0.03017807f, 
    -0.12004480f, -0.05441743f, 0.20075205f, 0.15357891f, -0.29535660f, -0.34442878f, 0.03973108f, -0.00306786f, 
    -0.28507736f, -0.05846303f, -0.05305672f, -0.06327263f, -0.02656484f, -0.01346648f, 0.04072747f, 0.12180244f, 
    -0.00039526f, 0.00619497f, -0.07920239f, -0.18699658f, -0.08844388f, -0.11548714f, -0.33312923f, 0.14503092f, 
    -0.02845144f, 0.19761652f, 0.01980265f, 0.20249464f, 0.02170406f, 0.05603418f, 0.07325782f, 0.22339651f, 
    -0.10564990f, 0.05481247f, -0.07721210f, 0.05641885f, -0.05616967f, 0.06624848f, 0.18076822f, 0.00805469f, 
    0.13208964f, 0.11126105f, 0.01174158f, -0.09632128f, -0.06020751f, 0.06418356f, -0.07036075f, 0.16376114f, 
    -0.18528864f, 0.04599784f, -0.01882410f, -0.09286116f, 0.16960250f, 0.05766932f, -0.11221210f, -0.00219654f, 
    -0.07812805f, 0.00487173f, 0.11256453f, 0.20221341f, 0.09530884f, 0.12873746f, 0.02500287f, -0.03977645f, 
    0.03440557f, 0.23634405f, -0.33512169f, 0.06927443f, 0.07382472f, -0.05253820f, -0.04925444f, 0.14848456f, 
    -0.05415535f, 0.05915986f, -0.02422152f, -0.08598933f, 0.04062681f, -0.16224872f, -0.03377353f, 0.20009860f, 
    0.16787548f, -0.09483527f, -0.22504848f, -0.00608244f, -0.04154667f, 0.02607325f, -0.06999406f, 0.30330110f, 
    -0.08971343f, 0.27186024f, -0.07201478f, 0.04758030f, -0.18407530f, 0.07048889f, -0.16334689f, -0.11890696f, 
    0.06980192f, 0.09580002f, 0.17712787f, -0.03716533f, 0.14120358f, 0.02412911f, 0.14250804f, 0.08466189f, 
    -0.13724452f, 0.06685486f, -0.15086606f, -0.09704611f, -0.07269503f, 0.34649307f, 0.23729968f, -0.37940794f, 
    0.12225623f, 0.17891179f, 0.13768283f, 0.31041041f, -0.47408751f, 0.10526657f, 0.04800667f, -0.16076168f, 
    -0.03760133f, -0.03431384f, -0.13215648f, -0.03501614f, -0.03484367f, -0.16877645f, 0.03596987f, 0.09736156f, 
    0.11904141f, 0.06824237f, 0.35453215f, -0.02218997f, -0.18630125f, -0.49919346f, 0.09351358f, -0.08539896f, 
    0.27020708f, 0.03646685f, -0.26887426f, -0.06790505f, 0.08439789f, -0.03655530f, 0.28286681f, 0.10821914f, 
    -0.25613719f, -0.22504175f, -0.02753796f, 0.17374611f, 0.15671036f, 0.01363595f, -0.62804967f, -0.18487979f, 
    -0.16515432f, 0.28283870f, 0.06409878f, -0.08121969f, 0.12606189f, 0.39158052f, -0.00261030f, 0.09090693f, 
    -0.17775284f, 0.00311669f, -0.03928528f, 0.05588833f, 0.04888549f, 0.01771826f, 0.13741291f, 0.39330941f, 
    -0.19282188f, -0.03242065f, 0.07682282f, 0.05852106f, -0.22405531f, -0.09865040f, 0.18637188f, -0.25297543f, 
    -0.35644537f, 0.12169710f, -0.04780088f, 0.13301225f, 0.07689150f, 0.11104642f, -0.06987447f, -0.04227349f, 
    -0.22034842f, -0.03809113f, 0.22224389f, 0.06399283f, 0.02507209f, 0.13763297f, 0.04763973f, 0.42617771f, 
    -0.03215367f, 0.18984526f, -0.06819873f, -0.07680631f, -0.50666749f, -0.06515112f, -0.11095253f, 0.22599809f, 
    0.07639990f, -0.21388978f, -0.07769561f, -0.06354185f, -0.30926186f, 0.12379698f, 0.19030580f, 0.23111668f, 
    -0.00549458f, -0.25423276f, -0.06620468f, 0.22067559f, 0.01602469f, 0.29501593f, -0.09456917f, 0.45316237f, 
    0.14226560f, 0.37174568f, 0.04214638f, -0.04081588f, -0.29908907f, -0.10634118f, -0.05509366f, -0.37811413f, 
    0.00053935f, 0.05475356f, 0.17754491f, -0.12242799f, 0.02714748f, 0.17086053f, 0.40465432f, -0.03113796f, 
    0.08240230f, -0.20076989f, 0.13015513f, 0.22681817f, 0.08559463f, 0.43730205f, 0.11363825f, -0.00122431f, 
    0.35889152f, 0.15801884f, 0.03217243f, -0.09920410f, 0.19809505f, 0.17009024f, -0.11588637f, -0.37967777f, 
    0.04528034f, 0.28412530f, -0.39044815f, -0.04266415f, 0.03745541f, 0.24040830f, 0.22352229f, -0.27432245f, 
    0.33664933f, 0.13716690f, -0.29049104f, -0.05824915f, -0.26292825f, 0.06321766f, -0.05850472f, 0.01517506f, 
    -0.30955479f, 0.07236745f, -0.10580809f, -0.00620698f, -0.39766338f, -0.08612802f, -0.18712845f, 0.08323989f, 
    0.03426680f, -0.17921388f, 0.17378613f, -0.05055818f, 0.11962706f, -0.03338649f, -0.43516722f, 0.34175357f, 
    0.10243996f, 0.18275468f, 0.25763392f, 0.24982293f, 0.05209782f, -0.03283278f, 0.13235693f, -0.00132702f, 
    -0.04402786f, -0.04554940f, -0.10593403f, -0.03591968f, -0.27208081f, -0.02098204f, -0.50718933f, 0.06362968f, 
    -0.15073684f, 0.09314466f, -0.10627560f, 0.09050447f, 0.74687684f, -0.04919738f, -0.11947431f, -0.30606204f, 
    -0.19980860f, -0.00305066f, 0.06549232f, 0.73789334f, -0.06949868f, 0.44252920f, -0.01695522f, 0.16139691f, 
    -0.13967431f, -0.11994414f, -0.22340748f, -0.03685091f, -0.39666638f, -0.34341010f, 0.07062129f, 0.29362357f, 
    0.03565086f, -0.29282352f, -0.16909826f, 0.28559691f, -0.45318091f, 0.11362054f, 0.01499246f, 0.12505651f, 
    -0.42584565f, -0.38382047f, -0.07587043f, -0.17322978f, 0.09010606f, -0.06477576f, 0.19277053f, 0.26064324f, 
    0.01903515f, -0.28489575f, 0.07375418f, 0.19867927f, -0.28611773f, 0.21398138f, 0.00975702f, -0.05349785f, 
    0.16920210f, 0.68294644f, -0.01131455f, 0.04763808f, -0.56322813f, 0.20718572f, 0.05695707f, -0.21391408f, 
    -0.03408142f, 0.12725911f, -0.01060207f, 0.10458263f, -0.14833248f, -0.04233679f, 0.05256664f, 0.16769443f, 
    -0.14160125f, 0.25068745f, 0.00003390f, -0.44535831f, 0.05063904f, 0.30585691f, -0.22592904f, -0.52441841f, 
    0.26712349f, 0.18317826f, 0.03782097f, -0.21796721f, -0.48403186f, 0.13931884f, -0.14275099f, -0.17606089f, 
    0.12769145f, 0.11623967f, -0.04285168f, -0.05677791f, 0.00520305f, 0.17364843f, 0.06096640f, -0.13884063f, 
    -0.13383859f, 0.08017007f, -0.47672299f, 0.13589287f, -0.22780567f, -0.05303805f, -0.03921991f, -0.08707763f, 
    -0.69572300f, -0.05478095f, 0.21389095f, 0.01741395f, -0.28072485f, 0.04327006f, -0.03562312f, 0.02827636f, 
    0.25574341f, 0.05365813f, 0.13902827f, -0.32334924f, -0.15470321f, -0.18931742f, -0.04674568f, 0.03806607f, 
    0.09648235f, 0.25053608f, 0.12147550f, -0.15170212f, 0.03146200f, -0.22576176f, -0.00339561f, 0.07894101f, 
    -0.01446157f, 0.06637096f, -0.03744046f, 0.01572842f, 0.07574039f, -0.07401166f, 0.08469441f, -0.07417060f, 
    0.19937950f, 0.05655957f, -0.00149864f, 0.01684968f, -0.07868697f, 0.30613893f, -0.01030609f, 0.06578550f, 
    -0.05140496f, 0.04133721f, 0.11596151f, -0.41868746f, 0.23944491f, 0.34849632f, 0.03663217f, 0.02319670f, 
    -0.26606113f, -0.13556233f, 0.03302258f, 0.17590922f, -0.08660381f, 0.14556764f, 0.06790282f, 0.15964602f, 
    0.02009651f, -0.05999606f, -0.09298836f, 0.02698013f, 0.06633723f, -0.11273333f, 0.11282928f, 0.27175543f, 
    -0.01498548f, 0.07653753f, -0.20201495f, 0.00127976f, 0.12279505f, -0.18753514f, 0.06372267f, 0.01375262f, 
    0.24699365f, 0.04435215f, 0.11599396f, 0.19784491f, -0.13545729f, 0.13279958f, -0.00615758f, 0.02462512f, 
    0.03450057f, -0.21468283f, -0.07845891f, -0.08892362f, 0.06304636f, 0.13089864f, -0.04599578f, 0.00667416f, 
    0.04223476f, 0.24277221f, 0.25705707f, 0.29019496f, -0.01008339f, 0.08966251f, -0.29624590f, 0.05128214f, 
    -0.15777448f, 0.18313980f, 0.01005258f, -0.01412729f, -0.25231943f, 0.15231048f, 0.12476465f, 0.04145409f, 
    0.08532958f, 0.11103529f, 0.03503728f, 0.27547726f, -0.03979718f, 0.02102975f, 0.14003144f, -0.02907300f, 
    -0.12877846f, 0.00194352f, 0.25927040f, -0.03298436f, -0.00006575f, -0.17100345f, -0.04049668f, 0.12239385f, 
    0.02881208f, -0.04129252f, -0.12281659f, 0.06628384f, 0.02143616f, -0.31239834f, 0.01185647f, -0.03280294f, 
    -0.15329643f, -0.02491954f, -0.31237811f, 0.09238120f, -0.03228842f, 0.08087916f, 0.19656648f, -0.08810827f, 
    -0.12437690f, 0.12422909f, -0.21617027f, 0.14603098f, 0.09402510f, -0.02437467f, -0.13158265f, -0.02717031f, 
    -0.06391858f, 0.04738098f, -0.03931094f, 0.05820913f, 0.01884771f, 0.37163568f, -0.13123234f, -0.12755990f, 
    -0.06147271f, 0.00367329f, -0.02812876f, -0.00458959f, -0.09629610f, 0.04999512f, 0.25235289f, 0.24869494f, 
    0.01513149f, -0.08751829f, -0.14773329f, -0.05907064f, -0.15089707f, -0.03349247f, 0.19962025f, 0.29274651f, 
    0.04508773f, 0.02208777f, -0.14726456f, 0.18804869f, 0.11354922f, 0.06063171f, 0.02080206f, 0.00216265f, 
    0.08891928f, 0.17860873f, 0.17125694f, -0.01604434f, 0.16873357f, 0.15325482f, -0.07245315f, 0.17659637f, 
    0.00123965f, 0.31309572f, -0.07789283f, -0.21177840f, -0.44413713f, 0.03022938f, 0.00606453f, 0.00161171f, 
    -0.02120543f, -0.06773223f, 0.15252401f, -0.04955167f, -0.21166325f, 0.17164662f, 0.08730731f, 0.10686969f, 
    0.00311654f, -0.22166702f, -0.42686605f, 0.22463077f, 0.21386938f, 0.04438841f, -0.01876836f, 0.10714886f, 
    0.15712942f, 0.52913767f, -0.05955551f, 0.06968191f, -0.06079691f, -0.01252987f, 0.09751888f, -0.29311118f, 
    -0.10943114f, -0.10835840f, -0.01140263f, -0.11747368f, 0.04793795f, 0.04323776f, 0.20381506f, 0.04577163f, 
    -0.09163386f, -0.24087736f, -0.18943520f, 0.16458833f, 0.14660141f, 0.23938720f, 0.12270729f, 0.03348779f, 
    -0.31664684f, -0.47453266f, 0.11973432f, 0.33237985f, -0.30803156f, 0.05029060f, 0.05220376f, -0.47680768f, 
    -0.27949336f, -0.25297764f, -0.24912865f, -0.34895515f, -0.04412789f, 0.12380201f, -0.02006114f, 0.25715581f, 
    -0.49817613f, 0.04273961f, 0.17125417f, 0.13677125f, 0.66813165f, -0.47423214f, 0.02470269f, -0.00515717f, 
    0.61764413f, -0.02994501f, 0.00302147f, -0.03654265f, -0.00280877f, -0.00976812f, 0.14577308f, -0.00655230f, 
    -0.07780714f, 0.48598304f, 0.23980087f, 0.99027884f, -0.11082406f, 0.11846051f, -0.43994007f, -0.31070685f, 
    -0.18503934f, 0.00142495f, 0.02733753f, 0.15231796f, -0.00324125f, 0.42299184f, -0.09347906f, -0.12524301f, 
    0.11155955f, -0.00778870f, -0.17575952f, 0.02045394f, 0.20589763f, 0.04870382f, 0.05291345f, -0.09763834f, 
    0.14525779f, -0.26145834f, -0.26333630f, -0.07676460f, 0.47855622f, 0.06769660f, 0.06820044f, 0.22092627f, 
    -0.11490028f, 0.08166693f, -0.32245526f, 0.05050819f, -0.14603686f, 0.01092889f, 0.05333628f, 0.09268685f, 
    -0.26491413f, 0.37030458f, 0.19090913f, 0.05078734f, -0.12246994f, 0.24916339f, -0.02224725f, -0.10430483f, 
    -0.02087453f, 0.09255642f, -0.56678605f, -0.17682913f, -0.25787520f, 0.39651030f, 0.10675921f, -0.01013261f, 
    0.27830023f, 0.22973293f, 0.05131027f, 0.02510352f, 0.13931993f, 0.09007678f, 0.11729654f, -0.07557838f, 
    -0.16131067f, -0.16574124f, -0.48315388f, -0.10710518f, 0.11617417f, 0.13970737f, 0.02221838f, 0.02974440f, 
    -0.00209795f, 0.17331403f, 0.06110352f, -0.08202835f, -0.10124222f, -0.25272813f, -0.09469328f, 0.09251735f, 
    -0.00450140f, -0.11472317f, -0.20104821f, -0.23762643f, 0.16343720f, -0.15881124f, 0.18789503f, 0.29318026f, 
    0.12746951f, -0.06046325f, -0.25696480f, 0.02771787f, 0.00678234f, 0.63488859f, -0.06330457f, -0.25560933f, 
    -0.11901596f, -0.16346161f, 0.19808598f, 0.19396397f, -0.51715744f, 0.05777089f, -0.04684631f, 0.09620926f, 
    -0.06931011f, -0.27781349f, -0.23155366f, -0.23730281f, -0.03968583f, 0.07207619f, 0.09387715f, 0.17078762f, 
    -0.25231895f, 0.03125593f, -0.35921571f, -0.03057628f, 0.30612198f, -0.26459721f, 0.04084445f, -0.00058078f, 
    -0.04071917f, -0.03628043f, -0.09401024f, -0.19768852f, 0.34916371f, 0.03539326f, 0.02728391f, 0.08976077f, 
    0.10340454f, 0.22858429f, 0.42773309f, 0.23185845f, -0.07294647f, 0.10767028f, -0.36316454f, -0.06325936f, 
    0.00101346f, 0.03193029f, 0.14190687f, -0.05696959f, 0.18935376f, 0.24159935f, -0.09256586f, -0.13105197f, 
    0.19387063f, -0.00671751f, 0.04517977f, -0.04322440f, 0.02403736f, 0.05560209f, -0.02411367f, 0.01353952f, 
    -0.04035284f, -0.11991144f, -0.22240520f, 0.09519727f, 0.06462522f, 0.06474470f, 0.10896078f, 0.16696984f, 
    -0.16968580f, -0.02427897f, 0.03306441f, -0.39882737f, 0.01426192f, 0.03136453f, -0.00974909f, 0.03893230f, 
    0.10818589f, 0.13588507f, -0.06847735f, 0.13151683f, -0.05199817f, 0.15702368f, 0.00533392f, -0.10302346f, 
    -0.04596596f, -0.02464912f, -0.22482181f, -0.46502769f, -0.19113626f, 0.22747356f, 0.01480968f, -0.12972337f, 
    0.24916662f, 0.14378816f, 0.22555217f, 0.12197071f, 0.03134678f, 0.31714141f, 0.21355040f, -0.07872666f, 
    0.08401157f, 0.05281202f, 0.48618877f, -0.16162053f, -0.09014474f, 0.13636589f, -0.04406208f, 0.15577006f, 
    0.05442344f, -0.45150903f, 0.07646249f, 0.06737071f, 0.31226087f, -0.06719948f, 0.04126002f, 0.38747510f, 
    -0.01469991f, -0.01348836f, -0.18115962f, 0.23538157f, -0.01755070f, 0.12629959f, 0.14359336f, 0.09207021f, 
    0.31389850f, -0.10363942f, 0.10251597f, 0.03814860f, -0.04754654f, 0.00554345f, -0.06065638f, -0.00788578f, 
    0.35993883f, -0.07242482f, 0.14437222f, 0.01017982f, 0.67327482f, 0.07261542f, 0.00267184f, -0.14287511f, 
    -0.08381122f, 0.04485062f, -0.20786737f, -0.00653165f, 0.04438650f, 0.26879641f, 0.51896107f, -0.45732841f, 
    0.34493312f, 0.02228275f, -0.45652744f, -0.06881012f, 0.07003583f, 0.42223370f, 0.08641699f, 0.03900439f, 
    -0.47293022f, 0.04786591f, -0.10106950f, -0.19101994f, -0.18057512f, 0.08804372f, -0.20307833f, 0.05176079f, 
    0.27110389f, 0.29220229f, 0.26296172f, -0.11551039f, 0.13205230f, 0.08075592f, 0.00113509f, 0.46429405f, 
    0.29600647f, 0.01351000f, 0.32582659f, 0.35446751f, 0.14691764f, 0.10850497f, 0.18483514f, 0.14324760f, 
    -0.17916697f, 0.06870252f, -0.01504554f, -0.06578872f, -0.22837123f, -0.05139969f, -0.20808165f, -0.05368124f, 
    -0.36768675f, 0.10444328f, -0.27391815f, 0.05006257f, 0.25356010f, 0.13653870f, -0.22996998f, -0.10373410f, 
    0.00720191f, -0.05135738f, 0.13769934f, 0.43278813f, 0.00220552f, 0.36931631f, 0.05251626f, 0.12343039f, 
    0.11868268f, 0.15886475f, -0.14706232f, 0.05690420f, 0.01508458f, -0.01354857f, 0.08650766f, -0.29343349f, 
    -0.00993005f, -0.09189238f, -0.12781198f, -0.06491579f, -0.04475721f, 0.39615637f, 0.03204887f, -0.07220532f, 
    -0.13661897f, 0.01454390f, 0.05514660f, 0.07074224f, -0.09585353f, 0.10088477f, 0.04620799f, 0.25301367f, 
    0.17961147f, -0.13097881f, -0.25992480f, -0.08429720f, -0.06270117f, 0.27369133f, 0.00634822f, -0.01890387f, 
    0.13333477f, 0.60576886f, 0.05892049f, 0.01727290f, -0.00807581f, 0.08644273f, 0.05611098f, 0.20476234f, 
    0.02621102f, -0.10385294f, -0.34433627f, -0.08810939f, -0.12118419f, 0.00695568f, 0.01513402f, 0.38827449f, 
    -0.17984726f, -0.05289251f, -0.19046323f, -0.26229861f, 0.05252463f, -0.05197332f, -0.18879928f, -0.37755704f, 
    -0.01244889f, 0.00486059f, 0.01462853f, 0.09960864f, 0.45958236f, -0.06120549f, 0.05851445f, 0.03634048f, 
    -0.07081638f, 0.09521160f, 0.09899580f, 0.06660595f, 0.08019455f, 0.09252255f, -0.08077852f, -0.04421310f, 
    -0.03977635f, 0.13044699f, 0.17449626f, -0.04900846f, 0.38327077f, -0.00787548f, -0.09909432f, -0.11692669f, 
    0.18038580f, 0.02793895f, 0.11049638f, 0.06831738f, -0.10905101f, 0.04161943f, -0.07291200f, -0.21409918f, 
    0.04151861f, 0.34419045f, 0.07718285f, 0.60222971f, -0.05042723f, 0.09733060f, 0.12740998f, 0.17876072f, 
    0.03315623f, 0.04064918f, -0.01043268f, 0.24067177f, -0.03721722f, 0.03539426f, 0.05640085f, -0.00864142f, 
    0.15142690f, 0.05754863f, -0.14397296f, -0.01046374f, -0.01239940f, -0.03003464f, -0.08787048f, -0.13111123f, 
    0.04078685f, 0.05975005f, -0.02593629f, 0.14977449f, -0.00346401f, -0.03195836f, -0.03825861f, 0.10813190f, 
    0.17907737f, -0.06698004f, 0.17076124f, 0.05471747f, 0.06317942f, -0.01469323f, 0.00176749f, 0.09573904f, 
    0.33422941f, 0.23063619f, -0.09239210f, 0.09193045f, 0.12532465f, -0.08863797f, 0.00962202f, 0.01382576f, 
    -0.04683437f, 0.07184325f, 0.04320168f, -0.01595437f, -0.01614910f, 0.20806271f, 0.04565790f, -0.23242660f, 
    -0.00971920f, -0.05836581f, 0.02662009f, -0.05901839f, 0.03370247f, -0.08628196f, 0.08381437f, -0.20773573f, 
    -0.09379002f, -0.09615642f, -0.08394275f, -0.23318653f, 0.16489041f, -0.12558812f, 0.08550894f, -0.01849535f, 
    0.02022222f, -0.02874706f, -0.01490280f, -0.02447862f, 0.05810251f, 0.09540883f, -0.00843146f, 0.22186913f, 
    -0.03801777f, -0.18820493f, -0.22245842f, -0.07800759f, -0.01139802f, -0.07898721f, 0.16815715f, 0.21348099f, 
    -0.00502355f, -0.02012673f, -0.04577474f, -0.08976381f, -0.00019583f, 0.08949081f, 0.20002460f, -0.13216761f, 
    0.04143324f, 0.02927686f, 0.01047357f, -0.03823086f, 0.18744624f, 0.09272919f, 0.02976963f, -0.02463615f, 
    0.18939236f, 0.07044195f, -0.04842101f, 0.06739897f, 0.06111481f, 0.28705928f, 0.13513324f, -0.36869597f, 
    0.11878126f, 0.03472041f, 0.18036903f, -0.04345489f, -0.09979907f, -0.14175998f, -0.00198703f, 0.04950758f, 
    -0.32448071f, 0.08628429f, 0.22297135f, -0.00231388f, -0.26535052f, 0.08042706f, -0.05383528f, -0.09428579f, 
    0.34072116f, 0.01400134f, 0.25412506f, 0.00860946f, -0.04472578f, 0.17698708f, -0.18886943f, 0.17451292f, 
    0.11592754f, 0.47127137f, -0.00394772f, 0.13634954f, 0.04969698f, -0.12986790f, 0.20081507f, 0.22881657f, 
    -0.09995683f, 0.04671547f, -0.12730558f, -0.05178776f, 0.03926992f, -0.02046842f, -0.04260385f, 0.06755400f, 
    0.11856957f, 0.22836635f, -0.07363465f, 0.01146374f, -0.14084047f, 0.25304124f, -0.10903167f, -0.05399227f, 
    -0.15002099f, -0.14341678f, 0.39221850f, -0.02784129f, 0.15393393f, 0.03941738f, 0.03793170f, 0.10982803f, 
    -0.03307297f, 0.02398639f, 0.07795796f, 0.15674432f, 0.04196672f, -0.10261898f, 0.05644157f, -0.16966042f, 
    0.05287737f, 0.05188013f, 0.00212471f, -0.06628608f, 0.16559057f, 0.14476529f, -0.14184628f, -0.02347718f, 
    -0.07116563f, 0.01951379f, -0.12539223f, -0.10271131f, 0.00325832f, -0.03740329f, 0.03499766f, 0.16935636f, 
    0.38251391f, 0.21930929f, -0.18374890f, -0.09294179f, -0.04242542f, 0.28607625f, 0.04201127f, 0.09762479f, 
    0.10778663f, -0.34843093f, -0.03055180f, -0.06174180f, 0.00695912f, 0.08873188f, -0.05779888f, 0.23280703f, 
    -0.01493198f, 0.03671158f, -0.04519394f, -0.17930943f, 0.09895401f, 0.18207420f, -0.04220560f, 0.07161376f, 
    0.04517376f, -0.08769726f, -0.15157390f, -0.15750244f, 0.00944997f, -0.01400338f, -0.00051701f, -0.04468405f, 
    0.11624786f, -0.05702619f, 0.17502517f, -0.07602958f, 0.30982333f, 0.01520578f, -0.24856250f, -0.16809617f, 
    -0.09265584f, 0.08823495f, -0.20989957f, -0.20663059f, -0.08022142f, 0.22240186f, -0.17303653f, 0.02920983f, 
    -0.28191185f, 0.06778001f, -0.07727309f, 0.05784371f, 0.25077748f, -0.28297263f, -0.07715047f, 0.01907655f, 
    -0.00911624f, 0.08183718f, 0.10602491f, 0.19181675f, -0.19548160f, -0.08037475f, -0.14569817f, -0.05575723f, 
    0.21509789f, 0.31350952f, -0.00261416f, 0.43889001f, 0.05007992f, 0.15012465f, -0.05623629f, 0.34569871f, 
    0.27223846f, -0.28654474f, 0.02423312f, 0.15440182f, -0.27519682f, -0.05601387f, 0.18775067f, 0.15715666f, 
    0.14017187f, -0.08798011f, -0.31532380f, 0.10124268f, 0.12823611f, 0.07053144f, 0.01724923f, -0.23752087f, 
    0.08262584f, 0.07856078f, -0.25124174f, 0.02729069f, 0.12924786f, -0.01191788f, -0.11023386f, 0.39721006f, 
    -0.01057203f, -0.27586702f, 0.01439766f, -0.10426889f, 0.00432313f, 0.21696074f, -0.00957910f, 0.21667159f, 
    -0.39792806f, 0.17020647f, -0.15181306f, 0.17531027f, -0.14848299f, 0.09530406f, 0.07011741f, -0.18333232f, 
    -0.03827077f, -0.04559438f, -0.27300206f, 0.25837916f, 0.10921920f, 0.22737615f, -0.14625426f, 0.03238434f, 
    0.02670262f, 0.11697032f, -0.51963419f, -0.16278131f, 0.22990677f, -0.29525298f, -0.08225489f, -0.24112126f, 
    0.06522480f, 0.10562418f, -0.33503154f, -0.02295814f, 0.18950380f, -0.00152708f, 0.11393014f, -0.39185226f, 
    0.08633072f, -0.21163005f, 0.06663024f, -0.02709372f, 0.13906665f, 0.12153097f, 0.12608182f, 0.21581395f, 
    -0.00206780f, 0.05980094f, -0.12700610f, 0.11476874f, 0.00773427f, -0.20421842f, -0.52613610f, 0.29630092f, 
    -0.11827895f, 0.28820777f, -0.28946570f, -0.28957912f, 0.08061911f, 0.44560075f, -0.41806787f, -0.07374708f, 
    0.03874759f, 0.01537419f, 0.14576779f, 0.04629774f, -0.39560226f, 0.01875567f, -0.16063450f, 0.12936231f, 
    0.07675291f, -0.14589870f, -0.16820253f, -0.03710146f, -0.01332383f, -0.07470952f, -0.07872109f, -0.36790660f, 
    0.06535098f, 0.02720191f, -0.27425697f, -0.15379319f, -0.24227245f, -0.11856406f, -0.04634905f, 0.04534645f, 
    -0.33573845f, 0.02206483f, -0.04430022f, -0.18200374f, 0.00077356f, -0.06833778f, -0.08076362f, -0.02713067f, 
    0.10640262f, -0.21923684f, 0.06379201f, -0.26172853f, 0.02767234f, 0.01711621f, -0.34060901f, -0.06934166f, 
    0.14845155f, 0.09814955f, 0.18195790f, -0.23219566f, -0.01605719f, -0.38611466f, 0.17251974f, 0.12252659f, 
    0.00562453f, 0.00129333f, 0.04304408f, -0.09145679f, 0.06678666f, 0.07861781f, -0.22859223f, -0.00412309f, 
    -0.28227946f, 0.07103398f, -0.01555360f, 0.05500467f, -0.13958660f, -0.06845778f, -0.07322378f, -0.34880126f, 
    -0.30356789f, -0.13874431f, 0.02544946f, 0.07081559f, 0.04647743f, 0.17630860f, 0.02264662f, -0.05581735f, 
    -0.30324501f, -0.10409223f, 0.03801114f, 0.08689050f, -0.36361197f, -0.03384944f, 0.02631866f, 0.19534795f, 
    0.00169083f, -0.36828843f, 0.11682144f, -0.07661846f, -0.00269355f, 0.08217839f, -0.08175449f, 0.19954836f, 
    0.05788286f, -0.05605755f, -0.43786615f, -0.28412902f, -0.04907022f, -0.32740310f, 0.03074249f, -0.09244514f, 
    0.06578278f, 0.09790237f, 0.04623511f, 0.07195152f, -0.25880718f, 0.20905980f, 0.00417632f, -0.21618538f, 
    0.05401675f, -0.13570614f, 0.02650520f, -0.06199583f, 0.20340019f, 0.04663436f, 0.14273545f, 0.14947836f, 
    -0.04131588f, 0.19521506f, 0.27540028f, 0.15472777f, 0.02246704f, 0.23018752f, -0.35394317f, -0.08361292f, 
    0.35133100f, -0.05046295f, 0.20279273f, -0.28559560f, -0.16350074f, 0.28190425f, -0.24188349f, 0.06775805f, 
    -0.02873363f, 0.00568191f, 0.01349581f, -0.00649751f, -0.04959424f, -0.03793425f, -0.06000710f, -0.03133149f, 
    -0.02568879f, -0.05084743f, 0.08771236f, -0.07988891f, 0.01667299f, -0.07511415f, -0.02470683f, -0.04170005f, 
    -0.04124943f, 0.05098368f, 0.00599632f, -0.08135909f, -0.08696349f, -0.04751251f, -0.05277135f, 0.07339203f, 
    -0.03072932f, -0.02663651f, -0.07587565f, 0.05932371f, 0.03660732f, -0.02227522f, -0.05690946f, -0.03023863f, 
    -0.07486129f, -0.02641744f, 0.03549362f, -0.00003742f, -0.07645518f, -0.08504305f, -0.04609139f, -0.05746380f, 
    0.00419843f, -0.00992477f, -0.06327084f, -0.07229648f, 0.00895619f, 0.07094687f, -0.07235417f, -0.03263611f, 
    0.04041773f, 0.01983818f, -0.06975533f, 0.06325942f, -0.03315222f, -0.00519673f, 0.00992918f, 0.02718407f, 
    0.06832452f, 0.07461539f, 0.04423756f, -0.04828444f, 0.06049143f, 0.04043306f, -0.03108358f, -0.01758182f, 
    0.01543874f, 0.01195248f, -0.00433153f, 0.04968373f, -0.04276412f, -0.01576361f, -0.03721837f, -0.06625513f, 
    0.00867158f, -0.05199138f, -0.07884075f, 0.02170393f, -0.00537299f, 0.03151266f, 0.04870266f, -0.01295594f, 
    -0.00717191f, -0.09390785f, -0.02583471f, -0.03768561f, 0.06809979f, 0.04515266f, -0.05737836f, -0.03660264f, 
    -0.09414511f, -0.01435814f, -0.09474450f, 0.04411578f, 0.00589003f, -0.09453445f, -0.08872174f, -0.00607841f, 
    -0.05555836f, 0.00746203f, 0.02134698f, 0.00866335f, -0.06251572f, 0.01939972f, -0.06878976f, -0.05045803f, 
    -0.00401548f, 0.05542283f, 0.06772441f, 0.00576877f, -0.07708561f, 0.05484616f, 0.07123315f, -0.04783731f, 
    0.06122573f, 0.01257923f, 0.01732781f, 0.07648320f, 0.06699615f, 0.04711999f, 0.00040653f, 0.07254356f, 
    -0.07613044f, -0.08008852f, -0.00367513f, 0.06414159f, -0.04877681f, -0.00692628f, 0.04395710f, 0.02136042f, 
    0.17762589f, -0.15698490f, 0.15514533f, 0.16820724f, 0.16257967f, 0.01828139f, 0.04139591f, -0.00715145f, 
    0.13491948f, 0.00120510f, -0.10210921f, -0.12457705f, 0.08052771f, 0.15871932f, 0.20697060f, -0.44885334f, 
    -0.45576113f, 0.00072063f, 0.18538111f, 0.06315760f, -0.07838287f, -0.09459871f, 0.06668858f, -0.08462245f, 
    -0.39849281f, 0.03071024f, 0.15659267f, -0.16462246f, -0.28649500f, -0.07895572f, -0.08353720f, -0.11437551f, 
    0.18613014f, 0.14231780f, 0.40366963f, -0.24783638f, 0.06357363f, 0.20128790f, -0.15707015f, 0.23640043f, 
    0.00671744f, 0.23436938f, 0.07733849f, 0.18153580f, 0.42626065f, 0.02881748f, 0.09534026f, 0.03814094f, 
    -0.22523066f, 0.16883533f, -0.35752472f, 0.00728149f, -0.07431211f, -0.06306843f, -0.19323497f, 0.19430627f, 
    -0.04948263f, 0.05558009f, -0.25337172f, 0.16387680f, -0.08289268f, 0.24050729f, -0.14313588f, 0.11726888f, 
    -0.13395584f, -0.11181894f, 0.32956114f, -0.39294827f, 0.22034134f, -0.05290639f, 0.04008766f, 0.22028659f, 
    -0.14999521f, 0.13738376f, 0.06252750f, 0.23237492f, 0.15260065f, -0.05402709f, -0.07165617f, -0.28637275f, 
    0.01185460f, -0.08055335f, -0.34606579f, -0.25302234f, 0.02877949f, 0.14736435f, -0.14346315f, -0.31321436f, 
    -0.01153099f, 0.09820841f, -0.04651428f, -0.05536380f, -0.02098763f, 0.06125665f, 0.20477222f, 0.20351005f, 
    0.26378781f, 0.12357201f, -0.24599504f, -0.10589465f, 0.01432267f, 0.23537041f, -0.05941896f, 0.19514279f, 
    0.14506927f, -0.23806491f, -0.00149093f, -0.00349834f, 0.10543154f, 0.07206085f, 0.12834679f, 0.07602765f, 
    0.06322889f, -0.13109308f, -0.32072917f, -0.09627800f, 0.06433383f, 0.08307472f, 0.15822303f, 0.15998285f, 
    -0.11757201f, -0.33567834f, -0.32962936f, -0.16366473f, 0.14851049f, -0.45073909f, 0.02397358f, -0.09761662f, 
    -0.00211239f, -0.03256722f, 0.02492430f, -0.13584740f, 0.29286641f, 0.03385537f, -0.33299223f, 0.45510712f, 
    0.02742767f, 0.00830147f, 0.02406517f, -0.19511192f, -0.05904878f, 0.04306218f, -0.12685534f, -0.11050210f, 
    0.03870134f, -0.05276005f, -0.35508311f, -0.09149282f, -0.20965613f, -0.13867480f, -0.04867813f, 0.03227983f, 
    -0.11697412f, 0.05070001f, 0.32122225f, -0.09046030f, -0.12210149f, -0.06460767f, -0.03617526f, -0.26677504f, 
    0.41579545f, -0.16423447f, -0.00519334f, -0.50281012f, 0.04202015f, 0.01734330f, -0.07633673f, 0.25327128f, 
    0.09550174f, -0.14917721f, 0.11647180f, -0.22802591f, 0.05240227f, -0.26489970f, 0.08303413f, -0.07714246f, 
    0.17138134f, -0.07894216f, -0.01013522f, 0.02534060f, 0.02672103f, -0.07232810f, 0.14794379f, -0.19537787f, 
    0.22793777f, 0.01005998f, 0.15455085f, 0.21734077f, -0.03995932f, 0.15070051f, -0.01456681f, 0.30956396f, 
    -0.08270253f, -0.32984883f, 0.10107987f, -0.06624506f, 0.15748537f, 0.19172622f, -0.09364554f, -0.04524965f, 
    -0.51258844f, -0.15199727f, -0.09352367f, 0.15573703f, -0.09069753f, 0.01734547f, 0.08112129f, 0.24994755f, 
    -0.07426044f, -0.12811239f, -0.02682955f, -0.22224334f, 0.11549022f, -0.10826395f, -0.14221698f, 0.20609273f, 
    0.09743467f, 0.10546624f, -0.34717456f, -0.35634774f, 0.15883550f, -0.44691133f, 0.07448303f, -0.21330579f, 
    0.13326223f, 0.51839012f, -0.19364192f, 0.35265586f, -0.08162522f, -0.04523949f, 0.02337256f, -0.23361905f, 
    -0.11659862f, -0.04239324f, 0.01883337f, -0.00178423f, 0.36011794f, 0.10562878f, 0.00174054f, 0.31897187f, 
    -0.05874744f, 0.13914050f, 0.39698154f, 0.55841333f, 0.04408124f, 0.30230051f, -0.59440482f, -0.06416617f, 
    0.14931895f, -0.01450796f, -0.22090505f, 0.08271270f, 0.00546103f, -0.49292991f, -0.06797229f, 0.42957175f, 
    -0.40615565f, -0.05406781f, 0.13368776f, 0.26204595f, 0.18965013f, -0.03331595f, 0.02649128f, -0.38658181f, 
    0.06037500f, -0.03739362f, -0.11101791f, -0.10464818f, -0.07441493f, 0.01537114f, 0.09794295f, 0.27021641f, 
    0.11707652f, -0.01524493f, -0.03053053f, 0.03192401f, 0.39417461f, -0.00424896f, -0.08382160f, 0.08565242f, 
    0.03005169f, 0.04700447f, -0.12851918f, 0.02903211f, 0.12029418f, -0.05883554f, 0.18239301f, 0.07653812f, 
    -0.22528440f, 0.32112265f, -0.03967922f, 0.52640808f, -0.26463285f, -0.05551752f, -0.08183029f, -0.32347786f, 
    -0.49112028f, -0.08277801f, -0.32923624f, -0.24126031f, -0.15948445f, 0.20658381f, -0.09967093f, -0.07693373f, 
    0.16485207f, 0.02493749f, 0.09696480f, -0.05233976f, 0.00748705f, -0.03709592f, -0.00881860f, -0.37300226f, 
    -0.12792225f, -0.19531867f, 0.05404004f, -0.16381562f, 0.31264549f, -0.01784729f, 0.15111727f, 0.09724994f, 
    0.01145864f, 0.06141404f, -0.32079345f, 0.07925598f, -0.19451967f, 0.08492251f, 0.08774362f, -0.06346413f, 
    -0.19805354f, 0.28663373f, 0.03653434f, 0.09992950f, -0.03380338f, 0.15017702f, 0.06594388f, -0.07231376f, 
    0.02984520f, 0.00609721f, -0.00097121f, -0.06040983f, 0.06588392f, 0.20043124f, 0.07953707f, 0.06027028f, 
    0.19452862f, 0.05383873f, -0.06759281f, 0.17591877f, -0.14943276f, 0.09311331f, 0.05517644f, -0.10474242f, 
    -0.25702488f, -0.08538151f, 0.18673673f, -0.06199975f, 0.10636436f, -0.02858799f, -0.03378090f, -0.04922567f, 
    0.28349841f, 0.15620516f, 0.07932679f, -0.02331850f, 0.23498480f, -0.18587483f, 0.16238317f, 0.02656493f, 
    0.05453585f, 0.08680920f, 0.07807807f, -0.18489397f, 0.16107991f, -0.05960741f, 0.02750055f, 0.16149965f, 
    0.03575477f, 0.00626078f, 0.06343387f, -0.10229439f, -0.09544634f, 0.55610621f, -0.09371088f, 0.19188392f, 
    -0.02981890f, -0.06630287f, 0.23505086f, -0.67108238f, -0.18470640f, 0.04946730f, -0.34268013f, 0.05738382f, 
    -0.07472545f, 0.15882769f, -0.54347593f, -0.06569327f, 0.06091537f, 0.26371366f, -0.17518768f, 0.38698125f, 
    -0.10140678f, 0.00629150f, 0.52147651f, 0.03933597f, -0.62283301f, -0.13949737f, -0.02939050f, 0.01496781f, 
    0.49575603f, 0.06680477f, 0.40240398f, 0.07822885f, 0.18344103f, -0.00280441f, 0.08592607f, -0.05289242f, 
    -0.09268221f, -0.31476030f, -0.09054097f, -0.42036265f, 0.00609612f, -0.01071021f, -0.11477587f, -0.30577186f, 
    -0.00129203f, -0.27579331f, -0.12445546f, 0.32421577f, 0.15031412f, -0.23461221f, -0.38592851f, -0.27486277f, 
    0.20689660f, -0.50426012f, -0.25910619f, -0.00156550f, 0.06930652f, 0.03165768f, 0.07512318f, 0.33277655f, 
    0.08510369f, -0.33570907f, 0.06964559f, -0.59116232f, 0.28566778f, -0.12213544f, -0.07185079f, 0.01331850f, 
    0.02447151f, -0.21301623f, -0.61640692f, 0.04500334f, 0.04015046f, 0.18178006f, -0.03174296f, -0.43314946f, 
    0.19896923f, -0.53698689f, -0.08670248f, 0.11348432f, 0.00442016f, 0.11520444f, 0.07466792f, 0.20523679f, 
    -0.00317490f, -0.13706306f, -0.01581956f, 0.01565262f, 0.04366073f, -0.50857681f, -0.02361847f, -0.06970934f, 
    0.10898004f, 0.13720058f, 0.06961859f, -0.13185561f, 0.18970923f, 0.04027894f, -0.22834598f, 0.41049823f, 
    -0.18985364f, 0.06088607f, -0.25961477f, 0.06999609f, 0.10371103f, 0.29207164f, -0.03000188f, 0.15422647f, 
    -0.42884955f, 0.06100070f, 0.00483007f, -0.06510314f, -0.25954467f, -0.06979835f, -0.13332993f, -0.93476284f, 
    -0.04313162f, 0.09728222f, 0.21559425f, 0.12140650f, 0.01043486f, -0.16062807f, 0.03997119f, -0.14822790f, 
    0.26433682f, 0.05040965f, 0.01964987f, 0.04491049f, 0.31615230f, -0.09497631f, 0.10829093f, 0.05660374f, 
    0.18486527f, 0.00577916f, -0.09774892f, 0.19391902f, 0.05563452f, 0.05086217f, 0.16478215f, 0.08034118f, 
    0.01033114f, -0.05367587f, -0.13332926f, -0.38962764f, 0.08600713f, -0.03422290f, 0.42336416f, -0.47346655f, 
    0.05829718f, -0.01002393f, -0.23219261f, -0.02172539f, -0.06107413f, -0.24188104f, 0.03814342f, 0.04138590f, 
    -0.00456508f, 0.01845339f, -0.23983364f, -0.44690251f, -0.39175236f, -0.05133689f, 0.11838423f, -0.05143931f, 
    -0.07810353f, -0.09862903f, 0.29219735f, -0.00256352f, 0.14734033f, 0.24903424f, -0.53179914f, 0.04428163f, 
    0.16029938f, 0.29339609f, 0.17648728f, 0.37437975f, 0.23845968f, 0.31372458f, -0.08957745f, -0.33092701f, 
    -0.34119943f, 0.13507146f, -0.13136671f, -0.07437305f, -0.18768604f, 0.00778742f, -0.23395625f, 0.20178294f, 
    -0.45243379f, -0.00707786f, -0.34066856f, 0.15014720f, 0.16580610f, 0.02930426f, 0.01107287f, -0.15981053f, 
    -0.34928140f, 0.09156094f, 0.02240742f, 0.46685866f, 0.01986713f, 0.03767495f, 0.07887878f, 0.08621106f, 
    -0.13179617f, -0.03832472f, 0.02670054f, 0.03542937f, -0.20800917f, -0.15693322f, 0.04531583f, 0.23000173f, 
    0.04941444f, -0.05054624f, -0.13755038f, -0.42329660f, -0.44624075f, 0.12120926f, -0.11900759f, -0.34744218f, 
    0.03590965f, -0.17130992f, 0.19642782f, 0.03278558f, -0.08863326f, 0.29014158f, 0.26780680f, 0.28865635f, 
    -0.09656991f, -0.33916968f, -0.08405396f, 0.09888423f, -0.22147027f, 0.21906798f, -0.03357435f, 0.32663465f, 
    0.16689305f, 0.53451610f, -0.01146767f, 0.04661873f, 0.01553949f, -0.24413756f, 0.01427314f, -0.00580986f, 
    -0.03150243f, -0.05445016f, -0.48822209f, -0.12133539f, -0.07349321f, 0.13853633f, 0.23217873f, 0.04512011f, 
    0.07231205f, -0.32101899f, -0.06805819f, -0.05810213f, 0.14604463f, -0.16797799f, -0.09174028f, -0.04127784f, 
    0.00072251f, -0.05334426f, 0.16095500f, -0.31503209f, 0.12073741f, 0.05759491f, -0.27485296f, 0.18078084f, 
    -0.14969228f, 0.04977097f, -0.17178757f, -0.31942335f, -0.06950484f, 0.12288663f, -0.20647310f, -0.31373224f, 
    -0.11949079f, -0.05429648f, 0.08116714f, -0.19544221f, 0.03232722f, -0.42961907f, -0.08890528f, 0.03059089f, 
    -0.05029106f, -0.06904840f, 0.14569199f, -0.49105135f, -0.18106627f, -0.07706653f, -0.48416427f, -0.06468581f, 
    0.36723942f, 0.34014121f, 0.15063171f, -0.04612326f, 0.01478192f, 0.17454487f, -0.04908606f, 0.26854697f, 
    0.14271988f, 0.00750934f, 0.03580113f, 0.09241188f, 0.00301051f, -0.19851805f, 0.19230588f, 0.08084893f, 
    0.05348529f, 0.00921492f, -0.20264342f, 0.07475215f, -0.01658945f, -0.03766743f, -0.16930532f, -0.15266863f, 
    0.17533968f, 0.20025593f, -0.04544993f, 0.00474483f, -0.23728937f, 0.28048304f, -0.48703939f, 0.30563292f, 
    -0.15445529f, -0.31094810f, 0.21570578f, -0.25833762f, 0.18866096f, 0.23323420f, -0.03391239f, -0.02033975f, 
    -0.34694397f, -0.01687186f, -0.18453497f, 0.18230779f, -0.29164401f, 0.07126143f, -0.07908012f, -0.17960304f, 
    0.06533423f, -0.23242868f, -0.38667101f, -0.03454497f, 0.09159798f, 0.11632062f, -0.23020281f, 0.09685954f, 
    -0.06508239f, 0.11690125f, -0.24088338f, -0.32112369f, 0.06624524f, -0.48683497f, -0.15289578f, -0.11220222f, 
    0.22000085f, 0.20714308f, -0.08132511f, -0.01554618f, -0.39483428f, -0.00845530f, 0.05022352f, -0.17340448f, 
    -0.11855089f, -0.37808987f, -0.00698471f, 0.02518055f, 0.00279303f, 0.04903532f, -0.28313816f, 0.38694632f, 
    0.00376992f, 0.17438433f, -0.36834142f, 0.26446086f, -0.21685922f, 0.05946881f, -0.07223212f, 0.28780150f, 
    -0.07523417f, 0.20972715f, -0.23916902f, -0.31788278f, 0.09198681f, 0.06991751f, -0.40164387f, -0.06804874f, 
    -0.01231018f, -0.03268914f, -0.06045942f, -0.01938778f, -0.02905429f, 0.01301257f, -0.02182810f, 0.03821295f, 
    0.01057945f, -0.08967610f, -0.06606466f, -0.00986053f, 0.02112616f, 0.06124003f, -0.03496560f, 0.11406854f, 
    -0.03592069f, -0.06561017f, 0.00206656f, -0.01070639f, -0.03701385f, 0.05693597f, -0.03175902f, 0.05019280f, 
    0.03438248f, -0.08515007f, -0.07825089f, 0.00434854f, 0.09283976f, 0.07499673f, 0.00886322f, -0.00173137f, 
    0.00522712f, -0.08390630f, 0.05771332f, -0.00907022f, -0.07310023f, -0.03195519f, 0.00309389f, -0.01851751f, 
    -0.04541447f, 0.03579018f, -0.00026341f, 0.02224410f, 0.06579654f, 0.07865074f, -0.02739369f, 0.03921985f, 
    -0.05377438f, -0.05017143f, 0.03564190f, -0.00766831f, 0.06245780f, 0.01362672f, 0.03917266f, 0.04690873f, 
    0.07898980f, -0.02390597f, -0.09286447f, -0.01231351f, 0.04164846f, -0.03755561f, 0.00049395f, -0.04363278f, 
    0.07323073f, -0.10414317f, -0.06881046f, 0.04725241f, 0.06662327f, -0.05037330f, 0.01572636f, 0.05537805f, 
    -0.07828353f, -0.12237799f, -0.03670637f, -0.09628132f, -0.09394505f, -0.01328859f, -0.02427751f, -0.00326474f, 
    0.03417799f, 0.00297886f, -0.10062980f, -0.07942265f, -0.02435670f, -0.07420573f, 0.00435318f, 0.04791556f, 
    -0.04423475f, 0.04057251f, -0.05778080f, 0.01005669f, -0.05778594f, -0.03649067f, -0.07556883f, -0.11116784f, 
    -0.04142077f, 0.02270966f, -0.02781237f, 0.04238937f, 0.00389471f, -0.06750412f, 0.02096621f, -0.01933206f, 
    -0.06974182f, 0.02700733f, -0.04037565f, 0.03645696f, 0.02358465f, 0.06346208f, 0.05819327f, -0.10280148f, 
    -0.06250393f, 0.00098052f, -0.00420413f, 0.03764815f, -0.08563504f, 0.01314090f, 0.04463655f, -0.00071688f, 
    0.05775512f, -0.05804979f, 0.04059970f, -0.00249026f, -0.10085947f, 0.01504302f, -0.10580812f, -0.05563580f, 
    0.30337468f, 0.24983656f, 0.21948370f, -0.02939077f, -0.21254182f, 0.04138691f, -0.00750365f, -0.18183263f, 
    -0.14574181f, 0.14946364f, -0.02572683f, -0.05894363f, 0.07863415f, 0.34744284f, 0.21887781f, 0.20227602f, 
    -0.16096021f, -0.01431034f, -0.00796545f, 0.19989753f, -0.03665837f, -0.20445298f, -0.06405175f, 0.03340009f, 
    -0.06083040f, 0.09720521f, 0.13418262f, 0.00261413f, 0.01783378f, 0.06383681f, 0.15300304f, 0.05477710f, 
    0.09791037f, 0.02349097f, 0.18940783f, -0.01313549f, -0.47300845f, -0.32728365f, -0.24976103f, 0.11546449f, 
    -0.15756159f, 0.08595476f, -0.15564118f, -0.19845863f, -0.14544038f, 0.15515250f, 0.03201103f, -0.10469596f, 
    0.33406192f, 0.09699652f, -0.09888529f, 0.00401040f, 0.12145466f, -0.01071254f, 0.31895763f, -0.02458138f, 
    0.15221913f, -0.04995172f, -0.02084886f, 0.11784028f, 0.09994995f, 0.08839543f, 0.00768987f, 0.22627747f, 
    -0.09394757f, 0.11869757f, -0.06362832f, 0.10999980f, 0.20949742f, 0.16341817f, -0.07783515f, -0.01901293f, 
    0.09288640f, 0.13297960f, 0.05554437f, 0.15046698f, 0.13442823f, 0.14555781f, 0.05017124f, 0.07377569f, 
    -0.00782073f, 0.17366260f, -0.24366428f, -0.04498263f, -0.08705851f, 0.03878463f, 0.06030919f, 0.01682680f, 
    0.02474599f, 0.14346078f, -0.00932645f, 0.08853123f, 0.28883311f, 0.17477420f, 0.20046002f, -0.08729222f, 
    0.03264011f, -0.16293085f, 0.05801317f, 0.06272689f, 0.12387503f, -0.06999931f, 0.07279526f, 0.22583532f, 
    0.01454971f, 0.62672973f, -0.04098374f, -0.00184161f, -0.02774559f, 0.07953184f, -0.01045114f, -0.07758950f, 
    0.03897749f, 0.05172628f, 0.20670831f, 0.06729762f, 0.18116899f, 0.07332234f, 0.00036527f, 0.19347017f, 
    0.12256519f, 0.10172284f, -0.03495629f, 0.17634571f, -0.21643828f, 0.16252464f, 0.21271375f, -0.08012762f, 
    -0.10066044f, -0.14785501f, -0.06842419f, 0.31702763f, 0.81453168f, 0.02547088f, 0.11974948f, 0.41576713f, 
    0.22249736f, -0.10487381f, -0.27493927f, -0.28003916f, -0.02307383f, 0.09764949f, 0.38242728f, -0.43030909f, 
    0.44905576f, -0.00069744f, -0.83451349f, -0.09587550f, 0.08530853f, 0.26604214f, 0.00596880f, 0.07957125f, 
    -0.21667141f, -0.05702555f, -0.07140141f, -0.05000115f, -0.49721438f, -0.01172937f, 0.12766713f, 0.07987184f, 
    0.06451339f, -0.03303915f, 0.37000334f, -0.16634563f, -0.03048185f, 0.10807682f, -0.36839873f, 0.24146140f, 
    0.11925621f, 0.15736347f, 0.13452938f, 0.29015931f, 0.04253611f, 0.18115740f, 0.11724590f, -0.29515648f, 
    -0.22627521f, 0.18471657f, -0.07569125f, 0.01144428f, -0.05825409f, -0.05816359f, -0.40771449f, 0.13138443f, 
    -0.36856797f, -0.00034465f, 0.04448801f, 0.24093084f, 0.16954052f, -0.11947218f, 0.12157970f, -0.29400072f, 
    -0.04550836f, 0.11410380f, 0.25077850f, 0.50613540f, -0.10277843f, 0.05765782f, 0.05735808f, 0.08991452f, 
    -0.40695888f, 0.06327264f, -0.03039536f, 0.06075445f, -0.20196241f, -0.12510718f, 0.05213584f, 0.14175817f, 
    -0.06061770f, -0.25729012f, 0.29564229f, -0.13590389f, 0.06503467f, 0.05494947f, -0.06494834f, -0.41249019f, 
    -0.02532583f, -0.04109487f, 0.02834392f, -0.03429477f, -0.05633419f, 0.27015787f, 0.10934145f, 0.08677862f, 
    -0.12042843f, 0.04038666f, 0.11251480f, 0.01012255f, -0.12292980f, 0.11486643f, 0.11774287f, -0.13740797f, 
    0.09431937f, 0.36004883f, 0.07489437f, 0.06589557f, -0.03809631f, -0.10921878f, 0.12666865f, 0.01065536f, 
    -0.05254894f, -0.06975517f, -0.20551187f, -0.29936224f, -0.04994585f, 0.16486210f, -0.10637016f, -0.04560164f, 
    0.16272007f, -0.27542150f, 0.16537207f, 0.00896382f, -0.05634450f, -0.24730754f, -0.21015656f, 0.22761807f, 
    -0.35909221f, -0.19674461f, 0.19830501f, 0.24677841f, -0.59452498f, -0.02801509f, 0.12237539f, -0.04134647f, 
    0.16677512f, -0.19742978f, -0.09367526f, -0.12521252f, -0.00453841f, 0.04873037f, -0.09474944f, -0.03500135f, 
    -0.41371858f, -0.10545888f, 0.28504089f, -0.07076287f, -0.03673777f, -0.06325296f, -0.04140036f, 0.05980936f, 
    0.38429943f, 0.01345651f, 0.18756163f, -0.21124423f, 0.12001034f, -0.01028758f, 0.16055502f, 0.26573354f, 
    -0.02729508f, 0.06620820f, 0.14420111f, -0.38837972f, 0.05038555f, -0.00450506f, -0.24535827f, -0.15148130f, 
    0.11357333f, 0.19924656f, 0.04487891f, -0.44149479f, 0.04053748f, -0.02795850f, 0.03567837f, 0.08934450f, 
    -0.18891110f, 0.18806973f, 0.04024822f, -0.03913122f, -0.04696235f, -0.02109503f, -0.06774636f, -0.00450445f, 
    -0.18590945f, 0.15329358f, 0.06559442f, 0.11995280f, 0.09659630f, 0.21601278f, -0.00863615f, -0.27784467f, 
    -0.17771670f, 0.06887623f, 0.00660051f, -0.38727498f, 0.12891713f, 0.06589302f, 0.02196512f, -0.00039910f, 
    -0.12548068f, 0.07384289f, 0.04785952f, 0.24256134f, 0.06452075f, 0.01087845f, 0.02296446f, -0.02663681f, 
    -0.00437972f, -0.10914235f, 0.02876830f, 0.01629779f, 0.17771167f, -0.06910060f, -0.07781994f, 0.21642143f, 
    0.09854358f, 0.12709711f, 0.07550721f, 0.07301199f, -0.00670870f, 0.17285338f, -0.18797776f, 0.09209371f, 
    0.10076646f, 0.07853926f, -0.02493575f, -0.16722532f, -0.20086312f, 0.11103197f, -0.13518004f, 0.21807116f, 
    0.15039411f, -0.83618414f, -0.06314848f, 0.06207458f, 0.12895441f, -0.13691474f, -0.02739291f, 0.13296595f, 
    -0.05614798f, 0.17368917f, 0.15544979f, 0.18826739f, 0.16522127f, 0.24984796f, 0.10474401f, -0.08426969f, 
    0.22478202f, -0.03434625f, 0.15056206f, 0.00442365f, -0.12310582f, 0.00522745f, 0.01010616f, -0.06163779f, 
    -0.01775028f, -0.04399200f, -0.04650922f, -0.02712487f, 0.01262258f, -0.02227986f, -0.05414118f, -0.06511831f, 
    -0.02464525f, -0.02239606f, -0.05095884f, -0.02404909f, 0.04184461f, 0.06802608f, 0.04259466f, -0.06175524f, 
    -0.02611624f, 0.01661159f, -0.04752637f, 0.00965603f, -0.00731063f, -0.03705531f, 0.03560042f, -0.03851950f, 
    -0.08646566f, -0.02838600f, -0.04143975f, 0.07478132f, -0.07207672f, 0.02138899f, 0.00751278f, 0.04987273f, 
    -0.07597523f, 0.03177547f, 0.06280928f, 0.00652805f, 0.00477498f, 0.06253020f, -0.04265042f, -0.04053725f, 
    0.06910945f, -0.06897347f, -0.03482353f, 0.00921753f, -0.03771126f, -0.08424585f, 0.05105477f, -0.00919716f, 
    0.07911667f, -0.06330612f, -0.07238101f, 0.06090819f, -0.08219942f, -0.04976241f, -0.07109270f, 0.05519194f, 
    0.03817208f, -0.00721484f, 0.08072245f, 0.00819599f, -0.06885172f, 0.02738283f, -0.00878457f, -0.07279466f, 
    0.03301446f, -0.02520203f, 0.03533949f, 0.07573242f, -0.03467244f, -0.03172365f, -0.04913840f, 0.02433816f, 
    -0.03925714f, 0.04677438f, -0.09248159f, -0.05660011f, 0.01613663f, -0.05676592f, 0.01794515f, -0.05162480f, 
    0.00841076f, -0.06767630f, -0.05321991f, -0.07304692f, -0.08385733f, -0.03197692f, -0.00849742f, 0.07400445f, 
    -0.06896413f, -0.04488947f, -0.03522529f, 0.00915817f, -0.08421885f, 0.08802854f, -0.01933892f, -0.04394868f, 
    -0.08223607f, 0.00579046f, 0.01841753f, -0.04795415f, -0.00314171f, -0.03519737f, 0.08349460f, 0.02993654f, 
    -0.05926239f, -0.00603274f, 0.07003602f, -0.01100627f, -0.06701233f, 0.03480286f, -0.00668180f, 0.04154381f, 
    0.08168431f, -0.00638207f, -0.07046688f, 0.07091089f, -0.09035705f, 0.06425500f, -0.06782642f, 0.01727538f, 
    0.01868285f, 0.02309156f, 0.02639222f, -0.04409891f, 0.06359837f, 0.03783562f, 0.06395084f, -0.09025601f, 
    0.36790168f, 0.19246545f, 0.13557120f, 0.06065242f, -0.15485437f, 0.00587879f, 0.00605704f, -0.36051849f, 
    0.07732362f, 0.05143644f, -0.22446214f, 0.02762861f, -0.07318676f, 0.20907028f, 0.00934271f, 0.07949786f, 
    0.16358759f, -0.08251616f, 0.19925439f, 0.11299692f, -0.01826144f, -0.22851548f, -0.05452743f, -0.04166675f, 
    0.15102702f, -0.06557940f, 0.16494443f, -0.04915170f, -0.03542968f, -0.00627508f, 0.15617852f, 0.20249088f, 
    -0.15463150f, -0.02574969f, 0.18881358f, -0.23846243f, -0.38014597f, -0.23192167f, -0.53582352f, 0.07214617f, 
    -0.07589467f, 0.45504642f, 0.00550494f, 0.05036352f, -0.02191491f, 0.05059523f, 0.02112649f, -0.03510383f, 
    -0.09585907f, 0.04007906f, -0.08695556f, -0.05959751f, 0.02412791f, -0.09299558f, 0.11830109f, 0.01591169f, 
    -0.03461617f, -0.03442976f, 0.13485727f, -0.00454291f, 0.06471974f, 0.13568136f, -0.03923723f, -0.10885577f, 
    -0.16443440f, 0.08486659f, 0.01864463f, 0.41594756f, 0.09787399f, 0.15268509f, -0.01100836f, -0.01214918f, 
    -0.05709365f, -0.00813190f, 0.09254070f, 0.19028078f, -0.06122591f, -0.06919523f, -0.06790307f, 0.15434070f, 
    0.00560603f, 0.10826188f, -0.15500763f, -0.00768112f, 0.05832345f, -0.08328579f, 0.04948354f, 0.12378982f, 
    0.02057044f, 0.07912510f, -0.02340904f, -0.03689977f, 0.13940760f, 0.09341784f, 0.02587126f, 0.24660447f, 
    0.05984931f, -0.18381056f, -0.05792065f, -0.03835556f, -0.02251140f, 0.11722027f, 0.06099349f, 0.27841821f, 
    0.02757712f, 0.47279987f, -0.05397189f, -0.00731420f, -0.29666746f, 0.06958697f, -0.19111718f, -0.19381258f, 
    -0.03898603f, 0.08803432f, 0.09368704f, 0.02823434f, 0.07700631f, 0.06808059f, 0.19550404f, 0.08271357f, 
    0.15956959f, 0.10149882f, 0.14717582f, 0.01882652f, -0.28851125f, 0.16377443f, 0.12576739f, -0.31310040f, 
    0.00674221f, 0.05154084f, -0.09331933f, 0.11617054f, -0.08694890f, 0.04209837f, 0.20823905f, 0.13068575f, 
    0.09539082f, -0.09708982f, 0.16187298f, 0.00567186f, -0.08824337f, -0.01888656f, -0.00713610f, 0.29870945f, 
    -0.27489141f, -0.04855545f, 0.09960444f, -0.05366042f, -0.12188838f, -0.19197990f, 0.05448495f, 0.04353021f, 
    -0.14021198f, 0.00919837f, -0.09447104f, -0.18073481f, 0.07292480f, -0.01929498f, 0.24225512f, -0.01488980f, 
    -0.06535909f, -0.09162933f, 0.01670275f, -0.25183621f, 0.15437265f, 0.07647794f, 0.03081875f, -0.07837812f, 
    -0.09477083f, 0.16942829f, -0.04278117f, -0.11168157f, 0.17486562f, 0.18882436f, 0.03031398f, -0.10441242f, 
    -0.01355925f, 0.16629054f, 0.10446831f, -0.05436377f, -0.10338505f, 0.07271821f, 0.11762719f, 0.25887057f, 
    -0.10822620f, 0.07818465f, 0.13614942f, 0.06343919f, 0.06915574f, 0.11534749f, 0.08663878f, -0.04499278f, 
    -0.20727313f, 0.05812749f, 0.04345154f, -0.10962150f, 0.15221459f, -0.07803801f, -0.04582604f, 0.00742623f, 
    -0.12588255f, -0.06961170f, 0.23851477f, 0.03318189f, 0.05052844f, 0.20092386f, 0.05635987f, 0.10120615f, 
    -0.01013487f, 0.10302111f, 0.03894388f, -0.17157266f, -0.19542204f, -0.05672053f, -0.03280393f, 0.19557749f, 
    0.13012472f, -0.04350751f, 0.19277689f, -0.05074102f, -0.08758795f, 0.17361425f, 0.04125710f, 0.09846566f, 
    0.13499036f, 0.07724374f, -0.36676303f, 0.13455933f, 0.05487084f, 0.00158369f, -0.10312204f, 0.24623230f, 
    0.00552149f, 0.18985792f, -0.03298215f, 0.03487420f, 0.02534885f, -0.01408325f, 0.02702764f, -0.20889169f, 
    0.01757642f, -0.04431415f, 0.34381071f, 0.16348548f, 0.10112712f, 0.20585646f, 0.26374492f, -0.17004599f, 
    -0.17469794f, -0.17542891f, -0.05394777f, 0.33607680f, 0.21773039f, -0.28100514f, 0.23954016f, 0.11287446f, 
    0.28136322f, 0.10250636f, 0.11720707f, -0.08891350f, -0.47438827f, 0.04009068f, 0.07307352f, -0.47932351f, 
    -0.07114322f, 0.04012431f, -0.01162101f, 0.14273292f, -0.05494473f, 0.19154672f, 0.09392380f, 0.43167368f, 
    -0.23744434f, 0.04316426f, -0.21459319f, 0.27644670f, 0.07779787f, -0.09281418f, 0.07439695f, -0.02782189f, 
    -0.03105365f, -0.06657948f, -0.01451090f, 0.13396053f, 0.09729008f, 0.00101334f, 0.09390877f, 0.08484960f, 
    -0.02846968f, 0.15582910f, 0.21285202f, -0.13054465f, -0.22294098f, -0.03617309f, -0.11390544f, -0.11222907f, 
    -0.27038684f, 0.15560508f, -0.13958098f, 0.05452015f, 0.10497814f, 0.13788950f, -0.00324591f, -0.03729250f, 
    0.33413297f, -0.10644846f, -0.11993334f, 0.03377078f, 0.08781241f, 0.04078310f, 0.31913003f, 0.03770860f, 
    0.18148035f, 0.08027933f, -0.22211154f, -0.01598570f, -0.20803539f, -0.02172858f, 0.01506114f, 0.17322999f, 
    0.05495548f, 0.07295276f, 0.09145287f, -0.43477911f, 0.17212860f, -0.28710514f, 0.07703810f, -0.01540036f, 
    0.12802806f, 0.24192804f, 0.13960096f, -0.01638941f, 0.23818517f, 0.22938628f, 0.05133037f, -0.29367298f, 
    0.05760726f, 0.09983201f, -0.19914770f, -0.02237809f, 0.11057486f, -0.10065512f, 0.18246490f, 0.05006941f, 
    -0.02490727f, 0.28572732f, -0.10596160f, 0.19215749f, 0.30524606f, 0.08909198f, 0.11604019f, 0.03791850f, 
    -0.00320645f, -0.07323385f, 0.05495117f, -0.14400947f, 0.05757541f, 0.02703966f, 0.04841893f, 0.38426930f, 
    -0.10762531f, -0.04476256f, -0.04549352f, -0.06642867f, -0.00758658f, -0.00640531f, -0.06089175f, -0.24517307f, 
    0.00538422f, 0.02704180f, -0.14527436f, 0.00746815f, 0.27156731f, 0.02628717f, 0.11839081f, 0.06473851f, 
    -0.15287562f, 0.02862956f, 0.01583044f, 0.10205447f, -0.12696280f, -0.22350684f, 0.36589658f, -0.32896534f, 
    -0.16442497f, -0.23917535f, 0.06081748f, -0.06688389f, -0.07436617f, -0.00256475f, -0.02914196f, 0.36677709f, 
    0.10035727f, -0.16266797f, -0.07763026f, -0.29391316f, 0.04911021f, -0.00476590f, -0.21698999f, 0.26214549f, 
    0.18124519f, -0.10325664f, -0.01405262f, -0.20701692f, 0.09582266f, -0.46871829f, 0.07932443f, -0.05830372f, 
    0.43348104f, 0.05311855f, 0.33321750f, -0.40406224f, 0.10010473f, -0.04049949f, 0.05887131f, -0.12941772f, 
    0.10186095f, -0.07379287f, -0.02709824f, -0.41724142f, 0.14601684f, 0.12078009f, -0.32629785f, 0.06466623f, 
    0.01300065f, 0.17700705f, 0.03759716f, -0.40553898f, 0.08776495f, 0.01436424f, 0.10380788f, -0.10082375f, 
    -0.03403050f, 0.12993386f, -0.06439373f, 0.05652536f, 0.01421303f, -0.01519753f, 0.31025770f, -0.11452155f, 
    0.13362397f, -0.14894187f, 0.21165714f, 0.22855505f, 0.25628188f, 0.06585737f, -0.09480556f, -0.03279219f, 
    -0.30204567f, -0.09077200f, 0.18181443f, -0.14090286f, 0.03781255f, 0.12715249f, 0.13261016f, -0.05436505f, 
    -0.42976171f, -0.06236953f, 0.08682532f, 0.18169072f, -0.14563325f, 0.15644021f, 0.00157090f, 0.26555225f, 
    0.05820074f, -0.14749165f, 0.14173925f, -0.28148842f, 0.00928449f, -0.28855354f, -0.14087056f, 0.33787635f, 
    0.24739125f, -0.06841324f, 0.03848009f, -0.28042561f, 0.34685707f, -0.16271204f, -0.19583267f, -0.18556954f, 
    0.00444132f, 0.43276507f, -0.06357729f, 0.16754875f, -0.30176023f, -0.07796756f, 0.04075271f, 0.03483452f, 
    -0.02414336f, 0.00535873f, 0.04363330f, 0.03663236f, 0.04675955f, 0.00712245f, -0.21316242f, 0.48344034f, 
    -0.07965481f, 0.04522572f, 0.56933099f, 0.28434706f, 0.04862000f, 0.21863690f, 0.08447696f, -0.25584087f, 
    0.27400878f, -0.04623822f, 0.10834047f, 0.13166861f, -0.07184324f, -0.54351324f, 0.10498667f, 0.30121273f, 
    -0.01635313f, 0.04698683f, 0.19429679f, -0.13583343f, -0.12012088f, 0.06584031f, -0.22426507f, -0.20645320f, 
    -0.16755375f, 0.16141234f, -0.13425198f, 0.08050385f, -0.00711309f, 0.34879547f, 0.02806607f, -0.06806126f, 
    0.15323332f, 0.08047330f, -0.08722700f, 0.19184759f, 0.06971665f, -0.15190133f, -0.05359354f, 0.06512041f, 
    -0.29223302f, -0.02299310f, 0.16496733f, 0.13847166f, -0.13013716f, -0.05904903f, 0.04699926f, -0.01144850f, 
    0.31931341f, 0.38049665f, 0.15778428f, 0.45505756f, -0.07048040f, 0.01307527f, 0.17110100f, 0.14392920f, 
    -0.05222802f, 0.09290061f, 0.04464743f, 0.34548503f, 0.04264761f, -0.01685013f, 0.06714791f, -0.04204138f, 
    0.21343388f, -0.11820482f, -0.11212935f, -0.07196981f, 0.18213208f, -0.09974485f, -0.03763754f, -0.10288382f, 
    0.15277481f, -0.05667831f, -0.11562840f, 0.09809047f, -0.00266926f, 0.14174643f, -0.05281587f, 0.40066710f, 
    0.14827180f, -0.05818087f, 0.27147454f, -0.26207054f, 0.20794512f, 0.18493395f, -0.01736445f, 0.23368314f, 
    -0.05204483f, 0.10012986f, -0.11506896f, 0.14857867f, 0.01462717f, 0.11185676f, 0.05792196f, -0.30188695f, 
    -0.07314862f, 0.22349425f, -0.16184209f, -0.02150544f, -0.01341923f, 0.26503643f, -0.00707681f, -0.15509620f, 
    -0.06630183f, 0.22442332f, -0.09176651f, -0.10142624f, 0.10160732f, -0.19268163f, 0.18287487f, -0.07279536f, 
    0.00450042f, -0.06277667f, 0.05827114f, 0.06666151f, 0.23842154f, 0.04153978f, 0.09286284f, -0.01557852f, 
    0.01842326f, -0.27112713f, -0.04873013f, 0.00620312f, 0.06972323f, 0.03317693f, 0.06366197f, 0.26261881f, 
    -0.04594026f, 0.08179777f, -0.24007444f, -0.05480852f, 0.08209455f, -0.08563486f, -0.09845165f, 0.38621849f, 
    -0.16801868f, 0.09073728f, -0.20488870f, -0.00730553f, 0.04813637f, -0.00372275f, 0.13554314f, -0.04196363f, 
    0.06705757f, -0.05726563f, -0.07833958f, 0.02551779f, 0.04920126f, -0.05569661f, -0.09715642f, -0.05966721f, 
    -0.03659771f, 0.05254961f, -0.05081831f, -0.10008382f, -0.08741891f, 0.00408649f, 0.06755923f, -0.03530893f, 
    -0.06043480f, -0.02529218f, 0.07304766f, -0.00537949f, -0.03201102f, 0.01252398f, 0.06224281f, 0.03160007f, 
    -0.00167926f, -0.05228255f, -0.08127077f, -0.00273390f, -0.00845403f, -0.05319044f, 0.05329897f, 0.04603847f, 
    -0.01522637f, 0.04206842f, 0.02951058f, 0.06904435f, -0.02060313f, -0.08773633f, 0.00624883f, -0.06041938f, 
    -0.07376865f, -0.08667769f, -0.05513823f, -0.03539629f, -0.08657284f, 0.00931613f, 0.05129463f, -0.02113931f, 
    0.01115512f, -0.07240561f, 0.00774664f, -0.02578662f, 0.07339696f, -0.03648933f, -0.07330123f, 0.01520737f, 
    0.07137573f, -0.00314357f, 0.05942450f, 0.01330805f, 0.08381706f, -0.03262791f, 0.03758403f, 0.04057142f, 
    -0.03252763f, -0.00589743f, -0.00813722f, -0.06293409f, 0.02088145f, -0.02088359f, -0.05928751f, -0.06210311f, 
    0.03195849f, -0.04286269f, -0.00441804f, -0.09542418f, -0.05567192f, -0.02346533f, 0.06212603f, -0.07922558f, 
    0.01927283f, -0.00510598f, -0.08827226f, 0.05271048f, -0.08782774f, -0.04605474f, -0.09580834f, 0.04067018f, 
    -0.06542413f, -0.08132620f, -0.00672029f, -0.05487902f, -0.03993642f, -0.06636569f, -0.06779829f, -0.06861442f, 
    0.02915787f, -0.00942668f, 0.03876937f, -0.00399502f, 0.04199144f, -0.08110248f, 0.06375571f, -0.03289237f, 
    -0.04393129f, -0.07370462f, -0.08245441f, 0.03705491f, 0.02557919f, 0.04843654f, 0.06025701f, 0.05298594f, 
    -0.04295693f, -0.06097446f, -0.06007487f, -0.03503166f, -0.01972082f, -0.06127516f, 0.03600735f, -0.02969240f, 
    -0.02020314f, -0.03278381f, 0.03428467f, -0.02092336f, -0.06561840f, 0.07026119f, 0.01916109f, 0.04089661f, 
    -0.07830932f, 0.01394499f, -0.06890516f, -0.01109994f, 0.01532791f, 0.02820391f, -0.02440502f, -0.00876381f, 
    -0.08846934f, -0.02824329f, -0.06819507f, -0.01588082f, -0.05090592f, -0.07362431f, -0.07996478f, 0.06265831f, 
    0.03979323f, -0.02388967f, 0.01189454f, -0.10045194f, 0.05525284f, 0.03652142f, 0.01673770f, -0.07690497f, 
    0.00540555f, -0.04580441f, 0.00258336f, 0.00253988f, 0.03860398f, -0.03975252f, -0.07310759f, 0.06326245f, 
    0.04698236f, 0.01860716f, 0.05691759f, -0.01289756f, 0.05712707f, 0.00529124f, -0.00843434f, -0.06556610f, 
    -0.09131299f, 0.00377074f, -0.06868583f, 0.01139682f, -0.03163939f, -0.02278734f, -0.01950715f, 0.04665167f, 
    -0.03975768f, -0.02016984f, 0.05228684f, -0.04314474f, 0.04857061f, 0.03919113f, 0.01165588f, 0.00614163f, 
    0.07602528f, 0.04666470f, -0.02519218f, 0.03326682f, 0.00994126f, 0.00157359f, 0.02791089f, -0.05487542f, 
    -0.07511081f, -0.03674674f, 0.07170168f, 0.01561634f, -0.04245061f, 0.07122294f, 0.01944287f, -0.04932096f, 
    -0.06038141f, -0.05161995f, -0.00865042f, -0.04370669f, 0.04488984f, 0.00016220f, -0.06261809f, 0.07258229f, 
    -0.05588040f, -0.04445163f, 0.00177973f, -0.09009439f, -0.03568688f, -0.05207879f, -0.08225071f, -0.04396638f, 
    -0.03555318f, -0.00627528f, -0.07650064f, -0.05363036f, -0.06728078f, -0.03508110f, -0.02078454f, 0.06734303f, 
    0.01266135f, -0.08573524f, 0.07998159f, -0.07186138f, -0.02233306f, 0.07996341f, -0.03280287f, -0.01076500f, 
    -0.08931329f, -0.01200975f, -0.05410689f, 0.01694560f, 0.06224376f, -0.04877779f, 0.02876737f, -0.03383171f, 
    0.01330194f, -0.01740290f, -0.07651936f, -0.07631254f, -0.07973600f, 0.02564210f, 0.06391059f, -0.04597577f, 
    -0.04875376f, -0.11020630f, -0.06634412f, -0.01853829f, -0.06928298f, 0.04448421f, -0.00468049f, -0.01011945f, 
    -0.14130831f, 0.14768274f, -0.08848638f, 0.14134583f, 0.83894587f, 0.07406561f, 0.16494581f, 0.29188773f, 
    0.01618868f, 0.09958737f, 0.35191628f, 0.01808943f, 0.01042843f, -0.02808162f, 0.03122648f, -0.17867437f, 
    0.04708988f, -0.03949403f, -0.15589024f, -0.04482216f, 0.03449320f, -0.06179894f, -0.07298167f, -0.01715540f, 
    -0.31451210f, -0.02060353f, -0.01214346f, 0.14371701f, 0.12349334f, -0.01786103f, 0.15381524f, -0.24713330f, 
    0.11739262f, 0.03441676f, -0.11521129f, 0.67559808f, 0.12171037f, 0.11833951f, 0.19079578f, 0.04071603f, 
    0.02670416f, -0.03749088f, 0.01443483f, 0.12823310f, -0.06704870f, 0.08729797f, -0.04091819f, -0.15422679f, 
    0.21368389f, -0.04907470f, -0.08338007f, -0.04313209f, 0.02982704f, -0.05124607f, -0.12653312f, 0.20588256f, 
    0.03509124f, -0.11972113f, -0.04809003f, 0.12967059f, -0.22690737f, -0.16400634f, 0.28855339f, 0.49308455f, 
    0.17885695f, 0.03169848f, -0.04771605f, 0.64860851f, -0.09891107f, 0.05067034f, 0.03346039f, 0.09937654f, 
    -0.05698221f, 0.16384874f, 0.08489362f, -0.03950160f, -0.04964779f, 0.12017997f, 0.05391217f, 0.29057100f, 
    -0.08435199f, 0.28585637f, 0.09967631f, -0.11152934f, -0.32415599f, 0.16380323f, -0.12786117f, -0.08296638f, 
    0.00661807f, -0.11096244f, -0.07561340f, -0.05638125f, -0.16667162f, -0.13924178f, 0.12880702f, -0.12087409f, 
    0.02873736f, 0.18025587f, 0.06328231f, 0.23665670f, 0.26924637f, -0.03265942f, 0.10187011f, -0.14443295f, 
    0.14726566f, 0.13784894f, -0.08177010f, 0.02582628f, 0.40292582f, 0.06477669f, 0.21400011f, 0.04797757f, 
    -0.09973910f, -0.16576493f, 0.12041914f, -0.07906195f, 0.14107212f, 0.11637134f, -0.04849067f, 0.00280933f, 
    0.13513444f, -0.23753637f, -0.06410117f, -0.07153909f, 0.03811738f, 0.38791344f, 0.04362925f, 0.64118487f, 
    0.03687815f, 0.09229203f, -0.08999114f, -0.06095544f, -0.08767017f, -0.02692151f, 0.02869792f, -0.03809741f, 
    0.03735027f, -0.02445394f, -0.11847835f, -0.07066570f, -0.01963901f, -0.11790338f, 0.03125089f, 0.00008005f, 
    -0.04541562f, -0.05573572f, -0.03609731f, -0.11204831f, -0.10832339f, -0.03384426f, -0.05941647f, -0.02901731f, 
    -0.02592684f, 0.01058775f, 0.04931412f, -0.04070443f, -0.06567842f, 0.00500961f, -0.02163318f, -0.11340301f, 
    -0.03120130f, 0.02121549f, -0.08113914f, -0.13620110f, 0.05046505f, -0.03834642f, -0.02041500f, 0.08590639f, 
    -0.00504931f, -0.02281699f, -0.02448692f, -0.06951447f, -0.04724572f, -0.10553191f, -0.08379447f, -0.14506862f, 
    -0.02897881f, 0.01774402f, -0.09389950f, -0.07721776f, -0.03529166f, 0.01898863f, -0.03342539f, -0.02890595f, 
    0.06523917f, -0.08354571f, -0.09014579f, -0.04834772f, -0.09467177f, 0.02468009f, -0.05637370f, -0.00373273f, 
    0.01564817f, -0.00699466f, -0.08347004f, 0.03481197f, 0.06658691f, -0.08077621f, -0.08628552f, 0.01708094f, 
    -0.01985730f, -0.03999416f, -0.06843828f, -0.11919711f, -0.06998559f, 0.04180412f, -0.03423651f, -0.01692655f, 
    0.04405962f, -0.03067170f, -0.02662726f, -0.08933882f, 0.02633654f, -0.04459094f, -0.11928058f, 0.00907730f, 
    -0.10441571f, -0.02671549f, -0.12348502f, -0.00434045f, 0.02504157f, -0.08381934f, -0.09821430f, -0.08322512f, 
    -0.01738809f, -0.05426044f, -0.01808956f, 0.08982076f, -0.08437183f, 0.00750924f, 0.04407177f, 0.02277706f, 
    -0.07973007f, 0.07640194f, 0.05711953f, 0.05449524f, -0.08592664f, -0.10718226f, -0.11514010f, -0.01904791f, 
    0.06708505f, -0.09431691f, 0.00122547f, 0.06958438f, -0.08025156f, 0.03727291f, 0.02298410f, -0.07380024f, 
    -0.04271945f, -0.08172596f, -0.04237330f, -0.01149014f, -0.09229433f, -0.10910638f, -0.03198498f, -0.00678503f, 
    0.02327338f, -0.00673951f, -0.06561321f, -0.01849081f, -0.04508794f, -0.01441005f, 0.05530713f, 0.03076337f, 
    0.03888378f, 0.00737067f, 0.01668976f, 0.05880029f, -0.01162240f, 0.01004107f, -0.02246984f, -0.04024721f, 
    0.03577590f, 0.02966667f, -0.05551890f, 0.03130504f, 0.05875239f, -0.03812925f, -0.06570740f, -0.03698581f, 
    0.07345644f, -0.08195229f, -0.01999041f, -0.06973188f, 0.00658218f, 0.02017742f, -0.06493470f, 0.03727783f, 
    -0.01104802f, -0.07727531f, -0.07646696f, -0.07444091f, -0.06245264f, -0.09419018f, 0.02974719f, -0.08145657f, 
    -0.05339685f, -0.02558327f, -0.09563529f, -0.05627711f, -0.03653582f, -0.08802925f, 0.02767068f, -0.09776230f, 
    -0.03896291f, -0.08586868f, -0.09224658f, 0.02211832f, -0.03233016f, 0.06149593f, 0.02590168f, -0.00903375f, 
    -0.08124980f, -0.07280389f, -0.05255055f, -0.01742021f, 0.02213081f, -0.10392915f, 0.00638880f, 0.02906666f, 
    -0.05819497f, 0.05218137f, -0.08691027f, -0.03202731f, -0.08722654f, -0.04923606f, -0.08555751f, -0.04178092f, 
    0.02987607f, -0.08396399f, -0.12030889f, 0.05524998f, -0.10562838f, 0.03921407f, -0.04424889f, -0.08194735f, 
    0.05848759f, -0.11389371f, -0.03044216f, 0.03488546f, -0.03033111f, 0.08493238f, -0.00455224f, -0.08816268f, 
    0.00593717f, -0.11130084f, -0.11388190f, 0.03718983f, -0.00295664f, -0.10734440f, -0.03256344f, -0.13106570f, 
    -0.07102951f, 0.03573075f, 0.01272681f, -0.03725540f, 0.03434940f, 0.01699118f, -0.07698525f, -0.11061721f, 
    -0.05609242f, 0.00360346f, -0.01505423f, 0.03901071f, -0.00078181f, -0.11676271f, 0.00111079f, -0.08831360f, 
    -0.02692401f, -0.08357806f, -0.02868029f, -0.04538905f, -0.10133439f, -0.00290808f, 0.04033571f, -0.02224841f, 
    0.05560216f, -0.04948187f, -0.03446178f, -0.11233774f, -0.00182665f, 0.01010697f, -0.11417093f, 0.02983539f, 
    0.02527519f, 0.11217146f, -0.03179331f, 0.00824666f, 0.30484778f, 0.14123836f, -0.00482921f, -0.32320246f, 
    0.16354835f, -0.01756941f, -0.16762000f, 0.01333358f, 0.06352887f, 0.24221960f, -0.17033072f, 0.02122052f, 
    0.05457330f, -0.02156789f, -0.49816203f, -0.04983714f, 0.08300406f, 0.01137722f, 0.00869355f, -0.01324610f, 
    -0.37851331f, 0.03501035f, 0.11203006f, 0.01936704f, 0.09935930f, -0.00557398f, 0.13742219f, 0.13343981f, 
    -0.00745210f, 0.12089333f, -0.02660960f, 0.07100780f, -0.31487319f, -0.29528034f, -0.06645107f, -0.09471906f, 
    -0.26151818f, 0.01802215f, -0.18365195f, -0.26123521f, -0.26596135f, 0.24066605f, -0.04705822f, 0.03063441f, 
    0.14397976f, -0.04254904f, 0.15573280f, -0.03564696f, 0.07936559f, 0.00187469f, 0.20629150f, -0.06157416f, 
    -0.14246783f, -0.08550774f, 0.06542251f, -0.13602476f, 0.60333556f, 0.09916448f, 0.04728166f, -0.11959201f, 
    -0.02846969f, 0.15102991f, -0.28710511f, 0.28742534f, 0.01561873f, 0.34679958f, -0.01962757f, -0.14910489f, 
    -0.29354808f, 0.00872517f, 0.20539068f, 0.06675375f, -0.12774971f, 0.14117947f, 0.02947801f, 0.15113458f, 
    -0.04173499f, -0.08023519f, -0.06659191f, -0.06326822f, -0.02789832f, -0.01363739f, -0.02735931f, 0.40631685f, 
    0.17075610f, -0.14710400f, 0.03664867f, 0.07745337f, -0.04849142f, -0.10157306f, 0.00659393f, 0.17176902f, 
    0.04614486f, -0.01498964f, 0.11892744f, 0.23345980f, -0.06384436f, 0.13740762f, -0.01732071f, 0.10686911f, 
    0.04836325f, 0.52334541f, -0.05333833f, 0.02888986f, -0.11686712f, -0.02155170f, 0.06693465f, -0.21051539f, 
    -0.07442651f, 0.11183815f, 0.39054880f, 0.01444844f, 0.00671824f, -0.04920002f, 0.25523216f, -0.02230551f, 
    0.03965379f, -0.03527879f, 0.10709959f, 0.01596127f, -0.15317640f, 0.60243696f, -0.11562319f, 0.22530621f, 
    -0.05397736f, 0.07038163f, -0.07910334f, 0.06641813f, 0.00014682f, 0.02321977f, -0.09064969f, 0.03227537f, 
    0.01991462f, -0.02208314f, 0.03403412f, 0.02673682f, -0.07703024f, -0.04410964f, -0.08488837f, 0.02769986f, 
    0.05001183f, 0.03488640f, -0.02927353f, 0.03470913f, 0.00544430f, 0.02226188f, 0.04274697f, 0.01104444f, 
    -0.02265449f, 0.06340358f, 0.01666016f, -0.01959607f, 0.03134897f, -0.07502083f, 0.02561141f, 0.05382851f, 
    -0.00734168f, -0.05335708f, -0.06841052f, -0.02571924f, -0.04551404f, -0.04690752f, 0.02144458f, -0.00991352f, 
    0.04337451f, 0.02202109f, 0.00313889f, -0.00664070f, -0.08600695f, 0.01632049f, 0.01554603f, -0.02860196f, 
    0.03551938f, 0.02583730f, -0.09952020f, 0.02348388f, -0.04514592f, 0.00170311f, 0.06702974f, -0.02837773f, 
    -0.02325508f, -0.07327869f, -0.01137586f, 0.00858248f, -0.08766986f, -0.04389799f, 0.01281748f, 0.07418428f, 
    -0.09767745f, -0.08203887f, -0.08817195f, 0.00717436f, 0.05325220f, 0.04104574f, -0.00731555f, -0.08041994f, 
    0.05129881f, -0.02113932f, -0.03796228f, -0.00660634f, 0.06574546f, -0.06945607f, -0.04758072f, 0.04577703f, 
    -0.08327518f, -0.05462072f, -0.09327294f, -0.02224538f, -0.09094317f, -0.01979665f, 0.03303158f, -0.08880325f, 
    -0.05876386f, 0.02246359f, -0.03599416f, -0.09611356f, 0.00342401f, 0.00879915f, -0.00525863f, 0.05418120f, 
    -0.01666571f, 0.02220070f, 0.04204367f, -0.06642948f, -0.03599626f, -0.02337519f, 0.07565372f, 0.04546618f, 
    0.00462751f, -0.03490184f, 0.01911727f, 0.02204253f, -0.00813857f, -0.00070442f, -0.05727983f, 0.06513350f, 
    -0.06078035f, -0.06829946f, -0.06096665f, 0.03677292f, 0.03614029f, 0.04681783f, 0.08660930f, 0.00837034f, 
    0.04792387f, -0.09955148f, -0.04710640f, 0.06122107f, 0.07653751f, -0.05873562f, -0.07148468f, -0.06170875f, 
    -0.47516042f, -0.02977142f, 0.17928387f, 0.06341739f, 0.11344569f, 0.00755576f, -0.00345008f, 0.16292763f, 
    0.00218661f, 0.04530584f, 0.14910348f, -0.10460400f, 0.00335744f, 0.03778006f, -0.44765216f, 0.40865779f, 
    -0.13771543f, -0.01669915f, -0.16063572f, 0.04918424f, 0.11506266f, -0.09619962f, 0.06699923f, -0.01811527f, 
    -0.07559724f, 0.01246208f, 0.01385771f, 0.04945292f, 0.07321405f, 0.07985893f, 0.11808483f, 0.07011465f, 
    0.10553782f, 0.06770193f, 0.00576207f, -0.15220758f, -0.20340076f, -0.42372617f, 0.00944676f, -0.01610658f, 
    -0.49825129f, -0.00256534f, -0.57050681f, -0.44596115f, -0.11533657f, 0.26483306f, -0.08122054f, 0.02427466f, 
    0.17872913f, -0.00061824f, 0.05426105f, -0.05031750f, -0.18884115f, 0.08682897f, 0.33526826f, 0.16107191f, 
    0.02411175f, -0.13201475f, -0.03462426f, 0.13471298f, 0.31542918f, 0.13920417f, -0.00230945f, 0.21747115f, 
    0.01410369f, 0.07696802f, -0.13342345f, -0.12228718f, 0.11396939f, 0.01844518f, -0.05977375f, -0.13432591f, 
    -0.03365765f, 0.07390545f, 0.14080210f, 0.26372713f, -0.02502188f, 0.32434046f, -0.07230408f, -0.02384262f, 
    -0.06973058f, 0.13032275f, -0.13220938f, 0.03293768f, 0.12732820f, -0.07170200f, 0.04386653f, 0.26655117f, 
    0.30592704f, 0.14553513f, -0.00232744f, 0.15189530f, 0.20816097f, 0.18429661f, 0.04785849f, -0.19481371f, 
    0.08192795f, 0.11014178f, -0.00393733f, 0.06739996f, -0.02758214f, -0.21774961f, 0.02065954f, 0.54481399f, 
    -0.16276345f, -0.24014394f, -0.03619475f, -0.08000102f, -0.01985310f, 0.01152410f, -0.03465031f, -0.20996930f, 
    0.08418621f, 0.01517850f, 0.38976321f, 0.29858515f, 0.05021310f, 0.08036368f, 0.29360160f, 0.07951778f, 
    0.04082713f, -0.05353783f, 0.10001072f, 0.10679068f, -0.03086911f, -0.23863228f, 0.04868459f, 0.15890896f, 
    0.02937065f, -0.10022394f, -0.06204468f, -0.05566129f, -0.02210308f, -0.05246856f, -0.10371771f, 0.04387467f, 
    -0.04986570f, -0.10371764f, -0.00693793f, 0.02864381f, -0.08735628f, 0.03036871f, 0.02571348f, -0.04061326f, 
    -0.08444086f, 0.08724964f, 0.08515245f, -0.01840795f, -0.03350927f, -0.05338636f, -0.08606648f, 0.06015661f, 
    0.02347191f, 0.04544647f, 0.05907120f, -0.05975593f, 0.06275789f, -0.00761095f, 0.02898049f, 0.00013630f, 
    -0.01424576f, -0.08022125f, -0.00494997f, -0.07268356f, -0.02831645f, -0.07320084f, 0.06132385f, -0.07215431f, 
    0.04614487f, -0.11448856f, 0.05192924f, -0.06852125f, -0.05511927f, -0.04401068f, -0.10726668f, -0.06474406f, 
    0.06857956f, -0.06723292f, -0.10079967f, 0.06575479f, -0.07100238f, -0.01677167f, -0.06850699f, 0.02642111f, 
    0.00670010f, -0.03659163f, -0.06220124f, 0.05136379f, -0.03672056f, -0.10751473f, 0.05010300f, -0.03044382f, 
    -0.01482449f, -0.00040574f, -0.06085959f, -0.02814483f, 0.09212928f, -0.01118537f, -0.00061742f, -0.06382257f, 
    -0.01872292f, -0.09467068f, -0.00450512f, 0.07514741f, 0.03772724f, -0.00202336f, 0.06033126f, 0.09936458f, 
    0.06525563f, -0.09539937f, -0.08145239f, 0.05976814f, -0.08803926f, 0.04144218f, 0.03714323f, 0.01497679f, 
    0.05626174f, -0.00130295f, -0.00058937f, 0.05312802f, 0.06856655f, 0.00113911f, 0.01876662f, -0.10328235f, 
    -0.12586114f, 0.03492521f, 0.05939979f, 0.03342458f, -0.03552023f, 0.04412084f, -0.04355385f, 0.09290689f, 
    -0.08771684f, -0.04746741f, -0.06566127f, -0.05582213f, -0.11506410f, 0.03650201f, -0.04408353f, -0.00242960f, 
    -0.02112753f, -0.06293723f, 0.06518500f, -0.03355502f, 0.00947134f, -0.03573060f, -0.04335996f, 0.03314541f, 
    -0.03366876f, -0.09910827f, 0.06176798f, -0.09783430f, -0.09815464f, 0.01857710f, -0.09431784f, -0.07921501f, 
    0.15031499f, 0.03436414f, 0.02161262f, -0.44420683f, 0.24818623f, 0.11296301f, -0.29098904f, -0.05032232f, 
    -0.33217332f, 0.03150455f, -0.23098004f, -0.19950977f, -0.03653706f, 0.23503223f, -0.17615475f, 0.11111423f, 
    -0.25289664f, 0.08762851f, -0.19747733f, -0.07615133f, 0.17432407f, -0.35999385f, -0.03197811f, -0.00812994f, 
    0.21589752f, 0.08400568f, 0.42912132f, -0.31091538f, -0.32254732f, 0.00335493f, -0.13485312f, -0.32942611f, 
    0.27267903f, 0.10811923f, -0.00055558f, -0.04194768f, 0.08240742f, 0.17786880f, -0.03924051f, 0.22073744f, 
    0.19491926f, -0.16828564f, 0.09169012f, 0.18439554f, -0.11144412f, -0.29938737f, 0.13323921f, -0.01843742f, 
    0.22119206f, 0.12224905f, -0.16373554f, -0.01018272f, 0.08088251f, 0.00846861f, 0.11895998f, -0.28244150f, 
    0.43515944f, 0.00485759f, -0.06462324f, 0.19047181f, 0.30376914f, 0.18313506f, -0.35641584f, 0.23741776f, 
    0.16432045f, -0.38081577f, 0.11969177f, 0.05097040f, 0.13518640f, 0.10984536f, 0.00477029f, 0.19508475f, 
    -0.13631907f, 0.17360431f, -0.28756705f, 0.07950508f, -0.18799327f, 0.10036564f, 0.01764185f, -0.02248480f, 
    -0.06801917f, -0.18670245f, -0.14453432f, 0.13214596f, 0.07502504f, -0.02323521f, -0.03293889f, -0.00894037f, 
    0.10587870f, 0.07003815f, -0.20192096f, -0.31385696f, 0.20581137f, -0.59731275f, -0.05872035f, -0.13445327f, 
    0.07460480f, 0.30629283f, -0.36728540f, 0.10648476f, -0.16652955f, -0.00387411f, 0.04733040f, 0.02351006f, 
    -0.05910490f, -0.12515941f, 0.08208584f, 0.08686495f, 0.06886350f, 0.18280692f, -0.06897168f, 0.18458204f, 
    -0.04738807f, 0.00815333f, -0.15768753f, 0.22153188f, -0.19290859f, -0.04384222f, -0.03558328f, 0.27654240f, 
    -0.05499345f, 0.26401126f, -0.52604556f, -0.15100156f, -0.03894119f, 0.16928256f, -0.10737385f, -0.05029910f, 
    0.16589834f, 0.22334360f, 0.13637498f, -0.11442337f, -0.19206475f, 0.17598680f, -0.03296313f, -0.14319587f, 
    -0.03865885f, 0.08590611f, -0.27593434f, -0.07423569f, -0.00022184f, 0.20259309f, -0.07464407f, 0.22396272f, 
    0.02907328f, -0.13252319f, 0.04627865f, 0.00875689f, -0.11066592f, -0.28478727f, 0.06671556f, 0.02132213f, 
    0.18933976f, -0.04599458f, 0.06043809f, -0.06620715f, 0.04883959f, 0.05180416f, 0.20996347f, 0.20610525f, 
    0.01465765f, -0.09571581f, 0.08453103f, -0.18189217f, -0.18964098f, -0.13405323f, -0.45359159f, -0.00401602f, 
    0.05317559f, 0.07114781f, 0.08956520f, -0.02953252f, -0.03960039f, 0.15430477f, 0.03202032f, -0.01794595f, 
    0.00660529f, 0.08103638f, 0.04354221f, 0.04319913f, 0.08339087f, -0.02692470f, 0.19610389f, 0.01634325f, 
    0.14562750f, -0.09536254f, 0.17101994f, -0.01137452f, 0.25764099f, 0.02460726f, 0.00134665f, -0.22450672f, 
    -0.11899786f, 0.12324807f, -0.06720707f, 0.39684737f, 0.08677708f, 0.25949365f, 0.02543791f, 0.00934466f, 
    0.16548017f, -0.12209944f, 0.13329932f, 0.11957572f, -0.11497919f, 0.00869705f, -0.05882561f, 0.27018204f, 
    0.04232604f, 0.02368747f, -0.25584543f, 0.06552307f, -0.12609699f, -0.15498370f, 0.08479058f, 0.23155291f, 
    0.12386216f, -0.02440528f, 0.22567694f, 0.16435029f, 0.33407202f, 0.03668137f, -0.04237956f, 0.27265856f, 
    0.07674644f, -0.18227421f, 0.13595712f, 0.19151914f, -0.05037825f, 0.11892719f, -0.00199233f, 0.41023788f, 
    -0.07311360f, 0.39846185f, 0.03161386f, -0.06065724f, -0.35946110f, -0.03142884f, -0.22404768f, -0.18758430f, 
    -0.03422272f, 0.14119440f, 0.34205487f, 0.01284577f, 0.05735210f, 0.09311900f, 0.19416688f, 0.02972548f, 
    0.11536063f, 0.19693376f, 0.21882372f, 0.08874849f, -0.05011776f, 0.26118913f, 0.19827642f, -0.28331634f, 
    -0.04845205f, 0.03943340f, 0.00362464f, -0.05453415f, -0.02621112f, -0.08820868f, -0.04451202f, -0.05850932f, 
    -0.01291271f, 0.05357278f, -0.03019674f, 0.04310486f, 0.00599251f, 0.01032936f, 0.00112356f, -0.05512679f, 
    -0.06627989f, 0.05386837f, 0.01406608f, -0.04662131f, 0.01774201f, 0.02476778f, -0.02175136f, -0.02374853f, 
    0.07922849f, -0.01976903f, 0.03421407f, -0.06588546f, 0.03957003f, -0.04524754f, -0.00985964f, -0.00840554f, 
    0.02258060f, 0.06726582f, 0.04132438f, 0.00509905f, -0.09339645f, 0.01989145f, -0.05676197f, -0.05154399f, 
    -0.01932704f, 0.01345688f, 0.01781523f, -0.03640122f, -0.09341233f, 0.06025272f, -0.02638562f, 0.00665561f, 
    -0.08099817f, -0.00670308f, -0.01769716f, 0.06070891f, -0.00698559f, 0.03926478f, -0.04141118f, -0.09450530f, 
    -0.05144166f, -0.08210287f, -0.01497032f, 0.05401677f, -0.04917813f, 0.05640258f, -0.03247637f, -0.09197801f, 
    0.11327863f, 0.02380186f, 0.05645688f, 0.06367329f, -0.01968772f, -0.02856104f, 0.02276493f, -0.01185692f, 
    0.03333966f, -0.09905883f, 0.02299915f, 0.05483922f, -0.03360234f, -0.04472511f, 0.08836593f, -0.06107697f, 
    -0.08277538f, -0.09864324f, -0.05756250f, -0.08836494f, -0.07349332f, -0.00702112f, 0.07192103f, -0.01308923f, 
    -0.10000293f, -0.06346755f, -0.07825674f, -0.08956245f, -0.05369011f, -0.07966176f, -0.06559936f, 0.02873955f, 
    -0.08910166f, 0.05676526f, 0.03884889f, -0.01494380f, 0.02519321f, -0.07092536f, -0.06443823f, -0.08679640f, 
    -0.02073043f, -0.02861951f, 0.05748981f, -0.07423293f, 0.06477810f, 0.04701712f, -0.00115595f, 0.04571522f, 
    0.06178136f, -0.06822879f, 0.00338298f, -0.07593510f, -0.00473756f, 0.04930740f, -0.00190788f, -0.02351810f, 
    0.00190276f, -0.08727577f, 0.03303551f, -0.00342576f, -0.03744407f, -0.11696976f, -0.06514191f, -0.00407149f, 
    -0.13436069f, -0.08719604f, 0.09188759f, 0.20897824f, -0.53669131f, -0.03005626f, 0.02842767f, 0.13671309f, 
    0.22821227f, -0.00964290f, -0.07894289f, -0.00608114f, -0.03857182f, -0.13181876f, -0.01180020f, 0.24260122f, 
    0.19144106f, -0.01662504f, 0.45945874f, -0.00143308f, -0.26433247f, -0.12238154f, -0.02332978f, -0.03499043f, 
    0.47937676f, -0.08678276f, 0.11044248f, -0.03249465f, -0.03155187f, 0.00206707f, -0.03815100f, 0.19414543f, 
    -0.00077101f, -0.17025456f, 0.17776799f, -0.57872283f, 0.04729198f, -0.00529477f, -0.25018314f, -0.02398936f, 
    0.03638708f, 0.39917529f, 0.09916344f, -0.33047450f, 0.03412355f, -0.16783024f, 0.06444658f, 0.07756550f, 
    -0.08398309f, 0.12959066f, -0.00372571f, -0.00671076f, -0.01589354f, -0.02790643f, 0.06070226f, 0.28929162f, 
    -0.11185628f, 0.08013427f, 0.07036621f, 0.16582602f, -0.11052961f, 0.00330470f, 0.11875251f, -0.38811132f, 
    0.00539953f, 0.04058881f, 0.14499903f, 0.25395867f, 0.14314808f, -0.17981172f, 0.00823800f, -0.00562845f, 
    -0.23308955f, -0.23570280f, 0.08354790f, 0.14722741f, 0.01924035f, -0.04811491f, 0.04086454f, 0.09439737f, 
    0.06562015f, 0.00397352f, 0.05285682f, -0.06513967f, -0.10208748f, -0.36245778f, 0.04512659f, -0.11903040f, 
    0.01696842f, -0.00102446f, -0.18141013f, -0.02820410f, 0.16620073f, 0.11993320f, -0.09641059f, 0.28118145f, 
    0.15106268f, 0.01808619f, 0.27241042f, -0.00801018f, -0.22530076f, 0.12507254f, -0.13977771f, 0.17140530f, 
    0.15981227f, -0.11180744f, -0.01419989f, -0.03905045f, -0.19564277f, -0.12680863f, -0.04494960f, 0.09814908f, 
    0.03073145f, 0.10616728f, 0.10250639f, 0.03045399f, 0.07618061f, 0.30563548f, 0.04824009f, -0.34359199f, 
    0.27817926f, -0.06681165f, 0.20971611f, 0.11011600f, -0.02519447f, -0.33279890f, 0.10391168f, -0.02160357f, 
    -0.03225888f, -0.03542500f, -0.06674426f, -0.02977007f, -0.06354143f, -0.05494696f, -0.00100083f, -0.01392549f, 
    0.00168159f, -0.04428331f, -0.06991813f, 0.06190707f, 0.01949191f, 0.00794523f, -0.00559669f, -0.01802559f, 
    0.05638838f, -0.01970134f, -0.06081202f, -0.04576056f, 0.00794475f, 0.05494801f, -0.05498503f, 0.00284071f, 
    -0.06038837f, -0.07106225f, -0.08053736f, -0.01966321f, -0.01486005f, -0.00145462f, -0.07123208f, -0.01430127f, 
    -0.06446562f, -0.07385735f, 0.06134447f, -0.03970429f, 0.02242974f, -0.03019533f, -0.04119447f, 0.03845797f, 
    -0.07646149f, -0.04938100f, 0.07897231f, -0.03392490f, 0.03028679f, -0.08780051f, 0.03719757f, -0.08404796f, 
    -0.07565564f, -0.03188459f, 0.08380935f, 0.07689994f, -0.02351971f, 0.03715108f, -0.01045095f, -0.04037799f, 
    -0.04704845f, 0.04451383f, -0.04608583f, 0.05148121f, -0.03480526f, -0.07217565f, -0.07839260f, 0.08476927f, 
    0.07626721f, -0.05241319f, -0.08122687f, -0.07038642f, -0.00754368f, 0.01265658f, 0.06540901f, -0.03491433f, 
    -0.07605476f, -0.04939179f, -0.03517304f, -0.07882882f, -0.08266216f, 0.05196688f, -0.04811060f, -0.03835489f, 
    0.01120364f, 0.07103006f, -0.00205997f, 0.04337376f, -0.06859941f, 0.05746588f, -0.02321499f, -0.04689939f, 
    -0.00251541f, 0.05612279f, -0.04465574f, 0.04496831f, 0.08407563f, -0.05888055f, -0.00753714f, 0.07045349f, 
    -0.03900058f, 0.06303583f, 0.00304862f, 0.00690584f, -0.00434463f, -0.06826971f, 0.07200088f, -0.01770379f, 
    0.03337213f, 0.05158926f, -0.02592917f, 0.01664048f, -0.01366507f, -0.05637100f, 0.04551996f, -0.07930318f, 
    -0.08686615f, 0.06643987f, 0.01104418f, 0.07871936f, 0.00832344f, 0.06890205f, -0.01690585f, -0.01274238f, 
    0.02855269f, -0.07957102f, -0.05668358f, 0.05908488f, 0.06317135f, -0.05671446f, -0.02098222f, -0.05103679f, 
    0.00124452f, -0.09498246f, 0.06538615f, -0.20906271f, -0.57456601f, 0.01905634f, -0.21760185f, -0.26767164f, 
    -0.05606219f, -0.06740319f, -0.13218540f, -0.07275190f, 0.01336917f, 0.04144964f, -0.05575799f, -0.20873529f, 
    0.07761959f, -0.08638468f, -0.06163443f, 0.11597360f, 0.09301243f, 0.04544286f, 0.01883311f, -0.00784947f, 
    -0.02123707f, -0.06593784f, 0.04934742f, -0.13805741f, 0.12822293f, -0.05065145f, 0.02842783f, 0.18099348f, 
    -0.03157585f, 0.17664212f, 0.12701865f, -0.13178609f, -0.19456130f, -0.19041814f, -0.14896083f, -0.22718805f, 
    -0.13477679f, -0.03394764f, 0.03532248f, -0.33940536f, -0.04071603f, 0.10013074f, 0.00816389f, 0.09117309f, 
    0.26309416f, -0.02180867f, 0.07304540f, 0.08440126f, 0.19573674f, 0.06535823f, 0.19133948f, -0.16216183f, 
    0.16549319f, -0.04085741f, 0.00996700f, -0.09495558f, 0.41143200f, 0.09810694f, -0.11098402f, 0.04501234f, 
    -0.30383393f, 0.01924166f, -0.25015265f, 0.07133234f, 0.02961013f, 0.25911006f, 0.04548508f, -0.15532644f, 
    -0.05379723f, -0.10957410f, 0.13331950f, 0.13706581f, -0.21947992f, 0.24222963f, -0.03525700f, 0.06200742f, 
    0.06440422f, -0.02926499f, -0.18069485f, 0.15174899f, 0.06385339f, -0.01578610f, 0.07762606f, 0.29154727f, 
    0.14352120f, 0.02833845f, -0.07580005f, -0.11939390f, 0.23362419f, -0.34196725f, -0.03544067f, 0.03691827f, 
    0.11950482f, 0.01875240f, 0.38390240f, 0.15247500f, -0.01906497f, 0.15211616f, -0.12291972f, 0.05291934f, 
    0.03562831f, 0.09792096f, -0.07561395f, -0.06089250f, -0.07709605f, 0.04719699f, -0.12305839f, -0.02014675f, 
    -0.05609202f, 0.18960345f, 0.50439197f, 0.15183835f, 0.09996767f, 0.04268582f, -0.24625619f, -0.04751920f, 
    0.06226296f, 0.14634044f, -0.05851541f, -0.13594575f, -0.23235762f, 0.38222644f, -0.19159025f, -0.10129884f, 
    -0.00945567f, -0.01533551f, 0.05669055f, -0.02930193f, -0.05599748f, -0.06510586f, 0.06075499f, -0.03623813f, 
    -0.00547947f, 0.05256769f, -0.11490833f, -0.10913420f, 0.04542461f, -0.08088653f, -0.02112987f, 0.02675676f, 
    0.02661589f, 0.06439135f, -0.04608642f, -0.04262432f, 0.03827033f, -0.07359464f, -0.00542209f, -0.05212469f, 
    -0.00309017f, -0.05856293f, -0.06260176f, 0.03554955f, -0.07148621f, -0.05892281f, 0.03727959f, -0.05729768f, 
    -0.04081418f, 0.02631134f, 0.02785931f, 0.00431763f, -0.11209204f, -0.01503935f, -0.01969188f, -0.09140041f, 
    0.02882912f, 0.00615364f, -0.09338291f, -0.00385027f, 0.07899876f, -0.05912308f, -0.00984280f, -0.03250754f, 
    -0.07244534f, -0.08603538f, -0.01410509f, 0.04354928f, -0.04800084f, 0.07494854f, -0.04069183f, -0.01766317f, 
    0.05879806f, -0.01469035f, 0.02293518f, 0.06028371f, 0.03745088f, -0.07468304f, -0.00206641f, -0.00813706f, 
    0.00931309f, -0.01088416f, 0.04072132f, -0.08796901f, -0.03088195f, -0.01365639f, 0.07224640f, -0.04611897f, 
    0.02844972f, 0.07284860f, -0.00599173f, -0.04455108f, 0.04188553f, -0.07413954f, -0.02225798f, -0.07504594f, 
    0.05808010f, 0.07578462f, 0.01583079f, -0.07067502f, -0.04014489f, -0.07081927f, -0.06959800f, 0.00590099f, 
    -0.07553899f, 0.05392300f, 0.04425613f, -0.04919927f, -0.06844195f, -0.00176875f, -0.00798556f, 0.07473703f, 
    -0.10512428f, -0.07217231f, -0.02185249f, 0.01109975f, -0.05523878f, -0.08622456f, 0.02327804f, 0.02044188f, 
    0.04245821f, -0.04065494f, 0.02370629f, -0.01168823f, 0.01074989f, 0.04893804f, -0.01479064f, 0.02201198f, 
    -0.02138112f, -0.02941510f, -0.04740866f, 0.04175577f, 0.05431616f, 0.03833137f, -0.00765763f, -0.08539218f, 
    0.02405510f, -0.08610103f, 0.01984560f, 0.03122158f, -0.07689431f, -0.04230481f, -0.09407339f, -0.03863503f, 
    -0.02971919f, 0.06374810f, -0.03411442f, 0.07863288f, 0.02496539f, -0.01762510f, 0.04805668f, -0.09221295f, 
    -0.05582496f, -0.07508706f, 0.01531109f, 0.01641934f, -0.00596033f, 0.06477968f, -0.04835469f, 0.00453019f, 
    -0.05270240f, -0.00713511f, -0.00531638f, 0.03036469f, 0.03586030f, 0.01407088f, 0.02775555f, 0.01917353f, 
    0.05245911f, 0.05423944f, -0.05093211f, -0.04295819f, 0.04896934f, -0.01862216f, 0.01297098f, 0.02519814f, 
    0.03060467f, 0.06373256f, -0.01509860f, -0.00214706f, -0.04589633f, 0.02674940f, 0.05182350f, -0.04917800f, 
    0.05311331f, 0.00099836f, 0.02622362f, 0.05804750f, -0.09611859f, -0.06604309f, 0.01592895f, -0.00763331f, 
    -0.02344450f, 0.04017298f, -0.11635210f, 0.03830918f, -0.06383495f, 0.01613110f, 0.00111082f, -0.07621387f, 
    -0.01541793f, -0.07728667f, -0.00411554f, -0.03210833f, 0.03859948f, -0.11208973f, -0.03805999f, 0.00643499f, 
    -0.00616081f, -0.00510084f, -0.05851433f, 0.01058270f, 0.02755141f, -0.09664260f, -0.05713001f, 0.00342517f, 
    0.04566589f, -0.05355787f, 0.04730814f, -0.08469603f, 0.02693165f, 0.05419016f, -0.06481355f, -0.07230758f, 
    0.08008982f, -0.03436208f, -0.05471231f, 0.05749715f, 0.02252623f, -0.02322789f, 0.03184221f, -0.01680673f, 
    0.03848863f, -0.06776600f, 0.04683438f, -0.09194077f, -0.07323670f, -0.08548155f, -0.01344626f, -0.02506505f, 
    -0.00168128f, 0.00624482f, 0.00355412f, -0.02511564f, -0.09453067f, 0.04812750f, 0.03100284f, -0.01049775f, 
    0.01443782f, -0.01068131f, -0.05539968f, -0.07115545f, -0.05613782f, 0.02241650f, 0.03647290f, -0.04006604f, 
    -0.01418527f, -0.06751502f, -0.02866686f, 0.04007162f, -0.06150412f, -0.07460086f, 0.00942810f, 0.04649323f, 
    -0.07620710f, 0.04730322f, 0.05009963f, -0.03409862f, -0.06746338f, 0.01308001f, 0.02286998f, -0.04232518f, 
    0.31136751f, 0.13191140f, 0.06630443f, -0.05344615f, 0.21776225f, 0.09170095f, -0.07539661f, -0.15231586f, 
    0.02606672f, 0.22545783f, -0.29625395f, -0.11384481f, 0.04993134f, 0.25833574f, 0.20891544f, -0.02729974f, 
    0.09652870f, -0.00612273f, 0.09613623f, -0.08660223f, -0.05629940f, -0.06057287f, 0.05873344f, -0.05583627f, 
    -0.04247332f, -0.04715768f, 0.03408066f, 0.05679036f, 0.02367990f, -0.02626451f, -0.11659281f, -0.01542228f, 
    0.29253265f, 0.03699220f, 0.21185258f, 0.03136387f, -0.03167095f, -0.06396708f, -0.34347901f, 0.25059119f, 
    0.11344113f, 0.30403504f, 0.19871841f, 0.09058795f, -0.16554737f, -0.14916962f, 0.06928702f, -0.04978885f, 
    -0.24233991f, 0.08207330f, -0.22574486f, -0.02951898f, 0.06368805f, 0.06635101f, -0.13098611f, -0.11484919f, 
    -0.13729165f, 0.12411939f, -0.08822996f, 0.21260364f, 0.02529254f, 0.14720765f, -0.13322143f, -0.03423281f, 
    -0.12285626f, -0.15096170f, 0.12696166f, 0.47103342f, 0.03523582f, 0.33969182f, 0.04931292f, 0.20896947f, 
    -0.27406052f, -0.01773847f, -0.11492489f, 0.11601697f, -0.19314605f, -0.08734352f, -0.06374163f, 0.12860976f, 
    -0.00782208f, -0.22425465f, -0.16004239f, -0.00308636f, -0.08621596f, 0.19059162f, -0.08035927f, 0.04337062f, 
    -0.09395666f, 0.06352900f, -0.43842578f, -0.21907046f, 0.17937177f, -0.14773661f, 0.11060314f, 0.23362821f, 
    0.13503921f, 0.12321100f, -0.11721893f, 0.04420530f, -0.08030035f, 0.24278072f, -0.03494028f, -0.28736562f, 
    0.14516993f, 0.49662378f, -0.07093626f, 0.06386396f, 0.06186954f, 0.02698610f, -0.01529904f, 0.10606467f, 
    0.00809479f, 0.23143706f, -0.14644732f, -0.04966784f, -0.03198843f, 0.12160861f, -0.35201851f, 0.23729813f, 
    0.09465801f, 0.07086280f, -0.15428130f, -0.26770502f, 0.08630706f, 0.45310569f, -0.18032835f, -0.15209162f, 
    0.20981848f, 0.18035375f, 0.29881001f, -0.01941794f, -0.80125320f, 0.04626535f, 0.13702588f, -0.39471000f, 
    -0.21820727f, 0.03934285f, -0.10086191f, 0.03810487f, 0.00200547f, -0.00672777f, -0.09786899f, 0.42902219f, 
    -0.24544944f, -0.10055661f, 0.45946020f, 0.09512909f, 0.00027274f, -0.09220187f, -0.01234579f, 0.10251403f, 
    0.41970953f, 0.08855089f, -0.01499690f, -0.01829438f, 0.23879571f, 0.04525372f, -0.03810362f, 0.22318621f, 
    -0.04544346f, 0.06980403f, -0.02659416f, -0.04871190f, 0.00089097f, -0.11060864f, -0.04532478f, 0.05974036f, 
    -0.08027012f, 0.05431647f, -0.08758046f, 0.00415402f, 0.04962315f, 0.04641819f, 0.01773912f, 0.16299951f, 
    -0.09781476f, 0.00191736f, -0.02186201f, -0.03675079f, 0.11717763f, -0.01288195f, 0.20497331f, 0.09056432f, 
    0.08014776f, 0.20628729f, -0.16469830f, -0.02087874f, -0.19180652f, 0.11184109f, -0.03651279f, -0.14665750f, 
    0.09508117f, 0.08323439f, -0.02135728f, -0.59118515f, 0.21061063f, 0.00025030f, -0.03050965f, 0.04852210f, 
    0.25820735f, 0.08641027f, 0.04388908f, 0.06419695f, 0.15149258f, 0.10879123f, -0.00624880f, -0.17117898f, 
    -0.04581524f, 0.25291792f, -0.07481114f, 0.08744647f, -0.09105580f, -0.04240256f, 0.15940468f, -0.02193537f, 
    -0.01724926f, 0.16223493f, 0.07634167f, 0.15664200f, 0.32369441f, 0.14023393f, -0.07275298f, 0.03490980f, 
    0.13630691f, -0.20428178f, -0.08310055f, -0.07675841f, 0.08795380f, 0.11062379f, -0.12267680f, 0.32324651f, 
    -0.04907005f, -0.26924291f, 0.00109661f, 0.05686484f, -0.32687217f, 0.11734206f, -0.04720604f, -0.10987073f, 
    -0.05483128f, 0.05465479f, -0.16057384f, 0.07572649f, 0.08077329f, -0.06508648f, 0.38831371f, 0.13324556f, 
    -0.09133039f, 0.22365282f, 0.07809083f, 0.21072303f, 0.06278355f, 0.22266077f, 0.23095870f, -0.36815014f, 
    -0.07998560f, -0.02324446f, -0.07792827f, -0.06248694f, 0.03982387f, -0.01310348f, -0.05192204f, 0.07769684f, 
    0.01686230f, 0.06756812f, -0.03480578f, -0.01038624f, -0.02846712f, 0.05402561f, 0.05127819f, -0.00597253f, 
    0.03784318f, -0.08834666f, 0.00286042f, 0.00522156f, 0.06082745f, -0.07263591f, 0.05202531f, -0.08360852f, 
    0.03789494f, -0.00743067f, 0.02881574f, -0.06986434f, -0.07365740f, 0.02670381f, -0.04386118f, -0.01133145f, 
    0.00976942f, 0.07760591f, -0.00681299f, -0.07631230f, 0.03487361f, -0.03489038f, -0.01293867f, -0.04536380f, 
    0.02693779f, 0.01247977f, 0.06168009f, 0.01986780f, -0.02677176f, -0.03902780f, -0.05310299f, -0.08696087f, 
    -0.03984510f, 0.07478189f, -0.07756189f, -0.03092412f, -0.08677826f, -0.08043412f, -0.02221198f, 0.04116735f, 
    0.07923246f, 0.08591141f, 0.03164517f, 0.00084847f, -0.05220463f, -0.05435321f, 0.06720447f, -0.00619761f, 
    0.00727938f, -0.00649301f, -0.03726491f, -0.02062867f, -0.04876921f, 0.03610808f, 0.01663690f, -0.08834624f, 
    0.04999595f, 0.03374646f, -0.09410195f, -0.07006221f, 0.02545064f, -0.02268016f, 0.06400345f, 0.05875765f, 
    -0.04883410f, -0.06422042f, -0.04647822f, 0.04074931f, -0.06263303f, 0.04366965f, -0.04595965f, -0.07175048f, 
    0.02195528f, 0.06487953f, -0.02762049f, -0.08584267f, -0.07521974f, 0.01514631f, -0.01270401f, -0.05705120f, 
    -0.03619575f, -0.03750134f, -0.08132015f, -0.05390304f, 0.06172837f, 0.01837028f, 0.04279584f, -0.06115573f, 
    0.03028436f, -0.07388317f, -0.04813633f, -0.02399239f, -0.05070410f, -0.04043398f, 0.02472938f, -0.01367662f, 
    -0.04215170f, 0.03944319f, -0.07280562f, 0.04437968f, 0.03966995f, -0.03709863f, 0.07063071f, -0.00441420f, 
    0.05863725f, -0.05575914f, 0.06620506f, -0.06293570f, 0.01439493f, -0.04950937f, -0.01812134f, -0.01502258f, 
    0.18214822f, -0.01997435f, 0.01655350f, -0.62415135f, -0.19040522f, 0.13361228f, -0.24347703f, -0.03137010f, 
    -0.19471519f, 0.20305766f, -0.03682888f, 0.19132696f, 0.07309581f, 0.20402679f, 0.05889087f, -0.14308988f, 
    0.10825477f, -0.04073833f, -0.05270451f, 0.18357506f, -0.34595916f, 0.11855102f, -0.00664666f, -0.02751503f, 
    0.02367362f, 0.04199520f, 0.15422407f, 0.10235355f, 0.33277369f, 0.00164520f, -0.00172558f, 0.04620475f, 
    0.33124164f, -0.17481627f, -0.00740114f, -0.05255710f, -0.09767628f, -0.11839671f, 0.06253524f, 0.26633397f, 
    0.26542020f, -0.33052480f, 0.01808179f, 0.37460405f, -0.32748386f, -0.24887972f, -0.03287252f, -0.00089389f, 
    0.33015546f, -0.19749306f, -0.00842398f, -0.00529162f, 0.10143098f, 0.07327176f, 0.04865994f, -0.22078486f, 
    0.39870256f, 0.03500301f, -0.15399770f, -0.09116038f, -0.01078798f, -0.18642388f, -0.16020693f, 0.42926317f, 
    0.14532739f, -0.07450183f, 0.04995349f, -0.16180347f, 0.07773670f, 0.16887110f, 0.05055366f, -0.13252801f, 
    0.09841048f, 0.00680122f, -0.10220944f, -0.11342471f, 0.30490661f, 0.15366997f, -0.07559879f, 0.14072248f, 
    0.04710948f, 0.17693017f, -0.05325672f, 0.20536919f, 0.17824349f, 0.05752396f, 0.18256538f, -0.12847154f, 
    -0.09832644f, 0.11226411f, 0.08597625f, 0.03201446f, 0.13158217f, -0.31894779f, 0.05407283f, 0.02378457f, 
    -0.02668621f, -0.01293560f, -0.23692872f, 0.19810903f, 0.18938546f, -0.31779301f, 0.11220567f, 0.12661314f, 
    -0.45284247f, 0.35291925f, 0.03274767f, -0.07701607f, 0.02332982f, 0.03300839f, -0.11246710f, 0.03498087f, 
    -0.00096927f, 0.04431155f, 0.09784959f, 0.14036441f, -0.01049352f, -0.29237935f, -0.32372522f, 0.20915259f, 
    -0.00348754f, 0.19732654f, -0.24339476f, 0.17081319f, -0.03458175f, -0.16071536f, 0.15311904f, -0.21206838f, 
    0.03312720f, 0.23269203f, -0.08331389f, 0.12001294f, 0.33651412f, 0.06646992f, 0.14735273f, 0.37191501f, 
    0.21937990f, 0.11947925f, -0.07399434f, -0.10157806f, -0.06242122f, -0.20105861f, 0.29525042f, -0.34812933f, 
    0.15449245f, 0.04951022f, -0.31949848f, -0.01899123f, -0.18424156f, -0.20663387f, 0.09811579f, -0.03986926f, 
    -0.21176158f, 0.03893904f, -0.14200184f, -0.13354464f, -0.56528592f, -0.02466621f, 0.04375072f, -0.03852196f, 
    0.01080097f, 0.05545880f, 0.22759859f, -0.39317119f, 0.40292537f, 0.14516354f, -0.17736281f, 0.09836844f, 
    0.03729011f, 0.43788916f, 0.23155349f, 0.22834708f, 0.30854210f, 0.11868555f, 0.04115703f, 0.12323259f, 
    -0.28606251f, 0.15326943f, -0.20869772f, -0.02731463f, -0.16872238f, 0.03741163f, -0.00381755f, 0.63741273f, 
    -0.16885430f, 0.18292430f, -0.08023666f, 0.12619327f, -0.16329114f, 0.07598708f, -0.03484809f, -0.15384276f, 
    -0.55655056f, -0.04011866f, 0.21196881f, 0.13620670f, 0.14939572f, 0.05170792f, -0.08593471f, 0.07626184f, 
    -0.20805778f, -0.02390472f, 0.06734522f, 0.05927501f, 0.07554049f, -0.11850114f, 0.07169276f, 0.28453827f, 
    -0.01250369f, 0.04362893f, -0.20554115f, -0.03431888f, -0.06597697f, 0.03179689f, -0.16040190f, -0.03017700f, 
    0.07755800f, -0.07137122f, 0.06165432f, -0.00516890f, -0.37395334f, 0.18774098f, 0.11109713f, 0.53746790f, 
    0.22048350f, 0.09625278f, -0.30177924f, 0.27040866f, 0.00838520f, 0.33020937f, -0.12041270f, 0.25707260f, 
    0.13854419f, 0.25718588f, -0.06612585f, 0.07348379f, -0.05722380f, -0.07844710f, -0.15889603f, 0.09438639f, 
    0.02310453f, -0.16950990f, 0.12494056f, 0.02483263f, 0.00832952f, 0.28974846f, 0.18910079f, -0.08315534f, 
    -0.10245020f, -0.38476717f, -0.22506055f, -0.05654931f, 0.33212736f, -0.46242982f, -0.04459950f, 0.20034593f, 
    0.29801038f, 0.23215473f, 0.17523552f, -0.15490197f, -0.73127145f, 0.15956990f, -0.10254768f, -0.41307217f, 
    -0.10666721f, 0.10086474f, -0.16573018f, 0.00933031f, 0.06939010f, 0.26486796f, -0.07366779f, -0.11444879f, 
    -0.00251903f, -0.09524664f, -0.29015160f, 0.03501284f, -0.11168391f, -0.07833992f, 0.06029326f, 0.10621925f, 
    -0.58064383f, 0.04608754f, 0.08229134f, 0.08173057f, -0.07363913f, -0.03304270f, 0.02941092f, 0.21754396f, 
    0.08375600f, 0.13665341f, 0.13913633f, -0.22560573f, -0.17066523f, -0.02509981f, -0.11373550f, -0.07193720f, 
    -0.00044759f, 0.07159954f, 0.01188915f, -0.15104292f, 0.07918246f, -0.04614701f, 0.10104637f, 0.12093411f, 
    -0.14265521f, -0.07918204f, 0.05695898f, 0.04048545f, 0.21654512f, -0.00307133f, 0.13407551f, -0.10160059f, 
    0.11630432f, 0.16091107f, 0.09202576f, -0.00234522f, -0.15064944f, 0.24414755f, -0.00892380f, -0.08476914f, 
    -0.12572941f, 0.05327906f, -0.08196341f, -0.34470469f, 0.21729699f, 0.16172242f, 0.03274336f, -0.07450380f, 
    -0.34981573f, -0.05134526f, 0.09150721f, 0.15900661f, 0.02881721f, 0.03715644f, 0.08063333f, -0.14781675f, 
    -0.04069952f, 0.04611316f, -0.23333488f, 0.04078611f, 0.05585522f, -0.01721813f, 0.11041043f, 0.25934628f, 
    0.00304514f, 0.00606494f, -0.16736558f, -0.05536551f, -0.02818131f, -0.12011085f, -0.09760993f, 0.15680543f, 
    0.13354325f, -0.09154911f, 0.00855766f, 0.08904576f, -0.09459906f, 0.15877125f, 0.02604476f, 0.27157077f, 
    0.06055991f, -0.06327887f, -0.07800526f, -0.05626112f, -0.21820766f, 0.17904764f, -0.05747703f, -0.02928222f, 
    0.10778034f, 0.18830466f, 0.06089377f, 0.15580194f, 0.10720646f, -0.04816096f, -0.00745125f, 0.05895757f, 
    -0.13777879f, 0.24018873f, 0.16558735f, 0.07873270f, -0.13587405f, 0.39581251f, 0.14098354f, -0.24721730f, 
    0.11903017f, -0.02181679f, 0.19663672f, 0.10097807f, -0.67600662f, 0.00776871f, 0.07567629f, -0.51824498f, 
    -0.09491076f, -0.22421776f, -0.18217391f, -0.08843890f, 0.01031923f, 0.26396367f, -0.01054860f, -0.34145978f, 
    -0.56493747f, -0.01448143f, 0.18766966f, 0.19702052f, 0.12476353f, -0.57973635f, -0.05269310f, 0.06454042f, 
    -0.36719966f, -0.00114532f, 0.02782265f, -0.37383109f, 0.02356338f, 0.06755104f, -0.01060701f, 0.10418352f, 
    0.09276120f, 0.40796709f, 0.33909634f, 0.12411968f, -0.10573682f, 0.18767369f, -0.72173053f, -0.00660776f, 
    0.04319222f, 0.28187406f, 0.13926689f, 0.06763998f, 0.18521120f, 0.33208764f, 0.05014535f, 0.07868022f, 
    -0.40013245f, -0.02472618f, -0.31398353f, -0.00072174f, 0.06039616f, -0.04129128f, -0.09942296f, 0.23187268f, 
    -0.03810721f, 0.14056566f, -0.43722659f, -0.00177428f, -0.14817365f, 0.14641413f, -0.06812423f, 0.13801393f, 
    -0.20748793f, 0.05865640f, -0.04572966f, -0.37678352f, 0.19486181f, 0.05619858f, -0.02642565f, 0.09211396f, 
    -0.18984658f, 0.28748602f, 0.05255314f, 0.05421900f, 0.17588101f, 0.12026343f, -0.08797539f, -0.35872629f, 
    -0.05441245f, 0.24981478f, -0.60339803f, -0.33191937f, -0.14175317f, 0.24316041f, -0.09252596f, 0.05568385f, 
    0.08662201f, 0.07637407f, 0.04734639f, 0.00531458f, -0.03580434f, 0.19721997f, 0.18827902f, 0.13840139f, 
    0.19149877f, -0.22989166f, -0.22207229f, -0.20756532f, -0.05373039f, 0.30712950f, -0.02927355f, 0.53394747f, 
    0.08000865f, -0.31581327f, -0.06134592f, 0.06191418f, 0.01678959f, -0.02260620f, -0.05164689f, 0.04419037f, 
    0.02227463f, -0.05087499f, -0.35486698f, 0.05124752f, 0.22745265f, 0.13843475f, 0.21534054f, 0.30032447f, 
    -0.10289064f, -0.07441533f, -0.05607756f, -0.14989057f, -0.04076675f, 0.27815557f, 0.21987118f, -0.51420122f, 
    0.41043809f, 0.25333697f, -0.07618006f, 0.03983849f, -0.02315537f, 0.11208677f, 0.13494137f, -0.25024384f, 
    -0.25655875f, -0.05742377f, -0.07543323f, -0.09177961f, -0.00198943f, -0.12066511f, 0.07133464f, 0.27544236f, 
    0.13359687f, -0.05305118f, 0.32520410f, -0.14245085f, -0.08877074f, -0.47348338f, 0.01367453f, -0.04649808f, 
    0.20120969f, 0.05415384f, -0.01023490f, -0.07473991f, -0.25136402f, -0.07886794f, 0.12069701f, -0.05643632f, 
    -0.22753686f, -0.22064146f, -0.05236436f, 0.09274184f, 0.20479885f, 0.11929300f, -0.31993181f, 0.02136504f, 
    -0.03188355f, 0.11998681f, 0.06869383f, 0.32648781f, 0.21363933f, 0.33254895f, -0.06948282f, -0.15094902f, 
    0.17605373f, 0.05138099f, -0.01901426f, -0.06896096f, -0.11778701f, -0.06079934f, 0.30871683f, 0.26268196f, 
    -0.04995566f, -0.04158961f, 0.16732569f, 0.06209553f, 0.00685884f, -0.04046923f, 0.12077977f, -0.02197836f, 
    -0.07186303f, 0.03538036f, 0.01108520f, 0.24815547f, 0.03857478f, -0.08627120f, -0.03597933f, 0.07529821f, 
    0.22199275f, -0.07833877f, 0.03660145f, 0.00801136f, 0.09260812f, 0.02132189f, -0.08700614f, 0.39569253f, 
    -0.05574454f, 0.19631207f, -0.18845215f, -0.13335782f, -0.62994266f, -0.19101013f, -0.02888243f, -0.04830432f, 
    -0.10082443f, -0.10117874f, 0.26894510f, -0.00107929f, 0.06467113f, 0.19030747f, 0.10724742f, 0.19245224f, 
    -0.14426737f, -0.25716886f, 0.18139781f, 0.24518123f, -0.02537569f, 0.11694726f, -0.05220135f, 0.51947933f, 
    -0.00760132f, 0.54669929f, 0.06140550f, 0.02336993f, -0.53949767f, -0.07305519f, -0.29002520f, -0.33647180f, 
    0.07338530f, -0.03836195f, 0.00922355f, -0.06786240f, -0.05767164f, -0.12286689f, 0.58353215f, -0.01273580f, 
    0.00266212f, 0.02539182f, 0.11526465f, 0.16589651f, 0.32804346f, 0.12937494f, 0.22598168f, -0.19744705f, 
    -0.11176086f, -0.07995804f, 0.00611031f, 0.13171560f, -0.29668838f, 0.08451029f, 0.02526563f, 0.17720744f, 
    0.07253107f, 0.06445593f, -0.22176333f, -0.27454805f, -0.08483709f, -0.10385436f, 0.25982729f, -0.38350844f, 
    -0.07108674f, 0.07835525f, -0.27472752f, 0.07345925f, -0.09457113f, 0.12391872f, 0.02408795f, -0.08797847f, 
    -0.25543070f, -0.02308458f, 0.07021717f, -0.17890677f, -0.59639907f, -0.00220058f, -0.05377925f, 0.05826834f, 
    0.03166750f, -0.07288106f, 0.37841597f, -0.28049207f, 0.19900261f, 0.14343934f, -0.28730118f, 0.13565189f, 
    0.01255303f, 0.36603537f, 0.23079237f, 0.23300296f, 0.23166482f, 0.14668573f, -0.01495242f, -0.10446854f, 
    -0.11348103f, 0.10813338f, -0.16858277f, -0.09055937f, -0.18605152f, 0.06832760f, -0.12155250f, 0.34431145f, 
    -0.09808142f, 0.04614105f, -0.26981664f, 0.18270381f, 0.05508186f, 0.10700069f, 0.06365324f, -0.23188204f, 
    -0.47632903f, 0.03722573f, 0.07622828f, -0.07819394f, 0.09125403f, 0.24130046f, 0.02347688f, 0.01472123f, 
    -0.24135131f, -0.14987028f, -0.00534270f, 0.10018406f, -0.08920588f, -0.03173370f, 0.02226998f, 0.23274520f, 
    0.05193786f, 0.00225408f, -0.07747862f, -0.20254941f, 0.15805839f, 0.08638734f, -0.03329471f, -0.14573649f, 
    -0.02687230f, -0.00983279f, 0.00184932f, 0.01363669f, -0.19943659f, 0.26534462f, 0.13407321f, 0.33251670f, 
    0.05710575f, 0.07104989f, -0.02190736f, 0.19154283f, -0.01431648f, 0.32804489f, -0.05156448f, 0.34861195f, 
    0.10296657f, -0.23589352f, 0.02899867f, 0.00715529f, -0.06599411f, -0.15270481f, -0.21234211f, 0.10832571f, 
    0.08174115f, -0.04366057f, 0.17826094f, -0.00988456f, 0.01591982f, 0.30701190f, 0.15160324f, -0.07845864f, 
    -0.14736100f, -0.23633403f, 0.07629694f, -0.05254683f, 0.13567008f, -0.38084584f, -0.05441383f, 0.23012444f, 
    -0.18973340f, -0.23844153f, 0.15308976f, -0.22091568f, -0.04302006f, 0.06049823f, -0.28676617f, 0.26914272f, 
    -0.36732960f, -0.10695770f, -0.06233186f, -0.19077680f, -0.00927753f, 0.14924292f, -0.44792911f, 0.15569848f, 
    0.27291080f, -0.08104971f, -0.28299883f, -0.09922720f, 0.03962906f, -0.59177345f, -0.00894691f, -0.03858805f, 
    0.03366514f, -0.08680763f, 0.31960863f, -0.23814435f, 0.21731927f, 0.03312945f, 0.12287868f, -0.07473852f, 
    0.21032235f, 0.10991735f, 0.18622354f, -0.18984577f, -0.24522169f, -0.17847094f, -0.23369174f, -0.15996821f, 
    -0.16206196f, -0.06906933f, 0.05791057f, -0.20871533f, -0.08990890f, 0.13027377f, -0.23688579f, -0.44215119f, 
    0.25966796f, -0.02131969f, -0.13634317f, -0.02050814f, 0.08072434f, 0.03988217f, 0.18240084f, -0.41511664f, 
    0.22371013f, -0.34539977f, 0.20257200f, 0.22497529f, 0.13558377f, 0.09333578f, 0.00965578f, 0.20947897f, 
    -0.05630762f, -0.25635007f, -0.03601687f, 0.02005483f, 0.11853255f, -0.04772066f, 0.01781457f, -0.12801196f, 
    -0.21543285f, 0.00060564f, 0.02782658f, 0.14048308f, -0.10483913f, 0.07246738f, -0.08174100f, 0.13717650f, 
    0.05653791f, -0.09569667f, -0.21951696f, -0.36048749f, -0.13621685f, -0.09795360f, 0.03010277f, 0.12970036f, 
    0.08490427f, 0.05789480f, 0.04866211f, -0.09371337f, 0.17224997f, -0.19515784f, 0.06616406f, -0.25131387f, 
    0.11683483f, 0.28911790f, 0.19062577f, 0.32512346f, -0.13527814f, -0.21031284f, -0.00774397f, 0.35128552f, 
    -0.40587509f, -0.08787587f, -0.07598057f, 0.02933610f, -0.07305718f, -0.11622848f, -0.33053359f, 0.35600626f, 
    -0.02239600f, -0.03264488f, 0.39691588f, 0.47635972f, 0.03837539f, 0.00776087f, 0.11280334f, 0.00457117f, 
    0.06616391f, -0.04699655f, -0.10500786f, 0.15271768f, -0.25467870f, -0.47915199f, 0.14937498f, 0.27630416f, 
    -0.05154217f, -0.07291786f, -0.09364934f, -0.02542189f, -0.01851379f, -0.08842899f, -0.06073507f, 0.04642820f, 
    -0.05703041f, 0.02564994f, 0.04332503f, -0.06432863f, 0.04484000f, -0.03172722f, -0.01317587f, 0.01786185f, 
    -0.02992804f, 0.04989448f, -0.05216892f, -0.02683219f, -0.02078725f, 0.00201002f, 0.01907475f, 0.01111099f, 
    0.02889343f, 0.06773048f, -0.05828768f, -0.05237749f, 0.01576190f, 0.07606123f, 0.05851493f, -0.03790122f, 
    -0.03662514f, 0.02608467f, 0.06093084f, -0.09768444f, -0.06633905f, -0.09975249f, -0.05508536f, 0.06875847f, 
    -0.03604808f, 0.05400458f, 0.05197642f, -0.00174042f, -0.02234432f, 0.05793986f, -0.00596888f, -0.08247987f, 
    0.06167326f, 0.03666555f, 0.01675165f, 0.06365304f, 0.06798583f, -0.04257981f, -0.01661921f, 0.03944447f, 
    -0.00262829f, -0.07197402f, -0.05001402f, 0.01526764f, 0.05322538f, -0.02020463f, 0.00191263f, -0.08305804f, 
    -0.03703316f, -0.05858715f, -0.03884159f, -0.00301646f, -0.07211703f, 0.06951693f, 0.00421875f, -0.01274588f, 
    0.05261426f, -0.00556417f, -0.03848764f, -0.07848223f, 0.04385130f, 0.00955674f, 0.07085048f, 0.05002614f, 
    -0.05010717f, 0.04247385f, -0.05257105f, 0.02697096f, -0.03120566f, 0.05118511f, -0.09202846f, 0.01298539f, 
    0.03103018f, -0.08113927f, 0.02976084f, -0.00176333f, -0.04249096f, 0.04169530f, 0.05242062f, -0.07474284f, 
    -0.02393674f, -0.03058364f, 0.05087369f, 0.01473854f, 0.05776509f, -0.01858184f, -0.07798254f, -0.08923881f, 
    -0.09398922f, 0.01206471f, -0.02221435f, -0.01025235f, 0.01409498f, -0.07674544f, -0.07705781f, 0.04264753f, 
    0.02304507f, -0.11125542f, 0.02043902f, 0.00608817f, -0.01426646f, -0.08841318f, -0.09916333f, -0.05855085f, 
    -0.04110175f, -0.07323470f, 0.01780001f, -0.00504617f, -0.01184371f, -0.10535504f, -0.07354271f, 0.01211472f, 
    0.33270326f, 0.30130908f, 0.15963604f, -0.16245401f, -0.57596242f, 0.17720902f, -0.04900132f, -0.50315690f, 
    -0.13212991f, 0.05778491f, -0.00277232f, 0.02238596f, 0.07882025f, 0.06293701f, -0.15425955f, 0.35052514f, 
    -0.16548595f, 0.04106731f, 0.03512858f, 0.20536125f, -0.09696057f, -0.12388888f, 0.00744011f, -0.03863403f, 
    -0.14982954f, -0.02389007f, 0.05232957f, 0.07129949f, 0.17875728f, -0.03565048f, 0.00137208f, 0.29728442f, 
    0.02285885f, 0.00071172f, -0.05276270f, -0.17086650f, -0.10427575f, -0.02667334f, -0.24132447f, -0.00307478f, 
    0.07005917f, 0.03777815f, -0.00030610f, 0.03567188f, 0.14710550f, 0.13463637f, -0.02051246f, 0.27018613f, 
    -0.01340345f, -0.05423055f, -0.07073011f, -0.00588638f, 0.12899870f, -0.05470186f, 0.41176546f, -0.04382099f, 
    0.19230726f, 0.14575739f, 0.03216694f, -0.09175031f, -0.12899101f, 0.09744374f, -0.03264170f, -0.04226504f, 
    -0.16396931f, 0.08509900f, -0.09954827f, -0.28284240f, 0.10826464f, 0.19696604f, 0.02573171f, -0.02064575f, 
    -0.06524221f, 0.01120772f, 0.00072340f, 0.04492553f, 0.17341754f, 0.10096494f, -0.02106137f, -0.00484395f, 
    0.08292349f, 0.12250607f, -0.16089131f, 0.03938347f, -0.05899180f, -0.15577263f, 0.08583566f, 0.26665333f, 
    0.03927673f, 0.11492596f, 0.08356107f, 0.11052591f, 0.20724963f, 0.00271218f, -0.04418984f, 0.14286993f, 
    0.04815974f, -0.25276813f, -0.06878493f, 0.10642327f, -0.05269727f, 0.12729365f, 0.02595445f, 0.41701511f, 
    -0.01650625f, 0.06552054f, -0.05720634f, -0.07854916f, -0.33689749f, 0.12999623f, -0.26219633f, -0.19953470f, 
    -0.00624164f, 0.19427975f, 0.00288809f, 0.07320495f, 0.11336242f, -0.10889781f, 0.28026783f, 0.10738156f, 
    -0.23476873f, 0.28846365f, 0.04241354f, 0.15362756f, -0.02600312f, 0.39805976f, 0.24502388f, -0.38793081f, 
    0.02887040f, -0.06882336f, -0.01656673f, 0.13379684f, -0.08211232f, 0.08268595f, 0.06550084f, 0.10200541f, 
    -0.06153673f, -0.02049303f, -0.22223808f, -0.00693991f, -0.04970852f, 0.10298277f, 0.33868104f, 0.17006035f, 
    0.08743352f, -0.08179235f, 0.20874299f, 0.05568353f, 0.20381239f, 0.15002625f, -0.08132396f, -0.10041172f, 
    0.56610012f, -0.01979912f, 0.02867942f, -0.07927790f, 0.11902418f, -0.07119051f, 0.07263704f, -0.04681742f, 
    -0.03691120f, 0.08258788f, 0.20701410f, -0.67369688f, -0.05999937f, -0.27062097f, -0.03774010f, -0.01775240f, 
    -0.08608604f, 0.08062699f, 0.06466271f, -0.03103501f, -0.03791616f, 0.07319637f, -0.05345238f, -0.16836704f, 
    0.06083294f, -0.06254379f, -0.04711556f, -0.08127610f, -0.02605434f, -0.06563948f, 0.29580978f, -0.14389242f, 
    0.02996385f, -0.00247636f, -0.15183228f, 0.03366853f, 0.34097335f, 0.01423754f, 0.07267130f, -0.18228637f, 
    -0.04240413f, -0.07161582f, -0.05684226f, 0.15449433f, 0.07943786f, 0.04758325f, 0.10156911f, -0.01206357f, 
    0.24546559f, 0.13426259f, -0.05855785f, -0.06488658f, 0.17277774f, 0.09411345f, 0.04484642f, -0.02541184f, 
    0.05649931f, -0.01813243f, -0.13871945f, 0.02058541f, 0.04591616f, -0.02469428f, 0.05196539f, -0.20083235f, 
    0.01098394f, 0.16170339f, 0.16127133f, 0.04005835f, 0.23520045f, 0.05807627f, -0.06608464f, 0.18691231f, 
    -0.07689557f, -0.02256422f, -0.12457050f, -0.10198972f, -0.08540861f, 0.06058748f, -0.09480944f, 0.12528206f, 
    0.10219734f, 0.20806722f, -0.02123130f, -0.05199163f, -0.20575391f, -0.08588406f, -0.04341976f, -0.03131172f, 
    -0.02872285f, -0.02999193f, 0.06972551f, 0.11746862f, 0.10301534f, 0.02527125f, 0.00516168f, 0.08509063f, 
    0.08069120f, -0.02785750f, -0.03437488f, 0.03019348f, -0.00328982f, -0.22747597f, -0.12100995f, 0.00194374f, 
    -0.10490711f, -0.24034704f, 0.07423749f, 0.10234112f, -0.35897571f, 0.07490102f, -0.01740716f, -0.30835781f, 
    -0.09641439f, -0.22463125f, -0.15857697f, -0.12349197f, -0.06299207f, 0.04250425f, 0.07995505f, 0.07729506f, 
    -0.64719588f, -0.02802647f, -0.03586241f, 0.06303123f, 0.08859095f, -0.15855384f, -0.02064895f, 0.05886963f, 
    0.17099257f, -0.02896346f, 0.02426662f, -0.18459396f, 0.03692560f, 0.04218639f, 0.11073635f, 0.05590210f, 
    0.10898348f, 0.25760323f, 0.30436924f, 0.01137058f, 0.04695994f, 0.26315242f, -0.26531821f, -0.13173327f, 
    0.11539027f, -0.00031940f, 0.01083644f, -0.04695386f, 0.19114614f, 0.11664525f, -0.08324564f, -0.03822107f, 
    -0.02627107f, 0.05550219f, -0.01513444f, -0.07110680f, 0.10488411f, -0.03343814f, 0.07920121f, -0.05904006f, 
    0.05214579f, -0.01824135f, -0.09303972f, -0.09120990f, 0.06575403f, 0.14550383f, -0.08857801f, 0.20537077f, 
    0.00762864f, 0.02319310f, -0.01314619f, -0.39219189f, 0.09552094f, 0.07855272f, 0.02532686f, 0.00421258f, 
    -0.25472584f, 0.08255295f, 0.19827695f, 0.08688737f, -0.05189587f, 0.14470467f, 0.01748432f, -0.13991147f, 
    -0.07979100f, 0.04088259f, -0.18456252f, -0.15224779f, 0.21445307f, 0.26907995f, -0.04007458f, 0.19083720f, 
    0.25444898f, 0.03779528f, 0.00695088f, -0.01856119f, 0.22670306f, -0.00783585f, 0.13244382f, -0.06908457f, 
    0.03577581f, 0.17852330f, -0.17334211f, -0.09259203f, -0.08904967f, 0.17990875f, -0.02757392f, 0.00106532f, 
    0.20001581f, -0.42913106f, 0.08428887f, 0.04116051f, 0.42099613f, -0.10907048f, 0.07080799f, 0.35882849f, 
    0.04361737f, 0.10186862f, -0.10574334f, 0.16405131f, 0.12920660f, 0.12063645f, -0.08211008f, 0.22645985f, 
    0.15669028f, 0.03706752f, 0.00996298f, 0.01903125f, -0.11933026f, 0.07655140f, -0.06441525f, -0.05777090f, 
    0.03957641f, -0.09053411f, -0.03990772f, 0.08739140f, -0.08798281f, 0.03639904f, -0.04533327f, -0.05185746f, 
    -0.05963741f, -0.12536697f, -0.00642416f, -0.09070752f, 0.01453964f, -0.09962171f, -0.06061981f, 0.07245503f, 
    0.02824545f, 0.02395383f, 0.06939811f, -0.06737933f, -0.04338961f, -0.05524815f, 0.05825394f, -0.01533752f, 
    0.04042456f, 0.04194640f, -0.08795549f, -0.01385295f, 0.01653124f, -0.02546965f, 0.03432365f, -0.05510062f, 
    -0.08963753f, -0.07253969f, -0.06466600f, 0.05602595f, -0.00967286f, -0.04032000f, -0.08506939f, -0.05034665f, 
    0.04440309f, -0.11288551f, 0.03073582f, 0.07600559f, -0.06936415f, 0.04865305f, -0.00210783f, -0.07822958f, 
    0.04587998f, 0.06468911f, -0.01550562f, -0.03545260f, -0.06541996f, 0.07752266f, -0.01073205f, -0.10146146f, 
    -0.06177951f, 0.00821674f, 0.02725616f, 0.00495856f, -0.02109380f, 0.04842553f, -0.03251626f, -0.09472929f, 
    0.02217001f, -0.01318930f, -0.07113458f, -0.09882260f, 0.02796498f, -0.05736174f, -0.07365705f, 0.05039676f, 
    0.02559756f, -0.04700228f, -0.06967030f, -0.07176568f, 0.01862284f, -0.09224112f, -0.07530206f, 0.04990926f, 
    0.07068724f, 0.06005946f, -0.02435228f, -0.01266651f, -0.06035436f, -0.01518744f, -0.05759251f, 0.04128083f, 
    0.00556839f, 0.03817844f, -0.04282318f, -0.05414635f, -0.03318419f, -0.01062312f, -0.08803955f, 0.05503343f, 
    -0.00457927f, -0.09747580f, 0.05481721f, 0.02759733f, -0.03080635f, -0.09067285f, 0.08511058f, -0.01422548f, 
    -0.04882912f, -0.03133952f, 0.05487841f, -0.00902751f, 0.01599741f, 0.02475884f, -0.01988993f, 0.02153749f, 
    -0.05608244f, 0.04471422f, 0.02009561f, 0.04481568f, 0.02117326f, -0.03580596f, 0.03426662f, -0.03453269f, 
    0.06178195f, -0.08114746f, 0.12697719f, 0.04060264f, -0.06754008f, -0.07143632f, -0.07137291f, -0.03502527f, 
    0.07914751f, -0.06210695f, -0.00301227f, -0.02294008f, -0.04278653f, -0.08087929f, -0.04090178f, 0.04763700f, 
    0.02958744f, -0.05332264f, -0.05513050f, -0.06410816f, -0.05065316f, 0.03362015f, -0.04848858f, 0.06054327f, 
    0.04568191f, 0.03569568f, -0.06102502f, -0.06750381f, 0.03988478f, -0.08774403f, 0.04140150f, -0.08448811f, 
    -0.00154834f, -0.04139930f, -0.03687231f, 0.04692178f, 0.00807201f, 0.07154054f, -0.01991539f, -0.08543263f, 
    -0.07831621f, -0.04447893f, 0.04637668f, 0.06022619f, 0.01071398f, -0.05205014f, -0.00539463f, -0.06314469f, 
    -0.07598048f, 0.04783943f, 0.06683519f, -0.02724407f, -0.05460896f, -0.01231406f, -0.09539777f, -0.04848868f, 
    -0.07018717f, -0.10145656f, -0.06028664f, 0.08487875f, 0.01509922f, -0.08722299f, 0.02047934f, -0.03157090f, 
    0.00174697f, -0.06184791f, 0.05173888f, 0.00609303f, -0.07554803f, -0.00420893f, -0.10814226f, -0.06294037f, 
    -0.00790934f, 0.05999141f, -0.03270498f, 0.08236459f, -0.04431383f, -0.03504786f, 0.07999855f, -0.00785423f, 
    -0.08874029f, 0.04030363f, 0.00898519f, -0.01331796f, -0.06179699f, 0.02692600f, -0.05926613f, -0.04151320f, 
    0.00027312f, -0.04735199f, 0.02239912f, -0.09194577f, -0.06495178f, -0.03450923f, -0.04894990f, -0.03855087f, 
    -0.09287314f, -0.09020280f, -0.03273439f, -0.06508439f, -0.08225652f, -0.01152078f, -0.00087433f, 0.03223145f, 
    -0.05504366f, -0.05113534f, -0.05079875f, 0.05411455f, 0.04470638f, -0.00634670f, 0.02673396f, -0.10414744f, 
    -0.05729550f, -0.03322492f, -0.03144940f, -0.00907631f, -0.01351192f, -0.09393272f, -0.06443605f, -0.01116537f, 
    -0.03165977f, -0.09076467f, 0.00016823f, -0.01645300f, 0.00226825f, -0.06685424f, 0.04079421f, -0.02340426f, 
    -0.02758739f, -0.02399779f, 0.02476223f, -0.04989907f, -0.03018889f, 0.06338291f, -0.01512626f, 0.02048887f, 
    0.08893041f, 0.02635915f, 0.17687446f, 0.25271928f, 0.38508493f, -0.08214395f, 0.05120491f, -0.36602589f, 
    -0.13279627f, -0.05463078f, 0.10104878f, 0.04202421f, 0.06897309f, -0.01608288f, 0.09484227f, 0.13417399f, 
    0.30439523f, 0.03556871f, 0.43725783f, 0.10273558f, 0.39073023f, 0.11974996f, -0.06558839f, -0.01318670f, 
    0.54728937f, -0.04282411f, -0.13542107f, 0.11439349f, 0.20259124f, -0.00961028f, 0.07528071f, 0.02243148f, 
    -0.25279066f, 0.34605312f, 0.20773971f, 0.87771225f, -0.24558945f, 0.23386201f, 0.11038264f, 0.10320850f, 
    -0.35451123f, 0.05534236f, -0.12704548f, -0.00589493f, -0.26088169f, 0.33939472f, -0.11523879f, -0.10421981f, 
    0.15129226f, -0.09675904f, -0.12366772f, -0.03058835f, 0.09269086f, -0.00235541f, 0.05624878f, -0.16044345f, 
    0.02669425f, -0.02328986f, -0.05770922f, -0.19776191f, 0.25566784f, -0.09788737f, 0.11735018f, 0.10884071f, 
    0.19684638f, 0.00321832f, -0.30826372f, 0.50244355f, -0.07824902f, 0.12998341f, 0.10383119f, 0.06653764f, 
    0.38330379f, 0.25360176f, -0.05073212f, 0.03311056f, 0.00147897f, -0.03655337f, 0.07481025f, -0.02729231f, 
    0.05502870f, 0.25050366f, -0.00385398f, 0.08001959f, -0.12893078f, 0.29747134f, -0.08354164f, -0.27976975f, 
    -0.00384437f, -0.05887294f, -0.00396199f, 0.14457838f, -0.08588601f, 0.11072711f, 0.04636573f, -0.06993261f, 
    -0.38601342f, -0.24405284f, -0.00067774f, -0.33896020f, 0.04604841f, 0.20644121f, -0.00099241f, -0.13513088f, 
    0.12283177f, 0.32315019f, -0.01638719f, 0.07815758f, -0.12950291f, -0.12410595f, 0.03570737f, 0.17886990f, 
    -0.09565162f, -0.17559938f, -0.21724661f, -0.36202535f, -0.05796049f, -0.13040257f, 0.40117180f, 0.25793564f, 
    0.10996537f, 0.07196641f, -0.13636610f, -0.03076386f, 0.03860375f, 0.69839716f, 0.10015693f, -0.15606679f, 
    -0.06319544f, 0.20987868f, 0.03972048f, -0.13035178f, -0.03979240f, 0.05366470f, -0.17260332f, 0.28009179f, 
    0.14042625f, 0.16071944f, -0.10113817f, 0.06354774f, -0.01161504f, -0.01089978f, 0.09069770f, -0.18980934f, 
    0.04791123f, -0.01641689f, -0.02021099f, -0.00658086f, -0.20668674f, -0.09894843f, 0.06432422f, 0.04973938f, 
    -0.31512114f, 0.00816637f, 0.01959444f, 0.07270475f, -0.06290877f, -0.03895468f, 0.03201786f, -0.01737050f, 
    0.31775403f, -0.02710777f, -0.17199725f, 0.04023035f, -0.08845653f, -0.11200541f, -0.08236229f, 0.03740871f, 
    0.13191989f, 0.18973202f, 0.04368744f, -0.29787567f, -0.12524725f, -0.11285517f, 0.13650471f, 0.03418218f, 
    -0.07495511f, -0.10016841f, 0.04745957f, 0.08621302f, 0.06037131f, 0.04913195f, 0.16972187f, 0.02196619f, 
    0.14607339f, 0.17291287f, 0.06159568f, 0.04690827f, -0.18109053f, 0.13500726f, 0.06001564f, 0.18670979f, 
    -0.07203726f, -0.10195287f, 0.13646422f, 0.16988476f, 0.05058846f, 0.30617395f, -0.02594280f, 0.11864202f, 
    -0.26348019f, -0.10407124f, 0.05696759f, 0.00831515f, 0.01095147f, -0.03447225f, -0.05091969f, 0.16959926f, 
    -0.05053656f, -0.01445109f, -0.01683162f, 0.09311049f, 0.05216518f, 0.06027883f, -0.02132217f, 0.10935254f, 
    0.00336190f, 0.05811568f, -0.37368703f, -0.22320218f, 0.02273338f, -0.16684237f, -0.03821852f, 0.01172897f, 
    0.27570000f, 0.24214269f, -0.19295767f, 0.23889406f, -0.05502763f, 0.17304724f, -0.02711187f, -0.11660214f, 
    0.07567853f, -0.23208432f, -0.01898397f, 0.05529028f, 0.06242226f, 0.14810741f, 0.02762252f, 0.12264598f, 
    0.05974586f, 0.12763761f, 0.22370082f, -0.05281306f, -0.00901611f, 0.08902558f, -0.34171322f, 0.07709473f, 
    0.08440342f, -0.01368294f, 0.01794775f, -0.02988425f, -0.07731127f, 0.20044784f, -0.06514781f, 0.18980430f, 
    0.16631921f, -0.15066467f, 0.03259136f, 0.09217356f, 0.63080102f, -0.07326857f, 0.10232504f, 0.12961382f, 
    0.14360461f, -0.02328103f, -0.20647049f, -0.09240479f, -0.00630891f, 0.04191363f, 0.24992166f, -0.38116226f, 
    0.20729186f, 0.12027038f, -0.00440701f, 0.03599336f, -0.06834584f, -0.03913516f, -0.01753095f, 0.05521129f, 
    -0.02417478f, -0.08242264f, -0.32774588f, -0.12462460f, -0.15272595f, 0.03833733f, -0.01786423f, -0.12526372f, 
    0.25414985f, 0.13621140f, 0.18527237f, 0.04777458f, 0.19777136f, 0.30553102f, -0.27054432f, 0.18252778f, 
    0.13500957f, 0.19762719f, 0.24187352f, 0.39533529f, 0.07165921f, -0.02431035f, 0.06430525f, -0.08927260f, 
    -0.27634868f, 0.09969901f, -0.23883037f, -0.07872237f, -0.09663363f, 0.00031385f, -0.20333587f, 0.20804363f, 
    -0.21546303f, 0.10493811f, -0.23490776f, 0.22573911f, -0.10374308f, -0.18745121f, -0.01762923f, 0.14413475f, 
    -0.06025029f, -0.14660157f, 0.34079814f, 0.47960559f, -0.11619051f, 0.14984061f, -0.09708180f, 0.22630800f, 
    -0.21470535f, 0.03166678f, -0.12962356f, -0.04791968f, 0.00392735f, -0.04390416f, -0.08813756f, 0.15363102f, 
    -0.03234443f, -0.12322566f, 0.05456271f, -0.13046241f, -0.12566365f, 0.27017540f, -0.18195120f, -0.20883730f, 
    -0.01404248f, -0.10458636f, -0.20228006f, -0.11486134f, -0.23552155f, -0.03789116f, 0.23097998f, 0.16889033f, 
    0.03793559f, 0.17086001f, -0.24439292f, 0.03114674f, 0.01147420f, 0.33206549f, -0.03290990f, -0.15538512f, 
    0.16516241f, 0.58286262f, 0.02399889f, 0.07388062f, 0.20456883f, -0.05128428f, 0.07675819f, 0.14164408f, 
    -0.08352536f, -0.05818018f, -0.20152472f, -0.24213354f, 0.08222800f, 0.12594479f, -0.07192532f, 0.17258704f, 
    0.05423968f, -0.31981418f, -0.17773505f, -0.12165576f, 0.20026438f, -0.06621903f, -0.23068205f, 0.11493930f, 
    0.05044032f, -0.08561856f, 0.32113272f, 0.38245252f, -0.66209704f, 0.05340277f, 0.11304272f, -0.24635436f, 
    -0.01408828f, -0.27622142f, -0.26174471f, -0.23395638f, -0.00173348f, 0.02717490f, 0.02009328f, 0.05115843f, 
    -0.18644185f, 0.10619606f, 0.08544324f, -0.00416549f, 0.25696614f, -0.51591367f, 0.00890252f, 0.07430705f, 
    0.12234920f, -0.06706923f, -0.09330375f, -0.22355805f, 0.34004071f, -0.08389953f, 0.09447431f, 0.18990789f, 
    0.03401450f, 0.28219345f, 0.36101982f, 0.23942521f, -0.12479343f, 0.16814089f, -0.76935524f, -0.01253020f, 
    0.13691348f, 0.15464512f, 0.14420864f, -0.12331376f, 0.29655173f, 0.30800819f, -0.01345982f, 0.15245160f, 
    0.03470497f, 0.10114444f, 0.00825721f, -0.05637197f, 0.11765521f, 0.01649263f, 0.02942318f, 0.19507574f, 
    -0.25973356f, 0.12882854f, -0.24847566f, -0.02006181f, 0.04972512f, 0.06357953f, 0.02597111f, -0.20228817f, 
    -0.22785345f, 0.12967443f, 0.02750602f, -0.09806588f, 0.12890548f, -0.04999770f, 0.02283539f, -0.00258432f, 
    -0.28541794f, 0.05250232f, -0.04656933f, 0.01764569f, -0.07700165f, 0.10458087f, -0.04593728f, -0.11495708f, 
    0.07121429f, 0.01266505f, -0.23462217f, -0.25150844f, -0.28727075f, 0.18165043f, 0.01695730f, -0.06682432f, 
    0.11854164f, 0.10668945f, 0.14125386f, 0.04579351f, 0.14055298f, 0.23436332f, 0.21770707f, 0.10441076f, 
    0.13002339f, -0.16187878f, 0.27040651f, -0.19079240f, -0.12303621f, 0.35042891f, -0.12390497f, 0.18784486f, 
    0.14362763f, -0.17203055f, 0.01649524f, 0.03268403f, 0.06749798f, -0.06476893f, 0.22365241f, 0.12710324f, 
    -0.06469724f, 0.11862267f, -0.25759900f, 0.06553460f, 0.15072390f, 0.12234389f, 0.16660005f, 0.18702529f, 
    0.39670992f, -0.07090278f, 0.14249153f, -0.09995935f, -0.08097675f, 0.27261358f, -0.08252527f, -0.39245331f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.13564387f, -0.11240637f, 0.25057065f, 0.22327484f, 0.06502337f, 0.20150064f, 0.14831765f, 0.02053565f, 
    0.17677358f, 0.23577958f, -0.09077776f, 0.15986718f, -0.02430765f, 0.08589223f, 0.11114623f, -0.10196003f, 
    0.21213290f, 0.14128959f, 0.06069125f, 0.34459424f, 0.10208927f, -0.02308187f, 0.03705423f, -0.06585660f, 
    0.17059185f, 0.12355532f, 0.01437770f, -0.02066523f, -0.08170933f, -0.04643452f, -0.17601815f, 0.11610365f, 
    0.16205782f, -0.10532273f, 0.15842600f, 0.14094400f, 0.26583403f, 0.29844287f, 0.06286909f, -0.07306062f, 
    -0.01559190f, 0.22174259f, 0.09020908f, 0.14388466f, 0.26307306f, 0.06525129f, -0.01966943f, -0.02068407f, 
    0.08752857f, -0.24742451f, -0.01864079f, 0.10160168f, -0.09531441f, 0.36972454f, 0.22160271f, -0.01058767f, 
    0.15184069f, 0.07868807f, 0.16989039f, 0.00838896f, -0.10327829f, 0.00965708f, 0.06957912f, 0.26732588f, 
    0.03778661f, 0.04012107f, 0.27272367f, 0.23498265f, 0.14872019f, 0.04201869f, -0.13144098f, 0.06837733f, 
    -0.04604235f, 0.08980496f, 0.05928993f, 0.10477688f, -0.17041245f, 0.08482261f, -0.00773229f, 0.20488584f, 
    -0.19825053f, 0.06798937f, 0.08741223f, 0.25511515f, 0.20142479f, -0.03945577f, 0.03818047f, 0.25535849f, 
    -0.02516366f, -0.14577338f, -0.06456420f, -0.09944711f, -0.05564645f, 0.08994940f, -0.04943549f, -0.07609846f, 
    0.21219443f, -0.04666524f, 0.20102654f, -0.11244176f, -0.27358523f, 0.03300550f, -0.05731434f, 0.12070925f, 
    0.05949030f, -0.02079524f, -0.01769618f, 0.01895438f, -0.00260908f, 0.03311556f, -0.02420858f, -0.19911887f, 
    0.35406548f, 0.17264172f, 0.10735137f, 0.04391111f, 0.27245528f, -0.21397071f, -0.03648070f, 0.13397507f, 
    0.14398976f, 0.11382103f, -0.11232626f, -0.09415013f, -0.04752589f, 0.18380703f, 0.19451116f, 0.21399242f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.23177998f, 0.17504372f, -0.21842551f, 0.24486899f, 0.44698444f, -0.25666687f, -0.38740334f, 0.06846329f, 
    0.08393941f, -0.47481078f, 0.06910191f, -0.24680364f, 0.21968769f, 0.05124704f, -0.09292515f, 0.03530793f, 
    -0.03965242f, -0.17208350f, 0.20069076f, 0.06132053f, 0.09320872f, -0.07738705f, -0.10615609f, 0.09193882f, 
    0.37351683f, -0.03358937f, 0.02581798f, 0.04199762f, 0.04683283f, -0.01126376f, 0.21022107f, -0.26502272f, 
    -0.43518674f, -0.06781824f, -0.17510979f, -0.07987100f, -0.37134576f, -0.42955148f, 0.03493344f, -0.01749247f, 
    -0.24655883f, -0.60204291f, -0.24320590f, -0.34364429f, 0.10514191f, -0.20148854f, -0.02681482f, 0.05538829f, 
    0.05957640f, 0.01436421f, -0.02514697f, -0.12516263f, 0.19191623f, -0.67312562f, -0.15568630f, 0.01357545f, 
    -0.22542220f, -0.20693992f, 0.16213171f, -0.00579948f, 0.07264704f, 0.00648805f, 0.01502004f, -0.37718526f, 
    0.20022699f, 0.06316370f, -0.28220579f, 0.57232600f, -0.18533807f, 0.13029239f, 0.13703600f, 0.07310171f, 
    0.26301208f, -0.07832025f, -0.08588967f, 0.00023081f, 0.15258962f, -0.17013931f, -1.15898085f, 0.02673408f, 
    0.21275468f, 0.02155230f, -0.02864824f, 0.08030881f, -0.18019862f, 0.06233823f, 0.01036967f, -0.47746015f, 
    -0.42834604f, 0.00833621f, 0.15079497f, -0.00230000f, 0.00188496f, 0.04479960f, -0.06113371f, 0.02941103f, 
    -0.02258147f, -0.05928021f, -0.14084595f, 0.01500945f, 0.28278822f, 0.07770331f, 0.05960980f, -0.14736269f, 
    0.07555211f, -0.00261193f, 0.04241638f, 0.03722623f, 0.12767144f, -0.21033919f, -0.07550421f, 0.08375788f, 
    0.02007607f, -0.01912960f, -0.09940262f, -0.20378509f, 0.00104209f, -0.57862645f, 0.03077393f, -0.04810572f, 
    -0.23557262f, -0.29156205f, -0.04667531f, 0.00764510f, 0.10912786f, 0.11683392f, 0.04489822f, -0.24162595f, 
    -0.39730909f, -0.11458730f, 0.09506925f, -0.25214252f, 0.09142103f, 0.07692112f, -0.19620080f, -0.08958339f, 
    0.02630205f, -0.10345748f, 0.05699694f, -0.00749042f, -0.63990223f, -0.04852283f, -0.12295221f, -0.05618539f, 
    -0.81999767f, -0.33947861f, 0.10209831f, 0.21621774f, 0.04273367f, 0.05254700f, 0.09003844f, -0.14472766f, 
    0.05147400f, -0.01737391f, 0.04623745f, -0.02389271f, 0.03624314f, 0.01602061f, -0.60514289f, -0.49151939f, 
    -0.47974470f, -0.01705046f, 0.02892674f, 0.16703984f, -0.10449447f, 0.04531391f, -0.05410370f, -0.03915385f, 
    -0.11675652f, -0.10503276f, -0.20930006f, -0.10113884f, 0.10559884f, 0.06663343f, 0.01511742f, -0.07490803f, 
    -0.53083223f, -0.11707447f, 0.04089092f, -0.08576549f, 0.18578568f, 0.10693454f, 0.25265503f, 0.05563170f, 
    0.07386387f, 0.22440912f, 0.08696890f, -0.18452755f, -0.00849112f, -0.06214953f, 0.08658423f, 0.19026339f, 
    0.34865078f, 0.05122436f, 0.19287445f, -0.55609125f, -0.29717827f, 0.10745287f, -0.07100878f, -0.06181639f, 
    -0.50271595f, 0.14542045f, -0.06820458f, -0.02604800f, 0.12669733f, -0.06194161f, 0.48437515f, 0.28049636f, 
    -0.44942728f, 0.06010156f, 0.16316290f, 0.20833039f, -0.28414270f, 0.02680620f, 0.12064830f, 0.10042396f, 
    0.03654347f, 0.04801746f, -0.16259725f, 0.06812593f, 0.02190672f, 0.00442288f, -0.03599912f, -0.06924467f, 
    0.10126505f, -0.06472004f, 0.20368457f, 0.08192383f, -0.62239796f, 0.20548636f, -0.05772819f, 0.07115829f, 
    -0.01507062f, 0.11572724f, 0.03192969f, -0.06169472f, 0.12062511f, -0.00820246f, -0.05337898f, 0.10953002f, 
    0.18341069f, 0.00482347f, -0.27987680f, 0.22429058f, 0.11419324f, 0.10384917f, 0.00852883f, 0.05067613f, 
    0.09382026f, -0.45871609f, 0.09333196f, 0.05554794f, -0.04182690f, 0.04996433f, 0.13623427f, -0.07498344f, 
    -0.44491190f, 0.16736874f, -0.03320791f, -0.02315768f, 0.09841388f, -0.33464018f, -0.13696612f, -0.01680609f, 
    -0.00991619f, 0.03583306f, -0.51984745f, 0.09690020f, -0.37730357f, 0.05862308f, 0.16166781f, 0.00957664f, 
    0.15653488f, -0.02601957f, -0.36571065f, 0.10464390f, -0.00134375f, -0.02216096f, -0.25863814f, 0.10713458f, 
    0.19018887f, -0.01416804f, 0.03371934f, 0.01151678f, -0.01503299f, -0.11719047f, -0.49670315f, 0.11672340f, 
    0.12311218f, -0.06549364f, 0.15708408f, -0.33798102f, 0.22629891f, -0.22234431f, 0.00143328f, 0.03683533f, 
    0.19436365f, 0.16107106f, -0.06113563f, -0.21565042f, -0.11448134f, -0.11116540f, -0.06247183f, 0.04333710f, 
    -0.18909556f, 0.25927216f, 0.09103265f, 0.16624127f, -0.39208061f, 0.05050267f, -0.13374040f, -0.01641833f, 
    0.08902174f, 0.13568296f, -0.32737625f, -0.27790311f, -0.01150687f, 0.00079926f, -0.37368304f, 0.09910597f, 
    -0.48404074f, -0.35328519f, 0.08669806f, 0.15492669f, 0.19167416f, 0.15033560f, 0.06822586f, -0.13258162f, 
    -0.24157366f, -0.08296446f, -0.01507482f, 0.01203051f, -0.56108087f, -0.05325586f, 0.12844902f, 0.27841905f, 
    -0.17471179f, -0.03691689f, -0.46756503f, 0.14922062f, 0.01281803f, -0.06286490f, -0.32094237f, 0.00180939f, 
    -0.15846503f, -0.36083999f, -0.02037405f, 0.03199864f, -0.09161064f, 0.03600641f, -0.01109645f, -0.06237897f, 
    -0.12415686f, 0.00109663f, -0.25705999f, -0.03823613f, -0.73403007f, -0.33684510f, 0.03810030f, -0.13246650f, 
    0.06623816f, -0.37901208f, 0.05348369f, -0.03591161f, -0.40033385f, -0.21032909f, -0.06645746f, 0.19522877f, 
    0.11707103f, -0.32383886f, 0.20568714f, 0.02129884f, 0.15266134f, -0.31980851f, -0.05282399f, -0.26895723f, 
    -0.06184689f, 0.13512959f, -0.08464658f, 0.07364401f, 0.14493351f, -0.05712919f, 0.13370769f, 0.12879872f, 
    0.08241576f, 0.17247373f, -0.41876230f, -0.15972498f, 0.06795028f, -0.15721828f, 0.11206572f, 0.08210620f, 
    0.02607287f, 0.03170632f, 0.13514692f, -0.14731079f, -0.07002040f, -0.13909350f, 0.10654116f, -0.01656666f, 
    0.09039152f, -0.22558060f, 0.21497661f, 0.05825884f, 0.18428399f, -0.09580937f, -0.33274466f, -0.02738993f, 
    0.08082064f, 0.00539866f, 0.07154759f, -0.07684044f, -0.00872102f, -0.05832376f, 0.26911277f, 0.18511161f, 
    0.10390841f, 0.00324866f, 0.07320864f, -0.25055477f, 0.18059795f, 0.00790087f, 0.06378800f, 0.05892564f, 
    0.06403551f, 0.11540597f, -0.13271375f, -0.10135634f, 0.12994127f, -0.38910979f, 0.02878381f, -0.01132181f, 
    -0.05349071f, 0.18698040f, 0.03494266f, 0.17464396f, 0.14779386f, 0.11943485f, -0.05658871f, -0.00793046f, 
    -0.70390755f, -0.00909746f, 0.08537920f, 0.19201112f, 0.08407705f, 0.03301955f, -0.17725793f, -0.45838869f, 
    -0.13151947f, 0.03653468f, -0.03110903f, -0.11048034f, 0.10894004f, 0.12758271f, 0.02207808f, 0.07879934f, 
    0.04402716f, -0.04124640f, -0.07591523f, 0.16832264f, 0.11754139f, -0.56977874f, -0.11584398f, -0.10246473f, 
    0.07237031f, -0.04971477f, -0.26552400f, 0.14860083f, -0.02688393f, -0.03271679f, -0.40929770f, 0.04353627f, 
    -0.26673755f, 0.03065185f, 0.14444031f, -0.05205091f, -0.10403955f, 0.21033745f, 0.02387248f, -0.15639485f, 
    -0.48074856f, -0.01232987f, -0.25844955f, 0.04687736f, -0.04695242f, -0.41743037f, -0.02533796f, -0.06208812f, 
    0.03496783f, -0.31972700f, 0.02858161f, 0.05568528f, -0.05508621f, -0.29773423f, -0.03123892f, -0.34868446f, 
    0.12763847f, -0.24644580f, -0.11244639f, -0.16689557f, -0.01427794f, -0.41776124f, -0.03721464f, -0.49053615f, 
    -0.05423603f, 0.15533696f, 0.04587894f, 0.03668943f, -0.77689248f, 0.10737661f, 0.10726874f, -0.16731934f, 
    0.10402452f, -0.25240126f, 0.18332310f, -0.52461243f, -0.63042521f, -0.04306380f, 0.13441195f, -0.06714577f, 
    -0.03552387f, -0.02801468f, -0.11123894f, -0.20517726f, 0.04327703f, -0.57005757f, 0.17484933f, 0.05989841f, 
    0.11251836f, 0.12193931f, 0.04247400f, -0.00938461f, 0.07070709f, -0.02061053f, -0.17824045f, -0.40771332f, 
    -0.57944030f, 0.07899054f, -0.07323242f, -0.07777705f, -0.06177467f, -0.11583265f, 0.03098299f, 0.14960343f, 
    0.05550528f, -0.10461470f, -0.31102121f, -0.04721210f, 0.08867031f, 0.08751997f, -0.06142922f, -0.04179601f, 
    -0.07677069f, -0.17311732f, 0.05303707f, 0.08372193f, 0.07897923f, -0.05343066f, 0.00566461f, -0.05785480f, 
    0.26755735f, 0.02871559f, -0.02325672f, 0.15165168f, 0.07167267f, -0.20028487f, -0.45219573f, 0.00415601f, 
    -0.04131801f, -0.04391212f, -0.06980941f, 0.01240138f, -0.00614202f, -0.00103556f, -0.04346136f, -0.11139593f, 
    0.01262214f, 0.15287016f, -0.36538801f, -0.43354297f, 0.11631116f, 0.09149280f, -0.05469398f, 0.04372002f, 
    0.11046541f, 0.12356710f, -0.02650429f, 0.04034787f, -0.00571325f, -0.07020871f, 0.02277347f, -0.15596706f, 
    0.14825314f, -0.04853676f, -0.02783229f, -0.03844179f, 0.16654575f, -0.05062060f, 0.00439926f, -0.20239587f, 
    0.06665978f, -0.14997120f, 0.13807014f, 0.04795339f, -0.05632956f, -0.20405637f, -0.01535565f, -0.01128392f, 
    -0.10480344f, -0.05526209f, -0.15735917f, -0.01689436f, 0.02892602f, 0.00834354f, -0.05102630f, 0.03504578f, 
    0.01926202f, 0.04940113f, -0.05648726f, -0.07861999f, 0.01024764f, 0.22047132f, -0.00256688f, 0.06962901f, 
    -0.05924477f, 0.18363144f, 0.20073135f, -0.46541312f, -0.01485555f, -0.46252978f, 0.01161824f, 0.11447217f, 
    0.01683901f, 0.12257155f, 0.07510857f, 0.01775205f, -0.05407974f, 0.13243054f, -0.04717473f, 0.22441590f, 
    0.06914049f, -0.28062421f, -0.22327754f, 0.32756901f, -0.11322476f, -0.11367807f, -0.02992882f, -0.07847361f, 
    0.03349038f, 0.04534422f, 0.08776920f, 0.20712610f, -0.08171228f, -0.07115062f, -0.13991711f, -0.05814625f, 
    -0.18880279f, 0.02435778f, 0.01656138f, 0.12144008f, -0.01117077f, -0.06473563f, 0.21500356f, -0.09957062f, 
    -0.41100088f, 0.18745188f, 0.01933930f, -0.03569619f, -0.05572558f, 0.02900300f, -0.20095374f, -0.27519825f, 
    -0.14785460f, -0.00415410f, 0.02641149f, 0.16645923f, 0.08487906f, -0.10729633f, -0.09110948f, 0.06504157f, 
    0.13571139f, 0.12908173f, 0.03176126f, -0.00677724f, -0.05878315f, 0.20692487f, 0.03341178f, -0.08494348f, 
    -0.36255285f, -0.04505164f, -0.07902727f, -0.13645773f, -0.07211172f, -0.01560599f, -0.16540641f, 0.00037586f, 
    -0.24271366f, -0.12695950f, 0.01359794f, 0.07309604f, -0.03275573f, -0.00966704f, 0.15603575f, 0.09652238f, 
    0.04424239f, 0.07719965f, 0.05650556f, -0.31051567f, -0.05875151f, 0.03675157f, 0.03420389f, 0.10575204f, 
    0.01161695f, -0.11858015f, -0.02086752f, 0.16044722f, -0.21531971f, -0.19057401f, -1.41624737f, 0.11532704f, 
    -0.03018861f, -0.02729423f, 0.05874087f, -0.06752502f, 0.00859984f, 0.04882028f, 0.06536307f, -0.02326969f, 
    0.29828385f, -0.64113557f, 0.11409695f, 0.06239652f, 0.04125604f, -0.16842180f, -0.00025882f, -0.02000410f, 
    -0.22539215f, 0.07128368f, -0.05641421f, -0.05781528f, -0.04118554f, -0.02512581f, -0.03241165f, -0.03716778f, 
    0.01048697f, -0.35387170f, -0.00120132f, 0.00169389f, -0.05496855f, 0.21542045f, -0.05400009f, 0.12137576f, 
    0.09937909f, 0.08460842f, 0.30464971f, 0.26444304f, 0.05770182f, -0.04250821f, -0.01961800f, 0.19318351f, 
    -0.11314566f, -0.02800528f, 0.00215159f, -0.07048985f, -0.19981830f, 0.01340507f, 0.03124517f, 0.13731246f, 
    -0.32530096f, 0.21748818f, -0.19219951f, 0.09103375f, 0.26480207f, -0.32409203f, -0.07384002f, -0.07315953f, 
    -0.01077437f, 0.03502777f, -0.04780720f, 0.13891236f, -0.13567443f, 0.13672735f, -0.08459781f, -0.04382549f, 
    0.23029870f, 0.09667560f, -0.22761516f, -0.80637830f, 0.02797569f, 0.03241946f, -0.19354174f, 0.10291220f, 
    0.28339911f, -0.19179380f, -0.02486439f, 0.05207380f, -0.00353767f, -0.05377321f, -0.33780733f, -0.17538494f, 
    0.05924172f, 0.01930413f, 0.28504109f, -0.31416863f, 0.15571722f, -0.34146404f, -0.05036559f, 0.05342445f, 
    0.16291510f, 0.24625930f, -0.03465842f, -0.28110379f, -0.52813244f, 0.16580892f, 0.00905161f, -0.08406925f, 
    -0.10160427f, 0.05594609f, 0.03032222f, 0.12562449f, -0.40242368f, 0.01926346f, 0.15129401f, 0.05064284f, 
    0.24814621f, 0.19815587f, -0.34820157f, -0.74377924f, -0.03687985f, 0.03407125f, -0.29130292f, 0.13680947f, 
    -0.15071693f, -0.56692564f, 0.19126798f, 0.23686399f, 0.25311941f, -0.56835145f, 0.18203107f, -0.78561008f, 
    -0.04458088f, -0.23641072f, -0.06797928f, -0.94552290f, -0.17665033f, 0.17387219f, 0.20218895f, -0.76657689f, 
    -0.31663087f, -0.03309102f, 0.03594049f, -0.43545133f, -0.24878666f, 0.04965555f, -0.16933388f, 0.03041341f, 
    0.11261022f, 0.03529317f, 0.01208044f, -0.07349684f, 0.04647232f, 0.04320290f, -0.00752806f, 0.02071434f, 
    0.05773698f, 0.07150933f, -0.00201372f, -0.07652970f, 0.08545335f, -0.14646086f, 0.02132743f, -0.42776209f, 
    0.00872425f, -0.17588800f, -0.07223324f, 0.02627717f, -0.82076955f, 0.03776200f, 0.00915570f, -0.08834019f, 
    -0.69721627f, -0.34745479f, -0.15501645f, 0.24930707f, -0.74924701f, 0.06480685f, -0.00084867f, -0.11614271f, 
    0.05195265f, 0.00348328f, -0.04064566f, 0.04480080f, 0.26314241f, -0.49771187f, -0.57548887f, 0.14300826f, 
    0.07617451f, -0.34142092f, 0.23360029f, -0.21525355f, -0.31932217f, 0.10780517f, -0.14915378f, 0.05787647f, 
    -0.33673191f, -0.24701807f, 0.09410612f, -0.19980335f, 0.21022454f, 0.05476793f, -0.45057788f, 0.01470864f, 
    0.13275583f, -0.13382809f, -0.68586439f, -0.94960934f, 0.03331989f, -0.09068413f, -0.00382898f, -0.20224623f, 
    0.03970748f, -0.40405387f, -0.04918357f, -0.02676954f, 0.02749251f, 0.04361624f, 0.30205736f, 0.26694736f, 
    -0.03953481f, -0.07653337f, -0.27878284f, -0.03440253f, -0.60010713f, 0.38886526f, -0.08107291f, 0.04555491f, 
    -0.20025958f, -0.44023520f, -0.25569755f, 0.03165342f, 0.07601407f, -0.07986278f, 0.04271478f, -0.05277724f, 
    0.11482947f, 0.07969508f, -0.04316774f, 0.05916638f, 0.19840765f, -0.63111085f, -0.05915317f, 0.03349487f, 
    0.01718285f, -0.08623823f, 0.14847860f, 0.10997920f, -0.00246285f, 0.00850886f, -0.04071263f, -0.38499492f, 
    -0.39434016f, 0.24047850f, -0.00075896f, -0.06248828f, 0.02014576f, -0.26078808f, -0.25704187f, -0.29627445f, 
    0.11787099f, -0.40681210f, -0.02155829f, -0.18236090f, 0.34550509f, 0.07426198f, -0.17115000f, -0.29894248f, 
    0.37940428f, -0.01384570f, 0.09140608f, -0.46597821f, -0.43141609f, -0.01739754f, -0.06032537f, -0.00343145f, 
    0.02844886f, -0.00211539f, 0.05301865f, 0.00162624f, -0.09718557f, 0.13820773f, 0.05343572f, -0.04949877f, 
    0.18145652f, 0.00950240f, 0.06179943f, 0.03367069f, -0.08026338f, 0.07358168f, -0.00116883f, -0.43649453f, 
    0.05472737f, 0.22962251f, -0.08640763f, 0.05745770f, -0.30970007f, -0.15527022f, -0.04370666f, 0.08054169f, 
    -0.91282487f, 0.16630061f, -0.46283177f, -0.38141462f, -0.55305374f, 0.16600452f, 0.07424211f, 0.05008765f, 
    -0.07340734f, 0.04648247f, -0.06239436f, 0.00243615f, -0.23111980f, 0.13030840f, -0.10057595f, -0.58813274f, 
    -0.03161554f, -0.63605207f, 0.10272022f, 0.27479020f, -0.13562927f, 0.21992569f, 0.20570828f, 0.05618032f, 
    0.32221839f, 0.17515722f, -0.24277195f, -0.08043122f, 0.15522866f, 0.18925489f, 0.22438313f, -0.00476316f, 
    0.04224676f, -0.08772407f, -0.00835524f, 0.00925338f, -0.51083428f, -0.09513423f, 0.26706120f, 0.06098276f, 
    -0.09179250f, 0.24568287f, -0.01594084f, -0.06098993f, 0.00522096f, -0.04005237f, -1.08742499f, -0.48744670f, 
    -0.48367998f, -0.08501981f, -0.07154701f, 0.37319291f, 0.00530924f, 0.22684437f, -0.06318845f, 0.06938815f, 
    -0.83856428f, 0.04848550f, 0.18740375f, 0.34979287f, 0.16253944f, -0.23696126f, -0.04445776f, -0.05023372f, 
    -0.04941587f, -0.26736942f, 0.06287856f, -0.41122171f, -0.52375573f, 0.11586224f, 0.17287613f, 0.08472235f, 
    0.12291390f, -0.15974697f, 0.17083694f, 0.06232571f, -0.01042604f, -0.00609228f, 0.06291679f, 0.10238785f, 
    -0.99053437f, -0.08198947f, 0.11584007f, -0.18977216f, -0.69518560f, -0.85391682f, -0.12103381f, -0.09174915f, 
    0.31676215f, -0.40592518f, 0.06701751f, -0.31408736f, 0.00047582f, 0.13317066f, -0.05926537f, -0.33180985f, 
    -0.17044745f, -0.02497783f, -0.14050816f, -0.77553576f, 0.16931638f, 0.00548032f, 0.00125943f, 0.23485559f, 
    -0.00970717f, 0.19800049f, -0.63183117f, -0.08009609f, 0.03008154f, -0.22400726f, 0.03924992f, 0.07086696f, 
    0.05533288f, 0.01635423f, 0.10652684f, 0.00446580f, 0.16595151f, 0.13867684f, -0.00695184f, 0.07214677f, 
    0.05261996f, -0.05928055f, 0.07540660f, -0.07474702f, -0.91931766f, 0.23222493f, 0.02021968f, -0.33882439f, 
    0.14436781f, 0.01921357f, -0.78447628f, 0.17291626f, -0.02480078f, -0.05331597f, -0.07091653f, 0.19429314f, 
    0.08347797f, -0.29652411f, 0.02317855f, -0.01940057f, 0.03105134f, -0.04747348f, -0.32569379f, -0.62774527f, 
    0.27394706f, -0.00390014f, 0.02241982f, 0.09834381f, 0.04606996f, -0.09349012f, -0.11625850f, 0.07131993f, 
    0.06921443f, 0.09219683f, -0.40169206f, 0.08173007f, 0.15497166f, 0.00976151f, -0.38239223f, 0.04999007f, 
    0.15388012f, 0.14852157f, -0.58963710f, -0.13989146f, 0.11115663f, 0.05129499f, 0.12342958f, -0.02003450f, 
    -0.00116423f, -0.07980332f, 0.01830534f, 0.07332934f, -0.03678074f, -0.02253839f, -0.50369865f, 0.15426472f, 
    0.14884026f, -0.10718316f, -0.11898636f, -0.48931175f, 0.09972285f, -0.17587423f, -0.03473832f, -0.01443916f, 
    0.10309081f, -0.10034019f, 0.18040921f, -0.27237475f, -0.07368769f, 0.02102414f, -0.07419809f, 0.08073155f, 
    0.18064068f, -0.21938747f, -0.03458064f, -0.02038293f, -0.15091832f, 0.03670264f, -0.08162071f, -0.07992790f, 
    0.02646208f, -0.07416030f, 0.15246315f, 0.04989416f, -0.00199766f, 0.00910381f, 0.11551899f, 0.09379308f, 
    -0.14689630f, 0.01132750f, 0.13624297f, 0.20427084f, 0.01288838f, -0.15850148f, 0.05872275f, 0.05988344f, 
    0.17986512f, -0.16794226f, 0.00202442f, -0.15672204f, -0.73854750f, 0.12092686f, 0.21494323f, -0.40465662f, 
    -0.44964495f, -0.07477972f, -0.00052380f, -0.05414252f, 0.06794789f, -0.10821713f, 0.14290056f, -0.14389986f, 
    -0.04023686f, -0.47938159f, 0.11946104f, 0.06420729f, -0.03041408f, 0.27993724f, 0.00354428f, -0.06585394f, 
    0.16922469f, -0.00734167f, -0.08050938f, -0.11004502f, -0.69648135f, 0.07625201f, 0.02538409f, -0.11354528f, 
    0.03759483f, 0.12156361f, 0.05462617f, 0.05398754f, 0.03736728f, -0.11259961f, 0.07935935f, -0.38248935f, 
    -0.28122127f, 0.11805680f, 0.14351775f, -0.33854988f, -0.35651809f, -0.51233053f, -0.01996723f, 0.03443724f, 
    0.01211410f, 0.15615866f, 0.04466316f, -0.08124711f, 0.13824749f, 0.06958248f, -0.02533732f, 0.09193096f, 
    -0.11607660f, -0.00703851f, 0.09812286f, -0.21964972f, -0.18879162f, 0.24191621f, 0.20693164f, -0.06704009f, 
    -0.00318548f, 0.22292967f, -0.60045338f, -0.17343205f, -0.15863423f, 0.12872760f, 0.08655565f, -0.05211645f, 
    -0.31176910f, -0.29671422f, 0.07780212f, -0.02475200f, -0.68531221f, -0.08689865f, -0.31235555f, 0.12800144f, 
    -0.22255319f, 0.15690723f, 0.06204881f, 0.05673427f, 0.02430019f, 0.00707165f, -0.14567244f, 0.29986024f, 
    0.28832218f, -0.04213183f, 0.00974329f, 0.04721647f, -0.16171250f, 0.21603650f, -0.08370865f, 0.00840827f, 
    -0.06599593f, 0.03676324f, 0.01326273f, 0.14100474f, 0.14251779f, -0.70316118f, -0.07481849f, -0.03685487f, 
    -0.05301124f, -0.10704803f, -0.00967490f, -0.63588583f, 0.10193720f, 0.18922444f, -0.00946076f, -0.00582277f, 
    -0.12571514f, -0.04674288f, -0.53840917f, 0.15684904f, -0.02271756f, 0.00510949f, -0.27065986f, 0.06758802f, 
    -0.27469149f, -0.01374045f, -0.16000268f, -0.46261176f, -0.04432572f, -0.41495094f, -0.37553823f, 0.11356714f, 
    -0.48642451f, 0.32862949f, -0.00123587f, -0.08898451f, 0.27965578f, -0.20771798f, -0.26347002f, 0.06631030f, 
    -0.42459828f, 0.08117737f, -0.47443601f, 0.16365102f, 0.25224385f, 0.04829784f, -0.12761790f, -0.01834443f, 
    -0.34653398f, 0.35087252f, -0.54502892f, -0.01855114f, 0.06422650f, 0.05157201f, -0.08108155f, -0.06587706f, 
    -0.06620421f, -0.08269452f, -0.46952587f, 0.01906092f, -0.50489634f, -0.09356761f, 0.03768589f, 0.24246269f, 
    0.07863527f, 0.27689460f, -0.05219168f, -0.08141875f, -0.15830989f, -0.25409284f, 0.06700724f, -0.52193308f, 
    0.12437744f, -0.23186156f, -0.32841536f, -0.11187159f, 0.10507397f, -0.25058141f, -0.05493429f, -0.34228551f, 
    -0.27944466f, 0.01746519f, 0.06358454f, 0.01436036f, -0.12147471f, 0.15471824f, 0.03612643f, 0.04018086f, 
    -0.69988894f, 0.21286163f, 0.15697455f, 0.20445171f, 0.11327152f, 0.21179479f, 0.18424277f, -0.04545827f, 
    -0.21621510f, -0.11920979f, -0.11358729f, 0.16846007f, -0.46253672f, 0.13293663f, -0.37505317f, 0.06091502f, 
    -0.44143933f, 0.15574135f, -0.43914041f, -0.09396771f, -0.41062945f, -0.02996613f, 0.08470651f, 0.18477096f, 
    0.07704985f, -0.32713696f, -0.04174859f, -0.02662183f, 0.08341055f, 0.03677263f, -0.21179423f, -0.29648077f, 
    -0.25533435f, -0.04392810f, 0.06453121f, 0.05887036f, -0.69462007f, -0.06561615f, 0.02831097f, -0.07045771f, 
    0.10833991f, -0.09378634f, 0.21481176f, 0.10781667f, -0.18695211f, -0.06541408f, 0.03817968f, -0.05603101f, 
    0.14149551f, -0.42473617f, 0.00573167f, 0.20687655f, 0.08093254f, -0.19943999f, -0.01068757f, 0.06238410f, 
    0.09106172f, 0.12729622f, -0.10674547f, -0.20217976f, 0.01963226f, -0.00121604f, -0.03170892f, -0.08410694f, 
    -0.56438500f, -0.01472908f, -0.18307123f, 0.10843159f, 0.06007332f, 0.05800657f, 0.07305185f, -0.05613027f, 
    -0.66601306f, -0.40727004f, -0.05432042f, -0.05683094f, -0.07459898f, 0.09173228f, -0.64608002f, -0.47225291f, 
    0.25471860f, -0.02552642f, 0.02681861f, 0.06029265f, 0.23256442f, -0.03254081f, 0.17106076f, -0.00157281f, 
    0.10689778f, 0.37060690f, -0.03576020f, 0.05792406f, 0.05938888f, -0.57664239f, -0.02797973f, 0.02680454f, 
    0.08797450f, -0.00822953f, 0.00781301f, 0.01885512f, -0.27630201f, 0.14124997f, 0.02840809f, 0.07334013f, 
    -0.05752859f, 0.09226245f, 0.07638999f, 0.00759997f, -0.29948315f, -0.00984785f, 0.02586087f, -0.24440086f, 
    -0.03455593f, -0.01104875f, 0.00897581f, -0.11945564f, 0.04388499f, 0.28112441f, -0.03471632f, -0.02166157f, 
    0.16485924f, 0.13130757f, -0.08525154f, -0.01492639f, 0.05771411f, -0.21957408f, -0.55500031f, 0.07522123f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.20983201f, 0.12165721f, -0.08095845f, -0.11183961f, 0.05594234f, -0.12944025f, -0.10689786f, -0.06520978f, 
    0.19371693f, 0.00701672f, 0.07918343f, -0.14942838f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
