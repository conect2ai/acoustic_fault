#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.44121125f, -0.18793699f, -0.05082121f, -0.51150846f, -0.43968618f, -0.12204075f, 0.21107556f, 0.17998487f, 
    0.19956069f, 0.12631507f, -0.20951626f, -0.13301638f, -0.12257175f, 0.13073060f, 0.10482522f, -0.07526173f, 
    0.16864100f, 0.05530624f, 0.12944473f, 0.07717811f, -0.25637388f, -0.13340093f, 0.06063924f, -0.27207017f, 
    -0.16078030f, -0.95075029f, 0.27578089f, 0.68254870f, -0.21497457f, 0.14633301f, 0.22258283f, -0.40799725f, 
    -0.21958266f, 0.15183185f, 0.08716313f, -0.16698001f, -0.19513556f, -0.25299484f, 0.20697662f, 0.14682195f, 
    0.09761010f, 0.01832500f, 0.17928538f, -0.00413578f, -0.16210142f, -0.09614842f, -0.13481133f, 0.26672739f, 
    -0.25521362f, -0.18507849f, -1.14376664f, 0.51331764f, -0.26935887f, -0.89852834f, 0.21646470f, 0.43460795f, 
    0.09630895f, 0.15207548f, 0.44943559f, 0.22436889f, -0.31551427f, -0.15137319f, -0.03034634f, -0.49233794f, 
    0.39997858f, 0.12901846f, 0.09952704f, -0.04785215f, 0.22614288f, 0.12189361f, -0.17076536f, -0.01239259f, 
    0.22978540f, -0.14290836f, -0.08415395f, -0.63194466f, -0.29799199f, -0.28279048f, -0.41067997f, 0.41543642f, 
    0.25306055f, -0.29053211f, -0.59294319f, -0.55734968f, 0.23281261f, -0.14523928f, -0.32024917f, 0.23532939f, 
    -0.08849017f, -0.27201492f, 0.01156353f, -0.23433812f, -0.12737539f, -0.04232366f, 0.01162331f, -0.02248098f, 
    -0.05463412f, -0.30167109f, -0.06546038f, -0.10463870f, 0.41762519f, -0.01743689f, 0.18481813f, 0.20367941f, 
    0.16885181f, -0.17374308f, 0.04157865f, -0.21125171f, -0.29886764f, 0.16124804f, 0.09807545f, 0.03518672f, 
    -0.25988963f, -0.09677796f, 0.13429300f, 0.28746328f, 0.33014128f, -0.14252451f, -0.09696408f, -0.31369928f, 
    -0.08738849f, -0.09328871f, 0.17352995f, -0.01483618f, -0.15053988f, -0.00751282f, -0.50086111f, -0.43795818f, 
    0.20670326f, 0.73305064f, -0.46795991f, 0.07163215f, -0.35187319f, -0.53455126f, -0.22982036f, 0.02874558f, 
    -0.28782147f, 0.16900761f, -0.42830488f, -0.21804760f, 0.25490299f, 0.03942046f, -0.06387138f, -0.08044229f, 
    0.10304612f, 0.02426583f, 0.07115725f, 0.27680215f, 0.14923289f, 0.03362701f, 0.24255449f, 0.35302651f, 
    0.32153839f, 0.21400116f, 0.19616507f, 0.00975814f, -0.17443207f, -0.33200917f, 0.09187347f, 0.22187410f, 
    0.24272493f, -0.03254332f, 0.17218038f, 0.03026983f, 0.13421637f, -0.04538741f, 0.22358249f, -0.30860922f, 
    -0.04347413f, 0.00410285f, 0.09319706f, 0.05439320f, -0.09571248f, 0.04370052f, 0.08579536f, -0.39417079f, 
    -0.46400973f, 0.60349816f, -0.13541161f, -0.03840051f, -0.13589470f, 0.21776104f, -0.00764837f, -0.18830115f, 
    -0.37334716f, -0.30074593f, 0.69101936f, -0.45570415f, 0.01767658f, 0.18695623f, -0.04314761f, 0.16150209f, 
    -0.09733385f, -0.26573807f, -0.30502126f, 0.32505202f, -0.16153367f, -0.31634450f, 0.10731436f, 0.35229421f, 
    0.68856561f, -0.65692765f, -0.21836123f, 0.05426344f, -0.51844996f, 0.16167606f, -0.07347744f, 0.74848640f, 
    -0.59959197f, -0.04560045f, -0.32643226f, -0.11095432f, -0.00110669f, -0.04965895f, -0.09559374f, 0.09147890f, 
    0.24089316f, 0.15122540f, -0.28143483f, 0.04513384f, -0.04972145f, -0.03297516f, -0.00553270f, 0.01741397f, 
    -0.10577085f, -0.36382443f, -0.24005792f, 0.28448236f, -0.24790086f, -0.15398701f, -0.53868842f, -0.48629048f, 
    -0.40524274f, -0.25989866f, -0.45644301f, 0.26126796f, 0.50298309f, 0.19639155f, 0.10882041f, 0.30933034f, 
    0.01364284f, -0.12705027f, -0.24387451f, -0.04841735f, -0.25888637f, 0.11312635f, -0.07552922f, -0.00166989f, 
    -0.12319198f, 0.25028074f, 0.66880637f, 0.01729049f, -0.15816268f, 0.19570787f, -0.03140676f, -0.43204498f, 
    -0.03909412f, -0.04803378f, 0.52067149f, -0.18538471f, 0.27876908f, -0.07040267f, -0.19188383f, -0.03413568f, 
    -0.28590509f, -0.35627553f, 0.19983599f, 0.15137267f, -0.23342194f, 0.26448414f, 0.17435196f, -0.01049923f, 
    0.03601395f, 0.17464875f, -0.32778916f, 0.41143605f, 0.27765682f, -0.08468446f, -0.08917814f, -0.02530621f, 
    -0.21406758f, 0.72795147f, -0.46521616f, -0.40332711f, -0.14409143f, 0.18396145f, 0.02309657f, -0.06799357f, 
    -0.08797289f, -0.15848422f, 0.05492851f, -0.11498947f, 0.20745957f, 0.11131954f, -0.25103411f, -0.12448344f, 
    -0.11151938f, 0.08347051f, -0.17517705f, 0.18002322f, -0.02825567f, 0.26956636f, -0.02578825f, -0.22455764f, 
    0.30549127f, -0.27456614f, -0.22011355f, -0.12548390f, 0.14469969f, 0.03396338f, 0.00861724f, -0.10979866f, 
    0.02330583f, 0.13804553f, 0.16775197f, 0.22219771f, -0.30895934f, 0.09477868f, -0.02783189f, -0.56408072f, 
    -0.20242721f, 0.27132770f, 0.31511691f, 0.14294913f, 0.24128628f, -0.03805514f, -0.01223147f, 0.25479436f, 
    0.14213134f, 0.05427741f, 0.23223050f, -0.02688008f, -0.25241405f, -0.21836725f, 0.01406977f, -0.09863736f, 
    0.37226000f, -0.23871072f, -0.10553925f, -0.18375508f, 0.23831820f, 0.27087203f, -0.07511019f, -0.12741052f, 
    -0.22818688f, -0.42045429f, -0.13470930f, -0.14981872f, 0.13328190f, -0.34829912f, -0.39208886f, 0.01016656f, 
    -0.42816666f, -0.67266136f, -0.51118493f, 0.37462574f, 0.05897047f, 0.31273350f, 0.17296880f, 0.15061812f, 
    -0.06681889f, -0.27570221f, -0.26315972f, -0.16354266f, -0.12869784f, -0.18812104f, -0.18497211f, 0.33149049f, 
    0.01910023f, -0.16410336f, -0.01969724f, 0.13593611f, 0.07000526f, -0.08701087f, 0.06825585f, 0.66345030f, 
    -0.31478879f, -0.19382921f, -0.74794042f, -0.72763199f, 0.12608010f, -0.23830085f, -0.04381771f, 0.49264041f, 
    0.08233533f, -0.05453540f, 0.15586795f, 0.08504073f, 0.10504521f, -0.04236841f, 0.08660938f, 0.14336054f, 
    0.08624507f, 0.00062553f, -0.31247136f, 0.00057301f, -0.17726640f, -0.28153658f, 0.10913371f, 0.03655689f, 
    -0.57160163f, -0.11429957f, 0.02931684f, 0.46594170f, 0.23229393f, -0.05688667f, 0.38317701f, 0.16157389f, 
    0.05834144f, 0.17590176f, 0.04477516f, 0.06077988f, 0.20475386f, 0.02538637f, -0.02225176f, 0.04889867f, 
    -0.21344116f, 0.08337326f, -0.19438843f, -0.27501702f, -0.09917484f, 0.18591376f, -0.28233907f, 0.04055953f, 
    0.26602945f, 0.46797350f, 0.22605230f, 0.10762852f, -0.27383536f, -0.06782194f, 0.09009438f, 0.15613790f, 
    0.04180010f, -0.05337456f, 0.07126936f, 0.18915622f, 0.23396559f, -0.24284159f, -0.34271947f, -0.09141790f, 
    0.36888453f, -0.11265951f, 0.09072643f, -0.27272952f, -0.34132418f, -0.17012788f, 0.04877387f, -0.18188778f, 
    0.02274404f, -0.26184329f, -0.35399467f, -0.29777065f, -0.32979253f, -0.07251120f, 0.04110669f, -0.19777350f, 
    -0.19263405f, 0.06145500f, 0.00168894f, 0.03618384f, -0.08516938f, -0.24463369f, -0.04682148f, -0.03245879f, 
    0.29768455f, -0.28214920f, -0.02500759f, -0.13860834f, -0.27021918f, -0.43474978f, -0.05670577f, 0.01892740f, 
    0.17113617f, -0.02815842f, 0.03900157f, -1.18420732f, 0.31453574f, -0.39758027f, 0.60623872f, 0.65023720f, 
    -0.24878880f, 0.19934662f, 0.12621398f, 0.14838181f, 0.41082227f, 0.34130564f, 0.15595050f, -0.43956620f, 
    -0.04595317f, 0.38874149f, 0.17033993f, -0.24214947f, 0.06762435f, -0.24860461f, -0.34650663f, 0.14927268f, 
    -0.07055706f, 0.23615256f, 0.18341604f, -0.16593246f, 0.37008780f, 0.19312175f, 0.26945341f, 0.10888351f, 
    -0.35190922f, -0.36683983f, 0.02860753f, 0.15056364f, -0.28222051f, -0.05271826f, 0.24603331f, -0.17000765f, 
    0.08008344f, 0.00292176f, -0.24480566f, -0.09506395f, -0.09693091f, 0.26441297f, -0.02406689f, -0.09473955f, 
    -0.03906457f, -0.05180206f, 0.13784702f, 0.12142350f, -0.05571218f, -0.07424648f, -0.19915235f, -0.73447853f, 
    -0.44765106f, -0.10865470f, 0.25515786f, 0.46767235f, 0.18476117f, -0.35846779f, -0.24766351f, -0.04430100f, 
    0.24374612f, -0.28409827f, 0.00006120f, -0.29994148f, -0.00790522f, 0.07786144f, 0.22118874f, 0.11238430f, 
    0.26909834f, 0.05402061f, -0.24800099f, -0.14171605f, -0.09492355f, -0.21022113f, -0.23395915f, -0.21754211f, 
    -0.63242501f, -0.49008691f, -0.34141082f, 0.02381154f, 0.24057396f, -0.01047451f, 0.20478971f, 0.22275308f, 
    0.25995740f, 0.19003713f, 0.03063716f, 0.21075219f, -0.14477129f, -0.26094446f, -0.19578709f, 0.08227867f, 
    0.05327675f, -0.03960707f, -0.25291041f, -0.24197386f, -0.05628840f, 0.22898182f, -0.18278024f, -0.26445428f, 
    0.40639079f, 0.47380415f, -0.49246088f, -0.26146844f, -0.29497296f, -0.15614879f, 0.40432990f, 0.28945908f, 
    -0.11121074f, -0.40260985f, -0.25456661f, 0.21270630f, 0.07355139f, -0.48851946f, 0.03194725f, -0.13262096f, 
    -0.12718987f, -0.03019611f, -0.11977224f, 0.07273500f, 0.01421500f, -0.28603876f, -0.25084248f, -0.43949473f, 
    0.54139638f, -0.64037621f, -0.07945662f, -0.28717136f, -0.31925255f, 0.06737349f, -0.06699242f, 0.11938190f, 
    0.05872801f, 0.01109865f, -0.41253170f, -0.31399363f, 0.13186599f, -0.07360724f, 0.29801741f, 0.08923880f, 
    -0.06955925f, -0.01772845f, -0.40554839f, -0.19176123f, -0.19737011f, -0.32185292f, -0.04253625f, -0.20756671f, 
    -0.47482413f, 0.10326756f, -0.25778663f, 0.22309648f, 0.71570772f, -0.77195352f, -0.10049317f, -0.60280675f, 
    -0.62365711f, -0.23514369f, -0.35213378f, 0.47731203f, -0.46093607f, -0.20308329f, 0.04658803f, 0.15749821f, 
    0.14144357f, 0.12338598f, 0.18386717f, -0.18901968f, -0.04044405f, 0.10535138f, -0.06796154f, -0.10228312f, 
    0.22957544f, -0.00024133f, 0.49993894f, -0.15094809f, -0.59859902f, -0.70563859f, -0.18754478f, 0.48954797f, 
    0.29843140f, 0.47202304f, -0.17663659f, -0.23376307f, -0.05248333f, -0.01848909f, 0.40584368f, -0.07504270f, 
    -0.04277139f, -0.41673657f, -0.36420968f, 0.26485920f, -0.06196757f, 0.51641244f, 0.19360930f, 0.23759446f, 
    -0.21579428f, -0.14364405f, -0.25571981f, -0.55146939f, -0.41297442f, 0.17208402f, 0.35945559f, 0.08352843f, 
    0.58053434f, 0.10510423f, 0.17785054f, 0.03716690f, 0.54643703f, 0.07329977f, -0.04753339f, -0.05363254f, 
    -0.18695438f, -0.13274978f, -0.21412855f, 0.02524829f, 0.07948997f, -0.17163299f, -0.19499263f, 0.07374502f, 
    -0.08398112f, 0.11535829f, 0.21065231f, 0.24618401f, 0.59462428f, 0.79964221f, 0.65505481f, -0.44159952f, 
    -0.56907552f, -0.37307304f, -0.01953238f, -0.16127634f, -0.28003922f, -0.21560301f, 0.00063426f, -0.08253938f, 
    0.02666364f, 0.13443589f, -0.08179409f, 0.16067606f, -0.31030864f, 0.27483368f, 0.09797017f, -0.05386505f, 
    0.17158562f, 0.00954020f, -0.07850473f, -0.37037438f, -0.26641232f, 1.00093937f, -0.04986344f, -0.35218841f, 
    -0.63062048f, -1.03089452f, 0.48699403f, 0.10870825f, -0.00386328f, 0.34994540f, 0.01287502f, -0.22989620f, 
    -0.10119118f, 0.34431863f, -0.03742763f, 0.11524956f, -0.11993560f, 0.19602396f, 0.11008471f, 0.02938609f, 
    -0.17695700f, -0.20268472f, 0.15791948f, 0.02980001f, 0.05232032f, 0.10860933f, -0.15346043f, 0.05566264f, 
    0.15674548f, 0.14671461f, 0.16941138f, 0.11663914f, 0.17443353f, -0.11728605f, -0.13245550f, 0.11760258f, 
    0.28126442f, 0.22106807f, -0.26437709f, -0.39436066f, -0.00838804f, 0.17247669f, 0.11686078f, -0.03392900f, 
    0.22086079f, -0.05490261f, 0.09303708f, -0.27412307f, -0.20268859f, -0.01126228f, 0.01471697f, 0.08472760f, 
    0.70345771f, -0.06767266f, 0.16707566f, -0.35467488f, -0.18530069f, -0.45747283f, 0.26912287f, 0.38417098f, 
    0.04699467f, 0.11714163f, -0.43862656f, -0.20852351f, 0.07250930f, -0.32670203f, -0.03516188f, 0.45731747f, 
    0.01912406f, -0.00448701f, -0.16770309f, -0.15709095f, 0.03314247f, 0.16972075f, -0.00443678f, -0.03121023f, 
    -0.82395905f, -0.13399781f, -0.06200789f, -0.55455315f, -0.41712618f, 0.57261384f, -0.00006331f, -0.06243973f, 
    -0.03807024f, 0.21342684f, -0.10182529f, -0.03742397f, -0.31187505f, -0.45725647f, -0.30627516f, 0.30458656f, 
    0.10666931f, 0.15389082f, 0.11765564f, 0.07804216f, 0.03169167f, -0.02782230f, 0.07064032f, 0.04918187f, 
    0.01941557f, 0.05587175f, -0.29606307f, -0.44910493f, -0.41810992f, -0.62005109f, 0.21458824f, 0.16593574f, 
    0.41153786f, -0.17139891f, 0.24762033f, 0.29487070f, -0.30545765f, -0.28420478f, -0.44049317f, -0.08332232f, 
    0.04897609f, -0.07137010f, -0.22837193f, 0.20358987f, 0.06975928f, -0.10656905f, -0.06596859f, 0.17275327f, 
    -0.04074619f, 0.04441146f, 0.14083272f, -0.35617447f, 0.36152259f, -0.05281897f, 0.38009432f, 0.04612665f, 
    0.22361326f, 0.10604077f, -0.12730873f, 0.02161544f, -0.26739216f, 0.09911282f, -0.00956411f, -0.04875157f, 
    0.34949854f, 0.03074197f, 0.02370054f, 0.15115270f, -0.07119194f, -0.10634605f, 0.13310061f, 0.02094186f, 
    0.02741709f, -0.22447857f, -0.23669799f, 0.29570767f, -0.39948854f, -0.03243517f, 0.37490848f, -0.17595869f, 
    0.34906417f, -0.07730160f, 0.05199906f, 0.21728277f, 0.18870959f, -0.12619109f, 0.18943733f, -0.27646255f, 
    0.03470673f, 0.35609081f, -0.16125670f, -0.19950077f, 0.05964054f, -0.12434634f, -0.12014242f, -0.35039330f, 
    0.21508428f, 0.11860292f, -0.03572975f, 0.38343981f, -0.71163303f, 0.08110657f, -0.20862569f, -0.57876343f, 
    -0.28114963f, 0.28061727f, 0.35299876f, -0.06755969f, 0.18893695f, 0.13552672f, 0.34234470f, -0.06730963f, 
    0.07873762f, 0.16605191f, -0.23589286f, -0.26380831f, -0.29199043f, -0.01912237f, 0.09290038f, -0.45056003f, 
    0.07323271f, 0.43740925f, 0.41051763f, 0.21726359f, -0.14687642f, 0.68866962f, 0.08379908f, -0.55334604f, 
    0.22572856f, 0.14194177f, -0.01019882f, -0.24913988f, -0.15026093f, 0.19831236f, 0.48475018f, -0.00010341f, 
    0.21574880f, -0.31932533f, -0.20934685f, 0.13701931f, -0.12522285f, -0.03292910f, 0.08151197f, 0.07492424f, 
    -0.13805935f, -0.21652520f, -0.12254584f, 0.15448679f, -0.25191337f, -0.17525089f, -0.32617903f, 0.53994381f, 
    -0.10662896f, 0.19329482f, 0.05087766f, -0.50685912f, -0.01448774f, 0.56938320f, 0.07267760f, -0.06179130f, 
    0.00682154f, 0.01378281f, 0.22164378f, 0.23045199f, -0.11116129f, -0.04312187f, -0.22785199f, -0.20857185f, 
    0.26749295f, -0.25434026f, -0.20431989f, -0.33358142f, 0.12829439f, 0.35890231f, 0.11007462f, 0.11736093f, 
    -0.16187127f, -0.15602762f, 0.01439665f, 0.10037219f, 0.05570074f, -0.10332496f, -0.03125357f, 0.13489328f, 
    -0.13175485f, 0.32316521f, -0.18125801f, 0.07634982f, 0.10257406f, -0.28079471f, -0.08431324f, 0.02625455f, 
    0.00740559f, 0.21070614f, 0.15447953f, 0.18942453f, -0.32226375f, -0.16453980f, 0.31488350f, 0.11922906f, 
    -0.37170348f, -0.63288242f, -0.01683284f, 0.09266292f, 0.21546286f, 0.28023565f, -0.09943194f, -0.45339027f, 
    -0.23535697f, 0.34865722f, -0.08837917f, -0.00990311f, 0.11334211f, 0.24176946f, 0.32256508f, -0.05628039f, 
    0.05505342f, -0.28822294f, -0.04706355f, -0.11433817f, 0.23945284f, 0.09684207f, -0.05151936f, 0.28553393f, 
    0.08768713f, -0.64623100f, -0.51895964f, -0.73430008f, 0.49851838f, 0.45791292f, -0.06960817f, -0.36852595f, 
    0.15088661f, 0.38241759f, 0.38318917f, -0.16089211f, -0.04779821f, -0.12699422f, 0.46961299f, -0.30884084f, 
    0.10860600f, -0.20795934f, -0.04157515f, 0.28547525f, 0.16393188f, -0.00346042f, -0.10443546f, 0.10343429f, 
    -0.11353682f, -0.04119055f, -0.34036216f, 0.50532293f, 0.40223479f, -0.37590989f, 0.36248487f, -0.28435668f, 
    -0.06960473f, 0.47462779f, -0.37637568f, -0.30025345f, -0.18251196f, 0.37796813f, -0.26808155f, 0.03621637f, 
    -0.10705964f, -0.07049589f, 0.17739996f, 0.18063197f, -0.13563423f, -0.07685246f, -0.15290961f, 0.05792540f, 
    -0.30911627f, 0.18718648f, 0.00002480f, -0.16414577f, 0.50903821f, 0.20855886f, 0.13341600f, 0.09191258f, 
    -0.15286720f, -0.34659788f, 0.16049348f, -0.14105013f, -0.19803043f, -0.30759686f, -0.14587982f, -0.00263441f, 
    0.22445995f, 0.02083220f, -0.00816367f, 0.20388582f, -0.11050481f, -0.05775281f, -0.33380532f, 0.09688614f, 
    -0.01138046f, -0.09101466f, 0.21128523f, 0.11843564f, 0.09946854f, 0.27268964f, -0.21639848f, 0.12889619f, 
    -0.13003369f, -0.42764491f, -0.24981248f, 0.00145009f, 0.33824319f, 0.28777695f, 0.07877033f, -0.31743547f, 
    -0.11041672f, 0.09112252f, 0.19479628f, -0.30014867f, 0.21039431f, -0.24355923f, -0.01147174f, 0.22986396f, 
    -0.02459972f, 0.34250548f, -0.17874728f, -0.04991323f, -0.30463246f, -0.50294864f, -0.50222868f, -0.29026222f, 
    -0.37355608f, -0.34636527f, 0.37588963f, 0.25048041f, -0.09805964f, 0.00615980f, 0.41380012f, 0.15928549f, 
    -0.02771292f, -0.01646609f, -0.00772901f, -0.07359787f, 0.04009326f, 0.11118189f, 0.05277617f, -0.18376715f, 
    -0.31499577f, -0.27595627f, -0.18543522f, 0.07314589f, -0.07450611f, -0.14767240f, 0.13009685f, 0.21250924f, 
    -0.19040668f, 0.21438105f, 0.25454617f, -0.03926956f, -0.46161932f, -0.17699850f, -0.03004147f, -0.04746824f, 
    -0.03657665f, -0.03043365f, 0.04972351f, -0.24586746f, -0.23653023f, 0.05147287f, -0.09744514f, 0.05106425f, 
    0.14108051f, -0.11229648f, -0.05464265f, 0.08531711f, 0.05114250f, 0.27874660f, 0.15607350f, 0.31460080f, 
    0.58393526f, 0.05521741f, 0.29669124f, -0.60870516f, -0.58755302f, -0.42754620f, -0.22462085f, -0.03210683f, 
    0.51203662f, 0.12739030f, 0.11259239f, 0.10499491f, -0.12391046f, -0.12524618f, 0.07305066f, 0.00832273f, 
    -0.02200458f, -0.09212735f, -0.45606890f, -0.24890225f, 0.20860338f, -0.00380114f, 0.00312231f, -0.06117402f, 
    -0.08562574f, 0.71242768f, -0.10364325f, -0.32799435f, -0.41564426f, -0.15349810f, 0.22976063f, 0.06029588f, 
    0.19755560f, 0.10652754f, 0.01067218f, -0.15590318f, 0.08164759f, -0.30247420f, -0.02250631f, 0.31463349f, 
    -0.41734177f, -0.10562334f, 0.32634175f, -0.09677670f, -0.22360007f, 0.21985310f, -0.10491198f, 0.17186792f, 
    0.06020324f, -0.23376766f, 0.39119697f, -0.28378856f, -0.67752945f, -0.12468066f, -0.13142872f, 0.12698577f, 
    0.38090718f, -0.02218470f, -0.36648127f, -0.15558797f, 0.58095038f, 0.24263744f, 0.11096441f, -0.26246107f, 
    -0.37187666f, -0.16132474f, -0.19557612f, 0.01413895f, -0.04373863f, 0.26532236f, 0.31449625f, -0.27367905f, 
    0.17644651f, 0.14918223f, -0.24677837f, -0.40444511f, -0.03032350f, 0.26040152f, 0.60045975f, 0.27200568f, 
    -0.46327525f, -0.36334595f, -0.55193871f, -0.57620591f, 0.58828282f, -0.12102671f, 0.39973962f, 0.12112883f, 
    0.08208771f, -0.39256358f, 0.11133768f, 0.14256822f, -0.19323739f, 0.10909852f, 0.02193767f, 0.28376225f, 
    0.01587892f, -0.15600182f, -0.06963930f, -0.16038764f, -0.52148336f, 0.39259979f, 0.78456903f, -0.18722808f, 
    -0.57973570f, -0.43367824f, -0.37101179f, -0.10152154f, -0.32355234f, 0.02422130f, -0.03762772f, 0.15584148f, 
    0.20204264f, 0.22365148f, -0.04200479f, -0.09284373f, -0.15947123f, -0.04913646f, -0.34096429f, -0.33319482f, 
    0.02217747f, 0.13410707f, -0.26708227f, -0.31806749f, 0.28256249f, 0.31125745f, 0.01180066f, 0.11326587f, 
    -0.29103994f, 0.12467981f, -0.54268235f, -0.15444745f, 0.29326150f, 0.22333212f, -0.16471118f, -0.20938908f, 
    0.04591924f, 0.15479131f, 0.11666670f, -0.08435307f, -0.14630373f, 0.21083736f, 0.24015540f, -0.31903490f, 
    -0.11238161f, -0.04080343f, 0.05222842f, 0.20567232f, -0.15761147f, -0.30449259f, -0.32064408f, -0.60021037f, 
    -0.29115844f, -0.19525304f, -0.04386494f, -0.20897484f, 0.08301521f, -0.32006484f, 0.18719189f, 0.18585728f, 
    0.41658714f, 0.44532609f, -0.27668139f, 0.01364489f, 0.19403888f, -0.04698016f, -0.17339368f, -0.05761761f, 
    -0.03728033f, -0.12404530f, -0.19643559f, 0.28576413f, -0.23424605f, -0.35019222f, 0.03800980f, -0.10621969f, 
    -0.05664354f, -0.03646690f, -0.35975182f, -0.46306518f, -0.29900071f, -0.27479014f, -0.30329502f, -0.12669431f, 
    0.03884424f, 0.50757176f, -0.22254458f, -0.22263679f, -0.03812706f, -0.18399896f, -0.22359617f, -0.05201428f, 
    -0.03993530f, -0.15659298f, -0.01117265f, 0.09854155f, -0.26211759f, 0.29003239f, -0.08243278f, 0.41819692f, 
    -0.37278187f, -0.02431672f, 0.04782737f, -0.66139203f, -0.38641426f, -0.23137966f, -0.21532707f, -0.16295274f, 
    -0.24221377f, 0.12577386f, -0.05736432f, -0.16109549f, -0.08198674f, -0.18613878f, -0.00348871f, 0.20492825f, 
    0.13513690f, -0.01550647f, 0.09868719f, 0.03049256f, -0.15384854f, -0.13273469f, -0.18370551f, -0.25302202f, 
    -0.16416575f, 0.67944902f, 0.10351837f, -0.67303222f, -0.39609024f, -0.46247506f, -0.07290070f, 0.31234050f, 
    0.11186941f, -0.14639083f, -0.23040678f, 0.01495306f, 0.34929022f, -0.26186013f, 0.21714512f, 0.46367681f, 
    0.08816297f, -0.02618087f, -0.19095308f, -0.16008796f, 0.00404329f, 0.03713815f, -0.38255098f, -0.18773200f, 
    -0.48916870f, -0.73280853f, -0.64415681f, 0.14983520f, 0.17157774f, 0.30808768f, 0.48314148f, 0.02841333f, 
    -0.43809485f, -0.67631191f, -0.39126268f, -0.39692965f, -0.15961197f, -0.35222203f, -0.27188170f, -0.37679771f, 
    -0.15538354f, -0.25904378f, -0.17442957f, 0.02091964f, 0.15488973f, 0.08661973f, -0.09100671f, -0.37766674f, 
    -0.18429688f, -0.00533673f, 0.07847513f, 0.23668973f, 0.28879946f, 0.10250435f, 0.29712725f, 0.18524654f, 
    -0.10799398f, -0.33707112f, 0.11179437f, -0.10610102f, 0.19615971f, 0.15736629f, 0.19294664f, -0.10560767f, 
    -0.00646911f, -0.25283146f, -0.11454237f, -0.09638111f, 0.18455745f, -0.18951671f, 0.28415883f, 0.32700506f, 
    -0.16664732f, 0.00235864f, -0.25533429f, -1.00808394f, 0.13174425f, 0.32681304f, -0.22408260f, -0.23358257f, 
    -0.49312401f, -0.22498579f, 0.49519420f, 1.06031048f, -0.00288888f, 0.12974793f, -0.16855578f, -0.00272080f, 
    -0.33802867f, 0.05083816f, -0.03117245f, -0.49414670f, -0.12027931f, 0.19310878f, 0.33352903f, -0.11354869f, 
    0.23986523f, 0.11437860f, -0.08350003f, 0.34109890f, -0.03956380f, 0.16790853f, -0.22053665f, 0.05026102f, 
    0.21506807f, -0.26419237f, -0.32777154f, 0.21320625f, 0.06523298f, -0.18932749f, 0.24213164f, -0.52502841f, 
    0.34149885f, 0.08715384f, -0.26401830f, -0.01747921f, 0.23504838f, -0.25999126f, -0.05970605f, 0.04194038f, 
    -0.20631585f, 0.27115315f, 0.06988431f, 0.18356274f, 0.16396201f, 0.27196911f, -0.14198604f, 0.12050586f, 
    0.09099194f, -0.36111036f, 0.46226028f, 0.55782884f, -0.18533140f, -0.32232082f, -0.02851632f, 0.17653427f, 
    0.37428713f, -0.44095674f, -0.32884467f, 0.21770674f, 0.16559814f, -0.26339471f, -0.22317293f, 0.00596496f, 
    0.34974134f, 0.15913880f, -0.07203644f, -0.06591605f, 0.03425049f, 0.15469269f, -0.39776275f, -0.05856390f, 
    -0.22945671f, -0.23092154f, -0.27529687f, 0.27456248f, -0.31778875f, 0.26006371f, 0.13841748f, -0.39036357f, 
    -0.27755326f, 0.16799067f, -0.01720334f, 0.13057707f, -0.13559560f, 0.12283147f, -0.32455224f, 0.11785911f, 
    0.00995231f, 0.00664192f, 0.15551403f, 0.41427141f, -0.09943438f, 0.04314371f, 0.25424159f, -0.16093928f, 
    0.52108097f, 0.67474711f, -0.43346316f, -0.60020024f, 0.66847140f, -0.45922962f, -0.30589139f, 0.09593273f, 
    -0.13780941f, 0.17401785f, -0.30141610f, 0.15689269f, 0.37297890f, -0.30212364f, 0.37055421f, -0.17034169f, 
    -0.26641604f, 0.01038773f, -0.01266820f, -0.13417532f, 0.52782673f, 0.28195462f, -0.23617734f, -0.16691324f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.26856276f, 0.11608759f, -0.18581025f, -0.08684946f, 0.01076585f, -0.07145961f, -0.09496830f, -0.13237479f, 
    0.08377974f, 0.05515080f, 0.00978036f, 0.06891704f, -0.04546085f, -0.25060555f, -0.39229929f, 0.27813992f, 
    0.13375385f, -0.04546628f, -0.10331504f, 0.11954148f, 0.12525024f, -0.37155941f, -0.01474918f, -0.15917750f, 
    -0.04375385f, 0.07385506f, 0.15193076f, 0.02135495f, 0.08408220f, 0.45987219f, -0.17967875f, 0.18225046f, 
    -0.33505368f, 0.07627320f, -0.21451601f, 0.01032739f, -0.02519355f, -0.02528238f, -0.09136907f, -0.25680393f, 
    0.06843549f, 0.16716203f, 0.08010177f, -0.12966166f, 0.24071927f, 0.05184792f, 0.16324218f, -0.07982853f, 
    -0.01886068f, -0.07970740f, 0.06882539f, -0.19767205f, 0.06345393f, -0.02451460f, -0.21545158f, -0.12326010f, 
    0.04417698f, -0.40395170f, -0.18315865f, 0.01795844f, -0.09747826f, 0.22554034f, 0.00878138f, 0.23385893f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.00924075f, 0.02822022f, 0.00867342f, 0.12433612f, 0.00145345f, 0.15436260f, -0.08728950f, 0.10429888f, 
    -0.03391456f, 0.02379670f, -0.03909614f, -0.17589885f, -0.10222986f, 0.06488290f, 0.19328952f, -0.10367903f, 
    0.25762305f, -0.04301024f, -0.06595859f, 0.26987484f, 0.06014714f, 0.09299070f, 0.01208901f, -0.09809785f, 
    -0.36903566f, 0.19263577f, 0.00333841f, 0.13216659f, -0.04921054f, 0.00265293f, 0.03347049f, -0.06024340f, 
    -0.00649448f, 0.15144248f, -0.09224030f, -0.06151311f, 0.22070473f, 0.11001826f, -0.08701106f, 0.13847508f, 
    0.19268893f, -0.00776805f, 0.04187975f, -0.06615454f, -0.06525344f, -0.04929594f, -0.07535857f, -0.10447790f, 
    -0.21636936f, 0.05197981f, 0.13628203f, 0.14926192f, 0.01292683f, -0.06218741f, -0.09072932f, -0.03884232f, 
    0.03135061f, -0.07481420f, 0.04066714f, 0.04048477f, 0.17576784f, 0.03013667f, -0.17565364f, -0.14983439f, 
    -0.02128174f, -0.01068081f, 0.21798947f, -0.00757378f, 0.01358293f, 0.11012983f, -0.01591431f, 0.12665813f, 
    -0.08951253f, 0.08999337f, 0.11258370f, 0.02528207f, -0.14665453f, -0.18150350f, -0.11111720f, -0.05935116f, 
    -0.03743207f, -0.12616867f, 0.01712009f, 0.07108848f, 0.06131035f, -0.04247300f, -0.08561841f, -0.20284298f, 
    0.00977095f, -0.02127469f, -0.23572621f, 0.23826529f, 0.09537455f, 0.00464421f, -0.07428372f, 0.23067878f, 
    0.36099610f, 0.02634860f, 0.01204571f, -0.08365498f, 0.05891513f, 0.10432148f, -0.06016958f, -0.04315676f, 
    0.13431987f, 0.10428757f, -0.01163443f, 0.06496085f, 0.08203993f, -0.08680501f, -0.14674659f, -0.14382537f, 
    0.07029007f, 0.14680129f, -0.13040251f, 0.00746132f, -0.01597899f, 0.04033499f, -0.05414440f, 0.02751532f, 
    -0.27506223f, 0.11525727f, -0.03974960f, 0.09242292f, 0.03661332f, 0.09528116f, -0.00006397f, -0.02315979f, 
    -0.05572359f, 0.03661931f, -0.00516370f, 0.07088740f, -0.05059261f, -0.02809574f, -0.15485176f, -0.17894466f, 
    -0.01134025f, 0.09719687f, -0.02635196f, -0.02682291f, 0.04821400f, -0.01907604f, 0.09907353f, 0.05051319f, 
    -0.06746965f, -0.06503878f, -0.05804380f, -0.13520171f, 0.01601537f, 0.06555787f, -0.07569990f, -0.00272845f, 
    -0.01193993f, 0.18132219f, 0.05298756f, 0.29880148f, -0.08056457f, -0.00252026f, -0.09975151f, -0.15329506f, 
    0.03732640f, -0.04834602f, -0.00758621f, 0.06969441f, 0.08012632f, -0.21001235f, -0.10425198f, -0.06897353f, 
    -0.08961558f, 0.35320938f, 0.14472814f, -0.01932043f, 0.00942425f, 0.11612246f, -0.01519768f, -0.11324119f, 
    -0.01969144f, -0.03689603f, 0.01091388f, 0.01048616f, 0.13594784f, -0.08243259f, -0.19254163f, -0.06096861f, 
    0.08625539f, 0.03883416f, 0.04457957f, -0.02553727f, 0.04880365f, 0.01003402f, 0.03463179f, 0.04528936f, 
    0.05702439f, -0.05348869f, -0.09658468f, -0.01648318f, -0.05018838f, -0.08223333f, -0.04043235f, 0.06534354f, 
    -0.01850334f, -0.00472799f, 0.13577153f, 0.15236515f, -0.11914429f, 0.09240776f, -0.03197666f, 0.02647409f, 
    -0.02285029f, 0.01608725f, 0.05538462f, -0.01672942f, -0.05550207f, -0.08551740f, -0.11992959f, -0.01034700f, 
    0.01475277f, -0.02206506f, 0.08487304f, -0.14188465f, -0.03465571f, 0.07223506f, -0.00622940f, -0.03976715f, 
    0.12934595f, 0.02239145f, -0.12664604f, -0.05247734f, 0.01631297f, -0.17573474f, 0.06629547f, -0.01337472f, 
    -0.16042925f, -0.09267711f, 0.01793930f, 0.08809733f, -0.01920646f, -0.02211401f, -0.01054087f, 0.16549376f, 
    -0.03894183f, 0.10077345f, 0.17993413f, -0.11910385f, 0.16017111f, -0.04903809f, -0.00542495f, -0.08282550f, 
    -0.04244359f, -0.04579486f, 0.01649681f, 0.08518741f, 0.18600644f, 0.04003966f, -0.16956320f, -0.01311281f, 
    -0.01209561f, -0.01898878f, 0.10264336f, -0.04263674f, 0.00675954f, -0.01786217f, 0.00624953f, 0.01821789f, 
    0.00518215f, -0.04634998f, -0.13425077f, -0.03672590f, 0.01753799f, 0.11576089f, 0.12097076f, 0.07743749f, 
    -0.00188207f, -0.01127620f, 0.05927777f, -0.12361333f, -0.11360765f, 0.09037750f, 0.10701118f, 0.04523483f, 
    0.00034198f, 0.10183284f, -0.09299868f, 0.01413814f, -0.02016419f, 0.04129259f, 0.01489310f, -0.16993535f, 
    0.08446997f, -0.19002186f, 0.09163023f, 0.01533267f, 0.08892238f, 0.11211353f, 0.04832294f, -0.16147493f, 
    0.03886502f, 0.04075927f, -0.01026212f, -0.30305526f, -0.20559525f, 0.08552690f, -0.02525210f, -0.35651746f, 
    0.08158533f, 0.00798801f, 0.08411401f, 0.09627149f, 0.02650719f, 0.10986145f, 0.14822264f, 0.07793172f, 
    0.24023178f, -0.22173874f, -0.17552169f, 0.08085684f, 0.03014613f, 0.03062488f, 0.09816982f, 0.07065617f, 
    0.08634920f, 0.19872758f, 0.05056050f, -0.04882605f, -0.15162759f, -0.25430807f, -0.07327868f, 0.00919704f, 
    -0.13133273f, 0.01620643f, -0.08032864f, 0.07291059f, 0.02346185f, -0.02556568f, 0.13829522f, 0.14967427f, 
    -0.07185364f, -0.33491471f, 0.14146037f, -0.12880123f, 0.02888366f, 0.10835446f, -0.09985106f, -0.10977917f, 
    -0.13486470f, -0.04947840f, -0.01719847f, -0.14244716f, 0.14136860f, -0.08788262f, -0.19160783f, 0.06160904f, 
    0.02700454f, 0.09959494f, -0.07158396f, -0.06117437f, 0.09839027f, 0.13425709f, -0.06158433f, 0.05398944f, 
    -0.00117703f, -0.02312846f, -0.07365260f, -0.01967650f, 0.02440022f, -0.11729056f, -0.13454702f, -0.01941542f, 
    0.04882224f, -0.14227667f, 0.00121376f, -0.00377837f, -0.19086307f, 0.24361774f, 0.17584287f, -0.07071441f, 
    0.07194188f, -0.04571019f, -0.08244268f, -0.02794615f, -0.00076955f, 0.05565096f, 0.02831243f, 0.15818262f, 
    0.11878293f, 0.40670538f, 0.07311417f, 0.00258121f, 0.05926866f, 0.14567079f, 0.00897264f, 0.02293458f, 
    -0.10151006f, 0.01698591f, -0.09518427f, 0.09591664f, 0.20820770f, 0.11814672f, -0.00814793f, 0.03142222f, 
    -0.03304156f, 0.09062869f, 0.03325970f, -0.02126985f, 0.11154594f, -0.07515740f, -0.05696442f, 0.11049898f, 
    0.04933397f, -0.06214670f, 0.08605532f, 0.00005001f, -0.15972649f, -0.05475571f, -0.15892939f, -0.08421347f, 
    -0.17731073f, -0.08598232f, 0.01628917f, -0.35094231f, -0.16042463f, 0.13224168f, -0.11007304f, 0.09214525f, 
    -0.15576634f, 0.03007711f, -0.03470358f, 0.00413404f, -0.00734089f, 0.12209488f, 0.00146904f, 0.16978309f, 
    -0.31522653f, -0.14418532f, -0.03429831f, -0.15514399f, 0.08921586f, 0.20720978f, 0.02464333f, 0.09383573f, 
    0.02114564f, 0.07136639f, 0.07052759f, -0.11592887f, -0.16438188f, 0.16049509f, 0.08911161f, 0.07473741f, 
    0.02731280f, 0.02230172f, -0.02721040f, -0.07945367f, -0.00475689f, -0.02671794f, -0.18031397f, -0.02732592f, 
    0.20652346f, -0.08975532f, 0.15163045f, 0.10432323f, -0.05830140f, -0.04054080f, 0.01257645f, -0.01837027f, 
    0.05544130f, -0.02774632f, 0.06544852f, 0.13114490f, -0.04539280f, -0.01685404f, -0.10412782f, -0.06640244f, 
    0.00996105f, -0.06064261f, 0.04199800f, 0.11774650f, 0.00122031f, -0.03980919f, 0.10908540f, -0.05748327f, 
    0.01650747f, -0.10937443f, 0.01136961f, -0.11180796f, 0.09239671f, -0.03628957f, 0.06398282f, 0.00371265f, 
    0.04494492f, 0.03588017f, 0.08312795f, -0.04184096f, 0.02511234f, -0.14270924f, -0.10779512f, 0.06876686f, 
    0.10390376f, 0.05941620f, 0.21209623f, -0.02633518f, 0.01303715f, -0.10343299f, 0.11862783f, -0.02451230f, 
    -0.00240581f, 0.03967848f, 0.00591516f, -0.14363860f, 0.07434089f, -0.06627978f, -0.03187875f, 0.09570536f, 
    -0.00494902f, -0.00701437f, 0.04587175f, 0.08634111f, -0.01198910f, 0.04569105f, 0.03486238f, -0.02665664f, 
    0.01272428f, -0.08804803f, -0.06469154f, -0.06506244f, 0.00419990f, -0.02327851f, 0.02255202f, 0.09852466f, 
    0.01085160f, 0.06346943f, 0.01855070f, 0.13321342f, 0.16231009f, -0.00953771f, -0.00110890f, 0.07839425f, 
    0.07368312f, 0.07870255f, -0.05552553f, 0.12939087f, -0.15834527f, -0.04507270f, 0.03309549f, -0.03403506f, 
    0.05152132f, 0.11142591f, 0.06497069f, 0.03082932f, -0.06368050f, 0.03502529f, 0.03485846f, -0.02293734f, 
    -0.11489881f, 0.14207628f, -0.03768451f, -0.00435393f, 0.00302902f, -0.02667633f, -0.04206846f, -0.01611287f, 
    0.03779890f, 0.04072364f, 0.03957703f, 0.10589541f, 0.03461567f, -0.02488735f, 0.16240232f, -0.15919612f, 
    0.17444232f, 0.02383449f, -0.05427935f, 0.13349229f, -0.01778156f, -0.08809222f, -0.03479750f, 0.14611907f, 
    -0.03710623f, 0.16375351f, 0.15452692f, 0.12528068f, -0.07997980f, 0.06064639f, 0.02729820f, -0.02857163f, 
    0.15987653f, -0.12630031f, 0.02202163f, 0.15982336f, 0.00192528f, -0.12723362f, -0.27950576f, 0.03276856f, 
    0.03797147f, 0.18652803f, -0.01007661f, 0.09112536f, -0.09348352f, 0.08089935f, 0.12766254f, 0.07567691f, 
    0.03337888f, 0.13628291f, -0.20538920f, -0.19365682f, -0.05443125f, -0.05336587f, 0.14090113f, -0.08351120f, 
    0.01783477f, 0.13380718f, -0.00544408f, 0.09995642f, 0.06339335f, 0.09497817f, 0.04711131f, -0.21560848f, 
    -0.05350327f, -0.14906727f, -0.01229395f, -0.00394435f, 0.03260590f, -0.04461195f, -0.02872060f, -0.14231206f, 
    -0.18507928f, -0.04043892f, 0.08774601f, -0.11843001f, 0.15040819f, -0.00017510f, -0.07688794f, 0.00966348f, 
    -0.01605514f, 0.00493036f, 0.05741546f, 0.05826079f, -0.00693490f, -0.07572356f, -0.14963573f, -0.03451739f, 
    -0.00923125f, 0.13385788f, 0.10888405f, -0.04110480f, -0.11294795f, -0.05179560f, -0.01575569f, -0.13187295f, 
    0.09441862f, 0.02296387f, -0.18995833f, -0.20816071f, 0.12943676f, 0.15574016f, -0.21003704f, -0.06006237f, 
    -0.01732144f, -0.06996734f, -0.03324019f, 0.10221070f, 0.02245585f, -0.04359279f, 0.02993582f, -0.20514956f, 
    0.02442327f, -0.03436643f, -0.01511494f, -0.14516354f, -0.03149301f, -0.00488143f, 0.04772647f, 0.01335864f, 
    -0.02150874f, -0.16937006f, 0.04690098f, 0.00552649f, 0.07267978f, 0.02262934f, -0.07229698f, 0.08199962f, 
    -0.00084768f, 0.18210217f, -0.03288772f, -0.04673030f, 0.33346534f, 0.25769955f, -0.08425686f, -0.17151281f, 
    -0.08458710f, -0.11123086f, 0.05613827f, -0.04355107f, 0.01001950f, -0.08702581f, -0.04377488f, -0.07236473f, 
    0.09929689f, 0.11451505f, -0.02178842f, -0.00592332f, -0.10733891f, -0.19517575f, -0.12190833f, 0.00655595f, 
    -0.10759740f, -0.06102737f, 0.01130627f, -0.07955563f, -0.14041974f, 0.01041983f, -0.14566123f, -0.01537246f, 
    0.10731889f, 0.15484209f, -0.00625895f, 0.02449799f, 0.02037696f, 0.00483297f, -0.04016591f, 0.15560618f, 
    -0.10860813f, 0.11164448f, -0.02900072f, -0.12670843f, 0.02451127f, 0.03391065f, 0.14743146f, -0.17542967f, 
    0.00560859f, 0.11006346f, -0.04942255f, 0.25447729f, -0.02452311f, -0.03989168f, -0.07359962f, -0.06185159f, 
    -0.04170521f, -0.08966596f, 0.01172129f, 0.10619262f, 0.19108835f, 0.09710801f, 0.08174008f, 0.11018190f, 
    -0.12640981f, -0.04662097f, -0.01073409f, -0.02827553f, 0.09240489f, 0.12542316f, 0.14674354f, 0.01864294f, 
    -0.03187627f, 0.01861956f, 0.08198284f, 0.01525155f, -0.11688273f, -0.24277620f, 0.01650279f, -0.06819707f, 
    0.18753058f, -0.00115471f, 0.00836952f, 0.16286419f, -0.00764949f, 0.10793848f, 0.07113370f, 0.09382427f, 
    0.01216956f, 0.02031168f, 0.02845480f, -0.00676855f, -0.00210945f, -0.03009559f, -0.03165341f, -0.03400095f, 
    -0.01162265f, -0.00876965f, 0.02464003f, -0.04487565f, 0.01092560f, 0.01897594f, -0.00367704f, 0.02528994f, 
    -0.01768255f, -0.03493804f, -0.01655129f, -0.04259085f, -0.00555449f, -0.00654779f, -0.01064283f, 0.02553108f, 
    -0.01577748f, 0.03393626f, -0.03048531f, 0.00796404f, -0.00791066f, -0.00066921f, 0.02212735f, 0.01804657f, 
    -0.02070823f, 0.03013400f, -0.03520812f, 0.00340106f, 0.02680322f, 0.03409685f, -0.03137375f, -0.02977333f, 
    0.03352793f, 0.01382906f, -0.01952722f, -0.03849924f, 0.01821963f, 0.02514651f, 0.00454587f, 0.01956835f, 
    -0.02450573f, 0.00003110f, 0.00450617f, 0.01358454f, -0.02252745f, -0.01885474f, 0.00832666f, 0.01705174f, 
    -0.04526075f, -0.03544819f, 0.00015299f, 0.00914186f, -0.00175384f, -0.00890231f, -0.01012689f, -0.00302690f, 
    -0.01790676f, -0.03181211f, -0.00607058f, -0.02447854f, 0.00781314f, 0.03204191f, 0.01102644f, -0.00977923f, 
    -0.00615124f, -0.03783227f, -0.00281906f, 0.01321628f, -0.03284280f, 0.02301149f, 0.00346156f, -0.02549342f, 
    -0.00396692f, -0.01172039f, 0.00574244f, 0.02888111f, -0.02610531f, -0.00272523f, -0.01400898f, -0.00376311f, 
    -0.03016483f, -0.03102758f, -0.00080307f, -0.00419347f, 0.02411322f, -0.01540269f, 0.01317960f, -0.03722101f, 
    -0.03263685f, -0.04073469f, 0.01931150f, -0.01675267f, -0.00041155f, -0.01788202f, 0.01726482f, 0.03156352f, 
    0.02966494f, 0.01175172f, -0.02327602f, 0.01817951f, 0.02267688f, 0.00600331f, -0.00031781f, -0.01913961f, 
    0.01463483f, -0.01427851f, 0.01049793f, -0.04186323f, -0.03705817f, 0.02106760f, 0.02683048f, -0.00067641f, 
    0.02939224f, 0.00443870f, 0.01232508f, 0.03646677f, 0.01676207f, -0.01379954f, -0.03643231f, -0.01693716f, 
    -0.03575563f, 0.03452394f, -0.02007949f, -0.00344738f, 0.00696326f, -0.04291961f, 0.01961628f, -0.04228508f, 
    -0.02757626f, -0.00033743f, 0.03022489f, -0.00017256f, -0.00371856f, -0.01642780f, -0.02208016f, 0.00173720f, 
    0.00299977f, -0.02324404f, -0.01538865f, 0.01560915f, -0.01565861f, 0.03003062f, -0.00834501f, 0.01141163f, 
    -0.02300171f, -0.00051402f, 0.02907391f, -0.03449399f, -0.03319008f, -0.02166681f, 0.02194814f, -0.01490580f, 
    -0.00128231f, -0.02289204f, 0.00359444f, -0.03283030f, -0.02096531f, -0.02096287f, -0.01215641f, -0.01399521f, 
    0.00613338f, 0.02160219f, -0.02927798f, 0.02894305f, -0.01134938f, -0.00536265f, 0.03352964f, 0.00982464f, 
    -0.01884904f, -0.02272046f, -0.00154051f, -0.01284991f, -0.03129064f, -0.00722010f, -0.03145495f, -0.03203152f, 
    0.00883630f, -0.02412194f, -0.00203063f, -0.02203499f, -0.03863162f, -0.01456994f, -0.03216512f, 0.01630086f, 
    -0.04124068f, -0.00433450f, 0.03209210f, -0.03045020f, -0.04341405f, 0.03597542f, -0.00393318f, 0.00329522f, 
    -0.01217679f, -0.02002625f, -0.00429688f, -0.00951845f, -0.02494149f, -0.00377125f, -0.01139222f, -0.03495226f, 
    -0.02418317f, -0.03017835f, 0.00098997f, -0.02392682f, -0.04081346f, -0.00697292f, 0.00058349f, -0.03478256f, 
    0.01373506f, 0.01520323f, -0.02151227f, -0.02248140f, -0.01346648f, 0.00190493f, -0.01643917f, 0.00858102f, 
    -0.02701920f, -0.03816114f, 0.01838518f, -0.02523124f, 0.00699379f, 0.01994479f, -0.00884177f, 0.00361792f, 
    0.02217977f, -0.01636806f, 0.00582382f, -0.01490584f, -0.00199361f, 0.00653502f, -0.02133534f, 0.01739428f, 
    -0.03236337f, -0.02169365f, 0.01824844f, -0.03439013f, -0.01210359f, -0.03866304f, -0.00459726f, -0.01058885f, 
    0.02122337f, 0.00706213f, -0.02551966f, 0.02052749f, 0.04342305f, -0.04085010f, 0.01914242f, 0.02319224f, 
    0.02387400f, -0.01414879f, -0.01570043f, -0.02471547f, 0.00996627f, -0.02309360f, 0.01044561f, -0.03382362f, 
    0.02204571f, -0.03010736f, -0.01617604f, 0.02425464f, 0.02852697f, -0.03219914f, -0.02045951f, -0.00724865f, 
    0.02143149f, 0.01645482f, 0.02006283f, 0.01035052f, -0.00111307f, -0.03400758f, -0.01634870f, 0.01047971f, 
    0.02493019f, -0.00116661f, -0.02114081f, -0.00588817f, 0.02147148f, 0.01217867f, 0.02299303f, -0.03618177f, 
    -0.01716785f, 0.00865549f, -0.01105325f, -0.03960372f, -0.02367393f, -0.00862542f, 0.02630976f, -0.01348778f, 
    -0.04296844f, -0.02101144f, 0.02099280f, -0.02749355f, -0.03213209f, 0.02389052f, 0.00540534f, -0.01874002f, 
    0.01043067f, 0.02694917f, 0.01383087f, -0.01210867f, -0.02842285f, -0.01500241f, 0.01874639f, 0.01914489f, 
    -0.01471429f, -0.00904858f, -0.03184085f, 0.03397246f, 0.02203748f, 0.00988001f, -0.02201065f, 0.01441831f, 
    -0.04100417f, -0.04003254f, -0.01767105f, 0.02879669f, 0.02901155f, 0.01181208f, -0.01770761f, 0.01276954f, 
    -0.04073073f, 0.00227845f, 0.02620175f, -0.02569213f, 0.01020038f, 0.01214800f, 0.01533178f, 0.01355928f, 
    -0.02852936f, 0.00395309f, 0.03565577f, -0.04067213f, 0.02593362f, -0.00471396f, 0.01351502f, -0.01825668f, 
    -0.01428272f, 0.00262853f, 0.00157792f, 0.02169944f, 0.01909042f, 0.01081440f, -0.00789052f, 0.01509421f, 
    -0.04041594f, 0.01115454f, -0.03186975f, 0.02382806f, -0.03956008f, -0.03836987f, 0.00243869f, -0.02162070f, 
    -0.02052434f, 0.01557271f, -0.00929080f, -0.03452428f, 0.01619595f, -0.02253672f, -0.01756158f, 0.01310659f, 
    0.01913991f, 0.01048574f, 0.01350273f, 0.03435781f, -0.01158673f, 0.00192285f, -0.00155782f, -0.00486624f, 
    -0.03381142f, 0.02117219f, -0.02510845f, -0.00168206f, -0.03197444f, 0.01223003f, -0.01322046f, -0.01081170f, 
    0.02697602f, -0.01480892f, -0.00360431f, 0.00626355f, -0.01883445f, 0.02268161f, 0.02671495f, -0.03503817f, 
    0.01994620f, -0.01526973f, -0.03149212f, -0.02485671f, -0.03311493f, -0.02935236f, -0.02429217f, -0.01736935f, 
    -0.00000698f, 0.02027276f, -0.00490858f, 0.02672791f, 0.02526744f, -0.00119742f, -0.03321134f, -0.00168103f, 
    -0.04353986f, 0.00147631f, 0.03262111f, -0.01573427f, -0.03187899f, -0.01177540f, -0.00349022f, -0.00559144f, 
    0.00106926f, 0.03346314f, -0.00700996f, 0.02299883f, -0.00424650f, -0.02414725f, -0.00528318f, -0.00198303f, 
    0.01939386f, 0.04327688f, -0.00842586f, 0.00348507f, -0.03488570f, -0.00103002f, 0.02454975f, -0.01818577f, 
    -0.01673418f, 0.01055257f, 0.02598409f, -0.00852220f, -0.01221435f, 0.01083781f, 0.01682322f, -0.00414781f, 
    0.02025543f, -0.00551856f, -0.03354006f, 0.02447295f, 0.01846266f, 0.00047300f, -0.00554007f, 0.01219221f, 
    -0.00428586f, -0.00738363f, -0.01094270f, -0.01689381f, 0.00958536f, -0.03347721f, 0.00776094f, 0.00282992f, 
    0.01733780f, 0.01219932f, -0.02331350f, 0.03391750f, -0.02701793f, 0.02210153f, 0.00134315f, 0.03506914f, 
    0.01362768f, -0.02727065f, -0.00705048f, -0.01509106f, 0.00203774f, 0.02964117f, 0.00327924f, 0.01359053f, 
    0.00935178f, 0.01257991f, 0.00719117f, -0.03807186f, -0.03985981f, 0.01693119f, -0.03665727f, 0.03080727f, 
    0.00185891f, -0.01252641f, 0.00375741f, 0.00274943f, -0.00555213f, 0.03639024f, -0.03843485f, 0.02576685f, 
    0.02965176f, -0.01138813f, 0.02083255f, -0.02201680f, -0.03460808f, -0.02235331f, 0.01377205f, -0.01610278f, 
    0.01307026f, -0.01221232f, -0.04391058f, 0.01286217f, 0.00534924f, 0.02229365f, 0.01369835f, 0.01462082f, 
    0.01946305f, -0.01793969f, -0.03035934f, -0.02686741f, -0.03143607f, 0.00387655f, 0.00833306f, -0.02208525f, 
    -0.04007940f, 0.02926027f, 0.02923031f, -0.02614230f, -0.03609399f, -0.02745114f, 0.02606056f, 0.02851532f, 
    -0.03956391f, -0.01520996f, -0.01016229f, 0.01275538f, -0.03033719f, 0.02549541f, -0.00856721f, -0.02348210f, 
    0.00471464f, -0.03082635f, 0.01223061f, 0.01533778f, -0.01481313f, -0.02494150f, 0.02285379f, 0.02300524f, 
    0.01615442f, 0.00933103f, -0.03533324f, -0.01407051f, -0.00230633f, 0.01492508f, 0.02800961f, -0.03052366f, 
    -0.02546757f, 0.00004472f, -0.03489538f, 0.01130368f, -0.03777207f, -0.04747184f, 0.02389239f, 0.02184026f, 
    -0.01181691f, 0.02191466f, 0.00287287f, -0.02121556f, -0.03917141f, -0.01734938f, 0.00636270f, 0.01630656f, 
    -0.00869118f, 0.00963566f, -0.03110824f, 0.02200538f, -0.02407523f, -0.03909136f, -0.01272441f, -0.00632360f, 
    -0.02560065f, -0.03519536f, -0.01059719f, -0.02071470f, -0.02154409f, -0.02334634f, -0.00480014f, -0.03141666f, 
    0.02032046f, 0.00867455f, -0.00996021f, 0.02340464f, 0.00022904f, -0.03002166f, -0.03228281f, -0.03610288f, 
    0.01881970f, -0.03482504f, -0.03231458f, 0.01816469f, -0.00184567f, -0.02384484f, -0.00549205f, 0.03506828f, 
    0.00833705f, -0.00565457f, 0.01880731f, 0.01663349f, -0.02067281f, 0.00515041f, -0.02235261f, -0.01671070f, 
    -0.01997072f, 0.02473764f, -0.03437769f, -0.01428093f, 0.02313526f, 0.02658979f, 0.01223548f, 0.03273801f, 
    0.01300691f, 0.03192080f, -0.00442764f, -0.00583003f, 0.01250367f, -0.00548948f, -0.03385344f, -0.02512119f, 
    -0.02758063f, -0.02380699f, 0.03337006f, 0.02746611f, -0.01865024f, 0.03040384f, -0.02782248f, 0.01901854f, 
    0.01614094f, 0.02152932f, -0.02396960f, 0.01720374f, 0.00646769f, -0.01370358f, 0.02443057f, -0.01891114f, 
    -0.01295968f, -0.01537983f, -0.02923846f, -0.04131866f, 0.00967709f, -0.03227516f, 0.02336229f, -0.03050961f, 
    0.02562904f, -0.01612566f, -0.03146572f, 0.03955501f, 0.01744240f, -0.01765944f, -0.03495810f, 0.01146938f, 
    0.00799876f, -0.03221624f, -0.01483593f, -0.02221366f, -0.01585399f, -0.02145427f, 0.03024511f, -0.01970608f, 
    0.02256913f, 0.00476497f, 0.01715314f, -0.00543885f, 0.03232135f, 0.01985356f, -0.02936773f, 0.00931277f, 
    -0.01199860f, 0.00202352f, 0.00831551f, 0.00376218f, -0.03032624f, -0.01218372f, -0.02413518f, -0.00032405f, 
    0.01372045f, -0.00759660f, 0.01162587f, 0.01292050f, 0.01384782f, -0.04340530f, 0.01737751f, -0.00594803f, 
    -0.00133080f, 0.01819789f, 0.00983726f, -0.02999417f, 0.03991261f, -0.00684026f, -0.00071613f, -0.03081748f, 
    0.00842606f, 0.02370423f, 0.02219593f, -0.02335345f, 0.03190621f, 0.03380812f, -0.00272691f, -0.02501660f, 
    -0.00997909f, -0.01405969f, -0.03249407f, -0.03874186f, -0.02847101f, -0.03904198f, 0.02011382f, -0.01177276f, 
    -0.01624356f, 0.03132696f, 0.00596341f, -0.03026876f, 0.02576840f, 0.04364597f, 0.00437702f, -0.00045218f, 
    0.00082103f, 0.00130471f, -0.03742295f, -0.00440583f, -0.01096513f, 0.02664632f, 0.00431968f, -0.01321395f, 
    -0.02938111f, 0.02315419f, 0.01878031f, -0.04162350f, 0.00551718f, -0.00049731f, -0.01141615f, 0.02768865f, 
    0.01209657f, 0.01233399f, 0.03599698f, -0.03254189f, 0.01249418f, -0.02607384f, -0.00188903f, -0.00977058f, 
    -0.03940435f, -0.03833425f, 0.02364806f, 0.00787341f, -0.01372404f, 0.01957718f, -0.00119721f, -0.00736113f, 
    0.01889779f, -0.00235265f, 0.00544173f, 0.01083141f, 0.01658021f, 0.02436079f, 0.00998041f, 0.01834160f, 
    -0.00065648f, -0.02959841f, 0.03213861f, -0.00164829f, 0.00611094f, -0.01557181f, -0.03752786f, 0.02965516f, 
    -0.02794239f, -0.00971752f, 0.00778154f, -0.02499205f, -0.00462897f, -0.01655823f, 0.01075630f, 0.03790571f, 
    -0.01389153f, -0.03883159f, -0.03015577f, 0.01370928f, 0.00866258f, -0.03799528f, -0.00465632f, -0.02373847f, 
    0.02099288f, -0.01018078f, 0.00618285f, -0.02127587f, -0.00956691f, -0.01128900f, 0.00416902f, -0.03148640f, 
    0.00461351f, 0.01194325f, 0.01015701f, -0.02649080f, 0.02185649f, -0.02671838f, -0.02079133f, 0.01517446f, 
    0.02383023f, -0.00868873f, 0.01625987f, -0.02925326f, 0.01558257f, -0.01013571f, -0.03664966f, -0.01100250f, 
    -0.00313761f, 0.01627753f, 0.02217730f, 0.02220117f, -0.02972907f, -0.01433649f, -0.00964185f, -0.03089580f, 
    -0.00066310f, -0.03829121f, -0.01738626f, -0.03148781f, 0.02254651f, -0.02414384f, 0.00619522f, -0.01350453f, 
    -0.01352037f, 0.01933077f, 0.01336947f, 0.00114807f, -0.00239945f, 0.00740466f, -0.03894541f, -0.02645252f, 
    -0.01690406f, -0.00035970f, 0.00877395f, 0.00872622f, 0.00767497f, 0.00944063f, -0.00748102f, -0.01003890f, 
    -0.01765601f, -0.02070449f, 0.02692047f, -0.00475004f, 0.01718386f, -0.02789495f, 0.02391260f, -0.00932379f, 
    0.02562909f, -0.02791672f, 0.00570313f, -0.01798092f, 0.02567664f, -0.01222142f, -0.03321655f, 0.02264657f, 
    -0.03553348f, -0.00122960f, -0.00291290f, 0.02827746f, 0.02320407f, -0.02871739f, -0.00877516f, 0.02666801f, 
    0.01235348f, 0.01324079f, 0.02966080f, -0.00201360f, -0.03212554f, -0.00989245f, 0.01046214f, -0.00673164f, 
    -0.03029488f, -0.00785508f, -0.02249801f, -0.00013810f, 0.00445779f, -0.03740101f, 0.02785451f, -0.00340003f, 
    0.00001186f, 0.02881045f, -0.03526628f, 0.00601292f, -0.02345311f, -0.03474043f, -0.02139752f, 0.00274784f, 
    0.00968169f, 0.02439281f, -0.01073991f, -0.02332915f, -0.02698913f, 0.01715891f, -0.02329759f, -0.02606258f, 
    -0.00872330f, 0.03206769f, 0.00753212f, 0.00100039f, -0.00843168f, 0.00233162f, 0.00106133f, 0.03046741f, 
    0.02593373f, -0.00526193f, -0.03538684f, 0.01796321f, 0.01727411f, -0.00959918f, 0.00077512f, -0.03601047f, 
    0.01719227f, -0.01202514f, -0.00040466f, -0.03527973f, 0.03246574f, 0.01702173f, -0.02236347f, -0.01710479f, 
    -0.00010426f, -0.02402232f, -0.02313579f, 0.01973112f, -0.01868739f, -0.02285061f, 0.01493766f, -0.03623766f, 
    -0.02477263f, -0.00513706f, -0.03348148f, -0.01688998f, -0.00515766f, -0.01882842f, -0.01045570f, -0.00691664f, 
    0.01461283f, -0.03406049f, -0.01650208f, 0.00646927f, -0.00116848f, 0.00367070f, -0.01619362f, 0.02679784f, 
    0.01177527f, -0.00510975f, -0.00650485f, 0.02942251f, 0.03007514f, -0.01590190f, 0.00723779f, -0.02544549f, 
    0.00410621f, 0.02042005f, -0.03715356f, -0.01529853f, 0.00042224f, 0.02933130f, -0.00049333f, -0.01606936f, 
    0.00092970f, 0.00753386f, -0.03885515f, -0.03547934f, 0.01082048f, -0.02738899f, 0.01083538f, -0.01818667f, 
    0.01005600f, -0.03416448f, -0.03866464f, 0.00135183f, -0.03951348f, -0.00041604f, -0.03352129f, 0.02418381f, 
    -0.01308544f, -0.02455068f, 0.02829494f, 0.00078856f, -0.01155467f, 0.01163722f, -0.01604955f, -0.00432810f, 
    0.02900565f, -0.01066181f, -0.00729204f, 0.01427580f, -0.01327584f, 0.00948576f, 0.03274988f, 0.00226068f, 
    0.02662577f, -0.00120775f, -0.02861180f, -0.01116948f, -0.03937423f, 0.00717315f, -0.03517029f, -0.01754047f, 
    -0.00177041f, -0.01937997f, 0.00968668f, 0.00756361f, -0.03318851f, 0.02597309f, -0.01831279f, 0.02887968f, 
    0.01566935f, -0.01759927f, 0.00642481f, -0.02850392f, -0.00257459f, 0.01706479f, 0.02297959f, 0.00405289f, 
    0.02013630f, -0.02786321f, -0.00514733f, 0.01800628f, 0.00153339f, 0.02445947f, -0.01343567f, -0.03312668f, 
    0.00821601f, -0.03175555f, 0.01060666f, -0.02755981f, 0.00367215f, -0.03804480f, -0.01081110f, 0.00996703f, 
    -0.00843845f, 0.03587210f, 0.03523152f, -0.00249640f, 0.02041686f, -0.00247068f, -0.02959128f, -0.00557814f, 
    -0.03348164f, 0.02030596f, -0.02153641f, -0.00340446f, 0.01299008f, -0.00013925f, -0.03311820f, -0.03189372f, 
    -0.02606804f, -0.01586641f, -0.01429251f, -0.03386635f, -0.02598147f, 0.00357253f, -0.01681186f, -0.00969207f, 
    -0.00663474f, -0.03332163f, 0.03284210f, 0.02194632f, 0.02644966f, 0.00130194f, -0.01300473f, 0.00351463f, 
    -0.02797178f, -0.02143293f, 0.00866877f, 0.01505732f, 0.00395140f, -0.02597253f, 0.00194867f, -0.00822626f, 
    -0.04107350f, -0.02722801f, 0.00467494f, 0.02116523f, -0.02704588f, -0.01516905f, -0.00071619f, -0.01422111f, 
    0.01024055f, 0.00934355f, -0.01995688f, -0.03762750f, -0.03243873f, -0.01842857f, 0.01185639f, 0.00242284f, 
    -0.00190239f, -0.00695809f, -0.03803588f, -0.01424888f, -0.00832631f, 0.01728632f, 0.02549001f, 0.00996100f, 
    0.02612528f, 0.01217306f, -0.01716148f, 0.00539001f, -0.01171147f, -0.03034801f, -0.03019633f, 0.01629239f, 
    -0.03342959f, -0.03761561f, 0.00068891f, 0.02062254f, -0.01485265f, -0.03906928f, -0.01707255f, -0.03565456f, 
    -0.01787543f, -0.01417751f, -0.03867264f, 0.00682079f, -0.01179513f, 0.03078837f, 0.01891632f, 0.00387963f, 
    -0.00718066f, -0.03014692f, 0.00481829f, -0.00509031f, 0.00335755f, -0.02826517f, -0.01078369f, -0.02614161f, 
    0.01283960f, -0.03730521f, -0.00653591f, -0.00412874f, 0.01922454f, 0.00176563f, -0.01120925f, -0.03669641f, 
    -0.03234575f, -0.03273543f, -0.01572088f, 0.00707231f, -0.03031592f, -0.00528382f, -0.00330674f, -0.03930034f, 
    -0.00816802f, 0.01314926f, 0.01717561f, -0.02615195f, -0.01848953f, -0.00240969f, -0.03747583f, -0.01439033f, 
    0.00724455f, 0.03022944f, 0.00476170f, 0.03508331f, -0.03402941f, -0.01583340f, 0.03233943f, -0.03814082f, 
    0.00587958f, 0.00244140f, -0.01677941f, 0.00547364f, 0.01303137f, 0.00400891f, -0.03428506f, -0.03501850f, 
    0.00539366f, -0.02062144f, -0.01231519f, 0.01050294f, -0.02783735f, 0.00788109f, 0.02592303f, 0.00749486f, 
    -0.03637789f, -0.00773988f, 0.00756149f, 0.02718902f, -0.00467865f, -0.00691656f, 0.00020309f, 0.03440444f, 
    0.02119153f, 0.03266957f, 0.02643329f, -0.03243828f, -0.01985136f, -0.00389993f, -0.00892228f, 0.00713164f, 
    -0.02107176f, -0.02492223f, 0.01836184f, -0.02886736f, 0.02080790f, 0.01638811f, -0.00731888f, -0.01248084f, 
    0.01612426f, -0.03119110f, 0.02947636f, -0.02487204f, -0.00994028f, 0.01919410f, 0.02112409f, 0.01784896f, 
    -0.02046827f, 0.02296678f, 0.01009114f, -0.01626032f, -0.02093905f, -0.02800131f, 0.02680142f, 0.02667272f, 
    0.01696130f, -0.04138798f, -0.03516755f, -0.00142762f, 0.00898072f, 0.00642643f, -0.02785782f, 0.01179422f, 
    -0.03336313f, 0.00205395f, 0.01364813f, -0.00715772f, -0.00175383f, 0.00512858f, 0.03506122f, -0.02072530f, 
    -0.00897082f, -0.02174636f, 0.02214083f, 0.02650298f, -0.01510348f, -0.01299186f, -0.03537877f, -0.04038446f, 
    -0.01510727f, 0.01623443f, -0.03598267f, -0.00419603f, -0.01723985f, -0.03013951f, -0.03993728f, -0.01684347f, 
    -0.00408944f, -0.02987305f, 0.01633958f, -0.00289350f, 0.01329677f, 0.01501333f, 0.00817713f, -0.00432975f, 
    -0.01235905f, -0.01219387f, -0.03552795f, -0.02676221f, -0.03171120f, 0.02581978f, -0.03442726f, -0.03438987f, 
    -0.00360540f, -0.02792131f, 0.00868170f, 0.00370792f, -0.00533014f, 0.02597077f, -0.00542857f, -0.02968712f, 
    0.01298329f, 0.01303445f, -0.00090996f, 0.00529790f, 0.01625634f, 0.00424419f, -0.02852116f, 0.01143680f, 
    -0.01601476f, 0.01744249f, 0.01122776f, -0.00138217f, -0.01782157f, -0.03432988f, 0.01095565f, -0.00722533f, 
    0.01332571f, 0.01624388f, 0.02941710f, -0.02495180f, -0.02492640f, -0.03171717f, -0.01881537f, -0.02894651f, 
    0.00058098f, -0.03751376f, -0.02547167f, -0.01303377f, 0.03435349f, -0.02007805f, 0.01596895f, -0.04151722f, 
    -0.02517912f, -0.02493153f, 0.02103205f, -0.02697981f, -0.03029427f, 0.01903965f, 0.01186120f, -0.02780706f, 
    0.00939163f, -0.01265364f, -0.02636272f, 0.00056530f, -0.00838206f, 0.00228003f, -0.03337562f, 0.01114454f, 
    -0.00138902f, -0.02896659f, -0.01640682f, -0.01753670f, -0.01761901f, -0.00809806f, -0.03235254f, -0.00835430f, 
    -0.02747771f, -0.03511832f, -0.02397867f, -0.01434069f, -0.02880271f, -0.01957414f, -0.01066615f, 0.00601778f, 
    0.00767488f, -0.03399982f, -0.02956852f, -0.03015134f, 0.00847537f, -0.01313356f, -0.04128162f, -0.02427543f, 
    0.02605316f, -0.00014034f, 0.01317238f, 0.01331117f, 0.02626632f, 0.00861262f, -0.01613591f, -0.01866812f, 
    0.00020101f, 0.01543517f, 0.00945992f, -0.03949793f, 0.00854325f, -0.00961406f, -0.02297824f, -0.02035066f, 
    0.02449547f, -0.01226070f, -0.02684521f, -0.01529312f, -0.02318084f, -0.04041320f, -0.00696389f, -0.01564244f, 
    0.01763209f, 0.00677629f, -0.00951324f, -0.00432142f, 0.00636765f, -0.02105901f, -0.02093463f, 0.02810631f, 
    -0.03353663f, 0.00555775f, 0.01246265f, -0.03777716f, -0.00740376f, -0.02451240f, 0.02017266f, 0.02754732f, 
    -0.02384156f, -0.00221737f, -0.02200049f, 0.00537993f, 0.01703130f, 0.00896983f, -0.00670376f, -0.00389382f, 
    -0.01821091f, 0.01386178f, -0.03985132f, -0.01555996f, -0.02322543f, 0.01291290f, 0.02827509f, -0.02140818f, 
    0.01622481f, -0.03061560f, -0.02173771f, -0.00978351f, -0.01057291f, -0.01023857f, 0.00718794f, 0.01776478f, 
    -0.02602954f, 0.03050049f, -0.00338988f, 0.02207928f, 0.02995344f, -0.03264002f, 0.00866366f, 0.02252237f, 
    -0.03646069f, 0.02959195f, 0.01103723f, 0.01766010f, -0.02319230f, 0.00515193f, -0.01453713f, 0.01760984f, 
    -0.02478079f, 0.01186164f, -0.02772456f, 0.01426345f, 0.01741883f, 0.02623485f, -0.00307577f, -0.02537544f, 
    -0.00107956f, 0.02774236f, 0.02561265f, 0.02202552f, 0.01647103f, -0.03977039f, 0.02689903f, -0.03834399f, 
    0.03045796f, 0.00992156f, -0.01448263f, -0.01096606f, -0.01091641f, -0.03386281f, -0.01728996f, 0.01016993f, 
    -0.01129686f, -0.01716604f, 0.01083104f, -0.02915599f, -0.03046432f, -0.03543352f, -0.00877547f, -0.01426863f, 
    0.00073061f, -0.03915257f, -0.02452943f, 0.00714289f, 0.01585367f, 0.02242953f, -0.03466285f, -0.00870746f, 
    0.03119648f, -0.03053104f, -0.01997055f, 0.02864650f, 0.02334721f, -0.03342272f, -0.03474415f, 0.00414934f, 
    -0.01591967f, 0.02007100f, -0.01113436f, 0.00720366f, -0.01852855f, -0.00695601f, -0.03853004f, 0.01900718f, 
    -0.01814848f, -0.00317243f, -0.00213919f, 0.02587374f, 0.01254181f, 0.00949374f, 0.01386854f, -0.03719469f, 
    -0.03504359f, 0.02784774f, 0.00292154f, 0.00223288f, -0.03289589f, 0.01532762f, 0.02836855f, -0.01328519f, 
    -0.02744919f, -0.01076046f, -0.00534237f, 0.00902282f, 0.01237942f, -0.03901414f, -0.02445607f, -0.01120170f, 
    -0.00309076f, -0.01186030f, -0.03852424f, 0.00863157f, -0.02834389f, -0.01642215f, -0.01874823f, -0.01224294f, 
    0.01769559f, 0.00987850f, -0.02524021f, -0.01893756f, -0.01211630f, -0.01867953f, -0.01232195f, 0.02262232f, 
    0.01124830f, 0.01397239f, 0.02422709f, 0.02026558f, -0.02384621f, -0.02811738f, 0.01016117f, -0.01339003f, 
    0.02824654f, -0.01490351f, 0.02856396f, 0.00934171f, 0.01208682f, -0.02755224f, -0.00305637f, -0.03238741f, 
    0.01013086f, -0.03315257f, -0.01508771f, 0.02811489f, -0.00307904f, -0.01294107f, 0.00513284f, -0.00867271f, 
    0.17364746f, -0.07316710f, -0.00633644f, 0.06602914f, 0.13981484f, 0.16074592f, 0.02009738f, 0.14022455f, 
    -0.07880970f, 0.00800468f, -0.09525239f, -0.03983937f, -0.06704887f, 0.19386515f, 0.33589417f, -0.36184102f, 
    0.09049391f, -0.14916943f, 0.07392105f, 0.05893865f, -0.06543742f, 0.01474142f, -0.02762667f, -0.06730294f, 
    0.11335696f, 0.07748663f, -0.16516697f, -0.14321078f, 0.02588793f, 0.07042072f, 0.07263498f, -0.09720034f, 
    -0.07188372f, 0.00140322f, -0.11038831f, 0.01124128f, 0.17246132f, 0.20043842f, -0.11836295f, -0.14115970f, 
    0.15261433f, 0.07198393f, 0.07170025f, -0.07408705f, -0.13435899f, -0.18630746f, 0.03474323f, 0.04390328f, 
    -0.15908515f, 0.19367638f, 0.26143870f, 0.11692012f, -0.05488412f, -0.07096604f, -0.12152592f, -0.02241854f, 
    0.05808874f, -0.00934572f, 0.16434413f, 0.04801196f, 0.25431290f, 0.47807994f, -0.03662170f, 0.06451079f, 
    0.04039160f, 0.06627115f, 0.16358778f, -0.03849452f, 0.05844454f, 0.05940358f, -0.07254200f, 0.00746079f, 
    0.00283822f, 0.15605798f, 0.11083783f, 0.02232777f, -0.00710027f, -0.05768487f, -0.07328629f, -0.03014245f, 
    0.07607763f, 0.06015399f, 0.07294583f, 0.10064704f, 0.12731530f, 0.09824111f, -0.21604460f, -0.12394436f, 
    0.00641327f, 0.04183979f, 0.02239384f, 0.28605819f, -0.08196986f, 0.10766976f, 0.00999513f, 0.00903275f, 
    0.22630847f, 0.14480017f, -0.03119740f, -0.06556678f, -0.09294930f, 0.06448340f, -0.06295735f, 0.06104163f, 
    -0.01697334f, 0.07499431f, -0.09023284f, 0.03055900f, 0.14222503f, 0.04293780f, -0.13161094f, -0.07612702f, 
    0.17668673f, 0.18788426f, -0.07603259f, 0.05060614f, 0.02959944f, 0.03941050f, -0.00766710f, -0.03641845f, 
    0.04282413f, 0.07387380f, 0.13721709f, 0.03476601f, -0.01268447f, 0.11092174f, -0.19027860f, 0.08013807f, 
    -0.01019194f, 0.02498103f, 0.05505420f, 0.01089865f, -0.13418680f, 0.25788993f, -0.00493106f, 0.24904691f, 
    -0.17843403f, 0.08711699f, -0.16426562f, 0.01493665f, -0.02938379f, 0.02104742f, 0.09689932f, 0.03516423f, 
    0.13458456f, 0.09803332f, 0.12700781f, -0.09130545f, 0.14166437f, 0.13900454f, -0.10912161f, 0.01686201f, 
    -0.00381699f, 0.15393893f, 0.14739196f, 0.14627752f, -0.20009767f, 0.24419415f, -0.06197805f, -0.12424139f, 
    -0.04121907f, -0.06030205f, -0.00526576f, 0.03500199f, 0.15298568f, -0.20049751f, -0.00141470f, 0.01275261f, 
    0.17564338f, -0.00454544f, -0.11767640f, -0.06554651f, 0.05439071f, 0.09322145f, -0.00814526f, -0.18464859f, 
    -0.01992049f, -0.05420946f, 0.01271547f, 0.08413936f, -0.10535235f, -0.37373891f, -0.16643526f, 0.09677127f, 
    0.00016031f, 0.12533408f, -0.03125437f, -0.03873021f, 0.05038086f, -0.21787003f, 0.09468684f, -0.01145588f, 
    0.18057421f, 0.00912482f, -0.25548792f, -0.11777069f, 0.01504591f, 0.01721998f, 0.08228313f, 0.03926916f, 
    0.05767543f, -0.06459771f, 0.13151561f, 0.10038110f, -0.19428408f, 0.13082764f, -0.06683592f, 0.02506893f, 
    0.01998779f, 0.01215095f, 0.00362801f, -0.02430432f, 0.00342577f, -0.17517528f, -0.15407731f, -0.06235471f, 
    0.05748922f, -0.04546265f, -0.01710631f, -0.08310509f, -0.04735046f, 0.03041444f, -0.04547447f, -0.01131874f, 
    -0.00312350f, -0.04471464f, -0.16926031f, 0.07236817f, 0.30745265f, 0.12113584f, -0.14378808f, -0.19902177f, 
    -0.02191005f, -0.05098778f, 0.06497763f, -0.02705879f, 0.03094126f, -0.14481711f, 0.07510711f, 0.01934163f, 
    0.01505827f, 0.12020737f, 0.23815618f, 0.09888250f, 0.03075008f, -0.14555578f, -0.11971315f, -0.03857731f, 
    -0.04617469f, 0.02937272f, 0.09194453f, 0.02052772f, 0.30850527f, 0.13763206f, -0.31211174f, 0.07646086f, 
    0.07996377f, -0.01292918f, 0.12335645f, 0.04448786f, -0.06774379f, -0.08735913f, -0.01780172f, 0.04650060f, 
    -0.08562757f, -0.27852422f, -0.32400733f, 0.04578188f, 0.10056205f, 0.17193964f, 0.14903305f, 0.06867851f, 
    0.06464212f, 0.05829411f, 0.07980797f, -0.13748376f, 0.06666937f, -0.15075810f, 0.29968801f, 0.16220692f, 
    0.01754546f, 0.10088130f, -0.20998193f, -0.05423756f, 0.11921849f, -0.00351935f, -0.00917939f, -0.11287002f, 
    -0.14341146f, -0.32566041f, 0.03224513f, -0.02407371f, -0.04042283f, 0.03112897f, -0.07143897f, -0.05205453f, 
    -0.00506889f, 0.02855982f, 0.03189902f, -0.24195243f, 0.04631672f, 0.21700048f, 0.24611123f, 0.05977605f, 
    -0.00386740f, 0.07358412f, 0.06015572f, 0.02463738f, 0.01938811f, 0.02493781f, 0.11142522f, 0.00749950f, 
    0.14434800f, -0.22053941f, -0.38643897f, 0.19453330f, -0.06345380f, 0.16437165f, 0.05440389f, 0.08462241f, 
    -0.08146583f, 0.14016277f, 0.07379172f, -0.12252997f, -0.04185250f, -0.02520651f, -0.14943756f, -0.18142872f, 
    0.04440900f, 0.06625385f, 0.05283323f, 0.08512338f, 0.02933733f, -0.09857112f, 0.10852247f, 0.15391156f, 
    -0.22162607f, -0.12473027f, 0.27017987f, 0.10260869f, 0.04583436f, 0.11785543f, -0.07394840f, -0.00464401f, 
    -0.08969869f, 0.12667446f, 0.07187951f, -0.12250808f, -0.16891992f, -0.44910836f, -0.13242799f, 0.24504158f, 
    -0.04110442f, 0.30326799f, -0.03769591f, -0.16518781f, 0.08467460f, -0.00784877f, -0.09579573f, -0.04123825f, 
    0.06176221f, 0.16886850f, 0.00077360f, -0.03181715f, 0.00803012f, -0.04886789f, -0.02315138f, 0.00895845f, 
    -0.00417688f, -0.05738819f, 0.03229324f, 0.18214077f, 0.05271091f, 0.01416137f, 0.35686675f, 0.08073119f, 
    0.06335848f, -0.01377867f, -0.14850877f, 0.00954893f, -0.07563271f, 0.02937973f, 0.09328846f, 0.07323281f, 
    0.28142747f, 0.36804304f, -0.16280930f, -0.09089434f, 0.14721593f, 0.20348532f, 0.01845295f, -0.04665397f, 
    -0.07967553f, -0.05964892f, -0.01949056f, 0.01931612f, 0.14049421f, -0.04486702f, -0.14794137f, 0.01815007f, 
    0.03346765f, 0.05385801f, -0.02306958f, -0.01913184f, 0.00095398f, -0.08991969f, -0.01377172f, 0.14940394f, 
    -0.02127866f, 0.03230340f, 0.05149919f, 0.07220175f, 0.00381044f, 0.00774845f, -0.02119919f, -0.04825021f, 
    -0.06427588f, 0.00493575f, 0.02186171f, -0.12835023f, -0.02913977f, 0.06065377f, -0.09778520f, -0.02627531f, 
    0.02716801f, 0.12552819f, 0.09535223f, -0.05783014f, 0.09543022f, 0.02680236f, -0.04429627f, 0.03546178f, 
    -0.05155504f, -0.22818865f, -0.19725347f, 0.01552487f, 0.02447263f, 0.23150240f, 0.13207550f, -0.03609484f, 
    0.02573297f, 0.23050137f, 0.04812311f, -0.15391752f, -0.18414591f, 0.10431553f, 0.01980097f, 0.04500839f, 
    0.01222903f, 0.03930019f, -0.08062050f, 0.05440519f, 0.02246894f, -0.01180653f, -0.13779838f, 0.01555882f, 
    0.36379436f, -0.16690464f, 0.08710633f, -0.02877934f, 0.06539279f, -0.04400858f, 0.01065905f, -0.05410717f, 
    0.14106531f, 0.08739760f, 0.02881505f, 0.04781376f, 0.09254726f, -0.02499462f, 0.03367662f, 0.01067034f, 
    -0.06971886f, 0.02274093f, -0.03398116f, 0.06942683f, 0.02417544f, -0.00447274f, 0.05104376f, 0.00084781f, 
    0.17623049f, 0.14297448f, -0.05314057f, -0.24880484f, 0.16201600f, 0.05018446f, 0.04924190f, -0.04706869f, 
    0.02698782f, 0.07320372f, 0.01700464f, 0.00577869f, 0.12896389f, -0.14784382f, -0.14352976f, -0.29832101f, 
    0.20279568f, 0.11462644f, 0.21164091f, -0.12737921f, -0.04168130f, -0.11044712f, 0.06111791f, 0.02151262f, 
    0.13456015f, 0.18479754f, 0.19052581f, -0.12906264f, -0.17948303f, -0.04519892f, -0.11003225f, 0.04462777f, 
    0.06420892f, 0.07558993f, 0.03777726f, 0.12273110f, 0.20097709f, 0.03920351f, 0.27264652f, -0.00968030f, 
    0.02362258f, -0.13168022f, -0.12959680f, -0.01196320f, 0.05225896f, 0.04751528f, 0.07445668f, 0.05198435f, 
    -0.08742411f, -0.05911378f, 0.11872357f, 0.05235885f, -0.00096244f, -0.04342647f, -0.08171678f, 0.03973432f, 
    -0.09948315f, 0.09900685f, -0.05093351f, -0.11288446f, -0.28915080f, -0.22026247f, -0.21122317f, -0.07161672f, 
    0.07442941f, 0.09872304f, 0.03790989f, 0.00178772f, -0.05628164f, -0.01278589f, 0.00318240f, -0.03454095f, 
    0.10660220f, 0.31725943f, 0.22812195f, 0.12432337f, -0.01397514f, -0.15547803f, -0.18446375f, -0.01720154f, 
    0.07293930f, 0.07765672f, 0.01518161f, 0.07271028f, -0.09608865f, 0.08380236f, 0.23517299f, 0.09319957f, 
    0.17030291f, -0.07379390f, -0.09874524f, 0.00844492f, -0.08360055f, 0.02495816f, -0.03779124f, 0.16973485f, 
    -0.16553617f, 0.07812585f, 0.04338863f, 0.16233753f, 0.05296463f, 0.10206220f, -0.00718423f, -0.07456750f, 
    0.04639300f, -0.22086014f, -0.02125294f, 0.13370311f, 0.09093367f, -0.17178184f, -0.28414819f, 0.25334036f, 
    0.03778976f, 0.22153950f, 0.05706869f, 0.16290192f, -0.21560274f, 0.05217667f, 0.15192620f, -0.00547186f, 
    0.09942143f, 0.31878871f, -0.13425864f, -0.13006668f, -0.13859963f, 0.05989132f, 0.03692953f, -0.01362154f, 
    0.04807657f, 0.02579453f, 0.10278034f, 0.02593943f, 0.06790540f, 0.10150053f, 0.15541461f, 0.03638786f, 
    -0.15345712f, -0.20790665f, -0.06528671f, -0.06049462f, 0.03101988f, -0.02434135f, 0.05092513f, -0.03258227f, 
    0.00515931f, -0.05372757f, 0.23426698f, -0.06732652f, 0.19569521f, -0.10072147f, -0.08525285f, 0.05942728f, 
    0.03680215f, 0.10297953f, 0.07232476f, 0.04874254f, 0.06782167f, -0.14991429f, -0.19600484f, 0.03967159f, 
    0.10832915f, 0.23927395f, 0.20566711f, -0.03709151f, -0.04556215f, -0.09355265f, -0.00644096f, -0.03085621f, 
    0.13208675f, 0.04705706f, -0.19314405f, -0.06419443f, 0.07648449f, 0.02378950f, -0.00092126f, 0.01674543f, 
    -0.00353563f, -0.02862858f, -0.05178712f, 0.04218701f, 0.11822718f, -0.01826988f, 0.03839782f, -0.05392468f, 
    0.00278507f, -0.05565720f, 0.00797357f, 0.00884813f, -0.11299026f, -0.00791454f, -0.03392022f, -0.02744251f, 
    -0.09512732f, -0.18584700f, 0.16540135f, 0.19477543f, 0.03861905f, 0.04506560f, -0.14426640f, 0.07209662f, 
    -0.02526583f, 0.03258364f, 0.02915646f, 0.04482379f, 0.22963281f, 0.36178210f, 0.00061929f, -0.23367493f, 
    -0.11153024f, -0.18937381f, 0.13661143f, 0.04344872f, -0.04899589f, -0.12182405f, -0.15728638f, -0.00193629f, 
    0.11417783f, 0.11187790f, 0.07331886f, -0.09220103f, 0.00217986f, -0.02172921f, -0.07011782f, 0.01846552f, 
    -0.01216239f, 0.12016247f, 0.08134384f, 0.06715942f, 0.32099670f, -0.27798355f, 0.05819352f, -0.11436694f, 
    -0.02053714f, 0.08550961f, 0.05757858f, -0.00535364f, 0.00064233f, -0.04039815f, 0.01508457f, 0.02457068f, 
    0.03058225f, 0.19927783f, 0.12418771f, 0.04691955f, 0.06393530f, -0.01323508f, -0.00950824f, -0.14718033f, 
    0.08479164f, 0.03244045f, 0.07301547f, 0.07460945f, -0.12683250f, 0.12356909f, -0.09678704f, 0.04756474f, 
    0.00771944f, -0.05516360f, 0.17731072f, 0.09823167f, 0.12839678f, 0.00659499f, 0.11307551f, -0.04423798f, 
    0.17301829f, -0.06351471f, 0.02830896f, -0.00123497f, 0.10600640f, 0.12429931f, 0.09576312f, 0.11527480f, 
    -0.05593845f, 0.06931180f, 0.06049018f, -0.04418634f, -0.26347226f, -0.29564247f, 0.18530856f, 0.06689148f, 
    -0.03743748f, 0.13988301f, 0.05099685f, -0.17041712f, -0.17578825f, 0.21971387f, 0.12703587f, 0.00808924f, 
    -0.03539086f, -0.00178882f, -0.01783098f, 0.00552652f, 0.00583923f, 0.00784510f, -0.03978585f, 0.00959017f, 
    -0.03181423f, -0.01114361f, -0.00804706f, -0.03229165f, 0.03375570f, -0.00878598f, -0.01664737f, 0.02823563f, 
    0.01906694f, -0.00924965f, -0.03003189f, -0.00017915f, -0.02785389f, -0.03466030f, 0.00358278f, 0.01169417f, 
    0.02184826f, -0.04034402f, 0.00925371f, 0.02688616f, -0.02172541f, -0.01906654f, 0.02443223f, -0.00932789f, 
    -0.03088019f, -0.01122343f, -0.01951970f, 0.01027356f, -0.04190057f, 0.02356146f, -0.02355516f, 0.02093823f, 
    0.02735623f, -0.02743224f, -0.02575722f, -0.03008994f, 0.01638495f, 0.02797536f, -0.02984402f, -0.01853697f, 
    -0.02628644f, -0.01042556f, 0.00321922f, 0.00291867f, 0.02344619f, -0.02540406f, 0.02056018f, -0.03529649f, 
    -0.02690155f, -0.00690848f, -0.02358687f, 0.02175466f, -0.04087305f, -0.03239294f, 0.00057735f, -0.04118016f, 
    0.02603303f, -0.01699823f, 0.02453846f, -0.01864418f, 0.00685233f, 0.00321113f, -0.03091555f, -0.03946374f, 
    -0.00050166f, -0.02108933f, -0.00705583f, -0.02064280f, 0.02065941f, 0.01148208f, -0.02488163f, 0.01531804f, 
    0.00355418f, -0.00371973f, 0.02642628f, 0.01343256f, 0.00619689f, -0.01677351f, -0.02949606f, -0.00020695f, 
    -0.00485398f, -0.03202619f, 0.01713202f, -0.01566957f, -0.04095413f, 0.01991478f, -0.01163330f, -0.04187699f, 
    0.01035967f, 0.00587422f, -0.01423588f, 0.02946433f, 0.00864810f, -0.03379715f, 0.02657645f, 0.00221686f, 
    0.01029067f, 0.01371405f, -0.02191392f, 0.00158695f, 0.00361020f, -0.00919154f, 0.01227694f, 0.02252369f, 
    -0.03791035f, 0.00400271f, 0.00334824f, 0.00974721f, 0.01460067f, -0.02664841f, 0.01247324f, -0.01832363f, 
    0.02269247f, 0.02200198f, -0.00824777f, 0.01471550f, -0.03428590f, 0.00947582f, -0.03627898f, 0.01935413f, 
    0.00840341f, -0.01361908f, 0.02663490f, 0.02264985f, 0.02899655f, 0.01444557f, -0.01868959f, 0.01659633f, 
    -0.02721255f, 0.01615358f, -0.02628007f, 0.02949281f, 0.01679668f, 0.00296120f, -0.00806445f, -0.01726616f, 
    0.03140151f, -0.02202829f, -0.02859410f, -0.00543399f, -0.02080308f, 0.00910029f, 0.00723694f, -0.01760865f, 
    0.02137764f, 0.02407826f, -0.03004329f, -0.01768172f, 0.00776239f, 0.03266185f, 0.01101862f, 0.01764630f, 
    -0.01769412f, -0.02448339f, 0.00615960f, -0.00714792f, -0.00203090f, -0.00453464f, -0.01415494f, 0.00299035f, 
    0.02589239f, 0.02466546f, -0.03991712f, -0.02634936f, -0.04098096f, 0.01441559f, -0.00749564f, -0.02496422f, 
    0.00898844f, -0.01205423f, -0.00854619f, -0.01643211f, 0.00879046f, -0.02565159f, 0.02470130f, -0.03846495f, 
    -0.00771351f, -0.01235290f, -0.02902996f, -0.01731948f, -0.02768986f, 0.00620893f, -0.01568075f, 0.00321447f, 
    -0.02295166f, -0.03058722f, -0.02918622f, -0.03087133f, -0.02720916f, -0.01120379f, 0.00916764f, -0.00676623f, 
    0.02083275f, -0.04177225f, 0.00975100f, -0.00163085f, -0.00931354f, -0.00732263f, 0.00250847f, 0.02033752f, 
    -0.02059927f, 0.01298242f, -0.03059183f, 0.00552995f, 0.00438001f, -0.01983677f, -0.02672273f, -0.03184140f, 
    0.01217439f, 0.01856345f, -0.04194655f, -0.02221811f, 0.00503512f, -0.03341252f, -0.01840218f, 0.02455372f, 
    0.02691464f, 0.02392532f, -0.04120407f, -0.03079652f, 0.02476999f, -0.02153730f, -0.02873384f, 0.02766127f, 
    0.01474926f, 0.02752790f, 0.02798976f, -0.01914229f, 0.02160347f, 0.01059282f, 0.02395733f, -0.02642404f, 
    -0.02742868f, -0.01028828f, -0.02428752f, -0.03605594f, -0.01625164f, -0.02187796f, 0.00240096f, -0.04132284f, 
    0.00838477f, 0.00457806f, -0.02801794f, -0.03569881f, 0.01561604f, -0.03301883f, -0.00289229f, -0.01778460f, 
    -0.01669347f, -0.01448621f, -0.00308473f, -0.03207933f, 0.01506387f, 0.01658604f, 0.00804937f, -0.01084398f, 
    0.02167817f, 0.00141954f, 0.02296122f, 0.01453672f, 0.01420184f, -0.01452254f, -0.00408825f, -0.01216701f, 
    -0.02977573f, -0.04018077f, -0.01993142f, -0.02956024f, -0.01404055f, -0.01502355f, -0.02047555f, 0.00536285f, 
    0.01810755f, 0.01367245f, -0.00013234f, 0.00160705f, 0.02856575f, 0.02270035f, 0.00340761f, -0.00888454f, 
    0.01027780f, -0.02992799f, 0.02972299f, -0.00500618f, -0.03173038f, -0.03191755f, 0.00885822f, -0.02172710f, 
    -0.02201575f, -0.02225172f, -0.04053073f, -0.01762032f, 0.02927426f, 0.02652922f, -0.04187264f, 0.00332238f, 
    -0.00063939f, 0.01826614f, -0.00411971f, -0.03629173f, -0.02286929f, -0.00935815f, 0.02775695f, -0.00514467f, 
    -0.01333107f, -0.02476110f, 0.00372245f, -0.02886241f, 0.02643769f, 0.01777393f, 0.01389777f, -0.02996127f, 
    0.00169682f, -0.03244067f, 0.02435767f, -0.03004023f, 0.00780562f, 0.02661325f, 0.01229248f, 0.02193549f, 
    -0.00264880f, -0.02891771f, 0.02843098f, 0.00248732f, 0.01415486f, 0.01412698f, -0.03765533f, 0.02096936f, 
    0.01980063f, -0.04030707f, 0.00722914f, 0.02135657f, 0.02662100f, 0.02922599f, 0.00265976f, 0.01512111f, 
    -0.03931919f, -0.01836378f, -0.03037674f, 0.02284310f, 0.01805466f, 0.02102749f, 0.00249966f, -0.02998235f, 
    -0.02084225f, 0.02163112f, -0.00323144f, -0.01634500f, -0.01501029f, 0.01259585f, -0.03309445f, -0.01744550f, 
    -0.00631858f, -0.02551087f, 0.02143747f, -0.02687847f, -0.00394973f, -0.01067614f, -0.03389051f, 0.00738302f, 
    -0.02187278f, -0.01299735f, -0.02834929f, 0.01025256f, 0.02736321f, 0.00614422f, 0.01089788f, -0.04132804f, 
    0.03590329f, -0.03281097f, -0.02251776f, -0.02133733f, -0.01551343f, -0.03221505f, 0.02169824f, -0.04031748f, 
    0.01817197f, -0.00678393f, -0.01678084f, -0.02982290f, 0.02954994f, -0.04091221f, -0.02253317f, 0.02488791f, 
    -0.04048515f, -0.00487479f, 0.01596055f, 0.01353137f, -0.00218892f, -0.00168322f, -0.01371858f, -0.03351080f, 
    -0.02395573f, -0.00997660f, -0.01683035f, 0.02107023f, 0.00912576f, 0.02261462f, -0.02274106f, 0.03003918f, 
    0.00957827f, -0.00139939f, 0.02109266f, -0.00336226f, 0.01820372f, -0.02770271f, -0.04104181f, 0.00507697f, 
    0.01914881f, 0.02001455f, -0.01626334f, 0.01442669f, 0.01176644f, 0.02220065f, 0.02518218f, 0.00158530f, 
    -0.01152713f, -0.02630443f, -0.03543716f, -0.02086190f, -0.04144535f, 0.00287229f, 0.00370666f, 0.02945708f, 
    -0.01489004f, -0.03392758f, 0.00262680f, 0.01249216f, -0.02631283f, -0.00216461f, -0.01891647f, 0.01143067f, 
    -0.03367532f, 0.02338548f, -0.00204676f, -0.01699467f, -0.02663609f, -0.01356653f, 0.00989114f, -0.03961104f, 
    -0.00233469f, -0.00767582f, 0.01785456f, 0.00495279f, 0.00526490f, -0.00849725f, -0.03968493f, -0.00662173f, 
    0.02478196f, -0.00371681f, -0.00742993f, 0.03519924f, -0.03510295f, -0.02801026f, -0.02041473f, -0.01080867f, 
    0.02949679f, -0.02303674f, 0.01441789f, -0.02245168f, 0.02375606f, -0.03188584f, -0.01784981f, 0.01857760f, 
    0.00966746f, -0.00474749f, 0.00721543f, -0.02601585f, -0.01075424f, -0.03470124f, 0.00718405f, 0.02266278f, 
    -0.01986077f, -0.03088204f, -0.02835252f, -0.03896989f, -0.04178759f, -0.01754428f, -0.02313904f, 0.01948185f, 
    -0.03354873f, 0.02074590f, -0.01190175f, 0.00273426f, -0.00521981f, 0.01451340f, -0.03599448f, 0.00502246f, 
    -0.01610867f, 0.00158083f, -0.01214842f, 0.01562240f, 0.02647394f, 0.02861517f, 0.00511201f, 0.02403818f, 
    -0.00034347f, -0.02922140f, -0.01852058f, -0.00376508f, -0.01230804f, -0.01539238f, -0.02115833f, -0.01825167f, 
    -0.01654493f, 0.00093638f, -0.00109860f, -0.00524215f, -0.03020653f, -0.00961603f, 0.01651753f, 0.02183803f, 
    -0.00764014f, -0.01537109f, -0.03486809f, -0.02033546f, 0.02399384f, 0.00443874f, -0.03490832f, -0.03442238f, 
    -0.00317029f, 0.00988569f, 0.02965766f, -0.03201457f, 0.01076062f, 0.00653538f, 0.02608863f, -0.00457109f, 
    0.02159478f, 0.02336250f, 0.00172879f, -0.00797068f, 0.02149029f, 0.01131224f, -0.01879608f, -0.01898739f, 
    -0.02821285f, -0.00422504f, -0.04151496f, -0.03781774f, -0.00436549f, -0.02190402f, 0.02888800f, -0.01313928f, 
    0.00262018f, 0.00531913f, 0.02557515f, -0.01810086f, -0.02599544f, 0.02368181f, -0.04150629f, 0.02750614f, 
    -0.01491892f, -0.00695573f, -0.02797230f, 0.01389748f, 0.01253025f, -0.03683450f, 0.00616757f, -0.03791898f, 
    0.01837655f, -0.02285800f, 0.01243706f, -0.00603790f, -0.03123227f, -0.02258529f, 0.01464557f, -0.01426268f, 
    -0.03602309f, 0.02073272f, -0.02274963f, 0.02353567f, 0.00374097f, -0.00283091f, -0.00781695f, 0.00672174f, 
    0.02365044f, -0.01025870f, -0.02474237f, 0.02786657f, 0.01585047f, 0.02024131f, -0.01428644f, 0.02045975f, 
    -0.03705253f, 0.02804511f, -0.04016114f, -0.03220795f, -0.03631363f, 0.02504272f, -0.02196718f, 0.01731597f, 
    0.02013067f, -0.03711693f, -0.00229954f, -0.00564930f, 0.01428312f, -0.01376477f, -0.04159833f, -0.02627140f, 
    0.01103353f, -0.02283553f, -0.02998683f, -0.02673563f, 0.01527030f, -0.04028974f, 0.02001210f, 0.02625835f, 
    -0.00444378f, -0.00943069f, 0.01312733f, 0.00899563f, -0.02723170f, 0.00546107f, -0.03090780f, -0.02581254f, 
    0.00923202f, -0.01682622f, 0.03338479f, -0.03547920f, -0.00476103f, -0.03155333f, -0.01030669f, -0.01994316f, 
    -0.01569615f, 0.01025845f, 0.00688605f, -0.02118988f, -0.00394544f, 0.00894995f, 0.00109794f, 0.01584716f, 
    0.01122764f, -0.02321804f, 0.00109043f, 0.00544851f, 0.01033340f, -0.02181165f, -0.01046133f, 0.02487108f, 
    0.02153435f, -0.01339505f, -0.02927902f, -0.00005463f, -0.00120442f, -0.00077367f, -0.00378534f, -0.01890790f, 
    0.00568752f, -0.03213259f, -0.00138858f, -0.01904655f, -0.02636360f, -0.03929096f, -0.01824473f, 0.01563369f, 
    -0.02324162f, -0.02818326f, -0.03842845f, 0.00933595f, 0.00257217f, -0.03839413f, -0.03336851f, -0.00075388f, 
    0.00604960f, -0.00947926f, -0.03023948f, -0.01568226f, -0.03471156f, 0.00820244f, -0.03846803f, 0.00772062f, 
    0.00497435f, -0.02268759f, -0.01142063f, -0.02814694f, 0.00148403f, -0.02070042f, 0.02152534f, 0.02851674f, 
    -0.01497792f, -0.03497135f, -0.01517169f, -0.03272129f, 0.00386080f, -0.00146090f, -0.03180038f, -0.02702866f, 
    0.02910798f, -0.00590092f, -0.00399692f, -0.02902443f, -0.01175208f, -0.03175875f, 0.02501916f, -0.00803620f, 
    0.02612034f, 0.02793937f, -0.02884117f, -0.01331699f, -0.01576461f, -0.03396498f, -0.03307016f, 0.02998860f, 
    0.00372942f, 0.01946918f, -0.00509020f, 0.00546440f, 0.01816394f, -0.00968104f, 0.01844873f, 0.02671402f, 
    -0.02210141f, -0.02240514f, 0.00853208f, 0.00782062f, -0.00367299f, 0.00381653f, 0.00831071f, -0.02746250f, 
    -0.02845310f, 0.01169130f, -0.02441072f, -0.00389541f, -0.01464569f, 0.01262124f, -0.02770404f, -0.01301625f, 
    -0.01380563f, 0.02748209f, 0.02089568f, -0.00471475f, -0.02982916f, -0.03640645f, -0.02775335f, -0.00567672f, 
    0.01135908f, -0.01719207f, 0.00435269f, 0.01099881f, -0.03795422f, 0.01343528f, 0.02070526f, -0.02480771f, 
    0.01272758f, -0.03756180f, -0.02000165f, -0.01638801f, -0.03274776f, -0.02250442f, -0.03883228f, -0.03132208f, 
    0.00239609f, -0.01299839f, 0.02004136f, -0.03150173f, -0.01388156f, -0.01354676f, -0.01093324f, -0.01791969f, 
    -0.17991728f, -0.05173272f, -0.10633922f, -0.09433512f, -0.08487401f, -0.10810038f, 0.10678360f, 0.00056300f, 
    -0.03558366f, -0.06463476f, -0.08200178f, 0.01060398f, -0.16067453f, -0.21104054f, 0.00699369f, 0.36569181f, 
    -0.11676509f, -0.15651114f, 0.09612232f, -0.11195269f, -0.02446044f, -0.08032294f, -0.16177657f, 0.11885043f, 
    -0.27214769f, -0.13446614f, 0.07876758f, -0.02136663f, 0.09182151f, -0.00254201f, 0.13163309f, 0.23994876f, 
    -0.08476240f, -0.05376005f, 0.14019977f, -0.00246692f, -0.38926697f, -0.01325855f, 0.22795752f, -0.06181068f, 
    -0.19068059f, -0.08554539f, 0.10782035f, 0.05910073f, -0.01445854f, -0.00450330f, 0.14507718f, 0.15199365f, 
    0.05078698f, 0.03970418f, -0.10731488f, -0.07117686f, 0.01951410f, 0.06499487f, 0.05880937f, 0.15042354f, 
    -0.03521337f, -0.11585805f, 0.08120850f, -0.21608737f, -0.13494140f, -0.10124850f, 0.11998145f, 0.07507302f, 
    -0.11702064f, 0.11572406f, -0.17617282f, 0.15368569f, 0.02773087f, -0.00566073f, 0.11863059f, 0.03817693f, 
    0.11107578f, -0.08355635f, -0.13129155f, 0.07038620f, 0.06423966f, 0.06858278f, 0.05432192f, 0.05456129f, 
    0.01463416f, 0.05103282f, -0.02706018f, -0.10804526f, 0.10611838f, 0.00444030f, 0.30701616f, 0.32254916f, 
    -0.00507096f, 0.06477333f, 0.17514497f, -0.18315545f, 0.00010794f, -0.03728990f, 0.26651713f, 0.02903489f, 
    -0.19710208f, -0.00397196f, 0.24904346f, 0.10285866f, 0.00367181f, -0.02070810f, 0.02172508f, 0.08866718f, 
    -0.04505854f, -0.00842314f, 0.06314443f, 0.08320020f, -0.00779750f, 0.07344893f, 0.27050784f, -0.00836614f, 
    -0.03558797f, -0.09183223f, 0.09496283f, -0.14624362f, -0.00054179f, -0.08038626f, -0.02954848f, 0.00082055f, 
    0.35538119f, 0.11907422f, -0.11799826f, 0.13652231f, 0.06819157f, -0.02738464f, -0.07260104f, 0.06511048f, 
    -0.06525242f, -0.03992476f, -0.02317904f, -0.11469678f, 0.05813129f, -0.01521789f, -0.06707921f, 0.15001316f, 
    0.19800851f, 0.02238191f, 0.17340936f, 0.08908796f, 0.13974689f, -0.03858842f, -0.12692536f, 0.02662262f, 
    0.11170404f, -0.07706317f, -0.02884728f, -0.16605414f, -0.03554696f, 0.06184993f, 0.00587979f, 0.10357682f, 
    0.05325945f, 0.02532482f, 0.00003181f, 0.10267173f, 0.03737728f, -0.07862008f, -0.02062720f, 0.14678739f, 
    0.07584208f, 0.01299090f, -0.07786608f, -0.06726941f, 0.06186345f, -0.03441437f, 0.10339205f, -0.07671488f, 
    -0.10891795f, -0.20123796f, -0.13455872f, -0.03681520f, -0.02043362f, -0.09044749f, -0.01571821f, 0.03697760f, 
    0.06539392f, 0.03273509f, 0.09724575f, 0.03369895f, 0.13452104f, 0.31023201f, 0.02611840f, 0.12824418f, 
    0.09534263f, -0.09567127f, -0.09163626f, 0.21863124f, 0.08999754f, -0.07573358f, 0.01341048f, -0.05677448f, 
    -0.27789748f, -0.12775505f, 0.20428725f, 0.04123949f, 0.08887742f, -0.00035395f, -0.00176139f, 0.02794578f, 
    0.10152250f, -0.09268282f, 0.11682165f, 0.16664487f, 0.10656191f, 0.06906445f, -0.16763110f, 0.06461383f, 
    -0.00391715f, -0.01284166f, -0.02652480f, 0.00268746f, -0.02028449f, -0.05030271f, -0.00091492f, -0.01589148f, 
    -0.10061682f, 0.02177904f, -0.01373496f, 0.00553922f, -0.03159072f, -0.11303806f, -0.08892867f, 0.07846147f, 
    -0.01924636f, 0.07020547f, 0.07627920f, 0.10466525f, -0.63403380f, 0.20458490f, -0.14608234f, 0.36084467f, 
    0.09996421f, -0.05269565f, -0.04135593f, 0.10810724f, -0.00190160f, 0.05145577f, -0.01670157f, 0.11113362f, 
    0.22667898f, -0.08146398f, -0.11272200f, 0.11576402f, 0.07305068f, 0.08083342f, 0.04116116f, 0.09332073f, 
    0.04118429f, 0.01561661f, -0.02953696f, -0.06333251f, -0.24053085f, -0.02412477f, 0.13757707f, -0.12730005f, 
    -0.02060512f, -0.05582682f, -0.07278688f, -0.05252241f, -0.10269929f, 0.09992597f, 0.03751924f, -0.22317518f, 
    -0.19153829f, 0.13019943f, 0.05880904f, 0.02410618f, -0.02619479f, -0.03711147f, -0.02444947f, -0.00901669f, 
    -0.01011243f, 0.03384262f, 0.00617023f, -0.07347976f, 0.23485047f, -0.03889896f, -0.01080819f, -0.32268786f, 
    0.03597645f, -0.13739116f, 0.24278283f, 0.01355152f, -0.05728964f, -0.02749186f, -0.02587554f, -0.04590712f, 
    -0.06886853f, 0.25265315f, 0.02475932f, -0.09977061f, -0.05634157f, -0.09128922f, 0.05281090f, 0.21090262f, 
    0.05875172f, 0.02725160f, -0.02678248f, 0.11999238f, 0.13034934f, 0.00224967f, -0.07019985f, 0.19312495f, 
    0.06600928f, 0.05420891f, 0.03351218f, -0.15044302f, -0.01056392f, -0.03028849f, -0.07264499f, 0.02233698f, 
    -0.12011278f, 0.00535888f, 0.14205658f, -0.14507888f, -0.05048902f, 0.20200726f, -0.03211761f, -0.09417365f, 
    0.05760378f, -0.06039619f, -0.08529114f, 0.07802080f, -0.40964079f, -0.00961846f, 0.07245792f, 0.33379966f, 
    0.12531555f, -0.13947125f, 0.00714008f, -0.04978293f, -0.07719532f, -0.03200438f, -0.07112888f, 0.04543604f, 
    0.33087590f, 0.01725701f, -0.06366014f, 0.10623533f, -0.02803797f, -0.13589634f, 0.12957552f, -0.01910155f, 
    0.01996936f, 0.06758762f, -0.22488749f, -0.00514187f, 0.19308305f, 0.08837264f, 0.10594961f, 0.00464675f, 
    0.15435636f, -0.10903588f, -0.06839707f, 0.00690577f, 0.08209803f, -0.03412561f, 0.08466152f, 0.08908675f, 
    -0.05798860f, -0.07999270f, -0.09620094f, 0.03038263f, 0.10603206f, -0.04296772f, -0.01156490f, 0.10341277f, 
    -0.16419275f, 0.09833390f, -0.02230184f, -0.27242914f, 0.36861652f, 0.01268679f, -0.40975776f, 0.15977430f, 
    0.02515351f, 0.02145474f, -0.00766733f, 0.00417739f, 0.06719218f, -0.07326027f, 0.13068980f, -0.10360228f, 
    -0.29110777f, -0.32878736f, 0.03572595f, 0.09180547f, 0.00466171f, -0.14987545f, 0.11495218f, -0.03333278f, 
    -0.08086294f, 0.00386831f, 0.23127390f, -0.03879766f, -0.09471717f, 0.05947022f, 0.14967869f, 0.07320362f, 
    0.02462877f, 0.07018521f, -0.06274558f, 0.01048822f, -0.02654698f, -0.01320034f, 0.08271029f, 0.00404141f, 
    -0.07647729f, -0.01208715f, -0.09867614f, -0.05680812f, 0.04678907f, -0.02659334f, 0.00133355f, 0.09019230f, 
    -0.06148318f, 0.02690706f, -0.10310166f, 0.02740616f, -0.19239797f, 0.05875053f, 0.01929492f, 0.29119912f, 
    0.00637305f, -0.00983193f, -0.00503085f, 0.03604306f, 0.11405362f, -0.05804997f, -0.08009074f, 0.12873855f, 
    -0.07946332f, 0.23031951f, 0.14905488f, 0.06904127f, -0.01370205f, -0.08432874f, -0.01167787f, -0.07656133f, 
    0.17378248f, 0.21484986f, -0.02123495f, 0.01101266f, 0.19587632f, 0.12082542f, -0.26205128f, 0.13850290f, 
    -0.03583238f, -0.06071747f, 0.10318255f, 0.10994333f, -0.03779511f, -0.19535288f, -0.04789504f, -0.06858598f, 
    0.01439277f, 0.05658638f, -0.00026625f, -0.11500758f, -0.03845930f, 0.03617426f, -0.07507675f, 0.19343583f, 
    -0.03852037f, 0.08117510f, -0.13478482f, -0.01366239f, 0.01117875f, -0.11465663f, -0.00377109f, 0.00109369f, 
    -0.04436899f, 0.16845426f, -0.10993417f, -0.05162661f, 0.07351343f, 0.08512539f, -0.05844029f, 0.04519573f, 
    -0.16355708f, 0.11393905f, -0.05703058f, 0.12882051f, 0.05699670f, -0.00181927f, 0.07228199f, 0.12532842f, 
    0.17230769f, 0.06525905f, 0.04654589f, 0.05122076f, -0.34414300f, -0.01475632f, 0.16134220f, 0.11274462f, 
    -0.07916452f, -0.07143111f, -0.09669011f, 0.25897199f, -0.01215707f, 0.16283196f, -0.16761716f, 0.11757160f, 
    0.04159027f, -0.11483026f, 0.05497678f, 0.10765136f, 0.18469761f, 0.17539178f, -0.03241701f, 0.09948766f, 
    -0.06779867f, -0.06382132f, 0.02750342f, -0.10207582f, 0.03616568f, -0.05415782f, -0.12218504f, -0.03146774f, 
    0.10287070f, 0.25172514f, -0.12369605f, 0.08967665f, 0.04072748f, 0.04586035f, 0.01577792f, 0.03557306f, 
    0.27769831f, -0.04054318f, -0.11377084f, 0.19521220f, -0.07650721f, -0.06254314f, 0.14486475f, -0.02370065f, 
    -0.07684439f, 0.09867966f, 0.11808641f, 0.02223190f, -0.19738837f, 0.14196567f, -0.06485457f, -0.04222194f, 
    0.02901618f, -0.08994428f, 0.03221549f, 0.02484792f, 0.00846212f, -0.02172645f, 0.05893599f, 0.05090811f, 
    0.14818695f, -0.21356982f, -0.02176087f, -0.07805525f, -0.01944812f, 0.12681784f, 0.12173928f, 0.12799932f, 
    0.13993837f, 0.03064114f, -0.02101637f, 0.04215832f, 0.25878838f, 0.21227211f, -0.22018299f, 0.01255853f, 
    -0.00571403f, -0.02140133f, 0.20263988f, 0.01144125f, 0.00926793f, 0.13962768f, 0.01908216f, -0.15648808f, 
    0.27903241f, -0.20588459f, 0.02359435f, -0.07215796f, 0.10800404f, 0.07750671f, -0.08295025f, 0.09640863f, 
    0.19576044f, 0.16286026f, -0.06874713f, 0.08340433f, 0.09221798f, 0.00846588f, 0.34928444f, -0.21952046f, 
    -0.03470503f, 0.06357285f, -0.03245891f, -0.10174593f, 0.15319599f, -0.09811486f, 0.03510851f, -0.15605938f, 
    0.02257438f, -0.19092114f, 0.17561544f, 0.20642737f, -0.02939521f, 0.11759925f, -0.03543675f, -0.16506961f, 
    0.01259386f, 0.06226865f, 0.05345960f, 0.00929366f, -0.14516768f, -0.13153869f, -0.00972940f, -0.02319827f, 
    0.06235998f, 0.22127600f, 0.00263448f, 0.08468480f, -0.00569747f, 0.05690872f, -0.00597788f, 0.17015204f, 
    0.14957060f, -0.13090068f, -0.16421801f, 0.24286211f, 0.01783882f, 0.03564453f, 0.04781106f, -0.01728676f, 
    0.06830360f, 0.18351436f, -0.09117540f, 0.05808269f, -0.10731329f, 0.11624525f, 0.13298777f, -0.09623978f, 
    -0.03880130f, -0.08586710f, -0.08821907f, 0.08660674f, -0.13672405f, 0.00511465f, -0.10927592f, -0.10915335f, 
    -0.03330885f, -0.05651278f, 0.21331400f, 0.01388839f, -0.08847673f, -0.00807439f, 0.11819565f, -0.07656404f, 
    0.01396963f, 0.06836881f, 0.19326967f, -0.08637928f, -0.05089706f, 0.01767766f, -0.02350209f, 0.06690191f, 
    -0.03089584f, 0.01758968f, -0.06655084f, -0.00877151f, -0.00465957f, -0.01388901f, 0.01095404f, -0.02486958f, 
    0.33526906f, 0.11887666f, -0.11136916f, -0.21104234f, 0.08749516f, -0.04388616f, 0.05224665f, 0.00690729f, 
    0.00741365f, -0.03595445f, 0.02883725f, -0.05089046f, -0.30896619f, -0.27630484f, 0.20193790f, 0.25267699f, 
    -0.00476755f, 0.10638335f, 0.04821164f, -0.16190365f, -0.06395459f, 0.01981851f, -0.04577297f, 0.10282455f, 
    -0.08900969f, -0.12303039f, -0.12824282f, 0.08656707f, 0.07967646f, 0.10420098f, 0.02319743f, -0.08110611f, 
    0.00605847f, 0.06984933f, -0.10862129f, -0.09166522f, -0.03316342f, -0.22876868f, 0.09518046f, 0.33205199f, 
    -0.00853439f, -0.19530427f, 0.10989773f, 0.16300820f, -0.03058945f, -0.00456006f, 0.05065499f, 0.14866002f, 
    0.25014976f, -0.13863032f, -0.00984709f, 0.04488989f, -0.17721115f, 0.12049570f, -0.12817174f, 0.17886479f, 
    0.15292694f, -0.05931029f, 0.06943710f, 0.10741043f, -0.06647360f, -0.04665951f, 0.05746298f, 0.23388799f, 
    0.17677529f, 0.08742851f, 0.03457973f, -0.07931990f, 0.03895157f, -0.15535858f, -0.09262686f, 0.18219607f, 
    -0.01020227f, 0.03214465f, 0.04717458f, -0.09507407f, -0.00404784f, -0.07709648f, -0.04165864f, -0.17758378f, 
    0.14122865f, 0.11839850f, -0.02903939f, 0.08143127f, 0.11014681f, 0.12255242f, 0.12540400f, 0.18016739f, 
    0.13403364f, -0.19460130f, 0.16186038f, -0.08793695f, 0.16158625f, -0.03443607f, -0.16285597f, 0.09169418f, 
    -0.03692614f, 0.09108040f, 0.15997407f, 0.09745097f, 0.01813249f, -0.05782152f, 0.05386038f, -0.10946430f, 
    0.12769397f, -0.03799494f, 0.11209579f, 0.15698171f, -0.05908454f, -0.17503035f, -0.14791496f, 0.28960478f, 
    0.05882236f, 0.03618982f, -0.05142728f, -0.17925993f, 0.12988006f, 0.06254912f, 0.00423549f, 0.06849535f, 
    0.04521950f, -0.00553856f, 0.23906700f, 0.15550382f, 0.09211003f, -0.00910924f, 0.06433909f, 0.11837120f, 
    0.20587067f, -0.03998972f, -0.00463048f, 0.12701932f, -0.01414495f, -0.04496316f, 0.18961456f, 0.13035443f, 
    -0.09477065f, 0.11839548f, -0.10098804f, 0.13188322f, 0.17090912f, 0.11578938f, -0.08019355f, 0.02985334f, 
    -0.08158374f, -0.21250875f, -0.20874178f, -0.13344710f, 0.07326108f, 0.05257182f, 0.06183228f, -0.00164127f, 
    0.02901439f, -0.03521993f, -0.04815917f, 0.04095670f, -0.04570883f, -0.11932451f, 0.40935165f, -0.09006202f, 
    0.11659914f, 0.00196611f, 0.06275590f, 0.05213731f, -0.04680189f, -0.13157779f, -0.09524819f, -0.15471728f, 
    -0.22348939f, -0.18887746f, -0.09836848f, 0.01030476f, 0.13869733f, 0.11924885f, 0.06163200f, 0.08377098f, 
    0.01460341f, 0.02438573f, -0.02547821f, -0.00501407f, 0.13584198f, 0.00518475f, 0.06702333f, 0.05040460f, 
    0.10870873f, 0.09645687f, -0.01441102f, -0.08389025f, -0.06623128f, -0.00621659f, -0.05968972f, -0.09931121f, 
    -0.04482549f, 0.07734822f, -0.08635733f, -0.01961261f, 0.11599903f, -0.02681397f, 0.16944052f, 0.08000385f, 
    -0.09096261f, -0.09806015f, 0.05388736f, 0.05105529f, 0.16916542f, 0.31519356f, 0.18503663f, 0.27556199f, 
    -0.06311644f, -0.07603319f, 0.05499496f, 0.01076037f, 0.07000366f, 0.04126307f, 0.01626590f, 0.05441298f, 
    0.01669877f, -0.31122541f, -0.21985665f, -0.14467351f, -0.11572725f, -0.08864778f, 0.09613679f, 0.00007665f, 
    0.16900066f, -0.09521952f, -0.02730361f, 0.04368545f, 0.09300254f, 0.02954493f, 0.00684568f, -0.23207934f, 
    0.06802703f, 0.06163774f, 0.07533589f, 0.10703032f, -0.00282605f, -0.04142790f, -0.11349291f, -0.13571021f, 
    -0.24194573f, -0.08807314f, -0.05767755f, 0.08494528f, 0.12407774f, -0.05969304f, 0.02818132f, -0.05692727f, 
    -0.05829254f, -0.20461449f, -0.27274713f, -0.26113266f, 0.08881726f, -0.21834056f, 0.00637758f, 0.08173265f, 
    0.01098418f, 0.03169123f, -0.04286944f, -0.04934955f, -0.02563808f, 0.22117792f, 0.17772397f, 0.15519010f, 
    -0.00291306f, 0.23394643f, 0.27375007f, 0.06776768f, -0.00479640f, 0.03250550f, -0.00414661f, 0.06280392f, 
    0.10181177f, -0.07212419f, 0.05019373f, 0.06328382f, 0.06372669f, 0.32043633f, 0.36350340f, -0.08430076f, 
    -0.08378963f, 0.05468485f, 0.10203888f, -0.04988184f, -0.09000571f, 0.15153348f, 0.02403317f, 0.12841380f, 
    0.02719257f, 0.10346898f, 0.09209139f, 0.14061250f, 0.03267721f, 0.00969878f, -0.11976667f, -0.11698331f, 
    0.02094497f, 0.13630228f, -0.03106028f, -0.09520786f, 0.13225178f, -0.19890752f, 0.03633612f, -0.00433245f, 
    -0.12707120f, -0.02806225f, -0.00776959f, -0.05163659f, 0.21256301f, 0.14031765f, 0.16697361f, 0.10493804f, 
    0.11303180f, 0.04902120f, 0.17125936f, 0.21258451f, 0.08475187f, -0.09475328f, 0.11016101f, 0.03367949f, 
    0.03150547f, -0.02726495f, 0.05695915f, -0.03862162f, -0.14499044f, 0.02581613f, 0.35071105f, 0.32025394f, 
    0.15437011f, -0.04087488f, -0.03589700f, -0.13432823f, 0.01324668f, 0.05011979f, 0.03228472f, -0.06464904f, 
    -0.10504287f, -0.03615393f, -0.16407388f, 0.07930927f, -0.05838993f, 0.16746250f, 0.02423570f, 0.13285916f, 
    0.03333783f, 0.01836007f, -0.06161047f, -0.03454499f, -0.06402485f, 0.13037832f, 0.33240938f, -0.00674244f, 
    0.03897063f, 0.12689768f, -0.05918248f, 0.14859012f, 0.10789926f, -0.02791190f, 0.07544658f, 0.14593551f, 
    0.30562681f, 0.28789356f, 0.36044309f, 0.10485762f, -0.00767442f, -0.13244982f, -0.02302675f, -0.05695879f, 
    -0.00787080f, -0.00054199f, 0.04620991f, 0.13624580f, -0.17692938f, 0.20380874f, -0.15977119f, 0.18896082f, 
    0.04836467f, -0.06658966f, 0.11637154f, -0.01578430f, 0.12220863f, 0.01809430f, 0.02779470f, 0.21649295f, 
    0.10187545f, 0.17863138f, 0.07212266f, 0.06822151f, -0.01258416f, -0.05976256f, -0.01949938f, -0.01477489f, 
    0.10145977f, 0.12687133f, 0.05555959f, 0.40473145f, 0.19401674f, 0.02998162f, 0.10292109f, 0.08734139f, 
    -0.00085360f, 0.04930421f, -0.01504883f, 0.15349323f, -0.01893107f, -0.04259148f, -0.12845974f, -0.11807442f, 
    -0.15394935f, 0.32985204f, 0.33130005f, -0.21455286f, 0.19526893f, -0.10831901f, -0.04201177f, 0.00388017f, 
    0.07079357f, -0.16721162f, 0.08029182f, 0.01133347f, 0.28146118f, 0.08232967f, 0.13804464f, 0.02061602f, 
    -0.02979542f, 0.09199878f, 0.05604374f, 0.01518448f, -0.00796273f, 0.18984649f, -0.09460451f, -0.24826133f, 
    -0.09548910f, 0.38926068f, -0.32642439f, 0.01660462f, 0.06226679f, 0.07487451f, 0.12341700f, 0.06476964f, 
    0.19400705f, 0.10288568f, 0.06953830f, 0.06435979f, 0.02594300f, 0.33188307f, 0.11490528f, -0.32179311f, 
    -0.06879862f, -0.00028101f, 0.14995541f, 0.12251486f, -0.08879977f, -0.04484504f, 0.04026966f, -0.00371938f, 
    -0.10854170f, -0.15599412f, 0.02002879f, 0.01744871f, -0.00195691f, 0.16918705f, 0.06902502f, -0.00354036f, 
    0.10358937f, 0.17260696f, 0.10832912f, 0.02329892f, -0.05652153f, -0.10487843f, -0.22498180f, 0.05973970f, 
    0.02753255f, -0.06516171f, 0.11840394f, -0.01835679f, 0.08616241f, -0.02388021f, 0.02168982f, -0.02227545f, 
    -0.10514122f, -0.01682991f, 0.18914054f, 0.01433305f, -0.03820050f, -0.06380653f, 0.03860541f, 0.07104500f, 
    0.13313186f, 0.07776184f, 0.11946765f, 0.11762251f, -0.03543069f, 0.16034909f, 0.15422373f, -0.16668826f, 
    0.05120000f, 0.01244174f, 0.04846527f, 0.10852854f, -0.04526039f, 0.00040863f, 0.00872587f, 0.00271583f, 
    0.05201777f, -0.11001375f, -0.16882123f, -0.01736239f, 0.13563170f, -0.09501085f, -0.02123117f, -0.03795644f, 
    0.24131608f, 0.08275315f, 0.14404961f, 0.22956382f, 0.16973214f, -0.21645769f, 0.06774679f, -0.16461499f, 
    -0.08129265f, -0.08971191f, -0.09646090f, -0.02438537f, -0.02770700f, 0.04670373f, -0.02214552f, -0.12284924f, 
    0.27380604f, 0.26655123f, 0.13315792f, 0.10801649f, 0.08935266f, -0.03880108f, 0.07295199f, 0.00644088f, 
    0.00143358f, -0.32102829f, -0.05212331f, -0.04659647f, 0.14423156f, -0.37425706f, 0.08044136f, -0.23581298f, 
    -0.08381069f, -0.05352809f, -0.06598438f, -0.07698565f, 0.05653090f, 0.05568848f, 0.19948487f, 0.00981563f, 
    -0.30904105f, -0.00010796f, -0.20474848f, 0.18655016f, 0.07111215f, -0.02717426f, -0.13951716f, -0.15781835f, 
    -0.25790104f, -0.04766175f, 0.02848579f, -0.03803654f, -0.10184076f, -0.12425733f, 0.02201100f, 0.05283046f, 
    0.05169392f, 0.14996406f, 0.10661097f, -0.00208827f, -0.00036290f, 0.10014261f, -0.12536380f, 0.05558421f, 
    0.23741356f, -0.07549423f, 0.20517275f, 0.23791602f, -0.12396170f, 0.14437942f, -0.04913040f, 0.05287878f, 
    -0.00250980f, -0.07763979f, -0.08142823f, -0.05440432f, 0.13367428f, -0.00048621f, 0.36222330f, 0.37091029f, 
    -0.00000731f, 0.02734444f, -0.09192872f, 0.00207794f, 0.13729024f, 0.15329385f, 0.00824626f, 0.05999637f, 
    -0.16559307f, 0.01334912f, -0.24704313f, 0.19106910f, 0.18019553f, -0.01686088f, 0.05706774f, -0.05237121f, 
    -0.01964055f, -0.10342793f, -0.18336461f, -0.14981818f, -0.17180067f, -0.11174805f, -0.31047118f, 0.04648814f, 
    0.11752338f, 0.08602861f, 0.13862811f, 0.00984815f, -0.06327786f, -0.12831841f, -0.12442403f, -0.21633050f, 
    -0.09547402f, -0.02915073f, -0.16341835f, -0.13393490f, 0.09643935f, -0.07500071f, 0.10948770f, -0.11468894f, 
    0.13568823f, -0.00997087f, -0.01258666f, 0.06880213f, 0.37081125f, 0.19214810f, 0.26170921f, 0.10889096f, 
    -0.03618561f, -0.05381167f, 0.05291860f, -0.02030152f, 0.21581788f, -0.01819347f, 0.06322580f, 0.21256863f, 
    -0.01675244f, -0.25008795f, 0.02926249f, -0.07273090f, 0.06459860f, 0.18258789f, 0.11282169f, 0.04693514f, 
    -0.05322653f, -0.20806083f, -0.13386220f, -0.24675259f, -0.10257044f, -0.07063527f, 0.04993940f, 0.28653580f, 
    -0.09985188f, -0.00945770f, -0.02265909f, 0.00768019f, 0.14678228f, -0.12077699f, 0.04643976f, 0.05626977f, 
    -0.00554075f, -0.03103099f, -0.21645077f, -0.18728174f, 0.06071283f, -0.16078776f, -0.00788502f, 0.00176784f, 
    -0.05350048f, 0.03858203f, 0.07400481f, 0.12516294f, 0.05950179f, 0.38866991f, 0.01910912f, -0.01600220f, 
    0.14068922f, -0.09970273f, -0.08625264f, -0.01686141f, 0.19746447f, -0.14330202f, -0.14231825f, -0.11753833f, 
    0.24515511f, -0.06675561f, 0.31803307f, 0.00120878f, 0.18348952f, 0.00934227f, 0.15104407f, 0.18057232f, 
    -0.05085155f, -0.13550395f, -0.08770648f, -0.13336170f, 0.16824694f, 0.02103390f, 0.05031141f, 0.19958425f, 
    0.13334036f, -0.01837998f, 0.08787994f, -0.02263525f, 0.05519833f, 0.02501369f, -0.01839577f, 0.10250878f, 
    -0.03411888f, -0.04396605f, -0.23815437f, -0.04504670f, 0.01485810f, 0.09975463f, 0.03319140f, -0.02104698f, 
    -0.05097201f, -0.01027151f, -0.02505840f, -0.14365630f, 0.22303420f, 0.26481873f, 0.32620457f, 0.17027323f, 
    0.07998294f, -0.20529991f, -0.11787120f, 0.00020035f, 0.13816023f, 0.06790183f, 0.05307684f, 0.13937245f, 
    0.05047411f, 0.17551884f, 0.25860837f, 0.19099304f, 0.07537603f, 0.01124237f, 0.09226656f, 0.15937620f, 
    0.08868347f, 0.03498292f, 0.02673548f, 0.03279359f, 0.11388052f, 0.24724148f, 0.16437110f, 0.09231204f, 
    0.02786406f, 0.04398484f, 0.08320900f, 0.24079771f, 0.05314930f, 0.07461334f, 0.04531006f, 0.09602735f, 
    -0.10158113f, 0.36932081f, -0.17491846f, 0.02602321f, -0.02284037f, -0.03086085f, 0.04018471f, -0.07674518f, 
    0.14557445f, 0.06850717f, 0.07253734f, 0.12425646f, -0.12353442f, -0.12702279f, 0.20107043f, 0.11908904f, 
    0.13277946f, 0.18780890f, -0.10214180f, 0.11347216f, 0.15487529f, 0.12767380f, 0.03196359f, 0.07709434f, 
    -0.16302374f, -0.15287744f, -0.01438515f, 0.04218183f, 0.15962535f, 0.09188403f, 0.10453130f, 0.02741057f, 
    0.09311626f, -0.14945126f, 0.02470339f, 0.02635275f, -0.24033216f, 0.21554017f, -0.03238137f, 0.02641218f, 
    0.12674803f, -0.09179654f, -0.04235449f, 0.05700749f, 0.01769414f, 0.04074326f, 0.00148646f, -0.06316669f, 
    -0.13412565f, -0.13527735f, -0.17800754f, -0.05032760f, 0.15763804f, 0.03010657f, 0.04556219f, 0.22582142f, 
    -0.03126882f, -0.22322378f, -0.17293666f, -0.19654229f, 0.05528883f, -0.10536987f, 0.04258123f, -0.23148954f, 
    -0.05701099f, 0.19264126f, -0.13736562f, -0.07630584f, 0.00050951f, 0.06834875f, -0.11757003f, 0.08958550f, 
    0.01674727f, 0.14243941f, 0.06326480f, 0.01590334f, 0.01194785f, 0.04497748f, 0.02245072f, 0.12807271f, 
    0.05006265f, -0.17222728f, -0.06278719f, -0.06180885f, 0.02723101f, 0.47123608f, -0.21346301f, -0.10316581f, 
    -0.03241821f, -0.07036557f, 0.08389661f, 0.09965938f, 0.08693185f, -0.10373928f, -0.08086719f, -0.01281223f, 
    -0.03540506f, 0.01673375f, -0.01075908f, -0.02602457f, 0.00142261f, -0.00745784f, 0.00682133f, -0.02785242f, 
    -0.00591667f, 0.02887554f, -0.00115652f, -0.01841582f, -0.02987579f, -0.02946034f, -0.04004664f, 0.00364933f, 
    0.01763855f, -0.02966503f, 0.01218663f, -0.00334629f, 0.01373603f, -0.02149778f, -0.03778904f, 0.00018161f, 
    0.00832670f, 0.02542463f, 0.02073181f, 0.01561978f, -0.03402917f, 0.01033130f, 0.01386368f, 0.00316728f, 
    0.00242920f, -0.00732085f, -0.01673327f, -0.00988038f, -0.03092029f, 0.02590126f, 0.01503509f, -0.00197421f, 
    -0.03284626f, -0.02435837f, -0.01036244f, 0.01348480f, -0.01432857f, -0.01436105f, -0.01274603f, -0.03081637f, 
    -0.00579830f, 0.00707479f, 0.00822072f, -0.01569805f, 0.02557156f, -0.03473595f, -0.02579744f, -0.02378313f, 
    -0.03542054f, -0.03066728f, -0.00478209f, 0.02307109f, -0.02554635f, 0.02163879f, -0.01771975f, 0.01538713f, 
    0.02886194f, 0.01563612f, -0.01821771f, -0.01624005f, -0.01619793f, -0.03591080f, 0.01985293f, -0.01152209f, 
    0.02102195f, -0.01954563f, 0.01601768f, -0.02834470f, 0.01129468f, -0.02060125f, -0.01193696f, -0.02258588f, 
    0.00516360f, -0.01917360f, -0.02370033f, 0.00344580f, 0.00664492f, -0.01223201f, 0.02466916f, -0.02723327f, 
    -0.02511577f, -0.03837117f, -0.02521487f, -0.03101423f, -0.03472316f, 0.02917165f, 0.00514898f, -0.00338745f, 
    -0.02799505f, -0.02215115f, -0.01335173f, 0.02648946f, 0.01669660f, -0.03446427f, 0.00874136f, -0.00906520f, 
    0.02917062f, 0.01912874f, 0.02339070f, -0.02822347f, -0.00210003f, -0.04005442f, 0.00967766f, -0.01245438f, 
    -0.04046324f, -0.03908362f, -0.00267141f, -0.03554531f, 0.02988301f, 0.02703667f, 0.02639915f, 0.00781308f, 
    -0.02842213f, -0.03641703f, -0.00231985f, -0.03174565f, 0.02070121f, 0.00696806f, -0.01475202f, -0.03246690f, 
    -0.01357153f, 0.02773346f, -0.02061227f, 0.01354524f, -0.01713866f, 0.01903576f, 0.02307590f, -0.04059105f, 
    -0.02681585f, -0.03311387f, -0.02681586f, -0.02596397f, -0.03959633f, -0.02829363f, 0.02981674f, -0.03993343f, 
    0.02822289f, -0.00078500f, -0.01085652f, -0.03911224f, -0.01448378f, -0.01679602f, 0.02625218f, -0.00685579f, 
    -0.02066708f, -0.01179846f, 0.01638788f, -0.00985760f, 0.01410329f, -0.03527123f, -0.01130919f, -0.03351488f, 
    -0.03764226f, -0.03254791f, -0.01201462f, 0.02304738f, 0.02079216f, 0.00608616f, 0.01039568f, -0.03242816f, 
    -0.00284323f, 0.02367995f, 0.01168052f, 0.02724150f, -0.00532724f, -0.01258170f, -0.00255493f, -0.03691657f, 
    0.00523288f, 0.00393808f, 0.02420841f, -0.02405819f, -0.01398178f, 0.01159066f, -0.01563594f, -0.03773305f, 
    -0.01737300f, 0.00665805f, 0.02729774f, 0.02832173f, -0.03901108f, -0.03269954f, 0.01606962f, -0.01699680f, 
    0.00974112f, -0.01045074f, -0.02241691f, -0.04127496f, 0.02413893f, 0.00743581f, -0.01147230f, -0.00321270f, 
    -0.00610967f, -0.03773935f, -0.00296870f, -0.03416090f, -0.03201875f, -0.02336785f, -0.02911111f, -0.01851430f, 
    -0.01774755f, 0.00946345f, 0.01254791f, -0.01516797f, -0.03159977f, -0.02116900f, 0.03361168f, 0.02353177f, 
    0.02605632f, 0.00047668f, -0.01489296f, -0.03222829f, 0.00540240f, -0.00477443f, 0.02394515f, 0.03143315f, 
    -0.02365929f, -0.00616691f, 0.03541337f, -0.03058027f, 0.03314133f, -0.03525814f, -0.02793594f, -0.03302711f, 
    -0.00957977f, -0.03328380f, -0.00162291f, 0.01173704f, 0.01267367f, -0.02888476f, -0.02259954f, 0.01976944f, 
    0.02394857f, 0.02663195f, -0.00999755f, -0.01570567f, -0.01656837f, 0.02114137f, -0.01371201f, -0.02459888f, 
    -0.00222420f, -0.04012172f, -0.02001257f, 0.00839893f, -0.02304587f, 0.02009306f, 0.00156943f, -0.03426647f, 
    0.01900479f, 0.01185251f, 0.01961184f, -0.01124081f, -0.03625278f, 0.01352205f, -0.03546317f, -0.03085430f, 
    0.01271082f, -0.01139185f, -0.01438468f, 0.00044918f, -0.00511813f, -0.00546559f, 0.02234398f, 0.02565688f, 
    -0.01178545f, -0.00173049f, 0.01220231f, 0.02692494f, -0.00553224f, -0.03585125f, -0.01995920f, -0.02228310f, 
    0.02125921f, 0.02199978f, 0.03240500f, -0.00955122f, -0.02198650f, -0.02784587f, -0.02544825f, -0.02165435f, 
    -0.03551685f, -0.03225924f, -0.02330671f, 0.01337155f, -0.03185335f, 0.00947598f, 0.00021768f, -0.01491785f, 
    0.01541991f, -0.01082763f, 0.02166666f, -0.02609673f, 0.02569906f, -0.00581259f, 0.01627548f, 0.02249888f, 
    0.00359128f, 0.00038756f, -0.02545138f, -0.03878859f, -0.03193129f, -0.01776740f, 0.02563569f, 0.01063489f, 
    0.01500371f, -0.02737565f, -0.02250022f, 0.00096485f, -0.00862531f, -0.03044859f, 0.01572243f, -0.01902780f, 
    0.02639907f, 0.02962392f, 0.01069458f, 0.01610743f, 0.00767153f, -0.03421237f, 0.01909567f, 0.00620344f, 
    0.02632672f, 0.02453596f, 0.01028441f, -0.00740930f, -0.03262685f, -0.01477832f, -0.00336362f, 0.02298781f, 
    -0.00429127f, -0.03558683f, 0.01621895f, 0.03130068f, -0.02672560f, 0.02930260f, -0.03483532f, -0.00847886f, 
    0.01790654f, -0.01625294f, -0.01504508f, -0.00442286f, 0.01153843f, 0.02169695f, 0.00326273f, 0.00246109f, 
    -0.03106674f, -0.01662322f, -0.02466258f, -0.02022166f, 0.02557537f, -0.01651887f, -0.00901729f, 0.03007124f, 
    0.01845788f, 0.00141839f, -0.03719349f, 0.02281310f, 0.01618565f, 0.02770831f, 0.01478734f, 0.00292705f, 
    -0.02117164f, 0.00648473f, 0.02210931f, -0.04056483f, 0.01497011f, -0.03203187f, -0.01359292f, 0.01166301f, 
    0.02052622f, -0.02574146f, -0.02431606f, 0.02544942f, -0.01397414f, -0.02810627f, -0.03326242f, -0.03716362f, 
    -0.00520482f, -0.01785005f, -0.02276214f, -0.03897135f, 0.02709658f, -0.04062144f, -0.03779022f, 0.02149274f, 
    -0.03291245f, 0.02967078f, -0.02059071f, -0.03502829f, 0.01639473f, -0.00530249f, 0.01967600f, -0.00802075f, 
    -0.01681354f, 0.00178761f, -0.01272803f, -0.00258512f, -0.03281257f, -0.02198959f, -0.03404681f, 0.00237533f, 
    -0.03339392f, -0.02671110f, 0.00555406f, -0.03002286f, -0.04001350f, 0.02073753f, 0.01299564f, -0.01171943f, 
    -0.00263300f, 0.00205853f, -0.01140009f, -0.02148003f, -0.04087725f, 0.02211753f, -0.01160272f, -0.03643411f, 
    -0.02468763f, 0.00129927f, 0.01930630f, 0.02128304f, -0.01812384f, -0.01014049f, 0.03037957f, 0.01271098f, 
    0.01997263f, -0.01402474f, -0.02760676f, -0.02339089f, 0.02133660f, -0.01928527f, -0.02736351f, 0.00020392f, 
    0.01957792f, 0.00005116f, -0.04019016f, 0.02053124f, 0.00022617f, 0.00884783f, -0.03196970f, 0.02848214f, 
    0.00096671f, -0.02855611f, -0.03111694f, -0.03696785f, -0.00256366f, -0.01592611f, -0.01155657f, 0.01114476f, 
    -0.01399212f, 0.00319155f, -0.00716880f, -0.01844897f, 0.00083425f, -0.00779429f, 0.00067974f, 0.00719327f, 
    -0.02447251f, -0.02385920f, 0.03058769f, 0.01491727f, -0.01368034f, -0.00309318f, -0.00578113f, 0.00423615f, 
    -0.03396886f, 0.01967846f, -0.04064243f, 0.02300872f, 0.01017078f, 0.02005900f, 0.01654259f, 0.00449355f, 
    -0.00211343f, -0.03164873f, -0.02420692f, 0.02749270f, -0.03036822f, 0.02843882f, 0.01197649f, 0.01308207f, 
    0.01621560f, -0.03714797f, -0.03363743f, -0.02923918f, 0.02841840f, -0.00875916f, -0.01663295f, -0.00629713f, 
    -0.00181091f, -0.01463256f, -0.00435432f, -0.02241514f, -0.03206284f, -0.02120875f, 0.02022934f, -0.01307248f, 
    0.02812823f, 0.01266538f, 0.01201397f, -0.00676280f, 0.02994268f, -0.03130848f, -0.01043020f, 0.01050970f, 
    0.02262291f, 0.01811001f, 0.02264298f, 0.00718033f, -0.03274550f, -0.03802167f, -0.00693974f, 0.00282442f, 
    -0.02066223f, -0.01616461f, -0.00445909f, -0.02758085f, 0.01673674f, -0.02114621f, 0.03051966f, 0.02629705f, 
    0.00076151f, 0.01182866f, -0.02069660f, -0.03543586f, 0.02550355f, -0.04020443f, -0.03604766f, -0.04031749f, 
    -0.03649329f, -0.01297588f, -0.02365167f, -0.02438005f, -0.00954617f, -0.03651604f, 0.00453334f, 0.01602717f, 
    -0.01994725f, -0.03180318f, 0.01768132f, -0.01350761f, 0.01989416f, -0.03476258f, -0.03099977f, -0.01673371f, 
    0.02988432f, -0.01234633f, -0.03336634f, 0.01855385f, -0.02738593f, 0.01296890f, -0.00652620f, -0.01458355f, 
    -0.03861815f, 0.01757967f, 0.01869306f, 0.01905054f, 0.01250806f, -0.02238853f, 0.02105391f, -0.00884261f, 
    -0.01279511f, -0.01551187f, -0.00223593f, 0.03417734f, -0.03221230f, 0.02986085f, -0.01910874f, 0.00961300f, 
    -0.04149147f, 0.02793131f, -0.02232941f, -0.03747726f, -0.01271538f, -0.02653169f, -0.00244144f, 0.00760558f, 
    0.02276463f, 0.02669312f, -0.00260113f, -0.00279299f, -0.00943514f, -0.01979519f, -0.01254318f, -0.02913594f, 
    -0.01783115f, 0.02245471f, 0.02080860f, 0.00393948f, -0.02023242f, 0.01102851f, 0.02675200f, 0.00868474f, 
    -0.03762820f, -0.02613159f, -0.02082282f, 0.01914159f, 0.01765858f, -0.03280491f, 0.02432827f, -0.03074771f, 
    -0.03766318f, -0.03833150f, 0.01504001f, 0.03013967f, -0.00882760f, 0.03062730f, 0.02847511f, 0.01588831f, 
    0.03363967f, 0.01479806f, -0.03114845f, 0.01294943f, -0.01002333f, 0.03570813f, -0.00114385f, 0.03045032f, 
    -0.00030921f, -0.02558265f, -0.02428902f, -0.03901497f, -0.02728757f, -0.01047266f, -0.00249104f, 0.01437979f, 
    -0.02279605f, -0.00712710f, 0.01182041f, -0.03034952f, -0.03214143f, -0.02170123f, -0.00425150f, 0.00556543f, 
    0.02012090f, -0.03319169f, -0.00103257f, -0.03443582f, -0.01534561f, -0.01845756f, 0.03582602f, 0.02870886f, 
    -0.02686150f, 0.01150089f, -0.00635914f, 0.00295866f, -0.02394767f, -0.01673979f, -0.02947977f, -0.01532811f, 
    0.02625742f, 0.01391955f, 0.00251042f, -0.02856206f, 0.01194972f, 0.03059442f, 0.00813811f, -0.01622338f, 
    -0.03437201f, -0.03521621f, -0.01480579f, 0.02049955f, 0.00156504f, -0.02779176f, 0.00665119f, 0.00987133f, 
    -0.03694368f, 0.02961082f, -0.03729343f, -0.02014869f, 0.01252409f, -0.00919904f, 0.01729619f, -0.01930073f, 
    0.02520904f, -0.03376807f, -0.02488251f, -0.02537147f, 0.02845512f, -0.01625388f, -0.01161789f, 0.01524454f, 
    0.00911050f, -0.04049473f, -0.00536782f, 0.01436077f, -0.03823887f, -0.02599589f, 0.01644353f, -0.00603866f, 
    -0.03458674f, 0.01289942f, 0.01988546f, -0.00242619f, -0.02729111f, -0.03534291f, -0.02027908f, 0.00924631f, 
    0.00526568f, 0.01934657f, -0.03083185f, 0.00356075f, 0.00486442f, 0.02288194f, -0.00606972f, -0.02278393f, 
    0.00799677f, -0.01544856f, -0.02696476f, -0.02473528f, 0.01184428f, -0.03057232f, 0.00654812f, -0.00595314f, 
    0.02604608f, -0.03297883f, 0.02481356f, -0.03978690f, -0.00795031f, -0.01725086f, 0.00657617f, -0.02786903f, 
    -0.01908767f, 0.02232229f, -0.00574103f, -0.01906341f, 0.01575862f, -0.00687290f, -0.02370907f, -0.00354577f, 
    -0.04109214f, 0.01632374f, -0.03747733f, 0.00283172f, -0.01277457f, 0.00909211f, 0.02893751f, 0.01677491f, 
    -0.01205465f, -0.01519628f, -0.03359177f, -0.02999514f, -0.02156953f, -0.03324838f, 0.00538342f, 0.01049503f, 
    -0.02449630f, 0.00866816f, -0.01248838f, -0.01856313f, 0.03039147f, 0.01451610f, -0.00309029f, -0.01577334f, 
    -0.00751111f, -0.02447273f, -0.02839700f, -0.00361803f, -0.03363182f, -0.03470521f, 0.01825710f, -0.00508815f, 
    0.00815436f, -0.00149033f, -0.01086928f, 0.02043781f, 0.02390357f, -0.01196593f, 0.00412445f, 0.02222277f, 
    -0.02467527f, 0.01173580f, 0.00553770f, 0.02011926f, -0.02112892f, -0.02086985f, -0.00237272f, -0.00484349f, 
    -0.03520919f, -0.00825754f, -0.01824093f, -0.01575332f, -0.02205806f, -0.01108142f, 0.01378151f, -0.00533786f, 
    0.02744624f, -0.00448066f, 0.00608754f, -0.02019698f, -0.01741042f, 0.01050725f, -0.03558115f, -0.04035762f, 
    -0.02940940f, -0.01756716f, -0.00994240f, 0.01447923f, 0.02057147f, -0.01992299f, -0.01993600f, -0.00020029f, 
    0.01863642f, -0.01785414f, 0.01027768f, 0.00396132f, 0.01623843f, -0.02563884f, 0.02055205f, 0.02325412f, 
    -0.04092604f, -0.00022640f, -0.01764781f, -0.03657736f, -0.04025793f, -0.00026108f, 0.01407785f, -0.02274192f, 
    -0.03027337f, 0.02682323f, -0.03263872f, 0.02698159f, 0.00734324f, 0.00620263f, 0.02478875f, -0.01321748f, 
    -0.01063635f, 0.03252014f, -0.02902739f, -0.00905194f, -0.01187801f, 0.00824041f, -0.02885658f, -0.02697365f, 
    -0.03567490f, -0.00167375f, -0.02663029f, -0.02145325f, 0.00745258f, -0.03811825f, -0.02981049f, -0.01494176f, 
    -0.01872842f, 0.00286572f, -0.01738471f, -0.01810568f, 0.01719071f, -0.01990570f, -0.00632698f, -0.00694249f, 
    -0.02121920f, 0.02594351f, 0.01311769f, -0.02434542f, -0.00204009f, -0.01270298f, -0.02535944f, 0.02100701f, 
    -0.02612497f, 0.00386165f, -0.03869415f, 0.00979220f, 0.02865230f, -0.00794778f, -0.00048598f, -0.02147236f, 
    0.02337424f, -0.00157132f, -0.00834360f, -0.01701331f, 0.02493772f, -0.03288569f, 0.02868568f, 0.02551479f, 
    -0.02079936f, 0.02701048f, -0.03093341f, -0.00479020f, -0.03814226f, -0.02485656f, 0.02074108f, 0.02397492f, 
    0.03237547f, 0.03297154f, -0.03818706f, -0.01979231f, 0.02559829f, -0.01241037f, -0.01866217f, 0.02237242f, 
    0.02548531f, -0.01351437f, -0.02748063f, -0.01860739f, 0.00197299f, -0.00180179f, -0.01269022f, 0.02137564f, 
    -0.01598217f, 0.00628139f, 0.02491509f, 0.01948662f, 0.02226995f, 0.01170098f, -0.01695133f, -0.02258728f, 
    0.02851484f, -0.00326832f, -0.02649757f, -0.02943186f, -0.01889545f, -0.00218419f, -0.02840746f, 0.02364219f, 
    0.01832828f, -0.00709380f, -0.00945656f, 0.03908730f, 0.01719296f, 0.01305433f, -0.04002357f, -0.03327652f, 
    -0.02641073f, 0.02823171f, -0.01434487f, -0.00840759f, -0.00762448f, 0.00356442f, 0.01953981f, 0.00643107f, 
    -0.03022341f, -0.02810905f, -0.02063249f, -0.01552519f, 0.00946504f, -0.02797283f, 0.01437146f, 0.00415914f, 
    -0.00933975f, -0.02745257f, 0.01861975f, -0.01068646f, 0.02454660f, 0.00916459f, -0.02638433f, -0.03702349f, 
    -0.03738666f, -0.03674801f, -0.04151554f, -0.03022570f, 0.02158401f, -0.03087901f, -0.00753930f, 0.01221745f, 
    -0.03258282f, 0.02708297f, -0.04007626f, -0.03107921f, 0.00673695f, -0.02316917f, 0.00024132f, -0.03462098f, 
    -0.03487691f, -0.02792116f, -0.03566707f, 0.02111726f, -0.00294967f, -0.00445005f, 0.01876781f, 0.02083168f, 
    -0.02849537f, -0.00282339f, 0.00276671f, -0.01635503f, -0.03330214f, 0.01172602f, 0.01969391f, -0.01500785f, 
    0.01766557f, -0.01143478f, 0.03314638f, -0.02219939f, -0.03565094f, -0.01071819f, 0.00963302f, 0.01622492f, 
    0.00069835f, -0.00820096f, -0.01650361f, 0.00988356f, -0.02818548f, -0.01807802f, 0.00510756f, 0.00132895f, 
    -0.03142583f, 0.01153843f, -0.02546910f, -0.00881762f, -0.04084540f, -0.02485019f, -0.04110967f, -0.04068028f, 
    -0.01967943f, 0.01885205f, 0.00433583f, -0.00122231f, -0.03762924f, 0.02964803f, -0.00023107f, -0.01405570f, 
    0.01053277f, -0.00403738f, 0.00333375f, 0.00041809f, 0.01265609f, 0.01559874f, 0.01913914f, -0.00632171f, 
    0.03682257f, 0.01561513f, -0.03555878f, -0.00059041f, 0.04022919f, 0.02205394f, 0.01948922f, 0.00027768f, 
    -0.04004622f, -0.01725720f, -0.02541279f, -0.03131066f, 0.00555254f, -0.03708072f, -0.02015245f, 0.02400359f, 
    0.03007460f, 0.02888771f, -0.03501285f, -0.01915856f, 0.02115761f, 0.00676360f, -0.02737653f, -0.00014876f, 
    -0.02941900f, 0.03269059f, 0.02954141f, 0.02342985f, 0.02986427f, 0.02992145f, -0.01862250f, 0.01760660f, 
    -0.00742770f, -0.01238788f, -0.03952588f, 0.02108195f, -0.03554272f, 0.01791932f, -0.02071310f, -0.02431816f, 
    0.02074263f, 0.01633269f, -0.02475746f, -0.02226132f, 0.00945646f, 0.01616064f, -0.03404998f, -0.03092687f, 
    -0.03776391f, 0.02783504f, -0.03086580f, 0.02529667f, -0.01916222f, 0.02577498f, -0.01813535f, 0.01797420f, 
    -0.00543618f, 0.02023422f, -0.00843025f, -0.02481541f, 0.02644791f, -0.02270847f, -0.00543504f, 0.01487540f, 
    -0.02188705f, -0.04072869f, 0.02058429f, -0.03242490f, -0.03792708f, -0.00184283f, -0.00163400f, 0.00978906f, 
    -0.01888264f, 0.00406167f, 0.02041309f, 0.00582358f, -0.01763266f, 0.01185523f, 0.02574880f, 0.00411851f, 
    0.02067512f, -0.00608132f, 0.01567490f, -0.02367564f, -0.01116336f, 0.02816222f, -0.02525244f, 0.04015401f, 
    -0.00927091f, -0.00099304f, 0.02213841f, 0.02364366f, 0.00030260f, -0.03950823f, 0.00980763f, -0.01138854f, 
    -0.02026973f, -0.00463707f, -0.03513902f, -0.01283535f, -0.04163344f, 0.00043842f, -0.00619992f, -0.02677739f, 
    0.01722710f, -0.03327690f, -0.03734219f, -0.03490455f, 0.02768026f, 0.00545169f, -0.01961804f, 0.01997516f, 
    0.00749211f, -0.03468785f, 0.02846053f, -0.03021995f, 0.02925931f, -0.02131112f, 0.01060291f, 0.02984753f, 
    -0.00411786f, 0.00898641f, -0.02518361f, -0.01799389f, 0.02136334f, 0.00951725f, -0.01333724f, -0.03681844f, 
    -0.01987829f, 0.01978744f, -0.03466190f, -0.04166887f, 0.01480351f, -0.00768274f, 0.02354485f, -0.04012276f, 
    0.02243654f, 0.01064380f, -0.03434499f, 0.00587074f, 0.02251295f, 0.02081862f, 0.00323229f, -0.00644552f, 
    -0.01821375f, -0.01404368f, 0.01999152f, -0.02646573f, -0.02487121f, -0.04090943f, -0.02585808f, -0.00292516f, 
    0.02182315f, -0.01063440f, -0.02598820f, 0.01910625f, -0.02743828f, -0.03751630f, 0.01732789f, 0.02982755f, 
    -0.03466690f, 0.00955606f, -0.01184676f, 0.03630897f, -0.03008645f, 0.02260242f, 0.02892549f, 0.00327062f, 
    -0.02797995f, 0.00491852f, -0.02980637f, -0.00477028f, 0.01240875f, -0.02641242f, -0.02905385f, -0.00273213f, 
    -0.00483027f, -0.02609965f, 0.00820078f, -0.00708864f, 0.04108847f, -0.02969352f, -0.02427142f, -0.00667154f, 
    -0.02345269f, -0.02009045f, 0.01762342f, -0.03819400f, -0.03893166f, 0.03970151f, 0.01026186f, -0.00904474f, 
    -0.01110314f, 0.01948888f, -0.01861696f, 0.01220369f, 0.02459876f, -0.03219675f, -0.01020364f, 0.02840281f, 
    -0.02616305f, -0.03932126f, -0.03799092f, 0.02459525f, -0.02839484f, -0.01858693f, 0.02246240f, 0.03041494f, 
    -0.02232136f, -0.03388040f, -0.02415148f, -0.00906776f, 0.00778632f, -0.03746057f, 0.01225537f, 0.02235540f, 
    0.01203165f, -0.03620022f, -0.00528922f, -0.01949305f, 0.02431028f, -0.00003689f, -0.01271091f, 0.00479440f, 
    -0.00549181f, -0.00004668f, 0.00033033f, -0.02483944f, 0.00576329f, 0.03043657f, 0.01078868f, -0.03830749f, 
    -0.03015899f, 0.02949539f, 0.02807856f, -0.00821129f, 0.02861268f, -0.01333657f, -0.01761188f, -0.01049418f, 
    -0.04004767f, 0.00233994f, -0.00832065f, 0.03034157f, -0.04120869f, -0.00149983f, -0.03855806f, -0.03906403f, 
    -0.00449879f, -0.00772188f, -0.02785040f, 0.01814876f, -0.01411299f, 0.01289077f, -0.03345072f, -0.00717639f, 
    -0.03888505f, -0.00509686f, 0.01506739f, 0.01834818f, 0.02279448f, 0.01912195f, 0.02249215f, 0.02238870f, 
    0.00187598f, -0.00831862f, -0.00851739f, -0.01475110f, -0.01793640f, -0.01210343f, 0.00965965f, -0.03564767f, 
    -0.03563950f, 0.02244088f, -0.01632965f, 0.01454177f, -0.00541583f, -0.01264995f, -0.00470258f, -0.02847098f, 
    0.00240922f, -0.00722273f, -0.01550647f, 0.00468414f, 0.02758896f, -0.02663050f, 0.01143816f, 0.01705591f, 
    0.02239053f, 0.01653617f, -0.03061246f, -0.00592955f, 0.00130880f, -0.00604479f, 0.01771090f, -0.00676868f, 
    0.01127349f, 0.01510287f, -0.04093574f, 0.02835326f, 0.00097401f, -0.00448168f, 0.02688054f, -0.01385729f, 
    0.01926007f, -0.01746096f, -0.03939695f, 0.02813096f, -0.00277365f, -0.00427223f, -0.02168618f, -0.02277924f, 
    -0.00997343f, 0.01012238f, -0.00094547f, -0.01578683f, -0.01601946f, 0.02209534f, 0.02634948f, 0.00426540f, 
    -0.03406269f, -0.00851588f, -0.02680005f, 0.01521371f, -0.02085754f, 0.01380230f, -0.02540836f, 0.00424827f, 
    -0.01854008f, 0.00917172f, -0.03310955f, 0.01154005f, 0.00779837f, 0.01822934f, 0.01383174f, 0.00895404f, 
    0.01374555f, 0.00285491f, 0.01552851f, 0.03191751f, -0.03938880f, 0.01414225f, -0.01724948f, 0.01793404f, 
    -0.02291080f, -0.01902583f, -0.00122547f, 0.01546917f, -0.03915899f, 0.02460150f, -0.01473463f, -0.03456057f, 
    -0.03582115f, -0.02654970f, 0.02785913f, -0.02868687f, -0.01174491f, 0.02877715f, 0.00592360f, -0.02676476f, 
    -0.03288740f, -0.02609160f, 0.00635318f, -0.00663790f, -0.02413670f, -0.02123030f, -0.03118557f, 0.02161485f, 
    -0.03962587f, -0.04194110f, 0.00446651f, -0.01550267f, -0.02656165f, -0.00619223f, 0.00300918f, 0.00529668f, 
    -0.03300434f, -0.03975990f, -0.00213950f, -0.01982463f, -0.00238690f, 0.02598038f, -0.01822376f, -0.01672396f, 
    -0.01633757f, -0.02661608f, -0.01751799f, -0.01001084f, -0.00636688f, -0.02166687f, -0.00970031f, -0.01593667f, 
    0.02689843f, 0.04071817f, -0.00344840f, -0.01014979f, 0.00885001f, -0.02062293f, -0.02007597f, 0.00018544f, 
    -0.00655085f, -0.01630609f, -0.03872345f, -0.04092379f, -0.01882303f, 0.02647125f, -0.01905387f, 0.02983393f, 
    0.00002224f, 0.01910932f, 0.00748710f, -0.03538531f, -0.03456219f, -0.01935071f, 0.02751761f, -0.00241789f, 
    -0.00933717f, 0.02509451f, -0.03264330f, -0.00353233f, -0.03687937f, 0.02984327f, -0.00377863f, 0.01229954f, 
    -0.01204995f, 0.01358610f, -0.01682865f, 0.02502360f, -0.00867326f, 0.02485623f, 0.02442208f, 0.01465621f, 
    0.02566784f, 0.01849359f, 0.02457460f, -0.00482596f, 0.00769111f, -0.00910098f, -0.00366848f, -0.01943936f, 
    -0.03978829f, -0.04168882f, -0.02932746f, -0.04042839f, -0.02981281f, 0.01641703f, 0.01791913f, -0.02514001f, 
    -0.01524397f, -0.03784147f, -0.01605325f, -0.02716727f, -0.04003360f, -0.02760115f, 0.03910540f, 0.01838933f, 
    0.01231456f, 0.02888373f, -0.00503417f, -0.04065319f, -0.00983472f, 0.00013645f, -0.02600128f, -0.03482286f, 
    -0.02528478f, 0.01925763f, 0.01770555f, 0.00975430f, -0.02015359f, 0.00823334f, 0.01757306f, 0.01213132f, 
    0.01028952f, 0.00605395f, -0.02243482f, -0.04095415f, -0.02975589f, -0.00839285f, 0.02878802f, 0.00004709f, 
    0.00295462f, -0.00277348f, -0.02980888f, 0.01163724f, -0.00124130f, 0.01965968f, 0.00529970f, 0.01865566f, 
    -0.02533945f, -0.00062169f, 0.00315908f, 0.00868504f, -0.02880798f, -0.02702651f, -0.01126895f, 0.01957136f, 
    -0.01177219f, 0.00799107f, 0.01448770f, -0.02021515f, 0.01755642f, -0.00495159f, 0.02830429f, -0.01616319f, 
    0.00166033f, 0.01256565f, 0.01761591f, 0.02244308f, -0.01088119f, 0.00778795f, -0.01042564f, 0.01326191f, 
    0.05767678f, 0.11606271f, 0.10757399f, 0.00923773f, -0.02277744f, -0.03051060f, -0.13050486f, -0.09437060f, 
    -0.06066747f, 0.08795947f, 0.00062832f, -0.21377864f, -0.26741570f, 0.04580536f, 0.04732251f, -0.02635412f, 
    0.29692468f, 0.05051771f, 0.18251902f, 0.20720035f, 0.03943957f, -0.02815001f, 0.16047232f, -0.00599819f, 
    -0.61532182f, 0.22297218f, 0.07622012f, -0.13814725f, 0.04251510f, 0.05489799f, -0.08337040f, -0.32143077f, 
    0.02387925f, 0.06019055f, -0.11255555f, -0.15438890f, 0.21779460f, 0.04553735f, -0.03733947f, 0.31010568f, 
    0.21268706f, 0.04741494f, 0.11307480f, -0.08576630f, 0.03211316f, 0.02352539f, -0.06142122f, -0.15127745f, 
    0.12419203f, 0.24350424f, 0.17402944f, 0.20129256f, -0.10099679f, -0.10207789f, -0.02578228f, 0.04537159f, 
    0.01062708f, 0.09297819f, -0.04970559f, -0.00462254f, 0.02137544f, 0.01086159f, -0.18369858f, -0.07702485f, 
    -0.17228407f, 0.02614007f, 0.25267276f, -0.03460352f, -0.10346633f, 0.05879732f, -0.01472308f, 0.02274016f, 
    0.10896966f, 0.23740365f, 0.11429607f, 0.08189669f, -0.14425747f, -0.11259912f, -0.13818732f, -0.09650521f, 
    -0.03618695f, -0.00116293f, -0.02267114f, 0.02472636f, -0.17525050f, 0.01313784f, -0.04674954f, -0.10615759f, 
    0.06111192f, 0.03836575f, 0.01338811f, 0.25493759f, 0.18744779f, 0.10031222f, -0.20330565f, 0.11936767f, 
    0.46951509f, 0.05543590f, 0.14048430f, -0.06673469f, 0.07861044f, 0.01385737f, -0.00640724f, 0.01121444f, 
    0.08649577f, -0.05930782f, 0.03219534f, 0.03791463f, -0.15207334f, -0.08347561f, -0.08839002f, -0.01315818f, 
    0.02797076f, 0.05918254f, -0.04080606f, 0.08753453f, -0.06122737f, 0.03129229f, -0.05206253f, 0.09776615f, 
    0.23441039f, 0.22029516f, 0.28526822f, 0.47611594f, -0.12147450f, -0.01252746f, 0.02893391f, 0.15149978f, 
    -0.03841207f, -0.10646246f, -0.06802775f, 0.05916054f, 0.21842700f, 0.06685107f, -0.00113940f, -0.04376487f, 
    -0.20137100f, 0.05923419f, -0.25450879f, 0.08997064f, -0.04016960f, 0.02307515f, 0.07225562f, 0.01757286f, 
    0.10076994f, -0.04195968f, 0.01172188f, -0.12508641f, 0.04690812f, 0.09116486f, -0.11798113f, 0.05164753f, 
    -0.14180101f, 0.11347304f, 0.01925778f, 0.02785757f, -0.04993363f, 0.09751741f, -0.02489248f, -0.00729453f, 
    -0.03827566f, -0.03389904f, 0.11254952f, 0.07631804f, 0.00295129f, -0.12148671f, -0.23261935f, 0.06051302f, 
    -0.10477115f, 0.36762667f, 0.15336856f, -0.20133381f, 0.04727153f, 0.09574208f, 0.10629342f, -0.02206908f, 
    -0.13981161f, 0.04289794f, -0.13292260f, -0.12176141f, 0.04130220f, -0.25029182f, -0.05485140f, -0.18123674f, 
    0.08750801f, 0.13027865f, 0.00220938f, -0.06225186f, 0.15273178f, 0.04538259f, 0.06817318f, 0.00132357f, 
    -0.06932767f, -0.07328961f, 0.00871480f, 0.22056983f, -0.16092300f, -0.02000316f, 0.01799848f, -0.02410472f, 
    0.02625984f, 0.01553386f, -0.01880442f, 0.05242860f, 0.11761071f, 0.03992325f, 0.05859363f, 0.01154966f, 
    -0.01218699f, -0.01631227f, 0.08941191f, 0.03788045f, -0.03019184f, 0.06334574f, -0.17508554f, 0.12597834f, 
    -0.15273924f, 0.03195281f, 0.04969541f, -0.09171770f, 0.09087423f, 0.09307435f, 0.04155799f, 0.10662349f, 
    0.00230370f, -0.02193467f, -0.05057888f, 0.03635357f, -0.38141620f, -0.08373173f, 0.03729846f, 0.30756950f, 
    -0.08004899f, 0.03584809f, 0.01142062f, 0.09282161f, 0.03176574f, 0.03478964f, -0.02563628f, 0.17734775f, 
    0.32836819f, 0.21021302f, 0.42137155f, -0.20259367f, -0.05968456f, -0.22448297f, -0.00934823f, -0.03996419f, 
    -0.08070733f, -0.06815910f, 0.05324513f, 0.00560813f, 0.17667916f, 0.06140427f, 0.07847794f, -0.06927909f, 
    -0.00286856f, -0.04933190f, -0.00346630f, -0.11371750f, -0.03777325f, -0.02251687f, -0.08201444f, -0.08077382f, 
    -0.01601058f, -0.13649510f, -0.13681436f, -0.21774344f, -0.06156963f, -0.02673865f, 0.11192325f, 0.05773222f, 
    0.09417590f, 0.01624168f, -0.02914558f, -0.03933971f, -0.02945943f, -0.09232612f, 0.21043321f, 0.02382638f, 
    -0.02713982f, -0.05132540f, 0.04669160f, 0.05386114f, 0.05293734f, -0.01284718f, 0.07202335f, -0.14185789f, 
    0.11638543f, -0.02188165f, 0.21046333f, 0.05855402f, 0.10976924f, -0.06474122f, 0.04609885f, -0.12358010f, 
    -0.08790568f, -0.01551106f, -0.01613018f, -0.29016984f, -0.25410134f, 0.18956698f, -0.09616999f, -0.25267923f, 
    -0.09644315f, -0.26386803f, 0.02351780f, 0.15783316f, -0.02118520f, 0.03239395f, 0.14891630f, 0.07158738f, 
    0.31007841f, -0.26977885f, 0.04101870f, 0.05989021f, -0.10559867f, -0.04225189f, 0.07199692f, 0.15453757f, 
    -0.00380061f, 0.32201841f, 0.03323099f, -0.10638992f, -0.17311785f, -0.06186523f, -0.15685852f, -0.00365787f, 
    -0.14688088f, 0.03970845f, -0.00964147f, -0.01155941f, 0.09820298f, -0.03508165f, 0.00183262f, 0.06324399f, 
    0.30448124f, -0.35843506f, 0.33613503f, -0.24958116f, 0.00697192f, 0.01429073f, -0.07807697f, -0.02247846f, 
    0.02734956f, -0.11349561f, 0.09669612f, -0.06751271f, 0.38393930f, -0.11317108f, 0.14192341f, -0.16737907f, 
    -0.03452976f, 0.10743278f, -0.04725206f, 0.17811552f, -0.00838400f, 0.15481006f, 0.00686619f, -0.03846621f, 
    -0.00423717f, -0.02261856f, -0.00028853f, 0.01406438f, -0.18052720f, 0.01717711f, 0.00031010f, -0.08381023f, 
    0.25626102f, -0.13931526f, -0.04711165f, 0.13523881f, -0.05497992f, 0.04735667f, 0.40940061f, 0.10660961f, 
    -0.02591153f, -0.17366216f, -0.04995282f, 0.03769529f, 0.03741184f, 0.06631445f, -0.07588028f, 0.05940605f, 
    0.11430742f, 0.35113075f, 0.20872279f, -0.04393702f, -0.09353998f, 0.06781939f, -0.05985211f, -0.01634463f, 
    -0.13991550f, -0.12722191f, -0.16279960f, 0.03212318f, 0.18891484f, 0.14650072f, 0.07330294f, -0.09575684f, 
    0.04578333f, 0.05268164f, 0.07483381f, 0.00571388f, 0.01183876f, -0.02779492f, -0.11260540f, 0.12301292f, 
    0.04560130f, 0.15449782f, -0.00457341f, 0.07647765f, -0.10740376f, -0.02506577f, -0.03542364f, 0.00064524f, 
    0.05980637f, -0.00795342f, 0.11658436f, -0.16331917f, 0.03561164f, 0.17904365f, -0.10439676f, 0.19487752f, 
    -0.09518298f, 0.08563956f, -0.06430852f, 0.09887005f, -0.14237356f, 0.07351618f, -0.02854403f, 0.01795371f, 
    -0.20181514f, -0.13474986f, -0.10529155f, -0.09332370f, -0.03647698f, 0.00686172f, 0.05192498f, 0.17120281f, 
    -0.11485165f, 0.03290268f, -0.08016432f, -0.14722048f, -0.03748653f, 0.14388193f, 0.08172609f, 0.20950978f, 
    0.02075587f, 0.04112336f, 0.06003201f, 0.01920058f, 0.06056135f, 0.16762879f, -0.06376085f, -0.07336076f, 
    0.07234114f, -0.37651449f, 0.27104560f, 0.08388951f, -0.08102240f, -0.04260141f, 0.03725625f, -0.00029460f, 
    0.05764993f, 0.04352657f, 0.12270410f, 0.09744943f, -0.08106068f, 0.10136160f, -0.00881919f, 0.12291877f, 
    0.14993377f, -0.04708731f, -0.00185438f, 0.06703352f, -0.17959569f, -0.07622041f, 0.00773169f, -0.05799073f, 
    -0.24145348f, 0.02372590f, -0.12307160f, 0.05669999f, 0.17897777f, -0.09626517f, 0.07475821f, 0.01970786f, 
    -0.03074771f, -0.08090960f, 0.01404936f, -0.06308573f, -0.40911824f, 0.12055591f, -0.26666737f, 0.11794937f, 
    0.19828598f, -0.02964940f, 0.21456204f, -0.18653695f, -0.01320869f, -0.06373866f, 0.04620183f, -0.01617713f, 
    0.22320737f, -0.12932660f, 0.20746306f, -0.19297715f, 0.02326501f, -0.06707352f, 0.13341138f, 0.06499204f, 
    0.03941327f, 0.07655008f, 0.03197949f, 0.09712018f, 0.19075504f, 0.09718546f, 0.09527183f, -0.06638037f, 
    -0.10185578f, -0.18930347f, 0.08538885f, -0.06350013f, 0.01755048f, -0.05091352f, -0.04181043f, 0.01316900f, 
    0.08417355f, 0.08904582f, 0.10846397f, 0.19238806f, 0.06473169f, 0.15168722f, 0.01197135f, 0.16926606f, 
    0.21411680f, -0.01204507f, -0.07239782f, 0.16069829f, -0.02557463f, 0.13419604f, -0.06736624f, -0.08980491f, 
    0.01822239f, -0.10216051f, -0.05124346f, -0.01979160f, -0.09738162f, -0.06356397f, 0.04858359f, -0.03670264f, 
    0.01363490f, 0.20262380f, -0.01713408f, 0.05801453f, -0.05697320f, -0.13664010f, -0.07215385f, -0.01138172f, 
    -0.10399844f, -0.04096668f, 0.04098236f, 0.04648668f, -0.15161854f, -0.07078743f, 0.46068314f, -0.14826812f, 
    0.15097776f, 0.15595157f, -0.06540242f, 0.12327467f, -0.08466291f, -0.06454694f, 0.05640903f, -0.03922397f, 
    0.00567835f, 0.14780769f, 0.44569460f, -0.05004133f, -0.12470737f, -0.10699578f, 0.03491480f, -0.05057454f, 
    0.22611998f, 0.00790616f, 0.04714899f, 0.15468219f, -0.01142461f, -0.26419893f, -0.06607249f, -0.09595364f, 
    -0.04947717f, 0.17820787f, -0.03318052f, 0.27145919f, 0.08335820f, 0.11048302f, -0.08691188f, 0.03874939f, 
    -0.16720900f, 0.17082715f, -0.35345051f, -0.16623789f, -0.06257831f, -0.17335773f, 0.08839380f, 0.10296159f, 
    -0.04347502f, 0.06325851f, 0.05102104f, -0.00296952f, -0.17326662f, 0.04856014f, -0.04983170f, -0.16522393f, 
    0.01468432f, -0.08919052f, 0.09915666f, 0.09254497f, -0.08714494f, 0.05616966f, 0.11920387f, -0.07575449f, 
    0.03961541f, 0.09301333f, 0.11304870f, 0.01302915f, 0.09144048f, -0.08443630f, 0.00773625f, 0.04243856f, 
    -0.09967273f, 0.08015089f, 0.13392311f, -0.03571492f, -0.16793424f, -0.17004716f, -0.02861213f, 0.02001030f, 
    -0.07396010f, 0.05571550f, 0.06870175f, 0.00255451f, 0.02842530f, 0.07980456f, -0.00379777f, -0.02911007f, 
    -0.05698317f, -0.01653516f, -0.15281659f, -0.08584565f, -0.00945450f, 0.00062807f, -0.29751089f, 0.16607513f, 
    -0.05306931f, -0.05706872f, -0.11789023f, 0.10868093f, 0.05955426f, 0.07896120f, 0.10576379f, -0.09195427f, 
    -0.01428562f, -0.16781539f, -0.12928662f, 0.02534965f, -0.02470021f, 0.02988998f, 0.00929744f, 0.03380797f, 
    -0.12066469f, -0.30289060f, 0.26403624f, -0.08748181f, 0.10740972f, 0.09291662f, 0.03337695f, 0.13920334f, 
    -0.00123802f, 0.22922109f, -0.01298233f, 0.12870958f, 0.28171104f, -0.02723296f, -0.05296430f, -0.02079084f, 
    0.07155939f, -0.07689299f, 0.04076050f, -0.02811300f, 0.17177391f, 0.00538902f, 0.01081990f, 0.03218937f, 
    0.19588481f, 0.29955599f, 0.00210475f, 0.03149942f, -0.16824202f, -0.15669952f, -0.10479823f, -0.01181473f, 
    -0.12928045f, -0.09248519f, 0.02512618f, 0.01806791f, -0.47162575f, 0.21629058f, -0.04799533f, -0.16161811f, 
    0.07053437f, 0.20174997f, 0.04916383f, -0.10645034f, 0.05269129f, 0.11626347f, -0.12983981f, -0.02406287f, 
    -0.06395644f, 0.10540845f, 0.11053944f, 0.01120752f, -0.01097415f, -0.06310127f, -0.03620210f, 0.03295733f, 
    -0.17747773f, 0.03312648f, -0.10606030f, 0.07437901f, 0.19538882f, 0.11124458f, -0.09876105f, 0.08769474f, 
    -0.03887225f, -0.08020042f, 0.07240989f, 0.05415952f, 0.14840476f, 0.23355177f, 0.08255518f, 0.17476086f, 
    -0.07520534f, 0.10768606f, 0.05728329f, 0.05391784f, -0.02642277f, 0.06798796f, 0.02394740f, 0.16201821f, 
    -0.12160295f, -0.04848470f, 0.03535462f, -0.04783509f, 0.10103695f, -0.19175310f, 0.07329096f, 0.17869318f, 
    0.17564411f, 0.01671557f, 0.03963727f, 0.20189303f, -0.02975333f, 0.20137468f, 0.11527482f, 0.19703317f, 
    -0.08235956f, 0.00506246f, -0.10218781f, -0.09081265f, 0.07901079f, 0.01305073f, 0.11960795f, 0.06326085f, 
    0.13099091f, 0.01538963f, -0.05950780f, -0.02954861f, -0.27098250f, -0.08501054f, 0.00192444f, 0.14565681f, 
    -0.11489854f, -0.04163997f, 0.03041006f, -0.07402547f, 0.05069172f, -0.05324261f, -0.08904517f, 0.08629771f, 
    -0.29696608f, 0.20676249f, -0.07072358f, -0.16340518f, -0.08905999f, 0.16453347f, 0.14588937f, 0.24982589f, 
    0.00130516f, 0.04667838f, -0.13684587f, 0.00006725f, 0.06670417f, 0.28660962f, 0.17802645f, -0.07074112f, 
    -0.02685707f, 0.20996657f, 0.01190619f, 0.08631656f, 0.04378527f, -0.02864530f, 0.00896688f, 0.12318020f, 
    -0.30455807f, -0.19425386f, -0.20161685f, -0.14244768f, 0.08513192f, -0.00929613f, -0.01786962f, 0.01556914f, 
    -0.07175204f, -0.03458180f, 0.03002599f, -0.05712050f, 0.07261698f, 0.05253368f, 0.25599462f, -0.12940119f, 
    0.15400276f, 0.11409455f, -0.02351702f, 0.16556785f, 0.05490757f, -0.00980561f, 0.00168996f, 0.16437721f, 
    -0.25474074f, -0.36116859f, -0.29513752f, 0.01184992f, 0.10460751f, 0.14150806f, 0.02617375f, -0.07567558f, 
    -0.05154990f, -0.00734117f, 0.01895203f, 0.02296301f, 0.19359072f, -0.04153161f, 0.34445456f, 0.20188801f, 
    0.06540046f, 0.03583610f, 0.27586901f, 0.04318036f, -0.00190696f, -0.09552233f, 0.25657400f, -0.07594271f, 
    0.11460729f, -0.03547519f, -0.00372679f, 0.04812828f, 0.13595635f, -0.03540443f, -0.00815695f, 0.22178233f, 
    -0.13336143f, 0.04617303f, 0.06520411f, 0.05786737f, 0.26340744f, 0.31324711f, 0.29909608f, 0.10533297f, 
    -0.01195559f, -0.02234701f, 0.13435614f, -0.00112035f, -0.02237582f, -0.01863322f, -0.06496321f, -0.02424728f, 
    0.19288166f, 0.00876773f, -0.28844389f, -0.06627380f, -0.06327379f, 0.04474264f, -0.08005650f, 0.00332081f, 
    -0.07044815f, -0.12569229f, 0.09307585f, 0.03699053f, 0.06590430f, 0.00267655f, -0.04614313f, 0.03793911f, 
    0.02982561f, -0.00618239f, 0.23636200f, 0.10182078f, 0.11997101f, -0.04743766f, -0.17659850f, 0.02330936f, 
    -0.22694048f, -0.08387014f, 0.02985362f, -0.09206900f, 0.08327645f, 0.04208295f, 0.09944586f, -0.02249343f, 
    -0.01877747f, 0.01554301f, -0.07425968f, 0.04259244f, -0.04594907f, -0.31602141f, -0.14317748f, 0.03897214f, 
    0.06704620f, -0.02053220f, -0.10943668f, -0.14906150f, -0.01044016f, -0.11783870f, 0.09079641f, -0.02880105f, 
    0.11027036f, -0.06128111f, -0.15408747f, -0.11482491f, 0.06199697f, 0.01811082f, -0.02084009f, 0.12066001f, 
    -0.02072456f, -0.10421173f, -0.00681413f, 0.00693190f, 0.17831287f, -0.03170022f, 0.03386506f, -0.08999620f, 
    0.00526163f, 0.03961383f, -0.06139218f, 0.22784592f, -0.10144053f, -0.04685934f, 0.05511334f, 0.01590803f, 
    -0.05783608f, 0.00445698f, 0.38364795f, 0.02895167f, -0.07284975f, 0.07763017f, -0.09062955f, -0.00614302f, 
    0.07371308f, -0.13595749f, 0.01327050f, 0.02847800f, -0.00493370f, -0.17863603f, -0.33608904f, 0.06454561f, 
    -0.15069687f, 0.02962225f, 0.07684173f, 0.04320338f, 0.13769448f, -0.19793494f, -0.04724158f, 0.00827373f, 
    0.17984973f, 0.13015370f, 0.09853461f, 0.09102774f, 0.08243779f, -0.03159175f, 0.01919342f, 0.05030416f, 
    0.03084675f, -0.08850276f, -0.05752957f, -0.03002759f, -0.61336643f, 0.33032832f, 0.32832903f, 0.28004766f, 
    0.05019508f, -0.08651888f, -0.01181167f, -0.00364541f, 0.00465097f, -0.03961571f, -0.00075587f, -0.00824602f, 
    -0.05999146f, -0.24463594f, -0.19581111f, 0.22512712f, 0.01722994f, 0.17722961f, -0.04179816f, 0.11709067f, 
    0.03633366f, -0.00589124f, -0.19971503f, -0.01155340f, -0.04939950f, 0.09703939f, -0.00997810f, -0.07865513f, 
    0.10424089f, 0.07843899f, -0.11980796f, 0.10496619f, -0.13807429f, 0.08300848f, 0.06503949f, 0.02675628f, 
    0.12981726f, 0.06664951f, 0.02415534f, -0.07390838f, 0.12432154f, 0.13363646f, -0.06756096f, 0.06774360f, 
    -0.05026070f, -0.15676326f, 0.01116795f, -0.00258621f, -0.08272205f, 0.04628979f, 0.05927958f, 0.02765447f, 
    0.04160148f, -0.07976712f, 0.08707412f, 0.01515133f, 0.16594316f, -0.19029480f, -0.19580355f, -0.10141354f, 
    0.24769288f, 0.07247642f, 0.08978692f, -0.04280920f, 0.06957489f, -0.03268995f, -0.06222171f, 0.21699984f, 
    0.05661920f, -0.10339311f, -0.10662413f, 0.20046262f, 0.30868611f, 0.04086524f, -0.07182875f, -0.06063571f, 
    0.21563388f, 0.22555876f, -0.00429292f, 0.12151656f, -0.04586043f, -0.00297871f, -0.04792625f, -0.00039570f, 
    0.08333389f, 0.03324796f, -0.20165306f, -0.12424763f, 0.05341498f, -0.06320915f, -0.04636487f, 0.11858355f, 
    -0.07031017f, -0.11842535f, 0.00728472f, 0.08290122f, 0.05067691f, -0.00131774f, 0.23865995f, 0.10509581f, 
    -0.11028204f, -0.00042424f, -0.03177038f, -0.03486711f, 0.02461685f, -0.00416771f, -0.10259216f, -0.13185889f, 
    0.04446497f, 0.09422822f, -0.35256055f, 0.31989029f, -0.04476031f, 0.00775918f, 0.22910494f, 0.03463065f, 
    -0.05834221f, 0.07881516f, -0.12144556f, 0.00871170f, 0.30618954f, -0.22556156f, -0.11063366f, -0.15887795f, 
    -0.01423516f, -0.06269562f, -0.00490372f, 0.21099468f, -0.06572235f, -0.00418066f, 0.04178265f, -0.06553125f, 
    -0.27230603f, -0.20526473f, -0.08423828f, 0.00354805f, 0.11775952f, -0.04648798f, -0.07698285f, 0.00114900f, 
    -0.07856430f, 0.06880716f, 0.12865183f, 0.01375212f, 0.16041908f, -0.03455630f, -0.36787355f, 0.12033121f, 
    -0.06746354f, -0.00879211f, 0.11489230f, 0.01834665f, -0.01939232f, -0.07694443f, 0.10995141f, -0.06310868f, 
    -0.17308041f, -0.04275051f, -0.00961653f, -0.18257610f, 0.08702653f, 0.00634888f, 0.14677872f, 0.04878874f, 
    -0.02543416f, -0.04428244f, 0.12484803f, -0.01287160f, 0.20216420f, 0.00297067f, -0.06077444f, -0.06231569f, 
    0.12549071f, 0.04543895f, 0.02958066f, 0.16411418f, -0.05390167f, -0.12429392f, -0.12363736f, 0.02925703f, 
    -0.13270605f, -0.12546986f, -0.09921679f, -0.18514270f, 0.07214326f, -0.11864077f, -0.01598585f, 0.04076189f, 
    -0.02054316f, 0.04621288f, 0.15520903f, 0.09469848f, 0.14547732f, 0.02812260f, 0.00078226f, -0.02598425f, 
    -0.08996154f, -0.01981849f, -0.02577493f, -0.01232302f, 0.02867083f, -0.01169196f, -0.16905822f, -0.04503974f, 
    0.14844210f, 0.25292549f, 0.03340425f, 0.00000177f, -0.01515946f, -0.00455352f, 0.02999965f, -0.07716102f, 
    -0.01585486f, -0.07272214f, -0.06150818f, -0.01238891f, 0.02131711f, -0.06349082f, -0.24422690f, -0.24664137f, 
    -0.09215628f, -0.03113239f, 0.09360959f, 0.09803257f, -0.02449130f, -0.16579957f, 0.00379496f, -0.13876446f, 
    -0.19863099f, 0.01934614f, 0.07233412f, 0.23812507f, -0.01303271f, 0.00662281f, 0.02255849f, -0.07177374f, 
    0.00804042f, 0.05694655f, -0.08272675f, 0.03254037f, -0.03050971f, -0.13555999f, -0.10608824f, 0.02774707f, 
    -0.05120416f, 0.10961118f, -0.14204656f, -0.14079981f, 0.00844671f, 0.11506712f, -0.08642309f, 0.05114527f, 
    0.04763322f, 0.22998163f, 0.03290986f, -0.00380129f, -0.01447268f, 0.10283154f, -0.07128141f, 0.07377381f, 
    0.09413043f, -0.07708168f, -0.03718433f, 0.00353480f, -0.08854435f, 0.19607319f, 0.31356737f, 0.00832444f, 
    0.07873698f, 0.05968367f, 0.01268183f, 0.07105117f, 0.05890524f, 0.18923756f, -0.18894967f, 0.01341509f, 
    -0.44159946f, -0.17904237f, -0.12016728f, 0.30809844f, 0.14778373f, 0.15158707f, 0.01800152f, -0.10091519f, 
    -0.04459021f, 0.06317814f, -0.02851637f, -0.06316414f, -0.31812415f, -0.32090446f, -0.23200817f, 0.13709433f, 
    0.09880500f, 0.18309461f, 0.02020182f, -0.04731105f, -0.04411441f, 0.08865035f, -0.00230187f, -0.09897255f, 
    -0.02152916f, -0.06355109f, -0.18824656f, 0.00093210f, -0.04120119f, -0.10775562f, 0.11972567f, -0.03457084f, 
    -0.02823640f, 0.00704370f, 0.08056228f, -0.04262210f, 0.06419944f, 0.00760489f, -0.18724932f, -0.16481200f, 
    0.07642711f, -0.02459943f, 0.05730519f, 0.06662791f, -0.00852852f, -0.01935394f, 0.01949905f, 0.06655651f, 
    -0.08283012f, -0.14174414f, -0.09965672f, -0.01815582f, -0.01875408f, 0.16221805f, 0.09193877f, 0.04375611f, 
    0.15049890f, -0.04121321f, -0.05484863f, -0.01045230f, 0.05347110f, 0.18725404f, -0.16530700f, -0.02716807f, 
    -0.02444902f, 0.12909296f, 0.07977387f, 0.02079418f, -0.09587384f, -0.00902589f, -0.02252928f, 0.04012053f, 
    0.01965003f, -0.13564932f, -0.17474930f, -0.09045883f, 0.04642377f, -0.04098626f, 0.04532099f, 0.06112794f, 
    0.21500410f, -0.02025636f, -0.12007333f, 0.04083022f, 0.22505766f, 0.15654020f, 0.11365593f, -0.01414171f, 
    -0.03814159f, 0.05236942f, -0.07773885f, -0.03614758f, 0.15448736f, -0.09507518f, -0.01460005f, -0.07399832f, 
    0.44208670f, 0.05310418f, 0.17488250f, 0.06891824f, 0.11070456f, 0.02063920f, 0.15757582f, 0.06077784f, 
    0.00278438f, -0.02074948f, -0.00667614f, -0.02269831f, 0.28747505f, 0.08534455f, 0.29671177f, -0.05145159f, 
    0.14280663f, 0.02726354f, -0.09569237f, -0.03691883f, -0.02177760f, -0.03904568f, -0.09039165f, 0.06156758f, 
    -0.09142356f, -0.14548275f, -0.38866645f, -0.01606055f, 0.03505226f, 0.10610540f, 0.00742930f, -0.10813054f, 
    0.01685183f, 0.07053334f, 0.01647322f, 0.02311653f, 0.18083143f, 0.18972872f, 0.21096838f, -0.01849421f, 
    0.21371919f, -0.01278401f, -0.07640419f, 0.20362145f, -0.05139872f, -0.04567525f, -0.12024704f, 0.10449661f, 
    0.23906134f, 0.24053812f, 0.35656160f, 0.01782556f, 0.13862820f, 0.20108590f, 0.15884535f, 0.04962066f, 
    0.00930095f, -0.01601165f, 0.13830538f, -0.04286063f, 0.23718807f, 0.12071857f, 0.10538886f, 0.03084006f, 
    0.19017340f, 0.09323987f, -0.04597538f, 0.19990905f, -0.12070608f, -0.01960910f, 0.12486877f, 0.00212258f, 
    -0.00090588f, 0.09416006f, -0.10717782f, 0.09426947f, -0.01372893f, -0.01114574f, 0.01916523f, 0.03480628f, 
    0.01760319f, -0.07293497f, 0.05480714f, 0.03068957f, 0.20227514f, 0.09346522f, 0.12429650f, 0.10156114f, 
    0.08896238f, 0.09239700f, 0.03706188f, 0.03592369f, 0.09315711f, 0.00233859f, -0.10474013f, 0.01722563f, 
    -0.33115494f, -0.32554987f, -0.14399755f, 0.04487534f, 0.06580409f, 0.06579761f, 0.07324199f, -0.09081995f, 
    0.11336365f, 0.06520060f, 0.07160109f, 0.00846374f, -0.25101388f, -0.05535692f, 0.32923576f, -0.10091167f, 
    -0.03896095f, -0.03892209f, -0.02013974f, 0.13533291f, 0.11021856f, -0.05668599f, -0.09250430f, -0.01682463f, 
    0.00601641f, 0.03850113f, 0.09307160f, 0.09319838f, -0.09015553f, 0.05051263f, -0.00446877f, 0.05777065f, 
    0.03817242f, -0.08386198f, 0.01811450f, -0.00256121f, -0.04002291f, -0.12673105f, 0.00867980f, -0.04282539f, 
    -0.06265102f, -0.06570161f, 0.00196470f, -0.08026985f, 0.13764672f, 0.07158715f, -0.07460318f, 0.10244051f, 
    0.15568791f, 0.28788239f, 0.11437377f, -0.00969341f, 0.03533230f, 0.14831917f, 0.08294661f, 0.06870723f, 
    0.03241041f, 0.03581962f, -0.04825068f, -0.00499565f, 0.13944383f, 0.11902878f, -0.47314331f, 0.08538476f, 
    -0.09047841f, -0.15375783f, 0.20916447f, 0.01992971f, 0.02420733f, -0.14765224f, -0.27127689f, 0.00289520f, 
    0.00117101f, 0.10359479f, -0.10107677f, 0.03391366f, 0.09194475f, -0.00978395f, -0.05707105f, 0.07794706f, 
    -0.00093882f, -0.10381035f, -0.12876527f, -0.26880023f, -0.33875051f, -0.16367185f, 0.07548390f, -0.05437397f, 
    0.11720508f, -0.17373210f, 0.06175887f, 0.23447315f, 0.12701294f, -0.03286278f, -0.09510960f, 0.03469799f, 
    -0.49144083f, 0.27472132f, 0.03910394f, -0.16309364f, 0.02271429f, -0.02156754f, 0.18320991f, 0.19137096f, 
    -0.04595700f, 0.02667212f, -0.05813077f, -0.13712406f, 0.00766210f, 0.25234967f, 0.25487188f, -0.02791848f, 
    0.02394471f, 0.09712933f, 0.07619655f, -0.00421101f, 0.12495245f, -0.08776157f, -0.14874683f, 0.07104833f, 
    -0.30639496f, -0.01046170f, 0.03888634f, -0.06448676f, -0.00778786f, 0.02236369f, -0.04402055f, 0.00193427f, 
    -0.02147609f, -0.10571744f, 0.05339750f, -0.11426818f, 0.20273569f, 0.14907607f, 0.27500504f, -0.19110720f, 
    -0.10796161f, 0.06561271f, 0.08252357f, 0.32379258f, 0.08347004f, 0.10871606f, -0.00544934f, 0.10616916f, 
    -0.13222311f, -0.09796312f, -0.07553315f, -0.07145151f, -0.06843384f, -0.06534042f, -0.00094160f, 0.00659218f, 
    0.03702082f, 0.00250422f, 0.11632957f, 0.09191592f, 0.18254359f, 0.27145112f, 0.26034930f, 0.18251447f, 
    0.06337187f, 0.19068511f, 0.16933762f, 0.34329414f, 0.21456124f, 0.05146379f, 0.07776812f, 0.19801882f, 
    0.38044226f, 0.06312503f, 0.16151200f, 0.18439859f, 0.10386424f, 0.05316591f, 0.04339596f, 0.20540091f, 
    0.02201608f, 0.05688578f, 0.05581161f, 0.11394621f, 0.18118934f, 0.24323680f, 0.19606934f, 0.09052915f, 
    0.08438158f, 0.07936301f, 0.11520328f, 0.10983495f, -0.05570856f, -0.07227049f, -0.15271868f, 0.01390973f, 
    0.16387291f, 0.13297452f, -0.07610534f, 0.15205081f, -0.11911689f, 0.05226407f, -0.10336954f, 0.05230433f, 
    -0.07218423f, -0.04284745f, 0.04117573f, 0.01114774f, -0.07235602f, 0.21837345f, 0.07436424f, -0.13898444f, 
    -0.06650544f, 0.03312017f, 0.21612008f, 0.08413869f, 0.02307841f, -0.05157565f, -0.04091475f, 0.11844365f, 
    -0.14671504f, -0.03738664f, -0.03271498f, -0.18589211f, 0.17853251f, 0.06739927f, -0.03651608f, 0.04580550f, 
    0.10177839f, 0.29443714f, 0.17310019f, 0.36468202f, -0.21026997f, -0.15896820f, -0.15209083f, -0.11310325f, 
    0.00594010f, -0.11965059f, -0.05887726f, -0.16516353f, 0.07173887f, -0.31466094f, -0.15645902f, -0.27307957f, 
    0.02616439f, 0.12473335f, -0.09224878f, -0.19330241f, -0.02183113f, -0.06194444f, 0.05325196f, -0.06695098f, 
    -0.03052766f, -0.08622002f, 0.10326117f, -0.06193753f, 0.06206720f, -0.23383567f, 0.01641379f, -0.08084562f, 
    0.05506180f, -0.01913222f, -0.06361890f, 0.14262544f, -0.01206076f, -0.15931779f, 0.01262767f, 0.04405545f, 
    -0.05668609f, -0.24987368f, -0.09859782f, 0.02329656f, -0.05946230f, 0.00101601f, -0.05097646f, 0.05171807f, 
    0.20966935f, 0.05320344f, 0.09549659f, 0.18005012f, -0.24509609f, -0.10599536f, -0.23385036f, -0.01506909f, 
    -0.14542864f, -0.09108447f, 0.03708996f, -0.04678946f, 0.05288425f, -0.28080299f, -0.23805816f, -0.16182324f, 
    0.08635262f, 0.04930066f, 0.15237503f, 0.04134004f, 0.05991253f, 0.00516690f, -0.04521684f, 0.11354944f, 
    0.20503399f, 0.08354306f, -0.14390263f, -0.07317994f, -0.08226711f, 0.00499685f, 0.04854462f, 0.22496574f, 
    -0.15547889f, -0.09680443f, -0.12111182f, 0.01327020f, 0.19573398f, 0.07138682f, 0.07495704f, 0.02731405f, 
    -0.03637041f, 0.04024765f, -0.03009054f, 0.13450894f, 0.00854574f, -0.05908803f, -0.08100574f, 0.02720310f, 
    0.03274610f, 0.00653747f, -0.04414725f, -0.00396118f, 0.11478160f, 0.31145236f, 0.00155747f, -0.04748646f, 
    -0.03630861f, 0.03526203f, 0.03156643f, -0.02041807f, -0.15438218f, -0.17226782f, -0.02567591f, -0.10218334f, 
    0.07373311f, -0.04935985f, -0.15331817f, -0.12236940f, 0.03144991f, 0.11157838f, 0.09289534f, 0.06372221f, 
    -0.03520268f, -0.14629097f, -0.06269381f, -0.24681006f, -0.21890621f, 0.03055704f, 0.13810337f, 0.06915604f, 
    0.10911433f, -0.04721950f, 0.02560205f, 0.08757238f, 0.09869646f, -0.17251454f, -0.14117469f, -0.41983682f, 
    0.12063773f, -0.29976651f, 0.19681385f, -0.00214568f, 0.14121595f, -0.00722568f, -0.07561291f, -0.03878696f, 
    -0.09991505f, -0.31083944f, -0.16520512f, -0.34271756f, 0.17706597f, 0.22048633f, 0.12169410f, -0.04220319f, 
    0.08025422f, 0.10310110f, -0.01989758f, 0.04495257f, -0.02641967f, 0.02163262f, 0.09203656f, 0.05266203f, 
    -0.09450916f, -0.29392740f, 0.02224789f, -0.07426864f, -0.11202962f, 0.14962752f, 0.12664004f, 0.19778603f, 
    -0.17536651f, 0.06440748f, 0.14768423f, 0.17547582f, -0.07584401f, -0.32114807f, -0.26368603f, 0.10647520f, 
    -0.14407076f, -0.04907712f, -0.08324642f, -0.03878135f, 0.22998975f, 0.03295585f, 0.18757309f, 0.17559952f, 
    -0.22635911f, 0.04543567f, -0.24882141f, -0.02989900f, -0.07796737f, -0.09431437f, 0.02708905f, 0.02131820f, 
    -0.24802816f, -0.04372231f, -0.15114410f, -0.18183243f, 0.14638054f, -0.27803019f, 0.10113922f, -0.04402161f, 
    -0.06474525f, 0.16211037f, 0.18300229f, 0.11830574f, 0.08572574f, 0.07288661f, 0.06093416f, 0.04501471f, 
    -0.17467783f, -0.12995973f, -0.09385198f, -0.12519276f, 0.01626218f, -0.06219861f, -0.08031663f, 0.01095207f, 
    0.03896518f, 0.11518806f, 0.10442896f, -0.00601758f, -0.07323494f, 0.05947569f, -0.14729685f, 0.12348755f, 
    0.03516203f, 0.02043152f, -0.10558417f, -0.03137208f, -0.05497312f, -0.05109747f, 0.01948457f, 0.08074102f, 
    -0.13338861f, 0.23323426f, 0.05769402f, -0.08511556f, -0.03126265f, -0.00172142f, 0.19135596f, -0.03969800f, 
    -0.13058347f, -0.09361525f, -0.02758095f, -0.06143795f, 0.32582074f, 0.06242272f, 0.02285767f, -0.02447045f, 
    -0.05415854f, 0.11955173f, 0.14773481f, 0.10595112f, -0.01428081f, -0.09171545f, -0.01751952f, 0.01932668f, 
    -0.23258555f, -0.06918103f, -0.02026629f, -0.16468254f, -0.08388481f, 0.00969032f, -0.11443408f, -0.09285706f, 
    0.01743273f, 0.00524862f, 0.12077110f, -0.07644884f, -0.05285010f, -0.04542631f, -0.18718816f, -0.03950740f, 
    -0.07969510f, 0.04354165f, 0.03113891f, -0.03805837f, 0.10254579f, 0.06042477f, 0.00848969f, 0.28678167f, 
    -0.20042305f, 0.15280968f, 0.07096458f, -0.03785330f, -0.08395329f, 0.14733407f, 0.12999511f, 0.04119168f, 
    0.12541397f, 0.22227499f, 0.09670074f, -0.06510601f, -0.02943550f, -0.17224544f, -0.11332271f, -0.17804182f, 
    -0.03320547f, -0.11634418f, 0.00583725f, 0.03055543f, -0.15595025f, -0.22925517f, -0.21154620f, -0.23588750f, 
    0.17573878f, -0.03052139f, -0.06863397f, 0.12333253f, -0.10112251f, -0.03900957f, -0.02635216f, -0.10076530f, 
    0.19960214f, -0.03813210f, 0.07635538f, 0.06896955f, -0.05577733f, -0.06640851f, -0.08992178f, -0.15719183f, 
    0.06210306f, 0.09244813f, 0.00139072f, 0.08502901f, 0.16492182f, 0.11326302f, 0.11244580f, 0.10647411f, 
    0.17116588f, 0.02989273f, 0.09397543f, -0.12727605f, 0.06167684f, 0.02052620f, -0.03199206f, 0.14335145f, 
    0.21820875f, 0.06522729f, 0.02315201f, 0.02069344f, 0.01502212f, -0.06494600f, -0.00738704f, 0.04379036f, 
    0.13334505f, -0.03849377f, 0.07992719f, 0.09674214f, 0.16629721f, 0.00318178f, -0.14868024f, 0.02328735f, 
    -0.08252204f, -0.02057390f, -0.15706137f, 0.00889446f, 0.06829125f, 0.06534981f, -0.10734896f, 0.10118400f, 
    -0.03479705f, 0.01708908f, 0.06029640f, 0.03957378f, -0.15974063f, -0.15664677f, -0.14004664f, -0.09265976f, 
    0.18135296f, 0.00255646f, 0.03167132f, -0.00234371f, 0.00106754f, 0.09874982f, 0.08730118f, 0.12014361f, 
    0.07127076f, -0.10639286f, -0.08091051f, 0.03810247f, 0.11445913f, -0.09104324f, -0.05640567f, 0.01060909f, 
    -0.02162665f, 0.09651723f, 0.02964746f, 0.04198024f, -0.15021709f, -0.02821862f, -0.21948513f, -0.12071907f, 
    -0.00936471f, -0.07255059f, -0.04674368f, 0.00616426f, 0.00697679f, -0.12076651f, -0.03363414f, -0.12857933f, 
    0.02646551f, 0.02447186f, -0.05127735f, -0.01012609f, -0.00476695f, 0.02780396f, -0.01231977f, 0.02286412f, 
    0.18940681f, 0.12312703f, 0.07202350f, 0.07897042f, -0.03005278f, 0.39677823f, 0.08953939f, -0.00727839f, 
    0.02265157f, -0.01280672f, 0.05650568f, 0.18136413f, -0.07461093f, -0.01111174f, -0.05081491f, 0.09026314f, 
    -0.15683360f, 0.07710097f, -0.19580609f, -0.18911485f, -0.09725014f, 0.04623689f, -0.07816326f, -0.06259084f, 
    0.22545633f, 0.01624695f, -0.03978720f, 0.12116026f, 0.09597621f, 0.12183625f, 0.04264668f, 0.08587038f, 
    -0.17600749f, 0.26226678f, 0.10948814f, 0.18250473f, 0.01305911f, -0.00467749f, 0.14130659f, 0.04346093f, 
    0.25128171f, 0.20463711f, 0.10060575f, -0.19350982f, -0.17272776f, 0.16276968f, 0.08514728f, -0.05754992f, 
    0.02777432f, 0.12013253f, 0.02236374f, 0.02976575f, 0.27769303f, 0.05345462f, 0.13028367f, -0.14654030f, 
    0.17318746f, 0.04245528f, 0.06662270f, -0.02587796f, 0.03280149f, -0.00233540f, -0.07279973f, -0.15682082f, 
    -0.04670998f, -0.13309731f, -0.11729641f, -0.09445634f, 0.24202707f, -0.06774587f, -0.02772049f, 0.04488526f, 
    0.05067101f, 0.09229986f, 0.15990615f, 0.13380480f, 0.02912797f, 0.02219016f, 0.04445911f, -0.02741317f, 
    0.03705259f, 0.15198620f, 0.04861860f, 0.10959440f, -0.17535566f, -0.22431709f, -0.20922959f, -0.16871123f, 
    0.18106131f, 0.15783630f, 0.24928635f, 0.04342225f, -0.07828575f, 0.02741998f, -0.00715711f, -0.02072288f, 
    0.03616042f, -0.06831523f, 0.05068291f, 0.02775159f, 0.29088673f, 0.19488232f, 0.14099325f, 0.04744786f, 
    0.05710377f, 0.01009274f, -0.07767618f, -0.04239305f, -0.19739760f, -0.17793062f, 0.02913053f, -0.05853982f, 
    -0.21637484f, -0.03185530f, 0.05647313f, 0.07232945f, 0.16424018f, -0.03074133f, -0.13019514f, 0.10371327f, 
    -0.17504011f, -0.06006541f, 0.04970986f, -0.21449335f, 0.18585861f, 0.09088515f, 0.30187714f, 0.02735715f, 
    -0.08849907f, -0.06864937f, 0.02607078f, -0.01813818f, 0.10659755f, 0.02554454f, -0.15527639f, -0.09920792f, 
    -0.12843563f, -0.06735131f, -0.09382360f, -0.12040146f, -0.11892136f, -0.12111223f, -0.09732525f, -0.02843687f, 
    0.00481035f, 0.09875472f, 0.05311228f, 0.03026306f, -0.09146122f, -0.15410160f, 0.04070724f, 0.14179838f, 
    0.03264402f, 0.05560130f, 0.09560453f, 0.22159585f, 0.09514926f, -0.03315905f, 0.02089383f, 0.15647009f, 
    0.02774063f, 0.18893245f, -0.02920680f, 0.03519365f, 0.01974859f, -0.03679148f, 0.06584856f, 0.01557628f, 
    0.17442015f, 0.07243530f, 0.09557021f, 0.23311388f, -0.16602448f, -0.15077448f, 0.05460095f, 0.00786712f, 
    -0.05433557f, 0.02217404f, 0.17351526f, 0.06092437f, 0.30578417f, 0.25000453f, 0.08932354f, 0.22252601f, 
    0.08670883f, 0.17892528f, 0.09840249f, 0.03223223f, -0.02599386f, 0.17197713f, 0.16605905f, 0.11720216f, 
    0.00389267f, 0.09222650f, 0.01639624f, 0.02311642f, -0.30320013f, 0.02067819f, -0.00087770f, 0.08015212f, 
    0.01901256f, -0.05392181f, 0.24207999f, 0.18760197f, -0.02095565f, 0.10590900f, -0.09588919f, 0.14408384f, 
    0.01533669f, 0.00196103f, -0.02580587f, -0.01366766f, -0.01155648f, -0.01034177f, 0.00377031f, 0.01510875f, 
    -0.03899220f, -0.02337712f, -0.02374323f, -0.03962016f, 0.00241724f, -0.00692961f, 0.01086738f, -0.03614999f, 
    -0.03468084f, 0.01246694f, -0.03014623f, 0.00342044f, -0.03743312f, 0.00699635f, -0.00477583f, 0.01940219f, 
    0.02685821f, -0.02421948f, 0.02744606f, -0.03637708f, 0.00620658f, 0.00875266f, -0.02700474f, 0.02983124f, 
    0.00729056f, -0.01356127f, 0.00432874f, 0.01819243f, -0.01012621f, 0.01848682f, 0.00929765f, 0.02043273f, 
    -0.02728884f, 0.00574147f, -0.03474637f, 0.03215928f, -0.01996651f, 0.00074294f, 0.01792950f, 0.02428717f, 
    0.00645366f, 0.00789980f, -0.02343511f, -0.02805891f, 0.00520520f, 0.00504249f, -0.01267735f, -0.01025189f, 
    0.02143228f, -0.00715165f, 0.01945280f, -0.01500886f, -0.03547648f, -0.02264246f, 0.01080281f, -0.02669267f, 
    -0.00916410f, 0.01943854f, 0.01680447f, -0.01431324f, 0.00180876f, -0.02280344f, -0.00362331f, -0.03868386f, 
    0.02079894f, 0.01117312f, -0.02235722f, 0.03053932f, -0.00522547f, -0.00326659f, -0.01190274f, -0.02507122f, 
    -0.00230469f, 0.01885435f, -0.03187753f, -0.01335061f, 0.01896343f, 0.00543382f, -0.01094567f, -0.01311216f, 
    -0.00307916f, -0.02277415f, 0.02738775f, 0.01923640f, 0.01816967f, -0.02748324f, -0.02231296f, 0.02593532f, 
    -0.02835370f, -0.00705696f, 0.00497792f, -0.01758745f, 0.00521372f, 0.02647137f, -0.01747321f, -0.03404437f, 
    -0.01673133f, 0.00162031f, -0.01964143f, -0.00727125f, -0.03420432f, -0.00250711f, -0.00756753f, -0.03129369f, 
    -0.01659467f, -0.01877503f, -0.03554609f, -0.01872491f, 0.02228599f, 0.02131001f, -0.01868739f, -0.01155433f, 
    0.00646280f, -0.02587031f, 0.03102051f, -0.03739367f, -0.00943427f, 0.01937785f, 0.02618115f, 0.02869059f, 
    0.01168042f, -0.01294747f, 0.01563475f, -0.00742886f, -0.03217246f, -0.00478874f, 0.02744285f, 0.01572207f, 
    -0.02050274f, -0.01281112f, -0.04087331f, 0.02962594f, -0.01506949f, -0.00565062f, -0.00298582f, 0.02550653f, 
    -0.01597289f, -0.00773692f, 0.01158810f, 0.02909739f, -0.02550048f, -0.04146025f, 0.02767318f, -0.00145514f, 
    0.01757373f, 0.02667709f, -0.00935598f, -0.03839945f, -0.03360574f, 0.00941955f, -0.01400162f, -0.01440463f, 
    -0.02365063f, -0.02511627f, 0.01637170f, 0.02758501f, -0.02004614f, 0.03479814f, -0.02445207f, 0.03008537f, 
    -0.02243166f, -0.02326945f, -0.00932411f, -0.00309313f, -0.00444588f, 0.01087684f, -0.01338363f, 0.00255492f, 
    -0.03136077f, -0.00328001f, -0.03716405f, -0.03915506f, -0.03164749f, 0.00382126f, -0.00804040f, -0.00945372f, 
    -0.00846756f, 0.02552725f, -0.02884575f, -0.03523387f, -0.01565823f, 0.00552836f, -0.03963712f, -0.03391578f, 
    -0.03774492f, -0.01526246f, 0.01529525f, 0.03048678f, 0.00880379f, -0.01154581f, -0.01924524f, 0.02066381f, 
    -0.03855175f, 0.02448390f, 0.02220848f, -0.01484116f, 0.02861548f, 0.00261054f, -0.02510465f, -0.03455192f, 
    -0.03785900f, 0.01930145f, 0.00162514f, 0.00323494f, -0.03018930f, -0.02182998f, -0.02831911f, 0.01603916f, 
    -0.03587304f, 0.00524859f, -0.04081170f, 0.02601862f, -0.03619331f, -0.03997919f, -0.03372803f, 0.02489037f, 
    -0.00013842f, 0.01372824f, -0.00919390f, 0.01193747f, 0.02367632f, 0.02341568f, -0.00770538f, 0.00108789f, 
    0.03128732f, -0.03737873f, 0.00517338f, -0.03028500f, 0.01204367f, -0.02618904f, -0.02151485f, -0.00496148f, 
    0.02361180f, 0.01119295f, 0.01403851f, 0.02820607f, -0.03482385f, 0.00319205f, 0.00963845f, -0.03907873f, 
    -0.03666082f, -0.03903484f, 0.01448126f, 0.02998738f, -0.03728051f, -0.00332208f, -0.04029684f, -0.02439914f, 
    0.02685125f, -0.02173185f, 0.01397224f, 0.00601290f, -0.03255498f, 0.00601781f, 0.00307168f, -0.02196816f, 
    0.00194829f, 0.01361691f, -0.01863201f, -0.02282749f, 0.01095477f, -0.03406417f, 0.03959762f, 0.00116052f, 
    0.01246084f, -0.00222122f, 0.01272510f, 0.01876851f, -0.02178233f, -0.03704091f, 0.02263448f, 0.01572951f, 
    0.01312608f, 0.01171057f, -0.03236218f, -0.03593246f, 0.00918878f, -0.03117224f, -0.02933076f, -0.02433481f, 
    -0.01217020f, 0.02707478f, -0.03935748f, -0.04195476f, 0.01625669f, 0.00593881f, -0.01558628f, 0.02674324f, 
    -0.01060704f, 0.00245143f, -0.02343681f, 0.02332645f, 0.02020494f, -0.03331953f, -0.04182269f, 0.00761819f, 
    0.01284486f, -0.02981116f, 0.00416428f, -0.02765421f, -0.01837434f, -0.01282768f, -0.03496628f, 0.01292694f, 
    0.02535973f, -0.03470587f, -0.03937355f, 0.01889252f, -0.01332519f, -0.02232319f, 0.00523555f, -0.00090787f, 
    0.00603648f, -0.02389850f, -0.01062861f, -0.02618783f, -0.01293178f, -0.01307479f, -0.00961097f, -0.01083433f, 
    -0.02503862f, 0.00766332f, -0.02554673f, -0.01014074f, 0.01752935f, -0.00900206f, 0.00961037f, -0.01495158f, 
    -0.01082120f, -0.00421377f, -0.00787553f, -0.01587191f, -0.00221856f, -0.03368719f, -0.01910309f, -0.01883662f, 
    0.02377218f, -0.00430458f, -0.03568065f, 0.01004651f, 0.00104932f, -0.00974114f, -0.03658954f, -0.02045788f, 
    -0.02147805f, 0.00589853f, -0.00044354f, -0.02809759f, 0.01381619f, 0.01132783f, -0.00253430f, -0.03239693f, 
    0.02025160f, 0.00174999f, 0.02192467f, -0.00172191f, -0.02493232f, 0.01637003f, -0.03424526f, -0.02914952f, 
    -0.02443775f, 0.02907773f, -0.03824298f, 0.01969000f, 0.00422998f, -0.00664225f, 0.00576338f, 0.01166493f, 
    0.00093402f, -0.00763395f, -0.00488210f, 0.02557489f, 0.00054226f, -0.01172002f, 0.00200114f, -0.02753723f, 
    0.02158196f, 0.02765367f, 0.02277366f, 0.01302142f, -0.00103523f, -0.02964804f, 0.01436306f, -0.02735422f, 
    -0.03215043f, -0.03728502f, 0.01913809f, -0.02588132f, -0.01760343f, -0.03098862f, 0.02043802f, -0.00628375f, 
    -0.03053914f, 0.02739596f, 0.01214498f, 0.02500604f, -0.00988068f, 0.02870775f, -0.02781613f, 0.00240256f, 
    0.01424231f, 0.03600003f, 0.02577889f, -0.01702519f, 0.03242398f, -0.02349038f, -0.04231307f, -0.01173025f, 
    0.02756785f, -0.02212425f, 0.02283696f, -0.01027064f, 0.01876957f, -0.02671780f, 0.03277318f, 0.02000878f, 
    -0.01936870f, -0.02790099f, 0.02609313f, -0.00405730f, 0.00094476f, 0.02826483f, -0.03265210f, -0.01874529f, 
    0.01074400f, -0.01962648f, -0.04123837f, 0.00542502f, -0.02250548f, 0.02182724f, 0.01546170f, -0.03631241f, 
    -0.02581799f, -0.01629634f, -0.03107657f, -0.01159859f, 0.00968861f, 0.02368923f, 0.00773673f, -0.00391497f, 
    0.00375740f, 0.02426182f, 0.00290543f, 0.01485664f, 0.01570473f, -0.02121369f, 0.02158369f, -0.02434086f, 
    0.02530138f, -0.01379003f, 0.03196276f, -0.00429809f, 0.00094586f, 0.01394849f, -0.01917441f, -0.02401426f, 
    -0.00364590f, -0.01731665f, 0.00309833f, 0.02953921f, 0.03014394f, -0.02940235f, -0.02811964f, -0.00416600f, 
    -0.02124194f, -0.01055726f, 0.00419453f, -0.02040468f, 0.00540848f, 0.02142926f, -0.01441552f, 0.01975334f, 
    -0.01803540f, -0.02062009f, -0.00570534f, -0.01319009f, -0.03404246f, -0.03055819f, 0.01881839f, -0.03891983f, 
    -0.01539702f, 0.00165363f, -0.03778853f, 0.00405988f, -0.02845752f, -0.01802360f, 0.00206405f, -0.03468161f, 
    0.02395121f, 0.01370688f, -0.01651751f, -0.03641156f, -0.00836792f, -0.01598610f, 0.01309554f, 0.00360187f, 
    -0.02473479f, -0.01020633f, 0.02878232f, 0.02485723f, -0.03505185f, -0.00879859f, -0.02422239f, 0.01393287f, 
    0.02392439f, 0.02433936f, -0.01347949f, 0.00156342f, -0.00887393f, -0.02394958f, 0.01045476f, -0.03109203f, 
    -0.00545755f, -0.03780216f, 0.00914845f, 0.00726154f, 0.02700821f, -0.00341506f, -0.00225215f, -0.01890359f, 
    -0.02248799f, -0.01913917f, -0.02281107f, 0.00115120f, 0.00962108f, 0.00882904f, 0.02700572f, -0.03825942f, 
    0.00523685f, 0.02914052f, -0.02886071f, -0.02327879f, 0.02938062f, 0.02551406f, -0.00711391f, -0.02681319f, 
    0.01025027f, 0.00002640f, -0.01730311f, -0.01869874f, 0.00612324f, 0.02423586f, -0.00545145f, 0.01148946f, 
    -0.01846672f, -0.00698276f, 0.02966078f, -0.02439085f, -0.00077512f, 0.02327099f, -0.01050344f, 0.02504375f, 
    -0.02275660f, -0.03795305f, -0.03883842f, 0.02304436f, 0.03012288f, 0.03172156f, -0.03801220f, -0.02526536f, 
    0.00916493f, 0.01749464f, 0.01218810f, -0.03058930f, -0.01472996f, -0.00264275f, 0.02747054f, 0.03085520f, 
    0.02194282f, -0.02304280f, -0.02365093f, -0.00956256f, 0.00053443f, -0.01365513f, -0.02350697f, -0.00708670f, 
    -0.01011698f, -0.01675541f, 0.01040271f, -0.01914338f, -0.03444578f, 0.01822711f, 0.00248548f, -0.00067684f, 
    -0.01194360f, -0.02278554f, 0.02059371f, 0.00975666f, 0.00533236f, -0.02069139f, -0.03226726f, 0.00669391f, 
    -0.00179602f, -0.02412682f, 0.02628945f, 0.01452437f, -0.02073994f, 0.02505134f, 0.00719359f, -0.02100644f, 
    0.02224929f, 0.00274116f, -0.01834300f, 0.03043944f, 0.00850738f, 0.01504177f, -0.01699073f, -0.00205981f, 
    -0.03423955f, -0.00029621f, -0.00192060f, 0.01793794f, 0.01943966f, 0.01312887f, -0.02161542f, 0.01330965f, 
    0.01428757f, -0.01418588f, -0.03398528f, -0.04125276f, 0.02620980f, 0.00589804f, -0.01349061f, 0.00501363f, 
    0.02400981f, 0.00275478f, -0.01410566f, -0.00329206f, -0.02695956f, -0.02316224f, -0.01628734f, 0.01999865f, 
    0.03290483f, 0.02058037f, -0.03620584f, -0.01775976f, -0.02076662f, 0.01226652f, -0.03589316f, -0.02690450f, 
    -0.02985660f, -0.00501714f, -0.01671601f, -0.03968978f, -0.03676449f, -0.00926623f, -0.03759591f, 0.00635232f, 
    -0.04215264f, -0.00754078f, 0.00382731f, -0.00415428f, 0.00218820f, -0.04035116f, -0.01026045f, -0.00870071f, 
    0.00715209f, 0.01985388f, -0.02399161f, 0.03058573f, 0.02435547f, -0.01753962f, -0.00599054f, 0.01511853f, 
    -0.01278847f, 0.02924359f, -0.00268604f, 0.02558736f, -0.02201647f, 0.00660371f, 0.01127769f, -0.03472987f, 
    0.02419327f, -0.00808565f, -0.01807608f, -0.02436318f, -0.02216705f, -0.00182137f, -0.01253778f, 0.00945617f, 
    -0.02624841f, -0.01689820f, -0.00742519f, -0.00876305f, 0.01608526f, -0.00134874f, 0.00812943f, 0.02278861f, 
    0.02251133f, -0.04008895f, -0.01845775f, -0.01078954f, 0.00058339f, 0.00465487f, -0.00556546f, 0.00692764f, 
    -0.02970354f, -0.01976593f, -0.00912776f, 0.00307719f, -0.01760504f, -0.03854821f, 0.02734388f, 0.00768348f, 
    0.02125931f, -0.03236958f, 0.01447051f, 0.00719661f, -0.00871992f, 0.00340141f, 0.03079013f, -0.01877441f, 
    -0.00432630f, -0.00582181f, 0.01430510f, -0.02533579f, -0.02454710f, -0.00903773f, -0.02810004f, -0.01394014f, 
    0.01379596f, 0.01606482f, -0.00211259f, 0.00754750f, -0.01631399f, -0.03361294f, -0.01877552f, 0.02468733f, 
    0.02668690f, 0.03055307f, -0.03363356f, -0.03893777f, -0.02430807f, -0.00988870f, -0.00284524f, -0.03591232f, 
    0.03164619f, -0.01684089f, 0.01956555f, 0.00429742f, 0.01280558f, 0.02425433f, -0.01829190f, 0.01353741f, 
    -0.03403553f, -0.03152345f, 0.01140513f, -0.00347499f, -0.02276877f, -0.01012393f, -0.00195034f, -0.03109137f, 
    -0.00225219f, 0.02422184f, -0.02898021f, -0.01296580f, 0.01631828f, 0.00346071f, 0.02824653f, -0.00019982f, 
    0.01834478f, 0.01010263f, 0.00557382f, 0.00026235f, -0.03220347f, 0.00794183f, -0.02840012f, 0.01559989f, 
    0.01502648f, 0.00554860f, -0.00607130f, -0.02681225f, 0.02500065f, -0.03529771f, -0.02826660f, -0.02470489f, 
    -0.00403459f, 0.01032028f, 0.00535742f, 0.00108864f, -0.03048414f, -0.00172278f, -0.03507811f, -0.00892058f, 
    -0.00285524f, 0.01160613f, -0.02928837f, 0.03016970f, 0.01390087f, -0.04055819f, 0.02542920f, -0.03217622f, 
    -0.03579865f, -0.01699900f, -0.02479931f, 0.00854405f, 0.02789500f, -0.03407426f, -0.00736993f, 0.02543073f, 
    -0.03018242f, 0.00571644f, 0.00822480f, 0.00059866f, 0.02636287f, 0.01072746f, -0.02477776f, 0.00202158f, 
    -0.01511552f, -0.02566846f, 0.00013145f, -0.00091271f, -0.02929667f, 0.02466089f, 0.02279901f, 0.01940026f, 
    -0.02332692f, -0.00444817f, 0.00583888f, 0.00799855f, -0.01561486f, -0.03457038f, 0.00393504f, -0.03351287f, 
    -0.01824037f, -0.02517390f, -0.02627324f, 0.03115183f, -0.01376255f, 0.02013377f, 0.00759530f, 0.00375152f, 
    -0.04144547f, -0.00416334f, -0.01467420f, -0.04503004f, 0.01817626f, 0.02435895f, -0.02811042f, 0.00119391f, 
    0.03251512f, 0.01879154f, 0.00334929f, -0.02511252f, -0.00730541f, -0.03938221f, -0.02215594f, -0.00648326f, 
    0.01251523f, 0.00294549f, -0.01899256f, -0.00717782f, -0.01358725f, 0.02280636f, -0.03221196f, -0.00651681f, 
    0.02868916f, -0.02495061f, -0.00247723f, -0.03483783f, -0.03450492f, -0.02500345f, -0.00139498f, 0.00001623f, 
    -0.02019489f, -0.02575029f, -0.01577385f, -0.01500648f, -0.04096036f, 0.01182710f, 0.00923788f, -0.02219216f, 
    0.00821272f, -0.03612713f, -0.02184367f, 0.01940011f, -0.00327092f, 0.00345026f, -0.02866750f, 0.01292219f, 
    -0.01820006f, 0.01482113f, 0.00674853f, -0.01854777f, 0.02567737f, -0.01903260f, 0.02469528f, -0.00626966f, 
    0.00141113f, -0.03921540f, 0.00632829f, -0.03895821f, 0.00605339f, 0.01879173f, 0.03057388f, 0.00943943f, 
    0.01104440f, -0.02132734f, -0.00371269f, 0.00680268f, -0.00300633f, -0.00258975f, -0.00841038f, -0.01378295f, 
    -0.01364415f, 0.02476950f, -0.03204657f, 0.00915755f, 0.01454209f, 0.02096484f, -0.00157731f, -0.00629238f, 
    -0.04121458f, -0.00663707f, -0.02963367f, 0.00512790f, 0.01392880f, -0.00107724f, -0.04399338f, -0.02101574f, 
    0.01749180f, -0.02767698f, 0.00491474f, -0.03549902f, 0.01641853f, 0.01509494f, 0.02177852f, -0.03220511f, 
    -0.02662290f, -0.03113497f, 0.00503909f, 0.00175825f, 0.00679233f, 0.00508057f, -0.01600911f, 0.00979632f, 
    0.00712795f, -0.00030306f, -0.02248155f, -0.01386197f, 0.01532176f, -0.04188446f, 0.00106924f, -0.03659115f, 
    -0.03452294f, -0.00627562f, -0.04094174f, 0.02809269f, 0.01003018f, 0.02030598f, 0.00785554f, 0.00408385f, 
    -0.01552402f, -0.01820157f, 0.00544232f, 0.01665465f, 0.02371537f, -0.00410790f, -0.02302590f, 0.00947359f, 
    -0.01370571f, -0.03947740f, -0.03498409f, -0.02831586f, 0.01177599f, -0.02032414f, -0.03558762f, 0.01605139f, 
    -0.00657219f, 0.01827280f, 0.00246571f, -0.02942613f, 0.02462137f, 0.01811110f, -0.02364306f, -0.02071030f, 
    -0.03087803f, 0.00298035f, 0.02790065f, 0.02359888f, -0.03656511f, 0.00970656f, -0.02941334f, 0.00222653f, 
    0.02247819f, 0.01228412f, 0.01886325f, -0.03068817f, -0.00329306f, 0.00046192f, 0.00034010f, 0.00852967f, 
    -0.02914156f, 0.03099357f, -0.01528511f, 0.03003378f, -0.01130325f, -0.01306176f, 0.02450500f, -0.02656779f, 
    -0.00116289f, -0.03763543f, -0.00464615f, -0.03483547f, -0.00167135f, -0.04067047f, -0.01687454f, 0.02054308f, 
    -0.01576862f, 0.03030157f, -0.03615601f, -0.01053760f, 0.00598740f, -0.00656176f, -0.00650158f, -0.00144842f, 
    0.01525444f, -0.00627851f, -0.02786221f, 0.01942097f, 0.02356340f, -0.03238839f, 0.02271280f, -0.03410563f, 
    0.01366111f, -0.03211319f, -0.02337430f, 0.01882848f, 0.01210718f, 0.01650961f, -0.01130514f, 0.02057080f, 
    -0.00633557f, -0.02178803f, -0.00680527f, 0.02857465f, 0.00872179f, -0.01600293f, 0.02026311f, -0.01126056f, 
    -0.02875017f, -0.00300536f, -0.03491231f, 0.00495704f, 0.01648744f, -0.02657416f, 0.01697613f, 0.02510139f, 
    -0.03868030f, -0.02391199f, -0.02199425f, 0.01346463f, 0.00340484f, 0.00397571f, -0.01227830f, 0.00964207f, 
    -0.02857001f, 0.02148666f, 0.00175427f, -0.01892163f, -0.00691149f, -0.02828149f, 0.00656409f, 0.00050126f, 
    -0.04400333f, 0.00320661f, 0.01113402f, 0.03044251f, -0.03889873f, -0.00465148f, 0.02951076f, 0.01604795f, 
    -0.01023459f, -0.01317223f, -0.00856556f, -0.00255626f, 0.02374781f, 0.02810537f, -0.02896293f, -0.01167328f, 
    -0.02145259f, -0.00410067f, -0.03171460f, -0.02694473f, -0.02527870f, 0.01832593f, 0.02441005f, 0.02531976f, 
    -0.00407993f, 0.02506213f, -0.00289586f, -0.03483962f, -0.01993209f, 0.02063351f, 0.00432699f, -0.01079291f, 
    -0.04310756f, -0.01921379f, 0.00929704f, -0.01388006f, 0.03337534f, -0.00997255f, -0.01209577f, 0.01392496f, 
    -0.00694057f, -0.01713662f, 0.01408031f, 0.01688044f, -0.02738896f, 0.00130780f, -0.01141316f, -0.00617784f, 
    -0.02453047f, -0.03139971f, 0.00701237f, 0.00923637f, -0.02134291f, 0.01035585f, -0.00861501f, -0.02082114f, 
    -0.02347778f, 0.01770245f, -0.02646071f, -0.04481356f, -0.00232874f, -0.01447661f, -0.03534042f, -0.04113481f, 
    -0.02216306f, -0.03634907f, 0.01300003f, -0.03488173f, 0.03152441f, 0.00402692f, 0.00893244f, -0.00156702f, 
    -0.01913370f, 0.00756340f, -0.02795081f, -0.00503331f, -0.01824857f, 0.02748964f, 0.00977704f, 0.00909990f, 
    -0.01318633f, -0.01165924f, 0.01092383f, 0.02773923f, -0.01467013f, -0.02046943f, -0.02718831f, 0.01632370f, 
    -0.04559103f, -0.00870823f, 0.02407121f, -0.03346062f, 0.01905378f, -0.01140852f, -0.02229381f, -0.01676096f, 
    -0.02509781f, -0.02968783f, 0.02234885f, -0.03656172f, -0.01260070f, -0.00771820f, 0.00060479f, -0.01208636f, 
    0.02017466f, 0.02489305f, 0.00613366f, 0.00253056f, -0.02843651f, -0.00852777f, -0.01275028f, 0.01531599f, 
    -0.03472543f, -0.03861374f, -0.00546933f, -0.02724263f, 0.02789057f, -0.00590548f, -0.03225866f, -0.01086745f, 
    -0.03351586f, -0.02156164f, 0.00513598f, 0.01873427f, 0.02113913f, 0.00723211f, 0.00739223f, 0.01625598f, 
    0.00583730f, -0.01824218f, 0.01207185f, -0.03391395f, 0.01934014f, 0.00558434f, -0.01119013f, 0.02770445f, 
    -0.03489818f, 0.02322119f, 0.00691344f, 0.02230688f, -0.03716536f, -0.00407055f, -0.00754782f, -0.03390266f, 
    0.00745545f, 0.02270124f, -0.01127569f, -0.03483874f, -0.03066592f, -0.00209740f, -0.00493710f, -0.02077287f, 
    -0.02435037f, -0.02833544f, -0.03142161f, 0.01628366f, -0.00602966f, 0.01509508f, 0.00780379f, -0.02259151f, 
    -0.02350849f, -0.01623557f, -0.03890270f, -0.02524659f, -0.02282592f, -0.00062449f, -0.01504102f, -0.03719080f, 
    0.01422567f, -0.02784485f, -0.02854096f, 0.01021978f, -0.00212111f, 0.00769175f, -0.03175207f, 0.02450364f, 
    -0.00915375f, 0.02426678f, -0.02869631f, -0.00885125f, 0.00496574f, -0.03041773f, 0.02791212f, -0.00750182f, 
    -0.02422178f, -0.00696038f, 0.00474826f, -0.04398881f, -0.00705668f, -0.02798064f, 0.01353468f, -0.02042949f, 
    0.01729003f, 0.00290258f, 0.02864323f, 0.02709055f, 0.01494980f, -0.02535557f, 0.01703187f, -0.02859675f, 
    -0.00708028f, -0.01354672f, -0.02193024f, 0.01214723f, -0.02407612f, 0.01812760f, 0.01164183f, 0.00067645f, 
    -0.03501499f, -0.01857534f, 0.00659795f, 0.01878764f, -0.03945870f, -0.00233402f, -0.00784667f, 0.00295436f, 
    -0.01251364f, -0.03125719f, 0.00506305f, 0.00740636f, 0.01500141f, 0.00586571f, -0.03351011f, 0.03131085f, 
    -0.01374058f, 0.00462389f, 0.00930322f, -0.01031993f, -0.00270316f, -0.02165222f, -0.00701759f, 0.00890371f, 
    -0.02155062f, -0.02566079f, -0.01152616f, -0.03100538f, -0.00889238f, 0.00442562f, 0.00545343f, 0.00835617f, 
    0.01476953f, 0.03013854f, 0.01136625f, -0.02423479f, -0.00182058f, -0.01484186f, -0.02263291f, -0.01703334f, 
    -0.00426941f, -0.00849795f, -0.00643170f, -0.01492300f, -0.00082271f, -0.01357813f, 0.02180663f, -0.01497600f, 
    0.01157363f, -0.02806456f, 0.01466478f, -0.00530107f, -0.02827152f, 0.01136028f, 0.01361638f, -0.00269711f, 
    -0.00346333f, -0.02338599f, 0.01739440f, -0.03595086f, -0.00746095f, -0.02385765f, -0.04004724f, -0.01799329f, 
    0.02118156f, 0.00238041f, -0.00542669f, -0.03808511f, 0.01450144f, -0.00276605f, 0.02598047f, -0.01562029f, 
    0.03425100f, 0.01028774f, -0.03000162f, 0.02459627f, -0.02116181f, 0.03027562f, 0.01485273f, -0.02864951f, 
    -0.01584678f, 0.03137242f, 0.02793059f, -0.02041726f, -0.04001558f, -0.00300225f, -0.03167190f, -0.03251061f, 
    -0.01152242f, 0.00096623f, 0.00662074f, 0.01584536f, 0.01913556f, 0.00917920f, -0.03356296f, -0.00853037f, 
    -0.02884017f, -0.03808982f, 0.03197123f, -0.02647692f, 0.01825901f, -0.04190879f, 0.01808347f, 0.02741352f, 
    -0.00925156f, 0.02131390f, 0.00810469f, 0.00425903f, -0.00456151f, -0.01702056f, -0.01745647f, -0.01907857f, 
    -0.04355464f, -0.03929840f, -0.02559138f, 0.00319780f, -0.00274397f, -0.00920188f, 0.02102072f, -0.02399421f, 
    -0.02402210f, 0.03128847f, -0.04115569f, -0.02491869f, -0.03414920f, 0.02090906f, -0.03226803f, -0.03576563f, 
    -0.00418112f, -0.00559688f, -0.00035073f, 0.01592938f, -0.01655213f, 0.01021748f, 0.02467609f, -0.02272995f, 
    0.01555243f, -0.00220110f, 0.02325898f, -0.02295601f, -0.02830207f, -0.01854440f, -0.02534584f, -0.00418079f, 
    -0.03403571f, -0.01266254f, -0.02856454f, -0.01815773f, 0.01307259f, -0.01905186f, 0.00911946f, -0.00742301f, 
    -0.02287968f, -0.00496821f, -0.02349164f, -0.00801811f, 0.02874395f, -0.03561663f, 0.00616058f, -0.03647758f, 
    -0.03286371f, -0.01402691f, 0.01949734f, -0.02256311f, -0.03606216f, -0.01224958f, 0.01447582f, -0.00426845f, 
    -0.03353712f, -0.04118725f, 0.01249513f, -0.03290076f, 0.03125291f, 0.02990879f, 0.03570120f, -0.03228055f, 
    -0.02931444f, -0.00119177f, 0.00145717f, -0.03518456f, 0.02282397f, 0.00715164f, 0.02009402f, 0.02451240f, 
    -0.00395755f, -0.03329289f, -0.03431975f, -0.02949112f, 0.00742428f, -0.03694475f, -0.01942050f, 0.01927799f, 
    -0.02553299f, 0.00570398f, -0.02879670f, 0.03116308f, 0.00091285f, 0.01301769f, 0.02711317f, -0.01449704f, 
    -0.02555752f, -0.01124168f, -0.02638853f, -0.00789505f, -0.01586113f, -0.03838174f, 0.01963273f, -0.00168195f, 
    -0.01492316f, -0.02382481f, -0.02360189f, -0.01567519f, 0.01707631f, -0.02463127f, -0.03018447f, -0.00006050f, 
    -0.00253011f, -0.02489145f, 0.00336948f, -0.00896905f, -0.02581934f, -0.01397715f, -0.00157776f, 0.03097171f, 
    -0.00848828f, 0.01882704f, 0.02067134f, -0.01913423f, 0.02653589f, -0.02227444f, 0.01585027f, -0.04056251f, 
    0.01619789f, -0.01211248f, -0.00754937f, -0.00505720f, -0.00417573f, 0.02196076f, 0.02973040f, 0.00240159f, 
    0.01064194f, -0.02848778f, 0.01466464f, 0.01203692f, -0.00559164f, -0.01143517f, -0.01413444f, 0.01059502f, 
    -0.02446973f, -0.02789284f, 0.02561438f, -0.00780225f, -0.00324016f, -0.00172189f, -0.03489348f, 0.00727703f, 
    -0.24952070f, 0.11351915f, 0.05833252f, 0.00094807f, -0.05706863f, -0.00681055f, 0.03990120f, 0.05015286f, 
    -0.05052632f, -0.04738687f, -0.06911707f, -0.23922351f, 0.16827165f, 0.11302924f, -0.20830479f, 0.07548050f, 
    0.01537002f, 0.09615374f, -0.25825492f, 0.29272464f, -0.02961998f, -0.04543034f, -0.00574694f, 0.09551929f, 
    -0.15895806f, 0.06814250f, -0.02089838f, 0.25050905f, -0.11415406f, -0.10378201f, -0.15664762f, 0.05497194f, 
    -0.05628350f, -0.03643025f, -0.07441062f, -0.18447407f, 0.17705595f, -0.24112345f, 0.00664236f, 0.38059968f, 
    0.08676781f, 0.06695027f, 0.05472238f, 0.22467740f, -0.05958052f, -0.11473812f, -0.06751058f, -0.08802203f, 
    0.08320188f, -0.07434054f, 0.20096973f, 0.04493525f, 0.04278874f, -0.03266901f, 0.02407158f, -0.11396264f, 
    0.05318896f, 0.06562102f, -0.08836094f, 0.04785555f, -0.21534216f, -0.39556140f, -0.26659662f, 0.02052787f, 
    0.00266513f, -0.15635581f, 0.12023924f, 0.03136826f, -0.03017974f, 0.00328693f, 0.02938737f, 0.11136311f, 
    -0.06460893f, -0.04435333f, 0.03563810f, 0.08790144f, -0.10550575f, -0.05384338f, -0.01350202f, -0.06374402f, 
    -0.00196474f, 0.04181396f, 0.05436818f, 0.01737030f, -0.18098831f, -0.19638646f, 0.22650401f, -0.16702238f, 
    -0.04430197f, -0.09199686f, -0.11365170f, -0.00102574f, -0.00234010f, 0.04383139f, 0.19871907f, -0.10368983f, 
    0.18246163f, -0.04576088f, 0.06951524f, 0.10257646f, 0.12419379f, 0.20289405f, 0.09554922f, -0.06717294f, 
    0.04956920f, -0.01159251f, -0.02324523f, -0.04597295f, -0.28613088f, -0.28244409f, -0.10073663f, -0.04966825f, 
    -0.00622333f, -0.00604989f, -0.00252741f, 0.00700778f, -0.15668708f, -0.01764201f, 0.00430957f, 0.05460060f, 
    -0.31180385f, 0.48786768f, 0.10400198f, -0.03643392f, 0.07889834f, -0.14819586f, 0.10148412f, -0.21693377f, 
    0.07425003f, 0.12416110f, 0.11012303f, 0.04473942f, 0.18157117f, -0.34563655f, 0.26418278f, -0.20651710f, 
    0.07434168f, -0.04069677f, 0.18249720f, 0.00734870f, 0.07428036f, 0.07280903f, 0.19138166f, 0.12313657f, 
    -0.02330728f, 0.01313903f, -0.02930142f, 0.04756126f, -0.09469780f, -0.12258583f, 0.17145900f, -0.08151135f, 
    0.13041478f, 0.04692462f, 0.09071294f, 0.06413884f, 0.09126168f, -0.06283677f, 0.16712570f, -0.07421582f, 
    0.00085818f, 0.04027771f, -0.02871368f, -0.02694201f, -0.12789384f, -0.04522981f, -0.20608276f, -0.08640175f, 
    -0.33530352f, 0.23098789f, 0.12020358f, 0.15525399f, -0.11556111f, 0.03588458f, 0.02359710f, 0.12108265f, 
    0.08014557f, -0.08483874f, -0.18542624f, -0.20890495f, 0.08987365f, 0.29938707f, -0.22779503f, -0.14857319f, 
    0.05539778f, 0.06160417f, 0.19317526f, 0.04419545f, 0.08787946f, 0.21576557f, 0.05570147f, -0.02380001f, 
    0.26278165f, 0.03986882f, 0.25596786f, -0.05390210f, -0.11630163f, 0.09612035f, 0.05582075f, -0.02817304f, 
    0.04320284f, 0.01642678f, -0.06047546f, 0.06586397f, 0.07583383f, 0.14952603f, 0.24406949f, -0.06199253f, 
    0.02052200f, -0.03606490f, -0.01896302f, 0.01804866f, -0.00556094f, 0.01507845f, -0.15297140f, -0.07057647f, 
    -0.19753249f, 0.02394644f, -0.01614211f, 0.00795864f, 0.16531420f, 0.21104813f, 0.09790587f, 0.08044055f, 
    -0.06468212f, 0.01136604f, 0.04496637f, -0.07616229f, 0.48899740f, -0.29334801f, 0.32413507f, -0.24475381f, 
    -0.08827528f, 0.10229663f, -0.01035653f, 0.00690174f, 0.06538777f, -0.08686493f, -0.06400087f, -0.08621962f, 
    0.05173983f, 0.13215576f, -0.14036380f, -0.18349467f, -0.04786283f, 0.02285018f, 0.05149839f, -0.05757567f, 
    0.06674515f, -0.02280521f, 0.06850978f, 0.10201078f, -0.11002002f, -0.29071346f, 0.11607941f, -0.06501311f, 
    0.01881119f, -0.06849750f, 0.05177590f, 0.04613029f, -0.08020376f, -0.11357560f, -0.18319382f, -0.09463896f, 
    0.05991981f, 0.09991457f, 0.23066561f, -0.06770151f, -0.07747981f, 0.00207906f, -0.06681966f, 0.10927723f, 
    0.02529324f, -0.09114546f, -0.04126960f, 0.01619942f, -0.13713278f, 0.20561208f, -0.11541126f, 0.14647485f, 
    -0.11152744f, -0.05173430f, -0.17720868f, 0.09611357f, -0.17034195f, 0.07050466f, -0.05022417f, 0.02989408f, 
    0.16340540f, 0.14129542f, -0.02977802f, 0.11171208f, -0.05802379f, 0.05777399f, -0.00933200f, -0.11055003f, 
    -0.03549537f, -0.19268458f, -0.00852812f, -0.10414600f, -0.32245898f, -0.16904229f, -0.26891258f, -0.32157579f, 
    0.20468177f, 0.00022463f, 0.05032958f, 0.01500951f, -0.05895441f, 0.02976387f, -0.01522316f, 0.12450488f, 
    0.24126908f, -0.04437456f, -0.04104711f, 0.00104701f, -0.00223865f, -0.23672444f, 0.13152215f, -0.00935815f, 
    0.00413560f, 0.01070131f, 0.03719053f, 0.25280118f, 0.36752498f, -0.00895243f, 0.25896540f, -0.06482250f, 
    -0.14511469f, 0.09011837f, -0.04526043f, 0.02475879f, 0.17377155f, 0.03119026f, 0.17435858f, 0.13280338f, 
    0.17300680f, -0.23013265f, -0.26743191f, -0.18403630f, -0.07367709f, 0.00959038f, 0.00235898f, 0.01607753f, 
    0.12537313f, 0.06118074f, 0.04610642f, -0.07242645f, 0.33663574f, 0.41764930f, -0.25745711f, 0.03566715f, 
    0.07008075f, -0.09491756f, 0.18472596f, -0.06348532f, 0.08609457f, 0.29161209f, 0.12768425f, 0.02623592f, 
    0.14142832f, -0.05563897f, 0.18619634f, 0.01947925f, 0.03724952f, 0.08380003f, -0.06507129f, -0.10212187f, 
    -0.05342156f, -0.06342935f, -0.07629292f, 0.06469300f, -0.15776168f, 0.38673621f, 0.16587815f, -0.19354068f, 
    -0.06374875f, 0.00137770f, 0.05505304f, -0.03389511f, 0.14520489f, 0.18242373f, 0.00063657f, 0.11697321f, 
    -0.05731047f, -0.02540439f, 0.15356444f, 0.17270808f, -0.06315406f, -0.15412147f, -0.09226420f, 0.16439582f, 
    -0.03833432f, -0.06207677f, -0.20568833f, -0.10039724f, -0.01516025f, -0.03168128f, 0.11523823f, 0.33772576f, 
    -0.05477926f, -0.08948108f, 0.14411207f, 0.06183177f, 0.06793191f, -0.05784810f, -0.21144103f, -0.16959667f, 
    0.15555029f, 0.02811899f, 0.25107142f, -0.04535583f, -0.10476175f, -0.03744355f, -0.04594081f, -0.00237761f, 
    -0.05800580f, -0.09878594f, 0.05411566f, -0.16442373f, 0.11859272f, 0.10063678f, 0.05570690f, -0.01817433f, 
    0.00523124f, 0.01833778f, 0.00070345f, 0.01445990f, -0.09011025f, 0.15336119f, 0.15008669f, 0.08664440f, 
    0.01096079f, 0.03037750f, 0.14149916f, -0.29367375f, 0.01107854f, -0.07257432f, 0.12617268f, 0.15181655f, 
    -0.01859964f, 0.10978291f, 0.14988390f, 0.15319845f, -0.03753555f, 0.20090130f, 0.17091766f, -0.09359048f, 
    0.03587415f, -0.04597700f, -0.01581594f, -0.14898822f, 0.02231194f, 0.03243923f, 0.11008087f, -0.02758789f, 
    -0.10670319f, 0.11771625f, 0.00760354f, -0.01216268f, -0.01547489f, 0.01750518f, 0.10257329f, -0.07084309f, 
    0.09352153f, -0.15755363f, 0.04571637f, 0.13412806f, -0.07472456f, 0.11985841f, -0.09285525f, -0.04135227f, 
    -0.00108266f, -0.20873229f, 0.05141424f, -0.10605726f, -0.04160292f, -0.12958074f, 0.11519586f, -0.00175436f, 
    0.00169067f, -0.22835676f, 0.13476855f, 0.08071838f, -0.12333979f, -0.02324138f, -0.03003126f, 0.08871144f, 
    -0.17719930f, 0.08203705f, 0.17671593f, 0.01382354f, -0.08979501f, 0.19609140f, -0.11132952f, -0.01249504f, 
    -0.29490858f, -0.04877598f, -0.01954299f, -0.04185376f, -0.16306040f, -0.13834880f, -0.04711909f, -0.06075022f, 
    -0.09725284f, -0.06423638f, -0.03687621f, 0.16626863f, 0.01736180f, -0.09590763f, 0.06765015f, -0.06576949f, 
    0.08687229f, 0.13712792f, 0.09683885f, 0.05806282f, -0.13653964f, 0.05856924f, -0.03611684f, 0.06693349f, 
    -0.21162592f, -0.03795120f, 0.05782982f, -0.15817596f, 0.07549657f, -0.01357154f, -0.00190123f, 0.10310712f, 
    -0.06146639f, 0.14489795f, -0.05655979f, -0.02701599f, -0.03740319f, 0.01520345f, 0.10240052f, 0.07024660f, 
    0.03340404f, -0.05860309f, 0.10595906f, 0.07089045f, 0.23640998f, -0.06135438f, 0.25555107f, -0.01187961f, 
    -0.05138861f, -0.07757003f, -0.13459668f, 0.07715378f, -0.09558365f, 0.00079524f, -0.03994376f, -0.16252699f, 
    -0.06195092f, -0.02945206f, -0.20239034f, 0.05009374f, -0.03972911f, -0.00483780f, 0.16103679f, -0.11776716f, 
    0.04217823f, 0.10396821f, 0.12236251f, 0.13670537f, -0.07879530f, -0.14079715f, -0.17814751f, -0.20656453f, 
    -0.02963723f, -0.00549017f, -0.09327692f, 0.03988714f, 0.12992875f, -0.02657942f, -0.03187420f, -0.03994180f, 
    0.09907758f, 0.20697138f, 0.16171370f, 0.09551359f, -0.08832794f, 0.04471915f, 0.14216885f, -0.05593256f, 
    0.02601504f, 0.10382168f, 0.07193657f, -0.16350223f, -0.14218408f, 0.06654960f, -0.05045291f, -0.02394140f, 
    0.00115567f, 0.07787499f, 0.19696605f, -0.07506877f, -0.06161739f, 0.07760336f, 0.03996897f, 0.20594203f, 
    -0.21250942f, -0.15225078f, -0.05385588f, 0.06029745f, 0.08992938f, -0.06733506f, 0.10159900f, 0.04130200f, 
    -0.06973326f, 0.04499255f, 0.01554477f, 0.14149544f, -0.19209358f, -0.07593235f, -0.06351515f, -0.06897695f, 
    0.06898820f, 0.17841445f, 0.07884140f, -0.16946952f, -0.04201208f, -0.08144872f, -0.09259538f, -0.21738333f, 
    -0.06142344f, 0.24411985f, -0.08831850f, -0.12386157f, -0.15874094f, 0.01683302f, 0.08648290f, -0.04031863f, 
    0.08149717f, -0.04478580f, 0.13013397f, 0.08948363f, -0.21084704f, -0.02003239f, 0.07172685f, 0.09976442f, 
    -0.01323015f, 0.06914297f, -0.13036543f, 0.17025219f, -0.10660532f, -0.08347294f, 0.02347804f, -0.00811599f, 
    -0.25472549f, -0.16496187f, -0.08000700f, 0.08450422f, 0.07247998f, 0.20334619f, -0.06828205f, -0.01403037f, 
    -0.07538821f, -0.17073768f, -0.04144922f, -0.00405501f, -0.14404778f, -0.06644140f, -0.07211989f, -0.05227241f, 
    0.08188096f, 0.12399543f, 0.05476503f, -0.09149055f, -0.02485920f, -0.10179283f, -0.07106959f, -0.03448294f, 
    -0.04563233f, -0.11656351f, -0.07311532f, 0.01724102f, -0.06076029f, 0.04973018f, 0.13193698f, -0.02015555f, 
    -0.11698192f, -0.02026404f, -0.09334282f, -0.11552256f, 0.09491771f, -0.15633839f, -0.14081982f, 0.03284911f, 
    -0.05483235f, -0.05069398f, 0.01979978f, 0.12304153f, -0.09481204f, -0.02588194f, 0.03730467f, -0.18826306f, 
    0.02993952f, -0.04170637f, 0.06454883f, 0.08619083f, -0.01254873f, -0.05376514f, 0.05036938f, 0.02260142f, 
    -0.00003391f, 0.10034706f, 0.03832847f, -0.06924841f, -0.28555036f, 0.48489720f, -0.41350320f, 0.14716506f, 
    -0.07081612f, 0.17579739f, -0.08291679f, -0.14800991f, 0.01938193f, 0.03307667f, -0.08592026f, 0.06274144f, 
    -0.08239620f, 0.14477602f, -0.21086824f, 0.05571374f, -0.14227062f, -0.01995607f, 0.39519256f, -0.22307785f, 
    -0.03390145f, 0.14130712f, -0.04180893f, 0.14621617f, 0.33909062f, -0.08502154f, 0.23583888f, -0.02641595f, 
    0.02420190f, 0.01062097f, -0.01586597f, -0.03308941f, -0.05467369f, 0.20056252f, 0.10826933f, -0.01570120f, 
    -0.31170690f, 0.11356270f, -0.12603985f, 0.11468703f, -0.12234338f, 0.01093820f, 0.14593568f, -0.01692853f, 
    -0.08862434f, 0.01706148f, 0.07164687f, 0.07131577f, 0.36149919f, 0.25164750f, -0.24261273f, -0.00779466f, 
    0.14189136f, 0.06042289f, -0.02831701f, 0.17548878f, 0.02038674f, 0.23217674f, 0.06876822f, -0.05658389f, 
    0.03146141f, -0.03732142f, -0.13635339f, -0.06658501f, -0.11726823f, -0.10328621f, 0.15290727f, 0.08139896f, 
    0.02162760f, -0.10438846f, -0.03104347f, 0.04047984f, 0.04351503f, -0.17247939f, 0.22269553f, 0.06317297f, 
    -0.03746375f, 0.00058903f, 0.04430892f, 0.07057913f, 0.10670409f, -0.05902284f, -0.00566547f, -0.01696026f, 
    -0.02900427f, -0.11576939f, 0.11300391f, -0.08551350f, 0.10571088f, -0.14167520f, 0.03344101f, 0.11512819f, 
    0.06658417f, -0.23498447f, -0.04898429f, 0.16197421f, -0.30465657f, -0.15294185f, 0.23788434f, -0.14256261f, 
    -0.06252517f, -0.11165492f, -0.01033793f, 0.11281827f, 0.07610281f, -0.00861819f, -0.09940915f, 0.12995870f, 
    0.11414757f, 0.08915758f, -0.00627991f, 0.00011643f, -0.02425945f, -0.03350816f, -0.07763965f, 0.03548736f, 
    0.02651663f, -0.12737399f, -0.01047171f, 0.01469903f, -0.12605691f, 0.08636935f, 0.11547901f, 0.07839344f, 
    0.01284047f, 0.10734890f, 0.10237718f, 0.08250360f, 0.06392600f, -0.02605850f, -0.06654425f, -0.08473801f, 
    0.12348915f, 0.00115227f, 0.13954987f, -0.08950495f, 0.02148803f, -0.03607586f, -0.07721948f, -0.01658084f, 
    -0.05406305f, -0.10200699f, -0.06094008f, -0.13072644f, 0.13239309f, -0.01941959f, -0.06060449f, 0.01139724f, 
    0.19877584f, 0.08241338f, -0.06943677f, -0.16661543f, -0.06136927f, -0.04435643f, 0.04854687f, 0.26253864f, 
    -0.19050781f, 0.10610411f, 0.02099106f, 0.04656162f, -0.00952473f, 0.06215879f, 0.07828823f, 0.13695602f, 
    -0.15265015f, -0.01053224f, 0.11058360f, -0.12341700f, -0.21504670f, -0.14993358f, -0.03966180f, 0.02916317f, 
    0.20348923f, 0.01652743f, 0.02941076f, -0.15748990f, -0.00615520f, -0.08712506f, -0.00965318f, 0.06427129f, 
    0.40191841f, -0.10618427f, 0.18563494f, -0.00196464f, 0.02382235f, 0.08114845f, -0.22806197f, -0.08318525f, 
    0.02951547f, -0.00807980f, 0.01191598f, -0.00715015f, -0.01368879f, 0.11855469f, -0.03785831f, 0.06976360f, 
    0.15967476f, -0.02107181f, 0.05300500f, 0.02707002f, 0.06189092f, -0.03042610f, -0.03512923f, 0.10501352f, 
    0.01949309f, -0.01078578f, -0.01884375f, -0.09062431f, 0.00311953f, 0.04370505f, -0.07868770f, 0.05296847f, 
    -0.05581487f, -0.05328539f, -0.04044996f, -0.13030520f, 0.01891663f, -0.04677211f, 0.04486297f, 0.02658418f, 
    -0.06095434f, -0.00511465f, -0.03727245f, -0.02171371f, 0.17881311f, 0.04837394f, 0.18304545f, 0.11830608f, 
    -0.21458760f, -0.12399977f, -0.05703048f, -0.00216845f, -0.14441471f, -0.18637648f, -0.00106616f, 0.00144196f, 
    -0.01543491f, 0.01388154f, 0.15430988f, 0.04451296f, -0.13645169f, 0.29924345f, 0.05014376f, -0.03323644f, 
    0.00798448f, 0.02622913f, 0.03053423f, 0.10204478f, 0.07237722f, -0.04740298f, -0.03751611f, -0.02018654f, 
    0.10833834f, -0.01135304f, -0.08580599f, 0.05947925f, -0.00402687f, -0.06223998f, -0.08715130f, 0.01164549f, 
    0.07058374f, 0.09049661f, 0.08328906f, 0.03607379f, 0.15752175f, 0.00747053f, 0.06623504f, 0.05247207f, 
    -0.06299040f, -0.01818983f, -0.09003729f, -0.01711217f, 0.14937998f, 0.10449377f, 0.07810526f, 0.06263956f, 
    -0.00500968f, -0.03603886f, 0.01404290f, 0.04752095f, 0.00312784f, -0.09378213f, -0.02702331f, 0.03140984f, 
    0.03668964f, 0.02491866f, -0.02163276f, 0.07425780f, 0.08553995f, 0.13062865f, -0.10002607f, 0.24379775f, 
    0.04831073f, -0.12593482f, -0.06574221f, 0.05349027f, 0.03257915f, 0.09373527f, 0.14693430f, -0.08778057f, 
    0.23401266f, 0.11673377f, -0.03988191f, 0.19424842f, 0.12588753f, -0.01891168f, -0.02881410f, -0.04638155f, 
    0.00325581f, -0.05846076f, 0.01442434f, -0.04188155f, -0.37168100f, 0.11053884f, -0.05623538f, -0.18958610f, 
    -0.13601893f, 0.02246653f, 0.09185446f, 0.02666643f, -0.09313565f, 0.01140497f, -0.00076744f, 0.09403973f, 
    -0.17284499f, 0.04283102f, 0.11441033f, -0.07494740f, -0.15459545f, -0.03737010f, 0.05141222f, -0.02864637f, 
    0.02368560f, 0.08157556f, -0.00410316f, 0.02235963f, 0.16128191f, 0.06718025f, -0.13536261f, 0.08376670f, 
    -0.05574718f, 0.13010883f, 0.12413505f, -0.09960023f, -0.04974707f, 0.08938866f, 0.00777040f, -0.02371153f, 
    -0.08591153f, -0.07614523f, -0.11985012f, 0.00075796f, -0.09775131f, 0.06075609f, -0.02363914f, 0.05646287f, 
    0.10729174f, 0.09306303f, 0.03712964f, 0.03912135f, -0.04304389f, -0.05011262f, 0.14180712f, 0.35804608f, 
    -0.00475246f, 0.15828730f, 0.05526618f, 0.00501669f, 0.01388991f, -0.09870894f, 0.02562777f, -0.07393558f, 
    -0.24164267f, 0.37232116f, 0.01533942f, -0.16455555f, -0.13394935f, 0.04944262f, 0.05554376f, -0.01464864f, 
    0.09195979f, 0.13561107f, 0.09323188f, 0.00363645f, -0.23706049f, -0.00488470f, -0.02009479f, 0.19574560f, 
    0.03301779f, -0.07451598f, -0.11101388f, 0.03366143f, 0.04408874f, 0.00129031f, -0.04221171f, 0.05993065f, 
    -0.03336021f, 0.16241902f, -0.07558102f, 0.02068025f, -0.02122932f, 0.12854382f, -0.02961600f, 0.30091360f, 
    -0.11867536f, -0.00967859f, 0.03016437f, 0.04297033f, -0.01076474f, 0.43174818f, 0.02494111f, -0.03838103f, 
    0.06631715f, 0.03423991f, 0.20449363f, 0.20719372f, 0.17166890f, -0.02470593f, -0.02978104f, 0.00267027f, 
    -0.03546099f, 0.06864852f, -0.08423761f, -0.13446876f, -0.01679065f, -0.09917033f, -0.05872637f, 0.01843022f, 
    0.01849023f, 0.11310380f, -0.07036734f, 0.09968846f, 0.51702523f, -0.00383021f, 0.14760512f, 0.16622874f, 
    0.01803462f, 0.03030536f, -0.11098626f, -0.06882876f, -0.04203043f, -0.05690753f, 0.04925929f, -0.07822768f, 
    -0.39972907f, -0.21404074f, -0.02553925f, 0.00587681f, 0.05044908f, -0.09070311f, -0.03133882f, 0.00223348f, 
    -0.02221419f, -0.06368754f, 0.10669521f, 0.06517959f, -0.15146455f, 0.01992166f, 0.06457843f, -0.01827609f, 
    -0.07176279f, 0.08162169f, 0.11593448f, 0.06615003f, -0.03764354f, 0.05490986f, 0.17993632f, 0.05059850f, 
    0.01947089f, -0.00189099f, -0.13319187f, 0.00427146f, -0.06827541f, -0.08798279f, -0.04932578f, -0.01975028f, 
    0.03170669f, 0.04785227f, -0.13450491f, -0.09259441f, 0.00043112f, 0.01695242f, 0.30335578f, -0.01116859f, 
    0.00618988f, -0.10045733f, -0.03254585f, -0.02278951f, 0.21595983f, -0.10358617f, -0.04527016f, 0.02446951f, 
    -0.26960105f, -0.04945166f, -0.03761928f, -0.04166595f, -0.12049460f, -0.12462421f, 0.12168852f, 0.14360286f, 
    -0.00466096f, 0.08032119f, 0.10569677f, -0.14030430f, 0.34967360f, -0.10430739f, 0.04691310f, 0.08793746f, 
    0.04238617f, -0.04295366f, -0.09979265f, 0.07753770f, 0.13386078f, 0.04895713f, 0.04319527f, 0.02145387f, 
    0.27908269f, 0.28089902f, -0.08142827f, 0.06838965f, -0.10282461f, -0.03446741f, -0.07215654f, -0.00885810f, 
    -0.09984812f, 0.05112896f, 0.01376502f, -0.03868150f, 0.00502716f, -0.11256451f, -0.11778936f, -0.15596808f, 
    -0.03238558f, 0.04272133f, 0.00615648f, 0.02079375f, 0.01791178f, -0.00457132f, -0.01612515f, 0.10014320f, 
    -0.03518892f, -0.14170480f, 0.07266805f, -0.00595864f, 0.11646442f, 0.08126462f, 0.09806940f, -0.00497408f, 
    0.02184076f, 0.04552313f, -0.11363143f, 0.03199204f, 0.21823344f, -0.20914198f, 0.13567290f, 0.20518956f, 
    0.13800497f, -0.08943509f, -0.03792385f, 0.16764775f, 0.05697812f, 0.05170345f, 0.18509948f, 0.00477053f, 
    0.05679147f, 0.22565173f, 0.03383188f, -0.00970078f, 0.03264054f, 0.05573591f, -0.08250130f, 0.04853747f, 
    -0.14255622f, -0.05239159f, 0.02332753f, 0.04209686f, 0.08995546f, -0.00140625f, 0.06119042f, -0.11784758f, 
    -0.03249788f, 0.13342588f, -0.07279956f, -0.03029723f, -0.12267370f, -0.03871531f, -0.08541022f, -0.00862667f, 
    0.28439754f, -0.11159925f, 0.03218175f, 0.14913984f, 0.06250194f, -0.01190542f, -0.11876416f, 0.08451680f, 
    -0.06653183f, 0.20570886f, 0.22194006f, -0.04553324f, -0.17971270f, -0.05211588f, 0.00801893f, -0.06698497f, 
    -0.15320195f, -0.01331967f, -0.02182484f, 0.01072741f, 0.09561146f, 0.01323220f, 0.01923919f, 0.09238818f, 
    0.07722731f, -0.04705597f, 0.07472356f, -0.04382744f, 0.03689764f, 0.06307188f, 0.01595152f, 0.03109644f, 
    0.02064045f, -0.04716909f, -0.05569812f, -0.06025783f, 0.41180459f, 0.01518749f, -0.07869677f, 0.17758530f, 
    0.06778188f, -0.00187251f, 0.04837302f, 0.31729192f, -0.04973604f, -0.07032077f, 0.04576237f, -0.01595953f, 
    0.32131091f, -0.04752907f, -0.13147952f, 0.04386534f, -0.03240094f, 0.07720882f, -0.01605174f, 0.05331646f, 
    0.09780750f, 0.12426110f, 0.11005601f, 0.17155047f, -0.08307958f, 0.07046420f, -0.02733083f, -0.05221724f, 
    -0.10928506f, 0.06867246f, 0.11602576f, 0.01674735f, -0.02567226f, 0.04418329f, -0.06674431f, 0.00089298f, 
    -0.15896289f, -0.09190551f, 0.14726597f, -0.00634369f, 0.14699097f, 0.20067897f, -0.05705937f, -0.11842403f, 
    0.09893940f, 0.09802678f, 0.00616255f, 0.04047882f, -0.16291679f, -0.12856407f, -0.11994829f, 0.24442264f, 
    0.06306079f, 0.12469102f, 0.08835379f, -0.00792505f, -0.01798595f, 0.05221532f, 0.10430328f, 0.07433668f, 
    0.13982278f, -0.03878550f, 0.11884849f, 0.01293720f, 0.00939945f, 0.05353796f, -0.13024156f, 0.04931552f, 
    0.03128288f, -0.02575191f, -0.00089723f, -0.07010190f, -0.14850076f, 0.01273067f, 0.06192451f, -0.09037539f, 
    -0.08623216f, -0.04695409f, 0.07585360f, 0.11514193f, -0.00938884f, 0.04536844f, -0.07141861f, -0.10412408f, 
    -0.07709098f, -0.07839856f, -0.03987120f, -0.00387919f, -0.03402104f, -0.01833244f, 0.20614500f, -0.06431615f, 
    -0.04131232f, -0.02467095f, -0.03506406f, 0.00150855f, -0.10624646f, 0.00550414f, -0.00821142f, 0.08448969f, 
    0.02943010f, 0.15480311f, 0.12432344f, -0.01573970f, -0.04302849f, -0.07817277f, 0.04984344f, -0.05288421f, 
    0.08575068f, 0.15497328f, -0.24958460f, -0.01263714f, 0.02267601f, 0.08704171f, 0.05994501f, 0.08552378f, 
    0.14582735f, -0.05327629f, 0.13655618f, -0.04774562f, -0.31017432f, 0.01526607f, 0.24635026f, 0.07646812f, 
    0.00626813f, 0.00327804f, -0.01326722f, 0.08703379f, -0.13681087f, 0.00506928f, -0.03101348f, 0.08454348f, 
    0.02220389f, -0.01303959f, 0.14412121f, -0.10668954f, -0.13862345f, -0.03900158f, -0.17425196f, 0.07019236f, 
    -0.05968843f, -0.15337940f, -0.06778266f, -0.06957833f, 0.24753745f, -0.25976294f, -0.08591740f, 0.62228233f, 
    0.12165062f, 0.06209601f, 0.11082684f, -0.00571918f, -0.09017406f, -0.02021739f, -0.03217169f, 0.03133781f, 
    0.11663619f, -0.08891287f, -0.04198158f, -0.04854906f, 0.00959705f, 0.07684156f, 0.04183545f, 0.01755391f, 
    0.02717101f, -0.02039047f, 0.06320965f, -0.08108391f, -0.12995863f, 0.10008505f, -0.01561153f, -0.00106043f, 
    0.10029408f, -0.02196022f, 0.02039960f, -0.03794458f, 0.25190714f, -0.04028931f, -0.09164041f, 0.11559118f, 
    -0.11564396f, -0.16967779f, -0.13064341f, -0.15460955f, 0.18710925f, 0.01293482f, 0.07567237f, -0.00765611f, 
    0.07636973f, 0.01056659f, -0.10539123f, -0.00030467f, -0.17012358f, -0.04953880f, 0.33603325f, -0.10324225f, 
    0.15893665f, 0.09148388f, 0.16760209f, 0.04329889f, 0.15761985f, -0.01108006f, 0.11684540f, 0.19837876f, 
    0.25218713f, 0.07601169f, 0.15312210f, 0.17006837f, 0.18097988f, 0.20362298f, 0.06516490f, 0.09920562f, 
    -0.07855608f, 0.06804130f, -0.01761238f, 0.08856063f, 0.18919060f, 0.31737664f, 0.06080171f, -0.09597210f, 
    0.10948538f, 0.05005158f, -0.07464775f, -0.03742130f, 0.00636339f, 0.13383958f, 0.07541030f, -0.06410784f, 
    0.49695799f, 0.08101847f, -0.06019923f, 0.15555280f, 0.13968840f, 0.11161271f, 0.17431825f, -0.01199436f, 
    -0.07066241f, 0.17461924f, -0.02881695f, 0.07134710f, 0.16420147f, 0.24872635f, -0.11360095f, 0.10042884f, 
    0.26229665f, 0.13936903f, 0.03415605f, -0.02971056f, -0.14925455f, -0.00941755f, -0.04201032f, -0.03117791f, 
    -0.22010228f, -0.04296335f, -0.00282884f, 0.18259263f, -0.19060519f, -0.12446980f, -0.10778148f, -0.17294605f, 
    -0.04038745f, 0.00133371f, -0.04317130f, 0.04787165f, 0.14744993f, 0.34970436f, 0.01749103f, 0.18209682f, 
    0.00438894f, -0.06043226f, 0.05148495f, -0.04466583f, -0.03971912f, -0.04030584f, -0.05756811f, -0.03427823f, 
    -0.38208354f, -0.17981848f, 0.07424486f, -0.07909168f, -0.16176490f, -0.20624448f, -0.15507676f, -0.16203447f, 
    0.04675382f, -0.01052633f, -0.02513008f, -0.01170458f, 0.25245753f, 0.19327566f, -0.01933192f, 0.05462383f, 
    -0.10008729f, 0.01942412f, -0.00476890f, 0.30982926f, -0.02507730f, 0.05304786f, -0.20628785f, -0.00257184f, 
    0.15588103f, 0.23183176f, 0.11572412f, -0.01163838f, -0.00861083f, 0.13296169f, -0.00910242f, -0.02156357f, 
    0.09071156f, 0.08367870f, -0.11510441f, 0.11021597f, 0.22306006f, 0.12791456f, -0.02965570f, 0.03908918f, 
    0.07868865f, 0.23763601f, -0.01969911f, 0.16358639f, 0.08689867f, 0.01648110f, -0.01470690f, -0.07764416f, 
    -0.41175228f, -0.16485877f, -0.03778604f, -0.07339385f, -0.18329732f, 0.05538461f, -0.04479775f, -0.04961631f, 
    -0.08998960f, 0.11668377f, -0.08684082f, 0.06678755f, -0.06194203f, 0.05074983f, -0.03428615f, 0.18861730f, 
    0.04062235f, 0.06173641f, -0.08583829f, 0.00919443f, 0.01167112f, 0.00231042f, 0.07430337f, -0.12318455f, 
    0.02852885f, -0.04126859f, 0.01298490f, 0.04646502f, -0.00140551f, 0.10668489f, -0.09088946f, -0.11347448f, 
    -0.03884541f, -0.08673913f, 0.04856184f, -0.06886885f, -0.31145570f, 0.19679490f, -0.08908918f, -0.13237412f, 
    -0.05806038f, -0.07148447f, 0.03219074f, -0.05667169f, 0.00533320f, 0.01450280f, 0.05556607f, 0.06554916f, 
    0.30514973f, 0.30241889f, 0.19016758f, 0.20370474f, 0.16836601f, 0.20207162f, 0.02962035f, -0.02269726f, 
    -0.00305842f, -0.02199194f, 0.03285807f, 0.11102472f, -0.04905621f, -0.16635761f, -0.10610353f, 0.10141868f, 
    -0.02305719f, -0.02190601f, 0.13615245f, -0.10618855f, 0.05423418f, 0.02886353f, -0.07676128f, 0.22702014f, 
    -0.02615357f, 0.07554895f, -0.08982003f, -0.08710905f, -0.05120578f, -0.08992102f, -0.08125820f, 0.04372212f, 
    -0.11977943f, -0.08865269f, 0.07449854f, 0.00355585f, -0.19011720f, -0.05335044f, -0.02136896f, -0.09487205f, 
    -0.06899352f, -0.06238293f, -0.10014614f, -0.09453166f, -0.10165018f, 0.02299176f, 0.05097054f, 0.05518052f, 
    0.14781380f, 0.10791500f, 0.16106629f, 0.07487372f, -0.03978164f, 0.10450171f, -0.01257438f, 0.04604016f, 
    -0.07669664f, -0.01072478f, -0.06151976f, -0.06641514f, 0.11485314f, 0.05809933f, -0.00927776f, -0.21701352f, 
    -0.00246653f, -0.13819858f, 0.01568142f, -0.09099082f, -0.09021190f, -0.07944381f, -0.03002886f, 0.13149123f, 
    -0.28913417f, -0.17009923f, 0.14599864f, 0.02129138f, 0.01222259f, -0.11174631f, -0.11089174f, -0.11165362f, 
    -0.01280065f, 0.02993909f, 0.03012271f, -0.02480067f, 0.34599152f, 0.15492551f, 0.00251279f, 0.20132889f, 
    0.28087690f, 0.06032424f, 0.11915766f, 0.11659299f, -0.03790798f, 0.00651071f, -0.04362856f, -0.04327255f, 
    0.14087392f, 0.06674413f, 0.01219677f, 0.15917303f, 0.13507934f, 0.01752459f, 0.05886687f, 0.00344691f, 
    -0.00088683f, -0.00148533f, -0.03790974f, -0.04032684f, 0.21247777f, -0.05799508f, 0.19667172f, 0.16204531f, 
    -0.11673865f, 0.01308861f, -0.12410308f, -0.07133842f, 0.18259256f, 0.02844202f, 0.08466890f, 0.03589377f, 
    -0.08001336f, 0.07669913f, 0.10293862f, 0.17652971f, -0.01708981f, 0.01939060f, -0.03340752f, -0.11085445f, 
    -0.00471338f, 0.11441828f, -0.00342847f, 0.00846575f, 0.04708388f, 0.19623668f, 0.25014803f, 0.03324274f, 
    -0.02589778f, 0.01042681f, 0.01686627f, 0.01620052f, -0.02405833f, 0.02368517f, -0.00736207f, -0.01145991f, 
    0.28004268f, -0.00114478f, -0.20348577f, 0.34473351f, 0.06828042f, -0.04191262f, -0.04371715f, 0.02965322f, 
    0.08237795f, 0.12660423f, 0.01240389f, -0.22571225f, -0.17505875f, 0.03170540f, 0.10142327f, -0.23346016f, 
    0.12249257f, 0.08190187f, 0.03834540f, -0.04709996f, -0.05250144f, 0.00010853f, 0.05467932f, 0.00701887f, 
    -0.22953346f, -0.12429865f, 0.40342882f, 0.03493655f, -0.02815445f, 0.04543469f, -0.16421017f, -0.15444070f, 
    0.11594239f, 0.08014955f, 0.14281431f, -0.05783047f, -0.13749409f, -0.09424627f, -0.03331873f, 0.22613166f, 
    -0.13867339f, 0.09054508f, -0.07110985f, -0.17000431f, -0.01484403f, 0.08260978f, -0.04932150f, 0.12454044f, 
    -0.01293408f, -0.13027750f, -0.03468367f, -0.06100900f, 0.01781069f, -0.14860630f, -0.11000752f, -0.09284241f, 
    0.05207087f, -0.05355864f, 0.09319300f, 0.07643296f, -0.20778742f, -0.21046454f, 0.14256616f, -0.10075724f, 
    -0.10067536f, -0.03931545f, -0.19199641f, -0.08236413f, 0.00117313f, 0.03233744f, -0.07911351f, 0.03256388f, 
    0.36493263f, 0.28272334f, 0.12657109f, 0.12087102f, 0.16287488f, 0.22271784f, 0.06105397f, 0.06008599f, 
    -0.07797318f, 0.03921492f, -0.04543496f, 0.01564655f, 0.13930516f, 0.26755428f, 0.02314028f, 0.14706001f, 
    0.23278061f, 0.12140963f, 0.03391550f, -0.01250351f, 0.01256456f, -0.01206613f, 0.02173890f, 0.11488468f, 
    -0.16409281f, -0.18444149f, -0.26162308f, -0.09533785f, -0.05875384f, -0.08496686f, -0.16832784f, -0.14559636f, 
    0.00583730f, -0.01743495f, -0.08628181f, 0.05480206f, -0.19469973f, -0.01889283f, -0.28697687f, -0.02702291f, 
    -0.12202611f, 0.02379436f, -0.01340947f, -0.10026505f, -0.17923556f, 0.10691876f, 0.08601891f, -0.06640132f, 
    0.31417969f, 0.15384489f, 0.02169338f, 0.19833729f, 0.11521313f, 0.13156167f, -0.00769809f, 0.02007582f, 
    0.09681034f, 0.06588721f, 0.02481605f, 0.03560415f, -0.45507479f, -0.10106543f, -0.12460438f, 0.02808916f, 
    -0.04387841f, -0.01642623f, -0.19663775f, -0.06788331f, 0.00820875f, 0.12389888f, 0.09259563f, 0.12247196f, 
    -0.11288835f, -0.20956139f, -0.11729211f, 0.05882997f, -0.02072201f, -0.10130776f, -0.05507308f, -0.07803363f, 
    0.00135130f, -0.03179775f, -0.08972793f, 0.06108133f, -0.10701220f, -0.05564528f, -0.05187510f, -0.12849928f, 
    -0.10474540f, -0.01189105f, 0.03801299f, 0.05812779f, -0.13461620f, 0.04824293f, 0.01477415f, -0.18721133f, 
    0.15874323f, 0.17071432f, 0.05153069f, 0.00231243f, 0.11119708f, -0.09381812f, -0.00794164f, 0.08829257f, 
    0.05594474f, 0.05424093f, 0.02813926f, 0.06204992f, 0.03243343f, 0.07893688f, -0.08990655f, -0.07602754f, 
    0.06121597f, 0.05124034f, -0.01440928f, -0.06612001f, -0.10648296f, -0.09100381f, 0.10491260f, -0.02408338f, 
    0.17054075f, -0.05459863f, 0.22431663f, -0.19985268f, -0.13328795f, -0.10695695f, -0.03198075f, -0.02775057f, 
    0.04848312f, 0.05900690f, -0.11249401f, 0.10743457f, -0.02026951f, -0.05642991f, 0.00235585f, -0.00613739f, 
    -0.10415917f, -0.20458902f, -0.10524094f, -0.02843736f, 0.04631369f, -0.01563139f, -0.01091281f, -0.06500369f, 
    -0.24242550f, -0.18659672f, -0.02207557f, -0.06004820f, -0.13499802f, 0.01495280f, -0.11911055f, -0.05408060f, 
    0.09080114f, -0.06386903f, -0.00650447f, 0.09325822f, 0.02880786f, 0.02892411f, 0.14543639f, 0.18810298f, 
    0.17899050f, 0.09900533f, 0.10388583f, -0.02981088f, -0.00678679f, 0.03008703f, 0.02737134f, 0.03573470f, 
    -0.16368596f, 0.09439676f, 0.11834890f, -0.00610262f, -0.00023109f, -0.08678994f, -0.21649392f, -0.03141225f, 
    -0.06664800f, -0.02432395f, 0.01661715f, -0.12607850f, -0.19866221f, -0.01922808f, 0.28513128f, 0.02268227f, 
    -0.08699348f, 0.03127949f, -0.19555618f, -0.18972060f, -0.00854000f, -0.09123807f, 0.05114397f, 0.09732812f, 
    0.06925373f, -0.01276115f, 0.07429810f, 0.18078980f, 0.04036383f, 0.03745072f, -0.08232392f, -0.09499401f, 
    0.10475218f, -0.16684377f, 0.04509819f, 0.08745121f, 0.34196436f, 0.07736570f, -0.09442093f, 0.25014454f, 
    0.15788837f, 0.03800973f, -0.05299683f, 0.13852476f, 0.01837920f, 0.09585762f, 0.00577618f, 0.00998724f, 
    0.21760555f, 0.31006041f, -0.15926312f, -0.03888797f, 0.00415200f, -0.01575599f, 0.12244731f, 0.23437797f, 
    0.03074187f, -0.05412697f, 0.02893513f, 0.01319812f, 0.12536582f, 0.24409160f, 0.10871144f, 0.13618785f, 
    -0.09587767f, -0.05663090f, -0.14735469f, 0.06276632f, -0.00524719f, -0.08661234f, 0.01027397f, 0.04900811f, 
    -0.32493043f, -0.18138553f, 0.01280168f, -0.12184022f, -0.10367574f, -0.00735722f, -0.11974129f, -0.07291017f, 
    -0.07653363f, -0.01431119f, 0.11529548f, -0.05026795f, 0.18132718f, -0.02401812f, -0.09152178f, 0.14918368f, 
    0.08047877f, 0.11142880f, 0.20725858f, -0.07774864f, -0.05902413f, -0.07969569f, 0.01386970f, 0.04926122f, 
    0.19614039f, 0.18181516f, -0.00596544f, 0.04002630f, 0.20921847f, 0.11822505f, 0.06467128f, 0.02992671f, 
    -0.04069033f, 0.02331177f, -0.08075462f, -0.01749373f, 0.10135174f, 0.10134266f, 0.09838307f, 0.03645866f, 
    0.05847400f, 0.03146166f, 0.04616307f, 0.06126178f, -0.04498312f, 0.07166206f, -0.05288082f, 0.08864300f, 
    0.07671650f, -0.05393441f, 0.14212941f, 0.07778982f, -0.02369729f, 0.05943775f, -0.11278887f, -0.02432247f, 
    0.08076195f, 0.09486688f, 0.00779716f, 0.26419565f, 0.16079988f, 0.36058727f, -0.03122327f, 0.01061687f, 
    0.07091127f, 0.08816478f, 0.06850462f, 0.05398569f, -0.10884690f, -0.00772467f, -0.07954761f, 0.01067008f, 
    -0.14280973f, 0.16454461f, 0.09393918f, -0.16529168f, 0.02532230f, -0.02510208f, -0.12477633f, -0.02999795f, 
    0.00891405f, -0.09652208f, -0.03257668f, 0.09758638f, 0.40538022f, 0.06112288f, 0.06313208f, -0.23511322f, 
    0.10140905f, 0.10937092f, -0.07703017f, 0.08928598f, 0.06573648f, 0.03979535f, -0.01605412f, -0.00064479f, 
    -0.07668398f, -0.09097531f, 0.11156196f, -0.09282197f, -0.02001693f, 0.04119269f, -0.08956258f, -0.04258994f, 
    0.05566574f, -0.04110615f, 0.03628126f, -0.07000311f, -0.11548518f, 0.02804499f, -0.18080267f, -0.17524523f, 
    -0.07540660f, -0.11356047f, 0.05701963f, 0.04112459f, -0.16228651f, 0.04251014f, 0.01080149f, -0.01866158f, 
    0.19291031f, 0.10405162f, 0.10952265f, 0.11795589f, -0.01033786f, 0.07856146f, -0.00911738f, 0.14522515f, 
    -0.08845074f, 0.02699633f, 0.12578920f, -0.04933568f, 0.07442959f, -0.06265892f, 0.18692040f, -0.00740840f, 
    0.02649443f, 0.00063651f, -0.20057175f, 0.04065059f, -0.01437317f, 0.09696788f, 0.10969671f, 0.02422355f, 
    0.01171295f, -0.00315434f, 0.02175022f, -0.04056888f, 0.02582032f, -0.02890357f, -0.02350835f, 0.01841743f, 
    -0.00611953f, -0.03006118f, -0.01504193f, -0.00664915f, -0.04012637f, 0.01894381f, -0.01989620f, 0.01303847f, 
    -0.02689967f, -0.00211498f, -0.02726072f, -0.01083667f, -0.00741993f, -0.00119958f, 0.01910184f, -0.03813456f, 
    0.01753173f, -0.03522368f, 0.00160238f, 0.02851974f, -0.00818930f, -0.00934210f, -0.03511858f, 0.01093024f, 
    -0.00790549f, 0.00153445f, 0.00083927f, -0.02791491f, -0.01881957f, -0.02577760f, -0.02859928f, 0.00586448f, 
    -0.01514206f, 0.01066995f, 0.01090182f, -0.00465738f, -0.02487497f, -0.00650477f, 0.00086667f, -0.02069203f, 
    -0.03541955f, -0.03876768f, 0.02793804f, -0.03588360f, -0.03754636f, -0.03915844f, 0.01128786f, 0.00827900f, 
    0.02926126f, -0.04154791f, 0.00079519f, -0.01646953f, 0.02006010f, 0.02357979f, 0.01072041f, 0.00810039f, 
    -0.03918134f, -0.00739261f, 0.00960271f, 0.01244497f, 0.02288556f, -0.04063594f, -0.01979204f, -0.03765778f, 
    -0.01633904f, 0.02016757f, -0.02933374f, -0.03654985f, -0.02117113f, -0.00028372f, 0.00636937f, 0.01327293f, 
    0.00765834f, 0.00534832f, 0.02931279f, 0.02472669f, 0.00586751f, 0.02095039f, -0.00066170f, 0.01054166f, 
    -0.01273755f, -0.03336759f, -0.01149456f, -0.00333094f, -0.03199834f, 0.00968973f, -0.00667589f, 0.01188510f, 
    -0.02726015f, -0.02123089f, 0.02953660f, 0.00056029f, -0.03691267f, -0.00875140f, -0.01525751f, 0.00003932f, 
    0.02387735f, -0.02700709f, 0.00257194f, -0.01819477f, 0.01956237f, 0.01221389f, -0.01530930f, -0.01023741f, 
    0.01920716f, 0.01995823f, -0.00965244f, -0.02801245f, -0.03797191f, 0.02398184f, 0.00179846f, 0.02104530f, 
    0.01043899f, -0.03580461f, -0.03495322f, -0.01508488f, -0.02832875f, 0.02656310f, 0.02082619f, -0.03602311f, 
    -0.01781683f, 0.00578266f, -0.02420156f, -0.03321938f, 0.00260265f, -0.03134907f, -0.02995133f, 0.01886551f, 
    -0.00545646f, -0.03814541f, -0.02143144f, 0.01196824f, -0.01250148f, -0.00122954f, 0.01698803f, -0.00304106f, 
    0.01269263f, 0.01491305f, -0.01497421f, -0.01349909f, 0.01893475f, -0.00964352f, -0.02377711f, -0.02199006f, 
    0.00772644f, -0.01608271f, -0.03644444f, 0.01128911f, -0.03603170f, -0.02188387f, -0.01966312f, 0.01314879f, 
    -0.03103157f, -0.03148934f, 0.00617441f, 0.00332360f, 0.02486658f, 0.00269279f, -0.00950632f, -0.00893141f, 
    0.00508772f, 0.00977841f, 0.00056063f, 0.01205714f, -0.00410756f, 0.02397587f, -0.00410008f, -0.03664967f, 
    -0.01721044f, -0.00561314f, -0.01240378f, -0.02196747f, -0.01311381f, -0.01418121f, 0.00170118f, 0.00882738f, 
    0.00605701f, -0.01175252f, 0.01314081f, -0.04105289f, -0.01193839f, -0.00160370f, 0.01734628f, -0.03527498f, 
    -0.03721472f, -0.03920462f, 0.01658354f, -0.02167097f, -0.00886059f, 0.01882743f, -0.03789015f, 0.00072199f, 
    -0.02398287f, -0.00587845f, -0.01197839f, -0.00632518f, -0.02992611f, 0.02131075f, -0.03963358f, -0.03113095f, 
    0.00266278f, -0.02281923f, -0.02559516f, 0.02067079f, 0.02344648f, 0.00345402f, 0.02822794f, 0.01273454f, 
    -0.01949839f, -0.03740276f, -0.01891954f, -0.00184791f, -0.01324508f, 0.00711311f, 0.02746985f, -0.04129496f, 
    0.03083562f, 0.02153919f, -0.00092374f, -0.02823111f, -0.02184055f, 0.02122604f, -0.00983390f, 0.01721345f, 
    0.01676550f, -0.01912805f, -0.00760997f, 0.01373402f, 0.00947563f, -0.00614368f, -0.02450658f, -0.00123497f, 
    -0.03831684f, -0.01280710f, 0.01308215f, 0.02945714f, -0.01240072f, -0.01782386f, -0.02768703f, -0.02991621f, 
    -0.01623832f, -0.03289178f, 0.00307552f, -0.01913766f, 0.00977409f, 0.02975699f, 0.01800605f, -0.01939632f, 
    -0.02274916f, 0.02311048f, 0.01219355f, -0.01922724f, -0.01684270f, -0.01921584f, 0.02921487f, -0.02618764f, 
    0.02972446f, 0.02253409f, 0.00483951f, -0.02240712f, 0.02345881f, -0.02066340f, 0.02316873f, -0.01439741f, 
    0.00111756f, 0.02037742f, 0.00667035f, -0.04077393f, -0.01295529f, 0.03169748f, -0.01484078f, -0.00392880f, 
    0.03355925f, 0.02202678f, -0.03472029f, -0.03574583f, -0.00124006f, -0.00581032f, 0.01689770f, 0.00687950f, 
    0.02964976f, -0.00465087f, 0.00373772f, -0.04186838f, -0.01677821f, -0.00560812f, -0.01521296f, -0.04095828f, 
    -0.02342685f, -0.04083790f, 0.00131581f, 0.02292709f, 0.00266711f, -0.02749555f, -0.00593480f, -0.01776594f, 
    0.02281383f, 0.02807004f, 0.00972829f, 0.00820046f, -0.00426504f, -0.04189741f, -0.02289159f, -0.01005937f, 
    -0.02532767f, -0.00235316f, -0.00230294f, 0.02389714f, -0.01447782f, 0.00608302f, -0.03182440f, -0.02545821f, 
    -0.02697185f, -0.03978973f, 0.02551712f, 0.00385858f, -0.01630855f, -0.01365758f, 0.02046483f, -0.00467617f, 
    -0.03128770f, 0.00778338f, -0.00999371f, 0.00357603f, -0.00879495f, -0.02582628f, -0.02821054f, 0.02581612f, 
    -0.03107860f, -0.01963583f, -0.03322299f, 0.00018496f, -0.02564751f, -0.01789853f, -0.01748487f, -0.03816415f, 
    -0.02160721f, -0.01171554f, 0.00364353f, 0.01837182f, -0.01465809f, -0.03636478f, 0.02649442f, -0.01961740f, 
    -0.01559765f, -0.02278067f, 0.02124842f, -0.00900710f, -0.02111246f, -0.00319240f, 0.01700500f, -0.02852814f, 
    0.00017423f, 0.01856200f, -0.01554533f, -0.01531342f, 0.02772878f, 0.00807474f, -0.01072950f, 0.00086996f, 
    0.02212948f, -0.01678940f, -0.01297578f, -0.00564588f, -0.02974898f, -0.02485877f, 0.01914972f, 0.02416416f, 
    -0.00884800f, -0.01105598f, -0.01443691f, 0.00277894f, 0.02533354f, -0.04045174f, -0.02191142f, -0.01420773f, 
    -0.03012395f, -0.02912328f, 0.02919683f, -0.04100950f, 0.01629559f, -0.02518279f, 0.03530005f, 0.00080838f, 
    0.00826095f, -0.03212296f, -0.04000414f, 0.01190392f, -0.02321643f, 0.00681365f, -0.02940508f, -0.02727054f, 
    -0.03726085f, 0.00876985f, -0.04027238f, -0.03409654f, 0.00541194f, 0.00224972f, 0.02635471f, -0.02993968f, 
    -0.02184702f, -0.00632449f, 0.01278135f, -0.00321918f, 0.01616115f, -0.02410736f, -0.04076000f, 0.00983545f, 
    0.01978113f, 0.01897333f, -0.01470787f, 0.02332946f, 0.02939376f, -0.02376497f, 0.02161852f, -0.02769499f, 
    -0.02831668f, -0.01881210f, -0.02224909f, 0.00484390f, 0.02619842f, -0.00637011f, -0.01995873f, -0.03564251f, 
    0.01900746f, -0.01377709f, 0.02262849f, -0.01170235f, -0.01967753f, -0.00973064f, 0.01082464f, -0.01688967f, 
    0.03323152f, -0.03125368f, -0.03412133f, 0.00245712f, 0.00114941f, 0.01092372f, 0.00090207f, -0.02622484f, 
    0.00673757f, 0.01921668f, -0.01314813f, 0.02143977f, 0.01710384f, 0.02744507f, 0.01656516f, -0.02160145f, 
    -0.01178076f, -0.00002008f, -0.00364336f, 0.00919252f, 0.01279312f, 0.02145492f, 0.02723592f, -0.00419130f, 
    0.01937042f, -0.03119070f, 0.01355412f, -0.02172217f, 0.01133114f, 0.02799428f, 0.02741113f, 0.01615518f, 
    0.02060142f, -0.02367445f, 0.02523478f, -0.00428620f, -0.04149726f, -0.01579937f, -0.03166325f, 0.01713888f, 
    0.00505740f, -0.00402294f, 0.01750434f, -0.00449933f, 0.00192375f, -0.01034759f, 0.01614218f, -0.02645381f, 
    0.00245789f, 0.00944754f, -0.01498521f, -0.00514304f, -0.00745040f, -0.02794579f, -0.02290703f, 0.00335867f, 
    -0.02794430f, -0.01479344f, -0.04052657f, -0.01659571f, -0.02963127f, 0.01049097f, 0.02066768f, -0.01230700f, 
    -0.04147181f, -0.00928143f, -0.03569386f, -0.04064921f, 0.01797067f, 0.02196078f, 0.02554684f, -0.02514986f, 
    -0.01616949f, 0.01712142f, -0.02917244f, -0.02223141f, 0.02690947f, -0.03215491f, -0.02835615f, -0.02116792f, 
    -0.03420952f, -0.01039632f, -0.04144254f, 0.00035829f, 0.00953717f, -0.02210305f, -0.04000430f, -0.01483908f, 
    -0.01939070f, 0.02815328f, 0.00967225f, 0.02821732f, 0.02900654f, -0.00681535f, -0.00477717f, 0.02636743f, 
    0.01428235f, -0.01813640f, -0.01365002f, -0.02322430f, -0.00642715f, -0.03541685f, 0.01887461f, 0.02656002f, 
    0.03580625f, -0.00732396f, -0.01211349f, 0.02377048f, -0.03737184f, -0.01740205f, 0.00190027f, -0.01060224f, 
    -0.01092106f, 0.00964609f, 0.00175445f, -0.03668234f, -0.03704853f, -0.03795132f, -0.01499317f, -0.00771074f, 
    0.01737865f, 0.00583276f, -0.03272673f, 0.02243197f, -0.03987537f, -0.04052849f, -0.00221600f, -0.00268185f, 
    0.00590393f, -0.02240305f, -0.02765287f, 0.00297311f, 0.01449341f, -0.02666073f, 0.00795360f, -0.00985769f, 
    -0.02449192f, 0.02414031f, 0.00750935f, -0.02342251f, 0.01752522f, -0.02128688f, -0.01363216f, -0.01359098f, 
    -0.03450834f, -0.03616673f, 0.01058738f, -0.01944350f, -0.00014335f, 0.02165706f, 0.00553977f, 0.01554922f, 
    0.00679936f, -0.02923150f, -0.01522543f, 0.00370273f, 0.02462770f, -0.02284708f, -0.01077844f, -0.04034622f, 
    -0.02466847f, -0.02831688f, 0.00280944f, -0.03824653f, 0.02617897f, -0.02059000f, 0.02952649f, -0.02087975f, 
    -0.03515359f, -0.02610456f, 0.02362827f, -0.03853900f, 0.01670353f, 0.00710526f, 0.00052631f, 0.02654116f, 
    -0.02271182f, -0.01201531f, -0.03099791f, -0.00633374f, 0.02655722f, 0.02966691f, -0.01874642f, 0.00737603f, 
    -0.00695811f, -0.01007933f, 0.01130302f, -0.01107840f, 0.00975136f, 0.01767431f, 0.00264608f, -0.01796702f, 
    -0.02864144f, 0.02807363f, -0.04183571f, -0.02303912f, -0.00914530f, 0.01278792f, -0.03718143f, 0.01126870f, 
    -0.03491705f, 0.01885252f, -0.01323851f, -0.03674636f, -0.02314157f, -0.01135708f, 0.01557844f, 0.02271531f, 
    0.00536827f, -0.01899152f, 0.02031592f, -0.03800193f, -0.02335805f, -0.02034466f, -0.00544795f, 0.00728656f, 
    0.03342411f, -0.01981374f, 0.00984166f, -0.01764242f, -0.00703334f, -0.03173235f, 0.02234146f, -0.00439458f, 
    0.00176988f, 0.03304848f, -0.02920341f, -0.03471052f, -0.01938358f, -0.00496986f, 0.00692358f, 0.02531809f, 
    -0.03183756f, 0.02954062f, -0.02027807f, -0.03730359f, -0.03305046f, 0.01509149f, 0.01296991f, -0.02365621f, 
    -0.02246946f, 0.00978776f, -0.01851156f, 0.01090421f, -0.01661350f, 0.03088634f, 0.02167623f, -0.03604852f, 
    0.01057496f, -0.02870064f, 0.01925256f, 0.02690568f, 0.01166402f, -0.02568289f, -0.00965880f, 0.00962944f, 
    0.02509237f, 0.02229518f, -0.01066524f, 0.02261612f, 0.02483963f, 0.02531102f, -0.03395798f, -0.03674140f, 
    -0.00203050f, -0.01080028f, -0.01468687f, -0.00528134f, -0.01313807f, -0.01798612f, -0.00837648f, -0.00271345f, 
    -0.02211807f, -0.03424361f, -0.00261786f, -0.02749183f, -0.00852250f, 0.01237603f, -0.03965611f, 0.01659717f, 
    -0.02709254f, -0.00971153f, -0.02922387f, -0.04069690f, 0.02843469f, 0.01545770f, 0.00738375f, -0.01161220f, 
    -0.01429264f, 0.01379401f, 0.01397210f, 0.02525086f, -0.03945025f, -0.01682555f, -0.00419727f, 0.00521723f, 
    0.00524311f, 0.01775134f, -0.03403241f, 0.02553909f, 0.00499527f, -0.03872320f, -0.00042590f, -0.03771329f, 
    -0.03734750f, -0.01464033f, -0.00309503f, -0.01341961f, -0.02250641f, -0.01489040f, 0.01128212f, 0.00928684f, 
    -0.02870076f, 0.00512088f, 0.02224414f, -0.03291028f, 0.00219492f, -0.03615871f, 0.01240913f, 0.02486693f, 
    0.02875831f, 0.01372192f, 0.01266824f, -0.01098080f, 0.02350569f, 0.01219776f, -0.04175543f, -0.03236375f, 
    0.04919681f, 0.02509107f, -0.04937228f, 0.01776609f, 0.00735217f, 0.01822230f, 0.19342397f, 0.01300974f, 
    -0.05651225f, -0.06540095f, -0.02183469f, 0.04028122f, 0.01354351f, -0.11553878f, 0.22214046f, 0.13124681f, 
    0.02107767f, -0.07344023f, 0.06239309f, 0.03818961f, 0.16128848f, 0.03308758f, 0.00784542f, 0.01885866f, 
    0.07175872f, -0.09149030f, 0.09383114f, 0.05515256f, 0.16239029f, -0.09311382f, 0.02909422f, 0.19373560f, 
    -0.03897501f, -0.14770046f, -0.07279566f, 0.12188855f, -0.30006444f, -0.09078574f, 0.30169332f, -0.12394729f, 
    0.00564210f, -0.14251968f, 0.05741724f, 0.08579456f, 0.10133602f, 0.03392867f, -0.02877340f, 0.14705883f, 
    -0.01065448f, -0.04079012f, -0.21991585f, -0.03163412f, 0.01154580f, 0.04325020f, -0.01422827f, 0.04019260f, 
    -0.01732138f, -0.17765601f, 0.01251656f, 0.04179113f, -0.07506620f, 0.11009453f, 0.14770092f, 0.21463174f, 
    -0.02353642f, 0.09601878f, 0.00119550f, 0.07897324f, 0.10959926f, -0.05615849f, -0.06947437f, -0.06731022f, 
    0.04051826f, -0.08318079f, 0.01637094f, -0.11862223f, -0.06372724f, -0.04536134f, -0.05459091f, 0.03595535f, 
    -0.02102032f, -0.09034751f, -0.12296069f, -0.15595484f, 0.12922952f, 0.02659244f, 0.05820773f, 0.09104444f, 
    0.16614690f, 0.12212580f, -0.04851425f, -0.20502225f, -0.07082151f, -0.03543907f, 0.02892874f, 0.22976027f, 
    -0.17878610f, 0.16410081f, 0.11311676f, 0.11101460f, 0.00919867f, 0.07261158f, 0.10975221f, 0.06498222f, 
    -0.15246965f, -0.02686813f, 0.12793881f, -0.08244975f, -0.14145808f, -0.14168882f, 0.02294470f, 0.05406612f, 
    0.20821056f, 0.03123995f, 0.03548900f, -0.14620736f, 0.06416867f, -0.12192520f, -0.05019269f, -0.01095633f, 
    0.30175117f, -0.08088963f, 0.03901044f, -0.02290378f, 0.08848739f, 0.00768741f, -0.13189702f, -0.08294414f, 
    0.11067823f, -0.01792866f, 0.00153255f, -0.05221296f, -0.01598432f, 0.06613644f, -0.08570137f, 0.20543285f, 
    0.18018679f, 0.00950927f, 0.05807307f, 0.02793912f, -0.01717985f, -0.03990339f, -0.01367117f, 0.10460265f, 
    0.13511160f, -0.15379030f, -0.16120414f, -0.19377260f, -0.02454418f, 0.05128045f, -0.05867881f, 0.17959870f, 
    -0.02093830f, -0.03231662f, -0.02517287f, -0.04436409f, 0.05100151f, -0.10651489f, -0.03900914f, -0.03930807f, 
    -0.06229689f, 0.05499244f, -0.07629810f, -0.08780549f, 0.15555717f, 0.04778062f, 0.16567329f, 0.03657906f, 
    -0.16582663f, -0.05625353f, -0.03759995f, 0.02136304f, -0.05247319f, -0.17555957f, -0.03983740f, -0.08702871f, 
    0.00141998f, -0.00381803f, 0.15599231f, 0.04407855f, 0.01565922f, 0.31049845f, -0.05885467f, 0.14417374f, 
    -0.02932868f, 0.05233337f, 0.01678997f, 0.12937504f, 0.01344856f, -0.07091006f, 0.00196158f, -0.02322655f, 
    0.00232245f, -0.02516694f, -0.02026148f, -0.09247246f, 0.07954162f, -0.03317191f, -0.05631137f, 0.02805720f, 
    0.15099277f, 0.11909912f, 0.10096314f, 0.11121890f, 0.09863815f, -0.05243894f, -0.08190473f, -0.12196865f, 
    -0.01385238f, -0.00361714f, -0.10831364f, -0.00954885f, 0.10818532f, 0.12485094f, 0.12988637f, 0.01552271f, 
    -0.04694929f, -0.05131138f, 0.02261864f, 0.14734252f, 0.02561822f, -0.09492040f, -0.03920165f, 0.07107395f, 
    0.14047304f, 0.09529830f, -0.01520751f, 0.05149496f, 0.04458581f, 0.14737409f, -0.23852058f, 0.03423530f, 
    -0.02129634f, -0.08052448f, 0.01767318f, 0.15336600f, 0.07250902f, 0.05969854f, 0.15829757f, -0.04618161f, 
    0.22287372f, 0.10639399f, -0.11842848f, 0.14281093f, 0.11223819f, -0.01927412f, 0.01651900f, -0.03356121f, 
    0.05637953f, -0.00693292f, -0.02597029f, -0.06479938f, -0.27634925f, 0.09702235f, 0.04679106f, -0.10507920f, 
    -0.01906639f, -0.05517770f, 0.07138108f, 0.02265250f, -0.10860131f, -0.00210386f, 0.02426936f, 0.06462116f, 
    -0.16170707f, 0.09210909f, 0.15258446f, 0.08198229f, -0.15289411f, -0.05051307f, 0.00585975f, 0.03120017f, 
    -0.03071904f, 0.10972536f, 0.01292878f, -0.02166413f, 0.32978779f, 0.01926254f, -0.07597069f, -0.07338376f, 
    0.07201124f, 0.06911842f, 0.10216462f, -0.08313617f, -0.05470993f, 0.08237062f, 0.03768082f, -0.01997942f, 
    -0.00725313f, -0.02514849f, -0.07784291f, -0.06795503f, -0.01053130f, 0.01276872f, 0.07471056f, 0.17001635f, 
    0.09054219f, -0.00072495f, 0.05072095f, 0.00709235f, -0.00199117f, -0.01511713f, 0.18205033f, 0.39791700f, 
    0.02346083f, 0.20533915f, 0.05243944f, -0.12022295f, 0.08192247f, -0.09811521f, -0.07041015f, -0.06003048f, 
    -0.24095339f, 0.29137361f, 0.16807494f, 0.00114196f, -0.07775090f, 0.08599035f, 0.00281590f, -0.06127917f, 
    0.07656007f, 0.09190889f, 0.11767325f, 0.06171323f, -0.32729724f, -0.03986842f, -0.04140043f, 0.12561533f, 
    0.01933730f, -0.10581139f, -0.04056736f, -0.01577079f, 0.08850843f, 0.03816393f, -0.02388994f, 0.05255994f, 
    0.00380020f, -0.03704521f, -0.04786550f, 0.04606246f, 0.08308899f, 0.01211137f, -0.03418621f, 0.10341412f, 
    -0.03865061f, 0.05367270f, -0.10722604f, -0.04788058f, 0.11570922f, 0.42404738f, 0.07019195f, 0.05093940f, 
    0.10784072f, 0.00998845f, 0.09798285f, 0.02230450f, 0.06251401f, -0.09535571f, 0.01729195f, 0.04468649f, 
    -0.04445100f, 0.01195567f, -0.23592250f, -0.10302817f, -0.03460568f, -0.12672766f, -0.04525305f, 0.07898799f, 
    -0.01208702f, 0.16286927f, -0.06043874f, 0.01726186f, 0.43830141f, -0.06888423f, -0.04706847f, -0.00706043f, 
    -0.02392948f, -0.02216591f, -0.08521637f, -0.03623221f, 0.00088592f, -0.06155305f, 0.15193604f, -0.11077862f, 
    -0.31443143f, -0.20605178f, 0.05380474f, 0.13215740f, 0.06548578f, -0.07910235f, 0.03663510f, 0.07237325f, 
    -0.12758327f, -0.06108752f, 0.01489939f, 0.05963537f, -0.08726399f, 0.04019466f, 0.14117393f, 0.09003878f, 
    -0.05677505f, 0.03229470f, 0.07020654f, -0.00614796f, -0.01830988f, 0.01813498f, 0.16755579f, -0.00442456f, 
    -0.09100263f, -0.02298715f, -0.17508043f, -0.01305068f, -0.05678498f, -0.11507212f, 0.03524101f, -0.00275229f, 
    -0.00581787f, 0.11034553f, -0.11834832f, -0.06489353f, -0.14259474f, -0.02182902f, 0.10183623f, -0.01377675f, 
    -0.02300703f, -0.11491629f, -0.01995183f, -0.00683524f, 0.24462463f, -0.01918536f, 0.01693525f, 0.06586712f, 
    -0.26575544f, -0.06233769f, 0.11811440f, 0.00088594f, -0.03767410f, -0.18604615f, 0.06969751f, -0.03236088f, 
    -0.04940316f, 0.09228516f, 0.09817671f, -0.13702323f, 0.31739360f, -0.15882090f, -0.09341148f, 0.05719958f, 
    0.02758474f, -0.05672406f, -0.03091468f, 0.10074548f, 0.11676413f, -0.02735746f, 0.04115484f, -0.00130334f, 
    0.30968285f, 0.15525629f, -0.08066180f, -0.23182866f, -0.09295341f, -0.00990525f, -0.04829586f, 0.01640550f, 
    -0.07340631f, 0.04079638f, 0.11451706f, -0.02739718f, -0.00720493f, -0.20628422f, 0.02725085f, -0.20117986f, 
    -0.00268627f, 0.11624663f, 0.09297927f, 0.07668158f, 0.00811421f, 0.07267435f, 0.03003195f, 0.05761743f, 
    -0.04846351f, -0.16229887f, 0.11219153f, 0.07785544f, 0.09817054f, 0.06756275f, 0.09676324f, 0.04760114f, 
    -0.05580998f, 0.04117960f, -0.16744198f, -0.07041100f, -0.02892368f, -0.21056588f, 0.18646450f, 0.14467724f, 
    0.07870807f, -0.00151002f, -0.02299963f, 0.20797981f, -0.01945572f, 0.01814579f, 0.16608053f, 0.00788297f, 
    0.08619671f, 0.04570137f, -0.05444586f, -0.02755903f, -0.00183045f, 0.09518350f, -0.16444552f, 0.09769952f, 
    -0.17172006f, -0.08680882f, 0.06377973f, -0.00182262f, 0.07321989f, -0.06744777f, -0.01540865f, -0.21946926f, 
    0.01932087f, 0.19943875f, -0.11408400f, 0.04697960f, -0.17745882f, -0.06097683f, -0.01529362f, 0.04755057f, 
    0.29448387f, -0.00808798f, -0.00420772f, 0.17532648f, -0.01535607f, 0.00053512f, -0.04776737f, 0.10975810f, 
    -0.01427540f, 0.17765257f, 0.10136733f, 0.04668474f, -0.19254062f, 0.05644380f, 0.09672341f, -0.09568141f, 
    -0.14235081f, 0.02119169f, 0.00190050f, 0.08290142f, 0.09995072f, 0.01580920f, 0.00845618f, -0.00205301f, 
    0.09948648f, -0.11088365f, 0.10692655f, -0.08375599f, 0.03445704f, 0.09743305f, 0.04630147f, 0.06904560f, 
    0.05935995f, -0.08004850f, -0.06890399f, -0.07550722f, 0.45691383f, -0.04261858f, -0.27659822f, 0.19316541f, 
    0.00296427f, -0.10807877f, 0.19166198f, 0.23658900f, 0.02997218f, 0.00137483f, -0.03424298f, -0.06961224f, 
    0.39879486f, -0.01507636f, -0.22118950f, 0.01807351f, -0.02427085f, -0.03195580f, -0.08030815f, 0.10899700f, 
    -0.00404962f, 0.20532592f, 0.12662748f, 0.11472590f, -0.05451991f, 0.06889328f, 0.09858243f, -0.06969149f, 
    -0.02784012f, 0.00362826f, 0.05357512f, -0.03400149f, -0.05375761f, 0.07002507f, 0.00353237f, -0.07450534f, 
    -0.17268518f, -0.13249955f, 0.25410652f, 0.08888584f, 0.09442436f, 0.18500564f, -0.09198014f, -0.18232538f, 
    0.05832359f, -0.00921500f, 0.06237702f, 0.06560575f, -0.16362299f, -0.11981487f, -0.05947703f, 0.30806890f, 
    0.09714837f, 0.15971178f, -0.00712732f, -0.15837468f, 0.13840553f, -0.04082646f, 0.11189946f, 0.02055236f, 
    0.09587122f, -0.13441627f, 0.04550387f, -0.05434866f, -0.05061359f, -0.02651190f, 0.03807820f, 0.04330200f, 
    0.09476489f, -0.00864704f, -0.00711444f, -0.09438393f, -0.09569063f, 0.10915484f, 0.02647182f, 0.02658595f, 
    -0.09314369f, -0.01613434f, 0.11424296f, 0.08444376f, -0.00125265f, -0.08131458f, -0.09854704f, -0.16970327f, 
    -0.06488337f, -0.10756879f, 0.01405670f, 0.03361015f, -0.00994541f, 0.05198553f, 0.14209945f, -0.10216772f, 
    0.00243499f, -0.01516505f, -0.00765105f, -0.09195901f, -0.12900430f, -0.02456248f, -0.02318237f, 0.11913596f, 
    0.04464793f, 0.17869379f, 0.13461027f, -0.08477458f, 0.01886040f, -0.11212767f, 0.03375477f, -0.07038420f, 
    0.25123620f, 0.05144106f, -0.17311190f, -0.06406815f, 0.09111256f, 0.09394836f, 0.08288087f, 0.10068965f, 
    0.12310550f, 0.04370767f, 0.13694447f, -0.07085738f, -0.36969432f, -0.01045726f, 0.25498408f, 0.17836133f, 
    0.01804219f, 0.03583564f, -0.05460132f, -0.00364588f, -0.07585134f, 0.09307633f, 0.05481500f, 0.04758454f, 
    -0.05614263f, -0.09423480f, 0.07360111f, -0.20203291f, -0.03616778f, -0.06787135f, -0.14303595f, 0.00906771f, 
    -0.08240718f, -0.22612143f, -0.15184896f, -0.12657925f, 0.20986484f, -0.17311750f, -0.07698151f, 0.65027964f, 
    0.04578186f, -0.07167043f, 0.07300007f, -0.00691187f, -0.09337556f, 0.04122428f, 0.00544974f, 0.11847689f, 
    0.20928369f, -0.16548242f, -0.08414693f, -0.05522013f, 0.01007700f, 0.07181731f, -0.01502563f, -0.00021393f, 
    0.02672573f, -0.12409212f, 0.08582814f, 0.02848262f, -0.14590202f, 0.10631485f, -0.11478468f, 0.08589205f, 
    0.08075606f, 0.04073385f, -0.00468051f, -0.13299590f, 0.10966828f, 0.07723381f, -0.07797235f, 0.08800786f, 
    -0.02351932f, -0.15991391f, 0.03986599f, -0.02678821f, 0.20377342f, -0.09798476f, 0.07419089f, -0.10264099f, 
    0.02276336f, -0.02946765f, -0.13554484f, -0.03366415f, -0.10146474f, 0.05500037f, 0.45190173f, -0.11001425f, 
    0.16458328f, 0.06796853f, 0.10938464f, -0.05571910f, 0.14083751f, -0.03364993f, 0.07319207f, 0.08019418f, 
    0.04603021f, -0.02336078f, 0.11489707f, -0.00571902f, 0.10959231f, -0.11121036f, -0.19993426f, -0.05337548f, 
    0.03649012f, 0.01225093f, 0.01743289f, 0.03193260f, -0.07137260f, -0.01728892f, -0.33584660f, 0.15887336f, 
    0.07896776f, 0.02372450f, 0.04077808f, -0.13944753f, -0.11418866f, 0.04260590f, 0.09408251f, 0.00308291f, 
    0.20588984f, -0.04153183f, 0.05955254f, -0.05605147f, 0.10497238f, 0.08543760f, -0.02107251f, -0.11120668f, 
    -0.00175673f, 0.06385820f, 0.06778358f, -0.10531704f, -0.02790622f, 0.04006565f, -0.15761198f, 0.20289661f, 
    -0.06050869f, 0.09267666f, 0.05159636f, -0.01535275f, 0.08907770f, 0.06970990f, 0.08574080f, -0.06346878f, 
    0.09868171f, -0.06641719f, 0.05495044f, -0.02905428f, -0.10738764f, -0.03638086f, 0.05636611f, -0.00751014f, 
    -0.05085051f, 0.14151572f, -0.14857340f, -0.16217528f, -0.09280923f, -0.09360474f, 0.12502560f, -0.01573725f, 
    -0.10210440f, 0.00114584f, -0.06154902f, 0.09382340f, -0.11377417f, 0.01342870f, -0.00729387f, -0.03964714f, 
    0.06189853f, 0.05442919f, -0.12508686f, -0.01691891f, 0.00605549f, 0.02214297f, 0.03566768f, -0.12946302f, 
    0.01205139f, 0.13044472f, -0.03864869f, 0.00250464f, -0.26062635f, 0.19957522f, 0.08237664f, 0.26167762f, 
    -0.10144563f, 0.10231982f, 0.21327715f, 0.17542996f, 0.14286824f, 0.14089893f, -0.10123485f, -0.19359931f, 
    0.04534557f, -0.10410245f, 0.11472502f, 0.07712865f, -0.04515660f, -0.14212157f, 0.05446590f, 0.05485141f, 
    0.03473255f, -0.04998495f, -0.11135031f, 0.13903138f, 0.07134064f, 0.22034220f, 0.20143351f, 0.25204122f, 
    -0.10971542f, 0.04995556f, 0.11753189f, 0.25778589f, 0.01279879f, 0.09754916f, 0.02523179f, -0.02087440f, 
    -0.08561534f, 0.08432372f, 0.08693335f, 0.31390068f, -0.19942287f, -0.07976752f, 0.13238299f, 0.16620791f, 
    -0.12846921f, -0.06577398f, -0.08957681f, -0.03674642f, 0.12134918f, 0.12582184f, 0.14856873f, 0.06407988f, 
    -0.13861364f, 0.09343900f, -0.07756181f, 0.07935345f, -0.09183618f, 0.03003963f, -0.08711252f, -0.14619249f, 
    0.04854856f, 0.11328405f, 0.07557670f, 0.13226902f, 0.13829172f, 0.00634723f, 0.04630329f, -0.14398131f, 
    -0.09738828f, -0.03526876f, 0.14113070f, -0.01125449f, -0.05018837f, 0.12384623f, 0.02352625f, 0.12999205f, 
    -0.00210646f, -0.02777956f, 0.03350111f, -0.04487071f, -0.04863469f, 0.08388183f, -0.09827671f, 0.09315212f, 
    0.29639900f, 0.08606490f, 0.12660070f, 0.02388646f, 0.12131721f, 0.07696932f, 0.15407513f, 0.06093475f, 
    -0.03890085f, 0.01908465f, -0.11115599f, 0.01236452f, -0.06656772f, -0.18871719f, 0.33847731f, -0.05325843f, 
    0.00883000f, -0.07064904f, 0.04558127f, -0.10201897f, -0.05279068f, 0.07055017f, 0.00730735f, 0.02278945f, 
    -0.06677689f, 0.08278587f, 0.00437489f, 0.28104171f, -0.04857105f, 0.05539318f, -0.05294531f, -0.22096466f, 
    -0.04474579f, -0.00927192f, -0.10222673f, 0.00643184f, -0.10961970f, -0.07457891f, 0.14866379f, 0.02807741f, 
    -0.01928012f, -0.01016748f, 0.04276285f, -0.10657906f, -0.05116367f, 0.00632201f, 0.05886289f, 0.11788697f, 
    -0.07262066f, 0.00910187f, 0.05980362f, 0.07335857f, 0.04135007f, -0.00324243f, 0.05689176f, 0.08946571f, 
    -0.04044794f, 0.03032106f, 0.12441926f, -0.03137644f, -0.28218651f, -0.10668544f, 0.12262779f, 0.18513896f, 
    0.10527621f, 0.05987303f, -0.20656887f, -0.19335885f, 0.03450461f, -0.01323600f, -0.13771483f, 0.19204895f, 
    0.02157857f, -0.09719393f, 0.12954371f, 0.12400158f, -0.16090266f, 0.06915706f, -0.01764044f, 0.07793843f, 
    -0.06810148f, -0.01507667f, 0.02782816f, -0.11643294f, 0.13641569f, 0.00754355f, 0.26262152f, 0.14740434f, 
    -0.02062177f, 0.02386451f, -0.07304307f, 0.03805112f, 0.09523206f, -0.09560393f, -0.07904882f, -0.07560657f, 
    0.09813172f, -0.09539161f, 0.00460596f, -0.05822242f, 0.11011998f, -0.05267298f, 0.06421781f, -0.00194894f, 
    0.10189641f, -0.01525549f, -0.01184931f, 0.04466433f, 0.06355791f, -0.08191010f, 0.00793682f, 0.01102709f, 
    0.03068435f, -0.13605939f, -0.02100167f, -0.00381053f, 0.10988984f, 0.10610895f, 0.03966977f, 0.09380797f, 
    -0.15019575f, 0.09437795f, 0.07862937f, 0.02454948f, 0.03566498f, -0.10353689f, -0.08759087f, -0.01303094f, 
    -0.10773272f, 0.03969074f, 0.00950677f, 0.13528025f, 0.02317774f, 0.11832908f, -0.02411632f, 0.06830187f, 
    -0.13041040f, -0.24159350f, -0.02969755f, 0.12237074f, -0.05625270f, -0.00287400f, -0.06622402f, -0.02381270f, 
    0.17337348f, -0.10731724f, 0.17248367f, -0.01626069f, -0.01987484f, 0.12488748f, -0.03944834f, 0.06432742f, 
    -0.10249852f, -0.09478441f, -0.05816780f, -0.04502259f, 0.18910457f, 0.18482670f, -0.06747134f, 0.05489245f, 
    0.06761374f, -0.03743219f, 0.04273133f, -0.18586595f, -0.08366298f, 0.02257851f, -0.04221150f, -0.03548527f, 
    0.19923586f, 0.35161287f, 0.20953090f, -0.09917750f, -0.00541516f, 0.04708872f, 0.08350093f, -0.01813605f, 
    0.07251845f, 0.00598729f, 0.12543260f, 0.04894802f, -0.05355405f, -0.22049040f, 0.32218125f, -0.12498857f, 
    -0.12724540f, 0.04568532f, 0.13361374f, 0.04333661f, -0.21925271f, 0.11597236f, 0.03534879f, -0.00054196f, 
    -0.22441444f, -0.16000436f, 0.07330165f, 0.01871452f, -0.12863313f, 0.11671632f, 0.09796369f, -0.12002309f, 
    0.14665756f, 0.01256189f, 0.01117698f, -0.07878847f, -0.19213150f, -0.13696711f, -0.10395664f, 0.28835717f, 
    -0.06067747f, -0.06724841f, 0.08221135f, -0.11683705f, 0.06266957f, 0.03917731f, -0.10530685f, -0.01112628f, 
    0.36389479f, 0.04476750f, 0.08180510f, 0.05166797f, -0.08514231f, -0.05794455f, 0.04058821f, -0.01182495f, 
    0.04346395f, 0.01787101f, 0.01954862f, -0.05285942f, 0.09651307f, 0.05747425f, 0.18273208f, -0.13866808f, 
    0.17865470f, -0.00025339f, 0.06926927f, 0.02762376f, -0.09815360f, 0.01545043f, 0.00491943f, 0.01011160f, 
    -0.19629718f, -0.03324419f, -0.10508119f, -0.04918285f, -0.00305645f, -0.04242259f, -0.13430661f, -0.02942583f, 
    0.09911202f, 0.02423446f, 0.09266970f, 0.27001584f, 0.13686423f, -0.01364229f, -0.26088655f, -0.02004750f, 
    0.02898703f, 0.00479634f, -0.04487871f, -0.11958118f, -0.24507642f, 0.07537655f, 0.02785575f, -0.10414823f, 
    0.44415811f, 0.14970013f, 0.01436565f, 0.20652449f, 0.01410527f, 0.01357023f, 0.01205336f, 0.17583266f, 
    -0.08303391f, -0.14436112f, -0.09372524f, 0.25769442f, -0.21763000f, -0.07551959f, -0.02739701f, -0.08125454f, 
    -0.11048658f, -0.02852472f, -0.01537569f, -0.11700796f, -0.00479242f, 0.18386917f, 0.03349923f, 0.02641892f, 
    -0.16876709f, -0.28178865f, -0.05831568f, 0.04936548f, 0.04651279f, 0.04069592f, -0.05549483f, -0.03612450f, 
    0.10542484f, -0.02821085f, -0.13122013f, 0.02385071f, -0.01775882f, 0.04772356f, -0.08495256f, 0.17452888f, 
    0.12904508f, -0.02581864f, -0.04158048f, -0.07670439f, -0.09799315f, -0.14150740f, -0.14019962f, -0.04325682f, 
    -0.09575838f, 0.28354871f, -0.09122232f, 0.13088198f, -0.05444764f, 0.01063762f, -0.01610425f, 0.02143119f, 
    0.03239235f, -0.05951135f, 0.11819629f, 0.01835004f, -0.23367661f, 0.16329496f, -0.18162943f, 0.07685301f, 
    0.05813540f, -0.11976119f, -0.05911284f, -0.06902930f, -0.00653276f, 0.00748358f, -0.20412242f, 0.03894952f, 
    0.10841555f, -0.13917284f, 0.14473197f, -0.07002686f, -0.06962076f, -0.03582926f, 0.16420026f, -0.07845201f, 
    0.11963609f, 0.07288852f, -0.09757810f, -0.10955580f, 0.04945770f, 0.03468769f, -0.15047835f, 0.03771300f, 
    0.09560958f, -0.13754018f, 0.08887977f, 0.00081027f, 0.09753244f, 0.02708190f, 0.03163234f, -0.16150649f, 
    -0.15903898f, 0.04355911f, -0.02788863f, -0.13791326f, -0.00120313f, 0.04919855f, -0.03788379f, -0.08220208f, 
    0.13334870f, -0.02821211f, -0.11984992f, 0.05267624f, 0.15348224f, 0.12653071f, 0.00377044f, 0.17845672f, 
    0.08364477f, -0.12244241f, -0.08817333f, -0.03543300f, -0.05728912f, -0.05335582f, 0.03796845f, 0.03256860f, 
    0.05471570f, -0.08934183f, -0.03508930f, 0.10342003f, 0.03211100f, -0.03145733f, -0.02785274f, -0.04969953f, 
    -0.14794669f, -0.08027948f, -0.03411554f, -0.12472020f, -0.49612939f, 0.22774838f, 0.42879972f, 0.25590774f, 
    0.00743595f, 0.19516854f, -0.05282275f, -0.19483627f, -0.05822323f, 0.05860278f, 0.02241913f, -0.04964184f, 
    -0.13512467f, -0.05633679f, 0.30524832f, -0.15018639f, -0.06022476f, 0.07932785f, -0.02382540f, -0.15016387f, 
    -0.01678180f, 0.01209715f, -0.02053885f, -0.04943768f, 0.15741913f, 0.03824195f, 0.25609654f, 0.07875387f, 
    0.03545998f, -0.04719575f, 0.01722572f, 0.19106199f, 0.10064200f, -0.05493701f, 0.00246961f, 0.01565963f, 
    0.08130741f, 0.13738786f, 0.00870536f, 0.08538336f, -0.04889439f, -0.05267575f, 0.13000399f, 0.33340782f, 
    -0.06726259f, -0.05595788f, -0.03276077f, -0.04805848f, 0.10462286f, 0.06153151f, 0.05151473f, 0.08725919f, 
    0.05771060f, -0.07409895f, 0.03894315f, 0.29905003f, -0.05335288f, 0.13068314f, 0.01160617f, 0.19166631f, 
    0.02593071f, 0.03573857f, -0.22966816f, 0.16178419f, 0.08203730f, 0.00063330f, 0.02665272f, -0.13609052f, 
    -0.08911452f, 0.09125751f, -0.04325329f, -0.07646340f, -0.11245626f, -0.07069394f, 0.07480370f, 0.09753865f, 
    0.06843112f, -0.06363992f, -0.02914646f, -0.11143727f, 0.03214807f, 0.13781637f, 0.06197911f, 0.20405197f, 
    -0.08027718f, 0.10225402f, 0.21873230f, 0.22152421f, -0.07101425f, -0.13797325f, 0.00066034f, 0.30439311f, 
    0.09270629f, 0.10061568f, 0.03748502f, 0.04236601f, 0.03976366f, 0.14516959f, 0.10166553f, 0.05922955f, 
    -0.11375384f, -0.18275219f, -0.06218854f, 0.20905907f, 0.01815215f, 0.04361504f, -0.05011135f, 0.02811122f, 
    -0.18363757f, 0.00791408f, 0.16500643f, -0.11898911f, 0.09760091f, -0.08451784f, -0.05678499f, -0.08820016f, 
    -0.11579427f, 0.05923430f, -0.05226194f, 0.18989274f, -0.18804860f, -0.31434399f, 0.01899775f, 0.14551584f, 
    0.02756802f, 0.06691641f, -0.05767697f, -0.01781468f, 0.26340285f, 0.00354179f, -0.04923555f, -0.00518452f, 
    -0.07531422f, 0.17887223f, -0.12363268f, 0.07654344f, 0.06567556f, -0.06496760f, 0.16559167f, -0.12353184f, 
    0.00857800f, 0.05404078f, -0.10454690f, 0.08582260f, -0.00688302f, 0.14419250f, 0.14766009f, -0.50207841f, 
    0.09186807f, 0.00399826f, -0.03451626f, 0.05875202f, 0.08424906f, 0.07534844f, 0.04751556f, -0.11613037f, 
    -0.09608939f, -0.10217911f, -0.02769577f, 0.13154799f, 0.08761815f, -0.10142472f, -0.14858603f, 0.15904430f, 
    -0.10073601f, -0.02649147f, -0.03726351f, -0.13917977f, 0.03627434f, -0.00975568f, 0.04951616f, -0.04914996f, 
    -0.16402583f, 0.06254216f, 0.01682092f, 0.09202976f, -0.10669056f, -0.02101221f, 0.03560358f, -0.00303098f, 
    0.20402187f, 0.18883114f, 0.10323385f, 0.20856957f, -0.25733742f, 0.01492576f, -0.08309880f, 0.26690948f, 
    -0.06245131f, -0.08276919f, 0.08436286f, 0.04018190f, 0.16678461f, 0.10065676f, 0.01511302f, 0.22309676f, 
    -0.14967667f, -0.03387463f, 0.04243085f, 0.17228493f, -0.10665078f, 0.08736291f, -0.15531521f, -0.03465699f, 
    -0.09068490f, 0.09957899f, -0.01893297f, -0.06824557f, -0.11155797f, -0.07546528f, -0.13607861f, -0.18717474f, 
    0.09464180f, -0.05918539f, 0.08185675f, 0.05864460f, -0.35855597f, -0.28027520f, -0.11675317f, 0.20645364f, 
    0.00039445f, 0.11049687f, -0.09195016f, 0.07806600f, 0.14654307f, -0.08537848f, 0.12489743f, -0.02073495f, 
    -0.65048712f, 0.13057341f, 0.24851792f, 0.00921689f, 0.03694474f, 0.02658562f, -0.07564355f, -0.01734990f, 
    0.15039290f, -0.08166227f, 0.02598431f, 0.06553521f, 0.09930885f, -0.02331143f, 0.11663631f, 0.08381318f, 
    -0.15619183f, 0.00583932f, -0.01248261f, -0.01934547f, 0.09705070f, 0.17272455f, -0.04932052f, 0.00556234f, 
    0.22575477f, -0.06404160f, -0.12124570f, 0.06500936f, 0.01664669f, 0.03377529f, -0.05084422f, 0.06332689f, 
    0.07605685f, 0.06788641f, 0.02619945f, 0.02945346f, 0.01988808f, -0.16372469f, 0.16978446f, -0.34932917f, 
    -0.04715752f, -0.15965497f, -0.01343039f, 0.03327538f, -0.03814981f, -0.04195840f, -0.00786403f, -0.08860682f, 
    0.13939103f, 0.01738014f, -0.06702964f, 0.16097201f, 0.10215169f, 0.05634923f, 0.00865745f, 0.02038512f, 
    -0.00754736f, -0.06045307f, -0.03657316f, 0.05676452f, -0.17891021f, -0.09543910f, -0.08585310f, -0.06498335f, 
    0.02400219f, 0.08199559f, -0.15312620f, -0.27281308f, 0.01688813f, -0.02981035f, -0.16443686f, 0.02672476f, 
    0.26295477f, -0.01421298f, -0.13006569f, -0.12523186f, 0.06830488f, -0.16812696f, 0.08520665f, -0.02423799f, 
    0.01786182f, -0.08937966f, -0.02928253f, -0.00555212f, 0.00107103f, 0.17381871f, 0.11033999f, 0.05476765f, 
    -0.18401518f, -0.15213697f, -0.04199641f, -0.01255222f, 0.02764625f, 0.01179737f, 0.01782490f, 0.06753233f, 
    0.43803447f, -0.26520023f, -0.20550948f, 0.18304907f, -0.08192809f, -0.07976302f, 0.10809195f, 0.02855268f, 
    0.10648404f, -0.08121271f, 0.04655150f, 0.03220395f, 0.27149394f, -0.01810854f, -0.24169619f, -0.25667077f, 
    -0.11117192f, -0.02766038f, 0.00731939f, 0.01690847f, 0.05624016f, 0.14857015f, -0.04806495f, 0.04953487f, 
    -0.02354087f, 0.04979914f, 0.05807431f, 0.11511581f, 0.12318164f, -0.02311850f, 0.05371810f, 0.11066995f, 
    -0.09706043f, -0.14292134f, -0.15284637f, -0.12645626f, 0.23510325f, -0.28714988f, -0.00480764f, 0.03042219f, 
    0.02810844f, 0.02523104f, 0.01695606f, 0.01143586f, -0.04740898f, 0.25155422f, -0.00579012f, 0.09703409f, 
    -0.11121048f, 0.19361332f, 0.12722564f, -0.19886096f, -0.01064899f, -0.00941845f, -0.08647313f, -0.00731612f, 
    -0.08706639f, 0.08186318f, -0.06051885f, -0.02857574f, 0.19572611f, 0.06819827f, 0.27042168f, -0.32994911f, 
    -0.07524811f, 0.03382039f, -0.02595700f, -0.00025747f, 0.04691114f, 0.18413642f, -0.02341605f, -0.01205138f, 
    -0.07682760f, 0.00307413f, 0.18919665f, 0.30716592f, 0.00903548f, 0.00593336f, -0.02394325f, -0.03665445f, 
    -0.00295272f, 0.20604788f, -0.08277039f, -0.09463083f, 0.25412241f, -0.16423297f, -0.11412841f, -0.02757976f, 
    -0.02377675f, 0.01667632f, 0.10487971f, 0.01537952f, 0.07832726f, 0.29008541f, 0.17318912f, 0.12515780f, 
    -0.02331291f, 0.01853841f, 0.10664658f, 0.01633645f, 0.09854372f, -0.05948876f, -0.02436869f, -0.10644910f, 
    -0.03690244f, 0.02632730f, 0.15854405f, -0.08662019f, -0.45648792f, -0.01422398f, 0.24845427f, 0.52108055f, 
    0.08344335f, -0.01978514f, -0.07529739f, 0.01822813f, -0.08081903f, 0.12189995f, 0.05032495f, -0.10590541f, 
    0.17881213f, 0.03814612f, -0.03985615f, -0.10686890f, -0.08425341f, -0.04411718f, 0.03608697f, 0.03609043f, 
    -0.01493285f, 0.04897569f, -0.05605472f, -0.01001241f, -0.04654641f, 0.24478580f, 0.20541908f, -0.12197334f, 
    -0.19482665f, 0.13204010f, -0.06784876f, -0.01074429f, -0.01696257f, 0.01153214f, -0.01985405f, 0.12297835f, 
    0.28967628f, 0.13522123f, 0.22607256f, -0.16584040f, -0.04670404f, -0.11049553f, 0.02412501f, -0.06009407f, 
    -0.05551921f, -0.02286690f, 0.11912291f, 0.15686138f, -0.36328134f, 0.04505736f, -0.17073341f, -0.22921848f, 
    0.03524841f, -0.12479735f, 0.06620031f, -0.08445522f, 0.02344338f, 0.05344703f, 0.11723144f, 0.10169519f, 
    0.26346308f, -0.12169928f, 0.07406485f, -0.17705126f, 0.07204729f, -0.00243808f, -0.05527949f, -0.17951393f, 
    0.06880360f, -0.01128560f, 0.21858428f, 0.28971711f, 0.20315953f, 0.14155635f, -0.12857047f, -0.16555026f, 
    -0.04120572f, -0.24409050f, -0.08889510f, 0.09412354f, -0.04257493f, -0.00590883f, -0.05309030f, -0.09078657f, 
    0.03849792f, 0.16615862f, 0.14962268f, -0.40375969f, -0.01768747f, -0.06093903f, -0.08223480f, 0.09186889f, 
    -0.01216155f, 0.02093296f, -0.04988326f, 0.18729128f, 0.10406683f, 0.01703626f, 0.06816453f, 0.17650524f, 
    -0.05952463f, 0.01703737f, 0.04290532f, -0.00816477f, -0.18937285f, 0.14222743f, -0.15936664f, -0.05908043f, 
    0.36267596f, 0.18706833f, -0.24164054f, -0.11793099f, -0.07756231f, 0.07549164f, 0.20663576f, 0.01920079f, 
    0.09001213f, 0.10807167f, 0.02869357f, 0.11184610f, 0.48293531f, 0.03672528f, -0.01727608f, -0.49943215f, 
    0.00513728f, -0.06248753f, 0.07643482f, 0.23806910f, -0.00543452f, 0.08549096f, 0.02462289f, -0.06910778f, 
    -0.01799090f, -0.11758721f, -0.01861696f, 0.17295061f, -0.06044327f, 0.11239732f, 0.03355370f, -0.02809238f, 
    0.20740825f, 0.16418095f, 0.02614343f, 0.07491454f, -0.09968416f, 0.01602333f, -0.10715143f, 0.14607760f, 
    -0.00074639f, -0.08874300f, 0.09925449f, 0.04386966f, 0.06509925f, 0.00243714f, 0.04388024f, -0.04814119f, 
    -0.22287220f, 0.18341881f, 0.09129030f, -0.22159888f, -0.11822163f, -0.02121782f, 0.04128084f, -0.03917198f, 
    0.00449886f, 0.01219071f, -0.06194577f, -0.02248836f, 0.15030710f, 0.10374501f, -0.01590832f, -0.30577651f, 
    0.03142306f, 0.01919062f, -0.00126886f, 0.02174156f, -0.03841570f, 0.04836725f, 0.08664748f, -0.04896129f, 
    0.04584996f, 0.05539608f, -0.03846186f, 0.01658680f, 0.04928162f, 0.02560011f, -0.05758372f, 0.00904373f, 
    0.16107258f, 0.07070622f, 0.11051130f, 0.04907583f, 0.27664277f, 0.02659976f, 0.20678943f, 0.14967437f, 
    -0.01240495f, -0.08616938f, -0.06101492f, 0.04760607f, -0.12779851f, -0.11229539f, -0.06637648f, -0.09192120f, 
    -0.17876466f, 0.08907112f, 0.08817279f, -0.11842949f, -0.03920724f, -0.04988606f, -0.03646677f, 0.13447289f, 
    -0.02164687f, 0.01081022f, -0.00040444f, -0.07512636f, 0.37012634f, -0.29112935f, 0.04802867f, 0.02647420f, 
    -0.00395908f, -0.03929114f, 0.05166250f, 0.08819762f, 0.13420403f, 0.06839911f, 0.19573379f, 0.10859514f, 
    -0.32329616f, -0.08041628f, 0.09500854f, 0.22881152f, 0.00836856f, -0.02445357f, -0.06158394f, 0.01291365f, 
    -0.06940690f, -0.00866756f, 0.04771305f, 0.11179537f, -0.02488089f, -0.04582569f, 0.06826908f, 0.07319355f, 
    0.18128087f, 0.01373958f, 0.09190063f, -0.03572347f, -0.00642555f, -0.05113601f, -0.06031884f, -0.01844052f, 
    0.06789747f, -0.11733212f, 0.00927607f, 0.07346936f, -0.04194348f, -0.00488751f, 0.12323663f, 0.00667695f, 
    0.10180958f, -0.08161529f, 0.03042245f, -0.00039455f, -0.18698826f, -0.21084403f, 0.13951176f, 0.34589389f, 
    0.10391831f, -0.07659137f, 0.00952254f, -0.12246801f, 0.10515354f, -0.04339689f, 0.12990564f, 0.14965881f, 
    -0.10572074f, 0.01900034f, -0.27980745f, 0.22892149f, 0.18867108f, 0.01719962f, -0.00434134f, -0.06620475f, 
    -0.03108470f, 0.06718195f, -0.07329571f, 0.08319995f, 0.02520684f, -0.01362301f, -0.05206884f, 0.04026028f, 
    -0.00952983f, -0.04059147f, 0.12980524f, -0.04151214f, -0.08485557f, -0.12004215f, -0.04216340f, -0.02638178f, 
    0.06169206f, 0.03825388f, -0.05338099f, 0.07911457f, 0.08514762f, 0.02138436f, 0.04028690f, 0.10989751f, 
    0.26465535f, -0.15381822f, 0.04494727f, 0.11235409f, 0.14096801f, 0.24679534f, 0.12204945f, -0.01004373f, 
    -0.10772703f, -0.06129986f, -0.04520112f, -0.09583502f, 0.13854854f, 0.07765709f, 0.03509179f, 0.13780645f, 
    0.07840616f, -0.00300068f, -0.03563162f, 0.07345170f, -0.03745956f, 0.07868063f, 0.08432914f, 0.06028950f, 
    -0.05444091f, -0.06668245f, -0.03198801f, -0.04075336f, 0.16326214f, 0.01891494f, 0.03353843f, -0.03402916f, 
    -0.07543427f, 0.01224101f, -0.04477899f, 0.20529591f, 0.04856759f, 0.01312913f, 0.14217602f, -0.04680425f, 
    -0.15962714f, -0.06913050f, -0.13775267f, -0.11696348f, 0.12484898f, -0.17907950f, 0.06382610f, 0.13173968f, 
    0.02774414f, 0.11405519f, 0.05807030f, 0.05573560f, -0.17185615f, 0.16702072f, -0.03320979f, -0.15936860f, 
    -0.00142162f, -0.06230335f, -0.13746743f, 0.03445816f, 0.23516354f, 0.09446761f, -0.15446790f, 0.09701807f, 
    0.04609063f, -0.09935719f, 0.10073559f, -0.15985130f, 0.17372720f, -0.08090025f, 0.16339743f, 0.04588810f, 
    -0.01688559f, -0.03236375f, 0.00392548f, -0.02854403f, 0.21066900f, -0.11018718f, -0.20194983f, -0.26939616f, 
    -0.00628667f, -0.02886206f, 0.09643768f, -0.00887170f, 0.01115339f, 0.11901677f, 0.02848120f, -0.02309155f, 
    0.19716179f, 0.06535467f, -0.03213561f, 0.04074066f, 0.09347364f, -0.04971195f, 0.02461637f, -0.00850771f, 
    0.07765411f, -0.02669707f, 0.01024900f, -0.02092867f, 0.01637992f, 0.20995833f, 0.14413528f, -0.01807915f, 
    -0.09273130f, -0.12160214f, -0.22804755f, 0.04781265f, 0.16208240f, 0.24039322f, 0.13001353f, 0.04773007f, 
    0.09455168f, 0.18314774f, 0.09911628f, 0.01651264f, -0.11023143f, -0.07749370f, -0.11974391f, 0.13144837f, 
    -0.02697540f, -0.01343902f, -0.05736104f, -0.03001240f, 0.19059755f, 0.31188795f, 0.20295684f, -0.04704269f, 
    -0.05211508f, -0.17756735f, 0.00229418f, 0.11569120f, 0.00306074f, -0.02023756f, 0.02657398f, -0.03140266f, 
    -0.15381561f, 0.23921233f, -0.12378935f, -0.18090788f, -0.03984742f, 0.14418559f, -0.08349176f, 0.04472255f, 
    0.01963482f, 0.22211777f, 0.05806218f, 0.00260859f, 0.06478334f, -0.20602135f, 0.17826897f, 0.18319549f, 
    0.04396172f, -0.03752601f, -0.03914503f, -0.11682887f, 0.14859928f, 0.09886004f, 0.10123781f, 0.00005767f, 
    0.14536175f, 0.00260410f, -0.04012726f, 0.23481740f, 0.02872968f, 0.02923825f, -0.00865247f, 0.00392663f, 
    0.04108530f, -0.09541366f, -0.01649402f, 0.02142831f, -0.71851319f, 0.07869160f, 0.04201278f, 0.09316633f, 
    0.15917513f, 0.00878949f, 0.05070354f, -0.09676009f, 0.05235090f, 0.04622984f, 0.01930342f, 0.06820138f, 
    -0.05783952f, 0.06926829f, 0.04395894f, -0.02977639f, 0.13228287f, -0.09006431f, -0.06667925f, 0.16958463f, 
    -0.06439964f, -0.13818045f, -0.15550005f, -0.11127347f, 0.20759961f, -0.13167292f, -0.05071832f, 0.19586407f, 
    0.03573088f, 0.07918426f, -0.01019888f, -0.10035662f, 0.11865722f, 0.11155529f, -0.09007529f, 0.10880217f, 
    -0.09278791f, 0.06111996f, 0.00398004f, -0.16641636f, 0.04444920f, -0.00481253f, -0.03041090f, 0.00825882f, 
    0.02626688f, -0.06240357f, -0.07474647f, 0.01686045f, -0.02409894f, 0.26675802f, -0.15549366f, -0.22848946f, 
    0.01912394f, 0.03005198f, 0.17068785f, 0.17355292f, 0.22906427f, -0.16608383f, 0.06750882f, -0.06679407f, 
    -0.13509698f, -0.08233906f, -0.08931626f, -0.04041911f, -0.02046395f, 0.00751515f, -0.02884482f, 0.14892231f, 
    0.06244056f, -0.12153061f, 0.00283663f, -0.19244486f, -0.26586998f, -0.01684828f, 0.09264708f, 0.04566911f, 
    0.02724877f, 0.09450828f, -0.10778968f, 0.27239883f, 0.11714703f, -0.07682256f, -0.01651096f, 0.05939448f, 
    -0.47550905f, 0.27230564f, 0.02768477f, -0.12366338f, -0.24576759f, 0.06478689f, 0.08167934f, -0.01884503f, 
    0.12355589f, -0.01932397f, -0.03166244f, 0.08112556f, 0.22403239f, 0.10854760f, 0.06826065f, -0.05623653f, 
    -0.01064790f, 0.11412213f, 0.01202453f, 0.11392416f, 0.06486216f, 0.02385220f, -0.05298561f, -0.06479596f, 
    -0.23701990f, -0.11001801f, 0.18823273f, -0.05685606f, 0.12802388f, 0.06612664f, -0.08276194f, -0.02450721f, 
    -0.04054253f, -0.00220383f, 0.12126962f, -0.11022085f, 0.07788614f, -0.15218750f, -0.03515537f, -0.22613887f, 
    0.22740425f, -0.01744927f, 0.22472812f, 0.04159527f, 0.03775243f, 0.11948898f, 0.10903465f, 0.13601838f, 
    -0.17870182f, -0.13456069f, -0.15857254f, 0.10884281f, -0.10072383f, -0.08692824f, -0.00920331f, -0.12908062f, 
    -0.09992135f, -0.11900306f, 0.01551289f, -0.01343411f, 0.01842237f, -0.12168089f, 0.07804912f, -0.19548289f, 
    0.09995385f, 0.00905142f, -0.02557206f, 0.05884177f, 0.12028550f, -0.07893027f, 0.23354335f, 0.04803901f, 
    0.28581294f, -0.08956872f, -0.12267879f, 0.06434388f, 0.24577986f, 0.10919041f, 0.05190019f, 0.18868072f, 
    0.06768941f, 0.10185378f, 0.04240732f, 0.11740556f, 0.13023394f, 0.10206655f, -0.02984215f, -0.07597224f, 
    0.00939361f, -0.03744195f, 0.01053659f, 0.04330107f, -0.07846092f, 0.05130989f, 0.02171336f, 0.02787096f, 
    -0.03422678f, 0.18325073f, -0.21689293f, -0.08320538f, 0.06026421f, 0.07405739f, 0.00928151f, -0.12811887f, 
    -0.01414534f, -0.08766606f, 0.02587751f, 0.04066217f, 0.12219600f, -0.20421712f, 0.13108510f, -0.28417453f, 
    0.02309650f, 0.03332179f, 0.27402589f, 0.06166159f, 0.07169163f, 0.05700349f, -0.03744540f, 0.20081969f, 
    -0.29368243f, 0.03665911f, -0.02874024f, -0.11792083f, 0.05105989f, -0.02581558f, 0.05813771f, -0.17859492f, 
    0.06325458f, 0.11302336f, -0.09454478f, 0.26912114f, 0.05823788f, -0.10269398f, 0.17484455f, 0.09736650f, 
    0.03997135f, 0.00036703f, -0.09508595f, 0.01623899f, 0.03094647f, -0.10206260f, -0.00665194f, -0.19419920f, 
    -0.02298227f, -0.00084969f, -0.12364433f, -0.09843718f, -0.05599998f, -0.00854145f, -0.04878557f, -0.03690448f, 
    0.07532357f, -0.00986476f, -0.03093985f, 0.00173380f, 0.18891962f, 0.02709120f, -0.08985844f, -0.22868998f, 
    0.07874738f, -0.04123763f, -0.08687349f, 0.18447532f, 0.05629117f, 0.01253061f, 0.10258842f, 0.01322214f, 
    0.10616115f, -0.01862708f, 0.26899809f, 0.10499373f, -0.14234520f, -0.05127483f, -0.07011347f, -0.05342309f, 
    0.19836828f, 0.10592493f, 0.14174859f, 0.10858890f, 0.01220751f, 0.14971530f, 0.02561070f, 0.18759555f, 
    -0.10374115f, -0.04747026f, 0.06248125f, -0.01348755f, 0.06659456f, -0.15353136f, -0.15442397f, -0.14367358f, 
    0.07987978f, 0.01045940f, -0.02935405f, -0.07207336f, 0.15023668f, 0.09107910f, 0.08400715f, -0.02227128f, 
    0.06744179f, -0.01742612f, -0.09807880f, -0.06035273f, 0.03312693f, 0.03547470f, 0.61258465f, 0.18247031f, 
    -0.09697687f, -0.13473269f, -0.01907356f, -0.05177225f, 0.21406162f, 0.05119346f, 0.13163631f, -0.08772222f, 
    -0.09136527f, -0.03473822f, -0.06389325f, 0.01731109f, 0.13162175f, 0.16058137f, -0.00121695f, 0.02736479f, 
    0.02723978f, -0.02626425f, -0.11588141f, 0.10075623f, 0.03127463f, -0.07430884f, -0.23511429f, -0.19371399f, 
    0.00353774f, 0.06062815f, -0.01714312f, 0.01207207f, -0.04896992f, -0.02036225f, -0.00753136f, 0.05577239f, 
    0.09116217f, -0.05537423f, 0.00224321f, -0.21420851f, 0.08034955f, 0.13451645f, -0.03105828f, 0.01958611f, 
    0.03670070f, -0.12777725f, 0.08888740f, -0.06267904f, -0.46159479f, 0.16764167f, -0.08531471f, 0.26213863f, 
    0.00620476f, 0.06953917f, 0.01972377f, 0.06242067f, 0.01872495f, -0.06053121f, -0.05041577f, -0.05660219f, 
    0.29377460f, -0.16189928f, 0.00126261f, -0.01782621f, 0.18131845f, 0.08590380f, -0.02194157f, -0.07919447f, 
    0.08322538f, -0.07245801f, -0.01934842f, -0.10255813f, 0.12999293f, -0.08305693f, -0.27309582f, -0.27619106f, 
    0.22528137f, 0.22581396f, 0.03018681f, 0.13691789f, -0.02061047f, 0.06870263f, 0.17226073f, 0.12048811f, 
    0.21925630f, -0.00081420f, -0.06420745f, -0.23939486f, 0.11993584f, -0.05681305f, 0.05166239f, 0.06260049f, 
    0.04156952f, 0.03414301f, 0.03124698f, 0.26716882f, 0.23988222f, -0.15116630f, 0.22063743f, 0.08335885f, 
    -0.38760221f, -0.05002893f, -0.20156872f, 0.02910668f, 0.24848133f, 0.15755938f, 0.26877192f, 0.20949574f, 
    -0.20266081f, 0.04282933f, -0.44539091f, 0.04276356f, -0.00697423f, 0.04444700f, 0.24936680f, 0.14347884f, 
    -0.08389543f, -0.04328175f, -0.20928957f, -0.03110096f, 0.29441464f, -0.05510383f, -0.22985406f, -0.22750810f, 
    0.06300017f, 0.00790419f, 0.06758116f, 0.16677818f, 0.17035674f, 0.04568231f, 0.01590346f, 0.00468681f, 
    -0.02221685f, -0.19798912f, 0.05620515f, -0.06460007f, 0.00744713f, 0.00060335f, -0.13757810f, -0.07092939f, 
    0.00313725f, -0.05098169f, 0.07768942f, -0.12978911f, -0.08961088f, 0.43405986f, -0.13009189f, 0.01479494f, 
    0.05387444f, 0.05154689f, 0.03987908f, -0.07406620f, -0.02146844f, 0.09410815f, 0.04217402f, 0.15516676f, 
    -0.12692450f, 0.07003012f, -0.07582747f, -0.24922270f, 0.01186755f, 0.01853907f, -0.02921406f, 0.03654702f, 
    0.02429007f, 0.01101282f, 0.08335403f, 0.06258312f, 0.22336470f, -0.15691225f, -0.12276351f, 0.00365858f, 
    -0.05508189f, -0.01712245f, 0.03185283f, 0.08458158f, 0.05019636f, -0.05552235f, -0.01186982f, -0.00507887f, 
    0.08212449f, -0.05649733f, 0.22192149f, 0.02765848f, -0.07387190f, -0.12543947f, -0.14495102f, -0.17270274f, 
    -0.10996963f, -0.07723909f, 0.21680301f, -0.24955878f, 0.16045263f, 0.14719197f, 0.26435977f, -0.04950874f, 
    -0.13711071f, -0.14038098f, -0.12477996f, -0.09074822f, 0.19503102f, 0.10778891f, 0.09427492f, 0.22732565f, 
    -0.20261967f, -0.00932529f, -0.02070267f, -0.21038768f, -0.00099591f, 0.06398838f, 0.00914679f, 0.03563857f, 
    0.02968826f, 0.11143156f, -0.01720918f, -0.05692511f, 0.09901997f, 0.06443798f, 0.23861419f, -0.21986979f, 
    -0.04499885f, -0.04184653f, 0.06386876f, -0.10149346f, -0.07615054f, -0.10643317f, -0.04370653f, -0.14680156f, 
    -0.00012654f, 0.27015623f, 0.07312042f, 0.33913371f, -0.08216989f, -0.10097563f, -0.00252819f, -0.12674677f, 
    -0.01869677f, -0.06154398f, 0.17137980f, 0.09708101f, -0.09701619f, -0.00769263f, -0.21993054f, -0.15257657f, 
    0.17067419f, -0.01124042f, 0.03265424f, -0.06617883f, 0.04482754f, 0.01722447f, 0.12517512f, 0.06944602f, 
    0.03985138f, -0.08480573f, 0.10461133f, -0.14318125f, -0.00992061f, 0.09793144f, -0.02501038f, -0.00841565f, 
    0.07367790f, -0.07519687f, 0.03396008f, 0.00320145f, 0.09238931f, 0.08830954f, 0.09853673f, 0.03630470f, 
    0.00146704f, 0.02059264f, 0.13430196f, -0.01252986f, 0.15100871f, 0.02204443f, -0.02682239f, 0.08146816f, 
    -0.40836784f, -0.02943980f, -0.07175890f, 0.35285297f, 0.30306846f, -0.01680656f, -0.01966054f, -0.06321098f, 
    -0.01047560f, 0.02414271f, 0.03063462f, 0.00368794f, -0.22907531f, 0.00092063f, -0.06465718f, 0.23751603f, 
    0.06033062f, 0.02909506f, 0.08842102f, -0.22596592f, -0.08205871f, -0.02963714f, -0.04278657f, 0.06395470f, 
    -0.02157439f, 0.13238983f, 0.01112442f, -0.02537337f, 0.14989699f, -0.15021347f, 0.10530604f, -0.04997576f, 
    0.03394492f, 0.04976631f, 0.00741764f, 0.01513616f, 0.11993621f, -0.10601595f, -0.03563666f, -0.12900597f, 
    0.04645028f, 0.03664878f, -0.08665927f, 0.03488157f, 0.13397402f, -0.01379059f, -0.01850577f, -0.02266579f, 
    -0.19391543f, 0.01104308f, -0.27822787f, 0.06373632f, 0.07981461f, 0.04914232f, 0.14738281f, -0.05311052f, 
    0.13035025f, 0.07881729f, 0.05360902f, 0.15225793f, 0.09153102f, 0.11676870f, -0.13675730f, -0.11688595f, 
    0.10466860f, 0.01415826f, -0.04571286f, 0.13304047f, 0.01928999f, -0.04984312f, -0.01657953f, 0.02647583f, 
    -0.23400210f, 0.16702829f, -0.09258442f, 0.03232665f, -0.06267156f, -0.03923438f, 0.06133568f, -0.17893657f, 
    0.16442840f, -0.05927455f, -0.05910251f, 0.05022003f, -0.11656331f, 0.18022290f, -0.14881474f, -0.09226069f, 
    -0.03007073f, 0.10600650f, 0.04258411f, 0.00680685f, 0.02757096f, 0.08206726f, 0.03506094f, 0.08697812f, 
    0.23225412f, 0.00042526f, -0.04147199f, -0.18105674f, 0.16602449f, 0.08081213f, 0.08922739f, 0.01219643f, 
    0.05929596f, -0.00559134f, 0.02322787f, 0.03013538f, 0.17844008f, -0.01155395f, 0.04327881f, -0.22759268f, 
    0.11558098f, -0.03072578f, 0.16260481f, -0.07594936f, 0.02701096f, 0.01551146f, -0.11734764f, -0.15806316f, 
    -0.12918293f, 0.10546110f, -0.18653998f, -0.10452650f, 0.13714665f, 0.04196480f, -0.11017884f, -0.06187031f, 
    0.07901727f, -0.03205244f, 0.01064732f, 0.20933795f, 0.04687652f, 0.01783055f, 0.07293739f, -0.15738860f, 
    0.06197192f, 0.05766276f, -0.11665790f, 0.17291278f, -0.06948732f, -0.08852385f, -0.04561577f, -0.04209889f, 
    0.14223753f, 0.06141960f, 0.02663707f, -0.11285017f, 0.13105294f, 0.17968851f, -0.00650554f, -0.03633961f, 
    0.03923111f, -0.07161149f, 0.04367134f, 0.04036582f, 0.10762442f, -0.03117570f, -0.02736674f, -0.14731272f, 
    0.19958864f, 0.05918614f, -0.03761511f, 0.05510786f, -0.04502413f, 0.01086348f, 0.15164459f, 0.01498492f, 
    -0.23419788f, 0.05264495f, -0.03674709f, 0.21115050f, 0.02436372f, -0.05856724f, 0.07306158f, 0.10695099f, 
    -0.06568368f, -0.03908287f, 0.00954808f, -0.15272146f, 0.40380070f, 0.19234797f, -0.03710342f, -0.15067138f, 
    -0.11235658f, -0.14214379f, 0.00343688f, 0.11996306f, 0.09824357f, 0.01362637f, 0.04891373f, -0.10729510f, 
    -0.03907970f, -0.22929819f, -0.07264490f, 0.20680819f, -0.08374508f, -0.04242564f, -0.10118911f, -0.08567209f, 
    0.01870053f, 0.03128980f, 0.01498865f, -0.05064237f, -0.61231494f, 0.09600762f, 0.03961972f, 0.09862241f, 
    -0.07303228f, 0.04929156f, 0.03743734f, 0.13343392f, 0.08878102f, -0.05931174f, 0.09699971f, 0.10982431f, 
    -0.19408280f, 0.27560070f, -0.12401517f, -0.07741731f, 0.10394576f, -0.00791659f, 0.30875888f, -0.16535731f, 
    -0.01556343f, 0.13260825f, -0.10261896f, 0.18714029f, 0.08884724f, -0.17588046f, 0.28118333f, -0.15743212f, 
    -0.01218440f, 0.00358923f, -0.14046022f, 0.04468844f, 0.37124538f, 0.07841278f, 0.16859338f, 0.13046850f, 
    -0.17830902f, 0.03580371f, -0.17644191f, -0.12079967f, 0.08731082f, 0.21486722f, 0.21650578f, 0.00859943f, 
    -0.04448450f, 0.10761693f, 0.00690645f, 0.06683517f, -0.03986858f, 0.15470277f, -0.56127506f, -0.09893342f, 
    -0.04133129f, 0.03985934f, 0.16835967f, 0.10008176f, 0.01030937f, -0.02555278f, 0.00490096f, 0.05697441f, 
    0.08493397f, -0.01534574f, 0.14292091f, 0.12221638f, 0.08585788f, -0.08057810f, -0.00169740f, 0.06371222f, 
    -0.04320431f, -0.03180203f, 0.02857699f, 0.21608889f, 0.28952825f, 0.19370936f, -0.07202604f, 0.08631397f, 
    -0.05129934f, -0.03387557f, -0.05986750f, -0.14603780f, 0.03383347f, 0.08998941f, -0.01486086f, 0.01817602f, 
    0.42199013f, 0.00578699f, -0.02422393f, 0.21520464f, -0.00594690f, -0.01783225f, 0.15133883f, 0.06161139f, 
    0.02082214f, -0.03351155f, -0.13804305f, 0.17762466f, 0.09210582f, 0.05104419f, -0.02481063f, 0.01485044f, 
    -0.01091927f, 0.17492422f, -0.12913832f, 0.03506069f, -0.01690819f, 0.04810355f, 0.00021652f, 0.04775089f, 
    -0.21000308f, -0.08817786f, 0.05850879f, 0.12876056f, -0.07596380f, -0.02077721f, -0.08757000f, -0.12534247f, 
    -0.03924986f, 0.04040287f, 0.03061817f, 0.16843836f, 0.08047637f, 0.08560777f, 0.11394464f, -0.01959558f, 
    0.12997982f, -0.03342550f, 0.07665820f, -0.05471995f, -0.05581452f, -0.12376966f, -0.04368439f, -0.08756989f, 
    -0.42492482f, -0.09240875f, 0.24405387f, 0.09175003f, 0.10807905f, -0.10496336f, -0.10958683f, 0.04580924f, 
    0.05119331f, 0.00065790f, 0.00663829f, 0.05017861f, 0.38149217f, 0.02450686f, -0.15864536f, -0.02489086f, 
    0.11545642f, -0.06327343f, -0.07584956f, 0.14385058f, -0.15345010f, -0.03433046f, -0.30138716f, -0.05049188f, 
    -0.13161981f, 0.12724189f, -0.18750629f, -0.04900838f, -0.01545995f, 0.02410560f, 0.00582989f, 0.09608219f, 
    -0.08277274f, 0.04484103f, -0.01863572f, 0.02342865f, 0.34554279f, 0.14190565f, -0.06883155f, 0.17479378f, 
    0.07773881f, 0.13695596f, -0.02815343f, 0.07872756f, 0.09496485f, 0.11766508f, -0.11273777f, -0.07538442f, 
    -0.29214579f, -0.16829824f, -0.11363778f, -0.24828978f, -0.08296625f, 0.12648404f, 0.00504028f, 0.02997175f, 
    0.01066965f, -0.01773985f, -0.15000525f, 0.28496945f, -0.11713446f, 0.11024851f, 0.06362603f, -0.10760368f, 
    0.12658498f, 0.00946968f, -0.00889595f, 0.05069492f, 0.04452810f, 0.03859917f, -0.09902385f, -0.22924262f, 
    -0.20833921f, -0.03790899f, 0.08072661f, 0.38239449f, -0.01822908f, 0.04875540f, -0.05014031f, -0.25559485f, 
    -0.10150109f, -0.21600787f, -0.15166450f, -0.25677237f, -0.14996356f, -0.06239962f, -0.03054466f, -0.04303688f, 
    -0.02785743f, 0.01556962f, -0.00840222f, -0.09747394f, 0.00504433f, 0.12946835f, 0.17033355f, 0.19537731f, 
    0.09169801f, 0.10430305f, 0.23591857f, 0.22714129f, 0.00591416f, 0.10685367f, 0.04281073f, 0.03162643f, 
    0.02277178f, -0.14028649f, 0.04600260f, 0.05048203f, -0.24050303f, 0.08980458f, 0.10176730f, -0.07865520f, 
    -0.11252145f, 0.10876540f, 0.05763817f, -0.05974585f, -0.14153604f, 0.04857085f, -0.01751520f, 0.21679874f, 
    0.21484509f, 0.15397759f, -0.00136501f, 0.08188017f, 0.09188654f, -0.05928676f, -0.17505239f, -0.01423810f, 
    -0.12613939f, -0.06510380f, -0.00159353f, -0.01786090f, -0.09564719f, -0.09401722f, 0.02842076f, -0.02556255f, 
    -0.10381196f, 0.00225240f, 0.02517503f, -0.07204555f, 0.15231140f, 0.06988294f, 0.07277862f, 0.09054480f, 
    0.22872721f, -0.00460999f, 0.09039214f, 0.09605328f, -0.00734940f, -0.03528989f, 0.03655880f, -0.03611477f, 
    -0.05801115f, -0.05183275f, -0.08427518f, -0.03957323f, 0.29233015f, 0.04726250f, 0.27180061f, 0.02498220f, 
    0.08253038f, -0.23501216f, 0.04679915f, -0.19902684f, -0.10788210f, -0.08217683f, -0.08181690f, 0.11984143f, 
    -0.39524177f, -0.04564882f, 0.15041515f, 0.27520603f, 0.06465486f, 0.09634700f, -0.08707308f, -0.01911486f, 
    0.00763531f, -0.00522378f, 0.00232126f, 0.05340959f, 0.09577042f, 0.07588960f, 0.05055543f, 0.03488790f, 
    0.10942700f, 0.04744906f, -0.02135991f, 0.15285778f, -0.02209211f, -0.00150617f, 0.11131369f, 0.09243129f, 
    0.25478873f, 0.15703392f, 0.09006445f, 0.19288541f, 0.02653895f, 0.01828167f, -0.00940181f, -0.09476358f, 
    -0.08325697f, -0.02264890f, 0.02931264f, 0.00401869f, -0.06260421f, 0.11467900f, -0.04172675f, 0.35964379f, 
    -0.01878691f, -0.02844190f, -0.06706169f, -0.08312175f, 0.23450060f, -0.07121184f, 0.04487221f, 0.10716070f, 
    -0.11930571f, 0.05168009f, 0.01302177f, 0.13329583f, 0.01828801f, 0.09989490f, 0.06796996f, -0.13594224f, 
    0.09675484f, 0.16565470f, 0.01235199f, 0.17582417f, 0.01344270f, -0.01934609f, 0.15861359f, 0.04165054f, 
    -0.01463681f, 0.12804684f, 0.03336104f, 0.20234168f, -0.03073769f, 0.02856887f, -0.01467047f, -0.08123311f, 
    -0.06356086f, 0.11670707f, -0.05814083f, 0.11850222f, 0.16840759f, -0.12896605f, 0.02545038f, 0.06633799f, 
    0.13675061f, -0.00187689f, 0.08287185f, -0.21549577f, 0.22123908f, 0.15183507f, 0.22240396f, -0.07293583f, 
    0.09614474f, 0.13440220f, -0.07732429f, 0.03592937f, -0.05083484f, 0.00593191f, 0.01823102f, -0.14501181f, 
    -0.50152493f, 0.40091503f, 0.12506565f, 0.20581746f, 0.05157422f, 0.00876544f, -0.05420040f, -0.09214573f, 
    0.19344397f, 0.11882916f, 0.11106832f, 0.00594726f, -0.44918558f, 0.16105425f, 0.04267783f, -0.06958886f, 
    -0.10151234f, 0.16394946f, -0.06023682f, -0.04449800f, 0.01030859f, -0.04751741f, -0.00638828f, -0.06888964f, 
    0.06609256f, -0.07408088f, 0.11011811f, -0.01209953f, 0.10673710f, 0.00064206f, -0.11862225f, -0.03441303f, 
    0.15391539f, 0.03932766f, 0.16869609f, 0.12474168f, -0.06194929f, -0.06108413f, -0.08154885f, 0.00954111f, 
    -0.04048354f, 0.04094504f, -0.02088450f, -0.06792874f, 0.04078582f, 0.03025316f, -0.06864835f, 0.07216243f, 
    0.10375477f, 0.07803395f, 0.13349319f, 0.05719271f, -0.00614401f, -0.00638114f, 0.00609818f, 0.02725968f, 
    0.06947517f, 0.06287441f, 0.12192342f, 0.12709428f, -0.04704136f, 0.12134889f, 0.09918264f, -0.00324733f, 
    0.03790627f, 0.01217386f, 0.00465749f, 0.00249381f, -0.02836250f, 0.00982644f, -0.01227417f, 0.10689133f, 
    0.08886791f, -0.16348049f, -0.10954566f, 0.06703651f, 0.09805653f, -0.09623334f, -0.00158222f, -0.09257806f, 
    0.08455218f, 0.08921787f, 0.16597909f, 0.18691596f, 0.07843863f, -0.07265800f, 0.07037026f, -0.16533576f, 
    -0.01237880f, -0.04995145f, -0.07157065f, -0.16078663f, -0.09048743f, 0.08603996f, -0.03549720f, -0.11199365f, 
    0.25166926f, 0.13464192f, -0.07259083f, 0.15604393f, 0.07059385f, 0.10666068f, 0.05965933f, -0.14317924f, 
    0.12629357f, -0.18733037f, 0.00286622f, -0.05929804f, -0.26771790f, -0.26603210f, 0.15779684f, -0.20653373f, 
    -0.07520902f, -0.00699574f, -0.13437593f, -0.18231803f, 0.01201404f, 0.16771142f, 0.11703552f, 0.13827781f, 
    -0.19846132f, 0.07122950f, -0.09898601f, 0.45777652f, 0.13043721f, -0.03243363f, -0.14418967f, -0.23900260f, 
    -0.16776092f, -0.07601438f, -0.09226502f, -0.03517744f, -0.09888611f, 0.04322838f, 0.00878447f, 0.02433276f, 
    -0.17882118f, 0.01509400f, 0.01130972f, 0.07804251f, -0.05486631f, 0.07674386f, -0.08711831f, -0.03584512f, 
    0.30338728f, -0.06069311f, 0.09565258f, 0.07963397f, -0.09361564f, 0.08989321f, -0.04310066f, 0.02402620f, 
    0.05018929f, -0.06647306f, -0.20652591f, -0.02843057f, 0.19176777f, -0.02899053f, 0.19062760f, 0.13104154f, 
    -0.05665784f, -0.02765474f, -0.11426347f, 0.00530698f, 0.06551513f, -0.02324373f, 0.01129527f, -0.02645175f, 
    -0.05120865f, 0.15307061f, -0.00440977f, 0.18191455f, 0.06918449f, -0.23138249f, 0.05992226f, -0.02905012f, 
    0.10555229f, -0.07751626f, -0.27993867f, -0.00775653f, -0.15793245f, 0.02543808f, 0.01725547f, 0.32638234f, 
    0.03151824f, -0.15291166f, 0.01199198f, 0.03348151f, -0.06920467f, -0.07074949f, -0.10848109f, -0.26706290f, 
    -0.30022377f, -0.16071978f, -0.06369723f, -0.15117438f, -0.02264091f, -0.03882588f, 0.03599412f, -0.12494589f, 
    0.05503005f, -0.01267896f, -0.05310601f, 0.17561564f, 0.21470737f, -0.01499601f, 0.25448081f, 0.20013386f, 
    0.12968229f, 0.09177893f, 0.13816704f, -0.00837816f, 0.07401529f, -0.07243180f, 0.02092052f, 0.17382176f, 
    -0.12938017f, -0.01362895f, 0.10479651f, 0.06924632f, 0.06375176f, 0.10110631f, -0.08851981f, -0.05238783f, 
    -0.07642424f, -0.15828748f, -0.01650926f, -0.19621989f, -0.30301511f, 0.01091168f, 0.13441004f, 0.24164101f, 
    -0.02325792f, 0.03767342f, -0.26747778f, -0.15074451f, 0.00984078f, -0.15276386f, 0.07922356f, 0.26570961f, 
    0.03365891f, 0.11545671f, -0.23832271f, 0.09527631f, 0.11917486f, -0.03716717f, 0.01260815f, -0.03466682f, 
    0.04500619f, -0.19206113f, 0.08649237f, 0.15375373f, 0.22149400f, 0.20085974f, -0.22598650f, 0.08477312f, 
    0.11860271f, -0.01639407f, -0.08734746f, -0.00513822f, 0.04145065f, -0.10567341f, -0.09661152f, -0.15477003f, 
    0.38054523f, 0.16279499f, -0.03847323f, -0.12935930f, 0.07230792f, -0.07446832f, 0.12811299f, 0.27701214f, 
    0.05101417f, -0.13130173f, -0.02257703f, -0.11675392f, 0.26503071f, 0.12642525f, 0.10148305f, 0.25435629f, 
    -0.02085495f, -0.15263002f, -0.01646134f, 0.02777166f, -0.01627202f, -0.07494137f, -0.03630111f, 0.02492459f, 
    -0.31048587f, -0.05446357f, -0.03254950f, -0.08732437f, -0.05907680f, 0.10841973f, -0.17407729f, -0.02299842f, 
    -0.17804578f, -0.11413959f, -0.01571742f, -0.05988848f, 0.32668647f, -0.00457170f, 0.16397810f, 0.15169343f, 
    0.17819262f, -0.11307082f, 0.19252796f, -0.09497153f, 0.07987400f, 0.03980319f, 0.05495078f, 0.07838253f, 
    0.12042879f, 0.13108870f, 0.02088487f, 0.04321424f, 0.16810809f, 0.04301761f, 0.11609314f, 0.05065138f, 
    0.01884019f, 0.01897025f, -0.01513765f, 0.04565442f, -0.04115856f, 0.09901258f, 0.11087251f, 0.01259643f, 
    0.06496258f, 0.11608223f, 0.00123559f, 0.15397421f, -0.10516532f, 0.11218598f, 0.11151172f, 0.17052789f, 
    -0.14037396f, 0.26213786f, -0.06383018f, 0.21651465f, 0.00790230f, 0.00173586f, -0.08904780f, -0.15337142f, 
    0.08608139f, -0.04282453f, 0.00514575f, 0.23850341f, 0.04386510f, 0.23850982f, -0.02584180f, -0.12274683f, 
    -0.00688745f, 0.13624096f, -0.05605915f, 0.19423248f, -0.00820257f, 0.02316809f, -0.09071050f, -0.01614938f, 
    -0.19999859f, -0.02956085f, 0.15858494f, 0.00016160f, 0.12601209f, -0.02595874f, -0.12362503f, 0.21699250f, 
    0.12394439f, -0.11028191f, 0.06886935f, 0.07565363f, 0.32339108f, 0.23654850f, -0.08250631f, -0.25729725f, 
    0.05601675f, 0.05830609f, -0.08174356f, 0.18097186f, 0.06554483f, 0.02036209f, -0.02063765f, -0.03164174f, 
    -0.14837399f, -0.10337156f, -0.07458933f, -0.03979353f, 0.09706636f, 0.05656963f, 0.00979793f, -0.04269109f, 
    -0.06273526f, -0.10882174f, -0.08018567f, -0.21258274f, -0.11959106f, 0.04500334f, 0.06190806f, -0.40234289f, 
    -0.06421744f, 0.04348885f, -0.16190778f, 0.11471216f, 0.04573580f, -0.00195117f, -0.10272536f, 0.01710980f, 
    0.10756195f, 0.09920868f, -0.06730844f, 0.05484005f, -0.00977384f, 0.04464925f, 0.00837687f, 0.15897176f, 
    -0.00443470f, -0.07118591f, -0.00242776f, -0.03765127f, 0.06401184f, 0.20267294f, -0.22942731f, -0.11271740f, 
    -0.00822692f, -0.04213004f, -0.08793981f, -0.04634549f, 0.08931921f, -0.03427334f, -0.06133431f, -0.01148486f, 
    -0.23213126f, 0.22625655f, 0.18543620f, 0.13402663f, 0.11829727f, 0.13911101f, 0.03825295f, -0.02891438f, 
    0.05254148f, 0.11203633f, -0.07552746f, 0.01230593f, 0.24292403f, -0.04011940f, -0.28715312f, 0.27761111f, 
    0.12389013f, 0.00220512f, 0.05628461f, 0.14347355f, -0.03792605f, 0.11382427f, 0.01468064f, 0.02042524f, 
    -0.09716017f, 0.06965581f, 0.12079258f, 0.47547925f, 0.04496008f, 0.08366249f, -0.12052173f, 0.08066130f, 
    -0.11746428f, 0.17915680f, 0.01706402f, -0.18602912f, 0.12143028f, -0.17676704f, -0.00768588f, 0.46776399f, 
    0.08522461f, -0.03925563f, 0.17862159f, 0.04958945f, -0.05622329f, -0.05165329f, 0.01490870f, -0.01234978f, 
    -0.12132031f, -0.11918117f, -0.11355720f, 0.00288724f, 0.05998516f, -0.02836297f, 0.07579141f, -0.07148659f, 
    -0.08539670f, 0.06046781f, -0.14278768f, 0.07562651f, -0.12731995f, -0.31319079f, -0.20648605f, 0.04882381f, 
    -0.08903359f, 0.05170147f, -0.11288144f, -0.01324988f, -0.07763425f, -0.06718525f, -0.03303228f, 0.04329990f, 
    -0.19996330f, -0.09484364f, -0.03997810f, -0.05016011f, -0.02934752f, 0.04899299f, -0.04812500f, 0.01900225f, 
    -0.05762270f, 0.04316530f, 0.03448496f, 0.09692165f, -0.00063827f, -0.10735373f, 0.30512726f, 0.20635767f, 
    -0.11611789f, -0.10349864f, 0.19177856f, 0.03800578f, 0.04106903f, -0.04057132f, 0.03415512f, -0.14955397f, 
    0.11909524f, 0.00530541f, 0.37068868f, 0.07751735f, 0.05817685f, 0.08993217f, 0.04965717f, -0.13865085f, 
    0.06096054f, -0.13095503f, 0.07675360f, 0.10418666f, -0.07560355f, -0.24695589f, 0.03416923f, -0.01337875f, 
    -0.11841642f, -0.00982879f, -0.00120930f, 0.04029075f, -0.04735566f, 0.03354384f, -0.06295700f, -0.02947738f, 
    -0.37903985f, 0.23742086f, 0.13822281f, 0.06089146f, 0.06160610f, -0.11498585f, 0.15414053f, -0.05240834f, 
    -0.01901023f, -0.04509716f, -0.04480326f, 0.03763836f, 0.08174289f, -0.27619255f, 0.12809479f, 0.08748221f, 
    0.12161701f, -0.05520593f, -0.07909387f, 0.02980909f, 0.08471643f, -0.07444878f, 0.07715788f, -0.04183178f, 
    -0.06786507f, -0.18162633f, -0.09240083f, 0.00799775f, -0.05884571f, 0.06382839f, 0.11674543f, 0.02446437f, 
    -0.00084256f, 0.05729309f, 0.09661362f, -0.02702231f, -0.04945988f, -0.19277170f, -0.12310783f, -0.18809159f, 
    -0.02150965f, -0.07207261f, -0.06064444f, -0.02605480f, -0.19123545f, 0.05794962f, -0.07930453f, 0.05688278f, 
    -0.23799345f, 0.45143193f, 0.31518519f, 0.24008144f, 0.04164215f, 0.11881324f, -0.01516582f, 0.06788690f, 
    0.00931077f, -0.08576478f, -0.19827999f, -0.07239385f, 0.27028444f, 0.30168787f, -0.07527808f, 0.19437478f, 
    0.12611660f, 0.08622383f, 0.21822041f, 0.02871701f, 0.10457766f, 0.25706503f, -0.11141831f, 0.11163920f, 
    -0.11710425f, 0.00080098f, 0.14482351f, -0.08386441f, -0.01678701f, 0.04476327f, 0.13465965f, 0.07705903f, 
    0.00174133f, 0.01144919f, -0.02707930f, 0.00779304f, -0.05807469f, -0.01195668f, -0.03323563f, -0.30336389f, 
    0.00114030f, -0.07453587f, -0.03151055f, 0.01750047f, -0.18218519f, 0.00991296f, -0.06503254f, 0.17008772f, 
    -0.15977845f, 0.07077282f, 0.05089413f, -0.02435230f, -0.03357694f, 0.10576336f, 0.05930109f, 0.09628130f, 
    -0.01493827f, 0.01339260f, 0.15918492f, 0.03159236f, -0.21393725f, -0.19821702f, -0.04111990f, -0.13573615f, 
    -0.09127964f, 0.09248913f, 0.07553642f, 0.23891661f, 0.03751658f, -0.01570365f, -0.11764700f, 0.17493926f, 
    -0.10956903f, -0.07448559f, -0.00725757f, -0.39119089f, 0.00415672f, -0.09138784f, 0.08305512f, -0.02177300f, 
    -0.01065930f, -0.04839224f, 0.01739519f, 0.05355281f, -0.05002957f, -0.16442879f, 0.33952230f, 0.12640129f, 
    0.00520985f, -0.04336403f, 0.02490136f, -0.03971230f, 0.05204861f, 0.07222078f, -0.09288292f, -0.17799278f, 
    0.16663238f, 0.36490455f, 0.13633162f, 0.16131730f, -0.04520821f, 0.05031623f, -0.00970544f, 0.07583818f, 
    0.19579324f, 0.11709310f, -0.14740245f, 0.08296838f, 0.18573095f, 0.12502024f, 0.09192516f, -0.12405823f, 
    -0.13074555f, -0.12833831f, 0.01495273f, 0.03345889f, -0.08817336f, 0.08839086f, 0.08068922f, 0.21570483f, 
    0.07295819f, 0.37799266f, 0.06298009f, 0.10281593f, -0.07186909f, -0.06485774f, 0.02363498f, -0.01500126f, 
    0.10697967f, -0.05501774f, 0.00947463f, 0.24331817f, -0.55766571f, -0.04119658f, -0.22818105f, -0.33257204f, 
    0.17030236f, -0.09496952f, 0.05940453f, 0.01223413f, -0.05866178f, -0.03540412f, -0.16717035f, 0.06999671f, 
    0.25281194f, -0.12323361f, 0.17594369f, 0.39957350f, 0.01852435f, -0.12360308f, 0.02943415f, 0.00416618f, 
    0.10766072f, 0.11934560f, -0.08876529f, 0.03494456f, -0.06366074f, 0.16910468f, 0.17691761f, 0.05236891f, 
    0.00799924f, -0.02130608f, 0.05367763f, 0.01836442f, 0.04549562f, 0.00133671f, 0.06339766f, -0.01504656f, 
    0.32156762f, -0.53706449f, 0.14529182f, -0.32741705f, 0.03227070f, -0.18655242f, -0.14025822f, -0.31598037f, 
    0.13609517f, -0.10982918f, 0.05078486f, -0.03567972f, 0.35380539f, 0.41303983f, 0.21235773f, 0.37049526f, 
    0.16226088f, -0.07021590f, -0.07142336f, -0.10707938f, -0.05127834f, 0.18263413f, 0.07864835f, 0.20484757f, 
    0.02001786f, -0.13286364f, -0.00207246f, -0.06356766f, -0.03606045f, -0.00249725f, 0.02986916f, -0.04886638f, 
    0.01851187f, -0.20674916f, -0.06090757f, -0.07568475f, -0.22200364f, 0.05888347f, 0.07710362f, -0.21496524f, 
    -0.06519949f, -0.14222427f, 0.04279086f, 0.07774774f, 0.10174288f, 0.08057904f, -0.09462416f, 0.00333737f, 
    0.25189167f, 0.20330791f, 0.33269575f, 0.40227485f, -0.02522444f, -0.04936946f, 0.02079637f, 0.18227693f, 
    -0.10672783f, -0.00259477f, -0.13598549f, -0.09908390f, -0.04451120f, 0.31882885f, 0.34967005f, 0.41940442f, 
    0.12610345f, 0.02546448f, 0.01569808f, 0.04536311f, 0.01348912f, -0.01570205f, -0.07041845f, -0.01316576f, 
    -0.00639109f, 0.00593780f, 0.00624461f, -0.10802283f, -0.10474519f, -0.10813980f, 0.01413533f, 0.11675048f, 
    0.00934126f, -0.10229067f, -0.03602391f, -0.01338614f, -0.28382894f, 0.17456947f, -0.36605734f, 0.27187207f, 
    -0.02865043f, 0.08849011f, 0.00815935f, 0.04322596f, -0.19614170f, 0.17275648f, 0.02611418f, 0.02610941f, 
    0.11132561f, 0.13933159f, 0.20335335f, -0.01171175f, 0.13304670f, -0.01033039f, -0.08450276f, 0.05485250f, 
    -0.05442042f, -0.14612524f, -0.11433249f, 0.12763838f, -0.36102998f, 0.27836907f, -0.14078717f, 0.07862701f, 
    -0.05496832f, -0.05085257f, 0.04621159f, -0.18229739f, -0.04680116f, 0.13434350f, 0.05558928f, 0.06386926f, 
    -0.18265803f, -0.29055303f, 0.04053765f, -0.23372281f, -0.14653349f, -0.00055215f, 0.07787196f, 0.11195564f, 
    0.00402694f, -0.13564773f, 0.00003578f, 0.10320807f, -0.09021913f, 0.10256858f, -0.02377203f, 0.12190355f, 
    -0.06428677f, -0.14191854f, -0.00711613f, 0.04565713f, -0.09010428f, -0.09193762f, -0.00155709f, -0.07021964f, 
    -0.17896615f, 0.10109691f, 0.03290401f, 0.42935476f, -0.00992300f, -0.03482548f, 0.11289214f, 0.14620130f, 
    -0.08089396f, -0.05144197f, 0.09033820f, -0.09478436f, -0.29837584f, 0.40741587f, -0.02852261f, 0.13337155f, 
    -0.17726754f, 0.19781192f, 0.11315618f, 0.04688333f, -0.03715179f, 0.12941895f, 0.00406949f, -0.10821639f, 
    0.08425894f, -0.26722309f, -0.06892361f, -0.07554638f, 0.09487695f, -0.08483028f, 0.19017805f, 0.03233748f, 
    0.05265602f, 0.03877179f, 0.10389203f, 0.08591830f, -0.36360243f, -0.03640136f, -0.12741615f, -0.06517263f, 
    -0.03262381f, 0.03773995f, 0.03535407f, 0.02191651f, 0.05348232f, 0.03989769f, 0.05081423f, -0.00378922f, 
    -0.03680988f, 0.10038801f, -0.10926714f, 0.12126130f, -0.09807311f, 0.08345845f, 0.09815780f, 0.06682724f, 
    0.14808865f, -0.08519117f, -0.02644511f, 0.17593434f, 0.19252691f, 0.24380174f, 0.25828686f, 0.24931891f, 
    0.06468046f, -0.03241098f, 0.06501862f, 0.04283682f, -0.02847668f, 0.10133624f, 0.07420020f, 0.01544709f, 
    -0.13031732f, -0.02041727f, -0.12792957f, -0.10467247f, -0.02794944f, 0.04630891f, 0.07948125f, 0.01484475f, 
    -0.04160827f, -0.00435445f, 0.03665507f, 0.01066242f, -0.23051196f, -0.33619222f, -0.04676481f, -0.38564113f, 
    0.02966913f, 0.12727368f, -0.03918279f, -0.22291328f, -0.02251195f, -0.01048114f, 0.05251249f, -0.10525175f, 
    0.17990617f, 0.06824207f, 0.48874494f, 0.11544333f, -0.08567410f, -0.01187792f, 0.04115955f, 0.07580944f, 
    -0.13193965f, 0.09792684f, -0.00802666f, -0.08200238f, 0.18038073f, -0.14092353f, 0.23670453f, -0.00719602f, 
    0.07506551f, 0.07169723f, 0.08323255f, 0.01469692f, -0.11312900f, -0.15299992f, -0.14835060f, -0.03373638f, 
    -0.25876608f, -0.00272166f, -0.13556398f, 0.27441755f, 0.04027638f, -0.23413543f, 0.02872499f, 0.03200618f, 
    -0.03110879f, 0.02186336f, 0.00605357f, 0.11659319f, -0.40265605f, -0.13451746f, -0.10572378f, -0.14016536f, 
    -0.05545991f, 0.03937574f, -0.05678357f, -0.02054329f, -0.11167356f, -0.04669342f, 0.00094089f, 0.09393625f, 
    -0.26612669f, 0.00347679f, -0.11201124f, 0.00257309f, -0.11095877f, 0.11271770f, 0.17618328f, -0.03794630f, 
    -0.03517013f, 0.07546530f, 0.04023312f, -0.07648155f, 0.02799041f, 0.15285449f, 0.00559578f, 0.27539328f, 
    -0.03253293f, 0.05819768f, 0.07437398f, 0.00400681f, 0.11797798f, 0.11353620f, -0.04093115f, 0.01369227f, 
    -0.16889197f, -0.13316195f, -0.01590531f, 0.06150599f, 0.05007980f, 0.08933119f, -0.17667034f, 0.02314712f, 
    -0.07277969f, -0.05897973f, -0.13264140f, -0.03201220f, -0.15972711f, -0.06520049f, -0.08891799f, -0.06590310f, 
    0.07965516f, 0.16213565f, 0.02300578f, -0.11869265f, 0.08233162f, -0.05690084f, -0.11967147f, 0.00054851f, 
    0.24795520f, -0.30312341f, 0.10085147f, -0.06305685f, 0.05333970f, -0.03580177f, 0.01046382f, -0.02670428f, 
    0.06775912f, 0.15276109f, -0.08352967f, 0.12364723f, 0.07141804f, -0.32162818f, -0.12140920f, 0.19776684f, 
    0.01379661f, 0.02958545f, -0.00065097f, -0.14171015f, 0.00705695f, -0.04924989f, -0.08069894f, -0.06518620f, 
    -0.14440437f, 0.00792711f, -0.23780878f, -0.15027517f, 0.02661511f, -0.17374606f, 0.12719826f, 0.01578828f, 
    -0.10066864f, 0.04901867f, 0.07080749f, 0.10599533f, 0.08234074f, 0.71770495f, -0.14529383f, -0.03330402f, 
    0.10866027f, 0.18117875f, -0.13590963f, -0.12694485f, 0.03091729f, 0.20045389f, -0.13052179f, -0.09059179f, 
    -0.09249473f, -0.13464299f, -0.06286302f, 0.01741923f, -0.17114593f, 0.08543288f, 0.03898825f, 0.02595636f, 
    -0.10472223f, -0.04688421f, -0.01960601f, 0.13817164f, 0.18618354f, -0.02824306f, -0.01888446f, 0.08066735f, 
    0.02724321f, -0.03979779f, 0.03223218f, 0.01123539f, -0.28496704f, 0.06020323f, 0.02286401f, -0.00025648f, 
    -0.04611034f, 0.31422946f, 0.27095452f, 0.30290014f, -0.13043885f, -0.01776844f, 0.01315217f, 0.00170577f, 
    -0.13068356f, -0.10143003f, -0.05731789f, -0.04054366f, 0.41879302f, -0.09164831f, 0.11367138f, 0.25699663f, 
    0.38869372f, -0.14402395f, -0.30366579f, 0.20060399f, -0.01186539f, 0.10479800f, -0.10111231f, 0.09944930f, 
    -0.02834302f, -0.01736609f, 0.02196732f, -0.01125022f, -0.02490206f, 0.01858607f, 0.02153359f, 0.02787363f, 
    0.00451067f, -0.03039447f, 0.00224081f, 0.00176937f, -0.01266324f, 0.00164584f, 0.01170308f, 0.00005885f, 
    0.00755742f, -0.01726442f, 0.00983187f, -0.02376699f, -0.03548807f, -0.04060828f, -0.00832117f, 0.02893746f, 
    -0.03743495f, -0.02079222f, 0.02754135f, -0.03531523f, -0.03797115f, 0.00645995f, -0.02751973f, 0.01804597f, 
    -0.03079712f, -0.01618003f, 0.01362693f, 0.01582160f, -0.00289931f, -0.00397003f, -0.03190036f, -0.03458855f, 
    0.00014676f, -0.00428003f, -0.01252145f, 0.00649239f, -0.01108405f, -0.03147589f, 0.00877845f, -0.02209714f, 
    0.00567807f, -0.01974447f, -0.03753777f, 0.00302783f, -0.02380006f, 0.01669554f, 0.02168446f, -0.00039017f, 
    -0.01664405f, -0.04010472f, 0.02203582f, 0.02098016f, -0.00738637f, -0.03708336f, -0.00482165f, -0.02535312f, 
    0.01848085f, -0.01940602f, -0.02693907f, -0.03499014f, 0.02431810f, 0.00537972f, -0.00260511f, -0.01079585f, 
    0.00944300f, 0.01242889f, 0.01579247f, -0.02015672f, 0.02578562f, 0.01317966f, -0.02021476f, 0.01717991f, 
    0.02265789f, 0.01082115f, 0.02867045f, 0.02821247f, 0.00578172f, 0.01498672f, -0.00110293f, -0.03199269f, 
    -0.00332758f, 0.00543784f, -0.03913724f, -0.00871892f, -0.00140401f, -0.00366372f, -0.04035120f, -0.00589463f, 
    -0.02214880f, -0.03290512f, -0.03402041f, 0.00511968f, 0.00586440f, 0.00903784f, 0.00405686f, -0.02583353f, 
    -0.04052607f, -0.02729137f, -0.00782275f, 0.02324099f, 0.02387213f, -0.01354255f, 0.02230089f, 0.00661472f, 
    -0.02589777f, -0.03562905f, 0.02498723f, 0.01843349f, 0.00508749f, 0.03075268f, -0.00300070f, 0.02666796f, 
    -0.00446319f, -0.03312205f, 0.02697342f, -0.01172589f, 0.01746403f, -0.02216199f, -0.00840688f, 0.00119752f, 
    -0.00178802f, -0.03621689f, 0.01953334f, -0.03729273f, -0.04052807f, -0.02695693f, 0.00641663f, -0.02228437f, 
    -0.03775619f, -0.01547725f, 0.01394904f, 0.02232991f, 0.02177995f, -0.00781899f, -0.01979712f, -0.01410458f, 
    -0.01353808f, 0.00316896f, 0.00369433f, -0.02948842f, -0.00762165f, 0.01451836f, -0.02772024f, -0.01255489f, 
    -0.01057562f, -0.01343630f, 0.02946703f, 0.02660564f, -0.02894764f, -0.03233278f, -0.01598480f, 0.02775405f, 
    -0.01486802f, 0.00467030f, 0.02161646f, -0.02910975f, -0.01870498f, -0.02501433f, -0.01610957f, -0.00598749f, 
    0.00330850f, 0.03153258f, 0.02207885f, -0.01389259f, 0.02950611f, 0.02870029f, -0.03278021f, -0.00049934f, 
    0.02459694f, 0.01778232f, 0.02773587f, 0.02941212f, -0.02404378f, 0.00459126f, 0.00832460f, -0.00508880f, 
    0.01162696f, 0.01065594f, 0.00046211f, 0.02610825f, 0.00050359f, 0.02072051f, 0.00309876f, -0.02774132f, 
    -0.01091904f, 0.02335932f, 0.01898164f, -0.01755131f, -0.03621935f, -0.03937545f, 0.02919513f, 0.02480610f, 
    -0.00385165f, -0.02364156f, -0.03214186f, 0.02477932f, -0.04112196f, -0.01227378f, 0.00238181f, 0.02982539f, 
    -0.00629297f, 0.02379735f, -0.04003871f, -0.01731640f, 0.02510530f, -0.00216925f, 0.01155525f, -0.00191417f, 
    -0.02175126f, -0.03953004f, -0.01801677f, -0.02013674f, 0.02492039f, 0.01643427f, -0.03515796f, -0.00195346f, 
    -0.03786829f, -0.02463164f, -0.01896000f, -0.00443110f, -0.00560279f, 0.01531059f, 0.01265787f, -0.00106401f, 
    0.01681902f, -0.03802604f, -0.04126687f, -0.00384921f, -0.01625680f, -0.02997775f, -0.02682293f, -0.01601798f, 
    0.01900652f, 0.02261183f, 0.00214054f, 0.01693066f, -0.00970834f, -0.00735911f, -0.03725759f, -0.02056373f, 
    -0.01149448f, 0.02404294f, -0.03014283f, -0.02176669f, 0.02254569f, 0.02712622f, 0.02305668f, 0.01110637f, 
    -0.01396874f, -0.01159701f, 0.00248526f, 0.01812493f, -0.03247194f, 0.01432108f, 0.02196166f, -0.01744235f, 
    -0.02672269f, 0.00885744f, -0.00291309f, 0.00425802f, -0.00328074f, 0.02281062f, 0.01446250f, -0.03143211f, 
    0.00618885f, 0.02110340f, -0.03313302f, 0.00630555f, -0.02637377f, 0.00362525f, -0.03915674f, -0.02627856f, 
    0.01147762f, 0.01152266f, -0.00583835f, -0.01509637f, -0.02193859f, -0.01526796f, 0.02227719f, -0.00581852f, 
    0.00095212f, -0.01411275f, -0.02563714f, -0.03188615f, -0.00095130f, -0.01898274f, -0.03103269f, 0.00057212f, 
    -0.03798646f, -0.02256693f, -0.01349887f, 0.02048564f, -0.02250407f, -0.00659843f, -0.04185011f, 0.02100613f, 
    -0.00883973f, -0.03108567f, -0.01990960f, -0.03157342f, -0.03633723f, -0.03300422f, -0.03995923f, 0.02385747f, 
    -0.03445559f, 0.02202852f, 0.02196166f, -0.03634259f, -0.01765094f, 0.00554322f, -0.00971764f, -0.04110443f, 
    -0.02049648f, -0.00053573f, 0.01741999f, 0.01437527f, -0.00544595f, -0.00782334f, -0.02800844f, -0.01480732f, 
    0.00140758f, 0.02097940f, 0.00443263f, 0.00661108f, 0.01881045f, 0.01865364f, 0.00248169f, -0.00906147f, 
    -0.03175383f, 0.02099564f, -0.03817265f, 0.00780130f, -0.00008609f, 0.02280078f, 0.00586075f, 0.02939606f, 
    0.02845300f, -0.03276869f, -0.00082117f, 0.02027303f, -0.00840748f, 0.02778330f, -0.02813686f, -0.00839328f, 
    -0.00171817f, 0.03027730f, -0.02124796f, -0.04123583f, -0.04082221f, -0.03898942f, 0.02929273f, -0.02878012f, 
    0.01929663f, -0.00025747f, 0.01298008f, 0.01004440f, -0.00025171f, 0.01517771f, -0.01562763f, -0.01114895f, 
    -0.01526210f, 0.00497733f, 0.00923255f, 0.00195491f, -0.02091627f, 0.00512060f, 0.02576505f, -0.04137479f, 
    0.00801857f, -0.03466827f, 0.01345463f, 0.01921388f, -0.02408112f, -0.03851759f, -0.01554939f, 0.00890888f, 
    0.01595095f, -0.01619426f, -0.00318074f, -0.03465848f, -0.03471320f, 0.01649527f, -0.01880760f, 0.02268803f, 
    0.01096371f, -0.00804155f, 0.02003589f, -0.03428502f, -0.00361431f, -0.03480176f, -0.04091173f, -0.00946736f, 
    0.02404165f, -0.02523778f, -0.04090098f, -0.03486722f, -0.00999918f, -0.01887635f, -0.01504967f, -0.01350277f, 
    0.01711798f, 0.01466452f, -0.00690199f, -0.00692979f, -0.01499019f, -0.04003056f, -0.02779131f, -0.03767993f, 
    -0.02481545f, 0.01074000f, 0.02333127f, -0.01125640f, 0.01068131f, -0.00525436f, -0.01828782f, -0.02785506f, 
    -0.03890258f, 0.01097896f, -0.02006635f, 0.01949402f, 0.01830287f, -0.01184184f, 0.02118104f, -0.01068319f, 
    0.03171476f, -0.02211497f, -0.00666535f, -0.02208353f, -0.01574997f, -0.03887525f, -0.02848888f, -0.02093970f, 
    -0.02575148f, 0.02244840f, -0.01825265f, -0.01591744f, -0.00804807f, 0.00571857f, -0.00355091f, 0.01273752f, 
    0.00852747f, 0.01746914f, 0.01888729f, -0.03139507f, 0.01263003f, -0.00636390f, 0.02242185f, 0.01711876f, 
    -0.03579214f, -0.00091019f, 0.00529496f, 0.02547129f, 0.01195395f, 0.01620000f, -0.02353793f, -0.01286940f, 
    -0.03405363f, 0.02746959f, -0.02904126f, 0.02603250f, 0.02049350f, -0.02719222f, -0.03047785f, -0.00910270f, 
    -0.01756140f, 0.01919614f, -0.02441831f, 0.00583446f, 0.02370521f, 0.02721191f, 0.02264799f, -0.01204150f, 
    -0.02540775f, 0.03007037f, -0.04117616f, -0.03816349f, -0.03841918f, 0.00813706f, 0.00524994f, -0.03402769f, 
    -0.00426370f, 0.02028098f, 0.01327113f, 0.02937516f, -0.03718028f, 0.01990602f, 0.00412850f, 0.02882066f, 
    -0.00040382f, -0.01613379f, -0.03279915f, -0.00367629f, -0.02525605f, -0.00111880f, 0.00021771f, -0.03463380f, 
    -0.00030675f, 0.00034501f, 0.02578628f, -0.03760218f, -0.02167894f, -0.02012979f, -0.02958617f, -0.03094699f, 
    -0.03960121f, 0.00098388f, -0.02221626f, 0.01249997f, 0.02214856f, 0.00507709f, -0.02733564f, 0.00753216f, 
    -0.03362881f, 0.00798165f, 0.00768716f, -0.03446226f, 0.00168796f, -0.00680987f, -0.03282772f, -0.01135348f, 
    -0.00140070f, 0.02292763f, 0.01190988f, 0.02620025f, -0.01486159f, -0.04094775f, -0.03415838f, 0.02188946f, 
    0.01118566f, 0.02176594f, 0.01347020f, -0.01680451f, -0.03267425f, -0.02319546f, 0.00809681f, -0.01818249f, 
    -0.00131216f, -0.02674896f, -0.01949177f, -0.00261904f, 0.00903888f, -0.03411780f, -0.00020477f, 0.02824776f, 
    0.01100932f, 0.00278527f, -0.01003165f, -0.00983496f, -0.01696377f, -0.02653201f, -0.03389216f, 0.01791872f, 
    -0.00647790f, -0.01884598f, -0.03504971f, -0.04028268f, 0.02810845f, 0.02893260f, 0.02337085f, -0.03329669f, 
    -0.03572523f, 0.01358537f, -0.03065499f, -0.01355287f, 0.00415713f, -0.02486916f, -0.01535278f, 0.02538205f, 
    -0.03374390f, 0.01778040f, 0.02744311f, 0.01770461f, -0.00082193f, -0.03183841f, -0.00810834f, 0.01810774f, 
    -0.00746393f, 0.01193623f, -0.02620537f, 0.01969185f, -0.03810380f, -0.02667431f, -0.00637958f, -0.01471749f, 
    0.01627929f, -0.01933001f, -0.02183360f, 0.02606803f, 0.00236790f, 0.00734519f, 0.02054516f, -0.01494272f, 
    -0.02462496f, 0.00283203f, 0.02113729f, -0.02646927f, -0.00538493f, -0.03800483f, -0.02455419f, 0.01867393f, 
    0.00109682f, 0.01579673f, 0.01526590f, 0.02684177f, -0.01666954f, 0.01397271f, 0.00184851f, 0.01279230f, 
    0.00689386f, 0.00785831f, -0.00794726f, 0.02384701f, 0.01748042f, 0.02384884f, -0.03951485f, -0.04081085f, 
    -0.02650820f, -0.00955814f, -0.00392369f, -0.01193762f, 0.00107140f, -0.00223180f, -0.02723867f, -0.04147217f, 
    -0.00892770f, -0.01310265f, -0.02578014f, 0.01588235f, 0.02619022f, -0.00053411f, -0.02832602f, -0.02544675f, 
    0.00083448f, 0.00289519f, 0.00141983f, 0.02313705f, 0.01987273f, 0.00944732f, 0.01246207f, 0.00746138f, 
    -0.01559871f, 0.02716852f, -0.00514559f, 0.02691210f, -0.03926150f, -0.03912416f, -0.03889241f, 0.00499774f, 
    0.00761176f, 0.02978342f, -0.03066736f, 0.02520177f, 0.02989894f, 0.01597822f, 0.01168452f, 0.00769358f, 
    -0.00119855f, -0.04129936f, -0.03255794f, -0.01428421f, 0.01144388f, -0.00612895f, 0.00618733f, -0.02785463f, 
    0.02583190f, 0.01248294f, -0.01796277f, 0.01519526f, -0.03700415f, 0.00941099f, -0.00154731f, -0.01185172f, 
    -0.01512153f, 0.01580963f, 0.01603145f, 0.00280632f, 0.02191665f, 0.01222392f, -0.00198302f, 0.03472460f, 
    -0.00247579f, 0.02759841f, 0.01854573f, -0.02265266f, -0.02255792f, 0.02147248f, 0.02566265f, 0.00587901f, 
    0.00769371f, -0.00993339f, 0.00926570f, 0.00007094f, -0.00204038f, -0.01451016f, 0.02678887f, 0.01236978f, 
    -0.01320609f, -0.02798964f, -0.03791620f, -0.01934658f, -0.00531966f, -0.01044104f, 0.01224601f, 0.00184593f, 
    0.01062683f, -0.00098537f, 0.01123932f, -0.01934720f, -0.00170568f, 0.01187646f, 0.01060659f, -0.00947046f, 
    -0.01428859f, -0.03616214f, -0.00132129f, 0.02998299f, -0.03498799f, 0.01280843f, 0.02958426f, -0.01860329f, 
    -0.01099974f, -0.03183657f, -0.02260914f, 0.01631268f, 0.01031806f, 0.01307553f, -0.02633353f, -0.02804552f, 
    -0.00292042f, -0.03101344f, 0.00433389f, -0.01829951f, -0.01315151f, -0.02973916f, -0.01845934f, 0.00134866f, 
    -0.02983736f, 0.02220469f, -0.03126965f, -0.03206646f, 0.02382044f, 0.01266718f, 0.02356577f, -0.01782885f, 
    -0.04106936f, -0.01572427f, 0.01935432f, 0.02928372f, -0.02636904f, -0.02509166f, 0.01622904f, -0.02152149f, 
    -0.02134087f, -0.01986657f, -0.01917292f, 0.00534733f, -0.02122990f, -0.02630158f, -0.01068804f, -0.01318613f, 
    0.04033558f, -0.09980318f, -0.10855369f, -0.06025044f, 0.04542701f, 0.04588496f, -0.14137267f, 0.05814001f, 
    0.00276934f, -0.00396476f, -0.05484216f, -0.25359395f, -0.14676081f, 0.15742381f, 0.06289198f, -0.07032888f, 
    0.08125346f, 0.05491491f, 0.16595925f, 0.15976034f, 0.00908846f, -0.04646315f, 0.02436405f, 0.07207692f, 
    -0.00011678f, 0.09687781f, -0.09950901f, -0.29367200f, -0.04851950f, 0.11843756f, 0.00939221f, -0.10520341f, 
    -0.09727740f, 0.16389045f, 0.10412347f, -0.13734403f, 0.03659860f, 0.18136455f, -0.18005717f, -0.03299446f, 
    0.07779398f, -0.02022330f, 0.22807629f, -0.11926260f, -0.01719856f, 0.01952345f, -0.00243750f, -0.02167762f, 
    0.04611635f, 0.13962758f, 0.18200473f, 0.02231907f, 0.05682071f, -0.02324747f, -0.03039603f, -0.01379546f, 
    -0.03463893f, 0.03234153f, -0.09382951f, -0.14901620f, -0.01236493f, -0.01682176f, -0.27777195f, 0.07899176f, 
    -0.08419156f, 0.09963513f, -0.07275257f, 0.10830146f, -0.07330701f, 0.09700600f, 0.09287512f, 0.08977447f, 
    0.17556804f, 0.08196305f, -0.14868824f, 0.00230146f, -0.07610730f, 0.02467071f, 0.02445702f, -0.21708810f, 
    -0.08825998f, -0.01363949f, -0.06268206f, -0.03603555f, -0.35039926f, 0.11660501f, 0.13621028f, 0.13803393f, 
    -0.12583919f, -0.02368815f, 0.26976097f, 0.23692086f, 0.24582501f, 0.01996379f, 0.07243098f, -0.03292907f, 
    0.19429307f, -0.24066716f, 0.20558478f, 0.17594083f, 0.03771948f, -0.04535603f, -0.06375700f, 0.04378995f, 
    0.03761047f, -0.02788256f, -0.12347032f, 0.08279206f, -0.08284710f, 0.05116073f, 0.16002931f, -0.13909413f, 
    -0.00632585f, 0.00842469f, 0.18135346f, 0.17909516f, -0.09319340f, 0.00001684f, -0.00237824f, -0.01661151f, 
    0.12825361f, 0.40731549f, 0.12725022f, 0.34013808f, 0.01724155f, 0.04511666f, 0.04926141f, 0.08618206f, 
    -0.21130532f, 0.01711006f, -0.07209171f, -0.23123573f, -0.05625122f, -0.10006282f, 0.15313710f, 0.21370272f, 
    -0.07528409f, 0.09948987f, 0.05604162f, 0.03674612f, 0.00889460f, 0.00030954f, 0.02621167f, 0.01894471f, 
    0.12809561f, 0.03770282f, -0.04685599f, -0.20375027f, 0.04848110f, -0.00992697f, -0.01378109f, -0.10076812f, 
    0.03167114f, 0.19905213f, 0.19158183f, 0.29337934f, -0.10145993f, 0.12740400f, -0.02390937f, 0.05841182f, 
    -0.04168979f, -0.11526672f, -0.02991050f, -0.00542398f, 0.06960064f, -0.18252580f, -0.20635335f, -0.17446554f, 
    0.35399985f, -0.22506060f, -0.25619358f, -0.09663537f, 0.07897464f, -0.02001840f, 0.02438501f, -0.01565779f, 
    -0.10710039f, 0.06527502f, -0.06620579f, -0.03187820f, 0.14537713f, -0.21151486f, -0.05913904f, 0.10764136f, 
    0.20720135f, -0.12951565f, -0.01093227f, 0.12618710f, 0.16493316f, -0.09107401f, 0.03068946f, -0.08118900f, 
    -0.02671033f, 0.03261704f, 0.08064190f, 0.02931264f, -0.10861854f, -0.05493163f, -0.00057756f, -0.03505828f, 
    0.11371800f, 0.02632863f, 0.03586112f, 0.19031404f, -0.00880302f, 0.20740823f, -0.01266461f, 0.04774957f, 
    -0.00771582f, -0.08201106f, 0.01145757f, -0.01849289f, -0.12197466f, -0.09719902f, -0.18642287f, -0.03501045f, 
    -0.19991855f, 0.03091036f, -0.14108379f, -0.08546305f, -0.00608104f, 0.15040100f, 0.11158621f, 0.14379412f, 
    0.00724616f, 0.07227900f, -0.05006002f, 0.06789201f, -0.16357917f, 0.06489224f, -0.01034032f, 0.03177186f, 
    -0.12690005f, 0.04444881f, -0.13157666f, -0.01126806f, 0.15801023f, 0.09976430f, 0.03335734f, 0.06071714f, 
    0.17032523f, -0.04484875f, 0.15204947f, -0.02658344f, -0.01745836f, 0.04077799f, -0.02675974f, -0.02339866f, 
    -0.08086643f, 0.01603404f, 0.01062161f, -0.02090594f, 0.28455701f, -0.15357654f, -0.06665656f, 0.07565345f, 
    0.09667034f, -0.05583258f, -0.00980894f, -0.20059416f, -0.01334487f, 0.01825440f, -0.05884305f, -0.13692424f, 
    -0.15586087f, -0.23555003f, -0.17807524f, -0.18590748f, 0.12417756f, 0.08022186f, 0.01561802f, 0.09590779f, 
    0.09077675f, -0.05010163f, 0.08254948f, -0.12302338f, 0.12443209f, -0.10746787f, 0.13040815f, -0.14570035f, 
    -0.02658910f, -0.12135218f, 0.02106715f, 0.17403686f, 0.00118697f, 0.03887396f, -0.01359250f, -0.21007583f, 
    0.06737352f, 0.03127579f, 0.08548761f, -0.02950949f, 0.04957734f, -0.09374418f, -0.04003657f, 0.13860147f, 
    -0.11104390f, -0.17002459f, -0.14548567f, -0.37708187f, 0.17952763f, 0.05377348f, -0.21943067f, -0.12942396f, 
    0.10689732f, -0.03956146f, 0.04084159f, -0.07626639f, -0.00878578f, 0.06407034f, 0.06798999f, 0.09978661f, 
    0.30434164f, -0.28238645f, 0.13403103f, 0.09161220f, -0.06420725f, 0.03627943f, -0.02042280f, 0.10172352f, 
    -0.05419848f, 0.09718113f, 0.08435348f, 0.15395814f, -0.10122185f, 0.02207669f, -0.02659348f, 0.24905233f, 
    -0.15459818f, -0.17234589f, -0.13127376f, -0.18096358f, 0.08369840f, 0.03156188f, 0.10749220f, 0.24999672f, 
    0.23972143f, -0.22574636f, 0.17165890f, 0.02577230f, -0.01780848f, 0.08069058f, 0.15444829f, 0.00859446f, 
    -0.14002329f, -0.13444795f, -0.14467612f, -0.02734581f, 0.29742157f, -0.33216375f, 0.14939296f, 0.20193839f, 
    0.04434909f, -0.03937557f, 0.02300531f, 0.08459170f, 0.02548638f, 0.23418593f, 0.00450374f, 0.08083341f, 
    -0.14278696f, -0.12712522f, -0.09230537f, -0.08472876f, -0.12046584f, -0.07595500f, -0.02459653f, -0.14122710f, 
    0.00929794f, -0.09551283f, -0.12493637f, -0.17163944f, -0.00410487f, 0.15478706f, -0.02059902f, 0.12569341f, 
    -0.06752120f, -0.02636753f, 0.01460352f, -0.00244201f, -0.01275655f, 0.02703828f, -0.06337307f, -0.03043326f, 
    0.27513149f, -0.01077774f, -0.01193901f, 0.00294771f, 0.03390415f, 0.04065095f, -0.00083316f, -0.06758292f, 
    -0.11764134f, -0.08416019f, -0.08263700f, -0.00163598f, 0.27687618f, -0.10917693f, 0.01515630f, 0.14982565f, 
    0.11740799f, 0.00583603f, -0.01801444f, -0.04623963f, -0.00285042f, -0.03549882f, -0.06063262f, 0.04826396f, 
    -0.15431778f, 0.07326338f, 0.09573636f, -0.15844312f, -0.11279244f, -0.03229560f, -0.06583641f, -0.09432282f, 
    -0.09776855f, -0.07472504f, -0.02518734f, -0.08366281f, -0.01737385f, 0.31226102f, -0.15383245f, 0.21227068f, 
    -0.06858955f, 0.02462080f, -0.05851602f, -0.05823997f, -0.03282738f, 0.14881727f, 0.11454947f, 0.18838158f, 
    0.06033551f, 0.04927882f, 0.04739697f, -0.01265816f, -0.06477051f, -0.02556629f, -0.03202185f, 0.08583955f, 
    -0.07148674f, 0.15708186f, -0.07934299f, 0.07350785f, -0.07006215f, 0.24651159f, -0.18758462f, -0.00713678f, 
    -0.05034821f, -0.04598912f, 0.10534102f, -0.03914937f, -0.06866075f, -0.03570268f, -0.18593010f, -0.18781741f, 
    0.15547711f, 0.07669700f, 0.21557161f, -0.17206995f, -0.11645280f, -0.07242937f, 0.03828562f, 0.05966300f, 
    0.21420996f, 0.07280331f, 0.09764025f, 0.11646353f, -0.04772433f, 0.03987582f, -0.05296110f, 0.03622358f, 
    0.12868282f, 0.01798017f, -0.13579114f, -0.05252830f, -0.04508015f, -0.16424835f, -0.01647784f, -0.06621214f, 
    -0.25265813f, 0.21894768f, -0.35775423f, -0.15055366f, 0.09905403f, -0.01023873f, 0.01480732f, 0.02666757f, 
    -0.05601788f, -0.07348912f, 0.10595789f, 0.03322246f, -0.27609608f, 0.27700809f, -0.28122452f, -0.18974960f, 
    0.06413014f, 0.04977345f, 0.09597320f, -0.06715459f, -0.06933708f, -0.02105887f, -0.08986367f, 0.03216313f, 
    0.03024663f, -0.17200962f, 0.34106395f, -0.11717876f, -0.04367935f, 0.13937910f, 0.01224484f, -0.00723120f, 
    0.04673344f, 0.02576913f, 0.05146058f, -0.04558446f, -0.02685631f, -0.05067814f, -0.02107479f, -0.08647082f, 
    0.11718027f, -0.01288148f, -0.05218792f, -0.10637139f, 0.05527367f, 0.05083856f, 0.09511153f, 0.10133786f, 
    0.18511286f, 0.11471435f, 0.01164521f, -0.02014136f, -0.07930633f, 0.09838278f, 0.07987567f, 0.01776015f, 
    -0.00999185f, 0.03223474f, -0.03404344f, -0.05312850f, -0.14990869f, 0.01991797f, -0.22024715f, -0.10009232f, 
    0.09597787f, -0.11234633f, -0.14391589f, 0.07752107f, -0.14812660f, 0.00904036f, -0.03732891f, -0.21735482f, 
    -0.02496236f, -0.00046516f, -0.13280365f, 0.10071741f, 0.02325065f, -0.07600833f, 0.00594585f, -0.05494761f, 
    0.01244318f, 0.07648695f, 0.05175781f, 0.13726819f, 0.08613924f, 0.33345965f, 0.10959341f, -0.18156405f, 
    0.16602705f, 0.14409135f, 0.23501073f, -0.01345261f, -0.01841986f, 0.12759705f, -0.06980769f, -0.13459072f, 
    0.01269362f, 0.09916709f, 0.33613735f, -0.02625442f, -0.14516897f, 0.03865051f, -0.00958551f, -0.13482854f, 
    0.22704181f, 0.17082973f, 0.01332042f, -0.16041252f, 0.01200147f, -0.16799462f, 0.29598704f, -0.02701849f, 
    -0.10889929f, 0.14489131f, 0.14753129f, 0.17042325f, -0.04487097f, 0.14069277f, 0.13819948f, 0.03368397f, 
    0.01527198f, 0.04217190f, -0.22417514f, 0.19913675f, -0.08411259f, 0.11412884f, 0.01909868f, -0.01986181f, 
    0.00423269f, 0.10787608f, 0.00271993f, 0.07161157f, 0.05051150f, 0.11681973f, 0.11167902f, -0.20795169f, 
    0.07392000f, 0.05069970f, -0.02852480f, 0.20755409f, -0.08665942f, 0.04674248f, 0.04422780f, -0.09655202f, 
    0.02835383f, 0.03441347f, -0.09336410f, 0.11145656f, 0.09693545f, -0.06193474f, 0.10290439f, -0.11129612f, 
    0.03125033f, 0.06168094f, -0.03626528f, 0.04522162f, -0.30902156f, -0.18169507f, -0.09185902f, -0.14972235f, 
    0.10855615f, 0.09215765f, -0.11828163f, 0.04747305f, -0.15519507f, -0.02415127f, -0.14837582f, -0.10000131f, 
    -0.05459949f, -0.07567607f, 0.10874337f, -0.10450547f, -0.05610289f, -0.02977112f, -0.07015187f, -0.02761308f, 
    0.06421165f, -0.01835860f, 0.03549151f, -0.00093233f, 0.07410116f, -0.09083973f, -0.04441603f, -0.01848697f, 
    -0.00769923f, -0.18102236f, -0.16445613f, -0.09778180f, 0.02685398f, -0.05929268f, -0.10986120f, -0.08918387f, 
    0.04155582f, -0.29720452f, 0.20745364f, -0.14450054f, 0.03347946f, -0.02554495f, 0.02814224f, 0.19179897f, 
    -0.09397351f, -0.01540442f, -0.07817335f, -0.09442936f, 0.13954107f, -0.01307291f, -0.19143769f, -0.05551253f, 
    -0.03715158f, -0.01507862f, 0.06072773f, -0.13538653f, 0.12205149f, -0.04604648f, 0.06009449f, 0.00256576f, 
    0.09094003f, 0.04405421f, -0.15632340f, 0.04386899f, -0.06796808f, -0.06142212f, -0.03248793f, -0.22586383f, 
    -0.12906183f, 0.04824369f, -0.16218938f, -0.04248371f, -0.08213732f, -0.09871691f, 0.21230535f, -0.24703050f, 
    -0.07137630f, 0.08484691f, 0.10816291f, 0.04556498f, 0.07305715f, -0.05078851f, 0.14229889f, 0.00267726f, 
    0.00083596f, 0.09409919f, 0.02260638f, 0.09818523f, -0.06384432f, 0.00094740f, -0.08703057f, -0.08554816f, 
    0.02841442f, 0.14572318f, 0.00234005f, 0.15456095f, 0.06608360f, 0.05180103f, 0.08939540f, 0.17203343f, 
    -0.04738209f, -0.12682989f, 0.06856167f, 0.02135292f, 0.02663257f, 0.00099053f, 0.11583433f, 0.00578821f, 
    0.02630886f, 0.03635636f, 0.00670497f, 0.07445327f, -0.09232382f, 0.00779108f, -0.00452359f, 0.07783268f, 
    -0.07415012f, 0.02481416f, 0.08452778f, 0.01829720f, 0.19766232f, -0.11054837f, 0.06021644f, 0.26763377f, 
    -0.00523283f, 0.11173185f, 0.00141924f, 0.07063092f, -0.08493676f, 0.13643436f, -0.01687126f, 0.01971840f, 
    0.28327784f, -0.10200825f, -0.04983346f, 0.05608908f, 0.11417753f, 0.08789038f, 0.04222539f, 0.12899151f, 
    -0.06932812f, 0.02070327f, -0.02664026f, 0.07747118f, 0.43893114f, 0.28633136f, 0.15071994f, -0.33520085f, 
    0.08429647f, 0.04834908f, 0.08146489f, -0.00963138f, 0.01237552f, 0.18896461f, 0.08785834f, 0.03700363f, 
    0.83392459f, -0.13579276f, -0.31159642f, -0.16742368f, 0.13759664f, 0.03548188f, 0.09434608f, 0.02929448f, 
    -0.04894330f, 0.07549943f, 0.03991317f, -0.01658779f, -0.15626885f, -0.07871470f, -0.15650991f, -0.23002183f, 
    0.10200560f, -0.08810940f, 0.05032664f, -0.06469858f, 0.03081049f, 0.00230559f, 0.00688987f, -0.01513463f, 
    -0.03758882f, 0.12133493f, 0.10620169f, -0.03134219f, -0.12955298f, -0.04029178f, 0.03195598f, -0.02862224f, 
    -0.07216746f, -0.17317328f, -0.04641679f, 0.01805350f, -0.02927913f, 0.21498069f, -0.09757917f, 0.29758337f, 
    0.05154567f, 0.12191580f, -0.01215613f, -0.06391146f, 0.05454121f, 0.06900679f, -0.00815182f, -0.02866130f, 
    -0.05860626f, -0.02353604f, 0.09146882f, -0.26343119f, -0.17852452f, -0.16061556f, -0.05626944f, -0.10798489f, 
    -0.06404901f, -0.08877412f, -0.09046458f, -0.12760612f, 0.01170999f, 0.16472253f, -0.10089208f, 0.01602776f, 
    0.02276170f, 0.05194996f, 0.06557458f, 0.16567507f, 0.15704985f, 0.09629746f, -0.07029009f, 0.07329361f, 
    -0.34756020f, 0.02184796f, -0.01173933f, 0.08380263f, -0.09085408f, 0.10019030f, -0.04535102f, -0.02474951f, 
    -0.01152920f, 0.01286306f, -0.07225796f, -0.05400614f, -0.07312588f, -0.09963453f, -0.09530555f, 0.07472359f, 
    0.18478303f, 0.15742259f, 0.06280518f, 0.06072696f, 0.09031696f, 0.01599996f, 0.04226052f, -0.06430867f, 
    -0.16645229f, 0.06953019f, 0.33143699f, 0.01720124f, 0.06951479f, -0.02331817f, -0.05699380f, 0.00555332f, 
    -0.12214153f, 0.06409094f, -0.09071418f, -0.03686380f, -0.25526860f, 0.07827136f, 0.13479538f, 0.31502500f, 
    0.10521427f, 0.06765395f, 0.00066163f, 0.03839548f, -0.10776598f, -0.05302951f, 0.08898858f, -0.00685432f, 
    0.08437099f, 0.01538405f, -0.04957315f, -0.05630216f, -0.04132005f, 0.06662054f, -0.03005835f, 0.00172402f, 
    -0.00870116f, 0.05035415f, 0.17949770f, 0.01933920f, -0.06607912f, 0.36924210f, -0.00455985f, 0.02441733f, 
    -0.12587096f, -0.04871501f, 0.03431543f, -0.04816130f, -0.09024962f, -0.00872552f, 0.02497336f, 0.03132386f, 
    0.20464750f, -0.31996879f, -0.11453085f, 0.18250950f, 0.12314649f, -0.03384622f, 0.09163824f, 0.10339317f, 
    0.00723792f, -0.00154289f, 0.08486465f, 0.10893251f, -0.32821932f, -0.28786510f, -0.06916001f, 0.25817519f, 
    0.00757228f, -0.00001504f, -0.01403357f, -0.06704901f, -0.00790032f, -0.06891541f, 0.04415713f, -0.02147635f, 
    0.06977654f, 0.08636902f, -0.30997163f, -0.29489407f, -0.03766874f, 0.00146570f, 0.06103197f, -0.05407444f, 
    0.08693893f, 0.03097997f, 0.09708945f, 0.07140251f, -0.13122140f, 0.12684602f, 0.20782663f, 0.08433141f, 
    -0.00177295f, -0.03265527f, -0.13294892f, -0.03621264f, -0.12067426f, 0.04593386f, 0.01415785f, -0.07832809f, 
    -0.04495272f, -0.06053836f, -0.16007471f, 0.00784692f, -0.03871479f, 0.08732516f, -0.01412339f, 0.07774173f, 
    0.13449351f, 0.06097396f, -0.01919901f, 0.12167271f, 0.64384109f, 0.13581085f, -0.38079268f, -0.56043607f, 
    -0.08932964f, 0.04659173f, 0.01636329f, -0.13108377f, 0.00611255f, 0.09361202f, 0.11443743f, 0.06273934f, 
    -0.03307600f, 0.07407914f, 0.11721986f, 0.19902691f, -0.00690962f, -0.03128839f, -0.01433458f, -0.01472754f, 
    -0.09039431f, -0.01012641f, 0.05400701f, -0.00356023f, 0.07253622f, -0.17540954f, -0.10951682f, 0.19239666f, 
    0.07163271f, -0.08966342f, 0.05759362f, 0.01611137f, 0.00605078f, -0.07254094f, -0.04960759f, -0.04781269f, 
    -0.19066861f, -0.24194281f, -0.16117990f, 0.12757017f, 0.05888262f, 0.05919105f, 0.02810663f, 0.06645682f, 
    0.05361412f, 0.02264570f, 0.00520701f, -0.02835754f, 0.25666627f, -0.18320523f, 0.17128412f, 0.15447353f, 
    0.01832204f, 0.03249221f, -0.02592191f, 0.06624045f, 0.00590411f, 0.07561838f, -0.04816074f, -0.06955537f, 
    -0.21557888f, -0.07830413f, -0.05539071f, 0.13638234f, 0.01360480f, 0.01832422f, 0.03056049f, 0.13711171f, 
    -0.14911836f, -0.03905232f, -0.07000403f, -0.24204922f, -0.05907669f, -0.00941027f, 0.25911403f, 0.36391070f, 
    -0.01502190f, 0.09274051f, 0.06371168f, -0.00520776f, 0.02427142f, 0.02696140f, -0.02256628f, -0.01796124f, 
    -0.14214081f, -0.13059112f, 0.03795001f, 0.28830433f, -0.11034934f, 0.05235847f, 0.01272475f, 0.05819016f, 
    -0.00417207f, 0.08149339f, 0.04333203f, -0.01858963f, -0.05712529f, 0.06257017f, -0.23962137f, -0.15592003f, 
    0.08410426f, -0.00433653f, -0.05839357f, -0.07545937f, 0.07948715f, -0.00747446f, 0.11950254f, 0.15458688f, 
    -0.33019701f, -0.00384798f, 0.30964148f, 0.11873680f, 0.06008767f, -0.02331538f, -0.13858093f, 0.12676105f, 
    -0.08900212f, -0.10493018f, -0.00121755f, -0.01110516f, -0.52575368f, -0.12355389f, 0.10606341f, 0.46778065f, 
    -0.03456653f, 0.09836952f, -0.08360676f, -0.03435794f, -0.02764351f, 0.04092448f, 0.01350185f, 0.10378575f, 
    -0.03150814f, 0.06996816f, -0.05253755f, -0.13471518f, -0.09698209f, -0.16337727f, 0.02055987f, -0.03664090f, 
    -0.02862733f, 0.03426954f, -0.07030638f, -0.06360615f, 0.03923405f, -0.06164943f, 0.27659887f, 0.06891022f, 
    -0.07580168f, -0.01104960f, -0.08705050f, -0.06614579f, -0.06767070f, -0.03813127f, -0.07566047f, 0.08321655f, 
    0.20092767f, -0.15946570f, -0.14989300f, 0.13684145f, 0.14839682f, 0.03725912f, -0.01608601f, 0.00119745f, 
    0.00576679f, -0.01266639f, -0.01829758f, 0.03604116f, -0.10967128f, -0.21500787f, -0.01843733f, 0.14464508f, 
    0.00789701f, 0.03161555f, 0.01229172f, 0.00201596f, 0.00673258f, 0.00707947f, 0.04409225f, 0.03788540f, 
    -0.14590646f, -0.04658971f, -0.03845075f, -0.12748998f, -0.11916504f, 0.02492638f, 0.01277992f, -0.11806873f, 
    -0.05474778f, 0.04658083f, -0.20311253f, 0.06379509f, -0.11654971f, -0.04407718f, -0.05886757f, -0.22779256f, 
    -0.04775621f, 0.02357435f, 0.02533380f, -0.05553292f, 0.09187248f, 0.06845547f, 0.25048766f, 0.05517292f, 
    0.17929859f, -0.17971368f, -0.11692398f, 0.24049903f, -0.04547910f, 0.05457772f, 0.09724008f, 0.06782847f, 
    -0.02605435f, 0.10326003f, 0.10392267f, 0.17041692f, -0.17314465f, 0.15260716f, -0.00189632f, -0.04620396f, 
    0.01893019f, 0.00894724f, -0.09266142f, 0.02774853f, 0.00256267f, 0.14723380f, -0.02359604f, 0.08932523f, 
    0.50124913f, 0.18635096f, 0.03989671f, -0.11684623f, -0.05435400f, 0.03349013f, 0.09112095f, -0.04298218f, 
    0.14701933f, 0.05323835f, -0.00021041f, -0.01386627f, -0.00940339f, -0.05614318f, -0.05692780f, -0.15551277f, 
    -0.11912050f, -0.08551823f, -0.03294472f, 0.04106948f, -0.03835937f, 0.02190045f, 0.05294920f, -0.09179651f, 
    -0.00377678f, -0.03053289f, -0.08502679f, -0.17622328f, 0.07929974f, 0.03376799f, 0.02477920f, 0.00342142f, 
    -0.03585526f, 0.12346648f, -0.02346864f, 0.03333133f, 0.25332630f, -0.00966786f, -0.26822087f, -0.31950158f, 
    0.07508632f, 0.11540999f, -0.01352052f, 0.07789887f, 0.03903832f, -0.00979864f, 0.04092507f, -0.03731959f, 
    0.25763389f, 0.05781102f, 0.32468772f, -0.29801539f, -0.25555339f, 0.04366275f, 0.00029966f, 0.00972675f, 
    -0.05532413f, -0.02958876f, -0.00318943f, 0.02784458f, 0.07996100f, 0.02462250f, 0.20072173f, -0.13563575f, 
    0.00696811f, 0.02884957f, -0.05064481f, 0.08227430f, 0.01907535f, 0.02026130f, -0.02338164f, 0.02563219f, 
    -0.00686558f, -0.00822448f, 0.19764578f, -0.15216421f, -0.03038310f, 0.10063984f, -0.06149919f, -0.06883449f, 
    -0.03475600f, 0.07740214f, 0.00255997f, 0.03340942f, -0.14363286f, -0.21287693f, -0.14985768f, 0.05055495f, 
    0.03014557f, 0.02986595f, 0.02553084f, 0.09361044f, -0.12504990f, -0.08300558f, -0.13913946f, -0.06768077f, 
    -0.02218933f, -0.01881981f, 0.13368645f, -0.05470368f, 0.05605674f, -0.03179408f, -0.04780903f, -0.03740147f, 
    -0.05366225f, 0.00342971f, 0.06609450f, -0.00383313f, -0.02261188f, 0.14803247f, 0.03405910f, 0.20535910f, 
    0.02608975f, 0.02662021f, 0.10438960f, 0.00008515f, -0.02474049f, 0.00607268f, -0.03639245f, 0.10471698f, 
    0.12369529f, 0.11390531f, 0.03592361f, 0.11666631f, -0.12560354f, 0.08769046f, -0.04307207f, -0.01230832f, 
    -0.13239567f, 0.02766723f, 0.10026572f, 0.02333586f, 0.01398746f, -0.08771122f, 0.06835905f, 0.27343401f, 
    -0.00166794f, -0.02477443f, 0.15380622f, 0.08424181f, -0.13597725f, 0.17258480f, 0.09819466f, 0.08648761f, 
    -0.12963152f, 0.11002857f, -0.05267142f, 0.07966243f, -0.02681050f, 0.20494470f, -0.07773781f, 0.04811586f, 
    -0.02140456f, 0.03951059f, 0.04242329f, 0.06923740f, 0.00076294f, 0.12501583f, 0.10635393f, 0.26016235f, 
    0.00642719f, 0.03382158f, 0.00255539f, 0.13396908f, 0.00714404f, 0.00508992f, 0.03102736f, 0.00092445f, 
    -0.10737257f, -0.04567347f, 0.09622333f, -0.03377454f, -0.12849887f, -0.03028974f, -0.02940131f, 0.02262216f, 
    -0.03616885f, -0.08366068f, 0.01295748f, 0.03813293f, -0.08867416f, -0.27555853f, -0.16852222f, 0.05782575f, 
    0.10867291f, 0.09163652f, 0.13649304f, -0.06689733f, 0.06045995f, -0.11392099f, -0.02347374f, -0.04052477f, 
    -0.09103526f, -0.12915623f, -0.08834635f, 0.08442920f, 0.00778538f, -0.07727967f, 0.09129452f, -0.09483320f, 
    0.03628995f, 0.05990268f, -0.02778704f, 0.03038272f, -0.15690270f, -0.16906905f, -0.14768365f, 0.12480335f, 
    -0.02200418f, 0.02093630f, 0.04369948f, -0.12012562f, 0.04273432f, -0.04156754f, -0.01019010f, -0.01997418f, 
    0.13059291f, -0.18262389f, 0.20073526f, 0.04912513f, 0.09890766f, 0.01985525f, -0.05341066f, 0.05036533f, 
    -0.05658391f, -0.12542200f, 0.00763084f, 0.05528732f, -0.17349264f, 0.11775698f, -0.13998690f, -0.18392633f, 
    0.09633590f, 0.07982010f, -0.02293561f, 0.04898734f, -0.05739221f, 0.02353701f, 0.02292386f, 0.02315573f, 
    -0.06153120f, 0.01999429f, 0.18105009f, -0.27713367f, -0.15087359f, -0.13927807f, -0.15279971f, -0.03316850f, 
    -0.14331615f, -0.07005880f, -0.13620313f, -0.06298728f, 0.75228763f, -0.16132414f, -0.02702997f, -0.07407887f, 
    0.05496386f, 0.04643522f, 0.11496120f, 0.09898791f, -0.02903255f, 0.01043663f, 0.15335573f, 0.00467681f, 
    0.00539300f, -0.09292998f, 0.02755607f, -0.00376264f, 0.03816999f, 0.11819546f, 0.00059526f, -0.18152162f, 
    -0.00755021f, 0.09330461f, 0.08141748f, -0.01455472f, -0.24758026f, 0.16883017f, -0.08244490f, -0.11470387f, 
    -0.02135344f, -0.17866592f, 0.03020229f, 0.07038561f, -0.08821265f, -0.16226768f, 0.13043950f, -0.18706158f, 
    0.10510369f, -0.24096650f, -0.09145430f, 0.10686342f, 0.09205164f, -0.01020723f, 0.02557775f, 0.04382881f, 
    0.00584117f, 0.05881659f, 0.09744492f, 0.05847389f, -0.09481635f, -0.21310164f, 0.39246851f, 0.19663720f, 
    -0.07987507f, 0.07987774f, -0.05623870f, -0.01705117f, -0.02292123f, 0.08028179f, 0.10551236f, -0.01541744f, 
    0.26640967f, -0.05486442f, -0.03885658f, -0.00449388f, 0.09384166f, 0.08673527f, 0.04074340f, 0.07116084f, 
    -0.02065528f, 0.03871409f, 0.11829138f, 0.11029234f, 0.57060665f, 0.36399028f, 0.09204466f, -0.19519588f, 
    0.03738317f, 0.17066532f, 0.07306626f, 0.05003078f, 0.01976237f, 0.05066383f, 0.15659082f, 0.06902264f, 
    0.79516923f, -0.06731208f, -0.10315214f, -0.14895070f, 0.16286221f, 0.01647584f, 0.08038238f, 0.00518392f, 
    -0.00923294f, -0.04401866f, 0.03641160f, 0.15963414f, -0.04861248f, -0.09847931f, -0.20910518f, -0.12932430f, 
    0.13213263f, 0.01871287f, 0.03726545f, -0.02224219f, 0.00920061f, 0.11178708f, 0.06799422f, 0.02004659f, 
    0.16474091f, 0.15426806f, 0.15275912f, 0.05490889f, -0.07929837f, -0.05706636f, 0.06594122f, -0.04318431f, 
    0.00132725f, 0.11874869f, -0.01181219f, 0.08358443f, -0.05594360f, 0.01139244f, -0.25167853f, 0.21354342f, 
    0.09325117f, 0.06616668f, -0.07880497f, -0.13681075f, -0.04887242f, -0.02137560f, -0.04660465f, -0.10415305f, 
    0.19243145f, 0.19366868f, 0.16014063f, -0.07012225f, -0.00082991f, 0.05948742f, 0.04768960f, 0.01448354f, 
    -0.00845054f, 0.03831014f, 0.03718100f, 0.00657905f, -0.04181244f, -0.01043162f, -0.22161505f, -0.10890631f, 
    0.02727934f, -0.05495209f, 0.02586060f, 0.05647620f, 0.02718190f, 0.02556354f, -0.16394405f, 0.04582482f, 
    -0.34027174f, 0.01270483f, -0.05483509f, 0.05919993f, -0.05166318f, 0.03450893f, 0.00043608f, -0.02330789f, 
    -0.03390805f, 0.00871745f, -0.07262947f, -0.09805748f, -0.08352056f, -0.15987600f, -0.17722026f, -0.09531808f, 
    0.12092211f, 0.09172446f, -0.00219349f, 0.05639523f, 0.07547139f, -0.01469029f, 0.01100532f, -0.08184525f, 
    -0.13651587f, 0.20795137f, 0.39462486f, 0.08819088f, -0.06217487f, 0.13142620f, 0.00398776f, -0.03936833f, 
    0.02407045f, 0.05994361f, -0.08124751f, -0.00544734f, -0.16328692f, -0.04798589f, 0.30750793f, 0.30178845f, 
    0.01807416f, 0.06353057f, -0.02351863f, 0.00313959f, -0.04007976f, -0.02053491f, 0.00919272f, -0.04218720f, 
    0.18133654f, 0.06503588f, -0.09564927f, -0.01411041f, 0.02797468f, 0.01858101f, -0.03025867f, -0.02300546f, 
    -0.03954707f, 0.02045673f, 0.07953732f, -0.13085391f, -0.16312771f, 0.27020457f, 0.05487882f, -0.12817968f, 
    -0.07786239f, -0.02270119f, 0.03303945f, -0.01740981f, 0.13177459f, 0.17495038f, 0.10518532f, 0.23527873f, 
    0.17940965f, -0.27484968f, -0.03257287f, 0.18603253f, 0.07584354f, -0.03082333f, 0.01937548f, 0.03016391f, 
    -0.09798098f, 0.07405958f, 0.07838672f, 0.12410241f, -0.32423636f, 0.01813513f, 0.03703823f, 0.13942438f, 
    -0.01081034f, 0.01668977f, 0.21181107f, -0.02708152f, 0.02767640f, 0.10535812f, -0.02804415f, 0.03663949f, 
    0.27627641f, 0.35377252f, -0.00792177f, -0.09347073f, 0.00634553f, 0.04789719f, -0.01537323f, -0.06375629f, 
    0.08028518f, 0.14591295f, 0.10716148f, 0.11483294f, -0.09305040f, 0.06920858f, 0.28246135f, -0.09776542f, 
    -0.03426408f, -0.06601197f, -0.10586733f, -0.00700802f, 0.12701334f, 0.24705823f, 0.12600189f, 0.09037442f, 
    0.02247730f, -0.04783224f, -0.14202836f, -0.03190397f, 0.02452167f, 0.05317600f, 0.01877284f, 0.03495361f, 
    0.00795060f, 0.05194634f, 0.05050369f, 0.10743735f, 0.71163434f, 0.24600340f, -0.08702157f, -0.35722354f, 
    0.10159760f, 0.04415949f, -0.05811649f, -0.07445985f, 0.07491271f, 0.08992868f, 0.18428236f, 0.02908876f, 
    0.08052309f, 0.12414967f, 0.22849831f, 0.20399201f, -0.10821456f, 0.02206755f, 0.04940768f, -0.00685816f, 
    -0.06447896f, 0.03483836f, 0.05051685f, 0.01005497f, -0.02374902f, -0.25413153f, -0.07455870f, 0.06574347f, 
    0.09721632f, -0.00262882f, 0.03354020f, -0.07263562f, -0.02464248f, -0.03236561f, -0.09399685f, 0.02973211f, 
    -0.19632719f, -0.04572978f, 0.04848490f, 0.03920958f, -0.06916687f, -0.09388734f, 0.01488649f, 0.06210374f, 
    0.07377124f, 0.10137750f, 0.00279859f, 0.05208807f, 0.27417848f, -0.06580944f, -0.00471590f, 0.14924660f, 
    -0.11098687f, 0.09767660f, -0.04069749f, 0.02686498f, 0.03800476f, 0.19810647f, 0.20258647f, 0.09014638f, 
    -0.20583694f, 0.11627882f, -0.13644597f, 0.15374202f, -0.07203950f, 0.06552894f, 0.08691622f, 0.10084516f, 
    -0.08316652f, 0.14680012f, 0.06733403f, -0.01995297f, -0.03696777f, -0.11580665f, 0.00552497f, 0.23950183f, 
    -0.03200892f, 0.02265777f, 0.05687184f, -0.06319487f, 0.00375579f, -0.00479759f, 0.00553845f, -0.04064190f, 
    -0.05816341f, 0.25069284f, 0.11120848f, 0.23478752f, -0.15917322f, 0.04151838f, 0.12540388f, 0.11473051f, 
    0.13631368f, 0.19327618f, 0.11096328f, -0.08397452f, 0.09861916f, 0.37300089f, 0.16182606f, 0.00504500f, 
    0.16220266f, -0.01935681f, -0.00949159f, -0.06279154f, 0.20709142f, 0.04617442f, 0.09143897f, 0.20584792f, 
    -0.12975290f, 0.02911310f, 0.31498247f, 0.08834847f, -0.06195702f, 0.23526829f, -0.06168599f, 0.21196018f, 
    -0.01469969f, -0.07600921f, 0.11853523f, 0.10520606f, -0.36412966f, 0.25496256f, 0.17385113f, 0.30504090f, 
    -0.04792442f, 0.03046381f, 0.20559108f, 0.15612307f, 0.10120394f, 0.03733621f, -0.09179989f, 0.10861669f, 
    -0.01967783f, 0.05899579f, 0.04755812f, -0.11344536f, -0.08164041f, 0.01113121f, 0.09115795f, -0.03415642f, 
    0.17018649f, 0.07813845f, -0.03989137f, 0.15235144f, 0.13029554f, 0.00387494f, 0.31260872f, 0.06731787f, 
    -0.16483155f, 0.02831138f, -0.03136136f, -0.06306209f, -0.07707643f, 0.11299056f, -0.03363779f, 0.01318024f, 
    0.11885037f, -0.20407455f, -0.12611735f, 0.17578585f, 0.10198359f, -0.04557421f, -0.09801532f, -0.07835810f, 
    -0.02827414f, -0.03758428f, -0.00131286f, 0.00820917f, -0.11724833f, -0.09062394f, 0.02424185f, 0.15601794f, 
    0.03670020f, -0.03821326f, 0.03221095f, 0.00710050f, -0.07134242f, 0.10786933f, 0.06403639f, 0.05059890f, 
    0.02280353f, 0.06990319f, -0.00505633f, -0.05136164f, -0.06424428f, 0.01954272f, 0.02693967f, -0.03747262f, 
    0.10651789f, 0.19244260f, -0.00645301f, 0.31202713f, 0.03488483f, 0.24178730f, 0.18544593f, -0.06854928f, 
    0.03465024f, -0.00481168f, -0.00467312f, 0.01012918f, 0.14527866f, 0.11886446f, 0.29195842f, 0.02683942f, 
    0.10561173f, -0.07903777f, -0.05850902f, 0.18089429f, -0.08413144f, -0.10871898f, 0.05988098f, 0.07774278f, 
    -0.08403847f, 0.03273206f, -0.04116519f, 0.04200552f, -0.13512924f, 0.11900183f, -0.08777958f, 0.03947327f, 
    -0.00679211f, -0.01042547f, -0.06453407f, -0.04114910f, 0.17725585f, 0.34314272f, 0.09315237f, 0.28674904f, 
    0.36090633f, 0.30529219f, 0.02242637f, -0.12652379f, 0.00540565f, -0.05884418f, -0.02839589f, -0.05164405f, 
    0.07024664f, 0.01735877f, 0.16741817f, 0.08898097f, 0.04178522f, 0.04858437f, 0.00946418f, -0.04821244f, 
    0.02490488f, -0.05795701f, 0.20804955f, 0.10939690f, -0.06202469f, 0.01484184f, 0.01330519f, -0.08352003f, 
    0.08422194f, -0.02277450f, -0.16927825f, -0.13578406f, 0.02109279f, -0.04427256f, 0.02743569f, -0.07814227f, 
    -0.15717071f, -0.00556355f, -0.12435762f, -0.00867550f, 0.40229541f, 0.12153190f, -0.10250398f, -0.16036771f, 
    0.09839309f, 0.02468164f, -0.03334019f, 0.09378666f, -0.01023855f, -0.01469993f, 0.20582895f, -0.05408815f, 
    0.20731752f, 0.18445198f, 0.37778893f, -0.24108773f, -0.23623657f, 0.05702659f, 0.06319885f, -0.01489552f, 
    0.00553513f, 0.02545525f, -0.04630312f, 0.05947083f, 0.08773497f, 0.09360395f, 0.12392907f, -0.07501411f, 
    -0.05759649f, 0.02425745f, 0.02530485f, -0.07306244f, -0.05846046f, -0.03101964f, -0.04492795f, -0.04015152f, 
    0.15243948f, 0.01992424f, 0.01621522f, -0.03927389f, -0.06559760f, 0.19232327f, -0.03348739f, 0.04158351f, 
    -0.02175922f, 0.12172325f, 0.18491629f, -0.01332020f, 0.02337781f, -0.02448295f, 0.07521764f, -0.00721377f, 
    0.00374227f, -0.03640839f, -0.03354895f, 0.10125236f, -0.01589089f, 0.04014270f, -0.02807397f, 0.03080238f, 
    -0.01268704f, 0.07809033f, 0.07803585f, 0.04526078f, 0.12559199f, -0.01417772f, -0.08657733f, -0.05832978f, 
    -0.11221160f, -0.02229388f, -0.05273863f, -0.08635408f, 0.15213650f, 0.00824430f, -0.08563865f, 0.01398866f, 
    0.00904199f, 0.21013151f, 0.08153660f, 0.11069357f, -0.06046984f, -0.01209196f, -0.06608927f, 0.05751448f, 
    0.31659353f, 0.13186556f, 0.18970357f, 0.13535453f, -0.10137042f, 0.02795541f, -0.04377766f, -0.01547949f, 
    0.06403742f, 0.13458531f, 0.19709900f, 0.05947941f, 0.02554897f, -0.08112828f, 0.03465582f, 0.13377619f, 
    -0.11484051f, -0.11904141f, 0.16249040f, 0.07331742f, -0.06222172f, 0.11165047f, -0.07852764f, 0.06907849f, 
    -0.22934279f, -0.01509773f, -0.15650235f, 0.09241384f, 0.06021581f, 0.11212294f, -0.16640857f, 0.08646870f, 
    0.01546810f, 0.01138103f, -0.01086102f, -0.00132238f, -0.00436492f, 0.07717939f, -0.08349308f, 0.17979237f, 
    0.08461685f, 0.11343159f, -0.04651729f, 0.13726437f, -0.04826269f, 0.03107694f, 0.16782866f, 0.07967558f, 
    0.12619121f, 0.12593307f, 0.13529390f, 0.00770665f, -0.10104349f, 0.06203360f, 0.02172832f, 0.08449680f, 
    -0.05131010f, -0.05546923f, -0.00259623f, -0.03321812f, -0.12268629f, -0.13650675f, -0.09875343f, -0.02192370f, 
    0.00774442f, 0.01800551f, 0.03466682f, -0.00147277f, 0.11138151f, 0.01336402f, -0.03519540f, 0.04521066f, 
    -0.09478198f, -0.20368904f, -0.17333342f, -0.08291897f, 0.06195054f, -0.03960681f, 0.13287410f, -0.04038501f, 
    0.02046122f, 0.01728394f, -0.07035607f, 0.01528442f, -0.20916705f, -0.20922323f, -0.14384863f, 0.12460428f, 
    -0.04090549f, 0.06850632f, 0.05037583f, -0.07973053f, 0.02401393f, 0.10220488f, -0.02653037f, -0.05515794f, 
    0.09376874f, -0.03178808f, 0.02868319f, -0.01661433f, -0.05946195f, 0.06627833f, 0.13460951f, 0.16078313f, 
    0.13085534f, -0.05897743f, 0.05968477f, 0.22673517f, -0.15735662f, 0.15054096f, -0.21632685f, -0.05706144f, 
    0.19051857f, 0.13078314f, -0.04391317f, 0.01451759f, -0.10695995f, 0.06240317f, 0.13738367f, 0.06709976f, 
    0.00078664f, 0.12847316f, 0.25514421f, -0.18978861f, -0.04047028f, 0.10025372f, -0.03534756f, -0.04240219f, 
    -0.04368920f, -0.03634255f, -0.04919146f, 0.06121922f, 0.71431422f, -0.02487712f, -0.01833902f, 0.13651657f, 
    0.12325032f, 0.18971284f, 0.05375588f, -0.02442255f, -0.01515317f, -0.08685511f, 0.20471555f, -0.15284622f, 
    0.01061866f, -0.05261409f, 0.01172889f, 0.01357130f, 0.12649806f, 0.01286218f, -0.00667877f, -0.03845493f, 
    -0.07431530f, 0.09650936f, 0.06470414f, -0.14907029f, -0.09357919f, 0.15659454f, 0.13328427f, 0.03633351f, 
    0.03177164f, -0.01640807f, 0.12327617f, 0.04931754f, 0.05099655f, -0.07609406f, 0.18530196f, -0.02510090f, 
    0.05031495f, -0.22451793f, -0.15775466f, 0.06980491f, 0.03672884f, -0.09062710f, -0.07930026f, -0.04197085f, 
    -0.11537736f, -0.03645202f, -0.02123225f, -0.01817647f, 0.09925178f, -0.19078182f, 0.38878006f, 0.11954786f, 
    0.03694433f, 0.23645516f, -0.05704547f, 0.05516945f, -0.00286139f, 0.15789889f, 0.13442421f, 0.11828323f, 
    -0.01619469f, 0.02757462f, 0.00078364f, -0.02889673f, -0.04115510f, -0.02743267f, -0.02917562f, 0.02795273f, 
    -0.03951466f, 0.02745095f, 0.01967717f, 0.01973272f, -0.04088560f, 0.02921569f, 0.01816634f, -0.00512744f, 
    0.00823298f, 0.01840147f, 0.02359825f, -0.02764342f, 0.01631160f, -0.01453898f, -0.01264227f, 0.01209377f, 
    0.00722724f, 0.00165146f, 0.01202299f, -0.03046729f, -0.03432239f, 0.00890392f, -0.03444822f, 0.02315509f, 
    -0.01978674f, -0.01867132f, -0.03339965f, 0.01005942f, 0.02630300f, -0.01899698f, 0.01901788f, -0.01706454f, 
    -0.01300743f, -0.02007242f, -0.02199192f, 0.00796462f, 0.00780290f, -0.01167931f, 0.02132041f, -0.04182810f, 
    0.02132177f, -0.00996465f, 0.00476431f, -0.00713381f, -0.00457798f, -0.01081478f, -0.04155492f, -0.02539806f, 
    0.00874690f, -0.00262879f, -0.04014492f, 0.01243641f, -0.02829370f, -0.01723720f, -0.00714679f, -0.01122839f, 
    -0.03143070f, -0.03655717f, -0.01447982f, -0.03703402f, -0.01165919f, -0.02441674f, -0.04267649f, 0.02438448f, 
    -0.01240093f, -0.01103844f, -0.01677123f, -0.02594077f, -0.00141372f, -0.00554771f, -0.03333154f, 0.01168776f, 
    -0.00386652f, -0.00650748f, 0.00994476f, -0.01922291f, -0.01754060f, 0.02453625f, -0.02902368f, -0.01999534f, 
    -0.03578047f, 0.00737367f, -0.03632599f, 0.01555873f, 0.01103526f, 0.00111494f, -0.01966746f, -0.01431837f, 
    0.02145270f, -0.04179455f, 0.01017085f, -0.01848502f, -0.01072611f, -0.03897706f, -0.00638413f, -0.03845096f, 
    -0.03305786f, -0.03664014f, 0.02011579f, -0.04038483f, -0.00433027f, -0.01476408f, 0.01047084f, -0.02035426f, 
    0.00674358f, 0.01529409f, 0.01349243f, -0.04184826f, -0.01523655f, -0.04050774f, -0.00188854f, 0.02057154f, 
    -0.01562074f, -0.01259356f, -0.03445730f, -0.01918701f, -0.02957360f, 0.02634076f, 0.00861262f, 0.02637139f, 
    0.00802701f, 0.01547756f, -0.02065113f, 0.00002153f, -0.01248392f, -0.02376471f, -0.00326598f, -0.01618934f, 
    0.00567279f, 0.01532433f, -0.02459404f, 0.00269921f, 0.01955865f, -0.01823921f, 0.01347246f, -0.03271998f, 
    0.02109941f, 0.01052399f, 0.01392338f, -0.00460511f, -0.04021954f, 0.01958353f, 0.02804733f, -0.01820108f, 
    0.00980028f, 0.02244620f, 0.02052343f, -0.01531585f, 0.01527147f, -0.01966719f, 0.02665913f, 0.02283354f, 
    -0.01202169f, -0.01092605f, -0.03110657f, 0.02704874f, -0.01444556f, 0.01202188f, -0.00684216f, -0.02264099f, 
    -0.01703647f, 0.02563394f, 0.02690321f, -0.03332945f, -0.02706533f, -0.01051539f, 0.00011220f, -0.01320786f, 
    0.02917282f, 0.01304125f, -0.03971943f, 0.00517577f, -0.00148336f, -0.02103572f, -0.02772724f, 0.00542199f, 
    0.00273112f, -0.01902607f, -0.02702434f, -0.00865586f, 0.02656956f, -0.02112395f, -0.03627887f, -0.01288960f, 
    -0.02259123f, -0.02090662f, -0.00700602f, -0.04134323f, 0.00309061f, -0.00786718f, 0.02712196f, 0.01427183f, 
    -0.00009674f, 0.01886807f, 0.01778198f, 0.02697822f, -0.02203446f, -0.01591063f, -0.03806603f, -0.00486235f, 
    -0.00028791f, -0.02986546f, -0.03820394f, -0.02931676f, 0.00643266f, -0.01937027f, 0.01038710f, -0.02825942f, 
    0.00418611f, 0.02053429f, -0.00511481f, 0.02657285f, 0.00584674f, -0.02054025f, -0.03200622f, -0.03376822f, 
    0.01395062f, 0.02655151f, 0.02488853f, -0.00286086f, -0.00962983f, 0.01701369f, -0.01596423f, -0.00933522f, 
    0.02293513f, 0.00160794f, -0.01913024f, 0.00291335f, 0.00604266f, 0.00292520f, 0.01397789f, -0.02789849f, 
    0.01098516f, -0.00113781f, -0.02402231f, -0.01572297f, 0.02204242f, -0.02577103f, 0.01713310f, -0.03440298f, 
    0.00383642f, -0.01561450f, -0.03348223f, 0.02280549f, -0.01281198f, -0.04104709f, -0.01850672f, -0.02563269f, 
    0.00552544f, -0.03126125f, 0.02063622f, -0.03842911f, -0.03558522f, -0.00315608f, -0.01776103f, 0.02493891f, 
    -0.02424806f, 0.01426700f, -0.02879529f, -0.02656148f, -0.01277449f, -0.02610195f, -0.01587938f, 0.01966438f, 
    -0.02020612f, -0.01884525f, -0.03898282f, 0.00735540f, -0.03956877f, -0.01650202f, -0.02531730f, -0.00465363f, 
    0.02318323f, -0.03225446f, -0.03931860f, 0.01379195f, -0.01696568f, -0.00053255f, -0.02719091f, -0.01650932f, 
    -0.04155964f, -0.03286179f, -0.02974362f, -0.03749776f, -0.03652313f, 0.01129729f, 0.02784067f, -0.01231317f, 
    0.01168666f, -0.03116594f, 0.02564448f, -0.01227854f, -0.03930169f, -0.01863907f, 0.02759011f, -0.01782368f, 
    -0.04057841f, 0.01656966f, -0.01820989f, -0.00430689f, 0.01058904f, -0.01673478f, -0.00358307f, -0.00150000f, 
    0.02609678f, -0.02560473f, -0.02475787f, -0.02827320f, 0.00474380f, -0.03055869f, -0.03819362f, -0.01563263f, 
    -0.04246148f, -0.00134742f, 0.00433759f, -0.02452050f, -0.00545859f, 0.01764198f, -0.03217085f, -0.02814407f, 
    0.02288559f, -0.01298162f, -0.01854146f, 0.01848426f, -0.03680822f, -0.03633060f, 0.02490194f, -0.01323517f, 
    -0.04427492f, -0.01613264f, -0.02333369f, 0.00345447f, -0.03799620f, 0.02915422f, 0.00989417f, -0.03788316f, 
    -0.04362348f, 0.01971131f, -0.00032224f, -0.00414394f, -0.01271679f, 0.01240339f, 0.01150726f, -0.00278626f, 
    0.02868642f, -0.01115562f, 0.00233410f, 0.00362800f, 0.01424425f, -0.01205137f, -0.00892810f, -0.00503698f, 
    0.01761696f, -0.00499964f, -0.03664996f, -0.02960934f, 0.02597136f, 0.00277298f, 0.02640996f, -0.02985181f, 
    0.00860248f, -0.02823390f, -0.01434703f, 0.02277415f, 0.02531470f, 0.00097713f, 0.02359893f, -0.00810876f, 
    -0.03653970f, 0.01315042f, 0.01875584f, 0.00414524f, 0.02368320f, 0.01641767f, -0.00769546f, 0.00747347f, 
    -0.03213049f, 0.01117611f, 0.02697707f, -0.00386684f, -0.01518791f, 0.00967539f, -0.02131008f, 0.02490086f, 
    -0.00820041f, 0.01738271f, -0.01733054f, 0.00189467f, 0.02235013f, 0.00100975f, -0.02191867f, -0.00959300f, 
    -0.03038931f, -0.01462183f, -0.02267621f, -0.02365515f, -0.02110437f, -0.01477869f, -0.01669860f, 0.00008956f, 
    0.00646772f, -0.01002277f, 0.01814852f, 0.00721142f, 0.01940457f, 0.02096104f, 0.00282695f, -0.01363085f, 
    -0.02257700f, -0.02908603f, 0.00585350f, -0.00908194f, -0.01605501f, -0.02948209f, -0.00412198f, 0.01084758f, 
    -0.03082851f, 0.01219724f, -0.00066863f, -0.00483682f, 0.00516368f, -0.03144354f, 0.02492186f, 0.02026414f, 
    -0.00641407f, 0.00990891f, -0.00983190f, 0.02813112f, -0.01900847f, -0.01956378f, 0.02699306f, 0.01323343f, 
    -0.02807909f, -0.00854919f, -0.00794596f, -0.01327997f, -0.00332479f, -0.00598319f, 0.01508621f, -0.01238394f, 
    -0.00650798f, 0.00117188f, -0.02353922f, -0.02536905f, 0.01552851f, -0.03969371f, -0.01122523f, -0.00723252f, 
    -0.03215834f, -0.01370990f, -0.01279913f, -0.00398039f, 0.02537997f, -0.01615654f, 0.00471802f, -0.01611566f, 
    0.00040322f, -0.02110555f, -0.00748250f, -0.03248592f, -0.01442632f, -0.03988786f, 0.00385734f, -0.01218193f, 
    -0.03167947f, -0.03399484f, -0.03739674f, -0.00523811f, -0.01568883f, 0.00457096f, -0.03307586f, -0.01985252f, 
    0.02405647f, 0.01524761f, -0.03989653f, 0.01744865f, -0.03535855f, -0.01370662f, 0.01126698f, -0.01835326f, 
    -0.02028502f, 0.01894381f, -0.00567517f, 0.00603936f, 0.02322289f, 0.02183711f, -0.00138606f, 0.00088497f, 
    0.01553363f, -0.01389160f, -0.00930605f, -0.03436706f, -0.02067452f, 0.00152516f, -0.02882361f, -0.03005725f, 
    -0.03109868f, -0.03088166f, -0.02786344f, -0.00174621f, -0.03965477f, -0.03730185f, 0.02364904f, 0.00292289f, 
    0.01006236f, -0.00231927f, 0.00274664f, 0.02862269f, 0.01400397f, -0.00529420f, -0.01742516f, -0.02849876f, 
    0.01539832f, -0.01521546f, -0.00395072f, -0.01616077f, -0.04102654f, -0.02124475f, -0.01509679f, 0.01691916f, 
    -0.03257364f, 0.02544674f, -0.03994718f, -0.02378785f, -0.00713065f, -0.03214858f, -0.02046818f, 0.01706828f, 
    -0.01626167f, -0.02163433f, -0.03615159f, -0.01669898f, -0.04235309f, 0.01656805f, -0.00520874f, -0.02198026f, 
    -0.02849835f, 0.02856291f, 0.01365562f, -0.00084516f, -0.02461701f, -0.00052443f, 0.02471884f, 0.01417336f, 
    0.02622105f, -0.00413937f, -0.01051458f, 0.01427810f, -0.01720115f, 0.00855101f, -0.02968619f, 0.00187771f, 
    -0.01760776f, -0.03944737f, -0.01650627f, -0.02870718f, 0.00458447f, -0.02706026f, -0.02705918f, -0.00205692f, 
    -0.01272669f, -0.04212859f, -0.01892558f, 0.01254785f, -0.03059852f, -0.00617494f, 0.01683544f, -0.03757719f, 
    0.00556433f, 0.00170669f, -0.02253783f, -0.01998605f, -0.01236615f, -0.00374199f, 0.02731439f, -0.02189084f, 
    0.01680862f, -0.02146711f, 0.02546843f, 0.02495359f, -0.03708321f, -0.04090796f, 0.01001865f, -0.02336385f, 
    -0.02476904f, -0.04313310f, -0.02028947f, -0.01966983f, -0.02022030f, -0.02385123f, -0.01751827f, 0.02884778f, 
    0.02777047f, -0.01324717f, 0.01318586f, -0.03861083f, -0.03958040f, -0.01831941f, -0.00119236f, -0.01715342f, 
    0.00893574f, 0.02204017f, -0.00478717f, -0.03239214f, -0.00068552f, -0.00155005f, 0.02464848f, -0.03062568f, 
    0.01800539f, 0.01879242f, 0.00622826f, -0.02004378f, -0.02756477f, 0.02368370f, 0.02150110f, -0.01921817f, 
    -0.03248027f, 0.00613384f, 0.01095848f, -0.03861373f, -0.03095532f, -0.01644954f, 0.01965475f, -0.00069737f, 
    -0.00321020f, -0.00765585f, -0.02464103f, 0.02876487f, -0.03239158f, 0.01757202f, 0.00322832f, -0.00295289f, 
    -0.02146087f, -0.03992950f, 0.02509812f, -0.01103206f, 0.02808876f, -0.01654427f, 0.01590664f, 0.02115439f, 
    -0.00426174f, 0.01064035f, 0.02660238f, -0.03232145f, 0.01184658f, 0.02368835f, -0.03929941f, 0.00368995f, 
    -0.02902010f, 0.00006016f, 0.01268009f, -0.04029276f, -0.03760161f, -0.00415702f, -0.01163457f, -0.02916622f, 
    -0.02063233f, 0.00324411f, -0.03815759f, -0.02996111f, 0.01026960f, 0.01065928f, -0.01231001f, -0.00946448f, 
    -0.03695862f, -0.03111326f, -0.00483684f, 0.01957421f, -0.01218051f, -0.00482295f, 0.02823164f, -0.03795215f, 
    -0.03827984f, 0.01199605f, 0.02342898f, -0.03662260f, -0.00364202f, 0.00140862f, 0.02810560f, -0.00419048f, 
    0.02102321f, 0.02074735f, -0.00867055f, -0.01015239f, 0.01068301f, -0.02927554f, -0.03810009f, 0.00180912f, 
    0.02944440f, 0.02949398f, -0.02149935f, -0.00186770f, -0.03332421f, 0.02649510f, -0.01067509f, -0.03750559f, 
    -0.01592968f, 0.01009958f, -0.00968978f, -0.01430802f, 0.01163345f, 0.00266364f, -0.04272727f, -0.00473066f, 
    0.01643416f, 0.01734808f, -0.00711516f, -0.01710783f, 0.00130593f, -0.03274804f, -0.02922854f, 0.01162014f, 
    0.00649602f, 0.02936350f, 0.01595628f, 0.00683391f, 0.00283415f, -0.02074723f, 0.01434185f, -0.01383787f, 
    0.02476129f, -0.03008461f, -0.01720766f, 0.01876918f, 0.02659588f, 0.00768324f, -0.00578382f, 0.01550038f, 
    0.02267668f, 0.02819422f, 0.00739101f, -0.03544266f, -0.01750370f, -0.01084325f, -0.02917651f, 0.00190341f, 
    -0.02007830f, 0.00622360f, 0.02531113f, 0.01320888f, 0.00777132f, 0.01894941f, 0.02729495f, -0.03922772f, 
    -0.00547485f, -0.02141141f, -0.01358548f, -0.00097061f, 0.01690868f, 0.01509903f, -0.03693721f, -0.00598948f, 
    -0.03644985f, -0.03216315f, 0.01005630f, 0.01953011f, 0.00476346f, 0.02218597f, 0.00637047f, 0.02011194f, 
    -0.01382578f, 0.01610535f, 0.01943797f, 0.00304015f, 0.01670945f, -0.03632999f, -0.03326108f, 0.01357391f, 
    0.01736411f, -0.03584068f, 0.02345744f, 0.02267721f, 0.00338016f, -0.02419780f, 0.00436043f, -0.01689356f, 
    0.03008867f, 0.00305638f, 0.00418517f, 0.00586564f, -0.02754727f, -0.02703012f, -0.02132765f, -0.00953668f, 
    0.02088050f, 0.00432048f, -0.00961435f, 0.02752441f, 0.02677698f, -0.01581379f, 0.00096621f, -0.03808087f, 
    -0.02226621f, -0.00164073f, -0.02747841f, -0.01835083f, -0.02908925f, -0.00969601f, 0.01484678f, 0.00633421f, 
    -0.01453468f, -0.03904566f, -0.00995041f, -0.01258487f, 0.02383108f, 0.00030969f, -0.02080770f, -0.00120185f, 
    -0.03695633f, -0.01611919f, 0.02285275f, -0.03306317f, 0.00411111f, -0.02444852f, 0.02185836f, -0.03245839f, 
    0.01415309f, 0.01967413f, -0.02484542f, 0.01106211f, -0.00578645f, -0.02845575f, -0.01541225f, -0.02114726f, 
    0.01216692f, -0.02516471f, -0.01968409f, -0.04053516f, 0.02512827f, 0.00722067f, 0.02704702f, 0.01849177f, 
    0.02928824f, -0.01382009f, 0.01181524f, 0.02856511f, 0.02364244f, -0.03568455f, 0.03462208f, -0.02469043f, 
    -0.01614566f, -0.03662004f, -0.01012803f, -0.01838093f, -0.04042024f, 0.00753697f, 0.00189891f, -0.00095158f, 
    0.02360401f, 0.00136302f, -0.03290891f, 0.00912118f, 0.01131605f, -0.01112596f, 0.01546795f, 0.00619524f, 
    0.02762328f, 0.01503113f, -0.01073780f, -0.00824739f, -0.01071910f, -0.03676570f, 0.02483052f, -0.00759938f, 
    0.02610988f, -0.02337248f, -0.00210068f, -0.02298991f, -0.01485317f, 0.02074928f, 0.02924656f, -0.01903671f, 
    -0.02926017f, -0.02429504f, -0.04014185f, -0.00095718f, 0.00515118f, -0.02946986f, 0.02235089f, -0.01252047f, 
    0.02800397f, -0.03706458f, -0.03079984f, 0.02585534f, -0.03593583f, 0.01421248f, 0.02887293f, -0.02760689f, 
    0.00920797f, -0.02786073f, 0.02323708f, 0.01985726f, -0.02957345f, -0.01283191f, 0.01406221f, 0.02396659f, 
    0.00157857f, -0.01391529f, -0.03339753f, 0.00207399f, 0.00195397f, 0.00339760f, -0.02481006f, 0.02378992f, 
    0.03249737f, 0.01490420f, 0.02610375f, 0.03170787f, -0.02564891f, -0.02850186f, -0.03073876f, 0.01327836f, 
    0.00451915f, -0.02868737f, 0.03100245f, 0.02822139f, -0.00250765f, -0.01230845f, -0.03295260f, -0.03205928f, 
    -0.02900772f, -0.01843534f, 0.03041026f, -0.00539332f, 0.00045872f, 0.02697439f, 0.02993657f, -0.01436378f, 
    -0.02033908f, 0.00747594f, -0.00601857f, -0.01521081f, -0.01934381f, -0.03705821f, -0.00482590f, -0.02059337f, 
    -0.03888070f, 0.03018077f, -0.03999877f, -0.01603231f, -0.01193154f, -0.00833134f, 0.00146752f, -0.01477468f, 
    -0.02398737f, -0.01710343f, -0.00708070f, -0.03709452f, -0.03817638f, 0.00258773f, -0.02094041f, 0.00372270f, 
    0.01069664f, 0.02749107f, -0.00914603f, 0.00584236f, -0.02007273f, -0.02580825f, 0.01905786f, -0.02717663f, 
    -0.00005999f, -0.02902109f, -0.02481669f, -0.02102739f, -0.02799881f, -0.02091258f, -0.00409999f, 0.01046360f, 
    -0.01390015f, 0.00088263f, -0.02574626f, 0.02957476f, -0.01511685f, -0.00467205f, -0.00362791f, -0.01937282f, 
    -0.03460507f, 0.00888018f, 0.01935039f, 0.00150895f, -0.02399684f, -0.03192299f, 0.01885697f, -0.03790338f, 
    -0.02118094f, 0.00172304f, 0.01322465f, 0.02384659f, 0.01544089f, 0.01527054f, -0.03645948f, 0.01855591f, 
    0.00570976f, -0.03280307f, 0.02783149f, -0.03540897f, -0.01910967f, 0.01890134f, -0.00097036f, -0.01841561f, 
    0.01727648f, -0.03173314f, -0.01734605f, 0.01666301f, 0.01454162f, 0.02014204f, -0.00119983f, -0.03902719f, 
    -0.02465537f, -0.01705869f, 0.02327617f, -0.02836271f, 0.01638978f, -0.00223260f, -0.00211448f, 0.02914121f, 
    0.01218443f, 0.02753887f, -0.03334646f, -0.02997518f, 0.00460644f, -0.01439217f, -0.01666864f, 0.02887706f, 
    -0.02389487f, 0.01563309f, -0.00596715f, -0.03602608f, 0.02611671f, 0.00298881f, 0.00071861f, -0.02471693f, 
    0.02694385f, -0.00530673f, 0.01502180f, -0.03368396f, -0.01891453f, -0.04129689f, -0.03409572f, 0.02199477f, 
    -0.00259611f, 0.03004964f, 0.02027019f, 0.02511785f, 0.02923207f, -0.02067994f, 0.02638125f, -0.02733270f, 
    0.00859761f, 0.01403444f, 0.01418337f, -0.01441039f, 0.03014748f, -0.02441788f, -0.01492433f, 0.00133345f, 
    -0.00056861f, -0.03754432f, -0.03480145f, -0.03640236f, -0.02500265f, 0.02976022f, -0.00294790f, -0.02115816f, 
    0.00706619f, -0.02820175f, 0.00384656f, -0.00663090f, 0.00357478f, -0.01706459f, -0.03111370f, 0.01723740f, 
    0.02371863f, -0.02292296f, 0.02964268f, 0.02445257f, -0.02718577f, -0.00568524f, -0.00480612f, 0.03087223f, 
    -0.03797042f, 0.02768792f, 0.00140804f, 0.02196525f, -0.02380094f, -0.00170779f, 0.01468432f, 0.02376354f, 
    0.00336712f, -0.02407753f, 0.02010851f, 0.01370733f, -0.03466039f, -0.02829518f, 0.01708155f, -0.01982432f, 
    0.03348915f, -0.00605600f, -0.01573169f, 0.00511561f, -0.02334714f, 0.02178126f, 0.00083505f, 0.01761442f, 
    -0.01669358f, 0.02806237f, 0.01698969f, -0.03396880f, 0.00288159f, 0.01418971f, -0.02485038f, 0.01710296f, 
    0.01907004f, -0.02541512f, 0.02199764f, -0.01801003f, -0.02658588f, -0.00814786f, 0.02527495f, 0.00715711f, 
    0.02454757f, -0.00783496f, 0.01402617f, -0.02210578f, 0.03116965f, -0.00102672f, -0.02628918f, -0.02910640f, 
    -0.02521161f, 0.00690349f, -0.02422774f, -0.03515015f, 0.02476626f, 0.00447273f, -0.03447104f, -0.00715727f, 
    0.01573397f, 0.02929528f, 0.03048919f, -0.03228050f, -0.00307664f, -0.01467694f, -0.03929021f, -0.02189511f, 
    -0.03089185f, 0.00507912f, -0.00749330f, 0.01007235f, -0.01522615f, 0.01213359f, -0.03814670f, -0.00259844f, 
    0.02773986f, -0.03859147f, 0.01513445f, 0.00887520f, -0.03864605f, -0.03669455f, 0.00405522f, 0.00545444f, 
    0.02471700f, 0.02608366f, 0.00649107f, -0.00462698f, -0.00258402f, 0.00096467f, 0.01677525f, -0.00757793f, 
    0.02209859f, -0.02806869f, -0.01549468f, -0.01297500f, 0.00185680f, 0.00002413f, 0.01266404f, -0.01301243f, 
    -0.00701434f, -0.01104300f, 0.02990949f, -0.00942904f, 0.02575886f, -0.00705658f, -0.00325859f, 0.01314997f, 
    -0.01241272f, -0.02476635f, 0.00119787f, -0.00657784f, 0.02811312f, 0.00285088f, 0.02753864f, -0.01213393f, 
    0.01412431f, -0.00110842f, 0.01092395f, 0.00927699f, -0.01892307f, 0.00306535f, -0.00886821f, 0.00651326f, 
    -0.03451195f, -0.04110565f, 0.02522485f, -0.03085442f, -0.00366081f, -0.00321716f, -0.00969780f, 0.00715782f, 
    -0.02034198f, 0.00177288f, 0.02955743f, 0.00077759f, 0.01724151f, -0.03369517f, -0.00926349f, 0.00874777f, 
    0.02653834f, -0.01830189f, 0.02405703f, 0.02961904f, -0.01160808f, -0.00286753f, -0.02354970f, -0.02378548f, 
    -0.03445240f, -0.03318296f, -0.00969108f, 0.02010236f, -0.00490073f, -0.02675648f, -0.00281216f, -0.02035073f, 
    0.00618425f, -0.03692994f, -0.00148443f, -0.03494333f, 0.00545112f, -0.00759577f, -0.00840515f, -0.03870208f, 
    -0.01703177f, -0.03676895f, 0.00244716f, 0.00006966f, -0.01311441f, 0.01250528f, -0.01154807f, 0.00182364f, 
    -0.02179424f, -0.02688441f, 0.01975466f, 0.01312349f, -0.00306013f, 0.00855445f, -0.00984921f, -0.01693192f, 
    -0.03256727f, -0.04145496f, 0.02058319f, -0.01894772f, 0.00415913f, -0.01858303f, 0.02555010f, -0.00658461f, 
    0.01848135f, 0.02037426f, -0.00231213f, 0.00476401f, -0.00988077f, -0.03595925f, -0.03420946f, -0.03592352f, 
    0.02733720f, 0.02135950f, 0.01344486f, 0.03284442f, 0.00345231f, 0.01433511f, 0.01656829f, 0.02969832f, 
    0.01156386f, 0.01805614f, 0.00325013f, -0.01783831f, 0.02805846f, -0.00183202f, -0.02962469f, -0.00131936f, 
    0.01860602f, -0.01713433f, 0.02639633f, 0.03526135f, 0.02934910f, -0.00453163f, 0.01287642f, -0.01054284f, 
    -0.03685122f, 0.01666420f, 0.01520676f, 0.01751561f, 0.02550729f, -0.02794542f, 0.00243509f, -0.02245331f, 
    -0.00973747f, -0.03585650f, 0.01186551f, -0.00094907f, -0.00044801f, -0.01763817f, -0.02334176f, -0.00388324f, 
    -0.01175979f, 0.01927447f, 0.01390669f, -0.01406774f, -0.02555150f, 0.03022845f, -0.01269624f, 0.01621124f, 
    -0.02772685f, 0.01390847f, -0.00405148f, 0.00094585f, -0.02894430f, -0.03719289f, -0.03470799f, -0.02113308f, 
    -0.02474867f, -0.00864195f, 0.01495582f, -0.00681112f, -0.00417589f, -0.01032617f, -0.00936707f, -0.03353221f, 
    -0.01320536f, -0.00541185f, -0.01032969f, -0.00844066f, -0.01047318f, 0.01218811f, -0.01723137f, 0.02752000f, 
    -0.02131498f, 0.03014040f, -0.00941084f, -0.02387141f, 0.01298693f, -0.02844959f, 0.00296241f, 0.01366717f, 
    -0.01363347f, -0.01612234f, -0.00672710f, -0.03503605f, 0.02019201f, 0.02869330f, -0.03863728f, -0.01102494f, 
    0.02116908f, -0.02139537f, 0.01405398f, 0.01001280f, 0.01666940f, -0.00059145f, 0.00908580f, -0.00773872f, 
    0.02399807f, -0.01818753f, 0.00567684f, -0.01007360f, 0.02393172f, -0.03088327f, 0.02473729f, 0.01392906f, 
    0.01363322f, 0.00584590f, -0.00172823f, 0.02016463f, 0.01798270f, 0.00253124f, -0.03251634f, 0.02055281f, 
    0.02858126f, 0.02636223f, -0.02372600f, 0.01420772f, -0.01974165f, -0.01523665f, 0.02065263f, 0.02844936f, 
    0.00578424f, -0.03436551f, -0.03072366f, -0.02204273f, -0.00483038f, -0.01664188f, 0.01723833f, 0.01981928f, 
    -0.03985687f, 0.01469543f, -0.02058357f, 0.00156794f, -0.02831991f, -0.03054063f, -0.02255596f, -0.00718043f, 
    -0.04100401f, 0.00378105f, 0.02641431f, -0.02898457f, -0.01706233f, 0.00881113f, -0.01149306f, -0.02174454f, 
    0.02037453f, -0.01769018f, 0.01889925f, -0.01132437f, -0.00012035f, -0.01559936f, 0.01373765f, -0.00789358f, 
    0.01101641f, -0.03115660f, 0.02958320f, 0.01442378f, -0.02254036f, -0.02927531f, 0.02926609f, 0.02103257f, 
    0.02881999f, -0.03778642f, -0.00623617f, -0.03618982f, 0.03040559f, -0.00047533f, -0.03826479f, -0.01949831f, 
    0.01151208f, -0.01649008f, 0.01614119f, 0.00152302f, -0.02698576f, -0.03224449f, -0.01660237f, -0.02010032f, 
    -0.00122949f, 0.00902369f, -0.01502256f, -0.04194159f, -0.02285116f, 0.01767696f, -0.02819957f, 0.02986913f, 
    0.00755547f, -0.01526724f, -0.00287670f, -0.01379734f, -0.01886562f, 0.02014636f, 0.00231291f, 0.01637112f, 
    -0.00104909f, -0.00487311f, 0.00065632f, -0.02516145f, -0.00414209f, 0.02476322f, 0.02616731f, -0.02777215f, 
    -0.01227480f, -0.03785203f, -0.04139179f, 0.00342471f, -0.01940384f, 0.00827571f, -0.02032150f, -0.00697151f, 
    0.03150020f, -0.03096878f, 0.00087090f, 0.03521478f, -0.00043278f, 0.00473013f, 0.02688904f, 0.01099107f, 
    -0.01463186f, -0.03832073f, 0.01204236f, -0.00820994f, 0.00319853f, -0.02151143f, -0.00628475f, -0.02512457f, 
    -0.02924621f, 0.00477745f, -0.03429563f, 0.01324949f, -0.02952462f, 0.01152880f, 0.00663514f, -0.01952312f, 
    0.02925319f, -0.03149756f, -0.01319072f, -0.01447190f, -0.00368161f, 0.01332715f, 0.01357563f, -0.03685692f, 
    -0.02614855f, 0.02457935f, -0.01791310f, 0.01970425f, 0.03105734f, -0.02215113f, -0.01001417f, -0.03460856f, 
    -0.01931220f, 0.02370950f, 0.02773233f, -0.00121464f, -0.03456186f, 0.01640931f, 0.01255793f, 0.02807363f, 
    -0.02996688f, 0.02462794f, -0.03534334f, -0.03944571f, -0.01019270f, 0.01962892f, 0.00150083f, 0.01511594f, 
    -0.01522061f, -0.02341503f, 0.02371579f, 0.02272325f, -0.00641130f, -0.03698701f, -0.00893356f, -0.03743567f, 
    -0.01168494f, 0.02154065f, -0.00084397f, 0.01618961f, -0.04166958f, -0.04185680f, -0.00683307f, 0.01845037f, 
    0.02243034f, -0.03964247f, 0.00164727f, -0.02511406f, 0.01680685f, -0.00830233f, 0.02799682f, -0.00056193f, 
    -0.02928479f, -0.03457579f, 0.02948121f, 0.02004115f, -0.00374709f, -0.00182027f, 0.02417023f, -0.02784802f, 
    -0.02383455f, 0.02365303f, 0.00743599f, -0.04096223f, 0.02952186f, -0.02818215f, -0.00155863f, 0.02947952f, 
    -0.00397519f, 0.02730312f, -0.03130469f, 0.01109516f, 0.02545192f, 0.00897418f, 0.02600330f, -0.02289953f, 
    -0.02022083f, -0.00293382f, -0.03351682f, 0.00970384f, -0.03834973f, -0.03109896f, -0.01883409f, -0.04117359f, 
    0.02404460f, 0.01723006f, -0.01456153f, -0.02480684f, -0.03982714f, -0.03806739f, 0.01468132f, 0.00044052f, 
    -0.03203472f, 0.01092136f, -0.03742477f, 0.00643415f, -0.03486032f, 0.00022949f, 0.00691603f, -0.02304895f, 
    0.03406731f, -0.02226938f, 0.00375587f, -0.00914051f, 0.00548194f, -0.04153271f, -0.01300036f, -0.00928110f, 
    -0.02327592f, -0.02083030f, -0.00270862f, -0.00670530f, -0.03264065f, 0.02523974f, 0.01545790f, -0.00274053f, 
    -0.02293072f, 0.00741869f, -0.03997686f, 0.02768598f, 0.01287863f, 0.00148368f, -0.03469374f, -0.03494818f, 
    -0.00829624f, 0.00192120f, -0.02623645f, 0.01000743f, -0.02671607f, -0.03524894f, -0.01976290f, -0.02158109f, 
    0.02185251f, -0.01146198f, -0.03191676f, -0.00963540f, -0.03913664f, 0.01183609f, 0.00603356f, 0.02721720f, 
    -0.03461422f, 0.01493043f, 0.01535518f, -0.03084373f, 0.02434396f, 0.01826506f, -0.02538989f, -0.00032796f, 
    -0.00216202f, -0.00446417f, 0.01621735f, -0.02152075f, -0.03284338f, 0.02196044f, 0.01427022f, -0.03106382f, 
    -0.01054420f, -0.02728759f, 0.03321933f, -0.00941939f, 0.00411241f, -0.00868602f, -0.00299583f, -0.02582677f, 
    -0.03200969f, -0.01832584f, 0.01603316f, -0.03674881f, -0.01225378f, 0.02535954f, -0.02952697f, -0.02490157f, 
    0.01631332f, 0.01213452f, 0.01693904f, -0.00950851f, -0.00009839f, -0.02432132f, -0.02031048f, -0.01802675f, 
    0.02401219f, -0.01858800f, 0.00841992f, -0.01251352f, -0.02702133f, -0.02672150f, -0.02093876f, 0.02550473f, 
    -0.03608051f, 0.00303517f, 0.00166904f, -0.01049433f, -0.00945563f, -0.00756748f, 0.00201290f, 0.01894933f, 
    -0.03992144f, -0.01710898f, 0.02965278f, -0.02037902f, -0.01117724f, 0.00120157f, -0.03609635f, -0.00600482f, 
    0.00830953f, -0.01268547f, -0.03909012f, 0.02289878f, -0.01035594f, -0.01940447f, 0.02774650f, -0.00784988f, 
    -0.04062687f, -0.01848168f, -0.03269236f, 0.00559260f, -0.03076847f, -0.01725327f, 0.02742074f, 0.02227868f, 
    0.02605074f, 0.00372574f, -0.01285738f, 0.00774858f, -0.02628533f, 0.00260717f, -0.02640960f, -0.00314574f, 
    0.01321500f, -0.03884864f, -0.00330815f, -0.01703568f, 0.02367203f, 0.02870161f, -0.01934477f, -0.01748146f, 
    -0.02485229f, 0.03425676f, -0.02982904f, -0.01623140f, -0.00339526f, -0.01255227f, -0.01789280f, 0.02432225f, 
    -0.04233022f, -0.03397854f, -0.01265620f, -0.03763622f, -0.00356894f, 0.01367449f, -0.03758022f, -0.03222162f, 
    0.01114504f, -0.01507649f, -0.03085412f, -0.02667642f, 0.00203765f, -0.01067878f, -0.03331077f, 0.01790081f, 
    -0.01973606f, 0.03528630f, -0.01605709f, -0.03291088f, 0.00018699f, -0.03128032f, -0.00595200f, -0.03257526f, 
    -0.03741582f, -0.01852022f, -0.03750009f, -0.01191230f, -0.02675616f, 0.01342388f, -0.03793417f, -0.01426263f, 
    0.01505934f, -0.03748479f, -0.01612820f, 0.00876361f, 0.02068520f, 0.01405335f, 0.01174905f, 0.02872992f, 
    -0.00568712f, 0.00913462f, 0.02885820f, -0.01923646f, -0.03337776f, 0.02855182f, -0.03168729f, -0.00032740f, 
    -0.03136124f, -0.01318645f, -0.00955709f, -0.02793710f, -0.03019003f, 0.00010504f, 0.00586709f, 0.01305094f, 
    -0.01017067f, -0.00231164f, 0.00684537f, 0.00182051f, -0.00348284f, -0.00986433f, -0.02551714f, 0.00821535f, 
    -0.01191614f, 0.03495298f, 0.01230152f, -0.01074813f, 0.02449244f, 0.02439429f, 0.01924446f, 0.00713613f, 
    -0.03466057f, -0.03282171f, -0.01194858f, 0.02663832f, -0.04158093f, -0.00503338f, -0.03493182f, 0.02303494f, 
    0.00411621f, 0.03510471f, 0.00419511f, 0.01188217f, -0.00919972f, -0.00561038f, 0.02758948f, -0.00662248f, 
    0.00379830f, -0.03152329f, -0.01566279f, 0.01800026f, -0.00251821f, 0.00186305f, 0.01079636f, 0.01976626f, 
    -0.03489183f, 0.01664599f, -0.04179078f, -0.00472175f, 0.00790055f, 0.01763823f, -0.03590473f, -0.00759973f, 
    -0.01998191f, -0.02080162f, -0.01967909f, 0.00864669f, -0.03975653f, -0.02808738f, 0.02286167f, 0.01189972f, 
    -0.03487384f, -0.00768383f, -0.03864974f, -0.00366392f, 0.02610139f, 0.01299763f, 0.00863990f, -0.00478369f, 
    0.01929022f, -0.03885791f, 0.01437617f, 0.01983192f, -0.03833931f, -0.01273538f, -0.02188533f, -0.03737302f, 
    0.00417584f, 0.00833178f, -0.02638081f, 0.02461195f, -0.02639015f, -0.02522528f, -0.04011078f, -0.00784119f, 
    0.02460007f, 0.00190914f, -0.04092138f, -0.01448524f, -0.02568159f, 0.02054028f, 0.00118925f, 0.02681262f, 
    -0.01432822f, 0.00199030f, 0.00737104f, 0.02411810f, -0.04158132f, -0.00757297f, -0.03316916f, -0.02555164f, 
    0.00264601f, -0.02969190f, 0.02346395f, -0.03585713f, 0.01894500f, -0.01296277f, -0.00818474f, 0.02685950f, 
    0.00989353f, 0.00861466f, -0.00603457f, 0.01645316f, -0.00368978f, -0.02241009f, -0.03391856f, -0.02326436f, 
    -0.02980612f, -0.02031048f, -0.02830268f, -0.01282999f, 0.00976253f, 0.02801606f, 0.01516637f, -0.00556257f, 
    0.00866676f, -0.00689055f, 0.00370297f, -0.03229400f, -0.00629389f, -0.03908183f, -0.00347790f, -0.02887134f, 
    -0.00474608f, 0.02321057f, -0.02583766f, 0.01394415f, 0.00114248f, 0.00267677f, -0.03468189f, -0.03968750f, 
    0.02620616f, -0.00181837f, 0.01098183f, 0.00406820f, 0.00064524f, 0.01371976f, -0.03810076f, -0.04004670f, 
    -0.03581025f, 0.00553205f, 0.02286977f, 0.01729367f, -0.01563615f, -0.01862046f, 0.02368020f, -0.02257956f, 
    -0.03418820f, 0.00905135f, -0.02120487f, -0.02460732f, 0.00386368f, -0.01174384f, -0.00519680f, -0.01485089f, 
    -0.02604629f, -0.03107420f, -0.02281340f, 0.01951378f, -0.01760667f, 0.00034318f, -0.03442700f, -0.03459681f, 
    0.00159109f, -0.02289671f, -0.00441082f, 0.01046550f, -0.00713056f, 0.00757510f, -0.01709562f, 0.01453205f, 
    0.01809509f, 0.01617430f, 0.00876829f, 0.02060493f, 0.02074778f, -0.02207694f, -0.01395610f, 0.01495474f, 
    0.02495378f, 0.02682194f, -0.00560919f, -0.02081038f, -0.01051100f, -0.02436309f, -0.02412099f, -0.03091393f, 
    -0.02402528f, -0.02125193f, -0.03073874f, 0.03084836f, 0.02053155f, -0.01336919f, 0.03379471f, 0.03344401f, 
    0.02027478f, 0.02204952f, -0.01812657f, -0.02641186f, -0.02052931f, -0.01557559f, -0.02097661f, -0.01298228f, 
    0.01970308f, -0.03097575f, -0.03541521f, 0.01601437f, -0.00029680f, -0.03179304f, -0.02341716f, -0.00443853f, 
    -0.01782631f, -0.03254184f, 0.01864322f, 0.02160113f, -0.02103972f, -0.00080810f, 0.00743002f, 0.00773534f, 
    -0.02473469f, -0.01721310f, 0.01798793f, -0.04042937f, -0.01441603f, 0.01355225f, 0.01426860f, 0.01288550f, 
    -0.01453461f, -0.03545235f, 0.01216829f, -0.02086742f, 0.01850447f, 0.00974764f, 0.02110497f, 0.02605846f, 
    -0.01264755f, -0.02170040f, 0.02900412f, 0.01657022f, -0.03027790f, -0.03586881f, -0.02286117f, -0.00397491f, 
    -0.01674042f, 0.00218466f, -0.00522530f, -0.04220743f, 0.01428144f, -0.00555106f, -0.03790960f, 0.01785139f, 
    -0.00876281f, 0.00533000f, -0.00554168f, -0.01114943f, 0.00423198f, -0.03994017f, -0.00201577f, -0.01837990f, 
    -0.02492726f, 0.01548213f, -0.02038453f, 0.02896627f, -0.03969559f, 0.03407691f, -0.00026666f, 0.00144302f, 
    -0.01375791f, 0.01899558f, -0.04020287f, 0.01875444f, 0.00950282f, -0.02692636f, -0.02085225f, -0.02405927f, 
    0.02141734f, -0.02483534f, -0.01980765f, 0.02319003f, 0.00454795f, -0.02758219f, 0.01559097f, -0.01322251f, 
    -0.01735607f, -0.01809453f, -0.01489070f, 0.01470924f, 0.00923705f, 0.01740059f, -0.02881095f, 0.01470402f, 
    -0.02055488f, -0.02537829f, 0.01506867f, -0.02463572f, 0.00107339f, -0.01671771f, -0.01279781f, -0.01449164f, 
    -0.03472823f, -0.00581457f, -0.01736139f, 0.02796393f, -0.03271311f, 0.01327262f, -0.02316304f, -0.03941621f, 
    0.01689242f, 0.01613962f, -0.02899735f, -0.02023279f, -0.03428499f, 0.00691557f, -0.00884181f, 0.02470387f, 
    -0.01449008f, -0.04126056f, 0.01409929f, -0.01680690f, 0.02196283f, -0.03558654f, -0.02749514f, -0.00068651f, 
    -0.04177891f, -0.02233458f, 0.01761011f, -0.01230110f, -0.01616879f, -0.02611764f, -0.00703350f, 0.00016686f, 
    0.01375104f, -0.02999485f, 0.01831409f, -0.01991162f, -0.04131050f, 0.01641612f, 0.00745089f, 0.00198664f, 
    -0.03588455f, 0.00918616f, -0.01466350f, 0.00584562f, -0.02869499f, -0.02805808f, 0.02029628f, -0.01124677f, 
    -0.03034117f, -0.00936332f, 0.01944878f, -0.01101658f, -0.01426545f, 0.02916274f, 0.00659261f, -0.01681616f, 
    -0.03517679f, -0.03728971f, -0.02946557f, -0.01672198f, 0.02517582f, 0.01971623f, 0.01222983f, 0.02499313f, 
    0.00394790f, -0.00533061f, 0.00000227f, 0.00066922f, -0.01572672f, -0.01001562f, -0.02467316f, -0.03217988f, 
    -0.02682581f, -0.04171408f, 0.01041977f, -0.02114301f, -0.03117770f, -0.03237551f, -0.01847474f, -0.00289517f, 
    -0.01835143f, 0.01555556f, -0.02294304f, -0.01429605f, 0.02309325f, 0.00364887f, 0.00074824f, -0.02085119f, 
    0.00044836f, 0.00087310f, -0.03629161f, 0.02125917f, -0.03114106f, 0.01594338f, 0.00022247f, -0.01048139f, 
    0.02362417f, 0.00125806f, 0.00950848f, -0.01661070f, -0.00772476f, -0.00625229f, 0.01199332f, -0.01551273f, 
    0.02465804f, -0.03097859f, -0.00597389f, -0.02654159f, -0.00348652f, 0.02432239f, -0.04238263f, 0.00171624f, 
    0.00997646f, -0.02430120f, -0.02288013f, 0.00783889f, 0.00616288f, -0.01923052f, -0.01887240f, -0.01223410f, 
    0.00255078f, 0.00714411f, -0.02869865f, -0.01748142f, -0.00967682f, 0.01951160f, 0.00512008f, -0.03743032f, 
    -0.01328462f, 0.02813838f, 0.00956887f, 0.00502258f, -0.03695153f, -0.01652786f, -0.00721233f, -0.00323457f, 
    -0.00125542f, -0.03641580f, -0.03227719f, -0.00735516f, -0.01916852f, 0.01123124f, 0.01715010f, -0.02017081f, 
    -0.02741256f, 0.01060363f, 0.01748498f, -0.01696303f, 0.01303841f, -0.02443763f, -0.02659675f, -0.02695830f, 
    -0.02000946f, -0.02565288f, -0.00794313f, -0.02702454f, 0.00420406f, 0.01908295f, 0.02908089f, -0.02130473f, 
    0.02835181f, -0.01609086f, -0.03638289f, 0.00666354f, 0.00142183f, -0.02651902f, 0.00319260f, 0.02703199f, 
    -0.02779236f, 0.01008213f, 0.02361422f, -0.04010495f, -0.03799570f, 0.02455558f, 0.01788327f, 0.02043329f, 
    -0.03335829f, 0.00055329f, 0.01119361f, 0.01518996f, 0.00572833f, -0.01428496f, -0.00324549f, 0.00986798f, 
    -0.02773045f, -0.00562056f, 0.00196548f, 0.00798165f, 0.01754731f, -0.01860544f, 0.00387878f, 0.00095094f, 
    0.00401622f, 0.00033039f, 0.01062887f, 0.00423198f, 0.01297949f, 0.02378032f, -0.03909533f, -0.01547475f, 
    -0.03651205f, -0.03786367f, 0.00338135f, -0.01569836f, -0.02881045f, -0.03816408f, 0.02947471f, -0.01067257f, 
    0.02674652f, -0.02535406f, 0.02066515f, -0.00800069f, 0.00624349f, -0.00472054f, 0.00813111f, -0.01212062f, 
    -0.03772888f, -0.00432222f, 0.01153610f, 0.01482087f, -0.00290346f, 0.02051449f, 0.02613911f, -0.02841105f, 
    -0.01359885f, -0.01356775f, 0.01208537f, 0.00664058f, -0.03405609f, -0.01375246f, -0.00249611f, -0.01338786f, 
    -0.00190667f, 0.02148020f, 0.01525295f, -0.01069730f, 0.01491646f, 0.00366099f, 0.01746082f, -0.01827101f, 
    -0.02571267f, -0.00889716f, -0.02730017f, -0.04174062f, 0.01257780f, -0.02456853f, -0.02008705f, -0.00301923f, 
    -0.00485738f, -0.01470559f, 0.00069694f, 0.00799630f, 0.01538316f, -0.03920444f, -0.03686635f, 0.02753099f, 
    0.02056780f, 0.01083575f, -0.01339816f, 0.02537782f, -0.04119490f, 0.01686062f, -0.03702757f, -0.04025953f, 
    -0.02989743f, -0.00055122f, -0.04162761f, -0.03587493f, 0.00995723f, 0.02962689f, -0.00735676f, -0.00805484f, 
    0.00564694f, -0.03077083f, 0.01272859f, -0.03246215f, 0.01068056f, 0.01961654f, -0.00236485f, 0.02355404f, 
    -0.02977062f, 0.00477899f, 0.00819213f, -0.03860778f, 0.00019832f, -0.03648787f, 0.00091900f, -0.03562707f, 
    -0.03137908f, 0.02510964f, 0.02215766f, -0.02510517f, -0.04197647f, 0.01846488f, -0.02387835f, 0.01777070f, 
    -0.00866544f, 0.02938520f, -0.02527147f, 0.00124295f, 0.00005954f, 0.02676035f, 0.00503029f, -0.01690368f, 
    -0.02628254f, -0.02392107f, -0.02634991f, 0.00633963f, 0.02111347f, -0.01011364f, -0.02431384f, -0.00583370f, 
    -0.01612221f, 0.00269695f, 0.01368017f, 0.02441131f, -0.01561939f, 0.02735789f, 0.02482564f, 0.01162712f, 
    -0.03605498f, 0.01026953f, 0.00266342f, 0.01250375f, -0.02482339f, -0.04167835f, -0.03299661f, -0.00154241f, 
    0.01798778f, -0.00555307f, 0.01136713f, 0.02705323f, 0.01734847f, 0.03783796f, 0.02640125f, 0.01491580f, 
    0.02872112f, -0.00197225f, -0.02499084f, 0.02593031f, -0.01331930f, -0.00418161f, -0.02028966f, -0.02667744f, 
    0.00899526f, 0.00376169f, 0.01069639f, 0.01933633f, -0.01406624f, 0.02758517f, 0.01960542f, 0.01605993f, 
    -0.01296260f, -0.01587510f, -0.01271015f, -0.01432991f, 0.01207160f, 0.01738689f, 0.01893884f, -0.03251355f, 
    -0.01436878f, 0.01145762f, -0.03746807f, 0.00213694f, 0.00334442f, 0.02347026f, -0.01413299f, -0.03055277f, 
    0.01925988f, 0.00864546f, 0.00170213f, -0.01626344f, -0.01156246f, -0.01064429f, 0.02812827f, -0.02237970f, 
    0.01966839f, -0.02961451f, -0.02116217f, -0.03838784f, 0.00078524f, 0.00082842f, -0.00613977f, -0.03589835f, 
    -0.02415284f, -0.00144925f, 0.00424705f, -0.03680271f, -0.01787898f, 0.01037252f, -0.03460506f, 0.01252741f, 
    -0.02569711f, -0.00283234f, -0.04002047f, 0.02670001f, -0.02699786f, -0.02009772f, -0.01461806f, 0.00754977f, 
    -0.02284905f, -0.02055384f, -0.03704319f, -0.02341592f, 0.00451648f, 0.02474340f, 0.01666343f, -0.02391219f, 
    0.01145179f, 0.00226285f, 0.02601081f, -0.04097622f, 0.02411414f, -0.03212637f, -0.00808546f, -0.00157502f, 
    -0.01188466f, 0.00118079f, 0.02651937f, 0.02803333f, 0.01294569f, 0.01693617f, -0.02542802f, -0.00758726f, 
    -0.00403270f, 0.00168470f, 0.01450636f, -0.00678435f, 0.02390797f, 0.01755620f, -0.03249492f, -0.03453671f, 
    -0.00621351f, 0.02160954f, -0.00620746f, -0.00898028f, 0.01908332f, 0.00019608f, -0.00324678f, 0.04121068f, 
    0.00472972f, 0.00519680f, -0.02035498f, -0.00824979f, 0.00135827f, -0.02580924f, -0.01373946f, -0.02899964f, 
    0.01467697f, 0.00863148f, 0.01556501f, -0.00681930f, 0.00554135f, 0.01003487f, -0.03876449f, -0.02968035f, 
    0.01945722f, -0.02745133f, -0.03938765f, -0.01880501f, 0.01051713f, -0.02131048f, 0.01350928f, 0.00342103f, 
    0.02992803f, -0.04054614f, -0.03633738f, -0.00415361f, -0.03539798f, -0.00810496f, 0.01867053f, 0.01454421f, 
    0.00664127f, 0.00974604f, -0.03345921f, -0.03077899f, -0.04148409f, -0.01138584f, 0.00968971f, 0.02811633f, 
    -0.03863901f, -0.00274920f, 0.00911970f, -0.00096790f, -0.03974614f, 0.02975112f, 0.00266314f, -0.02357406f, 
    -0.04173531f, 0.00998893f, -0.02030035f, -0.00443730f, -0.00810894f, -0.02175980f, -0.02002509f, 0.01696407f, 
    0.00566360f, -0.00212852f, 0.01512378f, 0.03204082f, 0.01261537f, -0.00515816f, -0.01336268f, -0.02779718f, 
    -0.00211069f, 0.02993281f, -0.02379481f, -0.02588750f, 0.01060202f, -0.03731840f, 0.00471561f, -0.02162211f, 
    0.02035005f, -0.01677528f, 0.00247426f, 0.00706613f, -0.00086587f, -0.00576396f, -0.01491845f, -0.04191070f, 
    -0.01397000f, -0.03167024f, -0.00889495f, -0.00408617f, -0.03018935f, -0.01987697f, -0.03935475f, -0.00071336f, 
    0.01330675f, -0.02329224f, -0.03480484f, 0.02528812f, 0.00048700f, -0.00777134f, 0.02491468f, -0.03564726f, 
    -0.04113571f, 0.00763710f, 0.02960707f, -0.03647848f, -0.00263462f, 0.00454698f, -0.03466440f, -0.01356108f, 
    -0.02364678f, -0.03489869f, 0.01717424f, 0.03156979f, -0.01569672f, -0.01710476f, -0.01269602f, -0.02050092f, 
    -0.00263287f, 0.00277757f, 0.01593687f, -0.01252991f, -0.02603438f, -0.04032178f, -0.01762250f, 0.00638855f, 
    0.00514136f, 0.02147311f, 0.01387324f, 0.02923481f, -0.02860728f, -0.01105114f, -0.00870849f, -0.00923747f, 
    -0.03351262f, -0.00451685f, 0.01386709f, -0.03530203f, -0.01526244f, -0.03227305f, -0.03238804f, 0.01533794f, 
    -0.03250236f, 0.00574482f, -0.02125026f, -0.02204644f, -0.01889557f, -0.01167318f, -0.00188223f, 0.01075508f, 
    0.00080667f, 0.02699207f, 0.01377815f, -0.01464768f, 0.00755295f, -0.01539412f, -0.01167091f, -0.02217411f, 
    -0.00106258f, -0.01089559f, 0.02804923f, -0.02793129f, 0.00377628f, -0.01577715f, -0.00266191f, 0.00465919f, 
    0.02167430f, -0.04204687f, 0.00904383f, 0.02992175f, -0.02631300f, 0.01980879f, 0.02645295f, 0.00270752f, 
    -0.00667093f, 0.01562370f, 0.00199425f, -0.01523182f, -0.02438705f, -0.01334326f, -0.02139761f, 0.01137937f, 
    -0.03748636f, -0.04012795f, -0.02929497f, -0.00778424f, 0.02387165f, -0.01592853f, 0.01699504f, 0.01241451f, 
    -0.02389459f, -0.01886297f, 0.02776832f, 0.00162010f, 0.02142627f, 0.00186368f, 0.02663892f, -0.00751772f, 
    0.02546335f, 0.02743104f, -0.02920945f, 0.02585511f, 0.00383847f, -0.01176421f, -0.00813107f, 0.02515052f, 
    0.01555184f, -0.00694863f, 0.02757677f, -0.00936838f, -0.03186254f, 0.01484590f, -0.01393229f, -0.03535147f, 
    -0.01123085f, 0.02291477f, 0.01117871f, -0.01666218f, 0.00604968f, 0.03204212f, 0.02974405f, 0.01425992f, 
    -0.03079177f, 0.02383256f, -0.03642812f, -0.01627153f, -0.01634160f, -0.00523843f, -0.00583967f, -0.01853623f, 
    0.01537380f, -0.03493866f, -0.00658407f, 0.02731404f, -0.03232305f, 0.00025890f, -0.03392741f, -0.00020991f, 
    0.02731014f, -0.03690606f, 0.01007021f, 0.01432767f, 0.00401359f, 0.01696342f, -0.03555205f, 0.01621735f, 
    -0.02673786f, -0.03083465f, -0.00496653f, 0.02834197f, 0.00171917f, 0.02060923f, 0.02264714f, 0.02689079f, 
    0.02566468f, 0.02221410f, 0.00837280f, 0.01737412f, -0.03408563f, 0.02059470f, -0.00132429f, -0.04135825f, 
    -0.02736946f, -0.03626110f, -0.04059859f, 0.02757001f, -0.01334606f, 0.00340255f, 0.01393605f, -0.01675080f, 
    -0.01575661f, 0.00432072f, 0.02854843f, -0.02976934f, -0.01895703f, -0.00990097f, 0.03799395f, -0.02567539f, 
    0.01403272f, -0.03309539f, 0.00950777f, 0.01820830f, -0.00833552f, -0.03187870f, -0.01959445f, -0.02270737f, 
    0.00077504f, 0.00932322f, -0.01753554f, -0.02275802f, -0.04163703f, 0.01301963f, 0.02213904f, 0.00231938f, 
    -0.00041167f, -0.03652576f, -0.00673670f, 0.02401085f, -0.00170381f, -0.03533135f, -0.02637265f, 0.00530467f, 
    0.00151400f, 0.01364124f, -0.00959048f, -0.04001908f, -0.03089851f, 0.02892636f, -0.00612507f, 0.02703706f, 
    -0.00059180f, -0.02762671f, -0.02478326f, -0.00817842f, -0.04034073f, -0.01452842f, 0.01371234f, -0.02091799f, 
    0.00953871f, -0.02486687f, -0.01907599f, -0.02000564f, 0.00328119f, -0.02693622f, -0.03176640f, -0.02875763f, 
    0.00845650f, 0.00103236f, 0.02355674f, 0.01593151f, 0.02866605f, -0.03699115f, -0.01720257f, 0.01251392f, 
    0.00683758f, -0.00144744f, -0.01121071f, 0.02749614f, -0.00167748f, 0.00124633f, -0.02183001f, -0.00936193f, 
    -0.03848043f, 0.01074198f, -0.00230440f, -0.01569202f, -0.03309634f, 0.00837857f, 0.02495275f, -0.01945332f, 
    -0.00739164f, -0.03219337f, 0.01120121f, 0.00443959f, 0.01988308f, 0.00227420f, 0.01136559f, -0.02272221f, 
    -0.03300398f, -0.03070053f, -0.01532779f, 0.02987014f, 0.01361861f, -0.03492204f, -0.00851687f, -0.00196341f, 
    -0.04030223f, 0.01097216f, 0.02143325f, 0.01167179f, -0.01675718f, -0.02660908f, 0.01967339f, -0.03904330f, 
    -0.03711360f, -0.00017047f, -0.00393151f, -0.02343480f, 0.00222895f, -0.01444996f, -0.03956988f, 0.02033051f, 
    -0.03714625f, -0.03575061f, -0.02469517f, 0.00051613f, 0.01485174f, 0.01159289f, 0.01431346f, 0.00013530f, 
    0.01895097f, -0.01702086f, -0.04072456f, -0.03559646f, -0.01870922f, 0.00525872f, -0.02622049f, 0.01115574f, 
    -0.00514119f, -0.00820968f, 0.01503693f, -0.01527198f, -0.04177643f, -0.03049461f, 0.01077465f, -0.00959210f, 
    0.02764700f, -0.04133384f, -0.03141630f, 0.01787781f, -0.00756515f, -0.01220674f, -0.00980679f, -0.00926683f, 
    -0.02462520f, -0.01256074f, 0.02245168f, 0.00499906f, -0.01503470f, -0.01330267f, 0.00077412f, -0.02722420f, 
    0.02371682f, -0.02076784f, -0.01814955f, 0.02363483f, 0.02637241f, -0.03673486f, -0.02909655f, -0.01869238f, 
    -0.00771718f, 0.02845997f, -0.02581178f, -0.03855952f, -0.02296972f, 0.02294907f, -0.02153678f, 0.01024373f, 
    0.00487853f, -0.01841184f, 0.02192565f, -0.01806175f, 0.01410242f, 0.00994578f, -0.03691074f, -0.01140451f, 
    -0.00610592f, 0.01979537f, 0.00350318f, 0.02630279f, -0.00232634f, -0.00760262f, -0.00700733f, 0.03902092f, 
    -0.03255613f, -0.04040651f, 0.01169616f, -0.01747135f, 0.02926534f, 0.02014598f, -0.02102126f, -0.02268061f, 
    -0.03814815f, -0.00364846f, -0.02239997f, 0.02372474f, -0.01241018f, 0.00903105f, 0.01887986f, -0.03374223f, 
    0.00922840f, 0.00116246f, -0.04070352f, 0.01887005f, -0.01781034f, -0.00250103f, 0.00314070f, 0.01539944f, 
    0.02186078f, 0.02316361f, 0.03266363f, 0.01251223f, -0.02467178f, -0.00176595f, 0.01109758f, -0.01646293f, 
    0.01463595f, 0.02727538f, -0.02901548f, -0.02505298f, 0.00229595f, -0.04004347f, 0.00428531f, 0.02233783f, 
    0.01767415f, 0.03222958f, 0.00748579f, 0.02927229f, -0.00618748f, -0.01997990f, 0.01333386f, -0.02749847f, 
    -0.03747108f, -0.01476449f, 0.03002130f, 0.00795727f, -0.00821968f, -0.00990777f, 0.02188093f, -0.03346583f, 
    0.01545897f, -0.01158640f, -0.03721917f, -0.00366813f, -0.01318945f, 0.00065726f, -0.01857476f, -0.01068286f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.12350631f, 0.01443466f, -0.01719616f, -0.05616049f, -0.03711281f, 0.05649801f, 0.06021056f, -0.01240984f, 
    0.01488046f, 0.18034855f, -0.00700697f, 0.08964016f, 0.02132522f, 0.01850875f, 0.13142510f, 0.10027035f, 
    -0.05079405f, -0.03369735f, 0.06729050f, 0.01113951f, 0.14108081f, 0.16001233f, -0.00797496f, 0.13796048f, 
    0.02527345f, 0.09698649f, -0.06232064f, 0.07054360f, 0.01642012f, -0.03365632f, -0.02794577f, -0.02186477f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.11228409f, -0.10257851f, 0.07836547f, -0.22372305f, 0.02085329f, 0.20643848f, 0.20087415f, -0.09798785f, 
    0.07767697f, 0.31059954f, 0.17031036f, 0.03661744f, 0.14469832f, -0.14119756f, 0.21494792f, 0.05379877f, 
    -0.20588663f, -0.03481165f, -0.16134304f, 0.02399870f, 0.38995489f, 0.25483623f, -0.03064489f, 0.24131715f, 
    0.00660582f, -0.00872960f, -0.47678399f, -0.12960282f, 0.11614645f, -0.02926237f, -0.10704502f, -0.06794710f, 
    0.20753883f, 0.08685111f, 0.13058718f, 0.28887811f, 0.00949486f, 0.17088731f, -0.00397430f, -0.05271276f, 
    0.16103512f, 0.30494708f, 0.22776926f, 0.03502181f, -0.08943973f, -0.16046023f, -0.25653949f, 0.20570365f, 
    0.07384243f, 0.11670388f, 0.22508261f, -0.29033393f, 0.05108662f, -0.05137501f, -0.21743864f, -0.03057998f, 
    0.12583923f, -0.06399582f, -0.20406617f, -0.15517336f, -0.14723121f, 0.04666748f, 0.13169035f, 0.05874259f, 
    0.29472685f, 0.07334045f, 0.06568735f, -0.07169221f, 0.17406414f, -0.22172587f, -0.06677504f, -0.08678269f, 
    -0.00725825f, 0.19063169f, -0.08355261f, 0.03035925f, 0.12978987f, -0.02785380f, 0.20082241f, -0.17712800f, 
    0.15826869f, 0.06903002f, -0.06108925f, 0.14383110f, -0.18859413f, 0.32539168f, 0.22812703f, 0.38092765f, 
    -0.00639700f, 0.07275099f, 0.14099823f, -0.01225408f, 0.00882770f, 0.03622127f, 0.17894341f, -0.09139674f, 
    0.05345254f, 0.10225663f, -0.08179156f, 0.24544944f, 0.13222854f, 0.00418577f, -0.16225041f, -0.01031647f, 
    -0.03200154f, 0.33503437f, 0.07354742f, 0.13497382f, -0.02141901f, -0.09534294f, -0.04307871f, -0.07882022f, 
    0.15528744f, 0.00976571f, -0.19252072f, 0.21543747f, -0.27515590f, -0.15594199f, 0.16730647f, 0.34749088f, 
    -0.15272447f, 0.31284136f, 0.20904751f, 0.23792668f, 0.02442650f, -0.09431738f, -0.01692728f, 0.04847359f, 
    -0.17200379f, -0.13422576f, 0.05039210f, -0.11302118f, -0.00165003f, -0.15045702f, 0.11302953f, -0.08070730f, 
    0.02487191f, -0.00662699f, 0.01537158f, -0.03285130f, 0.08440043f, 0.11112718f, -0.13617490f, 0.07119044f, 
    -0.04455610f, -0.10128524f, -0.10465394f, -0.14876318f, 0.03842478f, -0.12046343f, -0.10561856f, 0.05932034f, 
    0.01906856f, 0.04841986f, 0.07701800f, -0.08985463f, -0.13734467f, 0.00656285f, 0.14190711f, 0.11348014f, 
    0.06576981f, -0.13463284f, 0.14246094f, 0.11929169f, -0.12017882f, 0.08546697f, -0.02054678f, 0.02879501f, 
    -0.04108976f, -0.02803337f, -0.19863214f, 0.26914522f, 0.11824381f, 0.05187599f, -0.11148006f, 0.30636853f, 
    -0.03043660f, 0.08307929f, 0.41831276f, -0.01426006f, 0.07428616f, 0.12712109f, -0.26632318f, -0.17973630f, 
    -0.14425129f, 0.27310690f, 0.44752464f, 0.22398135f, 0.16714002f, -0.02470845f, -0.13747551f, -0.16330086f, 
    -0.29548866f, -0.04637862f, -0.05855586f, -0.05902674f, -0.11044411f, -0.29942307f, 0.18329735f, -0.01741057f, 
    -0.07378360f, -0.12010293f, -0.09915411f, -0.15086088f, -0.02868976f, -0.10180451f, 0.10355859f, 0.20046370f, 
    -0.01214762f, 0.04085859f, -0.09160158f, 0.10677911f, -0.19691648f, 0.30175126f, 0.13607514f, -0.48963633f, 
    0.13526164f, -0.15676747f, 0.29318923f, 0.04176996f, 0.15975799f, 0.03336789f, -0.14664213f, 0.02848841f, 
    -0.05230396f, 0.16287047f, 0.05512285f, -0.18686379f, 0.16333261f, -0.05622504f, -0.12741560f, -0.14059862f, 
    -0.12305868f, -0.11766441f, -0.10549865f, -0.15161794f, -0.15128012f, -0.09943739f, -0.12873338f, -0.17262435f, 
    0.13585994f, 0.15385291f, -0.00441149f, -0.02370213f, -0.08116847f, 0.06457939f, 0.13441008f, -0.10488787f, 
    0.05152817f, 0.16778305f, -0.07856914f, 0.05459099f, -0.11074982f, 0.06649143f, -0.01895706f, 0.09484296f, 
    -0.11539798f, 0.13921034f, -0.14396083f, -0.07292388f, 0.11220366f, 0.04275579f, 0.05542595f, -0.10557707f, 
    0.05084992f, 0.00563030f, 0.06619195f, -0.00988633f, 0.06314968f, 0.06316896f, -0.10385943f, -0.10827670f, 
    -0.11597660f, 0.03575503f, -0.03431763f, -0.02169599f, 0.03827289f, 0.14869896f, 0.04021517f, -0.16324803f, 
    0.06743906f, 0.08028369f, -0.08812322f, -0.27336663f, 0.05717080f, -0.13618930f, -0.07610121f, 0.16247573f, 
    -0.21160208f, 0.13239911f, 0.01769528f, -0.21053164f, 0.09218694f, -0.13749427f, 0.06876130f, 0.04579854f, 
    -0.07276673f, 0.48480710f, -0.09270747f, -0.19270238f, -0.15213941f, -0.10450079f, -0.02681561f, 0.08816079f, 
    -0.01249512f, -0.11293058f, -0.00459032f, 0.21161927f, 0.25936007f, -0.17389578f, -0.18948296f, 0.13345139f, 
    0.13147525f, 0.29938766f, -0.28930515f, 0.26247147f, 0.03887572f, -0.00439827f, -0.00774851f, -0.12276882f, 
    0.04119636f, -0.07704518f, -0.01477390f, -0.06247470f, 0.03391765f, -0.08747966f, 0.02536753f, 0.08963617f, 
    -0.13711567f, -0.13012144f, -0.02568294f, 0.04353141f, 0.01503726f, 0.14733063f, 0.00393289f, -0.03851479f, 
    0.09346623f, -0.04981929f, -0.11034003f, -0.12860808f, -0.12524989f, 0.09027826f, -0.12254041f, -0.09157965f, 
    0.14204264f, -0.07054993f, -0.13696939f, -0.15231198f, 0.13681778f, 0.12145346f, -0.05600608f, -0.05057185f, 
    0.14519933f, -0.00554130f, -0.11976855f, 0.19085982f, -0.11003448f, -0.04487460f, -0.10156206f, 0.03915918f, 
    -0.07332024f, -0.11278780f, -0.24523708f, 0.09417921f, -0.15421335f, -0.11795603f, 0.25508735f, -0.11569733f, 
    0.05307553f, 0.01057239f, -0.16447251f, -0.33795139f, -0.06082496f, 0.13106081f, 0.11558031f, -0.16750042f, 
    0.04781640f, -0.00016941f, 0.19883323f, 0.06644590f, 0.02934019f, -0.09729672f, 0.06918789f, 0.08169624f, 
    -0.17357071f, 0.07679615f, 0.09837887f, -0.10235182f, 0.02641710f, -0.06145144f, -0.13018462f, 0.14727637f, 
    0.10602079f, -0.01724050f, -0.07875785f, 0.13880226f, 0.04860324f, -0.11643657f, 0.03635427f, -0.14160113f, 
    -0.06225417f, -0.15458079f, 0.05781257f, -0.00884614f, -0.02400267f, -0.16982080f, 0.06732111f, -0.15512429f, 
    0.06131468f, 0.01854387f, -0.01718440f, -0.10142042f, -0.03092094f, 0.00153734f, 0.00106374f, 0.14177099f, 
    -0.02099640f, 0.15664655f, -0.08407489f, -0.08298657f, 0.16101779f, -0.02680662f, 0.23755720f, 0.16312413f, 
    0.06915280f, 0.11440164f, 0.22784631f, 0.19690070f, -0.07355622f, 0.06871244f, -0.19094802f, -0.29024115f, 
    0.15875652f, 0.00339731f, -0.20359880f, 0.29227784f, 0.19829461f, 0.02463348f, -0.13197723f, 0.15797392f, 
    -0.11263772f, 0.29028013f, -0.09207408f, -0.29782471f, 0.10189675f, 0.14052443f, 0.14893404f, -0.06914875f, 
    -0.10312647f, 0.07233907f, 0.05215934f, -0.00060531f, 0.17895822f, -0.18478169f, -0.11012002f, -0.05356413f, 
    -0.04874346f, -0.04737372f, 0.04689445f, 0.12154568f, -0.02670753f, 0.09207299f, -0.04132457f, -0.19027451f, 
    -0.16780639f, 0.16426848f, 0.09112541f, -0.12889303f, -0.12298709f, -0.03311500f, -0.17158744f, -0.19673651f, 
    0.10628660f, 0.04767038f, -0.03766678f, -0.06379326f, 0.05373729f, 0.06032478f, -0.11987166f, -0.17000860f, 
    0.19581406f, -0.12959343f, 0.15435337f, -0.16804071f, -0.04474516f, -0.01947083f, 0.12065005f, 0.00099942f, 
    -0.07333356f, -0.07959352f, 0.30938730f, 0.08392496f, -0.06285781f, -0.05829900f, 0.20848601f, -0.00551961f, 
    -0.12745461f, -0.02546825f, 0.18376215f, -0.26516882f, 0.34481707f, 0.33785540f, 0.13003610f, -0.05826769f, 
    -0.12569934f, -0.06205074f, -0.48798424f, -0.04875645f, 0.13202074f, 0.03817204f, -0.01345025f, 0.06798142f, 
    -0.16697820f, 0.10974290f, 0.02213896f, 0.00456193f, 0.00534091f, -0.40386191f, 0.29087812f, 0.00693786f, 
    -0.10348539f, -0.17492773f, 0.08641958f, -0.23071639f, -0.02995754f, -0.09439552f, -0.02644751f, 0.11710076f, 
    0.28779173f, 0.01517873f, 0.15501671f, -0.08727980f, -0.17199881f, 0.18536179f, 0.41835433f, -0.16975108f, 
    0.03209842f, -0.42591941f, 0.10679806f, 0.11034828f, 0.09798101f, 0.11119906f, -0.10007598f, 0.08723114f, 
    0.02688270f, -0.15402342f, 0.05480855f, 0.06975447f, -0.05151930f, -0.02293976f, 0.34066227f, 0.10075083f, 
    0.16343302f, -0.09540997f, 0.14481652f, 0.18254919f, 0.04363910f, -0.03565428f, -0.19371429f, -0.04439831f, 
    0.35826775f, 0.12941884f, -0.10899457f, 0.32413933f, 0.25680876f, -0.30372199f, 0.45360282f, 0.16628206f, 
    -0.17735870f, -0.43791410f, -0.09779803f, -0.18233569f, 0.12439834f, -0.13490549f, -0.06236928f, 0.14262173f, 
    0.12891218f, 0.04381794f, 0.06489599f, 0.05960781f, -0.14863871f, -0.37319162f, 0.03883604f, -0.11696438f, 
    -0.01551394f, 0.39234024f, -0.21309775f, 0.17365679f, 0.08542846f, 0.11723061f, -0.12226563f, 0.03136343f, 
    0.22126864f, 0.07322937f, -0.23155551f, 0.11314984f, -0.17088637f, 0.22774434f, -0.02175985f, 0.06790528f, 
    -0.10121445f, 0.36550209f, 0.21175106f, 0.16166577f, -0.07959050f, 0.05281409f, -0.12322380f, 0.03849102f, 
    -0.09699842f, 0.14754209f, -0.00316909f, -0.26797664f, 0.11541739f, 0.10229535f, 0.19294699f, 0.05280012f, 
    -0.13699619f, 0.20915261f, -0.25399524f, -0.28567576f, 0.13024554f, 0.08489773f, -0.28968659f, 0.11603898f, 
    0.09686840f, 0.13458990f, 0.37182352f, 0.12988529f, 0.11487623f, -0.50359941f, 0.04320332f, 0.13682874f, 
    -0.06553569f, -0.19752818f, 0.26531291f, 0.18481384f, -0.01075581f, -0.03432863f, -0.02167006f, 0.16125551f, 
    -0.42266265f, 0.05219335f, -0.07269155f, -0.06823964f, 0.12680148f, 0.20137379f, 0.18544263f, 0.13964227f, 
    -0.16525763f, -0.45882532f, 0.11836857f, -0.08785830f, 0.13639703f, -0.13477911f, -0.44045290f, -0.07538088f, 
    0.24860886f, 0.10808373f, -0.10798693f, 0.25866750f, -0.07546846f, -0.28601974f, 0.28677428f, -0.00385959f, 
    0.13580024f, -0.21618068f, 0.11325737f, 0.07879862f, -0.01293119f, -0.02901525f, 0.08180103f, -0.13853601f, 
    -0.05200846f, -0.11164036f, 0.17560767f, -0.20228602f, -0.06540289f, -0.24548909f, 0.05382876f, 0.04951694f, 
    -0.16706577f, -0.00565843f, 0.14810622f, -0.21857995f, -0.16367650f, -0.10522024f, 0.04946305f, 0.03104822f, 
    -0.35314274f, -0.00017086f, -0.06378518f, -0.02768513f, 0.28537613f, 0.33810964f, 0.05090528f, -0.14143379f, 
    0.04182524f, 0.11109091f, -0.25288105f, 0.14076106f, -0.13917263f, -0.07209948f, -0.10381789f, 0.17071223f, 
    -0.28180173f, -0.04534888f, 0.12493286f, -0.26317140f, 0.04761522f, 0.33614516f, 0.03394408f, 0.11609305f, 
    0.01654227f, -0.40352166f, 0.19818404f, 0.04111699f, 0.01334613f, -0.12664513f, -0.22236121f, 0.26774174f, 
    -0.06391050f, -0.13607582f, 0.38502705f, -0.10458453f, -0.29906884f, -0.18415864f, 0.10118555f, 0.13927479f, 
    -0.02341558f, 0.25751048f, 0.21939322f, 0.22725587f, -0.13348077f, 0.12672329f, 0.00180678f, -0.01270698f, 
    -0.35030830f, 0.07466281f, -0.07254286f, -0.28423065f, -0.00007324f, 0.13016261f, 0.12313457f, -0.04712612f, 
    -0.15816459f, -0.11952817f, 0.08070458f, 0.09526446f, 0.02081058f, -0.03301334f, -0.29272580f, 0.25420240f, 
    -0.24291526f, 0.01068000f, 0.16412853f, 0.25040963f, 0.26332703f, 0.03399414f, 0.16797134f, -0.22156952f, 
    -0.01959320f, -0.21567090f, -0.18755710f, 0.00965270f, 0.11405631f, 0.14780295f, 0.02046640f, 0.12558380f, 
    0.00963154f, 0.10168251f, -0.01662222f, 0.15386054f, -0.02141584f, -0.15457802f, -0.16184977f, -0.11939237f, 
    0.14203559f, 0.24005178f, -0.31051821f, -0.25771680f, -0.05730500f, 0.00451847f, 0.19944310f, 0.31413382f, 
    -0.49878946f, 0.14714141f, 0.09810909f, -0.31731066f, 0.08021428f, 0.04110537f, -0.42189479f, -0.07789437f, 
    -0.09292729f, 0.04026845f, 0.20067661f, 0.28633282f, -0.10390401f, 0.08246566f, -0.16449161f, -0.00274395f, 
    -0.02395308f, -0.12021009f, 0.14195213f, -0.34982377f, 0.16969764f, 0.25723016f, 0.12176671f, -0.06758066f, 
    0.10679774f, 0.06074445f, 0.06042500f, 0.19676782f, 0.10231824f, 0.06717741f, 0.09885338f, 0.14661476f, 
    -0.16678710f, 0.16609225f, 0.20699181f, 0.10565627f, -0.01280448f, 0.44790909f, -0.19865583f, 0.03280565f, 
    0.15312558f, 0.14994790f, -0.05375123f, -0.08951019f, 0.15970236f, -0.00126499f, -0.10664950f, -0.10299832f, 
    0.05063848f, 0.06662217f, 0.14289623f, -0.12294365f, -0.04887262f, -0.00483193f, 0.17001601f, -0.14469488f, 
    -0.12114555f, -0.16012084f, -0.31452662f, -0.11682487f, 0.13079323f, -0.07131717f, 0.07146008f, 0.18621409f, 
    -0.20276894f, 0.15189205f, 0.26115394f, -0.29681289f, 0.00487133f, 0.13906828f, -0.02012928f, 0.27061638f, 
    0.15010534f, -0.29307139f, 0.07058702f, 0.21287405f, -0.16923639f, -0.15343727f, 0.15981892f, 0.02683865f, 
    0.01685386f, -0.17121592f, 0.14384437f, -0.16238074f, 0.16184273f, -0.02318280f, -0.16990715f, -0.12303384f, 
    0.14601099f, -0.12706244f, 0.05711873f, 0.01615292f, 0.03589120f, -0.07258113f, -0.00344385f, 0.12051585f, 
    -0.01438721f, -0.07270384f, -0.15153290f, -0.06390450f, -0.22785129f, 0.05756649f, -0.02425014f, 0.13959199f, 
    0.01731871f, -0.15686484f, -0.08310404f, -0.16496268f, 0.00017912f, -0.10340084f, 0.15497899f, 0.15835749f, 
    0.19520546f, -0.08524850f, -0.10390165f, -0.06045841f, -0.10206769f, -0.14494799f, 0.02069359f, -0.05723677f, 
    0.15802227f, 0.42781451f, -0.13823095f, 0.13506538f, 0.14072090f, -0.11243077f, -0.15326381f, 0.28998780f, 
    0.16575961f, -0.03473556f, 0.20409334f, -0.14625701f, -0.02235880f, 0.03803881f, 0.25394312f, 0.03541006f, 
    -0.15006948f, -0.30753773f, -0.09727661f, -0.20234798f, 0.10109958f, -0.12613527f, 0.00684437f, -0.03720362f, 
    -0.18856297f, -0.16733214f, 0.02160804f, -0.19625615f, 0.05692747f, -0.28979510f, 0.19794403f, 0.00835961f, 
    0.12032371f, -0.35703769f, 0.08624554f, -0.20290165f, 0.13663408f, -0.14833099f, -0.33708724f, 0.07452776f, 
    0.20580506f, -0.09465965f, -0.23257010f, 0.02158440f, 0.19284056f, 0.14064784f, 0.30891186f, -0.04745581f, 
    -0.02354161f, -0.07147910f, 0.05961574f, 0.21037008f, -0.10416945f, 0.06679933f, 0.13300315f, -0.02933116f, 
    0.13133152f, -0.00535206f, -0.08629622f, 0.15038352f, -0.00266370f, -0.06332339f, 0.02752337f, 0.15414506f, 
    0.09151093f, 0.25175184f, 0.06786083f, 0.22651091f, -0.00928516f, 0.02141204f, -0.49143606f, 0.01028821f, 
    0.07327559f, 0.02732505f, -0.03768319f, 0.06241615f, 0.35694623f, 0.04958786f, 0.14161740f, -0.46611750f, 
    -0.15008789f, 0.03577219f, -0.05565486f, 0.13823248f, 0.03771120f, -0.10955571f, -0.00505141f, -0.10302036f, 
    0.07904286f, 0.13318247f, -0.00617858f, 0.11601832f, 0.16519378f, 0.19177647f, 0.08675943f, -0.11277737f, 
    -0.00345259f, 0.01885081f, 0.45515734f, 0.27212647f, 0.15822104f, -0.00490873f, -0.07456309f, -0.08641185f, 
    0.31772843f, -0.02308708f, -0.05563518f, -0.00408100f, -0.40194589f, 0.28558484f, 0.07054190f, -0.07785688f, 
    0.08942935f, 0.29783759f, 0.03100781f, -0.10585600f, -0.03554514f, 0.10280780f, -0.14906994f, -0.03915540f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.03252335f, 0.09461549f, 0.03808415f, -0.05203683f, -0.16682991f, 0.24923433f, -0.23063532f, -0.08384668f, 
    -0.16014087f, 0.27338663f, 0.10929562f, -0.04634576f, -0.17374678f, -0.20726338f, -0.06455918f, 0.25318578f, 
    -0.13872458f, 0.12213274f, -0.03636898f, -0.02349656f, 0.14147198f, 0.13361710f, 0.23791696f, 0.14103381f, 
    0.04095272f, 0.09276447f, 0.05994703f, -0.16708958f, 0.04427027f, -0.15463328f, 0.07369501f, -0.08252695f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.11239517f, 0.01368563f, 0.25508577f, 0.24669132f, -0.15313621f, -0.45599791f, 0.04991657f, -0.13478553f, 
    -0.03139729f, -0.19166391f, 0.09918547f, -0.02880739f, -0.03720610f, 0.05329749f, 0.03872083f, -0.15665914f, 
    0.13842635f, 0.15342283f, 0.07473891f, -0.66716921f, -0.02064290f, 0.05088454f, -0.54570425f, -0.52672994f, 
    0.03879586f, -0.28511989f, -0.25102022f, -0.07893795f, -0.02908363f, 0.25526923f, 0.09335728f, 0.00721188f, 
    0.13735738f, 0.00352693f, 0.27871406f, 0.05462459f, -0.01421746f, -0.10946100f, 0.06861068f, 0.04694604f, 
    -0.15338098f, 0.33216357f, -0.02266944f, -0.06095351f, 0.04992259f, 0.35930458f, -0.06982114f, 0.03309290f, 
    -0.53362131f, 0.24873888f, 0.17699122f, -0.22195219f, -0.78369004f, 0.23227578f, -0.63351840f, -0.62388486f, 
    0.24161100f, -0.00511419f, -0.14850551f, -0.14996003f, 0.20435922f, -0.64949977f, -0.13820551f, -0.06657558f, 
    0.19251664f, -0.13163424f, 0.29113749f, 0.01626249f, 0.15413570f, -0.20510577f, -0.31728864f, -0.06991161f, 
    0.00783779f, 0.09233239f, -0.17785484f, -0.12533973f, -0.08279316f, -0.51878184f, -0.00452232f, 0.07479186f, 
    0.18134473f, 0.12493113f, 0.11218059f, 0.28737161f, -0.38124743f, -0.27263719f, -0.07605310f, -0.09349886f, 
    -0.27339152f, 0.03325800f, 0.24216612f, 0.07955302f, 0.35656831f, -0.12758631f, -0.47946545f, -0.19302557f, 
    -0.61750036f, -0.16030045f, 0.07565319f, 0.14128843f, -0.02313245f, 0.02608971f, -0.27073023f, -0.20603435f, 
    -0.04260991f, -0.21131051f, -0.15313111f, -0.06297766f, 0.04409310f, -0.18774082f, 0.05755458f, -0.51669925f, 
    0.08702271f, 0.17860006f, 0.07669422f, 0.21605791f, 0.19087604f, 0.07612027f, 0.12487788f, -0.24646975f, 
    -0.50647545f, -0.46676224f, -0.15050554f, 0.08515673f, -0.02530331f, 0.12665454f, -0.09077844f, 0.00929173f, 
    0.19769871f, -0.13372424f, -0.10170135f, -0.06013770f, -0.05166303f, -0.10789707f, -0.60099381f, -0.04440657f, 
    -0.01605380f, -0.16067743f, 0.06426719f, 0.13293830f, -0.17382959f, 0.13151360f, 0.06294150f, -0.02931885f, 
    -0.08975454f, 0.25784752f, -0.15811597f, 0.01239780f, 0.34001198f, -0.16278400f, 0.09605017f, 0.05810826f, 
    0.15984496f, -0.16820177f, -0.18395634f, -0.06666896f, 0.06867145f, -0.03264542f, -0.16285267f, -0.08604777f, 
    0.01648144f, 0.21075816f, -0.04925663f, -0.14806195f, 0.04478358f, 0.17866082f, -0.04431521f, -0.07215482f, 
    0.18399328f, -0.46384701f, 0.06901533f, -0.00670530f, 0.07625400f, -0.00374026f, -0.04291625f, 0.21312180f, 
    -0.06617766f, 0.07831700f, -0.05027678f, -0.66636926f, -0.25385782f, 0.02202022f, 0.01685319f, -0.07147111f, 
    -0.18925598f, 0.13677283f, -0.13705102f, -0.05730413f, 0.26552108f, -0.20431431f, 0.14814258f, 0.13366705f, 
    0.20479573f, -0.04680216f, -0.14783452f, -0.44347778f, 0.00453821f, 0.08839044f, -0.51222599f, -0.03049327f, 
    -0.03861387f, 0.09773950f, -0.09803376f, -0.17259420f, 0.02987438f, -0.39942777f, -0.01496833f, 0.24820855f, 
    -0.36142263f, -0.51523167f, -0.26701722f, 0.18820193f, -0.23103994f, 0.03219564f, 0.27072728f, -0.08874287f, 
    -0.03822229f, 0.24313954f, 0.22679032f, -0.01696226f, -0.18867065f, -0.08921532f, -0.62106043f, -0.35951391f, 
    -0.15646663f, -0.22884613f, -0.06312890f, -0.00302019f, -0.03212864f, 0.08059835f, 0.45395464f, -0.16778965f, 
    -0.04653049f, -0.19927919f, -0.15433061f, 0.13494205f, 0.10619098f, -0.16176151f, 0.11358487f, -0.07395572f, 
    0.56739312f, -0.24479491f, -0.21718548f, -0.03228812f, -0.15774727f, -0.11729243f, -0.11810199f, 0.00226779f, 
    0.25915566f, -0.18363601f, 0.09870977f, 0.02669795f, -0.00693422f, 0.07085703f, -0.27793166f, -0.38351148f, 
    -0.54913610f, -0.28963438f, 0.32911921f, 0.02621986f, 0.02133255f, 0.30767018f, 0.06786381f, -0.01913124f, 
    -0.12001065f, -0.22443900f, -0.14466795f, 0.03099404f, -0.15826291f, -0.48804250f, -0.02247493f, -0.38501561f, 
    -0.22097158f, -0.67892152f, 0.33081248f, -0.40567592f, -0.26048237f, -0.19676913f, -0.08444493f, -0.54974091f, 
    -0.01097464f, -0.03207867f, 0.03006115f, -0.07645502f, -0.00195972f, -0.19739293f, -0.02809427f, -0.09151129f, 
    0.32042542f, -0.42493349f, -0.10995526f, -0.52532011f, 0.15626362f, -0.09075090f, -0.01168553f, 0.07690342f, 
    0.00323212f, 0.23725875f, 0.05904255f, -0.04558462f, -0.06973035f, 0.03216203f, -0.04509445f, 0.19138537f, 
    0.01269133f, 0.07505231f, -0.08244480f, -0.10420458f, -0.09061977f, 0.27772614f, -0.16150321f, 0.34574947f, 
    -0.42935225f, 0.11689220f, -0.07925472f, 0.11093383f, -0.19740775f, 0.16047029f, 0.16046095f, -0.29893866f, 
    0.04190020f, -0.30244270f, 0.24634169f, 0.22752738f, -0.08592490f, -0.08904605f, -0.24925824f, 0.00832734f, 
    0.10963036f, 0.16261676f, -0.00865821f, -0.50684434f, -0.01944668f, 0.13118808f, -0.10142139f, -0.30689216f, 
    -0.57113129f, -0.26464015f, 0.15122034f, -0.10739415f, -0.24137598f, -0.45802096f, 0.33682188f, -0.34624514f, 
    -0.29615605f, 0.24504448f, -0.28874749f, -0.05288468f, -0.41563609f, -0.31696746f, -0.77107191f, 0.19715293f, 
    -0.14197306f, 0.20657960f, -0.44840914f, 0.07218383f, 0.13298541f, 0.20909892f, -0.18235378f, 0.14028905f, 
    0.09902789f, 0.30159169f, -0.07154124f, -0.65358138f, -0.00798865f, -0.18817776f, 0.01716396f, -0.42332816f, 
    -0.57196343f, 0.00675544f, 0.02093173f, 0.38912061f, -0.14525568f, -0.52931464f, 0.03856245f, 0.02816842f, 
    0.00474139f, -0.02753676f, -0.10686837f, -0.09706210f, 0.08724694f, -0.30379048f, 0.23702732f, -0.28923887f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.33498254f, -0.04115494f, 0.26886970f, -0.22815502f, 0.19545570f, -0.04991639f, -0.10323427f, -0.18597734f, 
    0.00518411f, -0.01808744f, 0.02511506f, 0.00756099f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
