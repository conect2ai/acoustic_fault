#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.87758726f, -0.14968450f, 0.51668197f, -0.43157980f, 0.41967416f, 0.04338412f, 0.29798564f, 0.75842148f, 
    0.53943652f, 0.03059469f, -0.47255984f, 0.16351150f, 0.40034971f, 0.14972527f, 0.01509073f, -0.12789385f, 
    0.14533897f, -0.70521110f, 0.04754386f, -0.03577211f, 0.19296502f, 0.11351655f, 0.00729504f, 0.00497709f, 
    0.13636990f, -1.31733310f, -0.06305530f, 0.26646402f, 0.79916400f, 0.80464762f, 0.52845502f, 0.09817075f, 
    -0.38063210f, -0.22412688f, -0.07757226f, -0.23752929f, 0.09054019f, -0.15963194f, -0.00222767f, -0.25983179f, 
    -0.03366159f, 0.17002772f, 0.05478603f, -0.20178370f, 0.29142421f, -0.24216010f, -0.22760381f, -0.05606870f, 
    0.15243219f, -0.41940722f, 0.76384574f, -0.83037359f, -0.79901475f, -0.32808599f, -0.47177646f, 0.68717682f, 
    0.08192996f, -0.06347453f, -0.06135642f, 0.10718942f, 0.49156913f, -0.08821707f, -0.25335512f, -0.32994869f, 
    0.64500761f, -0.47763407f, -0.10119481f, 0.09416609f, -0.17028643f, -0.30074799f, 0.04103058f, -0.21359217f, 
    0.20972611f, 0.05144682f, 0.49289611f, 0.00021281f, -0.32052538f, -0.37020808f, -0.11791757f, -0.37269455f, 
    -0.51337850f, -0.35587308f, -0.70568156f, -0.54622728f, -0.88011086f, 0.24066478f, 0.42141503f, 0.01889424f, 
    -0.45357794f, -0.04422054f, 0.11856938f, -0.23142551f, -0.08807096f, 0.07718997f, -0.08565284f, -0.24390478f, 
    -0.01039985f, -0.00389405f, 0.10427825f, -0.39974329f, -0.03035731f, -0.17931914f, 0.38771406f, 0.11141742f, 
    -0.12828289f, -0.08788465f, -0.21880212f, -0.33505088f, 0.07090028f, 0.48505688f, -0.14797211f, 0.21497922f, 
    -0.11720743f, -0.30633259f, 0.05842325f, 0.15118940f, 0.33617237f, -0.12129544f, 0.35746151f, 0.59990942f, 
    -0.14971651f, -0.08135416f, -0.15199904f, -0.27477214f, -0.38242358f, -1.54492259f, 0.92037696f, 0.03730330f, 
    -1.04949749f, -0.55195427f, 0.27237532f, 0.86654103f, -0.04839687f, -0.31517839f, -0.14105995f, -0.10005101f, 
    0.00941493f, -0.16810577f, -0.63709605f, 0.07520163f, 0.11938883f, 0.10856304f, -0.03785387f, -0.23276247f, 
    -0.05720698f, 0.00903942f, 0.09409974f, -0.09346586f, -0.03574338f, -0.00908618f, -0.32554993f, -0.32647598f, 
    -0.39863649f, 0.15347727f, -0.32743561f, -0.34570101f, -0.70419770f, -0.40507939f, -0.13584876f, -0.37219167f, 
    0.28376269f, -0.05424412f, 0.43929720f, 0.25831813f, 0.37739667f, 0.29584634f, 0.05716039f, 0.03512744f, 
    -0.22099636f, -0.11527900f, -0.14537340f, 0.26005808f, 0.24521174f, -0.09320921f, 0.47222441f, 0.51005846f, 
    0.26424408f, 0.33939359f, 0.61139333f, 0.74205619f, 0.27129507f, 0.02687634f, -0.01050071f, 0.15020661f, 
    0.24688390f, 0.25216943f, 0.44556889f, -0.09227186f, -0.38874456f, 0.06597768f, -0.03954492f, 0.05264047f, 
    0.06462546f, 0.01648252f, -0.31329742f, -0.12280702f, 0.33869857f, 0.19358985f, 0.01681861f, -0.38185126f, 
    -0.17861277f, -0.07288185f, 0.12766539f, 0.40800762f, 0.10455860f, 0.41980591f, 0.15266332f, -0.02518126f, 
    0.23203027f, -0.33792123f, 0.05834424f, -0.28755209f, -0.48690429f, 0.18974018f, 0.19717173f, -0.02620233f, 
    -0.07893866f, 0.07645053f, -0.14119336f, -0.26750681f, 0.10490096f, -0.11152373f, -0.26856935f, 0.36577860f, 
    0.14152519f, 0.20622297f, 0.68435389f, -0.08942448f, 0.00255792f, 0.00176988f, -0.05444755f, -0.33171806f, 
    -0.05717026f, 0.19478019f, 0.06949997f, 0.62197620f, -0.59531301f, 0.14093252f, 0.36959180f, -0.29623035f, 
    0.22073592f, 0.13612631f, 0.06037143f, -0.08562436f, -0.44089186f, -0.05908079f, 0.22405784f, -0.10357311f, 
    0.13018565f, -0.16943914f, -0.63764554f, -0.51402104f, 0.06749654f, -0.58373153f, -0.28308529f, 1.03166628f, 
    -0.17580791f, -0.68957639f, -0.59806228f, 0.64571553f, 0.00168458f, -0.24232575f, -0.05690974f, -0.12597251f, 
    -0.22108263f, -0.07433891f, -0.06217327f, 0.08736560f, 0.14092728f, 0.05644458f, -0.00300960f, -0.04665010f, 
    -0.33690137f, -0.02185474f, -0.09466177f, 0.74182123f, -0.22256763f, -0.99821270f, -1.05273676f, -0.90014333f, 
    0.14854211f, -0.15830682f, 0.23133938f, 0.34347147f, -0.02876940f, 0.28408018f, 0.34533969f, 0.58652043f, 
    0.30684239f, -0.01632502f, -0.07646569f, -0.09654300f, -0.06891874f, -0.17472430f, -0.35854977f, 0.01666907f, 
    -0.18646336f, -0.09288126f, -0.16898753f, -0.21831232f, 0.23356923f, -0.32653978f, -0.60687274f, 0.14858939f, 
    0.65967637f, -0.00091254f, -0.02004131f, 0.15920945f, -0.07169912f, -0.35242379f, -0.16052434f, 0.29432666f, 
    -0.07051153f, 0.24965031f, -0.22523923f, 0.07686782f, -0.15234531f, 0.01044277f, -0.01594383f, 0.03070685f, 
    -0.10956115f, 0.29553086f, 0.11934684f, 0.47833547f, 0.68714666f, -1.04457200f, 0.35202447f, 0.31830657f, 
    -0.30363828f, 0.29834896f, -0.27220964f, -0.39208502f, -0.08396108f, 0.39932236f, 0.29821062f, 0.00392274f, 
    -0.47738290f, -0.27956188f, 0.07368921f, 0.43483934f, 0.26812890f, -0.07708010f, -0.09638347f, -0.10773711f, 
    -0.25484136f, -0.25709751f, -0.42018235f, -0.03789521f, -0.02746382f, -0.52187937f, 0.55372429f, 0.03264717f, 
    0.48584855f, -0.41031158f, -0.52663833f, -0.06827486f, 0.25996941f, 0.32901782f, -0.21374989f, 0.34849504f, 
    0.07700640f, -0.03821860f, -0.23853669f, -0.02640234f, 0.46415743f, 0.09751485f, 0.30726621f, 0.01015173f, 
    -0.22483665f, -0.01046791f, 0.18321684f, -0.11215632f, -0.22220618f, -0.12737417f, -0.29036132f, -0.81935579f, 
    -0.37179267f, -0.58533651f, -0.96538091f, -0.42738461f, 0.66328377f, -0.09951498f, -0.29858980f, 0.09415833f, 
    0.54355150f, -0.40055358f, -0.44764206f, -0.20267582f, 0.05118486f, -0.12415680f, 0.17108439f, 0.08275387f, 
    -0.02286455f, 0.41727072f, 0.10651159f, 0.05567931f, 0.25142527f, 0.26951855f, -0.07150144f, -0.12233130f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.12020820f, 0.09699447f, 0.40613905f, -0.07962624f, 0.18492761f, -0.12111607f, 0.01185426f, -0.05875674f, 
    0.22337045f, 0.46945694f, 0.22670990f, 0.14802873f, 0.43744522f, 0.32802081f, -0.12182111f, -0.09294558f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.01017794f, 0.05284593f, 0.03746224f, -0.07535519f, -0.03709137f, 0.04182260f, 0.02383300f, 0.05475070f, 
    0.02886287f, -0.04599627f, 0.04345009f, 0.05940416f, -0.07802980f, -0.06711112f, 0.02629390f, 0.01369066f, 
    0.01432704f, -0.01583437f, 0.02725247f, -0.05132604f, -0.06787392f, -0.02518079f, -0.03202030f, -0.07382036f, 
    -0.00168805f, 0.03105653f, -0.07495115f, 0.02184770f, -0.00393311f, 0.04027732f, -0.04037242f, -0.05126395f, 
    -0.00565181f, 0.00250668f, 0.05384668f, 0.01795555f, -0.05156232f, 0.04285171f, -0.06683179f, -0.06216070f, 
    0.04850325f, 0.04627872f, 0.06274520f, 0.04370809f, -0.03088111f, -0.08009936f, -0.04309690f, 0.03419393f, 
    -0.04881220f, 0.02325571f, -0.05542865f, -0.00521838f, 0.04260491f, 0.03472940f, -0.04720371f, -0.07604504f, 
    -0.07049717f, -0.01512550f, -0.01140971f, 0.00083855f, 0.06435734f, -0.07683560f, -0.06459083f, -0.04071340f, 
    0.02545783f, 0.05378516f, -0.04530331f, -0.07937697f, 0.06163556f, -0.01203334f, -0.04987279f, -0.05951587f, 
    0.06085569f, -0.04465506f, 0.00782535f, 0.01485664f, -0.05418024f, -0.06038516f, 0.05314122f, -0.04803811f, 
    0.01148145f, -0.00821259f, 0.00460317f, 0.05534582f, -0.00584919f, -0.06269267f, 0.02764860f, -0.02306019f, 
    -0.03717356f, -0.06414508f, -0.00690104f, 0.02127999f, 0.05237583f, 0.02350335f, -0.02091644f, 0.00202577f, 
    0.00659684f, -0.04103713f, -0.07166405f, 0.00285980f, 0.02356888f, 0.02479288f, 0.04069614f, -0.01369593f, 
    -0.05883524f, -0.04042965f, -0.01823288f, -0.02586279f, -0.06530379f, -0.02572363f, -0.02367956f, -0.02451520f, 
    0.00551269f, -0.02688056f, 0.02165909f, 0.05627808f, 0.01536604f, 0.05681548f, 0.03599164f, -0.06117215f, 
    0.04870909f, -0.01254397f, 0.00740445f, -0.02632003f, 0.04162747f, -0.07977550f, -0.05077839f, -0.07811078f, 
    -0.05784377f, -0.02928328f, -0.01692327f, 0.01158526f, -0.03387797f, -0.03277539f, -0.07772510f, -0.00689723f, 
    -0.01876695f, 0.01986161f, 0.02682930f, -0.06097556f, -0.07288150f, 0.04606050f, 0.01629234f, -0.02941477f, 
    -0.03885311f, -0.00262459f, -0.03554306f, 0.00693103f, 0.06759771f, -0.00575931f, 0.00618339f, -0.04621759f, 
    -0.03039752f, -0.02516675f, -0.01270666f, -0.02464105f, -0.08187229f, 0.02608828f, 0.03837176f, 0.03852438f, 
    0.04839613f, 0.03817594f, 0.03080551f, 0.02052587f, -0.03685424f, 0.05475216f, 0.06046652f, -0.06802032f, 
    -0.01184263f, 0.06114008f, -0.04226564f, -0.00015516f, 0.02084814f, -0.00824204f, -0.04212990f, 0.00894600f, 
    0.02994166f, 0.05396569f, -0.07439264f, -0.07570110f, 0.00397645f, -0.06227006f, -0.00156375f, -0.02047192f, 
    0.04816879f, 0.05306976f, 0.00185480f, -0.03547913f, 0.02305335f, -0.07332253f, 0.00916868f, -0.01712517f, 
    -0.22870402f, -0.51426715f, 0.07543831f, -0.16081907f, -0.12390479f, 0.08910979f, 0.06070075f, -0.08201310f, 
    -0.05615222f, 0.05204831f, 0.08952144f, 0.07802413f, -0.01617283f, -0.14604516f, -0.21571846f, -0.24415947f, 
    0.01998958f, 0.03164476f, 0.09114978f, 0.01260171f, -0.00766695f, 0.04089450f, 0.14198038f, -0.07965953f, 
    -0.05709806f, 0.15693663f, -0.07118975f, 0.19338846f, 0.05475017f, -0.02506956f, 0.14797227f, 0.15980805f, 
    0.14028889f, 0.07658181f, -0.03890317f, 0.00735379f, 0.00124394f, -0.10191805f, -0.06449530f, -0.09928229f, 
    -0.26569808f, -0.04441930f, -0.19658440f, -0.15200348f, -0.21186100f, -0.13358516f, -0.13720414f, 0.03833274f, 
    -0.14322382f, 0.01522948f, -0.13405047f, 0.03067301f, 0.14604083f, 0.15923618f, 0.00321081f, -0.01329739f, 
    0.00339746f, -0.04600240f, -0.16171995f, -0.04899913f, -0.54944432f, 0.46946263f, 0.31336656f, -0.12960561f, 
    -0.01769785f, 0.17158201f, 0.03706756f, 0.08179507f, 0.03617236f, 0.13155164f, -0.08646826f, 0.01814089f, 
    -0.40732002f, 0.07256933f, 0.02846079f, -0.10108051f, 0.04619039f, 0.03178251f, -0.06989679f, -0.21219902f, 
    -0.12409981f, 0.03772965f, 0.08128993f, 0.11799192f, 0.12043189f, 0.31530854f, -0.12540664f, -0.00871400f, 
    -0.16144788f, -0.13768411f, -0.03020114f, -0.06736799f, -0.04949700f, -0.09986380f, -0.02066099f, -0.10889576f, 
    -0.15254349f, -0.21444601f, 0.35677329f, 0.24755128f, 0.02690499f, 0.07266753f, 0.00957271f, -0.10676585f, 
    0.26030982f, 0.08100805f, 0.25432247f, 0.13124143f, 0.16219273f, 0.03787068f, 0.29104009f, 0.08910908f, 
    -0.04639273f, -0.03924279f, 0.24446104f, 0.24070412f, -0.03541042f, 0.08267528f, 0.16285434f, 0.07367679f, 
    0.45461220f, 0.34937772f, 0.03919982f, 0.05285580f, -0.01353340f, 0.02248365f, 0.21304113f, -0.00003168f, 
    -0.08639999f, 0.17530634f, -0.00517661f, 0.04735928f, 0.23770876f, -0.22275774f, -0.30307934f, -0.21361545f, 
    0.07404468f, 0.10597768f, 0.06523846f, 0.07021115f, 0.13353625f, 0.07662655f, -0.05774119f, 0.08187064f, 
    -0.20854314f, 0.18274412f, -0.05904329f, 0.03608104f, -0.16393094f, 0.28025547f, 0.10907476f, 0.11659787f, 
    0.08674911f, 0.11543160f, 0.01237615f, 0.04904792f, -0.13349625f, -0.00947520f, 0.23421992f, -0.06629309f, 
    -0.02004390f, 0.10649980f, 0.09533557f, 0.15657596f, -0.02987293f, 0.06171080f, 0.03597165f, 0.00929274f, 
    0.36075398f, -0.26759416f, -0.04384647f, 0.01679930f, -0.26786673f, -0.14184853f, 0.07844739f, -0.05714416f, 
    -0.05415771f, 0.03371898f, -0.01709107f, 0.15310991f, -0.04381427f, 0.38568816f, 0.04036713f, -0.13434072f, 
    0.26821086f, 0.01022001f, 0.05087303f, -0.06744052f, -0.15108849f, 0.05277061f, -0.01566626f, -0.26794225f, 
    0.27404055f, 0.29329062f, -0.63539314f, -0.01157204f, 0.02323013f, 0.10370534f, -0.09335421f, -0.20857285f, 
    0.08194441f, 0.06615251f, -0.11555120f, -0.16553573f, 0.18735684f, 0.34628892f, 0.15370685f, 0.04001382f, 
    0.04616449f, 0.07337413f, 0.11775080f, 0.13417934f, -0.07853549f, 0.23307526f, 0.01760429f, 0.27434519f, 
    -0.08704595f, -0.10052670f, -0.00600473f, -0.06768237f, -0.07559121f, -0.00609491f, 0.00071242f, -0.19244082f, 
    -0.12691531f, 0.02152081f, -0.09610653f, -0.03655102f, 0.15840739f, 0.24604431f, 0.06625690f, 0.30552661f, 
    0.21061943f, -0.12058635f, 0.06210966f, 0.27797246f, 0.11633582f, -0.12162895f, 0.01003788f, 0.09077983f, 
    -0.01406289f, 0.09711315f, 0.27173600f, -0.19739555f, 0.09083082f, 0.09400925f, 0.27076578f, -0.15437342f, 
    0.07545816f, -0.00886856f, -0.04299569f, -0.16835603f, 0.46180221f, -0.11200824f, -0.11555592f, 0.33352113f, 
    0.12561491f, 0.04577571f, 0.09405772f, 0.21819945f, -0.00450239f, -0.09837508f, 0.33922884f, 0.08081274f, 
    0.40508974f, -0.06599448f, 0.09649753f, 0.16978650f, -0.04595238f, 0.05790827f, -0.03308374f, 0.00761510f, 
    -0.07098286f, -0.12520866f, -0.15169427f, -0.34308323f, 0.12165090f, 0.03659904f, 0.22696811f, -0.08260847f, 
    0.04904381f, -0.02274021f, -0.19185671f, -0.11647032f, 0.01253066f, -0.11528855f, 0.10720526f, 0.28287065f, 
    0.33610359f, 0.18119873f, -0.13493235f, -0.15223335f, -0.09920461f, -0.13086388f, -0.11103591f, -0.02722332f, 
    -0.08836765f, 0.08437888f, 0.01192087f, -0.00889034f, -0.12570286f, -0.19445175f, 0.28609160f, -0.12902284f, 
    -0.14109428f, -0.02364480f, -0.28131646f, -0.11822879f, -0.26842332f, -0.15187843f, -0.03803819f, -0.13722430f, 
    -0.04547120f, 0.01455019f, 0.06333504f, -0.14125381f, -0.06006928f, 0.04706135f, -0.10842152f, 0.27927878f, 
    0.06412266f, 0.05622511f, 0.05000702f, 0.11207912f, -0.19195800f, 0.06839442f, 0.06472156f, 0.34873292f, 
    -0.05115302f, -0.07722285f, -0.03405322f, -0.03978571f, 0.03137220f, 0.09439981f, 0.23901419f, 0.07793064f, 
    -0.03652419f, -0.06702319f, 0.02750169f, -0.38483143f, 0.24422966f, -0.04093976f, -0.05918418f, 0.05116569f, 
    -0.38240853f, -0.34449327f, -0.54663628f, -0.89540613f, 0.14488688f, -0.10348152f, 0.10418668f, 0.11517262f, 
    -0.10463858f, 0.10581355f, 0.06869048f, 0.01187750f, 0.01696031f, 0.15641437f, -0.05864092f, 0.33611673f, 
    -0.19137490f, -0.14378671f, -0.17158675f, -0.05472554f, 0.20716022f, 0.21011785f, 0.26702350f, 0.04346883f, 
    0.02423441f, -0.02572022f, 0.10299039f, 0.09421787f, 0.11926140f, -0.22106452f, 0.01348082f, -0.00097974f, 
    -0.00118436f, 0.08177092f, 0.07007013f, 0.24864367f, 0.10383575f, -0.05348721f, -0.09246658f, 0.15309393f, 
    0.29412815f, 0.29588294f, -0.21566945f, -0.04409712f, 0.19192125f, -0.00670233f, -0.11145440f, -0.12066738f, 
    0.00777547f, 0.06410808f, 0.02556789f, 0.16782780f, 0.27244246f, 0.07672594f, -0.05333741f, -0.05034675f, 
    0.16250353f, 0.10178559f, 0.06075098f, -0.00619849f, 0.22973375f, 0.11641517f, 0.21863826f, 0.01358160f, 
    -0.16127816f, -0.37356189f, 0.04307013f, -0.16036887f, 0.07831432f, -0.12907685f, 0.30388173f, 0.17370242f, 
    -0.01280012f, -0.07140974f, 0.14385013f, 0.26167127f, -0.10092934f, -0.27169845f, -0.08187981f, -0.03255062f, 
    0.00445802f, -0.12341204f, 0.10408048f, 0.06691168f, 0.12795424f, 0.01911134f, 0.04274362f, -0.13638659f, 
    0.04412976f, 0.05241993f, 0.07036152f, -0.09834681f, 0.15075746f, 0.15545373f, 0.17778790f, -0.12467827f, 
    0.14358269f, 0.03687852f, -0.01769554f, 0.27903265f, -0.48343405f, 0.10452402f, -0.49441761f, 0.01050127f, 
    -0.01302901f, 0.23815250f, 0.11279751f, 0.23980825f, 0.02908776f, 0.02606801f, -0.06458660f, 0.04720815f, 
    -0.03295521f, -0.08972778f, 0.08900636f, -0.09457534f, 0.07961224f, 0.09269810f, -0.00064317f, 0.05869152f, 
    0.09463388f, 0.10870958f, -0.02299067f, -0.07218529f, 0.20451197f, 0.22957037f, 0.12637599f, -0.33009437f, 
    -0.12125761f, 0.07074860f, -0.07464828f, -0.03481073f, 0.05271261f, 0.05844052f, 0.01687746f, -0.11434753f, 
    0.45094076f, 0.26288658f, 0.06646588f, 0.03087465f, 0.02104052f, 0.10531012f, -0.00753878f, -0.03074678f, 
    -0.00917357f, 0.28017420f, 0.25329289f, 0.18856645f, 0.19162473f, 0.06740389f, 0.22724584f, -0.05022934f, 
    0.07024155f, 0.04266004f, -0.02256272f, -0.12918486f, 0.05381680f, -0.13319612f, 0.10048608f, 0.02716079f, 
    -0.25447437f, -0.17184140f, -0.06229814f, -0.24718405f, -0.29768497f, -0.03283500f, 0.05804785f, 0.19835664f, 
    0.08743759f, 0.03213450f, 0.05628124f, 0.04047250f, -0.37080333f, -0.08260260f, 0.11132682f, -0.23801200f, 
    -0.03123674f, -0.07976997f, 0.23295055f, 0.33161926f, -0.27945748f, -0.03251506f, 0.05925724f, -0.03900800f, 
    0.01478657f, 0.06740133f, 0.08730245f, -0.28589389f, 0.21011913f, 0.08042200f, 0.17680296f, 0.13630262f, 
    0.10573647f, 0.07011006f, -0.05296599f, -0.01677545f, 0.21106642f, -0.24190857f, 0.16138038f, 0.11801767f, 
    0.12996016f, -0.05496858f, -0.06582037f, -0.03264725f, 0.38583940f, -0.03236092f, -0.06270224f, 0.06720040f, 
    -0.07406154f, 0.05996096f, -0.09351098f, -0.12627739f, -0.07068025f, 0.15460190f, 0.14986545f, 0.20414415f, 
    0.01365794f, -0.04320708f, 0.07662475f, -0.06920363f, 0.19937158f, -0.46839389f, -0.33653536f, -0.15582745f, 
    -0.09028405f, 0.02796208f, -0.05516854f, 0.11972789f, 0.14118403f, -0.05705439f, -0.02171023f, 0.12905733f, 
    0.12499049f, 0.36032173f, 0.12123594f, 0.21471049f, -0.10856310f, 0.05414324f, -0.06649978f, 0.07042007f, 
    -0.02381021f, 0.06299097f, -0.12119524f, -0.04333366f, 0.01975285f, -0.57825035f, 0.06631158f, 0.43853909f, 
    0.14708214f, 0.02955100f, -0.11003815f, 0.09970462f, 0.13051960f, 0.12897214f, 0.00062885f, 0.03971013f, 
    0.16587278f, 0.20906244f, 0.28117070f, -0.14360356f, 0.13450767f, -0.17402980f, -0.01965734f, -0.06276895f, 
    -0.13041349f, -0.03052297f, 0.15590182f, 0.06794008f, -0.15328112f, 0.02019805f, 0.24387027f, -0.06851945f, 
    0.00311096f, 0.16402076f, 0.01488994f, -0.01263606f, 0.01884687f, -0.10304723f, 0.02429953f, -0.12526211f, 
    0.15326992f, 0.00116970f, -0.08907583f, 0.18026316f, -0.06214121f, 0.15807275f, 0.09972579f, -0.03669035f, 
    0.14404850f, -0.06358694f, 0.01555223f, 0.23487632f, -0.38720438f, -0.25322852f, 0.06616974f, -0.00601033f, 
    0.08185905f, -0.27436867f, -0.01017023f, -0.04264986f, 0.05953768f, -0.07591149f, 0.00121241f, 0.02449258f, 
    -0.23269995f, -0.12828106f, -0.00724525f, -0.06862815f, -0.11001345f, -0.16977169f, 0.14066459f, 0.05609604f, 
    0.02006427f, -0.02346824f, 0.00636721f, -0.04541345f, 0.19530813f, -0.09571509f, -0.10127302f, 0.01646611f, 
    -0.01858200f, 0.02453628f, 0.03319017f, 0.07556050f, 0.15595534f, 0.05349883f, 0.00274146f, -0.10688254f, 
    0.21049954f, -0.00429982f, 0.10789511f, 0.12728159f, 0.08238591f, 0.02999929f, 0.08134876f, -0.06366511f, 
    -0.00250962f, 0.14356650f, -0.08947429f, -0.23915903f, 0.23118220f, -0.03703644f, -0.07737970f, -0.11980176f, 
    -0.00147927f, -0.11230997f, -0.02503791f, 0.05489108f, 0.21069042f, -0.08394021f, -0.18474139f, -0.24977215f, 
    -0.13032731f, -0.30475199f, 0.26057413f, 0.08190446f, -0.06274396f, 0.01827219f, -0.08555391f, -0.04315107f, 
    0.02275186f, 0.11061294f, -0.01633579f, 0.10615905f, 0.30586457f, 0.71403509f, 0.40239027f, -0.07296733f, 
    -0.12496354f, -0.13411967f, 0.01059032f, -0.02900816f, 0.08095744f, -0.02186853f, 0.17681520f, 0.11375567f, 
    -0.06511054f, -0.07831950f, 0.21294162f, -0.02397057f, -0.05675420f, -0.04125804f, 0.08193945f, 0.06249361f, 
    -0.17739542f, -0.13618398f, -0.17457335f, -0.19479664f, -0.03970361f, 0.14106227f, -0.23444706f, 0.19359536f, 
    -0.21281438f, -0.11604013f, -0.19824162f, -0.04871687f, 0.10719580f, -0.02193541f, 0.18836415f, 0.09313650f, 
    0.38055483f, 0.17805305f, -0.07970286f, -0.03259304f, 0.01740303f, -0.00023762f, 0.03678297f, 0.06210726f, 
    0.09323104f, 0.10352510f, 0.05802695f, -0.02239696f, -0.31215602f, -0.02187418f, 0.12717733f, 0.11918547f, 
    -0.09451641f, 0.02212035f, 0.05212608f, 0.05866948f, 0.11706893f, 0.02183137f, 0.11036188f, -0.00282983f, 
    -0.19715835f, -0.41276214f, 0.15796319f, -0.18440270f, 0.04408880f, 0.03053015f, 0.16000165f, 0.05957596f, 
    0.04928792f, 0.16536500f, 0.13213646f, 0.14642990f, 0.11612723f, -0.03024955f, -0.25729090f, -0.15453145f, 
    -0.10839980f, -0.01738552f, 0.11471947f, -0.02390704f, 0.11102419f, 0.06575198f, 0.06096876f, -0.01261504f, 
    -0.17063266f, 0.09794168f, -0.13887273f, 0.29585722f, 0.00219390f, 0.12544401f, -0.03827859f, 0.07762673f, 
    0.22352271f, -0.07856786f, 0.00146792f, -0.02549448f, -0.25002667f, -0.11107883f, -0.38170189f, -0.16766001f, 
    -0.14733693f, 0.06455593f, -0.15231553f, -0.36303061f, 0.07207298f, 0.11900660f, 0.00563655f, 0.16640513f, 
    -0.03032491f, 0.02892072f, -0.18181086f, 0.05658352f, 0.04900916f, 0.03384037f, 0.11342163f, 0.15577458f, 
    0.01213538f, 0.08056679f, -0.11559423f, -0.03233057f, -0.63967681f, 0.18267721f, 0.06029868f, 0.19895238f, 
    -0.07841110f, -0.02278460f, -0.09119044f, -0.14852278f, 0.00523342f, 0.04769542f, 0.02030037f, -0.11556729f, 
    -0.40585601f, -0.19952205f, -0.10079817f, -0.07171673f, -0.03608921f, -0.17448227f, -0.18601507f, -0.12770718f, 
    -0.06752065f, 0.00876501f, -0.11961839f, 0.13497512f, -0.06452116f, 0.19670810f, -0.04299387f, 0.10433154f, 
    0.01585831f, -0.05778738f, 0.02821061f, 0.10333388f, -0.18720609f, -0.03645372f, 0.02405544f, 0.03397145f, 
    -0.33065340f, -0.12797785f, 0.21559195f, -0.07650257f, 0.02843425f, -0.15616783f, 0.00632802f, 0.03475704f, 
    0.12725577f, 0.15094844f, 0.11948472f, 0.17588738f, 0.11937817f, 0.09942308f, 0.12863554f, -0.18014412f, 
    0.18364573f, -0.05094154f, -0.04735349f, 0.26915273f, -0.11087000f, 0.07424864f, 0.21281436f, -0.02628023f, 
    0.11210249f, 0.09153248f, 0.11012960f, 0.22141485f, 0.03995158f, 0.11235453f, 0.17096728f, -0.19199876f, 
    -0.02281847f, 0.02605369f, 0.05975331f, -0.02915011f, 0.11954515f, -0.02402212f, -0.34589154f, -0.19548705f, 
    0.11833365f, 0.17948605f, -0.08139379f, 0.01638151f, 0.07367273f, 0.04320857f, -0.06260870f, 0.11969095f, 
    -0.12691766f, -0.02889341f, -0.00605712f, 0.06042540f, -0.05585374f, -0.06282865f, -0.06009037f, 0.04307593f, 
    0.14523214f, 0.15050445f, 0.08751304f, 0.11654342f, 0.17872629f, -0.01492397f, -0.03502493f, -0.10895872f, 
    0.06066639f, -0.00618163f, 0.11870966f, 0.14299765f, 0.05856461f, 0.07335587f, 0.18753424f, 0.06488226f, 
    0.14643505f, -0.17538747f, 0.05756012f, 0.11084272f, 0.02454267f, -0.09727916f, 0.09776284f, -0.03118034f, 
    0.00556350f, 0.07629107f, 0.10268763f, 0.18181352f, -0.20366557f, 0.06824081f, 0.04024489f, 0.12202646f, 
    0.29544425f, 0.05826584f, -0.16158366f, -0.19931051f, -0.08915154f, -0.05840129f, -0.03365131f, -0.12997377f, 
    -0.05803569f, -0.10242699f, 0.13861568f, 0.06332719f, -0.10892122f, -0.05123720f, 0.01900536f, 0.00916853f, 
    -0.07235371f, 0.00139166f, -0.25320631f, -0.11537575f, 0.08388371f, -0.51768607f, 0.26126042f, 0.10382836f, 
    -0.01312288f, -0.01782718f, 0.00292135f, -0.00754510f, -0.01465577f, 0.06207429f, -0.03925006f, 0.09161282f, 
    0.22091107f, -0.12988439f, 0.01033219f, 0.03851528f, -0.13890143f, -0.13665020f, -0.03719768f, 0.13179997f, 
    -0.16648896f, 0.08286020f, -0.23878640f, 0.10533203f, 0.24449202f, 0.20291467f, 0.34332898f, 0.13782439f, 
    -0.11898439f, 0.02153754f, -0.02094946f, 0.15966517f, -0.06052855f, -0.00170926f, -0.04618905f, -0.09301812f, 
    0.12964092f, 0.08827894f, -0.02518959f, 0.19116680f, -0.05062145f, -0.03958512f, -0.03629469f, -0.05324626f, 
    0.01317293f, 0.05500033f, -0.16603027f, 0.11356149f, -0.16599500f, 0.04255610f, -0.13201945f, 0.05897630f, 
    -0.05076176f, -0.08403931f, -0.05350410f, -0.01081358f, 0.14912468f, -0.03622813f, -0.09789869f, 0.07865297f, 
    0.22388449f, 0.15065561f, -0.00280017f, 0.07689189f, 0.01301449f, 0.22297062f, 0.09597981f, 0.11491425f, 
    0.02801370f, -0.13627754f, 0.04060917f, -0.09615834f, 0.31217721f, 0.27804816f, -0.10413504f, 0.23311238f, 
    -0.00393045f, -0.00904407f, 0.01504452f, 0.01807455f, 0.15720542f, 0.04932491f, -0.01345877f, -0.04385558f, 
    0.27326813f, -0.06720128f, -0.00927913f, 0.37743005f, 0.10358584f, -0.00787542f, 0.00141263f, 0.02435937f, 
    0.02970852f, 0.09924612f, -0.08172736f, -0.16301538f, 0.25736296f, 0.10901059f, 0.20414594f, 0.49503011f, 
    0.13905869f, 0.00439799f, -0.07569955f, 0.11889181f, 0.00021104f, -0.04859451f, -0.06729840f, 0.14512460f, 
    -0.08894641f, 0.18644707f, -0.30266991f, 0.11937402f, -0.03648030f, -0.21979195f, 0.06234610f, -0.18852657f, 
    0.01723831f, -0.10454844f, 0.08367129f, 0.06805118f, -0.09650240f, -0.52548355f, 0.42014316f, -0.12235594f, 
    -0.02307412f, 0.00264367f, -0.04933662f, -0.10081040f, 0.18240291f, -0.17325790f, 0.31167355f, -0.11973812f, 
    0.03706609f, -0.09584812f, 0.01299771f, 0.04378794f, -0.03840383f, 0.43982232f, -0.29381248f, 0.01464293f, 
    -0.00532559f, -0.31487662f, -0.19054957f, -0.12272737f, -0.41262859f, 0.14007062f, -0.05621475f, 0.14731890f, 
    -0.16944599f, -0.10819864f, 0.08239833f, -0.27292791f, -0.00795444f, 0.12973255f, 0.30161238f, 0.30668366f, 
    -0.02323598f, 0.09700835f, 0.02947918f, -0.04882296f, 0.03737823f, -0.07146362f, 0.03104782f, 0.06077079f, 
    0.02707826f, -0.06523851f, -0.04997241f, -0.08580394f, -0.15756401f, 0.11665381f, 0.02183789f, 0.00483644f, 
    -0.15529419f, -0.10316785f, 0.00084269f, -0.15174671f, 0.06947704f, 0.05754922f, -0.02059894f, -0.08702523f, 
    -0.01527042f, 0.00735182f, 0.02136224f, -0.00973431f, 0.01643434f, 0.00544746f, -0.01028092f, 0.01457173f, 
    -0.04472104f, 0.01666709f, -0.00840059f, -0.06835011f, 0.02469066f, -0.06960440f, 0.03076710f, -0.04506213f, 
    -0.05546503f, 0.06391911f, -0.02808037f, -0.07259149f, -0.03470059f, -0.02513417f, 0.01231956f, -0.00084582f, 
    0.00805943f, -0.06516775f, 0.01970445f, -0.03706023f, -0.00932859f, 0.06533627f, -0.06476744f, -0.03498742f, 
    0.06092925f, -0.07703994f, -0.00673337f, -0.04546109f, -0.02564106f, 0.01910959f, -0.00220009f, -0.05290461f, 
    -0.00497609f, -0.06991507f, -0.04973979f, 0.04850858f, 0.03420231f, 0.04196463f, -0.00916628f, -0.04273203f, 
    0.02780066f, -0.04663856f, -0.06676730f, -0.01471338f, 0.03836462f, -0.06280841f, 0.02615396f, -0.07368443f, 
    0.01837543f, -0.04719676f, -0.03656352f, -0.01389651f, -0.04005526f, -0.01178569f, -0.03878471f, 0.01790878f, 
    -0.02449759f, 0.06542999f, -0.00280356f, -0.03693894f, -0.05553930f, 0.02268251f, -0.02778761f, 0.04924862f, 
    -0.03383959f, -0.04406097f, -0.05024001f, 0.04171611f, -0.05336021f, -0.01776187f, 0.04144043f, 0.03581216f, 
    0.06256233f, -0.04194340f, -0.06060205f, -0.03425888f, 0.01725404f, 0.06448624f, 0.04244133f, -0.01432914f, 
    -0.03583981f, 0.05910349f, -0.05605724f, 0.05480101f, 0.02105370f, 0.01461727f, -0.07206964f, -0.05420537f, 
    -0.00506249f, -0.03518773f, -0.07516920f, 0.00757318f, 0.00270128f, -0.05088061f, -0.01771254f, -0.05692661f, 
    -0.05542773f, -0.01284803f, -0.03591848f, 0.04942306f, 0.06257605f, 0.04921795f, -0.03422287f, -0.06854573f, 
    -0.07041805f, 0.05582346f, 0.02732616f, -0.04446281f, 0.06232479f, -0.06435969f, -0.02714243f, -0.05619542f, 
    -0.06699175f, 0.05469984f, -0.06202512f, 0.00444807f, -0.05859172f, -0.04811426f, 0.04179432f, 0.00997462f, 
    0.01471271f, 0.04016701f, 0.00604303f, -0.02209097f, 0.03159218f, -0.04060487f, 0.03402871f, -0.00149745f, 
    -0.05477863f, -0.02833103f, -0.01505614f, -0.00306814f, -0.05663901f, -0.05924455f, 0.02456439f, -0.05241537f, 
    -0.02277347f, 0.02983456f, -0.06327443f, 0.04147412f, -0.03755998f, 0.00784961f, -0.05922995f, -0.01414828f, 
    -0.03052723f, -0.05510518f, -0.07126175f, 0.05345688f, -0.06541649f, 0.03694426f, -0.02634625f, 0.07177856f, 
    -0.01211246f, 0.05430752f, -0.06111066f, -0.01860441f, -0.04867331f, -0.04033140f, -0.04426229f, -0.05484661f, 
    0.02387777f, 0.00274279f, -0.00100715f, 0.02514021f, 0.04121101f, 0.01922054f, -0.04209333f, -0.04047612f, 
    -0.00114953f, -0.04995281f, -0.01249413f, 0.02549758f, 0.05705068f, 0.05925359f, -0.02701948f, 0.06380477f, 
    0.00833948f, -0.06335880f, 0.05953441f, 0.01280779f, -0.00189410f, -0.06177054f, 0.02386719f, -0.03010432f, 
    0.42389220f, 0.32607329f, 0.12764801f, -0.32782975f, -0.15162753f, -0.04566505f, 0.10773528f, -0.05629713f, 
    -0.09233873f, 0.05914248f, -0.17786242f, -0.06090611f, -0.20487511f, 0.13506474f, -0.17282183f, 0.18612479f, 
    -0.13003176f, 0.03586165f, 0.02312327f, -0.03680075f, 0.08378559f, 0.22344778f, -0.07432855f, 0.14513062f, 
    0.02535402f, 0.50712222f, 0.16758095f, 0.31173384f, -0.10527541f, 0.05812658f, 0.05728010f, 0.06556762f, 
    -0.11634063f, 0.08815205f, -0.08310570f, -0.03812627f, -0.12982813f, -0.27153260f, -0.03458805f, 0.18916732f, 
    -0.10512209f, -0.12508702f, 0.07611278f, 0.19913302f, 0.06864381f, 0.17381717f, 0.14570296f, 0.07213092f, 
    0.11098057f, 0.18017615f, 0.07595719f, 0.07133042f, -0.06701297f, -0.20786926f, 0.09928667f, -0.09992897f, 
    0.10024867f, 0.02661140f, -0.01444053f, 0.02138151f, 1.00146210f, -0.91822106f, 0.29859573f, 0.24151713f, 
    0.04080534f, -0.05542637f, -0.00825552f, -0.02128245f, -0.19571230f, 0.07917178f, 0.14702511f, 0.04541849f, 
    0.02799927f, -0.00835237f, 0.10521214f, 0.23613277f, -0.15227424f, -0.06406100f, 0.19290352f, 0.12181561f, 
    -0.07347945f, 0.06657157f, 0.01146474f, -0.06752033f, -0.12759338f, -0.08348613f, -0.04340004f, -0.06459311f, 
    -0.13502355f, -0.06793408f, -0.04365879f, -0.10737479f, 0.01405854f, 0.16677541f, -0.02085968f, 0.01983188f, 
    0.09034640f, 0.40826416f, 0.00227605f, 0.11775858f, 0.08670361f, 0.07413205f, 0.01532811f, -0.08476218f, 
    0.05750541f, -0.04448335f, -0.23961499f, -0.16471493f, 0.12780452f, -0.11628518f, 0.05676358f, 0.35654175f, 
    -0.15209016f, 0.02498597f, 0.14130165f, -0.27259642f, 0.12969236f, 0.07703061f, -0.16738655f, 0.05291703f, 
    -0.00462404f, -0.06864249f, -0.21712548f, 0.42666090f, 0.11109982f, -0.04399235f, -0.06152203f, 0.01024495f, 
    -0.14122657f, -0.06853843f, -0.01237343f, -0.00311784f, -0.02272867f, -0.08710951f, 0.10353661f, 0.49981958f, 
    -0.01420824f, 0.04248325f, -0.02622131f, 0.06067014f, 0.31506363f, 0.03372129f, 0.03722914f, 0.15486559f, 
    0.29731756f, 0.02658202f, 0.09055216f, 0.12872046f, -0.16613089f, 0.00339858f, -0.15919593f, -0.01366176f, 
    -0.23588881f, -0.20775607f, 0.07629237f, -0.20254430f, 0.27072155f, 0.19306636f, -0.19171850f, -0.17484781f, 
    -0.02268747f, -0.02102854f, 0.01558387f, -0.14234942f, -0.11271798f, 0.11026125f, 0.12746090f, 0.10817824f, 
    -0.04902066f, 0.02443922f, 0.28210920f, -0.01464413f, 0.03873832f, 0.02257423f, -0.00421577f, -0.05477813f, 
    -0.17099580f, -0.05935622f, 0.05290513f, -0.04100447f, 0.09398812f, 0.07902503f, 0.04677780f, 0.21242480f, 
    -0.12874533f, -0.09862381f, -0.11215682f, 0.02139877f, -0.07650665f, 0.21277815f, -0.01184951f, -0.06581428f, 
    -0.08198194f, 0.02992556f, 0.33555406f, -0.02179619f, -0.00569099f, -0.13400638f, -0.12136875f, -0.03159983f, 
    0.21206382f, 0.25310102f, 0.20454931f, 0.11405349f, -0.24742140f, -0.06789515f, 0.39541569f, 0.21980761f, 
    0.05939527f, 0.22000034f, -0.07916477f, 0.09985126f, 0.27437341f, -0.15514131f, 0.09186674f, -0.16646470f, 
    -0.18279369f, 0.19514945f, -0.13226017f, 0.19772835f, -0.00297270f, 0.01387844f, 0.13247706f, 0.22680660f, 
    0.39626375f, 0.10193355f, 0.23924969f, -0.01255895f, -0.30474174f, -0.20535058f, 0.07087652f, -0.12167790f, 
    0.16353460f, 0.18750173f, 0.02428683f, -0.25965849f, 0.02489914f, -0.08569785f, -0.01463281f, -0.00740887f, 
    0.02064142f, -0.16532452f, -0.05980936f, -0.03920346f, 0.07814454f, 0.08159157f, 0.03470248f, 0.25133473f, 
    0.01795231f, 0.08284886f, 0.03294611f, -0.08764660f, -0.14546521f, -0.18546554f, 0.11835375f, -0.07492614f, 
    0.05883330f, -0.13767122f, 0.18971561f, 0.09792110f, 0.09244395f, -0.06552501f, 0.05120346f, -0.00398021f, 
    -0.51702744f, -0.17466332f, -0.14792429f, -0.12728091f, 0.21671201f, 0.18160868f, 0.05100602f, 0.06503472f, 
    -0.01225434f, -0.09178357f, -0.00377982f, 0.01653842f, 0.14071108f, 0.02926467f, 0.09078874f, 0.01930898f, 
    -0.11371986f, -0.07654089f, -0.12760231f, -0.08085349f, 0.01433652f, -0.06396526f, 0.02527561f, -0.06816655f, 
    0.17517723f, 0.23203230f, 0.47605556f, 0.11059546f, -0.00583039f, 0.02533492f, -0.02044206f, 0.05982447f, 
    0.18605177f, -0.03906773f, 0.18506004f, 0.20088346f, 0.51594955f, 0.40787545f, -0.10993794f, 0.01226933f, 
    -0.04612475f, -0.02120540f, 0.05583931f, -0.02834387f, 0.01501662f, 0.18734773f, 0.18126279f, -0.00412645f, 
    -0.32984057f, -0.32443407f, 0.29768375f, 0.06551573f, 0.17585920f, 0.08170987f, -0.02790903f, 0.02712919f, 
    -0.13695222f, 0.13221419f, 0.06688556f, 0.00873999f, 0.16848017f, 0.38553014f, -0.20344274f, -0.02443349f, 
    0.02778425f, -0.08484083f, 0.03363323f, 0.03338693f, 0.10258213f, 0.09545925f, -0.10410842f, -0.04754017f, 
    -0.25698647f, 0.05464653f, 0.07220801f, 0.01522309f, 0.10782715f, -0.08844127f, 0.10352498f, -0.09992517f, 
    -0.00288200f, 0.19191791f, 0.02050917f, 0.31337002f, -0.01283818f, 0.04679039f, 0.09052054f, 0.05509723f, 
    -0.02972323f, 0.02086515f, 0.06765381f, 0.20954512f, 0.00326584f, -0.05410020f, -0.05184837f, -0.02353956f, 
    0.13841869f, -0.04440716f, -0.13520086f, -0.09415644f, -0.19367991f, -0.16973561f, -0.02466960f, 0.06354338f, 
    -0.01932571f, 0.22605111f, -0.08329687f, -0.23448549f, -0.37162733f, -0.20525105f, -0.25176576f, -0.00063815f, 
    0.19095543f, -0.20804618f, 0.15358540f, 0.09086321f, -0.03269885f, 0.01995560f, -0.03435323f, 0.08026716f, 
    -0.02467004f, -0.02696316f, 0.02870346f, -0.02351254f, 0.00182587f, -0.03755947f, 0.02447300f, 0.00027249f, 
    -0.07539545f, 0.04273761f, 0.03151252f, 0.05224209f, 0.03066880f, -0.00999842f, 0.04761753f, 0.03794657f, 
    0.05117775f, -0.01360597f, 0.03320625f, 0.02002077f, -0.01276081f, -0.03354413f, 0.05899307f, -0.06869300f, 
    0.01626805f, 0.04567165f, -0.06706747f, 0.00997794f, 0.00775988f, -0.03998307f, -0.00156231f, -0.07694604f, 
    0.01706792f, 0.02691481f, -0.02731170f, 0.03633600f, -0.00556685f, -0.04571344f, -0.00836647f, -0.06983929f, 
    -0.06160581f, -0.07885484f, -0.06932718f, 0.05439356f, -0.03873648f, -0.04114901f, 0.06199924f, -0.06649414f, 
    0.03125532f, -0.04867884f, -0.07660512f, -0.07362800f, -0.05155627f, -0.01864711f, -0.03000501f, 0.03177178f, 
    0.04995503f, -0.02526851f, -0.03943962f, 0.02608548f, 0.00989474f, -0.02746308f, -0.01623780f, 0.04205001f, 
    0.03078590f, 0.05250324f, -0.01701814f, -0.00401494f, 0.03726127f, 0.05737198f, -0.01435173f, -0.06895365f, 
    -0.07888924f, -0.06795830f, 0.01402084f, 0.04597760f, -0.01260388f, -0.03208780f, -0.04694437f, 0.00527656f, 
    0.05616041f, -0.02134326f, 0.05431769f, -0.03301797f, -0.04557312f, 0.05622426f, -0.05393671f, -0.00672269f, 
    -0.04996395f, 0.00107501f, -0.03239229f, 0.00195016f, -0.01676323f, 0.04419774f, -0.03547358f, -0.02071963f, 
    -0.01104471f, 0.03126904f, 0.01756530f, -0.01912478f, 0.04140284f, -0.00667580f, -0.03628746f, -0.02078520f, 
    0.02803554f, -0.00010390f, -0.00988775f, -0.05025533f, -0.00885125f, 0.02327540f, -0.02788075f, -0.04701874f, 
    0.03843488f, 0.04380430f, 0.00993824f, -0.04359393f, -0.06856642f, -0.03967156f, 0.01301191f, -0.03366805f, 
    0.03205761f, -0.06181664f, -0.04361001f, -0.01501786f, -0.01594469f, -0.06141552f, -0.04811687f, -0.04964969f, 
    0.04670784f, 0.03768095f, 0.02584288f, -0.02418619f, -0.04705035f, -0.02759386f, -0.04567383f, 0.05130335f, 
    -0.02427703f, 0.04556889f, -0.04166747f, -0.00948047f, 0.01920728f, -0.01339875f, -0.01979717f, 0.01561387f, 
    0.05223686f, -0.03003982f, -0.01422805f, -0.06255115f, 0.02248744f, -0.01132960f, 0.06295615f, -0.00552531f, 
    -0.02381542f, -0.03131856f, -0.00150999f, -0.00605294f, -0.05635476f, -0.03697184f, -0.01795891f, -0.01736478f, 
    -0.07630926f, -0.04148745f, -0.01003064f, 0.00580641f, 0.04165361f, 0.00754202f, -0.06048235f, 0.06034596f, 
    -0.04386399f, -0.06282098f, -0.07508672f, -0.00029327f, 0.01594162f, -0.03557731f, -0.05808185f, -0.05573490f, 
    -0.03916547f, 0.03823741f, 0.04553927f, 0.01503512f, 0.01186556f, 0.00312964f, 0.02401827f, 0.01583470f, 
    0.03020857f, -0.05628179f, -0.02978089f, 0.02016561f, -0.00997244f, -0.01698433f, 0.03517221f, -0.04814966f, 
    0.04139572f, -0.00870312f, 0.01911860f, 0.05435258f, 0.01093314f, -0.05441225f, -0.05430374f, -0.04457557f, 
    0.00211170f, 0.04134093f, -0.00522092f, -0.02388565f, -0.00419471f, -0.04859978f, -0.04929148f, -0.01385985f, 
    0.04317348f, -0.00397110f, -0.05467697f, -0.06663986f, -0.06969804f, -0.06948687f, 0.03233000f, 0.05560761f, 
    -0.04395596f, -0.00249727f, -0.04895207f, -0.00350072f, -0.03338979f, 0.04050777f, 0.00769564f, -0.02014621f, 
    0.05599806f, 0.04133340f, -0.01796634f, 0.03348346f, -0.04044571f, -0.00180663f, 0.03795812f, -0.00362008f, 
    -0.06395965f, -0.06573833f, -0.07388098f, -0.07922141f, 0.05066916f, -0.00121535f, 0.01464393f, -0.05549208f, 
    0.02170740f, -0.04251780f, 0.05069888f, -0.04298770f, -0.01231527f, -0.03523870f, 0.03099256f, 0.05372041f, 
    0.04536749f, -0.01240955f, -0.04472474f, 0.06076963f, 0.06390605f, -0.03782637f, -0.00117832f, -0.07500397f, 
    -0.07348261f, -0.05738408f, 0.05684665f, 0.04126321f, 0.01540132f, 0.06440973f, 0.06166145f, 0.03282480f, 
    -0.04570023f, 0.06587570f, -0.00857638f, 0.01514021f, -0.06305773f, 0.01522380f, -0.06369573f, -0.05511063f, 
    -0.02445763f, 0.03633903f, -0.05793277f, -0.04208707f, -0.04017867f, -0.04318566f, 0.04644374f, -0.04723963f, 
    -0.00660234f, 0.02255673f, -0.07213701f, -0.00652238f, 0.05633109f, -0.07748298f, -0.05165641f, -0.03743785f, 
    0.01765303f, 0.04654623f, -0.03499350f, -0.00689413f, 0.06222447f, 0.01801572f, 0.00773542f, -0.01648389f, 
    -0.00535712f, 0.01629959f, -0.07048716f, -0.05656600f, 0.03298943f, -0.03748928f, 0.01696293f, -0.04966760f, 
    0.05251098f, 0.02787431f, -0.03465085f, -0.07841371f, 0.04408149f, 0.01362180f, -0.07137739f, -0.05975359f, 
    0.06727305f, 0.01618796f, -0.00844665f, -0.01375078f, -0.03104828f, 0.00198253f, 0.04618918f, 0.00893450f, 
    0.06057531f, 0.04904161f, -0.04295319f, -0.00474821f, 0.03401781f, -0.03454009f, 0.01161871f, -0.01549139f, 
    0.00987678f, -0.00737696f, -0.06121010f, -0.05047470f, 0.03347832f, 0.01667297f, -0.01682646f, -0.07531521f, 
    -0.00658417f, 0.04516861f, 0.04371154f, 0.01604821f, -0.04330513f, -0.05730569f, -0.06833092f, -0.07554831f, 
    -0.04940806f, -0.04239453f, -0.01063734f, 0.02442621f, 0.02202343f, -0.04834478f, 0.03155291f, 0.06524706f, 
    0.05312031f, 0.02032496f, -0.00598237f, -0.06022356f, -0.07231181f, 0.02150496f, 0.03835053f, -0.03520795f, 
    -0.03673511f, 0.02996875f, 0.07049192f, -0.00774842f, -0.07337480f, 0.05609073f, -0.05386174f, 0.06099343f, 
    -0.00209908f, -0.04896508f, 0.03823377f, -0.04160849f, -0.05132843f, -0.02472540f, 0.03077132f, -0.04574940f, 
    -0.03239986f, -0.06855571f, -0.05767476f, 0.00901634f, -0.07201164f, -0.03420471f, -0.05221211f, 0.00741276f, 
    -0.23129922f, 0.08494935f, 0.03553224f, 0.16179778f, -0.00624067f, -0.08664352f, 0.03675196f, -0.20915234f, 
    0.11547739f, 0.00178723f, -0.04455845f, 0.10177119f, 0.35118985f, 0.11368710f, -0.15887226f, -0.31117877f, 
    -0.16377728f, 0.04302257f, 0.10253651f, -0.06070832f, -0.10070410f, 0.14996429f, -0.06622245f, -0.03904097f, 
    0.36556658f, -0.10420735f, -0.23428948f, -0.23288697f, 0.09225094f, 0.21052824f, -0.02680702f, -0.01505781f, 
    0.00023329f, 0.15049472f, -0.17108391f, -0.22780706f, 0.42066106f, 0.11918917f, -0.21870705f, -0.01939279f, 
    0.08075529f, 0.01205420f, 0.00399127f, 0.35275140f, 0.01674258f, 0.05785915f, -0.10854433f, 0.06148986f, 
    -0.27692088f, 0.14211650f, 0.20435981f, -0.19419967f, 0.22889359f, 0.03299191f, -0.00068251f, -0.15364921f, 
    0.11573193f, -0.01145752f, 0.13706459f, -0.17335051f, 0.12516932f, 0.33331901f, 0.06742828f, -0.17843084f, 
    -0.02436519f, 0.32583293f, 0.04055150f, 0.12088753f, -0.04803453f, 0.02315052f, -0.19829057f, 0.06330592f, 
    0.32799944f, 0.46166980f, 0.12203440f, 0.01634859f, 0.16618633f, 0.14688508f, 0.14480963f, 0.16124111f, 
    -0.05932681f, -0.00179976f, 0.08453406f, -0.02999082f, -0.12535839f, -0.07289659f, 0.26869917f, 0.01512664f, 
    -0.04575310f, -0.06327768f, -0.03358049f, -0.19516963f, -0.18078269f, 0.05835992f, 0.07644691f, 0.11783894f, 
    0.12298641f, -0.01643985f, 0.19115801f, 0.12205292f, -0.25607997f, 0.03758337f, -0.01787875f, -0.03578363f, 
    0.09272642f, 0.04997014f, 0.07213053f, -0.10198867f, -0.48054352f, -0.05079904f, -0.01348609f, 0.23899792f, 
    -0.07762687f, 0.01179676f, 0.15424407f, -0.23481634f, -0.09836649f, 0.10381158f, 0.01564287f, 0.15004954f, 
    0.53090608f, 0.21976638f, -0.21458803f, -0.17554842f, -0.02844864f, 0.08245016f, -0.15737545f, 0.15519515f, 
    0.10460158f, -0.09647273f, -0.17380610f, -0.05078356f, 0.06079919f, -0.49789366f, -0.12905489f, -0.12761496f, 
    0.17282562f, 0.15013462f, -0.01221791f, -0.02855524f, 0.03789225f, 0.03342184f, 0.01074457f, -0.01361703f, 
    0.07995765f, 0.12018970f, -0.01029029f, 0.05311086f, 0.08508035f, 0.07688923f, 0.22854824f, -0.13084085f, 
    -0.03263886f, 0.08558204f, 0.06747418f, 0.14863737f, -0.10468888f, 0.09193411f, 0.21029930f, -0.08386369f, 
    0.17273407f, 0.16325575f, -0.03086543f, -0.01728602f, -0.03129439f, 0.16827150f, -0.15343522f, -0.20294116f, 
    -0.24667776f, -0.10431338f, 0.12426913f, -0.00955158f, -0.11419313f, 0.07979283f, -0.12460604f, -0.00313031f, 
    0.17883252f, 0.03201725f, -0.06171953f, 0.04611411f, 0.39591369f, 0.23392220f, -0.02262293f, -0.19722965f, 
    0.08571959f, 0.07094711f, -0.01902680f, 0.18264717f, -0.20081869f, 0.01446527f, -0.06741554f, -0.06291981f, 
    0.01126943f, -0.06686514f, -0.00256061f, 0.04016092f, 0.01666848f, 0.05570763f, -0.05945954f, -0.06900418f, 
    0.06560882f, -0.05622827f, -0.04223171f, -0.00163096f, -0.02717222f, -0.02807828f, -0.07015578f, -0.02267833f, 
    0.02626604f, -0.02555759f, -0.04529255f, -0.02826151f, 0.02267216f, 0.00684352f, -0.01024629f, -0.07508669f, 
    -0.04141197f, -0.00115468f, 0.05947577f, -0.01080560f, 0.03075377f, 0.03194411f, 0.05085538f, -0.02749599f, 
    0.00734748f, 0.02083193f, -0.02443199f, 0.00140398f, -0.00175242f, 0.06611466f, -0.00286190f, -0.05969997f, 
    0.05170790f, 0.04623087f, -0.07459283f, -0.01472646f, 0.02151024f, -0.03036007f, -0.01309018f, 0.02653368f, 
    0.04851373f, -0.03021494f, -0.00759632f, -0.03479826f, 0.00882303f, 0.00562451f, 0.01675663f, 0.04721977f, 
    0.00721844f, -0.02321165f, 0.02689173f, -0.04850779f, 0.06140887f, -0.02059680f, -0.04377085f, -0.01285176f, 
    0.02879981f, -0.07657455f, -0.01728853f, -0.04797371f, 0.04638415f, -0.04387384f, 0.06616800f, -0.01812100f, 
    0.03263444f, -0.05853325f, -0.01460709f, -0.05604770f, -0.03852249f, 0.06157815f, -0.01184978f, 0.03620684f, 
    0.00318468f, -0.06912922f, -0.01374868f, 0.04801095f, -0.02749213f, 0.04261941f, -0.02745766f, 0.05850725f, 
    -0.05775799f, -0.03957536f, -0.04747643f, 0.01191740f, 0.04036489f, 0.02955979f, -0.04756649f, -0.07619032f, 
    -0.04593937f, -0.03890774f, -0.07548391f, -0.03312701f, -0.00730682f, -0.03506142f, -0.01895341f, 0.00276745f, 
    -0.00426837f, -0.05445748f, -0.00465245f, 0.01431568f, -0.00666866f, -0.04905147f, -0.04464454f, 0.04162056f, 
    0.06035356f, -0.01699602f, 0.01750913f, -0.07316245f, 0.06092756f, -0.03371141f, -0.04788291f, -0.00897488f, 
    -0.01659190f, -0.04858523f, -0.02206033f, -0.03742383f, -0.03438260f, -0.02560149f, 0.06560185f, -0.03040266f, 
    0.05682670f, -0.03390914f, -0.04659027f, -0.03773632f, -0.02153043f, 0.03842811f, 0.03266462f, -0.01777799f, 
    0.02623841f, 0.04311651f, 0.06605699f, -0.04355190f, 0.02664327f, 0.03670967f, 0.02686272f, -0.06961959f, 
    -0.06000585f, 0.05104147f, -0.04407943f, 0.03433110f, -0.04411282f, 0.00533919f, -0.01719088f, -0.04189352f, 
    -0.04349717f, -0.03906295f, -0.04245197f, -0.01988777f, 0.01848555f, 0.00878860f, -0.03610506f, -0.05561202f, 
    -0.02822776f, 0.01258548f, -0.05622014f, -0.00760704f, -0.00846484f, 0.06088962f, 0.00561971f, -0.03007912f, 
    -0.01404535f, 0.04089974f, 0.00717922f, -0.03026064f, 0.01884639f, -0.05925334f, -0.07769151f, 0.00852496f, 
    -0.04643388f, 0.04827384f, 0.06316096f, -0.06716052f, -0.00656709f, 0.01203996f, -0.03605240f, -0.03050425f, 
    0.00018175f, -0.01300940f, -0.02108318f, -0.07557064f, -0.05255717f, 0.01881643f, 0.00637003f, -0.06056253f, 
    0.10723738f, 0.32176307f, -0.09946393f, 0.58029336f, -0.13598441f, -0.07298803f, -0.21057874f, 0.09320354f, 
    0.04522847f, 0.12218437f, -0.04925750f, -0.08028406f, 0.21334623f, -0.66837388f, 0.33108306f, 0.32373980f, 
    0.09364893f, -0.07864298f, -0.20030074f, 0.05766789f, 0.13254291f, -0.06421217f, -0.07023297f, -0.22314371f, 
    0.41766000f, 0.18349554f, 0.24336132f, -0.25864416f, -0.17348018f, 0.12178516f, 0.02852960f, 0.10269190f, 
    0.07310738f, 0.12998278f, -0.03582716f, -0.00607241f, -0.12166138f, 0.27245244f, 0.16783154f, -0.07955571f, 
    0.17093261f, 0.13964522f, 0.09129884f, -0.06689130f, -0.01086088f, -0.12297130f, 0.07550825f, 0.09917928f, 
    0.07554428f, -0.13584261f, -0.02159189f, 0.04848816f, -0.03491115f, -0.06851041f, -0.06552338f, 0.11030566f, 
    -0.00593871f, 0.16087717f, 0.36425987f, 0.03244334f, -0.33820701f, 0.08404474f, 0.05293014f, -0.34773698f, 
    0.12099269f, -0.22183943f, 0.03502753f, 0.05136666f, 0.11075362f, -0.10479131f, -0.00018871f, 0.00235734f, 
    -0.18887794f, -0.02936184f, 0.01993955f, -0.06762148f, -0.06331384f, 0.00321795f, 0.35848260f, 0.03678839f, 
    0.08192793f, 0.10901266f, 0.09991726f, 0.17891480f, -0.08826891f, -0.51646549f, 0.03354795f, 0.11690766f, 
    0.11714074f, -0.04586915f, -0.00683295f, -0.00578625f, 0.08461818f, -0.09428389f, 0.06999294f, 0.05872452f, 
    0.13529806f, -0.14869492f, -0.00805153f, -0.07301988f, -0.06236884f, 0.07266124f, -0.03136710f, -0.02641528f, 
    -0.02930079f, 0.05069317f, -0.13493939f, -0.22933654f, -0.09839864f, -0.09315955f, -0.28385186f, -0.07540288f, 
    0.16863436f, -0.05360237f, 0.11557644f, -0.08232146f, 0.14023024f, -0.17925166f, -0.18481009f, -0.06754135f, 
    -0.05584663f, -0.26918209f, 0.33610752f, -0.02516629f, 0.00629256f, 0.16866745f, -0.28699881f, 0.11820384f, 
    0.04594645f, 0.08948364f, 0.00921463f, 0.10942842f, 0.27210763f, 0.59277076f, 0.05112074f, -0.12949234f, 
    -0.16386327f, -0.13595180f, -0.05658685f, 0.07787178f, 0.11448617f, -0.03412483f, 0.03981036f, -0.05141630f, 
    -0.05839654f, 0.00145056f, 0.11934748f, -0.03973443f, -0.17109571f, 0.00900933f, 0.29869506f, -0.07784230f, 
    0.17788598f, 0.11564615f, 0.07671355f, 0.04854265f, -0.14286029f, 0.16761318f, -0.07247775f, 0.27361864f, 
    -0.03770867f, -0.02613016f, -0.15976435f, -0.12956075f, -0.05621852f, 0.00964226f, -0.05920304f, 0.05664089f, 
    0.20755649f, 0.04541731f, -0.06794696f, 0.02845201f, 0.12195200f, 0.11171150f, -0.12918822f, -0.11710982f, 
    0.02962586f, 0.22640948f, 0.19178122f, 0.24781701f, -0.48362216f, -0.00396726f, 0.21891265f, 0.02475847f, 
    -0.10139810f, -0.08413220f, 0.03428606f, 0.24820963f, 0.12694183f, -0.03078713f, 0.07938088f, -0.02431757f, 
    0.15360729f, -0.40866658f, 0.09869990f, -0.26990893f, 0.16723281f, -0.01152470f, 0.04137874f, 0.09518452f, 
    0.21826608f, 0.21786609f, 0.18490444f, -0.01909376f, -0.50745261f, 0.00380882f, 0.44720364f, 0.36575866f, 
    0.04693793f, -0.01259630f, -0.19985095f, -0.05370778f, 0.16159296f, 0.00114929f, 0.18636358f, 0.27014634f, 
    -0.23583710f, 0.25811496f, 0.03430216f, 0.36202651f, -0.11619730f, 0.15349247f, 0.01034072f, 0.26246864f, 
    0.06005052f, -0.14022851f, -0.04163276f, 0.08875475f, -0.10238100f, 0.19610795f, 0.43693271f, 0.02745000f, 
    0.21635313f, 0.08474357f, 0.11810833f, -0.18708077f, 0.02804622f, -0.06058406f, 0.00865975f, -0.04589174f, 
    -0.04161385f, -0.39003399f, -0.31096622f, 0.15898906f, 0.05639604f, -0.14530523f, 0.17965674f, 0.18364364f, 
    -0.00297506f, 0.39174795f, 0.08388206f, 0.07661310f, 0.20673668f, -0.04428914f, -0.06368392f, 0.32436413f, 
    -0.02661054f, -0.08649295f, 0.06434506f, 0.12192154f, -0.00667741f, -0.15635835f, 0.12081219f, -0.02272786f, 
    0.27737924f, 0.03225373f, 0.13954459f, 0.10645434f, -0.02045405f, 0.14228547f, -0.12152370f, 0.05740153f, 
    0.05394367f, -0.16659051f, -0.22735621f, -0.13745305f, -0.29335949f, 0.01512156f, -0.38922346f, -0.08571339f, 
    0.02033937f, 0.09507583f, -0.08604120f, 0.05778709f, 0.11490258f, 0.04404492f, 0.10971960f, 0.18137656f, 
    -0.07760924f, 0.09402457f, -0.31232956f, 0.03207807f, 0.30141255f, -0.04644305f, -0.12363167f, -0.02196038f, 
    -0.17817611f, -0.13417946f, 0.00934879f, 0.28209785f, 0.11390672f, 0.00217525f, 0.00704626f, 0.16346481f, 
    0.12415961f, 0.27605751f, -0.20603827f, 0.08360786f, -0.04225753f, 0.02883339f, 0.25900733f, 0.26514104f, 
    -0.41597268f, 0.05509404f, 0.27234295f, 0.25692657f, 0.05594112f, 0.01165613f, 0.34734333f, -0.09591144f, 
    -0.20271742f, 0.03431891f, -0.00389778f, -0.06789670f, 0.02313414f, 0.25621301f, 0.28290141f, 0.25540310f, 
    -0.06218177f, -0.11408468f, -0.15313315f, 0.12192545f, -0.01155619f, -0.10853395f, -0.06646301f, -0.12496321f, 
    -0.11698518f, 0.00359298f, 0.12344404f, -0.06573128f, 0.12447411f, 0.34085205f, -0.16618578f, -0.00773136f, 
    0.21633120f, -0.10447732f, 0.03831184f, 0.02509608f, 0.13586892f, 0.02887711f, 0.03027457f, 0.19647552f, 
    -0.13135229f, -0.08890383f, 0.23659927f, 0.00638297f, 0.12101912f, 0.11364119f, 0.21740001f, 0.33581004f, 
    -0.38715896f, -0.05586863f, -0.08083173f, -0.07487334f, 0.07029792f, 0.02546174f, 0.05368805f, 0.04743614f, 
    -0.12078604f, 0.20060046f, 0.08459559f, 0.20538957f, -0.19059628f, -0.09575354f, 0.09389590f, 0.18606928f, 
    0.13346592f, -0.16870697f, 0.31993827f, 0.00138996f, 0.01565737f, -0.02338608f, -0.03815636f, 0.06907004f, 
    -0.27774417f, -0.11778151f, 0.39381200f, 0.02007901f, 0.12427181f, -0.09749535f, -0.06915314f, -0.16732417f, 
    0.06503711f, 0.02748057f, -0.00434857f, -0.02229267f, 0.09001554f, -0.01350514f, 0.25263608f, -0.08179016f, 
    0.00037802f, 0.01641246f, 0.00308188f, -0.08884717f, -0.00161046f, -0.07126013f, -0.11688117f, -0.00952178f, 
    0.32152560f, -0.21354708f, -0.46552598f, -0.13314053f, 0.10327005f, 0.01303468f, -0.05296420f, 0.21264991f, 
    0.00391848f, -0.00218154f, -0.11325147f, -0.02526354f, 0.59388131f, 0.31276345f, 0.12242465f, 0.00927703f, 
    -0.01185627f, -0.05436967f, 0.07237809f, 0.20897119f, 0.01707454f, 0.19734003f, 0.06370354f, 0.09433260f, 
    -0.08398886f, 0.03727508f, 0.07708884f, -0.15650313f, 0.13430680f, -0.08667691f, -0.09694372f, -0.06185779f, 
    -0.06509030f, 0.16345982f, 0.05263317f, -0.05210182f, -0.20472161f, 0.45370537f, -0.04110646f, -0.33223411f, 
    -0.00461067f, 0.28852129f, 0.10692128f, 0.11001497f, 0.12173313f, 0.01547149f, -0.07217636f, 0.07646695f, 
    0.37389597f, 0.54514098f, -0.00971496f, -0.15302843f, 0.22017916f, 0.31366718f, 0.13286337f, 0.14469455f, 
    0.06794429f, 0.05607399f, 0.15346722f, 0.07110084f, 0.00792747f, 0.13815606f, -0.06744055f, 0.15498054f, 
    0.03402079f, 0.05381509f, -0.06330166f, -0.12800576f, -0.03750441f, -0.07749524f, 0.02558170f, 0.03037288f, 
    0.10870171f, 0.00953041f, 0.08467316f, 0.26872128f, -0.12677765f, 0.12839997f, -0.04742945f, -0.08430584f, 
    0.05033415f, -0.14209622f, 0.08739910f, 0.12640606f, -0.30685201f, 0.15149072f, 0.00990126f, 0.44117999f, 
    0.08998396f, -0.00276261f, -0.00242963f, -0.21598269f, -0.11101993f, -0.09404390f, 0.06579449f, 0.15374495f, 
    0.28094465f, 0.25241783f, -0.47899890f, -0.14283162f, 0.02442939f, 0.08372972f, 0.08198408f, -0.03911971f, 
    0.15516283f, -0.00935129f, 0.08529878f, -0.04653846f, 0.10625459f, -0.56924361f, 0.02058834f, -0.21346274f, 
    0.08333246f, -0.02807862f, -0.01527406f, 0.07785694f, -0.12727945f, -0.07507782f, 0.12683541f, -0.06188310f, 
    -0.04445020f, 0.03520982f, -0.02035415f, -0.03669518f, -0.02857308f, 0.38582006f, 0.03327241f, -0.10072301f, 
    0.10868471f, -0.06167094f, 0.14563681f, 0.06803264f, -0.36964065f, 0.23345062f, 0.15458420f, 0.00793260f, 
    0.14495383f, 0.13755982f, 0.06883639f, 0.06572153f, 0.05666645f, 0.05063795f, -0.10829776f, -0.11333141f, 
    -0.33799371f, 0.00849686f, 0.15342979f, -0.00376575f, -0.11352307f, -0.01899830f, -0.13226938f, 0.08262957f, 
    0.05923450f, 0.06496156f, -0.01329107f, 0.04745124f, 0.16720152f, 0.11326705f, -0.28894836f, -0.27304965f, 
    0.04021081f, -0.00882938f, 0.01543042f, 0.02303626f, -0.05800789f, 0.11686389f, -0.01767825f, -0.01255313f, 
    -0.19119205f, 0.01619353f, 0.13041738f, -0.39041632f, 0.12668748f, 0.04915136f, 0.13002357f, -0.00250682f, 
    0.05465805f, 0.04445917f, 0.18549687f, 0.27965194f, -0.50202769f, 0.47818947f, 0.00844530f, -0.04334624f, 
    0.04069631f, 0.24045983f, 0.15357590f, -0.02221112f, 0.15490249f, 0.24652845f, 0.17671144f, 0.42186639f, 
    -0.35201845f, 0.06384918f, -0.01139446f, 0.37346986f, 0.11383568f, -0.31391478f, 0.21171793f, 0.25647625f, 
    -0.09148782f, -0.11488428f, 0.30237460f, -0.13173324f, -0.17328306f, -0.35648495f, -0.09684712f, 0.06661579f, 
    -0.28109160f, 0.04932606f, 0.01546104f, 0.01703278f, -0.11195393f, 0.01531982f, -0.14175461f, -0.02556905f, 
    -0.08386255f, -0.02866263f, -0.15758233f, 0.04370230f, 0.04053888f, 0.44527209f, 0.18244430f, 0.14091928f, 
    0.01176902f, -0.10281302f, -0.21583870f, 0.02648729f, -0.07672995f, -0.08315551f, 0.24433254f, 0.20356956f, 
    -0.04918220f, 0.14810237f, 0.19320349f, -0.13493241f, -0.06674828f, 0.05539183f, 0.02800312f, -0.00205851f, 
    -0.05174936f, 0.17206338f, -0.11635059f, -0.10875914f, -0.07467255f, -0.24585867f, -0.27302027f, 0.03494406f, 
    -0.12422351f, -0.19140418f, -0.13886948f, -0.18870139f, 0.17425972f, 0.42972717f, -0.11998783f, 0.06612805f, 
    -0.06716469f, 0.14512780f, -0.11758310f, -0.03986467f, -0.06396852f, 0.18984537f, -0.03933703f, -0.13797639f, 
    -0.19108197f, 0.26679173f, 0.11808915f, 0.06547242f, 0.08386274f, -0.15025459f, 0.02665860f, -0.15728743f, 
    -0.00363729f, 0.03694550f, 0.33979639f, 0.24507414f, 0.23715156f, 0.07954665f, 0.24278897f, 0.06542180f, 
    -0.10561988f, 0.13053313f, -0.01694012f, 0.15565005f, -0.08023324f, 0.32412744f, 0.17021805f, -0.10483632f, 
    0.07869978f, 0.17286889f, -0.06596958f, 0.22359474f, -0.06887208f, 0.08588170f, 0.44030115f, -0.11651754f, 
    -0.02656151f, 0.10024828f, 0.15224476f, 0.02118735f, -0.25169986f, -0.11131933f, 0.10753047f, -0.00365710f, 
    -0.08650117f, 0.01858132f, 0.07535496f, 0.23070402f, 0.00767542f, 0.16992252f, -0.08111013f, 0.10301863f, 
    -0.01157810f, 0.08384293f, -0.04370413f, -0.00089470f, 0.29501247f, 0.00225478f, -0.24630129f, 0.27817869f, 
    -0.15911286f, -0.08727459f, -0.07932449f, -0.11955143f, 0.18751106f, -0.16831073f, -0.04640082f, -0.08539431f, 
    0.21956192f, 0.23475647f, 0.13329504f, 0.35158926f, 0.08979409f, 0.07890256f, 0.30130830f, 0.08006799f, 
    0.02111826f, -0.12472665f, -0.03632238f, -0.00866264f, -0.14061376f, 0.02043573f, 0.21016710f, 0.18775015f, 
    0.03324643f, 0.08304506f, 0.08280689f, 0.01414693f, 0.53927988f, 0.03075134f, -0.20536487f, -0.00789572f, 
    0.16056605f, 0.14840958f, 0.13849527f, -0.00162886f, -0.16938591f, 0.07025549f, -0.04359894f, -0.02821537f, 
    0.03516082f, -0.04726040f, 0.05107232f, -0.04663065f, -0.00299161f, 0.01692679f, -0.01412849f, -0.05905523f, 
    -0.03331766f, -0.07224440f, -0.02641630f, -0.04610830f, 0.02393412f, -0.02678620f, 0.05290458f, -0.01253641f, 
    -0.06248784f, 0.01714201f, -0.06659853f, -0.02110665f, -0.05863525f, -0.01244070f, -0.07638074f, -0.07206072f, 
    -0.04700578f, 0.02361681f, 0.02168578f, -0.04226600f, -0.03364167f, 0.03646236f, 0.04968003f, -0.01770127f, 
    0.05871986f, 0.00229571f, -0.00717050f, -0.01775221f, 0.05115523f, 0.02749279f, -0.06685048f, 0.06692268f, 
    0.02165002f, -0.00597017f, 0.04082391f, -0.02100653f, 0.01996862f, -0.05991539f, 0.01268384f, -0.01803394f, 
    -0.00353677f, -0.03015150f, -0.03016755f, -0.03970547f, 0.01053791f, 0.03947646f, 0.03174766f, -0.06388426f, 
    -0.06238049f, 0.01749394f, -0.04816888f, -0.04899831f, 0.01975043f, 0.05035461f, -0.00151071f, -0.06922038f, 
    -0.04733621f, -0.02061432f, -0.02322787f, -0.05158969f, 0.03071166f, -0.06071955f, -0.02969589f, -0.05022205f, 
    -0.00453958f, -0.06283218f, 0.05240566f, 0.06382028f, 0.05500479f, -0.02741908f, -0.06103166f, 0.06778904f, 
    -0.04023270f, -0.04491518f, 0.02293497f, 0.02698718f, 0.05021868f, -0.02338627f, -0.00800367f, 0.00833867f, 
    0.03969250f, -0.03170542f, -0.06224082f, 0.02261216f, 0.03068310f, -0.04752348f, -0.05351678f, -0.04006230f, 
    0.06528980f, 0.02334286f, 0.06394248f, 0.03666271f, -0.05675813f, -0.02275166f, -0.00837067f, -0.07245632f, 
    -0.01709986f, -0.03287164f, 0.06724969f, 0.04682129f, -0.05008116f, -0.01428979f, -0.02247036f, -0.04676987f, 
    -0.06171579f, 0.01059212f, -0.01872224f, -0.05239479f, -0.02690755f, 0.03455671f, 0.05945941f, -0.01792218f, 
    0.07303821f, -0.01952391f, -0.06177212f, -0.06884099f, -0.06368060f, 0.05241914f, -0.01731485f, 0.06117516f, 
    -0.04263089f, 0.06140745f, -0.05543708f, -0.07303334f, 0.03088343f, -0.06755804f, 0.01912967f, -0.02521448f, 
    -0.04385593f, -0.06676697f, 0.02726596f, 0.05020657f, 0.03501368f, -0.05496772f, -0.06550247f, -0.07856557f, 
    -0.04230383f, 0.06295826f, 0.04870093f, -0.05299861f, 0.07066394f, -0.03380129f, -0.06863349f, 0.01807882f, 
    0.05865800f, 0.06899765f, 0.04238502f, -0.05990766f, 0.05453433f, 0.03428106f, 0.04513062f, -0.00823091f, 
    0.06581187f, -0.03763364f, -0.03114293f, -0.05603007f, -0.06979368f, 0.03232142f, 0.03904709f, 0.03456654f, 
    0.02611063f, -0.05161162f, 0.03951876f, -0.01042198f, -0.03016046f, 0.02986229f, -0.00405192f, 0.00041042f, 
    -0.03176906f, -0.02967886f, -0.02343356f, -0.05205492f, -0.06323483f, 0.04230630f, -0.00561355f, 0.02661066f, 
    0.03229825f, 0.04566228f, 0.04447202f, -0.07127190f, -0.06142741f, -0.02168294f, 0.01365465f, -0.03342253f, 
    0.40186515f, 0.05444838f, -0.05087543f, -0.23637079f, -0.16241966f, 0.05673985f, 0.04995200f, -0.10040966f, 
    -0.09043409f, 0.10883660f, -0.06737431f, 0.07286974f, 0.73715818f, 0.01856341f, -0.02337307f, -0.06730116f, 
    -0.05798952f, 0.04644776f, 0.22038504f, 0.13869672f, 0.14170070f, 0.29929990f, 0.15303683f, 0.08052782f, 
    -0.33899775f, 0.00452471f, -0.26760665f, 0.20869941f, 0.22264867f, 0.11482669f, 0.24423176f, 0.18295825f, 
    0.31945267f, 0.02618366f, 0.11818207f, 0.08069994f, -0.29791415f, -0.24036397f, -0.35277811f, -0.01367295f, 
    0.03607216f, -0.11234715f, -0.04956462f, -0.04869958f, 0.10744805f, -0.02078047f, -0.03311403f, 0.04228987f, 
    0.04671374f, 0.12214288f, 0.03881991f, 0.05951770f, -0.02004406f, 0.10859197f, 0.15676355f, 0.03387206f, 
    -0.00048864f, -0.19190076f, -0.12449401f, 0.13801898f, -0.22136682f, -0.36154923f, -0.22685768f, 0.23155195f, 
    -0.00464180f, -0.02364296f, 0.01670423f, 0.13904503f, -0.11331476f, -0.00903588f, -0.17151621f, 0.09257568f, 
    -0.43100861f, -0.47640377f, 0.00750164f, -0.11602750f, 0.00128774f, -0.09443074f, -0.01507432f, -0.01091975f, 
    0.14961608f, 0.08816801f, -0.12673394f, -0.02081968f, 0.33608884f, 0.32057402f, 0.31430987f, 0.04779064f, 
    -0.12681188f, -0.23326159f, -0.09100878f, 0.03730873f, -0.17061992f, -0.09690682f, -0.01936403f, 0.04469719f, 
    0.35897186f, 0.10249524f, 0.31715047f, 0.04339961f, 0.03867859f, -0.06969900f, 0.11695064f, -0.08253296f, 
    0.09058557f, 0.33708310f, 0.10680992f, -0.09730841f, 0.38931516f, 0.16755579f, 0.48409763f, -0.02082615f, 
    -0.08836940f, -0.04093518f, 0.01977085f, 0.26184273f, -0.08576522f, 0.02256014f, 0.05890964f, -0.09681224f, 
    0.02781630f, -0.19714014f, 0.07565611f, -0.01419982f, -0.13381252f, -0.00127364f, 0.05145591f, 0.24201380f, 
    -0.04074597f, 0.12951197f, 0.04502820f, 0.03784601f, -0.05302423f, -0.17806296f, -0.52292997f, -0.13167132f, 
    0.05550875f, 0.22680150f, 0.19950850f, 0.24781162f, 0.26657525f, 0.00429883f, -0.02165159f, 0.11844500f, 
    -0.06204551f, 0.05536471f, 0.00976505f, 0.05636528f, 0.06528864f, -0.03022309f, -0.01250354f, -0.04354336f, 
    -0.10934855f, 0.00026270f, -0.04724805f, -0.00472213f, 0.37181762f, -0.12115705f, 0.03545797f, 0.00776765f, 
    0.12947316f, 0.13244039f, -0.03080796f, 0.16153109f, 0.16143741f, 0.17404456f, -0.10613903f, 0.00478469f, 
    0.20343694f, -0.07310133f, -0.14282352f, 0.01815343f, 0.03427569f, 0.04969893f, 0.00192600f, 0.10269468f, 
    0.01310048f, -0.11525833f, -0.05442263f, 0.04958497f, 0.00893305f, -0.02328740f, -0.18797663f, -0.09583858f, 
    0.11100215f, -0.02708596f, -0.25921685f, 0.03321768f, -0.01345494f, 0.01312686f, -0.09542052f, -0.06102480f, 
    -0.08042188f, -0.30230573f, -0.47304761f, 0.39272484f, 0.04204376f, 0.01493899f, -0.07973275f, -0.08799679f, 
    0.08720875f, -0.06052494f, -0.05277361f, -0.09033021f, -0.26057762f, 0.07546843f, -0.00156936f, 0.32099500f, 
    0.05479315f, -0.13842383f, 0.02476566f, 0.10895026f, 0.09567095f, 0.14144708f, -0.01158440f, 0.05248522f, 
    -0.04032002f, -0.00300517f, 0.73871171f, -0.30480197f, -0.15270713f, 0.32942420f, 0.28845087f, 0.10531759f, 
    0.00719485f, 0.06657231f, -0.17673555f, -0.00941020f, -0.41379058f, -0.03220934f, 0.08973432f, -0.02851757f, 
    -0.25320801f, -0.02705101f, 0.24411239f, 0.24180734f, 0.16263664f, -0.09111254f, -0.03152885f, -0.00817008f, 
    0.09885573f, 0.01321874f, -0.07190840f, 0.15959288f, 0.13749114f, 0.13611560f, -0.14845179f, -0.04352613f, 
    -0.04553242f, 0.12384310f, -0.13296141f, 0.20465399f, 0.10846018f, 0.31875896f, -0.24269909f, 0.29496527f, 
    0.05083018f, 0.00009815f, -0.32154766f, 0.03985868f, 0.22183281f, 0.10339274f, -0.18638161f, 0.22665711f, 
    -0.16931494f, -0.23000458f, 0.02679734f, 0.23374222f, -0.02243649f, 0.17058267f, -0.01767260f, -0.05213875f, 
    0.13543743f, -0.11467265f, -0.08600641f, -0.17685869f, 0.24602135f, 0.10488044f, -0.14460433f, 0.15093330f, 
    -0.24883084f, -0.11681386f, -0.17646724f, -0.12504798f, -0.00142512f, -0.05927962f, -0.02338821f, -0.08208715f, 
    0.24093495f, 0.04292193f, -0.40532702f, 0.53569722f, -0.07898726f, -0.06915187f, 0.10573217f, 0.09540606f, 
    0.10979527f, 0.28598613f, -0.02807953f, -0.13162944f, 0.12949434f, -0.05454005f, 0.31013891f, 0.15814477f, 
    0.15579750f, -0.15125017f, -0.16636562f, 0.21451098f, 0.06829869f, 0.06401474f, 0.27946457f, 0.11427265f, 
    -0.13234241f, 0.26839429f, 0.28775418f, 0.13925166f, -0.03841227f, -0.00230830f, 0.06490337f, 0.11891701f, 
    0.08728935f, 0.01777473f, -0.03909873f, 0.26301897f, -0.60522175f, 0.10986029f, 0.56556630f, -0.04989661f, 
    -0.16245238f, 0.00895463f, 0.19294544f, -0.07051957f, 0.09251850f, 0.00043317f, 0.18550992f, 0.01669814f, 
    0.20407704f, -0.11427584f, -0.12165354f, -0.09889562f, 0.03191445f, 0.26229802f, -0.00858807f, 0.18608591f, 
    0.01316858f, -0.05889373f, -0.18901114f, -0.16695808f, 0.00476243f, -0.06187811f, 0.04646650f, 0.36826530f, 
    0.32029051f, 0.02927775f, 0.14329764f, -0.18920684f, 0.01620950f, 0.11023381f, 0.23145761f, 0.36100066f, 
    -0.28230160f, -0.01313225f, -0.20863870f, -0.04811737f, -0.02030124f, 0.04263165f, -0.08219922f, -0.29797310f, 
    0.29036242f, -0.01003363f, -0.02667623f, 0.28990793f, -0.06080649f, 0.34412631f, 0.82890862f, 0.40408784f, 
    -0.08656199f, -0.02962053f, 0.20151152f, -0.02163699f, -0.00807817f, -0.04293296f, 0.18912694f, 0.06977026f, 
    -0.06492159f, -0.42783535f, -0.23968251f, 0.12087011f, 0.10106130f, -0.11228221f, -0.22963509f, 0.00287528f, 
    0.10226180f, 0.16288301f, 0.16606025f, 0.15242665f, -0.05466113f, 0.27984661f, 0.01353853f, 0.05502579f, 
    0.04097058f, -0.13954470f, -0.06052149f, 0.04673436f, 0.19362286f, -0.14277074f, 0.03882128f, -0.06981846f, 
    -0.18331893f, -0.03267176f, 0.25562769f, 0.06083824f, 0.02786202f, 0.28197533f, 0.15715565f, 0.07480819f, 
    0.32681546f, 0.06906286f, 0.12607229f, 0.15699790f, -0.30535716f, 0.04236908f, -0.09616795f, -0.02623351f, 
    0.06698828f, 0.12752508f, 0.09918749f, -0.31583494f, -0.00255961f, -0.12928388f, -0.06835494f, -0.01052366f, 
    -0.11211729f, -0.20840238f, -0.14072315f, -0.07649425f, 0.15442348f, -0.15687478f, -0.15915884f, 0.14503478f, 
    0.00155539f, 0.19534418f, -0.10832251f, -0.10730389f, -0.22168536f, 0.35600761f, 0.01796755f, -0.00401770f, 
    0.13456707f, -0.00650455f, -0.02699914f, 0.08646868f, 0.03767626f, 0.00566564f, -0.06141461f, 0.08631480f, 
    -0.25174683f, -0.31442997f, -0.29120779f, -0.21470684f, 0.08062950f, 0.08096445f, -0.12860410f, 0.03657241f, 
    -0.02458354f, 0.04093060f, -0.04699372f, 0.21876007f, -0.15307748f, 0.09132045f, 0.09990977f, 0.02944190f, 
    -0.11827387f, -0.33946401f, -0.13410597f, -0.17102511f, -0.04665711f, -0.13934261f, -0.14402634f, 0.01366262f, 
    -0.24400140f, -0.13045095f, 0.11693850f, -0.04277711f, -0.20487233f, -0.01372818f, -0.10940658f, 0.07119870f, 
    0.11282932f, 0.02492867f, 0.15257695f, 0.28190860f, 0.11982928f, 0.26995105f, -0.06059700f, -0.43155789f, 
    0.03019274f, -0.01284151f, 0.05853982f, -0.00410109f, 0.15939586f, -0.02468860f, 0.35798100f, 0.11399751f, 
    -0.09165157f, -0.06541578f, 0.42623365f, -0.05069434f, 0.08792499f, 0.04516931f, -0.00535177f, 0.04876506f, 
    0.00083899f, 0.01598581f, 0.03683078f, 0.12458446f, 0.01100799f, 0.03946532f, -0.31807959f, -0.15534674f, 
    0.09931611f, 0.01778838f, -0.02470864f, 0.01234072f, -0.07078525f, 0.06470837f, 0.00749875f, 0.02371988f, 
    -0.08583930f, 0.04904921f, -0.11715655f, -0.03204254f, -0.00458603f, 0.05937971f, 0.27926698f, -0.09940506f, 
    0.28744528f, 0.14343672f, 0.08095749f, 0.32065779f, 0.19088840f, -0.10083313f, 0.25696781f, 0.02144048f, 
    0.10065058f, -0.04936640f, 0.16971542f, 0.12365095f, 0.02876154f, 0.00708330f, -0.03512936f, -0.04328559f, 
    -0.15457220f, -0.16389422f, -0.17004101f, 0.03482627f, -0.01983729f, -0.07320556f, -0.14433815f, -0.10489132f, 
    0.20029637f, 0.15718651f, 0.11045863f, -0.01832145f, -0.24484228f, -0.05778923f, 0.17514443f, 0.09698928f, 
    0.29973972f, 0.00161688f, 0.15135010f, 0.05261100f, 0.04196477f, -0.09636008f, 0.03069620f, 0.12288175f, 
    0.10678786f, 0.64577293f, -0.05639202f, 0.27602223f, -0.15048565f, 0.04220245f, -0.11860527f, -0.01756641f, 
    0.05454531f, -0.04387512f, -0.10022481f, 0.12090477f, 0.38080812f, 0.33213314f, -0.42457280f, 0.05692270f, 
    0.07047311f, -0.11147736f, 0.06967851f, -0.14904991f, 0.07512153f, 0.28437641f, 0.03765122f, 0.12409423f, 
    0.26495630f, -0.11237393f, 0.21516640f, -0.22893198f, 0.18456878f, 0.07471984f, -0.19069801f, -0.17538874f, 
    -0.10387414f, -0.12271917f, -0.10267599f, -0.13935523f, 0.12846003f, -0.01084914f, -0.47692779f, -0.08226779f, 
    -0.04434011f, -0.07030841f, 0.03353795f, 0.18943146f, 0.01994534f, 0.08846010f, -0.01026862f, 0.04875132f, 
    -0.13448979f, 0.22208214f, 0.05095683f, -0.19269204f, 0.03956327f, 0.30172023f, 0.14520085f, 0.06695966f, 
    0.22391964f, -0.17884237f, 0.23088264f, 0.00901842f, 0.23576000f, 0.17106907f, -0.02826850f, 0.01895373f, 
    0.07814254f, 0.12350709f, -0.18857309f, -0.10933930f, -0.12771630f, 0.05491974f, 0.07253027f, 0.07273471f, 
    0.25324318f, -0.09607840f, -0.39816156f, -0.33338150f, -0.14815678f, -0.11670103f, 0.01225592f, -0.06006436f, 
    -0.01707456f, 0.06596227f, -0.06322929f, -0.23058984f, 0.15986659f, -0.13674513f, 0.25144079f, 0.14593206f, 
    -0.05561345f, 0.07411127f, 0.04732388f, -0.10526750f, -0.09260933f, 0.11007494f, 0.04160812f, 0.29411775f, 
    0.10926462f, -0.01017257f, 0.03544671f, 0.21161112f, -0.27596581f, -0.09716814f, 0.09785153f, -0.10730695f, 
    -0.08405687f, 0.04028647f, 0.07201627f, -0.16302824f, -0.27201077f, -0.14717484f, 0.01892646f, -0.22726430f, 
    -0.12444760f, -0.06951234f, -0.01630034f, 0.03281652f, 0.02320981f, 0.02024009f, -0.11549830f, -0.02797480f, 
    0.40083155f, -0.00451290f, -0.04928716f, -0.01401799f, 0.00821385f, 0.17832589f, -0.02005395f, 0.22992359f, 
    0.05945878f, -0.12566367f, 0.01946671f, 0.08820587f, -0.15412046f, 0.35709307f, 0.07854176f, 0.01528332f, 
    -0.14356914f, -0.12584007f, 0.01975843f, 0.00973020f, -0.02411684f, 0.13077210f, 0.07589720f, 0.17109250f, 
    0.12765899f, -0.08746389f, -0.20421498f, 0.02844911f, -0.02627359f, -0.20509247f, 0.09652074f, 0.12667783f, 
    -0.24615386f, 0.01164602f, -0.10903404f, -0.29797611f, 0.08450226f, 0.00065733f, -0.01090693f, -0.01662925f, 
    0.21788965f, 0.08369122f, -0.01155389f, 0.05937465f, 0.01587396f, 0.19658670f, 0.07887909f, -0.03058854f, 
    0.01913353f, 0.11914828f, -0.18397066f, 0.03746982f, -0.08095324f, 0.03702178f, -0.14443518f, -0.24602471f, 
    0.23458786f, 0.00899338f, 0.10815622f, 0.21879539f, 0.31127623f, -0.01749547f, 0.20043318f, 0.08228385f, 
    -0.04959582f, 0.20405225f, -0.11185501f, 0.12694523f, -0.04524507f, -0.18010722f, 0.00065881f, 0.14589845f, 
    -0.53772169f, 0.01741672f, 0.25159174f, 0.14165339f, -0.05212486f, -0.00143422f, -0.07240251f, 0.01476568f, 
    0.03796482f, 0.15374497f, -0.09968659f, -0.04770678f, -0.17717533f, -0.42359260f, 0.29662365f, 0.23321769f, 
    0.15541920f, 0.11419030f, 0.11664575f, 0.04855379f, 0.27235940f, 0.13755611f, 0.16114882f, 0.14821199f, 
    0.42627060f, -0.15758951f, 0.05458606f, -0.10945963f, 0.07272415f, -0.29307899f, -0.13664952f, 0.10371476f, 
    -0.09200171f, -0.05968782f, 0.19775245f, 0.04360295f, 0.27638745f, 0.32152790f, 0.18491662f, 0.05564628f, 
    -0.12841320f, 0.02901035f, -0.14860277f, 0.02931736f, 0.02368050f, 0.04890663f, 0.10620674f, -0.00841353f, 
    0.06957451f, -0.17472729f, -0.10235014f, -0.04401921f, 0.00533326f, 0.22994636f, -0.02803213f, 0.07454202f, 
    0.01926615f, -0.04231292f, -0.00657545f, 0.07532194f, -0.89681619f, 0.50454152f, -0.17886178f, -0.17626376f, 
    0.01999619f, -0.14007699f, 0.09380434f, -0.04180583f, 0.10176682f, 0.00650426f, 0.10619529f, 0.02234448f, 
    0.13867924f, 0.37099612f, 0.13250363f, -0.14850132f, -0.02511482f, -0.17516011f, -0.01256567f, -0.05082791f, 
    -0.00173219f, -0.02339936f, 0.05837163f, -0.03090816f, 0.10298061f, 0.07071084f, -0.35605121f, 0.15296111f, 
    0.08262617f, 0.12338176f, 0.03245616f, 0.09351280f, 0.04246640f, -0.02163064f, -0.01127210f, -0.25182092f, 
    -0.18495119f, -0.29729834f, 0.11892398f, 0.05079324f, 0.17379937f, 0.05688659f, 0.01839720f, -0.07541576f, 
    -0.12829725f, -0.01988507f, 0.15320450f, 0.08936412f, 0.12010188f, -0.05550046f, -0.14481471f, 0.08113624f, 
    0.21661165f, 0.05314149f, 0.00266829f, 0.10994714f, 0.05587099f, 0.00289372f, -0.01253086f, -0.20283926f, 
    0.08014416f, 0.09083626f, -0.17824955f, -0.02930026f, -0.02900792f, 0.06803821f, 0.16776267f, -0.18820323f, 
    0.14822069f, 0.05116842f, 0.14650622f, 0.10713929f, 0.36493981f, 0.27986553f, 0.36096376f, -0.40844160f, 
    -0.07228524f, -0.15499774f, -0.05052896f, 0.11244269f, -0.04356446f, 0.10582056f, 0.14912142f, -0.05961382f, 
    -0.26078835f, -0.06101267f, 0.10841031f, -0.10626671f, 0.12464676f, 0.09046379f, -0.19051996f, 0.21924868f, 
    0.00077241f, -0.16667712f, -0.14339401f, -0.22738031f, -0.37033758f, 0.05444897f, -0.00360769f, 0.28007305f, 
    -0.00842098f, 0.01369116f, 0.13167435f, 0.20508394f, 0.22299175f, 0.03651468f, 0.35401142f, 0.11736275f, 
    0.13349211f, 0.09363580f, -0.16631046f, -0.07224555f, -0.09587093f, -0.04698671f, 0.10097766f, -0.00072955f, 
    0.14787982f, 0.21070175f, 0.16210188f, 0.17814456f, -0.07609535f, 0.06950241f, -0.10331065f, -0.10403500f, 
    0.03820464f, 0.12737975f, 0.00875921f, -0.16892548f, 0.17778790f, 0.06159307f, 0.03959044f, 0.05494504f, 
    -0.31663728f, 0.31542480f, 0.20983006f, 0.41068980f, -0.21063399f, -0.01478339f, -0.00260824f, -0.11806568f, 
    -0.03357803f, -0.15863301f, -0.11456455f, 0.08870903f, -0.13810495f, -0.17310628f, -0.29205075f, 0.21084362f, 
    0.03682306f, 0.16883096f, -0.01265774f, -0.01631704f, 0.12598349f, 0.29495320f, 0.00385874f, 0.17767145f, 
    0.40573901f, 0.01802402f, 0.35127476f, -0.18313579f, 0.14834078f, -0.03630868f, -0.02625105f, -0.01600014f, 
    -0.16112097f, 0.09622329f, 0.03772963f, -0.13144764f, -0.24434458f, -0.41786426f, -0.19745909f, -0.26991907f, 
    -0.36706072f, -0.00666135f, -0.05032427f, 0.32711709f, 0.01711625f, -0.08103872f, -0.03908309f, -0.09243223f, 
    -0.03861140f, 0.13578776f, -0.03799398f, 0.08115481f, 0.01218123f, 0.28717399f, -0.08464547f, -0.05168708f, 
    0.25116214f, -0.11518800f, -0.06104298f, 0.14827524f, -0.07238242f, -0.19336469f, 0.08870089f, -0.12239170f, 
    -0.01780004f, 0.00457636f, -0.18898186f, -0.12898506f, 0.11248750f, 0.08611403f, -0.33227599f, 0.14226621f, 
    -0.13889405f, -0.03397508f, -0.09850922f, -0.05006878f, -0.18724462f, -0.13138266f, 0.07744497f, 0.09379997f, 
    -0.17129858f, -0.08825985f, 0.14468218f, -0.12817281f, 0.24205564f, -0.01230068f, -0.16038582f, 0.13314402f, 
    -0.12198572f, 0.13516422f, 0.01859740f, -0.00547033f, 0.03349733f, 0.10613427f, 0.02431609f, 0.12733014f, 
    0.08170526f, 0.07146412f, 0.16707525f, 0.44046393f, 0.02016978f, 0.03575458f, 0.13046494f, -0.07667527f, 
    -0.00123766f, 0.20091382f, -0.02466185f, -0.21407729f, 0.15256493f, -0.07443836f, -0.01292155f, 0.18816790f, 
    -0.03673382f, -0.09783523f, 0.04908157f, 0.07967919f, 0.19896051f, 0.19451851f, -0.10805538f, 0.06998537f, 
    0.32898998f, -0.06674922f, -0.11385263f, 0.08458734f, -0.15206817f, -0.04475387f, -0.02814999f, 0.03204816f, 
    0.08455428f, 0.03870333f, -0.03716006f, 0.06109440f, -0.14319338f, 0.32146716f, 0.57301021f, -0.47980577f, 
    -0.16752253f, -0.16932364f, 0.01882021f, -0.03352349f, 0.07336817f, 0.03567380f, 0.11821788f, 0.08961768f, 
    0.15344423f, 0.03736422f, 0.04666049f, 0.18155642f, 0.03395699f, -0.01892898f, 0.01997032f, 0.24729526f, 
    -0.29724240f, -0.03215422f, -0.09279478f, -0.11553399f, -0.09873439f, 0.08536920f, -0.25117660f, 0.13622239f, 
    0.21852471f, 0.13824071f, -0.05357297f, -0.08531797f, -0.03600166f, 0.12697756f, 0.25361115f, 0.07053830f, 
    0.18319036f, 0.07413290f, -0.06297369f, -0.14549147f, -0.13523780f, 0.00350875f, 0.00137673f, -0.02595069f, 
    0.20394032f, -0.06610509f, 0.03488486f, 0.03352244f, 0.23800942f, 0.24705581f, 0.39395568f, 0.21196198f, 
    -0.23911612f, -0.00012270f, -0.14805505f, -0.07756452f, -0.10101086f, -0.07949363f, 0.09104577f, -0.11365210f, 
    0.16514094f, 0.04418522f, -0.07887044f, 0.21466692f, 0.05000043f, -0.08176296f, -0.11903631f, 0.09809893f, 
    0.22240731f, 0.03306068f, -0.15667556f, 0.09185740f, -0.14960876f, 0.25731677f, 0.36063227f, 0.05493195f, 
    -0.01034460f, 0.18075314f, -0.13956840f, 0.12520462f, -0.11608518f, -0.02779008f, 0.13332804f, 0.27698907f, 
    0.11650214f, -0.07473511f, 0.07730483f, 0.04447673f, -0.04872734f, 0.05176042f, 0.04807453f, 0.04106225f, 
    0.00169098f, 0.06591062f, -0.01472738f, -0.11272492f, 0.26018021f, 0.40859497f, 0.25520468f, 0.04488753f, 
    0.51842910f, 0.22305448f, 0.05516819f, 0.05641007f, 0.11454515f, 0.07314524f, 0.10636036f, -0.07653195f, 
    -0.05236730f, -0.44483250f, -0.09192497f, -0.02365927f, 0.01752542f, -0.12591301f, 0.13584526f, 0.14475873f, 
    -0.03523260f, 0.02358151f, 0.24044290f, 0.06068239f, 0.25165102f, 0.17542937f, -0.16157246f, 0.02959164f, 
    -0.04229855f, -0.19489102f, 0.14659968f, 0.03259959f, -0.10740271f, -0.08431108f, 0.14773880f, -0.10546787f, 
    0.53939438f, 0.19014312f, 0.04002874f, 0.08016839f, 0.08202957f, 0.11777285f, 0.08810692f, 0.25482666f, 
    0.15693945f, 0.03200145f, -0.03307004f, 0.05039236f, -0.67330623f, -0.71415734f, -0.24764661f, -0.18788698f, 
    0.09946754f, -0.06711739f, -0.35818505f, -0.02530619f, 0.18578483f, -0.01435636f, 0.07337787f, 0.28078890f, 
    -0.03886338f, 0.10008036f, -0.30596614f, -0.09585430f, 0.03078469f, 0.04339291f, 0.03751037f, 0.13165589f, 
    -0.03123377f, 0.13168909f, -0.08008201f, 0.17076278f, -0.36393180f, -0.09751765f, -0.23912376f, 0.00715250f, 
    -0.12214992f, 0.06398963f, -0.32881969f, -0.23640583f, 0.07267217f, -0.26124865f, 0.06204526f, 0.01527045f, 
    -0.17310518f, 0.07795697f, 0.17837743f, 0.02939125f, 0.12856546f, 0.07492145f, 0.02042060f, 0.06839542f, 
    -0.12244043f, -0.09309766f, 0.06676055f, 0.03482628f, 0.07627972f, 0.28247079f, 0.18502897f, 0.40666676f, 
    0.02607089f, 0.05476938f, -0.00507628f, 0.05542669f, -0.14881392f, -0.04897866f, -0.08584280f, 0.00068173f, 
    0.00470575f, -0.09867264f, -0.07314122f, -0.11836346f, 0.12797317f, -0.06685311f, 0.06060967f, 0.17860660f, 
    0.27906612f, -0.03372731f, -0.06060554f, -0.09316823f, 0.01543176f, 0.20274517f, 0.19796692f, 0.23605272f, 
    -0.04744825f, 0.11142823f, 0.20438451f, 0.03717051f, 0.07982425f, -0.10001605f, 0.02221913f, 0.23518518f, 
    -0.53864777f, -0.14548288f, -0.15825237f, -0.06491364f, 0.13173491f, 0.14044771f, -0.07790475f, -0.05638561f, 
    0.17543752f, 0.06547107f, 0.13803615f, 0.09190109f, 0.04676833f, -0.18195961f, 0.13983457f, 0.03849470f, 
    0.02572355f, 0.00921150f, 0.13242260f, 0.08729975f, -0.04797275f, -0.01143899f, 0.02598988f, 0.14326355f, 
    0.01037150f, -0.02248174f, -0.07188565f, 0.03071568f, 0.03101016f, 0.03305623f, -0.04418039f, 0.06036958f, 
    0.04102908f, 0.02896145f, 0.01434628f, 0.03489576f, -0.05344506f, -0.03555997f, -0.04015560f, -0.07819999f, 
    -0.03886904f, -0.00650896f, 0.00751364f, -0.00644992f, -0.07130320f, 0.05470369f, -0.02916332f, -0.02114857f, 
    -0.04571008f, 0.00881933f, -0.05610171f, 0.02331171f, -0.07459973f, -0.05597372f, 0.02686123f, 0.00910767f, 
    -0.01898352f, -0.02233238f, -0.05907873f, 0.01188195f, -0.03761669f, 0.03195483f, 0.01001417f, 0.02381842f, 
    0.00304079f, 0.01057843f, -0.04793203f, -0.05417388f, 0.02081753f, 0.01947391f, -0.07773105f, 0.05688074f, 
    0.05823057f, 0.06618690f, 0.02915970f, -0.03754300f, 0.05606228f, 0.04251375f, -0.05233795f, 0.00493785f, 
    0.01434365f, -0.02235323f, -0.03453621f, 0.02896812f, 0.02206851f, -0.07826918f, -0.04656983f, -0.06323992f, 
    0.06042488f, -0.03834068f, -0.01363043f, -0.04709908f, 0.01403988f, 0.01971366f, 0.04662388f, -0.02545092f, 
    0.03239170f, 0.05381735f, 0.06175045f, -0.06968562f, 0.05229980f, -0.07149763f, 0.06472379f, -0.06014096f, 
    -0.01705968f, -0.02093463f, -0.01839571f, -0.00837466f, 0.04150941f, 0.00150199f, -0.04501273f, 0.00856810f, 
    -0.00739916f, -0.07837096f, -0.02663558f, 0.02190096f, -0.06566564f, -0.05862025f, -0.06855038f, 0.04171370f, 
    -0.01317355f, -0.00688958f, 0.01436719f, -0.06543423f, 0.04008098f, -0.02724703f, 0.06623401f, -0.02475844f, 
    0.05088013f, -0.02454842f, -0.02241945f, -0.06128334f, -0.05010800f, -0.01566674f, 0.02931842f, 0.01899203f, 
    0.02772024f, -0.03336777f, 0.03088023f, -0.01367335f, -0.02339479f, -0.03439860f, 0.03549505f, 0.00115255f, 
    -0.06770848f, 0.00265370f, 0.03897644f, 0.04444894f, 0.01574018f, -0.03665343f, -0.00152791f, -0.00526780f, 
    0.02874831f, -0.00609326f, -0.07790613f, 0.05727210f, -0.00622355f, -0.01616045f, -0.01989905f, 0.00025732f, 
    -0.00534294f, -0.01480091f, -0.03029344f, 0.01788747f, -0.01629279f, -0.01522588f, -0.05048382f, -0.03910397f, 
    -0.00686317f, -0.04236219f, -0.04576819f, 0.03302345f, -0.04012300f, -0.06210732f, 0.02190975f, 0.04276126f, 
    -0.06701981f, -0.01275323f, 0.04485805f, -0.07538902f, -0.00454350f, 0.00630885f, -0.06488241f, -0.06266900f, 
    0.05483912f, -0.02218066f, 0.02156585f, 0.01674326f, -0.05462242f, -0.04334095f, 0.01823291f, 0.01448142f, 
    -0.01903926f, -0.03275057f, 0.01666409f, -0.04926439f, -0.02664634f, -0.04757775f, 0.01257379f, -0.07060614f, 
    0.00316990f, -0.04060277f, 0.00089887f, -0.04684325f, 0.06556185f, -0.05357971f, -0.02471959f, -0.07094318f, 
    -0.07349899f, -0.02354295f, 0.04985152f, 0.06352656f, 0.06196406f, -0.03280064f, 0.00066710f, 0.03955325f, 
    -0.06561255f, 0.17078860f, -0.19065896f, 0.11846146f, -0.38331905f, 0.01023466f, 0.12423461f, 0.01674958f, 
    -0.10301322f, 0.21981777f, 0.00669658f, 0.04017876f, 0.12838520f, -0.25891080f, -0.34298611f, -0.37632018f, 
    0.02093784f, -0.28749534f, 0.00312181f, -0.01824064f, 0.06844734f, -0.17114672f, 0.00778991f, -0.36802760f, 
    0.29122874f, 0.34301490f, 0.17640287f, 0.09879052f, 0.05742003f, 0.22883466f, 0.22595905f, 0.12559304f, 
    -0.09952468f, 0.02921502f, -0.07324739f, 0.07198463f, 0.02584834f, -0.06205771f, -0.07223832f, 0.14077190f, 
    -0.26970163f, -0.07610299f, -0.08824632f, 0.09314597f, -0.31303743f, -0.01161250f, 0.00559685f, 0.13497569f, 
    -0.30710977f, 0.13805602f, 0.10058729f, -0.19882362f, 0.20892619f, -0.04953767f, -0.05846079f, -0.15990967f, 
    -0.21356961f, 0.08197010f, 0.02697045f, -0.18468244f, 0.28454605f, -0.15622769f, 0.48201984f, -0.19689760f, 
    0.04933082f, 0.19483128f, 0.11220884f, -0.00741066f, -0.06562269f, 0.07951593f, 0.07623167f, 0.03627059f, 
    -0.39204434f, 0.02710122f, 0.11248790f, 0.00990831f, -0.12103661f, 0.08168231f, 0.13916279f, 0.02149510f, 
    -0.11098588f, 0.15353119f, 0.14265461f, 0.24130493f, 0.06586460f, -0.06233532f, 0.06887548f, -0.33653647f, 
    -0.12565742f, -0.11000580f, 0.21769080f, -0.19480900f, -0.30777171f, -0.03253398f, -0.07253118f, -0.10347578f, 
    -0.24652562f, -0.01581550f, 0.29320922f, 0.05502684f, -0.05285066f, -0.16465174f, -0.13276953f, -0.14747524f, 
    0.10103303f, -0.04302546f, -0.10463129f, -0.15903409f, -0.40686423f, 0.01441277f, 0.02536604f, 0.13157499f, 
    -0.16128913f, -0.13352743f, 0.35584760f, 0.07492388f, 0.00374356f, 0.12376057f, -0.17385080f, 0.18892278f, 
    0.44989720f, 0.17821704f, 0.04339803f, 0.15417844f, 0.12952107f, 0.06815619f, -0.18682612f, 0.03657239f, 
    0.10719801f, -0.04072977f, 0.07409254f, -0.12060998f, 0.31042498f, -0.32858992f, -0.27442214f, -0.14117590f, 
    -0.02660161f, 0.03858226f, 0.08860782f, 0.09757771f, 0.21020080f, 0.06056225f, -0.05098211f, 0.03520402f, 
    -0.00517439f, 0.10157047f, -0.10320774f, 0.11004482f, -0.26489711f, 0.15969443f, 0.13409305f, 0.00667568f, 
    0.01049093f, 0.25070813f, 0.26252288f, 0.19529645f, 0.09490968f, 0.03290428f, -0.01338891f, 0.14894329f, 
    0.24205874f, -0.00326529f, -0.01331120f, 0.01456137f, 0.07844285f, 0.05728588f, -0.28950340f, -0.30623713f, 
    0.09143875f, -0.11977736f, 0.18798895f, -0.00046284f, -0.23335071f, -0.22479139f, -0.10959028f, -0.34286454f, 
    -0.07135428f, 0.04131710f, 0.12798946f, 0.05842536f, -0.00345572f, 0.32165149f, 0.13462470f, 0.04647708f, 
    0.02133251f, 0.11307477f, -0.01890564f, 0.17429639f, -0.03757477f, 0.08046944f, -0.03830585f, -0.27073306f, 
    -0.15425667f, 0.04088773f, 0.27853766f, 0.35045978f, 0.08516261f, -0.03909056f, -0.06978703f, 0.12988268f, 
    0.14681068f, 0.14241943f, -0.03445216f, -0.04159419f, 0.22831702f, -0.14304644f, 0.28649235f, 0.19784383f, 
    -0.18886170f, 0.16685916f, 0.19555697f, 0.11921215f, 0.18783854f, -0.15980363f, -0.10465511f, -0.16963464f, 
    0.12972514f, -0.28405228f, -0.32026961f, -0.50304699f, 0.02349945f, 0.22520328f, -0.16927446f, -0.23354332f, 
    0.27874988f, 0.09174769f, -0.04650528f, -0.13574982f, 0.29940751f, 0.60803849f, 0.02904928f, -0.15800530f, 
    0.33736619f, -0.00258465f, 0.11129724f, 0.07252907f, 0.17063819f, 0.25103948f, 0.05527069f, 0.13617624f, 
    -0.08572682f, 0.00236022f, 0.05571958f, -0.03107287f, -0.15956005f, -0.05161609f, -0.07155417f, 0.09826254f, 
    -0.04072104f, 0.16276048f, 0.18326649f, -0.03465018f, -0.32128656f, 0.08567033f, -0.42150548f, -0.05425655f, 
    -0.26750883f, -0.00661501f, -0.22130468f, -0.04025709f, -0.12774639f, -0.03348664f, -0.07349693f, -0.04504424f, 
    0.25456768f, 0.23459318f, -0.13283239f, 0.05369731f, 0.12672891f, 0.22316988f, 0.36042538f, 0.30090362f, 
    0.14543058f, 0.01179414f, -0.05928967f, 0.03894553f, -0.24523172f, -0.09770530f, 0.17585206f, 0.27444959f, 
    0.11159398f, 0.07015778f, 0.02553572f, -0.02206795f, -0.04494559f, -0.03121344f, 0.10512464f, 0.31275004f, 
    0.24340372f, 0.13891284f, 0.24989127f, 0.02265287f, -0.04336142f, -0.00901924f, 0.03955818f, 0.13236873f, 
    -0.05289682f, 0.07347126f, 0.12098949f, 0.24062736f, -0.14273860f, 0.23241463f, -0.02176389f, 0.00187121f, 
    0.08821930f, 0.03631424f, 0.08483411f, -0.09131337f, 0.06371678f, 0.16986784f, 0.06632552f, 0.15488666f, 
    -0.27646294f, -0.38301033f, 0.12656754f, -0.40194100f, 0.21508905f, -0.06964084f, -0.29678851f, 0.10492862f, 
    -0.10832571f, 0.01676103f, 0.02586045f, -0.17962487f, 0.18505733f, 0.22554830f, -0.35509855f, 0.05753338f, 
    0.19298500f, 0.21784414f, 0.02605217f, -0.11479852f, 0.07405197f, -0.10672808f, -0.00226008f, -0.16539769f, 
    -0.09062514f, 0.00391887f, 0.15025485f, 0.14783591f, -0.14892614f, -0.15589410f, -0.04149016f, -0.24797258f, 
    0.05762453f, 0.11374591f, 0.09848316f, 0.28019595f, -0.58183354f, 0.01082923f, -0.08671737f, -0.26513952f, 
    0.06127357f, 0.07704345f, 0.11233609f, 0.03563647f, 0.05591251f, 0.06354428f, 0.06982585f, -0.25751102f, 
    -0.08802677f, 0.10904107f, 0.03422287f, 0.04192778f, 0.00414411f, -0.01279785f, -0.16730347f, -0.07753390f, 
    -0.08546123f, 0.11606576f, 0.02670768f, -0.11297277f, -0.33475041f, -0.28291619f, -0.11656185f, -0.17652836f, 
    -0.15781359f, -0.15515742f, -0.02235908f, 0.05621454f, -0.08164722f, -0.14355125f, 0.08541514f, 0.06691188f, 
    -0.03511966f, 0.02865894f, -0.04181451f, -0.06946910f, 0.05043866f, -0.00436109f, 0.02446248f, 0.06280445f, 
    -0.00294400f, 0.02098523f, -0.00720784f, 0.05034687f, 0.05720092f, -0.05718816f, 0.03579171f, 0.06595173f, 
    0.03981914f, 0.03809704f, -0.07112265f, 0.01095633f, -0.01797485f, -0.01238939f, -0.01589942f, 0.05306394f, 
    -0.02279691f, -0.02357115f, -0.05186512f, 0.05633905f, -0.00253945f, -0.05984568f, -0.06815962f, -0.01518255f, 
    0.01875587f, -0.06769697f, 0.00196179f, -0.03600617f, -0.02966010f, -0.07513455f, 0.02289886f, -0.06906806f, 
    -0.06517828f, 0.00336159f, -0.05549040f, -0.01411938f, 0.05574454f, -0.04038419f, -0.04873472f, 0.04883098f, 
    -0.05001900f, 0.00358745f, 0.04676971f, -0.02425082f, -0.00074194f, -0.02377454f, 0.05860920f, -0.04741523f, 
    -0.06861375f, -0.03319608f, 0.02599284f, -0.00493856f, 0.02260377f, -0.04628390f, -0.02411986f, -0.06067574f, 
    0.05243807f, -0.02948917f, -0.02641854f, 0.05625676f, -0.06085076f, 0.00292493f, 0.00930520f, -0.07580896f, 
    -0.00184620f, -0.01312379f, 0.05879081f, -0.07799090f, -0.03804175f, 0.01593316f, -0.01017937f, 0.01286444f, 
    -0.01752852f, 0.03402004f, -0.02602451f, -0.04070596f, 0.02502108f, -0.07417706f, -0.06610231f, 0.01971202f, 
    0.04775137f, -0.00621330f, 0.01683869f, -0.06461957f, -0.06994607f, 0.04456364f, 0.01237200f, -0.03829816f, 
    -0.05206813f, -0.01871255f, 0.03210142f, 0.05882453f, -0.00521953f, -0.07735881f, -0.07345083f, -0.05669017f, 
    0.00615772f, 0.06064285f, 0.01612356f, -0.05550340f, -0.07382927f, 0.03242723f, 0.02338566f, -0.07199746f, 
    -0.03618060f, -0.06820819f, 0.02859685f, 0.05382808f, -0.03965730f, 0.03521906f, -0.06230771f, 0.04601223f, 
    0.03017203f, 0.02904782f, 0.00410931f, 0.05252637f, -0.03055855f, -0.04988058f, -0.05694091f, 0.02574039f, 
    -0.01161226f, -0.03422070f, -0.01641713f, 0.05656855f, 0.00921879f, -0.05474720f, -0.00124522f, -0.03842885f, 
    0.02929904f, 0.04163526f, -0.00297649f, 0.03427411f, 0.03119507f, 0.02825481f, -0.00012992f, 0.03958278f, 
    0.03767461f, -0.03235662f, -0.04243907f, 0.00060726f, 0.01197214f, -0.03904988f, 0.03899284f, -0.02611136f, 
    0.01488711f, -0.05258306f, -0.08043539f, 0.02461073f, 0.02005426f, 0.00775227f, 0.02882472f, 0.06089776f, 
    0.02507714f, -0.06642236f, 0.01457481f, 0.02702751f, -0.03111970f, 0.05719750f, -0.02759266f, -0.05908668f, 
    0.06488913f, -0.06615945f, -0.06427705f, -0.04549798f, 0.01068124f, -0.07354913f, 0.03449898f, 0.02946735f, 
    0.01654426f, 0.05790620f, -0.01172900f, 0.01626269f, -0.04396551f, -0.02820698f, -0.06988379f, -0.04972749f, 
    -0.06279942f, 0.00598605f, 0.04962275f, -0.00931365f, -0.05089407f, -0.00204739f, 0.05274035f, -0.04633658f, 
    0.17699130f, 0.28978753f, -0.37857991f, 0.00204023f, 0.06343564f, 0.03328684f, -0.05310929f, 0.00325874f, 
    -0.10298422f, -0.16407889f, 0.03652022f, 0.11367016f, 0.24317366f, 0.71257150f, -0.50771916f, -0.14589158f, 
    -0.06459419f, -0.02904087f, 0.13246433f, -0.07269473f, -0.07572541f, 0.05042112f, -0.02841624f, 0.09926865f, 
    -0.23468685f, -0.32173759f, 0.22839162f, -0.00543681f, 0.09432507f, 0.19487602f, 0.07547229f, -0.19852541f, 
    0.00231770f, 0.05059867f, 0.10170650f, -0.00137139f, -0.01949862f, -0.20960367f, -0.47567227f, 0.08464609f, 
    0.02697692f, 0.02501084f, 0.17242825f, 0.14064707f, -0.02669601f, -0.05694473f, -0.02375445f, -0.05872268f, 
    -0.06612456f, 0.26298657f, 0.23340133f, -0.01805470f, 0.04441342f, 0.11583464f, 0.09062497f, 0.02061539f, 
    0.18861558f, -0.11022649f, -0.09380654f, 0.15590344f, 0.55772871f, -0.02842757f, -0.10639463f, 0.31057122f, 
    0.11207112f, 0.06462069f, -0.20483285f, -0.21682164f, -0.11844899f, 0.08106149f, -0.05905736f, 0.22226740f, 
    0.25552565f, -0.30162343f, -0.20716040f, 0.04693847f, 0.04350794f, -0.00077282f, -0.06019047f, 0.04292212f, 
    0.03281758f, 0.12753996f, -0.05294086f, 0.00556616f, -0.06170743f, -0.03122970f, 0.31512094f, -0.30930007f, 
    -0.06365559f, -0.29000375f, -0.05155031f, -0.18111713f, -0.08481527f, 0.04721498f, -0.07199982f, 0.09618384f, 
    0.02384335f, 0.33359951f, -0.13189937f, -0.07434053f, -0.16051444f, -0.18627033f, 0.06289706f, 0.05053377f, 
    -0.07870528f, 0.13470910f, 0.02061822f, -0.04310698f, -0.22095272f, 0.05122549f, 0.16073591f, -0.60922569f, 
    -0.23091073f, -0.20096877f, -0.04543757f, -0.11932401f, 0.00883440f, 0.02445791f, 0.10258173f, -0.07143078f, 
    0.05015603f, -0.09807646f, 0.06143207f, -0.06719589f, 0.08376893f, 0.06109551f, 0.01818842f, 0.08871061f, 
    -0.00792469f, -0.07911132f, -0.01282517f, 0.01830001f, -0.42579913f, -0.07451377f, 0.00626366f, 0.39138684f, 
    0.19028679f, 0.16152371f, 0.01219460f, 0.04361062f, -0.15566888f, 0.14456464f, 0.09568639f, 0.16684712f, 
    0.23320483f, -0.10343955f, -0.27343929f, 0.03120711f, 0.07168747f, -0.14381361f, 0.12899452f, -0.11306749f, 
    -0.00470972f, 0.24903877f, 0.05164836f, 0.12623289f, 0.39188951f, -0.11737242f, -0.03513217f, -0.15930164f, 
    0.16040729f, -0.03639871f, -0.01814044f, -0.11898848f, -0.06517727f, -0.03793189f, -0.12933744f, -0.18062571f, 
    -0.39372721f, -0.20724414f, -0.03157312f, 0.06218622f, -0.06702745f, 0.10048895f, -0.15367851f, -0.17543879f, 
    0.12704465f, -0.05384120f, -0.02776472f, -0.05128512f, 0.49311486f, -0.14091522f, 0.19655475f, 0.27830324f, 
    0.10253704f, 0.23245761f, 0.03679819f, 0.08920090f, -0.01037311f, 0.01012872f, 0.05428359f, 0.13227116f, 
    0.25448367f, -0.24064942f, 0.01107484f, -0.42576033f, -0.02529646f, 0.10594710f, 0.10470786f, 0.01536435f, 
    0.05829995f, -0.09950467f, 0.10217132f, 0.11856367f, 0.05037899f, 0.33993736f, -0.32257032f, -0.26681748f, 
    -0.15353128f, -0.14369348f, 0.02226507f, -0.20801254f, -0.12442289f, -0.13459133f, -0.09853680f, -0.14527652f, 
    -0.23162298f, 0.35176134f, -0.02679950f, 0.40970489f, -0.08296409f, 0.14827840f, 0.17362244f, 0.15878703f, 
    0.02730619f, 0.16142721f, -0.07011443f, 0.12133940f, -0.27780303f, -0.33110437f, -0.15270592f, 0.16152561f, 
    -0.21447325f, 0.05944088f, 0.07678360f, 0.01191541f, -0.04415878f, 0.03600627f, 0.06499697f, 0.05557008f, 
    -0.01274720f, 0.13653225f, -0.00157236f, 0.07710637f, 0.14435957f, -0.27700719f, 0.01041337f, -0.01200145f, 
    0.03923230f, 0.02929461f, -0.01482722f, -0.13232149f, 0.72838783f, -0.49168172f, 0.36270437f, 0.37194732f, 
    -0.08665232f, 0.12072627f, -0.00874580f, -0.08142920f, -0.04678762f, 0.12537721f, 0.02433677f, 0.11267891f, 
    -0.21721415f, -0.22735366f, 0.00570913f, 0.23691678f, 0.04637635f, 0.03123606f, 0.00399705f, 0.10598774f, 
    -0.02197483f, -0.01669663f, 0.01998342f, 0.13657121f, -0.03550446f, 0.34670919f, 0.16990967f, -0.12990530f, 
    -0.05633882f, -0.16350313f, 0.14992607f, -0.03308529f, -0.01667327f, 0.06872829f, 0.02422534f, 0.01497627f, 
    -0.14918967f, 0.11265439f, 0.05945455f, 0.00619274f, 0.09522876f, 0.00105683f, -0.03303196f, 0.00048257f, 
    0.23827763f, -0.07286749f, -0.14872180f, -0.01274983f, -0.02199292f, 0.24409600f, 0.17490138f, 0.18918720f, 
    -0.07155557f, 0.05074968f, 0.12738520f, -0.04225358f, 0.03195248f, 0.20460342f, -0.00828255f, 0.23758431f, 
    0.07873490f, 0.16440462f, -0.04867596f, 0.35167220f, 0.13979615f, -0.10371298f, 0.07000361f, -0.07971416f, 
    -0.11730027f, -0.12533015f, -0.00844430f, -0.03721340f, -0.24459976f, -0.50572360f, -0.26196867f, 0.20910475f, 
    0.01429333f, 0.21525653f, 0.09031837f, -0.01667954f, 0.12840137f, -0.01907141f, -0.07003355f, 0.07364170f, 
    0.28337595f, -0.01344439f, -0.18785031f, 0.11192958f, -0.01300629f, 0.17147751f, 0.03870451f, 0.04655178f, 
    0.18079343f, 0.16179945f, 0.21408841f, 0.25363126f, 0.31688386f, 0.01369436f, -0.00245056f, -0.22842781f, 
    0.14270507f, -0.09278466f, 0.10224586f, -0.12997486f, -0.09564420f, 0.04946247f, -0.04181585f, -0.02340135f, 
    -0.23015384f, -0.06027649f, 0.28163472f, 0.03267086f, 0.07254636f, -0.07050207f, 0.08453251f, 0.00909764f, 
    -0.09601256f, -0.15775038f, -0.05758120f, 0.05570788f, 0.19114678f, 0.15280853f, 0.06123746f, 0.13666192f, 
    0.03549470f, -0.10154981f, 0.07472148f, -0.13305663f, -0.13871132f, 0.24439809f, 0.02656694f, 0.04653927f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.06139202f, 0.26910803f, -0.16162500f, 0.05967943f, 0.08207526f, 0.10241511f, 0.01954449f, 0.04557278f, 
    -0.05924315f, 0.24337052f, -0.06172651f, -0.00252911f, -0.04409878f, -0.03530794f, 0.01602388f, 0.09513995f, 
    0.08408719f, 0.18365936f, 0.00101167f, 0.20125003f, 0.16617204f, 0.22840405f, -0.12982933f, 0.07703276f, 
    0.24929197f, -0.04463539f, 0.00342083f, 0.10704085f, 0.10554449f, -0.05026171f, -0.14362584f, 0.05719737f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.04868248f, 0.28991270f, -0.47734421f, 0.02108746f, 0.00459183f, 0.30509144f, -0.11900315f, -0.04639002f, 
    -0.02502931f, 0.13851564f, 0.17912100f, -0.07068686f, -0.27326933f, -0.12023520f, -0.32399368f, 0.33331645f, 
    -0.21493581f, 0.32631645f, -0.01071636f, -0.16267398f, 0.29312259f, 0.29742363f, -0.23154263f, -0.04912058f, 
    0.32412300f, -0.05704593f, -0.16372575f, 0.03188812f, -0.51182669f, -0.02533580f, -0.07936373f, 0.22135271f, 
    -0.12824680f, 0.16950132f, 0.04802336f, 0.21083359f, 0.13273884f, 0.16467501f, -0.47891977f, -0.13656706f, 
    0.34477398f, 0.07765745f, 0.04804680f, 0.05535198f, -0.18273304f, 0.17137568f, -0.13097784f, 0.03532917f, 
    -0.40965354f, 0.31355792f, 0.07200829f, 0.13908745f, 0.00396946f, 0.20083195f, 0.29050335f, 0.04114718f, 
    0.22401932f, -0.12641698f, -0.06795949f, -0.10070997f, -0.49498755f, -0.05034625f, 0.69924796f, 0.21293613f, 
    0.12912497f, -0.42502484f, 0.16225506f, -0.27786079f, -0.01026415f, -0.45095167f, 0.14025830f, -0.15542175f, 
    0.02719785f, -0.29402041f, -0.00448617f, -0.01702271f, -0.16837601f, 0.02330938f, 0.29554823f, 0.18701358f, 
    -0.28812206f, -0.00820330f, -0.01601163f, -0.15485373f, 0.34341478f, 0.12550601f, 0.17985691f, 0.08507649f, 
    0.10115051f, 0.31135502f, 0.08236624f, 0.06671461f, -0.20498475f, 0.04878034f, 0.33354104f, -0.24494763f, 
    0.02336970f, -0.17016913f, -0.10795223f, 0.25071040f, 0.21227325f, -0.22634162f, 0.17546558f, -0.05110160f, 
    -0.19564934f, 0.29123574f, 0.06109595f, -0.04257833f, -0.03384737f, 0.06169620f, -0.24568470f, 0.04352929f, 
    0.30310106f, 0.27830508f, -0.02076944f, 0.05411931f, 0.12148672f, -0.19897813f, -0.16902663f, 0.47098002f, 
    0.21740331f, -0.29843503f, 0.00974227f, -0.74701530f, -0.10732248f, 0.16623437f, -0.35064718f, -0.35418233f, 
    -0.07539397f, -0.07692321f, 0.12079743f, -0.01774091f, 0.00734854f, 0.09450638f, 0.16943932f, 0.00163258f, 
    -0.15808491f, -0.00934947f, 0.13624740f, 0.03746374f, -0.04855603f, 0.00322714f, -0.35165700f, -0.32402325f, 
    -0.29570135f, 0.05623812f, -0.15693092f, 0.21863939f, -0.05451356f, -0.13236947f, 0.33566293f, -0.30965573f, 
    0.28293067f, 0.25383353f, 0.05188736f, 0.03997151f, 0.13895629f, 0.13888957f, 0.02736707f, -0.26754719f, 
    0.07200579f, 0.33403081f, -0.24260625f, -0.38843834f, 0.23417211f, 0.15457143f, 0.16905354f, -0.06653389f, 
    -0.00500589f, -0.05273212f, 0.06281191f, -0.04865361f, -0.20401545f, -0.01760107f, 0.16109204f, 0.30260962f, 
    -0.39128754f, 0.12010716f, 0.06399055f, -0.04105883f, 0.19615903f, 0.16186273f, 0.08108912f, 0.26546881f, 
    0.27515945f, -0.11006955f, -0.17887111f, 0.14521529f, -0.21074264f, -0.10340967f, -0.24384226f, -0.31089914f, 
    -0.02055308f, -0.10581671f, 0.02492345f, -0.09998636f, 0.03335693f, 0.19172269f, -0.06452733f, -0.03868262f, 
    -0.33021337f, -0.07677246f, -0.05565644f, 0.16840841f, -0.05087636f, 0.08606625f, -0.10150576f, 0.35613936f, 
    0.24678387f, 0.25988537f, 0.14261778f, -0.07752094f, -0.07788644f, 0.07419918f, -0.02065285f, 0.42252007f, 
    -0.22842120f, 0.39862379f, -0.09565237f, -0.37477538f, 0.13484429f, -0.13838413f, 0.04690111f, 0.05522490f, 
    -0.05232110f, 0.19966795f, -0.44778198f, -0.17385164f, -0.27676460f, -0.02845399f, 0.00688840f, -0.08385236f, 
    0.24304371f, -0.00620667f, 0.03769100f, 0.05928380f, 0.22724834f, -0.10773951f, -0.41790861f, -0.06084090f, 
    -0.02426358f, 0.20298967f, -0.07638659f, -0.07692648f, 0.10651229f, -0.18666649f, 0.33387923f, 0.04848792f, 
    0.26867446f, -0.13834733f, -0.16618396f, 0.36673006f, 0.06769789f, -0.10662575f, 0.25769171f, 0.18820173f, 
    -0.11762275f, 0.42958999f, -0.30724451f, 0.13176802f, 0.15055878f, 0.09615801f, -0.13324760f, -0.00528208f, 
    -0.60361290f, 0.28540778f, 0.15720308f, -0.02466557f, 0.21605304f, -0.08033693f, 0.26007620f, -0.16986580f, 
    0.16773422f, 0.10488231f, 0.17374060f, 0.20625852f, 0.29249048f, 0.51262969f, 0.16399369f, 0.28930435f, 
    0.12009753f, -0.22171879f, 0.00954272f, 0.30935526f, 0.06567860f, -0.12958345f, 0.06175415f, -0.24115412f, 
    -0.02281302f, 0.27502346f, 0.81151146f, 0.15074037f, -0.05154304f, -0.08145590f, 0.00679261f, -0.13501476f, 
    -0.21994458f, -0.08503659f, -0.03402719f, 0.16995670f, 0.06932408f, -0.09148079f, -0.07710440f, 0.21678622f, 
    -0.12860861f, 0.08685727f, -0.12241280f, -0.12176152f, 0.28108403f, 0.03220109f, 0.27451143f, 0.11922617f, 
    -0.12833706f, 0.26545379f, -0.05542354f, -0.38219804f, -0.11517940f, -0.10950565f, -0.08539581f, -0.45754278f, 
    -0.05314855f, 0.53109878f, -0.31562528f, 0.11652026f, -0.22430430f, 0.21091044f, 0.18712819f, -0.11667971f, 
    -0.27960092f, 0.05334630f, -0.09845340f, 0.16686954f, 0.00998625f, -0.12606496f, -0.42217132f, -0.03147244f, 
    0.21578240f, 0.20954219f, -0.06181632f, 0.24480200f, -0.09112566f, 0.30211830f, 0.00316856f, 0.27548590f, 
    -0.13876535f, -0.00353951f, -0.13049996f, 0.25177637f, -0.22214018f, -0.08910266f, 0.05841841f, -0.17721985f, 
    -0.09769256f, 0.00239567f, -0.05918165f, 0.14700779f, -0.09253889f, 0.08388382f, 0.05835380f, -0.02752088f, 
    0.00847752f, 0.17418611f, 0.06052753f, 0.07415944f, -0.27471733f, -0.08519948f, -0.08538140f, 0.32677099f, 
    -0.14396024f, -0.04395873f, -0.15868340f, 0.27381000f, 0.20086595f, 0.26860395f, -0.37763983f, -0.11808901f, 
    -0.14662234f, 0.20708732f, -0.01911126f, -0.19080082f, -0.10265750f, 0.17228986f, 0.00659081f, 0.18800698f, 
    -0.00716553f, -0.03356335f, 0.12070131f, -0.07048322f, -0.06630342f, 0.14876319f, -0.09269246f, -0.00148281f, 
    -0.14593419f, -0.08009868f, 0.05460152f, 0.02599854f, -0.08248463f, 0.04604025f, 0.05497506f, -0.12766536f, 
    -0.04176835f, 0.00156330f, -0.05022772f, 0.02649463f, -0.15008897f, -0.08270860f, 0.08999517f, -0.04717578f, 
    -0.02908657f, 0.14850257f, -0.03209820f, -0.10640381f, -0.17472899f, 0.01793557f, -0.07706100f, 0.04240550f, 
    0.16308159f, 0.10308876f, -0.36005402f, -0.37941125f, 0.12634054f, -0.02126040f, -0.06150793f, 0.12222517f, 
    0.69441497f, 0.28500661f, 0.10322461f, -0.13811548f, -0.23358975f, -0.13113816f, -0.02866039f, -0.08846191f, 
    -0.27407670f, 0.25711784f, 0.16394520f, -0.05050517f, 0.20409037f, 0.09506583f, 0.05600256f, 0.10769860f, 
    0.50614637f, -0.15930769f, -0.10661330f, 0.35112709f, -0.45983106f, 0.11394178f, -0.29915845f, 0.13469535f, 
    0.15136307f, -0.08473109f, -0.10909621f, -0.02512926f, 0.04487120f, -0.21053565f, -0.12191266f, -0.14025199f, 
    0.69132435f, 0.33498421f, -0.14945474f, 0.12650171f, -0.08964497f, -0.05405525f, -0.09941270f, 0.23213530f, 
    -0.07811671f, 0.03413741f, 0.05739039f, 0.43875784f, -0.17647596f, -0.02424052f, -0.28254181f, -0.29324803f, 
    -0.10179796f, 0.15295306f, -0.15372804f, 0.33511361f, 0.03309904f, 0.12267794f, 0.08115683f, 0.24606904f, 
    -0.11024837f, -0.04522730f, -0.14277275f, -0.04591764f, 0.02301026f, -0.15057181f, -0.04305115f, 0.06085807f, 
    0.10145760f, -0.01015575f, -0.15026629f, -0.10908987f, 0.06321180f, 0.10276803f, 0.00320686f, -0.16490707f, 
    -0.02332880f, 0.03912705f, -0.07887650f, -0.06984255f, 0.00306439f, -0.15462090f, -0.10196079f, -0.00610299f, 
    0.04433642f, 0.00774634f, -0.02694151f, -0.07651243f, -0.10508563f, -0.06247393f, 0.12230651f, -0.20459083f, 
    -0.14907511f, 0.40352389f, -0.00004797f, -0.62784714f, -0.29183829f, -0.12925100f, -0.34589753f, -0.15555096f, 
    -0.20914087f, -0.46612808f, 0.05796013f, 0.06890418f, 0.45395717f, 0.08916743f, 0.20715019f, -0.07591289f, 
    0.31834719f, 0.14772119f, 0.02415746f, -0.99245864f, 0.09057607f, -0.04445690f, 0.12423018f, 0.18158472f, 
    0.13243736f, 0.10866517f, -0.15612319f, 0.50137925f, -0.62305629f, -0.03378372f, -0.19016659f, -0.05350290f, 
    -0.12220255f, -0.09518114f, -0.01124391f, -0.05454673f, 0.33251303f, -0.02630037f, -0.02518643f, -0.17348844f, 
    -0.39684021f, 0.23404215f, 0.02953713f, 0.06799054f, -0.08654092f, -0.05448854f, 0.57840312f, -0.15496716f, 
    -0.20897813f, -0.30703175f, 0.15686740f, -0.00616327f, 0.17104959f, 0.33787835f, 0.49074319f, 0.13212009f, 
    0.33621708f, 0.30659276f, -0.13136402f, -0.02344522f, 0.10939734f, -0.13006669f, 0.05396424f, -0.17763908f, 
    -0.07570230f, -0.05502197f, 0.00351344f, -0.14413664f, -0.02289038f, -0.31521204f, 0.02621409f, -0.00993925f, 
    0.13870715f, 0.48309234f, 0.11678626f, -0.04319169f, 0.02315013f, 0.15048562f, 0.32034343f, 0.27417457f, 
    -0.03916627f, 0.01895811f, -0.06485767f, -0.16703485f, 0.01568365f, 0.09149358f, -0.45719695f, 0.05820840f, 
    -0.26893786f, 0.27624902f, -0.02381228f, -0.00564374f, 0.22148690f, 0.00272147f, -0.54925823f, -0.22281884f, 
    0.09464128f, -0.31821668f, 0.48990902f, 0.38738501f, -0.14801501f, -0.17792435f, -0.64467299f, 0.13783246f, 
    0.25125003f, 0.12791678f, 0.13404466f, 0.08516361f, -0.05963781f, 0.14679477f, -0.26173848f, 0.09091988f, 
    -0.44207633f, 0.27147335f, -0.12489156f, 0.30433479f, 0.08812136f, 0.24976915f, 0.06154824f, -0.45425597f, 
    -0.29689845f, 0.06751847f, -0.10443051f, -0.27255145f, -0.30260447f, 0.11811066f, 0.70746511f, 0.16347785f, 
    -0.16665137f, -0.08279411f, 0.20468247f, -0.26105654f, -0.05550260f, -0.12354286f, 0.20344661f, -0.08384830f, 
    0.13059725f, -0.33527893f, -0.15276970f, 0.08125731f, 0.19621632f, -0.16349588f, 0.05699901f, 0.04982683f, 
    -0.04846781f, -0.03795347f, -0.01222813f, -0.44008651f, 0.09245716f, -0.17840099f, 0.02472326f, 0.00782094f, 
    0.06617060f, -0.08416732f, -0.08357629f, 0.09218612f, 0.14035757f, -0.16486171f, -0.38714319f, -0.11024877f, 
    -0.08530939f, -0.30657527f, 0.22342038f, 0.31530938f, 0.25470454f, -0.49141058f, -0.38502026f, -0.11508535f, 
    0.10949195f, 0.02493291f, 0.11961512f, 0.06329028f, 0.18498686f, -0.07536379f, -0.00840194f, -0.09780894f, 
    0.04110103f, 0.10774396f, -0.13288900f, 0.00152792f, -0.13110007f, -0.24154584f, 0.52622443f, 0.18097192f, 
    0.37327185f, 0.14870274f, 0.08587532f, -0.20308502f, -0.13386178f, -0.06522702f, 0.28088865f, -0.63555962f, 
    0.04412121f, 0.24899572f, 0.06441722f, 0.02724024f, -0.28321120f, -0.42187911f, -0.11999037f, 0.17209679f, 
    -0.17015797f, -0.03307644f, 0.17022651f, -0.10238738f, 0.53645337f, -0.02505651f, 0.19182621f, 0.05745140f, 
    0.34734008f, 0.15450399f, 0.12806061f, -0.41522971f, -0.15065520f, 0.14734003f, -0.13117829f, 0.42066851f, 
    -0.00200045f, 0.33441886f, -0.01506533f, 0.36518183f, -0.19255783f, -0.05706310f, -0.38967574f, -0.22069129f, 
    0.05718058f, -0.20934068f, 0.68290341f, 0.26334387f, 0.05246621f, -0.20408247f, 0.39058685f, 0.14605568f, 
    0.03151250f, -0.29711637f, 0.10898054f, 0.08211017f, -0.02707189f, -0.17108776f, -0.18206227f, -0.02919227f, 
    0.14681308f, -0.08058472f, 0.10004882f, 0.04165697f, 0.33604556f, -0.28203034f, 0.00285813f, 0.06174382f, 
    0.19302280f, 0.01956246f, 0.13582028f, -0.11648921f, -0.20200248f, 0.05941837f, 0.16196609f, 0.14724793f, 
    -0.10035216f, 0.12016329f, 0.25086236f, -0.06464271f, 0.11073711f, -0.02337608f, 0.30852854f, -0.10745797f, 
    0.51551372f, -0.11570048f, 0.00430819f, -0.10156988f, 0.33026686f, -0.00122189f, -0.13480122f, -0.20295897f, 
    0.08408771f, 0.11566727f, -0.00328809f, 0.01014234f, -0.01257796f, -0.31617591f, 0.34563205f, -0.14839490f, 
    0.20977204f, -0.09217186f, 0.09633316f, 0.35683540f, -0.04169571f, -0.17313942f, 0.14179158f, 0.33477503f, 
    0.00635845f, 0.29951411f, -0.24227646f, -0.03922284f, -0.32993525f, -0.06087233f, -0.10097875f, -0.06268325f, 
    -0.01205427f, 0.22522040f, -0.05954741f, 0.10169792f, 0.34614545f, 0.04273153f, -0.22548056f, 0.03401512f, 
    0.25712210f, -0.09574733f, -0.13083026f, 0.21004039f, 0.24167122f, 0.41413537f, -0.05982878f, -0.33119997f, 
    -0.07700283f, -0.08748857f, -0.00383005f, 0.39281997f, -0.23609293f, 0.10545729f, 0.22436935f, 0.28684655f, 
    -0.15941592f, 0.01926556f, 0.14998798f, -0.26110429f, 0.08122654f, -0.28455478f, 0.13173826f, 0.12272029f, 
    0.56557822f, -0.04408415f, 0.07696129f, 0.11827123f, -0.25332335f, 0.03445569f, 0.17431025f, 0.42807537f, 
    0.27305922f, 0.11430462f, 0.10244729f, -0.28985509f, 0.18995447f, -0.16867262f, 0.12398599f, 0.21199323f, 
    -0.00265718f, 0.39387366f, -0.06143844f, -0.09351248f, -0.27004096f, -0.08668727f, -0.44745818f, -0.18499494f, 
    -0.09473342f, 0.45736405f, 0.26353219f, 0.30790937f, -0.00990050f, -0.11890122f, 0.25321436f, 0.02188610f, 
    -0.17047738f, -0.05128238f, 0.09343868f, -0.12371021f, -0.21233337f, -0.07130549f, -0.67821729f, 0.01086148f, 
    -0.18421003f, 0.42413101f, -0.08775898f, 0.22418143f, 0.11792197f, -0.11787307f, -0.26254570f, 0.36444354f, 
    0.18287425f, -0.42475143f, -0.14547533f, -0.53130162f, -0.38962662f, -0.04943516f, -0.23776488f, 0.00387864f, 
    -0.06602745f, -0.41218844f, -0.16302046f, 0.14695178f, -0.19889648f, -0.42746595f, 0.12995523f, 0.14726897f, 
    -0.00925634f, -0.04212851f, -0.01271999f, 0.13586265f, 0.18922980f, 0.17642681f, 0.15131135f, 0.08137769f, 
    0.40319693f, -0.02597679f, -0.14225060f, -0.38446370f, 0.12615027f, 0.07436998f, 0.25223312f, 0.01669576f, 
    0.16622873f, 0.37732834f, -0.11763126f, -0.23107702f, 0.13452308f, -0.07852509f, 0.18995935f, -0.10803179f, 
    0.14940812f, 0.05138458f, -0.06125191f, -0.06866775f, -0.09356251f, 0.02968065f, -0.12412050f, 0.14709634f, 
    -0.08995264f, -0.18935810f, 0.00873727f, -0.08775441f, -0.15822355f, 0.02442448f, -0.13366064f, -0.15958475f, 
    0.17461142f, -0.08243918f, 0.09350485f, -0.07640851f, -0.07771666f, -0.13325772f, -0.16431843f, 0.01500400f, 
    -0.07092600f, -0.18538208f, 0.07734248f, -0.08347140f, 0.06438839f, -0.01695831f, 0.01895228f, 0.06490523f, 
    0.13391593f, 0.14911975f, 0.04443103f, -0.06889252f, -0.11715059f, -0.05868625f, -0.02666954f, -0.10839569f, 
    0.00702122f, -0.07729184f, 0.01970909f, -0.03212121f, -0.07346579f, 0.15395232f, -0.17971720f, 0.07461679f, 
    -0.17529044f, 0.00878530f, 0.15867817f, 0.03439119f, -0.11084941f, -0.15508182f, 0.06530638f, 0.08901386f, 
    0.05300160f, -0.10580980f, 0.07742736f, 0.01719929f, -0.07485883f, -0.07393722f, 0.00287470f, -0.01583729f, 
    -0.16855022f, -0.12827025f, -0.02738275f, 0.05355490f, -0.36163434f, 0.01643180f, -0.11964271f, -0.16402870f, 
    0.07966676f, -0.10257126f, -0.01518421f, -0.12493980f, 0.51950479f, 0.14199971f, -0.26476759f, -0.02672710f, 
    0.21196018f, 0.10777029f, 0.12205238f, 0.02761915f, 0.21434222f, 0.32178232f, 0.18697463f, -0.14792056f, 
    -0.00752606f, 0.22829655f, -0.13569368f, 0.29321033f, 0.18647026f, 0.00460354f, 0.56004757f, 0.16562381f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.27066824f, 0.13390084f, 0.00741545f, 0.22843930f, 0.40471148f, 0.07154600f, 0.01106016f, 0.15700299f, 
    0.34387761f, 0.16547960f, 0.16157912f, 0.03912864f, -0.06235345f, 0.10331406f, 0.11783600f, -0.15417165f, 
    -0.14992170f, 0.13303767f, 0.14992119f, -0.25080207f, 0.17416489f, 0.07797152f, 0.05305690f, -0.27226740f, 
    -0.00488556f, 0.21319257f, 0.09199660f, 0.25364241f, -0.08906538f, -0.03943288f, -0.02802908f, 0.16727199f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.58005583f, -0.35303780f, -0.11506362f, -0.44429913f, -0.93044037f, -0.34861302f, 0.18993515f, 0.18868761f, 
    -0.16492277f, 0.17707390f, 0.12641554f, -0.67881018f, -0.02933354f, -0.56887126f, -0.12755993f, -0.01917809f, 
    0.31528062f, -0.00626712f, -0.30273190f, -0.35779643f, 0.03850180f, 0.36151740f, 0.24569042f, -0.07318787f, 
    0.24908273f, 0.02202478f, 0.05017283f, -0.48405135f, 0.01408316f, -0.07941307f, 0.10411384f, 0.19721673f, 
    -0.15952392f, -0.06398555f, 0.11647824f, 0.19350740f, 0.45255145f, 0.04024258f, -0.22597551f, 0.16822216f, 
    0.27497932f, -0.59428513f, 0.21096875f, -0.23485430f, 0.05987718f, 0.10665792f, -0.00782963f, -0.06141338f, 
    0.52167177f, 0.11728258f, -0.22540757f, -0.82416719f, -0.44741413f, -0.45160377f, 0.19874167f, -0.24907598f, 
    0.08697396f, 0.28813609f, -0.10357898f, 0.14560510f, -0.14389817f, -0.10929371f, -0.08538330f, 0.17135233f, 
    0.17390782f, 0.16408630f, 0.34245089f, -0.50111145f, -0.41611528f, 0.35809839f, -0.08487042f, 0.06796705f, 
    0.06647743f, 0.24040975f, -0.49336693f, -0.26584294f, 0.01047691f, 0.35585460f, -0.23027353f, 0.13818106f, 
    -0.87116450f, 0.29268092f, -0.23098464f, 0.00687641f, 0.03832134f, -0.21870504f, -0.82142228f, 0.09052163f, 
    -0.05473069f, 0.11834662f, 0.07562481f, -0.38790569f, -0.02838550f, -0.13032047f, 0.00793603f, -0.07228484f, 
    -0.12670724f, 0.22253774f, 0.23533966f, -0.53946966f, -1.17386222f, -0.29722771f, 0.10170235f, 0.06099318f, 
    -0.68216854f, -0.01932165f, -0.44599608f, 0.04957989f, 0.15052228f, -0.16554081f, 0.20714965f, -0.00800494f, 
    -0.33997187f, -0.14035246f, -0.18099977f, 0.61456567f, -0.23075165f, 0.05735727f, -0.20312376f, 0.03873890f, 
    -0.01316497f, -0.05038040f, 0.14733031f, -0.38036302f, 0.19430162f, -0.34804851f, 0.01019280f, 0.27350211f, 
    -0.30493033f, -0.36250776f, 0.30538583f, -0.05343064f, 0.16656362f, 0.19355677f, 0.12250011f, -0.19209154f, 
    -0.32361475f, 0.00158464f, -0.44754824f, 0.01577245f, -0.13952824f, -0.05848590f, 0.14812094f, -0.15224496f, 
    -0.04359471f, 0.08528950f, 0.33285344f, -0.51351959f, 0.23448309f, -0.09420140f, -0.04007740f, 0.35217571f, 
    0.06873426f, -0.28836563f, 0.30708328f, -0.12898853f, 0.00053468f, -0.18705112f, 0.02890765f, -0.04404371f, 
    -0.10503718f, -0.42989388f, -0.18442090f, -0.03074222f, -0.95611584f, -0.00673933f, 0.23383291f, -0.40098372f, 
    0.22977278f, 0.06367476f, 0.22976644f, 0.18149671f, 0.14299823f, -0.59350818f, 0.01236170f, 0.04453842f, 
    0.08898620f, 0.04862152f, 0.41014582f, -0.20815980f, -0.01680595f, -0.10195473f, 0.26939970f, -0.29740909f, 
    -0.54334307f, 0.12240081f, 0.05943421f, -0.52492720f, -0.02343713f, -0.14838928f, -0.05051276f, 0.05201786f, 
    0.15910909f, 0.33420894f, -0.46361205f, 0.07826315f, -0.25918508f, 0.34489819f, 0.22070423f, -0.23809730f, 
    0.25538376f, 0.03224124f, -0.02845991f, -0.02435750f, -0.14781614f, 0.23172787f, 0.05165762f, 0.04450582f, 
    -0.19451660f, 0.26425877f, -0.12728766f, -0.03640883f, -0.17632014f, 0.04870812f, -1.05435622f, -0.54477090f, 
    -0.30963150f, -0.92321646f, 0.06924734f, 0.15325664f, -0.86716694f, -0.08141313f, 0.10764567f, -0.98025960f, 
    -0.38456503f, 0.18825662f, -0.44483918f, -0.23849708f, -0.34609318f, -0.38311088f, -0.67630112f, -0.49256074f, 
    0.12035701f, 0.47409898f, -0.28194261f, -0.01574650f, 0.07031459f, -0.83711129f, 0.09455642f, 0.13171591f, 
    0.06447973f, 0.01078834f, 0.10925356f, 0.61942583f, -0.41041863f, 0.29268965f, 0.03196226f, 0.35455757f, 
    0.15217555f, -0.02028022f, -0.61640316f, 0.12778604f, -0.46011570f, -0.22644487f, 0.10700396f, -0.11685856f, 
    0.28461730f, 0.36542898f, -0.41904864f, -0.34680143f, -0.03543129f, -0.51058644f, 0.15882337f, 0.26580745f, 
    0.08562064f, -0.61241317f, 0.29793552f, 0.02030338f, 0.02168396f, -0.24995643f, 0.04622968f, -0.01746912f, 
    -0.41595078f, -0.33829767f, -0.86124331f, 0.10836515f, -0.11591719f, -0.18439066f, -0.42278802f, -0.02230236f, 
    -0.18562017f, 0.15593798f, -0.78606468f, -0.14574291f, -0.30281287f, -0.27874720f, 0.02188809f, 0.22274043f, 
    0.03897448f, -0.01926475f, 0.40369594f, 0.41862914f, 0.00557934f, -0.05930216f, -0.00196761f, -0.21670379f, 
    0.14755508f, 0.01811408f, -0.31614527f, -0.50918686f, 0.05945319f, -0.08274103f, -0.49405086f, 0.01334435f, 
    -0.55746138f, 0.27987295f, -0.12430244f, -0.31811911f, -0.51714879f, 0.58313090f, 0.01149856f, 0.17664152f, 
    -0.40930700f, -0.82064092f, 0.18504709f, -0.00909021f, 0.35484868f, -0.12829107f, -0.00221904f, -0.50105625f, 
    0.13089496f, -0.00296472f, -0.76840687f, -0.19072245f, -0.41640729f, -0.24419367f, -0.38307759f, 0.15432797f, 
    -0.31244016f, -0.83059037f, -0.38379380f, -0.01384879f, 0.05787320f, 0.49091578f, 0.51644582f, -0.12028854f, 
    -0.05225726f, -0.49317333f, 0.39087409f, -0.09086656f, 0.02104052f, -0.06601720f, 0.19478026f, -0.71488333f, 
    0.20324184f, 0.30719224f, 0.23115805f, -0.60719091f, -0.02550392f, -0.10386495f, -0.04063231f, -0.13305558f, 
    0.35660028f, 0.06118423f, -0.14620399f, 0.35609370f, -0.81894726f, 0.11150265f, 0.14586474f, 0.11976825f, 
    -0.07186351f, 0.10570266f, 0.33876929f, -0.01661216f, -0.12529983f, 0.14469972f, -0.29751745f, 0.04842700f, 
    -0.34400693f, -0.64605343f, -0.69208038f, -0.24964190f, -0.01145399f, -0.76787251f, 0.16031508f, 0.28752112f, 
    -0.07545171f, -0.02684746f, 0.04089168f, 0.54954207f, -0.25639924f, 0.00324638f, -0.14445728f, -0.26304951f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.35479352f, 0.05232363f, 0.18878564f, -0.21331082f, 0.09468532f, 0.13898577f, -0.02051177f, -0.05602680f, 
    0.10660730f, -0.04759355f, -0.12789318f, -0.26027903f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
