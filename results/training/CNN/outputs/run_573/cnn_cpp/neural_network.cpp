#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.32032222f, -0.59450489f, -0.47992560f, -0.03158646f, -0.34647036f, -0.51316112f, -0.66736090f, 0.01528506f, 
    0.04662008f, 0.12201189f, 0.15915672f, 0.31957272f, 0.06561849f, 0.05583576f, -0.24565789f, 0.00751412f, 
    0.20805573f, 0.18568739f, -0.01405511f, 0.43514827f, 0.06977189f, 0.16406748f, 0.14622632f, 0.17753047f, 
    -0.11263075f, 0.28799385f, 0.59253466f, 0.49347416f, 0.14240181f, 0.53945613f, 0.25584456f, -0.53233993f, 
    -0.55300736f, -0.49554425f, -0.31945169f, -0.13497297f, 0.29414371f, 0.29374182f, 0.24664107f, -0.15298975f, 
    -0.00998520f, -0.05293159f, -0.02223115f, -0.21441965f, -0.22079509f, 0.02367618f, -0.02125445f, 0.20120530f, 
    -0.03112092f, -0.04871497f, -0.02992327f, -0.42523900f, -0.34972131f, -0.50373513f, -0.25072083f, -0.35899222f, 
    0.18490946f, 0.39091569f, -0.28678694f, -0.04425801f, -0.14012222f, -0.34160751f, -0.33724821f, -0.44350436f, 
    0.24288228f, -0.00819843f, -0.02994160f, -0.29680485f, -0.14549439f, -0.30134931f, 0.05440989f, 0.00337133f, 
    0.00669868f, 0.05172159f, 0.02530891f, -0.74718446f, 0.24574165f, -0.51203227f, -0.56715971f, -0.11373992f, 
    0.29701337f, -0.21695679f, -0.27620640f, 0.14662775f, 0.28355250f, 0.02583057f, 0.00675932f, 0.18466511f, 
    -0.08095010f, -0.09164760f, -0.01322189f, 0.28582072f, 0.26128036f, -0.04584697f, -0.31490463f, 0.06568839f, 
    -0.23662780f, 0.22832914f, 0.25630578f, 0.04335543f, -0.34173667f, 0.51534057f, 0.40367144f, 0.28174669f, 
    0.19591063f, 0.25354156f, 0.46434894f, 0.50290555f, -0.09431747f, 0.46758270f, -0.48347652f, -0.25115561f, 
    -0.15216653f, -0.03946257f, -0.00672835f, -0.09393642f, -0.01814335f, -0.15159319f, 0.00333790f, -0.33642238f, 
    -0.06090663f, -0.01370975f, -0.13417104f, -0.03298474f, 0.12258181f, 0.82174724f, 0.52743793f, -0.12608434f, 
    -0.07886203f, -0.44421738f, 0.20177686f, 0.26327154f, 0.22960731f, 0.34857559f, 0.32383183f, 0.12789370f, 
    0.01083041f, -0.04323003f, -0.01060757f, 0.29836741f, 0.13824154f, -0.10608199f, 0.01010876f, 0.15511829f, 
    0.18647954f, 0.11864541f, 0.06109665f, 0.04915405f, -0.00242821f, 0.15210420f, 0.77533460f, 0.12183315f, 
    0.32782093f, 0.02520640f, 0.20481537f, -0.51832497f, -0.44814920f, -0.01264467f, -0.23705079f, -0.34461966f, 
    -0.08796323f, -0.33684301f, -0.19657728f, -0.26115856f, 0.01509137f, 0.01904724f, -0.16498786f, -0.07739811f, 
    -0.07034659f, 0.23288770f, 0.14892043f, 0.04981886f, -0.09340104f, -0.19382215f, -0.16773683f, -0.63111925f, 
    -0.20495866f, 0.31061718f, -0.08465419f, -0.23732431f, 0.23515402f, -0.08137573f, -0.34482473f, -0.25480282f, 
    -0.11772969f, 0.07232468f, 0.27664059f, -0.36731482f, 0.05272730f, -0.28059173f, -0.37034103f, -0.07020182f, 
    -0.14855452f, -0.27615666f, -0.42571738f, 0.11295924f, -0.05602944f, 0.13370802f, 0.17561832f, -0.08987128f, 
    0.02118323f, 0.42155629f, -0.07548922f, 0.38728043f, 0.15162757f, -0.55893737f, 0.15298514f, 0.43100148f, 
    0.02800637f, 0.55561471f, 0.22024296f, 0.13038257f, -0.02191998f, -0.26937422f, 0.40418914f, -0.17456400f, 
    -0.11008811f, -0.01497124f, -0.20150666f, -0.10149047f, 0.15254769f, 0.23401746f, -0.05036034f, -0.02032826f, 
    -0.17916694f, -0.75031769f, -0.07800999f, -0.46891978f, -0.55482715f, -0.08507675f, 0.19470836f, 0.76570630f, 
    0.48263815f, 0.31018576f, 0.30185959f, 0.15903296f, 0.04139534f, 0.17170426f, -0.27994305f, 0.22621994f, 
    0.01124299f, 0.07895581f, -0.05930731f, 0.06326699f, -0.00346403f, -0.14775409f, -0.09842060f, 0.01461674f, 
    0.01670639f, 0.03354396f, 0.62147188f, 0.17860557f, 0.21745919f, 0.89188039f, 0.83968765f, 0.28904617f, 
    -0.00304752f, -0.50556475f, 0.23769762f, 0.25488824f, -0.07886037f, 0.08359806f, 0.01519115f, 0.22066694f, 
    -0.08540971f, 0.05436160f, 0.06783585f, 0.17040636f, 0.08237546f, 0.02978090f, 0.20317625f, 0.21873823f, 
    0.04792704f, -0.16107509f, -0.00467233f, -0.63692033f, -0.78502852f, -0.18033774f, 0.67789000f, 0.24735293f, 
    -0.13611004f, 0.77409792f, 0.43347451f, -0.37679401f, -0.03719171f, -0.02045817f, -0.01418054f, 0.10411786f, 
    0.13532382f, 0.05874719f, -0.25225252f, 0.16246288f, 0.08114648f, -0.12520327f, -0.12096231f, 0.16678123f, 
    0.01389523f, -0.14067967f, -0.06231766f, -0.16490600f, -0.58834666f, -0.98488027f, -0.51587957f, 0.11817656f, 
    0.25598156f, 0.25904116f, 0.10960351f, -0.24751727f, 0.52056891f, -0.01465855f, -0.19974983f, -0.03308912f, 
    -0.20385969f, 0.23933434f, -0.08739978f, 0.12747580f, 0.13177158f, 0.12509359f, 0.13463865f, -0.01237508f, 
    -0.09542648f, -0.15454109f, 0.01416656f, -0.08270563f, 0.09768936f, 0.63448983f, 0.48000735f, 0.45796081f, 
    0.41518739f, 0.26465362f, 0.31422108f, 0.29153654f, -0.11206170f, -0.11028300f, -0.17149866f, 0.21363336f, 
    0.47079977f, -0.19566151f, -0.18501481f, -0.19775513f, 0.12991491f, -0.19416170f, 0.11278997f, -0.03797654f, 
    -0.15765980f, -0.04434280f, 0.32506436f, 0.09442394f, 0.06327033f, 0.25293580f, -0.30484349f, -0.52321535f, 
    0.70974863f, 0.48628169f, -0.65095872f, 0.22428171f, 0.06027130f, 0.47498676f, -0.19000646f, -0.21886612f, 
    0.20782992f, -0.22286220f, -0.18630843f, -0.14120515f, -0.12962279f, 0.06966170f, 0.23029995f, -0.11975875f, 
    -0.08503418f, -0.11303464f, -0.18307571f, -0.13915168f, -0.15978657f, -0.05130015f, -0.04724893f, -0.68787342f, 
    0.04138488f, -0.15989307f, -0.46604919f, -0.24382047f, -0.28557128f, 0.14526008f, -0.11983119f, -0.04206637f, 
    -0.11753422f, -0.09372125f, 0.18362288f, -0.18429562f, 0.14670968f, 0.11915383f, 0.24621709f, -0.17180300f, 
    0.37506926f, 0.16589536f, -0.18755770f, -0.09924988f, -0.03453434f, -0.33862385f, -0.14152193f, -0.13260363f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.26613903f, 0.17352353f, 0.11251416f, 0.21072525f, -0.02166068f, 0.22810249f, 0.01343430f, 0.15941839f, 
    0.03575126f, -0.15587281f, 0.12235460f, 0.28090772f, 0.12528950f, 0.24204992f, 0.03866397f, 0.20580077f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.17001097f, -0.13500208f, 0.00823749f, 0.21904449f, 0.00165203f, 0.04132712f, 0.00405243f, 0.04097973f, 
    0.09634440f, -0.00905690f, 0.05365992f, -0.08503155f, 0.00230577f, 0.05186490f, 0.18308087f, -0.17189457f, 
    0.01077548f, 0.12049596f, -0.06471640f, -0.14227422f, 0.00661891f, 0.06489415f, -0.14966485f, -0.03845300f, 
    -0.12681302f, -0.10243524f, -0.07530957f, 0.01930001f, 0.04819974f, -0.05226320f, 0.13043475f, 0.12502930f, 
    0.05116870f, 0.07550550f, 0.02586259f, 0.14975846f, 0.17269810f, 0.09588400f, -0.04252877f, -0.16679832f, 
    0.00505896f, 0.02009561f, 0.00225182f, 0.09232709f, 0.12083394f, 0.05811988f, 0.02521297f, 0.07740741f, 
    -0.02118463f, -0.01039683f, -0.07019939f, -0.13825002f, 0.13061559f, -0.01660138f, -0.08363620f, -0.05628128f, 
    0.06358632f, 0.02459715f, -0.03829988f, 0.09088890f, -0.11717311f, -0.27426010f, -0.12719458f, -0.40249404f, 
    -0.07879422f, -0.06506346f, 0.11193505f, -0.31291506f, 0.13411972f, -0.01536790f, 0.03809977f, 0.06707188f, 
    0.26441258f, 0.00775110f, 0.12451631f, 0.12902659f, -0.05344749f, -0.01241090f, -0.07457092f, -0.03665806f, 
    0.11354727f, 0.05906288f, 0.03803518f, 0.00732789f, -0.07960428f, 0.13790111f, 0.22664218f, 0.05667116f, 
    0.00911793f, -0.11208355f, 0.04770636f, 0.11612841f, 0.06433523f, 0.13900837f, 0.17456460f, 0.00073968f, 
    -0.13421382f, -0.23317745f, -0.15399268f, -0.02954296f, 0.08452225f, -0.00359055f, 0.00638458f, -0.30343276f, 
    -0.03346549f, 0.00557317f, 0.13784546f, -0.04311180f, 0.13107365f, 0.42177927f, -0.10977029f, -0.43703878f, 
    0.04884881f, 0.03335933f, 0.05447629f, 0.17086789f, 0.11047827f, 0.04780506f, -0.07902433f, 0.24717881f, 
    0.02506233f, -0.10191931f, -0.07833292f, 0.28716245f, 0.02078476f, -0.12378429f, 0.07401085f, -0.19542027f, 
    0.04287163f, 0.11002435f, -0.13974723f, 0.04417628f, -0.17688483f, 0.21844140f, -0.12737796f, 0.00862193f, 
    0.03474246f, -0.07273647f, 0.01604532f, 0.04973473f, -0.17767583f, 0.00017616f, -0.04717278f, 0.00804711f, 
    -0.25336227f, 0.05102076f, 0.12216259f, 0.20744117f, 0.00946561f, -0.06807202f, 0.03426103f, 0.10562433f, 
    0.13422817f, 0.03569169f, 0.11172163f, 0.09290593f, -0.27168477f, 0.07449593f, -0.11038295f, -0.14926147f, 
    -0.10106236f, -0.03185116f, -0.26785764f, -0.04694140f, 0.08639471f, -0.03677035f, 0.05141061f, 0.00204235f, 
    -0.00721828f, 0.23993200f, -0.08244184f, 0.18593761f, 0.13655066f, 0.03609313f, 0.07843789f, -0.04697125f, 
    -0.05006129f, -0.00345575f, 0.08019783f, 0.03429375f, 0.12222785f, 0.10732576f, 0.28741756f, 0.14973600f, 
    0.12799379f, 0.05346417f, 0.08929224f, -0.02011176f, 0.04168348f, -0.03817901f, -0.07336605f, 0.04624312f, 
    0.20362641f, -0.12668464f, -0.09869616f, 0.19469956f, 0.07592759f, -0.00147315f, -0.03393284f, -0.02539920f, 
    0.05946561f, -0.03211783f, 0.02441963f, -0.05790520f, -0.00989991f, 0.14137112f, 0.22580613f, -0.02671367f, 
    -0.02345961f, 0.03781321f, -0.01697627f, -0.09207574f, -0.00738151f, 0.04265601f, 0.07825694f, 0.03921492f, 
    -0.47595599f, -0.08955412f, -0.14804217f, 0.11872346f, -0.01371657f, -0.00232685f, 0.07843580f, -0.02083126f, 
    -0.02106003f, -0.10332785f, 0.28713858f, 0.06294215f, 0.32114220f, -0.24799606f, -0.09574703f, 0.07393548f, 
    0.00258754f, 0.17463100f, 0.06065657f, 0.06097644f, 0.00692378f, 0.10157134f, -0.20052356f, -0.00955304f, 
    0.02687513f, -0.09450614f, -0.10605913f, -0.15579711f, -0.01187441f, 0.05854584f, 0.10719761f, 0.08875547f, 
    0.06841017f, -0.02126204f, 0.07466761f, 0.13001135f, -0.20176260f, 0.06036041f, 0.13140823f, 0.13614614f, 
    0.13582230f, -0.02395562f, 0.06736308f, -0.09418871f, 0.04720264f, -0.03096256f, 0.10290122f, -0.06017759f, 
    0.34009761f, 0.10525517f, 0.11805557f, 0.07890996f, -0.20539093f, -0.06055790f, -0.00157410f, -0.21733674f, 
    0.01580406f, -0.10059564f, 0.06034877f, 0.07455494f, -0.23852177f, -0.02439336f, 0.18980053f, -0.10854239f, 
    -0.07665395f, -0.08352530f, -0.00262521f, -0.08897375f, 0.05834730f, 0.17773147f, -0.04860669f, -0.00773693f, 
    -0.13199414f, -0.02269296f, 0.03666143f, -0.07865719f, -0.08066350f, -0.10153516f, -0.01108767f, -0.04321097f, 
    0.02425706f, 0.03666538f, 0.03860562f, -0.14357108f, -0.09883539f, -0.03478992f, 0.01562226f, 0.01840206f, 
    0.09747272f, 0.11012878f, 0.04558445f, -0.04641007f, -0.12040781f, -0.06493901f, 0.00008453f, 0.03276187f, 
    0.09409826f, 0.07863666f, -0.12756012f, -0.02213944f, 0.23321548f, 0.01897589f, 0.09266061f, 0.15056886f, 
    -0.01122492f, 0.08640642f, -0.13660042f, 0.24680060f, -0.53267264f, 0.38828033f, -0.19642404f, -0.18473293f, 
    0.10106932f, 0.05457781f, -0.00416539f, -0.05027067f, -0.03219299f, -0.05496765f, -0.11158824f, 0.01083197f, 
    -0.17467158f, 0.02226575f, -0.08436890f, 0.14250210f, 0.03476595f, -0.00049370f, 0.04367250f, 0.08065320f, 
    0.11408995f, -0.05028178f, -0.14415030f, 0.03826411f, 0.20547564f, 0.15487033f, -0.03071141f, -0.18068071f, 
    0.02402761f, -0.01323333f, 0.05568258f, 0.01660765f, 0.11082356f, 0.02795546f, 0.06865326f, -0.00593133f, 
    -0.08704011f, -0.06719831f, 0.08758020f, -0.08200265f, 0.06295493f, 0.06564621f, -0.09172397f, 0.01669351f, 
    0.08015822f, 0.05797262f, 0.01182279f, 0.01190736f, 0.30498686f, -0.06592102f, 0.13939109f, 0.34918103f, 
    0.13281265f, -0.04591182f, 0.01719850f, 0.08293115f, 0.17682734f, -0.01286977f, -0.12225506f, -0.12973097f, 
    -0.12168398f, -0.24369775f, 0.03226326f, -0.09050838f, -0.03839808f, 0.04626767f, 0.04149072f, 0.23154810f, 
    0.02852045f, 0.11003005f, 0.06315999f, 0.03590194f, 0.00297569f, 0.04172182f, 0.10532124f, -0.20305386f, 
    -0.00919974f, 0.08723700f, -0.02051726f, 0.03745529f, 0.00257792f, -0.04633902f, 0.01785181f, 0.08265395f, 
    -0.40645501f, 0.06776783f, -0.08968934f, -0.17463580f, 0.04886442f, -0.06304802f, 0.16527191f, 0.10809896f, 
    0.05085104f, -0.00987543f, -0.06027330f, -0.02940284f, 0.13925815f, -0.07395083f, 0.06184683f, -0.10278378f, 
    0.00431203f, 0.05268379f, 0.12441777f, 0.15366836f, 0.26042747f, -0.08883158f, -0.01476625f, -0.04246275f, 
    0.09672634f, -0.05765353f, 0.02721644f, 0.15503782f, 0.19880469f, -0.02293323f, 0.04048898f, -0.12285483f, 
    0.07407688f, 0.00075698f, 0.06876203f, -0.07096408f, 0.20909499f, 0.02204548f, 0.02883378f, -0.13902926f, 
    0.01664215f, -0.07382017f, 0.02947426f, 0.03822025f, -0.02459381f, 0.00371116f, 0.06874544f, 0.09711462f, 
    0.16775630f, -0.06023861f, 0.06661939f, -0.11035152f, -0.00142577f, 0.02295051f, -0.07784505f, 0.11301135f, 
    -0.01125211f, -0.00184051f, -0.06815789f, -0.07384199f, -0.30600816f, -0.14306985f, 0.07776514f, -0.14096616f, 
    0.12977082f, -0.06933373f, 0.08097000f, 0.05593281f, 0.01317375f, 0.02528533f, 0.02521885f, -0.00006367f, 
    0.04625378f, -0.22829284f, -0.08132570f, 0.27614245f, 0.07843620f, -0.04217028f, 0.02779587f, -0.11974324f, 
    0.18287623f, 0.21345043f, -0.08047163f, 0.03918775f, 0.15758300f, 0.03993858f, 0.16589293f, -0.09749544f, 
    0.04361744f, 0.06783471f, 0.03830010f, 0.13377635f, 0.02272331f, -0.01102305f, 0.00412518f, -0.06397418f, 
    0.13615920f, -0.21437514f, -0.23194604f, 0.40060410f, 0.02220724f, -0.08460218f, 0.06164829f, 0.06903435f, 
    0.02075486f, 0.18469064f, -0.09807757f, 0.18621609f, -0.35228828f, 0.45334834f, -0.25525486f, 0.28608441f, 
    -0.02296641f, -0.10692578f, -0.06015886f, -0.01717114f, -0.01910607f, -0.02543293f, 0.11304518f, -0.00327092f, 
    -0.06984044f, -0.10789007f, -0.02250295f, 0.27303314f, 0.07197995f, -0.05581019f, 0.03704949f, -0.11285589f, 
    0.17296216f, 0.02932668f, 0.03459365f, 0.18224888f, 0.25305510f, 0.05533360f, -0.01507026f, 0.03258238f, 
    0.03014521f, 0.07790872f, -0.12725942f, -0.05772642f, -0.03293114f, 0.04009388f, 0.04266253f, -0.00116475f, 
    -0.02714872f, 0.22772652f, 0.00702584f, -0.03368416f, -0.02249691f, 0.08233868f, 0.11535222f, -0.07776500f, 
    -0.07960732f, 0.07238919f, 0.04459197f, 0.11592691f, -0.08893503f, -0.09120118f, -0.00315980f, -0.02077687f, 
    -0.03811513f, 0.02740549f, 0.07030375f, 0.03213518f, 0.16020311f, -0.02011735f, 0.03706766f, -0.01926048f, 
    0.24500817f, 0.12971278f, -0.02492903f, -0.02832343f, -0.00636128f, 0.05854075f, -0.04535867f, 0.00841202f, 
    -0.04497619f, -0.02042079f, 0.00289837f, -0.15449466f, 0.21313992f, -0.18641183f, -0.08180477f, -0.14378725f, 
    0.16239251f, -0.06404628f, 0.02431633f, 0.03881160f, 0.08742124f, 0.08683161f, -0.12377135f, -0.05711668f, 
    0.27466759f, 0.02899188f, 0.11549702f, 0.10908385f, -0.08867238f, -0.12382265f, 0.00532736f, -0.16509943f, 
    0.04766374f, -0.08595308f, -0.09886634f, 0.07806421f, 0.12408554f, 0.16359968f, -0.11596920f, -0.10368118f, 
    -0.09281544f, -0.06039453f, -0.07349254f, 0.01328022f, 0.04903653f, 0.15739678f, -0.06820761f, 0.03270604f, 
    -0.29646540f, -0.10941843f, -0.05711701f, -0.20635507f, -0.07128597f, -0.10831097f, -0.04792113f, 0.06202427f, 
    0.21527149f, 0.04918857f, 0.00986826f, 0.10867303f, -0.24648182f, -0.20348337f, -0.02064047f, -0.09454847f, 
    -0.03955192f, 0.02602721f, 0.18870619f, 0.14284700f, 0.13544078f, 0.07344031f, 0.00464200f, -0.00032364f, 
    0.00376592f, 0.04235299f, 0.06406655f, -0.07710404f, 0.07313910f, 0.09516034f, 0.05349587f, 0.06092862f, 
    -0.00171477f, -0.11231211f, 0.02333886f, -0.08343081f, 0.14387852f, 0.20881891f, 0.09980422f, 0.14653052f, 
    0.04172820f, -0.05980379f, 0.01162058f, 0.07221331f, 0.04863551f, 0.13173401f, 0.19745085f, 0.05799188f, 
    -0.14187875f, 0.09844018f, -0.07576014f, -0.08842824f, 0.11860429f, 0.11522439f, 0.00572660f, -0.08305704f, 
    -0.05971449f, 0.08988578f, 0.10920282f, 0.01910050f, 0.18074699f, 0.12792669f, -0.06713872f, -0.10905614f, 
    -0.01965519f, -0.02235791f, -0.05722488f, 0.03130750f, -0.11323854f, 0.07263610f, 0.03190975f, 0.07871014f, 
    -0.21189766f, -0.03044667f, -0.06224896f, -0.01015252f, 0.07602566f, 0.00445757f, 0.06564881f, -0.10985434f, 
    0.00001907f, 0.01111875f, 0.05925250f, 0.06661260f, 0.36259946f, -0.07631708f, 0.05870081f, 0.14860746f, 
    0.06041449f, -0.04748559f, 0.08187103f, 0.10813277f, -0.03427752f, 0.02536582f, -0.14019236f, 0.15166117f, 
    0.17075118f, 0.07259119f, 0.05429886f, -0.00719306f, -0.02541930f, -0.06605393f, 0.05211501f, 0.10527870f, 
    -0.03640969f, 0.05299216f, 0.07448008f, 0.03834375f, -0.30183709f, -0.13209358f, -0.14739017f, -0.13721158f, 
    0.02005708f, 0.06120393f, -0.06096289f, 0.00897961f, -0.07543008f, 0.06046367f, 0.03328793f, 0.00552298f, 
    0.23723759f, 0.03393974f, 0.15511745f, 0.27229184f, -0.01632187f, 0.06964270f, 0.15047930f, -0.00835352f, 
    0.08453088f, 0.00613718f, 0.10891240f, 0.03135722f, -0.08782855f, 0.18598843f, 0.12809445f, 0.02679357f, 
    0.04477165f, 0.05709065f, 0.07138719f, -0.06760359f, -0.14641288f, -0.02206470f, -0.02638127f, 0.10617513f, 
    -0.02264949f, -0.11014311f, -0.16982380f, -0.01384065f, -0.04884687f, -0.07864222f, -0.01179837f, -0.16281371f, 
    0.00534815f, -0.01972442f, -0.05159304f, 0.11078405f, 0.22620800f, 0.08807565f, -0.04762748f, 0.24397631f, 
    0.05954502f, -0.00313318f, 0.17849053f, 0.06748158f, -0.01068021f, -0.10141020f, 0.22349952f, 0.09343252f, 
    -0.19120856f, 0.07320207f, -0.09714003f, 0.10812853f, 0.07563215f, 0.21293728f, 0.11880142f, 0.08443473f, 
    0.01294711f, 0.20241137f, -0.01729885f, -0.09036703f, -0.15268475f, -0.31328592f, 0.01314718f, 0.03242663f, 
    0.02592238f, 0.14546721f, 0.04703435f, -0.06994832f, 0.05188681f, -0.11775810f, -0.08180054f, -0.02491967f, 
    -0.19738406f, -0.01534848f, -0.01029106f, -0.21369442f, 0.06091231f, 0.09300900f, -0.02516345f, 0.02016540f, 
    -0.05500089f, -0.01108102f, 0.05912381f, -0.01510948f, 0.31012458f, 0.34540802f, -0.05201039f, 0.05556604f, 
    0.23292434f, -0.06063412f, 0.04428091f, -0.03754809f, -0.12086512f, 0.00525590f, -0.00595488f, 0.07532261f, 
    0.13528195f, 0.19526519f, -0.15655886f, -0.06737807f, 0.05001884f, -0.01553956f, 0.08469945f, -0.08855746f, 
    0.01617335f, 0.08287948f, 0.11791984f, 0.06746721f, -0.20561355f, -0.09607584f, 0.06793125f, 0.24625589f, 
    0.04862024f, -0.05215269f, 0.05322606f, -0.17975704f, 0.16077991f, 0.13415276f, -0.01840440f, 0.01086194f, 
    0.08706948f, 0.14469793f, -0.00113196f, -0.31655627f, -0.13668132f, 0.00523776f, 0.04503453f, 0.32664120f, 
    -0.02196257f, -0.04549247f, -0.04876292f, -0.04930544f, -0.40490881f, -0.24152148f, -0.05639732f, 0.02291484f, 
    0.01163689f, -0.04513755f, 0.01776968f, -0.08139344f, 0.00462863f, -0.00555386f, -0.08510178f, -0.07851785f, 
    0.03181783f, -0.06538354f, -0.01327707f, -0.50048739f, 0.15893613f, 0.00255586f, 0.03797332f, 0.04830756f, 
    0.13476115f, -0.04020672f, 0.03530173f, 0.17954874f, -0.28228512f, 0.20107208f, 0.01804693f, -0.38590810f, 
    0.08469012f, -0.01246493f, 0.01005536f, 0.03249188f, 0.05668484f, 0.04210325f, 0.09808074f, -0.15053426f, 
    0.01354313f, 0.13504761f, -0.00310069f, -0.14479803f, -0.07535369f, -0.07598581f, 0.08689510f, -0.21084565f, 
    0.02322060f, 0.03050344f, 0.00288853f, -0.14357510f, 0.39959720f, 0.04128966f, -0.14411950f, -0.06444731f, 
    0.07641619f, 0.06163317f, 0.09052411f, -0.07686125f, 0.06364585f, -0.06760532f, -0.09864241f, 0.03471656f, 
    0.05670384f, 0.00904946f, -0.05705922f, 0.00342348f, 0.10830976f, 0.02079037f, -0.10774444f, 0.00007305f, 
    0.06953764f, 0.05295147f, 0.07394283f, 0.04641820f, 0.02663483f, -0.06668651f, -0.01943048f, 0.14789018f, 
    0.00264879f, -0.07722479f, -0.11082134f, 0.04631757f, 0.18124717f, -0.06923383f, 0.15515451f, 0.05112739f, 
    0.01822792f, 0.03349229f, 0.03040691f, 0.06300928f, -0.04999967f, 0.06021773f, 0.04512899f, -0.05478927f, 
    0.03170120f, -0.01930621f, -0.02350716f, 0.01458818f, -0.03507268f, 0.03624477f, -0.02918250f, 0.06317528f, 
    -0.06853810f, -0.04151978f, -0.01230310f, -0.00984060f, -0.03470894f, -0.01546959f, 0.00297587f, 0.02106329f, 
    0.04463321f, 0.05764766f, -0.00625183f, -0.05327148f, -0.06708244f, -0.01878096f, 0.02086497f, 0.01529693f, 
    0.02431990f, -0.01700354f, 0.00617742f, -0.07514290f, 0.01487542f, 0.01018697f, -0.01885852f, -0.00330767f, 
    0.01300246f, -0.00876069f, 0.05879425f, 0.05521298f, -0.03834106f, -0.06536494f, 0.03167176f, -0.04304568f, 
    -0.00162593f, 0.05534186f, -0.01961574f, 0.03996032f, -0.06784647f, -0.01845751f, 0.00548379f, 0.02433433f, 
    -0.02745642f, -0.04276178f, 0.03140986f, -0.03898052f, 0.04577716f, 0.05515224f, 0.04835025f, -0.00585623f, 
    -0.06369057f, 0.01974741f, -0.07466798f, 0.03135666f, -0.01631114f, 0.04306639f, 0.00223146f, 0.01564719f, 
    -0.05795389f, 0.03375150f, 0.02096838f, -0.02147807f, -0.07103410f, 0.04663890f, -0.07464588f, -0.03183212f, 
    0.03511083f, -0.06441393f, -0.03334957f, -0.00824518f, -0.07418190f, 0.02386711f, -0.06037184f, 0.02397073f, 
    -0.00164855f, -0.04673897f, -0.05998171f, -0.01385555f, -0.00092621f, -0.06088362f, 0.01858469f, -0.04902185f, 
    -0.05032007f, -0.03818940f, 0.03111938f, 0.01188158f, -0.02383835f, -0.03412682f, -0.07268076f, -0.07328794f, 
    -0.03608906f, -0.06919157f, -0.07188814f, 0.03663372f, -0.05589059f, -0.04290920f, -0.03395166f, -0.07467125f, 
    -0.05807839f, 0.02485869f, -0.07964567f, 0.02641490f, -0.04554795f, -0.02115845f, 0.03410082f, -0.02242632f, 
    0.05553987f, 0.02750458f, -0.03502906f, 0.00597532f, -0.05899357f, -0.00696422f, 0.05397277f, 0.00204908f, 
    0.00019529f, 0.03144744f, -0.08013356f, 0.02351861f, -0.04118595f, 0.05769096f, -0.00626595f, 0.03423971f, 
    0.02184306f, -0.00694847f, -0.05441429f, 0.05092209f, -0.00655098f, 0.02178510f, -0.01126536f, -0.05943872f, 
    -0.03117454f, -0.06318896f, -0.05805181f, -0.03401191f, -0.05973778f, -0.03265398f, 0.02023731f, 0.02993355f, 
    0.05216592f, 0.03870146f, -0.06682064f, 0.04458239f, 0.06118417f, -0.02941598f, -0.03725598f, -0.05874088f, 
    0.04368201f, -0.02535075f, -0.06609556f, -0.04618898f, 0.02181852f, -0.02164655f, -0.04797610f, -0.04629435f, 
    0.03540990f, 0.04535361f, -0.02851515f, -0.05428367f, 0.06301150f, 0.04215840f, 0.04944079f, 0.00014740f, 
    -0.02524456f, -0.07516267f, -0.05731478f, -0.01226282f, 0.05085775f, -0.02777567f, 0.06054904f, -0.05736550f, 
    -0.00832120f, 0.03267377f, -0.06482042f, -0.04326862f, -0.02556218f, 0.03633447f, 0.01813206f, 0.04927864f, 
    0.17251910f, -0.02790647f, -0.08302802f, -0.04125324f, 0.10494830f, 0.04653661f, -0.10706107f, 0.08364363f, 
    -0.13594754f, 0.06184709f, -0.13065693f, -0.17149960f, 0.18718003f, 0.06104395f, 0.06073699f, -0.08919029f, 
    -0.01714965f, 0.02732340f, -0.11387927f, -0.06634575f, 0.10590801f, 0.03104906f, -0.12021617f, 0.13397916f, 
    0.01585411f, -0.06498493f, -0.11213119f, 0.14538939f, -0.00469050f, -0.17007408f, -0.08009094f, -0.12355015f, 
    0.03576459f, 0.02161101f, 0.09331872f, 0.22610784f, 0.34574994f, 0.00302898f, -0.03274019f, -0.13540515f, 
    -0.06779395f, -0.03074177f, -0.00918791f, 0.09067075f, -0.02920645f, 0.07065275f, -0.26531994f, 0.01929002f, 
    0.00768704f, -0.07906014f, -0.26666507f, -0.20611493f, 0.02452137f, 0.09689068f, -0.11283395f, 0.07782087f, 
    0.16769415f, 0.24632177f, 0.11363528f, 0.16337456f, -0.18341663f, -0.14895354f, 0.06103171f, 0.04121472f, 
    -0.01926743f, 0.01239186f, 0.15094593f, -0.07090285f, 0.06582032f, -0.12182258f, 0.01100026f, -0.01204824f, 
    0.22319734f, 0.10969961f, 0.04542975f, -0.02027790f, 0.10357405f, 0.12304164f, -0.05882887f, 0.01868599f, 
    0.02950345f, -0.19641918f, 0.01510406f, -0.00432363f, 0.07452106f, -0.04951103f, -0.03397416f, 0.02239870f, 
    -0.04643991f, -0.00457073f, -0.13398160f, 0.13848156f, -0.01192292f, 0.14854409f, 0.13294341f, 0.14927085f, 
    -0.04148562f, -0.04610498f, -0.07653666f, 0.03955093f, 0.11579852f, -0.00072957f, 0.08189066f, -0.23954026f, 
    -0.04350183f, -0.10856456f, 0.05629034f, 0.10592066f, 0.31391659f, 0.06841612f, -0.13021913f, -0.20106936f, 
    0.05749376f, 0.05872241f, -0.00727003f, 0.30063829f, -0.07662003f, -0.11174049f, -0.02568349f, 0.00535720f, 
    0.20961055f, -0.11301358f, -0.02508927f, 0.11248458f, 0.03971634f, -0.02940892f, -0.10373280f, -0.09917341f, 
    0.00265986f, 0.06860831f, -0.17698753f, 0.05884930f, 0.23460589f, 0.03317454f, -0.21950191f, 0.26079857f, 
    -0.06115695f, 0.02448286f, 0.06747682f, 0.06277579f, -0.08011767f, 0.07177620f, -0.00210906f, 0.15536050f, 
    0.26827323f, -0.19509858f, 0.01805326f, 0.21825913f, 0.11106861f, -0.03787807f, 0.04620873f, 0.15107451f, 
    0.06183766f, 0.04880113f, -0.11474055f, 0.00583938f, -0.03046546f, 0.01491801f, -0.01034059f, -0.20087130f, 
    -0.01257462f, -0.07237982f, -0.11422600f, -0.01627301f, -0.04257519f, 0.08966444f, 0.07661600f, 0.04662263f, 
    0.03314077f, 0.04019706f, 0.04161566f, 0.13828358f, 0.02382620f, 0.18241797f, 0.04027777f, -0.01286283f, 
    0.06701305f, 0.15137485f, 0.15237296f, -0.02830232f, 0.00856273f, 0.07235123f, -0.11745290f, 0.03848577f, 
    -0.00642655f, 0.06634492f, 0.14937276f, -0.11351269f, 0.04461730f, -0.06117118f, -0.15057127f, -0.02737730f, 
    -0.18012354f, 0.01064262f, 0.06282494f, -0.15743028f, 0.02003411f, 0.05923957f, -0.11708287f, 0.07517433f, 
    0.11875066f, -0.01351029f, -0.01990457f, 0.09204507f, 0.20540577f, 0.01143388f, -0.03493204f, 0.20082767f, 
    0.11903906f, 0.06710095f, 0.01088324f, -0.03196372f, 0.15203337f, 0.03842598f, 0.05325886f, -0.00992496f, 
    -0.14240091f, 0.14278786f, -0.13868906f, -0.03901802f, 0.02978811f, 0.12752727f, 0.02598636f, 0.12115876f, 
    0.00716165f, 0.12971744f, 0.14630722f, 0.05149733f, 0.00866856f, -0.11472704f, 0.15520769f, 0.01941337f, 
    -0.08162017f, 0.14261121f, 0.07550215f, 0.08689396f, -0.02884404f, -0.08575468f, -0.04451308f, 0.09086571f, 
    0.21324074f, -0.12233698f, -0.17549770f, -0.05210604f, 0.01391821f, 0.05744622f, -0.05644182f, -0.08921248f, 
    -0.04151434f, 0.04105863f, 0.27511245f, 0.04697701f, 0.36188155f, 0.30092904f, -0.05718037f, 0.01104840f, 
    0.13187975f, 0.08567809f, 0.11888413f, 0.06533045f, -0.05319010f, -0.02873762f, 0.10089175f, -0.04807318f, 
    -0.18572214f, 0.14587052f, -0.05450841f, -0.11494745f, 0.16227721f, -0.08023512f, 0.02388667f, -0.07393108f, 
    0.14850722f, -0.00706952f, 0.05541631f, 0.04348262f, -0.06821637f, -0.35698584f, -0.04703665f, -0.27677408f, 
    0.01887667f, -0.00850402f, -0.07483996f, 0.01334299f, 0.04693038f, 0.11124696f, 0.09411547f, 0.01179891f, 
    0.28627473f, -0.06173028f, 0.01403036f, 0.18219422f, 0.07031251f, 0.03727405f, 0.13209437f, -0.02666167f, 
    0.07575131f, 0.04288441f, 0.05107391f, -0.03102725f, -0.01724753f, -0.24499366f, 0.07362145f, 0.06521972f, 
    0.02082050f, 0.07055710f, 0.06835055f, 0.16976312f, 0.03726351f, -0.19236587f, -0.02625792f, -0.20722236f, 
    0.24300103f, -0.31733614f, 0.04182405f, 0.11577722f, 0.24073164f, 0.00570520f, -0.09200511f, -0.08689638f, 
    0.11083011f, -0.00738592f, 0.04384853f, 0.17522815f, -0.07886723f, 0.13836710f, 0.07039752f, 0.09268174f, 
    0.13683909f, 0.08533236f, -0.03820129f, -0.02761460f, 0.09663058f, 0.05737002f, 0.03942962f, 0.01599789f, 
    0.01017985f, -0.16007142f, 0.07509497f, 0.14693585f, -0.07301997f, -0.03378042f, -0.08858349f, -0.04336341f, 
    0.14258260f, -0.09319140f, -0.12535571f, 0.06769094f, 0.49323860f, 0.02087536f, 0.08462939f, -0.03817658f, 
    0.19485044f, -0.08499549f, 0.03470230f, -0.06522871f, 0.16271223f, -0.02671754f, -0.04092642f, 0.05838985f, 
    -0.17395118f, -0.06999352f, 0.03789012f, -0.25149992f, -0.03905753f, 0.16682948f, -0.21780486f, 0.03285234f, 
    -0.05479939f, -0.00420008f, 0.04012005f, 0.16117308f, 0.00548872f, -0.08125716f, -0.12396748f, -0.01904681f, 
    -0.16409872f, -0.05727774f, -0.00185797f, 0.18489391f, 0.28423989f, -0.10412734f, 0.01163321f, -0.11224398f, 
    0.01125104f, 0.03119869f, 0.04002398f, -0.07497415f, -0.07170550f, -0.01004674f, 0.01053200f, 0.01151406f, 
    -0.02684160f, 0.05850734f, 0.00112889f, -0.06144202f, -0.06112783f, -0.00304524f, -0.00941676f, -0.00200961f, 
    -0.00057828f, -0.06887929f, 0.02768193f, -0.00059673f, 0.06522711f, -0.03721763f, 0.02076353f, -0.01832282f, 
    -0.06804916f, -0.03656705f, -0.00372784f, -0.03298540f, 0.05117085f, 0.02348324f, 0.00757466f, -0.00172266f, 
    -0.00375556f, -0.01147393f, 0.02862041f, -0.06667693f, 0.05255117f, 0.00324614f, -0.07136261f, -0.02658816f, 
    -0.03428160f, -0.00552180f, 0.00239364f, -0.04386079f, -0.06743716f, 0.04749632f, -0.00235998f, -0.04528844f, 
    -0.03027588f, -0.02917706f, 0.06694944f, -0.02649566f, -0.04354381f, -0.03376366f, -0.02972433f, 0.05218606f, 
    -0.02024459f, 0.01320455f, -0.02317883f, -0.03580756f, 0.06046771f, -0.07551488f, -0.05107458f, -0.00316119f, 
    -0.01689394f, -0.04243191f, 0.05323024f, 0.04454922f, -0.00600440f, 0.00476583f, -0.04584941f, 0.02087572f, 
    0.01730219f, 0.05205106f, -0.03802930f, -0.00308863f, 0.05805609f, -0.02408904f, -0.07402271f, -0.04685663f, 
    0.03546844f, 0.02071759f, 0.02580094f, -0.01071694f, -0.02156263f, 0.00920865f, -0.02151333f, 0.04051555f, 
    0.05664400f, -0.03650964f, 0.00659380f, 0.03476777f, -0.03137901f, 0.02811062f, 0.05927191f, -0.02299047f, 
    0.02052855f, 0.02089309f, 0.00033905f, -0.06121306f, 0.05496220f, 0.06128505f, 0.00077930f, 0.03248606f, 
    0.04692505f, -0.03868963f, -0.04809413f, -0.06449109f, 0.04753588f, 0.05337239f, -0.06936765f, -0.04750447f, 
    -0.02043993f, 0.05975971f, -0.04357906f, 0.05263316f, 0.05603396f, -0.04593450f, -0.04572824f, 0.05126771f, 
    -0.03951408f, -0.05669677f, -0.04999499f, -0.03917584f, 0.02230641f, 0.01292306f, 0.00258154f, -0.02686837f, 
    -0.00631016f, -0.02591499f, -0.04320285f, 0.05065443f, 0.01362446f, 0.04258733f, -0.00763926f, -0.06757360f, 
    -0.03312244f, -0.00988827f, -0.04838620f, 0.01593524f, 0.03894459f, -0.06611262f, -0.02984989f, -0.05833222f, 
    -0.06758349f, -0.00394702f, -0.07197898f, -0.07434356f, -0.02428762f, -0.04505746f, -0.02739414f, 0.00721555f, 
    0.05475385f, -0.03110191f, 0.01593586f, -0.04169393f, -0.05049444f, 0.01251694f, -0.06613082f, -0.00596772f, 
    0.05256567f, 0.01852458f, -0.07288659f, 0.05891467f, -0.06514788f, 0.01851469f, 0.00912760f, 0.02298670f, 
    -0.03823734f, 0.01803403f, -0.03821377f, 0.00872616f, 0.02311346f, -0.04105679f, -0.06357067f, 0.02666718f, 
    0.04841125f, 0.00194107f, -0.03273121f, -0.01612500f, -0.05513543f, -0.06341005f, -0.04224930f, -0.05800125f, 
    -0.07022476f, 0.06381353f, 0.00503581f, 0.00028343f, 0.02889513f, 0.00927158f, 0.03592651f, 0.01969529f, 
    -0.08126006f, 0.01753784f, 0.01042256f, -0.05232935f, 0.02040276f, 0.06591371f, 0.16020429f, 0.18255349f, 
    -0.02475253f, 0.05435362f, 0.03738647f, 0.19630663f, 0.05845416f, -0.03969432f, 0.02974704f, -0.11041103f, 
    -0.08122187f, -0.04182252f, 0.00879593f, -0.04263945f, 0.15230557f, 0.06977477f, 0.07499423f, -0.01157349f, 
    -0.16475414f, -0.00453919f, 0.00676951f, -0.14344054f, 0.06916276f, -0.00080984f, -0.05088539f, -0.07902811f, 
    0.04533388f, -0.03348080f, 0.08046186f, -0.04940819f, 0.12182132f, -0.03833437f, 0.07280693f, -0.12264126f, 
    -0.03679439f, 0.02767297f, 0.03436958f, -0.09787522f, 0.04632706f, -0.01245521f, 0.06228283f, 0.06441759f, 
    0.13090168f, 0.18417720f, 0.12687206f, 0.22893052f, -0.03407639f, -0.04481668f, -0.00270773f, 0.06282203f, 
    -0.00247158f, 0.02902009f, 0.02257411f, -0.07536976f, 0.15792622f, -0.14555985f, -0.05274169f, 0.08076450f, 
    -0.07333414f, 0.07804843f, -0.08445001f, 0.04035994f, -0.04771426f, 0.03582165f, -0.05389734f, -0.00100293f, 
    -0.01434092f, 0.04206161f, 0.11390363f, -0.07120556f, 0.03809823f, 0.19954775f, 0.04057317f, 0.11627749f, 
    -0.00592032f, 0.03768183f, -0.04249065f, 0.12734841f, 0.03515743f, -0.00173752f, -0.14153871f, -0.01371600f, 
    -0.00666683f, 0.03685660f, -0.00496409f, 0.03470575f, -0.14299877f, -0.05907208f, 0.03028044f, -0.04428956f, 
    -0.02258967f, 0.04473851f, 0.15214209f, 0.17534164f, 0.01297830f, -0.02351177f, -0.04668467f, 0.01439461f, 
    0.07370503f, -0.00622373f, -0.06359696f, 0.08244249f, 0.02575324f, -0.05500942f, -0.07386026f, -0.12266786f, 
    -0.02863732f, 0.02616650f, -0.05327480f, 0.13361436f, -0.00311258f, -0.03757579f, 0.10235919f, 0.01381091f, 
    0.26285094f, -0.06255796f, 0.17834155f, 0.19666564f, -0.20449206f, -0.03636343f, -0.13249710f, 0.06015606f, 
    0.10941798f, 0.04732154f, -0.03174388f, -0.09812666f, -0.04408012f, -0.00867547f, -0.09783321f, 0.24212477f, 
    -0.00117093f, -0.07909526f, -0.05223121f, -0.01137380f, -0.01721921f, -0.02856219f, 0.05821665f, 0.18395007f, 
    0.11803077f, -0.12522072f, -0.00621686f, -0.04663140f, 0.24266782f, -0.02092260f, 0.09457257f, 0.17940244f, 
    -0.01671721f, 0.09733062f, -0.02094308f, -0.00078898f, -0.01791760f, 0.13688755f, 0.19933306f, 0.19053362f, 
    0.04978875f, 0.09579353f, 0.02414743f, 0.09386898f, 0.03350963f, 0.05254725f, 0.08844462f, -0.03000951f, 
    -0.17197548f, -0.11518265f, -0.09374801f, -0.10410426f, 0.06578687f, -0.04570318f, 0.01729278f, -0.01347423f, 
    0.02462921f, -0.00434963f, 0.00005762f, 0.10895091f, -0.15971100f, -0.10305940f, -0.03262977f, -0.09107745f, 
    0.01606535f, 0.11779037f, 0.09389978f, -0.04207563f, 0.03739941f, 0.06729852f, 0.08192911f, -0.02046264f, 
    0.09216758f, 0.17029148f, 0.16564624f, 0.02786924f, -0.01485343f, -0.03397123f, -0.12325157f, -0.07772956f, 
    -0.00542527f, 0.02862226f, -0.04129124f, -0.16906774f, -0.15799810f, 0.00716391f, -0.10765369f, -0.02521132f, 
    0.08628449f, 0.04190895f, -0.02507053f, -0.02707002f, 0.00698660f, 0.01240109f, -0.04698902f, -0.09053693f, 
    0.31819749f, 0.01662462f, 0.05689199f, 0.13865155f, -0.04095301f, 0.00677856f, -0.01047634f, 0.13062598f, 
    -0.00761762f, 0.10566124f, -0.05216948f, -0.03746119f, -0.12349828f, 0.23307113f, 0.04629150f, 0.08514819f, 
    0.15058102f, -0.02743951f, -0.05699345f, 0.04706902f, -0.03657106f, 0.06610288f, 0.08647218f, 0.05567310f, 
    -0.01108739f, -0.19193675f, -0.14588512f, -0.05845702f, -0.00356918f, -0.01028102f, 0.00138710f, 0.00215358f, 
    0.03966324f, 0.03850517f, -0.02957057f, 0.17287157f, -0.17698404f, 0.11754113f, 0.08048807f, -0.06891049f, 
    0.00970619f, 0.13440552f, 0.08778475f, 0.04024377f, -0.04826476f, 0.03590046f, 0.07601766f, 0.08995209f, 
    -0.02888082f, -0.14755140f, -0.11151230f, 0.08188844f, -0.00093694f, -0.01798599f, -0.12335746f, -0.07588343f, 
    0.03838079f, 0.09482472f, 0.04284908f, -0.10523289f, 0.09380892f, 0.06301063f, 0.09344092f, 0.16562705f, 
    -0.03387204f, -0.06673933f, 0.02931086f, -0.00440397f, 0.02408201f, 0.08830226f, 0.01218597f, -0.05696666f, 
    0.17762995f, -0.01049647f, -0.05243798f, -0.13987035f, 0.16278985f, 0.16334254f, -0.07133537f, 0.07213012f, 
    -0.08269008f, 0.05851172f, 0.06954411f, -0.06530519f, 0.21954881f, 0.11725812f, 0.12927110f, 0.12786132f, 
    0.09026067f, -0.00267049f, 0.02649574f, 0.13272506f, 0.05994688f, -0.04505798f, 0.00560255f, 0.04860959f, 
    -0.37470269f, 0.12279911f, -0.02203684f, 0.04620745f, 0.08578597f, -0.01184427f, -0.02918331f, -0.07451052f, 
    -0.16090286f, 0.00453659f, -0.01539872f, 0.00866356f, 0.24781948f, -0.26829544f, 0.21263227f, -0.13712302f, 
    -0.03383366f, 0.00184884f, 0.03964896f, -0.01251599f, -0.02331230f, 0.03232274f, -0.11418790f, -0.04575122f, 
    -0.02501871f, 0.04045219f, 0.18276770f, 0.11529967f, -0.07987684f, -0.05057371f, -0.05527078f, -0.14075916f, 
    -0.12183802f, 0.07422042f, 0.10818364f, 0.02906853f, -0.28418753f, -0.00177852f, -0.15860668f, 0.02658721f, 
    0.08863535f, 0.00691441f, -0.07628597f, -0.03741894f, -0.09108260f, -0.01927852f, -0.06994824f, 0.05276367f, 
    0.29042417f, 0.20300671f, 0.13608046f, 0.09295222f, 0.10348152f, -0.08905789f, 0.01354063f, 0.05032250f, 
    0.08440172f, 0.03917653f, 0.05751993f, 0.02343997f, 0.11682826f, 0.10089388f, 0.06454562f, -0.06146288f, 
    0.08713772f, 0.01233320f, -0.03043026f, 0.00304166f, -0.06561758f, -0.16969509f, 0.00015529f, -0.03960310f, 
    -0.37081245f, -0.00377643f, 0.11851923f, -0.07512122f, 0.05109514f, 0.00258106f, 0.06654568f, 0.14429699f, 
    -0.00944959f, 0.03523129f, -0.09580605f, 0.08998328f, 0.01801523f, 0.07307762f, -0.16972016f, 0.00469871f, 
    0.09916443f, 0.09648617f, -0.08362997f, 0.07086069f, -0.03090114f, -0.02714255f, 0.05657976f, -0.03664148f, 
    -0.21672840f, -0.04092834f, -0.11694684f, -0.10062945f, 0.03681127f, -0.00758726f, -0.00696349f, 0.12025536f, 
    -0.06235605f, -0.08270299f, 0.11319814f, -0.15615466f, -0.19721259f, -0.03741392f, -0.07682209f, -0.04341824f, 
    0.07691940f, 0.03635541f, 0.02343777f, 0.07267626f, -0.05319342f, -0.12305843f, 0.11286178f, 0.06224221f, 
    0.26219225f, -0.04754154f, 0.08876410f, 0.13084525f, 0.07835031f, -0.03141272f, -0.07268616f, -0.21169493f, 
    -0.12820444f, -0.01301610f, 0.02902271f, -0.00333737f, 0.17276858f, 0.23899154f, 0.06776783f, 0.07953606f, 
    0.18195269f, 0.00624973f, -0.10630944f, 0.05280904f, 0.11984656f, 0.03176752f, 0.01797734f, -0.01431683f, 
    0.06365032f, -0.21238808f, 0.08862212f, 0.09346449f, -0.00228489f, -0.03478814f, 0.02316327f, -0.02315386f, 
    0.06644119f, 0.08518009f, 0.04174687f, 0.00128625f, -0.22731301f, -0.30375639f, -0.02605694f, -0.04068483f, 
    0.03274333f, 0.08401287f, 0.06437022f, 0.02094643f, -0.01006688f, -0.03813266f, 0.14873289f, 0.16569677f, 
    0.27281642f, -0.07370664f, 0.11529247f, 0.15233663f, 0.00055945f, -0.02541804f, -0.03316484f, -0.07854655f, 
    0.13169508f, 0.09952042f, -0.10727343f, 0.01888570f, -0.16578959f, -0.39106733f, -0.08565651f, 0.00303853f, 
    0.10002132f, -0.00042406f, -0.07844955f, 0.07225096f, -0.08656251f, -0.05973691f, 0.01937534f, 0.02348053f, 
    -0.30144355f, 0.44100669f, -0.05141494f, -0.07801469f, 0.14040971f, 0.03743926f, -0.10839517f, -0.14591169f, 
    0.00446434f, 0.06900388f, 0.04993756f, 0.01829457f, -0.17926121f, -0.18606144f, 0.05285427f, 0.06907553f, 
    0.04334901f, -0.10997424f, 0.03118971f, 0.03120547f, -0.06094894f, 0.05092883f, 0.00470588f, 0.07382664f, 
    -0.25908720f, -0.06134066f, 0.16239710f, 0.14897686f, 0.04518401f, -0.00797647f, -0.01355630f, -0.06741104f, 
    0.03961503f, -0.08619495f, 0.08613690f, 0.17175889f, 0.02223173f, 0.31941947f, 0.05384476f, 0.07607609f, 
    0.31155002f, 0.07723833f, -0.05893815f, -0.12946969f, 0.02067142f, -0.00222488f, -0.16398424f, 0.00802049f, 
    0.41115847f, 0.01315034f, 0.03271645f, -0.14982776f, 0.08650405f, -0.02557581f, 0.04113766f, -0.01825987f, 
    -0.00557098f, -0.02170826f, -0.07402141f, 0.17128491f, -0.27856401f, -0.50297761f, -0.05767602f, -0.09015740f, 
    -0.06350102f, 0.08111484f, 0.06177291f, 0.09697342f, 0.05340745f, 0.03503935f, 0.04767734f, -0.03502682f, 
    0.16101307f, 0.05489615f, 0.11740061f, -0.04646657f, -0.02775080f, -0.02342970f, -0.00563380f, 0.11366979f, 
    0.07395299f, -0.01702681f, 0.13853018f, 0.20343029f, 0.06520595f, 0.09382632f, 0.09937300f, -0.15914831f, 
    0.09514195f, -0.11299424f, 0.06334547f, -0.12199721f, -0.03469379f, -0.05514677f, 0.11097127f, -0.09654821f, 
    0.22588490f, 0.05745674f, 0.09036076f, -0.04060973f, -0.06105608f, 0.00607837f, -0.05826968f, 0.01743796f, 
    0.06185966f, 0.00423136f, -0.14570408f, -0.11425801f, -0.09374171f, 0.02511054f, 0.06428099f, -0.00105360f, 
    0.20832393f, 0.04469022f, 0.02422525f, -0.12026192f, 0.02953380f, 0.05000127f, 0.05878394f, -0.03221101f, 
    0.02523293f, 0.07903631f, 0.05506278f, 0.03335065f, 0.07613160f, 0.08473618f, -0.06104880f, -0.15206422f, 
    0.02220928f, 0.01283673f, -0.01509122f, -0.19942297f, 0.23230805f, -0.16162917f, -0.12672509f, -0.08365498f, 
    -0.07551395f, -0.11364383f, 0.00969280f, -0.07428531f, -0.10024366f, 0.08186557f, 0.01101035f, 0.14173926f, 
    -0.18551700f, 0.10094316f, 0.01743424f, -0.04616509f, -0.03238008f, -0.02516929f, -0.03304840f, 0.05654755f, 
    -0.10686425f, 0.02716619f, 0.01697767f, 0.04622320f, -0.08937068f, 0.08657344f, -0.17524043f, 0.09933471f, 
    -0.02085787f, 0.13503362f, 0.12146056f, 0.01394307f, -0.05882796f, -0.08144369f, -0.09424899f, -0.24097353f, 
    0.08783448f, 0.09623472f, -0.12927428f, -0.00462789f, 0.07119459f, 0.11828600f, -0.03733573f, 0.14551982f, 
    -0.11190514f, -0.04084388f, 0.01614098f, -0.01652190f, 0.43002352f, 0.29203770f, 0.01609118f, -0.14941810f, 
    -0.10145480f, 0.08835392f, 0.01192021f, 0.04940042f, 0.09357353f, 0.00171030f, -0.00153519f, 0.05603756f, 
    0.08136795f, -0.37585199f, 0.00903764f, 0.19053996f, -0.07476690f, -0.10757042f, -0.08524859f, 0.06049545f, 
    -0.00408490f, 0.13840754f, 0.16920094f, -0.04307881f, 0.33497903f, 0.07953157f, -0.11013101f, 0.20349801f, 
    -0.13714470f, 0.08006269f, -0.12594314f, -0.01774695f, 0.03847752f, -0.09750336f, 0.18909097f, -0.10336807f, 
    0.15164798f, -0.04149039f, -0.08302919f, 0.02724745f, 0.15643631f, 0.14031175f, 0.04860055f, 0.07258407f, 
    -0.00639275f, -0.01832464f, -0.06254480f, 0.01378252f, 0.12070122f, -0.06724533f, 0.08954902f, 0.06220720f, 
    -0.00945163f, 0.13054663f, -0.02526939f, -0.00677777f, -0.05348090f, -0.01802831f, 0.00956285f, -0.01724717f, 
    -0.48508003f, 0.04572873f, -0.12287351f, 0.40333474f, -0.06027412f, -0.00979666f, 0.06199748f, -0.12059286f, 
    -0.04532060f, -0.02730751f, -0.10738055f, -0.02934863f, 0.07643420f, 0.12023896f, -0.15618214f, -0.00456464f, 
    0.10679452f, 0.11920858f, -0.04188873f, 0.02378507f, -0.14760175f, 0.05525919f, -0.06173379f, -0.03049879f, 
    -0.21241273f, 0.00829220f, -0.15122128f, -0.02473020f, 0.00963015f, 0.05074116f, 0.09014836f, 0.14491232f, 
    0.18709308f, 0.07511279f, 0.05660699f, 0.31566441f, 0.07079563f, -0.06689984f, 0.17895976f, 0.20186858f, 
    -0.01093804f, 0.03274279f, 0.04991931f, -0.04470867f, -0.05499319f, -0.05928911f, 0.03542464f, 0.04906233f, 
    -0.10545973f, -0.10336576f, -0.04697052f, -0.12537742f, 0.13856471f, 0.00713644f, 0.04789571f, 0.10899068f, 
    -0.02524098f, 0.08688752f, -0.17174524f, -0.13130958f, -0.28492728f, -0.04142584f, -0.07724884f, -0.09020322f, 
    0.15272550f, 0.06430160f, 0.10345937f, -0.04693576f, 0.17013694f, -0.16773610f, 0.16410704f, 0.10941896f, 
    -0.05993148f, 0.24634033f, 0.08314699f, -0.00559823f, 0.03957268f, 0.05349741f, -0.12305318f, -0.05659932f, 
    -0.01106642f, -0.10190063f, -0.06320765f, -0.11927944f, 0.23073514f, -0.01351986f, -0.02624250f, -0.19799978f, 
    -0.04088316f, 0.08674720f, -0.02748750f, 0.02400798f, 0.04024393f, 0.08241659f, 0.13321239f, 0.07679625f, 
    0.06395152f, -0.07230794f, 0.11968224f, 0.24913329f, -0.06753021f, 0.00298683f, -0.15824670f, -0.01526571f, 
    -0.09586803f, 0.14853515f, 0.00520352f, 0.08073784f, -0.14565618f, -0.00908965f, -0.02653607f, 0.08003841f, 
    0.09999064f, 0.09341201f, 0.15050220f, 0.10400305f, -0.01761642f, -0.09813673f, -0.19269171f, -0.20082495f, 
    0.11627683f, 0.04312096f, -0.08746538f, 0.06551153f, -0.07340208f, -0.01347214f, -0.07621395f, 0.30021465f, 
    -0.02882381f, 0.02705350f, -0.00744227f, -0.00699300f, -0.29537979f, -0.14786825f, -0.27521378f, -0.30283633f, 
    0.08477340f, 0.00758053f, 0.05558694f, -0.12265466f, 0.13328601f, 0.02932288f, -0.05431754f, 0.07904311f, 
    0.02155664f, -0.15916649f, 0.19738762f, -0.15261613f, 0.05857351f, -0.09028460f, -0.12966186f, 0.00766755f, 
    0.04911003f, 0.09800883f, 0.08918602f, 0.00658238f, -0.24778818f, 0.17826347f, -0.03032786f, -0.09395815f, 
    0.10259637f, 0.08325154f, -0.03889717f, -0.00204269f, 0.07883658f, 0.04698332f, 0.10455544f, -0.05567268f, 
    -0.12226250f, 0.04928446f, -0.08507200f, -0.19672349f, 0.15436991f, 0.00811889f, -0.03835636f, -0.10050263f, 
    0.06604239f, 0.07780973f, 0.08517709f, -0.14185810f, 0.04819146f, 0.02908687f, 0.12634225f, 0.25109273f, 
    -0.00584494f, 0.08338092f, -0.03087091f, -0.06213537f, 0.03521583f, -0.02566122f, -0.00791598f, 0.14790024f, 
    -0.32687068f, 0.00997508f, -0.15688010f, 0.18667771f, 0.02685703f, -0.03774909f, -0.03946627f, -0.12338767f, 
    -0.09735911f, -0.15901408f, -0.09832209f, 0.08303485f, -0.18301906f, -0.14934966f, -0.10235117f, -0.13758326f, 
    0.16926886f, -0.01256896f, -0.11471964f, 0.06663173f, 0.03460325f, 0.11359342f, 0.24754119f, 0.07890826f, 
    -0.34054554f, -0.08828675f, 0.04633781f, 0.11353759f, -0.00529153f, 0.03072863f, -0.01460098f, 0.06191270f, 
    -0.06874014f, -0.01440054f, -0.14700234f, 0.03920133f, 0.05458917f, 0.03662429f, 0.14389141f, 0.32495105f, 
    -0.04215683f, 0.15033293f, -0.04117607f, 0.12782428f, -0.13816574f, 0.00471661f, -0.00460271f, 0.01968419f, 
    0.01868100f, -0.07178605f, -0.09823216f, -0.04720418f, 0.07769239f, -0.00960588f, 0.06275377f, -0.00364759f, 
    -0.03312597f, 0.14917225f, 0.10202742f, -0.03005227f, -0.23853999f, 0.08903188f, 0.00640915f, -0.00265548f, 
    0.00804154f, -0.01800329f, 0.01274715f, -0.05951091f, -0.07775694f, -0.11316440f, 0.05142676f, 0.15574272f, 
    0.28768945f, 0.15112078f, 0.02993321f, 0.22209992f, 0.07270987f, 0.11238575f, 0.09805208f, -0.06601365f, 
    -0.12022826f, -0.12430935f, 0.08318274f, 0.15772654f, 0.33263010f, 0.28003818f, 0.00819153f, 0.04122095f, 
    -0.02032390f, 0.18558069f, 0.07988606f, 0.02018932f, -0.00118014f, -0.17173512f, 0.11386287f, -0.14312440f, 
    0.08844397f, -0.04814353f, 0.05261906f, 0.21069786f, 0.07759158f, 0.14005661f, 0.10054702f, 0.03789546f, 
    -0.11466424f, 0.14627920f, 0.09989627f, 0.17987756f, 0.01709914f, -0.04028323f, 0.02883445f, -0.05582872f, 
    0.03960058f, -0.03130442f, -0.04526430f, 0.03228072f, 0.05827346f, 0.11322872f, -0.03360233f, 0.22167063f, 
    0.18656050f, -0.19102870f, 0.09839533f, -0.01824428f, -0.01006316f, -0.06514473f, 0.01954598f, 0.03193357f, 
    0.14800677f, -0.12117006f, 0.08696586f, 0.04737018f, -0.23543841f, -0.07361446f, -0.14248993f, 0.02786933f, 
    0.10432893f, 0.08392932f, 0.06529153f, -0.07261519f, 0.13631237f, -0.06774037f, 0.05753314f, 0.12401459f, 
    0.29797187f, 0.27375826f, 0.29975355f, -0.11269639f, -0.01455562f, 0.14606251f, -0.00007238f, -0.11714019f, 
    -0.01956554f, -0.09548128f, -0.06431724f, -0.04611448f, -0.03716771f, -0.18965408f, 0.12347788f, -0.01446291f, 
    0.07590097f, -0.06340878f, 0.06521261f, 0.14833276f, 0.13519040f, 0.07199632f, 0.04040532f, 0.03724620f, 
    -0.14850847f, -0.06398989f, -0.00283112f, -0.05780046f, 0.06885909f, 0.08181620f, -0.08944067f, -0.09300746f, 
    -0.02314175f, 0.05227762f, 0.15790531f, -0.04392523f, -0.08348137f, 0.26723126f, 0.20156404f, 0.23867449f, 
    0.04581964f, -0.02335026f, 0.05953424f, 0.15000416f, -0.00810320f, -0.05873053f, 0.07624947f, 0.03050396f, 
    0.40501890f, -0.17811728f, -0.14789581f, -0.19932066f, 0.02636535f, -0.05852207f, -0.09408192f, 0.14916982f, 
    0.14992084f, -0.09401574f, 0.00471467f, 0.02888829f, -0.15477797f, -0.11254606f, -0.03517762f, -0.10862746f, 
    0.03173709f, -0.04533094f, 0.05828887f, 0.12011674f, 0.04235322f, -0.01325743f, 0.01159170f, 0.03583271f, 
    -0.07038523f, -0.17871559f, 0.21554378f, -0.06175093f, -0.05153184f, -0.02646406f, -0.06308427f, 0.07943107f, 
    -0.07137374f, 0.05311669f, 0.02342167f, -0.03928040f, -0.17252864f, 0.29184708f, 0.00229273f, -0.24550882f, 
    0.15237893f, 0.02633426f, -0.04544097f, -0.06385724f, 0.04273087f, 0.06033593f, -0.01874285f, -0.14634466f, 
    0.05185980f, 0.09208518f, -0.03115895f, -0.12452810f, -0.08211656f, -0.04339189f, -0.08337974f, 0.03818466f, 
    0.07586370f, 0.05908022f, 0.04023834f, 0.02427008f, -0.05485682f, 0.12221505f, -0.05035344f, 0.06404670f, 
    0.12969692f, 0.01823695f, -0.10138370f, -0.03751545f, 0.04297094f, 0.13354540f, 0.05822765f, 0.09598272f, 
    0.42611971f, 0.00431401f, -0.09025581f, 0.16017690f, -0.00333509f, 0.01524835f, -0.03204932f, -0.10838879f, 
    0.02838050f, -0.00094604f, -0.05983773f, 0.10136222f, -0.11930931f, 0.13442834f, -0.00511529f, 0.09291852f, 
    -0.10516851f, 0.01645423f, 0.03819388f, -0.03122863f, 0.02236366f, 0.01258117f, 0.00839185f, -0.04034086f, 
    -0.40281656f, 0.01943617f, -0.14933595f, -0.11150518f, 0.03181401f, -0.04484503f, 0.05750595f, -0.06507638f, 
    0.06230505f, -0.01820059f, 0.01613315f, -0.13779236f, 0.11530674f, -0.18258201f, 0.03820347f, -0.31641009f, 
    0.07805307f, -0.02411331f, 0.06718826f, 0.06486597f, 0.11887793f, 0.00425386f, 0.07586721f, 0.00246563f, 
    0.30481786f, -0.05670229f, -0.01634510f, 0.18950723f, 0.13063577f, -0.03913591f, 0.10572078f, -0.15001540f, 
    0.09222029f, 0.03936228f, 0.11708066f, -0.03248353f, 0.49540347f, 0.18165211f, 0.12506242f, 0.17188464f, 
    -0.17398098f, 0.05112676f, 0.02664666f, 0.19482496f, -0.03261293f, -0.02943687f, 0.00906839f, 0.13000123f, 
    0.10416788f, 0.01227276f, 0.06309894f, 0.22609916f, 0.05373228f, 0.09132136f, 0.05053962f, -0.06901861f, 
    -0.00786315f, 0.03725187f, 0.00982234f, -0.06239318f, 0.33739465f, -0.15769511f, 0.04812389f, -0.05380466f, 
    -0.12054288f, 0.08600645f, -0.00452039f, 0.02666892f, 0.03446259f, 0.11209086f, -0.13495663f, -0.00257325f, 
    -0.06317148f, -0.13715391f, 0.11589934f, 0.16043676f, -0.13191837f, 0.05760492f, -0.05268104f, 0.10922351f, 
    -0.10990543f, -0.04719225f, -0.10413186f, 0.16694258f, 0.08523594f, 0.14946853f, 0.07528345f, -0.09682436f, 
    0.05109757f, -0.03651242f, -0.03945632f, -0.04258857f, 0.05765970f, 0.05808693f, 0.05531613f, 0.05565431f, 
    0.06294090f, 0.07512747f, -0.09100185f, -0.03566060f, -0.02357271f, 0.04170357f, 0.03506847f, 0.07513317f, 
    -0.02243377f, -0.11242859f, -0.02025084f, 0.02724912f, -0.00799873f, -0.20457865f, -0.15017112f, -0.17073645f, 
    -0.03775841f, 0.03161144f, 0.17267424f, -0.04596303f, 0.02718035f, -0.15056936f, -0.06459222f, -0.01605022f, 
    0.06402199f, 0.13800062f, 0.22175977f, -0.11866540f, 0.19352560f, -0.14136615f, 0.09068797f, 0.02876635f, 
    0.02813903f, 0.04057116f, 0.04948418f, 0.07948947f, -0.15450105f, 0.08964320f, -0.10788827f, -0.20496517f, 
    0.12084523f, -0.07675961f, -0.13449512f, -0.13968533f, 0.12623835f, -0.02418993f, 0.15898016f, -0.05868442f, 
    0.11344125f, 0.03216164f, 0.08813906f, 0.00300031f, -0.11958606f, 0.25777841f, -0.04855909f, 0.10414581f, 
    0.12754771f, 0.02348606f, -0.24888512f, 0.04757778f, -0.21916194f, 0.12236078f, 0.16441511f, 0.21469122f, 
    0.07892525f, 0.00501112f, 0.09178545f, -0.03187761f, 0.02284416f, 0.08513062f, 0.20938511f, 0.04157570f, 
    0.16030690f, -0.09108069f, -0.14015707f, -0.05510924f, 0.06023171f, 0.14555255f, -0.07246726f, -0.12597135f, 
    -0.00263735f, 0.02256765f, 0.03039659f, -0.10715324f, 0.06615169f, 0.00209035f, 0.01248361f, 0.16074729f, 
    -0.06138837f, -0.10165448f, -0.13425809f, -0.14991355f, 0.13718905f, -0.00174920f, 0.02796435f, 0.22044376f, 
    -0.52890831f, -0.06431130f, 0.01549708f, -0.17579256f, 0.01672217f, -0.20238344f, -0.08844108f, -0.16535713f, 
    0.13852152f, 0.04104047f, 0.07656209f, -0.00168000f, -0.13233759f, 0.11039738f, 0.05517888f, 0.03365966f, 
    0.06110001f, 0.01562174f, 0.11861049f, 0.02875997f, -0.06051936f, -0.14702784f, 0.00358467f, -0.05867168f, 
    0.16487652f, -0.01956708f, -0.19208053f, -0.00177826f, 0.10875655f, 0.09598641f, -0.00985422f, 0.15365978f, 
    -0.06523918f, -0.00313623f, 0.04754785f, -0.10615192f, 0.26183718f, 0.04695071f, 0.15610245f, 0.21045665f, 
    -0.16842097f, 0.00102669f, 0.16493255f, 0.07964737f, 0.08723555f, 0.08929290f, -0.01726746f, -0.05077060f, 
    -0.41705754f, -0.03993510f, -0.12865645f, 0.02730954f, 0.05112175f, -0.16504562f, 0.02849299f, 0.10177296f, 
    0.08544156f, 0.08016358f, 0.24795116f, -0.06841831f, 0.22750165f, -0.06805146f, 0.08707783f, -0.06842135f, 
    -0.12203083f, -0.10386321f, 0.04871972f, 0.14983289f, -0.06389163f, 0.00192793f, 0.00571623f, -0.14978532f, 
    0.03358602f, 0.01357566f, 0.13094792f, 0.12781134f, -0.02249776f, 0.04981169f, 0.02620581f, 0.07948796f, 
    0.03952614f, 0.04433113f, 0.03027694f, 0.04981763f, 0.13012668f, -0.04330393f, -0.07304703f, -0.13611464f, 
    0.14788823f, 0.09374211f, -0.01658751f, -0.12918396f, 0.03385184f, -0.09412589f, 0.01190645f, 0.10459434f, 
    -0.26283458f, -0.10986730f, 0.11841332f, -0.02820672f, 0.06750337f, -0.33587727f, -0.04113220f, -0.04498126f, 
    -0.03827590f, 0.00875538f, 0.00008212f, 0.14901175f, 0.31080669f, -0.09991966f, -0.02078274f, 0.05283437f, 
    -0.01218840f, -0.00870882f, -0.12928852f, 0.05413815f, -0.02496148f, 0.08345318f, 0.08025073f, 0.00344034f, 
    -0.07283369f, 0.00127926f, 0.14144686f, -0.09480773f, -0.06088777f, -0.12552840f, -0.05104874f, 0.09476325f, 
    0.04243761f, -0.08110132f, 0.08579947f, 0.11124864f, 0.08380861f, -0.05747959f, -0.10691916f, 0.16399986f, 
    0.01656585f, 0.01431411f, 0.03242990f, 0.03521064f, -0.01162604f, 0.01451873f, 0.01551533f, -0.11278770f, 
    -0.06549056f, 0.19071820f, 0.10410575f, -0.13882592f, -0.01260569f, 0.06734642f, 0.04406780f, -0.00196828f, 
    -0.01589538f, 0.11996971f, -0.06450783f, -0.04239459f, -0.02798947f, 0.23299681f, 0.24498071f, 0.02269764f, 
    0.04456801f, 0.01388497f, -0.01987934f, 0.07257771f, 0.11069405f, -0.10284600f, 0.02163032f, -0.03190056f, 
    0.19625477f, 0.00457949f, 0.06897067f, 0.03291003f, -0.01610400f, 0.04894274f, 0.02010158f, 0.06204049f, 
    0.06907122f, 0.00889900f, 0.10337196f, -0.13899660f, 0.45139790f, 0.01094418f, -0.10421456f, -0.09976911f, 
    -0.03023406f, -0.07056020f, -0.04528244f, -0.02281528f, -0.16088499f, 0.09363631f, -0.05865480f, 0.01199495f, 
    -0.13175358f, -0.17971116f, -0.18738586f, 0.00625156f, 0.02648380f, -0.10925890f, 0.06503616f, 0.03143279f, 
    0.05197151f, 0.10891610f, -0.13752830f, 0.00084339f, -0.03254884f, -0.13715969f, -0.06767620f, -0.05177152f, 
    -0.02677169f, 0.02458218f, 0.06671972f, -0.05462006f, -0.07204028f, -0.15629488f, -0.14788890f, -0.09458671f, 
    0.31128743f, 0.02222845f, 0.03110926f, 0.02458682f, -0.06666890f, 0.01825820f, 0.07246617f, -0.03570194f, 
    0.01351035f, -0.01025359f, -0.13097073f, -0.04812784f, 0.13030678f, 0.22879472f, 0.12942994f, 0.10402565f, 
    0.02448163f, 0.04962007f, -0.00611768f, 0.01551564f, 0.10967226f, -0.01633502f, 0.16089244f, -0.04556808f, 
    0.28532308f, -0.28321779f, -0.00454545f, 0.36556378f, 0.02105805f, -0.08051642f, -0.02609073f, -0.03024538f, 
    0.01573873f, 0.08145896f, 0.03205025f, -0.01614616f, -0.01814848f, -0.01626525f, 0.09701943f, 0.00993201f, 
    -0.01388715f, 0.08430462f, 0.04528087f, -0.01797627f, -0.03058874f, 0.00882459f, 0.13876280f, -0.11040271f, 
    0.06308569f, -0.05713898f, 0.00936007f, 0.00901788f, 0.06390444f, 0.11416608f, -0.08678515f, -0.00296087f, 
    -0.01652901f, -0.09904535f, 0.04777018f, 0.09334551f, 0.29522952f, 0.01083910f, 0.09332559f, 0.14800702f, 
    0.08459564f, 0.09389975f, -0.01146329f, -0.07239718f, -0.04143536f, -0.05440462f, -0.10022683f, 0.02520234f, 
    -0.23988228f, -0.02240379f, -0.16940272f, -0.05092433f, -0.14424285f, -0.17643026f, -0.09862467f, -0.10319301f, 
    -0.08225925f, 0.07969652f, -0.06601755f, 0.04142731f, 0.04911003f, 0.10127643f, 0.05215009f, 0.03768352f, 
    0.01207257f, 0.03027717f, -0.11910569f, -0.00367337f, 0.01524220f, -0.01214607f, 0.10602453f, 0.01140101f, 
    -0.07750399f, 0.11124555f, 0.06924880f, 0.08131468f, 0.04279660f, 0.09815004f, -0.00907387f, -0.00451670f, 
    -0.02989603f, 0.00711203f, -0.13711636f, -0.08124863f, 0.06797554f, -0.02973826f, -0.19852702f, -0.05706954f, 
    0.05343360f, 0.16415164f, -0.01511234f, 0.12750371f, 0.05637056f, 0.00581853f, -0.08865724f, 0.11528178f, 
    0.15371515f, -0.06778659f, -0.07317271f, 0.14427002f, -0.03745395f, -0.06622917f, 0.01327761f, 0.08804796f, 
    -0.02124732f, 0.00659020f, 0.06850003f, 0.11150886f, 0.01523694f, -0.03695600f, -0.05464046f, 0.03643029f, 
    -0.19937858f, -0.05150668f, -0.08707859f, 0.01474940f, -0.12791282f, 0.08720835f, 0.05599190f, 0.11978503f, 
    -0.12687054f, -0.14590509f, 0.00864483f, -0.10953230f, -0.02540006f, 0.00576983f, 0.01931172f, 0.02216335f, 
    -0.03007592f, 0.00728152f, 0.10193918f, 0.24377719f, -0.20898364f, 0.12663785f, 0.15677679f, 0.16252124f, 
    0.10670404f, 0.13664396f, 0.02542522f, 0.13031861f, 0.03941940f, -0.00124420f, -0.04510660f, -0.12928055f, 
    0.00876133f, -0.10576129f, 0.02483505f, -0.03894011f, 0.00022115f, 0.12239280f, 0.03034383f, 0.02942711f, 
    -0.05529798f, 0.03487443f, 0.00682918f, 0.07827196f, 0.11196271f, -0.05223481f, 0.04617869f, 0.10950456f, 
    0.08822359f, 0.01493752f, -0.00910552f, 0.00942231f, -0.06188207f, 0.04690220f, 0.21025863f, 0.19318666f, 
    -0.10278776f, -0.03738724f, 0.10901069f, -0.11820570f, 0.06471608f, 0.06635643f, 0.02077529f, -0.09857014f, 
    0.02586738f, 0.02300571f, -0.03122733f, 0.02504285f, -0.13204157f, -0.49101251f, -0.07363547f, 0.02209446f, 
    0.16346057f, 0.04940982f, -0.13847126f, 0.04534825f, -0.10718642f, -0.02880742f, -0.04140962f, 0.06635650f, 
    -0.25038412f, 0.47666135f, -0.03487138f, -0.43677801f, 0.12663653f, 0.04546560f, -0.05598525f, -0.05434575f, 
    0.01285670f, -0.01909796f, 0.06458513f, 0.00114161f, 0.06007188f, -0.13148496f, 0.08891094f, -0.03028422f, 
    0.04943640f, -0.09759112f, 0.01698074f, 0.09300156f, 0.00560958f, 0.12429350f, -0.10405889f, 0.11690742f, 
    -0.03153922f, -0.12231597f, -0.02046406f, 0.01365716f, -0.03400370f, -0.08101697f, 0.08935191f, -0.07185126f, 
    0.01432991f, 0.06043582f, 0.09512456f, -0.04784748f, -0.25223446f, 0.12690470f, -0.16468190f, -0.12596610f, 
    0.22874753f, -0.07262602f, 0.04041344f, 0.12545139f, 0.04077031f, 0.02972410f, 0.06274196f, -0.03399665f, 
    0.50831562f, 0.09022070f, 0.06671065f, -0.12849380f, 0.10045509f, 0.01936634f, 0.02582781f, 0.15490669f, 
    0.07408399f, 0.05462769f, 0.16576263f, 0.10808807f, -0.17149296f, -0.17061806f, 0.03101058f, 0.02520650f, 
    -0.10217944f, -0.02083921f, 0.14339195f, 0.04373783f, 0.06078923f, 0.04164809f, -0.01979792f, 0.05570945f, 
    -0.06740716f, 0.05309116f, 0.01540959f, 0.04046820f, 0.01212620f, -0.05438918f, 0.05809933f, -0.05279706f, 
    0.03263228f, -0.00370769f, 0.01292358f, -0.05108963f, -0.05729641f, 0.01970296f, -0.04773786f, -0.00578798f, 
    -0.07159625f, 0.06686496f, -0.01361973f, -0.01132002f, -0.01164398f, 0.05132148f, 0.05680773f, -0.01324766f, 
    -0.03492954f, -0.01405367f, -0.00096006f, 0.02277026f, -0.07081342f, 0.01797797f, -0.01935909f, -0.03161765f, 
    -0.05391058f, 0.06555793f, 0.03447406f, 0.04633133f, -0.01613328f, 0.02185454f, -0.01666956f, -0.03030774f, 
    0.00704778f, -0.02350363f, -0.02741246f, 0.04765953f, -0.06815857f, -0.06797291f, -0.02564814f, 0.03378294f, 
    -0.02680504f, 0.03970172f, -0.03305223f, -0.06926608f, -0.04975791f, -0.00700524f, -0.04168123f, 0.02147037f, 
    0.01018198f, 0.02132534f, 0.02025576f, -0.03464590f, -0.06477656f, 0.02623830f, -0.05695191f, -0.04193918f, 
    0.04738812f, 0.05140769f, -0.00050316f, 0.02933353f, 0.02957160f, -0.00701452f, -0.06808443f, 0.04825144f, 
    0.03088088f, -0.06021486f, -0.01334378f, 0.06879684f, -0.06495380f, -0.05201428f, 0.04831038f, -0.00076580f, 
    0.06860328f, -0.00096888f, -0.05176628f, 0.02974870f, -0.01945575f, -0.01116118f, -0.04642241f, -0.03018241f, 
    -0.06916134f, 0.00730075f, -0.01857982f, -0.02596362f, -0.04819652f, 0.04892468f, 0.04061997f, -0.03942061f, 
    -0.06412732f, 0.01823509f, 0.04854429f, 0.04468913f, -0.03594979f, 0.06670977f, -0.05283052f, 0.01543107f, 
    0.06239685f, -0.06915468f, -0.01056134f, -0.06947783f, 0.03394875f, -0.05530281f, 0.07091851f, -0.05764787f, 
    -0.06973202f, -0.05978029f, 0.01712676f, -0.05452292f, -0.06147391f, -0.00915904f, -0.01337298f, -0.05698214f, 
    -0.00179961f, -0.00476364f, 0.06443258f, 0.03583925f, -0.04432762f, 0.02461028f, -0.06774521f, 0.04292360f, 
    0.03276142f, -0.02567953f, 0.05742911f, -0.04621499f, -0.00015148f, -0.06511591f, -0.05594087f, 0.06715066f, 
    0.02769227f, 0.03989478f, -0.05807898f, 0.00338757f, -0.02531254f, -0.00147915f, -0.05612483f, 0.04070085f, 
    -0.04789801f, -0.04685631f, 0.02731905f, -0.01437882f, 0.02363234f, -0.02070279f, 0.04243351f, -0.00043394f, 
    -0.04712276f, -0.01409370f, -0.00003573f, -0.00507177f, -0.05852854f, 0.03873358f, -0.01525852f, -0.05944329f, 
    0.03786445f, 0.04886915f, -0.06498150f, -0.04091781f, -0.05208433f, 0.06160839f, 0.02883184f, 0.04313518f, 
    -0.04951007f, -0.05019915f, -0.00627437f, 0.05944325f, -0.01533909f, 0.06655346f, -0.02820578f, -0.01548968f, 
    0.05683340f, 0.02973651f, -0.01991603f, 0.00928152f, -0.05701400f, -0.05789240f, -0.06182866f, -0.04630469f, 
    -0.05593371f, -0.02861055f, -0.03799137f, -0.03498976f, 0.06721105f, -0.06105965f, -0.00742237f, 0.00860506f, 
    -0.05373161f, 0.22140354f, -0.17519625f, -0.13986413f, 0.11394326f, -0.08434083f, 0.15603839f, 0.07789185f, 
    0.13160843f, 0.02462579f, 0.03437725f, 0.22018062f, 0.16562656f, -0.00578191f, 0.06638402f, 0.18401465f, 
    -0.13402598f, -0.05428148f, 0.06070668f, -0.03731768f, 0.14353544f, 0.04173453f, 0.13095810f, 0.06170313f, 
    -0.14803699f, -0.07612962f, 0.11530911f, -0.11758988f, 0.00612389f, 0.06872124f, -0.06421667f, -0.00326273f, 
    0.13681804f, -0.03024716f, 0.07368533f, -0.00978842f, 0.07098700f, -0.09067611f, -0.05800198f, 0.05233812f, 
    0.04194247f, 0.09796332f, 0.00306120f, -0.05063263f, 0.00209167f, 0.08594665f, -0.02787874f, 0.05975606f, 
    -0.08881181f, 0.11435059f, -0.08754236f, -0.06182728f, -0.00076551f, 0.08594351f, -0.07532734f, -0.03692099f, 
    -0.02351738f, -0.03479434f, -0.01067644f, -0.06357785f, -0.07251361f, 0.10993564f, -0.12256658f, 0.31580803f, 
    0.01925603f, -0.00246153f, -0.05875509f, -0.01741820f, 0.02361115f, -0.03936324f, 0.04680062f, 0.02444167f, 
    -0.03269355f, 0.16630614f, 0.05973964f, -0.04907866f, -0.12761883f, -0.04173161f, -0.01079224f, -0.08652861f, 
    0.03631673f, 0.06824265f, 0.02232392f, 0.05324339f, -0.01286647f, -0.08062606f, -0.07815006f, -0.05565163f, 
    -0.08081917f, 0.09025436f, 0.03873846f, 0.01856929f, -0.03394822f, -0.06978767f, -0.13884541f, -0.03419289f, 
    -0.20947175f, 0.26853159f, 0.04762827f, 0.04759589f, 0.08339894f, 0.06893852f, -0.01201386f, 0.18136588f, 
    0.00972399f, -0.00938654f, 0.02140591f, 0.08068181f, -0.27945971f, -0.31818140f, -0.10680211f, -0.02948234f, 
    0.03976838f, 0.05984762f, 0.08394948f, -0.13536748f, -0.04872021f, 0.09238626f, -0.05719103f, -0.04898371f, 
    0.24632215f, -0.09666506f, 0.23202024f, -0.16041864f, -0.11217471f, -0.10650117f, -0.11515674f, 0.12188499f, 
    0.07608956f, 0.02602924f, 0.12032977f, 0.02267932f, -0.01524782f, -0.10831305f, 0.03891255f, -0.02408524f, 
    0.05449614f, 0.00411611f, 0.01349921f, -0.01020825f, 0.02349240f, -0.03970103f, 0.05750253f, 0.10265609f, 
    0.10333688f, 0.02278640f, 0.11909790f, -0.20833543f, 0.07535473f, -0.00361729f, -0.07492089f, 0.10278312f, 
    0.00388921f, 0.05290256f, -0.07811689f, -0.05402406f, 0.30393797f, 0.03070760f, 0.03889588f, 0.01086936f, 
    -0.07552780f, 0.06144995f, 0.11919926f, 0.02221369f, 0.16411421f, 0.00049983f, 0.01206876f, -0.02814325f, 
    -0.28556615f, -0.35017070f, 0.21545821f, -0.03895285f, 0.01304568f, -0.07768151f, -0.03096694f, 0.00236916f, 
    -0.03019354f, 0.04813036f, -0.07386906f, 0.04068419f, -0.06091616f, -0.01375666f, -0.03318252f, -0.06489570f, 
    -0.05539222f, 0.12851845f, -0.09287494f, -0.01842701f, -0.06651156f, 0.18869640f, 0.01317742f, 0.03988476f, 
    0.02720354f, -0.08047390f, 0.03165977f, 0.03688717f, 0.00096319f, 0.02751307f, 0.00688334f, 0.01871304f, 
    -0.02905938f, 0.01539401f, 0.03126669f, -0.04497754f, -0.05545446f, -0.02563524f, -0.07135700f, 0.02527651f, 
    -0.06300753f, -0.02122440f, 0.03655672f, 0.04045272f, -0.02104021f, 0.06125477f, 0.05224066f, 0.04657639f, 
    0.04813037f, -0.05101251f, 0.01985765f, -0.02904972f, -0.04943561f, -0.02769857f, -0.01931740f, 0.00676452f, 
    0.05345472f, 0.04585623f, -0.03612471f, -0.05825964f, -0.01151988f, -0.07236309f, 0.00367558f, 0.00509521f, 
    -0.05330002f, -0.05465021f, 0.05497944f, -0.05363657f, 0.03235018f, -0.01036653f, 0.05141255f, 0.00056056f, 
    -0.01839496f, 0.04411945f, 0.01876083f, 0.06171172f, 0.02142894f, 0.00820955f, 0.02215367f, 0.02195976f, 
    0.04584346f, -0.03520674f, 0.02069876f, -0.02976823f, 0.05776653f, -0.03933560f, -0.00593658f, -0.06684738f, 
    -0.06682754f, -0.00341730f, 0.05319867f, 0.03967981f, -0.06827694f, -0.00170521f, 0.03261431f, 0.06301858f, 
    0.06229595f, 0.07610629f, -0.05761397f, -0.07157689f, 0.06186320f, -0.01986710f, -0.04273210f, -0.01197343f, 
    -0.00357892f, -0.03128142f, -0.03474899f, -0.05901562f, 0.03869564f, -0.02550799f, -0.06732743f, -0.05088121f, 
    0.01453798f, -0.02669885f, -0.00322607f, -0.01881657f, 0.04473372f, -0.05098535f, 0.01209829f, -0.06821135f, 
    -0.03168277f, -0.00740051f, -0.04051260f, -0.01184957f, -0.07535768f, -0.07279608f, -0.03553692f, -0.00878698f, 
    0.01756613f, -0.06927127f, -0.01985186f, -0.03668126f, 0.05081373f, 0.03665087f, -0.01340736f, -0.00325236f, 
    0.05557724f, 0.02390497f, 0.01961747f, -0.07903238f, -0.07148097f, -0.01047490f, 0.03086163f, -0.00763783f, 
    0.02833175f, -0.00437457f, -0.00582750f, 0.05923685f, -0.03689050f, 0.01484126f, 0.02798316f, -0.04686355f, 
    -0.00456510f, 0.05376625f, 0.01354445f, 0.06228683f, -0.03217656f, 0.03069430f, -0.01668078f, 0.03277831f, 
    0.02262844f, -0.02661010f, 0.03859600f, -0.06439121f, -0.04965068f, -0.05958063f, -0.06776165f, 0.00489157f, 
    -0.06323785f, -0.03110254f, -0.01968748f, 0.05396505f, 0.05087272f, -0.07031107f, -0.02472683f, -0.04551641f, 
    -0.06465661f, -0.06210658f, 0.07188116f, -0.05408806f, 0.06344714f, -0.00157362f, -0.07320552f, 0.01082440f, 
    -0.06067445f, -0.01899293f, 0.03466275f, -0.04346453f, -0.07283757f, -0.06078697f, -0.04136974f, 0.00020861f, 
    0.03670973f, -0.01212656f, -0.07843232f, 0.05747886f, 0.06228431f, -0.02691160f, -0.06822593f, 0.05276357f, 
    -0.05665917f, -0.03914372f, -0.01380971f, -0.05550576f, -0.03851002f, 0.03772843f, 0.05199651f, 0.00950422f, 
    -0.04773472f, -0.06529879f, -0.02093251f, 0.04267973f, -0.07303640f, -0.07322278f, -0.06846148f, 0.01405161f, 
    0.05755151f, 0.04359040f, -0.07365748f, -0.01023530f, -0.01392223f, -0.01583058f, -0.02163281f, -0.04505930f, 
    -0.08000194f, -0.03696959f, -0.03208803f, 0.03953134f, 0.00794363f, 0.04422385f, 0.06689565f, -0.03933291f, 
    0.02648397f, 0.06983928f, -0.01317255f, 0.03726265f, 0.06028895f, -0.00699071f, -0.03107229f, 0.00141150f, 
    -0.00163037f, -0.02663771f, 0.05127067f, 0.05219876f, 0.02049429f, -0.04375991f, 0.00993499f, -0.00113724f, 
    0.04495038f, 0.01816132f, -0.02205161f, -0.03425237f, 0.05494656f, -0.02592718f, 0.00533496f, 0.02095566f, 
    0.06248246f, -0.03079876f, -0.00091908f, -0.00017467f, -0.03910888f, 0.01249703f, 0.02863324f, 0.05058853f, 
    0.01820552f, -0.04486039f, 0.03147936f, -0.01249146f, 0.02472741f, -0.03657844f, 0.00727965f, 0.03901396f, 
    -0.05144677f, -0.07076812f, -0.02168668f, -0.05362218f, -0.02817673f, 0.03632680f, 0.02505015f, -0.06938035f, 
    -0.05614576f, -0.02718414f, -0.07299905f, 0.05868319f, -0.08218367f, -0.05446722f, -0.08100942f, -0.06750205f, 
    0.08074549f, 0.03078396f, -0.01119363f, 0.02130986f, -0.01257364f, 0.03127226f, -0.06306285f, -0.03317212f, 
    -0.01155791f, -0.05710756f, -0.04979124f, 0.04620652f, -0.07946667f, -0.02870028f, 0.03988714f, -0.03223915f, 
    -0.06954072f, -0.04914822f, -0.05348684f, 0.00623484f, 0.00674118f, -0.04928067f, -0.02663241f, 0.00683251f, 
    -0.03891528f, 0.04209849f, 0.05646086f, 0.03866145f, -0.03181623f, -0.05069486f, 0.01286134f, 0.05394316f, 
    0.03601868f, -0.06655540f, 0.04523305f, -0.03558104f, -0.01380561f, -0.04664754f, 0.02960785f, -0.04021731f, 
    -0.07450952f, -0.04642256f, 0.05728930f, -0.03450818f, -0.03226733f, 0.06484243f, -0.04421136f, -0.07794292f, 
    -0.02477571f, -0.00419868f, -0.01910723f, -0.03147773f, 0.00126692f, 0.00849225f, 0.03521687f, -0.02600199f, 
    -0.02560731f, -0.07990626f, -0.03062797f, 0.05215025f, 0.04166783f, 0.02713258f, 0.03527334f, -0.07758118f, 
    -0.03765514f, -0.06419893f, -0.03116196f, -0.05548266f, -0.05374841f, -0.02638583f, 0.05555675f, 0.01895219f, 
    -0.05386969f, -0.05217280f, 0.03084079f, 0.04189054f, -0.05545420f, 0.00734910f, -0.05116126f, 0.03545433f, 
    0.05753988f, 0.03955983f, 0.02578283f, -0.06749251f, 0.00963868f, -0.03972644f, -0.05974636f, 0.03842718f, 
    0.00632307f, 0.04334076f, -0.07264604f, 0.01338173f, 0.04108291f, 0.02640374f, -0.02324192f, 0.01919200f, 
    0.02376755f, -0.01701472f, -0.04506404f, -0.00902295f, -0.06471113f, -0.06705245f, -0.01960892f, -0.07057407f, 
    -0.03032675f, 0.04879970f, -0.02724149f, 0.06065121f, -0.06490910f, -0.04320906f, -0.02790882f, -0.00923800f, 
    0.06890708f, -0.01245698f, 0.04391177f, 0.01469602f, -0.07181138f, -0.00835067f, -0.04344971f, -0.06168306f, 
    -0.01713747f, 0.04165078f, 0.01347776f, -0.04787325f, -0.03772860f, -0.01047618f, 0.04149267f, 0.04091362f, 
    -0.08266409f, -0.01569538f, 0.02984642f, 0.03602220f, -0.02971466f, -0.02612924f, -0.03104042f, -0.04401418f, 
    0.00691559f, 0.05310995f, 0.01452006f, -0.05971456f, -0.02887734f, -0.05700035f, 0.03526723f, -0.04738559f, 
    0.05549223f, 0.04553049f, -0.02945682f, 0.04450182f, 0.05233976f, 0.04350648f, -0.07003663f, 0.04197904f, 
    0.06136218f, 0.03884094f, 0.01913414f, 0.06039455f, -0.00964623f, 0.04310313f, -0.04439745f, 0.05590414f, 
    0.02296929f, 0.00310870f, -0.00426342f, 0.02897939f, -0.02880822f, 0.02129875f, 0.05508124f, -0.06324006f, 
    -0.05321247f, -0.04185256f, -0.01898246f, 0.00539742f, -0.00588730f, -0.01255086f, 0.04937743f, -0.00371626f, 
    -0.03088345f, 0.05959429f, 0.04155536f, 0.00892748f, 0.03780260f, -0.02229253f, 0.03481352f, -0.01704796f, 
    0.05644325f, -0.00824837f, -0.08212474f, -0.01337828f, -0.05029874f, 0.00390613f, -0.02241179f, -0.06209671f, 
    -0.00183729f, 0.05519607f, -0.07140733f, -0.03222142f, -0.02928344f, -0.03908404f, 0.02076569f, -0.06780824f, 
    0.05036712f, 0.03544838f, -0.03145180f, 0.01480314f, -0.03620356f, -0.04692602f, -0.04727354f, 0.04807353f, 
    0.04316925f, 0.03868503f, -0.02830415f, 0.00417571f, -0.05451528f, 0.03006044f, 0.06690303f, 0.05739812f, 
    0.05956209f, -0.06981909f, -0.00713422f, -0.04545221f, -0.01789287f, -0.01791142f, -0.03768937f, 0.04181295f, 
    -0.05532098f, -0.06840692f, 0.01066036f, -0.07439913f, -0.00781211f, 0.01418291f, 0.01084822f, -0.03426988f, 
    0.02545923f, -0.06445228f, -0.04066112f, -0.02906037f, 0.01471701f, -0.02409247f, -0.05794599f, -0.03092884f, 
    0.02623734f, -0.03107533f, -0.08231258f, 0.01926926f, -0.01979846f, 0.03397908f, -0.06736691f, 0.02297601f, 
    -0.04246650f, -0.04352565f, -0.04233777f, -0.00310974f, -0.05009873f, 0.00175674f, -0.04915089f, -0.04623445f, 
    -0.00448485f, -0.05934021f, 0.02375253f, -0.04996062f, -0.02009696f, -0.00560826f, 0.04226238f, -0.00649490f, 
    0.05369632f, -0.03908450f, -0.00008264f, -0.03556495f, -0.00836989f, 0.00795925f, -0.05583645f, -0.03243458f, 
    -0.00741861f, -0.04325293f, -0.01506511f, 0.05394094f, -0.07564925f, 0.02541325f, -0.05622828f, 0.02749905f, 
    -0.02772339f, -0.06626094f, -0.00108418f, -0.02161218f, -0.06042107f, -0.05976905f, 0.02111110f, -0.01453535f, 
    -0.05661980f, -0.05044493f, 0.04160202f, 0.05156371f, 0.04552918f, 0.01846408f, -0.01679237f, -0.00685863f, 
    -0.07249659f, 0.03593400f, 0.01006620f, -0.01943997f, -0.03734976f, 0.01738099f, 0.02293120f, 0.01246750f, 
    -0.05614221f, -0.03442334f, -0.02974026f, -0.02059881f, -0.01445897f, -0.02551623f, -0.01126078f, 0.01691825f, 
    0.17824964f, -0.06557640f, -0.03002059f, 0.09264871f, 0.01837402f, 0.14021693f, 0.01481915f, 0.02515841f, 
    -0.08798010f, 0.00490478f, -0.02274647f, -0.16294762f, -0.00402910f, -0.02815797f, -0.03783081f, 0.22770120f, 
    -0.00396023f, -0.02413171f, -0.16661680f, 0.04042157f, 0.01785930f, 0.00299463f, -0.00381222f, 0.03499383f, 
    -0.25309038f, -0.09870164f, 0.08058681f, 0.18762475f, 0.01783069f, 0.06054467f, 0.11885491f, 0.01672593f, 
    -0.06931414f, -0.10282744f, 0.14394234f, 0.16753376f, 0.27809179f, 0.05280484f, 0.02885416f, 0.16328403f, 
    0.00864045f, -0.01615688f, 0.13700408f, 0.19297692f, 0.06462781f, -0.06981900f, -0.11873004f, -0.03774547f, 
    -0.12196863f, -0.02039536f, -0.11862756f, -0.18148966f, -0.05520351f, -0.16283047f, 0.05592855f, 0.11030480f, 
    0.06065267f, 0.06265661f, 0.06097777f, 0.02075787f, 0.19333768f, -0.01911636f, 0.03083984f, -0.04950129f, 
    0.00655042f, 0.00062935f, -0.03313221f, -0.15151639f, -0.08165995f, -0.04295688f, -0.00139893f, -0.07102684f, 
    0.25107735f, -0.07750235f, -0.05034398f, 0.09580948f, 0.05090453f, -0.03544107f, -0.07594083f, -0.12560138f, 
    0.28217918f, -0.06062867f, 0.00639904f, -0.02699105f, -0.10215976f, 0.05552882f, 0.18360749f, -0.25858030f, 
    -0.05032495f, 0.06246184f, -0.09618756f, 0.00947595f, -0.03922965f, 0.13827699f, -0.07060605f, 0.09175239f, 
    0.00771836f, -0.13599883f, -0.06225393f, 0.03289462f, -0.00911149f, 0.00749795f, 0.02353834f, -0.10715926f, 
    0.09128013f, 0.08517357f, -0.08037318f, -0.01448910f, -0.29704154f, 0.29166549f, 0.16101974f, 0.11151823f, 
    0.11673659f, -0.03204039f, 0.13108806f, 0.03192614f, -0.03797828f, -0.17676471f, 0.09690316f, -0.01955201f, 
    0.11587854f, -0.21491943f, -0.18537652f, 0.21626309f, 0.14079455f, 0.00053461f, 0.06035685f, 0.03613392f, 
    -0.07805272f, -0.09754093f, -0.05124951f, 0.03879724f, -0.48201728f, 0.32872263f, -0.02593570f, -0.03814228f, 
    0.09783179f, 0.03739227f, -0.01717973f, -0.04526259f, -0.03330231f, 0.06093186f, -0.07993390f, -0.01634520f, 
    0.06092734f, 0.02718164f, -0.04027200f, 0.32554722f, -0.03977294f, -0.12954201f, 0.01986206f, 0.07792274f, 
    0.01869643f, 0.05250284f, -0.02733364f, 0.06163691f, 0.25844514f, -0.04755131f, -0.02303891f, -0.09231386f, 
    -0.04159936f, -0.17799321f, -0.09381479f, -0.07430755f, 0.06542446f, -0.05297360f, -0.03238850f, -0.05122840f, 
    -0.18133406f, -0.02868111f, 0.21785203f, -0.16757713f, 0.01450948f, -0.01495777f, -0.05571853f, 0.05501733f, 
    -0.03651695f, 0.21142979f, 0.06833057f, 0.09578931f, 0.17787276f, 0.17832577f, 0.28952771f, 0.20638217f, 
    0.11790750f, 0.02620680f, 0.00086180f, 0.07025307f, 0.13803346f, -0.08322708f, 0.06370191f, -0.03216829f, 
    0.06426906f, 0.12743162f, -0.19432037f, -0.02441123f, 0.04700907f, -0.01657676f, 0.06561778f, 0.01744321f, 
    0.06544016f, 0.03352484f, 0.09868935f, 0.11861840f, 0.23050195f, -0.16690870f, 0.18265399f, 0.26087433f, 
    0.04810771f, -0.09186105f, 0.06129411f, -0.05557479f, 0.12584682f, -0.04431865f, 0.00348398f, 0.04566986f, 
    -0.22807929f, 0.00676684f, 0.08240332f, -0.09176093f, 0.10977571f, 0.07641632f, 0.15455522f, -0.06377997f, 
    0.04194877f, 0.03850092f, -0.06648261f, -0.05079781f, 0.26095942f, 0.07558877f, -0.05294170f, -0.00802553f, 
    0.03300095f, 0.00735596f, 0.08239151f, -0.01544628f, 0.07679252f, -0.05511348f, 0.02018673f, 0.01998285f, 
    -0.28606170f, 0.17394599f, -0.01878745f, -0.06219438f, -0.05152268f, -0.00901730f, -0.07224686f, 0.04126935f, 
    0.06984552f, 0.05547141f, -0.01613022f, -0.20487677f, 0.15647338f, -0.10975847f, -0.11997335f, -0.08118892f, 
    0.03970317f, -0.01065656f, -0.05751358f, 0.05200037f, 0.04457726f, 0.14390540f, 0.03891345f, 0.06297030f, 
    0.17033951f, 0.12896396f, 0.10107315f, 0.02198947f, -0.05059112f, 0.01139641f, -0.07317317f, -0.04264597f, 
    0.01660306f, -0.05852429f, 0.00938755f, 0.00354591f, -0.13901551f, 0.15853058f, 0.06627180f, -0.13301651f, 
    -0.06938668f, -0.04379021f, -0.06146520f, 0.04156515f, 0.02380159f, 0.01529759f, -0.12741654f, -0.05718320f, 
    -0.08191175f, 0.08578017f, -0.09596317f, 0.15065509f, 0.02243372f, 0.05457481f, 0.00269638f, 0.22811078f, 
    -0.03428566f, 0.08694150f, -0.07566094f, 0.02276800f, -0.27133992f, 0.21332593f, -0.01217922f, -0.19758555f, 
    -0.08157154f, -0.00711035f, 0.14642158f, -0.04221828f, -0.01240371f, 0.00349959f, -0.02091606f, -0.01508048f, 
    0.18219225f, -0.38891202f, 0.08111880f, 0.31508216f, -0.09822729f, 0.02847048f, 0.00627642f, -0.01545052f, 
    0.00045721f, 0.09398079f, 0.16532251f, 0.21241590f, -0.30765182f, 0.33644754f, -0.01958849f, 0.08314234f, 
    0.09599378f, -0.09664223f, 0.04227633f, -0.00988812f, -0.07480002f, -0.02832724f, 0.09353969f, -0.07523720f, 
    0.13448691f, 0.07887112f, 0.01176576f, 0.06462870f, 0.01630201f, -0.05110693f, 0.07230353f, 0.11118419f, 
    0.08548202f, -0.03513660f, 0.06104567f, -0.10295177f, 0.17738113f, -0.20925735f, 0.10985012f, 0.16984372f, 
    -0.16555941f, 0.10901462f, 0.01168729f, -0.03029943f, 0.14411330f, -0.03342205f, -0.00109716f, 0.01992035f, 
    -0.46670884f, -0.10386949f, -0.00185574f, -0.00968880f, -0.08488653f, 0.00447680f, -0.09343021f, -0.14999786f, 
    -0.01252770f, 0.11479997f, -0.00826877f, -0.02846984f, -0.03064416f, 0.22634196f, 0.01766324f, -0.08037099f, 
    -0.02505033f, -0.05483083f, -0.03554472f, 0.10373309f, 0.03557900f, 0.17766242f, 0.07687465f, 0.10935476f, 
    -0.01474655f, -0.04582000f, 0.02604771f, -0.02278837f, -0.07451007f, -0.04241275f, 0.03175227f, -0.06487262f, 
    -0.01909875f, -0.06090659f, -0.04539559f, -0.06958974f, 0.05638934f, -0.04845175f, -0.03448180f, 0.02971458f, 
    -0.01154418f, -0.00064010f, 0.00026592f, 0.03333533f, 0.03404767f, 0.01019198f, -0.04637276f, 0.04199199f, 
    -0.06447727f, -0.01500329f, -0.02146647f, 0.05573991f, 0.05223320f, 0.04605949f, -0.01091965f, -0.03024839f, 
    0.00729631f, -0.01141510f, 0.02401510f, 0.02069457f, -0.01615223f, 0.05800118f, -0.04678792f, -0.00740806f, 
    0.01051742f, 0.03676002f, 0.03520152f, -0.05804396f, -0.00339978f, -0.05988905f, 0.05163708f, 0.00404023f, 
    -0.00537888f, -0.02283699f, -0.03171598f, -0.05323585f, 0.04305642f, 0.02463092f, -0.02940560f, -0.04336045f, 
    -0.04553400f, 0.03647484f, 0.04415237f, -0.07330397f, -0.04601603f, 0.01234149f, 0.06553322f, 0.02027992f, 
    -0.03534994f, -0.02517875f, 0.05446640f, 0.00460988f, -0.05316953f, -0.01709770f, -0.05645338f, 0.02213074f, 
    -0.05310027f, -0.07417157f, -0.05356508f, 0.06604670f, -0.07737262f, 0.03086997f, 0.01177151f, -0.04902849f, 
    -0.05400620f, 0.02222206f, -0.06134024f, -0.01000969f, -0.06794903f, -0.01966691f, -0.02073804f, 0.05916917f, 
    -0.00075134f, 0.06293119f, -0.03871671f, -0.06836610f, -0.00059789f, -0.05813991f, -0.04431558f, 0.06668750f, 
    -0.01763383f, -0.06529947f, -0.04546118f, -0.04331455f, -0.02932357f, -0.07626458f, -0.05202555f, -0.01573810f, 
    0.06380024f, -0.04393933f, -0.00729085f, -0.05148865f, -0.03256391f, -0.05631157f, -0.02984323f, 0.06090544f, 
    0.05659479f, 0.02097082f, -0.03483697f, -0.01512741f, 0.03341461f, 0.06910102f, 0.04910923f, 0.01804792f, 
    -0.05661428f, 0.06644233f, -0.03573234f, 0.07180412f, -0.02920628f, 0.03880108f, -0.07452992f, -0.05030873f, 
    0.04930247f, -0.00325785f, 0.00692110f, -0.07080889f, 0.03660592f, 0.05975210f, -0.01281472f, -0.02906047f, 
    -0.06130577f, -0.02366869f, -0.03817069f, -0.02730469f, -0.01989481f, -0.06766468f, 0.01380154f, 0.06328365f, 
    -0.05097474f, -0.02965518f, -0.04439683f, 0.05553703f, -0.06096829f, -0.00638304f, 0.05960030f, 0.04838246f, 
    -0.02658332f, -0.04593824f, 0.00381242f, -0.03390215f, -0.02316853f, -0.00741576f, 0.04656889f, -0.03952444f, 
    -0.05591164f, -0.01591947f, -0.04750558f, -0.06951787f, 0.01173024f, 0.06091255f, -0.01196800f, -0.01065809f, 
    -0.02229213f, 0.06542604f, 0.04701667f, 0.01032600f, -0.03306924f, -0.03628467f, 0.05812726f, -0.05218983f, 
    0.04795713f, -0.00058582f, -0.06169354f, -0.00457188f, -0.06187063f, 0.04251041f, -0.01811113f, 0.06338312f, 
    -0.00904019f, 0.02400426f, 0.01693007f, 0.00062121f, 0.06327505f, -0.06767062f, 0.00588174f, 0.05215926f, 
    0.16091610f, -0.06413794f, -0.11934562f, 0.11183915f, 0.02135726f, 0.02285772f, -0.10091569f, -0.11464408f, 
    -0.01348395f, 0.05100916f, 0.10033750f, -0.02580448f, 0.06458265f, 0.10545999f, 0.36006492f, 0.14662550f, 
    0.07463321f, -0.01490744f, 0.09487636f, 0.07480413f, -0.19942793f, 0.04537111f, 0.01690522f, 0.20631370f, 
    0.06855020f, -0.16348128f, -0.00573096f, 0.28158411f, -0.05552849f, -0.04116243f, 0.13541539f, 0.03912557f, 
    -0.06025425f, 0.07506900f, 0.01551906f, -0.12514441f, 0.01751785f, -0.05089550f, -0.00156111f, -0.01735382f, 
    0.07422093f, 0.08605633f, -0.05525724f, 0.07388804f, 0.06065730f, 0.01135984f, 0.01275023f, -0.06502566f, 
    -0.11887676f, 0.06964882f, 0.08640672f, -0.03852001f, 0.02242177f, 0.02388725f, 0.07414205f, 0.07590059f, 
    0.04099341f, 0.07798579f, -0.14242613f, 0.12815128f, 0.03565841f, -0.04053593f, 0.14599471f, -0.19811335f, 
    -0.05221974f, -0.06368928f, 0.24192743f, -0.00474368f, -0.01203745f, 0.08124822f, 0.11260421f, -0.03677425f, 
    0.13779381f, -0.02245903f, 0.06215235f, 0.15914375f, -0.00885886f, 0.00859501f, 0.00636710f, 0.06413683f, 
    -0.21147910f, -0.02830119f, 0.02085503f, 0.06896418f, 0.00074861f, 0.32581031f, 0.01671130f, 0.18981285f, 
    0.03758664f, 0.00415722f, -0.00930992f, 0.02720869f, 0.16085732f, 0.14303796f, -0.09555290f, 0.01512845f, 
    -0.16847020f, -0.03190053f, 0.04552504f, -0.15490241f, -0.16905873f, -0.04588971f, 0.07308818f, 0.01755610f, 
    0.03195246f, -0.00318354f, 0.05543850f, 0.12782110f, -0.07656311f, 0.17827976f, -0.05461453f, -0.03386423f, 
    0.06157136f, -0.02679502f, 0.14197460f, -0.05887001f, 0.11862526f, 0.09680056f, -0.05019220f, 0.08101166f, 
    -0.06183618f, 0.08942590f, -0.13517669f, -0.11686777f, -0.01153794f, 0.12566689f, 0.14702192f, 0.07858378f, 
    0.06371415f, -0.06936775f, -0.08178023f, 0.03854318f, -0.09743579f, 0.17493141f, -0.12286789f, -0.15890707f, 
    -0.00912963f, 0.01605242f, -0.03086150f, 0.07637582f, 0.03025409f, -0.04590179f, -0.01137086f, -0.08466665f, 
    -0.04758335f, 0.27631098f, -0.33198592f, -0.02882881f, -0.08265003f, 0.07324772f, 0.00812063f, -0.03483373f, 
    0.01628763f, 0.11803924f, 0.02417429f, -0.02661762f, -0.26366854f, -0.09140723f, 0.06325802f, -0.02261021f, 
    -0.17249885f, 0.05530512f, 0.04104279f, 0.10485420f, 0.07346570f, 0.11255044f, 0.07448902f, -0.07099840f, 
    0.03019994f, 0.03894946f, -0.17792426f, 0.21284591f, -0.01030210f, 0.19089864f, 0.08971290f, 0.07949455f, 
    0.04165158f, 0.07439990f, 0.02607824f, -0.13429485f, 0.11878054f, 0.15896286f, 0.08473098f, 0.02584284f, 
    0.19790362f, -0.06895345f, -0.04523126f, 0.00053269f, -0.06311435f, 0.09627878f, 0.03805758f, 0.16326688f, 
    0.17429920f, 0.09927121f, 0.14578238f, -0.06510658f, 0.14054170f, 0.02739848f, 0.11669210f, 0.04470270f, 
    -0.10191932f, -0.02015202f, -0.00975787f, -0.05323735f, -0.10955192f, 0.05937105f, -0.15655328f, -0.40323907f, 
    0.18626951f, -0.00380530f, -0.06058778f, -0.09325925f, -0.06859727f, -0.07673419f, 0.11478912f, 0.06063244f, 
    0.28606543f, -0.08124118f, 0.00991741f, 0.15487954f, -0.07784074f, 0.07312927f, -0.06042976f, 0.16416900f, 
    0.00087490f, -0.01600233f, -0.01770880f, 0.05026665f, -0.11915253f, -0.18808439f, 0.09267245f, 0.03931184f, 
    0.02891575f, -0.04347951f, 0.04754372f, 0.14701237f, 0.02664878f, 0.09698880f, 0.14046615f, -0.01015526f, 
    -0.04554823f, -0.14353228f, -0.10685386f, -0.33683509f, 0.04376239f, 0.12586993f, -0.03867267f, 0.00296931f, 
    0.11094720f, 0.03326141f, -0.01060904f, 0.00895961f, -0.11987556f, 0.02854664f, 0.20346917f, 0.03602130f, 
    0.20072255f, -0.10189601f, -0.00829533f, 0.05024040f, 0.06682263f, 0.05527201f, -0.05247252f, 0.14509599f, 
    -0.16582131f, 0.00177783f, -0.02578885f, -0.10628646f, -0.01780737f, -0.22770487f, 0.01947239f, -0.06502145f, 
    -0.08072508f, 0.00735825f, 0.01654398f, 0.03769766f, -0.01982117f, 0.11702521f, 0.00629575f, 0.19794041f, 
    0.11153682f, 0.07208291f, 0.09793247f, -0.05681757f, -0.03667612f, -0.09300759f, 0.05697831f, -0.03256985f, 
    0.20601334f, 0.06641082f, -0.05800654f, -0.05618769f, 0.16454528f, 0.08098040f, -0.08208570f, 0.04222746f, 
    0.01656371f, 0.03188150f, -0.03617202f, -0.09283794f, 0.37723041f, -0.09984156f, 0.03921774f, 0.12590387f, 
    0.03053465f, 0.08706614f, -0.01509110f, 0.13878596f, -0.06609154f, -0.00691809f, -0.01410734f, 0.04067013f, 
    -0.38772872f, 0.18036416f, -0.23172335f, -0.14868049f, -0.01456934f, -0.07201419f, 0.01357097f, 0.06635932f, 
    -0.01364275f, 0.15401679f, 0.21504830f, 0.00846919f, 0.45739180f, -0.08735708f, -0.12190531f, 0.00569724f, 
    -0.08146363f, -0.04117871f, -0.11333795f, 0.01757979f, 0.00132081f, 0.05708430f, -0.00548896f, -0.03756854f, 
    0.28734273f, 0.03268194f, -0.08715430f, 0.22239809f, 0.06005999f, -0.01026251f, 0.02376060f, 0.10711929f, 
    -0.08060011f, 0.08622705f, -0.06314146f, 0.17449862f, -0.02099583f, 0.02258620f, -0.02914453f, -0.28593087f, 
    0.16165832f, 0.09883212f, -0.05893582f, 0.00872426f, 0.00069989f, -0.01439425f, 0.11237885f, 0.09039307f, 
    0.06350660f, 0.24562111f, 0.08643248f, 0.11949944f, -0.00738846f, -0.00067147f, -0.01271930f, 0.04202243f, 
    -0.01095936f, 0.11475299f, 0.02886918f, 0.06911671f, 0.18380041f, 0.02037838f, -0.02325623f, 0.10871591f, 
    -0.05701850f, 0.14361297f, 0.10081849f, -0.03215929f, -0.08422777f, 0.01452993f, -0.05490132f, 0.00857089f, 
    0.02766373f, -0.09426989f, -0.03009617f, -0.13172472f, -0.08623564f, 0.00553385f, 0.03389291f, 0.06651202f, 
    -0.04820805f, 0.06381205f, -0.02325812f, 0.07449125f, 0.17832287f, 0.14557165f, 0.14390624f, -0.18309167f, 
    0.05029963f, -0.00224981f, 0.21461894f, -0.09827643f, -0.09292811f, -0.00928567f, 0.13015392f, 0.18879373f, 
    -0.12539920f, 0.03055659f, -0.11365958f, -0.00869363f, 0.04553628f, -0.00344965f, 0.07410046f, 0.01950442f, 
    0.10946357f, 0.04439216f, -0.04645953f, -0.09486868f, 0.05143175f, -0.41908118f, -0.08664527f, 0.01435200f, 
    0.05668066f, 0.09151559f, -0.11052936f, 0.00754789f, -0.07502474f, 0.03240091f, 0.00743473f, 0.02947689f, 
    -0.04105959f, -0.08805673f, 0.06149485f, -0.12050931f, 0.14469811f, 0.20747884f, 0.01687264f, -0.08943053f, 
    -0.00442689f, -0.02702377f, 0.04199117f, -0.08011036f, 0.05751277f, 0.04707238f, 0.02516467f, 0.14394146f, 
    0.03775424f, -0.02287062f, 0.16590989f, 0.09597425f, 0.00718826f, -0.06483345f, -0.00502353f, 0.09420962f, 
    0.02430080f, 0.40316120f, -0.04749657f, -0.09087855f, 0.01846680f, 0.01610764f, 0.01857282f, 0.06649536f, 
    -0.27065030f, -0.07440189f, 0.14589927f, 0.07390431f, -0.09374230f, -0.20540892f, -0.18326782f, 0.23897593f, 
    0.06308300f, 0.10460517f, 0.02703397f, -0.01304757f, 0.14510012f, 0.06005710f, 0.10381187f, -0.07038531f, 
    -0.17780295f, 0.15505217f, -0.02338946f, -0.13406013f, 0.04741905f, -0.05174113f, 0.08853301f, 0.16365844f, 
    0.03980121f, 0.07481851f, 0.12230206f, 0.04663493f, 0.14511845f, -0.29196322f, -0.11035722f, -0.25793654f, 
    0.09412396f, 0.01001484f, -0.03055844f, 0.11060499f, -0.02662019f, 0.07748520f, -0.04150905f, -0.06152972f, 
    0.05771641f, 0.01927827f, 0.00688447f, -0.29872012f, -0.01222519f, -0.07428112f, 0.02579988f, 0.11766832f, 
    0.03936252f, 0.08187257f, -0.02797361f, -0.00162924f, 0.26932630f, 0.04233574f, -0.17065066f, -0.01549127f, 
    0.11308637f, 0.09610917f, -0.10831413f, 0.00654763f, 0.08022033f, 0.00751184f, 0.12495806f, -0.04320331f, 
    0.20278132f, 0.01358333f, -0.18771575f, 0.01735727f, -0.01574071f, 0.15915368f, 0.06812125f, 0.02856182f, 
    -0.04139537f, 0.04934787f, -0.15960568f, -0.10951265f, 0.18958987f, 0.07587665f, -0.03285418f, -0.21727939f, 
    0.15088575f, -0.01701370f, 0.18577756f, 0.05363578f, -0.01172642f, 0.13093200f, -0.00144110f, -0.04520355f, 
    0.00200319f, 0.11782039f, -0.03914424f, 0.14889114f, 0.04853867f, 0.18370408f, -0.01786443f, 0.10248704f, 
    0.05502796f, 0.04164344f, 0.00199596f, -0.02766108f, -0.07043641f, -0.11087500f, -0.18164876f, 0.00026453f, 
    0.05712794f, -0.00488716f, 0.03066642f, 0.01173266f, -0.03743090f, -0.06221523f, -0.08272132f, -0.08076693f, 
    0.15408263f, 0.01281390f, 0.00450824f, -0.02533815f, 0.10597378f, 0.13603453f, -0.05065382f, -0.06229161f, 
    0.00183601f, 0.07764398f, 0.05762542f, 0.07206534f, -0.12946738f, 0.00875363f, -0.06368575f, -0.02229712f, 
    0.24866998f, 0.13371712f, -0.04022426f, -0.01218378f, -0.02155955f, 0.06450985f, -0.01974065f, 0.05262409f, 
    0.50612450f, -0.09783275f, 0.01330068f, 0.26134664f, -0.02567267f, 0.14916584f, -0.03679229f, 0.09404489f, 
    0.08402972f, 0.01482088f, -0.02395099f, 0.12569359f, -0.11306575f, 0.02109009f, 0.01224843f, 0.15347368f, 
    -0.10543180f, -0.06331608f, 0.04488042f, 0.12360561f, -0.13920192f, 0.07619987f, 0.03614116f, 0.07317885f, 
    0.02390428f, -0.04573436f, -0.10064474f, -0.10544164f, -0.09303620f, -0.04040523f, 0.05813223f, 0.00430586f, 
    -0.00221219f, -0.01180687f, 0.03144027f, 0.07363364f, -0.04474549f, -0.08490676f, 0.20304832f, 0.05443153f, 
    0.00881751f, -0.00763302f, 0.02643637f, 0.03604540f, 0.04630491f, -0.08689132f, -0.04242881f, -0.02884429f, 
    -0.49466270f, -0.11440215f, -0.10880016f, -0.09258053f, 0.17808419f, -0.02149224f, 0.15317990f, -0.08501038f, 
    0.08845087f, 0.05027694f, -0.02784899f, 0.12231552f, 0.21061453f, 0.03923137f, 0.01623384f, -0.04606317f, 
    0.08456001f, 0.15927275f, -0.02559781f, 0.06373940f, 0.03072222f, -0.16306724f, 0.10143116f, 0.05776508f, 
    0.29766551f, -0.01450846f, -0.03547188f, 0.05572288f, 0.10700680f, 0.04786903f, 0.10501070f, 0.01695692f, 
    0.10250212f, -0.05797447f, 0.01553833f, -0.07274485f, 0.20984356f, 0.02611419f, 0.07062232f, 0.32540268f, 
    -0.14178067f, 0.01672883f, 0.01583165f, 0.18348655f, -0.09789930f, -0.05657087f, 0.10802519f, 0.04090238f, 
    -0.22742878f, 0.09132311f, -0.05317779f, -0.25628656f, 0.14727381f, 0.05364277f, -0.05748645f, -0.04808068f, 
    -0.03059019f, -0.09718294f, 0.01954789f, 0.00777516f, 0.47365892f, -0.11990502f, -0.07309744f, -0.12052111f, 
    -0.09066477f, 0.03491002f, -0.12386676f, -0.00890390f, -0.05759604f, 0.04180263f, -0.02378085f, 0.00413102f, 
    0.13992739f, -0.05211946f, -0.15676685f, 0.18467592f, -0.20974696f, 0.06017033f, -0.10328900f, 0.14687233f, 
    -0.04284543f, -0.02562378f, -0.06009857f, 0.10370160f, -0.09626055f, 0.00213903f, -0.04992450f, -0.24831039f, 
    0.16503955f, 0.03164088f, -0.01129454f, -0.08805753f, 0.05656716f, 0.06753754f, 0.07423276f, -0.01046889f, 
    -0.04106436f, 0.11975966f, -0.01479812f, -0.20841742f, 0.05725933f, 0.10962246f, -0.15444499f, 0.06712778f, 
    0.11505096f, 0.06207735f, 0.02996513f, 0.15952906f, 0.21541117f, -0.09332989f, -0.11282677f, 0.03456512f, 
    -0.05430515f, -0.02413565f, 0.05618855f, 0.06463071f, -0.06240248f, 0.05967696f, -0.02228261f, 0.00588914f, 
    -0.12213032f, -0.30247858f, 0.11807008f, -0.08034903f, -0.05383144f, -0.07437973f, 0.05927237f, 0.12194510f, 
    0.00202240f, -0.00908380f, 0.06153163f, 0.06038558f, -0.17834233f, 0.24143331f, 0.05394459f, -0.36583087f, 
    0.10743614f, 0.08301263f, 0.01149264f, -0.00243364f, -0.16478607f, 0.08095091f, -0.00817004f, -0.04122938f, 
    0.19882476f, -0.06014483f, -0.10002588f, -0.04737768f, -0.09078114f, -0.04831516f, 0.00617017f, 0.13957836f, 
    0.01502720f, 0.02701636f, -0.04541328f, -0.04453351f, -0.20251215f, -0.12208838f, 0.08032376f, -0.08018235f, 
    -0.00370815f, 0.04572809f, -0.05560134f, 0.03602581f, 0.05221855f, 0.09056351f, 0.17306924f, 0.09790883f, 
    0.34444156f, 0.04025092f, 0.03825478f, 0.15039557f, 0.12853123f, 0.15378740f, 0.06828962f, -0.04339213f, 
    -0.03139226f, -0.09815524f, -0.07177325f, 0.09241557f, 0.12138838f, -0.00753242f, 0.19862063f, -0.13917996f, 
    0.02450028f, -0.02782503f, 0.20003633f, 0.07764296f, -0.03875470f, -0.10231045f, -0.00894437f, 0.02664723f, 
    -0.30162436f, 0.00715890f, -0.12455656f, -0.05610575f, -0.01780796f, -0.03893626f, 0.09278683f, 0.03011384f, 
    -0.12018334f, 0.14839044f, 0.05515262f, 0.00259183f, 0.08828886f, -0.19562672f, -0.21529070f, 0.05622195f, 
    0.06092931f, 0.00108251f, 0.08044591f, 0.10293656f, 0.06283563f, -0.05528942f, 0.20771188f, -0.00585915f, 
    0.25824282f, -0.07439192f, 0.01415733f, 0.10070319f, 0.08880665f, 0.00800975f, 0.03773563f, -0.11850020f, 
    0.09199016f, 0.01485715f, 0.07418556f, 0.08018606f, 0.37225637f, 0.04056774f, -0.11995647f, 0.02248508f, 
    -0.06047382f, 0.06036380f, -0.07875883f, 0.07949772f, 0.06420830f, -0.04052055f, -0.04009740f, 0.02929701f, 
    -0.01793358f, 0.07164653f, -0.03465510f, 0.12879302f, 0.06529838f, 0.07213873f, 0.02302868f, 0.09322136f, 
    -0.02208585f, 0.15918384f, 0.00196886f, -0.02856288f, 0.35315114f, -0.09221686f, -0.24087323f, 0.10131961f, 
    -0.05089673f, -0.05301983f, 0.01452051f, -0.00183492f, 0.10212342f, 0.08840820f, -0.05491276f, 0.01041405f, 
    0.11289193f, -0.12088530f, -0.12944883f, 0.20636992f, -0.04825019f, 0.08581417f, -0.13370192f, 0.06559327f, 
    -0.10621455f, 0.06657411f, -0.03305693f, 0.13091175f, -0.12286118f, 0.09147491f, 0.13492690f, -0.13042413f, 
    0.08510678f, 0.01979326f, 0.03706567f, 0.06813514f, -0.01699481f, 0.08015328f, 0.01439899f, 0.11935813f, 
    0.08380025f, 0.11641177f, -0.26708999f, 0.05583708f, 0.02699415f, 0.17756066f, 0.15274644f, 0.09561473f, 
    0.07286403f, -0.05008766f, 0.09562074f, 0.04770099f, -0.08975293f, -0.23252454f, -0.27198529f, -0.10880316f, 
    -0.11656313f, -0.02473192f, 0.08856679f, -0.01283577f, -0.01742260f, -0.02966955f, -0.04979561f, -0.03741159f, 
    -0.31434798f, -0.17939146f, -0.02024332f, -0.08971970f, 0.03732318f, 0.05671478f, 0.08950386f, 0.10521884f, 
    0.09502284f, 0.05987956f, -0.00362890f, -0.02091469f, 0.00054723f, 0.21580710f, -0.00893064f, -0.07159479f, 
    0.00768784f, 0.02816080f, 0.01818081f, -0.03662235f, 0.13455088f, 0.11234246f, 0.01187076f, 0.08964995f, 
    -0.28698686f, 0.08668945f, 0.00124339f, -0.07427555f, -0.01223549f, -0.08560432f, -0.03146915f, 0.00310722f, 
    0.13437065f, -0.06865617f, 0.21770957f, 0.05066697f, 0.13569783f, -0.14978679f, -0.03499274f, -0.01573370f, 
    0.01811418f, 0.06674471f, -0.01973073f, 0.01489978f, 0.03420352f, 0.05258213f, -0.02335642f, 0.06307948f, 
    0.32184231f, 0.02472197f, -0.02575277f, 0.16772583f, 0.05195100f, -0.03811756f, 0.06410857f, -0.04123124f, 
    -0.09897304f, -0.00427637f, 0.13147330f, 0.01513627f, 0.14584048f, 0.04870934f, -0.17554365f, -0.02922641f, 
    -0.12842081f, 0.03639934f, 0.06119068f, 0.09556394f, -0.08496879f, -0.11032753f, -0.03462422f, -0.12602471f, 
    0.03248097f, 0.22516878f, 0.04176942f, 0.04270918f, -0.04647641f, 0.17134066f, 0.04958025f, 0.08431308f, 
    0.07234256f, 0.06187700f, 0.02399970f, 0.02272492f, 0.02386853f, -0.25040585f, -0.08100031f, -0.21077444f, 
    0.05451680f, 0.08398370f, -0.01194715f, 0.08282343f, 0.01395287f, 0.03285167f, 0.01802248f, 0.00045041f, 
    -0.02711224f, -0.02201644f, 0.16122156f, 0.15098839f, -0.01796983f, -0.16767338f, 0.04316199f, -0.09423958f, 
    0.08814214f, 0.02446359f, -0.02411463f, 0.09714195f, 0.01794879f, -0.04657232f, -0.06281783f, -0.04091186f, 
    -0.00265680f, 0.06811111f, -0.01488253f, 0.07414600f, -0.03169491f, 0.02162546f, 0.03498172f, 0.06491046f, 
    0.36595875f, -0.10056128f, 0.03834061f, 0.23051821f, -0.02838953f, 0.04245948f, -0.02988927f, 0.08531521f, 
    0.07179278f, -0.02138671f, -0.12899278f, -0.01769788f, -0.06818364f, 0.07691322f, 0.00674565f, 0.12401649f, 
    0.12265685f, 0.08188905f, -0.00397308f, 0.04455804f, 0.13163184f, 0.02483644f, 0.05116334f, 0.22697943f, 
    -0.04623954f, -0.13440461f, 0.00846523f, -0.05093038f, 0.01309046f, 0.11597066f, -0.02765861f, 0.13898589f, 
    0.05825084f, 0.04206781f, -0.07287782f, 0.01301700f, 0.33403879f, 0.05062137f, 0.13293259f, -0.03795765f, 
    0.03036920f, -0.11393201f, 0.05235221f, 0.05674960f, -0.02413591f, 0.07643534f, 0.03736005f, -0.02130708f, 
    -0.21719103f, -0.09479725f, -0.04685567f, -0.12700646f, -0.11347739f, 0.20485741f, 0.04192309f, 0.13015695f, 
    0.09818319f, -0.11432147f, 0.01543730f, -0.02518541f, -0.10637389f, -0.05224031f, -0.04999357f, -0.03573417f, 
    -0.00702491f, 0.00806690f, 0.09096534f, -0.05780223f, 0.14191438f, 0.03384919f, -0.00009402f, -0.02164419f, 
    0.01255847f, 0.01001922f, -0.06309164f, 0.04131477f, 0.02943374f, 0.03561721f, 0.06472838f, -0.05100024f, 
    -0.07289451f, 0.05205123f, 0.00973507f, -0.07106420f, -0.04536771f, -0.00429818f, 0.05877605f, 0.04899019f, 
    -0.06485020f, -0.02690769f, -0.01105603f, -0.07746989f, -0.04429707f, -0.03734130f, -0.07590015f, -0.06732907f, 
    -0.06861205f, 0.00635370f, 0.01542049f, 0.04009109f, -0.02076051f, -0.04391110f, -0.06422757f, 0.05739132f, 
    -0.06598175f, -0.03930964f, 0.05824294f, -0.07912431f, -0.06597690f, 0.05782346f, -0.04260966f, 0.01598531f, 
    0.03303433f, 0.00518908f, -0.07427233f, 0.02642641f, -0.06875487f, 0.05669608f, -0.00953252f, 0.05623874f, 
    -0.06888819f, 0.03902983f, -0.01156659f, 0.00768462f, -0.06480429f, -0.02700717f, 0.03314332f, 0.01724715f, 
    -0.00251343f, -0.04677986f, -0.04405294f, -0.02304016f, 0.01213195f, 0.05303087f, 0.04143387f, -0.07240412f, 
    -0.06694087f, 0.04334205f, -0.01324384f, -0.04513137f, 0.00829034f, 0.02935273f, 0.05204692f, 0.03976789f, 
    -0.07987368f, 0.05609040f, 0.06455994f, -0.07177386f, -0.07508452f, -0.07038652f, -0.06291362f, -0.00670645f, 
    -0.04074564f, 0.01584407f, -0.01384454f, -0.00651358f, 0.00060463f, -0.03249761f, 0.04226955f, 0.01924906f, 
    0.06827591f, 0.00968685f, -0.00147371f, 0.03306830f, -0.07156489f, -0.06086672f, -0.07296943f, 0.00569652f, 
    -0.02733051f, -0.06690884f, -0.01301477f, 0.03789820f, -0.05252086f, -0.01221157f, -0.06694726f, -0.05063018f, 
    0.02370469f, -0.00312449f, -0.00833787f, -0.00551617f, -0.00641502f, -0.01094614f, -0.02684277f, 0.01513283f, 
    0.02580699f, 0.06046301f, 0.03437910f, -0.03601053f, 0.03145331f, -0.01813767f, -0.07420291f, 0.04449559f, 
    0.00136961f, 0.03196313f, 0.01510059f, -0.06392761f, 0.02240754f, 0.03772740f, -0.01528253f, -0.05026754f, 
    0.05914417f, -0.05222574f, -0.00371707f, -0.06438684f, -0.05462133f, -0.05184560f, -0.06248762f, -0.00939917f, 
    -0.05188788f, 0.00929476f, -0.02655656f, 0.05962670f, 0.04005657f, -0.03832994f, 0.03483377f, -0.00522954f, 
    -0.06168974f, -0.00583811f, 0.04929084f, -0.01112830f, 0.05999766f, 0.03756761f, -0.05450745f, -0.05386824f, 
    -0.00125172f, 0.01542367f, 0.01485797f, -0.02647168f, -0.06263466f, 0.05547148f, 0.02297847f, 0.01929518f, 
    0.02501465f, -0.02384570f, 0.05244147f, -0.07152017f, -0.03785713f, 0.01758276f, -0.04740795f, -0.03600846f, 
    -0.01274424f, -0.02430992f, -0.03940104f, -0.03289773f, -0.01998393f, -0.00614716f, -0.03430674f, -0.03907228f, 
    0.04166632f, 0.03312622f, -0.03290290f, 0.01759435f, -0.06531343f, -0.07536941f, 0.03041782f, -0.03852252f, 
    -0.02816669f, 0.04599574f, 0.01941046f, 0.05232227f, 0.04418935f, -0.03017695f, -0.03282813f, 0.03610437f, 
    0.03464673f, 0.03691598f, -0.07051218f, 0.05665577f, -0.04724833f, -0.00077823f, -0.00286032f, 0.02133035f, 
    -0.01370453f, -0.01215868f, -0.04571781f, -0.02111424f, -0.06817338f, 0.00514813f, -0.06603492f, -0.04308167f, 
    -0.02077646f, 0.02152251f, 0.02225652f, 0.03702017f, -0.07793385f, -0.04815837f, 0.03510164f, -0.02966616f, 
    0.05410522f, -0.06150948f, 0.06345980f, 0.01069409f, -0.07944836f, -0.07207929f, -0.05817390f, 0.00390973f, 
    -0.03831847f, -0.07258336f, 0.05639324f, -0.03447932f, 0.05988488f, 0.03446296f, 0.00331518f, -0.03218246f, 
    -0.07094004f, 0.00433469f, -0.07727707f, -0.01447310f, 0.01899808f, -0.02246833f, 0.01342789f, -0.05665763f, 
    -0.01866927f, -0.06730734f, 0.06121337f, -0.05921686f, -0.06600894f, 0.03888499f, -0.01754186f, -0.04328676f, 
    -0.07586984f, 0.05786158f, 0.05437093f, -0.07378887f, 0.05289723f, -0.07733755f, -0.02606912f, 0.01304538f, 
    0.04105712f, -0.04640351f, -0.03994749f, 0.04034113f, 0.00797256f, 0.03175199f, -0.01591528f, -0.02579483f, 
    -0.07176325f, 0.02379756f, -0.06397512f, 0.02551221f, -0.03060369f, 0.03926277f, -0.04742775f, 0.02496795f, 
    -0.07037094f, -0.02101322f, -0.05831275f, 0.03440280f, 0.04291847f, -0.05960302f, 0.06236521f, -0.01560744f, 
    -0.03286409f, -0.04142078f, 0.03366463f, 0.05738078f, 0.06154209f, -0.02337551f, -0.04051055f, -0.05793540f, 
    0.02224358f, -0.00583455f, 0.01160295f, -0.03665341f, -0.04537340f, 0.05608234f, 0.04823134f, -0.03991587f, 
    0.00541167f, -0.02616053f, -0.07017233f, -0.01725034f, -0.00733440f, -0.04059423f, 0.04084228f, 0.03834453f, 
    -0.06600092f, 0.00375090f, -0.05418814f, 0.01779940f, -0.00338710f, -0.04726811f, -0.02738180f, 0.00355197f, 
    0.01627664f, -0.01200235f, -0.02011947f, 0.04996714f, -0.04806125f, -0.03271177f, -0.07742867f, 0.00452786f, 
    0.06243557f, 0.00868194f, -0.04113117f, 0.00490096f, 0.04486967f, 0.02331306f, 0.01270276f, -0.01758355f, 
    0.01792182f, 0.00446503f, 0.05185122f, -0.03222927f, 0.05969233f, -0.03160323f, 0.05177728f, 0.00431149f, 
    -0.05362132f, 0.01968027f, -0.04949524f, -0.05402929f, 0.02157577f, -0.07453459f, 0.04029479f, -0.05131314f, 
    -0.07085105f, -0.07915753f, -0.02586690f, 0.01911220f, 0.03876479f, -0.06268073f, 0.01949594f, -0.07372407f, 
    0.01215105f, -0.04458404f, -0.00194447f, 0.03661007f, -0.04657472f, -0.04514116f, 0.05174217f, -0.00901959f, 
    0.01421621f, 0.03965579f, -0.04174638f, 0.05892904f, 0.06090471f, -0.03366183f, -0.02572741f, -0.00943937f, 
    0.00016732f, -0.05176922f, -0.01640915f, 0.05468725f, -0.00606682f, -0.04698255f, -0.01185188f, -0.00117375f, 
    -0.06239427f, -0.02410037f, 0.00787228f, -0.06851746f, 0.04863040f, -0.00194966f, 0.02256154f, 0.01547097f, 
    0.09346411f, -0.07712605f, 0.12902413f, -0.20954511f, 0.11436535f, -0.02553054f, -0.08987099f, 0.14024951f, 
    0.00491574f, 0.00741299f, 0.02694585f, 0.10137585f, 0.03386317f, -0.00080442f, -0.21881923f, 0.01287430f, 
    -0.05698235f, 0.08073198f, -0.06309000f, 0.03987213f, 0.04428069f, -0.06585832f, 0.08562596f, -0.07264280f, 
    0.03873520f, 0.14376214f, -0.03457317f, 0.09617484f, -0.09383627f, 0.10230887f, 0.13727118f, 0.11793367f, 
    0.04376441f, 0.12977694f, -0.05538585f, 0.00725777f, 0.03131406f, -0.10274374f, 0.15706743f, 0.07329354f, 
    0.05049254f, -0.03964733f, 0.07622033f, 0.11540159f, -0.01022673f, -0.04678154f, 0.03543782f, -0.07538678f, 
    0.11711893f, -0.04356015f, -0.02765432f, -0.06032911f, 0.10392708f, 0.08810945f, 0.04434439f, 0.02135760f, 
    0.01127308f, 0.04823409f, 0.10557535f, -0.06793489f, 0.48941571f, 0.00953695f, 0.08824356f, 0.00110587f, 
    0.08507033f, -0.09779391f, -0.16652420f, -0.00549832f, -0.10843490f, 0.06690025f, -0.07774576f, 0.05050160f, 
    -0.03021411f, -0.31248185f, -0.26097667f, -0.05331347f, 0.02938812f, -0.13871679f, 0.05414407f, -0.16969573f, 
    0.17775802f, 0.10169696f, -0.16195080f, 0.06116187f, -0.12440628f, -0.11541510f, -0.17775980f, 0.09723747f, 
    0.05897095f, 0.07037303f, 0.06263166f, -0.15745586f, -0.11903410f, -0.05873753f, 0.05503581f, 0.06047446f, 
    0.33347395f, -0.07612477f, 0.01908561f, 0.02002826f, -0.02600858f, 0.20042317f, -0.00112338f, -0.01345750f, 
    0.05551641f, -0.02078161f, -0.25307336f, -0.03678538f, -0.03775674f, -0.05348455f, 0.06357858f, 0.23532993f, 
    0.08267710f, 0.04487270f, -0.07394501f, 0.09618364f, -0.02699191f, 0.00668734f, -0.02224511f, -0.14289360f, 
    0.00989563f, 0.04110081f, -0.27487898f, 0.19472103f, 0.11198186f, -0.01588050f, -0.02697961f, -0.05112337f, 
    -0.01827713f, -0.03244642f, -0.01685630f, 0.04216620f, -0.10099372f, 0.06156911f, -0.12433674f, 0.12010311f, 
    -0.01404116f, -0.03718467f, -0.03034089f, -0.05591422f, -0.06887108f, 0.09726020f, 0.18725917f, -0.12881078f, 
    0.25613213f, -0.01797739f, -0.02812228f, 0.26585010f, 0.04798198f, -0.09305782f, -0.01633636f, 0.00649320f, 
    -0.01711714f, 0.01414062f, 0.04274344f, 0.14365174f, 0.50590473f, 0.17665972f, -0.03501415f, -0.02569837f, 
    0.16798766f, 0.09023459f, -0.03891129f, -0.16525103f, -0.10021478f, -0.10060260f, -0.10808379f, -0.02251560f, 
    -0.14215866f, 0.21040735f, 0.02631865f, -0.12760907f, -0.07933126f, -0.12891106f, -0.13382669f, -0.12218480f, 
    -0.06128722f, 0.22903763f, 0.06165932f, 0.22386150f, 0.08716767f, 0.03113679f, -0.08523640f, 0.06940238f, 
    -0.07938573f, 0.10834051f, 0.04696443f, 0.19110180f, 0.08608596f, 0.00298543f, 0.06506802f, -0.00454658f, 
    0.05427791f, -0.00846410f, 0.04798338f, -0.05292561f, -0.00378507f, -0.06233067f, 0.01824878f, -0.02756693f, 
    0.03450326f, 0.04397386f, 0.06005195f, -0.01203977f, 0.02652088f, -0.07102320f, 0.01162655f, -0.03904881f, 
    -0.05245811f, 0.01110021f, -0.02971976f, 0.05806598f, -0.04501919f, -0.03610582f, -0.06951425f, -0.01777465f, 
    -0.01671864f, -0.05343779f, -0.03514758f, -0.02228617f, -0.02273862f, 0.05097232f, 0.04153189f, 0.05593814f, 
    0.01613780f, 0.05072832f, -0.04975768f, 0.02258311f, -0.05762535f, -0.06008470f, -0.05855449f, 0.01816181f, 
    0.04562168f, -0.02403455f, -0.03813532f, -0.07137647f, 0.05923448f, -0.00138470f, -0.01954324f, -0.05785565f, 
    0.02936388f, 0.01053029f, -0.04181986f, 0.04933351f, -0.07199912f, -0.00536535f, -0.05601937f, -0.00582395f, 
    -0.05305148f, 0.05303936f, 0.04046714f, -0.03565640f, -0.05109292f, 0.02432606f, 0.01200372f, -0.02750949f, 
    -0.00211443f, -0.05136145f, -0.04611100f, -0.02384285f, 0.02487160f, 0.05220043f, -0.07408579f, -0.02257706f, 
    -0.05580664f, -0.04799060f, -0.02351028f, -0.00101387f, 0.00567643f, -0.05837415f, -0.04909556f, 0.03994578f, 
    0.06598890f, 0.00939135f, -0.01306218f, -0.05608403f, 0.00402366f, -0.06911721f, 0.02569486f, -0.03402414f, 
    -0.07042437f, -0.04966901f, -0.00147608f, 0.01680292f, -0.04183686f, 0.00238450f, 0.03463794f, 0.04671198f, 
    -0.03021638f, 0.00438412f, -0.00492543f, -0.05827588f, -0.05341472f, -0.02817795f, -0.04429125f, -0.03815358f, 
    0.00330450f, 0.02222148f, -0.01981050f, -0.05383891f, -0.04922407f, 0.03011422f, 0.00898297f, 0.04312190f, 
    0.05444621f, -0.00690914f, 0.06485450f, -0.04425344f, -0.00215853f, 0.03944673f, -0.00332715f, -0.03109209f, 
    -0.06598558f, 0.03993659f, 0.05754223f, -0.01204842f, 0.04037470f, 0.01714684f, 0.01351519f, 0.01589904f, 
    0.04026604f, -0.04706155f, -0.00874492f, 0.01555907f, -0.04010895f, 0.05822551f, -0.07098610f, 0.00537480f, 
    0.00728996f, -0.00233404f, 0.02432963f, -0.04583273f, 0.05846136f, -0.01567635f, -0.05059476f, 0.04450615f, 
    0.02191427f, -0.06633767f, -0.02314581f, -0.02568074f, -0.06908326f, -0.02396089f, -0.04815855f, -0.03838966f, 
    -0.05571710f, -0.00802010f, -0.03870566f, -0.02279651f, -0.02280828f, -0.01450738f, -0.00367279f, 0.04944495f, 
    0.02378411f, -0.04577923f, -0.05801198f, -0.00547884f, -0.03185486f, 0.02793614f, 0.01954638f, 0.00855495f, 
    0.04829667f, -0.04444660f, 0.00022019f, -0.03339329f, -0.01305796f, 0.01110060f, -0.02019683f, -0.02911525f, 
    -0.00367913f, 0.05519858f, 0.04304062f, -0.04445921f, 0.00859531f, 0.03627765f, 0.03666269f, -0.02013997f, 
    0.02049159f, 0.05943216f, -0.06614541f, -0.03422789f, -0.04312142f, -0.03013217f, 0.02801748f, 0.04897051f, 
    -0.00046846f, -0.03636923f, -0.06446408f, 0.02655224f, 0.03706383f, -0.00012238f, -0.00306476f, 0.01289437f, 
    0.02201667f, -0.07529058f, 0.04815157f, -0.07401919f, 0.00682073f, -0.05172301f, 0.05142488f, 0.03820560f, 
    -0.02237373f, 0.04079490f, 0.01570783f, -0.07257485f, 0.06191027f, -0.00699226f, -0.03067350f, -0.02319405f, 
    -0.04667902f, -0.03678512f, -0.04169165f, -0.06525869f, 0.04856159f, 0.03839787f, -0.04524727f, -0.03887490f, 
    -0.00048093f, -0.04541557f, -0.06726760f, -0.02198824f, 0.00510749f, -0.02709791f, -0.06953260f, 0.03364915f, 
    0.03210412f, -0.05112827f, -0.04839397f, 0.03487444f, -0.02812895f, 0.00970880f, 0.00949744f, -0.06834071f, 
    -0.02186093f, -0.01515427f, -0.02353827f, -0.01572587f, 0.03167073f, -0.01682726f, -0.01533774f, 0.05216485f, 
    -0.07553163f, 0.00427161f, -0.02225172f, -0.02721895f, -0.05224774f, -0.07661894f, -0.00457820f, 0.02745016f, 
    -0.07065684f, 0.00153050f, 0.01693039f, 0.02662361f, -0.04610428f, -0.02742666f, -0.02947325f, -0.05462940f, 
    0.01517295f, -0.04481324f, 0.05848798f, 0.00206454f, -0.00022859f, -0.06936580f, -0.04178895f, 0.03670752f, 
    -0.05709222f, -0.03804323f, 0.02628563f, 0.02119159f, -0.05104380f, -0.01588926f, 0.05545374f, -0.02416263f, 
    0.03518681f, 0.01898331f, -0.01212402f, 0.05912542f, -0.04487382f, -0.04723050f, 0.00797386f, -0.03061253f, 
    -0.02873432f, -0.02586242f, -0.02486490f, -0.03740972f, -0.00835150f, -0.02474707f, 0.06395401f, -0.05165727f, 
    -0.00218819f, -0.07777533f, 0.06312335f, -0.02829412f, 0.00793662f, 0.00255932f, 0.00237671f, 0.04187571f, 
    -0.04091644f, -0.02547127f, -0.05264794f, -0.03100361f, 0.03287940f, 0.04575741f, -0.00408812f, 0.00536373f, 
    -0.02296464f, 0.00945623f, 0.02595983f, -0.07453146f, 0.06146585f, 0.02693836f, 0.04468699f, -0.00704100f, 
    -0.03795508f, -0.07573841f, 0.05263491f, 0.02600508f, -0.02077091f, 0.03091146f, 0.04806593f, -0.03152287f, 
    -0.00579793f, -0.03047247f, 0.05788586f, 0.01125934f, 0.03848177f, -0.01282331f, 0.05854534f, -0.02337966f, 
    -0.05581165f, 0.02145232f, -0.03115899f, 0.04854237f, -0.01069312f, -0.07392382f, 0.00576614f, -0.06033012f, 
    -0.06817782f, 0.02514563f, -0.04164743f, 0.06795668f, -0.03769485f, -0.00915685f, 0.05837151f, 0.03749801f, 
    -0.04572192f, -0.04031724f, -0.02900671f, 0.05828933f, -0.05926500f, 0.02226961f, 0.01725497f, 0.03612743f, 
    0.00349261f, -0.03757721f, 0.02402071f, -0.04364264f, -0.06033487f, 0.05204047f, 0.02342211f, -0.07647558f, 
    0.01689375f, 0.01331308f, -0.00723540f, 0.00596870f, -0.04015119f, -0.07350047f, -0.05738320f, -0.04071812f, 
    0.04430741f, -0.02919327f, 0.06493889f, 0.04079663f, 0.05547822f, -0.04715843f, 0.00268606f, 0.04981950f, 
    0.29976380f, 0.13567714f, 0.14844646f, 0.06758513f, 0.26571664f, 0.00111755f, -0.02205359f, -0.03588621f, 
    -0.11281738f, -0.00527882f, 0.03436779f, 0.02390862f, -0.12833083f, -0.02106939f, -0.00547473f, -0.04485087f, 
    -0.30916336f, 0.02594871f, -0.10263611f, 0.08354412f, -0.19969541f, 0.03631464f, 0.08819634f, 0.02040637f, 
    0.41689384f, 0.11366872f, -0.07319844f, 0.16828167f, 0.06033624f, 0.04048898f, 0.11880764f, 0.22177199f, 
    -0.08932053f, 0.05654659f, -0.03548553f, -0.01631222f, 0.01758258f, -0.03133177f, 0.03565263f, 0.00840071f, 
    0.24067001f, 0.21044928f, 0.01615351f, -0.03404099f, -0.06586118f, -0.06962769f, 0.05128030f, 0.00340894f, 
    0.01713927f, 0.02487225f, 0.12865384f, 0.14249672f, -0.00042731f, -0.07881421f, 0.12763019f, 0.11904185f, 
    -0.00186017f, 0.08067081f, -0.06086490f, 0.09383961f, -0.04016240f, -0.23225993f, 0.10950398f, -0.00875677f, 
    0.04195443f, -0.11150372f, -0.09310646f, 0.02359606f, -0.12831531f, -0.01037807f, 0.05385025f, 0.07428490f, 
    0.35171449f, -0.01821568f, 0.23586391f, -0.05741987f, -0.29580498f, -0.09289021f, -0.06541222f, -0.14404456f, 
    -0.11960157f, 0.11947525f, -0.07373318f, -0.02295722f, 0.16219768f, 0.26037088f, -0.08809663f, 0.02978152f, 
    0.06366606f, 0.11875205f, 0.06819132f, -0.06829458f, 0.03626242f, -0.18164961f, -0.06762902f, -0.09989729f, 
    -0.12459823f, -0.29304361f, 0.21957107f, -0.22124846f, 0.03211254f, -0.25221366f, -0.04336835f, -0.08345393f, 
    0.04410775f, -0.10687136f, -0.18099362f, 0.02308099f, 0.01300578f, -0.03568289f, 0.03879537f, 0.12418655f, 
    0.28961763f, 0.15660700f, 0.07363566f, -0.03446069f, 0.04281797f, 0.08606580f, 0.12485898f, 0.05969023f, 
    -0.46755719f, 0.03259672f, 0.07602473f, -0.29333812f, -0.02956329f, -0.02750935f, 0.08698853f, 0.02476549f, 
    0.02050013f, 0.05839891f, -0.10364904f, 0.06096043f, -0.25063452f, 0.16047269f, -0.09106350f, -0.13173392f, 
    -0.13761349f, 0.17187224f, -0.05789292f, 0.13630725f, -0.10047884f, 0.00170724f, -0.08586287f, -0.14644283f, 
    -0.04019945f, 0.24956758f, -0.18028703f, -0.01222082f, 0.16799569f, 0.09498391f, 0.08519657f, -0.16598791f, 
    -0.11758940f, -0.05021900f, 0.04269453f, 0.17726822f, -0.36376995f, -0.09864338f, -0.02906694f, -0.01127269f, 
    -0.08481719f, -0.03800750f, -0.07990520f, 0.15529452f, 0.00006721f, -0.06037432f, -0.08174404f, -0.11792792f, 
    0.21323159f, 0.25146735f, -0.07543187f, -0.22119848f, -0.00523179f, -0.02966250f, -0.04997297f, -0.08593382f, 
    -0.07793546f, 0.02998768f, 0.08761706f, -0.15097332f, 0.27425247f, 0.09435102f, 0.08254340f, 0.04082454f, 
    0.21262750f, 0.07296676f, -0.00122269f, 0.00397493f, 0.01652728f, -0.10580839f, -0.04412410f, -0.02234200f, 
    0.07387807f, 0.17201017f, -0.10813293f, 0.23731987f, 0.05157172f, 0.09242455f, -0.08323572f, -0.13893029f, 
    -0.02540378f, 0.06184630f, 0.07388751f, -0.09256544f, -0.05308168f, -0.08936147f, 0.04093118f, 0.41280824f, 
    -0.00025335f, -0.00760868f, -0.07220143f, -0.03678966f, -0.00046180f, 0.03845865f, -0.08740747f, -0.04279454f, 
    0.15986638f, -0.24475142f, 0.09478490f, 0.13718545f, 0.08631182f, -0.03486457f, -0.04855923f, 0.03655682f, 
    -0.10944613f, 0.03436877f, -0.01660104f, -0.06486030f, -0.10770373f, 0.37831339f, 0.00894869f, 0.01853727f, 
    -0.05116254f, -0.08629914f, 0.04139461f, 0.03734665f, 0.12573728f, 0.03577843f, 0.00564647f, -0.08197224f, 
    -0.12397025f, 0.14728118f, -0.02026234f, -0.01149700f, -0.00930434f, -0.11164815f, -0.03652859f, 0.04403593f, 
    0.07878874f, 0.02091299f, 0.02249193f, 0.21664335f, -0.15702862f, -0.12087344f, -0.02139514f, -0.09215911f, 
    -0.08296996f, 0.15068372f, -0.03563147f, 0.00650241f, 0.00094168f, 0.14068139f, 0.01558191f, -0.00292079f, 
    0.10197069f, -0.22620730f, 0.11565175f, 0.22358005f, 0.08238858f, 0.08703981f, -0.04439805f, -0.10558302f, 
    0.05559815f, 0.04684132f, -0.03827769f, -0.08535603f, 0.15874550f, 0.15102082f, 0.15400238f, -0.04396538f, 
    -0.01337471f, -0.04341684f, -0.21633163f, 0.00716540f, 0.06253608f, -0.05418267f, -0.12670498f, 0.15619640f, 
    0.01910440f, -0.00964698f, 0.00971493f, -0.08114678f, 0.02918746f, 0.01851211f, -0.02514755f, -0.00714697f, 
    -0.04876700f, -0.13733432f, 0.01883921f, 0.08233631f, -0.33090642f, 0.21445851f, -0.01651448f, 0.02564599f, 
    -0.00252571f, -0.13696608f, 0.23740236f, 0.00473227f, 0.06350172f, -0.05130183f, 0.04898243f, 0.01864981f, 
    -0.01334173f, 0.07781438f, 0.06035509f, -0.04115562f, 0.03395206f, 0.12997855f, 0.09245656f, -0.17726924f, 
    -0.13511974f, -0.09595665f, 0.11413266f, 0.08035040f, -0.01688222f, -0.12832063f, 0.17746650f, -0.23777907f, 
    0.05961943f, -0.02771854f, 0.13189991f, 0.00563991f, 0.00787978f, 0.06264271f, 0.02904546f, -0.09755554f, 
    -0.12027465f, 0.13169076f, 0.11903568f, 0.00129063f, -0.05919898f, -0.05651087f, -0.01574712f, 0.00603704f, 
    -0.01666384f, 0.09581781f, 0.16703953f, -0.06330386f, -0.39971200f, -0.08117388f, 0.12788577f, 0.17949778f, 
    -0.11755466f, -0.02349611f, -0.09146253f, 0.04617164f, 0.01098023f, -0.12731472f, 0.00386157f, 0.06546304f, 
    0.29899633f, -0.10117324f, 0.02559338f, -0.14716049f, 0.08778607f, 0.01688277f, 0.03819256f, 0.00966084f, 
    0.10629781f, -0.06144490f, 0.04683896f, 0.03548912f, -0.10764267f, 0.13479540f, 0.21039847f, -0.09873064f, 
    0.06677864f, -0.08701576f, 0.00019207f, -0.00476577f, 0.00750634f, 0.06722029f, -0.02434986f, 0.10698077f, 
    -0.04602827f, 0.11716029f, 0.07356948f, -0.02355884f, 0.03199495f, -0.13773260f, 0.06255184f, 0.04614589f, 
    0.11230903f, -0.03976402f, 0.03354479f, 0.28898686f, 0.13657936f, -0.07776528f, 0.00443276f, 0.04450930f, 
    0.00236023f, -0.11986010f, 0.06518389f, 0.00515562f, -0.02037140f, -0.12512366f, 0.03956648f, -0.06852575f, 
    0.06630349f, 0.01955760f, 0.02479431f, -0.22947598f, 0.11671997f, 0.14399444f, 0.06231973f, 0.06845495f, 
    0.05919629f, 0.08740360f, -0.30584770f, -0.10309123f, -0.16082902f, 0.00300623f, 0.07242706f, 0.03477803f, 
    0.04992009f, 0.09151869f, 0.04413934f, -0.10412395f, 0.19431640f, -0.13798115f, 0.12107369f, 0.03015074f, 
    -0.04133817f, 0.09002958f, 0.00710190f, 0.03680569f, 0.08610845f, 0.07727291f, -0.13965710f, -0.12349042f, 
    -0.01629379f, -0.16396925f, -0.09498602f, -0.22650148f, 0.16132416f, 0.11197477f, -0.17371571f, 0.07906980f, 
    0.12640917f, 0.03556425f, -0.13263245f, -0.11011453f, 0.00439139f, 0.02845534f, 0.09650356f, 0.09145810f, 
    -0.07728279f, -0.02245681f, 0.23356678f, -0.04647195f, 0.01670674f, 0.07990385f, -0.06671084f, -0.01687258f, 
    -0.00786013f, 0.18293066f, 0.06041943f, 0.08755413f, -0.24385606f, 0.06602088f, -0.04407410f, 0.12922195f, 
    0.13144983f, -0.07617275f, 0.21669330f, -0.02023866f, -0.08807363f, -0.06869701f, -0.01637315f, -0.02330498f, 
    0.01909818f, 0.08483139f, -0.04100029f, 0.01963475f, 0.11559015f, 0.08808722f, -0.11797766f, 0.21864113f, 
    -0.05171516f, 0.04403695f, 0.00800254f, 0.04461736f, -0.03247446f, -0.04451726f, -0.13844225f, -0.14959604f, 
    -0.08926953f, -0.06338009f, 0.09203711f, -0.13044205f, 0.12611236f, 0.07393880f, -0.07606605f, -0.05845657f, 
    -0.13814640f, -0.03777258f, 0.08801219f, -0.07506350f, -0.06487930f, -0.10156461f, -0.01097906f, 0.08221556f, 
    0.01492208f, 0.07248271f, 0.23585637f, 0.00014542f, 0.00300273f, 0.02829946f, 0.05136677f, 0.10374862f, 
    0.03754520f, -0.04445599f, 0.03951143f, 0.07210506f, 0.00268172f, -0.05703199f, 0.13646035f, -0.02768914f, 
    -0.02797001f, 0.02106420f, 0.15514240f, -0.09974227f, 0.16329767f, 0.09729800f, 0.07626444f, -0.04643632f, 
    -0.02336292f, 0.11593001f, 0.14420782f, -0.07350168f, -0.01709342f, -0.06791831f, 0.00871584f, 0.18897487f, 
    0.02158712f, 0.15595770f, 0.03524018f, 0.05001984f, 0.03305173f, -0.14183649f, -0.08993205f, 0.07634015f, 
    -0.00994859f, 0.08700547f, 0.00280448f, 0.18738997f, 0.11100924f, -0.17354310f, 0.04585156f, -0.02611215f, 
    -0.05471356f, -0.07795805f, -0.09137534f, 0.12785645f, -0.23235855f, -0.20696633f, -0.14464949f, -0.07451322f, 
    0.06747744f, 0.02773265f, -0.15760271f, 0.00525454f, -0.07157222f, 0.08344226f, 0.12689330f, 0.06962502f, 
    0.02826692f, -0.03163091f, -0.00440356f, 0.01985712f, 0.01557183f, -0.01689371f, -0.00384189f, -0.05919625f, 
    0.05827898f, -0.05291280f, -0.04214993f, 0.05376294f, -0.08102913f, 0.05459050f, 0.02388994f, -0.01148244f, 
    -0.00621874f, -0.07262161f, -0.07229652f, 0.02894657f, 0.01325929f, -0.06297969f, -0.04193186f, -0.05160279f, 
    -0.06269737f, -0.03128334f, 0.06297076f, -0.06471478f, 0.01270101f, 0.02428951f, 0.05475513f, 0.01744091f, 
    -0.04390628f, -0.02301101f, -0.04533688f, -0.02537395f, -0.04817778f, 0.04373003f, -0.02560371f, -0.03260841f, 
    -0.03828117f, -0.05970085f, -0.05814325f, 0.01411955f, 0.03097825f, -0.03103012f, 0.06298339f, 0.06152435f, 
    0.01273285f, -0.02805534f, -0.05475903f, 0.01135170f, -0.00228713f, -0.06092433f, -0.00157313f, -0.04404755f, 
    -0.02066781f, 0.03781596f, 0.04067041f, -0.04493477f, -0.00878883f, 0.02381667f, 0.01838710f, 0.02117994f, 
    0.02629161f, 0.03265259f, -0.05769369f, 0.04927947f, 0.04164036f, 0.01942511f, -0.05386774f, 0.05112690f, 
    0.01624162f, -0.01517461f, -0.05842534f, 0.02947851f, 0.01923054f, -0.02959620f, -0.03357782f, -0.05201133f, 
    0.03746606f, 0.04061951f, 0.01171152f, 0.00472484f, -0.04068706f, -0.04211297f, -0.01381005f, -0.03465190f, 
    -0.04162202f, -0.07535291f, -0.03346528f, 0.04767350f, -0.00688249f, -0.01944308f, 0.00209912f, -0.05264883f, 
    -0.00172229f, 0.01655046f, -0.02642434f, -0.04539322f, -0.05391486f, 0.04316057f, 0.05292063f, 0.00370565f, 
    0.03199120f, -0.00558125f, -0.06864521f, -0.05298152f, 0.01628518f, 0.05449042f, -0.00999059f, 0.05890736f, 
    -0.07287361f, -0.06213775f, 0.01745963f, -0.02972957f, -0.06018725f, 0.01017922f, -0.07796302f, 0.00308819f, 
    0.00530735f, -0.07222959f, 0.02963186f, -0.01718967f, 0.02660733f, -0.02996993f, -0.02001326f, 0.03973038f, 
    -0.05625742f, -0.01300470f, -0.06320682f, 0.05617366f, -0.07168095f, -0.06653643f, -0.06473246f, 0.03973810f, 
    0.03680101f, -0.06265081f, -0.01258229f, 0.02138730f, -0.06268529f, 0.00821062f, -0.06827469f, -0.00862340f, 
    -0.04164534f, 0.02266248f, -0.02966834f, -0.02518284f, -0.01253236f, 0.05941789f, 0.03643850f, 0.01401485f, 
    -0.06295384f, -0.05109771f, 0.05786267f, -0.04841188f, -0.04450866f, -0.03339611f, 0.04875664f, -0.07471099f, 
    0.05700378f, 0.06719473f, -0.01007527f, -0.02533998f, -0.00428510f, 0.04582913f, 0.03542455f, -0.05423643f, 
    0.03249460f, -0.07082915f, -0.02125772f, -0.02900383f, -0.02491913f, 0.03061262f, 0.04450251f, -0.03955976f, 
    -0.05709273f, 0.05081040f, -0.00591915f, -0.06996739f, -0.07112203f, 0.02163055f, -0.01820399f, 0.00727473f, 
    -0.05991613f, 0.04680400f, 0.01706444f, -0.02962920f, -0.02051173f, -0.05330357f, -0.05694763f, -0.06210530f, 
    -0.11636616f, 0.28897202f, 0.03741230f, -0.21925597f, 0.12576379f, 0.07873575f, 0.02715736f, 0.10727892f, 
    0.07137073f, -0.00853411f, -0.08742364f, 0.13428794f, 0.15043144f, 0.00715901f, -0.09006093f, 0.10638859f, 
    0.11252090f, -0.06273732f, 0.02123982f, -0.12318388f, 0.07648651f, -0.03001115f, 0.04948444f, 0.01360449f, 
    0.14484353f, -0.05132846f, 0.08617322f, 0.02645305f, -0.01001709f, 0.05013803f, -0.13398267f, 0.01559166f, 
    0.12106210f, 0.02907191f, -0.01509968f, 0.02426549f, -0.13775180f, -0.11599731f, 0.06776842f, 0.09855806f, 
    -0.05731202f, 0.02622094f, 0.00220516f, -0.08896797f, -0.07632779f, 0.09340616f, 0.02856745f, 0.05365513f, 
    -0.16144119f, 0.06650411f, -0.12894046f, -0.10353856f, -0.02359846f, 0.12060630f, -0.17061125f, -0.01034018f, 
    0.03537861f, 0.03090057f, 0.08493982f, -0.05752917f, -0.06379614f, 0.07246570f, -0.14567707f, 0.28483099f, 
    0.11498014f, -0.03705922f, -0.00303722f, 0.13267297f, 0.07595295f, -0.02201295f, 0.04405189f, 0.05472133f, 
    -0.23260452f, 0.29223761f, 0.08417891f, -0.08367948f, 0.02910858f, 0.10903300f, 0.13404083f, 0.10176858f, 
    -0.02139125f, -0.07450394f, 0.07308638f, 0.03908461f, 0.14975892f, -0.02747531f, -0.07321864f, -0.03788161f, 
    0.02049752f, 0.09546851f, 0.08803893f, 0.09061165f, 0.04041390f, -0.08943152f, 0.06516693f, -0.03014642f, 
    -0.05258555f, 0.21691225f, -0.03581130f, -0.00577697f, 0.19460112f, 0.04015273f, -0.00303944f, 0.26399669f, 
    -0.01776091f, 0.03589956f, 0.08263358f, 0.03487839f, 0.04437561f, -0.25162998f, -0.13095574f, 0.05542617f, 
    -0.08302999f, 0.01440182f, -0.10820694f, 0.06620303f, -0.13826744f, -0.04216855f, -0.05809319f, -0.08179977f, 
    0.05047449f, -0.03837408f, 0.23404968f, -0.21965151f, -0.09741764f, -0.03018198f, -0.04392882f, -0.03891223f, 
    0.04889170f, -0.09401982f, 0.22652207f, -0.08893353f, 0.38591498f, -0.26576364f, 0.03593296f, 0.12898949f, 
    0.03882828f, 0.01969425f, -0.01052692f, 0.03725282f, 0.11424743f, -0.00572533f, 0.00389926f, 0.04453421f, 
    0.26304036f, -0.06165482f, 0.06212048f, -0.20775510f, 0.02005099f, -0.00389522f, 0.11543930f, 0.06490012f, 
    -0.01972282f, 0.01232065f, -0.05095418f, -0.14744271f, 0.09127366f, -0.13704970f, -0.00265301f, -0.07763619f, 
    0.08590573f, 0.12987293f, 0.18096976f, -0.10853997f, 0.01618338f, 0.10314977f, 0.03130210f, 0.11069398f, 
    -0.15969487f, -0.18975738f, 0.15160190f, -0.15659912f, 0.07784542f, 0.08249660f, -0.00762140f, 0.03783001f, 
    -0.00543354f, 0.00524457f, -0.05398679f, 0.08130986f, -0.09903005f, -0.11710089f, -0.17819972f, -0.12834762f, 
    -0.09044660f, 0.11486419f, -0.00571906f, 0.12393928f, -0.02137540f, 0.02772291f, 0.12309638f, -0.04976591f, 
    0.19176732f, 0.16298653f, 0.05187602f, 0.13587657f, 0.10241098f, -0.03883043f, 0.00912950f, -0.12913097f, 
    0.00310673f, -0.02695236f, -0.13611108f, -0.21017537f, 0.12525368f, -0.11185031f, 0.02436310f, 0.20252317f, 
    -0.11932016f, -0.05126772f, 0.00643524f, 0.13210070f, -0.06288221f, 0.00934790f, -0.03387505f, 0.13857406f, 
    -0.10978178f, -0.00780467f, -0.03623065f, 0.03049124f, 0.06619998f, 0.00463341f, 0.04884540f, -0.00297291f, 
    -0.09159849f, -0.01334454f, 0.06089195f, 0.06187460f, 0.12123309f, -0.02297727f, -0.06764506f, 0.00852883f, 
    -0.08533104f, -0.00932227f, -0.03845466f, 0.03228907f, 0.04226532f, 0.06784210f, -0.06431718f, 0.11285292f, 
    -0.17815481f, -0.07186677f, -0.10889830f, -0.08891775f, 0.04156256f, -0.07451507f, -0.12831479f, 0.09795088f, 
    -0.05511992f, -0.08955529f, 0.00156894f, 0.20649934f, -0.27237162f, 0.09987801f, 0.07886576f, -0.02113192f, 
    0.22474864f, 0.04219070f, 0.09431618f, -0.08024620f, 0.04730491f, 0.05085373f, 0.07184711f, 0.01796605f, 
    0.35906634f, 0.04163789f, 0.00945069f, 0.15185001f, -0.09147052f, -0.02335545f, -0.05283465f, -0.09657051f, 
    -0.01033958f, -0.06452771f, 0.00172137f, 0.00028321f, 0.00481568f, 0.11006600f, 0.17957765f, 0.17494635f, 
    0.08407056f, 0.00395341f, -0.13491279f, -0.09394272f, -0.08113299f, 0.16056411f, 0.08079375f, 0.07058828f, 
    -0.17243062f, -0.01462991f, -0.01846337f, -0.11048862f, 0.09972372f, 0.04268340f, -0.06121576f, 0.06867850f, 
    0.02197192f, 0.05524392f, 0.01285225f, -0.04524171f, -0.18083560f, -0.16324845f, 0.10772011f, 0.05232681f, 
    0.21000746f, 0.00954880f, 0.04834313f, 0.03823111f, 0.03892798f, 0.02303760f, -0.15211686f, -0.05008807f, 
    -0.16578540f, 0.21508564f, -0.04458125f, -0.30428299f, 0.09056333f, -0.13065191f, 0.10953856f, -0.02965873f, 
    -0.04269573f, 0.01719538f, -0.09214444f, 0.06023437f, -0.20912845f, 0.03280658f, 0.08175455f, -0.12041286f, 
    0.18126065f, 0.07095776f, 0.13307357f, 0.08482049f, -0.09910293f, -0.05319194f, -0.01296296f, -0.00512971f, 
    -0.11457500f, 0.23116581f, 0.16010717f, -0.04061910f, 0.04071499f, -0.11387173f, 0.11058834f, -0.20231637f, 
    -0.03362964f, -0.02973249f, -0.00023028f, -0.12542109f, -0.08300515f, 0.01396762f, -0.06567435f, -0.03454263f, 
    0.14908105f, -0.14092460f, 0.01344673f, -0.04231236f, 0.11348182f, 0.08708464f, -0.03665805f, 0.06947725f, 
    0.46725911f, 0.12251912f, 0.20893458f, 0.09224853f, 0.02770117f, 0.01859707f, -0.08699182f, 0.04070449f, 
    0.06995912f, 0.08945346f, 0.21391255f, 0.08969011f, 0.08946374f, 0.05748767f, 0.20895092f, 0.11858537f, 
    0.09511312f, 0.05477731f, 0.04661167f, 0.03834136f, 0.11724073f, -0.05435626f, 0.00642647f, 0.05913458f, 
    -0.07739221f, 0.03255837f, 0.03771700f, 0.02808356f, -0.04967875f, 0.01196012f, -0.06171024f, -0.01452984f, 
    -0.03589023f, -0.05398407f, 0.04132384f, 0.00058197f, 0.01856550f, 0.00373394f, 0.05243114f, 0.00292708f, 
    0.06243175f, -0.06804895f, -0.04527462f, -0.05296717f, 0.05334887f, -0.04231135f, -0.06054748f, 0.00206435f, 
    -0.02504780f, -0.07815373f, 0.06185222f, -0.02157121f, 0.05461195f, 0.01924009f, 0.05576180f, -0.06874643f, 
    -0.01305910f, -0.05666315f, 0.03820529f, 0.02788980f, -0.05413181f, -0.03130814f, -0.04386346f, 0.00118547f, 
    -0.01468107f, -0.06852839f, -0.02799798f, 0.04225982f, 0.00396928f, -0.06747801f, 0.04875274f, 0.02326536f, 
    -0.07584457f, -0.05907981f, -0.00171196f, -0.01079273f, -0.06178565f, 0.03240507f, 0.00294711f, -0.01165798f, 
    -0.02179851f, 0.00480207f, 0.02736688f, 0.00946808f, -0.04517080f, -0.01196786f, -0.01231194f, -0.04959239f, 
    0.03662948f, 0.04017012f, 0.01584928f, -0.01016128f, -0.06573545f, -0.06500832f, 0.06236396f, -0.06861486f, 
    0.03948536f, -0.06445546f, 0.01238053f, 0.01308592f, -0.00894410f, -0.05465443f, 0.06396540f, 0.05689100f, 
    -0.03184271f, 0.01090239f, -0.05177804f, -0.05540475f, 0.00489363f, -0.02767169f, 0.02975620f, -0.07003036f, 
    -0.04904675f, -0.05353042f, 0.06558804f, -0.00239073f, 0.01507485f, -0.01582008f, 0.02312467f, 0.03660131f, 
    0.05922358f, 0.01337533f, -0.05801092f, 0.04060734f, 0.03720556f, -0.05283618f, -0.05551983f, -0.00738624f, 
    -0.06490979f, -0.03311845f, 0.01248857f, 0.04452496f, 0.04832489f, -0.07496218f, 0.01353424f, 0.01409045f, 
    -0.01052878f, -0.00662797f, -0.03149879f, -0.00756688f, 0.00213971f, -0.06775049f, -0.02657226f, -0.05484106f, 
    -0.06512766f, -0.05471323f, 0.00509874f, 0.06179780f, -0.07655675f, 0.05831179f, 0.03358396f, -0.00745248f, 
    0.06004270f, -0.06000802f, 0.00811889f, 0.04806426f, -0.03455856f, 0.02826575f, 0.01136936f, -0.04603166f, 
    -0.06603325f, -0.04672424f, 0.01346707f, 0.06610028f, -0.05981323f, -0.02150241f, 0.02791863f, 0.00264116f, 
    -0.01775966f, -0.05519007f, -0.07451816f, 0.04921509f, -0.06010258f, -0.01473337f, 0.02637569f, 0.02491312f, 
    0.02554014f, -0.06781648f, 0.05204418f, -0.01860924f, -0.06793257f, -0.02071683f, 0.00034394f, 0.01011682f, 
    -0.00679495f, 0.04585264f, -0.05167541f, -0.06773451f, -0.06842600f, -0.06558634f, -0.03651590f, 0.01134468f, 
    0.01998438f, -0.01258055f, 0.05513811f, -0.02031981f, -0.02134197f, -0.00962074f, 0.00255260f, 0.01208978f, 
    -0.01768916f, 0.05730188f, 0.00634837f, -0.03443851f, 0.01391872f, -0.02431883f, 0.01929768f, 0.00941037f, 
    0.04987697f, -0.06022543f, -0.00052831f, 0.01480544f, -0.02497295f, 0.01280379f, 0.05796497f, -0.02107383f, 
    -0.06216732f, -0.05236767f, -0.01939133f, 0.06459483f, -0.06723526f, -0.04387430f, 0.04597629f, 0.03759734f, 
    -0.00062579f, 0.06499773f, 0.04502055f, -0.01605076f, 0.02493194f, -0.02961265f, -0.05409780f, -0.00782975f, 
    -0.02679378f, -0.02663477f, -0.07147411f, -0.02139372f, -0.00702223f, -0.07272581f, 0.05454212f, 0.06230551f, 
    -0.04788803f, 0.01333383f, -0.03091065f, -0.03855674f, -0.04839940f, -0.03585486f, 0.01202419f, -0.03081367f, 
    -0.01823039f, -0.04591894f, 0.03544716f, -0.03021844f, -0.02408726f, 0.06035091f, 0.02200997f, 0.04084611f, 
    -0.06803530f, -0.04588056f, 0.00552360f, -0.01423037f, -0.06184132f, 0.06161712f, -0.06841040f, 0.03925739f, 
    0.04553902f, 0.03407238f, 0.04838450f, 0.04818792f, 0.04799259f, 0.03757075f, 0.01972661f, -0.04806982f, 
    -0.03515678f, 0.04266356f, 0.05771817f, -0.06400287f, -0.02634041f, -0.04490167f, -0.06089798f, 0.06067055f, 
    0.00615767f, 0.02265933f, -0.04227036f, -0.02304015f, 0.03746786f, -0.05858168f, -0.00548994f, -0.02896816f, 
    -0.06590120f, 0.02374551f, -0.05972673f, 0.01939031f, 0.01077487f, -0.03987518f, 0.03067340f, -0.00172593f, 
    0.04102877f, 0.03662681f, -0.05906794f, -0.01502607f, 0.02340974f, -0.03982598f, 0.02540999f, 0.01404554f, 
    -0.02913122f, 0.02313278f, -0.06023455f, -0.04008685f, 0.00768827f, -0.04153767f, 0.03657380f, -0.03149094f, 
    -0.05305512f, -0.04092249f, 0.04737197f, 0.02470161f, 0.06109661f, -0.02244161f, -0.02213340f, 0.00961306f, 
    0.04918883f, 0.04009075f, -0.01545208f, 0.06837707f, -0.06006122f, -0.00711347f, -0.04333204f, -0.02797008f, 
    0.01307713f, -0.07671219f, -0.03635680f, -0.03904550f, -0.03787447f, -0.00395518f, -0.03504511f, -0.03015672f, 
    -0.07339667f, -0.01823893f, 0.02418815f, -0.07299615f, -0.00294629f, -0.03097572f, -0.03713175f, -0.04112706f, 
    0.00469959f, -0.05856547f, -0.01839370f, 0.01337297f, 0.02525132f, 0.03351324f, 0.04671282f, -0.02386377f, 
    -0.05607119f, -0.00972006f, -0.05962866f, 0.01079670f, 0.00242643f, -0.06649691f, 0.05082280f, -0.06738893f, 
    0.01115972f, 0.00892688f, -0.01450431f, 0.03702716f, -0.06428489f, 0.05740816f, 0.04263186f, -0.04569996f, 
    -0.04869467f, -0.05830844f, -0.00178742f, -0.06693048f, -0.01936076f, -0.05872983f, 0.00372913f, 0.03797135f, 
    -0.05325368f, -0.03825690f, -0.03059912f, 0.05045189f, 0.03244629f, -0.06356449f, -0.04995081f, 0.02531474f, 
    0.04187584f, -0.04388116f, 0.05759751f, -0.02747992f, 0.02629261f, -0.02927176f, -0.06344322f, 0.02272135f, 
    0.03969548f, -0.03259178f, 0.04985020f, -0.07546776f, 0.04866922f, 0.01789178f, -0.00964214f, -0.05915389f, 
    0.02469032f, -0.00191002f, 0.04759388f, -0.04031124f, -0.05830786f, -0.06116869f, -0.06066890f, -0.03382738f, 
    0.09632593f, 0.18600452f, -0.16826238f, -0.11710987f, -0.05602797f, -0.02867658f, -0.06483655f, 0.01672052f, 
    0.11909743f, 0.09353825f, 0.07785299f, 0.10966216f, 0.21346511f, -0.15280068f, 0.07936994f, 0.42291257f, 
    0.13599896f, -0.08012836f, 0.08585456f, -0.14006764f, 0.12872724f, 0.09264115f, 0.02190676f, 0.03951602f, 
    -0.11255934f, 0.02763545f, 0.02640084f, -0.00204631f, 0.11475215f, 0.06953868f, 0.06391548f, -0.01765095f, 
    0.01176488f, 0.09311738f, 0.02228992f, -0.03248645f, 0.21438910f, 0.17524073f, 0.09326459f, 0.08061689f, 
    -0.05032256f, 0.13916977f, -0.00158715f, -0.04476367f, 0.05953371f, 0.10175256f, -0.10889944f, 0.05409742f, 
    -0.20835517f, 0.01410557f, -0.09055115f, 0.04343460f, -0.03329100f, -0.01218380f, 0.03026200f, 0.07916935f, 
    0.07807472f, 0.05348910f, 0.08627306f, -0.13665292f, 0.14624752f, -0.15198888f, -0.18292671f, 0.07502291f, 
    -0.07312074f, -0.06223143f, 0.06553189f, -0.02826383f, -0.08552579f, 0.04077084f, 0.00104402f, 0.00800039f, 
    0.00940064f, 0.21350501f, 0.15163893f, 0.00621750f, 0.12585045f, 0.10668248f, 0.02074844f, 0.03345569f, 
    0.16352992f, -0.04793573f, 0.06176246f, -0.03144724f, 0.08892772f, 0.01391742f, 0.12910320f, -0.34505856f, 
    -0.15367565f, 0.05306261f, -0.02284625f, 0.00228292f, 0.10211930f, 0.15803993f, -0.04784849f, 0.06313819f, 
    -0.05186998f, 0.06498144f, -0.11065736f, 0.20371176f, -0.01897309f, 0.10395445f, 0.11872344f, 0.00497697f, 
    -0.02004987f, 0.03401183f, 0.00891217f, -0.01843398f, 0.01602152f, 0.39287865f, -0.03207731f, -0.12430839f, 
    -0.13372469f, 0.01234683f, 0.13767478f, -0.01569605f, -0.04076442f, 0.03611772f, 0.05686238f, -0.02871030f, 
    0.33730841f, -0.59304595f, 0.19533972f, 0.38615900f, 0.06662005f, 0.10706497f, -0.03038313f, -0.09168182f, 
    -0.00348332f, -0.12075783f, -0.03448944f, 0.16262671f, -0.10832796f, 0.18150631f, 0.13877364f, -0.01960215f, 
    0.00743880f, 0.00535237f, 0.08978010f, -0.02515883f, 0.04170728f, 0.03007172f, 0.06085525f, -0.03328630f, 
    0.07884284f, -0.04777557f, 0.12192550f, -0.07514849f, -0.16565570f, 0.03979436f, 0.02899343f, 0.08311971f, 
    0.07600468f, -0.13679968f, -0.07888234f, -0.01049438f, 0.23713820f, -0.34469375f, 0.02210232f, 0.19542097f, 
    -0.03889864f, 0.00262199f, -0.10420989f, -0.13293169f, 0.14750028f, 0.05006423f, -0.00149337f, 0.03751430f, 
    -0.37194461f, -0.26955530f, 0.10097227f, -0.13343862f, -0.06379382f, 0.20816837f, -0.17949000f, 0.01516164f, 
    -0.02020426f, 0.11054227f, -0.01710517f, -0.06533354f, 0.04778542f, 0.22914444f, -0.02568888f, -0.06494668f, 
    -0.07199050f, -0.03022269f, 0.01550170f, 0.02657052f, 0.00227275f, 0.08702333f, 0.06190450f, -0.02111810f, 
    -0.01654660f, -0.06462283f, -0.01958092f, 0.02614979f, 0.01002663f, -0.07106648f, 0.00804738f, -0.03327451f, 
    0.04344416f, -0.04381730f, -0.05361153f, 0.05389837f, -0.07527011f, -0.01293519f, 0.04538640f, -0.03712674f, 
    0.01400105f, -0.02773627f, 0.02644838f, -0.05481652f, -0.00836177f, -0.00708052f, -0.04369663f, 0.01237988f, 
    -0.06787903f, -0.03676089f, 0.02814472f, 0.05869418f, -0.00398821f, -0.06778257f, -0.03519031f, -0.03122265f, 
    -0.04795950f, -0.04019874f, 0.01251530f, -0.07171924f, -0.06832554f, 0.00959771f, 0.00423135f, 0.02078366f, 
    0.03014715f, -0.01904417f, -0.03020281f, -0.01969000f, 0.02680415f, 0.00644031f, -0.02786896f, 0.00467447f, 
    -0.07686315f, -0.06560318f, 0.00303653f, -0.01025998f, 0.02107830f, 0.02579434f, -0.07359990f, -0.03947346f, 
    -0.06096787f, -0.01925451f, -0.02424866f, 0.03875456f, 0.04171775f, -0.03395008f, -0.03900452f, 0.01228219f, 
    0.05658294f, -0.06313786f, 0.04405367f, -0.05563651f, 0.06006162f, 0.03795154f, -0.04210823f, 0.05938168f, 
    -0.01311556f, 0.02558558f, -0.05053601f, -0.04349983f, -0.04933716f, -0.06120265f, 0.05274476f, -0.02936953f, 
    0.03428751f, 0.00538986f, 0.00363491f, -0.04674697f, -0.03429708f, -0.04592199f, -0.00874026f, 0.03393996f, 
    0.02896313f, -0.07144005f, -0.03136374f, -0.00019422f, 0.00971524f, -0.02335021f, -0.05209556f, -0.03276111f, 
    -0.03722496f, -0.02059607f, -0.00563941f, -0.00499773f, 0.06331936f, -0.05993664f, 0.02136118f, -0.01911669f, 
    -0.05960139f, -0.04037324f, 0.02990086f, 0.03067134f, 0.06374711f, 0.02148052f, 0.00265788f, 0.04047494f, 
    -0.04907854f, -0.02015532f, 0.03043991f, 0.05905137f, -0.06497420f, 0.02713531f, -0.02234200f, -0.00891047f, 
    0.03647993f, 0.02693488f, -0.05166794f, -0.04805755f, 0.06042372f, -0.01231179f, 0.04989431f, -0.05774147f, 
    0.02802623f, -0.05524156f, -0.06679562f, 0.02656578f, 0.06166532f, -0.06144865f, 0.00216546f, -0.02377801f, 
    -0.04932652f, 0.05775881f, -0.06357909f, 0.00199526f, -0.01220648f, 0.01856300f, -0.05195581f, 0.03241019f, 
    -0.01401799f, -0.07733595f, 0.05611094f, -0.02303179f, 0.06062493f, -0.03960390f, -0.05729077f, 0.04373650f, 
    -0.04734696f, 0.05206426f, -0.00794661f, -0.05552001f, -0.04219868f, -0.07188902f, 0.05852301f, 0.01277242f, 
    0.01573442f, -0.03708518f, 0.01644163f, 0.00467809f, -0.04435427f, 0.06397079f, 0.03490413f, -0.06547314f, 
    0.02382754f, -0.00263054f, 0.03670292f, -0.06598441f, -0.04381911f, -0.06000698f, -0.02641664f, -0.02733169f, 
    0.00117955f, 0.04765691f, -0.03431951f, -0.00981502f, -0.02485234f, 0.03206635f, 0.01382465f, -0.07232910f, 
    -0.03907083f, 0.02007528f, 0.04401078f, 0.03389228f, -0.05684358f, -0.00985305f, 0.02256543f, -0.05470535f, 
    -0.05757103f, -0.06424212f, -0.04292991f, 0.03376160f, 0.03148404f, 0.03937607f, -0.02057040f, -0.03463510f, 
    -0.05913402f, -0.03184749f, -0.06060300f, 0.04920980f, -0.07540582f, 0.00684614f, -0.01886112f, -0.05468383f, 
    0.04854444f, -0.01846234f, -0.01085587f, -0.03530399f, 0.05596139f, -0.06346727f, 0.02394063f, -0.03587592f, 
    -0.00843689f, -0.01094905f, 0.02140451f, 0.02020172f, 0.06859735f, -0.03021628f, -0.01743908f, -0.03225308f, 
    -0.04620839f, -0.07762864f, 0.03921669f, -0.04343805f, -0.06184100f, 0.01575202f, -0.06763195f, -0.04552105f, 
    -0.07315958f, 0.00481240f, 0.02790274f, 0.05901630f, -0.03033685f, 0.01736362f, -0.00520720f, -0.04571051f, 
    0.00201857f, -0.05385353f, 0.00306407f, 0.05377527f, 0.06508577f, 0.05418561f, -0.02743143f, 0.05075374f, 
    0.02948380f, 0.00813301f, 0.01599231f, -0.07845499f, -0.05608516f, 0.02385960f, -0.06909053f, -0.01517164f, 
    -0.05769639f, -0.00529681f, 0.06231944f, 0.06168159f, 0.03917322f, 0.02191510f, 0.06109369f, 0.04931813f, 
    0.02282532f, 0.04816715f, -0.04416471f, -0.02945031f, -0.03305681f, 0.06416940f, 0.01207869f, -0.01561730f, 
    0.00231889f, 0.03734159f, 0.05223141f, 0.06038710f, 0.04220298f, -0.04955614f, 0.01758271f, -0.01120721f, 
    0.00840093f, -0.01302144f, 0.02783869f, -0.03513289f, 0.03945157f, 0.04133141f, 0.02965488f, -0.01482350f, 
    -0.07006215f, 0.02542718f, -0.03392622f, -0.03001594f, 0.04875016f, 0.03419703f, -0.07802687f, -0.06834611f, 
    -0.07294546f, -0.01635211f, -0.01048587f, -0.00860255f, 0.05528953f, 0.03372241f, -0.07632744f, -0.07499154f, 
    -0.02346166f, 0.05560371f, -0.07429346f, -0.02394005f, 0.03398200f, -0.06494185f, 0.03234775f, 0.04503189f, 
    -0.04023482f, -0.03125121f, -0.05464510f, -0.00918317f, -0.02105363f, -0.05201708f, 0.06061579f, 0.03733751f, 
    -0.03672817f, 0.04326160f, -0.00056771f, -0.07838698f, 0.06207570f, -0.02887522f, -0.00691261f, 0.00468645f, 
    -0.02975969f, 0.04972137f, 0.03724435f, 0.04056845f, -0.00420015f, -0.01002168f, -0.06700851f, 0.03148336f, 
    0.04916440f, 0.02597911f, -0.01981334f, -0.05850616f, 0.03299363f, -0.05621575f, -0.01383040f, -0.07585300f, 
    -0.06275807f, 0.03352088f, -0.06352021f, -0.07840811f, -0.07593985f, -0.04470623f, -0.05780296f, 0.06038199f, 
    -0.06969326f, -0.07370599f, 0.03361070f, -0.02238456f, 0.00676272f, 0.04891090f, -0.07517829f, -0.07634249f, 
    0.04839769f, -0.07842090f, -0.05253070f, -0.04992291f, -0.05638814f, 0.00266780f, -0.06987821f, -0.05710590f, 
    -0.04311013f, 0.02155655f, -0.05320269f, -0.07253473f, -0.03085298f, -0.00431937f, 0.00824911f, 0.05638137f, 
    0.00885035f, -0.03656506f, 0.03480281f, -0.06991221f, -0.07675806f, 0.04101873f, -0.00949175f, -0.02890349f, 
    0.10246256f, -0.11243074f, -0.03456084f, 0.23050295f, 0.05258705f, 0.04849783f, 0.08649357f, -0.01426034f, 
    -0.14763544f, 0.04461281f, 0.00014096f, -0.11750682f, -0.05222879f, 0.17471753f, 0.01299463f, -0.06494162f, 
    -0.17938142f, -0.08373646f, -0.05247950f, 0.11851066f, -0.09303971f, 0.01257652f, 0.01704260f, 0.09101143f, 
    -0.22702804f, 0.16636147f, -0.01682170f, 0.01095912f, 0.07055539f, -0.06627747f, 0.06744411f, -0.03499642f, 
    -0.00205407f, -0.04864239f, -0.00402300f, -0.02099692f, 0.10484739f, 0.04670340f, 0.01915411f, -0.09218104f, 
    0.02385450f, 0.08763100f, -0.05784322f, -0.05688415f, -0.05496594f, -0.03230938f, -0.11530966f, 0.00304460f, 
    0.06558906f, 0.01898171f, 0.14117916f, 0.04127939f, 0.06080755f, -0.11906706f, 0.11772893f, 0.07100494f, 
    0.05789066f, -0.07631253f, -0.04787820f, 0.14981927f, 0.00731637f, 0.18477255f, 0.02109876f, -0.12047438f, 
    0.03741107f, 0.02394864f, 0.06792276f, 0.00437153f, 0.03789861f, 0.09055097f, 0.02171602f, -0.12893429f, 
    0.57180148f, -0.04324429f, 0.01070931f, 0.14524747f, -0.21033813f, 0.06098450f, 0.05937150f, 0.03770931f, 
    -0.13510589f, -0.16755311f, -0.04867847f, -0.02670667f, -0.13495034f, 0.12267993f, 0.24253519f, 0.21463716f, 
    -0.01412478f, -0.06821924f, -0.05270245f, -0.12007762f, -0.06129025f, 0.10886353f, -0.02125650f, 0.04465285f, 
    -0.23835024f, 0.05417484f, 0.06965628f, -0.25170502f, -0.02642724f, -0.08541593f, -0.12916818f, -0.04478306f, 
    0.02025235f, 0.08288946f, 0.08142208f, -0.10059430f, -0.16575921f, 0.02156449f, -0.04270062f, -0.07759596f, 
    0.15645047f, 0.01808054f, 0.01331967f, -0.17408353f, 0.11167025f, 0.12618840f, -0.03699225f, 0.16939753f, 
    0.00971449f, 0.32746711f, -0.04614367f, -0.10737435f, 0.03414553f, 0.10555997f, 0.11101250f, 0.10231923f, 
    -0.04545888f, 0.11136942f, -0.05652567f, -0.00988694f, -0.30550286f, 0.16867813f, 0.11071207f, -0.06586635f, 
    0.12814842f, 0.07469942f, 0.00944739f, 0.02465988f, -0.00624082f, -0.06480984f, -0.04959476f, -0.04303420f, 
    -0.21502517f, 0.08142028f, -0.00662325f, -0.04483640f, 0.08623158f, -0.01497385f, 0.09455822f, -0.10717446f, 
    0.04392620f, 0.09043419f, 0.05228496f, -0.05150382f, 0.06279591f, 0.13143627f, -0.06582960f, 0.04961578f, 
    -0.07229649f, -0.07150137f, -0.05781639f, 0.15790099f, -0.09643254f, 0.03747122f, 0.00156230f, -0.04875802f, 
    0.26533765f, 0.14922282f, 0.01944069f, 0.27182898f, 0.04628314f, -0.05913039f, 0.18585847f, 0.03497679f, 
    0.07161882f, 0.05999904f, 0.07333208f, 0.00497014f, 0.14133178f, 0.05075118f, 0.22760904f, 0.21693829f, 
    0.14528176f, -0.02620665f, 0.05323157f, -0.00883895f, 0.02670830f, -0.03750981f, -0.06469665f, 0.01145643f, 
    -0.03252194f, 0.05667825f, 0.04427208f, -0.02046882f, -0.04696649f, -0.03615180f, -0.00838707f, -0.02582902f, 
    -0.05507101f, 0.01593191f, -0.07503160f, -0.02924000f, -0.02388193f, 0.01742486f, -0.01554043f, 0.03088995f, 
    0.05038087f, -0.06129640f, -0.06440575f, 0.05520732f, -0.02319193f, 0.04993233f, -0.00902842f, 0.04424867f, 
    -0.04080323f, 0.04871680f, 0.03187140f, -0.02987934f, -0.05550990f, 0.05639891f, 0.04117415f, -0.03457023f, 
    -0.07500871f, -0.07527442f, 0.01441840f, -0.02437130f, -0.04153310f, 0.05570236f, 0.00509016f, -0.06362771f, 
    -0.05967243f, -0.02993277f, 0.01251618f, -0.05794907f, -0.00087605f, -0.02155384f, -0.06125013f, 0.05454490f, 
    -0.07434197f, 0.02285628f, -0.06720608f, 0.00759361f, -0.03611529f, 0.03122953f, 0.00198965f, -0.05041528f, 
    0.01963216f, -0.01737839f, 0.03317583f, 0.00760847f, -0.01470692f, -0.01304688f, -0.01885449f, 0.02303675f, 
    0.06460756f, -0.03554197f, 0.00470810f, -0.00519285f, -0.01418586f, -0.06885095f, -0.02447401f, 0.04607838f, 
    0.04570457f, -0.07941285f, 0.00369458f, 0.02456059f, 0.00265758f, -0.05574051f, 0.06721052f, -0.03115088f, 
    -0.06119075f, -0.01948027f, 0.05262874f, -0.01349715f, -0.07320245f, -0.05617233f, 0.05894732f, -0.05520355f, 
    -0.03327010f, -0.01317443f, 0.04742610f, 0.04684536f, -0.04224708f, 0.02644758f, -0.07217771f, -0.04942564f, 
    0.07132175f, 0.00860873f, 0.06170393f, 0.05537426f, -0.04396341f, 0.05755880f, -0.07012223f, 0.03585863f, 
    -0.02522730f, -0.07337936f, -0.00851567f, 0.02116901f, 0.01298248f, -0.02595195f, 0.02793883f, -0.03660028f, 
    -0.04489877f, -0.02648458f, 0.02854819f, 0.05260937f, 0.03258752f, 0.03682645f, -0.01243753f, -0.01725281f, 
    0.04281856f, -0.01053744f, 0.06212128f, 0.04642586f, -0.07877955f, -0.07292498f, 0.04362687f, 0.04427585f, 
    0.03798755f, -0.00617472f, 0.00540027f, 0.00809637f, -0.08616195f, 0.00217673f, -0.03222132f, -0.05746597f, 
    0.05634519f, -0.05422608f, -0.06193002f, -0.04345289f, 0.03371107f, -0.00951620f, 0.00521289f, -0.00842180f, 
    -0.05310048f, -0.06589772f, -0.04738357f, 0.04544096f, -0.05137103f, 0.03961186f, -0.01328902f, 0.01757672f, 
    0.03836155f, -0.04266984f, 0.05638479f, -0.01223696f, -0.00553038f, 0.02077921f, -0.04042796f, 0.00427927f, 
    -0.03030487f, -0.03433701f, -0.02178763f, 0.06101750f, -0.01112580f, 0.04517028f, 0.02807150f, -0.02723117f, 
    0.02732247f, 0.05215894f, 0.06407837f, -0.02539394f, -0.07200350f, -0.05571534f, -0.05416454f, -0.06063225f, 
    0.00085771f, -0.03055453f, -0.07115559f, -0.05767536f, 0.01173364f, 0.05792882f, -0.07527935f, -0.02349856f, 
    0.01148174f, -0.06876420f, 0.01626135f, -0.06959774f, -0.03302755f, 0.01168376f, -0.00180020f, 0.04931736f, 
    0.17434111f, 0.20298453f, -0.11678708f, -0.00008175f, 0.12114354f, -0.00564417f, 0.06705568f, -0.08828053f, 
    0.04551479f, 0.05844268f, 0.05367977f, 0.12026015f, 0.01546862f, -0.19301826f, -0.04080192f, 0.20718436f, 
    0.06075086f, 0.01151532f, -0.04081751f, 0.07040526f, 0.03723659f, 0.03061239f, 0.14096266f, -0.01833563f, 
    0.43847695f, -0.17539607f, 0.03596807f, 0.16477904f, 0.06295998f, 0.17780818f, 0.11713616f, 0.17006439f, 
    0.01519287f, 0.01315673f, -0.12375603f, 0.06540678f, -0.07932144f, 0.07669447f, 0.07236503f, 0.20017800f, 
    -0.08418889f, 0.02727884f, 0.00609603f, 0.00016652f, -0.01290709f, -0.00402547f, 0.10596807f, 0.11912651f, 
    -0.35889900f, -0.04955120f, -0.05120663f, -0.14856185f, -0.12711997f, 0.06264296f, -0.11364681f, 0.10579560f, 
    0.13856316f, 0.06804361f, 0.10357566f, -0.02447395f, -0.01046857f, -0.05168553f, 0.11137921f, 0.12668732f, 
    0.03091512f, 0.04231548f, -0.07590296f, 0.01007735f, 0.13424297f, 0.06995734f, 0.03332866f, 0.13060860f, 
    -0.14255261f, -0.05867740f, 0.13327624f, 0.03500300f, 0.00664115f, -0.00799930f, -0.02155430f, -0.09447474f, 
    0.11175548f, 0.05105191f, 0.03930650f, 0.06797929f, 0.16190654f, 0.22434242f, 0.07150771f, 0.04732671f, 
    -0.04152124f, 0.07741874f, -0.09174046f, 0.03186521f, 0.06452912f, -0.00338401f, -0.10078964f, 0.07086535f, 
    0.00719964f, 0.05526472f, -0.04260223f, -0.02657047f, 0.09483264f, 0.21840015f, -0.01177091f, 0.27290738f, 
    -0.10332098f, -0.11715721f, -0.00894525f, 0.07138769f, -0.30230960f, -0.12292125f, -0.03233856f, 0.13759029f, 
    -0.09179248f, -0.09679119f, 0.20667508f, -0.09071127f, -0.11769082f, 0.06909170f, 0.03398965f, -0.09784847f, 
    -0.19172779f, -0.04311603f, -0.05236480f, -0.37923780f, -0.02366724f, -0.01760496f, -0.01165977f, -0.03407415f, 
    -0.02044639f, -0.07938460f, 0.22239815f, 0.04827973f, 0.05329153f, -0.03902538f, -0.02326469f, -0.16985279f, 
    0.03786903f, -0.06331068f, 0.04658363f, 0.07584392f, 0.00683220f, 0.10855257f, -0.00223105f, 0.01711059f, 
    0.24226432f, 0.21346274f, 0.01707266f, 0.01917683f, -0.07153549f, -0.13520916f, 0.05797601f, 0.08319596f, 
    0.04509677f, 0.01923606f, 0.12360905f, -0.06794643f, -0.10032566f, -0.17771827f, -0.06035284f, -0.06419556f, 
    0.03523824f, 0.06541211f, 0.04793699f, 0.00085248f, 0.14492580f, -0.02606055f, 0.01349147f, 0.08091505f, 
    -0.10603376f, -0.15363674f, 0.07070131f, -0.03287001f, 0.05439161f, -0.12405244f, -0.12077564f, 0.02671927f, 
    0.07136045f, 0.02480711f, -0.02156740f, 0.03605974f, 0.06672353f, 0.10556161f, 0.03814717f, 0.04735685f, 
    -0.11506279f, 0.03422052f, -0.13458732f, 0.18396498f, 0.00341892f, 0.21741937f, 0.09248734f, 0.07492586f, 
    -0.00666981f, -0.01158234f, -0.05506989f, -0.06123787f, -0.04492982f, -0.06675669f, -0.04228023f, -0.08605014f, 
    -0.02981167f, 0.03949442f, -0.01258985f, 0.00363274f, -0.06844333f, 0.02237795f, 0.04567431f, 0.03448850f, 
    -0.09447046f, -0.07165355f, -0.04280415f, -0.05688264f, -0.02891967f, 0.03077018f, 0.02467517f, 0.02874616f, 
    0.04728630f, 0.01795851f, 0.00712261f, 0.05738888f, -0.01512786f, -0.03291853f, -0.02851596f, -0.04655829f, 
    -0.05924209f, -0.06331370f, -0.02397350f, -0.07167559f, -0.04781272f, -0.02782317f, -0.07873802f, -0.08671349f, 
    -0.03419348f, -0.00716300f, 0.01673130f, -0.04785255f, 0.04481667f, -0.03619231f, -0.09799989f, -0.05334829f, 
    -0.02523483f, -0.07659580f, 0.02856568f, -0.06588190f, 0.04260436f, -0.00825868f, 0.01281881f, 0.04409165f, 
    -0.06470106f, -0.05008475f, -0.03022641f, -0.02017603f, -0.01574860f, 0.04559037f, -0.06999587f, -0.05339682f, 
    -0.01984021f, 0.04119111f, -0.02020124f, -0.03420570f, -0.09102176f, 0.04386587f, 0.04832656f, -0.02735789f, 
    -0.03216701f, -0.06473602f, 0.03087242f, 0.03986349f, -0.08522499f, 0.03951737f, -0.02254708f, -0.03303637f, 
    -0.06559432f, -0.09030198f, 0.03288149f, -0.04592272f, -0.03495773f, -0.00789682f, -0.00529693f, -0.04975121f, 
    0.02705083f, -0.03781726f, -0.04529599f, -0.07177893f, -0.02064760f, -0.06388699f, -0.04822999f, -0.00174709f, 
    -0.06084874f, -0.03371111f, 0.00864422f, 0.01904497f, -0.03856412f, -0.01469892f, -0.05475347f, -0.06068942f, 
    -0.01642052f, -0.02737539f, -0.05375240f, -0.07042501f, 0.05078330f, -0.03665431f, 0.05825851f, -0.06509367f, 
    0.05796733f, -0.04491630f, 0.01735959f, 0.01618792f, -0.05254890f, -0.01986127f, 0.03664798f, -0.02566075f, 
    -0.03337030f, -0.06456910f, 0.03190999f, -0.02726978f, -0.06379797f, -0.06899919f, 0.03752500f, -0.00537054f, 
    -0.00350001f, -0.00905360f, -0.08826166f, -0.03826351f, -0.07371530f, 0.01097302f, 0.01349204f, -0.07274647f, 
    -0.02913018f, -0.04712701f, -0.03404068f, -0.06865505f, -0.09726036f, -0.07907609f, -0.05679200f, 0.01187587f, 
    0.03664559f, 0.01961999f, 0.02718590f, -0.00318895f, 0.04642469f, -0.01533399f, -0.00490819f, -0.00726656f, 
    0.00172555f, -0.05790180f, -0.09633763f, 0.02990393f, -0.04364879f, -0.03634502f, 0.05154919f, -0.06399035f, 
    -0.05669279f, -0.00879340f, -0.09524589f, -0.03827886f, -0.01378162f, -0.05414762f, 0.04441914f, -0.01743308f, 
    -0.03422001f, -0.08156338f, 0.06094960f, 0.03070598f, 0.05224921f, -0.06058159f, 0.02601920f, -0.07685562f, 
    -0.02264378f, -0.08146042f, -0.06202396f, -0.03158903f, 0.02113614f, -0.04906779f, -0.06109784f, -0.04980254f, 
    -0.02133583f, -0.06169185f, 0.03822236f, 0.04757822f, -0.04212052f, -0.04329198f, -0.06347168f, -0.06984481f, 
    -0.01714721f, 0.06579483f, 0.01932067f, 0.09117144f, 0.06849888f, 0.16795693f, 0.02926831f, 0.01199101f, 
    0.15426910f, 0.07067070f, 0.05474968f, 0.15157647f, -0.13930245f, -0.26248726f, 0.03224103f, 0.03583188f, 
    0.02744539f, 0.14321576f, -0.16658966f, 0.12055780f, 0.20240697f, 0.02870999f, -0.02567355f, -0.19755447f, 
    -0.08348668f, -0.21306890f, 0.03409828f, -0.01655369f, 0.07192416f, 0.00985059f, 0.07259921f, 0.07860273f, 
    -0.05541812f, -0.01282408f, 0.01947677f, 0.05970815f, -0.05424823f, 0.36014217f, -0.04484254f, 0.11400291f, 
    -0.15674365f, 0.04136247f, 0.03512073f, 0.09440642f, 0.01441386f, -0.02183580f, 0.05995541f, 0.07691593f, 
    -0.01321350f, 0.05873106f, -0.09535153f, 0.11324833f, -0.01984226f, -0.09331127f, -0.20126393f, 0.03619555f, 
    0.14261831f, -0.05629373f, -0.07667751f, 0.07269589f, -0.23280972f, -0.17597282f, -0.01625650f, 0.04806855f, 
    -0.07359076f, 0.15993445f, -0.09785686f, 0.07313962f, 0.13321446f, 0.05401398f, -0.04815904f, -0.01732142f, 
    -0.01455418f, -0.29100987f, 0.16540711f, 0.03083691f, 0.08130992f, 0.09067448f, -0.04712838f, -0.03065521f, 
    0.26142699f, 0.20984684f, 0.05484688f, 0.02867619f, 0.20968316f, -0.00587514f, 0.16578782f, -0.30596074f, 
    -0.05153818f, -0.08904184f, 0.06760078f, 0.13236672f, -0.00630542f, -0.01141862f, 0.07452655f, 0.21307470f, 
    0.10712802f, -0.13705501f, 0.02695644f, 0.29760697f, 0.02970499f, -0.02630743f, -0.00331469f, -0.14474031f, 
    0.09213460f, 0.12882981f, -0.10719876f, 0.04501267f, -0.31948718f, 0.07774816f, 0.05434126f, 0.08992713f, 
    -0.16613297f, -0.13978262f, 0.04888274f, 0.00614899f, -0.04566606f, -0.02669992f, 0.00007031f, 0.03021021f, 
    0.02020302f, -0.22017768f, 0.04890104f, 0.25718725f, 0.02739961f, 0.08593451f, -0.01917588f, -0.03077050f, 
    0.04685543f, -0.00904229f, 0.06111283f, 0.00436191f, -0.26148832f, 0.01025185f, -0.06132486f, 0.12292450f, 
    0.05037609f, -0.10007939f, 0.14693998f, 0.14954883f, -0.12565354f, 0.07558216f, -0.11594399f, -0.02145390f, 
    -0.15354741f, -0.13443080f, 0.09011623f, 0.26351926f, -0.15378878f, -0.14173466f, -0.07365146f, -0.05909152f, 
    0.10989105f, -0.10200740f, 0.11230001f, -0.06632566f, -0.40252647f, -0.05299973f, -0.06516972f, 0.08789413f, 
    0.01656309f, 0.06045067f, -0.00113152f, 0.14051516f, 0.07747462f, -0.03185495f, 0.11406197f, -0.03313051f, 
    0.22799002f, -0.01187653f, 0.00897510f, -0.33382630f, 0.10410891f, -0.05621662f, 0.13834175f, 0.02483949f, 
    0.01624160f, -0.07355171f, -0.00275927f, 0.05180860f, -0.30251759f, 0.00524027f, 0.08241560f, -0.21115133f, 
    -0.10797576f, -0.04225051f, 0.11487218f, -0.05323169f, 0.03645807f, 0.09598629f, 0.12049416f, 0.20244136f, 
    0.02857895f, -0.11948771f, -0.16812666f, 0.19321176f, 0.10752983f, 0.03447801f, -0.12825088f, -0.08892933f, 
    -0.03792709f, 0.05527999f, -0.03067284f, -0.08647899f, 0.01162924f, 0.11860631f, 0.26725093f, 0.14836848f, 
    -0.16464622f, 0.05663652f, -0.04544741f, 0.01124428f, -0.03672692f, -0.00813266f, -0.04093681f, 0.11865163f, 
    -0.40880424f, -0.11725546f, -0.18586630f, 0.13009383f, 0.08253431f, 0.05260638f, 0.11272624f, -0.04581087f, 
    -0.02526503f, -0.11590155f, 0.21713784f, 0.03616162f, 0.29984978f, -0.27331096f, -0.16163908f, -0.02967469f, 
    -0.11376048f, 0.17055079f, 0.00277861f, 0.07312343f, -0.04853598f, -0.02671294f, -0.09215640f, -0.01154150f, 
    0.06467056f, 0.08645415f, 0.02002309f, -0.07403311f, 0.07662172f, 0.06925552f, 0.05718437f, 0.03163217f, 
    -0.00073114f, -0.05379661f, 0.07630516f, 0.20539106f, -0.03791463f, 0.19681546f, 0.11089750f, 0.05537624f, 
    0.14891951f, 0.05967579f, 0.11903956f, -0.10567874f, 0.03447840f, -0.13046890f, 0.12011775f, -0.09281668f, 
    0.41746560f, 0.14881624f, 0.09875556f, 0.07937087f, -0.12560402f, 0.11408972f, -0.09742039f, -0.06363980f, 
    -0.00964042f, -0.15054385f, 0.07072619f, 0.04242747f, -0.17389859f, -0.04736150f, 0.20242833f, -0.00738317f, 
    0.04454155f, -0.08396419f, -0.09880748f, 0.05533123f, -0.01765121f, 0.27497849f, 0.10339703f, 0.05410232f, 
    -0.12301349f, 0.02064935f, 0.04305291f, -0.00863729f, -0.10064605f, -0.12808105f, -0.05401681f, -0.01849233f, 
    -0.06725568f, -0.07147074f, 0.06925137f, 0.00244517f, -0.17317428f, -0.01445014f, -0.14074662f, -0.10765662f, 
    0.17527485f, 0.11988526f, 0.10126424f, -0.04713332f, -0.02856592f, -0.05009199f, -0.06012173f, 0.13995740f, 
    0.14809315f, 0.02817909f, 0.13561825f, -0.12662718f, 0.23348719f, 0.06466220f, -0.03897021f, 0.02031489f, 
    -0.03225726f, 0.03440546f, -0.08879548f, 0.14992769f, -0.26763645f, 0.28601408f, -0.04515719f, -0.18776856f, 
    0.17561792f, 0.07634077f, 0.00988834f, 0.01078071f, 0.00356018f, -0.01613549f, -0.06570555f, 0.00207876f, 
    -0.06399475f, 0.10232641f, -0.12390655f, 0.02482750f, 0.01868268f, -0.07555093f, 0.05468347f, -0.00751632f, 
    0.15479086f, -0.04922021f, 0.01273720f, -0.11489399f, 0.00330885f, 0.18838739f, 0.05801578f, -0.04931857f, 
    0.02327445f, -0.11766154f, 0.06283310f, -0.05402456f, 0.06529640f, 0.10643101f, 0.04246529f, 0.04414213f, 
    0.15012419f, 0.08223228f, 0.02446673f, 0.06833395f, 0.04812093f, 0.12014213f, 0.01259549f, 0.13745603f, 
    0.09115532f, 0.13439003f, 0.07798590f, 0.03864023f, 0.15700811f, -0.12005468f, 0.04083556f, 0.20327613f, 
    0.15471922f, 0.04860809f, 0.14445512f, -0.00779143f, 0.10512242f, 0.01005627f, -0.15731898f, -0.03437857f, 
    0.05270476f, 0.04017137f, -0.06800750f, 0.26141962f, -0.04157567f, 0.03494665f, -0.01184020f, 0.00195646f, 
    0.02920686f, 0.01788108f, -0.02454401f, 0.05246181f, -0.07241279f, -0.09623597f, 0.12638234f, 0.19504040f, 
    -0.03648175f, 0.16724977f, -0.09659588f, 0.07569856f, -0.10640839f, -0.08250621f, 0.08353615f, 0.17217730f, 
    0.06062581f, -0.25674489f, -0.00453475f, 0.18818986f, 0.03497998f, 0.01309904f, 0.10263877f, 0.22709297f, 
    -0.08001029f, 0.14999405f, -0.00787887f, 0.01751170f, -0.08984131f, 0.11407107f, -0.03183109f, 0.01532831f, 
    -0.05119317f, 0.07797254f, -0.00026844f, 0.08151250f, 0.04928708f, -0.08845651f, -0.01563380f, 0.03974423f, 
    -0.13397074f, 0.04841521f, -0.03198368f, -0.15681760f, -0.01014413f, -0.00754279f, -0.05842749f, -0.00408362f, 
    -0.03645071f, -0.03382708f, -0.07222354f, 0.18748386f, -0.07137793f, 0.01848421f, 0.05969532f, -0.07254045f, 
    0.01475200f, 0.05155613f, 0.04892500f, -0.08798753f, 0.02857206f, 0.05492278f, 0.06808829f, 0.09023082f, 
    0.12509069f, -0.21257327f, 0.19174570f, 0.06925932f, -0.01881838f, -0.07305074f, 0.00082233f, -0.12894627f, 
    -0.01417670f, 0.03122059f, 0.03112362f, 0.04023379f, 0.03058335f, 0.09531860f, 0.19077033f, 0.15087999f, 
    0.02667803f, 0.00956507f, -0.06542506f, 0.05521950f, 0.14115608f, 0.03034566f, -0.03974253f, 0.17306603f, 
    -0.13958669f, -0.02890799f, -0.10427563f, -0.14118257f, -0.10115538f, -0.04269084f, 0.01864521f, 0.09111556f, 
    0.04197816f, -0.02039418f, -0.03184272f, -0.00337171f, -0.45010185f, 0.08939675f, -0.11209533f, -0.13835470f, 
    0.09680010f, -0.13142385f, 0.08773883f, -0.11011580f, 0.03249370f, -0.05003000f, -0.07327922f, 0.04498366f, 
    -0.18539636f, 0.19223563f, -0.11837222f, -0.36254472f, 0.13817607f, 0.06273040f, 0.07773171f, 0.01517431f, 
    0.08933812f, -0.03985617f, -0.05561888f, 0.17035802f, -0.22150213f, 0.19842936f, -0.01032373f, -0.20424889f, 
    0.12778324f, -0.00335429f, 0.07389642f, 0.16305797f, -0.01433392f, 0.07615688f, -0.13399084f, -0.15058911f, 
    -0.22310841f, 0.17359813f, -0.06624027f, 0.08600760f, -0.10023387f, -0.10618085f, 0.02889112f, -0.14000735f, 
    0.02734245f, 0.05677092f, 0.17978646f, -0.01283033f, -0.28958440f, 0.05345543f, 0.01186594f, -0.03179661f, 
    0.09594084f, 0.03302789f, -0.12836084f, -0.01120386f, 0.15980223f, 0.00695198f, 0.07956567f, 0.05930057f, 
    0.26507837f, 0.11711482f, -0.03491900f, 0.11012948f, 0.13352479f, -0.03912554f, 0.05156418f, 0.07956097f, 
    0.05399045f, -0.03112596f, 0.10018437f, 0.10392112f, -0.01936945f, -0.02967109f, 0.09618693f, 0.09452213f, 
    0.05241954f, -0.03706988f, -0.00553618f, 0.16209924f, 0.05139409f, 0.08541241f, 0.11737084f, 0.13640809f, 
    -0.11250865f, -0.01093424f, -0.20228961f, -0.03048850f, -0.03671731f, 0.10224958f, 0.00788840f, 0.05603379f, 
    -0.01682447f, 0.06556050f, -0.09143422f, -0.22461358f, -0.01577595f, 0.23233193f, 0.01750824f, -0.07244677f, 
    -0.18333034f, 0.03729342f, -0.00834964f, 0.13176301f, 0.11936396f, 0.06324086f, -0.02218481f, 0.02554891f, 
    -0.36518693f, 0.05466234f, -0.04938417f, -0.01748558f, 0.04999082f, -0.09898911f, -0.02907892f, -0.16466852f, 
    0.05144627f, -0.12870161f, 0.33426929f, 0.17185645f, 0.27386358f, -0.09314887f, -0.08944258f, 0.05292689f, 
    -0.17746615f, 0.00898490f, -0.06192205f, -0.03194940f, -0.20548469f, 0.15955721f, -0.11079107f, 0.11230368f, 
    0.04458118f, -0.03027744f, 0.01366117f, 0.11966099f, 0.05614197f, -0.06303608f, 0.13649471f, 0.14133997f, 
    -0.07563391f, 0.11443251f, 0.08350717f, 0.23389716f, -0.14245349f, 0.10569959f, -0.00616690f, 0.16042867f, 
    0.03411046f, 0.04747465f, -0.01036599f, 0.12496631f, 0.08269460f, -0.14930452f, -0.09481207f, -0.21016718f, 
    0.33008164f, 0.24483158f, 0.02024337f, -0.11296608f, -0.01908736f, 0.12214133f, 0.15867007f, 0.04778973f, 
    0.10752750f, -0.09782080f, 0.06059599f, 0.04149750f, 0.13548939f, -0.16141574f, 0.00435686f, -0.18604505f, 
    -0.11352876f, 0.01086346f, -0.08575841f, 0.04155002f, -0.00280820f, 0.11209976f, 0.13770145f, 0.19829708f, 
    -0.18474081f, 0.08586817f, 0.11228785f, 0.02487604f, -0.03569939f, -0.04985968f, 0.00764147f, -0.11702312f, 
    0.09281198f, 0.05701184f, -0.01387216f, -0.04731609f, -0.17024086f, -0.16313000f, -0.14353429f, -0.01022718f, 
    0.00098296f, 0.04147678f, -0.05739125f, 0.08333437f, -0.02482257f, -0.03320054f, 0.08648068f, 0.08287994f, 
    0.21624118f, 0.19464818f, 0.17869557f, -0.21480021f, 0.03516930f, 0.09485026f, 0.08324171f, -0.00184145f, 
    0.02630289f, -0.01348735f, -0.14334226f, -0.07842761f, -0.20370154f, 0.00270757f, 0.08308995f, -0.02835809f, 
    0.08950204f, 0.03721565f, -0.02322535f, -0.01504885f, 0.04078934f, -0.03103064f, 0.01522699f, 0.21702014f, 
    -0.05031937f, -0.00368393f, 0.02886094f, -0.17782001f, 0.02072152f, 0.03146420f, 0.09922951f, 0.08517370f, 
    -0.01421670f, 0.02723786f, -0.04460992f, -0.01532608f, 0.25908774f, 0.17152269f, 0.03249688f, -0.17105970f, 
    0.06927121f, -0.05585896f, 0.06317244f, 0.09078372f, -0.03089770f, 0.08611054f, 0.05989868f, -0.12760040f, 
    0.13487157f, -0.26623681f, 0.15892980f, -0.09149958f, -0.07103103f, 0.09195075f, -0.02593239f, 0.25693244f, 
    0.07493079f, 0.03248795f, 0.07437140f, -0.00008710f, -0.05341233f, 0.06338324f, 0.09993872f, 0.08443642f, 
    -0.00999572f, 0.04992285f, 0.09489305f, 0.05929137f, 0.16949880f, -0.07204342f, -0.03788928f, -0.06368355f, 
    -0.22839127f, -0.18215440f, -0.04320306f, 0.03439955f, 0.03932532f, 0.02378658f, 0.02676430f, 0.20667671f, 
    -0.00467941f, -0.00145210f, 0.01996342f, 0.01597537f, 0.05893173f, 0.13535623f, 0.26068905f, 0.09153207f, 
    -0.19281241f, -0.11815314f, 0.04860741f, -0.00841981f, -0.03291368f, 0.02167785f, 0.09157690f, 0.09548640f, 
    -0.17343310f, 0.00122386f, -0.13372986f, -0.14867416f, 0.08949221f, 0.08359333f, 0.04504156f, 0.06976319f, 
    0.02231529f, 0.08019931f, 0.03939046f, -0.12670311f, -0.09843458f, -0.12262028f, -0.03645734f, -0.16574346f, 
    0.08103937f, -0.01998093f, 0.05376333f, 0.03167076f, 0.08949301f, -0.10778654f, 0.11097120f, -0.11975560f, 
    0.23492302f, 0.16194846f, 0.22053733f, 0.16045047f, 0.01472652f, 0.01708370f, 0.13507774f, -0.12154813f, 
    -0.06918826f, 0.06131417f, 0.07227661f, -0.02082684f, 0.33254254f, 0.03371423f, 0.01438820f, -0.21380176f, 
    -0.00121021f, -0.04244805f, -0.04001272f, 0.04137677f, -0.08818408f, -0.06204310f, -0.05841747f, 0.05661207f, 
    0.32218334f, -0.17640190f, 0.06296553f, 0.27366000f, -0.08025741f, 0.03572341f, -0.05827918f, -0.09554610f, 
    -0.13935333f, 0.15962146f, -0.02818308f, 0.11464774f, -0.22192743f, 0.01950985f, -0.17972019f, 0.01207140f, 
    0.16848205f, 0.07977754f, -0.00386210f, 0.04923323f, -0.07483993f, 0.01481801f, -0.11389652f, -0.12825410f, 
    0.08510611f, -0.08570017f, 0.07364482f, 0.09036482f, -0.16339734f, 0.02852056f, -0.02324411f, -0.00422945f, 
    0.03995175f, -0.12411445f, -0.07450799f, 0.17108424f, -0.11028768f, 0.12223464f, -0.16366203f, -0.12030838f, 
    0.10849119f, 0.09545308f, 0.10739528f, 0.05933219f, 0.09862102f, 0.02359661f, 0.02491159f, 0.04683052f, 
    0.19630098f, 0.14482591f, 0.05582663f, 0.25329438f, -0.16625403f, 0.05072225f, 0.00443404f, 0.02533089f, 
    0.04141748f, 0.04850604f, -0.00281557f, -0.02225306f, -0.24797036f, 0.26695660f, -0.16550487f, 0.12411598f, 
    0.05243835f, 0.01754370f, -0.07167025f, 0.12536481f, -0.07941345f, 0.03601584f, 0.11360734f, 0.00013694f, 
    0.08718704f, 0.11890677f, -0.22551571f, 0.09551902f, 0.16128612f, -0.06616040f, -0.02674867f, 0.03488066f, 
    0.05452389f, 0.08771279f, 0.05217852f, 0.01081993f, 0.09777930f, 0.27942276f, 0.28744388f, 0.26912156f, 
    -0.07762998f, -0.04663927f, -0.00103077f, -0.02204502f, -0.03801945f, -0.09893855f, 0.01555476f, -0.02634204f, 
    -0.09633228f, 0.17386891f, -0.20392092f, 0.11657057f, -0.00698961f, -0.03809513f, 0.02864444f, 0.02157138f, 
    -0.01462109f, -0.02589408f, 0.03338755f, 0.10570987f, -0.18791829f, -0.17363347f, -0.13702942f, -0.06112508f, 
    0.10339392f, 0.11720952f, 0.03746799f, 0.05367181f, 0.00601969f, 0.01002086f, -0.04242489f, 0.01926514f, 
    0.00352884f, -0.00164888f, -0.00149839f, 0.01190054f, -0.06475673f, 0.02935376f, -0.02377092f, 0.04597580f, 
    0.00904555f, 0.03507826f, -0.04185591f, -0.08236558f, 0.03259115f, -0.06828421f, 0.03252016f, 0.01781664f, 
    0.00221315f, 0.02283286f, -0.01825767f, 0.00084502f, -0.02682298f, -0.01249485f, -0.03912703f, 0.06014302f, 
    -0.05157182f, -0.07261902f, 0.03679214f, -0.00231255f, -0.01250921f, 0.03506522f, -0.03131606f, 0.01766169f, 
    0.03540477f, -0.03846276f, -0.07659606f, -0.00452707f, -0.04251135f, 0.00643781f, 0.03379539f, 0.05616101f, 
    0.03206414f, 0.02487519f, -0.01731628f, 0.03021877f, 0.00444870f, -0.03352151f, 0.04363291f, -0.02705152f, 
    0.03223461f, -0.01404753f, -0.00579424f, -0.05168378f, -0.04720410f, -0.05698046f, 0.01941931f, -0.03782538f, 
    -0.05185987f, -0.04542578f, 0.04884023f, -0.03067309f, 0.03086565f, -0.06277083f, 0.04827458f, -0.03183741f, 
    0.00488823f, -0.01463296f, -0.03595529f, 0.02450505f, -0.07964010f, -0.04532894f, -0.04322379f, 0.03258511f, 
    0.07176127f, -0.02874065f, -0.01814922f, 0.07153254f, 0.02630704f, 0.02489164f, -0.05746704f, 0.05639565f, 
    0.04102154f, -0.03287393f, 0.05822090f, -0.03771108f, 0.03189765f, -0.02588576f, -0.01137300f, -0.07060096f, 
    -0.04163321f, -0.02887226f, 0.06160074f, -0.03612887f, -0.03382280f, 0.04729467f, 0.01678054f, -0.00447850f, 
    0.00121108f, 0.03580172f, -0.05644390f, -0.04041019f, -0.00338759f, -0.05664641f, 0.04041900f, -0.04756263f, 
    -0.01494813f, 0.02818001f, 0.01381157f, 0.05835962f, -0.03076904f, -0.03671691f, 0.08815004f, 0.01577862f, 
    -0.06653468f, -0.05664518f, -0.05558362f, -0.01287374f, 0.04344616f, 0.00850677f, 0.00275072f, 0.04385056f, 
    -0.04794619f, -0.01744270f, -0.02846868f, 0.07792638f, -0.03452184f, -0.06833850f, 0.02723059f, -0.05145968f, 
    -0.01273388f, 0.01543710f, -0.06530020f, 0.01676597f, -0.00200007f, 0.00205019f, -0.07318904f, -0.06054170f, 
    0.00464038f, -0.01973998f, 0.02961989f, 0.03734684f, -0.07781605f, -0.01907841f, 0.03083856f, -0.03865320f, 
    -0.06633060f, -0.00358430f, -0.01589675f, -0.04195831f, 0.02269271f, -0.07466774f, -0.01851877f, 0.05601846f, 
    0.04603365f, 0.04850411f, 0.03354576f, -0.02288159f, -0.05451427f, -0.04273633f, 0.02097585f, 0.04697955f, 
    -0.03389961f, 0.05978934f, 0.01879426f, -0.00793531f, 0.02336664f, 0.07701270f, -0.02915288f, 0.03643453f, 
    -0.03884272f, -0.04288509f, -0.07369757f, 0.03344107f, -0.04892647f, -0.07398892f, 0.04043911f, -0.01128979f, 
    0.04023298f, -0.00668625f, 0.02345537f, -0.01894465f, 0.03691972f, -0.03078242f, 0.02924132f, 0.05779450f, 
    -0.07796496f, 0.05158224f, -0.07133237f, -0.00789666f, 0.04239182f, 0.05190475f, 0.00203641f, -0.03890649f, 
    0.02282680f, 0.25572044f, 0.04593245f, -0.11357825f, 0.01985405f, 0.00355404f, 0.14467886f, -0.01339664f, 
    0.11030474f, 0.05496962f, -0.10164605f, -0.08063662f, -0.01939433f, 0.08097681f, -0.16665450f, -0.12845121f, 
    0.10473284f, 0.02420893f, -0.04664782f, -0.06539215f, -0.02594400f, -0.00869464f, 0.08733272f, 0.04152670f, 
    0.04857210f, 0.04780219f, 0.06496681f, -0.11126524f, 0.09170729f, 0.16595274f, 0.01387012f, 0.02035115f, 
    0.03516505f, -0.03320247f, 0.03474031f, 0.06432834f, -0.07989733f, -0.03186695f, -0.06819370f, 0.03699782f, 
    -0.04247398f, 0.13363206f, 0.07163429f, -0.00735018f, 0.00529629f, 0.12903485f, 0.07267044f, 0.11575168f, 
    -0.03442322f, -0.04324135f, -0.06841005f, -0.07144998f, 0.08508577f, 0.01303705f, -0.21190678f, -0.04197691f, 
    -0.06444672f, -0.20026709f, 0.03354057f, 0.07810766f, -0.34937027f, 0.12038676f, -0.02662044f, 0.28430852f, 
    0.07089388f, 0.06288850f, 0.03142821f, -0.04443273f, 0.07314882f, -0.06331512f, 0.06822333f, -0.01336442f, 
    -0.13003471f, 0.21814500f, 0.06877384f, -0.10712553f, 0.08676737f, 0.01582948f, 0.06024007f, -0.00138664f, 
    0.08489183f, -0.03494371f, 0.04580457f, 0.02862487f, 0.13566305f, -0.00927620f, 0.23822528f, 0.00501183f, 
    0.05974884f, 0.05890777f, 0.05480502f, -0.04142853f, 0.02198877f, -0.01255934f, 0.17810224f, 0.11908010f, 
    -0.14797188f, 0.20464122f, -0.00368918f, -0.04934236f, 0.16174591f, -0.02528063f, -0.18617380f, 0.18295598f, 
    -0.01441751f, 0.07994618f, 0.15727299f, -0.03469942f, 0.03494103f, -0.22271188f, 0.07184325f, 0.10609765f, 
    -0.01062792f, 0.05527679f, -0.04058848f, -0.06136537f, -0.01359836f, 0.12503536f, -0.11802668f, -0.04929628f, 
    -0.45006421f, 0.27220014f, 0.09622904f, -0.20932283f, 0.03266769f, -0.03483675f, 0.03396421f, -0.06842395f, 
    0.05228890f, 0.01138949f, 0.15765987f, -0.08816531f, 0.20894039f, -0.16273569f, 0.24499634f, -0.20726682f, 
    -0.01745448f, -0.02318087f, 0.07983587f, -0.02883631f, 0.07884253f, 0.09389769f, 0.01986047f, -0.00356242f, 
    -0.17153437f, 0.06129370f, 0.27072901f, -0.19374169f, -0.16625151f, -0.04850087f, 0.04027100f, -0.12399597f, 
    0.04594753f, -0.04482898f, 0.03011486f, -0.01322486f, -0.03442520f, -0.04083142f, -0.24842870f, -0.18928534f, 
    0.20336150f, -0.08770946f, 0.04089146f, -0.04673877f, 0.03339625f, 0.02914461f, 0.11766162f, 0.10111442f, 
    0.32691249f, -0.12472251f, 0.35234743f, -0.08843840f, 0.04869000f, -0.03552595f, -0.09185462f, 0.12903814f, 
    0.01425030f, -0.07851283f, 0.01254216f, 0.00953591f, 0.11052171f, -0.05968187f, 0.08828809f, 0.03720598f, 
    -0.05360428f, 0.05631847f, 0.00137231f, -0.02045668f, 0.06564285f, 0.06499895f, 0.05956611f, -0.05046866f, 
    -0.11718053f, -0.09569129f, 0.07021462f, 0.02922913f, 0.08314638f, -0.00907292f, 0.02478412f, 0.06871022f, 
    0.11774392f, 0.11924212f, 0.01162642f, 0.25733832f, 0.03973236f, 0.21769087f, 0.28855377f, 0.07073047f, 
    0.10950428f, -0.01065690f, 0.05171430f, -0.07990095f, -0.01944390f, -0.03819362f, 0.11011153f, 0.01312897f, 
    0.16028234f, -0.10912222f, -0.07218631f, 0.07039611f, 0.05194558f, 0.03083514f, 0.00527407f, 0.07431763f, 
    0.08823541f, 0.10462247f, -0.02111501f, -0.09151797f, -0.17779002f, -0.19793686f, -0.01714455f, -0.04523362f, 
    0.12857039f, -0.00511614f, 0.09512258f, -0.02954093f, -0.00489074f, 0.02823074f, 0.16388045f, 0.07912300f, 
    0.15364923f, 0.20750558f, 0.13556355f, 0.05640515f, 0.08657496f, 0.21528688f, 0.02062732f, -0.01707533f, 
    -0.07966577f, -0.07558133f, -0.01263922f, 0.04370668f, 0.05589548f, 0.01300496f, 0.03595491f, 0.07042021f, 
    0.01862030f, 0.09307494f, 0.09366352f, 0.05292427f, 0.02754228f, -0.00685017f, 0.04760638f, 0.12099823f, 
    -0.20778677f, 0.09367220f, 0.18265718f, 0.09175035f, -0.13466841f, -0.01053852f, 0.02311523f, 0.07176645f, 
    -0.11159986f, 0.19201703f, 0.15420164f, 0.17724206f, 0.00478939f, -0.05281074f, -0.06645092f, -0.06939095f, 
    0.11770208f, 0.11509754f, 0.04175056f, 0.15172154f, 0.06143625f, -0.04339971f, 0.00751959f, -0.07973925f, 
    0.02530747f, -0.09218241f, 0.05353295f, 0.10150669f, -0.02915719f, -0.02457144f, 0.00827620f, 0.12542135f, 
    0.12248664f, -0.11111430f, 0.12550591f, 0.09047354f, 0.04390325f, -0.08741657f, -0.28636190f, -0.07220800f, 
    -0.02780883f, 0.01226551f, 0.05309876f, 0.06867959f, 0.06319710f, 0.06449225f, 0.04013565f, 0.09437162f, 
    0.10120445f, 0.01626669f, 0.18204053f, -0.17462277f, -0.08336423f, 0.08522318f, -0.05735743f, 0.10576132f, 
    0.16656601f, 0.00844294f, 0.10087010f, 0.04024884f, 0.29030326f, -0.11492739f, -0.05012543f, -0.03089770f, 
    0.06306525f, -0.01430081f, -0.02961801f, 0.04864743f, 0.13089621f, 0.05255189f, 0.05259610f, 0.01614908f, 
    -0.07414719f, -0.10478515f, -0.15406480f, 0.05022667f, 0.00247797f, 0.09458657f, -0.09394509f, 0.16770811f, 
    -0.02841221f, 0.08184016f, -0.10305435f, 0.04176415f, -0.22907126f, 0.10640165f, 0.23246531f, 0.05342082f, 
    0.06470883f, 0.11065375f, 0.16108921f, 0.01731120f, 0.13121757f, 0.02738028f, 0.03881906f, 0.12361810f, 
    -0.14816873f, -0.04049303f, -0.16768944f, -0.01827449f, 0.04754491f, 0.14159426f, -0.03163795f, 0.00296264f, 
    0.03163758f, -0.19750819f, -0.15081896f, -0.02160228f, -0.16699445f, -0.22790959f, -0.23342280f, -0.13414584f, 
    0.04725392f, 0.06696279f, 0.05631457f, 0.02094134f, -0.05426148f, 0.11435086f, 0.04468743f, 0.08687285f, 
    0.14574333f, -0.02392535f, -0.08603460f, 0.21978268f, 0.04689251f, 0.06978320f, -0.01464510f, -0.07793478f, 
    -0.03751937f, 0.04369679f, -0.06597846f, -0.09680822f, -0.22545680f, 0.19110556f, 0.16699918f, 0.10120561f, 
    -0.00177150f, 0.07864796f, -0.10576598f, 0.00262618f, -0.02945131f, 0.12257598f, -0.07779688f, 0.05324461f, 
    -0.14788644f, -0.00704184f, 0.03303632f, 0.24996985f, 0.00949641f, 0.06570813f, 0.11251616f, -0.05317940f, 
    -0.05755122f, -0.07778523f, 0.27680108f, 0.08258256f, 0.29936010f, 0.03202023f, -0.13454615f, 0.16381770f, 
    -0.09763303f, 0.01588468f, 0.03666719f, -0.00235070f, -0.11188137f, 0.09896618f, -0.01267944f, 0.13108127f, 
    0.11499839f, -0.03695160f, -0.17170733f, 0.03812148f, -0.06621931f, -0.03210714f, 0.15685029f, 0.13774431f, 
    -0.03459055f, 0.08902293f, -0.02257082f, 0.23387057f, -0.31653783f, 0.07316143f, 0.07996551f, 0.00592783f, 
    0.01105319f, 0.08305812f, 0.01394704f, -0.13102567f, 0.07573833f, -0.12716733f, 0.02870720f, -0.19290185f, 
    0.19460233f, 0.07844850f, 0.05937786f, 0.16256648f, -0.02346134f, 0.08714979f, 0.11915515f, -0.10220537f, 
    0.06594439f, -0.01226958f, 0.03652767f, 0.00925580f, 0.26017976f, 0.05599277f, 0.25455621f, -0.20297717f, 
    -0.10343928f, 0.09552594f, -0.22745103f, 0.04418065f, 0.05988193f, 0.09553479f, -0.01729062f, 0.16164048f, 
    -0.05508469f, 0.09520447f, 0.03708774f, 0.01888970f, -0.07994161f, -0.15794832f, 0.00273509f, -0.19437432f, 
    0.05025393f, -0.04365521f, 0.00558386f, 0.03174883f, -0.17626642f, 0.07855265f, 0.03392939f, 0.22597472f, 
    0.08104534f, -0.00795761f, 0.07784431f, -0.04577370f, -0.02074915f, -0.02757668f, -0.02198393f, 0.09495421f, 
    0.02667533f, 0.14313151f, -0.02046478f, -0.11649944f, 0.03944214f, 0.14002210f, -0.04904366f, 0.03936102f, 
    -0.06285655f, -0.12246128f, -0.17491657f, 0.05212836f, -0.21566056f, 0.03786924f, -0.01807997f, -0.24098957f, 
    0.03997868f, 0.07911814f, 0.08954409f, 0.00954218f, -0.03073755f, 0.00672805f, -0.16701840f, 0.09414547f, 
    -0.19576192f, 0.01017519f, 0.05300030f, 0.02540489f, -0.06756514f, -0.04318910f, -0.03636676f, 0.04937245f, 
    -0.01898148f, -0.02488471f, 0.01879024f, -0.01678248f, -0.03124755f, 0.11150920f, 0.00719993f, -0.15806469f, 
    -0.07092097f, -0.15565474f, -0.06208556f, 0.04658318f, 0.06691651f, 0.10956130f, 0.09649720f, -0.00496729f, 
    0.08526027f, -0.07628193f, 0.07061251f, -0.18959714f, 0.00950881f, 0.12160153f, -0.07610190f, 0.19142839f, 
    0.12798609f, -0.03278792f, 0.06090995f, -0.05892940f, 0.23367018f, 0.08243376f, 0.16303651f, 0.25586885f, 
    0.08184689f, -0.09895639f, 0.14562622f, -0.03143677f, 0.14199632f, 0.00593861f, -0.12065490f, 0.05445412f, 
    0.11545753f, 0.13470428f, -0.11302576f, -0.11633520f, 0.04371824f, 0.05002707f, 0.02442190f, 0.02336466f, 
    -0.05083940f, -0.06519114f, 0.06921567f, 0.00449155f, 0.32782674f, -0.17602067f, -0.16532208f, -0.09152181f, 
    0.05660543f, -0.01449800f, 0.07484379f, 0.10456996f, 0.14412354f, 0.06377150f, -0.14213224f, 0.07453766f, 
    0.11998975f, 0.03882252f, -0.01363068f, 0.04164594f, 0.03578958f, -0.12699415f, -0.09224729f, -0.18374190f, 
    0.09225918f, -0.04718890f, -0.05017844f, 0.16491072f, 0.18502226f, 0.00387961f, 0.02505441f, -0.05098283f, 
    -0.07281053f, -0.08784186f, -0.00067774f, 0.15211099f, -0.02138216f, 0.13956152f, -0.03580695f, -0.08026379f, 
    -0.36638433f, 0.00592742f, 0.05641406f, -0.16183351f, -0.04418188f, 0.00417688f, 0.03899878f, 0.14349112f, 
    0.25720635f, 0.16917622f, 0.06163286f, -0.06012154f, -0.04532164f, -0.20033249f, -0.03918921f, 0.07860425f, 
    0.05596302f, -0.07521893f, 0.05729276f, 0.16336611f, 0.03068513f, 0.05438706f, -0.16650936f, 0.00663420f, 
    0.05188205f, 0.10691790f, 0.04176764f, -0.11077588f, 0.12404104f, 0.21505181f, 0.11745330f, 0.18233420f, 
    -0.07252242f, -0.19136238f, -0.00493177f, -0.01249517f, 0.19204131f, 0.15474725f, -0.19093555f, -0.00416521f, 
    -0.09941183f, -0.00802525f, 0.01307984f, 0.13934757f, -0.03117340f, 0.08877712f, 0.10775917f, 0.00739222f, 
    -0.20030811f, 0.13542250f, 0.01353166f, 0.06087428f, 0.00585043f, 0.13371339f, 0.09326876f, -0.05601339f, 
    -0.01914363f, 0.08852736f, -0.10467310f, 0.02863136f, 0.13220091f, 0.02516121f, -0.07936371f, -0.23080969f, 
    -0.05952413f, -0.03913684f, -0.19105525f, 0.17654888f, -0.02826001f, 0.03251101f, 0.03304951f, -0.07143966f, 
    0.21296291f, -0.22629523f, -0.01699826f, 0.12068131f, -0.13225402f, -0.04596356f, -0.02873960f, -0.02345413f, 
    0.01498806f, -0.01671977f, 0.04956559f, -0.02588726f, 0.28429198f, 0.04943990f, -0.08520490f, 0.30693543f, 
    -0.01627582f, 0.00899058f, 0.04061075f, 0.04558476f, -0.06034994f, -0.10280015f, 0.11160310f, 0.22773412f, 
    0.49624282f, -0.10983502f, -0.11623013f, 0.01981870f, 0.05165541f, -0.11063765f, 0.02033682f, 0.17253870f, 
    -0.01894675f, 0.10535938f, -0.04760353f, 0.01289705f, -0.02700649f, -0.12662202f, -0.00791451f, -0.06258823f, 
    -0.05247711f, 0.10014497f, 0.02749935f, -0.00916941f, -0.16640159f, 0.09341967f, 0.08639583f, -0.04019659f, 
    -0.22369517f, -0.00834937f, 0.15830848f, 0.05397128f, 0.01935369f, 0.00518187f, 0.05350323f, 0.00542404f, 
    -0.01804355f, 0.24504723f, 0.12536924f, 0.05402201f, -0.03209227f, 0.22036888f, -0.02490855f, -0.04250662f, 
    -0.07207270f, 0.18177257f, 0.07940296f, 0.00635293f, -0.19340804f, 0.06943948f, -0.04179685f, 0.07604422f, 
    -0.03628061f, 0.05909038f, -0.05892418f, -0.02520142f, -0.06146622f, -0.03126553f, -0.04171240f, -0.02799930f, 
    -0.00011173f, -0.05634346f, 0.06642221f, 0.06100351f, -0.06496958f, -0.06715678f, 0.05372682f, 0.03989113f, 
    0.05599056f, -0.07590410f, -0.05931212f, -0.04321627f, -0.06657029f, 0.00243343f, 0.05514821f, -0.02954408f, 
    -0.01939629f, -0.04810373f, -0.03503888f, 0.04515031f, 0.03706377f, 0.03618554f, -0.01056364f, -0.07659837f, 
    0.02774911f, -0.06414245f, -0.05101169f, -0.01627206f, 0.04250434f, -0.05224797f, -0.06855981f, -0.02272289f, 
    -0.02469748f, -0.05483292f, -0.07196818f, -0.00523056f, -0.06074720f, 0.02249697f, 0.04348558f, -0.08020502f, 
    0.00747102f, -0.02283881f, -0.03206544f, 0.04305758f, -0.03634552f, -0.01031297f, -0.05018415f, -0.01600893f, 
    0.04379207f, 0.06184626f, -0.06121148f, -0.00786595f, -0.03545946f, -0.04949128f, 0.06223266f, 0.01696678f, 
    0.00880631f, -0.01569236f, -0.07559347f, -0.06672701f, 0.03046042f, -0.00065735f, -0.05500934f, 0.01370397f, 
    -0.07845362f, 0.04590146f, -0.00820529f, -0.05629179f, 0.00377335f, -0.05445337f, 0.02921953f, -0.06485800f, 
    0.01135870f, 0.00933903f, 0.03565551f, 0.02581842f, -0.03104988f, -0.06721532f, 0.00408249f, -0.05839388f, 
    0.06468891f, -0.06601038f, 0.04234279f, -0.04519027f, -0.07569482f, 0.06246061f, -0.01211960f, 0.04100612f, 
    -0.03975754f, -0.06938770f, 0.03241156f, 0.05231738f, -0.07487442f, 0.00243276f, 0.04722530f, -0.04815300f, 
    -0.02959266f, 0.04588404f, -0.01135565f, 0.01655446f, -0.04615834f, 0.06251206f, 0.04448545f, 0.06786445f, 
    0.02821807f, 0.00330043f, -0.04277264f, -0.01688438f, 0.03696179f, -0.04077003f, -0.04837170f, -0.04320380f, 
    0.04622659f, 0.06710795f, 0.00091945f, -0.07032581f, -0.05894890f, 0.00118620f, 0.00061195f, -0.04045217f, 
    -0.03666608f, 0.02210940f, -0.05139373f, -0.02244198f, -0.04729113f, -0.02337575f, 0.02496464f, 0.03147990f, 
    0.02660567f, -0.04849802f, 0.04211237f, 0.03071125f, 0.00990300f, -0.04010652f, 0.03407802f, -0.02048978f, 
    -0.05023688f, -0.01383413f, -0.04032370f, 0.05404938f, -0.06801904f, -0.01612206f, 0.03436478f, -0.02636570f, 
    -0.00686208f, 0.01720953f, -0.07001377f, -0.05146893f, 0.02899943f, -0.04533096f, -0.03643363f, -0.06108434f, 
    -0.07598374f, -0.05219189f, 0.02885656f, 0.00999354f, -0.04529409f, 0.02725786f, 0.00401919f, -0.03491619f, 
    0.05044030f, -0.04622010f, -0.03068255f, 0.03553629f, 0.05525690f, -0.01883592f, 0.05357459f, 0.01919938f, 
    0.06109072f, 0.06190431f, 0.05688998f, 0.00472599f, -0.05440980f, -0.02036837f, -0.05556979f, -0.06010333f, 
    -0.03300836f, -0.04991990f, -0.01540717f, 0.04068796f, 0.05950452f, -0.01730263f, -0.06192046f, -0.01996140f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.07126921f, 0.08380527f, -0.04376272f, 0.02449905f, 0.03863810f, -0.06608118f, 0.07750639f, 0.08772074f, 
    -0.04212131f, 0.02072042f, 0.03940532f, 0.04849382f, 0.01809156f, 0.01669115f, -0.08136716f, -0.08462699f, 
    0.11128796f, -0.03043055f, 0.12575452f, 0.01910046f, 0.16889268f, -0.00780336f, -0.03404435f, -0.03171263f, 
    -0.03962411f, 0.07171462f, -0.04989114f, 0.03736518f, 0.04502295f, 0.08256686f, 0.05093025f, -0.12103228f, 
    -0.00429030f, 0.00800309f, -0.03203120f, -0.01900847f, 0.01760007f, -0.06671289f, -0.14424711f, -0.01029954f, 
    0.02176258f, -0.04613079f, 0.19887041f, 0.04036895f, -0.02504042f, -0.03776140f, 0.04980204f, -0.00613436f, 
    -0.00822972f, 0.00774217f, 0.04144098f, 0.25176778f, -0.06698235f, 0.09965042f, 0.05851045f, 0.10435981f, 
    0.01853526f, -0.04138271f, -0.04806599f, 0.15179676f, 0.02905525f, -0.03440889f, 0.12557162f, -0.01248059f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.20913360f, -0.00906180f, 0.18055846f, 0.19333649f, -0.51898968f, 0.07741272f, 0.33700213f, -0.12912239f, 
    0.07985061f, 0.18086582f, -0.09167349f, -0.29876819f, -0.09299950f, 0.07069888f, 0.00364622f, 0.03194905f, 
    -0.34443375f, -0.15179512f, -0.05522785f, -0.00691825f, -0.11594434f, -0.10597797f, 0.03280025f, 0.01522051f, 
    0.14867346f, 0.22262904f, 0.05339213f, 0.18651360f, -0.15900651f, -0.03069831f, 0.03781913f, 0.08689159f, 
    0.17513748f, 0.04384820f, 0.00925457f, -0.27663052f, 0.05951578f, -0.04683093f, -0.22999842f, 0.12237187f, 
    -0.16201584f, -0.06865858f, -0.04567104f, -0.08486045f, 0.09366401f, 0.05461032f, 0.23112984f, 0.06726029f, 
    0.03352137f, 0.06314049f, 0.07721930f, -0.00766473f, 0.06931946f, 0.25682378f, 0.06723057f, 0.03759019f, 
    0.02750371f, 0.03649994f, -0.04681701f, -0.15812516f, 0.09187779f, 0.10081383f, 0.26223350f, 0.09803405f, 
    -0.15974140f, -0.04901463f, -0.05315838f, -0.13239898f, -0.50398660f, -0.10290821f, -0.00506950f, 0.06532818f, 
    -0.00885774f, 0.02036799f, -0.01101715f, 0.03084135f, -0.09531750f, -0.03029003f, 0.14617947f, 0.40274495f, 
    -0.10693347f, 0.07764915f, -0.21433505f, 0.08305095f, 0.06394961f, 0.05424093f, 0.09789041f, -0.05598183f, 
    0.12205638f, -0.03206860f, 0.02845040f, -0.07603288f, -0.10604287f, -0.28302595f, 0.10928944f, 0.21549627f, 
    0.20924364f, -0.02677089f, 0.03221899f, 0.07750396f, -0.09844444f, 0.06666704f, -0.39007786f, 0.19578134f, 
    -0.36659840f, 0.08906565f, -0.13068044f, -0.09488322f, -0.09902533f, 0.10386913f, 0.28283447f, -0.05442366f, 
    0.04485665f, -0.27129322f, 0.11101776f, -0.06423716f, 0.01584228f, 0.35052583f, -0.04125775f, -0.03585103f, 
    0.22882405f, 0.14223832f, 0.06075043f, -0.16513087f, 0.02191326f, 0.36176527f, -0.07538856f, 0.05623630f, 
    -0.21230207f, -0.23775925f, 0.08106236f, 0.06777375f, -0.10888464f, 0.11730924f, -0.07924926f, 0.18977146f, 
    -0.03577696f, 0.03601716f, -0.13085283f, -0.12505649f, 0.45078009f, 0.20289658f, 0.06778903f, 0.19442987f, 
    0.30171543f, 0.09663212f, 0.01582238f, 0.07046613f, 0.31352305f, -0.02517450f, -0.02393512f, -0.03413567f, 
    -0.15435760f, 0.05525810f, 0.05976509f, -0.13157463f, 0.16819392f, 0.11585424f, 0.03449867f, 0.23556758f, 
    0.16743378f, 0.06447616f, -0.09972029f, -0.01783208f, 0.03677284f, -0.06979357f, -0.12862463f, -0.09924980f, 
    0.26530716f, -0.11522985f, 0.41573256f, -0.20439333f, 0.07995425f, 0.00397474f, 0.25353780f, 0.11417650f, 
    0.00328089f, -0.23959525f, 0.06359968f, -0.05630894f, 0.08393477f, -0.26084176f, 0.00676604f, -0.08257152f, 
    -0.02387046f, 0.04907413f, -0.03788540f, 0.07283939f, 0.15682372f, -0.11544058f, 0.10793147f, -0.09832601f, 
    0.57064438f, 0.11484575f, 0.18888336f, 0.27624896f, -0.11491752f, 0.04857042f, 0.31658909f, -0.09790055f, 
    -0.04311675f, -0.11915274f, 0.07501879f, -0.27630121f, 0.14832960f, -0.15643613f, -0.23252380f, 0.16474636f, 
    0.00781550f, -0.00294687f, -0.10791020f, 0.11017789f, -0.06797373f, 0.06809325f, -0.07953662f, 0.12832360f, 
    0.02130826f, 0.11979207f, 0.10530367f, 0.14231554f, 0.03983675f, 0.13085628f, 0.02632192f, -0.06424349f, 
    -0.00311373f, 0.02954197f, 0.09268476f, -0.10172533f, -0.10775467f, 0.10457424f, 0.05428554f, 0.12561785f, 
    0.06972693f, -0.00508015f, -0.20229344f, 0.15964928f, -0.03887867f, 0.10166608f, 0.13189380f, 0.01897165f, 
    0.06241262f, 0.05520078f, -0.04958679f, -0.04654370f, 0.03535803f, 0.09882046f, 0.14803907f, 0.12941258f, 
    -0.16392908f, -0.13309419f, -0.07777190f, 0.03725036f, -0.00982892f, -0.00761837f, 0.16505960f, -0.05230197f, 
    -0.12893017f, -0.05248263f, -0.20037413f, 0.17995520f, 0.16406319f, -0.08244076f, -0.04424054f, -0.14987269f, 
    -0.09231627f, -0.01156917f, -0.19214103f, -0.25216517f, 0.18437313f, 0.35071039f, 0.11823694f, -0.10013711f, 
    0.03122106f, -0.27665153f, -0.07777658f, -0.11789903f, 0.27625480f, -0.08507916f, -0.04535019f, 0.04160418f, 
    -0.11886443f, 0.24559836f, 0.06091997f, 0.19597718f, -0.04064336f, 0.22622709f, 0.06592309f, -0.10404889f, 
    -0.00604393f, -0.01241677f, -0.11035272f, -0.25547922f, -0.02752993f, -0.05510988f, -0.13414881f, 0.12794232f, 
    0.21369113f, 0.00920350f, 0.25165322f, 0.15021226f, -0.10983200f, 0.10080479f, 0.00849179f, -0.01716436f, 
    -0.02185317f, -0.03615838f, -0.07130462f, 0.28345808f, -0.03111215f, -0.14925711f, -0.03779179f, 0.07073817f, 
    -0.13596143f, 0.17014489f, -0.05934792f, -0.10811552f, 0.19379807f, -0.08901948f, 0.19092244f, 0.02417222f, 
    -0.10383523f, -0.01180698f, -0.00487835f, 0.26325369f, 0.09027732f, 0.05085842f, 0.26053929f, 0.17358944f, 
    -0.01880348f, -0.02454753f, -0.07251656f, -0.09654414f, -0.19297118f, -0.36342874f, 0.00796043f, -0.11719760f, 
    -0.40257454f, 0.02055414f, 0.29709357f, 0.07995307f, 0.12386501f, 0.10201024f, 0.12887932f, 0.07560588f, 
    0.14037432f, 0.05429927f, -0.09576416f, -0.15976837f, 0.11570872f, 0.04980916f, -0.19706026f, -0.16152664f, 
    0.03843921f, -0.11716127f, -0.05780761f, 0.05911322f, -0.09399325f, 0.10143102f, -0.47162846f, -0.02360849f, 
    -0.15334187f, 0.05737672f, 0.14752808f, 0.20364100f, -0.06410551f, 0.04703259f, 0.18694817f, -0.03107733f, 
    0.04527289f, 0.14295933f, 0.03016592f, -0.11990435f, -0.09844518f, -0.14802070f, 0.03860331f, -0.07834319f, 
    0.37196529f, 0.03481584f, 0.00035614f, 0.20229906f, -0.14437923f, 0.01636680f, 0.28708926f, -0.09961345f, 
    0.06603066f, -0.02687887f, -0.10538006f, 0.10525236f, -0.08662079f, 0.08371233f, -0.01697243f, -0.03955527f, 
    0.08574203f, -0.12041057f, -0.06727857f, 0.07500292f, -0.06035126f, -0.04875641f, -0.10423601f, -0.08997190f, 
    -0.07460992f, -0.10519865f, -0.13404104f, -0.01343341f, -0.09598976f, -0.07433802f, -0.09599632f, 0.07152115f, 
    0.09065828f, 0.07759931f, 0.03005214f, -0.08887307f, -0.07822811f, 0.05580272f, -0.10235351f, 0.01936461f, 
    0.04688880f, 0.09017557f, -0.09598640f, 0.05732971f, -0.01877517f, 0.04363007f, -0.06155676f, 0.08294438f, 
    0.08734716f, 0.03246191f, -0.08830981f, -0.01372479f, -0.02267392f, -0.08808787f, 0.01867318f, -0.05193934f, 
    -0.02996160f, -0.04181147f, 0.04399197f, -0.05701305f, 0.06830033f, -0.00683255f, 0.00611672f, -0.14057049f, 
    0.03904864f, -0.08971686f, -0.05963127f, 0.01276368f, -0.07489454f, -0.09021138f, -0.11028518f, -0.00530839f, 
    0.16859674f, -0.02965168f, 0.06588636f, 0.12461288f, -0.16899332f, -0.06371669f, 0.09853629f, -0.15260504f, 
    0.01464659f, 0.09084847f, 0.11041637f, 0.10416830f, 0.22222860f, 0.13510752f, 0.20180242f, -0.03370387f, 
    -0.21170567f, -0.04495102f, 0.03922512f, -0.08468497f, -0.22394447f, -0.05971122f, 0.08588246f, 0.00876186f, 
    -0.13034238f, -0.17162701f, 0.03315847f, 0.31118822f, 0.11996496f, 0.20849936f, -0.13452838f, 0.27853394f, 
    0.06122366f, -0.00799967f, 0.11512188f, -0.09061106f, 0.09087362f, 0.00745190f, 0.28403717f, 0.01224169f, 
    -0.04427718f, 0.03644595f, -0.17280097f, 0.00371954f, -0.03423709f, 0.07915056f, -0.09439412f, 0.01790204f, 
    -0.03464004f, 0.36298430f, 0.08150458f, -0.23306262f, 0.09679836f, -0.23765829f, 0.12955552f, 0.08747520f, 
    -0.03720683f, 0.26553953f, -0.02351140f, -0.16420534f, 0.17173161f, 0.02831232f, -0.00709408f, -0.10812689f, 
    0.19761308f, 0.02754064f, 0.17683136f, -0.19972506f, -0.04775759f, 0.09098743f, 0.15333840f, 0.00378983f, 
    -0.04351617f, 0.04710981f, -0.14878614f, -0.05316518f, 0.14276002f, 0.38215280f, 0.13000493f, 0.25382653f, 
    0.04793166f, 0.09704425f, -0.25508648f, -0.05591717f, -0.07838955f, -0.10931399f, 0.00726536f, -0.02530653f, 
    0.07073512f, -0.04759481f, -0.01084390f, 0.22522075f, -0.05067661f, 0.20258321f, 0.07248149f, 0.30831999f, 
    0.19443886f, -0.01812318f, 0.12163942f, 0.10887478f, 0.11318775f, -0.07333604f, -0.16438651f, -0.15637782f, 
    -0.00688433f, -0.09697241f, -0.04339775f, -0.30086738f, 0.04085505f, -0.01851627f, 0.05732863f, -0.05051714f, 
    -0.01472954f, -0.09120538f, -0.09764791f, -0.24808905f, -0.00941564f, -0.12971632f, 0.04046078f, -0.13965987f, 
    -0.18952329f, 0.37917161f, -0.08290821f, -0.52769709f, 0.30317816f, -0.01476256f, -0.14546250f, -0.08997913f, 
    -0.09721182f, -0.14649129f, -0.10994528f, 0.08229799f, 0.06027053f, 0.05534149f, -0.11039089f, -0.12504447f, 
    -0.05042405f, -0.07637604f, -0.10625581f, -0.10986102f, -0.07747597f, -0.06547555f, -0.11998554f, -0.07897553f, 
    0.10079511f, 0.09133596f, 0.02716938f, 0.02054100f, -0.05375810f, 0.06586071f, 0.04417842f, 0.08028603f, 
    -0.02910574f, -0.03001690f, 0.06221008f, 0.04883995f, -0.03217032f, 0.08633484f, -0.12000848f, -0.04150596f, 
    -0.00294219f, 0.03001422f, 0.08836670f, -0.10396901f, 0.04566756f, -0.07895230f, -0.10434091f, 0.05878070f, 
    -0.05502966f, -0.09312284f, 0.00796666f, 0.00483446f, 0.03418986f, 0.04611491f, -0.11741264f, -0.00369054f, 
    -0.00189997f, -0.04034942f, 0.08240144f, 0.08872195f, -0.11603115f, 0.05040035f, -0.08720200f, -0.08731516f, 
    -0.14165032f, -0.06943835f, -0.09087891f, -0.02771586f, -0.00745345f, -0.02826267f, 0.01590874f, -0.11919875f, 
    -0.17176285f, -0.18759373f, 0.00947992f, -0.06942774f, -0.13071716f, 0.08975700f, -0.40794930f, 0.18482296f, 
    0.00584181f, 0.05255052f, 0.12650517f, 0.41408023f, 0.01104621f, -0.07856669f, 0.10916304f, 0.33284804f, 
    0.22082956f, 0.22532997f, -0.15660539f, -0.10729781f, -0.02938555f, -0.05129589f, -0.02509181f, 0.01220067f, 
    -0.10587522f, 0.01787781f, 0.08943938f, -0.22154714f, -0.16481952f, -0.23634183f, 0.08700748f, 0.06995202f, 
    0.12052308f, -0.12260789f, -0.01681175f, 0.10192961f, 0.05145670f, 0.00369162f, -0.11171313f, 0.08441298f, 
    0.09538041f, -0.01784392f, 0.05394492f, 0.04088531f, 0.03615968f, 0.07357624f, 0.13447426f, -0.04517947f, 
    0.05268161f, 0.03846517f, -0.07880700f, 0.00136386f, 0.11301209f, 0.23296347f, -0.11387978f, -0.05067280f, 
    -0.03276271f, -0.15614083f, -0.04649959f, 0.34371915f, 0.02583370f, -0.05423891f, -0.21428239f, -0.12484144f, 
    0.18190135f, -0.08712278f, 0.21963252f, 0.17830043f, 0.44891602f, 0.03567013f, 0.09870075f, 0.13985465f, 
    -0.01140589f, 0.08356285f, 0.04875920f, -0.08825721f, 0.25903326f, 0.28141132f, 0.06140852f, -0.27460334f, 
    -0.19757095f, 0.25633958f, -0.06287703f, -0.07458869f, -0.16178191f, -0.10032050f, 0.00149973f, 0.06015142f, 
    0.34377745f, 0.34560817f, -0.11413152f, 0.04057886f, 0.01362411f, 0.03366839f, -0.30290994f, -0.15642370f, 
    -0.02753413f, -0.06150060f, 0.08592606f, 0.28514677f, 0.02745891f, -0.03706554f, 0.18366836f, 0.03556459f, 
    0.05622730f, 0.07715596f, -0.22643873f, 0.06609010f, 0.01135657f, 0.08376284f, 0.05890844f, 0.11209743f, 
    -0.03463164f, 0.06005676f, 0.10019238f, 0.04866104f, -0.08870911f, -0.19736136f, 0.12102518f, 0.18117958f, 
    -0.19203262f, 0.12114608f, -0.06205917f, -0.31783333f, -0.07672859f, -0.30881128f, 0.22219087f, 0.09478920f, 
    0.03117008f, 0.26918194f, -0.02067569f, 0.04193006f, 0.25938359f, -0.09107964f, -0.06638249f, -0.01437605f, 
    0.01529221f, -0.19153351f, 0.11751048f, -0.01944905f, -0.29971939f, -0.05190360f, 0.17718272f, -0.09334960f, 
    -0.20964503f, -0.13157807f, 0.22730617f, -0.11868274f, 0.10500771f, 0.10070355f, 0.09157252f, 0.04184973f, 
    0.02735399f, -0.00651885f, 0.07802007f, 0.21979845f, -0.19149719f, 0.06303319f, -0.18107244f, -0.11386637f, 
    -0.03989952f, -0.05084960f, 0.00468426f, -0.26843303f, -0.11078894f, -0.12006245f, 0.03466098f, 0.17375354f, 
    -0.04644653f, -0.01239701f, -0.07387680f, 0.31870785f, -0.09234606f, -0.05044650f, 0.03140812f, 0.00278675f, 
    -0.10032685f, 0.29359281f, 0.05197681f, 0.11187638f, -0.03335467f, -0.06984910f, 0.15504429f, 0.31414264f, 
    0.18423174f, -0.01732318f, 0.05462169f, 0.30354178f, -0.04510281f, 0.31386265f, -0.10227294f, 0.06526784f, 
    -0.26983351f, 0.05266786f, -0.21222916f, 0.07025254f, 0.23656504f, -0.06219005f, 0.13206637f, 0.11200120f, 
    -0.04040666f, -0.14688635f, 0.16522697f, -0.06990345f, 0.03549775f, -0.37632042f, -0.06930732f, 0.18405968f, 
    0.28621873f, -0.02209663f, 0.05840134f, 0.03070068f, -0.04125760f, -0.08779513f, 0.09358273f, -0.12080114f, 
    -0.09639323f, -0.12116501f, -0.12824631f, 0.07715970f, 0.23647979f, 0.20739171f, 0.31612602f, 0.19772266f, 
    0.07351594f, -0.01044354f, 0.02809259f, 0.00925966f, 0.01071588f, 0.01168775f, -0.14020126f, -0.01110305f, 
    -0.01137786f, 0.08520304f, 0.18065204f, 0.07603844f, -0.02929104f, 0.00931275f, 0.00836950f, 0.00615481f, 
    -0.00449561f, -0.02907780f, 0.07424492f, 0.14067037f, 0.05315428f, -0.27547896f, -0.05175308f, -0.08844266f, 
    0.01840739f, -0.28594980f, 0.07381012f, 0.34674829f, 0.06837199f, 0.21964431f, 0.00585759f, 0.09708598f, 
    0.11291829f, 0.39576280f, 0.17895429f, -0.28898406f, 0.35995102f, -0.04481200f, -0.14183296f, 0.09029265f, 
    -0.12160710f, 0.10728794f, -0.26434401f, 0.09241308f, -0.12467023f, 0.31251413f, 0.21116434f, 0.06575248f, 
    -0.06173471f, 0.09551547f, 0.03832353f, -0.09836964f, 0.05185140f, 0.10661961f, -0.08517300f, -0.06241913f, 
    0.14901401f, 0.14027742f, -0.01659743f, 0.17893454f, -0.13933854f, 0.16468941f, -0.14007048f, 0.11150125f, 
    0.26573837f, -0.03403961f, 0.01920322f, -0.05830279f, -0.10092005f, -0.00694352f, -0.00749268f, -0.18826330f, 
    -0.06146754f, 0.06622554f, -0.14295289f, 0.12540261f, 0.09385677f, -0.09295952f, -0.04212014f, -0.11840713f, 
    -0.02269565f, 0.13970485f, 0.09356385f, -0.21192420f, 0.02553595f, -0.20798101f, 0.26612964f, 0.06483503f, 
    0.23259541f, 0.26186588f, -0.05600528f, -0.17840198f, 0.16933997f, 0.16419813f, -0.18447863f, -0.02212893f, 
    -0.14530478f, 0.08147477f, 0.33335105f, -0.24102351f, 0.45898604f, -0.03061947f, -0.22958331f, 0.15848291f, 
    0.03677347f, -0.07565101f, -0.20825373f, 0.24268909f, -0.14894600f, 0.31003943f, -0.13998687f, -0.29184884f, 
    0.41437361f, 0.16638069f, 0.05663397f, 0.01098068f, 0.23114567f, -0.00348728f, -0.02552238f, -0.06122440f, 
    0.28688517f, 0.30379197f, 0.03587092f, 0.04450558f, -0.02228111f, 0.15148224f, -0.01307579f, -0.08994875f, 
    -0.04266181f, 0.05566185f, 0.05666050f, 0.43442291f, -0.04086913f, 0.13255374f, 0.03617511f, -0.12534957f, 
    0.28965184f, -0.04902333f, 0.04058176f, 0.04744094f, 0.01225156f, -0.05222960f, 0.20756456f, -0.01767109f, 
    0.06697025f, -0.00220115f, -0.05971113f, 0.09497354f, 0.01431900f, 0.05418570f, 0.06361303f, 0.11616269f, 
    -0.04362058f, 0.00275096f, -0.00690966f, -0.03960376f, -0.06452959f, -0.06792967f, -0.00720369f, -0.01037546f, 
    0.02704523f, 0.13579893f, -0.08577728f, -0.09485693f, 0.29944968f, 0.10878912f, -0.27661458f, 0.01797726f, 
    -0.10510677f, 0.03329536f, -0.01439800f, -0.08998980f, 0.10413001f, 0.53237891f, 0.07360484f, 0.04962501f, 
    0.32153034f, 0.03831493f, -0.13433219f, -0.02757661f, 0.23702709f, 0.09624761f, 0.09534774f, 0.01744129f, 
    0.11949550f, 0.24510606f, -0.04620501f, -0.16975713f, -0.04570951f, -0.08901309f, -0.17841001f, -0.19771887f, 
    0.00453490f, 0.01141121f, 0.04332329f, -0.14879157f, -0.09026285f, 0.05503849f, -0.17679529f, 0.12777357f, 
    0.07090876f, -0.03186938f, 0.04287918f, -0.06648467f, -0.04598792f, -0.00890566f, 0.30086070f, 0.04531861f, 
    0.07994865f, 0.04601833f, -0.04000853f, 0.15450895f, 0.06796149f, 0.00427602f, 0.14732273f, 0.07128497f, 
    0.03793614f, -0.08214270f, -0.08572101f, 0.17820668f, 0.14333317f, 0.09308705f, -0.12139855f, -0.07120647f, 
    -0.09861268f, -0.20119168f, 0.10589641f, 0.05741143f, 0.23092353f, -0.03003302f, -0.16720626f, 0.24311900f, 
    0.09709662f, -0.16520160f, 0.31233558f, 0.18436408f, 0.27201155f, -0.02067718f, 0.04568548f, 0.37477377f, 
    0.51034766f, 0.25944197f, -0.08077755f, -0.02371538f, -0.15668263f, 0.13376321f, 0.08705954f, -0.02387801f, 
    -0.01802923f, -0.17844631f, -0.02494499f, -0.11238185f, 0.37347814f, 0.12221251f, 0.44058630f, 0.30292803f, 
    -0.09040614f, 0.05555396f, 0.06739502f, 0.40313897f, -0.11876294f, 0.10067394f, 0.23534131f, -0.11594371f, 
    0.01336430f, -0.04610887f, -0.03799552f, -0.04597935f, 0.08912237f, -0.00799087f, -0.16419144f, 0.01891568f, 
    -0.02057469f, -0.19035323f, -0.00599657f, 0.16375658f, -0.00075121f, -0.27191833f, -0.16242206f, 0.15227422f, 
    -0.24235994f, 0.05611492f, -0.19563639f, 0.03168840f, -0.00862356f, -0.10826577f, -0.16892028f, 0.04610079f, 
    0.32160470f, -0.03570497f, 0.17138565f, -0.04436208f, -0.01379479f, -0.00941900f, -0.00582934f, -0.07496709f, 
    -0.05028068f, 0.10718090f, 0.21631289f, 0.39055696f, -0.01431372f, 0.28861997f, 0.02757634f, -0.02640867f, 
    0.27239993f, 0.15827915f, 0.11167238f, 0.00884216f, -0.04336746f, 0.09536760f, 0.12555327f, -0.02314012f, 
    0.15021658f, 0.09799159f, -0.00745050f, -0.04147647f, 0.07875798f, -0.20623840f, -0.05350088f, 0.06334113f, 
    -0.11829952f, 0.08403893f, -0.05977483f, 0.34927946f, -0.02150370f, 0.04689429f, 0.34904960f, 0.20390610f, 
    0.31846955f, 0.08483089f, -0.08764482f, 0.10509215f, -0.10223167f, 0.04067800f, -0.16737510f, -0.06895199f, 
    -0.06583018f, -0.00678638f, 0.06010998f, 0.02529077f, -0.11164464f, 0.36918700f, -0.12043745f, 0.09254330f, 
    -0.16930325f, 0.27048951f, -0.02420689f, -0.22456650f, -0.02068324f, -0.09993487f, 0.01919026f, 0.11640790f, 
    0.02363463f, 0.10592137f, -0.04079926f, 0.02366767f, -0.08416112f, -0.00090900f, 0.09220692f, 0.01838402f, 
    0.05457351f, -0.06705511f, -0.10612044f, -0.19015427f, -0.09480765f, 0.07354625f, -0.05055869f, 0.11756828f, 
    0.00063196f, 0.03090577f, 0.02960203f, 0.01547609f, 0.03732716f, 0.00051302f, -0.00146806f, 0.11256682f, 
    -0.10583941f, 0.14456229f, -0.05838098f, -0.02908052f, -0.02584133f, 0.09014342f, -0.01462277f, 0.03899017f, 
    -0.04553512f, 0.00291393f, -0.08040824f, -0.02893372f, 0.03176738f, 0.09472880f, -0.06612688f, 0.09446820f, 
    -0.03618165f, -0.03922111f, 0.08333232f, -0.07219674f, 0.09758300f, -0.07384463f, 0.11232154f, -0.00414221f, 
    0.03813568f, -0.06076650f, 0.10987152f, 0.16627850f, 0.03514902f, -0.06381124f, 0.04929658f, 0.06583375f, 
    0.02121590f, 0.02004422f, 0.10174988f, 0.12606467f, -0.04403996f, 0.06507575f, 0.07747205f, -0.00720172f, 
    0.06417771f, 0.39266810f, -0.21739990f, -0.11518911f, 0.44608915f, 0.07407121f, 0.08672900f, 0.00711703f, 
    0.00686260f, -0.17097889f, -0.03719522f, -0.04795506f, -0.03951981f, -0.08686218f, -0.30469206f, -0.33415881f, 
    0.28937659f, -0.09164951f, 0.02766298f, 0.08595613f, 0.26884404f, 0.02764135f, 0.03577737f, 0.09856860f, 
    0.21723017f, 0.11963310f, 0.11216582f, -0.00654417f, 0.21184175f, -0.02079662f, -0.03378502f, -0.31798512f, 
    -0.04107844f, 0.02533156f, -0.03402261f, 0.16416340f, 0.02722266f, -0.05072042f, 0.02949907f, -0.06417086f, 
    -0.15172988f, -0.01682222f, 0.08644301f, 0.00657415f, 0.05445886f, -0.00096887f, -0.14842662f, -0.06847300f, 
    0.12665673f, 0.18870826f, 0.10029095f, 0.24143422f, 0.04383406f, -0.21022652f, 0.01892164f, 0.18833058f, 
    0.06313516f, -0.21052311f, -0.10219925f, -0.01269756f, -0.04751925f, 0.12436997f, 0.02767446f, 0.01817449f, 
    0.00204584f, -0.23336762f, -0.15012312f, -0.08914936f, -0.02245258f, -0.00484358f, -0.11587069f, 0.19510058f, 
    0.07049598f, 0.04240829f, 0.25907058f, 0.18601090f, -0.08693375f, 0.27599937f, 0.21832548f, 0.24218521f, 
    0.29153109f, 0.01978958f, -0.01744554f, 0.09438987f, 0.14282773f, 0.10781906f, 0.00543423f, -0.03307338f, 
    -0.06673850f, -0.03402552f, -0.02205403f, -0.13120656f, -0.05014850f, -0.12818928f, 0.29459813f, 0.04629267f, 
    -0.00089626f, 0.11899766f, 0.10420088f, -0.17180647f, -0.01172148f, 0.04204154f, -0.01383859f, 0.38504153f, 
    0.08526594f, -0.09108929f, 0.31535614f, 0.09992770f, 0.08358562f, 0.05099614f, 0.13584037f, 0.09682737f, 
    -0.09691664f, -0.23991570f, 0.00194355f, 0.08498599f, 0.09862638f, 0.12086459f, -0.02397103f, 0.09867568f, 
    -0.09437830f, -0.08904648f, 0.03333955f, 0.23162299f, 0.16743454f, -0.02065879f, -0.16769098f, -0.11719656f, 
    0.14983238f, 0.03065554f, 0.27745438f, -0.13563959f, -0.39372891f, -0.02139218f, 0.20496564f, 0.11705028f, 
    -0.00520331f, 0.21349292f, -0.10381883f, 0.22946310f, 0.02271910f, 0.16799708f, 0.27092600f, 0.15906571f, 
    -0.17609726f, -0.15040599f, 0.16191946f, -0.01805712f, 0.10629640f, 0.03174434f, 0.02592841f, -0.00913069f, 
    -0.16986014f, -0.26291972f, -0.10278450f, -0.01302071f, 0.17492576f, 0.18463574f, -0.20488840f, 0.22514506f, 
    0.28190941f, 0.00569288f, -0.00525086f, 0.00261307f, -0.01617526f, -0.03070171f, -0.05770705f, -0.21370168f, 
    0.12746198f, -0.01001804f, -0.05145966f, -0.09715358f, 0.06485833f, 0.02081762f, -0.31258786f, 0.06589320f, 
    -0.03805576f, 0.19656837f, -0.11452322f, -0.31807378f, 0.00770007f, -0.14380902f, 0.13774800f, 0.12919092f, 
    0.24332617f, 0.40114006f, 0.08748811f, -0.13631850f, 0.28864631f, -0.06471065f, -0.00780925f, 0.05535819f, 
    -0.00310298f, 0.17254956f, 0.13308086f, -0.17712831f, -0.24463585f, -0.02061359f, 0.09613191f, 0.11934686f, 
    -0.05825177f, 0.11622864f, -0.27560729f, 0.03424861f, 0.01178730f, -0.10381831f, 0.04842336f, 0.18176804f, 
    -0.08297902f, 0.29898292f, -0.06568664f, 0.06129277f, -0.00920235f, 0.01798699f, 0.07358804f, -0.02208084f, 
    0.36741817f, 0.09925211f, -0.04604623f, -0.10415266f, -0.00087070f, -0.01797019f, 0.14844272f, 0.06840656f, 
    0.18810609f, -0.08368338f, 0.03119944f, 0.47373578f, -0.00809704f, 0.01651922f, 0.15174502f, -0.07406236f, 
    -0.23195185f, 0.13619581f, -0.13485886f, -0.04423189f, -0.07269148f, -0.00627578f, -0.01155583f, -0.09966533f, 
    -0.12053290f, -0.15883239f, 0.11127780f, 0.04543138f, -0.09492484f, 0.02252826f, 0.04978685f, -0.01797353f, 
    0.06404454f, 0.16758168f, 0.02587267f, -0.32534379f, 0.14346369f, 0.02695819f, 0.14651218f, -0.07585712f, 
    0.03363590f, 0.28609380f, 0.24077043f, -0.05418900f, 0.28975543f, -0.03980184f, 0.16457663f, 0.21415871f, 
    -0.11253283f, 0.00830113f, -0.18884186f, 0.03289586f, -0.34581664f, -0.01641772f, 0.30689347f, -0.06434245f, 
    -0.36501321f, 0.10719173f, 0.09709937f, -0.03168447f, -0.07254879f, 0.11289264f, -0.09518484f, 0.01771650f, 
    0.27722290f, -0.00951519f, -0.02602508f, -0.11962795f, -0.24684693f, 0.01804422f, -0.02171269f, -0.17090946f, 
    0.25674671f, -0.06584739f, -0.08911750f, 0.11833853f, -0.09190730f, -0.04280257f, 0.14589235f, 0.07575045f, 
    -0.14048129f, 0.03307503f, -0.23478304f, 0.16257656f, -0.00717121f, 0.10111933f, 0.22452581f, -0.07843436f, 
    0.11892054f, 0.24128106f, 0.09771126f, -0.13085422f, 0.03735526f, 0.11357396f, 0.08364538f, -0.02225219f, 
    0.31332904f, 0.11816502f, 0.01569396f, -0.09236548f, -0.00244289f, 0.24961741f, 0.00268498f, 0.09704859f, 
    0.04938701f, 0.07173853f, -0.10304381f, -0.13706458f, 0.10510019f, 0.10924818f, -0.13606788f, -0.08854403f, 
    -0.11913218f, -0.03824557f, -0.12041499f, 0.04741348f, -0.00492075f, -0.02557477f, -0.04379182f, 0.00973424f, 
    -0.00221504f, -0.13894336f, -0.01156544f, 0.09600544f, 0.00049931f, -0.04407483f, 0.01290707f, -0.09603511f, 
    0.03131618f, 0.06060381f, 0.10637012f, 0.10763807f, -0.11446937f, -0.12112443f, -0.09721029f, -0.08668809f, 
    0.07274769f, 0.03100948f, 0.09479424f, 0.00472120f, 0.10084081f, -0.00743851f, -0.00548303f, 0.04572422f, 
    -0.00935131f, -0.11873579f, 0.02573913f, -0.07040510f, 0.06781057f, 0.06235833f, -0.03434650f, 0.11902499f, 
    -0.09896608f, -0.04485190f, 0.08782420f, 0.01871254f, -0.07646479f, 0.04316444f, -0.02114936f, 0.06847475f, 
    -0.04844947f, 0.00417668f, -0.04494585f, -0.02742176f, -0.04278720f, -0.12040005f, 0.04439121f, 0.03104706f, 
    -0.13306104f, -0.04004765f, -0.02665859f, -0.21153499f, 0.47298235f, -0.11369789f, -0.12006881f, 0.16349024f, 
    -0.02928616f, -0.13095774f, 0.12560856f, -0.05524132f, -0.14526072f, -0.11006032f, 0.18018024f, -0.00424727f, 
    0.00909606f, 0.07729907f, 0.06403010f, -0.10059509f, -0.06094727f, -0.08994985f, 0.01998691f, 0.01582097f, 
    0.10447977f, -0.00941239f, -0.11776398f, 0.05254287f, -0.01976758f, 0.08931258f, 0.30252904f, 0.02421211f, 
    0.11294386f, -0.04103003f, -0.07967712f, 0.08885534f, 0.05135432f, -0.06566326f, 0.47378421f, 0.00747188f, 
    -0.27819371f, -0.06533619f, -0.17327745f, -0.06125005f, 0.01362357f, -0.08774975f, 0.22591321f, -0.02827455f, 
    0.04870078f, -0.11319576f, -0.04901485f, 0.06035288f, -0.10378730f, -0.13865505f, 0.13946968f, 0.18377826f, 
    0.01373523f, -0.13779733f, 0.10556316f, -0.02998028f, 0.07566452f, 0.10368355f, -0.19049451f, 0.05671663f, 
    0.40292183f, 0.05345033f, 0.19231988f, 0.20336786f, -0.40637946f, -0.13212547f, 0.00278514f, 0.09121017f, 
    0.11073427f, -0.06215427f, 0.14576471f, -0.26747227f, 0.40374005f, 0.07152047f, 0.02357135f, 0.32649124f, 
    0.09966139f, 0.33987412f, -0.11354800f, 0.08965498f, -0.15979417f, 0.01373757f, -0.07455856f, -0.10479646f, 
    0.12773150f, 0.34968004f, 0.01007888f, 0.17404704f, 0.02872418f, -0.11977143f, -0.13399068f, 0.02598006f, 
    -0.00923463f, -0.00070837f, -0.05222996f, -0.15165122f, 0.07905939f, 0.07455314f, -0.16825584f, 0.36997834f, 
    0.21709034f, -0.03171819f, -0.23077698f, 0.00020062f, -0.11184809f, -0.04982415f, 0.36614421f, 0.01005921f, 
    0.05225807f, 0.01468367f, -0.03994656f, -0.09349709f, 0.11329389f, 0.36552089f, 0.02008890f, 0.02506077f, 
    -0.23940301f, 0.01406292f, 0.13940698f, -0.06135171f, 0.12817162f, -0.07123924f, 0.10192708f, 0.01416565f, 
    -0.14000513f, 0.04005614f, 0.02479924f, 0.12079589f, 0.16342634f, 0.09295817f, 0.02518897f, -0.07427684f, 
    0.12121829f, 0.08461951f, 0.08128489f, -0.24497685f, -0.12374976f, -0.34675503f, 0.07942031f, -0.14086394f, 
    0.11229224f, 0.03198129f, 0.08266938f, 0.02483831f, 0.14289644f, -0.12041304f, 0.05780539f, -0.09655009f, 
    0.07290163f, 0.14686356f, 0.05923861f, -0.05774123f, -0.11969483f, 0.08932177f, -0.14346583f, -0.17084914f, 
    0.04144157f, 0.04526320f, 0.11764503f, 0.10839364f, -0.09129137f, -0.12425244f, -0.40457386f, 0.05593117f, 
    0.01153362f, 0.04079425f, 0.22739980f, 0.09856512f, -0.12423870f, 0.00243215f, -0.01865914f, -0.08103655f, 
    -0.04862571f, 0.02018565f, 0.01859093f, 0.07451507f, 0.09117268f, 0.04805888f, -0.12325602f, -0.18443650f, 
    0.12838241f, 0.00173696f, -0.07536796f, 0.08067870f, -0.08430342f, 0.06573680f, 0.09878565f, -0.09942473f, 
    -0.01725038f, 0.09005927f, 0.04961533f, -0.03568230f, 0.03899984f, -0.09884922f, -0.07197557f, 0.02539933f, 
    -0.04174176f, 0.01738406f, -0.05195370f, -0.00196629f, -0.05550630f, 0.09594044f, -0.10171797f, 0.06935440f, 
    0.04178632f, 0.03751583f, 0.04658708f, 0.10672407f, -0.05973490f, -0.07392392f, -0.03551717f, 0.07475595f, 
    -0.13203326f, -0.06227628f, -0.10340546f, -0.09754128f, -0.04133309f, -0.12261695f, -0.13817732f, -0.03513249f, 
    -0.01686957f, -0.11494707f, -0.02507484f, 0.07599418f, 0.07545349f, 0.01353825f, 0.07720108f, 0.06036793f, 
    0.01877191f, 0.04823576f, 0.01224909f, -0.11740978f, -0.11369854f, 0.04289743f, 0.07800829f, 0.09166019f, 
    -0.07089382f, 0.01934279f, -0.03110692f, -0.11158247f, -0.09721634f, -0.06490762f, -0.08053782f, 0.09109556f, 
    -0.14501132f, 0.00425766f, -0.04387957f, -0.08378373f, -0.01646334f, -0.05411299f, -0.05145085f, -0.07318578f, 
    0.14511216f, 0.09630478f, -0.19982688f, -0.03665110f, -0.22806349f, 0.10722531f, 0.01936227f, -0.14621530f, 
    0.06795939f, -0.06132505f, 0.22244264f, 0.20085426f, -0.18404928f, -0.04418326f, -0.04396481f, 0.06146645f, 
    0.20989920f, -0.01424822f, 0.20260820f, -0.10949917f, -0.04622527f, -0.05074262f, -0.02811496f, 0.08768544f, 
    0.17919700f, -0.24834220f, 0.05941512f, 0.07104039f, 0.23470785f, -0.16518219f, 0.16572534f, 0.11473503f, 
    -0.25738955f, 0.03490913f, -0.11563558f, 0.03186181f, 0.03192746f, -0.06451106f, 0.43375298f, 0.19466875f, 
    0.00716436f, -0.04136818f, -0.32600576f, 0.20928352f, -0.01043955f, 0.12891875f, -0.29780653f, 0.02407438f, 
    -0.10986248f, 0.22264083f, 0.02434356f, 0.17537089f, 0.02664172f, 0.14016069f, 0.01533620f, 0.20831510f, 
    -0.09385473f, 0.02316704f, 0.10237300f, -0.01618179f, -0.01637526f, 0.25315079f, 0.01173771f, 0.10185861f, 
    0.05351985f, -0.04882066f, -0.04079390f, 0.15426882f, 0.00448913f, 0.11680859f, -0.05769897f, 0.05886485f, 
    0.05545536f, -0.06837567f, 0.14922936f, 0.32244724f, -0.21734487f, -0.11457984f, 0.16017365f, 0.11255216f, 
    0.09034087f, -0.02730319f, 0.29834008f, -0.08209684f, -0.19525617f, -0.02091110f, -0.09958624f, -0.05389830f, 
    -0.16272125f, -0.19727941f, 0.11022793f, 0.15655255f, 0.08194683f, 0.02234494f, 0.14246473f, 0.24927366f, 
    0.01004883f, 0.04751934f, -0.06540668f, -0.07992447f, 0.07670869f, -0.02975313f, 0.38124111f, 0.04231997f, 
    -0.07234547f, -0.10629323f, 0.05969426f, -0.03007104f, -0.09578064f, 0.09908451f, -0.06950470f, 0.05074629f, 
    0.00732653f, -0.13385788f, -0.07580329f, 0.16313824f, 0.03425153f, 0.45455799f, 0.09003016f, 0.13290446f, 
    -0.05665632f, -0.17258222f, 0.00748448f, 0.14384115f, 0.16504222f, 0.01668124f, -0.03205315f, -0.04176190f, 
    -0.06141203f, -0.04466344f, 0.03108776f, 0.00747273f, -0.09483144f, -0.11843754f, 0.03193662f, 0.04488497f, 
    -0.00929563f, -0.01232937f, -0.10432041f, 0.04916614f, 0.02054207f, -0.01989095f, 0.01288651f, -0.10726856f, 
    0.06993739f, 0.07329750f, -0.12775135f, 0.00040780f, -0.01654413f, 0.04479006f, 0.11442914f, -0.00890797f, 
    0.01767738f, -0.08368442f, 0.00436617f, 0.06290420f, -0.05053647f, 0.01645587f, -0.05017219f, -0.15302132f, 
    0.06738419f, 0.06443083f, 0.09675267f, -0.14325374f, -0.03877639f, -0.12348928f, -0.09719073f, -0.09419025f, 
    -0.13728432f, 0.01829654f, 0.01692314f, -0.08716371f, 0.00838488f, -0.09506011f, 0.07307877f, 0.05079044f, 
    -0.11487430f, -0.09921257f, 0.11252131f, -0.00921308f, -0.03837782f, -0.06389400f, -0.05097858f, 0.00404706f, 
    -0.11697805f, -0.04713514f, -0.01492321f, -0.03080990f, 0.08173453f, -0.02394746f, -0.07797427f, -0.04291235f, 
    -0.10235877f, -0.01033710f, -0.07579114f, 0.01803413f, -0.08925276f, -0.11935806f, -0.30670440f, -0.43544346f, 
    0.03744397f, 0.00792074f, 0.08463422f, -0.10118441f, 0.16365497f, -0.16915002f, -0.12284021f, 0.16480812f, 
    0.29800114f, 0.20504500f, -0.01270696f, 0.11717685f, -0.20810369f, -0.11025552f, -0.06913126f, -0.07574081f, 
    -0.05065001f, -0.22098514f, 0.00456370f, 0.15460180f, 0.11099205f, -0.08551803f, 0.13904695f, 0.07760189f, 
    -0.08075333f, 0.09240924f, 0.09238976f, 0.16223396f, -0.01078916f, -0.00429982f, 0.21103439f, -0.05987220f, 
    -0.21661970f, 0.03250113f, -0.35854542f, 0.09606231f, -0.01083262f, 0.01184349f, -0.02401403f, 0.04634683f, 
    -0.03248565f, 0.23328120f, -0.01555206f, 0.07977919f, 0.05997163f, -0.21031746f, -0.19270699f, -0.02308054f, 
    0.14163294f, -0.02494232f, -0.08668042f, 0.19887690f, -0.21345671f, 0.16832682f, 0.11884319f, 0.10824978f, 
    0.39144176f, 0.30011797f, 0.10423344f, -0.07037452f, -0.13062820f, 0.02438275f, 0.20035410f, 0.16926023f, 
    0.07803944f, -0.05682041f, 0.05928876f, -0.15559411f, -0.11029259f, -0.33098942f, -0.02991731f, 0.28396729f, 
    -0.02944060f, -0.13530609f, -0.08017896f, -0.08546682f, -0.01803814f, -0.07170194f, 0.12606059f, 0.04386931f, 
    0.31609878f, -0.01391163f, 0.09850354f, -0.01508092f, 0.17519291f, -0.01777346f, 0.18751150f, -0.07620483f, 
    -0.09040771f, -0.09891856f, 0.02843162f, 0.11801670f, 0.04041602f, 0.03856840f, -0.10487177f, 0.11683886f, 
    -0.35991114f, -0.02463581f, -0.16462308f, 0.01612817f, 0.10228862f, -0.01788040f, 0.01446824f, -0.12270488f, 
    0.01785376f, -0.13443470f, 0.05040095f, -0.16823231f, -0.06647231f, 0.20338836f, 0.22022538f, 0.13569108f, 
    -0.00998565f, -0.05698429f, -0.02675850f, -0.07904211f, -0.02961573f, 0.27002618f, -0.10713805f, 0.11854116f, 
    -0.08507106f, -0.19451104f, -0.33212659f, 0.35968605f, -0.07376298f, -0.05852288f, 0.25959474f, -0.07100810f, 
    -0.07565278f, 0.01255237f, 0.25434506f, -0.30636057f, 0.09600313f, -0.36167449f, 0.12408727f, -0.08051694f, 
    -0.12578155f, -0.08218267f, 0.21913388f, -0.00107272f, -0.06954483f, 0.06923264f, -0.02080915f, -0.00418158f, 
    -0.04467954f, 0.20340332f, 0.04233731f, 0.05301335f, 0.08890649f, -0.11032919f, 0.23858728f, -0.03657646f, 
    -0.15749252f, 0.03598484f, -0.00250240f, -0.13406016f, 0.10442013f, -0.11019787f, -0.50558603f, 0.24190763f, 
    0.03773658f, 0.06865496f, 0.42764196f, 0.01569365f, -0.11767444f, -0.00277180f, 0.37132511f, 0.09283721f, 
    0.03017817f, -0.13176781f, 0.05555040f, 0.27481365f, 0.03519064f, 0.11144876f, -0.03831035f, 0.10867807f, 
    0.12868194f, -0.29380080f, -0.05162787f, 0.12210912f, -0.07035824f, -0.04815505f, 0.28350407f, -0.07159003f, 
    0.31595549f, 0.22005202f, 0.16127944f, -0.01952420f, 0.02902558f, -0.06901754f, -0.13026051f, -0.06771204f, 
    -0.12266935f, -0.09290584f, 0.09468756f, 0.28416985f, -0.17258398f, 0.14539403f, 0.04961084f, -0.07205579f, 
    0.04540383f, -0.24714565f, 0.13307504f, 0.04932225f, -0.21791428f, 0.03879754f, 0.01925680f, 0.06932999f, 
    -0.11128034f, -0.20611736f, 0.12419666f, 0.08160278f, 0.11720841f, -0.05619451f, 0.05674200f, 0.21192922f, 
    -0.16724193f, 0.00109126f, 0.01556934f, -0.09541493f, -0.09199014f, -0.12837820f, 0.42166719f, 0.09707781f, 
    0.14545900f, -0.09994821f, -0.24139100f, 0.24613144f, -0.11733574f, -0.05373900f, -0.23603001f, -0.02671361f, 
    -0.08441745f, 0.24472313f, 0.09746560f, 0.10579370f, 0.07058929f, 0.22593978f, 0.17515007f, 0.20784278f, 
    -0.03692092f, 0.17955102f, 0.06532855f, 0.18608220f, 0.09082514f, -0.06632199f, -0.15344156f, 0.05656651f, 
    -0.02695856f, 0.19716488f, 0.33155370f, -0.08779162f, -0.00026632f, -0.11288928f, -0.04285505f, 0.08326324f, 
    -0.12009645f, 0.26243451f, -0.21519887f, 0.41554004f, 0.01851983f, -0.15775959f, -0.01725125f, 0.17980649f, 
    0.35360768f, -0.08722417f, 0.10895608f, -0.02117607f, 0.28614640f, 0.09264142f, 0.00636019f, -0.06054007f, 
    -0.00771442f, -0.00388312f, -0.02351670f, -0.16833077f, 0.25274500f, 0.31988636f, 0.05918079f, 0.14394930f, 
    0.13362618f, -0.01330696f, 0.02779969f, 0.29120249f, 0.12673040f, -0.06290522f, -0.01669305f, -0.31972978f, 
    0.09520946f, -0.05736156f, 0.21892491f, 0.00241310f, -0.07060330f, -0.01981155f, -0.11843497f, -0.03948928f, 
    -0.01685975f, -0.13180588f, -0.09169794f, -0.11438114f, 0.07336232f, 0.08158276f, 0.02750125f, -0.06829919f, 
    0.16811198f, 0.03837085f, -0.06494480f, 0.27040398f, 0.08651511f, -0.11005658f, 0.10906462f, 0.10946074f, 
    0.35973117f, 0.16247824f, 0.17476261f, 0.14122161f, 0.20935820f, -0.04157274f, -0.03919073f, 0.13273923f, 
    0.00181032f, -0.03084307f, 0.03649075f, 0.08094826f, -0.24504246f, -0.06192253f, -0.08534769f, -0.10403984f, 
    -0.13350555f, -0.21875593f, 0.18136942f, 0.02652203f, -0.19300391f, -0.05960746f, -0.02528583f, -0.11161678f, 
    0.16778415f, 0.08228703f, 0.01010998f, 0.24422629f, 0.11320677f, 0.09114519f, 0.08865108f, 0.13731509f, 
    -0.14844289f, 0.07440459f, -0.06782475f, -0.12942728f, -0.10578664f, 0.03619331f, 0.29325065f, 0.14397262f, 
    -0.01377099f, 0.04535469f, -0.07742517f, 0.20486857f, 0.03834146f, 0.04565278f, -0.06110206f, -0.10843606f, 
    0.12790139f, 0.05923191f, -0.09290572f, 0.04557260f, 0.04606639f, 0.20452143f, 0.02088188f, 0.30810010f, 
    0.04882811f, -0.17029783f, 0.01809265f, 0.21233854f, -0.00913623f, 0.27425823f, -0.09275388f, 0.08259054f, 
    -0.27208623f, -0.06431577f, -0.11639345f, -0.07563301f, 0.29582837f, 0.11110692f, -0.19059648f, 0.08245648f, 
    -0.04465206f, -0.06992323f, 0.01247178f, -0.08817384f, 0.10242638f, 0.32414961f, 0.07470869f, -0.19347180f, 
    0.24057063f, 0.12982020f, -0.02222347f, -0.05189058f, 0.13497548f, 0.04303983f, -0.10725485f, 0.06564425f, 
    -0.03052008f, 0.20665184f, -0.12449177f, 0.01935336f, -0.00143399f, -0.02426542f, 0.03483871f, -0.00262747f, 
    -0.10594252f, 0.10775450f, -0.08170708f, 0.16394182f, -0.07288234f, -0.05620268f, -0.12358453f, 0.04289364f, 
    0.15741046f, 0.03828315f, 0.12112252f, 0.02443239f, -0.02493967f, 0.01176587f, 0.24623370f, -0.03183556f, 
    0.02374558f, -0.02634926f, -0.04828651f, 0.28631786f, -0.09341056f, 0.09360743f, 0.07707382f, 0.21427858f, 
    -0.17464484f, 0.13828422f, 0.09240220f, -0.14335427f, 0.04274374f, -0.22956811f, 0.16744681f, 0.05419044f, 
    -0.14342853f, -0.18732511f, -0.05261162f, 0.28243101f, -0.13196509f, 0.05325850f, 0.09030605f, -0.07336909f, 
    0.11059780f, 0.17366527f, 0.03107033f, 0.23860934f, -0.15285456f, -0.25080106f, 0.08908813f, 0.17657734f, 
    0.03914042f, -0.29683387f, 0.33005190f, -0.04405299f, 0.16270581f, 0.06850691f, 0.02212595f, -0.09689803f, 
    -0.30322376f, -0.11672127f, -0.11598545f, -0.09133492f, 0.07121220f, 0.17569160f, 0.11595523f, -0.03514307f, 
    0.03555834f, 0.10292877f, 0.06683387f, -0.25653505f, -0.08734024f, -0.00810578f, -0.06271945f, 0.06795602f, 
    0.22264260f, -0.04399363f, 0.25275603f, 0.16840553f, 0.07587861f, 0.01458944f, -0.08818547f, -0.07858551f, 
    -0.08444604f, -0.11350926f, 0.05367107f, 0.11624535f, -0.10456274f, 0.38250124f, 0.10137861f, 0.13035989f, 
    0.11805347f, -0.21965429f, -0.10383864f, 0.44577044f, 0.16015607f, 0.05770629f, 0.16581635f, -0.11082724f, 
    0.04985725f, 0.11358170f, 0.17704874f, -0.08694410f, 0.37276003f, 0.11593524f, -0.09662525f, 0.12106961f, 
    -0.11822271f, 0.17339559f, -0.22601910f, -0.07892097f, 0.03968929f, 0.56853437f, 0.05196707f, -0.28631577f, 
    -0.05244849f, 0.01832158f, -0.18422809f, -0.04929802f, 0.27271688f, 0.03985224f, -0.08829748f, 0.10274684f, 
    0.32646978f, 0.38111854f, 0.01106345f, 0.08240629f, -0.21961243f, -0.05319565f, -0.30127999f, -0.07599191f, 
    0.02431010f, 0.11185725f, 0.10123560f, 0.08754632f, 0.07926145f, -0.04501745f, -0.14572218f, 0.09431133f, 
    0.13979131f, -0.01804781f, -0.19339815f, 0.06789093f, 0.08104242f, 0.12827159f, 0.04384894f, -0.00735296f, 
    -0.01397371f, 0.21488658f, -0.01727584f, -0.04120969f, -0.08317490f, 0.14238547f, 0.16743875f, 0.03658047f, 
    0.17149945f, 0.24132755f, 0.02726767f, -0.16864884f, -0.09585773f, 0.17550230f, -0.08261851f, 0.00664456f, 
    -0.05648653f, 0.04440504f, 0.02088726f, -0.12045805f, -0.12228597f, 0.12126517f, 0.10097241f, -0.07479857f, 
    -0.09031440f, 0.02213664f, -0.01441438f, 0.01406408f, -0.06898153f, -0.10682066f, 0.07682791f, 0.05674751f, 
    -0.12449402f, -0.06845503f, 0.05832096f, 0.04287125f, -0.04594339f, 0.08771335f, 0.05945450f, -0.07789197f, 
    -0.02311851f, 0.08447655f, -0.02190296f, 0.00860840f, -0.08681545f, 0.07231607f, -0.15352410f, -0.08293857f, 
    -0.00001956f, -0.05093445f, -0.00180135f, -0.07444450f, -0.09912550f, 0.00032667f, 0.02922074f, -0.02419749f, 
    -0.00536713f, 0.11288586f, -0.11247892f, 0.06983642f, 0.00559267f, -0.12007134f, -0.14844720f, -0.03934018f, 
    -0.09327742f, -0.01716884f, -0.06275041f, 0.06342084f, -0.04354427f, 0.01439912f, -0.12937132f, 0.02485842f, 
    -0.04083003f, -0.07686911f, -0.06993027f, -0.08507603f, -0.02522828f, -0.07522218f, -0.11606080f, -0.11770482f, 
    -0.16786174f, -0.09289765f, 0.04011331f, -0.05743315f, 0.19781241f, -0.02569482f, -0.11496786f, 0.01371158f, 
    -0.11619773f, -0.08218905f, 0.18859065f, -0.10412562f, -0.21312183f, 0.05190211f, 0.07642397f, -0.22048417f, 
    0.17521265f, 0.14032823f, -0.07840388f, 0.02244185f, 0.00864136f, -0.07042227f, -0.02093351f, 0.04496718f, 
    0.39593336f, 0.08613542f, 0.06756656f, 0.15652333f, -0.03050662f, -0.12481308f, -0.02886466f, -0.42087105f, 
    -0.17330265f, -0.10310768f, 0.01089875f, 0.35489619f, 0.10400796f, -0.05314245f, 0.27347443f, 0.20059633f, 
    -0.15214059f, 0.04154668f, 0.04639750f, 0.22485954f, 0.00694068f, -0.03743506f, 0.21179883f, -0.11766121f, 
    0.06653213f, 0.02635913f, -0.03982069f, 0.15719837f, 0.10535743f, -0.10855556f, -0.01403334f, -0.02018856f, 
    0.02645728f, 0.09200013f, -0.00040355f, -0.07824720f, -0.11927637f, 0.10488098f, 0.05515025f, -0.00565373f, 
    0.01624281f, 0.10965380f, -0.04731490f, -0.01562028f, -0.28202730f, 0.02739154f, -0.03573246f, 0.10914241f, 
    0.00251047f, 0.01113437f, -0.14978972f, -0.28124529f, -0.20112276f, -0.02209379f, 0.18858944f, -0.00737167f, 
    -0.14937198f, -0.10754094f, 0.15965325f, -0.00428228f, 0.03690244f, 0.08726291f, -0.04391709f, -0.07272477f, 
    0.01238120f, -0.01892702f, 0.02583236f, 0.16536339f, 0.00262892f, -0.10088017f, 0.26876882f, 0.17515893f, 
    -0.04763599f, -0.09552329f, -0.09924066f, -0.15370744f, 0.01564346f, 0.02369413f, 0.03128208f, 0.28342423f, 
    -0.32194310f, -0.02484522f, -0.19741701f, -0.12850609f, -0.10331650f, -0.02672723f, 0.10211560f, -0.11620198f, 
    -0.07607947f, -0.03027818f, 0.05286076f, 0.17911522f, 0.00893986f, 0.19791964f, 0.14536682f, 0.21378084f, 
    0.11188213f, 0.11658190f, 0.21593706f, -0.30198002f, 0.16070963f, 0.29877901f, -0.02973911f, 0.10693205f, 
    0.15083621f, 0.18129177f, -0.33504552f, 0.31264874f, -0.11258713f, 0.05269004f, -0.05087411f, -0.28274563f, 
    0.09994787f, -0.13126443f, 0.08815935f, -0.29594308f, 0.14841262f, 0.26102293f, -0.33092281f, -0.04341149f, 
    0.26937339f, -0.12207112f, 0.06624100f, 0.06938455f, 0.06356272f, 0.10076765f, 0.03229766f, -0.02835052f, 
    0.08595733f, 0.01559876f, -0.07932456f, 0.07423797f, 0.28506032f, -0.12076262f, 0.26621428f, -0.11156313f, 
    -0.32577026f, -0.01567000f, -0.04509670f, -0.11613173f, -0.02635743f, 0.07308944f, 0.14660323f, 0.09370437f, 
    -0.03640943f, 0.06670583f, -0.00157435f, 0.13477421f, -0.04667234f, -0.01021867f, -0.05699334f, 0.06418148f, 
    0.01333369f, 0.10538266f, -0.07322107f, 0.22867368f, -0.03834652f, -0.08381726f, 0.01696965f, 0.21767111f, 
    -0.24115238f, -0.19911225f, -0.09776638f, 0.19210996f, 0.06744427f, 0.23394449f, -0.02879264f, 0.00386629f, 
    -0.36247250f, 0.18138058f, -0.12246025f, -0.31931332f, 0.55528307f, 0.10190639f, -0.26413608f, 0.03393117f, 
    0.11223404f, 0.01163325f, 0.10195163f, 0.47306859f, -0.15210022f, 0.08381163f, 0.17068496f, 0.03439432f, 
    0.19403806f, -0.11613405f, 0.18540373f, -0.03354685f, 0.05904952f, 0.12648121f, -0.02772319f, -0.09919570f, 
    0.05523626f, -0.10322949f, -0.05799103f, 0.13801801f, 0.03759420f, 0.00620739f, 0.30950096f, 0.02978154f, 
    0.09619468f, -0.07967661f, 0.04870521f, 0.23587663f, -0.12622954f, 0.12877360f, 0.45564604f, -0.01806122f, 
    0.00594794f, -0.06944486f, 0.14140055f, -0.07591755f, -0.06185608f, -0.09805384f, 0.00435962f, 0.03068751f, 
    -0.11117466f, -0.10875714f, -0.12432314f, 0.19953388f, -0.09660812f, -0.04138214f, 0.10080573f, 0.11984693f, 
    -0.05332955f, 0.04559720f, -0.03582004f, 0.09201359f, 0.15111943f, 0.06396343f, -0.30416036f, -0.08158118f, 
    -0.30227661f, -0.11142950f, -0.11327972f, -0.23726106f, 0.16916144f, 0.02226112f, -0.16008604f, 0.16092512f, 
    0.04776030f, 0.22787297f, -0.17028780f, 0.40405586f, -0.03713904f, 0.44264463f, 0.24285473f, -0.22724827f, 
    -0.17662783f, -0.14238819f, 0.15818287f, -0.05788155f, 0.15364185f, -0.06307621f, 0.07079916f, -0.10652897f, 
    -0.32146576f, -0.07045577f, 0.02416595f, -0.11099038f, -0.07247131f, 0.08295473f, -0.10734691f, 0.00325306f, 
    -0.04432954f, -0.06852455f, 0.03282237f, 0.08043662f, 0.08400067f, 0.11574014f, 0.21876734f, 0.07967273f, 
    0.27099261f, 0.00139195f, 0.28271964f, 0.10483307f, -0.07782435f, 0.06523354f, -0.23036948f, -0.05451717f, 
    -0.05691839f, -0.01534902f, 0.08761696f, -0.04814809f, -0.02691389f, -0.18767878f, 0.05687230f, 0.11251153f, 
    -0.06138058f, 0.20286208f, -0.07063483f, -0.02996108f, 0.26597199f, -0.12809698f, -0.08279380f, 0.03653548f, 
    0.11049936f, 0.04722784f, -0.04990899f, 0.24389431f, 0.02470630f, -0.11216010f, 0.07993175f, -0.12440661f, 
    0.00069848f, -0.14274608f, 0.12301477f, -0.05979990f, -0.25089923f, -0.19635864f, -0.04985572f, -0.25219035f, 
    0.21242185f, -0.17262252f, 0.24596140f, 0.10877395f, 0.06930966f, 0.09394963f, 0.03780749f, -0.02361046f, 
    0.19944064f, 0.00547158f, -0.03847481f, -0.00851683f, 0.24137591f, -0.14532267f, 0.19994566f, -0.08755913f, 
    -0.14642896f, 0.03961954f, -0.08325122f, 0.06427604f, -0.08089110f, 0.01412859f, 0.10327420f, 0.21055025f, 
    -0.00054166f, -0.04100477f, 0.08007546f, 0.19703786f, -0.04986785f, 0.03366545f, -0.24058209f, 0.02069786f, 
    0.07666433f, 0.12675904f, -0.11297306f, 0.38200781f, -0.06430283f, 0.18924989f, 0.04432255f, 0.26765898f, 
    0.02890914f, -0.13868028f, -0.07034550f, 0.11859035f, -0.15538241f, -0.00520910f, -0.00659136f, 0.10062782f, 
    0.03191327f, 0.09791300f, -0.12780710f, -0.12424371f, 0.10317568f, 0.01085767f, 0.04329713f, 0.09365508f, 
    -0.01634419f, -0.01372250f, -0.04373160f, -0.03515315f, -0.12214097f, 0.07055192f, -0.06913025f, 0.09681647f, 
    -0.01516647f, 0.05985098f, 0.01763300f, 0.01449458f, -0.07177199f, 0.11280622f, -0.01101366f, -0.08907673f, 
    -0.10115221f, 0.01298401f, 0.09890379f, 0.05715002f, -0.04370861f, -0.07768898f, -0.11477752f, -0.05048413f, 
    -0.11313604f, -0.02000926f, 0.07841055f, 0.07424908f, 0.09864171f, 0.03806180f, -0.11804596f, -0.07957381f, 
    -0.11802016f, -0.08214128f, 0.10419441f, -0.07946565f, -0.00502740f, -0.02737294f, -0.06355649f, -0.08264381f, 
    -0.08808851f, -0.04634744f, -0.04278256f, 0.06752080f, -0.10006595f, -0.09974285f, -0.09165179f, 0.02025335f, 
    -0.07452264f, -0.00782349f, -0.06891048f, -0.11701505f, -0.05150089f, -0.09190280f, 0.08874130f, -0.03723952f, 
    -0.05815823f, 0.00855732f, -0.32289413f, 0.11673079f, 0.04817995f, -0.00337803f, -0.16196269f, -0.24598506f, 
    0.00388567f, -0.00190686f, 0.34393311f, 0.11785100f, 0.20932980f, -0.01477615f, -0.08022951f, 0.22141398f, 
    0.17668687f, 0.22776656f, -0.12930407f, 0.10046737f, -0.21708751f, -0.02791983f, -0.07567048f, 0.08426112f, 
    0.01057224f, -0.15423664f, 0.09155560f, 0.05529525f, 0.18274251f, -0.01123341f, 0.03496236f, 0.05102075f, 
    -0.20704430f, -0.01828161f, 0.06580599f, 0.21337827f, -0.02524555f, -0.05557666f, 0.30903423f, 0.15926658f, 
    0.00450444f, 0.03522898f, -0.14440159f, 0.11296503f, 0.09248921f, -0.06694262f, -0.19786116f, -0.11481126f, 
    0.01879185f, 0.22757252f, 0.10195843f, -0.08845063f, -0.03572012f, -0.42216536f, 0.11927967f, -0.08245286f, 
    -0.07929480f, 0.06768007f, -0.01788078f, 0.19434690f, -0.16159992f, 0.17831782f, 0.00606275f, 0.00590457f, 
    0.14875266f, 0.24192944f, 0.22586676f, -0.26954409f, 0.14386947f, -0.02501860f, -0.05225588f, 0.05920714f, 
    0.08161555f, -0.02899462f, 0.03949760f, 0.23083352f, 0.09773925f, 0.12185411f, 0.26813826f, 0.15677391f, 
    -0.19039187f, 0.08688768f, 0.00612282f, 0.11196312f, -0.07875048f, -0.06760874f, -0.07080939f, -0.02759479f, 
    -0.01893889f, -0.00852293f, -0.11856303f, 0.08001830f, -0.07946732f, 0.11018497f, -0.17925030f, 0.09938683f, 
    0.29815784f, -0.06881147f, 0.03052447f, -0.09366149f, 0.10674329f, -0.00050244f, 0.01610517f, -0.10049056f, 
    0.11847622f, 0.06291354f, -0.18658683f, 0.05901392f, -0.00102648f, -0.04956725f, 0.04750361f, -0.00000289f, 
    -0.09619858f, 0.24520393f, -0.08452050f, -0.28797653f, -0.03797404f, -0.11138289f, 0.10663949f, 0.13752739f, 
    0.31007725f, 0.22423148f, -0.00383173f, 0.01595297f, 0.11897483f, 0.18371487f, -0.21614334f, 0.08732502f, 
    0.26440090f, 0.27400088f, -0.01085315f, 0.21908748f, -0.13998313f, 0.06410625f, 0.44514865f, 0.17571007f, 
    0.10335738f, -0.05223373f, 0.24397065f, 0.07576370f, -0.29189956f, -0.43822402f, -0.01027977f, 0.27580401f, 
    -0.22285540f, -0.22510047f, 0.22951257f, 0.05817263f, -0.13194552f, -0.01353637f, -0.11950227f, 0.11966491f, 
    0.21303147f, -0.25424346f, 0.08017822f, -0.12249640f, 0.03621663f, 0.01260123f, 0.03298599f, 0.06176547f, 
    0.04306967f, 0.10234247f, -0.07397743f, 0.18311226f, 0.07458728f, 0.06537528f, -0.18131050f, -0.09833558f, 
    -0.36483163f, -0.10742180f, 0.08268493f, 0.28421399f, -0.03595990f, -0.08662301f, -0.12313583f, 0.09546831f, 
    -0.06923177f, 0.16609119f, 0.07237990f, -0.24456517f, 0.02060748f, -0.22652268f, 0.27338630f, -0.00549419f, 
    0.24089319f, 0.08769639f, 0.04200226f, 0.04602755f, -0.17940754f, 0.19867341f, 0.03892394f, 0.01328367f, 
    -0.11524496f, -0.06289836f, 0.08702607f, 0.09698699f, -0.58451265f, -0.08562747f, 0.32502723f, 0.14889453f, 
    0.04179129f, 0.21720812f, -0.10840892f, -0.01597247f, -0.00566844f, -0.28218102f, 0.09255557f, 0.07454921f, 
    -0.23487015f, 0.15870434f, 0.05547244f, 0.04636413f, 0.04487466f, -0.03451255f, -0.06770204f, -0.11812817f, 
    0.11243515f, 0.11673243f, 0.05713603f, -0.02028292f, -0.07835037f, -0.01245741f, 0.12735751f, 0.13449128f, 
    0.21704075f, 0.02983125f, -0.07670423f, 0.01792613f, 0.09110457f, -0.12872735f, -0.12992685f, 0.14496778f, 
    -0.11796978f, -0.03155613f, 0.23879917f, -0.14429885f, -0.08966470f, 0.11189563f, 0.15664141f, 0.00048498f, 
    -0.00207920f, -0.12665971f, 0.11748232f, 0.07144681f, 0.04664381f, 0.45317173f, -0.03880308f, -0.19453986f, 
    0.15727888f, -0.09330936f, 0.10853440f, -0.23545189f, 0.08071367f, 0.16502155f, 0.32545897f, -0.03096321f, 
    -0.31016874f, 0.03642196f, -0.01339417f, 0.01485496f, -0.20553210f, -0.01249376f, 0.16482806f, 0.08932911f, 
    -0.10272688f, 0.15332188f, 0.02217821f, 0.04210610f, 0.30218667f, -0.40918419f, 0.07853313f, 0.30128524f, 
    0.34274817f, -0.03574682f, -0.03062885f, -0.08389316f, 0.14872167f, -0.04887670f, 0.00590599f, 0.09381166f, 
    -0.03623434f, -0.30044726f, 0.07173176f, 0.06046123f, 0.19134913f, 0.20804732f, 0.18839808f, 0.11428445f, 
    0.04510050f, 0.01262837f, 0.00609397f, -0.12377643f, 0.07069712f, -0.00383236f, -0.15701742f, -0.17031275f, 
    -0.08061507f, 0.03356911f, 0.34877768f, -0.00318907f, 0.02494573f, 0.00288149f, -0.08894240f, 0.05381556f, 
    0.00081013f, 0.05713402f, -0.01533473f, 0.00627330f, 0.08954896f, -0.29462063f, 0.06014044f, -0.23767763f, 
    0.11827488f, -0.03278739f, -0.11051288f, 0.10949577f, 0.21631671f, -0.06428160f, 0.08625947f, 0.01865544f, 
    0.02608876f, 0.17890751f, -0.09182543f, 0.03557393f, 0.14347181f, -0.00064226f, 0.00043180f, 0.05127323f, 
    -0.00901185f, 0.10203120f, -0.21192305f, -0.44049096f, 0.08936118f, 0.29815361f, -0.06577218f, -0.27736267f, 
    -0.04963906f, 0.08867520f, -0.18176256f, -0.01960537f, 0.24770479f, 0.05075406f, 0.08531161f, -0.12913384f, 
    0.03837943f, 0.44895577f, 0.00149572f, 0.26723742f, -0.12964183f, 0.18590422f, 0.03830954f, -0.07436502f, 
    0.03310042f, 0.08251551f, -0.06464870f, -0.07658099f, -0.07023975f, -0.09986646f, -0.30773690f, 0.07008902f, 
    -0.09004609f, -0.09092406f, 0.16305991f, -0.03919889f, -0.09004185f, -0.05470939f, 0.34608930f, 0.01445037f, 
    0.10901330f, -0.03880011f, 0.07343266f, 0.09848115f, 0.06328458f, 0.01987462f, 0.04507803f, 0.11951727f, 
    0.17415014f, 0.06354642f, 0.23145637f, -0.15294664f, 0.10376522f, 0.17035727f, 0.16007413f, 0.09393376f, 
    -0.20445001f, 0.02027857f, -0.02173980f, 0.19052076f, 0.15461704f, -0.02020863f, 0.23997121f, 0.06072365f, 
    0.00168376f, -0.07579625f, 0.01516107f, -0.07126874f, 0.25318286f, -0.17177495f, -0.11356098f, -0.04870528f, 
    0.09776895f, -0.21896702f, 0.21480688f, -0.08008948f, 0.02887513f, -0.06236516f, -0.11755507f, 0.08120616f, 
    -0.22119975f, -0.16696721f, -0.07369269f, 0.11711617f, 0.29164410f, 0.39179084f, 0.26978320f, 0.23542181f, 
    -0.01167852f, -0.10201342f, -0.02589667f, 0.09496529f, 0.02065202f, -0.08658836f, -0.28751317f, -0.33257270f, 
    0.01396611f, 0.01824449f, 0.22610126f, -0.01819620f, 0.06703296f, -0.00232262f, -0.02076685f, -0.04165843f, 
    -0.06113337f, -0.14297238f, -0.01980604f, 0.08937266f, 0.00945559f, -0.30371764f, -0.00405156f, -0.08379109f, 
    -0.01559529f, -0.13081197f, 0.01583418f, 0.09218736f, 0.20040260f, -0.19446288f, 0.32052743f, -0.10352222f, 
    -0.13476714f, 0.07777103f, -0.11907575f, -0.01547642f, 0.10378284f, 0.06548654f, -0.13580559f, -0.12531625f, 
    -0.01704010f, -0.04875748f, -0.00289801f, -0.06903815f, 0.09006383f, -0.08051793f, 0.03522976f, -0.14165042f, 
    0.09680855f, -0.09079748f, -0.08150952f, -0.04132292f, 0.09360962f, -0.05611745f, 0.01004415f, -0.09359140f, 
    -0.09732342f, 0.02450075f, -0.06225365f, -0.12362432f, 0.07171321f, 0.08199591f, 0.08786904f, 0.00244566f, 
    -0.07884352f, -0.01406055f, 0.11543500f, -0.04429498f, 0.07624738f, -0.00679265f, -0.02252725f, 0.02618293f, 
    0.04188060f, 0.04383342f, -0.10654530f, 0.05236408f, 0.10391940f, -0.05451885f, 0.04378918f, -0.10811207f, 
    0.03442486f, -0.12713020f, -0.07646766f, 0.00242541f, 0.09137285f, -0.02435473f, 0.07568398f, -0.04762241f, 
    0.05848179f, -0.00880543f, 0.08418155f, -0.02334157f, -0.00505099f, -0.11416115f, 0.03721585f, -0.01024864f, 
    -0.07117393f, 0.00388381f, 0.03330164f, -0.11408865f, -0.10257524f, 0.02158485f, -0.17094855f, 0.07237056f, 
    -0.01577622f, 0.03985879f, -0.11583863f, -0.10771982f, 0.03716366f, -0.17851233f, 0.01324098f, 0.03760586f, 
    -0.10712700f, -0.06722867f, -0.00425922f, 0.12106697f, 0.05384909f, 0.11222734f, -0.04721230f, 0.00444405f, 
    -0.14990488f, 0.00544831f, 0.07428133f, -0.10120071f, -0.08355431f, -0.00566138f, -0.08173112f, 0.11140068f, 
    -0.06686687f, 0.05181147f, -0.11036136f, -0.05340083f, 0.10506674f, -0.00414102f, 0.03376216f, -0.05870232f, 
    -0.10198707f, -0.04448551f, -0.15059248f, -0.14737344f, 0.10398998f, -0.06704336f, 0.02202186f, -0.06054826f, 
    -0.00862383f, -0.04945552f, 0.11715548f, 0.10368297f, 0.00422992f, 0.05923747f, -0.13559169f, -0.04627468f, 
    -0.03380046f, -0.02014005f, -0.10095700f, -0.04700529f, 0.04816265f, -0.08416314f, 0.06404815f, -0.01132023f, 
    -0.08103478f, -0.05041562f, -0.10322411f, 0.05330014f, 0.00155555f, 0.08553882f, 0.03480566f, -0.05580600f, 
    0.06349632f, -0.04616360f, -0.10309257f, 0.08417973f, 0.07985283f, -0.06253406f, -0.06563305f, 0.02430186f, 
    0.03992845f, -0.01935131f, -0.11125195f, -0.06880324f, -0.01762945f, 0.00326246f, -0.03695244f, 0.07585892f, 
    0.02099682f, -0.00238799f, 0.03825513f, 0.02499248f, 0.04894388f, 0.06155909f, -0.11665945f, 0.00178693f, 
    -0.10375215f, -0.02358831f, 0.04962587f, 0.09238700f, 0.02978243f, -0.01157062f, 0.10059787f, 0.10574591f, 
    -0.11184113f, -0.05903596f, 0.06115687f, -0.01536723f, -0.10363398f, -0.01567882f, 0.05355586f, 0.07209368f, 
    0.05615287f, -0.04312889f, 0.09966717f, -0.10785703f, -0.02081363f, 0.00032691f, -0.03796292f, -0.04036794f, 
    0.09786201f, -0.03180409f, -0.07621841f, -0.10531007f, 0.03998324f, -0.04344928f, -0.13032013f, 0.00726970f, 
    -0.03639122f, 0.24432532f, 0.35723898f, -0.01413743f, 0.01185307f, 0.10497187f, 0.03726784f, 0.20809488f, 
    -0.02900408f, 0.23146194f, -0.13555856f, -0.39075840f, 0.16945782f, 0.03823943f, -0.26558134f, -0.00147809f, 
    0.22497199f, -0.03523387f, -0.18070939f, -0.11457548f, 0.30354214f, -0.07139648f, -0.00780429f, 0.06108937f, 
    0.26252550f, 0.36599845f, 0.05107414f, -0.16329336f, 0.05326903f, 0.02967505f, -0.04213504f, -0.03698937f, 
    0.23625785f, -0.01737527f, -0.05941201f, 0.13453022f, 0.11606506f, -0.05891776f, -0.13649476f, -0.29402629f, 
    0.14373037f, -0.01015687f, 0.20419444f, 0.03804096f, 0.09287837f, -0.10809442f, 0.31912145f, 0.06433492f, 
    -0.06084438f, -0.17315666f, 0.00052080f, 0.07240301f, 0.08502664f, 0.14261849f, 0.05687429f, -0.11518587f, 
    -0.01336946f, -0.04633729f, 0.06950586f, 0.14980161f, 0.07917912f, -0.03012327f, 0.22529829f, -0.08716802f, 
    -0.39184344f, -0.42047608f, -0.15908672f, 0.00610108f, -0.07152073f, 0.06504354f, -0.12670161f, -0.05458994f, 
    -0.11342872f, 0.03622190f, 0.12910999f, -0.06377728f, 0.10452767f, 0.04563940f, 0.12533505f, -0.22039625f, 
    0.04024033f, 0.18247908f, 0.19206998f, -0.07366152f, -0.16046649f, -0.07343598f, 0.06862678f, -0.04299782f, 
    0.11537635f, -0.06362651f, 0.09965153f, 0.11457450f, -0.05767382f, -0.25529730f, 0.11699477f, -0.11699919f, 
    0.12688430f, -0.09652893f, 0.02712410f, 0.38601351f, 0.07698350f, 0.02195438f, -0.08173614f, 0.11707565f, 
    0.03744950f, 0.08948788f, -0.07771639f, -0.07640194f, -0.03132445f, -0.09700730f, 0.02519648f, -0.08851377f, 
    -0.02880298f, 0.11891271f, -0.04080935f, 0.01703530f, 0.01063539f, -0.01556441f, -0.15408589f, 0.03241517f, 
    0.28266618f, 0.05832165f, 0.07976376f, -0.01339599f, -0.15899310f, -0.02788301f, 0.28921667f, -0.05699094f, 
    -0.14462598f, 0.12260106f, -0.24994247f, 0.09749027f, 0.30740204f, 0.02745236f, 0.00305176f, 0.02807056f, 
    0.03766588f, 0.01036874f, 0.18776762f, 0.41580066f, -0.55200011f, -0.08811884f, 0.30754980f, -0.05331951f, 
    -0.33275327f, -0.21620375f, 0.32559296f, -0.10370798f, 0.06670654f, 0.10603999f, 0.08915732f, 0.02425187f, 
    0.03661618f, -0.26792774f, 0.03310049f, 0.00342412f, -0.08680990f, -0.05620092f, 0.10614700f, -0.22394738f, 
    0.08708569f, 0.00049260f, -0.07204750f, -0.15221535f, 0.11583325f, 0.05148372f, 0.12336384f, 0.39739516f, 
    0.04274398f, -0.10159931f, 0.04958835f, 0.23964585f, -0.03746067f, 0.10188169f, -0.16930626f, 0.10691291f, 
    -0.05065128f, 0.07293383f, -0.12166190f, 0.20276400f, 0.00402147f, 0.13241547f, 0.14374329f, 0.20272130f, 
    0.29262456f, -0.03741837f, -0.02383820f, 0.26639926f, 0.06614372f, 0.26152575f, 0.04735984f, -0.05671188f, 
    0.16432622f, 0.29722318f, -0.05336562f, -0.06268632f, 0.54613918f, 0.04250780f, 0.15086742f, 0.00815871f, 
    0.01854670f, 0.00516660f, -0.09575398f, -0.31680420f, 0.06343064f, 0.22794238f, -0.13929157f, -0.26707345f, 
    -0.11601932f, -0.14249727f, -0.04766033f, -0.02773023f, 0.22422330f, 0.06558232f, 0.09037299f, 0.09991987f, 
    0.15619156f, 0.34178212f, -0.09006536f, 0.16691226f, 0.01060289f, 0.31517693f, -0.21631724f, -0.13139315f, 
    0.04032921f, 0.03321481f, 0.03344882f, -0.17597219f, -0.06733726f, -0.08055355f, -0.27248773f, -0.04977363f, 
    0.08895176f, -0.10811152f, 0.04068233f, 0.23201434f, -0.07766357f, -0.12202713f, 0.12554641f, 0.01860884f, 
    0.09419260f, 0.27928761f, -0.07444923f, 0.14564879f, 0.05281606f, -0.33523738f, 0.22182138f, 0.01361913f, 
    0.20012772f, 0.01104866f, 0.06985108f, 0.02296958f, 0.02569397f, 0.09485563f, 0.05300746f, 0.02510018f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.13599335f, 0.10726828f, -0.01358451f, 0.09403673f, 0.12946491f, 0.04802250f, -0.01082446f, -0.05743063f, 
    -0.05578118f, 0.03349251f, -0.00418779f, 0.02256805f, 0.09814616f, 0.05719823f, 0.01633089f, 0.09036605f, 
    0.03783946f, -0.00568378f, 0.06154480f, 0.02093641f, 0.03132984f, -0.05119418f, -0.05071789f, -0.01137347f, 
    0.07837585f, -0.06680416f, -0.07296405f, -0.09399384f, -0.02500520f, -0.10674598f, 0.07648416f, 0.00757913f, 
    -0.09084261f, -0.16104209f, 0.11434803f, 0.19642280f, -0.02638890f, 0.05247524f, 0.10496636f, 0.04824805f, 
    0.17400356f, -0.00957584f, -0.10629506f, -0.01474064f, -0.01853963f, -0.02097578f, -0.06479120f, 0.17199367f, 
    0.01084498f, -0.12646849f, 0.03212475f, -0.12997106f, 0.10386339f, 0.13204606f, -0.03467391f, 0.14268821f, 
    0.18909886f, -0.13897458f, 0.08249908f, 0.05564893f, 0.22664785f, 0.17765854f, 0.13867024f, 0.01652794f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.16653991f, -0.20587586f, -0.04749039f, 0.19601497f, -0.11259767f, 0.07569893f, 0.05677338f, 0.25946411f, 
    0.15804751f, -0.06083611f, -0.06268793f, 0.22397231f, 0.03615781f, -0.33788514f, 0.13011779f, -0.09708059f, 
    -0.04912373f, -0.50967932f, 0.04061374f, 0.01750198f, -0.43915358f, -0.57379502f, 0.19463155f, 0.03072451f, 
    0.12831146f, -0.11283579f, -0.35657322f, 0.27066556f, -0.00297685f, 0.00896393f, -0.07953538f, -0.31212828f, 
    -0.12166391f, -0.27409333f, 0.10415230f, -0.39206871f, 0.01456458f, 0.05642107f, -0.08571348f, -0.30703622f, 
    -0.29504248f, 0.17927662f, -0.08647658f, -0.49624890f, -0.14579961f, -0.34212157f, -0.62352282f, -0.40361831f, 
    -0.20022921f, -0.00966084f, -0.13617484f, 0.21440598f, 0.10200341f, -0.00415194f, -0.02909181f, 0.09039566f, 
    -0.28925171f, -0.05495794f, 0.04873193f, -0.02989308f, 0.11157761f, -0.00775052f, -0.39063159f, 0.14816086f, 
    -0.03445024f, 0.08261656f, 0.11460842f, -0.24803343f, 0.23316236f, -0.18706517f, -0.00733018f, 0.07697413f, 
    0.35266536f, -0.08566274f, -0.32966319f, 0.22739784f, -0.50251359f, -0.29604962f, 0.03966998f, 0.08046493f, 
    -0.02249160f, 0.14365140f, 0.15982528f, 0.03612556f, 0.33419937f, -0.16451499f, 0.18535638f, 0.20229369f, 
    -0.06374799f, -0.12803791f, -0.12707092f, -0.06592327f, -0.08115005f, 0.02752674f, 0.22483534f, -0.22183843f, 
    -0.08891433f, 0.13933161f, -0.33738628f, -0.15640537f, -0.34568778f, 0.04280172f, -0.40794691f, 0.19778974f, 
    -0.34224913f, 0.12273521f, 0.03281544f, 0.18859398f, -0.02548955f, 0.21153769f, -0.03725467f, 0.24322708f, 
    0.09080004f, 0.01661409f, 0.37602067f, -0.02771379f, -0.45791236f, 0.11137620f, 0.02739049f, 0.18064062f, 
    0.12368825f, -0.09861573f, -0.04053704f, -0.12163664f, 0.00680001f, 0.23565394f, -0.36144549f, -0.07705386f, 
    -0.02286828f, 0.13180736f, 0.14499322f, -0.00214173f, -0.20375966f, -0.13302308f, 0.05345171f, -0.00247081f, 
    0.24068034f, -0.04282540f, -0.08970705f, -0.29196888f, -0.32592034f, 0.30553544f, -0.12221020f, -0.28322408f, 
    -0.30509937f, 0.22511825f, -0.42471412f, 0.02711266f, -0.44630343f, 0.07271317f, -0.05051148f, 0.19579980f, 
    -0.09898259f, -0.11653710f, 0.29655421f, 0.07888265f, -0.40925109f, 0.07887062f, -0.25512987f, 0.18759114f, 
    0.10748649f, -0.09470906f, 0.11795114f, 0.04572044f, -0.50695592f, -0.00904287f, -0.04438536f, -0.15341896f, 
    -0.03832920f, -0.48980767f, 0.00037460f, -0.19829392f, 0.15147868f, -0.52016014f, -0.02627947f, -0.28164887f, 
    -0.45240319f, -0.01688476f, -0.32301131f, -0.06519490f, 0.12856065f, 0.20817429f, 0.25804695f, 0.02055824f, 
    0.22392239f, 0.07623494f, 0.05804170f, 0.09004658f, -0.01018669f, 0.04483500f, -0.28943506f, -0.33050227f, 
    0.26510456f, -0.43892604f, -0.25760102f, 0.12940492f, 0.12468064f, 0.25012198f, -0.10684679f, -0.08719660f, 
    -0.23872523f, -0.04472754f, -0.15862495f, 0.29236141f, 0.05282697f, -0.22549707f, -0.52512473f, -0.09936612f, 
    -0.06696373f, -0.39724407f, 0.18961990f, -0.01092623f, -0.17751016f, 0.08674745f, -0.50823659f, -0.12685591f, 
    0.00404923f, 0.01772664f, -0.11053570f, 0.27155066f, 0.12453765f, -0.03943967f, -0.03691895f, 0.14925574f, 
    0.00348163f, -0.64022726f, 0.03197081f, 0.29379773f, -0.00474921f, -0.35847455f, 0.16088726f, 0.12379315f, 
    0.12773919f, -0.01351493f, 0.07276496f, 0.09837387f, 0.14271283f, -0.08786976f, -0.47736433f, -0.16196208f, 
    0.11228098f, -0.13296428f, -0.37478137f, -0.43212661f, 0.05600045f, 0.23385860f, -0.50167149f, 0.10650326f, 
    -0.15437600f, -0.00452371f, -0.09117006f, -0.05140118f, -0.12190958f, 0.01434712f, 0.16897684f, -0.08605400f, 
    0.07820532f, 0.44550979f, -0.27365416f, -0.11081418f, -0.20296036f, -0.05285801f, 0.03502848f, -0.10831984f, 
    -0.02052908f, 0.07067513f, 0.01843735f, -0.19443366f, 0.11349858f, -0.19619945f, 0.14301230f, 0.02861615f, 
    0.04642325f, -0.33119363f, 0.04889499f, 0.08393589f, 0.22618814f, -0.09353577f, -0.03093037f, 0.19334018f, 
    0.23402603f, -0.09522193f, 0.09960464f, -0.12755015f, -0.14085402f, -0.12612928f, 0.23956387f, 0.06913495f, 
    0.07539831f, 0.10846053f, 0.23654824f, -0.29945117f, 0.05423192f, -0.04619311f, 0.11906982f, -0.20139471f, 
    -0.15017791f, 0.17527981f, 0.05727907f, -0.04092136f, 0.28942871f, -0.04636132f, 0.09845040f, -0.26293856f, 
    0.15087734f, 0.09992590f, -0.30293760f, 0.08297328f, 0.02293065f, 0.11682170f, -0.14883029f, 0.05306179f, 
    -0.53537244f, 0.07594243f, -0.01741409f, -0.01166481f, -0.02740771f, 0.11536193f, 0.15011531f, -0.08116454f, 
    -0.22066341f, -0.55480850f, -0.06002962f, -0.07075043f, 0.22213252f, -0.26583278f, -0.08219244f, 0.08604913f, 
    0.02806996f, -0.02699805f, -0.13239720f, 0.20848325f, 0.21053310f, -0.05517884f, 0.15873371f, 0.18663719f, 
    0.20554800f, 0.29349515f, 0.03376985f, 0.01079828f, -0.53012341f, 0.01312484f, -0.08309781f, -0.17026317f, 
    0.12440385f, -0.08440052f, 0.24320628f, -0.11707723f, -0.35255912f, 0.00821850f, -0.36409238f, 0.05382082f, 
    0.07043748f, 0.02986990f, -0.31665647f, -0.42444500f, 0.14555836f, -0.10325599f, 0.07897230f, 0.18158923f, 
    -0.18931152f, 0.22627659f, 0.07218765f, 0.01223427f, -0.04736980f, -0.34060973f, 0.19546038f, 0.30117589f, 
    -0.38075426f, -0.10477632f, 0.20692281f, 0.11850152f, -0.36472064f, -0.35905573f, -0.17072554f, 0.16221794f, 
    -0.21641310f, 0.08091277f, -0.00352587f, 0.02546198f, -0.08167743f, -0.54933411f, 0.04523959f, 0.17774187f, 
    0.01041670f, -0.14157337f, 0.06489284f, -0.27180558f, 0.25204664f, 0.31555408f, -0.00774285f, 0.06988360f, 
    -0.25632247f, -0.04791211f, -0.22144184f, -0.54003662f, 0.24157831f, 0.13131842f, 0.02628123f, -0.29885304f, 
    0.03029051f, -0.48530883f, -0.41471490f, 0.01140262f, -0.40366110f, 0.04238929f, 0.16024657f, -0.24374734f, 
    0.05809068f, 0.03818995f, -0.18073989f, -0.41066709f, 0.14252679f, -0.06818185f, -0.32647967f, 0.09701730f, 
    0.04707817f, -0.06996927f, -0.37873554f, 0.25118986f, -0.12692766f, 0.04786357f, -0.12469100f, -0.14384563f, 
    0.42249802f, 0.00178932f, -0.02186767f, -0.54271787f, 0.03302306f, -0.51032197f, -0.03929598f, 0.20442045f, 
    -0.13377345f, 0.10373940f, -0.19646007f, 0.08668062f, 0.11373074f, 0.09247756f, 0.20945224f, 0.07714503f, 
    0.03150814f, 0.00655473f, -0.01769834f, -0.11341596f, -0.15987594f, 0.07855523f, 0.31993517f, 0.09520963f, 
    -0.16957620f, 0.24236323f, -0.09922866f, 0.02863606f, -0.10507163f, -0.19500291f, 0.04954427f, 0.14017178f, 
    0.13467750f, 0.00734632f, 0.25052103f, -0.15889589f, 0.17133148f, 0.15613310f, -0.02834426f, -0.45628130f, 
    0.05317660f, 0.26741618f, 0.09791674f, -0.09196123f, 0.05868380f, 0.25935766f, -0.03668515f, -0.31042051f, 
    -0.20356184f, 0.04774945f, -0.05984741f, 0.14529097f, -0.23987795f, -0.12168548f, 0.28233144f, -0.03672548f, 
    0.07810700f, 0.07846940f, 0.11649762f, -0.01066577f, 0.17077802f, -0.40812981f, 0.03135511f, -0.19495678f, 
    -0.16800880f, -0.16694459f, -0.00465984f, 0.13116211f, 0.05541901f, 0.29841605f, 0.06609321f, -0.19039279f, 
    0.09172100f, -0.12175551f, 0.43125907f, 0.10190477f, 0.12195367f, -0.36234781f, 0.04053911f, -0.40645117f, 
    -0.09502456f, 0.05922141f, -0.09024121f, -0.09524731f, -0.49761108f, -0.15306433f, 0.10681164f, -0.10431447f, 
    -0.41781622f, 0.16395123f, 0.22320466f, -0.29051033f, -0.30375975f, -0.12611362f, 0.03192059f, -0.53275663f, 
    -0.03777366f, -0.05466970f, 0.42220950f, -0.15092798f, -0.17163809f, -0.06334566f, -0.10480835f, 0.20087811f, 
    0.25156185f, 0.22463539f, 0.26247054f, -0.01699293f, 0.01844156f, 0.32053766f, -0.02939532f, 0.04688245f, 
    -0.04136228f, -0.00301226f, -0.14411046f, 0.11839718f, 0.03912120f, -0.09621491f, -0.09908144f, 0.01537983f, 
    -0.06739581f, 0.11673258f, -0.20712228f, -0.19779634f, -0.15867922f, 0.19307436f, -0.29062876f, 0.13159864f, 
    0.05016324f, 0.04522304f, 0.01965224f, -0.12394609f, -0.51794118f, -0.05862743f, 0.08678935f, 0.22730264f, 
    -0.10291415f, -0.03285174f, 0.10367094f, -0.00893891f, -0.42310905f, 0.05299811f, 0.01250340f, -0.25863460f, 
    -0.35026088f, -0.04700221f, -0.00081191f, 0.07380100f, 0.13182539f, 0.08941656f, -0.01967650f, -0.49560884f, 
    -0.26625425f, -0.27181342f, -0.16912659f, -0.03445195f, -0.39981240f, 0.05773846f, 0.11414292f, 0.14725968f, 
    -0.12303501f, -0.02283930f, -0.11078434f, -0.01676742f, -0.00909108f, 0.02369476f, -0.04654259f, 0.00782308f, 
    -0.57228839f, 0.22555242f, 0.23168431f, -0.15369979f, -0.29049802f, -0.22912143f, 0.18602432f, 0.05459706f, 
    0.04781672f, -0.02070948f, 0.00799535f, -0.43822613f, -0.43574539f, -0.00982309f, 0.27376434f, 0.25610766f, 
    -0.09043574f, -0.47383785f, 0.06069902f, -0.27595681f, 0.34426060f, 0.21048027f, 0.19625831f, -0.37462309f, 
    0.13532865f, -0.27101851f, 0.02278395f, -0.14860153f, -0.11832936f, -0.20610891f, 0.12067691f, 0.15655540f, 
    0.15779194f, -0.02437730f, 0.11700851f, 0.04680167f, 0.30040041f, -0.06257313f, 0.05254019f, -0.59253246f, 
    0.22063769f, 0.03975270f, -0.06741541f, 0.07597288f, -0.18645023f, -0.16451927f, 0.16302283f, -0.21445511f, 
    0.02176037f, -0.14789490f, 0.09658237f, 0.16478148f, 0.30197901f, -0.25533882f, -0.10497867f, -0.24919803f, 
    -0.16443713f, -0.04309714f, -0.27091664f, -0.23037200f, -0.11387862f, 0.13249034f, -0.64937836f, 0.02736673f, 
    0.11390575f, 0.06991421f, 0.01739213f, 0.13154647f, 0.09796321f, 0.02604512f, -0.22427845f, -0.22347949f, 
    -0.75628716f, 0.11411965f, -0.33216846f, 0.06437781f, -0.10282623f, 0.00394407f, -0.01142896f, 0.14063606f, 
    0.06038925f, -0.34015879f, 0.03795549f, 0.13058880f, 0.11994172f, 0.15229735f, 0.13526170f, 0.02416654f, 
    0.28043181f, -0.18939941f, -0.01350614f, -0.23070469f, -0.04856004f, 0.24858153f, -0.08242828f, -0.00735917f, 
    0.11021480f, 0.07799110f, -0.22925554f, -0.66773039f, -0.27910209f, -0.00896173f, 0.07217181f, 0.09844989f, 
    0.35073161f, -0.08404572f, 0.07440969f, 0.07230563f, 0.19498414f, -0.28502625f, -0.22120658f, 0.07413953f, 
    -0.10353337f, -0.33143443f, 0.03714878f, -0.03771479f, -0.02401521f, 0.37092996f, -0.13997664f, -0.46111768f, 
    -0.53366482f, -0.09340653f, -0.04231073f, 0.14321212f, 0.12570874f, 0.19087680f, -0.04176220f, 0.26237893f, 
    0.13708621f, -0.03107679f, -0.26517466f, 0.04188809f, 0.12794065f, -0.15560748f, -0.43666279f, 0.08042591f, 
    0.12660666f, -0.11372820f, 0.10374284f, -0.19678779f, 0.50889277f, -0.04662742f, -0.49029258f, -0.38766634f, 
    0.04759148f, -0.20630743f, 0.09500828f, 0.04689521f, -0.40881476f, 0.06290305f, -0.02112022f, 0.04695194f, 
    -0.13165560f, 0.13819396f, -0.10385383f, 0.23266405f, -0.18431020f, -0.40110186f, -0.01039602f, -0.33110511f, 
    0.04870839f, -0.04276051f, -0.29075238f, -0.16701108f, 0.18285006f, -0.02017175f, 0.04832849f, 0.21251361f, 
    0.17590657f, -0.04843529f, -0.06161898f, 0.10682163f, 0.26111111f, 0.01247031f, -0.01425501f, 0.28192133f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.05951724f, -0.01379315f, 0.03352508f, 0.03891221f, 0.04604148f, -0.06232697f, 0.13680293f, -0.07307912f, 
    0.05709270f, -0.12238505f, 0.06669629f, 0.00151047f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
