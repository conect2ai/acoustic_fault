#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.20500031f, -0.55519378f, -0.64767182f, 0.11321194f, 0.07692329f, -0.22024633f, -0.05264688f, 0.05902952f, 
    0.02031423f, -0.34093288f, 0.09371834f, -0.28021461f, -0.19769676f, 0.34663457f, -0.40865701f, 0.33563718f, 
    0.34368226f, 0.24175775f, -0.16381070f, -0.11448647f, -0.22216980f, -0.26129237f, -0.22437276f, -0.27680022f, 
    -0.15992092f, 0.17659687f, 0.20947677f, 0.29596588f, -0.98627418f, -1.21726835f, 0.19082572f, 0.12853748f, 
    0.04465294f, 0.31565291f, 0.32121554f, 0.04572396f, -0.01379715f, 0.01651474f, 0.31776306f, 0.11949027f, 
    -0.08791681f, 0.11006957f, -0.09039779f, -0.31932288f, -0.05265723f, 0.08820242f, 0.03288826f, -0.01089258f, 
    -0.06433434f, -0.10213354f, 0.37648684f, 0.35902297f, -0.20307331f, 0.49163935f, -0.15828922f, -0.17800248f, 
    -0.27090123f, 0.07600431f, 0.37109685f, 0.38636097f, -0.06005601f, 0.20431210f, -0.30776063f, -0.10277963f, 
    -0.32423365f, -0.17879653f, 0.30317572f, 0.07082760f, -0.17974636f, -0.06180846f, -0.45472592f, 0.07288355f, 
    -0.26225576f, -0.48505348f, -0.14588070f, 0.39971745f, -0.64426041f, 0.12784746f, -0.04327852f, 0.15505517f, 
    -0.43231529f, -0.09741157f, 0.77753055f, -0.16226667f, -0.18875565f, -0.38991100f, -0.10991196f, 0.41297278f, 
    0.07108227f, 0.09389169f, -0.20264339f, 0.05341218f, -0.27475297f, 0.03175891f, -0.03548509f, 0.31747615f, 
    -0.02065356f, 0.22209291f, 0.00459373f, -0.04139190f, -0.04555035f, -0.05167044f, -0.25410044f, -0.41834104f, 
    -0.39505035f, -0.49495882f, -0.54218113f, -0.40342802f, -0.45135731f, -0.70293492f, 0.26071739f, 0.20767534f, 
    0.37071806f, 0.04000269f, 0.29408371f, -0.18889675f, 0.01573934f, -0.40609875f, -0.26611656f, -0.35584030f, 
    -0.05494425f, -0.08198687f, 0.14804229f, -0.30082071f, 0.01117332f, -0.04321368f, -0.29392090f, -0.16698681f, 
    -0.14290114f, 0.41556796f, 0.11434406f, 0.05643973f, 0.25302237f, 0.45583454f, 0.44393626f, 0.20953162f, 
    -0.18861048f, -0.28836501f, -0.20048939f, 0.17760222f, -0.03775477f, -0.24466680f, 0.00337542f, -0.03407172f, 
    -0.12839301f, 0.23327109f, 0.08696259f, 0.15283965f, -0.14188464f, 0.28919134f, -0.21940973f, -0.47159785f, 
    -0.58003902f, -0.22544837f, -0.40375352f, 0.01275998f, -0.24703732f, -0.25597912f, -0.22203583f, 0.03079683f, 
    -0.33826625f, -0.02818400f, -0.00408078f, 0.00607501f, -0.16726017f, -0.01142820f, -0.31197360f, -0.10222235f, 
    -0.00163144f, -0.52946526f, -0.02034321f, 0.27763569f, 0.21764788f, -0.01791552f, 0.42623544f, -0.37506184f, 
    -0.67163330f, 0.05559257f, 0.22932819f, 0.75458074f, -0.66314983f, -0.51680481f, -0.29510298f, -0.38422543f, 
    0.50811309f, 0.44458729f, -0.09841379f, 0.22467208f, 0.20579028f, -0.20469695f, 0.16943896f, 0.13939069f, 
    0.02612065f, -0.00464752f, -0.24839348f, 0.17445555f, 0.06140218f, -0.02184672f, 0.21147592f, 0.19634102f, 
    0.57490450f, 0.55590510f, 0.19052783f, -0.38440806f, -0.58110267f, -0.10040901f, 0.25709060f, -0.01367964f, 
    -0.31443423f, -0.64552343f, 0.12804948f, 0.54678929f, -0.05467324f, -0.14733182f, 0.02862789f, 0.10302806f, 
    -0.03287682f, -0.00664917f, -0.12621103f, -0.27123114f, -0.12208188f, 0.00661690f, 0.23694749f, 0.19101658f, 
    -0.17144535f, -0.42967212f, -0.20536713f, 0.25945997f, 0.39735743f, -0.16993110f, 0.36681914f, -0.27768439f, 
    0.05228030f, -0.13942821f, 0.32978195f, -0.19669968f, 0.64693844f, -0.18701285f, -0.33863905f, 0.07637779f, 
    -0.48971388f, 0.11047993f, 0.07146077f, -0.18947883f, 0.22949649f, 0.21206659f, 0.30344617f, -0.00603610f, 
    0.08353346f, 0.25902247f, 0.03327200f, 0.00101880f, 0.13368835f, -0.03509666f, 0.31656146f, 0.14127865f, 
    0.07347883f, 0.24973255f, -0.20781167f, -0.43938848f, -0.12485007f, -0.37741202f, 0.24170691f, -0.30499446f, 
    -0.32685214f, 0.07617163f, 0.13204074f, 0.17337531f, 0.17525682f, -0.12184157f, -0.19876580f, -0.31033444f, 
    -0.13935246f, 0.28911331f, 0.33736134f, 0.14098248f, 0.19149953f, 0.35578641f, 0.45622516f, 0.32766652f, 
    0.37714365f, 0.25020280f, -0.02381463f, 0.09675793f, -0.11846108f, 0.17517377f, 0.18484482f, 0.13641900f, 
    0.09084253f, -0.27225390f, -0.22636257f, 0.00267523f, -0.07068550f, -0.19281751f, 0.14964765f, 0.25124797f, 
    -0.18830474f, 0.05269760f, -0.04354615f, -0.15786284f, 0.53403348f, -1.07886446f, -0.27047285f, 0.42009327f, 
    0.60827911f, 0.31145218f, 0.01572218f, -0.39564374f, -0.62896264f, 0.07593579f, 0.16171744f, -0.05775913f, 
    0.10178974f, -0.32427144f, -0.01038569f, -0.14929616f, 0.03154979f, 0.14797874f, 0.11619377f, 0.10107455f, 
    -0.00176109f, -0.32192838f, -0.09161678f, 0.22814193f, -0.18091568f, -0.83065325f, -0.81637585f, 0.25103545f, 
    0.23788117f, 0.40360576f, 0.85913366f, 0.62437361f, -0.26306197f, -0.36552602f, -0.16724882f, -0.11127512f, 
    0.27295578f, -0.41343004f, -0.05761891f, -0.30720136f, 0.17195006f, -0.10182557f, 0.09930728f, 0.13007188f, 
    -0.22272599f, 0.10792305f, -0.08499210f, 0.02693597f, 0.08716501f, -0.21422863f, 0.90399861f, -0.04291116f, 
    0.30173689f, -0.52427477f, -0.10916836f, -0.00242458f, -0.28570396f, -0.10616251f, 0.05837439f, 0.13497102f, 
    -0.25784558f, 0.25962269f, 0.62023526f, -0.59049881f, -0.13199055f, -0.37447184f, 0.09779380f, 0.18530552f, 
    0.17120230f, -0.12928924f, -0.09649017f, 0.30943999f, -0.12503472f, 0.07026090f, -0.05020490f, 0.65177965f, 
    0.34892443f, -0.38644058f, 0.47634003f, 0.08117205f, 0.07558019f, -0.09536530f, -0.37963197f, -0.23092343f, 
    0.01154853f, -0.17084366f, 0.01297723f, 0.18340908f, 0.07061730f, -0.09342513f, -0.14187038f, -0.12670805f, 
    0.27387351f, 0.11706273f, -0.13704056f, 0.04776046f, -0.02088149f, -0.01983933f, -0.11736713f, 0.01182496f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.17093995f, 0.25729164f, 0.02806937f, -0.00201298f, -0.03149118f, 0.04490712f, 0.03345354f, 0.07457196f, 
    0.28386679f, 0.18690991f, -0.00573850f, -0.01200838f, 0.22119793f, 0.20540699f, 0.10350000f, 0.01133329f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.15666868f, -0.15613647f, -0.06493002f, 0.21440183f, -0.15482987f, 0.01997610f, -0.06350712f, -0.04809440f, 
    -0.02411668f, -0.02141967f, 0.24293709f, -0.05862263f, 0.19178048f, 0.21604645f, 0.22410019f, 0.32431665f, 
    0.02029799f, -0.09190314f, 0.02533573f, -0.21882488f, -0.03643254f, -0.06895688f, 0.04450295f, 0.18405679f, 
    0.02466741f, 0.04382828f, -0.05520977f, 0.06556987f, -0.01784928f, -0.10117193f, 0.01258984f, 0.02109540f, 
    -0.00537106f, -0.01608995f, -0.05064913f, -0.02730239f, -0.04591848f, 0.04651964f, -0.08585344f, -0.08181388f, 
    0.00336058f, -0.05082303f, -0.00914149f, 0.01585519f, 0.01289335f, -0.09006417f, -0.05583533f, -0.03030206f, 
    -0.13848539f, -0.17959514f, 0.10275006f, 0.08974732f, -0.09558628f, 0.00694361f, -0.09461685f, -0.05406471f, 
    0.05767903f, -0.00187458f, -0.05184883f, -0.03283211f, 0.01105141f, 0.00892519f, -0.12933022f, 0.00534255f, 
    0.05235738f, -0.02054618f, -0.01002502f, 0.01167192f, -0.04121881f, -0.13712709f, -0.03964661f, 0.10237080f, 
    -0.02376272f, -0.07924017f, 0.03000837f, 0.24455066f, -0.13150656f, -0.21382660f, -0.01183918f, -0.20360123f, 
    -0.00006220f, -0.06425808f, -0.08380842f, -0.12694222f, -0.11471755f, -0.22155447f, -0.21707191f, -0.03220163f, 
    -0.05638770f, -0.05527602f, 0.00023927f, -0.01096719f, -0.02888729f, -0.05114920f, 0.02749785f, -0.11056993f, 
    0.13913763f, -0.01752618f, 0.22804458f, 0.07537032f, 0.07695213f, -0.03638269f, -0.02228735f, -0.16118848f, 
    0.01327072f, 0.16054039f, 0.04051771f, -0.04700304f, -0.05133054f, 0.00490922f, -0.07306086f, 0.05146128f, 
    0.25354245f, 0.04485175f, -0.01708917f, -0.06058798f, 0.07347735f, 0.00636245f, -0.09246199f, -0.06929959f, 
    -0.34666023f, -0.03271168f, 0.12607007f, -0.17336242f, 0.06609109f, -0.03651975f, -0.03274843f, 0.03124360f, 
    -0.14870115f, -0.08206517f, -0.10216645f, -0.13847032f, 0.03973305f, 0.11541095f, 0.05740351f, -0.10645679f, 
    0.01571882f, -0.07657310f, -0.03736092f, 0.01180374f, -0.01075140f, 0.01029614f, -0.10557524f, -0.05097142f, 
    -0.39501274f, 0.18185984f, -0.17433266f, 0.43901783f, 0.05971595f, -0.15221509f, -0.02749804f, -0.10936648f, 
    -0.25144321f, 0.01205611f, -0.02179530f, -0.10284407f, -0.46651331f, 0.17098731f, -0.02698482f, 0.15747069f, 
    0.09349423f, 0.14141253f, 0.06675410f, -0.11717405f, -0.09413879f, 0.03747827f, 0.07668106f, 0.07739192f, 
    -0.16565935f, 0.21110806f, 0.35268050f, -0.16759968f, -0.02184480f, -0.11593147f, 0.09474982f, 0.06426012f, 
    -0.10853671f, 0.05717506f, -0.08353458f, -0.22661941f, -0.07451326f, -0.03961819f, 0.01515664f, 0.12785496f, 
    -0.02769657f, -0.00715566f, 0.02717298f, -0.02736206f, 0.04261436f, -0.08002805f, -0.11992189f, -0.00563246f, 
    -0.04646004f, 0.00766613f, -0.03648634f, -0.02868828f, 0.02644848f, 0.00718274f, 0.00788691f, -0.00080020f, 
    -0.04640114f, -0.04703116f, -0.04561115f, -0.02325203f, -0.06684168f, 0.05840465f, -0.00525269f, -0.07289287f, 
    -0.03797053f, -0.02391138f, 0.05489283f, -0.05498103f, -0.00184904f, 0.03834159f, -0.01002977f, 0.06016736f, 
    0.01877673f, 0.05764358f, -0.01342765f, 0.03656736f, -0.02479799f, -0.00569844f, 0.05831840f, -0.02068565f, 
    0.05754335f, -0.07102099f, 0.05431552f, -0.02914234f, -0.05931124f, -0.06633135f, -0.01467176f, -0.04625329f, 
    0.02385086f, -0.04846280f, 0.03315450f, 0.03992094f, -0.02102496f, 0.04776064f, -0.07396647f, -0.02834441f, 
    0.04320749f, -0.05765401f, -0.04128200f, 0.05209129f, -0.06652709f, -0.05424874f, -0.00270230f, 0.02406451f, 
    0.02149313f, -0.06859905f, 0.03367912f, 0.00554485f, 0.05971763f, 0.04148759f, -0.01844438f, -0.06250160f, 
    0.03577180f, -0.07338791f, -0.02212140f, 0.04529428f, 0.01058333f, -0.03677115f, 0.02018146f, 0.00983660f, 
    0.04910985f, -0.01537333f, -0.07384684f, -0.06410647f, 0.01422362f, -0.01811267f, -0.05887518f, 0.03958647f, 
    0.02163080f, 0.03570824f, -0.03833919f, 0.04426365f, -0.04182009f, -0.02392493f, 0.01496914f, 0.01383146f, 
    0.02146375f, -0.01316219f, -0.07652794f, -0.00929080f, -0.06599083f, -0.05352283f, -0.06467328f, 0.01561225f, 
    -0.06538469f, 0.03486216f, -0.04469645f, -0.01026682f, -0.01695836f, -0.04540191f, 0.04067428f, 0.01139958f, 
    0.01913302f, -0.07435758f, -0.02039303f, -0.00330694f, -0.05938444f, 0.01409416f, 0.04202088f, 0.01578782f, 
    -0.07091819f, 0.01768340f, -0.03503524f, 0.02090985f, -0.05962099f, 0.00965104f, 0.03256634f, -0.00838349f, 
    0.03324635f, -0.01354492f, 0.05711533f, -0.01420304f, 0.05986573f, 0.05786747f, -0.03431528f, -0.06349239f, 
    0.02561923f, 0.02223479f, -0.00508162f, -0.06889085f, -0.01607912f, -0.04769147f, -0.05538397f, 0.05282729f, 
    -0.04346624f, 0.05594741f, 0.01901361f, 0.01592579f, -0.03515994f, 0.03914348f, -0.07058514f, -0.00992397f, 
    0.01840764f, 0.01450196f, 0.01498703f, 0.02650902f, -0.06544077f, -0.01607396f, -0.02396299f, -0.03571420f, 
    -0.04776913f, -0.06213196f, 0.00070911f, 0.03619137f, 0.04529147f, 0.03708193f, -0.05255485f, -0.02303478f, 
    0.01228385f, 0.03107668f, -0.01345383f, -0.02688105f, 0.01771565f, -0.03403902f, -0.04196063f, -0.02372878f, 
    -0.06359399f, 0.06702705f, 0.04182998f, -0.04830572f, -0.02012895f, -0.03768848f, 0.03449457f, -0.00445016f, 
    -0.03601931f, 0.01410379f, 0.00368547f, -0.06715201f, -0.07174724f, -0.01793287f, 0.00665169f, -0.05668590f, 
    -0.03830907f, 0.01181694f, -0.05117332f, -0.04319931f, 0.03758244f, 0.02526141f, -0.00244649f, -0.04830316f, 
    -0.34392646f, 0.08946788f, 0.06101181f, 0.18411697f, -0.05622691f, 0.03398390f, 0.08764164f, 0.01261484f, 
    -0.02461908f, 0.18001796f, 0.04140629f, 0.05251176f, 0.25633773f, 0.38349736f, 0.07161541f, 0.07311566f, 
    -0.12133434f, -0.02184388f, 0.12696455f, -0.09616780f, 0.12616013f, 0.04440539f, -0.08748390f, 0.15622483f, 
    0.07584118f, 0.14687264f, 0.01546567f, 0.05569649f, 0.01813697f, 0.07297672f, -0.04887088f, -0.11471302f, 
    0.05254509f, -0.12428296f, 0.19942890f, 0.08363413f, 0.07345008f, 0.12882659f, 0.02178768f, -0.01534459f, 
    -0.14082041f, 0.10582984f, -0.05676635f, 0.20386457f, -0.02161546f, 0.06978054f, 0.11033874f, 0.00065817f, 
    -0.39291394f, -0.07602496f, 0.03361597f, 0.31674862f, -0.08044292f, -0.08922995f, 0.04755975f, -0.15631025f, 
    0.09727921f, 0.09740861f, -0.09157446f, -0.03348199f, 0.19395390f, -0.12999497f, -0.01102913f, 0.02286673f, 
    0.04329000f, -0.00475733f, -0.00291559f, -0.07182653f, -0.00552004f, -0.18757305f, -0.13009600f, -0.13289674f, 
    -0.31219739f, -0.17470033f, 0.12654513f, 0.15472908f, -0.14244549f, -0.01612982f, 0.08321939f, -0.07317130f, 
    -0.04429312f, -0.05133649f, -0.08928504f, -0.11591616f, -0.21589790f, -0.27850607f, -0.10074266f, 0.25280738f, 
    -0.11111585f, -0.02823893f, -0.02715870f, -0.03598791f, -0.06126147f, 0.01830937f, 0.03797069f, -0.00254887f, 
    -0.12552461f, 0.09524228f, 0.26309830f, 0.02587848f, 0.05404640f, -0.03071205f, 0.17847887f, 0.11276957f, 
    0.13575087f, 0.02285712f, 0.08650582f, 0.08849485f, 0.06731122f, -0.04423723f, 0.07259681f, 0.04995146f, 
    0.15527415f, 0.16310792f, 0.01639480f, 0.11919610f, 0.01791790f, -0.00361106f, 0.06524815f, -0.09531525f, 
    -0.19126426f, -0.02840110f, -0.17188424f, -0.05343833f, 0.07805992f, 0.08080873f, 0.03369342f, -0.10633956f, 
    -0.09119298f, -0.01948370f, 0.01443896f, -0.07595836f, 0.12750827f, 0.20445308f, 0.01383381f, -0.11389458f, 
    -0.00366456f, 0.04742906f, 0.05914561f, 0.00663915f, 0.01273662f, -0.00917668f, -0.06312703f, -0.08929803f, 
    -0.43474692f, -0.04379386f, 0.30139145f, 0.01809215f, 0.19854432f, 0.09568034f, 0.09785163f, 0.13579413f, 
    0.07791610f, 0.17653386f, -0.00853146f, -0.10285410f, 0.13415003f, -0.11197776f, 0.18474911f, 0.18756425f, 
    0.18368168f, 0.03096655f, 0.14324072f, 0.10732320f, 0.04020705f, 0.10298816f, 0.16155635f, -0.12538144f, 
    -0.22366670f, 0.06953308f, 0.26062840f, 0.02357162f, -0.02017578f, -0.04265545f, 0.17710795f, 0.29916635f, 
    0.05324072f, -0.03471802f, 0.12707756f, -0.04522876f, 0.02935506f, 0.06105897f, -0.02352790f, -0.09001403f, 
    -0.01271299f, 0.05439894f, -0.01309806f, 0.02900556f, 0.09733758f, 0.05239122f, -0.00218041f, 0.03884194f, 
    -0.19699068f, -0.03233652f, 0.09017430f, 0.12472856f, 0.05042558f, 0.06639402f, -0.08004188f, 0.09951229f, 
    0.13310856f, 0.10795895f, 0.21656096f, 0.09853191f, -0.34784049f, 0.25611356f, 0.08595828f, -0.00642798f, 
    -0.00510853f, 0.02654662f, 0.12631588f, -0.17924476f, 0.02879218f, 0.04293802f, -0.07086813f, 0.00612864f, 
    0.20841581f, -0.28992006f, 0.04102100f, 0.05435634f, -0.01586417f, -0.06123372f, 0.13347514f, 0.09889901f, 
    0.22716868f, 0.16911392f, 0.35590738f, -0.08682214f, 0.30754587f, -0.11974351f, 0.32960784f, -0.20511401f, 
    0.08110648f, -0.09317606f, -0.04926879f, 0.21740787f, -0.10828902f, -0.05919889f, -0.02656732f, -0.12107673f, 
    -0.11931351f, 0.05032730f, 0.20315453f, 0.36940929f, 0.04318171f, -0.00304834f, 0.11615156f, -0.03888297f, 
    0.07292192f, 0.04212722f, -0.00162890f, 0.01112740f, -0.01632046f, -0.15697360f, -0.01141759f, -0.21504033f, 
    -0.13734908f, -0.05236733f, -0.23708944f, -0.05986298f, 0.08306149f, -0.06714758f, 0.10106118f, -0.00924683f, 
    -0.14146115f, -0.04377811f, 0.14647187f, 0.17071234f, -0.09922450f, -0.11151146f, -0.08301374f, -0.07566775f, 
    0.12004481f, -0.00608449f, 0.03282728f, -0.05737134f, 0.03327492f, -0.23891020f, 0.03258611f, 0.37480515f, 
    0.15386994f, 0.03872010f, -0.07726077f, -0.02670409f, 0.02529413f, 0.06640840f, -0.17480111f, -0.10425807f, 
    -0.01453037f, 0.45253623f, 0.08956964f, 0.25041530f, 0.01242314f, 0.04986940f, -0.01717152f, -0.07879612f, 
    0.01173470f, 0.05094979f, 0.16705556f, -0.07838103f, -0.07322259f, 0.07351332f, -0.21507157f, -0.16562131f, 
    -0.08566546f, -0.01283553f, -0.01840758f, -0.23035686f, -0.12223336f, -0.10587044f, -0.09834705f, -0.35312641f, 
    0.01116945f, 0.05571200f, 0.15290546f, 0.04385186f, -0.00647277f, -0.03013084f, -0.19320647f, 0.08670909f, 
    -0.14125396f, 0.17738636f, 0.01816713f, -0.18883337f, -0.00412131f, 0.12884076f, -0.01249989f, -0.15095557f, 
    -0.02689093f, -0.04655546f, -0.11459637f, 0.01127946f, 0.01424886f, -0.02758333f, 0.09081674f, -0.01383170f, 
    -0.42883652f, 0.11173333f, 0.26020515f, -0.03714048f, -0.03094465f, 0.00240186f, 0.05831320f, 0.15461446f, 
    -0.07226858f, 0.14417598f, -0.10547343f, 0.02812711f, -0.63733482f, 0.09643116f, 0.06645681f, 0.10476390f, 
    0.08986484f, 0.14634502f, -0.02207023f, -0.22579886f, 0.06844580f, -0.04722656f, 0.05421172f, 0.07479940f, 
    -0.07035372f, 0.08001003f, 0.47597316f, -0.17196743f, -0.11877735f, -0.08730190f, 0.16612948f, -0.01330657f, 
    0.01302712f, 0.06663733f, -0.03814637f, -0.03589913f, 0.42960900f, -0.04698943f, 0.09693327f, 0.10813251f, 
    -0.06172819f, -0.23582272f, 0.14375968f, 0.11401363f, -0.20771389f, 0.09522549f, -0.13935569f, -0.00673280f, 
    -0.06354547f, 0.01002381f, -0.10414524f, -0.03149729f, 0.02307163f, 0.01748594f, -0.16737193f, 0.20466405f, 
    -0.05402783f, -0.06311470f, 0.01430252f, -0.01474445f, -0.14108342f, -0.01694497f, -0.02815902f, 0.00952857f, 
    0.12259527f, 0.03774808f, 0.16860814f, -0.00746876f, -0.11382266f, 0.05916831f, 0.06632738f, -0.07365737f, 
    0.14715943f, -0.10428703f, -0.18059959f, 0.07819207f, -0.01498189f, 0.01563005f, 0.17588404f, 0.04187474f, 
    0.03581730f, 0.11344617f, 0.08921070f, -0.15869783f, -0.00254194f, -0.20190480f, 0.21992949f, -0.06231222f, 
    0.23079455f, -0.17937244f, -0.12863220f, 0.01122916f, 0.07274657f, 0.09029869f, -0.06347977f, 0.05447786f, 
    0.02590307f, -0.01107516f, -0.01224777f, -0.02439941f, 0.01816795f, -0.02831426f, 0.09149103f, -0.07959748f, 
    0.03763352f, 0.14074513f, 0.00665234f, -0.07676658f, 0.04058465f, -0.03127358f, 0.03790351f, 0.00118944f, 
    -0.00420484f, -0.14028949f, 0.01217524f, -0.01820409f, 0.10146279f, -0.11605623f, 0.04372808f, 0.09115846f, 
    -0.02316488f, -0.07689562f, -0.07797885f, -0.25661317f, -0.00790930f, -0.16716300f, -0.07023863f, -0.00035095f, 
    0.07795632f, 0.05395918f, 0.04712895f, 0.10949444f, 0.39365619f, 0.00344319f, 0.20482880f, -0.06285883f, 
    0.11164278f, 0.15072049f, 0.03397331f, 0.00659604f, 0.12062925f, 0.01055240f, 0.07516254f, -0.01250677f, 
    -0.03492272f, 0.36917767f, -0.13925968f, 0.18648171f, 0.09331597f, 0.07063074f, -0.11318697f, 0.14987610f, 
    0.01105334f, -0.01656578f, 0.09095611f, -0.18712877f, -0.06119554f, -0.10759189f, -0.01891778f, 0.02386933f, 
    -0.20878489f, -0.09412857f, 0.12440710f, -0.21335855f, -0.03885348f, -0.07870660f, 0.00401493f, -0.05868069f, 
    0.15056904f, 0.04866066f, -0.00491178f, -0.03903494f, 0.00611527f, -0.03307803f, -0.03431450f, 0.07866945f, 
    -0.12441456f, 0.03156365f, 0.07876085f, 0.00175395f, -0.02005848f, -0.09227245f, -0.03822805f, -0.05148995f, 
    0.05782421f, 0.02208906f, -0.05998517f, 0.04436016f, -0.07542522f, 0.00231697f, 0.14013425f, -0.07566337f, 
    -0.02213193f, -0.05032409f, 0.22030349f, -0.01458398f, 0.02260938f, 0.10375813f, 0.12598202f, 0.10262650f, 
    0.01185473f, 0.00084273f, -0.01221352f, -0.01949621f, -0.41835985f, 0.28111419f, -0.14239213f, -0.05291484f, 
    0.11156417f, 0.08776105f, -0.04982181f, -0.01016934f, 0.07196814f, 0.11951786f, -0.01068578f, 0.11182687f, 
    -0.19096684f, -0.06435385f, 0.01562593f, 0.11689571f, -0.16649403f, 0.16656277f, 0.13907523f, -0.08781277f, 
    0.09340122f, 0.01110280f, 0.00158139f, -0.11473885f, 0.12527083f, -0.18044186f, -0.05517583f, 0.01775190f, 
    -0.04623242f, 0.13161799f, 0.24831688f, 0.12320664f, 0.06456047f, 0.09311581f, -0.08017142f, -0.00361817f, 
    -0.04588971f, -0.09618004f, -0.05608908f, 0.03958520f, 0.14953946f, 0.04039106f, -0.00201914f, -0.02172265f, 
    -0.19276239f, -0.13292603f, -0.21930391f, -0.00471163f, -0.22711180f, -0.07147031f, -0.06350365f, 0.08885372f, 
    -0.04993962f, 0.06001163f, -0.04648961f, 0.19078130f, 0.02769893f, 0.03103083f, 0.14774649f, -0.08187877f, 
    -0.17031023f, 0.11963554f, 0.17547730f, -0.19843116f, -0.06809156f, -0.03341067f, -0.10498328f, -0.10707562f, 
    0.08288381f, 0.03928832f, -0.08307033f, 0.21714397f, 0.00288936f, 0.10824932f, -0.27242315f, 0.05747426f, 
    0.07683263f, 0.08053685f, 0.19152379f, -0.19646512f, -0.14321312f, -0.00262459f, -0.00557557f, -0.10496490f, 
    -0.09674636f, -0.15359183f, 0.02639513f, 0.26846901f, 0.09086808f, 0.19800542f, 0.03882825f, 0.19205095f, 
    -0.01398558f, -0.06839296f, 0.01719035f, -0.00648259f, 0.15128744f, 0.00739820f, 0.01931937f, -0.23529877f, 
    0.05210434f, 0.03272201f, -0.08558433f, -0.04469140f, 0.06113428f, 0.06171868f, -0.15160751f, 0.05107896f, 
    0.06389166f, -0.11674701f, 0.09553534f, 0.28774604f, 0.03542531f, 0.20274991f, 0.19981924f, 0.11474884f, 
    -0.02687782f, -0.05325538f, 0.05809585f, 0.06312034f, -0.06975561f, -0.08642878f, -0.24054898f, 0.00806860f, 
    0.03011116f, -0.20900869f, -0.14287870f, -0.05861624f, -0.17569546f, -0.00419491f, 0.02122670f, 0.09353733f, 
    -0.29238933f, -0.05203094f, 0.15251985f, 0.12818110f, -0.01079025f, -0.15557849f, 0.14752801f, -0.00059549f, 
    0.05240879f, -0.08346175f, -0.12371656f, -0.00805058f, 0.20627175f, -0.00742852f, 0.03853890f, -0.11264326f, 
    0.13072838f, 0.07311885f, -0.05947245f, 0.11471040f, -0.13272917f, 0.05604891f, -0.00953680f, 0.03935426f, 
    0.04987488f, 0.20102274f, -0.06906680f, 0.21857534f, -0.06045607f, -0.09564744f, -0.00816328f, -0.11411853f, 
    0.14147729f, -0.08228000f, 0.01237668f, -0.12315769f, 0.00904926f, 0.20052473f, 0.03114226f, -0.03654730f, 
    -0.13772990f, -0.19355974f, -0.10842335f, -0.11863336f, 0.11932536f, 0.03936242f, -0.08126798f, 0.06521002f, 
    0.18163404f, 0.21333332f, 0.07114743f, 0.09511546f, -0.06667710f, 0.11402787f, 0.14540833f, -0.15985113f, 
    0.05656405f, 0.00610218f, -0.03796241f, -0.05617671f, 0.54705447f, 0.15400892f, 0.00035926f, -0.15842617f, 
    -0.06213390f, -0.01634955f, 0.06430136f, 0.18847162f, -0.00549864f, 0.11848713f, -0.04910485f, -0.02162983f, 
    -0.10001544f, 0.26721635f, -0.03234988f, 0.08232112f, 0.15776150f, -0.15254481f, -0.13536596f, -0.06822799f, 
    -0.03453999f, -0.02235962f, -0.09345222f, 0.00507550f, -0.16136645f, 0.18286489f, 0.16052437f, 0.00183247f, 
    -0.10053988f, -0.02976146f, -0.15216494f, -0.13737799f, 0.06904440f, 0.01360173f, 0.08975829f, 0.00830837f, 
    -0.08088616f, 0.15040585f, -0.08009471f, 0.31044793f, 0.07794535f, -0.05361550f, -0.00973814f, 0.04718454f, 
    -0.04068110f, -0.00681787f, -0.11016299f, -0.04845157f, -0.03563096f, 0.17020914f, 0.18603699f, 0.13953298f, 
    0.03206422f, 0.05282250f, 0.17147219f, 0.11038981f, 0.11977975f, 0.19265349f, -0.05346802f, -0.00931658f, 
    -0.44350883f, 0.18204029f, 0.10724341f, -0.30171585f, -0.16414453f, -0.02095285f, -0.10355914f, -0.15163809f, 
    -0.02530003f, 0.27057645f, -0.13995904f, -0.00650422f, -0.16291505f, 0.24818900f, -0.21153195f, 0.16346641f, 
    0.18237899f, 0.04865697f, -0.07945494f, -0.03744678f, 0.02221501f, -0.16976427f, 0.01670111f, 0.04582080f, 
    -0.07383557f, -0.24703850f, -0.06000094f, -0.05043614f, 0.05427505f, 0.06504047f, 0.04269470f, 0.18547463f, 
    -0.03284032f, 0.01580493f, 0.00266333f, 0.07516736f, -0.14307961f, 0.19267038f, 0.02291216f, 0.18541482f, 
    -0.05432776f, 0.02625286f, 0.01941649f, -0.11103225f, 0.03828289f, 0.04402103f, 0.20833409f, 0.18502775f, 
    0.07214610f, -0.12111693f, -0.04547849f, 0.23295413f, -0.09853990f, -0.00385448f, -0.05385900f, 0.04949855f, 
    -0.12229186f, 0.15535937f, 0.12051205f, -0.01572232f, 0.05192491f, 0.04321655f, -0.46209648f, 0.10310242f, 
    -0.02907274f, 0.07997505f, 0.02561453f, -0.01189692f, 0.07033219f, -0.07362407f, 0.16557325f, -0.00344082f, 
    -0.07282559f, -0.12040459f, 0.24297862f, 0.04332034f, -0.07225622f, 0.01169639f, -0.00980369f, 0.12582536f, 
    -0.19858816f, 0.18937731f, 0.04076490f, 0.10335826f, -0.11563239f, 0.13783145f, 0.03794780f, -0.05464819f, 
    0.05181582f, 0.12050270f, -0.03396406f, 0.01348921f, -0.09743180f, 0.12302566f, -0.04257753f, 0.04125857f, 
    0.02738503f, 0.21388446f, 0.15768071f, 0.22113898f, -0.20811756f, -0.04971518f, -0.01879331f, -0.22610846f, 
    0.05487061f, -0.03011777f, 0.02011266f, -0.02543895f, 0.04826500f, 0.03270011f, 0.03832043f, -0.28393984f, 
    -0.21969566f, 0.04834478f, 0.09660675f, -0.00583138f, -0.01958607f, 0.11227783f, 0.03912424f, 0.16169764f, 
    -0.20999219f, 0.41369620f, -0.42994386f, 0.36141941f, -0.10190892f, 0.08540539f, 0.01516013f, -0.02354549f, 
    -0.08489613f, -0.14628509f, 0.03570490f, -0.01260727f, -0.24468848f, 0.52694333f, -0.28193074f, 0.02285860f, 
    -0.01568047f, 0.24362825f, 0.08035650f, 0.03424790f, -0.03574851f, -0.02034279f, 0.05194525f, 0.08830935f, 
    -0.22688761f, 0.11868441f, 0.27859083f, 0.22389215f, 0.02804102f, -0.14270540f, -0.16175281f, 0.04657112f, 
    -0.11938816f, 0.07273243f, -0.16140994f, 0.09335741f, -0.17099391f, 0.14791469f, -0.04286068f, 0.02258860f, 
    -0.01478757f, 0.11977614f, -0.13897249f, 0.07826339f, 0.11108237f, 0.03219010f, 0.05524214f, 0.13990378f, 
    -0.09153082f, 0.02886452f, 0.16453512f, -0.07700368f, -0.03660933f, -0.05370773f, -0.07951190f, -0.08452392f, 
    -0.00665445f, -0.00798064f, 0.11096193f, 0.12744309f, -0.08266544f, 0.02350724f, -0.24170752f, -0.15060966f, 
    -0.09871719f, 0.05104231f, 0.00700140f, -0.02568023f, -0.02633106f, 0.01036410f, -0.13606682f, -0.07579920f, 
    0.16381654f, -0.27668160f, -0.11000826f, 0.15020730f, 0.07855413f, -0.01025121f, 0.05636544f, -0.02329989f, 
    -0.04818741f, -0.17107826f, 0.06993616f, 0.13024010f, 0.13283646f, -0.15092964f, -0.03236061f, 0.03846637f, 
    -0.24644983f, -0.01055335f, 0.12633079f, -0.11467826f, -0.12469953f, -0.07060464f, -0.12753060f, -0.12542564f, 
    0.05070914f, 0.27520147f, 0.11831836f, 0.10728992f, 0.01891102f, -0.05334324f, 0.03476100f, -0.03533288f, 
    0.01675070f, 0.07501163f, -0.11808460f, -0.18917845f, 0.05768697f, -0.07777211f, 0.12716530f, 0.04357930f, 
    0.00102846f, 0.02027167f, -0.09669981f, 0.05874503f, -0.03894611f, 0.02941509f, -0.11693110f, 0.01940145f, 
    0.05855995f, 0.13921343f, 0.20276007f, -0.02185039f, 0.09403036f, 0.14070225f, 0.09218760f, -0.01361929f, 
    0.09483938f, -0.12724140f, 0.01542435f, -0.01353676f, -0.08216803f, -0.10450465f, 0.16081774f, 0.08613981f, 
    0.04779964f, 0.07999023f, 0.03664340f, 0.14773150f, -0.07384635f, -0.06286047f, -0.04054028f, -0.02369070f, 
    0.03875497f, 0.10633368f, -0.31368256f, -0.14892167f, 0.05905132f, -0.02308309f, -0.07513592f, -0.15377870f, 
    0.07131562f, -0.14531486f, -0.03956830f, -0.11598138f, 0.03666620f, 0.05747296f, -0.05697655f, -0.04088066f, 
    0.11249845f, -0.02572902f, 0.00925859f, -0.05628636f, -0.03745322f, -0.00588801f, 0.03449016f, -0.13443480f, 
    0.11142657f, -0.17983003f, 0.00575137f, 0.02216351f, 0.13039449f, -0.09714081f, -0.06520543f, 0.05148106f, 
    0.00888664f, 0.01768188f, -0.05189053f, -0.13354829f, 0.04812947f, -0.04158954f, -0.11560530f, 0.06164560f, 
    0.02318686f, -0.08671524f, -0.00740664f, 0.05677778f, -0.04347500f, -0.00126400f, 0.10730354f, 0.05947275f, 
    0.27913484f, -0.20486553f, 0.25048384f, -0.30918249f, -0.02722337f, -0.00965685f, 0.04675842f, 0.10156167f, 
    -0.06297216f, 0.08146635f, 0.02197832f, -0.03489916f, 0.16250299f, -0.36479673f, 0.21031643f, 0.03090226f, 
    -0.06498279f, -0.13605919f, -0.01300576f, 0.02329749f, 0.24866283f, -0.06478666f, -0.05295158f, 0.07578320f, 
    0.19113633f, 0.02527524f, 0.00017917f, -0.16181351f, -0.00090120f, 0.10219587f, -0.00261942f, -0.08712388f, 
    0.02699831f, -0.02441497f, -0.01147849f, -0.18944107f, 0.04138779f, -0.03451512f, 0.06242590f, 0.02260604f, 
    -0.03371146f, -0.03283047f, -0.08831909f, 0.01314164f, 0.00966603f, -0.09202666f, 0.02352944f, -0.04641148f, 
    0.30289841f, 0.11270725f, 0.14027251f, 0.08104765f, 0.14596309f, -0.08067119f, -0.04280252f, 0.11148125f, 
    -0.21006481f, 0.01999282f, 0.02577464f, 0.02585912f, -0.04793202f, -0.26809239f, 0.22607574f, 0.20654783f, 
    -0.07884111f, 0.04659033f, -0.03766062f, 0.07606111f, 0.09820769f, -0.00593136f, -0.05107347f, 0.02846837f, 
    -0.23696582f, 0.03717100f, 0.07182127f, 0.16598904f, -0.09909619f, -0.05370791f, -0.32221186f, -0.04739673f, 
    -0.12177487f, -0.03256559f, -0.19907558f, 0.01175137f, 0.16412757f, -0.04959550f, -0.03650365f, 0.03374321f, 
    -0.09671664f, 0.00755276f, 0.00268817f, 0.00049594f, 0.05799531f, 0.04101113f, 0.00316720f, -0.07534675f, 
    0.10865919f, -0.00289401f, -0.11769468f, -0.13100989f, 0.03277431f, 0.19519489f, -0.06681622f, -0.00444790f, 
    -0.20169461f, -0.02182035f, -0.06199559f, -0.07242209f, -0.21956024f, -0.10075255f, -0.20080034f, 0.11565275f, 
    -0.16303182f, 0.10400436f, -0.10934748f, -0.14408439f, -0.05800781f, -0.09468510f, 0.01789043f, 0.15304288f, 
    0.07302029f, 0.09981243f, 0.04151507f, 0.07625289f, 0.19206533f, 0.09120179f, -0.01506819f, 0.07399561f, 
    -0.04906172f, -0.17164393f, -0.03306740f, -0.05749270f, 0.15608020f, 0.53230911f, -0.02940991f, -0.08636116f, 
    -0.00772369f, 0.18934040f, 0.02878853f, 0.05424661f, -0.06331779f, -0.12495764f, 0.17466764f, -0.08319056f, 
    -0.02672081f, -0.15138958f, -0.00587161f, 0.09799978f, -0.04776635f, 0.04768761f, -0.11696952f, 0.01418374f, 
    -0.16969100f, 0.11409388f, 0.02412980f, -0.05273264f, -0.09956501f, 0.02574850f, -0.10780495f, -0.07563171f, 
    -0.01173456f, -0.12459226f, 0.03143416f, 0.19048594f, -0.13396056f, 0.09180848f, -0.09805367f, -0.20742498f, 
    0.00734346f, 0.04454121f, 0.03863947f, 0.04697924f, -0.21431053f, -0.08723237f, -0.01615771f, -0.08947101f, 
    0.00955479f, -0.13097443f, -0.01167406f, -0.14476298f, 0.01808285f, 0.16719666f, -0.02859372f, -0.04411984f, 
    -0.17323615f, -0.17348182f, 0.00022746f, -0.09025226f, -0.21270537f, -0.02602811f, -0.01291107f, -0.01444053f, 
    -0.06070203f, 0.62525797f, -0.39611006f, 0.11662723f, -0.03244109f, -0.01401820f, -0.02968157f, -0.08343977f, 
    -0.04685028f, -0.03391145f, -0.01150151f, -0.08981634f, -0.09199747f, 0.27118093f, -0.24571042f, 0.03247040f, 
    0.02943620f, -0.09842044f, 0.16089463f, -0.13621268f, -0.08096191f, -0.11461277f, 0.03015228f, 0.08324122f, 
    -0.20767614f, -0.05123528f, 0.41555580f, 0.15043324f, -0.14991866f, -0.08083234f, -0.26371318f, -0.13894896f, 
    0.06134846f, 0.09652494f, 0.09456078f, -0.10094599f, -0.03840433f, 0.31323466f, -0.05112288f, 0.03029198f, 
    -0.00270981f, -0.01697247f, -0.12593316f, -0.05299868f, 0.05938946f, -0.03264004f, 0.03013447f, -0.26589334f, 
    0.10832302f, -0.05093307f, 0.22919762f, -0.30643445f, 0.01826233f, -0.07897600f, 0.08929998f, -0.13048668f, 
    -0.16006908f, -0.03704505f, -0.08882137f, 0.11322807f, 0.02553353f, -0.59329724f, -0.25221786f, 0.06920124f, 
    -0.00378802f, 0.00932358f, -0.26182556f, 0.18821274f, 0.13362353f, 0.03471885f, -0.01438316f, -0.06487166f, 
    0.07091879f, -0.01927576f, 0.17152168f, 0.02318955f, 0.04973586f, 0.07851396f, -0.06629948f, 0.07858817f, 
    0.11383665f, -0.11624714f, -0.11863615f, 0.12194880f, 0.15651496f, 0.03798423f, 0.05676128f, 0.00704058f, 
    -0.10458799f, -0.09666713f, 0.03373707f, -0.19999233f, -0.10209358f, 0.03914571f, -0.00525191f, -0.08437999f, 
    0.24353975f, 0.16581027f, 0.07046298f, 0.18668257f, 0.05212342f, 0.03430722f, -0.05539658f, -0.07776691f, 
    -0.16563436f, -0.08741439f, 0.00740439f, -0.00295369f, 0.07243969f, 0.05595077f, 0.05109324f, -0.14199764f, 
    0.00620131f, 0.03217450f, -0.05519771f, -0.02884935f, -0.07859591f, -0.03109803f, -0.14151642f, -0.09312417f, 
    0.02624230f, 0.10624231f, 0.05303604f, -0.07278010f, 0.22613330f, 0.22224756f, 0.11288621f, 0.04328293f, 
    0.04936872f, 0.00644759f, 0.00886070f, 0.05730043f, -0.00597460f, 0.28101832f, 0.19413091f, -0.25020334f, 
    0.07511718f, 0.10690457f, -0.01765041f, 0.14260444f, 0.05775004f, -0.08414035f, 0.04471089f, -0.01439306f, 
    0.18373679f, 0.17373048f, -0.20721643f, -0.04694539f, 0.19187780f, -0.11493918f, 0.05073804f, -0.05358327f, 
    -0.00787032f, -0.15793125f, -0.02367359f, 0.03315785f, 0.12082890f, 0.01121655f, 0.05933207f, 0.02733834f, 
    -0.01541022f, -0.00859414f, 0.03744346f, 0.04136815f, -0.05701496f, -0.05987266f, -0.09227294f, -0.09628130f, 
    0.43819651f, 0.14519431f, 0.02563902f, 0.04115610f, -0.01612675f, 0.02934973f, -0.04342578f, 0.06347390f, 
    0.04370531f, 0.03034599f, 0.06423853f, 0.04544950f, 0.04798016f, 0.08234949f, 0.07396587f, 0.17431580f, 
    0.04518290f, -0.01128566f, -0.00073469f, -0.07748536f, 0.04527987f, 0.04013363f, 0.04309979f, -0.04349816f, 
    0.29939198f, 0.34481463f, 0.38132784f, -0.25239670f, -0.17050387f, -0.10243593f, 0.07998219f, -0.01344218f, 
    -0.07336514f, 0.15383103f, -0.06189884f, -0.04154016f, 0.36604142f, -0.11123944f, 0.04890208f, -0.31066370f, 
    -0.06947848f, -0.13177098f, 0.11125104f, 0.14814343f, -0.08275306f, -0.09659466f, -0.08570599f, 0.00324173f, 
    0.36856374f, -0.02697132f, -0.27724984f, 0.07658553f, -0.05992096f, 0.09629736f, -0.14438486f, 0.00389254f, 
    -0.00585605f, 0.07449072f, 0.06582806f, 0.04505210f, 0.14984123f, 0.06002498f, 0.07294998f, 0.13638803f, 
    -0.10522860f, -0.01190459f, -0.05928206f, -0.07521553f, 0.01423497f, 0.07932417f, -0.04990494f, 0.07430684f, 
    -0.35630587f, 0.14096098f, 0.02386259f, -0.04587005f, -0.03348578f, 0.08301590f, 0.03520109f, -0.10096944f, 
    -0.00945339f, -0.07816427f, 0.00590424f, -0.18070319f, 0.17191194f, -0.02115772f, 0.00017169f, -0.23934816f, 
    0.17107116f, -0.08415572f, 0.15267211f, 0.05834667f, -0.04515195f, 0.11654247f, -0.04156096f, -0.08437616f, 
    0.07847545f, 0.22113447f, -0.11817440f, 0.01026787f, -0.03854880f, -0.13992409f, 0.07353564f, -0.06816477f, 
    0.02029464f, -0.08433961f, -0.03655600f, -0.08358782f, 0.09276872f, -0.04602528f, 0.19404376f, -0.01332609f, 
    0.05160052f, 0.03495101f, -0.13796762f, 0.19098523f, -0.06806230f, -0.01025821f, 0.09042160f, 0.09868114f, 
    -0.18872248f, -0.10199044f, 0.07819200f, -0.02625208f, 0.07682480f, -0.07943161f, 0.00679110f, -0.23793021f, 
    -0.15654756f, -0.04029633f, -0.06887767f, 0.03450093f, -0.34559467f, -0.06013757f, -0.04780710f, 0.21124890f, 
    -0.16180436f, -0.18117060f, -0.18923746f, -0.03922937f, 0.08324465f, -0.01177971f, 0.24548805f, 0.02272419f, 
    -0.08933575f, 0.06357838f, 0.11392469f, -0.06434642f, 0.06382601f, 0.04907607f, 0.07382017f, 0.03381061f, 
    0.08480233f, 0.04840844f, -0.03048243f, 0.03714900f, -0.12195666f, -0.16526888f, 0.04939359f, 0.06096974f, 
    0.08699477f, -0.01903355f, -0.00095363f, 0.08013716f, 0.02724547f, -0.03242129f, 0.03580786f, 0.03107613f, 
    0.30338761f, 0.04180035f, 0.05280173f, -0.28711832f, 0.02142421f, 0.18190926f, -0.00812998f, -0.02305903f, 
    -0.08864482f, -0.01719299f, 0.14900248f, 0.02989853f, -0.25283509f, -0.04561021f, -0.05651771f, 0.29521742f, 
    -0.06049987f, 0.03258703f, -0.05430862f, -0.06513032f, 0.12265640f, -0.02097943f, 0.22239482f, 0.07677657f, 
    0.00420492f, -0.04332659f, 0.20605987f, 0.04103931f, -0.11498328f, -0.03321721f, -0.17729141f, -0.27635843f, 
    0.00146624f, -0.03108411f, 0.00334367f, 0.18433943f, 0.04498493f, -0.00776213f, -0.10487519f, -0.13695583f, 
    -0.01982056f, -0.04553572f, -0.14312349f, -0.16020308f, -0.03277539f, 0.10080352f, 0.01786766f, -0.14928117f, 
    -0.12953490f, 0.17234093f, 0.03386351f, 0.13198854f, 0.11967065f, 0.13296625f, 0.02910350f, 0.24697579f, 
    0.03192815f, 0.01511745f, -0.06490004f, -0.02130431f, -0.29581031f, -0.13607042f, 0.09793559f, 0.13114756f, 
    -0.05459015f, -0.11760303f, 0.07865043f, -0.10136226f, 0.09222765f, 0.09921400f, -0.00580840f, 0.00973759f, 
    0.50324821f, 0.07131134f, 0.17845565f, 0.29452115f, -0.03235218f, 0.18433629f, -0.08189820f, 0.29758450f, 
    -0.03471242f, 0.05326115f, 0.15277787f, -0.03826746f, 0.14998384f, -0.09215904f, -0.18603906f, -0.11607111f, 
    -0.08407457f, 0.18139085f, 0.06645267f, -0.05100589f, -0.07801500f, -0.02050288f, -0.04953925f, -0.07560468f, 
    -0.05065626f, 0.03089827f, -0.01720350f, 0.06418692f, -0.08044039f, -0.06276024f, 0.00947614f, -0.05381329f, 
    0.01957511f, 0.00430301f, 0.05304816f, -0.04409016f, 0.03263152f, 0.00840627f, -0.06065613f, 0.04225634f, 
    -0.04379104f, -0.00882505f, 0.06744302f, 0.00621895f, -0.07877491f, -0.04747818f, 0.01027701f, -0.05953401f, 
    -0.03172199f, -0.00017018f, -0.06983141f, -0.07381309f, -0.05288580f, 0.04655721f, -0.02308023f, -0.03459373f, 
    0.01616338f, -0.05684346f, -0.00052831f, -0.07324684f, 0.06183640f, -0.07499758f, -0.05129669f, -0.04406826f, 
    0.06190083f, 0.06711399f, 0.01511407f, 0.00918459f, 0.02045971f, 0.02189563f, -0.05124291f, 0.03648778f, 
    -0.02336507f, -0.03313068f, -0.07431410f, 0.04447359f, -0.05341677f, 0.00452475f, -0.01232877f, -0.06837759f, 
    0.02819187f, -0.05583422f, -0.07888453f, 0.00402859f, -0.00261509f, -0.01323876f, -0.05621631f, -0.01504808f, 
    -0.01050474f, 0.03128992f, 0.04065736f, -0.03731549f, 0.00053921f, 0.01107486f, 0.02057488f, -0.05930248f, 
    -0.00212772f, -0.03628364f, 0.05128155f, -0.06534098f, 0.01392648f, 0.05570621f, -0.07390781f, 0.01130426f, 
    0.02188345f, -0.04009761f, 0.01967254f, 0.00341110f, -0.06774592f, 0.02140493f, 0.02978209f, 0.02234479f, 
    0.06476283f, -0.07018393f, -0.00809259f, -0.00584913f, -0.00577928f, -0.01049122f, -0.05015567f, 0.01618002f, 
    0.00748820f, -0.02450097f, -0.01748179f, 0.03290119f, 0.04705001f, -0.05822185f, 0.02551416f, -0.05917963f, 
    -0.00717234f, -0.00831180f, -0.00063845f, 0.05903709f, 0.00101036f, 0.06249384f, 0.04597300f, 0.01981682f, 
    0.05205850f, -0.03553617f, -0.01968454f, -0.02699805f, -0.00659150f, 0.02918911f, -0.02405511f, 0.06869877f, 
    -0.06261078f, 0.05689506f, -0.02628261f, -0.03823217f, -0.01392412f, -0.07419992f, -0.05887809f, -0.03472001f, 
    0.03681350f, -0.02544187f, 0.04256719f, -0.00197058f, -0.06455891f, 0.00797459f, 0.01704929f, 0.03110095f, 
    0.04005736f, -0.05198513f, -0.05815615f, -0.07919332f, 0.03934683f, -0.03828128f, -0.03981346f, -0.06481542f, 
    -0.07422337f, -0.00554400f, 0.06201634f, -0.04185707f, 0.01714330f, 0.05444258f, -0.06121337f, -0.03798310f, 
    -0.01519407f, 0.00780316f, -0.03034429f, -0.05356243f, -0.05210246f, 0.03115827f, -0.00049380f, -0.00498362f, 
    -0.05672553f, 0.04152115f, -0.01824998f, 0.00983840f, -0.00858479f, 0.04006511f, -0.04296164f, 0.04492702f, 
    0.05797897f, 0.02044884f, -0.04819942f, -0.03123100f, -0.05451693f, 0.03114067f, -0.06699545f, -0.03837828f, 
    0.02857462f, 0.01178941f, 0.01326758f, -0.01499573f, -0.06467342f, 0.04502916f, -0.02341604f, -0.03118394f, 
    0.00477478f, -0.02980599f, 0.00566743f, -0.07638810f, -0.02748096f, -0.02540604f, 0.02532915f, 0.04958498f, 
    0.12450220f, 0.02782694f, 0.09737048f, 0.02064041f, -0.11522465f, 0.01400366f, -0.02141996f, 0.11132747f, 
    0.11426044f, 0.07696483f, 0.00518100f, 0.03748381f, -0.03246258f, -0.00834642f, 0.07268152f, -0.10934029f, 
    -0.11136636f, -0.04520376f, -0.09088700f, -0.06104727f, -0.01459038f, 0.03317663f, -0.02204359f, -0.04066037f, 
    0.05067395f, -0.02918458f, 0.07378837f, -0.08133207f, -0.00991561f, 0.13257776f, 0.11771310f, -0.02980430f, 
    0.11893056f, 0.01425358f, 0.10663851f, 0.10455112f, -0.07854725f, -0.08153852f, 0.09174652f, -0.18866733f, 
    -0.14935037f, 0.05991217f, 0.12176502f, 0.15326071f, -0.04120823f, -0.03914464f, -0.11394449f, -0.11040967f, 
    0.12889621f, 0.11661811f, 0.16137949f, 0.12695614f, -0.08257218f, -0.09061076f, 0.02600443f, 0.16815254f, 
    0.06189220f, -0.01988591f, 0.10534771f, 0.12025443f, 0.30729160f, 0.08394787f, 0.14010841f, -0.03756757f, 
    0.05846570f, -0.05726821f, -0.00769896f, -0.03057689f, 0.04426528f, -0.00654819f, -0.16524668f, -0.23752138f, 
    -0.00985924f, 0.05364528f, 0.07671966f, -0.05243456f, -0.10630833f, 0.01753529f, 0.06377579f, -0.03927800f, 
    -0.01798526f, -0.09847197f, 0.01394142f, -0.01877229f, -0.05291679f, -0.01326955f, 0.02625117f, 0.02594522f, 
    -0.06857784f, -0.00542888f, 0.04382691f, -0.07634007f, -0.11944074f, 0.08239693f, -0.05594150f, -0.17125167f, 
    -0.00044229f, 0.07006535f, -0.19176596f, 0.20889696f, 0.11220887f, 0.02379368f, 0.08270336f, 0.12951033f, 
    0.06116728f, 0.00246414f, -0.02514637f, 0.09286035f, 0.01511874f, 0.04540458f, 0.08754160f, -0.12537692f, 
    0.07847470f, 0.02374936f, 0.21216281f, -0.00411643f, -0.01371689f, -0.13307425f, 0.00434576f, -0.15494703f, 
    0.03577352f, -0.23590733f, -0.02469772f, -0.16178602f, 0.16483386f, 0.10266789f, 0.06541156f, 0.16537973f, 
    -0.16262652f, 0.08414122f, -0.00852053f, -0.13145727f, -0.01972871f, 0.06784453f, -0.01983847f, 0.00159099f, 
    0.16385992f, 0.10400470f, 0.01118670f, 0.02214904f, 0.09973387f, 0.04084452f, -0.02745736f, 0.00425893f, 
    0.11888208f, -0.43033767f, 0.23800282f, -0.32770959f, 0.14462169f, 0.02587987f, -0.05327577f, 0.04855768f, 
    -0.02575825f, -0.09221933f, 0.04733774f, -0.17376558f, 0.37590030f, -0.49983773f, 0.09271064f, 0.25142550f, 
    0.03851229f, -0.07548404f, -0.15109849f, 0.01814152f, 0.13680308f, -0.00591197f, 0.13982156f, 0.01056492f, 
    0.11836389f, -0.10753451f, 0.11033361f, -0.14432509f, 0.07486501f, -0.04751858f, 0.17369321f, -0.06740094f, 
    0.02293602f, -0.04640191f, -0.03951085f, -0.02605681f, 0.07528433f, -0.19464679f, 0.07620385f, -0.01850901f, 
    0.09847626f, -0.05630683f, -0.00261927f, 0.00879744f, -0.01223698f, -0.07459291f, -0.04151758f, 0.10994163f, 
    -0.06405467f, -0.04030545f, 0.05924088f, 0.01944472f, -0.01646935f, 0.01822685f, 0.07022966f, -0.03511588f, 
    0.06825811f, 0.05404655f, 0.03740255f, -0.04466011f, -0.02943183f, -0.05343495f, -0.07658676f, -0.04196397f, 
    -0.00151546f, -0.04799534f, -0.05537505f, -0.01194090f, -0.03712280f, -0.03328464f, -0.03136873f, -0.05817224f, 
    -0.04052936f, -0.00045846f, 0.00057322f, 0.01566195f, -0.06290694f, 0.04620073f, 0.04491251f, -0.02818569f, 
    -0.02993056f, -0.01754321f, -0.06674906f, 0.06486866f, -0.05135083f, 0.06927986f, -0.06406906f, -0.02271271f, 
    0.03439960f, -0.07377479f, 0.05754999f, 0.05360159f, -0.04265330f, -0.02876269f, -0.05987278f, 0.01601140f, 
    -0.06624156f, 0.00110455f, 0.03452298f, 0.05467136f, -0.07036306f, -0.05639520f, 0.01877554f, -0.06269063f, 
    -0.07105768f, 0.04476696f, 0.05697488f, -0.03679079f, -0.05118019f, 0.05213925f, -0.00816626f, -0.07100006f, 
    -0.00610227f, -0.06577650f, -0.00365598f, -0.04258790f, -0.02393824f, 0.03144285f, 0.04513898f, -0.03390274f, 
    -0.03237211f, -0.07004790f, -0.03390877f, 0.05545024f, 0.01895205f, -0.04074901f, 0.06603027f, -0.06285026f, 
    -0.01819252f, 0.01870824f, -0.01967121f, -0.06245438f, 0.02570467f, -0.01482677f, 0.00652478f, 0.02512777f, 
    -0.01918110f, -0.01443562f, 0.05803504f, -0.02319731f, -0.02570250f, 0.01018899f, 0.05014643f, -0.01053923f, 
    0.05412987f, -0.07593164f, -0.03345218f, -0.04083687f, 0.03234914f, 0.00305339f, -0.03207385f, 0.01292378f, 
    -0.05754564f, 0.03501833f, -0.06147379f, -0.03426201f, -0.03394231f, -0.01744795f, -0.01457798f, -0.05442530f, 
    0.02956977f, 0.06449967f, -0.04101342f, -0.02587718f, 0.02255745f, -0.02773504f, -0.01607532f, -0.00934885f, 
    -0.04652376f, 0.04503108f, 0.04536428f, -0.00645513f, 0.00770942f, -0.02410694f, -0.05663354f, -0.01871236f, 
    -0.02058557f, -0.03931976f, -0.02367821f, -0.06470419f, 0.03766454f, -0.04836394f, 0.02690817f, 0.01946262f, 
    -0.01470770f, -0.02646920f, -0.05455389f, 0.03922308f, -0.04742618f, -0.00429665f, 0.03018359f, 0.03162924f, 
    -0.00331312f, 0.05939647f, 0.03630225f, 0.03460779f, 0.02122930f, 0.05011952f, 0.02858896f, -0.05803209f, 
    0.06217517f, 0.00816525f, -0.07325210f, -0.00543079f, -0.03612933f, -0.02010597f, -0.02818600f, 0.02001377f, 
    -0.04560615f, -0.04091552f, 0.04099843f, 0.00687436f, -0.07662117f, -0.04861736f, -0.07004505f, -0.01186357f, 
    -0.00231364f, 0.00206367f, 0.06157983f, -0.01369736f, 0.03967141f, 0.04387045f, 0.02989513f, -0.01677311f, 
    -0.01908323f, -0.03705657f, -0.03414108f, 0.05987698f, -0.02558986f, -0.07190021f, 0.01205591f, 0.04502298f, 
    -0.03205056f, -0.03145456f, 0.01591366f, -0.01100132f, -0.06283120f, 0.03318733f, 0.06635952f, 0.04027003f, 
    -0.05750639f, -0.06246945f, -0.05336807f, -0.01780567f, -0.01309510f, -0.02523937f, -0.03519135f, 0.00716791f, 
    -0.04101562f, -0.00519512f, -0.06872343f, -0.05385726f, -0.04315948f, -0.04363779f, 0.04177085f, -0.00784321f, 
    0.05512134f, 0.04521485f, 0.01850590f, 0.03306257f, -0.07402844f, -0.04638703f, -0.08027674f, 0.01916306f, 
    0.05112888f, -0.06921048f, -0.01388548f, -0.01292742f, 0.02228929f, 0.04192794f, 0.01783050f, -0.04039108f, 
    -0.07611697f, 0.03359395f, 0.05222170f, -0.01578690f, 0.05124268f, -0.01000686f, -0.03169004f, -0.00569728f, 
    0.02955074f, 0.03692356f, -0.01726770f, 0.05244676f, 0.04449436f, -0.04112812f, 0.02902354f, -0.01706507f, 
    -0.04842383f, 0.02074767f, 0.04850730f, 0.00531065f, 0.00053936f, 0.03619852f, -0.03361877f, 0.02433607f, 
    -0.02099085f, 0.03189738f, 0.05362653f, 0.03351527f, 0.03683142f, 0.05371664f, 0.04045082f, -0.06551575f, 
    -0.02926316f, -0.06161528f, 0.03174140f, -0.06138689f, 0.03765937f, -0.02819535f, -0.06048711f, -0.01417930f, 
    0.04210222f, 0.01991665f, -0.05929978f, 0.03752171f, -0.05906370f, -0.02630178f, -0.05010752f, 0.02370908f, 
    -0.05037074f, -0.00714643f, -0.04787447f, -0.00140462f, 0.05664582f, 0.00613479f, 0.03204304f, 0.06577236f, 
    -0.07716072f, -0.06665309f, -0.01229992f, 0.01623333f, -0.00805956f, -0.06540070f, 0.01888963f, -0.04115767f, 
    0.02998448f, -0.07769654f, 0.05691361f, -0.03203747f, 0.02333013f, -0.03410667f, 0.05564849f, 0.05068197f, 
    -0.03390779f, 0.03207435f, 0.04567520f, -0.06947020f, 0.05020931f, -0.00050738f, -0.05187407f, -0.00014546f, 
    -0.07613976f, -0.04970769f, -0.02385886f, -0.00293211f, -0.02978918f, 0.03427181f, -0.00461397f, -0.00253076f, 
    0.04566385f, 0.00169094f, 0.01564186f, -0.00291400f, -0.00002533f, 0.06157640f, 0.01098976f, 0.02625883f, 
    -0.00042476f, -0.04054811f, -0.04945659f, -0.03653742f, -0.00810396f, 0.04606095f, -0.01916546f, -0.05719347f, 
    0.02132009f, -0.07172695f, 0.04384603f, -0.05392636f, 0.05049204f, -0.03183817f, 0.04108459f, 0.03581626f, 
    0.03789061f, -0.05037297f, -0.02792967f, -0.07788161f, -0.06675878f, -0.08175346f, -0.04320124f, -0.01178214f, 
    -0.06762893f, -0.06287315f, 0.03832926f, -0.07565075f, 0.02845825f, -0.03169031f, -0.05269663f, -0.06557807f, 
    -0.08532531f, -0.01564205f, -0.07969227f, 0.03497127f, 0.04428767f, 0.00624246f, -0.04520312f, -0.08170661f, 
    -0.05709827f, 0.05329502f, 0.06027121f, 0.02257252f, -0.04301171f, -0.00459868f, 0.03740017f, 0.04784248f, 
    0.03746556f, -0.07848161f, -0.00924010f, -0.02158652f, -0.06938824f, -0.01646442f, 0.04120094f, 0.00753482f, 
    0.00022667f, -0.02294460f, -0.03952399f, -0.02666436f, -0.04082491f, -0.02697380f, 0.02117209f, 0.02083507f, 
    -0.26543716f, 0.00869899f, 0.28684026f, 0.21535586f, -0.06676411f, 0.00309783f, 0.08744057f, -0.12675053f, 
    0.15911910f, -0.06748875f, -0.15306124f, 0.00136203f, 0.14491382f, 0.37555569f, 0.01976335f, -0.21438542f, 
    -0.11724890f, -0.08350783f, -0.06580947f, -0.02426698f, 0.04616857f, 0.00647916f, 0.12774555f, 0.00706214f, 
    0.11486536f, -0.18223754f, 0.10196799f, 0.03069042f, 0.01340933f, -0.03455850f, -0.03357525f, -0.02316660f, 
    0.31350264f, 0.26674357f, -0.07681044f, 0.06950384f, 0.16225605f, 0.13804184f, -0.12935209f, 0.05974060f, 
    -0.22288500f, 0.14518532f, 0.03090608f, 0.00972721f, -0.09714839f, -0.08015224f, -0.20460150f, 0.10165980f, 
    0.02916854f, 0.16248515f, 0.13293913f, 0.00740593f, -0.11634863f, 0.00786995f, 0.05659207f, 0.00590418f, 
    0.00268230f, -0.08542226f, -0.06281888f, -0.04210480f, 0.07497513f, 0.09136732f, 0.11105651f, 0.03815971f, 
    0.08885380f, 0.01811543f, 0.02468288f, 0.06570537f, -0.06869327f, 0.06120138f, -0.05286855f, -0.14510168f, 
    0.02339021f, 0.10835879f, 0.17407586f, 0.10537039f, -0.16066536f, 0.07494929f, 0.03418322f, -0.10538881f, 
    -0.07874394f, -0.19181980f, -0.10324443f, -0.06179622f, -0.31404570f, -0.16047159f, -0.21938947f, 0.02582127f, 
    0.00642004f, -0.07713313f, 0.02595659f, 0.01069931f, -0.18785289f, -0.07067422f, -0.06453609f, -0.13289928f, 
    0.42611742f, -0.02760610f, -0.03715594f, -0.25834441f, 0.00086724f, -0.02010253f, 0.02898893f, 0.04958082f, 
    -0.01612050f, 0.08938043f, -0.11373362f, -0.00231281f, 0.07625146f, 0.04855664f, -0.11034561f, -0.02472926f, 
    0.11605991f, 0.06181486f, -0.02721943f, -0.05451842f, -0.01527912f, -0.14140476f, -0.25484955f, 0.07195494f, 
    -0.15469718f, -0.09794886f, 0.12202924f, 0.01564988f, -0.05770655f, -0.02137704f, 0.16275388f, 0.05578670f, 
    0.03790511f, 0.32672751f, 0.02716422f, -0.11128175f, 0.11289021f, -0.06936840f, 0.16207139f, 0.22979364f, 
    0.06452779f, 0.07467154f, -0.04030902f, -0.06904597f, 0.09507038f, 0.09751765f, -0.02348615f, 0.10220961f, 
    0.10550724f, -0.22469141f, 0.07469753f, -0.08282894f, 0.05791245f, 0.06739306f, 0.03148875f, 0.24909437f, 
    -0.08236203f, 0.10071316f, 0.07678139f, -0.05811021f, 0.05507302f, -0.30736068f, 0.24228823f, 0.25436467f, 
    0.03523660f, 0.28162187f, -0.14325579f, 0.03612913f, 0.10444382f, 0.10699360f, 0.05679954f, 0.06567370f, 
    0.49614570f, 0.08680940f, 0.18235086f, -0.06620622f, 0.15179038f, 0.04610848f, -0.16016608f, -0.08437171f, 
    -0.05555372f, 0.01047128f, -0.16080274f, -0.04754938f, 0.10553131f, 0.01778371f, 0.10969178f, 0.06476329f, 
    0.08728231f, -0.07836658f, -0.04538607f, -0.06109677f, -0.00336774f, -0.08440968f, 0.04729537f, 0.06679859f, 
    -0.16242671f, -0.04578305f, -0.20270462f, 0.01531093f, -0.05149801f, -0.33783853f, -0.32763359f, -0.12174954f, 
    -0.03320327f, -0.07505482f, 0.03074061f, 0.08813854f, -0.22759572f, 0.08695516f, -0.44054309f, -0.36541176f, 
    -0.19888890f, 0.02698293f, -0.16731107f, 0.06169081f, 0.11711252f, -0.04833106f, -0.05995905f, -0.17646970f, 
    -0.02195506f, -0.05923249f, 0.08594263f, 0.18673421f, -0.04345651f, 0.01930364f, 0.07840156f, 0.04312292f, 
    0.12575909f, 0.07208549f, -0.02648218f, 0.18904629f, 0.00622370f, -0.08441808f, -0.05401819f, 0.04731868f, 
    0.05243738f, -0.11035462f, 0.12700662f, -0.13311289f, -0.03422218f, -0.14857607f, -0.07467634f, -0.01000050f, 
    0.30161291f, 0.16854204f, -0.10770833f, -0.47516969f, -0.08977196f, 0.11980841f, 0.11142771f, 0.17819639f, 
    0.01761591f, -0.04190494f, -0.09096733f, -0.03609792f, 0.10660329f, 0.24654703f, 0.20642206f, 0.16722739f, 
    -0.11590517f, -0.03699499f, -0.09610261f, 0.00166703f, -0.00710175f, 0.02670583f, -0.13763772f, -0.03002045f, 
    -0.22136964f, 0.01310147f, -0.30543619f, -0.39413539f, -0.06642329f, 0.24350882f, 0.05951639f, 0.27333120f, 
    -0.07545818f, 0.00622654f, 0.00287327f, 0.04241872f, -0.21820979f, 0.09287031f, -0.07311557f, -0.11431715f, 
    0.27872720f, 0.37904313f, 0.21685836f, 0.06466295f, -0.08629607f, -0.14776041f, 0.06195002f, -0.00176514f, 
    0.09631451f, -0.04818844f, -0.21217939f, -0.10656233f, 0.06142734f, 0.27031779f, 0.08767811f, 0.28701070f, 
    -0.09048191f, 0.01022429f, -0.01802906f, 0.06544345f, -0.10859832f, -0.01908602f, 0.04628330f, 0.05422762f, 
    0.09909829f, 0.23097219f, -0.04534955f, -0.12297679f, -0.10339151f, -0.11377370f, -0.07462505f, 0.03775985f, 
    0.23624806f, -0.04326147f, 0.35136309f, 0.30648160f, 0.02618617f, -0.11195303f, -0.02516517f, -0.01874387f, 
    0.05841702f, -0.01835737f, -0.01832480f, -0.09028021f, 0.17833622f, -0.03318622f, 0.14322606f, 0.22225644f, 
    -0.00773975f, -0.05734747f, 0.00998252f, 0.00977202f, -0.07442889f, 0.01142129f, -0.03641607f, 0.09349141f, 
    0.33799726f, -0.01576913f, -0.24556328f, -0.14466828f, -0.02842436f, 0.12292311f, 0.08258996f, -0.08206338f, 
    -0.07714810f, -0.03880127f, -0.00292911f, -0.04781256f, -0.01823921f, 0.13691981f, 0.11454756f, 0.01435807f, 
    -0.05714707f, 0.01959059f, -0.03214185f, -0.00281803f, 0.12749012f, -0.10901109f, 0.01849443f, 0.02566539f, 
    0.19579951f, 0.12407275f, 0.00632223f, 0.02353733f, 0.13556913f, 0.07858048f, -0.15935072f, -0.13725054f, 
    -0.08840814f, -0.06360002f, -0.12473741f, 0.02007490f, 0.12405588f, 0.06213504f, -0.00133765f, 0.14983149f, 
    0.16218778f, 0.04765065f, -0.04737774f, 0.00924744f, -0.07876820f, -0.00638438f, -0.02688462f, -0.09462724f, 
    -0.33299875f, -0.09456465f, 0.07076040f, 0.06317697f, -0.07465936f, 0.02313149f, 0.05112318f, 0.06190680f, 
    0.05478820f, -0.03692264f, 0.02020621f, -0.00192527f, 0.31282121f, 0.59559709f, -0.17321700f, -0.00383175f, 
    -0.04793097f, -0.02474303f, 0.20817748f, 0.04128725f, 0.16817521f, 0.21506171f, 0.10554147f, 0.12669940f, 
    0.21427514f, -0.19243124f, -0.13108301f, 0.11174914f, -0.08572040f, 0.00682617f, 0.11168647f, 0.05896070f, 
    0.03468179f, 0.01492404f, 0.20076592f, -0.00671564f, 0.04226546f, -0.01627319f, -0.11167314f, -0.02446687f, 
    0.15979779f, -0.09534478f, 0.11148341f, -0.04513812f, -0.00514374f, 0.07386329f, 0.02439237f, 0.06339059f, 
    -0.23477577f, 0.08569051f, 0.05417176f, -0.01753886f, 0.07862281f, -0.00614539f, 0.21033055f, -0.18653695f, 
    0.01507721f, -0.06283922f, -0.11104124f, -0.05121107f, -0.05851417f, -0.18963684f, 0.05351863f, -0.01166528f, 
    0.01701017f, -0.08556709f, -0.13114932f, -0.03502058f, 0.18669476f, 0.14409691f, 0.16738075f, 0.07287442f, 
    -0.11307629f, -0.16390906f, 0.05343786f, -0.15870783f, 0.12037705f, 0.07126559f, 0.01561561f, 0.13615803f, 
    0.03443390f, -0.04433186f, 0.08741517f, 0.04784429f, 0.04085689f, -0.43498102f, 0.06798149f, 0.00961780f, 
    0.06778567f, 0.03528472f, -0.03033838f, 0.22713856f, -0.05921097f, -0.12233787f, -0.12705408f, -0.03852076f, 
    0.02275206f, 0.38802531f, -0.01366111f, -0.16426019f, 0.26912484f, 0.09870205f, 0.11658439f, 0.02699736f, 
    0.04744794f, -0.01559455f, 0.02248498f, -0.12092408f, -0.10735276f, -0.18738957f, -0.15925223f, 0.05290616f, 
    -0.08340497f, 0.04936415f, -0.04774344f, 0.04982252f, 0.21352211f, -0.06071430f, 0.12366892f, -0.04247394f, 
    0.00004457f, 0.01783403f, -0.00877944f, -0.02786682f, 0.04771560f, -0.08550955f, -0.10587192f, -0.07110402f, 
    -0.13343610f, 0.03703696f, 0.00793673f, -0.01428661f, -0.15420862f, -0.10591942f, -0.04260027f, -0.11635113f, 
    0.06159301f, -0.01046109f, -0.14082235f, -0.10848670f, 0.02533323f, -0.00021497f, 0.06309754f, -0.14546216f, 
    -0.20426752f, -0.19113551f, 0.35176986f, -0.09833720f, 0.09109140f, 0.07265533f, 0.09033345f, 0.25104710f, 
    0.03104327f, 0.16212611f, 0.00399425f, -0.01056772f, -0.32005233f, -0.02316952f, 0.22698309f, -0.02681263f, 
    -0.00505857f, 0.07207754f, -0.08852271f, 0.05371366f, 0.28099963f, 0.16672198f, 0.09047289f, -0.08533842f, 
    0.12434005f, 0.08762577f, -0.08916358f, -0.11098953f, -0.08635029f, 0.17125914f, -0.16893700f, 0.13831459f, 
    0.00675874f, -0.04106117f, 0.07694094f, -0.10054306f, 0.11750039f, -0.32314020f, -0.01263014f, -0.28625569f, 
    -0.10662502f, 0.04868557f, -0.00153648f, 0.05007886f, -0.15253650f, 0.00050013f, -0.11006992f, -0.07474931f, 
    -0.00672308f, -0.14848039f, 0.19159105f, 0.16956823f, -0.00170388f, 0.05139906f, -0.01045514f, 0.23083064f, 
    0.26597086f, 0.03596813f, 0.18739624f, 0.11681244f, -0.25825718f, 0.40522212f, 0.15214399f, 0.07504264f, 
    -0.06506690f, 0.11219366f, -0.02272256f, -0.25289154f, 0.05540264f, -0.10493025f, 0.01172590f, 0.20444638f, 
    0.02733261f, -0.28620821f, 0.01105362f, 0.10173936f, 0.00136091f, 0.03980904f, -0.00906429f, -0.05585440f, 
    0.14709482f, 0.20900910f, 0.36844614f, 0.28048897f, 0.06805180f, -0.12870686f, -0.03059795f, -0.42934495f, 
    0.05133092f, 0.03266084f, -0.02597654f, 0.03280733f, -0.07456110f, -0.13949850f, -0.23183006f, -0.31167629f, 
    0.08584573f, 0.19564866f, 0.17896608f, 0.10663249f, -0.04026207f, -0.06606470f, 0.05455154f, 0.24550977f, 
    0.17371835f, 0.06201581f, 0.12751181f, -0.02377359f, 0.24291772f, -0.00459359f, 0.10764260f, -0.07563761f, 
    -0.08209572f, -0.11912667f, -0.10162090f, -0.26602718f, 0.02421033f, -0.01397437f, -0.25406542f, -0.02740499f, 
    0.02319038f, 0.03067003f, 0.08115991f, 0.03632955f, -0.01524778f, -0.03580006f, 0.06211962f, 0.10846976f, 
    -0.00853639f, -0.06771682f, -0.01208795f, -0.09003201f, -0.14070024f, -0.20273702f, 0.01573660f, 0.36658141f, 
    0.09140192f, -0.06275684f, 0.03106082f, -0.09399361f, -0.16519563f, -0.10069489f, -0.16971065f, -0.34787413f, 
    -0.08513793f, 0.27364567f, -0.02959067f, 0.24785189f, 0.08104797f, 0.00928763f, 0.12307042f, -0.01651839f, 
    0.06958827f, -0.03362707f, -0.06676292f, -0.08679672f, 0.07196349f, 0.12164073f, -0.07151043f, -0.33276966f, 
    0.09244882f, 0.07480910f, 0.04071789f, -0.19622912f, -0.30003744f, -0.31592065f, -0.34336641f, -0.42213693f, 
    -0.04777827f, -0.07249938f, 0.01766065f, 0.04657820f, 0.07623190f, -0.01277444f, 0.00738422f, 0.25133964f, 
    -0.12890626f, 0.10529650f, 0.08234721f, -0.44251123f, 0.00917472f, 0.04703276f, -0.10417297f, -0.04871874f, 
    0.05938902f, -0.05864234f, -0.07684992f, -0.06506521f, 0.04516103f, -0.02180920f, -0.04284351f, 0.06953698f, 
    0.13323919f, -0.34494025f, 0.19884387f, -0.12279748f, 0.03236580f, 0.03928218f, 0.06989168f, 0.17819005f, 
    -0.06982417f, 0.00492811f, -0.05191600f, 0.00833857f, -0.13116080f, -0.05703500f, 0.05170549f, 0.29921174f, 
    0.00015161f, 0.16271283f, -0.03258522f, 0.01682797f, 0.13368694f, 0.10308098f, 0.13145372f, 0.11852684f, 
    -0.10335878f, -0.00783433f, 0.34042588f, -0.13693812f, 0.07558903f, -0.00335935f, 0.15511891f, -0.13004260f, 
    -0.04924774f, -0.02008343f, -0.10633935f, -0.26223975f, 0.08964748f, -0.13039561f, 0.29053149f, -0.00234160f, 
    0.12556897f, -0.25503516f, 0.00077123f, -0.03939561f, -0.13348836f, 0.05444676f, -0.04649246f, -0.15647827f, 
    -0.02541313f, 0.01606897f, 0.05118118f, -0.03044991f, 0.05249748f, 0.04128495f, -0.06594756f, -0.03945346f, 
    -0.06692958f, 0.02238324f, 0.00935941f, 0.03437649f, -0.07035274f, -0.06724497f, 0.02066263f, -0.03765887f, 
    0.01619679f, -0.07296917f, -0.00205208f, -0.00881104f, -0.06047390f, 0.00451726f, 0.05047181f, -0.04291867f, 
    -0.05052162f, 0.00631640f, -0.05633473f, -0.05317542f, -0.01717291f, -0.04945775f, -0.00418937f, 0.00884438f, 
    -0.01248268f, -0.02399618f, 0.03469212f, -0.02652856f, 0.06485648f, -0.05528337f, -0.05760585f, 0.01286843f, 
    -0.03909172f, -0.03749885f, 0.01288117f, 0.04063812f, -0.03321586f, -0.02364875f, -0.06091469f, 0.01799559f, 
    -0.04889579f, -0.06536432f, 0.02177880f, 0.03310771f, 0.02515930f, 0.02067353f, -0.07425819f, -0.00143395f, 
    0.05588154f, -0.02454453f, -0.02998444f, -0.07365904f, -0.04496294f, -0.03311727f, 0.00043250f, -0.06311657f, 
    0.01733877f, -0.02702489f, -0.04942776f, -0.06678919f, 0.01678142f, 0.05582438f, -0.07175990f, 0.00734020f, 
    -0.03671744f, -0.03149902f, 0.02260029f, -0.05243707f, -0.00178196f, -0.00613862f, 0.03541879f, -0.03462059f, 
    0.04782122f, -0.03566968f, 0.03389432f, 0.05129397f, -0.02131408f, 0.00213331f, -0.03801814f, -0.07856523f, 
    0.06836929f, -0.03241237f, -0.02393613f, 0.04358392f, -0.06994829f, -0.02935337f, 0.04970686f, 0.04685241f, 
    -0.07095793f, 0.03077762f, -0.00665817f, 0.01905615f, 0.05903707f, -0.04509654f, 0.01502279f, -0.05722226f, 
    0.06359607f, 0.02341673f, -0.06262065f, -0.05810205f, 0.03619888f, -0.05054249f, 0.00062225f, 0.04881720f, 
    0.06369157f, -0.06848273f, -0.07682566f, -0.01758748f, -0.03988380f, -0.00696104f, -0.06260990f, 0.04688745f, 
    -0.07598753f, 0.06252010f, 0.04930988f, -0.00683500f, 0.04042961f, -0.03008899f, -0.04258243f, -0.03438111f, 
    -0.01087596f, -0.05977597f, 0.01577906f, -0.02724278f, -0.06819990f, 0.04652804f, -0.00726212f, -0.01862542f, 
    -0.07253402f, 0.00904424f, -0.04927358f, -0.01539845f, 0.05655944f, -0.04408342f, 0.04666601f, 0.05791245f, 
    -0.01656494f, -0.03996293f, 0.05352219f, -0.01533346f, -0.05701646f, -0.02647715f, -0.01446436f, 0.04447848f, 
    0.06778581f, 0.03383497f, -0.04876547f, 0.04400211f, -0.06990833f, 0.04766467f, 0.01081908f, 0.05335049f, 
    -0.00904489f, -0.01646107f, -0.03579347f, -0.07278315f, 0.01755292f, 0.00060254f, 0.02010243f, -0.03306082f, 
    0.02032520f, 0.03659687f, 0.01433339f, 0.04012213f, 0.01037124f, 0.00805013f, -0.03430051f, 0.03863413f, 
    0.00681455f, -0.05400814f, -0.05636944f, -0.04087675f, 0.01179035f, 0.04581422f, 0.03115116f, 0.01907150f, 
    -0.02391112f, 0.04723467f, -0.06193962f, 0.01616883f, 0.02750479f, 0.03471859f, -0.03772726f, -0.04665370f, 
    -0.06105613f, -0.00700213f, 0.12751761f, -0.06857105f, 0.12233731f, -0.02970766f, 0.22293842f, -0.11807949f, 
    0.04252712f, 0.13462470f, 0.03189280f, -0.07734841f, 0.44253701f, 0.14804174f, 0.06405510f, 0.08206030f, 
    0.07084350f, 0.04564966f, 0.00567193f, 0.22569486f, 0.04582446f, 0.08819226f, 0.06711331f, 0.04353922f, 
    -0.10506536f, 0.15923831f, 0.01288722f, 0.07512604f, -0.06599418f, 0.00634196f, -0.11780494f, 0.02420766f, 
    -0.05738992f, -0.11738293f, -0.24233998f, -0.03828777f, -0.00495860f, 0.11846702f, -0.40749392f, 0.25613135f, 
    0.07604536f, 0.03360646f, 0.03996715f, -0.18078338f, 0.02389832f, -0.00453754f, 0.03370569f, -0.00681054f, 
    -0.13531399f, -0.12266638f, -0.13353395f, -0.16864905f, 0.06940555f, 0.13855349f, -0.07470700f, -0.14111589f, 
    -0.04944497f, 0.08201208f, -0.05000171f, 0.07350033f, -0.09497765f, -0.03697854f, -0.03839839f, 0.17515056f, 
    -0.02870811f, 0.05724455f, -0.00894441f, -0.05962143f, -0.00353294f, 0.09695452f, 0.08506413f, 0.07797275f, 
    0.05293722f, 0.03497312f, 0.13694425f, 0.02944199f, 0.03660997f, 0.05768707f, 0.04714675f, -0.00493630f, 
    0.07522491f, 0.11918754f, -0.03909636f, -0.10056791f, -0.05392213f, -0.07483549f, -0.27985036f, -0.24656163f, 
    -0.04105551f, -0.12049250f, -0.01388472f, 0.26972985f, -0.04993422f, -0.15605874f, 0.01178972f, -0.03413684f, 
    0.17961848f, -0.45252898f, 0.02858011f, -0.27454591f, -0.00563188f, 0.05260122f, 0.07263624f, 0.01616489f, 
    0.03027588f, 0.08463593f, -0.02009907f, 0.14471681f, -0.06741549f, -0.08969830f, -0.19387910f, 0.00859221f, 
    0.13176355f, 0.01945917f, -0.04946897f, 0.15464416f, 0.00396748f, 0.10002282f, -0.06332289f, 0.11585987f, 
    -0.05704718f, 0.00074293f, -0.17679513f, 0.05653465f, -0.04620975f, -0.12776309f, 0.08856205f, -0.20479697f, 
    -0.01776334f, -0.02708308f, 0.02290710f, 0.08051498f, 0.13338566f, 0.06848862f, 0.01756654f, 0.10433289f, 
    -0.12994190f, -0.13068262f, 0.02197558f, -0.06371725f, -0.13615470f, -0.13362545f, -0.04532540f, -0.07978863f, 
    0.00589533f, 0.27292350f, -0.14784208f, 0.25972864f, -0.03816234f, -0.07415333f, 0.18525159f, 0.01192961f, 
    0.07318975f, 0.07168566f, -0.02874023f, -0.03337342f, 0.16275389f, 0.09104582f, 0.13001585f, 0.00170159f, 
    0.02441596f, -0.05563711f, 0.01277840f, 0.11961909f, 0.11998323f, -0.04550923f, -0.03768313f, 0.02013860f, 
    0.19284795f, -0.04364353f, -0.11999934f, -0.01906812f, 0.15253188f, 0.05205938f, -0.20729932f, 0.02836790f, 
    0.06775561f, 0.09880938f, -0.07540620f, 0.12914133f, -0.11445065f, 0.03188341f, 0.00977088f, -0.14644924f, 
    -0.07413691f, 0.00595457f, -0.17881364f, -0.02371279f, 0.05538078f, -0.06090130f, 0.00936676f, -0.05517268f, 
    0.02344565f, 0.03926531f, 0.13769251f, 0.20841616f, 0.00019675f, -0.03866813f, -0.06654207f, 0.08103350f, 
    0.27856478f, 0.06511515f, 0.08286540f, 0.23923227f, 0.26779070f, 0.65694606f, 0.11126800f, 0.05684853f, 
    -0.16502063f, -0.01550912f, -0.06754503f, 0.03216849f, 0.02479464f, -0.02177001f, 0.06584778f, 0.20989217f, 
    -0.03428638f, -0.09059501f, -0.20125386f, 0.08457126f, 0.11268939f, 0.07264115f, -0.11160365f, -0.08072471f, 
    0.12134486f, 0.14538729f, 0.14679641f, 0.26925221f, -0.13850971f, -0.11936880f, -0.33779326f, 0.14358465f, 
    -0.14810750f, 0.28796330f, 0.02221487f, -0.03350012f, 0.04228632f, -0.11384363f, -0.14338878f, -0.32058537f, 
    0.20119435f, 0.15065657f, 0.11610444f, 0.02380501f, 0.10349122f, 0.13453391f, 0.10157090f, 0.15125981f, 
    0.09612405f, 0.02804508f, -0.01883078f, 0.09581160f, 0.15134868f, 0.17277534f, 0.01270959f, 0.20063516f, 
    0.09336406f, -0.02579907f, 0.03372312f, 0.02208639f, -0.04199602f, 0.05865891f, -0.16441786f, 0.00237189f, 
    0.16831434f, 0.15695381f, 0.12810712f, 0.26341563f, -0.04915573f, 0.16181339f, 0.05495825f, 0.10846562f, 
    0.04105353f, -0.09892777f, -0.01175186f, -0.07053091f, -0.43263507f, -0.17705686f, -0.08368406f, 0.10555200f, 
    0.05882325f, -0.09915811f, 0.05220540f, 0.06565768f, -0.07155093f, 0.01104093f, 0.00943935f, -0.14790392f, 
    0.04933687f, -0.10367101f, 0.06141846f, -0.25156069f, -0.00056221f, -0.05523574f, 0.05359791f, 0.08010828f, 
    -0.00378480f, -0.14829889f, -0.05020285f, 0.14007047f, -0.13190266f, 0.05600923f, -0.15986213f, -0.12148824f, 
    0.15255927f, 0.09948246f, 0.15073532f, 0.08253691f, -0.00991868f, -0.18010382f, -0.28734705f, -0.08057309f, 
    -0.13888669f, -0.19602300f, -0.06656187f, 0.07202777f, 0.01384882f, 0.07278401f, 0.15935145f, 0.03048976f, 
    -0.13915171f, -0.02581344f, 0.04300407f, -0.16229421f, -0.05245085f, -0.31832302f, -0.10524092f, 0.22444060f, 
    0.18417676f, -0.05551625f, 0.07178816f, 0.01375513f, -0.10644451f, -0.17235492f, 0.14060508f, 0.25301364f, 
    0.13060164f, -0.26969364f, -0.02443409f, 0.03772768f, 0.06255931f, 0.07469641f, 0.04184929f, -0.03393413f, 
    0.14345324f, -0.07840437f, 0.03020420f, -0.06220014f, -0.12045953f, 0.01873112f, 0.33182997f, 0.32191151f, 
    0.09274518f, 0.07487345f, -0.06700998f, 0.06054503f, 0.10191986f, 0.06424569f, 0.00774459f, 0.15857990f, 
    -0.06294128f, -0.02437715f, -0.15570568f, -0.16141966f, -0.02736568f, 0.00843285f, 0.01907070f, -0.10638094f, 
    -0.21858591f, -0.12307551f, -0.29216772f, -0.00353030f, -0.16451749f, -0.13483782f, -0.06499553f, -0.15577072f, 
    0.06150015f, -0.03886688f, -0.12329771f, -0.08673628f, -0.09725059f, -0.21243358f, 0.08550595f, -0.08040044f, 
    0.04288264f, 0.18868174f, 0.19572431f, 0.08727691f, 0.02180095f, 0.06634247f, 0.10634067f, 0.01790357f, 
    0.05322897f, 0.02073915f, 0.00722558f, 0.14868496f, 0.11296639f, 0.18133964f, 0.30392981f, 0.11887060f, 
    -0.01771368f, 0.05415197f, 0.05061200f, -0.00696880f, -0.03398108f, -0.12019812f, -0.08739343f, -0.03777397f, 
    -0.28998569f, -0.01039214f, -0.08401980f, -0.21565118f, -0.04218088f, -0.06924342f, -0.23007245f, -0.20935459f, 
    0.12023119f, -0.07392047f, 0.07639842f, 0.19555572f, -0.04120946f, -0.00398684f, 0.00857864f, 0.12099326f, 
    -0.24334024f, 0.22682068f, -0.06196316f, 0.04472041f, -0.09139909f, -0.09967510f, -0.00612140f, -0.07076949f, 
    0.03415025f, 0.12487053f, 0.12126865f, 0.11437009f, -0.11495348f, -0.05985978f, -0.06114484f, -0.05066753f, 
    0.01020702f, -0.04780291f, -0.01171756f, 0.05869675f, -0.18966405f, 0.03040656f, -0.11116051f, 0.03231645f, 
    -0.05816413f, 0.10934726f, -0.01306082f, 0.01648997f, 0.09166508f, -0.06872327f, -0.26085865f, -0.02865678f, 
    0.17340109f, 0.28852591f, 0.21819380f, 0.25840557f, -0.11482392f, 0.16430353f, 0.08658330f, -0.00083446f, 
    -0.09364817f, -0.17769068f, -0.05766113f, -0.18180330f, -0.44489631f, 0.31154212f, 0.00204723f, 0.24723594f, 
    -0.17957892f, 0.06830165f, 0.12568155f, 0.08563027f, -0.02187161f, -0.08566825f, 0.06290799f, -0.02038049f, 
    0.15072589f, -0.16283174f, 0.13015430f, -0.10756085f, -0.01113792f, 0.08463795f, 0.02335328f, -0.01965409f, 
    -0.06293818f, -0.06685407f, 0.06616171f, 0.07049394f, 0.01765710f, 0.22363496f, -0.09171975f, -0.11231447f, 
    0.23335104f, 0.03848387f, 0.03089804f, 0.11381894f, 0.01126360f, -0.08732221f, -0.10770448f, -0.10174555f, 
    -0.17291787f, -0.23446873f, -0.02981617f, -0.10665071f, -0.05992395f, 0.05907681f, 0.04730665f, -0.07478590f, 
    -0.01069235f, -0.04864348f, 0.07652988f, -0.20248356f, -0.08619867f, 0.13635875f, -0.28442699f, -0.19533427f, 
    -0.12202567f, -0.11934162f, 0.06800083f, 0.11178331f, -0.06015744f, 0.01580853f, -0.11607705f, 0.03417885f, 
    -0.13566591f, 0.10725894f, -0.01197981f, 0.17691968f, -0.15694721f, 0.00203481f, -0.05653593f, 0.01699785f, 
    0.03875810f, -0.06142349f, -0.02926123f, -0.09934559f, 0.26068598f, -0.27865070f, 0.25230378f, 0.46586642f, 
    -0.03465798f, -0.19081639f, 0.18872485f, 0.09353785f, 0.03701016f, 0.08568156f, -0.02576449f, 0.14778824f, 
    -0.04130195f, -0.02088173f, 0.53486520f, 0.00754116f, 0.07438207f, -0.14100817f, -0.09517269f, 0.08375374f, 
    -0.06894438f, 0.10322604f, 0.12309981f, -0.11460853f, -0.30575350f, 0.17646894f, -0.08083244f, -0.14338712f, 
    0.07515690f, -0.00771920f, -0.06685457f, 0.05541843f, 0.10092663f, 0.02907725f, 0.25962159f, -0.04778532f, 
    -0.17643391f, 0.08136815f, -0.07596796f, 0.11615395f, 0.03134162f, 0.15270250f, -0.08844334f, -0.21473695f, 
    0.02374374f, -0.24337725f, -0.09105764f, -0.24546625f, -0.34679055f, 0.14778672f, 0.09280473f, -0.12956248f, 
    0.09439240f, -0.00458926f, -0.04477279f, 0.00907940f, -0.14628956f, 0.00355451f, 0.12201726f, -0.07807403f, 
    -0.26043236f, 0.23866555f, -0.03707456f, -0.22352570f, -0.01129038f, -0.09257647f, -0.14019848f, -0.27413130f, 
    0.07725488f, -0.09014129f, -0.16050756f, 0.08632363f, -0.05575351f, -0.06015073f, -0.01148040f, 0.02775974f, 
    -0.01891455f, 0.24737360f, -0.12097909f, 0.00795221f, 0.00027482f, -0.22205931f, 0.07947683f, 0.14599150f, 
    -0.00244057f, 0.07023987f, 0.04605241f, -0.02819745f, -0.09865264f, -0.06520586f, -0.11481148f, -0.00213037f, 
    0.05775508f, 0.11912271f, 0.07597587f, -0.01021034f, -0.06665535f, 0.18507898f, 0.09922243f, 0.05064122f, 
    -0.12125693f, -0.10500210f, -0.06561356f, -0.07094806f, 0.16874097f, -0.01291552f, -0.01268588f, -0.07381166f, 
    0.06077183f, 0.08508113f, 0.01891560f, 0.15147166f, -0.11602872f, 0.03428461f, 0.10639113f, -0.00547954f, 
    0.03766420f, -0.01366823f, -0.04158467f, 0.08401987f, -0.29818764f, -0.00568380f, -0.24908891f, 0.00936165f, 
    0.07122044f, -0.11481675f, 0.11185163f, -0.08768007f, -0.15284292f, 0.07725573f, 0.07511931f, -0.09888236f, 
    -0.05513024f, -0.14465232f, 0.11010516f, -0.01213937f, -0.10681000f, 0.10665867f, -0.14915934f, 0.14635800f, 
    -0.00267788f, 0.10001908f, -0.14523432f, 0.11670446f, -0.02657074f, 0.21468078f, 0.00945408f, -0.11482526f, 
    0.15857445f, 0.10374445f, 0.03271553f, -0.12853298f, -0.05686427f, -0.01919196f, 0.07570300f, 0.09713984f, 
    -0.08297287f, -0.07132176f, 0.11278858f, 0.12226893f, -0.22681504f, 0.02194051f, -0.01103368f, -0.01323276f, 
    0.19645834f, -0.07093012f, -0.09088155f, -0.08366485f, 0.12547860f, 0.01097566f, 0.03582859f, 0.09705476f, 
    -0.11996008f, 0.11473120f, -0.04683691f, -0.12724128f, 0.09594554f, 0.03886968f, -0.03995237f, 0.14089979f, 
    0.32570446f, -0.16327739f, -0.06307931f, 0.12347162f, -0.00797033f, 0.09442357f, 0.05572901f, 0.06350444f, 
    0.10029408f, -0.12469685f, 0.05933090f, -0.02180075f, 0.16906533f, -0.32885590f, 0.11637852f, 0.24134110f, 
    -0.17220087f, 0.01197837f, -0.02957649f, -0.00257468f, 0.09481580f, 0.18504652f, -0.06795038f, 0.06563874f, 
    0.30197525f, 0.18300423f, 0.26685557f, 0.33774957f, 0.20775412f, -0.08290849f, 0.08733909f, -0.03208809f, 
    -0.03199071f, 0.01731637f, -0.12064670f, -0.03281704f, -0.06499143f, 0.17009190f, -0.04356695f, 0.10667352f, 
    0.11025236f, 0.05406242f, 0.07291348f, -0.04933400f, 0.09393824f, -0.08529522f, 0.03774090f, 0.07051878f, 
    -0.30112624f, 0.10578331f, -0.12970212f, 0.14553434f, -0.03398665f, -0.03577136f, -0.07252573f, 0.03343806f, 
    -0.00437753f, 0.05605293f, 0.00549051f, -0.02713807f, 0.20844498f, 0.49879101f, 0.28996637f, 0.12924655f, 
    -0.10604206f, -0.13382024f, 0.21744293f, -0.07488065f, 0.15011804f, 0.14156693f, -0.04554960f, 0.18184245f, 
    0.08330635f, 0.07896879f, -0.12703173f, -0.19221108f, -0.16838054f, -0.04344062f, -0.04851540f, -0.10363613f, 
    0.09248434f, 0.16060781f, 0.13602678f, -0.09757390f, -0.22734833f, 0.22434679f, -0.02967128f, -0.00197352f, 
    0.22240606f, 0.03829614f, -0.14514330f, 0.25695357f, -0.00997940f, -0.12502007f, -0.08970395f, 0.02280126f, 
    -0.30992359f, -0.22530021f, 0.03514709f, 0.01887542f, -0.00190512f, 0.01366087f, 0.10566708f, 0.05158597f, 
    0.06103601f, 0.00319923f, -0.04567520f, 0.07023685f, 0.01666047f, 0.10495663f, 0.04370381f, 0.06694190f, 
    -0.04049581f, 0.00194105f, 0.04665950f, -0.09524555f, 0.14290254f, 0.06846365f, 0.14874801f, 0.12810002f, 
    -0.11472829f, -0.13967210f, -0.03667673f, 0.11999510f, -0.23844999f, -0.22078274f, -0.10698926f, -0.03930574f, 
    -0.02420589f, 0.01685287f, 0.01161955f, -0.02956502f, -0.10387161f, -0.34838301f, -0.38480380f, 0.12120575f, 
    0.01845357f, 0.00318742f, 0.10965633f, -0.02781183f, 0.00917497f, 0.02072700f, -0.11278953f, -0.16052085f, 
    0.06064298f, 0.09431261f, 0.27569035f, 0.07500343f, 0.05210127f, 0.19411872f, 0.07108293f, 0.10498577f, 
    -0.10353525f, 0.01546335f, 0.04986062f, -0.04661421f, -0.14289470f, 0.08277825f, -0.06848412f, 0.03987551f, 
    0.10436630f, 0.00159891f, 0.07616809f, -0.00253655f, -0.11898932f, -0.05338165f, -0.11295516f, -0.03884495f, 
    -0.26488096f, -0.01296940f, 0.09195668f, -0.11134697f, -0.00848738f, 0.00223757f, -0.11844914f, 0.03425060f, 
    -0.17008628f, 0.04669954f, -0.05507780f, -0.07390373f, -0.02427738f, -0.05937462f, -0.00649939f, -0.22692347f, 
    -0.11784039f, 0.05937236f, 0.04332569f, -0.02503555f, -0.03928990f, 0.08744514f, -0.09458993f, 0.06513633f, 
    -0.51731622f, 0.05143255f, -0.03780442f, 0.21901385f, 0.02361924f, 0.12385647f, -0.07275445f, 0.10544903f, 
    -0.08986018f, 0.00453156f, -0.10171229f, -0.08814115f, -0.34702379f, 0.11751691f, 0.09761421f, 0.27406597f, 
    0.11443793f, 0.17305656f, -0.15394728f, -0.05979458f, -0.04415043f, 0.16586843f, 0.12250800f, 0.06208085f, 
    -0.05389956f, 0.01069084f, 0.31502426f, 0.00897609f, -0.00532929f, -0.03044411f, 0.13542756f, 0.17149214f, 
    -0.13238347f, -0.02764276f, -0.16160560f, -0.10292806f, 0.06670758f, -0.00748290f, -0.14935759f, -0.07429017f, 
    -0.05787195f, 0.01022706f, 0.01992223f, -0.01598010f, 0.00130187f, 0.04117952f, -0.01485763f, -0.02300681f, 
    0.19520120f, -0.05693661f, -0.01472120f, -0.07847304f, 0.11473154f, 0.17263101f, 0.07581735f, 0.11446247f, 
    -0.12772152f, -0.05117856f, -0.02195743f, -0.13076241f, 0.01383586f, -0.26324138f, -0.25229722f, -0.20242518f, 
    -0.00670827f, 0.07697665f, 0.00236874f, 0.12207213f, 0.03991651f, 0.01327003f, 0.04460063f, 0.03268426f, 
    0.10853080f, -0.41893506f, -0.18741027f, 0.16919535f, -0.03643231f, -0.13827495f, 0.09340860f, 0.05842787f, 
    -0.01258869f, -0.20736825f, 0.09654026f, -0.13830228f, 0.16269457f, -0.29016945f, -0.01549872f, -0.17646953f, 
    0.12092204f, 0.02005458f, 0.08121024f, -0.00130555f, 0.13010736f, 0.17964785f, 0.09048648f, -0.01351016f, 
    0.23345362f, 0.18117341f, 0.03377679f, 0.06050433f, 0.19174229f, 0.11035417f, -0.00066000f, -0.04221503f, 
    -0.06394965f, -0.07784776f, -0.04485123f, -0.06495345f, -0.09465668f, -0.25432089f, -0.07446095f, -0.15395451f, 
    -0.07020438f, -0.09581232f, -0.14234585f, -0.08936062f, 0.12623960f, 0.00185349f, 0.05371523f, 0.04065003f, 
    0.11659541f, 0.01617646f, 0.08422164f, -0.21231245f, 0.20260879f, 0.07221036f, 0.00968704f, 0.16176182f, 
    -0.01644031f, 0.05242585f, 0.02090556f, 0.14463635f, 0.16824198f, 0.11063596f, 0.49789599f, -0.22965352f, 
    0.18977417f, 0.02035467f, -0.13132925f, 0.04392867f, -0.00490119f, -0.06032115f, -0.07223423f, 0.19613281f, 
    -0.03690868f, 0.18389463f, -0.18921316f, 0.10501352f, 0.05309097f, 0.05769422f, 0.12237563f, 0.05410666f, 
    -0.04193282f, -0.01248670f, -0.00987411f, -0.08405645f, -0.06944449f, -0.50103778f, 0.04566227f, -0.02324320f, 
    -0.14568105f, 0.06794126f, 0.09531013f, 0.03058356f, 0.13929032f, 0.04208190f, 0.17035399f, 0.08858348f, 
    0.00635090f, 0.04072292f, -0.04889532f, 0.01859529f, 0.11500168f, -0.08474701f, -0.11480805f, -0.00332552f, 
    0.04559551f, -0.06509817f, -0.09428873f, 0.20052685f, -0.10567731f, -0.32502332f, 0.00973810f, 0.17030334f, 
    0.07329366f, -0.01938037f, -0.24180835f, -0.03793159f, -0.03835326f, -0.01672542f, 0.07070629f, -0.20624456f, 
    0.36532855f, -0.07905059f, 0.22130725f, -0.17231499f, 0.16664892f, 0.06224359f, 0.13249724f, 0.20719907f, 
    0.02581438f, 0.15052500f, 0.00681021f, 0.16204855f, 0.06544926f, 0.17978255f, -0.10035431f, -0.38873237f, 
    -0.12745216f, -0.05213845f, 0.07841021f, 0.01817388f, 0.09130453f, -0.00790434f, -0.01834796f, -0.01916670f, 
    0.03866877f, -0.15546982f, -0.30524790f, -0.06650394f, -0.07908979f, 0.17691720f, -0.25463256f, 0.04692364f, 
    0.14358456f, -0.01458305f, 0.12404156f, -0.04987354f, 0.15240896f, -0.37693039f, -0.23135085f, -0.05150260f, 
    -0.08952897f, -0.02919008f, 0.02989976f, 0.18466786f, -0.00672877f, 0.01218158f, -0.13227674f, -0.18786541f, 
    0.22460815f, -0.18457454f, 0.05699107f, 0.01941571f, 0.08566436f, 0.07194784f, 0.13704118f, -0.24383320f, 
    -0.05650913f, -0.05320062f, -0.13943759f, -0.13401234f, -0.57602936f, -0.39696902f, 0.14510806f, 0.06239752f, 
    0.12466451f, 0.11406168f, 0.04049226f, 0.10731491f, -0.12237079f, -0.15743557f, 0.07469750f, 0.00168467f, 
    -0.11985915f, 0.02052548f, -0.02451060f, -0.08559754f, -0.08250987f, -0.05914817f, -0.04181568f, -0.04328161f, 
    0.03746130f, 0.16991141f, -0.15644917f, 0.08964492f, 0.12210912f, 0.02143824f, -0.06105284f, -0.02979637f, 
    0.15885907f, 0.05964055f, 0.11347331f, -0.25218126f, -0.12661184f, 0.01406935f, 0.07023341f, 0.08029298f, 
    -0.09899037f, -0.20184158f, -0.12476862f, -0.06505673f, -0.03483972f, -0.00462691f, -0.01764881f, 0.24151678f, 
    0.04211152f, -0.08481391f, -0.01927993f, 0.01437890f, -0.07089940f, -0.01413502f, -0.01592165f, -0.10321260f, 
    0.13596827f, 0.08823659f, -0.06840749f, -0.02324079f, -0.04146121f, 0.10192297f, 0.06553831f, 0.08454776f, 
    0.17656972f, -0.08430136f, -0.18491854f, 0.14249294f, 0.11073297f, 0.04250170f, 0.02904490f, 0.03744562f, 
    0.03399349f, -0.01334770f, 0.01509833f, -0.09997562f, 0.16649430f, 0.12711394f, -0.11219022f, -0.12539867f, 
    -0.01629308f, -0.26359493f, 0.09004412f, -0.16479652f, 0.00559253f, 0.06436502f, 0.02501318f, -0.03717700f, 
    0.00231888f, -0.04799391f, -0.05624226f, 0.11267929f, -0.07958849f, -0.08624062f, 0.03791909f, -0.02369821f, 
    0.06702531f, 0.11275853f, -0.10414851f, 0.07659581f, 0.11911551f, 0.19152479f, -0.14533013f, -0.01406751f, 
    0.08370053f, 0.04850888f, 0.00361714f, 0.00653039f, -0.03732830f, 0.00466753f, -0.06094741f, 0.05621484f, 
    0.14220908f, 0.09476728f, 0.29370359f, 0.10829663f, -0.05701923f, -0.07054208f, -0.04177569f, 0.07251006f, 
    0.10932611f, -0.02330843f, -0.12718472f, -0.01054932f, 0.07926956f, 0.10942540f, 0.14164844f, 0.06653487f, 
    -0.04394083f, 0.00946074f, -0.00208133f, -0.06546081f, -0.03503559f, 0.07984150f, -0.12625960f, 0.15362513f, 
    0.45713878f, 0.07188922f, -0.13100106f, 0.19063495f, -0.14608018f, 0.00796027f, 0.12851456f, -0.08803692f, 
    0.01300928f, -0.04495042f, 0.01123957f, -0.04304431f, 0.36207482f, -0.05453250f, -0.26829901f, -0.09280804f, 
    -0.16958714f, 0.12934068f, 0.11570455f, 0.09624849f, 0.06042916f, 0.18178718f, 0.05462531f, -0.02960313f, 
    0.40341944f, 0.15873997f, 0.16990149f, 0.02163012f, 0.09181861f, -0.06895352f, -0.09168051f, -0.23889378f, 
    -0.07953568f, 0.08592746f, -0.15382946f, 0.00324744f, -0.09944980f, 0.25791451f, 0.02704427f, 0.09763153f, 
    -0.04119295f, -0.08934516f, -0.02100309f, 0.10003147f, 0.07764011f, 0.04721365f, -0.05678140f, 0.02126567f, 
    -0.11956032f, -0.18447757f, 0.06754507f, -0.17195551f, 0.13525175f, 0.08914715f, 0.10814042f, -0.00171232f, 
    -0.03458365f, 0.04262780f, 0.03923534f, -0.04975625f, 0.39910820f, 0.25950482f, -0.15473200f, 0.22887363f, 
    0.09376889f, 0.09617855f, 0.09402680f, 0.26720211f, 0.10660462f, 0.04633257f, -0.03752232f, 0.12316208f, 
    -0.15747513f, -0.06319556f, -0.26933339f, 0.07748714f, -0.08907150f, -0.01718645f, -0.02184538f, 0.08213181f, 
    0.07715479f, 0.00971231f, -0.00329681f, -0.03994180f, 0.10953088f, 0.01067295f, -0.14634222f, 0.10719855f, 
    -0.02216269f, -0.03944051f, 0.07348157f, -0.11318514f, -0.01253504f, 0.12119858f, -0.01193587f, 0.02709205f, 
    -0.09255307f, -0.13460901f, -0.29882011f, -0.20896560f, 0.06590424f, 0.14528300f, -0.03394212f, -0.23886256f, 
    0.02861054f, 0.02096913f, -0.08657467f, -0.05478542f, -0.07133325f, -0.08633632f, -0.01182099f, -0.04471257f, 
    -0.11996907f, -0.05109827f, -0.00488883f, 0.01187768f, 0.10797802f, 0.03205369f, 0.08999077f, 0.12726873f, 
    -0.12809467f, -0.18244685f, -0.04975017f, -0.16666423f, 0.18427715f, 0.04085099f, -0.00889628f, -0.01315967f, 
    0.02210127f, -0.13678457f, -0.02684636f, 0.00168709f, 0.14568290f, -0.23179583f, -0.06153970f, -0.12110732f, 
    0.21370362f, -0.05721403f, 0.01364215f, 0.16357774f, -0.04534405f, -0.03825513f, -0.06505932f, 0.04413262f, 
    -0.28469563f, -0.09755299f, -0.03680513f, -0.11072568f, 0.11595248f, 0.01514121f, -0.17444967f, -0.17425448f, 
    0.10595400f, -0.05033243f, 0.00434250f, -0.03214261f, 0.05501934f, -0.15707514f, -0.06072886f, 0.14384094f, 
    -0.07491671f, 0.04450957f, 0.02503137f, 0.01890828f, 0.01120681f, -0.05034960f, 0.06170240f, -0.03160828f, 
    -0.04620254f, 0.04144530f, -0.22719389f, -0.15546481f, -0.05544138f, -0.07473714f, -0.06470823f, -0.07325871f, 
    -0.06643458f, 0.04281706f, 0.08713380f, 0.07430342f, -0.08397781f, 0.08107472f, -0.04761210f, -0.13408923f, 
    -0.15638205f, -0.19750677f, -0.08316314f, -0.05346300f, 0.06938582f, -0.04441198f, 0.11438093f, -0.01394172f, 
    -0.00272557f, 0.04460993f, 0.02887424f, 0.24891619f, 0.14279754f, -0.09029109f, 0.22945204f, 0.01057151f, 
    0.03164361f, -0.00744523f, -0.03752212f, 0.09408788f, 0.04814528f, 0.12594934f, 0.13664241f, -0.14184433f, 
    -0.02520034f, -0.07710923f, -0.11861663f, -0.00855853f, -0.00249465f, -0.00100181f, 0.07063019f, -0.01559371f, 
    -0.29297698f, -0.06667063f, -0.16116947f, -0.08726192f, -0.21149974f, 0.07496012f, -0.11312784f, 0.12617585f, 
    0.07341170f, -0.08293547f, 0.04891266f, 0.04039871f, -0.27620888f, -0.29176328f, 0.09575461f, -0.08164181f, 
    -0.19671708f, -0.14895417f, -0.09069123f, -0.06830941f, -0.11632079f, -0.07228185f, -0.06505497f, -0.14455931f, 
    0.31009531f, -0.09304848f, 0.14408986f, -0.04474597f, 0.16420266f, 0.01804059f, 0.00747131f, 0.16180031f, 
    -0.12297405f, -0.02712343f, 0.05867208f, 0.08245850f, 0.09224365f, -0.17274615f, -0.16472545f, -0.10564011f, 
    0.00937824f, -0.00394373f, 0.06096439f, 0.09331754f, 0.03346195f, 0.09356187f, 0.00326043f, 0.03060459f, 
    0.09652074f, -0.41477501f, -0.19654100f, 0.29369453f, -0.10448127f, 0.01715006f, -0.02726527f, 0.23572458f, 
    0.04012905f, -0.00506203f, 0.03515330f, -0.01814404f, 0.13692369f, -0.17186144f, -0.08633842f, -0.13806261f, 
    0.21713078f, -0.07705431f, 0.07797158f, -0.23928668f, 0.10702406f, 0.15939875f, -0.04620803f, -0.09045607f, 
    0.31605417f, 0.16432486f, -0.06539433f, 0.03385261f, 0.25470573f, 0.24926542f, 0.05518871f, 0.01994653f, 
    -0.14110830f, -0.00920289f, -0.09891404f, -0.01339946f, 0.04814071f, -0.39765328f, -0.04109647f, -0.18262868f, 
    0.06602076f, -0.01963077f, -0.22727953f, -0.09047120f, -0.01571745f, -0.06897377f, 0.10342436f, 0.09819041f, 
    0.17104103f, 0.08535559f, 0.07343666f, -0.12682366f, 0.24785186f, 0.08119784f, 0.04457279f, 0.16795072f, 
    0.02026456f, 0.04619725f, 0.02905541f, 0.10843319f, 0.48211133f, 0.17707619f, 0.47684923f, -0.35037321f, 
    0.17927599f, 0.02434680f, -0.02332728f, 0.02075931f, 0.10369454f, -0.15644608f, -0.01174218f, 0.11277117f, 
    0.05211060f, 0.24688302f, -0.13145137f, 0.13043869f, 0.12780827f, -0.00683694f, 0.09971446f, 0.13574672f, 
    -0.05599684f, 0.11268151f, 0.01673464f, -0.15662888f, -0.02725038f, -0.49284023f, -0.02725662f, 0.02156550f, 
    -0.10063191f, 0.04051921f, -0.01931922f, -0.00485745f, 0.08481643f, 0.07761085f, -0.05971246f, -0.02851916f, 
    0.03991651f, 0.15580359f, -0.11524643f, 0.09995159f, 0.02099004f, -0.19042718f, -0.07842902f, -0.05099655f, 
    -0.03683925f, 0.10120448f, -0.05981157f, 0.20200120f, -0.07078899f, -0.39212602f, -0.08727443f, 0.07228060f, 
    -0.00696496f, -0.10223834f, -0.25807044f, -0.10430107f, -0.08254358f, 0.00532198f, 0.23889071f, -0.11826680f, 
    0.13826227f, 0.13049844f, 0.01704798f, -0.09966129f, 0.10764581f, -0.06935608f, 0.03612282f, 0.06671660f, 
    -0.00200035f, 0.11041205f, -0.06704823f, 0.10518090f, -0.29902929f, 0.45646685f, -0.21723853f, -0.30375946f, 
    -0.03033114f, 0.09261052f, 0.12330429f, -0.11597151f, -0.06782385f, -0.06894718f, 0.05686083f, 0.04596623f, 
    -0.21088211f, -0.09308338f, -0.38346207f, -0.11819322f, -0.23251455f, 0.17681788f, -0.27538368f, -0.02709612f, 
    0.16217540f, -0.06572238f, 0.06350990f, 0.13418283f, 0.34821203f, -0.34777102f, -0.20681289f, -0.19392887f, 
    -0.31012952f, -0.10075922f, -0.10123491f, 0.00881727f, 0.08414190f, -0.00318215f, -0.23197316f, -0.29509968f, 
    0.17743887f, -0.22824316f, 0.35058746f, -0.17478453f, 0.08779500f, 0.04071629f, 0.30753911f, -0.03036743f, 
    0.03376288f, 0.00930519f, 0.26256791f, 0.02073658f, 0.08689288f, -0.30227214f, 0.17050996f, 0.22831325f, 
    0.26968440f, 0.15286207f, -0.08886708f, 0.02032619f, 0.08759655f, -0.00718359f, -0.12435843f, 0.10567503f, 
    -0.05453432f, -0.06852484f, -0.04379633f, 0.08800327f, 0.01090768f, -0.03378768f, 0.03539540f, 0.21633834f, 
    -0.00974998f, 0.01410786f, -0.17581758f, 0.05084341f, 0.11086140f, 0.05464584f, 0.05812864f, 0.07810840f, 
    -0.13906610f, 0.00979741f, 0.05237689f, -0.16224900f, -0.11426618f, 0.11607808f, 0.02249098f, 0.13863248f, 
    0.00067778f, -0.17927285f, -0.19029923f, -0.23015532f, 0.05302216f, 0.04532485f, -0.12766498f, -0.21260923f, 
    -0.05287343f, -0.08350524f, -0.06493720f, 0.08958372f, -0.28268102f, -0.13288477f, -0.13537262f, 0.09942841f, 
    -0.05041233f, -0.00457804f, -0.00691970f, 0.12092450f, 0.08287509f, 0.06865410f, 0.08240655f, 0.10749308f, 
    0.06167668f, -0.06982083f, 0.03425232f, -0.10084826f, 0.24715081f, 0.07194385f, 0.09916144f, -0.10753486f, 
    -0.04806092f, 0.03658867f, -0.12690966f, -0.00672487f, 0.17755182f, 0.13128674f, -0.01424664f, -0.18398480f, 
    -0.02120782f, 0.00851407f, 0.03980517f, 0.21692313f, 0.12804985f, -0.12385303f, 0.02536421f, -0.13278528f, 
    0.32110134f, -0.10528589f, -0.02071664f, -0.02609090f, -0.12521131f, -0.02840143f, 0.06738327f, -0.18031934f, 
    0.01151004f, -0.02384185f, 0.07783587f, 0.02529875f, -0.03794484f, 0.10596417f, -0.21922237f, 0.17754680f, 
    0.00969965f, -0.01725103f, -0.13811792f, 0.11522911f, -0.02118206f, -0.07636519f, 0.05159848f, -0.07673298f, 
    0.18586990f, 0.13578787f, 0.03289234f, -0.08374640f, -0.05675733f, -0.19313122f, -0.10637017f, -0.00977289f, 
    0.07016540f, -0.01152211f, 0.00059443f, 0.02948174f, 0.04604720f, 0.15584050f, -0.01841118f, 0.11785771f, 
    -0.04704632f, -0.03038300f, -0.04365900f, 0.01283248f, -0.13330494f, -0.00184676f, 0.05682958f, 0.10628150f, 
    0.10596236f, 0.48177966f, -0.05972591f, 0.30970034f, 0.10043426f, -0.17933555f, 0.08817932f, -0.04045753f, 
    0.04076816f, 0.24538048f, -0.06197093f, -0.00000525f, -0.12251745f, -0.13664447f, -0.16495271f, -0.09224878f, 
    -0.11262524f, -0.09192778f, 0.30513310f, 0.01067616f, 0.03313331f, 0.13993421f, 0.14506637f, 0.07110821f, 
    0.29500172f, -0.09324799f, 0.21210788f, -0.00412265f, -0.05358838f, 0.13270737f, -0.33170485f, 0.13429572f, 
    -0.11243624f, 0.05678666f, 0.14282347f, -0.00866046f, -0.12186687f, 0.10167806f, 0.06299615f, 0.02650620f, 
    0.02510138f, -0.04669579f, 0.06018684f, 0.08025917f, -0.08613150f, 0.00389566f, -0.03703987f, -0.08747196f, 
    0.17961235f, 0.08698351f, 0.21859203f, 0.16983020f, 0.13346991f, 0.11771669f, 0.35434404f, -0.01600229f, 
    0.09789495f, 0.11937584f, 0.03625070f, -0.00710178f, -0.14425412f, -0.32275900f, 0.23025681f, 0.02293546f, 
    -0.06306875f, 0.07024911f, -0.17185855f, -0.04460508f, -0.01050598f, 0.06877144f, 0.18232749f, 0.12606941f, 
    -0.24512911f, -0.15591712f, 0.04305674f, -0.13507107f, 0.07327193f, 0.03063508f, -0.22461745f, -0.18806686f, 
    -0.04982251f, -0.08848151f, 0.11505684f, 0.13777162f, -0.15116395f, 0.11252527f, -0.25168476f, -0.02132980f, 
    0.00531675f, 0.12095845f, 0.05102629f, -0.18241543f, 0.03051688f, -0.08350993f, 0.11365604f, 0.03305809f, 
    0.22837521f, 0.17285052f, 0.17488672f, 0.22843288f, -0.00749564f, 0.00200317f, -0.06036086f, 0.14294232f, 
    0.05330524f, 0.06429808f, 0.09514090f, 0.08697436f, -0.13950749f, -0.41191846f, -0.16476823f, -0.00791708f, 
    0.05814689f, -0.00546764f, 0.06812029f, 0.03832780f, 0.09396522f, 0.04551881f, 0.06082143f, -0.14971103f, 
    0.31182310f, 0.40127826f, 0.29571497f, 0.30782452f, -0.01569159f, -0.01213974f, 0.10053784f, 0.06431427f, 
    -0.07036564f, -0.07635156f, -0.02130702f, -0.10196096f, 0.04323633f, 0.19425188f, 0.09613062f, -0.09959017f, 
    -0.06576962f, -0.17457052f, 0.15454932f, 0.02428645f, 0.10980686f, -0.06958736f, 0.01942803f, -0.08437424f, 
    0.15265992f, -0.13427989f, -0.22603972f, -0.09715736f, -0.22638904f, 0.07009451f, 0.20072313f, 0.09512459f, 
    0.01208402f, 0.03390293f, -0.01909126f, 0.19794101f, 0.00713599f, 0.11260401f, -0.21004087f, -0.17191909f, 
    0.12008837f, 0.04703972f, -0.02355938f, 0.14106791f, 0.04547530f, 0.02944483f, -0.20572914f, 0.06118966f, 
    -0.15671897f, -0.18642032f, -0.16020241f, -0.17682974f, -0.03230010f, -0.04365198f, 0.04209451f, -0.05778551f, 
    0.02076983f, -0.00012530f, -0.17744996f, 0.02616119f, -0.22930023f, -0.25823429f, -0.32779911f, -0.25952834f, 
    -0.04813984f, -0.10629655f, -0.01202574f, -0.03810777f, -0.05654190f, 0.06594758f, -0.00746836f, 0.05143372f, 
    0.36062452f, -0.07391630f, 0.16173849f, -0.13463345f, -0.20646508f, -0.09968021f, 0.15155421f, -0.15333831f, 
    0.03109741f, -0.08594845f, 0.01870511f, -0.02411362f, 0.17248462f, -0.13902140f, -0.25128171f, 0.07083283f, 
    -0.16624136f, -0.11377072f, 0.12917773f, 0.12114082f, 0.07990313f, -0.09455985f, 0.04028296f, -0.08926866f, 
    0.11446245f, -0.47574180f, -0.06558871f, 0.00464349f, 0.23284547f, -0.06459536f, -0.04777670f, -0.20277883f, 
    -0.15351048f, -0.05578835f, -0.05245293f, 0.07063089f, -0.27756032f, -0.09442064f, -0.43641523f, -0.30101722f, 
    0.16861610f, -0.06241605f, -0.26716378f, -0.14001819f, 0.01952847f, -0.09365252f, 0.03559738f, 0.11087503f, 
    -0.00586886f, 0.00472324f, -0.03625914f, 0.01701903f, -0.04135689f, -0.06959234f, -0.04307430f, -0.03766181f, 
    0.04135876f, -0.04401732f, 0.03955525f, -0.04023566f, -0.01083967f, -0.03358447f, 0.02531434f, -0.01314642f, 
    -0.04374654f, -0.01030287f, 0.00011013f, 0.03778351f, -0.01138771f, 0.00019015f, -0.03084784f, -0.08019967f, 
    -0.01135513f, 0.05781613f, -0.00051695f, -0.05734607f, -0.04797164f, 0.04822388f, -0.01356326f, 0.01754721f, 
    0.00249743f, -0.01452282f, -0.06035067f, 0.02320812f, -0.03840549f, -0.04272283f, 0.01983644f, 0.01468185f, 
    0.01715038f, 0.04977877f, -0.07859263f, 0.05696438f, -0.01761323f, -0.02833732f, 0.04511488f, 0.00371119f, 
    -0.03625064f, -0.06962745f, -0.07613332f, -0.06478446f, 0.03265908f, 0.01142153f, -0.07575966f, -0.02969187f, 
    -0.04250264f, 0.03799535f, -0.07415000f, -0.05511960f, -0.00780080f, 0.02081161f, -0.01251973f, -0.01978032f, 
    -0.02783748f, 0.01110096f, -0.07630308f, 0.02192752f, 0.02131490f, -0.07361221f, -0.00138872f, -0.00506526f, 
    0.05442803f, -0.05715526f, 0.03050178f, 0.02461670f, -0.06546141f, 0.03947676f, 0.05157947f, -0.04099280f, 
    0.00966116f, -0.01336279f, -0.01822373f, -0.03281026f, -0.00620394f, -0.07904778f, 0.00034176f, -0.00750211f, 
    -0.06599091f, -0.06185874f, 0.01763353f, -0.02741448f, 0.04584755f, -0.03156621f, -0.01707496f, -0.04578971f, 
    -0.06482260f, 0.00968292f, 0.03854724f, 0.02701697f, -0.07078499f, -0.07875171f, -0.04984509f, 0.04452055f, 
    -0.04513628f, 0.01507209f, -0.04437765f, -0.04520717f, -0.07906324f, -0.04361397f, -0.02789126f, 0.01764171f, 
    0.02667868f, 0.00237350f, 0.01026419f, -0.02805743f, 0.02921771f, 0.01950450f, 0.01485112f, 0.05872831f, 
    -0.01226833f, 0.04606035f, 0.01339498f, -0.02450961f, -0.06868558f, 0.05357042f, -0.07812182f, 0.05077271f, 
    -0.06383907f, 0.02627669f, 0.05708176f, 0.03950842f, -0.05708140f, 0.04199862f, 0.03259563f, -0.05674683f, 
    -0.04365011f, 0.03647364f, 0.03096704f, -0.02596372f, -0.00754435f, -0.00989925f, -0.03673124f, 0.00667842f, 
    0.01752817f, 0.01038775f, 0.01827659f, 0.05468280f, -0.05329234f, -0.06275112f, -0.05971933f, -0.04933242f, 
    -0.00521655f, -0.06746039f, -0.01516873f, -0.04469677f, 0.05528180f, -0.06902256f, -0.00988575f, -0.06619769f, 
    -0.03925603f, -0.07201020f, -0.06321019f, -0.02464444f, 0.05329727f, 0.04768605f, -0.07186151f, -0.07048957f, 
    -0.07633415f, -0.04271468f, 0.04881542f, 0.03980879f, 0.00918170f, 0.04230431f, -0.06457609f, 0.01466568f, 
    -0.04247275f, -0.06087233f, 0.04227381f, -0.01542504f, -0.05378029f, -0.05949854f, -0.03753009f, -0.05529099f, 
    -0.03180915f, 0.01850764f, 0.04988317f, 0.05870959f, -0.07139295f, -0.04902136f, 0.03850793f, 0.04283750f, 
    0.23649323f, 0.06814511f, -0.13029818f, -0.11809624f, 0.05739100f, 0.04570330f, 0.01589033f, 0.08044228f, 
    -0.17557366f, -0.05451639f, -0.02021633f, -0.03348833f, 0.13657685f, -0.60843480f, -0.19664557f, -0.22173798f, 
    0.04529857f, -0.04010176f, -0.09041588f, -0.05868593f, -0.07473656f, 0.01118032f, -0.01260937f, 0.10478599f, 
    0.12625100f, -0.09166827f, -0.04497037f, 0.00094491f, -0.09173360f, -0.10197031f, -0.00648891f, -0.03209333f, 
    -0.01918071f, -0.21523075f, 0.03003963f, -0.06118764f, -0.20509674f, -0.16737403f, 0.28362176f, -0.17021775f, 
    -0.05732990f, 0.08724552f, -0.03855176f, 0.16950040f, -0.08993237f, 0.03675308f, 0.06907047f, -0.05274041f, 
    0.31943077f, 0.23188618f, 0.29047328f, 0.36689669f, 0.15985906f, -0.02158830f, 0.05374329f, 0.23555322f, 
    -0.04973779f, 0.03067056f, -0.06052463f, -0.11553546f, -0.10795909f, 0.00200360f, -0.18103257f, -0.32849562f, 
    -0.02297108f, 0.05237599f, 0.00744470f, -0.14874583f, 0.02823433f, -0.14443462f, -0.02636629f, 0.04066311f, 
    0.08725702f, 0.26085120f, 0.07600180f, 0.09630053f, 0.19049150f, 0.17440279f, 0.18136199f, 0.11466364f, 
    -0.01258446f, -0.05338670f, 0.02205710f, 0.10267422f, -0.30219856f, 0.43461272f, 0.66124666f, -0.14883198f, 
    0.07458227f, 0.18268403f, 0.14137056f, 0.08829743f, 0.12942325f, 0.26224533f, -0.00336985f, 0.16199930f, 
    0.17124902f, 0.08354647f, -0.01947453f, 0.19477552f, 0.06774499f, 0.08892708f, 0.04975978f, 0.21971397f, 
    -0.04203835f, 0.03138923f, 0.10236523f, -0.02025474f, -0.19398408f, -0.22717266f, 0.15895775f, -0.13697083f, 
    0.13663591f, 0.13974877f, 0.05017827f, -0.08307921f, 0.16001073f, -0.00360715f, 0.23326780f, 0.05926937f, 
    -0.03471034f, -0.09405737f, 0.06164740f, 0.21545947f, -0.09082153f, 0.03498464f, -0.12762678f, -0.10747177f, 
    -0.03433906f, -0.07368610f, -0.17631218f, 0.09597526f, -0.13512129f, -0.30942670f, -0.09404015f, 0.11128403f, 
    0.10522747f, 0.07904860f, -0.20333473f, -0.12952471f, -0.11283389f, 0.03052776f, 0.01054826f, 0.02004335f, 
    0.07723132f, 0.20135505f, 0.11980544f, -0.06371300f, 0.21940857f, 0.21718043f, -0.05177764f, 0.13203347f, 
    0.05574321f, 0.03540240f, -0.17723547f, 0.10954159f, 0.20341566f, -0.08113796f, 0.01805300f, -0.00648789f, 
    -0.10906456f, -0.07711575f, 0.19364278f, -0.17607433f, 0.11294297f, 0.11300134f, 0.01950376f, 0.02573200f, 
    -0.12516236f, -0.11089916f, -0.23090397f, 0.14422457f, -0.10380602f, -0.11870263f, 0.10433917f, 0.06202627f, 
    0.12214019f, -0.04507001f, 0.03201320f, 0.03770889f, 0.09957736f, 0.07837344f, -0.49887595f, -0.05031468f, 
    -0.08788896f, 0.02670905f, 0.15473354f, 0.01952626f, 0.07849156f, -0.05681803f, 0.03824528f, -0.04408175f, 
    0.06140404f, -0.02787363f, -0.07625322f, 0.01872643f, 0.02443318f, 0.00303564f, 0.01599396f, 0.05486517f, 
    -0.00822167f, -0.04581805f, -0.07244435f, -0.03473090f, -0.00843307f, -0.04395491f, 0.00155219f, -0.07749578f, 
    -0.06701549f, 0.05430984f, -0.02655287f, -0.03988006f, -0.00747873f, -0.01431993f, -0.01299101f, -0.07632236f, 
    -0.00060201f, -0.01172081f, 0.00502242f, 0.04470791f, 0.00905867f, 0.00111291f, -0.03019429f, -0.01955119f, 
    0.06548461f, -0.00739733f, -0.04306546f, -0.01697729f, -0.06393493f, 0.02466901f, -0.00475011f, -0.00924257f, 
    0.02146064f, 0.02790911f, -0.00406694f, 0.03462307f, -0.00586844f, -0.05581298f, 0.01007330f, 0.02030804f, 
    -0.02095569f, -0.04588379f, 0.06007663f, -0.00070693f, 0.00139118f, -0.00241917f, -0.00883056f, -0.00045025f, 
    -0.01316289f, -0.01860082f, -0.01846162f, 0.03740002f, -0.06475618f, -0.00748432f, -0.06132995f, -0.04550797f, 
    -0.05468659f, -0.06144437f, -0.02907065f, -0.03259973f, 0.02798210f, -0.00043296f, -0.03146264f, 0.04312333f, 
    0.01088824f, -0.05702878f, 0.02079432f, 0.01082911f, 0.06394819f, 0.05411796f, -0.00101307f, -0.02990407f, 
    0.00725211f, -0.06761730f, -0.01575527f, 0.04405607f, -0.06595434f, -0.04491832f, -0.06076283f, -0.05539239f, 
    0.05933415f, 0.01441661f, 0.00129374f, 0.02150771f, -0.07090266f, -0.04081520f, 0.01994018f, 0.04890694f, 
    -0.04404613f, 0.02416722f, -0.07193724f, -0.03338056f, -0.02858743f, -0.06896862f, -0.05053731f, -0.05679477f, 
    0.06358469f, 0.01395224f, 0.00081915f, -0.05391946f, -0.01653486f, 0.00766643f, -0.03560546f, -0.01791855f, 
    0.05622403f, 0.04872837f, -0.05354910f, -0.03840938f, 0.00407091f, -0.05603687f, -0.03148612f, 0.04189981f, 
    0.03055577f, 0.03099176f, -0.02714583f, -0.03564643f, -0.00111971f, -0.00891872f, -0.05094400f, -0.05639626f, 
    0.01680782f, 0.01085448f, 0.01503140f, -0.01479977f, 0.02085857f, 0.02157366f, 0.02146334f, -0.03923924f, 
    -0.06975632f, -0.04803631f, -0.05324700f, -0.03169425f, 0.05410047f, 0.01400603f, 0.04567150f, -0.06220613f, 
    0.06377058f, 0.05080089f, 0.03462927f, -0.02420522f, -0.01819761f, -0.05071762f, 0.03457136f, 0.04369614f, 
    -0.01449302f, 0.02352998f, -0.07229111f, -0.05282014f, -0.06754507f, 0.03451333f, -0.06404378f, -0.02881453f, 
    -0.03673445f, -0.07792728f, 0.03569268f, -0.04463428f, 0.00282171f, -0.04236513f, -0.02222840f, 0.03159771f, 
    0.05176200f, 0.02979701f, -0.03330087f, -0.04838390f, -0.00179695f, -0.00278685f, -0.02065425f, -0.04880816f, 
    0.04222047f, 0.06345829f, -0.01316796f, 0.01720703f, -0.06615407f, 0.01180480f, 0.01664867f, 0.04072774f, 
    -0.06534360f, -0.04288934f, 0.04844669f, 0.06768376f, 0.06342223f, -0.05958348f, -0.01118141f, 0.01075792f, 
    -0.20686898f, -0.17780183f, -0.02473793f, 0.07438831f, 0.04629040f, 0.09046963f, -0.02963469f, 0.06029882f, 
    0.15711586f, 0.11058125f, 0.15015155f, 0.08397359f, -0.07978167f, 0.37084100f, 0.08773208f, 0.02253417f, 
    -0.23520026f, -0.10226582f, -0.08325386f, -0.16957469f, -0.01651862f, 0.03716195f, 0.08096516f, -0.06717388f, 
    0.12593880f, -0.24554878f, 0.00277067f, -0.10586215f, 0.04900296f, 0.06576865f, 0.03758842f, -0.03423277f, 
    0.22520910f, 0.22687970f, 0.27387863f, 0.25683224f, -0.06709385f, -0.07081795f, -0.00690897f, -0.30454320f, 
    0.00987474f, -0.00426792f, -0.01925056f, 0.07045634f, -0.17330775f, -0.18773155f, -0.25094959f, -0.18154465f, 
    0.09649861f, 0.16767044f, 0.17686413f, 0.21396777f, -0.05360964f, 0.01292672f, 0.14892508f, 0.33670503f, 
    0.09981743f, 0.00711607f, 0.03502788f, 0.04347144f, 0.39202791f, 0.14500037f, 0.01509492f, -0.05641912f, 
    0.04077235f, -0.15566140f, 0.12239572f, -0.00167705f, 0.09485275f, 0.08720431f, -0.22998475f, -0.14844319f, 
    -0.03211147f, -0.08137596f, 0.06886963f, 0.19616280f, -0.08715063f, -0.02141439f, 0.05366955f, 0.00951280f, 
    -0.08613619f, -0.07065912f, 0.07243344f, 0.00096428f, -0.23724119f, -0.20944235f, -0.02663898f, 0.12178553f, 
    0.02441474f, -0.01941864f, -0.05002961f, -0.12227570f, -0.11325285f, 0.05449701f, -0.11595067f, -0.16320674f, 
    0.03115285f, 0.26187870f, 0.02818825f, 0.24582539f, 0.10431886f, -0.07603266f, 0.10945543f, 0.00404218f, 
    -0.08265368f, -0.05457018f, -0.18367213f, -0.10473970f, 0.02216495f, 0.03576782f, -0.07822152f, -0.23057334f, 
    0.16225262f, 0.00384012f, 0.10433538f, -0.14269687f, -0.29347011f, -0.10970555f, -0.14610352f, -0.04239383f, 
    -0.01443775f, 0.08301750f, 0.06025745f, 0.01808624f, -0.03534995f, 0.15898646f, 0.00514160f, 0.24049422f, 
    -0.05632606f, 0.05970061f, 0.01455015f, -0.27288979f, 0.01996834f, -0.16598377f, 0.12080395f, 0.18624429f, 
    0.16167912f, 0.08475904f, -0.15066226f, -0.10818174f, -0.03977537f, -0.10941212f, -0.06850025f, 0.10005055f, 
    0.00190383f, -0.32370010f, 0.17331286f, -0.10992730f, 0.22980998f, 0.13099684f, 0.02890745f, 0.03698162f, 
    -0.00031138f, -0.02400864f, -0.00070059f, -0.04145795f, -0.09880358f, -0.10018480f, 0.15507938f, 0.18413351f, 
    -0.01345934f, 0.11727607f, -0.21391751f, -0.10934258f, 0.12515339f, -0.01339987f, 0.07284448f, 0.16022050f, 
    0.08756559f, 0.07225519f, 0.04096242f, -0.30306408f, 0.02385060f, 0.04555999f, 0.32165277f, -0.13042638f, 
    -0.09364647f, -0.12406696f, -0.33723128f, -0.11072210f, 0.24005565f, -0.13821909f, 0.03170235f, 0.14853850f, 
    0.22255474f, -0.05034730f, -0.09888679f, 0.02400137f, 0.00703516f, -0.11022796f, -0.06239516f, 0.05283229f, 
    -0.18941870f, 0.26719877f, -0.04009724f, -0.05066269f, 0.04481216f, -0.05939058f, -0.01043787f, -0.19368915f, 
    -0.00193711f, -0.08421712f, -0.22139986f, -0.12000988f, 0.10071949f, 0.02349670f, -0.21978493f, -0.49125665f, 
    0.04783748f, -0.15104541f, -0.06706131f, 0.15287036f, 0.05733535f, 0.04055803f, 0.03696277f, -0.14327843f, 
    0.10688266f, 0.20153292f, 0.00772960f, -0.01877060f, 0.03312529f, -0.02331694f, 0.00904504f, -0.13285506f, 
    0.05833722f, -0.12652868f, -0.10220349f, -0.06924723f, -0.07476757f, -0.16350602f, -0.01320550f, 0.10757221f, 
    -0.02772906f, 0.09989527f, -0.06589875f, -0.00032883f, -0.10425095f, -0.01372453f, -0.00600692f, 0.02020353f, 
    -0.08076167f, 0.09532379f, 0.01121302f, 0.01675481f, 0.15084049f, 0.09931964f, 0.01119509f, -0.15236311f, 
    0.01088344f, 0.09523425f, 0.11275008f, 0.14464793f, -0.11756352f, 0.11802491f, 0.04683953f, 0.09555358f, 
    -0.06939645f, -0.13608196f, -0.08432708f, -0.08857656f, 0.10454627f, 0.03275522f, 0.03614739f, 0.01428806f, 
    0.06430979f, 0.07985998f, 0.10081420f, 0.09357494f, 0.01331342f, 0.08999890f, 0.15966995f, 0.09282934f, 
    0.02964977f, 0.15081248f, 0.06162401f, 0.11789537f, -0.33444223f, -0.13950741f, -0.11071870f, -0.09583233f, 
    0.08323110f, 0.01970510f, 0.07971835f, 0.00426445f, -0.12872116f, 0.01003321f, -0.05184476f, 0.05420928f, 
    0.11708189f, -0.07482772f, 0.03034650f, -0.28908333f, -0.05098226f, 0.11283881f, -0.12471717f, 0.06209885f, 
    -0.04933557f, -0.12111850f, -0.01995986f, 0.07160897f, -0.08127571f, -0.04916662f, -0.11218502f, 0.00467395f, 
    -0.11020575f, -0.02920214f, -0.09934240f, -0.01698164f, -0.00021631f, -0.00454232f, 0.07642253f, 0.08968648f, 
    0.08763815f, -0.05293769f, 0.03859106f, 0.18365672f, -0.08723780f, -0.04588745f, -0.01893943f, -0.13371491f, 
    0.04544767f, -0.02628972f, -0.10003865f, 0.08866233f, 0.01657805f, -0.09422917f, -0.05921399f, 0.07807694f, 
    -0.00796283f, -0.03101271f, -0.14508832f, -0.07291765f, -0.06747880f, -0.00869104f, -0.02408750f, -0.12222419f, 
    0.06734134f, -0.00011869f, 0.03355801f, -0.03454034f, 0.12934881f, 0.09257548f, -0.07119969f, 0.15482423f, 
    0.13053881f, 0.02807718f, -0.00347822f, -0.00881890f, 0.07461542f, -0.17130885f, 0.31377801f, 0.10553066f, 
    -0.11876312f, -0.08647089f, -0.10449913f, 0.07630359f, 0.11407496f, 0.11418848f, -0.06519031f, -0.01687652f, 
    0.42476588f, 0.17291673f, -0.15296610f, 0.21095730f, -0.01772718f, -0.04605544f, -0.19700344f, 0.00494294f, 
    -0.05216691f, 0.02604910f, 0.02703124f, 0.07778747f, 0.09557104f, 0.03833593f, -0.19988848f, -0.02844145f, 
    -0.08747665f, -0.03686768f, -0.08685654f, -0.14994736f, -0.02864062f, -0.14415921f, 0.00408446f, -0.01502849f, 
    -0.06698858f, 0.14528982f, 0.06303480f, -0.04011146f, 0.03021071f, -0.00639560f, -0.21372929f, 0.06826992f, 
    0.02159197f, -0.00526009f, 0.14773467f, 0.19649126f, -0.03212187f, 0.22644354f, -0.21000351f, -0.19735754f, 
    0.03108069f, -0.02249419f, 0.05137439f, -0.03443088f, -0.00427610f, -0.01416466f, -0.00863411f, -0.09791967f, 
    0.09229249f, -0.24436618f, -0.17997707f, 0.16583559f, 0.00296418f, -0.11267165f, 0.04725803f, 0.00862265f, 
    -0.08042962f, 0.06561214f, 0.13215372f, -0.00202898f, 0.03297560f, -0.24568297f, 0.20287438f, -0.12170795f, 
    -0.00520058f, 0.10239617f, 0.00576796f, 0.19436665f, 0.05130680f, -0.02279687f, 0.02703421f, -0.15238510f, 
    0.20354818f, 0.22558615f, 0.19616421f, 0.07094000f, 0.10726550f, -0.00835607f, 0.00085938f, 0.06412181f, 
    0.09154329f, 0.14823106f, -0.00537796f, -0.05812131f, -0.04265736f, 0.02622380f, 0.09478352f, 0.11028619f, 
    -0.11167200f, -0.04298654f, 0.03083265f, -0.03157067f, 0.06202429f, 0.02721896f, -0.04637471f, 0.15436429f, 
    0.12604308f, 0.07797164f, 0.06866638f, -0.07362778f, -0.03763686f, 0.02131095f, -0.00697838f, 0.06722273f, 
    0.02682828f, 0.01710766f, 0.00386696f, 0.08675011f, -0.21380125f, 0.02322774f, 0.24119487f, 0.04999866f, 
    0.04040303f, 0.14396597f, 0.08636082f, -0.01579712f, -0.00699886f, 0.02556449f, -0.00838852f, 0.00789035f, 
    0.13720539f, 0.20194519f, -0.08779680f, -0.15029185f, 0.14890899f, 0.09844261f, -0.04230176f, 0.11870009f, 
    -0.08572404f, -0.09040412f, 0.07661239f, -0.10229167f, -0.20741944f, -0.06502180f, -0.03472503f, 0.06285927f, 
    -0.08310322f, 0.11928950f, 0.09601651f, -0.13082650f, 0.11796931f, -0.08356916f, -0.00873354f, -0.12091274f, 
    -0.04063486f, -0.15593113f, 0.18580940f, 0.06294519f, 0.07878699f, 0.09683445f, 0.00152461f, 0.03625124f, 
    -0.06674314f, -0.02006243f, 0.08455089f, -0.01199756f, -0.05829269f, -0.20094272f, -0.06554568f, 0.08341160f, 
    0.06620903f, 0.09743497f, -0.04564071f, 0.01403741f, 0.01583543f, 0.02984307f, 0.06438334f, 0.07436217f, 
    -0.07641435f, -0.25316730f, 0.10209400f, -0.15970311f, 0.03582371f, 0.15928683f, -0.00025338f, 0.13840067f, 
    -0.05836917f, -0.05687438f, 0.01227047f, -0.08636932f, -0.38944542f, -0.03962303f, 0.17923921f, 0.17655674f, 
    0.00823413f, -0.00048797f, -0.07783653f, -0.11007243f, 0.03646722f, 0.08800503f, -0.03167371f, 0.21403706f, 
    0.07813261f, 0.00052759f, 0.05677969f, 0.09320819f, -0.05405171f, 0.01504634f, 0.11499290f, 0.00919981f, 
    -0.05517178f, -0.07092372f, -0.05031890f, -0.01273533f, 0.25444764f, -0.24864808f, -0.12766482f, 0.03790665f, 
    -0.00749080f, 0.06886039f, 0.18451117f, 0.03386995f, 0.01496484f, 0.06530252f, -0.14351375f, -0.16674706f, 
    0.06471814f, 0.03135024f, -0.00193811f, -0.02345573f, -0.06129437f, 0.06993598f, 0.03888267f, 0.04380602f, 
    -0.00306753f, -0.04507208f, -0.01749161f, -0.06647202f, 0.03463850f, -0.02873242f, -0.03483247f, -0.03160450f, 
    0.01163410f, 0.02694490f, -0.03385068f, 0.00891572f, -0.00994526f, -0.05396729f, -0.04680573f, -0.04848244f, 
    0.05640343f, 0.05038777f, -0.01893706f, -0.04418847f, 0.02908019f, -0.00362732f, 0.02376670f, -0.06733019f, 
    -0.03889375f, -0.04767860f, 0.02296167f, -0.00034314f, 0.03509735f, -0.03185770f, 0.05195242f, -0.00240686f, 
    0.03768850f, -0.00850303f, -0.00862384f, -0.06313875f, -0.02276606f, 0.05494538f, 0.04424293f, -0.05688170f, 
    0.04902313f, -0.05680529f, -0.08010086f, 0.00406658f, 0.02448529f, -0.02686269f, -0.01430616f, 0.04663000f, 
    -0.03355441f, -0.00570603f, 0.05339227f, -0.05918069f, -0.03738647f, -0.06838641f, 0.01647120f, 0.02365335f, 
    -0.07269843f, 0.00040054f, -0.07483013f, 0.02597994f, 0.03287414f, -0.06950507f, -0.04698906f, -0.07502834f, 
    -0.06342358f, -0.01783588f, -0.02673965f, -0.06840975f, 0.01690100f, -0.01959493f, 0.04846338f, -0.00365641f, 
    0.05532094f, -0.00963648f, -0.01994292f, -0.07496069f, -0.05836265f, -0.05371996f, 0.06273680f, -0.02024888f, 
    -0.00096582f, -0.04477603f, -0.06166441f, -0.02449187f, 0.02869326f, -0.01954971f, -0.01921257f, 0.04418465f, 
    -0.01660785f, -0.02356543f, -0.04264889f, -0.05300251f, -0.02702943f, 0.06913754f, -0.01333813f, -0.04523008f, 
    0.04824536f, 0.02779832f, -0.04927251f, 0.03130893f, 0.04085014f, 0.06252250f, -0.05090056f, -0.06843928f, 
    0.01923668f, -0.02147462f, 0.00618256f, -0.07697360f, -0.07721341f, 0.00571659f, 0.03635967f, 0.04607984f, 
    0.02397888f, 0.04840310f, 0.01627544f, -0.06616900f, 0.05012618f, 0.03416986f, -0.04270148f, -0.01324983f, 
    -0.00688621f, -0.07789072f, -0.07482276f, 0.03101587f, 0.04721428f, -0.05294891f, 0.01392411f, -0.02650001f, 
    -0.03064912f, -0.02629918f, -0.06836621f, -0.03219740f, 0.05170766f, -0.05801395f, 0.02458685f, -0.05101451f, 
    0.05062526f, -0.02352766f, -0.04964344f, -0.03866364f, 0.06133045f, -0.05667694f, 0.05253837f, -0.02650605f, 
    -0.04810578f, 0.02983410f, -0.06178601f, 0.03347768f, -0.06183961f, -0.04258975f, -0.02061281f, 0.06407170f, 
    -0.00241574f, 0.04169806f, -0.02458163f, -0.04707399f, 0.00536884f, -0.00214538f, 0.03061144f, -0.05074937f, 
    -0.07471915f, 0.00431209f, 0.04713442f, -0.04108451f, 0.05999265f, 0.05166360f, -0.04582328f, -0.01767682f, 
    0.04354353f, 0.03144220f, -0.01264729f, -0.03489552f, -0.01509522f, -0.04593606f, 0.00573290f, -0.05095517f, 
    0.00415895f, 0.05594899f, -0.05741075f, -0.03896185f, 0.04241817f, -0.03817793f, 0.03470326f, -0.01815719f, 
    0.25896740f, -0.09065950f, 0.13325006f, -0.03016165f, 0.06406510f, 0.08536433f, 0.17835441f, 0.00765243f, 
    -0.01498369f, 0.12871771f, 0.00011597f, 0.11113063f, 0.07690331f, -0.46421644f, -0.13406569f, -0.05702719f, 
    -0.02773458f, -0.10250726f, -0.12943375f, -0.01070083f, 0.06526860f, 0.09483153f, 0.10875471f, 0.01110796f, 
    0.15268497f, 0.01383539f, 0.23957027f, 0.12209027f, -0.06587000f, 0.02213051f, -0.03129348f, -0.00435823f, 
    0.01827866f, -0.11261988f, 0.06622540f, -0.00389902f, 0.03907258f, 0.14342646f, -0.03196242f, -0.06608114f, 
    -0.02165429f, -0.03432516f, -0.07964218f, -0.14089900f, -0.20084482f, -0.00475530f, -0.02249989f, -0.06327021f, 
    0.20399421f, 0.09199931f, -0.00978047f, 0.03290742f, -0.02539188f, 0.05224516f, -0.02286552f, 0.12805143f, 
    -0.05526055f, -0.02005970f, 0.03985595f, 0.02771736f, 0.08986130f, -0.17482176f, -0.01666379f, -0.18810520f, 
    0.01167541f, 0.06544013f, -0.06083113f, -0.04124150f, -0.03988942f, 0.00092955f, -0.01479270f, -0.06659028f, 
    -0.05926615f, 0.00458427f, 0.05417218f, -0.02513398f, 0.03327955f, -0.03944325f, 0.03594613f, 0.06725530f, 
    -0.11204846f, -0.02032445f, -0.07147662f, -0.01995037f, 0.04562208f, 0.14278381f, 0.16857946f, -0.22907908f, 
    -0.00638813f, 0.01161722f, -0.13941035f, -0.00638706f, -0.05152931f, -0.09977827f, -0.10914744f, -0.07948097f, 
    0.19462742f, 0.20216364f, -0.08100285f, 0.03361695f, -0.05896742f, -0.21178859f, 0.23320076f, 0.06378403f, 
    -0.00745251f, 0.01368339f, -0.17633605f, -0.05756022f, 0.03900857f, -0.09489259f, -0.05267150f, -0.04102926f, 
    0.01501520f, 0.05216626f, -0.07132636f, 0.01271763f, -0.09550404f, -0.08217996f, -0.22018513f, -0.09260681f, 
    0.16574977f, 0.12293746f, 0.00919981f, 0.00315715f, 0.11210638f, -0.01392112f, 0.00362599f, -0.08866742f, 
    0.01047952f, 0.02412509f, -0.06373902f, -0.06004426f, 0.08786686f, 0.04536469f, 0.13681260f, 0.13209629f, 
    0.07374421f, 0.00488852f, 0.01115560f, -0.14739464f, 0.02867408f, -0.04324788f, -0.09209650f, -0.10887587f, 
    0.14890076f, 0.08269291f, 0.31326526f, -0.05922122f, -0.02219160f, -0.13994423f, 0.12414718f, -0.03463869f, 
    -0.09144073f, 0.05783653f, -0.04118608f, -0.06971966f, 0.17260735f, 0.05008393f, -0.06234730f, -0.22741026f, 
    -0.11815031f, -0.06873921f, 0.07983918f, 0.03454134f, -0.05001330f, 0.00356999f, -0.02612929f, -0.07735655f, 
    0.08675946f, -0.11611564f, -0.20476466f, -0.15986770f, -0.04383371f, -0.01168054f, -0.18126251f, -0.09840175f, 
    -0.04613361f, -0.04484595f, -0.02992366f, -0.01375499f, 0.01698872f, 0.04841631f, 0.03864420f, 0.03851051f, 
    0.03261426f, -0.04749527f, -0.00475116f, -0.11149015f, -0.06930699f, -0.07986789f, -0.08048914f, -0.03382737f, 
    0.15360561f, 0.21702312f, -0.08536907f, 0.08321285f, 0.01357507f, 0.09741774f, -0.11946749f, -0.06894790f, 
    -0.04311429f, -0.10357808f, -0.04531581f, -0.07930997f, -0.08871319f, -0.16073248f, 0.33522755f, 0.24702840f, 
    0.05505161f, 0.01471807f, -0.05556158f, 0.06470671f, 0.07177608f, 0.00828496f, 0.09875442f, 0.05781581f, 
    -0.26808232f, 0.25571826f, -0.00529573f, -0.13116615f, -0.01471082f, 0.04047922f, -0.17606676f, -0.14948338f, 
    -0.09164838f, -0.15031384f, -0.01055735f, -0.03416123f, -0.05856948f, 0.14094111f, 0.00984080f, -0.04452637f, 
    -0.14912924f, 0.16725110f, -0.02269979f, 0.09511940f, -0.05276417f, -0.09467132f, 0.19437690f, 0.00182563f, 
    -0.03915306f, -0.05103711f, 0.08239368f, 0.15887626f, -0.02434012f, 0.07300661f, -0.08212534f, 0.14316188f, 
    -0.12285699f, 0.00112585f, -0.00911843f, 0.13022253f, -0.19233599f, 0.14804156f, -0.07150616f, 0.07882645f, 
    -0.17346549f, 0.06260101f, -0.02897297f, 0.00263944f, -0.05262524f, 0.10263979f, -0.01721703f, 0.05818326f, 
    0.08807322f, 0.09285481f, 0.11255167f, 0.26762378f, 0.02967014f, 0.05405931f, 0.16965513f, 0.08267100f, 
    0.00661466f, -0.06453032f, 0.10600298f, 0.06984098f, -0.02262880f, 0.37113252f, -0.35920018f, 0.04953048f, 
    0.01419148f, 0.19855961f, 0.08193977f, 0.08087979f, 0.01550463f, 0.03257935f, 0.09242913f, -0.06337969f, 
    -0.02799344f, -0.34968218f, 0.31362540f, -0.02796737f, -0.16609095f, 0.01234217f, 0.04751234f, 0.00959213f, 
    -0.04659582f, 0.13184421f, -0.02368346f, 0.10297316f, -0.07231538f, 0.20064643f, -0.07913829f, -0.07023803f, 
    0.12624851f, 0.04716870f, 0.04956096f, 0.18325135f, -0.02297410f, 0.09912404f, -0.00288363f, 0.03049318f, 
    -0.12670995f, -0.10166775f, -0.00596240f, 0.05460051f, -0.22344331f, -0.04250571f, -0.02677662f, -0.15669566f, 
    0.06722049f, -0.05483523f, 0.00356190f, -0.07915092f, -0.10774108f, -0.03635279f, -0.08394310f, -0.15782291f, 
    -0.12299243f, -0.02773755f, 0.00406817f, -0.05497684f, -0.04839721f, -0.02353363f, -0.07571871f, 0.12847196f, 
    -0.04500807f, 0.34650826f, -0.36019105f, 0.35230327f, -0.10660377f, 0.07263657f, -0.10435645f, -0.10166846f, 
    0.05629680f, -0.01762575f, 0.07131860f, 0.05251694f, 0.19218108f, -0.01165764f, -0.06219135f, 0.23525201f, 
    -0.08912792f, -0.02293345f, 0.13843261f, 0.01334382f, -0.05980199f, 0.00418875f, -0.02686282f, 0.10026899f, 
    -0.13906710f, -0.10596094f, 0.31050980f, 0.20390046f, 0.00213879f, -0.17839353f, -0.04204321f, 0.05754555f, 
    -0.02282093f, -0.00029464f, 0.02445816f, -0.01885208f, -0.36709645f, 0.14424412f, -0.13155444f, -0.05223290f, 
    0.03735726f, 0.04023774f, -0.17862676f, -0.05101055f, 0.03200137f, -0.01794954f, 0.22571348f, 0.07168748f, 
    0.02530100f, -0.06121904f, -0.01427194f, -0.01800245f, -0.04936226f, 0.02425904f, -0.04632535f, 0.01012022f, 
    0.03015572f, -0.04640172f, -0.04667190f, 0.02949511f, -0.06671509f, -0.05980910f, 0.04851017f, -0.04067450f, 
    -0.06571788f, 0.03167528f, -0.01855795f, -0.05318571f, -0.07238458f, -0.02303954f, -0.04803926f, 0.04060205f, 
    -0.05365930f, -0.05667467f, -0.02853866f, 0.00235968f, -0.07123140f, 0.03640828f, 0.01743169f, -0.01392761f, 
    -0.03675170f, -0.03149663f, -0.00044001f, 0.02893681f, 0.01712393f, -0.05147858f, 0.03445801f, 0.06233574f, 
    -0.00903700f, 0.05630002f, 0.06077858f, -0.02349730f, 0.04823107f, -0.03333628f, 0.05841231f, 0.01666475f, 
    -0.02172628f, 0.05752088f, -0.04319755f, -0.05606565f, 0.01409199f, -0.05756933f, 0.06103463f, -0.04499534f, 
    -0.05920667f, -0.00075802f, 0.01165908f, 0.06159662f, -0.00089112f, 0.01451858f, -0.00864916f, 0.00160840f, 
    -0.03216538f, 0.05531163f, 0.04363389f, -0.01692238f, 0.03276437f, -0.02052382f, -0.06958552f, -0.01652630f, 
    0.05184555f, -0.07712702f, -0.03568104f, 0.03517567f, 0.01966505f, -0.07226121f, -0.02304806f, 0.00462709f, 
    -0.04464643f, 0.01318807f, -0.06374183f, -0.01475874f, -0.06072875f, -0.05766493f, -0.05755868f, 0.06416093f, 
    -0.07134182f, 0.05531948f, -0.02544685f, 0.02650470f, -0.04358962f, -0.04905418f, -0.07570978f, 0.06483075f, 
    -0.01576516f, 0.02571960f, -0.04491168f, -0.05113783f, -0.04805962f, -0.05666658f, -0.00585210f, -0.01479718f, 
    -0.07091838f, -0.00011660f, -0.01545038f, 0.01373355f, 0.02115734f, -0.01367947f, -0.04046705f, -0.05103110f, 
    -0.04047087f, -0.07421869f, -0.04969352f, 0.04696198f, -0.05267160f, 0.05661065f, -0.05486721f, -0.01405570f, 
    -0.05690021f, -0.02351062f, -0.06255890f, -0.05579675f, -0.05624257f, -0.04876983f, -0.05654167f, 0.02831908f, 
    0.05636234f, 0.04712874f, -0.03967020f, 0.06214623f, -0.07685415f, 0.00998709f, -0.06527758f, 0.02337181f, 
    -0.03209405f, 0.01321586f, -0.04776048f, 0.03126547f, 0.04839182f, -0.01824295f, -0.06754882f, -0.01714242f, 
    -0.01324986f, -0.02121353f, 0.05007630f, -0.04626947f, -0.00072681f, -0.00105971f, 0.05927531f, 0.01158336f, 
    -0.00469271f, -0.00199565f, 0.01476989f, 0.01240350f, -0.03712856f, -0.02738057f, 0.03025876f, -0.07087882f, 
    0.02592181f, 0.01362567f, 0.01064047f, -0.00511979f, 0.05340057f, 0.04801527f, -0.01497506f, 0.05494019f, 
    0.03498526f, -0.00477635f, 0.04856344f, -0.01587795f, 0.02085408f, 0.01457872f, 0.03066886f, 0.00609228f, 
    -0.01111826f, 0.04122131f, -0.05975030f, 0.06121616f, -0.00808078f, 0.03610478f, -0.00262267f, 0.02094547f, 
    -0.07102755f, 0.03929698f, -0.04377614f, 0.03411169f, 0.00166587f, -0.06917134f, -0.03369215f, -0.07079924f, 
    0.15087380f, -0.10968705f, 0.00748237f, -0.10764151f, 0.15087894f, -0.00446901f, 0.19430745f, 0.18009143f, 
    0.24391957f, 0.26423746f, 0.24011986f, -0.00874802f, 0.41896322f, 0.30947596f, 0.28006786f, -0.01536956f, 
    0.09346278f, -0.03517118f, -0.05860394f, -0.08413631f, 0.11266945f, -0.01087529f, 0.09879890f, 0.24885082f, 
    -0.02851473f, -0.01389075f, -0.01071932f, 0.05956249f, 0.08165628f, 0.08396915f, 0.05702997f, 0.09302837f, 
    -0.21822150f, 0.11086951f, -0.21833588f, -0.04667607f, -0.06817407f, 0.09112173f, 0.00478500f, 0.00125086f, 
    -0.11451280f, 0.01823831f, -0.02587830f, 0.07093780f, 0.10468900f, 0.00554147f, -0.06341795f, -0.06630336f, 
    0.09148917f, -0.05334778f, -0.18167064f, -0.38208616f, -0.02667983f, -0.01130329f, 0.04302252f, -0.01927125f, 
    0.09457268f, -0.05560184f, -0.00481693f, 0.07291625f, -0.04598071f, -0.10636879f, -0.06727056f, 0.19489793f, 
    -0.01478728f, -0.00444993f, -0.03217091f, -0.00787324f, -0.13546944f, 0.11378089f, 0.02498378f, 0.06995083f, 
    0.02308711f, 0.08469143f, -0.05394786f, -0.25361654f, 0.17933545f, -0.13724869f, -0.04307072f, -0.03070783f, 
    -0.07169577f, -0.06964639f, -0.07606638f, -0.01184306f, -0.05764917f, 0.00547595f, -0.05415832f, 0.01150937f, 
    -0.02759296f, -0.19029549f, 0.11912524f, -0.04789831f, 0.04079653f, -0.14266008f, 0.02008807f, -0.14317001f, 
    0.29270199f, -0.37391901f, -0.12119094f, -0.13360673f, -0.08253675f, 0.07267380f, -0.06381727f, -0.05755328f, 
    0.08456744f, 0.21686003f, -0.13126254f, -0.04808451f, -0.06556363f, -0.09409289f, -0.12039514f, -0.02829430f, 
    -0.01798926f, 0.02652849f, -0.00865507f, 0.03074149f, 0.09382013f, -0.06496860f, -0.02853281f, 0.09969311f, 
    -0.31045690f, -0.27465796f, -0.06067600f, -0.16699158f, 0.16056158f, 0.12693837f, 0.08766554f, 0.19591308f, 
    -0.10910819f, 0.07030143f, -0.01599427f, 0.00651757f, -0.06186356f, -0.06812209f, -0.03352669f, 0.13794921f, 
    0.02621905f, 0.06193848f, 0.04475974f, 0.13154003f, -0.14729890f, -0.03744387f, -0.05412873f, 0.06846490f, 
    0.08217838f, -0.21069880f, -0.33863068f, 0.21916859f, 0.26070711f, -0.15543631f, 0.03009440f, 0.07206432f, 
    0.00266176f, 0.08926077f, 0.12299689f, 0.07588531f, -0.27351084f, 0.04056418f, 0.08099459f, 0.27102616f, 
    0.01039828f, 0.20267746f, -0.01411031f, -0.22897092f, 0.02778900f, 0.08215158f, 0.10851625f, 0.23569849f, 
    -0.00144871f, -0.15310882f, 0.06904481f, -0.12137951f, 0.05498423f, 0.03006691f, 0.04055339f, -0.00703768f, 
    -0.07468788f, 0.00189094f, -0.00333612f, -0.02193700f, 0.00489656f, -0.06698355f, -0.03645733f, 0.00267414f, 
    0.08075909f, 0.07511807f, 0.04620767f, 0.08240081f, -0.14753757f, 0.00098482f, 0.04239185f, 0.01602243f, 
    -0.11755712f, 0.11218677f, -0.08722914f, -0.09997731f, -0.05125982f, -0.05257670f, -0.09834635f, -0.01860603f, 
    0.03208433f, 0.02067392f, 0.09346800f, 0.05003183f, 0.15816300f, 0.52285564f, -0.00480204f, -0.11599169f, 
    0.03845675f, -0.00366537f, 0.23293152f, -0.23549035f, -0.02692143f, -0.05467928f, -0.13851416f, 0.06946063f, 
    -0.07372434f, -0.11845268f, -0.23877229f, 0.03685560f, -0.00597766f, -0.12576383f, 0.13833873f, -0.05139454f, 
    -0.03436447f, -0.06666444f, -0.01919148f, -0.02832378f, -0.01256715f, -0.21075056f, -0.03741781f, -0.03054221f, 
    0.02757725f, 0.00110068f, 0.05345680f, -0.03020594f, 0.10915110f, 0.04959058f, 0.02505265f, -0.01473010f, 
    0.01196001f, 0.15063736f, -0.06945752f, -0.31182384f, -0.06125737f, 0.01380771f, -0.01899398f, -0.17956558f, 
    0.13160807f, 0.11095463f, -0.07314104f, -0.01938586f, -0.20534015f, -0.01329185f, 0.08292589f, 0.24747404f, 
    -0.11887362f, -0.09415486f, -0.06331415f, -0.10742563f, 0.13344881f, 0.11348417f, 0.04677892f, 0.12392195f, 
    0.03925417f, 0.03091146f, -0.02065563f, -0.28096521f, 0.01300256f, -0.09635896f, -0.06900294f, -0.04764239f, 
    -0.02748907f, -0.08184732f, -0.00242203f, 0.15989688f, 0.03791792f, -0.08419313f, 0.06473272f, 0.09652121f, 
    0.00758850f, 0.02684818f, -0.03663608f, 0.08494134f, -0.09316068f, 0.01724794f, 0.04560131f, 0.05399376f, 
    0.01331860f, -0.04671033f, -0.11698613f, -0.10128620f, 0.04048278f, 0.12615797f, -0.20292924f, -0.04993736f, 
    0.08078346f, 0.11249824f, 0.05111710f, -0.10961752f, -0.04855708f, -0.02598565f, 0.04279524f, 0.04602506f, 
    -0.01827825f, 0.07553439f, -0.06786408f, -0.11981881f, 0.11200001f, -0.07015221f, 0.12109385f, -0.05227351f, 
    -0.13498619f, -0.11819765f, 0.07512368f, 0.02268855f, 0.08108858f, -0.03807652f, -0.12459040f, 0.04235950f, 
    -0.12212526f, -0.01054920f, -0.02277016f, 0.02395942f, -0.08862329f, -0.01446014f, -0.06304996f, 0.00305220f, 
    -0.00893596f, 0.06400809f, -0.02888461f, 0.11707336f, -0.03107167f, -0.01983383f, 0.07112374f, 0.02830502f, 
    0.03769249f, -0.20322978f, 0.11171763f, 0.13860510f, 0.20859212f, 0.05799701f, -0.00042257f, 0.06673740f, 
    0.02399739f, 0.00676427f, 0.02007255f, -0.12767352f, -0.34249049f, -0.00466973f, 0.15600562f, 0.12724885f, 
    -0.03409762f, 0.05641139f, -0.08007125f, -0.00272452f, 0.18793455f, 0.08781538f, 0.02097152f, 0.06545007f, 
    -0.08791336f, 0.05912408f, 0.18656749f, 0.19014980f, -0.09029669f, 0.01981980f, 0.02573174f, 0.09957362f, 
    0.06879606f, 0.03753660f, -0.03461777f, -0.12741765f, -0.00766104f, -0.07182407f, -0.01103320f, -0.03894738f, 
    0.03846801f, 0.13426606f, 0.19913489f, 0.08176463f, -0.04674712f, -0.07579172f, -0.14962165f, -0.13322848f, 
    0.02244517f, 0.04508765f, 0.05975294f, 0.05834371f, -0.04911904f, -0.04357147f, -0.03155144f, -0.07333685f, 
    0.01004821f, 0.03650138f, -0.06752136f, -0.05505639f, -0.03450677f, -0.06467609f, -0.05595905f, -0.00808086f, 
    -0.00678022f, -0.06049496f, 0.03504814f, 0.00800613f, 0.02766728f, 0.06009200f, -0.06529210f, -0.06357273f, 
    0.04726519f, 0.01008039f, -0.04808540f, -0.04192177f, -0.06352252f, -0.05723497f, 0.04638998f, 0.02079780f, 
    -0.03169189f, 0.05070177f, -0.04028212f, -0.03078352f, 0.03440822f, 0.03957605f, -0.00432568f, 0.05642811f, 
    0.02855513f, -0.07991581f, -0.05683623f, -0.06749118f, -0.06136966f, 0.05800413f, 0.04485380f, -0.05989157f, 
    -0.06687211f, -0.01678322f, 0.06072895f, 0.01805464f, -0.01806577f, 0.05455183f, -0.07584487f, -0.05931345f, 
    -0.06206676f, -0.03598990f, -0.07438403f, 0.02907810f, -0.05032598f, 0.02698441f, -0.05023582f, 0.00378742f, 
    0.02402320f, -0.03710398f, 0.02392042f, -0.00090315f, 0.05256409f, -0.06582391f, 0.05807262f, -0.04876862f, 
    -0.06100300f, -0.07612827f, -0.02313441f, -0.02795614f, -0.04276244f, 0.06066416f, -0.07604288f, -0.02057393f, 
    0.03474836f, 0.02628529f, 0.01824750f, -0.00785377f, -0.00906674f, 0.05269219f, -0.05502853f, -0.03498025f, 
    0.05231550f, 0.04473391f, -0.05806489f, 0.06114040f, 0.04489731f, 0.03577868f, -0.05503871f, -0.01581888f, 
    -0.06182659f, -0.05383515f, -0.03573716f, 0.04191468f, 0.03689044f, 0.00918233f, -0.04728449f, 0.03415153f, 
    -0.03349148f, -0.06836796f, 0.00580043f, 0.02021055f, 0.03836459f, 0.05793397f, 0.02400276f, -0.06864999f, 
    -0.00293931f, 0.02675007f, 0.06326202f, -0.01253830f, 0.01162919f, -0.01038570f, -0.02063927f, -0.05067473f, 
    0.05776824f, 0.01868168f, -0.08337095f, 0.01896987f, 0.03449879f, -0.00087258f, -0.02080555f, 0.05279873f, 
    -0.04952722f, 0.00702611f, 0.00366002f, 0.01685440f, 0.04213427f, 0.03517739f, -0.06672435f, 0.04575719f, 
    0.03445311f, -0.05123653f, -0.05565418f, 0.03935093f, -0.00333598f, 0.02568337f, -0.06977072f, -0.07729430f, 
    -0.05676231f, -0.02595708f, -0.01671518f, -0.05308338f, -0.03221957f, 0.03829376f, -0.03737106f, -0.03291669f, 
    -0.04945647f, -0.06375133f, -0.03988969f, -0.00675484f, -0.07019126f, -0.03239252f, 0.03472226f, -0.07612430f, 
    0.01695156f, 0.02751207f, -0.07275129f, -0.00501242f, 0.02100080f, 0.05502314f, -0.01763239f, -0.04210105f, 
    0.03472178f, -0.07722048f, -0.01701127f, -0.06640152f, -0.04366107f, 0.05384942f, -0.00831274f, -0.03631440f, 
    -0.02778345f, -0.04252509f, -0.01065210f, 0.00424840f, 0.05128919f, -0.04734707f, 0.00705211f, -0.03013191f, 
    0.05328019f, 0.06127352f, -0.05578260f, 0.03453167f, -0.00589103f, -0.07270939f, 0.01746101f, -0.07093884f, 
    0.14160611f, 0.16947617f, 0.16445893f, 0.11215502f, 0.00150469f, 0.09337598f, 0.00933288f, -0.11427969f, 
    -0.00842382f, -0.10666667f, -0.08656419f, -0.13785735f, 0.07009546f, -0.14557186f, 0.16259694f, 0.17003322f, 
    0.05221450f, -0.03270378f, -0.13687794f, -0.05569384f, 0.02891401f, 0.06802184f, 0.01425956f, -0.07332918f, 
    -0.12019747f, -0.34695318f, -0.05730917f, -0.22995584f, 0.04196307f, -0.07393645f, -0.10388607f, -0.11047482f, 
    0.02289972f, -0.01866411f, -0.09997291f, -0.11752342f, -0.04496977f, -0.10076499f, -0.02293214f, -0.09518080f, 
    0.04740635f, 0.09284405f, -0.08155425f, 0.05336643f, 0.01368214f, 0.05517682f, 0.00055528f, 0.06328199f, 
    0.32449555f, 0.25316006f, 0.43064231f, 0.41210377f, 0.04165407f, 0.05290980f, 0.04441942f, 0.19393337f, 
    -0.07184058f, -0.10521360f, -0.02614612f, -0.09496750f, -0.00303214f, -0.07115687f, -0.14550835f, -0.25417253f, 
    0.05657564f, 0.15320064f, 0.07840738f, 0.06746172f, -0.04642475f, -0.05487243f, 0.09375274f, -0.05751724f, 
    0.22117057f, 0.35165277f, 0.33013198f, 0.45632792f, 0.03540522f, 0.09879886f, -0.02591626f, -0.15782875f, 
    -0.02441643f, 0.00926250f, -0.02179583f, -0.09986978f, -0.05192552f, 0.25165921f, 0.24865896f, 0.08195356f, 
    0.04270897f, 0.06025804f, 0.07972982f, 0.14272091f, 0.06573478f, 0.08183069f, 0.06383713f, 0.12172715f, 
    0.05749499f, 0.12858702f, 0.03891021f, 0.03186905f, 0.10390364f, -0.06020534f, 0.14430396f, 0.03083898f, 
    0.06509552f, 0.01347359f, -0.06917885f, 0.02650911f, 0.08231919f, -0.06963918f, -0.07463435f, -0.09443993f, 
    0.05842413f, -0.02764893f, 0.09043521f, -0.09438022f, 0.01000285f, 0.15755369f, 0.10222878f, 0.09507074f, 
    0.00787967f, -0.13171144f, -0.03911250f, -0.01116785f, -0.05777758f, -0.04822196f, 0.02269372f, 0.00165039f, 
    0.08972088f, 0.00107333f, -0.17349869f, -0.05134654f, -0.31113186f, -0.32287365f, -0.25507909f, -0.24041241f, 
    -0.01217984f, -0.08045001f, -0.12006674f, -0.06448626f, 0.05164799f, 0.05020117f, 0.00130212f, 0.07026762f, 
    0.11193457f, 0.09322733f, 0.24968000f, 0.01772431f, -0.08297261f, 0.02875490f, -0.02885554f, 0.04323080f, 
    0.01654527f, -0.04326903f, -0.17929281f, -0.06824947f, 0.10524616f, -0.00798540f, -0.02200592f, 0.02058515f, 
    0.01907376f, 0.03462298f, -0.01447765f, -0.02412569f, -0.14595155f, 0.03309717f, -0.10360766f, -0.13788241f, 
    0.01718650f, -0.27515414f, -0.37370205f, -0.20876336f, 0.01624881f, -0.18536296f, 0.05394088f, -0.03704316f, 
    -0.00798144f, 0.08622850f, -0.11259385f, 0.03948541f, -0.14490518f, -0.21970685f, -0.35398203f, -0.05938084f, 
    -0.09038314f, -0.02852714f, -0.07481070f, -0.03812666f, 0.14131063f, 0.05148217f, 0.10509151f, 0.16872825f, 
    0.00473016f, 0.16573139f, 0.02145761f, -0.07710480f, 0.02077445f, 0.18727536f, 0.09926677f, -0.09442213f, 
    0.06646929f, -0.01440588f, -0.08666112f, -0.18189001f, 0.14322065f, -0.05144897f, 0.00209569f, -0.07831102f, 
    0.01927467f, -0.04435734f, -0.04078457f, 0.12089049f, -0.10319489f, -0.15272556f, 0.00871326f, -0.00220050f, 
    -0.16616915f, 0.22260058f, -0.04736022f, -0.10616361f, -0.02807203f, -0.04131973f, -0.10097117f, -0.04752859f, 
    -0.07147319f, -0.11386187f, -0.07326075f, 0.00312481f, -0.12632149f, -0.04822560f, 0.00516400f, -0.05801191f, 
    -0.07820294f, 0.15627731f, 0.02567257f, 0.14101107f, -0.00719164f, -0.03713714f, 0.04748933f, 0.11657235f, 
    0.02400608f, 0.01756577f, -0.09495287f, -0.17396428f, 0.04351583f, -0.07429001f, 0.02738161f, -0.02175122f, 
    -0.01386219f, -0.06756905f, 0.05149328f, 0.02737516f, -0.08423889f, 0.15914118f, -0.10580853f, 0.07129660f, 
    -0.10045979f, -0.08659753f, -0.03991573f, -0.04428376f, 0.13095213f, 0.17130846f, 0.04409253f, 0.07161222f, 
    0.07818281f, 0.03931803f, -0.00509945f, 0.00512740f, -0.00008559f, -0.02865306f, 0.00080444f, 0.06418273f, 
    0.02181484f, -0.02624143f, 0.03964207f, -0.00366393f, -0.26146159f, 0.11508245f, -0.04347864f, 0.04466363f, 
    -0.03954460f, -0.02624978f, -0.01883681f, -0.05609247f, -0.13788036f, -0.00133123f, 0.00681489f, -0.00918050f, 
    0.22008625f, -0.34252360f, 0.08036803f, -0.19441448f, -0.07427944f, 0.09235988f, -0.07949578f, -0.06718589f, 
    -0.05461284f, 0.15189661f, -0.04474022f, 0.11714344f, -0.10926858f, -0.00715494f, 0.01108178f, 0.04016396f, 
    0.03735928f, 0.06101574f, -0.04403310f, -0.06987844f, -0.04575798f, 0.03895257f, 0.07755988f, 0.20093572f, 
    -0.05930783f, -0.09847463f, 0.22068611f, 0.08301358f, -0.04756797f, 0.03771864f, 0.02073446f, -0.02322208f, 
    -0.01582910f, -0.05519865f, -0.00544716f, -0.01030775f, -0.03583064f, -0.12448005f, 0.02102526f, -0.01604478f, 
    -0.05877031f, -0.02791989f, 0.03759865f, -0.01640904f, 0.01649489f, 0.02643484f, -0.09869449f, 0.04505360f, 
    0.31060001f, -0.09394038f, -0.29995105f, 0.26540145f, 0.11682241f, 0.08182546f, -0.16355360f, 0.01641451f, 
    0.07106325f, 0.00662240f, 0.10335109f, 0.08657932f, 0.25168583f, -0.30923882f, 0.07792454f, 0.16077156f, 
    -0.27779195f, -0.04989422f, -0.03861044f, -0.05819137f, 0.03703769f, 0.08896775f, -0.06612081f, 0.03978472f, 
    0.35171667f, 0.04382392f, 0.01051125f, -0.03441521f, 0.01258413f, -0.11477499f, -0.01100408f, 0.03652568f, 
    -0.19030419f, 0.05524119f, -0.10215045f, 0.04037329f, -0.21933018f, -0.05953899f, -0.18713981f, 0.05628202f, 
    -0.01343109f, 0.04975288f, 0.01190472f, -0.05387308f, -0.00704548f, -0.09755218f, 0.01340608f, 0.02411263f, 
    -0.03275774f, -0.01646763f, -0.03872128f, -0.00071640f, 0.05905262f, -0.01633387f, -0.06586517f, 0.00937194f, 
    -0.06861456f, -0.08072191f, 0.05125710f, -0.00553740f, -0.02383056f, -0.07632682f, 0.00091319f, 0.05063069f, 
    0.05792258f, -0.08177642f, -0.06051821f, -0.03150827f, 0.04419449f, 0.02149072f, 0.03516262f, -0.05649330f, 
    -0.06906476f, 0.03034968f, -0.05916493f, 0.03094413f, -0.01472403f, 0.06974454f, 0.00932563f, -0.07367103f, 
    0.05912961f, 0.02461339f, -0.00576874f, 0.05508358f, -0.03855681f, -0.02909232f, 0.05824227f, 0.04575396f, 
    0.06108701f, -0.06663280f, 0.00415027f, 0.01308594f, 0.06795365f, -0.04565301f, -0.03079247f, 0.02879299f, 
    0.00525601f, -0.03557935f, 0.02146553f, -0.05597072f, -0.07367023f, 0.01961207f, -0.06128695f, 0.02915706f, 
    -0.02942199f, 0.03709431f, -0.00417891f, -0.04268230f, -0.05917125f, -0.04077072f, -0.04613357f, 0.05522597f, 
    -0.03660428f, 0.01095447f, 0.06094240f, -0.00257800f, 0.00115545f, -0.05829261f, -0.06696460f, -0.06159357f, 
    -0.04020897f, -0.00803074f, -0.05744864f, 0.06154908f, -0.04792623f, 0.04534232f, 0.00310336f, -0.01270621f, 
    -0.05622634f, -0.05307186f, -0.07410383f, 0.03413966f, 0.01872396f, -0.06023219f, -0.07576998f, -0.05329230f, 
    0.00275042f, -0.01096788f, 0.00608385f, -0.01743755f, 0.05693070f, 0.03455511f, 0.03115590f, -0.04639912f, 
    -0.01769051f, 0.01520672f, -0.06185595f, 0.00717137f, 0.00370302f, -0.06509014f, 0.01708056f, 0.02334738f, 
    0.00874289f, -0.01537872f, -0.03885363f, -0.06818137f, 0.01297866f, -0.05653020f, -0.00391555f, 0.02292687f, 
    0.02391397f, -0.05632997f, -0.05490286f, -0.05341963f, -0.00039899f, 0.05243397f, -0.07137269f, 0.05874455f, 
    -0.07846764f, -0.03399417f, 0.05621582f, 0.05580298f, -0.04752573f, -0.06116747f, 0.02486197f, -0.00875362f, 
    0.02199540f, -0.05978762f, -0.02137776f, -0.04423404f, -0.05260258f, -0.00971124f, -0.05577059f, -0.03442582f, 
    -0.03571125f, -0.00385961f, 0.01072449f, -0.06031286f, 0.05182244f, 0.02281374f, 0.06360602f, -0.06915442f, 
    -0.01504467f, 0.00379649f, 0.01662879f, -0.06491982f, -0.00275786f, 0.00111544f, 0.00783137f, 0.05557667f, 
    0.01445965f, -0.04057258f, -0.06280492f, 0.02104176f, 0.01855850f, 0.05876996f, 0.01751470f, -0.00724303f, 
    -0.01969650f, 0.01023487f, -0.04220486f, -0.04231801f, 0.05676525f, 0.03197652f, 0.04416060f, -0.00247730f, 
    0.02832280f, -0.05495187f, -0.00723418f, 0.01807365f, 0.04314716f, 0.03567557f, -0.01578263f, -0.02354666f, 
    -0.05972317f, -0.05460821f, 0.02107943f, 0.01544681f, -0.04048046f, 0.02029992f, -0.02451517f, -0.05166871f, 
    0.02438932f, 0.02313891f, 0.02768869f, -0.05280625f, 0.02806922f, 0.01755993f, 0.02307746f, 0.04765415f, 
    -0.07783112f, -0.00194941f, 0.02591780f, 0.24639387f, 0.07594886f, -0.09898301f, -0.06318616f, 0.06137966f, 
    -0.07628955f, -0.02376280f, 0.09050301f, 0.02600041f, -0.07733773f, -0.22100991f, 0.29979369f, 0.02427948f, 
    -0.07727551f, 0.02751482f, 0.17765558f, -0.03667887f, 0.05823490f, 0.04613414f, -0.13923380f, -0.03247527f, 
    0.04520749f, -0.11906710f, 0.04678731f, 0.03908012f, -0.05692844f, 0.03512387f, -0.00126681f, 0.04491481f, 
    0.09871436f, 0.01816844f, 0.13368094f, -0.04742400f, 0.19077359f, -0.02486698f, -0.00831731f, 0.01545984f, 
    -0.09305462f, 0.03190055f, 0.10540272f, 0.08309082f, 0.00312254f, -0.09910943f, 0.05795513f, -0.06031676f, 
    -0.08247527f, -0.15793575f, 0.12356908f, 0.27082992f, 0.01170009f, 0.09997807f, -0.02345080f, -0.01585926f, 
    -0.02697792f, 0.08961377f, -0.00683568f, 0.00918412f, -0.12601149f, -0.09712319f, -0.06906065f, -0.01807888f, 
    -0.02761864f, 0.16043453f, -0.08483880f, 0.04178489f, -0.10164409f, -0.08491445f, -0.06410848f, 0.05567286f, 
    -0.04146798f, 0.12141082f, 0.16593508f, 0.28389847f, -0.11280682f, 0.06052725f, 0.04523724f, -0.04771278f, 
    0.05725423f, 0.05895124f, 0.09628793f, -0.03609211f, -0.09160342f, 0.09999370f, -0.14982089f, 0.05898452f, 
    0.03719262f, 0.15610534f, 0.08931964f, 0.21148893f, 0.05106480f, -0.11058805f, 0.01808329f, -0.08515681f, 
    0.04548253f, -0.02696007f, 0.06177919f, -0.01078302f, 0.03269670f, -0.02238639f, -0.05291264f, -0.06034062f, 
    -0.04592833f, 0.03956897f, 0.10964003f, 0.02016032f, 0.01177792f, 0.19138880f, -0.08677467f, -0.09063859f, 
    0.08972306f, -0.03372596f, -0.03204122f, 0.00651424f, -0.13204469f, 0.06506424f, -0.20987190f, -0.12600484f, 
    0.01109245f, 0.03322030f, 0.16203301f, 0.00520063f, -0.12377015f, -0.00664418f, 0.02279242f, -0.01101259f, 
    -0.01775127f, -0.07918305f, -0.06148202f, -0.00191190f, 0.03676128f, 0.21127827f, 0.02173807f, -0.09667689f, 
    -0.12019637f, -0.04484160f, 0.00406684f, -0.02438473f, -0.15868442f, -0.03007152f, 0.03645044f, 0.02167866f, 
    -0.64799851f, 0.64758241f, -0.13369246f, 0.10254751f, -0.04574676f, 0.00043061f, -0.03872909f, 0.00517450f, 
    0.00373417f, -0.02390581f, -0.07231935f, -0.02880699f, -0.29549745f, 0.32673392f, -0.26289222f, 0.13455579f, 
    0.20362322f, 0.07478852f, 0.12212162f, -0.11044367f, -0.08025672f, -0.03075902f, 0.01742523f, 0.04176830f, 
    -0.00508126f, 0.09417200f, 0.47416589f, -0.02658077f, -0.09024884f, -0.03721794f, 0.01551365f, 0.01676090f, 
    -0.01275999f, -0.04901377f, 0.04071243f, -0.13492480f, 0.20263237f, 0.24966860f, 0.03103916f, -0.00691017f, 
    -0.00914013f, -0.10005654f, -0.10572052f, -0.06734473f, 0.03875435f, 0.06977146f, 0.13074863f, -0.10678434f, 
    -0.01294207f, 0.27188316f, 0.08202919f, 0.12402575f, -0.01153841f, -0.09346902f, -0.01791640f, -0.01587261f, 
    0.07411095f, 0.01191198f, -0.13656206f, -0.01410651f, 0.02325713f, -0.03442501f, 0.04573155f, -0.22132453f, 
    0.01088341f, -0.10779502f, -0.09483485f, -0.02516967f, -0.14309134f, 0.08140984f, 0.01638853f, -0.04687535f, 
    -0.10918076f, 0.04993855f, -0.01385665f, -0.22042607f, 0.03190114f, -0.05225096f, -0.05838459f, -0.08432005f, 
    0.02888487f, -0.10853597f, 0.05369772f, 0.02879419f, -0.17500125f, -0.09021481f, 0.01203796f, 0.03760032f, 
    -0.13645327f, 0.21165340f, 0.01206887f, 0.13410467f, -0.01212628f, -0.08659606f, 0.15781517f, 0.11033107f, 
    0.15026660f, 0.28686985f, 0.15175356f, 0.12161708f, -0.10807127f, -0.18868595f, 0.03292646f, -0.00741895f, 
    0.00763268f, 0.04003961f, 0.07358535f, 0.11927285f, -0.16252065f, -0.10851178f, -0.12449107f, -0.00038938f, 
    -0.05654406f, -0.04208058f, 0.05172692f, 0.01587811f, 0.00012470f, -0.12187457f, -0.08839825f, -0.12607923f, 
    0.17268938f, 0.29383260f, 0.20123386f, 0.21854682f, -0.19471644f, 0.06575219f, 0.16064200f, 0.08137139f, 
    -0.01244313f, 0.05415482f, 0.05480770f, -0.04491152f, -0.32461384f, 0.17796515f, 0.06400457f, 0.18943198f, 
    -0.17716396f, -0.03640359f, 0.18473049f, -0.02772209f, -0.08911198f, 0.08702099f, -0.02587250f, -0.00211878f, 
    0.17944810f, -0.12852813f, -0.07791626f, -0.26496834f, -0.05216721f, 0.12124268f, -0.03349085f, 0.09331924f, 
    -0.10536993f, 0.02528729f, -0.05339521f, 0.02744652f, -0.16009820f, 0.01932059f, 0.02524587f, -0.06680764f, 
    0.07835203f, -0.05567134f, 0.03886999f, -0.04207775f, 0.05371866f, -0.03719110f, 0.00439189f, 0.06052731f, 
    -0.28910628f, -0.34277925f, -0.14261302f, -0.23052807f, 0.02708354f, 0.06491832f, -0.05122905f, -0.13917740f, 
    -0.02749522f, -0.03155315f, -0.00376657f, -0.02207646f, -0.27348137f, -0.40388739f, -0.25903267f, -0.19355135f, 
    -0.10455334f, -0.07076993f, 0.00756851f, -0.05725243f, 0.04523935f, 0.06941300f, -0.01598464f, 0.01669137f, 
    0.12371761f, -0.22552630f, 0.18932787f, -0.29343018f, -0.13110006f, 0.08956574f, -0.05136981f, 0.17192107f, 
    0.02473788f, -0.10000948f, 0.03585803f, -0.01016820f, 0.21623886f, -0.51085556f, 0.16689093f, 0.21563448f, 
    -0.06115654f, -0.15318273f, -0.05823185f, 0.08608701f, 0.08512725f, 0.01202347f, 0.04053969f, 0.00103597f, 
    0.29263785f, -0.20722821f, 0.06675752f, 0.08704159f, 0.12306689f, -0.08675562f, 0.14296690f, -0.00509024f, 
    -0.06774322f, -0.01008237f, -0.04198442f, 0.01110405f, -0.14752093f, -0.15316367f, -0.31486279f, -0.11608800f, 
    -0.00979113f, 0.05840375f, -0.09105927f, -0.11389123f, -0.00173370f, -0.03820822f, 0.00185177f, 0.11963730f, 
    -0.07099167f, -0.00966875f, -0.03151512f, -0.02659732f, 0.03076752f, 0.01872313f, -0.00562562f, 0.06159652f, 
    0.03817518f, -0.06752444f, -0.05178733f, 0.01326793f, 0.04354485f, 0.02151859f, -0.06358386f, 0.02136346f, 
    0.03988421f, -0.01115789f, -0.00643141f, 0.02776066f, -0.02148815f, 0.03262505f, -0.00502680f, -0.02177815f, 
    0.00666455f, -0.06911402f, 0.04270025f, -0.00892861f, -0.06899981f, 0.03091828f, 0.00686406f, -0.07187480f, 
    -0.03793412f, -0.05051205f, -0.00469308f, -0.05695970f, -0.02124457f, -0.02881904f, -0.01052714f, 0.01160993f, 
    0.03049199f, 0.05334217f, 0.00325492f, -0.04233352f, 0.01823847f, 0.03759479f, 0.01522184f, 0.05072742f, 
    0.05407026f, -0.00824889f, -0.00305301f, 0.06669304f, 0.05688050f, -0.04788062f, -0.03776715f, 0.04556284f, 
    -0.06582081f, 0.04146210f, -0.05991948f, -0.06262236f, 0.01768477f, 0.04749272f, -0.07570303f, 0.03191020f, 
    -0.06018777f, 0.00751966f, -0.04158442f, -0.01441429f, -0.06925442f, -0.06370004f, -0.03015854f, -0.00207314f, 
    0.01787955f, -0.03035154f, 0.04299058f, -0.05785565f, -0.01827764f, -0.07179409f, 0.02711233f, -0.05747679f, 
    -0.02286968f, -0.01217222f, 0.00987683f, -0.01388894f, -0.06642600f, 0.02087341f, -0.06081124f, -0.03384865f, 
    0.04411072f, -0.06595189f, -0.00352717f, -0.07015681f, 0.01762511f, -0.03766869f, 0.06063658f, -0.03114829f, 
    0.03440516f, 0.00614803f, 0.05975066f, -0.06584892f, -0.06692544f, -0.04110521f, 0.04838237f, -0.06589027f, 
    -0.05825435f, -0.01204276f, 0.06271257f, 0.00869028f, -0.00270163f, 0.06083040f, -0.01346182f, 0.03221410f, 
    -0.06958416f, -0.00776488f, -0.04773175f, -0.04814818f, 0.03780822f, -0.07885726f, 0.03462828f, 0.05265927f, 
    -0.04449555f, 0.02382440f, -0.05158404f, -0.08188901f, -0.02254574f, -0.07578585f, 0.03801671f, 0.05235947f, 
    -0.01910084f, -0.01529913f, 0.02475187f, 0.00351007f, -0.07513414f, -0.06146274f, 0.05164640f, 0.02594519f, 
    -0.01431318f, -0.00806274f, 0.00866215f, -0.07049846f, -0.00663053f, -0.02332062f, 0.00104827f, 0.02630025f, 
    -0.07876614f, -0.08046802f, 0.02893177f, -0.02970313f, 0.04343951f, 0.01474723f, -0.03629748f, -0.04020844f, 
    -0.07298794f, 0.06599986f, -0.03344661f, -0.02982933f, 0.05121975f, 0.04149237f, -0.02158940f, -0.01787750f, 
    0.02967018f, -0.02782092f, -0.01690216f, 0.02492967f, 0.01666020f, 0.03384080f, 0.01777333f, 0.01403077f, 
    -0.01663727f, -0.01230428f, 0.05262167f, 0.05126449f, -0.02183585f, -0.03992521f, 0.05543211f, 0.05402717f, 
    0.04356414f, -0.03811715f, 0.05600465f, -0.05358309f, 0.00134655f, 0.02869874f, -0.00518708f, -0.01950073f, 
    -0.07423414f, -0.03176893f, 0.06307174f, 0.06198595f, 0.01859532f, -0.06034921f, -0.02007766f, 0.05066285f, 
    -0.05458894f, 0.22699149f, -0.01852252f, -0.07223152f, 0.14123341f, -0.11386400f, -0.01278613f, 0.01806544f, 
    -0.14617665f, -0.03485868f, -0.10160115f, -0.13821450f, 0.05676550f, -0.43147925f, -0.02493646f, -0.33895078f, 
    0.01654735f, -0.14517398f, 0.04634502f, 0.29816213f, -0.00295948f, -0.03839619f, -0.03501439f, -0.02885889f, 
    0.07895524f, 0.08019834f, -0.03485246f, 0.00162151f, -0.02670467f, -0.07857558f, -0.28312206f, -0.10082973f, 
    -0.10646249f, -0.16649798f, -0.13766071f, -0.05987314f, 0.05746891f, 0.02337907f, 0.14032230f, 0.14971836f, 
    0.06189111f, 0.08561802f, 0.02249382f, 0.07288186f, -0.03065559f, 0.01848041f, 0.29432014f, 0.07620028f, 
    -0.00829705f, -0.03799368f, -0.07396706f, 0.02284198f, 0.08960857f, 0.04760694f, -0.00632671f, -0.13476838f, 
    -0.18932068f, 0.01519032f, 0.03321171f, 0.01739325f, -0.27253875f, 0.08667032f, -0.15127161f, 0.02691075f, 
    -0.11922431f, 0.06054224f, -0.07864989f, -0.06899450f, 0.06484748f, 0.01483710f, 0.18032238f, 0.04564340f, 
    0.00464319f, 0.13811783f, 0.06646284f, 0.07110666f, 0.22688782f, 0.07972985f, 0.08400954f, 0.09120690f, 
    0.09005962f, -0.00232573f, 0.03884055f, 0.06192413f, -0.25252086f, 0.32108766f, -0.04417631f, -0.24239036f, 
    0.13587040f, 0.11514346f, 0.04661540f, 0.16604170f, 0.02408364f, -0.04364544f, 0.14092235f, 0.13937435f, 
    0.27017933f, -0.15172713f, 0.15353012f, -0.17695303f, -0.13362074f, 0.17925136f, 0.05060839f, 0.10390753f, 
    -0.05834574f, 0.06864527f, 0.12057033f, 0.02054453f, -0.21100368f, -0.01293625f, -0.05474089f, 0.11827733f, 
    0.03285023f, 0.03162392f, -0.06403153f, 0.11143082f, 0.05541272f, 0.04421431f, 0.07412451f, 0.01163929f, 
    0.18369763f, 0.01869513f, 0.04610706f, 0.22714631f, -0.13067217f, -0.01951428f, -0.01798911f, -0.31374627f, 
    0.02189256f, -0.03893708f, -0.04781175f, 0.15746152f, 0.08653227f, 0.13423276f, 0.06177964f, 0.08319806f, 
    -0.20720120f, -0.11802407f, -0.14053671f, -0.18294600f, 0.01409181f, -0.02959567f, 0.10978336f, -0.10497564f, 
    -0.13851938f, 0.63696361f, -0.09882294f, 0.19515626f, -0.01205457f, -0.03019555f, -0.00135184f, 0.17764463f, 
    0.11191886f, 0.08606339f, -0.02029413f, 0.03991820f, -0.00065603f, 0.17172989f, -0.10570554f, -0.01070088f, 
    0.00815011f, -0.09441497f, 0.12032489f, -0.00870660f, -0.00056925f, -0.00457628f, 0.01756500f, 0.07710496f, 
    0.25484321f, 0.01855764f, 0.26307353f, 0.22127464f, -0.16964017f, 0.00521328f, -0.25512356f, -0.00285574f, 
    0.12424036f, 0.10617021f, 0.22497587f, 0.01046789f, 0.11319788f, 0.20808981f, -0.23856506f, -0.07313667f, 
    -0.22713454f, 0.04568484f, -0.08385478f, -0.07383435f, 0.07894623f, 0.07370739f, 0.13309857f, -0.02189019f, 
    0.01592019f, 0.03028686f, -0.01335867f, -0.03457240f, -0.01935956f, -0.00483429f, 0.01182511f, -0.04189011f, 
    -0.02055396f, 0.00082700f, -0.01392947f, -0.02605946f, -0.05672122f, 0.06254188f, -0.00885651f, 0.06270374f, 
    0.01293386f, -0.03705125f, -0.01499442f, -0.03961502f, 0.01383763f, 0.02490742f, -0.02272988f, -0.01020605f, 
    -0.06266075f, 0.02237839f, 0.05877582f, 0.06464946f, 0.00422108f, 0.00524777f, 0.00907588f, 0.05689325f, 
    -0.07639743f, 0.02327401f, 0.02906968f, -0.03983016f, 0.01516494f, -0.05248033f, -0.05085153f, -0.03249971f, 
    -0.01154385f, -0.05859421f, -0.04707764f, -0.07617490f, 0.01640943f, -0.01547259f, 0.02121181f, -0.02285945f, 
    -0.05330192f, 0.06123332f, 0.03094133f, 0.03455384f, 0.04680140f, -0.00581775f, 0.01055498f, -0.02176436f, 
    0.04009024f, 0.05048748f, -0.06880943f, -0.06379950f, -0.04738636f, -0.00026538f, 0.00892428f, -0.01727318f, 
    0.00306092f, 0.04511344f, -0.01283034f, 0.01286403f, -0.06809770f, 0.05546337f, 0.02971367f, 0.03399976f, 
    0.02625777f, 0.02483624f, -0.00722309f, -0.03850644f, -0.01043831f, -0.02784206f, -0.07036937f, -0.05571949f, 
    -0.04653198f, 0.00307328f, 0.02565441f, -0.05421080f, -0.01128760f, 0.04286109f, -0.03086500f, -0.05868539f, 
    -0.02784579f, -0.07323847f, -0.03504979f, -0.00907000f, -0.04402961f, 0.03134774f, 0.02910396f, 0.05294304f, 
    0.05076905f, -0.06792346f, -0.00354463f, 0.05237464f, -0.00114732f, -0.00700464f, 0.01761726f, -0.06283443f, 
    -0.07004479f, 0.02652539f, -0.07325678f, -0.04346554f, 0.00041020f, -0.01247218f, -0.02944768f, 0.05980528f, 
    0.00696335f, -0.06405532f, 0.00355452f, -0.04979263f, -0.01754395f, 0.01773015f, 0.00876728f, -0.02932185f, 
    -0.05317156f, 0.05506914f, 0.05966486f, -0.02170355f, 0.02583090f, -0.05386416f, -0.03673988f, -0.03944675f, 
    0.00336027f, -0.00240397f, 0.01551790f, -0.05647483f, -0.07293250f, -0.03462531f, -0.00752470f, 0.05340310f, 
    -0.02468699f, -0.03029541f, -0.01333523f, 0.01866752f, 0.01460356f, -0.07124219f, -0.02235018f, -0.04945585f, 
    -0.03713654f, 0.03174292f, -0.01850203f, -0.00502681f, -0.05572838f, -0.05968314f, 0.06150045f, 0.04696300f, 
    -0.03259723f, -0.07918560f, -0.07141531f, -0.04663449f, -0.05113344f, -0.02953856f, 0.03306581f, 0.06202631f, 
    0.02518358f, 0.03668891f, -0.00903212f, 0.03074399f, -0.03346112f, 0.00043168f, -0.07749182f, 0.06147715f, 
    0.02418526f, 0.01955679f, 0.00810413f, -0.03534860f, 0.05262703f, 0.05023860f, -0.07159846f, 0.06111720f, 
    -0.01056069f, -0.03616989f, 0.06621710f, 0.00332150f, -0.03525145f, 0.04293733f, -0.01591350f, 0.00645977f, 
    0.03115162f, -0.05114016f, 0.03432159f, 0.02870311f, -0.05335756f, 0.04558411f, 0.00039551f, 0.06817687f, 
    -0.12320963f, -0.17665391f, -0.00637071f, 0.14996719f, -0.05175322f, 0.12470472f, 0.04869406f, -0.09839568f, 
    -0.13088629f, -0.01893094f, 0.02457439f, -0.11203017f, 0.09081110f, -0.03521224f, 0.20183270f, 0.24758235f, 
    -0.03386224f, -0.07350891f, 0.05715996f, 0.05091237f, 0.03043907f, 0.04794786f, -0.03775366f, 0.04071845f, 
    0.17710043f, 0.08967296f, 0.09583385f, -0.19945714f, -0.06267578f, -0.01391277f, -0.12800419f, -0.00318921f, 
    0.15208659f, 0.13396721f, 0.06143934f, 0.17194892f, 0.13746181f, 0.16727945f, 0.00681072f, -0.02399903f, 
    -0.08118975f, 0.10643372f, 0.07115943f, 0.15901165f, -0.02284090f, -0.14034916f, 0.02854906f, 0.07896251f, 
    -0.21739255f, -0.22293811f, 0.13779660f, 0.27180812f, -0.03534535f, 0.03017724f, 0.10575220f, 0.06394912f, 
    -0.06540541f, -0.10924987f, 0.02369429f, -0.00948563f, 0.15103683f, 0.08824065f, -0.05137356f, -0.04126361f, 
    0.10179270f, 0.14107196f, -0.06254172f, 0.08572284f, -0.01118082f, -0.05400871f, 0.08207671f, -0.01731751f, 
    -0.12424753f, -0.13930084f, 0.09521167f, 0.29197803f, -0.06684578f, -0.06557293f, 0.05873327f, -0.02835263f, 
    -0.01418253f, -0.05036853f, -0.07409512f, -0.25450024f, -0.06758516f, -0.11671600f, -0.23024571f, 0.11268787f, 
    -0.13449593f, 0.00293593f, -0.05271282f, 0.07915232f, -0.04565858f, 0.07764714f, -0.07707044f, -0.12015573f, 
    0.06100686f, 0.08167762f, 0.19524038f, 0.08733027f, -0.01699542f, -0.04925355f, 0.11815707f, -0.00588076f, 
    -0.00270041f, -0.00216776f, 0.04915054f, 0.05687399f, 0.07618108f, 0.22933435f, -0.11546707f, -0.00077286f, 
    0.21033238f, 0.05160171f, -0.04279120f, 0.03545267f, -0.12474024f, 0.06471369f, -0.14159018f, 0.00035875f, 
    -0.00130631f, 0.21666762f, 0.12539025f, -0.14129336f, -0.02792246f, -0.02665608f, -0.05463057f, -0.05332285f, 
    -0.02047076f, 0.03342951f, -0.07625505f, -0.07991956f, 0.11731203f, 0.23569502f, 0.05989524f, -0.09809562f, 
    -0.10132282f, -0.10683080f, 0.08617385f, -0.02144130f, 0.02565489f, 0.10640672f, -0.11417849f, 0.08189029f, 
    -0.45090544f, 0.38338804f, 0.05887860f, 0.39649647f, -0.01956614f, 0.03671364f, 0.14184333f, -0.05546384f, 
    0.02133355f, 0.03395572f, 0.02019208f, -0.01924839f, -0.06474177f, 0.15863736f, -0.13217188f, 0.08042934f, 
    0.21525593f, 0.12313512f, 0.17756715f, -0.01905632f, -0.06668438f, -0.04799754f, 0.16729064f, 0.01135558f, 
    0.09177416f, 0.12841405f, 0.53105742f, -0.04651039f, 0.06619901f, -0.16166924f, 0.12828112f, 0.11354002f, 
    0.07021965f, -0.07138557f, -0.04610410f, -0.00770133f, 0.07902878f, 0.30777940f, 0.03509025f, 0.16349827f, 
    -0.05245325f, -0.09543702f, -0.02715373f, -0.05235614f, 0.12794393f, -0.00652841f, 0.06844974f, 0.13495030f, 
    -0.24431275f, -0.05235789f, 0.04807020f, 0.19884260f, -0.03975362f, -0.12472036f, 0.02772427f, -0.06715339f, 
    -0.06141519f, -0.04059122f, -0.12078916f, -0.14725387f, -0.18145964f, 0.07978837f, 0.25203827f, -0.03731608f, 
    -0.18364890f, -0.04393608f, 0.08603317f, 0.04118981f, 0.08385535f, 0.04901082f, -0.15108880f, 0.03044320f, 
    -0.09024603f, 0.04143454f, 0.05897139f, -0.11742210f, -0.08909389f, 0.01333412f, -0.19221753f, -0.12640424f, 
    0.12007691f, 0.03406517f, 0.09138141f, 0.16236255f, 0.05008908f, -0.02078046f, -0.08258566f, 0.07413734f, 
    -0.14271444f, 0.16103542f, -0.03038463f, 0.13760844f, -0.03485058f, -0.03599681f, 0.06931043f, 0.00238316f, 
    -0.18575045f, -0.08222695f, 0.07841271f, 0.18399040f, -0.10858493f, -0.00520550f, 0.01345614f, 0.00809662f, 
    -0.05905633f, -0.02104889f, -0.10540675f, -0.09392764f, -0.01631812f, 0.03345076f, -0.03521986f, 0.07768431f, 
    -0.04462323f, 0.13065498f, -0.10946281f, -0.05402419f, -0.00301176f, -0.01576526f, 0.03928318f, -0.10883833f, 
    -0.08020358f, 0.06956825f, 0.19070439f, 0.25659770f, -0.20090511f, 0.01149973f, -0.01565168f, 0.02478031f, 
    -0.09369616f, -0.01666321f, -0.07921544f, -0.06039920f, -0.21416692f, -0.03888617f, -0.31636328f, 0.13982600f, 
    -0.05650103f, -0.03019810f, 0.03396819f, 0.14710633f, -0.02176201f, 0.00538691f, 0.05446761f, -0.04827514f, 
    -0.01034871f, -0.05165902f, 0.18122251f, -0.06585785f, -0.12170484f, -0.01059957f, 0.12367861f, 0.00966529f, 
    -0.15103273f, -0.11662005f, -0.05956082f, 0.11475807f, -0.03775892f, 0.11625773f, -0.08895472f, -0.13088356f, 
    0.14251177f, 0.15152539f, -0.12632154f, 0.09223186f, -0.18710792f, 0.01479198f, -0.17600481f, -0.06133439f, 
    -0.10955629f, -0.00992874f, -0.09985266f, -0.01774395f, -0.11740114f, -0.04973138f, 0.04646555f, -0.13682161f, 
    0.05203498f, 0.03091923f, -0.06515676f, -0.15930694f, 0.15848547f, 0.20288768f, 0.06324310f, -0.07877871f, 
    -0.13481721f, -0.06036511f, 0.00996159f, 0.01481609f, -0.01176397f, 0.04743459f, 0.00506511f, -0.00518283f, 
    -0.33141163f, 0.29593107f, -0.06059948f, -0.05837548f, -0.16833602f, -0.03875411f, 0.09618302f, 0.00465759f, 
    -0.06208417f, -0.04373356f, -0.09812225f, -0.03792328f, 0.02331176f, 0.12691870f, -0.01733967f, 0.15772730f, 
    0.12788400f, -0.03821998f, 0.06351190f, -0.03378012f, -0.09889553f, -0.01540582f, 0.05875067f, -0.04075461f, 
    -0.11852953f, 0.13514404f, 0.57174414f, 0.08356868f, -0.01807796f, -0.07314838f, -0.00316877f, 0.11428103f, 
    0.03456827f, -0.07078849f, -0.00470672f, -0.05748028f, 0.06547265f, 0.31191906f, 0.10521895f, -0.10512604f, 
    -0.05072155f, -0.05004523f, -0.07070707f, -0.00480521f, 0.00261384f, -0.00695570f, 0.16301112f, -0.00350992f, 
    0.11214671f, 0.07798147f, 0.21648447f, -0.01414669f, 0.09660926f, 0.00164347f, -0.00548225f, 0.05253516f, 
    -0.05258457f, 0.11985268f, 0.14300315f, 0.10959400f, -0.01418712f, -0.52884066f, 0.19364332f, 0.09905881f, 
    0.15750279f, -0.05221517f, 0.15009739f, -0.04582237f, -0.08768579f, 0.05015805f, -0.23906270f, -0.01726631f, 
    0.19080202f, -0.18359093f, -0.07054787f, 0.16737837f, 0.04923199f, 0.03982006f, 0.05593746f, 0.17212722f, 
    -0.00688216f, 0.04138259f, 0.11170473f, -0.10975067f, 0.28122482f, -0.03582662f, 0.29114386f, -0.05154388f, 
    -0.02094905f, -0.08847348f, 0.05906976f, 0.02826870f, -0.14134525f, -0.06830049f, 0.04524533f, -0.07504693f, 
    0.07671105f, -0.07264368f, 0.11553720f, -0.00388389f, -0.04708185f, -0.02279845f, -0.13142483f, -0.07460734f, 
    0.07854443f, 0.04476710f, -0.01706400f, 0.01551772f, -0.11251944f, 0.01008088f, -0.15224661f, 0.00062372f, 
    -0.06891447f, 0.12907678f, -0.07075248f, -0.04560262f, -0.03076814f, -0.16616577f, 0.06097324f, 0.12168248f, 
    -0.05052966f, 0.10486010f, 0.03339227f, 0.03660674f, 0.16359647f, 0.03077065f, 0.04198596f, -0.05155732f, 
    0.07802811f, 0.10759662f, 0.02830264f, 0.06688113f, -0.01516145f, 0.38254479f, 0.10904437f, -0.07436897f, 
    0.04222181f, 0.28221387f, 0.09650172f, 0.12790462f, 0.12449779f, 0.03459366f, 0.02810148f, -0.06205453f, 
    0.30643293f, 0.02450205f, -0.04260608f, -0.01008113f, 0.01919636f, 0.13676956f, 0.01489799f, -0.03845177f, 
    -0.08478074f, 0.03549238f, 0.15728271f, -0.09222572f, -0.13896281f, 0.19180548f, 0.00246636f, 0.10504177f, 
    -0.01545000f, -0.12454525f, 0.05354218f, 0.00517339f, -0.07111999f, -0.02325445f, -0.10989086f, -0.11093798f, 
    0.19367494f, 0.16750093f, 0.25840703f, 0.00819374f, -0.06876387f, -0.03874062f, -0.17872125f, 0.02430162f, 
    0.02976888f, 0.04376176f, -0.08849134f, -0.02443704f, 0.17582914f, 0.06032363f, 0.06973175f, 0.01316702f, 
    0.01480894f, -0.10919330f, -0.13867983f, -0.00025660f, -0.07060942f, 0.07943427f, 0.10636453f, 0.04204985f, 
    -0.53948259f, 0.76207370f, -0.01696240f, 0.17860991f, -0.07710073f, -0.07366005f, 0.09791724f, 0.02116930f, 
    -0.11490753f, 0.10828341f, -0.15168375f, -0.07065184f, -0.41094404f, 0.17984554f, -0.18672365f, 0.06532922f, 
    0.18288627f, -0.06897455f, 0.16715029f, -0.18292426f, -0.13611214f, -0.07500047f, 0.08679800f, 0.15409401f, 
    0.10282353f, -0.13244820f, 0.39001295f, -0.00118049f, -0.19880916f, 0.08064386f, -0.09626269f, 0.00476923f, 
    -0.11684490f, 0.09946196f, 0.05372633f, -0.06662086f, 0.25768551f, 0.16971566f, -0.05810911f, 0.13716669f, 
    -0.11873491f, -0.06333227f, 0.14974044f, 0.00188574f, 0.07313047f, 0.08671474f, 0.00137608f, -0.00625912f, 
    0.44200668f, -0.02407519f, -0.07944546f, -0.02766179f, 0.25541675f, 0.11949006f, 0.04884179f, 0.32977292f, 
    0.04647370f, 0.10666953f, 0.18661505f, 0.06496808f, -0.18577410f, -0.20178498f, 0.26792046f, 0.26608756f, 
    0.02641929f, 0.08498409f, -0.07890982f, -0.18371333f, 0.12120050f, 0.17430948f, -0.06659201f, 0.17331421f, 
    -0.20188485f, -0.17191531f, 0.05049931f, 0.03752707f, -0.09143016f, 0.03439939f, 0.09663034f, -0.03367013f, 
    -0.11905491f, 0.36914667f, 0.02017265f, 0.22392868f, -0.19580470f, -0.02875127f, 0.22819209f, -0.51572931f, 
    0.34856388f, 0.00509399f, -0.11836162f, -0.08804201f, -0.14285260f, -0.09902517f, -0.10565178f, -0.04527092f, 
    0.26913252f, 0.00263846f, -0.09149355f, 0.03730454f, 0.01083420f, 0.01270070f, -0.01857184f, 0.18524033f, 
    0.17811595f, 0.06897096f, 0.14053208f, -0.02784500f, 0.07933334f, -0.07385262f, -0.00677833f, -0.01035561f, 
    0.07511421f, -0.05597444f, -0.08624122f, -0.43987709f, -0.02719976f, 0.02949796f, 0.14552207f, 0.05769367f, 
    0.08946843f, -0.10756144f, -0.26054126f, -0.14118175f, 0.08788104f, -0.10253052f, 0.05665006f, 0.14789897f, 
    -0.16997473f, 0.04725409f, -0.08145358f, -0.03129410f, 0.44269156f, 0.36935598f, 0.03611364f, -0.09908819f, 
    -0.02361738f, -0.00729757f, 0.05642057f, -0.17990111f, 0.06413017f, -0.03306828f, -0.05354718f, -0.22724445f, 
    -0.05409601f, 0.29775485f, 0.16191660f, 0.49353310f, 0.04941920f, 0.11006597f, 0.12878877f, -0.02725852f, 
    0.00941906f, 0.24694082f, 0.00949013f, -0.19122316f, -0.06231795f, -0.21087742f, 0.03269286f, -0.21721162f, 
    0.05959821f, -0.02433410f, -0.00644920f, -0.27238598f, -0.16662937f, -0.13201982f, -0.32866508f, -0.35956430f, 
    0.06729794f, 0.20489249f, 0.09834565f, 0.08338660f, -0.21067035f, -0.17488872f, -0.08832783f, 0.35097039f, 
    -0.25317541f, 0.14676717f, -0.15137315f, -0.14814243f, -0.04491530f, 0.17491342f, 0.14575705f, -0.12499570f, 
    0.12341800f, 0.05204776f, -0.19776988f, -0.26720694f, -0.07902887f, -0.09147894f, -0.15435161f, 0.01792848f, 
    0.14984322f, 0.10805589f, -0.03255808f, 0.28065571f, 0.14822769f, -0.08017044f, 0.20075485f, -0.12076029f, 
    -0.01015385f, -0.06455410f, -0.09038891f, -0.08204496f, -0.02043542f, 0.39139038f, -0.50851566f, 0.02024896f, 
    0.06115754f, 0.36297378f, 0.04128926f, -0.13966388f, 0.09527409f, -0.00388098f, 0.26343980f, 0.12023671f, 
    -0.43066940f, 0.00508657f, 0.11730509f, 0.04091124f, 0.20931643f, -0.07422509f, 0.13012096f, -0.19624057f, 
    -0.13440889f, -0.03578254f, -0.20272346f, 0.05921789f, 0.08500555f, 0.02298760f, 0.10682989f, 0.17872497f, 
    0.08759510f, -0.09894564f, 0.22376227f, -0.08716265f, -0.20437515f, -0.12204588f, -0.25845248f, -0.12752026f, 
    0.03933305f, 0.03341947f, 0.00838323f, -0.05086114f, -0.05637620f, 0.04555041f, -0.01379108f, -0.06368749f, 
    0.04697018f, -0.02114453f, 0.03450326f, -0.02088824f, -0.07880835f, -0.07196655f, -0.04280903f, 0.00173696f, 
    -0.07916740f, -0.03080493f, -0.03344535f, 0.00399934f, -0.00647623f, 0.00242949f, -0.00999853f, 0.02324412f, 
    0.04985674f, 0.04116118f, 0.02454937f, -0.01790624f, -0.03560694f, 0.05692728f, 0.00818707f, 0.05225996f, 
    0.03507762f, 0.05720950f, -0.03102480f, -0.01565922f, -0.08983296f, -0.04826891f, 0.04429178f, -0.01994028f, 
    -0.01952520f, -0.01961416f, -0.05647407f, -0.02116998f, 0.00246558f, -0.00015658f, -0.05855606f, -0.03012358f, 
    -0.00527962f, -0.06808224f, 0.05527859f, -0.01858006f, -0.05698478f, -0.05521341f, 0.03538166f, 0.02101994f, 
    0.03755560f, 0.04271019f, -0.07315201f, -0.00581567f, -0.01735708f, -0.00186660f, -0.04700074f, 0.05287227f, 
    0.04194732f, -0.03367929f, -0.03853700f, -0.06944592f, 0.04384178f, -0.08360031f, 0.00151768f, -0.05073641f, 
    -0.04050228f, -0.04439151f, 0.01012845f, 0.00128751f, 0.02507881f, 0.05237081f, -0.01565304f, -0.00552805f, 
    0.02808511f, -0.05928141f, -0.05784426f, 0.00350631f, 0.00797363f, -0.03825436f, -0.03041316f, -0.02377522f, 
    -0.00387422f, 0.03222545f, 0.01606069f, 0.02266858f, -0.00548703f, -0.06825482f, 0.00086136f, -0.01607221f, 
    -0.02259180f, 0.00744260f, -0.07598426f, -0.03214938f, -0.06943997f, 0.00620102f, -0.01796521f, -0.02932662f, 
    0.01639671f, -0.05010568f, -0.04117304f, 0.00167327f, -0.02403604f, -0.06001735f, -0.03625194f, 0.02145128f, 
    -0.03649263f, -0.00469908f, 0.05390605f, -0.06651910f, -0.08544870f, -0.04036870f, -0.03247032f, -0.04404136f, 
    -0.03273317f, 0.02604310f, -0.03002490f, -0.01092895f, -0.01894609f, 0.05835659f, 0.05388308f, 0.00219942f, 
    -0.03304978f, 0.03643540f, -0.06356154f, 0.05531461f, 0.04695943f, -0.06048258f, -0.05580334f, 0.02120416f, 
    0.02070190f, -0.01243527f, 0.03185700f, -0.02865170f, -0.06250713f, -0.05918409f, -0.07538377f, 0.01214167f, 
    -0.03909082f, -0.00898002f, 0.04718343f, -0.06106986f, -0.06878375f, 0.05622661f, -0.07351190f, -0.00470433f, 
    -0.06562647f, -0.06601649f, 0.03454997f, -0.02705667f, -0.03732537f, 0.02015563f, -0.07644176f, 0.02663620f, 
    0.01175439f, -0.01869801f, -0.01208007f, 0.02444714f, -0.07249323f, -0.01657024f, -0.06292833f, 0.05219860f, 
    0.06603237f, -0.01836493f, 0.00161291f, -0.02254334f, -0.08752417f, 0.03748026f, -0.02747088f, -0.01252686f, 
    -0.05656631f, 0.05306476f, -0.04468875f, 0.05560410f, -0.07796406f, -0.00308106f, -0.07434725f, 0.02626426f, 
    -0.00345902f, -0.05132535f, -0.03728258f, 0.05243998f, -0.01512292f, -0.01723383f, 0.00570042f, -0.06181758f, 
    -0.28022745f, 0.01009130f, 0.16827191f, -0.01590728f, -0.06299785f, 0.00105299f, 0.07315975f, -0.19032785f, 
    0.07280315f, -0.14096436f, -0.09547427f, -0.20918287f, -0.22683430f, 0.09173204f, -0.10251544f, -0.20925105f, 
    0.15647508f, -0.02803618f, 0.10026306f, 0.10340937f, -0.07123639f, 0.16683009f, 0.08854750f, -0.06850015f, 
    0.10633219f, 0.02577429f, -0.00994842f, -0.03791869f, -0.01181756f, -0.18843628f, -0.07748637f, -0.02528622f, 
    0.06124279f, -0.18842496f, 0.01432927f, -0.06162705f, 0.12719168f, -0.17519161f, 0.00536090f, -0.14292295f, 
    0.09865378f, 0.11355473f, 0.10284203f, -0.13529341f, -0.00647030f, -0.02235478f, 0.08650818f, 0.03777437f, 
    -0.08280566f, 0.06685817f, 0.16449293f, -0.00637347f, 0.07285351f, -0.07264575f, -0.02775804f, -0.08619426f, 
    -0.04087058f, 0.03310093f, 0.10220223f, 0.06264386f, -0.10406657f, -0.08409103f, 0.07588956f, 0.09421658f, 
    -0.09723883f, -0.10334228f, -0.14392653f, -0.04025069f, 0.06200005f, 0.07536050f, 0.11285295f, 0.04912883f, 
    0.09509970f, 0.05685262f, 0.11295485f, -0.00608820f, -0.01506941f, 0.03262898f, 0.03978480f, 0.13791113f, 
    -0.00215944f, -0.00292623f, 0.00171252f, 0.07912929f, 0.03048749f, -0.17986402f, 0.04487254f, -0.04853422f, 
    0.08141901f, -0.17931826f, 0.16230600f, 0.18175386f, -0.04377704f, -0.03308016f, 0.02678282f, 0.01818536f, 
    0.16804427f, 0.13836835f, -0.17258129f, -0.17950551f, 0.06586891f, 0.21457596f, -0.06719788f, 0.16013920f, 
    0.00660338f, -0.02213938f, 0.06771645f, -0.01545769f, -0.10663090f, 0.00103820f, -0.22375721f, 0.01866951f, 
    0.00846269f, 0.00765610f, -0.10163948f, -0.09055828f, 0.03922391f, -0.02775491f, 0.05846766f, 0.07249735f, 
    0.04185218f, -0.07595566f, 0.21448730f, -0.04365456f, -0.05126214f, -0.01151732f, -0.08220109f, -0.10259947f, 
    0.02640075f, -0.04922418f, -0.13353723f, 0.06297044f, -0.03741137f, -0.06799586f, 0.04446776f, 0.08493056f, 
    0.00734847f, -0.06566349f, -0.01945160f, -0.08285040f, 0.00872866f, 0.01486786f, -0.04532172f, -0.03543182f, 
    0.28965661f, -0.10586464f, 0.06136138f, -0.10724215f, 0.10812682f, 0.05327605f, 0.16529502f, 0.20620172f, 
    0.04858732f, -0.02927819f, 0.04488006f, -0.03081692f, -0.18771146f, -0.21267286f, 0.04409706f, 0.06883746f, 
    -0.13347124f, -0.03880852f, -0.00687200f, -0.04409686f, 0.29004151f, 0.09560434f, -0.11907686f, 0.02782346f, 
    0.69404840f, 0.11943415f, 0.10572839f, 0.14941740f, 0.09046230f, 0.08022687f, -0.16781160f, -0.02466450f, 
    -0.06026076f, 0.03331463f, -0.00254788f, 0.01706573f, 0.13000430f, -0.01098426f, -0.05829955f, -0.02330927f, 
    -0.05958143f, -0.00095229f, -0.06635473f, 0.07904615f, -0.07318384f, -0.11322230f, -0.03535368f, -0.03215092f, 
    0.15303004f, 0.02740823f, 0.08558075f, 0.18071170f, -0.10495950f, -0.07002642f, -0.14161268f, 0.06703886f, 
    0.10401122f, 0.01402496f, 0.06081492f, 0.12771170f, -0.33668646f, 0.10153716f, 0.15209192f, -0.09996437f, 
    -0.06455834f, -0.00695417f, -0.06768069f, -0.11060917f, 0.05061864f, 0.11403768f, 0.06175051f, 0.03575669f, 
    -0.10967084f, -0.41897687f, -0.05399648f, -0.07387218f, -0.01405560f, 0.06569245f, -0.07819945f, 0.01696771f, 
    0.00310415f, 0.14235049f, 0.17856880f, 0.05819023f, 0.03675308f, -0.06066863f, -0.04312119f, -0.24655031f, 
    0.09154090f, 0.06188611f, -0.04600307f, -0.06333027f, -0.01304632f, -0.03029961f, -0.06742150f, 0.00038499f, 
    0.13248995f, 0.13697487f, 0.25905040f, 0.13855284f, 0.04671546f, -0.03454084f, 0.13147649f, 0.24352311f, 
    0.07088868f, 0.08281413f, 0.09200566f, 0.02992714f, 0.14970611f, -0.02057829f, 0.02154071f, -0.06958887f, 
    0.02643926f, 0.02904241f, -0.08279720f, -0.09503085f, -0.02379962f, 0.04614827f, -0.00368531f, 0.00071767f, 
    0.16380349f, 0.15475075f, 0.10600135f, 0.16416395f, -0.20687899f, 0.10507251f, 0.04921894f, -0.01098904f, 
    0.01226352f, 0.03646807f, -0.01967017f, -0.08001280f, 0.04709502f, 0.08478464f, 0.26633203f, 0.28029260f, 
    0.07161400f, -0.12208772f, 0.24998891f, 0.15439302f, 0.08540291f, 0.10899588f, 0.00705211f, -0.14792299f, 
    0.19194500f, 0.21984845f, -0.08697749f, 0.06007285f, 0.07950585f, 0.02759268f, 0.17991006f, 0.13941996f, 
    -0.04773864f, 0.12426843f, -0.04600847f, 0.01811094f, 0.09539536f, -0.02387269f, -0.15597905f, -0.15053383f, 
    0.19831899f, 0.19164144f, 0.02990768f, -0.11940704f, -0.08459791f, -0.07607337f, -0.14015079f, 0.02716788f, 
    -0.18026787f, -0.14926629f, -0.04356726f, -0.04648357f, 0.08090236f, 0.06642935f, 0.08989203f, 0.11190095f, 
    0.05634130f, -0.00337715f, -0.11892252f, -0.12529102f, -0.26565087f, -0.62041283f, -0.23009160f, -0.17617272f, 
    0.10595511f, 0.15749896f, -0.11734169f, -0.08022487f, 0.05878698f, -0.05454436f, -0.01759350f, 0.04406870f, 
    0.12302064f, -0.43461034f, 0.25572914f, -0.36291149f, -0.17779866f, -0.02268162f, -0.06014170f, 0.03488718f, 
    -0.05000521f, -0.08570004f, -0.06480370f, 0.01311033f, -0.21833961f, -0.07696988f, 0.03968537f, 0.13990094f, 
    0.00710928f, 0.08985973f, -0.06588002f, -0.08480026f, -0.07619190f, -0.03378671f, -0.05263212f, 0.06841363f, 
    0.13158478f, -0.19721451f, -0.12502132f, -0.22128396f, 0.11637172f, 0.01487729f, 0.09544371f, -0.33934152f, 
    -0.10513406f, 0.03724010f, -0.20602420f, -0.08730449f, 0.22901274f, -0.30061921f, -0.14288196f, -0.13415845f, 
    0.09764446f, 0.06761552f, 0.01777866f, -0.09296626f, 0.10755935f, 0.10404702f, 0.02488180f, 0.10703488f, 
    -0.06232797f, -0.05332120f, -0.05145563f, -0.00966858f, 0.03583195f, 0.01455494f, 0.03938402f, -0.02925323f, 
    -0.00660149f, -0.03115749f, -0.05580977f, 0.05833951f, -0.01249350f, -0.00288738f, -0.03132092f, 0.00813505f, 
    0.05420690f, 0.00915296f, 0.04889245f, 0.04044911f, 0.01569603f, -0.00418541f, 0.05434616f, -0.02878890f, 
    0.04259654f, 0.04598866f, 0.07238853f, -0.01011981f, 0.03692744f, -0.00986997f, -0.06368716f, -0.03358388f, 
    -0.07754438f, -0.04913981f, 0.02796159f, -0.00851553f, 0.05146039f, 0.03086475f, 0.05537080f, -0.07622498f, 
    -0.02343618f, -0.06767884f, 0.05043324f, 0.00477225f, -0.03501738f, -0.02193239f, 0.02053054f, -0.03545854f, 
    0.05284243f, -0.00228227f, 0.02721980f, -0.00670966f, -0.06702477f, 0.00049377f, 0.02028588f, -0.03244324f, 
    -0.06412904f, 0.04879051f, 0.00304686f, 0.02771721f, -0.00231161f, -0.00335618f, 0.04253974f, -0.01601928f, 
    0.03286828f, -0.05474193f, -0.03073052f, 0.02912855f, 0.03018438f, -0.00626980f, 0.02569632f, -0.03536490f, 
    0.02012780f, -0.04055908f, 0.04326911f, 0.01578764f, -0.02737758f, -0.01938284f, -0.03963910f, -0.07938708f, 
    0.01729054f, -0.05214314f, -0.02205962f, 0.00430728f, 0.03021365f, 0.02776060f, 0.02154883f, 0.00572800f, 
    -0.03240167f, 0.04189140f, -0.02616646f, -0.06844952f, 0.05190838f, 0.00941296f, -0.02025997f, 0.00840181f, 
    0.03525002f, -0.04315011f, -0.03523821f, 0.04739286f, -0.07981015f, 0.04237072f, -0.05226545f, -0.05552696f, 
    -0.00393377f, -0.04710463f, -0.01450693f, -0.06120936f, -0.01133486f, -0.01296792f, -0.06591769f, 0.04947231f, 
    -0.05575829f, -0.00642621f, -0.02982362f, 0.03666465f, 0.00365266f, -0.08159189f, -0.03811245f, -0.07338759f, 
    -0.03477610f, 0.04659564f, -0.05446178f, -0.00962084f, -0.07167645f, -0.01114385f, -0.00669399f, -0.07594597f, 
    -0.06907618f, 0.00583631f, -0.02981976f, 0.05423462f, -0.06794850f, -0.02566186f, -0.00723668f, -0.03193023f, 
    0.01363385f, 0.02201794f, -0.01844438f, -0.00745209f, -0.06732364f, -0.04307454f, 0.03917304f, -0.02868361f, 
    0.00887488f, -0.02896001f, 0.04749490f, -0.01073375f, -0.02760606f, -0.07700200f, 0.01044768f, -0.00611834f, 
    0.01225765f, 0.00480776f, -0.04374680f, 0.02612796f, 0.01822080f, 0.06345952f, -0.00653946f, 0.05732991f, 
    -0.03065206f, -0.05726949f, 0.05377364f, -0.03235392f, -0.04476804f, -0.01357050f, 0.01986031f, -0.02522300f, 
    -0.00793071f, 0.01554604f, 0.06961106f, -0.07163081f, 0.01598054f, -0.07310960f, -0.05247113f, 0.04436209f, 
    -0.01155827f, -0.05993003f, -0.07565407f, -0.07422147f, -0.04776848f, 0.00226212f, -0.03572744f, -0.04598104f, 
    0.05817628f, -0.00355976f, 0.00682565f, 0.02087199f, 0.00167220f, 0.00594528f, -0.00099726f, 0.01670531f, 
    0.13947634f, 0.02436211f, 0.09243503f, 0.20285365f, -0.02105172f, -0.01777646f, -0.00906103f, 0.10043766f, 
    0.15229265f, 0.10361614f, 0.09666713f, 0.04169080f, -0.04259224f, -0.02487206f, 0.31366289f, 0.27276775f, 
    -0.08280718f, 0.02485600f, -0.10200803f, -0.07529433f, -0.04210058f, 0.02423540f, -0.03167573f, 0.10756405f, 
    -0.19097298f, -0.05248003f, 0.08380109f, -0.20317572f, 0.00012995f, 0.17605817f, -0.09333328f, 0.06438097f, 
    -0.00768188f, 0.12603590f, 0.21477376f, 0.11767334f, -0.18210416f, 0.04807999f, -0.17563440f, -0.24801554f, 
    -0.17175615f, 0.12090053f, -0.01647892f, -0.01932270f, -0.09820673f, -0.18288571f, 0.00396085f, -0.07529323f, 
    0.09005525f, 0.01069170f, 0.22266544f, 0.19225830f, -0.07578368f, 0.04027699f, 0.11160187f, 0.24557085f, 
    -0.04967582f, 0.05566816f, 0.17420118f, 0.19196627f, 0.07452754f, 0.23383468f, -0.13419135f, -0.09168718f, 
    -0.00928835f, 0.16470146f, 0.07040030f, 0.09351446f, -0.02322834f, -0.06584899f, -0.08953035f, -0.03230530f, 
    0.07644431f, 0.14632244f, 0.07616014f, 0.28243735f, -0.12770076f, 0.00724158f, 0.09766666f, 0.09754756f, 
    -0.05089246f, -0.00835263f, 0.00928026f, -0.06221430f, -0.05481413f, 0.08569030f, -0.23316605f, 0.21031618f, 
    -0.08779766f, 0.14277224f, 0.19739176f, -0.01998817f, -0.02404365f, 0.02133013f, -0.05343194f, -0.17163137f, 
    0.05748307f, 0.01102161f, 0.11973489f, 0.02818440f, 0.16774184f, 0.07192267f, 0.06998048f, -0.01585996f, 
    -0.05802526f, -0.01015239f, 0.03163889f, 0.00042494f, 0.11320820f, 0.31686515f, -0.05130807f, -0.28025913f, 
    0.14867234f, 0.02741551f, 0.00144835f, 0.06224974f, -0.22414403f, -0.03981124f, -0.21771795f, -0.12228515f, 
    -0.27567109f, 0.09696978f, 0.07965334f, -0.17709480f, 0.01622880f, 0.04401017f, 0.15756814f, 0.13665812f, 
    0.08706090f, -0.00758994f, -0.07225058f, -0.14758267f, -0.40809965f, -0.39560699f, -0.33939555f, -0.35959002f, 
    0.13837802f, 0.01057812f, 0.01623068f, -0.10107282f, 0.03544961f, 0.00538141f, -0.15277906f, 0.15845847f, 
    -0.15918757f, 0.01053574f, -0.11969027f, 0.01251653f, -0.01730758f, -0.06493058f, -0.05937716f, -0.16589920f, 
    -0.17403683f, -0.05570238f, -0.07067093f, 0.08284864f, -0.10878608f, -0.18174647f, -0.21271922f, 0.19949467f, 
    0.14970188f, 0.02814436f, 0.09528390f, -0.08325892f, -0.02663344f, -0.04621954f, 0.03764527f, 0.07224818f, 
    -0.10576072f, -0.13587847f, 0.01549533f, -0.38193563f, 0.12277155f, -0.08789197f, 0.38615939f, -0.16142870f, 
    0.03165285f, -0.07790525f, -0.19096784f, -0.05315315f, -0.31401023f, -0.14687087f, -0.21953775f, -0.04467239f, 
    0.31035811f, 0.14183544f, -0.20863655f, -0.18071459f, 0.10064228f, 0.04316099f, 0.05812818f, 0.10943368f, 
    -0.06303639f, -0.07423209f, 0.11555314f, 0.11246411f, 0.02228100f, -0.02586870f, 0.20607007f, -0.04320876f, 
    0.14398852f, -0.13654678f, 0.11654869f, -0.10558716f, -0.53310746f, 0.25981644f, 0.12441758f, 0.14535609f, 
    0.10059668f, 0.16569616f, 0.14113528f, 0.02771461f, -0.01718497f, 0.02005518f, -0.03885355f, 0.09642740f, 
    -0.12074740f, -0.01787821f, -0.12579902f, -0.13687436f, 0.00658217f, -0.10025523f, -0.03312100f, -0.04159559f, 
    -0.08179732f, 0.00393053f, -0.08101515f, 0.06329784f, 0.09926888f, -0.07663463f, -0.21162942f, -0.04269686f, 
    0.11413582f, 0.00382076f, 0.22200644f, -0.24349840f, 0.06820837f, 0.13247317f, 0.04684543f, 0.12634024f, 
    -0.22041747f, -0.11944195f, -0.16342418f, -0.21218154f, 0.07908571f, 0.02986568f, 0.00541652f, -0.12529206f, 
    0.14096679f, 0.11268504f, 0.01065277f, 0.09005035f, -0.12033284f, -0.06507535f, -0.07807148f, 0.02307182f, 
    0.05628976f, -0.04464726f, -0.01563522f, -0.06615406f, 0.01021700f, 0.21945687f, 0.11204904f, 0.19119471f, 
    0.01706574f, -0.14628351f, 0.01320995f, -0.01538906f, 0.04428919f, 0.02773548f, 0.08441714f, 0.07509880f, 
    0.09972607f, 0.04879766f, -0.01780936f, -0.06334554f, 0.32854810f, -0.22349378f, -0.11944672f, 0.07475241f, 
    -0.05599121f, -0.22460999f, 0.05921987f, 0.13531062f, 0.08438007f, 0.02501314f, 0.06940617f, 0.02709168f, 
    -0.38154784f, 0.13691863f, -0.03328658f, 0.02748315f, 0.06689199f, 0.11703084f, -0.09095097f, 0.07247893f, 
    0.08238716f, 0.05719412f, 0.06857077f, 0.05199302f, -0.04237949f, 0.13251559f, -0.20375083f, -0.01850116f, 
    0.15598722f, 0.01986902f, -0.07548109f, 0.02401738f, 0.07783590f, 0.10905970f, 0.02286115f, 0.09194069f, 
    -0.05695684f, 0.13453807f, 0.01208037f, -0.08097638f, -0.02393459f, -0.05987166f, -0.06886763f, -0.10512879f, 
    0.01224379f, -0.13206734f, -0.04900683f, -0.01623037f, 0.00826572f, 0.12407072f, 0.07961679f, -0.14344236f, 
    -0.02677478f, -0.11705353f, -0.00764021f, -0.06885787f, -0.06728592f, -0.03578624f, 0.04988078f, 0.05040050f, 
    0.26828715f, 0.03456010f, -0.05217519f, 0.07321030f, -0.02085944f, 0.00026576f, 0.21358015f, -0.02831127f, 
    0.11703929f, -0.00265262f, 0.08732172f, 0.05325087f, -0.16008222f, 0.04390771f, -0.22306317f, -0.10698245f, 
    -0.17634474f, 0.04545781f, 0.01601109f, 0.06963707f, 0.28053188f, -0.04130258f, 0.00941086f, 0.13436227f, 
    0.01254921f, 0.15777700f, 0.17009093f, 0.07511663f, -0.00056480f, 0.06595589f, -0.21632777f, -0.03356995f, 
    -0.05552170f, -0.00510854f, -0.05128051f, -0.00461240f, -0.10201959f, -0.03332773f, 0.15728381f, -0.04795956f, 
    0.00319851f, 0.07335203f, -0.02365253f, 0.03775133f, 0.04081633f, 0.04434891f, -0.02079109f, -0.01437451f, 
    0.13960534f, 0.21489345f, -0.00555016f, 0.15347351f, 0.08444484f, -0.05966182f, -0.14814588f, 0.18788636f, 
    -0.25546041f, 0.00158418f, -0.05327393f, 0.00201311f, -0.03567909f, -0.11931822f, -0.16505206f, -0.38520351f, 
    -0.14711183f, -0.19010888f, 0.06850971f, -0.07094806f, 0.00311895f, 0.11956723f, 0.07564799f, 0.12198524f, 
    0.07306966f, -0.39655983f, -0.02298526f, 0.00426015f, -0.11571439f, -0.04608826f, 0.04242577f, 0.02722097f, 
    0.01442412f, -0.04351845f, 0.12459966f, 0.02131341f, 0.00300368f, -0.20205082f, 0.12685405f, -0.18915266f, 
    0.07220650f, -0.12271786f, -0.14579974f, 0.02705907f, -0.04450327f, 0.19352613f, -0.01353076f, -0.05114984f, 
    0.38949323f, 0.37094888f, 0.21445353f, 0.15443894f, 0.08995225f, 0.12376723f, 0.11725334f, 0.12104703f, 
    -0.14051703f, -0.09035522f, -0.12490652f, -0.02168159f, -0.06468087f, -0.07135575f, -0.01884671f, 0.01341517f, 
    0.03570276f, 0.08573119f, 0.01572868f, -0.13277656f, 0.01899236f, 0.00279300f, 0.18883526f, 0.04775895f, 
    0.17123935f, 0.24726827f, 0.06371626f, 0.03045665f, -0.13879371f, 0.10942464f, 0.04759612f, 0.13357298f, 
    0.09484705f, 0.02399465f, 0.14602044f, 0.15881422f, -0.11635822f, 0.23040247f, 0.49389404f, 0.04845121f, 
    0.18467945f, 0.25801408f, 0.02798995f, 0.03165790f, 0.00592624f, 0.10163013f, -0.07550640f, 0.11222414f, 
    0.29206175f, 0.15291685f, -0.10514525f, -0.03726935f, 0.09612302f, 0.02440615f, 0.09811793f, 0.27857411f, 
    -0.03594410f, -0.02821271f, 0.13120878f, -0.12642696f, -0.17653492f, -0.26689866f, 0.07490967f, -0.03947724f, 
    0.00934354f, 0.12243500f, 0.04190020f, -0.11987634f, 0.13996582f, 0.12966795f, 0.20329721f, 0.10925121f, 
    -0.25757468f, -0.20893762f, -0.10695383f, 0.07357857f, -0.10351951f, -0.04591546f, 0.00955221f, 0.00363602f, 
    0.06454347f, -0.05727846f, -0.07716379f, 0.01127469f, -0.20794556f, -0.48610926f, -0.09360482f, -0.02193097f, 
    0.07712948f, 0.15666813f, -0.10744761f, -0.02995253f, 0.00521744f, 0.03068402f, 0.22122543f, -0.03925093f, 
    -0.01351666f, -0.11078668f, 0.10654856f, -0.37162077f, 0.15645137f, 0.09103377f, -0.16652136f, 0.14985006f, 
    -0.07448710f, 0.02641277f, -0.18377735f, 0.02946464f, -0.21225031f, 0.05669828f, 0.12435131f, 0.03688993f, 
    0.02923315f, 0.19990616f, -0.04135806f, -0.09730418f, 0.00684901f, 0.02298680f, 0.05799923f, 0.06832441f, 
    -0.11930615f, -0.01392101f, -0.13772182f, 0.02251974f, -0.09694555f, -0.07532902f, -0.10553305f, -0.01024523f, 
    0.08191704f, 0.06489801f, -0.12189453f, 0.05039392f, 0.24990822f, -0.21862328f, -0.22657797f, -0.26354721f, 
    -0.05384347f, -0.04922900f, 0.03819133f, -0.00699469f, 0.10288547f, -0.03204832f, -0.07317606f, -0.03827979f, 
    -0.24270540f, 0.26635963f, -0.01909768f, 0.17392546f, -0.04986944f, -0.00497852f, -0.06379776f, -0.19651957f, 
    0.04626259f, -0.19553864f, -0.06827820f, -0.07879215f, -0.06990590f, 0.36075422f, -0.04107070f, -0.13197845f, 
    0.04553263f, 0.05350323f, 0.08471694f, 0.00578071f, -0.03067854f, -0.02751003f, -0.06051096f, 0.03222420f, 
    0.06115938f, 0.00536621f, -0.06279645f, -0.08600733f, -0.07173403f, -0.08090137f, -0.04344016f, -0.07795852f, 
    -0.03117414f, -0.11185054f, 0.06275805f, 0.03891055f, 0.00842496f, -0.11959150f, -0.05081051f, 0.02241379f, 
    0.00680504f, 0.20793691f, 0.07252984f, 0.08537029f, -0.07467572f, 0.01129465f, 0.18496741f, 0.01877064f, 
    -0.26717094f, 0.00048742f, 0.20554766f, 0.07712799f, -0.07395845f, -0.09361245f, -0.05082357f, -0.04594425f, 
    0.15052384f, 0.17694142f, 0.01225139f, 0.15817609f, -0.22682378f, 0.13674891f, 0.03547933f, 0.07239347f, 
    -0.08428771f, -0.11867105f, -0.10505664f, 0.04267812f, 0.11623839f, 0.05409841f, 0.03646412f, 0.08918706f, 
    -0.08990007f, -0.04553266f, 0.13692477f, 0.17659529f, -0.23134494f, 0.04601076f, 0.09501930f, 0.02119613f, 
    0.00336232f, 0.10307001f, 0.03037347f, 0.12506984f, -0.19483891f, -0.17346765f, -0.19108643f, 0.10662091f, 
    0.02338859f, -0.10828128f, 0.11516720f, 0.06047906f, -0.08315402f, 0.13149890f, 0.06400432f, 0.01708796f, 
    -0.04987542f, -0.01651527f, 0.14204951f, -0.19526301f, -0.08185229f, 0.09769104f, -0.18482953f, -0.08549532f, 
    -0.06395962f, -0.07568447f, -0.06208346f, 0.07740262f, -0.10889319f, 0.02830214f, -0.08596017f, 0.05250831f, 
    0.16366644f, 0.17352591f, -0.14729626f, -0.01304176f, -0.08025922f, 0.03506276f, 0.18268688f, 0.08112083f, 
    -0.11659113f, 0.06381746f, 0.26452562f, 0.11920984f, -0.06845163f, 0.04194431f, -0.05504129f, -0.12522882f, 
    0.05025091f, -0.06607611f, 0.03195001f, 0.00004665f, -0.06492944f, -0.06795202f, -0.07351261f, -0.02359720f, 
    -0.01244153f, 0.01758936f, -0.00839921f, -0.06718677f, 0.01765039f, -0.00667127f, -0.02396714f, 0.01426917f, 
    -0.02578875f, -0.03190274f, -0.03609432f, 0.06755684f, 0.05251709f, 0.14819077f, -0.03383439f, 0.20327479f, 
    0.14787306f, 0.01904730f, -0.00086511f, 0.05592393f, -0.10549731f, -0.22594538f, 0.12927656f, 0.17409909f, 
    -0.11740815f, 0.00641150f, -0.07936812f, 0.04982014f, 0.17263885f, 0.03848530f, -0.08711211f, 0.03116068f, 
    0.31333375f, 0.36953822f, 0.29105404f, 0.12220296f, -0.01352822f, -0.05559409f, 0.07242206f, 0.15632229f, 
    -0.04866434f, -0.01212507f, 0.05332867f, 0.02561667f, -0.04929684f, 0.11456823f, -0.01984432f, 0.02326166f, 
    0.05234214f, 0.06474859f, 0.06127074f, 0.03498284f, 0.05307728f, 0.03775475f, 0.00448391f, 0.04164524f, 
    -0.05568619f, 0.05216435f, 0.04460327f, -0.00244408f, 0.03232146f, 0.03798062f, 0.04955024f, -0.02128128f, 
    -0.01004634f, 0.03719441f, -0.00263243f, -0.05868679f, -0.05542767f, -0.05940054f, 0.04671405f, -0.02412363f, 
    -0.00572292f, -0.04696538f, -0.06585349f, 0.00150353f, 0.02714497f, 0.02767791f, -0.06407004f, -0.03602339f, 
    0.01718616f, 0.05734655f, -0.04344359f, 0.04375286f, 0.05582623f, 0.04336312f, -0.04980788f, -0.07504712f, 
    -0.07754471f, 0.04367793f, 0.00529159f, 0.02519429f, -0.02133568f, -0.04132528f, -0.07495562f, 0.05466268f, 
    -0.00913890f, -0.03896442f, -0.03852018f, 0.00739450f, -0.03098500f, -0.06938516f, 0.00072313f, 0.02976857f, 
    -0.07536996f, -0.05500478f, 0.01978382f, -0.01128160f, -0.04705817f, 0.03356488f, -0.01542692f, 0.03404864f, 
    0.00602621f, -0.07223269f, -0.03277999f, 0.04375813f, -0.06205235f, -0.00922407f, -0.02074921f, 0.02995866f, 
    0.06301585f, 0.01376723f, 0.00020529f, 0.05438709f, -0.01844132f, 0.04710098f, -0.03946948f, -0.00077916f, 
    -0.04843290f, -0.01765063f, -0.00977355f, -0.04382030f, -0.04071922f, 0.01875398f, -0.04296355f, -0.02773130f, 
    0.02074637f, -0.07423317f, 0.05218785f, -0.03103665f, 0.03224030f, 0.00066339f, -0.01628460f, 0.04589770f, 
    -0.01638366f, -0.02487683f, -0.01818656f, 0.00971784f, -0.05772528f, -0.01217201f, -0.01456517f, -0.02719193f, 
    0.01801105f, -0.05017308f, -0.06076837f, 0.06392975f, 0.02137779f, 0.01653354f, 0.04611726f, -0.05945582f, 
    -0.03575400f, 0.04766232f, 0.03048266f, 0.06338550f, 0.02629922f, 0.01347488f, 0.05483839f, -0.05647323f, 
    0.00736177f, -0.06959685f, -0.07287768f, -0.05060674f, -0.04553225f, -0.04644658f, 0.00399213f, 0.04626143f, 
    -0.02656826f, -0.00963901f, 0.05967242f, -0.06608387f, 0.00292146f, 0.05093556f, -0.01099646f, -0.07608872f, 
    -0.02824701f, 0.02580959f, -0.01129113f, 0.03644638f, 0.00945425f, -0.03487693f, -0.00972288f, -0.05706031f, 
    -0.05202784f, -0.07376639f, 0.02779831f, -0.00076529f, -0.02836340f, 0.05383242f, 0.02254336f, -0.06274112f, 
    -0.03544118f, -0.03246777f, -0.06965806f, -0.03218939f, -0.05809971f, -0.03302093f, -0.05701159f, 0.01522075f, 
    -0.00754340f, 0.06353064f, -0.01736929f, 0.04648673f, -0.04696245f, 0.04480689f, 0.04167095f, -0.00020232f, 
    -0.04321278f, 0.01480055f, -0.04933796f, 0.06137186f, 0.04928578f, -0.07252613f, 0.00661848f, 0.03244640f, 
    -0.01890409f, -0.03545259f, -0.03227938f, 0.05838855f, -0.05937067f, -0.06408913f, 0.05032117f, 0.04195786f, 
    -0.03057569f, 0.01379297f, 0.00879957f, -0.00650608f, 0.06482286f, -0.02474892f, -0.02846029f, 0.01300854f, 
    -0.02101076f, 0.01446455f, 0.03419028f, -0.00258377f, -0.00197331f, -0.06077329f, -0.06223207f, -0.07386648f, 
    -0.01007295f, 0.16262142f, 0.15869258f, 0.03429789f, 0.10323288f, 0.10052276f, 0.13174891f, -0.00178578f, 
    0.12817307f, -0.04554738f, -0.14216082f, -0.04959686f, 0.27985802f, -0.29190326f, 0.01223557f, -0.08796048f, 
    0.01519727f, 0.15129486f, -0.20816042f, 0.09644361f, -0.12129427f, -0.14744301f, -0.18895738f, -0.20652519f, 
    -0.17290667f, -0.08351352f, 0.06860878f, -0.08845073f, 0.05211999f, 0.00126436f, -0.12035555f, 0.04305400f, 
    -0.31474149f, -0.21079679f, -0.02506460f, -0.21323460f, -0.16630426f, 0.04801176f, 0.02301763f, 0.09966664f, 
    -0.32438412f, 0.18843591f, 0.02749583f, 0.13568981f, -0.05624875f, 0.04404239f, 0.24568406f, 0.11826510f, 
    0.09993985f, 0.14211902f, 0.12735821f, 0.12318521f, -0.15881464f, -0.01231667f, -0.10614651f, -0.01028341f, 
    -0.17269646f, 0.00808411f, -0.00350908f, 0.14199960f, -0.17686988f, 0.03662021f, -0.03773144f, -0.01945138f, 
    -0.06138258f, 0.00651788f, 0.09568582f, 0.13021956f, -0.03632538f, 0.02692579f, -0.08112767f, -0.13482124f, 
    0.11868787f, 0.31036764f, 0.13051333f, 0.24263148f, 0.02140900f, 0.17570660f, 0.19608834f, 0.05792443f, 
    0.09106765f, 0.05495669f, 0.10617118f, -0.02002000f, -0.34164444f, 0.24188736f, 0.04411943f, 0.21053538f, 
    -0.09395573f, 0.05995183f, 0.12304195f, 0.01567947f, 0.09788416f, 0.07597389f, 0.01937048f, 0.05974758f, 
    0.25177410f, -0.27744615f, 0.08859182f, -0.20334129f, -0.27121994f, -0.05913342f, 0.08095798f, -0.25861293f, 
    -0.17169346f, 0.03096517f, -0.01477650f, 0.16950113f, -0.02824103f, 0.06364112f, -0.04185431f, -0.02135982f, 
    -0.05461556f, 0.05190809f, -0.08427969f, 0.18013500f, 0.06941448f, -0.04062116f, 0.01816645f, 0.10295562f, 
    -0.05718174f, -0.00927357f, -0.08200951f, -0.03918253f, -0.01281066f, 0.05575075f, 0.02248581f, -0.11098088f, 
    0.09871306f, 0.00685746f, 0.10421181f, 0.11751664f, -0.12052745f, -0.16068202f, -0.18760072f, -0.12686051f, 
    -0.04383803f, -0.13580662f, -0.05563709f, 0.01142745f, -0.02009742f, 0.08350418f, 0.03730773f, -0.02582592f, 
    0.02276911f, 0.19208294f, -0.17895712f, -0.01040450f, -0.14386137f, -0.01604440f, -0.13051993f, 0.07065275f, 
    0.09471849f, 0.05401995f, -0.04179217f, 0.10274526f, 0.27992970f, -0.14862552f, 0.22233541f, -0.05021407f, 
    -0.12344187f, -0.25406086f, 0.05928551f, 0.12130595f, 0.01563887f, 0.01570160f, 0.00941626f, -0.10134385f, 
    0.22808850f, -0.13869385f, -0.04754164f, -0.25919238f, 0.18570937f, -0.14402276f, 0.02778599f, 0.03285450f, 
    -0.14188239f, -0.09813128f, 0.08971877f, 0.10750418f, -0.07595339f, 0.11812048f, -0.23403072f, -0.07952535f, 
    0.10476451f, 0.07587720f, -0.08161976f, -0.09418616f, -0.03628829f, 0.00349795f, 0.09791796f, 0.07178846f, 
    0.25586292f, -0.18683434f, 0.05247943f, -0.17316332f, 0.14118960f, 0.08090474f, 0.08006820f, 0.10666335f, 
    -0.09997056f, -0.13464817f, -0.08140577f, 0.03650419f, -0.29278004f, -0.57605124f, 0.16373934f, 0.19037104f, 
    0.06162091f, -0.00653249f, 0.08728821f, 0.24618842f, -0.01901250f, 0.10419931f, -0.03229021f, -0.08196551f, 
    -0.03482361f, -0.12086982f, 0.10483713f, -0.08343335f, -0.08369924f, 0.00519652f, -0.04216793f, 0.08403145f, 
    0.07952961f, 0.04870072f, 0.07598044f, 0.00654545f, 0.13316299f, 0.06585038f, 0.06442184f, -0.11291687f, 
    0.10295342f, -0.11375017f, 0.05443028f, -0.12381840f, -0.06774706f, -0.02362564f, 0.00542613f, 0.06811170f, 
    0.01638373f, -0.08446041f, -0.07085818f, 0.17495061f, 0.02873136f, 0.05802442f, 0.03664114f, 0.12714051f, 
    -0.03388283f, -0.04436975f, -0.00221548f, -0.01408326f, 0.00735667f, -0.15140402f, -0.14320096f, -0.23260859f, 
    0.04981135f, 0.04917015f, -0.05762903f, 0.05161357f, -0.06853800f, 0.00454896f, 0.18049116f, 0.03961423f, 
    0.05616854f, 0.01275259f, -0.01468410f, -0.00201084f, 0.15049744f, 0.05658686f, 0.03912355f, 0.03572389f, 
    0.01249544f, -0.00757081f, 0.01279847f, -0.04873767f, 0.43609589f, 0.37487999f, 0.06326538f, -0.26815569f, 
    0.00999300f, 0.03240753f, -0.01361382f, 0.00555456f, 0.07586800f, -0.00517104f, 0.00632598f, -0.14415681f, 
    0.08094279f, 0.26702181f, 0.05550438f, 0.29714558f, 0.02206394f, -0.06382020f, 0.13318151f, 0.05745793f, 
    -0.11465290f, -0.09950242f, 0.18513854f, -0.06501354f, -0.03478037f, 0.04282879f, -0.00839583f, -0.06908039f, 
    -0.00390326f, -0.15198699f, 0.04953549f, -0.03802604f, -0.18014556f, 0.09175593f, -0.11737245f, -0.17987816f, 
    0.29584607f, 0.36358467f, 0.03143702f, -0.06430264f, -0.17850100f, -0.10828879f, -0.18130372f, -0.03681391f, 
    0.08940777f, 0.00840828f, -0.00730119f, 0.04083183f, 0.09886342f, 0.16948926f, -0.02398179f, -0.07948959f, 
    -0.05209857f, -0.05815478f, -0.03076156f, -0.18570836f, -0.00804531f, -0.00921430f, -0.01029997f, -0.08071652f, 
    -0.08533643f, 0.58124518f, 0.02597670f, 0.22591794f, -0.06666669f, -0.06155992f, 0.08831447f, -0.08876253f, 
    0.02505996f, 0.06220004f, -0.13727193f, 0.06022064f, 0.00477289f, 0.24905257f, -0.33537138f, -0.25806546f, 
    -0.02858260f, -0.01313072f, 0.15244517f, -0.00260337f, -0.11513993f, -0.02837998f, -0.00059031f, 0.00845113f, 
    0.09678789f, -0.18302178f, 0.16997270f, 0.09539890f, -0.02910290f, 0.00939791f, -0.18475728f, -0.03679584f, 
    -0.01341859f, 0.04383157f, 0.02240094f, 0.05925484f, 0.13282961f, 0.21948683f, 0.00076747f, 0.14740954f, 
    -0.15508015f, -0.12057361f, -0.06783306f, -0.08413801f, 0.07493997f, 0.03292887f, -0.02333898f, 0.01407312f, 
    0.16036266f, -0.00659054f, -0.05963757f, 0.05161925f, 0.17031807f, 0.04996422f, 0.05216007f, -0.12903209f, 
    0.01858696f, 0.00191374f, -0.10130531f, -0.02181955f, -0.07202367f, -0.38565707f, 0.16695398f, -0.20988673f, 
    -0.11438417f, -0.07475436f, -0.22269419f, 0.03016567f, -0.01128692f, -0.11902170f, 0.06858519f, -0.03048220f, 
    0.06709813f, 0.27635995f, 0.29334456f, -0.05613268f, 0.03298875f, 0.11120536f, -0.23534676f, -0.05642413f, 
    0.07786983f, 0.04162085f, -0.12591711f, 0.12615529f, -0.05158178f, 0.17309214f, -0.16495736f, 0.04520296f, 
    -0.07828154f, 0.10472489f, -0.02012269f, 0.00169793f, -0.20388709f, -0.06080702f, 0.02885137f, -0.07959209f, 
    0.19434498f, -0.03170741f, 0.05844441f, 0.13239835f, -0.03427820f, 0.01494741f, -0.10015513f, 0.09985987f, 
    -0.01503875f, 0.01767146f, 0.00086244f, 0.00840250f, 0.07128106f, 0.03799170f, 0.07973886f, 0.03188211f, 
    -0.05303875f, 0.10127006f, 0.03102935f, -0.13123536f, -0.07194690f, 0.00286784f, -0.01432681f, -0.08157714f, 
    0.16321644f, 0.15314344f, 0.06579144f, 0.23513243f, 0.11721908f, 0.15372138f, 0.11057816f, 0.06161307f, 
    -0.00655502f, 0.03494570f, 0.04402404f, -0.05766626f, -0.42992404f, 0.20531450f, -0.26648679f, -0.11062779f, 
    -0.01710427f, -0.00786611f, 0.13748311f, -0.02260882f, -0.02170624f, -0.08872706f, -0.02740759f, -0.04650843f, 
    0.10736798f, -0.39588851f, 0.03034578f, -0.07687655f, -0.15870544f, -0.04858786f, 0.10377710f, 0.09394779f, 
    -0.09710489f, 0.02523920f, -0.13601466f, 0.01010995f, 0.10620616f, 0.10606208f, -0.01018686f, -0.10826417f, 
    0.12268373f, 0.04754378f, -0.06286023f, 0.11019465f, -0.11381015f, -0.00256498f, -0.13428323f, 0.08689210f, 
    0.18563469f, 0.11529824f, -0.01133760f, 0.17355357f, -0.12531967f, -0.09621616f, 0.08022989f, -0.20019642f, 
    0.13440621f, -0.11618330f, -0.11909435f, -0.04206996f, 0.20751235f, 0.21395330f, 0.10788181f, 0.20003942f, 
    -0.13593294f, -0.11937964f, -0.00972591f, -0.13214570f, 0.05717587f, 0.07293690f, -0.13110727f, 0.03608261f, 
    0.11960080f, 0.26113433f, -0.21980599f, -0.03320994f, -0.05595149f, 0.04882155f, -0.00964661f, -0.20442563f, 
    0.04377206f, -0.00846910f, 0.04757022f, -0.12688857f, 0.56043434f, -0.12963814f, -0.02958808f, 0.11698680f, 
    -0.06162360f, -0.07158981f, 0.14030775f, 0.13791566f, 0.06849276f, 0.02672263f, 0.05271217f, -0.00779776f, 
    0.13326402f, 0.04157764f, 0.12292103f, 0.05481669f, 0.18281780f, -0.04040648f, -0.07271884f, -0.12528324f, 
    -0.07021386f, 0.01145803f, 0.00713570f, 0.09274666f, 0.08026426f, 0.21671729f, -0.02322199f, 0.01350531f, 
    -0.02704025f, -0.12417397f, -0.14694658f, -0.15037110f, -0.06436303f, -0.03057374f, 0.00685530f, 0.03340093f, 
    0.14941251f, 0.09225257f, -0.13117480f, 0.17328718f, 0.08875965f, 0.00390217f, -0.01894368f, 0.03534093f, 
    -0.10527973f, -0.13220048f, -0.26889586f, -0.06654508f, -0.15914853f, -0.22879516f, -0.08301596f, 0.02550199f, 
    -0.07223525f, -0.02371741f, 0.01138053f, 0.23318169f, 0.13831925f, 0.05417303f, 0.05459085f, 0.01985238f, 
    -0.10768189f, 0.15901221f, 0.15334009f, -0.04615546f, -0.02288669f, -0.00517058f, -0.21172479f, -0.06503893f, 
    -0.04325798f, 0.05831092f, -0.09433389f, -0.12282714f, -0.10318174f, 0.17368913f, -0.17139077f, 0.09938827f, 
    0.19756025f, -0.00890676f, 0.05547076f, -0.12185086f, -0.02262245f, -0.05032945f, 0.07887724f, 0.01909178f, 
    0.04600640f, -0.15946062f, -0.16489026f, 0.06368781f, 0.13218684f, 0.09862980f, 0.12605709f, 0.12829885f, 
    -0.04490580f, 0.07452105f, 0.00419585f, -0.02451104f, -0.03917471f, 0.05802726f, 0.09106430f, -0.07232421f, 
    -0.02681956f, 0.22627258f, -0.05946328f, -0.08766066f, 0.01502708f, 0.10103700f, 0.16602996f, 0.04318020f, 
    0.04090106f, 0.02521478f, 0.08462756f, 0.09306711f, 0.11746316f, 0.17687707f, 0.08951062f, 0.17340112f, 
    -0.03414273f, 0.01289900f, 0.06511720f, 0.00485414f, -0.00066601f, 0.09790998f, -0.19018595f, -0.14299086f, 
    0.09230794f, 0.03006736f, -0.01484402f, 0.01051373f, 0.02389012f, 0.06745704f, 0.19222088f, 0.08737648f, 
    -0.20062651f, -0.18413854f, 0.20802800f, 0.04202282f, 0.00954632f, -0.12297957f, 0.07285549f, 0.30392843f, 
    -0.07826926f, -0.02768802f, -0.06056016f, 0.13215914f, 0.09589794f, 0.01003675f, 0.03900446f, -0.25703958f, 
    0.04427021f, 0.09401648f, -0.12778787f, 0.20266542f, 0.04961276f, 0.21585068f, 0.06939749f, 0.16534898f, 
    0.27146947f, 0.22979690f, 0.00204642f, 0.39765620f, -0.16791086f, -0.09183631f, 0.07028112f, -0.25967449f, 
    0.11482655f, -0.09260424f, -0.04939884f, 0.03019355f, 0.00368924f, 0.14153661f, 0.07006658f, -0.08502235f, 
    -0.20124587f, -0.11919487f, -0.05846266f, -0.14370354f, 0.04024059f, -0.06337060f, -0.05079265f, -0.00539274f, 
    -0.03509012f, 0.44900030f, -0.10379784f, 0.02434279f, -0.00889694f, 0.07371940f, -0.07200772f, -0.12671149f, 
    0.06394459f, -0.04404109f, -0.01615732f, 0.05913512f, 0.35130703f, 0.48554811f, -0.08633088f, -0.11756600f, 
    -0.05179401f, -0.00265256f, 0.02959552f, 0.31498912f, -0.01924366f, -0.10153223f, 0.01493791f, -0.13270661f, 
    -0.20658012f, 0.11426093f, 0.03782663f, 0.18755992f, 0.04422022f, -0.19747987f, -0.16836645f, 0.00501560f, 
    0.01237471f, 0.06408456f, 0.07776053f, 0.16806844f, -0.07891010f, 0.20818038f, 0.05090252f, -0.18234910f, 
    -0.13134030f, -0.12776648f, -0.25411534f, -0.09162664f, 0.10074256f, 0.04514682f, 0.05333718f, 0.03683000f, 
    0.05622647f, 0.01482104f, 0.19350886f, 0.12394738f, 0.21294679f, -0.09272828f, 0.12664263f, 0.08102858f, 
    0.21262535f, 0.09175306f, 0.09239634f, -0.00308957f, 0.29673448f, 0.29140353f, 0.04036653f, -0.45668006f, 
    -0.13329573f, -0.05843129f, 0.10868996f, 0.13536377f, 0.05636893f, 0.04518906f, 0.07678798f, 0.08732229f, 
    -0.09307311f, 0.03671553f, -0.05578519f, 0.04981020f, 0.04132000f, 0.06859111f, -0.07159232f, -0.01463676f, 
    0.01520125f, 0.12400407f, 0.04606168f, 0.06776794f, -0.07182499f, 0.10249291f, -0.07914522f, 0.07369494f, 
    -0.00537697f, 0.13828225f, -0.08112654f, -0.17231032f, 0.01760927f, -0.09573466f, -0.03544255f, -0.01684172f, 
    0.10067818f, 0.15105441f, -0.24362066f, -0.32098752f, -0.01691177f, 0.02570098f, 0.02845024f, 0.00339096f, 
    0.03166332f, 0.10978886f, -0.02767377f, 0.02746840f, 0.03911708f, 0.01251344f, 0.25573897f, 0.44421041f, 
    -0.00695891f, -0.05576601f, -0.01353828f, -0.16518930f, -0.00229441f, 0.09143429f, 0.18529679f, -0.06555127f, 
    0.16816865f, 0.19824952f, 0.04181471f, -0.22824328f, 0.06679534f, -0.11747626f, -0.01294358f, 0.11820377f, 
    -0.05956510f, -0.01189082f, -0.05003453f, -0.06196835f, -0.26490173f, -0.02808442f, -0.11680843f, -0.23734623f, 
    -0.01338558f, -0.23573773f, 0.10392136f, -0.01683729f, -0.07892181f, -0.19815525f, 0.00653221f, -0.27307454f, 
    0.31165180f, -0.21942380f, 0.02101289f, -0.24822107f, -0.18949878f, 0.14160149f, 0.07652608f, 0.21274392f, 
    -0.07601675f, 0.12483595f, -0.17347945f, -0.01561936f, -0.23261313f, -0.06835587f, -0.01923076f, 0.06299418f, 
    0.02101150f, 0.13074154f, -0.01229376f, 0.07350980f, -0.00027423f, -0.12178101f, -0.16615276f, -0.05368990f, 
    -0.20316173f, -0.29454279f, -0.06866275f, 0.04704610f, -0.03627966f, -0.15676659f, 0.08078778f, 0.00811233f, 
    0.01591431f, 0.13880928f, -0.11800183f, 0.12230600f, 0.13886726f, -0.08535626f, 0.00096317f, 0.14421020f, 
    0.01727652f, 0.18310641f, 0.01782255f, -0.01511545f, -0.00526180f, -0.00275516f, 0.04693484f, -0.00429967f, 
    0.42181790f, -0.31929737f, 0.00226379f, -0.01009058f, 0.03546407f, -0.00304450f, 0.06002808f, 0.23332965f, 
    0.08671878f, 0.03349666f, 0.00575485f, -0.10891364f, -0.02057877f, -0.03670257f, 0.24734397f, 0.31591588f, 
    0.02267386f, 0.11583632f, -0.08283837f, 0.02808465f, 0.08873523f, 0.11307738f, 0.10169411f, 0.05998075f, 
    0.24218667f, -0.05946951f, -0.03614574f, 0.01829082f, 0.05526027f, 0.15458353f, -0.17305557f, -0.08802114f, 
    -0.11480994f, 0.01535646f, -0.11607633f, 0.11964434f, 0.12520587f, -0.07355488f, -0.06145556f, -0.24736226f, 
    0.03485899f, 0.03293340f, -0.00920789f, 0.03242005f, -0.15462506f, -0.04750459f, -0.12823255f, 0.00015666f, 
    -0.23760830f, -0.08626298f, -0.13620478f, 0.11162666f, -0.06742006f, 0.08182417f, -0.04258307f, -0.00081729f, 
    -0.01748517f, -0.14717382f, -0.13543092f, -0.00676751f, -0.05475301f, 0.51876915f, 0.13443482f, 0.53110367f, 
    -0.01489083f, 0.04279171f, 0.09577478f, 0.10110781f, 0.06588925f, 0.14061782f, 0.05751508f, 0.13987626f, 
    -0.06976479f, -0.12937745f, -0.01638403f, -0.17361651f, -0.08004739f, -0.03479492f, 0.11117388f, -0.03690295f, 
    0.24953976f, 0.21060562f, 0.20713310f, 0.09539013f, -0.01026235f, 0.02067615f, -0.18852068f, 0.01080315f, 
    0.15538788f, -0.20182943f, 0.00368930f, -0.02363784f, 0.01003061f, 0.02684244f, -0.10768047f, -0.04987764f, 
    -0.27206004f, -0.19895595f, 0.05789032f, 0.17822839f, 0.01599944f, 0.11529855f, 0.10618355f, 0.05783501f, 
    0.07304634f, 0.01777593f, -0.06768876f, 0.00742316f, 0.12289068f, -0.03423910f, -0.11479454f, -0.26626441f, 
    -0.02890512f, -0.02570025f, 0.02674397f, 0.06736716f, -0.01403242f, 0.15466635f, 0.06268796f, -0.00625270f, 
    -0.12792216f, -0.27458254f, 0.02749537f, 0.23516238f, -0.05724061f, 0.00912231f, -0.09226528f, 0.02200683f, 
    0.06154390f, 0.08761853f, 0.11401501f, -0.07680351f, 0.34095374f, -0.42452049f, -0.32516235f, 0.28517181f, 
    0.05716741f, -0.09437394f, 0.01934920f, 0.07367968f, 0.02502917f, -0.03032615f, -0.05545594f, -0.01534625f, 
    -0.28743669f, 0.29507238f, 0.30887124f, 0.35097784f, 0.20120543f, 0.00062413f, 0.07152318f, 0.04694770f, 
    0.06793126f, -0.15625092f, -0.02135186f, -0.04662711f, 0.13678375f, -0.04861327f, -0.13702722f, -0.07397507f, 
    0.06697902f, -0.04191735f, -0.01540210f, -0.08450114f, -0.06944405f, 0.08209503f, -0.12621431f, -0.06112788f, 
    0.05877417f, 0.31542489f, 0.12816539f, 0.01988903f, -0.07898040f, -0.01671598f, 0.00130417f, -0.04549909f, 
    -0.04950771f, -0.07526977f, 0.01886697f, -0.12698197f, -0.21074726f, 0.02292038f, -0.11064389f, -0.35982344f, 
    -0.03211338f, -0.16700412f, -0.02524519f, -0.06806706f, 0.10620288f, -0.00300728f, -0.16443627f, 0.05792282f, 
    -0.13532582f, 0.14330472f, 0.24732786f, 0.15808077f, -0.04499035f, 0.08909412f, 0.04354197f, -0.01796500f, 
    0.09855860f, -0.04896552f, 0.03178932f, 0.00784494f, -0.17277771f, 0.29742202f, -0.00476520f, -0.11157972f, 
    0.03830230f, 0.24570844f, -0.06807449f, 0.19021428f, 0.00918808f, -0.01219940f, 0.10236758f, 0.05208704f, 
    -0.07280292f, 0.21497862f, 0.02344292f, -0.03855288f, 0.05730821f, -0.04472208f, 0.16989245f, -0.09364340f, 
    0.06794821f, -0.04528882f, -0.08602914f, -0.11063844f, -0.25741655f, -0.28995991f, 0.13114560f, -0.06519067f, 
    0.07748514f, 0.01626900f, -0.00751930f, -0.06920319f, 0.02833040f, 0.01607419f, -0.00938334f, 0.02889441f, 
    -0.13186045f, -0.06964511f, -0.05310743f, 0.06830855f, 0.05600357f, -0.06959399f, -0.09383741f, 0.02407223f, 
    -0.08227681f, -0.16045466f, -0.09984646f, -0.03930746f, -0.09983785f, 0.29690233f, 0.10529849f, 0.29699099f, 
    0.11130833f, -0.01374161f, 0.13712773f, 0.15501779f, 0.11902064f, 0.20120768f, -0.00546886f, 0.12924471f, 
    -0.00403838f, -0.08710725f, -0.01430430f, 0.09348974f, -0.12019461f, -0.12153964f, -0.07016163f, 0.11855304f, 
    -0.04217520f, 0.22045802f, -0.02772072f, -0.07115446f, 0.08456403f, -0.09351423f, -0.00608748f, -0.12334144f, 
    0.27375230f, -0.08919779f, -0.02821191f, 0.03649822f, 0.16147733f, -0.00057062f, 0.02397802f, 0.06101761f, 
    -0.15943322f, -0.11675061f, -0.11589605f, 0.02603701f, 0.09960324f, 0.05599133f, 0.13482299f, 0.00068171f, 
    -0.13496245f, 0.03417286f, -0.07415334f, -0.02453925f, -0.06673764f, -0.17466496f, -0.05849615f, 0.04755645f, 
    -0.15485333f, 0.00338249f, -0.04734973f, -0.03251185f, 0.01100056f, 0.06640892f, 0.19189677f, 0.22228509f, 
    -0.07800059f, -0.15720177f, -0.09634749f, 0.08085919f, 0.05208077f, -0.06676657f, -0.11144137f, 0.11230285f, 
    0.05731792f, 0.06913375f, 0.03199407f, -0.05714381f, 0.30479172f, -0.27121481f, -0.09893291f, 0.04167964f, 
    0.06164249f, 0.04202651f, 0.07115003f, 0.09165698f, 0.02000309f, -0.03555875f, 0.12585908f, -0.01385473f, 
    -0.04469251f, 0.23000562f, 0.13210315f, 0.20591480f, 0.08479950f, 0.20833987f, -0.03873635f, 0.11463995f, 
    -0.03291935f, 0.02787414f, 0.06157463f, 0.05135006f, -0.16330132f, -0.00128709f, -0.21861626f, 0.03536814f, 
    -0.12592509f, -0.03044445f, -0.01256689f, -0.05780291f, 0.01102496f, 0.07539473f, 0.01033371f, -0.07631068f, 
    -0.00924475f, 0.28685299f, 0.17683315f, -0.04651965f, -0.09573808f, -0.03783403f, -0.11131670f, -0.10552301f, 
    -0.10387354f, -0.02277201f, 0.08242087f, 0.06135430f, -0.02602101f, -0.01564570f, -0.00275253f, -0.26991382f, 
    -0.08325129f, -0.13897042f, -0.07171075f, -0.01843896f, -0.10328948f, 0.05560859f, 0.10171109f, -0.11346255f, 
    -0.29719079f, 0.28747356f, -0.02116545f, 0.28793165f, -0.01857243f, 0.08025574f, 0.14958839f, 0.00487438f, 
    0.05815051f, 0.08141661f, -0.08191582f, 0.10616843f, -0.53893340f, 0.50917530f, -0.32401159f, -0.13514355f, 
    0.05160887f, 0.23466992f, -0.06272247f, -0.20157614f, 0.00157231f, 0.03358951f, 0.13934459f, 0.09644810f, 
    -0.04172828f, 0.14699112f, 0.19545163f, 0.11849148f, -0.11790148f, 0.12537363f, -0.03324907f, 0.04805016f, 
    0.06897175f, 0.03356750f, -0.08814868f, -0.01844687f, 0.06709804f, -0.12043888f, 0.04618339f, -0.00478632f, 
    -0.08858719f, -0.02811560f, -0.01367079f, -0.10172218f, -0.03254027f, 0.03296774f, -0.10869365f, -0.13888560f, 
    0.12220544f, 0.13660434f, 0.09409057f, -0.10806161f, 0.08607727f, 0.19531684f, -0.11928386f, 0.12342666f, 
    -0.01375052f, 0.03240871f, 0.03976673f, -0.04545753f, -0.31539634f, -0.25956133f, 0.16153662f, 0.12975965f, 
    -0.02676327f, -0.08108566f, 0.11412420f, 0.09571224f, -0.29972377f, 0.07314365f, -0.01268615f, -0.23667897f, 
    -0.16346417f, -0.02969426f, -0.21215393f, -0.12316614f, 0.05288595f, 0.01221061f, -0.00314284f, 0.00482337f, 
    -0.06274249f, -0.01212938f, 0.03971389f, 0.03617652f, 0.02019523f, 0.04709648f, 0.25416002f, -0.11035973f, 
    -0.12259077f, -0.03155497f, 0.02568711f, 0.03494520f, -0.02338605f, -0.11168453f, -0.04908101f, -0.08691083f, 
    0.27608013f, 0.05859326f, 0.10968508f, 0.14510274f, 0.05036082f, -0.11599473f, 0.01336496f, 0.10868639f, 
    0.03715263f, 0.01747196f, 0.14100243f, 0.09808876f, -0.08851467f, 0.18685707f, -0.12479750f, -0.23777314f, 
    -0.07936087f, 0.04311423f, 0.03770234f, 0.01622615f, 0.11225671f, -0.02215790f, -0.11379099f, -0.05833013f, 
    0.13464950f, 0.22013108f, 0.00904272f, 0.12290848f, -0.01745344f, 0.01017371f, 0.04742391f, 0.02001462f, 
    -0.01971304f, -0.10556423f, 0.03529202f, 0.00346128f, 0.05165238f, 0.30855796f, 0.12612243f, 0.11653899f, 
    -0.05378191f, 0.10148308f, 0.08415583f, -0.17223930f, 0.04730818f, -0.05387149f, -0.05569253f, 0.01393766f, 
    0.08875488f, 0.00283064f, 0.07309087f, 0.14802529f, 0.03136735f, -0.00325895f, -0.08725165f, -0.13988169f, 
    -0.07827565f, 0.02304633f, 0.07179648f, -0.07724908f, 0.04960397f, 0.15674269f, 0.12363727f, 0.00591334f, 
    0.00609908f, -0.10130120f, 0.21856013f, -0.04780763f, 0.00460140f, -0.09896658f, 0.11432928f, -0.03994211f, 
    0.16099958f, -0.24620844f, 0.22854692f, -0.02751249f, -0.11727861f, 0.12074426f, -0.07407436f, 0.06581470f, 
    0.00512541f, -0.05242168f, 0.00378450f, -0.03334108f, -0.08442254f, -0.11056375f, -0.11652568f, -0.06933604f, 
    0.08522165f, 0.12290542f, -0.07301641f, 0.01797196f, 0.00654952f, 0.07979850f, 0.01498755f, -0.02614878f, 
    0.23258480f, -0.01816810f, -0.22827637f, 0.10376903f, -0.10733901f, 0.15057430f, -0.21535395f, 0.01903060f, 
    -0.14241874f, -0.11857434f, 0.12618771f, -0.02282082f, 0.38024041f, -0.40082288f, 0.03640708f, 0.32365832f, 
    -0.12174871f, 0.02128302f, 0.00293862f, -0.17788491f, -0.09246992f, -0.01724443f, -0.05996843f, 0.11557177f, 
    -0.04255328f, -0.03149793f, 0.17981693f, 0.09529566f, 0.02888216f, -0.15293245f, 0.21592525f, 0.00541184f, 
    -0.09319337f, 0.11108271f, 0.07272234f, -0.02910301f, 0.05556067f, -0.04381218f, -0.07428324f, 0.15789595f, 
    -0.10352912f, 0.06828818f, 0.11405998f, -0.01399779f, 0.02750411f, 0.03607157f, 0.10052636f, 0.01427606f, 
    -0.08710258f, -0.00416025f, 0.04758364f, 0.10778829f, -0.02143485f, -0.16867992f, -0.11764546f, -0.03674908f, 
    0.22895910f, 0.19583204f, 0.06444219f, 0.00168685f, 0.02791317f, -0.01640563f, -0.04089769f, -0.45666200f, 
    -0.20150848f, -0.11735319f, 0.03843831f, -0.00006543f, 0.13938311f, 0.12131158f, 0.07296114f, 0.07558648f, 
    0.21984506f, -0.04033376f, 0.03938621f, 0.04537214f, -0.07313184f, 0.07780354f, 0.01738903f, 0.16863389f, 
    0.11922838f, 0.17965569f, 0.13970205f, 0.02306835f, -0.05770120f, 0.01110985f, 0.05493470f, -0.03827092f, 
    0.06873325f, -0.08551852f, -0.04698116f, 0.08202196f, -0.01726592f, -0.09217900f, -0.13245933f, 0.06674514f, 
    0.14689562f, -0.07914621f, -0.04625021f, -0.31311584f, -0.10293072f, -0.11319687f, 0.14756621f, 0.04953780f, 
    0.10496385f, 0.04427459f, 0.02284827f, 0.10274754f, 0.12389381f, 0.08471996f, 0.11961894f, 0.21288206f, 
    0.00120835f, -0.03340928f, -0.07943367f, -0.10119183f, -0.18765438f, 0.06125348f, 0.07436153f, -0.09857950f, 
    -0.14690456f, -0.04802437f, -0.35026860f, -0.25161374f, 0.06156845f, -0.19603367f, -0.09483522f, 0.11368792f, 
    0.03899880f, 0.06144338f, -0.06419141f, -0.14053172f, -0.24289060f, -0.06820010f, 0.06542640f, -0.19568479f, 
    -0.07219166f, -0.10862254f, -0.15390599f, 0.08299413f, -0.05939790f, -0.01708177f, -0.10834369f, -0.25242895f, 
    0.48412707f, 0.11973712f, 0.26711783f, -0.15136291f, -0.20570680f, 0.08951248f, 0.21100393f, 0.09825969f, 
    -0.14061421f, -0.04480736f, -0.16083200f, -0.00788988f, -0.09925240f, -0.05963206f, -0.07014660f, 0.10607476f, 
    0.00573168f, 0.07939439f, -0.06181398f, -0.00310722f, -0.02262466f, -0.07430503f, -0.23562993f, -0.05231894f, 
    -0.07043401f, -0.02395966f, 0.16912134f, -0.03913147f, 0.05858182f, -0.02229858f, 0.00522731f, 0.08053313f, 
    -0.11014589f, 0.04122899f, -0.06280657f, 0.07801719f, 0.11966743f, 0.04906994f, 0.16992724f, 0.11909497f, 
    0.08050190f, 0.03120641f, 0.01459588f, -0.08733629f, -0.05313139f, -0.01070223f, 0.01749017f, -0.10292154f, 
    0.00894049f, -0.05423833f, 0.09697603f, -0.09137651f, 0.16445464f, 0.09356021f, -0.01477756f, 0.38477612f, 
    0.00633821f, 0.04450933f, 0.05206051f, 0.07948021f, -0.27707601f, -0.10331322f, 0.04976042f, 0.16888858f, 
    0.01607329f, 0.14319843f, -0.09177268f, -0.08727220f, -0.02898227f, -0.00469788f, 0.07651457f, 0.11200543f, 
    0.41715801f, 0.16126750f, 0.22911072f, -0.07097672f, 0.09639988f, 0.00643711f, -0.10436561f, -0.05781485f, 
    0.02180596f, -0.06657788f, -0.13215432f, -0.04943906f, 0.29402405f, 0.08013440f, 0.02650786f, 0.02250226f, 
    0.09185126f, -0.08640380f, -0.04105198f, 0.05352705f, -0.11238325f, -0.09573935f, -0.01226837f, 0.02367673f, 
    0.03941011f, -0.06597339f, -0.09131827f, 0.02697833f, 0.06274080f, -0.07627859f, 0.01221933f, -0.01334772f, 
    -0.02767069f, -0.04725020f, 0.02820870f, 0.02481410f, -0.00363183f, -0.06841132f, -0.06139454f, 0.04855334f, 
    0.01684699f, -0.03104089f, 0.01637889f, 0.03046933f, 0.02338734f, 0.04677828f, -0.07397822f, -0.02515794f, 
    -0.01035302f, 0.05904581f, -0.05155017f, -0.06747378f, -0.01700555f, -0.03326149f, 0.00742009f, 0.05043277f, 
    0.00593031f, -0.03413004f, -0.04423437f, -0.05338399f, -0.03420239f, -0.07418045f, 0.04964118f, 0.03085140f, 
    0.04272677f, -0.01211506f, -0.00831219f, 0.05285562f, -0.03029314f, -0.05741492f, -0.01248906f, 0.02109547f, 
    -0.04475927f, -0.05517517f, 0.03169437f, 0.02589248f, -0.06020011f, 0.04267816f, -0.05530931f, 0.03422160f, 
    0.06159833f, 0.04232365f, -0.05987926f, -0.06347827f, 0.03407530f, -0.07418365f, 0.02687929f, 0.04157056f, 
    -0.02748406f, 0.03190687f, 0.01090922f, -0.08085075f, 0.00119239f, -0.05950812f, -0.03627260f, -0.01030267f, 
    0.01571850f, -0.00514523f, 0.00291968f, 0.02713162f, -0.07151297f, -0.01734123f, -0.06720735f, -0.03394895f, 
    0.02445241f, -0.01807271f, -0.02792308f, -0.05637356f, -0.04677415f, 0.03222531f, 0.00651250f, -0.06954847f, 
    0.00742849f, 0.03022697f, 0.04344295f, -0.03778558f, -0.03399826f, 0.01514750f, -0.05629767f, 0.04207848f, 
    0.05660584f, 0.03595779f, 0.00911730f, -0.03354973f, 0.03879179f, -0.01080367f, -0.04869728f, -0.02290774f, 
    -0.06680627f, 0.01454904f, 0.06006424f, -0.00663914f, 0.00229863f, -0.03397204f, 0.04354285f, 0.04951984f, 
    -0.02751637f, -0.03262081f, -0.00329854f, 0.05047405f, 0.00621384f, 0.06450146f, -0.07945159f, 0.00304746f, 
    -0.08477751f, 0.06317345f, -0.02180780f, -0.02226046f, -0.00818168f, -0.02367725f, 0.01476697f, 0.06154246f, 
    0.05428736f, -0.07299061f, -0.03510195f, -0.05591425f, 0.03093726f, -0.02493429f, 0.02396326f, 0.03029124f, 
    -0.06380162f, 0.01372501f, -0.07021951f, -0.02578731f, -0.03309732f, -0.03715257f, -0.03282493f, -0.03938490f, 
    0.06115505f, -0.04970518f, 0.05707508f, -0.04070851f, -0.00250934f, 0.05758270f, 0.00099580f, 0.06598137f, 
    0.03326221f, -0.04405643f, -0.04991689f, -0.00515537f, 0.04274122f, 0.04727922f, -0.02106098f, 0.05958063f, 
    -0.00080570f, -0.01001033f, 0.04079565f, -0.00400336f, 0.00910229f, -0.05025649f, -0.01193097f, 0.03671756f, 
    -0.08640108f, 0.05403408f, 0.05380135f, 0.03723912f, -0.06349632f, 0.02316017f, 0.04481719f, -0.01738555f, 
    -0.00887175f, 0.06315125f, -0.05855408f, -0.06121035f, -0.04861455f, -0.07312774f, -0.04185468f, -0.06104540f, 
    -0.03745270f, 0.06576601f, 0.03119763f, 0.01901752f, 0.01737897f, -0.01055553f, 0.02804724f, -0.04820680f, 
    -0.17980297f, 0.12688848f, -0.02161818f, 0.18406463f, 0.06413507f, -0.06238763f, 0.04888085f, -0.21117693f, 
    0.15964565f, 0.10152157f, -0.11260723f, -0.02633919f, 0.40636614f, 0.23901287f, 0.33544099f, 0.26791424f, 
    0.05877723f, -0.09046391f, 0.11766381f, 0.03825913f, 0.09177013f, 0.06182612f, 0.07719628f, 0.12951276f, 
    -0.13991044f, 0.42587024f, 0.06299289f, -0.07903878f, -0.12712228f, -0.02701252f, -0.32687962f, -0.14084212f, 
    -0.04870074f, 0.06218761f, -0.19845955f, 0.02067419f, -0.15060627f, 0.19350821f, -0.32561314f, 0.25549102f, 
    -0.17467813f, 0.12008172f, 0.02765586f, -0.00373591f, 0.00493204f, -0.05669597f, 0.01319405f, 0.08481915f, 
    -0.19321346f, -0.15966976f, 0.02376782f, 0.01670096f, -0.04345331f, 0.11576676f, 0.01965051f, -0.00861973f, 
    0.00537188f, 0.00970631f, 0.01574397f, 0.07873192f, -0.28055280f, 0.05681354f, -0.07489746f, 0.12826611f, 
    -0.00081666f, 0.11955448f, 0.01798910f, 0.00422726f, 0.02284406f, 0.09620972f, 0.04403398f, -0.04310254f, 
    0.02048781f, -0.00155054f, 0.10929658f, 0.26492828f, -0.09485508f, 0.06735680f, 0.05701192f, -0.02644315f, 
    0.00177495f, 0.06671094f, -0.04603243f, -0.09777551f, -0.29761872f, -0.03685746f, -0.55667824f, 0.01623060f, 
    -0.14282420f, 0.02936609f, 0.02968864f, 0.05184076f, 0.10418520f, -0.08807687f, -0.01992356f, 0.05048024f, 
    0.14202316f, -0.39472890f, 0.28222290f, -0.22830595f, -0.14315137f, -0.04230231f, 0.11612022f, 0.10143802f, 
    -0.05769871f, 0.03111243f, -0.00134552f, 0.17209929f, -0.03400785f, 0.08566502f, -0.15364443f, 0.01087686f, 
    0.18664683f, -0.02466137f, -0.08756132f, 0.17961520f, -0.09595571f, 0.10525560f, -0.10724365f, 0.12379850f, 
    -0.01089266f, 0.10275681f, 0.03079383f, 0.09607086f, -0.18940181f, 0.00456530f, 0.00502063f, -0.17924643f, 
    0.08477299f, -0.10072555f, -0.01075039f, -0.12785199f, 0.04669888f, 0.01330453f, -0.07790735f, -0.14526951f, 
    -0.28941822f, -0.19937292f, 0.10681748f, -0.03955349f, -0.13965508f, 0.00390303f, -0.11627559f, -0.01332568f, 
    -0.27654985f, 0.45661613f, -0.29667729f, 0.35926577f, -0.17078845f, 0.04535251f, -0.06440790f, 0.01093336f, 
    0.10835548f, -0.12471659f, 0.15778182f, -0.00412109f, 0.18714011f, 0.16210793f, 0.11001846f, 0.07503537f, 
    0.11880799f, -0.04082790f, 0.02058123f, 0.19030309f, -0.06364542f, 0.10815085f, 0.07246969f, -0.03046549f, 
    0.24420454f, 0.07317912f, 0.18331787f, -0.01968781f, 0.04462174f, -0.07618370f, -0.11359768f, 0.00981257f, 
    -0.03658012f, 0.08457398f, -0.07237650f, -0.08233283f, -0.25438809f, 0.21072127f, -0.12349458f, -0.14695206f, 
    -0.06859385f, 0.09731307f, -0.27621606f, -0.15187998f, 0.00150721f, -0.12924032f, 0.08819599f, 0.11190193f, 
    0.09958053f, 0.03394075f, 0.00483105f, -0.02994396f, 0.05349698f, 0.00521252f, -0.04307630f, 0.02900550f, 
    -0.05876464f, -0.03165976f, -0.08519505f, -0.00572339f, 0.00744207f, -0.10060810f, 0.04145276f, -0.12586488f, 
    0.05069049f, -0.02846781f, 0.03323433f, -0.05335088f, -0.07349820f, -0.02831610f, 0.02730631f, -0.04205861f, 
    0.00230201f, -0.03921507f, -0.06279416f, 0.02110312f, 0.00790369f, 0.03735990f, -0.03965558f, -0.06280335f, 
    0.05742900f, 0.03153236f, -0.01815555f, -0.03096041f, -0.04584120f, -0.10754042f, 0.05083835f, -0.01580818f, 
    -0.02116902f, -0.00060090f, -0.06294332f, -0.11905912f, 0.04670033f, -0.10052804f, 0.06653503f, 0.00250412f, 
    -0.04447664f, -0.01716566f, 0.05100296f, -0.09573641f, 0.05969034f, 0.03976854f, 0.03183421f, 0.03194299f, 
    0.02839915f, 0.05527071f, -0.00929457f, -0.07706641f, -0.00341855f, -0.02564439f, -0.00169286f, 0.03836982f, 
    -0.05877317f, -0.07622664f, -0.07143585f, -0.01506230f, -0.08906326f, -0.03234005f, -0.11911746f, -0.00784894f, 
    0.04177614f, -0.03427700f, 0.04994550f, -0.02764885f, -0.00100304f, -0.08200300f, -0.01939238f, -0.01041071f, 
    -0.00404063f, -0.08122931f, 0.07653319f, 0.03172586f, -0.02681980f, 0.06709439f, 0.02381236f, -0.01161489f, 
    0.01250318f, 0.00850537f, -0.02885091f, -0.08689470f, -0.03647152f, 0.00702075f, -0.00964630f, 0.00463977f, 
    -0.03229599f, -0.02017074f, -0.01102619f, -0.01591706f, 0.00027061f, 0.00784170f, -0.07617857f, 0.01534920f, 
    -0.03323251f, -0.01193536f, 0.09479295f, -0.09159008f, -0.02946114f, -0.02266707f, -0.00487689f, -0.05178118f, 
    -0.08491333f, -0.09796659f, -0.10506055f, -0.03030678f, -0.03057485f, 0.06324255f, -0.03603959f, -0.00619217f, 
    -0.03685433f, -0.10301579f, -0.02623514f, 0.01406761f, -0.00476597f, -0.09953137f, 0.00015333f, -0.07102127f, 
    0.02068470f, -0.03213651f, 0.03663149f, 0.03250028f, -0.01146523f, -0.03602875f, -0.07680570f, 0.05122613f, 
    -0.02028361f, -0.07250291f, 0.02174348f, -0.03505672f, -0.00692326f, 0.02590887f, -0.11186010f, -0.05749087f, 
    0.02009368f, 0.02586985f, -0.01826276f, -0.07198230f, -0.00024109f, -0.03398964f, -0.01010697f, -0.03499573f, 
    -0.08334578f, 0.02691219f, -0.10699134f, -0.00107109f, -0.02948443f, -0.08926450f, 0.07660452f, -0.04599695f, 
    -0.00811722f, -0.04012458f, 0.03976619f, -0.08805621f, -0.07280400f, -0.06989187f, -0.10265326f, -0.06894384f, 
    -0.04562261f, 0.00543276f, -0.04180136f, 0.03688773f, -0.12928458f, -0.02045058f, 0.02672637f, -0.05464308f, 
    0.05358305f, 0.00633004f, 0.04636658f, -0.04345565f, 0.00441092f, -0.05265573f, 0.02226941f, -0.01181358f, 
    -0.00224366f, 0.03056119f, -0.02150241f, -0.05129600f, -0.01995583f, -0.10118639f, -0.09408807f, -0.09294110f, 
    0.03386829f, 0.22720991f, -0.00672172f, 0.02417117f, 0.08499681f, -0.05795410f, -0.12121791f, 0.19354062f, 
    -0.10894426f, 0.06784337f, -0.02445315f, 0.00152315f, -0.05901806f, 0.15127499f, -0.22221056f, -0.48672038f, 
    -0.12369600f, 0.01687919f, 0.08226433f, 0.01686490f, -0.06043854f, -0.18831359f, -0.10338617f, 0.12322907f, 
    0.11886872f, -0.06169954f, -0.00517457f, 0.04326085f, 0.13196465f, -0.01963815f, 0.09806900f, -0.18459685f, 
    -0.11634537f, -0.09462260f, -0.00039348f, -0.21538472f, -0.09599543f, -0.14534847f, 0.28273022f, 0.12775378f, 
    -0.07628050f, 0.07818068f, 0.00791762f, 0.02055951f, -0.00077707f, 0.00966943f, -0.00205581f, -0.02259007f, 
    0.03781641f, 0.27556512f, 0.05727884f, -0.06444590f, 0.00200831f, -0.21133743f, -0.06121564f, -0.10493296f, 
    0.09263345f, 0.05960873f, -0.16421212f, -0.15984395f, 0.16220778f, 0.00537641f, 0.18192871f, 0.03030342f, 
    -0.17376150f, -0.09395503f, -0.17925684f, -0.19006866f, 0.14630012f, -0.03039234f, -0.07950160f, -0.01760227f, 
    -0.02972228f, 0.18166973f, 0.03880956f, -0.11863250f, 0.06337128f, 0.08248153f, -0.02257757f, 0.03144575f, 
    0.04665275f, -0.18530309f, -0.09127004f, 0.13589087f, -0.22745465f, 0.08118740f, 0.21942559f, 0.12868068f, 
    0.09765450f, 0.15198438f, 0.06649669f, -0.04065099f, -0.09096593f, 0.08596808f, -0.07940385f, -0.09007839f, 
    -0.16669303f, -0.00342091f, -0.09834190f, -0.04351960f, 0.06981351f, 0.09872176f, -0.12168875f, 0.10347516f, 
    -0.10092629f, -0.07038912f, 0.02776118f, -0.03011042f, -0.14025719f, -0.08721554f, 0.28088456f, -0.11122430f, 
    -0.12298857f, 0.16780199f, 0.08472151f, 0.14043824f, 0.13966760f, 0.05764842f, 0.28356481f, -0.12159265f, 
    -0.03356481f, -0.31306934f, -0.11126351f, 0.11707675f, 0.04651901f, 0.05876140f, 0.09306171f, 0.09111562f, 
    -0.02815348f, 0.07133504f, 0.03745148f, 0.05179045f, -0.00299354f, -0.02802914f, -0.13630535f, 0.02699959f, 
    -0.01964022f, 0.12087452f, -0.10444564f, -0.01178021f, 0.12003424f, -0.04125503f, 0.03296636f, -0.06208210f, 
    0.28629944f, -0.40229928f, 0.27592266f, -0.31111765f, 0.18101749f, 0.10956775f, 0.07349144f, 0.27691865f, 
    0.03016205f, -0.05368749f, 0.01237503f, -0.02940004f, 0.33697954f, -0.30295017f, 0.45153174f, 0.17136337f, 
    0.03956392f, -0.10957500f, -0.08683367f, 0.20588619f, 0.14981891f, 0.01582950f, 0.02301994f, -0.07418301f, 
    -0.15372314f, 0.07640222f, 0.14656664f, 0.23863065f, -0.01244322f, 0.01525186f, 0.01792837f, 0.19520333f, 
    0.07227794f, 0.01415251f, 0.20720062f, 0.07707620f, -0.02772242f, -0.01084731f, 0.02110648f, -0.23564422f, 
    0.01550668f, -0.09218442f, 0.10719831f, 0.07197027f, -0.17366473f, 0.09636030f, -0.06198514f, -0.14639167f, 
    0.20117569f, -0.25958109f, 0.17816240f, -0.08627655f, 0.20163515f, 0.11190885f, 0.06804235f, -0.00889349f, 
    0.17832698f, 0.07213989f, 0.25279117f, 0.29105204f, 0.50426221f, 0.38353798f, 0.36025226f, 0.63675946f, 
    -0.06203619f, 0.01030001f, -0.19657332f, 0.14064042f, -0.00236798f, -0.03385756f, 0.03229149f, 0.09468835f, 
    -0.10929964f, 0.03688051f, -0.14796114f, -0.00307986f, -0.11798435f, 0.06592968f, -0.08814901f, -0.03100315f, 
    -0.03661385f, 0.20981684f, 0.00130041f, 0.27759993f, 0.10403258f, 0.09286438f, -0.38752499f, 0.06677515f, 
    -0.10743303f, 0.01999351f, 0.08902986f, 0.02550153f, -0.02910209f, -0.09665097f, -0.20488524f, -0.18077813f, 
    0.05569790f, -0.03549564f, -0.00506790f, -0.03715244f, 0.07678688f, 0.05493667f, -0.12143357f, 0.02709661f, 
    0.11277851f, 0.09151719f, -0.03855173f, 0.03656705f, -0.08279065f, -0.00925108f, -0.19574545f, 0.04723993f, 
    -0.04338172f, 0.14086333f, 0.03234472f, 0.04010171f, -0.17868198f, 0.01587960f, -0.17430465f, 0.04989283f, 
    0.05314660f, -0.04346322f, 0.03503110f, 0.16737047f, 0.12411490f, -0.00124097f, 0.07300000f, -0.09148987f, 
    -0.09167198f, -0.05735810f, -0.14399280f, -0.23591734f, 0.12659453f, 0.11803589f, -0.32865709f, -0.10112692f, 
    -0.14051704f, 0.05005442f, -0.09788135f, 0.13093369f, -0.08228756f, -0.20436721f, -0.05096134f, -0.09114547f, 
    0.06091595f, -0.19442874f, 0.07732508f, -0.08450408f, 0.15362191f, -0.05948563f, 0.03736193f, -0.11156399f, 
    0.02120061f, -0.09447078f, -0.05786148f, 0.08088479f, -0.05200888f, 0.11531789f, -0.13824199f, 0.12787317f, 
    0.19942640f, -0.10046379f, 0.06415558f, -0.04005750f, -0.27767771f, -0.23672298f, -0.31029719f, -0.14018786f, 
    -0.06443828f, 0.07871022f, -0.07872860f, -0.05477881f, -0.11211308f, -0.12482621f, -0.05563398f, 0.04642801f, 
    -0.13430926f, -0.00049757f, 0.07719707f, -0.32915762f, -0.12317909f, 0.05632294f, -0.06195280f, 0.04825455f, 
    -0.03801938f, -0.46135718f, -0.03760125f, -0.06347108f, -0.12986588f, -0.20723674f, -0.17634000f, 0.21330383f, 
    -0.00422415f, 0.19157234f, -0.11901456f, 0.37939367f, 0.00691445f, -0.09509476f, 0.09297065f, -0.10657470f, 
    0.10633036f, -0.01566148f, 0.06127579f, -0.03580606f, 0.13200662f, 0.09068267f, 0.08662036f, 0.07817457f, 
    0.13484852f, -0.06796156f, 0.19587886f, -0.04169123f, 0.04614566f, 0.01215401f, 0.04877256f, 0.19547601f, 
    -0.16590956f, -0.03829467f, 0.03225396f, -0.42869571f, -0.06900546f, 0.16567284f, -0.02314093f, 0.01398404f, 
    -0.05407441f, -0.19692288f, -0.22931160f, -0.01490001f, -0.60406548f, -0.24184610f, 0.10970626f, 0.04163392f, 
    0.05216303f, 0.09263803f, -0.12772015f, -0.06403239f, -0.12064288f, -0.01499445f, 0.00709200f, -0.06445754f, 
    -0.04543234f, 0.01718372f, 0.03509029f, -0.06804363f, -0.00343287f, 0.00144801f, 0.05591813f, 0.03201684f, 
    -0.04890844f, -0.02242864f, 0.03225258f, -0.01206782f, -0.04074088f, -0.01824022f, 0.03065272f, -0.01195408f, 
    0.06137643f, -0.03576383f, 0.03552988f, -0.06242881f, -0.06153819f, 0.01216731f, -0.06681066f, 0.00306492f, 
    -0.00790734f, -0.00124775f, 0.01771443f, -0.04521858f, -0.07333732f, 0.01670511f, -0.02953982f, 0.05154116f, 
    -0.03714053f, 0.03328885f, -0.05266001f, 0.00823182f, -0.01209245f, -0.02798611f, -0.00494308f, -0.00273244f, 
    -0.04310700f, -0.03937827f, -0.04506609f, -0.02631440f, 0.01801423f, 0.02565496f, -0.07597674f, -0.02988692f, 
    -0.04380276f, -0.05601387f, 0.06434818f, 0.00635140f, 0.00715809f, -0.05747259f, -0.00749097f, -0.03145649f, 
    0.03803032f, -0.05160493f, -0.01427590f, 0.03941187f, 0.05172001f, 0.03941431f, -0.06370999f, -0.07231063f, 
    -0.06443914f, 0.03019277f, 0.02391196f, -0.00652928f, 0.01798345f, -0.04732956f, 0.04035589f, 0.00521485f, 
    -0.02903692f, -0.00035453f, 0.00408210f, -0.04781233f, -0.04569672f, -0.04901491f, -0.04667725f, 0.04931226f, 
    -0.02193137f, -0.05745270f, -0.03286649f, 0.00173940f, 0.01782176f, -0.04078858f, 0.03070575f, 0.05864787f, 
    0.03853616f, -0.03752393f, -0.05258564f, -0.04046595f, 0.00290012f, 0.02285008f, -0.06153715f, 0.06468278f, 
    -0.06406231f, -0.00278736f, -0.05286658f, -0.05251543f, -0.04637267f, -0.07522663f, -0.01693006f, -0.04226239f, 
    -0.07022429f, 0.02783457f, 0.02738643f, -0.05287934f, 0.02508475f, 0.02244734f, -0.04328829f, -0.01007991f, 
    -0.06821113f, -0.00121636f, -0.00545591f, 0.01377735f, 0.04639887f, -0.05396426f, -0.05909956f, -0.00749719f, 
    0.05253858f, -0.04904711f, -0.00457446f, -0.02054853f, 0.06342690f, -0.05499451f, 0.06444469f, -0.03340458f, 
    0.04166213f, -0.06475725f, 0.04964324f, -0.03445202f, -0.00790119f, -0.04163404f, 0.01099595f, 0.00827993f, 
    -0.02490831f, -0.00407000f, -0.03635140f, 0.03798676f, -0.06443899f, 0.04886232f, -0.00821664f, 0.03863186f, 
    0.01449700f, -0.06168216f, -0.01949137f, 0.01835789f, -0.06927408f, 0.01391631f, 0.01693854f, -0.00440052f, 
    0.05711501f, 0.06134199f, -0.06273506f, 0.04652460f, -0.02507999f, -0.04168665f, 0.04401209f, 0.04968798f, 
    -0.03805921f, -0.00308283f, 0.06406209f, -0.01835835f, 0.02851149f, 0.05241599f, -0.06923442f, 0.04057890f, 
    0.01377537f, -0.02745803f, -0.04128726f, -0.00649793f, -0.05732257f, -0.00588098f, 0.04736777f, -0.01646775f, 
    0.00804122f, 0.05569366f, 0.02931818f, -0.05050267f, 0.01086159f, -0.03912409f, -0.06287720f, 0.05218070f, 
    0.02245414f, -0.06024095f, -0.01622550f, -0.04774554f, 0.01678702f, 0.03817431f, -0.02821356f, -0.03518647f, 
    0.03654031f, -0.17573513f, -0.06500746f, 0.15937591f, 0.00594597f, -0.07896142f, -0.10289334f, 0.11905207f, 
    0.05928654f, 0.03730463f, 0.00676368f, 0.29386675f, -0.08746883f, 0.37944326f, -0.17309672f, 0.07611223f, 
    -0.12265752f, 0.01712706f, -0.00547416f, -0.07263707f, 0.14203785f, -0.00614526f, -0.00915449f, 0.14100870f, 
    0.24880290f, -0.38060665f, 0.19372378f, 0.15347071f, 0.00175459f, 0.03321109f, -0.14782082f, -0.06893523f, 
    0.15155667f, 0.09020455f, 0.09930746f, 0.11086986f, 0.09200706f, -0.05974988f, -0.24164107f, -0.02428990f, 
    0.12247813f, 0.00004752f, 0.24917145f, -0.28180963f, -0.10423419f, 0.06205393f, -0.18724011f, -0.31124863f, 
    0.08746389f, 0.25062817f, 0.07598484f, 0.27847472f, 0.10688306f, 0.20513614f, 0.18098903f, 0.19033799f, 
    0.07645352f, 0.12068957f, -0.01975664f, -0.04148079f, 0.16843729f, -0.10252091f, 0.08494650f, -0.27511427f, 
    0.08535544f, 0.07682962f, -0.18469529f, -0.35291392f, 0.04624559f, 0.13904074f, -0.11045717f, 0.08420084f, 
    0.02181496f, 0.01425243f, 0.21986856f, 0.14748153f, -0.04433877f, 0.19422269f, 0.07925132f, 0.11621028f, 
    0.02121993f, -0.04570077f, 0.03160420f, 0.00522503f, -0.04306893f, -0.31534126f, -0.03425109f, 0.11997863f, 
    0.23767905f, 0.16804042f, -0.07975555f, 0.09246572f, -0.01537271f, -0.23636797f, -0.22338164f, 0.02475112f, 
    -0.36118916f, 0.29075262f, -0.13761462f, 0.16161661f, 0.20752227f, -0.17084239f, 0.04327684f, 0.01072747f, 
    0.11019431f, -0.12726475f, -0.09171174f, -0.03928952f, 0.17368336f, -0.18916003f, -0.09450851f, -0.56778884f, 
    0.07690100f, 0.09210984f, 0.00324726f, 0.13195151f, 0.10479886f, 0.09438807f, -0.15985759f, -0.16913135f, 
    0.13885961f, 0.14455707f, -0.02732950f, 0.18226466f, 0.18677473f, -0.08108395f, 0.12316485f, -0.04844430f, 
    -0.11205468f, -0.00675293f, 0.00402125f, -0.22225139f, 0.02948922f, -0.01825150f, -0.10402258f, 0.02529159f, 
    0.09680991f, -0.09553721f, 0.00880946f, -0.08069072f, 0.12694512f, -0.05213481f, -0.01858594f, 0.02015724f, 
    -0.07939244f, -0.06053832f, 0.36774656f, -0.25648013f, -0.04372869f, 0.01781552f, 0.19263653f, 0.11527201f, 
    -0.05182345f, 0.09703299f, -0.01202102f, 0.01917380f, 0.10396460f, 0.27269837f, 0.22443496f, -0.18029895f, 
    -0.04645405f, 0.07322971f, -0.00303536f, 0.20734955f, 0.20985816f, 0.00030432f, 0.15781595f, 0.00890964f, 
    -0.24925688f, -0.05511765f, -0.07188737f, -0.22643563f, 0.02324882f, 0.02883893f, -0.06599781f, -0.15682004f, 
    0.15196182f, -0.14787441f, 0.10966775f, -0.09536795f, -0.04552044f, -0.23089635f, 0.27908489f, -0.27850342f, 
    0.04460832f, -0.27155712f, -0.20304489f, 0.05520059f, -0.07245469f, -0.02512711f, -0.10052031f, -0.20584053f, 
    -0.05396339f, 0.02597961f, -0.06698864f, 0.03210712f, -0.03219064f, -0.03249769f, 0.02832390f, 0.04002932f, 
    -0.00334672f, 0.00407959f, 0.00310866f, -0.03368896f, -0.05509510f, -0.03380862f, 0.00422079f, -0.06397003f, 
    -0.04810473f, 0.01625586f, -0.03886634f, -0.01804318f, -0.01860846f, -0.06896549f, 0.02021674f, 0.05460293f, 
    -0.01339558f, 0.06447310f, 0.00960326f, -0.05662782f, 0.03584809f, 0.07119792f, -0.01622322f, 0.03294679f, 
    -0.02817409f, -0.02985247f, -0.06058524f, 0.02672492f, -0.03858052f, -0.03816678f, -0.01918219f, 0.01830848f, 
    0.06557428f, -0.03568569f, 0.05993383f, -0.05649726f, -0.04729332f, -0.03857296f, 0.00720573f, 0.02623481f, 
    -0.00249604f, -0.06785967f, -0.00440694f, -0.06957751f, 0.00820244f, -0.03925060f, 0.00777930f, -0.00819704f, 
    -0.05489185f, -0.01201745f, 0.06427656f, -0.00104877f, -0.05551035f, -0.03721941f, -0.04118213f, -0.03574928f, 
    -0.06181494f, -0.04546322f, 0.06187060f, 0.04386253f, 0.01945544f, 0.00783659f, -0.03875278f, -0.01437254f, 
    0.02500666f, -0.05169236f, -0.01101389f, -0.05063028f, 0.02573407f, -0.04909788f, -0.01978487f, -0.01698039f, 
    -0.02742964f, 0.02087426f, -0.05433552f, 0.02352226f, 0.00795737f, 0.07039900f, 0.03517058f, -0.00774821f, 
    -0.02578381f, 0.07103378f, 0.05780672f, -0.00147364f, -0.04669770f, 0.03363900f, -0.02994293f, -0.04387895f, 
    0.01044939f, 0.00350877f, -0.02524699f, -0.02154060f, -0.04104885f, 0.00499410f, -0.06285541f, 0.03912833f, 
    -0.03326621f, 0.05205010f, 0.04246177f, 0.03653165f, -0.05165072f, 0.04799034f, -0.00558557f, -0.06220179f, 
    -0.02607160f, 0.05092921f, -0.04688333f, -0.00633202f, 0.01183502f, -0.05656594f, -0.03475229f, -0.03370490f, 
    0.05274212f, 0.02933820f, 0.06859291f, -0.01788409f, -0.05547250f, 0.00124523f, -0.01819683f, -0.00789054f, 
    -0.01764192f, -0.06019655f, 0.04915098f, -0.02471443f, 0.00333941f, -0.07146192f, 0.00094257f, 0.05327607f, 
    -0.03762423f, -0.04841387f, 0.02487505f, 0.01232181f, 0.04022747f, 0.01534152f, -0.03463966f, -0.06803819f, 
    -0.02640484f, -0.05695020f, -0.06328162f, -0.05051975f, -0.02395691f, -0.05822393f, -0.02270239f, 0.04953710f, 
    -0.02025662f, -0.00227965f, -0.05708396f, -0.06931750f, 0.06164568f, 0.01996025f, 0.00525372f, -0.06286008f, 
    -0.00770256f, 0.04890420f, 0.02792055f, 0.02016388f, 0.05678175f, -0.06185733f, 0.06710715f, 0.00228547f, 
    -0.04363412f, 0.01520470f, 0.00025901f, 0.00764957f, -0.05331568f, 0.03631159f, 0.02400198f, -0.05338361f, 
    -0.01811398f, -0.05944180f, 0.06789719f, -0.02735640f, -0.03301443f, 0.02008093f, 0.05587829f, 0.01639153f, 
    -0.05335613f, 0.03711385f, -0.03319051f, -0.01906198f, -0.04763548f, -0.01996361f, -0.04359492f, -0.03169402f, 
    -0.09046015f, 0.00912044f, -0.11581656f, 0.07667456f, -0.01380800f, 0.06955461f, -0.03776260f, 0.07734219f, 
    -0.22873844f, -0.05343088f, -0.10764226f, 0.06248895f, -0.27762330f, 0.11815955f, -0.13089721f, 0.14459267f, 
    -0.00932262f, 0.06521391f, 0.11791559f, 0.07068683f, -0.12574247f, -0.02306192f, -0.11324932f, 0.10814547f, 
    -0.09340679f, 0.05329013f, 0.01722231f, -0.10155476f, -0.08697878f, -0.03999161f, -0.05617148f, -0.13155864f, 
    0.09866096f, -0.14418837f, 0.07888882f, 0.04772076f, 0.02625234f, -0.06978995f, -0.11050571f, 0.01470303f, 
    0.23170617f, -0.11992750f, 0.06598651f, -0.23608479f, -0.01066963f, 0.17816742f, 0.01764335f, 0.04268019f, 
    -0.14825913f, -0.04380595f, -0.06641970f, 0.16426969f, 0.15597557f, 0.07874616f, 0.04027513f, -0.02032938f, 
    0.00147940f, -0.00236950f, -0.05040854f, -0.10612088f, 0.12784411f, -0.07573280f, 0.07087957f, -0.10364960f, 
    -0.04584436f, -0.07099322f, -0.09312968f, -0.14919280f, 0.02555095f, 0.09560512f, -0.04130123f, 0.05626061f, 
    -0.19136164f, -0.16917741f, 0.04201854f, 0.01853864f, 0.07627901f, 0.19406866f, 0.02571132f, 0.05616774f, 
    0.08966356f, -0.07065342f, 0.11676209f, 0.12448351f, 0.23603609f, -0.12209651f, -0.01715526f, 0.11454007f, 
    0.11286980f, 0.22096601f, -0.10355528f, 0.01549985f, 0.03407151f, 0.04541490f, 0.08452338f, 0.12701668f, 
    -0.73905098f, 0.28796762f, 0.18129669f, 0.12924765f, 0.10045908f, -0.06989568f, 0.00476097f, 0.22310901f, 
    0.00860229f, -0.17276907f, 0.08243893f, 0.01119256f, 0.15378301f, -0.03630402f, 0.11103681f, -0.13122377f, 
    0.00479103f, 0.01274612f, 0.05436865f, 0.00631127f, -0.03461323f, 0.19880211f, 0.20993994f, -0.00985023f, 
    0.03469129f, 0.12840515f, -0.19660333f, 0.16323441f, 0.02404534f, -0.05429865f, -0.01283708f, -0.11236269f, 
    0.05634987f, -0.15465519f, 0.09282263f, -0.02206325f, -0.07790954f, 0.08293832f, 0.00059323f, -0.10619036f, 
    -0.06545758f, -0.04925201f, 0.04050612f, -0.08383959f, 0.02358164f, 0.03432078f, 0.09223279f, 0.02745098f, 
    0.11817076f, -0.03296719f, 0.23442277f, -0.21411911f, -0.07670221f, 0.18566418f, 0.06134221f, -0.07317914f, 
    0.08704534f, -0.05899883f, 0.04114440f, -0.07729734f, 0.15061423f, 0.27666640f, 0.04267461f, -0.21037993f, 
    0.04488872f, -0.08720461f, -0.00956603f, 0.24539919f, 0.09493153f, -0.09687760f, -0.04752360f, -0.20422570f, 
    -0.51947057f, 0.02326071f, -0.02419277f, 0.17316228f, -0.14423718f, -0.01888825f, -0.03414757f, 0.05394749f, 
    0.13533363f, -0.04203678f, 0.07484047f, -0.05111090f, -0.15899245f, 0.01222612f, 0.11820042f, -0.12745598f, 
    -0.05215242f, -0.05713434f, 0.05204212f, -0.05253544f, -0.01399105f, 0.06599490f, 0.00025433f, 0.02514852f, 
    0.33987826f, -0.15198869f, 0.08234401f, 0.06033146f, 0.15368889f, 0.01466857f, 0.01852189f, 0.33706671f, 
    0.00743262f, 0.08637835f, 0.31086180f, 0.25185373f, -0.18669008f, -0.17978668f, 0.13660188f, 0.06815152f, 
    -0.07886456f, -0.06998511f, -0.04788952f, -0.19027871f, 0.12097029f, -0.04524269f, -0.15954469f, 0.07753102f, 
    0.10720434f, -0.32756057f, 0.17826059f, 0.27917349f, -0.08351325f, 0.11857467f, -0.11496883f, 0.11406142f, 
    0.06092425f, 0.15045090f, 0.17125045f, 0.07810182f, 0.19852963f, -0.07178707f, 0.01999403f, -0.27802920f, 
    0.08686139f, -0.04948658f, 0.14226130f, -0.15199821f, -0.09411248f, -0.06397942f, -0.06660610f, -0.38316187f, 
    0.13198291f, 0.00356928f, -0.00047020f, 0.07078577f, 0.12544325f, 0.20810990f, -0.02579092f, 0.19294882f, 
    0.00864028f, 0.04085213f, 0.02252299f, -0.02384868f, 0.04992042f, -0.19409478f, -0.04345390f, -0.25460339f, 
    -0.05964941f, 0.02677321f, -0.21623755f, -0.43623081f, -0.07657138f, 0.07241572f, -0.00425286f, 0.01560986f, 
    0.14055389f, 0.04120956f, 0.05265999f, -0.05918489f, 0.10967764f, 0.03803046f, 0.00300852f, 0.10360391f, 
    -0.08559447f, -0.13777216f, -0.14065617f, -0.02916411f, 0.27962244f, 0.17050013f, 0.17598243f, -0.18993656f, 
    0.24803337f, 0.23657396f, -0.04193636f, -0.16848128f, 0.10084436f, -0.31930819f, -0.09313222f, -0.07421828f, 
    -0.18074855f, 0.33028236f, -0.01794816f, 0.40642387f, 0.13090622f, -0.06794406f, 0.12846349f, 0.10732566f, 
    -0.11053707f, 0.16304472f, 0.04791973f, -0.05377359f, 0.02987454f, -0.20129341f, -0.03494874f, -0.34117219f, 
    -0.09891546f, 0.01231863f, -0.01696604f, 0.04718552f, -0.08940882f, -0.01170979f, -0.40681568f, -0.42003742f, 
    0.29852733f, 0.18116288f, 0.03445069f, 0.18936102f, 0.03855356f, -0.20757626f, -0.02244598f, 0.11424376f, 
    -0.14780870f, 0.06333870f, 0.12575397f, -0.06114085f, 0.20399792f, 0.21840121f, 0.02790517f, 0.05079382f, 
    -0.02170101f, -0.12210612f, -0.13706985f, -0.02248101f, 0.07723775f, -0.05027890f, 0.07237100f, 0.04656091f, 
    -0.00954866f, 0.28305152f, -0.00199754f, -0.09711536f, 0.03583216f, 0.01684672f, 0.13626246f, -0.00674483f, 
    -0.13272037f, 0.04623612f, -0.03792241f, 0.07301381f, 0.09714989f, 0.33983523f, -0.20412178f, -0.04074797f, 
    -0.07909350f, 0.15780139f, 0.22115256f, -0.04529544f, -0.00344366f, -0.04274947f, 0.18617474f, 0.17165598f, 
    -0.41075417f, 0.01889336f, 0.22948453f, -0.02203232f, -0.19453694f, -0.11758079f, -0.09248717f, -0.15991089f, 
    0.09748603f, 0.01553565f, 0.14823812f, 0.01746779f, 0.29741779f, 0.10382228f, 0.28344244f, 0.04545685f, 
    0.01324236f, -0.17483620f, 0.01378110f, 0.05472529f, -0.07794957f, 0.15402924f, -0.11742947f, -0.37043354f, 
    0.23486236f, -0.11264979f, -0.06817633f, 0.00375246f, 0.10059293f, -0.00086061f, 0.07355244f, 0.19546586f, 
    0.00123802f, 0.09764206f, 0.05763334f, 0.16037650f, 0.03100651f, 0.20289633f, -0.10980101f, 0.33552730f, 
    -0.27948660f, 0.18903823f, -0.05244796f, -0.17699189f, 0.16886982f, 0.05631881f, 0.09423354f, 0.10040190f, 
    -0.17806120f, -0.10046659f, 0.10704125f, 0.08155673f, -0.19217916f, 0.16504821f, -0.06325638f, -0.13928775f, 
    -0.01636928f, 0.10796821f, -0.02217615f, 0.16013576f, -0.09351836f, 0.05902919f, -0.27599400f, 0.06457672f, 
    0.25187069f, -0.02947394f, 0.21315062f, -0.31637001f, -0.05000428f, -0.00409415f, -0.24819635f, -0.12205814f, 
    0.06264225f, 0.01795178f, -0.31202915f, -0.09126770f, 0.00643392f, 0.07243989f, 0.03866743f, 0.20633514f, 
    0.09491332f, 0.08947759f, 0.02481509f, -0.05389640f, 0.25689429f, -0.06714075f, 0.11818372f, -0.01188397f, 
    0.04250881f, 0.13330197f, -0.06712718f, -0.33664644f, -0.00009720f, 0.24340069f, -0.05017925f, 0.09127329f, 
    -0.00978787f, -0.12013390f, -0.04664695f, -0.04316408f, 0.04237710f, 0.05579812f, 0.01801815f, 0.11078935f, 
    -0.02745203f, -0.12435742f, -0.10805879f, 0.04082134f, 0.17623048f, 0.00412054f, -0.20941417f, -0.05366686f, 
    0.12566674f, 0.09809914f, -0.03161124f, -0.01078728f, -0.05074350f, -0.25592065f, -0.12923330f, -0.06653329f, 
    -0.50098282f, 0.08760456f, 0.10056904f, 0.14764044f, 0.09235483f, -0.05795876f, 0.16335006f, 0.17859836f, 
    0.07693189f, 0.01246972f, -0.15717535f, -0.13942498f, 0.22680038f, -0.20109844f, 0.21626650f, -0.31999037f, 
    -0.03169558f, 0.18997294f, -0.00787034f, 0.05728536f, -0.04951802f, 0.08680371f, -0.10587454f, -0.18833259f, 
    0.03476706f, 0.17213665f, -0.06098324f, 0.12000219f, 0.07932220f, -0.13266589f, 0.06303832f, 0.21208505f, 
    -0.17378247f, -0.01471209f, 0.09912328f, -0.22404574f, -0.04386512f, 0.00448470f, -0.05670924f, -0.05611980f, 
    -0.01593558f, -0.01989778f, 0.01507097f, 0.01840209f, 0.03440689f, -0.05955415f, 0.01765475f, 0.04122619f, 
    0.24276651f, -0.12972988f, 0.05265726f, -0.07842481f, 0.04435988f, 0.02140222f, 0.11043092f, -0.10982227f, 
    -0.02997009f, 0.01074035f, 0.08483312f, 0.00356725f, 0.37865356f, 0.36137724f, -0.00525107f, -0.17259632f, 
    0.02157050f, 0.02167214f, -0.02150511f, 0.31473610f, 0.00965186f, -0.06701463f, 0.20550543f, 0.00385738f, 
    -0.59092337f, -0.09926070f, -0.08348721f, -0.08786707f, 0.14427638f, 0.00497666f, -0.05204357f, -0.16870791f, 
    0.13306989f, -0.04154810f, 0.04127585f, 0.11557241f, -0.34709898f, -0.14068682f, 0.22721843f, -0.07437981f, 
    0.18170744f, -0.09890058f, -0.08914657f, -0.06183467f, -0.22404267f, 0.02702600f, -0.03027131f, 0.00853440f, 
    -0.04951335f, -0.03228159f, -0.08706854f, 0.00323434f, -0.09017049f, -0.07411058f, 0.03013791f, -0.01917789f, 
    -0.05626893f, -0.01191738f, -0.06331108f, -0.06623314f, -0.04005791f, -0.01624596f, -0.03606214f, -0.05619019f, 
    0.02953503f, -0.10162313f, -0.07148585f, -0.01673647f, -0.03255538f, -0.06990448f, -0.03359057f, 0.00959511f, 
    -0.05993546f, 0.01048390f, -0.09590074f, -0.09332164f, -0.04343911f, -0.01959064f, -0.04556997f, -0.04085776f, 
    0.01016396f, 0.01791357f, -0.09844338f, -0.02558805f, -0.03494966f, 0.02731370f, -0.01718153f, -0.02390661f, 
    -0.00967191f, -0.09080713f, -0.05617924f, -0.02210280f, -0.07607536f, 0.01856312f, -0.02149518f, -0.01479670f, 
    -0.02078506f, -0.03063894f, 0.02952763f, -0.02667434f, -0.03712676f, -0.00355100f, -0.01965740f, -0.08500689f, 
    0.03399339f, -0.04422659f, -0.00596743f, -0.05744426f, -0.03841226f, -0.02006144f, 0.03520817f, -0.08133113f, 
    0.00361711f, -0.06418183f, 0.00952800f, -0.04561460f, -0.02349505f, -0.04212013f, -0.01126827f, -0.09960577f, 
    -0.04169413f, -0.07434769f, 0.03270353f, -0.00183593f, -0.09168930f, -0.08566959f, -0.06082818f, -0.04232681f, 
    -0.03407517f, 0.01809048f, -0.04169231f, -0.03996789f, -0.06777488f, -0.04390968f, -0.00630221f, -0.08137614f, 
    -0.05968899f, -0.01024137f, 0.02368409f, -0.06237721f, -0.06202473f, -0.04996724f, -0.05438552f, 0.02996644f, 
    -0.07436699f, -0.07821900f, 0.00986103f, 0.01181484f, 0.01036077f, -0.09636646f, -0.01724614f, -0.02940365f, 
    -0.10872976f, -0.01228329f, -0.03245884f, -0.01712762f, 0.00385855f, 0.00013046f, -0.08190834f, 0.00880462f, 
    -0.05849687f, -0.00023278f, -0.01418213f, -0.04762791f, -0.00789422f, -0.00234475f, -0.08555790f, -0.07214631f, 
    -0.11062364f, -0.06706508f, -0.04212928f, -0.06355063f, 0.00672240f, -0.06032809f, -0.05813564f, -0.06544080f, 
    -0.04988220f, -0.03236905f, -0.07257747f, 0.00084409f, -0.05046039f, 0.01391581f, -0.00762934f, -0.03643471f, 
    0.01719354f, 0.05307268f, -0.08031342f, -0.02065813f, -0.00402990f, 0.02273721f, -0.08090408f, 0.02373041f, 
    -0.01660132f, -0.01542366f, -0.08702611f, -0.04275878f, -0.01188106f, -0.09465729f, -0.00053937f, -0.08490951f, 
    -0.06184992f, -0.08222805f, -0.07667378f, -0.08724879f, 0.02375932f, -0.07784041f, 0.03279413f, -0.10379966f, 
    0.01239271f, -0.01087771f, 0.01474172f, -0.04993615f, -0.09016878f, -0.09348735f, 0.02703049f, 0.02257289f, 
    -0.01763793f, -0.02749004f, -0.00900706f, -0.04974341f, -0.03126507f, -0.00574843f, -0.01924777f, 0.05030759f, 
    -0.00265029f, -0.07988640f, 0.00978767f, -0.07793205f, -0.06130436f, -0.03743668f, -0.05527539f, -0.03986977f, 
    -0.05743374f, -0.08068916f, -0.05280785f, 0.01892705f, 0.00331791f, -0.05354049f, -0.07273614f, -0.06912786f, 
    0.01065907f, 0.21810955f, -0.12175664f, 0.00486452f, 0.09973589f, -0.13909081f, -0.09555823f, -0.01933468f, 
    -0.10943372f, 0.21299864f, -0.09107526f, 0.13379471f, 0.48954791f, 0.15465386f, -0.00080507f, 0.11199665f, 
    -0.21437889f, -0.07255107f, -0.17821229f, 0.04576681f, 0.07106438f, -0.04377872f, 0.01191973f, 0.03168928f, 
    -0.19743486f, -0.07408994f, -0.01063802f, -0.11400748f, -0.13121010f, -0.05387473f, -0.28217167f, -0.24296200f, 
    0.12769148f, -0.06800822f, -0.02323915f, 0.12335742f, -0.14587241f, -0.00327392f, -0.26965377f, 0.32983765f, 
    -0.06119303f, 0.17564927f, 0.05981103f, 0.11272842f, 0.03255511f, -0.00834156f, -0.02521174f, -0.07373331f, 
    0.00649146f, 0.08126071f, 0.08969226f, 0.14215724f, 0.01704437f, 0.13030076f, 0.08280215f, 0.05475353f, 
    -0.01460228f, 0.01551408f, -0.12201086f, -0.04235267f, -0.02235613f, 0.04633068f, -0.01658754f, -0.03337064f, 
    0.05113634f, 0.08962958f, 0.04605265f, -0.06007442f, 0.03963694f, 0.00691042f, -0.12381100f, -0.00828882f, 
    0.01760423f, 0.22495361f, 0.26423073f, 0.34769320f, -0.14032447f, 0.30314365f, 0.12275108f, -0.00905223f, 
    -0.02670017f, -0.03126149f, -0.09307925f, -0.07650160f, -0.57169950f, 0.18629444f, -0.08645943f, -0.01399734f, 
    0.15431659f, 0.11481053f, 0.02497818f, 0.19683404f, 0.02515216f, 0.10773011f, -0.00090294f, 0.05267893f, 
    -0.05368202f, -0.23688865f, 0.06650697f, -0.11119719f, 0.12831339f, -0.08895886f, 0.05472502f, 0.01759936f, 
    -0.13246822f, -0.00767331f, -0.11425424f, -0.02889930f, -0.04187573f, 0.04402001f, 0.10892947f, -0.20135958f, 
    0.15979470f, 0.18979050f, 0.03807703f, 0.15603875f, 0.02554505f, 0.19610335f, -0.07118443f, 0.08838633f, 
    -0.07609562f, -0.00437206f, -0.02983419f, 0.27376166f, -0.05110250f, 0.07377730f, 0.04322131f, -0.21068670f, 
    -0.03512654f, -0.07658530f, -0.01136588f, -0.17261738f, -0.10685466f, -0.14355859f, -0.11802400f, 0.13876088f, 
    0.04728053f, -0.14174615f, 0.10857425f, 0.00322864f, 0.12059985f, -0.03164302f, 0.06719420f, 0.15645073f, 
    -0.01000281f, 0.20497143f, -0.01511392f, -0.11284087f, 0.09561265f, 0.16271853f, 0.00519513f, 0.02634815f, 
    0.00605457f, -0.10025326f, -0.00696647f, -0.02559292f, 0.31860742f, 0.14503641f, 0.33050200f, -0.04900803f, 
    0.16359207f, -0.04980927f, 0.08743467f, 0.17120393f, -0.02675165f, 0.08045536f, -0.05233611f, -0.07551871f, 
    -0.14070517f, -0.00822511f, -0.17258149f, -0.05674519f, -0.08356669f, -0.09879138f, -0.04679732f, -0.08261132f, 
    0.04411069f, -0.06273754f, -0.05561385f, 0.01661522f, -0.21838689f, 0.10372499f, -0.03686243f, -0.12107600f, 
    -0.06562509f, -0.01042616f, -0.19275761f, -0.08922277f, 0.09577113f, -0.09921504f, 0.10584240f, 0.03212306f, 
    -0.31644559f, -0.02692638f, 0.01799502f, -0.01837381f, -0.13893059f, 0.09845732f, -0.03363259f, 0.04873455f, 
    -0.14423244f, 0.00824908f, 0.02646229f, 0.03381575f, -0.03349290f, 0.38100037f, -0.17661016f, -0.08585802f, 
    0.01131472f, 0.04224054f, 0.12440513f, -0.17402902f, -0.11007322f, 0.09165949f, 0.09351817f, 0.14233105f, 
    0.19257838f, -0.02385153f, -0.06878825f, 0.03443204f, 0.03309670f, -0.07045118f, -0.02244142f, -0.06228413f, 
    0.05051953f, -0.11524392f, 0.18317899f, -0.00185244f, -0.00592031f, -0.14804959f, -0.07013262f, -0.05810300f, 
    0.10383923f, -0.02655626f, 0.12898311f, -0.14954039f, 0.04586011f, 0.09484722f, -0.10766903f, -0.07896589f, 
    -0.02264089f, 0.21037018f, 0.09494490f, 0.12673096f, 0.11284266f, 0.03274475f, 0.05431513f, -0.10787322f, 
    0.02128115f, -0.02388400f, -0.14030759f, -0.05901802f, 0.04072794f, -0.16484196f, -0.03036054f, -0.10343089f, 
    0.02110381f, -0.10952522f, 0.03339943f, -0.12606327f, 0.00654406f, -0.01596823f, -0.05405565f, 0.02060115f, 
    -0.03837397f, -0.09200466f, 0.06754927f, -0.06954660f, 0.03198240f, 0.08389996f, -0.02888201f, 0.06689499f, 
    0.09456500f, -0.11911145f, -0.04850120f, -0.04203847f, 0.15088381f, -0.30589256f, 0.09936456f, 0.09188098f, 
    0.15242207f, 0.02896820f, -0.09411176f, 0.11692017f, -0.02125811f, 0.06878804f, -0.07038108f, 0.05516525f, 
    -0.25309867f, 0.40183389f, -0.12222439f, 0.02501190f, 0.27086383f, 0.02094492f, 0.02432498f, 0.05347812f, 
    0.09730265f, -0.13241819f, 0.03102476f, -0.13421586f, 0.10489787f, -0.09879019f, -0.00553303f, -0.06850760f, 
    -0.00328789f, -0.04656905f, 0.09127425f, -0.14399375f, 0.04084087f, -0.06805532f, 0.12030917f, -0.10406730f, 
    -0.05338342f, 0.00988427f, -0.11065365f, -0.06976017f, 0.18664998f, -0.00457873f, -0.13225132f, 0.05039765f, 
    -0.15681900f, -0.11116389f, 0.01484598f, -0.12022339f, 0.02781957f, 0.01584782f, -0.13815704f, -0.06950483f, 
    0.00295069f, -0.06411389f, -0.04028665f, 0.00003677f, 0.05057501f, -0.04729576f, 0.05235464f, -0.07330314f, 
    0.09321085f, -0.36821327f, 0.43695554f, -0.21932377f, 0.10836820f, 0.11646954f, 0.15865265f, 0.12521467f, 
    0.00354209f, 0.08365929f, 0.00603039f, -0.04176608f, -0.10690305f, -0.17334364f, 0.24524003f, 0.06085000f, 
    0.02285084f, -0.13249077f, -0.01316852f, 0.10931483f, 0.15160863f, 0.09963932f, -0.01577126f, -0.04294623f, 
    -0.11971769f, 0.00714072f, -0.07813169f, 0.10156932f, -0.06657793f, 0.09157672f, 0.03938010f, -0.04549223f, 
    0.11316201f, 0.02886557f, 0.00779886f, -0.12803534f, 0.05205379f, -0.19341265f, 0.02597197f, 0.00835471f, 
    -0.02757010f, -0.07245275f, 0.15590549f, 0.06800623f, -0.01852139f, -0.03116771f, -0.02021384f, 0.00108558f, 
    0.06305232f, 0.12829599f, 0.03405850f, 0.06747516f, -0.12808116f, 0.01606297f, -0.25722650f, 0.05105723f, 
    -0.03941382f, -0.02421629f, 0.13808927f, 0.14430366f, 0.17778961f, 0.40523967f, 0.14052677f, 0.40169746f, 
    0.08565838f, -0.01426164f, -0.06816734f, 0.01730735f, -0.06769422f, 0.00185723f, 0.02632538f, 0.03075036f, 
    0.10819307f, -0.08718903f, -0.28209201f, -0.15109563f, -0.01403414f, -0.11527497f, 0.06273977f, 0.12252074f, 
    0.19861773f, 0.04286159f, 0.24356005f, 0.10901269f, -0.03367937f, -0.19429788f, -0.03534589f, -0.15515104f, 
    -0.03062504f, -0.00834956f, 0.04989989f, 0.10825989f, 0.13255371f, -0.08536657f, -0.10554649f, -0.03228871f, 
    0.07942753f, 0.01894216f, 0.08805892f, 0.08752852f, 0.05630774f, 0.07716648f, 0.09358615f, 0.11754034f, 
    0.08447905f, -0.05389763f, 0.09564529f, 0.04204531f, 0.08104534f, 0.14055581f, -0.22930664f, -0.04740117f, 
    0.01095278f, -0.01259561f, -0.00686747f, 0.06399406f, -0.02556971f, -0.09759818f, -0.14547396f, 0.03766714f, 
    0.01207583f, -0.05561955f, -0.01052970f, 0.12627789f, -0.11973254f, 0.06529929f, 0.10063639f, 0.12814640f, 
    0.00753850f, -0.02254094f, 0.14309461f, 0.00318792f, 0.08644192f, -0.13343468f, -0.12235650f, 0.24973209f, 
    -0.03111436f, 0.05448858f, -0.01746576f, 0.08204138f, 0.03844200f, 0.12126351f, -0.07586391f, 0.11103493f, 
    0.05998432f, 0.23786007f, 0.14429867f, 0.09328108f, 0.21358339f, -0.03018769f, 0.01116143f, -0.23941198f, 
    0.05118895f, 0.02398242f, 0.12986599f, -0.02948844f, 0.03278134f, -0.06376546f, -0.00906071f, 0.03680548f, 
    0.14463378f, 0.10455021f, -0.01632182f, -0.22632638f, -0.11208553f, -0.03320869f, 0.06727801f, 0.01176594f, 
    -0.00688644f, 0.15376383f, 0.23880316f, 0.05525788f, 0.04898394f, 0.12044521f, -0.08681040f, 0.17696178f, 
    0.00059721f, 0.04106786f, -0.05489195f, -0.08397575f, -0.31166488f, -0.37425700f, -0.21854562f, -0.15096933f, 
    0.17498727f, -0.01665447f, -0.09991159f, 0.02979436f, 0.09468351f, -0.10792514f, -0.05310948f, 0.13472182f, 
    -0.16502452f, -0.19557470f, 0.17708480f, 0.24549872f, 0.04242613f, 0.02922692f, -0.06254149f, 0.04933521f, 
    -0.12135760f, -0.05046982f, -0.04226226f, 0.11213957f, -0.23058529f, 0.18462639f, 0.19765511f, 0.07027908f, 
    0.04800264f, 0.16785879f, -0.01337822f, -0.04823573f, -0.12232847f, 0.07000742f, -0.06688016f, 0.05579177f, 
    -0.15434539f, 0.22501966f, -0.19806162f, -0.35421252f, -0.16501302f, 0.02763375f, 0.25659379f, -0.14213385f, 
    -0.02952888f, -0.11426155f, -0.25493166f, -0.13227552f, -0.04532818f, -0.32028416f, -0.11977275f, 0.18313581f, 
    -0.02216280f, 0.07980016f, 0.05336647f, -0.04509977f, 0.08233292f, 0.04351272f, -0.12821032f, -0.09102327f, 
    0.02043539f, 0.26392615f, -0.13536870f, -0.08776666f, 0.09472544f, 0.09320045f, 0.08807293f, -0.13234061f, 
    -0.00755982f, 0.12304076f, -0.08994862f, -0.02836818f, 0.50565982f, -0.40169120f, -0.06592727f, -0.24808128f, 
    0.00890788f, -0.16859213f, -0.00837719f, -0.00916846f, 0.11608865f, -0.00961623f, 0.06300767f, -0.12410536f, 
    0.19193204f, 0.24466260f, 0.06587290f, -0.17229700f, -0.04392787f, -0.10372957f, -0.14136690f, 0.02811204f, 
    0.17121103f, 0.11131181f, 0.07290912f, -0.00048633f, -0.19585864f, 0.23297982f, 0.21649261f, 0.01711111f, 
    0.03955582f, 0.14153075f, -0.12273432f, 0.20058168f, -0.06779980f, -0.03846197f, 0.10427078f, 0.08754312f, 
    -0.02952964f, -0.06638497f, 0.02397684f, 0.15759246f, 0.06026173f, -0.09099143f, 0.09341265f, 0.12411219f, 
    -0.03428356f, 0.00495681f, 0.10464237f, 0.03338456f, -0.03119825f, 0.21775356f, 0.05130866f, 0.10874709f, 
    0.01444734f, -0.05194832f, -0.04291160f, 0.01764426f, -0.05424587f, -0.05153191f, 0.08138510f, -0.05162301f, 
    -0.13573918f, 0.05934305f, -0.11289968f, 0.17400792f, -0.00017005f, -0.08887173f, 0.10783488f, 0.04258699f, 
    -0.02831843f, 0.09754488f, 0.05284622f, 0.06783152f, -0.57214797f, 0.18066902f, -0.04897812f, -0.17200142f, 
    -0.04575729f, 0.14452764f, 0.00544873f, -0.01130256f, -0.05816095f, 0.02086585f, -0.04834912f, 0.03108437f, 
    0.52739459f, -0.29140294f, 0.18631981f, -0.17538913f, 0.00332035f, 0.14470412f, 0.12572752f, 0.10295875f, 
    -0.07131459f, 0.11862773f, -0.02880387f, -0.03016111f, -0.10586225f, -0.05489060f, 0.08334951f, 0.11465176f, 
    -0.00565636f, 0.06636265f, 0.03080428f, 0.00170385f, -0.07818941f, 0.03622063f, -0.05583747f, 0.01540058f, 
    0.05486354f, -0.06161286f, 0.22624783f, 0.09147213f, -0.08530369f, 0.02472258f, -0.03940421f, -0.16899200f, 
    0.05580752f, 0.02272437f, -0.07061208f, 0.07928350f, 0.08631422f, -0.03020501f, 0.04085921f, 0.13233157f, 
    -0.12988105f, -0.02972327f, -0.03537234f, -0.10554941f, -0.01013705f, -0.01825250f, -0.01004907f, -0.02380462f, 
    -0.32326722f, 0.39457902f, -0.10122852f, 0.19510551f, 0.02349213f, 0.07760588f, -0.19327882f, -0.00521756f, 
    0.05400510f, 0.03145095f, -0.03640418f, 0.02043342f, 0.11328054f, -0.07372318f, 0.02139301f, 0.02067840f, 
    0.10175449f, 0.06204922f, 0.13663444f, -0.14098713f, -0.02755145f, 0.05348163f, 0.07752838f, -0.04721371f, 
    0.36123490f, 0.09398899f, -0.05449444f, 0.10977145f, 0.06903125f, -0.16284104f, 0.01357331f, 0.16771710f, 
    -0.14472243f, 0.09220392f, -0.02564768f, 0.08997189f, 0.17839456f, 0.14758934f, -0.28411594f, 0.10020035f, 
    -0.11060886f, -0.01325581f, -0.03767941f, -0.08315814f, 0.04668224f, 0.01133720f, -0.04457678f, -0.03752758f, 
    -0.05746005f, 0.11842877f, -0.30771980f, 0.13485198f, 0.03660060f, 0.06381489f, -0.29278496f, 0.01401485f, 
    -0.03838146f, 0.09587525f, 0.03583685f, -0.01846519f, 0.42483166f, 0.31373990f, 0.00250625f, 0.26414764f, 
    0.04403698f, -0.19130337f, 0.09277970f, -0.05914623f, 0.03176034f, 0.11241441f, 0.00827558f, -0.07474306f, 
    -0.09876142f, 0.18204962f, -0.21027610f, -0.01154729f, -0.00651713f, 0.04101748f, 0.07314178f, 0.09287984f, 
    0.08486416f, 0.22302976f, 0.15799683f, 0.04631062f, -0.25063160f, 0.00703311f, 0.03090124f, -0.17600362f, 
    0.27599856f, -0.03504149f, -0.19014858f, 0.32453537f, 0.02377427f, -0.10673650f, -0.06150300f, 0.03862323f, 
    0.03850730f, -0.02293380f, -0.02772755f, 0.00027994f, 0.08325120f, 0.09434498f, 0.19350065f, 0.15947320f, 
    0.07196061f, -0.06052938f, 0.10383158f, 0.13023479f, 0.00769159f, 0.23599854f, -0.01405128f, 0.18024547f, 
    -0.02698409f, -0.01977839f, 0.12915525f, 0.00764583f, 0.13145079f, -0.01770620f, 0.11683267f, 0.13482836f, 
    0.03640196f, -0.17041983f, -0.21501780f, 0.02053858f, -0.14951679f, -0.15906915f, -0.02046376f, 0.00635492f, 
    -0.05299285f, 0.12058900f, -0.00710897f, 0.08080123f, -0.02510184f, -0.05694866f, -0.08794148f, 0.02314692f, 
    0.05163767f, 0.15929332f, -0.00775754f, -0.21100596f, -0.07577579f, 0.12742718f, 0.00446267f, -0.00398418f, 
    0.17085069f, -0.03324429f, 0.34860396f, 0.20088185f, 0.19218025f, 0.18555096f, 0.08218273f, 0.03113867f, 
    0.00569651f, -0.06965077f, 0.13646491f, -0.02031917f, -0.14081678f, -0.17685771f, 0.15882772f, 0.08625142f, 
    0.01360757f, -0.03750597f, 0.06182284f, -0.27531922f, -0.10371459f, -0.02242564f, 0.10581716f, -0.00478544f, 
    -0.03411018f, 0.07300426f, 0.19625205f, 0.19881324f, -0.04831724f, 0.03556935f, -0.08143696f, 0.06731943f, 
    -0.08146101f, -0.04291166f, 0.00251774f, 0.04543417f, -0.16170830f, -0.27219859f, 0.04385075f, 0.01649793f, 
    0.05644280f, 0.13192469f, -0.08804271f, -0.04676865f, -0.03672876f, -0.06738818f, -0.05902207f, -0.02351343f, 
    -0.39744473f, 0.05448886f, -0.17139915f, 0.32344246f, 0.14936568f, 0.17663951f, -0.14520164f, 0.02359748f, 
    -0.11774881f, -0.05702490f, -0.07621614f, 0.08686013f, -0.26016539f, 0.35184094f, -0.05223806f, 0.04256423f, 
    0.11673009f, 0.29271236f, -0.09171019f, -0.22433309f, -0.14081652f, 0.03479224f, 0.04411685f, 0.00629288f, 
    -0.13102718f, 0.04870303f, -0.22807230f, 0.02595721f, -0.03819536f, -0.02762368f, 0.28603965f, 0.02859650f, 
    -0.05061568f, -0.00607233f, -0.13367417f, -0.04630171f, -0.09357657f, -0.17699946f, -0.16273063f, 0.17041290f, 
    0.02548655f, 0.06687368f, 0.07875688f, -0.07880508f, 0.03576068f, 0.02902829f, -0.07664257f, 0.08827140f, 
    0.01458837f, 0.18387610f, -0.05569096f, -0.15572469f, 0.09505067f, 0.10772603f, -0.06562442f, -0.01285410f, 
    -0.10699390f, -0.11417034f, -0.20114174f, -0.04682757f, -0.14875163f, -0.15958002f, -0.25441760f, -0.00525508f, 
    0.05577180f, 0.10452865f, -0.06867344f, 0.13688758f, -0.00034517f, 0.00873008f, 0.02462722f, -0.04294517f, 
    -0.20590536f, 0.04255073f, -0.13010110f, -0.11048774f, -0.03797929f, -0.12152000f, -0.10866644f, -0.11101383f, 
    0.07206818f, -0.19510747f, 0.01872441f, -0.01360855f, 0.03009115f, -0.18626311f, -0.18899386f, 0.00820894f, 
    0.00359609f, 0.09378187f, 0.06253728f, -0.02264719f, 0.12047036f, 0.13356075f, 0.13445018f, 0.07782359f, 
    0.23731869f, 0.08188901f, -0.06452351f, -0.08144925f, 0.14947811f, 0.10013139f, -0.05154218f, 0.03292086f, 
    -0.05866343f, -0.03686435f, -0.06809963f, -0.08679300f, -0.26293290f, -0.08752393f, -0.05656642f, 0.00059357f, 
    -0.15045604f, -0.02978496f, -0.05076326f, -0.03288940f, 0.05765602f, 0.01617963f, 0.01821517f, 0.06790507f, 
    0.06298233f, 0.17315197f, 0.12862591f, 0.13913299f, 0.06807934f, 0.31305555f, 0.15021144f, 0.23563309f, 
    0.03629668f, -0.01470162f, 0.14837691f, 0.09488796f, 0.12162547f, 0.18796875f, 0.05612571f, -0.01060668f, 
    0.12934382f, 0.13986862f, -0.13939606f, 0.16788676f, -0.12708291f, 0.05980798f, 0.07640245f, 0.22114018f, 
    -0.26096341f, -0.06608489f, 0.11325447f, -0.04738479f, 0.03829446f, -0.05058764f, 0.00571178f, 0.05000376f, 
    -0.04776902f, 0.05733439f, 0.02546356f, 0.07097667f, -0.08372633f, -0.12313995f, -0.11831522f, -0.15864666f, 
    0.09750711f, -0.09682074f, 0.04842542f, 0.00262851f, 0.06102695f, 0.19342481f, 0.19608420f, 0.08572398f, 
    -0.13452075f, -0.07825878f, -0.00862962f, 0.14353278f, -0.08343298f, -0.05632295f, -0.10680497f, -0.21913582f, 
    0.07311822f, -0.04469214f, 0.11957581f, 0.06706323f, -0.19792728f, -0.17287782f, 0.00514794f, -0.04630831f, 
    -0.16521326f, -0.06206990f, -0.02590239f, -0.00126154f, 0.01582508f, -0.02471853f, 0.03902898f, -0.05473897f, 
    0.41282013f, 0.09308513f, -0.07915904f, -0.12543684f, 0.16821086f, 0.11151945f, -0.07502843f, 0.23133162f, 
    -0.00337955f, -0.00292238f, -0.01120317f, 0.08990279f, 0.15692584f, 0.08077532f, -0.01653501f, -0.12573738f, 
    -0.08828878f, -0.10031584f, 0.03015955f, 0.00795515f, -0.13175111f, 0.06467558f, -0.15017985f, 0.02370956f, 
    0.03171687f, -0.05578227f, -0.21985978f, 0.14744125f, -0.08957493f, 0.01573847f, -0.25740385f, -0.13370368f, 
    0.08315866f, 0.06133224f, 0.07526223f, -0.00798940f, -0.31557548f, -0.02468045f, -0.12361380f, -0.14481260f, 
    -0.12837857f, 0.08390906f, -0.21066533f, -0.07509162f, 0.02175231f, -0.15939704f, -0.01919334f, -0.08479433f, 
    0.00599777f, -0.06821866f, 0.33687642f, -0.05760755f, -0.00493528f, -0.10827500f, 0.15426953f, -0.18697791f, 
    0.12016999f, -0.01454005f, 0.01881218f, -0.02906226f, -0.25838122f, -0.11952511f, 0.03216225f, -0.35632557f, 
    -0.04098513f, 0.05465242f, 0.04650791f, 0.13594642f, 0.05734510f, -0.00611047f, -0.00957558f, -0.08635043f, 
    0.06616215f, -0.14756283f, 0.15106879f, 0.10297215f, 0.06138152f, 0.03352847f, -0.20507008f, 0.00199404f, 
    0.05438913f, -0.12925474f, -0.04694875f, 0.02858445f, 0.32666299f, -0.09212141f, -0.05262636f, 0.07681143f, 
    -0.14630023f, 0.07134879f, 0.13827097f, -0.18711467f, -0.03906248f, 0.08123861f, 0.08189992f, -0.07266626f, 
    -0.09245042f, 0.03142103f, 0.02707759f, -0.07683130f, -0.01826164f, -0.00889960f, -0.06314393f, -0.19588307f, 
    -0.07967539f, -0.05957499f, -0.01306656f, -0.03530932f, -0.08968151f, -0.14108762f, 0.10814670f, 0.11284348f, 
    -0.02576022f, 0.12214811f, -0.13189153f, -0.09089340f, -0.00560071f, -0.00391974f, 0.02042117f, 0.02441363f, 
    0.08643955f, 0.19925179f, 0.24223600f, -0.02247111f, 0.10058147f, 0.10523710f, 0.09940467f, -0.02199478f, 
    0.01093984f, -0.09772944f, -0.01667596f, -0.06890736f, -0.09605505f, -0.04029232f, -0.04938008f, -0.04384374f, 
    0.05043255f, -0.12814374f, 0.10877560f, 0.23437341f, -0.02945025f, -0.16406050f, 0.05066669f, 0.01849983f, 
    0.13992673f, -0.05614766f, -0.18404151f, -0.25312942f, -0.05349465f, -0.03828386f, 0.05019164f, -0.00538300f, 
    -0.06166027f, 0.05357046f, -0.05373890f, 0.20230529f, -0.05985432f, 0.10501792f, -0.17984506f, -0.05850003f, 
    0.03285415f, 0.05656193f, -0.10882150f, 0.14129065f, 0.05932670f, 0.03898739f, -0.14705186f, 0.04139860f, 
    0.18694682f, -0.02947415f, 0.00033190f, -0.10938579f, -0.00708308f, -0.05105321f, 0.00623414f, -0.09760083f, 
    0.07221779f, 0.00964037f, 0.04815646f, -0.03233030f, 0.11557695f, 0.20398469f, 0.04753875f, 0.09142591f, 
    -0.03738652f, -0.05535466f, -0.01932261f, -0.10727305f, -0.01836352f, -0.00125272f, 0.02531160f, -0.02666875f, 
    0.23951130f, 0.05130165f, 0.13036987f, -0.10657141f, -0.07727925f, 0.01655548f, 0.34048080f, 0.09443591f, 
    0.07089745f, 0.13003281f, 0.04754775f, -0.10992883f, 0.18074797f, -0.30970979f, 0.20985231f, 0.13955556f, 
    -0.07626253f, -0.10126005f, 0.14241876f, 0.22297086f, 0.15153818f, 0.01592597f, 0.08125810f, -0.00884771f, 
    0.41772413f, 0.03774642f, 0.34095895f, -0.02135684f, 0.12232670f, 0.01913697f, -0.26935840f, -0.03781429f, 
    0.04358667f, 0.03072874f, 0.14852443f, 0.00950606f, 0.12092648f, 0.23564583f, 0.17904648f, -0.16060591f, 
    -0.05490404f, -0.19261611f, -0.21072166f, 0.08304404f, -0.08823666f, -0.00224803f, 0.11904100f, -0.10093620f, 
    -0.16368204f, -0.03597882f, -0.22874905f, 0.04408215f, -0.00823790f, -0.02191537f, -0.06540173f, 0.08890368f, 
    -0.11348572f, -0.10093564f, -0.16740343f, -0.08845900f, 0.08055739f, 0.48193359f, -0.11019701f, 0.18800108f, 
    -0.04090927f, -0.00709882f, 0.20438969f, 0.09927754f, 0.13741700f, 0.18451199f, 0.03083776f, 0.01548242f, 
    0.07776188f, -0.06374271f, 0.01950420f, 0.03145741f, -0.15514444f, -0.08453621f, 0.05858622f, -0.01226668f, 
    0.07176914f, 0.05656008f, 0.10298520f, -0.09214866f, -0.09425101f, 0.07460681f, -0.09352235f, -0.00021556f, 
    0.33139029f, -0.14559944f, 0.12957437f, -0.11115706f, 0.12245521f, 0.08906680f, -0.07177359f, 0.05165831f, 
    -0.13037677f, -0.09582394f, -0.13320003f, 0.10818866f, 0.11306135f, 0.03966350f, 0.10150322f, 0.09082833f, 
    -0.02683347f, 0.01453015f, -0.01112780f, -0.09337325f, 0.07167505f, 0.04566104f, 0.11928062f, -0.12639959f, 
    -0.12634261f, -0.08037705f, -0.03677097f, -0.09138219f, 0.04369126f, 0.13597926f, 0.17359102f, 0.15734249f, 
    -0.06666269f, -0.29679558f, 0.02472319f, -0.00866672f, 0.02184679f, -0.02583016f, -0.04784265f, 0.07149568f, 
    -0.02197430f, 0.16814736f, 0.02729610f, 0.15725528f, 0.24882412f, -0.50232905f, -0.17925425f, 0.14731371f, 
    0.20816746f, 0.01939940f, 0.05589974f, -0.01109617f, 0.06845390f, -0.01741140f, -0.11218674f, 0.05220472f, 
    -0.23884918f, 0.24921148f, 0.22421429f, 0.12964095f, 0.26128799f, 0.07611162f, 0.07671805f, 0.12554464f, 
    0.03728252f, -0.06869937f, 0.04894706f, -0.03043891f, 0.04053997f, -0.20812179f, -0.06623732f, 0.00726427f, 
    -0.09229315f, 0.08773828f, -0.10806920f, -0.04098863f, 0.09908386f, 0.05232894f, 0.03165584f, 0.09481653f, 
    0.08032478f, 0.29946387f, 0.07759042f, 0.18013044f, 0.01233697f, 0.00660983f, -0.02568923f, -0.07770358f, 
    -0.11774828f, -0.09385262f, 0.03082514f, 0.08340932f, -0.10183840f, -0.06290268f, -0.08192865f, -0.20792449f, 
    -0.03640607f, 0.07211343f, -0.10247989f, -0.12298746f, 0.03875664f, -0.03966151f, 0.05535284f, -0.15169503f, 
    -0.15972774f, 0.01897390f, 0.21671115f, -0.03651001f, 0.03074453f, 0.19280402f, 0.04673232f, 0.04278710f, 
    0.08666448f, -0.00490676f, 0.01070192f, 0.06795699f, -0.22576407f, 0.30705860f, 0.05906633f, -0.16108443f, 
    0.03477912f, 0.13609171f, -0.14115348f, 0.09401126f, 0.07967492f, 0.11400516f, 0.06531849f, -0.10887517f, 
    -0.07647211f, 0.05625960f, -0.25477064f, -0.04733678f, 0.02677638f, 0.11056063f, 0.00494950f, 0.00395287f, 
    0.08276910f, -0.07390767f, 0.00001223f, 0.02006496f, -0.12184937f, -0.26394928f, 0.07167145f, -0.15713909f, 
    -0.04522750f, 0.00728605f, -0.09010378f, -0.11844830f, 0.00097049f, 0.02312777f, -0.08012988f, 0.00830988f, 
    0.22417511f, -0.05148616f, 0.07992200f, 0.11453393f, 0.00660314f, -0.01011307f, 0.17337649f, 0.27338153f, 
    0.07943516f, 0.18173428f, 0.08213594f, 0.12568626f, -0.25352868f, -0.13737445f, 0.45054469f, -0.05480545f, 
    -0.16499080f, -0.01277459f, 0.03367626f, -0.19820079f, 0.00148351f, 0.10149848f, 0.04456069f, 0.15243395f, 
    -0.06846575f, -0.07607806f, 0.14046432f, 0.08291347f, -0.02492005f, 0.06578763f, -0.02799445f, -0.06625160f, 
    -0.01285753f, 0.28446284f, 0.02676497f, 0.19187176f, 0.01366814f, 0.20957075f, 0.04624636f, -0.35422647f, 
    -0.04861308f, 0.08353852f, -0.07187237f, -0.11807474f, -0.14096524f, -0.14265855f, -0.17646083f, -0.07932277f, 
    0.19912738f, 0.06096189f, 0.06822437f, -0.01739523f, -0.14018117f, 0.09330541f, 0.04249243f, 0.29443753f, 
    0.08376638f, 0.03997919f, 0.01832488f, 0.08892932f, 0.09848341f, -0.02524694f, -0.04366320f, 0.07358945f, 
    0.01352192f, 0.02385854f, -0.01090821f, -0.38906503f, -0.06237257f, 0.04071547f, 0.04087049f, -0.12367407f, 
    0.08563361f, 0.18802904f, -0.05659544f, 0.06088625f, -0.10047203f, -0.11919636f, 0.04023837f, 0.15673047f, 
    -0.13145854f, -0.10998162f, -0.07206459f, -0.15045667f, -0.14903721f, 0.23645084f, -0.14063857f, -0.06344809f, 
    -0.06932841f, -0.08922649f, 0.08719946f, -0.21215710f, 0.04489002f, -0.10955739f, -0.10302044f, -0.29912752f, 
    0.20679024f, 0.08093113f, 0.03719147f, 0.18643491f, -0.12511019f, 0.05846720f, 0.15899576f, 0.09964436f, 
    -0.07052162f, 0.29567686f, -0.15029433f, 0.01769600f, 0.03553490f, 0.26556990f, -0.14139579f, -0.27063763f, 
    0.07573611f, -0.04742705f, -0.11952700f, 0.07986966f, -0.15769461f, -0.08257817f, -0.41418728f, -0.19541550f, 
    0.04997226f, -0.09226564f, 0.07289548f, -0.04568322f, -0.18161014f, 0.01791961f, -0.09147959f, 0.30337325f, 
    -0.05658045f, 0.16329783f, -0.05597705f, -0.11596463f, 0.10894755f, 0.09321196f, -0.00536831f, -0.11609630f, 
    -0.09547353f, 0.01394644f, 0.04850954f, -0.04016140f, -0.13510931f, 0.10245302f, -0.16484040f, 0.07080626f, 
    0.07205989f, -0.11091706f, -0.11794570f, -0.05855372f, 0.14632779f, -0.06478869f, 0.18295200f, 0.06375899f, 
    -0.07109805f, -0.16874947f, 0.05270505f, -0.07829946f, 0.02573953f, -0.02475390f, -0.10439411f, 0.37105188f, 
    0.03178377f, 0.28271559f, 0.04035648f, -0.00046548f, -0.03554159f, -0.08143632f, 0.15595318f, 0.25123167f, 
    -0.03856951f, 0.07747006f, 0.46633556f, -0.01032356f, -0.12764128f, -0.00734513f, 0.05126197f, -0.12072460f, 
    -0.20325744f, 0.15049145f, -0.13764477f, -0.05410477f, 0.36164021f, 0.26153848f, 0.10392634f, 0.01134432f, 
    0.10629833f, -0.09180924f, -0.01071614f, 0.08374655f, -0.11979052f, -0.09042352f, -0.02324055f, 0.01666329f, 
    0.02517169f, -0.15476452f, 0.23150489f, -0.11207117f, 0.08291329f, 0.10703383f, 0.00859698f, 0.00738815f, 
    0.11644566f, -0.12038347f, 0.08563126f, 0.17138308f, 0.31210166f, 0.49624741f, -0.06879254f, 0.51576757f, 
    0.06862164f, 0.07681090f, -0.03509928f, 0.31940165f, 0.03363667f, 0.02075797f, 0.02710088f, 0.05022247f, 
    0.10269845f, -0.35866603f, -0.35508931f, 0.14406098f, 0.08574189f, -0.12191822f, 0.06585625f, 0.21021980f, 
    0.11275725f, 0.06572286f, 0.25584906f, 0.20504867f, 0.26855975f, -0.24243377f, -0.27668834f, -0.10302185f, 
    0.04104032f, -0.05449061f, 0.11449089f, -0.04744641f, 0.12326437f, 0.15400805f, -0.07547598f, -0.14231524f, 
    0.12437623f, 0.20118994f, 0.05439008f, -0.09982853f, 0.21283612f, 0.19705199f, 0.09774881f, -0.03181778f, 
    -0.04741236f, -0.07827700f, -0.01433142f, -0.04133590f, -0.00052181f, -0.08777765f, -0.08298644f, -0.00628045f, 
    -0.01597247f, -0.03861998f, -0.15941744f, 0.27932325f, 0.01441732f, 0.03102919f, -0.12914898f, 0.13469979f, 
    0.01846712f, -0.00192994f, 0.09769617f, 0.00231889f, 0.12747729f, 0.09628024f, 0.06426262f, 0.02915617f, 
    0.06970564f, -0.11841951f, 0.01247418f, -0.01383524f, 0.41707703f, -0.13893178f, 0.19976901f, -0.00875700f, 
    0.11181803f, 0.03279911f, -0.02685290f, 0.30696285f, 0.05333607f, -0.19484296f, -0.05173165f, 0.10972308f, 
    -0.18536273f, 0.18955028f, -0.08127398f, 0.00682912f, 0.22530147f, -0.06716221f, -0.05563643f, -0.27171838f, 
    0.01104368f, -0.13611211f, 0.13163012f, -0.08808269f, 0.07821299f, -0.22175772f, -0.20776729f, 0.00913909f, 
    0.04812421f, -0.04851595f, 0.12289266f, -0.05960843f, -0.04277851f, -0.00898365f, 0.00083876f, -0.11856312f, 
    0.06049185f, 0.09925317f, -0.07883096f, -0.00595457f, 0.12239682f, -0.06715269f, -0.04843423f, 0.02459166f, 
    -0.04707611f, 0.05226536f, 0.02657391f, 0.00335930f, -0.21071726f, -0.10307992f, -0.17031406f, 0.05727922f, 
    0.06957643f, -0.21095768f, -0.15931004f, -0.02602722f, 0.03461074f, -0.02160618f, 0.12575519f, 0.07430904f, 
    0.20997180f, -0.15848660f, 0.18879482f, 0.00087704f, 0.13929009f, -0.00941701f, 0.20697723f, 0.04072878f, 
    0.08434607f, 0.05995530f, -0.08199748f, 0.14670525f, -0.16012970f, 0.13098891f, 0.14967327f, -0.14237019f, 
    -0.07221192f, 0.01065040f, 0.05830375f, -0.07791281f, -0.01196974f, -0.02957989f, -0.03983154f, -0.02750812f, 
    -0.02714501f, 0.03437239f, -0.30499259f, -0.32401967f, -0.18083386f, 0.22095644f, -0.07506642f, -0.05294505f, 
    -0.00659813f, -0.21163753f, -0.06297164f, -0.07241877f, -0.24916855f, -0.62145472f, 0.10655938f, -0.05204161f, 
    -0.10325266f, -0.04850467f, -0.14645813f, -0.00462832f, 0.02450281f, 0.02775048f, -0.14783205f, -0.25614902f, 
    -0.11464548f, 0.04238741f, -0.09667699f, -0.04987413f, 0.01438887f, -0.07056282f, -0.00444242f, 0.19040297f, 
    -0.15007761f, -0.10405468f, 0.06941595f, -0.04834939f, -0.34266296f, 0.03512688f, -0.20228843f, -0.24669519f, 
    -0.01967603f, 0.07028543f, 0.06243050f, 0.05942053f, 0.02507953f, 0.04453075f, -0.01735967f, 0.02979769f, 
    0.11866156f, -0.14305845f, -0.02891631f, 0.07092357f, -0.09821873f, -0.17479022f, 0.05642005f, 0.01640103f, 
    -0.12392858f, -0.19769095f, 0.03631375f, -0.22882803f, 0.10399536f, -0.05417368f, 0.13483030f, -0.09386518f, 
    0.32166564f, -0.08544423f, 0.10885977f, -0.02119404f, 0.12944478f, 0.06027700f, 0.14848818f, 0.00466593f, 
    0.04051014f, 0.10387573f, -0.12645987f, 0.01494039f, 0.06615745f, -0.02559785f, 0.06413879f, -0.02520660f, 
    -0.09510640f, 0.03097741f, -0.13138436f, 0.01221584f, 0.01170458f, -0.21980615f, 0.15789653f, -0.00579250f, 
    -0.20068684f, -0.10496646f, -0.16350697f, -0.12729719f, 0.17666438f, 0.07490674f, 0.23348351f, 0.09584354f, 
    -0.04250548f, -0.03702064f, -0.05878587f, -0.24074416f, 0.02298155f, 0.02683386f, 0.08576528f, 0.23025894f, 
    0.01076070f, -0.01664393f, -0.07925475f, 0.06578983f, 0.20210321f, -0.14209943f, 0.29294947f, 0.00941998f, 
    0.26304695f, 0.00331970f, 0.02067651f, 0.05080693f, 0.00804180f, 0.06682771f, -0.00397761f, -0.00942111f, 
    -0.07548124f, 0.26227850f, -0.11368517f, 0.10571568f, 0.00248157f, 0.17932288f, -0.09498115f, 0.33149147f, 
    -0.08975660f, 0.08210801f, 0.07721453f, 0.04073564f, -0.12732232f, -0.09327850f, 0.01631028f, 0.04353739f, 
    -0.08240550f, 0.10773807f, 0.11947724f, 0.00663083f, 0.21664698f, 0.05166588f, 0.28619054f, 0.05986731f, 
    0.06680916f, 0.07323080f, -0.04971226f, 0.00427593f, 0.09810820f, -0.01911766f, -0.13990581f, -0.15058413f, 
    -0.01941815f, -0.03852812f, -0.08100103f, 0.11572037f, 0.01390481f, 0.05040973f, 0.01426727f, -0.04791866f, 
    -0.01661740f, 0.09824681f, -0.09079737f, -0.07293639f, 0.06193200f, -0.00080464f, 0.05936731f, -0.06820523f, 
    0.07984101f, -0.22060049f, 0.18463974f, -0.25094545f, 0.23263672f, 0.10486620f, 0.08292811f, 0.18588167f, 
    0.01288964f, 0.02522862f, -0.00444027f, -0.01711984f, -0.23948351f, 0.13855727f, -0.04124578f, -0.04677399f, 
    -0.20427819f, -0.05707185f, -0.10880570f, 0.02730719f, 0.14198297f, 0.03968105f, -0.03251018f, -0.04284493f, 
    -0.05141350f, 0.11854172f, 0.03181465f, 0.19525039f, 0.04865490f, 0.10310894f, -0.03975969f, 0.12010644f, 
    0.02164798f, 0.05777158f, 0.15014319f, -0.09453890f, 0.14554361f, -0.17493671f, 0.05677843f, -0.23745395f, 
    0.00212344f, 0.05771419f, 0.18115352f, 0.15778138f, -0.15146327f, 0.09860914f, -0.23081177f, -0.19710296f, 
    0.08971233f, 0.06171001f, 0.05436750f, 0.00792729f, 0.14058347f, 0.07635814f, 0.14235331f, 0.02082452f, 
    0.07094967f, 0.23621671f, -0.10841945f, 0.07618982f, 0.39962626f, -0.01937105f, 0.07464635f, -0.23725052f, 
    0.01929032f, -0.07113552f, -0.16305675f, 0.00745294f, 0.06817298f, -0.16888022f, 0.05684029f, 0.05339927f, 
    -0.18093190f, 0.09015770f, -0.05561098f, -0.00431329f, -0.05210551f, 0.02507605f, -0.07959656f, -0.03468519f, 
    -0.03416720f, 0.00003130f, -0.04756591f, 0.19468074f, -0.21658392f, 0.05485831f, -0.06290469f, 0.07716016f, 
    -0.22015171f, 0.15774596f, -0.03596319f, 0.08390751f, 0.03673597f, -0.05564886f, -0.08971385f, 0.04864506f, 
    0.17649007f, 0.10124296f, -0.12942483f, -0.20759659f, -0.08701373f, 0.04781634f, 0.00598105f, 0.19187920f, 
    0.04295060f, 0.02793936f, 0.06652625f, 0.02586960f, 0.03533700f, 0.11787784f, 0.08075134f, 0.23088053f, 
    0.00122706f, 0.06382317f, -0.03825951f, -0.06564949f, -0.07278817f, -0.06134596f, -0.07383422f, -0.16137712f, 
    0.18287247f, 0.23459753f, -0.02986701f, 0.04176728f, 0.00621555f, 0.01865519f, 0.14181532f, -0.04934182f, 
    -0.06999400f, -0.06536295f, -0.13211845f, -0.14443372f, -0.33133215f, 0.22309282f, -0.08799596f, -0.04142109f, 
    -0.16026771f, -0.12400455f, 0.07687493f, -0.08697613f, -0.08826295f, -0.01750328f, -0.01956781f, -0.09014075f, 
    0.27664214f, -0.44344980f, 0.00868084f, -0.18430014f, -0.08157279f, 0.01120415f, 0.02337815f, 0.03788557f, 
    -0.02892121f, 0.07802393f, -0.18143901f, 0.09537369f, -0.14765629f, 0.00007498f, 0.13291505f, 0.04767881f, 
    0.13803852f, 0.07369067f, 0.04511787f, 0.05834015f, -0.07587673f, -0.13401248f, -0.07897226f, -0.04642697f, 
    -0.15839374f, -0.27093473f, -0.08614688f, 0.04451559f, -0.01067175f, 0.02415812f, 0.10139467f, 0.08863040f, 
    0.05365879f, -0.00079888f, -0.04358424f, 0.01884575f, -0.07809306f, -0.15965258f, -0.01756879f, 0.11343494f, 
    0.06984691f, 0.07021142f, -0.00186386f, 0.04712365f, 0.01934480f, -0.02108319f, -0.10938794f, 0.03203387f, 
    0.32824284f, -0.12223698f, -0.23998383f, -0.11022336f, 0.02689028f, 0.07121059f, 0.00497961f, 0.13014293f, 
    0.07755240f, -0.02753133f, 0.06646006f, -0.07434370f, 0.47317415f, -0.28851271f, 0.23385872f, 0.31641841f, 
    -0.08433206f, -0.08818492f, 0.02945877f, 0.05721509f, 0.07086284f, 0.02077276f, -0.02677236f, 0.07335259f, 
    0.17314093f, -0.13851680f, -0.12024381f, -0.04129393f, 0.16246587f, 0.00936264f, 0.00989121f, -0.02432572f, 
    -0.14328320f, 0.04424600f, -0.03870196f, 0.09367471f, -0.15468585f, 0.01752437f, -0.12779054f, -0.05458968f, 
    0.02093552f, 0.06218516f, 0.06043471f, -0.03926046f, -0.05699369f, -0.12158076f, 0.04119523f, 0.04388001f, 
    -0.04037008f, 0.12699172f, -0.07949024f, -0.09642902f, 0.12902580f, 0.03689086f, -0.11252931f, 0.09531887f, 
    -0.22398843f, -0.08397977f, 0.08390928f, -0.05490448f, 0.24889836f, -0.20620692f, -0.28662494f, -0.14522366f, 
    0.12750298f, -0.01576074f, 0.01164544f, 0.14474085f, 0.02013688f, -0.00842603f, -0.06209336f, -0.00200982f, 
    0.07238216f, 0.07368637f, -0.28170255f, 0.19537167f, -0.05674327f, -0.13859530f, 0.34931508f, 0.10920689f, 
    -0.04191094f, -0.07857616f, 0.11316332f, -0.18944067f, 0.06313311f, -0.11721760f, 0.35028884f, -0.10503560f, 
    0.15513772f, -0.10698893f, -0.09479388f, 0.21509369f, 0.10007527f, 0.13346621f, 0.09859892f, 0.07632074f, 
    0.16388342f, 0.16214529f, -0.01480876f, -0.02810471f, 0.20305729f, 0.05347331f, -0.03042029f, -0.03243021f, 
    -0.04566243f, -0.02951911f, -0.14871255f, -0.10565422f, -0.09718527f, 0.09297932f, -0.05610020f, 0.08539580f, 
    -0.27993822f, -0.12026871f, -0.02081973f, -0.07630731f, 0.17552790f, -0.01883586f, 0.05289478f, 0.06837041f, 
    -0.06696344f, 0.00491612f, -0.01969652f, -0.18962955f, 0.14642270f, 0.07977912f, 0.06839676f, 0.06394725f, 
    -0.01839203f, -0.00376765f, -0.04171477f, 0.22712424f, 0.00241719f, -0.02196947f, 0.45107561f, -0.19535090f, 
    0.13421309f, 0.16970754f, 0.02314217f, -0.04809417f, -0.03033834f, -0.02435591f, -0.08933155f, 0.09231967f, 
    0.04694780f, 0.11150675f, -0.02583712f, 0.05500288f, 0.15290706f, 0.17904399f, -0.03978051f, 0.03691584f, 
    -0.01967497f, -0.10187647f, 0.08728377f, -0.09703743f, -0.18389121f, -0.30658159f, 0.26782525f, 0.40439016f, 
    -0.23081736f, 0.00598133f, 0.05007984f, -0.08484181f, 0.14045799f, -0.07983676f, 0.39662459f, -0.10511472f, 
    0.12894079f, 0.01649577f, 0.14206931f, 0.24429967f, -0.06584675f, -0.05278708f, -0.27321258f, -0.06313914f, 
    -0.09610251f, -0.06311537f, 0.00716493f, 0.24596690f, -0.09434988f, -0.16604382f, -0.04986251f, 0.02202101f, 
    0.24951588f, 0.08658690f, -0.26726806f, -0.03602868f, 0.04311556f, 0.01561113f, 0.10844383f, -0.10933156f, 
    0.01923339f, 0.01012740f, 0.20123379f, -0.03687287f, 0.31875387f, 0.07144090f, 0.04003067f, 0.12813859f, 
    0.07085247f, 0.05935223f, -0.05567214f, 0.05031618f, -0.03920048f, 0.08671408f, 0.05992024f, -0.08766370f, 
    -0.05082844f, -0.17449355f, 0.02176922f, -0.07088571f, 0.02090528f, 0.00617440f, -0.11393673f, -0.00649087f, 
    -0.03491715f, 0.09016628f, -0.21288626f, 0.21025023f, -0.17490162f, 0.09492907f, 0.05583726f, 0.27409908f, 
    0.08102296f, -0.11131815f, 0.17233808f, 0.12120114f, 0.03806921f, -0.48555523f, -0.24567096f, 0.06859931f, 
    -0.19023190f, 0.10853151f, 0.36101308f, 0.08811299f, -0.01352821f, 0.00767341f, -0.23524404f, -0.17560218f, 
    0.09379180f, 0.02140600f, 0.18727741f, 0.07018428f, -0.01595872f, -0.01268121f, -0.06831806f, 0.15146326f, 
    -0.07130437f, 0.07126790f, 0.06930936f, 0.07581618f, -0.20825012f, -0.11483492f, -0.33750880f, -0.32260281f, 
    -0.06564153f, 0.08389294f, -0.03070931f, -0.09672736f, 0.12015826f, 0.06556993f, 0.02734430f, 0.06543688f, 
    0.16721204f, -0.54244918f, -0.12882958f, 0.20949711f, 0.06148366f, -0.10663658f, -0.07201416f, 0.08985786f, 
    0.00405487f, -0.03056392f, 0.17051001f, 0.03011011f, 0.18805124f, -0.34541684f, 0.05162873f, -0.13490637f, 
    0.05207195f, -0.04476738f, 0.08045846f, -0.18189934f, 0.06707814f, 0.08827718f, -0.10151663f, -0.12755865f, 
    0.21723907f, 0.39389515f, 0.11304217f, 0.07716613f, 0.10456130f, 0.14276083f, 0.11194249f, 0.00515900f, 
    -0.05020561f, 0.01173802f, 0.05695445f, -0.11483575f, 0.02157374f, -0.23815629f, 0.09353216f, -0.07868841f, 
    -0.01582794f, -0.08684452f, -0.13024135f, -0.13039222f, 0.08564903f, 0.03177230f, 0.04786153f, 0.05661477f, 
    0.18252818f, 0.09327643f, 0.11362590f, -0.15705788f, 0.10480355f, 0.17364965f, -0.02101108f, 0.19018912f, 
    0.04107494f, -0.01557555f, -0.01059173f, 0.10882846f, 0.08661656f, -0.01286620f, 0.58387959f, -0.01193661f, 
    0.13538235f, -0.05660924f, 0.02240175f, 0.18521041f, -0.03610670f, -0.13130502f, -0.08233061f, -0.00500612f, 
    0.12346746f, 0.33680841f, -0.42075709f, 0.01649413f, 0.12835738f, -0.02903425f, -0.01298555f, 0.10646716f, 
    -0.00522822f, 0.02083234f, 0.00005407f, -0.25624415f, -0.09683418f, -0.35437998f, -0.06864292f, -0.17142673f, 
    0.03341440f, 0.11260966f, 0.09250262f, -0.08264209f, 0.17751446f, 0.03341683f, 0.03764852f, -0.00112733f, 
    -0.13788137f, -0.12487330f, -0.17095223f, 0.06508943f, 0.20487534f, -0.15981722f, 0.04303999f, 0.14306544f, 
    -0.06473137f, 0.09770161f, -0.05846015f, -0.02631558f, 0.04856761f, -0.39084041f, -0.08301739f, 0.32117450f, 
    0.13650073f, 0.01307086f, -0.14973678f, 0.02119655f, 0.07276656f, 0.05164092f, 0.14805765f, 0.03982805f, 
    0.34260187f, -0.22590607f, 0.31236580f, -0.39835525f, 0.15508567f, -0.00920938f, 0.20459127f, 0.24654748f, 
    -0.05086429f, 0.09503295f, -0.06378449f, 0.15191878f, -0.31097928f, -0.00810938f, 0.04997549f, -0.19497515f, 
    -0.07922333f, -0.06923108f, -0.01388116f, 0.06114955f, 0.15608890f, 0.06468483f, 0.04128965f, 0.02985633f, 
    0.03540395f, -0.06993323f, -0.20799531f, -0.14589933f, 0.00856475f, 0.15262970f, -0.18375175f, -0.21040863f, 
    0.09989323f, 0.07111213f, 0.14045474f, -0.08199696f, 0.35018688f, -0.30004594f, 0.08345201f, -0.20073563f, 
    0.07461695f, -0.20644681f, 0.00463983f, 0.11553275f, -0.11620360f, -0.01789048f, -0.19716589f, -0.25530556f, 
    -0.04724630f, 0.10099711f, 0.15238434f, -0.01692384f, 0.05167755f, -0.00490689f, 0.14380921f, -0.03520535f, 
    0.19666384f, -0.00325611f, 0.07279128f, -0.07794996f, 0.11677708f, 0.36625469f, -0.01107692f, -0.31628236f, 
    -0.13653871f, -0.03811494f, -0.04883650f, 0.00793464f, -0.05661698f, -0.00137872f, 0.15225412f, -0.01815090f, 
    0.03110424f, 0.05649287f, 0.01312484f, -0.02331227f, 0.10675872f, 0.01374237f, 0.01855615f, -0.19961183f, 
    -0.07272881f, -0.12963384f, 0.11201964f, 0.06454086f, -0.01614167f, 0.02169834f, -0.00668522f, 0.00307555f, 
    -0.25437838f, 0.18445139f, 0.07262622f, 0.21689777f, 0.09457405f, -0.05044845f, 0.10418382f, 0.04780211f, 
    0.07362546f, 0.20539957f, 0.01290654f, -0.11208024f, 0.00031978f, -0.08342329f, 0.04444353f, -0.05433007f, 
    0.09956522f, -0.07177702f, 0.02636790f, -0.07295254f, -0.04531438f, 0.01500379f, 0.02453561f, 0.17382431f, 
    -0.02328937f, -0.03661856f, 0.02321508f, -0.01952647f, 0.07014614f, 0.05812821f, -0.08913895f, -0.06378581f, 
    0.04612903f, 0.18587145f, 0.08289676f, -0.13230130f, -0.02301757f, 0.06944502f, 0.06667060f, -0.02009007f, 
    -0.03660903f, -0.16395073f, -0.05381962f, -0.01820382f, -0.38743535f, -0.08529671f, 0.16137475f, 0.22613390f, 
    0.01788793f, -0.04919764f, 0.11303277f, 0.00495057f, -0.09079451f, -0.11052542f, -0.07409842f, 0.03975810f, 
    0.20721731f, -0.15424867f, -0.05448711f, -0.23225026f, -0.03179321f, 0.09545232f, -0.00276928f, -0.02077276f, 
    0.01804240f, 0.12227044f, -0.10703000f, 0.12095997f, -0.09116783f, 0.03160706f, 0.01683169f, -0.09797658f, 
    0.03827674f, 0.13436416f, 0.05091850f, 0.14672254f, 0.06972324f, -0.12142684f, 0.07455184f, 0.01814438f, 
    -0.33414230f, -0.54581159f, -0.05040693f, -0.14351918f, 0.09810675f, 0.07737155f, 0.19933008f, 0.09043714f, 
    0.04900892f, 0.09706816f, 0.07028627f, 0.03629066f, -0.04026499f, -0.21128343f, -0.04406858f, 0.04269196f, 
    0.01192303f, 0.06430168f, 0.10931664f, 0.07504878f, 0.07824937f, -0.03605357f, -0.09463748f, 0.01193802f, 
    0.39556718f, -0.60275924f, 0.06526259f, -0.12273370f, 0.11255696f, 0.05940271f, 0.00930891f, 0.29334205f, 
    0.00533700f, -0.03768279f, 0.14493561f, 0.02719565f, 0.34954402f, -0.49909028f, 0.55055785f, 0.39799216f, 
    -0.09254056f, -0.01490099f, -0.13719924f, -0.00451474f, 0.22064392f, 0.15971132f, 0.05372933f, 0.08319113f, 
    0.19052367f, -0.03408172f, 0.15269746f, -0.05256099f, 0.13306968f, -0.05548649f, -0.02623706f, 0.05199189f, 
    0.01297367f, 0.00479867f, 0.18187371f, -0.05889452f, -0.02231421f, -0.07932779f, -0.02956258f, -0.20146650f, 
    0.16525322f, -0.02990677f, -0.04793466f, 0.10799643f, -0.09526858f, -0.05708886f, 0.07568364f, -0.11717142f, 
    -0.35083666f, -0.17170666f, 0.29197270f, -0.13902736f, 0.05994288f, 0.32613140f, 0.34442568f, -0.15308447f, 
    -0.03026733f, 0.00544652f, 0.13198482f, 0.01169385f, 0.28694013f, 0.15650819f, 0.01253291f, 0.15216541f, 
    0.02190613f, 0.04943170f, -0.04455178f, 0.08576253f, 0.09424318f, -0.11084034f, -0.02245362f, 0.05043378f, 
    -0.08918869f, 0.10471193f, 0.01034486f, -0.02708475f, -0.06994029f, -0.02030755f, 0.01398731f, 0.14434180f, 
    0.25514957f, 0.09015980f, 0.00132174f, 0.13990170f, 0.07394435f, 0.23418115f, -0.08523504f, 0.05230008f, 
    -0.14595385f, 0.04038920f, 0.02007823f, 0.12632646f, -0.09904446f, -0.03882399f, -0.07018554f, 0.06781592f, 
    -0.31478852f, -0.20849437f, -0.07499864f, -0.07482506f, -0.06660585f, -0.04419510f, -0.04529805f, -0.12576444f, 
    0.01239528f, -0.12308025f, -0.07019685f, -0.04063723f, 0.07874034f, -0.03929358f, -0.00348183f, 0.05691863f, 
    0.05811067f, 0.03804298f, -0.08130754f, 0.02043311f, 0.02580830f, 0.02053123f, -0.03396456f, -0.02407089f, 
    -0.13310805f, -0.05022898f, -0.00135648f, 0.02827071f, 0.04879966f, -0.15716194f, -0.11315168f, -0.28454685f, 
    -0.10900889f, -0.14193264f, -0.16907232f, -0.17773789f, -0.28561974f, -0.23850696f, -0.09083270f, 0.05430169f, 
    -0.01473223f, -0.26928183f, -0.05745111f, -0.01243774f, -0.05979289f, -0.16268834f, -0.14138225f, -0.02944557f, 
    0.34684509f, -0.14156675f, 0.23144439f, -0.13014901f, -0.03680296f, -0.01755477f, 0.03417278f, -0.09563023f, 
    0.14550418f, 0.08845706f, -0.06111443f, -0.03857539f, 0.01084507f, -0.03286634f, -0.07763428f, 0.03618276f, 
    0.06264993f, -0.00341717f, -0.20469038f, 0.11515678f, -0.03560848f, -0.09082248f, -0.11508950f, -0.02443795f, 
    -0.05316423f, -0.05941172f, 0.10852963f, -0.02024955f, -0.04476496f, -0.04781954f, 0.00439153f, 0.00773998f, 
    -0.03856021f, 0.17373993f, 0.05746810f, 0.05629995f, -0.00297872f, 0.13378976f, -0.00499446f, 0.17580925f, 
    0.00306924f, -0.00847542f, 0.03389956f, -0.06333659f, 0.06110397f, -0.08272035f, -0.15195802f, 0.06353088f, 
    -0.06847259f, 0.01075050f, 0.00167818f, 0.43614712f, 0.04145798f, 0.01973536f, 0.24258646f, 0.20257488f, 
    0.08132150f, 0.21042794f, 0.08537426f, -0.10627221f, 0.31414443f, -0.20126835f, 0.29242873f, 0.05853736f, 
    -0.00837578f, 0.01855971f, 0.19372348f, 0.09111692f, 0.11074099f, 0.17882456f, 0.18081968f, 0.02310213f, 
    0.27565202f, 0.23433857f, 0.23738116f, -0.04355972f, -0.04953847f, -0.00502702f, -0.05420019f, 0.18437161f, 
    0.10717044f, 0.00836204f, -0.03358389f, 0.01664240f, -0.13554642f, 0.17676944f, 0.06207950f, 0.12537076f, 
    -0.03937319f, -0.10085858f, 0.03480279f, 0.06286788f, 0.07264207f, 0.01576472f, 0.01903778f, -0.05805467f, 
    0.00628698f, 0.09279829f, -0.22274409f, -0.06234286f, -0.07979161f, -0.05844852f, -0.10486964f, -0.05058088f, 
    -0.14725979f, -0.00320885f, -0.13875233f, -0.01347879f, 0.74434274f, 0.15773241f, -0.14816323f, -0.10626945f, 
    -0.20942473f, -0.16072048f, -0.21398838f, -0.09351026f, 0.27938941f, 0.04026097f, 0.14353365f, -0.05778817f, 
    0.05553407f, 0.07306808f, 0.18090162f, -0.01203317f, -0.02030976f, 0.03510188f, -0.04589611f, 0.01829667f, 
    0.11071364f, -0.00818131f, 0.06421866f, 0.08451159f, -0.11720365f, 0.11013746f, -0.01828515f, 0.23222712f, 
    -0.11109356f, -0.06563603f, -0.04436456f, 0.23290649f, 0.04926499f, -0.13371630f, -0.09440883f, -0.02999237f, 
    0.02194284f, 0.02005842f, -0.12488302f, 0.20044672f, 0.04496328f, 0.01893392f, 0.13420539f, 0.10191516f, 
    -0.14109252f, -0.19855505f, -0.19864461f, -0.06647856f, 0.12281335f, 0.02314986f, 0.04311717f, -0.06169973f, 
    0.12716718f, 0.08408359f, 0.05075365f, -0.02159430f, -0.10296044f, -0.12551528f, 0.00986134f, -0.15690519f, 
    -0.14195836f, 0.03175853f, -0.07696495f, 0.12726593f, -0.14376774f, 0.09443533f, 0.05216302f, -0.00619643f, 
    -0.07631566f, -0.11693725f, -0.05187795f, -0.07580917f, -0.42622653f, 0.00583116f, -0.06002216f, -0.02451196f, 
    0.00724785f, 0.18785942f, 0.01017025f, -0.03846369f, -0.10464254f, -0.03276616f, -0.03814303f, 0.11876638f, 
    0.16481656f, -0.19365926f, 0.04078780f, -0.04292311f, 0.15399437f, 0.03140806f, 0.11468004f, -0.02406406f, 
    0.05858620f, -0.07795153f, -0.02584529f, -0.04986894f, 0.03221596f, -0.17618999f, 0.14897195f, 0.03544447f, 
    -0.01075308f, 0.04782064f, 0.00124929f, 0.04383944f, 0.11265623f, -0.00735972f, 0.00701330f, 0.05729925f, 
    0.05682141f, -0.06199684f, -0.19770765f, 0.15019898f, -0.01093764f, 0.11504985f, 0.12396827f, -0.01444137f, 
    -0.09201135f, 0.00192630f, -0.04325728f, 0.01459752f, -0.06320427f, -0.02755991f, -0.10009793f, 0.15057053f, 
    0.07439180f, 0.02985463f, -0.04138871f, 0.04091145f, 0.07488418f, -0.04581480f, -0.03344107f, -0.05101020f, 
    -0.28444356f, 0.07985922f, 0.03629519f, -0.20886168f, 0.06366884f, 0.04082966f, -0.12007747f, 0.07667784f, 
    -0.10144681f, -0.07768662f, -0.04189352f, -0.02014504f, 0.17162563f, 0.08643636f, 0.31305414f, -0.05193334f, 
    0.11106267f, 0.08227506f, -0.07971249f, 0.10302579f, -0.08996554f, 0.01195771f, -0.05028911f, -0.19256082f, 
    -0.22364369f, 0.00382935f, -0.38794014f, -0.13138932f, -0.05129262f, -0.11176232f, 0.06538870f, -0.02885452f, 
    0.04100318f, -0.06733640f, 0.01217374f, 0.05552488f, 0.05699596f, -0.05405508f, -0.05828809f, -0.13613077f, 
    -0.06203902f, -0.04442375f, -0.12166248f, -0.14168729f, 0.07756405f, 0.08205657f, 0.11543198f, 0.02737653f, 
    0.18916914f, -0.27817023f, -0.06829751f, 0.01204748f, 0.08007040f, 0.12231690f, 0.01669045f, 0.07586847f, 
    0.02234862f, 0.00889436f, 0.13206016f, 0.05638230f, 0.02546619f, -0.13810173f, 0.19029245f, 0.23810242f, 
    -0.06597256f, -0.10455371f, 0.05073847f, -0.06277049f, -0.02018402f, 0.05456389f, -0.00600491f, 0.10514155f, 
    -0.05282704f, -0.07542651f, -0.14155607f, 0.01217639f, -0.00402722f, -0.01978671f, 0.01438414f, 0.08378162f, 
    -0.04185780f, 0.30592182f, 0.03301309f, 0.02414643f, -0.10542133f, -0.01502909f, 0.04940698f, -0.27122498f, 
    0.09272755f, -0.02415405f, -0.22363058f, -0.06568860f, -0.02120506f, -0.14101519f, -0.08387892f, 0.01239022f, 
    0.18542559f, -0.13577391f, -0.02803998f, -0.17110550f, 0.03669406f, 0.01097519f, -0.04277528f, 0.07265676f, 
    0.07541324f, -0.13394947f, -0.02974816f, 0.05643091f, -0.06846617f, -0.09785683f, -0.15826011f, 0.08822020f, 
    -0.07910424f, -0.03590132f, 0.02894788f, -0.03064152f, -0.06928442f, -0.05346040f, 0.09378461f, 0.02873568f, 
    0.01755117f, -0.07353982f, -0.17537174f, -0.06806385f, 0.12030526f, -0.25753728f, -0.09680745f, -0.03004063f, 
    -0.11657792f, -0.10747502f, -0.02497206f, -0.20583546f, 0.15805724f, 0.13742889f, -0.06284292f, -0.08182114f, 
    -0.10939323f, 0.05504189f, 0.03870147f, -0.04931176f, 0.05487703f, -0.03808371f, -0.06700334f, -0.20714931f, 
    0.17295088f, 0.02703078f, 0.04128172f, 0.13365261f, 0.04312254f, 0.03837326f, 0.00987404f, -0.06977933f, 
    -0.09156760f, 0.12333322f, 0.08714934f, -0.15925369f, -0.10914147f, -0.10880741f, -0.07782183f, 0.03652711f, 
    0.03902438f, -0.12337639f, 0.01248849f, -0.17721196f, -0.14667496f, -0.21980692f, -0.15395232f, -0.11787193f, 
    -0.07386066f, 0.07046600f, 0.07057407f, -0.17351103f, -0.12516104f, -0.02605088f, -0.04895520f, 0.13966279f, 
    -0.03030685f, 0.05790661f, -0.07879136f, -0.04655127f, -0.00275458f, -0.00800909f, 0.05566850f, -0.08359006f, 
    0.02255969f, 0.06472938f, -0.05851261f, -0.11589510f, -0.21795826f, -0.08820711f, -0.03615886f, 0.06051746f, 
    -0.13933966f, 0.18044466f, -0.29479742f, 0.41954279f, 0.12531909f, -0.03159180f, -0.05462455f, -0.08486241f, 
    -0.20393658f, -0.03958933f, -0.06705892f, 0.03827971f, -0.32071266f, 0.18938775f, -0.45442805f, 0.01700083f, 
    0.08494391f, 0.19647203f, -0.04964758f, -0.32238927f, -0.09671850f, -0.07476268f, 0.20962836f, 0.25106329f, 
    -0.06845037f, -0.17600539f, 0.14005770f, -0.15021847f, -0.06656647f, 0.00319357f, 0.02125216f, -0.19038358f, 
    -0.05635667f, 0.03121947f, -0.18382874f, -0.04180215f, 0.06858172f, -0.15245737f, -0.03314682f, 0.05994557f, 
    -0.01861065f, -0.00624740f, -0.04614849f, -0.03090915f, -0.17983107f, -0.01746358f, -0.15788136f, -0.03594539f, 
    -0.04310428f, 0.28457379f, 0.01294673f, 0.09767489f, 0.13544413f, -0.10066566f, -0.08943800f, -0.04886460f, 
    -0.08073658f, -0.03817302f, -0.15252218f, -0.20030816f, -0.17975321f, -0.29758602f, 0.03392027f, -0.48731941f, 
    0.09434163f, -0.12688093f, 0.08597349f, 0.13510661f, -0.03838978f, 0.03351838f, -0.03739487f, -0.07488792f, 
    -0.00034974f, 0.20455621f, 0.06589837f, -0.02299178f, 0.04717312f, -0.14412536f, -0.16617979f, -0.07603051f, 
    0.02399619f, -0.10159755f, -0.08481386f, -0.16180484f, -0.03613571f, -0.01509633f, 0.14308280f, 0.04089779f, 
    -0.08959454f, 0.02822410f, -0.05701555f, 0.04916790f, -0.00451080f, -0.09307262f, 0.07502334f, 0.02068356f, 
    -0.04409693f, -0.02606881f, 0.12156834f, -0.03475524f, -0.02544999f, 0.00486965f, 0.03276321f, -0.00792062f, 
    -0.06422616f, 0.06358963f, 0.09637439f, 0.08588572f, -0.09615570f, 0.17037953f, 0.04235228f, 0.11113241f, 
    -0.10003220f, 0.00314497f, -0.04240503f, -0.09449036f, 0.06148863f, 0.04080447f, 0.10034948f, 0.07527079f, 
    0.07068934f, 0.09564766f, 0.02640465f, 0.06685404f, -0.02893833f, 0.13908856f, 0.01367941f, 0.10984117f, 
    0.00161051f, 0.09997503f, 0.13289362f, 0.06500949f, -0.29222730f, 0.12632443f, -0.11929998f, -0.20805982f, 
    -0.02427959f, 0.14805631f, 0.20141782f, 0.10245842f, 0.01339752f, 0.03226750f, 0.09228877f, 0.06775396f, 
    0.17503488f, -0.11304069f, 0.10553634f, -0.10224401f, -0.08921755f, 0.23841125f, -0.03613896f, 0.19363157f, 
    -0.17421216f, 0.04270136f, 0.01728243f, 0.04659960f, -0.19981690f, 0.00546948f, -0.07811297f, -0.03330502f, 
    -0.02851779f, 0.05720317f, -0.07587688f, -0.02838885f, 0.04770959f, 0.03756625f, 0.00767783f, 0.14110580f, 
    0.01597355f, -0.06574637f, 0.17082934f, 0.21363702f, -0.13406149f, -0.04998254f, -0.02753022f, -0.25144321f, 
    0.09609972f, -0.11462195f, 0.02886597f, 0.05727017f, 0.08247542f, -0.04963251f, 0.12496509f, 0.03083936f, 
    -0.07126389f, -0.05828734f, -0.08175590f, -0.11260540f, -0.10980868f, 0.03118856f, 0.02701630f, -0.03598288f, 
    -0.14593732f, 0.26455945f, -0.19476351f, 0.03630068f, -0.03928850f, 0.11351948f, -0.12128852f, 0.24073848f, 
    0.07747283f, -0.06569467f, -0.09091246f, 0.00663272f, -0.08650207f, 0.13430788f, -0.05575469f, 0.08847566f, 
    -0.00580485f, 0.09854740f, 0.05811802f, -0.09867347f, 0.11106883f, 0.05977390f, -0.04633709f, 0.06946137f, 
    0.33766782f, 0.15619449f, 0.20148206f, 0.32620743f, -0.04932035f, -0.07760579f, -0.07982659f, -0.04701831f, 
    -0.01502335f, 0.03936167f, 0.07002647f, -0.00899812f, 0.24208048f, 0.18359633f, -0.06581268f, 0.07863504f, 
    -0.09677582f, -0.01753544f, -0.02715473f, 0.04226813f, 0.07807007f, -0.00741643f, 0.08816167f, -0.06320707f, 
    0.07138658f, 0.10006814f, -0.20152606f, 0.16567700f, -0.05579653f, -0.06116199f, -0.26935408f, 0.15561639f, 
    -0.09918472f, -0.05889765f, -0.10547763f, 0.06217439f, -0.44234771f, 0.19086757f, -0.08886353f, 0.16333576f, 
    -0.00655110f, -0.04251701f, 0.21540876f, 0.08358414f, -0.13824104f, 0.05611363f, -0.00939414f, -0.11441743f, 
    -0.03991681f, -0.11985992f, -0.09130975f, -0.03677168f, -0.01748182f, -0.01278261f, -0.00972105f, -0.13062607f, 
    0.10069251f, 0.02818950f, 0.09594832f, 0.08893668f, 0.05065491f, -0.20281358f, -0.13159999f, -0.13297407f, 
    0.23355921f, -0.03944062f, 0.00624982f, -0.16827837f, 0.07692550f, 0.07726063f, -0.02314838f, -0.03688540f, 
    0.08272511f, 0.02334071f, 0.09978377f, 0.19923921f, 0.08572981f, 0.00366810f, 0.00643297f, 0.11996405f, 
    0.10861678f, 0.20070682f, -0.00105971f, -0.06142700f, 0.09657081f, -0.06349383f, 0.08167960f, -0.13300900f, 
    0.06904360f, -0.00585921f, -0.02598376f, -0.10686835f, 0.02974265f, 0.03978932f, -0.06153781f, 0.16577464f, 
    -0.01011581f, -0.05699129f, 0.02793783f, 0.06194506f, -0.08376858f, 0.10563391f, -0.03600192f, 0.12911072f, 
    0.06521700f, 0.02181803f, 0.21377607f, 0.14174666f, 0.42917186f, -0.06582208f, -0.02687086f, 0.11095015f, 
    0.11778088f, 0.18291642f, -0.08065437f, -0.07640711f, 0.00283525f, 0.13913579f, 0.05694038f, 0.17974089f, 
    -0.59164518f, 0.29037365f, 0.00864617f, 0.21234354f, 0.10816152f, -0.03945884f, -0.04511405f, 0.17054531f, 
    0.07246128f, 0.00846665f, 0.06254550f, 0.06155816f, 0.12449075f, 0.01163469f, 0.08189581f, -0.18446030f, 
    0.04195715f, -0.03361075f, 0.04071967f, -0.10911772f, 0.00915977f, 0.14208400f, 0.11995078f, -0.02145043f, 
    0.20740370f, 0.14822011f, 0.02521392f, 0.25524560f, 0.02278647f, 0.03211160f, -0.00220860f, -0.08257069f, 
    0.06891659f, -0.03888577f, 0.05071787f, -0.13862111f, -0.06979251f, 0.00926198f, -0.07896379f, -0.14167511f, 
    0.03371441f, -0.03292891f, -0.11062000f, -0.09369387f, 0.11252392f, -0.00100493f, 0.10883038f, 0.06466221f, 
    0.22756669f, -0.06672686f, 0.16213073f, -0.23324195f, -0.10802288f, 0.20702788f, -0.07656809f, -0.09175362f, 
    0.02138411f, -0.09704662f, 0.03712890f, -0.03456208f, 0.15551916f, 0.30433038f, -0.12133117f, -0.17919445f, 
    0.06180711f, 0.10250828f, -0.06641251f, 0.11876748f, -0.00518745f, -0.13220327f, -0.09869658f, -0.05667209f, 
    -0.32513845f, 0.12188388f, -0.13061388f, 0.12725742f, 0.02002341f, -0.00756809f, 0.01122548f, -0.16122344f, 
    0.05217959f, -0.03389288f, 0.03146329f, -0.05623400f, -0.02946153f, -0.01798044f, 0.11124603f, 0.06533874f, 
    0.03764018f, 0.04423030f, 0.02558233f, -0.05394725f, 0.04620625f, 0.06748249f, 0.07833889f, -0.03748511f, 
    -0.32776138f, 0.04612478f, 0.10649671f, -0.14233530f, -0.11610372f, 0.01654964f, -0.03276647f, 0.00106648f, 
    0.06100779f, 0.05073955f, 0.02281811f, 0.01897884f, -0.02797145f, -0.21162213f, -0.20245101f, -0.02723157f, 
    0.05957577f, 0.00875514f, 0.07745773f, 0.01097493f, -0.05976674f, 0.12671950f, -0.02604751f, 0.01383573f, 
    0.30117688f, 0.03041473f, 0.04099962f, 0.10291579f, 0.08558508f, 0.02852898f, 0.02248848f, 0.11047275f, 
    0.04672399f, -0.10419214f, 0.03946553f, -0.18510468f, 0.06870209f, -0.11854818f, 0.04254450f, -0.00016453f, 
    0.20202018f, -0.07871989f, -0.06129514f, 0.00330289f, -0.06354745f, 0.04950243f, -0.06650681f, 0.17355482f, 
    -0.19059703f, -0.05621911f, 0.02307288f, 0.10183690f, -0.00361620f, -0.02069357f, -0.02146646f, -0.24753518f, 
    0.03032641f, 0.18283255f, 0.04974595f, -0.02221096f, 0.05203120f, -0.08382959f, 0.12158868f, -0.02001741f, 
    0.02445012f, -0.13691688f, -0.06533294f, -0.03237160f, 0.03190059f, -0.06794371f, 0.18515565f, 0.11149985f, 
    -0.18098256f, -0.08234932f, 0.06908932f, -0.06387706f, -0.00746593f, -0.05134705f, 0.07394277f, -0.03824037f, 
    0.13144946f, 0.09361377f, 0.12280535f, 0.02735563f, -0.08122855f, -0.17822294f, 0.24641314f, -0.06846085f, 
    0.07795935f, 0.06370862f, 0.07884438f, 0.01722013f, 0.05801274f, 0.14177093f, 0.00245983f, -0.00299767f, 
    0.04483927f, 0.41880777f, -0.03134846f, 0.06593712f, 0.04102460f, 0.13064362f, -0.01737831f, 0.18361515f, 
    0.06879875f, -0.15529883f, 0.02572148f, -0.03140817f, 0.00016066f, -0.14687584f, -0.06151957f, 0.14113551f, 
    -0.13832171f, -0.15835708f, 0.04687379f, -0.13209988f, -0.00498817f, -0.03950598f, 0.00129880f, -0.03289908f, 
    0.13548587f, 0.23475404f, -0.05661964f, -0.06839640f, 0.17147399f, -0.07196532f, -0.11940240f, -0.05548331f, 
    -0.06367762f, 0.05777287f, -0.03199230f, 0.11043863f, 0.10737929f, 0.11815371f, 0.08547781f, -0.05616806f, 
    -0.03212062f, -0.04237967f, 0.00216210f, -0.06981973f, -0.06996767f, -0.01289087f, 0.01986672f, -0.21497427f, 
    -0.13782647f, 0.13378766f, 0.53477478f, -0.15154530f, -0.00732243f, 0.06701493f, 0.22018257f, 0.09111477f, 
    0.09863561f, 0.16278216f, -0.01196393f, 0.00293120f, -0.38894671f, 0.04721169f, -0.04901716f, -0.16908064f, 
    0.13145466f, -0.20762299f, 0.05841012f, 0.12888947f, 0.00313687f, 0.13636082f, -0.00896075f, -0.01720306f, 
    0.31089652f, -0.02832757f, 0.10230545f, 0.18722223f, 0.00269083f, 0.27380377f, 0.02395158f, 0.09767099f, 
    0.02550026f, 0.00669089f, 0.08297364f, -0.00769206f, 0.18848428f, -0.08897632f, -0.06818271f, 0.02163048f, 
    -0.07612516f, 0.00894929f, 0.06324163f, 0.08617316f, -0.03959731f, 0.03793820f, -0.18109958f, -0.01817766f, 
    0.18049137f, -0.02344367f, 0.07717705f, 0.14134805f, 0.08220026f, -0.02160593f, -0.06953255f, 0.21853270f, 
    0.03628661f, 0.15401269f, 0.22132188f, 0.30260849f, 0.03908034f, 0.28648645f, -0.30545518f, -0.11274107f, 
    -0.18690181f, 0.00902714f, -0.07596029f, -0.11322386f, 0.14357267f, 0.00823309f, -0.03330319f, 0.11218851f, 
    0.17009825f, -0.52092934f, -0.04702851f, 0.25962144f, -0.05516319f, 0.06397286f, 0.00852340f, 0.09747016f, 
    0.08118173f, 0.05806416f, 0.23776810f, 0.15428860f, -0.01871055f, -0.25174317f, 0.10411992f, 0.00533668f, 
    0.15465601f, 0.02034305f, 0.21452089f, 0.04171630f, 0.03106312f, -0.01222382f, -0.23529153f, -0.43079570f, 
    0.19159888f, 0.28755209f, 0.04090594f, 0.06721799f, 0.09815433f, 0.12627392f, 0.09875038f, 0.19879785f, 
    0.04511603f, 0.12945582f, 0.01017408f, -0.03232400f, 0.21562681f, -0.05292888f, 0.10559081f, -0.12142172f, 
    -0.05019393f, -0.17185672f, -0.02807382f, -0.20894629f, 0.00699027f, 0.01608113f, -0.07468145f, -0.02474547f, 
    0.01090997f, 0.13019794f, 0.04450342f, -0.07546524f, 0.03079010f, 0.12968150f, 0.00324855f, 0.13236469f, 
    -0.00526097f, -0.13805868f, -0.05903097f, 0.11895647f, -0.07953848f, -0.14916240f, 0.33421037f, 0.02219353f, 
    0.27654999f, 0.26143235f, -0.03868506f, -0.04283599f, -0.09092735f, -0.10724866f, -0.15522148f, -0.12999044f, 
    -0.12388846f, 0.28765455f, -0.16898681f, -0.00218308f, 0.20397353f, -0.00875062f, -0.02335648f, 0.11561809f, 
    -0.10355287f, -0.06435597f, 0.02061651f, -0.02061891f, -0.14978123f, -0.39842880f, 0.10401664f, -0.18331239f, 
    0.06423068f, 0.22763200f, 0.13204768f, -0.09552773f, 0.07448252f, -0.19217503f, -0.14801152f, -0.32990274f, 
    0.11162923f, -0.08169329f, -0.11089783f, 0.18250771f, 0.22329035f, -0.00830565f, 0.05449615f, 0.02795701f, 
    -0.33577892f, 0.12201293f, 0.17416783f, -0.16440009f, 0.04270631f, -0.16943870f, -0.12270790f, 0.17231970f, 
    0.22398199f, -0.05459436f, -0.06667250f, 0.11155865f, 0.12067847f, -0.09627400f, 0.18255258f, 0.04926406f, 
    0.16002111f, -0.25519839f, 0.27591836f, -0.37651116f, 0.19864488f, 0.12999338f, 0.14951833f, 0.04457358f, 
    -0.10044372f, 0.14590086f, -0.03433351f, 0.06489700f, -0.04228956f, 0.21671270f, 0.33923411f, -0.03334745f, 
    -0.09485173f, -0.01158853f, -0.07523517f, 0.02136684f, 0.13262387f, 0.02238037f, 0.16466324f, 0.21159437f, 
    -0.38845596f, -0.06507451f, -0.08401594f, -0.19991724f, -0.06320311f, 0.08822302f, 0.06605247f, -0.04806969f, 
    0.06682243f, -0.16322474f, -0.09158557f, 0.08667490f, 0.31181443f, -0.32437292f, 0.11516648f, -0.11163455f, 
    0.16572228f, -0.00971426f, 0.14542912f, 0.00226033f, -0.14543870f, -0.00347614f, -0.14135563f, -0.20603497f, 
    0.01757908f, 0.06426039f, 0.06096184f, 0.03100897f, -0.02086711f, 0.02291994f, 0.03325429f, -0.07097606f, 
    -0.05740140f, -0.08035246f, -0.00011804f, -0.01736506f, 0.00463284f, -0.05266349f, -0.06148698f, -0.03290062f, 
    -0.06907873f, -0.01792955f, 0.06506918f, -0.00607552f, 0.03648411f, -0.04205664f, -0.07617448f, 0.03856501f, 
    0.01057111f, -0.04722644f, 0.00314756f, -0.03724977f, -0.03829047f, -0.02263973f, -0.07475987f, 0.05749317f, 
    0.00423353f, 0.00078656f, -0.03327309f, -0.02270536f, -0.05750542f, 0.04088339f, 0.06133873f, -0.04853605f, 
    -0.03900189f, 0.00920916f, 0.04574096f, -0.03782113f, 0.05019249f, 0.00111663f, 0.03796702f, 0.00727724f, 
    0.01418316f, -0.01002864f, 0.00008907f, -0.06500977f, 0.02601457f, -0.00529292f, -0.04800425f, -0.05854421f, 
    -0.04854816f, 0.00414157f, 0.00372495f, 0.00007587f, -0.01484771f, -0.07149903f, -0.05578865f, -0.00933704f, 
    0.02875462f, -0.06204747f, -0.02480054f, -0.05853184f, -0.02255727f, 0.05332427f, -0.05729886f, -0.07218933f, 
    -0.01637739f, 0.01547450f, 0.05414759f, -0.07770278f, 0.00993497f, 0.04438866f, 0.01201651f, -0.04693390f, 
    -0.05097645f, -0.04810382f, -0.06266656f, 0.02787848f, -0.04032579f, -0.02613701f, 0.05839906f, 0.05648246f, 
    -0.05692066f, -0.00980492f, 0.00918518f, -0.04087273f, 0.03429535f, -0.04544421f, 0.03984307f, 0.01262730f, 
    -0.04138029f, 0.05453377f, -0.03197869f, 0.02761362f, -0.08219294f, -0.04591677f, 0.02164445f, -0.05727269f, 
    -0.05705747f, 0.06238908f, -0.02245063f, -0.02973072f, 0.03115164f, 0.03473117f, 0.04485500f, -0.01579116f, 
    -0.03242965f, -0.05213343f, -0.03018257f, 0.02805874f, -0.04420904f, 0.05441731f, -0.06275918f, -0.07879573f, 
    -0.07777768f, 0.00203920f, -0.02334932f, -0.02379379f, -0.02116575f, 0.04920979f, -0.07063489f, 0.02823106f, 
    0.00971171f, 0.00064936f, -0.07094844f, -0.04919546f, -0.00691256f, 0.05171435f, 0.01669575f, -0.07807577f, 
    0.02504559f, 0.03385321f, 0.00666307f, 0.04661797f, -0.06078979f, 0.02027309f, -0.02846023f, 0.05401673f, 
    0.04559533f, 0.03187856f, 0.04278795f, -0.06742261f, -0.00600283f, 0.03051040f, 0.00723609f, 0.01506470f, 
    -0.06265249f, -0.06968240f, 0.05910802f, 0.03620033f, 0.01855936f, 0.05516340f, 0.02183299f, -0.00161066f, 
    -0.00458315f, -0.00742926f, 0.01668355f, -0.03688325f, -0.00787087f, 0.04516531f, 0.03534292f, -0.02062839f, 
    -0.07760116f, -0.02858465f, -0.03311782f, 0.00132011f, -0.05190485f, 0.05203040f, 0.03250939f, 0.00445902f, 
    0.05791740f, 0.03846801f, 0.05386429f, -0.07553391f, -0.03826394f, 0.04404229f, -0.03982690f, -0.06417041f, 
    0.01615328f, 0.00051763f, -0.05945998f, -0.02767444f, -0.02333950f, -0.04696912f, 0.01018566f, 0.02512945f, 
    -0.18050118f, 0.13032712f, -0.14681834f, 0.05345203f, 0.03761657f, 0.08324534f, 0.02735245f, 0.04331625f, 
    0.03735207f, 0.04696574f, 0.05370558f, -0.00362566f, 0.75897968f, 0.37670615f, 0.19463693f, 0.43583912f, 
    0.09742413f, -0.05757499f, 0.11170517f, 0.16402438f, 0.08701688f, 0.08926561f, 0.00608764f, -0.01787471f, 
    -0.03726876f, 0.11652001f, -0.31548500f, -0.27303672f, -0.15413935f, 0.01830266f, 0.22084205f, 0.04233232f, 
    0.10771406f, 0.24591000f, 0.17378297f, 0.16774039f, -0.27937853f, 0.14424542f, 0.09436461f, 0.01535222f, 
    -0.04815205f, 0.09242794f, -0.11913366f, 0.36872131f, -0.07854337f, -0.12756439f, 0.00818754f, 0.07779099f, 
    -0.22003433f, -0.17549196f, 0.09491969f, 0.02739594f, 0.08013000f, 0.11007130f, 0.02255546f, 0.00612597f, 
    0.07825781f, 0.03278463f, 0.02229291f, 0.00198698f, -0.05625213f, 0.23792601f, -0.12671228f, 0.03126808f, 
    0.02677240f, -0.06674747f, 0.16658893f, 0.03677130f, 0.04843369f, -0.07538678f, 0.11852200f, 0.04507122f, 
    -0.15081191f, -0.17945087f, -0.06681578f, 0.14837034f, -0.02336516f, -0.07644740f, 0.02170682f, -0.18844433f, 
    -0.02438947f, 0.08878099f, -0.03777161f, 0.01679466f, -0.18028420f, -0.32827398f, -0.34712422f, 0.15463655f, 
    -0.01903252f, 0.10008394f, 0.04320812f, -0.02309344f, -0.05877768f, 0.07997251f, -0.15284841f, -0.05139500f, 
    0.18603557f, -0.07855792f, 0.33535406f, -0.05335615f, 0.17629656f, 0.15236090f, 0.08228149f, -0.07399983f, 
    -0.09228808f, -0.18175687f, 0.14279252f, -0.07138366f, -0.14501399f, -0.13385946f, 0.11379737f, 0.23105502f, 
    0.01420607f, -0.04995396f, 0.06057801f, -0.23650101f, -0.15224501f, -0.20351817f, 0.12245380f, -0.01630288f, 
    0.03162477f, 0.04057274f, 0.11199345f, 0.04339880f, -0.10414992f, 0.06234827f, -0.17300649f, -0.16330163f, 
    -0.15264146f, -0.04891803f, -0.01860618f, -0.07781947f, -0.34058994f, -0.22100173f, -0.11954404f, -0.17010061f, 
    0.00881217f, -0.01528314f, -0.06450436f, -0.11176195f, 0.05320903f, -0.04008853f, -0.17102253f, -0.01024666f, 
    -0.52030694f, 0.23711099f, 0.01037626f, 0.55918163f, 0.11156479f, 0.15794100f, -0.09675638f, 0.03076456f, 
    0.07508589f, -0.07091735f, -0.06513701f, 0.00161898f, -0.16698229f, 0.06328251f, 0.11161084f, 0.14554773f, 
    0.17286161f, 0.10659245f, 0.04368146f, -0.05517092f, -0.00216986f, 0.04530006f, -0.00789965f, 0.20096450f, 
    0.02847761f, 0.11023461f, -0.18541658f, -0.10312064f, -0.21419765f, -0.01034349f, 0.25275180f, 0.34632954f, 
    -0.12352999f, -0.04349424f, -0.14515693f, 0.04314240f, -0.18729338f, -0.49587172f, -0.29587284f, 0.01831022f, 
    -0.15727295f, 0.18117698f, 0.09882434f, -0.11466812f, 0.04310114f, -0.02391828f, -0.10247049f, 0.04786265f, 
    -0.02472663f, -0.10324936f, -0.01121704f, -0.12701073f, 0.08308194f, 0.23573311f, 0.29327506f, -0.05232760f, 
    0.24411857f, -0.06120690f, -0.06653746f, -0.10498597f, -0.21659189f, -0.17214122f, -0.02373381f, 0.02036345f, 
    0.07472015f, 0.04231923f, -0.05635894f, 0.13386825f, -0.02419676f, 0.05667717f, 0.16604021f, 0.01678725f, 
    -0.11931388f, 0.22822759f, 0.05810626f, -0.04112370f, 0.03273436f, -0.00234311f, -0.04791990f, -0.13188948f, 
    -0.07970949f, -0.15867147f, -0.07018448f, 0.00348860f, -0.01093366f, 0.06997612f, -0.08085110f, 0.01537506f, 
    0.10333326f, 0.14119968f, 0.07435774f, -0.14070706f, 0.02073572f, 0.06452608f, 0.09125639f, 0.07285167f, 
    -0.13202626f, -0.23693913f, -0.27175847f, -0.16169684f, 0.08974347f, -0.04336337f, -0.03699494f, -0.14213721f, 
    0.12265951f, 0.06937606f, 0.15656593f, 0.12495133f, -0.04263793f, -0.02187423f, -0.07330870f, -0.11037737f, 
    -0.04513398f, -0.15545391f, -0.15123883f, -0.09209195f, 0.09598272f, 0.11284460f, 0.09666506f, 0.06873715f, 
    0.03661141f, -0.20329179f, -0.09596545f, -0.05093462f, 0.11441041f, 0.04929995f, 0.05777312f, 0.11539124f, 
    -0.01344096f, 0.07370779f, -0.01054223f, 0.01472842f, 0.18072271f, -0.19380695f, -0.09868298f, 0.00561035f, 
    -0.02479765f, -0.19808634f, 0.04357360f, -0.02434278f, -0.01925024f, -0.02278852f, -0.06104647f, -0.02584689f, 
    -0.22182789f, -0.07401061f, 0.08708461f, 0.00612039f, -0.11622789f, -0.01152982f, 0.00358247f, 0.12112419f, 
    -0.00388617f, 0.04955519f, -0.02126865f, 0.05648153f, 0.05862224f, -0.06481789f, -0.09539415f, -0.03674107f, 
    0.00170046f, 0.02986631f, -0.06039397f, 0.08495586f, 0.07046908f, -0.01721238f, 0.14393747f, 0.08960111f, 
    0.08883372f, 0.00712680f, -0.04964302f, -0.00778455f, -0.05482316f, -0.08386075f, -0.05724851f, -0.04548039f, 
    0.06751195f, -0.08414028f, 0.03365510f, 0.09989392f, -0.08408622f, 0.12355483f, -0.00082811f, -0.03316050f, 
    -0.10527717f, -0.00366905f, -0.02771864f, -0.05812764f, -0.06525406f, 0.05296839f, -0.05555012f, -0.05909826f, 
    0.51400405f, -0.25932759f, 0.06609171f, 0.14085270f, 0.03998181f, 0.10224324f, 0.08755431f, -0.04681643f, 
    0.23250474f, 0.10360732f, 0.08306122f, 0.09127396f, 0.42304876f, -0.23944919f, 0.06344764f, 0.01754860f, 
    -0.17496809f, -0.12657188f, -0.02171572f, 0.13208981f, 0.10829737f, 0.17776318f, 0.06708089f, -0.07325638f, 
    0.20777479f, -0.02020905f, 0.09848332f, 0.18110593f, 0.12769008f, 0.10863413f, -0.18335585f, 0.09664520f, 
    -0.03676173f, 0.02789020f, 0.08219107f, 0.02122973f, -0.20838480f, -0.03839822f, 0.02045902f, -0.09068473f, 
    -0.08653948f, 0.00970273f, 0.02575302f, 0.02960620f, -0.12885767f, -0.05520441f, 0.02960795f, 0.11615670f, 
    0.02167227f, 0.03403953f, -0.16357377f, -0.12006290f, 0.15923689f, 0.05281724f, 0.15595710f, 0.04329725f, 
    -0.01473590f, -0.07229700f, -0.10499621f, -0.09006203f, -0.14525048f, -0.09796838f, -0.06093618f, 0.03557178f, 
    0.13383402f, 0.07092845f, 0.12044431f, 0.24568661f, 0.02128045f, 0.11983840f, 0.13712761f, -0.00437878f, 
    -0.27069584f, 0.21854807f, 0.12423018f, -0.00667853f, -0.08603394f, 0.00709627f, -0.09771177f, -0.19267407f, 
    -0.08725540f, -0.08232652f, -0.23865254f, -0.05683253f, -0.04164261f, -0.08395820f, -0.31695312f, 0.26751342f, 
    0.11952493f, -0.08478333f, 0.10415071f, -0.31213027f, -0.02668033f, 0.22525942f, 0.15268037f, 0.06155464f, 
    -0.02719691f, -0.06860219f, -0.25114420f, -0.08995729f, 0.08364932f, 0.14062411f, -0.04452397f, -0.10157149f, 
    -0.11836140f, 0.02648006f, 0.02068893f, 0.10299726f, -0.18836582f, 0.00782246f, -0.03637544f, 0.00305934f, 
    -0.12249589f, -0.08062437f, -0.12506077f, -0.09393202f, 0.02626371f, 0.18461342f, 0.16061372f, 0.07669434f, 
    0.00556277f, -0.04189321f, 0.10682121f, -0.02389653f, 0.19419274f, 0.21635202f, 0.09012501f, 0.10645096f, 
    0.08366372f, 0.11670565f, 0.07551859f, 0.13388363f, 0.24173540f, 0.06214294f, -0.22358616f, -0.15636802f, 
    0.12590569f, 0.06248090f, 0.05324690f, 0.12235281f, -0.03347659f, -0.05397670f, 0.08454995f, 0.11524655f, 
    -0.26319939f, -0.08233394f, 0.05725478f, -0.09663541f, -0.04649907f, 0.16644634f, 0.02286205f, 0.17969760f, 
    -0.01924532f, 0.04012452f, 0.04581630f, 0.13104422f, 0.05202195f, -0.14980188f, -0.11604120f, -0.09917794f, 
    -0.13073678f, -0.01269866f, -0.10004618f, 0.11860736f, 0.12437365f, 0.04915644f, 0.06772310f, 0.06611103f, 
    0.15253145f, 0.19231190f, -0.09111590f, 0.24409939f, -0.15573917f, -0.14731942f, 0.01510486f, -0.25853181f, 
    0.13222884f, -0.13114387f, 0.02465557f, 0.08527777f, -0.03828121f, 0.07090491f, 0.03828571f, -0.04863771f, 
    -0.26917979f, -0.14325300f, -0.02908737f, -0.10368865f, -0.08292306f, 0.04186294f, 0.05900925f, -0.03870561f, 
    0.25141263f, 0.22550143f, -0.18061723f, 0.10046005f, -0.06969367f, 0.07934299f, 0.10416609f, -0.00568332f, 
    0.14324158f, 0.03063291f, 0.08203969f, 0.05367829f, 0.26858494f, 0.22757976f, -0.13983770f, -0.30720246f, 
    -0.19250327f, -0.06217853f, -0.00194982f, 0.24938199f, 0.14048125f, -0.07487743f, 0.00355097f, -0.07231163f, 
    -0.04043036f, -0.02090044f, -0.13026704f, 0.37412813f, 0.00160944f, 0.03827757f, -0.27072081f, 0.01037743f, 
    0.08274935f, 0.05640659f, 0.14227685f, 0.14640105f, -0.39400366f, -0.00930319f, -0.01464381f, -0.15159585f, 
    -0.14290228f, 0.00810981f, -0.07834435f, -0.11792634f, -0.10849832f, -0.07454603f, -0.02389171f, -0.00386265f, 
    -0.15996978f, -0.06695338f, -0.03017851f, -0.16413447f, 0.06906770f, -0.14077979f, 0.07681187f, -0.10111313f, 
    0.06757773f, -0.17562704f, -0.06155559f, -0.06949227f, -0.16872713f, -0.25624081f, -0.00670445f, -0.08618546f, 
    0.05735073f, 0.14249760f, -0.03647557f, 0.24074496f, 0.11801849f, -0.07899881f, -0.06545358f, -0.15949894f, 
    -0.15877162f, 0.14241005f, 0.12010643f, 0.05652617f, -0.06295077f, -0.08255678f, -0.10404823f, 0.06466402f, 
    0.07719976f, -0.19408770f, -0.21796454f, 0.07603879f, 0.12637146f, -0.09462779f, -0.04863096f, 0.02308647f, 
    -0.04649575f, 0.08068418f, 0.18040517f, -0.10637985f, -0.14591785f, 0.01531551f, 0.15276153f, -0.00072633f, 
    -0.16287068f, -0.10303076f, -0.25351867f, -0.13210890f, 0.01146688f, 0.05178950f, -0.07122131f, -0.23476371f, 
    -0.04570545f, 0.16675720f, -0.01848326f, 0.12519589f, -0.22850868f, -0.00019938f, 0.02223394f, 0.01630714f, 
    -0.15837915f, -0.05821948f, -0.04750077f, -0.05065966f, -0.00518361f, 0.13026661f, 0.04458044f, -0.02224042f, 
    -0.01285154f, -0.08208559f, 0.05140081f, -0.03620983f, 0.03913772f, 0.14420639f, 0.05168198f, 0.06990547f, 
    0.12481266f, 0.09962666f, 0.11123446f, 0.17161438f, -0.04014973f, 0.10408752f, -0.26859710f, -0.16743854f, 
    0.07228291f, -0.07254289f, -0.02355328f, 0.06645095f, -0.02234713f, -0.02066424f, 0.23061870f, 0.05542871f, 
    -0.05427524f, -0.11514863f, -0.09719358f, -0.00499261f, -0.07845503f, 0.08385079f, -0.14859429f, 0.14116113f, 
    -0.04845321f, 0.01132217f, 0.06852194f, 0.21012855f, 0.00973397f, 0.11666188f, -0.17390487f, 0.01739793f, 
    0.05104363f, 0.05274474f, -0.17282076f, 0.01375404f, -0.08633092f, -0.01300624f, 0.11481906f, 0.08845466f, 
    0.20170130f, 0.13407719f, 0.01076021f, 0.08044348f, -0.20958711f, -0.13953456f, -0.05394296f, -0.12309076f, 
    0.07702578f, -0.05903555f, 0.05241832f, -0.01729040f, 0.12904535f, 0.16190653f, -0.01042856f, 0.09047346f, 
    -0.08338504f, -0.03422443f, -0.11459246f, -0.08491993f, 0.01016526f, -0.06160512f, 0.04050837f, 0.03675158f, 
    0.14816874f, 0.37311825f, -0.10117581f, 0.10741506f, 0.02839627f, -0.09165973f, 0.27986357f, -0.03192423f, 
    0.11768164f, 0.10967829f, 0.06523076f, 0.03756574f, 0.14173637f, -0.09370071f, -0.08573207f, 0.05598274f, 
    -0.00715260f, -0.10421804f, 0.12680145f, 0.17802677f, 0.08113011f, -0.04586994f, 0.05280770f, -0.03029099f, 
    0.18971516f, 0.14087571f, 0.22329006f, 0.19978158f, -0.02386408f, 0.04645928f, -0.21915589f, -0.00619350f, 
    -0.05572411f, -0.03976391f, 0.14581960f, 0.11416472f, -0.05766741f, 0.13201545f, 0.07994825f, 0.06818438f, 
    -0.08109988f, -0.06344908f, -0.08117335f, 0.00479017f, -0.07322375f, -0.00623297f, 0.02170522f, -0.00947265f, 
    -0.13297477f, -0.11104050f, -0.19557732f, -0.05546856f, 0.01848892f, 0.05544792f, 0.05175255f, 0.05151163f, 
    -0.00109513f, -0.05748833f, -0.05506406f, 0.00917360f, 0.15601251f, 0.27943707f, -0.24646007f, 0.04584857f, 
    -0.03372432f, 0.03697991f, 0.15312710f, 0.03663399f, 0.01185011f, 0.12334456f, 0.34620237f, 0.11298940f, 
    0.07566573f, 0.02497421f, -0.01418836f, 0.05013144f, 0.06428235f, -0.10327341f, 0.01969111f, -0.09499261f, 
    0.04083633f, 0.04866402f, 0.05548564f, 0.01302038f, -0.08882199f, -0.00245694f, -0.09285146f, -0.09975934f, 
    0.45108360f, -0.10487778f, -0.10030894f, -0.10025730f, 0.05939935f, -0.00819372f, -0.08866650f, 0.09343972f, 
    -0.10650340f, -0.12984070f, -0.06578319f, -0.01803483f, 0.16348803f, 0.12226862f, 0.17145538f, 0.00706077f, 
    0.02375087f, 0.00459275f, 0.10124949f, 0.03796032f, 0.22967528f, 0.01100443f, 0.13549566f, 0.03678437f, 
    0.05617016f, -0.17814833f, 0.02027804f, -0.11362579f, 0.09974236f, 0.04303576f, 0.21943645f, 0.13668311f, 
    -0.15236440f, -0.34615761f, -0.04301783f, -0.05759558f, 0.06159689f, -0.05421064f, 0.04666517f, 0.17697528f, 
    0.07364567f, 0.09223785f, 0.09407248f, 0.04762942f, 0.33219764f, -0.39995959f, 0.04574920f, -0.22547573f, 
    0.09773709f, 0.00444987f, -0.03177683f, -0.07330354f, 0.00190307f, 0.08874118f, -0.01878247f, 0.03317745f, 
    -0.26191077f, 0.40327758f, 0.05321201f, 0.18949775f, 0.22532228f, 0.07492573f, 0.16872369f, 0.26019156f, 
    0.14477436f, 0.02848377f, -0.00626790f, -0.04252210f, 0.10034510f, -0.20056012f, 0.04194063f, -0.07461643f, 
    0.00281672f, -0.00723167f, 0.09832811f, -0.09821206f, 0.11480080f, 0.03914051f, 0.04159608f, 0.05938059f, 
    -0.06516997f, 0.17013864f, -0.08418215f, 0.19489057f, 0.08211164f, 0.04624991f, -0.05444575f, -0.04856167f, 
    -0.12408356f, -0.07002626f, -0.10431627f, 0.06454530f, -0.03853275f, -0.06764502f, 0.06933706f, -0.03479760f, 
    0.09252807f, 0.13214484f, 0.04038648f, -0.10531941f, 0.06873758f, 0.04207944f, 0.02408052f, -0.02023308f, 
    -0.01460075f, -0.21706334f, 0.33236897f, -0.10202734f, 0.22202165f, 0.17103900f, 0.11640006f, 0.00313230f, 
    0.05685380f, 0.00923694f, -0.03900605f, 0.02369211f, -0.18988098f, 0.26643887f, -0.03200622f, -0.24728973f, 
    -0.00054694f, 0.06919726f, -0.14256248f, 0.03223267f, -0.05444333f, 0.07716718f, 0.03568944f, -0.06139894f, 
    -0.07609452f, 0.09294386f, -0.32102147f, 0.17297141f, 0.08098857f, 0.03461700f, 0.09665167f, -0.09588679f, 
    0.11821178f, 0.08532704f, -0.11045664f, 0.03978799f, -0.00456407f, -0.23161328f, 0.04556413f, 0.06881250f, 
    0.04312666f, 0.03971456f, 0.05629638f, -0.04553637f, 0.08630498f, 0.08665159f, -0.20542730f, -0.01108398f, 
    -0.27628705f, -0.07311279f, 0.16862646f, -0.19430390f, -0.12965226f, 0.07324364f, 0.15008138f, -0.25625846f, 
    0.07256197f, -0.09717461f, 0.02932723f, -0.11474129f, -0.09259751f, 0.26298797f, 0.09831824f, 0.05020936f, 
    0.23923106f, 0.04933294f, 0.02566271f, 0.18947138f, -0.00561192f, 0.14331207f, 0.01602139f, 0.11198914f, 
    0.04803665f, -0.01066487f, -0.18110868f, 0.03723498f, -0.04534483f, -0.12023741f, 0.01489933f, -0.02871655f, 
    0.03653580f, -0.10435396f, 0.10360643f, 0.09242573f, 0.25722679f, -0.00625491f, -0.09314217f, -0.08589412f, 
    0.02736668f, 0.10475958f, 0.06716412f, -0.12086947f, -0.10284236f, 0.04898255f, -0.02595670f, 0.04472362f, 
    -0.20218500f, -0.05987521f, 0.03354819f, -0.15141827f, -0.05992164f, -0.04136119f, -0.15076008f, -0.17806931f, 
    0.10392305f, -0.07671097f, -0.06397549f, 0.06843070f, -0.09394301f, -0.11035815f, -0.02865470f, 0.10867210f, 
    0.00019598f, -0.15164180f, -0.04715672f, 0.05377093f, 0.07578070f, 0.16247703f, -0.00230304f, 0.06802057f, 
    0.00007323f, 0.02527980f, 0.04281603f, -0.10989818f, 0.09801067f, -0.07447413f, 0.08891674f, -0.01404425f, 
    0.07433819f, -0.02640583f, -0.04257609f, -0.10612896f, 0.19735967f, -0.24917628f, 0.01850045f, 0.10863395f, 
    0.02858401f, -0.16397321f, 0.02305295f, 0.16112527f, -0.06182478f, 0.05912910f, 0.02384984f, -0.06517476f, 
    0.12809335f, 0.14528359f, -0.07879587f, -0.08013967f, 0.11053754f, 0.11960362f, 0.03487453f, -0.05968698f, 
    0.03579592f, 0.09163412f, 0.07876755f, 0.04458378f, -0.08968332f, 0.04941370f, -0.22310306f, 0.20787431f, 
    0.18539257f, -0.06351309f, 0.06983701f, -0.04026589f, 0.00743585f, -0.07457064f, -0.01549278f, 0.01345374f, 
    -0.00478721f, -0.02619972f, 0.04099391f, -0.12694839f, 0.00422315f, -0.11355524f, -0.03163114f, -0.01474632f, 
    0.00197465f, 0.00008165f, -0.01248917f, 0.03172525f, -0.03832447f, 0.08022728f, -0.06388431f, 0.05887158f, 
    -0.03409319f, -0.08200663f, -0.03952302f, -0.02095130f, 0.04649408f, -0.00562426f, -0.06528447f, 0.04434356f, 
    0.34474623f, -0.27612001f, 0.19082196f, 0.09815170f, 0.03295207f, -0.03835642f, 0.22770631f, 0.10916501f, 
    0.11310855f, 0.11242230f, 0.07119275f, 0.04708432f, 0.04910320f, -0.41483006f, 0.04804232f, 0.12957871f, 
    -0.12188014f, -0.13724245f, 0.01429742f, -0.00855877f, 0.24456184f, 0.15716201f, 0.07308289f, 0.10472298f, 
    0.56993598f, 0.07319862f, 0.07031393f, 0.02861828f, 0.05993292f, 0.17870480f, -0.13342528f, 0.08186297f, 
    -0.04283303f, 0.14656007f, 0.02715472f, -0.09662782f, -0.06731644f, -0.10341607f, 0.09174927f, -0.03541222f, 
    -0.08184502f, -0.10324866f, 0.04577523f, 0.00118381f, -0.03844881f, 0.05512578f, -0.02414604f, 0.04731056f, 
    0.02645466f, -0.00708750f, -0.07143424f, -0.08250222f, 0.02595078f, 0.02145052f, 0.05858722f, -0.02400408f, 
    0.00189507f, -0.01092985f, -0.01734810f, 0.03714538f, -0.00441521f, 0.02659680f, 0.02634064f, 0.00285403f, 
    -0.03060746f, 0.04206517f, -0.04876504f, 0.03737944f, -0.08086251f, -0.04541722f, -0.07108519f, 0.06203027f, 
    -0.03708481f, -0.04045121f, -0.00512023f, 0.01497196f, -0.03132384f, -0.02561128f, 0.00396434f, -0.07354847f, 
    -0.05713600f, -0.05887688f, 0.02000854f, 0.00536138f, 0.04836889f, 0.02444349f, -0.07912294f, 0.03614100f, 
    -0.02251871f, -0.02397040f, -0.04354106f, 0.01723715f, -0.07151964f, 0.00821057f, 0.02188739f, -0.00416731f, 
    0.04032509f, -0.04830278f, -0.01773490f, -0.06314546f, 0.04362580f, -0.02667782f, 0.04967397f, 0.04380264f, 
    0.00228345f, -0.07130340f, -0.01042891f, 0.02019194f, 0.04638803f, 0.03900681f, 0.02394452f, -0.01351288f, 
    0.05267390f, -0.03495722f, 0.04027244f, -0.02073981f, -0.04079089f, 0.01526876f, -0.08585139f, 0.05331945f, 
    -0.02477654f, 0.03652338f, 0.01195691f, -0.04837999f, -0.03199483f, -0.02314364f, -0.06356401f, -0.06735686f, 
    0.00549115f, -0.02981113f, -0.05891151f, 0.05559392f, 0.02321982f, 0.03568534f, 0.03595363f, -0.05955330f, 
    -0.02885908f, -0.08230320f, -0.06153865f, -0.04784700f, -0.06661656f, 0.03714512f, -0.05614690f, 0.06056963f, 
    -0.04891797f, -0.00918049f, -0.05101576f, -0.07367081f, 0.05841419f, 0.00137083f, -0.01407116f, -0.04951375f, 
    -0.07528105f, -0.07315646f, -0.04254365f, -0.03307192f, 0.05130375f, -0.05585417f, -0.05270603f, -0.00299130f, 
    0.05453871f, -0.07090373f, -0.05398618f, -0.04709027f, -0.00325511f, -0.07053649f, -0.08510795f, 0.04676388f, 
    0.00356462f, -0.08284130f, -0.02790814f, 0.03956401f, 0.03945741f, 0.03048073f, -0.05087603f, -0.01374999f, 
    -0.03104995f, 0.00177876f, -0.05050679f, -0.08272567f, 0.00042047f, -0.01818169f, 0.02464136f, -0.01944188f, 
    -0.03072041f, -0.05241661f, -0.06053896f, 0.02182384f, 0.02410146f, 0.05143764f, -0.06705687f, -0.01953990f, 
    0.04098679f, 0.03812292f, -0.01507322f, 0.00682207f, -0.03799770f, -0.08295050f, -0.01362284f, 0.02608072f, 
    -0.02135686f, -0.01706566f, 0.02756414f, -0.08018627f, 0.03219739f, 0.04124990f, -0.04529051f, 0.01102444f, 
    -0.08402095f, -0.06222622f, -0.07173099f, 0.00598745f, 0.02778432f, -0.02003111f, -0.03489742f, -0.01286450f, 
    -0.05752835f, -0.05657746f, -0.02445357f, -0.06536121f, 0.05091521f, 0.01004384f, 0.03310857f, 0.05011082f, 
    -0.05745773f, -0.00448863f, 0.05456271f, -0.04242318f, -0.01933331f, 0.02954860f, 0.01030446f, 0.04277632f, 
    0.05394612f, 0.00726076f, 0.05322077f, -0.04102605f, -0.02747227f, 0.03990338f, 0.02677080f, -0.03624091f, 
    -0.24956341f, 0.12741722f, -0.21154170f, 0.08965448f, 0.06939258f, 0.00372450f, 0.07509829f, -0.01337469f, 
    0.00715045f, -0.15282732f, -0.11823209f, -0.20070392f, -0.00654263f, 0.19774926f, 0.31940821f, 0.15787546f, 
    -0.00883531f, -0.07557813f, 0.21658067f, -0.01789377f, 0.01756503f, 0.09089770f, 0.10107479f, 0.05713939f, 
    -0.13156810f, 0.25411361f, -0.08297996f, -0.23576730f, -0.11002656f, -0.13254924f, -0.09542833f, -0.10566699f, 
    -0.01061771f, 0.08506211f, -0.08697101f, -0.13607439f, -0.04141157f, 0.13468747f, 0.01590157f, -0.00015962f, 
    0.11547931f, 0.03132674f, -0.08550067f, 0.05400983f, 0.05200754f, -0.10871314f, 0.11372679f, 0.07629625f, 
    -0.31036341f, -0.21599893f, -0.01460928f, 0.04143361f, 0.00053534f, 0.06538359f, 0.01989401f, 0.05199829f, 
    -0.01559437f, -0.00979383f, 0.06103479f, 0.05613273f, -0.18563600f, 0.06895301f, -0.02012289f, -0.05672033f, 
    -0.09546865f, -0.08460657f, -0.03579797f, -0.07668070f, 0.15187709f, 0.21638256f, 0.16164239f, 0.06595685f, 
    -0.15718985f, -0.13767670f, -0.01196197f, 0.07059667f, -0.07239233f, -0.06521191f, 0.03975578f, 0.05770536f, 
    -0.06369761f, 0.02909495f, 0.04031206f, -0.00362647f, 0.09605686f, -0.21031114f, -0.39788321f, 0.15049244f, 
    -0.08830138f, 0.03311655f, -0.01308412f, -0.07097504f, 0.07431512f, -0.01870641f, 0.07000002f, -0.07199182f, 
    -0.06789223f, 0.03597561f, 0.40759701f, 0.09898496f, -0.00763258f, 0.09620658f, 0.10022660f, 0.14224990f, 
    -0.02065674f, -0.06279846f, 0.13322805f, 0.00027259f, -0.14000857f, 0.10255790f, 0.03438623f, 0.05590094f, 
    0.01822224f, 0.08670302f, 0.06922619f, 0.02840745f, -0.01193284f, 0.03409274f, 0.09340003f, 0.10396256f, 
    -0.04044117f, 0.16790417f, 0.06740812f, -0.02948604f, -0.09553321f, -0.13593589f, -0.10778461f, -0.14283277f, 
    -0.05299196f, -0.07132524f, -0.06367660f, -0.03403749f, -0.03149867f, 0.04873449f, -0.01288416f, -0.26456922f, 
    -0.22590823f, -0.00474026f, -0.04728752f, -0.08007133f, 0.03604954f, -0.00126439f, -0.08902185f, -0.04715773f, 
    -0.27131197f, 0.25124469f, -0.14270760f, 0.40604174f, 0.01725362f, 0.15252069f, -0.03765443f, 0.02709589f, 
    -0.03508786f, -0.11835653f, 0.04635023f, 0.00002060f, -0.14770123f, 0.28962579f, -0.18952170f, 0.00796338f, 
    -0.00187257f, 0.16106899f, -0.04540389f, 0.05316759f, 0.02115350f, 0.13973680f, 0.16719159f, 0.07450436f, 
    0.04622574f, 0.10317931f, 0.46797344f, 0.19844039f, -0.05901247f, 0.00594413f, -0.02684957f, 0.12780431f, 
    -0.08147401f, 0.09907284f, -0.00476747f, -0.04151269f, -0.15251216f, -0.00152918f, 0.04555388f, -0.00378261f, 
    -0.07042744f, 0.13735585f, 0.05661156f, 0.06530067f, 0.03144105f, 0.03211341f, 0.00298111f, -0.02760409f, 
    -0.19637722f, 0.13358425f, 0.21439818f, -0.08071861f, 0.00444776f, -0.17333150f, -0.00245248f, -0.05653522f, 
    0.00685271f, -0.15404837f, -0.01911182f, 0.01299244f, -0.35454515f, -0.20347957f, -0.10691394f, -0.34978399f, 
    0.07978740f, -0.01063606f, 0.09812730f, 0.16304326f, -0.04047543f, -0.03105113f, 0.03151999f, -0.14199287f, 
    0.24404769f, -0.09633496f, -0.05451111f, 0.14653115f, 0.07244541f, -0.12408423f, -0.09267180f, 0.04061832f, 
    -0.03143120f, -0.25760397f, -0.00049347f, -0.06892321f, 0.39692751f, -0.23296912f, 0.17343955f, -0.06717803f, 
    -0.04113605f, 0.04010457f, 0.14188333f, 0.03868889f, -0.02745056f, 0.10347259f, 0.20591918f, 0.03621072f, 
    -0.07770418f, 0.18266065f, 0.06848151f, 0.07567899f, -0.05750788f, -0.11483635f, -0.08757503f, -0.26561227f, 
    -0.07259959f, 0.14130418f, -0.04658620f, -0.04492752f, -0.34229630f, -0.15558060f, 0.00391454f, 0.11099784f, 
    -0.15321100f, -0.12621160f, -0.18231188f, -0.03048110f, 0.14389314f, 0.05951791f, 0.04385382f, 0.15202713f, 
    0.02066033f, 0.13305761f, 0.19161505f, 0.01246221f, 0.08965740f, 0.12537731f, 0.03144855f, 0.09758124f, 
    0.09007365f, 0.06499246f, 0.01920623f, 0.03795076f, -0.10648923f, -0.01291461f, 0.26767600f, -0.02301336f, 
    0.15133661f, 0.12674507f, 0.13192202f, 0.22618428f, -0.00161253f, -0.00152079f, 0.04843657f, -0.01541090f, 
    0.21010365f, 0.26104072f, -0.29117101f, -0.10800999f, -0.00495310f, 0.16137141f, -0.06615388f, 0.12069316f, 
    -0.10442828f, -0.01709620f, 0.08328809f, 0.06685662f, -0.09166789f, 0.04696706f, -0.19421797f, 0.11942267f, 
    -0.06108468f, 0.00479271f, 0.05154025f, 0.03381179f, 0.04349498f, 0.10647668f, 0.08098929f, 0.04095783f, 
    0.25928199f, -0.07591487f, 0.03863850f, 0.00158789f, 0.00677423f, 0.03908831f, -0.16298114f, -0.18527229f, 
    0.02391185f, 0.05283337f, -0.00138035f, -0.03461172f, 0.14605393f, 0.01528584f, -0.01110059f, 0.13871047f, 
    -0.06889687f, -0.07843033f, -0.05791330f, -0.04359218f, -0.07361326f, -0.00434664f, 0.18280303f, -0.13091549f, 
    0.12024894f, 0.02823738f, 0.24728797f, -0.27075058f, -0.01783336f, 0.04117018f, 0.14870422f, 0.16475888f, 
    0.10713913f, 0.13763715f, -0.04664484f, -0.03048964f, -0.20080227f, -0.17460248f, 0.09297660f, 0.09481630f, 
    -0.00408132f, -0.15339285f, 0.05870429f, -0.08999226f, 0.12207241f, -0.03267909f, -0.01865330f, 0.02500533f, 
    0.55086052f, -0.02614479f, 0.36732605f, 0.30002001f, -0.01700815f, 0.09047562f, -0.25136188f, 0.03192209f, 
    -0.02713645f, -0.00207130f, 0.18008448f, -0.14461659f, 0.29671192f, 0.11745919f, 0.03809783f, -0.03914145f, 
    -0.07637826f, -0.10637618f, -0.12567492f, 0.05948495f, 0.02875634f, -0.01737234f, -0.04513539f, -0.16004692f, 
    -0.23185571f, -0.11522596f, 0.13340613f, 0.05348327f, -0.12228689f, 0.12361959f, 0.20605811f, 0.06133176f, 
    0.17433059f, 0.05622830f, -0.03931512f, -0.12013923f, 0.17570236f, -0.00746673f, 0.09610547f, -0.07626426f, 
    -0.09795205f, -0.17147145f, 0.17639995f, 0.14109074f, 0.07847037f, -0.00459571f, 0.22111911f, 0.22437328f, 
    0.11969133f, -0.15633988f, -0.14126225f, -0.10844573f, -0.16339932f, 0.02166169f, 0.11107348f, 0.20363873f, 
    0.29468405f, 0.38736650f, -0.04015820f, 0.12503910f, 0.05395870f, 0.10515234f, 0.03744223f, -0.19157095f, 
    0.04280509f, 0.14616425f, -0.15913458f, 0.01544376f, -0.08839560f, -0.11087486f, -0.16492404f, -0.02657720f, 
    -0.16382623f, -0.12570949f, -0.13716631f, -0.22910838f, -0.06607226f, -0.06682257f, 0.14849082f, 0.17247185f, 
    0.02116071f, -0.12754469f, 0.01440701f, 0.05747960f, 0.15540388f, 0.06839962f, 0.05893128f, 0.10294587f, 
    0.18228537f, -0.06780607f, -0.00895012f, 0.04433198f, -0.14391302f, -0.00774676f, 0.06396566f, 0.07008815f, 
    -0.13424660f, -0.09931423f, -0.22405165f, -0.15298322f, 0.00292816f, -0.23257743f, -0.12054487f, -0.17325632f, 
    -0.11167544f, -0.16481693f, -0.28718475f, -0.23653360f, -0.23962821f, -0.14408715f, -0.12317575f, -0.30873317f, 
    -0.05746115f, -0.20242399f, -0.10252025f, 0.04226130f, 0.00576326f, -0.07198446f, -0.15306105f, -0.13606922f, 
    0.66092491f, -0.04481834f, 0.31077495f, -0.03623661f, -0.24171814f, -0.09076904f, 0.23833200f, 0.06452374f, 
    0.01233328f, 0.09140050f, -0.02503984f, -0.16486888f, -0.10179314f, 0.01206749f, -0.14352743f, 0.08616409f, 
    0.03874271f, 0.04932300f, 0.01592495f, 0.09774659f, -0.05617649f, -0.23907155f, -0.14908169f, -0.04291891f, 
    -0.11345229f, -0.15944535f, 0.18349664f, -0.19555384f, -0.15663867f, -0.04171317f, 0.03640413f, 0.22562179f, 
    -0.07074779f, 0.31169480f, -0.01813585f, -0.04972103f, 0.09151699f, 0.01130866f, 0.25400195f, 0.31212932f, 
    0.04121517f, 0.15030010f, 0.05254689f, -0.07527615f, -0.03240948f, -0.03728801f, -0.06487177f, 0.09926458f, 
    -0.04252182f, -0.09395126f, -0.04605884f, 0.29999843f, 0.20767716f, 0.06662962f, 0.00411905f, 0.44580957f, 
    0.17810930f, 0.10034952f, -0.00281798f, 0.01331855f, 0.00111147f, -0.06166804f, 0.11161996f, 0.10567401f, 
    0.06883165f, 0.38001511f, -0.04914381f, -0.07036296f, 0.04579507f, 0.12223577f, 0.29533681f, 0.10706765f, 
    0.59205002f, 0.00290537f, 0.02266079f, -0.02501955f, -0.10324820f, 0.16299324f, -0.02230026f, -0.10270771f, 
    -0.02419553f, 0.03327790f, -0.21464473f, -0.15475716f, 0.19155429f, 0.04804041f, 0.02574628f, 0.17379116f, 
    -0.12959217f, 0.01120899f, -0.06775214f, 0.05158023f, 0.06885803f, -0.05499965f, -0.11580171f, -0.01672966f, 
    0.28190187f, 0.02156326f, 0.42555043f, -0.06950493f, 0.05748375f, 0.04883304f, 0.31803498f, 0.08045963f, 
    0.10050309f, 0.02582609f, 0.00390881f, 0.04644263f, 0.12506644f, -0.04258875f, 0.12462299f, 0.13636068f, 
    0.00395150f, 0.16337109f, -0.09039522f, 0.09649766f, -0.02803624f, 0.05141023f, 0.02552703f, -0.07924307f, 
    -0.24659806f, -0.38675430f, 0.05106641f, -0.12099746f, 0.05215327f, 0.10763060f, -0.02179970f, 0.05129161f, 
    -0.09676309f, -0.12634395f, 0.02671269f, 0.09243792f, 0.12239087f, 0.01546575f, -0.12773599f, 0.06993604f, 
    -0.23375729f, 0.13082077f, 0.17927067f, -0.18911713f, 0.09487235f, -0.01979505f, -0.02303565f, 0.10795084f, 
    0.19049016f, 0.28350666f, 0.14396365f, 0.03659301f, -0.17056049f, -0.02743813f, -0.09494907f, -0.06384800f, 
    0.01582232f, 0.02724305f, -0.02392118f, -0.07596452f, -0.06967154f, -0.25732061f, 0.01749353f, -0.08826692f, 
    0.13541101f, 0.00284216f, 0.04962432f, 0.14889576f, 0.03591131f, 0.06222945f, -0.07876394f, -0.18006232f, 
    0.16520333f, 0.25578350f, 0.26664120f, 0.11889819f, 0.02883893f, 0.01263026f, -0.00399909f, -0.02186047f, 
    0.03578023f, -0.01692084f, -0.12113517f, -0.03767917f, 0.11463232f, 0.17785364f, 0.40390474f, 0.16155455f, 
    -0.04655777f, -0.26386833f, 0.01134477f, 0.25341612f, 0.06389529f, -0.10322789f, -0.02522018f, -0.02154305f, 
    0.15976775f, 0.00540633f, -0.27503100f, -0.22139840f, -0.15601045f, 0.02195652f, 0.05955364f, -0.32569543f, 
    -0.02386036f, 0.08217685f, -0.09268090f, 0.05711613f, -0.00414331f, -0.03812284f, -0.07310756f, -0.08048915f, 
    0.11344868f, -0.01707535f, -0.07776886f, 0.03275429f, 0.04681020f, -0.02538870f, 0.00523559f, 0.05795702f, 
    -0.11605837f, -0.16853973f, -0.34120288f, -0.07238524f, 0.13496056f, -0.05172973f, 0.03234700f, 0.06695026f, 
    0.00835165f, 0.09265918f, 0.02150043f, 0.04153309f, -0.22830670f, -0.25275257f, -0.24921052f, -0.10917012f, 
    0.14975074f, 0.04832432f, -0.02725891f, 0.14463252f, 0.00076613f, 0.03767753f, 0.17192896f, 0.08996256f, 
    0.49145225f, -0.10191341f, 0.06246437f, -0.13179991f, -0.28465217f, -0.04976515f, 0.09528640f, 0.04660696f, 
    -0.00419583f, 0.11771844f, 0.07272533f, 0.00418100f, 0.11570614f, -0.03345843f, -0.04337892f, -0.06259619f, 
    -0.05359459f, -0.16941158f, 0.02529503f, 0.00211548f, 0.23606309f, -0.11542868f, -0.02058803f, 0.01807086f, 
    0.08033832f, -0.32178640f, -0.41230834f, -0.39333692f, 0.11729199f, 0.15138447f, -0.16048546f, -0.09967482f, 
    0.09817538f, -0.00229589f, 0.07176251f, 0.01359984f, -0.10759204f, -0.16913058f, -0.06661268f, -0.23718415f, 
    0.12715332f, 0.03754326f, -0.03829098f, -0.02410328f, -0.00314224f, 0.06991319f, 0.09601891f, -0.02879524f, 
    -0.04059247f, -0.18055050f, -0.29005051f, -0.21864477f, -0.18442936f, 0.08090554f, -0.06333339f, -0.12934348f, 
    -0.03797001f, -0.06764287f, -0.13477363f, -0.12803169f, 0.10282017f, -0.20935303f, -0.30319813f, -0.05335767f, 
    -0.08581214f, -0.06674092f, -0.14234042f, 0.40972206f, 0.05577942f, 0.05886327f, 0.29560930f, -0.22207151f, 
    0.23452184f, 0.10022894f, 0.09823338f, -0.04532915f, 0.02398622f, 0.06287908f, 0.00637863f, 0.16695361f, 
    -0.02411153f, 0.07282832f, -0.14768755f, -0.04162213f, -0.08328859f, 0.16170204f, 0.00657319f, 0.05684242f, 
    0.27589965f, -0.10580319f, -0.07535032f, 0.08700532f, 0.01300168f, -0.06169637f, 0.04734829f, 0.08024640f, 
    -0.12393672f, -0.25588688f, -0.39925596f, -0.18815793f, 0.09956596f, -0.08451564f, 0.16176684f, 0.20129335f, 
    0.03997020f, -0.08320457f, 0.09716535f, 0.14945787f, 0.18113098f, 0.18379210f, 0.16846280f, -0.11771432f, 
    -0.04184943f, -0.09334520f, -0.02675777f, 0.06335549f, 0.05325918f, -0.02929859f, 0.14767978f, -0.02283667f, 
    -0.38538989f, -0.72500241f, -0.54964948f, -0.25171524f, 0.10234781f, -0.14409204f, -0.03714776f, 0.13477921f, 
    0.01716282f, 0.07325693f, -0.03114395f, 0.06813760f, 0.06014943f, -0.08555350f, 0.11432652f, -0.13182878f, 
    0.17217991f, -0.09542324f, -0.07574064f, 0.04565264f, 0.05907951f, -0.01941629f, -0.12080032f, 0.02378162f, 
    0.24533340f, 0.04524469f, 0.19877157f, 0.16985524f, 0.06460471f, -0.05649262f, 0.23064344f, 0.01879750f, 
    0.00422051f, 0.09104539f, 0.02634440f, -0.02057408f, 0.09783083f, -0.03396517f, -0.01883960f, 0.11833977f, 
    -0.08250555f, 0.06153581f, 0.05981708f, -0.04284035f, 0.09491523f, -0.00378820f, -0.03477903f, 0.06516260f, 
    0.02455384f, -0.07370748f, 0.18345077f, 0.14183165f, -0.01038579f, 0.06648014f, 0.02125981f, 0.07665308f, 
    0.06423973f, -0.02465058f, -0.00856196f, 0.14744852f, 0.04567328f, 0.01446260f, 0.09885829f, 0.05604247f, 
    0.04861265f, 0.06522440f, -0.10708445f, -0.06366891f, 0.04846950f, -0.01238429f, -0.10786539f, -0.02958271f, 
    0.11346418f, -0.14814763f, -0.10965288f, 0.05549870f, 0.12546860f, 0.19622701f, 0.03093288f, 0.14986189f, 
    -0.07169726f, -0.01686470f, 0.13034932f, 0.06271025f, 0.38719830f, -0.16992289f, 0.07962219f, -0.31047231f, 
    -0.09124277f, 0.09561948f, -0.15987697f, -0.02639320f, -0.02770689f, 0.18866003f, 0.05850579f, 0.04262048f, 
    0.32483345f, 0.26187572f, -0.23098876f, 0.07461127f, 0.01444129f, -0.04039060f, 0.12059906f, -0.13135390f, 
    -0.02935225f, 0.15877485f, 0.00066861f, 0.02452244f, 0.06229224f, -0.00929302f, 0.02868950f, 0.04176898f, 
    0.00929415f, -0.01963734f, -0.10283610f, -0.00253654f, -0.01624308f, -0.04284221f, -0.04877266f, 0.11967248f, 
    0.32837811f, -0.05384003f, -0.05193831f, -0.15708852f, 0.09402780f, 0.07949352f, 0.06881033f, 0.09061608f, 
    -0.00563492f, 0.14312755f, -0.08057215f, 0.00107775f, -0.16126911f, 0.00875447f, 0.05345512f, 0.07875586f, 
    -0.05622254f, -0.02255325f, -0.15784240f, 0.12858750f, 0.07946844f, 0.11206678f, 0.00734031f, 0.00644070f, 
    -0.40819386f, 0.10278145f, 0.00931780f, 0.01845858f, -0.00922805f, 0.12251911f, 0.01831313f, -0.07116780f, 
    0.02935633f, 0.00344029f, -0.05174313f, 0.06001233f, -0.12483791f, 0.14952967f, -0.00244678f, 0.06705660f, 
    -0.17988257f, 0.12128094f, -0.02961718f, -0.09175337f, 0.04125028f, -0.00906762f, 0.06087710f, -0.13437714f, 
    0.24042343f, 0.09258656f, -0.19361590f, -0.11785141f, 0.02482594f, 0.07813549f, 0.00495414f, 0.17552522f, 
    -0.05363357f, -0.08409385f, -0.01969848f, -0.07536580f, 0.17155546f, 0.11521979f, 0.12387663f, -0.01543288f, 
    0.03322207f, 0.09489221f, 0.00285702f, 0.04678717f, -0.06766499f, 0.00434742f, -0.25438783f, -0.12693043f, 
    0.11902803f, 0.09028788f, -0.08789600f, -0.08027410f, 0.07378098f, 0.08836590f, -0.01794673f, 0.05049713f, 
    -0.03474713f, -0.18551254f, -0.01318710f, -0.03795972f, 0.05264461f, 0.30292067f, -0.04625405f, 0.07822239f, 
    -0.03728676f, -0.01816085f, -0.02660956f, -0.03483249f, 0.02783405f, -0.06569760f, -0.11248028f, -0.01704013f, 
    -0.11317605f, -0.46681702f, -0.04705511f, 0.06129483f, -0.00029070f, -0.03045312f, -0.06016515f, -0.01118050f, 
    -0.03460424f, 0.11337073f, -0.14257857f, -0.08574118f, 0.00232264f, 0.02032722f, 0.03060343f, -0.07377640f, 
    -0.10047321f, 0.06159093f, -0.02168679f, 0.15059251f, 0.02472420f, 0.03121448f, -0.00962996f, -0.01704853f, 
    0.00638433f, -0.33006266f, -0.09283669f, 0.16017419f, -0.03637148f, 0.00660644f, 0.13296714f, -0.00800175f, 
    0.01559690f, -0.01416659f, 0.06329965f, -0.03541147f, -0.04509550f, -0.03585974f, 0.08195638f, 0.08626216f, 
    0.06196396f, 0.04987971f, 0.07880796f, 0.12160642f, 0.11927072f, 0.02489366f, 0.09672170f, 0.09937997f, 
    0.46251452f, -0.25016102f, -0.34291965f, -0.23068756f, 0.00853845f, 0.16518863f, -0.13443658f, -0.01065898f, 
    -0.05024813f, -0.06539827f, 0.08192946f, 0.02006529f, 0.73516691f, -0.21053004f, 0.16583553f, 0.07565229f, 
    -0.14007698f, 0.13976112f, -0.08206256f, 0.01151561f, 0.14703228f, -0.12575103f, -0.01174090f, -0.10567582f, 
    -0.24074267f, -0.18592687f, -0.32249388f, -0.07523719f, 0.08545917f, -0.02232999f, -0.09771033f, -0.09496979f, 
    0.08597248f, -0.07704058f, -0.02277480f, 0.10032062f, -0.15126272f, -0.09095524f, -0.01324402f, -0.15840326f, 
    0.10332868f, -0.04269675f, -0.06673784f, -0.04850155f, 0.00365782f, 0.01369144f, 0.09125924f, 0.00622343f, 
    0.19895799f, 0.09225053f, 0.01612029f, -0.12000106f, 0.23234791f, 0.16130331f, 0.09123769f, 0.13702290f, 
    0.07820796f, 0.12155339f, -0.00045603f, -0.03658652f, 0.31075457f, -0.38124809f, 0.21708761f, 0.10462565f, 
    0.12962295f, 0.01016362f, -0.10703966f, 0.08827982f, 0.14436638f, -0.11964161f, -0.10426769f, 0.01623386f, 
    -0.34281844f, 0.19599219f, -0.00167441f, -0.01664519f, 0.01262906f, -0.01857040f, -0.05706277f, 0.03564268f, 
    -0.01453838f, 0.05895387f, -0.20803455f, 0.01472530f, -0.03848524f, 0.06010759f, 0.17526093f, 0.22394399f, 
    -0.03197744f, 0.12364745f, -0.07933559f, 0.04043800f, -0.11249641f, 0.06321578f, 0.04723831f, 0.06434976f, 
    -0.01451800f, -0.17461745f, -0.17450811f, -0.07930433f, 0.08958794f, 0.13198633f, -0.05492896f, -0.06232487f, 
    -0.13007715f, -0.01731149f, -0.13929465f, -0.01234994f, -0.28531900f, -0.00924345f, -0.17567773f, 0.14853127f, 
    -0.12725307f, 0.00867283f, -0.01449806f, -0.00039619f, -0.00410990f, 0.02186296f, 0.09471928f, 0.05824910f, 
    -0.07038613f, 0.08500633f, 0.00328764f, 0.05531565f, 0.23630148f, 0.18562950f, 0.05102887f, -0.02867206f, 
    -0.09535426f, 0.02771964f, -0.04784302f, -0.02843877f, -0.00893498f, 0.36078146f, -0.08336852f, -0.04198964f, 
    -0.00977714f, 0.20169547f, 0.05930834f, -0.00829487f, 0.02757087f, -0.07478292f, 0.14198868f, -0.00185337f, 
    0.08445562f, -0.47254843f, 0.20490703f, 0.02297291f, -0.14197955f, -0.04890911f, -0.05358886f, -0.03294219f, 
    -0.12211043f, -0.13307343f, 0.10732160f, 0.15139066f, -0.15356813f, 0.10343968f, 0.01837769f, 0.07326341f, 
    -0.13205250f, -0.06059850f, -0.14831376f, 0.13684098f, -0.02621977f, -0.01587424f, 0.08364834f, 0.01089769f, 
    0.24732769f, 0.26662090f, 0.01890537f, 0.08937040f, -0.19219039f, -0.04084519f, 0.04849224f, -0.05515977f, 
    0.07413959f, -0.01337448f, -0.02542011f, 0.10215469f, -0.09601264f, 0.09292092f, -0.01956263f, -0.05976999f, 
    -0.11969402f, -0.11692334f, 0.08988108f, 0.03303268f, 0.00032226f, 0.06302024f, 0.03752172f, 0.07194622f, 
    0.01358271f, 0.71041477f, -0.28272799f, 0.41784763f, -0.00550194f, -0.04845566f, 0.03777311f, -0.05617520f, 
    0.03465726f, 0.07711219f, 0.00604817f, 0.01493719f, 0.18888623f, 0.21584149f, -0.05288311f, -0.04016196f, 
    0.03970286f, -0.01997538f, 0.27009693f, 0.10422611f, 0.03804085f, -0.03895627f, 0.05160321f, -0.00627080f, 
    -0.09488551f, -0.15586749f, 0.13832161f, 0.01968651f, -0.07853913f, 0.08339679f, -0.23433261f, 0.20519312f, 
    -0.08216525f, 0.06361462f, 0.18469217f, 0.15310232f, -0.12627296f, 0.11814456f, -0.11575201f, 0.01466861f, 
    -0.04514553f, 0.02063106f, -0.01579583f, 0.00382446f, 0.01935827f, 0.08812451f, 0.10727001f, -0.01900870f, 
    0.15699084f, 0.00907349f, -0.26999825f, -0.02127813f, 0.15547134f, 0.02211946f, -0.16573356f, 0.19140731f, 
    -0.22307104f, 0.13797945f, 0.03851607f, 0.05000164f, 0.22338922f, 0.02800052f, -0.15658808f, 0.15918134f, 
    -0.12629835f, -0.08283535f, 0.05714448f, 0.01863206f, -0.04314774f, -0.07376736f, -0.06024710f, -0.05214059f, 
    0.05403167f, 0.00501580f, -0.05039848f, 0.06415607f, -0.00921957f, 0.03367105f, 0.22450916f, -0.05247179f, 
    0.01436542f, -0.01426950f, 0.12714033f, -0.25880894f, -0.07746828f, -0.03234612f, 0.18575677f, -0.08586990f, 
    -0.00373385f, -0.34490117f, -0.23405217f, 0.08198238f, 0.00313572f, -0.05834527f, -0.09462682f, -0.12419840f, 
    0.28588653f, 0.17483389f, 0.08935001f, 0.20067261f, 0.07516163f, 0.04772921f, 0.15622585f, 0.17998484f, 
    -0.02165078f, -0.04010963f, 0.01625618f, -0.04517837f, 0.09238304f, 0.01131297f, -0.01649958f, -0.03758408f, 
    0.00894378f, 0.02154286f, -0.02108876f, 0.05561414f, -0.02761376f, -0.18723854f, -0.04751996f, -0.06610753f, 
    -0.06167891f, 0.01091299f, -0.06587610f, -0.01375461f, -0.05390243f, -0.07758677f, -0.02010271f, -0.13296366f, 
    -0.04047543f, 0.07867891f, 0.00587480f, 0.04439674f, 0.12573059f, 0.12190467f, 0.16475892f, -0.01744886f, 
    0.07303359f, 0.22186959f, -0.22425875f, -0.17943516f, -0.13336702f, 0.11898684f, -0.10691872f, 0.11241966f, 
    -0.16142601f, 0.10352509f, 0.26580477f, 0.27323329f, 0.18970083f, 0.00353300f, -0.00789434f, 0.03526464f, 
    0.01143300f, -0.11967822f, 0.14806105f, -0.20168330f, 0.02133944f, -0.14626156f, 0.14762592f, 0.05353348f, 
    -0.22557716f, -0.23588425f, 0.13022646f, -0.19446363f, -0.08054654f, 0.06456222f, 0.10873447f, -0.10666559f, 
    -0.00878780f, 0.08148771f, -0.00371167f, 0.22935912f, -0.00286299f, 0.08513841f, -0.01634784f, 0.05539175f, 
    -0.00413804f, -0.01937441f, 0.11102292f, 0.01454407f, -0.10933500f, -0.08114794f, -0.07634450f, -0.04995861f, 
    0.16006602f, 0.01433408f, -0.07471820f, -0.00239947f, 0.06544463f, 0.01725999f, -0.02371124f, -0.07391763f, 
    -0.17943454f, 0.00499778f, 0.19904537f, -0.02741257f, 0.10140929f, 0.15761532f, -0.24888580f, -0.05233418f, 
    -0.13994575f, 0.04866594f, -0.08182736f, -0.02733650f, -0.14861281f, 0.31018707f, 0.04214162f, -0.11899111f, 
    0.08884576f, 0.03045478f, -0.11322244f, -0.02318799f, -0.09478189f, -0.16691314f, -0.08619678f, -0.06823882f, 
    -0.49007356f, 0.02547437f, -0.28535786f, 0.08134339f, -0.12213442f, -0.06576734f, 0.09879849f, 0.00494180f, 
    0.03668366f, 0.03530176f, 0.02460057f, -0.08186461f, -0.02287868f, -0.13105197f, -0.03193105f, 0.08380260f, 
    -0.06765398f, 0.07525426f, 0.05741302f, -0.08993420f, 0.00753827f, 0.01545461f, -0.06085172f, 0.00931649f, 
    -0.15040742f, -0.08477176f, 0.33859113f, 0.08417278f, 0.12951584f, -0.07932826f, 0.06492396f, -0.02530849f, 
    0.02142536f, 0.20629838f, 0.18170673f, 0.27608803f, 0.69256842f, 0.46360737f, 0.16661412f, -0.03115798f, 
    0.05052129f, -0.09304100f, 0.01199324f, -0.02542137f, 0.12866193f, -0.04490288f, -0.05784194f, 0.12071474f, 
    0.03643377f, -0.10959839f, -0.20261730f, 0.12376325f, -0.00514033f, 0.06108043f, -0.07841845f, 0.10771658f, 
    0.04164777f, 0.04103466f, 0.11114504f, 0.22805010f, 0.04699668f, -0.05417317f, -0.05521567f, 0.00942476f, 
    -0.30345461f, 0.12589979f, 0.01277528f, 0.16579722f, 0.02106984f, -0.13165793f, -0.06789872f, -0.21371539f, 
    0.02918783f, 0.22141393f, 0.25318685f, 0.02991986f, 0.04644874f, 0.10314621f, -0.00537795f, -0.04523123f, 
    0.02592674f, 0.00166814f, -0.08438379f, -0.05570790f, -0.07300806f, -0.05800679f, -0.05306620f, 0.30542687f, 
    0.07471130f, 0.07114373f, -0.05886959f, -0.00623575f, 0.00249471f, -0.10144869f, -0.13362095f, 0.00461601f, 
    -0.03300446f, 0.32549173f, 0.24451604f, 0.05553985f, 0.07203052f, 0.07390282f, 0.11314046f, -0.08633243f, 
    -0.13831447f, -0.19743510f, -0.12164206f, -0.19817479f, -0.31066152f, -0.12820299f, 0.08630435f, 0.16547400f, 
    -0.14367807f, 0.00164928f, -0.06331876f, 0.10550697f, -0.00335118f, -0.15993132f, -0.04692033f, -0.03850140f, 
    0.61544377f, 0.01101529f, -0.04851077f, -0.21393970f, 0.05275368f, 0.06736730f, 0.03987046f, -0.15413903f, 
    -0.00534071f, -0.02938204f, 0.03196415f, -0.09149589f, -0.11000008f, -0.01552945f, -0.06155651f, 0.03506809f, 
    0.14768389f, 0.05305867f, 0.05061080f, 0.10141174f, -0.06654536f, -0.17251346f, -0.12751310f, -0.14911969f, 
    -0.20707680f, -0.16423084f, -0.02589508f, -0.03747489f, 0.09553347f, 0.12483278f, 0.08984490f, 0.03147978f, 
    -0.09823340f, 0.01255755f, -0.04198505f, -0.08469827f, -0.01211137f, -0.14964044f, -0.14033885f, 0.13265660f, 
    0.15836790f, 0.05532586f, 0.12325115f, 0.10285535f, -0.08323570f, -0.02876413f, 0.04690953f, 0.10770582f, 
    -0.21765250f, 0.08359203f, 0.04444361f, 0.18482403f, 0.13588358f, -0.04578672f, 0.06373053f, 0.07310214f, 
    -0.04224492f, 0.00875539f, -0.02907015f, -0.12056168f, -0.21143541f, -0.09644634f, 0.40674677f, 0.37641621f, 
    0.26730078f, -0.10407221f, 0.18775409f, -0.22345880f, 0.03161255f, 0.09221715f, 0.13704774f, 0.14030439f, 
    0.10944727f, -0.07289623f, -0.02403563f, -0.26379320f, -0.08403117f, 0.13313347f, 0.10753522f, 0.16203550f, 
    -0.04827412f, -0.09967172f, 0.04847424f, -0.06541750f, 0.12068053f, -0.08658209f, -0.17251457f, -0.08841894f, 
    0.05330722f, 0.06016852f, 0.12908174f, 0.02546961f, 0.07333847f, -0.07830043f, 0.00537238f, -0.15449420f, 
    -0.24884298f, 0.12030821f, 0.00530236f, -0.01101293f, -0.09229265f, -0.14655866f, 0.07229035f, -0.12213678f, 
    0.17127438f, -0.13876830f, -0.13211015f, 0.06962153f, -0.12493332f, 0.39526597f, -0.26981422f, -0.27944332f, 
    0.01356520f, 0.10023063f, 0.15788341f, 0.06294737f, -0.03780418f, 0.10475969f, 0.07697295f, 0.02873946f, 
    0.21570002f, 0.00496905f, 0.01624093f, -0.07127735f, 0.02867830f, -0.09451136f, -0.06228362f, -0.02178898f, 
    0.15642019f, -0.12807339f, 0.01467530f, -0.00938334f, 0.13122368f, -0.20053977f, -0.08981459f, 0.11152043f, 
    0.05697162f, -0.03711542f, 0.12174349f, -0.10089551f, 0.01490900f, 0.01598865f, 0.10583944f, 0.12675221f, 
    -0.28954828f, 0.09391048f, 0.09915879f, 0.04737429f, 0.05298170f, -0.03242111f, -0.00755235f, -0.20433357f, 
    0.13328256f, 0.23932254f, 0.09127513f, -0.01872264f, 0.00398471f, -0.12308230f, 0.21876192f, 0.06511745f, 
    -0.00882951f, -0.14829543f, -0.10129178f, -0.02791812f, 0.01777363f, 0.02307781f, 0.07900944f, 0.02444908f, 
    -0.11045236f, -0.01600752f, 0.13046329f, -0.10683177f, 0.01055964f, 0.15017600f, 0.02234886f, 0.11399738f, 
    0.20335875f, 0.18549317f, -0.00567905f, 0.08236559f, -0.00002568f, -0.32900482f, -0.01128534f, 0.09143700f, 
    0.16037476f, -0.00827949f, 0.07436541f, 0.04606961f, -0.03557329f, 0.08793410f, 0.12012776f, 0.09555297f, 
    -0.24381271f, 0.33350372f, -0.04835749f, -0.22412896f, -0.04345564f, 0.01077039f, 0.06788714f, 0.11093487f, 
    0.04265999f, -0.08264485f, -0.11044375f, 0.13544610f, 0.01391628f, -0.05536697f, 0.03755239f, 0.01938462f, 
    -0.05420680f, -0.05019639f, 0.01132102f, -0.00472281f, 0.03456415f, -0.01392768f, 0.05694619f, 0.00515124f, 
    -0.05466256f, 0.04799678f, -0.23408802f, -0.01869969f, 0.04398716f, 0.01068963f, -0.05498834f, -0.08015546f, 
    0.03729676f, -0.00876682f, 0.00324043f, 0.01717572f, 0.07356388f, 0.01824319f, 0.02609655f, -0.02359145f, 
    -0.10771641f, 0.00481338f, -0.10624019f, -0.10626163f, -0.03119669f, -0.00861249f, 0.04765670f, -0.14062715f, 
    0.20308046f, -0.27326927f, 0.46625578f, -0.41415080f, -0.04792482f, 0.11233637f, 0.25954595f, 0.12626983f, 
    0.27688923f, 0.03407041f, 0.04460097f, -0.05368146f, 0.03351086f, -0.22938979f, 0.36376661f, 0.05865122f, 
    -0.06794214f, -0.18151332f, -0.06660311f, 0.17782202f, 0.33372864f, 0.16094288f, -0.04064213f, -0.04190020f, 
    0.18256195f, 0.14505655f, 0.06030955f, 0.14982648f, -0.03968683f, 0.06210013f, -0.13503860f, 0.05040554f, 
    0.01136978f, -0.01417160f, -0.00531455f, 0.06695604f, -0.02251975f, 0.02519733f, 0.07735296f, -0.12950829f, 
    -0.05698405f, 0.00018526f, -0.09635562f, -0.04470385f, -0.01128560f, -0.00524947f, 0.00632116f, 0.07826170f, 
    -0.05113471f, 0.01268842f, 0.04066994f, -0.04446046f, -0.02962521f, 0.02104624f, 0.04902641f, 0.02188118f, 
    -0.06988633f, 0.04934164f, -0.02487416f, 0.03512026f, -0.06736643f, 0.04002606f, 0.06212213f, 0.06591136f, 
    -0.01841768f, 0.04882438f, -0.08018947f, -0.04355784f, -0.06910521f, 0.00533056f, -0.07396723f, -0.00203417f, 
    0.05742779f, 0.03616675f, -0.00703744f, -0.07692785f, 0.04197509f, -0.08404583f, -0.05405635f, 0.05958924f, 
    -0.03244630f, 0.04518020f, -0.03350229f, -0.04538315f, -0.06093293f, -0.06209245f, 0.06145298f, -0.00874683f, 
    -0.05848901f, -0.04043556f, 0.02448159f, -0.02246085f, 0.04365691f, -0.06548882f, -0.02552903f, -0.07480243f, 
    -0.02427933f, -0.01796597f, 0.05562218f, -0.02286715f, 0.01749942f, -0.07399248f, 0.01188284f, -0.00105007f, 
    -0.02557524f, -0.04803840f, -0.07582995f, 0.04267344f, 0.02132214f, -0.08262817f, 0.01121827f, 0.00669945f, 
    -0.03775510f, 0.03581596f, -0.07592665f, 0.06187659f, 0.05731222f, 0.00876030f, 0.01522364f, -0.01115702f, 
    0.01463413f, -0.01579319f, 0.03702618f, -0.04584096f, -0.02142312f, 0.02384971f, 0.05117729f, -0.00465984f, 
    0.00468860f, 0.05249201f, -0.00202760f, -0.05471397f, 0.00142026f, -0.05064233f, -0.02116321f, 0.00954300f, 
    -0.01558718f, 0.00046447f, -0.02424507f, 0.05606217f, 0.02167363f, -0.05666101f, -0.04308723f, -0.03644683f, 
    0.04334586f, 0.01128266f, -0.01151702f, -0.03600648f, 0.00499470f, -0.05019246f, -0.03545225f, -0.04764311f, 
    -0.05326885f, 0.04342326f, -0.04092034f, 0.02917271f, -0.00598958f, 0.02438981f, -0.05342002f, -0.01117816f, 
    -0.00705304f, 0.04546600f, -0.02360302f, -0.01163885f, -0.00234149f, -0.01866957f, 0.00907802f, 0.03164742f, 
    0.03021214f, -0.07204049f, -0.00029095f, -0.00337870f, -0.00438581f, -0.02036549f, -0.04510299f, -0.01707030f, 
    0.06301291f, -0.03574856f, 0.03717287f, -0.01608484f, -0.06617530f, 0.02745960f, -0.02796846f, 0.04081256f, 
    -0.03178641f, 0.05560746f, -0.01374093f, -0.08599076f, 0.00765836f, 0.04464183f, -0.06657006f, -0.05493372f, 
    -0.02092014f, -0.06458405f, -0.03601413f, -0.05132172f, -0.03813594f, 0.03017922f, -0.01308648f, 0.00313293f, 
    -0.05430717f, -0.03406907f, -0.04850115f, -0.00891878f, 0.02953591f, -0.07787313f, 0.02943657f, -0.06766129f, 
    -0.05258189f, -0.07176818f, 0.01566991f, -0.06387969f, -0.05036141f, -0.08003761f, 0.05088161f, 0.06113135f, 
    -0.02811065f, -0.01899347f, -0.02717978f, 0.00481479f, 0.04504761f, 0.02363074f, -0.04640389f, 0.04986291f, 
    -0.04029474f, 0.02484514f, 0.00531050f, 0.03381694f, 0.03758178f, -0.06867213f, -0.02232296f, -0.04170430f, 
    0.01602974f, 0.00347668f, 0.03921989f, 0.02186794f, -0.08189946f, 0.02959548f, -0.04898614f, 0.04735589f, 
    -0.30844450f, -0.32430261f, -0.26306376f, -0.10430209f, -0.11667053f, -0.19461399f, -0.18584023f, -0.18760908f, 
    -0.06272364f, -0.07774201f, -0.04840615f, -0.02286116f, -0.15822716f, -0.25630870f, -0.43410948f, -0.37779373f, 
    -0.19999748f, 0.01347913f, -0.15109967f, 0.18089080f, 0.25825217f, 0.01093487f, -0.06957801f, -0.17522170f, 
    0.22781777f, -0.12741472f, 0.15829670f, 0.04516723f, 0.04527788f, 0.00068091f, 0.03060707f, 0.18755610f, 
    0.21089377f, -0.04174452f, 0.04852098f, 0.04582550f, 0.06044262f, 0.04209059f, 0.13797235f, 0.15218663f, 
    -0.07573247f, -0.03434922f, 0.03824958f, 0.07483994f, -0.07454329f, -0.05803788f, -0.02193954f, -0.01760725f, 
    -0.11940629f, -0.24267378f, -0.18432966f, 0.05841057f, 0.01467244f, 0.05898297f, 0.10736778f, 0.10040575f, 
    -0.04279713f, -0.16305074f, 0.04053109f, -0.00120377f, 0.20623617f, 0.11141518f, 0.09001569f, 0.03248958f, 
    0.00420009f, 0.09766240f, 0.00040333f, 0.04952542f, 0.00241837f, -0.01405356f, -0.08082765f, -0.08347304f, 
    -0.62382299f, -0.41074648f, -0.47872880f, -0.41881898f, 0.07570596f, 0.16001509f, -0.03704285f, 0.04186178f, 
    -0.07724546f, -0.00962174f, -0.04968725f, 0.02703306f, -0.24650396f, -0.01730702f, -0.00236315f, -0.22106968f, 
    0.23612250f, 0.17933062f, -0.03220166f, 0.08848055f, -0.06077958f, -0.12158024f, 0.04802366f, 0.01068426f, 
    0.21290922f, -0.06821819f, 0.11438756f, -0.02867903f, 0.01816540f, -0.05256952f, 0.26227099f, 0.14873716f, 
    -0.10872110f, -0.12309910f, 0.00608692f, 0.09844021f, 0.04924977f, 0.05382427f, 0.03469429f, 0.08408102f, 
    -0.03710610f, 0.13484164f, -0.01283007f, 0.00014220f, -0.03651379f, 0.02865162f, -0.04696842f, -0.07697401f, 
    0.25220674f, 0.00480461f, 0.18245240f, 0.11957991f, -0.10445636f, -0.01155359f, 0.09581674f, -0.10348303f, 
    0.13576478f, 0.15160289f, 0.07843081f, 0.07180496f, 0.14173746f, 0.11291019f, 0.07709230f, 0.22951315f, 
    -0.04386767f, 0.03204431f, 0.00418117f, 0.01134039f, 0.10414586f, -0.02996528f, -0.00220220f, -0.03549265f, 
    0.02019118f, 0.06718584f, -0.07412314f, -0.34485430f, 0.02493159f, 0.22747856f, 0.02737797f, 0.11186375f, 
    0.01077738f, 0.23337665f, 0.05195603f, -0.03854412f, 0.08986388f, -0.20382956f, 0.02568920f, -0.00900735f, 
    0.01682695f, 0.12885256f, 0.01609445f, 0.02579901f, 0.05835501f, -0.02572451f, 0.12045469f, -0.02597714f, 
    0.21634185f, 0.06349061f, 0.12475502f, -0.04574279f, 0.01393174f, -0.05430668f, -0.08754613f, -0.04512525f, 
    -0.01980936f, 0.04594186f, 0.03686702f, -0.00176498f, 0.19626510f, 0.12553644f, 0.10807132f, -0.00483181f, 
    -0.03979325f, -0.07505802f, -0.17741044f, 0.02921626f, -0.02914402f, 0.04377612f, -0.02603480f, -0.07045451f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.02922967f, 0.06546544f, 0.14884189f, -0.10412245f, 0.05440907f, -0.04751809f, 0.02193762f, 0.11980721f, 
    0.10732769f, 0.00985813f, 0.18103221f, 0.03766782f, -0.06694873f, -0.00741644f, -0.07630752f, 0.14118370f, 
    0.06592300f, 0.16426684f, 0.06638245f, -0.02921562f, 0.18471448f, 0.07113746f, 0.10510041f, 0.15480316f, 
    0.12299512f, 0.00463794f, 0.06079148f, 0.19081451f, 0.10791973f, 0.13182904f, -0.10057114f, 0.05252505f, 
    -0.08703307f, -0.01466179f, -0.03174049f, 0.18119594f, 0.04904176f, 0.02022577f, -0.20428556f, -0.01172757f, 
    -0.02742488f, -0.02544818f, 0.15659028f, 0.04051306f, -0.13998286f, 0.05158249f, 0.01296017f, 0.00465280f, 
    -0.08885191f, -0.05308486f, 0.14653385f, 0.03817663f, 0.05179385f, 0.08588590f, -0.07646524f, -0.13974842f, 
    -0.04747329f, 0.16550441f, -0.06634563f, 0.03737225f, -0.09921356f, 0.12791829f, -0.04271147f, 0.18902379f, 
    -0.06088942f, -0.04989344f, -0.11737689f, -0.08976837f, -0.05902537f, 0.08975508f, 0.07111634f, 0.18669517f, 
    -0.09977440f, 0.11511053f, -0.06338757f, 0.09009778f, -0.02828626f, 0.06641300f, 0.09296934f, 0.06135250f, 
    0.06694255f, -0.01273644f, 0.00299272f, -0.01894965f, 0.00095938f, -0.02723298f, -0.01325480f, 0.02809860f, 
    0.06455347f, -0.03039709f, -0.02627133f, 0.15836228f, 0.16043299f, 0.09661420f, -0.10675764f, 0.20289262f, 
    -0.00006499f, -0.01207928f, 0.04959859f, 0.05041577f, 0.12410609f, 0.18863474f, -0.05716480f, -0.07075407f, 
    0.06833882f, 0.00772226f, 0.05542699f, 0.01676139f, -0.03293569f, 0.12338454f, 0.05407181f, 0.20757379f, 
    0.14598055f, 0.03484949f, 0.22529598f, 0.03575323f, 0.05247158f, 0.12485898f, 0.10258371f, -0.10623701f, 
    0.01099145f, 0.01067022f, 0.12342410f, -0.17690402f, 0.19061923f, 0.23420255f, -0.05504034f, 0.13232781f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.16073741f, 0.04481979f, -0.35660806f, -0.46336383f, -0.00252490f, -0.01786417f, -0.24942377f, 0.04055164f, 
    0.16688584f, 0.14071280f, -0.32330388f, -0.00260053f, 0.03706753f, 0.06518659f, -0.02982645f, -0.28625107f, 
    -0.04464372f, -0.47394043f, -0.06312156f, -0.01954887f, -0.09799992f, 0.05504841f, 0.07328604f, -0.12928253f, 
    -0.44470766f, 0.18877007f, 0.06160010f, -0.08014618f, 0.22557934f, 0.11167055f, 0.17038216f, -0.08636838f, 
    0.20482893f, -0.10074481f, -0.19140974f, -0.18048079f, -0.01700693f, -0.00319681f, 0.17613877f, 0.02636119f, 
    0.06923445f, 0.10079998f, -0.03560368f, -0.01485987f, 0.08380309f, 0.04959314f, -0.03472805f, -0.11828792f, 
    -0.01588785f, -0.04585927f, 0.01626124f, 0.04411040f, -0.37134004f, -0.32479492f, 0.03119243f, 0.33096850f, 
    -0.05538242f, -0.32365727f, -0.06741972f, -0.08925850f, -0.03595376f, -0.29468986f, 0.05804382f, -0.28165933f, 
    0.07320126f, 0.08567636f, 0.11275996f, 0.20898044f, 0.01124696f, 0.17484240f, -0.73985672f, -0.43978772f, 
    0.17248203f, -0.05151533f, -0.01175279f, -0.37431586f, 0.05331177f, 0.13441028f, 0.14987428f, -0.04098144f, 
    -0.09026382f, -0.04089021f, -0.15258990f, 0.22380736f, 0.20894121f, 0.07739295f, 0.06451660f, -0.18659602f, 
    -0.16036595f, 0.08185005f, -0.11248735f, 0.11026593f, -0.10723908f, -0.53887910f, 0.21414132f, 0.03185277f, 
    -0.08168515f, 0.31112051f, 0.14060433f, 0.07944026f, 0.00336942f, 0.03546019f, 0.05148843f, 0.11951635f, 
    -0.08698857f, -0.00708070f, -0.37453315f, 0.15699495f, -0.05156500f, -0.28483257f, -0.06791216f, 0.01543382f, 
    -0.06810635f, -0.24943024f, -0.29131711f, 0.06560554f, -0.32354158f, -0.21932410f, -0.26011926f, 0.18099222f, 
    0.02466550f, 0.23787087f, 0.16737460f, 0.14206059f, 0.03763838f, -0.39919171f, 0.08659416f, -0.18650059f, 
    -0.11764733f, -0.05676246f, -0.08146016f, -0.45906925f, -0.18714492f, 0.06343856f, -0.00196815f, 0.04758222f, 
    0.02954481f, 0.07937247f, 0.02023973f, 0.04650611f, -0.08161091f, -0.02052632f, -0.02349077f, 0.25242013f, 
    0.14073396f, -0.09019802f, -0.48152694f, 0.00483932f, 0.17428567f, 0.00035882f, 0.19379228f, 0.13542782f, 
    -0.16535081f, -0.04336119f, 0.14905889f, -0.21471378f, -0.15531452f, 0.11740402f, 0.33597121f, 0.04834794f, 
    0.04272223f, -0.02334659f, -0.07413344f, 0.14579453f, -0.13148446f, -0.07531317f, 0.04036991f, 0.08647724f, 
    -0.08060648f, -0.05098029f, -0.10195293f, -0.00381410f, 0.14075577f, 0.04409697f, 0.05316345f, 0.02884639f, 
    0.30872461f, -0.04898693f, 0.16236469f, 0.00500253f, 0.05364299f, 0.07623035f, -0.04944182f, -0.79421556f, 
    -0.01163900f, 0.13715523f, -0.03566349f, -0.06416853f, 0.04267349f, 0.00288220f, -0.06166824f, 0.02170200f, 
    0.06791246f, 0.22656794f, 0.06308207f, 0.34899017f, 0.06605481f, 0.03663033f, -0.23000012f, -0.22600789f, 
    -0.09103288f, 0.19757320f, -0.01829467f, 0.32368577f, -0.00995949f, -0.05034858f, -0.05901726f, -0.09163559f, 
    -0.11329287f, 0.08773169f, -0.07189675f, -0.33189410f, -0.19788037f, -0.05454240f, 0.10231123f, -0.16665223f, 
    -0.16921866f, 0.19181679f, -0.28584021f, 0.13693127f, 0.18917221f, -0.17242140f, -0.07955441f, -0.10024406f, 
    -0.15742794f, 0.19671169f, -0.28190258f, -0.08547658f, 0.03952687f, 0.10920086f, -0.04418222f, -0.22450560f, 
    0.14231043f, -0.04929077f, -0.01918101f, -0.33695057f, -0.07742887f, -0.28081781f, 0.01981484f, 0.14000922f, 
    0.11737151f, -0.19432165f, 0.06185487f, -0.07147843f, -0.08090978f, 0.15370673f, 0.38093305f, 0.15011762f, 
    0.04802553f, -0.01300028f, 0.11209067f, -0.36311999f, 0.00117262f, 0.05955478f, -0.00582893f, 0.17305437f, 
    0.12365902f, 0.00008255f, 0.12185952f, 0.04872255f, -0.13800241f, 0.01236404f, 0.04028498f, 0.09848268f, 
    0.17181654f, -0.07981604f, -0.08749086f, -0.09227478f, -0.06092789f, -0.01581451f, -0.02830487f, 0.10593869f, 
    -0.20075889f, 0.16591051f, 0.26692319f, 0.03798713f, 0.31686455f, 0.32674935f, 0.31296626f, -0.08402439f, 
    0.02893096f, -0.48532426f, -0.16522716f, 0.34796453f, -0.23923117f, 0.07497942f, -0.54996175f, -0.08119908f, 
    -0.89788824f, 0.04909604f, -0.18766893f, -0.01069965f, -0.01001196f, -0.06368265f, -0.12442277f, 0.03033357f, 
    -0.00119213f, 0.16301030f, 0.20978330f, 0.03783222f, -0.48284051f, 0.02827949f, 0.02353884f, 0.05117081f, 
    -0.38160869f, -0.08888260f, -0.06881741f, -0.06764857f, 0.07479633f, 0.21035145f, -0.10586254f, -0.42273510f, 
    -0.02742350f, -0.07826985f, -0.44559070f, 0.08034649f, -0.14400762f, 0.07387365f, -0.44142231f, 0.03017799f, 
    -0.03874292f, -0.01673127f, -0.27828696f, -0.12300924f, -0.01710178f, -0.00994537f, 0.12712240f, 0.06396631f, 
    -0.08933971f, -0.22832513f, 0.05960028f, 0.45465609f, 0.02979087f, 0.13603170f, 0.51494920f, -0.02247907f, 
    0.31445011f, -0.07187112f, 0.08260907f, -0.05306445f, 0.26095873f, -0.04215533f, 0.25422332f, 0.11464291f, 
    -0.02136587f, -0.35221300f, -0.19377548f, 0.02450232f, 0.17052387f, 0.04730032f, -0.10694789f, 0.40431932f, 
    -0.27308345f, 0.05678507f, -0.40466166f, -0.20194134f, 0.13344063f, 0.24058568f, 0.06867418f, -0.13475743f, 
    -0.28940329f, 0.01707530f, -0.14673118f, 0.17023355f, 0.03979429f, 0.10960103f, 0.01818410f, 0.14786293f, 
    0.02491647f, -0.12711626f, 0.12631905f, 0.05176275f, 0.03271326f, 0.01209571f, -0.30075261f, 0.06792120f, 
    -0.34500882f, 0.12402231f, 0.06692938f, -0.09732520f, 0.31793520f, 0.05036955f, 0.01571774f, -0.22619715f, 
    0.27806261f, -0.08461349f, -0.10743679f, 0.13711259f, -0.00184358f, 0.11130155f, 0.40379670f, -0.24884385f, 
    0.13618526f, -0.01302026f, -0.32784668f, -0.05042131f, -0.24658653f, 0.02996221f, -0.04817360f, -0.24018928f, 
    -0.15232505f, -0.12678470f, -0.05534153f, -0.07848620f, 0.01532781f, 0.04766258f, -0.05358320f, -0.40007934f, 
    0.11492024f, -0.13864490f, 0.01189581f, -0.12269197f, 0.12254811f, -0.04755865f, 0.04290958f, 0.07643173f, 
    -0.00305005f, -0.05981046f, 0.13403291f, -0.31689399f, -0.12841502f, -0.06641964f, 0.10803911f, 0.11812614f, 
    -0.04778483f, -0.11949269f, -0.32930592f, 0.03157531f, 0.12508562f, -0.23111367f, -0.01144281f, 0.28658143f, 
    -0.23456123f, -0.03603033f, -0.02437788f, -0.08127882f, 0.34428343f, 0.14551802f, 0.09218458f, 0.18502627f, 
    0.07061808f, -0.27847660f, -0.00139650f, -0.00229937f, 0.24951172f, -0.10141605f, -0.01376078f, -0.15786903f, 
    0.07121373f, -0.10172705f, 0.24613708f, 0.04724181f, 0.23312610f, -0.41214004f, 0.29927966f, 0.24925959f, 
    -0.09854118f, -0.03091958f, -0.06172578f, 0.28629011f, -0.03264511f, -0.75764340f, 0.17969126f, 0.01454917f, 
    0.14276838f, 0.02639538f, 0.05198255f, 0.15677425f, 0.09373580f, -0.04686816f, 0.10332735f, -0.28675866f, 
    0.11410473f, 0.10692092f, 0.22168417f, 0.01207221f, -0.33655721f, 0.14722832f, 0.07138567f, 0.05532733f, 
    -0.30461988f, -0.19826928f, -0.29413688f, -0.16031462f, -0.68901283f, -0.52921492f, 0.12646231f, 0.19374073f, 
    -0.03526673f, 0.14812319f, -0.14235906f, -0.00520846f, -0.01547336f, 0.12578574f, -0.27481335f, -0.04070297f, 
    -0.16864714f, 0.07785828f, -0.38509610f, -0.02062421f, 0.07189751f, -0.44399264f, -0.04184047f, -0.11962502f, 
    -0.14456370f, -0.14379214f, 0.10908078f, 0.19069259f, -0.02029128f, -0.31693298f, 0.06895276f, -0.31503156f, 
    0.05692491f, 0.02693335f, -0.09394790f, 0.20166579f, -0.00013776f, 0.02849098f, -0.38285857f, 0.10233497f, 
    -0.07671052f, 0.06604828f, -0.18944298f, -0.06437302f, 0.26189423f, 0.07499619f, 0.04482570f, 0.17090711f, 
    -0.02749477f, -0.09067205f, 0.29035404f, -0.07617957f, -0.44412205f, 0.16989569f, 0.11986603f, 0.07971543f, 
    -0.09142594f, -0.03816456f, 0.09615585f, -0.22847539f, -0.09418368f, -0.08095241f, 0.05744958f, -0.08629844f, 
    0.08793694f, 0.07389279f, 0.39780125f, -0.11949898f, 0.08920898f, -0.08235429f, 0.06304052f, -0.03688337f, 
    -0.08949649f, -0.09359715f, -0.00954818f, 0.00395054f, 0.15615484f, 0.00993807f, -0.05862968f, 0.01007641f, 
    0.13487226f, -0.00047375f, -0.22886662f, -0.02142147f, 0.03927092f, -0.07693349f, -0.03696937f, -0.08010022f, 
    0.06505357f, 0.00189581f, 0.28750578f, -0.07821137f, 0.27717975f, -0.07297972f, 0.04199765f, 0.01522581f, 
    0.06484183f, -0.06347945f, -0.01142032f, -0.11269284f, -0.38107023f, -0.31592673f, 0.05470033f, -0.15885414f, 
    0.14821872f, -0.10081106f, 0.02398431f, -0.35921326f, -0.01923275f, -0.13599409f, 0.08527956f, 0.02520026f, 
    0.03607364f, -0.04954324f, -0.12501717f, -0.02701228f, -0.13671508f, -0.03684154f, 0.00753518f, 0.07447482f, 
    0.26089874f, -0.08135667f, 0.01653329f, 0.02761444f, -0.11067998f, -0.19614154f, 0.06939571f, 0.15654911f, 
    -0.23328851f, 0.01029237f, -0.08658256f, 0.09246789f, 0.04485779f, 0.10059714f, -0.00967759f, -0.00744864f, 
    -0.13715467f, 0.08741707f, -0.04480882f, 0.09593154f, -0.06581653f, -0.04753776f, -0.16213064f, -0.57948619f, 
    -0.26575962f, -0.05166013f, 0.02471482f, -0.02385140f, -0.19028254f, -0.01050905f, -0.05144608f, 0.00404853f, 
    0.17451248f, -0.00336285f, -0.26900378f, 0.07033186f, 0.09464230f, -0.08322266f, 0.00152629f, 0.11728213f, 
    -0.05934513f, -0.06814528f, -0.08362485f, 0.12466787f, 0.15669453f, -0.15700555f, -0.33101243f, 0.09929719f, 
    -0.01175745f, 0.12865792f, 0.08827542f, -0.01927975f, -0.11600854f, -0.01106202f, -0.01643397f, -0.14731188f, 
    0.20688710f, 0.16330037f, -0.26586923f, 0.05405661f, -0.07149494f, -0.10318510f, -0.11901506f, -0.21778266f, 
    -0.20570642f, 0.31071982f, -0.19290294f, 0.01993692f, 0.30467936f, 0.08637989f, -0.06545831f, -0.04736014f, 
    0.14148545f, -0.02105976f, -0.40541685f, 0.09874862f, 0.11405580f, 0.00335783f, 0.08322684f, -0.14334965f, 
    0.04289128f, -0.14174812f, 0.06654556f, -0.07983103f, 0.08621150f, -0.07210523f, -0.05243272f, -0.03430629f, 
    -0.03669790f, 0.04544038f, 0.12371626f, 0.00288819f, -0.22320276f, -0.18662749f, 0.06324714f, -0.38738891f, 
    0.03815908f, 0.12516244f, -0.03781649f, -0.07296354f, -0.35259947f, -0.07215036f, 0.19886383f, -0.00312927f, 
    -0.00017781f, -0.02771348f, 0.08401787f, -0.28421777f, -0.11470337f, -0.09567238f, -0.14565046f, 0.04232911f, 
    -0.11441647f, 0.02305909f, -0.04579655f, -0.40046862f, 0.09116147f, 0.09272376f, -0.21713223f, 0.00924974f, 
    0.05269090f, 0.01222753f, 0.05691433f, 0.02435489f, -0.18683358f, -0.06817836f, -0.04221930f, 0.13492616f, 
    -0.05431648f, -0.02232222f, -0.11790779f, 0.12433422f, 0.02654276f, 0.04721143f, -0.38615963f, 0.16865188f, 
    0.28894001f, -0.23479046f, 0.37841636f, 0.26948273f, -0.08338194f, -0.26793566f, -0.01206016f, -0.15128101f, 
    0.05208959f, 0.06506097f, 0.21324925f, 0.15616713f, 0.03144792f, -0.12758824f, -0.06720901f, 0.03674944f, 
    0.07537603f, 0.03652806f, 0.01601194f, -0.02436892f, -0.14209539f, 0.28775275f, -0.59678930f, 0.01335435f, 
    -0.03298101f, -0.12792353f, 0.00062160f, 0.13598216f, 0.02588763f, 0.10355019f, 0.01103414f, -0.00595367f, 
    0.14557403f, -0.08807506f, 0.07397847f, -0.10655928f, 0.00950489f, -0.31257078f, -0.14938481f, -0.10725711f, 
    -0.62736809f, -0.08094922f, 0.21232784f, 0.06557318f, 0.00664581f, 0.02655543f, 0.01699062f, 0.09238119f, 
    -0.22261894f, 0.27678022f, -0.15016975f, 0.03449202f, 0.14741628f, -0.00007173f, -0.62292892f, -0.19603357f, 
    0.25882798f, -0.30601272f, -0.18911637f, 0.21606103f, -0.49619687f, 0.06049948f, -0.18520956f, -0.07517281f, 
    -0.62697160f, -0.05474187f, 0.01791781f, 0.04043452f, -0.01547686f, -0.05133430f, 0.05529867f, -0.50540942f, 
    -0.09228853f, 0.21029362f, 0.06316027f, -0.04993035f, -0.38684490f, 0.14049020f, -0.07494128f, -0.26786453f, 
    -0.18303242f, -0.05465950f, -0.24439856f, 0.07132798f, -0.00355779f, -0.23776376f, -0.13378108f, 0.02434117f, 
    -0.01107597f, 0.07471464f, -0.47406721f, -0.08609741f, -0.13649943f, -0.06686867f, -0.81537050f, 0.00330037f, 
    0.00561704f, -0.02492218f, -0.17459995f, -0.41441610f, -0.56626463f, 0.15165783f, 0.11502842f, 0.04197637f, 
    -0.28694460f, 0.16906248f, 0.03696230f, 0.19142888f, 0.06663110f, -0.30130777f, 0.37462032f, 0.02432593f, 
    -0.39643243f, 0.01036939f, -0.29358914f, -0.69723904f, -0.14234534f, -0.06488923f, -0.32643825f, 0.04680083f, 
    0.05681535f, 0.21236336f, 0.21207649f, -0.52525562f, -0.20965227f, 0.15334637f, -0.23994797f, 0.16627434f, 
    -0.09918910f, 0.08000737f, 0.25680566f, -0.82537395f, 0.06451828f, 0.23522344f, 0.07985960f, 0.13078198f, 
    -0.27210039f, -0.45670509f, 0.14130743f, -0.13410455f, -0.00550218f, 0.64568090f, 0.05741669f, -0.26118484f, 
    -0.19435991f, 0.19449410f, 0.21366900f, -0.02443190f, 0.16359448f, -0.38895825f, 0.39260492f, -0.41407892f, 
    0.14107101f, -0.13283867f, 0.01150240f, -0.06389945f, 0.17625824f, 0.00562121f, 0.03918153f, -0.06066843f, 
    -0.08152871f, -0.03546532f, 0.17062742f, 0.27925709f, -0.01598482f, 0.14295709f, -0.26100200f, 0.02320371f, 
    -0.26814699f, 0.07077845f, -0.16154855f, 0.01143793f, 0.16104308f, -0.05612409f, 0.02548502f, -0.16543342f, 
    -0.18633328f, 0.09273355f, 0.26698899f, -0.05022925f, -0.25657547f, -0.49687025f, -0.32292578f, -0.11030097f, 
    -0.00662001f, 0.05382368f, 0.04619547f, -0.02002238f, -0.50557089f, -0.11001837f, -0.17006564f, 0.06705932f, 
    -0.01080306f, -0.00927945f, 0.04163164f, -0.13263163f, -0.18551333f, -0.07699776f, 0.14826573f, -0.19976088f, 
    0.02487452f, -0.37782663f, -0.26485300f, -0.07201915f, -0.17411557f, -0.16647463f, -0.05651414f, -0.06722306f, 
    -0.08104562f, -0.01657721f, -0.22681487f, -0.05700717f, 0.13053961f, 0.12159260f, -0.16633880f, 0.21976483f, 
    -0.04071435f, -0.08312009f, -0.35386750f, 0.06668400f, -0.13412882f, -0.01301854f, -0.45254719f, -0.06635617f, 
    -0.07779459f, -0.30384457f, 0.15675989f, 0.12039757f, 0.14173770f, -0.27055028f, 0.26121223f, -0.13896990f, 
    -0.00489326f, -0.12136830f, -0.01854222f, -0.38059068f, -0.06749271f, 0.27827173f, -0.44260055f, -0.05658029f, 
    0.45847830f, 0.08563055f, 0.23837537f, 0.28268886f, 0.34572273f, -0.08443521f, -0.05252424f, 0.18853030f, 
    -0.57143420f, -0.14773272f, -0.40688211f, -0.26826602f, 0.03880134f, 0.14312543f, 0.18614545f, -0.53128105f, 
    0.18469770f, -0.30231363f, -0.17452553f, 0.20858675f, 0.01584048f, 0.03959623f, -0.00441387f, -0.27905762f, 
    -0.23864351f, 0.21535583f, 0.05164276f, 0.20586409f, -0.00523746f, -0.30297324f, 0.09599983f, -0.05896708f, 
    -0.08899417f, 0.09387476f, -0.05287118f, -0.03847746f, 0.01462849f, -0.08891901f, -0.19648643f, -0.23455250f, 
    0.04929204f, 0.04968171f, -0.07144839f, 0.07857384f, -0.39399496f, 0.09819517f, 0.01915715f, 0.07712694f, 
    -0.06480207f, -0.01846237f, -0.18643409f, -0.51208371f, 0.09530240f, 0.13444477f, 0.24900138f, -0.17500813f, 
    0.06775776f, -0.17773154f, 0.05816684f, 0.06359036f, -0.24806869f, -0.07132281f, -0.01715759f, -0.16975373f, 
    -0.05108329f, -0.01356615f, -0.18513276f, -0.03317339f, -0.00287102f, -0.78867501f, -0.39337650f, 0.24746203f, 
    -0.05113100f, 0.07905111f, 0.26825622f, 0.09809431f, -0.13488130f, 0.09191587f, -0.14371413f, -0.01737556f, 
    -0.35090163f, 0.03293875f, -0.47016984f, -0.02404090f, -0.29030991f, -0.05238874f, -0.05726893f, 0.17731601f, 
    0.01962789f, -0.14536366f, 0.11364627f, 0.02588812f, -0.28540140f, 0.18657529f, -0.07670172f, -0.14891638f, 
    -0.23140068f, -0.08133846f, -0.04117623f, -0.04415703f, -0.02964526f, -0.06835334f, -0.23403946f, 0.11804591f, 
    0.05365883f, 0.16595590f, -0.40593460f, 0.01159315f, -0.42992485f, 0.22532000f, -0.45722908f, 0.14138545f, 
    0.01462343f, -0.04613927f, 0.11570388f, -0.19184361f, 0.11626726f, -0.14885069f, 0.30769902f, 0.21796767f, 
    0.02141602f, -0.22950099f, -0.10238266f, 0.07059955f, -0.04314521f, -0.09106106f, -0.05757540f, 0.04696494f, 
    -0.36887562f, -0.05796450f, 0.18461959f, -0.38888633f, 0.13091010f, -0.02907235f, -0.33990970f, -0.07086121f, 
    -0.04526305f, -0.26975015f, 0.04099686f, 0.23384586f, -0.11244301f, 0.23660991f, -0.51717007f, 0.10540788f, 
    0.15119761f, -0.30260095f, 0.03351078f, -0.34358191f, -0.11611133f, 0.00310329f, -0.44844559f, 0.00088434f, 
    0.04490933f, 0.19913790f, 0.01496174f, -0.76098973f, 0.04518991f, -0.10515436f, 0.21617956f, 0.53609359f, 
    0.13310625f, 0.22173226f, 0.15805340f, 0.06090026f, 0.20466650f, -0.05080441f, -0.14834394f, -0.19321376f, 
    0.02527999f, 0.00880199f, 0.12809712f, -0.16724332f, -0.80523556f, 0.08613938f, 0.00077355f, -0.23182382f, 
    -0.20787293f, 0.06422912f, -0.05405268f, 0.02121964f, 0.14241645f, -0.26173821f, 0.10720544f, 0.00270476f, 
    -0.36532828f, -0.49356711f, -0.18809065f, -0.08846824f, 0.11356137f, -0.01932942f, -0.02635642f, 0.28161064f, 
    0.23448791f, 0.13715705f, 0.34216017f, 0.04205811f, -0.16439414f, 0.33055276f, -0.32741758f, 0.14172298f, 
    0.11764896f, -0.01193894f, -0.25768337f, -0.18029919f, 0.10182139f, -0.55204642f, -0.09608933f, -0.01457500f, 
    -0.35949409f, 0.03692583f, 0.25229201f, 0.09130983f, 0.14243546f, 0.02097095f, -0.16095239f, -0.44651887f, 
    0.07532148f, 0.15118717f, 0.19174100f, 0.01604556f, -0.28975615f, 0.01735797f, 0.03733761f, -0.37235543f, 
    0.09415074f, -0.01738040f, -0.51398188f, 0.01670717f, -0.33754322f, -0.04676105f, -0.70686877f, -0.00149577f, 
    0.02434297f, 0.07317274f, 0.43624529f, -0.08392602f, -0.21632929f, -0.02149785f, 0.27060527f, 0.05257440f, 
    -0.06973565f, -0.10034928f, -0.56844425f, -0.34335974f, -0.23022079f, 0.36832350f, 0.02502376f, 0.00493875f, 
    -0.17415437f, 0.25409415f, 0.07092955f, -0.27305263f, -0.05958759f, 0.28131214f, -0.39795813f, -0.00809035f, 
    0.20844452f, -0.03466399f, -0.02781532f, -0.17152271f, 0.15852776f, 0.08196081f, -0.07261913f, 0.06620272f, 
    -0.09437930f, -0.17261636f, 0.07449888f, -0.06213178f, -0.11182918f, 0.17414731f, 0.21333216f, -0.07360814f, 
    0.16882217f, 0.14136784f, -0.29657847f, 0.28343236f, 0.27691680f, -0.20233621f, 0.10426970f, -0.14874987f, 
    -0.01836456f, 0.11405159f, -0.09183091f, 0.30849960f, -0.03016157f, -0.19202280f, -0.03653833f, -0.28803000f, 
    -0.34477791f, 0.21400787f, -0.06474449f, 0.05195205f, -0.05992835f, -0.23041260f, 0.06676511f, 0.05234595f, 
    0.08449374f, 0.14236905f, -0.61958724f, -0.00861014f, -0.01368787f, 0.18694347f, -0.01163632f, 0.07042910f, 
    0.01396506f, -0.08918225f, 0.09344285f, -0.08510654f, 0.03112298f, -0.12557580f, 0.25337949f, -0.34401494f, 
    0.03723029f, -0.31148416f, 0.22000031f, 0.08028376f, -0.12462575f, 0.00655257f, 0.05815040f, -0.33923745f, 
    -0.28729206f, -0.05341182f, -0.54299343f, -0.06240337f, -0.15137222f, -0.17271942f, 0.15756030f, 0.17089354f, 
    0.25694293f, -0.24722475f, -0.41840222f, -0.04665282f, -0.56530416f, -0.20140423f, -0.43893847f, 0.07108919f, 
    0.14716333f, 0.06624819f, -0.31876221f, 0.14952087f, 0.05438415f, 0.06381824f, -0.38981059f, 0.21207361f, 
    0.00968420f, -0.25864556f, 0.11143681f, 0.02178812f, 0.01138765f, 0.20352426f, -0.03210386f, 0.06318393f, 
    0.20234245f, -0.05119340f, 0.20347103f, -0.00426967f, 0.01289550f, 0.10953979f, -0.00310139f, -0.16718058f, 
    0.02300253f, -0.07911991f, -0.38963953f, -0.04767834f, -0.04360975f, -0.27034202f, 0.06956796f, 0.19371735f, 
    0.01886829f, 0.17952281f, -0.16270687f, 0.05685575f, 0.09297296f, -0.20700027f, -0.03676905f, 0.02903723f, 
    0.17869554f, -0.24381831f, -0.04496383f, 0.22898638f, 0.03270125f, 0.25761178f, -0.17383385f, 0.05290841f, 
    -0.50424385f, 0.02870229f, 0.05263845f, -0.60747123f, -0.26016632f, 0.04945603f, 0.16701835f, -0.22802006f, 
    0.09599371f, 0.42272708f, 0.38666660f, 0.12857157f, -0.44986919f, 0.06235286f, -0.51115173f, -0.28950199f, 
    0.05377129f, 0.05416328f, 0.49572763f, -0.53658855f, -0.00350194f, -0.16908707f, 0.23914191f, -0.15776531f, 
    0.22991654f, 0.04215091f, -0.05385232f, -0.26757380f, -0.08906135f, 0.43760589f, -0.09707553f, -0.04521682f, 
    -0.01184640f, -0.10658929f, -0.21476401f, -0.07045725f, 0.22190763f, -0.09125637f, -0.38103461f, -0.46819648f, 
    -0.23918343f, -0.05518356f, 0.24145177f, 0.27681756f, -0.06055899f, -0.07135891f, 0.03420087f, -0.34104851f, 
    0.19902034f, 0.04956697f, -0.00226078f, 0.45683950f, 0.22625662f, -0.34192029f, 0.22295988f, -0.08671405f, 
    0.24231507f, -0.33057851f, 0.14615424f, 0.05663480f, -0.07469838f, 0.01053516f, 0.05267844f, -0.03347012f, 
    -0.21770534f, -0.00633418f, 0.16747688f, -0.04002835f, -0.13833039f, -0.21534067f, 0.26022193f, 0.00638347f, 
    0.20007756f, -0.60423881f, 0.08127237f, -0.26661232f, -0.13545297f, 0.23228514f, -0.14522600f, -0.02609637f, 
    -0.18945614f, 0.06762452f, -0.19166555f, -0.13388905f, 0.01304885f, 0.07122985f, -0.12513484f, 0.18006720f, 
    0.00258867f, 0.15671642f, 0.14674832f, -0.03962384f, -0.39693132f, -0.08663470f, 0.06717364f, 0.31815851f, 
    -0.27525806f, 0.03518920f, 0.18663643f, -0.02845641f, 0.23454738f, 0.23811086f, 0.41168460f, 0.31332889f, 
    0.02014707f, 0.13524830f, 0.08791298f, 0.06213721f, -0.06256450f, 0.14610623f, -0.00762937f, 0.04650661f, 
    -0.03003767f, -0.47010952f, 0.22363466f, -0.20305160f, -0.20196150f, 0.05414789f, -0.09231896f, 0.28567773f, 
    0.15356964f, 0.22119661f, -0.03423991f, -0.03284861f, 0.05044222f, -0.15815683f, -0.20307599f, 0.03212401f, 
    -0.51611048f, -0.02102208f, -0.20931600f, 0.15601771f, -0.38860703f, -0.06134674f, -0.62176901f, -0.14219901f, 
    -0.35417354f, -0.01684127f, -0.10914455f, -0.22780590f, 0.10024688f, -0.15236622f, 0.45442769f, -0.51738453f, 
    0.14126772f, -0.16438091f, -0.22754969f, -0.14324005f, -0.06452638f, -0.01784777f, -0.43031511f, 0.38007778f, 
    0.17393601f, -0.10786486f, 0.14097789f, -0.30030799f, -0.05656258f, -0.22951990f, -0.05380461f, -0.28248817f, 
    0.01531074f, -0.21500592f, 0.12111650f, -0.03589139f, 0.18755190f, 0.33035144f, 0.13328022f, -0.25486422f, 
    -0.19999805f, -0.52530742f, 0.12379691f, -0.24498472f, 0.08286007f, -0.03101358f, 0.06456126f, -0.15687892f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.18059145f, -0.04810321f, 0.18388620f, -0.01551227f, -0.07242084f, 0.05138088f, 0.08087724f, -0.15571626f, 
    0.02630851f, -0.02911700f, -0.11861444f, 0.01681275f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
