#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.67410344f, 0.07426395f, -0.29102907f, -0.47656286f, 0.08499066f, 0.16771932f, -0.30673686f, -0.53002936f, 
    -0.61156261f, -0.41588405f, -0.42465848f, 0.04775278f, 0.14836408f, 0.21248773f, 0.34457302f, -0.28217572f, 
    0.17352758f, -0.33304021f, 0.23647572f, 0.36344603f, -0.34664440f, 0.14369619f, 0.28803414f, -0.15052649f, 
    0.21251740f, -0.29366714f, -0.12631254f, -0.41743004f, -0.87739599f, -0.66510272f, -0.19846635f, 0.14930129f, 
    -0.09937694f, -0.33470798f, -0.31007758f, 0.05606457f, 0.34042826f, -0.13219693f, 0.34797028f, -0.13092069f, 
    0.03593154f, 0.07620670f, 0.24495023f, 0.24934636f, -0.11132396f, 0.05769158f, -0.11144850f, -0.23319344f, 
    0.04091501f, 0.10513785f, 0.81120300f, 0.12894484f, -0.35451046f, -0.08878441f, -0.19559354f, 0.21585520f, 
    0.15523979f, 0.01887354f, 0.62552220f, -0.12516895f, -0.40087461f, -0.26804122f, -0.14857507f, -0.35347256f, 
    -0.42857340f, -0.11937722f, -0.25534606f, -0.32413992f, 0.01435272f, -0.01755698f, 0.09998579f, -0.04322752f, 
    -0.12600861f, -0.26605389f, -0.00792999f, 0.57004601f, 0.23881763f, 0.40008983f, 0.94708484f, 0.39227363f, 
    -0.41135305f, 0.21554956f, 0.30151111f, -0.10004598f, 0.32472837f, -0.10318420f, -0.24414602f, 0.19194981f, 
    -0.19061099f, 0.18235880f, -0.15072116f, -0.24214511f, 0.17067654f, -0.33799165f, 0.14409068f, 0.32182083f, 
    0.14243631f, -0.00311591f, -0.07083815f, -0.30494481f, 0.73132700f, 0.08841828f, 0.57379812f, 0.24360918f, 
    0.45148867f, -0.10073818f, -0.62781787f, 0.17510852f, 0.17893560f, -0.44376498f, -0.38292974f, -0.52441114f, 
    -0.06543891f, -0.07023852f, 0.36308709f, 0.15744537f, 0.22775428f, 0.13095286f, 0.22161253f, -0.30032867f, 
    0.49248445f, 0.31935534f, -0.09240717f, 0.17057112f, -0.03456750f, -1.02342272f, 1.03465986f, -0.11341947f, 
    -0.32931802f, 0.05925063f, -0.29271767f, 0.48079866f, 0.14481738f, 0.37234369f, 0.42753273f, -0.29833770f, 
    0.13000211f, 0.14407936f, -0.14734446f, -0.09136128f, 0.21370968f, -0.00430186f, -0.18562794f, -0.08674357f, 
    -0.32601866f, -0.16073471f, 0.07348850f, 0.14021105f, 0.02446951f, -0.25069839f, -0.31061018f, -0.54980904f, 
    -0.04598512f, -0.04360645f, -0.35182738f, -0.43978673f, -0.50739789f, -0.34924135f, -0.00009909f, -0.18253285f, 
    -0.43823078f, 0.33075231f, -0.37147859f, -0.22860727f, -0.06743663f, -0.68286604f, -0.21531054f, -0.18918242f, 
    -0.04257471f, -0.28988388f, 0.24101341f, 0.00736017f, 0.23852874f, -0.20619835f, -0.12807801f, 0.80839020f, 
    0.81116551f, 0.38638249f, -0.22473247f, -0.18076117f, 0.24030913f, 0.65107268f, 0.44336960f, 0.35071892f, 
    0.43712306f, -0.04872177f, 0.06117477f, -0.19073547f, -0.39454952f, 0.04468895f, -0.19337630f, 0.00594712f, 
    -0.18578404f, -0.15635821f, -0.17567430f, -0.10682078f, -0.14856187f, -0.03375124f, -0.15529071f, 0.02799368f, 
    -0.18728577f, -0.15457614f, -0.18926398f, 0.08891058f, 0.66344476f, -0.01522414f, -0.67222893f, -0.50754374f, 
    0.24428099f, -0.56333286f, 0.36852407f, 0.01163907f, -0.37489560f, 0.43989906f, 0.15392248f, 0.26234499f, 
    -0.00245573f, 0.03306026f, 0.01760755f, 0.21501088f, 0.10592063f, -0.22239733f, 0.17443880f, 0.05224662f, 
    -0.23538704f, 0.83978206f, 0.96830773f, -0.49928978f, -0.11704666f, -0.47244340f, -0.15592742f, 0.32281324f, 
    -0.20877637f, -0.03746359f, 0.32520583f, 0.26285309f, 0.19751537f, 0.20478724f, 0.08881029f, -0.09744459f, 
    0.12635644f, -0.06732535f, 0.28053638f, 0.20976569f, 0.00534195f, 0.20672210f, 0.04557900f, 0.06212637f, 
    0.05298690f, 0.09203621f, 0.94799143f, 0.32813537f, -0.85957628f, 0.07682249f, -0.20706211f, 0.06661985f, 
    -0.54311621f, 0.31317249f, -0.09631776f, -0.13454467f, 0.04575487f, 0.09796128f, 0.24042012f, 0.13260946f, 
    0.21416050f, 0.01303482f, -0.42135060f, -0.21977676f, -0.16644610f, 0.29251570f, 0.14717187f, 0.12475471f, 
    0.12020536f, -0.33952990f, -0.05579399f, 0.56074345f, -0.39825791f, -0.61532795f, -0.70654052f, 0.01890627f, 
    -0.10090891f, -0.53935391f, 0.50158781f, 0.31215432f, -0.01402920f, -0.41021371f, -0.15310495f, 0.09719049f, 
    -0.06802376f, -0.24754591f, 0.13805632f, 0.11462294f, 0.20981835f, 0.04670900f, -0.09587712f, 0.11336391f, 
    0.00232265f, 0.15548956f, 0.17884085f, -0.23055379f, 0.01075016f, -0.91857463f, 0.44077879f, 0.30231896f, 
    -0.00142105f, 0.09599058f, -0.38407841f, 0.42551905f, 0.42859346f, -0.19389218f, 0.27540088f, -0.63569432f, 
    -0.08245116f, 0.44646487f, -0.22533076f, 0.03270497f, -0.06993527f, -0.03122902f, -0.09898423f, -0.31758666f, 
    -0.33216324f, 0.06911699f, 0.13969025f, 0.05281113f, 0.26523730f, -0.68742514f, -0.84929943f, -1.04261959f, 
    -0.44546020f, 0.04949551f, 0.02883117f, 0.54742235f, 0.37597832f, 0.50669909f, 0.49041805f, 0.02201603f, 
    -0.04014911f, -0.01460328f, -0.17467037f, -0.16085814f, -0.09298720f, 0.15240593f, 0.06811398f, 0.04626260f, 
    -0.14591159f, -0.03277297f, -0.14846663f, 0.01261231f, 0.07663753f, 0.17488377f, -0.18783386f, 0.72625393f, 
    0.51726818f, 0.21299471f, 0.20002076f, -1.24313092f, -0.01168231f, -0.44398397f, -0.60548997f, -0.41289628f, 
    0.06189577f, -0.17990780f, 0.00779412f, 0.07819472f, 0.17963876f, 0.03048854f, -0.05895000f, 0.01674382f, 
    -0.10061577f, -0.20221177f, 0.03883617f, -0.02879888f, -0.02305971f, 0.09907334f, 0.10448564f, 0.87117815f, 
    0.60470855f, 0.71137214f, 0.83597589f, 0.62136328f, 0.50454444f, -0.18177974f, -0.39952806f, 0.01322373f, 
    -0.21896601f, 0.34655738f, 0.34318224f, 0.09936335f, 0.18159032f, -0.18199980f, 0.09875338f, 0.02324337f, 
    0.24616860f, -0.13222624f, 0.03318396f, -0.19930378f, -0.11063694f, 0.12005951f, -0.05930706f, 0.10999536f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.04650101f, 0.21515177f, -0.13136986f, -0.08488787f, 0.12686177f, 0.04491345f, 0.16694336f, -0.00161458f, 
    -0.08157134f, 0.26152039f, -0.04751292f, 0.10378523f, -0.08003379f, 0.01004606f, 0.28769508f, -0.00299581f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.21164246f, -0.11398268f, 0.05111506f, -0.17201777f, 0.04330982f, -0.10849682f, -0.07951339f, 0.12710454f, 
    -0.21334390f, 0.09586257f, 0.00986874f, 0.00345809f, -0.36216795f, -0.10797916f, -0.09940439f, -0.07998028f, 
    -0.18439752f, -0.01828657f, 0.00769520f, 0.07247609f, -0.13891594f, 0.17642237f, -0.02199595f, 0.12017637f, 
    0.19828038f, -0.08362965f, -0.01068278f, 0.04345442f, 0.15631032f, -0.08225733f, -0.00574029f, 0.09620473f, 
    0.02259003f, 0.27425054f, 0.00639025f, -0.08016980f, -0.01490343f, -0.04523517f, -0.22269280f, 0.22506082f, 
    0.04158041f, 0.09746123f, 0.05206449f, -0.01426933f, 0.05952751f, 0.01202096f, 0.18311222f, 0.13882868f, 
    0.03310252f, 0.03866322f, 0.05565166f, 0.08605392f, -0.03992913f, 0.02645721f, -0.00657378f, -0.08938958f, 
    0.16283141f, -0.24381258f, -0.23285168f, 0.04157663f, 0.12961309f, 0.18434677f, -0.18500465f, -0.40861771f, 
    0.07945312f, 0.23174801f, -0.06135817f, 0.11159811f, 0.16519220f, 0.04647306f, -0.00778893f, -0.10839974f, 
    -0.22138423f, -0.03655895f, -0.04656947f, 0.23870593f, -0.00800218f, -0.03047150f, 0.08880980f, -0.12037347f, 
    -0.05044524f, 0.06273021f, 0.08015557f, -0.11312415f, 0.41438597f, -0.04817550f, 0.02856034f, -0.19949716f, 
    0.05113106f, -0.01477329f, 0.14556430f, 0.06986458f, -0.00819022f, 0.09426174f, -0.02078880f, 0.02167188f, 
    0.45336354f, -0.00105208f, 0.14506932f, 0.04503348f, 0.12756763f, 0.09261786f, 0.25647345f, -0.04657589f, 
    -0.07344761f, -0.13674369f, 0.09001350f, -0.24650298f, 0.49133393f, 0.10033948f, 0.19027746f, -0.24229652f, 
    -0.08823609f, -0.09983793f, 0.02407432f, 0.01586919f, -0.05327266f, -0.03159368f, 0.00454588f, 0.00662594f, 
    0.32528502f, -0.26998338f, 0.20214686f, -0.01486988f, 0.08171477f, -0.10094705f, 0.19833946f, 0.15967409f, 
    -0.05708216f, -0.09438676f, -0.08064284f, 0.03359128f, 0.18106943f, -0.02363298f, 0.16320713f, -0.19058600f, 
    -0.00147873f, 0.01631203f, 0.07978514f, -0.20211554f, -0.04966425f, 0.02831290f, -0.01118010f, -0.01339710f, 
    -0.20714995f, 0.25697163f, -0.13308412f, 0.21113773f, 0.02822508f, 0.00301536f, -0.02286388f, -0.05805205f, 
    -0.12869626f, 0.14072256f, 0.18640250f, -0.00206488f, 0.53648102f, 0.24408016f, -0.27203906f, 0.02945482f, 
    0.04821338f, -0.07509850f, 0.05686855f, 0.15026721f, 0.12391054f, 0.03058263f, -0.05104808f, 0.08217840f, 
    0.10207471f, 0.34624833f, -0.47519565f, -0.11629349f, 0.05396380f, 0.18493150f, 0.04371405f, -0.03485632f, 
    -0.20731409f, 0.03725151f, 0.06101879f, -0.02976906f, 0.34031233f, -0.22251204f, 0.07688260f, 0.46660149f, 
    0.06687618f, 0.01044343f, 0.12039413f, -0.00363243f, 0.00174972f, 0.00377831f, -0.09682371f, 0.07021810f, 
    -0.03665917f, -0.08706918f, 0.13192758f, 0.02100926f, 0.11490499f, 0.15949154f, -0.10447071f, 0.19905351f, 
    0.15219167f, -0.08979207f, -0.06170954f, 0.12064908f, 0.17974588f, 0.01663828f, 0.17755909f, -0.16885361f, 
    0.10187105f, -0.02117876f, -0.05181050f, -0.06788998f, -0.00167314f, -0.06844786f, 0.04062782f, -0.08893389f, 
    -0.31847978f, -0.16757058f, 0.11974143f, -0.00285674f, -0.23948708f, 0.04659040f, 0.25949076f, 0.02153957f, 
    0.26657683f, -0.11394587f, 0.14518456f, 0.13059366f, -0.29659402f, -0.11970041f, -0.03989958f, -0.10635008f, 
    0.27639246f, -0.07143509f, 0.05689047f, -0.10341953f, 0.04204915f, 0.07945473f, -0.00379447f, 0.02756652f, 
    -0.25863549f, 0.07768302f, 0.06922704f, -0.06331819f, 0.16051668f, 0.16641270f, 0.08751280f, 0.01300087f, 
    -0.08977877f, 0.01753577f, 0.03664685f, -0.03175495f, 0.23939210f, 0.30702341f, -0.12725730f, 0.11787365f, 
    -0.11939929f, -0.03096106f, 0.28520307f, 0.08777134f, -0.14328949f, -0.01218429f, -0.05108701f, 0.00195737f, 
    0.29655057f, 0.15453345f, 0.14534007f, -0.25639647f, 0.03599259f, 0.01602929f, -0.16219033f, -0.00246048f, 
    0.22542612f, 0.07702852f, 0.21052933f, 0.21509697f, -0.36242253f, -0.27693525f, -0.03761582f, -0.07768155f, 
    -0.06939998f, 0.16248788f, 0.12710977f, 0.18856242f, 0.06250579f, -0.00363586f, 0.07043299f, 0.19116805f, 
    0.22161067f, 0.17941980f, 0.00343168f, 0.18396677f, -0.00465588f, 0.05942439f, 0.02135526f, 0.07651807f, 
    0.07438461f, 0.00073945f, -0.04963718f, -0.02407985f, -0.21483785f, -0.37970102f, -0.14559504f, 0.11628532f, 
    0.04739884f, 0.06203149f, 0.07073669f, -0.02865230f, 0.08490169f, 0.17191170f, -0.12056144f, 0.06798829f, 
    0.01431823f, 0.09976555f, -0.29121006f, 0.06555785f, -0.03543830f, 0.04361114f, 0.07655957f, 0.00458253f, 
    0.22346526f, 0.02333984f, -0.01445559f, -0.11252621f, -0.20443869f, 0.21734099f, -0.26296121f, 0.43878689f, 
    -0.00158913f, -0.03044488f, 0.04960303f, 0.01599211f, 0.04956514f, -0.05658790f, -0.18198130f, 0.13200141f, 
    0.10790862f, -0.06747496f, -0.10413744f, -0.20609897f, -0.04986219f, 0.07835779f, -0.14385788f, 0.09006426f, 
    0.12360723f, 0.06390169f, 0.08209471f, 0.07103545f, -0.12094009f, -0.06714785f, 0.11072685f, 0.49664778f, 
    -0.33412915f, -0.22332878f, 0.04252489f, 0.13479146f, -0.02799479f, 0.00504991f, 0.15171133f, -0.02222921f, 
    -0.16917798f, 0.18537688f, 0.14912432f, 0.06885932f, 0.26530445f, 0.08360301f, 0.01781446f, 0.05842335f, 
    0.09957586f, -0.00913313f, -0.06494600f, -0.04777495f, -0.24656247f, -0.25385788f, -0.17709452f, -0.23075402f, 
    0.17161931f, -0.02378187f, -0.05195763f, -0.07998684f, 0.10738089f, -0.03376562f, 0.01189402f, -0.00325394f, 
    0.14465441f, 0.12830810f, 0.11094321f, -0.06472506f, 0.22939432f, 0.00017539f, 0.09827559f, 0.09698446f, 
    0.27028775f, 0.00099626f, 0.13270546f, -0.00447041f, 0.16760863f, -0.04505371f, 0.08366193f, -0.16782826f, 
    0.18073288f, 0.06880009f, 0.11232779f, 0.18806516f, 0.04175417f, 0.08941812f, 0.12199284f, 0.13620463f, 
    -0.16219296f, -0.54468179f, 0.00017583f, 0.07838475f, 0.00199348f, -0.00355867f, 0.33135647f, 0.06749748f, 
    0.16425227f, 0.10902933f, 0.11270414f, 0.09186023f, 0.09238084f, -0.07059803f, 0.38718870f, 0.22654241f, 
    0.06299035f, -0.11642202f, 0.05147724f, 0.06270409f, 0.06870618f, 0.10992397f, 0.04894423f, 0.18461266f, 
    -0.10443512f, -0.00000200f, 0.16566718f, 0.12266769f, 0.10838082f, -0.07531222f, 0.20504205f, 0.06356582f, 
    0.10276294f, 0.19245227f, 0.14443363f, 0.06021528f, 0.17355989f, 0.16497441f, -0.10843994f, 0.16326703f, 
    -0.05021584f, 0.08178163f, 0.14793624f, 0.20060559f, 0.10134003f, 0.11922497f, 0.07395838f, 0.13410446f, 
    0.19882983f, 0.11896788f, 0.09158543f, -0.04564304f, 0.05779881f, 0.09954469f, -0.04780783f, 0.25194940f, 
    0.05152488f, 0.04656404f, 0.07169334f, 0.12590933f, -0.02798278f, 0.18317670f, -0.09007901f, 0.11000154f, 
    0.13716139f, 0.10273082f, -0.09274900f, -0.06186259f, -0.01736775f, 0.06821259f, 0.35937041f, 0.09995072f, 
    0.03073378f, 0.01467783f, 0.04093098f, 0.06379542f, 0.05046301f, -0.00281439f, -0.04343997f, -0.02030775f, 
    0.01038384f, 0.04574626f, 0.02925784f, 0.13168859f, 0.22101797f, -0.06694503f, -0.18848656f, 0.20645924f, 
    -0.00671078f, 0.00815293f, 0.09948207f, -0.06224502f, 0.04498398f, 0.01099510f, 0.01958674f, -0.03712672f, 
    0.37579769f, -0.03073216f, -0.06592006f, 0.15506579f, -0.15777041f, 0.00832707f, -0.00907010f, -0.07586631f, 
    0.18318857f, 0.19330542f, 0.01316856f, -0.06222935f, -0.34862435f, -0.60886723f, -0.06312743f, 0.03506497f, 
    0.03572166f, -0.14933889f, 0.11862097f, -0.00745550f, 0.19590347f, 0.05395967f, 0.06883034f, -0.01234748f, 
    -0.05744626f, -0.09479380f, 0.08562610f, 0.16381153f, -0.07432340f, 0.17017145f, 0.01424575f, 0.08615734f, 
    0.06583505f, -0.09536002f, 0.08153635f, 0.19839899f, -0.12791614f, -0.24268837f, -0.19614315f, 0.06256980f, 
    -0.17181300f, -0.02985612f, -0.13488823f, 0.08159804f, 0.09038784f, -0.19145063f, 0.03879676f, 0.01352366f, 
    -0.49100611f, 0.16342136f, 0.35186249f, 0.03270123f, 0.19535546f, 0.14763767f, 0.09367979f, 0.07758202f, 
    0.17464067f, -0.09303471f, -0.05543334f, 0.23245792f, 0.07036456f, 0.32195064f, 0.25601205f, -0.06299955f, 
    -0.05182335f, 0.05051725f, -0.02729671f, -0.03082704f, 0.05648084f, -0.08893089f, 0.11979975f, -0.04127797f, 
    -0.21036236f, 0.18765679f, 0.14330451f, -0.01833976f, 0.06495749f, 0.06576980f, 0.30387077f, -0.14849731f, 
    0.06253305f, -0.07309756f, -0.00567504f, 0.07254542f, -0.30757082f, 0.04796191f, -0.02374775f, 0.06497549f, 
    0.25135186f, 0.02179977f, 0.12549546f, -0.00302397f, -0.04690791f, -0.05329827f, -0.17086601f, -0.20554717f, 
    -0.24288659f, 0.19684730f, -0.10249082f, -0.07374895f, -0.10465535f, -0.21722861f, 0.09567614f, 0.10279185f, 
    0.06825365f, -0.01026422f, 0.13475214f, -0.09354516f, 0.20120537f, 0.26788223f, -0.06498818f, 0.17776735f, 
    -0.24674185f, 0.11177965f, 0.05945770f, 0.02104205f, -0.00900256f, 0.00373617f, -0.08127078f, 0.27101061f, 
    0.14490928f, 0.14766072f, -0.09834673f, 0.02479285f, 0.14866795f, -0.01188312f, 0.16445363f, -0.11362179f, 
    0.08246940f, 0.06384866f, -0.02686969f, -0.09060214f, 0.38569012f, -0.52726650f, -0.37104765f, -0.14961946f, 
    0.09738539f, 0.03831572f, 0.30163941f, 0.14983021f, -0.13207841f, -0.00763271f, 0.08987974f, -0.05093074f, 
    -0.32925305f, -0.15226506f, -0.24659355f, -0.05029076f, -0.00893320f, -0.01860026f, 0.15262532f, -0.08407266f, 
    -0.09089472f, -0.04910609f, -0.07870483f, 0.00331461f, 0.07561108f, 0.26708674f, 0.24008271f, -0.02674656f, 
    -0.12174839f, -0.00556615f, 0.11034910f, 0.12358323f, 0.12001794f, 0.14696211f, 0.10014989f, 0.16946132f, 
    -0.03480054f, -0.16929361f, 0.00720900f, 0.23813887f, 0.15236299f, -0.00876029f, 0.06203870f, 0.19818325f, 
    0.10694589f, 0.04466074f, 0.11173449f, 0.09577210f, -0.06995510f, 0.03147516f, 0.49016339f, -0.13894016f, 
    0.06669436f, 0.07195984f, 0.34000108f, -0.10669064f, 0.01356606f, -0.08866650f, 0.02373086f, 0.03071458f, 
    -0.34421071f, -0.36661205f, 0.25392365f, -0.00977413f, -0.16131799f, -0.09060668f, 0.16381182f, -0.24242833f, 
    0.06982780f, -0.05446547f, -0.00896829f, -0.02425378f, -0.11175437f, -0.12400981f, 0.14641127f, 0.04046013f, 
    0.03664362f, -0.05770551f, 0.10467645f, 0.12726720f, 0.03515401f, -0.06282791f, 0.11560153f, 0.02211750f, 
    0.04896400f, 0.02799676f, -0.22063455f, 0.10775624f, 0.17554596f, 0.04327498f, 0.11993465f, -0.11336292f, 
    0.11115436f, 0.16722436f, -0.00367152f, 0.23579355f, -0.00870120f, -0.39649612f, -0.17290826f, 0.03330161f, 
    0.36416069f, -0.08024890f, -0.13586926f, 0.38247839f, 0.08051626f, 0.03764654f, 0.01876555f, 0.10302001f, 
    0.10426220f, 0.06872430f, 0.11476041f, 0.12069923f, -0.19922772f, 0.06438991f, -0.11144443f, -0.15950015f, 
    0.04175875f, 0.07986840f, 0.10705345f, -0.06537589f, 0.08499078f, 0.43677789f, 0.21525663f, -0.37422800f, 
    -0.05621435f, -0.20276743f, -0.01173268f, 0.05683248f, 0.07330679f, 0.11931725f, 0.10897186f, 0.15349175f, 
    -0.23063236f, 0.23025446f, 0.12354083f, -0.50437188f, -0.02358784f, 0.00241712f, 0.00436026f, 0.02058335f, 
    -0.23591238f, -0.03887979f, 0.15257891f, 0.00636166f, -0.17625400f, 0.10678953f, -0.18443289f, -0.21434569f, 
    -0.00568167f, -0.04113804f, 0.15598933f, 0.00682592f, -0.08064797f, 0.09065317f, 0.18624863f, -0.03354973f, 
    0.24043837f, -0.14852989f, -0.02164412f, 0.13299681f, 0.04468065f, -0.15455647f, 0.07782774f, 0.09532223f, 
    -0.11073779f, -0.01060094f, 0.10425495f, -0.08312651f, 0.30655798f, 0.02377285f, -0.08349081f, 0.56930238f, 
    -0.11145173f, 0.09673950f, -0.00700791f, 0.09798718f, 0.08069803f, 0.04488574f, 0.06911940f, -0.02240510f, 
    -0.28622264f, 0.23150261f, 0.07333271f, -0.06403670f, 0.05802744f, -0.10377397f, -0.04124888f, 0.00483848f, 
    0.02646200f, 0.08293007f, -0.14480221f, 0.08129308f, 0.29277876f, 0.31700334f, -0.02402476f, 0.03786711f, 
    0.09378462f, 0.03715925f, 0.09843287f, 0.25732759f, 0.13131382f, 0.09330632f, 0.16776279f, -0.16160400f, 
    -0.18187217f, -0.12953319f, 0.02911530f, -0.27899832f, 0.03102672f, -0.02781499f, -0.08204703f, -0.17777550f, 
    -0.08537657f, -0.01909911f, -0.10127712f, -0.20726834f, 0.11668975f, 0.39214367f, -0.02153659f, 0.10625452f, 
    0.03800287f, -0.07123817f, 0.03022309f, 0.04387340f, -0.13847885f, -0.02092752f, -0.08815529f, -0.00939448f, 
    -0.04742147f, -0.00423805f, 0.14085972f, 0.02377052f, 0.10210844f, 0.09560961f, 0.10509811f, 0.00423530f, 
    -0.17443489f, -0.00941889f, -0.04779254f, 0.06916141f, 0.28846547f, 0.20222427f, -0.13332669f, -0.18650004f, 
    0.02019011f, -0.14476293f, -0.01227334f, -0.06611970f, -0.08273885f, -0.01709462f, -0.02501417f, 0.05564130f, 
    0.03765258f, -0.24599397f, -0.08243194f, -0.15766720f, -0.16138928f, -0.03563835f, 0.04470610f, 0.05038027f, 
    0.03450629f, -0.02685244f, 0.04601844f, -0.00588243f, -0.32307646f, -0.14883140f, 0.14141546f, -0.37442496f, 
    0.00220223f, 0.02285930f, 0.01177590f, -0.12256552f, -0.01767108f, -0.14245202f, -0.04178870f, 0.06166563f, 
    -0.28929010f, 0.08505853f, 0.15051778f, 0.04847564f, 0.03794990f, 0.10599698f, 0.02670373f, -0.03384203f, 
    -0.11134662f, -0.02134588f, 0.12817866f, -0.03134623f, 0.26694444f, 0.13549426f, 0.11336544f, 0.20142385f, 
    -0.07567522f, -0.03616083f, -0.10487299f, 0.08453322f, 0.09379304f, -0.12603329f, -0.01445320f, 0.18429649f, 
    -0.19052681f, 0.17750777f, -0.29626730f, -0.10193180f, 0.19302119f, 0.00203275f, -0.00718971f, -0.14305572f, 
    0.03393518f, 0.02570516f, -0.00838579f, 0.03595342f, 0.26730654f, 0.26995125f, 0.25495458f, 0.45978576f, 
    -0.22658864f, 0.00000196f, -0.02869560f, 0.09914034f, 0.00786846f, 0.06756424f, 0.01918238f, -0.08202277f, 
    0.02917830f, -0.03117113f, -0.02547454f, -0.08873172f, -0.01407452f, -0.07820585f, -0.07861930f, 0.00229515f, 
    -0.06882684f, -0.07537238f, 0.02584193f, 0.02004504f, -0.05386134f, 0.00156702f, -0.00674411f, 0.05077564f, 
    -0.03246468f, 0.03253999f, 0.04067258f, 0.04635208f, -0.05773291f, -0.03173035f, -0.04758888f, 0.03602626f, 
    0.02005982f, 0.01671600f, 0.04625732f, 0.05767811f, -0.07890353f, -0.03710577f, 0.02047938f, 0.00221788f, 
    0.04340401f, 0.06811224f, -0.01283636f, 0.02208244f, -0.07327633f, -0.03309577f, 0.05894445f, -0.01199970f, 
    0.03116271f, -0.05460818f, -0.04462529f, -0.07066575f, 0.01908819f, 0.03340266f, 0.02227248f, 0.05950564f, 
    -0.06014301f, -0.05316352f, -0.02931713f, -0.04709959f, 0.04707560f, 0.03260915f, -0.07306972f, -0.01282520f, 
    0.05380174f, 0.01757935f, -0.03744891f, -0.08026927f, -0.05620607f, 0.01111048f, -0.06587148f, -0.05935635f, 
    -0.01816727f, 0.06075641f, -0.03028063f, -0.01665541f, -0.07303276f, -0.04739312f, -0.02564898f, -0.05858544f, 
    0.05393393f, -0.03693943f, 0.01533075f, -0.07867098f, -0.06183590f, 0.03213592f, -0.06083186f, 0.05340900f, 
    -0.07580278f, 0.02263765f, -0.00684687f, -0.05066385f, -0.07657348f, 0.06051744f, 0.01074300f, -0.02804948f, 
    0.01233944f, -0.07178098f, -0.06923137f, -0.00378805f, 0.01789899f, -0.06308610f, 0.03807632f, -0.05209855f, 
    0.04605845f, -0.02846169f, 0.02080561f, 0.00041025f, -0.06130042f, -0.02907464f, 0.00649644f, -0.04553235f, 
    0.05297189f, 0.01666341f, -0.02881105f, -0.06478781f, -0.06718479f, -0.06682394f, 0.00186925f, -0.04011101f, 
    0.05174443f, 0.04860350f, -0.02393238f, -0.02409926f, 0.02861570f, -0.06308416f, 0.02426853f, -0.05197173f, 
    0.05926417f, -0.01340243f, -0.02057628f, 0.04588953f, -0.01915881f, -0.00060192f, -0.06051579f, -0.04288804f, 
    0.04008177f, 0.01784484f, -0.07171381f, -0.01677197f, -0.07093667f, 0.01270256f, -0.06213699f, 0.00817252f, 
    0.03783347f, -0.04145418f, 0.03247007f, 0.06621053f, 0.03890568f, 0.03904470f, -0.06203147f, -0.04770953f, 
    -0.05077351f, 0.04838788f, -0.04074743f, 0.00748454f, 0.00373514f, 0.05392509f, 0.02110850f, -0.00466471f, 
    0.02259064f, -0.04679950f, 0.03527464f, -0.01829478f, -0.08606462f, -0.04388374f, -0.06606207f, 0.06381924f, 
    -0.02114470f, 0.02524641f, 0.03634177f, -0.04285241f, 0.00578256f, -0.05423266f, -0.07230372f, 0.04633553f, 
    0.02201903f, -0.00335113f, 0.03088243f, 0.06082048f, -0.02515205f, 0.03565674f, 0.05192901f, 0.00542467f, 
    -0.00546103f, 0.03458559f, 0.02551870f, 0.03795419f, 0.06001784f, 0.01110269f, 0.02122760f, -0.04658081f, 
    -0.03423141f, 0.01165473f, -0.03769877f, -0.00176020f, 0.05141607f, -0.02175827f, -0.06164769f, -0.02735137f, 
    -0.02621653f, 0.05537147f, -0.00430280f, 0.22168343f, -0.05729984f, -0.04141951f, 0.06567956f, -0.01097391f, 
    0.08188727f, -0.20209448f, -0.05711340f, 0.12187590f, 0.28915557f, 0.04296710f, 0.16277215f, 0.21568234f, 
    0.11062641f, 0.00973407f, 0.02507502f, -0.05487061f, 0.05178392f, -0.08401319f, -0.19130579f, 0.09551349f, 
    0.01993709f, 0.23357484f, -0.06317396f, 0.04381123f, -0.02356925f, 0.05963676f, -0.03576008f, 0.02913429f, 
    -0.00274184f, 0.12512043f, 0.21987192f, 0.29322609f, 0.19942917f, 0.03019100f, 0.22778350f, -0.22420169f, 
    -0.00636919f, 0.07408340f, 0.01240307f, -0.00603608f, -0.12552387f, -0.00735767f, -0.05613122f, 0.08043339f, 
    0.23750944f, -0.03360294f, -0.05869216f, -0.05373558f, -0.09964386f, 0.07730599f, 0.14212164f, -0.09464222f, 
    -0.10767303f, 0.07203999f, 0.17847335f, -0.07073582f, 0.01939931f, -0.11037298f, 0.11338659f, 0.13921838f, 
    0.13671945f, -0.03229192f, 0.05586183f, 0.10124128f, -0.00680064f, 0.04800438f, 0.05536109f, 0.21022628f, 
    0.01550680f, 0.02981962f, -0.04924513f, 0.01408347f, -0.12792288f, -0.02607556f, -0.10941136f, 0.07345469f, 
    0.00914424f, 0.04424981f, 0.20398921f, 0.26088980f, -0.31438848f, -0.08511611f, 0.11513955f, 0.12304918f, 
    0.05629364f, -0.05674161f, 0.05142805f, 0.12436880f, 0.09504118f, 0.11134312f, 0.15341832f, -0.03590465f, 
    -0.23934348f, 0.02537008f, 0.03826817f, 0.05025252f, -0.16634746f, 0.15835258f, 0.05472653f, -0.14180027f, 
    -0.04692036f, 0.01274727f, -0.00189570f, -0.11170971f, -0.09908848f, -0.16244781f, -0.06702454f, 0.14990267f, 
    -0.03388651f, 0.08155178f, 0.05825916f, 0.00189955f, 0.01653123f, 0.04262815f, -0.17485860f, -0.08767392f, 
    0.33850649f, 0.37125471f, -0.02950118f, 0.01858423f, -0.06214666f, 0.04254432f, -0.03020062f, 0.01370952f, 
    -0.05844289f, -0.04215043f, 0.12938583f, -0.00691873f, 0.27777901f, 0.07931001f, 0.02045910f, 0.22967280f, 
    -0.06563257f, -0.02367556f, 0.03254217f, 0.15050539f, 0.02358518f, 0.10817655f, 0.00300044f, -0.00007764f, 
    0.51696861f, -0.04471986f, 0.06436941f, -0.15189430f, -0.09295203f, -0.08869743f, 0.02511658f, 0.03753969f, 
    0.01585273f, -0.03931022f, -0.10466542f, 0.09955524f, -0.34023622f, 0.03918513f, 0.05864734f, -0.14853664f, 
    0.14897150f, 0.09098606f, 0.13450427f, -0.04778923f, -0.00380367f, 0.02790926f, 0.24518605f, 0.01044229f, 
    -0.12186911f, -0.28510466f, 0.31289673f, 0.07413389f, -0.04043158f, -0.08111091f, -0.00099094f, 0.07512999f, 
    0.14696030f, -0.06388444f, -0.00402143f, -0.12482382f, 0.03993680f, 0.31897524f, -0.05316382f, -0.25816590f, 
    -0.03938425f, -0.02770074f, -0.18281960f, 0.10596969f, -0.01391990f, 0.07941285f, 0.02481133f, -0.18598311f, 
    0.21500427f, -0.10219702f, -0.01691297f, 0.05720880f, 0.09597844f, -0.02688946f, -0.00324090f, -0.06974168f, 
    0.16037232f, 0.15298383f, 0.01435769f, 0.01087430f, -0.01275858f, -0.13250314f, -0.17859346f, -0.07551315f, 
    0.10536934f, 0.02332442f, -0.12084299f, -0.04953831f, -0.00659667f, -0.01428489f, 0.07449038f, 0.06190235f, 
    -0.32928494f, -0.08573776f, 0.07463818f, -0.06944425f, 0.03112324f, 0.13756914f, 0.01454550f, -0.02316854f, 
    0.19350965f, -0.08644955f, -0.09928278f, 0.17639126f, -0.38047570f, 0.10074320f, 0.07009944f, -0.33027899f, 
    0.05793021f, -0.00874202f, 0.04378349f, -0.00138713f, -0.02007910f, -0.05470334f, 0.14934947f, 0.05080200f, 
    -0.53271496f, 0.02573798f, -0.00162608f, -0.04453800f, 0.14795348f, -0.00042249f, 0.11618400f, 0.05939480f, 
    -0.02840958f, 0.02030265f, 0.11323643f, -0.06303453f, -0.15978998f, -0.16902989f, -0.10862896f, 0.03357657f, 
    0.05918165f, 0.03315267f, 0.05332315f, -0.04758823f, -0.08010791f, -0.01626815f, -0.02158171f, 0.06828759f, 
    0.06791316f, 0.19831249f, -0.02254777f, 0.01608877f, 0.08399479f, 0.05006720f, 0.23159441f, -0.09736823f, 
    0.08880059f, 0.08409214f, 0.07515132f, -0.00457227f, -0.11780747f, 0.05160068f, -0.26522464f, 0.11920480f, 
    -0.09596054f, 0.22243729f, -0.07556902f, 0.03757885f, 0.10511145f, -0.14889036f, -0.02761422f, 0.19496694f, 
    0.32771713f, 0.03171972f, -0.05805242f, -0.16266300f, 0.20585717f, 0.01355372f, 0.05456677f, 0.05649599f, 
    -0.05595363f, 0.05012399f, 0.01333855f, -0.06469568f, -0.15224004f, 0.25024945f, 0.03287547f, 0.31469053f, 
    0.23503320f, 0.25763237f, 0.10154300f, 0.19987211f, 0.13778219f, 0.11781174f, 0.13949622f, 0.10305908f, 
    -0.25976107f, -0.08098635f, 0.04762530f, 0.01839541f, 0.13150693f, 0.06416710f, -0.03418112f, 0.07201177f, 
    0.14257820f, -0.00538329f, 0.02163800f, 0.09910090f, -0.22054860f, -0.09555894f, 0.06994046f, 0.24834596f, 
    0.09369757f, 0.03715546f, 0.04838079f, 0.12361097f, 0.17225742f, 0.03549032f, -0.08243850f, -0.00413145f, 
    0.04835474f, -0.11431389f, 0.01388794f, 0.04299236f, -0.03368324f, 0.16698438f, 0.09219156f, 0.02324792f, 
    0.05479748f, 0.18219529f, 0.13988945f, 0.02554092f, 0.17935854f, -0.31423721f, -0.06244267f, -0.40270898f, 
    -0.27649626f, 0.02573913f, -0.02520072f, -0.02171880f, -0.06493445f, -0.01108056f, -0.13252178f, -0.03042600f, 
    0.33923581f, 0.32444176f, 0.04149201f, 0.02130681f, 0.05753850f, 0.15287769f, 0.12639184f, 0.22498280f, 
    -0.11301254f, 0.03576815f, 0.01112391f, 0.14430086f, -0.19223222f, -0.12581943f, 0.03248765f, -0.29541516f, 
    0.07523025f, -0.06075732f, 0.01065566f, -0.07618511f, 0.16602525f, -0.01598705f, 0.11767282f, 0.01498299f, 
    0.09006503f, 0.09856659f, 0.16479000f, -0.06261408f, 0.08596893f, -0.03000339f, 0.15380065f, 0.07672542f, 
    -0.05251805f, -0.00593137f, 0.22594799f, -0.07637885f, 0.07580347f, -0.00180249f, -0.03841739f, -0.00830949f, 
    0.14915042f, 0.08504203f, 0.08473764f, 0.14367029f, 0.07361054f, 0.01997474f, 0.18416400f, 0.02506866f, 
    0.39376616f, -0.30997968f, 0.15943351f, 0.03974571f, 0.15126599f, 0.04813392f, 0.02031446f, 0.06903833f, 
    0.01497013f, 0.07118013f, -0.07984926f, -0.05694245f, 0.29040903f, -0.11520548f, 0.22441684f, 0.25990677f, 
    -0.04126921f, -0.00462412f, -0.03730032f, 0.01525449f, 0.03018385f, 0.11859666f, 0.02908030f, -0.10118487f, 
    0.21985427f, -0.22018622f, 0.03914936f, 0.16575183f, -0.06681361f, -0.03426427f, 0.06039529f, 0.04862694f, 
    0.01349237f, 0.25047627f, 0.05085424f, 0.19853452f, -0.16064870f, 0.08719476f, 0.08657566f, 0.07832618f, 
    0.02440788f, -0.05288712f, -0.06484360f, -0.02730513f, 0.15985644f, 0.10039135f, -0.03357338f, 0.18364264f, 
    0.05558943f, -0.09563610f, 0.01859773f, 0.15744328f, 0.05122443f, 0.08107033f, -0.03021594f, 0.15214016f, 
    -0.09557170f, -0.15249452f, -0.11317092f, -0.13548411f, 0.13853063f, 0.24055487f, -0.03305697f, 0.00096051f, 
    0.15393209f, -0.02657264f, -0.10234855f, -0.13392897f, -0.02336975f, -0.01761583f, 0.01691980f, -0.03374156f, 
    -0.24256763f, -0.00742472f, 0.10454123f, 0.01287142f, 0.03641337f, -0.17046076f, -0.11962193f, -0.05918669f, 
    -0.11024166f, 0.11129842f, -0.05224545f, 0.08832422f, -0.02249559f, -0.02532169f, -0.12809247f, -0.11807571f, 
    -0.06135701f, -0.09460416f, 0.04738246f, 0.01612090f, -0.07216597f, -0.11135640f, 0.11368965f, -0.09672331f, 
    0.24661766f, -0.00183452f, -0.06198862f, 0.13640080f, -0.17439868f, -0.04029954f, -0.16264054f, -0.00230899f, 
    -0.00347277f, 0.18482278f, -0.14443779f, -0.05905431f, -0.14909437f, -0.55039436f, 0.15031666f, -0.38107890f, 
    -0.05416775f, -0.06603415f, 0.12133650f, -0.05951506f, 0.11463436f, 0.06715602f, 0.03592749f, -0.05165758f, 
    -0.29940039f, 0.06614540f, 0.17869286f, 0.09860001f, -0.04186182f, 0.08543225f, 0.18970910f, -0.12335128f, 
    0.05230933f, -0.29714096f, -0.01150671f, 0.00383106f, -0.19704577f, -0.06201087f, -0.20091657f, -0.17254296f, 
    0.01256854f, 0.17500407f, -0.00708528f, -0.11800761f, 0.10613140f, -0.12186803f, 0.04230260f, 0.03596876f, 
    -0.47063249f, -0.08365240f, 0.23585716f, 0.22684801f, 0.09483815f, -0.00348761f, 0.04072025f, 0.05927213f, 
    0.05497738f, -0.00065456f, 0.15390748f, 0.18860523f, -0.02185213f, 0.29051903f, 0.28436363f, 0.37344468f, 
    -0.14465486f, 0.11377526f, 0.05445127f, -0.01317639f, -0.07975195f, -0.07718173f, 0.15377553f, 0.01930756f, 
    0.31222206f, 0.01058251f, 0.18851590f, -0.00752292f, 0.07858273f, -0.21308914f, -0.07945425f, -0.11958297f, 
    -0.21262354f, -0.06876964f, 0.12999530f, -0.00108440f, 0.09755088f, 0.04505756f, 0.14314876f, 0.05687569f, 
    0.05094865f, 0.08906564f, 0.06106954f, 0.20564102f, 0.01874283f, 0.22462450f, 0.08529188f, 0.10486440f, 
    0.30510861f, -0.23805098f, 0.02333863f, 0.04736257f, 0.04126010f, -0.03920850f, 0.06294982f, 0.03475662f, 
    0.03274653f, 0.15951009f, -0.20128936f, 0.12015265f, -0.18068485f, -0.10077309f, 0.03943566f, 0.10726050f, 
    -0.00907771f, -0.03170004f, 0.05585565f, 0.11067273f, -0.11892985f, -0.11202732f, 0.08552203f, 0.13096085f, 
    0.13474564f, -0.19306912f, 0.18548305f, -0.06055730f, -0.06377741f, 0.01201980f, 0.02169755f, 0.06049964f, 
    -0.06234619f, -0.10256936f, -0.04493863f, 0.09057891f, -0.23830985f, 0.15339558f, 0.08297479f, 0.00334515f, 
    0.10473799f, 0.03817412f, -0.14904296f, 0.02697950f, 0.00148899f, 0.04099476f, -0.00018612f, 0.30653390f, 
    0.14665629f, 0.09038270f, -0.04853015f, 0.12197343f, -0.22194454f, -0.06132003f, 0.00608375f, 0.02892021f, 
    -0.16284586f, -0.12850769f, 0.16031680f, 0.15266785f, 0.21798418f, 0.06091646f, -0.03069270f, 0.06605006f, 
    0.07338042f, -0.08768620f, 0.04985834f, -0.09236385f, -0.02735497f, 0.01846104f, 0.02862725f, 0.01341179f, 
    -0.03407731f, -0.00247215f, -0.29639044f, -0.07151675f, 0.04641517f, -0.03921330f, 0.08845529f, -0.14723584f, 
    -0.22079615f, -0.17843853f, -0.02297851f, -0.06339447f, 0.34864277f, -0.22289844f, -0.11385145f, -0.08874726f, 
    -0.17963293f, -0.18931375f, -0.06873179f, -0.08639031f, 0.00698649f, 0.04506446f, -0.06219872f, -0.04870735f, 
    0.45168155f, -0.11884078f, 0.06962950f, 0.12963578f, -0.22336788f, -0.13738704f, 0.03942527f, -0.02539560f, 
    -0.11362714f, 0.19975170f, -0.08926434f, -0.04525523f, 0.16804887f, -0.46618715f, 0.14420606f, -0.21413319f, 
    -0.05099345f, -0.04953749f, 0.00929523f, -0.15743211f, 0.04682547f, 0.12701002f, -0.00519498f, 0.05102626f, 
    -0.07463107f, -0.01892587f, 0.01521147f, 0.09292622f, -0.36439905f, 0.06545874f, -0.00113793f, 0.17814144f, 
    0.05151903f, -0.10214233f, 0.18419772f, 0.14424390f, 0.32814881f, 0.00908143f, 0.06558996f, 0.05725309f, 
    -0.11497427f, 0.01161329f, 0.04355112f, 0.06870232f, 0.02131943f, -0.06506401f, 0.04127822f, -0.00004841f, 
    -0.32266438f, -0.12209635f, -0.14083667f, -0.19262934f, 0.02051133f, 0.12458450f, -0.05158436f, 0.04005056f, 
    -0.08824972f, -0.17126688f, 0.06791625f, 0.12761022f, -0.08080430f, -0.13799408f, 0.16291662f, 0.15282995f, 
    0.13431545f, 0.04584461f, 0.08030254f, 0.14067246f, -0.18190274f, -0.05687428f, -0.04644745f, -0.20638759f, 
    0.09740540f, -0.03253612f, 0.05964518f, -0.37262982f, 0.02836833f, -0.03110366f, 0.05231969f, 0.09008916f, 
    0.06091114f, -0.10565905f, 0.02486074f, -0.01413072f, -0.43141529f, 0.04825592f, -0.26171169f, -0.24883372f, 
    -0.04921350f, 0.07570260f, 0.05025668f, 0.14042623f, -0.10466974f, 0.12464532f, -0.02824375f, 0.07489865f, 
    -0.12929292f, -0.31514302f, -0.03450010f, -0.14336260f, 0.20805661f, 0.03865588f, 0.03247737f, -0.09012175f, 
    -0.10225572f, 0.06175394f, 0.09755308f, 0.09693141f, 0.26380578f, 0.18535988f, -0.03270127f, 0.26854300f, 
    -0.43856186f, 0.12903047f, -0.03500137f, 0.08064529f, 0.05770287f, 0.01161680f, 0.01679552f, -0.00664713f, 
    0.08943084f, 0.05124407f, 0.05298205f, 0.13785388f, 0.01054771f, 0.08538507f, 0.00573480f, -0.00057628f, 
    -0.06887594f, 0.23145898f, 0.00694836f, -0.07025903f, 0.00281040f, 0.29061607f, 0.01141425f, -0.30856559f, 
    -0.05256171f, -0.13307264f, -0.02721134f, -0.05653748f, 0.14954086f, 0.03101844f, 0.07387025f, -0.10742669f, 
    -0.16315486f, 0.02552421f, 0.19413611f, -0.09842744f, -0.00106947f, -0.04436489f, 0.00938236f, 0.03524670f, 
    -0.18057604f, 0.07087382f, 0.06083479f, -0.17851080f, -0.50540978f, 0.02106227f, -0.24928956f, 0.08271088f, 
    -0.07106354f, -0.18257454f, 0.10345427f, -0.03186212f, 0.04924564f, 0.01725228f, -0.03178308f, 0.07022130f, 
    0.15845288f, 0.17705829f, 0.43488726f, 0.04173410f, 0.13043690f, 0.26606566f, 0.14208122f, -0.00228467f, 
    -0.15628757f, -0.00085425f, 0.03104612f, -0.11714339f, -0.00514720f, 0.23572303f, -0.23148631f, -0.00525764f, 
    -0.07049792f, 0.09633988f, -0.00790363f, 0.09377861f, -0.00120264f, 0.13005058f, -0.17522198f, 0.05396310f, 
    0.32337978f, -0.07091225f, 0.03505232f, -0.30443764f, -0.05529071f, 0.15530954f, -0.10950593f, 0.13723701f, 
    -0.09456518f, -0.05514640f, 0.04810562f, 0.03560659f, -0.12869810f, -0.01226621f, 0.36246568f, -0.39970183f, 
    0.06802148f, 0.17331928f, 0.10059742f, -0.07617801f, -0.07856140f, 0.12429492f, -0.07386329f, -0.07742644f, 
    0.11729437f, 0.09436202f, 0.23382616f, 0.23424105f, 0.28447571f, -0.03653245f, 0.09104549f, 0.08488116f, 
    0.05853149f, -0.00608024f, -0.06340419f, 0.04411558f, 0.06266125f, 0.25366110f, -0.26667857f, -0.83805382f, 
    0.04172178f, 0.03437220f, -0.02305281f, 0.08179077f, 0.04878665f, 0.17862062f, 0.04560108f, 0.19596891f, 
    -0.19678698f, 0.39982709f, -0.05855696f, -0.03082126f, 0.16609989f, -0.00491875f, 0.13865079f, 0.04429554f, 
    -0.01292712f, -0.00778592f, -0.12566175f, -0.13606048f, 0.36791462f, 0.01010510f, -0.02668457f, 0.22782663f, 
    -0.57046753f, -0.05227719f, -0.04185458f, 0.04642282f, 0.22676387f, 0.14354032f, -0.16404329f, -0.00331988f, 
    0.11471909f, -0.00057237f, -0.26544353f, 0.10820761f, -0.06417811f, -0.12001100f, -0.15917608f, -0.00847456f, 
    0.01391272f, -0.04038955f, -0.09250529f, 0.07835319f, 0.05646352f, -0.07321949f, -0.25437370f, 0.17365406f, 
    -0.06418239f, -0.10100106f, -0.08048110f, -0.15036970f, 0.08707184f, -0.14884119f, -0.18388350f, -0.12631707f, 
    -0.17941533f, 0.43162766f, -0.19106601f, -0.05094351f, 0.04292129f, 0.18290263f, 0.06570708f, -0.07044721f, 
    -0.08206408f, 0.17804372f, 0.04175644f, 0.21020275f, -0.01955096f, 0.14473966f, 0.07368384f, -0.48406324f, 
    0.05859273f, -0.07662172f, -0.00456551f, 0.00552388f, -0.04093873f, 0.03471435f, -0.00885472f, 0.13253847f, 
    -0.14246199f, 0.17044641f, -0.04873141f, -0.04364731f, -0.03186110f, 0.15750960f, -0.12412096f, -0.05628540f, 
    0.02997013f, -0.15214188f, -0.04676862f, -0.03668498f, -0.56766790f, -0.19393797f, 0.03531208f, 0.12078178f, 
    -0.02319247f, -0.02049560f, -0.05861834f, 0.02771549f, -0.18209152f, 0.08690848f, -0.01814458f, 0.06350900f, 
    -0.27103028f, 0.21756694f, -0.08914081f, -0.14623785f, 0.03956110f, -0.07040256f, 0.08335706f, 0.01403757f, 
    0.21232744f, 0.16067719f, 0.09036654f, 0.27583832f, -0.13867776f, 0.21630926f, -0.04038753f, 0.14927259f, 
    -0.16051209f, -0.13167660f, 0.01312407f, 0.04220507f, 0.04572567f, -0.00037595f, 0.02501880f, 0.02020149f, 
    -0.03863152f, -0.19113795f, -0.04782528f, -0.07778443f, -0.02803599f, 0.19136098f, -0.09790230f, 0.02326044f, 
    -0.10954434f, -0.10913698f, -0.10392494f, 0.00555524f, 0.41112983f, 0.31014594f, 0.00228988f, 0.28086421f, 
    0.18135899f, 0.19542362f, 0.03082372f, 0.16846842f, -0.01111180f, 0.02536491f, -0.02881943f, 0.10719325f, 
    -0.08842479f, 0.31209600f, 0.12329445f, -0.02796095f, 0.26059532f, 0.01253670f, -0.07718427f, 0.10665369f, 
    0.08275613f, -0.01713315f, 0.16365668f, 0.09236826f, 0.19891107f, 0.26731870f, -0.08022289f, 0.17086887f, 
    0.02683954f, 0.01391284f, -0.01237352f, -0.00032009f, 0.11136486f, -0.07936214f, -0.01579713f, 0.04272217f, 
    0.19692275f, -0.10328250f, 0.02560182f, -0.22192901f, 0.08653173f, -0.03700088f, -0.02711583f, 0.05242215f, 
    -0.01029144f, 0.00687940f, -0.00957614f, 0.08592737f, -0.15375210f, -0.10023329f, 0.10816815f, -0.16090249f, 
    0.01931147f, 0.05222786f, 0.10050032f, -0.21837562f, -0.08755643f, 0.09982178f, -0.01607991f, 0.01365749f, 
    0.48814470f, -0.06370738f, -0.08980503f, 0.02843879f, -0.00123531f, 0.00079347f, 0.14136739f, 0.13993002f, 
    0.03518866f, -0.04434961f, -0.08168589f, 0.08464002f, 0.23636691f, 0.07277565f, -0.10169086f, -0.09384201f, 
    -0.13822640f, -0.02880187f, -0.03457985f, -0.13616897f, -0.08781503f, -0.01817668f, 0.18537225f, 0.06816203f, 
    0.07919990f, -0.26605967f, 0.16308162f, -0.12487110f, 0.06496190f, 0.15893482f, 0.00804232f, 0.19844301f, 
    0.12210836f, 0.12809229f, -0.06168607f, 0.07217357f, 0.04143009f, 0.12449186f, 0.13585077f, -0.30243596f, 
    -0.15627687f, -0.01338289f, 0.14422145f, 0.04051828f, -0.16195339f, 0.11065193f, 0.14531910f, 0.09168008f, 
    -0.11613140f, -0.35135275f, 0.09868320f, -0.09215344f, 0.02267375f, 0.01984369f, 0.04284944f, 0.02297712f, 
    0.18249737f, -0.02580814f, 0.09901079f, 0.07568961f, -0.16054198f, -0.05214805f, -0.28403920f, 0.24220951f, 
    0.07892597f, 0.04522694f, 0.01582971f, -0.10138790f, 0.17392875f, 0.06784804f, 0.05314534f, 0.05399320f, 
    -0.16149826f, 0.00051809f, 0.08082666f, -0.00051041f, 0.03360909f, 0.00051496f, 0.07888357f, 0.00420456f, 
    0.02476907f, 0.04012844f, 0.03918025f, 0.20313039f, 0.16917808f, 0.44045156f, -0.04741852f, -0.22378133f, 
    -0.07481622f, 0.12339927f, -0.07297401f, 0.01812770f, -0.04130811f, -0.05130903f, -0.01103488f, -0.18197851f, 
    0.26552296f, 0.17266998f, 0.16433428f, 0.20961513f, -0.03778540f, -0.01948974f, -0.06170884f, -0.00391891f, 
    -0.07495026f, 0.03062690f, 0.13023382f, -0.12162912f, -0.24232557f, -0.19823048f, -0.24510913f, -0.29584917f, 
    0.03491068f, 0.09645212f, 0.19820932f, -0.03638210f, 0.02223065f, -0.03560023f, -0.01043400f, 0.13264520f, 
    0.37066826f, 0.22001618f, 0.10784448f, 0.24732523f, 0.17432104f, -0.03708965f, 0.27493107f, 0.04072254f, 
    0.12121351f, 0.00728389f, 0.17140041f, -0.15624779f, -0.15362690f, -0.14426912f, -0.01898388f, -0.12256664f, 
    0.05862384f, 0.09803320f, -0.00781320f, 0.00709746f, 0.01642978f, 0.12085658f, 0.06103648f, 0.02577744f, 
    0.23928598f, -0.21463121f, -0.04105486f, -0.04437681f, -0.04899187f, 0.07256314f, 0.03943825f, 0.07580500f, 
    -0.06429764f, -0.01908044f, 0.02261099f, 0.04369805f, -0.08964280f, 0.19584019f, 0.21657422f, 0.04088106f, 
    -0.00725009f, 0.09761025f, 0.12304595f, -0.08226120f, -0.03646965f, 0.04574849f, -0.01885710f, 0.01204519f, 
    -0.02581544f, 0.00215613f, 0.07369843f, 0.27314952f, 0.02503095f, 0.11085036f, -0.16461550f, 0.15514153f, 
    0.07601830f, 0.30468750f, -0.00730071f, -0.05069029f, 0.37942511f, 0.33177960f, -0.04179771f, 0.12401418f, 
    -0.21507825f, -0.18058817f, 0.08073962f, 0.06150702f, -0.07537446f, 0.05423442f, 0.06984236f, -0.04650510f, 
    -0.25942340f, 0.21740048f, -0.07379068f, -0.06614510f, 0.19786526f, 0.06798271f, 0.03100640f, 0.08571553f, 
    -0.06173119f, 0.00755795f, -0.06257146f, -0.16070324f, -0.05609268f, -0.45485076f, -0.24450991f, -0.01451499f, 
    0.02266701f, 0.02505931f, -0.05396572f, 0.06741808f, 0.07610279f, 0.12031789f, -0.02315819f, -0.07516971f, 
    -0.04998730f, -0.04992694f, 0.00175711f, -0.00119794f, 0.01477089f, 0.05424401f, 0.02293087f, -0.06971242f, 
    -0.01408056f, -0.01523797f, -0.05799027f, -0.05534765f, 0.04308229f, 0.00849118f, -0.04267137f, -0.02116162f, 
    -0.03296587f, -0.03543741f, -0.03309221f, -0.06456283f, -0.05474302f, -0.04385738f, -0.06767784f, -0.00975688f, 
    -0.00773541f, -0.01812968f, 0.01054402f, -0.04834458f, -0.00741998f, -0.07796305f, -0.02918205f, 0.02475235f, 
    -0.06503599f, 0.03193229f, 0.01136654f, -0.03065619f, -0.01488405f, 0.06337523f, -0.07522192f, 0.03060221f, 
    -0.05437339f, 0.03552051f, -0.03734724f, 0.00832596f, 0.01857021f, 0.01705957f, -0.03147983f, 0.02367430f, 
    -0.03279271f, -0.02326606f, -0.01609186f, 0.05348277f, -0.00617495f, -0.00772242f, 0.00936759f, -0.02148668f, 
    -0.04137640f, 0.00603726f, -0.03931620f, -0.02813681f, 0.02816566f, -0.00794384f, -0.00369167f, -0.04019663f, 
    -0.01966542f, -0.04247852f, 0.02800599f, 0.02893400f, 0.02298733f, -0.07211088f, -0.01934398f, -0.02335938f, 
    0.02322158f, -0.00103985f, -0.04577848f, -0.06522443f, -0.01480808f, -0.00667269f, -0.05094020f, 0.02253150f, 
    0.05374122f, -0.02688020f, 0.06478428f, 0.03968564f, 0.04897078f, -0.03083726f, -0.04620036f, 0.02129674f, 
    -0.07621326f, 0.02682808f, 0.05480627f, -0.06176785f, 0.03320674f, -0.04889158f, -0.02703852f, -0.05569675f, 
    0.03755923f, -0.04657304f, -0.02296758f, 0.02109585f, -0.01190144f, -0.02728482f, 0.00320651f, 0.03523918f, 
    -0.07699919f, -0.02011962f, -0.00258682f, -0.01674188f, -0.06835676f, -0.04487103f, 0.06288227f, 0.02273389f, 
    0.05987300f, -0.00109685f, 0.06123832f, 0.03604958f, -0.00677266f, -0.06295380f, -0.06690393f, -0.01372255f, 
    -0.06461627f, -0.00744879f, 0.00548989f, -0.06534193f, -0.05324183f, 0.03501852f, 0.05063998f, -0.00029603f, 
    -0.04337307f, 0.06587838f, -0.05729573f, -0.04409628f, 0.02149548f, -0.02485443f, 0.00507102f, 0.00867466f, 
    -0.01212795f, 0.03792651f, -0.03168240f, 0.04948854f, 0.05595755f, -0.02347524f, 0.05251545f, -0.05510201f, 
    -0.02339756f, -0.06502502f, -0.01293564f, -0.04973917f, -0.03339553f, -0.03662832f, 0.04800805f, 0.00284821f, 
    0.00795166f, 0.05513608f, 0.00796915f, -0.02083152f, -0.05625699f, -0.00188689f, 0.00346557f, 0.05282491f, 
    0.05721020f, 0.02174360f, -0.07135719f, 0.03662375f, -0.00927315f, -0.03182055f, 0.05839449f, -0.00126699f, 
    -0.04309075f, 0.01679974f, 0.05670234f, -0.06770504f, -0.06627202f, -0.05612258f, 0.00205489f, -0.01211241f, 
    -0.06097032f, -0.03855588f, 0.04798649f, 0.01286031f, 0.02329319f, -0.02000395f, 0.05519743f, -0.04393456f, 
    0.04822335f, -0.03109962f, -0.03747864f, 0.06176644f, 0.04264898f, -0.01493147f, 0.01264337f, -0.06703927f, 
    0.25317168f, -0.21718362f, 0.29683399f, 0.59489208f, 0.05968824f, -0.31520098f, 0.08764210f, 0.10620570f, 
    0.12434670f, 0.03913072f, 0.17519620f, 0.10379949f, 0.23055160f, 0.02833122f, 0.00618313f, 0.23868059f, 
    -0.03069768f, 0.10301471f, -0.05956925f, 0.04337774f, 0.27403918f, -0.06379190f, 0.01286002f, -0.01330905f, 
    0.05278757f, 0.12878104f, -0.26615804f, -0.18080150f, -0.04696595f, 0.14497489f, 0.16314690f, -0.06876726f, 
    -0.16398177f, -0.09373656f, 0.01949622f, 0.08172799f, 0.31477734f, 0.34949777f, 0.19382364f, -0.15857193f, 
    -0.03223088f, -0.03264567f, 0.01771012f, 0.10855463f, 0.16289654f, 0.04609079f, -0.07479882f, -0.00903550f, 
    0.64660144f, 0.18739806f, 0.19387035f, 0.14843304f, 0.02102268f, 0.21811266f, -0.02183988f, 0.12318607f, 
    0.12276081f, -0.10891555f, 0.03322090f, -0.00873134f, -0.43732992f, 0.51721740f, 0.12180601f, 0.04519643f, 
    -0.04133714f, -0.11494992f, 0.13380456f, -0.02665223f, -0.00261989f, 0.10465906f, -0.23943569f, 0.09378932f, 
    -0.00464343f, 0.13553987f, -0.14051016f, -0.08082854f, 0.26267996f, -0.05271069f, -0.23755133f, 0.13109298f, 
    -0.07827224f, 0.09058518f, 0.10383118f, 0.02083985f, -0.28871003f, -0.15838234f, 0.06496654f, 0.04185609f, 
    -0.10237703f, -0.05298202f, 0.11888555f, 0.13848977f, 0.01313427f, 0.04866162f, 0.25454903f, -0.21232542f, 
    -0.01364680f, -0.05857028f, 0.30753526f, 0.12326840f, -0.07229117f, -0.04733841f, -0.01480520f, 0.00614254f, 
    -0.11566246f, 0.05622242f, -0.09413371f, 0.20559640f, 0.01770899f, -0.24828042f, -0.17759761f, 0.23847896f, 
    0.21186683f, 0.09230272f, 0.02171336f, 0.05228211f, 0.12816153f, 0.05889477f, 0.07893341f, 0.00937011f, 
    0.33537433f, 0.38577840f, -0.23988155f, 0.19615534f, 0.14409889f, -0.09692126f, -0.05371815f, -0.04708687f, 
    0.07139020f, 0.13573681f, 0.00683012f, -0.01935554f, 0.22452356f, 0.07679034f, -0.09549107f, -0.13022964f, 
    0.10646802f, -0.21883832f, 0.15386997f, -0.08519696f, 0.08701736f, 0.06564657f, 0.12302192f, -0.09611492f, 
    -0.44979057f, 0.18922077f, -0.12551840f, -0.18518144f, 0.11531808f, 0.06804879f, 0.09175719f, 0.22267884f, 
    0.04313778f, -0.21968330f, -0.10968363f, -0.09802368f, -0.27953857f, 0.42072949f, -0.03429772f, -0.06726785f, 
    0.26228809f, 0.23009223f, 0.22270708f, -0.25963232f, -0.00550550f, 0.20450835f, 0.10417095f, -0.09759807f, 
    0.16670114f, 0.23982547f, 0.16922766f, 0.70325089f, -0.13447154f, -0.07983071f, 0.15377566f, 0.02573543f, 
    -0.05257683f, 0.05032180f, -0.10815953f, 0.11259910f, 0.35600320f, -0.27966344f, 0.03912241f, 0.33406699f, 
    -0.27983978f, 0.02813036f, 0.16638091f, 0.08170213f, 0.03654456f, 0.06993604f, 0.04503082f, 0.16981685f, 
    -0.10236307f, 0.00830965f, 0.05861856f, -0.01485464f, -0.01735293f, 0.08534513f, 0.12034602f, 0.15164913f, 
    0.01396411f, -0.07504273f, -0.08479130f, 0.06992424f, -0.30294690f, -0.03912138f, 0.16685539f, -0.19338368f, 
    -0.03686394f, 0.01326414f, 0.04313089f, 0.11019117f, -0.00874805f, 0.03281132f, -0.13375430f, 0.11579928f, 
    -0.00299890f, 0.25116760f, -0.01089299f, 0.03078424f, 0.10309398f, -0.11926960f, -0.02262854f, 0.08140393f, 
    0.01526976f, 0.11933761f, 0.12364569f, -0.10995635f, -0.00987932f, 0.03467922f, -0.25798219f, 0.27619070f, 
    0.11630639f, 0.17412476f, -0.02644782f, -0.03080161f, 0.11881231f, -0.13123943f, -0.03932151f, -0.01143531f, 
    0.29791433f, -0.02941557f, 0.02825752f, 0.02393328f, 0.08687650f, 0.04097912f, -0.03637546f, -0.07601555f, 
    0.02193729f, -0.12368224f, -0.11293533f, -0.07760888f, 0.72296339f, -0.14571540f, -0.13530730f, -0.18044510f, 
    -0.04724403f, 0.16048075f, 0.01350940f, 0.06542835f, 0.07316744f, -0.05021439f, -0.06108508f, -0.03323556f, 
    -0.20021586f, -0.27122796f, -0.07682600f, 0.13342151f, -0.03666607f, 0.00971399f, 0.12395713f, 0.02474060f, 
    0.11813407f, 0.07340539f, 0.09909848f, -0.02341737f, 0.26859140f, -0.23381378f, 0.27752635f, -0.23034710f, 
    0.09419115f, 0.04790122f, 0.07645372f, 0.07482834f, -0.01963076f, 0.01785465f, 0.08716360f, 0.04327790f, 
    0.29187632f, -0.07116952f, 0.04531255f, 0.20168231f, -0.03781075f, 0.04761493f, 0.08678687f, -0.06298722f, 
    0.26772800f, -0.06471929f, 0.23832251f, 0.01246762f, -0.10410263f, -0.05015288f, 0.32238585f, -0.28821394f, 
    -0.06574740f, -0.02451633f, 0.18075579f, -0.16148831f, -0.06964373f, -0.07562517f, 0.04940549f, -0.03601632f, 
    0.02249923f, -0.18598060f, 0.13217488f, -0.12930995f, 0.05156308f, -0.19398005f, 0.21937981f, -0.05024324f, 
    -0.14204107f, -0.01366136f, -0.03253278f, -0.06743580f, 0.25324312f, 0.17901714f, -0.00509636f, 0.06500123f, 
    0.06787154f, 0.07881121f, 0.01251332f, -0.04879570f, 0.00297352f, -0.00329027f, 0.04573721f, 0.13598008f, 
    0.03640867f, 0.10901867f, -0.25279975f, 0.18203467f, 0.10731024f, -0.02707521f, -0.04466875f, 0.09670436f, 
    0.06840204f, 0.25056070f, 0.08647111f, -0.00197668f, 0.08260511f, 0.23507424f, -0.15125751f, 0.41333470f, 
    0.21692033f, -0.05734548f, 0.06116188f, 0.39219838f, 0.08901112f, 0.10414249f, -0.08937803f, 0.20433640f, 
    0.05299279f, -0.03390301f, -0.20045742f, -0.09721148f, -0.13751517f, 0.12786891f, -0.09748743f, -0.15081973f, 
    -0.06264558f, 0.01992838f, 0.09274492f, -0.14953054f, 0.18215100f, -0.10846502f, -0.17389506f, -0.00210960f, 
    0.23760927f, 0.09528330f, 0.08183243f, 0.02291933f, 0.02687905f, 0.06413741f, -0.16916905f, 0.15758899f, 
    -0.14196071f, 0.14163142f, -0.13895588f, 0.04120184f, -0.00361035f, 0.14181162f, -0.06569546f, 0.07201903f, 
    0.10452420f, -0.14882557f, -0.13955110f, 0.15534686f, 0.20901535f, 0.16601069f, 0.19844094f, 0.11974993f, 
    0.12073517f, 0.00109707f, -0.03238313f, 0.00225550f, 0.04455628f, 0.02256827f, -0.23568405f, -0.03071884f, 
    0.15395802f, 0.34014443f, 0.00078968f, 0.01056334f, -0.07418274f, -0.00655121f, 0.05934123f, 0.01610240f, 
    -0.01630229f, 0.06305192f, 0.22370230f, 0.14038062f, 0.02932398f, 0.01876816f, -0.10099568f, -0.08459118f, 
    0.10099738f, 0.10687897f, -0.03735541f, -0.16245091f, -0.03854242f, -0.17894103f, -0.03860771f, 0.00263291f, 
    0.15838854f, -0.05845241f, -0.04232227f, 0.04586750f, -0.05853228f, 0.13097130f, 0.08246036f, -0.12988245f, 
    -0.11409673f, 0.06639539f, 0.13383500f, 0.01082217f, 0.38901496f, -0.19532263f, 0.09117712f, 0.26711467f, 
    0.16239502f, -0.02210803f, -0.07775711f, 0.05787536f, -0.12247150f, 0.03920091f, 0.02765674f, 0.02812611f, 
    0.12977375f, -0.01065237f, 0.09138409f, 0.03296901f, -0.04766149f, 0.08529591f, -0.07198107f, -0.04029018f, 
    0.12604547f, -0.07032430f, 0.08567416f, 0.30485359f, -0.20337127f, -0.11332192f, 0.19346420f, -0.06736385f, 
    0.05457791f, -0.01303956f, 0.07495534f, 0.13701902f, 0.10466331f, 0.13391870f, -0.05340409f, 0.10395475f, 
    -0.10511348f, 0.05763880f, -0.08567023f, 0.03381896f, -0.08344536f, 0.02723093f, 0.05332155f, -0.00719189f, 
    0.23374844f, -0.06310380f, 0.12540533f, -0.04353615f, -0.30480698f, -0.06813835f, 0.12152688f, -0.06575718f, 
    -0.01652841f, 0.09148567f, 0.02467301f, -0.02218924f, -0.04279622f, 0.00063330f, -0.04885920f, -0.02886633f, 
    -0.04033974f, 0.19225816f, 0.08220141f, 0.02938787f, 0.02663513f, 0.15563419f, 0.10772033f, 0.03381472f, 
    -0.05562308f, -0.06004899f, 0.15033267f, 0.01394591f, 0.24610502f, 0.40673175f, -0.10954973f, 0.29499948f, 
    -0.06288416f, 0.24071810f, -0.02533775f, 0.22527438f, -0.01872918f, 0.09001085f, 0.01548400f, 0.05434935f, 
    0.59537989f, -0.07729984f, 0.02426499f, 0.03395673f, 0.05278838f, -0.01485231f, 0.02314175f, 0.08894235f, 
    0.00958143f, 0.07318654f, -0.08070461f, 0.14599536f, -0.05897701f, 0.08130872f, 0.29858634f, 0.35350847f, 
    0.05349934f, -0.05531289f, 0.04661818f, 0.15148298f, -0.02831191f, -0.00815790f, 0.14248544f, 0.09522738f, 
    -0.08827054f, -0.47760516f, 0.12707858f, -0.08008620f, -0.09769014f, -0.12574016f, -0.10370285f, -0.07378338f, 
    0.01386971f, 0.00455316f, 0.07315892f, -0.08466174f, -0.17217620f, 0.23427156f, -0.06854101f, -0.41389930f, 
    0.16299698f, 0.05466744f, -0.15477790f, 0.01264646f, -0.16149563f, 0.15046397f, -0.09882848f, -0.13154824f, 
    0.05270015f, 0.01070855f, -0.06955295f, -0.00111141f, -0.08546414f, -0.06117652f, 0.05606034f, -0.02532575f, 
    0.00711453f, -0.05185702f, -0.07535049f, 0.00642190f, -0.03235133f, -0.06011608f, -0.07082675f, 0.03871403f, 
    -0.00656021f, -0.03389599f, -0.03800559f, -0.01028144f, -0.06397367f, -0.02078788f, -0.05396571f, 0.04754070f, 
    0.05176246f, -0.06216110f, -0.06439615f, -0.00457330f, 0.05669588f, -0.04718198f, 0.02938615f, 0.03355540f, 
    0.00335801f, 0.02150773f, -0.07169909f, 0.04562993f, 0.00359260f, -0.00079111f, -0.05698660f, -0.02647657f, 
    0.02197902f, -0.01365662f, 0.05373795f, -0.05462863f, 0.03274712f, -0.02272115f, 0.00264666f, -0.06368390f, 
    -0.00773306f, 0.00594088f, 0.00860850f, 0.03459945f, -0.02507499f, 0.03331069f, 0.00602354f, 0.03520640f, 
    0.04486045f, 0.04261978f, -0.01613244f, 0.05304113f, -0.00461167f, -0.05114837f, 0.03873454f, 0.01994747f, 
    0.02298324f, -0.03317774f, 0.02279889f, 0.06150496f, 0.04837721f, -0.04102347f, -0.03306107f, -0.07352689f, 
    -0.02213327f, 0.02869062f, -0.07982118f, -0.05387269f, -0.05832839f, 0.01031900f, -0.02187712f, -0.03958317f, 
    -0.03793003f, -0.04968374f, -0.03060592f, -0.07778437f, -0.04881068f, 0.02406329f, -0.01677390f, 0.00009737f, 
    -0.00191220f, 0.02046209f, 0.01188080f, -0.03008915f, -0.07237297f, 0.03963039f, -0.06988785f, -0.00863149f, 
    -0.02514849f, 0.01818674f, 0.05500536f, -0.05223377f, 0.00102370f, 0.00368429f, -0.05423241f, -0.01762743f, 
    0.00934682f, 0.02266770f, 0.04664682f, 0.03828491f, 0.00346994f, -0.00534892f, 0.01488429f, 0.04061234f, 
    0.04694118f, 0.06495301f, -0.04042754f, 0.02150831f, -0.02656325f, -0.02910979f, 0.04831684f, -0.06571529f, 
    -0.00153195f, -0.05724646f, -0.03315305f, -0.08293562f, 0.03308656f, -0.07163985f, 0.04352608f, -0.08000199f, 
    -0.02314945f, 0.00446860f, 0.05698229f, -0.08663774f, -0.07879928f, -0.07315497f, -0.00429571f, 0.05171494f, 
    -0.03900733f, 0.05240909f, -0.07617545f, 0.02966178f, -0.07178924f, 0.04783482f, -0.06555489f, -0.06949028f, 
    0.00234253f, -0.02056813f, -0.00774085f, -0.03864326f, -0.06168187f, 0.05520133f, 0.01702473f, -0.01879310f, 
    -0.04740425f, -0.04068669f, 0.00222554f, -0.07101245f, 0.07394154f, 0.03156865f, 0.02090808f, -0.05630206f, 
    -0.05802361f, -0.07824369f, -0.02767425f, -0.01837960f, 0.01681597f, -0.06914257f, -0.06135622f, -0.04827888f, 
    -0.02945587f, 0.06095189f, -0.04382587f, -0.04993074f, 0.03242418f, -0.05795037f, -0.01199074f, -0.04062128f, 
    0.03997653f, -0.01532638f, 0.01220281f, -0.01057589f, 0.02506397f, 0.04066779f, -0.01361885f, -0.06533977f, 
    0.01457529f, -0.05824102f, -0.02409220f, 0.03829839f, -0.02379470f, 0.06133568f, -0.01266759f, -0.06386698f, 
    -0.02087803f, -0.02246186f, -0.06235598f, -0.02581482f, -0.08654961f, 0.00636996f, -0.07163591f, -0.03687406f, 
    -0.03303019f, 0.22675385f, 0.04672128f, -0.07343602f, 0.05179979f, 0.15666392f, -0.12192409f, -0.08351338f, 
    -0.03981635f, -0.00038672f, 0.03033722f, 0.05844053f, -0.08168716f, 0.01269479f, 0.22036149f, 0.01121416f, 
    0.30130482f, -0.29783809f, 0.07886317f, -0.02279013f, -0.03390016f, 0.00628499f, 0.00290849f, -0.04070015f, 
    -0.01301893f, -0.06716132f, -0.18291923f, -0.22995573f, -0.08659109f, -0.16940413f, -0.16713710f, 0.18053325f, 
    0.23635815f, -0.14460236f, -0.01197571f, 0.00667080f, 0.15276718f, 0.09664536f, 0.21232155f, -0.11303123f, 
    -0.15769456f, -0.09746507f, 0.09023616f, 0.00934532f, 0.07303159f, -0.03172193f, -0.10318030f, 0.14422798f, 
    0.06819636f, -0.03510873f, 0.01399202f, 0.22825696f, -0.32107583f, 0.29723370f, -0.11914053f, 0.05543361f, 
    0.04776506f, -0.03085095f, 0.03129731f, 0.01697204f, 0.08915287f, 0.00777898f, -0.03593357f, -0.00587531f, 
    0.14756073f, 0.07425554f, 0.17072059f, 0.04580747f, 0.09558118f, 0.08653697f, 0.05364619f, 0.07005456f, 
    -0.03989469f, -0.10029414f, -0.13110587f, -0.24328494f, 0.41714525f, 0.12014803f, -0.26198518f, -0.23409677f, 
    -0.03924537f, 0.07655854f, -0.04239988f, -0.15026166f, -0.05807154f, -0.08776153f, -0.04888757f, -0.06670602f, 
    -0.08893199f, -0.02316154f, -0.09035508f, -0.00633131f, 0.10750766f, -0.19669721f, -0.03865210f, 0.06741322f, 
    -0.03985224f, 0.03921926f, 0.06603801f, 0.01782245f, 0.11172120f, 0.22235183f, -0.10525674f, -0.10173497f, 
    0.08956765f, -0.04773540f, 0.02666920f, -0.07269663f, 0.13108160f, -0.08155356f, 0.12886526f, 0.15519859f, 
    -0.22369532f, 0.05322175f, -0.04001547f, -0.03705382f, 0.09557935f, 0.00885372f, 0.05517206f, 0.06697832f, 
    0.06677966f, 0.19570819f, -0.10395422f, 0.00513553f, -0.03392154f, 0.03723988f, -0.00691338f, -0.12419321f, 
    0.11167616f, -0.02975253f, 0.05480955f, 0.01462259f, 0.07399791f, 0.01354431f, -0.04335641f, -0.07009940f, 
    -0.30354369f, 0.07085104f, 0.11404948f, 0.22503752f, -0.04995940f, 0.13921182f, -0.02548543f, 0.00127027f, 
    -0.10794726f, -0.00385722f, 0.17218107f, -0.04778437f, 0.45153466f, 0.21099213f, 0.19857538f, 0.14219372f, 
    -0.11972598f, 0.10013828f, 0.05715400f, 0.02403591f, 0.07706209f, 0.08953707f, -0.04320579f, -0.09438413f, 
    0.10382985f, 0.10376382f, -0.17744939f, 0.04558861f, 0.08996005f, -0.01453485f, -0.02044989f, 0.03670310f, 
    -0.08353492f, -0.01239463f, 0.08890617f, 0.21880244f, -0.10822421f, -0.21386451f, 0.03246034f, 0.26507968f, 
    0.20124227f, 0.02583250f, 0.03411239f, -0.13893472f, 0.02880187f, -0.12050876f, 0.01120255f, 0.13411359f, 
    -0.02766117f, 0.21456487f, -0.16169217f, 0.08024172f, 0.04944518f, -0.02260939f, 0.09206074f, -0.00726163f, 
    0.07419153f, 0.15527789f, 0.07362394f, 0.08256448f, -0.03308399f, -0.07222845f, -0.09790208f, -0.13290758f, 
    0.18206209f, 0.07525348f, 0.00277223f, 0.04027444f, -0.02970276f, -0.03187776f, 0.10047138f, -0.02865821f, 
    -0.25358239f, 0.05072442f, 0.00179741f, -0.06098337f, -0.08965143f, -0.07935709f, 0.04712193f, -0.03846129f, 
    0.12604129f, -0.05970210f, -0.04696549f, -0.09307443f, -0.14138810f, -0.07154855f, 0.11656059f, 0.04491388f, 
    0.15543526f, -0.09661998f, 0.02245947f, 0.08539964f, -0.00385524f, 0.12545645f, 0.00524064f, 0.11612961f, 
    -0.23131411f, -0.09472317f, -0.10031492f, 0.10598850f, 0.10442942f, -0.13603091f, 0.05502056f, 0.13967896f, 
    0.03840785f, 0.08966550f, 0.06033498f, -0.04570622f, 0.13057442f, -0.36114296f, -0.10234176f, 0.05891137f, 
    -0.05831761f, 0.03151615f, 0.08779642f, 0.05498391f, -0.09756911f, 0.03135012f, 0.00845363f, 0.03908196f, 
    -0.11037805f, -0.10221262f, -0.02003803f, -0.13832363f, 0.07359525f, 0.05907360f, 0.27011442f, 0.05111689f, 
    0.14676437f, -0.03568669f, -0.09744610f, -0.01592063f, 0.47982609f, 0.15104172f, -0.03945074f, 0.19530325f, 
    0.14476599f, 0.14941505f, -0.08596884f, -0.04673307f, 0.15597695f, 0.05231870f, -0.00289799f, 0.10035778f, 
    -0.11508674f, -0.03932276f, -0.11209389f, -0.14714836f, 0.05301397f, -0.06920769f, -0.10831618f, 0.09329550f, 
    -0.00136743f, 0.11758663f, -0.02400513f, 0.13592808f, 0.14446595f, 0.27103207f, 0.15490949f, 0.08510000f, 
    0.06666260f, 0.11479574f, 0.11198429f, -0.08674125f, 0.11374591f, -0.05211493f, 0.19028869f, 0.01150671f, 
    -0.45200971f, 0.00004091f, 0.19776243f, -0.00725363f, 0.13406800f, 0.05970875f, 0.02459236f, -0.04262834f, 
    0.13535859f, 0.13149714f, -0.04434169f, 0.02568900f, -0.30401123f, -0.21694005f, -0.13975720f, 0.09174629f, 
    0.04649378f, 0.03763365f, 0.02607726f, 0.20887497f, 0.12094373f, -0.00828175f, 0.08704297f, 0.02580508f, 
    0.05945029f, -0.15307510f, 0.05552125f, -0.01545947f, 0.02299464f, 0.09991152f, 0.05125429f, 0.05555030f, 
    0.01454916f, -0.00262808f, 0.06905776f, 0.17656907f, -0.16597573f, -0.45191333f, -0.03568738f, 0.01548034f, 
    0.04500824f, -0.05279155f, -0.07220446f, 0.10394105f, 0.07507830f, -0.13181214f, -0.18567853f, 0.06376343f, 
    0.17386025f, -0.05907285f, 0.05445100f, -0.18677807f, -0.05669646f, 0.11382917f, 0.06582198f, 0.05966503f, 
    0.05407940f, 0.04725589f, 0.12328668f, 0.22028905f, -0.08581941f, 0.26075426f, 0.12601429f, -0.29148716f, 
    0.18468729f, 0.01167991f, -0.01239890f, -0.13162239f, -0.04925768f, -0.04006944f, 0.15694623f, 0.02547908f, 
    -0.02440556f, 0.04452585f, -0.05555752f, -0.08295104f, -0.04109550f, -0.06517982f, -0.05723250f, 0.04237260f, 
    0.02399728f, -0.05037773f, 0.05894377f, -0.04603115f, -0.01069530f, 0.03430341f, -0.06705698f, -0.01515904f, 
    -0.02369224f, 0.05231164f, -0.04085570f, -0.03918552f, -0.01161603f, 0.03640010f, 0.01003081f, -0.02544592f, 
    -0.05815235f, -0.01379966f, 0.01783228f, 0.00309794f, -0.06638280f, 0.00563602f, 0.03749029f, 0.04794642f, 
    -0.02169834f, 0.02477947f, -0.06990663f, -0.00484838f, -0.01660376f, -0.01010711f, 0.00619830f, -0.09350670f, 
    -0.06519650f, -0.01941815f, -0.07627176f, -0.03252858f, -0.08019455f, -0.08351650f, 0.01943825f, -0.05596744f, 
    0.05561508f, -0.03092412f, -0.07851011f, -0.07634342f, -0.04891777f, 0.05124477f, -0.07107847f, -0.02252995f, 
    0.04447892f, -0.01461062f, -0.06017787f, 0.06662078f, -0.07509577f, -0.01689529f, 0.00030618f, -0.07301797f, 
    -0.06989579f, -0.05732876f, -0.05897896f, 0.03696190f, 0.01142660f, -0.05369222f, 0.03396716f, 0.06104935f, 
    -0.05124595f, -0.05413849f, 0.05511033f, 0.01454196f, -0.04960411f, -0.00898515f, -0.05363636f, -0.01974355f, 
    -0.02640462f, -0.02292456f, -0.07769942f, 0.03311761f, 0.03319436f, -0.06496899f, 0.04660846f, -0.05443089f, 
    0.04103941f, 0.04316850f, -0.05340340f, -0.02652430f, -0.02390848f, 0.01560695f, 0.03053525f, -0.08139852f, 
    0.00518526f, 0.03484575f, -0.05043329f, -0.00419206f, -0.00476825f, 0.05524563f, -0.06194481f, 0.01509709f, 
    -0.04027209f, 0.03529230f, -0.03560627f, -0.01149396f, -0.00423227f, 0.03900844f, 0.01880339f, -0.06352986f, 
    -0.06194657f, -0.00671881f, -0.06979484f, 0.01764519f, -0.02131083f, -0.01016124f, 0.03351995f, -0.06340863f, 
    -0.03617450f, -0.06998505f, 0.00452642f, -0.03870281f, -0.00162886f, 0.01879224f, -0.02351303f, 0.04076416f, 
    0.02412378f, -0.06957662f, -0.02682549f, 0.00147627f, -0.04511067f, 0.03805727f, 0.01927039f, -0.03454209f, 
    -0.03687169f, 0.03101636f, 0.01267044f, 0.01474354f, -0.02297711f, 0.02095300f, -0.07845758f, -0.06727536f, 
    0.04744143f, 0.01891117f, -0.00208632f, -0.05979599f, -0.07354628f, 0.01900956f, 0.04399472f, -0.02742816f, 
    -0.05767637f, 0.02927513f, 0.01286591f, -0.02755383f, -0.06433158f, -0.00566417f, 0.01084314f, 0.02403952f, 
    0.01477911f, -0.03839051f, -0.05218979f, 0.04719887f, 0.04247916f, -0.01717440f, -0.04299527f, -0.04139644f, 
    0.03465052f, 0.02361015f, -0.03700008f, 0.01045270f, -0.00782240f, -0.05846757f, 0.05697659f, 0.04034910f, 
    -0.04580289f, -0.02271137f, -0.05551840f, -0.07857655f, 0.00171401f, -0.05241220f, 0.04060867f, -0.06187570f, 
    0.03578500f, 0.04477714f, 0.04389964f, 0.03043072f, 0.03055372f, -0.04020658f, -0.03056917f, -0.00867337f, 
    0.02156561f, -0.03244358f, -0.01625423f, -0.05061061f, 0.03930620f, -0.02427595f, 0.03734354f, -0.05018337f, 
    -0.03524187f, -0.07538491f, 0.05485842f, 0.00209979f, 0.05284343f, 0.03634265f, 0.01612852f, -0.06740699f, 
    0.01840631f, 0.02518086f, -0.00889556f, 0.01279131f, -0.07380378f, -0.05270015f, -0.05921044f, 0.03598398f, 
    -0.04899655f, -0.03294578f, -0.03083091f, -0.01935831f, -0.02648479f, -0.07153487f, -0.00898079f, 0.01757783f, 
    0.04588625f, -0.03302793f, -0.04477205f, 0.01106935f, -0.03734910f, 0.03606284f, 0.01518435f, -0.01318357f, 
    0.04298265f, -0.01516089f, 0.01078981f, 0.01470222f, -0.00122914f, -0.02081341f, 0.04398743f, 0.01979273f, 
    0.00197761f, -0.06440740f, 0.05972093f, -0.04089649f, 0.04535712f, -0.04580601f, 0.01177721f, -0.03442785f, 
    0.04001815f, -0.01874759f, 0.04191118f, -0.05217308f, 0.02783818f, 0.06166947f, 0.01910154f, -0.05617100f, 
    -0.06836931f, 0.06473534f, -0.02709259f, -0.06014201f, -0.06792445f, -0.00243666f, -0.07125255f, 0.01517395f, 
    0.05523159f, -0.02929952f, -0.06315196f, -0.04910879f, -0.06727254f, 0.03717218f, 0.06489719f, 0.07097862f, 
    0.03242990f, -0.03922011f, -0.03478263f, -0.02936246f, -0.04243967f, 0.05585877f, 0.04924677f, 0.04324004f, 
    -0.00452936f, 0.01392493f, -0.02577647f, -0.05607176f, -0.02170984f, -0.03892459f, 0.02882358f, -0.04307547f, 
    -0.06287460f, 0.04234728f, -0.04549179f, -0.04055442f, 0.01122781f, 0.01725619f, -0.02025593f, -0.02821333f, 
    0.03799601f, -0.06641358f, -0.04187870f, -0.07399050f, -0.04111691f, 0.05279221f, 0.01812615f, -0.03336063f, 
    -0.03879357f, 0.01160395f, 0.06486910f, -0.07294333f, -0.00897246f, -0.02317830f, 0.02380791f, -0.04736226f, 
    -0.04520592f, 0.01603629f, -0.03712733f, -0.03519213f, -0.04465118f, -0.03860233f, 0.04142128f, -0.02941791f, 
    -0.03223528f, 0.05378445f, 0.06758259f, -0.08309434f, 0.00156063f, 0.02250069f, 0.02798681f, -0.02742584f, 
    -0.02816956f, -0.00811159f, -0.00596804f, 0.05821033f, 0.00675784f, -0.07493386f, -0.06218747f, 0.01335133f, 
    -0.04061825f, -0.00543815f, -0.02232888f, -0.02969224f, 0.05191068f, -0.01030339f, -0.07237238f, -0.07320214f, 
    -0.05602815f, -0.00302371f, -0.02574651f, -0.00922335f, 0.04089608f, 0.05978994f, 0.02619366f, -0.07805020f, 
    0.01731650f, -0.04155953f, -0.06466634f, 0.01835255f, 0.06883089f, 0.05842376f, 0.00064890f, -0.00145635f, 
    0.01243097f, -0.01864718f, -0.01460572f, 0.00509723f, -0.04815716f, 0.04718253f, 0.01187394f, -0.04517080f, 
    -0.04399450f, -0.03476530f, 0.03170440f, -0.01551715f, -0.06928952f, 0.02509964f, 0.06167950f, -0.05673536f, 
    -0.06819443f, -0.01952685f, 0.00086235f, -0.07692869f, 0.02226256f, -0.06413939f, -0.05575247f, -0.05400884f, 
    0.07119846f, -0.22002569f, 0.05301807f, 0.23736273f, -0.00996058f, 0.08931267f, -0.08950986f, 0.06051673f, 
    0.10311925f, 0.15333787f, -0.13976939f, 0.04165174f, 0.34731084f, 0.21792056f, 0.18603559f, 0.06402605f, 
    -0.02735295f, 0.11129342f, 0.16681103f, 0.02474945f, -0.02754998f, -0.02267898f, 0.08325203f, -0.05257603f, 
    0.07834961f, -0.18181133f, 0.16447392f, -0.02633168f, -0.10515407f, 0.00852628f, 0.12273667f, -0.05431763f, 
    0.14044625f, -0.14386995f, 0.06954795f, 0.08245458f, -0.00825750f, -0.17280565f, -0.15288308f, -0.13255014f, 
    0.20590948f, -0.02015882f, -0.02824821f, -0.06658240f, 0.13427274f, -0.04204129f, 0.05131343f, -0.10104837f, 
    0.09831720f, -0.03454545f, 0.13262945f, -0.03840173f, -0.21467960f, 0.05003830f, 0.07796155f, 0.06128431f, 
    -0.01341250f, 0.02583012f, 0.16033845f, 0.27821010f, -0.15849277f, 0.48339251f, 0.03601934f, 0.06605301f, 
    -0.00098815f, -0.02537672f, -0.03956767f, 0.02792595f, 0.01369805f, 0.10181762f, -0.14145841f, 0.03404386f, 
    0.47854561f, 0.10326988f, 0.22574276f, 0.25400677f, 0.12173726f, 0.01544939f, -0.11440578f, 0.08786445f, 
    -0.06266385f, -0.16242513f, 0.05602088f, -0.07053845f, -0.14968176f, -0.24983740f, -0.19756024f, -0.30547243f, 
    -0.03943238f, 0.14140368f, -0.04076979f, -0.11059642f, 0.02887679f, -0.05497581f, 0.04609926f, 0.04157797f, 
    0.09298597f, 0.03125330f, -0.01394960f, 0.25495258f, 0.01328663f, -0.11631459f, 0.05864787f, 0.05130807f, 
    0.01853801f, -0.01623633f, 0.02843238f, 0.00207738f, -0.31466830f, -0.20910084f, -0.10339548f, -0.06718059f, 
    0.08034122f, 0.00076715f, -0.05569379f, -0.02409923f, 0.01153373f, 0.10858881f, 0.04967295f, -0.00243435f, 
    0.09785829f, 0.08237069f, -0.17322229f, 0.12112873f, 0.02355922f, 0.15661740f, 0.01655606f, -0.00886675f, 
    0.00586152f, -0.03412851f, -0.05925784f, 0.04683327f, 0.20735979f, 0.25628453f, -0.08876924f, 0.19923681f, 
    -0.01614526f, 0.00479312f, 0.01904983f, 0.06508623f, -0.07976654f, -0.06155980f, -0.09961534f, 0.04354365f, 
    0.02744835f, 0.07530604f, 0.13178068f, -0.07866016f, 0.04762583f, 0.04522916f, -0.17880937f, 0.19915283f, 
    0.04099401f, 0.07360037f, 0.13674338f, -0.03882416f, 0.24782039f, 0.37454635f, 0.24310714f, 0.30622241f, 
    -0.05507793f, -0.01792503f, 0.12465726f, 0.03583433f, -0.00661546f, -0.03585039f, 0.11279905f, -0.16722789f, 
    -0.11551730f, 0.01352111f, 0.11435181f, 0.19546823f, -0.04600457f, -0.02398362f, -0.05573223f, -0.03069860f, 
    -0.02176603f, 0.07387922f, 0.01440411f, -0.02676540f, -0.18936849f, -0.35622531f, -0.20280112f, -0.04644946f, 
    0.15187000f, 0.00303890f, -0.05723206f, 0.02096822f, -0.05864526f, 0.03519113f, 0.03383110f, -0.05627293f, 
    -0.16524817f, 0.08027771f, -0.26826075f, -0.09127091f, -0.07758813f, 0.04729787f, -0.08403576f, -0.08569553f, 
    -0.06557103f, 0.05996662f, -0.02041992f, 0.08004137f, 0.08867527f, 0.08736756f, -0.25064811f, 0.03544999f, 
    0.04381625f, -0.15076330f, 0.06011868f, -0.22588967f, -0.12915243f, 0.05627581f, 0.10139248f, -0.11961877f, 
    0.07951735f, 0.09125423f, -0.10365317f, 0.04607965f, -0.04834878f, 0.00465417f, 0.18336023f, 0.03180816f, 
    0.10657384f, 0.08658497f, 0.07427462f, 0.04136242f, 0.08142167f, 0.17719252f, -0.00563270f, -0.07877061f, 
    0.08063927f, -0.02150906f, 0.03879476f, 0.06808797f, -0.04488627f, -0.05177364f, 0.02247060f, 0.05091223f, 
    -0.49264675f, 0.32556769f, -0.21894580f, -0.12404267f, -0.01973825f, -0.02339250f, 0.04121338f, 0.02615008f, 
    -0.08451322f, -0.14736016f, -0.03533162f, 0.03192144f, -0.31547585f, 0.07653999f, -0.00291241f, -0.04743638f, 
    0.27538565f, -0.03475997f, 0.08602200f, 0.09684003f, -0.08659336f, 0.00735120f, 0.17664935f, -0.03572981f, 
    -0.08419469f, 0.13826439f, -0.03265623f, -0.27073908f, 0.07673032f, -0.02455321f, 0.00262412f, -0.02634376f, 
    0.12542075f, 0.05713855f, 0.03186586f, 0.10737406f, 0.24514358f, 0.35026523f, -0.08964274f, 0.05483000f, 
    -0.05122890f, 0.01717969f, 0.06673753f, -0.01127618f, -0.02722277f, -0.00138386f, -0.06031854f, 0.08796820f, 
    -0.20434144f, -0.14162165f, -0.28549674f, 0.02869401f, 0.06970350f, 0.01869139f, 0.06314397f, 0.10449599f, 
    -0.25146767f, -0.02686824f, -0.13957866f, 0.00519140f, 0.48282686f, 0.36563319f, -0.03881309f, 0.10931887f, 
    0.13224545f, -0.01946660f, -0.01144833f, 0.05964177f, -0.00378901f, 0.13900144f, 0.06317304f, 0.03565903f, 
    -0.44770119f, 0.09580587f, 0.06676742f, -0.16921684f, 0.15700558f, 0.15198313f, -0.00980629f, 0.06352372f, 
    0.18493752f, -0.04955642f, 0.04952467f, 0.01358596f, -0.12221661f, 0.43314108f, -0.24183996f, 0.13941424f, 
    0.08078766f, -0.08164214f, -0.02758330f, 0.03742135f, 0.10080837f, 0.03409286f, -0.08925177f, 0.09938034f, 
    -0.04581937f, -0.08925924f, 0.13470714f, -0.07163908f, 0.07099641f, 0.09310378f, -0.20271786f, 0.03870568f, 
    -0.19265522f, 0.11270569f, 0.21273656f, 0.08914451f, 0.44177487f, -0.14972752f, 0.36755490f, 0.14496300f, 
    -0.16026248f, -0.07786722f, -0.05732607f, 0.13981724f, 0.03275675f, 0.04080601f, -0.02261893f, 0.08424486f, 
    0.39953697f, -0.12619267f, -0.32628259f, -0.36541408f, 0.09208430f, 0.02569979f, -0.01785640f, -0.00478855f, 
    0.05649340f, -0.07579835f, -0.01388170f, 0.06641510f, 0.09977341f, 0.26368120f, 0.21501175f, 0.00393048f, 
    0.03446816f, -0.04627034f, -0.10409813f, -0.00537195f, -0.00047292f, 0.04870280f, 0.05357539f, -0.19214229f, 
    -0.21499190f, 0.05078539f, -0.22983642f, 0.15846626f, -0.07466909f, -0.05379271f, -0.04140214f, -0.06352226f, 
    0.12382761f, 0.18315388f, -0.02068275f, 0.00400778f, 0.01553464f, 0.14899029f, -0.11217283f, -0.15992464f, 
    -0.24032287f, -0.00131936f, 0.04613371f, -0.09261288f, 0.02452212f, -0.03907606f, 0.18218836f, 0.04173973f, 
    0.18463352f, 0.24154422f, -0.11182961f, 0.06410795f, -0.03338842f, -0.07575943f, -0.02923773f, 0.04771508f, 
    0.00150574f, 0.05349709f, -0.01400998f, -0.26808706f, 0.06576456f, -0.03540767f, -0.09945158f, 0.30240875f, 
    0.12701315f, -0.11215909f, 0.08547864f, -0.02800970f, 0.23162970f, 0.07213206f, 0.06878901f, -0.16826062f, 
    0.01972725f, 0.01986734f, -0.05596871f, 0.05294668f, 0.01081809f, 0.05773551f, -0.08147498f, 0.01747703f, 
    0.08218040f, -0.05681225f, 0.01027831f, -0.03190253f, -0.15263677f, 0.15103404f, 0.07802488f, 0.10992309f, 
    -0.05089603f, -0.05840314f, -0.05282534f, 0.01422399f, 0.13429673f, -0.12602775f, 0.03785464f, 0.11309353f, 
    -0.29398879f, -0.06388137f, 0.13774408f, -0.02271061f, -0.02222718f, -0.06069236f, 0.00428263f, 0.07629785f, 
    0.13607211f, -0.09960686f, -0.15002163f, 0.03492116f, 0.63975298f, 0.05555039f, -0.02889375f, -0.16916253f, 
    0.03486672f, 0.07810217f, -0.08299096f, -0.06710493f, 0.02218791f, 0.11451757f, 0.05606044f, -0.04233363f, 
    -0.33313081f, -0.29727560f, 0.00885493f, 0.07212068f, -0.08394475f, -0.01023900f, -0.07497491f, -0.00110623f, 
    -0.02936376f, 0.07279078f, 0.03412408f, 0.03681817f, 0.41240713f, 0.20686904f, -0.07507434f, -0.03792019f, 
    -0.01738244f, -0.08928031f, 0.02738297f, -0.04366540f, 0.05077673f, -0.11889189f, 0.08321898f, 0.14827859f, 
    -0.28995049f, 0.31832784f, -0.09650123f, -0.05602812f, 0.30096829f, -0.11011501f, -0.12123089f, 0.07981170f, 
    0.10943489f, 0.10869055f, -0.05617929f, 0.07186455f, -0.02519331f, 0.34592789f, -0.29665491f, -0.03904647f, 
    0.03260094f, -0.12153842f, -0.02235847f, 0.11598290f, 0.07289968f, 0.00655010f, 0.08400489f, 0.13407320f, 
    -0.35668334f, 0.00588824f, 0.21986340f, -0.04292144f, 0.05844102f, 0.02283044f, -0.10192221f, 0.03910472f, 
    -0.10229810f, -0.04423724f, 0.12058972f, 0.00835813f, -0.15645115f, 0.02663606f, 0.19381809f, 0.30256030f, 
    0.05823563f, -0.04498275f, 0.06035458f, 0.10370502f, -0.00739765f, 0.07071309f, -0.14800006f, -0.09966008f, 
    0.07296661f, -0.27461141f, -0.29827955f, -0.16848940f, -0.07889050f, -0.04486190f, 0.03394912f, -0.09231856f, 
    0.07193121f, 0.01958790f, 0.09352940f, 0.15174615f, 0.36055520f, -0.09633426f, -0.01861725f, 0.32383418f, 
    0.23117432f, 0.14349596f, 0.05752682f, -0.08977417f, 0.05603640f, -0.14716372f, -0.00465604f, 0.15255122f, 
    0.04685395f, -0.07777495f, 0.00880077f, 0.02817312f, -0.05210526f, 0.00326420f, 0.00451545f, -0.05242391f, 
    -0.02127777f, -0.05944612f, -0.05797981f, 0.04242334f, -0.03117444f, 0.03167447f, -0.05087071f, 0.00834635f, 
    0.05557220f, 0.06420537f, -0.05370541f, -0.01396555f, -0.06194874f, 0.00815901f, 0.00375640f, 0.00663990f, 
    -0.01627236f, 0.03679824f, 0.04418426f, 0.00293727f, 0.01187282f, -0.04200128f, -0.00859736f, -0.05371930f, 
    -0.02208214f, -0.02658621f, 0.02414543f, -0.04016509f, 0.02648313f, -0.01356103f, -0.01040035f, -0.04553853f, 
    0.04826228f, -0.03447911f, -0.06414301f, -0.01232080f, -0.02463240f, -0.03228997f, -0.01707517f, -0.02828462f, 
    0.04001927f, 0.01622566f, -0.04722798f, -0.05512897f, -0.02073658f, 0.00288488f, 0.04926587f, 0.03911849f, 
    0.01896127f, -0.01717936f, 0.04617106f, -0.06861247f, 0.04596524f, 0.00390786f, 0.02621828f, 0.01210843f, 
    -0.03564977f, -0.01975563f, -0.00913245f, -0.03581000f, -0.05461111f, 0.01511387f, -0.03544468f, 0.07708124f, 
    -0.05783204f, -0.00291505f, 0.01040636f, -0.07311845f, -0.07466524f, 0.04658177f, 0.04765883f, -0.04851949f, 
    -0.04269329f, 0.03196114f, -0.05719697f, 0.01646304f, 0.00997375f, -0.06259362f, -0.00241376f, 0.06204149f, 
    -0.02960734f, -0.07383002f, -0.02666788f, 0.01610404f, -0.03876415f, -0.00890317f, -0.02154373f, 0.06071645f, 
    -0.00102161f, -0.06277164f, -0.02955978f, -0.00506206f, -0.00794329f, -0.04126556f, -0.07708789f, -0.07557305f, 
    -0.05132277f, 0.01872368f, -0.01645898f, -0.02317847f, -0.05854063f, -0.01404061f, -0.07637709f, -0.06418439f, 
    0.05588286f, -0.00494976f, 0.00162081f, -0.03179803f, 0.00093936f, -0.06646477f, 0.00023737f, -0.00993325f, 
    -0.02799990f, -0.07493678f, 0.00476693f, 0.03244324f, -0.06416524f, -0.00604177f, 0.04268986f, -0.07570308f, 
    0.02896343f, -0.03445939f, 0.06197144f, -0.04314185f, -0.05639301f, 0.01350531f, -0.02269535f, -0.05610298f, 
    -0.06150731f, 0.08425508f, 0.02869051f, -0.07484665f, 0.03381165f, -0.06454505f, 0.03814260f, -0.00170436f, 
    0.00966462f, -0.04961214f, -0.03184447f, -0.02476643f, -0.05376213f, -0.07760751f, 0.00272927f, 0.01048357f, 
    -0.03771382f, -0.07526364f, 0.01268810f, 0.01887887f, 0.03822815f, 0.00733478f, 0.04382552f, -0.03114886f, 
    -0.06713640f, 0.00924022f, -0.06742591f, -0.03178816f, -0.03194445f, 0.06012284f, 0.01318335f, -0.00796474f, 
    -0.04988568f, -0.04837225f, -0.00097870f, -0.01441382f, -0.07676567f, -0.06483460f, 0.04484138f, 0.04298221f, 
    -0.06962688f, 0.06199370f, -0.05165552f, 0.00051061f, 0.00135025f, -0.04719847f, -0.08039990f, -0.06959075f, 
    0.00382229f, -0.05050934f, 0.04116640f, 0.07061331f, -0.06232520f, 0.03985969f, -0.01319138f, 0.00413415f, 
    0.27849528f, -0.08069168f, -0.01389045f, 0.11934582f, 0.13832860f, -0.07214927f, 0.15678973f, -0.02648235f, 
    0.13622338f, 0.09328849f, 0.17779095f, 0.11760462f, -0.09936665f, -0.10855899f, -0.13207802f, 0.07630235f, 
    0.02017305f, 0.04806676f, -0.03702645f, -0.09665170f, -0.04370899f, 0.01218170f, 0.14091437f, -0.01079214f, 
    -0.47882554f, -0.05086397f, -0.10818108f, -0.22209582f, 0.03866310f, 0.06810825f, 0.14459999f, -0.01538992f, 
    -0.04222070f, -0.19110665f, 0.01936617f, 0.04416744f, -0.15115070f, 0.42213172f, 0.16808544f, -0.18291132f, 
    -0.08829758f, -0.02609033f, -0.04448291f, 0.21337701f, 0.07160271f, 0.07293082f, 0.04407806f, 0.12705089f, 
    -0.08335553f, 0.30364832f, -0.05876238f, 0.03340782f, 0.22689363f, 0.08017696f, 0.02663662f, 0.16731441f, 
    0.10424682f, -0.03578960f, -0.00924189f, -0.11544178f, -0.30102718f, 0.00446411f, -0.05383616f, -0.08719120f, 
    -0.13265979f, 0.02561750f, 0.09413787f, -0.01796175f, -0.13980898f, 0.09558228f, -0.09669649f, -0.07362729f, 
    -0.26245075f, 0.17775320f, -0.20121548f, -0.20934871f, 0.15241571f, -0.09244814f, 0.13471998f, -0.04033361f, 
    0.04864888f, 0.21270415f, 0.06466653f, -0.02485592f, -0.09662263f, 0.11199649f, -0.06279027f, 0.20550905f, 
    -0.01096006f, 0.13275538f, 0.13549772f, 0.11572000f, 0.18734454f, -0.02176615f, 0.17515670f, 0.03222256f, 
    0.13975373f, -0.06795885f, -0.05352847f, -0.08080236f, 0.17214072f, 0.02880780f, -0.09854691f, 0.20742199f, 
    -0.01839832f, 0.04203197f, -0.14709966f, 0.08507214f, 0.42545444f, 0.17239751f, 0.10653868f, 0.35364252f, 
    0.23886341f, 0.03903316f, 0.07417153f, 0.10398400f, 0.29145905f, 0.03416040f, 0.00456570f, 0.06349639f, 
    -0.21217074f, -0.11872795f, 0.06706275f, 0.08455300f, 0.14298777f, -0.04300373f, -0.01216883f, -0.07005183f, 
    0.21568859f, -0.03755352f, 0.04782465f, 0.13269341f, -0.18294032f, -0.04734118f, 0.00864877f, 0.03608390f, 
    0.11876097f, -0.16506313f, 0.20161894f, -0.04373896f, 0.06606409f, 0.04623727f, 0.04903987f, -0.02438924f, 
    -0.32465464f, 0.07841959f, -0.13342115f, -0.04243543f, 0.12852938f, 0.13572647f, 0.07491467f, 0.12516034f, 
    0.03584009f, 0.05538925f, -0.07744357f, -0.06572498f, 0.02843617f, -0.27473187f, -0.13749985f, -0.19765998f, 
    -0.00727810f, -0.06918453f, -0.06341573f, -0.06803741f, 0.07351619f, 0.08627243f, 0.03552104f, 0.06268798f, 
    0.40231606f, 0.35510939f, -0.08161556f, 0.12289794f, 0.07877342f, 0.14883953f, 0.08419464f, 0.07829653f, 
    0.03272639f, -0.04104178f, -0.11362027f, 0.17276633f, 0.25591478f, -0.10016388f, 0.14018430f, -0.25738686f, 
    -0.09493434f, -0.08155299f, 0.16097660f, 0.02754716f, 0.13559471f, 0.15139022f, 0.13819528f, 0.06588488f, 
    -0.17835732f, 0.05747940f, -0.00805588f, -0.07801899f, 0.03712921f, 0.10033793f, -0.03368983f, 0.09782262f, 
    0.00813356f, -0.16594405f, -0.12606026f, 0.02613020f, 0.02435620f, -0.01684180f, 0.10080390f, 0.08408727f, 
    0.15265524f, -0.04605451f, -0.07012063f, 0.05883647f, 0.12190042f, -0.00239380f, -0.22707462f, 0.06783234f, 
    0.00091018f, 0.30978140f, 0.00224520f, 0.11390714f, 0.06464610f, 0.13356358f, 0.02730565f, 0.05063617f, 
    -0.11185979f, 0.06685322f, 0.12464216f, 0.14465484f, 0.16196203f, 0.01664961f, 0.07445816f, -0.06070141f, 
    -0.01155958f, 0.07912587f, -0.03075932f, -0.12836283f, -0.16130632f, -0.07402682f, -0.10986005f, 0.06025123f, 
    0.24787024f, -0.02683304f, -0.06619868f, -0.01238098f, 0.04110290f, 0.10056604f, 0.01908784f, -0.13475814f, 
    -0.09309268f, 0.04658021f, 0.05956041f, -0.13267374f, 0.48392868f, -0.28440851f, 0.11790235f, 0.23561837f, 
    0.11001488f, -0.00236849f, 0.02939845f, 0.06715383f, 0.03933621f, 0.01676973f, 0.00369088f, 0.00802756f, 
    -0.09437753f, -0.10306689f, -0.06784505f, 0.05237289f, -0.09803912f, -0.00577466f, 0.12822475f, 0.00189371f, 
    -0.06739044f, 0.02203798f, 0.13183439f, 0.23970999f, -0.20250954f, -0.04738536f, 0.20528993f, 0.23930517f, 
    0.06282785f, -0.13468745f, 0.10145621f, 0.18700641f, 0.06923360f, 0.04502416f, -0.01095585f, 0.05443063f, 
    -0.07982657f, 0.18855849f, -0.01184304f, -0.01622102f, -0.12442705f, 0.06901523f, -0.00226683f, -0.06656525f, 
    0.16975170f, -0.11607119f, 0.17421590f, -0.00578561f, -0.33386126f, -0.06117344f, 0.18256925f, -0.06248983f, 
    -0.09781322f, 0.06097224f, 0.09348451f, 0.00867158f, -0.02461762f, -0.03267268f, -0.06554667f, -0.07116830f, 
    0.07606458f, 0.17352608f, 0.11520631f, -0.05867700f, -0.05814622f, 0.08513140f, 0.12765309f, -0.03735923f, 
    -0.12033310f, -0.16253266f, 0.15707858f, 0.03768244f, 0.31944445f, 0.14642805f, -0.03635165f, 0.13441581f, 
    0.02071254f, 0.15739621f, -0.02439239f, 0.06523716f, 0.01232581f, 0.04428271f, -0.03081709f, 0.11813153f, 
    0.46478653f, -0.05013729f, -0.10611509f, 0.04330755f, -0.07179596f, -0.08771494f, 0.10135536f, -0.04483273f, 
    0.05414772f, 0.07569773f, -0.07533728f, 0.07289501f, -0.29118037f, 0.05765618f, 0.07900027f, 0.00157552f, 
    0.09143610f, 0.07161873f, 0.07055059f, 0.09002161f, -0.05726987f, 0.02080546f, 0.13539031f, 0.18921517f, 
    -0.12603600f, -0.27873728f, 0.22338223f, 0.03636700f, -0.01131575f, -0.04121706f, 0.04908523f, 0.05319012f, 
    0.03349350f, 0.05911079f, 0.01145353f, -0.07218641f, -0.15486187f, 0.36662063f, -0.01750742f, -0.27587205f, 
    -0.01399842f, -0.02911130f, -0.03842273f, 0.15971863f, -0.09147101f, 0.11934666f, -0.10968225f, -0.08222362f, 
    0.01298895f, -0.05021664f, -0.03493031f, 0.17491281f, -0.10218190f, -0.12005007f, -0.22060426f, 0.16356152f, 
    -0.02525271f, -0.12119985f, -0.18390419f, 0.01450305f, -0.00061618f, -0.09950030f, 0.13608256f, 0.06328768f, 
    0.02839359f, -0.11496142f, -0.10405080f, 0.04268281f, 0.14887796f, -0.14881665f, -0.24487622f, 0.27471268f, 
    0.17021930f, 0.35957807f, 0.01939444f, 0.07763854f, 0.09728901f, 0.24041501f, -0.17317808f, 0.03680775f, 
    -0.02952566f, 0.27001429f, 0.03822111f, 0.15600693f, 0.03435539f, -0.07652095f, 0.16220559f, -0.17923217f, 
    0.12033981f, 0.05253846f, -0.00367848f, -0.06354054f, 0.00722909f, -0.11581650f, 0.03916812f, 0.02226890f, 
    0.36306968f, -0.01726529f, 0.01477275f, 0.15604624f, 0.10237267f, 0.16467114f, -0.02829030f, -0.14516197f, 
    -0.03531216f, -0.12140703f, 0.07730824f, -0.11595380f, 0.33639795f, -0.07812767f, 0.13560872f, 0.15321743f, 
    -0.01043305f, 0.13720538f, -0.13993934f, 0.00902896f, 0.11287782f, -0.08696368f, -0.01180512f, 0.24550056f, 
    0.04134326f, -0.04447875f, 0.01420817f, 0.31451231f, -0.15375884f, -0.02686605f, 0.03708438f, 0.04520240f, 
    0.16764101f, 0.23698893f, 0.07336576f, 0.34683344f, -0.07713251f, -0.38291371f, 0.03038736f, 0.01040313f, 
    0.03508020f, -0.00839000f, -0.05211863f, 0.13624951f, -0.07237212f, 0.14740212f, 0.02400585f, 0.04759311f, 
    0.24623877f, 0.11359520f, 0.15353994f, 0.01709669f, -0.24596356f, 0.24463445f, 0.13655476f, -0.24982618f, 
    0.27785820f, -0.03464796f, 0.10099805f, -0.09539469f, -0.31620660f, -0.05952654f, 0.04606537f, 0.06220001f, 
    -0.10297243f, 0.04360097f, -0.03601535f, 0.15184218f, -0.16115163f, -0.10669269f, -0.02916396f, 0.00449518f, 
    0.29685354f, 0.52489990f, -0.10813251f, 0.12153431f, 0.21283478f, 0.08270755f, 0.03610530f, 0.10945259f, 
    -0.05502011f, -0.00322055f, 0.09207878f, -0.00874410f, 0.26102352f, 0.34358329f, -0.01709070f, 0.27376583f, 
    -0.00478116f, 0.15446481f, -0.10907514f, 0.05423451f, -0.04289036f, 0.01710690f, -0.06407566f, 0.05771954f, 
    0.49364731f, -0.06217630f, -0.10820460f, -0.06968172f, -0.14187859f, -0.16750045f, 0.06157752f, -0.08650747f, 
    0.01864758f, 0.01326151f, -0.05494241f, 0.04718101f, -0.31791845f, 0.18779202f, -0.08834328f, 0.12118860f, 
    -0.00826311f, 0.03482059f, 0.27596277f, -0.05929257f, -0.15137616f, 0.04582942f, 0.04871398f, 0.06596618f, 
    0.11029875f, -0.11705257f, 0.15742970f, 0.23225516f, -0.08198787f, -0.19313867f, 0.00087488f, -0.02253037f, 
    -0.09979314f, 0.07682166f, 0.02862944f, -0.08404527f, 0.06935403f, -0.20431167f, -0.18437546f, 0.26654002f, 
    0.09602912f, 0.05396983f, 0.08672261f, 0.04146382f, -0.12357067f, -0.03505357f, -0.10842497f, 0.14820667f, 
    -0.06085159f, -0.18612804f, -0.01580352f, 0.20456184f, 0.06029113f, -0.13703445f, -0.13652118f, -0.02926672f, 
    0.02189537f, -0.06567375f, 0.00264644f, 0.15956816f, 0.02893196f, 0.06881226f, 0.06455540f, 0.17854190f, 
    -0.11161759f, -0.16453147f, 0.09465448f, 0.03882759f, 0.05361207f, -0.06401111f, -0.12009495f, -0.18931486f, 
    0.07148527f, -0.24469098f, -0.25973120f, 0.05545726f, 0.08482587f, -0.00121057f, 0.17116784f, -0.19289902f, 
    -0.00492919f, 0.07604467f, 0.29877120f, 0.23058218f, 0.39981696f, 0.19436085f, -0.13227901f, 0.27491033f, 
    -0.02820951f, -0.13265714f, -0.11008489f, -0.22789705f, 0.00882971f, -0.07365661f, -0.00881355f, -0.00850109f, 
    0.39469144f, 0.14412974f, 0.10222770f, 0.02768342f, -0.00804299f, -0.04947993f, -0.11869806f, -0.13685605f, 
    0.09162926f, -0.09873479f, 0.02862168f, -0.01256478f, 0.15050668f, 0.34139255f, -0.07409510f, -0.02324457f, 
    0.04634423f, 0.08660676f, -0.03016415f, 0.20759828f, 0.00929589f, 0.15999998f, -0.01423006f, -0.13601318f, 
    -0.11746708f, -0.10282169f, -0.05210085f, -0.09919091f, -0.00103882f, 0.05712534f, -0.12915885f, -0.11091048f, 
    0.07100756f, 0.17033021f, 0.24217249f, 0.14330524f, -0.27277660f, -0.04772213f, -0.16382512f, -0.15129386f, 
    -0.05666405f, 0.01261508f, 0.13817717f, -0.09252993f, 0.12013070f, 0.10206237f, 0.25579721f, 0.09550108f, 
    0.09517010f, -0.05881530f, 0.29657841f, 0.11976941f, -0.07143059f, 0.11959624f, 0.15572141f, -0.01738923f, 
    -0.09041070f, -0.05586968f, -0.01059761f, -0.20076823f, 0.25674170f, -0.06967042f, -0.23735164f, -0.00368846f, 
    0.00332549f, -0.05098097f, -0.01819193f, -0.18193126f, 0.02057348f, 0.07897776f, -0.28288531f, -0.05245987f, 
    0.31855503f, 0.09399547f, -0.32939959f, 0.05318337f, 0.12247235f, -0.08535385f, 0.05542714f, 0.03343629f, 
    0.25417945f, -0.12738052f, -0.07470902f, -0.06855489f, 0.07343262f, 0.17363368f, -0.20184113f, -0.13985585f, 
    0.01972875f, -0.01420074f, 0.18580487f, -0.21641491f, -0.13222751f, 0.12967081f, -0.02992643f, -0.02096612f, 
    -0.23694614f, -0.08617046f, -0.11123543f, -0.07869709f, 0.13837931f, 0.03262864f, 0.01991256f, 0.16589907f, 
    -0.01379850f, 0.16096033f, -0.08829140f, -0.09725568f, -0.00900506f, 0.20940761f, -0.13771206f, 0.17256935f, 
    -0.05040749f, -0.02213810f, 0.14062917f, 0.12839739f, -0.07515820f, 0.08393117f, 0.23417974f, 0.23892435f, 
    -0.08656105f, -0.03153550f, -0.06044299f, 0.11096456f, -0.15969029f, -0.07894116f, -0.11249304f, -0.03824398f, 
    0.02659424f, -0.02298693f, -0.10699993f, -0.08583004f, 0.57560503f, -0.18495771f, -0.00334968f, 0.13515750f, 
    -0.15073441f, -0.15971859f, -0.06312799f, 0.10377321f, -0.00574427f, 0.04795568f, -0.11533765f, -0.01384426f, 
    0.18203822f, -0.12179969f, 0.12982216f, 0.28119054f, 0.01480986f, -0.12000770f, 0.18038785f, -0.05958407f, 
    -0.03046142f, 0.19076368f, 0.17257461f, -0.05695201f, -0.13984026f, 0.06236658f, -0.02772559f, 0.21360821f, 
    0.09469432f, 0.21744779f, 0.05317583f, 0.29299322f, 0.15359777f, 0.07593521f, 0.16337295f, 0.12538482f, 
    0.33822182f, -0.08691680f, -0.01530303f, 0.02929339f, 0.15116894f, 0.08711366f, -0.15304361f, -0.02311371f, 
    -0.14381228f, -0.13159508f, -0.19606128f, -0.32056427f, -0.00831713f, 0.06939149f, -0.00988605f, -0.04531796f, 
    -0.05269860f, -0.10988428f, 0.03206914f, 0.05930242f, -0.00054186f, 0.07624149f, 0.03298760f, -0.04239455f, 
    0.37515748f, -0.14494984f, 0.07964397f, 0.20443916f, 0.06357681f, -0.04938008f, -0.02020171f, 0.13714992f, 
    0.10881706f, 0.05194548f, 0.09366811f, 0.03050044f, -0.23058869f, -0.15128726f, -0.03574969f, -0.12041981f, 
    -0.01536837f, -0.06360735f, -0.00517927f, -0.19956031f, 0.12644221f, -0.02861588f, -0.19047174f, 0.09950666f, 
    0.01382460f, -0.17369936f, -0.05548816f, 0.39178199f, 0.17752758f, 0.04895131f, 0.26624620f, 0.17018890f, 
    -0.21223345f, -0.06295191f, -0.11646875f, -0.23527054f, 0.40193132f, -0.04960674f, 0.14303693f, 0.01882477f, 
    0.07666224f, 0.13479704f, -0.19517373f, -0.16370593f, -0.00323716f, -0.05659155f, 0.01146427f, -0.06882030f, 
    -0.17298938f, -0.07872726f, -0.05133032f, -0.19939603f, 0.09313895f, -0.22035430f, -0.02771487f, -0.06779645f, 
    0.01151133f, 0.16639148f, 0.06686750f, 0.18444158f, -0.20033285f, -0.05049315f, 0.11995103f, -0.19559817f, 
    -0.08221163f, -0.08849163f, 0.03109266f, -0.00743355f, 0.11448608f, -0.08151118f, 0.22760397f, 0.05168837f, 
    -0.10274610f, -0.13724691f, 0.23654136f, 0.04500746f, -0.00310469f, -0.06006261f, 0.01530719f, -0.04191514f, 
    -0.14324023f, 0.17686671f, -0.11018340f, 0.04950514f, 0.26304212f, -0.48665154f, 0.13166863f, -0.31428376f, 
    0.11437570f, -0.01922050f, -0.00345227f, -0.01650568f, -0.02636186f, 0.08023672f, 0.22463031f, -0.06006353f, 
    -0.37443578f, 0.17012243f, -0.06442116f, 0.13204707f, 0.08771800f, 0.14456998f, 0.17147769f, 0.01346733f, 
    0.04265476f, -0.11501987f, 0.03674799f, -0.09333975f, 0.03006912f, 0.17228426f, -0.27331826f, -0.39864263f, 
    0.25356871f, 0.36319676f, -0.02345618f, -0.07151543f, 0.14460842f, 0.06384379f, -0.19703919f, -0.05639053f, 
    0.13083668f, 0.09391160f, 0.02694407f, 0.27391550f, -0.17272040f, -0.05319981f, -0.11562822f, 0.00752868f, 
    -0.14327051f, 0.08296242f, 0.16875750f, 0.27297184f, -0.12147680f, -0.12542966f, 0.12983586f, 0.17052457f, 
    0.05073585f, 0.00148819f, 0.16418119f, -0.10233812f, -0.05403503f, -0.01619201f, 0.19011429f, 0.22925521f, 
    -0.03051124f, -0.03907643f, -0.08246419f, 0.04475889f, -0.06546268f, 0.01367819f, -0.04581644f, 0.00205648f, 
    -0.03657550f, 0.04320374f, -0.04173286f, 0.05397753f, 0.00694132f, 0.04408148f, 0.03480249f, -0.00277697f, 
    -0.05639158f, 0.05942756f, -0.05249134f, -0.03722445f, 0.04704307f, -0.02305954f, -0.01395416f, -0.01396296f, 
    -0.00349134f, -0.07028446f, 0.02340131f, -0.05835966f, 0.06099552f, -0.07444038f, -0.06638280f, 0.03425118f, 
    -0.06110826f, 0.03922552f, 0.02261436f, -0.00453632f, -0.01931843f, 0.03034360f, 0.05099186f, -0.07379747f, 
    -0.01956306f, -0.00294576f, 0.00224387f, -0.05810998f, -0.00207299f, -0.05945706f, -0.05642147f, 0.04510079f, 
    0.02847289f, 0.05692666f, 0.02961651f, -0.03989933f, -0.06412414f, -0.03826983f, -0.03007026f, -0.07168473f, 
    -0.07978897f, -0.01247788f, -0.04365180f, 0.05575989f, 0.04834452f, -0.04239744f, -0.05997662f, 0.03994059f, 
    -0.05499512f, -0.07128704f, 0.01933758f, -0.01463112f, -0.02651830f, 0.01494361f, 0.05036707f, -0.05741945f, 
    -0.03988195f, -0.00351223f, 0.02475287f, -0.00199029f, 0.03837255f, 0.00411872f, 0.04683526f, 0.05168488f, 
    -0.07041831f, -0.02518441f, 0.01954261f, 0.00378873f, -0.01635944f, -0.01523446f, -0.07676994f, -0.06909087f, 
    -0.07237699f, -0.05694702f, 0.01003538f, 0.02154783f, -0.05497954f, -0.04395074f, -0.04598517f, 0.06185817f, 
    0.02087747f, 0.04497611f, -0.01618456f, -0.00778874f, 0.01835589f, 0.04590585f, 0.00750175f, -0.06402776f, 
    0.01776045f, 0.02757697f, -0.03018495f, 0.00284985f, -0.01337168f, 0.03417586f, -0.00192580f, 0.00054594f, 
    -0.00983639f, -0.01167537f, -0.06598740f, 0.03478422f, 0.04101350f, -0.07188895f, -0.01465844f, -0.06779139f, 
    -0.07825299f, 0.02562971f, -0.01445413f, -0.06655599f, 0.03458951f, 0.01187516f, 0.02739335f, 0.03607721f, 
    -0.01540079f, -0.06369305f, -0.05221793f, -0.07475284f, -0.03290121f, 0.03208737f, -0.06643347f, -0.03316847f, 
    -0.06929835f, 0.05191799f, -0.03912815f, -0.05496116f, -0.07723870f, -0.05167383f, 0.04521912f, 0.06095558f, 
    -0.05780925f, 0.01110940f, 0.02453058f, -0.01088066f, 0.01728998f, 0.03000307f, -0.04091537f, 0.00376749f, 
    -0.07120842f, -0.03967711f, -0.03697839f, -0.01825209f, 0.03472195f, 0.06434210f, -0.06736587f, -0.03090411f, 
    0.02446708f, -0.00127659f, -0.05690401f, -0.06265552f, 0.04435456f, 0.05860769f, 0.05566635f, 0.01718783f, 
    -0.07929573f, 0.06150006f, -0.05446333f, -0.06652877f, 0.01343997f, -0.05703710f, 0.02320698f, 0.01682540f, 
    -0.03138800f, -0.02041998f, -0.06019969f, -0.00384770f, -0.07668398f, -0.03600400f, -0.02116753f, 0.04065671f, 
    0.05365661f, -0.00008000f, 0.05413835f, -0.00886191f, -0.00017119f, -0.04063444f, 0.05725418f, -0.01844432f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.08760338f, 0.22145282f, 0.13587417f, 0.02147410f, -0.06061529f, -0.01983891f, 0.04149007f, 0.18710835f, 
    0.03555764f, 0.03499506f, -0.04244111f, 0.07441538f, 0.00168880f, -0.02860595f, 0.07329919f, -0.00124747f, 
    -0.03925121f, 0.00029430f, 0.08619840f, 0.20507944f, -0.00508408f, 0.00816634f, 0.02217887f, -0.00472263f, 
    -0.05479299f, -0.06438500f, 0.17645144f, 0.00576438f, 0.01833989f, -0.02799720f, -0.06533035f, 0.00872764f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.07600266f, -0.03080944f, 0.24751553f, -0.10207522f, 0.32346943f, 0.08886307f, -0.27191088f, -0.23005418f, 
    0.69257206f, 0.17611499f, 0.18445732f, -0.47569087f, 0.19818392f, 0.09664877f, 0.13718888f, -0.00991391f, 
    -0.27305534f, 0.06012587f, 0.44294158f, 0.22417378f, 0.14594650f, -0.10832750f, 0.12101700f, -0.33599794f, 
    0.33329675f, -0.14800355f, 0.10477985f, -0.13260378f, -0.07574528f, -0.09630882f, 0.55765378f, -0.16404870f, 
    0.48443910f, -0.21706492f, 0.06852449f, -0.15116554f, -0.12010380f, -0.16427524f, 0.00968133f, 0.36233735f, 
    0.05947033f, 0.00072560f, 0.53898376f, -0.07027778f, 0.10313381f, -0.11201559f, -0.04234073f, 0.11615720f, 
    -0.27562076f, 0.15582155f, 0.30919909f, -0.12025825f, 0.13218141f, -0.12213744f, -0.16765980f, -0.23737334f, 
    -0.16531119f, -0.01479695f, 0.03710948f, -0.06326183f, 0.36894935f, -0.03099298f, 0.37081695f, 0.00704903f, 
    -0.42448935f, -0.01974510f, 0.15641451f, -0.13811053f, -0.47724536f, 0.09617110f, 0.41207498f, 0.44706044f, 
    0.02285125f, -0.24960333f, 0.28281567f, 0.54388779f, 0.13183771f, -0.03140763f, 0.17655124f, -0.32784480f, 
    0.16709149f, 0.11239507f, -0.28971818f, -0.05644249f, 0.00309904f, 0.14197496f, 0.11641065f, 0.07631086f, 
    -0.28941935f, -0.03431434f, 0.23239788f, 0.19424699f, 0.26472050f, 0.02491572f, 0.08021526f, 0.07364210f, 
    0.09342344f, 0.41298434f, 0.13924271f, -0.16990960f, 0.17190786f, 0.02437307f, 0.10577173f, -0.35270590f, 
    -0.10829051f, -0.28199694f, 0.06656200f, -0.08750330f, 0.34090611f, 0.15917051f, 0.18283220f, 0.29223049f, 
    0.28854570f, -0.03217616f, -0.28436068f, -0.24311304f, 0.04883416f, -0.03697736f, 0.18208990f, -0.19690752f, 
    0.08155848f, 0.15886097f, -0.02296914f, 0.10142620f, 0.35135505f, 0.78927463f, -0.43213549f, 0.15237695f, 
    0.03260219f, 0.02831437f, -0.12671064f, -0.18465099f, 0.14668916f, -0.06772215f, -0.06025814f, 0.13031000f, 
    -0.10707136f, -0.22063385f, -0.21430130f, 0.28306568f, -0.18619235f, 0.17426197f, 0.21307610f, -0.03260681f, 
    0.15739276f, 0.07399810f, 0.11662237f, -0.18357277f, 0.14361264f, 0.10519230f, 0.12154766f, 0.36906764f, 
    0.09460688f, 0.00580805f, -0.11510725f, -0.12455349f, -0.01311739f, 0.34556210f, 0.10698266f, 0.14378989f, 
    -0.10286918f, -0.11374411f, -0.08987461f, -0.11930229f, 0.04686185f, 0.15939595f, -0.09216548f, 0.11473357f, 
    -0.14737453f, 0.07340086f, 0.04929136f, 0.11391694f, -0.20287319f, 0.05940697f, 0.02813316f, 0.04617190f, 
    -0.00509249f, -0.13610852f, 0.00858341f, 0.04178745f, 0.07062019f, 0.00761056f, 0.01041065f, -0.22133949f, 
    0.07546347f, -0.17370737f, -0.17658593f, 0.03334945f, -0.05602124f, 0.13977030f, 0.03267935f, 0.08934537f, 
    -0.25538963f, -0.20885406f, 0.22288206f, 0.24250139f, 0.39166281f, -0.02273552f, 0.17160855f, -0.12851170f, 
    0.65137655f, 0.15628120f, 0.50571895f, -0.21239603f, 0.03729182f, 0.10345981f, 0.21919572f, -0.07516257f, 
    0.01684124f, -0.13713206f, -0.20091952f, 0.04950527f, -0.01955213f, -0.12268634f, -0.06070868f, -0.28302041f, 
    -0.25985268f, 0.06728403f, -0.02881207f, 0.23634981f, -0.23858832f, 0.06612745f, 0.35563374f, -0.07973491f, 
    -0.26968494f, 0.26685378f, 0.18364184f, -0.19503982f, -0.48479256f, -0.14018366f, 0.12451081f, 0.32307890f, 
    0.10644686f, -0.34655097f, 0.01960497f, 0.28329340f, 0.04776773f, 0.01255169f, 0.41850030f, -0.31866238f, 
    -0.37517321f, 0.07544387f, 0.08802458f, 0.05244274f, 0.11896760f, -0.13251880f, 0.31750628f, -0.04559918f, 
    0.15737419f, 0.16594554f, 0.32746872f, -0.34041151f, -0.14331791f, 0.20326316f, 0.10820866f, 0.04251755f, 
    0.04510432f, 0.22256538f, 0.17855790f, -0.41148305f, -0.02347026f, -0.13789353f, 0.29023054f, -0.52383691f, 
    0.36079025f, 0.53667635f, -0.55929112f, 0.07101331f, -0.02723122f, -0.13841952f, 0.09228019f, -0.16848540f, 
    0.24097848f, -0.06711072f, 0.10666656f, -0.21810023f, -0.06344922f, -0.03063722f, 0.36955488f, 0.13531911f, 
    0.20728430f, 0.02468018f, -0.28959784f, -0.05052977f, 0.27647182f, 0.09338297f, -0.19500357f, -0.17267731f, 
    0.26008806f, -0.47849390f, -0.29219010f, -0.42116109f, -0.41453260f, 0.05737080f, 0.16772805f, -0.29514042f, 
    -0.09735410f, 0.29178900f, 0.21092919f, 0.39678136f, 0.11899558f, 0.15991782f, 0.29902738f, -0.02964666f, 
    0.18124209f, -0.00063373f, 0.38765466f, -0.44860503f, -0.10334865f, 0.12169813f, 0.40608034f, 0.07254026f, 
    0.30341071f, -0.11713877f, -0.12756671f, 0.04850647f, 0.31031296f, 0.17795330f, 0.50098288f, 0.02447786f, 
    -0.03439634f, 0.20548451f, 0.07366869f, 0.08896795f, -0.60644126f, 0.18100263f, 0.16206047f, 0.11648371f, 
    -0.17820340f, -0.27188998f, -0.55338019f, 0.11292060f, -0.26415846f, -0.10903187f, 0.17957753f, 0.33153734f, 
    0.16797246f, 0.03932476f, -0.24510717f, 0.20004663f, 0.04167530f, 0.13256787f, -0.12045690f, -0.36847514f, 
    0.08846683f, 0.02467633f, 0.18497723f, 0.13012600f, 0.46204716f, -0.11573532f, 0.13512392f, 0.11253558f, 
    0.05612464f, 0.22761773f, 0.33390665f, 0.20399503f, -0.16942731f, -0.03894311f, 0.13503192f, 0.45568591f, 
    0.09373739f, 0.45702288f, -0.08354556f, -0.07764927f, 0.00954743f, 0.02463686f, 0.05166128f, -0.10373358f, 
    -0.27365795f, 0.04788802f, -0.02328071f, 0.19590208f, 0.11876331f, -0.01640433f, -0.14380020f, -0.02649107f, 
    -0.42566594f, -0.03479661f, 0.30619264f, -0.16223238f, -0.17692092f, -0.12881862f, -0.00234081f, -0.06975669f, 
    -0.25877014f, 0.59548199f, 0.21228956f, 0.01586853f, -0.04096211f, -0.04513815f, 0.18771923f, 0.04830704f, 
    -0.39968690f, -0.30726576f, 0.25580087f, 0.04896514f, 0.32101908f, 0.05455045f, 0.09873293f, -0.02579787f, 
    0.29235062f, -0.08364103f, -0.22469887f, -0.23359710f, -0.11772157f, 0.02755843f, 0.20786412f, 0.05316908f, 
    -0.41060853f, 0.11437805f, 0.19707344f, 0.20626996f, -0.00503413f, 0.32043636f, -0.44543946f, -0.12834845f, 
    -0.03559382f, 0.04434714f, -0.06229096f, -0.09671627f, -0.16196722f, 0.04577590f, 0.14832057f, -0.00404235f, 
    -0.08449223f, -0.15750009f, 0.08607136f, -0.11616854f, 0.01047341f, -0.05871600f, -0.15969114f, -0.11569687f, 
    -0.00322114f, -0.11630492f, -0.08701053f, -0.01685823f, -0.02222458f, 0.02996645f, 0.04531235f, -0.10331667f, 
    0.00893707f, 0.10674016f, -0.14782624f, -0.17518321f, -0.07857108f, -0.14931084f, 0.15185478f, 0.03000023f, 
    0.31959027f, 0.36990789f, 0.01634596f, -0.13875042f, 0.21829294f, -0.11778345f, -0.09476259f, -0.07798278f, 
    -0.16931093f, -0.38501665f, 0.14159474f, -0.21225807f, 0.45510811f, 0.02647519f, 0.22731638f, 0.21162075f, 
    -0.13719003f, -0.14504775f, 0.41495627f, -0.21584676f, -0.08734033f, 0.03066043f, 0.39939174f, -0.16765282f, 
    0.26232731f, -0.02245382f, -0.03548977f, -0.13055687f, 0.02675722f, 0.32342544f, 0.12689495f, -0.07409039f, 
    -0.36890018f, -0.07485527f, 0.23171866f, -0.02506234f, 0.04483788f, -0.03222743f, 0.12105436f, 0.25499782f, 
    0.32435238f, -0.15798290f, -0.53900963f, 0.42109296f, -0.52872789f, 0.07153004f, 0.08173407f, -0.25202778f, 
    0.28074989f, -0.15681450f, 0.17918631f, 0.42246377f, 0.02191063f, -0.17831816f, -0.18505514f, 0.27090108f, 
    0.30994290f, -0.11450960f, -0.00229380f, 0.23631085f, 0.26296219f, -0.47918087f, 0.03789448f, 0.13835193f, 
    -0.06049356f, -0.06836971f, -0.00527444f, 0.22004439f, 0.36301729f, 0.05000864f, -0.00316955f, 0.12795198f, 
    0.12390139f, 0.36265862f, 0.07888976f, -0.14064789f, 0.24549980f, 0.12300787f, -0.07383242f, 0.02257126f, 
    -0.10826309f, -0.08118036f, 0.22981964f, -0.00352928f, -0.09436269f, 0.15567017f, 0.15277243f, 0.31816402f, 
    -0.29827470f, -0.03384350f, 0.07330274f, -0.15813389f, -0.32204229f, -0.13033669f, 0.10698704f, 0.01820923f, 
    0.24978377f, 0.35002294f, 0.27918869f, -0.20680541f, 0.12871596f, -0.13644177f, 0.02714445f, 0.39860651f, 
    -0.26371199f, 0.18705554f, 0.23228553f, 0.26244473f, 0.33654362f, -0.10672741f, -0.19974394f, -0.05484969f, 
    -0.06131867f, 0.05545712f, 0.07516711f, 0.28895673f, -0.04187154f, 0.04747376f, -0.03937836f, 0.42651787f, 
    0.26424909f, 0.07468873f, 0.04175889f, -0.06939368f, -0.00302750f, 0.07415218f, -0.53041905f, -0.07737562f, 
    -0.05956608f, -0.00416408f, 0.02062168f, 0.08461853f, 0.10359064f, -0.11037038f, 0.37781903f, -0.40601754f, 
    0.03197376f, 0.27159700f, -0.77588999f, -0.25654474f, -0.12328478f, -0.14702426f, 0.07905378f, 0.01507868f, 
    0.32578495f, 0.06878530f, -0.02934899f, -0.23698348f, 0.01696855f, -0.04127247f, 0.34863341f, -0.04212262f, 
    -0.13221581f, -0.06891878f, -0.21451652f, 0.10563281f, 0.00091811f, 0.32867453f, 0.17059743f, 0.16932946f, 
    0.36902317f, -0.32202384f, 0.18760684f, 0.26786953f, 0.56568700f, 0.01734496f, -0.17961609f, -0.34212476f, 
    0.14620778f, 0.08335504f, 0.13854976f, 0.16001795f, -0.17928360f, 0.11179875f, 0.34211633f, 0.22889227f, 
    -0.35811049f, -0.11778399f, 0.37474316f, -0.04674605f, -0.08445452f, 0.17250928f, -0.21236923f, 0.48081392f, 
    0.57154596f, 0.07378036f, 0.26367724f, -0.22402076f, -0.17193659f, 0.43660247f, 0.22687526f, -0.01478852f, 
    -0.16789030f, 0.23066232f, -0.18859710f, 0.14402792f, -0.03049495f, -0.16946875f, 0.21501686f, -0.14291197f, 
    -0.53885722f, -0.37538013f, -0.46768874f, 0.37526193f, -0.09811085f, 0.01424627f, 0.03914687f, 0.20532092f, 
    0.46020311f, 0.05622112f, 0.01545316f, 0.28976336f, 0.16282941f, 0.15535168f, -0.06767674f, 0.42240492f, 
    0.37101880f, -0.02724203f, 0.04539230f, 0.40609246f, 0.34571511f, 0.15317820f, -0.04429855f, 0.10978420f, 
    0.42736018f, -0.29579988f, 0.24999771f, 0.26060888f, -0.01741814f, 0.02208381f, 0.27228445f, -0.27628762f, 
    0.37213308f, 0.36240181f, 0.25897139f, -0.46869102f, 0.26896244f, 0.03626696f, -0.02714252f, 0.38479847f, 
    0.16840304f, 0.06005749f, -0.26202956f, -0.13581660f, 0.11979139f, 0.00587922f, -0.13889074f, -0.44788340f, 
    -0.30140227f, 0.09302180f, -0.16416444f, 0.37141311f, 0.37574437f, 0.26491377f, 0.18980229f, 0.02163456f, 
    0.42032927f, -0.29717818f, 0.12421335f, 0.58735788f, 0.45931983f, 0.02623615f, 0.22589183f, -0.18569578f, 
    -0.10413186f, 0.13237335f, 0.18764229f, 0.38297734f, -0.22367530f, -0.07295249f, 0.02712276f, 0.01068804f, 
    0.06906301f, -0.03997164f, -0.17006125f, 0.39065069f, -0.15548810f, 0.05187152f, -0.37668529f, 0.54813737f, 
    0.03617501f, 0.07870813f, 0.38202512f, 0.09312601f, -0.30911046f, 0.26567209f, -0.12402636f, -0.03864424f, 
    -0.10835857f, -0.03100310f, -0.10464872f, -0.12637608f, -0.02659772f, 0.09308892f, -0.07376651f, -0.18220967f, 
    0.14087632f, -0.05587249f, 0.02911264f, -0.15780112f, 0.06584637f, 0.13258412f, 0.01088641f, -0.11659729f, 
    -0.11820710f, 0.05436908f, 0.03014782f, -0.09583975f, 0.04956339f, 0.15921724f, -0.11917119f, -0.03742905f, 
    -0.07646248f, -0.15824805f, -0.00307868f, -0.12209891f, -0.11695649f, -0.04809012f, -0.14831917f, 0.13856383f, 
    0.34805259f, -0.03833744f, -0.05592669f, -0.18098761f, 0.10042444f, -0.13144091f, -0.27057412f, 0.52185112f, 
    -0.18262009f, 0.11456661f, 0.36764228f, 0.34310532f, 0.33739710f, 0.07484003f, 0.14679548f, -0.12959351f, 
    -0.18260716f, -0.02937577f, 0.18895014f, -0.13358334f, 0.13269451f, 0.02712513f, -0.03342584f, 0.44403234f, 
    -0.25838616f, 0.02490371f, 0.37876326f, -0.15642525f, -0.08763144f, 0.03312276f, -0.10068388f, 0.01831182f, 
    -0.01119717f, 0.34050640f, 0.21023668f, -0.38687202f, 0.12997770f, -0.04625356f, -0.10317189f, 0.22294547f, 
    0.06639811f, 0.51849240f, -0.12021880f, -0.37381029f, 0.41285178f, -0.14930470f, -0.09381820f, -0.13821104f, 
    0.08989109f, 0.13746397f, 0.44535241f, 0.11522029f, 0.07830008f, 0.09067197f, 0.50005341f, 0.20373984f, 
    -0.12226214f, -0.06673405f, -0.21248628f, -0.09250557f, -0.11490068f, -0.61019140f, -0.00979706f, 0.14490069f, 
    0.18689933f, 0.36517474f, -0.18649356f, 0.01233177f, 0.04512296f, -0.11632863f, -0.18731406f, 0.19317748f, 
    0.05941115f, -0.14045347f, 0.06151488f, -0.36526754f, 0.06858341f, -0.13881555f, 0.04201040f, -0.12901317f, 
    0.06700982f, -0.02749269f, 0.18170993f, -0.11735333f, 0.14665931f, 0.06022178f, -0.01373545f, 0.15972529f, 
    0.21147929f, 0.00744113f, -0.16121568f, -0.11177495f, -0.21110970f, -0.08368617f, 0.11872128f, -0.00752521f, 
    -0.05573831f, -0.03769182f, 0.09951637f, 0.19819543f, -0.19538841f, 0.12695217f, -0.19933434f, 0.27519578f, 
    -0.18069158f, -0.06619291f, -0.57729536f, -0.17709775f, 0.26971477f, 0.08379871f, -0.27876261f, 0.25301465f, 
    0.24950995f, 0.09900998f, 0.47560394f, 0.51581073f, -0.12860624f, -0.07403989f, 0.19774777f, 0.42541879f, 
    0.55731302f, -0.08743106f, 0.06561686f, -0.17701694f, -0.33158103f, -0.81921822f, 0.17609440f, 0.07920616f, 
    -0.13319422f, 0.03488939f, 0.00113528f, -0.10324410f, -0.16859677f, 0.14882487f, 0.08220395f, -0.18065795f, 
    -0.07819518f, -0.11930589f, -0.07203792f, 0.01050979f, -0.02518206f, -0.05061994f, -0.11058695f, 0.00075105f, 
    -0.15492322f, -0.07499503f, 0.00166665f, -0.10509373f, 0.01596154f, 0.15239723f, 0.08409101f, -0.07927167f, 
    0.10894208f, -0.07637666f, 0.05356036f, -0.12557133f, -0.13309895f, 0.11046805f, 0.02425008f, -0.05931347f, 
    0.02336712f, 0.38496768f, -0.09573432f, 0.04007984f, 0.02274773f, 0.00645425f, -0.09712470f, 0.17891377f, 
    -0.25020882f, -0.37815517f, -0.60270101f, -0.40837082f, 0.30540156f, 0.05469051f, -0.03451766f, 0.27986377f, 
    0.36921546f, -0.06877486f, 0.15423748f, -0.19273482f, -0.09384574f, -0.06154879f, 0.41563335f, 0.09544445f, 
    -0.39637631f, 0.12317455f, -0.12039426f, 0.17602931f, 0.09886514f, 0.25999385f, -0.00704397f, 0.15709972f, 
    0.19684228f, -0.06414650f, 0.01242255f, 0.13495451f, -0.65190208f, 0.00972994f, -0.03800503f, 0.32901499f, 
    -0.26133555f, -0.00085225f, -0.25526869f, 0.11006785f, 0.00744737f, 0.07628999f, 0.15809585f, 0.21201879f, 
    -0.04191234f, -0.13042355f, -0.11704758f, 0.35080269f, -0.06728974f, -0.17737177f, -0.01302095f, -0.26302832f, 
    -0.06517072f, -0.11854389f, 0.24279781f, 0.12624054f, 0.04583258f, -0.42120516f, 0.52873439f, -0.04126925f, 
    -0.05951158f, -0.09894487f, 0.03004309f, 0.06873418f, 0.09491500f, 0.02453973f, -0.09695856f, -0.11125243f, 
    -0.10387898f, 0.11179223f, 0.04838457f, -0.10533875f, -0.13429357f, -0.07041364f, -0.16895661f, 0.04071290f, 
    -0.00515625f, -0.11231185f, 0.15965669f, -0.02965166f, 0.16668305f, -0.08911093f, 0.06911095f, -0.11003564f, 
    0.04478768f, 0.06410413f, -0.01344435f, 0.05889117f, -0.08478025f, -0.05331047f, -0.15290728f, 0.04805813f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.18691868f, -0.02194964f, 0.14348413f, 0.09931717f, 0.04265177f, -0.17810290f, -0.05325717f, -0.00649851f, 
    -0.00872632f, -0.10406032f, 0.19988276f, 0.26834470f, 0.12518397f, -0.03089151f, 0.12959154f, -0.03181129f, 
    -0.06786148f, -0.11708150f, -0.20191461f, 0.07440633f, 0.13411984f, 0.19630712f, 0.00940145f, 0.15180260f, 
    0.02419125f, 0.20613518f, -0.07889985f, 0.17728993f, -0.16846308f, -0.05731913f, 0.21159287f, -0.12671496f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.13999817f, 0.36505812f, -0.21918710f, 0.29096720f, -0.30382651f, 0.08518808f, 0.23794682f, -0.56450254f, 
    -0.66089833f, 0.14733066f, -0.23767768f, -0.39174283f, 0.00666247f, -0.03139694f, 0.30273771f, -0.59086591f, 
    0.03589729f, -0.26083788f, -0.28804684f, 0.05566603f, -0.07777834f, 0.37831458f, 0.11611635f, -0.14898041f, 
    -0.02935392f, -0.71635616f, -0.20727004f, -0.46915087f, 0.08823130f, 0.04847303f, -0.04760102f, 0.15671813f, 
    0.26513347f, 0.03859689f, -0.48174480f, -0.42337322f, -0.23215884f, 0.00520807f, 0.26922211f, -0.21169315f, 
    0.29038751f, 0.03742460f, -0.49648833f, 0.21991460f, -0.48873597f, -0.13676222f, -0.15017943f, -0.21501745f, 
    0.40719229f, -0.09369320f, 0.39506027f, 0.23119444f, -0.51099122f, 0.09085161f, 0.39200234f, -0.18817990f, 
    0.06183544f, 0.22128443f, -0.18992451f, 0.03102664f, -0.17665890f, -0.22485779f, -0.09741182f, 0.12370620f, 
    -0.20113984f, 0.10007805f, -0.82793975f, 0.12758628f, 0.28240812f, -0.06379820f, -0.52328122f, -0.73161131f, 
    -0.50171375f, -0.74996817f, -0.13612710f, -0.04171849f, 0.09548751f, -0.05969671f, 0.18149807f, -0.14584431f, 
    0.11438174f, 0.18719460f, -0.20792592f, 0.23854414f, 0.28070661f, -0.06390490f, 0.25366810f, 0.07009026f, 
    0.30577013f, 0.05940694f, -0.07476887f, 0.09892416f, 0.08402167f, 0.27493709f, -0.14918733f, -0.10202326f, 
    -0.02020561f, 0.31520897f, 0.07924129f, 0.34081748f, -0.01040443f, -0.01996668f, -0.19938383f, 0.03507331f, 
    0.23080465f, 0.00504508f, -0.15536457f, -0.06712355f, 0.14352931f, -0.07614494f, 0.16217606f, -0.32156140f, 
    -0.18357146f, 0.22030452f, -0.19310634f, -0.46757054f, -0.38191876f, 0.28090146f, -0.59789896f, -0.06873244f, 
    0.18369649f, 0.15686339f, -0.01143102f, -0.75526702f, 0.10027311f, -0.08910193f, -0.31276125f, 0.11927334f, 
    0.19871524f, -0.36202976f, -0.08322553f, 0.30541509f, -0.13530861f, -0.09557798f, 0.38602504f, 0.07554727f, 
    0.09592460f, -0.42163578f, 0.13798182f, -0.02352011f, 0.25297990f, 0.01222499f, 0.01956529f, -0.02855133f, 
    -0.25919360f, -0.31170464f, 0.21835858f, -0.13070594f, 0.03761821f, 0.19328190f, 0.01882121f, 0.12384813f, 
    -0.85419160f, -0.30375400f, -0.18323371f, -0.41859850f, -0.01893323f, -0.07665662f, -0.09843245f, 0.03887326f, 
    0.21176355f, 0.34353933f, 0.04256646f, -0.40031555f, -0.06047042f, 0.09653652f, 0.07940952f, 0.07206842f, 
    -0.07768220f, 0.33714652f, 0.31260708f, 0.08475666f, -0.51143378f, -0.17409299f, -0.16444315f, 0.25451753f, 
    -0.22423777f, -0.46699220f, -0.19317806f, 0.03163594f, -0.10769286f, 0.00353644f, -0.08161052f, -0.13414031f, 
    -0.15824823f, -0.31405699f, -0.18961552f, 0.05762495f, -0.01852751f, -0.67941445f, 0.40239069f, 0.11016852f, 
    -0.54472911f, -0.08814771f, 0.46515071f, -0.17212565f, -0.27795911f, -0.07154810f, 0.26143849f, 0.04419855f, 
    -0.01052343f, -0.40429139f, 0.01467220f, 0.24920359f, 0.42595202f, 0.06840480f, -0.65468800f, 0.16253850f, 
    -0.08795223f, 0.04758935f, -0.70146793f, -0.20866309f, 0.07282451f, -0.15016368f, 0.31128576f, 0.13587254f, 
    0.21390451f, 0.24693978f, -0.17177072f, -0.82458335f, -0.10778948f, -0.79863113f, -0.07105538f, 0.01482948f, 
    -0.34423545f, -0.29376712f, 0.18859601f, -0.00950195f, 0.38761637f, 0.11776707f, 0.07576872f, -0.22631077f, 
    0.24360585f, 0.36669114f, -0.25179487f, -0.72800630f, 0.07536062f, 0.14599721f, -0.08883319f, 0.12076450f, 
    0.00732529f, -0.44818622f, 0.33152378f, -0.17682701f, 0.20486812f, 0.00748354f, -0.08800305f, -0.07321048f, 
    -0.15556335f, 0.08061793f, -0.20233776f, -0.11005853f, 0.04924796f, 0.29036847f, -0.36558908f, -0.06663024f, 
    0.37996119f, -0.21132270f, -0.18188399f, -0.29590493f, 0.08517542f, 0.00642423f, -0.01892203f, 0.12298493f, 
    0.37034643f, -0.07156339f, -0.52604723f, -0.46432161f, -0.39058977f, 0.14145212f, 0.00822166f, 0.45271388f, 
    -0.01539660f, 0.31562617f, -0.27128834f, 0.18371554f, 0.05120656f, -0.52164972f, 0.07959007f, 0.14054359f, 
    -0.11650620f, 0.28330880f, 0.28633702f, 0.29637840f, 0.13931566f, -0.36327481f, -0.80117762f, -0.06241542f, 
    -0.68199551f, -0.07733240f, -0.02232825f, 0.03725870f, -0.15494703f, -0.10683057f, -0.21944033f, -0.52437741f, 
    -0.28409919f, 0.03519175f, 0.36219299f, -0.13695391f, 0.07242047f, 0.05919171f, -0.41344967f, 0.20209061f, 
    -0.26896060f, 0.09895284f, -0.06249469f, -0.44616032f, 0.29937911f, 0.26631367f, 0.18714650f, 0.15567200f, 
    -0.50089300f, -0.34370509f, 0.08838230f, 0.45068389f, -0.08295342f, -0.14793491f, 0.29856828f, -0.01334208f, 
    0.10092618f, -0.12455086f, 0.17748217f, -0.27848759f, -0.04803448f, -0.14452370f, -0.07923184f, 0.29628339f, 
    -0.29964799f, -0.31452614f, -0.21623941f, 0.24911429f, 0.26716632f, -0.07122002f, 0.21000427f, -0.34496436f, 
    0.36052990f, 0.03421155f, -0.35882038f, -0.69027138f, -0.32920372f, -0.31176862f, -0.31481922f, 0.14021441f, 
    0.19398767f, 0.46677983f, 0.30127335f, 0.49051103f, -0.05989350f, 0.23046681f, 0.17768732f, 0.10182970f, 
    -0.30372387f, -0.10521579f, 0.05959296f, 0.21890770f, 0.25670812f, 0.08741719f, -0.68794984f, 0.45111182f, 
    -0.25056097f, 0.32492983f, 0.11811700f, -0.18005347f, 0.14516695f, -0.08852505f, 0.27657685f, -0.28396684f, 
    -0.40306246f, -0.03847468f, -0.44732156f, 0.07515442f, 0.11445814f, -0.35806006f, 0.04373307f, -0.05779932f, 
    0.28690529f, -0.55550754f, -0.14683565f, -0.15348493f, -0.16627680f, -0.22286847f, 0.14365470f, 0.12949379f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.10284420f, -0.04091146f, 0.08979772f, 0.00988536f, 0.21645123f, -0.15424949f, 0.11623398f, -0.11890582f, 
    -0.04196630f, 0.04671994f, -0.06697253f, -0.05421319f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
