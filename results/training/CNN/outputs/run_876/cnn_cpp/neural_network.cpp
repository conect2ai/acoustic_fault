#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.00097334f, -0.50767201f, 0.30708742f, -0.62311548f, -0.63313949f, -0.64674705f, 0.11311040f, 0.48543367f, 
    -0.01009874f, -0.05174216f, 0.55487937f, 0.34886324f, 0.46743253f, 0.32782531f, -0.68161052f, 0.44286135f, 
    0.50044221f, 0.02078617f, -0.17802966f, 0.26600993f, -1.02820969f, -0.34353605f, 0.69292665f, 0.25455874f, 
    0.11826307f, -0.26312572f, -0.05863980f, 0.85001260f, 0.25821313f, 0.42959774f, 0.12098323f, 0.29597288f, 
    -0.00818294f, -0.37104395f, 0.41174841f, 0.53673369f, 0.12665372f, 0.65833938f, -0.30256605f, 0.40024433f, 
    -0.28308564f, 0.51811409f, -0.31044808f, -0.49122682f, -0.44387206f, 0.74805480f, -0.65403849f, 0.52604252f, 
    -0.06477555f, 0.13474141f, 0.82100874f, -0.04285969f, -0.03422202f, -0.01666863f, -0.91454113f, 0.46110797f, 
    -0.10571746f, -0.36807811f, 0.70121592f, -0.56213897f, 0.04328250f, 0.23538503f, -0.34452295f, 0.56043208f, 
    -0.33073381f, -0.69076216f, -0.68746358f, -0.00639912f, -0.73282236f, 0.17689362f, 0.36398709f, 0.34993351f, 
    -0.54544526f, -0.29682052f, -0.10721295f, 0.63425779f, 0.59445536f, 0.67301702f, 0.53774917f, -0.20574315f, 
    0.27747256f, 0.86147463f, 0.66209841f, 0.81940615f, 0.06176893f, -0.90070575f, 0.04212512f, 0.31127471f, 
    0.03521083f, 0.08291306f, 0.80414796f, 0.28493562f, -0.04639138f, 0.39691252f, 0.27510953f, 0.15109572f, 
    0.15848166f, -0.28878585f, -0.54709595f, -0.01168905f, 0.25157431f, 0.38825092f, 0.78625780f, 0.88141513f, 
    0.34054300f, -0.09146442f, 0.04363107f, 0.06651279f, -0.66583854f, -0.51542807f, -0.27528298f, 0.51017636f, 
    0.54477423f, -0.34818301f, -0.09780055f, -0.49494916f, -0.34805363f, -0.18386729f, -0.86256939f, -0.61786962f, 
    0.23124905f, -0.28522187f, 0.14717257f, 0.11683998f, -0.07612235f, -0.34498554f, -0.14400229f, -0.92470783f, 
    -0.26233765f, -0.14352433f, -0.38375685f, 0.22442116f, -0.19879785f, -0.07432746f, 0.40337014f, -0.12219959f, 
    0.63996893f, -0.23301058f, 0.13363031f, -0.65556037f, -0.76162302f, -0.48214194f, -0.18670703f, -0.07449122f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.20444131f, -0.03723920f, -0.22340284f, -0.30786774f, 0.21143772f, 0.02910653f, 0.09453786f, 0.24344283f, 
    -0.13645694f, -0.03184295f, 0.30581421f, -0.06835471f, -0.22041018f, 0.22688505f, 0.13875341f, 0.24975528f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.04269603f, -0.15506519f, -0.06234784f, -0.11206966f, 0.03048060f, -0.22847171f, 0.12257935f, 0.00583919f, 
    -0.07402499f, 0.22204159f, -0.27013874f, -0.02981284f, -0.11442100f, -0.14995436f, -0.01912744f, 0.24281001f, 
    -0.06067058f, 0.10111193f, -0.12934417f, -0.08681417f, 0.03678979f, -0.30250502f, -0.23222552f, -0.03782560f, 
    0.16019264f, -0.01972931f, 0.11494896f, 0.14095084f, -0.06808707f, -0.03673498f, 0.16247112f, -0.03895446f, 
    0.16529977f, 0.02931570f, 0.06087077f, 0.14152296f, -0.21626419f, -0.21195553f, 0.14674902f, 0.05193014f, 
    0.13693924f, 0.11839277f, -0.00259806f, 0.04959622f, 0.17085400f, 0.10862232f, 0.23116684f, -0.07599663f, 
    0.20319675f, 0.00889281f, 0.03579903f, -0.08104689f, 0.15608329f, 0.09574427f, -0.26743907f, -0.19482411f, 
    -0.14793371f, 0.02811874f, 0.12399863f, 0.04826089f, 0.28313833f, -0.05920931f, -0.33979079f, -0.01620062f, 
    0.18451080f, -0.21104988f, 0.03779523f, 0.00336903f, -0.10055842f, 0.14566013f, 0.11190061f, -0.08536445f, 
    0.37186420f, 0.03566730f, 0.36385867f, -0.42453781f, -0.22322427f, -0.19087143f, -0.09928107f, 0.13478108f, 
    0.06545772f, 0.12196438f, 0.04293999f, -0.03740241f, 0.13234422f, 0.09531724f, -0.01404658f, -0.05478431f, 
    -0.11013040f, -0.07908182f, -0.03102808f, 0.23701903f, -0.07291368f, 0.01481912f, 0.16740489f, 0.04618620f, 
    0.19937269f, -0.06898840f, -0.02528924f, 0.38362414f, 0.17771190f, 0.04296350f, -0.26593578f, -0.23308156f, 
    0.22111684f, -0.01701842f, 0.29481873f, 0.00257681f, -0.32249054f, -0.39130086f, 0.28509420f, 0.05723218f, 
    -0.06234951f, 0.10586566f, 0.14054288f, -0.46921533f, 0.07887012f, -0.37149841f, 0.06664304f, 0.50862765f, 
    0.07987262f, -0.05054729f, -0.01622468f, 0.04265591f, 0.09232102f, -0.02032910f, -0.04688906f, 0.20501615f, 
    0.22026968f, -0.01034951f, -0.15480681f, -0.06620421f, -0.00556725f, 0.09282135f, -0.04162018f, -0.17754745f, 
    -0.17858747f, -0.20789525f, 0.12550339f, 0.21761119f, 0.10360911f, -0.11727855f, -0.00734989f, 0.08924695f, 
    0.04370853f, 0.05551063f, -0.03707680f, -0.03170857f, 0.05142523f, -0.08002004f, -0.03681016f, 0.03786867f, 
    0.00560154f, -0.08483695f, -0.05310180f, -0.06342198f, 0.05690630f, -0.06635198f, -0.08402518f, -0.03602736f, 
    0.07401654f, -0.07527036f, -0.00030692f, -0.03131319f, 0.00054882f, -0.08348113f, -0.03167447f, -0.07976297f, 
    -0.08547948f, -0.05102257f, 0.02101112f, 0.02563968f, 0.06557576f, -0.05888340f, -0.03997929f, -0.04145451f, 
    0.01065598f, -0.01212846f, -0.07727776f, 0.07957993f, -0.02730804f, 0.04544951f, -0.06678139f, -0.01887349f, 
    0.02438989f, -0.05836270f, -0.03215478f, -0.09893142f, 0.00180467f, 0.02741437f, 0.01665066f, -0.05658370f, 
    0.04874814f, 0.05007930f, -0.05757248f, -0.04174380f, -0.08437160f, -0.04371537f, 0.03327440f, -0.07055829f, 
    0.04384513f, 0.05102058f, -0.01740560f, -0.08558829f, 0.06464607f, -0.00407525f, -0.06310899f, -0.07028915f, 
    0.05144216f, 0.00444719f, 0.00657232f, -0.04986449f, 0.00316146f, 0.00909874f, -0.04565472f, -0.04247675f, 
    -0.07505992f, -0.01901313f, -0.05508786f, -0.02930265f, -0.03027561f, -0.01820720f, -0.08351930f, -0.03852026f, 
    -0.07592317f, -0.06948310f, 0.03874091f, 0.04511784f, -0.02784054f, 0.05732986f, -0.05851241f, -0.00597749f, 
    0.04230757f, 0.00162179f, -0.01670292f, 0.00959084f, 0.05922253f, -0.05844114f, 0.02762335f, 0.00756192f, 
    0.01031395f, -0.05865918f, -0.08283674f, 0.06035743f, -0.07723257f, -0.01981106f, 0.07167313f, -0.04814475f, 
    -0.02501647f, 0.04487386f, -0.07411297f, 0.05325333f, -0.03230888f, -0.03179619f, 0.01260833f, 0.04749731f, 
    0.03845228f, 0.04392488f, -0.01493269f, -0.04092960f, 0.04293498f, -0.06488536f, 0.06097754f, -0.03258225f, 
    -0.05315315f, 0.03896976f, -0.02267679f, 0.01528369f, 0.04972661f, 0.06783202f, -0.07014070f, 0.03726656f, 
    0.05360809f, 0.06372727f, 0.01055376f, -0.00028257f, -0.02324447f, 0.06921449f, -0.04134457f, 0.04709430f, 
    -0.01982044f, -0.05931863f, -0.02291566f, 0.02185394f, -0.08252625f, 0.03613301f, 0.05894813f, 0.05777888f, 
    -0.26926699f, -0.22628264f, 0.36777386f, -0.00150322f, 0.10074426f, 0.01032689f, -0.09151819f, 0.01355156f, 
    -0.02286775f, -0.11932906f, -0.03378171f, -0.15076278f, 0.10778131f, 0.12272777f, -0.13000107f, -0.05986692f, 
    -0.04277452f, 0.11612027f, 0.19306853f, 0.18716827f, -0.36850527f, -0.01831350f, 0.00263889f, -0.02766492f, 
    0.17190741f, -0.15692224f, 0.01088274f, 0.08285581f, -0.26913640f, -0.09276922f, -0.10037494f, 0.05385497f, 
    0.16185760f, -0.02684884f, 0.09950668f, 0.04550876f, 0.16584511f, 0.06732457f, 0.09025467f, -0.01931560f, 
    -0.04606105f, -0.20302941f, 0.12005770f, 0.04119751f, -0.13555507f, -0.12148011f, -0.12241709f, -0.16688551f, 
    0.16312586f, -0.04708376f, -0.13714963f, -0.02767894f, 0.02911997f, 0.10806941f, -0.10536478f, -0.04166918f, 
    -0.09661516f, 0.09229837f, 0.09064467f, 0.27952436f, -0.08810285f, -0.21280839f, -0.14545476f, -0.46026748f, 
    -0.35779199f, 0.12400927f, -0.00784730f, 0.15875354f, 0.10971254f, 0.13655379f, -0.16025352f, -0.01243811f, 
    -0.00710787f, 0.33836830f, -0.31445587f, 0.03245915f, 0.10970812f, -0.08678340f, 0.12226230f, -0.08384945f, 
    -0.10884420f, 0.06528902f, 0.25217405f, 0.14373791f, -0.05138649f, -0.12256470f, -0.17796960f, -0.03630722f, 
    0.08075687f, 0.28110197f, 0.03326184f, -0.01124476f, -0.18436873f, -0.22477996f, -0.11579364f, -0.19292039f, 
    0.07610651f, 0.25146630f, 0.14379327f, 0.13524120f, 0.34915370f, 0.17786103f, -0.01925416f, -0.02833285f, 
    -0.17909117f, 0.17941394f, 0.11412043f, 0.14803718f, 0.01229155f, -0.02061707f, -0.11617351f, 0.03189284f, 
    0.03864656f, 0.11300153f, 0.21805340f, -0.14275256f, -0.01476237f, 0.27331647f, -0.07821982f, -0.21051519f, 
    0.05956251f, 0.06083515f, 0.05534025f, 0.12803601f, -0.00532680f, -0.21624950f, -0.18472992f, 0.22908743f, 
    -0.13741341f, 0.09115642f, 0.19741730f, -0.01200515f, -0.02960155f, -0.02053146f, 0.21122707f, 0.09532157f, 
    -0.11214709f, 0.21241760f, 0.05250613f, -0.20421810f, -0.00680197f, -0.02354452f, 0.17301777f, -0.01331394f, 
    -0.07682657f, 0.28762138f, -0.19058800f, 0.44186240f, -0.07547935f, 0.07815897f, -0.00234189f, -0.10178477f, 
    -0.09063224f, 0.65392143f, -0.23209900f, -0.02866889f, 0.07820242f, 0.00381774f, 0.06405912f, -0.05981977f, 
    0.04868954f, 0.06282476f, -0.16772239f, -0.14679688f, -0.03143505f, -0.27839667f, 0.07647230f, -0.08522752f, 
    -0.19033195f, -0.05843698f, -0.03739301f, -0.01132092f, 0.05959690f, -0.10248600f, -0.05292464f, -0.03050088f, 
    0.07559186f, 0.14551237f, 0.17493941f, -0.02900278f, 0.29403752f, -0.28209192f, -0.18263982f, -0.00098705f, 
    0.06478582f, -0.03567746f, -0.08193544f, -0.09111333f, 0.00260501f, -0.47823286f, 0.07886325f, -0.00540327f, 
    0.14579661f, -0.12641160f, 0.05059970f, -0.01790677f, 0.18209723f, -0.01419343f, -0.03385962f, 0.17749651f, 
    -0.10416632f, 0.09959020f, -0.15935320f, -0.16746613f, -0.13750800f, -0.07499830f, -0.04141303f, 0.01894135f, 
    0.13272323f, -0.44333759f, 0.03511028f, 0.07874644f, 0.08266690f, 0.09053275f, 0.18429035f, -0.06130784f, 
    -0.16919523f, 0.03559281f, 0.11825135f, -0.13477932f, -0.03144249f, -0.09944994f, -0.09792805f, 0.05464645f, 
    0.10998929f, 0.57118613f, -0.01829946f, 0.10654250f, 0.23446287f, 0.02831306f, 0.00572607f, -0.02727662f, 
    0.05765044f, 0.02059584f, 0.09934598f, -0.06876486f, -0.23098969f, 0.15451217f, -0.19732754f, 0.29899567f, 
    -0.16621846f, 0.00403486f, -0.03819268f, -0.44329229f, -0.20836625f, -0.07551209f, 0.04564390f, 0.01988747f, 
    0.08375778f, 0.03004944f, 0.03909418f, -0.12581596f, -0.33602995f, -0.11071286f, 0.07799567f, -0.04557040f, 
    0.05178749f, 0.08627452f, -0.24237230f, 0.08365495f, -0.12198179f, 0.17771624f, 0.10915656f, -0.18000618f, 
    -0.26446986f, 0.04133782f, -0.09693417f, -0.10223339f, 0.09862342f, -0.05962691f, 0.17855784f, 0.12351954f, 
    -0.20757180f, -0.09280288f, -0.02532597f, -0.01137465f, 0.05061632f, 0.09936642f, -0.02794936f, 0.10540798f, 
    0.05837181f, 0.05511132f, -0.03491042f, 0.04603746f, 0.08014248f, 0.14468975f, 0.00551714f, 0.11819049f, 
    0.08210728f, -0.22120970f, -0.05002993f, -0.05982808f, 0.08213826f, -0.07756066f, -0.15468447f, -0.08810444f, 
    -0.14933074f, -0.35625836f, 0.09643006f, 0.10612027f, 0.12195080f, 0.01795117f, 0.12103306f, -0.07184190f, 
    0.13809842f, -0.02004053f, -0.14095688f, 0.03031193f, 0.19740590f, -0.12374727f, -0.48308149f, -0.17095192f, 
    0.07334586f, 0.03668318f, -0.06732573f, -0.24916592f, 0.11069341f, 0.12911578f, 0.11753660f, 0.04980962f, 
    0.14971066f, -0.03884194f, -0.03874711f, 0.10211097f, -0.09923181f, 0.14298530f, 0.17036125f, -0.00582833f, 
    -0.12917644f, 0.18149568f, 0.15834239f, -0.17832786f, -0.04955051f, 0.14984560f, 0.03646107f, -0.11063918f, 
    -0.16533625f, 0.24120757f, -0.06345114f, -0.04357956f, 0.12330561f, -0.03964363f, 0.16721317f, 0.24738899f, 
    0.07805254f, -0.13157074f, -0.15524289f, -0.04014273f, -0.14241713f, 0.00127135f, 0.02636978f, 0.14934510f, 
    -0.14193808f, 0.14131600f, 0.06101880f, -0.03050817f, -0.00491183f, -0.16801246f, -0.09036860f, 0.10214457f, 
    -0.03323710f, -0.17616770f, -0.05610771f, -0.05488839f, -0.07527265f, 0.08168020f, 0.03555204f, -0.02723472f, 
    0.13337451f, -0.42421883f, 0.20465022f, -0.22695421f, 0.04021549f, -0.07140443f, 0.00518337f, -0.04241863f, 
    -0.20716219f, -0.00155230f, -0.19435780f, 0.21373296f, -0.11907776f, -0.04802246f, 0.04590547f, 0.07965490f, 
    0.07840493f, -0.12146822f, -0.06092886f, -0.20192818f, 0.06072824f, -0.11855570f, 0.01129953f, -0.10967635f, 
    0.06236238f, 0.17048176f, -0.27308878f, 0.07071067f, 0.11457293f, 0.18808940f, 0.30349338f, 0.01204357f, 
    0.13597763f, -0.03905313f, -0.00491277f, 0.25870359f, -0.27689180f, 0.06055043f, -0.00759645f, 0.23369399f, 
    0.08340947f, 0.20488200f, -0.09619457f, 0.12850830f, 0.02881104f, 0.20172623f, 0.29817626f, -0.01560535f, 
    0.34002399f, 0.11283082f, -0.02370597f, 0.03699813f, 0.08803663f, -0.04618350f, 0.09543801f, 0.05166439f, 
    0.17412107f, 0.04222225f, -0.15367949f, -0.22207972f, -0.01113017f, 0.07362594f, -0.04027610f, 0.20750915f, 
    0.09401222f, 0.28254539f, -0.57641870f, 0.01548549f, -0.00495291f, 0.17980574f, -0.21597978f, -0.11614311f, 
    -0.00530625f, -0.00588305f, -0.07898471f, 0.17701629f, 0.01027770f, -0.06012087f, -0.00408266f, -0.04329989f, 
    0.01209164f, 0.08322889f, -0.36141005f, -0.05150403f, -0.15996636f, -0.00892995f, -0.00841389f, 0.15871675f, 
    0.00519200f, 0.10944300f, -0.09043182f, -0.01142859f, 0.14683312f, -0.03381180f, 0.11420705f, 0.24780795f, 
    0.13005716f, -0.20002678f, -0.01548129f, 0.05338188f, -0.03602171f, 0.14708447f, -0.00944220f, 0.15525854f, 
    0.03346744f, 0.05459432f, 0.12649268f, 0.16000104f, -0.00951322f, -0.32773218f, 0.16549234f, -0.17670876f, 
    -0.11941259f, -0.02557515f, 0.07710860f, -0.15816665f, -0.00156825f, -0.00489833f, -0.08468554f, -0.27776751f, 
    -0.42788026f, -0.07010395f, 0.11141556f, 0.01357628f, 0.23612806f, -0.28372434f, 0.00263235f, -0.14402647f, 
    -0.21688806f, 0.10987726f, 0.03751742f, -0.14514649f, 0.00649452f, 0.13144481f, 0.03943706f, 0.12127040f, 
    -0.31770736f, 0.06346516f, -0.15215601f, 0.05811548f, -0.10851332f, 0.10445492f, 0.08515806f, -0.13996036f, 
    -0.04638751f, 0.16554092f, 0.20458905f, -0.00875168f, -0.10061011f, 0.18870935f, -0.18257818f, 0.06106224f, 
    -0.01934719f, -0.03929587f, 0.00966920f, 0.02708031f, -0.05260008f, 0.05932581f, 0.01610661f, -0.05209829f, 
    0.01785810f, 0.33044487f, -0.11289044f, 0.14189072f, 0.05471450f, 0.13684347f, -0.06587079f, 0.19707482f, 
    -0.17366348f, -0.06968636f, -0.10078971f, -0.07872947f, -0.16297036f, 0.19132140f, -0.58487523f, -0.14209384f, 
    0.01743685f, -0.00873960f, -0.03983602f, -0.04490993f, -0.05624583f, -0.39243495f, -0.01432553f, -0.49667883f, 
    0.23776449f, -0.06285910f, 0.15507148f, 0.18779537f, 0.15717959f, -0.26438552f, -0.90505731f, -0.43693852f, 
    -0.19575562f, 0.05686453f, 0.22780547f, -0.11070611f, -0.18900059f, 0.07525206f, 0.20484927f, 0.12306993f, 
    -0.07604467f, 0.07275493f, 0.12045541f, 0.12212043f, -0.03513031f, 0.15183488f, 0.15582828f, 0.15816551f, 
    0.36508802f, 0.21288563f, -0.02548606f, -0.13432300f, -0.13101950f, -0.18125634f, -0.02496771f, -0.27824271f, 
    0.08619791f, 0.10327008f, 0.15157107f, -0.11047325f, -0.01944811f, -0.05994477f, -0.24515192f, -0.01921892f, 
    0.02570826f, 0.02715061f, 0.20001623f, 0.02705857f, -0.05603159f, -0.06153382f, -0.20868760f, -0.07564206f, 
    0.07827933f, 0.09292976f, 0.03528781f, -0.30092305f, -0.33680281f, 0.13381159f, 0.02063664f, -0.01333511f, 
    -0.09817455f, 0.06288359f, 0.13248640f, -0.22063012f, 0.13612288f, 0.14714812f, -0.02307065f, 0.12118514f, 
    0.06615298f, 0.08066060f, 0.10541540f, -0.10094409f, 0.05890066f, -0.07382441f, -0.16135052f, -0.26174465f, 
    -0.05744822f, 0.12210864f, -0.06295967f, 0.18987428f, -0.01275041f, -0.09963181f, 0.02270213f, 0.18643415f, 
    0.05633167f, -0.03592333f, -0.07621779f, 0.02961885f, 0.03911511f, 0.01978220f, 0.12501036f, -0.01614397f, 
    0.11513530f, 0.04134044f, -0.02430739f, -0.14458089f, -0.09573598f, 0.19660053f, 0.11322200f, 0.07169638f, 
    0.31309113f, 0.03060955f, -0.04458143f, -0.03932981f, 0.15396142f, 0.11804471f, -0.13947172f, 0.01547688f, 
    -0.01353766f, -0.22413142f, -0.73584896f, 0.05096876f, 0.23228003f, 0.15739241f, -0.15610051f, 0.09951990f, 
    -0.01945699f, -0.27601540f, -0.25647953f, -0.08166493f, -0.12257507f, 0.15581132f, 0.22167435f, -0.13935359f, 
    -0.12304766f, -0.02736795f, 0.19505168f, 0.17571354f, 0.03125760f, -0.13593276f, -0.02275772f, 0.01559188f, 
    0.20371190f, -0.12141486f, 0.17238821f, -0.05360704f, 0.05251507f, -0.09194488f, -0.04377419f, -0.02487321f, 
    -0.38228342f, 0.22528179f, -0.01843654f, 0.18346137f, 0.17343134f, -0.03395316f, -0.04206129f, -0.13261589f, 
    -0.17147867f, 0.01723848f, 0.01171116f, -0.04134531f, 0.10169886f, 0.10935925f, 0.06106935f, -0.21882758f, 
    -0.04520355f, -0.24383225f, -0.14199969f, 0.04234974f, 0.34418532f, 0.07968906f, -0.21889208f, 0.48153093f, 
    -0.01234554f, -0.05605943f, -0.02048432f, 0.02229994f, 0.00194830f, 0.06379593f, 0.11219488f, 0.19486663f, 
    0.06268803f, 0.15400158f, -0.06572519f, -0.00706757f, -0.10532103f, 0.07627942f, -0.16599268f, -0.03873122f, 
    -0.06181262f, -0.01563961f, -0.22527170f, -0.15695830f, -0.02298892f, -0.12758881f, 0.00811042f, 0.09181136f, 
    -0.11012892f, 0.03100503f, -0.36935279f, -0.47911891f, 0.20876984f, 0.00617511f, 0.02641408f, 0.21144243f, 
    0.02379557f, -0.16728054f, -0.16318859f, 0.07920056f, 0.17964730f, 0.10079570f, -0.04619796f, -0.08689864f, 
    0.07620734f, -0.11538341f, 0.02697769f, 0.09654121f, -0.10215908f, -0.05937821f, 0.29640427f, 0.10764809f, 
    0.18712379f, -0.01262872f, -0.13020286f, -0.15402152f, 0.13359439f, 0.29162681f, 0.11257831f, 0.08604705f, 
    -0.11209721f, 0.05959353f, -0.07821104f, -0.03328577f, -0.14333057f, 0.15354870f, -0.17238897f, -0.08668345f, 
    0.02221196f, 0.20066226f, 0.32309368f, -0.13644546f, -0.13579991f, 0.00471279f, -0.17033024f, -0.06876080f, 
    -0.04221768f, -0.15957607f, -0.02395619f, -0.10269628f, 0.02963729f, 0.05591602f, -0.06375889f, -0.10790446f, 
    -0.27692658f, -0.12779175f, -0.24337295f, 0.03364708f, 0.15128198f, 0.03487622f, -0.05594707f, 0.09363019f, 
    -0.07799859f, 0.37608385f, 0.24540696f, 0.41309819f, 0.00977772f, 0.02430378f, 0.27780879f, -0.04737072f, 
    -0.02177614f, 0.05578236f, -0.01523784f, 0.09651709f, 0.02121119f, -0.01344855f, 0.00322160f, -0.10024642f, 
    -0.07322226f, 0.19340414f, 0.17080176f, -0.04732033f, -0.43057445f, 0.04535691f, 0.23556101f, 0.19679195f, 
    0.09926347f, 0.12600608f, 0.01635323f, -0.14602734f, 0.09638014f, -0.23585644f, -0.22037153f, 0.12457301f, 
    0.07684688f, -0.14222009f, 0.10968295f, -0.00013357f, -0.22878161f, 0.25290054f, 0.01031845f, -0.55820763f, 
    -0.11696871f, -0.02893548f, 0.14680523f, -0.04330143f, 0.19846091f, 0.06161227f, -0.07019752f, 0.05892617f, 
    0.01125429f, 0.11781745f, -0.11710602f, 0.04351757f, -0.31963173f, -0.12492074f, 0.19385974f, 0.14103863f, 
    0.18018870f, -0.12028884f, -0.01285015f, 0.03192298f, 0.05672266f, -0.01818776f, 0.06146003f, 0.13203922f, 
    -0.28812671f, -0.14683442f, -0.27124822f, -0.00986230f, 0.02713984f, 0.08220173f, -0.05707170f, -0.00790068f, 
    0.01744954f, -0.16426490f, -0.23558091f, 0.16392666f, -0.12356710f, 0.01843217f, 0.17590964f, -0.04002469f, 
    -0.05046730f, 0.20991451f, 0.40870956f, -0.15701456f, -0.19337296f, -0.09852342f, 0.04324897f, -0.01637845f, 
    -0.18823141f, 0.21649623f, 0.03616333f, 0.01147239f, 0.04044678f, -0.14783838f, -0.06554692f, 0.00059717f, 
    -0.05110364f, -0.05718485f, 0.05024901f, -0.05211710f, -0.10373601f, 0.08888548f, -0.16236621f, 0.10091951f, 
    -0.10962395f, 0.07310995f, -0.14153875f, -0.10095321f, 0.02094416f, -0.05869157f, -0.02914098f, -0.09115582f, 
    0.17529562f, -0.09237701f, 0.07275932f, -0.04897824f, 0.07264236f, -0.02231472f, -0.29769436f, -0.15303171f, 
    -0.15904060f, -0.01957440f, 0.05625656f, 0.33145815f, 0.04859267f, 0.06553704f, 0.02212696f, 0.62618017f, 
    -0.19600272f, -0.23605359f, 0.05070520f, 0.03268421f, 0.06222054f, -0.08932935f, 0.12877202f, 0.10220159f, 
    0.13252988f, 0.25588638f, -0.00774350f, -0.11509448f, 0.03572804f, -0.01014682f, 0.14367241f, 0.04079343f, 
    -0.04710924f, -0.22509043f, -0.15992031f, 0.28241938f, 0.08602492f, -0.22445041f, 0.01060475f, -0.01427083f, 
    -0.07936428f, 0.01383065f, 0.22283018f, -0.03417821f, 0.19079126f, 0.13551970f, -0.04873621f, -0.02304991f, 
    0.02446567f, 0.23915148f, 0.10045882f, 0.07196355f, -0.06207659f, 0.04140925f, -0.16487278f, 0.05956595f, 
    -0.06048429f, -0.03740605f, 0.03239901f, -0.16921173f, -0.16343339f, 0.09323414f, -0.24119766f, 0.11626809f, 
    0.04564091f, -0.20020911f, -0.00023113f, 0.04039907f, -0.29389879f, 0.03216473f, 0.35474414f, 0.16324633f, 
    0.03384322f, 0.05118990f, -0.01271146f, -0.09887648f, 0.06403269f, -0.10474217f, -0.16910474f, 0.32949248f, 
    -0.02312488f, -0.19257592f, -0.01656321f, 0.10036387f, -0.03032909f, -0.04071573f, 0.19915566f, -0.13559251f, 
    -0.42159498f, -0.04945917f, -0.08256598f, 0.10416085f, 0.06960119f, 0.00953757f, -0.15942805f, 0.05703694f, 
    0.00922877f, -0.19676712f, -0.09700668f, 0.30771235f, 0.17474829f, 0.03700041f, 0.11678347f, -0.18670258f, 
    0.15804751f, 0.06454340f, 0.11625119f, -0.11359207f, -0.21347827f, 0.10008403f, -0.02425795f, 0.09977694f, 
    -0.03641623f, 0.13638492f, 0.10794720f, -0.25321421f, -0.10198944f, -0.21593352f, 0.12297068f, 0.12534711f, 
    -0.09314703f, -0.00963301f, 0.04595571f, 0.33744696f, 0.10152482f, -0.11824528f, -0.13819215f, 0.00810406f, 
    -0.09995047f, 0.04005967f, 0.04463709f, -0.01998156f, -0.13648655f, -0.02726609f, 0.00752742f, -0.00994561f, 
    -0.17758605f, 0.10794636f, 0.10991208f, 0.16958217f, -0.07319456f, 0.26605287f, -0.15535451f, 0.17920470f, 
    0.08931919f, -0.02282928f, -0.10250776f, 0.01840116f, 0.02867178f, -0.04748548f, -0.11469463f, -0.35832116f, 
    -0.24859531f, -0.07720116f, 0.18458878f, -0.00755440f, 0.04238263f, -0.16016825f, -0.05413103f, 0.20672201f, 
    0.05205083f, -0.14980964f, 0.08682407f, 0.01348186f, 0.10330191f, -0.04731125f, 0.07883504f, 0.07558673f, 
    0.12826967f, -0.12684855f, 0.07295595f, -0.00319716f, -0.13328575f, -0.02873076f, 0.16495252f, -0.14995451f, 
    0.04169219f, 0.13969107f, 0.18515728f, -0.16375118f, -0.04102143f, -0.05433962f, -0.03382603f, 0.12816261f, 
    0.05976218f, 0.02753958f, 0.23982720f, 0.16421469f, 0.12748544f, -0.32650700f, -0.10320602f, 0.04176008f, 
    0.16154733f, -0.02953712f, 0.09252463f, 0.20872338f, 0.24413237f, 0.04516314f, -0.03027743f, -0.21597728f, 
    -0.15210445f, -0.18278636f, -0.04728896f, -0.13994153f, -0.16236275f, -0.42153135f, -0.11675940f, -0.03149266f, 
    0.12259292f, 0.02639334f, 0.17637680f, -0.21931265f, -0.00026501f, 0.11386389f, 0.15081185f, -0.04456299f, 
    0.04495367f, 0.01256114f, 0.11566872f, -0.02858923f, -0.05656140f, -0.17695001f, -0.00733025f, 0.10527629f, 
    0.01645399f, -0.00122519f, 0.17850548f, -0.01568753f, -0.11397833f, 0.05264313f, -0.20157997f, -0.25102869f, 
    -0.05052819f, -0.09553347f, 0.21349272f, -0.08704830f, -0.06021672f, -0.08682672f, 0.28076360f, -0.03540499f, 
    0.24253203f, 0.04811516f, -0.29915664f, -0.06170404f, 0.11915844f, -0.00252572f, 0.17964666f, -0.09165273f, 
    -0.01169972f, 0.01743538f, -0.13719593f, 0.09312846f, -0.04886168f, 0.09906100f, -0.06273640f, 0.09613573f, 
    -0.07053057f, 0.12596002f, -0.14860210f, -0.02345682f, 0.40240261f, 0.20999183f, -0.04254207f, 0.04800209f, 
    0.03199759f, -0.00990445f, -0.06655444f, -0.12723430f, 0.02877011f, 0.12472992f, 0.03269647f, -0.18855496f, 
    -0.29183060f, -0.02357323f, 0.18821689f, 0.11650925f, -0.01729400f, 0.11326386f, -0.02345616f, -0.21438104f, 
    0.12151781f, -0.07944304f, 0.02384705f, -0.17282501f, 0.11035630f, 0.60767931f, -0.02335989f, 0.13804454f, 
    0.19958618f, 0.09777449f, -0.02063799f, -0.05682139f, 0.19506519f, 0.13428716f, -0.17916559f, -0.62486655f, 
    0.12901363f, -0.00718931f, 0.22282235f, 0.11262511f, -0.10699588f, -0.08940594f, 0.15830626f, -0.25252855f, 
    0.24471614f, -0.00611178f, 0.11681265f, -0.07895558f, 0.12914108f, 0.12446011f, -0.16959803f, 0.12657441f, 
    -0.16296510f, -0.33055115f, -0.22685632f, -0.28864777f, 0.05584125f, -0.08420702f, 0.02044104f, 0.04401398f, 
    0.04559531f, 0.16883968f, 0.33102977f, 0.01392640f, -0.10431683f, 0.07333415f, -0.06827887f, -0.03015970f, 
    -0.13880560f, 0.03540966f, -0.14471927f, 0.22224118f, -0.10433505f, -0.02710018f, 0.11524344f, -0.05928928f, 
    -0.01349288f, 0.30199936f, 0.08165118f, 0.00534392f, -0.31281239f, -0.22199862f, 0.03874861f, -0.04162791f, 
    -0.13524352f, -0.09777077f, -0.08164506f, -0.01976248f, 0.18964079f, -0.25877252f, -0.02841898f, -0.06614389f, 
    -0.09567054f, -0.26674670f, -0.01584447f, 0.07371017f, -0.14362620f, -0.12523092f, 0.36542565f, -0.28084284f, 
    -0.02887870f, -0.06503165f, 0.01914839f, 0.03884986f, -0.00875135f, -0.10764875f, -0.15552481f, -0.18195775f, 
    -0.14654942f, -0.05011597f, 0.07198250f, -0.13105360f, 0.16486242f, 0.03917817f, 0.00718540f, -0.25645047f, 
    0.02798958f, -0.02253662f, 0.09718087f, 0.10628647f, 0.13125055f, -0.00246673f, 0.06891257f, -0.20636562f, 
    -0.09483059f, -0.03639493f, -0.06381725f, -0.10728909f, 0.08209551f, -0.23227826f, 0.38807324f, 0.00900872f, 
    0.00881530f, -0.28621584f, -0.14170972f, -0.29074228f, 0.01849058f, -0.04758759f, 0.27177995f, -0.27732140f, 
    0.22319718f, 0.26524809f, -0.57112980f, -0.09720675f, -0.10010009f, -0.08458351f, -0.20469616f, 0.14187211f, 
    0.00641542f, -0.30941257f, 0.25871411f, -0.25885510f, 0.30072328f, 0.13670342f, -0.08575064f, -0.10553315f, 
    0.21507677f, -0.01944998f, 0.13664661f, -0.24069884f, 0.11646156f, -0.09420603f, 0.14175054f, -0.03212317f, 
    -0.01096577f, 0.20775585f, 0.09361049f, -0.02118601f, 0.17405845f, 0.24992749f, -0.06251050f, -0.07971125f, 
    -0.18310748f, -0.02088128f, 0.05420423f, 0.05801935f, -0.07457348f, 0.07472616f, -0.07556149f, -0.08209506f, 
    0.20085016f, 0.08958615f, 0.05089177f, 0.01317329f, -0.15022673f, 0.15719239f, -0.01134440f, -0.08513156f, 
    0.05512260f, 0.14241461f, 0.26238701f, -0.13717619f, -0.07646449f, 0.00479645f, 0.14603236f, -0.08349805f, 
    -0.17311253f, 0.10551483f, -0.07776262f, 0.46745840f, 0.14154221f, -0.02779217f, -0.28124630f, -0.16511057f, 
    -0.13716273f, -0.09099329f, 0.35010234f, 0.19618008f, -0.20579417f, -0.05103090f, -0.04464928f, 0.15359104f, 
    0.04836832f, -0.03753546f, 0.12493463f, 0.22740607f, 0.09227268f, 0.11376752f, 0.09473071f, 0.34708181f, 
    0.07018182f, 0.11876991f, 0.16888665f, -0.13707961f, -0.16039217f, 0.30133140f, 0.29021257f, 0.28748116f, 
    0.11928251f, 0.22946630f, -0.03359692f, -0.06636236f, -0.24440137f, -0.16781498f, -0.32948917f, 0.22904867f, 
    0.04069530f, -0.21294251f, 0.01671490f, -0.24171060f, 0.10144414f, 0.02777176f, -0.08684608f, 0.05413457f, 
    0.22343828f, 0.23227742f, 0.14122768f, -0.15726325f, 0.00095894f, -0.18914670f, -0.10905956f, -0.21957347f, 
    -0.00159314f, 0.20823555f, -0.03229285f, -0.04291863f, 0.06806145f, 0.04567042f, 0.20454915f, 0.11529052f, 
    0.17870346f, 0.21836649f, 0.11950072f, 0.11410992f, -0.19265576f, 0.24994294f, 0.25812528f, 0.38473344f, 
    0.05052645f, -0.04133302f, 0.11789159f, -0.06029027f, -0.00173767f, -0.01720692f, 0.02847416f, 0.02201704f, 
    -0.07849908f, 0.09309632f, 0.05160177f, -0.04480680f, 0.20856255f, -0.24798748f, -0.08129549f, -0.07283121f, 
    0.06434510f, 0.05553251f, -0.27972990f, -0.13927345f, 0.04730404f, 0.12377412f, 0.07126480f, -0.16696538f, 
    0.10619219f, 0.03370096f, -0.24007908f, 0.03528389f, -0.01077414f, 0.10418481f, 0.00457986f, 0.13871221f, 
    -0.18085131f, -0.03581242f, -0.13433066f, 0.36976644f, 0.11533599f, 0.00511250f, 0.00416264f, 0.05803641f, 
    -0.02594754f, -0.03969479f, -0.18696687f, 0.13079207f, 0.14210784f, -0.13330874f, 0.07974829f, 0.26995698f, 
    0.08847812f, 0.06019979f, -0.21967137f, 0.15700741f, -0.04332650f, 0.12823673f, 0.11959145f, 0.04629962f, 
    0.11739850f, 0.22161987f, -0.11419791f, 0.16445974f, 0.05306787f, -0.09826409f, -0.15789820f, -0.30773729f, 
    -0.03312040f, 0.22297747f, 0.10255250f, -0.12319015f, 0.12930208f, 0.04930263f, -0.15502946f, -0.09288013f, 
    0.16884558f, 0.09178954f, 0.03798588f, -0.06607852f, -0.10097552f, -0.14858486f, 0.16810113f, 0.17378615f, 
    0.09232856f, -0.20268138f, -0.20385799f, 0.22928979f, -0.02649135f, -0.04373160f, 0.23206581f, -0.13592188f, 
    -0.10694480f, 0.23833007f, -0.03198734f, -0.00865543f, 0.02381216f, 0.04102634f, 0.01904970f, 0.01789882f, 
    0.03516144f, 0.15246402f, 0.02856561f, -0.04774304f, 0.11003310f, -0.07170636f, 0.11049599f, -0.10929877f, 
    -0.22692016f, 0.11655523f, -0.04851133f, -0.10832230f, 0.19903682f, 0.29706985f, -0.17769696f, -0.04492776f, 
    -0.01188690f, 0.10421629f, 0.10797298f, -0.00909552f, -0.03965105f, -0.12838677f, 0.13796914f, -0.02053961f, 
    0.10108966f, -0.09045024f, -0.08275706f, 0.31497368f, -0.00791681f, 0.00176371f, -0.12601726f, 0.19957192f, 
    -0.11330919f, 0.12318542f, 0.01095872f, -0.04705223f, -0.06203004f, -0.00141996f, 0.01695446f, 0.20615847f, 
    -0.26479551f, -0.08193569f, -0.22726876f, 0.17187111f, -0.02023898f, 0.01169737f, -0.10253264f, -0.27838111f, 
    -0.47503519f, -0.03737191f, -0.36355013f, -0.00198797f, -0.02125056f, 0.01051165f, -0.10592303f, -0.00758818f, 
    -0.05334229f, -0.02905710f, -0.17561772f, -0.12851351f, 0.04379653f, 0.13291681f, -0.13628016f, -0.03459040f, 
    0.04809244f, 0.09883878f, 0.43996838f, 0.14334035f, -0.10921809f, -0.01602271f, -0.08714952f, -0.10669532f, 
    0.11035270f, -0.17094338f, 0.07689697f, -0.44131720f, 0.23143287f, 0.09381969f, -0.04032857f, -0.03767426f, 
    -0.12528580f, -0.11221807f, 0.04127554f, 0.01909779f, 0.10116065f, -0.09227873f, -0.22745430f, 0.02342747f, 
    0.01476850f, 0.11750565f, -0.05278687f, 0.01587986f, -0.09287076f, -0.19410171f, 0.14339912f, -0.36727419f, 
    -0.06843730f, -0.00339633f, 0.12120508f, -0.08916858f, 0.04235212f, 0.01156769f, 0.11707926f, -0.10841845f, 
    -0.49425480f, 0.21023013f, 0.03692473f, 0.09131613f, -0.09389201f, 0.05111404f, -0.02508197f, 0.18299130f, 
    -0.09987866f, 0.07015584f, -0.00187447f, 0.12340693f, -0.07683657f, -0.09051739f, 0.02666754f, -0.13724844f, 
    0.39535618f, 0.21713610f, -0.03141704f, 0.18078950f, -0.00631582f, 0.11540238f, 0.06873303f, -0.07981985f, 
    -0.07722846f, -0.48815444f, 0.30427289f, -0.17133473f, -0.13122632f, 0.09425392f, 0.01975375f, -0.20293979f, 
    -0.02115758f, 0.11813101f, 0.11024816f, -0.26352400f, -0.04377691f, -0.04618442f, 0.01341420f, 0.12790558f, 
    -0.02673276f, 0.13334467f, 0.14041512f, 0.43261042f, 0.10879396f, 0.26874301f, 0.17898767f, 0.01343693f, 
    -0.09127966f, -0.08524550f, 0.13728482f, 0.15725327f, 0.48394153f, 0.07876743f, 0.01823320f, 0.04455306f, 
    -0.16732435f, -0.16388345f, 0.19405174f, 0.13058245f, -0.11269319f, 0.15223013f, 0.19087411f, 0.19502379f, 
    0.01296545f, 0.08870368f, 0.00936126f, 0.10807437f, 0.14370133f, 0.09016301f, 0.28340805f, 0.01748209f, 
    0.20801945f, 0.01521127f, -0.00677713f, -0.24023494f, 0.02003966f, -0.12207008f, 0.16044067f, -0.32687822f, 
    -0.35692784f, -0.04228037f, -0.10013511f, 0.20877662f, 0.02956789f, -0.19838308f, 0.29957426f, 0.02580270f, 
    0.24728456f, 0.12576880f, -0.11423387f, -0.19893618f, -0.10264969f, -0.12943546f, 0.23083226f, -0.06123115f, 
    -0.00802233f, 0.45077491f, 0.15747023f, -0.01832053f, 0.08418163f, -0.07921868f, 0.20689318f, -0.04322976f, 
    0.07399122f, -0.09298589f, -0.22392508f, 0.16028754f, 0.25829411f, 0.07872418f, 0.22502819f, -0.10549755f, 
    -0.12575771f, -0.09717394f, 0.08170918f, -0.03631859f, 0.08601844f, -0.33912179f, 0.12421771f, 0.07219896f, 
    0.21894355f, -0.02192370f, -0.17872493f, -0.13348253f, 0.17707613f, 0.18795136f, -0.25330445f, 0.13772808f, 
    0.13008679f, 0.17469238f, -0.28797483f, 0.01848117f, -0.30002880f, -0.02325974f, 0.16962393f, -0.13704295f, 
    -0.25492164f, 0.06794978f, 0.23526770f, 0.00225249f, -0.03385715f, -0.05028678f, 0.19181921f, 0.19719733f, 
    -0.08316954f, -0.35452393f, -0.02471710f, -0.13853094f, -0.15945183f, 0.00438670f, 0.20121293f, 0.35218215f, 
    0.02086366f, -0.10518362f, -0.00002865f, 0.01438470f, -0.27162287f, 0.07726432f, 0.08474959f, -0.20171782f, 
    -0.04552159f, 0.01262286f, 0.21789594f, 0.04693511f, -0.03860612f, -0.00368658f, -0.29260588f, 0.02485203f, 
    0.22644363f, 0.09815346f, -0.24341848f, -0.26331502f, -0.06219719f, 0.06873637f, 0.00189555f, 0.17612486f, 
    0.08348277f, -0.37182719f, 0.20169850f, -0.15951422f, -0.30400869f, -0.02552735f, 0.28830406f, 0.13910893f, 
    0.12645110f, 0.02345241f, -0.20700665f, -0.14125025f, -0.16080491f, -0.09757543f, 0.25605223f, -0.03724721f, 
    0.27196938f, -0.06429633f, -0.01679533f, -0.27287647f, -0.18646266f, 0.05112907f, 0.45447487f, 0.01119289f, 
    -0.09542508f, -0.10564210f, -0.25090674f, 0.35103291f, 0.06638539f, 0.00619019f, 0.11307111f, 0.16915680f, 
    0.05519930f, -0.03297900f, 0.11946296f, 0.01025257f, -0.08477695f, 0.02937042f, 0.06184526f, -0.09943896f, 
    0.18265967f, -0.00584782f, -0.13876417f, 0.00856903f, -0.04419389f, 0.12030376f, 0.01349592f, 0.23221244f, 
    0.03457864f, -0.03089802f, 0.13175587f, -0.12663671f, 0.05979332f, -0.02683464f, -0.06212964f, 0.02938450f, 
    0.33074635f, 0.20556585f, 0.22373675f, -0.09934125f, 0.11384581f, 0.01783637f, 0.09083048f, 0.02441734f, 
    -0.04258250f, -0.16356096f, -0.07197491f, -0.21528895f, -0.26997143f, -0.09145999f, 0.07235062f, 0.03253702f, 
    0.17441301f, 0.26079744f, 0.25705698f, -0.03908423f, -0.08085575f, -0.04388281f, -0.21500848f, 0.10516790f, 
    -0.05390307f, -0.04149781f, 0.15010837f, -0.69146508f, -0.46674138f, 0.01801857f, 0.06636424f, 0.05780323f, 
    -0.02726042f, 0.05754437f, -0.05666387f, 0.20940395f, -0.09143696f, -0.14097950f, -0.10031200f, 0.04281068f, 
    0.13218191f, -0.09446283f, -0.07221173f, -0.11654973f, -0.22413294f, -0.15668659f, -0.08489060f, 0.13301431f, 
    0.00555310f, -0.04244471f, -0.11888331f, -0.13224930f, 0.09186759f, 0.25037742f, -0.17896993f, -0.17756212f, 
    -0.03850554f, -0.06123839f, 0.02192026f, 0.04840101f, 0.13511720f, -0.06785543f, -0.14117961f, -0.06995770f, 
    -0.19165790f, 0.12201722f, 0.07962862f, -0.04532204f, -0.05470121f, 0.02662023f, -0.09781530f, -0.05974438f, 
    0.34419405f, 0.33183593f, -0.00550100f, 0.11142872f, 0.21711458f, -0.03361321f, 0.16899408f, 0.00198748f, 
    -0.03088363f, -0.12006159f, -0.15040179f, -0.14904028f, 0.20344254f, 0.02472421f, 0.19199041f, -0.10045569f, 
    -0.09994791f, 0.03052715f, -0.24868026f, -0.42576775f, -0.15490523f, -0.02105505f, 0.19176455f, -0.05223951f, 
    0.04327666f, 0.00245806f, 0.02435719f, 0.06511252f, 0.13704868f, -0.12866288f, -0.05443282f, 0.09335399f, 
    -0.06611250f, 0.09156705f, 0.11187296f, 0.07526415f, 0.27602866f, 0.03228927f, -0.09375800f, 0.03826287f, 
    -0.04972976f, -0.03389123f, -0.05190409f, 0.02552719f, -0.07551113f, -0.08187265f, 0.24122497f, 0.09611480f, 
    0.05528625f, 0.04401790f, 0.17529666f, 0.03724021f, 0.21837644f, -0.14937580f, 0.21528044f, 0.20688590f, 
    -0.10613642f, -0.04668568f, -0.23165689f, 0.09626329f, -0.15813082f, 0.13135116f, 0.04874241f, 0.18692049f, 
    -0.07386236f, 0.04179714f, 0.06562052f, 0.12578203f, 0.06866124f, -0.14223260f, 0.07227451f, -0.20774892f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.09314846f, -0.09592608f, 0.17265749f, 0.00987676f, -0.07755909f, 0.30037013f, 0.16651809f, 0.16593775f, 
    0.06183930f, 0.12019667f, 0.25488356f, 0.32650271f, -0.11806780f, 0.06621112f, -0.06190920f, 0.11527104f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.15278403f, 0.00445257f, -0.37356088f, -0.43509170f, 0.56225151f, -0.06189389f, 0.32026735f, -0.23364501f, 
    -0.24556148f, -0.43761253f, 0.39689407f, -0.12897183f, 0.33654681f, 0.21443379f, 0.04621670f, 0.66192973f, 
    0.37949577f, -0.23473461f, 0.46329796f, -0.42773691f, 0.47537637f, 0.13700220f, -0.12228004f, -0.23424175f, 
    -0.04506188f, -0.29596889f, -0.56026143f, 0.08334050f, 0.23078433f, 0.57226968f, -0.07112688f, -0.16048430f, 
    0.13191022f, 0.00417953f, 0.20810132f, 0.60708094f, -0.41054142f, 0.57122463f, -0.08061229f, 0.38843808f, 
    0.87433636f, 0.25144130f, 0.53578550f, -0.19209138f, 0.44618979f, -0.38257346f, -0.11126859f, 0.21029374f, 
    0.06520922f, -0.19809829f, 0.23239978f, 0.25096247f, 0.21086088f, -0.03490078f, 0.38419414f, -0.00663784f, 
    0.01223073f, -0.18412170f, -0.00065887f, 0.04867066f, 0.53248584f, 0.41595635f, -0.24490534f, 0.56650293f, 
    0.58091950f, 0.17525710f, -0.28249484f, -0.42940107f, -0.13986918f, -0.22751153f, -0.38088465f, 0.10599329f, 
    -0.16281308f, 0.49146578f, 0.11298466f, 0.31792912f, -0.03335841f, 0.55209273f, 0.24251005f, -0.14446703f, 
    -0.01492905f, 0.16974869f, -0.15379804f, 0.44095919f, -0.06764729f, -0.46608105f, 0.12644659f, -0.12383459f, 
    -0.51058072f, 0.40728775f, -0.26693556f, 0.17260838f, -0.43662664f, 0.23277207f, 0.16768548f, 0.04542550f, 
    0.05802690f, -0.00477434f, -0.24131241f, -0.26662287f, -0.07451873f, -0.11304202f, 0.08541555f, 0.30664799f, 
    -0.63831723f, -0.09986815f, 0.53129965f, 0.42217395f, -0.49893248f, -0.09304918f, 0.16471574f, -0.36378187f, 
    0.53267246f, 0.14625219f, 0.01091308f, 0.23882097f, -0.08069012f, -0.21825118f, -0.12775336f, -0.18590489f, 
    0.41574979f, 0.39233649f, -0.20708095f, -0.14014006f, 0.48867351f, 0.49877748f, -0.05289611f, 0.44034839f, 
    -0.34564394f, 0.14952826f, 0.32558337f, -0.11667542f, 0.09373266f, 0.82011777f, -0.30643210f, 0.30018640f, 
    0.61552602f, -0.06449311f, 0.08415724f, 0.06575124f, 0.19125073f, -0.05983625f, -0.39160272f, 0.28346086f, 
    -0.08930161f, -0.08991065f, 0.31135643f, -0.50194252f, -0.09082837f, 0.06339387f, -0.20750803f, 0.15570265f, 
    0.39898938f, 0.35937080f, 0.21012515f, 0.44231474f, -0.11008462f, 0.11703476f, -0.12270525f, -0.42983893f, 
    0.14326648f, 0.17993745f, 0.04930767f, 0.15199043f, 0.29921240f, 0.09413647f, 0.16094863f, 0.08105512f, 
    -0.11148605f, -0.21577896f, -0.31088504f, 0.22907257f, 0.27263930f, -0.53888482f, 0.21212369f, -0.24781691f, 
    0.16820814f, -0.20633815f, -0.21839915f, 0.43125984f, -0.48896569f, 0.52525991f, 0.06193890f, 0.27533394f, 
    0.01584833f, -0.37186185f, 0.64514029f, 0.02492514f, 0.41348365f, -0.26621404f, 0.07406970f, 0.51855087f, 
    0.13582356f, -0.23274584f, -0.40636811f, 0.80915534f, -0.44315907f, 0.10739692f, 0.27795625f, 0.55597192f, 
    0.08675908f, -0.12138990f, -0.03639100f, 0.32355806f, -0.13217792f, -0.16383466f, -0.02631995f, -0.01022921f, 
    -0.22633761f, -0.07668768f, -0.07794960f, 0.00350146f, 0.51554668f, -0.12738764f, 0.37979752f, 0.07537457f, 
    -0.76612669f, -0.41657838f, -0.30941236f, 0.41626018f, 0.15960319f, 0.26789501f, 0.03177267f, -0.10523590f, 
    -0.11054500f, -0.15958631f, -0.24950793f, 0.12142115f, 0.13492188f, 0.74803108f, -0.13166331f, 0.01600800f, 
    -0.20453764f, -0.36346272f, -0.11288970f, -0.00364280f, 0.29878345f, 0.58050466f, 0.57265157f, 0.02022155f, 
    -0.06687516f, -0.07181245f, 0.24658313f, -0.15666440f, -0.16040972f, -0.06225082f, 0.23591790f, -0.19083151f, 
    -0.03162715f, 0.17580789f, -0.06792215f, -0.22005951f, -0.05252767f, -0.21918851f, -0.21851745f, -0.19519010f, 
    -0.38841096f, -0.04091625f, 0.40798008f, -0.26551834f, 0.40284386f, -0.06144199f, 0.34933063f, 0.12125177f, 
    -0.00147724f, 0.02175067f, -0.24181679f, 0.07583321f, 0.41159958f, -0.13555495f, -0.36735573f, 0.13533023f, 
    -0.09741867f, 0.21519689f, 0.09894828f, -0.11420690f, 0.19301338f, 0.18926482f, 0.00005804f, -0.21788189f, 
    -0.14838161f, 0.07026102f, -0.14316437f, -0.19540991f, -0.25165311f, -0.05872945f, 0.10802964f, -0.20721619f, 
    -0.46198654f, 0.20033596f, 0.51231647f, -0.38877553f, -0.23708177f, 0.41695896f, 0.09837507f, 0.29318947f, 
    -0.26681408f, -0.21413612f, 0.14335832f, 0.37229398f, 0.01924467f, 0.32935694f, -0.44454601f, 0.19722556f, 
    -0.26463425f, 0.03920668f, -0.14982496f, -0.03949565f, -0.00306472f, -0.08539650f, -0.25911143f, -0.26111442f, 
    -0.22760268f, -0.07613495f, 0.10129961f, 0.06741474f, 0.14664111f, 0.05406956f, -0.27939993f, -0.19056302f, 
    0.30127579f, -0.09664273f, -0.35125744f, 0.63877952f, 0.08291843f, -0.31883425f, 0.36076942f, 0.16795962f, 
    0.22684024f, 0.17095837f, 0.36106980f, -0.03936861f, -0.20023781f, -0.34993240f, 0.25411761f, 0.35110986f, 
    -0.05865061f, 0.06520405f, 0.13287500f, 0.32713139f, 0.11521018f, 0.19152954f, -0.31764060f, 0.01735794f, 
    0.23592514f, -0.33397380f, -0.03178403f, -0.12502739f, -0.05355800f, 0.16915390f, 0.22589199f, -0.37122911f, 
    0.04098776f, 0.17829067f, 0.07874982f, 0.08969227f, 0.13882713f, -0.03012789f, -0.42514047f, 0.14761177f, 
    0.34176862f, 0.53631032f, 0.34315598f, 0.03418337f, -0.31934789f, 0.29773882f, 0.02471130f, 0.05488097f, 
    -0.29948431f, -0.12426531f, -0.00949449f, -0.20042315f, -0.02147900f, -0.74031526f, -0.00508667f, 0.54788029f, 
    -0.48177937f, 0.45827153f, 0.30104572f, 0.24072446f, -0.53241640f, -0.00302604f, -0.02999181f, -0.25703168f, 
    0.05790759f, 0.05911305f, 0.35716215f, 0.05561953f, 0.24777102f, 0.22144036f, 0.25700116f, 0.19885798f, 
    0.02114229f, -0.27397019f, -0.54717052f, 0.16580394f, 0.14704435f, -0.51861459f, 0.46439776f, -0.38276052f, 
    -0.01792700f, 0.10564391f, 0.32927540f, 0.44885734f, -0.18200071f, 0.66848308f, 0.12224470f, 0.38440651f, 
    0.36052403f, 0.32254162f, 0.27350658f, 0.28875652f, 0.06415378f, -0.34678039f, -0.35674390f, -0.02109041f, 
    -0.19930808f, 0.03391860f, -0.54045385f, 0.44965115f, 0.03994864f, 0.21422344f, 0.56848145f, 0.22409968f, 
    -0.01116470f, -0.18389843f, 0.12971677f, 0.14826682f, -0.04231137f, -0.22092290f, 0.40641078f, 0.29314923f, 
    0.43484363f, 0.22208655f, 0.07956792f, 0.61230057f, -0.35257864f, -0.05010045f, -0.08505344f, -0.33319637f, 
    0.79946977f, 0.27878150f, -0.09497819f, 0.01892019f, -0.08474380f, 0.29966536f, 0.46776858f, -0.08737706f, 
    0.19543393f, -0.23155518f, 0.02023314f, -0.18729052f, 0.51050603f, -0.75186568f, 0.46770683f, -0.30166131f, 
    -0.01008550f, -0.22264761f, -0.16494477f, 0.02568141f, 0.17586409f, -0.26567861f, 0.28087080f, 0.30500928f, 
    -0.53671110f, 0.12566489f, 0.05099592f, -0.21819931f, 0.01607111f, 0.25769660f, -0.22996907f, 0.09759032f, 
    -0.83945227f, 0.26940814f, 0.19362214f, 0.36722946f, -0.38410974f, 0.45984459f, 0.36693114f, 0.01902562f, 
    0.44565839f, -0.13695587f, 0.17087196f, -0.21504477f, 0.28215256f, -0.54023886f, 0.41432875f, -0.33667988f, 
    -0.49983984f, 0.18510574f, -0.00830812f, 0.04527346f, -0.08433827f, -0.11415932f, 0.05977815f, 0.41144806f, 
    -0.49486053f, 0.18335602f, -0.41223431f, 0.48668543f, 0.16166511f, -0.21521266f, 0.16381507f, 0.04880581f, 
    0.07419204f, -0.48152462f, -0.21571742f, 0.47287270f, -0.07184659f, -0.04897715f, -0.21623752f, -0.20289500f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.06437352f, -0.06826572f, -0.11359756f, 0.36897480f, 0.13957937f, -0.02389347f, 0.38659069f, 0.08434490f, 
    -0.20802875f, 0.10854946f, 0.08523273f, -0.02307976f, 0.03692614f, 0.39842352f, -0.65531194f, -0.17215571f, 
    0.33321643f, -0.24988361f, 0.46798751f, 0.14320374f, 0.09573790f, 0.17674284f, -0.08171911f, -0.06584650f, 
    0.24308984f, 0.31026638f, -0.36870596f, 0.10855302f, 0.30535263f, 0.07559273f, 0.10774748f, 0.38521823f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.14986318f, -0.08757059f, -0.15174249f, -0.08628640f, -0.15532556f, 0.07217102f, -0.07402107f, -0.01500442f, 
    -0.01658157f, -0.14201459f, -0.10501543f, 0.09045887f, -0.10181902f, 0.04798345f, 0.15385346f, -0.11395366f, 
    -0.03378991f, 0.01288242f, -0.15138534f, -0.17366029f, -0.01552275f, -0.12874351f, -0.02441285f, -0.01292728f, 
    -0.05919655f, 0.12301645f, -0.01334002f, -0.03083092f, 0.15328310f, 0.04324955f, -0.11452995f, 0.13083719f, 
    1.08912838f, -0.10471410f, -0.09371137f, 0.11816429f, 0.18089542f, 0.04243832f, 0.76109165f, -0.18617974f, 
    0.15656513f, -0.11105681f, -0.04619057f, 0.43270734f, 0.13849524f, 0.31404984f, 0.04414397f, 0.06017084f, 
    -0.01245384f, -0.09629548f, 0.03014530f, -0.06092404f, 0.24817027f, -0.34626368f, 0.01979042f, 0.16429707f, 
    -0.28618333f, 0.02788458f, 0.36068809f, -0.39605108f, 0.14513475f, 0.12640655f, 0.21469374f, -0.08478329f, 
    -0.02017344f, 0.03318249f, 0.02790862f, 0.03524675f, -0.07184729f, 0.14107738f, -0.07931373f, -0.10033695f, 
    0.12064052f, 0.01467577f, -0.10030667f, -0.02401882f, -0.17701425f, -0.16609247f, -0.15020430f, 0.16261691f, 
    0.09482394f, -0.11492122f, -0.06053465f, 0.06376325f, -0.09799398f, -0.07314704f, -0.08671384f, -0.14710678f, 
    -0.17698695f, 0.04975304f, 0.08445961f, -0.05625242f, 0.08696690f, -0.16643319f, -0.08319274f, -0.09788746f, 
    -0.09223527f, -0.72937232f, 0.74151099f, 0.22862354f, -0.14954586f, -0.32047257f, 0.03187242f, 0.07305045f, 
    0.52345806f, -0.04193229f, -0.04213526f, 0.69770914f, 0.37536672f, -0.18004011f, -0.26690266f, 0.02761493f, 
    0.36434442f, -0.05102543f, 0.29152331f, -0.08935844f, 0.34433386f, 0.07531929f, 0.16386889f, 0.28976938f, 
    -0.17246826f, 0.41967231f, 0.11019083f, 0.10845602f, -0.13969636f, 0.05875194f, 0.17793328f, 0.15859510f, 
    0.07559438f, 0.00290865f, -0.16863145f, -0.11263449f, -0.05683328f, -0.10349002f, -0.09399490f, 0.14333032f, 
    0.03513331f, 0.04837953f, -0.01208392f, -0.03125699f, -0.13987167f, -0.07180986f, -0.16745149f, 0.04273279f, 
    -0.17408815f, 0.02928890f, -0.07714411f, -0.03876511f, -0.05464625f, 0.09801161f, -0.00679606f, -0.07893164f, 
    0.06740478f, 0.08032586f, -0.13002491f, -0.12547219f, -0.14559646f, -0.07405959f, 0.10391208f, 0.17248328f, 
    0.29374301f, 0.08969269f, -0.39130810f, 0.07992867f, 0.14957173f, 0.33677807f, 0.60463995f, -0.25495708f, 
    -0.30964357f, 0.16838695f, 0.12397790f, -0.16597094f, -0.13564999f, 0.51454562f, -1.14624214f, -0.11255415f, 
    0.56152886f, -0.04104976f, 0.38994172f, -0.13132423f, -0.16526361f, -0.00753387f, -0.36913803f, 0.16594298f, 
    0.17163804f, 0.25405601f, 0.11221267f, -0.11007327f, 0.40382060f, 0.28645030f, 0.82556796f, -0.21356989f, 
    -0.00630040f, -0.11339193f, -0.04156547f, -0.09555634f, 0.02098723f, -0.00894161f, 0.10093204f, 0.05513582f, 
    0.11807563f, -0.18455312f, -0.08609510f, 0.06279439f, -0.11170092f, 0.13605708f, 0.01599714f, -0.11603750f, 
    -0.10263987f, 0.01717231f, -0.16084851f, 0.11429791f, -0.04651279f, -0.01748050f, 0.01667487f, 0.03483109f, 
    0.09206466f, -0.06507505f, -0.18787163f, -0.10522383f, -0.12673050f, 0.09930944f, 0.05817014f, 0.07817696f, 
    0.56868494f, 0.17826612f, -0.04986647f, 0.18581152f, -0.23107491f, -0.26670712f, -0.01453198f, -0.21490456f, 
    0.48366648f, -0.09383528f, 0.70471352f, 0.15272939f, -0.08246974f, 0.40514806f, 0.13060281f, -0.03134196f, 
    0.41905496f, 0.12606606f, 0.17340833f, -0.13751785f, 0.08851935f, -0.11822550f, -0.42442024f, -0.33554268f, 
    0.75235230f, 0.11619066f, -0.04560495f, 0.03141601f, 0.26204911f, 0.08158416f, -0.00737185f, 0.47234219f, 
    -0.51123637f, -0.23476805f, 0.30166268f, -0.24228416f, 0.22325550f, 0.36851045f, 0.44130144f, 0.13595946f, 
    -0.48727921f, 0.01514725f, 0.26425779f, 0.14875005f, 0.41850182f, -0.07591153f, 0.10200936f, -0.05543379f, 
    -0.44814444f, 0.08366658f, -0.46055925f, -0.04290273f, 0.14696552f, -0.00886115f, 0.04092698f, 0.39628521f, 
    0.42152858f, 0.12206279f, 0.27581814f, 0.25837913f, -0.24448062f, 0.00518597f, -0.09087241f, 0.34529403f, 
    0.01949644f, 0.03350838f, -0.06113533f, -0.12851273f, -0.18150017f, 0.11335304f, 0.07028449f, 0.00932879f, 
    0.10197185f, 0.04441517f, 0.02872206f, 0.02197764f, -0.11370554f, -0.04965263f, 0.09312770f, -0.01342322f, 
    0.12780005f, 0.09207164f, -0.11311935f, -0.14277188f, -0.17265034f, -0.10257617f, -0.11105945f, 0.01187616f, 
    -0.06969124f, -0.05746615f, -0.09495798f, -0.11378853f, 0.03748402f, 0.01801807f, -0.16816571f, 0.10078353f, 
    -0.67251658f, 0.15293518f, -0.00589226f, 0.09604766f, -0.24290873f, -0.04141103f, -0.08658227f, -0.32563642f, 
    0.54706687f, 0.14678316f, 0.11867218f, 0.09145520f, 0.43557826f, 0.26449242f, 0.04397598f, -0.12062681f, 
    0.46121275f, 0.08876766f, 0.32685173f, -0.02679702f, -0.12567019f, 0.18728013f, -0.14705789f, -0.03021461f, 
    0.21603829f, 0.33767346f, 0.17941333f, -0.24965206f, -0.28252700f, 0.02158942f, -0.45440423f, 0.61623693f, 
    0.06795939f, -0.09154190f, 0.08462404f, -0.15626374f, 0.07924716f, -0.16422561f, 0.13015567f, -0.11456489f, 
    -0.15369426f, 0.08055154f, 0.10971358f, -0.10457722f, -0.02045724f, -0.14009979f, -0.03649418f, -0.00484621f, 
    -0.05570479f, -0.03019356f, -0.06140760f, -0.09109377f, -0.07849475f, 0.10253559f, -0.14249966f, -0.10574345f, 
    -0.15537764f, 0.05226064f, -0.14351775f, -0.01373151f, -0.13824455f, -0.12962306f, -0.01415664f, -0.05073014f, 
    -0.08853675f, 0.23346327f, -0.06242395f, 0.20289631f, 0.09103222f, -0.04797284f, -0.13358602f, -0.03450136f, 
    0.35601619f, 0.25503168f, -0.08943632f, -0.09091217f, 0.43915215f, 0.11972354f, -0.07947519f, -0.14494197f, 
    0.05839559f, -0.01309694f, 0.59799469f, -0.13181688f, -0.06079419f, -0.05138694f, 0.07901733f, -0.24026568f, 
    0.04992016f, 0.21461798f, -0.29131258f, -0.00317677f, -0.14153501f, 0.05914073f, -0.34913862f, 0.01559551f, 
    0.16440053f, -0.11629488f, -0.06144109f, 0.19398491f, -0.15090796f, 0.40470073f, -0.33867314f, -0.05482354f, 
    -0.17130913f, -0.35871267f, 0.43303674f, -0.27219513f, 0.26027432f, 0.33335635f, 0.14829382f, -0.01348143f, 
    0.04130247f, -0.09783059f, -0.45682085f, -0.08552290f, 0.11230423f, -0.11580914f, -0.33013323f, -0.19189000f, 
    0.54285878f, -0.02752510f, 0.52434886f, 0.19419193f, 0.48698702f, 0.10042083f, 0.25193647f, 1.26361680f, 
    0.09596974f, 0.18303429f, -0.24524432f, -0.07273036f, 0.07435771f, -0.05370563f, 0.47609189f, -0.27464789f, 
    0.57827628f, 0.29473788f, 0.00389445f, -0.35655138f, -0.12122925f, 0.17350970f, 0.25488025f, 0.09931462f, 
    0.33377150f, -0.05377734f, 0.31535053f, -0.12713076f, -0.19011873f, 0.27918127f, 0.19759695f, 0.36311007f, 
    -0.04863473f, 0.09425592f, -0.19094849f, 0.00081555f, -0.04832875f, 0.39695576f, -0.05908071f, -0.58335632f, 
    -0.14739123f, 0.02443013f, -0.15327083f, -0.12633614f, -0.00137030f, -0.13097622f, -0.00488294f, -0.10621610f, 
    -0.02333755f, 0.13747451f, 0.08241805f, 0.04919353f, -0.12264568f, -0.04482770f, -0.10490968f, 0.17642698f, 
    0.11877608f, 0.15121782f, -0.17269422f, -0.01580640f, -0.05701672f, -0.03251735f, -0.13486189f, 0.04093551f, 
    -0.11131960f, 0.13769278f, -0.08698260f, 0.00171000f, -0.12098596f, -0.09147874f, -0.13625823f, 0.00340920f, 
    -0.27798086f, -0.75952733f, 0.42700693f, -0.02171504f, -0.26616618f, 0.25409740f, 0.09751272f, -0.19683829f, 
    0.10557397f, -0.23875338f, 0.11717980f, -0.01943373f, 0.35292804f, -0.04015452f, 0.17011148f, 0.10800511f, 
    -0.10438498f, 0.18171608f, -0.16820544f, 0.07377113f, 0.30323669f, 0.02224852f, 0.04058894f, 0.25361258f, 
    0.15275922f, 0.18656434f, 0.33608183f, -0.04848668f, -0.20836082f, -0.06641348f, -0.04341548f, 0.47452337f, 
    -0.51247579f, 0.21783754f, -0.30669022f, 0.04261833f, 0.09642771f, 0.26953200f, 0.28997943f, 0.31893474f, 
    -0.24449575f, 0.33286938f, 0.10204279f, -0.62875378f, -0.15486324f, -0.07953409f, -1.01594520f, 0.09616246f, 
    0.55329674f, -0.03935316f, 0.09380536f, 0.18846904f, 0.09783768f, 0.47271764f, 0.32924795f, 0.63047403f, 
    0.10451467f, 0.17666084f, -0.34802911f, 0.05899860f, 0.27833369f, 0.08248723f, 0.30105007f, 0.19764113f, 
    0.27462554f, 0.25994518f, -0.01361099f, 0.32613036f, 0.23509057f, 0.46063104f, -0.25891483f, 0.62412578f, 
    -0.23603986f, -0.20310651f, -0.20848665f, -0.15757270f, -0.06732325f, 0.13427565f, 0.17899500f, 0.13304660f, 
    -0.22168899f, -0.07570282f, -0.02881472f, -0.00855307f, 0.26679540f, -0.04569599f, 0.25167856f, -0.17732437f, 
    -0.40964267f, -0.13107909f, -0.13563208f, 0.20417839f, 0.19684429f, -0.00460461f, 0.40138111f, 0.20057687f, 
    -0.13746510f, 0.02971653f, -0.02868286f, 0.16527107f, -0.05828967f, 0.13105798f, -0.12495229f, 0.12447477f, 
    -0.15008490f, -0.14803335f, -0.45632413f, 0.27812377f, 0.15048996f, 0.18435974f, 0.60908538f, 0.12332775f, 
    -0.23257415f, -0.04616812f, 0.47147703f, 0.03155516f, -0.18513648f, -0.54272735f, 0.02247228f, -0.13931435f, 
    -0.48497945f, 0.03133644f, -0.09591340f, 0.16705298f, -0.43691498f, 0.42021707f, -0.29874822f, 0.05169167f, 
    0.02224964f, -0.07922634f, -0.13247482f, -0.03390237f, -0.15027535f, 0.09775081f, -0.07518993f, 0.06207873f, 
    -0.02851284f, 0.02188034f, -0.16153006f, -0.03997318f, -0.12217026f, 0.09119833f, -0.03787370f, -0.10683044f, 
    0.06918354f, 0.09319102f, 0.02736543f, 0.17151694f, 0.01471623f, -0.01587887f, -0.11947926f, -0.04406160f, 
    -0.05095812f, 0.10292437f, -0.07687585f, -0.13112970f, 0.13079005f, -0.16384301f, -0.12626638f, 0.04076564f, 
    -0.52981550f, -0.11247123f, -0.15575753f, 0.11565276f, 0.28683576f, 0.35387969f, 0.89812875f, -0.16272226f, 
    -0.06679634f, 0.51522905f, -0.26097858f, -0.20930129f, 0.23571353f, 0.23704338f, -0.02638832f, -0.02937106f, 
    -0.11182032f, -0.06973621f, 0.45723760f, 0.12853217f, -0.18949440f, 0.55390555f, 0.48338795f, 0.68762159f, 
    -0.07574961f, 0.07562578f, 0.06481004f, 0.07000756f, -0.35750222f, 0.47678608f, -0.37800857f, -0.12750274f, 
    -0.05809144f, -0.17215696f, 0.28542471f, 0.02346445f, 0.27146718f, -0.09108186f, 0.05347567f, 0.03835658f, 
    0.32452682f, 0.38610941f, -0.36113548f, 0.03428028f, -0.20304345f, -0.16244645f, 0.16945767f, 0.04095335f, 
    -0.13761772f, -0.16405296f, 0.09697124f, -0.03603392f, -0.04018999f, 0.29336029f, 0.42706889f, 0.33183867f, 
    -0.11294466f, 0.23314749f, -0.25306711f, 0.16616893f, -0.27374944f, 0.49732599f, -0.34393513f, -1.21195352f, 
    -0.13905652f, -0.05565748f, 0.02163220f, -0.11504380f, 0.07919636f, 0.06787092f, 0.00315891f, -0.17414828f, 
    -0.03533436f, -0.17261796f, 0.10524964f, -0.13587090f, 0.00424602f, -0.00659402f, -0.15550227f, 0.15608327f, 
    -0.08159669f, -0.14805321f, -0.13037731f, 0.01745307f, 0.00679270f, -0.01287755f, -0.17943759f, -0.05312911f, 
    -0.06855626f, -0.16333993f, 0.09729540f, 0.01476967f, -0.04999711f, -0.05702034f, 0.09241926f, -0.14613649f, 
    -0.03649123f, -0.15589625f, 0.08613605f, 0.05033219f, -0.08100706f, -0.06564452f, -0.11511128f, -0.05624130f, 
    -0.07326052f, -0.05507902f, 0.13794406f, -0.12687290f, -0.00370439f, -0.12914610f, 0.09408601f, -0.12756838f, 
    0.02582039f, 0.16170456f, -0.01794393f, 0.16787298f, -0.17705138f, 0.05744318f, -0.01242358f, -0.00678660f, 
    -0.18095964f, 0.01627585f, 0.07487538f, 0.12171841f, -0.08846013f, 0.08118728f, -0.01281277f, 0.11407548f, 
    -0.13087161f, -0.04037033f, -0.02790496f, -0.07785117f, -0.13558598f, 0.03713628f, -0.19218771f, -0.14489652f, 
    -0.15454617f, -0.07633762f, 0.02875573f, 0.16216171f, -0.14429601f, 0.12285063f, 0.07398452f, 0.02726515f, 
    0.00210553f, 0.12313347f, -0.03680785f, 0.07080009f, -0.13952753f, 0.11681528f, 0.03223864f, -0.10764301f, 
    0.06677864f, 0.08698736f, -0.13450170f, -0.16814773f, -0.08991057f, 0.04172635f, 0.06475931f, 0.08889222f, 
    0.44468957f, 0.37885827f, -0.24793987f, 0.10846025f, 0.24324931f, 0.68016499f, -0.42590660f, 0.52086306f, 
    -0.61464101f, -0.35104433f, 0.12504221f, 0.02465517f, -0.19531518f, 0.05392261f, 0.41463724f, 0.05960477f, 
    -0.32485139f, 0.11543893f, -0.47100106f, 0.13280138f, 0.01922352f, -0.19313419f, 0.05285528f, -0.20387183f, 
    0.10297262f, 0.02411558f, 0.26326445f, 0.25113040f, 0.39786586f, 0.14094879f, 0.42386070f, 0.62015742f, 
    -0.28018606f, -0.25071579f, 0.11652922f, -0.10914849f, 0.08073209f, 0.21101134f, 0.64741820f, -0.26204222f, 
    -0.40336230f, -0.01163441f, 0.26085705f, 0.23016068f, 0.59142703f, -0.08798371f, -0.07421059f, 0.00408262f, 
    -0.32780635f, -0.17723352f, -0.16364914f, 0.13335162f, 0.41540441f, -0.18480955f, 0.02812889f, 0.34551188f, 
    0.12978972f, 0.11905406f, 0.23334865f, 0.25896865f, 0.06720469f, -0.04335836f, -0.13330187f, 0.83057553f, 
    0.58021849f, -0.07518829f, 0.55149281f, 0.22293468f, 0.20330605f, -0.64595866f, -0.59827232f, 0.52346700f, 
    0.48277089f, 0.15564936f, -0.18707013f, 0.49826473f, 0.17408442f, -0.53624451f, -0.21798100f, 0.10809383f, 
    0.01316878f, -0.20017438f, -0.08061728f, 0.02059437f, 0.06404339f, 0.21710964f, 0.05626422f, -0.50764453f, 
    -0.29414338f, 0.34403628f, -0.26607102f, 0.26332191f, -0.02668149f, -0.42285344f, -0.18566224f, -0.50384468f, 
    -1.08982432f, 0.66714740f, -0.05370165f, 0.18217626f, 0.04539797f, 0.05092731f, -0.42142951f, 0.49946907f, 
    -0.14857714f, 0.18803990f, -0.28301987f, -0.58038038f, -0.22253300f, 0.18061855f, 0.13823140f, 0.15580267f, 
    0.30515835f, 0.12323373f, -0.10591252f, 0.09064026f, -0.12024806f, 0.40322310f, 0.08156437f, 0.00626684f, 
    -0.13560711f, -0.01370960f, -0.21148951f, 0.13224468f, -0.10170288f, -0.02287562f, 0.00870622f, -0.76350427f, 
    -0.76839942f, -0.15143445f, -0.41881290f, -0.08786058f, 0.29930708f, 0.27190882f, 0.82076728f, -0.19614990f, 
    -0.38979551f, 0.17051841f, -0.03420236f, 0.16634364f, 0.57874399f, 0.11767379f, 0.16059953f, 0.01893456f, 
    -0.26970172f, 0.08227132f, -0.04397928f, -0.11229202f, 0.12754114f, 0.03891961f, 0.04266648f, 0.68461454f, 
    -0.16209018f, 0.01956312f, 0.25161380f, -0.03895343f, -0.19568078f, 0.31894654f, -0.01575484f, 0.31510863f, 
    0.36151949f, 0.53872067f, -0.16076002f, -0.21616030f, 0.09982528f, -0.17813143f, 0.14630599f, 0.03359303f, 
    0.22594813f, 0.43207061f, 0.33537731f, -0.25707492f, 0.05758674f, 0.03837255f, 0.34463087f, -0.14914027f, 
    0.17368890f, -0.01962678f, -0.11383505f, 0.01735221f, -0.33021730f, -0.06560107f, 0.13449410f, -0.32091501f, 
    0.33086455f, 0.09741149f, -0.33801618f, -0.00516172f, 0.04090336f, 0.08596914f, -0.13119654f, 0.18069462f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.14426123f, 0.08092050f, -0.05930184f, 0.20186824f, 0.06756843f, 0.76956904f, 0.10956320f, 0.15255912f, 
    -0.30027643f, 0.06899264f, 0.03744784f, 0.05899444f, 0.41489300f, 0.00867787f, 0.07902218f, -0.14063600f, 
    -0.20728226f, 0.20252231f, 0.29519081f, 0.03281625f, 0.16080411f, 0.09558497f, 0.25086620f, 0.02717624f, 
    -0.18533655f, 0.10359040f, -0.00615689f, 0.00192491f, 0.30261245f, -0.27794707f, 0.07902043f, 0.16799468f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.15157339f, -0.37298647f, 0.05149831f, -0.27585071f, -0.11210287f, 0.49382293f, 0.08679508f, 0.07682514f, 
    -0.94555008f, -0.20590658f, -0.06033568f, -0.02908586f, -0.02657450f, -0.27365336f, 0.13652582f, -0.06279785f, 
    -0.35747096f, 0.60461539f, 0.03335194f, -0.41513821f, 0.09744988f, 0.05652187f, -0.09254941f, -0.08931504f, 
    0.10498619f, -0.08713479f, -0.17873630f, -0.43219942f, -0.73673487f, 0.72940940f, -0.14526434f, 0.02279355f, 
    0.05679020f, -0.20106491f, -0.19020829f, 0.03918450f, 0.12469110f, -0.06505718f, -0.08732780f, -0.25350139f, 
    -0.46839800f, 0.12046704f, -0.10118787f, -0.05032612f, 0.12456339f, -0.03204170f, 0.37399676f, 0.10334180f, 
    0.32387963f, 0.18436807f, 0.12963709f, -0.21031554f, -0.15669206f, 0.07577457f, 0.27254367f, -0.17590047f, 
    -0.16916427f, -0.02932889f, -0.29173622f, -0.40413800f, 0.37804094f, 0.18769319f, -0.32897809f, -0.03231177f, 
    -0.04225605f, -0.14271903f, 0.00328952f, -0.17291616f, 0.01875116f, -0.22416437f, -0.13354890f, -0.84106058f, 
    0.01428211f, 0.06558401f, -0.50461656f, 0.01048841f, -0.01794923f, -0.54376316f, -0.04487073f, -0.07221424f, 
    -0.10972082f, -0.21958324f, 0.38702399f, 0.78383803f, 0.13208658f, 0.41721377f, 0.13429601f, -0.12866165f, 
    -0.02378016f, -0.02621065f, 0.09479062f, 0.06893338f, -0.40035960f, 0.31423426f, 0.48243043f, -0.54927677f, 
    0.09706131f, 0.07898242f, 0.04855949f, 0.17423429f, -0.00460106f, 0.04564468f, -0.05071375f, 0.30640674f, 
    -0.17161827f, 0.07580587f, 0.09702278f, 0.05110803f, -0.60433668f, 0.39243287f, -0.40857643f, 0.14824103f, 
    0.17411645f, -0.47878560f, 0.03017449f, -0.04611568f, -0.04483633f, -0.94763535f, -0.20780322f, -0.14109732f, 
    -0.03728403f, 0.08836193f, 0.09937084f, 0.27679598f, 0.09624810f, -0.85885155f, -0.43671492f, -0.18165512f, 
    -0.19245318f, 0.04253352f, 0.00091373f, -0.39260566f, -0.12017260f, 0.23102035f, -0.13208875f, 0.12936305f, 
    0.19878571f, 0.04213108f, -0.14624017f, -0.03075104f, 0.18375459f, 0.03838027f, 0.06626796f, 0.05868350f, 
    -1.02906203f, 0.17864050f, -0.08781224f, -0.15968046f, -0.13846427f, 0.01876681f, -0.42200133f, -0.00229715f, 
    -0.01883698f, -0.00687040f, -0.15236728f, 0.16181923f, 0.13268846f, -0.19912836f, 0.15050635f, 0.34296763f, 
    0.04394611f, -0.14812170f, 0.05426208f, -0.00389418f, 0.03917949f, 0.03253342f, -0.05889560f, 0.44703397f, 
    -0.20307951f, -0.17173278f, 0.36682203f, 0.14505118f, 0.32313573f, -0.10635050f, 0.25262281f, -0.09162910f, 
    -0.41268703f, -0.47198504f, -0.44322845f, 0.29117942f, 0.06344708f, 0.12338034f, 0.10858756f, 0.12034364f, 
    -0.14875300f, 0.02848167f, -0.25652364f, -0.22167015f, 0.04993191f, -0.46561918f, -0.36748144f, 0.17024629f, 
    -0.11594997f, 0.18551460f, 0.13386405f, 0.30367380f, -0.03617069f, 0.00356768f, -0.13712850f, 0.03799217f, 
    0.17061456f, 0.05084889f, 0.11477432f, 0.07390176f, -0.04252040f, -0.45905563f, 0.11409833f, 0.01182948f, 
    0.40293625f, -0.06076363f, -0.72507977f, -0.11335679f, 0.02177943f, 0.23822132f, 0.02907128f, 0.06403334f, 
    0.12816216f, -0.13162276f, -1.07489204f, 0.36409134f, -0.65216964f, 0.37083349f, 0.34060651f, -0.28767532f, 
    -0.00076812f, 0.19118299f, 0.07531985f, -0.82310480f, -0.03597289f, -0.08817659f, -0.16778368f, 0.29014587f, 
    -0.35717723f, 0.05924980f, -1.28293622f, 0.00795912f, -0.46541902f, 0.16968255f, -0.00247665f, -0.10334121f, 
    -1.02462673f, -0.61664104f, 0.29138723f, -0.08096322f, 0.17086826f, -0.41937706f, -0.15970282f, -0.11877713f, 
    0.01645636f, -0.08061093f, 0.39281592f, -0.97858870f, -0.11631788f, 0.03737295f, -0.71488976f, 0.33687940f, 
    -0.18418659f, -0.62728232f, -0.07127423f, 0.20172197f, 0.13196146f, -0.96556592f, -0.11138330f, -0.27274582f, 
    0.21319759f, 0.04991544f, -0.42796576f, 0.05466233f, -0.09546495f, -0.63428611f, -0.75111598f, 0.10584559f, 
    0.28040424f, -0.24609306f, 0.20441109f, -0.36364937f, 0.06994729f, -0.18606243f, 0.24722743f, 0.03025580f, 
    0.00755515f, 0.09126331f, 0.08719586f, 0.18940426f, 0.58570349f, 0.14614001f, -0.42352667f, 0.02235813f, 
    -0.05912485f, 0.26338199f, 0.15083824f, 0.00494299f, 0.13558432f, 0.26575851f, -0.09747435f, -0.20978241f, 
    0.31255448f, 0.16602881f, -0.66748559f, -0.15288807f, -0.09844665f, -0.26847410f, 0.15487215f, 0.02037501f, 
    -0.33546689f, 0.17786172f, -0.32473299f, -0.34440589f, 0.04964552f, 0.29036793f, 0.12760440f, 0.01407622f, 
    0.10542700f, -0.18857923f, -0.33550632f, 0.22382389f, -0.60120434f, -0.75364584f, 0.35651031f, 0.05880219f, 
    0.12270381f, 0.26497242f, 0.05372629f, 0.36446869f, 0.01439169f, 0.32321104f, -0.13648821f, 0.03583969f, 
    -0.71698904f, 0.13854848f, -0.89082348f, -0.07509470f, -0.05949718f, -0.01945001f, -0.74802214f, -0.15367931f, 
    -0.48595709f, -0.09857651f, 0.39005807f, 0.29303756f, -0.03282687f, -0.72290188f, -0.46755865f, 0.03384233f, 
    0.10236844f, 0.14625330f, 0.06217239f, -0.20866592f, 0.49144745f, -0.45215741f, -0.17620867f, -0.63624251f, 
    0.04466287f, -0.35328317f, 0.09155070f, -0.01638148f, -0.05719697f, -0.30730513f, -0.01789748f, -0.11033104f, 
    0.43559381f, -0.00323847f, 0.56115109f, 0.05466646f, -0.14415421f, 0.32433632f, -0.64638120f, -0.15582307f, 
    0.50369507f, 0.13034935f, 0.07534098f, -0.23557572f, 0.05352552f, -0.19398126f, -0.45032802f, -0.04295545f, 
    -0.06379539f, 0.03070093f, 0.17502008f, 0.20349495f, -0.08297969f, 0.33845600f, 0.11495697f, -0.24063694f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    0.28239372f, -0.09665400f, -0.05535576f, 0.12383550f, 0.07400832f, 0.14649384f, -0.32141647f, -0.51939780f, 
    -0.27674997f, 0.27522999f, 0.43329099f, -0.00764597f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
