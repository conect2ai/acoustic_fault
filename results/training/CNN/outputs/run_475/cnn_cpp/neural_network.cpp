#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.40219703f, 1.06101429f, 0.77658039f, 0.49559438f, 0.63206720f, -0.67125863f, -0.38481286f, 0.09920038f, 
    0.05603479f, -0.79124743f, 0.17788793f, 0.65619516f, -0.26851758f, -0.36007556f, -0.43689665f, 0.33947015f, 
    0.59941715f, -0.29278681f, 0.62155163f, 0.59767306f, 0.53317994f, 0.25360367f, -0.84561634f, 0.33040693f, 
    0.63177544f, 0.26549131f, 0.07377490f, 0.45778993f, 0.63881677f, 0.06969929f, -0.01942280f, 0.33281204f, 
    -0.96848702f, 0.30889431f, 0.06984624f, 0.52041739f, 0.96181417f, 0.41299379f, 0.42895609f, 0.41304412f, 
    0.22716877f, -0.15206362f, -0.05148052f, 0.44821107f, -0.22541672f, -0.74863166f, -0.80227876f, -0.78488535f, 
    -0.28963947f, 0.20154496f, 0.71174484f, 0.33395797f, 0.06411777f, 0.28248242f, 0.01983636f, -0.95445377f, 
    -0.14768298f, 0.13021404f, -0.69640386f, -0.59193522f, 0.63395751f, 0.40332577f, 0.23413196f, -1.00380433f, 
    -0.40399837f, -0.25246000f, 0.00164106f, 0.55473059f, -0.47650599f, 0.48104918f, -0.12546004f, -0.32847160f, 
    -0.54746872f, 0.55818200f, 0.79386103f, 0.56609094f, 0.13898259f, 0.74642432f, -0.14216138f, -0.60890698f, 
    0.14843245f, 0.39950362f, 0.35598156f, 0.04226044f, -1.13510621f, -1.17372835f, -0.68185407f, -0.05430964f, 
    -0.12444408f, 0.17007749f, -0.70216525f, 0.95581001f, -0.64786690f, -0.28644952f, -0.23611623f, -0.90156013f, 
    -0.18928093f, 0.26135612f, 0.15738910f, 0.70260388f, 0.90776414f, -0.72731984f, -0.36405092f, 0.07717086f, 
    0.18073636f, 0.37411770f, 0.61353952f, -0.13793086f, -0.60353529f, -0.63748574f, -0.56809896f, 0.33926198f, 
    0.57727367f, 0.73253632f, -0.13285965f, 0.30177891f, -0.33999297f, 0.59452987f, 0.71917552f, 0.47319010f, 
    -0.43169004f, -0.61623424f, 0.56710720f, -0.58919376f, 0.37001613f, -0.24830033f, -1.43256891f, 0.90817535f, 
    -0.21809925f, 0.12836280f, -0.06841297f, 0.20168737f, -0.08046319f, 0.25128204f, -0.49200383f, 0.84332502f, 
    0.70472896f, 0.80126727f, -0.37924787f, -0.29598838f, -0.02017573f, 0.16693881f, -0.34126660f, -0.01377694f, 
    0.02871582f, -0.75619739f, -0.73037332f, -0.85831678f, 0.51079565f, 0.57163024f, -0.02119256f, -0.06141186f, 
    0.29672420f, -0.44402465f, -0.61943233f, -0.53185767f, 0.00091940f, 0.72685790f, 0.36346531f, -0.19278793f, 
    -0.13333860f, -0.44607061f, -0.83963311f, -0.67663568f, 0.55054533f, 0.39160442f, -0.07783213f, 0.80726421f, 
    0.51426554f, -0.19150211f, 0.66058940f, 0.14465459f, -0.80168003f, -0.73190886f, -0.31933406f, -0.96213955f, 
    -0.60625708f, -0.29271495f, -0.13477345f, 0.11817616f, 1.09911776f, 0.66744041f, 0.10159554f, -0.90761650f, 
    0.55568558f, -0.53520852f, -0.40145850f, 0.03087059f, 0.03540953f, 0.43594554f, 0.34134048f, 0.58988500f, 
    0.74085099f, -1.10321105f, -0.39898592f, -0.65996403f, -0.34723452f, -0.17265302f, -0.44864297f, -0.49756324f, 
    -0.36669970f, 0.68068683f, -0.11008441f, 0.83847594f, 0.18296990f, -0.84234405f, -0.34598488f, 0.44581664f, 
    0.19224778f, -0.36317897f, 0.54752332f, 0.78440785f, 0.62761968f, -0.63316625f, 0.11588097f, 0.36461759f, 
    1.43217623f, -0.54387820f, -0.93272996f, 0.28874698f, 0.17164655f, -0.21061975f, 0.11507915f, -0.19342758f, 
    0.16671571f, 0.01675195f, -0.76548529f, -0.23346454f, 0.36332250f, 0.86714244f, -1.07499111f, -0.11969662f, 
    -0.06661860f, -0.00646354f, -1.04375839f, 0.02605199f, -0.75388134f, 0.27519327f, 0.04460276f, -0.33636844f, 
    -0.19369936f, -0.17782137f, 0.27092272f, 0.62764961f, -0.10567906f, -0.57834864f, -0.19884343f, -0.21236461f, 
    0.46072173f, -0.08618752f, -0.53029382f, -0.69133419f, -0.70342815f, 0.47262675f, -0.37128294f, 0.59981865f, 
    0.83754611f, -0.59883475f, -0.06171382f, 0.55238509f, 0.17781019f, -0.02711459f, 0.23255557f, -0.50969762f, 
    0.93235868f, -0.31079799f, -0.47367969f, -0.28403649f, -0.26232603f, -0.59031415f, -0.11369339f, 0.55110598f, 
    -0.69007546f, 0.72988838f, 1.02427959f, 0.01481354f, 0.52398056f, -0.16254938f, -0.43501598f, -0.22420308f, 
    0.08789574f, 0.63660610f, -0.59389997f, -0.39489025f, 0.02999841f, -0.15186152f, 0.21564727f, 0.69622427f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.00217210f, 0.03759205f, 0.10893719f, 0.35303247f, 0.18387833f, 0.01806177f, 0.08737885f, -0.00395379f, 
    0.19178154f, 0.32081419f, 0.22933529f, -0.41687557f, 0.05033408f, -0.21108674f, 0.10400610f, 0.01985832f, 
    -0.20297737f, 0.01886746f, 0.11253534f, 0.33208072f, 0.06264087f, -0.27039590f, -0.28159380f, 0.22768897f, 
    0.13451794f, -0.05422835f, 0.27027494f, -0.16980363f, 0.01319804f, -0.24632914f, -0.37274125f, 0.29602724f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.02086917f, -0.01954068f, 0.00961675f, 0.00314972f, -0.05905467f, -0.05472572f, 0.04908534f, 0.00986462f, 
    -0.04105049f, 0.00856984f, -0.01447781f, 0.02405131f, -0.05452925f, 0.04199405f, -0.05709321f, -0.04829663f, 
    0.04560012f, -0.05218680f, -0.03907623f, 0.01125641f, 0.05099559f, -0.00582371f, -0.04628101f, -0.01820991f, 
    -0.02795323f, -0.01829622f, -0.05959581f, 0.00848061f, -0.04777150f, 0.01467532f, -0.00171871f, -0.00168556f, 
    -0.02946619f, -0.01626586f, -0.03374380f, 0.02370134f, -0.01070353f, 0.02094527f, -0.00184138f, 0.02337762f, 
    0.00454134f, -0.04041744f, -0.05229244f, -0.03707609f, 0.04499398f, 0.04096686f, 0.03487455f, -0.05039036f, 
    0.01975280f, 0.03719957f, -0.01819088f, -0.01604015f, 0.01862450f, -0.00489902f, -0.01532438f, 0.00491610f, 
    -0.04040130f, 0.02572870f, -0.05687081f, -0.03177061f, -0.02449721f, 0.00765538f, -0.00461099f, -0.01415774f, 
    0.01370941f, -0.05195886f, -0.05063661f, -0.02006723f, -0.00822430f, -0.05404705f, -0.04967184f, 0.02186318f, 
    -0.03653106f, -0.05571642f, -0.05876657f, -0.01829018f, 0.03550879f, -0.01234877f, -0.03753950f, -0.05200470f, 
    -0.04173567f, -0.00068065f, -0.03942250f, -0.03283416f, -0.00642568f, 0.04681093f, -0.01193034f, -0.06032103f, 
    0.05012221f, -0.04139153f, -0.04933882f, 0.02817211f, 0.04735846f, 0.02750330f, -0.00940544f, -0.04021200f, 
    0.04113166f, -0.04275135f, 0.00396465f, -0.01127941f, 0.02534938f, 0.04331128f, -0.03171133f, -0.04036350f, 
    -0.06323112f, -0.02295016f, -0.02346729f, -0.04677697f, -0.06314677f, 0.04938895f, -0.01104848f, 0.02375519f, 
    -0.04624540f, 0.01212271f, 0.01633206f, 0.03399532f, 0.01903205f, -0.02633367f, 0.01801436f, -0.00933097f, 
    -0.00274292f, 0.03189569f, 0.04109236f, -0.05574709f, 0.05184893f, -0.03976049f, 0.05117827f, -0.03811359f, 
    0.00705627f, -0.04269041f, 0.00436356f, -0.03696815f, 0.00027840f, -0.04637231f, 0.05268105f, 0.02691072f, 
    -0.05708132f, -0.03729527f, -0.00379054f, -0.03331383f, -0.05620439f, -0.00982985f, 0.05130276f, 0.03496961f, 
    -0.05580130f, 0.03902553f, -0.02160666f, -0.02123516f, -0.06262162f, -0.04569103f, -0.06405810f, -0.05687635f, 
    0.03070498f, -0.01956354f, -0.05309518f, -0.03773052f, -0.00093479f, -0.00100656f, 0.04663255f, 0.01463368f, 
    -0.05223500f, -0.01525265f, -0.01459028f, -0.05632805f, -0.05865013f, 0.04648818f, -0.00334707f, -0.01408428f, 
    -0.00912367f, -0.04901005f, 0.03788757f, -0.03224234f, 0.01122073f, -0.02870880f, -0.06195469f, 0.04801643f, 
    0.03776995f, 0.01247553f, -0.05854593f, -0.04783544f, 0.02665481f, 0.00565946f, 0.04315175f, -0.04100157f, 
    0.03121340f, -0.04695329f, -0.05516574f, 0.00151209f, -0.00967242f, -0.05653650f, 0.03822927f, 0.03996867f, 
    0.04088894f, -0.03379326f, -0.05694338f, -0.02995355f, 0.00848845f, -0.03642570f, -0.02514556f, -0.05155249f, 
    -0.02523920f, -0.05426667f, -0.05759243f, 0.03070883f, 0.00017418f, -0.04362617f, 0.03181879f, 0.00302542f, 
    -0.05683444f, 0.01166444f, -0.00122369f, 0.02063326f, 0.04142010f, -0.03097327f, 0.03953547f, -0.05501811f, 
    0.02825728f, -0.03847150f, -0.01241796f, -0.04892256f, -0.04856223f, 0.03571590f, -0.00308690f, 0.00891847f, 
    -0.00293455f, -0.06191291f, -0.02474315f, -0.02177702f, -0.04966661f, 0.02188299f, 0.04445358f, 0.03606783f, 
    -0.05622828f, 0.01773249f, -0.03625304f, -0.03930921f, 0.04919446f, 0.04639431f, -0.01637469f, 0.01635679f, 
    0.04548913f, 0.01011278f, 0.02182029f, 0.02147614f, -0.03907892f, -0.04257869f, -0.02421426f, -0.00237020f, 
    0.05058328f, 0.00662336f, -0.04040504f, -0.01651126f, 0.05812745f, -0.00504020f, 0.00063772f, -0.01155419f, 
    0.04781953f, 0.00704861f, 0.03502305f, 0.01255637f, -0.02757434f, 0.05116156f, -0.01516218f, 0.04793511f, 
    -0.04763317f, 0.02424848f, -0.00023825f, -0.05410079f, 0.02801209f, -0.04327110f, -0.04762470f, -0.00096831f, 
    -0.04243245f, 0.01573485f, -0.02893757f, 0.00409536f, -0.06071812f, -0.03801105f, 0.03135608f, -0.03301201f, 
    -0.03923621f, 0.00091451f, -0.05758003f, 0.03510970f, -0.00425856f, -0.05561214f, 0.01998972f, -0.01573129f, 
    -0.00409577f, 0.00268434f, 0.00949670f, -0.05625723f, 0.00783150f, -0.05189357f, 0.02636607f, 0.03967570f, 
    -0.03468506f, 0.01471319f, -0.03584409f, -0.01141840f, 0.04419035f, -0.02980729f, 0.00632209f, -0.05933935f, 
    0.03606769f, -0.04071483f, 0.02376241f, -0.02937022f, -0.05935504f, 0.02786284f, -0.03744187f, 0.00628719f, 
    -0.04739917f, 0.00988610f, -0.01168666f, -0.06820952f, -0.03609218f, -0.03603828f, 0.01678750f, 0.04750615f, 
    -0.06343020f, 0.02700989f, 0.02946568f, 0.04664221f, 0.02357646f, -0.01543232f, -0.02987479f, -0.01291239f, 
    0.00822373f, -0.04971131f, -0.03608738f, 0.03193291f, 0.00232882f, -0.03031491f, -0.05921783f, 0.01296938f, 
    -0.04932894f, 0.02103082f, -0.02123736f, 0.00933027f, -0.03367077f, 0.00847781f, -0.06470121f, 0.04453482f, 
    0.02727439f, -0.05827316f, -0.03961137f, 0.00380938f, -0.03979696f, -0.00521858f, -0.04759127f, 0.00534663f, 
    -0.01738953f, -0.04266420f, 0.04678475f, -0.00299942f, -0.03374830f, -0.01522591f, -0.07027589f, -0.01730527f, 
    0.02631531f, -0.04736049f, -0.05288422f, -0.01234300f, 0.02047491f, -0.03840613f, -0.00368719f, 0.02283521f, 
    -0.05675519f, -0.01116716f, -0.00138130f, 0.00028923f, 0.04894336f, 0.01196955f, -0.00298472f, -0.04472522f, 
    0.02673844f, 0.04448483f, -0.01850604f, -0.01326771f, 0.03899644f, -0.00460066f, -0.01501508f, -0.00335763f, 
    0.04501430f, 0.04290223f, -0.03511630f, 0.02628436f, -0.02579480f, -0.04783802f, 0.00328291f, 0.00528892f, 
    -0.00586666f, 0.00391531f, -0.05652214f, 0.01699457f, -0.03520112f, 0.04960280f, -0.00664478f, 0.00246430f, 
    -0.06654300f, -0.00658695f, -0.03856777f, 0.01823512f, -0.00971648f, -0.02954233f, -0.05006001f, 0.01718932f, 
    0.02661183f, -0.07072821f, 0.00221209f, -0.04589354f, 0.04618268f, 0.05181423f, -0.00292069f, -0.00043814f, 
    -0.02545865f, -0.05694066f, -0.05507734f, -0.04160798f, 0.00851931f, -0.00676038f, -0.00081896f, -0.03305892f, 
    -0.01555044f, -0.01768240f, 0.01752155f, -0.01662002f, -0.05900868f, -0.05887546f, -0.01012240f, -0.03249417f, 
    0.01966470f, 0.03075839f, -0.02950957f, -0.02952426f, -0.03915708f, -0.00919959f, -0.02888663f, 0.00111226f, 
    0.02117656f, -0.04668085f, 0.05399130f, -0.04654393f, -0.02122920f, -0.01082499f, 0.01704117f, -0.02264439f, 
    0.04557186f, -0.05413084f, 0.03621522f, -0.01894567f, -0.02592151f, 0.03666371f, -0.03348839f, -0.01190767f, 
    -0.06207179f, 0.02853407f, 0.04583233f, -0.00258011f, 0.04781886f, 0.04096408f, -0.00729907f, -0.02006291f, 
    0.03351182f, 0.00465231f, 0.04638260f, -0.01173792f, 0.03971272f, 0.03814790f, 0.02940996f, 0.01430871f, 
    -0.01300575f, -0.02370101f, -0.03561358f, -0.04358192f, -0.00927480f, 0.00324064f, -0.00277913f, -0.02030384f, 
    -0.00515363f, -0.01590107f, -0.04338838f, -0.06271127f, -0.03282076f, -0.06003463f, 0.02107204f, 0.03429095f, 
    0.00986372f, -0.04463436f, 0.01970612f, -0.02729532f, 0.00384511f, 0.02499863f, 0.04171819f, 0.00719371f, 
    0.02864806f, -0.03453591f, -0.07153355f, -0.05205581f, -0.01435183f, 0.04544456f, -0.01531458f, -0.05541044f, 
    0.03239383f, 0.01022534f, 0.01054591f, -0.00048376f, 0.02552954f, -0.01035056f, 0.00776284f, -0.04525211f, 
    -0.05408468f, 0.03797186f, -0.01064580f, 0.05021804f, -0.04946778f, -0.02616693f, -0.01617071f, -0.03591127f, 
    0.01751151f, 0.02912058f, -0.02485054f, 0.03443272f, -0.02199307f, -0.02284802f, -0.06874628f, 0.01438460f, 
    -0.00627365f, -0.05097342f, -0.02997167f, 0.04131909f, -0.05129302f, -0.03658327f, -0.04408488f, 0.00237806f, 
    -0.05826837f, 0.03713834f, -0.02363213f, -0.05432721f, 0.03174109f, 0.04340645f, 0.04787002f, -0.04677897f, 
    -0.04094461f, -0.01985438f, 0.02137129f, 0.04113754f, -0.01479874f, -0.03374984f, 0.03919303f, 0.03098611f, 
    0.03974808f, 0.03990534f, -0.05744580f, 0.03880890f, -0.02753942f, -0.01652447f, 0.00402142f, -0.04834596f, 
    -0.01989258f, -0.04452132f, -0.06390421f, 0.04148193f, 0.02405694f, 0.04811680f, 0.02085149f, -0.05328992f, 
    0.03898776f, -0.01470567f, -0.04689584f, -0.03867017f, 0.04503710f, -0.03469254f, -0.03450714f, -0.03473405f, 
    -0.01341420f, 0.00965881f, -0.02717619f, -0.03763924f, 0.04878305f, 0.05040329f, 0.04043801f, 0.05244519f, 
    -0.00366590f, -0.06282251f, -0.06087393f, -0.03480078f, 0.04684921f, 0.01879440f, 0.00159293f, -0.04428327f, 
    -0.04249838f, -0.04642716f, 0.01780999f, 0.01795621f, -0.03695422f, 0.03281447f, -0.03855873f, -0.04644785f, 
    -0.05450803f, 0.04943805f, -0.02677002f, -0.01173017f, 0.04430327f, -0.00326159f, 0.03127285f, -0.04633899f, 
    0.00443533f, -0.02720846f, -0.01982776f, 0.01175345f, -0.04775364f, -0.04692162f, -0.00186405f, 0.02829554f, 
    0.01574087f, -0.05647230f, -0.03332458f, 0.04602545f, -0.04697760f, -0.03291890f, -0.05567142f, -0.04158698f, 
    0.01791266f, 0.01149852f, -0.00405333f, 0.05583612f, -0.01640532f, -0.02022501f, 0.05028000f, 0.01641961f, 
    -0.04507676f, 0.01023692f, 0.04755113f, -0.02734739f, 0.04685873f, 0.03651386f, -0.04791125f, -0.00887045f, 
    -0.00897306f, 0.00014936f, -0.04952084f, 0.02167796f, 0.01518626f, -0.04440787f, 0.04478323f, 0.02644268f, 
    -0.02956738f, 0.00360989f, -0.03122241f, 0.01576025f, -0.01839247f, -0.00984061f, 0.00418395f, 0.00527720f, 
    -0.00392698f, -0.01043604f, 0.02590335f, -0.06417916f, -0.05518391f, 0.02869957f, 0.00961263f, -0.05248061f, 
    -0.02315447f, 0.00793015f, 0.03877425f, -0.04153563f, 0.03801495f, 0.03712583f, -0.03457690f, -0.05589332f, 
    -0.03850664f, 0.02848846f, -0.00594716f, -0.01428507f, -0.04399965f, 0.05784956f, -0.02096250f, 0.00710140f, 
    0.04520795f, 0.01270097f, -0.00145943f, -0.02033737f, -0.04025703f, 0.01029723f, -0.03254366f, -0.02245230f, 
    0.02414539f, -0.05343864f, 0.05191698f, 0.01464664f, 0.02692076f, -0.04671942f, -0.02378066f, -0.05427388f, 
    0.02502876f, -0.02985161f, -0.03678437f, 0.02042930f, -0.02708227f, 0.00729819f, -0.01824880f, -0.03520414f, 
    -0.01279696f, -0.01798417f, -0.01499097f, -0.00077995f, -0.00140587f, -0.01278938f, 0.03092290f, 0.01947174f, 
    -0.03521327f, 0.02900580f, -0.04763360f, 0.02185440f, 0.03475470f, -0.01167038f, -0.02091486f, 0.02670227f, 
    0.03960504f, 0.00979387f, -0.00762989f, -0.01860924f, 0.01835765f, 0.04760586f, -0.02293695f, -0.00815379f, 
    -0.02558003f, 0.03736829f, -0.00961188f, 0.04794648f, 0.00955860f, -0.02991221f, -0.01759379f, -0.02276151f, 
    -0.01284033f, 0.04878245f, -0.00252506f, -0.04409591f, -0.00184611f, 0.04970147f, 0.02616574f, -0.01754326f, 
    0.01815496f, 0.01845245f, 0.04472280f, -0.00465385f, -0.02358774f, 0.04629727f, -0.05416673f, -0.05926096f, 
    0.01195756f, -0.05936256f, -0.02922737f, -0.00862675f, -0.05724026f, -0.03531284f, -0.06005019f, 0.02843386f, 
    -0.05896530f, 0.01780342f, -0.03007708f, 0.02012886f, -0.03406096f, 0.00066353f, -0.00440910f, 0.02114365f, 
    -0.01083746f, -0.04114819f, -0.01052686f, -0.02158849f, 0.00196370f, 0.04192530f, -0.03993127f, -0.03158394f, 
    -0.03113556f, -0.02127956f, -0.05309107f, 0.02495414f, -0.00582706f, 0.03803861f, -0.04520944f, -0.00443197f, 
    -0.04531450f, -0.01363755f, -0.04819999f, 0.05290247f, 0.00808990f, -0.01502750f, 0.02990337f, 0.05347598f, 
    0.03601937f, 0.00906487f, -0.05758006f, 0.01666148f, -0.02364946f, 0.03046312f, -0.03760191f, -0.02765859f, 
    0.02698940f, 0.01468505f, 0.01473936f, -0.03658708f, -0.00885691f, -0.05255273f, 0.02526291f, 0.00599524f, 
    -0.04354244f, -0.05276941f, -0.01097929f, 0.01649858f, 0.04873627f, -0.05361417f, 0.03954085f, 0.02406790f, 
    -0.01376168f, -0.05709479f, -0.03458920f, 0.02526777f, -0.05225546f, -0.01952307f, 0.03461855f, -0.01833913f, 
    0.03406271f, -0.05919841f, -0.04894567f, 0.03970735f, -0.01146653f, -0.01975187f, -0.00034786f, -0.06214913f, 
    -0.04029798f, -0.04374613f, -0.03548817f, -0.00099232f, -0.03262931f, -0.06494807f, 0.00218501f, -0.05981541f, 
    -0.00496264f, 0.02821804f, 0.02482602f, -0.00841732f, 0.00677947f, 0.04372020f, -0.00275577f, -0.01609349f, 
    -0.00898659f, 0.00399385f, 0.02810644f, -0.04612764f, 0.03103464f, -0.05915755f, 0.00333801f, 0.05389350f, 
    0.00447638f, -0.02960775f, 0.02038691f, -0.00071254f, 0.05234816f, 0.05007280f, -0.06092541f, -0.02305482f, 
    -0.01271137f, -0.00953957f, 0.05181085f, 0.03367373f, -0.03123882f, -0.02391048f, -0.04014913f, 0.03243796f, 
    -0.05478010f, -0.04370856f, 0.04887411f, -0.00986805f, -0.04369199f, -0.02318129f, 0.04211169f, -0.00714952f, 
    -0.00808668f, -0.01312389f, -0.03807226f, -0.00041777f, -0.03268216f, -0.01436424f, -0.00289140f, -0.04706328f, 
    0.02032114f, -0.02334472f, -0.02327658f, -0.03297975f, -0.04877063f, -0.00023836f, 0.01705198f, 0.00141782f, 
    -0.00743895f, -0.04956858f, 0.03226142f, 0.02716051f, -0.00793522f, 0.03680120f, -0.05527576f, -0.02388587f, 
    -0.04294925f, -0.02402228f, 0.00828987f, 0.04715650f, 0.05142390f, 0.04669529f, 0.00034121f, -0.00723050f, 
    -0.05679776f, 0.05048966f, -0.01766637f, -0.05753200f, -0.04165770f, 0.05103619f, 0.00485468f, -0.00594249f, 
    -0.01052283f, 0.00452074f, -0.04300383f, -0.02259468f, 0.04893039f, 0.01645982f, -0.00291542f, -0.01097895f, 
    -0.00415882f, -0.03479820f, 0.02978376f, -0.02386796f, -0.05402872f, -0.01260917f, -0.03147956f, -0.05399907f, 
    0.00794031f, -0.02139997f, -0.02635778f, 0.02418689f, -0.05355281f, -0.04732556f, -0.00818612f, -0.00641315f, 
    -0.02057929f, 0.03085192f, -0.06037708f, -0.02621995f, 0.03600768f, 0.00622156f, 0.04123359f, 0.04681372f, 
    -0.02603434f, -0.05313864f, -0.00503206f, -0.06261186f, -0.04783820f, -0.06433981f, 0.01329739f, 0.04001288f, 
    0.02280863f, -0.03378587f, 0.04281680f, -0.01226901f, 0.04699732f, 0.03333187f, 0.01544390f, 0.03389997f, 
    0.01372771f, -0.05227873f, -0.01223470f, 0.03270632f, -0.00715102f, -0.05270391f, 0.01348675f, -0.06035104f, 
    -0.03984540f, -0.01722340f, 0.04381158f, 0.00271811f, -0.04583855f, -0.03264207f, -0.03115438f, -0.04553048f, 
    -0.03296521f, -0.03957762f, -0.02862100f, 0.04801533f, -0.04015726f, -0.03720156f, 0.02484594f, -0.04781376f, 
    -0.01302660f, 0.02814101f, -0.04741479f, -0.03976477f, 0.04871291f, -0.01878410f, -0.03452675f, -0.05366516f, 
    0.00150187f, -0.03201802f, -0.00823422f, -0.02850891f, -0.02885352f, -0.03879979f, -0.02403432f, 0.04889759f, 
    -0.05485689f, -0.03501160f, -0.01896988f, -0.00138509f, -0.04806354f, -0.02038650f, -0.05315834f, -0.04591126f, 
    0.03140600f, -0.01285186f, -0.00200443f, 0.03401191f, 0.00962681f, -0.02856034f, -0.04776268f, 0.04708793f, 
    -0.02543029f, 0.04094010f, 0.02150684f, -0.05227263f, 0.00664371f, 0.02371777f, -0.00575480f, 0.00666290f, 
    0.00147795f, -0.05043470f, -0.02334337f, 0.03030392f, -0.03037440f, 0.02429582f, -0.06354266f, 0.01968269f, 
    0.02444528f, 0.00100363f, 0.03455594f, 0.00798614f, -0.01961139f, -0.00994262f, 0.01430597f, -0.05971129f, 
    -0.02229994f, -0.00632973f, 0.02183473f, 0.04499141f, -0.04407907f, -0.02290376f, 0.02081892f, 0.02140994f, 
    -0.03919929f, -0.04565087f, 0.02723137f, -0.01685468f, -0.01867820f, -0.01350785f, -0.01913407f, 0.03003050f, 
    -0.06451853f, 0.03747799f, -0.01819437f, -0.05800357f, 0.02645886f, 0.00580215f, -0.01774467f, -0.00159967f, 
    -0.00656112f, -0.03360701f, 0.02289106f, -0.05023891f, -0.03346395f, -0.06241830f, -0.03308245f, 0.02114772f, 
    -0.02499492f, 0.01836411f, 0.01964260f, -0.01637548f, 0.02914229f, -0.01470800f, -0.02216098f, -0.00296117f, 
    0.03445777f, -0.02831370f, -0.05878976f, -0.00601432f, 0.03925551f, 0.01825005f, -0.03480890f, -0.03949250f, 
    0.03330710f, 0.00486375f, 0.01110298f, 0.01279755f, 0.00376892f, 0.04251931f, 0.01715564f, -0.06406852f, 
    -0.02214453f, -0.02869369f, 0.03845150f, 0.04203267f, 0.03055383f, -0.01064848f, -0.06069249f, 0.01070386f, 
    -0.01433130f, -0.00716349f, -0.04246661f, 0.03892673f, -0.01422983f, 0.04588157f, -0.05910090f, 0.01381072f, 
    0.04382726f, 0.05265994f, 0.03168296f, -0.06243893f, -0.02278043f, -0.04515700f, -0.05919476f, -0.00915377f, 
    0.02261270f, -0.00467805f, -0.00816210f, 0.04873451f, -0.05343983f, 0.01375651f, 0.04045781f, 0.02285004f, 
    0.01931083f, -0.05075435f, 0.04419401f, 0.03397153f, 0.01917431f, 0.02569949f, 0.03574409f, -0.00370608f, 
    -0.02625546f, -0.03658005f, -0.06331398f, 0.04323989f, 0.01780927f, -0.05878174f, -0.04235378f, 0.01696682f, 
    0.04897791f, 0.01271539f, -0.04198737f, -0.06031666f, -0.03787021f, -0.06841448f, 0.01646602f, -0.04475615f, 
    -0.00850311f, -0.02842350f, -0.03032989f, -0.01195686f, -0.00666204f, 0.01374904f, 0.00604767f, 0.03905534f, 
    -0.04267907f, -0.05048152f, 0.01541046f, 0.02918794f, -0.03313968f, -0.00290539f, 0.04873430f, 0.00326047f, 
    -0.01653783f, -0.06882709f, 0.00215297f, 0.04335961f, 0.01423922f, -0.00247874f, -0.05952067f, 0.02761585f, 
    0.03372518f, 0.00980830f, -0.03939731f, 0.03832269f, -0.02990960f, 0.02876860f, -0.03711615f, 0.01967589f, 
    -0.03976317f, -0.01932753f, -0.01210324f, 0.00253122f, -0.04284723f, -0.03105589f, -0.04078885f, -0.04806884f, 
    -0.05931177f, 0.02552626f, -0.02112881f, -0.00649567f, 0.01083939f, -0.01417813f, -0.01075851f, -0.04165975f, 
    0.01030610f, 0.02409916f, -0.01085227f, -0.06108799f, 0.00290810f, 0.01538670f, 0.03866265f, -0.05407386f, 
    -0.03753109f, -0.04030209f, 0.03844747f, -0.04246926f, 0.02034902f, -0.03589517f, -0.02247761f, 0.00946048f, 
    -0.04475056f, 0.01952942f, 0.02566676f, 0.01372602f, -0.02555116f, -0.03993623f, -0.04110052f, 0.01132806f, 
    -0.06064282f, -0.02585129f, -0.04656611f, 0.00801027f, -0.00667739f, 0.00956939f, 0.02806786f, -0.06397613f, 
    -0.05367040f, -0.02261091f, -0.04015253f, -0.02748394f, 0.04070958f, -0.01894681f, -0.02142968f, 0.01394265f, 
    -0.01992530f, 0.02254619f, 0.03160848f, -0.05955584f, 0.04779543f, -0.01187815f, -0.02990129f, -0.02244541f, 
    -0.06092189f, -0.02170200f, 0.02973112f, -0.04824183f, 0.04601521f, -0.03814860f, -0.05910842f, 0.00745054f, 
    -0.03275778f, -0.01762950f, 0.00833639f, 0.00912101f, 0.04296559f, 0.03096669f, -0.04515964f, 0.00280696f, 
    -0.05052285f, -0.03132616f, -0.03133158f, 0.01512117f, 0.02018710f, -0.03869572f, 0.03928981f, -0.00116094f, 
    -0.04965427f, -0.02012873f, -0.03239245f, -0.04356546f, 0.03441806f, -0.04896387f, 0.00057589f, 0.00337657f, 
    -0.00429645f, 0.01029959f, -0.00723746f, -0.01138907f, 0.00495489f, -0.06640316f, -0.00864813f, -0.01917843f, 
    -0.05483135f, -0.02304915f, -0.01144746f, -0.03964984f, 0.01070524f, 0.03205490f, -0.05137912f, -0.02493203f, 
    -0.00643734f, 0.01540147f, 0.00870817f, 0.02401218f, -0.02457238f, -0.06125164f, -0.05751348f, 0.00252282f, 
    -0.06125803f, 0.04494577f, -0.03922754f, -0.03572681f, -0.02705932f, 0.01641866f, -0.05706491f, 0.02682439f, 
    0.01267521f, -0.05045066f, -0.05363128f, -0.01276774f, 0.01725299f, 0.00064620f, -0.02826712f, -0.03898977f, 
    0.03109552f, 0.00460061f, -0.02721247f, -0.05089581f, 0.00145960f, -0.03262778f, -0.02637964f, 0.04989127f, 
    -0.06470985f, 0.00056581f, 0.03194740f, -0.03041913f, -0.04065191f, -0.03042928f, -0.03503788f, -0.06485072f, 
    0.01129366f, 0.02468534f, 0.01281622f, -0.03935063f, -0.05140510f, -0.05687891f, -0.02134339f, -0.06715084f, 
    -0.04407153f, -0.06148075f, 0.01548686f, 0.00142897f, -0.02123511f, -0.05059522f, 0.05001464f, 0.02070477f, 
    -0.03649100f, 0.01047928f, 0.04302091f, 0.00071619f, -0.00366334f, 0.02000151f, 0.03433926f, -0.01577329f, 
    -0.03994601f, -0.02372756f, -0.02342635f, -0.00111637f, -0.01736706f, 0.00752479f, 0.01444219f, 0.00040384f, 
    -0.02867098f, 0.04979889f, -0.06117208f, -0.06087363f, 0.03918754f, -0.02129732f, -0.04260880f, -0.01259146f, 
    0.02882464f, 0.01469986f, 0.01755820f, -0.00920805f, -0.03319143f, -0.02312880f, -0.03527693f, 0.03173573f, 
    -0.00126186f, 0.01872642f, 0.03878304f, -0.01032600f, -0.01315437f, 0.04598591f, 0.03565072f, -0.06306971f, 
    0.04110220f, 0.04094219f, -0.01599948f, 0.03661710f, 0.04698426f, 0.03195551f, -0.04282597f, 0.02226093f, 
    0.01093519f, -0.05341124f, 0.03537064f, 0.02889233f, -0.02390535f, 0.01585147f, -0.01683428f, 0.03386294f, 
    -0.06656905f, -0.06663643f, -0.06164025f, -0.05582226f, -0.01411931f, -0.02906220f, 0.02885613f, -0.04554235f, 
    0.00273677f, -0.05193080f, -0.02868449f, 0.04346054f, 0.00477174f, -0.00548789f, -0.06854100f, -0.03738178f, 
    0.04348091f, 0.04449276f, -0.01228084f, -0.03278019f, 0.00044186f, 0.00999200f, -0.00211630f, -0.06396367f, 
    0.01737593f, 0.00724359f, 0.02069137f, 0.02851793f, 0.02699665f, 0.02514808f, -0.05835617f, -0.00783134f, 
    -0.05433716f, 0.03698644f, -0.00606564f, -0.01907539f, -0.06101240f, -0.06341448f, -0.00866963f, -0.05006735f, 
    0.03222246f, -0.02622866f, -0.04981877f, 0.01276118f, -0.04269980f, -0.01789891f, 0.01554758f, -0.04818394f, 
    -0.07554246f, -0.04723334f, -0.03036850f, 0.04315617f, -0.07340356f, -0.00553987f, -0.01931787f, -0.02151149f, 
    -0.05263200f, -0.00487464f, 0.02870591f, -0.07102633f, -0.00213917f, -0.02371594f, -0.04028912f, -0.07127643f, 
    -0.00051650f, -0.04714886f, -0.01877207f, -0.06188936f, -0.00444380f, -0.05162846f, -0.03797490f, -0.00153920f, 
    -0.01211496f, 0.00075777f, -0.02242106f, 0.04241430f, -0.02621030f, -0.02259224f, -0.00074506f, 0.03788729f, 
    -0.01178693f, -0.00180523f, 0.02002683f, 0.02419064f, -0.00409504f, 0.03324766f, -0.00767206f, -0.03510019f, 
    -0.03092100f, -0.01159098f, 0.00516238f, -0.08446532f, -0.05541441f, -0.06134016f, -0.02345778f, 0.01663264f, 
    -0.07332963f, -0.02582532f, -0.04668512f, -0.05704594f, -0.01293649f, -0.00173378f, -0.04127027f, -0.03201586f, 
    0.03110435f, -0.00136514f, 0.00623625f, 0.03202353f, 0.01759259f, 0.01148180f, -0.03137399f, -0.02005764f, 
    -0.02193855f, 0.00382398f, -0.03686450f, -0.01701977f, -0.06180299f, -0.01625886f, -0.01359311f, -0.05283477f, 
    -0.00716761f, -0.00334000f, 0.00682415f, -0.05835490f, 0.02728568f, -0.00603790f, -0.07260735f, -0.06393237f, 
    -0.02543851f, -0.04693335f, -0.06194576f, -0.08088794f, -0.00823504f, 0.00317615f, -0.03040293f, -0.05880479f, 
    -0.04835714f, -0.01224117f, 0.02977129f, -0.02904360f, 0.02681586f, -0.07846359f, -0.04831165f, -0.05874022f, 
    0.01023789f, 0.00003064f, -0.07153515f, 0.00935384f, 0.04340422f, -0.05165492f, 0.00767122f, -0.00018057f, 
    -0.03586677f, 0.01718107f, -0.01424413f, -0.02725817f, -0.06796262f, 0.00657464f, -0.04737666f, -0.04717015f, 
    -0.01302222f, -0.05319108f, 0.03967711f, 0.00450913f, -0.07747848f, 0.01573894f, -0.00428806f, -0.05478081f, 
    -0.06987477f, 0.00886953f, -0.02821206f, 0.00754399f, 0.01549124f, -0.06787604f, 0.01451629f, -0.01208353f, 
    -0.07370213f, -0.01356525f, -0.04448291f, -0.05340533f, -0.03918869f, 0.00046289f, 0.03507974f, -0.03538200f, 
    -0.06672056f, 0.00398871f, 0.02121588f, -0.07364666f, 0.00650657f, -0.03529479f, 0.02258227f, -0.02964316f, 
    0.01371004f, -0.05757336f, 0.01736392f, -0.03311292f, -0.03588696f, 0.03065370f, 0.04792922f, -0.05033061f, 
    -0.05534765f, -0.01248656f, 0.03665974f, -0.05156859f, 0.04095239f, -0.04817745f, -0.02039571f, 0.00333706f, 
    -0.01720334f, -0.05334322f, -0.06636953f, -0.05152021f, -0.03516314f, 0.03423031f, -0.05950497f, 0.02700945f, 
    -0.08401357f, 0.00396015f, -0.06349237f, -0.06811906f, -0.03591306f, -0.03845777f, 0.03485384f, -0.06038388f, 
    -0.01960831f, -0.06657358f, 0.01431461f, 0.02278582f, -0.00444281f, -0.06451776f, 0.00218565f, -0.07879815f, 
    -0.03300610f, -0.07086720f, -0.00546363f, 0.02363539f, -0.02912157f, -0.04292932f, -0.02947428f, -0.02538996f, 
    -0.00275891f, -0.04062053f, -0.04041841f, -0.02011883f, -0.01862506f, -0.02053764f, -0.01908508f, -0.01540734f, 
    0.00264302f, -0.06332818f, -0.01853157f, -0.00103058f, -0.02937159f, -0.07586329f, -0.06634673f, -0.02472139f, 
    -0.07641830f, -0.04010547f, -0.01575111f, 0.02059938f, -0.00126934f, 0.01359079f, -0.00357375f, -0.00648466f, 
    -0.03770174f, -0.05754254f, -0.05627955f, 0.02419503f, -0.02699295f, -0.06577435f, 0.03032586f, 0.02074220f, 
    -0.04400336f, -0.05818388f, 0.03361699f, -0.03169506f, 0.03723741f, -0.06519184f, -0.04813066f, -0.05591252f, 
    -0.06607492f, 0.03399053f, -0.01701906f, -0.03113269f, -0.05349308f, 0.05316340f, -0.05925674f, 0.00064492f, 
    -0.02459063f, -0.07566048f, -0.01859201f, -0.00316429f, 0.02615874f, -0.04029679f, 0.01349780f, -0.01056060f, 
    0.01331434f, -0.05042396f, -0.07730638f, -0.01207439f, -0.01014026f, -0.05117989f, -0.07136786f, -0.06695017f, 
    -0.05130778f, -0.06561240f, 0.01278746f, -0.00416599f, 0.02848952f, -0.04708943f, -0.07738204f, 0.02361566f, 
    0.27330583f, -0.25038293f, -0.45797712f, -0.20057566f, 0.05586932f, 0.02181645f, -0.09811157f, 0.04810394f, 
    0.00714583f, 0.29380670f, 0.09087013f, -0.41164941f, -0.08050664f, 0.15799110f, 0.13002771f, 0.21589175f, 
    -0.05248752f, -0.13853323f, -0.40308788f, 0.12520012f, -0.10270482f, 0.17509128f, 0.21654174f, 0.05009661f, 
    0.11391813f, 0.04868967f, 0.00980269f, 0.01012807f, 0.15751547f, -0.00657488f, 0.18794659f, 0.12796709f, 
    -0.07208614f, 0.13082890f, 0.05783433f, -0.12260024f, -0.09531074f, -0.29998770f, -0.00873205f, 0.35751456f, 
    0.08420420f, 0.15454260f, -0.12882134f, 0.19479953f, 0.07869777f, 0.40411660f, 0.09356863f, 0.13504530f, 
    -0.30798626f, 0.15782303f, 0.02801939f, 0.00863333f, -0.14986987f, 0.09581435f, -0.29898942f, -0.27919272f, 
    -0.10659336f, -0.19098668f, 0.12925439f, -0.34965682f, 0.19738394f, -0.01849305f, -0.11321422f, 0.19477051f, 
    0.11847862f, 0.07417995f, 0.02885311f, -0.27003467f, -0.05599030f, 0.07565083f, 0.05976257f, 0.06221448f, 
    0.50684482f, 0.22845604f, -0.28954443f, -0.06819798f, 0.05828652f, 0.25653878f, 0.01275218f, 0.17577100f, 
    0.14230064f, 0.40353057f, 0.30322897f, 0.03463569f, -0.06132932f, 0.03043839f, 0.19060007f, 0.02660486f, 
    0.01491400f, -0.06354619f, -0.51999533f, -0.47944716f, -0.49526492f, 0.01637763f, 0.05841824f, 0.01627085f, 
    -0.11382207f, -0.05804541f, -0.13354653f, 0.22208014f, 0.21119364f, 0.02124372f, -0.13112518f, -0.18841311f, 
    0.09557544f, 0.09134606f, 0.11602113f, 0.11671964f, 0.27337208f, 0.29108116f, 0.19272430f, -0.27948201f, 
    -0.10338133f, 0.06698062f, 0.14472854f, -0.17219459f, -0.08475060f, -0.10341292f, 0.11104593f, -0.23008429f, 
    0.13110961f, 0.06996883f, 0.12791856f, 0.09270184f, 0.02962082f, 0.00230267f, 0.43786299f, 0.04604415f, 
    -0.30082366f, -0.03485735f, 0.07239679f, 0.00911254f, -0.15330686f, 0.03590641f, 0.06919456f, -0.32236370f, 
    0.08445404f, -0.41995516f, 0.26101092f, -0.03783977f, 0.17067832f, 0.12424085f, -0.04748961f, 0.12937398f, 
    0.74932355f, 0.17183305f, -0.12337793f, -0.06800939f, -0.07853056f, 0.07342287f, -0.02497735f, -0.08313808f, 
    0.15491432f, 0.15715994f, 0.32830492f, 0.03174462f, -0.14893734f, -0.20599341f, -0.01609028f, -0.07729068f, 
    0.00742037f, 0.00187042f, 0.02860800f, 0.10949327f, 0.14835182f, -0.32823142f, 0.05187241f, -0.06939946f, 
    0.09597647f, -0.26268101f, -0.05469527f, -0.34694341f, -0.63794076f, -0.21150985f, 0.08164756f, 0.21186575f, 
    -0.04461259f, 0.09574299f, 0.07346150f, -0.07420657f, 0.14226171f, 0.29711467f, -0.03303511f, 0.19952661f, 
    0.07046048f, 0.06025642f, -0.31663749f, -0.01894964f, -0.19723801f, -0.13970013f, -0.28894860f, 0.23139131f, 
    0.24842390f, 0.23102076f, 0.01766357f, -0.18877435f, 0.01107942f, 0.28325725f, -0.17988789f, 0.19379826f, 
    0.09731277f, -0.15062419f, 0.13668597f, -0.05514954f, -0.11910998f, -0.12154778f, -0.20982321f, 0.08664638f, 
    0.08234969f, 0.16585143f, -0.05007031f, 0.07452230f, 0.05822753f, 0.08711492f, 0.00463433f, 0.34735385f, 
    -0.16522633f, -0.37574229f, -0.10012468f, -0.12994990f, -0.06340238f, 0.17267236f, -0.05952965f, -0.13903336f, 
    -0.14811173f, 0.10850380f, -0.34197468f, 0.12973048f, 0.09606253f, 0.13043909f, -0.14166777f, 0.03538767f, 
    -0.03318636f, 0.06597907f, -0.03992019f, 0.04006853f, -0.05886026f, 0.18317780f, -0.02175555f, -0.18388528f, 
    -0.02727593f, 0.04860864f, 0.00150311f, -0.01178953f, 0.09625134f, -0.31321272f, -0.18522538f, -0.10395645f, 
    0.02865474f, -0.08687542f, 0.30871844f, 0.00831753f, 0.18033619f, -0.23146217f, -0.10365174f, -0.10100917f, 
    -0.09292060f, -0.04556454f, -0.04469038f, -0.08218052f, -0.09063150f, 0.09648628f, -0.52528775f, 0.28371099f, 
    0.17050000f, 0.35147706f, -0.06868894f, -0.17236422f, -0.18901528f, 0.13769135f, 0.29115459f, 0.18823172f, 
    0.07638519f, -0.14287569f, 0.04165144f, 0.02212857f, 0.20308687f, -0.03404285f, 0.14394654f, 0.31344748f, 
    0.33736888f, -0.33824548f, -0.15092927f, 0.10710476f, -0.03575942f, -0.11381870f, -0.00467038f, -0.01510658f, 
    0.01934224f, -0.05202921f, 0.00768239f, -0.05211633f, 0.04063181f, -0.01492276f, 0.01853884f, 0.03803516f, 
    -0.03690640f, 0.04694248f, -0.01423970f, 0.01838034f, -0.05872152f, 0.02641941f, -0.03973769f, 0.03481184f, 
    -0.01853765f, 0.03096010f, -0.03419714f, -0.01580916f, 0.02259656f, 0.04755988f, 0.00674499f, -0.04006452f, 
    0.03946752f, 0.04608932f, 0.04804609f, -0.04740267f, -0.05323066f, -0.02047298f, -0.03426587f, -0.00157765f, 
    -0.03083924f, 0.02119621f, 0.03903883f, -0.05800272f, -0.04289705f, -0.01084461f, 0.04119887f, -0.03181857f, 
    0.03833985f, -0.04134245f, -0.06758743f, 0.04464918f, 0.02949156f, 0.03882155f, -0.04269151f, -0.06143508f, 
    0.03919749f, -0.01860316f, -0.05947723f, 0.02879432f, -0.00858270f, -0.00068565f, -0.02853905f, 0.03813162f, 
    0.01111588f, -0.00650375f, -0.03100273f, -0.02114923f, -0.02801629f, -0.00886595f, 0.01262877f, -0.00316449f, 
    0.03667657f, -0.03373367f, -0.06780940f, -0.01615099f, 0.02794042f, 0.02668011f, -0.01959660f, -0.02951598f, 
    -0.02999070f, -0.04818416f, 0.02582822f, -0.01986849f, 0.03011085f, -0.04194353f, 0.02772808f, -0.06054885f, 
    0.02316850f, -0.05409495f, -0.03322974f, -0.05561929f, 0.01402224f, 0.04914381f, 0.03832177f, 0.02834122f, 
    -0.04349554f, 0.04066278f, -0.01375682f, 0.02408015f, 0.00306346f, 0.04874859f, -0.06114413f, -0.05437610f, 
    -0.00005218f, -0.00297881f, -0.01165087f, -0.03751508f, -0.06267668f, -0.04329894f, 0.03223556f, -0.01623077f, 
    -0.04622202f, 0.04567678f, 0.01358647f, -0.00840136f, -0.04880234f, -0.01087337f, 0.01110880f, 0.00117165f, 
    0.05186021f, -0.05727241f, 0.02221844f, 0.00583106f, 0.02729276f, -0.03301497f, 0.00635258f, 0.02346698f, 
    -0.06596079f, 0.00528237f, -0.00726354f, -0.00958155f, 0.01059521f, 0.02013887f, 0.00892436f, 0.02618535f, 
    0.01250190f, -0.04143792f, -0.05361343f, 0.04393012f, 0.03209943f, 0.02022627f, 0.00408256f, 0.03520466f, 
    0.01079964f, -0.01757691f, -0.04180958f, -0.02940878f, -0.04260685f, 0.02800362f, 0.02998379f, -0.01789368f, 
    -0.06613327f, 0.03953477f, 0.03193229f, -0.05429379f, 0.01922903f, 0.00740561f, -0.04522634f, 0.03244702f, 
    -0.05492166f, -0.05704082f, 0.00403178f, 0.03619356f, -0.05815992f, 0.03738341f, -0.05563448f, -0.00398162f, 
    -0.00986779f, -0.01045149f, -0.04888416f, 0.03858335f, 0.00158506f, 0.00078692f, -0.04678521f, 0.05042576f, 
    -0.05078391f, -0.00667474f, -0.06700093f, -0.02074308f, -0.04374267f, 0.05181956f, 0.03590423f, 0.03373749f, 
    0.00175408f, -0.04166534f, -0.06548996f, -0.02621324f, -0.01225846f, 0.02180122f, 0.04953181f, 0.02054490f, 
    0.00681745f, 0.04301283f, 0.03480642f, 0.04582860f, 0.02674445f, -0.02974035f, 0.00562140f, -0.05958832f, 
    0.04578016f, 0.04163273f, -0.03247199f, 0.02972129f, -0.02067532f, -0.02422406f, -0.01064458f, -0.02055422f, 
    0.02068584f, -0.02860960f, 0.02941952f, 0.02795122f, -0.01371088f, -0.00906032f, 0.01138773f, -0.03458227f, 
    -0.00734703f, -0.02443941f, 0.03146240f, 0.03717254f, -0.03050831f, 0.00820373f, -0.00920795f, -0.01524391f, 
    -0.00547944f, -0.05912526f, -0.01093677f, -0.01582092f, 0.03760967f, 0.00710467f, -0.06802777f, -0.00539154f, 
    -0.04452123f, 0.00810042f, -0.02310775f, -0.05198541f, -0.06235027f, 0.03212176f, 0.04168473f, -0.01726248f, 
    -0.02979734f, -0.04918132f, -0.06792963f, -0.05794919f, -0.00775052f, 0.01792957f, -0.01395112f, -0.05574315f, 
    0.01951901f, -0.03853910f, -0.01525445f, -0.06235899f, -0.05896972f, -0.01956445f, -0.05087849f, 0.05035735f, 
    -0.04207157f, 0.05427727f, -0.03848625f, 0.02331584f, -0.01500991f, 0.02140571f, 0.02762780f, -0.03429337f, 
    0.01483367f, -0.03083517f, 0.01954487f, -0.06358483f, -0.05117649f, -0.02024677f, 0.02925723f, 0.04460567f, 
    -0.05037943f, -0.04169316f, 0.00622711f, 0.00546641f, -0.03940444f, -0.02627176f, -0.00565419f, -0.02765026f, 
    0.03128754f, 0.04623266f, -0.03843351f, -0.02780740f, 0.02298123f, -0.03701577f, -0.04185850f, 0.02204265f, 
    0.02212322f, -0.01754094f, 0.01734717f, -0.04897418f, -0.02880747f, -0.03470729f, 0.02511017f, -0.04672217f, 
    0.07735439f, 0.09064481f, -0.10968024f, 0.17162672f, 0.09316239f, 0.20046090f, -0.13224961f, 0.07732739f, 
    0.12006446f, -0.24333443f, -0.00285586f, -0.08285540f, 0.09641513f, 0.09662765f, 0.06980135f, -0.06150107f, 
    0.12136845f, -0.26655123f, 0.28029430f, 0.17923243f, 0.23674753f, 0.07498430f, 0.01041796f, 0.10665990f, 
    0.09232482f, 0.19991648f, -0.27413177f, 0.28811541f, 0.08627883f, 0.11488462f, 0.06152531f, -0.02475286f, 
    0.09667772f, -0.06532203f, -0.21518798f, 0.21409798f, 0.05952212f, 0.06357115f, 0.24224499f, -0.14174537f, 
    0.13571636f, 0.12688148f, -0.04810711f, 0.03683046f, -0.14018640f, -0.14981355f, 0.00682127f, -0.13103254f, 
    0.04212524f, -0.00108236f, 0.15633999f, 0.02496917f, -0.07240992f, 0.00725322f, -0.01168914f, -0.09328821f, 
    -0.29500771f, 0.13175157f, 0.00777495f, 0.04529316f, -0.21132106f, -0.11612119f, 0.04714482f, -0.11024464f, 
    -0.21245429f, -0.25097960f, -0.16816962f, 0.08722887f, -0.11485152f, 0.04538101f, 0.01017915f, -0.08482169f, 
    0.24221861f, 0.05644500f, 0.13410844f, -0.10244512f, 0.05195513f, 0.22605994f, 0.00529641f, -0.04975186f, 
    -0.17568941f, -0.02274612f, 0.08237609f, -0.07169779f, -0.02279844f, -0.02665197f, 0.07069145f, -0.00045499f, 
    0.05060933f, 0.13412198f, 0.32321128f, -0.10177985f, -0.03245977f, -0.04190456f, 0.01814577f, 0.12191640f, 
    -0.11157804f, 0.03367412f, 0.16040604f, 0.39891747f, -0.02150824f, 0.22514595f, -0.19890994f, -0.06285074f, 
    -0.09495817f, -0.06006020f, -0.04891016f, 0.00721264f, -0.01995908f, -0.39149946f, -0.20068622f, -0.03410310f, 
    0.05834208f, 0.11001477f, -0.00835709f, 0.12720144f, -0.03334678f, -0.04757190f, 0.16455521f, 0.05948991f, 
    -0.16006409f, -0.10385831f, 0.19864281f, 0.14888866f, 0.08180717f, 0.01635714f, -0.35179144f, -0.09928357f, 
    -0.13851550f, -0.04011647f, 0.01764639f, -0.14008373f, 0.01205636f, 0.13104989f, -0.11374664f, 0.07127689f, 
    0.11473302f, 0.21871221f, -0.02139876f, -0.01957805f, 0.08051650f, 0.05485132f, -0.09095608f, -0.11095816f, 
    -0.02966277f, -0.09561197f, -0.34642678f, -0.08608969f, -0.11381955f, 0.11285568f, -0.02587190f, 0.20293161f, 
    -0.10206494f, 0.13792321f, -0.46967030f, -0.56575274f, 0.02588067f, 0.06794926f, 0.09884793f, -0.12136538f, 
    0.12390979f, -0.09823545f, -0.46179730f, -0.29477611f, -0.03229918f, 0.00013102f, -0.06882922f, -0.10374758f, 
    -0.09017205f, -0.18215096f, 0.04176651f, -0.15436943f, -0.07128844f, -0.16736147f, -0.06778333f, 0.09730340f, 
    -0.08082179f, -0.04510072f, 0.05468957f, 0.04109276f, 0.24585503f, 0.19812764f, 0.17180240f, 0.01504905f, 
    0.22490980f, -0.02565257f, -0.11609815f, -0.04527195f, 0.13808480f, -0.03709150f, 0.12176781f, 0.13167918f, 
    0.01719049f, 0.16436106f, -0.16513944f, 0.18894710f, 0.17251962f, 0.14847934f, -0.00564708f, 0.09776471f, 
    -0.40146530f, -0.04521521f, -0.02802130f, 0.13725512f, 0.10395562f, -0.20967939f, -0.03191527f, -0.25035655f, 
    0.13158959f, 0.21460807f, 0.06846138f, -0.10955848f, 0.01710435f, -0.08504479f, -0.14015415f, -0.01553629f, 
    -0.22042716f, -0.30238858f, -0.16542807f, 0.14734748f, 0.04840409f, -0.14119384f, 0.08758014f, 0.00090808f, 
    -0.03246890f, -0.05734142f, -0.45298114f, -0.43242100f, 0.02418912f, -0.12485227f, 0.18265134f, -0.04464779f, 
    -0.08422390f, -0.03880628f, -0.03432411f, -0.14655688f, 0.17821135f, -0.06922180f, -0.17896816f, 0.08469626f, 
    0.21202035f, 0.05267089f, 0.12916738f, -0.03282632f, -0.09155022f, -0.02526128f, -0.16192183f, -0.25493628f, 
    0.11955270f, 0.10465393f, 0.09713604f, 0.21960625f, -0.43052405f, -0.14102972f, 0.21353868f, 0.04814363f, 
    0.09355847f, -0.14059013f, 0.10173850f, -0.21214065f, 0.07705422f, -0.24771252f, -0.15694557f, -0.01548166f, 
    0.02112211f, 0.15655346f, -0.23571584f, 0.21133663f, 0.06575499f, 0.08363487f, -0.38273370f, -0.14329255f, 
    0.21741465f, 0.08115651f, 0.17696573f, -0.10386270f, 0.04549212f, -0.00590649f, -0.12707110f, 0.11516116f, 
    -0.06960756f, -0.02022113f, 0.02111541f, -0.03665848f, -0.06655511f, 0.08362666f, 0.06937291f, 0.38247156f, 
    -0.05092491f, 0.20007026f, 0.17640752f, 0.19789377f, -0.06740872f, 0.10167186f, -0.12224872f, 0.04030500f, 
    0.02735180f, -0.13462435f, -0.13899541f, -0.07106293f, 0.08582511f, 0.01920446f, -0.01754969f, 0.03652312f, 
    -0.01894290f, 0.05288288f, -0.04928359f, 0.27731863f, 0.14196603f, -0.04913637f, -0.04700787f, -0.08521227f, 
    -0.04300825f, 0.10234062f, 0.10394095f, 0.17124262f, -0.00732257f, 0.10027298f, -0.10658722f, 0.06090937f, 
    -0.14793687f, -0.03840230f, 0.23515023f, 0.19540147f, 0.06476685f, 0.05194273f, 0.08776706f, 0.13798408f, 
    0.01295362f, -0.08215626f, -0.01181021f, 0.16432719f, 0.00832890f, -0.19333570f, 0.06462109f, -0.03397056f, 
    -0.07638025f, -0.05548166f, -0.07948107f, 0.00286668f, -0.08229779f, 0.13534871f, -0.24699274f, 0.05328203f, 
    0.43413955f, 0.06442144f, -0.11367638f, -0.02622102f, 0.17314890f, -0.02986428f, 0.15177183f, -0.36241928f, 
    -0.12305229f, 0.10905480f, -0.13009675f, 0.20425752f, -0.11846823f, 0.01795694f, -0.17226085f, -0.07933077f, 
    0.06844139f, 0.19440815f, 0.13646664f, -0.09738387f, -0.07100288f, -0.15758133f, 0.16351412f, 0.01710186f, 
    -0.01776704f, -0.19940493f, 0.02397376f, 0.11998662f, -0.01122725f, -0.12786514f, 0.11835428f, -0.02078165f, 
    -0.08935934f, 0.21764365f, -0.10931078f, -0.15665655f, -0.22738843f, 0.14725576f, -0.05297697f, 0.35035315f, 
    0.07699983f, -0.16846688f, -0.03307937f, 0.10395835f, 0.22771023f, -0.09934561f, -0.12871313f, -0.11364783f, 
    0.14421907f, -0.05242009f, -0.00969571f, 0.17842600f, 0.15845805f, -0.01591255f, -0.19676621f, 0.07100947f, 
    -0.02094523f, -0.07532457f, -0.09753706f, -0.01659057f, 0.09708085f, 0.20074980f, -0.05297303f, -0.08388112f, 
    -0.06428817f, -0.05493158f, 0.09433863f, 0.20236282f, 0.11417318f, -0.16119547f, -0.01216920f, -0.05802633f, 
    0.05901876f, 0.14351653f, 0.06458940f, -0.00803131f, 0.03559870f, 0.03206413f, 0.03501434f, -0.01589977f, 
    0.03333366f, -0.10217248f, -0.04668421f, -0.06744886f, 0.10170846f, -0.02720277f, -0.08150665f, 0.05420786f, 
    -0.37200305f, 0.04759278f, -0.03858569f, 0.08419103f, -0.12337576f, 0.02806168f, 0.02741921f, 0.02888452f, 
    -0.05084265f, 0.22422537f, 0.09574866f, -0.31460971f, -0.01202654f, -0.08275838f, -0.05083342f, 0.00338196f, 
    -0.22035369f, -0.13735855f, -0.18757737f, -0.05017403f, -0.04462991f, 0.11716539f, -0.02836960f, 0.05269050f, 
    -0.02098649f, 0.11680978f, 0.04042836f, -0.38079506f, -0.08104017f, 0.09374770f, -0.08360294f, 0.02558823f, 
    0.07023492f, -0.02866677f, 0.01188986f, 0.03292006f, 0.09759409f, -0.16129363f, -0.15185532f, 0.11799700f, 
    0.14360647f, 0.01968937f, -0.13358101f, 0.04826603f, 0.05587673f, -0.37775999f, 0.06286005f, 0.17435069f, 
    0.01085239f, -0.12063446f, -0.10803126f, 0.04984744f, 0.24323322f, 0.10061900f, 0.09578815f, 0.30913106f, 
    -0.14874506f, -0.28440601f, -0.18915871f, -0.16817357f, 0.27076906f, -0.19831364f, -0.14950392f, 0.08560076f, 
    0.12338592f, -0.28491840f, -0.20340669f, -0.03507670f, -0.18225187f, 0.13682595f, 0.16971375f, -0.05004365f, 
    -0.31636760f, -0.02821855f, 0.03041501f, 0.21638949f, -0.02256942f, 0.12309412f, 0.05771307f, -0.09752952f, 
    0.04391355f, -0.20617974f, -0.18682428f, -0.02839567f, -0.00839008f, 0.00934667f, 0.06902854f, -0.10493235f, 
    0.19558276f, -0.03955067f, -0.31535888f, -0.05681738f, 0.00280452f, 0.10981806f, 0.02760188f, 0.11022434f, 
    0.07399250f, 0.06791016f, 0.00056942f, 0.05000225f, 0.11619864f, -0.05780100f, 0.10431511f, -0.25477868f, 
    -0.02597508f, 0.15213560f, -0.07241391f, -0.15859431f, -0.34190169f, 0.10244142f, -0.27890217f, 0.17048755f, 
    0.17424798f, 0.19807351f, -0.13530552f, 0.05951313f, 0.16916804f, -0.27496698f, -0.18327013f, -0.20455515f, 
    0.15306130f, 0.06181600f, 0.19311085f, 0.25008383f, -0.21470192f, -0.14579596f, 0.19328456f, 0.02403496f, 
    -0.57609409f, 0.09881133f, -0.18873663f, -0.05040263f, 0.21542998f, -0.12128019f, 0.27018872f, 0.18263359f, 
    -0.08009525f, -0.10363895f, 0.00021911f, -0.02954515f, 0.10797663f, -0.02590765f, 0.28079325f, 0.24429707f, 
    -0.05750282f, -0.20022839f, 0.05914252f, 0.08518122f, -0.01912480f, 0.06547771f, -0.07230475f, -0.04830284f, 
    0.05919474f, -0.13625720f, -0.08077864f, -0.00763263f, -0.00392855f, 0.06548354f, 0.23653024f, -0.03042121f, 
    0.06657666f, -0.03033461f, 0.39023712f, 0.07878936f, 0.22382851f, 0.01834027f, -0.01646704f, -0.01088210f, 
    0.06340633f, 0.25347060f, 0.22105059f, 0.24312463f, 0.01507979f, -0.06380899f, 0.03843588f, -0.10553786f, 
    0.08068296f, 0.21228336f, 0.09969423f, 0.04508745f, 0.04683657f, 0.04193873f, 0.17531708f, 0.10942214f, 
    0.11063565f, -0.14224291f, -0.04028959f, -0.02543337f, 0.08558792f, -0.09109751f, 0.24089016f, -0.09078698f, 
    -0.01558558f, 0.12877782f, 0.04414526f, -0.07592994f, -0.10025919f, -0.07021982f, 0.26529658f, 0.21859103f, 
    0.01819470f, 0.14849390f, -0.03233378f, 0.26870635f, 0.07449605f, -0.00896251f, 0.06832100f, -0.32382151f, 
    -0.21947931f, -0.11721875f, -0.20654584f, 0.05305919f, -0.14781161f, -0.00136812f, 0.01083051f, -0.00101032f, 
    -0.19343568f, 0.08977970f, 0.08275853f, 0.20546758f, 0.03194318f, -0.09631754f, 0.10564813f, -0.04650829f, 
    0.04103106f, 0.14150023f, 0.16472054f, -0.10565206f, 0.18786931f, -0.09191068f, 0.36108017f, -0.16372605f, 
    -0.11401126f, -0.15024653f, -0.06510054f, -0.14922312f, -0.11895707f, 0.04473878f, 0.06953872f, 0.16633311f, 
    0.00984009f, -0.09393252f, -0.19312796f, 0.33084917f, -0.07928122f, 0.03370239f, 0.12302516f, -0.26849073f, 
    -0.01705717f, 0.03217511f, 0.02232130f, 0.05525134f, 0.03883458f, 0.11242812f, -0.29145211f, -0.12156926f, 
    0.11055133f, -0.15946433f, -0.03073405f, -0.14080769f, -0.09541092f, 0.15056565f, 0.06023446f, -0.08799459f, 
    -0.00917517f, -0.07412975f, 0.00965335f, 0.08196948f, 0.04966781f, 0.02953317f, -0.50422221f, -0.02810105f, 
    0.16070998f, 0.15396909f, -0.04376170f, -0.20727268f, -0.14315942f, 0.19642350f, 0.15320013f, 0.21843827f, 
    -0.00793175f, 0.15632655f, -0.03556974f, -0.11895470f, 0.06469145f, -0.07599062f, 0.06516008f, 0.09789599f, 
    -0.27032256f, 0.14786886f, 0.08680030f, 0.14459772f, -0.05314562f, 0.00632623f, 0.08923721f, 0.06554077f, 
    -0.01018583f, -0.05739726f, -0.01907350f, -0.17582406f, -0.06392749f, -0.03922290f, -0.14781454f, 0.01308545f, 
    -0.13740423f, -0.30706474f, -0.04977770f, 0.10689348f, 0.00441380f, -0.07426432f, 0.03534639f, -0.02656388f, 
    0.09339085f, 0.08690169f, 0.10480211f, 0.31596935f, 0.24396552f, -0.27042961f, 0.18276149f, -0.05186454f, 
    0.26577207f, -0.12588811f, -0.11361293f, -0.24038830f, -0.08130927f, 0.00098917f, -0.01730059f, 0.10200857f, 
    -0.02906640f, 0.13099624f, -0.01644594f, -0.03443153f, -0.11651796f, -0.21124630f, 0.20382801f, 0.03807358f, 
    0.02731298f, -0.08487906f, 0.00026261f, -0.07645433f, 0.08668447f, 0.08544362f, -0.15391068f, 0.27167159f, 
    0.07137141f, -0.09290018f, -0.01019265f, -0.08756790f, 0.23844671f, -0.10954706f, 0.09574049f, -0.02509912f, 
    -0.03747446f, 0.04744425f, -0.23047803f, 0.00471936f, -0.19358635f, 0.07678419f, 0.02190201f, 0.24846925f, 
    -0.21144192f, 0.29291353f, -0.11544479f, 0.27061161f, -0.08100999f, -0.16685741f, 0.19083931f, -0.04712196f, 
    -0.05774450f, 0.08421874f, -0.12028533f, -0.16139309f, 0.03710831f, 0.11163550f, -0.06832227f, 0.07234792f, 
    -0.22495297f, 0.00305429f, -0.16824201f, 0.09695549f, 0.10864902f, -0.06938230f, 0.13003679f, -0.06573828f, 
    -0.15909192f, 0.14799462f, -0.08675864f, -0.08037233f, 0.27573666f, -0.09959914f, 0.08578359f, -0.27756432f, 
    0.14451934f, -0.16818911f, -0.18938956f, -0.05400533f, -0.40087014f, -0.21807733f, 0.08241148f, 0.01177081f, 
    0.02068733f, 0.01027665f, -0.07714702f, -0.18075204f, -0.01999251f, -0.17982358f, 0.18627454f, -0.25409329f, 
    0.11149141f, -0.10198650f, 0.05894043f, -0.14393456f, 0.06788049f, -0.00757087f, 0.12728824f, -0.10142136f, 
    -0.02203799f, -0.22728965f, -0.03022002f, -0.15237865f, 0.14098416f, 0.01619365f, -0.02927938f, 0.01428891f, 
    0.04191996f, -0.11852968f, 0.22261481f, 0.01446719f, 0.04853841f, 0.07608446f, 0.08579774f, 0.22325245f, 
    -0.01252345f, -0.04562892f, 0.03121422f, 0.00859293f, 0.02955203f, -0.06211635f, 0.04459516f, 0.01967844f, 
    0.03683000f, -0.05140574f, 0.01252234f, -0.03098403f, 0.00375369f, -0.02789060f, -0.01291796f, -0.05162828f, 
    -0.04283436f, -0.00988175f, 0.02793114f, 0.02715951f, 0.04559290f, -0.04584954f, -0.02216080f, -0.00663541f, 
    0.00659017f, 0.00096187f, -0.04528089f, -0.01981552f, -0.03445994f, -0.01965687f, -0.06784234f, -0.04473738f, 
    0.03557707f, 0.04030757f, 0.01399800f, 0.02768757f, -0.05177788f, -0.00062076f, 0.01785425f, -0.03793724f, 
    -0.03377660f, 0.00709572f, -0.05462539f, 0.01169509f, 0.02422379f, 0.00458266f, 0.01511719f, 0.03721280f, 
    0.01286137f, -0.03297856f, -0.04148480f, -0.05213912f, -0.04706974f, -0.05433083f, 0.02396155f, 0.00778151f, 
    -0.00762724f, -0.03142112f, 0.00744239f, 0.03330089f, -0.03913497f, -0.04529788f, -0.02465086f, 0.04680904f, 
    -0.05224792f, 0.03814564f, -0.05979197f, -0.02607748f, -0.02233418f, 0.00339733f, -0.02334758f, 0.04414659f, 
    0.02249838f, -0.01438055f, -0.02231203f, 0.03247433f, -0.02627744f, 0.00390341f, -0.05299468f, 0.03906619f, 
    -0.04609971f, -0.05639184f, -0.05152126f, 0.01547769f, -0.01510286f, -0.03030297f, 0.01044190f, -0.03002159f, 
    0.03206914f, -0.04312321f, -0.03312529f, -0.00678463f, -0.00940958f, 0.02774647f, 0.04416764f, -0.03649507f, 
    -0.02456752f, -0.01035067f, -0.02953119f, 0.04720641f, -0.05648822f, -0.00397064f, -0.00618866f, -0.03701281f, 
    -0.06513682f, 0.00618812f, -0.04857124f, -0.02599013f, -0.03006162f, -0.04868653f, -0.06247842f, -0.05873116f, 
    0.04320946f, -0.04424024f, 0.02614772f, 0.04621474f, 0.01484118f, 0.04394387f, -0.00108886f, 0.00550859f, 
    -0.01704228f, -0.05817129f, -0.02156490f, -0.00125106f, 0.02096020f, 0.01546415f, -0.00783009f, -0.05497656f, 
    -0.05966207f, 0.04534519f, -0.04014125f, -0.04766510f, -0.02643172f, 0.02924026f, -0.06835976f, 0.00582129f, 
    0.01553092f, -0.05217566f, -0.05300554f, -0.01099823f, -0.03893820f, -0.00241526f, -0.03196369f, -0.00849612f, 
    0.05022859f, -0.02835953f, -0.06140848f, -0.05529869f, -0.06494006f, 0.03086938f, -0.04033900f, -0.04718810f, 
    -0.01392914f, -0.01409983f, -0.00730774f, -0.03876493f, 0.02506502f, -0.00818308f, -0.01898249f, -0.00024352f, 
    0.02686411f, 0.00858800f, -0.03966319f, 0.00815052f, -0.04999597f, -0.04261664f, -0.05908892f, -0.01995086f, 
    -0.01231697f, -0.05271173f, -0.00031371f, -0.03074956f, -0.01614290f, -0.00577515f, 0.02049294f, -0.04043515f, 
    0.02688518f, -0.02732346f, 0.01726543f, -0.03794731f, -0.04244227f, -0.00334002f, -0.01571573f, -0.00563795f, 
    -0.03658636f, -0.06733866f, -0.00828096f, 0.02480075f, -0.00868845f, -0.04001450f, -0.04797812f, -0.05318986f, 
    -0.01592089f, 0.03795468f, -0.01590240f, 0.01031801f, 0.01437375f, 0.02503730f, 0.03745667f, 0.03646471f, 
    -0.02770035f, 0.01423248f, -0.02722630f, 0.03339517f, -0.03510101f, 0.03865237f, -0.01468474f, -0.06282304f, 
    -0.02650994f, 0.00446527f, 0.02323494f, 0.00942573f, -0.02957564f, 0.01848677f, -0.05612275f, 0.04554743f, 
    -0.00871437f, -0.01282738f, 0.03636059f, 0.04537292f, 0.00228882f, -0.03026648f, -0.03134958f, -0.01047530f, 
    0.01886783f, 0.01687961f, -0.06760918f, 0.02433243f, -0.02151435f, 0.03272463f, -0.01957958f, 0.04781174f, 
    -0.03645775f, 0.03965385f, 0.02425150f, -0.01179519f, 0.01635823f, 0.02884453f, -0.00398869f, -0.00768219f, 
    0.02497152f, -0.00356430f, -0.00324396f, 0.04615474f, 0.00410888f, 0.03156696f, -0.03142520f, -0.04127394f, 
    0.03589883f, -0.05571802f, 0.01334265f, -0.05602759f, 0.03911874f, 0.04831745f, -0.01792914f, -0.05793092f, 
    -0.01322171f, 0.04111119f, 0.02552010f, 0.04617669f, -0.02248022f, 0.01026456f, 0.03021424f, 0.02630143f, 
    0.04861514f, 0.01292700f, 0.01607157f, -0.02243497f, -0.04106280f, 0.03655785f, -0.04639184f, 0.00468037f, 
    0.03365973f, -0.00638237f, 0.02210545f, -0.00310172f, 0.00601022f, -0.04822548f, -0.02759569f, 0.01440871f, 
    0.00262720f, 0.00939005f, 0.01306875f, -0.01910039f, -0.02386989f, 0.04148627f, 0.00924275f, -0.01820688f, 
    0.24441245f, -0.03031663f, -0.02183599f, 0.12618023f, 0.06780806f, 0.06453074f, 0.02666139f, -0.05342937f, 
    -0.10017920f, 0.20864467f, 0.30884489f, 0.03825313f, 0.01054187f, -0.13044393f, 0.05298614f, 0.01171378f, 
    0.03205064f, 0.06314798f, 0.01120639f, -0.29634383f, -0.20863688f, 0.09603710f, 0.10618046f, -0.00143104f, 
    0.12920402f, 0.04958288f, -0.10547241f, 0.18314739f, -0.01351873f, 0.08800361f, 0.08485658f, 0.03604614f, 
    -0.04960993f, -0.04780490f, 0.07629620f, -0.01769152f, -0.25408316f, 0.00074298f, -0.23157538f, 0.22870311f, 
    0.15147573f, 0.05184864f, 0.15999736f, 0.08153273f, -0.08680931f, -0.06331199f, 0.02829684f, -0.07924867f, 
    0.25899434f, 0.15320471f, -0.05103498f, -0.02283647f, -0.10577797f, -0.09572902f, -0.15847158f, -0.08203646f, 
    -0.13199699f, 0.01127636f, 0.12609011f, -0.15965484f, 0.18580730f, 0.07168017f, -0.03999713f, -0.06249608f, 
    0.26340505f, -0.04173030f, -0.08880149f, 0.03580830f, 0.12042942f, -0.06892147f, 0.04883976f, 0.16326037f, 
    -0.31369326f, 0.03846991f, -0.19073823f, -0.00091963f, 0.11365979f, 0.24831863f, 0.04133376f, -0.07390465f, 
    -0.26313493f, 0.18404926f, 0.16523847f, -0.35270026f, 0.11047235f, -0.00994884f, -0.29203713f, 0.02236880f, 
    0.09128069f, -0.03371084f, 0.12491318f, -0.02605983f, 0.17963549f, -0.10604902f, -0.01320782f, -0.12800238f, 
    0.08617535f, -0.01156228f, -0.14969179f, -0.32811946f, 0.02995802f, -0.00282208f, -0.10007759f, 0.07151990f, 
    -0.10034946f, -0.07767591f, 0.00622691f, -0.18967177f, -0.16231233f, 0.14875621f, -0.11071951f, -0.04810458f, 
    0.09768201f, 0.21032199f, -0.09819946f, -0.03481629f, 0.12943669f, -0.10162583f, -0.03525478f, -0.13708667f, 
    0.04031094f, 0.22270596f, 0.08473818f, 0.12355708f, 0.10067584f, 0.04229757f, 0.12442809f, 0.31669942f, 
    -0.02998006f, -0.39684543f, 0.05601035f, 0.13994053f, 0.12965192f, 0.03436070f, -0.01612681f, 0.14188106f, 
    0.03267078f, -0.30438489f, 0.16074304f, 0.11397331f, 0.06743681f, 0.26592082f, 0.03691596f, 0.02953186f, 
    -0.27761570f, -0.04489816f, -0.09256936f, 0.23211168f, 0.13913806f, 0.15199739f, 0.07839857f, -0.14859471f, 
    -0.14104262f, -0.34400478f, 0.22530176f, -0.04002689f, 0.06937969f, -0.00003088f, 0.22768950f, -0.07539125f, 
    0.10427458f, 0.29493594f, 0.08984857f, 0.10658494f, -0.14841688f, 0.08688771f, 0.14815955f, 0.08445507f, 
    0.05180759f, -0.06109163f, -0.04618369f, 0.20502469f, 0.08991147f, -0.12930855f, -0.07171914f, -0.06384861f, 
    -0.13859630f, 0.16323993f, 0.14212327f, 0.04379576f, 0.01683031f, 0.33641952f, -0.11847685f, 0.02429016f, 
    0.14688386f, -0.03154811f, 0.07716195f, -0.03051490f, 0.03289904f, 0.24085471f, -0.08413537f, -0.15922870f, 
    -0.10841835f, 0.16291495f, 0.04699907f, 0.05999758f, 0.10486642f, -0.00144932f, -0.12314496f, 0.16041628f, 
    -0.04136872f, -0.17103510f, 0.15037991f, 0.10502147f, -0.04227270f, -0.05598390f, 0.03202782f, -0.19078748f, 
    -0.06234391f, -0.12573972f, 0.23529463f, 0.16697849f, 0.17899460f, 0.14509182f, 0.07847713f, -0.49668643f, 
    -0.06880345f, 0.27036878f, -0.20626067f, -0.08991703f, -0.08976671f, 0.13003361f, 0.06677894f, 0.08358964f, 
    0.06512257f, -0.25294113f, 0.03174056f, 0.25500360f, 0.14693877f, -0.24722844f, 0.07582666f, -0.00009593f, 
    -0.01674703f, 0.17754270f, 0.19279365f, -0.07925261f, -0.01526627f, 0.01533129f, -0.01942696f, -0.03478461f, 
    -0.06370550f, 0.06876409f, -0.01526592f, -0.11754314f, 0.02087551f, -0.30435058f, -0.00431275f, 0.14557409f, 
    0.26232138f, 0.17874943f, 0.14098863f, -0.25438264f, 0.27355164f, 0.10310867f, -0.02759681f, -0.01850163f, 
    0.05853230f, -0.02930666f, 0.08280928f, 0.10415657f, 0.04117914f, 0.34041041f, -0.06599479f, -0.02808370f, 
    0.02366005f, -0.21507619f, 0.14698319f, 0.18531531f, 0.29369524f, 0.12192442f, -0.03210141f, 0.04210414f, 
    -0.15489145f, 0.03919823f, 0.18337071f, 0.21061902f, 0.04508603f, 0.26394057f, 0.01126888f, -0.19622287f, 
    0.01151529f, -0.00321122f, 0.01783524f, -0.13376522f, -0.09255344f, -0.02136772f, 0.16440676f, -0.05572543f, 
    -0.05345968f, -0.02650814f, 0.01788107f, -0.02147818f, 0.02831551f, 0.01334712f, 0.02827308f, -0.04331535f, 
    -0.02170562f, -0.03202458f, 0.02978352f, 0.04401589f, -0.03939275f, 0.00763082f, -0.02315162f, 0.01842670f, 
    0.03734833f, 0.05930804f, 0.03158555f, 0.03603417f, 0.00277220f, -0.05265767f, 0.03447974f, 0.02130780f, 
    -0.01145505f, 0.04834256f, -0.00878662f, -0.05359805f, -0.04791812f, -0.02608932f, -0.04660368f, -0.03550878f, 
    0.00290534f, 0.04698853f, -0.00315482f, -0.06695241f, -0.05705175f, 0.00570137f, -0.00637503f, 0.04620715f, 
    -0.02542082f, 0.02413762f, 0.05028671f, 0.02347457f, 0.01649433f, -0.04672271f, 0.02791289f, -0.00154264f, 
    -0.04767860f, -0.03176818f, 0.02242981f, -0.05540175f, 0.00750419f, -0.02762329f, 0.02809274f, -0.00011376f, 
    -0.05110659f, 0.03152860f, 0.00007711f, 0.04454472f, -0.01840938f, 0.01035715f, -0.03064222f, 0.02034801f, 
    0.01311152f, 0.00312771f, -0.05765767f, -0.02436371f, 0.00214527f, 0.03543951f, 0.02976480f, 0.00483845f, 
    0.04339923f, 0.02002974f, -0.07031985f, -0.01109295f, -0.05290790f, -0.00973873f, -0.01634925f, 0.01938707f, 
    0.00340849f, -0.06298856f, 0.02946612f, 0.04280557f, 0.03177436f, 0.03827453f, -0.04112536f, -0.02688381f, 
    0.03301127f, 0.03712280f, -0.05414663f, -0.03140624f, -0.06530257f, 0.03741305f, -0.00616587f, 0.01546270f, 
    -0.00389640f, 0.01119002f, -0.04696698f, 0.03430950f, 0.01585928f, -0.02391997f, 0.03430241f, -0.01676111f, 
    0.03980050f, 0.01496213f, -0.00978139f, -0.05522959f, -0.05175033f, -0.05389730f, -0.02912112f, -0.00291822f, 
    0.04637835f, 0.03182009f, -0.01683956f, -0.02215537f, 0.02163607f, 0.03348633f, 0.02908931f, 0.03620653f, 
    -0.00710501f, -0.01510038f, 0.01749876f, 0.03857504f, -0.02876016f, 0.01063730f, 0.00437026f, 0.02207600f, 
    -0.02019870f, -0.01412288f, -0.06317838f, -0.02518714f, 0.02013423f, -0.01819454f, -0.04860147f, -0.06987462f, 
    -0.03106447f, 0.03053228f, 0.02996495f, -0.00886353f, 0.01261484f, 0.01956465f, 0.02350227f, -0.01373486f, 
    -0.01047955f, 0.00322991f, -0.05920907f, 0.02778590f, 0.00503748f, -0.01287130f, 0.03981192f, 0.02561126f, 
    0.02305887f, 0.05085876f, 0.04257071f, -0.01749355f, -0.05571472f, -0.01707846f, 0.04198394f, -0.01918799f, 
    -0.02726098f, -0.05808125f, 0.03034144f, -0.03400227f, -0.06173096f, 0.03896071f, -0.06171379f, 0.01206896f, 
    -0.02669736f, 0.04025857f, -0.02003973f, -0.03320594f, -0.03104827f, -0.03908930f, -0.00441856f, -0.02640443f, 
    -0.05745902f, -0.00020794f, -0.05880986f, 0.01970903f, -0.06390776f, -0.05918890f, -0.06410845f, -0.01838232f, 
    -0.00331853f, -0.02568397f, -0.02624987f, -0.05592280f, 0.00590371f, -0.04095927f, -0.01569613f, -0.03864169f, 
    -0.05354851f, 0.02224234f, -0.04472390f, -0.03741778f, 0.01226246f, 0.04624017f, -0.03330745f, -0.00015897f, 
    -0.00389584f, -0.05832030f, 0.01898258f, -0.00869347f, -0.03245752f, 0.00029088f, -0.05240392f, 0.01272803f, 
    -0.05005549f, 0.00061633f, 0.03505773f, -0.02892405f, 0.00116750f, -0.00037727f, 0.04505198f, -0.06969332f, 
    0.00423938f, -0.03983312f, 0.02067942f, -0.01791702f, 0.04914426f, -0.06360867f, 0.05341418f, -0.02412971f, 
    -0.05459980f, -0.02782637f, -0.06343133f, 0.00507885f, 0.03756377f, -0.03162142f, -0.01862756f, 0.04855223f, 
    0.02894208f, 0.02906026f, -0.00337186f, 0.01815084f, 0.02219394f, -0.00544142f, -0.06598817f, -0.05254970f, 
    0.01387722f, 0.04554619f, 0.03612754f, -0.01504856f, -0.00826929f, -0.01051066f, -0.01442116f, -0.03518483f, 
    -0.00841684f, -0.02003201f, -0.02549731f, 0.02144380f, 0.05024161f, 0.01306566f, 0.05188720f, -0.03266314f, 
    -0.00748913f, -0.03361939f, -0.05962479f, -0.04440993f, 0.03098170f, -0.03116510f, -0.03150504f, -0.01513247f, 
    0.01155127f, 0.02369915f, -0.02500442f, -0.02055040f, 0.02409442f, 0.04773468f, -0.04099169f, -0.05481092f, 
    -0.04670907f, 0.00557869f, -0.01242472f, -0.02969356f, 0.03247743f, 0.01869529f, 0.00504374f, -0.01632758f, 
    0.04487928f, 0.04115105f, -0.04261237f, 0.03751251f, -0.02219000f, 0.00562301f, -0.04008781f, -0.04076178f, 
    0.08341467f, -0.16779083f, 0.02462013f, 0.12923279f, -0.10422229f, -0.10961940f, 0.22705546f, 0.15351127f, 
    0.05545886f, -0.32024843f, -0.14703874f, 0.04701799f, 0.17815103f, 0.00433720f, -0.10798797f, 0.01073387f, 
    0.20121047f, -0.15235874f, -0.04215097f, -0.03353687f, 0.15081149f, -0.25277460f, -0.01001153f, -0.03186674f, 
    -0.27216309f, 0.08938980f, -0.28137016f, 0.05546795f, 0.18569721f, 0.14958067f, -0.08304264f, -0.07815479f, 
    -0.14076318f, 0.00784252f, -0.02714447f, -0.12810630f, 0.02643949f, 0.23932691f, 0.19979802f, 0.07110257f, 
    -0.02967305f, -0.09385859f, 0.04061572f, 0.19010685f, -0.08894260f, -0.23826699f, -0.08164244f, -0.18998028f, 
    0.19355801f, 0.20129079f, 0.14885281f, -0.05128482f, -0.17620650f, -0.12618858f, -0.08003039f, -0.36346516f, 
    -0.18040028f, 0.24938537f, 0.10758183f, -0.16465446f, -0.09104107f, 0.02490189f, 0.06004254f, -0.76638567f, 
    -0.27417630f, -0.17145661f, 0.12584947f, 0.18469816f, -0.10812590f, 0.23592582f, 0.03930902f, -0.07840642f, 
    0.42684624f, 0.04221664f, 0.04272838f, -0.17146818f, 0.04844590f, 0.02713501f, 0.10607746f, 0.01056729f, 
    -0.03889623f, 0.16591297f, 0.13398553f, 0.35346961f, -0.11027578f, -0.03395664f, 0.18755090f, 0.01102786f, 
    0.04509950f, 0.26256558f, -0.00269154f, -0.12349642f, 0.06959993f, -0.05316748f, -0.06107253f, 0.16381994f, 
    -0.10856883f, 0.02723854f, 0.10104271f, -0.16393872f, -0.10683296f, 0.05239971f, -0.33184782f, -0.25744638f, 
    0.09647126f, -0.02991665f, -0.07369301f, -0.17140254f, 0.13532852f, 0.15539837f, -0.09891999f, 0.20761433f, 
    0.21560812f, 0.18816118f, -0.19388221f, 0.00461170f, -0.09151466f, -0.06561082f, -0.00188774f, 0.23840620f, 
    -0.17237543f, -0.10274445f, 0.07306839f, -0.10332923f, 0.07638495f, 0.16249086f, -0.00923419f, -0.43673110f, 
    0.15752377f, -0.09281153f, -0.06153415f, 0.05201835f, -0.11208172f, -0.08172120f, 0.06846859f, -0.02826703f, 
    0.05498003f, 0.35265958f, -0.10213801f, -0.12612674f, -0.15474853f, 0.12724036f, -0.06222152f, -0.17829849f, 
    -0.12312009f, -0.20415151f, -0.15518245f, 0.07393339f, 0.18479599f, -0.07075085f, -0.08167454f, -0.18874468f, 
    -0.19522808f, 0.03993614f, 0.03295121f, -0.18843813f, 0.18147273f, 0.25664780f, 0.14688738f, -0.25189522f, 
    0.00336958f, -0.04701857f, -0.12580776f, -0.32288671f, -0.27334541f, 0.12248987f, 0.04880384f, 0.15647678f, 
    0.17338927f, 0.01478850f, -0.11379501f, -0.04852312f, 0.07785966f, -0.08452375f, 0.23308872f, 0.27778089f, 
    0.16231842f, 0.14283052f, 0.00271479f, 0.14192146f, -0.04302927f, 0.12847506f, 0.20508212f, -0.20147194f, 
    -0.06266708f, -0.14011437f, -0.13474348f, 0.18134113f, 0.08917198f, 0.15023251f, 0.12239201f, 0.10163104f, 
    -0.07821255f, -0.09862702f, -0.01756096f, 0.29913196f, 0.22150764f, 0.25770748f, 0.26432398f, -0.10766889f, 
    -0.13258690f, -0.10419321f, 0.28500855f, 0.14458990f, 0.22991969f, -0.47436813f, -0.03987374f, 0.20791486f, 
    0.15514289f, 0.31033301f, 0.16064173f, -0.05504881f, 0.06662285f, 0.11556498f, 0.09670191f, -0.15499747f, 
    0.10650990f, -0.03873693f, 0.02240682f, 0.01812517f, -0.03202669f, -0.05851178f, -0.04623474f, 0.13274416f, 
    0.17828512f, -0.41008011f, -0.24259271f, -0.41908127f, 0.08067888f, 0.11684932f, 0.12644455f, 0.04010601f, 
    0.13388717f, -0.10436994f, -0.22406150f, -0.20166303f, 0.06432620f, 0.19011936f, 0.07232179f, 0.05471921f, 
    0.05205315f, -0.03864234f, 0.07709869f, 0.24500009f, -0.05471608f, 0.12530263f, -0.21836041f, 0.22214030f, 
    0.00812648f, 0.12854967f, 0.21757641f, 0.24709292f, -0.25958252f, -0.27355915f, 0.08458664f, 0.16924468f, 
    0.13559389f, -0.11006872f, -0.01991970f, -0.00609804f, -0.05755964f, -0.18273526f, 0.25356251f, 0.11810031f, 
    -0.03905205f, -0.06656583f, -0.33932829f, 0.20996521f, 0.02852935f, 0.06533352f, 0.08438992f, 0.07664680f, 
    0.23800628f, 0.04390488f, 0.04238334f, -0.17339975f, 0.16095695f, -0.09207514f, -0.17107758f, -0.07060746f, 
    0.04882115f, -0.02392819f, -0.03156817f, -0.13565446f, -0.02665451f, 0.11173732f, -0.02538132f, 0.15317285f, 
    -0.04613120f, -0.04675639f, 0.00880460f, -0.00416865f, 0.03821900f, -0.04133080f, -0.00770847f, -0.01615764f, 
    -0.01868248f, 0.05219374f, 0.03248928f, -0.01730091f, -0.01094452f, -0.04958522f, -0.00064797f, 0.00914794f, 
    0.01139712f, 0.03898960f, -0.01430428f, 0.03818187f, -0.03953553f, -0.05315879f, -0.04965124f, 0.05260056f, 
    -0.01126295f, -0.04828999f, -0.01004920f, 0.02638986f, -0.01136459f, -0.06044785f, 0.00174827f, -0.01276254f, 
    -0.03310272f, 0.00054102f, -0.04156590f, -0.05774823f, 0.04316848f, 0.04652447f, -0.02342601f, -0.06108990f, 
    -0.02938156f, -0.01717409f, -0.02557768f, 0.00101657f, 0.02136382f, 0.01108764f, 0.02561003f, 0.02778315f, 
    -0.00633925f, -0.02208954f, 0.00086464f, -0.04538615f, -0.06182361f, 0.04792864f, 0.00941618f, -0.01859377f, 
    -0.02088851f, -0.05029324f, 0.02220985f, -0.01828665f, -0.01944199f, 0.02919037f, 0.04841315f, -0.03415373f, 
    0.00137088f, 0.03145070f, 0.03329882f, -0.04455921f, 0.04012335f, 0.01384851f, 0.02024113f, 0.04061405f, 
    0.00211121f, -0.04126706f, 0.01693664f, -0.00088909f, -0.04893925f, 0.04220596f, -0.04984106f, -0.03499918f, 
    -0.06081464f, 0.04046801f, 0.01482556f, 0.03283472f, -0.00357620f, -0.00339657f, 0.05796002f, -0.04785208f, 
    -0.06769995f, -0.04817007f, 0.03386727f, -0.00146724f, 0.01834908f, -0.02678847f, 0.01021529f, -0.01578125f, 
    -0.05536820f, 0.01596165f, 0.00909081f, -0.03267013f, 0.05279413f, -0.00126517f, -0.03287020f, 0.03827836f, 
    0.04171914f, 0.01484742f, -0.00880463f, 0.03359416f, 0.00349031f, 0.00627891f, -0.05746478f, 0.00324076f, 
    -0.01803856f, 0.00530164f, -0.05096364f, -0.05527497f, -0.04434742f, 0.04905245f, 0.02461831f, -0.03600748f, 
    -0.04014870f, 0.02689824f, -0.05134705f, -0.01487588f, 0.04960053f, 0.04109873f, 0.04325973f, 0.04997656f, 
    -0.00454093f, -0.06512544f, -0.01357405f, 0.02307493f, 0.02218563f, -0.05342968f, 0.02330532f, 0.02145647f, 
    -0.05569567f, 0.03745642f, -0.04330434f, -0.05707792f, -0.05658638f, -0.05452810f, 0.00043873f, -0.04708550f, 
    0.01395537f, -0.00648604f, -0.04974441f, -0.02925844f, 0.00917260f, -0.00821606f, 0.00045854f, -0.02913064f, 
    -0.04775552f, -0.01083621f, -0.01931443f, 0.01515565f, -0.02872933f, 0.02581847f, 0.06270551f, -0.01775718f, 
    -0.06691084f, -0.00097108f, -0.00469494f, 0.05174986f, -0.00606823f, 0.02668329f, 0.01350939f, 0.03911528f, 
    -0.05168533f, 0.04990759f, -0.04029521f, -0.04164345f, -0.04876897f, -0.03389176f, -0.04533223f, -0.00853742f, 
    -0.02768098f, 0.03013249f, -0.02334339f, -0.05246552f, 0.02062960f, -0.04950618f, 0.01824559f, 0.04457009f, 
    -0.05193709f, -0.00338377f, 0.02597783f, 0.01584741f, 0.03261821f, -0.04365778f, -0.03158379f, 0.05457667f, 
    0.04930319f, -0.03345499f, 0.01652278f, -0.02962470f, -0.05290357f, -0.00071090f, -0.04855480f, 0.00254210f, 
    -0.02534386f, -0.05474261f, -0.05740737f, -0.04883050f, 0.02307906f, -0.01315745f, 0.03254429f, -0.00753439f, 
    0.03986228f, -0.04263386f, -0.01407882f, -0.03717636f, -0.00638428f, -0.02013402f, -0.05725010f, 0.03919731f, 
    0.02826642f, 0.04688922f, -0.02724189f, 0.03750684f, -0.01163548f, -0.02249790f, -0.00187513f, -0.05621693f, 
    -0.04568226f, -0.00535517f, 0.03109905f, 0.04550054f, -0.03691211f, 0.03924863f, -0.01258882f, 0.04341860f, 
    0.01675211f, -0.02907856f, -0.03340903f, 0.03011264f, 0.01304276f, -0.01502039f, 0.01031308f, -0.04007476f, 
    -0.06256000f, 0.00493431f, 0.02719592f, 0.02987537f, 0.05071710f, -0.01715213f, -0.05518357f, -0.00299267f, 
    -0.03431119f, 0.01902869f, -0.00859187f, 0.01281071f, -0.03638010f, -0.00323549f, 0.02725459f, -0.02937542f, 
    0.00986908f, 0.01478892f, 0.02408493f, 0.03656692f, 0.04274853f, -0.06266989f, 0.03699577f, 0.03203147f, 
    -0.00454231f, -0.01430462f, -0.01848883f, -0.03655334f, 0.04428185f, 0.00291903f, -0.06647343f, -0.04192451f, 
    -0.05081829f, 0.01285930f, -0.05811336f, 0.02101310f, -0.04456409f, 0.00715927f, -0.00537037f, 0.01095409f, 
    0.03116348f, -0.02248802f, 0.04362447f, -0.02299781f, -0.00160921f, -0.03315848f, 0.00221306f, -0.03800498f, 
    -0.08565818f, -0.06862312f, -0.43976000f, 0.05231262f, -0.08340230f, -0.08792646f, -0.01244517f, 0.22198109f, 
    0.17660093f, -0.01822980f, -0.17837833f, -0.25507629f, -0.09914970f, -0.09912220f, -0.11494119f, 0.01177069f, 
    -0.09527341f, -0.05012516f, 0.16061105f, 0.39035869f, -0.02979958f, 0.02411217f, 0.07440303f, -0.07022940f, 
    0.04808468f, 0.03087813f, 0.02713574f, 0.18592890f, 0.07618334f, -0.53442335f, 0.17753474f, 0.07799195f, 
    -0.00537121f, -0.01865907f, -0.05540974f, 0.13528925f, 0.30933261f, 0.03785565f, 0.32898617f, 0.05232213f, 
    -0.12896805f, -0.10766631f, 0.00664114f, 0.09296007f, -0.08377454f, -0.15375809f, -0.09164460f, 0.46207270f, 
    -0.13088794f, -0.07263166f, 0.10071734f, -0.14934850f, -0.01273343f, 0.12606212f, 0.10208455f, -0.02304574f, 
    0.35141060f, 0.03488100f, -0.29308292f, -0.01655477f, -0.19435246f, 0.08859298f, -0.14149569f, -0.31080243f, 
    -0.53565997f, 0.27986169f, -0.00492095f, 0.07450597f, 0.00308368f, 0.01968927f, -0.02457665f, -0.03989629f, 
    0.25408256f, 0.04296185f, 0.20716560f, 0.13017343f, -0.00231299f, -0.13235858f, 0.09223911f, -0.01627736f, 
    0.14528884f, -0.25065240f, -0.13629395f, -0.34465948f, 0.14572115f, -0.02582944f, -0.02419920f, 0.08341030f, 
    0.03967951f, -0.03026526f, -0.49881649f, -0.05298124f, -0.67567337f, 0.23927511f, 0.09600938f, -0.03553422f, 
    -0.05995563f, 0.18968211f, 0.02150960f, -0.11267278f, 0.27666584f, -0.13677107f, -0.10003749f, -0.21247762f, 
    -0.13019587f, 0.15739426f, 0.01013828f, -0.20457833f, -0.17248152f, -0.10467736f, 0.08766265f, -0.06667227f, 
    0.20748121f, 0.02664661f, 0.01007700f, -0.04453282f, -0.08073309f, -0.40823111f, -0.11525924f, 0.05495323f, 
    0.07640594f, 0.15445788f, 0.08119196f, 0.06363352f, 0.03438954f, -0.12222584f, -0.54906183f, -0.16047698f, 
    -0.18919337f, -0.03330658f, 0.15204339f, -0.16653270f, 0.05971844f, 0.17792375f, -0.15400764f, -0.27333388f, 
    0.12789045f, 0.32297999f, 0.14329211f, -0.08845924f, 0.09211376f, -0.03133643f, 0.03276085f, -0.05184850f, 
    -0.06902187f, 0.24871233f, 0.19079705f, -0.07404145f, -0.05626942f, -0.08007932f, -0.03632357f, -0.00176817f, 
    0.06983776f, -0.24613078f, -0.00935065f, 0.31068417f, -0.04680923f, 0.02661251f, -0.07559151f, 0.05326344f, 
    -0.00733031f, -0.00026040f, 0.36390740f, 0.02854412f, 0.16119362f, -0.18830618f, -0.07009109f, 0.09569312f, 
    -0.00471373f, 0.01191781f, 0.15709229f, -0.20710024f, 0.18619190f, 0.10570886f, 0.04310664f, 0.03477887f, 
    0.10416044f, -0.13286652f, 0.07648434f, 0.04849678f, 0.18259834f, -0.08295868f, -0.49235043f, 0.18505873f, 
    0.06455363f, 0.00039028f, -0.10409492f, -0.14767203f, 0.08947890f, 0.02998522f, 0.09922054f, -0.36748260f, 
    -0.11853757f, 0.03440132f, 0.01232651f, 0.13971590f, 0.02338813f, 0.15448968f, 0.32410994f, 0.15810290f, 
    0.09921024f, 0.08111034f, -0.18207178f, -0.26306671f, -0.07835533f, 0.16901824f, -0.06937914f, 0.30651557f, 
    -0.00263597f, 0.09921928f, -0.04968472f, 0.07165079f, 0.04163186f, 0.04549713f, 0.18328695f, -0.02459483f, 
    0.39169466f, 0.24332458f, 0.25881582f, -0.35146287f, -0.11059501f, -0.23518513f, 0.11400279f, -0.06823331f, 
    -0.04318729f, 0.03223510f, -0.17098206f, 0.04179716f, -0.21830435f, 0.01629033f, 0.07478868f, 0.00232383f, 
    0.03216743f, 0.26753122f, -0.35671413f, -0.23148330f, 0.27038202f, 0.10888319f, 0.04296224f, 0.17755719f, 
    0.05704020f, -0.05715441f, 0.24503922f, 0.15754823f, 0.04559300f, 0.16849467f, -0.10059216f, 0.18184264f, 
    0.05571863f, -0.00611293f, 0.17075162f, 0.15955614f, 0.04656078f, -0.11217226f, -0.42934161f, -0.09576613f, 
    0.09596831f, 0.10090711f, 0.05806553f, -0.03659230f, 0.14468043f, -0.20096859f, -0.28672358f, -0.58415771f, 
    -0.04257825f, -0.14996217f, -0.30461445f, 0.15858606f, 0.00604629f, 0.09497093f, 0.00103564f, 0.15416566f, 
    -0.29772019f, -0.01560055f, -0.11582115f, -0.21799259f, -0.05396165f, -0.07677317f, 0.23943621f, 0.04025192f, 
    0.06847800f, -0.01273850f, 0.10608232f, 0.04766236f, -0.05682293f, 0.01323971f, -0.01461879f, 0.16544758f, 
    0.00798646f, -0.02482610f, 0.03523839f, 0.03574498f, 0.01695120f, -0.02374290f, -0.00702318f, 0.01441659f, 
    -0.02491202f, 0.00781537f, -0.05017748f, 0.04249485f, 0.04752317f, -0.01898495f, -0.06662855f, -0.04176652f, 
    -0.03750540f, -0.04161917f, -0.03844566f, -0.03475277f, 0.02256428f, 0.03877065f, -0.03651896f, 0.02551932f, 
    -0.04804485f, 0.01844518f, -0.00919673f, -0.01945754f, -0.00912426f, -0.01049809f, 0.03465020f, 0.01897517f, 
    0.02868901f, -0.01807317f, -0.02977703f, 0.03156113f, -0.00040104f, 0.01588276f, -0.02043907f, 0.01767962f, 
    0.04649516f, 0.02875185f, 0.03847985f, -0.05638191f, 0.04169691f, -0.04665803f, 0.00901391f, 0.03613583f, 
    -0.04603464f, -0.05452460f, -0.06603669f, -0.06753818f, -0.04613462f, -0.04493346f, 0.03692754f, -0.02587084f, 
    -0.02872883f, 0.02734786f, 0.02352008f, 0.04759235f, -0.06009063f, -0.06291696f, -0.06100177f, -0.02545438f, 
    -0.06858199f, -0.00756470f, 0.04104963f, -0.02789514f, 0.03690738f, 0.03007261f, -0.07144941f, -0.04330226f, 
    -0.03270934f, -0.03738346f, -0.02016399f, 0.00433592f, -0.00834311f, 0.01022302f, 0.04115065f, -0.03891415f, 
    -0.02627186f, 0.01065923f, -0.06671205f, -0.02599988f, -0.01713195f, 0.00429313f, -0.00848874f, 0.00840212f, 
    -0.02657184f, -0.05358880f, 0.03820162f, 0.01722068f, 0.01115641f, -0.06317595f, -0.03055046f, 0.03241519f, 
    -0.00503617f, -0.02433435f, 0.00560958f, 0.02462255f, -0.05052926f, 0.00939610f, -0.00074103f, -0.02388780f, 
    -0.00769453f, -0.02738487f, -0.05797908f, 0.03930375f, 0.01117796f, 0.01473649f, -0.02085661f, -0.03400596f, 
    -0.01812909f, 0.01565176f, -0.00849324f, 0.02768160f, -0.03594206f, 0.00262545f, 0.05184440f, -0.05812383f, 
    0.03778575f, -0.00685326f, -0.06520037f, -0.04034822f, -0.04855074f, 0.03399285f, 0.04614230f, 0.00304074f, 
    -0.01469927f, -0.06379912f, -0.05216318f, 0.04214548f, -0.01923357f, 0.03637640f, -0.05213216f, -0.01276605f, 
    0.01072796f, 0.02341069f, -0.03793898f, -0.06242290f, -0.03966571f, -0.00240787f, 0.01301338f, 0.04379523f, 
    -0.03697853f, 0.00269266f, -0.02048042f, 0.02621381f, -0.00720414f, 0.00688220f, -0.05059348f, -0.01238464f, 
    0.02863919f, -0.00306112f, -0.03985744f, -0.01083869f, 0.03582350f, -0.01152943f, -0.04612327f, -0.04405503f, 
    0.02077937f, 0.00352703f, 0.03643026f, 0.00414869f, 0.04713818f, -0.00367235f, 0.03580590f, -0.01017557f, 
    0.03699033f, -0.04987865f, -0.05511177f, -0.05028886f, 0.03636935f, 0.03893270f, -0.03182167f, 0.00360345f, 
    -0.06045936f, -0.00988831f, 0.03467339f, -0.00832965f, 0.02522274f, 0.01227700f, -0.00012393f, -0.05266203f, 
    0.04518330f, -0.05911656f, -0.02089790f, 0.03735602f, 0.02197553f, -0.02527868f, 0.03020407f, 0.04545875f, 
    -0.03134103f, 0.01022954f, -0.00709228f, 0.04783820f, 0.02002284f, -0.00353437f, 0.04912359f, -0.03162337f, 
    0.02144405f, 0.04280600f, -0.05471537f, 0.02170035f, 0.00345169f, 0.01509689f, -0.03760128f, 0.00549013f, 
    -0.00056189f, 0.01722351f, -0.01317023f, 0.00088697f, 0.01749246f, -0.00284464f, 0.02212913f, -0.02888767f, 
    0.00038388f, -0.02747771f, 0.01486875f, 0.04780547f, 0.04066579f, 0.01694990f, -0.04712597f, -0.06339733f, 
    0.03761853f, -0.06382925f, -0.01001670f, 0.03457548f, -0.00609482f, -0.06663182f, 0.00359908f, -0.01340844f, 
    0.03665552f, -0.04072186f, -0.02787038f, 0.03809716f, 0.04702269f, -0.06223706f, -0.02959941f, -0.02095615f, 
    -0.06080950f, 0.04277811f, -0.06146937f, 0.02437634f, -0.02784525f, 0.03240675f, -0.05721419f, -0.02824307f, 
    0.01830332f, -0.06111668f, -0.01169524f, -0.04726851f, -0.01792120f, -0.00404955f, 0.00426097f, 0.00785070f, 
    -0.00471467f, 0.02741843f, -0.01503207f, -0.06473542f, 0.04139295f, -0.00285232f, 0.02221553f, 0.04975742f, 
    -0.05603126f, 0.03647117f, -0.04950070f, 0.01109554f, -0.05440331f, 0.02578188f, 0.00344356f, -0.00593310f, 
    -0.04318497f, -0.02656134f, -0.04706693f, 0.00961523f, 0.04422201f, -0.03187869f, 0.03132613f, -0.05879733f, 
    0.00205781f, -0.04134086f, -0.03792107f, -0.02014739f, 0.03053505f, 0.01841935f, 0.02909172f, -0.01360340f, 
    -0.02410240f, 0.03767983f, 0.06010671f, -0.05237129f, -0.06067501f, -0.06244565f, -0.04629031f, -0.06933667f, 
    -0.00116973f, -0.04333932f, 0.03473002f, 0.01593603f, -0.03373000f, -0.03240367f, 0.00739965f, 0.04742038f, 
    -0.06196946f, 0.01956927f, -0.05724952f, 0.01478519f, -0.03037772f, -0.00979519f, 0.00668829f, 0.03203413f, 
    -0.02548918f, 0.00187727f, -0.05262147f, 0.01015011f, -0.00854174f, -0.01867891f, -0.03411986f, -0.00445479f, 
    -0.00451839f, 0.00906004f, -0.05392691f, 0.01297599f, -0.01792949f, -0.03433707f, -0.00686022f, 0.00516786f, 
    -0.03522259f, -0.06302532f, -0.06746887f, 0.04193604f, -0.06130454f, 0.03594522f, -0.00383370f, -0.00928140f, 
    0.03583623f, 0.03213003f, -0.06493080f, -0.03938139f, 0.04484338f, -0.03792851f, 0.04055465f, -0.04786633f, 
    0.00838844f, -0.05396841f, -0.03117850f, 0.00486470f, -0.05856674f, 0.01513123f, 0.00019273f, 0.04100220f, 
    0.02777389f, -0.03280730f, -0.01076649f, 0.01470279f, 0.04558569f, 0.04726017f, -0.01049328f, -0.01208828f, 
    0.00317390f, -0.06508806f, 0.03946649f, 0.02693390f, -0.06388848f, 0.01561439f, -0.00438932f, 0.01167630f, 
    0.01682709f, 0.01832705f, -0.01692679f, -0.00308601f, 0.00979439f, -0.01029968f, -0.00385477f, -0.05480874f, 
    -0.06362133f, -0.04478799f, 0.05000074f, 0.03938707f, -0.01425791f, -0.06172188f, 0.01281755f, -0.01738412f, 
    0.02518396f, 0.03181651f, -0.03935852f, -0.00628287f, -0.00002210f, -0.06442863f, -0.04142657f, 0.02061797f, 
    0.04708149f, 0.03222606f, 0.02961217f, -0.04282095f, 0.04321431f, 0.03766190f, -0.04962593f, -0.01712717f, 
    -0.03573022f, -0.01794785f, 0.03007285f, -0.03816757f, -0.03372773f, -0.04453130f, 0.01478249f, -0.02935941f, 
    -0.01434451f, -0.04537396f, -0.04181287f, -0.01127207f, -0.05987942f, -0.01420844f, 0.00921332f, 0.02527713f, 
    0.03450607f, 0.05225438f, 0.02446953f, -0.02987118f, 0.03883765f, 0.04858147f, -0.02372710f, 0.02564968f, 
    -0.04097847f, -0.00966405f, -0.02295029f, 0.00214237f, 0.00492249f, 0.02318462f, 0.01814763f, -0.00745165f, 
    0.01495437f, -0.03499485f, -0.01800136f, -0.01281098f, -0.01190585f, -0.01096695f, -0.02561724f, -0.02449593f, 
    -0.06198607f, -0.05716851f, 0.01435322f, 0.02670945f, -0.03771466f, -0.02131061f, -0.04532149f, 0.02086767f, 
    0.01627870f, -0.05665851f, -0.00421611f, -0.03284658f, -0.04824155f, -0.00308460f, -0.02931804f, 0.00680831f, 
    -0.00703781f, 0.04139951f, -0.00476767f, -0.03672023f, 0.04485089f, -0.03618348f, -0.07037324f, -0.00100816f, 
    -0.06271543f, 0.01119218f, -0.05255343f, -0.04786785f, 0.01908292f, 0.02323368f, 0.03428340f, 0.00571660f, 
    -0.02733194f, 0.01613114f, -0.01774062f, 0.03074547f, -0.03985472f, 0.00575175f, -0.00577743f, 0.02563220f, 
    0.03179674f, -0.03171719f, 0.02167089f, 0.00495948f, 0.02208392f, -0.03391488f, -0.00432261f, 0.00850688f, 
    -0.00142227f, 0.00415521f, 0.00716133f, 0.04439651f, -0.02611578f, -0.05430106f, -0.05887717f, -0.03099955f, 
    0.00138599f, -0.04822532f, 0.04837417f, -0.02980097f, -0.04969883f, -0.02662445f, 0.02603950f, -0.02972457f, 
    0.04532300f, 0.02837799f, 0.01996010f, -0.02538328f, 0.00831481f, 0.01741799f, 0.00597239f, 0.02521947f, 
    0.02246106f, -0.02316916f, -0.05686112f, 0.04352545f, 0.04464970f, -0.00772195f, 0.04767830f, -0.01157291f, 
    -0.06456803f, 0.02275489f, -0.03036669f, -0.05389969f, -0.03734472f, 0.01389873f, 0.03862080f, -0.03906179f, 
    -0.03479606f, 0.03999115f, 0.00304411f, 0.03060746f, -0.01914755f, -0.06186369f, 0.03720203f, -0.02261439f, 
    0.01662143f, 0.05248021f, 0.00597415f, -0.00096780f, 0.01786979f, -0.03000852f, 0.01080010f, 0.03481865f, 
    -0.01541010f, 0.04687077f, 0.03000576f, 0.02567555f, -0.00292468f, -0.04248590f, -0.02085207f, 0.03760504f, 
    -0.02462899f, 0.02703234f, 0.03730288f, -0.01640731f, -0.01876110f, 0.02997371f, 0.04250357f, 0.01368710f, 
    0.04061489f, -0.02065700f, -0.00622151f, -0.00525367f, 0.02289812f, -0.04351388f, 0.03679152f, -0.03638381f, 
    -0.02582220f, 0.02920897f, 0.03698164f, -0.04913187f, -0.04111920f, -0.02291164f, -0.00546322f, -0.00713940f, 
    -0.06468152f, 0.03013404f, -0.05498108f, 0.03754940f, -0.00650100f, 0.02989818f, -0.02267601f, -0.05272584f, 
    0.02813984f, -0.04710656f, -0.00724041f, 0.01098442f, -0.04521176f, 0.01270335f, 0.03212456f, 0.01652979f, 
    0.03804029f, -0.02212427f, 0.04789095f, 0.00812133f, 0.02305418f, -0.04805456f, 0.04976488f, -0.02659935f, 
    -0.00218029f, 0.04623349f, -0.04107669f, -0.03163669f, 0.02859342f, 0.01970100f, -0.04494976f, 0.04386563f, 
    -0.02952082f, -0.01476898f, 0.02459732f, 0.01466047f, 0.01522034f, -0.02332803f, -0.02717568f, 0.03012959f, 
    -0.03012403f, -0.05131778f, 0.01901546f, 0.00920497f, -0.00640648f, 0.03084969f, -0.02634626f, 0.02479742f, 
    0.02574924f, -0.01100751f, 0.03330173f, 0.00787954f, 0.03805970f, -0.05869465f, 0.00823677f, -0.00334892f, 
    0.02397640f, 0.02412757f, 0.03397055f, -0.05506768f, 0.03320503f, -0.01025779f, 0.02545516f, 0.04632843f, 
    -0.05551140f, -0.02296180f, -0.00141771f, 0.00883117f, 0.03724641f, -0.03544950f, -0.01641896f, -0.04692402f, 
    0.04874734f, 0.00273591f, 0.02275751f, -0.02776576f, -0.05405749f, -0.00306386f, -0.03893713f, -0.00441082f, 
    -0.04602161f, -0.00279050f, -0.03018836f, -0.05500143f, -0.03487198f, -0.03285796f, -0.01482718f, -0.01001987f, 
    -0.01629690f, -0.04506858f, -0.03892915f, 0.04548668f, 0.04064697f, -0.04796929f, 0.00987845f, -0.06323129f, 
    -0.05746150f, -0.05539412f, -0.01905597f, -0.02979449f, 0.00121706f, -0.03133918f, -0.01137244f, 0.02562930f, 
    0.04478339f, -0.04397013f, -0.06429098f, -0.05543682f, 0.01822530f, 0.03448990f, 0.05278107f, 0.00222659f, 
    0.00908097f, 0.00582873f, -0.01778599f, -0.03159486f, 0.02390414f, 0.02231594f, -0.04065977f, -0.04798539f, 
    -0.01207485f, -0.05210140f, -0.05133653f, -0.00022970f, 0.00069079f, 0.02330530f, 0.04026876f, 0.05189353f, 
    -0.02687925f, 0.00814402f, -0.06850457f, -0.01793914f, 0.01483448f, 0.02114632f, -0.04122589f, 0.02742006f, 
    -0.05266419f, 0.04010851f, 0.01947483f, -0.05585733f, 0.00967032f, 0.00221457f, -0.02320280f, 0.01215431f, 
    -0.05882455f, -0.01257789f, -0.05118265f, -0.04268850f, 0.03260947f, -0.04410960f, -0.02077392f, -0.07067277f, 
    0.01055302f, -0.00736807f, 0.00056727f, -0.03437873f, -0.04721768f, 0.01618182f, -0.02214319f, -0.03943354f, 
    -0.03897396f, -0.06030069f, 0.01697362f, 0.00239565f, -0.04618319f, 0.01450699f, -0.04849114f, 0.05080929f, 
    -0.02733919f, -0.01047362f, 0.00920072f, -0.04397065f, 0.00215428f, -0.05358173f, -0.06525394f, 0.00836360f, 
    0.02341496f, -0.01735394f, 0.05082132f, 0.02787846f, 0.04504131f, 0.04187056f, 0.03444373f, -0.02679283f, 
    0.02362717f, 0.04423930f, 0.02488660f, -0.03362834f, -0.00701328f, 0.02419232f, -0.02362572f, -0.05090431f, 
    0.01954666f, -0.00963483f, -0.04648602f, -0.04558541f, -0.06073778f, 0.01009443f, -0.01567912f, 0.02576776f, 
    0.01386734f, -0.04454604f, -0.05331680f, 0.00007008f, -0.05412817f, -0.05994984f, 0.04266054f, -0.00939159f, 
    0.01287766f, -0.04407657f, 0.01948535f, -0.02970156f, -0.01773987f, -0.04708310f, -0.02536160f, -0.02554192f, 
    -0.03282721f, -0.02290432f, 0.00365611f, -0.03259207f, 0.03346549f, 0.01490692f, 0.03030761f, -0.00431320f, 
    0.01739899f, -0.00857887f, -0.02910104f, 0.00716781f, -0.06470764f, -0.04465150f, 0.00389584f, -0.00184115f, 
    -0.04199917f, -0.01155448f, -0.00629751f, 0.02844759f, -0.03057365f, 0.01350161f, -0.00711217f, -0.00867877f, 
    -0.02938185f, -0.04750497f, -0.01513409f, 0.02500154f, 0.04742363f, -0.01797761f, -0.01958377f, -0.03632862f, 
    -0.00381249f, 0.01731981f, -0.05149448f, 0.04749253f, -0.04458676f, -0.03006112f, -0.04089628f, -0.00869136f, 
    0.01310787f, -0.01069770f, 0.05158585f, 0.02028295f, -0.05027136f, -0.00022272f, 0.03589195f, -0.04002051f, 
    -0.04722010f, -0.01792718f, 0.04808291f, 0.03705886f, 0.03401864f, 0.00198642f, 0.04177620f, -0.01931368f, 
    0.01929704f, -0.05477656f, 0.02167900f, -0.03688806f, -0.00498580f, -0.00146364f, 0.02075728f, -0.06513663f, 
    0.02118008f, 0.03537418f, 0.02279671f, 0.03192838f, -0.05567519f, -0.03302412f, 0.00118348f, -0.00030297f, 
    -0.02630620f, 0.00888065f, -0.04990306f, -0.00345659f, -0.06152886f, 0.02757552f, -0.01446046f, -0.03959573f, 
    0.03012387f, 0.01231803f, 0.00063833f, 0.04132786f, -0.02296073f, 0.00989700f, -0.02996683f, -0.00945057f, 
    0.03705738f, -0.00951264f, 0.00860829f, 0.04590183f, -0.05900291f, -0.05520590f, 0.04389043f, -0.03768603f, 
    0.03925331f, -0.00959249f, -0.03986938f, 0.01442449f, 0.04850410f, 0.04837033f, 0.00186636f, -0.04489881f, 
    -0.03230648f, -0.05555610f, 0.04027895f, -0.00087773f, -0.00557029f, 0.00310824f, -0.05693401f, 0.03693353f, 
    -0.05368542f, -0.02364558f, 0.04578928f, 0.00270770f, -0.00932359f, -0.02420954f, -0.02848723f, 0.01090818f, 
    -0.04304238f, -0.01086336f, 0.02335639f, 0.02440099f, -0.02650457f, -0.02279763f, 0.02610603f, -0.00323004f, 
    0.03760049f, 0.01684368f, -0.00460016f, -0.01480869f, -0.00802954f, -0.03194749f, 0.04283641f, 0.03526250f, 
    0.01378732f, -0.01164725f, -0.05923073f, -0.00215261f, -0.00000951f, -0.02696794f, -0.02273281f, 0.01718167f, 
    0.04561216f, 0.01062556f, 0.03336025f, -0.01956253f, -0.04600430f, 0.00643752f, -0.03619739f, 0.03975809f, 
    0.03021261f, -0.06844526f, 0.03828752f, -0.02410742f, -0.05299116f, 0.00394964f, 0.04865639f, 0.00764934f, 
    -0.01065965f, 0.01291947f, -0.01914719f, 0.04466610f, 0.02346485f, -0.04773256f, -0.06678742f, -0.03813267f, 
    0.03128526f, 0.01249769f, 0.02775951f, 0.04871854f, -0.00550215f, -0.02414888f, -0.01456900f, -0.00358012f, 
    0.02900654f, 0.01771257f, -0.03273007f, 0.01152491f, 0.02247495f, 0.00559800f, 0.02572497f, -0.00348700f, 
    0.00514447f, 0.00178532f, -0.06627662f, 0.02856961f, -0.03553709f, -0.03428742f, 0.02016881f, -0.05518406f, 
    0.02348880f, -0.03922531f, -0.04652189f, -0.05001639f, 0.04501121f, -0.00817245f, -0.03910144f, 0.04209578f, 
    -0.02601019f, -0.06367017f, -0.05105517f, 0.01328955f, -0.03033094f, -0.04182633f, -0.01071977f, -0.03959357f, 
    -0.01713884f, 0.03925496f, -0.02191484f, -0.06097642f, -0.00794881f, -0.06793150f, 0.02152765f, -0.05979752f, 
    -0.02109631f, -0.02634862f, -0.00750685f, -0.00257557f, -0.06029216f, 0.03027249f, 0.05011125f, 0.01615695f, 
    -0.00144171f, -0.06187502f, -0.02372777f, 0.04435607f, 0.03710145f, 0.02357650f, 0.00969649f, -0.03515167f, 
    -0.02310600f, -0.05646172f, -0.00674238f, -0.02804505f, -0.02794645f, -0.00177823f, 0.03624005f, -0.00310198f, 
    0.04177960f, 0.01846037f, -0.01137473f, 0.02845245f, -0.01023416f, 0.03598263f, -0.05199080f, -0.05834084f, 
    -0.04983890f, 0.02945264f, -0.02762972f, 0.00114295f, -0.00716805f, -0.01331866f, 0.02553217f, 0.00960124f, 
    -0.00866727f, 0.00417140f, -0.01099575f, -0.05901047f, -0.01726461f, -0.01862783f, -0.05229413f, 0.03504744f, 
    0.05202983f, -0.02692931f, 0.03945300f, -0.06467725f, 0.03049978f, -0.05589569f, 0.04602650f, 0.01614000f, 
    0.05130612f, -0.05305764f, -0.05629349f, 0.02146675f, -0.01977806f, 0.00628202f, -0.01773990f, -0.02470689f, 
    0.04555625f, 0.01167031f, 0.02507336f, -0.05832596f, 0.05082373f, -0.02500344f, 0.02789606f, 0.04157832f, 
    -0.03717896f, 0.00001888f, 0.03493944f, 0.02630559f, -0.05493214f, -0.02428088f, -0.00538930f, 0.04596179f, 
    0.03489958f, 0.02799582f, 0.03392207f, -0.00461655f, -0.06225003f, -0.06201902f, -0.05930167f, 0.03896968f, 
    -0.03144505f, -0.05825160f, -0.05750427f, -0.05701438f, 0.02953404f, 0.01682130f, 0.00302927f, 0.00835667f, 
    -0.04857419f, 0.02666944f, -0.00651536f, 0.03137194f, 0.01535305f, -0.01234308f, -0.00077560f, -0.05670724f, 
    -0.05776684f, 0.03439878f, -0.01129786f, -0.01261252f, -0.03472574f, -0.02938509f, 0.00593144f, 0.03938944f, 
    0.01688066f, -0.05538855f, -0.03131469f, -0.00736998f, -0.05415630f, -0.00219089f, -0.05681620f, 0.02080514f, 
    0.03493702f, 0.03739750f, -0.00571026f, -0.06090983f, 0.02701449f, -0.03481326f, -0.03052443f, 0.04464895f, 
    -0.03168649f, 0.04672582f, -0.01743911f, 0.03661976f, -0.06941318f, -0.06115861f, -0.06036407f, 0.01387255f, 
    -0.01654259f, 0.02457289f, -0.06310882f, 0.02948232f, 0.04457201f, -0.00797147f, -0.02880069f, -0.05493839f, 
    0.11686435f, -0.02326274f, -0.17195669f, -0.09135874f, -0.07990156f, 0.03473207f, 0.04266759f, 0.12871298f, 
    -0.16655368f, 0.14880918f, -0.18267658f, -0.14108407f, 0.12219013f, -0.09814955f, -0.05027836f, 0.04535268f, 
    -0.17641136f, -0.15179195f, -0.11178742f, -0.05772157f, -0.28813893f, 0.01214247f, -0.08821736f, -0.02843849f, 
    -0.07955938f, 0.08973831f, 0.05781392f, 0.01907305f, 0.04833682f, 0.01609161f, -0.08164754f, -0.12260067f, 
    -0.04703225f, -0.13546792f, -0.15870792f, -0.16197707f, 0.01001781f, 0.02708890f, 0.24284449f, -0.06553466f, 
    0.12633274f, 0.05562448f, 0.00813197f, 0.07821397f, -0.03558987f, 0.17131171f, -0.10550416f, 0.14790487f, 
    -0.13819037f, 0.10337837f, 0.06340415f, 0.09890295f, 0.16173612f, -0.11453274f, -0.02604190f, 0.09824587f, 
    -0.05861858f, -0.21661431f, 0.08484516f, 0.05298780f, 0.00169248f, -0.03326958f, 0.02679145f, 0.10475340f, 
    0.39982626f, 0.34756753f, 0.10934860f, 0.00961554f, 0.17718053f, -0.27775526f, -0.03821694f, -0.02785563f, 
    -0.12122101f, -0.11630419f, -0.06249661f, -0.08230133f, -0.01014958f, -0.08514630f, 0.02296243f, 0.07467037f, 
    0.03420947f, -0.11473902f, -0.07453253f, -0.40936881f, -0.18119358f, -0.04082939f, -0.14797586f, -0.10654367f, 
    -0.08594900f, 0.03190164f, -0.00787758f, 0.07269768f, 0.08943155f, 0.02281150f, -0.11822911f, -0.11618710f, 
    -0.03960319f, -0.08010836f, -0.11339606f, -0.43974084f, 0.11038830f, -0.02946076f, 0.06958603f, -0.06821633f, 
    -0.22285363f, 0.02158112f, 0.07984961f, 0.07964370f, 0.18879211f, 0.02538544f, 0.28108042f, 0.09165934f, 
    0.01339678f, 0.08308450f, 0.06948842f, 0.02498089f, 0.13270316f, 0.29448402f, -0.52309895f, -0.05783290f, 
    -0.03156266f, -0.05873045f, 0.04559017f, -0.17702827f, 0.02802056f, 0.00296898f, 0.00136419f, -0.35866955f, 
    -0.01545196f, -0.13228844f, -0.01883341f, 0.03187449f, 0.12730177f, -0.07865649f, 0.11596146f, -0.21761163f, 
    -0.21532448f, 0.01245286f, -0.23593028f, 0.01965923f, -0.00308617f, -0.03440440f, 0.02854212f, 0.17713229f, 
    0.15562591f, -0.09198804f, 0.20200968f, -0.04536005f, 0.02370842f, -0.03494830f, -0.09367455f, 0.17056911f, 
    -0.07249544f, 0.33809435f, 0.29600704f, 0.28110936f, 0.28681391f, 0.24991409f, 0.09716009f, -0.02864193f, 
    0.10003258f, 0.01601897f, 0.07446698f, -0.11477125f, 0.15871714f, -0.00512224f, -0.13384774f, 0.01348469f, 
    0.05646763f, -0.07912588f, -0.01279140f, 0.27404287f, 0.22204418f, 0.01343687f, -0.03721263f, -0.26056355f, 
    -0.18115602f, 0.04999016f, -0.14870423f, -0.23874791f, -0.11830248f, -0.20338598f, -0.32333350f, -0.07511048f, 
    -0.03507593f, 0.09766600f, -0.20166901f, -0.12758805f, -0.10711522f, 0.44889063f, 0.03200272f, -0.10616263f, 
    -0.18561123f, -0.19330703f, 0.05241359f, -0.01384242f, 0.08998320f, 0.01323432f, 0.47429180f, 0.22296219f, 
    -0.04130838f, 0.19950423f, 0.33123425f, 0.14571579f, 0.11938170f, -0.00228261f, 0.12405250f, 0.03036561f, 
    -0.01235980f, -0.06423637f, 0.06726021f, 0.01509988f, -0.15295349f, 0.00720534f, 0.18245222f, 0.10134274f, 
    0.20898452f, 0.07825113f, -0.09352450f, -0.28071716f, -0.09219602f, 0.15021083f, -0.13955617f, 0.06446791f, 
    -0.13250138f, -0.25204572f, 0.34316337f, 0.09714080f, 0.04274565f, 0.07404555f, -0.01449563f, -0.02776854f, 
    0.07919167f, -0.06764206f, -0.06925108f, 0.13926166f, 0.18582076f, 0.06857002f, 0.13673353f, 0.17729747f, 
    -0.04515569f, 0.05983046f, 0.04407632f, 0.13985369f, -0.12058723f, -0.06859566f, 0.03088860f, 0.08645280f, 
    -0.10820995f, 0.05534579f, -0.01594129f, 0.15397204f, 0.22875971f, 0.14543715f, 0.06179183f, 0.05605675f, 
    0.09444603f, -0.16098501f, -0.02415621f, 0.05152791f, -0.03379495f, 0.55465090f, 0.33087939f, 0.08170726f, 
    0.02721749f, -0.11570314f, 0.04202747f, 0.03523698f, -0.06660527f, -0.17355168f, -0.00791977f, 0.12554124f, 
    0.13839057f, 0.02045742f, -0.02373655f, -0.26342249f, 0.05423271f, -0.09580367f, 0.25560457f, 0.04722563f, 
    -0.22237444f, -0.33060208f, -0.14670426f, -0.10697285f, -0.08833660f, -0.05149303f, -0.12374835f, -0.00941883f, 
    -0.33897221f, 0.07008468f, -0.46587154f, -0.06042151f, -0.08554994f, -0.04237003f, -0.17378309f, -0.17449725f, 
    0.12735564f, -0.10423465f, 0.21692300f, -0.21967039f, -0.04252287f, -0.02754734f, -0.19729117f, 0.00170855f, 
    0.08181146f, -0.04831535f, 0.21368225f, -0.14528282f, -0.31269935f, 0.05649417f, 0.26122543f, 0.07743353f, 
    -0.05336180f, 0.17744550f, -0.12034310f, 0.34022161f, 0.09116277f, -0.26066339f, 0.16839363f, 0.13969527f, 
    0.08237679f, 0.25047913f, -0.13348305f, -0.02436585f, 0.39662218f, 0.10372500f, 0.19413646f, 0.20814481f, 
    0.13063973f, 0.03490263f, 0.33796975f, 0.11343019f, 0.06809623f, -0.24880089f, 0.10851825f, 0.12228601f, 
    0.10491791f, 0.02416619f, 0.05979174f, 0.13582820f, -0.15712200f, -0.02232112f, 0.04777137f, -0.20662673f, 
    -0.16809581f, 0.06985722f, -0.10644228f, -0.27030009f, -0.08965781f, -0.17915250f, -0.19206601f, -0.31354925f, 
    -0.11149883f, 0.09659787f, 0.21418718f, -0.09844768f, 0.02134194f, 0.05019740f, 0.16681708f, -0.27236435f, 
    -0.11959106f, -0.11882601f, -0.12333759f, 0.24904615f, -0.01485426f, -0.16515703f, 0.06868288f, 0.12065981f, 
    0.09404963f, 0.12811077f, 0.08711927f, -0.40069023f, 0.06308204f, 0.03449325f, 0.00174778f, 0.23049134f, 
    0.27303636f, 0.00937649f, -0.38584247f, -0.09702509f, 0.37216592f, -0.06037306f, 0.17540412f, -0.04544010f, 
    -0.02885672f, -0.18465389f, 0.10779680f, 0.15371652f, 0.17266439f, -0.07704990f, 0.00955003f, -0.15242478f, 
    -0.22337562f, -0.09634520f, 0.07811096f, 0.02081278f, -0.06028356f, -0.06286732f, 0.21495917f, 0.00420680f, 
    -0.05750195f, 0.01256321f, -0.03442293f, -0.02258050f, 0.15749329f, -0.10618190f, 0.16729087f, -0.04446552f, 
    0.20823613f, -0.06976932f, -0.12006794f, 0.03900920f, 0.04953421f, -0.05215420f, -0.65407103f, -0.22546904f, 
    0.33565438f, -0.04596827f, -0.09754963f, 0.17828852f, -0.00047801f, -0.01606170f, -0.04961957f, 0.20258166f, 
    0.28728241f, 0.05404772f, 0.26578510f, -0.06874549f, 0.04714390f, 0.13851501f, 0.02492458f, 0.15533856f, 
    -0.07890518f, -0.26533124f, 0.06506214f, -0.01953901f, 0.04316791f, 0.06890189f, 0.03048100f, -0.26595363f, 
    0.01133869f, -0.29589844f, -0.38258028f, 0.22026539f, -0.04733001f, -0.00618799f, -0.08566305f, -0.25590959f, 
    0.14273770f, 0.12953435f, -0.20554967f, -0.04565636f, 0.04353281f, 0.11297633f, 0.17116177f, 0.18838108f, 
    0.20774624f, -0.08583011f, 0.08865812f, 0.25563851f, -0.01735008f, 0.08944429f, -0.03954495f, -0.06557813f, 
    0.01895902f, -0.01424101f, 0.11196006f, 0.13940892f, 0.34372583f, 0.26245290f, -0.14373805f, 0.04905847f, 
    0.05855421f, -0.03290069f, -0.02599158f, -0.17749551f, 0.13304552f, 0.03074455f, -0.05083535f, -0.29725039f, 
    -0.19704551f, 0.13849926f, 0.16931719f, 0.01325933f, 0.02932301f, 0.11064587f, -0.35189718f, -0.39464554f, 
    -0.22388877f, 0.15256336f, 0.26704788f, 0.17096195f, -0.33065459f, -0.00957693f, 0.11716978f, 0.11236466f, 
    0.06237264f, 0.17417257f, 0.05138062f, 0.10549435f, -0.03345837f, 0.05289571f, -0.08935650f, 0.13057424f, 
    0.56196439f, -0.03096391f, 0.34281904f, 0.04073536f, -0.03522330f, -0.10141480f, -0.07968140f, 0.13781498f, 
    -0.17794541f, -0.08489963f, -0.20576438f, -0.08411079f, 0.13533126f, -0.16102827f, 0.05521267f, 0.06707219f, 
    0.05457767f, -0.09838892f, -0.18591131f, 0.19227093f, 0.43243209f, -0.19651476f, 0.13072635f, 0.11919458f, 
    0.14132440f, 0.02962914f, 0.05754894f, 0.18926346f, 0.07681977f, -0.21609835f, 0.04403038f, 0.13137643f, 
    0.16155370f, 0.08501884f, 0.06053362f, 0.09109869f, -0.26080984f, -0.10838003f, 0.33347145f, 0.07148036f, 
    -0.05364073f, 0.06970102f, -0.18171184f, -0.12300435f, -0.06699912f, 0.06050948f, 0.16045541f, -0.28845906f, 
    -0.04453588f, -0.14803609f, 0.00200080f, -0.11159158f, -0.18166789f, -0.04001940f, 0.08561112f, -0.02020492f, 
    0.03409256f, 0.17578882f, -0.06647320f, 0.12488828f, -0.02911812f, 0.11752215f, -0.04960432f, -0.16913585f, 
    0.24340211f, -0.31420973f, 0.04132728f, -0.10601963f, 0.19754264f, 0.10745434f, 0.05572420f, -0.11526818f, 
    0.26183441f, 0.09975539f, -0.24792574f, 0.16387807f, -0.01967973f, 0.11461964f, 0.13332057f, 0.07586429f, 
    0.03826275f, -0.16301602f, -0.08467733f, 0.13460492f, 0.13749820f, -0.12317828f, -0.24263187f, -0.11158939f, 
    -0.01300463f, 0.04105099f, -0.21099514f, -0.00247806f, 0.35747761f, -0.04543957f, 0.11392548f, 0.05355127f, 
    -0.04654593f, 0.20353311f, 0.14945446f, -0.12018202f, 0.17068838f, -0.08805647f, -0.03102908f, -0.02809579f, 
    0.17305399f, 0.10109066f, -0.05007869f, -0.07103030f, -0.16270842f, 0.23698288f, 0.24488494f, 0.15804508f, 
    -0.20046262f, 0.09213582f, 0.01455388f, 0.21791498f, -0.04313836f, 0.08816522f, -0.09996714f, 0.16397581f, 
    0.10329349f, 0.10544775f, 0.16752450f, 0.12501009f, 0.03667408f, -0.09392915f, 0.17371160f, -0.05422018f, 
    -0.03695669f, -0.03909675f, 0.01657433f, -0.15069288f, -0.04028878f, 0.01638605f, -0.16316968f, -0.15064509f, 
    -0.13494724f, -0.23900126f, 0.15496686f, 0.02110583f, -0.01236272f, -0.18415241f, -0.11129682f, -0.11072332f, 
    0.52158993f, 0.14225605f, -0.24540032f, 0.10859839f, -0.07783214f, 0.08615882f, 0.17993791f, 0.14006726f, 
    0.00819740f, -0.03772273f, -0.07022383f, 0.22345382f, -0.22372161f, 0.15667854f, -0.38050669f, 0.13334623f, 
    -0.00972754f, -0.04805799f, 0.11309617f, 0.26859570f, 0.09012301f, 0.01342486f, 0.29516429f, -0.05090317f, 
    -0.01933072f, -0.01929310f, 0.04529608f, -0.29313904f, -0.32695696f, -0.24784476f, -0.20377153f, -0.29251069f, 
    -0.21516083f, 0.02858269f, 0.02729560f, 0.05962022f, -0.10349384f, -0.28565672f, 0.10468571f, 0.01195001f, 
    0.15750574f, 0.03464001f, 0.12921315f, -0.19465151f, 0.01821639f, -0.34675589f, 0.18602282f, 0.47171032f, 
    -0.15399934f, 0.14881213f, -0.31917474f, 0.04536204f, 0.02304249f, -0.02436107f, 0.36427292f, -0.01855095f, 
    -0.09520549f, -0.04932349f, 0.25173295f, 0.06243772f, -0.22104949f, 0.01322485f, 0.11751457f, -0.16205694f, 
    0.12367927f, 0.58797365f, -0.00680114f, -0.08038187f, -0.32031968f, 0.03087704f, 0.09556644f, -0.05680575f, 
    -0.19237970f, -0.23852448f, 0.01216225f, 0.01040320f, -0.04272017f, 0.17315371f, -0.01256090f, -0.15133137f, 
    0.08401044f, -0.32947144f, -0.45181221f, 0.25137019f, 0.03262823f, 0.05586997f, 0.01539882f, -0.01372261f, 
    -0.11305524f, 0.04766182f, 0.37619323f, -0.09413158f, -0.38883498f, 0.17297842f, 0.03910052f, 0.04787602f, 
    0.07430873f, -0.05344125f, -0.12279057f, -0.02118214f, 0.02944235f, 0.05712705f, 0.03851410f, 0.08713013f, 
    0.11490502f, -0.06638357f, -0.11315070f, -0.09481742f, 0.01380237f, 0.07281735f, 0.34134904f, 0.19591244f, 
    0.10301332f, 0.01770842f, -0.21455306f, -0.06737141f, -0.01691174f, 0.09252321f, 0.13805790f, 0.31877232f, 
    -0.16678406f, 0.07906839f, -0.08548278f, -0.13903797f, 0.09153428f, 0.04683441f, -0.01971511f, -0.26599434f, 
    -0.44088137f, 0.05981221f, 0.00279339f, 0.15931678f, -0.06827020f, -0.16643362f, 0.08838806f, -0.07023045f, 
    -0.19321693f, -0.06521298f, 0.16675068f, -0.00157045f, 0.25501901f, 0.14506382f, -0.04219964f, -0.06166767f, 
    0.00972003f, 0.05158563f, -0.19133289f, -0.07190909f, 0.21572305f, 0.13284937f, -0.19002397f, 0.11605218f, 
    -0.08121593f, -0.25652084f, -0.26022536f, -0.02017563f, 0.01851720f, -0.09225167f, -0.03222471f, 0.36071342f, 
    0.09763895f, 0.30349129f, -0.00817962f, -0.00356513f, 0.28298363f, -0.01800913f, 0.00810774f, 0.13921139f, 
    0.03578168f, -0.13568467f, 0.06382068f, -0.18548596f, -0.27217609f, 0.08587418f, -0.05572497f, -0.12881321f, 
    -0.03793172f, 0.08588315f, 0.11398948f, 0.18697155f, -0.12159476f, -0.11402979f, -0.07451348f, -0.01576318f, 
    -0.09624235f, 0.15720531f, 0.13212590f, -0.00611253f, 0.06968524f, 0.09527643f, -0.32822564f, 0.09031540f, 
    -0.13756905f, 0.02172713f, 0.02413254f, 0.09286302f, -0.20001449f, -0.00627645f, -0.13382661f, -0.45283124f, 
    0.21635869f, 0.04326594f, -0.08821309f, -0.16538255f, 0.02131981f, -0.00334038f, 0.24415731f, -0.13672236f, 
    0.11724553f, 0.08592146f, 0.06512433f, -0.12288003f, -0.28831697f, 0.18314055f, 0.07320704f, -0.01639822f, 
    -0.18546854f, 0.22788334f, 0.21968012f, -0.20517793f, 0.00236858f, -0.00579632f, -0.09609691f, 0.11995947f, 
    0.10378178f, -0.53063893f, -0.06576635f, -0.17166778f, -0.23170131f, 0.16213702f, -0.00448853f, 0.00238545f, 
    0.09105667f, 0.04522241f, -0.11453451f, 0.02171727f, 0.13175723f, 0.20457517f, -0.18308391f, 0.04701826f, 
    -0.13412331f, -0.06357700f, 0.03856625f, -0.15169458f, 0.05014133f, 0.13017488f, -0.12300705f, -0.08155313f, 
    0.09425686f, -0.06384570f, 0.06480161f, 0.19154119f, 0.21379848f, 0.18671221f, 0.07234544f, 0.09754899f, 
    -0.21033101f, -0.00435341f, -0.16897608f, 0.19038777f, -0.04050362f, 0.39456123f, 0.38021550f, -0.03033718f, 
    0.12163054f, -0.10528726f, -0.10632773f, 0.07237548f, -0.02712891f, 0.11313233f, -0.22428693f, -0.06961164f, 
    -0.01876132f, 0.17012280f, 0.16129042f, 0.02148860f, 0.07958834f, 0.08463184f, -0.11920826f, 0.23681539f, 
    0.16093615f, 0.08713755f, -0.09224468f, -0.00552410f, 0.03358888f, -0.02167026f, -0.02672694f, -0.13763459f, 
    0.15639569f, 0.19168873f, -0.21009830f, 0.05609956f, 0.02047754f, 0.03601022f, 0.03135051f, 0.08139072f, 
    -0.06365422f, -0.11181981f, -0.33242613f, 0.17264545f, 0.04303925f, 0.06583685f, 0.03185030f, -0.00922732f, 
    0.06591316f, 0.22846906f, -0.13033363f, -0.29230052f, -0.41613710f, 0.14474985f, 0.10654084f, 0.01383188f, 
    0.04187410f, -0.01639698f, -0.01255961f, 0.29470703f, -0.08250291f, 0.01068019f, 0.03533686f, -0.02711203f, 
    0.05088057f, -0.02349083f, -0.07573844f, -0.10018086f, 0.17530109f, 0.12717189f, -0.13104042f, 0.15822981f, 
    -0.04376081f, -0.08831150f, 0.17498952f, 0.03946617f, 0.10201454f, -0.02509855f, 0.05444323f, 0.01102870f, 
    0.19478512f, -0.18191957f, -0.00523136f, -0.11281157f, -0.05366444f, -0.03942374f, -0.04036423f, -0.01795901f, 
    -0.40039030f, 0.01149876f, -0.01853271f, 0.06994461f, 0.02533418f, -0.04718282f, -0.06137690f, 0.08251509f, 
    0.23803271f, -0.27020901f, -0.01606448f, -0.21295273f, 0.04078409f, -0.04829884f, -0.01699630f, -0.08694527f, 
    0.22102128f, -0.07809013f, -0.05483681f, -0.05881511f, 0.09914690f, -0.04524058f, 0.16527152f, -0.10897047f, 
    -0.05214577f, 0.31208122f, 0.09996022f, -0.09122545f, -0.08636503f, -0.05167188f, 0.04393488f, 0.12453537f, 
    0.08265775f, -0.12539454f, -0.34847331f, 0.28497443f, -0.11080866f, 0.08109004f, 0.01721323f, 0.00016204f, 
    0.11875034f, -0.02458929f, -0.20726462f, -0.20965837f, 0.14101419f, 0.19147721f, -0.09243433f, 0.23911029f, 
    0.11948067f, -0.01665177f, 0.02093393f, -0.03505832f, 0.45674756f, -0.01898696f, -0.41464359f, -0.04663572f, 
    -0.10063586f, 0.07668240f, 0.01539238f, 0.01191823f, 0.04505622f, -0.22099388f, 0.11079296f, -0.02769465f, 
    -0.38380715f, -0.06831696f, 0.09348564f, 0.06001551f, 0.12439857f, 0.08143313f, 0.06367392f, 0.54538250f, 
    -0.06673703f, 0.14075169f, -0.10649367f, -0.00095888f, 0.20329003f, 0.00924745f, -0.13877067f, 0.13885920f, 
    0.13548151f, -0.06382408f, 0.03341258f, 0.00941826f, -0.08080008f, -0.00828418f, 0.00630734f, -0.03820593f, 
    0.27658290f, -0.65702522f, 0.01958329f, -0.08259354f, 0.10182752f, -0.09196310f, -0.04651434f, -0.02235799f, 
    0.08569926f, 0.01530376f, -0.26920500f, -0.35597858f, 0.10324959f, 0.00759504f, 0.05833679f, 0.02868871f, 
    0.10925749f, 0.03012861f, 0.20603056f, 0.12520097f, -0.17329396f, -0.05714593f, -0.05726278f, 0.07548541f, 
    0.11378645f, -0.09595101f, -0.02230966f, 0.11283141f, 0.00995554f, 0.03306574f, -0.06340606f, 0.07764338f, 
    0.06102453f, 0.14459710f, 0.09803607f, -0.12115103f, -0.08148420f, -0.17470117f, 0.03974319f, -0.00010272f, 
    0.12601823f, -0.19917424f, 0.05377622f, -0.14661863f, 0.12291150f, -0.22380085f, -0.37980723f, -0.14141238f, 
    0.09077242f, -0.10396071f, -0.09707232f, -0.15938842f, 0.15748039f, -0.17371401f, 0.28914541f, -0.09804261f, 
    -0.03256439f, -0.13609734f, 0.07212641f, -0.12825362f, -0.08739671f, -0.00796871f, 0.00945413f, -0.21843627f, 
    -0.03318766f, -0.08937898f, -0.04210806f, -0.16728799f, 0.05683024f, -0.09881969f, -0.02231041f, 0.07872144f, 
    0.22659464f, 0.38081843f, -0.01982052f, 0.28911498f, -0.24628688f, 0.20702842f, 0.01256229f, -0.00407963f, 
    -0.28628173f, 0.16232778f, 0.12732646f, -0.17002490f, 0.03802941f, 0.02196558f, -0.16254678f, -0.00996240f, 
    0.08668294f, -0.12875880f, -0.13156526f, -0.12289437f, -0.10845613f, -0.03596851f, -0.11620996f, -0.03315099f, 
    -0.07060062f, 0.00611032f, 0.03918296f, -0.00216276f, -0.02561066f, 0.37960458f, -0.00502596f, -0.10925671f, 
    0.02853324f, 0.03780154f, -0.05003976f, 0.14601451f, -0.07025526f, -0.05633529f, -0.08525982f, 0.18967634f, 
    -0.03193538f, 0.17144120f, 0.15147403f, -0.12414920f, -0.22746374f, 0.09318558f, -0.20872238f, 0.08208771f, 
    -0.11113808f, -0.11947145f, -0.15402550f, 0.03510074f, 0.04182974f, 0.02706969f, -0.08002704f, -0.36442733f, 
    0.00117836f, 0.02178120f, -0.00070014f, 0.02464061f, -0.08397380f, -0.07023323f, -0.01474494f, -0.00049717f, 
    0.28094608f, 0.11817670f, -0.01721501f, -0.05032958f, -0.06406179f, -0.10247681f, -0.07864789f, 0.03015918f, 
    0.11460132f, -0.33479765f, -0.20349662f, 0.01352609f, -0.11153726f, 0.19319773f, 0.21989478f, -0.21608637f, 
    -0.11911546f, 0.00048429f, 0.11885139f, -0.04841946f, -0.02731644f, 0.22497635f, -0.25816381f, -0.03211530f, 
    0.03202866f, -0.09336978f, 0.18770064f, 0.05838402f, 0.03022096f, 0.09270265f, -0.00398539f, -0.00106751f, 
    0.02732895f, -0.18466116f, -0.03372027f, -0.44114143f, -0.17457817f, -0.06044816f, -0.13378304f, 0.05884458f, 
    0.01466511f, -0.03302092f, 0.05884832f, 0.06832951f, 0.17715597f, -0.09968724f, 0.37473452f, -0.02740029f, 
    -0.06066835f, 0.04742439f, 0.07623454f, 0.11178032f, 0.08939971f, -0.23530406f, -0.07217808f, 0.01303900f, 
    0.02979779f, 0.10928145f, 0.19879983f, -0.05305230f, -0.09337411f, -0.03009255f, 0.00361260f, 0.01923219f, 
    -0.25557277f, -0.10394021f, 0.18911237f, -0.04066603f, 0.12110076f, 0.00256206f, 0.05121020f, -0.16288941f, 
    -0.12797672f, -0.05163666f, 0.10668314f, 0.12226605f, -0.00453419f, -0.01266611f, 0.04886460f, -0.05131431f, 
    0.02914631f, -0.36181015f, 0.23794903f, -0.26056299f, 0.08565779f, 0.08715125f, 0.11856422f, 0.03892577f, 
    -0.10109338f, 0.07410397f, 0.04097021f, 0.31286439f, -0.01810521f, -0.08272868f, 0.03901548f, 0.03893998f, 
    0.24066961f, 0.20680131f, 0.26820350f, -0.22237566f, -0.06240530f, -0.18569686f, 0.03169037f, -0.01715452f, 
    -0.00586279f, -0.12524885f, -0.05801665f, 0.18534376f, -0.05780564f, 0.15734915f, 0.13295078f, 0.08965218f, 
    -0.16144353f, 0.15975805f, 0.05253218f, 0.04856005f, -0.16332301f, 0.17564541f, -0.14450842f, -0.00425712f, 
    0.08850734f, -0.00713384f, 0.13292906f, -0.03578666f, -0.02347804f, 0.16506302f, 0.27798408f, -0.38333762f, 
    0.10390009f, -0.07006018f, 0.09066247f, 0.06720437f, -0.02705675f, 0.00869615f, -0.05910943f, -0.23125076f, 
    0.05385663f, 0.01421224f, 0.05727668f, 0.06458875f, -0.06313055f, -0.27846450f, 0.14199272f, 0.05038216f, 
    0.01524401f, 0.07909670f, 0.09543682f, 0.04570829f, 0.08817956f, 0.02795667f, -0.13747126f, -0.18018769f, 
    0.21379271f, -0.04740093f, 0.08618675f, -0.00219052f, -0.04798636f, -0.08270063f, -0.15738027f, -0.01837870f, 
    0.09554972f, -0.13433109f, -0.09129020f, 0.30150288f, -0.14152727f, 0.10820414f, -0.08808546f, -0.02068731f, 
    -0.03304348f, -0.07514258f, -0.22141041f, -0.09513731f, 0.16754346f, -0.07112771f, 0.01197896f, -0.13833486f, 
    -0.11517026f, 0.08378209f, 0.15107153f, -0.26897055f, -0.12335680f, -0.00637408f, 0.12474090f, 0.05078395f, 
    0.15326563f, 0.04500761f, -0.05163756f, 0.11365446f, 0.01407270f, 0.16357660f, 0.06924973f, -0.19108419f, 
    -0.06256294f, -0.03052173f, -0.03444839f, 0.04200308f, 0.04379353f, 0.19449066f, 0.06104748f, -0.09437359f, 
    0.04316738f, 0.03025702f, 0.07833725f, -0.05534128f, -0.09511463f, 0.22829339f, -0.40914452f, 0.08676703f, 
    0.13228486f, 0.04677957f, -0.00188896f, 0.02255236f, 0.19530901f, -0.16458304f, 0.09725897f, -0.01488411f, 
    0.00182842f, 0.23423040f, -0.21120225f, -0.03362482f, 0.14186804f, -0.08150467f, 0.01827607f, 0.11038530f, 
    -0.54754549f, -0.09207306f, -0.48910910f, 0.11096764f, 0.03327965f, -0.03138395f, -0.06326114f, 0.15987927f, 
    -0.02144218f, -0.04907299f, 0.11473851f, -0.05609676f, -0.19647804f, -0.05408423f, -0.06602738f, 0.05503931f, 
    0.05332409f, -0.02494762f, -0.35991168f, -0.27761143f, -0.14307649f, 0.22932199f, -0.03268887f, -0.00319935f, 
    -0.00948059f, -0.00899998f, 0.09251407f, -0.09431298f, -0.11498193f, 0.02107445f, -0.12642446f, -0.05228880f, 
    0.19872215f, 0.19987489f, -0.09636842f, 0.13282271f, -0.55922365f, -0.36098972f, -0.09075729f, 0.10515007f, 
    0.11563022f, -0.04411537f, 0.15301223f, -0.10529908f, 0.04069137f, 0.17991832f, 0.22149178f, 0.06301155f, 
    0.06623118f, 0.22125115f, -0.03460701f, 0.03308788f, 0.13260251f, 0.11408735f, 0.10887463f, 0.09158051f, 
    0.11947281f, 0.13835473f, -0.11611678f, 0.17328331f, 0.01831281f, 0.07812982f, -0.03494834f, -0.00983030f, 
    0.14287344f, 0.00222977f, 0.02722570f, 0.03073630f, 0.10680205f, 0.19419093f, -0.06696326f, -0.03250936f, 
    -0.09565508f, 0.03155774f, -0.12081505f, 0.06790877f, 0.08914883f, 0.00441602f, -0.04635713f, 0.00311261f, 
    0.03268766f, 0.30430537f, -0.05259522f, 0.14834772f, 0.11844090f, 0.02469223f, 0.23667224f, -0.04330369f, 
    0.12144457f, 0.02408535f, 0.40243736f, -0.09125738f, -0.13177380f, -0.06826431f, 0.23717378f, -0.01602633f, 
    -0.30079421f, -0.09998686f, -0.21128672f, -0.40395641f, -0.50097275f, -0.21475428f, -0.02412356f, -0.10075151f, 
    -0.31666863f, 0.13029800f, -0.02460527f, -0.01282424f, 0.31610096f, 0.14261158f, 0.19695002f, 0.03750907f, 
    0.18589260f, -0.08053394f, 0.13673112f, 0.05441170f, -0.04469606f, -0.21358062f, -0.40028527f, -0.09285232f, 
    -0.03233066f, -0.03167127f, -0.09970862f, 0.11430079f, -0.07256869f, 0.05516763f, -0.19035302f, 0.04353435f, 
    -0.13051644f, 0.21333554f, 0.12902664f, -0.22096018f, -0.02590267f, 0.06434965f, -0.04920086f, -0.21219130f, 
    -0.22815178f, -0.01521132f, 0.26638052f, -0.01079312f, 0.06698766f, -0.16952485f, 0.01131132f, -0.04116493f, 
    -0.10345431f, 0.10502002f, 0.01999920f, 0.12224338f, 0.02554154f, -0.29168242f, 0.03880664f, 0.25594997f, 
    -0.00967960f, 0.36817190f, 0.10184320f, 0.09716012f, -0.08204248f, 0.02576101f, -0.12536496f, 0.21419573f, 
    -0.10592739f, -0.17629276f, 0.07983236f, 0.37154767f, 0.02594685f, 0.06422280f, -0.09635162f, 0.06021172f, 
    0.06628270f, 0.06173677f, 0.05894582f, 0.17162690f, -0.01735193f, -0.01162496f, 0.04568158f, 0.14355673f, 
    0.23725148f, -0.20903279f, 0.18524767f, -0.14928028f, -0.72712588f, -0.31438008f, 0.32835364f, 0.22751062f, 
    0.09022430f, 0.17755495f, -0.04404619f, -0.24542920f, -0.11513483f, -0.37190607f, -0.02562477f, 0.24064931f, 
    0.13957945f, 0.06537928f, 0.17860441f, -0.18159255f, 0.03842356f, -0.09952438f, 0.31374744f, 0.05390844f, 
    0.06431874f, -0.10321043f, 0.12312705f, 0.00577036f, -0.12122154f, 0.23561314f, 0.09990825f, 0.12690026f, 
    -0.01439419f, -0.06264592f, 0.08028787f, 0.11479016f, -0.09438481f, 0.07964791f, 0.20486219f, 0.34186593f, 
    -0.01799276f, -0.00500463f, -0.02338241f, 0.08130267f, -0.06330261f, 0.00248264f, 0.01923035f, 0.09473127f, 
    -0.12983839f, 0.02332919f, 0.06120532f, -0.28276762f, -0.25021365f, -0.14439832f, 0.12022746f, 0.11034474f, 
    -0.02012095f, 0.00729350f, 0.07252901f, 0.11722602f, 0.17269576f, -0.11510149f, 0.06996044f, 0.25114956f, 
    -0.08927632f, 0.14137071f, -0.10758912f, -0.01237190f, -0.23267205f, -0.03052106f, -0.14264448f, -0.06081118f, 
    -0.16754773f, 0.04416876f, -0.03329752f, -0.16521125f, -0.05047585f, 0.09593166f, -0.08344380f, 0.01216452f, 
    -0.08130155f, 0.18506886f, 0.05212973f, 0.23489016f, 0.12247254f, 0.10646779f, 0.05735710f, -0.18348262f, 
    -0.02433477f, -0.01536700f, 0.00306121f, 0.01151494f, -0.18933840f, -0.30899864f, 0.14507449f, -0.10797068f, 
    0.00678356f, 0.13989972f, 0.10633302f, -0.06368997f, 0.25323868f, 0.25260770f, 0.04592226f, -0.09282991f, 
    -0.04690510f, -0.23016596f, -0.19445224f, 0.13950393f, 0.14044100f, 0.06143925f, 0.12480140f, 0.09259552f, 
    -0.04170350f, -0.00085904f, -0.05844140f, 0.00456433f, -0.04411752f, 0.01092913f, -0.07114374f, 0.04441403f, 
    -0.05976013f, -0.04753163f, 0.00306604f, 0.02182218f, -0.00755024f, -0.01417338f, -0.04031969f, -0.02813764f, 
    0.00844133f, 0.02804988f, -0.05840530f, -0.06197479f, 0.03746760f, 0.01920342f, -0.00967411f, -0.02883110f, 
    -0.00297882f, 0.02055030f, -0.02897050f, 0.02508862f, -0.03636671f, 0.03740757f, -0.00310190f, -0.00759219f, 
    -0.06210493f, -0.03813598f, 0.03348467f, -0.00543665f, -0.03134878f, 0.00399872f, -0.03836576f, 0.01251020f, 
    -0.01583435f, 0.01174066f, 0.03079577f, 0.02890616f, -0.05337331f, 0.02415633f, 0.00592956f, 0.00428918f, 
    0.00286582f, 0.04548667f, -0.01217965f, -0.03446376f, 0.01369194f, 0.04352965f, -0.06371769f, -0.01517131f, 
    0.01626614f, -0.02615707f, -0.01080825f, -0.05164247f, 0.01606262f, 0.03422015f, -0.01675812f, 0.01651954f, 
    0.01681140f, 0.02949276f, -0.04233529f, -0.01606968f, 0.01674451f, -0.00030992f, 0.00701682f, 0.00974128f, 
    0.00214611f, -0.04116442f, 0.01889714f, 0.02952494f, 0.00909746f, 0.02998856f, -0.00139522f, -0.01028179f, 
    -0.02980066f, -0.01846150f, -0.00805608f, -0.00575793f, -0.00475750f, 0.03190244f, -0.06378881f, -0.00107532f, 
    0.01684011f, -0.02225059f, -0.03691327f, 0.03305459f, -0.05361551f, -0.06975459f, -0.01765763f, -0.03260918f, 
    0.00646998f, -0.01268764f, -0.03971736f, -0.06745899f, 0.01690430f, -0.02316042f, 0.01960129f, 0.04160033f, 
    0.00295878f, -0.05030734f, -0.06618588f, -0.06331837f, -0.07151459f, 0.04170675f, 0.04517357f, -0.02986923f, 
    0.02722492f, 0.03238094f, 0.00309426f, 0.02792131f, 0.03683908f, 0.02249005f, 0.00498920f, -0.05994432f, 
    0.03797994f, 0.04859432f, -0.02070194f, 0.03190815f, -0.00573640f, 0.01561384f, -0.02555512f, -0.06660494f, 
    -0.04536332f, -0.04388118f, -0.03864977f, -0.03178531f, 0.00454701f, -0.00306934f, -0.00391053f, 0.04168777f, 
    0.01410809f, -0.03840375f, 0.01238935f, -0.01577647f, 0.01501526f, -0.02978078f, -0.02216683f, 0.04284040f, 
    -0.02559355f, -0.04382059f, 0.00901794f, -0.01434098f, 0.03949891f, 0.03184018f, 0.01075219f, 0.00228182f, 
    -0.00177235f, 0.04662155f, -0.00900877f, -0.02831324f, 0.00084522f, -0.03671035f, -0.05894704f, -0.01475216f, 
    -0.04849498f, 0.01398880f, 0.04007929f, -0.05272998f, 0.01271337f, 0.03580331f, 0.01220662f, 0.01876378f, 
    -0.03748550f, 0.03789184f, -0.03790072f, 0.00376696f, 0.03717215f, -0.05686527f, -0.00025286f, 0.01264117f, 
    -0.02204656f, -0.02863184f, 0.02112196f, -0.00046012f, -0.03033728f, 0.02279541f, -0.00321014f, -0.05711447f, 
    -0.04529079f, -0.00646606f, 0.03319060f, 0.00449749f, -0.04202247f, 0.00779417f, 0.02144119f, -0.00082870f, 
    0.01201612f, 0.03749273f, -0.02480691f, 0.04229866f, -0.01255661f, 0.03667303f, -0.03706439f, 0.00349558f, 
    0.03566775f, -0.00835873f, -0.01329171f, -0.03338230f, -0.00467855f, -0.02588100f, -0.01555060f, -0.02362756f, 
    -0.00687103f, -0.05422069f, -0.01830810f, 0.01763087f, -0.02995090f, 0.01512531f, -0.02671159f, -0.02110274f, 
    0.00895532f, 0.03362273f, 0.00329979f, -0.01284367f, 0.02788389f, 0.02810462f, 0.01446597f, -0.04694170f, 
    -0.02222646f, 0.04596232f, 0.00028320f, 0.04526290f, -0.00319267f, 0.02299471f, 0.04230999f, -0.00025591f, 
    0.02231495f, -0.05526970f, -0.05387117f, 0.01352249f, 0.01419200f, -0.06567279f, -0.01183110f, 0.04280119f, 
    0.00645191f, 0.02937451f, 0.03152192f, 0.00624273f, 0.00398675f, -0.05478929f, 0.03699599f, -0.06832258f, 
    -0.02309770f, 0.01022013f, -0.02603127f, 0.04685769f, -0.00487323f, 0.00383969f, -0.06850156f, 0.04390231f, 
    0.01986768f, -0.03977743f, 0.00134386f, -0.01643614f, -0.02231674f, 0.04405167f, 0.03381651f, -0.04765182f, 
    -0.05846064f, -0.03695927f, 0.03842174f, 0.01233417f, -0.02445863f, 0.00703921f, 0.03145543f, -0.06141360f, 
    -0.03117234f, -0.04874489f, -0.02289979f, -0.01254670f, -0.01092999f, -0.01834878f, -0.01538476f, 0.00790304f, 
    -0.03015572f, 0.04827265f, -0.04476354f, 0.05085472f, -0.01983005f, -0.02182386f, 0.00996110f, -0.04206980f, 
    0.00069158f, -0.03914942f, -0.00025663f, -0.04977393f, 0.00209186f, -0.02023510f, -0.05635617f, 0.03620709f, 
    -0.02433639f, 0.02550719f, -0.05250501f, 0.03548457f, -0.01896924f, 0.02833299f, 0.05107066f, 0.04323167f, 
    -0.01741919f, 0.04936671f, -0.03694332f, -0.01925193f, -0.01284118f, 0.02098455f, -0.03874926f, -0.01109695f, 
    0.01561888f, -0.02749733f, 0.04851233f, 0.03367505f, -0.02134738f, -0.00267553f, 0.00474378f, -0.05099198f, 
    0.01050117f, -0.00670874f, 0.02992663f, -0.01332077f, 0.02169922f, -0.04474001f, -0.03543012f, -0.00773385f, 
    -0.00275789f, 0.04788316f, 0.01191349f, -0.04136891f, 0.04164646f, 0.03450193f, -0.03381733f, -0.01351867f, 
    -0.03698179f, -0.05963182f, -0.06396499f, 0.03750075f, -0.04334245f, 0.04194659f, -0.06399030f, -0.01556829f, 
    0.05104999f, -0.02211932f, 0.00144135f, 0.02124975f, 0.03932646f, 0.03911870f, 0.00028525f, 0.01506671f, 
    -0.03151876f, 0.00707358f, 0.05049348f, 0.00766281f, -0.00297688f, 0.05159802f, -0.01309953f, 0.01235051f, 
    -0.01418439f, 0.03558558f, 0.03580449f, -0.00216720f, -0.04009855f, 0.02637903f, -0.04128589f, -0.03706457f, 
    -0.05569725f, -0.02046913f, 0.02066393f, -0.02725673f, -0.01220939f, 0.04610418f, -0.05490138f, -0.06301400f, 
    0.01082460f, -0.01286813f, 0.02126386f, -0.02492788f, -0.03791273f, -0.05331615f, 0.03832088f, 0.04200352f, 
    0.04644729f, -0.00200379f, -0.01297230f, 0.01161020f, -0.06205447f, 0.05684068f, -0.03064162f, -0.05413131f, 
    -0.02377191f, 0.01820059f, 0.00324727f, -0.05567753f, 0.02165237f, 0.00535586f, 0.00041517f, 0.04783607f, 
    0.04532875f, -0.06424914f, 0.03098352f, -0.05677203f, 0.02630131f, 0.03637203f, -0.03676881f, 0.03262591f, 
    -0.01958266f, 0.03161377f, 0.00232777f, -0.04101711f, 0.03623273f, -0.02800410f, 0.03138620f, -0.04565937f, 
    0.02064930f, -0.06296270f, 0.03475242f, -0.05862717f, 0.01856614f, -0.03450396f, -0.05713475f, -0.05436484f, 
    0.04426877f, -0.06261066f, 0.02888921f, -0.04224118f, -0.00431431f, -0.05394068f, -0.04055797f, 0.02714233f, 
    -0.02631969f, 0.00312049f, -0.05978383f, 0.01701205f, 0.03304783f, -0.03872359f, -0.02051236f, -0.04279984f, 
    0.03943024f, -0.06191866f, -0.03737378f, -0.00570211f, 0.03335277f, 0.05074275f, -0.01631817f, -0.01758293f, 
    -0.00161925f, 0.02516253f, -0.02650648f, -0.06111647f, -0.01593724f, -0.02304816f, -0.01944940f, 0.04688036f, 
    0.02165168f, -0.02034488f, -0.06381680f, -0.01588637f, 0.04137530f, 0.01769338f, 0.03700159f, -0.01887617f, 
    -0.06059240f, -0.03581524f, -0.04588743f, 0.05103764f, -0.01188503f, -0.02199248f, -0.00930224f, 0.04306559f, 
    -0.05442670f, 0.02160578f, -0.02370322f, -0.00206347f, 0.04879948f, 0.01149053f, -0.03317855f, -0.01944044f, 
    0.03120300f, 0.04414838f, -0.01124021f, 0.04964459f, -0.00622737f, -0.05334158f, 0.04859203f, 0.00478630f, 
    0.04562077f, 0.06134642f, 0.05395098f, -0.05315858f, 0.00861865f, -0.00849253f, -0.03003418f, 0.02048400f, 
    -0.06002130f, 0.00471628f, -0.05412759f, -0.03788931f, 0.01245026f, 0.03293791f, -0.03322675f, -0.04652226f, 
    0.02764430f, -0.04529013f, -0.04746044f, -0.02096930f, -0.04278551f, -0.00557143f, -0.00885798f, -0.06356356f, 
    0.02643904f, -0.02025724f, 0.05094213f, -0.03670676f, -0.01457109f, 0.01246904f, 0.01450442f, 0.03501477f, 
    -0.01184352f, -0.06269208f, -0.04236753f, 0.02796323f, 0.04202975f, 0.01975971f, 0.03821957f, -0.02982279f, 
    -0.06080968f, -0.06237259f, -0.03343127f, -0.04487117f, 0.04136001f, 0.03628880f, -0.03839266f, -0.03139671f, 
    -0.01675324f, -0.03780263f, -0.02773993f, -0.04209917f, 0.02987421f, 0.02571592f, 0.02289951f, -0.00236275f, 
    -0.03741341f, -0.03429388f, 0.03617807f, 0.00416362f, -0.04014308f, 0.01375494f, -0.02688321f, -0.01799124f, 
    -0.06311033f, -0.04837036f, -0.05205644f, -0.03127859f, 0.01727090f, 0.03109410f, -0.04459560f, -0.02284149f, 
    0.00737839f, -0.02612297f, 0.00961410f, 0.03576583f, -0.00193784f, -0.01629130f, -0.03666980f, -0.03156314f, 
    -0.01746790f, 0.01330920f, -0.05936623f, -0.00364857f, -0.04521160f, -0.02118505f, -0.04061375f, 0.00547029f, 
    -0.00816174f, -0.01619311f, 0.01822291f, -0.00845384f, 0.03788339f, 0.00480861f, 0.04806632f, 0.00017277f, 
    -0.05112035f, 0.04444943f, 0.01386481f, 0.02138161f, -0.02520771f, -0.02633938f, 0.04131592f, 0.02310795f, 
    0.00058787f, 0.03236245f, 0.04391521f, 0.03216678f, 0.03636917f, 0.00491846f, -0.05285244f, -0.05222320f, 
    0.01472696f, -0.02537404f, -0.05649898f, -0.04410836f, -0.01211426f, 0.02238337f, 0.04498260f, -0.04236072f, 
    -0.01590235f, -0.03507927f, -0.02738906f, 0.01611987f, 0.01505956f, -0.05486045f, 0.00149840f, -0.05701926f, 
    0.04476709f, 0.05018621f, 0.04257550f, -0.00707516f, -0.05433060f, -0.02662743f, -0.00340524f, 0.03711376f, 
    -0.00945375f, -0.02850973f, -0.03432516f, -0.00291180f, -0.04309086f, -0.00435396f, 0.02586777f, 0.03096890f, 
    -0.03466985f, -0.03190176f, 0.04163619f, -0.00682187f, -0.06353049f, -0.01504967f, -0.05865695f, -0.02287256f, 
    -0.03743056f, -0.02634868f, -0.06083615f, -0.05365229f, -0.03518247f, 0.01849818f, -0.05556365f, 0.03151681f, 
    0.00784192f, 0.03548921f, -0.02176893f, 0.01450089f, -0.00982909f, -0.05992130f, -0.01142608f, 0.00619672f, 
    -0.03992851f, -0.02386131f, 0.03385650f, 0.02313790f, -0.01933850f, 0.04369021f, -0.04445741f, 0.02544942f, 
    0.01632892f, -0.02661464f, 0.02796523f, -0.00279833f, -0.01025064f, -0.05215332f, -0.06183977f, -0.00646569f, 
    0.01935350f, -0.01082953f, -0.05306308f, -0.02638071f, -0.06332238f, 0.02331303f, 0.01557908f, -0.06615636f, 
    -0.05741129f, -0.01805850f, 0.01888931f, -0.05144380f, -0.01713679f, -0.05616199f, 0.03277482f, 0.00510685f, 
    0.04275787f, -0.02405810f, 0.03243193f, 0.00678999f, -0.04104123f, 0.04838789f, -0.02996454f, 0.01515586f, 
    -0.05189990f, -0.04265870f, 0.04586326f, -0.01161967f, -0.04666511f, 0.04671792f, -0.05361249f, -0.04686338f, 
    0.00328857f, -0.02404497f, 0.03662396f, 0.00595746f, -0.06776684f, 0.03794964f, 0.00607309f, -0.04838318f, 
    -0.00494231f, 0.04026796f, -0.05371815f, -0.02002959f, 0.00355638f, -0.02269489f, -0.01229181f, -0.05802845f, 
    0.03002002f, 0.02201045f, 0.02067962f, 0.02302680f, 0.04868459f, 0.00509482f, 0.04478835f, -0.03898941f, 
    0.02959657f, -0.01128840f, 0.03805958f, -0.03122494f, 0.04296730f, -0.04652525f, 0.01299865f, -0.04588064f, 
    -0.05744584f, 0.04480921f, -0.05846258f, 0.00027700f, -0.01023140f, 0.01063858f, 0.04493644f, -0.06352867f, 
    0.04524300f, -0.05312077f, 0.03683806f, -0.02996255f, -0.06119496f, 0.04755614f, 0.01246765f, -0.02858107f, 
    -0.03417196f, -0.01381608f, 0.00225006f, 0.03045951f, 0.00880362f, -0.01868101f, -0.00306866f, -0.03327996f, 
    0.04465814f, 0.02810442f, -0.01002339f, -0.06885914f, 0.03424879f, 0.03216812f, -0.04434137f, 0.00883393f, 
    -0.05144162f, -0.03054554f, -0.01043710f, -0.02728951f, -0.04339123f, -0.00264915f, 0.00046824f, -0.01223326f, 
    -0.01076997f, 0.00933904f, 0.00418691f, 0.03591763f, 0.04720232f, -0.02243875f, 0.01885734f, 0.01743062f, 
    -0.06576069f, 0.01407022f, -0.06918868f, 0.03575743f, -0.06482425f, -0.01178608f, -0.04980323f, -0.00678167f, 
    0.00360343f, -0.02906187f, -0.04575897f, 0.01986357f, 0.01477322f, -0.03695590f, -0.05717717f, 0.00059691f, 
    -0.01323704f, 0.04296670f, -0.00434428f, 0.01517194f, 0.01325992f, -0.00427491f, -0.05379631f, 0.01674214f, 
    0.03885364f, -0.05420965f, 0.01304412f, -0.04311289f, 0.03223651f, -0.06561164f, 0.03034961f, 0.01563702f, 
    -0.01122543f, -0.03517535f, 0.01981721f, -0.05775149f, -0.02253973f, 0.00487878f, -0.01339112f, -0.05862412f, 
    -0.03035885f, -0.02425851f, -0.04791584f, -0.05750074f, 0.03201880f, 0.03819143f, -0.01892853f, 0.00587677f, 
    -0.01805725f, -0.01022064f, -0.01414964f, -0.06924877f, 0.01612872f, 0.02921285f, 0.01876681f, 0.01653658f, 
    0.00544919f, 0.03032897f, 0.03334571f, 0.01573088f, -0.03575983f, -0.03106707f, 0.03132103f, -0.05087557f, 
    -0.02477686f, -0.05406712f, -0.00241634f, -0.01197430f, -0.05188803f, 0.01078529f, -0.00732831f, -0.00438400f, 
    -0.03019740f, -0.02134822f, -0.02361689f, 0.01456918f, -0.06476527f, -0.00514853f, 0.02428919f, 0.01524988f, 
    0.31058171f, 0.23680194f, 0.06668787f, -0.03180738f, -0.09484535f, 0.06967731f, -0.05368760f, 0.08367271f, 
    -0.14874844f, -0.60425377f, -0.02680712f, 0.09735058f, 0.13421975f, 0.12837233f, 0.04579167f, -0.04828789f, 
    0.03840409f, -0.08602246f, 0.45805812f, 0.10246670f, 0.31225497f, -0.02776202f, -0.06037977f, 0.13752942f, 
    0.04847376f, 0.01610484f, 0.00274837f, 0.21432899f, 0.05873320f, -0.13117874f, -0.02937318f, 0.06031321f, 
    0.00727053f, -0.04362414f, 0.04515710f, 0.07291210f, 0.39933842f, 0.10864832f, 0.06192628f, -0.07607244f, 
    -0.15949190f, 0.09084593f, 0.19015568f, -0.09828968f, 0.11153793f, -0.06384274f, 0.38523170f, -0.28010204f, 
    0.00183004f, 0.02791559f, 0.14057375f, 0.08449424f, -0.04097663f, 0.08552063f, -0.26512825f, -0.63623244f, 
    -0.22761393f, 0.00839076f, 0.25555187f, 0.09277152f, -0.10224056f, -0.01002971f, -0.21889910f, 0.53566933f, 
    -0.06681671f, 0.10607316f, -0.06483676f, 0.10859504f, 0.06842240f, -0.14540307f, 0.15309434f, -0.20827278f, 
    -0.18823844f, -0.11376292f, 0.04905213f, 0.05053980f, 0.18819225f, 0.09718281f, 0.17872635f, -0.00074292f, 
    0.01765247f, 0.29077756f, 0.08961033f, -0.02851285f, 0.17330967f, -0.16458616f, 0.00511812f, -0.00739892f, 
    -0.10715910f, 0.22989817f, -0.00621873f, -0.08704991f, -0.08330379f, 0.07676741f, -0.11017649f, -0.28165585f, 
    0.10925311f, 0.11289490f, -0.04435631f, 0.01903653f, -0.04720666f, 0.31973559f, -0.17460307f, -0.19464464f, 
    -0.28102925f, 0.00888541f, -0.11267207f, -0.00593104f, -0.13669102f, 0.10764010f, -0.36889344f, 0.22536339f, 
    0.09826843f, 0.01185845f, -0.13182491f, 0.06058773f, 0.12382007f, 0.41262659f, 0.14874828f, -0.10608084f, 
    -0.01474334f, 0.07167099f, -0.22100455f, 0.15979995f, 0.06977326f, 0.14416082f, 0.07471458f, -0.10633861f, 
    0.09270757f, -0.31572112f, -0.18184508f, 0.14197913f, -0.22021501f, -0.00458328f, -0.11570719f, 0.42364538f, 
    0.40556028f, 0.32763609f, -0.19482882f, -0.22305791f, -0.23140517f, 0.19581737f, 0.08921852f, 0.21983370f, 
    -0.33035967f, 0.23127651f, -0.47126484f, 0.02712023f, 0.16600242f, 0.07865617f, -0.14794117f, -0.05490636f, 
    0.06703957f, -0.13029918f, 0.20817406f, -0.28159267f, 0.03977006f, 0.08255818f, 0.00484832f, -0.09187089f, 
    0.06279313f, 0.07530630f, -0.82189864f, 0.27498677f, 0.08456126f, 0.11165108f, 0.05055550f, 0.00632860f, 
    0.03464178f, -0.10347567f, -0.08202286f, -0.07660262f, -0.19146825f, 0.08780384f, 0.15755877f, 0.07820508f, 
    -0.02765092f, -0.04337431f, -0.10125069f, -0.01542381f, 0.36559150f, 0.16111955f, 0.07043274f, 0.02810743f, 
    0.05064699f, -0.09574918f, -0.06701468f, -0.12054593f, 0.08942356f, 0.07373724f, 0.13502987f, 0.14121571f, 
    0.07633247f, 0.05141174f, 0.02915054f, 0.25189075f, 0.05032117f, -0.01203504f, -0.12916523f, 0.08905461f, 
    -0.54389066f, 0.23133370f, 0.48237756f, 0.20039904f, -0.17196815f, -0.03439624f, 0.11709931f, -0.28366283f, 
    0.04315443f, -0.23277444f, 0.25282216f, -0.16736050f, 0.19545193f, -0.06125979f, 0.03982548f, 0.02373905f, 
    0.05523631f, -0.41096526f, 0.17340031f, -0.00211625f, 0.08640862f, 0.02591852f, -0.10360670f, 0.08784129f, 
    0.09458887f, -0.43984798f, -0.19747904f, -0.30188596f, -0.12817746f, 0.02361282f, 0.15714876f, -0.07545628f, 
    -0.10540957f, 0.12513009f, 0.65085870f, -0.06305432f, -0.20434463f, -0.17117088f, -0.20337373f, -0.08542673f, 
    0.11727475f, 0.00639303f, -0.13406144f, 0.22183706f, -0.19552524f, 0.04138015f, -0.05156199f, 0.22560580f, 
    -0.11471500f, 0.15538025f, -0.04200273f, 0.26170868f, 0.53385967f, -0.12220985f, -0.13056242f, 0.07955432f, 
    -0.14439374f, -0.04265299f, -0.01179860f, 0.04656338f, -0.13917318f, -0.32243580f, -0.49447942f, -0.06355199f, 
    0.07600375f, 0.02345221f, 0.02288567f, 0.27507740f, 0.12080985f, 0.03973871f, 0.18965900f, -0.14892921f, 
    -0.01748771f, 0.01509768f, 0.37101433f, 0.06063326f, -0.25333929f, -0.01009455f, 0.05043525f, 0.04335723f, 
    0.14922814f, -0.11984605f, 0.04102014f, -0.08124657f, -0.06843016f, 0.03235299f, -0.16045257f, -0.10672833f, 
    0.33722731f, 0.01383284f, -0.32508790f, -0.21346104f, -0.10267477f, -0.10814369f, -0.18172537f, 0.11771517f, 
    -0.11577975f, 0.15318547f, 0.14032228f, 0.14354388f, -0.05647842f, -0.05647311f, 0.01427530f, 0.11281498f, 
    0.10615112f, -0.06330179f, 0.18328021f, -0.46363840f, 0.01276869f, 0.30191231f, 0.07102688f, 0.12333710f, 
    0.04437899f, 0.15638645f, -0.08793156f, 0.00591606f, -0.40262884f, 0.14102550f, 0.08186352f, 0.05704901f, 
    0.07125919f, -0.12527493f, 0.19398247f, 0.23765656f, -0.33211821f, -0.57054371f, -0.30765641f, -0.02600366f, 
    0.05892288f, 0.03376797f, 0.09680953f, -0.15070629f, -0.10443818f, 0.10962133f, 0.18870780f, -0.00269813f, 
    -0.25663915f, -0.23928279f, -0.02388949f, 0.02803184f, 0.16920030f, -0.05427319f, 0.22989078f, 0.23077920f, 
    -0.21724623f, 0.02386318f, -0.11932352f, 0.01183664f, -0.33400968f, 0.04267912f, 0.08578239f, -0.36945570f, 
    0.19144511f, -0.00772724f, -0.10955384f, 0.02216374f, 0.00245046f, 0.00066974f, 0.05910311f, -0.06048666f, 
    -0.43106729f, -0.16893077f, 0.05426366f, -0.03516689f, 0.06463820f, -0.07122299f, -0.00145706f, -0.03021060f, 
    -0.10280635f, 0.52013111f, 0.27703571f, 0.07035725f, 0.01109621f, -0.19924472f, 0.04576227f, 0.19286898f, 
    -0.21131003f, 0.27570522f, 0.17983621f, -0.07574345f, 0.02904416f, 0.00314654f, 0.07861304f, 0.08547083f, 
    -0.04312069f, -0.03945094f, 0.03415105f, -0.17572685f, -0.32756373f, -0.04755145f, -0.07641677f, 0.04932060f, 
    -0.13102669f, 0.09059212f, -0.20426634f, 0.06542740f, 0.07687954f, 0.04313520f, 0.07366268f, -0.08435997f, 
    -0.19033776f, -0.03749716f, 0.08407391f, 0.13374770f, 0.01991617f, -0.22581424f, -0.45517603f, 0.21669140f, 
    0.16715591f, 0.08137179f, -0.08149979f, 0.00410985f, -0.35603955f, -0.21962403f, -0.09078164f, -0.04126328f, 
    0.07091370f, -0.05322796f, -0.11404936f, -0.12040744f, 0.18370423f, -0.16977985f, 0.07676113f, 0.24334955f, 
    -0.35075322f, 0.25217882f, 0.28318372f, 0.12752341f, 0.09240739f, -0.02036026f, 0.00492700f, 0.00362223f, 
    0.18787746f, -0.01212945f, -0.06106633f, -0.12394587f, 0.07017922f, -0.11697868f, 0.06877131f, 0.21317101f, 
    -0.00138377f, -0.09948935f, 0.00306911f, 0.04379641f, -0.18172087f, -0.14180945f, -0.15996100f, 0.15422684f, 
    0.06592305f, 0.02829376f, 0.13684329f, 0.39303026f, -0.12661821f, -0.11732548f, -0.05951368f, -0.04673583f, 
    -0.10278673f, 0.19275542f, 0.11771369f, 0.36379030f, 0.18884127f, -0.09984136f, -0.13655142f, 0.02470748f, 
    -0.16862197f, 0.09260660f, -0.01365334f, -0.03948863f, 0.15300986f, -0.19030069f, -0.04698030f, 0.11497989f, 
    -0.07277301f, 0.05751018f, -0.11314004f, -0.09535266f, -0.05373859f, -0.06433106f, -0.21943346f, 0.21457216f, 
    0.13725334f, 0.13941188f, 0.02605979f, 0.10648993f, -0.14054509f, 0.07163233f, 0.14406809f, 0.20782076f, 
    -0.07752404f, 0.03256273f, 0.05759049f, -0.09393646f, -0.05029897f, -0.03527922f, -0.11097719f, -0.11887449f, 
    -0.09717187f, 0.13029397f, 0.02767559f, 0.00642569f, -0.08595341f, 0.03067861f, 0.03536616f, -0.02469077f, 
    0.20731556f, 0.45361915f, -0.14825520f, -0.11503494f, 0.01539704f, -0.14919804f, 0.17523220f, 0.03624447f, 
    0.14894615f, -0.21269627f, -0.03213951f, 0.03772914f, -0.24005398f, 0.13993613f, 0.01928527f, -0.22378235f, 
    0.16502008f, 0.02437149f, -0.16171847f, -0.14010149f, -0.34322533f, -0.00185563f, -0.03972776f, -0.05710472f, 
    -0.21807425f, 0.07167213f, 0.03910315f, 0.11873716f, 0.12064008f, 0.09364887f, -0.06671322f, 0.16314243f, 
    -0.07779790f, 0.00406749f, 0.06849618f, -0.09322806f, 0.31707835f, 0.02535463f, 0.02607684f, -0.20672990f, 
    -0.11200851f, -0.18448792f, -0.13351761f, 0.04627386f, 0.00204572f, 0.15534340f, -0.04919969f, -0.17531908f, 
    -0.05393409f, -0.10083844f, -0.12756912f, 0.05584874f, 0.01504835f, 0.11932486f, 0.03812337f, -0.10092418f, 
    -0.09640153f, 0.06562471f, 0.04842637f, -0.01474304f, 0.08615225f, 0.11863904f, -0.00387541f, 0.03648628f, 
    0.14968964f, 0.14873053f, 0.05222061f, 0.11216831f, 0.14527823f, 0.37332460f, 0.02978412f, 0.00994684f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.02830547f, 0.00552761f, 0.01299679f, -0.05084734f, 0.04594279f, -0.04404415f, 0.03489484f, -0.05310600f, 
    0.15227187f, 0.09842056f, 0.07980487f, 0.03553885f, 0.10492275f, -0.04636176f, 0.23771320f, -0.03482105f, 
    0.01294960f, -0.02639028f, 0.00560674f, 0.01132280f, -0.06505635f, -0.25624347f, 0.21000077f, 0.18121609f, 
    0.03423667f, 0.02115674f, 0.16554542f, 0.02036310f, -0.04433008f, 0.02536245f, 0.07221221f, 0.06340576f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.00011018f, 0.13228546f, -0.03227359f, 0.05491109f, -0.00392673f, -0.01815472f, -0.16833770f, -0.09310114f, 
    0.11106028f, -0.08415687f, 0.15506928f, -0.08295317f, -0.18139358f, -0.01521098f, 0.27890685f, 0.16965970f, 
    0.89981896f, 0.02327340f, -0.09623360f, 0.10114119f, 0.01065121f, -0.04301145f, 0.25118268f, 0.24517617f, 
    0.59191310f, -0.11471240f, -0.22579150f, -0.12765509f, -0.16127932f, 0.05271351f, 0.02108910f, 0.23925033f, 
    -0.02472374f, 0.13036160f, 0.15108225f, -0.08931968f, 0.00944297f, -0.11497746f, -0.06163099f, -0.11601198f, 
    -0.15308253f, 0.43734333f, -0.08237704f, -0.05157609f, -0.10196131f, 0.06675687f, 0.22391528f, 0.04793371f, 
    -0.64422333f, 0.15914500f, 0.15482491f, 0.05856578f, -0.15572938f, 0.56828433f, -0.24309875f, -0.30062869f, 
    0.00232806f, 0.07781942f, 0.19268918f, 0.15099834f, -0.11252023f, -0.11681987f, 0.23166949f, -0.21869762f, 
    -0.00979752f, 0.07116226f, 0.03658768f, -0.07262494f, 0.11950434f, -0.14856943f, 0.40427646f, 0.13097656f, 
    0.03705296f, 0.18424776f, 0.02821200f, -0.12705302f, -0.31527793f, -0.05178876f, 0.19605242f, 0.14059082f, 
    0.53063029f, 0.00276827f, 0.04790528f, -0.14648187f, -0.07651515f, -0.37701809f, -0.45245019f, -0.07482101f, 
    0.35638443f, -0.31243905f, 0.03914085f, -0.12813428f, 0.10119146f, -0.14082839f, 0.26108494f, 0.03812600f, 
    -0.00875721f, 0.01567593f, -0.04376931f, -0.05988516f, 0.01165457f, -0.05190245f, -0.06923921f, 0.07026909f, 
    -0.02243131f, 0.11249617f, -0.06463261f, -0.17548461f, 0.02710626f, 0.04315904f, 0.03432148f, -0.01194312f, 
    -0.14779881f, -0.00963016f, 0.15323655f, -0.08324515f, -0.11218596f, -0.02163134f, 0.00839181f, -0.04964599f, 
    -0.19556348f, -0.08681142f, -0.15230885f, 0.12076704f, -0.17050549f, -0.15275973f, -0.13915886f, -0.01095203f, 
    -0.12327100f, -0.08990820f, -0.07404499f, 0.14905150f, 0.01686754f, 0.06468344f, -0.20028515f, 0.04963414f, 
    -0.09414356f, -0.38642231f, 0.11677185f, 0.00631151f, 0.00235929f, -0.14683792f, 0.05992024f, 0.01618341f, 
    0.45764196f, -0.06692154f, 0.11832628f, 0.14623523f, 0.05727394f, -0.35113627f, 0.15903497f, 0.32411265f, 
    -0.12607288f, -0.13657588f, -0.01288582f, 0.05292785f, 0.16501945f, -0.09468774f, 0.21150102f, 0.90136534f, 
    0.13219459f, -0.14899783f, 0.02288002f, 0.13128805f, 0.02605571f, -0.00489376f, 0.19642413f, 0.11411501f, 
    0.50047457f, 0.16423059f, 0.30805066f, -0.12732306f, 0.08507614f, -0.05962856f, 0.01019008f, 0.08190497f, 
    -0.15410234f, -0.14085835f, -0.00752359f, -0.07378916f, -0.02675607f, 0.44264227f, -0.01820525f, -0.22294635f, 
    -0.73089796f, 0.05012369f, 0.35915926f, 0.14434384f, 0.05984941f, 0.14644103f, -0.30789810f, 0.46772167f, 
    0.10628902f, -0.13876228f, -0.14561355f, 0.15751712f, -0.03534108f, 0.08310288f, 0.27967188f, -0.02106030f, 
    0.06728064f, 0.49531093f, -0.32597914f, 0.11074594f, 0.27099970f, 0.04804501f, 0.09454665f, -0.17553505f, 
    -0.64307529f, -0.03111044f, -0.10150154f, -0.02609480f, -0.06387229f, 0.27689260f, -0.43973136f, -0.10748105f, 
    0.26105192f, 0.19406679f, 0.15007052f, 0.04671850f, -0.13048713f, -0.14823063f, 0.23620926f, -0.24725989f, 
    0.06743768f, 0.02857917f, 0.12496500f, -0.16894396f, 0.04869529f, 0.16001752f, 0.30945504f, -0.12426264f, 
    0.38677666f, -0.06065805f, -0.13663626f, 0.14148495f, 0.10227340f, -0.14472809f, 0.16216053f, 0.13655357f, 
    -0.14927554f, -0.09175263f, 0.00970938f, 0.09626178f, 0.04989795f, -0.17944978f, -0.04788036f, 0.31104645f, 
    0.67523450f, -0.04989512f, -0.47240776f, 0.06409848f, -0.09778046f, -0.03296120f, 0.34577534f, -0.38016388f, 
    -0.07290293f, 0.10746533f, 0.05008605f, -0.06106212f, 0.09189097f, -0.02383922f, 0.12637335f, 0.16328290f, 
    -0.09833702f, -0.49263749f, -0.04575951f, 0.15497413f, 0.04055026f, -0.04867793f, -0.00010544f, 0.17009726f, 
    -0.05044368f, 0.15103900f, -0.00338623f, 0.00357820f, -0.00191440f, 0.86555600f, -0.32155156f, 0.14522520f, 
    -0.24808194f, 0.38637978f, 0.19518055f, -0.07002826f, -0.02578816f, 0.11008861f, -0.06259121f, 0.21200357f, 
    -0.01471622f, -0.00031083f, 0.06213683f, -0.14075838f, 0.17542477f, 0.09477527f, -0.41612804f, -0.07431634f, 
    0.53801632f, 0.43568528f, 0.57437176f, -0.01599991f, -0.09058063f, 0.16712283f, 0.17071925f, -0.14083388f, 
    -0.20057936f, -0.10865872f, -0.16984288f, -0.14143752f, 0.07384956f, 0.45194685f, 0.45037916f, 0.08891608f, 
    0.43860191f, -0.37319812f, -0.02308820f, 0.06457773f, -0.14837708f, -0.14426583f, 0.07657866f, -0.36573821f, 
    0.05678965f, -0.11090048f, -0.14295602f, -0.10532615f, 0.05173235f, -0.16399112f, 0.25635627f, 0.04402860f, 
    -0.70855397f, -0.24874732f, -0.41094941f, 0.04693366f, 0.24478227f, 0.08032378f, 0.00949927f, 0.02594081f, 
    0.67038459f, 0.10732269f, -0.01974132f, -0.08119202f, -0.04029861f, 0.34596610f, -0.16136105f, 0.32408136f, 
    0.12458257f, 0.76384860f, 0.03799203f, -0.17893256f, 0.17309970f, -0.08124658f, -0.05476262f, -0.21458673f, 
    0.14988427f, -0.13795283f, -0.12854348f, 0.03590220f, -0.05373997f, -0.02935901f, -0.15361388f, 0.01777170f, 
    0.09240709f, 0.01889249f, -0.14374714f, 0.01962627f, 0.01383702f, -0.01467347f, -0.13463689f, 0.13854775f, 
    -0.16852170f, -0.04093228f, 0.05220564f, 0.01357759f, 0.00399112f, -0.04159714f, 0.00873982f, 0.01901066f, 
    0.03269125f, 0.10489216f, -0.20367283f, -0.11255611f, 0.15574867f, -0.01224494f, -0.14208199f, -0.01287260f, 
    -0.05534315f, 0.01485533f, 0.03206792f, 0.12032358f, -0.02988323f, -0.10203633f, -0.03957441f, 0.02662474f, 
    -0.14994058f, -0.10916848f, -0.14970930f, 0.00168916f, -0.03836805f, 0.11690044f, -0.15290430f, -0.09835358f, 
    0.03447175f, 0.12076001f, 0.07765409f, -0.07023578f, -0.07200678f, -0.03654010f, -0.13982564f, 0.15602584f, 
    0.12450384f, 0.06169424f, -0.16479558f, 0.06705248f, -0.16960308f, -0.09956786f, 0.16847542f, -0.09184048f, 
    -0.01041402f, 0.00521377f, -0.12690541f, -0.03126247f, -0.03327011f, 0.02365570f, 0.04450488f, -0.03679679f, 
    0.27436301f, 0.07148929f, 0.56872439f, -0.02653197f, -0.23114355f, 0.08380038f, 0.04634488f, 0.11637028f, 
    -0.30559975f, 0.07379997f, -0.06044845f, -0.15114473f, -0.13358946f, -0.32675993f, 0.45650798f, -0.15452629f, 
    -0.13356222f, -0.41843221f, 0.24178371f, -0.05402423f, 0.00289677f, 0.07370031f, 0.32341817f, -0.14785312f, 
    -0.04995394f, -0.14604016f, 0.01536855f, 0.17083512f, 0.10040779f, 0.17372303f, -0.02837071f, -0.03333957f, 
    -0.14815983f, -0.03837079f, -0.18867084f, -0.15567876f, 0.05750222f, -0.07279555f, -0.01577120f, -0.03533872f, 
    0.02126635f, -0.02971595f, 0.08924781f, 0.15736704f, 0.05482401f, -0.06602577f, -0.05536486f, -0.03353713f, 
    -0.15453543f, -0.05012860f, -0.19792694f, 0.14403681f, 0.15182860f, 0.12996978f, -0.16816144f, -0.18499587f, 
    0.08360586f, 0.13435417f, 0.08284901f, -0.03831621f, 0.09945558f, -0.07927904f, -0.12632415f, 0.13427335f, 
    0.22301795f, 0.37843117f, 0.19944017f, 0.04535799f, -0.06796834f, -0.10742365f, 0.09696624f, 0.16931695f, 
    -0.17590110f, 0.12621814f, -0.14475410f, -0.08204178f, 0.13836417f, -0.33858386f, -0.31919408f, 0.46497443f, 
    0.30668402f, -0.07675077f, 0.54798514f, 0.12168967f, -0.10235828f, 0.16112719f, 0.03079973f, -0.42787164f, 
    -0.03954295f, 0.14992900f, -0.04919513f, 0.09294535f, 0.16496649f, -0.16614676f, -0.07698718f, -0.07733898f, 
    -0.15938087f, 0.16400613f, -0.08755899f, 0.14111717f, -0.14632261f, -0.03630996f, 0.00975383f, -0.06366514f, 
    0.03799349f, 0.03253843f, -0.04441590f, -0.04535842f, -0.06044523f, 0.04948598f, -0.05982720f, -0.14366086f, 
    0.14097010f, -0.14349268f, -0.17764176f, 0.03556001f, 0.10884928f, 0.07609401f, -0.10752505f, 0.11385092f, 
    0.16366948f, -0.15184709f, 0.09828613f, -0.16475214f, -0.07976969f, 0.07633740f, 0.39881185f, 0.03148807f, 
    -0.63565147f, 0.37408429f, 0.43096679f, 0.00307986f, 0.25864974f, 0.16610084f, -0.05101624f, -0.12005615f, 
    0.34070492f, 0.10712046f, -0.07410950f, -0.00574057f, 0.09194630f, -0.63423288f, 0.24898618f, -0.37830922f, 
    -0.34911454f, -0.16683434f, 0.29519871f, 0.06308929f, 0.13486347f, 0.15726097f, -0.04616933f, 0.48278651f, 
    0.01158613f, 0.07256430f, 0.08543614f, -0.11934995f, -0.09585345f, -0.03958160f, -0.39932954f, 0.13836868f, 
    -0.00638459f, -0.40823475f, -0.41241094f, 0.16598231f, 0.35557562f, 0.13172597f, 0.10139859f, 0.17598112f, 
    -0.34833914f, 0.08870750f, 0.08631774f, 0.09389555f, 0.02862329f, 0.21283622f, 0.37279859f, 0.31397223f, 
    -0.41654587f, 0.32467598f, -0.22728296f, -0.08955996f, -0.14970057f, -0.04625351f, 0.45490518f, 0.34725323f, 
    -0.08641788f, 0.14956516f, 0.08691423f, 0.08317081f, -0.00973624f, -0.17854507f, -0.38944647f, -0.12889011f, 
    -0.32023194f, 0.56395674f, -0.34053236f, -0.01143968f, 0.08364622f, 0.14257081f, 0.21618272f, -0.12931292f, 
    0.12057378f, 0.06843936f, 0.01659570f, 0.12968485f, 0.11186131f, 0.81639308f, -0.05597894f, 0.03726986f, 
    0.44702014f, 0.28984973f, -0.14230849f, 0.13129015f, 0.01380612f, 0.17722532f, 0.38839754f, -0.11714876f, 
    -0.15757036f, 0.05558587f, 0.15343280f, 0.07963001f, 0.08030782f, 0.06073778f, -0.01932949f, 0.03138213f, 
    -0.15385996f, -0.06440099f, 0.03481656f, 0.16521400f, -0.05701930f, -0.12634386f, 0.02391347f, 0.12610972f, 
    -0.04096965f, -0.14863028f, -0.11311226f, -0.02866352f, 0.07741339f, -0.05334598f, -0.18285711f, 0.08796313f, 
    -0.01723394f, 0.03321240f, -0.13315557f, -0.04210484f, 0.11204524f, 0.14533024f, -0.09375907f, 0.05839126f, 
    0.08620749f, 0.06893954f, -0.00934587f, 0.13513711f, 0.06627405f, -0.15735094f, 0.38170177f, -0.02585003f, 
    -0.25852242f, -0.14735864f, -0.21562299f, -0.05958743f, 0.34466296f, 0.07838141f, -0.25023791f, 0.05446602f, 
    -0.50880456f, -0.07047152f, -0.01794785f, 0.09337769f, 0.02399314f, -0.47963247f, -0.29840916f, -0.03124976f, 
    0.32606247f, 0.22085010f, 0.33683714f, 0.02814883f, -0.12286867f, -0.04302406f, 0.42633054f, 0.59677768f, 
    0.03162289f, 0.07309502f, -0.12458231f, -0.12129629f, -0.09761502f, -0.16396612f, 0.19539349f, 0.01392739f, 
    -0.07233103f, 0.34584084f, 0.18763873f, -0.16617201f, 0.00909411f, -0.05057974f, -0.02697851f, -0.06679168f, 
    -0.31933326f, -0.16719852f, -0.11924621f, -0.12278489f, 0.12305140f, -0.48903009f, 0.08511237f, -0.16127396f, 
    0.36670950f, -0.06729706f, 0.36137807f, 0.01541186f, 0.03978977f, -0.06906080f, -0.29345328f, 0.12897238f, 
    -0.14542906f, -0.02758223f, 0.13333936f, 0.14463164f, -0.11155438f, 0.05900763f, 0.02781561f, 0.13280705f, 
    0.24115092f, 0.00389125f, 0.32983142f, -0.10563776f, -0.00097751f, 0.07998121f, -0.32676095f, -0.16986388f, 
    -0.34847906f, -0.00222442f, 0.02420909f, -0.05291754f, 0.06085915f, 0.13951682f, -0.18208951f, 0.22859511f, 
    -0.44601765f, 0.23937109f, -0.01228532f, -0.14335302f, 0.09786540f, 0.01308958f, 0.28314123f, 0.11655383f, 
    0.05468941f, -0.06619961f, 0.11644264f, 0.04438055f, -0.10620009f, -0.17575511f, -0.19600290f, 0.13817060f, 
    -0.07544907f, 0.06423977f, -0.20300943f, -0.01087195f, -0.08706599f, -0.05939344f, 0.05319326f, 0.13015544f, 
    -0.19908708f, -0.02091150f, -0.10918172f, -0.12729783f, 0.14728230f, -0.16666293f, -0.04375182f, 0.05724936f, 
    0.11618812f, -0.03574649f, -0.20186308f, -0.16666113f, -0.05771649f, -0.12074652f, -0.17962898f, 0.06929293f, 
    0.00253089f, 0.17255123f, 0.12382987f, 0.04316737f, -0.07741602f, -0.03861717f, -0.00670004f, -0.16603033f, 
    0.02036278f, -0.12979789f, 0.04230548f, -0.05879767f, -0.07529923f, -0.08891309f, -0.14067225f, 0.05284188f, 
    -0.10448062f, -0.17328674f, 0.04451045f, 0.03910949f, 0.02582034f, -0.09188963f, -0.15282065f, 0.13729846f, 
    -0.06983634f, 0.00778037f, -0.04331680f, 0.16461770f, 0.08431473f, 0.10674295f, -0.18937932f, 0.05006178f, 
    -0.14267784f, 0.06394952f, -0.06446036f, -0.09074885f, 0.11844177f, 0.09302650f, 0.33451891f, -0.06587504f, 
    -0.40244117f, -0.37420377f, 0.37169409f, -0.00734927f, 0.21988054f, -0.02463303f, 0.04073719f, 0.04722601f, 
    0.09842240f, -0.09764960f, -0.14448869f, -0.00370103f, -0.08283546f, -0.18681401f, 0.36104345f, -0.62372226f, 
    0.12230421f, -0.10476627f, -0.19856703f, 0.09409229f, 0.04380012f, 0.02559601f, 0.21036562f, -0.07869305f, 
    -0.16116056f, 0.07699504f, 0.03108992f, 0.12231474f, -0.08620284f, -0.15794562f, 0.01839353f, -0.06416747f, 
    0.60160059f, -0.34492955f, -0.00484473f, -0.13289283f, 0.29436144f, 0.15311423f, 0.53223115f, -0.02307433f, 
    -0.60770589f, -0.02580670f, 0.09852878f, 0.10955185f, 0.13570091f, -0.18666467f, 0.40858203f, 0.20084879f, 
    -0.49894860f, -0.26644602f, -0.53872561f, -0.10674910f, 0.13869962f, 0.03473132f, 0.31403038f, -0.32902229f, 
    -0.09494656f, -0.14353642f, -0.16850480f, -0.06775834f, 0.13545385f, 0.16381276f, -0.13177058f, -0.14878039f, 
    0.24335420f, 0.64763445f, 0.42456427f, -0.01140517f, -0.22284476f, -0.04145261f, -0.12085550f, 0.00097593f, 
    0.30647117f, -0.10970803f, 0.06724703f, -0.07945915f, 0.03116250f, 0.34610260f, -0.29549256f, -0.07716037f, 
    0.61129963f, -0.32753640f, 0.45797727f, 0.10095186f, -0.12776685f, -0.11782344f, 0.20280899f, -0.06656990f, 
    -0.11762572f, 0.00828551f, 0.00138304f, 0.15817609f, -0.01936018f, -0.14827667f, 0.44916785f, -0.08045481f, 
    0.36966485f, 0.52344942f, -0.14406157f, 0.02984423f, -0.16795799f, -0.05578818f, 0.43184900f, -0.07945400f, 
    0.38908610f, -0.17355961f, -0.12510099f, -0.12322527f, 0.17915890f, 0.28923342f, 0.07833267f, 0.23355666f, 
    0.19588964f, 0.00068315f, 0.05117078f, 0.04749955f, -0.11006380f, 0.06831605f, -0.34310493f, -0.55291849f, 
    -0.14563255f, 0.03548751f, 0.13700843f, -0.07619378f, 0.17193386f, 0.10875493f, 0.11071024f, -0.14864759f, 
    -0.28637546f, -0.39396966f, -0.31103739f, 0.09071278f, 0.36614409f, -0.05963415f, 0.05686970f, 0.02931810f, 
    -0.26753494f, -0.10620949f, -0.10199297f, -0.15344286f, -0.02874498f, 0.21132995f, 0.12964301f, 0.32487381f, 
    -0.61736768f, 0.72523272f, 0.48296747f, 0.00466072f, -0.10622921f, -0.03277156f, -0.18867265f, -0.07040261f, 
    -0.00184953f, -0.13213563f, -0.11537324f, 0.09401393f, -0.11792642f, 0.01357871f, -0.12742946f, -0.08460636f, 
    -0.14671774f, 0.15192485f, -0.14610958f, 0.15793145f, -0.12813339f, -0.02334351f, -0.11350613f, -0.00192056f, 
    0.08486658f, 0.16407973f, 0.12374812f, -0.01040046f, -0.11210760f, 0.15272978f, -0.11468184f, 0.17690156f, 
    -0.01366211f, -0.11792395f, -0.01030893f, 0.10168236f, 0.07017276f, 0.11101005f, -0.15903594f, -0.10829469f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.11285903f, 0.01254955f, -0.04152882f, -0.13793060f, -0.00115914f, 0.21193175f, -0.12798527f, -0.01824329f, 
    -0.32082173f, 0.04009118f, 0.19668612f, -0.10395790f, 0.10082593f, 0.25952446f, -0.03452781f, 0.09336310f, 
    0.14405090f, 0.28964406f, 0.03306906f, -0.16200347f, 0.01259327f, 0.25527453f, 0.50762999f, -0.18219526f, 
    -0.12695116f, -0.00269233f, -0.08875648f, 0.38443559f, -0.21435042f, 0.11643647f, 0.29611346f, -0.09903570f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.30740386f, 0.55958122f, 0.30235532f, -0.13197099f, -0.25899664f, -0.90371114f, 0.53640538f, 0.10495538f, 
    -0.51026320f, -0.27580160f, 0.09859064f, 0.01502613f, 0.03691497f, -0.05228003f, -0.17944682f, 0.05375279f, 
    -0.05392575f, -0.06289076f, 0.20390844f, 0.62567616f, 0.07235349f, 0.35772610f, -0.29067975f, -0.04368298f, 
    -0.17038445f, -0.00104447f, -0.17085309f, -0.18125094f, 0.10985973f, -0.30165890f, -0.29568112f, 0.01243199f, 
    0.23379707f, -0.28385171f, 0.21740115f, -0.12192822f, -0.18771510f, -0.38427398f, 0.10152888f, 0.23933616f, 
    0.08215079f, 0.38814291f, -0.12327635f, -0.15112427f, -0.04790403f, 0.01471797f, 0.11991621f, 0.35137558f, 
    0.02662724f, -0.37092328f, -0.68879873f, 0.03871096f, 0.07136585f, -0.09266857f, 0.28492406f, -0.30146232f, 
    0.14804029f, -0.18476392f, -0.48666275f, -0.35836336f, 0.61022621f, 0.19840938f, -0.58609831f, 0.04333589f, 
    -0.12771727f, -0.24983931f, 0.48707977f, 0.07841156f, -0.22092602f, -0.10283742f, 0.17362425f, 0.48726588f, 
    -0.42370149f, -0.81523418f, 0.21520148f, -0.16977249f, -0.07539493f, -0.08913301f, -0.07960966f, -0.34803537f, 
    0.09897933f, 0.15941665f, -0.74756181f, -1.02843273f, 0.09748910f, 0.17190452f, 0.06932175f, 0.04464068f, 
    -0.01285544f, -0.14742211f, 0.43649966f, 0.26060787f, -0.66824234f, 0.61568022f, -0.18942720f, 0.06996745f, 
    -0.12231758f, -0.62383825f, -0.35422966f, 0.09463795f, 0.28149217f, 0.36928988f, 0.16359524f, -0.70275003f, 
    0.34743711f, -0.74747360f, 0.03376939f, -0.01215853f, -0.07264585f, -0.67895222f, -0.06829648f, -0.48318601f, 
    -0.01677699f, 0.07713286f, 0.43501857f, -0.04082322f, -0.03268346f, 0.45043388f, -0.05555064f, 0.47658154f, 
    0.13877285f, -0.01477932f, -0.69827729f, -0.40360114f, -0.17567945f, -0.88341653f, 0.04038883f, 0.17698275f, 
    -0.01500264f, -0.35843366f, -0.36093485f, 0.12071037f, -0.02734873f, -0.37309310f, 0.03417614f, -0.05946232f, 
    -0.02111094f, -0.32709101f, 0.54723775f, 0.07057746f, -0.13302846f, -0.50049055f, -0.09114551f, 0.31078538f, 
    0.13108644f, -0.12648502f, 0.29251176f, 0.00847066f, 0.04895253f, -0.11815178f, -0.24367790f, -0.12979612f, 
    -0.00025787f, 0.08046459f, -0.53287244f, 0.12854673f, -0.66654205f, 0.06525183f, 0.40705591f, 0.05041672f, 
    -0.30650911f, 0.83097625f, -0.29515427f, -0.01588361f, -0.50787932f, 0.33933184f, 0.24793915f, -0.10309435f, 
    0.29487428f, 0.40343788f, -0.93690896f, 0.17512797f, -0.09911039f, 0.21545187f, -0.02420066f, 0.17156450f, 
    0.06892263f, 0.08726739f, -0.35676178f, -0.10229815f, -0.04738884f, -0.40405566f, 0.18099213f, 0.03706786f, 
    0.16277799f, -0.02169784f, 0.05035289f, 0.36431655f, 0.16565475f, 0.38140678f, -0.33782408f, -0.13348554f, 
    -0.14743260f, -0.48356476f, -0.23078527f, -0.13317165f, 0.14258794f, -0.03964821f, -0.04124893f, 0.23112243f, 
    -1.10619354f, 0.28662995f, -0.95854217f, -0.05120862f, 0.02319238f, 0.41212609f, 0.14960203f, 0.01831036f, 
    0.00262495f, -0.49010286f, 0.52385032f, -0.19052701f, -0.02663978f, 0.03855173f, -0.34708175f, 0.33803669f, 
    0.15577975f, 0.15340777f, -0.41728100f, 0.56961840f, -0.24751846f, -0.41254264f, -0.22460487f, -0.05267507f, 
    -0.34937629f, 0.08105195f, -0.11753189f, -0.07986282f, -0.55372816f, 0.30046642f, 0.27068964f, -0.30847082f, 
    0.64396012f, 0.00393138f, 0.44391096f, -0.15960841f, -0.11984347f, -0.39946905f, 0.09627701f, -0.50311142f, 
    -0.13746513f, -0.46311849f, -0.05690454f, 0.40482402f, -0.11217818f, -0.19335021f, -1.24286485f, 0.06558778f, 
    0.11691392f, -0.05068959f, -0.20850042f, -0.70165682f, 0.21375707f, 0.02224194f, 0.24760151f, -0.02683965f, 
    0.46193984f, -0.55804616f, 0.57534868f, 0.08768133f, 0.43090975f, -0.07873289f, -0.74851513f, -0.35847163f, 
    -0.03521381f, -0.07746635f, -0.06639901f, -0.10513902f, -0.18754826f, 0.05330034f, -0.05168938f, 0.04777277f, 
    0.01928277f, 0.41589817f, -0.62536049f, -0.21719381f, -0.13855109f, -0.49418038f, -0.40194452f, 0.18732487f, 
    0.03538158f, 0.06422822f, 0.00683199f, -0.54439378f, 0.56396514f, 0.06374546f, -0.84598607f, -0.10714518f, 
    0.40707603f, -0.33531886f, -0.48876113f, -0.10444918f, 0.13639449f, -0.09690536f, -0.62803566f, -0.11331128f, 
    0.04732420f, 0.27067751f, -0.02832567f, -0.04762921f, 0.19840968f, 0.10132585f, 0.01725229f, -0.42896241f, 
    0.08288312f, 0.01802031f, 0.27037519f, 0.25665492f, 0.14527841f, -0.68351471f, -0.18207030f, -1.29335570f, 
    0.06372387f, -0.08683894f, 0.05043991f, 0.25950330f, -0.48111251f, 0.13260281f, -0.04051683f, -0.13107839f, 
    -0.47784421f, -0.17929660f, 0.16101341f, 0.04334611f, -0.06180311f, 0.41971123f, -0.09657682f, -0.93789703f, 
    -0.12737001f, -0.42929336f, -0.13779935f, 0.17526390f, -0.12771410f, 0.42863387f, -0.07618472f, 0.36012411f, 
    -0.14101985f, 0.37747312f, -0.47577998f, -0.97991240f, 0.05827707f, 0.31076333f, 0.62133336f, -0.13164698f, 
    -0.04701400f, 0.05553581f, -0.41081437f, -0.73867708f, 0.14484671f, -0.02028673f, 0.31427705f, 0.16749348f, 
    -0.16342875f, -0.44445306f, -0.49753642f, 0.14834194f, 0.08567529f, -0.20582998f, -0.10158670f, -0.07724064f, 
    -0.32470101f, -0.11086927f, -0.11016061f, 0.06909183f, 0.03317548f, 0.16210489f, -0.14245734f, -0.41146976f, 
    0.07011632f, 0.44061312f, 0.13688773f, -0.27729097f, 0.03917462f, 0.41053864f, 0.07279909f, 0.17645240f, 
    -0.02701898f, -0.08437290f, 0.83197862f, 0.21566403f, -0.21452852f, -1.13228977f, -0.15670170f, -0.14213799f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.09628803f, -0.04343627f, -0.14314364f, 0.20475134f, 0.10927860f, -0.09226845f, 0.09476954f, -0.47065255f, 
    -0.25374973f, 0.05487843f, 0.17637447f, 0.15119906f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
