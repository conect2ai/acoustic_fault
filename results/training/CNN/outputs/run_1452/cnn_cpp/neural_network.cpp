#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    1.05151117f, -1.10212815f, 0.03789783f, -0.19599284f, -0.19128725f, 0.35302660f, -0.22673672f, 0.10267104f, 
    -0.10914988f, -0.42344853f, 1.17341304f, -0.71418047f, -0.48844311f, 0.32581916f, 0.10781638f, -0.13331498f, 
    -0.15163808f, 0.36720353f, -0.62605631f, -0.36367023f, -0.66980571f, 0.21584938f, 0.28956547f, 0.64260030f, 
    0.24851836f, 0.13993573f, 0.24188681f, -0.81447607f, -0.73958409f, 0.17915741f, 0.00218030f, 0.12790985f, 
    -0.44600010f, 0.16121815f, 0.08806624f, -0.02214637f, 0.57528949f, 0.40786153f, -0.08743925f, 0.08814625f, 
    0.16747059f, 0.35420319f, -0.09233092f, -0.56036931f, -0.37953901f, 0.53110266f, -0.23166482f, 0.55359310f, 
    0.19111574f, 0.14990757f, 0.07057120f, 0.07132934f, 0.48583841f, -0.09855021f, 0.67160809f, 0.39116830f, 
    0.51626873f, 0.29298529f, -0.65672737f, 0.18205571f, 0.31159654f, -0.04323259f, -0.40733981f, -0.55335397f, 
    -0.41440824f, -0.28690860f, -0.26097625f, -0.20782310f, -0.53626895f, -0.16131069f, -0.35387704f, -0.35603541f, 
    -0.15501820f, -0.27674252f, 0.51612848f, 0.43502975f, 0.04528493f, -0.25667170f, 0.31673193f, 0.21060316f, 
    0.53297460f, 0.07990261f, 1.04531157f, -0.67474777f, 0.26478797f, -0.15854183f, -0.04306553f, -0.03746919f, 
    0.20744926f, -0.05741200f, 0.36502481f, -0.66267824f, 0.73198938f, -0.23911785f, -0.31171414f, -0.27985752f, 
    0.62801850f, -0.33566672f, 0.35708979f, -0.51023394f, -0.11964096f, 0.32091740f, -0.64156431f, -0.54937762f, 
    1.07667768f, -0.18945658f, 0.21122658f, 0.42347232f, 0.24340624f, -0.05635023f, -0.56784225f, -0.39723027f, 
    -0.63540584f, -0.22359978f, -0.26668453f, -0.41164583f, -0.12995547f, 0.68393999f, -0.05303583f, -0.71622837f, 
    -0.14511696f, -0.29146412f, -0.07246603f, 0.02071636f, 0.51714778f, 0.57609612f, 0.19213171f, 0.18457796f, 
    0.20806189f, -0.14035341f, 0.35214344f, 0.43955934f, -0.29941228f, -0.42384729f, 0.73603600f, 0.27851099f, 
    -0.04948144f, 0.44130605f, 0.49740326f, 0.41142434f, 0.16861480f, 0.35032412f, -0.29407081f, 0.17507678f, 
    0.53507203f, -0.48019204f, -0.68062615f, 0.92129284f, -0.01081445f, -0.16763420f, -0.35128531f, -0.18131350f, 
    -0.19285397f, 0.00512199f, -0.31391457f, -0.30526689f, -0.28750581f, -0.33388042f, -0.52009207f, 0.09582224f, 
    0.45341757f, 0.42023024f, 0.58879328f, 0.35790190f, -0.29565907f, 0.53180224f, -0.01931159f, -0.62114388f, 
    0.31351420f, -0.46269953f, 0.49820989f, 0.95693964f, -0.60526568f, 0.27987584f, 0.14007583f, 0.45066243f, 
    -0.14586572f, 0.14530653f, 0.15351026f, 0.20138919f, -0.82386243f, 0.54008770f, 0.66598570f, 0.16557544f, 
    0.13248706f, 0.22255163f, -0.50418299f, -0.19720039f, -0.49139473f, -0.09980465f, -0.60468334f, -0.60140520f, 
    0.62593818f, 0.59684724f, 0.48563588f, -0.10534935f, 0.30538672f, -0.76446605f, 0.19612865f, 0.63098234f, 
    0.67252296f, -0.03570343f, -0.59554273f, -0.32771948f, -0.18409735f, -0.26171440f, -0.02728558f, -0.52071273f, 
    -0.28550315f, -0.29597980f, -0.28116369f, -0.04310642f, 0.08723797f, 0.32996720f, 0.35897291f, 0.43274412f, 
    0.47421148f, 0.29532522f, -0.55176491f, -0.28447592f, 0.27309594f, -0.35742798f, 0.53551888f, 0.36589172f, 
    0.28199416f, -0.09449755f, 0.62736887f, -0.89998978f, -0.48350513f, 0.37497646f, -0.44088435f, -0.19331831f, 
    -0.25682893f, -0.65691048f, 0.01755599f, 0.16117573f, 0.18773527f, -0.14552626f, -0.96592075f, -0.61958688f, 
    -0.27875176f, 0.25256318f, -0.28293443f, -0.09330870f, 0.31944799f, -0.22884551f, 0.58855313f, -0.68838608f, 
    -0.78541279f, 0.12764810f, 0.17512409f, -0.17062961f, 0.00558513f, 0.16745174f, 0.21091010f, -0.19145553f, 
    -0.47388369f, -0.58849990f, 0.57606280f, 0.55322140f, 0.58540356f, -0.79630762f, 0.01987491f, 0.80911589f, 
    0.45038456f, -0.29042226f, -0.51100767f, -0.21303943f, 0.71427405f, -0.31913030f, 0.26902366f, 0.27251700f, 
    0.46500048f, -0.63240463f, 0.43496725f, -0.42487663f, -0.08635896f, 0.36863884f, -0.17711893f, -0.38518003f, 
    -0.24049756f, -0.03137640f, 0.82079786f, -0.21702939f, 0.04120317f, -0.14870192f, -0.34861603f, -0.18444213f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.08229785f, -0.08143307f, 0.24165064f, -0.05562948f, -0.03113705f, -0.01854731f, 0.10587594f, -0.46829826f, 
    0.01106980f, 0.39277714f, -0.18848443f, -0.17462875f, -0.11304099f, -0.16270930f, -0.17150618f, -0.39368820f, 
    -0.19581114f, 0.06475017f, -0.15521577f, 0.12830618f, -0.04920873f, 0.10873684f, -0.03197199f, 0.28400105f, 
    -0.07387457f, -0.36464921f, 0.04935901f, 0.26012811f, -0.14784680f, -0.12289820f, 0.03709216f, 0.13558470f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.36059061f, -0.08347979f, -0.36753356f, -0.00422442f, 0.21192344f, 0.04604647f, 0.38624370f, 0.05520016f, 
    -0.00578991f, 0.35693088f, 0.01877967f, -0.35868174f, -0.11710428f, 0.20766185f, -0.19999260f, 0.03548809f, 
    -0.06463255f, 0.16981460f, 0.21653016f, 0.20322065f, 0.15217949f, -0.17520757f, -0.22364978f, -0.16371922f, 
    -0.03781952f, 0.11625943f, 0.13906394f, 0.23700285f, 0.22276093f, 0.15785773f, -0.08912773f, -0.09860310f, 
    -0.14262579f, -0.16414765f, -0.09574299f, 0.10311774f, -0.07891171f, 0.02778520f, 0.06185676f, -0.07995693f, 
    0.03130426f, -0.08620162f, 0.17848893f, 0.01526533f, -0.01253757f, -0.04865848f, 0.01557537f, 0.01425847f, 
    0.19841267f, -0.06970642f, -0.14623590f, 0.17812048f, -0.04842578f, 0.06065645f, -0.41074306f, -0.10124207f, 
    0.16449574f, 0.08400714f, 0.08004902f, 0.00778481f, 0.01981669f, -0.14038211f, -0.06925255f, 0.16770259f, 
    0.28286055f, 0.20614706f, -0.30147412f, -0.20883060f, -0.03902885f, 0.09308805f, 0.02412755f, -0.06689170f, 
    0.00155923f, -0.05348958f, -0.00364316f, -0.02371972f, -0.14163414f, -0.14798234f, 0.16935691f, 0.10256167f, 
    0.27731386f, -0.04360608f, -0.13640796f, -0.22058266f, -0.00373017f, 0.12779750f, -0.05582844f, 0.04553163f, 
    0.07131159f, 0.11361125f, -0.11123062f, -0.07090742f, -0.11341666f, -0.04445237f, 0.23510447f, 0.07041220f, 
    -0.08640685f, -0.03647117f, 0.05708238f, 0.09063831f, -0.01601629f, 0.04209906f, -0.09521999f, 0.04780123f, 
    -0.03497386f, -0.02019097f, 0.01874633f, 0.17136917f, 0.07486379f, 0.28767681f, 0.22637987f, -0.10413730f, 
    -0.10395980f, -0.01037220f, 0.10159836f, 0.10545085f, 0.10313261f, -0.02497517f, 0.15539397f, -0.13105072f, 
    -0.12614968f, -0.01990920f, 0.21026237f, 0.10699291f, 0.20806289f, 0.05063920f, 0.06532365f, 0.07265189f, 
    0.11604924f, -0.16774043f, 0.03737001f, -0.13410428f, -0.04949813f, 0.06582598f, 0.17000119f, -0.16209751f, 
    0.22546165f, 0.11867196f, -0.02546991f, -0.17780945f, -0.22209452f, 0.10464209f, -0.13144100f, 0.03100574f, 
    -0.32506934f, -0.12472222f, -0.18847521f, 0.00016249f, 0.09833581f, 0.14370042f, -0.14918604f, -0.01547850f, 
    -0.12912333f, 0.15010957f, 0.24556661f, 0.00403144f, -0.02218776f, -0.03532861f, 0.01167995f, 0.00599254f, 
    0.10557895f, 0.15240254f, -0.32414022f, 0.27557287f, -0.08770214f, -0.00495046f, -0.04235237f, -0.05956597f, 
    0.12286597f, 0.06014895f, 0.01503029f, -0.35329181f, -0.01555834f, -0.22523485f, 0.15261295f, 0.06816718f, 
    -0.07880919f, 0.25726220f, -0.05124214f, 0.05411314f, 0.01493705f, -0.22152884f, 0.13416591f, -0.04300192f, 
    -0.06062659f, -0.08946143f, 0.02229987f, -0.19590682f, 0.06809531f, 0.39535069f, 0.20857999f, 0.18628111f, 
    -0.27473933f, -0.16806163f, -0.08131333f, 0.10620414f, -0.08682259f, -0.06004043f, -0.21927592f, -0.28950700f, 
    0.23855796f, 0.07672231f, -0.02047122f, 0.01158568f, -0.01202379f, -0.00992923f, -0.03916581f, 0.18817410f, 
    0.02195159f, -0.03808630f, -0.09181386f, -0.09025697f, 0.02112507f, 0.04495814f, 0.08263975f, 0.15706228f, 
    -0.08938438f, 0.07477064f, -0.30524015f, -0.09122879f, -0.02981685f, 0.03346334f, 0.22749764f, 0.09462171f, 
    -0.00665940f, 0.02084449f, -0.19181682f, -0.23258542f, -0.16749822f, -0.18903293f, -0.09064994f, 0.11309575f, 
    -0.02168710f, 0.05768564f, 0.10151125f, -0.01183761f, 0.13192406f, -0.03934262f, -0.13134010f, -0.02153948f, 
    0.00432489f, 0.00874318f, -0.03761117f, -0.04962467f, 0.03980539f, 0.03884765f, 0.10557995f, -0.09309340f, 
    -0.08536729f, 0.01822474f, 0.07835105f, 0.13448365f, -0.05420670f, 0.01255994f, 0.34027433f, -0.04972552f, 
    -0.10285755f, 0.01144262f, -0.03317277f, -0.03616646f, 0.13702060f, -0.02042208f, 0.17576042f, -0.13715543f, 
    0.11492494f, -0.27374512f, 0.01724575f, 0.08601886f, 0.11010104f, 0.02685387f, -0.13698308f, -0.30574095f, 
    -0.00500373f, 0.14379704f, 0.06806237f, 0.08902917f, -0.03165762f, -0.04604745f, -0.06842484f, 0.10833384f, 
    0.09865751f, 0.12057513f, -0.11442920f, -0.04048767f, 0.03322066f, -0.02672209f, -0.03991929f, -0.12353992f, 
    0.17794232f, -0.06951753f, 0.55832338f, -0.04848583f, 0.19403207f, 0.29039735f, 0.10797057f, 0.06954458f, 
    -0.08020878f, 0.11205517f, 0.44310695f, 0.21468708f, 0.02013985f, 0.26404873f, 0.08993826f, 0.05786938f, 
    0.14842775f, -0.05476846f, -0.19794063f, -0.01769585f, -0.17986232f, -0.04433970f, -0.04585601f, 0.06468284f, 
    -0.15166512f, 0.09159257f, 0.18857004f, -0.23734970f, -0.09195158f, 0.01132458f, 0.11350569f, -0.08903994f, 
    -0.14861110f, -0.01170614f, 0.05450335f, 0.12402492f, 0.10020047f, -0.00245054f, 0.03863683f, 0.01507394f, 
    -0.02867697f, -0.13448209f, 0.10610303f, -0.12736011f, 0.13583580f, 0.16997983f, -0.01925194f, 0.13090616f, 
    0.05836676f, 0.05511991f, 0.10132387f, -0.09434991f, -0.09866206f, -0.08665445f, 0.37420428f, 0.21616139f, 
    0.31712505f, -0.04094324f, -0.08204148f, -0.25401878f, -0.02622519f, -0.15503387f, 0.01224952f, -0.07292078f, 
    -0.17721711f, 0.06507391f, 0.06587656f, -0.06281322f, 0.04176113f, 0.03227094f, -0.06085563f, 0.18348962f, 
    -0.03372523f, 0.06956015f, -0.01795114f, -0.00259546f, -0.05717419f, 0.12389933f, -0.34553209f, -0.11478895f, 
    -0.11179194f, 0.26637647f, 0.26132029f, 0.11322228f, 0.08374777f, 0.11511880f, 0.06537312f, 0.06425150f, 
    0.11125617f, -0.04572290f, -0.07702474f, -0.02157481f, 0.24084798f, 0.21837755f, -0.27962738f, 0.15083581f, 
    -0.39313540f, -0.23906368f, 0.04576012f, -0.20292930f, 0.30851358f, 0.14381514f, 0.11181275f, 0.11975505f, 
    -0.13377392f, -0.09002478f, 0.06223912f, -0.13218401f, 0.25592089f, -0.01441807f, 0.23527208f, 0.19135584f, 
    -0.05028466f, 0.06790851f, 0.09391861f, -0.02869441f, 0.03701106f, -0.06627716f, -0.06748518f, 0.10191596f, 
    -0.19934779f, -0.02488457f, -0.03626440f, -0.26305297f, -0.00649635f, -0.16531377f, -0.02051807f, -0.04622480f, 
    0.18922697f, 0.03157747f, -0.05329993f, 0.07835615f, 0.09978171f, -0.14623137f, -0.07443889f, 0.07568461f, 
    0.03543747f, 0.28615305f, 0.07265332f, 0.01319267f, -0.00693780f, 0.00492637f, -0.06012435f, -0.05183040f, 
    -0.03016377f, -0.23744859f, 0.16406512f, 0.12873943f, 0.00609905f, 0.12050214f, -0.03070030f, -0.01742320f, 
    0.18083274f, -0.12629879f, -0.13251267f, -0.08474632f, -0.00360564f, -0.13574187f, -0.10996519f, 0.05218574f, 
    -0.10797978f, 0.03274338f, 0.26513854f, 0.25987825f, 0.34845993f, -0.17056696f, -0.11528482f, 0.07384556f, 
    -0.08614251f, 0.07885931f, -0.15473787f, 0.09969208f, 0.01614908f, 0.10775757f, -0.07282156f, -0.01045158f, 
    0.10958771f, 0.05301517f, -0.12379286f, -0.14833879f, -0.57752341f, 0.28934023f, 0.12918243f, -0.10552725f, 
    -0.04538981f, 0.11667687f, -0.11247818f, 0.09309134f, 0.01548253f, -0.15108141f, -0.13696823f, -0.16701061f, 
    0.06316424f, 0.08811987f, 0.11833575f, -0.04399566f, -0.12012599f, 0.16553156f, 0.42752334f, 0.37297693f, 
    0.37327513f, -0.13156456f, -0.08826827f, -0.08332127f, -0.05094460f, 0.14448501f, -0.07099743f, -0.14434303f, 
    -0.15692155f, -0.09602238f, 0.04391318f, -0.05045040f, -0.00040889f, -0.08911027f, 0.01073211f, 0.00640256f, 
    0.01044005f, 0.09526559f, -0.11333974f, -0.04279684f, -0.10152544f, 0.09087494f, -0.00134594f, -0.11181458f, 
    -0.00692245f, 0.29862159f, 0.27793607f, 0.19723792f, 0.10690472f, 0.05405398f, 0.08878439f, 0.20030390f, 
    0.04822868f, -0.01622893f, 0.17130992f, 0.08484823f, 0.33494610f, 0.11199661f, -0.08704224f, -0.08166997f, 
    0.08456629f, -0.09975795f, 0.04040614f, -0.01546663f, -0.05231922f, 0.22207598f, 0.09616957f, -0.04246937f, 
    0.00664506f, 0.09035768f, 0.01955991f, 0.15449019f, -0.02982404f, 0.05026091f, -0.08026361f, -0.10947217f, 
    -0.23408708f, -0.21904713f, -0.27566248f, -0.15354091f, -0.08151361f, -0.26852444f, 0.26384124f, 0.11339058f, 
    0.20426773f, 0.00665829f, 0.16788761f, 0.05152986f, 0.04496334f, 0.32196525f, 0.19717194f, 0.30755812f, 
    0.19832927f, -0.08993167f, -0.02107101f, -0.09562581f, -0.03862055f, -0.03623463f, 0.02224447f, -0.06798144f, 
    -0.05135595f, 0.05428446f, 0.05023470f, 0.02751829f, 0.05252963f, 0.04957073f, -0.02922152f, 0.16856523f, 
    0.22068147f, -0.00957087f, 0.22640316f, 0.13525008f, 0.21743685f, 0.21068272f, -0.27647302f, 0.02682656f, 
    0.13315400f, 0.10089503f, 0.16589807f, 0.46984670f, 0.26878533f, 0.05276503f, 0.16943857f, -0.13134913f, 
    -0.01406616f, -0.04605834f, -0.20787054f, 0.15472250f, 0.04335630f, 0.11368500f, 0.09683757f, -0.13950361f, 
    -0.00065383f, 0.00050911f, -0.03900432f, -0.36079624f, -0.07611106f, 0.13575453f, -0.01358686f, 0.01581208f, 
    -0.15717037f, -0.07053152f, 0.03055878f, -0.05840651f, -0.20829189f, -0.10500824f, -0.10520673f, -0.02752895f, 
    -0.14946346f, -0.00129201f, -0.02641693f, -0.36304802f, -0.03272748f, 0.01435901f, 0.03953409f, 0.01737079f, 
    0.04921496f, 0.12975834f, 0.00709259f, -0.13196395f, -0.15024836f, 0.01505484f, -0.15200664f, -0.03837763f, 
    -0.02187091f, 0.08669730f, -0.03531862f, -0.00082451f, -0.14392309f, 0.13786548f, -0.06398474f, -0.34409028f, 
    -0.37293446f, -0.04554536f, 0.09379270f, 0.12772894f, 0.01045263f, -0.06352165f, -0.02825110f, 0.02619471f, 
    -0.07608271f, 0.08631429f, 0.07208890f, 0.03589925f, 0.18968132f, 0.00732805f, -0.28021860f, 0.01659639f, 
    0.14139655f, 0.14582314f, -0.05759402f, 0.26540712f, 0.20835848f, 0.10416090f, 0.10112041f, -0.11908159f, 
    0.14038347f, -0.11269052f, -0.20929745f, 0.12821338f, 0.13037075f, -0.15026012f, 0.23367834f, -0.06412065f, 
    -0.05659629f, 0.14128520f, 0.05871991f, 0.32369253f, 0.08046073f, 0.31654912f, 0.30892137f, 0.12666133f, 
    0.18288283f, 0.07389238f, 0.07195968f, -0.11067534f, -0.09215107f, -0.24301466f, -0.21096893f, 0.04508368f, 
    0.05920272f, 0.10083424f, -0.00881666f, 0.02899365f, 0.04238826f, 0.15570851f, -0.08498429f, -0.00914261f, 
    0.08120283f, -0.01661143f, 0.10829901f, 0.13784368f, -0.02502823f, 0.12629277f, -0.03412073f, 0.05362106f, 
    -0.03562367f, 0.00907471f, -0.00897653f, -0.06019495f, -0.03616131f, -0.01326235f, 0.06224145f, 0.00390349f, 
    -0.06014572f, -0.02939058f, -0.01524103f, 0.14641228f, 0.04587600f, -0.02629538f, -0.10197157f, 0.06792219f, 
    -0.04680885f, 0.08586589f, 0.28065595f, -0.15598933f, -0.04325245f, -0.06772154f, 0.00050928f, -0.02410570f, 
    -0.33858541f, 0.05091044f, -0.03972127f, -0.01669616f, -0.02336225f, -0.19985722f, -0.10608321f, 0.09194347f, 
    0.04813289f, 0.01278946f, -0.09677266f, 0.20669086f, -0.05171485f, 0.00086759f, 0.14479737f, -0.05744400f, 
    -0.10422907f, 0.05454019f, 0.14523810f, 0.04110751f, 0.05930332f, 0.01098906f, -0.05691393f, 0.11925332f, 
    0.17352550f, -0.28073460f, -0.02022257f, 0.13532008f, -0.18660073f, 0.02274026f, -0.08647401f, 0.07876863f, 
    -0.10375746f, 0.03599423f, 0.03123949f, -0.18964940f, -0.06289193f, -0.00811864f, -0.11952781f, -0.00666657f, 
    0.06760757f, 0.06477138f, 0.04643069f, -0.06639457f, -0.11775581f, -0.16120046f, -0.14376585f, -0.10889132f, 
    0.04337565f, 0.12213936f, 0.05887285f, -0.04497550f, -0.02862623f, -0.14806609f, -0.26046842f, -0.18796094f, 
    0.02629931f, -0.00349173f, 0.02067676f, -0.15267976f, -0.17547867f, -0.00487012f, 0.12470064f, 0.14272679f, 
    0.10235711f, -0.00441749f, -0.02533065f, 0.04815470f, -0.08707500f, 0.02578049f, 0.03460391f, 0.01909075f, 
    0.13977225f, -0.09594217f, 0.11859014f, -0.04858864f, 0.26630515f, 0.08175859f, 0.00389686f, -0.19209768f, 
    0.00815887f, 0.01742120f, 0.03243595f, -0.07824663f, -0.02097621f, -0.09860943f, 0.07612083f, 0.05767783f, 
    0.13400932f, 0.12739539f, 0.07198616f, 0.04456715f, 0.11738364f, 0.12901407f, -0.03219772f, -0.00120255f, 
    0.13203460f, 0.14541176f, 0.10981056f, -0.10016271f, 0.16889326f, 0.00940536f, -0.13538681f, -0.04395465f, 
    0.22965261f, -0.11148106f, 0.12555312f, 0.05353154f, 0.14183713f, -0.10314138f, -0.00247896f, 0.34189421f, 
    -0.17618152f, 0.13880837f, 0.06916323f, -0.20953904f, -0.04041449f, 0.08974545f, 0.15925522f, 0.04473818f, 
    -0.03276303f, 0.08534894f, 0.17731373f, -0.11912897f, 0.03293693f, -0.06661410f, 0.09941517f, 0.07026293f, 
    0.02864570f, -0.01095229f, -0.01757266f, -0.03056202f, -0.04421088f, -0.01947473f, -0.17650838f, -0.29305729f, 
    0.10435251f, -0.01177817f, -0.03262637f, 0.19330022f, -0.10268658f, 0.02274934f, 0.00712552f, -0.10365389f, 
    0.20741954f, -0.16121045f, -0.25471160f, 0.22315945f, -0.13309900f, -0.17737569f, 0.05559200f, 0.13856472f, 
    -0.14521241f, -0.05892634f, -0.32556534f, 0.16045244f, 0.25589877f, 0.05676457f, 0.14360870f, 0.12093017f, 
    -0.13018037f, 0.09118615f, 0.11246739f, -0.31697309f, -0.00980053f, 0.04717671f, -0.06023432f, -0.09059032f, 
    -0.02710834f, -0.08333369f, -0.04574353f, 0.17614508f, -0.01893556f, -0.16329931f, -0.26029959f, -0.02151738f, 
    -0.10314361f, -0.05129109f, 0.06079977f, 0.02245970f, -0.10534984f, 0.13380423f, -0.14220034f, -0.04215200f, 
    -0.03921948f, 0.10584053f, 0.14103408f, 0.08100431f, 0.11904072f, 0.01901364f, 0.06320544f, 0.00640751f, 
    0.08744357f, -0.11054737f, 0.08411906f, 0.05402916f, 0.23808771f, 0.07055544f, 0.16871651f, -0.32975951f, 
    -0.12570196f, 0.05774473f, 0.04145624f, -0.06662551f, -0.01225723f, -0.07884619f, -0.06870490f, -0.03954228f, 
    -0.11507205f, 0.10408156f, 0.10961386f, 0.11105563f, 0.12016711f, -0.01411961f, 0.12296548f, 0.12782460f, 
    0.17134631f, 0.14826688f, 0.06708240f, 0.09078325f, 0.11580836f, -0.04351021f, 0.05973000f, 0.19533019f, 
    0.13380215f, 0.02503439f, -0.00447673f, -0.09870615f, -0.23451805f, -0.09079053f, -0.05665501f, -0.17249401f, 
    0.25090370f, 0.02841103f, 0.00266408f, -0.12178090f, -0.25116614f, 0.14682433f, 0.06910285f, -0.20278244f, 
    0.17248771f, 0.02826319f, 0.06890979f, 0.23837554f, -0.14803797f, -0.06127072f, -0.17429788f, 0.21754247f, 
    -0.06013821f, -0.08818888f, 0.05522472f, 0.09953255f, -0.02891286f, 0.28179717f, 0.06302986f, -0.14625360f, 
    0.00570428f, 0.20985456f, -0.12001559f, 0.05244172f, 0.00915125f, 0.19322354f, -0.03365558f, 0.05590175f, 
    0.19159943f, -0.00003426f, 0.03554447f, 0.11322611f, 0.12098149f, -0.01035433f, -0.16142264f, -0.20623176f, 
    -0.17750189f, 0.06143372f, 0.15683387f, 0.06522075f, -0.06957407f, 0.12922689f, 0.09902086f, -0.07775332f, 
    -0.16214712f, 0.00265274f, -0.20571963f, -0.29638061f, -0.16686495f, -0.15707755f, -0.08037268f, 0.02017820f, 
    0.09376548f, -0.15397160f, 0.02047824f, -0.21007760f, 0.10269324f, 0.02654294f, -0.17233710f, 0.02104081f, 
    0.13001968f, 0.12893192f, 0.24910043f, -0.44117182f, 0.06493658f, -0.22693400f, 0.02166768f, -0.03385177f, 
    0.06632385f, 0.00089251f, -0.03069567f, 0.32587743f, 0.18849105f, -0.08087461f, -0.01895846f, 0.16412014f, 
    0.00605315f, 0.14363289f, 0.04019940f, 0.07444242f, -0.35815915f, -0.18173657f, -0.03423559f, -0.09651518f, 
    -0.13465081f, 0.04463957f, -0.01388705f, 0.08063970f, -0.03030181f, -0.01580725f, 0.18356031f, 0.12472901f, 
    -0.15377678f, 0.06427342f, 0.16327968f, -0.06759322f, -0.06280822f, 0.14582984f, -0.22944736f, -0.47053534f, 
    -0.09652794f, 0.06722737f, 0.08022512f, 0.09868655f, 0.01473807f, 0.08841467f, 0.07093501f, -0.29626054f, 
    0.06763157f, 0.04089771f, 0.12117775f, -0.00236421f, 0.03441409f, 0.12322833f, 0.13561456f, 0.09446633f, 
    0.26610026f, -0.08056085f, -0.04498664f, -0.04963211f, 0.10089431f, -0.00054742f, 0.10036384f, 0.25531602f, 
    -0.01494509f, -0.33844456f, -0.13143000f, 0.07967025f, 0.11056486f, 0.07985859f, 0.17785276f, -0.21191743f, 
    0.03842702f, -0.34438342f, -0.22420934f, -0.32953927f, -0.34642938f, 0.22111095f, 0.11103512f, 0.05486523f, 
    0.17764390f, 0.05046329f, 0.00212475f, -0.24407181f, -0.00275210f, -0.07440324f, 0.05899766f, 0.01081389f, 
    0.00240862f, 0.27958667f, 0.13783020f, 0.15892109f, -0.06473887f, -0.16854219f, -0.32730329f, -0.07705247f, 
    0.10524535f, 0.01445670f, 0.26918542f, 0.21102664f, -0.06141248f, -0.76616061f, -0.16542618f, -0.24116680f, 
    -0.05388366f, 0.07046102f, 0.19003792f, 0.14154577f, -0.22737932f, 0.19136733f, 0.07967863f, -0.51056129f, 
    0.16351470f, 0.01810628f, 0.14357354f, 0.11156723f, 0.03294249f, 0.00385025f, 0.15723309f, -0.12131695f, 
    0.11152031f, -0.05471995f, -0.06204593f, -0.11516064f, 0.04355279f, -0.07285589f, -0.02580324f, 0.06914093f, 
    0.41719493f, 0.10001788f, 0.00056739f, -0.11635333f, 0.07666406f, 0.25210842f, 0.06265095f, 0.12047033f, 
    0.00337773f, -0.25777224f, 0.01291039f, -0.02736410f, 0.12146735f, 0.35435417f, -0.23553814f, -0.12130088f, 
    -0.02659836f, -0.09183969f, -0.23652369f, 0.15013070f, 0.12325986f, -0.13409817f, -0.05760123f, 0.06498051f, 
    0.07898112f, -0.09551624f, 0.07019557f, 0.20866935f, -0.05195044f, 0.10534371f, -0.17717180f, 0.01178387f, 
    -0.06949416f, 0.04121445f, 0.00037106f, 0.00670533f, -0.46329945f, -0.33476564f, -0.09415176f, 0.03650397f, 
    -0.16703661f, 0.01945814f, 0.02933833f, 0.05238254f, 0.08498620f, -0.11485112f, -0.03411793f, -0.15316769f, 
    -0.21100530f, 0.17024563f, -0.06263629f, 0.07652478f, -0.02943522f, -0.20371278f, -0.59758347f, -0.33703181f, 
    0.08366600f, -0.03847054f, -0.02982297f, -0.13597649f, -0.10934465f, 0.09161969f, -0.05931975f, 0.24992952f, 
    -0.12041566f, 0.10745639f, -0.06749813f, -0.00085233f, -0.09330364f, 0.00837729f, 0.10061588f, -0.05383716f, 
    0.02624493f, 0.07085329f, -0.12903601f, -0.03933507f, 0.02843876f, -0.03597354f, 0.16515109f, -0.11671621f, 
    -0.03481831f, -0.25345388f, 0.00952019f, 0.19185498f, 0.04803322f, 0.17913035f, -0.08616856f, -0.13948415f, 
    0.14343509f, 0.00957879f, -0.26310331f, 0.02308649f, 0.15622208f, 0.09759644f, 0.25751269f, 0.19266187f, 
    0.00740988f, 0.12025283f, 0.16217735f, 0.14672300f, 0.28413680f, -0.53060889f, -0.23897226f, -0.12759732f, 
    0.08249494f, -0.00202528f, -0.03955456f, -0.05208652f, 0.03849539f, -0.33390406f, 0.22343951f, -0.12086405f, 
    -0.02167665f, -0.03425448f, -0.03423083f, 0.20343949f, 0.10309137f, -0.06759807f, -0.29699636f, 0.14954314f, 
    -0.06579053f, 0.02797546f, 0.03370574f, -0.06155367f, -0.02760756f, 0.10008170f, -0.10774436f, 0.07464045f, 
    -0.50962692f, 0.02934189f, -0.09290367f, -0.06967533f, -0.08556631f, -0.04819890f, 0.09387878f, 0.16630550f, 
    -0.15509272f, -0.22593397f, -0.07780722f, -0.02106117f, -0.04747861f, 0.00700053f, -0.03504076f, 0.05167582f, 
    0.34358701f, -0.01907334f, 0.52540666f, -0.05051248f, -0.05919793f, -0.07059201f, 0.10808359f, 0.17087595f, 
    -0.04220262f, 0.22023721f, 0.01068700f, 0.22183815f, -0.23217776f, 0.00441982f, 0.18352662f, 0.05713524f, 
    0.12017801f, 0.08396158f, -0.30221286f, 0.13187388f, 0.19811940f, 0.00418447f, -0.02533434f, 0.01551829f, 
    -0.01776615f, 0.08168973f, 0.09896567f, -0.11773662f, 0.13440287f, -0.12743139f, -0.15938109f, -0.02737577f, 
    0.10901833f, 0.08456194f, 0.01304399f, -0.17104241f, 0.21226054f, -0.26702484f, -0.49490663f, -0.03779056f, 
    0.03035332f, -0.04343143f, 0.02008893f, 0.06763065f, 0.00009725f, -0.07590607f, -0.00526755f, 0.27640593f, 
    0.20919113f, 0.00125296f, 0.08648162f, 0.04201294f, 0.11347962f, -0.08163676f, -0.51141781f, -0.14863221f, 
    -0.19279288f, -0.11011238f, -0.00655723f, -0.11861162f, -0.03922669f, -0.11259685f, -0.06274889f, 0.12946410f, 
    0.10564527f, -0.07122423f, 0.00769013f, -0.05687283f, 0.03803752f, 0.09934451f, 0.05769190f, 0.07283383f, 
    -0.16955175f, -0.11025506f, 0.16744949f, 0.08199085f, 0.01169172f, -0.02625241f, -0.02824022f, 0.05847971f, 
    0.23489350f, -0.12490492f, 0.26384351f, 0.32753006f, -0.00471753f, 0.19906895f, 0.01942816f, -0.05254863f, 
    0.03957264f, 0.08705811f, -0.11660744f, 0.13462023f, 0.26589558f, -0.19806734f, -0.14500269f, -0.03817328f, 
    -0.03258316f, 0.09090960f, 0.01186380f, 0.18003483f, 0.05649950f, 0.36742347f, -0.15066202f, -0.07259520f, 
    -0.00937030f, -0.12125496f, 0.28038451f, 0.07408744f, -0.17823631f, 0.04745337f, 0.13250868f, 0.12863199f, 
    0.15934463f, 0.00156728f, -0.03373443f, 0.00948054f, 0.16188520f, 0.62789798f, 0.03330034f, 0.06504179f, 
    0.04030612f, -0.05595515f, -0.03033397f, 0.01518828f, 0.19314098f, -0.03008290f, -0.28225479f, 0.59543347f, 
    -0.32584250f, -0.08663517f, 0.05867020f, -0.12197958f, -0.03326937f, 0.11110259f, -0.06054139f, 0.07667235f, 
    0.03744491f, 0.06803084f, -0.00797526f, 0.07695904f, -0.08087765f, 0.16577013f, -0.01851362f, -0.06792451f, 
    0.01182948f, -0.06801441f, -0.04186383f, -0.05516133f, 0.02218228f, -0.01907954f, 0.02417661f, -0.00910537f, 
    -0.04396408f, -0.05379020f, -0.05656890f, -0.04696436f, -0.01694090f, -0.05304487f, -0.06775542f, 0.00028321f, 
    0.02337666f, -0.02547839f, -0.06192301f, -0.01318645f, -0.00452377f, 0.00192951f, -0.04774472f, -0.01067387f, 
    -0.02766956f, 0.03805407f, 0.00471900f, -0.03260575f, -0.05289779f, -0.03850818f, -0.05249417f, -0.01610346f, 
    -0.04829436f, 0.03797774f, -0.03111400f, -0.01751141f, -0.03036678f, 0.03709927f, 0.03896654f, -0.02561043f, 
    -0.05730651f, -0.01905624f, -0.05402070f, 0.03747098f, -0.01785292f, -0.01467665f, -0.06954465f, 0.04467329f, 
    -0.04269128f, 0.00548294f, 0.02697803f, 0.02405103f, -0.00872881f, -0.02877704f, 0.00629706f, 0.04420067f, 
    -0.06810699f, -0.03409882f, 0.01178280f, -0.02388768f, -0.02888327f, -0.06015826f, -0.06597809f, -0.04977873f, 
    -0.02583700f, 0.04201786f, 0.03924297f, -0.06060104f, 0.02874926f, 0.02982911f, 0.01986738f, -0.02426955f, 
    -0.01387219f, 0.02759300f, -0.00612748f, -0.01840281f, -0.05017111f, 0.02955886f, 0.00915544f, -0.01195056f, 
    -0.04478773f, -0.02398452f, -0.06122104f, 0.01470989f, 0.03932535f, -0.04685098f, -0.00999827f, -0.01495963f, 
    0.03248302f, -0.03149194f, -0.04251491f, -0.02141353f, 0.00972762f, -0.00122145f, -0.02395959f, 0.01595898f, 
    -0.02468140f, -0.05205574f, -0.05421932f, -0.03693603f, 0.01730983f, -0.06367118f, 0.01236789f, -0.02321908f, 
    -0.05176217f, 0.00610175f, -0.04152756f, 0.04768658f, -0.02054966f, -0.01608261f, 0.02719123f, 0.01180176f, 
    -0.00535593f, -0.01875250f, 0.04746025f, 0.01514748f, 0.00552998f, -0.06127551f, -0.06748797f, 0.06132866f, 
    -0.03974526f, 0.04407520f, -0.05598126f, -0.05629423f, -0.04627440f, 0.02805131f, -0.00961726f, -0.03871945f, 
    -0.04517720f, -0.00476415f, -0.03434933f, -0.03676553f, -0.01236195f, -0.00745210f, -0.02099970f, 0.01320991f, 
    0.03092869f, -0.04913566f, -0.03346596f, 0.04111385f, 0.01293641f, -0.03297087f, -0.05863721f, -0.03865672f, 
    -0.00999432f, -0.02602546f, -0.00945041f, 0.04520026f, -0.01885447f, -0.01964565f, -0.02927277f, -0.04745522f, 
    -0.05968487f, 0.01838806f, 0.01122491f, 0.05214195f, -0.02625556f, 0.03922882f, -0.05315849f, -0.04980577f, 
    -0.04311495f, 0.05101493f, 0.03717529f, 0.01872388f, -0.03140795f, 0.05636285f, -0.02159149f, -0.04537508f, 
    0.00860177f, 0.03991295f, 0.00580274f, 0.00794098f, -0.02210425f, -0.00566884f, -0.02119470f, -0.06408112f, 
    0.02911497f, -0.05309573f, 0.01612453f, -0.05224139f, 0.00616597f, -0.01211590f, 0.04894920f, -0.02708745f, 
    0.04011961f, -0.00148611f, 0.02678557f, -0.02600275f, 0.03968114f, 0.03869999f, 0.02145643f, -0.04245890f, 
    0.00162067f, -0.06572923f, -0.02247661f, -0.00766719f, -0.04500060f, -0.04150122f, 0.04390830f, -0.06037899f, 
    0.02517894f, -0.04660600f, -0.06300445f, 0.00467367f, 0.05444110f, -0.02853720f, -0.01353083f, -0.05151986f, 
    0.00557384f, 0.02016610f, 0.01239074f, -0.00775376f, -0.04475621f, -0.06800649f, 0.04026364f, 0.03639974f, 
    -0.06031205f, -0.01873142f, 0.02579715f, -0.01060324f, 0.01871960f, -0.01183118f, 0.00517802f, -0.02956825f, 
    -0.02041962f, -0.03753168f, -0.00978276f, 0.04957363f, -0.04139611f, -0.01229609f, 0.01588316f, 0.03952012f, 
    -0.05150286f, -0.01847133f, 0.03149201f, 0.04605290f, 0.00801454f, -0.00693466f, 0.03708385f, 0.04540433f, 
    -0.00699194f, 0.04120113f, -0.03898599f, 0.01998785f, -0.00909494f, -0.03819492f, -0.01613398f, -0.06250543f, 
    -0.03091854f, 0.01287801f, -0.00208732f, -0.04955338f, -0.04524195f, -0.04825131f, -0.02964641f, 0.03407134f, 
    -0.04269842f, -0.06041231f, -0.02565644f, 0.03488151f, 0.05090630f, -0.01459588f, -0.04774129f, 0.01566257f, 
    0.03487482f, -0.02247416f, -0.00602115f, 0.02729061f, -0.02121729f, -0.03059298f, -0.02238625f, -0.00882008f, 
    -0.02633416f, -0.06636587f, -0.05963660f, 0.01988940f, -0.05059860f, -0.05087809f, -0.05385801f, 0.04672543f, 
    0.00550446f, 0.01222285f, 0.03462596f, -0.04910700f, -0.03737914f, 0.00646437f, 0.00123777f, 0.02796471f, 
    -0.17529057f, 0.03005511f, 0.00475591f, 0.39823425f, -0.12357216f, 0.09265900f, 0.00712296f, -0.10674153f, 
    0.12349861f, 0.01598429f, 0.04839659f, -0.25080100f, 0.04719491f, -0.01345036f, 0.03951727f, 0.18957525f, 
    -0.08731066f, -0.08790454f, -0.03524781f, -0.18624762f, -0.04817809f, -0.04987985f, 0.04225500f, 0.04905806f, 
    -0.02439181f, 0.02455694f, -0.05499163f, -0.08127101f, -0.33523747f, 0.08516777f, 0.15123564f, -0.01885239f, 
    -0.04210434f, 0.04829035f, -0.03357784f, 0.14444695f, -0.01246063f, 0.15126361f, -0.06225620f, 0.08986780f, 
    0.04592030f, -0.14867258f, 0.05195501f, 0.14456049f, 0.03279882f, 0.11024749f, -0.13081136f, -0.24642316f, 
    0.06279343f, 0.05783428f, 0.06279414f, -0.04484377f, -0.07443705f, 0.08802917f, 0.28271955f, 0.18592648f, 
    -0.10806991f, -0.18127410f, 0.02116320f, 0.07415662f, -0.17183852f, -0.02396335f, 0.02040900f, -0.18592387f, 
    -0.21935906f, 0.15249613f, 0.15260915f, -0.10951221f, 0.07233392f, -0.00910594f, -0.02140153f, 0.18498862f, 
    0.10063322f, -0.10841560f, 0.05124560f, -0.12068042f, 0.09316096f, -0.06727371f, -0.11517355f, 0.02389973f, 
    -0.25190032f, 0.25941318f, -0.03618417f, -0.08540020f, 0.01160783f, 0.08236960f, 0.07196574f, 0.07288425f, 
    0.00552528f, -0.01276686f, 0.20503087f, -0.19424810f, 0.06154295f, -0.10986358f, -0.12110721f, 0.06076109f, 
    0.03034982f, -0.11292014f, -0.19452879f, 0.08279835f, 0.06962600f, -0.24630515f, 0.16617243f, 0.04593937f, 
    0.00058396f, -0.04224002f, -0.06825978f, -0.18832210f, -0.01112700f, 0.05419603f, 0.26856509f, 0.25972915f, 
    -0.04285682f, 0.02224004f, 0.10299514f, 0.01842506f, 0.07785231f, -0.14293040f, 0.15314643f, 0.20148960f, 
    -0.01429082f, 0.05635704f, -0.14048162f, -0.01054024f, -0.16286823f, -0.07837673f, -0.00902303f, -0.08137105f, 
    -0.00430052f, -0.02268631f, 0.03419964f, -0.01558553f, 0.01839393f, -0.00881833f, 0.01624290f, 0.05534005f, 
    -0.06392836f, 0.00595624f, 0.01776274f, 0.09865795f, 0.09054860f, 0.02774109f, 0.09475951f, 0.00715936f, 
    -0.22749592f, -0.07825717f, 0.18565167f, 0.02035545f, 0.15796354f, 0.09424600f, -0.04492713f, -0.10371581f, 
    0.16730788f, -0.18759854f, -0.17182361f, 0.15961985f, -0.03647559f, 0.05497785f, -0.08746988f, 0.03690461f, 
    0.00504586f, -0.17512472f, 0.24633998f, 0.00661120f, -0.05904386f, 0.00490290f, 0.09435143f, -0.05204780f, 
    -0.14328867f, 0.11870977f, -0.05881730f, 0.18242964f, -0.05571219f, -0.14202979f, 0.10426829f, -0.10305996f, 
    0.06818234f, -0.07190055f, 0.08796550f, -0.10606858f, -0.13838325f, -0.09628007f, -0.15630583f, -0.03190626f, 
    -0.04364328f, -0.03439843f, 0.05672182f, 0.04363054f, -0.03528915f, -0.19681272f, 0.00383284f, -0.05046983f, 
    -0.02006758f, 0.08257645f, 0.04322913f, -0.02194788f, 0.00758339f, 0.16044120f, 0.37811002f, 0.11473889f, 
    -0.16760944f, -0.21939851f, -0.03412554f, 0.05045543f, -0.08367729f, 0.10216013f, 0.05950968f, -0.02039680f, 
    -0.09671487f, 0.06225840f, -0.03665137f, -0.03776831f, 0.00027392f, 0.09788822f, -0.01515272f, -0.35658997f, 
    0.04939628f, -0.07269362f, 0.09551816f, 0.06843338f, -0.03750056f, 0.02301766f, -0.05481926f, -0.15930633f, 
    -0.22887656f, -0.04325839f, -0.17430142f, 0.14029598f, 0.19922724f, 0.04080152f, 0.14386702f, 0.00865744f, 
    0.00803922f, 0.22244549f, 0.15002491f, 0.08868852f, 0.02973931f, -0.06784932f, 0.11160432f, -0.02793872f, 
    0.18385436f, 0.07013860f, 0.14513704f, 0.10635725f, -0.18288866f, -0.06348787f, -0.10159987f, 0.02096297f, 
    -0.06208296f, 0.15453921f, 0.03157137f, 0.11571614f, 0.00786709f, 0.03802206f, -0.17916918f, -0.12549677f, 
    -0.04077819f, -0.13201018f, -0.05422788f, 0.01079940f, -0.20420083f, 0.09581771f, -0.36851224f, -0.16368480f, 
    -0.11489076f, 0.08521932f, -0.13099699f, 0.08186226f, 0.07377497f, 0.10086122f, 0.10579703f, -0.04569258f, 
    -0.27020657f, 0.17575462f, -0.07865304f, 0.07883549f, -0.04190305f, -0.03447223f, -0.11164530f, -0.02467163f, 
    -0.13149060f, 0.00315604f, 0.08417465f, 0.02871378f, 0.19044936f, 0.06765916f, 0.04701477f, 0.18887068f, 
    -0.13511576f, -0.13069113f, -0.12530638f, 0.00104127f, 0.05381583f, 0.03288541f, 0.21192263f, 0.03148706f, 
    -0.13858987f, -0.25546095f, -0.14207639f, -0.14566420f, -0.11024290f, 0.06894716f, 0.16810548f, -0.00423727f, 
    0.02318971f, -0.08143784f, -0.06224085f, -0.09586802f, -0.09926555f, 0.11673567f, 0.05200868f, 0.11006478f, 
    0.04924859f, 0.07703755f, 0.08651087f, 0.34903640f, 0.09878776f, -0.02439800f, 0.13922712f, 0.01025251f, 
    -0.02810187f, 0.01346837f, 0.09849142f, 0.02658520f, -0.01889869f, -0.35445318f, 0.02298150f, 0.25378180f, 
    -0.07745395f, -0.16711752f, 0.02417424f, 0.00903284f, 0.12288958f, -0.15954202f, -0.16251357f, -0.08573759f, 
    0.07002386f, 0.03023279f, 0.12617227f, -0.00380631f, 0.04066349f, -0.06367679f, -0.46904731f, -0.46521598f, 
    0.31719604f, -0.01008001f, 0.03958318f, -0.18289274f, 0.07266857f, 0.08126049f, 0.12101080f, 0.26347098f, 
    0.07590339f, 0.03270397f, 0.10154938f, -0.02339439f, 0.17984667f, 0.02052868f, 0.03011751f, -0.08565401f, 
    -0.04288467f, -0.06961573f, -0.00223530f, 0.01107668f, -0.11639008f, -0.11910226f, 0.02030013f, 0.10971899f, 
    -0.13158672f, 0.01283710f, -0.23792888f, -0.14166880f, -0.01351898f, 0.07225859f, -0.02173176f, 0.06793727f, 
    0.05971757f, 0.09833492f, -0.09520558f, 0.12902093f, 0.26429480f, -0.23578894f, 0.15559174f, 0.12751700f, 
    0.03898039f, -0.17803188f, 0.01545794f, -0.15481533f, 0.12310528f, 0.19945687f, 0.12726171f, -0.16379355f, 
    -0.23312926f, 0.11329017f, 0.02978763f, -0.07683987f, -0.03819283f, 0.12705708f, 0.25107160f, 0.01339832f, 
    -0.01025037f, 0.08230493f, 0.00622410f, -0.09640321f, -0.10386644f, 0.11941607f, 0.38381502f, 0.04996184f, 
    -0.02284894f, -0.01676779f, 0.13953887f, -0.13425662f, -0.18177232f, -0.35003549f, -0.00061057f, -0.18633091f, 
    -0.04609246f, 0.19245398f, -0.03911484f, -0.02331206f, 0.07135370f, -0.06097697f, -0.00202273f, -0.40704587f, 
    -0.10927730f, 0.10520138f, 0.14061978f, 0.06474451f, 0.02766410f, -0.06630681f, 0.09025642f, -0.10008829f, 
    0.17944859f, -0.12328257f, -0.21617556f, 0.04262711f, -0.05499350f, 0.07804736f, 0.01149265f, 0.01350721f, 
    -0.00621362f, 0.32560152f, 0.34101236f, 0.33845699f, 0.09957405f, 0.03849769f, -0.00675705f, 0.16680564f, 
    -0.04860020f, -0.02010074f, -0.01381460f, -0.09175928f, 0.14958058f, 0.03231490f, 0.02371688f, -0.08787692f, 
    -0.02650512f, 0.03691273f, -0.04076207f, -0.20188567f, -0.16800664f, -0.32507274f, -0.03130092f, 0.00727208f, 
    0.13999835f, -0.14720447f, 0.07990892f, -0.01860226f, -0.21272971f, 0.05564679f, 0.28330755f, -0.12301322f, 
    0.03320194f, 0.01021497f, 0.04654028f, -0.06934874f, -0.01183946f, 0.16501918f, -0.27321643f, -0.39421871f, 
    0.01998184f, -0.05168644f, -0.10647099f, 0.09570476f, 0.11389833f, 0.18252410f, -0.27087724f, -0.25845620f, 
    0.26938292f, 0.04010961f, 0.14628546f, -0.06067019f, 0.04927820f, -0.01600402f, -0.01329555f, 0.22109038f, 
    0.05115489f, 0.14074923f, 0.09013079f, 0.04397894f, 0.16488703f, 0.03882167f, -0.05334341f, -0.05179122f, 
    0.12972620f, 0.22544812f, -0.15484075f, -0.05218996f, 0.15174463f, 0.11200491f, -0.07864783f, 0.01129755f, 
    -0.00430345f, -0.10552157f, 0.08259249f, 0.12870289f, -0.04336192f, 0.09379884f, 0.11635840f, -0.04789454f, 
    -0.03990035f, 0.03660161f, -0.08343928f, -0.01917860f, 0.28496051f, -0.09854061f, 0.13801919f, -0.12512057f, 
    -0.05425241f, -0.13628210f, 0.05724685f, 0.07793970f, 0.13004045f, 0.12699486f, -0.08672371f, -0.01094214f, 
    -0.08518796f, 0.06422316f, 0.01671963f, 0.13912009f, 0.22443534f, 0.17190276f, 0.16495046f, -0.14522175f, 
    0.05768694f, -0.12779437f, -0.00834687f, -0.10697412f, -0.02962762f, 0.02957828f, 0.10529398f, 0.11480908f, 
    -0.12170801f, 0.05523913f, -0.10132337f, 0.21409734f, 0.01750033f, 0.12355387f, -0.08828686f, -0.01545576f, 
    0.20359488f, 0.01795835f, -0.04543191f, 0.02808736f, 0.12789895f, 0.08236476f, 0.02663179f, 0.20866911f, 
    0.19032022f, 0.00108190f, 0.02954311f, -0.00093332f, -0.00040535f, -0.00042137f, 0.08525171f, 0.08492216f, 
    -0.32287917f, 0.34308222f, -0.19054654f, 0.04302194f, -0.10686798f, -0.04188631f, 0.07459640f, 0.06961323f, 
    -0.00146951f, -0.24723287f, 0.29464939f, -0.06887494f, 0.09483398f, -0.01530562f, 0.11207526f, 0.17886451f, 
    -0.05256663f, 0.13830963f, 0.08656504f, -0.02031420f, 0.16782972f, -0.04754126f, 0.03468226f, -0.04280584f, 
    0.14727084f, 0.08575068f, 0.08912591f, 0.25079313f, -0.03734890f, -0.16907115f, 0.07697750f, 0.15876533f, 
    -0.10053279f, 0.14050597f, 0.05467962f, -0.10584357f, -0.11879247f, -0.05423263f, -0.16699772f, 0.21327226f, 
    0.13963839f, 0.12940378f, 0.02381966f, 0.08648864f, 0.12589775f, -0.06257744f, -0.11283393f, 0.03199300f, 
    -0.09474209f, 0.05855900f, 0.04398632f, 0.13815278f, 0.00527182f, 0.16349864f, -0.08066395f, -0.22136477f, 
    -0.11554413f, 0.02981506f, 0.00829777f, -0.05178604f, 0.05160509f, -0.02237586f, 0.04519034f, 0.16716999f, 
    -0.09945490f, -0.20321900f, 0.04376313f, 0.13713995f, -0.21439229f, -0.10835193f, 0.08144742f, 0.02243770f, 
    -0.04276782f, 0.03814837f, 0.05949504f, 0.13762857f, 0.13673747f, 0.09018042f, -0.34321249f, -0.32115391f, 
    -0.20945635f, -0.11023832f, -0.00639592f, 0.00304818f, -0.10625976f, -0.10826510f, 0.07273705f, 0.10199921f, 
    -0.15194984f, 0.02160796f, 0.09251185f, 0.11668141f, 0.00090275f, 0.18335199f, 0.04080741f, -0.09435665f, 
    -0.00728770f, 0.05659344f, -0.09495057f, -0.32675424f, 0.10907241f, 0.04385291f, -0.00890511f, -0.01760270f, 
    0.18459611f, -0.14487112f, -0.10891113f, 0.19433466f, 0.07932097f, -0.00128276f, -0.07189966f, 0.11232248f, 
    0.13744035f, -0.07071248f, -0.12003783f, 0.08757022f, -0.10539027f, 0.00703029f, 0.05926641f, -0.01818137f, 
    0.03155501f, 0.11315817f, 0.03321401f, -0.06609546f, -0.34857774f, -0.05424173f, 0.03767562f, -0.23252435f, 
    0.02431106f, 0.16529578f, 0.06335282f, 0.10596207f, -0.11153664f, 0.04754318f, 0.11540832f, 0.08453563f, 
    -0.14012121f, 0.02120818f, 0.12914769f, 0.15924641f, 0.18169169f, -0.10258112f, -0.02275431f, 0.00991751f, 
    -0.18338139f, 0.08292808f, -0.10846630f, 0.21270914f, 0.25134024f, 0.01120074f, 0.06637771f, 0.02598475f, 
    0.12737037f, -0.02709974f, -0.10839010f, -0.02418595f, 0.11280767f, 0.12618725f, -0.02880230f, 0.00949172f, 
    -0.06573576f, -0.12548929f, 0.08762670f, -0.05841620f, 0.00749787f, -0.02786325f, 0.05072293f, 0.10360676f, 
    -0.10543005f, 0.10505735f, 0.04028712f, 0.01160926f, 0.01967129f, 0.09655628f, -0.11181812f, -0.08289058f, 
    -0.00362190f, -0.01056529f, -0.00986127f, -0.01396954f, 0.30069038f, -0.14925940f, -0.02286915f, 0.13708107f, 
    0.15189292f, 0.01396372f, 0.02833047f, -0.10376523f, -0.04076438f, -0.12336478f, 0.03393671f, 0.31712499f, 
    0.00570179f, 0.01956637f, 0.05716071f, 0.09786260f, -0.02703211f, 0.03280647f, 0.07826918f, -0.24695212f, 
    -0.07820665f, -0.10066650f, 0.11850718f, 0.03717779f, 0.04073964f, 0.00916394f, 0.01840970f, -0.03827639f, 
    -0.01396567f, 0.03114150f, 0.21461892f, 0.15311506f, 0.06573381f, 0.06493194f, -0.18400614f, -0.02149820f, 
    0.07895619f, -0.05222455f, 0.08662220f, 0.05442437f, 0.06588166f, 0.09983484f, -0.26979399f, -0.37459311f, 
    -0.23629358f, 0.11045017f, -0.04763358f, 0.00810603f, 0.04492429f, -0.03420162f, 0.02915855f, -0.19345443f, 
    0.09560306f, 0.16812876f, 0.03410206f, -0.07479779f, 0.07551539f, 0.11466085f, 0.12840858f, -0.12390757f, 
    0.05049818f, 0.03280494f, 0.06766146f, -0.00827336f, -0.19340338f, 0.07975835f, -0.16670418f, -0.01267651f, 
    -0.02460661f, -0.11524311f, -0.03319347f, -0.09427031f, -0.00290691f, 0.05311064f, -0.02994180f, 0.10217006f, 
    -0.02604115f, 0.21300167f, -0.31620991f, -0.30889872f, -0.12991107f, 0.18556541f, 0.11081237f, 0.00437548f, 
    0.10523204f, 0.25741497f, 0.01148828f, 0.02229000f, -0.11277975f, 0.08406401f, -0.07985985f, -0.08067224f, 
    0.11194537f, -0.04092778f, -0.04896045f, 0.02978434f, 0.13513418f, -0.18256478f, 0.07068308f, 0.08856831f, 
    0.10019650f, -0.06682439f, 0.05862733f, 0.06497177f, 0.01363663f, -0.01889408f, 0.05024268f, 0.16692920f, 
    0.42128742f, 0.11834732f, -0.08662856f, 0.09910390f, 0.08865425f, 0.00901082f, -0.15443085f, -0.04011697f, 
    0.04617577f, -0.19266185f, -0.27015716f, -0.21160899f, -0.21162665f, 0.05558735f, 0.33328211f, -0.04132722f, 
    0.11443924f, -0.14381842f, 0.14109518f, 0.23955436f, 0.45862365f, -0.15307257f, 0.11147425f, -0.06638874f, 
    0.12026057f, 0.17021431f, -0.10024457f, -0.20027019f, 0.13728487f, 0.19581673f, -0.05290204f, -0.04233787f, 
    -0.10244574f, 0.04937816f, 0.08594405f, 0.02213634f, -0.17309541f, -0.09095065f, 0.04948864f, -0.03627366f, 
    -0.23610646f, -0.10014045f, 0.12397531f, -0.13487415f, -0.23639075f, -0.08454165f, 0.06726196f, 0.02548786f, 
    -0.31258592f, 0.02351886f, 0.21265009f, 0.01532550f, 0.12164576f, 0.17383930f, -0.22558014f, -0.10958903f, 
    -0.01179367f, -0.11296394f, -0.15337950f, -0.06549666f, -0.09496798f, -0.05364174f, 0.21998304f, -0.26044729f, 
    0.08319801f, -0.02890491f, -0.08985406f, 0.03713568f, -0.18860425f, 0.08093331f, -0.10803001f, -0.08970899f, 
    0.07317898f, 0.04582066f, -0.03238750f, -0.20225875f, -0.14887843f, 0.15052630f, -0.06516735f, 0.25294974f, 
    0.07453854f, 0.12049996f, 0.10976992f, -0.09684286f, 0.04406847f, 0.03473085f, 0.23513100f, 0.02095698f, 
    0.08752760f, 0.12931125f, -0.20887190f, -0.36601818f, -0.49540311f, -0.35356048f, 0.03401658f, 0.05641641f, 
    -0.08748264f, -0.00028880f, 0.07728699f, -0.39315704f, -0.40491229f, 0.35198754f, -0.11015612f, -0.06727980f, 
    -0.13462964f, 0.05884030f, -0.01740293f, -0.34364071f, -0.02630834f, 0.10989084f, -0.00404352f, 0.07557440f, 
    0.01078651f, -0.12601426f, 0.03878707f, -0.02149310f, -0.08256696f, -0.10140431f, -0.17147221f, -0.20491886f, 
    -0.00884185f, 0.00385898f, 0.01250042f, 0.02132333f, -0.19213323f, 0.13703685f, 0.09666000f, -0.27292216f, 
    -0.14119443f, 0.01638057f, 0.09382018f, -0.17571087f, 0.00544901f, 0.07950994f, -0.13684404f, -0.22464867f, 
    -0.14118163f, -0.06463911f, -0.15383448f, -0.19088168f, 0.01437875f, 0.01400855f, 0.08725104f, 0.08829093f, 
    0.17209616f, 0.44257277f, 0.10197214f, 0.06883640f, -0.05814999f, -0.27688506f, 0.09578224f, 0.04095100f, 
    -0.18394956f, -0.15362567f, -0.13809155f, 0.31316698f, -0.02616980f, -0.08359436f, -0.07087709f, 0.13165274f, 
    0.10432046f, -0.04729945f, -0.27401403f, -0.12893826f, -0.09328879f, -0.25506538f, -0.16716914f, -0.14855760f, 
    0.07161357f, -0.14420943f, 0.02668732f, -0.00578205f, -0.07379252f, 0.01006654f, -0.14029023f, 0.01727740f, 
    0.21557993f, -0.02857075f, 0.13882908f, 0.12143749f, -0.10355882f, -0.28753942f, 0.03579136f, 0.00252372f, 
    -0.15611321f, 0.09542003f, 0.18585169f, -0.11727673f, -0.09822571f, -0.35615236f, 0.24838971f, 0.42125309f, 
    0.00982315f, -0.03092449f, -0.17280841f, 0.06483306f, -0.01857184f, 0.01718667f, -0.20361385f, -0.27557823f, 
    -0.41521013f, -0.07539435f, -0.18402453f, 0.11589602f, -0.08493111f, -0.00922839f, -0.12063025f, 0.11658804f, 
    0.03622432f, 0.41497946f, -0.02393396f, 0.08893338f, -0.04461611f, 0.01330066f, 0.08423341f, 0.04414824f, 
    -0.26654547f, -0.34040561f, -0.11662889f, -0.12120041f, -0.12517126f, 0.01545542f, -0.05987027f, -0.14863491f, 
    0.06241610f, -0.15017413f, 0.10203408f, 0.12113763f, 0.00592467f, -0.12967357f, 0.03531518f, 0.17574367f, 
    -0.17216209f, -0.05430328f, -0.39999035f, -0.05437042f, 0.19892174f, 0.08728603f, -0.07236788f, 0.04338296f, 
    0.06255942f, 0.07098676f, 0.09293114f, 0.13488999f, 0.00736110f, 0.09354337f, -0.06529142f, -0.10061692f, 
    0.06347048f, 0.23281913f, 0.04328312f, 0.13864218f, -0.42729568f, -0.29162964f, -0.07247850f, -0.04882096f, 
    -0.10614362f, -0.19722171f, 0.01719846f, 0.08658500f, 0.04472096f, 0.34803113f, -0.12046160f, 0.57348675f, 
    0.09949366f, -0.11123994f, 0.19868200f, -0.16297315f, -0.00041827f, 0.20404191f, -0.34841937f, 0.07476588f, 
    0.23422144f, 0.01638699f, -0.28586209f, 0.04901877f, -0.17184894f, -0.10019381f, 0.15595789f, -0.14163384f, 
    0.09369757f, 0.20717229f, 0.22920422f, 0.16972403f, 0.05653422f, 0.20014779f, 0.06026900f, -0.16147597f, 
    -0.49760965f, -0.10254077f, -0.24283515f, 0.00041229f, -0.22337204f, 0.05083064f, -0.13068013f, -0.07749282f, 
    -0.08320971f, -0.34684762f, 0.15736616f, -0.36781558f, -0.01866872f, -0.14349484f, 0.07816602f, 0.02375855f, 
    -0.03315323f, -0.01339390f, 0.10144058f, 0.05930342f, 0.29959303f, -0.11893377f, -0.14129651f, -0.23722298f, 
    0.09807185f, 0.07780497f, -0.11098287f, 0.14754435f, 0.06049677f, -0.20283155f, -0.03657209f, -0.11225319f, 
    -0.03541594f, -0.05189338f, 0.06808685f, 0.00155779f, 0.12220962f, -0.08140681f, -0.06069975f, 0.05214486f, 
    0.01247883f, 0.04266315f, 0.10119790f, 0.18129423f, 0.27572513f, -0.01247301f, -0.13422459f, -0.12370869f, 
    0.13437074f, 0.05488068f, 0.07280461f, -0.00086350f, -0.05087249f, -0.10247598f, 0.03585629f, -0.27782357f, 
    -0.01833230f, -0.00736034f, 0.11688489f, 0.01856704f, 0.09323964f, -0.03569054f, -0.00823527f, 0.25156954f, 
    -0.06386934f, -0.19052456f, -0.01305304f, -0.12723324f, -0.01049971f, 0.00892747f, 0.08387222f, 0.08334237f, 
    0.05480505f, 0.00831870f, -0.07599632f, 0.06387354f, -0.01875640f, -0.03306130f, 0.08594754f, 0.07116015f, 
    -0.18699250f, 0.00193243f, 0.12908380f, -0.11724041f, -0.13949679f, -0.08966587f, 0.06513910f, 0.03779534f, 
    0.03953170f, -0.05557938f, 0.14423011f, 0.12926757f, -0.03290121f, -0.03994381f, 0.01017531f, 0.01119636f, 
    -0.05249055f, 0.00716842f, -0.18721543f, -0.35090187f, -0.12138664f, -0.11217497f, 0.05444727f, -0.19179827f, 
    -0.09385659f, -0.15150647f, -0.00666077f, -0.18763098f, -0.01152708f, -0.27435687f, -0.12131891f, -0.18082644f, 
    -0.23658857f, 0.05602314f, 0.02793711f, 0.08721264f, 0.01477838f, 0.13559748f, 0.16000322f, 0.08042176f, 
    0.08006848f, -0.08519352f, -0.01114554f, -0.19651330f, -0.10367983f, -0.22674258f, -0.08856343f, -0.05793887f, 
    -0.11841352f, 0.13279687f, -0.07267158f, 0.17057654f, 0.04305702f, -0.01649971f, -0.06449060f, 0.11886374f, 
    -0.01469140f, 0.08587077f, -0.03527151f, -0.05956911f, 0.00475655f, -0.01065456f, -0.09270021f, -0.08868238f, 
    0.12640744f, -0.22914127f, -0.52578741f, -0.13349155f, 0.00851703f, 0.02656562f, 0.07349680f, 0.17782792f, 
    0.11321076f, 0.10836888f, 0.05052663f, 0.11406113f, -0.11435307f, -0.13315208f, -0.03893086f, 0.09864345f, 
    0.01458869f, -0.09231030f, 0.09511293f, -0.13740270f, -0.02826277f, -0.00672873f, -0.17218663f, 0.06175662f, 
    0.14054413f, 0.05581697f, -0.07337055f, -0.08353454f, -0.05386551f, 0.05663761f, 0.16747159f, 0.04240736f, 
    0.04781815f, 0.05750715f, -0.06261078f, -0.05411168f, 0.07687128f, 0.36505190f, 0.13419402f, -0.01464118f, 
    0.12949492f, -0.13616721f, 0.20181811f, -0.13242896f, 0.17028274f, 0.30896839f, 0.27032933f, 0.25601801f, 
    -0.10847559f, -0.16967297f, -0.25207812f, 0.21032390f, 0.03106262f, 0.03798261f, -0.30425259f, -0.23621351f, 
    0.00273117f, 0.03105386f, 0.05834333f, 0.17820621f, 0.16618299f, 0.09503876f, 0.09820833f, 0.04352518f, 
    0.04703080f, 0.12018444f, 0.12328137f, -0.02395407f, -0.14263828f, 0.22290976f, -0.00871416f, -0.00801521f, 
    0.27708447f, 0.16613951f, 0.14743283f, 0.07260306f, 0.05585767f, 0.03989702f, 0.08019038f, -0.16636014f, 
    -0.14227940f, 0.11859562f, -0.34245285f, -0.21860690f, -0.08917727f, -0.20903455f, -0.04986031f, -0.03041529f, 
    0.11049771f, 0.13194586f, -0.16441783f, -0.13666274f, -0.16387093f, 0.07434288f, 0.12568294f, -0.01700268f, 
    0.07013402f, 0.03295671f, -0.01856831f, -0.09688669f, -0.20811777f, -0.09692859f, -0.10520359f, -0.10717472f, 
    -0.00405723f, 0.01840548f, -0.08882298f, 0.03440660f, 0.10666182f, 0.08355915f, 0.04313422f, 0.09015658f, 
    0.08497033f, 0.02961032f, -0.03125787f, -0.02605916f, -0.11959346f, -0.13704795f, -0.02183621f, -0.25902870f, 
    -0.01651657f, -0.02621357f, -0.14737199f, 0.00085322f, 0.02739261f, 0.29259643f, -0.02014506f, 0.03878159f, 
    -0.03886351f, 0.08489444f, 0.01618840f, -0.00276779f, 0.16017132f, -0.06522908f, -0.01445287f, 0.20162410f, 
    0.01186829f, -0.01111306f, -0.32649368f, 0.04493524f, -0.06009042f, 0.10828471f, 0.05206083f, 0.19178168f, 
    0.31649771f, 0.01791382f, 0.37306502f, -0.07376612f, 0.11126925f, 0.05037121f, 0.04873219f, -0.00859681f, 
    0.21910632f, 0.06921691f, 0.24484965f, 0.31303567f, 0.02485382f, -0.11696762f, 0.24426663f, 0.05636305f, 
    0.20122245f, 0.04198148f, -0.20084095f, 0.24213666f, 0.10321487f, -0.02261738f, 0.02737121f, -0.14688224f, 
    -0.03420116f, 0.06256325f, -0.00877746f, 0.14459565f, 0.18666150f, -0.13941234f, 0.02514330f, 0.06757700f, 
    0.00397180f, -0.02627418f, 0.08267296f, -0.00647502f, -0.23953183f, -0.21410319f, 0.07278527f, 0.04765716f, 
    -0.05593244f, -0.11800477f, -0.13933106f, -0.05609918f, -0.00770053f, -0.01532446f, 0.17920555f, 0.16647939f, 
    -0.05168833f, 0.14181124f, -0.13345143f, -0.03947115f, 0.13676751f, -0.19028290f, -0.13376576f, 0.05000113f, 
    0.03114410f, 0.08945993f, 0.03389847f, -0.14501052f, -0.02341651f, 0.06462423f, -0.09928314f, 0.24491099f, 
    0.13384762f, -0.33749503f, 0.11993735f, 0.07337146f, -0.10629094f, -0.04392195f, 0.07065967f, -0.14225848f, 
    0.05946429f, 0.06066598f, -0.06663974f, 0.01541204f, 0.05176971f, -0.04151350f, -0.01396754f, -0.13363698f, 
    -0.02421425f, -0.08268295f, 0.02075472f, 0.11926544f, 0.09237895f, -0.00012145f, 0.08269013f, -0.01183638f, 
    -0.02336509f, -0.06133946f, -0.17303193f, 0.26166955f, 0.01341682f, 0.15164138f, 0.23062776f, -0.05226051f, 
    -0.08767522f, 0.16237755f, 0.26828048f, 0.33242041f, -0.04079952f, 0.07262951f, 0.06978749f, -0.02789817f, 
    0.00626760f, 0.14795701f, 0.03029886f, 0.05969275f, 0.13217428f, 0.02538432f, -0.26875019f, 0.04576198f, 
    0.03592260f, -0.01140366f, -0.14077626f, 0.04537251f, -0.01674688f, 0.07972883f, -0.16965128f, -0.01220830f, 
    -0.06823621f, 0.06629986f, -0.01977259f, 0.14701001f, -0.16150410f, 0.08449439f, -0.02620116f, -0.04916278f, 
    0.11954888f, 0.11486079f, 0.04247683f, 0.03171239f, 0.04622285f, -0.02067476f, 0.02261554f, -0.01759377f, 
    0.09163128f, 0.07454391f, 0.09676568f, 0.07547096f, 0.07021314f, -0.13595028f, 0.10963259f, 0.06846189f, 
    0.12779939f, 0.02446903f, 0.13131990f, -0.20768605f, 0.08997010f, -0.11265466f, 0.07319290f, 0.06791386f, 
    0.01115045f, 0.17445177f, -0.01132372f, -0.03742798f, -0.12697856f, 0.01156125f, 0.01227296f, 0.06012386f, 
    -0.07339384f, 0.09782012f, -0.42685112f, 0.11389382f, 0.07989785f, 0.19045053f, -0.02458771f, -0.05236939f, 
    -0.05755344f, 0.14354759f, 0.25392595f, -0.03831306f, 0.04138946f, 0.14171250f, 0.04081270f, 0.01095432f, 
    -0.05968969f, -0.00271422f, 0.11182607f, 0.13916065f, -0.08562925f, 0.10474823f, -0.19473441f, 0.13678674f, 
    0.00829551f, 0.06570984f, -0.26295292f, 0.02605201f, -0.20874718f, -0.22522315f, -0.09832229f, 0.11412460f, 
    0.03125911f, 0.05704602f, -0.08494198f, -0.10383289f, 0.01481473f, -0.06504833f, -0.40992928f, 0.15987493f, 
    -0.04939720f, 0.01524505f, -0.05524898f, -0.20741090f, -0.31512988f, -0.07113381f, -0.12011593f, -0.00476449f, 
    -0.01157681f, 0.06168340f, -0.12241590f, 0.09721841f, -0.17495786f, 0.01709567f, -0.08425360f, -0.04377229f, 
    -0.00131354f, -0.02055402f, -0.17734785f, 0.06456837f, -0.16380395f, -0.06128605f, 0.05678544f, -0.06937836f, 
    0.21590336f, 0.11333048f, 0.14841668f, -0.13493012f, -0.07801223f, 0.19646120f, -0.01597540f, -0.16738142f, 
    0.00170030f, 0.06673808f, -0.13108069f, 0.05950418f, -0.29549557f, -0.07612707f, 0.07401237f, -0.00108339f, 
    -0.07270355f, 0.06727393f, 0.05258106f, 0.14102764f, 0.14881375f, 0.01144409f, -0.26110014f, 0.12185536f, 
    0.05626304f, 0.16424347f, 0.21158695f, -0.02546114f, 0.12284084f, -0.08505697f, -0.08367148f, -0.12832324f, 
    0.10833491f, -0.09560606f, -0.11759871f, 0.03863787f, 0.10697812f, 0.12429676f, 0.31843036f, -0.19810946f, 
    -0.19265123f, 0.08145796f, 0.30251831f, -0.08668382f, 0.05930018f, -0.01233685f, -0.20857191f, 0.17308092f, 
    0.08219725f, -0.05557378f, 0.02863591f, -0.00405821f, -0.17888102f, 0.08147323f, -0.01145912f, 0.05778893f, 
    0.10099369f, -0.13357477f, -0.09698105f, -0.03085462f, -0.10164224f, 0.05336460f, 0.05681963f, -0.13159868f, 
    0.43236360f, -0.05139679f, 0.08444844f, 0.01355593f, 0.18519336f, 0.07077237f, 0.08633363f, -0.12211625f, 
    -0.03809829f, 0.19300725f, 0.23567112f, -0.04102009f, 0.04301231f, 0.11705345f, -0.03159783f, -0.02776735f, 
    -0.05473797f, -0.04566239f, 0.05585291f, 0.02598711f, 0.04987774f, 0.03771803f, -0.10174707f, -0.12434013f, 
    0.04789305f, 0.10974322f, -0.03194874f, -0.07906125f, 0.01476028f, 0.03974335f, -0.04710699f, 0.03768270f, 
    0.15855986f, -0.01035963f, 0.02731750f, -0.17117284f, 0.04171554f, -0.02621843f, 0.05305432f, -0.07786162f, 
    0.08039662f, -0.06573516f, -0.02830009f, -0.14668487f, -0.24942811f, 0.04611546f, 0.13304475f, 0.17678177f, 
    0.11996929f, -0.01782941f, -0.07695127f, 0.07063996f, 0.05632066f, 0.06696384f, 0.05741703f, -0.00659437f, 
    0.23039426f, -0.03661266f, 0.03612154f, -0.03359413f, -0.03970318f, 0.12361110f, 0.13357759f, -0.37867704f, 
    -0.02337041f, -0.01730132f, -0.10068837f, 0.01689572f, -0.08328392f, 0.10497625f, 0.07758310f, -0.15390792f, 
    0.09682846f, 0.17170815f, 0.05661422f, -0.03964384f, 0.10057279f, 0.13317907f, -0.08764847f, 0.21674079f, 
    0.07470251f, 0.17672920f, 0.14928293f, 0.12660529f, 0.14686587f, 0.12179507f, 0.01894386f, -0.00415437f, 
    0.01778523f, -0.03133756f, -0.10701802f, 0.20492859f, 0.02297091f, -0.33332562f, 0.07609198f, 0.04473320f, 
    -0.12052971f, 0.11658530f, 0.21754780f, -0.09052379f, -0.02164231f, 0.33948836f, 0.09919019f, 0.07677615f, 
    0.01418329f, 0.06337637f, 0.04720801f, 0.05447746f, -0.11206522f, 0.16340843f, -0.18055923f, 0.16303782f, 
    0.03365709f, 0.03392599f, 0.00662456f, 0.09810486f, -0.30755007f, -0.11602003f, -0.16112474f, -0.09690461f, 
    0.14915864f, -0.01651049f, 0.15683824f, 0.02963023f, -0.03476839f, 0.14616926f, -0.05714964f, 0.17925660f, 
    0.09027319f, -0.10951453f, -0.03496812f, -0.21685030f, 0.08759511f, -0.20197606f, -0.04283280f, 0.03092498f, 
    -0.03814346f, 0.05975795f, -0.11975685f, -0.01493046f, 0.00312727f, -0.10776596f, -0.08729429f, -0.07996653f, 
    -0.12101766f, -0.09632570f, -0.03655072f, -0.10883547f, -0.03200664f, 0.11176617f, -0.01861363f, -0.28907099f, 
    -0.09029938f, -0.00478902f, -0.00548329f, -0.09093902f, -0.08664656f, 0.08046030f, -0.01061591f, 0.05024787f, 
    -0.01812484f, 0.03038407f, -0.23710419f, 0.08167198f, -0.09948450f, 0.15055618f, -0.02112410f, 0.05771843f, 
    0.02299091f, 0.00531581f, -0.18687908f, 0.17084217f, 0.07536237f, 0.12647954f, 0.02045162f, -0.01634511f, 
    0.06984891f, -0.00136654f, 0.01603312f, 0.13777958f, -0.28683412f, -0.03052380f, 0.03873788f, 0.03241597f, 
    0.03136628f, -0.20153335f, -0.06481014f, -0.13061905f, -0.10766513f, -0.13027675f, -0.05998601f, -0.02390459f, 
    -0.12466758f, -0.00325479f, -0.19857879f, 0.08059976f, -0.09747983f, -0.31244972f, -0.01731121f, 0.04832160f, 
    0.07694719f, 0.01883842f, -0.00938731f, -0.01822619f, -0.06865392f, -0.02051765f, 0.03407131f, 0.13763210f, 
    -0.04968322f, -0.12245104f, 0.07578146f, 0.04781892f, 0.10012729f, 0.03978614f, 0.02019876f, 0.04412157f, 
    -0.17002319f, -0.20140639f, 0.01255850f, -0.01781674f, 0.01279501f, 0.10208895f, 0.15634856f, 0.04058740f, 
    0.25820833f, -0.18250446f, 0.17065352f, -0.33086446f, 0.09376083f, -0.06819589f, -0.08955603f, -0.06755409f, 
    0.11667459f, -0.28087223f, -0.11497958f, -0.00911029f, 0.13068914f, -0.09846912f, 0.09795779f, 0.08272454f, 
    0.10615167f, 0.02351993f, 0.09521526f, 0.01882257f, 0.00745565f, -0.06892601f, -0.03671591f, 0.09532349f, 
    -0.05141448f, 0.11654371f, 0.12707601f, 0.08365373f, -0.10852603f, -0.02242348f, -0.11695384f, 0.10239971f, 
    0.19896176f, 0.05399361f, 0.00001595f, 0.11176918f, 0.33185589f, -0.10399215f, -0.03774123f, 0.54017049f, 
    0.06663013f, 0.15324453f, 0.03789443f, -0.09391659f, -0.15103723f, -0.08452618f, 0.14085941f, -0.13766983f, 
    0.17616478f, 0.11285234f, 0.05719019f, -0.04629619f, 0.01438750f, 0.10027322f, 0.30972639f, -0.26435089f, 
    -0.08687736f, -0.04499396f, 0.05239103f, -0.01587406f, -0.16711070f, 0.02850893f, -0.19103788f, -0.06058866f, 
    0.17361997f, 0.01005031f, 0.30834207f, -0.12012616f, 0.08106938f, -0.01959193f, 0.09563652f, 0.36516166f, 
    -0.14722817f, 0.28322116f, 0.08464130f, -0.14232123f, 0.16627099f, -0.13532563f, 0.00649983f, 0.15542233f, 
    0.11211684f, -0.02977053f, -0.32411966f, 0.04752781f, 0.34852451f, 0.13543098f, 0.16440505f, 0.05253379f, 
    -0.07563367f, 0.07199565f, 0.10948849f, -0.28498316f, 0.06128692f, 0.20832799f, -0.03096587f, -0.00684450f, 
    0.05129443f, 0.05419994f, -0.05205839f, -0.06142351f, -0.00622051f, -0.10185194f, -0.13470633f, -0.05563246f, 
    -0.06834815f, -0.25404882f, 0.27427539f, 0.12701024f, 0.02483448f, 0.08982388f, 0.03615896f, 0.03674616f, 
    -0.06471265f, -0.11131142f, 0.04526618f, 0.18094730f, 0.10864710f, 0.18097837f, 0.11859687f, -0.07823728f, 
    -0.00587616f, -0.15315680f, 0.00049750f, -0.07802974f, 0.17918450f, -0.01701876f, -0.10924625f, -0.12173555f, 
    0.04647677f, 0.17215504f, -0.05498449f, 0.08561864f, 0.03121787f, 0.08935319f, 0.06444243f, -0.10883839f, 
    -0.07063090f, -0.16016035f, -0.03108237f, -0.07148225f, -0.07801545f, -0.01346722f, 0.05466830f, 0.05043698f, 
    -0.07671745f, 0.32574210f, -0.03461991f, 0.03804107f, 0.02042154f, -0.03387978f, -0.13331133f, 0.24306558f, 
    0.36053061f, 0.02058368f, -0.00136551f, -0.15152742f, 0.04191726f, -0.39024305f, 0.07744861f, -0.03264549f, 
    0.06947085f, 0.12030412f, -0.06281333f, -0.04121229f, -0.05924874f, -0.40362886f, 0.15667121f, -0.28235236f, 
    -0.09223767f, 0.36559120f, -0.02542515f, 0.04137016f, 0.11629560f, 0.01775652f, 0.20651333f, 0.10579650f, 
    0.07691155f, 0.02512641f, 0.11938956f, 0.07575238f, 0.05478109f, -0.03609272f, 0.16354254f, -0.04380934f, 
    -0.15097661f, -0.34765536f, -0.20968488f, -0.03244590f, 0.04957495f, -0.07267157f, -0.02394849f, 0.04011151f, 
    -0.13298431f, 0.11370398f, -0.14682913f, 0.03682074f, 0.12811707f, 0.20240796f, 0.20398560f, 0.10289375f, 
    0.00557242f, -0.06635613f, -0.16141698f, 0.01745945f, -0.01212626f, 0.29997948f, 0.17198607f, -0.06426111f, 
    -0.02515722f, 0.13032746f, -0.02130184f, -0.04696930f, -0.01927954f, 0.04354499f, -0.03367662f, 0.22994252f, 
    -0.03686699f, 0.03769200f, -0.06608243f, -0.03264306f, 0.01985069f, 0.10033707f, -0.03363700f, -0.05908365f, 
    -0.01227321f, -0.01570038f, -0.05397314f, 0.07483396f, 0.03740389f, -0.16914901f, -0.18805483f, -0.12979153f, 
    0.25822645f, 0.10498153f, -0.17974965f, 0.13910007f, 0.05398947f, 0.02751864f, -0.08062778f, -0.16381447f, 
    0.20446120f, 0.19437096f, 0.00211771f, -0.00164523f, 0.09606724f, 0.03725430f, -0.01725674f, -0.05147384f, 
    -0.19464792f, -0.20647772f, -0.04165871f, -0.01705219f, 0.03804219f, -0.09614230f, -0.07802744f, 0.03746738f, 
    0.08173773f, 0.13611248f, 0.06271388f, -0.03318634f, 0.16307253f, 0.17859535f, -0.02249655f, 0.01043477f, 
    0.11652700f, -0.17394109f, -0.07703171f, -0.09003066f, -0.08670998f, -0.19198579f, -0.07611739f, -0.04736732f, 
    0.04491977f, 0.08142962f, 0.11188433f, 0.06113349f, -0.07368910f, 0.07701345f, -0.08609144f, 0.03456785f, 
    0.02018058f, -0.01175785f, -0.21645319f, -0.04136679f, -0.25105163f, -0.17962536f, 0.00161820f, 0.00953138f, 
    -0.03763377f, 0.43870059f, 0.07561789f, 0.36519745f, 0.03222746f, -0.05613603f, 0.16820610f, -0.03291560f, 
    0.11533327f, 0.21146323f, 0.11311685f, 0.16677016f, 0.28398916f, -0.05313962f, 0.03982019f, 0.03843428f, 
    0.06072270f, 0.08783373f, -0.04653452f, -0.00117833f, -0.01183484f, 0.16642161f, 0.21006794f, 0.19494434f, 
    0.03983970f, 0.30307311f, 0.08221889f, 0.00808081f, -0.20597750f, -0.12630416f, -0.32943246f, -0.23405868f, 
    -0.24968138f, -0.07146185f, -0.18486084f, -0.13236549f, 0.02596458f, -0.17593238f, -0.14101072f, -0.47362763f, 
    0.14727393f, 0.06969985f, -0.06654090f, 0.24697018f, -0.19695443f, 0.04884558f, -0.04861848f, -0.14852339f, 
    0.01028710f, -0.05417620f, -0.10487898f, 0.00254061f, -0.03228086f, -0.11325225f, 0.13281333f, -0.18309504f, 
    0.27230555f, 0.03489500f, 0.07928523f, -0.05331251f, 0.10460191f, 0.26684618f, 0.20977420f, 0.38133961f, 
    0.07213177f, -0.43509665f, -0.26405048f, 0.13417245f, 0.36780354f, -0.03151760f, 0.03593309f, 0.12357875f, 
    -0.16429152f, -0.01075092f, -0.49062333f, 0.04042586f, 0.02439561f, 0.41419643f, -0.10262717f, -0.06364854f, 
    0.11239728f, -0.11023934f, -0.18504409f, -0.78279638f, -0.30991003f, 0.07372619f, 0.17622393f, 0.02631163f, 
    0.05976496f, -0.10958686f, -0.07436325f, 0.28096583f, -0.55392379f, -0.61702389f, -0.20471875f, 0.11104770f, 
    0.14011152f, 0.11127923f, -0.09651221f, -0.00688908f, 0.06434873f, 0.16747046f, 0.17995331f, -0.12557860f, 
    0.10989391f, -0.15328965f, -0.01867676f, 0.07410586f, 0.25655138f, 0.24300680f, 0.33472157f, 0.03651284f, 
    -0.02279537f, -0.07741090f, 0.04796384f, -0.01309521f, 0.00280649f, 0.00519560f, 0.17924650f, 0.33059973f, 
    0.03212621f, -0.04268296f, -0.00056779f, 0.06846090f, 0.06301992f, 0.02649146f, 0.14124143f, 0.21928421f, 
    -0.41613290f, -0.55052853f, -0.14977227f, 0.10144489f, 0.26121065f, 0.13496941f, 0.00401493f, 0.04172906f, 
    0.03324305f, -0.11836089f, -0.13761784f, -0.06749670f, 0.09617208f, 0.10525267f, 0.21363986f, 0.06068700f, 
    -0.07749147f, 0.06186093f, 0.08581685f, -0.02052290f, 0.04811719f, 0.29851300f, 0.06811459f, 0.04295078f, 
    0.11912971f, 0.01067951f, -0.24428304f, -0.14200890f, 0.04259667f, -0.27052522f, -0.00503934f, -0.00094480f, 
    -0.03311483f, -0.13445871f, -0.15314116f, -0.01095766f, -0.32269338f, 0.31406748f, 0.06426919f, 0.05189146f, 
    -0.00825148f, 0.05222553f, -0.07316743f, 0.02851096f, -0.03130115f, -0.09624878f, -0.13661730f, -0.07663707f, 
    0.03101166f, 0.03418789f, 0.09593467f, -0.02099282f, 0.05889111f, -0.44378889f, -0.23011780f, 0.08271137f, 
    -0.03565412f, -0.10445816f, -0.09111711f, 0.05900797f, -0.02448704f, -0.10875493f, 0.21920918f, 0.11500124f, 
    0.30163923f, 0.01427591f, 0.14620036f, 0.00025868f, -0.07765525f, 0.02642903f, -0.01611274f, 0.30915380f, 
    0.19285457f, 0.01002443f, -0.18704921f, -0.02330688f, -0.03840345f, -0.05639091f, -0.30339700f, -0.07164540f, 
    -0.47331232f, -0.56359172f, -0.32365429f, -0.18207023f, -0.13348188f, 0.03866674f, -0.05191582f, -0.11551767f, 
    -0.14618537f, -0.15510453f, -0.35184866f, -0.00777028f, -0.04094052f, 0.02285821f, -0.10212802f, 0.13821708f, 
    -0.06826965f, 0.08153685f, 0.04209146f, 0.31702387f, 0.20007364f, -0.04250415f, 0.10991106f, -0.16796924f, 
    0.10128517f, -0.12778907f, -0.00518926f, 0.11728263f, 0.18190788f, -0.05148420f, -0.08267979f, 0.13202864f, 
    0.11974508f, 0.07424678f, -0.00669410f, -0.11366168f, 0.03126433f, 0.06743528f, -0.12423065f, -0.01094943f, 
    0.03093891f, -0.23966235f, 0.04904757f, 0.07845481f, 0.17633086f, -0.19912750f, -0.26012030f, -0.15945902f, 
    -0.06820650f, 0.03889340f, -0.12371178f, -0.11680137f, -0.13502289f, 0.08786796f, 0.48976240f, 0.23367536f, 
    0.09684153f, -0.03018290f, -0.14155018f, -0.08504819f, 0.02840196f, 0.04911513f, 0.08169363f, -0.09418519f, 
    -0.59353524f, -0.06783545f, 0.09995054f, 0.12147976f, -0.01955218f, 0.15334775f, -0.01766388f, -0.05975569f, 
    -0.11299350f, 0.03143793f, -0.03666836f, -0.10678448f, 0.19622390f, 0.02503264f, 0.01226163f, 0.19627568f, 
    0.02799829f, -0.27474901f, -0.43984765f, -0.62001652f, -0.08862428f, -0.05271379f, -0.02044478f, -0.00977735f, 
    -0.07381885f, -0.08756136f, 0.22499870f, 0.47691527f, 0.22020605f, -0.08772600f, -0.06845133f, -0.13123500f, 
    0.05933031f, 0.03619431f, 0.10938426f, -0.55293292f, 0.12790029f, -0.07276080f, 0.17508921f, 0.09154150f, 
    0.07120010f, 0.07983866f, 0.13299736f, 0.07935151f, 0.02925271f, 0.11230674f, 0.12080847f, -0.03632849f, 
    -0.08301689f, -0.14499441f, 0.17241211f, 0.07288563f, -0.01256050f, -0.28179607f, -0.00993202f, -0.61134350f, 
    -0.07791928f, -0.22877976f, 0.10103867f, 0.15884505f, -0.05616602f, 0.09448949f, 0.30342749f, 0.14510737f, 
    0.26323423f, 0.03844691f, -0.05273356f, -0.07215790f, 0.06541868f, 0.04284303f, -0.05637134f, -0.22537532f, 
    -0.43471423f, -0.32568964f, -0.02282953f, -0.16000527f, 0.19036192f, 0.06286158f, 0.04062035f, 0.08298571f, 
    -0.03711784f, -0.05691862f, 0.02983929f, -0.06543271f, -0.01338740f, -0.06129882f, 0.02336819f, 0.02551865f, 
    -0.05042055f, -0.01937026f, 0.03362012f, -0.02684834f, -0.00562619f, 0.00510534f, 0.04597365f, 0.02631720f, 
    -0.05514512f, -0.05238978f, 0.02324960f, 0.03971977f, -0.02943302f, -0.03428312f, 0.01243669f, 0.04103309f, 
    -0.00349729f, 0.01098399f, -0.06107137f, -0.03171424f, -0.05033752f, -0.01349131f, 0.03466872f, -0.01509255f, 
    -0.06163968f, -0.04552387f, -0.01385497f, -0.04229199f, 0.02395647f, 0.01309124f, 0.02036140f, 0.01889479f, 
    0.01084349f, 0.00894555f, 0.00821995f, 0.04227384f, -0.00169453f, -0.05497257f, -0.05251377f, 0.03172255f, 
    -0.03614082f, 0.01846831f, 0.04355309f, -0.02092937f, -0.02733859f, 0.03248842f, 0.04718981f, 0.04403033f, 
    0.04913502f, -0.02348467f, -0.02459117f, 0.02812258f, 0.04109989f, -0.02018824f, -0.01630221f, 0.01544407f, 
    -0.00415265f, 0.02385997f, 0.02936137f, -0.03561536f, 0.03500211f, -0.02158194f, 0.00609594f, -0.02179086f, 
    -0.00847744f, -0.01828040f, -0.05897362f, -0.00908298f, 0.01526440f, -0.04877679f, -0.04367182f, -0.01793140f, 
    -0.04076079f, -0.02310204f, 0.02192744f, -0.00935529f, -0.05017933f, -0.00794310f, -0.05302192f, -0.03269115f, 
    -0.02543870f, -0.03087453f, -0.05632382f, -0.00664627f, 0.04075360f, -0.00209468f, 0.02640796f, -0.01434856f, 
    -0.00440146f, 0.04014797f, 0.02835497f, -0.05893217f, 0.04670767f, 0.00940620f, -0.02568794f, -0.04010935f, 
    0.01068673f, -0.01292930f, -0.00777184f, 0.03343507f, -0.00568240f, 0.00260746f, 0.02028782f, -0.02941362f, 
    0.05086530f, 0.00800315f, -0.04146014f, 0.03340531f, -0.01448918f, 0.01283174f, -0.04108055f, 0.02702678f, 
    -0.03626486f, -0.03271146f, -0.04656746f, -0.01804391f, 0.01549440f, -0.01009438f, -0.01545463f, -0.00055555f, 
    0.02718049f, 0.02220043f, -0.02300752f, 0.02335718f, 0.05042923f, -0.03066773f, -0.03873523f, -0.04779645f, 
    -0.00120234f, -0.01071082f, 0.04151465f, -0.06054671f, 0.02716503f, -0.03757723f, -0.03025603f, -0.00833995f, 
    -0.03687391f, 0.01151783f, 0.04420220f, -0.06362000f, -0.02086358f, -0.06310599f, 0.05018051f, -0.05676812f, 
    0.04018310f, -0.03252261f, -0.03755695f, 0.01304195f, 0.00451537f, -0.06541549f, 0.03672972f, -0.06381488f, 
    -0.03166896f, 0.05029550f, 0.03924866f, 0.01095807f, -0.06451905f, -0.00645050f, -0.02411985f, 0.01026148f, 
    0.03138364f, -0.00579174f, -0.00078537f, -0.03467653f, 0.02919959f, -0.00362802f, 0.01862066f, 0.00484594f, 
    0.04644171f, -0.02248196f, -0.01828571f, 0.04132224f, 0.02757203f, -0.04297461f, -0.05715160f, 0.03955047f, 
    0.00472589f, -0.00494024f, -0.05583239f, 0.02291867f, 0.02041686f, -0.03223173f, -0.00479820f, -0.04389336f, 
    -0.05248968f, 0.04338353f, -0.06570015f, 0.02417296f, -0.04672302f, 0.02464843f, -0.01440653f, -0.02043541f, 
    -0.03794463f, 0.02186093f, -0.04382120f, 0.00054550f, 0.00847887f, 0.03775313f, 0.00347816f, -0.03948211f, 
    0.00413487f, -0.03231076f, -0.01495092f, 0.02722272f, 0.00343615f, 0.04675898f, -0.06004464f, -0.00865139f, 
    0.03914922f, 0.00234908f, -0.02710480f, -0.06431795f, 0.02928285f, -0.01850689f, 0.02905217f, -0.03582658f, 
    -0.06375849f, 0.03377854f, -0.01576496f, 0.03796843f, 0.02217218f, -0.03658694f, 0.03605237f, 0.04470596f, 
    -0.05435637f, -0.01143740f, -0.02722926f, 0.00209408f, -0.03532465f, 0.03489435f, -0.04338085f, -0.02043919f, 
    -0.01694882f, 0.01160673f, -0.05650250f, 0.03677769f, -0.00766812f, -0.01091328f, 0.03698650f, -0.06231195f, 
    -0.05422037f, -0.01602646f, 0.02828674f, -0.01921225f, 0.00872274f, -0.05329349f, -0.04824313f, -0.05458440f, 
    0.00258228f, 0.00133354f, -0.03822881f, 0.00892294f, -0.00895236f, 0.00199683f, -0.02883893f, -0.00996219f, 
    0.01046377f, 0.02679987f, 0.00786418f, -0.00887967f, -0.00224520f, 0.01039022f, 0.04905644f, 0.04487332f, 
    0.04765395f, -0.00356494f, -0.02571797f, -0.06080916f, 0.01259561f, -0.03794665f, -0.05781966f, -0.02235481f, 
    -0.01471899f, -0.01196333f, 0.00693632f, -0.03166488f, -0.01082945f, -0.00902246f, 0.02618016f, -0.03418244f, 
    -0.26408747f, -0.13091308f, -0.09626154f, -0.00376963f, -0.00713748f, 0.21308792f, 0.05645327f, -0.11417103f, 
    -0.02723537f, -0.10025596f, -0.34264648f, -0.34620363f, -0.09501281f, 0.07811157f, 0.17675002f, 0.10672557f, 
    0.09836750f, -0.01119012f, 0.19154814f, -0.16188575f, 0.00311022f, -0.24571788f, -0.05654595f, 0.06599887f, 
    0.03134683f, 0.06697368f, 0.05426636f, 0.37052014f, 0.10840794f, 0.10105451f, -0.08136357f, -0.04515554f, 
    0.02651601f, 0.00655973f, 0.03209164f, -0.00800720f, 0.03115737f, 0.15656377f, -0.15884550f, -0.06655667f, 
    -0.05220659f, -0.10970289f, 0.02133556f, -0.09066118f, -0.01642676f, -0.18271255f, -0.28315040f, -0.33714846f, 
    0.10241711f, 0.06012626f, -0.05360549f, 0.08362043f, -0.05289004f, 0.12115269f, 0.03604405f, -0.35258341f, 
    0.14557236f, 0.02074140f, 0.11976109f, -0.03082698f, -0.07355101f, -0.04408076f, -0.04561748f, 0.17490290f, 
    0.02353283f, 0.19876412f, 0.02063160f, 0.02158642f, 0.02880285f, 0.09634715f, 0.01282618f, -0.01270223f, 
    -0.07469243f, -0.13997796f, -0.37543830f, -0.07953358f, 0.06941946f, 0.16537853f, 0.05843561f, 0.07934076f, 
    0.17830072f, -0.05861036f, -0.32500294f, -0.94127876f, -0.01645768f, 0.02575040f, 0.21834308f, -0.02399345f, 
    0.05454706f, -0.00549563f, -0.37360254f, -0.14716303f, -0.00534804f, -0.07131489f, 0.14896651f, -0.07374895f, 
    -0.04478367f, 0.13237800f, -0.07077778f, -0.36323977f, -0.14053078f, 0.44381842f, -0.05482395f, 0.02113149f, 
    -0.11059939f, 0.02470904f, -0.04220843f, 0.16092993f, 0.03334463f, 0.25540444f, 0.35197732f, -0.03644110f, 
    0.07932910f, 0.07854974f, 0.12216719f, -0.06404165f, -0.01418873f, 0.28281420f, 0.19237825f, -0.17717573f, 
    -0.07192486f, 0.00694728f, -0.07992224f, 0.04481224f, 0.11142781f, 0.00737058f, 0.20053464f, -0.12742054f, 
    0.00536723f, 0.05209314f, -0.12232119f, -0.09136459f, 0.09379372f, 0.03140714f, -0.12593459f, 0.08203220f, 
    0.04499287f, 0.03938472f, 0.09477004f, -0.02574479f, -0.01820683f, 0.07446069f, 0.09059330f, -0.10665053f, 
    -0.18797119f, -0.17203438f, 0.01844473f, -0.06044169f, -0.00486991f, -0.09158193f, 0.05675616f, 0.00835404f, 
    -0.06124260f, 0.24448079f, 0.37116534f, 0.20548259f, 0.08809761f, -0.05705260f, -0.04281118f, 0.04905927f, 
    0.02529321f, 0.09042577f, -0.13641460f, -0.30654129f, 0.52680981f, 0.09470633f, -0.20840339f, -0.01140358f, 
    -0.09848606f, 0.05441257f, -0.00851635f, -0.52208239f, -0.26180911f, -0.54934067f, -0.05577072f, 0.04177715f, 
    0.10931379f, 0.13574691f, 0.01289388f, -0.01880211f, -0.28328979f, -0.42257258f, -0.43310988f, 0.04511000f, 
    -0.07396045f, 0.01604883f, 0.15298657f, -0.11719220f, 0.02780528f, -0.05930626f, -0.83763957f, -0.19891854f, 
    0.01832305f, -0.05074178f, -0.12960401f, 0.10281713f, 0.04289946f, 0.09970113f, 0.34233457f, 0.08527435f, 
    -0.12476349f, 0.00132606f, 0.10234731f, -0.01930923f, -0.04221473f, 0.01554404f, -0.23072979f, 0.14280587f, 
    0.28780550f, 0.17266725f, -0.12347106f, 0.03630351f, -0.04654397f, 0.11306623f, 0.05820971f, 0.08073521f, 
    0.20104764f, -0.04207895f, -0.46873307f, 0.03290565f, 0.06852901f, 0.07283323f, 0.17098708f, 0.09991336f, 
    0.06630272f, -0.15818310f, 0.12808679f, 0.13840681f, -0.13676769f, 0.11180478f, 0.11048030f, 0.12246268f, 
    -0.07220940f, 0.04144286f, 0.02801867f, 0.11490729f, 0.05912213f, -0.14560150f, 0.06075339f, -0.17343181f, 
    0.08961968f, 0.05422901f, -0.02425169f, 0.06795007f, 0.09566692f, -0.09912533f, -0.01883029f, 0.01033884f, 
    -0.18873861f, 0.02017023f, 0.08601022f, 0.00163740f, -0.02276672f, -0.00551077f, 0.05128326f, -0.01729029f, 
    0.01745854f, -0.20456347f, 0.05074525f, 0.12009703f, 0.05808195f, -0.06844036f, -0.13452123f, 0.15688135f, 
    -0.05260266f, 0.19635499f, -0.01156794f, 0.21465547f, 0.05555858f, 0.06364552f, -0.23444612f, -0.64024520f, 
    0.19026841f, 0.21435921f, -0.07236898f, -0.03793418f, 0.11473896f, 0.19767787f, 0.03321853f, -0.07316119f, 
    -0.19590463f, -0.09658593f, -0.26466623f, 0.01178606f, -0.09073936f, -0.00475651f, -0.04953082f, -0.07563679f, 
    0.24928913f, -0.05332115f, -0.21541208f, 0.00762085f, -0.01381702f, -0.06711031f, 0.08524235f, 0.02792096f, 
    -0.15652002f, 0.04027463f, -0.23283871f, 0.29063344f, -0.06595109f, 0.27084532f, -0.07691170f, 0.12986861f, 
    -0.01394234f, 0.19612004f, 0.17521411f, 0.06751390f, -0.03040403f, 0.00306364f, -0.02695263f, -0.04194180f, 
    -0.03020382f, -0.03885284f, 0.02458492f, 0.17465903f, 0.30441535f, -0.11608193f, 0.02401562f, -0.06457002f, 
    0.14798862f, 0.03516084f, 0.10246522f, 0.05057413f, -0.11131454f, -0.13217683f, 0.15190506f, 0.13554025f, 
    0.20076762f, 0.00371157f, -0.12725163f, -0.38302130f, -0.25656220f, 0.02490965f, -0.08580355f, -0.04146753f, 
    -0.05597758f, -0.09698736f, -0.08553871f, -0.07575913f, -0.07659570f, 0.05007397f, -0.20977627f, -0.14392769f, 
    0.07372871f, 0.12812376f, 0.00948595f, 0.03609654f, -0.02029127f, 0.16437708f, 0.08200724f, 0.34914938f, 
    0.27205598f, -0.15400970f, 0.05390534f, 0.10671756f, 0.07588664f, 0.00809997f, 0.06807518f, -0.17088251f, 
    0.06311376f, 0.13033263f, 0.15512794f, -0.21182185f, -0.09412055f, -0.14434071f, 0.07864552f, 0.22795103f, 
    0.06086684f, -0.05062869f, 0.06547799f, 0.06764423f, 0.08893105f, 0.05719877f, -0.08315855f, -0.14613673f, 
    -0.01813522f, -0.20559736f, 0.14490561f, 0.14554235f, 0.08226630f, -0.10249453f, 0.30233636f, -0.00209242f, 
    0.08876731f, 0.06431950f, 0.15159485f, -0.12438349f, 0.05791453f, 0.42468694f, 0.03307338f, 0.01362550f, 
    -0.24953061f, 0.24995993f, 0.09162228f, -0.01482335f, -0.01230822f, 0.18302815f, -0.04434985f, 0.20361836f, 
    0.17221582f, -0.02471870f, 0.02520856f, -0.03818687f, -0.33619091f, 0.01150100f, -0.10590878f, -0.43943962f, 
    -0.16027646f, 0.19380933f, 0.14847538f, 0.06010418f, -0.07913316f, 0.07541329f, -0.09474111f, -0.07247104f, 
    -0.00988870f, -0.01073980f, 0.23453753f, 0.00134588f, -0.02494743f, -0.19222344f, 0.19934665f, -0.11112233f, 
    -0.16993503f, -0.01758648f, -0.24165279f, -0.04992117f, -0.08168072f, -0.29354703f, 0.01651704f, 0.02311929f, 
    0.29850158f, 0.11050089f, -0.28541240f, -0.05695168f, 0.16291499f, 0.13229707f, 0.08216456f, 0.01588964f, 
    -0.17222129f, 0.05816811f, 0.06593578f, -0.22647271f, -0.10933892f, 0.26835480f, 0.24489048f, 0.16872853f, 
    0.04146425f, 0.12435949f, -0.13203193f, -0.00176480f, -0.09530500f, -0.07550632f, -0.14661141f, -0.18497032f, 
    0.04798711f, -0.13690384f, 0.18984698f, 0.15736438f, -0.07055788f, -0.05251381f, -0.29495436f, -0.19490160f, 
    -0.12613893f, 0.05511511f, 0.09809618f, 0.26096648f, -0.16617654f, -0.06646546f, 0.22954737f, 0.08772368f, 
    0.11502976f, 0.12104826f, -0.05813058f, -0.30635837f, -0.32144308f, 0.08166765f, -0.13310795f, -0.05294679f, 
    0.06016318f, 0.16919170f, -0.09328318f, -0.09025065f, -0.16068640f, -0.02241869f, -0.28502676f, -0.09002816f, 
    0.11558766f, 0.11861629f, 0.09148129f, 0.08372208f, -0.44098470f, -0.23576216f, -0.06176069f, 0.06215760f, 
    0.12380379f, -0.02210201f, -0.21998648f, -0.06156576f, 0.14291470f, 0.01472036f, 0.13042766f, 0.03768528f, 
    0.06115281f, -0.07563539f, -0.08316828f, -0.54149014f, -0.33589152f, 0.22038661f, -0.12617064f, 0.05691099f, 
    0.10037176f, 0.00316945f, 0.22352104f, 0.11467408f, 0.13833933f, 0.06638552f, 0.02870221f, 0.05989960f, 
    -0.02540367f, -0.15077086f, -0.08610123f, 0.02656192f, -0.18413861f, -0.00754461f, 0.09930625f, 0.21942490f, 
    0.00976526f, -0.08102791f, -0.09616856f, 0.03263240f, 0.07746639f, -0.03043251f, -0.01515682f, 0.04933183f, 
    0.06154853f, 0.03135077f, -0.02443698f, -0.02258379f, -0.18383859f, 0.07462680f, 0.08265451f, -0.36486116f, 
    -0.04180855f, 0.07353631f, 0.01838060f, 0.02993261f, 0.17811629f, 0.27464020f, 0.42261958f, 0.42082986f, 
    -0.25309283f, -0.03558317f, -0.15648513f, 0.23294173f, 0.05207697f, -0.17762749f, 0.06956273f, -0.14115383f, 
    0.09478579f, 0.01411650f, 0.05974742f, 0.07050062f, 0.00498337f, 0.04405551f, 0.08619906f, 0.09202216f, 
    0.19864362f, 0.01680047f, 0.09204694f, 0.04325372f, -0.04073779f, -0.11031141f, 0.03938384f, -0.17180240f, 
    -0.01139231f, -0.03473363f, 0.03017242f, -0.03830076f, 0.00477199f, 0.02272214f, -0.00811600f, -0.04505728f, 
    0.01720041f, 0.01964347f, 0.00983000f, 0.04767491f, 0.00688257f, -0.02833983f, 0.03962357f, -0.04190948f, 
    -0.05217514f, 0.03808199f, -0.00226229f, -0.03052034f, -0.04496327f, -0.02429513f, 0.02128958f, -0.00491235f, 
    -0.02674887f, 0.00874630f, 0.01431646f, 0.03075975f, -0.05645172f, -0.05919847f, 0.05326182f, -0.05626625f, 
    -0.00809397f, 0.05767161f, -0.00218085f, -0.02876518f, -0.01405592f, -0.05183139f, 0.03884304f, -0.03567903f, 
    -0.06844313f, 0.04662072f, 0.04083043f, 0.03925961f, -0.01204339f, -0.00744983f, -0.05767461f, -0.01257890f, 
    0.04849023f, 0.01526195f, 0.01576338f, -0.03511002f, -0.04706959f, -0.05796755f, -0.05104033f, -0.06455613f, 
    -0.00438536f, -0.00013352f, -0.04709631f, -0.02981544f, -0.06357212f, 0.04160767f, -0.06287878f, 0.03879496f, 
    -0.02793803f, -0.04068306f, 0.06224555f, -0.00185320f, 0.00296847f, -0.04795048f, -0.01232652f, -0.01724113f, 
    0.04213877f, -0.05149473f, -0.04922741f, 0.04269899f, -0.06612679f, 0.00230523f, 0.04990861f, -0.00569709f, 
    0.01625031f, 0.04947935f, -0.05380240f, 0.00668138f, -0.00341417f, -0.02911994f, -0.00627060f, -0.05403633f, 
    0.01911012f, -0.06009054f, 0.02469236f, 0.02611960f, -0.00307945f, -0.01159109f, -0.03489702f, -0.01791143f, 
    0.04814102f, 0.02540712f, -0.03721577f, -0.04965347f, -0.03860088f, 0.00567588f, 0.01481076f, -0.05441465f, 
    0.04276473f, -0.05543619f, -0.04353470f, 0.03383449f, -0.03594605f, -0.01023865f, 0.03457559f, 0.04404355f, 
    -0.01418080f, 0.04936763f, -0.02339120f, 0.00915417f, -0.04479893f, 0.00208590f, -0.02482445f, -0.00840224f, 
    -0.03653442f, 0.01570549f, -0.05006884f, 0.00687585f, 0.03507220f, -0.04736958f, 0.04169519f, 0.04030625f, 
    -0.02505770f, -0.00926276f, -0.03320819f, 0.04513697f, 0.02773234f, 0.00947348f, -0.05395108f, 0.01321116f, 
    -0.01396791f, 0.02033864f, -0.00431418f, -0.00912761f, -0.03850506f, -0.00208216f, 0.03239209f, 0.00873240f, 
    -0.04936093f, -0.03987888f, -0.02631657f, -0.03363854f, -0.01059883f, -0.04193939f, 0.03290224f, -0.04720648f, 
    0.01616157f, 0.02995673f, -0.04575601f, -0.04297004f, 0.02017268f, -0.02641982f, -0.01180486f, 0.00671189f, 
    0.02900953f, 0.02656737f, -0.01532260f, -0.06428355f, -0.00825802f, -0.02722439f, -0.02361065f, 0.01998570f, 
    -0.00172429f, -0.06645009f, 0.00162636f, 0.04620183f, -0.02833489f, 0.03292044f, -0.03723811f, -0.05481006f, 
    -0.00633271f, -0.00496044f, -0.05958154f, 0.00230982f, -0.02918045f, -0.06792866f, -0.06306275f, 0.02507113f, 
    -0.00738137f, 0.02121921f, -0.04039476f, 0.02602560f, -0.05863129f, -0.03768662f, 0.01999859f, -0.01476019f, 
    -0.02741900f, 0.02735932f, -0.05808623f, -0.02466598f, 0.00027951f, 0.05107659f, -0.05309672f, -0.01448093f, 
    -0.01784640f, -0.04958748f, 0.00751155f, 0.03561039f, -0.00723434f, -0.00030488f, 0.01372708f, 0.00957781f, 
    -0.04396402f, 0.03781718f, 0.00549787f, 0.04640498f, -0.03363536f, -0.02558704f, -0.06069844f, -0.05398440f, 
    0.00971641f, -0.00266754f, -0.02761608f, 0.04060464f, 0.03551010f, 0.02692951f, -0.04350611f, 0.04477564f, 
    -0.02265143f, 0.04962343f, 0.03340134f, -0.02167286f, 0.00113757f, -0.01058774f, -0.02772147f, -0.05114616f, 
    0.05007384f, -0.02769242f, -0.05305672f, -0.03667786f, 0.01072840f, -0.04825189f, 0.01839801f, -0.04846564f, 
    -0.00418936f, -0.02459711f, 0.04974885f, -0.06646772f, -0.02040223f, -0.05368205f, -0.03114774f, 0.03703270f, 
    0.04830458f, 0.00598398f, 0.02899676f, -0.05834803f, -0.02993051f, -0.00344492f, 0.01091830f, -0.06616257f, 
    0.02142532f, -0.00114162f, 0.00935603f, 0.02976522f, -0.00569741f, -0.04888164f, -0.02865869f, -0.04136564f, 
    -0.02164505f, -0.04487249f, 0.00776417f, 0.00214331f, -0.04253323f, -0.01114196f, -0.00073954f, -0.06627291f, 
    -0.01253696f, -0.04161679f, -0.06391225f, 0.03400952f, 0.03068382f, 0.02397307f, -0.05449224f, 0.01462317f, 
    -0.04806843f, 0.04936735f, -0.06754743f, -0.05073073f, -0.00395154f, -0.03534940f, 0.01359436f, 0.02360527f, 
    0.05430890f, -0.15971589f, 0.12008366f, 0.07200391f, 0.07077031f, 0.14754187f, 0.17134532f, 0.06347014f, 
    -0.01230236f, -0.01949381f, 0.04962750f, 0.07007995f, 0.10042079f, 0.10967730f, 0.01091818f, -0.12982079f, 
    0.03441094f, 0.13594824f, 0.02232763f, -0.10998020f, -0.04612038f, 0.06712438f, -0.13512284f, -0.09496888f, 
    0.05148957f, 0.08504192f, 0.12547998f, -0.19193378f, -0.16961968f, -0.01276337f, 0.05393756f, -0.04953891f, 
    -0.08702840f, -0.02005729f, 0.08435869f, -0.02453807f, -0.25832421f, -0.20424823f, 0.00631201f, -0.05516160f, 
    -0.10354240f, 0.03175483f, 0.02844778f, -0.18610337f, -0.16832325f, -0.13872720f, -0.12499085f, -0.03051912f, 
    -0.07388039f, 0.00801470f, 0.07312824f, -0.02200033f, 0.12646866f, -0.03040379f, -0.28721485f, -0.13388902f, 
    0.06008350f, -0.09472384f, -0.01001167f, -0.10703104f, 0.11365422f, 0.01827922f, 0.00382417f, 0.00080740f, 
    -0.34640816f, 0.01135844f, 0.06461952f, -0.01961126f, 0.03379477f, 0.15754893f, 0.15866455f, 0.09777629f, 
    -0.24679981f, -0.03623386f, -0.06127081f, 0.04641138f, 0.05802117f, -0.00198685f, 0.03709658f, 0.17547752f, 
    0.22993967f, -0.17072897f, -0.16057836f, 0.16355914f, -0.00478692f, 0.17946838f, 0.25590605f, 0.03149067f, 
    -0.02511952f, 0.04115628f, 0.14780658f, 0.09410895f, 0.09813291f, -0.14695098f, 0.13828249f, 0.04017805f, 
    0.22001503f, 0.01567574f, 0.08158799f, 0.38054407f, 0.02722092f, -0.14772768f, 0.01117537f, -0.03441261f, 
    -0.00582599f, 0.16059174f, 0.17116214f, 0.01267213f, 0.18069230f, -0.27056274f, 0.04248316f, 0.18538302f, 
    0.13137023f, 0.19372892f, 0.13152313f, 0.02123376f, 0.01146209f, -0.25656402f, -0.14025237f, 0.17930734f, 
    0.05349461f, -0.06748769f, 0.11992677f, 0.05156815f, 0.05655935f, -0.02882867f, -0.23310940f, -0.09200005f, 
    -0.04978051f, -0.16563438f, 0.06679731f, 0.14001435f, 0.01064688f, -0.00533292f, 0.02237255f, -0.27462661f, 
    -0.10530856f, -0.11139622f, -0.00233639f, 0.06675766f, -0.01985290f, -0.04139691f, 0.07716639f, 0.14912641f, 
    0.03281617f, -0.08059624f, 0.19122827f, -0.03011638f, -0.16831574f, 0.17217886f, 0.03129200f, -0.06403878f, 
    -0.21229872f, 0.17276108f, 0.14318672f, 0.31062070f, -0.06156562f, -0.01266999f, -0.03277943f, 0.19626150f, 
    0.08574525f, 0.03884006f, -0.39612809f, -0.05807634f, -0.03251689f, 0.02588154f, -0.22760350f, 0.06859443f, 
    0.17375155f, 0.26027256f, 0.24408999f, -0.24753390f, -0.21129963f, 0.04339622f, 0.11820610f, -0.03444050f, 
    0.07587177f, 0.08501869f, 0.10994200f, 0.24846619f, -0.11658116f, -0.16415808f, -0.04887507f, 0.00644771f, 
    -0.03203702f, -0.07882974f, -0.09954460f, -0.34695071f, -0.31631327f, 0.03124297f, -0.13754280f, -0.00297404f, 
    -0.05099087f, 0.03522878f, 0.11608417f, -0.09911471f, -0.09621613f, -0.10395466f, -0.04384206f, -0.31373060f, 
    0.10584960f, -0.05905863f, 0.03864522f, -0.13834608f, 0.01218021f, -0.21520995f, -0.16565150f, 0.10473440f, 
    -0.08760450f, 0.12594940f, 0.06881903f, -0.07760393f, -0.13720526f, 0.11700566f, 0.17453261f, 0.12018952f, 
    -0.24619471f, -0.16629249f, 0.06624614f, -0.07810394f, -0.14913316f, 0.09870389f, 0.11857670f, 0.16111352f, 
    0.14789629f, -0.14641169f, -0.07496720f, -0.01787362f, 0.04480378f, 0.12893505f, 0.06186790f, 0.10124418f, 
    0.32795963f, -0.05577765f, 0.21180509f, -0.06183958f, 0.19040632f, 0.05318766f, 0.18036033f, 0.10546697f, 
    0.03774654f, 0.01733370f, 0.00780260f, 0.14314593f, 0.17557842f, 0.36007097f, 0.00587944f, 0.12107293f, 
    0.12803724f, 0.23328131f, 0.03579549f, 0.08708674f, 0.00324880f, 0.08407414f, 0.07795507f, 0.09561811f, 
    0.10822520f, 0.00402702f, 0.09756153f, 0.02423153f, 0.15971161f, -0.18446009f, 0.05023058f, 0.12925380f, 
    -0.05202831f, 0.03083063f, -0.13253617f, 0.02585842f, 0.24019921f, 0.04418192f, 0.03262215f, 0.15185980f, 
    0.04485377f, -0.07447605f, 0.06728920f, 0.07732017f, 0.07409082f, 0.15144898f, 0.07435627f, 0.09467020f, 
    0.14517611f, 0.00571581f, 0.02259469f, -0.06014112f, 0.03672057f, 0.05435865f, -0.13134943f, -0.19058637f, 
    -0.12890673f, 0.11769626f, 0.35023981f, 0.02754474f, 0.08277266f, 0.03065414f, 0.13148493f, 0.39881927f, 
    -0.00553888f, 0.11824039f, -0.06882880f, 0.09381370f, 0.18551235f, 0.09228757f, -0.30866581f, 0.00990745f, 
    -0.00643350f, 0.09942637f, 0.10711158f, -0.19865140f, 0.04110408f, -0.00684952f, 0.12475368f, 0.07884444f, 
    -0.19852296f, -0.05227624f, -0.07107870f, 0.16572194f, 0.02212682f, -0.02438061f, 0.23465186f, 0.03102519f, 
    0.06865650f, 0.02380386f, -0.05498751f, 0.02527444f, -0.24288118f, -0.12192410f, 0.03976531f, 0.02156486f, 
    0.21332245f, 0.00038710f, 0.13151057f, 0.07181937f, -0.22427893f, 0.15888374f, 0.18022227f, -0.01993423f, 
    -0.18294294f, -0.03997594f, -0.03856875f, -0.03572508f, 0.05350298f, 0.07090005f, 0.03518241f, 0.23918910f, 
    -0.02909422f, -0.04668314f, 0.05431040f, 0.05458171f, -0.03700090f, 0.19655283f, -0.22614966f, 0.19060612f, 
    0.13417004f, -0.02652999f, 0.04111712f, 0.05378116f, -0.23508066f, 0.03232414f, 0.04747595f, 0.08011893f, 
    -0.00856422f, -0.14961472f, -0.12627810f, -0.04931048f, -0.06834108f, -0.13359791f, -0.01395335f, 0.00008731f, 
    -0.36341661f, -0.16604047f, -0.19025603f, 0.03902360f, 0.05672073f, -0.03209155f, 0.17893870f, 0.04366472f, 
    0.14941259f, -0.16169287f, 0.04026585f, 0.00250767f, -0.20156774f, 0.11673137f, 0.15254091f, -0.39922747f, 
    0.02241223f, 0.37863961f, -0.29655245f, 0.30203727f, 0.09794181f, -0.07285838f, 0.05551725f, 0.32798865f, 
    0.05150486f, -0.04904906f, -0.21546383f, -0.23567916f, 0.16223507f, 0.03975718f, 0.19737227f, 0.03123367f, 
    -0.04360009f, -0.03568403f, -0.08207582f, 0.01116149f, 0.02276876f, -0.16736335f, -0.09711780f, 0.11581936f, 
    0.07976311f, 0.05342749f, -0.25134814f, -0.01672880f, 0.26197392f, -0.00561735f, 0.07845524f, 0.06572570f, 
    -0.02146894f, 0.09636488f, 0.04484653f, -0.04202802f, 0.20919709f, -0.26904041f, -0.03146551f, 0.16493323f, 
    0.03146135f, -0.06331073f, -0.03680481f, 0.04678202f, -0.13966301f, 0.16127257f, -0.05076213f, -0.14667767f, 
    0.09492560f, -0.00567027f, -0.01239624f, -0.02019516f, 0.04093413f, 0.21587169f, -0.20819308f, 0.17896107f, 
    0.22773631f, 0.07137894f, -0.00952969f, 0.01935059f, 0.14085338f, 0.06605503f, -0.04352281f, -0.15168969f, 
    0.18154031f, -0.25288796f, -0.12914588f, 0.01423596f, -0.17592727f, -0.00675879f, 0.20617068f, 0.14621520f, 
    0.09999792f, 0.04412800f, -0.17545712f, 0.00331950f, 0.01552988f, 0.07800324f, -0.02687847f, -0.07809057f, 
    -0.08566277f, 0.08180644f, 0.06159848f, -0.09941486f, 0.20662017f, 0.08070733f, -0.32482195f, -0.11586990f, 
    0.20311029f, 0.18652573f, 0.22599134f, 0.00355399f, -0.04723340f, -0.09343954f, -0.15104418f, -0.11142407f, 
    -0.12911205f, 0.17446150f, 0.35406360f, 0.10671254f, 0.09025093f, 0.11987565f, 0.05304820f, 0.32126606f, 
    0.30078530f, 0.10507534f, -0.00646721f, 0.00649847f, 0.01040363f, 0.10306127f, -0.08156630f, 0.09998316f, 
    0.10562187f, 0.04698833f, 0.08012904f, 0.07522568f, -0.10292552f, -0.14447415f, -0.07889785f, -0.22072047f, 
    -0.01802929f, -0.03422588f, -0.09458659f, 0.02140434f, -0.03037645f, -0.25036120f, -0.07558072f, 0.02950010f, 
    -0.03743810f, 0.37716031f, -0.03491816f, -0.00545033f, 0.07934478f, -0.08466900f, 0.08367276f, -0.10872363f, 
    0.06946136f, 0.20066389f, 0.29679060f, 0.28044155f, 0.23696493f, 0.12917963f, -0.16789037f, -0.06128789f, 
    -0.03525693f, 0.09286364f, 0.11252984f, 0.24502468f, -0.05325465f, -0.01099790f, 0.17763451f, 0.04718687f, 
    0.12921812f, -0.08963881f, 0.12992714f, 0.02979470f, -0.18613854f, -0.03225348f, -0.10082839f, 0.11971828f, 
    -0.02719599f, -0.09232534f, -0.39849147f, 0.07688770f, -0.07477795f, 0.43680009f, 0.16971141f, -0.59130704f, 
    0.30524272f, 0.10216657f, -0.11020503f, -0.08667143f, 0.04702374f, 0.03365169f, -0.05315352f, 0.13447721f, 
    -0.04778982f, 0.00305523f, 0.08538301f, 0.14564194f, -0.01869133f, -0.12877069f, 0.07612545f, 0.01409838f, 
    -0.10501260f, -0.26914880f, -0.09915756f, 0.22704577f, 0.16462456f, 0.06736311f, 0.30820566f, 0.32148364f, 
    0.03119880f, 0.05123582f, -0.02862855f, 0.02333570f, 0.00919786f, 0.00062599f, -0.05878563f, 0.03389082f, 
    -0.00734290f, -0.04390048f, 0.03346881f, -0.05517848f, -0.01749129f, -0.04644095f, -0.04288477f, 0.04190003f, 
    -0.00786289f, -0.04243245f, 0.04173959f, 0.02191407f, -0.05965786f, -0.02956994f, -0.02847623f, -0.00179272f, 
    0.00924461f, 0.04634616f, 0.00689215f, -0.04199189f, 0.02591425f, 0.03661608f, 0.01388486f, 0.00351124f, 
    -0.01732842f, 0.02519804f, 0.02443826f, -0.02422155f, 0.00246551f, -0.01576469f, 0.03514935f, 0.03417242f, 
    0.04334654f, -0.00032880f, 0.02433021f, -0.00371829f, 0.01962272f, -0.04383033f, 0.03033484f, 0.02753049f, 
    -0.01523118f, 0.00281376f, 0.03861557f, -0.04182984f, -0.04424420f, 0.03771273f, -0.01084690f, -0.00903319f, 
    -0.00798279f, 0.02840756f, 0.05123454f, 0.00597897f, 0.02720381f, 0.01700121f, 0.02408013f, 0.03257262f, 
    -0.01484297f, -0.03041614f, 0.02951470f, 0.03632262f, 0.02272990f, -0.01738333f, 0.01037197f, -0.05992949f, 
    -0.05287023f, -0.05474957f, -0.02411769f, -0.02681587f, 0.01755734f, 0.03771620f, -0.03186843f, -0.04863867f, 
    -0.06759626f, -0.02982301f, -0.04607040f, 0.02759774f, -0.00320400f, -0.02932486f, 0.02800111f, -0.02258241f, 
    -0.01149316f, 0.04714839f, 0.05285271f, 0.03359609f, -0.03995224f, -0.03296124f, 0.00323220f, -0.04152031f, 
    -0.03493155f, 0.02301722f, 0.03973387f, 0.01130454f, -0.03766454f, 0.00950311f, 0.01269396f, -0.04906297f, 
    -0.05701616f, 0.01025159f, -0.05159037f, -0.05274382f, -0.02118103f, -0.04285525f, 0.02200340f, -0.06418394f, 
    -0.05944929f, -0.05636251f, -0.02865405f, 0.00093431f, -0.00895683f, -0.01969952f, -0.02697690f, 0.03053898f, 
    0.04805573f, -0.02959494f, -0.01239917f, -0.05480810f, 0.03933581f, -0.00329136f, -0.02458555f, 0.00124523f, 
    -0.06002223f, -0.01766880f, -0.02142152f, 0.03720737f, -0.03960579f, 0.01704205f, 0.00177225f, 0.02062054f, 
    -0.00563883f, -0.04430403f, 0.01829076f, -0.01537261f, 0.01300893f, 0.05324174f, -0.05086881f, -0.00528854f, 
    -0.04931424f, 0.03093413f, 0.04203522f, 0.00898604f, -0.01168965f, 0.03911221f, 0.03146630f, -0.02612395f, 
    -0.01888204f, 0.02448133f, 0.01511544f, -0.02952581f, -0.00101291f, -0.01203713f, -0.01591603f, 0.02221248f, 
    0.04149561f, -0.02308275f, 0.02368375f, -0.02173745f, 0.04517994f, 0.01563773f, -0.01835087f, 0.03379725f, 
    -0.05076418f, 0.04624348f, -0.02648866f, 0.05136540f, -0.00879796f, 0.02636422f, 0.03719541f, -0.06157238f, 
    0.00873391f, -0.03309417f, -0.04662185f, 0.02746879f, -0.02536662f, 0.01194952f, -0.01421029f, -0.05392040f, 
    -0.01947936f, -0.05540876f, -0.02145119f, -0.02345810f, -0.04923644f, -0.01527437f, 0.00554079f, -0.03830891f, 
    -0.04952346f, -0.06395706f, 0.05242768f, -0.01771812f, 0.03898153f, 0.04949157f, 0.02932944f, -0.04614789f, 
    0.02670236f, 0.00854056f, 0.03201663f, 0.02150373f, 0.03960767f, -0.04846216f, 0.03333940f, -0.05060477f, 
    0.01535830f, -0.00672838f, 0.00216664f, -0.02311642f, -0.05845827f, -0.03709751f, 0.03805207f, 0.00825675f, 
    -0.05297212f, -0.00087610f, 0.04120377f, 0.05209095f, -0.05655704f, -0.04651684f, -0.06369142f, 0.00527468f, 
    0.04177838f, 0.03497236f, 0.04727374f, 0.04289529f, 0.01917132f, -0.02402278f, -0.01237226f, -0.00160199f, 
    -0.01228187f, 0.02371591f, -0.00438246f, -0.00343306f, 0.00979147f, 0.01343539f, 0.00077095f, -0.01729943f, 
    0.01829183f, 0.01581755f, 0.00008769f, -0.00435213f, -0.02773524f, -0.04417930f, -0.01194437f, -0.02317808f, 
    -0.01589291f, -0.03888976f, -0.04811923f, -0.00296809f, -0.00560660f, -0.02730048f, 0.06012484f, -0.02836949f, 
    -0.03650734f, 0.03217297f, 0.04584429f, -0.03596601f, 0.04939888f, -0.04292579f, -0.02856140f, -0.02543068f, 
    0.04420784f, 0.00020463f, -0.06134671f, -0.04842257f, 0.03550644f, -0.06087682f, -0.01588636f, -0.02518435f, 
    -0.03051349f, -0.03640962f, -0.03497519f, -0.05405560f, -0.05600607f, -0.01740908f, -0.03647759f, 0.00704289f, 
    -0.01159758f, -0.01794176f, -0.03734184f, 0.00897423f, -0.00694234f, -0.00819861f, -0.03190560f, 0.04004538f, 
    0.26828474f, 0.36537746f, -0.40872520f, 0.17473620f, 0.25228813f, -0.23102355f, 0.01679471f, -0.05971255f, 
    -0.11806101f, -0.07029034f, -0.00144689f, -0.17544812f, 0.00963902f, -0.19582018f, -0.34342676f, 0.20337178f, 
    0.03869211f, 0.05587302f, -0.03774013f, 0.12038565f, 0.27486295f, 0.06547549f, 0.04704828f, -0.05689532f, 
    0.08411431f, 0.13069846f, -0.02436852f, -0.22947153f, 0.08991754f, 0.22757395f, 0.07674416f, 0.01668919f, 
    0.00389438f, -0.02912765f, -0.04028695f, -0.10645079f, -0.16403498f, 0.11603753f, -0.11570022f, 0.01797554f, 
    0.02437407f, -0.12023789f, 0.01735692f, -0.02095946f, 0.08278906f, -0.07039389f, -0.21099019f, -0.28167632f, 
    0.05701305f, -0.21023801f, -0.09077994f, 0.04677661f, -0.01866451f, -0.17878114f, -0.24430072f, -0.09432990f, 
    -0.24057257f, 0.00820179f, -0.23156948f, -0.12783383f, -0.01194786f, -0.02177017f, 0.07509136f, -0.11348107f, 
    0.03349140f, 0.21529287f, 0.03110574f, 0.06983879f, 0.07916267f, 0.00770218f, 0.11562432f, -0.17625438f, 
    0.27415511f, -0.14761637f, -0.34136957f, -0.07537375f, 0.07629459f, 0.03887499f, 0.08078624f, 0.14881697f, 
    -0.04802404f, -0.06531676f, 0.23876101f, -0.18740159f, -0.08892515f, 0.11102692f, -0.18923949f, -0.00079850f, 
    0.07879630f, -0.00350618f, 0.31414452f, 0.09688804f, -0.82617718f, 0.15938440f, 0.16752124f, -0.13820805f, 
    0.07803693f, -0.06218420f, -0.01321107f, 0.14299683f, -0.30132845f, 0.03580349f, 0.10858275f, 0.04472487f, 
    0.00118987f, 0.04884580f, 0.05136156f, -0.16629252f, 0.00141359f, 0.21364351f, 0.28260514f, 0.11951551f, 
    0.04113309f, -0.07521687f, 0.10121106f, -0.06665957f, -0.28217036f, -0.04833159f, -0.02906224f, -0.05060515f, 
    -0.05091976f, 0.17178032f, -0.13829412f, 0.01570343f, -0.16831222f, 0.01165405f, -0.06354549f, 0.17841603f, 
    -0.28512380f, -0.01155460f, 0.22599916f, 0.02271171f, 0.10468768f, -0.04852395f, 0.15223822f, -0.04859982f, 
    -0.36260527f, -0.26657605f, -0.19451596f, -0.02693664f, -0.13936220f, 0.01586209f, 0.09869252f, -0.02436967f, 
    0.25633484f, 0.36798370f, 0.17215711f, 0.05640932f, 0.17199069f, -0.20866914f, 0.10366792f, 0.15840283f, 
    0.07016490f, -0.04943844f, -0.09653151f, 0.10295738f, -0.05998793f, -0.00593541f, 0.08086697f, 0.04038925f, 
    0.04190488f, -0.03806645f, -0.09629191f, -0.06256504f, -0.18261848f, 0.02823864f, 0.27489734f, -0.07738097f, 
    0.16817994f, 0.04200542f, 0.14300236f, 0.06241952f, -0.01176754f, -0.34881520f, 0.06031146f, 0.05297871f, 
    0.09538619f, 0.05294497f, 0.08277021f, 0.06268050f, 0.12883225f, -0.28563008f, -0.06289624f, -0.06035766f, 
    -0.07573600f, -0.02762661f, -0.04265887f, -0.16373353f, 0.28224340f, -0.34539667f, 0.39292169f, 0.29065874f, 
    0.08296252f, 0.09170494f, -0.01256674f, 0.08485876f, 0.08813295f, 0.02091980f, 0.02096414f, -0.11392687f, 
    -0.16864887f, -0.08395958f, -0.21871099f, 0.06673270f, 0.01916623f, -0.05251859f, 0.00975215f, -0.01771878f, 
    -0.23505268f, 0.06379014f, 0.08303709f, -0.01739876f, -0.00518802f, -0.04156347f, 0.02404766f, 0.05698152f, 
    -0.28162095f, -0.07939016f, -0.08218867f, -0.08630646f, 0.10949654f, 0.15732683f, -0.14838515f, 0.06243048f, 
    0.16549364f, 0.01293835f, -0.02303400f, 0.08897831f, -0.04106265f, -0.09569103f, -0.16445613f, 0.23839185f, 
    -0.03772145f, -0.12618375f, 0.08876265f, 0.12694912f, 0.06129818f, -0.03364654f, -0.05234380f, 0.11344044f, 
    -0.10163100f, -0.14343517f, -0.01946221f, 0.23754446f, 0.02512238f, 0.04975024f, -0.10882285f, 0.11474007f, 
    0.08316650f, 0.15497170f, -0.13371444f, 0.01519851f, 0.34465167f, 0.06654839f, -0.11430164f, 0.01333380f, 
    -0.10983493f, -0.03035781f, -0.04274234f, 0.05751424f, 0.06013737f, 0.46385601f, -0.15265736f, 0.12571265f, 
    -0.05724462f, 0.19199067f, 0.08738227f, -0.04119432f, -0.23017447f, 0.06911555f, -0.10781580f, -0.10111313f, 
    -0.27582106f, 0.00596490f, -0.09113206f, 0.11921225f, -0.06823619f, -0.00049743f, 0.03701136f, 0.14491642f, 
    0.26515725f, 0.21849339f, 0.04708686f, 0.18578239f, 0.01084813f, 0.00870263f, 0.06751087f, 0.02632077f, 
    -0.08566450f, 0.24691258f, -0.80780017f, -0.14300486f, 0.11982962f, 0.02877228f, 0.13201180f, 0.24171995f, 
    -0.02396799f, 0.41137764f, -0.60891879f, -0.94141662f, -0.01841583f, -0.05832185f, 0.07911573f, 0.04487889f, 
    0.01635268f, 0.01162946f, 0.26451015f, 0.25040394f, 0.14910173f, -0.08267029f, 0.13657771f, -0.00408310f, 
    0.17518158f, 0.06359178f, 0.01138949f, 0.50665635f, -0.19245921f, 0.33288664f, -0.03316817f, 0.07486196f, 
    -0.14109921f, -0.06534528f, -0.03624501f, -0.01648222f, 0.14809389f, 0.20391293f, 0.10066634f, 0.07159065f, 
    -0.07937079f, 0.05475568f, 0.11325551f, -0.04756131f, 0.15638755f, 0.20189700f, 0.03628694f, 0.05935616f, 
    -0.13058138f, -0.12944683f, 0.01561420f, -0.06628774f, 0.01684059f, 0.04962324f, 0.27184314f, 0.02060768f, 
    0.12205126f, 0.12789141f, 0.03347810f, 0.04457014f, -0.03761123f, 0.02373637f, 0.06677724f, -0.33655757f, 
    -0.14355052f, 0.03206900f, -0.19687423f, -0.20114937f, -0.17065318f, -0.04707303f, 0.07019497f, 0.15536618f, 
    0.14923969f, 0.12937182f, 0.16997519f, -0.18705438f, -0.10847685f, 0.00710696f, 0.28547668f, -0.00892658f, 
    0.06440397f, 0.38154027f, 0.01696556f, 0.07705853f, 0.03733958f, -0.10179115f, 0.07904779f, -0.01299533f, 
    -0.06162779f, -0.02263953f, -0.09681689f, -0.06137086f, -0.44182038f, 0.05683165f, -0.04325613f, 0.03366027f, 
    -0.19401723f, -0.09610206f, 0.13361277f, -0.43140587f, -0.35192752f, -0.71492630f, -0.42014998f, 0.03331662f, 
    0.05083477f, 0.08313319f, 0.02838217f, -0.00946938f, -0.67733705f, -0.03922519f, -0.14287050f, -0.03949003f, 
    0.08321581f, -0.15692520f, 0.18362617f, 0.05297706f, 0.21379048f, -0.27585819f, -0.09984516f, -0.59759301f, 
    0.11144929f, 0.06326734f, -0.05763809f, 0.01677619f, 0.00776779f, -0.00036844f, 0.25717425f, 0.05590943f, 
    -0.12590376f, -0.05617769f, -0.12640293f, 0.05890502f, -0.19685289f, -0.04754816f, 0.06636938f, 0.29910669f, 
    0.00680580f, 0.04183918f, -0.15276979f, -0.14893204f, -0.25779074f, -0.10027125f, -0.15571006f, -0.00209904f, 
    -0.33018678f, -0.00199287f, 0.25857177f, -0.20556095f, -0.32612532f, -0.03107113f, -0.06837904f, 0.02759016f, 
    0.08898465f, -0.30989882f, -0.24718606f, -0.21867375f, 0.06385921f, 0.08430051f, -0.07757522f, -0.05076913f, 
    -0.10633405f, -0.05038333f, 0.19986656f, -0.09095202f, 0.16430512f, -0.03393905f, -0.23362881f, -0.02752018f, 
    -0.09170952f, -0.09579436f, 0.03075449f, 0.21181147f, 0.20141272f, 0.11898516f, -0.21098092f, -0.09990073f, 
    0.04143674f, -0.00766072f, 0.11835613f, 0.12722442f, 0.12571417f, 0.08307099f, -0.01025526f, -0.28381002f, 
    0.04594649f, -0.13642117f, 0.15014844f, -0.02436657f, 0.13572216f, -0.09575099f, -0.16474968f, 0.57873124f, 
    -0.12237436f, -0.23310313f, 0.02333881f, -0.01570868f, 0.08470758f, -0.00884511f, 0.03135455f, -0.17523199f, 
    -0.16680336f, 0.10937282f, 0.10981524f, -0.00493087f, 0.11595622f, -0.01414835f, 0.13383010f, 0.20443752f, 
    0.24271965f, 0.09619297f, 0.00320968f, 0.03008792f, 0.10993831f, 0.01135647f, 0.03886918f, -0.08103506f, 
    0.00991423f, -0.11955724f, 0.01254548f, -0.03525018f, -0.04592619f, 0.08684397f, -0.00204360f, -0.01858504f, 
    -0.09895975f, -0.00804607f, -0.92393267f, -0.25536484f, -0.09808695f, -0.04889902f, -0.06643846f, 0.10682254f, 
    0.02269945f, 0.11842433f, -0.75245696f, -0.59171665f, 0.00348855f, 0.01288112f, 0.11482229f, -0.07355081f, 
    0.06610990f, 0.00522724f, 0.12467461f, -0.17288499f, -0.67290312f, -0.03565212f, -0.01104390f, 0.04183513f, 
    -0.05816897f, 0.16569331f, 0.08845928f, 0.24311493f, -0.39526856f, -0.51811397f, 0.10800841f, 0.00870506f, 
    0.12011839f, -0.06794871f, -0.08556119f, -0.19330887f, -0.07573126f, 0.36786959f, -0.03685967f, 0.09074743f, 
    0.25356615f, -0.06766131f, 0.08913410f, 0.16082919f, -0.04279394f, -0.09416002f, 0.07853261f, -0.36457214f, 
    0.10905042f, -0.03370659f, 0.07736596f, -0.07994705f, 0.04901272f, 0.00826639f, -0.00177717f, -0.17234668f, 
    -0.34056783f, 0.02766203f, -0.00602499f, 0.06603731f, 0.03282477f, 0.08974939f, 0.02944679f, 0.06218038f, 
    -0.47207919f, -0.16486004f, 0.28774342f, -0.12203644f, -0.02598458f, 0.21918482f, -0.25573283f, 0.24824785f, 
    -0.07333829f, -0.04053320f, 0.01104288f, -0.04285468f, -0.00409284f, -0.11672801f, 0.21879484f, -0.05664141f, 
    -0.07942810f, 0.01147842f, 0.04099392f, 0.22940470f, 0.15335566f, -0.07843056f, -0.14326881f, -0.18407086f, 
    -0.14386952f, -0.12443949f, 0.07191168f, -0.12496596f, -0.16930686f, 0.05565939f, -0.08958494f, 0.14091989f, 
    -0.19633755f, 0.02058128f, 0.15913461f, 0.12906379f, -0.02588616f, 0.00795505f, 0.08824382f, -0.01106660f, 
    0.07483882f, 0.05026323f, 0.09351696f, -0.03736036f, 0.08937477f, 0.23764902f, 0.05376514f, 0.11421652f, 
    -0.01382067f, 0.04844436f, 0.07989374f, -0.02648084f, -0.02621093f, -0.22914661f, 0.30319673f, 0.21154927f, 
    0.18532147f, -0.06722601f, 0.02045107f, -0.04735173f, 0.07526422f, 0.00886283f, -0.02048208f, -0.00405752f, 
    -0.09107649f, 0.03742933f, -0.03952379f, 0.20953761f, -0.06919173f, 0.09150223f, 0.16468841f, 0.13728227f, 
    -0.06377033f, -0.09417459f, -0.01251390f, -0.00157763f, 0.03318138f, -0.02619083f, -0.21852127f, 0.11633478f, 
    -0.06659880f, 0.06191944f, -0.06121273f, 0.18793415f, -0.00443255f, -0.09056756f, 0.18910153f, 0.03634598f, 
    -0.06742261f, -0.03189019f, -0.22953902f, -0.15589438f, 0.10603829f, -0.08043861f, 0.18151359f, -0.34018537f, 
    -0.17067550f, 0.01349854f, -0.29404250f, -0.27176341f, 0.19971141f, -0.06865555f, -0.08200446f, 0.22376843f, 
    -0.22303127f, 0.05382427f, 0.00198645f, -0.04947826f, 0.13697731f, -0.05110341f, 0.18195482f, -0.20559961f, 
    -0.12079435f, -0.12306813f, -0.00407316f, 0.14557415f, 0.03162048f, -0.12119323f, 0.05005922f, 0.01396304f, 
    0.14825670f, 0.16890851f, 0.03678120f, -0.23249866f, -0.15156361f, -0.23453461f, 0.03531180f, 0.12871841f, 
    0.01814434f, 0.08314756f, -0.02081576f, -0.05709011f, 0.16558236f, -0.10427720f, -0.12461001f, 0.33730954f, 
    0.18332741f, 0.07925672f, 0.05680084f, -0.00051536f, 0.04866449f, -0.10049943f, 0.08147850f, -0.19762094f, 
    -0.15854043f, -0.30922905f, 0.37161154f, 0.12763633f, 0.11079569f, 0.13486721f, 0.00674047f, 0.15311734f, 
    0.22692335f, -0.17934228f, 0.12640068f, 0.09695165f, -0.07445808f, 0.01009360f, -0.19556384f, -0.23991840f, 
    -0.11178284f, -0.10331826f, 0.22714791f, 0.28323615f, 0.04217388f, 0.03121374f, -0.00150884f, 0.08175197f, 
    0.04196196f, 0.17230766f, 0.08468901f, 0.15154555f, -0.05682467f, 0.02573977f, 0.07909130f, -0.06095744f, 
    0.24541995f, -0.14472972f, -0.11880863f, -0.23903076f, -0.42408597f, 0.00561735f, -0.34844968f, -0.23417701f, 
    0.05507698f, 0.14728267f, -0.02080974f, 0.10082727f, -0.01187075f, 0.07949218f, -0.01190466f, 0.29492497f, 
    -0.02031780f, 0.13622363f, 0.06831657f, 0.05441083f, -0.14204249f, 0.29080868f, 0.18808678f, 0.03754631f, 
    0.00323849f, -0.15083243f, 0.06023669f, 0.04870322f, 0.09511367f, 0.09490350f, 0.02172872f, -0.15977050f, 
    0.06803530f, 0.07011830f, 0.04885370f, 0.05775253f, -0.18143430f, -0.19096485f, -0.01254443f, -0.04930983f, 
    0.11429028f, 0.03597163f, -0.05752752f, 0.14200906f, 0.11135440f, 0.11346771f, -0.12487171f, -0.24757707f, 
    -0.11780117f, 0.04323307f, -0.24764797f, -0.01156086f, -0.06312686f, 0.06929285f, 0.01148166f, -0.05194494f, 
    0.27586278f, 0.01530563f, 0.02859356f, 0.04640231f, 0.31185585f, -0.20115858f, -0.14172098f, -0.32423836f, 
    0.19429503f, 0.01297926f, 0.02780265f, -0.16227293f, -0.17476343f, 0.32486400f, -0.11145011f, -0.17140014f, 
    -0.22314318f, 0.15101737f, 0.05926229f, 0.02017479f, -0.10614608f, -0.05277685f, 0.06417292f, 0.20079367f, 
    0.12909968f, -0.13572633f, -0.11055891f, -0.22804298f, -0.12319744f, -0.61465430f, -0.30418026f, -0.00790304f, 
    -0.03824421f, 0.13512810f, -0.33418012f, 0.04936609f, -0.17363633f, 0.18287547f, 0.10637013f, 0.00078669f, 
    -0.00954744f, 0.00187948f, 0.14643855f, -0.08283199f, -0.03345032f, 0.02306731f, -0.00592828f, -0.13481671f, 
    -0.00370305f, 0.04525775f, -0.10323739f, 0.13515276f, -0.11038704f, -0.05813662f, 0.08958919f, 0.19959939f, 
    -0.02965934f, -0.00249870f, 0.01044778f, -0.05195307f, -0.02885101f, 0.01166658f, 0.02453133f, -0.03327198f, 
    0.00815599f, 0.03784826f, -0.04192832f, -0.04810964f, -0.02989282f, -0.04881446f, -0.06673909f, -0.02222462f, 
    0.00617810f, -0.04109680f, 0.02787842f, -0.03679105f, 0.03712684f, -0.02699407f, -0.01022718f, 0.02734761f, 
    -0.05260610f, -0.04914771f, 0.02287321f, 0.01665628f, -0.01571995f, -0.04210069f, 0.04476262f, -0.04807336f, 
    0.04082685f, 0.00599226f, -0.00739395f, -0.04626822f, 0.02486428f, 0.03136549f, -0.01150318f, 0.00925363f, 
    0.04767745f, 0.04271588f, 0.04602514f, -0.02835310f, 0.00884259f, -0.00731134f, -0.03559561f, 0.03784284f, 
    -0.02074244f, -0.05229319f, 0.02701134f, 0.01964084f, 0.03905447f, -0.04355165f, 0.00473940f, 0.00913603f, 
    -0.06736123f, 0.03594213f, -0.02721342f, 0.00425049f, -0.00818049f, 0.01783505f, -0.02537097f, -0.02724672f, 
    -0.06411005f, -0.04991623f, -0.05216096f, -0.01461748f, -0.06244555f, 0.01026635f, 0.03006658f, 0.04636720f, 
    -0.00109548f, -0.00392966f, -0.06664528f, 0.00901960f, 0.03201654f, 0.03365750f, -0.02779665f, -0.06887309f, 
    -0.02884383f, -0.03533264f, 0.03439173f, 0.04380135f, 0.01326388f, -0.05203759f, -0.04320214f, -0.01026302f, 
    -0.03291102f, 0.05557362f, 0.03857373f, 0.01633366f, -0.03562346f, 0.03399870f, 0.02281661f, -0.05031944f, 
    -0.01738045f, -0.06155144f, 0.01334119f, -0.00579787f, -0.04128096f, 0.03009498f, -0.01313005f, -0.02002991f, 
    -0.02739394f, -0.01547104f, 0.03186438f, -0.04548650f, 0.04733849f, -0.05439931f, -0.04126562f, -0.00164955f, 
    0.05553139f, -0.04644366f, 0.02244051f, 0.00558804f, 0.00335090f, 0.01710276f, 0.01799902f, 0.01764212f, 
    0.03487267f, -0.02448751f, -0.05235387f, 0.01201917f, -0.05623289f, -0.02446217f, 0.02084179f, -0.03565677f, 
    -0.03231897f, -0.04337860f, 0.01406920f, -0.03360393f, -0.05307351f, -0.00660895f, -0.03654864f, -0.00165501f, 
    0.01709153f, -0.04968444f, -0.02842005f, -0.04219474f, 0.01175157f, 0.01575647f, -0.03915707f, -0.02675086f, 
    -0.02208638f, 0.00918126f, -0.04986313f, -0.03163701f, 0.01861686f, 0.04606073f, -0.02665441f, 0.00291568f, 
    0.03633004f, -0.00731119f, 0.03345094f, -0.02661015f, -0.00781238f, 0.03792749f, -0.01844517f, -0.01819196f, 
    -0.05071622f, -0.04584895f, 0.02552149f, -0.04890013f, -0.02784129f, 0.04395756f, 0.00805393f, 0.02210130f, 
    0.01927831f, -0.05246554f, -0.06514244f, -0.05982532f, -0.00128911f, 0.00555496f, 0.02926552f, -0.01297737f, 
    -0.05076449f, 0.02054742f, 0.02139957f, 0.01809616f, -0.03636367f, -0.01137526f, 0.01228662f, -0.01411969f, 
    -0.01304566f, -0.01051924f, -0.01981953f, -0.04199339f, -0.03160198f, 0.03423072f, 0.01530677f, 0.02283182f, 
    -0.05052041f, 0.03300140f, -0.01923172f, -0.06110787f, 0.03722298f, -0.02853124f, 0.04084858f, 0.00293473f, 
    0.01920746f, 0.00461176f, -0.04812012f, -0.02501261f, -0.01023457f, 0.04010613f, -0.04885431f, -0.04993829f, 
    -0.00008634f, 0.00892657f, 0.03736429f, -0.00439164f, -0.03310190f, 0.01284870f, 0.00908267f, -0.04301503f, 
    -0.03047965f, 0.03416995f, -0.00035315f, -0.00890663f, 0.02506829f, -0.04013368f, -0.04762977f, 0.01083822f, 
    -0.00646112f, -0.03308512f, 0.01204353f, -0.06288473f, 0.00346823f, -0.02130034f, 0.04001430f, -0.05773992f, 
    -0.04406728f, -0.02309355f, -0.04807707f, -0.03575420f, -0.03153951f, -0.05769151f, 0.00603691f, -0.01887083f, 
    -0.01915889f, 0.02631307f, -0.01569037f, -0.00035069f, 0.04298486f, -0.05668033f, -0.01416544f, -0.02176704f, 
    -0.01969257f, 0.00890880f, 0.04485784f, -0.06141187f, -0.00155064f, -0.00749484f, 0.01026795f, 0.04315738f, 
    0.02319845f, -0.06543329f, -0.02892474f, 0.04429228f, -0.05235888f, -0.01347293f, 0.01135562f, 0.00974538f, 
    -0.05415941f, -0.02125154f, 0.01185467f, -0.00509105f, -0.04238225f, 0.01386279f, -0.05197565f, 0.04631365f, 
    -0.06317972f, -0.00959430f, 0.03192982f, 0.00158799f, -0.05214545f, 0.00470601f, 0.03053605f, 0.04438016f, 
    -0.02057576f, 0.00693867f, -0.04839013f, 0.02706080f, 0.02450090f, 0.01437623f, -0.04683007f, 0.00723104f, 
    0.37390798f, -0.04635181f, -0.03670605f, 0.14645584f, 0.02556502f, 0.07572950f, 0.14506677f, 0.03351553f, 
    0.18718070f, 0.39066422f, -0.14740314f, -0.51892364f, -0.19651364f, 0.05926379f, -0.01508791f, -0.08166487f, 
    0.12713650f, 0.14569299f, -0.26454130f, 0.24811766f, 0.08365624f, 0.03893819f, -0.04553957f, 0.05298315f, 
    0.11658537f, 0.04562571f, 0.19383915f, -0.43278623f, -0.10928947f, 0.29403466f, 0.05581895f, -0.20640898f, 
    -0.06197964f, -0.10125428f, -0.04986506f, 0.03782449f, 0.03216263f, -0.04541576f, -0.14955440f, -0.10822997f, 
    0.04530073f, -0.25127482f, -0.01771072f, 0.12119994f, 0.04879171f, -0.03130763f, -0.00609990f, -0.11275395f, 
    -0.06693244f, -0.13125923f, -0.18401007f, 0.03263906f, 0.11801133f, 0.13564645f, -0.07351605f, 0.13230051f, 
    -0.02563469f, -0.05480858f, -0.01695400f, -0.10360838f, -0.12301031f, 0.03795776f, 0.16644681f, -0.36014634f, 
    -0.16187495f, 0.10770014f, -0.07615402f, -0.20169754f, -0.10362971f, -0.10045166f, -0.04249003f, -0.02890330f, 
    -0.07637264f, -0.00657370f, -0.08102322f, -0.06802493f, -0.00437896f, -0.03794304f, 0.11982992f, 0.16897313f, 
    0.06322604f, 0.29658717f, -0.02103837f, -0.34286624f, 0.09337823f, 0.12505320f, -0.04728279f, 0.16671407f, 
    0.21544409f, 0.18684347f, -0.09475477f, -0.25752705f, -0.13882808f, 0.03803245f, -0.13784498f, -0.00410063f, 
    0.05778960f, 0.06614091f, -0.03268293f, 0.26353389f, -0.45314834f, -0.24175647f, 0.16982192f, -0.02585663f, 
    -0.00523529f, 0.10880154f, 0.07721640f, 0.01502985f, -0.00051699f, -0.09443517f, -0.00132730f, -0.01346647f, 
    -0.16912037f, 0.06398771f, 0.01341426f, 0.17213862f, 0.12560290f, 0.12590797f, 0.20972188f, -0.26892287f, 
    -0.20757033f, 0.09229443f, -0.00450660f, 0.10796728f, 0.14917818f, -0.07120527f, 0.10256667f, 0.01005938f, 
    -0.00050567f, -0.27497238f, 0.07144012f, -0.23551595f, -0.07694173f, 0.19551910f, 0.14767587f, -0.06480243f, 
    0.07694857f, 0.04290856f, -0.20451200f, -0.19473131f, -0.16553433f, 0.19527160f, 0.10151795f, 0.04151471f, 
    -0.41512436f, 0.12009554f, 0.01483034f, -0.02324111f, -0.14304577f, 0.16740693f, -0.16007645f, 0.23620559f, 
    -0.06918031f, -0.08205893f, 0.10615967f, 0.01088313f, -0.06722215f, 0.00878879f, -0.04015226f, -0.09331394f, 
    0.08607215f, 0.01439263f, 0.13576627f, -0.04879945f, -0.15416959f, -0.11165627f, 0.09258939f, -0.23620600f, 
    0.21808237f, 0.00341917f, -0.04554964f, -0.04489638f, 0.14789402f, -0.19499451f, -0.07913449f, -0.07300454f, 
    -0.10900141f, 0.13148625f, -0.03334837f, 0.19672656f, -0.12713012f, -0.00015234f, 0.00368251f, -0.14854409f, 
    -0.03846405f, -0.12158338f, -0.14624149f, 0.04143457f, 0.01659181f, -0.25967598f, 0.32313195f, 0.14303580f, 
    -0.02971746f, 0.08407955f, 0.17645018f, 0.01123365f, 0.12368775f, 0.19274290f, -0.12132277f, -0.30164716f, 
    -0.16504560f, 0.07549267f, 0.04673726f, -0.13239583f, -0.10747739f, -0.03639572f, -0.05293602f, 0.04101570f, 
    0.00299803f, 0.04009787f, 0.08274194f, 0.04483835f, 0.08103821f, 0.04892746f, 0.07094194f, 0.12165424f, 
    0.01684547f, 0.22703797f, -0.28273904f, -0.19764648f, -0.08021498f, 0.07352349f, 0.09295175f, 0.16258723f, 
    -0.14322668f, 0.03031332f, -0.11347741f, -0.10172971f, -0.16646741f, -0.21135087f, 0.15004197f, -0.05010756f, 
    0.17194554f, 0.02516594f, 0.04887940f, -0.21747375f, 0.24424134f, 0.05144701f, 0.04608214f, -0.23992459f, 
    0.04505093f, 0.09744214f, 0.14205371f, 0.07424541f, 0.03993371f, 0.14495799f, 0.11338277f, 0.06989107f, 
    -0.11729346f, 0.23266587f, 0.10192224f, 0.02930081f, 0.00621526f, -0.04729840f, -0.15052703f, -0.12273412f, 
    0.06263492f, 0.03947425f, -0.02949899f, 0.05358853f, -0.14708355f, -0.27965513f, -0.32149896f, 0.11174461f, 
    0.14439967f, 0.15402208f, -0.29683205f, 0.06633256f, 0.04613000f, 0.02330426f, -0.39260355f, -0.21474904f, 
    -0.10783879f, -0.03024901f, -0.05775642f, 0.08116407f, -0.17632203f, -0.05635024f, 0.06877823f, -0.14848094f, 
    -0.04800754f, 0.17830227f, -0.04425580f, -0.04761881f, 0.09030244f, 0.00356905f, 0.13699032f, 0.22814836f, 
    0.58877653f, -0.23167908f, -0.20666945f, -0.05550347f, 0.12153467f, 0.04540029f, 0.04690285f, -0.07667212f, 
    0.03098651f, -0.40349472f, -0.44505799f, -0.40614083f, 0.03957324f, -0.11231341f, -0.00307138f, 0.11702833f, 
    -0.04010801f, 0.11773825f, -0.18988329f, -0.25216952f, -0.17032351f, -0.05470077f, 0.07986613f, 0.20544264f, 
    0.10642028f, -0.03516103f, -0.01322644f, 0.20040290f, 0.01048396f, 0.18853390f, -0.06565121f, -0.07937249f, 
    0.17000523f, -0.00282019f, -0.05032364f, -0.04492143f, 0.59183770f, -0.03149579f, 0.02995296f, -0.04157677f, 
    -0.21219437f, -0.16207615f, 0.02301112f, 0.08722053f, 0.01110452f, 0.11739526f, -0.23180248f, -0.10341252f, 
    0.06238740f, -0.13675840f, 0.00891263f, 0.22799465f, -0.00624687f, 0.01706693f, 0.02778424f, -0.25524521f, 
    0.20145255f, -0.08515586f, -0.02632377f, 0.01342851f, 0.03541208f, 0.07477387f, 0.02605526f, 0.08192902f, 
    0.07896292f, 0.26921573f, 0.08259722f, 0.02503089f, 0.04292682f, -0.07456490f, -0.08080603f, 0.07242098f, 
    -0.11411233f, 0.01345460f, -0.19523066f, -0.02612289f, -0.05080222f, 0.16234669f, 0.12266790f, -0.01389715f, 
    0.15909520f, 0.35149133f, -0.01559657f, -0.63520944f, 0.08102102f, -0.04650580f, 0.08786888f, -0.00996685f, 
    0.08227686f, 0.02295534f, -0.00744480f, 0.09162958f, -0.46820974f, -0.20438594f, 0.20004092f, -0.20680827f, 
    -0.17846049f, 0.07106180f, -0.08978698f, -0.59815633f, 0.01467091f, 0.22537701f, 0.08203466f, 0.11881715f, 
    -0.07930592f, 0.21148634f, -0.02196318f, 0.06130707f, 0.04469653f, 0.23829147f, 0.08353437f, 0.06450067f, 
    0.16713427f, 0.05114552f, 0.13020526f, 0.01880531f, -0.03218004f, 0.13238116f, 0.08588286f, -0.24967578f, 
    -0.21273577f, 0.10389634f, 0.01243615f, -0.02222926f, -0.01734357f, 0.03322242f, 0.10591305f, -0.25150397f, 
    0.32209840f, -0.05224091f, -0.03071617f, -0.25823933f, -0.03981092f, -0.03971604f, 0.00846068f, -0.03164722f, 
    -0.24174593f, 0.30292308f, -0.37136024f, 0.03200108f, 0.06283285f, -0.06919502f, 0.04865807f, -0.00825467f, 
    0.17838071f, -0.20824406f, -0.20946072f, 0.00912361f, 0.08190327f, -0.11856690f, 0.13422239f, 0.01119605f, 
    0.08073467f, 0.08494285f, 0.14360751f, 0.18633620f, -0.06343698f, 0.07378349f, -0.04126061f, -0.00753309f, 
    -0.00702521f, 0.12870902f, -0.12728876f, 0.11638847f, 0.08407359f, -0.09360274f, -0.09885449f, -0.17737372f, 
    0.17985532f, -0.05346646f, 0.07639058f, -0.02021016f, -0.18880409f, -0.18609789f, -0.18443796f, 0.09003204f, 
    0.12068408f, 0.09107584f, 0.01812743f, -0.02532589f, -1.13475752f, -0.17078547f, -0.13142352f, 0.07602053f, 
    -0.15806863f, -0.01276871f, 0.06885093f, -0.06596595f, -0.10311978f, 0.02373137f, -0.51014733f, -0.12719257f, 
    -0.04890184f, -0.03853980f, -0.17110357f, 0.11576438f, 0.06101356f, 0.01479844f, -0.08450847f, -0.24674648f, 
    -0.52805197f, 0.06297834f, -0.11489425f, -0.07661067f, -0.02366841f, -0.00981842f, 0.10285919f, 0.03341126f, 
    0.02443424f, -0.01046739f, -0.00156260f, 0.03771373f, 0.02791366f, 0.09530295f, -0.04194411f, 0.07145970f, 
    -0.08589394f, -0.00119245f, -0.22492123f, 0.02459383f, 0.05938918f, 0.05840507f, 0.08333357f, -0.01159040f, 
    0.04367651f, -0.20436861f, 0.11269523f, 0.12842992f, 0.00585846f, 0.01096139f, 0.14065750f, 0.10767779f, 
    0.08385012f, 0.02870267f, -0.11587711f, -0.07157426f, -0.01759255f, -0.17784148f, -0.00215634f, -0.20111060f, 
    0.05041656f, 0.02653345f, 0.17444740f, 0.07993954f, 0.12980707f, -0.08661947f, 0.00810876f, -0.05010399f, 
    -0.00321625f, 0.17905563f, 0.03229632f, 0.01885145f, -0.00385037f, 0.09709038f, 0.22159979f, -0.09258943f, 
    -0.07891628f, -0.05830893f, 0.02353801f, 0.11177801f, 0.10351373f, -0.40582073f, -0.28936100f, 0.17523299f, 
    0.00611627f, 0.00903157f, 0.02538176f, -0.01447270f, 0.05964856f, 0.13291395f, 0.24257836f, -0.65086126f, 
    0.00461173f, 0.13895521f, -0.03607364f, -0.10333040f, 0.09166279f, 0.09794766f, -0.01613156f, -0.17855071f, 
    0.02789468f, 0.01759287f, -0.06366224f, 0.05643663f, -0.02726379f, 0.18598273f, 0.04106488f, 0.01841767f, 
    0.00483825f, 0.30577439f, -0.30240571f, 0.11483196f, 0.08848020f, -0.02803364f, 0.06695461f, 0.11171345f, 
    -0.15454639f, 0.05457890f, 0.40165097f, -0.39338475f, -0.29997638f, 0.13876876f, 0.21663406f, -0.06025402f, 
    0.21446151f, -0.34061316f, 0.03839180f, -0.05289252f, 0.21916009f, -0.01770148f, 0.06423876f, -0.07870547f, 
    0.14029133f, 0.15545867f, 0.06906652f, -0.02809487f, -0.05816035f, 0.31000364f, 0.00510808f, -0.06916902f, 
    -0.10358751f, -0.03481561f, 0.06389012f, -0.03951015f, -0.11329062f, 0.24832493f, -0.03518017f, 0.11058896f, 
    -0.09635060f, -0.10279014f, 0.11610842f, 0.02155757f, 0.02852307f, 0.00408924f, -0.20021042f, -0.10066310f, 
    0.08103131f, 0.02592070f, 0.02369474f, 0.08653652f, -0.20244969f, -0.00507739f, -0.01371621f, -0.02028431f, 
    -0.12849009f, 0.22494541f, -0.00845463f, -0.07991297f, 0.05736411f, -0.07225925f, 0.04656259f, -0.19684584f, 
    0.19989875f, 0.30408078f, -0.08338295f, 0.00921128f, 0.00503099f, 0.01952741f, -0.11222400f, 0.01519390f, 
    -0.02597597f, 0.01934213f, -0.11299936f, 0.08149354f, 0.01255011f, -0.07805505f, -0.12822744f, -0.10573842f, 
    0.03412184f, 0.29831728f, 0.15640375f, -0.47658861f, 0.06823594f, -0.00386811f, 0.10049634f, -0.02574577f, 
    0.06520015f, 0.08176977f, -0.02286747f, 0.08418402f, -0.14363356f, 0.10320478f, 0.11009672f, 0.04146360f, 
    -0.08590709f, -0.01509385f, -0.18325190f, 0.14833120f, 0.03680133f, -0.21220136f, 0.17090662f, 0.01543792f, 
    -0.18011366f, -0.24704848f, 0.10361535f, -0.26162583f, 0.20508963f, 0.35875216f, 0.21743318f, 0.06649207f, 
    0.06641470f, -0.00550537f, 0.06073628f, -0.09071811f, -0.12966098f, -0.03100505f, 0.32676089f, 0.15104893f, 
    -0.03122705f, 0.06672640f, -0.19134924f, -0.00015781f, -0.15120426f, -0.11713803f, -0.16347079f, 0.00762089f, 
    -0.16003075f, -0.09053984f, 0.23645274f, -0.04403942f, -0.18917976f, 0.02266339f, 0.10479639f, -0.16463751f, 
    -0.02581921f, 0.01057802f, -0.03759529f, 0.07080356f, 0.17548020f, 0.11988347f, -0.27789059f, -0.02721029f, 
    0.08856438f, -0.03524004f, 0.14576541f, -0.07784608f, 0.09863242f, -0.29510421f, 0.08217704f, -0.02112676f, 
    -0.04594893f, 0.12615004f, 0.11615995f, 0.41789550f, 0.02551909f, 0.15631402f, -0.15487087f, 0.02510528f, 
    -0.08844505f, -0.03405650f, 0.21995550f, 0.14763166f, -0.14100182f, 0.10316733f, 0.12618089f, -0.14926739f, 
    -0.10980358f, -0.10326480f, 0.05626837f, -0.24347129f, -0.06894808f, -0.05602081f, -0.00726956f, 0.05467339f, 
    0.07478540f, 0.13368292f, -0.19756307f, 0.15265007f, -0.15206006f, 0.00915608f, -0.06870297f, -0.13218914f, 
    -0.17531845f, 0.04426200f, -0.07271802f, -0.01836915f, -0.06956720f, -0.46790805f, -0.10368732f, 0.15200445f, 
    0.02552570f, 0.05255723f, -0.27084979f, 0.10473225f, 0.02961720f, 0.14989272f, 0.17378855f, -0.25837633f, 
    -0.06896090f, -0.02773978f, -0.12713112f, 0.04618979f, -0.01903630f, 0.18369398f, -0.05347782f, 0.22485887f, 
    -0.11757194f, 0.24464865f, 0.03435842f, -0.06761818f, -0.01296394f, -0.00996529f, -0.00229889f, -0.11035371f, 
    0.02382765f, 0.08094666f, 0.06061312f, 0.11400900f, 0.04095915f, 0.11922318f, 0.04057792f, -0.11444758f, 
    -0.11812408f, 0.08455981f, 0.26707914f, 0.11377484f, 0.05644670f, 0.06088149f, 0.27241835f, 0.16257621f, 
    -0.13972580f, -0.31667861f, 0.05193105f, 0.02834671f, 0.26635456f, 0.09797186f, 0.01587134f, -0.01134402f, 
    -0.00590702f, -0.13580413f, 0.00858497f, 0.06682368f, -0.01652482f, 0.08348794f, 0.05556004f, -0.00851902f, 
    0.06853864f, 0.06964572f, -0.01078244f, 0.06487624f, 0.17738135f, -0.00795828f, 0.12376682f, 0.11697313f, 
    -0.08792379f, 0.00082824f, -0.24477743f, -0.32247299f, -0.11110260f, -0.03112070f, -0.28016806f, 0.42244494f, 
    -0.15051442f, 0.05036533f, -0.02087101f, 0.12066930f, -0.03871727f, 0.08029883f, -0.01845198f, -0.29884806f, 
    0.04106589f, -0.08212005f, 0.01351168f, 0.07104978f, 0.03416757f, -0.05369161f, -0.16480583f, -0.15631978f, 
    -0.11016775f, 0.10306698f, 0.00171226f, 0.19028923f, -0.00892003f, 0.06590086f, -0.00007709f, 0.03931089f, 
    0.43944278f, -0.04646172f, -0.17389984f, -0.01858002f, 0.04211795f, 0.00129257f, -0.04141748f, -0.08459009f, 
    -0.00897575f, -0.82743692f, -1.08151841f, -0.19523090f, -0.06127355f, -0.33950096f, 0.01002431f, 0.08819786f, 
    0.02962489f, 0.17194577f, 0.19112965f, -0.15601474f, -0.14137697f, -0.09285604f, 0.04479310f, 0.14203425f, 
    -0.09197884f, 0.00393784f, -0.03014230f, 0.57918775f, 0.15491651f, 0.19921461f, -0.01846181f, 0.01125660f, 
    0.02282899f, 0.02203191f, 0.01777414f, -0.11223622f, 0.47564328f, -0.02158809f, 0.07819087f, -0.19474749f, 
    -0.16733097f, 0.08287491f, 0.01699531f, 0.02402697f, 0.00480866f, -0.23033510f, -0.36227268f, -0.16914152f, 
    -0.07773964f, 0.06113238f, 0.01995777f, 0.05048898f, 0.02074392f, -0.04102809f, -0.18725756f, -0.69058585f, 
    0.00083096f, 0.02313819f, 0.05601440f, -0.26610598f, 0.05790034f, 0.03051270f, -0.09134627f, 0.36330116f, 
    0.10103797f, 0.16379683f, 0.14822896f, 0.09160949f, 0.11775388f, 0.06410383f, -0.01360044f, -0.09440127f, 
    -0.02984972f, -0.04663693f, -0.24051394f, 0.07480843f, -0.09567828f, 0.22279716f, -0.02495207f, 0.02555614f, 
    0.09524106f, -0.30076572f, -0.54250139f, -0.37056735f, -0.01878035f, -0.17317215f, -0.00084671f, -0.18673928f, 
    0.05505038f, -0.03217211f, -0.39293912f, 0.37776414f, -0.28597960f, -0.12905143f, 0.05527850f, -0.13798857f, 
    -0.13203208f, 0.10793585f, -0.04083093f, -0.66151661f, -0.19403948f, 0.23502785f, -0.17999697f, 0.06186575f, 
    0.04478052f, 0.03109722f, 0.17753445f, 0.13400030f, 0.01720359f, 0.25112018f, 0.23783825f, 0.09565109f, 
    0.00922603f, -0.07854290f, 0.06137565f, -0.03446303f, 0.08537724f, 0.10209382f, 0.08049505f, -0.33206257f, 
    0.05566092f, -0.06980202f, -0.00754078f, 0.08458678f, 0.00147136f, 0.04900394f, 0.15076916f, -0.31344792f, 
    0.39510843f, 0.08027587f, 0.03384753f, 0.00552725f, 0.04744886f, -0.16081572f, -0.00873900f, 0.00262007f, 
    0.18042634f, -0.41553015f, -0.17132656f, -0.09711315f, 0.00953281f, 0.13283119f, -0.05887254f, 0.02297434f, 
    0.43934789f, -0.00913651f, 0.22384694f, -0.08351775f, -0.07510983f, 0.16399822f, 0.14832734f, 0.09328961f, 
    0.03048937f, -0.00872370f, 0.17501147f, -0.02172978f, 0.01348124f, -0.02493888f, 0.01983947f, 0.04151876f, 
    -0.02762982f, 0.01623715f, -0.23742810f, -0.04380837f, 0.26621377f, 0.30888206f, -0.31228447f, -0.03652041f, 
    -0.03505638f, 0.21426567f, -0.04131456f, 0.13705972f, 0.16632926f, -0.48429620f, -0.05014228f, 0.01677528f, 
    -0.01130938f, -0.10561755f, 0.04308235f, 0.03843320f, -0.68289369f, -0.44551954f, -0.09827437f, -0.07138762f, 
    0.00627690f, -0.04408976f, 0.08735134f, 0.02837380f, 0.03630837f, 0.41173750f, -0.31749609f, 0.01577470f, 
    -0.08736569f, -0.07514193f, 0.11964252f, 0.01243527f, -0.04982490f, -0.02704033f, -0.10342306f, 0.12437910f, 
    -0.29710594f, 0.06624065f, 0.04303917f, -0.12891823f, 0.09330838f, -0.07749081f, 0.04338680f, 0.00680675f, 
    0.13633424f, -0.11967462f, -0.02398240f, -0.04865310f, 0.02205029f, -0.15645671f, 0.09639300f, 0.01556956f, 
    -0.00318337f, 0.01443192f, -0.33132559f, 0.07276055f, -0.05896053f, 0.10510199f, 0.03177287f, 0.15346768f, 
    -0.04319729f, -0.25957000f, -0.06021932f, 0.38315234f, -0.01186999f, 0.02731017f, -0.02835999f, 0.18968533f, 
    -0.05262462f, -0.07022561f, -0.03436324f, 0.04205378f, -0.19118671f, -0.07085557f, 0.03505248f, -0.25913811f, 
    -0.07753669f, -0.00937725f, 0.11606194f, 0.06916994f, 0.02211900f, -0.25472817f, -0.09397543f, -0.09001055f, 
    -0.14098325f, -0.13072713f, 0.08197670f, -0.00159245f, 0.00541085f, 0.22165366f, 0.11198287f, 0.04834584f, 
    -0.00736871f, -0.21990044f, 0.01755000f, 0.08397000f, 0.09989703f, -0.11249785f, 0.07215159f, 0.00536928f, 
    -0.00438894f, -0.07826293f, -0.03475738f, -0.06309705f, 0.07436963f, -0.14980036f, 0.46111974f, -0.07164003f, 
    0.01231656f, -0.06214668f, -0.11992648f, -0.12973823f, -0.09099147f, 0.19162831f, -0.12280384f, 0.19232380f, 
    0.17192702f, 0.12063439f, -0.11155402f, 0.00098564f, 0.10070615f, 0.03533685f, -0.00561558f, 0.03016665f, 
    0.39357343f, -0.13732122f, 0.19845670f, 0.03254643f, 0.17491184f, 0.28776571f, 0.18838951f, 0.15281747f, 
    0.17473398f, -0.16022658f, -0.00907576f, 0.06349121f, -0.04705444f, 0.30639878f, 0.17354989f, 0.02632181f, 
    0.04491034f, 0.22327216f, -0.13298082f, 0.13756460f, 0.10019348f, -0.02024005f, 0.24083292f, 0.12503874f, 
    0.10364395f, 0.08903760f, 0.11568252f, -0.05696133f, 0.03423097f, -0.17219198f, -0.17291388f, 0.12930280f, 
    0.18943499f, -0.02830755f, 0.07945562f, -0.08476909f, -0.01125398f, -0.04469527f, -0.09585944f, -0.19216010f, 
    -0.19603997f, -0.16649653f, -0.05842554f, -0.00926205f, -0.13564393f, -0.13024777f, -0.01867289f, -0.04547328f, 
    -0.10085504f, 0.02432913f, 0.02640858f, 0.10168360f, 0.03274428f, 0.07070693f, -0.12585159f, -0.05635788f, 
    -0.07177417f, -0.09950955f, -0.12104961f, -0.23326759f, 0.08284327f, 0.13413359f, -0.06777729f, -0.01696903f, 
    0.00611416f, -0.04356249f, -0.01533950f, -0.06648086f, 0.02643306f, 0.05903363f, 0.02207784f, -0.26268518f, 
    -0.08728150f, -0.12606509f, -0.05542125f, 0.02231707f, 0.00201175f, -0.01302903f, 0.05433741f, -0.07037082f, 
    0.20247486f, -0.14703341f, 0.19048633f, -0.00781753f, 0.04807504f, 0.03676854f, 0.01604490f, 0.04417983f, 
    0.05724376f, 0.14961243f, 0.08504284f, 0.02473094f, 0.10866461f, 0.03534493f, -0.21732140f, -0.02069849f, 
    -0.03236471f, 0.11146933f, 0.15561022f, -0.17274924f, -0.10903322f, -0.12497155f, 0.08569246f, -0.15533715f, 
    -0.04466928f, 0.20695242f, 0.06269176f, 0.17577539f, -0.16960929f, -0.17576668f, -0.04440806f, 0.02192794f, 
    0.01031881f, 0.09415016f, -0.03364351f, -0.06299720f, -0.07896549f, -0.13984661f, -0.39900404f, 0.07061036f, 
    0.14896636f, 0.03332689f, 0.02618939f, -0.02601028f, -0.16544364f, 0.17150871f, -0.05979590f, 0.04215119f, 
    -0.17027314f, -0.08552392f, -0.04063219f, 0.16272320f, 0.04775219f, 0.03454613f, 0.09366081f, 0.06872895f, 
    -0.22103770f, -0.14413865f, 0.01290061f, -0.27931747f, -0.15588877f, 0.15902035f, 0.02699687f, 0.01106467f, 
    0.23223132f, 0.00408751f, 0.13733332f, 0.03416206f, 0.05504680f, -0.12277327f, 0.00367805f, -0.16279343f, 
    -0.14319414f, 0.09356634f, -0.10797858f, 0.13686901f, 0.10646580f, 0.08316432f, -0.07117771f, 0.08185021f, 
    -0.10748714f, 0.15368052f, -0.16926880f, -0.04155836f, 0.12254728f, 0.16626453f, -0.00706618f, -0.10724917f, 
    -0.01157488f, 0.29145586f, 0.01947092f, 0.13164026f, -0.35256591f, 0.04977235f, 0.01722110f, 0.11398920f, 
    0.07812846f, 0.18018670f, -0.04893655f, 0.11907052f, -0.07571099f, -0.00484683f, -0.23544063f, 0.01608749f, 
    -0.24034679f, 0.02930567f, 0.06859580f, -0.06754312f, -0.06486058f, -0.00143340f, 0.19128200f, 0.19596343f, 
    -0.01159531f, -0.14444315f, 0.03822734f, -0.11128887f, 0.04738082f, -0.04547527f, -0.50681937f, -0.01394841f, 
    -0.02996327f, -0.17630899f, 0.14209586f, -0.04824632f, -0.09361906f, 0.06179217f, 0.02356542f, 0.10770889f, 
    0.20327972f, -0.00051736f, 0.00384642f, 0.11193167f, 0.09243263f, 0.12269914f, -0.04024033f, 0.08226213f, 
    -0.11801460f, -0.39945090f, 0.00726666f, 0.04012451f, 0.03433845f, -0.08518898f, 0.12384844f, -0.12304226f, 
    0.16739275f, -0.19718705f, 0.30025539f, -0.01596764f, 0.04245034f, -0.00626820f, -0.14926666f, -0.05940483f, 
    -0.31729478f, -0.00061962f, -0.25436407f, -0.11180294f, 0.09220804f, -0.01647088f, 0.13953699f, 0.11813678f, 
    -0.18503237f, 0.00756930f, 0.02754973f, -0.04786843f, 0.08587106f, 0.26842019f, 0.00081475f, 0.09088326f, 
    0.06913150f, -0.02648548f, 0.04937468f, 0.08119360f, -0.36036354f, -0.20766892f, -0.13158390f, -0.08580797f, 
    -0.06545810f, -0.15647079f, -0.04419086f, -0.17571604f, 0.06881783f, 0.17426573f, 0.16275620f, -0.15251011f, 
    -0.06835577f, 0.27221653f, 0.11927066f, -0.11939828f, 0.20478387f, 0.10366304f, -0.35934535f, 0.16479804f, 
    0.11255962f, -0.27227178f, 0.05432132f, -0.15412354f, -0.03666492f, 0.09706655f, 0.26657358f, 0.02869057f, 
    0.16267329f, 0.20360459f, 0.25633910f, 0.00053111f, -0.09638827f, 0.15516408f, 0.00165646f, -0.02615075f, 
    0.03057585f, -0.06528311f, -0.02840231f, -0.01573391f, -0.03220073f, 0.05610931f, -0.01433429f, -0.02891552f, 
    -0.02453675f, -0.02459142f, -0.06671011f, -0.01121219f, 0.01150193f, 0.01651341f, 0.00235131f, -0.03808448f, 
    -0.07176676f, 0.03913399f, 0.03784418f, 0.02021426f, 0.00619746f, 0.00605085f, -0.03361159f, 0.04297692f, 
    -0.04480182f, 0.00523976f, 0.02133603f, 0.02299562f, 0.00464866f, -0.02914366f, 0.02423847f, -0.02368121f, 
    -0.05140360f, -0.00669554f, 0.03098492f, 0.04040432f, -0.01025006f, 0.00147823f, -0.00162743f, 0.01156458f, 
    0.02582521f, 0.02130982f, 0.04091575f, -0.06145551f, -0.06613372f, 0.01236494f, -0.06381697f, -0.02518078f, 
    0.00860405f, 0.02267941f, -0.03523640f, -0.06526927f, -0.05249082f, -0.05279547f, 0.03933973f, 0.03790658f, 
    -0.01596707f, -0.01932245f, 0.03193435f, 0.03909306f, -0.03778170f, -0.01291610f, -0.01308553f, -0.00717637f, 
    0.05362846f, -0.01984930f, 0.00157035f, -0.03002355f, -0.02502208f, -0.03444648f, -0.02348940f, -0.03455144f, 
    -0.05310207f, 0.02307023f, 0.04801949f, -0.05305999f, 0.03242119f, 0.02830836f, -0.02886778f, 0.02564015f, 
    -0.06594505f, -0.05719127f, -0.01651733f, 0.02792835f, 0.00005488f, 0.02149625f, 0.00936356f, -0.04296746f, 
    0.01138002f, -0.02971037f, -0.06736032f, -0.04337655f, 0.04211513f, -0.03066235f, -0.04134678f, -0.02810347f, 
    0.00891837f, -0.04575831f, 0.00292530f, 0.04939235f, -0.05717082f, 0.02930138f, -0.00421405f, -0.03493529f, 
    -0.00237450f, 0.00238915f, -0.04046675f, 0.02819108f, -0.04849129f, -0.01740492f, -0.06018451f, -0.00166982f, 
    -0.00325483f, -0.05971220f, -0.04306643f, -0.02782266f, 0.00246090f, -0.02973554f, -0.06518693f, 0.03704846f, 
    0.05119513f, -0.01731608f, 0.03575003f, -0.02469600f, 0.02370784f, 0.03517283f, -0.04832406f, 0.03219777f, 
    -0.04396702f, -0.01423219f, 0.00134607f, 0.01349636f, -0.01650237f, 0.02596309f, 0.00917632f, 0.02138395f, 
    -0.04308209f, -0.01441884f, -0.05490798f, -0.03931141f, 0.03710757f, 0.01119171f, 0.00268675f, 0.01765417f, 
    -0.01066865f, -0.04182878f, -0.06397778f, -0.04146431f, 0.00557202f, 0.02453158f, -0.04634206f, -0.00457662f, 
    0.01838489f, 0.03516858f, -0.00290160f, 0.00216281f, 0.02328560f, -0.03139743f, 0.01510691f, -0.05690227f, 
    -0.01934934f, -0.06442587f, -0.01904196f, 0.00167676f, -0.02191952f, -0.05688259f, -0.05747326f, -0.05887354f, 
    0.04345860f, -0.00444578f, -0.00044439f, 0.04851908f, 0.01870857f, 0.02311115f, -0.00247313f, -0.02959093f, 
    -0.02669505f, 0.00596236f, 0.03986825f, 0.02580469f, 0.03696254f, -0.03349394f, 0.04275006f, -0.04826577f, 
    0.03335043f, 0.03621940f, -0.02082776f, -0.03192311f, 0.03529111f, -0.05276056f, 0.02054288f, -0.00543050f, 
    -0.00591333f, -0.00890402f, 0.02364346f, 0.01499831f, -0.03780768f, -0.03056434f, -0.04613979f, -0.03470006f, 
    0.04104543f, -0.05551951f, -0.06062785f, -0.04434635f, -0.00285266f, 0.03017377f, -0.00085922f, -0.03500507f, 
    -0.00316942f, -0.01971390f, 0.01027457f, 0.02591308f, -0.01579867f, -0.03346890f, 0.01642549f, 0.02348505f, 
    0.02384542f, -0.00327544f, 0.03310654f, -0.01815020f, 0.04836657f, -0.04200753f, 0.00868265f, -0.01679922f, 
    0.00291377f, 0.04423868f, 0.03938800f, 0.03944385f, 0.00013887f, -0.03861397f, -0.04042435f, -0.01674517f, 
    -0.01939831f, -0.00881938f, 0.00616778f, -0.04039824f, -0.00330170f, -0.03659606f, -0.03879154f, -0.00561739f, 
    -0.00066389f, -0.01780215f, -0.05695595f, 0.00986387f, 0.00322230f, 0.00345294f, -0.00901904f, -0.00931929f, 
    0.04063761f, -0.04008885f, 0.00611080f, -0.06636638f, -0.04025876f, -0.04404961f, 0.03387938f, 0.02096039f, 
    -0.06494496f, 0.00975913f, -0.04167637f, -0.01593888f, -0.03407224f, 0.05129198f, 0.02694244f, 0.00836914f, 
    0.04117768f, -0.04842239f, 0.02575778f, 0.02499022f, -0.01516698f, 0.01198708f, -0.02995259f, -0.02206882f, 
    0.01730714f, 0.00629553f, -0.06145231f, -0.05608521f, 0.01228039f, 0.01539597f, -0.04516529f, 0.02562955f, 
    -0.05178332f, -0.05821411f, -0.04650633f, -0.00743238f, 0.03246563f, 0.04953342f, -0.02746695f, -0.01802319f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.11223859f, 0.16449252f, 0.04662159f, 0.26655886f, -0.00224951f, 0.00611224f, 0.09718770f, -0.02389675f, 
    -0.09856987f, 0.23520049f, -0.07303110f, -0.06975974f, 0.07992274f, 0.35865679f, 0.24100448f, 0.04477182f, 
    -0.01263139f, -0.01819747f, 0.01537719f, 0.04907532f, 0.09476963f, 0.04481724f, 0.09216239f, 0.18982324f, 
    0.02881120f, -0.00046656f, 0.25119564f, 0.14576143f, 0.05169598f, -0.10342536f, 0.20945741f, 0.01631727f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.03813178f, 0.29273021f, -0.00010353f, 0.18281035f, -0.21018860f, 0.04734500f, 0.23642080f, -0.11798997f, 
    -0.02422854f, 0.01417023f, -0.34862956f, 0.02785189f, 0.17597984f, 0.17297310f, 0.21652648f, 0.09860671f, 
    0.04738458f, -0.30062613f, -0.16434738f, -0.00798852f, -0.11490384f, 0.03346719f, 0.05195587f, -0.11533496f, 
    0.26653504f, -0.11509120f, 0.37481633f, 0.33246794f, 0.15876032f, 0.05459585f, 0.09391614f, -0.15244058f, 
    0.23273386f, 0.09262382f, 0.15417062f, 0.07058885f, -0.14935821f, -0.14226252f, 0.08834902f, 0.05669714f, 
    -0.07538543f, -0.29151469f, 0.13089959f, -0.07012547f, 0.28165260f, -0.03260410f, 0.12746324f, -0.04018746f, 
    0.08351666f, 0.08822859f, -0.15428986f, 0.05218927f, -0.17851493f, -0.16459832f, -0.03462417f, 0.17449921f, 
    -0.02155813f, -0.08921579f, -0.15093508f, 0.38889325f, -0.03187667f, 0.79071045f, -0.08057324f, -0.16414414f, 
    -0.06939537f, -0.27367938f, 0.27130002f, 0.01442889f, 0.41645262f, 0.16515499f, -0.29708534f, -0.03290825f, 
    -0.24472281f, 0.07354251f, -0.17799060f, 0.21661615f, 0.19342519f, -0.03594227f, 0.42568922f, -0.02640378f, 
    -0.09873857f, 0.11741581f, 0.15934734f, 0.22011042f, -0.07199091f, -0.10662191f, 0.06231057f, 0.03538312f, 
    0.07120747f, -0.16171418f, -0.17589246f, 0.08016182f, -0.21200994f, 0.65857244f, 0.32625684f, -0.14886340f, 
    -0.17140660f, 0.27913159f, 0.13421065f, -0.00906194f, 0.25666651f, -0.15051882f, 0.09602904f, -0.05495512f, 
    0.00188685f, 0.61124045f, -0.14534532f, -0.05390298f, 0.17922421f, -0.28491035f, -0.16768789f, 0.06171328f, 
    0.22609021f, 0.01992255f, -0.09827348f, 0.21582752f, -0.31600896f, -0.15903392f, 0.06758609f, 0.04819647f, 
    0.11884081f, -0.04886966f, -0.01248220f, 0.00453331f, 0.24370819f, -0.25208050f, 0.03563805f, 0.16726734f, 
    0.04520636f, -0.14597732f, 0.01463714f, 0.15704918f, -0.13168289f, -0.16641021f, -0.14463027f, -0.06353364f, 
    -0.18399186f, -0.09242418f, 0.18211597f, -0.07939720f, -0.03173869f, -0.18144220f, -0.15130715f, -0.11246216f, 
    -0.13603842f, -0.13877526f, -0.12933461f, 0.05417061f, -0.15273789f, 0.13416123f, -0.46497762f, -0.10362196f, 
    -0.27061361f, 0.04923108f, -0.09317795f, 0.01882891f, -0.17825787f, 0.08814712f, 0.45613459f, 0.07084837f, 
    0.26331577f, 0.12391232f, -0.04585599f, -0.12807702f, 0.04948612f, 0.09916574f, 0.18846869f, -0.30974567f, 
    0.22997470f, 0.41737512f, -0.16730604f, -0.13861595f, 0.01696294f, -0.17720686f, 0.30675939f, -0.09205098f, 
    -0.16727538f, -0.41636559f, -0.07445894f, -0.24116400f, 0.21386772f, 0.18119581f, 0.60275954f, 0.21044336f, 
    0.25499278f, 0.01940737f, 0.23968372f, -0.34023145f, 0.49961627f, -0.19741395f, 0.08103380f, -0.09862065f, 
    0.36148518f, 0.35950541f, -0.13474765f, 0.26917815f, -0.16451591f, 0.09517275f, 0.09391113f, -0.18644081f, 
    0.10105050f, 0.03263423f, 0.36156872f, -0.18378735f, -0.08665072f, 0.16401112f, -0.48342034f, 0.12122399f, 
    0.50151420f, -0.28375679f, -0.04372451f, 0.07883984f, 0.10632125f, 0.01274631f, -0.29931653f, -0.14376916f, 
    0.05151911f, 0.09210397f, 0.14362364f, -0.07272148f, 0.22306260f, -0.60446471f, 0.02119632f, 0.12053294f, 
    0.00799998f, -0.16526939f, -0.06227878f, 0.02227087f, -0.08304328f, -0.11526699f, -0.09132142f, -0.16614024f, 
    0.02333551f, -0.12165300f, -0.16596156f, -0.16046792f, -0.10562889f, -0.03660694f, -0.03261568f, 0.06245387f, 
    -0.05001891f, -0.06143259f, 0.10801017f, -0.14319451f, -0.08486129f, -0.08870856f, 0.01117332f, 0.06641089f, 
    0.02946449f, -0.16688462f, -0.03414327f, 0.01379262f, -0.01025979f, 0.01891839f, -0.13564269f, 0.01862522f, 
    0.14794791f, 0.08940708f, -0.22321348f, 0.14487202f, 0.03257082f, 0.09444080f, 0.41543916f, -0.19856103f, 
    -0.10131612f, -0.08075416f, -0.31812680f, -0.32738450f, -0.19731283f, 0.18140692f, 0.48796189f, -0.00305620f, 
    0.04077392f, -0.36915761f, 0.11204451f, 0.27816054f, 0.30271751f, -0.10713263f, 0.30294985f, -0.02861129f, 
    0.12185273f, 0.02551455f, 0.23179741f, -0.08475729f, 0.42889297f, -0.40339464f, -0.02615865f, 0.03481452f, 
    -0.04485020f, -0.02377070f, -0.00879965f, -0.60002935f, 0.17354782f, -0.10369074f, -0.08276321f, 0.07531634f, 
    0.27150786f, 0.23365863f, -0.03273623f, -0.10329502f, 0.08818369f, -0.14698341f, 0.29354677f, -0.04463550f, 
    0.01397943f, -0.18430860f, 0.12447581f, 0.15414439f, 0.17351995f, -0.07518364f, 0.23527169f, 0.19424985f, 
    -0.27555761f, -0.14656220f, -0.26458150f, 0.16818227f, 0.20164843f, 0.66646737f, 0.16258161f, -0.05932470f, 
    -0.27080792f, 0.34535357f, 0.18229878f, 0.14521125f, -0.12069315f, 0.13977024f, 0.07694271f, 0.33419505f, 
    -0.18172927f, -0.00123915f, 0.05554477f, -0.15444160f, -0.10676245f, 0.35472861f, -0.22282812f, 0.12467851f, 
    0.11422291f, 0.02503137f, -0.05078679f, 0.07978696f, 0.12968625f, 0.03093512f, 0.03415890f, -0.20247635f, 
    0.20475993f, -0.07869024f, 0.02675653f, 0.31370106f, 0.17331795f, -0.21304950f, 0.02594500f, -0.16130228f, 
    -0.12961510f, 0.26076689f, 0.00887867f, 0.04526526f, -0.15517192f, -0.09973724f, -0.09664688f, -0.42945817f, 
    -0.08584071f, -0.21375756f, -0.07476529f, -0.16222502f, -0.02301421f, -0.31278744f, 0.16690360f, -0.14483687f, 
    -0.06056173f, 0.17551599f, 0.03784598f, 0.14535639f, -0.22434209f, -0.15292574f, 0.14375927f, 0.00869301f, 
    0.26932392f, 0.01648012f, -0.00123438f, -0.05143610f, -0.46753448f, -0.04300042f, 0.18265739f, -0.11802289f, 
    -0.34311542f, 0.03000236f, 0.14512089f, 0.05350956f, 0.46287280f, -0.05776817f, -0.26674646f, 0.02724236f, 
    -0.12138161f, 0.42162755f, -0.23528841f, 0.28272179f, 0.24102542f, 0.02690542f, -0.07449844f, -0.02300279f, 
    -0.30541912f, -0.05919218f, -0.05093433f, -0.08552411f, -0.13258700f, 0.12711978f, 0.05153913f, 0.10167799f, 
    -0.32966620f, -0.02010486f, 0.00777702f, -0.13519295f, 0.13884099f, 0.19229050f, 0.39577445f, -0.05329286f, 
    -0.05621067f, -0.13948669f, -0.09529567f, -0.09616970f, 0.05834655f, 0.11590904f, -0.12498020f, -0.16584665f, 
    0.07207809f, -0.19853756f, -0.18513468f, 0.12768961f, -0.05258868f, 0.04295102f, -0.12639745f, 0.16165264f, 
    -0.04772874f, 0.12306383f, 0.14161845f, -0.14325930f, 0.01478073f, 0.12218998f, -0.10966095f, 0.09968825f, 
    -0.02424846f, 0.08773013f, -0.15752092f, -0.16336833f, -0.15769187f, 0.03168471f, 0.02109617f, 0.13624480f, 
    0.46032175f, 0.08838573f, 0.00487194f, -0.20180799f, -0.15538622f, -0.02707581f, 0.18891691f, 0.20994262f, 
    0.06237775f, -0.10823038f, 0.34851789f, -0.16211540f, -0.25726232f, -0.02044571f, -0.54898846f, -0.16869192f, 
    0.31864861f, 0.16472976f, -0.12469254f, 0.00639507f, 0.20556368f, -0.14687793f, 0.19518763f, -0.45252493f, 
    -0.18227889f, 0.17135754f, 0.02680521f, 0.16356561f, -0.02429159f, 0.24638130f, -0.18387361f, -0.11285146f, 
    0.24340050f, -0.19800715f, -0.07773064f, -0.28490245f, 0.28983444f, 0.05627101f, 0.11132286f, -0.02043538f, 
    0.21224092f, 0.01535847f, 0.28745422f, 0.11262784f, -0.10799017f, -0.01538783f, 0.22599208f, 0.16497780f, 
    0.29245746f, -0.22324461f, 0.02494660f, 0.16116950f, 0.18231566f, 0.01023660f, 0.10470795f, -0.12372466f, 
    0.10543285f, -0.05263026f, -0.32439181f, -0.49476808f, -0.02496302f, 0.12398942f, 0.11544287f, -0.00920357f, 
    -0.03200947f, -0.19270067f, 0.22919773f, 0.11320255f, 0.39229318f, 0.06570152f, 0.20637174f, 0.01423741f, 
    -0.09778313f, 0.07263100f, -0.11213905f, 0.17380808f, 0.00023181f, 0.23309794f, -0.15183586f, 0.11900422f, 
    -0.44020554f, -0.19380309f, 0.04983889f, 0.19638006f, 0.23760478f, 0.01801598f, 0.10056801f, -0.12484221f, 
    0.08972978f, -0.17298964f, 0.24758075f, -0.61177784f, 0.07149491f, -0.60645306f, 0.30254912f, -0.09286022f, 
    -0.12112594f, 0.06653552f, -0.14616959f, -0.08640812f, 0.05410615f, 0.07470415f, -0.18323986f, 0.01008211f, 
    -0.11543058f, -0.16709404f, 0.12580627f, -0.13314191f, -0.02415805f, -0.00141689f, -0.02739292f, 0.08958606f, 
    -0.18043955f, 0.01756331f, -0.03265051f, 0.07196413f, -0.16687174f, 0.16319516f, 0.02555956f, -0.15529419f, 
    -0.17670241f, 0.15569150f, -0.03237306f, 0.07889275f, -0.13807042f, 0.12121663f, -0.08398650f, 0.14674860f, 
    0.64787579f, 0.17205493f, 0.04569652f, -0.08125161f, -0.17881873f, -0.06931725f, 0.16741064f, 0.15398002f, 
    -0.11578019f, -0.01824971f, 0.00900444f, -0.32804778f, 0.04314288f, -0.07642736f, 0.13274072f, -0.05528494f, 
    0.35587656f, -0.16462749f, 0.04987343f, 0.27281901f, -0.17914017f, 0.02389182f, 0.18713748f, -0.57456255f, 
    -0.02515243f, -0.06609914f, 0.36530516f, 0.27612650f, 0.33284950f, -0.26525378f, -0.17207813f, 0.13135789f, 
    -0.17011210f, 0.00922354f, -0.11094218f, -0.09250350f, 0.02988192f, -0.04404890f, -0.00942960f, 0.40150458f, 
    0.18602702f, 0.18978964f, -0.23622015f, 0.27828538f, -0.32171887f, 0.27347821f, -0.87599576f, -0.15232772f, 
    0.01484480f, -0.06776032f, -0.05475777f, -0.00292554f, 0.03025935f, 0.08446968f, -0.00743750f, -0.14227873f, 
    -0.18569495f, 0.10394798f, -0.11735694f, -0.15617850f, 0.31563967f, -0.15079911f, 0.26792666f, -0.16591451f, 
    -0.51201683f, 0.24276200f, 0.18217719f, 0.27812380f, -0.02360212f, 0.00201759f, 0.11761134f, 0.20693558f, 
    -0.14819820f, -0.62347329f, -0.23872113f, 0.13338087f, -0.09176435f, 0.05044914f, 0.32783806f, -0.08659455f, 
    -0.50163597f, -0.54899019f, -0.09696490f, 0.06906193f, 0.22282469f, -0.00953899f, -0.33558622f, -0.23919836f, 
    0.17266074f, -0.03012547f, -0.10745427f, 0.13250461f, 0.05181382f, -0.47824940f, 0.23981096f, 0.12270136f, 
    0.30107054f, -0.05977527f, 0.30501950f, -0.18828900f, 0.22668178f, 0.14019491f, -0.00922054f, 0.27905327f, 
    -0.29517400f, 0.27648199f, -0.27670774f, 0.22636811f, -0.12837505f, -0.04292928f, -0.08888546f, 0.09188673f, 
    0.37106323f, 0.14496243f, 0.09413759f, 0.36764205f, -0.09981614f, 0.07868431f, 0.05026054f, -0.64591426f, 
    -0.03684296f, -0.11933189f, 0.23994549f, 0.72156495f, 0.22764812f, 0.19265658f, 0.20047019f, 0.08770013f, 
    0.17508474f, -0.09978617f, 0.03884994f, -0.20846988f, -0.07118382f, 0.00807108f, 0.11877144f, -0.00394250f, 
    -0.06999961f, -0.52402252f, -0.15272897f, 0.03475774f, -0.08457400f, 0.02677060f, 0.29065037f, -0.03156208f, 
    -0.26037151f, 0.21072370f, 0.10666246f, 0.26838532f, 0.19026108f, -0.03263826f, 0.32069963f, 0.01057713f, 
    -0.31565306f, -0.01531153f, -0.12923531f, -0.37695622f, -0.03023369f, -0.33508429f, 0.11879265f, -0.11448506f, 
    0.06890613f, 0.22996873f, -0.28918606f, -0.21366122f, -0.03578779f, 0.15864736f, 0.14658123f, 0.41286486f, 
    0.21514371f, 0.24460822f, 0.12209732f, -0.00690086f, 0.06851932f, 0.15324436f, -0.29295996f, -0.05446007f, 
    0.36171931f, -0.05052249f, 0.03294805f, -0.05842737f, -0.05805058f, -0.10715587f, 0.03764309f, 0.24222668f, 
    -0.12756041f, -0.08910052f, -0.09382685f, 0.55627567f, 0.49771538f, 0.26322103f, 0.04604491f, 0.05995229f, 
    -0.04487302f, 0.09547627f, -0.08747421f, -0.25378942f, 0.36105609f, -0.10269313f, -0.00522470f, 0.23375006f, 
    0.03199136f, -0.23748432f, 0.18578526f, 0.30071187f, -0.16026880f, -0.01887340f, 0.28491399f, 0.07662866f, 
    0.30196363f, -0.03822611f, 0.15844548f, 0.05903948f, 0.24104011f, 0.02717303f, -0.20733204f, -0.54149455f, 
    0.20710392f, -0.01133485f, -0.14622532f, -0.45753682f, -0.10584147f, -0.11489445f, 0.23247141f, -0.06493367f, 
    -0.37029275f, 0.19760984f, 0.31685472f, -0.09602947f, 0.09035582f, -0.13369437f, 0.21167932f, 0.14460650f, 
    -0.29501370f, -0.02214903f, -0.32771644f, 0.23076226f, 0.22480872f, 0.08096810f, 0.49734181f, -0.09542461f, 
    0.05289992f, -0.08206291f, -0.11020750f, 0.27139175f, -0.11960888f, 0.02024892f, -0.20241302f, -0.32300588f, 
    0.01599975f, 0.04882485f, -0.03153121f, 0.47256276f, 0.04630475f, 0.16445863f, -0.13298473f, 0.15993200f, 
    -0.10348973f, -0.06873953f, -0.38745067f, -0.55269980f, 0.09753027f, -0.00702743f, -0.08307815f, 0.22570933f, 
    0.25387824f, -0.19309445f, 0.21870267f, 0.03916077f, -0.48155579f, 0.12737781f, 0.05755506f, -0.04899229f, 
    0.33031887f, 0.09465111f, -0.08613490f, -0.02748032f, 0.33111802f, 0.14597738f, 0.05708761f, -0.28110519f, 
    -0.24072397f, -0.12907587f, -0.22508855f, -0.11797117f, -0.01362494f, 0.28409952f, -0.05639274f, 0.16606428f, 
    -0.14170720f, 0.22410326f, 0.11227079f, 0.12791467f, 0.10617127f, -0.08333046f, 0.26114979f, -0.37995893f, 
    0.19390348f, 0.23649959f, 0.00924398f, 0.15474024f, -0.37591195f, 0.21419764f, -0.60117894f, -0.08083511f, 
    -0.45170185f, -0.33068141f, 0.11558432f, -0.14383847f, 0.23410822f, -0.04270722f, -0.05798622f, 0.05334612f, 
    0.18276481f, -0.15865435f, 0.17823550f, -0.39619699f, -0.30041939f, -0.36815411f, 0.23329642f, -0.02783099f, 
    -0.10567059f, 0.29058379f, -0.10572262f, 0.01166394f, 0.12656212f, 0.08117829f, 0.24530488f, -0.30534649f, 
    -0.16358657f, -0.12859266f, -0.03203445f, 0.05073654f, 0.02491476f, 0.22095856f, -0.01941658f, 0.08228827f, 
    -0.29491746f, 0.08876271f, -0.03288545f, 0.07750312f, 0.33715776f, 0.04049726f, -0.03178010f, 0.03431093f, 
    0.23627846f, 0.01715544f, 0.35795051f, -0.48767668f, 0.26775348f, -0.82903171f, 0.01029155f, -0.05879813f, 
    0.04910200f, -0.30391079f, 0.13212961f, 0.29070690f, -0.08507373f, 0.02053417f, -0.26688403f, -0.10536473f, 
    -0.22588068f, 0.29961571f, -0.28656849f, 0.22044143f, 0.13378249f, 0.37550756f, -0.11243599f, -0.11541347f, 
    -0.42073256f, 0.31860223f, -0.04744773f, 0.28168157f, 0.05556610f, -0.08187886f, 0.25516981f, 0.07736926f, 
    -0.43076542f, -0.07751665f, 0.18049523f, 0.17507152f, -0.41928995f, 0.15557167f, 0.41164953f, 0.02719956f, 
    -0.14533326f, 0.35637909f, 0.01093514f, 0.07877146f, -0.35457087f, 0.05608175f, 0.14147660f, 0.22248891f, 
    0.25834954f, -0.22551936f, 0.29247668f, 0.08060782f, 0.12858707f, -0.06673384f, -0.26029554f, -0.05887401f, 
    0.31670281f, -0.20937110f, 0.11909579f, -0.23366401f, 0.10837010f, -0.07662313f, -0.29486462f, 0.15611410f, 
    0.24240339f, -0.00451281f, -0.01235160f, 0.29819417f, -0.15192227f, 0.26439029f, -0.10772456f, -0.01686249f, 
    0.02504831f, -0.01317825f, -0.19354004f, -0.20507954f, -0.05772341f, 0.06412808f, 0.12811872f, 0.43129528f, 
    -0.03896601f, 0.26348478f, 0.16582209f, 0.07879680f, 0.15136185f, 0.27948684f, -0.20020188f, 0.09613644f, 
    -0.00428240f, 0.15706514f, -0.10973729f, 0.22006342f, -0.20219131f, -0.05339270f, 0.21657147f, 0.03936477f, 
    -0.41227975f, -0.05577428f, 0.12889926f, 0.54722667f, 0.32887805f, 0.39115766f, 0.23437849f, 0.13755637f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.27848455f, -0.04042973f, 0.03761990f, -0.18394168f, -0.04317860f, 0.23857963f, 0.02670710f, -0.15717374f, 
    0.23888032f, -0.02176416f, 0.34482133f, 0.23460060f, 0.23190619f, -0.16398068f, 0.14944059f, -0.25409231f, 
    0.17390853f, -0.17413802f, -0.05920212f, 0.13576190f, 0.17285945f, 0.11861853f, -0.03803724f, -0.05773601f, 
    0.05042456f, 0.19468647f, -0.07954269f, 0.05578032f, 0.11043965f, 0.38381904f, -0.21912125f, 0.30437282f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.10625789f, -0.11821751f, 0.14443453f, -0.23051906f, -0.32352749f, -0.13356890f, 0.07168383f, 0.00203627f, 
    -0.03479770f, -0.27774307f, 0.17571145f, -0.16656309f, 0.02970709f, -0.13697490f, -0.21401791f, 0.49701026f, 
    0.38896391f, -0.06397984f, -0.02004134f, -0.24720995f, -0.00226912f, 0.12325677f, 0.31038037f, -0.49255538f, 
    0.75406986f, 0.23275481f, 0.28933689f, 0.17525443f, 0.31854934f, 0.04777549f, 0.11908776f, -0.17708506f, 
    -0.10704882f, -0.09076022f, 0.15422791f, 0.16378826f, 0.40264976f, -0.42455876f, -0.15957788f, -0.12484084f, 
    -0.19741641f, 0.37910628f, 0.05394081f, -0.13794738f, 0.21590118f, 0.00165017f, -0.05001356f, 0.40745142f, 
    0.01534875f, 0.06186264f, 0.04442250f, 0.05610730f, 0.60380089f, 0.19507401f, -0.42217553f, 0.15233813f, 
    0.49743670f, 0.31587899f, 0.30655006f, -0.05064005f, -0.20641293f, -0.15396127f, 0.09887211f, 0.17901160f, 
    -0.23529769f, -0.03391594f, 0.22725175f, -0.14984241f, 0.00520564f, -0.59036130f, 0.09421828f, -0.02228249f, 
    -0.48402277f, 0.27669853f, 0.05739515f, -0.18240224f, 0.40105766f, 0.14563051f, 0.03920624f, 0.21980669f, 
    -0.03060101f, 0.06808313f, -0.36779860f, 0.38001099f, -0.08573126f, 0.27550110f, 0.12499994f, 0.18914412f, 
    0.53023612f, -0.00074319f, 0.40777612f, 0.20056269f, -0.23812178f, 0.12459662f, -0.16403323f, 0.14548014f, 
    -0.07276157f, 0.08064794f, -0.01787764f, -0.17516100f, 0.08265672f, -0.15641914f, 0.06654707f, 0.16272557f, 
    0.00018673f, -0.00439525f, 0.10331831f, 0.09887910f, -0.03440988f, -0.03128167f, -0.07317177f, 0.08132096f, 
    -0.11746915f, 0.00725653f, 0.05015181f, 0.14517164f, -0.08982319f, 0.03694833f, -0.04140838f, -0.01175871f, 
    0.09938224f, -0.01758462f, -0.17783272f, -0.10648082f, 0.06485806f, -0.11887252f, -0.04259947f, 0.13077924f, 
    0.19848147f, 0.16201043f, 0.21443844f, 0.10390465f, -0.02203801f, 0.16713497f, -0.49827477f, 0.04530550f, 
    0.28561673f, 0.22734316f, 0.08464706f, 0.09841584f, -0.19841516f, -0.06932265f, -0.13141198f, -0.55644155f, 
    -0.30623162f, -0.08964304f, 0.15903674f, -0.12799615f, 0.27413040f, 0.31598803f, 0.26731515f, 0.12046466f, 
    -0.37039959f, 0.46523935f, -0.22852618f, -0.78425479f, -0.02748593f, 0.06425774f, -0.03217080f, 0.09465432f, 
    0.25648761f, -0.04350030f, -0.01173084f, 0.32295826f, -0.20086928f, -0.26981384f, 0.17403249f, 0.11898910f, 
    0.26914138f, -0.10841516f, 0.06700210f, -0.00008735f, 0.11112949f, -0.01047526f, -0.12324543f, -0.09696463f, 
    -0.06649484f, -0.07247894f, 0.39145330f, -0.09531812f, 0.13697794f, 0.27377862f, 0.19970724f, -0.15916534f, 
    0.10281098f, 0.44455501f, -0.36981535f, -0.60401922f, 0.10116243f, 0.09499427f, -0.29392037f, -0.13035600f, 
    -0.24507394f, 0.22632942f, -0.00148419f, -0.14235120f, -0.05276557f, -0.18600456f, 0.31406716f, 0.16263787f, 
    0.14471671f, 0.22864054f, 0.00893191f, 0.06756230f, -0.19977352f, 0.09618811f, 0.63711262f, 0.47208598f, 
    -0.13313611f, -0.02828922f, 0.45242506f, 0.17131892f, 0.09799011f, 0.27773085f, 0.37513456f, 0.38040322f, 
    0.51610482f, 0.18712471f, 0.42173472f, -0.32819533f, -0.26600516f, 0.06122620f, -0.24197406f, 0.37145478f, 
    0.14136539f, -0.00800094f, 0.24554209f, -0.42155263f, -0.08955783f, -0.00950319f, -0.19357309f, 0.14249218f, 
    0.19932009f, 0.15801989f, -0.03419983f, -0.36475605f, 0.02532724f, -0.13392949f, 0.07534683f, 0.62979120f, 
    0.15050790f, 0.14543760f, -0.04955660f, 0.00298574f, 0.32667565f, -0.17150983f, 0.02366080f, -0.16419216f, 
    0.42012557f, -0.12093136f, 0.50420552f, 0.40585622f, -0.20008875f, 0.28890377f, -0.05408104f, -0.23001799f, 
    -0.01766422f, 0.04890970f, -0.24495579f, -0.38833049f, 0.01246969f, -0.17484513f, 0.55234075f, 0.01202877f, 
    0.33259186f, -0.26116404f, 0.34713203f, -0.11440986f, -0.30175656f, -0.06141669f, 0.27009144f, -0.63406819f, 
    0.12711552f, 0.04695914f, 0.22364295f, 0.20883164f, -0.21522596f, 0.01490868f, 0.08671816f, 0.13875958f, 
    -0.51656258f, -0.03544096f, 0.13117576f, 0.12443609f, 0.06012494f, 0.14328323f, 0.06163844f, 0.32960749f, 
    -0.04810088f, -0.41984957f, -0.05047918f, -0.34712946f, 0.04820382f, 0.32159492f, 0.03425675f, 0.06398281f, 
    0.24205205f, 0.12387395f, 0.00761223f, -0.02398081f, -0.01094939f, -0.00313074f, -0.05599128f, 0.18783669f, 
    0.21216825f, 0.01531907f, -0.24346192f, 0.14663383f, -0.09865548f, -0.28854072f, 0.39727193f, -0.17648809f, 
    0.11250880f, -0.13690411f, 0.17526977f, 0.64521533f, 0.36695749f, 0.22245108f, -0.12562257f, -0.03529405f, 
    0.17938094f, 0.09946901f, -0.05991626f, -0.22664946f, 0.12089171f, 0.14929886f, 0.48053360f, 0.10816396f, 
    0.34751758f, -0.14173250f, -0.04100836f, -0.11676464f, -0.34869379f, -0.13133743f, 0.35583541f, 0.20784895f, 
    0.25323728f, -0.07900909f, 0.05688063f, -0.21620438f, 0.43879244f, -0.39011484f, -0.16431613f, -0.02107523f, 
    0.25719315f, -0.05281213f, -0.84402239f, 0.20204146f, -0.05451248f, -0.08866922f, -0.09076192f, -0.15075384f, 
    -0.09958982f, 0.05924896f, 0.26366264f, 0.30148485f, 0.06353041f, 0.27031851f, -0.10671419f, 0.08561880f, 
    0.03006193f, 0.31325623f, -0.00555553f, -0.17549020f, 0.27139834f, -0.00073286f, -0.18430030f, 0.37354216f, 
    0.08160320f, 0.04603009f, -0.09599315f, -0.16233684f, -0.26347205f, 0.11052559f, 0.03681672f, 0.08416572f, 
    -0.37068605f, -0.10078157f, -0.23735562f, -0.11554708f, 0.04773062f, 0.29823104f, -0.28294238f, 0.24228334f, 
    0.18038604f, 0.13398859f, -0.08055022f, -0.00427402f, -0.04050515f, 0.32645035f, 0.05505189f, 0.11927430f, 
    0.13666815f, 0.42183402f, -0.24448244f, 0.10436204f, 0.08433162f, 0.02718153f, -0.30527112f, -0.11480805f, 
    0.06307697f, 0.10593572f, 0.35442516f, -0.47977367f, -0.30522645f, -0.54982185f, 0.33949670f, 0.50239241f, 
    -0.12416980f, -0.26494598f, -0.17224056f, -0.26834095f, 0.19928031f, -0.06824323f, 0.03054805f, -0.06638293f, 
    0.18305552f, -0.01352609f, 0.21352696f, 0.29446009f, -0.30582207f, 0.17048541f, 0.12753411f, -0.05679031f, 
    0.20444497f, -0.05963931f, 0.19129582f, -0.05953322f, -0.03450295f, -0.02304259f, -0.18064843f, -0.05652790f, 
    0.33294466f, -0.09980030f, 0.40875271f, -0.01541660f, 0.32548022f, -0.02061813f, -0.27339906f, 0.03238485f, 
    0.02268099f, 0.33457503f, -0.43969777f, -0.17052826f, 0.41742861f, -0.16903856f, -0.09297924f, -0.14661291f, 
    -0.13619973f, -0.45349604f, -0.32760808f, 0.09930198f, 0.09997980f, 0.31978047f, 0.01974983f, 0.04368858f, 
    0.28060684f, 0.34772378f, 0.12327813f, -0.17077014f, -0.04797172f, 0.08466206f, 0.22129118f, 0.47111195f, 
    0.08484870f, -0.02673933f, 0.05715194f, 0.19315819f, -0.21536815f, -0.09917147f, 0.15325154f, 0.12637258f, 
    0.50971383f, -0.28261194f, 0.44620666f, -0.05386703f, -0.00186778f, -0.45501301f, -0.24471156f, 0.02690656f, 
    0.06288485f, 0.27324373f, -0.02058485f, 0.14114220f, 0.30464798f, 0.32795829f, 0.12718669f, 0.12100390f, 
    0.05131466f, 0.65263796f, -0.16283926f, -0.26514041f, 0.02500092f, 0.03604073f, -0.01658011f, 0.37022704f, 
    0.04998161f, -0.04409190f, 0.00475671f, -0.10997291f, -0.17177540f, -0.04326742f, -0.29407957f, 0.14839576f, 
    0.18791765f, 0.05482133f, 0.16508970f, -0.21566950f, -0.25568780f, 0.00562944f, 0.12649198f, -0.00688874f, 
    0.32515973f, -0.22525048f, 0.06499981f, 0.32891715f, 0.07314416f, 0.55871415f, 0.13411899f, 0.10515444f, 
    0.06452280f, 0.10677929f, 0.18744582f, 0.13170366f, 0.35831702f, 0.11808910f, -0.03564867f, 0.01905281f, 
    0.15621749f, -0.17323241f, 0.08424748f, -0.08245032f, -0.20414598f, -0.01338068f, -0.27572346f, 0.12030853f, 
    -0.36314109f, -0.11947474f, -0.31614015f, 0.02200460f, 0.03340393f, -0.08077564f, 0.01583939f, 0.03218272f, 
    0.33023715f, -0.03265601f, -0.01706404f, 0.14399113f, 0.10020995f, 0.02568663f, 0.40006748f, 0.07118777f, 
    0.23248564f, -0.33300117f, 0.08532499f, 0.06149090f, -0.31382790f, 0.03480044f, -0.21675628f, -0.37740970f, 
    -0.04480411f, 0.17644900f, -0.74048883f, -0.31883636f, 0.69905597f, -0.71961820f, -0.15453070f, -0.16313282f, 
    0.29903832f, 0.09403338f, -0.33209372f, 0.43764493f, 0.11275294f, 0.03046921f, -0.05555052f, -0.26785520f, 
    0.24322172f, -0.03587986f, -0.39746988f, -0.19022614f, 0.04940723f, -0.06289585f, 0.28719485f, -0.01663332f, 
    0.15248735f, -0.13084553f, 0.21140817f, -0.20438543f, -0.21314098f, -0.05796690f, 0.39394176f, -0.13382563f, 
    -0.22276261f, -0.04359461f, 0.42518610f, 0.05183066f, 0.01716469f, 0.19602570f, -0.12093575f, 0.23225945f, 
    -0.13932894f, 0.19985740f, 0.05980467f, -0.12226494f, 0.04110200f, -0.09044278f, -0.01004255f, 0.23069167f, 
    -0.13051869f, -0.10980173f, 0.15770151f, 0.16215096f, 0.05492657f, -0.09585065f, -0.03334595f, -0.00997850f, 
    -0.14475062f, 0.05902031f, -0.06882694f, -0.15395068f, -0.16788492f, -0.00605941f, -0.09344776f, -0.16638520f, 
    -0.16072303f, 0.04553387f, 0.09890143f, -0.00268789f, -0.03322619f, 0.08813152f, 0.11933869f, -0.17348425f, 
    -0.06469847f, -0.13531262f, -0.06534519f, 0.01850955f, 0.06206826f, -0.11087260f, -0.08785629f, -0.13898082f, 
    0.13555938f, 0.21295147f, -0.14829595f, -0.15817083f, -0.13799076f, -0.01238613f, 0.19923417f, -0.13188964f, 
    -0.01882903f, -0.16757751f, 0.23092051f, -0.01021016f, -0.36483994f, -0.00412651f, 0.52493745f, -0.14792730f, 
    -0.18087418f, 0.17176856f, 0.23162460f, 0.06893235f, 0.35154703f, 0.16543446f, -0.27167985f, 0.15299644f, 
    -0.04220391f, -0.08330739f, 0.24119435f, -0.09310934f, 0.13275665f, 0.15337244f, 0.07111188f, 0.04201236f, 
    0.11776078f, -0.17545982f, -0.04059936f, 0.02753249f, 0.16469671f, -0.19028889f, 0.12414432f, 0.02648550f, 
    0.09407806f, -0.14729889f, -0.04754294f, -0.14753693f, -0.06689189f, -0.07275306f, -0.19858697f, -0.07385670f, 
    -0.12504563f, 0.14925791f, -0.00882015f, -0.00093897f, -0.19534306f, 0.08569811f, 0.14159578f, 0.08311413f, 
    0.13677518f, 0.10264064f, 0.01694024f, 0.01368776f, -0.09391003f, -0.18812586f, 0.03099569f, -0.10045413f, 
    -0.11467232f, -0.61282384f, -0.07808663f, 0.41024470f, 0.28104651f, -0.00576169f, 0.52428102f, -0.09401457f, 
    0.23934983f, -0.23073450f, -0.00490406f, 0.33837268f, 0.05335390f, 0.12025964f, -0.09425511f, 0.25999033f, 
    -0.00756851f, -0.12222359f, 0.03638427f, 0.32912329f, -0.38665915f, 0.11409267f, -0.28028449f, 0.16704151f, 
    0.15050401f, -0.23236425f, 0.23824368f, 0.52921468f, 0.21909273f, -0.05181374f, -0.26125911f, -0.02202759f, 
    0.27539349f, -0.05937447f, -0.15854253f, 0.22670999f, 0.21529362f, -0.08727811f, 0.48339060f, 0.19979922f, 
    0.04958713f, 0.09230979f, 0.05533858f, 0.12586190f, -0.00672917f, 0.11646849f, 0.06165814f, -0.09081497f, 
    -0.20284282f, -0.17765445f, 0.21958584f, 0.05629075f, 0.34889722f, 0.06866718f, -0.57215613f, 0.23653781f, 
    -0.26870814f, 0.27167749f, -0.19166070f, 0.25286037f, -0.08984038f, -0.19263381f, 0.16106932f, 0.19614793f, 
    -0.03282850f, 0.00683805f, -0.17678016f, 0.28008658f, -0.17103094f, -0.03597740f, 0.21621075f, 0.16629505f, 
    -0.01842471f, -0.28193659f, 0.19075517f, -0.12382130f, 0.45729944f, 0.13696742f, -0.35775605f, -0.25775072f, 
    -0.09325705f, 0.20216279f, -0.56163961f, 0.13852784f, -0.12643662f, -0.10314561f, -0.31896713f, 0.41452685f, 
    -0.16542867f, 0.19766179f, -0.20433857f, 0.51138449f, 0.18000659f, 0.03588323f, 0.20285845f, 0.16028234f, 
    0.08224377f, -0.37907487f, 0.06254083f, 0.03466539f, 0.04396495f, -0.23960321f, -0.10755517f, -0.09111539f, 
    0.04786692f, -0.25614694f, 0.12262157f, -0.34039828f, 0.55540192f, -0.11863888f, -0.07885223f, -0.41080040f, 
    0.44833353f, 0.00037917f, -0.01413022f, 0.14592800f, 0.02057514f, 0.16830362f, 0.01150157f, 0.01295231f, 
    -0.56095511f, -0.03051611f, -0.35652560f, 0.15859242f, 0.05165775f, 0.40072328f, -0.52037537f, 0.33791935f, 
    0.11695998f, -0.53805190f, -0.43158081f, 0.07907864f, 0.15597844f, 0.34364757f, 0.20697343f, -0.05368400f, 
    0.33852181f, -0.18305363f, -0.03356218f, -0.82782161f, -0.15083157f, 0.06349637f, 0.10012505f, -0.05633330f, 
    0.35785064f, 0.01633180f, 0.33758307f, 0.23277110f, -0.17930968f, 0.11190372f, 0.03740195f, 0.12615587f, 
    0.21724196f, -0.11303762f, -0.09018990f, 0.34066066f, 0.12793684f, -0.19866341f, -0.21362591f, -0.00131357f, 
    -0.03176159f, 0.03210201f, -0.03411679f, -0.14940493f, 0.39532408f, 0.00031654f, -0.05841738f, -0.01483946f, 
    -0.20549305f, 0.38663942f, 0.22877926f, -0.57797599f, 0.22524814f, -0.01135761f, 0.25866160f, -0.05280751f, 
    0.04829236f, -0.06528197f, 0.08060613f, 0.42677400f, -0.21166807f, 0.09278575f, 0.11509255f, 0.33561617f, 
    -0.06751866f, -0.06882624f, 0.13347441f, 0.04745169f, -0.16204689f, 0.08392941f, -0.39068866f, 0.40420675f, 
    -0.12666121f, 0.14139247f, 0.11840431f, 0.01313206f, -0.04823538f, -0.11447868f, -0.03624270f, -0.03522484f, 
    -0.14294173f, 0.10404933f, -0.03213992f, -0.11853635f, -0.02757921f, 0.13737714f, -0.03383581f, 0.08522567f, 
    -0.12054079f, -0.03421213f, 0.18720220f, -0.19047740f, -0.12742996f, -0.11177526f, -0.06938012f, 0.07719989f, 
    0.12492745f, -0.16004182f, -0.08742508f, 0.14109495f, -0.01652543f, -0.10640224f, -0.11942351f, -0.01957189f, 
    0.22723019f, -0.21150786f, 0.19386825f, -0.16375077f, 0.42538622f, -0.06667885f, -0.62370521f, -0.00052306f, 
    0.10315753f, 0.03278195f, 0.12458999f, 0.21177749f, 0.47520369f, 0.05472844f, -0.16360681f, -0.27468094f, 
    0.12372613f, -0.10026573f, -0.29800102f, 0.12463145f, 0.71351326f, 0.29061079f, 0.04023681f, -0.22267042f, 
    -0.06577296f, 0.54295927f, -0.35653162f, -0.07276677f, -0.03952466f, 0.27207386f, -0.15971646f, 0.01967199f, 
    0.09831115f, -0.00209706f, -0.45913711f, -0.14940229f, 0.15138870f, 0.01911209f, 0.02518394f, 0.13995068f, 
    0.24162363f, 0.59242356f, -0.13687703f, -0.80753684f, -0.36738566f, -0.07981165f, 0.02561753f, 0.09962581f, 
    -0.02727278f, -0.01111254f, 0.22129108f, -0.08652068f, 0.13068253f, -0.23432784f, 0.14447416f, 0.09255534f, 
    -0.08843500f, 0.10850296f, -0.20694801f, -0.16438988f, 0.23029470f, -0.53086472f, 0.09304305f, -0.39217529f, 
    0.24401787f, -0.17338961f, 0.26229021f, 0.05280749f, -0.07061484f, 0.30927292f, -0.67487669f, 0.16170476f, 
    0.37680477f, 0.50225914f, -0.04256847f, 0.08860541f, -0.03716363f, 0.11169945f, -0.29811192f, -0.15844202f, 
    0.07129408f, 0.18016681f, 0.02555606f, -0.15049750f, 0.13774858f, -0.09660880f, 0.44099927f, 0.06184111f, 
    -0.14854543f, 0.35271445f, -0.28468111f, -0.54062968f, 0.03775743f, -0.00896411f, -0.31574851f, 0.29906017f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.05184730f, -0.15657905f, -0.00795238f, -0.09907242f, 0.05776684f, -0.02352178f, -0.12612598f, 0.22490013f, 
    0.25895104f, 0.19202039f, 0.36500263f, 0.27333158f, 0.10044192f, 0.23087242f, -0.31170663f, -0.01050595f, 
    0.22154292f, 0.21113873f, 0.01089180f, -0.03010163f, 0.01057049f, 0.08576725f, -0.10802045f, 0.11793168f, 
    0.06857898f, 0.29185003f, -0.17606905f, -0.00685021f, 0.15963936f, 0.05737188f, 0.05239104f, 0.11751045f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.24308628f, 0.27689791f, 0.31988782f, -0.20144206f, -0.04588602f, -0.41031939f, 0.22114505f, 0.19419299f, 
    -0.01809200f, -0.19623099f, -1.00697577f, -0.06137532f, 0.08116326f, -0.74651200f, 0.03377824f, 0.24524446f, 
    -0.59393573f, -0.14339828f, 0.11054915f, -0.13993202f, 0.18140957f, 0.06210942f, -0.08712593f, -0.06075379f, 
    0.01089997f, -0.59458637f, -0.48004711f, 0.07634157f, -0.01025796f, -0.26587376f, -0.39551476f, -0.42754242f, 
    -0.46435890f, 0.01091029f, 0.08438379f, -0.16113539f, 0.24375869f, 0.00304519f, 0.06335552f, -0.09366822f, 
    -0.06476482f, -0.25872746f, 0.27685782f, 0.22437267f, -0.07837886f, -0.04366091f, -0.59052026f, 0.00981615f, 
    0.00824178f, 0.15284134f, -0.14134680f, -0.14635471f, 0.05395288f, 0.15515319f, -0.94183385f, 0.19695674f, 
    -0.04941456f, 0.17235003f, -0.83292007f, 0.11771246f, 0.19869620f, 0.23548077f, -0.55957484f, 0.43357462f, 
    -0.15489690f, -1.04317510f, -0.47072458f, -0.06395604f, -0.17744799f, -0.47355148f, -0.49082136f, -0.01991163f, 
    0.23764651f, 0.24309590f, -0.43959492f, 0.33941901f, -0.13361561f, -0.03603572f, -0.00049822f, 0.20022129f, 
    0.26937100f, -0.45969388f, -0.18392879f, 0.06612458f, -0.08387635f, 0.15660165f, 0.40835387f, 0.19019055f, 
    0.20949923f, 0.10844099f, 0.27131754f, 0.17205238f, -0.01611620f, -0.08988114f, -0.74900419f, -0.12415474f, 
    0.23704857f, -0.15018344f, 0.16749366f, 0.02344423f, -0.33261621f, -0.25483251f, 0.15273146f, 0.35662994f, 
    0.13303462f, 0.45258439f, -0.60369855f, 0.08416434f, -0.47202143f, -0.18881832f, 0.25430441f, -0.09728621f, 
    -0.33570585f, -0.50576532f, -0.18704532f, -0.06479018f, 0.01888282f, 0.01614353f, 0.19145931f, -0.37104174f, 
    -0.52142000f, -0.06003589f, 0.16513729f, 0.16799058f, 0.07118546f, -0.21571963f, 0.21122652f, -0.18732937f, 
    -0.06927464f, 0.05536830f, -0.12802070f, -0.04999063f, -0.01411984f, 0.03308132f, 0.20614658f, -0.21862026f, 
    -0.00246916f, -0.87893265f, -0.15884662f, 0.09398302f, -0.00126325f, 0.07448733f, 0.19664492f, 0.18922934f, 
    0.19182633f, -0.13484268f, 0.09004624f, -0.11686701f, 0.05346571f, 0.07075430f, 0.11448842f, 0.24797565f, 
    -0.26940230f, -0.48292246f, 0.00527320f, 0.05488017f, 0.08892684f, -0.58014905f, -0.52703679f, -0.12362821f, 
    -0.18538891f, -0.21435003f, -0.05848769f, 0.06192293f, 0.28291085f, 0.24945420f, 0.06127388f, -0.64154470f, 
    0.25277033f, -0.50376344f, -0.60169101f, -0.15689705f, 0.00595758f, 0.03243120f, -0.34727314f, -0.24233787f, 
    -0.05702845f, -0.25897014f, 0.30537030f, 0.07856502f, 0.10386759f, -0.11668574f, -0.21206626f, 0.17208080f, 
    0.04324706f, 0.09563839f, 0.10667324f, 0.10627020f, 0.03992365f, 0.00830834f, -0.33435917f, 0.12922937f, 
    0.16572501f, -0.58824402f, -0.43891472f, 0.17011596f, -0.39567557f, -0.66846174f, -1.29064870f, 0.23629919f, 
    -0.10592394f, 0.46984246f, 0.24747303f, -0.20375454f, -0.11155327f, -0.09404241f, -0.49648723f, -0.39664397f, 
    0.11594510f, 0.42731693f, -0.21755747f, 0.12130737f, 0.01869608f, -0.14615366f, 0.26979458f, 0.09067754f, 
    0.37242869f, 0.07649644f, 0.16219974f, -0.79732609f, 0.04503006f, -0.23591438f, -0.41964611f, -0.75437766f, 
    -0.13797900f, -0.08486585f, -0.44985938f, -0.04773322f, 0.21181341f, 0.09922444f, 0.04112402f, -0.08911946f, 
    -0.87864393f, 0.24517377f, -0.10924545f, 0.21959531f, 0.27884850f, 0.15063868f, 0.31931239f, -0.01311737f, 
    0.28105593f, -0.35261083f, -0.43702862f, 0.06609393f, -0.26839378f, 0.08049344f, -0.29308790f, -0.11531856f, 
    -0.30023760f, -0.83940256f, 0.22579555f, -0.43087509f, 0.11124270f, -0.00133879f, 0.19562042f, 0.36813608f, 
    0.35845059f, -0.47248313f, -0.41098785f, -0.17430583f, 0.29207021f, 0.33212042f, -0.04702707f, 0.31439546f, 
    -0.16458565f, -0.00521200f, -0.21060710f, 0.36175290f, -0.39016512f, 0.05381906f, -0.19022949f, -0.13381557f, 
    -0.12142947f, -0.33516261f, -0.51115608f, -0.12161215f, -0.14991650f, 0.10241346f, -0.32722718f, -0.55667782f, 
    -0.53634745f, 0.26309094f, -0.60477656f, -0.35947204f, -0.07276267f, 0.29691839f, 0.05742120f, 0.22784808f, 
    0.00844941f, -0.74153042f, -0.56128883f, -0.04138645f, -0.17611437f, 0.11288180f, 0.05483731f, -0.28699544f, 
    0.20689741f, -0.02801560f, 0.17396297f, -0.03986884f, -0.11043312f, 0.24507833f, -0.13921453f, -0.31731033f, 
    -0.03052041f, -0.01201572f, 0.35614228f, -0.04249393f, 0.32896110f, -0.01813298f, 0.11261142f, 0.18652742f, 
    -0.27546403f, -0.27196461f, 0.17043701f, -0.15051234f, 0.06874746f, -0.43116388f, 0.49382082f, -0.69550157f, 
    0.11989214f, 0.30990288f, 0.42325971f, -0.10144999f, -0.32927397f, 0.18693776f, -0.21570744f, -0.32903555f, 
    -0.35137221f, -0.32492137f, -0.63342726f, 0.23132119f, -0.55839705f, 0.03430884f, -0.40643591f, -0.16428451f, 
    0.00334890f, -0.28281751f, -0.68469703f, -0.10052131f, -0.84916836f, -0.15692382f, 0.23874263f, -0.11488577f, 
    0.37344417f, 0.29958597f, -0.22129312f, -0.00640457f, -0.07613755f, 0.17228666f, -0.32822838f, -0.30300939f, 
    0.37344733f, 0.14148109f, -0.68608880f, -0.01606660f, -0.10830685f, 0.04162744f, -0.28399035f, 0.34492168f, 
    -0.35745364f, 0.00782918f, -0.10750990f, -0.67163092f, -0.69944894f, 0.30112302f, -0.14126430f, -0.33497933f, 
    -0.02782792f, 0.14442037f, -0.23473445f, -0.07303707f, -0.05651883f, -0.04886676f, -0.14835690f, 0.18990077f, 
    -0.18582626f, -0.14113241f, 0.23152091f, -0.55080920f, 0.00990294f, 0.32598233f, -0.18912779f, -0.20080745f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.27849939f, 0.18673834f, 0.18586132f, -0.07416315f, -0.06131463f, -0.22956765f, 0.09201816f, -0.04539156f, 
    0.00711003f, 0.25514334f, -0.09054095f, 0.12403403f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
