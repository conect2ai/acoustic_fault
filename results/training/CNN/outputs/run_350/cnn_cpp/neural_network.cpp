#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.15183809f, -0.48272529f, -0.63688546f, -0.43915352f, -0.12762074f, -0.55795568f, -0.24906148f, 0.23060323f, 
    0.64759403f, -0.11404507f, -0.31217727f, 0.01939445f, 0.32472715f, -0.24151088f, -0.57668906f, -0.06661815f, 
    0.19768852f, -0.15118921f, 0.15482205f, -0.19455154f, 0.05237807f, -0.20084749f, 0.05219157f, -0.02606733f, 
    -0.22272927f, -0.54107255f, -0.32445556f, 0.42355719f, 0.36036226f, 0.41635707f, 0.53808624f, 0.85995770f, 
    0.46658427f, -0.42617732f, 0.43316582f, -0.07670642f, 0.14283708f, 0.43070331f, -0.25073853f, -0.21817814f, 
    -0.28313604f, -0.01511218f, -0.19193117f, 0.09269414f, -0.01832865f, 0.07709438f, -0.05243620f, -0.00032410f, 
    -0.02469296f, 0.02738531f, 0.24022114f, 0.80827844f, 0.33644253f, -0.11448760f, 0.45600784f, -0.50884759f, 
    0.31680200f, 0.20922700f, -0.17024948f, -0.53473920f, -0.25169495f, -0.14066288f, 0.24875651f, 0.52234244f, 
    0.42291802f, 0.09276936f, -0.04681545f, 0.41774705f, 0.04582300f, 0.06159998f, 0.05693512f, -0.32699686f, 
    -0.03718704f, -0.19806913f, 0.09741639f, 1.02830172f, 0.35240555f, -0.42578337f, 0.47783667f, 0.30906540f, 
    0.35863274f, -0.38394862f, -0.32704833f, -0.10621318f, 0.33399180f, -0.05037589f, -0.12335844f, 0.11988590f, 
    0.19862106f, -0.15729281f, 0.04305182f, -0.18369460f, 0.21345910f, 0.28833368f, 0.22738996f, 0.22834383f, 
    0.21367352f, 0.19377100f, 0.04786120f, 0.05709990f, 0.93604577f, -0.25797781f, 0.81770617f, -0.73025644f, 
    -0.73048151f, 0.52396375f, -0.41262907f, 0.41268477f, -0.19245897f, 0.01416565f, 0.39431232f, 0.50691789f, 
    0.20565191f, 0.10377568f, -0.15331215f, -0.16963878f, 0.08808426f, 0.11991196f, -0.01909057f, -0.23184767f, 
    0.28709880f, 0.27459136f, 0.06492320f, -0.05031798f, 0.07762130f, -0.61780661f, -0.88698208f, -0.96608138f, 
    -0.12483047f, 0.21274218f, -0.73464507f, 0.77464807f, 0.47662321f, -0.54048568f, -0.07185581f, 0.36281487f, 
    -0.13692059f, -0.08094566f, -0.10201321f, 0.22303554f, -0.07996060f, 0.06879453f, -0.20767020f, -0.28557315f, 
    -0.05846375f, 0.14115946f, 0.13585579f, -0.03377100f, 0.22916991f, -0.08760481f, 0.20185012f, -0.89303207f, 
    0.57526553f, 0.59400344f, 0.26878315f, 0.32638657f, -0.32003903f, 0.56860620f, 0.01663892f, -0.53377867f, 
    -0.01951474f, -0.56330913f, -0.42067739f, 0.17475563f, 0.14466368f, 0.02071108f, 0.08417951f, 0.13625455f, 
    -0.01819280f, 0.00023629f, -0.01427133f, -0.14136232f, -0.25755325f, -0.05239489f, -0.34805837f, -0.65659344f, 
    -0.78770179f, -0.51962143f, -0.32348260f, -0.57122815f, 0.20982577f, 0.50459856f, 0.46328089f, 0.23999470f, 
    0.08324997f, -0.26363757f, -0.16108841f, -0.11808058f, 0.01940511f, -0.18185283f, -0.03854397f, 0.01955901f, 
    0.19992347f, 0.03603593f, -0.05316001f, 0.19079977f, -0.24041808f, 0.23297930f, 0.06990105f, 0.31760597f, 
    -0.49356276f, 0.82988727f, -0.44647932f, -0.76388139f, 0.19560881f, -0.07802977f, -0.58620816f, -0.31643972f, 
    0.15298818f, -0.61165583f, 0.07729340f, -0.26889923f, -0.38431352f, -0.09354902f, -0.27430260f, 0.07638633f, 
    0.27415684f, -0.38424107f, -0.24907742f, -0.17307875f, -0.07936753f, 0.09832510f, 0.32095233f, 0.02891445f, 
    0.12430575f, 1.08312929f, 0.72026986f, 0.31769419f, 0.67017508f, 0.56688523f, -0.20255855f, -0.04294932f, 
    -0.29074997f, 0.55558974f, 0.09635308f, -0.17177455f, -0.10361177f, 0.02567369f, -0.04545493f, -0.10256310f, 
    -0.20211826f, -0.16490187f, -0.21586101f, -0.26129389f, -0.26573223f, 0.20142703f, 0.05725992f, 0.17772064f, 
    -0.11703826f, 0.07536483f, -0.93027329f, 0.59150851f, -0.45656034f, -0.62562215f, -0.31557274f, 0.81125760f, 
    0.41410547f, -0.58408767f, 0.04972574f, -0.05178712f, 0.18050504f, -0.12159178f, 0.51310861f, 0.27510503f, 
    0.10052067f, -0.10744851f, -0.16803342f, -0.03745897f, -0.13275090f, -0.15632910f, 0.02347002f, -0.06506044f, 
    0.18626289f, 0.17288794f, -0.07857493f, 0.52285647f, -0.04965004f, 0.64769214f, 0.77890140f, 0.83547038f, 
    -0.24318428f, -0.12158307f, -0.21259335f, -0.18368047f, -0.17730720f, 0.23415709f, 0.08441181f, -0.28144446f, 
    -0.28465343f, -0.15141939f, 0.04899274f, 0.14223073f, 0.04243707f, 0.10399909f, 0.21018867f, -0.06472588f, 
    -0.08874533f, -0.12882094f, -0.05650980f, -0.02175907f, 0.27951920f, 0.66115856f, 0.90315747f, 0.57984304f, 
    -0.39068010f, 0.03962876f, -0.42560089f, -0.50594032f, -0.51393050f, -0.19038366f, 0.37742189f, 0.03208124f, 
    -0.09220917f, 0.28708228f, -0.08106577f, 0.09909060f, -0.25519648f, -0.03173872f, 0.08868223f, -0.03836815f, 
    -0.01331799f, 0.36217681f, 0.26180157f, 0.05353604f, 0.21361972f, -0.05791719f, -0.06861180f, 0.16886668f, 
    -0.19985172f, 0.46818459f, -0.74115694f, -0.81240100f, -0.60258263f, -0.65529442f, -0.15871292f, 0.33385843f, 
    0.57762533f, 0.00933243f, -0.07035995f, 0.24824257f, -0.18376677f, -0.01253900f, 0.05182285f, 0.12496351f, 
    0.45163673f, 0.32178244f, -0.00336593f, -0.03696369f, 0.20071955f, 0.35986629f, -1.20118976f, 0.06939580f, 
    1.17851913f, -0.32378662f, -0.17483312f, 0.40879700f, 0.17881362f, 0.32474622f, 0.27380574f, -0.49850446f, 
    -0.37401322f, 0.02292483f, -0.24100080f, 0.12456400f, -0.03277522f, -0.23557308f, -0.17434341f, -0.21385099f, 
    -0.26080891f, -0.17849860f, -0.01820596f, -0.03134172f, -0.12604485f, 0.09893878f, -0.08896286f, -0.10036013f, 
    -0.33828604f, 0.20311634f, -0.08658513f, -0.53770256f, -0.57062572f, 0.36007228f, 0.50892967f, -0.44908553f, 
    -0.42237845f, -0.10238535f, 0.22185054f, -0.36523709f, -0.25863388f, -0.45498726f, 0.28183365f, 0.19816257f, 
    0.21108146f, 0.33287093f, 0.02183036f, 0.02474792f, -0.28098509f, -0.19951211f, -0.33700490f, 0.02331350f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.12133636f, -0.06950030f, -0.02416908f, 0.17919588f, 0.05034217f, 0.21629900f, -0.06661151f, 0.08071799f, 
    0.21487164f, 0.32375610f, 0.19927230f, -0.07714991f, 0.20911813f, 0.38423514f, 0.02016271f, -0.00886371f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.00601518f, -0.04276484f, -0.07006665f, -0.05367941f, -0.01830964f, -0.06445726f, 0.03998427f, -0.05012794f, 
    0.00558062f, -0.05305111f, 0.03672454f, -0.04731821f, -0.02768586f, -0.01058657f, 0.04540644f, 0.03427152f, 
    -0.05564815f, 0.03082372f, 0.03954393f, 0.05235852f, 0.03382825f, -0.00405671f, 0.02171001f, -0.00150748f, 
    -0.07227368f, 0.03770041f, -0.01162550f, -0.01050906f, 0.03987778f, 0.00766111f, -0.04456192f, 0.05909609f, 
    0.00848689f, -0.05780315f, -0.06158160f, 0.01421738f, -0.00215593f, -0.04766381f, -0.03255047f, -0.05966407f, 
    0.00467701f, -0.05521787f, -0.06968865f, -0.00328221f, -0.05081890f, 0.02621672f, -0.07555760f, 0.04065500f, 
    0.01168066f, 0.03940796f, 0.01096612f, 0.04920695f, 0.00727273f, -0.05707933f, 0.00624409f, -0.05751493f, 
    0.02484540f, 0.00182084f, -0.02758465f, -0.07563021f, 0.06107659f, -0.03128248f, -0.05161244f, -0.01128681f, 
    0.00731491f, -0.07416680f, 0.02392737f, -0.02386859f, 0.02554385f, -0.07814874f, 0.00636150f, 0.00846457f, 
    -0.01518009f, -0.03894238f, -0.01739958f, -0.00384611f, -0.07738155f, -0.02354474f, -0.07661714f, -0.05363788f, 
    -0.02191736f, 0.02185188f, -0.05476368f, -0.07548433f, 0.00995167f, -0.06305615f, 0.03229845f, -0.02118616f, 
    0.01175421f, -0.07024864f, -0.01289841f, -0.03535261f, 0.00851504f, -0.01996699f, 0.01455617f, -0.07906798f, 
    0.00819136f, -0.04623627f, -0.03126088f, 0.04699307f, 0.06129554f, 0.00229167f, 0.06226701f, -0.05502873f, 
    -0.03428040f, -0.05571121f, -0.07877829f, -0.01150614f, -0.05245594f, -0.01742235f, 0.00194586f, 0.04478014f, 
    -0.04610756f, -0.04364036f, 0.00697352f, 0.05167304f, 0.03700363f, -0.05882090f, -0.03603305f, -0.03227504f, 
    0.05895445f, 0.02708475f, -0.04121018f, 0.04355496f, 0.04065464f, -0.04194482f, -0.03147070f, 0.00858656f, 
    0.01174017f, 0.05861371f, -0.01173527f, 0.01738583f, 0.03086955f, 0.02254565f, -0.06211380f, 0.00786344f, 
    -0.04107541f, -0.00094808f, -0.06363848f, -0.06424906f, -0.04102774f, -0.05485025f, -0.01549733f, -0.00660508f, 
    0.06188019f, -0.02789716f, 0.01533234f, 0.00268387f, 0.01735166f, -0.04649090f, 0.01656659f, 0.05687810f, 
    -0.05266365f, -0.04241741f, -0.06104812f, 0.03029910f, -0.02801372f, 0.04819135f, 0.05680106f, -0.00997387f, 
    -0.05949428f, -0.04985167f, 0.04386966f, 0.01490574f, -0.02737598f, 0.02650610f, 0.04874479f, 0.00222702f, 
    -0.05195257f, 0.02312739f, -0.06523568f, -0.03835883f, 0.05743559f, 0.04201856f, 0.03290020f, -0.07550636f, 
    -0.00008196f, 0.02894762f, 0.00107899f, -0.07546049f, -0.07846586f, -0.05734786f, -0.05867913f, 0.02832579f, 
    -0.06744555f, -0.02355759f, 0.02020198f, -0.05555669f, -0.04426913f, -0.04366523f, 0.03404355f, 0.02383980f, 
    0.02724694f, -0.00420944f, -0.06672976f, 0.00882395f, 0.00589054f, 0.00338234f, -0.07682187f, 0.06401377f, 
    -0.04986573f, 0.00683186f, 0.05580407f, 0.05809292f, -0.07418014f, 0.06170507f, -0.00421348f, -0.05755622f, 
    -0.02524948f, 0.02586329f, -0.05152257f, -0.03211154f, -0.05493242f, -0.05197107f, -0.01255431f, 0.03652209f, 
    0.05144016f, 0.06468768f, -0.00204883f, -0.02894824f, 0.04794370f, -0.07736807f, 0.05852178f, -0.06452338f, 
    -0.00789689f, 0.03727420f, 0.03469699f, -0.06447959f, -0.07708568f, -0.03431084f, -0.05210227f, 0.03303055f, 
    0.04208739f, 0.03040597f, 0.02496054f, -0.01242005f, 0.04133910f, -0.07195002f, 0.01246858f, -0.02124826f, 
    -0.05061247f, 0.00279703f, -0.03892151f, -0.00392566f, 0.00330863f, -0.03597016f, -0.04415619f, 0.02404844f, 
    -0.02117796f, -0.04621722f, 0.04569092f, 0.06328830f, -0.07135294f, 0.00961561f, -0.03666602f, -0.03588908f, 
    -0.01239150f, 0.05857867f, -0.05822773f, 0.01985700f, -0.04584799f, -0.01375459f, -0.02761550f, -0.00753008f, 
    -0.02285753f, -0.05139678f, -0.00880601f, 0.00664951f, 0.05941972f, -0.08035704f, 0.04543842f, -0.05752387f, 
    -0.05048982f, 0.01518360f, -0.00752418f, 0.04352225f, -0.00241437f, -0.05292228f, 0.00599017f, -0.02927305f, 
    -0.03711773f, -0.04232879f, 0.04776757f, -0.04928181f, 0.03827702f, -0.00891894f, 0.02245325f, -0.04117607f, 
    0.05321555f, -0.00674009f, 0.00134672f, 0.00841512f, 0.02407372f, 0.01798774f, -0.00236025f, -0.06104689f, 
    0.01964137f, -0.03826618f, 0.03342010f, 0.03008029f, -0.01486765f, -0.01619248f, -0.02321802f, -0.04036501f, 
    0.03730950f, -0.07326594f, 0.05383733f, 0.04582858f, -0.04074708f, 0.04106278f, -0.07265166f, 0.05745318f, 
    -0.00629832f, -0.03738505f, 0.05868696f, 0.04302188f, -0.05737055f, 0.01446339f, -0.01295167f, -0.02396969f, 
    0.01255203f, -0.00022098f, -0.04748864f, 0.00177571f, 0.01750885f, -0.03104849f, 0.00597255f, -0.06492252f, 
    -0.03273310f, -0.03377528f, -0.03432113f, -0.01769114f, -0.01620446f, 0.06143687f, -0.07407182f, -0.00638787f, 
    0.06404780f, -0.04078830f, 0.05538689f, 0.05122045f, -0.03390374f, -0.03344904f, 0.03159986f, -0.05199917f, 
    -0.05541274f, 0.06374390f, -0.06403466f, 0.04588904f, -0.06415287f, -0.02618282f, -0.02522513f, -0.05335220f, 
    0.03022169f, -0.03030799f, 0.05772862f, -0.06044915f, 0.06626102f, -0.01600688f, 0.01056474f, -0.03951024f, 
    -0.04935544f, -0.00681409f, 0.04737593f, -0.07436327f, 0.00574751f, 0.01956830f, -0.01189804f, -0.04860906f, 
    0.03958530f, 0.00716618f, -0.02861543f, -0.00213258f, -0.07313717f, -0.02272402f, -0.02342914f, -0.03881627f, 
    0.03517081f, -0.00964697f, -0.00538889f, -0.01509019f, -0.03384832f, 0.05115178f, -0.00624393f, -0.04855013f, 
    -0.06235044f, 0.03767265f, -0.03943982f, -0.01102458f, -0.02237863f, 0.06022598f, -0.07540308f, -0.02413510f, 
    -0.03514849f, -0.02205242f, -0.07944030f, -0.00113483f, 0.02407775f, 0.01076297f, -0.06469300f, -0.05885204f, 
    0.01263337f, 0.05170734f, -0.03567905f, 0.02272099f, -0.04903340f, -0.07685132f, 0.01273507f, 0.03041579f, 
    0.00131407f, -0.07069900f, -0.03422607f, -0.03065631f, 0.01172822f, -0.03141686f, -0.06145093f, -0.02272550f, 
    -0.02723398f, -0.04058759f, -0.00553290f, -0.07138409f, 0.02354035f, 0.00792269f, 0.03985301f, -0.04076046f, 
    0.01421157f, -0.07428388f, -0.07384917f, 0.01685117f, -0.05054228f, -0.00881422f, -0.07673550f, 0.04470669f, 
    -0.00940882f, -0.00748758f, -0.07472227f, 0.04728333f, -0.01096739f, -0.00333821f, -0.06950916f, -0.01695289f, 
    0.01851708f, 0.03730266f, -0.00386839f, -0.06828026f, 0.00274729f, 0.00718673f, -0.06268982f, 0.00952499f, 
    0.02998447f, 0.01300485f, -0.02646061f, 0.04126589f, -0.06060730f, 0.04091254f, 0.02831925f, 0.01975630f, 
    -0.01001166f, -0.01961304f, 0.01840456f, 0.00357499f, 0.04002822f, -0.05814170f, 0.01982811f, -0.08164257f, 
    -0.07038419f, -0.00732393f, -0.08061884f, 0.01764798f, -0.02666484f, -0.07784544f, -0.04404245f, -0.07734580f, 
    -0.04000549f, 0.04311465f, 0.01672122f, 0.00416173f, -0.08222385f, 0.00929369f, 0.02588921f, -0.03604008f, 
    -0.01123012f, -0.04649931f, 0.00927258f, -0.00000730f, 0.02579060f, 0.04910841f, 0.02878435f, 0.05548503f, 
    -0.07853054f, 0.01644778f, -0.04093508f, -0.04945733f, -0.03580346f, -0.01230274f, 0.04067165f, -0.01215991f, 
    0.04665909f, 0.00692369f, 0.05632885f, -0.03212661f, 0.01477754f, -0.05082419f, 0.03521225f, -0.07192198f, 
    -0.04052040f, -0.04452241f, -0.03489902f, 0.03090462f, -0.00358062f, -0.00656843f, -0.02318541f, 0.00094597f, 
    -0.01551137f, -0.00967604f, 0.02361961f, -0.07538477f, 0.04457689f, 0.00318164f, -0.02871521f, 0.03571771f, 
    -0.07181162f, 0.00977400f, -0.03287163f, 0.05715616f, 0.04070247f, -0.00360982f, 0.05102663f, -0.02912630f, 
    -0.07604451f, -0.07849239f, -0.01093466f, 0.04484677f, -0.07897299f, 0.01563451f, 0.03695882f, -0.04417003f, 
    0.05926107f, -0.07118694f, 0.00877816f, -0.05681258f, 0.03956456f, -0.01694326f, 0.04722409f, 0.03062694f, 
    0.06011687f, 0.01091651f, 0.02223193f, -0.07801134f, 0.05537473f, 0.05893975f, -0.06168063f, 0.04261045f, 
    0.00215014f, -0.02837026f, 0.05619676f, 0.00453435f, -0.06697559f, -0.06540062f, -0.04279129f, -0.04056256f, 
    0.05925472f, 0.01004760f, -0.02430609f, 0.00515797f, -0.06512783f, 0.03707003f, -0.04383769f, 0.02741618f, 
    0.01878013f, -0.02713607f, -0.05591162f, 0.04416360f, -0.00000280f, 0.04039850f, 0.02272438f, -0.00923945f, 
    0.05407214f, 0.42705086f, -0.00195317f, -0.13606220f, -0.01943703f, -0.13776784f, -0.01234045f, -0.21886571f, 
    0.16948228f, 0.22102910f, -0.04944898f, -0.21270521f, -0.09682629f, -0.20802653f, 0.14150809f, -0.03584362f, 
    0.01784872f, -0.00584976f, 0.17458229f, 0.09030045f, 0.11455721f, 0.12094387f, 0.02961847f, 0.14805810f, 
    -0.07897751f, 0.28873068f, 0.09796035f, 0.14573683f, 0.10181351f, -0.07285880f, 0.04647705f, -0.14244752f, 
    -0.07552394f, -0.02673305f, -0.10920248f, 0.00545911f, 0.30517319f, 0.16002569f, 0.01350750f, 0.09774495f, 
    0.07564647f, -0.06591326f, -0.14071298f, -0.06864121f, -0.10489441f, 0.10906791f, -0.06401088f, 0.08653994f, 
    -0.47406667f, -0.09315644f, -0.06817314f, 0.13085292f, -0.07072290f, -0.13166621f, -0.00426462f, -0.14339823f, 
    -0.12565191f, -0.16770573f, -0.01071823f, -0.14080466f, 0.04043856f, 0.17299719f, 0.17173705f, -0.12247069f, 
    -0.00053059f, -0.10586698f, -0.02309514f, -0.11621774f, 0.00282219f, 0.02229743f, -0.02110556f, -0.03305986f, 
    -0.25303832f, -0.22081009f, 0.13471234f, -0.08955655f, -0.02510550f, 0.24138148f, -0.05556241f, -0.03359955f, 
    0.01282554f, -0.05419480f, -0.03835647f, 0.04260032f, 0.06621753f, 0.25942099f, 0.06886325f, 0.08688393f, 
    -0.04127488f, 0.16634095f, 0.04964835f, -0.02292274f, 0.14177278f, -0.05656315f, -0.01360046f, -0.01924188f, 
    0.00067441f, -0.02614423f, 0.10779769f, 0.34104866f, 0.06265308f, 0.05901503f, -0.03913092f, -0.11558573f, 
    0.00270718f, -0.05625080f, 0.08478049f, 0.00497518f, 0.24606670f, 0.32334381f, -0.17204194f, -0.09146420f, 
    0.12061438f, 0.07158591f, 0.04054534f, 0.08321333f, -0.06885254f, 0.01410439f, 0.09855612f, -0.19802167f, 
    0.35953248f, 0.19124216f, -0.09304414f, 0.12733316f, 0.00325306f, 0.02422872f, -0.05810388f, 0.08038891f, 
    -0.08085058f, -0.07677924f, -0.10991997f, 0.09902422f, 0.26422945f, -0.13765767f, -0.07532981f, 0.13505968f, 
    -0.03894952f, 0.26740843f, 0.10432719f, 0.03781673f, 0.00830559f, -0.04957693f, -0.00471124f, -0.06204371f, 
    0.37257683f, -0.10649562f, -0.21436632f, 0.21905468f, -0.06562625f, -0.03246067f, -0.03456776f, -0.07591773f, 
    -0.04072207f, -0.01116740f, -0.03158090f, -0.00248742f, 0.11929203f, -0.01162826f, -0.15153049f, 0.34193996f, 
    -0.07394713f, -0.05655338f, -0.06194058f, 0.02424271f, -0.10798764f, -0.13854930f, -0.10931196f, -0.00991422f, 
    -0.12407830f, -0.14983442f, 0.06814523f, 0.10916883f, -0.17175382f, 0.09012140f, 0.00049886f, 0.12653594f, 
    0.00970292f, 0.12987404f, 0.07222498f, -0.00339273f, 0.23838171f, 0.09937248f, 0.22887900f, 0.06658312f, 
    -0.12150676f, 0.03272696f, -0.02967012f, -0.05319170f, 0.09880846f, 0.12023045f, -0.03835478f, -0.07892571f, 
    0.00569400f, -0.10755288f, 0.02723926f, -0.06179723f, 0.13909104f, 0.07836089f, 0.01544681f, 0.07826232f, 
    -0.08353250f, 0.14520097f, 0.11309979f, -0.09834232f, 0.02850405f, -0.19090071f, -0.19772744f, -0.08421621f, 
    0.01347297f, -0.07530051f, 0.11709456f, -0.02341254f, 0.09977680f, 0.05374774f, -0.04418904f, 0.12054308f, 
    -0.01095513f, -0.06543896f, -0.08364082f, 0.12826768f, 0.05761315f, -0.10499659f, -0.07528560f, 0.04481104f, 
    0.10317971f, 0.02401521f, -0.04132478f, 0.02109983f, -0.25744301f, 0.09515357f, 0.04055348f, -0.05067085f, 
    0.13383740f, -0.01152927f, 0.05132543f, -0.03455733f, 0.10462356f, 0.05998011f, 0.03762437f, -0.06811422f, 
    0.20215462f, 0.00030519f, -0.11386844f, 0.39836881f, 0.12712547f, 0.04286313f, -0.02528715f, 0.06789275f, 
    -0.00008673f, -0.12510836f, 0.00078265f, -0.03990871f, -0.26446635f, -0.12299877f, -0.15935607f, -0.03239563f, 
    0.04703423f, 0.16337754f, 0.11166982f, 0.04527648f, -0.04485397f, 0.04214200f, 0.13889757f, -0.06868394f, 
    0.42441675f, -0.04184344f, 0.01981989f, -0.18982476f, 0.02466542f, -0.10643588f, 0.02539837f, 0.02886761f, 
    -0.09454914f, 0.02074587f, -0.02611529f, 0.18546143f, 0.00555779f, -0.05778831f, -0.12667052f, -0.18544659f, 
    0.05212031f, -0.05478763f, -0.06790061f, -0.11474884f, -0.13281810f, 0.02071504f, 0.03022105f, 0.04786131f, 
    -0.04075613f, -0.21912941f, 0.04469494f, 0.26125708f, 0.02177638f, 0.11338478f, 0.00596445f, 0.08016461f, 
    -0.04512543f, 0.07453352f, 0.09165190f, 0.09388859f, -0.45858818f, 0.31350419f, 0.19445719f, -0.26742584f, 
    0.04356091f, 0.08942131f, -0.02861693f, 0.07583334f, 0.15238768f, -0.07653254f, 0.08835401f, 0.08682191f, 
    -0.18505681f, -0.30108967f, 0.04063692f, 0.28956959f, -0.12774411f, 0.10127198f, 0.07105226f, -0.02803026f, 
    0.05345340f, 0.18811122f, 0.03835922f, 0.06540118f, 0.09253220f, 0.24961050f, 0.21251537f, -0.52630991f, 
    -0.01559263f, -0.00214582f, -0.05069540f, -0.00909929f, -0.04031641f, 0.02807990f, 0.09891947f, 0.21658270f, 
    0.22507976f, 0.13250069f, 0.21846169f, -0.15101343f, -0.07348277f, -0.04333997f, -0.00519182f, -0.01851392f, 
    -0.05622708f, 0.05078176f, 0.02366986f, -0.02496170f, 0.14611706f, 0.03957881f, -0.07352318f, -0.11297836f, 
    0.09077413f, 0.07245011f, 0.02427342f, 0.07732045f, 0.08703174f, -0.02550368f, -0.11730417f, 0.01359680f, 
    -0.03519870f, -0.29008946f, -0.02724423f, 0.22457854f, 0.18615749f, 0.07587095f, -0.11468069f, 0.04842269f, 
    -0.04347069f, 0.06458707f, 0.01871274f, 0.10422050f, 0.10108951f, -0.13356319f, -0.10618954f, -0.03098124f, 
    -0.02023820f, 0.15553901f, 0.13509770f, -0.04323798f, 0.02772820f, -0.05519726f, 0.07432508f, -0.05904595f, 
    -0.04983215f, -0.00117067f, 0.01033069f, -0.07086641f, 0.01082256f, 0.00596504f, -0.06473515f, 0.05315436f, 
    -0.03289372f, 0.01914353f, -0.06695860f, 0.06811802f, 0.04690640f, 0.01280798f, 0.01314195f, -0.00607764f, 
    -0.05859758f, 0.04240524f, -0.01162737f, -0.05198441f, -0.08057882f, 0.05805075f, -0.06324387f, -0.00315044f, 
    0.04101355f, -0.04663303f, 0.04655312f, -0.06106288f, 0.07041619f, 0.05172700f, -0.00810637f, -0.05406159f, 
    -0.04875120f, -0.00149896f, 0.03715342f, 0.02082497f, 0.03103113f, -0.04739343f, -0.03754544f, -0.05964203f, 
    -0.04647093f, -0.06545594f, -0.05978236f, 0.02163758f, 0.04537304f, -0.05619837f, -0.04452564f, -0.02451465f, 
    -0.03989170f, -0.05942753f, -0.06631877f, -0.03052361f, 0.06392358f, -0.02805520f, -0.04157148f, -0.03126232f, 
    -0.03570556f, -0.07078373f, -0.05933668f, 0.05750239f, -0.03411134f, -0.02294541f, 0.05015790f, -0.03412625f, 
    -0.04616648f, 0.00096630f, 0.03669928f, -0.04845589f, 0.03085976f, 0.05274456f, -0.02837586f, 0.01221164f, 
    0.06201571f, -0.01225491f, 0.01892457f, -0.06595412f, 0.04495806f, 0.06823038f, 0.04396465f, -0.07448900f, 
    -0.05211318f, 0.05203079f, -0.04904944f, 0.01751374f, -0.00304967f, 0.06864260f, -0.05406785f, -0.01046740f, 
    -0.02034719f, -0.01052426f, 0.01330152f, 0.01613585f, 0.06046725f, -0.04793007f, 0.04721634f, 0.01359400f, 
    -0.02383354f, -0.05557566f, -0.06350130f, -0.08431502f, -0.05778522f, -0.01741883f, -0.05549033f, 0.06119490f, 
    0.01878384f, -0.01188860f, -0.04326244f, -0.06018195f, -0.06866571f, -0.03194409f, 0.04579546f, 0.03221949f, 
    -0.06134108f, -0.01382665f, -0.02128766f, 0.01513571f, 0.05973541f, -0.02120375f, -0.04890842f, 0.01518748f, 
    0.01871381f, -0.04475681f, -0.00350870f, -0.02472035f, 0.03165773f, 0.03288116f, 0.03724195f, -0.04083434f, 
    -0.06297530f, -0.04370240f, -0.02436453f, -0.04604819f, -0.06503526f, -0.01060501f, -0.03042010f, -0.03618309f, 
    0.01402315f, 0.06270942f, -0.02983751f, -0.03622630f, 0.01958876f, 0.05664607f, 0.05076455f, -0.07001854f, 
    -0.04532525f, 0.05759328f, 0.00896276f, -0.06894077f, 0.03482948f, -0.02626277f, -0.05216571f, -0.05241098f, 
    0.01434776f, 0.01223342f, 0.04876697f, -0.00878850f, 0.06818257f, -0.04715523f, 0.04673661f, 0.01217177f, 
    0.02969878f, -0.01931649f, 0.00266246f, -0.05978984f, -0.00110731f, 0.01585382f, 0.02442344f, 0.01756044f, 
    0.02665919f, 0.03506092f, -0.02707069f, 0.04584919f, -0.03076116f, -0.03350546f, -0.01061631f, 0.02981583f, 
    0.05016389f, 0.00026137f, -0.03365559f, 0.05374615f, -0.06752054f, -0.04415779f, 0.05391754f, -0.03488185f, 
    0.03480190f, 0.02447279f, -0.04498266f, -0.03490584f, 0.03426649f, -0.04214893f, -0.04749555f, 0.04927518f, 
    -0.04973212f, 0.00497353f, -0.01727386f, 0.05101669f, -0.07229189f, -0.03248978f, 0.06714696f, 0.02344942f, 
    0.02541932f, 0.00161062f, -0.06662899f, -0.06525111f, 0.00557318f, 0.04885624f, 0.05525589f, -0.05636199f, 
    -0.05578756f, 0.03595690f, 0.05741459f, 0.04886950f, -0.02688379f, -0.05219608f, 0.06493116f, 0.02395956f, 
    -0.05673318f, 0.04294856f, -0.05271408f, 0.05359092f, 0.01227286f, 0.00885127f, -0.06494340f, 0.01966671f, 
    -0.05082691f, 0.05701207f, -0.01751631f, -0.02936553f, -0.01142092f, 0.00760522f, 0.00335911f, 0.01549378f, 
    -0.02300430f, 0.04808111f, 0.06374557f, -0.03212970f, 0.05058733f, 0.02061568f, -0.01529488f, 0.06033031f, 
    -0.00963907f, 0.05519456f, 0.04537862f, -0.05964781f, 0.06875775f, -0.05904702f, -0.01228969f, 0.00117951f, 
    0.06311747f, -0.01987315f, -0.00456456f, 0.06889454f, 0.05311362f, 0.06990967f, -0.02909460f, 0.03747474f, 
    0.03354875f, 0.03093439f, 0.05714519f, -0.02548525f, -0.04673725f, -0.04279066f, -0.04383690f, 0.02798021f, 
    0.01834143f, 0.00995894f, -0.03577270f, -0.06320116f, -0.03401535f, 0.01983971f, -0.02058471f, -0.02744853f, 
    0.04906707f, -0.01446100f, -0.04248142f, 0.04324984f, -0.00536659f, 0.04225821f, 0.01279228f, 0.02755998f, 
    0.06050419f, 0.05181901f, -0.01079297f, -0.04449166f, 0.00873735f, -0.06455585f, -0.07778308f, 0.01355981f, 
    -0.00194925f, -0.01891924f, -0.07040019f, -0.04550697f, 0.04785965f, 0.02131747f, -0.06123707f, -0.05329274f, 
    0.03480705f, -0.06578518f, 0.02134219f, -0.04101839f, -0.05860597f, -0.05230321f, -0.02260417f, -0.07113822f, 
    -0.05820717f, -0.05558155f, -0.07397678f, -0.05096643f, -0.00820718f, -0.04475366f, -0.04874853f, -0.03667109f, 
    -0.02432135f, -0.05392620f, -0.00112381f, -0.04160996f, 0.06712972f, -0.04548113f, 0.03000589f, 0.02468364f, 
    -0.04905016f, 0.02326533f, -0.03258721f, 0.00347964f, -0.05710322f, -0.03475060f, -0.00049240f, -0.06475225f, 
    -0.04232667f, 0.04498644f, 0.04637285f, -0.01172284f, 0.02316096f, -0.05561104f, 0.03875582f, 0.03789388f, 
    0.01152494f, 0.04369146f, -0.04242691f, -0.03258461f, 0.04022483f, 0.00490409f, -0.00381224f, -0.01234931f, 
    0.06187221f, -0.03020202f, 0.04171606f, -0.03724013f, -0.05050173f, 0.04383052f, -0.04063010f, -0.07242125f, 
    -0.00638732f, -0.01293782f, 0.01750141f, 0.01658527f, 0.04192204f, 0.04592421f, -0.07289600f, -0.07008948f, 
    -0.03781508f, -0.01931198f, -0.06880127f, 0.03745963f, -0.01760997f, -0.01239375f, 0.05133449f, 0.03246947f, 
    -0.06123732f, 0.00768761f, 0.03245288f, -0.07843799f, -0.04943406f, -0.05274756f, -0.04049709f, -0.02322676f, 
    -0.01706366f, 0.00207793f, 0.05436552f, -0.02549826f, -0.07511215f, -0.02320239f, 0.03363241f, -0.01468810f, 
    -0.01293190f, 0.02156518f, 0.00800680f, -0.04974036f, -0.01599767f, -0.05030188f, -0.01535221f, -0.01175429f, 
    0.05319698f, 0.03043290f, 0.05737164f, -0.03486721f, 0.00892418f, 0.05220594f, 0.06398835f, -0.08157337f, 
    -0.07012125f, 0.02411827f, -0.02771287f, -0.05915590f, -0.07247252f, -0.06948241f, -0.00504906f, -0.06095609f, 
    0.01079996f, -0.01750350f, -0.00636426f, 0.02269174f, -0.05969468f, -0.03473716f, -0.04945579f, 0.02565451f, 
    0.06329540f, -0.04879015f, 0.05994143f, -0.04175398f, -0.06388082f, -0.00544198f, 0.05047214f, 0.01831451f, 
    0.01612629f, -0.00899720f, -0.00043615f, -0.00993804f, -0.04751093f, 0.00959856f, -0.06111031f, 0.01789612f, 
    -0.06057770f, -0.06005574f, -0.01434107f, -0.04896210f, 0.04301769f, -0.07720814f, -0.00534791f, -0.03029551f, 
    -0.01763142f, -0.01168269f, 0.02744984f, 0.01177563f, -0.03399513f, -0.05278789f, 0.02398027f, -0.07637668f, 
    -0.05931825f, 0.06464750f, -0.06879196f, -0.05543299f, 0.01073670f, 0.02483851f, 0.05857443f, 0.00550323f, 
    0.00158853f, 0.04991042f, -0.05116332f, 0.05073024f, -0.07419468f, 0.04051462f, 0.02763078f, -0.04209437f, 
    -0.03147155f, -0.04717406f, -0.05869124f, -0.07166555f, -0.01410765f, 0.00934755f, -0.02222548f, -0.06654066f, 
    -0.02627425f, -0.03324739f, -0.06550096f, -0.01168790f, 0.06487048f, -0.08146071f, 0.02269739f, 0.06400466f, 
    -0.00176572f, -0.04857183f, 0.06305264f, 0.00402964f, -0.04392033f, -0.01424296f, -0.03189570f, 0.04431416f, 
    0.04668054f, 0.05337995f, 0.00853533f, 0.03576070f, 0.06383049f, 0.01158717f, -0.05825873f, 0.03051496f, 
    -0.00945683f, -0.04101855f, -0.01320639f, -0.06019390f, -0.03669051f, -0.02641756f, -0.06631381f, 0.03495362f, 
    -0.02368474f, 0.03396734f, -0.01252704f, -0.00981756f, -0.02962898f, -0.05561906f, 0.03658724f, -0.01529768f, 
    -0.07282121f, -0.00389051f, 0.00673057f, 0.02266201f, -0.02564447f, -0.01095936f, 0.06226695f, -0.01153707f, 
    0.00002394f, -0.03234819f, -0.03455329f, -0.05264485f, 0.01331198f, 0.06612110f, 0.01729237f, 0.01029506f, 
    -0.05923745f, -0.01814023f, 0.03278835f, -0.04537886f, 0.03696580f, -0.01810665f, -0.00938205f, 0.05397100f, 
    0.02766541f, -0.02454879f, -0.01528570f, 0.01799660f, 0.00695640f, 0.04619134f, 0.03522811f, -0.04322565f, 
    -0.00663923f, -0.02271920f, -0.00485687f, -0.04481857f, 0.03513913f, -0.03362244f, 0.03177653f, 0.00816527f, 
    -0.02500011f, -0.05799910f, -0.02740506f, 0.06428710f, 0.02639891f, -0.02676039f, 0.00674306f, 0.01609204f, 
    0.06127581f, 0.01513459f, -0.00094681f, -0.06240399f, -0.00446320f, -0.02950138f, 0.01463529f, 0.03594653f, 
    -0.01108213f, -0.01687032f, 0.06411217f, 0.01678144f, -0.02678667f, 0.06059533f, 0.04023284f, -0.02526699f, 
    -0.22924198f, 0.04978017f, -0.09931321f, -0.12054573f, -0.08156516f, -0.07853239f, 0.05589339f, -0.05308149f, 
    0.05539714f, 0.12867461f, -0.02071078f, 0.03192667f, 0.17469196f, -0.24673787f, -0.02437740f, 0.06604668f, 
    0.08239829f, -0.03080521f, 0.15065463f, 0.14555152f, 0.09886652f, 0.07764050f, -0.07450021f, 0.16120487f, 
    -0.09823957f, 0.18200029f, 0.10202433f, -0.25758222f, -0.22343719f, 0.00906148f, 0.00060475f, 0.02640791f, 
    0.04959595f, -0.12815563f, -0.16235085f, -0.07833965f, 0.21167034f, 0.12779661f, 0.04497516f, 0.11522393f, 
    0.02043056f, 0.14520757f, -0.10280796f, -0.08643646f, -0.02134649f, -0.11755793f, -0.09259941f, -0.04026555f, 
    -0.04774804f, -0.10146870f, 0.02029520f, 0.15026544f, 0.02527883f, 0.15904956f, 0.12345731f, -0.17678738f, 
    -0.20123258f, 0.10919019f, -0.06887498f, 0.10581729f, -0.26884249f, 0.06050126f, -0.14361547f, 0.10277403f, 
    -0.07783233f, 0.04806710f, 0.03419345f, -0.08908253f, -0.00995115f, -0.01891040f, 0.08066786f, -0.10931115f, 
    0.24438608f, -0.23927307f, 0.06798109f, 0.03020903f, 0.04349694f, 0.11150218f, 0.11214257f, 0.03786518f, 
    0.05319889f, -0.17779301f, -0.08981264f, 0.15941203f, 0.12075651f, -0.04683863f, -0.01264908f, -0.46022949f, 
    -0.00590740f, -0.04981290f, -0.01530569f, -0.00293852f, 0.01545748f, 0.15121408f, 0.00835282f, 0.14444859f, 
    -0.01037849f, -0.12710820f, 0.06810768f, -0.09073959f, 0.02572137f, 0.05133288f, -0.08750316f, 0.08912047f, 
    0.02513070f, 0.07756176f, 0.16815753f, -0.09619410f, -0.10576218f, 0.24764168f, -0.08235179f, -0.09264994f, 
    -0.13481997f, 0.02776059f, -0.03500336f, 0.01366158f, 0.03959595f, 0.08324504f, 0.06877416f, 0.13255446f, 
    0.58369166f, -0.07407929f, 0.15297748f, -0.08045009f, -0.10539924f, 0.12004369f, -0.10252921f, 0.01312150f, 
    -0.03360853f, 0.06790017f, -0.05460905f, 0.17083918f, 0.29793057f, 0.08746804f, 0.06739926f, -0.03418073f, 
    -0.04343267f, 0.05768308f, 0.06547945f, 0.01909454f, 0.07487748f, -0.03422814f, 0.10582334f, -0.05275983f, 
    0.30463243f, 0.05604448f, -0.12687717f, -0.12168929f, 0.05407031f, 0.02376030f, -0.06759588f, 0.06013085f, 
    0.00346720f, -0.05026243f, -0.03092706f, -0.09957189f, 0.21190783f, 0.12782626f, 0.14601049f, 0.08786398f, 
    0.08887831f, 0.11289236f, 0.10912570f, -0.01375615f, -0.04187797f, -0.16068350f, -0.10553256f, -0.07829425f, 
    -0.21142173f, -0.13471544f, 0.15436970f, 0.32609528f, -0.04328509f, 0.03088438f, 0.09263109f, 0.21867706f, 
    0.02246931f, 0.19147536f, 0.24124554f, 0.12393549f, -0.20839135f, 0.26236445f, -0.02728428f, 0.07552670f, 
    -0.08822968f, 0.05927091f, 0.08161987f, -0.04867233f, 0.00747480f, -0.04942848f, 0.14052223f, 0.00621898f, 
    0.09293045f, 0.11257100f, 0.01565033f, 0.02240076f, -0.03321614f, 0.03109992f, 0.06460093f, 0.06057880f, 
    -0.14991324f, 0.20157339f, -0.10806973f, -0.08364898f, -0.26041016f, -0.01057458f, -0.17136066f, -0.21302988f, 
    0.12769297f, -0.03861180f, -0.01195552f, -0.03880474f, 0.06673881f, 0.11290495f, -0.11856251f, 0.07023702f, 
    -0.03912304f, 0.03970912f, 0.10262558f, -0.14286596f, -0.28461322f, -0.08552274f, 0.07167727f, 0.03144093f, 
    0.06782092f, 0.00124294f, -0.08592140f, -0.01114207f, -0.04797074f, 0.18652387f, -0.06693420f, 0.16313370f, 
    -0.09334435f, 0.07394394f, -0.08134473f, -0.06886990f, -0.12647811f, -0.16441059f, -0.03675133f, 0.01517917f, 
    0.03696326f, -0.13110355f, -0.06558471f, 0.05662908f, -0.04615651f, 0.08916865f, 0.12740771f, -0.18069065f, 
    -0.18961358f, 0.12180939f, -0.12414634f, 0.10559187f, -0.40924397f, -0.18891169f, 0.00825113f, 0.09157846f, 
    0.02893500f, 0.07316713f, -0.07911259f, -0.03962043f, -0.11822142f, 0.05819264f, -0.03039127f, -0.06590249f, 
    0.59874451f, -0.10014841f, -0.16599868f, 0.01023528f, -0.04166094f, -0.00765748f, 0.05913092f, -0.07384841f, 
    -0.03494120f, -0.24715681f, -0.09337374f, 0.06037592f, -0.01104992f, -0.14491953f, -0.01580392f, -0.20052493f, 
    0.21180534f, -0.00629788f, -0.02146485f, -0.05067333f, -0.16238394f, 0.08832811f, -0.02380752f, 0.05298189f, 
    0.10008480f, -0.03143514f, 0.12338649f, 0.07102640f, -0.05888211f, -0.12325448f, -0.10228603f, 0.10709555f, 
    -0.03231053f, -0.02040741f, 0.00557711f, -0.14526445f, -0.24104743f, 0.09585517f, -0.06287105f, -0.22322349f, 
    -0.09568175f, -0.08279068f, -0.03752700f, -0.10751629f, -0.02470550f, -0.03698465f, 0.00291908f, -0.01920324f, 
    0.23987703f, -0.21245654f, 0.15708116f, -0.04592896f, -0.08911028f, 0.01925723f, -0.01189789f, -0.00828673f, 
    -0.02329320f, 0.08111854f, -0.10119081f, 0.11193108f, 0.03282487f, 0.12446158f, -0.10908144f, -0.10942768f, 
    -0.08585793f, 0.02256253f, 0.06123591f, 0.01225645f, 0.18336053f, 0.05956358f, 0.10764973f, -0.11498755f, 
    -0.09979846f, 0.06945191f, -0.01598819f, -0.17488201f, -0.05209096f, -0.01330228f, -0.16764645f, 0.07886794f, 
    -0.02943358f, 0.04378142f, -0.00753976f, -0.05680590f, 0.05811264f, -0.14585195f, 0.01455209f, 0.04823839f, 
    -0.03435794f, -0.12108965f, 0.08849514f, -0.12388345f, -0.08492394f, -0.16632180f, -0.00463385f, -0.04123961f, 
    -0.00403908f, -0.12043136f, 0.19098224f, 0.11951951f, 0.08868300f, -0.09235041f, -0.00650246f, 0.02996953f, 
    -0.03118684f, -0.07330498f, 0.14434217f, 0.10769018f, 0.08920436f, 0.22229537f, 0.14778373f, 0.15010355f, 
    0.13343818f, 0.15828510f, 0.12308814f, 0.01593648f, 0.04225469f, 0.05788917f, 0.08851904f, -0.04391001f, 
    -0.31596896f, -0.32830974f, -0.02278528f, -0.27893540f, 0.20557292f, 0.01284212f, 0.01333070f, -0.07684778f, 
    0.05560510f, -0.26146942f, 0.06143112f, -0.06126472f, -0.45040548f, 0.32338908f, -0.24230175f, -0.08719800f, 
    0.10884553f, 0.14353883f, -0.07559128f, 0.01918482f, -0.10141271f, -0.00507831f, 0.17258096f, 0.12782265f, 
    0.28273210f, 0.32942408f, 0.06019168f, 0.04703690f, 0.11709396f, -0.16206591f, -0.12286469f, -0.05062794f, 
    -0.06113948f, 0.04980396f, 0.23533358f, 0.08345408f, 0.14910530f, -0.21386452f, 0.18423113f, 0.28171307f, 
    -0.08337047f, -0.01370684f, -0.00995578f, 0.05771612f, 0.27003455f, 0.11944740f, 0.04260007f, 0.02478386f, 
    -0.14722238f, -0.02656192f, -0.03544838f, -0.02938284f, 0.06912426f, 0.04955878f, -0.02920870f, 0.00666362f, 
    0.21739183f, -0.02395743f, 0.18527512f, -0.10790570f, -0.76398891f, 0.29520333f, -0.19093964f, -0.19310534f, 
    0.16746275f, -0.03317990f, 0.12041429f, -0.07932854f, 0.07192992f, -0.05520616f, -0.02804170f, -0.01327504f, 
    -0.34597063f, 0.00354159f, 0.02054546f, 0.30898851f, 0.11073444f, -0.01577833f, -0.17496105f, -0.19519871f, 
    0.01123728f, 0.07091188f, -0.02851264f, 0.17680244f, -0.39724389f, -0.03536950f, -0.26449692f, -0.20394970f, 
    0.16440824f, 0.23010056f, 0.07540978f, 0.04175060f, 0.04967942f, -0.07092126f, -0.07958398f, -0.01420726f, 
    0.01437835f, 0.05857204f, 0.34163257f, 0.12508944f, 0.01577217f, -0.18452100f, 0.12299799f, 0.00829976f, 
    0.23743844f, 0.04617704f, -0.01760906f, -0.00111112f, 0.48617277f, -0.12419826f, 0.07543671f, 0.33066574f, 
    -0.14108264f, -0.13363934f, -0.02443934f, -0.08464057f, 0.17173302f, 0.05626937f, 0.02556595f, 0.03017403f, 
    -0.32509518f, -0.14561562f, -0.23615319f, -0.27756950f, -0.06502797f, 0.21011095f, 0.27552024f, -0.10460003f, 
    0.04351662f, 0.04931850f, 0.06404875f, -0.05265424f, 0.34261233f, 0.03980549f, 0.15531544f, 0.18502776f, 
    -0.11629830f, -0.06255674f, -0.14012060f, -0.08378967f, -0.03544541f, -0.03004917f, -0.00275356f, 0.20415580f, 
    0.01160360f, 0.24147002f, 0.19984160f, 0.15859996f, -0.09101512f, -0.07402505f, 0.01677859f, 0.00950127f, 
    0.12574351f, 0.13302091f, 0.14574227f, 0.21779796f, -0.05845952f, 0.00009232f, 0.29627654f, 0.24524720f, 
    -0.11910605f, -0.02283419f, -0.07963462f, 0.12675975f, 0.13970041f, 0.13365111f, 0.11715961f, 0.31804451f, 
    -0.30973548f, 0.21465302f, -0.15975785f, -0.02530441f, 0.09668507f, 0.17180994f, -0.05428509f, -0.06289802f, 
    -0.00164940f, -0.02453071f, -0.14768277f, -0.09268042f, -0.33277613f, 0.04351231f, 0.09804896f, 0.10508049f, 
    -0.08765182f, 0.05923292f, -0.09575129f, 0.04264307f, 0.09303402f, 0.01651039f, -0.14371060f, -0.01289909f, 
    0.17991127f, 0.36093453f, -0.00283713f, 0.32159859f, -0.09106434f, 0.17187038f, -0.03799953f, 0.14436322f, 
    -0.13854069f, 0.19605888f, 0.00159308f, 0.09403799f, -0.29119989f, 0.20097539f, -0.24453372f, -0.36637557f, 
    0.05408374f, 0.00878696f, 0.11356819f, 0.28006846f, 0.03752737f, -0.01238466f, 0.10039974f, -0.06863489f, 
    -0.15459456f, -0.22422998f, -0.04583462f, 0.00562430f, -0.06932143f, 0.19334589f, -0.05081115f, -0.11464329f, 
    0.00553566f, -0.06831945f, -0.01944665f, -0.02516756f, -0.07405245f, 0.06939161f, 0.04195344f, 0.11820902f, 
    0.14569169f, -0.00797519f, 0.03202697f, -0.10512196f, -0.17026649f, -0.06424259f, -0.01042457f, 0.09030030f, 
    -0.11377383f, -0.13234353f, 0.12533703f, -0.46415174f, -0.04443704f, 0.07298958f, 0.20601992f, -0.18243881f, 
    -0.12778203f, 0.01371625f, -0.12557498f, 0.10607804f, 0.20462012f, 0.01808654f, 0.02304538f, 0.25673282f, 
    -0.02935711f, 0.04865954f, -0.06158868f, 0.09198747f, -0.16841428f, -0.06482529f, 0.10316226f, 0.03309809f, 
    0.33621237f, -0.01411891f, -0.28398195f, 0.05316244f, -0.07230163f, -0.12817025f, -0.07326327f, 0.06084694f, 
    0.03079805f, -0.10568998f, 0.04684926f, 0.15681519f, 0.00006931f, 0.07173515f, 0.06114721f, 0.16606417f, 
    -0.12827253f, 0.00438767f, -0.17253949f, 0.06378172f, -0.17672496f, -0.04145702f, -0.03141760f, -0.02563605f, 
    0.23100108f, 0.12679522f, 0.08318789f, 0.12057392f, -0.03753856f, -0.08824678f, -0.08692564f, 0.06321619f, 
    0.01392265f, 0.01697512f, 0.04414447f, -0.00930802f, -0.03242224f, -0.25490895f, -0.13247225f, -0.09845637f, 
    0.07831377f, -0.06659116f, -0.16499700f, -0.27839777f, 0.06942602f, 0.01391011f, 0.04399063f, 0.14110993f, 
    0.22104914f, 0.06116360f, -0.04444329f, 0.04593215f, 0.05129770f, 0.04193357f, -0.02623274f, 0.05150254f, 
    0.02712025f, 0.04811115f, 0.07835504f, 0.02925843f, -0.16664128f, -0.01353134f, -0.23174499f, 0.08310954f, 
    0.15684314f, -0.16146731f, -0.10998800f, -0.07933783f, 0.12543112f, 0.17010845f, 0.14223449f, -0.11290075f, 
    0.08853950f, -0.15563750f, 0.15390398f, -0.01475580f, 0.02013929f, 0.04379622f, -0.26125377f, -0.00512176f, 
    0.06013645f, 0.03321963f, 0.08597858f, 0.02858563f, 0.12193546f, -0.00524951f, 0.06199837f, 0.24131431f, 
    0.04465544f, -0.19024985f, -0.01432858f, 0.00158730f, 0.19956398f, -0.13688080f, 0.04103671f, -0.16813131f, 
    0.05934415f, 0.33077401f, -0.06295872f, -0.18655105f, -0.00707039f, 0.12556392f, -0.06018330f, 0.21619682f, 
    0.05096237f, -0.03450095f, 0.22617447f, 0.17634450f, 0.18675673f, 0.36379939f, 0.33362627f, 0.17706524f, 
    0.01387090f, 0.13389298f, 0.13519432f, 0.05842777f, -0.04310435f, 0.02039454f, 0.02226036f, -0.11901942f, 
    -0.03385542f, -0.18745556f, -0.07005519f, -0.12019756f, 0.07783245f, 0.05838124f, 0.08969166f, -0.15705183f, 
    0.02596794f, -0.06817026f, 0.18716763f, 0.04580535f, -0.15559095f, 0.06561129f, 0.06899936f, 0.11906471f, 
    -0.08824189f, 0.11631899f, -0.03816237f, 0.04121305f, 0.03924441f, -0.00142792f, 0.17356257f, -0.00261217f, 
    0.08278640f, 0.08164537f, 0.06676172f, 0.16218051f, 0.20432311f, 0.17174311f, -0.09022451f, -0.08415458f, 
    0.01702751f, -0.02275005f, 0.11480689f, 0.13227943f, 0.20012914f, -0.14464226f, -0.03554563f, -0.05396464f, 
    -0.02140270f, -0.08083297f, 0.03438834f, 0.05998415f, 0.03455571f, 0.05366258f, 0.07378204f, 0.05055979f, 
    -0.01189217f, 0.06697257f, 0.05433055f, 0.10859843f, -0.08638510f, -0.06530546f, -0.10808405f, 0.22905004f, 
    0.16593133f, -0.21391942f, 0.13764349f, -0.17079103f, 0.10222664f, 0.16008651f, -0.07193886f, -0.15315767f, 
    0.10068336f, -0.11434279f, 0.06858674f, -0.03891408f, 0.11960257f, -0.17659155f, -0.01411205f, 0.01252408f, 
    -0.57392365f, -0.01200074f, 0.16434641f, -0.06161494f, 0.02029727f, 0.10794453f, -0.11530949f, -0.06874489f, 
    0.02165302f, 0.14955586f, 0.07734376f, 0.04171398f, -0.03632686f, 0.13660020f, -0.12752010f, 0.09548512f, 
    0.11292610f, -0.02454630f, 0.03055640f, -0.03091265f, 0.12838709f, -0.07983235f, -0.04009705f, -0.00983134f, 
    0.06374992f, -0.06807914f, 0.03313547f, 0.18168482f, 0.10519674f, 0.04815922f, 0.15042593f, -0.10801915f, 
    0.07311566f, 0.08914445f, -0.02293854f, 0.18940693f, 0.47197792f, 0.06643351f, 0.07050251f, 0.23828213f, 
    0.08137934f, -0.08526926f, 0.13537502f, 0.12882766f, 0.05732722f, -0.00021415f, -0.08972915f, -0.00702871f, 
    -0.36122209f, -0.00015833f, -0.12123325f, -0.01805667f, -0.06268606f, 0.03919289f, 0.09319045f, 0.10255005f, 
    -0.02373619f, -0.08846877f, 0.00946484f, -0.02392908f, 0.12231436f, -0.09144020f, 0.07921810f, 0.18900141f, 
    0.02889025f, 0.04986836f, -0.08263997f, -0.03064271f, -0.02706464f, -0.00879964f, -0.00892584f, 0.08448540f, 
    0.20210287f, -0.08267376f, 0.02165638f, 0.19583143f, -0.09921259f, 0.09324018f, 0.06147159f, 0.05631424f, 
    -0.05675590f, 0.01542674f, 0.06856692f, 0.12174942f, -0.23032992f, -0.01622553f, -0.07635277f, 0.00336329f, 
    0.01359156f, 0.06137500f, -0.10785917f, 0.10643826f, -0.16814357f, 0.19473417f, 0.08178857f, 0.17712392f, 
    -0.28991848f, 0.07983685f, -0.06751911f, -0.09922308f, -0.06327254f, -0.05329095f, 0.03698393f, -0.13104790f, 
    -0.02341486f, 0.03116433f, -0.10235026f, -0.02037407f, -0.17358913f, -0.13996913f, -0.32437935f, 0.02959052f, 
    -0.06122638f, -0.11372013f, -0.15986195f, 0.10442133f, 0.04497259f, 0.08353493f, -0.07594623f, -0.01457983f, 
    -0.10056449f, -0.24117289f, -0.09495470f, 0.25515422f, -0.07069790f, -0.00176607f, -0.06905386f, 0.12120261f, 
    0.09081743f, -0.01999906f, 0.09143528f, 0.10982589f, 0.14662185f, 0.03489934f, 0.02877087f, 0.18002346f, 
    -0.12678340f, 0.14231852f, 0.00044898f, 0.14374352f, -0.01157085f, -0.02388889f, 0.05702450f, -0.03473229f, 
    0.30881464f, -0.06528858f, -0.10362427f, 0.05109354f, 0.11880054f, 0.28267339f, -0.04556311f, -0.00227073f, 
    0.10730205f, -0.01372956f, -0.01513059f, 0.04818555f, 0.18801743f, 0.23167853f, -0.05379478f, 0.05522252f, 
    0.06677859f, -0.03880646f, 0.04856976f, -0.08826304f, -0.02638351f, -0.13717885f, -0.01177604f, -0.03826670f, 
    0.40543479f, 0.19541124f, 0.16569178f, -0.27402073f, 0.08204735f, 0.13596797f, 0.01473874f, 0.09954628f, 
    0.01697946f, -0.07796322f, 0.00915136f, 0.06060395f, 0.24197422f, 0.05343039f, -0.16499257f, 0.00159890f, 
    0.05434150f, 0.06653815f, -0.00883480f, -0.01118494f, 0.06987695f, -0.07864045f, 0.11744413f, -0.11167863f, 
    0.02977241f, 0.06503242f, -0.08651908f, -0.11974154f, 0.05015632f, 0.02461006f, 0.08459807f, 0.16518202f, 
    0.04403456f, 0.10924700f, 0.05304623f, 0.04097854f, -0.23965894f, -0.00732909f, -0.00428502f, 0.11150949f, 
    -0.03095376f, -0.08883524f, -0.04855238f, 0.07410138f, -0.02600341f, -0.07881581f, 0.04598303f, 0.08569042f, 
    0.07712802f, -0.22618918f, -0.27436545f, -0.45267731f, -0.18482307f, 0.02244241f, 0.03132685f, 0.02445526f, 
    0.09328891f, 0.03616957f, 0.06754012f, 0.07536157f, 0.36668670f, -0.00964575f, 0.15164806f, 0.27512613f, 
    0.00105563f, -0.04871945f, -0.04965382f, 0.05645816f, 0.06825127f, 0.01309580f, -0.06081216f, 0.14450988f, 
    -0.18018010f, -0.01532109f, 0.12731323f, -0.15097931f, 0.17820022f, 0.21738467f, 0.05579246f, 0.00361819f, 
    0.04358468f, 0.01739733f, -0.05032430f, 0.02992507f, -0.07565729f, 0.01675172f, 0.14273672f, 0.19119151f, 
    0.06049191f, -0.03275368f, -0.01052299f, 0.01495217f, -0.05364409f, -0.03628742f, -0.03427452f, -0.02837049f, 
    0.12180320f, 0.08423302f, 0.04638650f, -0.20510313f, 0.02367155f, 0.16865516f, -0.04253645f, 0.03033264f, 
    -0.02181802f, -0.06195374f, 0.06351487f, -0.03291944f, -0.41005883f, -0.10132615f, 0.05386905f, -0.25105160f, 
    0.04741775f, 0.10697046f, -0.09007154f, -0.01060168f, 0.13738784f, 0.16919376f, 0.02336242f, -0.07978210f, 
    0.11703478f, -0.03294137f, -0.28337371f, -0.14539324f, 0.07281463f, -0.12954633f, 0.05013605f, -0.02642981f, 
    0.03722404f, 0.05329006f, 0.08298285f, 0.12300833f, -0.15068574f, -0.00526996f, -0.23505980f, 0.03476582f, 
    0.09128095f, -0.19952594f, 0.03996136f, 0.05344593f, -0.10856714f, -0.02191037f, -0.00825123f, 0.04874630f, 
    0.04374573f, 0.27592283f, 0.02433515f, 0.22523685f, -0.13311844f, -0.06998322f, -0.09704566f, 0.17414430f, 
    -0.01386747f, 0.13907076f, -0.08242052f, 0.02257549f, 0.08367390f, 0.07669427f, -0.09154130f, -0.04068737f, 
    0.10783823f, 0.00013999f, -0.06850291f, 0.07637698f, -0.00661729f, -0.03306876f, -0.01588915f, 0.01519257f, 
    -0.15151948f, -0.11369918f, -0.09901187f, 0.14453307f, 0.19128945f, 0.11312234f, -0.02586114f, -0.13090940f, 
    -0.01987584f, -0.03193695f, -0.09054713f, -0.13370116f, -0.25919876f, 0.10432498f, -0.11399932f, 0.00477724f, 
    0.04736905f, 0.01769664f, 0.10997507f, -0.12058937f, -0.05313540f, 0.07181411f, 0.01225798f, 0.04242126f, 
    -0.08424964f, -0.04370690f, 0.10415387f, -0.25362986f, 0.08661983f, 0.08936549f, 0.03701556f, 0.00452074f, 
    -0.04717469f, 0.07211986f, -0.08058778f, 0.04720254f, 0.38120976f, -0.07666700f, -0.00175476f, 0.14776541f, 
    -0.02645309f, 0.13319613f, 0.06335206f, 0.02390645f, -0.00688326f, 0.06593467f, 0.06996572f, 0.06012305f, 
    0.13970609f, -0.02503216f, 0.00455407f, -0.12032370f, 0.02518395f, -0.09878793f, -0.05887736f, 0.09485986f, 
    0.03851128f, 0.00380955f, 0.12082432f, -0.06450053f, -0.12684868f, -0.03719776f, 0.23357452f, 0.22502144f, 
    -0.27624604f, -0.11695744f, -0.05392693f, 0.02057028f, -0.16967057f, 0.06096400f, -0.00319849f, -0.07331984f, 
    0.19791375f, 0.17175080f, -0.01753795f, -0.00626768f, -0.11267231f, 0.01943477f, -0.01965699f, 0.01263421f, 
    -0.02004197f, -0.03274696f, 0.17255446f, -0.09380500f, -0.18631829f, -0.22448514f, -0.07187691f, -0.15047890f, 
    0.17512374f, 0.06811547f, 0.00119646f, -0.09194408f, 0.03875468f, 0.00310859f, 0.04712537f, 0.01241729f, 
    0.09117504f, 0.15532000f, -0.15143178f, 0.05606790f, 0.14100343f, -0.02353116f, -0.11226401f, 0.10563799f, 
    0.03531982f, 0.06698306f, -0.03761524f, 0.06865084f, -0.26398078f, -0.01092495f, -0.10558090f, -0.02232160f, 
    0.12768626f, -0.19089451f, -0.12006877f, -0.04310014f, -0.01928293f, 0.07195072f, 0.08026664f, -0.14975165f, 
    -0.14176987f, -0.09255652f, 0.11154334f, -0.03334212f, 0.17421408f, 0.02624932f, -0.04897134f, -0.07819359f, 
    0.10754070f, -0.11211966f, -0.07240401f, -0.08998757f, 0.18179585f, 0.14140713f, 0.09844376f, 0.06220834f, 
    0.02038647f, 0.03413871f, -0.00668791f, 0.05666302f, 0.14465460f, 0.09838088f, 0.04227938f, -0.13133563f, 
    0.50083011f, 0.08187749f, -0.18015771f, -0.32865724f, 0.08895637f, 0.10023175f, -0.08494598f, 0.16701794f, 
    0.17165154f, -0.06407055f, 0.03467571f, 0.08180076f, 0.13594733f, -0.02599070f, 0.29543719f, -0.04122606f, 
    0.01558185f, -0.03137005f, 0.12041447f, -0.07517808f, -0.16591896f, 0.00600915f, 0.01004395f, -0.02563212f, 
    0.13518210f, 0.18003561f, 0.07452892f, -0.04322664f, -0.24534556f, 0.00387329f, -0.10989991f, -0.13058853f, 
    0.04546065f, 0.04414447f, 0.04449887f, 0.03541426f, -0.40685877f, -0.06859339f, -0.24176940f, 0.03086237f, 
    0.01997120f, 0.00616010f, 0.15024742f, 0.09885953f, 0.06964955f, -0.03296985f, 0.04282663f, -0.16814251f, 
    -0.32609600f, 0.03450340f, 0.30167514f, 0.16806734f, 0.29130980f, 0.06328174f, -0.18841635f, 0.07163058f, 
    -0.10015251f, -0.12475388f, 0.01034521f, -0.08793582f, 0.14255075f, 0.00780152f, -0.20542428f, 0.20272352f, 
    0.23539492f, 0.06298406f, 0.12728365f, -0.06636754f, 0.21462107f, -0.00044261f, -0.01047889f, 0.05694550f, 
    -0.07193039f, -0.33969319f, -0.05742767f, 0.12505010f, 0.14797285f, 0.14190765f, -0.03091020f, 0.15584052f, 
    -0.05710752f, -0.03581379f, 0.09911810f, -0.04631389f, -0.22411452f, 0.09342752f, 0.13648377f, 0.08448045f, 
    0.04700865f, -0.14966182f, 0.10195947f, -0.07566790f, 0.03017423f, 0.00362083f, -0.01019070f, 0.07041615f, 
    -0.10055270f, -0.29443702f, 0.19198723f, -0.06966645f, 0.00179851f, 0.01536272f, 0.09350232f, 0.07334445f, 
    -0.09365144f, -0.01203962f, -0.06447528f, 0.12425096f, 0.02845324f, 0.00465969f, 0.00486431f, -0.13218604f, 
    -0.32624713f, 0.04850851f, -0.00981676f, -0.05025057f, 0.02191971f, -0.02519342f, 0.03337438f, -0.18489569f, 
    0.46808511f, 0.26930904f, 0.11871002f, 0.17977333f, -0.00931822f, -0.10553523f, -0.06372481f, -0.02494185f, 
    0.06589857f, 0.03963235f, -0.02991828f, 0.19890775f, 0.12078886f, -0.28453526f, -0.01853970f, -0.18100828f, 
    0.04295741f, 0.06255808f, 0.07734519f, -0.11823108f, 0.12463211f, 0.03523149f, 0.04943362f, 0.01009534f, 
    0.10632361f, 0.14940073f, -0.26950797f, 0.16333455f, -0.12604105f, 0.03733758f, 0.02311461f, 0.01332106f, 
    -0.10986526f, 0.02805678f, -0.06605639f, -0.01135872f, -0.03755338f, -0.04016237f, 0.05438078f, -0.12298489f, 
    0.05195243f, -0.00388432f, -0.03429756f, 0.06641599f, -0.10656188f, 0.07074078f, 0.12221158f, -0.12475758f, 
    0.15356208f, -0.41495490f, 0.15631869f, 0.17129044f, 0.09241146f, -0.00076712f, 0.00701701f, 0.12595172f, 
    0.09479488f, 0.00922746f, 0.20201105f, -0.00539276f, 0.16775844f, 0.21987700f, -0.09131790f, 0.36014375f, 
    0.09802793f, -0.16890167f, -0.03452531f, 0.08127087f, 0.20792256f, 0.04783104f, -0.02911250f, -0.01926688f, 
    -0.13698952f, 0.02274845f, -0.12043799f, -0.23760381f, 0.17508547f, 0.02016257f, -0.13720188f, 0.16879435f, 
    0.00103096f, -0.02148694f, 0.00489587f, -0.00023157f, -0.17714112f, 0.10910646f, 0.19031629f, -0.15123425f, 
    -0.04824888f, 0.12254592f, -0.10151254f, -0.01439006f, -0.06709508f, 0.07960449f, -0.03485579f, -0.12918407f, 
    0.33768305f, -0.13454668f, 0.03619097f, -0.08507102f, 0.20363979f, 0.22469139f, 0.17045230f, 0.00939913f, 
    -0.13250890f, 0.03396213f, 0.03003369f, -0.07884909f, -0.25159776f, 0.13816930f, -0.05673886f, -0.06002274f, 
    0.05182083f, 0.11362284f, 0.07466858f, -0.15342164f, 0.00546859f, 0.14984040f, 0.00117104f, 0.09195147f, 
    0.11723952f, 0.11992425f, 0.24452318f, -0.19137381f, -0.32401770f, -0.08742870f, 0.11526480f, 0.09457016f, 
    -0.01199872f, 0.01765474f, -0.01255122f, 0.12784000f, 0.07025366f, -0.03975331f, 0.06005051f, -0.07373704f, 
    -0.13940315f, 0.07577866f, 0.02079448f, 0.09956434f, -0.03430452f, -0.03429356f, 0.03295052f, 0.05752427f, 
    -0.09237400f, -0.20622787f, -0.04026040f, 0.36958417f, -0.06472725f, -0.03509838f, 0.08240464f, -0.07891314f, 
    0.01192446f, 0.02401340f, -0.07034367f, 0.02116712f, -0.28368974f, -0.12399202f, -0.15128605f, 0.00351689f, 
    0.02667224f, -0.01812583f, -0.08585066f, 0.14891659f, 0.07519969f, 0.11399890f, -0.11956239f, -0.01916234f, 
    0.26363134f, 0.09116658f, -0.16089362f, 0.18382472f, -0.02637324f, 0.00333053f, 0.10376281f, -0.20579535f, 
    0.08631214f, -0.04287470f, -0.05530173f, -0.02736838f, 0.28875473f, -0.01292986f, -0.39965403f, -0.29883236f, 
    0.41126117f, 0.04468306f, 0.06122602f, -0.02597764f, 0.09036956f, 0.04391192f, -0.04592421f, 0.08636496f, 
    -0.00920092f, 0.08136442f, 0.25071144f, 0.30602604f, 0.15788254f, -0.05270806f, 0.14309503f, 0.11368790f, 
    -0.01088950f, 0.06394766f, 0.02603440f, -0.01396856f, -0.04628592f, 0.16182578f, 0.05688770f, 0.01001315f, 
    -0.21026912f, -0.01188024f, -0.06772652f, 0.03660537f, -0.09883790f, -0.14230013f, 0.02258068f, 0.01609348f, 
    0.05077475f, -0.21549028f, 0.24592289f, -0.04760239f, -0.16886330f, 0.02282430f, 0.02658310f, -0.01995366f, 
    0.01335301f, -0.10498828f, -0.04699412f, -0.02788837f, 0.07562534f, 0.14626324f, 0.13903318f, 0.03214379f, 
    -0.06489698f, 0.14301182f, 0.00446898f, -0.03793899f, 0.10886578f, 0.02247411f, -0.01943852f, -0.07124362f, 
    -0.06974510f, 0.13203484f, -0.04918955f, 0.11584654f, -0.07314525f, 0.06463510f, 0.00240158f, 0.04480130f, 
    -0.05730750f, 0.09167890f, -0.00722824f, 0.10136569f, 0.19389729f, -0.06995163f, 0.07416268f, 0.10128904f, 
    0.07398831f, 0.00387099f, 0.08100960f, -0.04480758f, -0.10680511f, -0.12748133f, 0.06585441f, 0.07650647f, 
    -0.33396295f, -0.12074198f, 0.37628886f, 0.33078983f, 0.09398673f, -0.00516086f, 0.01065375f, -0.04227536f, 
    -0.05697362f, 0.03098954f, -0.11965101f, 0.00868801f, 0.18418352f, 0.17180677f, -0.17232068f, 0.17726330f, 
    0.12828451f, 0.19684805f, -0.07703621f, 0.21347654f, 0.13260022f, 0.06761691f, 0.09376229f, 0.06666850f, 
    0.06884909f, -0.05091165f, -0.06328801f, 0.05023891f, 0.17169778f, 0.10133708f, 0.04946196f, 0.14112218f, 
    -0.10426167f, 0.05194808f, -0.04256367f, -0.18132691f, 0.18626073f, 0.08569646f, -0.08559386f, 0.04199242f, 
    0.10006633f, 0.04630098f, -0.02399691f, 0.00929540f, 0.00258015f, 0.08068273f, 0.06031806f, 0.14014252f, 
    0.18124534f, 0.16992652f, -0.07951799f, -0.19182761f, -0.08011190f, 0.00790629f, 0.05643500f, 0.00066581f, 
    -0.00274967f, -0.00003090f, -0.12432513f, 0.05009462f, -0.10390855f, 0.02289012f, 0.12096879f, -0.09001747f, 
    -0.07348249f, -0.06777260f, 0.04639295f, 0.03302838f, -0.15489203f, 0.12103263f, 0.08216061f, 0.05118511f, 
    -0.23704442f, 0.03440292f, 0.09562176f, 0.13998307f, 0.01825146f, -0.03158812f, 0.17250670f, -0.04911411f, 
    -0.16956779f, -0.01483174f, -0.10818340f, 0.02742003f, 0.46976748f, -0.10074730f, -0.12799996f, 0.14161183f, 
    -0.07697102f, 0.20426872f, -0.16847351f, -0.01450490f, -0.05028632f, -0.01424595f, 0.12803078f, -0.03878402f, 
    0.09914456f, 0.10613894f, -0.17183931f, 0.06979173f, 0.00533255f, 0.06715370f, -0.07423110f, 0.08387174f, 
    -0.05293118f, 0.08140542f, -0.01338774f, -0.10203823f, 0.25258902f, 0.13486081f, -0.02723082f, 0.20367573f, 
    0.25498509f, -0.12615284f, 0.00885289f, 0.11420247f, 0.03375411f, -0.02332210f, -0.01645655f, 0.19042610f, 
    -0.51893342f, -0.18997091f, 0.00002882f, -0.13370873f, -0.02622283f, -0.02715646f, 0.00089795f, -0.01612051f, 
    -0.16211432f, 0.02721870f, 0.11405198f, -0.06644879f, -0.27309281f, 0.32924551f, 0.07261366f, -0.04489266f, 
    0.05292204f, -0.04047380f, -0.03979141f, 0.02484628f, -0.13395479f, 0.08859552f, 0.01902776f, 0.06112704f, 
    -0.03483119f, -0.02470813f, 0.27725452f, 0.00585299f, -0.00198889f, -0.04209122f, -0.07319728f, 0.13500774f, 
    0.11951670f, 0.03354916f, 0.02116785f, -0.13253208f, 0.18688749f, 0.26468334f, -0.01864505f, -0.16518082f, 
    -0.02496329f, -0.01518560f, 0.00111649f, 0.02600720f, 0.04062377f, -0.13203330f, -0.12789595f, -0.06699020f, 
    -0.20719390f, 0.40985525f, 0.20081295f, -0.24756606f, -0.07150767f, 0.11705411f, -0.07169104f, -0.09458821f, 
    -0.12461376f, 0.16960828f, -0.07223488f, -0.02771900f, 0.09816479f, -0.15359353f, 0.19228473f, -0.19263105f, 
    0.11235099f, 0.01574189f, 0.11402714f, -0.06396435f, -0.01546860f, -0.00310080f, 0.16696787f, 0.07298153f, 
    0.41216081f, 0.04486967f, -0.25252202f, 0.01021074f, 0.01991196f, -0.03833091f, -0.00297035f, -0.03857058f, 
    0.02308374f, -0.05394439f, -0.00713440f, -0.08398894f, 0.34954906f, -0.03061621f, 0.03040603f, 0.17615259f, 
    0.17793010f, 0.04045689f, 0.01875825f, 0.01342288f, -0.07428531f, -0.00379019f, 0.02101050f, -0.00412003f, 
    -0.21958838f, -0.20707005f, 0.01728154f, -0.07970362f, -0.09105014f, 0.08060253f, -0.01932267f, 0.09773359f, 
    -0.01470130f, -0.10587604f, -0.00393141f, 0.05273818f, 0.24395455f, 0.10867311f, 0.06352839f, 0.00121243f, 
    -0.08092646f, 0.12530239f, -0.06234352f, 0.03585999f, -0.19229548f, -0.02355048f, 0.09752353f, -0.08398037f, 
    0.23488155f, -0.16650954f, -0.19450863f, 0.03058416f, 0.14200774f, 0.09649707f, -0.02131693f, 0.06791411f, 
    0.08485535f, -0.01449612f, -0.02402335f, 0.01988920f, 0.19514264f, 0.06162476f, 0.06163000f, -0.00418826f, 
    0.11010021f, -0.16221160f, -0.01804154f, 0.03152335f, 0.02507832f, 0.04562616f, -0.02119151f, -0.00339294f, 
    0.42146388f, 0.33256286f, 0.03213014f, -0.05861713f, 0.02024893f, -0.03384136f, 0.07948484f, 0.03688101f, 
    0.08638012f, -0.08748104f, 0.06949270f, -0.01772693f, 0.25088355f, 0.02686813f, 0.06358824f, -0.08650172f, 
    0.01448802f, -0.02695227f, -0.08999648f, 0.01759047f, 0.01902315f, -0.03361744f, 0.03288769f, -0.05056647f, 
    -0.12766384f, 0.16399835f, 0.00496651f, 0.07613755f, 0.08379736f, -0.03175442f, -0.11418922f, 0.03603607f, 
    -0.02772244f, 0.09284070f, 0.11384346f, 0.13809457f, 0.04791594f, 0.08935370f, 0.03366989f, -0.00201960f, 
    0.03425168f, 0.06347517f, -0.17293192f, 0.07286792f, 0.04728854f, -0.04341413f, -0.02534980f, 0.00250790f, 
    -0.30972108f, -0.24854945f, -0.07563288f, -0.20753750f, 0.05298240f, 0.16965580f, -0.02069094f, -0.06689050f, 
    0.19509694f, 0.01865608f, 0.03580596f, 0.14549445f, 0.35523123f, -0.02694813f, -0.07706897f, 0.19324401f, 
    0.14979565f, -0.07096004f, -0.01358134f, 0.12487455f, -0.01159063f, -0.00065750f, -0.02458091f, 0.12125553f, 
    -0.19727351f, -0.14652522f, 0.12449327f, -0.04504862f, 0.13008064f, 0.14123335f, -0.06555968f, 0.05757776f, 
    -0.00369421f, 0.00924158f, 0.07091339f, -0.07536986f, -0.03324792f, -0.11695443f, -0.07918301f, 0.26106936f, 
    0.03544239f, -0.08769266f, -0.07835074f, -0.03455638f, -0.06537475f, -0.01200163f, -0.04845472f, 0.16998655f, 
    0.51792431f, 0.04781991f, -0.02495394f, 0.04065124f, -0.04470943f, 0.04563547f, 0.07057168f, 0.06363191f, 
    -0.05335521f, 0.08153463f, 0.01188689f, 0.06974001f, -0.11224946f, 0.03892758f, -0.08106212f, -0.32909751f, 
    0.11319044f, 0.11276422f, 0.04765203f, 0.05274301f, -0.00776857f, 0.19892693f, 0.02556017f, 0.06403805f, 
    -0.49459642f, -0.01417202f, 0.04002859f, 0.11537784f, 0.07068130f, 0.08482249f, -0.06414987f, -0.07262538f, 
    0.04080904f, 0.10266568f, 0.03302613f, 0.06574395f, -0.17916681f, 0.14593583f, -0.37602717f, 0.06296516f, 
    -0.07095191f, -0.04265624f, -0.01713550f, -0.07699493f, 0.06806144f, -0.11121864f, -0.13869242f, 0.06511231f, 
    -0.08980380f, 0.30047017f, -0.14560901f, 0.11084414f, -0.24886598f, -0.20582739f, -0.06681290f, 0.03948138f, 
    0.15578350f, 0.23445003f, -0.06373949f, 0.00220049f, 0.23695724f, -0.11452732f, -0.02944510f, -0.08369105f, 
    -0.02150745f, 0.07151641f, 0.05325296f, 0.18888800f, 0.10280259f, 0.07381658f, -0.03112420f, 0.10071014f, 
    -0.02074350f, 0.09068625f, -0.03831892f, -0.03124168f, -0.01859833f, 0.07768986f, 0.06021976f, -0.07459251f, 
    0.06321665f, -0.08549260f, -0.19388726f, -0.09699447f, 0.23336229f, 0.30841735f, -0.08137240f, 0.09178339f, 
    0.04599943f, -0.00785398f, -0.13194954f, -0.14082637f, -0.20180140f, -0.02052813f, -0.15191409f, 0.09641643f, 
    -0.16425653f, -0.04463757f, 0.09046423f, -0.21273562f, 0.00566268f, 0.08914685f, 0.08254277f, -0.07270166f, 
    -0.18567431f, -0.00176532f, -0.14101036f, -0.02724232f, 0.39843184f, -0.00916076f, 0.03658286f, 0.24498962f, 
    -0.04100812f, 0.04448060f, -0.09227687f, -0.00388111f, 0.01613105f, 0.02937632f, 0.02904424f, -0.12999089f, 
    0.39033535f, -0.04546019f, 0.06700934f, -0.08419064f, 0.00875165f, 0.19782172f, 0.05132590f, 0.12615183f, 
    0.09969669f, -0.15524872f, 0.00384904f, 0.09086282f, 0.03713363f, 0.11783734f, 0.04732130f, 0.03758682f, 
    -0.13724956f, -0.09636554f, -0.14327435f, 0.16124187f, -0.11642291f, 0.04359131f, 0.03389882f, 0.01442144f, 
    -0.04515141f, -0.10552073f, -0.13976759f, -0.12893488f, -0.12905627f, 0.04746323f, -0.08080870f, 0.08240279f, 
    0.00703507f, -0.09054341f, 0.11495617f, -0.16720709f, 0.14705385f, 0.28523704f, -0.22047763f, -0.14183381f, 
    -0.02682722f, -0.02966972f, -0.04565753f, -0.03999203f, 0.06009293f, 0.03413879f, 0.01110744f, 0.02884063f, 
    0.42574850f, 0.06418218f, 0.14934348f, -0.08825494f, 0.06629866f, 0.11446618f, -0.17279007f, 0.09045048f, 
    -0.04927463f, 0.01862391f, -0.11036401f, 0.13378111f, -0.01288535f, -0.09646516f, -0.09466588f, 0.18009157f, 
    0.01032679f, 0.14215177f, 0.07915916f, -0.01746215f, 0.01173816f, 0.02916945f, 0.09982771f, -0.14432365f, 
    0.28659323f, -0.07050835f, -0.08337420f, -0.07462762f, 0.09478836f, 0.11380869f, -0.15480618f, 0.05692933f, 
    0.04405471f, 0.01747137f, -0.04036312f, -0.06554951f, -0.01481244f, 0.03283251f, 0.04885458f, 0.10294054f, 
    0.11282489f, -0.04054429f, 0.04987327f, 0.02851204f, 0.06772423f, -0.02253715f, -0.00470830f, -0.26602721f, 
    -0.05683296f, -0.12039606f, 0.06035068f, 0.03225135f, 0.02091403f, -0.03667294f, 0.14554274f, 0.25748050f, 
    0.01056923f, 0.08025008f, 0.30466089f, 0.18712644f, -0.01364739f, 0.21194580f, 0.18183245f, 0.16029932f, 
    -0.00122478f, -0.09486049f, 0.20804000f, -0.00411567f, -0.07653743f, 0.06598015f, -0.04907699f, -0.06522752f, 
    -0.00008207f, 0.06401989f, -0.05389209f, 0.01244335f, -0.06241208f, 0.06511822f, -0.05083839f, -0.01914998f, 
    -0.06730965f, 0.06529649f, -0.06934809f, -0.00904968f, -0.02703354f, 0.03933012f, -0.01936231f, -0.06090635f, 
    -0.04276194f, -0.01010835f, -0.06254438f, 0.02106950f, -0.06143698f, 0.03377700f, -0.06831792f, 0.01194879f, 
    0.01617592f, 0.05618015f, -0.03807247f, 0.04345544f, 0.05282060f, -0.05603512f, 0.02459823f, -0.06738999f, 
    0.00682089f, 0.02814901f, -0.04215099f, -0.04306291f, 0.04960048f, -0.03947335f, -0.03725621f, -0.00186422f, 
    -0.06329060f, -0.06113230f, -0.02739744f, -0.00603370f, -0.03670024f, 0.03704276f, -0.06680307f, -0.05992591f, 
    0.06276166f, -0.05013666f, -0.03110132f, 0.05040939f, -0.01874961f, 0.02936306f, -0.05701915f, -0.07358084f, 
    -0.05754252f, 0.05441876f, 0.01445026f, -0.06257810f, 0.00311368f, -0.06452353f, -0.04982049f, -0.01291567f, 
    -0.01011452f, -0.04317120f, 0.05564125f, -0.01418013f, 0.02828923f, 0.05980325f, 0.01079759f, 0.01263562f, 
    0.05260177f, 0.04485894f, 0.04487858f, -0.02090631f, 0.03663672f, 0.03712704f, -0.01024276f, 0.06367407f, 
    -0.00806469f, -0.05867858f, -0.00846714f, -0.03151394f, -0.04396273f, 0.05335284f, -0.03193989f, 0.03952717f, 
    -0.00029407f, -0.06805029f, -0.05993266f, 0.02686650f, -0.01410931f, -0.01760127f, 0.00996988f, -0.02030989f, 
    -0.07584237f, 0.02947411f, 0.05580177f, -0.05554656f, -0.05338847f, 0.03097701f, -0.06060036f, 0.00293533f, 
    0.03427279f, -0.07380643f, -0.04751243f, 0.01303394f, -0.03355873f, -0.03015649f, 0.04941798f, -0.05483044f, 
    -0.03170247f, 0.01948345f, -0.03359872f, -0.06277958f, 0.03412262f, -0.01088623f, 0.02123288f, 0.00938386f, 
    -0.05573562f, -0.04677075f, 0.05521541f, -0.03406828f, -0.07588928f, -0.07539567f, -0.01710566f, -0.02836463f, 
    0.02630504f, 0.06442393f, -0.05266172f, -0.05634474f, -0.06041862f, -0.01755493f, -0.03497680f, -0.03411658f, 
    0.05768709f, 0.03197179f, -0.04536673f, -0.04517955f, -0.05268329f, -0.02287036f, 0.01787609f, 0.01363600f, 
    -0.02539578f, -0.01295136f, 0.01489509f, -0.02057283f, 0.02401452f, -0.00818151f, -0.03034636f, 0.06303883f, 
    0.04089244f, 0.06263273f, 0.02282895f, -0.06552198f, -0.02536143f, 0.01378345f, -0.02725786f, 0.02254418f, 
    -0.07130685f, 0.01555999f, 0.03892170f, 0.05311629f, -0.01053730f, -0.04111129f, 0.04607179f, -0.04571029f, 
    -0.07667582f, 0.04968252f, -0.05662021f, 0.05775094f, 0.02811458f, 0.03991414f, -0.03841114f, 0.03613606f, 
    -0.06312507f, -0.05973392f, 0.03408101f, -0.00387877f, -0.05597946f, -0.04501906f, -0.04199394f, -0.01881073f, 
    0.02046401f, -0.05092409f, 0.01255234f, -0.02539984f, 0.00226029f, -0.07009611f, 0.02293693f, -0.01573275f, 
    0.00716257f, -0.05558579f, -0.05535906f, -0.04703867f, 0.01323910f, -0.01257038f, 0.00891368f, 0.06399536f, 
    0.03307009f, 0.05183778f, 0.01749793f, 0.02111322f, -0.00320637f, -0.02627331f, -0.05984360f, 0.02627205f, 
    0.04186267f, -0.04101516f, -0.04979021f, -0.07470737f, -0.02793771f, 0.00475856f, -0.01487290f, -0.06166774f, 
    -0.00412022f, 0.00036716f, 0.02083738f, 0.03755390f, 0.01922818f, -0.04866373f, 0.00773663f, 0.00822301f, 
    -0.01726717f, -0.07480793f, -0.04607996f, -0.06721099f, 0.00885175f, 0.01211781f, 0.06291352f, 0.02647240f, 
    -0.00967518f, -0.01347605f, -0.04142880f, 0.02805405f, 0.03772387f, 0.05575837f, 0.04488225f, -0.03809808f, 
    -0.06707081f, 0.02700919f, 0.00340303f, -0.05435853f, -0.06405892f, 0.00077645f, -0.07405539f, -0.00442235f, 
    0.05507319f, -0.05559970f, 0.03041943f, -0.01836488f, -0.04355737f, 0.02110585f, 0.02801022f, 0.00255777f, 
    -0.03488699f, 0.06436443f, 0.00238048f, 0.05654386f, 0.01851857f, -0.00553071f, 0.02066257f, -0.05251434f, 
    -0.08028260f, 0.06060991f, -0.04385949f, -0.04149093f, 0.05087621f, -0.07875674f, -0.00826186f, -0.05197652f, 
    -0.00686940f, 0.04586164f, -0.06444621f, -0.05384756f, -0.03320592f, -0.04687749f, 0.04841457f, 0.02245851f, 
    -0.00362517f, -0.07444563f, 0.00844283f, 0.05979475f, 0.01662908f, -0.04043730f, -0.07088714f, -0.06684273f, 
    0.04983543f, 0.05595671f, -0.05501372f, -0.00367996f, 0.01154896f, -0.03933673f, -0.03537124f, 0.04215839f, 
    -0.02549431f, -0.00962877f, 0.00551261f, 0.02902216f, -0.02967851f, -0.05092400f, -0.03766353f, -0.04142327f, 
    -0.00222320f, 0.06217958f, -0.05384086f, -0.07460190f, -0.01759189f, -0.06641787f, 0.06803974f, -0.07063467f, 
    0.04287053f, 0.04251303f, 0.02023297f, -0.07865917f, 0.03708772f, -0.02565562f, -0.06117680f, 0.01719579f, 
    -0.01135772f, 0.06217086f, 0.05043031f, 0.06571871f, 0.01296783f, -0.04572060f, -0.07124868f, 0.06720353f, 
    0.03814031f, -0.02046361f, -0.00090688f, 0.03041790f, -0.01611152f, 0.01950413f, 0.00058976f, 0.03437655f, 
    0.01382250f, -0.03558716f, -0.07788590f, 0.01480793f, 0.02769173f, 0.01318840f, 0.00593834f, -0.07260505f, 
    0.03336647f, 0.00056733f, 0.04817887f, -0.00690132f, -0.07498950f, -0.02307084f, -0.00101275f, -0.04128941f, 
    0.05236575f, -0.03616438f, 0.04558251f, -0.01472381f, 0.06065953f, -0.02333614f, -0.01058870f, -0.05438108f, 
    -0.05272731f, 0.02416291f, -0.03100871f, 0.01740481f, -0.00554750f, -0.07164459f, -0.03321734f, -0.00212611f, 
    -0.04779558f, -0.00541035f, 0.01515104f, -0.00937471f, -0.03326698f, -0.03764326f, 0.01886057f, -0.03515079f, 
    -0.03342066f, 0.00625245f, -0.07156162f, 0.06024161f, 0.01021933f, 0.03995676f, -0.07947211f, 0.03093256f, 
    0.20704885f, -0.08911763f, 0.22224130f, -0.25934201f, 0.03957793f, -0.06029862f, 0.15469885f, 0.01839237f, 
    -0.06723271f, 0.01732589f, -0.02906965f, 0.00632063f, 0.52611959f, -0.42870641f, 0.11830336f, 0.10754947f, 
    -0.13328911f, 0.06508563f, -0.02261583f, -0.12521316f, 0.04273593f, -0.05012099f, 0.05651178f, 0.02399334f, 
    0.13032006f, -0.03442306f, 0.22756723f, 0.01618204f, 0.12632178f, 0.08554389f, 0.08582211f, -0.01053113f, 
    0.10782741f, -0.12187859f, -0.13788971f, -0.03119549f, 0.16039054f, 0.18943433f, -0.10565376f, -0.13224301f, 
    -0.10201894f, -0.06603251f, -0.20466626f, -0.08162496f, -0.09531879f, 0.08818194f, -0.02186706f, 0.09455933f, 
    0.09685273f, 0.15650535f, -0.24838237f, 0.36479092f, 0.02189193f, -0.14187789f, 0.07672866f, 0.20378780f, 
    0.11110205f, -0.07570752f, -0.03111013f, -0.13062033f, 0.54414952f, 0.01437110f, 0.15497361f, -0.08342395f, 
    0.08069988f, -0.01962009f, 0.05577794f, 0.01106222f, 0.03170240f, 0.01894618f, 0.02380116f, -0.01254457f, 
    -0.01901436f, -0.05547674f, 0.19604628f, 0.08868358f, -0.03907994f, 0.07710099f, -0.03871434f, -0.03229608f, 
    0.10163169f, 0.12700421f, 0.07648062f, -0.03639840f, 0.21538031f, 0.00352865f, -0.03134267f, -0.06426550f, 
    0.11328793f, 0.06464293f, 0.10392285f, 0.06913757f, 0.03426767f, 0.00392910f, 0.07398413f, 0.06251180f, 
    -0.17213587f, 0.18087323f, -0.08826021f, 0.22403574f, 0.18056433f, 0.07699634f, -0.03772977f, -0.07429423f, 
    -0.00226800f, 0.18855400f, -0.06578162f, 0.07381043f, 0.12979411f, 0.14487247f, -0.02549584f, -0.00214289f, 
    0.05074902f, -0.03318269f, -0.04655108f, -0.04603468f, -0.05041968f, -0.03430324f, 0.02649580f, -0.03741611f, 
    -0.34429523f, 0.22746198f, 0.01512481f, 0.09346957f, 0.02043729f, 0.00161364f, -0.02326004f, 0.15480885f, 
    -0.15669252f, 0.07776713f, -0.12308934f, 0.06096716f, -0.01182906f, -0.07225221f, 0.25522053f, 0.17731085f, 
    -0.17050073f, 0.07149788f, -0.08074500f, -0.12123843f, -0.11445089f, 0.03622006f, 0.00976381f, -0.05494913f, 
    0.10066590f, -0.19838080f, -0.08132532f, 0.22341429f, -0.07089741f, 0.03981927f, 0.02359746f, -0.10968021f, 
    0.02751451f, 0.10563613f, -0.00737350f, 0.00304523f, -0.08659291f, 0.03265088f, -0.28051457f, -0.12480741f, 
    0.02074641f, 0.00998001f, -0.06185381f, -0.12927639f, -0.11840563f, 0.04840787f, -0.01444902f, 0.04842461f, 
    -0.27199528f, -0.20991908f, 0.07431551f, 0.16308123f, 0.07173520f, -0.03777287f, -0.13146326f, -0.10402160f, 
    0.01037754f, 0.05411322f, 0.02404280f, 0.06344713f, 0.09987532f, 0.00780681f, -0.23268335f, 0.07949820f, 
    0.15714356f, -0.07414152f, -0.02385578f, 0.06441288f, -0.11397518f, -0.10609961f, -0.11995624f, 0.11264225f, 
    -0.02389142f, 0.05212802f, 0.07185207f, 0.00473675f, 0.03695739f, -0.05340043f, 0.03749533f, -0.05862559f, 
    0.02266988f, -0.05194604f, -0.06934372f, -0.06996194f, -0.00060068f, -0.04572894f, 0.02231491f, 0.05684200f, 
    -0.06658527f, -0.00900891f, -0.05568635f, -0.05547150f, 0.04134019f, 0.01904831f, -0.00652140f, -0.03352627f, 
    0.06627500f, -0.02137388f, 0.00122942f, -0.04884937f, -0.02032230f, 0.05374458f, -0.05658824f, -0.05096762f, 
    0.01612021f, 0.00639086f, 0.02878685f, 0.06445883f, -0.07548171f, -0.05885957f, 0.02046061f, -0.01211395f, 
    -0.03596316f, -0.05039141f, 0.01900108f, 0.05905255f, 0.00093872f, 0.02476506f, -0.00982817f, -0.06100479f, 
    0.04158175f, -0.05426895f, -0.00513267f, -0.04395834f, 0.01516760f, 0.02530652f, -0.03545570f, 0.04469042f, 
    -0.07405490f, 0.00955025f, -0.06132334f, -0.07455628f, 0.02488047f, -0.05862124f, 0.04338029f, -0.01815833f, 
    -0.02466271f, 0.01292513f, -0.02677699f, 0.02489525f, -0.05814634f, -0.07076963f, -0.07418519f, -0.04556006f, 
    0.03846874f, -0.05322487f, -0.04942343f, -0.01206278f, 0.01937762f, -0.02211246f, -0.00010837f, 0.03946993f, 
    -0.00491019f, 0.01984546f, 0.04088725f, -0.05557057f, 0.03136804f, 0.02076409f, 0.04513233f, -0.05337653f, 
    0.02681871f, -0.05621741f, 0.00552600f, -0.07012491f, 0.04456278f, -0.06723426f, -0.01775387f, -0.06364436f, 
    0.04984262f, 0.02774217f, -0.05482471f, -0.04672357f, 0.01471770f, 0.06565865f, 0.02850152f, 0.01790289f, 
    -0.05459861f, 0.04729357f, 0.02227896f, -0.04692814f, -0.02918651f, -0.00931042f, -0.05062843f, 0.04054010f, 
    -0.00075040f, 0.05447111f, -0.00325766f, 0.05970203f, -0.07660545f, -0.02041201f, -0.06187985f, 0.04940938f, 
    -0.07563887f, -0.05089512f, 0.03834046f, -0.00101067f, -0.07676876f, -0.00075081f, -0.00070654f, 0.00528559f, 
    0.02017181f, 0.03882258f, -0.05505614f, -0.01931646f, 0.03406801f, 0.02764504f, 0.05027539f, -0.01564157f, 
    -0.02356437f, -0.00791547f, -0.06090885f, 0.04257779f, 0.05835169f, 0.03185083f, -0.03253093f, 0.06249658f, 
    -0.03190220f, 0.05062307f, -0.07007649f, -0.02518816f, 0.04371466f, 0.02358139f, 0.01385045f, -0.05743071f, 
    -0.01984503f, -0.00440265f, 0.01920098f, 0.03196627f, -0.03215481f, 0.00008070f, -0.06437834f, 0.05182946f, 
    0.03810993f, -0.04618024f, -0.05779510f, -0.00989530f, -0.05196963f, -0.00657739f, 0.03617394f, -0.05242241f, 
    -0.02326526f, -0.02967479f, -0.06597350f, -0.02438969f, -0.05230644f, -0.03823374f, 0.06553850f, -0.00529238f, 
    -0.06568359f, 0.04223064f, -0.06040611f, 0.04149003f, 0.01448143f, -0.06138094f, 0.01904363f, -0.03938890f, 
    -0.01218331f, 0.04848679f, -0.05608015f, -0.04926093f, -0.03729010f, -0.07179633f, 0.02004929f, -0.05889228f, 
    -0.08086962f, 0.09906132f, 0.05178358f, 0.00024547f, -0.02342894f, -0.06433327f, -0.03002853f, -0.10144646f, 
    0.06761914f, -0.05562002f, -0.04036663f, 0.14996628f, -0.21339150f, 0.02805564f, -0.07713251f, 0.13902867f, 
    -0.04126778f, -0.14161721f, 0.08772802f, 0.08725420f, 0.14155109f, 0.01118334f, -0.02231108f, 0.06221792f, 
    -0.30292404f, 0.21830963f, -0.01044844f, -0.07914743f, -0.06205116f, -0.11981747f, -0.14024416f, 0.04415641f, 
    -0.16093907f, -0.04187054f, 0.01448677f, 0.08485068f, 0.19981164f, -0.38843343f, 0.10824721f, 0.21362202f, 
    0.09279715f, 0.10509602f, 0.09152745f, 0.02012504f, 0.24955945f, 0.08467636f, -0.02819992f, -0.04641575f, 
    -0.43257168f, -0.17494352f, 0.02558024f, 0.02611250f, 0.03568447f, 0.17506547f, -0.17740701f, 0.02349853f, 
    -0.17186706f, 0.07970775f, -0.06928411f, -0.00172911f, -0.25239265f, 0.24730186f, -0.11648142f, 0.04853888f, 
    -0.07428102f, -0.04440005f, -0.04507386f, -0.10752656f, 0.04602989f, -0.09979281f, 0.12557276f, 0.13012041f, 
    -0.37747833f, -0.20155604f, 0.12549423f, 0.22626932f, 0.07299168f, 0.02379807f, 0.07672410f, 0.05129084f, 
    -0.13377930f, 0.08401290f, -0.13513252f, 0.00926923f, 0.08979619f, -0.05372683f, 0.00209468f, -0.26964971f, 
    -0.29119378f, -0.15386230f, -0.04111019f, 0.08373231f, 0.03700111f, 0.06811554f, 0.02032604f, 0.08014968f, 
    0.29245555f, 0.20937599f, 0.09377641f, -0.24982432f, 0.02546194f, -0.08536054f, 0.03784048f, 0.05450145f, 
    0.07065549f, 0.11338203f, -0.01128865f, 0.00293403f, -0.05186444f, -0.24125974f, 0.08159155f, 0.09532508f, 
    -0.10394268f, -0.11143185f, 0.02886789f, 0.03281301f, 0.04762794f, 0.01581884f, 0.05025945f, 0.07809280f, 
    0.56856120f, 0.25625077f, -0.20755492f, -0.02591197f, -0.09850645f, -0.03854908f, -0.00225919f, 0.02989460f, 
    -0.03383967f, 0.00275009f, 0.01924329f, 0.04203483f, 0.17834105f, 0.07058762f, 0.08137428f, -0.15645620f, 
    0.06789224f, -0.09780411f, 0.02183924f, 0.14623149f, -0.07659283f, 0.06182044f, -0.09566044f, -0.06215028f, 
    -0.17920418f, 0.04612065f, 0.01572531f, -0.01629711f, 0.18238406f, 0.06361618f, 0.04946054f, 0.05694965f, 
    0.12928654f, -0.04669936f, -0.06234697f, 0.05999113f, 0.26077858f, 0.21912074f, 0.30327299f, 0.03054523f, 
    0.08268517f, 0.19024085f, 0.08065065f, 0.17621036f, 0.12959592f, 0.06208251f, 0.03236631f, 0.06902704f, 
    0.05873621f, 0.12243947f, -0.16849123f, -0.05121442f, -0.06135977f, 0.10710069f, 0.03948892f, 0.17034870f, 
    0.03683355f, 0.04257130f, 0.08955088f, -0.04777011f, -0.29671773f, 0.15384030f, 0.11792019f, -0.16445486f, 
    -0.12065668f, 0.14855309f, 0.01336441f, 0.06927063f, 0.10074848f, 0.05010308f, 0.04965379f, -0.04426175f, 
    0.17782053f, 0.12085138f, -0.02711093f, 0.29110071f, 0.22640866f, 0.16192922f, -0.05339975f, 0.00465705f, 
    -0.05196447f, 0.07683112f, 0.13148548f, -0.07125235f, -0.28986305f, 0.12941135f, 0.08088505f, -0.07065099f, 
    0.10619994f, -0.04530280f, 0.14152876f, 0.05662034f, 0.04799806f, 0.11982556f, 0.03607263f, -0.03209889f, 
    0.25741577f, 0.04754613f, 0.21929477f, 0.13734512f, -0.00999625f, 0.01354748f, 0.06212896f, -0.01866968f, 
    0.08719804f, 0.13402055f, 0.09142234f, 0.03880661f, -0.16972601f, 0.29204649f, 0.02346163f, -0.15339026f, 
    -0.03260288f, 0.08563436f, 0.06860093f, 0.06518765f, -0.07591338f, -0.18161781f, 0.05066603f, 0.05718178f, 
    -0.10195772f, -0.13278423f, 0.12230892f, -0.04416908f, 0.11279657f, 0.01505355f, -0.02509901f, 0.01128015f, 
    0.01417420f, -0.09773035f, -0.02417587f, 0.03182158f, -0.10935498f, -0.13079472f, -0.06868806f, -0.01923297f, 
    0.07203537f, 0.03731145f, 0.06665129f, 0.12457465f, -0.12862392f, 0.01180746f, -0.04022418f, 0.04665059f, 
    0.08058334f, 0.08908024f, -0.17060156f, -0.21358059f, -0.03774588f, -0.05444743f, 0.06831841f, 0.03053186f, 
    0.11888622f, -0.14494732f, 0.03512740f, -0.03406887f, -0.26846802f, 0.02769037f, -0.05046267f, 0.34358597f, 
    0.26906094f, -0.02530115f, 0.06217154f, -0.10848668f, -0.09252468f, -0.03998955f, 0.01105831f, 0.08517221f, 
    0.14058779f, -0.07563345f, -0.07602036f, 0.32937530f, -0.12676768f, 0.03657422f, 0.09664644f, 0.06280439f, 
    -0.20312747f, -0.04224942f, 0.00042838f, -0.03204228f, -0.14219739f, 0.26110128f, 0.20572072f, -0.08027416f, 
    0.00978186f, 0.10962663f, 0.04326991f, -0.06620187f, -0.03478606f, 0.04803302f, -0.01827785f, -0.04549273f, 
    -0.17378899f, 0.04365786f, 0.17859636f, 0.15393782f, 0.01857203f, -0.08535698f, 0.15294160f, 0.00997202f, 
    0.00211930f, 0.03254950f, 0.05102769f, -0.00108000f, -0.02091033f, 0.20721346f, 0.08470970f, -0.13282216f, 
    0.08394359f, 0.12404548f, 0.14150934f, 0.02342612f, 0.15792343f, 0.02581123f, 0.08912209f, -0.06220694f, 
    -0.28459871f, 0.02742616f, 0.15518430f, -0.12266535f, -0.15110578f, -0.03742784f, -0.16021307f, -0.06098948f, 
    -0.04507045f, -0.02228194f, -0.00297163f, -0.13769123f, -0.29959509f, -0.25622916f, -0.02138032f, 0.25452796f, 
    -0.23987900f, -0.17015994f, 0.07469568f, 0.04862022f, -0.16776507f, -0.08425932f, -0.06677201f, 0.09593840f, 
    0.57843024f, 0.00319748f, -0.11511236f, -0.05628983f, 0.01901991f, -0.16805948f, 0.09056862f, -0.00455474f, 
    -0.01776763f, -0.03192685f, -0.04356014f, 0.08411902f, 0.41120657f, -0.18538672f, 0.10642625f, 0.08248546f, 
    0.13902850f, 0.01443503f, 0.08623178f, 0.07946712f, 0.06744822f, 0.10599425f, -0.00910451f, -0.01707152f, 
    0.06286680f, 0.15178952f, 0.16094123f, 0.03069616f, 0.02976513f, 0.04403573f, 0.02360811f, 0.14420493f, 
    -0.11050849f, 0.12060942f, 0.03404551f, 0.09168307f, 0.21142289f, -0.33355913f, -0.07720280f, 0.11448082f, 
    0.04649118f, -0.05507605f, -0.03516842f, -0.05462926f, 0.15281208f, 0.07431474f, 0.02660108f, 0.07204267f, 
    0.14016108f, 0.00916013f, 0.29203969f, 0.16496247f, 0.12791619f, 0.09030189f, 0.07861000f, 0.01143259f, 
    0.03182688f, 0.00009903f, -0.04846213f, -0.06947656f, -0.17904180f, 0.33840334f, -0.01248743f, -0.00169613f, 
    -0.16057177f, 0.17406607f, -0.11809321f, -0.06120879f, -0.03694926f, -0.04411500f, 0.01257152f, -0.06295111f, 
    0.09059653f, 0.05399534f, -0.13632616f, 0.01545482f, 0.05874294f, 0.11154034f, 0.03258605f, -0.01959201f, 
    -0.09467257f, 0.02157008f, 0.00412492f, 0.02856522f, 0.24597304f, -0.20355615f, 0.15560070f, -0.00914347f, 
    0.00318650f, 0.17986085f, 0.10551895f, 0.03779501f, 0.03939464f, -0.01229539f, -0.08666790f, -0.02407735f, 
    0.36594066f, 0.03366008f, 0.03393396f, -0.07001171f, -0.14569415f, 0.12948632f, 0.14874753f, -0.03197270f, 
    0.06893662f, -0.08423526f, -0.00214338f, -0.01369454f, -0.08227024f, -0.06418892f, 0.05922592f, 0.23250145f, 
    0.15607661f, -0.02204016f, 0.16597259f, -0.00381156f, -0.18541536f, 0.03113081f, 0.04930355f, 0.08314290f, 
    0.16133115f, 0.21164654f, -0.19954668f, -0.04869240f, -0.10775375f, 0.03091310f, -0.08345349f, -0.03978362f, 
    -0.10743606f, -0.00031968f, 0.09631568f, -0.11986958f, -0.32290837f, 0.00440471f, 0.16339749f, 0.00059051f, 
    -0.11620390f, 0.07899564f, -0.06805985f, -0.09356820f, -0.07737539f, 0.13425681f, 0.02861355f, -0.01728746f, 
    -0.13084589f, 0.28273901f, 0.01716454f, 0.10600609f, 0.12877503f, -0.06319280f, -0.01749057f, 0.08339421f, 
    -0.05489144f, 0.10407584f, -0.15446313f, 0.05497498f, -0.17092820f, 0.05535447f, 0.23295169f, -0.04060334f, 
    0.05256395f, 0.08915038f, 0.04941043f, -0.00528143f, 0.08976150f, 0.19383031f, 0.07737418f, -0.04738079f, 
    -0.32738438f, -0.15165146f, 0.09409771f, -0.12272476f, -0.12647122f, -0.05836094f, -0.04805035f, -0.10646451f, 
    0.00771743f, 0.00857350f, -0.00140885f, -0.11068963f, -0.11533137f, 0.01116190f, -0.02189357f, -0.08141173f, 
    -0.02829743f, -0.03684139f, -0.05581380f, -0.10724282f, 0.03770908f, 0.02420894f, -0.04664335f, -0.04458225f, 
    0.63114339f, -0.12891990f, -0.08935617f, -0.16152842f, 0.16602443f, -0.08074087f, 0.02081821f, -0.06790657f, 
    -0.01569429f, -0.01108709f, 0.03909383f, 0.04656777f, 0.32127306f, -0.27132380f, 0.13677807f, -0.04933689f, 
    0.31526378f, -0.04759977f, 0.11230865f, 0.01542256f, -0.12867363f, 0.06988072f, 0.14649653f, -0.00447923f, 
    -0.06036566f, 0.17117336f, 0.14694445f, -0.11969838f, -0.26015311f, 0.07167072f, -0.01732347f, 0.01452434f, 
    0.05837770f, -0.14407632f, -0.12400556f, 0.07157533f, 0.32334098f, 0.15150438f, 0.17744854f, -0.13636267f, 
    0.04748385f, -0.10527415f, 0.02645964f, -0.01030042f, -0.05436203f, -0.17244498f, 0.06660344f, -0.13538322f, 
    -0.27434447f, -0.16591188f, -0.13708331f, 0.09455252f, 0.08892162f, -0.01909231f, -0.04893178f, 0.05914707f, 
    -0.01138753f, 0.04730232f, 0.12713231f, 0.05121623f, -0.13109456f, -0.17933999f, 0.04643871f, -0.11087403f, 
    0.17299835f, 0.00159941f, 0.07583372f, 0.12076782f, -0.03182091f, 0.16593525f, 0.11955898f, 0.16562977f, 
    -0.17548378f, 0.05756859f, -0.04449197f, -0.09421136f, -0.06286103f, -0.10600621f, 0.00290775f, 0.19168669f, 
    0.18180059f, 0.08326313f, 0.04794605f, 0.07903530f, 0.15220495f, 0.08839746f, 0.20250547f, -0.03250911f, 
    -0.06912305f, -0.08463418f, -0.02039473f, -0.01329194f, -0.03299994f, 0.22846760f, 0.00856388f, 0.08051240f, 
    -0.33788401f, 0.09055091f, 0.05419722f, 0.18819951f, -0.09651408f, -0.10254224f, -0.12137040f, -0.06968314f, 
    -0.08904599f, 0.12978826f, 0.05877533f, 0.01694263f, 0.27328697f, 0.10160939f, 0.19745816f, 0.19875562f, 
    -0.18453778f, 0.18318161f, -0.01142413f, 0.01370551f, 0.13858330f, -0.07083759f, -0.02486069f, -0.04564419f, 
    0.02006715f, 0.12445223f, 0.13137648f, 0.16160764f, 0.15564236f, 0.06178854f, -0.05861170f, -0.01087414f, 
    0.13322374f, 0.01874932f, -0.17206927f, -0.08308356f, 0.03120916f, -0.33806661f, -0.22084099f, -0.07540013f, 
    0.15401028f, -0.03695716f, -0.01655238f, -0.06596988f, 0.08686546f, 0.12350411f, -0.03068406f, -0.07817198f, 
    0.07424007f, 0.28564882f, -0.03518281f, 0.04444003f, 0.09563949f, -0.13577160f, -0.01346133f, 0.01753520f, 
    0.02161251f, -0.09413604f, 0.19884785f, -0.03198355f, -0.20265651f, -0.24586438f, -0.14652264f, 0.36026603f, 
    0.17632446f, -0.15446132f, -0.07132079f, -0.04440340f, -0.05116111f, -0.03521021f, 0.07098236f, 0.00824670f, 
    0.22105139f, -0.06330007f, -0.27435890f, 0.42007437f, 0.14903581f, -0.02871541f, 0.11599980f, -0.02082754f, 
    0.06856960f, 0.03319963f, 0.08614992f, 0.01749254f, 0.34307590f, 0.21488264f, -0.10504372f, 0.08418508f, 
    0.07530542f, 0.01752610f, -0.03458216f, 0.01094643f, 0.05669995f, 0.11723179f, 0.02844501f, 0.07794713f, 
    -0.30224589f, 0.16033857f, 0.19885996f, 0.04856027f, 0.02212924f, 0.07370479f, -0.15352438f, -0.00883900f, 
    0.11794132f, -0.04162595f, -0.10574037f, -0.11472878f, 0.06249019f, 0.23337606f, 0.08417202f, -0.06627480f, 
    -0.18365310f, -0.04249424f, -0.09763047f, -0.08263782f, 0.04127848f, -0.09498819f, -0.05779459f, 0.08245263f, 
    -0.21044950f, 0.27789590f, -0.08532649f, 0.00147162f, 0.04567373f, 0.00879469f, 0.18834025f, -0.08007577f, 
    -0.04295310f, 0.22348796f, 0.07402485f, 0.04580713f, 0.14874317f, -0.38024220f, 0.05584687f, 0.00772329f, 
    0.07616376f, 0.05439371f, 0.06403749f, 0.07304886f, 0.17896512f, -0.01130303f, 0.02047049f, 0.12089393f, 
    0.17511065f, 0.24945912f, -0.00343645f, -0.10320877f, -0.13497944f, -0.09573527f, -0.11535402f, -0.24137545f, 
    0.02123420f, -0.22715828f, -0.19977114f, -0.11275857f, 0.20355096f, 0.04494445f, 0.10288622f, 0.14843975f, 
    0.10710353f, 0.18062370f, -0.13290480f, -0.23677127f, 0.11965044f, -0.06558193f, -0.01666823f, -0.08004577f, 
    -0.56938076f, 0.12991133f, -0.19434161f, -0.21606743f, -0.11565640f, -0.05625473f, 0.05851540f, -0.21003005f, 
    -0.12336524f, -0.01546909f, -0.17355746f, 0.02487968f, 0.01981124f, 0.17530060f, -0.06929851f, -0.15010841f, 
    0.04257403f, -0.04649154f, -0.02990772f, -0.05818691f, 0.00090387f, -0.13317062f, 0.14480309f, 0.04823790f, 
    -0.01963618f, -0.04342132f, -0.12923321f, -0.16411383f, -0.05142621f, 0.17154077f, 0.12742175f, 0.10997511f, 
    0.02529866f, -0.13391015f, 0.07271213f, 0.02724235f, 0.00599013f, 0.12660435f, 0.03175659f, 0.13995746f, 
    -0.01889152f, -0.01085452f, 0.01849089f, 0.13310651f, -0.05875201f, -0.10245311f, -0.14546001f, 0.10680365f, 
    -0.11169036f, 0.02853681f, -0.02420179f, 0.03114206f, 0.03240816f, -0.13246393f, -0.19594380f, -0.05834287f, 
    -0.07337022f, 0.02883248f, 0.07665005f, -0.02094972f, -0.03439802f, 0.28026679f, 0.20658404f, 0.07945056f, 
    0.08399919f, 0.07569693f, -0.19376872f, -0.07585422f, -0.11078467f, 0.06338119f, 0.23110054f, 0.03226291f, 
    0.58329898f, 0.31232867f, -0.11116067f, -0.12362508f, 0.15061645f, 0.01563706f, 0.07447544f, 0.08569252f, 
    -0.01461814f, 0.06791376f, -0.23348890f, -0.00372323f, 0.39703080f, 0.23784758f, 0.17576896f, 0.14044982f, 
    0.05785117f, -0.08760732f, -0.17181492f, -0.08192550f, -0.01929416f, -0.00989922f, -0.07455222f, -0.08549147f, 
    -0.23702683f, 0.11077913f, 0.03930058f, 0.03732662f, 0.02147496f, 0.09471011f, -0.30132073f, -0.10410110f, 
    0.02965603f, -0.06235900f, 0.02502029f, -0.02834460f, 0.00257824f, -0.08287167f, 0.15812175f, -0.02733624f, 
    -0.02682630f, -0.06661396f, -0.08260506f, -0.17465554f, 0.12596464f, -0.05121388f, -0.11601043f, -0.02507666f, 
    0.78747916f, -0.15522806f, -0.36052126f, 0.01359264f, -0.15888262f, 0.08131175f, 0.14299352f, 0.00587361f, 
    -0.09160551f, 0.14759502f, 0.03922375f, 0.13466796f, 0.29252222f, -0.10204171f, 0.23947296f, -0.01871378f, 
    0.01614405f, -0.07200707f, 0.19934417f, 0.11249786f, 0.03627123f, 0.02165273f, 0.08394766f, -0.09748778f, 
    -0.00208766f, -0.13744773f, -0.05082314f, 0.39029890f, 0.04046883f, 0.20726849f, -0.02771153f, 0.11043487f, 
    -0.03286882f, -0.02965448f, -0.11089951f, 0.04938806f, -0.05815184f, 0.18532716f, 0.13041043f, -0.12419721f, 
    0.16655283f, -0.08380421f, -0.06102425f, -0.08265166f, -0.07890867f, -0.12842500f, 0.04544334f, -0.06479404f, 
    0.13204129f, -0.18913202f, -0.04402662f, 0.01650336f, -0.04075833f, 0.21204077f, 0.13550855f, 0.12194205f, 
    -0.07525209f, 0.04018369f, 0.22241864f, -0.01604681f, -0.43640661f, 0.22812822f, -0.12085980f, -0.08991227f, 
    0.05283534f, 0.00048468f, 0.12861885f, 0.01754244f, -0.02463375f, 0.03796919f, 0.11913195f, 0.23109393f, 
    0.05039114f, 0.03214866f, 0.15328363f, -0.15641756f, -0.00067826f, 0.05201470f, 0.18203308f, 0.14944942f, 
    0.12776966f, 0.02790797f, 0.03783145f, 0.15254396f, 0.14017490f, -0.33201453f, -0.04576847f, 0.12546283f, 
    -0.00626660f, 0.00424829f, -0.04653154f, 0.16122001f, -0.08049334f, 0.17545743f, -0.05703645f, -0.02682727f, 
    0.10259306f, 0.10370835f, -0.28594407f, 0.12284845f, -0.03136818f, -0.05634073f, -0.08961368f, -0.03857406f, 
    -0.01758478f, 0.07005864f, 0.13439539f, -0.08583345f, -0.01386896f, -0.01311432f, 0.07889781f, 0.30439726f, 
    0.00576346f, -0.04579776f, 0.01044926f, -0.03924515f, -0.01156424f, 0.01493453f, -0.00709616f, -0.06167761f, 
    0.11003456f, 0.03879288f, -0.03733860f, 0.03344081f, -0.08118047f, -0.02036205f, -0.03244381f, -0.06977015f, 
    0.12329240f, 0.04201167f, 0.03750579f, -0.11375589f, -0.30421296f, -0.27227777f, -0.04640727f, -0.02109209f, 
    0.09155250f, -0.06039036f, -0.05476492f, -0.19554910f, 0.13049474f, 0.06687164f, -0.08475807f, 0.12174174f, 
    -0.08781355f, 0.25864521f, 0.09733870f, -0.09103700f, 0.08749598f, -0.15503488f, -0.00406355f, 0.02579607f, 
    0.14232838f, -0.02940213f, 0.10376776f, -0.14351691f, -0.39917198f, -0.04449563f, -0.03902336f, 0.06646872f, 
    0.23435144f, -0.10648141f, -0.15871790f, -0.00548712f, 0.18061192f, 0.06908336f, 0.17860563f, 0.07729638f, 
    -0.35312670f, 0.06730535f, 0.01859677f, 0.04867148f, -0.03662723f, -0.04128123f, -0.01028107f, 0.01129701f, 
    0.11775301f, -0.02342496f, 0.01713815f, -0.07864029f, 0.07018711f, 0.16637057f, 0.11486195f, 0.01653908f, 
    -0.09218764f, -0.05396382f, -0.10887157f, -0.03763615f, 0.01783999f, 0.01736899f, 0.16148882f, -0.05397218f, 
    0.30167195f, -0.00152000f, 0.00787477f, -0.33133686f, 0.00061198f, -0.02007179f, 0.02834095f, -0.03278407f, 
    0.16648267f, 0.05427983f, -0.00032704f, 0.10491063f, 0.25217897f, -0.00143231f, -0.04907585f, -0.15670483f, 
    -0.03803702f, -0.07398526f, -0.04658170f, 0.22473440f, 0.05119812f, 0.04390528f, -0.00511738f, 0.09750906f, 
    0.20484409f, -0.06032795f, 0.27319059f, -0.11035231f, -0.04890949f, 0.03082984f, 0.08985399f, 0.14971709f, 
    0.01674691f, -0.18987399f, -0.08985235f, 0.27138501f, 0.11500255f, -0.05198205f, 0.09180676f, 0.22948316f, 
    -0.09406190f, 0.10797633f, -0.03893116f, -0.00549653f, 0.08152995f, -0.12760372f, 0.08149932f, 0.00151403f, 
    -0.21222654f, -0.27917516f, 0.00258837f, -0.03037102f, 0.06413299f, 0.13169099f, -0.07978800f, 0.06466420f, 
    -0.10801402f, -0.01457164f, 0.08809846f, 0.09164255f, 0.02459601f, -0.30232918f, -0.12169362f, 0.02243503f, 
    -0.10117453f, 0.09334347f, -0.01214042f, 0.03818430f, -0.18283850f, -0.05411037f, 0.07149304f, 0.01365354f, 
    0.32638311f, 0.08979710f, -0.15950477f, 0.10190652f, -0.11619180f, -0.12605067f, -0.08863778f, 0.27927324f, 
    0.24590982f, 0.08171506f, 0.06922463f, -0.01170835f, 0.31435570f, -0.02209635f, 0.11795860f, 0.09708671f, 
    0.05383336f, -0.18529366f, 0.04272762f, -0.01719294f, -0.01910874f, 0.04628334f, -0.07819887f, 0.23120919f, 
    -0.11446185f, 0.08713106f, 0.02936870f, 0.15689565f, -0.06267006f, 0.02909897f, -0.03239889f, 0.06973209f, 
    -0.02960681f, 0.13659933f, 0.14518738f, -0.10407901f, 0.31472471f, 0.03310983f, 0.10618842f, -0.22700568f, 
    -0.13151331f, 0.07862399f, 0.04909822f, 0.03330872f, 0.06409106f, -0.03860440f, -0.01425883f, -0.03064324f, 
    0.20856804f, 0.26806214f, -0.13639297f, -0.17692743f, 0.07556529f, 0.09193677f, 0.08608616f, 0.08311755f, 
    -0.00391589f, 0.27781621f, -0.06213362f, 0.14305340f, 0.15679924f, -0.43605882f, -0.00436970f, 0.03343903f, 
    0.07873853f, 0.01382432f, -0.09432760f, -0.09048232f, -0.25114030f, -0.13746870f, -0.16210005f, 0.00001052f, 
    -0.00938165f, 0.38587379f, 0.03166329f, -0.14642826f, -0.13578910f, -0.05674250f, 0.02029479f, 0.10747665f, 
    -0.05622822f, 0.09047284f, 0.06609505f, -0.09888282f, -0.22419313f, -0.15376207f, 0.15592660f, 0.08540148f, 
    0.17289938f, 0.06853262f, -0.08608294f, -0.00561183f, -0.22709461f, -0.08828986f, 0.02008136f, -0.07749609f, 
    -0.33426651f, -0.30533013f, -0.06677131f, 0.12957603f, 0.08432877f, 0.14447038f, 0.13552995f, -0.02711379f, 
    -0.03971609f, -0.19647674f, -0.08933027f, 0.02758815f, -0.15746130f, 0.09677798f, -0.16960758f, -0.08787643f, 
    0.18788336f, 0.12633033f, 0.06632174f, -0.04406239f, -0.02404418f, 0.05687432f, -0.01384323f, -0.02920676f, 
    -0.16030371f, -0.06265143f, 0.10059541f, -0.03754883f, 0.01006447f, 0.06276256f, -0.07860044f, -0.12328172f, 
    -0.19761351f, 0.03666402f, -0.05430481f, 0.13707127f, -0.09076855f, 0.12580916f, 0.04874300f, -0.09868150f, 
    0.04163582f, 0.04115135f, -0.02926729f, 0.11347913f, -0.11372554f, -0.13400941f, 0.05951102f, 0.06988303f, 
    0.14067161f, 0.26021218f, 0.03235389f, -0.02912260f, 0.03961537f, 0.14522535f, -0.05958793f, -0.28245920f, 
    0.03162432f, 0.05700314f, 0.09121244f, -0.10226667f, -0.46110848f, 0.16642554f, 0.04052101f, -0.18110543f, 
    -0.00152192f, -0.02788294f, 0.13903515f, -0.00623223f, 0.00546924f, -0.02514603f, -0.01190216f, -0.10571609f, 
    0.04260772f, 0.11301372f, 0.04978451f, 0.22326481f, -0.12124471f, -0.15001568f, 0.09014316f, 0.10139836f, 
    0.00228144f, -0.05135767f, 0.19893132f, -0.08475713f, 0.15138777f, 0.04940234f, -0.00621026f, 0.16056302f, 
    0.01588864f, 0.01199281f, -0.12900786f, -0.00920943f, 0.08790429f, 0.00178243f, -0.06036559f, -0.01418656f, 
    0.09419820f, -0.09723569f, 0.05745406f, 0.03117401f, -0.08083834f, 0.02656265f, -0.00803966f, -0.02862196f, 
    0.13278259f, 0.01261273f, 0.10208466f, 0.00543639f, -0.75238669f, 0.26736853f, 0.26141673f, -0.05907026f, 
    0.01605364f, 0.02011215f, 0.09012344f, -0.06803596f, 0.05374574f, 0.04326772f, -0.12959719f, 0.06399687f, 
    -0.07697029f, -0.00801953f, 0.07252804f, 0.02237008f, -0.03622635f, -0.10906254f, -0.01846263f, -0.11717815f, 
    0.02844159f, -0.06951680f, 0.00978445f, -0.04866422f, -0.02084504f, 0.14012747f, -0.04363647f, 0.01633049f, 
    0.09994125f, 0.23809832f, 0.07336603f, -0.05780971f, 0.02594196f, -0.00880513f, 0.01250160f, -0.05743414f, 
    0.18805718f, 0.19795652f, 0.27494687f, 0.40067735f, 0.19301316f, -0.02481676f, -0.06674761f, -0.05997633f, 
    -0.01049328f, -0.07551151f, -0.17334636f, 0.11130466f, 0.24257638f, -0.00869717f, -0.12235486f, 0.03923403f, 
    -0.07247449f, -0.04038033f, -0.01801658f, 0.09550862f, 0.06405384f, -0.06681675f, -0.06841552f, -0.08796848f, 
    0.04111932f, -0.04921452f, -0.02821223f, 0.08974034f, -0.10210510f, 0.00276708f, 0.11208198f, -0.11769395f, 
    0.06030026f, 0.03997458f, 0.06615124f, 0.11708713f, 0.10307205f, -0.13675861f, -0.12390498f, 0.14021385f, 
    0.11281710f, 0.10707951f, 0.04690290f, 0.04891540f, 0.03261277f, -0.01266192f, 0.05218225f, 0.13159463f, 
    0.28461471f, -0.17483664f, -0.03258381f, 0.33075389f, -0.02033178f, -0.15204872f, -0.06459534f, 0.08908189f, 
    0.11635746f, 0.03686076f, 0.06598545f, 0.08839542f, 0.00449030f, -0.00924430f, -0.15526259f, 0.31682134f, 
    -0.13583185f, -0.13545676f, -0.04978063f, 0.05731197f, -0.10297561f, -0.12748991f, -0.05027616f, 0.12572977f, 
    -0.19956228f, 0.04412733f, 0.29839066f, 0.21836109f, -0.03401653f, 0.09990729f, -0.02799290f, -0.05132348f, 
    0.05612366f, -0.05715413f, 0.01188815f, -0.02837230f, 0.07663713f, 0.15012887f, 0.22893170f, 0.06758924f, 
    -0.13959201f, 0.17473119f, -0.14310983f, -0.05800291f, 0.14491171f, 0.17107290f, 0.00041347f, -0.01748191f, 
    -0.24521905f, -0.26070198f, 0.06381931f, -0.04550687f, -0.06867980f, 0.07948695f, 0.02310639f, -0.02186581f, 
    -0.02770863f, -0.06742715f, 0.04466279f, 0.12478428f, 0.39677948f, -0.23859207f, 0.06653679f, 0.06603277f, 
    0.12406526f, -0.11635185f, -0.01908804f, -0.08879264f, 0.02277368f, -0.06347425f, 0.01531545f, 0.02838216f, 
    -0.03193935f, -0.28355789f, -0.17247884f, 0.05105324f, 0.03466583f, 0.02043791f, -0.07395922f, 0.07990581f, 
    -0.04940156f, 0.14594404f, 0.04681066f, 0.05158040f, -0.46516016f, 0.02137287f, 0.10190717f, -0.11019056f, 
    0.04163687f, 0.00392832f, 0.19442309f, 0.04852932f, 0.11646406f, 0.16628522f, 0.14949660f, -0.04642403f, 
    0.04110664f, 0.26298097f, -0.03517530f, 0.22541866f, -0.08548891f, -0.00464775f, 0.00910583f, 0.06424604f, 
    0.16039357f, 0.05722535f, -0.01226329f, 0.15763631f, 0.00460887f, -0.16534270f, 0.05708127f, -0.10947795f, 
    -0.06937972f, -0.04657265f, 0.06813413f, 0.10580415f, 0.02365605f, 0.19043401f, 0.04745002f, -0.03475221f, 
    0.00019004f, -0.05538408f, 0.02763352f, -0.00022517f, -0.08137117f, -0.12612671f, -0.12515099f, 0.03256231f, 
    -0.11484413f, 0.17777753f, -0.05732707f, -0.03077989f, 0.14912958f, -0.11850225f, 0.10080953f, 0.03392978f, 
    -0.01473042f, -0.04380802f, 0.07957188f, -0.13539775f, 0.02559813f, 0.06244367f, -0.00252435f, -0.01420084f, 
    -0.28411400f, -0.02416081f, -0.03597496f, 0.23410159f, 0.12111758f, 0.03662634f, 0.01949646f, -0.00586607f, 
    -0.09339809f, 0.10423108f, -0.09376828f, 0.10293411f, -0.50187385f, -0.07843990f, 0.05398354f, -0.22941896f, 
    0.24219294f, 0.12695949f, -0.05209449f, 0.03314020f, 0.00946337f, -0.00511797f, 0.03012007f, 0.11996438f, 
    -0.03545771f, 0.16710496f, 0.01037228f, 0.07773740f, -0.02364662f, -0.07473160f, 0.03353573f, 0.06192180f, 
    0.00285006f, 0.03966948f, 0.20035905f, -0.08974242f, -0.12107950f, 0.13226911f, 0.16791227f, -0.22413760f, 
    0.22545025f, -0.12202923f, -0.10762616f, 0.02360246f, 0.07197463f, 0.05379422f, 0.08580013f, 0.17351429f, 
    -0.06534053f, 0.12669420f, -0.00347656f, -0.06357043f, 0.10038852f, 0.05087468f, 0.02620388f, 0.00767279f, 
    -0.00004024f, -0.07877950f, 0.08136096f, 0.08052971f, 0.23765080f, 0.13454509f, -0.02983298f, -0.25829607f, 
    -0.01019331f, 0.06444982f, 0.15239915f, -0.04820502f, -0.04605045f, 0.07959040f, 0.02958321f, 0.15491396f, 
    0.09097200f, -0.18528371f, -0.02764560f, 0.08692978f, 0.08467686f, 0.12774780f, -0.12492078f, 0.04157345f, 
    0.07665424f, 0.04912620f, -0.06352377f, 0.03390624f, 0.13467658f, -0.13561942f, -0.10918136f, -0.17139284f, 
    -0.11260263f, -0.04886319f, -0.05345216f, -0.00455435f, 0.12343829f, -0.01880740f, 0.15491480f, 0.06853700f, 
    0.14172482f, 0.21664888f, 0.04042833f, -0.17643131f, -0.14309254f, 0.03457447f, 0.04918846f, -0.10095762f, 
    -0.04935876f, 0.21091972f, 0.04805959f, 0.06432353f, -0.00054493f, -0.27667809f, -0.03196855f, -0.10143120f, 
    0.16000175f, -0.13824303f, 0.05632106f, -0.01511528f, 0.07617273f, 0.07515151f, -0.03164869f, 0.11375808f, 
    -0.32362166f, 0.00402477f, 0.20814864f, 0.09964389f, -0.02234465f, -0.05339625f, 0.02152523f, 0.02339765f, 
    -0.10134031f, -0.06572044f, 0.07056826f, 0.01316407f, -0.17000566f, 0.03694311f, 0.02203636f, -0.01100306f, 
    0.09308594f, 0.11686301f, 0.10898440f, -0.02516993f, 0.07934902f, 0.03877441f, 0.07079624f, -0.01228358f, 
    -0.37338296f, -0.26544204f, -0.08080488f, 0.24542649f, 0.01901963f, 0.05462904f, -0.08235634f, -0.02967143f, 
    -0.15167485f, 0.08072834f, -0.02034937f, 0.01169994f, -0.12830874f, -0.06693695f, 0.12351128f, -0.02407182f, 
    0.07332875f, 0.02437853f, 0.05167631f, 0.04965360f, -0.05730241f, 0.16717760f, 0.02788639f, 0.09011958f, 
    0.24732697f, -0.24262206f, 0.16063288f, -0.11750357f, -0.03190977f, 0.09293763f, 0.03846546f, -0.00330504f, 
    -0.08502569f, -0.06124769f, -0.03115249f, -0.01601519f, 0.15319081f, -0.09392686f, -0.07368462f, -0.16653068f, 
    -0.19381396f, -0.02371032f, 0.05506160f, -0.17049618f, -0.07385756f, 0.05494953f, 0.07064947f, -0.00924542f, 
    0.19958271f, 0.29905501f, 0.14229488f, 0.51206100f, 0.20376278f, 0.05877926f, -0.00793651f, 0.09252379f, 
    -0.02938897f, 0.11312474f, 0.06429542f, 0.06337264f, -0.54461932f, 0.01971041f, -0.09514484f, -0.43930382f, 
    0.00270144f, 0.12752286f, -0.05824709f, -0.06056833f, -0.00835702f, 0.04953453f, 0.10095681f, -0.08148959f, 
    0.40679723f, 0.24895202f, -0.11554264f, 0.24630640f, -0.19260554f, -0.12337151f, -0.00785415f, 0.01672179f, 
    -0.05611523f, 0.00120164f, 0.04142418f, 0.15358932f, 0.05756703f, 0.22299416f, 0.12800585f, -0.30472976f, 
    0.11024280f, -0.00121167f, 0.05683212f, 0.00780901f, 0.02744748f, 0.06288362f, 0.07230626f, -0.00298621f, 
    -0.02660869f, -0.06954268f, -0.02668055f, 0.07529096f, 0.06961391f, -0.05558710f, -0.03674286f, 0.00788270f, 
    0.03511091f, -0.04424233f, 0.00003895f, -0.02313904f, 0.38920870f, 0.25386986f, -0.00226107f, 0.24709761f, 
    0.08189266f, 0.03251673f, 0.03167144f, -0.01240021f, -0.04468816f, -0.11079088f, -0.15533896f, -0.05642014f, 
    0.26209441f, -0.23411384f, 0.10851453f, 0.04116219f, 0.10360427f, 0.05458982f, -0.02696972f, 0.22393797f, 
    0.10078857f, 0.09155886f, 0.07513949f, 0.13910949f, 0.20960361f, 0.12428273f, 0.23637369f, -0.15300725f, 
    0.00346294f, 0.05197065f, 0.13560551f, -0.01358576f, 0.11472653f, 0.04179109f, 0.16358952f, -0.02748787f, 
    0.09128778f, 0.31902358f, 0.13014777f, 0.27626607f, 0.01321287f, -0.02744073f, -0.08582529f, 0.14385912f, 
    -0.04273458f, -0.00587299f, -0.00062846f, 0.06349242f, 0.00111111f, -0.02220406f, 0.14657277f, 0.16501224f, 
    0.02217400f, 0.08927846f, -0.15136643f, 0.03371553f, 0.04529943f, 0.03749649f, 0.00673013f, -0.09612502f, 
    0.11426820f, -0.05231440f, 0.02939007f, 0.23242062f, 0.21087265f, 0.09231905f, 0.07903507f, -0.06334828f, 
    0.10594381f, -0.03958679f, -0.05222049f, -0.02307356f, -0.14542671f, 0.13656065f, -0.02825476f, 0.03721432f, 
    -0.01968972f, 0.04340082f, -0.07178161f, -0.14462392f, -0.11599299f, 0.00091084f, -0.00560942f, -0.13833314f, 
    0.19964215f, 0.07844530f, -0.03411574f, -0.32106304f, 0.02222654f, 0.08130988f, 0.01015353f, -0.03264838f, 
    0.05048539f, 0.04347544f, -0.04958404f, -0.05530433f, 0.34431770f, -0.02972629f, 0.15517056f, 0.12059017f, 
    0.03511825f, 0.03406526f, -0.01727401f, 0.11191774f, -0.03606319f, 0.05073386f, 0.02229718f, 0.00700079f, 
    0.12491474f, 0.09708114f, -0.01990437f, -0.11482380f, -0.00064500f, 0.00331844f, 0.11638928f, 0.06958175f, 
    0.13260567f, 0.03055033f, 0.05746428f, 0.00479333f, -0.25129414f, 0.12445413f, 0.27594239f, 0.44747946f, 
    -0.02239365f, -0.13774352f, -0.10390835f, 0.01612024f, -0.23403300f, 0.03196934f, -0.04879598f, -0.00268451f, 
    0.12413460f, 0.02565224f, -0.28567165f, -0.27129221f, -0.12231536f, -0.08983120f, -0.06337012f, 0.01457575f, 
    0.05379676f, -0.03273096f, 0.17459300f, 0.05525420f, 0.10990795f, -0.13608369f, 0.02528597f, 0.15779005f, 
    0.12579159f, 0.14843014f, -0.00672653f, -0.08729479f, -0.13787562f, -0.02221816f, -0.09791816f, -0.16877319f, 
    -0.14335497f, 0.35158637f, 0.12568481f, -0.01851472f, 0.16166227f, -0.05014048f, 0.00720240f, -0.00766084f, 
    0.07201099f, 0.04512134f, 0.00061649f, 0.04294288f, -0.27768761f, -0.09979752f, 0.13313921f, 0.28206757f, 
    0.21513548f, -0.00162752f, -0.04581850f, -0.08950441f, -0.00798601f, 0.05282114f, 0.07213686f, -0.16180442f, 
    -0.21400535f, -0.22285573f, 0.09906921f, 0.05022580f, 0.13665804f, 0.08377555f, 0.01714992f, -0.04699671f, 
    0.00201199f, 0.01932764f, -0.13417031f, 0.02014332f, -0.35653153f, -0.18016109f, -0.14756519f, -0.06146067f, 
    -0.05730178f, -0.14356081f, 0.05305813f, -0.06392525f, 0.13640121f, 0.04975542f, 0.05218797f, -0.08974780f, 
    0.58409894f, -0.00671133f, -0.23182710f, -0.39605534f, -0.01805222f, 0.04265587f, -0.02729426f, 0.02308584f, 
    -0.02243235f, 0.08716384f, -0.05329865f, 0.09341447f, 0.04545685f, -0.16429846f, 0.17488477f, -0.08174636f, 
    0.09483737f, -0.04115303f, -0.06828150f, -0.03919195f, -0.15854378f, 0.11584609f, 0.02467335f, 0.08316211f, 
    -0.13308656f, 0.20798385f, -0.00383000f, 0.03960486f, -0.19228256f, -0.19226903f, 0.01073173f, 0.12984961f, 
    0.02285649f, 0.03028371f, -0.01777542f, -0.09287334f, 0.15772659f, 0.00796416f, -0.28702471f, 0.09115028f, 
    -0.05397613f, 0.15431955f, -0.05960349f, 0.05866066f, -0.03867117f, 0.15421347f, 0.01735992f, 0.16768034f, 
    -0.06804530f, -0.11629208f, -0.17543963f, -0.02177656f, 0.04154734f, 0.11827479f, -0.01382605f, 0.01218042f, 
    0.12663867f, -0.04721657f, -0.22949034f, -0.12782963f, 0.00993232f, 0.21185035f, -0.00608347f, 0.17209241f, 
    0.06437891f, -0.04085237f, 0.07509942f, -0.13762589f, -0.10703823f, -0.02017367f, -0.16625403f, 0.05733252f, 
    0.12578562f, -0.01154720f, 0.01436822f, -0.24563633f, 0.14528000f, 0.07622645f, 0.06917617f, -0.05638562f, 
    -0.07335240f, -0.07611546f, 0.06841683f, -0.02961166f, 0.56600225f, 0.03574055f, 0.02316424f, 0.17170274f, 
    -0.00214170f, 0.16136225f, -0.15109472f, -0.00171967f, -0.02283901f, -0.09158269f, 0.17111051f, -0.05215109f, 
    0.45925641f, -0.01583423f, -0.10250418f, -0.18657361f, 0.09075530f, 0.03108614f, 0.08665570f, 0.24220364f, 
    -0.06410503f, -0.10088255f, 0.08291986f, 0.15186329f, -0.03012702f, 0.08696902f, 0.10803285f, 0.10459021f, 
    -0.20213528f, -0.07219731f, -0.10548870f, 0.12911946f, 0.01140377f, -0.00505308f, -0.05963468f, 0.01096683f, 
    -0.05352829f, -0.30886373f, -0.14248338f, -0.29324177f, -0.23985274f, 0.06828995f, -0.05606176f, 0.12537366f, 
    0.02392246f, -0.10006990f, 0.10717245f, 0.03983533f, 0.02445149f, 0.29144102f, 0.07041577f, -0.09131394f, 
    0.08058488f, 0.11823890f, 0.04365157f, 0.11914926f, 0.05828022f, 0.09212944f, 0.07915652f, 0.09840784f, 
    -0.00691859f, -0.30612910f, 0.08586368f, 0.01110188f, 0.16366591f, 0.25405413f, 0.01490168f, 0.01597651f, 
    0.04605497f, 0.16040100f, -0.08470361f, 0.05163183f, 0.11425132f, 0.00428881f, -0.21070060f, -0.23601724f, 
    -0.04116008f, -0.14050880f, -0.04697273f, 0.10636987f, -0.02546458f, -0.11535225f, 0.10393802f, -0.09044261f, 
    0.30726677f, 0.02224622f, 0.19876605f, -0.41061944f, 0.07976411f, 0.06215236f, -0.11853006f, -0.05586046f, 
    0.05467157f, 0.12037003f, 0.11082257f, -0.06549811f, 0.03003103f, -0.01280944f, -0.02353094f, -0.17573404f, 
    0.11597658f, 0.06590273f, -0.03631533f, 0.11642924f, 0.10050276f, -0.03490298f, 0.01711547f, -0.25556204f, 
    -0.05355806f, 0.06002012f, -0.25014794f, -0.06220846f, 0.02511361f, 0.03184810f, -0.02993960f, 0.03011793f, 
    0.05324570f, 0.04156636f, 0.26411045f, 0.16275355f, 0.02486609f, 0.05004554f, 0.12419063f, 0.16595313f, 
    0.07397834f, -0.05897734f, 0.22561949f, -0.07427927f, -0.10300769f, -0.08107878f, -0.02483645f, -0.09829609f, 
    0.00047767f, -0.04729940f, 0.01393963f, -0.25375813f, -0.01612008f, -0.02657466f, 0.02910071f, -0.07971106f, 
    0.03593520f, -0.04728678f, 0.15316021f, -0.17740647f, 0.13111283f, -0.16818906f, -0.13609199f, 0.04464575f, 
    -0.11022516f, 0.07434665f, -0.02163108f, 0.05458855f, -0.08145266f, 0.03520798f, 0.00418719f, 0.04314923f, 
    -0.14182878f, -0.11286265f, -0.01074035f, 0.25355721f, 0.32154316f, -0.03324812f, -0.11058881f, 0.01847066f, 
    0.03544470f, -0.10474969f, -0.08216321f, -0.00686815f, 0.01090380f, -0.06411093f, -0.08225961f, -0.05544406f, 
    0.19434188f, -0.05782865f, 0.11670479f, 0.03913789f, 0.11368033f, 0.16608065f, -0.03873318f, 0.06289045f, 
    -0.04435999f, -0.05598831f, -0.04020534f, 0.32624173f, 0.12356096f, -0.17305814f, -0.02908538f, 0.13753951f, 
    0.13963132f, -0.14531539f, 0.13115780f, -0.11939965f, 0.26833197f, 0.18278177f, 0.06576000f, -0.12748584f, 
    0.07687679f, 0.02334285f, 0.03056415f, -0.00661011f, 0.01259377f, 0.08375572f, 0.14261936f, -0.03984857f, 
    -0.19691664f, -0.22082287f, 0.15388010f, -0.15223967f, 0.10955689f, 0.00872468f, -0.06594142f, 0.00303721f, 
    -0.05964186f, 0.15634462f, -0.02894191f, 0.16851981f, 0.05443671f, 0.13333127f, -0.11720245f, 0.06867144f, 
    -0.07880849f, -0.01463968f, 0.01244518f, -0.04392432f, 0.07655736f, -0.00512777f, 0.07025181f, -0.05338190f, 
    -0.05365528f, -0.16043591f, 0.08263601f, 0.36241800f, 0.17171107f, 0.10530604f, 0.07260638f, -0.10047705f, 
    0.02597097f, 0.05539980f, -0.05410836f, 0.31024480f, -0.00760022f, 0.19168946f, 0.03312311f, -0.15562549f, 
    0.20493570f, 0.07192656f, 0.01847131f, 0.03658485f, -0.00056966f, -0.05415442f, 0.04254889f, 0.09364423f, 
    -0.20165163f, -0.23378611f, -0.17474969f, 0.26207936f, -0.09405221f, 0.10216866f, 0.08853555f, 0.03311666f, 
    -0.05848314f, 0.09440981f, -0.00014285f, 0.02526215f, 0.13070025f, 0.07428009f, 0.06054204f, -0.28041065f, 
    0.06768804f, -0.03733291f, -0.11420176f, -0.02202858f, -0.17278077f, -0.17225336f, 0.01677941f, 0.11628871f, 
    0.35766229f, -0.18350305f, 0.10356628f, -0.00227365f, 0.11010982f, 0.01999561f, 0.05652152f, -0.09469552f, 
    -0.03375683f, 0.04557135f, 0.06777623f, 0.00367567f, 0.22715965f, 0.13371223f, -0.23526001f, -0.04651391f, 
    0.09139029f, -0.02004469f, 0.01911981f, 0.18320467f, 0.02910726f, 0.17319074f, -0.00354989f, 0.03694998f, 
    -0.49322477f, -0.16862902f, 0.01083315f, 0.05240574f, 0.10948143f, 0.04190442f, -0.20266497f, 0.05472681f, 
    0.08048723f, 0.15945601f, 0.04388123f, 0.04658446f, -0.01973075f, 0.03680952f, -0.14152984f, -0.06994149f, 
    -0.12327952f, -0.00631091f, 0.02786562f, -0.12126433f, 0.09456640f, -0.09746824f, -0.16673209f, -0.07743509f, 
    0.00096620f, -0.49690697f, -0.07779796f, -0.00721871f, 0.23167169f, 0.19747061f, 0.13502668f, 0.12306067f, 
    -0.02877845f, -0.09664519f, -0.03965406f, 0.06459350f, -0.01468015f, 0.10584243f, 0.03661770f, 0.07270867f, 
    0.03758268f, 0.09867298f, -0.12066993f, -0.13598377f, -0.10479853f, 0.04403556f, 0.01247499f, -0.03337875f, 
    0.34081817f, 0.12797935f, 0.21708302f, 0.00274253f, -0.11822187f, 0.11559881f, 0.17135024f, 0.12191218f, 
    0.13536899f, 0.00381346f, 0.02536588f, 0.16015263f, -0.01658412f, 0.13164113f, 0.07672928f, -0.00133581f, 
    -0.07624511f, -0.05762269f, -0.04429601f, 0.05261317f, -0.06189736f, -0.02098232f, 0.03261311f, 0.08076575f, 
    0.36003354f, 0.12989572f, 0.04778598f, 0.37882900f, 0.03267614f, -0.01030483f, 0.17208280f, 0.12495227f, 
    0.08446484f, -0.01182594f, 0.04813425f, 0.03818144f, -0.13338599f, -0.22981974f, -0.17218624f, -0.04130854f, 
    0.09869269f, -0.04573508f, -0.03323343f, 0.11488218f, -0.00060922f, 0.13900580f, -0.10497820f, -0.04445883f, 
    0.34629926f, 0.07262324f, -0.10488735f, 0.01774972f, 0.00932031f, 0.07551984f, -0.05950832f, -0.07685484f, 
    0.05611075f, 0.08050390f, 0.01087114f, 0.09453455f, 0.04667738f, -0.10084377f, -0.37079269f, -0.25442955f, 
    0.32138529f, 0.10219389f, 0.09021089f, -0.01691110f, 0.04550850f, -0.02819827f, 0.03581656f, 0.14604786f, 
    -0.08749586f, -0.11665838f, 0.09829903f, 0.07716743f, 0.01051588f, -0.05057676f, 0.10523542f, 0.11356078f, 
    -0.06059857f, 0.09768005f, -0.07553848f, 0.05642679f, -0.03399755f, 0.11730485f, 0.18324333f, 0.18512018f, 
    -0.18296744f, -0.07590037f, 0.03196094f, -0.08513275f, -0.07737133f, -0.14174469f, -0.03382222f, 0.10334553f, 
    -0.38721001f, -0.28066441f, 0.19783805f, -0.12085853f, -0.02124679f, 0.07133514f, 0.12765390f, -0.00820822f, 
    0.05300336f, 0.02853890f, -0.06808565f, -0.07550436f, 0.06943817f, 0.17758206f, 0.31360218f, 0.07380374f, 
    -0.14740196f, 0.10914543f, 0.03496235f, -0.05198106f, 0.15860114f, 0.05170164f, 0.00731138f, 0.11563324f, 
    -0.02859337f, 0.21516091f, 0.02869747f, -0.03215288f, -0.20057379f, 0.07591961f, 0.09371372f, 0.04043277f, 
    -0.14851695f, 0.05530450f, 0.01830414f, 0.06382530f, -0.11441094f, -0.05211002f, 0.10498222f, -0.11532638f, 
    0.05546875f, 0.08919705f, -0.06920747f, -0.06255074f, -0.17088950f, -0.03156432f, 0.03637138f, 0.10562094f, 
    -0.34906566f, -0.13428731f, 0.21113034f, 0.13772501f, 0.00800822f, -0.01886423f, -0.03783402f, -0.12842414f, 
    -0.17569067f, 0.03835059f, -0.00322158f, 0.03916628f, -0.11577392f, 0.06611727f, -0.50197721f, 0.08026394f, 
    0.12739909f, 0.10372251f, -0.08203982f, 0.21760243f, 0.08508823f, -0.13077164f, 0.00234721f, 0.06206043f, 
    -0.02220317f, 0.16879080f, 0.02644622f, -0.05552146f, -0.17409688f, 0.01780283f, -0.11582498f, -0.07264188f, 
    -0.01317024f, -0.08896524f, -0.02651560f, -0.05267022f, -0.16998479f, 0.27383408f, 0.06485105f, -0.19285491f, 
    0.00680649f, 0.06996091f, 0.10213012f, -0.11902087f, -0.21188055f, -0.08375230f, 0.00540205f, -0.05633494f, 
    0.06136893f, -0.15319014f, -0.10320311f, 0.09830470f, -0.11094794f, -0.03481355f, 0.02027370f, 0.16862476f, 
    0.03085435f, 0.01212550f, 0.12011946f, -0.04759207f, 0.03098175f, 0.21969017f, 0.07144079f, 0.20560791f, 
    0.10442742f, -0.00508365f, -0.10860540f, -0.00373034f, -0.00682648f, -0.09968843f, -0.02722543f, 0.11708783f, 
    0.65085858f, 0.18685143f, 0.12891136f, -0.24779119f, 0.01618657f, 0.00332362f, 0.02280605f, -0.06752530f, 
    0.17249259f, 0.07296374f, 0.14534910f, 0.09181211f, -0.51787180f, 0.09074944f, 0.11971158f, 0.02864257f, 
    -0.06054178f, -0.02835857f, 0.08493462f, -0.01124475f, 0.08061484f, 0.10322520f, -0.02056151f, -0.05545790f, 
    0.20883071f, 0.13222125f, -0.04252831f, -0.00950771f, -0.09686036f, -0.22722661f, 0.05814026f, -0.04156240f, 
    0.00979090f, -0.03502439f, 0.04220535f, 0.16093144f, -0.13749133f, 0.12296233f, 0.12063444f, -0.03340207f, 
    0.06366508f, 0.25752729f, -0.08408485f, -0.05930461f, 0.02174887f, 0.00748266f, -0.03563480f, -0.12729374f, 
    0.03757336f, -0.12790959f, 0.11784060f, 0.00780325f, 0.06984808f, 0.06191159f, -0.09749749f, 0.00384373f, 
    0.17408970f, -0.10909881f, -0.15381217f, 0.10196891f, 0.31633148f, -0.05010020f, -0.20984186f, 0.10993864f, 
    0.06530318f, 0.04445035f, 0.06186657f, -0.00352416f, 0.01700957f, -0.09442995f, -0.01095168f, 0.03436322f, 
    -0.00072080f, -0.25558713f, 0.19476615f, 0.02051170f, -0.01091901f, 0.06046233f, -0.05037376f, -0.13491681f, 
    0.07273202f, 0.02753243f, 0.10974911f, 0.01645871f, -0.14482798f, -0.11764589f, -0.12192122f, 0.35774851f, 
    0.09948853f, -0.08502786f, -0.04996788f, 0.07215127f, 0.01259206f, 0.05851659f, 0.14822547f, 0.16085708f, 
    0.50787073f, 0.00683965f, -0.10947883f, 0.07405127f, -0.03707220f, -0.09318820f, -0.04035171f, 0.09374355f, 
    0.08377033f, 0.11102697f, 0.07565313f, 0.16558349f, -0.16208804f, -0.09738767f, -0.26746917f, 0.04611465f, 
    -0.10836606f, -0.13221121f, 0.07034080f, -0.00981161f, 0.13552266f, 0.10056739f, 0.01593249f, -0.02769530f, 
    -0.53776062f, 0.01418372f, 0.45177642f, 0.21016343f, 0.07208899f, 0.02524963f, -0.02658311f, -0.00887130f, 
    0.06279384f, 0.02140502f, 0.01197664f, 0.04660581f, -0.22260016f, 0.23608789f, -0.10029247f, 0.12182010f, 
    -0.18387821f, -0.04497743f, -0.11125579f, -0.17896207f, 0.01178769f, -0.08551239f, -0.02763058f, 0.03245673f, 
    -0.27762055f, -0.20000640f, 0.12193510f, -0.28345588f, -0.00756329f, -0.16309087f, 0.10412192f, 0.05375204f, 
    0.10049341f, -0.09070630f, -0.02617984f, 0.12430826f, 0.47718427f, -0.43235219f, 0.00173474f, 0.25024650f, 
    -0.15715928f, 0.06567422f, -0.05119420f, -0.06216630f, 0.12071710f, -0.05182157f, 0.02952293f, 0.14889447f, 
    -0.01923313f, -0.01011774f, 0.02900363f, -0.08098614f, 0.07699484f, 0.04001895f, -0.12489116f, -0.06089027f, 
    0.04173857f, -0.14796641f, -0.03419953f, 0.03658521f, 0.06813388f, -0.01350034f, -0.01026696f, -0.03079996f, 
    -0.04329479f, 0.03477950f, -0.02605692f, 0.04124406f, -0.03166229f, 0.10306708f, 0.02658870f, -0.07519098f, 
    0.12202359f, 0.24206731f, -0.19881175f, 0.19613798f, 0.05218868f, 0.03920492f, 0.07477082f, 0.14609864f, 
    0.07847512f, -0.05998707f, -0.03681052f, 0.06407318f, 0.29075876f, 0.07216534f, 0.02957291f, -0.01710744f, 
    0.02068495f, 0.01787601f, 0.15151635f, 0.00397545f, 0.11312710f, 0.03202078f, 0.00113948f, -0.02853067f, 
    -0.00718482f, -0.02953430f, 0.30736646f, 0.00991675f, 0.02386404f, 0.14617249f, 0.01977362f, 0.09632328f, 
    0.05615463f, 0.07070075f, -0.04155919f, -0.02751641f, 0.06825958f, -0.17417713f, 0.06683192f, -0.22089717f, 
    -0.11856831f, -0.09376381f, 0.02051706f, 0.08038370f, 0.02734563f, -0.00349781f, -0.04250528f, 0.05998126f, 
    -0.15883759f, 0.15642650f, -0.15789326f, -0.17976300f, 0.05362967f, 0.10083194f, -0.07514916f, -0.00272113f, 
    0.03472700f, 0.12826821f, -0.02350382f, 0.04150565f, 0.10753835f, 0.07361431f, 0.05341610f, 0.05739850f, 
    -0.05645289f, 0.00166902f, 0.00884767f, 0.04879652f, -0.04361813f, 0.03253538f, 0.07641993f, 0.13384616f, 
    -0.04491001f, 0.18776664f, -0.01366782f, -0.04814781f, 0.07429593f, 0.03185378f, -0.10821591f, 0.08097630f, 
    -0.04577138f, 0.03076250f, -0.04381627f, 0.02485704f, 0.07623823f, -0.03719182f, 0.18674004f, 0.08282193f, 
    -0.09394899f, -0.04150498f, -0.04648141f, 0.04384855f, -0.19832650f, 0.00129221f, -0.09127484f, 0.09211311f, 
    0.17932631f, 0.03513076f, -0.20146228f, -0.05080800f, 0.06820015f, 0.00738981f, 0.08443462f, -0.03221758f, 
    0.08314647f, 0.00294451f, 0.00015333f, 0.03765745f, 0.04046096f, 0.23697282f, -0.06715534f, -0.31719077f, 
    0.06403689f, 0.10742054f, -0.06574757f, -0.07108113f, 0.01467992f, 0.06326225f, -0.00560471f, 0.01476366f, 
    -0.11365665f, -0.20392399f, -0.07262319f, 0.11736751f, -0.02537759f, -0.01311548f, 0.00288790f, -0.11767402f, 
    0.02552496f, 0.15739070f, 0.00234201f, 0.01327757f, -0.06028233f, -0.10070670f, -0.18737710f, -0.07911001f, 
    0.09192888f, -0.11758764f, 0.07978574f, 0.01305496f, -0.03927688f, -0.22688024f, 0.07272150f, 0.07486476f, 
    0.02501537f, 0.08615603f, 0.25494662f, -0.03477950f, 0.00668558f, -0.15661065f, 0.05631513f, 0.17806827f, 
    -0.03374973f, -0.06046495f, 0.06134932f, -0.01675872f, 0.18625772f, -0.21080004f, -0.37497687f, -0.03014611f, 
    -0.03990775f, 0.10855184f, 0.00151968f, -0.01170225f, 0.01993186f, 0.08753349f, -0.01171917f, 0.07945083f, 
    -0.18074284f, 0.00237734f, 0.04788535f, -0.22126475f, 0.07772784f, -0.03026166f, -0.13572943f, 0.08582423f, 
    0.13857077f, -0.01974545f, -0.24913506f, 0.00085899f, -0.07050727f, -0.15489790f, -0.15052438f, 0.03791296f, 
    -0.05744307f, 0.17338027f, -0.03973166f, -0.06502975f, 0.12029849f, 0.02742953f, -0.02701101f, 0.03319751f, 
    0.03550945f, -0.04831062f, -0.10816994f, 0.09588313f, 0.09285529f, 0.14329712f, -0.01475338f, 0.04141194f, 
    -0.21015531f, 0.11379470f, -0.07816764f, -0.06271999f, 0.53151321f, -0.09925254f, 0.03843330f, 0.26483229f, 
    -0.18022144f, 0.11980454f, -0.02450243f, 0.03219061f, 0.00233102f, -0.02099027f, 0.11157294f, 0.11980328f, 
    0.42837116f, -0.16989322f, -0.03451689f, 0.03558291f, 0.10374518f, 0.03860983f, 0.12864813f, 0.20338093f, 
    0.06686711f, 0.19722769f, 0.00141362f, 0.11402499f, 0.13648798f, -0.15524639f, 0.02597272f, -0.31050107f, 
    -0.14498957f, -0.17386234f, 0.06068948f, 0.04644586f, -0.17109641f, 0.13679391f, 0.06501600f, 0.16811627f, 
    0.02264580f, 0.33079273f, 0.05544182f, -0.29942524f, -0.15406005f, -0.02224600f, -0.05230213f, -0.00580820f, 
    0.04095408f, 0.09617619f, 0.14598964f, 0.05385030f, -0.31883538f, -0.09868087f, 0.12302454f, -0.19608261f, 
    -0.07269195f, 0.00133106f, -0.00210180f, -0.10395139f, 0.00093105f, 0.04594751f, 0.07012035f, 0.27446869f, 
    0.09795692f, -0.02248829f, -0.11222772f, 0.12089641f, 0.01279480f, 0.08527233f, 0.10911245f, 0.06434844f, 
    -0.02731049f, 0.06188620f, -0.05623360f, 0.04831642f, 0.00561694f, 0.10469833f, -0.04436674f, -0.47733968f, 
    -0.15676266f, -0.11528373f, 0.00240751f, 0.02677932f, -0.07237112f, 0.11486223f, -0.02627911f, -0.00691641f, 
    -0.25824064f, -0.14770047f, 0.22365403f, -0.34500048f, 0.04614919f, 0.17086992f, -0.04002607f, 0.03053558f, 
    0.07639164f, 0.03389631f, 0.12485048f, -0.01397703f, 0.16348006f, 0.11465701f, 0.18254526f, -0.10338520f, 
    0.15641654f, 0.01211746f, -0.05676607f, 0.04372407f, 0.26410630f, 0.13439327f, 0.03053294f, -0.10771935f, 
    0.03435167f, -0.18363638f, -0.33907807f, -0.23999073f, 0.13412163f, 0.02105562f, -0.03844791f, -0.00970358f, 
    -0.00418827f, -0.10901538f, 0.11512573f, -0.04471380f, 0.10759164f, 0.14032967f, 0.27433336f, 0.04900607f, 
    0.26036388f, -0.09696349f, 0.23822714f, -0.04524900f, -0.09015235f, -0.12541035f, 0.10093378f, -0.14029451f, 
    0.04871415f, -0.03111517f, -0.07336840f, -0.06609210f, 0.01737907f, -0.07727910f, -0.00173823f, 0.06776195f, 
    -0.02223914f, -0.07506865f, 0.03004455f, -0.07870448f, -0.05864422f, 0.05011572f, 0.02552398f, -0.06296882f, 
    -0.02942534f, 0.04755660f, -0.04533854f, 0.02834467f, 0.04777495f, -0.03101937f, 0.01660508f, -0.01372946f, 
    0.01344361f, 0.03822874f, -0.06838717f, -0.00449336f, 0.05570636f, -0.01345406f, 0.03656305f, 0.02155333f, 
    -0.02031823f, -0.01751191f, 0.00868384f, -0.03862325f, 0.05204979f, -0.02245433f, 0.01619281f, -0.04260346f, 
    -0.06539100f, -0.01934526f, -0.05950785f, 0.05382677f, 0.06470201f, -0.03628416f, 0.04124080f, 0.04560527f, 
    -0.02103773f, -0.00573624f, -0.07288974f, 0.05407413f, 0.03304207f, 0.01298183f, -0.01686365f, 0.02875032f, 
    -0.07501493f, 0.05290586f, 0.04626884f, 0.04868465f, -0.06064466f, -0.04885475f, 0.05370757f, -0.00604986f, 
    0.00406087f, -0.00992051f, -0.07353491f, 0.03997707f, -0.06578145f, -0.05907434f, -0.04945124f, -0.07097466f, 
    -0.04011536f, 0.03617653f, -0.00965264f, 0.05091558f, -0.04012615f, -0.03881957f, 0.06411267f, 0.00494520f, 
    -0.05198707f, -0.07924693f, -0.06841671f, 0.02812661f, -0.05011403f, -0.05566010f, 0.06264880f, 0.00924213f, 
    -0.00388464f, 0.01391055f, 0.05936931f, -0.06632313f, 0.01716117f, -0.06639551f, 0.03444241f, 0.00999364f, 
    -0.05229458f, -0.01925059f, -0.06619327f, -0.02733375f, -0.02181634f, -0.01868748f, -0.06108242f, -0.06709468f, 
    -0.05958527f, 0.04317063f, -0.06677270f, 0.03807085f, -0.05969864f, -0.02198969f, 0.00890706f, 0.00107326f, 
    0.00551002f, -0.04605485f, 0.06493243f, -0.05191140f, 0.05607772f, 0.02439285f, 0.03582159f, 0.04615992f, 
    0.03514040f, 0.00908646f, 0.03801718f, 0.04531317f, -0.06197390f, -0.02513673f, 0.05463698f, -0.06076147f, 
    -0.04801185f, -0.05556583f, 0.03918581f, -0.04085192f, 0.02848603f, 0.06119868f, 0.04286171f, -0.04709458f, 
    0.04175645f, 0.03817731f, -0.02949354f, -0.05587200f, -0.04534246f, 0.03128216f, -0.01787732f, -0.04487475f, 
    -0.00536941f, 0.06547887f, -0.03781238f, -0.06000171f, 0.04244583f, -0.00846476f, 0.04894182f, 0.04470658f, 
    -0.04218477f, -0.02235636f, 0.01361695f, 0.03378859f, -0.00006575f, -0.06823983f, -0.06880533f, -0.07888639f, 
    -0.06094725f, 0.06107439f, -0.00104344f, 0.00584015f, -0.03943517f, -0.05997827f, -0.04535618f, -0.01236320f, 
    0.05513465f, -0.00948571f, 0.02198575f, -0.05929466f, -0.03832491f, 0.05206542f, -0.05526561f, -0.03227068f, 
    0.04998155f, -0.07414734f, 0.05193179f, 0.05648201f, -0.00150920f, -0.04516218f, 0.04949500f, 0.01264254f, 
    -0.00192568f, -0.03226894f, -0.07498267f, -0.04041538f, -0.07108926f, -0.04301007f, -0.07020570f, -0.02880281f, 
    0.01103851f, -0.07617151f, 0.03619596f, 0.05021689f, -0.01083356f, 0.01791212f, 0.00407243f, -0.04833559f, 
    -0.04778239f, 0.03823909f, 0.05636115f, -0.01119468f, 0.01528227f, -0.04078722f, -0.05977375f, -0.02403682f, 
    -0.06754404f, -0.00304878f, -0.07287045f, 0.04591412f, 0.05239172f, 0.03253364f, 0.03211311f, -0.02540971f, 
    -0.07453336f, 0.04019709f, 0.00711901f, -0.05994047f, -0.04975609f, -0.00584321f, -0.01921989f, -0.05643110f, 
    -0.03309283f, 0.04712929f, -0.03383714f, -0.02181579f, -0.07363082f, -0.07491211f, -0.03327512f, 0.02581884f, 
    -0.00871350f, -0.07877547f, -0.07339891f, -0.03401856f, -0.04456593f, -0.07312980f, -0.02664971f, 0.05021224f, 
    -0.03321455f, -0.02459065f, 0.03473879f, -0.00866907f, -0.05147615f, -0.04397259f, 0.01655809f, 0.01011752f, 
    0.00005811f, -0.07269856f, -0.05198372f, -0.06923583f, 0.00029631f, -0.03630927f, -0.04890257f, -0.05309696f, 
    -0.02744805f, -0.00831588f, -0.06334464f, -0.07763996f, -0.07510307f, 0.04122743f, -0.07448801f, 0.01173801f, 
    -0.00572678f, -0.08202413f, 0.01623225f, -0.06384166f, -0.00591791f, -0.07859842f, -0.07044792f, -0.05299283f, 
    -0.01636427f, -0.06704157f, -0.05080830f, 0.01760136f, 0.04628913f, -0.00079574f, 0.03191575f, -0.02099044f, 
    0.02551926f, -0.02560741f, -0.02313910f, -0.06795587f, -0.01192101f, -0.07618802f, 0.03796829f, 0.05789680f, 
    0.05884799f, 0.04201143f, -0.07549015f, -0.06048688f, -0.04453088f, 0.04317835f, -0.01379313f, -0.03859975f, 
    -0.02059161f, 0.04334750f, -0.00233926f, -0.00722457f, -0.07826301f, -0.02521625f, 0.04570883f, -0.04526916f, 
    0.02080085f, -0.04039866f, 0.02799197f, 0.02194508f, -0.01846547f, -0.03505361f, 0.06348914f, 0.04083028f, 
    0.03340111f, 0.05305981f, -0.00516867f, 0.02736243f, -0.05190644f, -0.00203452f, 0.02708475f, -0.06971706f, 
    -0.02808584f, 0.01058570f, -0.05239730f, 0.00814020f, 0.00890145f, -0.01415821f, 0.06088690f, 0.02513639f, 
    -0.05078698f, -0.04982691f, 0.05873648f, 0.04846078f, 0.05635013f, -0.03831832f, -0.08342685f, -0.04763203f, 
    0.01946234f, 0.04449709f, -0.01875413f, -0.02410371f, -0.01844355f, -0.00120898f, 0.02739918f, -0.07311203f, 
    0.03116344f, -0.07490376f, 0.05946462f, -0.01988658f, -0.05227118f, 0.00620402f, -0.07858967f, 0.03990236f, 
    0.04732440f, -0.00934956f, 0.00125254f, 0.06074073f, -0.05046940f, 0.00263413f, 0.03125527f, 0.04099737f, 
    -0.03158042f, -0.07538643f, 0.05616484f, 0.02565892f, -0.01444718f, -0.02352215f, 0.02212136f, -0.02288633f, 
    0.03454570f, -0.05362993f, -0.03242172f, 0.05000737f, -0.02365780f, 0.02105678f, 0.04418046f, -0.02355748f, 
    -0.01258778f, -0.00112130f, -0.03191072f, 0.02702114f, -0.08078327f, 0.04104154f, 0.00990032f, -0.05725184f, 
    -0.26481375f, -0.13260329f, 0.04339997f, -0.18300883f, 0.11121759f, -0.00282767f, -0.00190345f, -0.08066010f, 
    0.05636945f, 0.05316739f, 0.23582694f, 0.14549273f, 0.00395688f, -0.28285718f, 0.00602611f, 0.12356762f, 
    0.05117447f, -0.10962769f, 0.04729262f, -0.10526025f, 0.10528394f, -0.06073074f, -0.04322684f, 0.01329417f, 
    0.09000394f, -0.12062917f, 0.11403196f, 0.28346932f, 0.04150812f, -0.00864953f, -0.06058379f, -0.03717990f, 
    0.11824948f, -0.06863572f, 0.19103202f, -0.08464675f, -0.19505939f, 0.11000919f, 0.06907226f, 0.11003666f, 
    -0.04154531f, 0.10100830f, -0.05456734f, 0.00698150f, 0.21710755f, -0.03558012f, 0.03332850f, -0.11375120f, 
    0.37529209f, 0.14206912f, -0.13276049f, 0.29826003f, 0.15354848f, 0.04138321f, -0.04345356f, 0.01780666f, 
    0.10616542f, -0.04559895f, 0.11253411f, 0.04069369f, -0.54824966f, -0.04740150f, -0.05482972f, -0.07869282f, 
    -0.05895327f, 0.04875920f, 0.31191668f, 0.06639791f, -0.00972607f, 0.05073094f, 0.07257656f, 0.03530387f, 
    0.31723198f, -0.05331318f, 0.06265980f, -0.17501597f, -0.05038085f, -0.08239885f, 0.02990631f, 0.02586598f, 
    -0.05687109f, 0.02479517f, -0.03334766f, -0.03417940f, -0.34533906f, -0.25833118f, 0.09407956f, -0.10617533f, 
    0.00324133f, 0.02055296f, 0.11416523f, -0.07299600f, -0.11904994f, -0.00372065f, 0.05140716f, -0.05868778f, 
    0.27844858f, 0.04353832f, -0.13057120f, 0.06290820f, 0.09873187f, -0.07410502f, -0.04015972f, 0.02321988f, 
    -0.14925548f, 0.02220683f, -0.01601879f, 0.16027877f, -0.31505778f, 0.14874639f, 0.17092143f, -0.09077701f, 
    0.06364980f, 0.12502986f, -0.10157143f, 0.07511080f, 0.08228894f, 0.06174381f, 0.06417108f, 0.02211764f, 
    -0.06964894f, 0.03947250f, -0.12889883f, 0.14393014f, -0.04536321f, 0.00862253f, 0.15049398f, -0.01995485f, 
    -0.10267906f, 0.08350267f, -0.01684650f, 0.08044846f, 0.03244120f, 0.18706523f, 0.30592072f, -0.22468628f, 
    0.08177229f, -0.11255895f, 0.11897311f, 0.00754219f, 0.09715515f, 0.12348231f, -0.02874464f, 0.21040513f, 
    0.04363516f, -0.08710457f, 0.12004795f, -0.14130738f, -0.02134725f, -0.06818045f, 0.04349837f, -0.05456165f, 
    0.12797055f, -0.09369414f, 0.10970583f, 0.03435464f, -0.17071003f, 0.03021433f, -0.17050220f, -0.08795093f, 
    -0.01945326f, 0.04209998f, 0.15796697f, 0.07349066f, 0.10236922f, -0.05042807f, -0.18742162f, 0.13323581f, 
    0.35712528f, -0.34124157f, 0.02960747f, -0.06734992f, 0.10215712f, 0.06177048f, 0.00455949f, -0.06430907f, 
    -0.06728142f, 0.04419152f, 0.05321083f, 0.09079569f, -0.00034839f, -0.29366851f, -0.00213905f, -0.22340077f, 
    0.05186293f, 0.17637892f, 0.07258500f, 0.00684645f, -0.02544064f, 0.02003152f, 0.12691072f, 0.06672602f, 
    -0.02684744f, 0.05748079f, 0.05111514f, -0.04151182f, 0.00307514f, -0.02853753f, -0.00019182f, 0.01916599f, 
    -0.00299556f, -0.06016175f, -0.05322713f, -0.02645096f, -0.04722549f, -0.04172246f, 0.04840119f, -0.05087717f, 
    -0.04130588f, 0.04993905f, 0.05378286f, 0.04987583f, 0.00463107f, 0.06491125f, 0.04990720f, 0.03579809f, 
    0.01309815f, -0.00044836f, 0.05714677f, 0.00046689f, -0.01331525f, 0.03649059f, -0.04167324f, -0.01622750f, 
    0.01785461f, 0.00260347f, 0.05058564f, 0.02801306f, -0.05988115f, 0.01922718f, 0.01841471f, -0.03475821f, 
    0.05951526f, -0.02232106f, 0.05245439f, 0.05376321f, -0.02544245f, 0.00730061f, 0.00881505f, -0.07157853f, 
    -0.01060012f, 0.05369130f, 0.03268743f, -0.03071821f, -0.07452142f, 0.05193863f, -0.07711054f, -0.07030611f, 
    -0.02917329f, -0.00368949f, -0.05037025f, 0.02545541f, -0.06288202f, 0.05037154f, 0.06200404f, -0.01550575f, 
    0.03476359f, 0.01862645f, -0.01346853f, 0.00998180f, 0.04119832f, 0.06234513f, -0.05207085f, 0.02834804f, 
    -0.00766362f, 0.02559993f, -0.01205965f, -0.06111078f, -0.00007740f, -0.07798667f, -0.04428476f, 0.00193622f, 
    -0.05350479f, -0.06852768f, -0.00229294f, 0.01582374f, 0.03951819f, -0.07621333f, 0.05201980f, 0.05979003f, 
    -0.06720079f, 0.04905189f, 0.03550441f, -0.07378832f, 0.04797288f, -0.04932761f, -0.02072066f, 0.00923593f, 
    0.01566515f, -0.06110657f, -0.04789619f, -0.05334195f, 0.02444948f, -0.01831454f, 0.04327737f, -0.06268886f, 
    -0.06640869f, 0.04822157f, -0.01219215f, -0.00125612f, -0.04178935f, -0.05462502f, 0.05809328f, -0.07252102f, 
    -0.03922960f, -0.00894443f, -0.06029024f, -0.07439020f, -0.00403160f, 0.03488718f, -0.04449407f, -0.07362356f, 
    -0.03675653f, -0.00892473f, 0.03802606f, -0.00077005f, -0.07559599f, 0.04000206f, -0.04775503f, -0.01484977f, 
    -0.06258691f, -0.03642806f, 0.03987261f, -0.05490088f, -0.05321911f, 0.01244786f, -0.02303373f, 0.03318482f, 
    0.01364176f, 0.01339395f, -0.00592673f, -0.03207372f, 0.04070347f, 0.03040470f, -0.01835376f, -0.06140027f, 
    0.00380534f, -0.02029971f, -0.05661394f, -0.05067196f, -0.06283965f, -0.04864684f, 0.02820861f, -0.02535672f, 
    -0.03806971f, -0.03234601f, -0.02451871f, -0.05204588f, -0.05407705f, -0.02550213f, 0.00891288f, 0.03789762f, 
    -0.05174454f, -0.06251159f, -0.07554442f, -0.04780880f, 0.01756727f, 0.04643913f, -0.04955434f, -0.03056934f, 
    0.03484323f, 0.02031382f, 0.03922807f, 0.00289307f, -0.02528685f, 0.03031765f, 0.02517553f, 0.01738617f, 
    -0.01323064f, -0.03665389f, 0.02943800f, -0.04911146f, -0.06251419f, 0.00916852f, 0.01245803f, 0.05587121f, 
    -0.03500454f, -0.06159908f, 0.05391780f, -0.04628686f, -0.06177292f, 0.02711633f, 0.05037110f, 0.02736888f, 
    0.16365580f, -0.22274275f, -0.00246340f, -0.00579752f, 0.11170768f, -0.04827705f, -0.03715076f, 0.19050476f, 
    -0.02772035f, -0.25864178f, -0.09362940f, 0.14351261f, -0.38479275f, 0.39714053f, -0.13550574f, -0.02213737f, 
    -0.00037330f, 0.05551585f, -0.12685001f, 0.05697903f, -0.06122405f, -0.07943103f, 0.16491731f, 0.03846457f, 
    -0.10415498f, 0.20171572f, 0.08836826f, -0.21760018f, 0.00740696f, 0.16161056f, -0.04595154f, 0.04735307f, 
    -0.05022203f, 0.10769735f, -0.05576520f, 0.03651246f, 0.04152854f, -0.45389518f, -0.02303609f, -0.01811757f, 
    -0.04251060f, 0.01057932f, 0.16451751f, 0.11475553f, 0.12677658f, 0.06166600f, 0.04280251f, 0.15283264f, 
    -0.16972996f, -0.21463740f, 0.00598370f, -0.05408791f, 0.00627269f, 0.13568619f, -0.04555425f, 0.06478504f, 
    -0.02867434f, 0.02430228f, -0.00199600f, -0.05096604f, 0.21412033f, 0.07300869f, -0.14095330f, 0.10376415f, 
    -0.06484825f, 0.00216120f, -0.08053621f, 0.01041146f, -0.00610286f, -0.10414711f, 0.06777009f, 0.14765707f, 
    -0.34175715f, -0.01797888f, -0.18134344f, 0.20589016f, 0.11765871f, 0.14414835f, 0.07984942f, 0.07687491f, 
    -0.02639604f, 0.20238476f, 0.08355174f, 0.00094409f, 0.20628855f, 0.03116008f, -0.18753885f, -0.21008602f, 
    -0.10599352f, -0.09920555f, 0.00743118f, 0.10926145f, 0.12693591f, 0.05536732f, 0.02755446f, 0.10826492f, 
    0.26866966f, 0.16607851f, 0.19740334f, -0.27930868f, -0.08307900f, 0.01715904f, 0.26599246f, -0.01684938f, 
    0.18407379f, 0.16767424f, 0.04002786f, 0.06274175f, 0.06455009f, -0.34153733f, 0.18653765f, 0.23571149f, 
    -0.15722403f, -0.08050136f, 0.03551606f, 0.02916720f, 0.00849288f, -0.02161204f, -0.11596505f, 0.16939256f, 
    -0.08985807f, 0.11880272f, -0.09159947f, -0.21807620f, -0.02368892f, -0.00232292f, 0.18082547f, 0.00778653f, 
    0.04536469f, -0.03513349f, 0.04153904f, -0.15500572f, 0.03932650f, 0.00058290f, 0.01591325f, -0.10349075f, 
    -0.08832800f, 0.02922617f, -0.08649784f, -0.04806200f, -0.03718630f, -0.10021925f, -0.07169516f, -0.04936946f, 
    -0.48170558f, 0.15254007f, 0.18171023f, 0.01054651f, 0.13532579f, 0.10926927f, 0.01354828f, -0.00222233f, 
    -0.05394616f, 0.05436373f, -0.03587180f, 0.00786797f, 0.12235416f, 0.16280399f, 0.33453166f, -0.00885545f, 
    0.21169558f, 0.16850322f, -0.01710394f, 0.16785519f, 0.04472011f, 0.10825920f, 0.07037970f, 0.04286396f, 
    -0.13374168f, 0.28700194f, -0.24767545f, -0.21030739f, 0.00632269f, -0.00380643f, 0.09167355f, -0.09260654f, 
    -0.02918899f, -0.08684403f, -0.12961030f, -0.03544366f, -0.25578383f, 0.05440426f, 0.02262349f, 0.01528933f, 
    0.19086674f, 0.01798440f, -0.04706481f, 0.22323684f, -0.05894173f, -0.04952854f, 0.02863994f, 0.06461912f, 
    -0.01236831f, -0.02627072f, -0.14357094f, 0.04254373f, 0.21479620f, 0.04552994f, -0.04510395f, -0.08685309f, 
    0.11478721f, 0.19710076f, 0.23183411f, -0.06517278f, -0.28787392f, -0.08470814f, 0.08475801f, 0.06388750f, 
    0.03682127f, 0.01499811f, 0.21779162f, 0.16061033f, 0.10149722f, 0.13701464f, 0.06610560f, 0.01787845f, 
    0.17106777f, 0.18723679f, 0.07519725f, 0.27859139f, 0.29587770f, 0.14663373f, -0.04049075f, -0.03510141f, 
    0.04121145f, -0.00640664f, -0.08030184f, -0.03431772f, 0.26147231f, 0.22596842f, 0.01760720f, 0.00470350f, 
    0.13545257f, 0.00652380f, 0.02261079f, -0.01003768f, 0.12129893f, -0.10731585f, 0.00518691f, -0.10683912f, 
    -0.07201505f, -0.12440538f, 0.11432169f, 0.06871130f, 0.07299832f, 0.07130578f, -0.02490051f, -0.01766559f, 
    -0.04291480f, -0.11557474f, 0.13592051f, -0.01061678f, -0.18393603f, 0.06894296f, -0.23409203f, -0.02753474f, 
    0.08504866f, 0.00946321f, 0.13679892f, -0.01529421f, 0.04582182f, -0.23496549f, 0.14915109f, -0.01343130f, 
    -0.14505060f, -0.14140199f, -0.04252353f, -0.35885260f, 0.08711269f, -0.01057987f, 0.08123116f, 0.20277023f, 
    0.03466729f, -0.00636355f, 0.07214807f, 0.13964887f, -0.30854365f, 0.05372958f, -0.25230476f, 0.17012002f, 
    0.10227132f, -0.06465075f, 0.00402543f, -0.05876025f, 0.04748319f, -0.06232615f, 0.04452495f, 0.10288465f, 
    0.14122342f, -0.35423532f, -0.12379695f, 0.27913302f, -0.15099221f, 0.02246021f, 0.10979523f, 0.04547485f, 
    -0.07360049f, 0.10839022f, 0.09366596f, 0.15758903f, 0.22610030f, 0.37718284f, 0.27121037f, 0.07156820f, 
    0.01314129f, 0.15348861f, -0.01816089f, 0.06859045f, 0.09865355f, -0.01591357f, -0.02022702f, 0.09365795f, 
    -0.17145877f, -0.23424126f, -0.00821214f, 0.13126124f, -0.11004021f, 0.21643656f, 0.03648170f, 0.13256545f, 
    -0.03300918f, -0.00367884f, -0.05897714f, -0.00428405f, 0.18909973f, 0.16753021f, 0.15154424f, -0.24540539f, 
    0.04752006f, 0.08014745f, 0.09522367f, 0.12739745f, 0.01002961f, -0.04972046f, -0.09456954f, 0.08578112f, 
    0.13903262f, 0.04442352f, 0.15146902f, -0.16550630f, -0.04405572f, 0.02815626f, -0.03069444f, -0.02316044f, 
    -0.05340787f, 0.00789460f, 0.08396087f, -0.00950501f, -0.22264449f, -0.10957836f, 0.02783474f, 0.03980054f, 
    -0.09258899f, 0.02888256f, -0.08044802f, 0.13023904f, -0.02901431f, -0.03617861f, -0.12712242f, 0.04088556f, 
    0.29141161f, -0.10500135f, -0.24377117f, -0.10492104f, 0.00919107f, -0.03183738f, 0.03666257f, 0.05724035f, 
    -0.04704075f, 0.06647706f, 0.09222157f, 0.15919736f, 0.03903354f, -0.25055379f, -0.14247650f, 0.01640033f, 
    -0.02574260f, 0.05814340f, 0.06660995f, 0.05225666f, 0.07586563f, 0.11904974f, -0.10819999f, -0.03024506f, 
    -0.42766425f, -0.26982725f, -0.05167997f, -0.17811009f, 0.07407379f, 0.08392964f, 0.13680574f, 0.11908273f, 
    -0.00699328f, -0.17424370f, -0.06590287f, -0.04750504f, 0.65651643f, 0.06641971f, 0.16031756f, 0.05604655f, 
    0.12786244f, 0.00392325f, -0.20580232f, -0.06941085f, -0.07769345f, 0.07013931f, 0.05112273f, 0.05353345f, 
    0.19949532f, -0.06599220f, -0.28162807f, -0.25320074f, -0.05129640f, -0.02029939f, 0.01195069f, 0.00322188f, 
    -0.03481975f, 0.11218210f, -0.04709619f, 0.02904032f, -0.21456018f, 0.06766225f, 0.22758077f, 0.04984562f, 
    0.04386364f, -0.01723529f, 0.01156897f, 0.03768895f, 0.06356442f, 0.19724230f, 0.07682228f, 0.03800946f, 
    0.10455149f, 0.39234784f, 0.14066890f, -0.06346738f, -0.13881290f, 0.03827850f, 0.20450696f, -0.01920344f, 
    0.04189898f, 0.06799301f, 0.00946755f, 0.07307009f, -0.00175540f, -0.14132985f, -0.00545997f, -0.05881311f, 
    -0.14710358f, 0.02885727f, -0.19996268f, 0.04259340f, 0.05413043f, 0.11871286f, 0.02178168f, 0.03201378f, 
    0.01168069f, 0.20989655f, -0.07979823f, 0.12918657f, -0.03452574f, -0.08947921f, -0.09833840f, 0.03852740f, 
    -0.01083203f, 0.06781831f, 0.03260765f, -0.09371062f, 0.21360700f, 0.05653702f, 0.04030993f, -0.13102572f, 
    0.01172541f, 0.02466168f, 0.05702731f, 0.16073626f, 0.07475244f, 0.05298048f, 0.00635906f, 0.02736500f, 
    -0.65555817f, -0.24500675f, 0.08969927f, -0.25379500f, 0.07054932f, -0.03459610f, -0.06787727f, -0.04542024f, 
    0.01432971f, -0.01934417f, 0.13682494f, -0.06366988f, -0.05625592f, 0.10460144f, -0.06445209f, 0.08519848f, 
    0.10807303f, -0.07193501f, 0.02335997f, 0.00848669f, 0.06301971f, -0.01723804f, 0.09724947f, 0.08892488f, 
    0.08451041f, 0.00988462f, 0.17125890f, -0.21828116f, 0.02877733f, -0.08221958f, -0.03556819f, 0.07615213f, 
    0.12201446f, -0.02611878f, 0.09230760f, -0.05576501f, 0.02665562f, 0.14102429f, -0.09262510f, 0.21511255f, 
    -0.04091274f, -0.09398470f, 0.06230932f, 0.03380157f, 0.10470202f, -0.08006455f, 0.00286231f, 0.25231645f, 
    -0.03409503f, 0.49194548f, -0.03158674f, -0.11142416f, 0.05866898f, 0.16806866f, 0.05197340f, -0.10153591f, 
    -0.04069861f, 0.16635805f, -0.07974230f, 0.08465272f, 0.08921902f, 0.02856614f, 0.07947724f, -0.38610801f, 
    0.04277942f, 0.07107601f, -0.00088209f, -0.05623303f, 0.00941416f, 0.04342828f, 0.10068175f, 0.17603542f, 
    -0.16252612f, 0.07059270f, 0.23770554f, 0.31068781f, -0.06643914f, 0.15040185f, 0.00442090f, -0.13382557f, 
    0.01670656f, 0.12204839f, -0.06029566f, 0.06060362f, -0.03233125f, 0.00165818f, -0.15577254f, 0.01079375f, 
    -0.09261123f, -0.08081360f, -0.10973168f, 0.05723359f, 0.10703491f, -0.09739974f, -0.01475574f, 0.13581699f, 
    -0.15819021f, 0.01391056f, -0.02360353f, 0.39903155f, -0.01794596f, 0.24611144f, -0.07263418f, -0.04627229f, 
    -0.18024382f, 0.18831766f, 0.16954727f, 0.16030802f, -0.10459453f, 0.25134099f, 0.15386780f, -0.31541157f, 
    0.21591426f, -0.15698944f, 0.06664688f, -0.01782757f, 0.04005604f, -0.03817886f, -0.00224040f, -0.06530645f, 
    0.11695398f, -0.10821228f, 0.01472898f, 0.04842484f, -0.12030634f, 0.00363850f, -0.06570831f, -0.02854724f, 
    0.04853383f, -0.02579193f, 0.12520114f, -0.05611745f, 0.14721785f, 0.29392251f, -0.03268553f, 0.31893912f, 
    0.08338853f, 0.06061008f, -0.08726133f, -0.18613024f, -0.09655242f, -0.21022853f, 0.02420098f, -0.04804783f, 
    0.45671141f, 0.25001174f, -0.00585838f, -0.37088117f, -0.03175106f, 0.03741391f, 0.00773470f, -0.15980642f, 
    0.13730530f, 0.17271855f, -0.10646176f, 0.00327029f, -0.57594442f, -0.03560938f, 0.13761225f, -0.03955050f, 
    0.01306692f, -0.02024556f, 0.04608366f, 0.03666821f, 0.00155428f, 0.06654903f, -0.15438128f, 0.18425184f, 
    0.09929693f, 0.14634392f, 0.01233824f, 0.03729813f, 0.04424332f, -0.17810629f, -0.02175833f, -0.00492326f, 
    0.06388036f, -0.10516408f, 0.17989980f, 0.06199412f, -0.21576452f, -0.07367375f, 0.14554878f, -0.07769662f, 
    0.16444969f, 0.11845893f, 0.02479025f, 0.05249907f, -0.10581725f, -0.10706466f, 0.06693806f, 0.01901567f, 
    0.24511679f, 0.20283382f, 0.05551748f, 0.06839549f, 0.10256685f, -0.01658010f, -0.11201478f, 0.07757132f, 
    -0.03891622f, 0.02604428f, -0.02368599f, 0.03822041f, 0.30927086f, -0.19781747f, -0.07859027f, 0.20479190f, 
    0.09719490f, 0.00799062f, -0.06729649f, -0.19863255f, 0.03022096f, -0.04154626f, 0.04698974f, -0.03917371f, 
    0.24202809f, 0.18589099f, 0.08143100f, -0.25102979f, 0.14259881f, -0.10572053f, 0.05737433f, -0.03849371f, 
    0.07206294f, -0.01713730f, 0.05932615f, 0.08541904f, -0.07248309f, -0.06075814f, -0.01892038f, 0.38388771f, 
    0.21811783f, -0.07254352f, -0.07434183f, -0.09809329f, 0.03728861f, 0.05700516f, 0.04044769f, 0.04998125f, 
    0.06443898f, -0.05160367f, -0.00470317f, 0.06127783f, 0.05335961f, -0.03556772f, -0.10551494f, -0.00564226f, 
    -0.03378118f, -0.08653942f, -0.13677932f, -0.09408608f, -0.17047364f, -0.11842238f, -0.04293872f, 0.01664984f, 
    -0.07595924f, -0.27641797f, -0.02048316f, -0.12195881f, 0.04150337f, -0.22868109f, -0.04189131f, -0.05141390f, 
    0.40876332f, 0.00180147f, 0.32752341f, -0.11410598f, -0.05453735f, -0.01323432f, 0.05001295f, 0.03588707f, 
    -0.02405529f, -0.05285446f, 0.11548699f, 0.14614540f, -0.02740233f, 0.07761215f, 0.08936390f, -0.00681189f, 
    0.02578221f, 0.13778999f, 0.10675796f, 0.10533683f, 0.12401451f, 0.08833908f, 0.04088235f, 0.03225819f, 
    -0.03015871f, -0.00147117f, 0.10917336f, -0.06537591f, -0.08370561f, -0.13803138f, 0.07536515f, -0.05961614f, 
    0.05416592f, -0.10005204f, -0.05340272f, 0.21542023f, -0.13230009f, -0.07734480f, 0.08921542f, 0.13290104f, 
    -0.09525781f, 0.03157143f, -0.04008940f, 0.06580999f, 0.11251181f, -0.13370472f, 0.09485665f, 0.05073909f, 
    -0.24336697f, 0.27013233f, 0.15009356f, -0.20835914f, 0.00881597f, 0.03073777f, -0.01522906f, 0.04041398f, 
    -0.15832910f, -0.09210035f, 0.07207888f, 0.07243638f, 0.42344892f, -0.29402649f, 0.01528788f, 0.29274681f, 
    -0.08592518f, 0.00416360f, -0.02808565f, 0.00795689f, 0.06698683f, 0.11395879f, -0.00042591f, 0.03075594f, 
    -0.23892650f, -0.06470774f, -0.09636605f, 0.05843485f, -0.15423563f, 0.07158423f, -0.02726874f, 0.15140872f, 
    -0.07145227f, 0.08438874f, -0.00273706f, -0.04403555f, -0.01282807f, 0.09287786f, -0.03670681f, 0.07991970f, 
    0.04607021f, -0.19703290f, 0.06557584f, -0.08374704f, 0.11179138f, -0.09322648f, -0.08107913f, 0.12692541f, 
    -0.44769174f, -0.19657360f, 0.15728529f, 0.28533882f, 0.07624455f, 0.13779691f, 0.10499299f, -0.01828768f, 
    0.02020686f, 0.11185167f, 0.00611695f, -0.06290439f, 0.13229179f, -0.01732716f, 0.07312921f, -0.25925907f, 
    -0.19466740f, -0.03905799f, 0.00762109f, 0.18878543f, 0.06702296f, 0.00705846f, 0.00514602f, -0.03332394f, 
    0.36474940f, 0.22657198f, 0.11833508f, -0.19505805f, 0.08935266f, 0.00000061f, 0.00697625f, -0.01154490f, 
    0.10023487f, 0.10807168f, 0.01847336f, 0.03774263f, 0.30615917f, -0.43059090f, 0.01958668f, 0.31075254f, 
    -0.12533152f, -0.17901899f, 0.09835258f, -0.01871433f, 0.01791148f, 0.03106559f, 0.03673830f, -0.05835592f, 
    0.45404521f, 0.28421491f, -0.24211106f, -0.21937393f, 0.03774858f, 0.01413563f, -0.04181426f, 0.00725865f, 
    -0.07058129f, -0.03921919f, -0.07294670f, 0.07662550f, 0.25633028f, -0.14084145f, 0.19732070f, 0.32604134f, 
    -0.01429329f, 0.09828937f, 0.03078945f, 0.10154169f, -0.00887490f, 0.02267954f, 0.01365939f, -0.10899137f, 
    -0.25331116f, -0.04947189f, -0.16012944f, 0.23785040f, 0.14959009f, 0.00983745f, 0.04256622f, 0.12662897f, 
    0.10538514f, -0.11095614f, -0.02138693f, 0.08470485f, 0.10366252f, 0.25723097f, 0.15326644f, 0.07985230f, 
    0.19007491f, 0.16785824f, 0.00658914f, 0.10650238f, 0.01364983f, 0.08937849f, 0.08274595f, 0.03561138f, 
    -0.15399629f, 0.17849103f, -0.10456743f, -0.05987956f, -0.14504772f, -0.02468681f, 0.08067091f, 0.04434065f, 
    -0.01541797f, -0.03048189f, 0.03913877f, -0.08014865f, -0.38292867f, 0.13108993f, 0.01616758f, -0.20718114f, 
    0.01528583f, 0.03749067f, -0.12915373f, 0.14503561f, 0.13018727f, -0.01237760f, 0.10284963f, -0.02099308f, 
    0.02917670f, -0.28574836f, -0.02960894f, 0.29309151f, 0.07497144f, 0.14200406f, 0.03394429f, 0.12147396f, 
    0.00954837f, -0.20769052f, -0.00619544f, 0.05371029f, -0.06334739f, 0.42089888f, -0.00271171f, 0.02129953f, 
    0.02618074f, -0.00331418f, -0.08532567f, 0.03437490f, -0.08492963f, -0.05367121f, 0.15739655f, -0.13001141f, 
    0.23967257f, -0.01986136f, -0.11741029f, -0.01016142f, 0.07543656f, 0.05364474f, -0.10164838f, 0.07154889f, 
    -0.08446691f, 0.09823848f, 0.02164291f, 0.15946773f, -0.19765413f, -0.23532540f, 0.04195870f, -0.13047926f, 
    0.04437575f, -0.00548554f, 0.18763828f, 0.09966855f, 0.18480381f, -0.10659025f, 0.11636891f, 0.01148107f, 
    -0.03465747f, 0.00379043f, 0.28177637f, -0.08743817f, -0.00964436f, 0.00801981f, 0.03099201f, 0.08233152f, 
    0.11231413f, 0.08923207f, 0.11728235f, 0.03905058f, 0.26728353f, -0.00645252f, -0.24456388f, -0.04933668f, 
    -0.01141756f, 0.05250997f, 0.04214688f, 0.11227285f, -0.06253569f, -0.02496189f, 0.06222118f, 0.08601207f, 
    -0.46953896f, 0.33254007f, -0.11888493f, 0.08817381f, 0.08033495f, -0.19837581f, -0.06696481f, 0.08353445f, 
    -0.01479840f, 0.27285135f, 0.01131042f, 0.02548863f, -0.00735385f, -0.01897731f, -0.06029729f, 0.29376984f, 
    0.09314601f, -0.09188972f, -0.02301249f, 0.02697993f, 0.05992572f, -0.03034735f, -0.04044106f, 0.07281060f, 
    -0.02386643f, -0.06662926f, -0.00593419f, -0.09169445f, -0.06969592f, 0.08899786f, 0.16828264f, -0.06897875f, 
    0.05309736f, 0.17629366f, -0.06826936f, 0.14863859f, -0.01171243f, -0.19978580f, 0.22527909f, 0.15171833f, 
    0.07238091f, 0.00235969f, 0.06982142f, -0.03432306f, -0.01054420f, 0.06151525f, -0.11462151f, 0.18238081f, 
    -0.23949863f, 0.02864370f, 0.05913045f, -0.17527449f, 0.09295615f, -0.03019390f, 0.04326121f, 0.06062030f, 
    0.07892688f, 0.00126297f, 0.17995606f, -0.22430819f, -0.07725128f, 0.09789208f, 0.04280828f, -0.12435728f, 
    0.14960860f, -0.14980461f, -0.07223994f, -0.02906310f, -0.01413768f, -0.11205413f, -0.14051165f, 0.11741640f, 
    -0.44338691f, 0.31413561f, 0.22012699f, -0.12030478f, 0.03195198f, 0.08870810f, 0.06598653f, -0.07089172f, 
    -0.00483056f, 0.02398997f, -0.08224409f, -0.00491066f, -0.04283664f, -0.07125616f, 0.23285295f, -0.08717790f, 
    0.00563338f, 0.18706955f, 0.10544040f, 0.11477090f, -0.06294754f, 0.07244769f, 0.14732192f, 0.18322290f, 
    0.28434727f, 0.25179154f, -0.23112907f, -0.29813167f, 0.01567008f, -0.06210355f, 0.00553448f, -0.00731599f, 
    0.03635683f, -0.03733687f, -0.21100833f, -0.13395035f, 0.01264904f, -0.17936938f, -0.17879924f, -0.06947906f, 
    -0.00570875f, -0.09056852f, -0.12828976f, 0.08600900f, -0.03795358f, -0.03395553f, 0.01832857f, 0.11046760f, 
    0.01048084f, -0.06545758f, -0.06863697f, -0.05420157f, 0.04709022f, -0.03135668f, 0.03777567f, -0.07021490f, 
    -0.00024574f, -0.02646268f, 0.01369024f, -0.00251231f, -0.00010062f, 0.05628817f, 0.01475210f, -0.04637659f, 
    0.01466310f, -0.07272993f, 0.05568461f, -0.03512560f, -0.01394250f, -0.04603814f, 0.05663690f, 0.05591456f, 
    -0.05103144f, 0.02098031f, -0.01544517f, 0.03798584f, -0.06531958f, -0.07517668f, 0.05148329f, -0.03202969f, 
    0.04181810f, 0.06069997f, -0.07302169f, -0.05030163f, 0.05805903f, -0.02649334f, -0.07273931f, -0.07390613f, 
    -0.00885225f, -0.04853514f, -0.04975075f, 0.03132274f, 0.00090861f, -0.00636762f, -0.01864394f, 0.03039928f, 
    0.00128802f, 0.04027506f, 0.01845776f, 0.05469764f, 0.05233214f, -0.00143956f, -0.03454125f, 0.02865894f, 
    0.01004812f, 0.00082498f, 0.05294042f, 0.02923390f, 0.02810803f, 0.01108355f, -0.01259645f, 0.01491174f, 
    -0.00657243f, -0.00732661f, 0.02939024f, -0.05702736f, -0.02709697f, 0.02935140f, -0.04915248f, -0.07499355f, 
    -0.05174146f, 0.04207559f, 0.00234424f, 0.00887912f, -0.05186594f, -0.06944732f, 0.05468170f, -0.02017590f, 
    0.05244529f, -0.01281219f, 0.01040635f, -0.03146163f, -0.07058989f, -0.04934955f, -0.04057544f, -0.06666800f, 
    -0.07219518f, -0.04314501f, -0.06780668f, 0.06239432f, 0.01273860f, -0.05819108f, -0.02154589f, 0.02438247f, 
    0.03703394f, -0.04676172f, 0.04531085f, -0.04332267f, -0.07693285f, -0.06552574f, -0.01980370f, -0.04505316f, 
    0.02808560f, -0.02043371f, -0.05807846f, -0.04794929f, 0.04157839f, 0.00040374f, 0.06049590f, 0.01597240f, 
    -0.05853314f, 0.00774166f, 0.01408085f, 0.02548943f, -0.07780927f, 0.00101719f, -0.01959276f, -0.05303112f, 
    -0.03189958f, 0.00761470f, -0.00762460f, -0.00275498f, 0.03715145f, 0.01594539f, 0.04613633f, -0.00699151f, 
    -0.03626368f, 0.01786265f, -0.01576119f, 0.05979121f, 0.05273506f, 0.01421446f, -0.00464685f, -0.01150340f, 
    0.01687844f, 0.01336025f, 0.02643123f, -0.02394493f, -0.03273556f, 0.01820362f, -0.02950549f, -0.02117275f, 
    -0.03987302f, -0.06903980f, 0.02864717f, 0.00874341f, -0.06411265f, 0.00504240f, -0.05294449f, 0.06350853f, 
    -0.02502187f, 0.02336267f, -0.05725899f, 0.03909913f, -0.07711434f, -0.01064693f, -0.04892532f, -0.07558292f, 
    0.00083120f, 0.04540074f, 0.01904801f, -0.05157473f, 0.01236802f, 0.06093715f, -0.05474861f, 0.01529158f, 
    -0.03610940f, 0.00473668f, -0.01329585f, -0.03949302f, 0.02114364f, -0.03465248f, 0.05617732f, -0.01393144f, 
    0.01006061f, -0.07638621f, -0.00646526f, 0.03960689f, 0.03661204f, -0.01782216f, 0.06274286f, -0.01080300f, 
    -0.00112952f, -0.03295890f, 0.00544490f, -0.03621646f, 0.06261156f, -0.07771253f, -0.02903271f, -0.03434068f, 
    -0.08575731f, -0.01632611f, -0.00743530f, -0.10821731f, -0.06121844f, -0.04946304f, -0.13589163f, -0.04028229f, 
    -0.07489110f, 0.01658613f, -0.08672495f, 0.04570653f, 0.26574945f, 0.35102257f, 0.17236121f, 0.28498614f, 
    -0.04864981f, -0.12517002f, -0.10294655f, 0.00463588f, -0.01059012f, 0.04185598f, 0.08493031f, -0.07811425f, 
    -0.00508008f, 0.18294083f, -0.12963749f, 0.10407203f, 0.12010029f, 0.04980756f, -0.02387788f, -0.01739862f, 
    -0.07698061f, 0.13265590f, -0.01292615f, -0.00930150f, 0.04262171f, -0.06944638f, 0.18578476f, 0.09019257f, 
    0.00463088f, -0.01649058f, -0.01521847f, 0.05172473f, -0.02447568f, 0.04136152f, 0.02197017f, -0.09106119f, 
    0.20122498f, 0.29452103f, 0.06610550f, -0.26946664f, 0.08125467f, 0.17618218f, -0.02759863f, -0.00547068f, 
    -0.10246523f, 0.01761433f, 0.06972749f, -0.03699673f, 0.33138639f, 0.03614426f, -0.21527880f, -0.12704888f, 
    -0.22903983f, 0.10565746f, -0.06889540f, 0.04943411f, 0.02263581f, -0.00608287f, -0.13403355f, 0.11698833f, 
    -0.13765565f, 0.19911997f, 0.08651096f, 0.15261088f, 0.00145461f, 0.02783217f, 0.12116367f, 0.14067473f, 
    -0.02901855f, 0.09884306f, -0.02936514f, -0.17760701f, 0.20379181f, 0.14572732f, 0.20262845f, -0.05702614f, 
    -0.15187304f, -0.20389117f, -0.09549922f, 0.13412696f, -0.00884424f, -0.04192070f, 0.00817562f, 0.00850057f, 
    -0.26001790f, -0.20341679f, -0.20786899f, -0.80985421f, -0.03053176f, -0.15649499f, 0.02891069f, 0.10551383f, 
    -0.04835072f, -0.04853418f, 0.17890833f, 0.01573785f, 0.15611014f, 0.03506816f, 0.12485763f, 0.63679880f, 
    0.03428354f, -0.00612191f, 0.05814422f, 0.13917366f, 0.00721534f, 0.09946462f, 0.00285901f, 0.02569578f, 
    0.04730866f, 0.24268295f, 0.00262698f, -0.19068688f, 0.10556193f, -0.03680610f, 0.01882536f, 0.09408604f, 
    0.10918623f, -0.08774324f, 0.10535862f, -0.03790281f, 0.22278529f, -0.07488325f, -0.00890190f, 0.38106832f, 
    -0.00577255f, 0.01552963f, -0.05356596f, 0.05899493f, -0.14199005f, -0.06606507f, -0.03310116f, -0.04574881f, 
    -0.25673953f, 0.09425696f, 0.03836653f, -0.28343835f, 0.14371711f, -0.03406000f, 0.13661562f, 0.00423772f, 
    -0.03302121f, -0.06939979f, -0.04480701f, -0.05250947f, -0.30703935f, -0.36717120f, 0.04638403f, -0.31553274f, 
    0.09507105f, 0.14302532f, 0.04678942f, 0.12059133f, 0.19722621f, -0.06912547f, 0.18070361f, -0.01157602f, 
    0.48273709f, 0.29464042f, -0.21606718f, -0.12821552f, -0.20706588f, -0.01773524f, 0.02767179f, -0.07005914f, 
    -0.05320161f, -0.07514988f, 0.06107473f, -0.16126697f, -0.22611140f, -0.08339508f, -0.00254500f, -0.24734639f, 
    0.04026927f, -0.05486060f, -0.02196860f, 0.03472265f, -0.00755731f, 0.01772296f, 0.08036355f, 0.13821276f, 
    0.34640399f, -0.13295686f, 0.05630509f, 0.11332311f, 0.16857637f, 0.21572854f, 0.06262689f, -0.05378371f, 
    -0.05227280f, -0.04137168f, 0.04984263f, 0.00708907f, -0.53234291f, 0.32222217f, 0.04583197f, -0.19875149f, 
    -0.01250504f, -0.01208729f, -0.01343695f, 0.04817405f, -0.05963930f, 0.00977846f, 0.02716807f, -0.19061868f, 
    0.08184461f, -0.03623218f, 0.08355390f, 0.09543668f, -0.10570540f, -0.09328113f, 0.02194842f, 0.05572677f, 
    -0.10043228f, 0.10042331f, 0.21552941f, 0.14926963f, -0.09515552f, -0.22497071f, -0.00352255f, -0.01832421f, 
    -0.07623818f, -0.01457578f, 0.05398643f, 0.11805392f, 0.05300844f, 0.01663618f, 0.16872720f, 0.10002574f, 
    0.08613869f, -0.19810024f, 0.04529490f, -0.04909070f, -0.01389687f, 0.00140075f, -0.09758099f, 0.00241528f, 
    0.16552335f, 0.13291956f, 0.01367405f, -0.03213980f, -0.52479118f, 0.11474548f, -0.00483819f, -0.02712127f, 
    0.13794740f, 0.03955214f, 0.00427656f, 0.09219377f, -0.04244697f, 0.10934588f, -0.18209957f, 0.17448127f, 
    -0.12431914f, 0.07033464f, -0.18667096f, 0.15540166f, -0.02012111f, -0.11056191f, 0.02876328f, -0.24928312f, 
    0.10994234f, 0.09679120f, 0.05495508f, -0.11034342f, -0.02413065f, 0.00563847f, -0.03019590f, 0.02730006f, 
    0.28929684f, 0.20417395f, 0.07795568f, -0.01573372f, 0.06988940f, 0.01541802f, 0.01702031f, -0.10996747f, 
    0.24531592f, 0.23854910f, 0.38403565f, 0.33998838f, 0.15878490f, -0.08638223f, 0.03340629f, 0.04837510f, 
    0.03771389f, -0.03116942f, -0.26331377f, 0.10738320f, 0.04005856f, -0.36746949f, 0.06389605f, 0.05756230f, 
    -0.02910896f, -0.06934508f, 0.02871383f, -0.02147970f, 0.05493253f, -0.06828325f, -0.16958694f, -0.03292211f, 
    -0.11342222f, 0.02470296f, -0.05536143f, 0.05845712f, -0.10002313f, -0.06297517f, 0.14957027f, -0.01894694f, 
    0.02616278f, -0.12028233f, 0.16155392f, -0.01386433f, -0.12591879f, 0.06447138f, 0.00607083f, -0.02261862f, 
    0.06505841f, -0.02851489f, -0.06106803f, -0.05038640f, 0.17901666f, 0.02626238f, 0.07153473f, 0.08531057f, 
    -0.27939191f, 0.00843314f, 0.09504564f, 0.26523539f, -0.14038502f, -0.14918379f, 0.12139706f, -0.03750422f, 
    0.04928921f, -0.00389705f, -0.00386164f, 0.07185181f, -0.05206358f, -0.03978889f, 0.16374297f, 0.30445275f, 
    -0.06204299f, -0.01992245f, 0.07807466f, 0.04970272f, -0.03027054f, 0.01388842f, 0.07954731f, 0.29435709f, 
    -0.02651211f, 0.21450216f, 0.15265240f, -0.06593389f, 0.09499656f, -0.07598390f, -0.10152768f, -0.04035109f, 
    0.01776561f, -0.14543101f, -0.23909520f, -0.08972368f, 0.08535916f, 0.07122136f, 0.18663611f, -0.09598545f, 
    0.06334683f, 0.20599394f, -0.16801183f, 0.04574436f, 0.12768565f, 0.12941743f, -0.03063185f, 0.09809598f, 
    0.35616750f, 0.30442777f, 0.17344253f, 0.08093975f, 0.17945234f, 0.28518122f, -0.01528698f, -0.02711951f, 
    -0.02017044f, -0.04909404f, -0.04019890f, -0.19637839f, -0.42322603f, 0.10643516f, -0.26864055f, -0.11200190f, 
    -0.01394010f, 0.00207002f, 0.06529774f, -0.03784644f, -0.09023517f, 0.13399786f, -0.11501309f, -0.09622065f, 
    0.08752714f, -0.31445843f, -0.10113639f, 0.19603461f, -0.08064742f, -0.04698328f, -0.05152741f, 0.09602484f, 
    -0.03006800f, 0.04965059f, -0.06580947f, -0.02626636f, -0.44143802f, -0.01640308f, -0.01450652f, -0.28914523f, 
    0.05589058f, -0.24061471f, 0.08264351f, -0.02861842f, 0.08364209f, 0.10073799f, 0.00867384f, -0.01959193f, 
    0.18136689f, -0.05979430f, 0.02409899f, -0.09094682f, -0.00708693f, -0.12029719f, -0.09338595f, 0.05482970f, 
    0.19028343f, 0.07302294f, 0.10741338f, -0.08317888f, 0.09651832f, -0.00744850f, 0.25677601f, 0.11334170f, 
    0.09081721f, 0.29535753f, 0.02465245f, 0.04230053f, -0.01730067f, 0.01250520f, 0.03519107f, 0.04219507f, 
    0.36530095f, 0.02247436f, -0.11898297f, -0.04967583f, 0.10545348f, -0.00493989f, -0.02071627f, -0.04309006f, 
    -0.20392093f, -0.06509186f, -0.04482165f, -0.00733684f, 0.11147847f, 0.21898393f, 0.27217767f, 0.32081810f, 
    0.14151086f, 0.17432402f, 0.00992818f, -0.04084539f, 0.01687062f, 0.05673855f, 0.00789750f, -0.11202420f, 
    0.07973690f, 0.02508677f, 0.24474333f, 0.26184228f, -0.01082198f, 0.10428233f, -0.08364825f, -0.06503459f, 
    -0.05737363f, -0.12552692f, -0.02515658f, 0.00656430f, -0.32984796f, -0.07593813f, -0.15950671f, -0.38711926f, 
    0.08242659f, -0.03047694f, -0.02344401f, 0.00056987f, 0.08495758f, -0.20024078f, -0.06199037f, -0.01869626f, 
    -0.39313334f, -0.17641565f, -0.00312662f, 0.33139265f, 0.07764751f, 0.07507746f, 0.11934529f, -0.00213648f, 
    -0.12127054f, 0.11078347f, 0.12684816f, -0.09744083f, -0.19616213f, -0.02329137f, -0.28241652f, -0.30238599f, 
    0.05611795f, -0.13054830f, -0.10504375f, -0.03987565f, -0.00932516f, -0.00648813f, -0.04217390f, 0.02767016f, 
    0.23806804f, -0.10785214f, 0.05300980f, -0.18541434f, -0.03493778f, -0.05122571f, -0.01548422f, -0.07736366f, 
    -0.04380066f, 0.08626787f, 0.07125830f, 0.03063170f, 0.35678643f, 0.20715140f, -0.05802352f, -0.03464267f, 
    0.04050744f, -0.15495737f, -0.01006853f, 0.00627178f, 0.02728919f, -0.03030001f, -0.00303836f, 0.02473074f, 
    -0.16630746f, 0.12024096f, 0.01819991f, 0.07552354f, 0.07698202f, 0.09286615f, -0.20113081f, -0.00661139f, 
    0.08111327f, -0.10732464f, -0.11083218f, 0.03665857f, 0.31450707f, 0.13317961f, 0.26166260f, 0.08241985f, 
    -0.01598849f, 0.15860897f, 0.09632128f, -0.09878618f, 0.01511104f, -0.05318068f, -0.03304429f, -0.09605684f, 
    0.13815986f, -0.11256120f, -0.23416476f, 0.18795666f, 0.09714770f, 0.19351517f, -0.11305496f, -0.04728098f, 
    0.03100767f, 0.01941778f, 0.12331911f, 0.03778429f, -0.51596570f, 0.18520279f, 0.01514294f, -0.12013844f, 
    -0.00021179f, -0.06032705f, 0.06468416f, 0.05349926f, 0.04435434f, -0.06848653f, 0.02099067f, -0.15545002f, 
    0.25273684f, -0.15378313f, 0.13304123f, 0.39325693f, 0.23179699f, 0.10901954f, 0.02200622f, -0.04806177f, 
    0.00945762f, 0.01483817f, 0.20228060f, 0.02071895f, 0.04712199f, 0.13436045f, -0.06402808f, 0.00512571f, 
    0.22363415f, 0.02085980f, 0.14440741f, 0.06283791f, 0.12923519f, -0.13974681f, 0.08879143f, 0.04283955f, 
    0.31269276f, -0.02190029f, 0.09298558f, -0.09299776f, 0.02865512f, -0.03508281f, -0.06871115f, 0.09354303f, 
    0.18226868f, -0.14426641f, 0.06865457f, 0.04642056f, -0.60944760f, 0.04129942f, 0.02441000f, -0.12158783f, 
    0.03265241f, -0.05212155f, 0.12046411f, 0.05907680f, 0.00608719f, 0.02541867f, 0.00176565f, -0.03356223f, 
    -0.13665308f, 0.08743138f, -0.04206542f, -0.28602424f, 0.04799781f, -0.16652119f, 0.04237960f, -0.07526758f, 
    -0.04722719f, -0.06951957f, 0.09252320f, 0.01438468f, -0.37937966f, -0.02133639f, -0.03960383f, 0.27933422f, 
    0.07991391f, -0.00939153f, -0.09825739f, -0.13166118f, 0.04505109f, -0.07517320f, 0.08645754f, -0.04286078f, 
    0.40488899f, -0.13498689f, -0.02974645f, 0.33328849f, -0.04431206f, 0.05222705f, 0.10250006f, 0.09391817f, 
    0.07108652f, 0.06241850f, -0.04158301f, 0.18308622f, 0.13686207f, -0.01314350f, 0.04918568f, 0.07590142f, 
    0.11342140f, 0.09955243f, 0.05571260f, 0.01915278f, 0.15255527f, -0.03212783f, -0.07736500f, 0.04268922f, 
    -0.24280864f, -0.12061443f, -0.12120497f, 0.16586141f, -0.02695625f, 0.03936989f, 0.07895351f, -0.02068358f, 
    -0.01625646f, -0.03088312f, 0.16272500f, 0.00546196f, -0.06665914f, 0.01457929f, 0.11526067f, -0.00374638f, 
    0.15626138f, 0.07591094f, 0.06343745f, 0.02256893f, 0.17601171f, 0.02050289f, 0.03593426f, 0.06408183f, 
    0.06447195f, -0.15667792f, 0.12032977f, 0.08418849f, -0.07283390f, -0.04262979f, -0.08747849f, 0.05302973f, 
    -0.03458158f, -0.04979229f, 0.09979587f, -0.02966406f, -0.24399684f, -0.14825840f, -0.07287540f, 0.26599303f, 
    -0.08463527f, -0.14132759f, 0.07317825f, 0.03175872f, -0.03155188f, -0.05624388f, -0.01123497f, 0.10061126f, 
    0.04616457f, 0.02310112f, 0.01193248f, -0.24462011f, 0.06671238f, -0.03578206f, 0.04047933f, 0.04693135f, 
    -0.01367561f, 0.09097042f, -0.04465955f, 0.08948499f, -0.11954298f, -0.05765997f, 0.01823543f, -0.03010019f, 
    -0.08856395f, 0.08057638f, 0.03907755f, -0.03178164f, 0.01947229f, 0.06636293f, -0.00092482f, 0.06949659f, 
    0.35901624f, 0.20836046f, 0.00141685f, 0.25197011f, -0.11663174f, -0.03587658f, 0.00602639f, 0.20695348f, 
    -0.02981503f, 0.11599586f, 0.01128256f, -0.01915109f, -0.54914922f, 0.35675091f, 0.07640737f, -0.13745065f, 
    0.00917749f, 0.06138155f, 0.02512097f, 0.16498999f, 0.01664183f, 0.12898813f, 0.05879979f, -0.03594659f, 
    0.02143925f, 0.08205327f, 0.27972689f, -0.06207778f, -0.00947969f, 0.16650729f, 0.22608209f, 0.06149225f, 
    0.09115929f, -0.00746417f, -0.03083306f, 0.00079763f, 0.35000759f, 0.24172316f, -0.16539592f, 0.11301953f, 
    0.04855685f, 0.07456272f, -0.12080291f, -0.03347462f, -0.13665128f, -0.14518328f, -0.14299077f, 0.12942155f, 
    0.20463820f, -0.35797948f, 0.02746970f, -0.26134178f, 0.07491527f, 0.05903896f, 0.11631659f, -0.04162940f, 
    -0.16453671f, 0.11855177f, 0.04281719f, 0.01422592f, 0.04536019f, 0.17737043f, 0.10398401f, 0.19951336f, 
    -0.00318169f, 0.01914373f, -0.07078088f, 0.03821496f, -0.01220411f, -0.07736263f, -0.03709843f, 0.02090689f, 
    0.21198715f, -0.01141826f, -0.11667055f, 0.14715952f, 0.06007005f, 0.09439702f, 0.15673083f, -0.01519369f, 
    0.06080974f, -0.18679513f, 0.06386629f, 0.03978560f, -0.04671130f, 0.06562367f, -0.01344325f, 0.07721702f, 
    0.10369357f, -0.02573127f, -0.10819779f, 0.03186445f, -0.08161062f, -0.03439176f, -0.04837240f, -0.00699351f, 
    0.33540547f, 0.22090529f, 0.09162746f, 0.00006853f, -0.21238595f, -0.14368895f, 0.15434082f, 0.11418396f, 
    -0.07013579f, -0.09805947f, 0.08586773f, -0.13510412f, 0.38233036f, -0.00665185f, -0.14746563f, 0.07871277f, 
    -0.27999166f, -0.15205598f, -0.03853704f, -0.09074574f, 0.00231468f, -0.10397594f, -0.08437064f, -0.13456932f, 
    0.07318272f, 0.12528908f, 0.12516727f, -0.11612436f, -0.05302551f, -0.02226958f, 0.02058098f, -0.04386041f, 
    0.03720965f, 0.01281442f, -0.03703449f, -0.01341551f, 0.03045621f, -0.16524190f, 0.00759686f, 0.18206255f, 
    -0.04766399f, 0.14296998f, 0.04473775f, 0.04868541f, 0.06631000f, 0.07696246f, 0.04803923f, -0.25227630f, 
    -0.11068194f, -0.23784856f, 0.09601998f, -0.06565275f, -0.02619818f, -0.05327961f, -0.06083438f, 0.05736479f, 
    -0.01917631f, 0.02917376f, -0.05144388f, -0.04584769f, -0.30307275f, -0.14493942f, 0.08784151f, 0.22275090f, 
    0.01885057f, -0.03325082f, -0.08034267f, 0.01387171f, -0.03820933f, -0.20169462f, -0.06058654f, -0.21871978f, 
    -0.07783645f, 0.20722596f, 0.16222842f, 0.02693409f, -0.04839022f, -0.14798672f, 0.06241991f, 0.06547868f, 
    -0.01427855f, 0.02959835f, -0.02028491f, 0.04701579f, -0.04228734f, 0.21602044f, 0.26478967f, 0.16507392f, 
    0.24197021f, 0.10843429f, 0.03203328f, 0.09430274f, -0.04607978f, 0.12551628f, 0.01776255f, -0.06730998f, 
    -0.09902871f, 0.03268584f, 0.04563850f, -0.20432383f, -0.00817942f, 0.02478039f, 0.02469736f, -0.01965181f, 
    -0.02178698f, -0.19470535f, -0.07534157f, 0.04380218f, 0.25129548f, 0.13163380f, 0.10826059f, 0.16942403f, 
    -0.14433435f, -0.00720431f, -0.03601364f, 0.01599279f, -0.09348332f, -0.03669544f, 0.11471271f, -0.01119596f, 
    0.00251831f, 0.01743789f, -0.22603816f, -0.16650957f, 0.02844172f, -0.06929059f, -0.13140664f, 0.00692088f, 
    -0.05137233f, -0.03266892f, 0.03864093f, 0.07520023f, 0.10833574f, -0.30619934f, 0.16231649f, 0.03515890f, 
    0.02907771f, -0.07461160f, 0.02854740f, 0.05679403f, 0.03470922f, 0.18325326f, 0.00431244f, -0.02660245f, 
    -0.05277568f, 0.12410191f, 0.03878514f, -0.06501285f, -0.10932569f, -0.03444416f, 0.00135325f, 0.06048857f, 
    0.14587347f, -0.04737335f, 0.01361946f, -0.11479666f, 0.26449782f, 0.18705310f, -0.00589787f, 0.03060349f, 
    -0.00503726f, -0.09179702f, -0.09724622f, -0.12659398f, 0.01826174f, -0.04827133f, 0.06642619f, 0.10423653f, 
    -0.41692263f, 0.08321221f, 0.03508229f, 0.33705476f, 0.06503648f, 0.01781671f, -0.07547651f, 0.06782626f, 
    0.01456163f, 0.11924083f, -0.00483865f, -0.05891038f, 0.23256947f, 0.27388012f, 0.09782256f, -0.08826975f, 
    0.00666114f, 0.09685642f, 0.05117742f, 0.15660603f, 0.18738864f, 0.01175804f, -0.01062948f, -0.01209324f, 
    -0.31606627f, -0.07629317f, 0.07650976f, -0.28502858f, 0.12098657f, 0.00725118f, 0.03679398f, -0.13098963f, 
    0.16907607f, 0.03977966f, -0.10105974f, -0.03645318f, 0.22557540f, -0.13038425f, -0.10383520f, 0.23352262f, 
    0.09489258f, -0.14513892f, 0.04253138f, 0.03167761f, 0.00434119f, 0.03171367f, 0.07501206f, -0.02706562f, 
    0.04921199f, 0.07721169f, -0.05015209f, -0.10521962f, 0.08025450f, 0.01164806f, 0.04466407f, 0.04890984f, 
    0.05856984f, -0.09308296f, -0.03997517f, -0.10609023f, 0.15255547f, -0.08110856f, -0.09091356f, 0.27493083f, 
    -0.16784224f, 0.00363635f, -0.12653902f, -0.04549661f, -0.08345918f, -0.09611093f, -0.10442428f, 0.14411154f, 
    0.11880939f, 0.18531150f, -0.12889962f, 0.05777563f, 0.06521674f, 0.07440666f, 0.07290237f, -0.01318821f, 
    -0.09579775f, 0.11977305f, -0.12139149f, 0.16358067f, 0.20755035f, 0.13695359f, 0.12896760f, -0.22343408f, 
    0.12859394f, 0.17877331f, -0.01990170f, 0.08733110f, 0.05449518f, 0.10290918f, 0.07020970f, 0.11028528f, 
    -0.32131431f, 0.20325738f, -0.03425083f, 0.16438092f, -0.10361752f, 0.10929343f, -0.01602261f, -0.07435449f, 
    0.08901329f, 0.07217917f, -0.03648262f, -0.11837049f, -0.12643006f, 0.16088733f, -0.19956824f, -0.02891361f, 
    -0.01811664f, -0.11980315f, -0.08121193f, -0.05113747f, -0.02467283f, -0.09030536f, -0.05410555f, 0.01535015f, 
    0.19382465f, 0.02175044f, 0.04933518f, 0.10390245f, 0.06436149f, 0.22771397f, 0.04322656f, 0.08039343f, 
    -0.02549833f, -0.11631358f, -0.04649478f, -0.23969062f, 0.14581972f, 0.14277536f, -0.04693245f, -0.08171013f, 
    -0.03249656f, -0.05329487f, -0.12282443f, -0.03310688f, -0.07654655f, -0.00362044f, 0.06043011f, -0.08272827f, 
    0.16958623f, -0.12395117f, -0.00666786f, 0.01491816f, 0.21848212f, 0.05871870f, -0.00660823f, -0.07488525f, 
    -0.08556717f, 0.04616176f, -0.06712829f, 0.10836667f, -0.27470052f, -0.07538593f, 0.01333432f, -0.28194174f, 
    0.04713837f, -0.03016451f, 0.09970166f, 0.02334466f, -0.08824217f, 0.06522676f, 0.10521370f, 0.09283070f, 
    -0.30249888f, -0.15577053f, 0.10395312f, 0.15240672f, 0.06635655f, -0.18014078f, -0.01342365f, 0.12861042f, 
    0.13193017f, -0.09072267f, 0.05265040f, -0.05793885f, 0.55899441f, -0.10187160f, 0.02128606f, -0.07006981f, 
    -0.00700019f, 0.02875381f, -0.12664936f, 0.08415857f, -0.01887331f, 0.09899803f, 0.07013208f, 0.01380766f, 
    -0.24553157f, 0.05492863f, -0.15520561f, 0.08102050f, -0.00386077f, 0.02200325f, -0.21406852f, -0.00244994f, 
    -0.00511992f, 0.16231821f, 0.02492311f, -0.08108351f, 0.20125620f, 0.20032395f, -0.12103456f, 0.37000582f, 
    0.12551947f, -0.11789276f, -0.00460595f, -0.04550173f, 0.05455492f, -0.03016806f, 0.06080082f, 0.04402895f, 
    -0.15604737f, -0.16210906f, 0.13120805f, 0.26846382f, 0.10246130f, 0.10770187f, 0.13608325f, -0.12836672f, 
    -0.08018830f, 0.01810391f, 0.04939110f, 0.08130646f, -0.06419249f, 0.13839911f, 0.08100709f, -0.06793873f, 
    0.08966168f, 0.06251339f, 0.09576311f, 0.02518653f, 0.01661022f, -0.04545013f, -0.01744036f, 0.08497687f, 
    -0.38548648f, 0.01077946f, -0.00191909f, 0.12140261f, 0.00734403f, 0.03203314f, 0.11243404f, 0.11981799f, 
    -0.00802607f, 0.04702976f, 0.16946292f, -0.19752780f, -0.17331077f, 0.11385790f, -0.03234379f, -0.07696380f, 
    0.07589363f, -0.05010825f, -0.05726247f, -0.03815456f, -0.02946508f, -0.12243012f, 0.01586469f, -0.03937477f, 
    -0.22061145f, 0.17248686f, 0.10224125f, 0.05217417f, -0.05362977f, 0.13515835f, 0.06101425f, -0.12125790f, 
    -0.17323220f, 0.14841174f, -0.04233071f, -0.01170490f, 0.18472615f, -0.01709910f, 0.04779346f, 0.00765104f, 
    0.06843730f, -0.04813885f, -0.04697817f, -0.01745259f, -0.02002491f, 0.07734089f, 0.13592586f, 0.05904990f, 
    0.00166277f, 0.21230991f, -0.15957157f, -0.08869541f, 0.04450711f, 0.05724677f, -0.02343252f, -0.03645623f, 
    0.04745811f, -0.08074878f, -0.14238377f, -0.02742401f, 0.34772107f, -0.07223780f, -0.00987639f, 0.13930063f, 
    0.00348213f, -0.01860172f, -0.06759436f, -0.02638241f, -0.06420157f, 0.06499058f, -0.05381373f, 0.06069620f, 
    0.04933356f, -0.02605669f, 0.02742705f, 0.02430646f, -0.07504231f, -0.06851348f, -0.03230244f, -0.03056473f, 
    -0.00164584f, 0.02736483f, 0.00031410f, -0.03997039f, -0.05287455f, -0.06049844f, 0.01117225f, 0.01736276f, 
    0.02917133f, -0.03186151f, -0.01506310f, 0.04422259f, -0.07756722f, -0.02750910f, 0.04573100f, -0.00180328f, 
    -0.00638198f, -0.08150218f, 0.05883167f, 0.04782948f, -0.03327704f, -0.00041557f, -0.04499845f, -0.05792939f, 
    0.05116173f, 0.04560974f, -0.01952732f, 0.01648270f, -0.06170759f, -0.07783004f, -0.00582843f, 0.00665498f, 
    -0.01255746f, 0.01290107f, -0.04238158f, -0.02841704f, -0.00384704f, -0.00731538f, 0.04492028f, 0.00701159f, 
    -0.01107914f, -0.01012701f, 0.00407334f, 0.05340564f, 0.05281051f, -0.05646991f, -0.06534309f, 0.02762368f, 
    0.03561245f, -0.04567379f, 0.05392469f, -0.07952719f, -0.06522499f, 0.00608896f, 0.06992203f, 0.01897896f, 
    -0.08246591f, 0.03135191f, -0.02438257f, -0.04821748f, -0.02696385f, 0.04874330f, -0.03436822f, -0.07283208f, 
    0.01422611f, -0.07703498f, -0.06467680f, -0.03273156f, -0.04431083f, -0.00239502f, -0.01357333f, 0.04774242f, 
    -0.01554441f, -0.07166532f, -0.00487631f, 0.04247299f, 0.03819895f, -0.03470019f, -0.04495914f, -0.06057931f, 
    0.02850772f, -0.02845922f, 0.05804304f, -0.01968000f, -0.07596768f, 0.04123715f, -0.05676604f, -0.03700070f, 
    -0.00102912f, -0.05875738f, 0.06808124f, -0.02014652f, -0.06184902f, -0.06902467f, -0.06902774f, -0.06078720f, 
    -0.07757642f, -0.04193774f, 0.04922811f, 0.01228054f, 0.00137262f, 0.04196209f, -0.01823754f, -0.01857956f, 
    0.05500354f, -0.04589014f, -0.06189472f, 0.01815835f, 0.00016855f, -0.07502318f, 0.02408183f, -0.04954505f, 
    0.04699129f, -0.03186433f, -0.04703531f, 0.01772984f, -0.02190297f, -0.03152381f, 0.02615973f, 0.00227886f, 
    0.04270359f, -0.07347654f, 0.03615047f, -0.01439019f, 0.01872565f, -0.01682856f, -0.03329080f, 0.05896019f, 
    -0.06185946f, -0.07435749f, -0.02591724f, 0.01331008f, 0.02545446f, -0.00854587f, 0.05196508f, 0.00519312f, 
    -0.01585591f, -0.03260170f, 0.00447882f, 0.01363732f, 0.00657634f, -0.01947880f, 0.04088971f, -0.07773285f, 
    0.01742904f, -0.07635029f, 0.01472283f, 0.04553243f, -0.02331114f, -0.08529007f, 0.04539691f, 0.04278482f, 
    0.05723053f, 0.00181520f, 0.02483651f, 0.05588729f, -0.07721015f, -0.06510381f, -0.04751947f, -0.02885785f, 
    -0.07476051f, 0.02938940f, 0.02420690f, -0.01643828f, -0.07389693f, -0.07180100f, 0.02321859f, -0.00292543f, 
    0.03754463f, 0.03139906f, 0.00223838f, 0.04021996f, 0.02483009f, -0.06330549f, -0.08040275f, -0.03883543f, 
    -0.03828842f, 0.03344228f, -0.06362595f, -0.03264555f, 0.05507576f, -0.06743045f, 0.02799578f, -0.04067406f, 
    -0.04730995f, 0.06662989f, 0.05096743f, -0.01881679f, -0.06132404f, 0.06106114f, -0.05098955f, -0.06817153f, 
    0.04024703f, -0.01204150f, -0.06208519f, 0.02254791f, -0.02481114f, 0.06183424f, -0.05859723f, -0.06642125f, 
    0.00762887f, 0.03452798f, -0.07150912f, 0.00161837f, -0.08350551f, -0.00921372f, 0.01687367f, 0.05535239f, 
    -0.01099699f, -0.06969836f, -0.05610172f, -0.03105803f, -0.01609653f, 0.03840322f, 0.02716159f, -0.06924213f, 
    -0.04953461f, -0.06539183f, -0.05988546f, -0.04305511f, 0.05438666f, -0.02981477f, -0.00381526f, 0.00153597f, 
    -0.03671091f, -0.05412142f, -0.02554876f, -0.03259586f, 0.04735622f, -0.06465723f, -0.02052537f, 0.04308309f, 
    -0.01438599f, 0.03524379f, 0.01729290f, -0.00943686f, -0.02647245f, 0.03605105f, -0.00761929f, 0.01370626f, 
    -0.02976332f, 0.00647606f, -0.01601863f, 0.00312501f, -0.02535038f, 0.04402747f, -0.06570573f, -0.06960718f, 
    -0.06694919f, 0.02058420f, -0.07005728f, 0.04541405f, -0.02107526f, -0.07416028f, -0.03819192f, 0.04530527f, 
    -0.01104522f, -0.00164507f, 0.03380863f, 0.03201025f, -0.01662120f, 0.06920781f, 0.04602329f, -0.05609519f, 
    -0.07277323f, 0.01962464f, 0.01308463f, -0.04518271f, -0.04806048f, -0.02470918f, 0.05634029f, 0.03224296f, 
    -0.04243085f, -0.05283471f, 0.01541424f, -0.07565855f, -0.06261830f, 0.06207594f, -0.05214886f, -0.02641337f, 
    0.00714923f, -0.02203191f, 0.00865068f, 0.01504550f, -0.07885122f, 0.01474324f, 0.01275544f, 0.03714417f, 
    0.04949004f, -0.03172316f, -0.04447071f, -0.02365101f, 0.04757419f, -0.02012254f, 0.06366005f, -0.04455380f, 
    0.00631441f, -0.06281753f, -0.06802945f, 0.05622170f, 0.04283981f, -0.04240208f, -0.03385261f, -0.04137442f, 
    0.04148655f, -0.04262888f, 0.00393663f, 0.05443062f, 0.00119356f, 0.04227887f, -0.01539983f, -0.03263769f, 
    -0.07003821f, 0.00605271f, -0.01187743f, 0.02563541f, -0.05913464f, -0.00071467f, -0.07118989f, 0.03497123f, 
    -0.08060048f, -0.02268996f, -0.06617238f, 0.00333326f, -0.07758246f, -0.06514712f, -0.00040798f, -0.02372482f, 
    -0.01213675f, -0.04417860f, -0.00537063f, 0.05043847f, 0.05129167f, -0.00168642f, -0.01994225f, 0.01910651f, 
    0.00656389f, 0.05010058f, -0.01285553f, -0.02822714f, -0.03448840f, 0.04969911f, -0.05729646f, 0.03964199f, 
    -0.05269444f, 0.04233552f, 0.01158361f, 0.02582232f, 0.05048273f, -0.02544770f, 0.05399706f, -0.00667807f, 
    0.06230823f, -0.01807257f, -0.06985807f, -0.07205880f, 0.06027973f, -0.02867081f, 0.04225760f, -0.00104023f, 
    0.04660162f, -0.03403091f, 0.03403340f, 0.00316975f, -0.01226964f, 0.01836275f, 0.02129959f, -0.06355816f, 
    0.03611907f, -0.03390650f, -0.07623812f, -0.03749100f, -0.07139233f, 0.01667715f, 0.05700982f, -0.05119035f, 
    0.15108036f, 0.09178991f, 0.27856687f, -0.24309671f, 0.12353724f, -0.08897963f, 0.00153383f, 0.02823205f, 
    -0.01229709f, -0.15754628f, -0.06532528f, 0.06083458f, -0.00553473f, 0.34396061f, -0.04436965f, 0.20978418f, 
    -0.08349533f, -0.04412719f, -0.15464272f, -0.03272853f, 0.05460245f, 0.00627987f, 0.06056149f, 0.00204176f, 
    -0.04864904f, 0.08114569f, -0.00066639f, -0.09059081f, -0.11404743f, -0.10808684f, -0.14320138f, 0.15844101f, 
    0.07159211f, 0.11256355f, 0.06216704f, 0.10371710f, 0.02620860f, -0.21176687f, -0.00518840f, 0.20667052f, 
    -0.15458451f, 0.03730471f, -0.05701685f, 0.05074498f, 0.05154413f, 0.19015697f, 0.03507195f, -0.03746691f, 
    0.24221316f, 0.13948329f, -0.08945834f, -0.16537164f, 0.00393094f, 0.18654311f, -0.04966279f, -0.03839720f, 
    0.05860519f, 0.07624207f, 0.06711482f, -0.07627182f, -0.19845811f, 0.32942575f, 0.11079051f, 0.05483706f, 
    -0.11359347f, 0.08862187f, -0.03165633f, -0.06010232f, 0.01874926f, -0.04779873f, -0.05056227f, 0.06324095f, 
    -0.06113575f, 0.01019410f, -0.07881263f, 0.28976104f, -0.02790732f, -0.03620385f, 0.09123270f, -0.04445964f, 
    0.10513975f, 0.20718697f, -0.03589172f, -0.06355320f, 0.11651898f, 0.00431162f, 0.21466523f, -0.21410784f, 
    0.09477090f, 0.06899428f, -0.03979730f, 0.04804394f, 0.11362422f, 0.03377393f, 0.05178176f, -0.08705028f, 
    -0.10450468f, 0.24213985f, 0.09747012f, -0.46525609f, -0.07032365f, -0.08603974f, -0.00385593f, -0.00099167f, 
    0.14609332f, 0.00498031f, -0.11059397f, -0.02087095f, 0.09182978f, -0.26605579f, 0.13638586f, 0.45361099f, 
    -0.07643601f, -0.07941392f, -0.06152909f, 0.05043045f, -0.03549682f, -0.01899862f, -0.00446195f, -0.05417269f, 
    -0.09062237f, 0.05477955f, -0.02380276f, -0.14943048f, 0.09425870f, 0.02745623f, 0.11362605f, -0.14037605f, 
    0.04864338f, -0.00886494f, 0.10115048f, -0.04651717f, 0.16249736f, -0.05941984f, -0.15033497f, 0.04864787f, 
    -0.15850593f, 0.03234230f, -0.05205119f, 0.02467150f, -0.02046120f, 0.07730661f, -0.08154418f, 0.09282021f, 
    -0.18196693f, -0.03461101f, 0.14655894f, -0.06690037f, 0.05348520f, -0.02358705f, 0.07408239f, -0.04856805f, 
    0.15272351f, 0.12975736f, 0.00537065f, 0.20556521f, -0.20165369f, -0.20491049f, 0.09074249f, -0.16873856f, 
    -0.07700001f, -0.01661617f, 0.05135123f, 0.06488238f, 0.20951413f, 0.03612546f, 0.02122434f, 0.05997589f, 
    -0.00805045f, 0.31827217f, -0.10212196f, 0.04234115f, -0.11273082f, 0.06346468f, 0.07195823f, -0.29663742f, 
    0.00191319f, -0.23998705f, -0.07416892f, -0.13001469f, -0.16550353f, 0.02620698f, 0.16341008f, -0.10958733f, 
    0.20606044f, 0.14673179f, -0.05121794f, -0.02001913f, 0.03139234f, -0.01632984f, -0.01415547f, -0.01396689f, 
    -0.24456044f, -0.10922303f, -0.09451526f, 0.11186285f, -0.00214666f, 0.05036749f, -0.03502470f, 0.15734878f, 
    0.08760582f, -0.09572832f, -0.05903258f, 0.01064821f, -0.11872766f, 0.25188774f, 0.05839998f, 0.01045434f, 
    0.01110404f, 0.10818942f, 0.00475125f, 0.07752745f, -0.14049673f, 0.05873577f, 0.11924537f, 0.06342705f, 
    0.12379891f, -0.06531192f, -0.14244607f, -0.18674940f, -0.20879775f, 0.01484104f, 0.11294731f, 0.08496854f, 
    0.11658703f, -0.03765137f, -0.09303100f, -0.02594434f, 0.31092390f, 0.09608876f, -0.00366088f, 0.23765726f, 
    0.08335877f, -0.09006889f, -0.07556093f, -0.07805678f, -0.13882056f, -0.12269611f, -0.11181520f, -0.00321263f, 
    0.40700611f, 0.18372913f, 0.24089810f, -0.28855646f, -0.06952041f, 0.13323438f, 0.14496204f, -0.19344772f, 
    -0.07034968f, 0.03563042f, -0.09789479f, -0.03521468f, -0.21824171f, 0.12390311f, -0.05325781f, 0.09208731f, 
    0.10407201f, 0.05031955f, -0.00736442f, 0.00687821f, 0.11214025f, -0.04613701f, 0.15863809f, -0.07284092f, 
    0.15997119f, -0.01035460f, -0.07830216f, 0.03594726f, -0.02767863f, 0.06314754f, 0.04139975f, 0.04732676f, 
    0.08823856f, -0.02528930f, 0.05920249f, 0.11139170f, -0.10417145f, 0.03979296f, -0.03679683f, -0.15438928f, 
    0.05034308f, 0.04114333f, -0.15879266f, 0.06050975f, 0.01304711f, 0.03067614f, -0.03399460f, -0.00294057f, 
    -0.10607358f, -0.21461414f, 0.00462991f, -0.21985412f, -0.17020318f, 0.04880079f, 0.05085354f, 0.06657638f, 
    0.11338087f, -0.01005408f, 0.09665295f, -0.07288454f, 0.41669530f, 0.13266890f, -0.11244838f, 0.25837520f, 
    -0.05806463f, -0.07237983f, 0.08441763f, 0.01733241f, 0.01548610f, -0.07678995f, -0.01800072f, 0.09781113f, 
    0.10740800f, -0.21505032f, 0.16644885f, -0.18299751f, 0.09313159f, 0.12981473f, 0.02929005f, -0.01537557f, 
    0.10103550f, -0.00055150f, 0.02584771f, 0.14458293f, 0.12858859f, -0.12315692f, -0.10199886f, 0.32197168f, 
    -0.05447996f, 0.04382810f, 0.00382384f, 0.06070991f, 0.05889290f, -0.10254069f, -0.01542493f, 0.06167236f, 
    0.34901732f, 0.16336243f, -0.15673241f, -0.16512835f, 0.05354255f, 0.08022600f, -0.06059274f, 0.12263657f, 
    0.06547967f, -0.01287689f, -0.01738119f, 0.03029558f, -0.21432601f, -0.02622333f, 0.15082692f, -0.12072247f, 
    -0.03181783f, 0.00322770f, 0.06861289f, 0.10902860f, 0.10356579f, 0.05756344f, -0.00085977f, -0.13540176f, 
    -0.44307593f, 0.03921762f, 0.14000703f, 0.18083465f, -0.06541563f, -0.05930468f, 0.02170926f, 0.08180211f, 
    -0.00107059f, 0.14690982f, 0.13305514f, 0.11595055f, -0.31203917f, 0.30456960f, -0.17350422f, 0.16248813f, 
    -0.07013004f, -0.03091920f, 0.07192434f, 0.01436668f, 0.07789909f, -0.08427424f, -0.05934560f, -0.00976798f, 
    -0.04125832f, -0.01557186f, -0.03837518f, -0.04761368f, -0.03191693f, 0.03710399f, -0.05362440f, 0.02277849f, 
    -0.02194021f, -0.04643695f, -0.06476139f, -0.00959137f, -0.02843493f, -0.07598499f, -0.02412746f, -0.00498504f, 
    0.06078697f, 0.03901977f, -0.04379447f, -0.04746597f, -0.06789894f, -0.05303266f, -0.04704476f, 0.06078499f, 
    -0.07109719f, -0.06997535f, 0.03421193f, 0.00733304f, -0.07581986f, -0.05201434f, 0.05743106f, -0.06174613f, 
    -0.04845406f, -0.02281390f, 0.02040577f, -0.02547555f, -0.06953766f, 0.05994252f, -0.05653619f, -0.03984027f, 
    -0.02237362f, -0.06872831f, -0.07379792f, -0.00864172f, -0.02582427f, 0.04710815f, -0.07313863f, -0.07332563f, 
    -0.03259630f, -0.06476258f, -0.06249167f, -0.07432559f, 0.00497612f, 0.01046514f, 0.01265709f, 0.01220251f, 
    0.02889999f, 0.04139223f, -0.06650168f, 0.00538446f, -0.07013384f, 0.00516975f, 0.00325784f, 0.05249751f, 
    -0.01041387f, 0.04052963f, -0.04458910f, -0.06425023f, -0.07073845f, -0.04053686f, 0.01683711f, -0.07478640f, 
    -0.06862996f, -0.03764828f, 0.05733991f, -0.04159490f, 0.06148235f, -0.02597421f, 0.03118500f, -0.04586238f, 
    -0.04598526f, -0.01419332f, -0.03663076f, -0.03620503f, -0.00884253f, 0.02911326f, -0.03504442f, 0.02577027f, 
    0.04916446f, 0.06573670f, 0.05783789f, 0.06228300f, 0.05704730f, 0.02389262f, -0.02219622f, 0.05982801f, 
    0.01584278f, 0.04976257f, -0.05901502f, 0.03217816f, -0.07532588f, -0.07788400f, -0.05958746f, 0.02745583f, 
    0.02670222f, 0.02517346f, -0.03200683f, -0.00990349f, -0.05107440f, -0.05906504f, -0.06669234f, -0.06409729f, 
    -0.02857270f, 0.06166034f, 0.03122419f, 0.00816872f, 0.03477700f, -0.01739844f, -0.00929228f, 0.02298402f, 
    0.03524921f, -0.01910461f, -0.05957156f, -0.02310692f, -0.02859331f, -0.00078223f, 0.05363834f, -0.05912956f, 
    -0.04838192f, -0.02145370f, 0.05574944f, 0.03782688f, 0.06081698f, -0.05813614f, 0.00299752f, -0.00010047f, 
    0.05496962f, -0.01859164f, -0.05133091f, 0.01033210f, 0.03141564f, 0.02037686f, 0.05691198f, -0.05217141f, 
    -0.02800846f, -0.01027417f, 0.04805635f, -0.05198770f, -0.07418285f, 0.04246075f, 0.05294248f, 0.02452972f, 
    -0.03290035f, -0.06908717f, -0.02145598f, 0.00156091f, 0.04422343f, 0.04170879f, 0.00695301f, 0.03946869f, 
    0.05553351f, -0.06772765f, -0.05071900f, -0.06798141f, 0.02462505f, -0.02550354f, -0.00148975f, -0.01860464f, 
    -0.06676307f, -0.04133483f, -0.02767508f, -0.02329040f, -0.02099116f, 0.04381277f, 0.00346611f, 0.03897271f, 
    0.00137375f, 0.00352423f, 0.01610845f, 0.00716124f, 0.00065985f, 0.02284442f, 0.05487539f, -0.01252891f, 
    -0.06551319f, -0.06290637f, 0.03004528f, 0.01621105f, -0.00225502f, 0.01418863f, -0.03727462f, 0.02003789f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.00240090f, -0.00093371f, -0.03219897f, -0.02845506f, 0.05887724f, 0.03115017f, -0.06092961f, -0.01951091f, 
    -0.03418753f, -0.11280175f, 0.08634524f, 0.07920828f, 0.03554725f, 0.09024109f, 0.10344116f, 0.12520884f, 
    -0.04425843f, -0.00797533f, 0.01784762f, -0.07429402f, 0.06450877f, 0.05071103f, 0.04946488f, 0.03616889f, 
    0.10925794f, -0.06315985f, -0.07097361f, -0.01193945f, -0.06645151f, 0.06762288f, 0.18641356f, -0.01224604f, 
    0.12760858f, 0.02332637f, -0.08730715f, 0.11187700f, 0.22008406f, -0.00626804f, -0.02433260f, 0.04695224f, 
    0.20453487f, -0.00031318f, 0.03402842f, 0.06070992f, -0.02615884f, 0.20410025f, 0.11059982f, -0.00533160f, 
    -0.01562095f, -0.02419576f, 0.09161181f, -0.06189361f, -0.00902465f, -0.02834593f, 0.00724290f, 0.11009715f, 
    -0.07807268f, -0.03177722f, 0.06418154f, 0.01827414f, -0.04218983f, 0.01904980f, 0.05939167f, 0.04506811f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.07383531f, -0.09276673f, 0.05754235f, 0.10533792f, -0.17830110f, 0.08521631f, -0.06460001f, 0.03869371f, 
    0.27792343f, 0.23719054f, 0.29346955f, 0.07139236f, -0.15488337f, -0.15262593f, -0.46490100f, -0.27738297f, 
    0.26834208f, 0.08469867f, -0.07011737f, 0.03725042f, 0.01875143f, -0.06062272f, -0.37956727f, 0.10958733f, 
    0.17497574f, -0.11694375f, -0.38767844f, -0.05868065f, 0.25435707f, -0.36491427f, -0.42287058f, 0.18848231f, 
    -0.37019515f, -0.08208351f, -0.57049644f, -0.10336623f, -0.35933068f, 0.03844481f, 0.22142524f, -0.15911993f, 
    -0.36311194f, 0.02401238f, -0.11177427f, -0.33376154f, -0.06266188f, 0.06154634f, -0.13860247f, 0.25024346f, 
    0.21874058f, 0.19554162f, -0.14789943f, 0.03202844f, 0.08063985f, 0.13346955f, -0.62554747f, -0.22974895f, 
    0.14378963f, 0.20581788f, -0.31117362f, 0.04289329f, -0.06172420f, 0.34175932f, 0.26854604f, 0.09173269f, 
    -0.04960537f, -0.03032403f, 0.08515143f, -0.12451482f, -0.20324743f, 0.10446688f, -0.12424845f, -0.02120910f, 
    -0.24851733f, -0.28729466f, 0.45966464f, -0.38369203f, 0.25834137f, 0.22491749f, -0.23306550f, -0.17032163f, 
    -0.00916502f, 0.10000289f, 0.20989586f, -0.11899412f, -0.08035546f, -0.06399856f, 0.29818112f, 0.07095812f, 
    -0.15928166f, -0.14052039f, -0.09846050f, -0.11735205f, -0.41148645f, -0.29072419f, 0.29268879f, -0.22571869f, 
    -0.28553805f, -0.49376217f, 0.13582908f, 0.11571093f, 0.05712378f, 0.23044984f, -0.02223942f, 0.07382650f, 
    0.27083170f, -0.01246020f, -0.10473840f, -0.27995476f, 0.11366129f, 0.22723438f, 0.00436390f, 0.07865096f, 
    -0.56235361f, 0.09271219f, 0.12770782f, -0.04082618f, 0.29290101f, -0.09714750f, -0.07305665f, -0.12009101f, 
    0.12131619f, 0.22756207f, 0.12465704f, 0.09595256f, 0.04130683f, 0.23493372f, 0.09312002f, -0.08683193f, 
    -0.02588295f, 0.05726728f, -0.05236022f, 0.17393614f, -0.25937080f, 0.02234329f, -0.04824262f, 0.03043069f, 
    -0.05267047f, -0.35717094f, -0.61607409f, 0.08316010f, 0.04357279f, 0.19719790f, 0.24153399f, -0.40394273f, 
    -0.29106897f, 0.31649026f, 0.05111671f, 0.31343868f, 0.08706447f, 0.03760782f, -0.00744723f, 0.09458593f, 
    0.06520429f, 0.09761965f, -0.02352118f, 0.13953342f, 0.47499472f, 0.17427786f, -0.37953442f, -0.53080744f, 
    0.04723981f, -0.07395404f, 0.17417055f, 0.16363105f, -0.07577797f, -0.44381967f, -0.44098693f, 0.02155926f, 
    -0.23541871f, -0.08923694f, 0.09408941f, -0.50862968f, -0.04646623f, 0.00284218f, 0.11626393f, 0.20519888f, 
    -0.22862124f, 0.05460430f, 0.25746471f, 0.01785055f, 0.25602114f, -0.69888377f, -0.48037401f, -0.18490377f, 
    -0.19002657f, 0.19103219f, 0.28125572f, -0.03620242f, -0.01871954f, -0.48205754f, -0.03552023f, 0.02658209f, 
    -0.01393399f, -0.00342895f, 0.08046681f, 0.01950273f, -0.39416340f, 0.09280349f, 0.06155956f, 0.04961007f, 
    0.09570293f, 0.10050268f, -0.52320457f, 0.19026887f, -0.13732453f, -0.10966200f, 0.13008676f, 0.33199924f, 
    0.09692556f, -0.40178472f, -0.27523088f, 0.17523991f, -0.12698106f, -0.03820799f, 0.15829748f, -0.00464777f, 
    0.15237881f, -0.15365323f, 0.08701298f, 0.17297347f, -0.23675720f, 0.19511326f, 0.34024426f, -0.02620709f, 
    -0.19343807f, 0.25834876f, 0.02938231f, -0.33960158f, -0.23302008f, -0.12178497f, -0.03977047f, -0.00444631f, 
    0.09736447f, -0.00265541f, 0.09101676f, -0.15037806f, -0.05890669f, 0.19600430f, -0.36990744f, -0.70868516f, 
    0.20970361f, 0.45503625f, -0.19995596f, 0.05099236f, -0.63936174f, 0.08779591f, -0.33970827f, -0.06972006f, 
    0.24081866f, -0.14820205f, -0.24817358f, -0.09007233f, 0.10315681f, -0.09330983f, -0.09927639f, 0.07227534f, 
    0.01389207f, -0.05263098f, 0.01887222f, -0.17308456f, -0.03994024f, -0.08885310f, -0.12015397f, 0.01517405f, 
    -0.20263496f, 0.01250413f, 0.19672003f, 0.16104263f, -0.05547276f, 0.12857546f, 0.11546832f, 0.11266578f, 
    -0.12558976f, -0.00778415f, -0.29893747f, -0.14169274f, 0.08738121f, -0.03329861f, -0.54395568f, -0.05032259f, 
    0.08979785f, 0.32769942f, 0.09902381f, -0.34940839f, 0.29277503f, 0.15066263f, -0.37450048f, 0.00051531f, 
    -0.27321556f, -0.06743070f, 0.25668511f, 0.01008425f, -0.27418774f, -0.19184713f, -0.08274455f, -0.35849223f, 
    -0.03693544f, 0.02748054f, -0.12256555f, 0.12266629f, 0.03949917f, 0.13701972f, 0.20442072f, -0.46226928f, 
    0.21628869f, -0.01182492f, 0.17664997f, -0.02123432f, 0.40561470f, 0.19943392f, 0.06281126f, 0.32984826f, 
    0.17681538f, -0.34957665f, -0.09652738f, -0.10378741f, -0.11681870f, 0.14230095f, -0.06515826f, 0.05990145f, 
    -0.03636494f, -0.09377491f, -0.03532820f, -0.00187973f, 0.13200493f, -0.03384658f, -0.01791505f, 0.03862413f, 
    -0.16955224f, -0.10630498f, 0.23248762f, -0.36072555f, 0.25868842f, -0.08124731f, -0.46006778f, -0.10161483f, 
    0.23898765f, -0.04152377f, 0.02399441f, -0.44249102f, -0.04185639f, 0.01186207f, 0.11404217f, 0.00928411f, 
    -0.15022030f, 0.18632787f, -0.22042260f, 0.04133215f, -0.40225780f, 0.14479384f, -0.20038942f, 0.17501894f, 
    0.18648775f, 0.01692684f, -0.58973551f, -0.46259475f, 0.15079951f, 0.31476808f, 0.13191170f, -0.17010826f, 
    -0.86097479f, 0.01516427f, 0.07186852f, 0.05839272f, -0.04186155f, -0.02081424f, 0.14151943f, 0.03062678f, 
    0.06143866f, -0.09449597f, 0.14378616f, 0.01999284f, -0.56398308f, 0.34348765f, 0.04553624f, 0.34677458f, 
    -0.15922289f, -0.07193372f, 0.16035441f, -0.12144761f, 0.07975611f, -0.21989417f, -0.06828636f, 0.06508120f, 
    0.03909628f, 0.04459180f, -0.03840872f, 0.09628864f, 0.35988846f, -0.08443802f, -0.03620489f, -0.02808214f, 
    0.31368050f, 0.07959729f, -0.17783655f, -0.48702654f, -0.07581334f, -0.02833797f, -0.21430430f, -0.01358999f, 
    0.11031684f, 0.15646754f, -0.23364200f, 0.02441845f, 0.01166326f, 0.08106611f, 0.30017987f, -0.04839338f, 
    0.12765442f, 0.06096610f, 0.25105977f, -0.58024704f, 0.54403293f, -0.55301017f, -0.00511626f, -0.23450154f, 
    0.16547483f, 0.34174231f, -0.35072142f, 0.06927821f, 0.13198985f, 0.12364300f, -0.47393209f, 0.25911948f, 
    0.48061123f, 0.04884789f, 0.11030211f, 0.36681843f, -0.11706848f, -0.10149448f, 0.20430952f, -0.04279333f, 
    -0.49628827f, 0.02657031f, -0.21561532f, -0.10964900f, -0.20931681f, -0.42662245f, -0.57375324f, -0.21885274f, 
    -0.29220328f, -0.16164134f, -0.15865256f, -0.08498490f, -0.03781999f, -0.10435429f, -0.19756377f, -0.01340790f, 
    0.09529369f, -0.04112795f, 0.09259766f, 0.26822385f, -0.08485095f, -0.09159264f, 0.07431764f, 0.03774926f, 
    -0.38887709f, 0.12746663f, -0.68257320f, 0.29608238f, -0.26067141f, -0.43497825f, 0.15814877f, -0.10875759f, 
    0.05880055f, 0.21498446f, -0.30141467f, 0.04622953f, -0.06883518f, 0.11108038f, 0.34780097f, -0.09609122f, 
    -0.47843188f, 0.28711829f, 0.33498016f, 0.19265451f, 0.11345511f, 0.08598869f, -0.14541595f, 0.07245971f, 
    -0.08154717f, 0.18037349f, 0.27389270f, -0.06767076f, -0.04755604f, -0.19375326f, -0.05423206f, -0.23128226f, 
    0.01714031f, -0.11621302f, -0.10141780f, -0.19612251f, -0.05122216f, -0.34754735f, -0.28070217f, 0.04366323f, 
    0.05082371f, -0.37386090f, -0.35119113f, -0.02664001f, 0.04653032f, 0.09938935f, 0.32889989f, -0.24220321f, 
    0.07456420f, -0.15002008f, 0.31512055f, 0.08941951f, -0.13529702f, -0.02190754f, -0.53957450f, -0.01717653f, 
    0.03905010f, 0.10845320f, -0.06836177f, -0.31014287f, -0.15991206f, -0.10122844f, -0.00064660f, 0.05290535f, 
    -0.32425475f, -0.42916369f, -0.00427310f, -0.48744604f, 0.00118791f, 0.14815620f, -0.02919916f, -0.16567776f, 
    -0.42871386f, -0.31367132f, 0.20139529f, -0.41749278f, 0.07723259f, -0.02986431f, 0.13383569f, -0.12951772f, 
    -0.06454132f, -0.24019730f, 0.13320810f, 0.26010683f, -0.11460000f, 0.08172201f, 0.24295712f, -0.03829339f, 
    0.30076581f, -0.23487245f, 0.28751111f, -0.28830275f, -0.19005020f, -0.19126430f, 0.28208101f, 0.28639442f, 
    -0.37231538f, -0.05324939f, 0.05254509f, 0.38218230f, 0.07589191f, -0.28061801f, -0.27928424f, 0.32610846f, 
    0.57763487f, 0.09645838f, 0.01970394f, -0.00902574f, 0.28535354f, -0.04985941f, -0.10940530f, -0.00350977f, 
    -0.59449512f, 0.17476222f, -0.36114633f, -0.04521985f, -0.04314880f, 0.33090016f, -0.05414765f, -0.06392266f, 
    0.00574534f, -0.12179339f, -0.08942233f, -0.47637734f, 0.28836623f, -0.10916533f, 0.00621955f, -0.03199335f, 
    0.12175777f, 0.27490824f, -0.47956026f, 0.24038899f, -0.41660696f, 0.19883867f, 0.06507420f, -0.53267312f, 
    0.10973556f, 0.23148698f, 0.11405350f, 0.21264523f, 0.00708538f, -0.04075551f, -0.09170650f, -0.02671309f, 
    -0.44509923f, 0.13443103f, 0.12214977f, -0.32806513f, -0.39561465f, 0.35042569f, -0.32679984f, -0.32954252f, 
    0.11792843f, -0.06420461f, 0.03377804f, 0.36500210f, -0.13296905f, 0.33199522f, 0.25553328f, -0.12830901f, 
    0.20593093f, -0.08104976f, -0.03997445f, 0.10285690f, -0.03925351f, -0.18297793f, -0.04025312f, 0.29099539f, 
    0.02478505f, -0.63153476f, 0.01316567f, 0.11819299f, -0.15557490f, -0.20255767f, 0.35335943f, -0.00028894f, 
    0.03392604f, -0.34919226f, 0.01040841f, -0.10133324f, 0.05831718f, -0.27613747f, 0.22526324f, -0.10471440f, 
    -0.10567161f, 0.00884154f, -0.09935677f, -0.28552759f, 0.16067459f, 0.07075269f, 0.03428477f, -0.12239838f, 
    -0.18032640f, -0.14476411f, -0.09670751f, 0.07540680f, -0.20570832f, -0.29187790f, 0.23446499f, 0.13969941f, 
    -0.06500261f, 0.14750643f, -0.14535436f, -0.35329804f, -0.01067182f, -0.12134469f, -0.27972358f, -0.01733063f, 
    0.29563671f, -0.31532159f, -0.25340286f, 0.29981044f, -0.46521434f, 0.12004115f, 0.11840358f, -0.24713607f, 
    0.34449068f, 0.24690916f, -0.33659321f, 0.00178739f, 0.21221958f, -0.36889884f, -0.31658447f, -0.07438129f, 
    0.41466811f, -0.07173172f, -0.07088167f, -0.10860401f, -0.13023466f, 0.36604565f, -0.36010113f, 0.13888410f, 
    -0.70039576f, 0.12093684f, 0.29603937f, -0.01755837f, 0.21989894f, 0.15783788f, 0.29107976f, -0.30497187f, 
    -0.44437277f, 0.21190313f, 0.28504315f, 0.07806256f, -0.00245257f, 0.15160054f, -0.39062676f, -0.07740710f, 
    0.04664183f, -0.05478961f, 0.09378011f, 0.34449434f, 0.16051704f, 0.07416336f, 0.02571621f, 0.09547009f, 
    0.15904371f, -0.07351509f, 0.02570388f, 0.19693357f, 0.07214114f, -0.01336020f, -0.03047580f, 0.35844496f, 
    -0.21313679f, -0.48283535f, 0.16280523f, 0.29157826f, 0.04696355f, 0.04775447f, -0.00065638f, 0.09815160f, 
    -0.01455526f, -0.25361803f, -0.41508171f, 0.11440671f, -0.27394438f, -0.54201925f, -0.33292472f, 0.23200257f, 
    -0.24506614f, 0.10508438f, -0.22407994f, 0.35482490f, 0.43380684f, -0.46271440f, 0.43230310f, -0.05114695f, 
    -0.20083585f, -0.11922955f, -0.06796146f, -0.04556410f, -0.12838435f, -0.32530314f, 0.13614680f, -0.48032230f, 
    -0.03079089f, -0.04765916f, -0.42849952f, 0.04128958f, -0.66840887f, -0.20094687f, 0.11376877f, 0.21726993f, 
    -0.02037839f, -0.01489524f, -0.21479331f, 0.02610620f, -0.10851479f, -0.23754966f, 0.18847796f, 0.01119039f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.18220860f, -0.03301140f, 0.04956241f, 0.00431503f, 0.08832651f, 0.01646090f, 0.11991092f, -0.12911540f, 
    -0.16643476f, -0.02962284f, 0.13866392f, -0.05660873f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
