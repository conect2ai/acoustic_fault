#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.51212949f, 0.22501555f, 0.60696131f, 0.35556516f, -0.26189321f, -0.25066227f, 0.23533621f, 0.25752541f, 
    0.26846448f, -0.46222574f, -0.50674933f, -0.19428994f, 0.25683320f, -0.43865344f, 0.43910292f, 0.15325500f, 
    -0.31085640f, -0.05337998f, -0.16597639f, -0.53935444f, -0.14008963f, -0.65004295f, 0.53459382f, -0.33952415f, 
    0.27088401f, 0.45728642f, 0.07363492f, 0.11531442f, 0.34430632f, 0.55553770f, 0.35948968f, -0.36053541f, 
    0.47069505f, 0.40255153f, -0.26950732f, -0.11775055f, -0.77450085f, -0.13541558f, 0.04303399f, 0.24795993f, 
    0.69041789f, -0.15421265f, -0.05489266f, -0.06016827f, -0.24056280f, -0.25722557f, -0.49806681f, -0.28267893f, 
    -0.43831724f, 0.09474108f, -0.60179025f, -0.32194296f, -0.34474069f, -0.19418359f, -0.08741601f, -0.04461830f, 
    -0.49975228f, -0.11552564f, 0.63206625f, 0.33596924f, 0.16622949f, -0.54095864f, 0.31198683f, 0.31618404f, 
    0.64931297f, -0.19877996f, 0.47547162f, 0.01295014f, 0.08309442f, 0.20152314f, 0.45907205f, 0.21224305f, 
    0.21605960f, 0.47821844f, -0.11679877f, -0.63653874f, -0.61574125f, -0.59188557f, 0.22966807f, -0.02045676f, 
    -0.14321613f, -0.60100108f, -0.24197960f, 0.06393412f, 0.40890011f, 0.51379460f, 0.70782870f, 0.16026589f, 
    0.13498293f, 0.16538858f, 0.04772130f, 0.36464050f, -0.07160606f, -0.26244095f, -0.92760754f, 0.17886426f, 
    -0.38735238f, 0.16038544f, -0.19920748f, 0.35864305f, 0.54038453f, 0.28576672f, 0.04192125f, 0.46717671f, 
    0.40874213f, -0.27660036f, 0.46492288f, 0.33746797f, 0.44345149f, 0.65123397f, 0.65159458f, 0.25759804f, 
    0.06822456f, -0.05194645f, -0.10394262f, -0.12387139f, -0.02304447f, -0.57388753f, -0.02460573f, 0.78341228f, 
    -0.23610930f, -0.09675001f, 0.37486213f, 0.07672302f, 0.00939264f, 0.18504414f, 0.61811954f, 0.49937618f, 
    0.53593981f, -0.52546674f, 0.18969388f, -0.28891322f, 0.15568280f, -0.08034320f, 0.16793865f, -0.57530624f, 
    -0.71360910f, -0.76802212f, 0.13953450f, 0.05665725f, 0.19032542f, -0.28030792f, 0.20712741f, 0.02180330f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.07400472f, -0.03861206f, -0.06818427f, -0.21649703f, -0.18660408f, 0.16341062f, 0.14870778f, -0.34871987f, 
    -0.15056120f, -0.25512215f, -0.06801947f, -0.29543409f, 0.00912184f, -0.14037271f, -0.15232532f, 0.05795940f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.26377630f, -0.02136453f, 0.28522438f, -0.04336326f, -0.04706471f, -0.13083240f, 0.08261478f, -0.02595557f, 
    0.14045347f, 0.04490736f, 0.35129717f, -0.33369726f, -0.04039985f, -0.10875206f, -0.00596346f, 0.12140672f, 
    -0.13708459f, -0.06328778f, -0.27725902f, -0.23355828f, -0.25653529f, 0.05718781f, 0.13769618f, 0.04338981f, 
    0.02629501f, -0.05201387f, -0.08847871f, 0.00564665f, 0.08807489f, 0.15122914f, -0.03359257f, 0.03835985f, 
    0.05847002f, -0.09460590f, 0.14172961f, -0.07419404f, -0.21420531f, -0.12194446f, -0.20330492f, -0.04455091f, 
    -0.03822729f, 0.02411812f, 0.04715455f, -0.07095157f, -0.07485656f, 0.02109828f, -0.20888945f, -0.25404352f, 
    0.08547664f, 0.05529474f, 0.21755145f, 0.00447635f, 0.17563702f, -0.06992522f, 0.37917829f, -0.26306924f, 
    0.04049991f, 0.19070020f, -0.02800772f, 0.00031283f, 0.20100228f, 0.07611626f, -0.02908282f, -0.01661425f, 
    -0.22212039f, -0.04382697f, 0.00606801f, 0.00731493f, 0.01366887f, -0.08507801f, 0.00612540f, -0.05683410f, 
    -0.10707113f, -0.08023460f, -0.14519267f, -0.00859527f, 0.01711177f, 0.14276838f, -0.13390222f, 0.05332221f, 
    0.21372828f, -0.01645445f, 0.06077432f, -0.19684030f, 0.09743849f, 0.06457991f, 0.05277620f, -0.02412225f, 
    -0.09186800f, 0.03778728f, -0.13762657f, 0.20360744f, 0.00316586f, -0.20881943f, 0.05707401f, 0.00085439f, 
    0.07426116f, -0.01262021f, 0.14721738f, -0.12617370f, 0.36294633f, -0.00252484f, 0.15914983f, -0.18539642f, 
    0.04353052f, 0.00354374f, -0.03991076f, 0.02233144f, 0.04489330f, 0.04566452f, 0.26342389f, -0.06151927f, 
    0.09222302f, -0.03153092f, -0.02017228f, 0.06613769f, 0.02838117f, -0.31996843f, -0.33234236f, -0.34116766f, 
    -0.04998639f, -0.09373609f, -0.05811128f, -0.26395866f, -0.09969801f, -0.04331623f, 0.23086445f, 0.09132337f, 
    0.16175605f, -0.06992596f, 0.08547699f, 0.09271832f, 0.04924595f, -0.02371948f, -0.04688526f, 0.19482772f, 
    0.00957305f, -0.08238446f, 0.12175164f, 0.11476520f, -0.18127164f, -0.02426937f, 0.00376103f, 0.01098818f, 
    0.12715530f, -0.00175571f, 0.25321630f, 0.14285251f, -0.11755297f, 0.04704030f, -0.00584414f, 0.05436882f, 
    -0.04739541f, -0.25714400f, 0.35044256f, -0.39936674f, -0.00007154f, 0.15910330f, 0.04346929f, 0.02074501f, 
    -0.11291461f, 0.02610618f, -0.03298539f, -0.40146762f, -0.14597006f, 0.06034955f, 0.06162324f, -0.00358480f, 
    0.08495901f, 0.02025284f, -0.00301184f, -0.32650378f, 0.09253316f, 0.04476823f, 0.17050180f, 0.15145054f, 
    0.05313694f, -0.10391836f, 0.05456348f, 0.06968180f, 0.26434433f, 0.04562169f, 0.17873725f, -0.16199039f, 
    -0.02408098f, -0.01772933f, -0.04080353f, -0.01564422f, -0.19624174f, -0.35101297f, -0.11267463f, 0.21171844f, 
    0.01662371f, 0.11663248f, -0.00505068f, 0.07352910f, 0.03301580f, -0.22928801f, 0.14636850f, 0.37899882f, 
    -0.29653758f, 0.01494501f, 0.09692531f, -0.15519287f, -0.01968836f, 0.09719570f, -0.10455883f, 0.07793347f, 
    -0.13158916f, 0.01006696f, -0.13937256f, 0.06907345f, -0.06505684f, -0.12524816f, -0.02693453f, 0.12053588f, 
    0.14595361f, -0.02990723f, -0.01749930f, 0.00013495f, 0.05044498f, 0.06633068f, 0.00664522f, -0.03490005f, 
    0.09090900f, -0.11489496f, 0.31751186f, -0.04467884f, -0.00673217f, 0.02943528f, -0.12339552f, 0.08671189f, 
    -0.02984418f, 0.01498937f, 0.18327601f, 0.04292994f, 0.10081581f, 0.08864249f, -0.24154431f, 0.02825171f, 
    0.08781081f, -0.03095348f, 0.20698008f, 0.08275939f, 0.42952022f, -0.30813804f, 0.13956422f, -0.00085485f, 
    0.04308095f, 0.03595170f, -0.08581469f, -0.00575278f, 0.06646115f, 0.14281529f, 0.23201670f, -0.16445538f, 
    0.08358861f, 0.18183477f, -0.02347765f, 0.10786188f, 0.01029489f, -0.79191285f, -0.15226875f, 0.04630007f, 
    -0.13544710f, -0.03700189f, -0.01116777f, -0.15732752f, 0.12958156f, -0.11174325f, 0.49059564f, 0.06621005f, 
    -0.19292869f, -0.07822051f, -0.09435719f, 0.09256909f, -0.06288552f, -0.03254799f, 0.01324211f, -0.06262276f, 
    0.12384340f, -0.59966362f, -0.08848073f, 0.07550770f, -0.02470356f, 0.01339002f, 0.06528834f, 0.01501221f, 
    0.03297018f, -0.06925043f, 0.01505806f, 0.02257676f, -0.08593255f, -0.04128940f, -0.04244580f, -0.01545379f, 
    -0.05592572f, -0.06547756f, -0.07982071f, 0.01686333f, -0.02522891f, 0.05505573f, 0.03266585f, 0.06240647f, 
    0.07001132f, 0.05165733f, 0.03174840f, 0.00455784f, -0.06418476f, -0.07374586f, 0.03335197f, -0.00102174f, 
    -0.04442883f, 0.00564362f, 0.01414622f, -0.07168573f, 0.05470700f, -0.00543372f, 0.03586496f, -0.04077805f, 
    -0.07963465f, -0.05520352f, 0.00575783f, -0.02269703f, 0.01861249f, 0.03404814f, 0.03953817f, -0.08387308f, 
    -0.01615494f, -0.07215489f, 0.04480899f, 0.00083075f, -0.08154948f, 0.08071820f, -0.07835852f, -0.05562377f, 
    -0.06003483f, 0.04859806f, 0.04519960f, -0.06220469f, -0.08922736f, 0.03992077f, -0.05243075f, -0.03027172f, 
    -0.07046859f, -0.00429393f, -0.03827199f, 0.05599557f, 0.04330224f, 0.05955781f, -0.08257756f, 0.06753784f, 
    -0.08529153f, -0.00257358f, 0.02100710f, -0.06049147f, -0.04140440f, 0.00011285f, 0.02536035f, 0.04874659f, 
    -0.06829142f, -0.04776135f, -0.07488620f, 0.01365332f, -0.08409979f, -0.06330319f, -0.00454881f, 0.04949628f, 
    -0.09213344f, -0.04334077f, -0.01746850f, -0.02484200f, -0.08487026f, -0.03212718f, 0.02299589f, -0.06769665f, 
    -0.04471533f, 0.04651500f, 0.06596570f, 0.03422048f, -0.05964050f, -0.03126995f, 0.03580617f, -0.07302690f, 
    0.04238550f, 0.03639868f, 0.05009207f, -0.07933564f, -0.04982108f, -0.01766237f, -0.03174379f, 0.03402887f, 
    0.00996267f, -0.08798027f, 0.07851130f, -0.06556977f, 0.04854914f, -0.01695508f, 0.01728611f, -0.02002168f, 
    0.02378880f, 0.06153576f, 0.07850347f, -0.05886004f, 0.03921167f, 0.02647751f, -0.05878866f, -0.02527284f, 
    0.04274532f, -0.02060283f, 0.04788702f, 0.02098572f, 0.02099347f, -0.07247704f, 0.02423146f, 0.04225525f, 
    -0.02821562f, -0.05765190f, 0.00365277f, 0.03691051f, -0.04842154f, -0.05739078f, 0.05859824f, -0.03001864f, 
    -0.07267088f, -0.04041087f, 0.03846399f, -0.07464697f, -0.06116040f, -0.07000108f, 0.03641694f, -0.06839240f, 
    0.21858868f, 0.09279975f, -0.04048610f, -0.10353324f, 0.06184959f, -0.13726057f, -0.11343640f, 0.11807764f, 
    0.13173741f, 0.08575976f, 0.06397283f, 0.21542767f, -0.03652293f, -0.15116656f, 0.18781452f, 0.25375468f, 
    -0.07558849f, 0.04275038f, -0.04930600f, -0.14633478f, -0.18747185f, 0.07010246f, 0.07142285f, 0.03763281f, 
    -0.00269662f, 0.01432502f, 0.14763378f, -0.22849151f, 0.16312344f, 0.24966486f, 0.07736779f, 0.03922913f, 
    -0.05919623f, -0.07925244f, -0.03816149f, -0.09263258f, 0.07189082f, -0.06035069f, -0.01399067f, -0.06445871f, 
    0.00296893f, 0.15826708f, -0.00535415f, -0.01993895f, -0.07566948f, -0.12016279f, -0.12736544f, -0.05806011f, 
    -0.00719488f, 0.05567554f, -0.02529589f, -0.18289813f, 0.01859602f, -0.01113537f, 0.15006872f, 0.02915588f, 
    -0.08133266f, -0.07178470f, 0.00890477f, -0.07470813f, 0.07005985f, -0.01669821f, 0.03048020f, -0.08718685f, 
    0.37259015f, -0.35935295f, -0.11984910f, -0.43962681f, -0.02121505f, 0.13139476f, -0.10682997f, 0.15325622f, 
    -0.10325661f, -0.32875070f, -0.43289924f, 0.14677601f, -0.07794531f, -0.07463710f, -0.06260825f, -0.00814780f, 
    -0.06599149f, 0.20733041f, -0.01629273f, 0.35110000f, 0.07128201f, 0.23941049f, 0.07463877f, -0.03368318f, 
    -0.05501632f, -0.02865070f, -0.26937217f, -0.25609514f, -0.25691953f, 0.00795364f, 0.01056858f, -0.06516325f, 
    0.18761975f, 0.13261288f, -0.14911951f, 0.15916362f, -0.41925535f, 0.14141859f, 0.10805502f, -0.09480603f, 
    -0.17442010f, -0.00358712f, 0.20312858f, 0.03999455f, -0.11586441f, 0.01588145f, 0.04131528f, -0.00169473f, 
    0.00242044f, -0.01093496f, 0.11966649f, -0.08472139f, -0.10714914f, -0.15884696f, -0.08966212f, 0.18163888f, 
    -0.27038568f, -0.07672327f, -0.05747166f, 0.04401169f, 0.00599070f, 0.13110092f, -0.06879265f, -0.09489708f, 
    -0.36898249f, 0.21862161f, 0.15194382f, 0.05097258f, -0.13615471f, -0.12762026f, 0.01176757f, 0.15802874f, 
    0.39650792f, 0.20868510f, -0.04923057f, -0.01519981f, -0.17067149f, -0.01054904f, 0.16274002f, 0.04145693f, 
    0.25502682f, 0.19498032f, -0.28501055f, 0.02005425f, -0.04317013f, -0.10122854f, 0.02559683f, 0.01619447f, 
    0.02186583f, 0.26854444f, -0.04008901f, -0.00077060f, 0.01746724f, -0.06201436f, -0.05839065f, -0.07947788f, 
    0.20256102f, 0.05779783f, -0.32206485f, 0.10536088f, -0.26712909f, 0.10509396f, 0.06893095f, 0.10260890f, 
    0.04454882f, -0.01663137f, 0.03654586f, -0.02293866f, 0.36385348f, -0.01081528f, -0.01414571f, -0.00973846f, 
    0.02743919f, 0.10794228f, -0.00423868f, 0.05153360f, -0.25174004f, -0.34286964f, -0.01219193f, -0.14368442f, 
    -0.12140916f, -0.10561305f, 0.19098674f, -0.02734862f, -0.03248209f, -0.21356405f, -0.13526367f, 0.08422532f, 
    -0.01313548f, -0.04338958f, 0.16642198f, 0.02627921f, -0.14168432f, 0.25064349f, 0.25574714f, -0.17391564f, 
    0.08645242f, -0.14241728f, 0.04936497f, 0.13007526f, -0.10901388f, 0.26034406f, 0.03454020f, 0.10107458f, 
    0.29881051f, -0.08746742f, -0.07354726f, 0.00920593f, -0.15637822f, -0.01150876f, 0.06690241f, -0.07925514f, 
    -0.20647876f, 0.11643382f, -0.24931313f, 0.02122360f, 0.16080597f, -0.14586233f, 0.05312460f, 0.10650835f, 
    -0.06947955f, 0.14677227f, -0.38258299f, 0.25355223f, -0.07736713f, 0.11248177f, 0.07281984f, -0.05290479f, 
    -0.06486177f, -0.04632151f, -0.05891775f, -0.38601056f, -0.01062367f, -0.04432381f, 0.06909870f, -0.07095371f, 
    0.19465706f, 0.04701250f, 0.14266691f, 0.21188384f, 0.09604993f, -0.02404849f, 0.02414366f, -0.12066104f, 
    0.04924772f, 0.14855531f, 0.17444742f, 0.03239637f, -0.22867924f, 0.19726364f, -0.07723763f, -0.06566457f, 
    -0.02774424f, 0.09653890f, -0.04623887f, 0.01738519f, 0.08483847f, 0.03905268f, 0.31487226f, -0.02279039f, 
    -0.15687360f, 0.25024641f, -0.27692175f, -0.05943384f, -0.01274829f, -0.01098952f, -0.02252705f, -0.10035813f, 
    -0.11646309f, 0.11323502f, -0.08727617f, 0.09510400f, 0.00318106f, -0.11599080f, 0.16843110f, -0.28541291f, 
    0.06865627f, 0.30503100f, -0.00696237f, -0.06784069f, -0.03843524f, -0.00349578f, -0.02994951f, -0.10018484f, 
    -0.26366347f, -0.18209806f, 0.14072880f, 0.04711812f, 0.15359639f, 0.02486837f, -0.09488600f, 0.09757344f, 
    -0.00855371f, -0.20265388f, 0.11474988f, 0.11620002f, -0.06404666f, 0.15318729f, -0.02305334f, 0.04865563f, 
    -0.16699561f, -0.11572235f, 0.40181276f, -0.07848975f, -0.08684088f, -0.09508517f, 0.02216414f, -0.03856649f, 
    -0.11069434f, -0.00863996f, -0.09869736f, -0.19785371f, 0.14849928f, -0.26012346f, -0.00462580f, 0.07202171f, 
    -0.03140976f, -0.06622954f, -0.18380800f, 0.11719612f, 0.32908657f, 0.02551245f, -0.12106763f, 0.02603921f, 
    -0.01296982f, -0.03864286f, -0.01777621f, -0.06531584f, 0.00178769f, -0.15920720f, -0.06037218f, -0.29808185f, 
    0.15111250f, 0.11493782f, -0.07934682f, -0.06460649f, -0.08963192f, -0.03709947f, 0.08534092f, 0.09870470f, 
    -0.06710951f, -0.04101908f, -0.26390341f, 0.05289099f, 0.16161568f, -0.02319072f, -0.08448832f, -0.15792570f, 
    -0.20137809f, 0.14463161f, 0.03716569f, 0.10147844f, 0.13503827f, -0.08891419f, -0.00197691f, 0.01857210f, 
    0.29800254f, 0.02631453f, 0.02491778f, -0.04975934f, 0.09920554f, -0.05195720f, -0.21901639f, 0.00631053f, 
    -0.10779796f, 0.31039122f, 0.17441738f, 0.20187569f, -0.13771398f, -0.05334933f, -0.06056300f, -0.00556496f, 
    0.12039160f, 0.10211816f, -0.40732437f, 0.10480043f, -0.03001514f, -0.02514477f, -0.03803902f, 0.10976382f, 
    -0.07342026f, 0.06988264f, 0.06014306f, -0.14845186f, -0.03862403f, 0.08280463f, -0.15581049f, 0.19883369f, 
    -0.00241304f, -0.08767891f, -0.03080362f, 0.16076267f, 0.00552709f, -0.24291560f, 0.05925804f, 0.07495071f, 
    0.20613836f, 0.07493313f, 0.03232207f, -0.03401595f, -0.00280440f, 0.42423391f, -0.08348191f, -0.31681779f, 
    -0.23600423f, -0.00596327f, -0.00068566f, -0.11879354f, 0.07599144f, -0.12220717f, 0.03883240f, 0.38042504f, 
    0.06316286f, 0.16727248f, 0.14370807f, 0.12203258f, -0.04284016f, -0.09581156f, -0.01777940f, 0.19869517f, 
    -0.09530776f, 0.05198469f, -0.10212787f, -0.07355004f, 0.14312993f, 0.02899293f, -0.06912008f, 0.10141279f, 
    0.23141305f, 0.05197044f, -0.09139106f, 0.18020432f, 0.08475199f, 0.00638488f, -0.03634971f, -0.05396627f, 
    -0.20517607f, -0.19673690f, -0.02838121f, -0.13578267f, -0.05018699f, -0.02002342f, 0.16654898f, -0.04287233f, 
    0.03157436f, 0.17880422f, -0.18436015f, 0.02015873f, -0.05205769f, 0.07501139f, 0.14139786f, 0.07678322f, 
    0.07587981f, 0.06628065f, -0.08838224f, 0.15670456f, -0.23448890f, -0.01145204f, 0.11986324f, 0.27421874f, 
    0.11694781f, -0.04960567f, 0.06027818f, 0.01670201f, -0.53854150f, -0.17708296f, -0.01325692f, -0.06859424f, 
    0.06854605f, -0.01589598f, -0.06535090f, -0.00514050f, 0.07879209f, 0.03950099f, -0.10919160f, -0.07783656f, 
    0.05102938f, -0.03803980f, 0.14862098f, 0.05018262f, -0.07073945f, 0.03740613f, -0.18381487f, -0.04856065f, 
    0.32135046f, -0.07974236f, -0.04204746f, 0.17537220f, -0.07709847f, -0.02722638f, -0.06356822f, -0.03415263f, 
    -0.11471881f, 0.12746873f, 0.41281900f, 0.30016881f, 0.00254119f, -0.02085101f, -0.15217313f, -0.08333977f, 
    0.32648131f, 0.02138442f, -0.33760273f, 0.05022319f, 0.00442143f, -0.10320774f, 0.10670545f, 0.08778207f, 
    0.04217881f, -0.53740859f, -0.04085139f, -0.09662222f, 0.12469102f, 0.02584953f, 0.21659465f, -0.08411971f, 
    0.14740647f, 0.00371021f, -0.07593843f, -0.00248321f, -0.21894085f, 0.02396065f, -0.10397612f, -0.06171589f, 
    0.06590030f, -0.09370123f, 0.17945832f, 0.14827427f, -0.01128935f, 0.14359622f, -0.11874819f, -0.03952994f, 
    0.08337537f, 0.01046017f, -0.13666521f, -0.08536820f, 0.36514160f, 0.09419329f, 0.03965589f, 0.06543414f, 
    -0.04120892f, -0.02746809f, -0.07140870f, -0.03103661f, 0.11998279f, -0.33566514f, 0.17582047f, 0.18362156f, 
    -0.14022617f, 0.01277538f, -0.09074857f, 0.19825874f, -0.08381008f, 0.06657206f, 0.39580876f, 0.37366185f, 
    -0.08339215f, -0.06799773f, -0.12421396f, 0.01876922f, 0.05287321f, -0.01476663f, -0.03232032f, 0.09432811f, 
    0.10027160f, 0.06563990f, -0.10254195f, 0.09050994f, -0.06808967f, 0.07950582f, -0.10670986f, -0.09808007f, 
    0.24827424f, -0.11551856f, -0.15841205f, 0.06506964f, -0.15093459f, -0.08624301f, 0.07215726f, -0.06537186f, 
    0.00375283f, 0.14227641f, -0.19975966f, -0.07619929f, 0.03427646f, 0.04511720f, 0.03431315f, 0.19963396f, 
    0.22939450f, -0.20225385f, -0.05827766f, -0.01289941f, -0.10708237f, -0.08587865f, -0.12314963f, -0.10961297f, 
    0.06378184f, -0.02297896f, -0.16014199f, 0.00470114f, -0.41637769f, -0.09948120f, 0.11246438f, -0.02123755f, 
    -0.01488351f, 0.25165159f, -0.15840718f, -0.08249304f, -0.02592147f, 0.26168394f, -0.02994478f, 0.13779172f, 
    -0.28438354f, -0.14562576f, -0.11799572f, -0.11247051f, 0.04618727f, -0.10270353f, 0.09909882f, -0.00291441f, 
    0.03916395f, 0.03590595f, 0.08059854f, -0.21664335f, -0.04047013f, -0.23863837f, 0.10486753f, -0.05952100f, 
    -0.02652052f, 0.02836494f, 0.10972066f, -0.06612244f, 0.02011087f, -0.17412527f, 0.11172924f, 0.17320694f, 
    -0.10130341f, 0.30251509f, 0.09183704f, -0.08988266f, -0.12453963f, 0.13431427f, -0.02267255f, 0.01415734f, 
    0.13154054f, 0.21283871f, 0.14404683f, 0.04964625f, -0.19096819f, 0.19892816f, -0.10066862f, 0.07283477f, 
    -0.08328865f, -0.16665904f, -0.15156852f, 0.09805734f, 0.12774688f, 0.24489313f, -0.05026669f, -0.15044020f, 
    0.14607838f, 0.24124967f, 0.23780033f, 0.12697311f, 0.03315827f, -0.22329342f, 0.12065616f, -0.14097576f, 
    -0.11537346f, 0.02924227f, -0.03694508f, -0.26721665f, -0.08340276f, 0.09701063f, -0.03408379f, 0.00324231f, 
    0.01377822f, -0.01242592f, -0.05437821f, 0.00028155f, 0.26581708f, -0.28093112f, -0.21686076f, -0.15262426f, 
    0.06318695f, 0.02307602f, 0.15986876f, 0.01688899f, 0.25581709f, 0.38551962f, -0.00052674f, -0.27410305f, 
    0.08674780f, -0.08212040f, -0.10137162f, -0.14209440f, 0.13531044f, -0.02280628f, 0.20917247f, -0.05301748f, 
    -0.09984111f, 0.22077665f, 0.03446609f, 0.14532238f, 0.03481421f, 0.05014486f, 0.10256224f, 0.08783571f, 
    0.00412020f, 0.20569617f, 0.04761237f, 0.10303593f, -0.08500349f, -0.13456292f, -0.07003927f, 0.12334921f, 
    0.05660572f, -0.19192065f, 0.01045196f, 0.03006490f, -0.05962851f, -0.01549952f, -0.10519575f, 0.15832144f, 
    0.08577663f, -0.13187756f, -0.16661184f, -0.09354898f, 0.18399426f, 0.03038215f, -0.07811074f, 0.00473751f, 
    -0.01314241f, -0.01857412f, 0.21662039f, -0.14996967f, -0.03752337f, 0.13337180f, -0.11424478f, 0.12901029f, 
    -0.04133103f, 0.09328696f, -0.17566697f, -0.09548755f, -0.15075822f, 0.21102074f, 0.01841873f, 0.12269887f, 
    0.07835446f, 0.10290820f, 0.03803413f, 0.06181020f, 0.10736435f, -0.02155688f, -0.08525439f, -0.04188362f, 
    0.01154802f, 0.13278991f, 0.06485235f, 0.01453190f, -0.01139867f, -0.01452137f, -0.00372575f, 0.13261910f, 
    0.11459897f, -0.10757882f, -0.01590518f, 0.09203287f, -0.15727390f, 0.20305747f, -0.02972897f, -0.01963219f, 
    -0.28326288f, -0.09521760f, 0.15751331f, 0.14208412f, -0.04845135f, 0.00554392f, 0.03953486f, -0.02042661f, 
    -0.28213349f, -0.35337710f, -0.23611702f, -0.02938717f, -0.13168445f, 0.06294453f, -0.02905719f, -0.03623797f, 
    -0.12821206f, -0.00958961f, 0.10556807f, -0.15229794f, -0.09768568f, -0.29290304f, 0.16256055f, 0.02605347f, 
    0.06606141f, 0.15863158f, -0.15164669f, -0.20798106f, 0.12084283f, 0.09042269f, 0.10935265f, 0.00415340f, 
    -0.03805199f, 0.05103612f, -0.24699974f, 0.17938852f, 0.08393905f, -0.28414854f, 0.25140280f, -0.15047529f, 
    0.07115398f, 0.08808494f, -0.05025097f, -0.14192289f, 0.13686793f, -0.07497103f, 0.17640167f, 0.10936866f, 
    0.02242027f, 0.03319589f, -0.03623383f, -0.11104977f, 0.28960344f, 0.35359868f, 0.36147326f, 0.19886315f, 
    -0.07344139f, 0.15679763f, 0.35552078f, 0.00941676f, 0.08342840f, -0.16857253f, 0.05830740f, 0.07090390f, 
    0.00297912f, -0.09230275f, -0.06369859f, -0.14627260f, -0.14761743f, -0.10472628f, 0.01239269f, 0.13468227f, 
    0.23047608f, -0.15613459f, -0.14646323f, -0.14697301f, 0.01733778f, 0.07079869f, -0.01438997f, 0.12628697f, 
    -0.10010786f, 0.02305274f, 0.03293577f, 0.07184141f, 0.23799455f, 0.07850460f, -0.18881345f, 0.09370957f, 
    -0.01983332f, -0.07787322f, 0.04448754f, 0.01461998f, -0.06818811f, -0.11259323f, 0.01043676f, -0.03822483f, 
    0.00919843f, -0.10619974f, 0.04399177f, 0.00175787f, 0.00114475f, -0.09899221f, 0.01737492f, -0.08360256f, 
    -0.03844585f, -0.10567056f, 0.04271647f, -0.08824132f, -0.05425039f, -0.01960833f, -0.10399360f, -0.04567709f, 
    -0.09616875f, -0.08823569f, -0.00504309f, -0.09999473f, -0.07776405f, -0.01750941f, -0.01385159f, -0.10611434f, 
    0.00650383f, -0.03180975f, 0.00104709f, -0.03368142f, -0.08480826f, -0.03759737f, -0.09258343f, -0.01482550f, 
    -0.01205377f, -0.08960649f, -0.10311854f, -0.08560874f, -0.08729048f, -0.08185373f, -0.03273213f, -0.03329392f, 
    -0.05334803f, 0.01048434f, -0.09272508f, 0.01522536f, 0.06681877f, -0.08202628f, -0.11559735f, -0.01316546f, 
    0.03998144f, -0.02316629f, -0.08536771f, 0.01358832f, -0.11761360f, -0.02440764f, 0.02450499f, -0.05765546f, 
    -0.04457437f, 0.03092610f, -0.12346370f, -0.10804430f, -0.01206837f, 0.01401549f, 0.01811006f, -0.04536253f, 
    0.04001794f, -0.07562336f, -0.05280574f, -0.01559356f, -0.03213261f, -0.11995112f, 0.02953107f, -0.05278624f, 
    -0.06082914f, -0.05045269f, 0.01154351f, 0.02530638f, 0.03303219f, -0.03371130f, 0.01450202f, -0.08156413f, 
    -0.03462303f, -0.09204589f, -0.00838894f, -0.10672142f, 0.04419276f, -0.10644012f, -0.04905814f, 0.01524573f, 
    -0.10194146f, 0.01325675f, -0.02716344f, -0.00993644f, -0.06311238f, 0.01122873f, -0.03882607f, -0.08189149f, 
    -0.06439959f, -0.01292039f, -0.04291762f, -0.04257051f, -0.04932280f, 0.00695761f, -0.08298302f, -0.05997855f, 
    0.07351807f, -0.11239076f, -0.09660157f, -0.06660175f, -0.02112052f, 0.02431575f, 0.03667620f, -0.01727332f, 
    0.03680065f, -0.08179310f, 0.03299173f, 0.04926931f, -0.01484803f, -0.05082179f, -0.06210594f, -0.02231992f, 
    -0.02831945f, -0.09841046f, 0.03440099f, -0.10543432f, -0.09896100f, 0.03598501f, -0.05895886f, -0.07387035f, 
    0.01620975f, -0.08549272f, -0.10687501f, 0.02655196f, -0.01750055f, 0.04203351f, -0.06991503f, -0.02310646f, 
    0.11581929f, 0.21750976f, 0.04891695f, -0.08375236f, 0.05134357f, 0.04088239f, -0.06133287f, -0.11197938f, 
    -0.04245442f, -0.34277040f, -0.05768440f, -0.35495135f, 0.21432336f, 0.07162308f, 0.02780697f, 0.07940736f, 
    0.10594767f, -0.09382219f, -0.28511322f, -0.02106372f, 0.15713012f, 0.12223379f, 0.09200614f, 0.14544024f, 
    0.05915929f, -0.14795512f, -0.13195121f, 0.02866521f, -0.15257178f, 0.12337861f, -0.10939275f, 0.08978410f, 
    0.03828949f, 0.30489945f, 0.15823747f, 0.12677999f, -0.06786185f, -0.26969159f, 0.03891688f, 0.09567818f, 
    0.13037769f, -0.04701101f, -0.07922599f, -0.09682193f, -0.13369650f, -0.05216098f, 0.11360787f, -0.15445134f, 
    0.06163609f, -0.04252008f, 0.24456249f, -0.02613904f, 0.03237588f, -0.09406818f, -0.02847309f, -0.19456591f, 
    0.00688461f, 0.02346353f, -0.09928328f, -0.02146940f, 0.10308760f, 0.07714808f, -0.08906712f, -0.13623722f, 
    0.18946974f, -0.04628618f, -0.16531186f, 0.03820377f, -0.08813874f, 0.04407991f, 0.04468012f, -0.05051236f, 
    0.11969133f, 0.16141859f, 0.15658300f, 0.01273047f, 0.00717990f, 0.09497347f, 0.04986573f, 0.01178021f, 
    0.04443140f, 0.01198422f, -0.35582545f, -0.12214378f, 0.07433418f, 0.15637627f, 0.04749750f, 0.03023716f, 
    -0.27618781f, 0.05765697f, -0.07141639f, -0.05778936f, -0.02663634f, -0.02934718f, 0.08648101f, 0.01792384f, 
    -0.08601540f, 0.12655267f, 0.09041978f, -0.15785168f, -0.01710954f, 0.05946023f, -0.05071215f, -0.15190648f, 
    -0.00122220f, 0.20553458f, -0.00012840f, 0.13039003f, -0.12922262f, 0.28419676f, 0.27462474f, 0.25015217f, 
    -0.14357665f, -0.15865850f, -0.05671251f, 0.21922845f, 0.01860385f, -0.00674245f, -0.49584913f, -0.20854004f, 
    -0.08536749f, -0.20416166f, 0.06610501f, 0.06694269f, -0.09968781f, 0.21149012f, 0.17259212f, 0.24209832f, 
    0.17966801f, 0.05403134f, -0.06560857f, -0.01030650f, -0.11391033f, -0.03209228f, 0.11424228f, -0.46250045f, 
    -0.08798525f, -0.16156127f, 0.11050976f, -0.00894337f, 0.02125290f, -0.14640006f, 0.13654390f, -0.07998853f, 
    -0.05946422f, 0.09652830f, 0.10506461f, -0.18463831f, -0.16308303f, 0.07189143f, -0.13899192f, -0.12030140f, 
    -0.15195239f, 0.06982291f, 0.00958752f, 0.08277623f, 0.02475918f, 0.07709130f, 0.06296715f, 0.05725159f, 
    -0.04185408f, 0.03545120f, 0.15305318f, 0.03085485f, 0.17540602f, -0.13303693f, -0.03772794f, -0.20045106f, 
    0.06686241f, -0.16105796f, -0.13056882f, 0.09159818f, -0.20505998f, -0.19938582f, 0.03672215f, 0.14262326f, 
    -0.08930439f, -0.16114596f, -0.12628177f, 0.08124133f, 0.10630628f, 0.40398040f, 0.11569060f, 0.12109932f, 
    0.13429810f, 0.13745494f, -0.08814359f, 0.27956629f, 0.09051389f, 0.20526305f, -0.03349939f, 0.25033164f, 
    0.00881909f, -0.26922992f, 0.10796311f, -0.05029594f, 0.07279666f, -0.00185530f, 0.00592644f, -0.02157979f, 
    0.02595384f, -0.15226357f, 0.07829911f, -0.00283151f, -0.05212975f, -0.17984550f, -0.14428766f, 0.17342402f, 
    0.08136907f, -0.05722433f, -0.09607265f, 0.04844325f, -0.02008671f, 0.26559100f, 0.06773928f, 0.10854332f, 
    -0.30458733f, -0.20257488f, -0.19079715f, -0.00145722f, 0.13531186f, -0.18739425f, -0.11132222f, 0.03426956f, 
    -0.09558222f, 0.17201962f, -0.20252119f, 0.10584800f, 0.11085186f, -0.02706412f, -0.02725152f, 0.00944539f, 
    0.06531037f, 0.06770686f, 0.24803136f, 0.05157768f, -0.04555170f, 0.03940441f, -0.03724900f, -0.16610686f, 
    0.00187330f, 0.13285756f, 0.13213941f, -0.08826898f, -0.08153803f, 0.15769720f, 0.06130590f, 0.17435078f, 
    -0.00182189f, -0.10899127f, 0.01958626f, 0.01845559f, 0.05526778f, 0.10018148f, 0.15077138f, 0.01923257f, 
    -0.17399344f, 0.06923011f, -0.06862279f, 0.25803870f, -0.00678403f, 0.26229033f, -0.07541335f, -0.15872571f, 
    0.01742865f, -0.16860831f, -0.02328041f, -0.01823861f, -0.18691812f, -0.14883897f, -0.21376108f, 0.02341699f, 
    0.07562640f, -0.00944776f, 0.03727047f, -0.06757865f, -0.02879320f, -0.13523358f, 0.00796664f, 0.26603940f, 
    -0.02484850f, 0.39492980f, 0.08375959f, 0.06533583f, 0.13521135f, 0.02477527f, 0.07496710f, 0.09700529f, 
    -0.24921374f, -0.37721953f, 0.15788092f, 0.09894479f, 0.11438343f, 0.16786426f, 0.04826094f, 0.02650307f, 
    -0.08676898f, 0.20589171f, 0.13690494f, -0.16629815f, -0.00417218f, -0.09526041f, 0.07419413f, -0.04314116f, 
    0.00319912f, 0.15207434f, 0.08084284f, 0.01453938f, -0.13321485f, -0.05148723f, -0.11408941f, -0.05701494f, 
    0.14039475f, 0.13104378f, -0.07267247f, -0.30865690f, -0.28880724f, -0.04714341f, 0.24027653f, -0.02577109f, 
    0.08601470f, -0.02372893f, -0.07949050f, 0.00613370f, 0.00232521f, 0.09127159f, 0.20678297f, -0.04603235f, 
    -0.07551102f, -0.00702004f, -0.08124046f, 0.24908918f, -0.07122047f, -0.11875829f, 0.29187664f, 0.07248241f, 
    0.09302881f, -0.01817613f, 0.14388889f, -0.00349045f, 0.00262483f, -0.18745679f, 0.06091045f, 0.15310687f, 
    -0.12559830f, -0.01123222f, -0.01365528f, 0.06231103f, 0.01560882f, 0.10048893f, 0.02500837f, 0.35933247f, 
    -0.15075646f, -0.02905875f, -0.15949856f, -0.14307031f, 0.14002720f, 0.09095643f, 0.16841941f, 0.31509805f, 
    0.25137222f, 0.05143797f, -0.06258891f, -0.14654562f, -0.01193644f, 0.02911080f, -0.17902829f, 0.04147447f, 
    -0.16743742f, -0.08072314f, 0.16151235f, 0.03187419f, 0.09935623f, 0.03233656f, -0.14693369f, 0.15254723f, 
    -0.06047933f, 0.13524926f, 0.06366170f, -0.37775445f, 0.15057808f, -0.00558498f, -0.13811283f, -0.05567183f, 
    0.27759391f, -0.15626141f, 0.08825511f, -0.25018939f, -0.23082016f, -0.03200706f, 0.05018321f, 0.02341966f, 
    0.08056097f, 0.09412997f, 0.07596731f, -0.02582389f, -0.06619485f, -0.25900868f, -0.11472332f, 0.03930253f, 
    0.09160723f, 0.07831811f, -0.03287700f, -0.03277855f, -0.03987089f, -0.21000822f, 0.10993266f, 0.12130166f, 
    -0.07418559f, -0.23663728f, -0.16085379f, -0.03678600f, 0.07706067f, 0.07361522f, -0.19554813f, -0.47551829f, 
    0.20933808f, 0.11031248f, 0.20359944f, 0.15847097f, -0.12474885f, -0.05206294f, -0.02233931f, 0.13926987f, 
    0.13948262f, -0.03979371f, -0.06625769f, -0.10547780f, -0.13369520f, -0.13266832f, 0.20370059f, 0.03483051f, 
    -0.11184376f, -0.06963728f, -0.05842502f, -0.00101056f, -0.07346641f, -0.06688015f, -0.08682636f, -0.08050302f, 
    -0.06948603f, -0.09823761f, -0.09562377f, -0.11105277f, 0.01998243f, 0.00085956f, -0.10706775f, -0.01022626f, 
    -0.08642650f, -0.01661593f, -0.03880298f, -0.10092184f, -0.01111717f, 0.03044272f, -0.06369407f, -0.10829806f, 
    -0.07596993f, 0.03302625f, 0.00478388f, -0.08282654f, -0.10815393f, 0.04359177f, 0.00886363f, 0.00126588f, 
    0.02222827f, -0.11009098f, -0.01024157f, -0.00717232f, 0.04689476f, -0.10127623f, 0.01103335f, -0.11667342f, 
    -0.09951744f, -0.06244938f, 0.00354795f, -0.02063130f, -0.08723499f, -0.01069070f, -0.02301317f, -0.06674791f, 
    -0.00583902f, -0.08557718f, -0.02272338f, -0.06880035f, 0.03733870f, -0.11362574f, 0.02252825f, -0.02251304f, 
    -0.03365010f, -0.08327246f, 0.03350315f, -0.01059473f, -0.09089518f, 0.02079006f, -0.10663273f, 0.03186515f, 
    -0.08101929f, -0.11867099f, -0.05675005f, 0.01136056f, 0.04590703f, -0.01989417f, -0.04965121f, -0.01690666f, 
    -0.06349617f, -0.06359513f, -0.10883823f, -0.08404583f, -0.03591603f, -0.08752429f, 0.03801350f, -0.01418982f, 
    0.01776050f, 0.02482277f, -0.08537815f, 0.04165775f, -0.11781691f, -0.09870674f, -0.03109921f, 0.04661953f, 
    -0.07078873f, -0.04666087f, -0.01745047f, 0.00860767f, -0.02021093f, -0.11965299f, -0.06282621f, -0.01928210f, 
    0.02741660f, -0.10192257f, -0.03608267f, 0.00699988f, -0.08803997f, 0.04264028f, -0.04742938f, -0.03845221f, 
    0.00738080f, -0.03378252f, -0.10392487f, -0.10747183f, 0.02155064f, -0.06327882f, -0.09946825f, -0.00248813f, 
    -0.06358864f, -0.08664782f, -0.07497752f, -0.05522178f, 0.00885073f, 0.01561358f, -0.06248291f, -0.09251180f, 
    -0.00244787f, -0.05348061f, 0.01209067f, 0.04397951f, -0.02602696f, 0.04155148f, -0.09969325f, 0.03673643f, 
    -0.03426722f, -0.08053625f, -0.06562158f, -0.11069060f, 0.01702637f, -0.04620940f, 0.00183498f, -0.06959902f, 
    -0.05562967f, -0.05959098f, -0.02929565f, 0.01956943f, 0.03922379f, 0.03096236f, -0.10101695f, -0.05936883f, 
    -0.25302944f, -0.13540474f, -0.26750889f, -0.02339933f, -0.07892915f, 0.02833929f, -0.20210204f, 0.02852826f, 
    -0.06702721f, 0.18069381f, -0.08581358f, -0.04181308f, -0.27948815f, 0.13553545f, -0.01232309f, -0.01743813f, 
    0.12956390f, 0.08015936f, 0.07586028f, 0.08404074f, -0.03693660f, 0.05879800f, -0.10513080f, -0.21590570f, 
    -0.09300992f, 0.15394540f, 0.06223537f, -0.12394656f, -0.19926779f, 0.01680901f, 0.18115413f, 0.20075887f, 
    0.06215590f, 0.14836225f, -0.03155868f, -0.23169333f, 0.13327748f, 0.00054719f, -0.05866003f, -0.22260159f, 
    -0.14835085f, 0.18359153f, 0.06221172f, -0.01437639f, 0.03265349f, -0.13629009f, 0.02559780f, 0.22318979f, 
    0.05848733f, -0.00853313f, -0.13375670f, 0.02654586f, 0.05490620f, 0.17605390f, 0.05099342f, -0.07106983f, 
    0.13759689f, 0.18683468f, 0.03063798f, 0.02621816f, 0.05194619f, 0.02956122f, -0.08421962f, -0.16578951f, 
    -0.08232176f, -0.13905549f, -0.14969230f, 0.08358975f, -0.08288159f, -0.14828682f, 0.07728645f, -0.22369313f, 
    0.23386990f, -0.00697097f, 0.13087648f, 0.33080599f, 0.01532412f, -0.02431304f, 0.00281359f, 0.13900760f, 
    0.21412344f, 0.14986114f, 0.02879183f, -0.14050315f, 0.04260688f, -0.04966891f, 0.06116480f, 0.10810389f, 
    0.12963505f, -0.05323780f, 0.02738592f, 0.05998345f, -0.02359934f, 0.20023772f, 0.05279190f, 0.11825219f, 
    0.08655480f, -0.10848835f, -0.14075792f, -0.41361052f, -0.15107156f, 0.10301155f, 0.13026166f, 0.01918354f, 
    -0.08768246f, 0.15494688f, -0.03956049f, -0.14732735f, -0.06959836f, -0.16738902f, -0.09550755f, 0.06680655f, 
    0.08509057f, 0.15964830f, -0.03480892f, -0.04689665f, -0.11642626f, 0.03938961f, 0.21630886f, -0.23954464f, 
    -0.08066379f, -0.13309276f, 0.11802500f, -0.09492657f, 0.13743010f, -0.13220033f, -0.24175330f, 0.32353866f, 
    0.05231260f, 0.15391783f, 0.06824827f, -0.17693470f, 0.17564400f, -0.04136283f, 0.11002056f, -0.01537098f, 
    -0.05902701f, 0.19601367f, -0.10357101f, -0.02458414f, 0.05079892f, -0.27662227f, 0.07478926f, 0.00395787f, 
    -0.52156407f, -0.05462937f, -0.05996067f, 0.02491355f, -0.06271627f, 0.03319269f, 0.03361292f, 0.03664513f, 
    0.03745027f, 0.08286251f, 0.10414758f, 0.29005501f, -0.19531879f, 0.00670276f, -0.02499998f, -0.00105781f, 
    0.11314062f, 0.06440216f, -0.19711460f, 0.03077921f, 0.08966955f, 0.09097717f, -0.19096738f, -0.01005709f, 
    0.10994793f, -0.02258333f, -0.02656545f, -0.07972735f, -0.02419312f, -0.07110341f, 0.08579373f, -0.17203254f, 
    -0.08246221f, -0.12760563f, 0.03851708f, 0.19459616f, 0.23821087f, 0.07259016f, 0.15661463f, 0.19857076f, 
    -0.03726896f, -0.11519681f, 0.11983741f, 0.03860622f, -0.06860920f, 0.24269220f, -0.07529134f, 0.12380604f, 
    -0.07085959f, -0.08036309f, 0.11459300f, -0.06261063f, -0.17917554f, -0.21369618f, 0.06948274f, 0.07271817f, 
    -0.14779113f, 0.03831477f, 0.01062223f, 0.16270748f, 0.22101732f, 0.05939697f, -0.00206348f, -0.07660663f, 
    0.04654027f, -0.09867566f, 0.13870430f, -0.00701636f, -0.08684125f, -0.01078760f, -0.03229908f, 0.09958201f, 
    -0.00199205f, -0.10098225f, -0.10290916f, -0.04214315f, 0.03403951f, 0.17222381f, -0.21398917f, 0.11744605f, 
    -0.10186106f, 0.19254743f, 0.10879903f, -0.04530305f, -0.00331779f, 0.25272101f, 0.04067202f, 0.10269145f, 
    -0.24596311f, 0.18618873f, 0.19907118f, -0.09126682f, -0.03798417f, -0.02247114f, 0.06611437f, -0.02317215f, 
    -0.25828892f, -0.12967186f, 0.09748261f, -0.23151539f, -0.16765630f, 0.11250403f, 0.12062832f, 0.06000125f, 
    -0.14581339f, 0.07152687f, 0.10965434f, 0.15657823f, -0.17662208f, 0.16398478f, -0.18896176f, -0.02566246f, 
    0.12449536f, -0.02551772f, -0.04812421f, 0.00904039f, 0.13486826f, -0.11497138f, -0.04353790f, -0.21242231f, 
    -0.10035338f, -0.13411236f, 0.07188089f, -0.01529864f, 0.26448187f, -0.03094817f, -0.43500406f, -0.08357012f, 
    0.14274332f, -0.03734785f, -0.03423071f, 0.07821645f, 0.01343535f, -0.11590061f, -0.06114749f, 0.28267708f, 
    0.39082518f, 0.20891687f, 0.11953496f, -0.01706824f, 0.03647901f, 0.06466990f, 0.24601822f, 0.02092014f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.10373515f, 0.17164855f, 0.03712239f, 0.07534861f, 0.20423529f, -0.10601403f, 0.12631461f, -0.09891539f, 
    0.15231284f, -0.11713122f, 0.11484610f, -0.17541446f, -0.01072025f, -0.01986623f, 0.05325103f, 0.08798606f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.39055386f, 0.18877716f, 0.10729822f, 0.30168340f, 0.04092341f, 0.16779889f, 0.28831592f, -0.04400777f, 
    -0.01140611f, -0.01186972f, -0.13138787f, -0.38449332f, 0.22655471f, 0.17418732f, 0.21288984f, -0.12139376f, 
    -0.02270117f, -0.04359802f, -0.02319869f, -0.63842374f, 0.11504932f, -0.29697585f, 0.25405872f, -0.13596238f, 
    0.08876158f, 0.23482190f, 0.34991470f, -0.12307802f, 0.04290133f, -0.17000364f, 0.03828953f, 0.16521367f, 
    0.23955068f, -0.13760079f, 0.14037275f, 0.50411880f, 0.27323222f, 0.14033365f, -0.12026400f, 0.29158559f, 
    -0.24433632f, 0.11711718f, 0.14813238f, 0.00276976f, 0.27499357f, -0.03749086f, -0.30044585f, 0.33620918f, 
    0.02007398f, -0.09695393f, 0.03529367f, -0.00523881f, -0.06856158f, 0.06676692f, -0.13342488f, -0.12083028f, 
    -0.22567515f, -0.04825497f, 0.01271525f, -0.12191411f, -0.10163116f, -0.20136359f, -0.14725113f, 0.11025865f, 
    0.60100597f, 0.40958443f, 0.03330552f, -0.31266731f, -0.25550044f, -0.03076899f, -0.26575390f, 0.02111034f, 
    0.03188341f, 0.12535462f, 0.26620921f, -0.25362137f, 0.04691665f, 0.06711734f, -0.30922601f, 0.19831386f, 
    0.33874530f, 0.40780690f, -0.00319488f, -0.30857968f, -0.31172639f, -0.42104229f, -0.24284083f, -0.05055226f, 
    0.23785202f, -0.20288691f, 0.20605221f, 0.46061498f, -0.08594539f, 0.08727254f, -0.11959081f, 0.29304242f, 
    -0.03142607f, 0.36942983f, -0.21454751f, -0.56402016f, 0.49897206f, -0.18764025f, 0.42473280f, -0.08845463f, 
    0.12433496f, -0.04868153f, -0.22019783f, -0.15188672f, -0.20517647f, 0.21966615f, 0.33108988f, 0.09054912f, 
    0.48883173f, -0.22284508f, 0.16185428f, 0.14586325f, 0.37024558f, -0.19681478f, 0.10398390f, 0.33346471f, 
    -0.00615441f, -0.16391422f, 0.13806801f, 0.14568856f, -0.25264740f, -0.08748418f, -0.39049944f, 0.13640182f, 
    -0.06694248f, -0.05840212f, -0.18194185f, 0.05362533f, 0.52882385f, -0.32828182f, 0.12486742f, 0.23604584f, 
    -0.51638955f, -0.01440836f, 0.21051127f, -0.24648930f, 0.26393780f, 0.02621511f, 0.20302643f, 0.11881379f, 
    0.01805493f, -0.78155792f, -0.19613144f, 0.07326114f, -0.04167646f, -0.24757457f, -0.02071739f, -0.37760407f, 
    0.34739223f, 0.12163693f, 0.32812297f, 0.05288738f, 0.02113324f, -0.15401599f, 0.05496782f, 0.11277055f, 
    -0.14088124f, -0.18277161f, -0.11719439f, 0.57568425f, -0.39413139f, 0.28597507f, -0.29979932f, 0.24951220f, 
    -0.09631430f, -0.14907020f, 0.11830723f, -0.05416118f, -0.25759152f, -0.19996984f, 0.16965193f, 0.43191677f, 
    -0.21719390f, -0.24418692f, -0.04624078f, -0.40084079f, 0.09606402f, 0.40313235f, 0.43092448f, 0.45788720f, 
    0.21862215f, -0.27846995f, -0.06027842f, 0.06280582f, -0.09132714f, 0.23812172f, -0.02672475f, -0.47430706f, 
    -0.03622106f, -0.31358904f, -0.23820034f, 0.39783961f, 0.39252749f, 0.33777043f, 0.32613459f, 0.10735229f, 
    0.02166913f, 0.11759820f, -0.21484832f, -0.09591544f, 0.06235222f, -0.00620742f, 0.10824914f, -0.02027489f, 
    -0.51974642f, 0.10548146f, 0.03598073f, -0.66232538f, 0.10476374f, -0.10616443f, 0.04819916f, -0.47066030f, 
    0.30494627f, -0.07000649f, 0.03626107f, 0.00241321f, 0.42585415f, -0.13470390f, 0.01249902f, -0.08635160f, 
    -0.25543678f, 0.53551942f, 0.14623451f, -0.07122681f, 0.14058058f, -0.45604199f, -0.21631067f, 0.04757300f, 
    0.11182182f, -0.01406357f, 0.25176236f, 0.22055852f, -0.54430664f, -0.15913248f, -0.22295009f, 0.06527077f, 
    -0.13026017f, -0.10609304f, 0.02649376f, 0.33017525f, 0.57499754f, -0.01841951f, -0.02088758f, -0.32330373f, 
    -0.22239448f, -0.07763925f, 0.40468165f, -0.04608251f, -0.08849458f, 0.07137001f, 0.18908374f, -0.07411722f, 
    -0.04515532f, 0.03818472f, -0.14633009f, -0.27991730f, 0.22414500f, -0.11771618f, 0.54972464f, 0.34097895f, 
    0.19329596f, -0.12008886f, -0.06524830f, -0.22975716f, 0.07247175f, -0.12742126f, -0.02626017f, -0.21045679f, 
    -0.25263253f, 0.18497604f, -0.06026581f, -0.15804023f, -0.19006237f, -0.23989084f, -0.00470086f, -0.05340105f, 
    -0.14575221f, -0.15042868f, -0.08153011f, -0.14520341f, -0.08165738f, -0.09898195f, -0.20202413f, 0.18363336f, 
    0.03785232f, 0.13510455f, 0.13023475f, 0.07177537f, -0.27528617f, -0.40325236f, -0.07943251f, 0.03000105f, 
    0.45762753f, 0.08308519f, -0.11314268f, 0.53491104f, 0.08150692f, -0.13910678f, -0.20832582f, 0.04415216f, 
    0.28327110f, 0.14610542f, 0.22580916f, -0.20537691f, -0.41851905f, 0.14987728f, 0.46817139f, -0.09826312f, 
    -0.17537457f, 0.09423945f, 0.33319503f, -0.19012143f, -0.02091012f, -0.19092461f, -0.00630067f, 0.11735686f, 
    0.36529559f, 0.08650411f, -0.20842332f, -0.53403056f, 0.29276878f, -0.01419790f, -0.09058867f, 0.04868325f, 
    -0.31188986f, 0.13930924f, 0.41601586f, 0.01811517f, -0.15991205f, -0.15987322f, -0.40541220f, 0.23755066f, 
    -0.22933078f, 0.32145542f, 0.08554637f, -0.02952881f, -0.27136648f, 0.21932571f, -0.03450780f, -0.17785415f, 
    0.27753547f, -0.13296662f, 0.03307445f, -0.29222468f, -0.25961626f, 0.24005933f, 0.26813194f, 0.25996339f, 
    -0.12608397f, 0.02796203f, -0.04628873f, -0.04678625f, -0.11934403f, -0.12566769f, 0.04268777f, -0.05027476f, 
    -0.03133488f, -0.17842275f, -0.05167747f, -0.11550245f, 0.00572306f, -0.23573750f, -0.23817930f, -0.18824017f, 
    0.07359464f, 0.25156534f, -0.07550815f, -0.22890727f, -0.72246391f, -0.33518130f, 0.26129228f, -0.07953074f, 
    -0.01293828f, 0.20176987f, 0.23506209f, -0.07606725f, -0.08407845f, 0.05499257f, 0.24327803f, 0.11946321f, 
    0.21198328f, 0.00447475f, -0.17848542f, 0.07450449f, 0.07180957f, 0.13806343f, -0.08805505f, 0.37594834f, 
    0.21856067f, -0.20463423f, 0.47084603f, -0.11716903f, -0.53831804f, 0.11463083f, -0.20704530f, 0.20125623f, 
    0.08585870f, 0.00460441f, 0.19284457f, 0.12216294f, 0.21142389f, 0.47880611f, 0.07552342f, 0.42408279f, 
    -0.40032619f, -0.11115266f, -0.06374214f, 0.22128688f, 0.32914415f, 0.14613613f, -0.01142776f, -0.34348321f, 
    -0.25897345f, 0.02880563f, 0.23835549f, -0.32043555f, 0.14939786f, 0.26567188f, -0.30869493f, 0.09222931f, 
    0.04586338f, 0.19683842f, 0.02237887f, 0.10094870f, 0.25940582f, -0.20983529f, 0.46290129f, 0.12807254f, 
    0.32149309f, -0.17808467f, 0.03229934f, -0.24225105f, 0.26753822f, -0.36985132f, -0.07484936f, -0.23785698f, 
    0.31097266f, -0.07460320f, 0.16213790f, -0.13742146f, -0.86962640f, -0.04828021f, 0.06015393f, -0.24146450f, 
    -0.28489971f, 0.04260954f, 0.11866844f, 0.25018412f, 0.19452228f, -0.14081161f, -0.26888564f, -0.35552046f, 
    -0.13998617f, -0.22136629f, -0.37849295f, 0.25805002f, 0.08147725f, 0.11621553f, -0.33142766f, 0.16088317f, 
    -0.51084280f, -0.38024262f, 0.03484717f, 0.21436322f, 0.18481822f, -0.08657213f, -0.23289482f, -0.34182817f, 
    0.29721808f, 0.03819647f, -0.14326327f, -0.11844825f, 0.40842322f, 0.20503609f, 0.29129845f, 0.47011328f, 
    0.09567873f, 0.36040428f, 0.17846872f, -0.00085230f, -0.31609628f, -0.21737219f, 0.22566243f, 0.19545013f, 
    -0.21854633f, -0.02222682f, 0.02082471f, 0.01439477f, 0.58160108f, 0.22810805f, 0.07520068f, -0.05181804f, 
    0.39624688f, 0.41356966f, 0.10234983f, 0.34541568f, 0.38643444f, 0.09838603f, -0.40515098f, -0.07327910f, 
    0.24176942f, 0.09518134f, -0.28576341f, 0.29683259f, -0.38610145f, 0.13980611f, -0.08960239f, -0.18639456f, 
    -0.23201250f, -0.28897893f, -0.04158390f, -0.03084159f, 0.14013205f, -0.29146186f, 0.13849160f, 0.53430766f, 
    0.07885325f, -0.06710520f, -0.18182778f, 0.42371610f, -0.02154592f, 0.20520395f, 0.32312366f, -0.23463699f, 
    -0.18344542f, 0.27580732f, 0.07985204f, -0.27691558f, 0.13936670f, 0.57455492f, -0.00244090f, 0.19983451f, 
    -0.23504426f, 0.21486884f, -0.08237641f, 0.28812221f, -0.69912875f, 0.15254614f, 0.18049221f, -0.27287111f, 
    -0.18216345f, 0.39589030f, 0.03285960f, -0.07861172f, -0.23340231f, -0.26961896f, 0.24831405f, 0.33463189f, 
    -0.27244806f, -0.06870513f, -0.08663686f, -0.14739995f, 0.41255599f, 0.09535707f, 0.11441440f, 0.20317075f, 
    0.33098215f, 0.21278580f, -0.05881480f, 0.16421030f, 0.35541016f, -0.08854519f, -0.29339197f, 0.19846359f, 
    -0.25855172f, 0.00689346f, 0.04525614f, 0.39282376f, 0.30099124f, 0.13077670f, -0.03581067f, -0.03169376f, 
    -0.33389008f, -0.09129208f, 0.04091712f, 0.27761182f, -0.11312649f, 0.17567380f, 0.17632471f, 0.45646149f, 
    0.19889811f, -0.09092688f, 0.00014998f, 0.07832094f, 0.36059502f, 0.11628316f, -0.10456372f, -0.25073895f, 
    0.01995264f, 0.02566820f, 0.15309009f, 0.35627216f, 0.29636690f, 0.23986816f, 0.18034053f, -0.22688812f, 
    -0.13208674f, -0.19527520f, 0.26178053f, -0.39047366f, -0.12500946f, 0.09393762f, 0.27074063f, 0.13663244f, 
    0.40762469f, 0.02166681f, 0.03890994f, -0.20869021f, 0.14999054f, -0.35506982f, 0.32091570f, 0.16420308f, 
    0.35549670f, -0.09447116f, 0.22373889f, 0.02281086f, -0.19128071f, -0.19942373f, -0.20749947f, -0.16469109f, 
    -0.21526660f, -0.04868745f, 0.16961154f, -0.53193676f, 0.07860012f, 0.31783897f, -0.03103795f, 0.03804493f, 
    0.19299398f, 0.06584576f, 0.18515076f, 0.11245134f, 0.06498687f, -0.01297128f, 0.48041525f, -0.29508737f, 
    0.38449579f, 0.17981222f, -0.16309883f, -0.13398458f, 0.45311770f, -0.13076143f, 0.46662152f, 0.27994511f, 
    -0.34657758f, -0.21527521f, -0.33067495f, -0.24225099f, -0.11986512f, 0.01848613f, 0.08549867f, -0.01905273f, 
    0.29982197f, -0.21087107f, -0.14724521f, 0.54115391f, 0.24050465f, -0.36514604f, 0.21376149f, -0.08135156f, 
    -0.08680264f, -0.00775053f, 0.14853819f, 0.30835184f, -0.01239376f, 0.04322279f, -0.37110567f, 0.16764820f, 
    -0.34780085f, -0.02047700f, -0.09923940f, 0.22444896f, 0.16461262f, 0.12755464f, 0.32310617f, 0.30589086f, 
    -0.26488587f, -0.22813886f, -0.26537362f, -0.10303505f, 0.23823380f, 0.04959961f, 0.23771149f, -0.09822488f, 
    0.30763462f, -0.13675945f, -0.00198206f, 0.03017829f, -0.18556216f, 0.23362072f, -0.34230542f, 0.17182650f, 
    0.01737926f, 0.14661306f, 0.21334796f, -0.13615254f, -0.43859783f, -0.02665957f, 0.44031435f, -0.04670322f, 
    -0.16573136f, 0.11526287f, 0.08047482f, 0.14316927f, 0.24601518f, 0.08974769f, -0.09188589f, 0.04181374f, 
    -0.26645201f, 0.04624028f, -0.24707600f, -0.25810379f, 0.33490270f, -0.21084656f, 0.15366742f, 0.45792320f, 
    0.04923071f, -0.33697715f, 0.11798178f, 0.06883569f, 0.43798751f, 0.24129061f, 0.45240676f, -0.10020255f, 
    -0.09634940f, -0.18862955f, 0.31551701f, -0.05105992f, 0.00844039f, 0.06015617f, -0.07502613f, -0.06272250f, 
    0.35342070f, -0.04431404f, -0.24138409f, -0.61068034f, 0.36800301f, -0.39473397f, -0.05315808f, 0.06781054f, 
    0.08028788f, -0.03709631f, 0.45661753f, -0.29964325f, -0.23266548f, -0.09262495f, -0.29419520f, 0.12646161f, 
    0.47590223f, -0.27580348f, -0.25066558f, -0.40727112f, 0.23192890f, 0.20167291f, -0.08819582f, -0.29666820f, 
    0.12235094f, -0.15179060f, 0.32244384f, 0.33417192f, 0.11181540f, 0.05359362f, -0.25161779f, -0.04211514f, 
    0.52514344f, 0.33839196f, -0.09428988f, -0.51285547f, -0.23369759f, -0.38021192f, 0.04334984f, 0.06586907f, 
    0.34452334f, 0.07538981f, -0.08212475f, 0.29241404f, 0.32267931f, -0.19591820f, -0.26987186f, -0.00713328f, 
    -0.11420275f, 0.29244187f, -0.11952375f, -0.00352278f, 0.36873525f, 0.05683608f, -0.28015855f, -0.14605761f, 
    0.24620408f, -0.00845694f, 0.45261562f, 0.09604183f, -0.29847807f, 0.13805957f, -0.02214292f, -0.08840434f, 
    -0.23468179f, 0.30240852f, 0.08005121f, -0.46098718f, -0.37676650f, 0.38062012f, 0.20344649f, 0.15944834f, 
    -0.05255491f, 0.05692287f, -0.20696318f, -0.04888628f, 0.14875825f, -0.12488241f, 0.45139444f, 0.23240742f, 
    0.14996411f, 0.34110475f, -0.02054583f, 0.12268518f, -0.26796028f, -0.40229571f, 0.26331863f, 0.01932237f, 
    -0.31597856f, 0.01586937f, 0.20654526f, 0.10350581f, -0.01135642f, -0.05554311f, -0.19233288f, 0.46115282f, 
    -0.74852771f, 0.22285971f, 0.16804726f, -0.23851541f, 0.55405831f, -0.20674448f, 0.21373187f, -0.06747255f, 
    -0.01652722f, 0.13411976f, 0.27312857f, -0.33125725f, 0.24411882f, -0.05290924f, 0.10031450f, -0.09492375f, 
    -0.46754688f, -0.32488343f, 0.11643374f, 0.13911311f, 0.07955296f, -0.27003133f, 0.15653720f, 0.46685061f, 
    0.16487727f, 0.08912540f, -0.24183318f, 0.23098210f, -0.09870625f, 0.02673230f, 0.25001523f, 0.12554212f, 
    0.29057235f, -0.24399541f, -0.10141298f, 0.21636334f, 0.05117774f, 0.01149948f, 0.32384446f, 0.14856508f, 
    -0.40594092f, -0.09221288f, 0.16834314f, -0.02023991f, 0.27771369f, -0.17015544f, -0.33195701f, 0.23360780f, 
    -0.28370848f, -0.14884466f, -0.12630853f, 0.05999000f, 0.07295374f, 0.35476807f, -0.24279371f, -0.20978002f, 
    0.18774159f, 0.10036320f, -0.17745787f, 0.22278424f, 0.24882044f, 0.05253362f, 0.38414693f, 0.13015601f, 
    -0.00899347f, -0.20314381f, 0.21286137f, -0.02362432f, -0.27860743f, 0.13557932f, 0.11715420f, 0.21076272f, 
    -0.27715209f, -0.25834230f, -0.07113848f, 0.47655225f, 0.38124052f, 0.12707876f, 0.07139917f, 0.02945188f, 
    0.25518307f, -0.23972300f, 0.04695245f, -0.40865934f, -0.12490337f, -0.27288306f, 0.33552796f, -0.25953263f, 
    0.20778227f, 0.02318979f, 0.39987835f, -0.00778429f, -0.54624867f, -0.05085559f, 0.27314314f, -0.02114536f, 
    0.17570408f, 0.43149704f, -0.10922133f, 0.28610510f, 0.56709850f, -0.01013845f, 0.03191365f, -0.09884720f, 
    0.22150886f, 0.12165495f, -0.21991737f, -0.26911277f, -0.45678684f, -0.12774201f, -0.37430063f, -0.24535477f, 
    -0.04920310f, 0.23545258f, -0.21298702f, 0.34632322f, 0.48456684f, -0.44732523f, -0.31713006f, 0.24407558f, 
    0.04381196f, -0.17588077f, -0.23702900f, 0.32194182f, 0.01665151f, 0.05632634f, 0.31930780f, 0.22622208f, 
    0.12811837f, 0.20911780f, 0.09249774f, -0.45212179f, -0.42587137f, -0.02949242f, 0.26359046f, 0.13037662f, 
    0.37924999f, -0.02832034f, -0.36517394f, 0.00381446f, 0.07670647f, -0.07214897f, 0.23710403f, 0.18829447f, 
    -0.06133951f, 0.30692956f, 0.00793928f, -0.29180664f, -0.12970263f, 0.51775843f, 0.10957759f, -0.03886511f, 
    0.16849890f, 0.12741005f, -0.21904215f, -0.08621470f, -0.16015343f, 0.14081404f, 0.05607885f, 0.21968210f, 
    0.22401805f, -0.41104931f, -0.14914978f, 0.12563030f, -0.13476419f, -0.09304666f, -0.26497322f, 0.19477120f, 
    -0.15288770f, -0.18919258f, -0.10434135f, 0.42430609f, 0.09379520f, 0.09816385f, -0.07226357f, 0.58894938f, 
    -0.38274413f, -0.08641396f, 0.05175861f, 0.31258506f, 0.43528247f, -0.64321405f, 0.01241984f, 0.30975407f, 
    -0.22494629f, 0.07907816f, 0.06997887f, 0.19210148f, 0.00814288f, -0.03531217f, 0.17480484f, -0.03557897f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.12620696f, 0.35638794f, -0.16915163f, 0.10451380f, -0.00957739f, -0.19662365f, 0.27547404f, 0.20537306f, 
    0.02796091f, 0.20857309f, -0.35133818f, 0.21523008f, 0.22120334f, 0.12837036f, 0.10486964f, 0.37794626f, 
    0.52748650f, -0.20582499f, -0.34796286f, 0.29554963f, -0.00492602f, 0.38801947f, -0.11556804f, 0.14200741f, 
    0.49413911f, -0.39063033f, 0.24245997f, -0.24728508f, 0.07575575f, 0.05141791f, -0.18123806f, 0.04336145f, 
    0.28446802f, 0.04315660f, 0.02888167f, -0.47365576f, -0.14215341f, 0.46239740f, 0.30931735f, -0.14804605f, 
    0.51012909f, -0.27292392f, -0.07548202f, 0.02783695f, -0.04760595f, 0.40708965f, 0.32032946f, 0.20386760f, 
    0.15495133f, 0.41076341f, 0.17752500f, -0.10957941f, 0.20722209f, 0.28941664f, -0.19982541f, 0.10914107f, 
    0.00349590f, 0.47364825f, 0.07733808f, -0.19908051f, -0.04455077f, -0.18862057f, 0.18869886f, 0.06976338f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.04491116f, 0.10911251f, 0.42356053f, -0.03308998f, -0.08618660f, 0.02312949f, -0.05362451f, 0.03969394f, 
    0.31246820f, -0.34981608f, -0.11375310f, -0.15308438f, 0.02455307f, -0.30822647f, -0.13458802f, -0.02138493f, 
    -0.04586950f, -0.05006507f, -0.09248648f, 0.10396095f, 0.32587066f, -0.24831089f, -0.06721421f, -0.12705687f, 
    -0.00163749f, 0.56406093f, 0.24225838f, -0.51652175f, -0.15423083f, 0.00268191f, 0.12274617f, -0.70158976f, 
    0.11604209f, -0.23096392f, 0.35960290f, 0.40321544f, -0.05393812f, -0.02357636f, -0.37714434f, -0.04076406f, 
    0.23290257f, 0.18391539f, 0.32183045f, -0.49085385f, 0.32504901f, -0.03847501f, 0.10834755f, -0.06013901f, 
    0.02428608f, -0.28157157f, 0.23544246f, 0.28221408f, -0.09398283f, 0.05419203f, 0.47313344f, 0.08072571f, 
    0.55238765f, -0.12823309f, -0.55338025f, 0.07457808f, 0.10486980f, 0.07182068f, 0.38989928f, -0.06564897f, 
    -0.23877196f, -0.04801734f, -0.08513148f, 0.06866954f, -0.44899192f, -0.00739289f, 0.05915387f, 0.40569913f, 
    -0.30316520f, 0.29673734f, 0.34296456f, 0.77445489f, 0.16226158f, -0.27786770f, -0.31731719f, 0.09094405f, 
    0.29789343f, 0.10389374f, 0.10732061f, 0.08299462f, -0.11925080f, -0.24862085f, 0.02120620f, -0.21302745f, 
    0.11510610f, 0.28733799f, -0.14280541f, 0.43478495f, 0.03299642f, -0.38256726f, -0.17608301f, 0.06863694f, 
    0.28476030f, 0.55227876f, -0.24840510f, -0.02568281f, 0.01978290f, -0.01628502f, 0.39058593f, 0.00331481f, 
    0.06288680f, 0.40919173f, -0.05449432f, -0.01836336f, -0.11494236f, 0.22180904f, 0.50738859f, 0.20474829f, 
    0.15783301f, 0.12657322f, -0.18285088f, -0.24664700f, -0.07017666f, 0.07755373f, 0.07734042f, 0.01485956f, 
    0.11889749f, 0.57038546f, 0.62969780f, -0.08174111f, -0.11201120f, -0.00133647f, 0.29916883f, -0.11805464f, 
    -0.10161138f, -0.03815752f, -0.07612957f, -0.04531796f, 0.10152943f, -0.08940117f, -0.08304249f, 0.10793358f, 
    -0.10035171f, -0.07001160f, 0.12478161f, -0.00611331f, -0.11281157f, 0.07054761f, 0.12113507f, 0.01936945f, 
    -0.05987623f, 0.12132700f, -0.02597667f, -0.02635369f, 0.00975603f, 0.03330241f, -0.09436417f, 0.00530629f, 
    -0.11207786f, 0.00909598f, -0.08799835f, 0.05593462f, 0.03994551f, -0.09226823f, 0.07973111f, 0.04077116f, 
    0.05673058f, -0.07097097f, 0.11752862f, -0.10024649f, 0.06219767f, -0.08407244f, -0.07181662f, -0.00941512f, 
    0.07019983f, 0.00506301f, -0.11742806f, -0.00585954f, 0.05666105f, -0.09232557f, -0.06927493f, -0.07055645f, 
    0.01135163f, -0.03789976f, -0.04064135f, 0.05717719f, -0.01863773f, 0.03176519f, -0.12015490f, -0.12184793f, 
    -0.08251694f, -0.03368017f, -0.10614516f, -0.06783848f, 0.01528540f, -0.04981345f, 0.05662364f, 0.02867372f, 
    -0.12857911f, 0.02601937f, 0.04578586f, 0.09302305f, 0.56977081f, 0.41054791f, 0.00196391f, 0.23167358f, 
    -0.15870185f, -0.30286044f, 0.82497585f, -0.43096963f, -0.31040406f, -0.30566487f, 0.63030100f, -0.02322170f, 
    -0.13868350f, 0.09613818f, 0.39817855f, 0.01153742f, 0.58401626f, 0.21167524f, -0.11337475f, 0.19338591f, 
    0.33324695f, -0.19090161f, -0.02312780f, -0.22016343f, 0.36995572f, -0.09193382f, -0.10851770f, 0.46561068f, 
    -0.22757766f, -0.49718034f, 0.11800831f, 0.06369280f, 0.04628835f, -0.00415740f, 0.13590597f, -0.10535230f, 
    0.08172799f, 0.01182292f, -0.11020859f, 0.52394158f, 0.01398077f, -0.23660322f, 0.46189585f, -0.18296339f, 
    0.17685582f, 0.14195333f, -0.01280813f, 0.41307357f, -0.02871723f, 0.10068280f, -0.17546013f, -0.17093223f, 
    -0.23603931f, -0.07792184f, 0.16151455f, 0.09001306f, 0.17943142f, 0.18429425f, 0.15761812f, -0.16612776f, 
    -0.24914953f, -0.11496058f, 0.01923225f, 0.02449960f, 0.01222826f, 0.24312216f, -0.25382957f, 0.04579160f, 
    -0.12842870f, 0.12870191f, -0.36352110f, 0.46758458f, -0.09230816f, -0.28451219f, 0.17121041f, -0.65416300f, 
    0.00274709f, -0.13001989f, 0.26239404f, -0.20029534f, 0.21612014f, -0.27843007f, -0.03357473f, 0.07990474f, 
    0.06883410f, 0.47856915f, 0.16440167f, -0.12013225f, 0.74215442f, -0.10042895f, 0.15658733f, -0.18104117f, 
    0.71673310f, -0.09437005f, 0.28729513f, 0.31495780f, 0.36723128f, -0.20125915f, -0.06048100f, 0.20890543f, 
    -0.10718249f, 0.02049863f, 0.16826855f, -0.12609172f, 0.02911726f, -0.30361736f, -0.01106838f, 0.02114927f, 
    0.36004314f, -0.11965882f, 0.25098127f, -0.11065663f, -0.45805976f, 0.33442137f, -0.13261403f, -0.00758265f, 
    0.36432642f, -0.00375301f, -0.26230556f, 0.21906081f, 0.29389054f, 0.05512919f, 0.42549348f, 0.20285946f, 
    -0.13263765f, -0.08885028f, 0.11985658f, -0.01510066f, -0.12728009f, -0.04181625f, 0.03826241f, 0.06652920f, 
    0.28741562f, 0.51287103f, -0.36696902f, -0.04983574f, 0.03808848f, -0.02236033f, 0.18396187f, -0.01158908f, 
    -0.21657543f, 0.10066032f, 0.19897029f, -0.26334238f, 0.10036813f, -0.23559588f, -0.04304029f, -0.23923440f, 
    0.13656563f, 0.34889987f, 0.17193471f, 0.19570847f, 0.37497190f, 0.21272966f, -0.00517937f, 0.42175856f, 
    0.61545324f, 0.08317231f, 0.02993866f, 0.44201887f, 0.08407030f, -0.19937387f, -0.07813590f, 0.06856698f, 
    0.03424191f, -0.04870280f, 0.00338356f, -0.28641146f, -0.00088168f, 0.02685326f, 0.08959534f, 0.19285163f, 
    -0.04480632f, -0.02598427f, -0.09589276f, -0.18873923f, 0.07303999f, 0.28456989f, -0.08413258f, 0.25399432f, 
    0.21362965f, -0.12682539f, 0.40418899f, 0.24566859f, -0.14024709f, -0.00553371f, 0.34133169f, 0.56202513f, 
    -0.09919307f, -0.03400568f, 0.26902708f, 0.09951675f, 0.00088190f, 0.03544063f, -0.08877601f, -0.00047705f, 
    0.14993601f, 0.32914969f, -0.18880819f, -0.21656054f, 0.20300917f, -0.03359349f, 0.00671182f, 0.34398076f, 
    -0.15065467f, -0.01528556f, -0.05260616f, -0.19261239f, 0.17896619f, -0.06555482f, 0.03304240f, -0.28591999f, 
    0.08510577f, 0.08876598f, 0.17487837f, 0.17792511f, 0.22518435f, 0.40583685f, -0.19229706f, 0.31057158f, 
    0.29727542f, -0.01888046f, -0.05291424f, 0.18739501f, 0.05508749f, 0.16488880f, -0.09023259f, 0.10923174f, 
    0.23019870f, 0.08469754f, 0.00238282f, -0.11591761f, 0.19334643f, 0.01743797f, -0.01063589f, 0.23932157f, 
    -0.18800433f, 0.09840715f, -0.01878026f, -0.17392851f, -0.01071443f, 0.07275171f, -0.08035778f, 0.14632666f, 
    -0.04195061f, -0.48773667f, 0.44585338f, 0.19556397f, -0.12845868f, -0.05140946f, 0.34157661f, 0.36439988f, 
    -0.10096186f, 0.33996901f, -0.46639514f, 0.09010728f, 0.06106074f, 0.44949031f, 0.44260252f, 0.07419169f, 
    0.16690639f, -0.24222289f, -0.28757420f, 0.11380740f, -0.37391675f, 0.41295126f, 0.76889157f, -0.06106842f, 
    0.18302561f, 0.11268876f, 0.17495993f, 0.08585212f, 0.50826597f, 0.06569191f, 0.11697362f, 0.38871464f, 
    0.03371266f, -0.32898480f, -0.05687016f, 0.31035784f, 0.52896965f, -0.44941375f, 0.09915721f, 0.17739947f, 
    0.12378924f, -0.27755603f, 0.06540663f, -0.02411134f, -0.40508813f, -0.08318816f, 0.38836595f, 0.16943347f, 
    0.26483580f, -0.21120891f, -0.23784335f, -0.05224872f, -0.13645180f, -0.12058934f, 0.80649203f, 0.06381623f, 
    0.48799619f, 0.18572782f, 0.07163903f, 0.31439686f, 0.26990390f, -0.25620443f, 0.03526925f, -0.22079757f, 
    -0.03934994f, 0.59183550f, 0.20143691f, 0.10345423f, 0.24220115f, 0.01931671f, -0.22212891f, -0.14620259f, 
    -0.03797465f, -0.08693376f, -0.09518661f, -0.11662266f, 0.03169393f, 0.18897413f, 0.21634109f, -0.08480975f, 
    -0.01715805f, -0.26679537f, -0.46354976f, -0.19617672f, 0.20420137f, 0.31677097f, -0.47286993f, -0.42398193f, 
    0.01874210f, -0.05027673f, 0.31255737f, -0.27763495f, -0.03906180f, 0.00338566f, -0.01565804f, -0.17805532f, 
    -0.23652489f, -0.07188956f, 0.16011086f, -0.07948134f, -0.44478843f, 0.38713396f, 0.17244200f, 0.34972367f, 
    0.46389624f, -1.22224712f, -0.02117923f, 0.27470246f, 0.17318438f, -0.08883590f, -0.00336528f, 0.09186192f, 
    0.39408731f, 0.03454779f, 0.01442260f, -0.08577093f, 0.13481791f, -0.23785627f, -0.38674691f, 0.02922517f, 
    0.31535619f, -0.10630866f, 0.09345040f, -0.30203259f, -0.21158972f, 0.26916346f, -0.28600100f, 0.21347682f, 
    -0.01781023f, -0.50294268f, 0.30062079f, 0.30197066f, 0.35086980f, 0.17543906f, 0.03518196f, 0.14235832f, 
    0.03045131f, -0.08222459f, -0.01603227f, 0.08873303f, -0.12307572f, 0.06770929f, 0.12879907f, 0.30805451f, 
    -0.25258666f, 0.11101182f, -0.30125588f, 0.54296482f, 0.22995718f, -0.12880567f, -0.42822990f, 0.04747520f, 
    0.22699051f, -0.04304426f, 0.22566420f, 0.22885764f, -0.31809041f, -0.17062916f, 0.03632250f, -0.10600182f, 
    0.14005002f, 0.27776915f, -0.15741237f, -0.41657507f, 0.50232470f, -0.22332986f, 0.12824516f, -0.32278645f, 
    0.16693217f, -0.01122084f, -0.02100268f, 0.08476628f, 0.25807875f, 0.07150739f, 0.36675483f, 0.00837711f, 
    -0.02101373f, 0.39721003f, 0.03649677f, -0.06621913f, -0.11985048f, 0.27414066f, -0.09161308f, 0.18274620f, 
    0.23688546f, -0.15023114f, 0.00147563f, -0.05723576f, -0.00260342f, -0.09214931f, 0.15677164f, 0.00611191f, 
    0.06192486f, 0.52641165f, 0.12719709f, -0.26826423f, 0.00692131f, 0.03877663f, 0.05030947f, -0.10617920f, 
    -0.12873627f, 0.29218823f, -0.02726432f, -0.06635302f, 0.05238191f, 0.14638169f, 0.24347556f, 0.24929467f, 
    -0.05664720f, -0.41019803f, 0.00829758f, 0.13823625f, -0.04938472f, 0.12817062f, 0.00305631f, -0.03725613f, 
    0.46559727f, -0.08142013f, 0.13267756f, 0.14677493f, 0.12429093f, -0.17199385f, -0.00641225f, 0.22932675f, 
    -0.04378908f, -0.27448913f, -0.02297087f, -0.18196791f, -0.16644073f, -0.01267661f, 0.22875997f, -0.48647082f, 
    -0.09067745f, -0.28409836f, 0.32999706f, -0.14628102f, -0.11824906f, -0.01483335f, 0.27027079f, -0.07925477f, 
    0.10745884f, -0.00465743f, 0.05649558f, -0.11639675f, -0.05141918f, 0.01943246f, 0.47559258f, 0.05274038f, 
    0.39122292f, -0.03198136f, 0.08063354f, 0.28232402f, 0.26179433f, -0.14254045f, 0.06436012f, -0.24778742f, 
    -0.04921287f, 0.53279483f, -0.17747480f, 0.01960828f, 0.13825443f, -0.02421425f, -0.12152440f, -0.16900185f, 
    -0.06366032f, 0.00409257f, -0.03691113f, 0.03472346f, 0.51458287f, 0.03019989f, 0.10952435f, -0.01009530f, 
    0.02255161f, -0.15323995f, -0.07448465f, -0.38228434f, -0.23675503f, -0.35070211f, 0.00345661f, -0.04461858f, 
    -0.11935265f, -0.08501637f, -0.01361755f, 0.00502158f, 0.12705652f, 0.06536255f, 0.05493769f, -0.16490440f, 
    0.02944798f, 0.05509097f, 0.17100213f, 0.79767245f, -0.32942104f, -0.30566192f, 0.15044598f, 0.53931057f, 
    -0.26621082f, -0.25044170f, 0.13093159f, 0.44670844f, -0.20936280f, 0.10140092f, -0.03118440f, 0.17109664f, 
    0.17284311f, -0.30815282f, -0.20828342f, 0.77488708f, 0.16697393f, -0.27298820f, -0.08307798f, 0.01327911f, 
    0.19724566f, 0.17753562f, 0.10250824f, -0.14217934f, -0.16282409f, -0.47101346f, -0.39388803f, -0.01986563f, 
    -0.43689883f, -0.39768627f, 0.47629529f, 0.27748176f, 0.13982569f, 0.17783862f, -0.18868598f, -0.47430214f, 
    0.01808978f, -0.12076917f, -0.05016711f, -0.01865219f, 0.13603672f, 0.04241044f, 0.01592841f, -0.00403192f, 
    -0.14462283f, 0.01933541f, 0.10096256f, -0.09717821f, 0.04483415f, -0.12323768f, 0.08364466f, -0.12610795f, 
    0.04448304f, 0.07554732f, -0.14923659f, 0.03206130f, -0.12647672f, -0.04108710f, -0.01857005f, -0.10429167f, 
    -0.10998496f, 0.01525699f, 0.04403265f, -0.01180840f, 0.10558906f, -0.01608492f, -0.00237776f, 0.03449307f, 
    -0.10380857f, 0.08281821f, -0.03652230f, -0.07238643f, -0.04201406f, -0.00236033f, -0.05308996f, 0.04043512f, 
    0.02896773f, -0.13243453f, -0.12733559f, 0.06077968f, -0.10401642f, -0.03766889f, -0.11520921f, -0.10698824f, 
    -0.13991491f, -0.05038037f, -0.11720474f, -0.05913848f, 0.10573994f, -0.06353732f, -0.04156776f, -0.04036267f, 
    -0.11980979f, 0.05154471f, -0.08034250f, 0.01147811f, -0.09164415f, 0.04867041f, 0.07614397f, 0.06624772f, 
    -0.12634748f, 0.05110713f, -0.06687628f, -0.11634304f, -0.01879588f, -0.09528302f, -0.09218662f, -0.00907485f, 
    0.02632670f, -0.02584492f, 0.06099284f, -0.03527257f, 0.02850511f, 0.01833736f, 0.00669907f, -0.11422486f, 
    0.01964412f, -0.00238258f, -0.09461979f, -0.13514021f, -0.05133256f, 0.02060062f, -0.12207900f, 0.09590583f, 
    0.07616599f, -0.00069112f, -0.07791328f, -0.00738461f, 0.00225003f, -0.04894006f, 0.04047152f, -0.07467963f, 
    0.01731841f, -0.11967783f, -0.07607818f, -0.11911121f, 0.10729154f, 0.03820862f, 0.07133166f, 0.05640223f, 
    -0.02106669f, -0.05999069f, -0.01089301f, -0.05942433f, 0.04193470f, -0.05668477f, -0.01576387f, -0.07620559f, 
    0.09806769f, -0.14104560f, 0.08643430f, -0.10432341f, 0.10222460f, -0.12136211f, -0.13176371f, 0.00794244f, 
    -0.13987234f, 0.04629508f, 0.04785939f, -0.08264323f, -0.13579930f, -0.08772194f, -0.11233786f, -0.00121753f, 
    0.01313762f, 0.27847847f, 0.03728462f, -0.09283562f, 0.06135238f, 0.17181620f, 0.19023032f, 0.31329095f, 
    0.14426532f, 0.12581253f, 0.62156981f, -0.27310407f, -0.08073936f, 0.07787473f, -0.05175898f, 0.46912813f, 
    0.21960355f, -0.04434709f, -0.14083464f, 0.16419841f, 0.25457814f, 0.03837656f, 0.04107152f, 0.04854661f, 
    0.09123698f, -0.33817485f, 0.02593380f, 0.56627154f, -0.28820267f, 0.26076126f, 0.02791902f, -0.22733201f, 
    -0.58540672f, -0.56862861f, -0.01714334f, -0.26042065f, -0.26659906f, 0.27691534f, 0.16055971f, -0.18279770f, 
    0.13303061f, 0.11458007f, -0.08114368f, -0.12893489f, 0.24734481f, 0.09257862f, 1.01327443f, 0.20926355f, 
    0.05761857f, 0.07079717f, -0.02541446f, 0.24725357f, 0.19615166f, 0.10210405f, 0.23395213f, -0.09590118f, 
    -0.14669901f, 0.42392102f, 0.22976901f, -0.01476103f, 0.02410084f, -0.22175592f, 0.36958036f, -0.42266387f, 
    0.08686937f, 0.07410961f, -0.01850756f, -0.06484653f, -0.01168157f, -0.12882741f, 0.02555348f, -0.05568547f, 
    -0.09239800f, -0.03496432f, 0.01881009f, 0.07025310f, 0.02884899f, 0.00660827f, 0.06201541f, 0.06121423f, 
    -0.13238436f, 0.03652912f, 0.04559634f, -0.10246743f, 0.01930387f, -0.11859619f, -0.11451551f, 0.05128835f, 
    -0.00171355f, -0.02189515f, 0.01851605f, 0.06793195f, -0.10516597f, 0.02826369f, 0.06518354f, -0.09856692f, 
    0.03775335f, 0.10386057f, 0.05389376f, -0.08399250f, 0.00871901f, 0.07122351f, -0.05041257f, 0.03499866f, 
    0.02558295f, -0.07719390f, -0.09454849f, -0.03843531f, -0.02572848f, -0.07834158f, -0.07639495f, -0.11448300f, 
    -0.05250322f, -0.05622029f, -0.00011496f, 0.02625435f, -0.11644565f, -0.12729293f, 0.05855928f, -0.02237120f, 
    0.07998696f, 0.10287088f, 0.10625707f, 0.08022320f, -0.00340388f, -0.11589776f, -0.04702087f, -0.09955589f, 
    0.06585675f, -0.14343134f, -0.14088215f, -0.08310053f, 0.01460496f, -0.04206232f, 0.05845166f, -0.15762772f, 
    -0.02490945f, -0.10405679f, -0.05995218f, 0.03114733f, -0.11427169f, -0.08051212f, 0.02673391f, -0.01058689f, 
    -0.10165116f, -0.05382314f, 0.07398942f, -0.12329040f, -0.09471826f, -0.11229222f, -0.05013025f, 0.03556347f, 
    0.08386845f, -0.01686469f, -0.09863103f, 0.10765515f, -0.05629940f, -0.03195883f, 0.04759054f, -0.05133061f, 
    -0.09023658f, 0.09091508f, 0.04254334f, 0.04099444f, -0.05579491f, -0.08622187f, 0.03607468f, -0.07009710f, 
    -0.07400898f, 0.06471741f, -0.06140258f, 0.00914037f, 0.00283463f, -0.00288334f, 0.07656215f, 0.06642828f, 
    -0.04131023f, -0.13527919f, -0.14654468f, -0.11755450f, -0.05041344f, -0.02769330f, 0.05713649f, -0.05400689f, 
    -0.01833181f, -0.07356904f, -0.09525002f, -0.15939432f, -0.06886655f, 0.01226077f, -0.04598519f, -0.08157722f, 
    0.25255203f, 0.05766021f, 0.22663364f, 0.00567162f, 0.07735902f, 0.04550238f, 0.05025048f, -0.02004928f, 
    0.22131324f, -0.19923645f, 0.21083383f, -0.42183098f, 0.02015359f, 0.30830339f, 0.77463806f, 0.32421198f, 
    -0.10294682f, 0.09919405f, -0.04320677f, 0.02290106f, 0.40194592f, 0.12441844f, -0.05952682f, 0.06545727f, 
    0.18766829f, -0.13353731f, 0.13469435f, -0.19432802f, -0.51235217f, -0.02213461f, 0.15602390f, 0.15307538f, 
    -0.38281819f, 0.04060784f, 0.17089668f, 0.14834264f, -0.12638989f, 0.27918100f, -0.08805820f, -0.10912960f, 
    0.23861828f, 0.05488619f, 0.12053625f, -0.20515691f, -0.01868876f, 0.01843730f, 0.67415494f, -0.07884704f, 
    -0.10286873f, 0.21841259f, -0.03439224f, 0.33547717f, 0.36962718f, -0.03408072f, 0.12506185f, -0.06372278f, 
    -0.26310518f, -0.16362256f, 0.23792550f, 0.15996313f, -0.25387079f, -0.10263945f, 0.04063905f, -0.01155716f, 
    0.18742174f, -0.08889354f, 0.06093517f, 0.01655282f, -0.45630267f, -0.16142197f, 0.38417679f, -0.39293313f, 
    0.19678470f, -0.05875226f, 0.43683833f, -0.47573519f, 0.16457430f, 0.24346566f, -0.40466815f, -0.01243059f, 
    -0.20279863f, -0.07809687f, -0.06228669f, -0.31470960f, 0.09976931f, 0.11300848f, 0.11980090f, -0.31087646f, 
    -0.38315588f, -0.25479114f, 0.25675058f, 0.23416094f, -0.91909355f, 0.77330017f, -0.19092448f, -0.17253774f, 
    0.22215827f, -0.81850207f, 0.05625178f, -0.05786002f, -0.03790805f, 0.02526250f, -0.57430643f, 0.09223108f, 
    0.24086311f, 0.01441598f, 0.30005634f, -0.54924691f, 0.28455031f, -0.19910704f, -0.60082048f, -0.08278459f, 
    -0.17531742f, -0.39458278f, 0.19857994f, 0.03078788f, 0.24050108f, 0.42334622f, 0.00749298f, 0.19916265f, 
    0.18108676f, -0.73374587f, 0.29868993f, 0.38191777f, 0.21684159f, 0.02132549f, 0.42191330f, 0.40098417f, 
    -0.02364491f, -0.06777532f, 0.18613729f, 0.00468875f, -0.25227126f, -0.07202197f, 0.31777665f, 0.22672176f, 
    0.31551352f, 0.00682848f, 0.50826615f, 0.15231918f, 0.24781460f, -0.20568831f, -0.62255484f, 0.34555921f, 
    0.28785205f, 0.00393555f, -0.27976018f, 0.16777967f, -0.11241291f, 0.03684387f, -0.12271626f, -0.02185015f, 
    0.21328658f, 0.04507929f, -0.01687859f, 0.42049900f, -0.31952640f, -0.05879576f, -0.22080706f, -0.03215473f, 
    -0.20633601f, 0.42029610f, 0.14776164f, -0.19378655f, -0.00385511f, 0.28819668f, -0.17811336f, -0.01476672f, 
    0.40310726f, -0.26625156f, 0.11436804f, -0.24759738f, 0.10961654f, 0.21462511f, 0.02271131f, -0.25513327f, 
    -0.37244797f, 0.05787581f, 0.06181314f, -0.04214105f, 0.22574840f, -0.00950140f, 0.20699957f, 0.02498111f, 
    -0.10248198f, -0.09057157f, 0.26273942f, 0.08406500f, -0.10478492f, 0.17512293f, 0.12411057f, -0.17985016f, 
    -0.25709435f, 0.09770890f, -0.00059936f, -0.11718364f, -0.23078643f, 0.01784626f, 0.04069726f, 0.34715566f, 
    -0.16852206f, 0.31726372f, 0.15493107f, 0.25924748f, 0.13856475f, -0.15251631f, -0.08383444f, 0.10777570f, 
    0.19874595f, 0.05876513f, -0.07189731f, 0.13844496f, -0.12164021f, -0.01933829f, -0.10897808f, -0.01277223f, 
    0.28072712f, 0.07778648f, -0.09109132f, -0.43372130f, 0.47662953f, 0.03138025f, -0.29666269f, 0.16263540f, 
    0.15503204f, 0.63503951f, -0.47629282f, -0.16210906f, 0.11347736f, -0.03534089f, 0.22675177f, 0.09895778f, 
    -0.02933649f, 0.15824264f, -0.21446246f, 0.30523500f, -0.23388778f, 0.28505567f, -0.09043430f, 0.25253904f, 
    0.01384992f, 0.14323832f, -0.19838102f, -0.17716114f, -0.04357644f, 0.05939178f, -0.20029925f, -0.06132064f, 
    0.02006760f, 0.45608655f, 0.07243562f, -0.21517469f, 0.03833226f, 0.09131441f, 0.22270834f, -0.25789821f, 
    0.39059177f, -0.49258110f, 0.23984616f, -0.01051409f, 0.12623811f, -0.18751442f, -0.12035501f, -0.10985415f, 
    0.26008669f, -0.60140985f, 0.17397845f, -0.19369987f, 0.29002407f, 0.03170051f, -0.10118923f, 0.04705727f, 
    -0.13546094f, -0.02971078f, 0.05791879f, 0.01115152f, -0.27373537f, -0.28509760f, -0.00175029f, 0.01224711f, 
    -0.35122767f, 0.26380220f, -0.00546561f, -0.32948214f, -0.27650034f, 0.32249260f, 0.12903441f, -0.16922860f, 
    0.39477012f, -0.76576674f, 0.32952675f, 0.14182080f, 0.23679705f, 0.02441020f, -0.22243826f, -0.12715010f, 
    0.19964001f, 0.02854997f, 0.25350544f, -0.38754991f, 0.21850918f, 0.04621551f, -0.38025540f, -0.32533789f, 
    -0.00482146f, -0.14216506f, 0.12326536f, 0.17321441f, 0.21077567f, 0.23746116f, 0.15703616f, 0.09307624f, 
    0.04560487f, -0.80755955f, 0.38252267f, 0.24621958f, -0.06754617f, -0.17299378f, 0.07525456f, 0.55886066f, 
    0.00680316f, 0.01038616f, 0.02975188f, 0.11198050f, 0.11621039f, 0.05710432f, -0.10198258f, -0.08536532f, 
    -0.00960737f, -0.11411075f, -0.07209839f, 0.10964800f, -0.15632789f, -0.08072989f, -0.09375563f, 0.03316892f, 
    0.00736886f, -0.08523887f, -0.12783748f, -0.07463323f, -0.10219569f, -0.05373509f, -0.12452471f, -0.08866075f, 
    -0.04034384f, 0.08655468f, -0.08075541f, -0.10970885f, -0.06263317f, -0.09033294f, -0.01528111f, 0.03626238f, 
    -0.01523410f, 0.05345359f, -0.01831366f, -0.11705047f, -0.17890128f, -0.11063870f, -0.01312578f, 0.04166605f, 
    0.07109978f, -0.06522630f, 0.01424565f, 0.03886628f, -0.05363239f, -0.07135130f, -0.07236869f, -0.01922757f, 
    -0.15203898f, -0.03235247f, 0.04889885f, -0.15575840f, -0.02239609f, -0.15834397f, -0.16088566f, -0.12343050f, 
    -0.11875563f, -0.06680670f, 0.10719744f, 0.03261078f, -0.06558879f, 0.11647037f, 0.00481665f, -0.15403987f, 
    -0.25198236f, 0.07912649f, 0.27413967f, 0.08839947f, 0.35665339f, 0.15292560f, -0.07444789f, 0.40370876f, 
    0.00443309f, 0.29937741f, 0.70200229f, -0.48181549f, -0.06598559f, -0.12189718f, 0.55911869f, 0.17893848f, 
    0.06299084f, 0.01150064f, 0.32360429f, -0.00433524f, 0.29938734f, 0.18307915f, -0.10107774f, -0.15067734f, 
    0.34567946f, -0.21076615f, -0.10602615f, -0.05328050f, -0.13192259f, 0.03256017f, -0.04203602f, 0.56499851f, 
    -0.24102190f, -0.25390884f, -0.14161132f, 0.23496774f, -0.02704275f, 0.07672421f, 0.08978350f, -0.12622793f, 
    -0.00487290f, 0.30679014f, -0.22203787f, 0.19161420f, -0.01844596f, -0.04391825f, 0.54543644f, 0.02104764f, 
    0.02121991f, 0.26907954f, -0.09236024f, 0.06005269f, 0.01760812f, 0.16458490f, 0.01408853f, 0.02837129f, 
    -0.29426503f, -0.23825014f, 0.31251994f, 0.14892241f, 0.00229393f, 0.03740781f, 0.18469034f, -0.05108709f, 
    -0.15461522f, 0.09395366f, 0.20069271f, 0.11303355f, 0.05023433f, 0.06167906f, -0.13409948f, 0.12837274f, 
    0.01483538f, 0.19830181f, -0.09833531f, -0.02478193f, 0.02075057f, 0.04747302f, -0.09599404f, 0.17135192f, 
    -0.04327524f, 0.02093020f, 0.05962479f, 0.09438133f, 0.06266224f, -0.30376813f, -0.00468867f, -0.02507172f, 
    -0.09534290f, 0.14166506f, -0.11721677f, -0.44559854f, 0.81065238f, 0.15347670f, -0.01392712f, -0.44421479f, 
    0.28800279f, -0.54261351f, 0.03536036f, 0.19219071f, 0.09679388f, 0.00350957f, -0.05332729f, -0.01505311f, 
    0.00531459f, 0.34466916f, 0.09635609f, -0.02032879f, 0.03412281f, 0.15494235f, 0.48147431f, 0.33865067f, 
    0.24895009f, -0.18591517f, -0.13258301f, -0.00413088f, -0.22129387f, 0.16336778f, 0.31442660f, 0.10726233f, 
    0.33495235f, 0.24931528f, -0.14702983f, 0.13053721f, 0.01081010f, -0.20244546f, 0.47648561f, 0.00670156f, 
    0.14869323f, 0.06438271f, -0.13668311f, -0.10206475f, 0.62653762f, 0.16958436f, -0.04824317f, -0.19099146f, 
    -0.17782043f, -0.45116353f, 0.18184668f, 0.14762355f, 0.00580981f, 0.34274539f, -0.01171179f, -0.45084321f, 
    0.17075643f, -0.06029296f, 0.06299788f, 0.30262017f, 0.37199932f, 0.30456287f, 0.08052398f, 0.29389623f, 
    0.08790337f, -0.06825978f, -0.03364057f, -0.27129543f, 0.20069303f, 0.03921995f, 0.35329258f, -0.34320429f, 
    -0.32797235f, -0.38948083f, 0.30904958f, -0.08215410f, 0.06925166f, -0.02457055f, 0.16761138f, -0.01090675f, 
    0.22176741f, -0.24664433f, 0.13778724f, 0.29424009f, -0.02330308f, -0.08536732f, 0.04533701f, 0.02066799f, 
    0.30989429f, -0.06516846f, 0.34649697f, 0.20206492f, 0.02129002f, -0.04435958f, 0.05609195f, -0.04470507f, 
    -0.11669689f, 0.10043787f, -0.35003823f, -0.34983692f, 0.42208552f, 0.33065981f, -0.34720778f, -0.34659424f, 
    0.16389345f, 0.23255600f, -0.29006884f, -0.03785862f, -0.55681878f, 0.08804303f, 0.26653713f, -0.16519804f, 
    0.11763686f, 0.57686377f, -0.26683575f, 0.34981662f, 0.00190256f, 0.46530703f, 0.22093834f, 0.08897884f, 
    0.33547869f, -0.09770701f, -0.07036292f, 0.04208734f, -0.50434220f, 0.29521659f, 0.03641759f, 0.05570823f, 
    0.16243388f, -0.34596017f, 0.16768754f, 0.06946950f, 0.21985088f, 0.22158191f, 0.01642857f, 0.06692068f, 
    0.10294577f, 0.94301975f, 0.10667517f, -0.18997180f, 0.04350235f, 0.14304222f, 0.07236494f, 0.17309178f, 
    -0.21713157f, -0.27447283f, 0.15877503f, -0.56587338f, 0.07126923f, 0.15356517f, -0.22800459f, 0.03409943f, 
    0.03945849f, 0.32301271f, 0.06100310f, -0.13809916f, 0.29038182f, 0.16162805f, -0.28585321f, 0.17385955f, 
    -0.20947930f, 0.33300859f, -0.25490049f, 0.13206145f, -0.00187586f, 0.09783626f, -0.10427920f, 0.00613772f, 
    -0.01853831f, -0.01285918f, 0.10854842f, -0.11896615f, 0.03796578f, -0.06817809f, 0.00766608f, -0.09097592f, 
    -0.05167330f, 0.07609988f, 0.07430300f, -0.06434735f, -0.06164578f, 0.07587630f, 0.08523039f, 0.05454985f, 
    0.04720769f, 0.01209097f, -0.10812449f, -0.04963967f, 0.07576686f, -0.15843311f, -0.10525742f, 0.07891450f, 
    -0.08881722f, -0.08418106f, -0.02564326f, 0.05234128f, -0.03122821f, -0.12607938f, -0.08168225f, -0.14719057f, 
    0.05489760f, -0.08803251f, -0.15207231f, -0.00524757f, -0.00360180f, 0.06708620f, -0.13182414f, 0.08984707f, 
    -0.04357461f, -0.15765855f, 0.08369115f, -0.11951472f, -0.10402182f, -0.08793493f, 0.02136603f, -0.02146833f, 
    -0.12375533f, 0.02564383f, -0.10722593f, -0.13751538f, -0.13886456f, -0.13818865f, -0.04919374f, 0.05515079f, 
    -0.15800528f, -0.01950722f, 0.02480005f, -0.13223948f, -0.08742709f, -0.06255896f, 0.02769743f, -0.05720311f, 
    0.13629922f, -0.30720013f, 0.36706215f, 0.07184890f, -0.23952584f, -0.26937997f, -0.00240226f, 0.18322253f, 
    0.20418759f, -0.46143347f, 0.43428612f, 0.32051137f, 0.16495897f, -0.21184501f, 0.00074598f, 0.02098650f, 
    0.11467998f, 0.03016545f, -0.00016551f, -0.07592800f, -0.22222207f, -0.38541517f, -0.06083265f, 0.06009434f, 
    -0.06045320f, 0.28575599f, -0.35885432f, -0.63932526f, 0.53795213f, -0.11144352f, 0.19023149f, -0.10685313f, 
    0.39639574f, -0.58602399f, 0.19294505f, 0.27187556f, 0.35159558f, -0.02844459f, 0.24755043f, -0.33247960f, 
    0.13537221f, 0.25321877f, 0.28087673f, 0.04214411f, 0.02981947f, 0.07151033f, 0.03667381f, -0.41167200f, 
    0.07024068f, 0.00461517f, -0.30749670f, 0.11079923f, 0.13146397f, 0.06776137f, 0.29992133f, -0.26141760f, 
    -0.14386444f, 0.10751028f, 0.12459157f, 0.09260568f, -0.22781827f, -0.43894079f, -0.24709447f, 0.54693592f, 
    0.03319428f, 0.16982558f, -0.02735535f, -0.05986005f, -0.18157576f, -0.15840761f, 0.17195520f, 0.30406988f, 
    -0.01912226f, -0.34566846f, 0.33777472f, 0.47665954f, 0.15808754f, -0.33827278f, -0.09024438f, -0.05668159f, 
    0.28736883f, -0.08242759f, -0.06675604f, 0.06360774f, 0.14858010f, 0.05157910f, 0.02846928f, 0.09227156f, 
    0.14880808f, 0.08076719f, -0.06078297f, -0.07774571f, -0.21701612f, -0.27135983f, -0.16374440f, -0.26059645f, 
    -0.21064992f, 0.20486726f, 0.03130000f, -0.13827664f, -0.23717181f, 0.02314029f, 0.14825667f, -0.03981825f, 
    0.44989949f, -0.28422219f, 0.06826969f, -0.20729588f, 0.10790148f, 0.11750513f, 0.37507141f, -0.04409057f, 
    -0.00494797f, 0.05833819f, 0.06366754f, 0.00606576f, 0.01643897f, 0.07385250f, 0.13899155f, -0.21625718f, 
    -0.10703854f, 0.25103214f, 0.27562496f, 0.06983212f, 0.13241135f, 0.18289700f, 0.23116450f, -0.34322557f, 
    -0.11811353f, 0.34883946f, -0.13168815f, -0.08491921f, -0.09105268f, 0.11264426f, 0.12330576f, -0.19087768f, 
    0.16181667f, 0.66711086f, -0.40528312f, -0.09245579f, -0.11630661f, 0.48589724f, 0.42749098f, 0.03128012f, 
    -0.09956455f, 0.10379236f, -0.06444627f, 0.00058285f, -0.30427855f, 0.19210802f, -0.02755404f, 0.26289111f, 
    0.03801392f, -0.28152454f, 0.48605698f, 0.06034362f, 0.40194955f, 0.28561813f, 0.12899256f, -0.02762294f, 
    0.40087527f, 0.01516884f, 0.16981822f, 0.02719114f, 0.00162676f, 0.04142743f, -0.15700355f, 0.37574130f, 
    -0.34363768f, -0.31804132f, 0.17573428f, -0.42206773f, 0.24596450f, -0.10005010f, 0.09111481f, 0.14026114f, 
    0.05855508f, -0.01380876f, 0.36764917f, 0.07960817f, 0.21983142f, 0.23385860f, -0.15703057f, 0.26210496f, 
    0.16759720f, 0.01817366f, -0.39996293f, 0.02478791f, 0.04063193f, 0.06199641f, 0.04413402f, 0.25288257f, 
    -0.00773214f, -0.19300787f, 0.07759403f, 0.10038684f, 0.05910199f, -0.39315376f, 0.17538305f, 0.10698064f, 
    0.14416100f, -1.21490371f, 0.18425724f, -0.04306967f, 0.21583350f, -0.20972304f, 0.04880437f, 0.20100456f, 
    -0.08694560f, -0.05071686f, -0.66593754f, 0.16402081f, 0.26823261f, 0.27276984f, 0.06340410f, -0.30583325f, 
    0.27717370f, 0.35060912f, 0.23678635f, -0.79098904f, -0.70305008f, -0.28506225f, -0.23792695f, 0.25821814f, 
    -0.71960694f, 0.73721033f, -0.28639588f, 0.00687846f, -0.34445000f, 0.43427652f, -0.11327288f, 0.12127396f, 
    0.14065561f, -0.15154915f, -0.02013742f, 0.13210490f, 0.09348857f, 0.33658722f, -0.20129310f, 0.18252848f, 
    -0.45826462f, 0.17931606f, 0.18942513f, -0.09579940f, 0.11697456f, -0.33804837f, 0.11639390f, 0.10771664f, 
    -0.24892007f, -0.36932161f, 0.18295644f, -0.20849632f, -0.03832963f, 0.29325297f, -0.17070156f, -0.24442968f, 
    0.01424974f, -0.03395152f, -0.04052822f, -0.04682896f, 0.10408348f, 0.09327871f, -0.07210821f, -0.09225750f, 
    -0.00372081f, -0.10036333f, -0.07219194f, 0.00316167f, -0.07006586f, 0.02848308f, -0.09090585f, -0.04773559f, 
    -0.08573167f, -0.02423909f, -0.05115645f, 0.10548083f, -0.04973212f, -0.09899649f, 0.03396182f, -0.01496002f, 
    -0.08301301f, -0.07173322f, 0.01573825f, 0.10988663f, -0.03588246f, 0.07258727f, -0.01794016f, -0.08958082f, 
    -0.09894690f, -0.02495091f, 0.07350418f, -0.06306335f, 0.00582799f, -0.04798840f, -0.08450776f, 0.06522417f, 
    0.00354657f, 0.01410711f, -0.05704018f, -0.04392050f, -0.12422928f, -0.06605870f, 0.09614773f, 0.04300816f, 
    0.05388385f, -0.09245726f, -0.12324992f, -0.04899390f, 0.09323929f, 0.06783707f, 0.06523888f, -0.06795108f, 
    -0.02168490f, -0.05783094f, -0.09216416f, 0.08850549f, 0.02248903f, -0.09194653f, 0.00917682f, 0.09880349f, 
    0.12839419f, -0.06128470f, 0.16295496f, 0.07253659f, 0.43495336f, 0.01792892f, -0.23746435f, 0.04378329f, 
    -0.15729792f, 0.02150131f, 0.14438480f, 0.08972955f, 0.15252255f, -0.13828063f, 0.03831593f, -0.04783983f, 
    -0.13147977f, 0.00054199f, 0.06717897f, 0.12061194f, 0.36907715f, 0.13880455f, -0.06631105f, -0.39518860f, 
    0.05326603f, 0.22143519f, -0.01501992f, 0.66299397f, 0.06921678f, 0.09573403f, 0.01703284f, 0.14964449f, 
    -0.86629343f, 0.40544373f, -0.25268397f, 0.07016077f, 0.22812440f, 0.12526225f, 0.13543837f, 0.05546269f, 
    -0.10184686f, 0.01391806f, -0.38158250f, 0.30211231f, -0.06114313f, 0.06814577f, -0.09892350f, 0.31633508f, 
    -0.06673524f, 0.23806211f, 0.02038560f, -0.23537414f, -0.02679620f, -0.87685162f, 0.07522080f, 0.12988515f, 
    -0.15044877f, -0.25745350f, 0.24312189f, -0.52146304f, -0.10551362f, 0.29644918f, -0.33919781f, -0.22650470f, 
    -0.11813179f, 0.35985216f, -0.45118546f, 0.04399113f, 0.03710907f, 0.16969018f, 0.17842607f, 0.11734263f, 
    -0.05220087f, 0.11713605f, -0.40447456f, 0.43983716f, -0.15443793f, 0.00168887f, -0.51532799f, -0.19936441f, 
    0.46948248f, -0.08429077f, 0.06665566f, 0.28459117f, 0.30530202f, 0.12404647f, -0.07036579f, 0.26513350f, 
    0.30824420f, -0.15000704f, -0.10865472f, 0.05532014f, 0.19465546f, -0.34270516f, -0.15482964f, 0.17916714f, 
    0.18972042f, -0.13330291f, -0.07787193f, -0.20020649f, -0.08731943f, -0.03513179f, 0.59954691f, 0.06711198f, 
    0.21119449f, -0.00149983f, -0.03306457f, 0.17207332f, -0.18971917f, 0.01144327f, -0.21437022f, 0.17886578f, 
    0.34844059f, 0.20429583f, 0.01572219f, -0.00314272f, 0.03186760f, 0.04864834f, -0.08121303f, -0.05530323f, 
    -0.17124213f, 0.54200602f, -0.21595584f, -0.14086361f, 0.16762739f, 0.03232268f, -0.17105034f, -0.49020913f, 
    0.10647969f, -0.09120402f, 0.18123284f, 0.01520495f, -0.32102799f, -0.10495702f, -0.03123317f, 0.06896634f, 
    0.54309922f, -0.07442185f, -0.06275999f, 0.28406525f, 0.25927088f, -0.49444741f, -0.04178013f, 0.10393314f, 
    0.13808918f, -0.00496788f, -0.21902539f, 0.04853162f, -0.27422643f, -0.13195388f, -0.07451178f, 0.04548290f, 
    -0.02951683f, 0.39308539f, 0.02541498f, 0.09837452f, 0.61292684f, -0.15163402f, -0.10925905f, -0.15801364f, 
    0.77882564f, 0.68097180f, 0.00085502f, 0.20554683f, 0.28071150f, -0.01034948f, -0.18402606f, 0.17562038f, 
    0.23476593f, -0.21458596f, 0.35824749f, -0.13691987f, -0.02987417f, 0.02538168f, -0.20343292f, -0.06984352f, 
    -0.39332601f, -0.07697172f, 0.08325311f, -0.23293571f, -0.09351926f, 0.23405299f, 0.01526167f, 0.03988659f, 
    0.17193812f, -0.03588270f, -0.08748356f, 0.04327824f, -0.08842964f, 0.02232443f, 0.24052377f, 0.72881424f, 
    0.17567094f, -0.18394127f, 0.23444597f, 0.02364963f, 0.01615827f, -0.27581903f, -0.13516754f, 0.07659218f, 
    -0.09096175f, 0.07607638f, -0.47120997f, 0.40480009f, 0.24035352f, 0.15010241f, -0.52962458f, -0.41918090f, 
    0.25139213f, 0.11167413f, 0.02746080f, -0.36249313f, -0.12272800f, -0.40447652f, -0.09660102f, -0.66601300f, 
    0.05288716f, 0.33427393f, -0.03272531f, 0.13323817f, 0.39433306f, 0.01479291f, 0.12604520f, 0.19975503f, 
    0.07611360f, -0.38618690f, 0.00038945f, 0.17660962f, 0.53416395f, -0.34866506f, 0.09555653f, -0.01642871f, 
    -0.29573554f, 0.14244340f, 0.21959314f, -0.18343104f, 0.12891032f, -0.01151539f, 0.11964121f, -0.09586210f, 
    0.18127996f, -0.21033385f, -0.19344589f, -0.22959626f, -0.03213375f, 0.02668656f, 0.09762244f, 0.00642350f, 
    0.02843269f, 0.13195193f, -0.02403519f, 0.14461069f, 0.03354297f, -0.07545105f, -0.13876563f, 0.06084823f, 
    -0.28515172f, 0.06934660f, 0.02970742f, 0.05910574f, 0.08474743f, 0.24876463f, 0.05868590f, 0.18154867f, 
    0.05696725f, 0.30405641f, 0.35747883f, -0.09395903f, -0.19459122f, 0.10011682f, 0.88105130f, 0.18591855f, 
    0.01474557f, 0.06650021f, 0.21804097f, -0.24219847f, 0.47802818f, 0.03547767f, -0.11465940f, -0.07178185f, 
    0.05263374f, -0.09800122f, 0.14141059f, 0.32615128f, -0.17297876f, -0.04289541f, -0.11572169f, 0.56254554f, 
    -0.00256494f, -0.06687143f, -0.10872159f, 0.38747427f, 0.01586401f, -0.14173806f, 0.14533213f, 0.03563944f, 
    0.05535990f, 0.14234491f, -0.09663078f, -0.08577520f, 0.06399754f, -0.08289510f, 0.66402513f, 0.12561460f, 
    0.09536783f, 0.26548681f, -0.22257465f, 0.21533005f, 0.28269747f, 0.06590182f, -0.02361941f, 0.02866288f, 
    -0.04666457f, -0.12794812f, 0.46745452f, 0.36820814f, -0.20789729f, -0.16810277f, 0.35211068f, 0.14656271f, 
    0.07313549f, -0.10459000f, 0.09284513f, 0.09162623f, 0.01050979f, -0.02374183f, -0.00406322f, -0.11224178f, 
    -0.07222835f, 0.03631816f, 0.10053377f, -0.09769689f, -0.17290440f, -0.08570244f, 0.12881027f, 0.00563430f, 
    -0.15423571f, -0.11358806f, -0.07253076f, -0.11698287f, -0.01400311f, -0.03781769f, 0.11533198f, 0.04303778f, 
    -0.16632712f, 0.04086483f, -0.14469720f, -0.02826202f, 0.21329199f, 0.03755919f, -0.01919991f, 0.03361715f, 
    -0.14624518f, -0.09035545f, -0.04859268f, 0.04850889f, -0.06428886f, -0.14307095f, -0.09455946f, -0.05200996f, 
    -0.16954955f, -0.08274621f, -0.00317794f, 0.00304788f, -0.15086979f, -0.14111954f, -0.09629294f, 0.08594540f, 
    0.01543031f, 0.02321529f, 0.00229554f, 0.07540734f, -0.04007735f, -0.14115562f, 0.03465819f, -0.01196102f, 
    -0.01538476f, 0.04440070f, -0.10548942f, -0.10009208f, -0.03370409f, -0.00845827f, 0.09867578f, -0.01809978f, 
    -0.02586114f, 0.11390796f, 0.13914743f, 0.02006488f, -0.00027368f, -0.08407634f, 0.06302806f, 0.32261381f, 
    0.07348657f, 0.46566004f, 0.69086933f, -0.43338713f, 0.03958840f, -0.33179003f, -0.41919920f, 0.20430045f, 
    0.04012094f, -0.05082768f, -0.07174603f, 0.16461129f, -0.27862924f, 0.29084852f, 0.06495202f, -0.02246212f, 
    0.33928719f, -0.35077193f, -0.05805135f, 0.56330687f, -0.24705836f, 0.12995827f, 0.14814134f, 0.33748305f, 
    -0.22861831f, -0.46446285f, 0.06798091f, -0.00161671f, 0.14992259f, 0.29652554f, 0.17570436f, -0.07899111f, 
    0.12231801f, 0.21234068f, 0.00234648f, 0.31660327f, 0.04464597f, 0.16545518f, -0.00768089f, -0.01961745f, 
    -0.08213446f, 0.04435175f, -0.19872631f, 0.10683559f, 0.00114697f, 0.04249796f, 0.15628734f, -0.09404274f, 
    -0.17556617f, 0.05999250f, 0.11130805f, 0.14975645f, -0.12106099f, -0.16243692f, 0.01711103f, -0.10531061f, 
    0.05316560f, -0.12024201f, 0.30618548f, -0.03865369f, -0.06896382f, -0.10335498f, 0.08813510f, 0.08404689f, 
    0.38564792f, 0.11537187f, 0.81072605f, -0.00213976f, 0.16508624f, -0.64512324f, -0.30445203f, 0.26607290f, 
    -0.02549925f, 0.05103141f, -0.27131653f, -0.00882526f, -0.18758862f, -0.11491808f, -0.04448985f, -0.13312070f, 
    0.19187751f, 0.38942835f, -0.00920671f, 0.55015820f, -0.19048476f, -0.11617316f, 0.04317902f, 0.31710801f, 
    0.14899741f, 0.40543681f, 0.09525572f, 0.31968430f, 0.04719402f, 0.22262269f, 0.07194722f, 0.04048586f, 
    0.34667912f, 0.13324559f, 0.13141097f, -0.21216218f, 0.01686897f, 0.08818249f, -0.20454472f, -0.31536776f, 
    -0.27371359f, 0.05858614f, -0.15701187f, -0.03758348f, 0.10629971f, 0.08303645f, 0.31564665f, 0.03613443f, 
    -0.01371155f, -0.31674120f, 0.50111771f, 0.11466189f, -0.22614169f, -0.11541610f, 0.24797493f, 0.24390601f, 
    -0.09418043f, -0.00281793f, 0.05091877f, -0.12323053f, -0.10604136f, -0.02567557f, -0.06786901f, -0.09485503f, 
    0.04910804f, -0.01025959f, 0.15098205f, 0.04956543f, 0.07597328f, -0.08607511f, 0.09621143f, -0.05732974f, 
    -0.02086173f, -0.00181732f, -0.04560556f, -0.11604476f, 0.09920527f, 0.08979103f, 0.09184165f, -0.05715307f, 
    -0.02814723f, 0.05082287f, -0.08117102f, -0.05764355f, 0.03622572f, -0.06705761f, -0.05599475f, -0.02889700f, 
    0.11185686f, 0.01322969f, -0.14467221f, 0.05859387f, 0.05085948f, -0.02692218f, -0.06005321f, -0.03411939f, 
    -0.00386839f, 0.03253219f, -0.14901899f, -0.06084560f, -0.07016800f, -0.12657349f, -0.06908691f, -0.07215422f, 
    -0.09930267f, -0.06064462f, -0.07926679f, -0.13105229f, -0.09932186f, 0.08324961f, -0.10588849f, -0.09896793f, 
    -0.13649261f, 0.09139957f, 0.02068169f, -0.07323376f, -0.07708593f, -0.12866285f, 0.12914270f, 0.04798565f, 
    0.07570652f, -0.20549577f, 0.12981278f, 0.03598778f, -0.05720024f, 0.09936830f, 0.12875456f, 0.27504957f, 
    -0.18839449f, 0.33507410f, 0.24971324f, 0.17776486f, 0.27875432f, -0.55814677f, -0.27111536f, 0.04970542f, 
    0.17073593f, -0.08393533f, 0.19381839f, -0.15742902f, -0.11992892f, 0.12386437f, -0.06525153f, -0.34903562f, 
    0.03570956f, 0.30127540f, -0.09417695f, 0.33283663f, -0.06282412f, -0.09734315f, -0.13374059f, 0.51231027f, 
    0.21912019f, 0.13765551f, -0.16184482f, 0.14871116f, 0.19798498f, 0.07780324f, 0.06096148f, -0.02659531f, 
    0.22800863f, 0.03950297f, 0.07243141f, -0.01933578f, 0.07021759f, 0.09185525f, -0.23945856f, -0.01729596f, 
    -0.00685230f, 0.01836804f, -0.09225204f, -0.22586541f, -0.12451315f, 0.17544740f, -0.01626891f, -0.01399471f, 
    -0.17820357f, -0.29309162f, 0.41233197f, 0.30700082f, -0.06846138f, 0.02147252f, -0.03800494f, -0.11726263f, 
    0.00943639f, 0.10550889f, 0.02043793f, -0.11921608f, 0.64311683f, 0.31628233f, 0.04615345f, 0.00697618f, 
    -0.20695662f, -0.33228162f, -0.10468043f, -0.27012879f, -0.12607217f, 0.21151429f, 0.41294354f, -0.05339113f, 
    -0.08561355f, 0.08749755f, 0.22856815f, 0.12047432f, 0.49657857f, 0.37036055f, 0.03910914f, -0.01019660f, 
    0.22203195f, -0.05703707f, 0.18438505f, -0.55456012f, 0.14703752f, 0.33839110f, -0.07504288f, 0.27409312f, 
    -0.15351747f, -0.35885698f, 0.21984887f, -0.03819347f, 0.03516437f, -0.04579277f, 0.08066400f, -0.01726621f, 
    0.33496001f, -0.25501800f, -0.08018165f, 0.33768842f, 0.14361809f, -0.21790372f, -0.04794678f, 0.04643838f, 
    0.18062577f, 0.12934431f, 0.27846083f, 0.04595785f, -0.02946193f, 0.08769493f, -0.40177721f, 0.15051997f, 
    -0.14984965f, -0.27392742f, -0.19130526f, 0.11774838f, 0.12894161f, 0.26334107f, -0.23896970f, -0.08918861f, 
    -0.00904538f, 0.07914776f, 0.03526612f, 0.08162908f, 0.02105555f, -0.11372639f, -0.09667294f, -0.12646052f, 
    0.10833202f, -0.01006555f, -0.02316358f, -0.04825747f, -0.00179694f, 0.03997982f, -0.06968252f, -0.07023464f, 
    -0.03724903f, -0.00124066f, 0.03001970f, -0.02027779f, 0.03253774f, 0.06892888f, -0.10769083f, -0.10059857f, 
    0.01593731f, 0.04932018f, 0.08084553f, -0.05806878f, -0.07828689f, -0.10074025f, -0.09177480f, 0.03434628f, 
    -0.00556247f, 0.07582014f, 0.01893476f, 0.02850007f, 0.02147999f, -0.06799970f, 0.06469027f, -0.06837760f, 
    -0.11192735f, 0.06642269f, -0.01341267f, 0.04098290f, 0.01749193f, 0.10843626f, 0.05773437f, -0.01584484f, 
    -0.04703499f, -0.13658676f, -0.13246676f, -0.00471580f, -0.01493978f, -0.07336031f, -0.03194141f, 0.03630891f, 
    -0.11772725f, 0.08162896f, 0.05536497f, -0.10581646f, -0.06688551f, -0.10444939f, 0.04862135f, -0.06983788f, 
    0.07718005f, 0.26381925f, 0.31712002f, -0.06220846f, 0.20453343f, -0.04618199f, 0.15297584f, 0.25690863f, 
    0.23716000f, -0.33663461f, -0.46900460f, -0.04807921f, 0.13200100f, 0.11492267f, -0.29330271f, 0.30572274f, 
    0.14533748f, 0.08916874f, -0.12901850f, 0.22601165f, 0.23102409f, -0.28763643f, 0.10713245f, -0.28196710f, 
    0.01840997f, 0.33590764f, -0.04904496f, -0.04143080f, -0.56160378f, 0.01093745f, 0.11210632f, -0.46017823f, 
    -0.54700613f, 0.28955749f, -0.14031292f, 0.16556588f, -0.20476942f, 0.12751606f, 0.12156256f, -0.04829165f, 
    0.04939865f, 0.19575560f, -0.13828045f, -0.11296383f, 0.04683385f, 0.35825655f, 0.39273331f, 0.28394228f, 
    0.24995035f, 0.00315866f, -0.21907930f, 0.18946905f, 0.19211872f, -0.44759199f, 0.62503839f, -0.00307933f, 
    -0.01750653f, 0.05342099f, 0.10585519f, -0.16029204f, -0.06924825f, 0.01906438f, 0.24340062f, -0.13290586f, 
    0.06186868f, -0.03313331f, 0.04977351f, -0.02121273f, 0.05071065f, 0.22436053f, 0.17339624f, -0.05844114f, 
    0.01352148f, -0.37928781f, -0.13392374f, 0.06424604f, -0.15831460f, 0.10749232f, 0.53962469f, -0.04968487f, 
    0.29828432f, -0.13162036f, 0.35033643f, -0.10235434f, -0.04631916f, -0.14035882f, 0.03303051f, 0.14753239f, 
    -0.13659260f, 0.25069508f, -0.11610019f, 0.59644961f, -0.66375530f, -0.32972285f, 0.28723365f, 0.17545182f, 
    0.17853157f, -0.36462364f, 0.16558890f, 0.41183636f, 0.12084568f, -0.25038543f, 0.25951591f, -0.04164923f, 
    0.13052507f, 0.17220291f, 0.16020104f, -0.13071162f, 0.03332629f, -0.01980912f, 0.67052937f, -0.25341520f, 
    0.45177886f, -0.11777241f, 0.00493434f, 0.43881273f, 0.11344870f, -0.12582250f, 0.17663866f, -0.18097472f, 
    0.08267260f, 0.08534324f, 0.47610906f, 0.18506408f, 0.06675693f, 0.02416477f, -0.30069244f, 0.10974943f, 
    0.11176867f, 0.18663643f, 0.03289898f, -0.07615583f, -0.32554948f, -0.15251999f, 0.30266187f, 0.04991842f, 
    0.32094783f, -0.14074664f, 0.09955611f, 0.10666262f, 0.13516329f, -0.18928365f, -0.43931034f, 0.16004856f, 
    0.37111163f, 0.01114451f, -0.17245097f, 0.25666818f, -0.68468088f, 0.11797659f, 0.12466571f, 0.18079482f, 
    -0.05528401f, 0.12786672f, -0.23803945f, 0.71816105f, -0.67505646f, -0.06508338f, 0.28486830f, -0.59100437f, 
    -0.13351494f, 0.01347396f, 0.37436396f, -0.16814108f, -0.05483355f, 0.20373300f, -0.03341397f, 0.05564560f, 
    0.16718276f, 0.17151164f, 0.17601934f, -0.30409682f, 0.03743508f, 0.23624532f, -0.21912387f, -0.19681071f, 
    -0.03423961f, -0.24625953f, 0.22247687f, 0.33243874f, 0.14578058f, 0.13168794f, 0.52908224f, -0.11299532f, 
    0.03408302f, 0.23358095f, -0.03593284f, -0.25310510f, 0.10799831f, -0.05432145f, -0.33669013f, 0.21868438f, 
    -0.16782436f, 0.08319487f, 0.05274620f, -0.00216198f, -0.00162782f, 0.05227535f, 0.04651760f, 0.40220496f, 
    -0.12905329f, 0.60364026f, 0.18310238f, 0.13952957f, 0.03913007f, 0.05146233f, -0.38916084f, 0.27672577f, 
    0.12213108f, 0.01656250f, 0.26091880f, 0.05930617f, 0.26553485f, -0.16514409f, 0.07744434f, -0.12792458f, 
    0.22877674f, -0.25102171f, -0.16864416f, 0.20839249f, 0.23504159f, 0.10400029f, -0.32905996f, 0.42804143f, 
    -0.09799645f, 0.44540086f, -0.44896907f, 0.02128706f, -0.20095541f, 0.09075616f, 0.31411380f, -0.02502699f, 
    0.04145663f, 0.30134341f, -0.25361428f, 0.51427573f, -0.18929492f, 0.31809920f, 0.21879576f, 0.47336143f, 
    0.11527492f, 0.28340030f, -0.13590010f, -0.11339919f, -0.03874648f, 0.01616042f, -0.03492939f, -0.15792052f, 
    -0.08353035f, 0.35171351f, 0.35307750f, -0.14419322f, -0.02079154f, -0.11095784f, 0.16025034f, -0.23233770f, 
    -0.06742769f, -0.00354830f, 0.07696308f, -0.04099236f, 0.08688321f, -0.04290263f, -0.03639642f, 0.05926416f, 
    -0.14786039f, 0.03665386f, -0.13139635f, -0.03166629f, -0.01599198f, -0.07289675f, 0.09308030f, 0.02331323f, 
    -0.04409872f, 0.10869883f, 0.02791588f, 0.05038936f, -0.04631591f, -0.07136495f, 0.09527136f, -0.10683671f, 
    0.05679381f, -0.05010204f, -0.06773876f, -0.16850062f, -0.08441588f, -0.03967157f, 0.06681564f, -0.07726415f, 
    0.01838949f, -0.08484031f, 0.03963318f, -0.00741269f, 0.06553689f, -0.11288124f, -0.03562756f, -0.01676717f, 
    -0.14275765f, -0.06598385f, -0.09189897f, 0.06981784f, -0.17246687f, 0.04540628f, 0.07423927f, -0.06666184f, 
    -0.13063510f, 0.01122493f, -0.12059385f, -0.00610258f, 0.05221299f, 0.07485682f, -0.01505659f, -0.05735597f, 
    -0.13803561f, -0.11225446f, -0.11677408f, -0.12225985f, -0.01567025f, -0.04880800f, -0.10031752f, -0.04894241f, 
    -0.04371720f, -0.05933367f, 0.37170830f, 0.10293490f, 0.20984951f, 0.32994139f, -0.30320081f, 0.08911003f, 
    -0.51204467f, 0.26635414f, 0.10650731f, -0.21712536f, -0.07374947f, 0.00851328f, 0.26253316f, -0.52180904f, 
    -0.33802781f, -0.07531583f, 0.39718530f, -0.05960412f, 0.24525939f, 0.05385582f, -0.06268674f, 0.11154576f, 
    0.11381039f, 0.14060348f, 0.17051660f, -0.11803698f, 0.67727858f, 0.29736960f, 0.21713264f, -0.51111436f, 
    0.02924738f, -0.32136273f, 0.18410651f, 0.21803728f, 0.13304469f, -0.23983730f, -0.22279426f, -0.02703655f, 
    -0.38820174f, 0.06721201f, 0.12210110f, 0.07224726f, 0.05141582f, -0.24842744f, -0.06308886f, 0.13478716f, 
    0.18736352f, -0.14547832f, 0.07352414f, 0.17485084f, -0.67566752f, 0.28383687f, 0.12968491f, 0.06484675f, 
    0.45298082f, -0.11609387f, -1.20442998f, -0.01034021f, 0.24486732f, -0.04788744f, 0.66787040f, -0.15084958f, 
    -0.10476818f, 0.27851501f, -0.07368454f, 0.05948222f, -0.01906954f, 0.10486557f, 0.10523248f, -0.17875263f, 
    0.02406118f, 0.45649669f, -0.70961642f, 0.34937370f, -0.07124260f, 0.39133939f, -0.27623746f, -0.26412380f, 
    0.07947063f, 0.08929108f, 0.24103549f, 0.13920076f, -0.28378466f, -0.07856537f, 0.00866854f, 0.23606978f, 
    0.09193279f, 0.00980533f, 0.20725676f, 0.40704352f, 0.45928437f, 0.07409752f, 0.24948224f, 0.00140684f, 
    0.54297489f, -0.43012878f, 0.23420192f, -0.04472923f, 0.19001694f, -0.24776302f, 0.08944201f, 0.24246682f, 
    -0.18264017f, -0.14064036f, -0.02141481f, -0.11415113f, -0.03705128f, -0.08140557f, -0.23422784f, 0.06024422f, 
    0.19684079f, -0.12089720f, 0.13215365f, 0.01778235f, -0.16170573f, 0.09468638f, -0.05042765f, 0.08395196f, 
    0.06938850f, 0.25077745f, -0.32316932f, 0.12799007f, 0.32072592f, 0.16304263f, -0.07824337f, 0.03673677f, 
    -0.07450043f, 0.17152172f, -0.22569171f, -0.08895893f, -0.22544689f, -0.08045737f, -0.01572619f, -0.26061267f, 
    0.30382937f, 0.73679155f, -0.63318628f, 0.28809699f, 0.10336459f, 0.46503553f, -0.32763824f, -0.23306695f, 
    0.00980514f, 0.05474579f, -0.02780590f, -0.04170891f, -0.28314701f, 0.24637330f, 0.10230377f, 0.07602316f, 
    0.14105755f, -0.09891575f, 0.51415646f, 0.04387288f, 0.45508578f, 0.45824951f, 0.11018222f, 0.03816242f, 
    0.45048076f, 0.30641213f, 0.01694608f, -0.15118530f, 0.24061017f, 0.07703473f, -0.10699660f, 0.46718800f, 
    -0.05652906f, -0.25985670f, -0.04015744f, -0.00125737f, 0.05164546f, 0.04904273f, -0.50444621f, 0.12705426f, 
    0.00135991f, 0.17351592f, 0.41720954f, -0.29331923f, 0.13334368f, 0.34785065f, -0.24412763f, 0.33801243f, 
    0.07591828f, 0.21282867f, -0.42280751f, -0.06022714f, 0.27011168f, 0.11181017f, -0.20391344f, 0.11496588f, 
    0.18166751f, 0.14742532f, 0.10513109f, -0.08382298f, 0.00444073f, -0.24602956f, 0.24918586f, 0.24627237f, 
    0.17185925f, -0.30942458f, 0.25571802f, -0.02005088f, 0.32977802f, -0.47290567f, -0.17622893f, 0.15530324f, 
    0.37518123f, 0.10746102f, -0.11982053f, 0.22836611f, -0.03699335f, 0.02650323f, 0.09186536f, 0.24040753f, 
    0.12118686f, -0.02254163f, -0.10108215f, 0.33421272f, -0.43881315f, 0.02738761f, 0.04177760f, -0.34868637f, 
    -0.19483112f, -0.37382001f, 0.29473001f, -0.21567011f, 0.00630216f, 0.14511661f, 0.02778037f, -0.35773504f, 
    0.41460901f, -0.04915325f, 0.22084941f, -0.31723782f, 0.21719573f, 0.08218788f, -0.13310294f, -0.30452392f, 
    -0.09253791f, -0.13488497f, -0.00868569f, 0.29554513f, 0.14114401f, 0.03322105f, 0.24816477f, -0.03020709f, 
    0.09333378f, 0.13035941f, -0.13540237f, 0.02976984f, 0.06674692f, 0.01689410f, 0.00706846f, -0.16284713f, 
    0.37947398f, 0.21545671f, -0.38746256f, -0.07624882f, -0.20654586f, -0.08492365f, 0.20301631f, -0.27262247f, 
    -0.11384098f, -0.11260461f, -0.43648320f, 0.43282759f, 0.10983338f, 0.49314222f, -0.14016728f, -0.24033764f, 
    0.27009675f, -0.07865714f, 0.05495913f, 0.20249838f, -0.36620167f, 0.22155540f, -0.08979426f, 0.33721828f, 
    0.03548649f, -0.03140219f, 0.06418394f, 0.46924493f, -0.27172074f, -0.15334234f, 0.14486517f, -0.24543205f, 
    -0.08675023f, 0.25311390f, 0.19605534f, -0.27866146f, 0.27067506f, 0.05340675f, -0.11617546f, 0.21364303f, 
    -0.11484274f, -0.43618935f, 0.20300280f, -0.03547787f, 0.13819191f, -0.01305541f, -0.18314907f, -0.18989925f, 
    0.13611606f, -0.10845795f, 0.33567414f, -0.16016294f, 0.26020375f, 0.06969203f, -0.19264813f, 0.07129927f, 
    -0.03312566f, 0.30856541f, -0.40060031f, -0.07184955f, 0.21326944f, 0.18695661f, -0.41872829f, -0.15180734f, 
    0.06966972f, -0.14624003f, -0.12362076f, 0.06086409f, 0.28073317f, 0.09460537f, 0.06271587f, -0.10363831f, 
    -0.21645316f, 0.08028735f, 0.09581994f, 0.01340760f, 0.02162107f, 0.04053392f, -0.22634549f, -0.72771907f, 
    -0.05724572f, 0.00801928f, 0.10821089f, 0.26592162f, 0.22260898f, 0.02284573f, 0.10880372f, -0.21302746f, 
    -0.00153455f, 0.00577564f, -0.09762336f, -0.06400627f, 0.26274621f, 0.05324123f, -0.01483385f, -0.00644572f, 
    -0.82771033f, 0.22094555f, -0.19731140f, -0.12070055f, -0.03631465f, -0.03392343f, 0.10476700f, 0.00151729f, 
    0.12904081f, -0.03956864f, -0.21334229f, -0.34866387f, -0.13631374f, -0.00255278f, 0.03576180f, 0.16630593f, 
    0.21833813f, -0.06515562f, 0.08701575f, -0.07110093f, -0.28291750f, -0.48264119f, 0.10135921f, 0.04711903f, 
    0.03179944f, 0.06749499f, 0.26425198f, -0.29360721f, 0.20795482f, 0.36718285f, -0.05927028f, -0.14825605f, 
    0.04151294f, 0.00713603f, 0.05534167f, 0.02233712f, -0.02501750f, -0.06649382f, -0.15763575f, 0.07901444f, 
    -0.14139995f, -0.05221548f, -0.05603787f, -0.05352066f, -0.01488715f, -0.01137146f, 0.05056095f, 0.06633347f, 
    -0.12878065f, -0.09769925f, -0.01267765f, -0.08246322f, -0.12345420f, 0.01319143f, 0.07571022f, -0.07171085f, 
    0.06492465f, 0.07351606f, -0.08647726f, -0.16951935f, 0.06822772f, -0.08327184f, -0.02272406f, -0.05068927f, 
    0.00984960f, 0.05067140f, -0.03390780f, -0.05560552f, -0.03475749f, -0.09180261f, -0.00710937f, -0.03139185f, 
    -0.09161089f, -0.12838364f, -0.08167313f, 0.00508361f, -0.06929540f, 0.07864265f, 0.01502787f, -0.12550874f, 
    -0.02629937f, -0.11161849f, 0.06361773f, 0.04202484f, -0.06210663f, 0.08881045f, -0.14872782f, -0.14025000f, 
    0.02072440f, 0.08336056f, -0.13222191f, -0.06861359f, -0.16743234f, -0.05951064f, -0.12677494f, 0.01297902f, 
    -0.12452564f, 0.06302372f, -0.10468058f, -0.02381477f, -0.03573968f, 0.05546167f, -0.00749463f, -0.14574485f, 
    -0.01692999f, -0.10855658f, 0.06833431f, -0.05818488f, -0.08569808f, 0.02495061f, 0.05667207f, -0.04857402f, 
    -0.05094545f, 0.08734611f, -0.14311899f, -0.04898124f, 0.01922102f, 0.00133493f, 0.10669588f, -0.11721986f, 
    -0.09716155f, 0.03713727f, 0.04194058f, 0.01445833f, 0.05920027f, -0.13849717f, 0.09400076f, -0.03362241f, 
    -0.00985054f, -0.04008554f, -0.06073612f, -0.16002692f, 0.07946910f, 0.03692267f, -0.01193179f, -0.14651440f, 
    -0.02586329f, -0.10429887f, -0.02215741f, 0.00914355f, -0.10536195f, 0.03168605f, -0.14658013f, 0.08596442f, 
    -0.13498668f, -0.08949121f, -0.15845323f, -0.12751983f, -0.01539899f, -0.13393983f, 0.03689428f, -0.00842548f, 
    -0.03670564f, 0.02085274f, 0.02228183f, 0.01041514f, -0.08857774f, 0.00021939f, -0.05007625f, -0.00856150f, 
    -0.01285044f, -0.02566864f, -0.10704955f, -0.06236710f, -0.08674143f, 0.05160510f, -0.15400220f, -0.00357980f, 
    0.00721453f, -0.08951794f, 0.01673559f, 0.06910460f, -0.11145152f, -0.05986796f, 0.08777334f, 0.01389897f, 
    0.07797037f, 0.01806858f, -0.06574591f, -0.08803323f, -0.14799836f, 0.04911828f, -0.06292546f, 0.06679308f, 
    0.01013067f, 0.04614133f, 0.10327817f, -0.04419987f, 0.10885614f, 0.06297595f, 0.01246530f, -0.11563956f, 
    0.10039763f, 0.03131627f, -0.07580048f, 0.02293555f, -0.03503520f, 0.07475210f, -0.11657357f, -0.10449722f, 
    -0.07695809f, 0.06103279f, -0.13236256f, 0.10728032f, -0.17172001f, 0.02250842f, -0.00831475f, 0.01763535f, 
    0.02768853f, 0.00662901f, -0.10785679f, 0.01931901f, -0.07015828f, -0.04040907f, -0.14674811f, -0.02146123f, 
    -0.07764590f, 0.03854317f, -0.12198381f, -0.14346562f, 0.04233672f, -0.01469607f, 0.01567971f, -0.05579890f, 
    -0.32025787f, 0.33753258f, -0.10607333f, -0.07644411f, -0.33035514f, -0.18883121f, -0.02726178f, 0.10418232f, 
    0.07731634f, 0.85805357f, -0.39225388f, 0.34560704f, 0.12143201f, 0.45478812f, 0.01326562f, 0.13230611f, 
    0.22106320f, -0.00871482f, -0.05709277f, 0.03023495f, -0.38977563f, 0.14845836f, 0.05695328f, -0.00780498f, 
    0.15074128f, -0.31713232f, 0.11992464f, -0.24817269f, 0.48501486f, 0.40556908f, -0.28872088f, -0.36718413f, 
    0.05945420f, 0.68827754f, -0.27775264f, -0.39369085f, -0.03710819f, 0.12128668f, 0.19125326f, 0.13593827f, 
    -0.06035925f, 0.00496043f, -0.21531889f, -0.24837558f, -0.00825772f, 0.20835666f, -0.00683079f, 0.20498936f, 
    -0.03493705f, 0.12751095f, -0.09057893f, -0.20607807f, -0.01943074f, 0.05598185f, -0.23174360f, 0.03662285f, 
    -0.00706386f, 0.56012255f, -0.00258503f, -0.27114788f, 0.02822098f, -0.18687721f, 0.17901991f, 0.10038859f, 
    0.10698320f, 0.17773828f, -0.06161392f, 0.02991350f, 0.23451293f, 0.10443471f, 0.14462782f, -0.08215050f, 
    -0.17732434f, -0.05696125f, -0.00169927f, -0.25311348f, -0.09169200f, 0.30615813f, -0.05466557f, 0.03449876f, 
    0.02047184f, -0.08052023f, 0.09752678f, 0.30664593f, 0.40483746f, 0.50642395f, 0.09987764f, 0.16032259f, 
    0.23600006f, -0.22727868f, 0.10334403f, -0.61839080f, -0.38857597f, 0.29260975f, -0.06551592f, 0.10715339f, 
    -0.47006020f, 0.27617079f, 0.24928422f, -0.29815102f, -0.15198749f, 0.07960203f, -0.14616388f, 0.05630792f, 
    0.13293345f, -0.08406744f, 0.06098530f, 0.36809495f, 0.21499582f, 0.00121231f, -0.27691126f, 0.00401767f, 
    0.10754348f, 0.20508097f, 0.28936464f, 0.21046443f, -0.01239328f, -0.05205003f, -0.27148128f, 0.15308967f, 
    -0.27372733f, 0.17649202f, -0.45476416f, -0.02528788f, 0.28472471f, 0.37733117f, -0.20306362f, -0.52989262f, 
    0.04942174f, -0.10626380f, 0.28727588f, 0.05425218f, 0.51344633f, 0.40107673f, 0.01747104f, 0.11929701f, 
    0.11887836f, -0.13460055f, 0.45917565f, -0.37390426f, -0.06767854f, -0.00544021f, 0.82052636f, 0.14562902f, 
    -0.20543501f, -0.09646359f, 0.20755878f, -0.03502549f, 0.57615441f, -0.02609248f, 0.03110081f, 0.16971390f, 
    0.21587569f, -0.17933919f, -0.16093078f, -0.28187001f, -0.05506735f, 0.04681634f, 0.12295835f, 0.34263465f, 
    -0.05249746f, -0.39632854f, -0.00408073f, 0.21671765f, 0.07636768f, -0.05619653f, 0.19946256f, 0.03583573f, 
    -0.03870135f, 0.36162060f, -0.08757529f, 0.31034210f, -0.05921835f, -0.06143020f, 0.76203245f, -0.01083235f, 
    0.17761350f, 0.11285847f, -0.16295516f, 0.51245922f, -0.01407662f, 0.07314202f, 0.05984426f, -0.09416573f, 
    0.05538310f, -0.08646290f, 0.28264198f, 0.26271504f, -0.01120576f, 0.03031573f, 0.20674638f, 0.14936294f, 
    0.08119518f, 0.03196611f, 0.03978332f, 0.03852233f, 0.01450860f, -0.16014059f, -0.02614225f, -0.01778338f, 
    -0.01849499f, 0.00346712f, -0.04544675f, -0.11313299f, -0.06779600f, -0.11451571f, -0.00356774f, -0.08005428f, 
    0.09484341f, 0.04484829f, -0.12395553f, -0.00833579f, -0.02918933f, 0.10360835f, 0.11810915f, -0.05798567f, 
    -0.08499930f, -0.14144449f, -0.04741174f, 0.05033919f, -0.06268494f, 0.01825699f, 0.08281409f, 0.02726977f, 
    0.00945391f, -0.10374288f, -0.05180855f, -0.11593854f, 0.02688207f, -0.08785293f, -0.01158299f, 0.06052159f, 
    -0.11368391f, 0.07162570f, -0.06190975f, 0.09897393f, -0.03375880f, -0.04847277f, 0.10776397f, 0.05420762f, 
    -0.14931871f, 0.01916885f, 0.03179197f, 0.05251142f, -0.01910525f, 0.03422411f, 0.02385060f, 0.01241702f, 
    0.03883009f, 0.00439571f, 0.01158789f, -0.08341303f, -0.04820114f, -0.03063981f, 0.06541428f, 0.00243405f, 
    0.43474591f, 0.09326425f, -0.18507504f, 0.06208067f, -0.66671151f, -0.26059335f, 0.11866900f, -0.24217990f, 
    0.12201867f, -0.05021223f, -0.28896344f, 0.25223044f, 0.17176285f, 0.49103963f, 0.18339150f, 0.24265431f, 
    0.35188067f, 0.12677485f, -0.10345221f, -0.09426170f, -0.52879673f, 0.18477796f, 0.09860818f, 0.09699109f, 
    -0.05483339f, 0.09700215f, 0.27107665f, 0.16833808f, 0.04663275f, 0.21382573f, 0.04935037f, -0.08737861f, 
    -0.11571477f, 0.90603918f, 0.16007152f, -0.10591183f, 0.19345227f, 0.25115743f, -0.15493488f, 0.16173476f, 
    0.05428753f, -0.15431540f, 0.31846419f, -0.58464408f, 0.25615001f, 0.13220850f, -0.24294385f, -0.25245982f, 
    -0.29596016f, 0.27460030f, 0.18021749f, -0.12596035f, 0.63175070f, 0.13014619f, -0.16117018f, 0.02017373f, 
    -0.05473704f, 0.04185268f, -0.07728642f, 0.11194992f, 0.07125677f, 0.09008141f, -0.47781682f, 0.27192044f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.05625860f, 0.17713031f, -0.06415397f, -0.06550139f, 0.11129908f, 0.05331165f, 0.15290135f, 0.11728726f, 
    -0.02638313f, 0.07736083f, 0.25743315f, -0.34045723f, -0.07863034f, -0.11188528f, 0.16657177f, -0.06117890f, 
    -0.12348986f, 0.18484792f, -0.10785071f, 0.12193468f, 0.15391640f, -0.11190765f, 0.01004647f, -0.03565717f, 
    0.11820649f, 0.06438503f, 0.19720219f, -0.02865478f, 0.06262852f, 0.15700629f, 0.11239321f, 0.18451709f, 
    -0.05967556f, -0.44563600f, 0.42063496f, -0.01540810f, -0.23423217f, -0.13202800f, -0.14095145f, -0.05904628f, 
    0.00530432f, 0.01240391f, 0.08951624f, 0.20755051f, -0.05224724f, 0.08292332f, -0.09708280f, 0.02889301f, 
    0.08469213f, -0.01345708f, -0.00211003f, -0.06501795f, 0.19054869f, 0.17805043f, -0.01922032f, -0.49740779f, 
    -0.05450540f, -0.15526550f, -0.13065729f, 0.22156921f, 0.30218536f, -0.09820886f, 0.04783367f, 0.30030653f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.30872729f, -0.38219088f, -0.08803909f, 0.33916017f, -0.13968064f, 0.06961387f, 0.05523684f, 0.11202509f, 
    0.08546627f, -0.48020428f, -0.13426092f, 0.35243127f, -0.16688620f, 0.08914942f, -0.12529583f, -0.02550810f, 
    0.11394741f, 0.24099068f, -0.04992848f, -0.37149858f, -0.40319794f, -0.45136708f, -0.14922871f, 0.27545947f, 
    -0.34695953f, 0.12383585f, 0.23737580f, -0.07056549f, -0.24205402f, -0.31666985f, 0.20148778f, 0.06345450f, 
    0.01780467f, 0.07728021f, -0.10199089f, -0.24180363f, -0.12706412f, 0.26128337f, -0.10164820f, 0.09823462f, 
    -0.13055655f, -0.07044348f, 0.08272512f, 0.32292679f, 0.04588365f, -0.76127791f, 0.09676953f, -0.22434662f, 
    -0.17674337f, 0.02366756f, -0.34538275f, 0.01396881f, 0.08346078f, -0.29539797f, 0.10221241f, -0.14481016f, 
    -0.12430181f, -0.09536730f, -0.13100559f, -0.16712281f, 0.25732315f, 0.26115838f, 0.12541871f, 0.09635162f, 
    0.06051950f, 0.13110934f, -0.02402887f, 0.21915725f, -0.19988792f, -0.05902097f, 0.14234036f, 0.06877127f, 
    0.49042037f, -0.04763845f, 0.01525542f, 0.44747126f, 0.02616990f, 0.10524514f, 0.17454648f, 0.03695796f, 
    0.04805084f, 0.04222014f, 0.57951522f, 0.09454863f, -0.06209816f, 0.03292865f, -0.10582104f, 0.22323301f, 
    0.11059330f, -0.12309148f, -0.35189304f, -0.00180552f, -0.50839841f, 0.08961236f, -0.32467318f, -0.26161686f, 
    -0.05482334f, 0.07453589f, 0.11330381f, -0.50873792f, -0.36157995f, 0.18822093f, -0.08442280f, 0.16892791f, 
    -0.00902577f, -0.07505624f, 0.19856870f, 0.12493393f, 0.10672842f, 0.09370477f, 0.12243956f, -0.11835626f, 
    0.19935557f, -0.03432821f, -0.10701568f, -0.21399087f, -0.36230624f, 0.04721637f, -0.55553591f, -0.23103839f, 
    -0.04668652f, 0.02488436f, -0.05072912f, -0.36368972f, 0.03418011f, 0.19612654f, -0.11250348f, -0.52712166f, 
    -0.54785931f, 0.16898887f, 0.09658095f, -0.40413710f, -0.51739699f, -0.05408639f, 0.09870643f, -0.66505736f, 
    -0.26814508f, 0.01568338f, -0.22146323f, -0.14985842f, 0.03989849f, 0.07240618f, -0.36553580f, 0.02087348f, 
    -0.06258334f, -0.29817370f, -0.37614137f, 0.30996013f, 0.19430800f, -0.47963175f, 0.11154994f, -0.15057826f, 
    -0.49858594f, 0.03649769f, 0.18175358f, 0.04111667f, -0.11301994f, 0.16215585f, -0.26212585f, 0.57542640f, 
    -0.11540425f, 0.25670415f, -0.00211921f, 0.29396185f, -0.54055566f, -0.36034298f, 0.00751985f, -0.06561590f, 
    0.17668302f, 0.07801017f, 0.27675867f, -0.13835230f, 0.01347119f, -0.02786617f, -0.60981536f, 0.05932514f, 
    0.12170156f, -0.06811605f, -0.46571600f, -0.39906442f, 0.15741609f, -0.01426741f, 0.25428060f, 0.03676825f, 
    0.04117293f, -0.08445279f, 0.00945808f, 0.12170196f, 0.11852912f, -0.46967322f, 0.00322404f, 0.27428475f, 
    0.15943892f, -0.63646734f, -0.07954496f, -0.86347789f, 0.15292539f, 0.20470023f, 0.16126105f, -0.39858741f, 
    0.27893740f, -0.07655129f, -0.08568294f, -0.62129557f, -0.15708935f, 0.02997604f, -0.39527869f, 0.02023350f, 
    0.09778351f, -0.17861943f, 0.24085924f, -0.34750140f, -0.73190445f, -0.03665928f, -0.17690285f, -0.78289616f, 
    -0.00046494f, 0.13975525f, -0.00436546f, 0.10141569f, -0.46347082f, -0.30705082f, 0.24972747f, 0.01823951f, 
    0.04463328f, 0.48038197f, -0.20965333f, 0.06705898f, 0.15232156f, -0.26322696f, -0.06375833f, -0.64160979f, 
    -0.31964040f, 0.04201699f, -0.35087162f, 0.19632734f, 0.04428498f, 0.51519889f, -0.07061358f, -0.14776051f, 
    -0.50004089f, -0.03857894f, -0.04621141f, 0.18657210f, 0.29699835f, -0.21459186f, 0.26678264f, 0.16561592f, 
    0.11061791f, 0.04166600f, -0.19065222f, 0.02553912f, 0.01524063f, -0.21851525f, -0.01442715f, 0.19174443f, 
    -0.22102901f, 0.20320018f, -0.05778690f, -0.20182367f, 0.20222768f, 0.21641907f, 0.17414314f, -0.03950879f, 
    0.06247219f, 0.18302931f, -0.09429540f, 0.48831874f, 0.07083008f, 0.09242402f, 0.02617277f, 0.02490426f, 
    -0.08438992f, -0.29932997f, -0.56615317f, -0.12387595f, 0.27489814f, -0.28764650f, -0.11148086f, -0.00641197f, 
    0.19010288f, -0.14814822f, 0.14156723f, 0.00945348f, -0.05819457f, -0.05971855f, 0.04549264f, -0.26900312f, 
    -0.04090983f, 0.06955142f, 0.25385419f, 0.02079954f, 0.40512654f, 0.03808017f, -0.14653526f, 0.11477458f, 
    -0.14381649f, 0.06390134f, 0.16860977f, 0.01231821f, -0.03054541f, -0.29722872f, -0.29038012f, -0.35940766f, 
    0.24163136f, -0.10243926f, 0.03293253f, 0.05759093f, 0.20891544f, -0.21888451f, -0.23894325f, 0.30484450f, 
    -0.06678750f, -0.08820585f, 0.05499283f, 0.44754678f, -0.04764929f, -0.05390831f, -0.02748338f, -0.15733123f, 
    -0.03085718f, 0.14148018f, -0.04538289f, 0.26180747f, 0.19832043f, -0.25773224f, -0.17553139f, 0.18718266f, 
    -0.38955146f, -0.01763370f, 0.13363208f, -0.85017526f, 0.06433345f, 0.10962250f, 0.16163467f, 0.11028297f, 
    0.05194407f, 0.20005926f, -0.21605586f, 0.07099970f, 0.00025036f, -0.03401610f, -0.08313634f, 0.09769612f, 
    0.12047164f, 0.09582493f, -0.14649326f, 0.02982804f, 0.00900925f, 0.17397426f, -0.21197388f, 0.24388859f, 
    -0.09649849f, -0.65437979f, 0.01864995f, -0.29254776f, 0.33435482f, 0.14825594f, 0.03038628f, -0.12231319f, 
    -0.15560460f, 0.11362566f, -0.17625004f, 0.18691933f, 0.07220913f, 0.18802249f, 0.06244982f, -0.28372210f, 
    0.08017373f, 0.03003871f, 0.59927744f, -0.27049294f, -0.43449411f, -0.00044462f, -0.23182857f, -0.62714094f, 
    -0.08556219f, 0.04628296f, -0.07584322f, -0.20315246f, 0.14572805f, 0.21559578f, 0.07441477f, -0.10263935f, 
    -0.34772372f, 0.06899506f, 0.03667012f, 0.14798172f, -0.51343453f, -0.62663835f, -0.59686393f, 0.17648177f, 
    -0.35080773f, 0.20837194f, 0.22025733f, -0.38438886f, -0.06363557f, -0.08412784f, 0.25449035f, -0.12152347f, 
    0.10466426f, -0.21628891f, 0.08473475f, -0.14435975f, 0.20380035f, 0.34308729f, 0.01154099f, -0.15241286f, 
    0.15209596f, 0.27639690f, 0.17434056f, 0.03171372f, 0.08317345f, -0.03700279f, 0.01944084f, -0.32211721f, 
    0.03104971f, 0.13366625f, 0.19031180f, -0.63230562f, 0.68354398f, -0.30026659f, -0.02920436f, 0.08202656f, 
    -0.66431630f, 0.05254302f, -0.44684255f, -0.02296114f, 0.07056195f, 0.05335944f, -0.08138400f, 0.17601173f, 
    0.25811446f, 0.02350116f, -0.64078140f, 0.08880449f, 0.02584363f, -0.02768485f, 0.31583777f, 0.30605713f, 
    0.03867258f, -0.05341973f, 0.08285133f, 0.22928515f, 0.28184387f, -0.02503757f, -0.10399283f, 0.00971997f, 
    0.15489940f, -0.12277488f, 0.08216235f, 0.27662566f, 0.31570902f, 0.30977398f, 0.22190346f, -0.43703997f, 
    0.11178196f, -0.15253702f, -0.79028827f, 0.27672046f, -0.14495319f, -0.03039072f, -0.41024432f, -0.06223684f, 
    -0.04795173f, -0.21155977f, 0.16103640f, -0.51418883f, -0.06893679f, 0.21215230f, -0.11098927f, -0.01501065f, 
    0.25408196f, -0.05250353f, -1.04076219f, -0.02366353f, 0.01626612f, -0.53362072f, 0.00983135f, 0.09236605f, 
    0.11945619f, 0.47331619f, -0.33972681f, 0.20406954f, -0.23666623f, 0.09095973f, -0.00412758f, -0.21815117f, 
    -0.00044860f, -0.10826154f, -0.12157750f, 0.02514386f, -0.11240283f, 0.20174517f, -0.15055129f, -0.43111607f, 
    0.05376306f, -0.00799925f, 0.15648623f, 0.00978051f, -0.06294446f, -0.51013702f, -0.55454355f, 0.38865706f, 
    -0.03355707f, -0.12091435f, -0.01461833f, -0.83616626f, -0.51240396f, 0.32138088f, -0.07570267f, -0.77852350f, 
    -0.04890935f, 0.02397096f, 0.04017967f, -0.33971262f, -0.52613962f, -0.02048591f, 0.15814397f, -0.64542449f, 
    -0.48980555f, 0.25128061f, -0.07488271f, -0.47568852f, 0.05113033f, 0.02862520f, 0.04166428f, 0.02175979f, 
    -0.11691394f, 0.22575594f, -0.38467610f, 0.10784675f, -0.06671199f, 0.29274085f, -0.22397582f, 0.04467869f, 
    0.24187958f, -0.41816369f, -0.16515936f, -0.02676108f, 0.45108366f, -0.07619857f, -0.57706606f, -0.24206758f, 
    -0.03793406f, -0.11350055f, -0.67714697f, 0.12920398f, 0.03733705f, -0.04811567f, -0.00199566f, 0.24163750f, 
    0.18914278f, 0.01244719f, 0.06814566f, -0.51967204f, -0.02112101f, 0.38091347f, 0.18151629f, 0.32214537f, 
    0.05389842f, 0.01167567f, -0.11511317f, -0.52761304f, -0.65469033f, 0.23228487f, -0.52067840f, -0.10308005f, 
    0.09755793f, -0.03064096f, -0.08698002f, -0.14238454f, -0.64012742f, 0.12757948f, 0.08867984f, 0.20558079f, 
    0.30462989f, 0.25696230f, -0.02466908f, -0.20954134f, 0.03565395f, 0.15405788f, -0.00648692f, 0.25664535f, 
    -0.29816836f, -0.00229459f, 0.03963277f, -0.03482191f, 0.02979534f, 0.03096809f, 0.07915830f, -0.01432030f, 
    -0.06142400f, 0.04169409f, -0.39544922f, 0.14353865f, 0.02781137f, -0.42280900f, -0.02693766f, -0.05767804f, 
    0.14987428f, -0.65803397f, 0.22418109f, -0.02945660f, -0.15044838f, 0.11353359f, 0.16294354f, -0.37449017f, 
    0.05040763f, -0.52025962f, -0.04604181f, 0.02834166f, -0.22406070f, 0.24939454f, -0.05202818f, -0.04988604f, 
    0.05899442f, 0.00758152f, -0.00048406f, -0.29173428f, 0.08017422f, -0.02784203f, 0.11001290f, 0.05481922f, 
    0.02573719f, 0.00036155f, 0.12709539f, -0.02527276f, 0.02067647f, -0.04328866f, -0.01591523f, -0.31262681f, 
    -0.07179469f, 0.01733915f, -0.11685299f, 0.21209370f, -0.28695184f, 0.00251836f, 0.05089873f, 0.15693533f, 
    0.12295251f, -0.62431562f, -0.11308745f, -0.07991564f, -0.22307962f, -0.05558170f, 0.16025636f, -0.87575758f, 
    -0.08537520f, -0.39451921f, -0.16040234f, 0.54783773f, -0.10368115f, 0.06469539f, 0.25642872f, 0.05483772f, 
    -0.11851648f, 0.13602430f, 0.38273862f, 0.30967689f, -0.57583570f, 0.14386472f, -0.05966289f, -0.12512273f, 
    -0.09946463f, 0.06588348f, -0.01226591f, 0.08274785f, -0.31087673f, 0.08871681f, 0.20381844f, 0.37370849f, 
    0.00447488f, -0.36006945f, -0.68917692f, 0.08985060f, -0.73642659f, -0.25511268f, -0.09920856f, 0.09048802f, 
    0.03887570f, -0.00293201f, -0.27000022f, 0.13479951f, -0.07090310f, -0.09974492f, -0.56400704f, 0.19783220f, 
    -0.48755395f, -0.05017550f, -0.11668161f, -0.10060317f, 0.11644061f, 0.30895671f, 0.12516041f, -0.32096922f, 
    -0.14196113f, -0.10660142f, -0.02516284f, 0.10008922f, 0.19082205f, -0.15114918f, 0.10897925f, 0.15168899f, 
    0.04385720f, 0.03767153f, 0.11707938f, -0.12029106f, 0.24455133f, -0.07880732f, -0.27103978f, 0.10289899f, 
    0.10160424f, 0.19094563f, 0.04729703f, -0.58922958f, -0.14711849f, 0.05404083f, -0.33502528f, 0.04368947f, 
    0.09585013f, -0.53347617f, -0.13379213f, 0.07081050f, -0.25244582f, 0.06139416f, -0.03674644f, -0.48090366f, 
    -0.15855406f, 0.37788540f, -0.03663031f, -0.12906736f, 0.38438845f, 0.19087368f, -0.09684062f, -0.70599025f, 
    -0.03079718f, -0.48529723f, 0.46208242f, 0.17638136f, 0.43403974f, -0.59290129f, 0.03037073f, -0.13484591f, 
    -0.06361228f, -0.07114965f, 0.07141812f, 0.04727594f, -0.00050775f, -0.27430645f, 0.11944259f, 0.27309725f, 
    -0.51727891f, -0.03428355f, -0.37236404f, 0.16205172f, 0.04143353f, 0.20319086f, 0.38484749f, -0.15905327f, 
    -0.07753158f, -0.01431366f, -0.10016022f, -0.07805263f, -0.08625605f, -0.24182524f, 0.09817930f, 0.05846725f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.11651532f, -0.19607231f, 0.15177058f, -0.12521304f, 0.31417280f, 0.29652750f, -0.24342601f, -0.39206371f, 
    -0.14458337f, -0.13813408f, 0.07414877f, -0.06523557f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
