#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.00139662f, -0.55772805f, 0.33864087f, 0.58687633f, 0.51543993f, 0.25024462f, -0.14113136f, -0.20164868f, 
    -0.32387200f, -0.40908343f, -0.11791880f, -0.28471214f, 0.00833740f, -0.11536349f, -0.00109404f, -0.05564893f, 
    -0.03539733f, 0.16631262f, 0.16351190f, 0.03336603f, 0.04045688f, 0.07743562f, 0.02327548f, -0.05104006f, 
    -0.08296864f, -0.25015247f, -0.47394478f, -0.54591334f, -0.40761766f, 0.09243885f, -0.20177546f, -0.09618531f, 
    -0.36530194f, -0.47439474f, -0.11226761f, 0.19999951f, 0.39770699f, 0.23019283f, -0.08495301f, -0.08723536f, 
    0.16952482f, -0.18331626f, 0.20582402f, 0.00089032f, -0.00192753f, 0.15052824f, -0.36206704f, -0.26468208f, 
    0.14890502f, -0.16302633f, 0.39030567f, 0.24020249f, 0.53268272f, -0.04621303f, -0.55059433f, -0.62391913f, 
    -0.55328208f, -0.34936580f, -0.01102203f, -0.45631397f, -0.01032414f, -0.34565619f, -0.50074446f, -0.12089998f, 
    0.53335178f, 0.03961199f, -0.12918757f, -0.33627445f, -0.05847330f, -0.03866792f, -0.17458586f, -0.03740267f, 
    -0.06436764f, -0.28829563f, -0.18409051f, -0.47340393f, -0.39348441f, 0.28231856f, 0.51262134f, 0.19713290f, 
    -0.14940411f, -0.54145968f, 0.21573824f, 0.15122306f, 0.05739821f, 0.16985178f, -0.36604452f, -0.31603536f, 
    0.37849090f, -0.09707890f, 0.14761893f, 0.22392590f, 0.32680455f, -0.20678338f, -0.32011011f, -0.05929868f, 
    -0.08034851f, -0.00568707f, -0.07404365f, 0.35003781f, -0.03446887f, -0.46258193f, 0.21095631f, 0.22998828f, 
    0.01245888f, 0.01137574f, -0.07666130f, -0.02479082f, 0.19131014f, 0.43527880f, -0.18862545f, 0.09050792f, 
    0.17632063f, 0.08524980f, -0.17257483f, -0.08918454f, -0.28300098f, 0.22115435f, -0.23817398f, 0.16688280f, 
    -0.03666125f, -0.02793840f, -0.18966088f, -0.00228681f, 0.28937033f, 0.49181041f, 0.95328474f, 0.58916575f, 
    -0.63578767f, 0.16587406f, -0.51081705f, -0.32864672f, -0.08647167f, 0.12656207f, -0.16269080f, 0.04675177f, 
    0.04261533f, 0.35955763f, -0.26010075f, -0.14055371f, -0.24516231f, -0.07546975f, 0.14115006f, 0.01800445f, 
    0.11272459f, -0.19957757f, 0.44001797f, 0.05046654f, -0.12883699f, -0.13868372f, -0.03965720f, 0.23477937f, 
    0.45027855f, 0.05994971f, -0.03995035f, -0.73468560f, -0.34863082f, 0.37006801f, 0.18803553f, -0.24641420f, 
    0.22564535f, 0.30094427f, -0.01307692f, 0.30203700f, -0.32344082f, 0.14135543f, -0.09168684f, -0.26027077f, 
    -0.42772377f, -0.05374063f, 0.20013642f, 0.19905111f, -0.05867854f, -0.09917378f, -0.26719439f, -0.04987288f, 
    0.39752862f, -0.12670977f, -0.13461843f, -0.59372061f, 0.06454258f, 0.20909654f, -0.12950294f, 0.19332926f, 
    0.32327011f, 0.50179696f, -0.24823640f, -0.16780753f, -0.22517860f, 0.05382292f, 0.33340895f, -0.38479143f, 
    -0.37221494f, 0.04486242f, -0.09846949f, -0.15047643f, 0.08101039f, 0.14837304f, -0.08608074f, 0.40404007f, 
    -0.66884512f, -0.21408993f, 0.40758201f, 0.17120232f, 0.28843474f, -0.04374091f, -0.16123590f, 0.52066547f, 
    -0.21352647f, -0.20005330f, -0.26096568f, 0.01936653f, -0.16414116f, 0.34792250f, -0.09785300f, -0.29225352f, 
    -0.01511357f, 0.18613364f, 0.16280305f, 0.13816364f, -0.34196573f, 0.13001347f, 0.21251647f, 0.12546675f, 
    -0.22875866f, 0.76179004f, -0.18972379f, -0.45451522f, -0.24037272f, -0.06767280f, 0.36126015f, 0.19803098f, 
    -0.04126737f, -0.31836465f, 0.00432205f, -0.22775467f, 0.36639649f, -0.16303943f, -0.26594698f, -0.04644204f, 
    0.31781512f, -0.07508916f, -0.17595930f, -0.25832203f, -0.24735546f, -0.09493215f, 0.10343926f, 0.16077246f, 
    0.26237240f, 0.33837190f, -0.03905125f, 0.13257495f, -0.01342442f, -0.33832207f, 0.26982349f, -0.27750799f, 
    -0.52482581f, -0.12832479f, 0.37606686f, 0.40591574f, -0.25311735f, 0.16845489f, 0.23100169f, 0.00014610f, 
    -0.11105039f, 0.09818356f, 0.01004292f, 0.08376633f, -0.22232741f, -0.26860648f, 0.13488747f, -0.15731619f, 
    0.13536602f, 0.19660504f, 0.01880007f, -0.47509608f, 0.36478290f, -0.30433655f, -0.15991862f, -0.02811479f, 
    -0.06859948f, -0.22354360f, 0.02180034f, 0.50901276f, 0.36124915f, 0.00704718f, -0.11956334f, -0.12125665f, 
    0.00324576f, -0.10648207f, -0.00722161f, -0.21301042f, 0.25867128f, -0.27906895f, -0.15617768f, -0.08169727f, 
    0.26425132f, 0.37707955f, 0.29973269f, -0.07931742f, -0.58272004f, -0.63808542f, -0.38668159f, -0.01942092f, 
    -0.41078100f, 0.27274668f, 0.22982511f, 0.01560947f, 0.30866131f, 0.51849723f, -0.03152191f, 0.07524506f, 
    -0.14566320f, 0.13064080f, -0.06489640f, -0.17771107f, 0.03831006f, 0.07014380f, 0.18965422f, 0.16881336f, 
    0.07962541f, -0.02661515f, 0.07095078f, -0.22250062f, -0.07400738f, 0.02013673f, -0.46755978f, -0.37440360f, 
    0.38696301f, -0.27489755f, 0.36818513f, 0.40584326f, -0.57078737f, -0.42457303f, 0.40951955f, 0.10871555f, 
    0.02576209f, 0.22419934f, -0.07205896f, -0.11217816f, -0.16257815f, -0.32051408f, 0.36350986f, -0.09237647f, 
    -0.44667307f, -0.19675115f, 0.42705709f, 0.17584607f, -0.08009832f, 0.21821305f, 0.53709710f, -0.02585238f, 
    -0.02053302f, 0.10617213f, -0.17161730f, -0.21149713f, -0.07004913f, 0.25741759f, 0.37315854f, -0.22483754f, 
    -0.22137327f, 0.13257860f, 0.06252415f, -0.00816840f, 0.03595648f, -0.03151492f, -0.18559398f, 0.26780683f, 
    0.10144588f, -0.36474681f, 0.07307499f, 0.13867681f, 0.10723276f, -0.23947163f, -0.06183966f, -0.44291925f, 
    -0.10183630f, -0.35117140f, -0.64317060f, -0.44856274f, -0.07469011f, -0.03369131f, -0.56859374f, -0.49569061f, 
    -0.08356951f, 0.49257562f, 0.53706169f, 0.11583419f, -0.35256699f, -0.41875264f, -0.51668489f, -0.14268975f, 
    -0.42292896f, -0.29986334f, -0.06708983f, 0.29343697f, -0.12420437f, -0.22110949f, 0.23066646f, -0.08100071f, 
    -0.60908949f, -0.61690658f, -0.45095021f, -0.72051686f, -0.68150133f, 0.27115625f, 0.28425878f, -0.18183641f, 
    -0.15446605f, -0.14405186f, -0.05236981f, -0.27598390f, -0.36957163f, -0.41884461f, -0.30159041f, -0.26385111f, 
    0.03494591f, -0.22056687f, -0.18228321f, -0.24686585f, -0.13140094f, 0.12389110f, 0.14669023f, 0.02007906f, 
    -0.06091848f, 0.30020502f, 0.18023500f, -0.43147552f, -0.12847333f, -0.15224443f, -0.22552983f, 0.90434229f, 
    -0.58215195f, -0.44499335f, -0.15056980f, 0.24457070f, -0.24342637f, -0.18697056f, 0.15989570f, -0.32768559f, 
    -0.10737315f, -0.44299194f, 0.05329467f, 0.30439836f, 0.22465660f, -0.00708130f, -0.19900608f, -0.17549278f, 
    0.09392372f, 0.21324162f, -0.02433750f, 0.19866143f, 0.19330300f, 0.23372756f, -0.53956795f, -0.18017481f, 
    0.40131649f, -0.26797763f, -0.30199113f, 0.02684874f, 0.17606027f, -0.35765663f, -0.20458332f, -0.20334502f, 
    0.22216326f, -0.23681235f, 0.24521536f, 0.16647533f, -0.07333139f, -0.40883404f, -0.18690743f, -0.32095456f, 
    0.00738495f, -0.08862675f, -0.58374178f, 0.77873534f, 0.56290656f, 0.49251866f, -0.26112780f, -0.78212523f, 
    -0.13624051f, -0.01801966f, 0.15924461f, 0.08645513f, -0.65500987f, -0.17472655f, -0.20112668f, -0.04149292f, 
    -0.04634902f, -0.08100292f, 0.38669825f, 0.13756500f, 0.27570853f, -0.09714422f, -0.17381923f, -0.15314327f, 
    -0.06632762f, -0.09511840f, 0.04359664f, 0.01028978f, 0.54612017f, -0.42075485f, -0.44947454f, -0.21341605f, 
    0.15385775f, -0.28579339f, -0.36278743f, -0.27133653f, 0.19927509f, 0.00783305f, 0.47629824f, 0.25025439f, 
    0.45101047f, 0.10533742f, -0.03887045f, 0.20951971f, -0.33816659f, 0.25517070f, -0.12073289f, -0.37333256f, 
    -0.22974575f, 0.24261944f, 0.12056149f, -0.24617687f, 0.20408137f, -0.09149632f, -0.59441394f, -0.50845635f, 
    -0.59695536f, -0.97163683f, 0.44070905f, 0.27271354f, -0.00631172f, 0.16348508f, 0.14527607f, -0.31330973f, 
    -0.34995055f, -0.05532193f, -0.17408453f, 0.10578117f, 0.00533470f, -0.10761058f, -0.31932482f, -0.10414077f, 
    0.09201605f, -0.04648972f, -0.27143154f, 0.28278112f, -0.16551518f, 0.16729000f, -0.45698112f, -0.38253328f, 
    -0.33500317f, -0.18905869f, -0.09070282f, -0.26726213f, -0.15633415f, 0.09298797f, -0.36753437f, -0.46764100f, 
    -0.25096387f, -0.09738069f, -0.00145333f, 0.18665515f, -0.38311759f, 0.11078519f, 0.15939645f, -0.03894166f, 
    -0.29526109f, 0.07292184f, 0.11941606f, 0.21724850f, 0.29567412f, 0.20536748f, 0.35028794f, 0.46095774f, 
    0.31093657f, 0.10042367f, 0.15442546f, 0.15262203f, -0.15160480f, 0.15059246f, 0.32874089f, -0.30545676f, 
    -0.25092465f, -0.13036145f, -0.09541474f, -0.08333394f, 0.07793488f, -0.02506202f, -0.09998469f, 0.03183741f, 
    -0.13858631f, 0.09251345f, -0.07807285f, -0.16574626f, -0.25277907f, -0.36877382f, -0.40265056f, -0.39462554f, 
    -0.37788811f, -0.00793653f, -0.19407307f, 0.27270162f, 0.09431717f, 0.08463020f, 0.09548230f, 0.33885559f, 
    -0.08249238f, -0.34220254f, -0.16152216f, 0.41485882f, 0.42953032f, -0.13843581f, -0.27203852f, -0.53945005f, 
    -0.12586498f, -0.30653962f, 0.14955969f, 0.22222452f, 0.31247196f, 0.18737382f, -0.31060514f, 0.16240567f, 
    0.11161180f, -0.22233574f, 0.23571955f, -0.40594387f, -0.40915811f, -0.16319862f, -0.09997988f, -0.03681679f, 
    -0.15563039f, -0.08093035f, 0.43597052f, 0.34968790f, 0.13099480f, 0.19334614f, 0.08792767f, 0.17741953f, 
    0.11396658f, 0.27414069f, -0.10025126f, -0.28031018f, -0.16125984f, 0.19671705f, 0.16069259f, -0.12409242f, 
    -0.26434004f, -0.29490516f, -0.41072708f, -0.42281541f, -0.39915588f, -0.54666406f, -0.50247383f, 0.29369885f, 
    0.10334565f, 0.35741675f, 0.16171302f, 0.23082718f, 0.27411711f, 0.12058025f, -0.13268141f, 0.12047928f, 
    0.03199130f, -0.01985357f, 0.12781034f, 0.21321818f, 0.16307934f, -0.04225697f, -0.02570024f, -0.08762227f, 
    0.20625947f, -0.19176662f, -0.25055939f, -0.06500414f, -0.21949457f, 0.38833079f, 0.16918220f, -0.33825973f, 
    -0.38135147f, -0.50889552f, 0.51473260f, 0.00891999f, -0.12029091f, 0.03995618f, 0.31128469f, -0.45016316f, 
    -0.05110845f, -0.07111116f, -0.34314173f, -0.18108346f, -0.13721357f, 0.36037150f, 0.25193292f, -0.12800120f, 
    -0.35225397f, -0.28783035f, 0.20547184f, 0.09030406f, -0.35352355f, 0.18401656f, 0.36952659f, -0.46871689f, 
    -0.06312021f, 0.15610619f, 0.39397284f, -0.19308113f, 0.10908797f, -0.30930394f, -0.25549248f, 0.28931877f, 
    0.12211852f, -0.36064392f, -0.17849560f, 0.15774940f, -0.00764698f, -0.16927566f, 0.00597813f, 0.12409262f, 
    -0.19789355f, 0.18127689f, 0.11447099f, -0.26749140f, 0.23266120f, 0.36367655f, -0.27180347f, 0.01052264f, 
    0.14785351f, 0.25194705f, -0.25411096f, -0.37731028f, -0.27179521f, 0.04688710f, -0.07831194f, 0.05608488f, 
    0.10114849f, 0.34133101f, -0.17591716f, 0.07008181f, 0.12048196f, -0.10137528f, 0.15681693f, -0.03709808f, 
    -0.36935455f, -0.11011960f, 0.13761963f, 0.02705762f, 0.31069592f, 0.13853176f, -0.16541110f, 0.15878896f, 
    -0.22430311f, 0.30567056f, 0.12967701f, 0.19843483f, -0.20884436f, 0.06062313f, 0.33503872f, 0.01168982f, 
    0.33126703f, -0.22845528f, -0.32161132f, 0.17389941f, -0.01007555f, 0.10978072f, -0.18095393f, 0.09527807f, 
    -0.32272038f, -0.11188053f, -0.30663815f, 0.08517069f, 0.30762145f, -0.17125958f, 0.09038952f, -0.32653958f, 
    -0.59909785f, -0.48068187f, -0.60219204f, -0.30696940f, -0.45277059f, -0.49175280f, -0.58095098f, -0.68665540f, 
    -0.87595588f, 0.25802070f, 0.32435027f, -0.22705357f, 0.11310384f, -0.18418141f, 0.01383880f, -0.37132952f, 
    0.05311218f, -0.02262949f, -0.35125312f, -0.31545046f, 0.10999785f, 0.16360937f, 0.07916604f, -0.21034619f, 
    -0.56859428f, -0.83793980f, -0.61981094f, 0.11579799f, 0.02039824f, 0.10434537f, 0.14808340f, 0.02933170f, 
    -0.18431498f, 0.06668728f, 0.34124368f, -0.12907954f, -0.23488545f, 0.50045717f, -0.07674320f, -0.00199439f, 
    -0.29930729f, -0.06457027f, 0.12899618f, -0.40784621f, -0.34221557f, 0.11153271f, 0.05520918f, -0.00543965f, 
    -0.14958999f, -0.20731209f, -0.40432209f, -0.16551080f, -0.29891381f, -0.61465579f, -0.67252254f, -0.61347783f, 
    -0.44910726f, -0.40939841f, -0.31165972f, 0.03649358f, 0.02233695f, 0.26821738f, 0.32262748f, 0.27286997f, 
    -0.00260543f, 0.08748590f, 0.07896066f, 0.01207240f, -0.17355976f, 0.16232735f, 0.30221236f, 0.01770021f, 
    -0.15911095f, -0.00215098f, 0.05290905f, -1.07508326f, -0.45294020f, 0.17966133f, -0.06898499f, 0.72951430f, 
    0.56814593f, -0.05771850f, 0.02118943f, -0.22012299f, -0.11489512f, -0.28861219f, 0.15858941f, -0.19234763f, 
    -0.01510522f, 0.10473308f, -0.08588054f, -0.06665558f, 0.13579418f, 0.03498737f, -0.11156139f, 0.08034517f, 
    0.08493587f, 0.01461378f, -0.43924460f, -0.26026055f, -0.47058922f, 0.00485111f, 0.37552109f, 0.09533469f, 
    -0.27638969f, -0.76134098f, -0.21023883f, -0.63408905f, -0.37067398f, 0.49115759f, -0.29971188f, 0.36675638f, 
    -0.16422124f, -0.02096702f, 0.05886228f, -0.32133913f, 0.16323894f, 0.07527868f, -0.33942789f, -0.32637340f, 
    -0.04016056f, -0.10922327f, -0.21049581f, -0.01688794f, -0.26157105f, -0.80087769f, 0.17487931f, 0.19027393f, 
    0.21650600f, -0.28479883f, 0.06708296f, -0.00612194f, -0.49270016f, -0.61899358f, 0.08842648f, -0.33378595f, 
    -0.25864756f, -0.04668919f, -0.17883177f, -0.23184751f, 0.11396518f, -0.16068052f, -0.30943748f, 0.13590749f, 
    0.05005954f, -0.04537585f, -0.07412271f, -0.17926411f, 0.15290919f, 0.68263829f, -0.07157652f, -0.65838176f, 
    -0.39210817f, -0.35032201f, 0.58335990f, 0.46707705f, 0.05683671f, -0.77307647f, -0.60270000f, -0.29444328f, 
    -0.39444244f, -0.21460402f, 0.02172228f, -0.05652429f, -0.48209080f, -0.47227335f, 0.22250418f, -0.33269089f, 
    -0.23121546f, 0.00500930f, -0.30657423f, 0.14428426f, 0.00072720f, -0.11993200f, -0.25604624f, -0.19977595f, 
    -0.48981401f, -0.24621996f, -0.19877250f, 0.27434549f, 0.33639967f, -0.41003892f, -0.52313256f, 0.78068519f, 
    -0.01930424f, 0.08272423f, -0.02022434f, 0.04603709f, 0.11845016f, 0.26427120f, 0.09720250f, 0.12519941f, 
    -0.01844673f, -0.24827108f, -0.01628938f, -0.28044343f, -0.24187930f, -0.16824025f, 0.35561377f, 0.03788950f, 
    0.01883994f, -0.02999861f, 0.11979289f, -0.37106356f, -0.27911294f, -0.12552084f, 0.26981807f, 0.27281448f, 
    -0.10475891f, 0.05183210f, 0.22050913f, -0.09909127f, 0.02754951f, -0.21283244f, -0.25610480f, 0.01842772f, 
    0.01299807f, -0.28639597f, 0.32741591f, 0.18882848f, 0.23896153f, 0.00418361f, -0.02653658f, 0.30232510f, 
    0.06379868f, 0.37369663f, 0.05165775f, 0.13667209f, -0.53605247f, -0.34624401f, -0.29779384f, -0.31298116f, 
    -0.13840845f, -0.25161985f, 0.04432870f, 0.38116825f, -0.03136410f, 0.33505854f, -0.03119952f, 0.05862984f, 
    0.08498212f, -0.11176439f, 0.09462691f, -0.14265817f, -0.20201622f, -0.24754450f, -0.44340202f, -0.06125196f, 
    -0.36406019f, -0.13766649f, -0.09308624f, -0.19992158f, 0.15334222f, -0.01969814f, -0.30302051f, 0.11882058f, 
    -0.05560333f, 0.13775818f, -0.20452076f, -0.24742812f, 0.32952407f, -0.13715199f, -0.07070776f, -0.02283485f, 
    0.14900450f, -0.20164581f, 0.01361857f, 0.32599077f, -0.04880720f, 0.26654965f, -0.30576855f, 0.10926880f, 
    0.18682940f, -0.11135206f, -0.91034907f, -0.49072617f, -0.11825483f, 0.96694815f, 0.40972313f, 0.32467178f, 
    -0.33897650f, -0.75287169f, -0.29932809f, -0.12894493f, -0.55484623f, 0.40890807f, -0.40691450f, 0.54863304f, 
    -0.14148496f, 0.03684273f, 0.09727471f, -0.20841238f, -0.12355277f, 0.08203688f, 0.32755312f, -0.29859194f, 
    0.04952124f, 0.08232564f, -0.03388432f, 0.08342032f, 0.21413761f, 0.10456736f, 0.19982970f, 0.12973537f, 
    0.25733566f, 0.05782916f, 0.14798403f, 0.18468119f, 0.13417192f, 0.19980626f, 0.22804676f, 0.21902278f, 
    0.13223144f, -0.26772362f, -0.17887034f, 0.18491144f, 0.17336550f, 0.17184393f, -0.13828951f, -0.25947195f, 
    0.12121832f, 0.12052175f, 0.06386767f, 0.20570058f, 0.56375104f, -0.70039028f, 0.17359413f, -0.28236318f, 
    -0.11482323f, -0.01248667f, -0.00504199f, -0.02776702f, -0.01754472f, -0.42295000f, -0.30186769f, -0.07744222f, 
    0.38359836f, 0.13688971f, -0.01177367f, -0.16471161f, 0.07110058f, 0.01061478f, 0.34873050f, -0.22214901f, 
    -0.19453725f, -0.30686119f, -0.29037443f, 0.00272619f, 0.27950460f, -0.74279737f, 0.32928076f, 0.07926297f, 
    -0.41870287f, -0.24145865f, -0.06986246f, 0.26444966f, -0.27024376f, -0.02532506f, 0.19409758f, 0.08056580f, 
    -0.05110817f, 0.02101217f, -0.16273850f, -0.18609491f, -0.24946497f, -0.00996250f, -0.30088294f, -0.37580463f, 
    -0.28849047f, -0.32429114f, -0.44118020f, -0.40748692f, -0.46494785f, -0.62304628f, -0.24023692f, -0.19433980f, 
    -0.08197816f, -0.17149413f, 0.26040775f, -0.71836573f, -0.94417244f, -0.51096904f, -0.47849697f, -0.35241362f, 
    0.38771823f, 0.59551686f, 0.06317165f, -0.06440905f, -0.13104098f, -0.38105306f, 0.28668895f, -0.01896357f, 
    -0.24936667f, -0.19257876f, 0.02591339f, -0.07748492f, -0.01564796f, -0.16969091f, -0.16369727f, 0.61269450f, 
    -0.29291669f, -0.80457348f, -0.14282736f, 0.07249302f, 0.13918296f, 0.53436637f, -0.28112617f, 0.02205256f, 
    0.30306482f, -0.12536094f, -0.20922798f, 0.14398915f, -0.48419484f, -0.21314687f, 0.24470374f, 0.20955966f, 
    0.20127143f, 0.01115474f, -0.04707803f, -0.17422497f, -0.18245371f, 0.10592262f, 0.14991508f, -0.09791025f, 
    -0.77120996f, -0.41927594f, 0.49285454f, 0.49157906f, 0.11212652f, -0.72739440f, -0.91662472f, -0.18734248f, 
    0.17012288f, 0.34254801f, 0.19809657f, 0.16147491f, -0.09364402f, -0.06902441f, 0.28852811f, -0.32230216f, 
    0.17773357f, -0.08015422f, -0.30227998f, -0.66136551f, 0.21515526f, 0.04667946f, 0.12614833f, -0.07574177f, 
    -0.08883258f, 0.50933963f, 0.34850961f, 0.25624335f, -0.09724148f, 0.21474220f, -0.07990344f, 0.13936767f, 
    0.04453298f, -0.07112932f, 0.05976897f, -0.01895113f, 0.18075225f, -0.18260609f, -0.33958319f, -0.05761418f, 
    0.03140607f, -0.13809146f, 0.09021174f, -0.09118286f, 0.03330501f, 0.11264838f, -0.22411312f, -0.20089105f, 
    -0.25552422f, -0.28458866f, -0.89290762f, 0.56176943f, 0.41047809f, -0.15279424f, -0.05031787f, 0.25932157f, 
    0.19806971f, 0.36846009f, -0.26641262f, -0.42046171f, -0.14772129f, 0.20428811f, -0.01703685f, -0.36165640f, 
    -0.24587104f, 0.30260068f, -0.15560521f, -0.41298172f, -0.30896613f, -0.29113257f, -0.30762288f, 0.30128261f, 
    -0.06265569f, -0.31525573f, -0.03737180f, -0.37037149f, 0.16655995f, 0.24924521f, -0.72804374f, -0.53638506f, 
    0.53191656f, -0.18461683f, 0.07256429f, -0.38110909f, 0.30684859f, -0.22303633f, 0.18283436f, -0.09198882f, 
    0.21406028f, 0.28745374f, 0.13771869f, 0.26379740f, -0.08404821f, -0.20793675f, -0.28124991f, -0.13795768f, 
    0.32340592f, -0.17794794f, -0.09608553f, 0.26861474f, -1.25425923f, 0.25804928f, -0.25940153f, -0.92130703f, 
    -0.65689331f, 0.21980944f, 0.20773110f, 0.25989902f, 0.11834365f, 0.07240485f, 0.13149817f, -0.21093719f, 
    0.06915878f, -0.42358157f, -0.01447721f, -0.05012436f, -0.22087874f, -0.03606375f, -0.01830957f, 0.18733025f, 
    -0.15209728f, -0.17223494f, 0.04860590f, -0.15325323f, -0.03554207f, -0.92628121f, -0.78774971f, -0.25942463f, 
    0.71381927f, 0.78186250f, 0.14388381f, 0.19372618f, -0.02447031f, 0.19303133f, 0.02786215f, -0.17445585f, 
    -0.14421493f, 0.04796069f, -0.20502853f, -0.09361442f, -0.10518164f, 0.08062249f, -0.16304502f, 0.14079481f, 
    0.18800679f, 0.09108767f, -0.03164084f, 0.06318419f, -0.12426825f, 0.12541758f, 0.28489670f, 0.39925405f, 
    -0.12253805f, -0.13160165f, -0.36453146f, 0.28327668f, -0.24295954f, 0.00858695f, -0.18771632f, -0.26564696f, 
    0.16363604f, 0.08840908f, -0.12033967f, 0.01524232f, -0.03562365f, 0.27078116f, -0.13803484f, 0.11612172f, 
    -0.13381219f, 0.13303027f, -0.25516683f, -0.13319801f, -0.17954879f, 0.12714772f, 0.28456292f, 0.67676705f, 
    -0.42254880f, -0.66600311f, -0.18459056f, -0.94878232f, 0.08870564f, -0.09468749f, 0.16174586f, -0.27835697f, 
    -0.52588379f, 0.20629528f, 0.13497184f, -0.34603408f, -0.39015612f, 0.16261540f, -0.01676131f, 0.23043339f, 
    0.41557509f, 0.09014761f, 0.04667244f, -0.18894438f, -0.34812182f, -0.25586891f, -0.12511522f, 0.10716611f, 
    0.31157973f, -0.66020131f, -0.12316643f, 0.01933135f, -0.04590372f, 0.25860810f, 0.36118561f, 0.18750840f, 
    -0.06436619f, -0.46237516f, 0.46583739f, -0.44548133f, -0.05567751f, -0.21602213f, 0.11877692f, 0.11731436f, 
    0.20707314f, 0.05286252f, -0.09459694f, -0.41493782f, 0.04760684f, 0.28965527f, 0.21230750f, 0.05064956f, 
    -0.22032250f, -0.24994856f, 0.64616334f, 0.39960930f, -0.14240472f, 0.06766143f, -0.79528344f, -0.58492166f, 
    -0.07220701f, 0.50169510f, 0.32888350f, 0.03653729f, -0.52245426f, -0.31179616f, 0.30777615f, -0.16259937f, 
    0.09927101f, 0.10292329f, 0.18097290f, 0.03417601f, 0.27444032f, -0.24080756f, -0.08585708f, -0.39465091f, 
    -0.05833516f, 0.15758218f, -1.17130935f, -0.89074606f, 0.42966193f, 0.15480338f, -0.11146738f, 0.58487022f, 
    0.17910233f, 0.15838921f, 0.01307841f, 0.12033511f, -0.13384263f, -0.27429122f, 0.17399913f, 0.43379503f, 
    -0.24422430f, -0.00469798f, 0.11182358f, -0.31212020f, 0.07696509f, -0.01844288f, 0.02008563f, -0.05887168f, 
    0.18016547f, -0.01220731f, 0.06456123f, -0.73933429f, -0.76195973f, -0.07805701f, 0.38713428f, 0.41257590f, 
    0.34491140f, 0.73606354f, -0.36215562f, -0.25585660f, 0.08647616f, 0.38274848f, -0.20734683f, -0.09627382f, 
    -0.04173694f, -0.24512775f, -0.06328888f, -0.16242751f, 0.06331868f, 0.29802653f, 0.25260368f, -0.06263189f, 
    -0.17800614f, 0.14112526f, -0.02564504f, -0.26378641f, -1.03963649f, -0.55065328f, -0.69220823f, -0.41067970f, 
    -0.16321595f, 0.56520003f, 0.32471335f, 0.12147990f, 0.36776397f, 0.67554003f, 0.11631735f, 0.38963300f, 
    0.02694773f, 0.00907512f, -0.07865082f, -0.30788994f, 0.01431184f, -0.22041556f, -0.19212189f, -0.22307910f, 
    0.04253516f, 0.09434780f, 0.09582207f, -0.02957404f, 0.31252736f, 0.03076773f, 0.42960879f, -0.08636820f, 
    0.15987211f, -0.46469292f, -0.29280427f, -0.39855427f, -0.16256195f, -0.19897884f, -0.18967193f, -0.01927078f, 
    -0.12949611f, 0.45272678f, -0.02143308f, -0.13774782f, -0.18307103f, 0.23047973f, 0.14176157f, 0.12044743f, 
    0.27589169f, 0.15824346f, -0.20977192f, 0.01762521f, -0.17738219f, -0.08224595f, 0.71027690f, -0.00542450f, 
    0.19125649f, -0.20804159f, -0.21984985f, -0.55409724f, -0.26470509f, 0.04452644f, 0.05952270f, 0.03454527f, 
    0.11681383f, -0.05559448f, 0.42445445f, -0.27388123f, 0.14967041f, 0.02158547f, 0.24182044f, -0.13155213f, 
    0.04733648f, -0.37118188f, -0.14753827f, 0.12332259f, -0.17221689f, 0.08696575f, -0.06617200f, 0.26714239f, 
    0.39640993f, 0.14816134f, -0.48639056f, -0.50219202f, 0.16405304f, 0.27160141f, 0.37325987f, -0.19420695f, 
    -0.31712699f, 0.11144496f, 0.01684065f, 0.39301535f, -0.21685493f, -0.21432967f, 0.22064428f, -0.06567247f, 
    -0.28953221f, 0.01599097f, -0.05643502f, 0.24014066f, 0.10548412f, -0.38520631f, -0.02932745f, 0.16908342f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.05976761f, -0.18646319f, -0.08705433f, 0.14228612f, 0.39803463f, 0.26378131f, 0.05196814f, 0.16535638f, 
    0.34109840f, 0.00264844f, 0.24280927f, 0.12641157f, 0.09241395f, 0.20192327f, 0.40386474f, -0.05823769f, 
    -0.17468408f, 0.28332892f, 0.11943541f, 0.26799563f, 0.12268502f, -0.24281351f, 0.01110915f, -0.02383395f, 
    0.02977018f, 0.08326840f, -0.14186960f, 0.11316563f, 0.23054302f, -0.05330372f, 0.31422219f, -0.48185420f, 
    0.28155524f, -0.07690658f, -0.05576181f, -0.04600764f, 0.26406583f, -0.01239651f, 0.13989551f, 0.02459925f, 
    -0.15831667f, 0.04919465f, 0.26102582f, 0.09646357f, -0.19858770f, -0.15691073f, -0.07179665f, -0.03560548f, 
    0.28326252f, 0.01415517f, 0.03462088f, 0.20446365f, 0.19719841f, 0.08482093f, 0.27833471f, -0.25237143f, 
    0.03513598f, 0.12823628f, 0.03077147f, 0.13838142f, 0.45541236f, 0.14521806f, 0.07889107f, 0.45032540f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.26162791f, -0.16466284f, 0.02355426f, -0.26959753f, -0.08257382f, -0.17516284f, 0.15102479f, 0.06956381f, 
    -0.01307142f, -0.00659131f, 0.00644850f, 0.06833179f, 0.28897709f, 0.25953293f, -0.11946520f, -0.12445832f, 
    0.09312589f, 0.06017250f, 0.05256620f, 0.01589275f, 0.05238022f, -0.07280398f, 0.05755879f, 0.05082839f, 
    0.04303599f, 0.08130126f, 0.10765690f, -0.26743576f, -0.19326322f, -0.07704532f, -0.04435360f, -0.04925755f, 
    0.08284827f, -0.04489945f, 0.03106505f, 0.05246994f, 0.03639757f, 0.08110025f, 0.34389052f, -0.53880137f, 
    -0.06191253f, -0.09426644f, -0.00339636f, 0.12026108f, -0.00533374f, -0.01113821f, -0.19592205f, 0.04503577f, 
    -0.24900392f, -0.02571603f, 0.07504642f, -0.10849675f, -0.03524234f, -0.00877117f, 0.03543796f, 0.01005490f, 
    -0.09352289f, -0.17380653f, -0.09083109f, -0.11538339f, -0.55521959f, -0.38421050f, -0.46045041f, -0.00785706f, 
    0.00795026f, -0.02529811f, -0.01913684f, -0.01023290f, 0.00766471f, 0.00035116f, 0.04710413f, 0.00321012f, 
    -0.42996523f, -0.18407224f, 0.25035724f, -0.06072170f, -0.11039479f, 0.04855943f, 0.03038880f, 0.03915517f, 
    -0.02176074f, 0.04430879f, -0.10675983f, 0.05428363f, -0.34045160f, -0.37308890f, -0.02997651f, 0.02779201f, 
    -0.00685779f, -0.02039118f, 0.02978115f, -0.05054503f, -0.15992917f, -0.09340260f, -0.16298741f, -0.18922451f, 
    0.07323400f, -0.10047380f, 0.07592344f, -0.12960161f, -0.17874052f, -0.11936194f, 0.03536763f, -0.14841115f, 
    -0.13729060f, -0.10181431f, -0.09982906f, -0.03684694f, -0.03452550f, 0.04078965f, -0.32775784f, 0.19155228f, 
    -0.02468024f, -0.02511804f, -0.00327150f, -0.01696957f, -0.09804907f, -0.05591250f, -0.01894316f, -0.11031749f, 
    -0.17402317f, 0.00574710f, 0.03390457f, -0.17467751f, -0.05831236f, 0.03937630f, -0.10064728f, -0.00906607f, 
    0.00936836f, -0.10656510f, 0.00341396f, 0.02806274f, -0.11263297f, 0.03052750f, 0.13741298f, -0.16006868f, 
    -0.02698541f, 0.04671803f, -0.02565094f, -0.00590287f, -0.02551880f, -0.10096293f, -0.10723040f, -0.10824964f, 
    0.25853011f, 0.15133467f, 0.01858927f, -0.00662139f, 0.07169977f, 0.02178812f, 0.00806893f, -0.02671285f, 
    0.01514696f, 0.06092643f, -0.00278174f, 0.06185804f, 0.06066384f, 0.08310405f, -0.12343126f, -0.06226197f, 
    0.02287606f, 0.02304537f, 0.07064547f, -0.25619602f, -0.03530816f, -0.16733718f, -0.17330283f, -0.00507325f, 
    -0.43668011f, -0.36546272f, -0.12175552f, -0.15025568f, -0.01258508f, 0.02362742f, 0.00282154f, 0.00518488f, 
    -0.02645355f, -0.02339142f, -0.06003392f, -0.12196884f, 0.24806161f, 0.22469446f, -0.05555561f, -0.15756668f, 
    0.07808550f, -0.05196901f, 0.11771872f, 0.01726073f, -0.05570726f, -0.11102215f, -0.04597913f, -0.07287183f, 
    0.24092674f, 0.07714112f, -0.08613091f, -0.01504921f, 0.12159780f, 0.20954181f, 0.02264597f, 0.04446016f, 
    -0.03921000f, -0.00919188f, -0.10025951f, -0.03138751f, 0.10760804f, -0.00969887f, -0.19176790f, -0.09420670f, 
    -0.08677143f, -0.11228327f, -0.06516856f, -0.15919943f, -0.03321901f, 0.07078481f, -0.00179445f, -0.06410089f, 
    -0.07675061f, -0.10404523f, -0.04235124f, -0.11203362f, 0.00093625f, -0.11112059f, -0.07751312f, -0.04000378f, 
    -0.05731966f, -0.05824628f, 0.06066439f, 0.20240594f, -0.18748066f, -0.33397165f, 0.06157809f, -0.11925195f, 
    -0.08056864f, 0.05818355f, -0.17810993f, -0.07170608f, -0.02353085f, 0.08436594f, -0.05471070f, 0.02991446f, 
    0.20603943f, 0.19212957f, -0.14528097f, -0.11160477f, -0.01882039f, 0.04040991f, 0.09592874f, -0.17629872f, 
    -0.15283820f, 0.01714224f, -0.04972609f, -0.03427022f, 0.13782316f, 0.02949663f, -0.09660719f, -0.03231809f, 
    0.11677418f, 0.04008116f, -0.00529417f, -0.07694200f, -0.05745771f, -0.00964678f, 0.07249089f, 0.00740050f, 
    0.22796354f, 0.10661146f, 0.00110176f, -0.09526606f, 0.13822766f, 0.01051282f, 0.07574969f, -0.00492975f, 
    0.00091370f, -0.04138902f, 0.05225805f, -0.03805938f, -0.15447795f, -0.16772400f, -0.00824590f, 0.01098507f, 
    0.01594602f, 0.05422619f, -0.00551556f, 0.02094525f, -0.03410950f, 0.06580094f, -0.06755781f, 0.06462285f, 
    -0.12712246f, 0.26437941f, -0.00006996f, -0.05773019f, 0.02041399f, -0.02191373f, 0.05154315f, -0.05903891f, 
    -0.03172191f, -0.00178897f, 0.03182090f, -0.17581277f, 0.11122483f, 0.12171394f, -0.00472199f, 0.04445180f, 
    0.03962765f, 0.03244636f, 0.00138686f, 0.05552553f, -0.10015181f, 0.03561242f, 0.00301010f, -0.02444066f, 
    0.16118872f, 0.06153414f, -0.03128970f, 0.02865879f, 0.13379805f, 0.18582894f, -0.12394907f, -0.04231262f, 
    0.02399051f, 0.04491745f, -0.00146177f, 0.12670831f, -0.12282065f, 0.06184412f, 0.24542512f, -0.13470988f, 
    -0.01736356f, -0.09377494f, 0.03024231f, -0.16193742f, -0.05325624f, 0.02768970f, 0.10128202f, 0.07871516f, 
    -0.04577390f, 0.01521104f, -0.18229818f, -0.11620429f, -0.09172501f, -0.04786545f, -0.07334607f, 0.01630440f, 
    -0.01587950f, -0.00261443f, 0.01825055f, -0.16533533f, 0.07449868f, 0.10184478f, -0.08309177f, -0.07481182f, 
    -0.05653814f, 0.09631160f, -0.19244775f, -0.22172272f, 0.00869343f, -0.03260765f, -0.06327877f, 0.03053737f, 
    -0.26003096f, -0.10551854f, -0.06117591f, -0.12250865f, -0.04596797f, 0.02597265f, 0.01084315f, -0.00077656f, 
    -0.03115595f, 0.01182539f, -0.16279031f, -0.08073165f, 0.27902877f, 0.21395350f, -0.11315395f, -0.15004914f, 
    0.15593146f, 0.13008821f, 0.08538444f, 0.12287348f, -0.01553160f, 0.01231161f, 0.01721597f, -0.00566775f, 
    0.25480402f, 0.13759969f, -0.05643729f, -0.05042908f, 0.09430728f, 0.04976002f, 0.03986067f, -0.16942585f, 
    -0.10036519f, -0.09600713f, -0.13914001f, 0.05539041f, 0.21862200f, 0.15688939f, -0.00538469f, -0.28078142f, 
    0.03390015f, 0.01754549f, 0.03065727f, 0.08403090f, 0.00536873f, 0.01988134f, -0.00149133f, 0.01680975f, 
    0.34911105f, -0.07857716f, -0.32282609f, 0.01390472f, 0.06454209f, 0.04783633f, 0.07933889f, -0.07917800f, 
    -0.02883849f, 0.04869802f, -0.03459978f, 0.17100815f, 0.25932959f, 0.17792556f, 0.01392911f, -0.13050854f, 
    0.09689796f, 0.05437743f, 0.01958460f, 0.00822409f, -0.02077215f, 0.01835213f, -0.08338521f, -0.02335936f, 
    0.39353210f, -0.06431177f, -0.02341152f, -0.23051816f, -0.00072949f, -0.03876853f, 0.02925171f, 0.03413272f, 
    -0.08156490f, -0.00574148f, -0.05356633f, -0.03136392f, 0.22796817f, -0.07967802f, -0.21832561f, -0.00353799f, 
    -0.05552090f, -0.15743349f, -0.17518711f, -0.13629401f, -0.02694641f, -0.10819967f, -0.09949179f, 0.09039218f, 
    0.13292772f, 0.15675341f, -0.03237724f, -0.03418538f, 0.02122176f, 0.08460502f, 0.04154222f, -0.01555103f, 
    -0.05589220f, 0.00962098f, 0.02261943f, 0.01680298f, -0.03327829f, 0.00472875f, 0.09451552f, -0.00496489f, 
    -0.24799995f, 0.01715246f, -0.05306245f, -0.09225021f, -0.03993522f, -0.03722881f, 0.01929939f, -0.06674034f, 
    0.09066496f, 0.06391305f, -0.01909342f, -0.08994983f, -0.03765022f, -0.18014665f, -0.13575882f, 0.09558270f, 
    0.10420364f, 0.04424731f, -0.01425267f, 0.04635767f, 0.09972972f, 0.05738693f, 0.03402530f, 0.01253314f, 
    0.06099431f, -0.07027665f, -0.00212294f, -0.18736632f, 0.05244759f, 0.01650039f, 0.03162238f, 0.00030579f, 
    0.25424594f, 0.07722801f, -0.05982507f, -0.41487491f, 0.04317102f, -0.06436129f, 0.14212850f, -0.09440774f, 
    -0.00942818f, -0.03758954f, -0.04523084f, -0.16958016f, -0.02147253f, -0.05417747f, 0.02182740f, 0.02829497f, 
    -0.05602235f, -0.03760707f, -0.00944896f, 0.03166781f, -0.16539873f, -0.21318570f, -0.04208519f, -0.10798479f, 
    0.10454594f, -0.10117006f, -0.05831208f, -0.10591412f, -0.06233465f, -0.11183185f, 0.03514081f, -0.00490423f, 
    0.02225689f, -0.04230985f, 0.02939839f, 0.07814695f, 0.02916060f, 0.09427463f, -0.04191628f, -0.03637761f, 
    -0.06379580f, -0.00645478f, -0.04116183f, 0.00201796f, -0.07585527f, 0.11132374f, 0.07432058f, 0.07182521f, 
    0.22171387f, 0.33992210f, 0.01139080f, -0.19974673f, 0.09050132f, 0.05602473f, -0.09429918f, 0.16163214f, 
    0.03335349f, 0.03936521f, 0.02326169f, -0.03550684f, 0.00675845f, 0.15194820f, -0.33468491f, 0.15519613f, 
    0.02680524f, -0.01890138f, 0.07522828f, 0.07754531f, 0.03727119f, 0.13453406f, -0.12133935f, -0.04307668f, 
    0.03923991f, 0.22012995f, 0.32424083f, -0.37345368f, -0.12215382f, 0.09370922f, 0.00068748f, -0.00708446f, 
    -0.02216644f, -0.11513539f, -0.20048277f, -0.17058207f, -0.30051640f, -0.22339255f, -0.15517895f, 0.13686736f, 
    0.02676332f, 0.06840546f, 0.02207891f, -0.05033814f, 0.03294510f, -0.00838711f, 0.02238065f, 0.01866527f, 
    0.09900147f, 0.17329617f, -0.08041187f, -0.02245276f, -0.06059017f, 0.02511336f, 0.06878816f, 0.02835986f, 
    -0.09789095f, 0.02848567f, 0.03407522f, 0.01282314f, 0.09408060f, -0.18295407f, 0.01809609f, -0.16789536f, 
    -0.15472643f, 0.11237116f, -0.16980204f, -0.12556148f, -0.04109318f, -0.02018059f, 0.02935386f, 0.00287727f, 
    0.06058945f, 0.07197805f, 0.00471701f, -0.17006604f, 0.02423775f, 0.08699197f, 0.15763094f, 0.13008039f, 
    0.01666639f, -0.10238481f, -0.00718386f, -0.07556881f, 0.36898410f, 0.14669687f, 0.13602200f, -0.27809575f, 
    -0.05031076f, -0.06422555f, 0.16337089f, -0.12070276f, 0.01324389f, -0.06782139f, -0.05457213f, -0.08905279f, 
    0.05357608f, -0.08896891f, -0.18961085f, 0.02565453f, -0.13121696f, -0.06876501f, -0.15973362f, -0.13888058f, 
    -0.06615845f, 0.05107518f, -0.05659942f, -0.08950876f, 0.24844643f, -0.01244220f, -0.11040210f, -0.06674998f, 
    0.19070646f, 0.06945940f, 0.01386635f, 0.06788780f, 0.00907864f, 0.14686987f, 0.02228826f, 0.06294063f, 
    0.21923706f, -0.36558822f, -0.28631604f, -0.06285188f, -0.08696498f, -0.09781230f, -0.12866887f, -0.13453224f, 
    -0.11102583f, 0.08436484f, -0.06686787f, 0.12168326f, -0.39657059f, 0.35265112f, 0.13936897f, -0.20864396f, 
    0.08573557f, 0.06162450f, -0.18551062f, -0.04056978f, 0.03209665f, -0.11089906f, -0.01083451f, 0.03202098f, 
    0.37753776f, -0.12970504f, 0.04119354f, -0.22540225f, -0.04556448f, 0.05488921f, 0.08882076f, 0.08739890f, 
    -0.01554749f, 0.08192462f, -0.10944863f, -0.10907530f, 0.36627290f, 0.06981450f, -0.09372851f, -0.01221243f, 
    -0.04949445f, -0.04479544f, 0.04659031f, -0.02664207f, 0.09558427f, -0.10392340f, 0.12192390f, 0.18903995f, 
    -0.05766616f, 0.01667955f, -0.04368763f, -0.02309508f, 0.07343385f, 0.10695776f, 0.03833774f, -0.02214593f, 
    -0.08048917f, -0.04125135f, -0.12133577f, -0.09909170f, 0.06865446f, 0.08760268f, 0.02323961f, -0.02402441f, 
    -0.00013780f, -0.05694909f, 0.01621683f, 0.07661343f, 0.06675325f, 0.04578548f, 0.04957839f, 0.01129392f, 
    -0.07393247f, -0.03887457f, 0.06471999f, -0.08515332f, -0.27632815f, 0.06115934f, -0.06723388f, -0.12670554f, 
    -0.07618780f, -0.04477410f, -0.01724722f, 0.05618755f, -0.09271469f, -0.40110263f, -0.26486287f, -0.05285237f, 
    -0.03046412f, -0.06180114f, -0.24124485f, -0.05678112f, -0.09003042f, -0.20192613f, -0.19228350f, -0.21379650f, 
    -0.05791551f, -0.02242521f, -0.14538944f, -0.01717011f, -0.01985183f, -0.04227527f, -0.07238574f, 0.02076930f, 
    -0.01222563f, 0.00332440f, 0.02983729f, -0.05206294f, 0.02277368f, 0.00724740f, 0.17111668f, 0.27533752f, 
    -0.09166704f, 0.13504337f, -0.01972381f, -0.05530715f, 0.07373008f, -0.04276203f, -0.01412339f, 0.02568448f, 
    0.07762664f, -0.11845208f, -0.21427400f, -0.66444969f, 0.00841832f, -0.07087690f, -0.03818971f, 0.08799383f, 
    -0.04962229f, 0.01333522f, 0.00538631f, -0.14549516f, -0.38964653f, 0.17013136f, -0.15942226f, -0.11118042f, 
    0.21443464f, 0.02475990f, 0.00970836f, 0.00807417f, 0.10344619f, -0.00666338f, -0.14416249f, 0.02515331f, 
    0.09157729f, 0.23771906f, 0.00570094f, 0.02120024f, -0.06600150f, 0.08212116f, 0.00082888f, -0.07112376f, 
    -0.02041188f, 0.01631362f, 0.03325079f, 0.11233424f, 0.47075376f, -0.01903863f, 0.23922083f, 0.02174888f, 
    0.09648754f, -0.07284795f, -0.04740994f, 0.00881094f, -0.08626380f, 0.00992419f, -0.03690349f, -0.00263984f, 
    0.04843751f, -0.02425862f, 0.04737980f, 0.05213485f, -0.01635097f, -0.08462519f, -0.04550122f, 0.03531370f, 
    0.02664619f, -0.01239417f, -0.04877893f, 0.08703501f, -0.02361069f, 0.10857707f, 0.18614271f, -0.24900396f, 
    0.00194214f, 0.09379783f, 0.01840581f, -0.03923918f, 0.20540787f, 0.07587677f, -0.02944588f, -0.05185137f, 
    -0.27939367f, -0.02876835f, -0.00274974f, -0.06125959f, -0.01881326f, 0.18302222f, 0.07297797f, 0.13478327f, 
    0.07932449f, 0.03801307f, 0.07696976f, 0.12512752f, 0.48964053f, -0.08634782f, -0.05431776f, 0.01441612f, 
    -0.02153062f, -0.06596303f, 0.05390953f, -0.05143502f, -0.01330748f, 0.03155859f, -0.23868826f, -0.02682674f, 
    -0.22194351f, -0.00136149f, 0.06080861f, 0.02483163f, 0.08291727f, -0.00506508f, 0.00810152f, 0.04966506f, 
    0.03424680f, -0.03258689f, 0.10522902f, -0.04218280f, -0.26130110f, 0.10592149f, 0.12638296f, -0.17941287f, 
    0.23208545f, 0.01792253f, -0.00122128f, 0.05658001f, -0.07801949f, 0.03013312f, 0.03170411f, -0.14351597f, 
    0.01487766f, 0.11009461f, -0.12488177f, -0.04590682f, -0.08393671f, 0.01594225f, -0.07337890f, -0.22004257f, 
    -0.06891491f, -0.03170661f, -0.02862801f, -0.07776357f, 0.09376549f, -0.27116674f, -0.03226196f, -0.13497299f, 
    -0.00135592f, 0.02901942f, 0.02590215f, 0.19029109f, -0.06398562f, 0.17985456f, 0.08015376f, 0.03568414f, 
    0.29457906f, 0.26953009f, 0.16567400f, -0.07655319f, -0.03772157f, -0.00777730f, -0.00590691f, -0.03824927f, 
    -0.05795364f, 0.07063953f, 0.03779768f, 0.01077578f, 0.02129892f, -0.25859895f, -0.00308859f, 0.12359586f, 
    0.06838793f, 0.08821075f, 0.03360993f, 0.13216069f, -0.04315473f, -0.05799103f, -0.14355725f, 0.11887743f, 
    0.37569487f, 0.26327723f, 0.19759867f, -0.05967702f, 0.10845750f, 0.09040289f, 0.15674296f, 0.23759553f, 
    -0.01119102f, 0.04676058f, -0.08108348f, -0.03427761f, 0.14551392f, -0.23169833f, 0.03465027f, -0.28844684f, 
    0.04251240f, -0.07776210f, -0.02982201f, 0.35672164f, -0.03582909f, -0.02690736f, 0.05485682f, -0.04720950f, 
    0.04447330f, -0.05236692f, 0.23092455f, -0.34696615f, 0.00116956f, 0.06028469f, 0.00304515f, -0.02969565f, 
    -0.09317749f, -0.20979600f, -0.09332818f, 0.00853458f, 0.33988333f, -0.15882066f, 0.05764635f, -0.08277781f, 
    0.04767599f, -0.10121993f, 0.06528355f, -0.25438780f, -0.02856741f, 0.03690990f, -0.07216878f, 0.09694716f, 
    -0.12149976f, -0.09068343f, -0.13225861f, -0.12945858f, -0.02257474f, 0.06739824f, 0.02093385f, -0.02069537f, 
    0.26366696f, 0.21968102f, 0.07120445f, 0.11742459f, 0.20792186f, 0.34275499f, 0.24181174f, -0.17153294f, 
    -0.04134561f, -0.01131396f, 0.02896167f, -0.00863363f, 0.01826754f, -0.01438231f, -0.01168171f, -0.13345650f, 
    0.00441581f, 0.09655146f, 0.25410831f, 0.15487808f, 0.01923893f, 0.10906021f, 0.22038238f, 0.07115432f, 
    -0.03720376f, -0.00942109f, 0.00667457f, -0.06166586f, 0.03871080f, 0.12514833f, 0.06467669f, 0.06823866f, 
    -0.00702262f, -0.03830761f, -0.03848321f, -0.02708086f, 0.01012101f, -0.14457308f, 0.01362591f, 0.17916401f, 
    -0.05975154f, 0.03891003f, -0.19191091f, 0.16362764f, 0.16729945f, -0.11644761f, 0.07719442f, -0.04748265f, 
    0.01186063f, 0.05206136f, -0.07980486f, 0.22808103f, -0.21827815f, -0.15861796f, -0.04267087f, -0.11394195f, 
    0.01432326f, 0.04680217f, 0.00614752f, 0.15713441f, -0.02944565f, -0.03106440f, 0.03408999f, 0.05815595f, 
    -0.05274810f, -0.03534186f, -0.07509162f, -0.06681562f, -0.05814680f, 0.00433313f, -0.08316651f, -0.19246596f, 
    -0.10750321f, -0.01167324f, -0.04620818f, -0.01732242f, -0.18356389f, -0.07227790f, -0.12913741f, -0.40009031f, 
    0.10311717f, 0.05337128f, 0.00512962f, 0.07178554f, 0.05423390f, -0.01548256f, 0.08269773f, 0.00391132f, 
    0.08929736f, -0.05161222f, -0.06923891f, 0.00578533f, -0.13060047f, -0.07953720f, 0.07866922f, 0.05485591f, 
    0.02680487f, 0.14033847f, -0.07514531f, -0.01227598f, -0.07154579f, 0.11826974f, -0.16383193f, 0.00249474f, 
    -0.04661674f, 0.02534023f, 0.02040325f, -0.12628625f, -0.07464016f, -0.00102859f, 0.03577391f, 0.05933259f, 
    0.01646533f, 0.19828169f, 0.11728110f, 0.13371806f, 0.04761312f, -0.01849993f, 0.00792375f, 0.01484980f, 
    0.00998810f, 0.22415215f, -0.10285172f, 0.16942264f, 0.00889078f, 0.08122171f, 0.16737883f, 0.26571962f, 
    -0.28284454f, 0.17600863f, -0.18722388f, 0.03316259f, -0.02234960f, 0.02578911f, -0.02354360f, 0.04691881f, 
    -0.03582962f, -0.12484793f, -0.10411058f, 0.00906247f, -0.01556101f, 0.04006588f, 0.17893071f, -0.00731220f, 
    0.01235760f, 0.03585026f, 0.04886220f, 0.01587507f, -0.11924935f, 0.13762458f, 0.17576297f, 0.06234487f, 
    -0.20558399f, -0.12981388f, -0.19461165f, 0.07710709f, -0.10127083f, 0.03321830f, 0.05454376f, -0.00078103f, 
    0.40946794f, -0.18873873f, 0.04963662f, 0.04235455f, -0.03110968f, -0.08766961f, 0.03064765f, 0.04831027f, 
    0.07832779f, -0.14669937f, 0.09320740f, -0.15181926f, -0.33198220f, 0.04316327f, -0.22503749f, -0.15054454f, 
    -0.11215164f, 0.17885923f, 0.15020780f, 0.02974531f, 0.03703336f, 0.07437135f, -0.06889436f, -0.03255060f, 
    -0.16886987f, -0.05638475f, 0.12201899f, -0.23862395f, 0.15403809f, -0.07217158f, 0.12576731f, -0.13671125f, 
    0.07429128f, 0.01772273f, -0.05386884f, -0.01454275f, 0.61333668f, -0.25577813f, 0.49195358f, -0.14664364f, 
    0.01849444f, -0.06497304f, 0.08086422f, 0.01480492f, 0.01075404f, 0.00820725f, -0.13884379f, -0.09017821f, 
    0.04065366f, -0.10553022f, -0.04992074f, -0.01433818f, 0.15723164f, 0.06737348f, -0.02014447f, -0.25543332f, 
    0.18656811f, -0.07149619f, -0.05810120f, -0.02321785f, -0.02200809f, 0.06295101f, 0.02374065f, -0.05234190f, 
    0.22899544f, -0.08417743f, -0.06716711f, 0.00396736f, -0.15072137f, -0.05895431f, -0.06930757f, 0.02637588f, 
    -0.05934761f, -0.09712701f, 0.00136702f, -0.30573300f, 0.08690739f, -0.06510401f, 0.00728494f, 0.11664614f, 
    -0.07188579f, -0.17926197f, -0.16474827f, 0.07909981f, -0.06359853f, -0.02591546f, -0.04174864f, 0.00309221f, 
    -0.12224407f, 0.13409588f, -0.08847433f, -0.03752868f, -0.00951025f, -0.06668577f, -0.03375276f, 0.00199639f, 
    -0.50537241f, -0.18846449f, 0.01776130f, -0.11172751f, 0.09448660f, 0.07662093f, 0.16474183f, 0.20881265f, 
    0.10850925f, -0.10328625f, 0.01153894f, 0.02158962f, 0.05044499f, 0.09270155f, 0.07997389f, 0.07035955f, 
    0.04976330f, 0.02207736f, -0.00359667f, -0.04300266f, 0.04800236f, 0.06736584f, 0.01640306f, 0.06023138f, 
    0.14444529f, -0.03346185f, -0.01310582f, -0.06248499f, 0.02917275f, 0.25623283f, 0.11598900f, -0.50628132f, 
    0.15637715f, -0.21106768f, 0.02784554f, 0.01059710f, 0.05108289f, -0.07703251f, -0.00311315f, -0.26695716f, 
    0.05505874f, 0.03450743f, 0.00733680f, 0.06543881f, -0.36148578f, -0.33613294f, -0.32250345f, -0.24971171f, 
    -0.28793624f, -0.00654205f, -0.26029271f, 0.20104577f, -0.11253583f, -0.06639522f, -0.00062745f, 0.22951530f, 
    -0.03734221f, 0.03146056f, -0.03458839f, 0.10361555f, 0.45198828f, -0.12622665f, -0.27765739f, -0.08082399f, 
    -0.00637616f, -0.10196734f, 0.00170913f, -0.04787486f, 0.06964324f, -0.12215836f, -0.06540172f, 0.04590154f, 
    -0.97589606f, 0.02631675f, -0.19852732f, -0.19350310f, -0.08123226f, -0.12244172f, -0.01463098f, 0.15609346f, 
    -0.03425843f, -0.00926799f, -0.04700473f, -0.08029138f, 0.22323965f, 0.15558167f, 0.16428569f, 0.09099057f, 
    0.02314242f, 0.01631012f, -0.06816449f, 0.01902559f, 0.03604682f, 0.01166667f, -0.00078727f, 0.01470819f, 
    -0.25711557f, -0.40001723f, 0.00546318f, 0.17408296f, -0.02382097f, -0.02161279f, 0.03809715f, 0.01875508f, 
    -0.05883909f, 0.02810842f, -0.40597647f, -0.01966810f, -0.29033861f, -0.20913278f, -0.07011025f, 0.14300133f, 
    0.28822517f, 0.05715047f, -0.15667000f, -0.05450632f, -0.12877554f, 0.04032904f, -0.05429420f, -0.03423541f, 
    -0.04410942f, 0.12099206f, -0.05875218f, -0.16122931f, 0.06506585f, 0.05173793f, -0.00650386f, -0.22977740f, 
    0.04483758f, 0.07309589f, -0.14817131f, 0.00565574f, -0.15481691f, -0.08953223f, 0.02358507f, -0.05497087f, 
    -0.08466410f, 0.10892294f, 0.07046396f, 0.04567422f, 0.08374791f, -0.00918236f, -0.10638586f, 0.02515917f, 
    0.08490264f, -0.07305576f, 0.06024454f, 0.01320299f, -0.00331841f, 0.06905962f, 0.13713305f, -0.03074650f, 
    0.15827486f, 0.04996463f, -0.15470527f, 0.08900006f, 0.34878960f, 0.07563264f, 0.13928850f, -0.31423265f, 
    -0.11618846f, -0.06185280f, -0.22365047f, -0.34027299f, 0.07958031f, -0.00917319f, -0.13105005f, 0.00258680f, 
    0.06478896f, -0.09415211f, 0.13557298f, -0.01426547f, -0.16836111f, 0.06831204f, 0.07300656f, 0.00228806f, 
    -0.04218379f, -0.09858435f, -0.03206944f, 0.00600542f, -0.15425904f, 0.04425177f, 0.13470040f, -0.08551918f, 
    0.00268850f, 0.02601653f, 0.01633899f, 0.02754344f, 0.08469824f, -0.03085945f, -0.02687340f, -0.02064552f, 
    0.02588496f, -0.12001696f, 0.17019041f, -0.11918709f, 0.02262327f, 0.01651579f, 0.10764593f, -0.10867303f, 
    -0.00028261f, -0.14618534f, 0.11722299f, -0.07299453f, 0.27381599f, -0.03560246f, -0.15148261f, 0.02076053f, 
    -0.02714180f, 0.09736337f, 0.03240987f, 0.05519096f, 0.00394670f, -0.01155471f, 0.05480153f, 0.00872902f, 
    0.06063942f, -0.04307974f, -0.53721613f, -0.24654037f, -0.07133828f, 0.05535142f, 0.00406083f, 0.00486950f, 
    -0.04625230f, 0.00754413f, -0.02604839f, -0.07421682f, -0.16318916f, 0.07059870f, -0.02058422f, -0.09121120f, 
    -0.05428403f, -0.06189908f, -0.25247622f, -0.17243290f, -0.10210560f, -0.01319942f, 0.03164077f, 0.10404289f, 
    -0.03877687f, -0.10477058f, 0.12922211f, -0.06606259f, -0.03532107f, 0.07207525f, -0.01022558f, -0.06785184f, 
    -0.03171097f, -0.01179638f, -0.09696047f, 0.10831366f, 0.25972217f, -0.17992280f, 0.21296206f, -0.00066378f, 
    -0.02769079f, 0.00443037f, 0.17673402f, -0.04123167f, 0.09589183f, 0.08995890f, 0.02919736f, 0.06788181f, 
    -0.05145855f, 0.50411743f, -0.43733415f, 0.00206731f, -0.02868818f, 0.02657403f, 0.00734952f, 0.01803591f, 
    0.00322401f, -0.00409176f, -0.00001917f, -0.02064971f, -0.05355325f, -0.22986096f, 0.17425266f, -0.09048332f, 
    -0.07675511f, -0.20757927f, 0.05130874f, 0.11436724f, 0.06205340f, 0.02866970f, 0.05062151f, 0.04526882f, 
    -0.60383415f, -0.08999168f, 0.02095067f, -0.10305048f, 0.04456582f, -0.09347618f, -0.29502168f, -0.19421126f, 
    0.01575207f, 0.01690646f, -0.05597809f, 0.02947153f, -0.09279805f, -0.04319328f, -0.21962531f, 0.14581652f, 
    0.13703993f, 0.06427328f, -0.05429741f, 0.05473218f, -0.02174288f, -0.03458842f, 0.12279706f, 0.01694863f, 
    0.10506982f, 0.09660611f, -0.06953856f, 0.09102836f, 0.03090661f, 0.00561369f, 0.00101824f, 0.05819152f, 
    -0.05108576f, -0.06923229f, 0.21131755f, 0.00805644f, -0.26075754f, -0.29339427f, 0.47621271f, -0.28592002f, 
    -0.02125535f, 0.04772669f, -0.03317176f, -0.00280584f, 0.00603480f, -0.04750483f, 0.01094254f, 0.02496533f, 
    -0.14903410f, -0.14734200f, -0.26974109f, -0.00552978f, -0.05636186f, -0.09600835f, -0.03896694f, 0.05323527f, 
    0.03907733f, -0.06508818f, -0.13042319f, 0.08418971f, 0.04102571f, 0.01322208f, -0.04937861f, -0.19697087f, 
    0.06626162f, 0.04819501f, -0.04201680f, 0.02222254f, -0.03418646f, -0.17612305f, -0.12492241f, 0.25777555f, 
    0.06348061f, 0.16979183f, -0.18713081f, 0.00393342f, -0.10085869f, -0.02398665f, 0.06512965f, 0.00440830f, 
    -0.03003001f, -0.01489832f, 0.00378473f, 0.00037530f, -0.04937855f, -0.05073022f, 0.05813300f, -0.14367260f, 
    -0.15058894f, -0.05912547f, -0.02322956f, -0.01542835f, 0.03541939f, -0.00645211f, -0.15469341f, 0.04370056f, 
    0.06619073f, -0.22419727f, 0.00789669f, 0.10321380f, -0.09256428f, -0.04205014f, 0.03057759f, 0.00273437f, 
    -0.00957829f, 0.00014428f, -0.07244385f, 0.00387449f, -0.04834005f, -0.01549965f, -0.01651958f, 0.10070539f, 
    0.08297502f, -0.07048425f, 0.00807544f, -0.02404690f, -0.06730601f, -0.10847947f, -0.03025446f, 0.00643678f, 
    0.00160254f, 0.13245939f, 0.19679202f, 0.17330228f, -0.03849003f, 0.00221932f, -0.00267406f, 0.12119082f, 
    0.07988010f, 0.05202833f, 0.03881114f, 0.00826927f, -0.05163889f, 0.00518926f, 0.20494729f, -0.06919502f, 
    0.14710596f, -0.03740830f, -0.17489426f, 0.01965697f, 0.05493940f, -0.27350822f, 0.09821402f, 0.01721969f, 
    -0.21998145f, 0.05934346f, 0.00169392f, 0.09623482f, -0.07420596f, 0.03460178f, 0.01974211f, -0.00692038f, 
    -0.02648585f, -0.03503623f, 0.13702646f, -0.06797132f, 0.18000232f, -0.12590189f, -0.19452730f, -0.08487904f, 
    0.03997428f, -0.05809817f, 0.01968100f, -0.03162940f, 0.05564236f, 0.01037709f, -0.07738020f, 0.02909784f, 
    -0.35519293f, 0.33265799f, 0.40840930f, 0.16371304f, -0.09472110f, -0.02204143f, -0.03354314f, -0.02837255f, 
    -0.01134149f, -0.06285143f, -0.00003840f, -0.04627911f, -0.11638809f, -0.03653597f, 0.12331327f, -0.34065893f, 
    0.01938103f, 0.12372629f, -0.06622802f, 0.01014316f, 0.00116899f, 0.01947316f, 0.00799920f, -0.07070741f, 
    0.05128181f, -0.00581495f, 0.20909810f, -0.12045614f, 0.03819764f, 0.00952401f, 0.06828756f, -0.09440421f, 
    0.04199046f, 0.15815781f, 0.03028842f, 0.09863672f, -0.26939884f, -0.01657571f, 0.07700463f, -0.52488720f, 
    0.00614046f, 0.00660922f, 0.03285113f, -0.07348099f, -0.00099569f, 0.00456447f, -0.01456390f, 0.01306663f, 
    -0.28058881f, 0.00103373f, -0.10293885f, 0.10608617f, -0.03736350f, 0.02813430f, -0.13422337f, -0.11117536f, 
    0.07924765f, -0.07113786f, 0.08945833f, 0.04738956f, -0.12023185f, 0.33059770f, 0.50064695f, 0.33429042f, 
    -0.19102409f, -0.00121651f, -0.03201979f, -0.09534837f, -0.05186123f, 0.01945749f, -0.05297793f, 0.04341830f, 
    -0.03673216f, -0.16619514f, -0.02438900f, -0.02677439f, -0.04839559f, 0.16179661f, 0.21096116f, -0.06771836f, 
    -0.02868535f, -0.05007767f, -0.00515171f, 0.00348760f, -0.01484583f, -0.03299674f, -0.04253889f, -0.02804647f, 
    -0.04464448f, -0.01502752f, 0.00296712f, 0.00036428f, -0.01861171f, -0.06188329f, -0.02034677f, 0.10859600f, 
    0.04065811f, 0.06631777f, -0.43393779f, -0.08896657f, 0.02602192f, -0.04566374f, 0.06972293f, 0.06858099f, 
    0.01643106f, 0.00177933f, -0.00487705f, -0.10521261f, 0.07960804f, -0.11480260f, 0.10805091f, 0.09360000f, 
    0.04070749f, -0.04835786f, -0.03255786f, -0.15927787f, 0.02745683f, -0.06023259f, -0.10349064f, 0.15328571f, 
    0.00587578f, 0.19394398f, 0.19967227f, 0.06372400f, -0.12916617f, -0.06726335f, 0.14510395f, -0.09272172f, 
    0.07133755f, 0.07077140f, 0.03486956f, 0.03686284f, -0.03516800f, 0.27727526f, -0.33644852f, -0.00568975f, 
    -0.01560626f, 0.07002808f, 0.12222670f, -0.05012063f, 0.02521644f, -0.03443930f, -0.07888369f, 0.04903046f, 
    0.11836027f, -0.00602627f, -0.10565104f, -0.00158929f, -0.05251597f, 0.04741228f, -0.03857028f, 0.00153497f, 
    -0.01525243f, 0.06356265f, 0.09107926f, -0.05216532f, -0.25816303f, -0.14526799f, 0.00377110f, 0.04102234f, 
    -0.17098255f, -0.06621418f, -0.11588759f, -0.12786484f, 0.02571373f, -0.01004625f, 0.06519968f, -0.05797376f, 
    -0.19431959f, -0.02289826f, -0.19201542f, -0.02078843f, 0.03793562f, -0.01346311f, 0.00646662f, 0.01307058f, 
    -0.06734259f, 0.04109102f, -0.07566749f, 0.04706567f, -0.84380287f, -0.23415449f, -0.27959689f, -0.49257532f, 
    -0.09516168f, -0.17216216f, 0.04722799f, -0.01946622f, -0.00086995f, 0.00001143f, 0.02709813f, -0.00584482f, 
    -0.17638835f, 0.02555412f, 0.43615901f, -0.01877180f, -0.06516836f, -0.06052145f, 0.05480549f, 0.13326594f, 
    -0.09961716f, -0.04615271f, 0.17030634f, 0.00706450f, -0.53596914f, -0.58864731f, -0.20152822f, -0.08411191f, 
    -0.05960089f, -0.00965192f, 0.01813850f, -0.14319693f, 0.05186420f, 0.01192899f, -0.02331499f, -0.02607405f, 
    -0.20368676f, 0.00915305f, 0.40348876f, 0.06314240f, -0.01582327f, -0.05357669f, 0.04610614f, 0.08980249f, 
    0.06482292f, 0.04121010f, 0.17156467f, -0.10229447f, -0.54867893f, -0.16404434f, -0.26478681f, -0.16673626f, 
    0.04070423f, 0.04920699f, -0.01416891f, -0.05322132f, -0.02399217f, -0.06942327f, 0.12998341f, -0.02965572f, 
    0.02854655f, 0.17590928f, -0.05948133f, 0.13784744f, -0.07010828f, -0.06334176f, -0.09207951f, 0.03169267f, 
    0.00178499f, 0.04615736f, -0.08298127f, 0.06991311f, -0.47637820f, -0.10405274f, 0.30480146f, -0.31398901f, 
    -0.02497259f, -0.00272068f, 0.06375983f, -0.07705296f, -0.04005735f, 0.10338118f, 0.01039211f, -0.17385975f, 
    0.18126458f, -0.14575617f, 0.14114024f, 0.01551217f, 0.02791050f, 0.12480979f, -0.14983611f, -0.00798516f, 
    0.13064776f, -0.00874940f, 0.03276419f, 0.09799480f, -0.02807076f, 0.04043175f, -0.08941192f, -0.04718187f, 
    -0.01984834f, 0.14793116f, -0.16840082f, -0.00025130f, 0.00809617f, -0.00922599f, -0.00218963f, -0.07577892f, 
    -0.09238137f, -0.07051608f, 0.02134344f, -0.07212774f, 0.12052550f, 0.03103191f, -0.11309839f, -0.15406276f, 
    0.04139234f, 0.03700329f, 0.10182192f, -0.00414659f, -0.01363828f, -0.00058118f, 0.01505722f, 0.12597522f, 
    0.07077660f, -0.01042990f, 0.20048632f, 0.05080592f, -0.03827434f, -0.03022901f, -0.00974567f, -0.02532844f, 
    0.08136038f, 0.24417523f, -0.20201281f, 0.13635491f, 0.07540936f, -0.15285304f, -0.07016599f, 0.19161020f, 
    0.03502854f, 0.02067391f, -0.09314634f, 0.01362134f, -0.10388003f, -0.05882170f, -0.06651084f, -0.03527892f, 
    -0.06779833f, -0.06483549f, 0.01521156f, 0.02944165f, -0.05343788f, -0.16604352f, 0.02270112f, -0.10235624f, 
    -0.10379393f, 0.02221836f, -0.00509880f, -0.11991148f, -0.13605906f, -0.02881581f, -0.12694821f, -0.24774842f, 
    -0.01745634f, -0.01683906f, 0.10029966f, -0.13006920f, 0.17263035f, -0.05584753f, 0.17405085f, 0.21354483f, 
    0.01968989f, -0.06663790f, -0.00028930f, -0.07142181f, -0.02206767f, 0.09775074f, 0.00469756f, 0.10493024f, 
    -0.57034844f, -0.58499312f, -0.21420464f, -0.20971392f, 0.07679132f, 0.02972753f, -0.03464093f, -0.02090652f, 
    0.03177080f, -0.05373154f, -0.04086558f, 0.04947105f, -0.25993547f, 0.00783096f, 0.24168180f, -0.05600014f, 
    0.07772090f, -0.16982973f, 0.05712811f, -0.03343546f, -0.01209900f, 0.11823394f, 0.06505150f, -0.02130921f, 
    0.13629012f, -0.03374689f, -0.13360076f, 0.12053847f, 0.00684018f, 0.09284081f, -0.12646905f, 0.05218717f, 
    0.03204063f, -0.00354804f, 0.03264752f, 0.11184603f, 0.00092765f, -0.15854235f, 0.02925877f, -0.16737603f, 
    -0.02579217f, 0.00004129f, -0.01864008f, 0.03707407f, -0.01430864f, -0.00389048f, -0.06628961f, 0.00351562f, 
    0.18399252f, -0.07086188f, -0.17611670f, -0.15591773f, 0.06745046f, -0.00202318f, -0.05287317f, -0.05728360f, 
    0.03804144f, 0.02366189f, -0.04342129f, 0.10014023f, 0.30403483f, -0.26372093f, 0.14816524f, 0.31823084f, 
    0.08186250f, 0.14353421f, -0.20849016f, -0.00194783f, 0.00887751f, -0.03861333f, -0.08732427f, 0.14836265f, 
    0.30869234f, 0.51896822f, 0.26439059f, 0.42215538f, 0.04164147f, -0.03632468f, -0.00154951f, 0.02061776f, 
    -0.02538698f, 0.03496970f, -0.02039496f, 0.01837369f, 0.02928731f, -0.04872019f, -0.10729675f, 0.21844964f, 
    0.05557783f, 0.03879504f, 0.07204678f, 0.05372041f, 0.05889700f, 0.00551637f, -0.01446764f, -0.04563983f, 
    -0.10288330f, -0.00071109f, 0.05018158f, -0.15377799f, 0.08563491f, -0.01826199f, -0.09319576f, -0.02767179f, 
    -0.01674999f, 0.08928607f, -0.05384954f, 0.07191287f, -0.42936286f, 0.14483254f, 0.25886047f, -0.37250483f, 
    -0.06772108f, 0.10455241f, -0.00818177f, -0.21711791f, 0.01798646f, 0.05011898f, -0.02827756f, 0.05132672f, 
    -0.09301291f, -0.02389124f, 0.12572744f, 0.00061129f, 0.02270340f, -0.06876624f, -0.07494868f, -0.10440740f, 
    0.08189910f, -0.10020462f, 0.02461024f, 0.06837702f, -0.10580179f, -0.13775532f, 0.04136621f, -0.09854040f, 
    -0.01342051f, 0.12231804f, 0.03039397f, 0.12716156f, -0.03470522f, 0.01014756f, 0.00032152f, -0.02335558f, 
    0.26358122f, -0.17184740f, 0.33016813f, 0.29202640f, 0.03127671f, 0.02330512f, -0.04488583f, 0.11052688f, 
    0.03834720f, -0.16917257f, 0.09744428f, -0.03445325f, -0.02047096f, -0.04500785f, 0.09065906f, -0.05493393f, 
    0.02142799f, -0.08665255f, 0.05772075f, 0.17520364f, 0.07203300f, -0.00740824f, 0.08348672f, -0.19123349f, 
    0.04571738f, 0.05147542f, 0.25968581f, 0.26567990f, 0.00598820f, 0.03405703f, 0.03493974f, 0.03703877f, 
    -0.10426778f, -0.14398824f, -0.13162138f, 0.09058867f, -0.05422794f, -0.07425552f, 0.05864127f, -0.09253795f, 
    0.16437627f, 0.05037048f, 0.03350325f, -0.08213893f, 0.04661866f, 0.03784125f, 0.05816971f, -0.03518606f, 
    -0.33386537f, 0.01227424f, 0.04308731f, 0.09495027f, -0.20344231f, -0.02177745f, -0.10518526f, -0.23504107f, 
    0.09529436f, -0.01139939f, -0.10768790f, 0.08675987f, 0.03737934f, 0.06145946f, 0.05594968f, -0.03985753f, 
    -0.05299085f, -0.05812949f, -0.09837826f, 0.10303909f, -0.01046213f, -0.07892350f, -0.02243742f, 0.01422636f, 
    -0.30311400f, 0.37674138f, -0.03037877f, 0.46795768f, -0.01417468f, 0.01130104f, -0.01521363f, -0.07228617f, 
    -0.01382304f, 0.02278596f, 0.11841882f, 0.13310774f, -0.14837445f, -0.11063733f, -0.09823363f, 0.14834502f, 
    0.05401899f, 0.01225465f, 0.10690390f, -0.06807802f, 0.03939766f, 0.07540452f, 0.13150197f, 0.04310921f, 
    -0.00916141f, -0.34569284f, 0.20837432f, 0.05044467f, -0.10404975f, 0.09826634f, -0.00287322f, 0.11184581f, 
    -0.02960596f, -0.02450326f, 0.00957902f, -0.06218625f, 0.23703718f, 0.26100838f, -0.13807681f, -0.17641693f, 
    -0.11853439f, -0.18180056f, -0.10773430f, -0.05815641f, -0.21326768f, 0.15759133f, 0.00419243f, -0.05859759f, 
    -0.28372028f, -0.16094084f, -0.12067525f, -0.45689288f, 0.07617430f, -0.05924623f, -0.13474858f, -0.07752360f, 
    -0.01045981f, 0.10106453f, -0.01799625f, -0.25600845f, -0.18646106f, 0.01694485f, 0.41291025f, -0.21823891f, 
    -0.19323745f, -0.08302346f, -0.25734678f, 0.08376156f, -0.00389528f, 0.01293483f, -0.01633873f, -0.06974705f, 
    0.20012008f, -0.04182654f, 0.16244587f, -0.48981938f, -0.01777571f, -0.16723908f, -0.03089832f, 0.15195978f, 
    0.08923446f, 0.10213066f, -0.00077453f, -0.00786246f, 0.22656636f, 0.00565860f, 0.11983035f, 0.08998334f, 
    -0.07207552f, 0.10686773f, -0.15368944f, -0.19235051f, -0.15972088f, -0.11389696f, 0.17663288f, -0.13031024f, 
    -0.00314780f, 0.30997312f, -0.13027488f, -0.14866319f, -0.02484801f, 0.07471095f, -0.11981410f, 0.11163937f, 
    0.02627230f, -0.16634683f, 0.08861083f, 0.09383547f, -0.26160496f, 0.13664891f, 0.08307904f, 0.20580024f, 
    0.01878797f, 0.08035090f, -0.08028141f, -0.15277638f, -0.08060750f, 0.16920449f, 0.12885800f, 0.04699357f, 
    0.18586785f, 0.02648326f, -0.07677709f, -0.15866379f, -0.07656674f, -0.17324686f, 0.04758133f, -0.09221619f, 
    0.05640101f, 0.03408185f, -0.19759093f, 0.01744528f, 0.39988995f, -0.01304965f, -0.00706876f, 0.13222115f, 
    0.04206387f, -0.01877641f, -0.12376688f, -0.13484664f, -0.00963095f, 0.06823937f, 0.11043101f, 0.12608808f, 
    0.04122389f, -0.10012695f, 0.04105578f, 0.09292801f, 0.08811489f, 0.07903028f, 0.06419255f, -0.12367335f, 
    -0.10122013f, -0.01270391f, 0.02315561f, 0.00587139f, -0.07307660f, -0.15454775f, -0.14637698f, -0.05809415f, 
    0.09088115f, -0.09644581f, -0.11203074f, -0.02356418f, 0.04127767f, 0.03758413f, 0.11124824f, 0.02948267f, 
    -0.34821954f, -0.06687195f, 0.07723708f, -0.15140554f, -0.03145172f, 0.07288268f, -0.10806746f, 0.03303136f, 
    -0.14128715f, 0.01504483f, -0.03069453f, -0.03775843f, -0.04441389f, -0.04157401f, -0.07140463f, 0.17720968f, 
    0.09230220f, -0.03337900f, 0.04962676f, 0.03913630f, -0.06428757f, 0.14455684f, -0.03071272f, 0.03102124f, 
    0.01364171f, -0.05869453f, 0.07935227f, 0.17708400f, 0.02951078f, -0.05850862f, 0.00043097f, -0.07220487f, 
    0.02807670f, 0.07036372f, -0.01249188f, 0.08702676f, -0.16080104f, 0.07341594f, -0.28672874f, 0.17140900f, 
    0.06013487f, 0.00791879f, 0.10332499f, 0.03888832f, -0.04692212f, -0.13582045f, 0.02892118f, -0.16437200f, 
    -0.02820279f, -0.00915756f, 0.04893803f, 0.14085856f, -0.03104133f, -0.06132467f, 0.03935542f, -0.02817662f, 
    -0.02423260f, 0.09875247f, -0.04020232f, 0.06733046f, -0.05456271f, -0.19738834f, 0.46546718f, 0.14895712f, 
    -0.20433822f, -0.17078024f, -0.03167914f, 0.04599699f, -0.02708984f, 0.17289771f, 0.14121245f, 0.00361201f, 
    -0.21230908f, 0.17387243f, -0.19921371f, 0.17219210f, 0.09011415f, 0.03412906f, -0.02249868f, -0.00143416f, 
    -0.08088419f, 0.07476386f, 0.20315857f, -0.08277737f, -0.05273102f, -0.06585940f, 0.03098281f, 0.18719831f, 
    0.02038755f, -0.01615018f, -0.00223266f, -0.07486630f, 0.14137539f, 0.07900631f, 0.00275370f, 0.06070327f, 
    0.02731646f, -0.12783219f, -0.08066934f, 0.10709116f, -0.09484716f, -0.05503658f, -0.08257053f, 0.01217790f, 
    0.02227176f, 0.04077889f, -0.16713040f, -0.12612453f, 0.02875447f, 0.01805161f, 0.14419436f, 0.26373503f, 
    -0.13672359f, 0.04177322f, -0.00287259f, 0.05980977f, 0.10948398f, 0.02453155f, 0.04136422f, 0.08112077f, 
    0.11279552f, 0.01131232f, -0.08522774f, -0.21173109f, 0.04616058f, -0.09434405f, 0.00006109f, 0.02059152f, 
    -0.15751825f, 0.08128810f, -0.06825352f, -0.02593470f, 0.05115035f, -0.21113853f, -0.02650314f, 0.10307609f, 
    0.12778220f, 0.06111341f, 0.02097324f, -0.00247624f, -0.12843393f, 0.02499003f, -0.07575563f, 0.09985892f, 
    0.22389159f, -0.19458491f, 0.07274485f, 0.25933966f, 0.15074903f, 0.10506846f, 0.12932545f, -0.13426174f, 
    -0.03077462f, 0.00672097f, 0.09358174f, 0.10023090f, -0.11283164f, -0.03316764f, -0.00684435f, -0.08327489f, 
    -0.09063359f, -0.19612406f, -0.05088823f, -0.10706324f, -0.02536338f, -0.10405098f, -0.18408948f, 0.00291090f, 
    0.31171489f, -0.23395576f, -0.01125538f, 0.06454623f, -0.08349232f, -0.01925890f, -0.22542171f, 0.02171088f, 
    -0.04828105f, -0.01619128f, 0.00624086f, -0.00326743f, -0.06000007f, 0.14656878f, 0.01802618f, 0.22070792f, 
    0.12766314f, -0.17612998f, 0.13754196f, -0.03660452f, -0.10548414f, 0.11506294f, 0.07998668f, -0.11802913f, 
    0.17699295f, -0.04364689f, -0.14660294f, -0.50299275f, 0.05318070f, -0.03419840f, -0.13881226f, -0.06376918f, 
    -0.23157990f, 0.01700635f, 0.12199103f, -0.09566192f, -0.02159391f, -0.21800867f, -0.11697643f, 0.14866231f, 
    0.06404477f, 0.09222133f, 0.05590329f, 0.04815662f, 0.06967187f, -0.04568494f, 0.08241180f, -0.02057551f, 
    -0.11817004f, -0.10334402f, -0.15427920f, 0.15099986f, 0.06959984f, -0.03580884f, -0.09775232f, -0.06907757f, 
    -0.08549251f, -0.04286464f, 0.09476862f, -0.03014307f, -0.06371262f, -0.13008234f, 0.00441169f, 0.11374321f, 
    -0.03304378f, 0.03747699f, -0.04403193f, 0.04251126f, 0.06624320f, 0.01467718f, -0.04597964f, -0.10662642f, 
    -0.42808324f, 0.54012960f, -0.12346081f, -0.04562112f, 0.15970869f, 0.22082143f, -0.03199245f, 0.00263086f, 
    -0.10484917f, 0.00792989f, -0.02061592f, -0.12778692f, -0.00298124f, -0.05545378f, -0.04516999f, 0.09520997f, 
    0.03553173f, 0.02683362f, -0.07230579f, 0.08494162f, 0.06432209f, -0.07406554f, 0.15018448f, 0.02279438f, 
    -0.17637546f, 0.13021480f, -0.22282310f, 0.09138585f, -0.03349384f, -0.00058911f, -0.13091287f, 0.04220221f, 
    -0.07710960f, 0.01143984f, -0.08714690f, -0.02616319f, -0.10421369f, 0.09457050f, -0.04529060f, 0.32834071f, 
    -0.00537863f, 0.03650216f, 0.07252681f, -0.06591749f, 0.01726568f, -0.05251116f, 0.03205906f, -0.08728108f, 
    -0.06633727f, -0.21367559f, -0.11940508f, 0.20150639f, 0.06965534f, -0.05289752f, 0.02588763f, -0.13368146f, 
    -0.13225451f, 0.05487679f, -0.02153748f, -0.08808450f, 0.12585033f, -0.03540277f, 0.09573928f, -0.02262641f, 
    -0.04168792f, -0.11655248f, -0.04763618f, 0.08814149f, 0.00961640f, 0.23535146f, -0.11672394f, -0.16539541f, 
    -0.01375358f, 0.10044172f, 0.03958490f, 0.15991999f, -0.07085088f, -0.00907083f, 0.08072693f, 0.03000361f, 
    0.09161810f, 0.00894286f, 0.07261428f, 0.09771294f, -0.08333220f, 0.01552176f, -0.04501507f, -0.10137001f, 
    0.01365586f, -0.08087308f, 0.03256399f, -0.04324147f, -0.00448098f, -0.16245580f, 0.27029455f, 0.04895345f, 
    0.01221838f, 0.47374651f, -0.38299227f, 0.04896688f, 0.06148268f, 0.09286496f, -0.03922026f, -0.08399383f, 
    -0.23393500f, 0.10144024f, 0.00008955f, 0.13549168f, -0.17106681f, -0.23439318f, -0.01451465f, -0.05338104f, 
    -0.07393014f, -0.07841031f, -0.11098137f, 0.01846453f, -0.11950627f, 0.02440852f, -0.16496001f, -0.21151435f, 
    -0.37101772f, -0.01117810f, -0.04702227f, 0.20447779f, 0.08844596f, -0.03269747f, 0.12158167f, -0.02953697f, 
    0.03745167f, -0.04820368f, -0.04529594f, -0.17694855f, 0.22082204f, -0.01053485f, 0.10008683f, 0.12359485f, 
    0.02592508f, 0.05899631f, -0.05081331f, -0.03194112f, -0.00725065f, 0.03443310f, 0.00427861f, 0.08333158f, 
    0.10210337f, -0.14400007f, -0.03198278f, 0.07509483f, 0.01168181f, 0.08803131f, 0.10665595f, 0.13083012f, 
    0.04152211f, -0.09682857f, -0.19141512f, -0.01109988f, -0.12276119f, 0.31964490f, -0.21720283f, -0.10605110f, 
    0.15926349f, 0.07481093f, 0.04272685f, -0.04925213f, 0.04121813f, 0.05070310f, -0.13997594f, 0.01992610f, 
    0.26886275f, 0.05585836f, -0.16383144f, -0.09295745f, 0.08046813f, -0.19639045f, 0.00811630f, 0.04839988f, 
    -0.04770981f, 0.08416973f, -0.15994346f, 0.04330405f, -0.49420661f, -0.10597313f, -0.00234990f, -0.13556285f, 
    -0.16317157f, 0.00961085f, -0.02683199f, 0.13314840f, 0.13889122f, 0.17424084f, 0.06165111f, -0.01706737f, 
    0.28125411f, 0.04859361f, 0.02560983f, 0.02110374f, -0.06562408f, -0.02187867f, -0.10727534f, -0.03783293f, 
    -0.19028413f, -0.06600446f, 0.06825866f, 0.00298898f, 0.13308841f, -0.02117610f, -0.06613789f, 0.23161368f, 
    -0.04673641f, -0.13952060f, -0.03859260f, 0.06315515f, -0.15157203f, 0.04675951f, -0.14783478f, 0.00314226f, 
    0.38330358f, -0.19462258f, 0.02794445f, 0.19810888f, 0.03618699f, -0.07337347f, -0.07583719f, -0.16174635f, 
    0.03189962f, 0.07421792f, 0.09378573f, 0.07924796f, -0.02668224f, 0.52201879f, -0.40763581f, -0.57055253f, 
    0.21785153f, -0.00041098f, 0.00071023f, 0.04944528f, -0.16709122f, 0.02512563f, 0.00880129f, -0.07936570f, 
    -0.16443305f, -0.05914808f, 0.33575150f, 0.13891596f, -0.08752440f, -0.04768264f, -0.08092827f, -0.06630439f, 
    -0.04343074f, -0.07357705f, 0.04275403f, -0.11571126f, -0.24626498f, -0.10435922f, 0.02873805f, 0.23672214f, 
    -0.06815334f, -0.05489153f, -0.03420212f, 0.02239745f, 0.04896817f, -0.10611191f, 0.00190131f, -0.02092835f, 
    -0.30834651f, 0.53025573f, -0.03497056f, -0.00962751f, 0.03129739f, 0.11700711f, -0.05782136f, -0.04728718f, 
    -0.10993296f, 0.09222805f, -0.07918297f, 0.08960174f, 0.41341591f, -0.13849255f, 0.14035794f, -0.24596566f, 
    -0.49384528f, 0.19646896f, 0.02759431f, -0.05405721f, 0.08252459f, -0.00951995f, 0.09019061f, -0.11556769f, 
    -0.27853557f, 0.46098998f, 0.07799128f, -0.21123239f, 0.16481152f, 0.17162159f, -0.13247663f, 0.04312782f, 
    -0.38123643f, 0.05003588f, 0.03588787f, -0.02515703f, -0.47202963f, 0.49238521f, -0.23868285f, -0.48283044f, 
    0.09990638f, 0.10213415f, -0.01217931f, -0.16603373f, -0.00657080f, -0.03054798f, -0.09807792f, -0.10834999f, 
    0.08335999f, -0.10697817f, -0.05623704f, 0.02185034f, 0.22504744f, 0.07584854f, 0.11651675f, 0.00315144f, 
    -0.11161656f, 0.09056196f, -0.12586261f, 0.02011663f, 0.01895864f, -0.05222994f, -0.02204017f, 0.08372395f, 
    0.02235541f, 0.04605921f, -0.02088762f, -0.19119701f, 0.00454219f, -0.00820881f, -0.13678820f, 0.11264116f, 
    -0.35151401f, 0.11116908f, -0.13630761f, 0.02625990f, -0.10984658f, -0.11167679f, 0.00001696f, -0.01109990f, 
    -0.14552104f, 0.12560436f, -0.06130068f, -0.05320148f, -0.27697983f, 0.07679351f, -0.01606582f, 0.29145664f, 
    0.05905678f, -0.00761775f, -0.09497485f, 0.01815138f, -0.02136734f, 0.05904286f, 0.05663493f, -0.05040019f, 
    0.17634536f, -0.31642753f, 0.24888788f, 0.06651150f, 0.06848433f, 0.04828102f, 0.06345534f, 0.07876711f, 
    0.06350633f, -0.02703234f, 0.02866667f, 0.02265844f, 0.16282630f, 0.07987896f, 0.07395398f, 0.20037575f, 
    -0.08013918f, -0.12636320f, -0.14695765f, -0.07628943f, -0.01670244f, 0.07141131f, 0.00372882f, 0.01927324f, 
    0.05927437f, 0.33046743f, -0.13670419f, 0.20826010f, -0.01907738f, 0.14809947f, 0.05259378f, -0.15639548f, 
    0.00261596f, -0.01749511f, -0.02773549f, 0.03752330f, -0.06747930f, -0.30726334f, 0.07528148f, -0.01053036f, 
    -0.10210277f, -0.00699532f, -0.02597743f, -0.05406449f, -0.11621268f, -0.01363286f, -0.12330744f, -0.09398796f, 
    0.00594574f, -0.08293544f, -0.15323722f, -0.05096690f, -0.00812070f, -0.01568250f, -0.01779526f, 0.09366088f, 
    -0.24928044f, -0.00901196f, -0.12422568f, -0.01448537f, 0.20668285f, -0.01200005f, -0.04165500f, 0.19230992f, 
    -0.07506538f, -0.00476749f, 0.17712772f, -0.15414400f, 0.09952495f, -0.10145295f, 0.05105038f, -0.03125601f, 
    -0.26350322f, -0.15429012f, -0.08708184f, 0.22218058f, -0.06589103f, 0.15384710f, -0.07102332f, -0.11924825f, 
    0.07469045f, -0.07011103f, 0.14985818f, -0.07221878f, -0.10660340f, 0.08805978f, -0.04782162f, 0.00301880f, 
    0.07632117f, -0.02732488f, -0.02620921f, 0.14717495f, -0.16071391f, -0.25110778f, -0.24579668f, -0.10729780f, 
    -0.07527692f, -0.39792040f, 0.11490951f, 0.13727318f, -0.13997458f, -0.14342839f, -0.05888798f, -0.19923030f, 
    -0.10911336f, -0.06195473f, -0.02675157f, 0.04730692f, 0.05739181f, -0.09185524f, -0.13904826f, 0.01279754f, 
    0.16790073f, 0.06646900f, 0.00210455f, 0.05587611f, -0.04040276f, -0.06519563f, 0.17692192f, -0.04626390f, 
    -0.15688795f, 0.03248620f, -0.10906252f, 0.08440754f, -0.13540865f, 0.00661594f, -0.04367516f, 0.02048550f, 
    -0.03543130f, -0.03382207f, 0.04462257f, -0.14676934f, 0.03846929f, 0.01548785f, -0.14088447f, 0.10012832f, 
    0.00381190f, -0.04800566f, 0.06303996f, 0.07382877f, 0.02244234f, -0.17759860f, -0.14943159f, 0.00870863f, 
    -0.03962179f, 0.07250267f, 0.03326391f, 0.05878491f, -0.13205729f, -0.02839190f, 0.01773917f, -0.00557680f, 
    0.01504425f, 0.03480641f, -0.09616864f, 0.06021211f, 0.09951296f, 0.11158694f, -0.06135142f, 0.20852391f, 
    0.03634666f, 0.00908825f, -0.03722983f, -0.18103555f, -0.10710707f, -0.02767500f, -0.02089489f, -0.15176454f, 
    -0.22030415f, -0.40708369f, -0.11133052f, -0.07955779f, 0.09179992f, -0.01279033f, 0.08531081f, 0.02167626f, 
    0.02353821f, 0.01745134f, 0.04136133f, -0.03099228f, 0.13560574f, 0.18459685f, 0.08060557f, 0.19458245f, 
    -0.01301083f, -0.01180172f, -0.03175064f, -0.14630416f, 0.07823911f, 0.12306609f, 0.04374668f, 0.02296236f, 
    -0.14732149f, -0.05276078f, -0.00046220f, 0.13263480f, -0.01461021f, -0.11364223f, -0.04060627f, -0.17306843f, 
    -0.01998752f, -0.02117582f, -0.01774959f, 0.00833910f, -0.11103427f, 0.09398320f, -0.04297574f, 0.03450533f, 
    0.04892056f, -0.00574197f, -0.17442238f, -0.04898130f, -0.12057383f, 0.01282563f, -0.05973543f, -0.01330571f, 
    0.01863056f, 0.12310256f, -0.19324186f, 0.06782993f, 0.00615801f, -0.21444018f, -0.04566983f, -0.09738866f, 
    -0.00067158f, 0.02549500f, -0.14774595f, 0.10386953f, 0.13910380f, 0.33365095f, -0.22525203f, 0.15998605f, 
    0.04484050f, -0.03158498f, -0.11846250f, -0.02592245f, 0.06238267f, 0.07025711f, -0.01800640f, -0.03578335f, 
    0.19359563f, -0.11063883f, 0.30317736f, -0.03642416f, 0.00960060f, 0.00569225f, -0.05832640f, -0.11499457f, 
    0.16799770f, -0.02659792f, -0.06807238f, -0.10501199f, -0.13875975f, -0.00851932f, 0.00873291f, 0.08719142f, 
    -0.05245304f, -0.02374833f, -0.06086850f, -0.05464113f, -0.05556242f, -0.02341251f, -0.03804949f, 0.00628262f, 
    0.03002873f, 0.03082507f, 0.05730987f, 0.08950347f, -0.08182009f, -0.02194695f, -0.12302988f, -0.05818440f, 
    0.01529995f, 0.00522993f, 0.07415462f, -0.01718352f, 0.02180817f, 0.01200026f, -0.03800100f, 0.00516671f, 
    0.02793261f, -0.03657722f, 0.05492690f, -0.03936358f, 0.02514245f, -0.00436322f, 0.13235597f, 0.21755658f, 
    0.20198667f, -0.06378641f, 0.07618041f, -0.21199031f, 0.02031763f, 0.00540969f, -0.04890956f, 0.01108506f, 
    -0.02832901f, -0.02608878f, -0.18439297f, -0.10468572f, 0.03666215f, 0.11606760f, 0.03906933f, 0.10585256f, 
    -0.04373662f, -0.01434813f, 0.02543204f, -0.05641859f, 0.23339881f, -0.05143291f, -0.00693239f, -0.04792692f, 
    -0.03186046f, 0.13622548f, 0.12052676f, 0.09179795f, 0.00255157f, -0.06948861f, 0.03017640f, -0.07065678f, 
    0.05372262f, -0.00706115f, -0.04948753f, 0.11357137f, 0.02632459f, 0.07479216f, -0.06753374f, -0.02412653f, 
    -0.23719624f, -0.01978081f, -0.08927298f, 0.27824777f, 0.01321709f, 0.07191879f, -0.00648112f, -0.12235741f, 
    -0.05249389f, -0.11572681f, -0.15229285f, -0.00222080f, -0.01211511f, -0.12274484f, 0.02625648f, -0.25565329f, 
    0.00286689f, -0.14209841f, 0.01218380f, -0.23750804f, 0.05850697f, 0.01003366f, 0.23692767f, 0.00541906f, 
    -0.05715429f, 0.00569800f, 0.08889010f, 0.24931504f, -0.03375537f, -0.05781797f, -0.08929583f, -0.07805820f, 
    -0.07995085f, -0.21915479f, 0.04180466f, -0.08993427f, -0.01394283f, -0.04951419f, 0.04912925f, 0.03708953f, 
    0.00511381f, -0.25881246f, -0.24323532f, -0.09605032f, 0.04847151f, 0.11154193f, 0.20741206f, 0.12877958f, 
    -0.07316386f, -0.09908502f, 0.05970557f, 0.09886118f, 0.01457655f, -0.01496471f, 0.01460291f, 0.04668896f, 
    0.05721544f, 0.01806824f, 0.12190714f, 0.06085503f, -0.11396560f, -0.07869717f, -0.01421024f, -0.01274885f, 
    -0.02607569f, 0.00577377f, -0.15442725f, 0.04477267f, 0.10190832f, 0.09410679f, 0.16095950f, 0.19439983f, 
    -0.08751789f, 0.00668745f, 0.10386848f, 0.08523490f, 0.09076531f, -0.01803253f, 0.02866815f, 0.00926953f, 
    -0.05362575f, -0.35109535f, 0.07550313f, -0.07287376f, -0.18145169f, -0.14699440f, -0.02062985f, 0.04614550f, 
    0.02248640f, -0.01579737f, 0.02852689f, 0.21085007f, 0.09020399f, 0.14313340f, 0.20220467f, 0.04368697f, 
    -0.03910308f, -0.12334338f, -0.01194422f, 0.07373762f, -0.05840673f, 0.03786475f, 0.01538350f, 0.03899944f, 
    -0.12005491f, -0.00567037f, 0.03628772f, -0.03038971f, -0.09757311f, 0.00670189f, -0.03617603f, -0.14655930f, 
    -0.01982847f, -0.07007324f, -0.00422248f, -0.04835898f, -0.23765472f, 0.02644673f, 0.08549949f, -0.04162234f, 
    0.02604965f, -0.04779017f, 0.01050517f, -0.01380970f, -0.01485778f, 0.09626627f, 0.09094154f, 0.03290430f, 
    0.13532689f, 0.08228854f, -0.09078879f, 0.09188777f, -0.09019796f, -0.02853683f, -0.01257135f, -0.15874359f, 
    -0.10946869f, 0.03327740f, -0.00637979f, 0.01009288f, 0.03269867f, -0.02949115f, 0.07703586f, -0.04297929f, 
    0.05128803f, 0.05791518f, 0.03234778f, 0.02041966f, 0.08076476f, -0.07513018f, -0.05073739f, -0.08860827f, 
    0.01743095f, 0.00793775f, 0.06947959f, 0.21186306f, 0.19769987f, 0.07892875f, -0.08455195f, -0.11130226f, 
    0.07460088f, 0.26439205f, 0.01130516f, 0.10330746f, -0.03750781f, 0.02478185f, -0.04108962f, -0.03159568f, 
    -0.12466701f, 0.00529326f, -0.18964195f, -0.08246046f, 0.01261858f, 0.05079314f, -0.08834627f, -0.02556394f, 
    0.09040865f, -0.35172567f, 0.29019091f, 0.11958830f, -0.11116134f, 0.10082646f, -0.20304851f, 0.00116749f, 
    -0.06831249f, 0.03236194f, -0.07302066f, -0.04020415f, 0.09777211f, 0.05214021f, 0.01170699f, 0.00722629f, 
    0.12154432f, 0.10421940f, 0.02591003f, 0.06210095f, 0.06837244f, -0.06980671f, -0.08939187f, -0.05677950f, 
    0.11849672f, 0.04646931f, 0.16040249f, -0.18134916f, 0.01627364f, 0.08182153f, -0.09532327f, 0.08818700f, 
    -0.16339228f, 0.05218507f, -0.06820510f, 0.04412127f, 0.04167407f, 0.02645168f, -0.03420817f, 0.12728301f, 
    0.00936011f, -0.10934775f, 0.09595884f, -0.09488129f, 0.25744119f, 0.11269715f, 0.21554706f, 0.37060300f, 
    -0.01693266f, 0.13962507f, 0.22463810f, 0.16855219f, -0.07313978f, -0.11214945f, 0.14170466f, -0.01466275f, 
    0.03916356f, -0.04205831f, 0.07778154f, -0.08709583f, -0.31451517f, -0.53614020f, 0.01235871f, -0.08214653f, 
    -0.00589065f, 0.09342521f, -0.01735350f, 0.02987496f, -0.03972205f, 0.00558760f, 0.10258715f, 0.06574787f, 
    -0.21492061f, 0.02059179f, 0.03104495f, 0.22946601f, 0.01727348f, -0.06772722f, -0.08218212f, -0.28993225f, 
    -0.10074482f, -0.10817379f, 0.05517828f, 0.05299634f, 0.25241289f, 0.02240763f, -0.02098379f, 0.02452647f, 
    0.05425281f, 0.03858310f, 0.05013433f, -0.01631820f, 0.13196781f, 0.09886833f, 0.08589781f, 0.10426691f, 
    0.21048775f, -0.42060745f, -0.00647670f, 0.11878259f, 0.01289770f, 0.00226003f, 0.07363766f, -0.09670780f, 
    0.00360111f, -0.01393035f, -0.04340824f, -0.03372854f, -0.00923222f, 0.12873338f, 0.03170065f, 0.02004882f, 
    -0.17400889f, -0.07059238f, -0.00697732f, -0.21826364f, -0.16259976f, -0.01779471f, 0.06413399f, -0.08347554f, 
    -0.09994405f, -0.05888572f, 0.00017400f, 0.13103397f, -0.05158862f, -0.02376593f, -0.11094742f, 0.00850091f, 
    -0.11411658f, -0.07191923f, -0.06919254f, 0.03304403f, -0.05184166f, -0.50654727f, 0.25675449f, 0.10857204f, 
    -0.14576149f, 0.09815805f, -0.21823762f, -0.05883947f, -0.08781561f, 0.05431193f, -0.02800086f, -0.03459382f, 
    -0.00714402f, 0.15921794f, -0.01608883f, 0.04930873f, 0.12966460f, 0.00001808f, -0.00489711f, 0.14305155f, 
    -0.11435039f, -0.03532213f, -0.05231564f, -0.11079687f, 0.04193754f, 0.15017064f, 0.13266404f, 0.03671681f, 
    0.03953744f, -0.01696951f, 0.02274196f, 0.04226807f, -0.00292739f, -0.04320025f, 0.01887470f, -0.07813253f, 
    0.02282616f, -0.21115436f, 0.02127539f, -0.36366427f, 0.07868530f, -0.16526826f, 0.05613953f, 0.05827435f, 
    0.13653016f, 0.10640426f, -0.03292265f, -0.10448705f, 0.12853926f, -0.14227355f, -0.16804315f, 0.22433501f, 
    -0.05792812f, 0.04028792f, -0.10968982f, -0.02311569f, 0.12410750f, -0.04761034f, -0.07352527f, 0.04577567f, 
    0.10760479f, -0.30947191f, -0.26264122f, -0.02812178f, -0.25445136f, -0.08854581f, 0.16522315f, -0.09383264f, 
    -0.08796936f, 0.01788161f, -0.00353876f, -0.13225800f, -0.05203165f, -0.15041037f, 0.10534343f, 0.18232384f, 
    -0.10612326f, -0.11190789f, -0.00316072f, -0.12112621f, -0.18463625f, 0.08420332f, -0.05389120f, 0.08715189f, 
    0.34635422f, 0.26010600f, 0.03260025f, 0.10301498f, 0.01515756f, -0.00013429f, 0.01809006f, 0.00290983f, 
    0.12624770f, -0.22917652f, -0.02951572f, -0.01451025f, 0.02874561f, 0.07338222f, 0.10177168f, 0.20228688f, 
    -0.01209036f, 0.00551806f, -0.07276395f, 0.12166221f, 0.07838705f, -0.11541844f, -0.01863826f, -0.10020570f, 
    0.06413706f, 0.00270735f, 0.13002890f, 0.02269234f, -0.11160116f, 0.04792650f, 0.02793109f, -0.19978125f, 
    0.09229740f, 0.05940999f, -0.08899656f, -0.04270169f, 0.14905842f, 0.03643839f, -0.15754834f, -0.21736306f, 
    0.01216385f, 0.00977778f, -0.24801087f, -0.11788306f, -0.13831830f, -0.17497952f, -0.17529696f, -0.25991008f, 
    0.13902971f, -0.02543206f, 0.07993519f, -0.06283443f, -0.09065237f, -0.11686543f, 0.08720192f, -0.04042612f, 
    0.00024198f, 0.01504074f, -0.01616290f, -0.00378109f, -0.02090761f, 0.14125802f, 0.03095901f, -0.30117655f, 
    0.11002152f, 0.00247495f, -0.01943720f, 0.13005817f, -0.04228553f, 0.04254114f, 0.00826304f, -0.01262893f, 
    0.11532760f, -0.05888533f, -0.06680325f, 0.28005546f, 0.14259478f, -0.13185933f, -0.01345617f, 0.17578141f, 
    0.00460468f, 0.03754320f, -0.01227255f, -0.05513759f, 0.16605760f, -0.30870476f, 0.18423170f, 0.16470818f, 
    -0.12723023f, 0.02273346f, 0.00871960f, -0.11356940f, 0.03230375f, -0.06251068f, 0.26921701f, 0.00839860f, 
    -0.04356222f, -0.38716164f, 0.13143539f, 0.17832431f, -0.06344613f, -0.10395557f, 0.03927122f, 0.08891553f, 
    0.13650049f, -0.06709928f, 0.09705234f, 0.05541436f, -0.47584569f, 0.04777244f, -0.48724946f, 0.06248157f, 
    0.04370178f, 0.13857619f, -0.07260320f, 0.02116880f, -0.01709910f, -0.05562549f, 0.02507816f, -0.01437485f, 
    0.08986714f, -0.18965207f, -0.05961976f, 0.17985880f, 0.06070634f, -0.04821135f, 0.04772773f, -0.05293756f, 
    -0.09743836f, 0.03846509f, 0.08366479f, 0.04130018f, 0.00153000f, -0.07400806f, -0.31116751f, 0.08293407f, 
    -0.00756035f, -0.10305326f, 0.03012473f, 0.00361711f, 0.16027705f, 0.25234354f, -0.03192985f, 0.27338883f, 
    0.17569636f, -0.11834465f, 0.05559412f, 0.08567477f, 0.14558855f, -0.10562257f, -0.05186437f, 0.06196790f, 
    0.18074398f, 0.19311579f, -0.10380815f, -0.17427839f, -0.16519018f, 0.12758513f, 0.02025567f, -0.16960256f, 
    0.04719492f, 0.09403118f, -0.09690710f, 0.00031161f, 0.19218525f, -0.16243674f, -0.02918398f, 0.14215562f, 
    0.04749069f, 0.09023350f, 0.09411637f, -0.03764885f, 0.07690433f, 0.05259558f, -0.06124166f, 0.06583932f, 
    -0.01778634f, -0.01747969f, -0.04427848f, 0.18331909f, -0.02124399f, -0.09595470f, -0.06872331f, 0.10145213f, 
    -0.25724012f, 0.10699275f, -0.05792861f, -0.06828389f, 0.05006150f, 0.11280172f, 0.07494480f, 0.13939036f, 
    -0.26060423f, -0.27910024f, -0.08046054f, -0.10768059f, -0.01285797f, -0.01330238f, -0.02422289f, 0.12008777f, 
    -0.02411498f, -0.00799093f, 0.06049354f, -0.06144550f, 0.00036282f, 0.15314287f, -0.05907958f, -0.27612379f, 
    -0.17247491f, 0.04241418f, -0.00183273f, 0.07888180f, 0.13094370f, -0.07137038f, -0.05375818f, -0.04224259f, 
    0.14432465f, -0.18243523f, -0.12227798f, 0.20562194f, 0.02593424f, 0.01527700f, -0.04638424f, 0.04736688f, 
    0.07817668f, 0.00148331f, 0.00057916f, 0.04689327f, -0.13199829f, 0.08718994f, 0.09106242f, -0.18541026f, 
    -0.12815554f, 0.10460611f, -0.10105871f, 0.00978183f, 0.09881160f, -0.10606305f, 0.12251335f, -0.10749510f, 
    -0.08499300f, 0.07875448f, -0.13203990f, -0.13858899f, -0.08986945f, 0.05424468f, 0.10572456f, -0.03567591f, 
    0.05658989f, -0.03050223f, 0.06785398f, -0.01884915f, 0.10529156f, 0.19463673f, -0.05203117f, -0.01950101f, 
    -0.06297079f, 0.09600054f, 0.11591975f, -0.28278968f, 0.15105654f, -0.03506039f, -0.09406449f, 0.16946632f, 
    -0.09844581f, 0.07487044f, -0.08213332f, 0.02415542f, 0.07641809f, 0.11972256f, -0.04469249f, 0.10719541f, 
    -0.01105798f, -0.08344573f, 0.04063470f, -0.43987805f, 0.04638748f, 0.08778713f, -0.42882907f, 0.09654526f, 
    0.06289701f, 0.16805075f, -0.20089875f, 0.16497228f, -0.01300310f, -0.14519727f, 0.09258079f, -0.06386156f, 
    0.01006881f, 0.03485536f, -0.03568913f, -0.09600158f, -0.10728191f, -0.00331217f, 0.09121846f, 0.17700467f, 
    -0.13468097f, -0.24838470f, -0.08906645f, -0.09268296f, 0.07802037f, -0.14322828f, -0.22297899f, -0.15721832f, 
    0.10986762f, 0.01373076f, -0.14625628f, 0.12913030f, 0.01348235f, -0.04530808f, -0.01999360f, -0.00210671f, 
    -0.03076513f, 0.13916789f, 0.03616668f, 0.02190294f, 0.17301148f, 0.04859727f, 0.06349148f, 0.06073803f, 
    0.05751349f, 0.05766437f, 0.06773069f, 0.09753338f, -0.00246151f, -0.09461095f, -0.08811434f, -0.01970800f, 
    0.06732318f, 0.01537487f, 0.00926073f, 0.03541146f, -0.11678125f, 0.02620647f, -0.27514181f, -0.66839957f, 
    -0.13167892f, -0.09490400f, -0.01442122f, 0.28447655f, -0.22948429f, 0.13725388f, -0.11538751f, -0.01608485f, 
    0.00166546f, -0.06240974f, 0.14995052f, -0.13490944f, 0.06471544f, 0.02338257f, -0.00855948f, -0.09892309f, 
    0.01942849f, -0.05517383f, 0.07915506f, 0.01973639f, -0.14433251f, 0.09674861f, 0.06693133f, -0.08171336f, 
    -0.10869323f, -0.04509683f, -0.22527729f, -0.13225077f, -0.01621626f, -0.00781634f, -0.03059372f, 0.17258878f, 
    0.04835674f, -0.11566535f, 0.08192245f, -0.14313194f, 0.24440411f, -0.13718653f, 0.04394815f, 0.34379211f, 
    0.06120038f, -0.06430512f, -0.08432411f, -0.14042823f, -0.05000067f, 0.00641685f, -0.11382400f, -0.00326385f, 
    -0.28265363f, 0.06570901f, 0.01719997f, 0.02096398f, 0.26475403f, 0.08526589f, 0.11112741f, 0.05926850f, 
    0.08778712f, 0.03456452f, 0.02164551f, 0.33117187f, 0.03155179f, -0.06696058f, -0.06602487f, -0.13046835f, 
    -0.01447217f, 0.26681608f, -0.01629851f, 0.03269555f, 0.04228283f, -0.01474162f, 0.03308186f, 0.02218608f, 
    0.12067146f, -0.26070586f, -0.13190274f, 0.09227338f, -0.05507192f, 0.01161042f, -0.08834700f, 0.02545538f, 
    0.08448467f, -0.05390580f, 0.16632259f, -0.01491800f, -0.00096905f, 0.22167622f, 0.04112086f, -0.12335039f, 
    0.25450608f, 0.02760700f, 0.14503737f, -0.23445670f, 0.01567165f, 0.02294744f, 0.03070025f, -0.01347606f, 
    0.01137675f, 0.15931083f, 0.06229721f, -0.20745692f, 0.01121527f, -0.03605632f, -0.04628718f, -0.10774450f, 
    0.07402873f, -0.09042820f, -0.14047982f, -0.07746317f, 0.14919715f, 0.08007438f, 0.07864842f, -0.01995465f, 
    0.25366533f, 0.13564740f, 0.10043179f, 0.00441690f, 0.00302971f, -0.03250235f, 0.02779956f, -0.02183330f, 
    0.01333065f, -0.04987184f, -0.19331354f, -0.26606771f, -0.01410376f, 0.06309842f, -0.06458294f, -0.17998074f, 
    -0.08422893f, 0.06102081f, -0.27071550f, -0.22548175f, 0.17976895f, 0.12744167f, 0.12041830f, 0.04253395f, 
    0.04724393f, -0.08360302f, -0.11495616f, -0.21061836f, 0.03441855f, -0.10392242f, -0.00841132f, 0.06973269f, 
    0.33373943f, 0.07239602f, 0.14824490f, 0.20593677f, -0.03989619f, 0.00889662f, 0.10485093f, 0.12535635f, 
    0.03724742f, 0.02173935f, 0.01079518f, 0.06214228f, -0.06193172f, 0.37307373f, -0.36140299f, -0.26332551f, 
    -0.06519654f, 0.09484211f, -0.05363470f, 0.11655721f, -0.00670418f, -0.06946509f, -0.04227775f, -0.10492399f, 
    -0.20642941f, 0.14122687f, 0.09182750f, -0.27975368f, -0.03434998f, -0.03796965f, -0.01203952f, 0.36476043f, 
    -0.11360051f, -0.10509264f, -0.00969500f, 0.03630099f, 0.08197720f, -0.16350870f, -0.08246610f, 0.13739662f, 
    -0.12402055f, 0.09745125f, -0.02195346f, -0.12175222f, 0.11357296f, 0.03611496f, 0.04580857f, 0.04915202f, 
    0.05444232f, 0.03366899f, -0.01033802f, 0.02402571f, -0.15967464f, -0.01682545f, -0.05335589f, -0.18019006f, 
    -0.24433003f, -0.18653859f, -0.03716189f, -0.27843779f, 0.06327575f, -0.00944513f, 0.03645692f, 0.00265008f, 
    0.15097328f, -0.04457453f, 0.23390265f, 0.07901766f, -0.06940267f, 0.15039921f, 0.03383865f, 0.05213155f, 
    0.16853684f, 0.00100667f, 0.19404660f, 0.01172010f, -0.10761833f, -0.12376455f, 0.04400702f, -0.09960748f, 
    0.04662166f, -0.02489669f, 0.03805343f, -0.02155553f, -0.06891982f, -0.07225474f, -0.05073753f, 0.05600606f, 
    0.00300326f, -0.04064486f, -0.08308371f, 0.01670201f, 0.11590439f, -0.08481881f, 0.10350406f, 0.20815350f, 
    0.11269421f, 0.13660930f, -0.16704458f, 0.10063560f, -0.03954173f, -0.14657050f, -0.28782740f, 0.04392838f, 
    0.01472965f, 0.19134007f, -0.04039603f, 0.01900293f, -0.33990151f, 0.08320456f, -0.04542725f, -0.04993511f, 
    0.02564348f, 0.06091154f, 0.01034797f, 0.03101083f, 0.10137636f, -0.30636504f, -0.26590329f, -0.41149935f, 
    0.23312430f, 0.01530062f, 0.24855895f, -0.18120693f, 0.16608143f, -0.00693731f, -0.17499620f, -0.12708166f, 
    0.05216997f, -0.02218988f, 0.07475467f, -0.02517210f, 0.22078040f, -0.04859897f, 0.04452725f, -0.19894336f, 
    -0.15606475f, 0.13051189f, -0.12575090f, -0.04014132f, -0.06130380f, -0.27062488f, -0.11678369f, -0.07833394f, 
    0.33729649f, -0.10746793f, 0.28928691f, 0.10216223f, -0.03355793f, 0.01501204f, 0.00219591f, 0.06520975f, 
    0.05163027f, 0.05025880f, 0.07305188f, -0.00997276f, -0.07982194f, -0.08948402f, -0.24796893f, 0.00369877f, 
    0.01871453f, 0.05071849f, 0.00592371f, 0.04070112f, -0.04178903f, -0.09369511f, -0.02062671f, -0.12216666f, 
    -0.26320404f, 0.26699227f, 0.00632152f, -0.13670117f, 0.03724193f, -0.01860704f, 0.05661756f, 0.08059403f, 
    0.14548574f, -0.24726281f, 0.01583827f, -0.05739469f, -0.08828647f, 0.25160214f, -0.12052322f, -0.32197759f, 
    0.12351838f, -0.07974482f, 0.14904726f, 0.11066533f, 0.26314220f, -0.14906752f, 0.03699429f, 0.05922137f, 
    -0.26310134f, 0.15932287f, -0.18611804f, -0.11572085f, -0.02897185f, 0.03010863f, 0.01547211f, 0.14310016f, 
    0.01881157f, -0.09873600f, 0.03924320f, -0.04850401f, -0.25697896f, 0.01515085f, 0.12920620f, 0.10416938f, 
    -0.13658510f, -0.26003054f, 0.14973657f, 0.03632680f, 0.01152714f, -0.05949303f, -0.01307651f, 0.03451710f, 
    0.06596564f, 0.08521234f, -0.25711593f, -0.14685234f, 0.02506645f, 0.10608351f, -0.02021237f, 0.01535551f, 
    0.03719417f, -0.06935772f, 0.17533465f, 0.14390595f, 0.00575180f, 0.00069607f, -0.20855236f, 0.03474357f, 
    -0.01337356f, 0.01156310f, 0.05171817f, 0.07990345f, -0.15865539f, 0.03716772f, 0.10283387f, 0.09016889f, 
    0.17753550f, -0.00152500f, -0.21100889f, -0.20017633f, 0.13825639f, 0.02804248f, 0.15033923f, -0.15583977f, 
    -0.02553181f, 0.02656314f, 0.05914007f, -0.22284438f, -0.13473783f, -0.12367509f, 0.02356673f, 0.30850315f, 
    0.22342801f, -0.23511153f, -0.19133319f, -0.03666851f, -0.04962748f, 0.07953770f, 0.00106745f, 0.03294012f, 
    -0.59780651f, -0.22934428f, -0.27195954f, 0.02955929f, 0.10947449f, -0.10872106f, -0.09683593f, 0.00834165f, 
    0.22985017f, 0.11585593f, -0.19981033f, 0.01793351f, -0.26753953f, 0.07402444f, -0.03255697f, -0.04846475f, 
    0.09320141f, -0.04671893f, 0.04125248f, 0.09455682f, 0.01362109f, 0.04197638f, -0.16504885f, -0.00548982f, 
    -0.68150902f, -0.35392937f, 0.06090203f, -0.17789268f, -0.06151301f, -0.01400231f, -0.00533274f, 0.00819030f, 
    0.20193148f, 0.01552966f, 0.12147204f, 0.00354849f, 0.19940832f, 0.01195050f, -0.11028533f, -0.09952395f, 
    -0.05057344f, 0.05109842f, 0.07521739f, 0.21182692f, -0.00090623f, 0.04440035f, 0.05509206f, -0.03971430f, 
    0.06330483f, -0.05914054f, -0.18454635f, 0.03692562f, 0.22763699f, -0.04317329f, -0.05574199f, 0.17980757f, 
    -0.01074584f, 0.00510000f, 0.21006438f, -0.07375490f, -0.07425473f, 0.02105879f, -0.45142078f, 0.00996976f, 
    0.22838557f, 0.01884804f, -0.04188201f, 0.04377263f, 0.07870642f, 0.11094216f, 0.12074539f, 0.22082804f, 
    -0.52323753f, -0.34368357f, -0.00398172f, 0.37891746f, 0.16041511f, 0.16218470f, -0.16504493f, -0.02552298f, 
    -0.02736464f, -0.01331702f, 0.04863939f, 0.06032563f, -0.46713838f, -0.14175598f, -0.17970648f, -0.11453086f, 
    -0.26714182f, -0.01852811f, 0.03290508f, -0.19883803f, -0.03270032f, 0.04442520f, -0.04646202f, 0.01327686f, 
    0.02544465f, -0.46311837f, -0.22088727f, -0.10653961f, -0.05510505f, 0.10208776f, 0.21427120f, -0.29149437f, 
    -0.00889159f, -0.03098988f, 0.09861612f, 0.02899628f, -0.23125283f, -0.02607675f, -0.01625308f, 0.06583227f, 
    0.02081938f, 0.05429318f, 0.07804169f, -0.11771180f, -0.12818982f, 0.05855883f, -0.03536679f, 0.10361622f, 
    -0.00183839f, 0.01375252f, 0.06072026f, 0.10194643f, 0.02928445f, 0.00366067f, 0.07079410f, 0.07987966f, 
    0.14761320f, 0.00431722f, -0.05382349f, 0.04902570f, 0.18423325f, -0.30822155f, -0.29311323f, -0.24914742f, 
    0.03929944f, 0.11466338f, 0.09667325f, 0.02289763f, -0.07336196f, -0.04735650f, -0.03915001f, 0.04973153f, 
    0.23858753f, -0.11171339f, -0.20365903f, -0.53026152f, 0.00711175f, 0.10136196f, 0.00328663f, 0.05278601f, 
    -0.01050549f, -0.03493437f, 0.09967897f, -0.28883210f, 0.25507087f, -0.06658901f, 0.14060248f, 0.44043544f, 
    0.07859550f, -0.16056366f, 0.07206164f, 0.09132998f, 0.02952506f, 0.07367265f, 0.20099717f, -0.16629086f, 
    -0.13305710f, -0.05822517f, -0.05967041f, 0.11198448f, 0.02672914f, 0.06478388f, -0.06611590f, 0.04523619f, 
    -0.06730444f, 0.08479100f, 0.04186646f, 0.05069282f, -0.05980579f, -0.10638523f, -0.07328164f, -0.17500500f, 
    -0.07124285f, -0.04285174f, 0.04918901f, 0.03297341f, 0.01584946f, 0.08925490f, 0.03195003f, -0.12686902f, 
    0.22906753f, -0.06280761f, -0.40063667f, -0.03226355f, -0.15837994f, -0.02670150f, 0.01442964f, 0.15209411f, 
    -0.02544347f, 0.01794360f, -0.02281301f, -0.07914192f, -0.03100971f, -0.05800558f, -0.23003271f, 0.28499129f, 
    -0.24423018f, -0.06954359f, -0.08346152f, 0.15393741f, 0.05875060f, 0.00519914f, 0.01515476f, -0.18480405f, 
    -0.29788908f, 0.12849875f, 0.25131276f, 0.17433739f, -0.07210823f, 0.02367069f, 0.01966562f, -0.02496341f, 
    0.04017200f, 0.09246224f, 0.03865454f, 0.06702372f, -0.06800614f, 0.00352657f, 0.28247014f, 0.22694418f, 
    0.10174956f, -0.13254659f, 0.14823836f, 0.15460572f, 0.00546106f, 0.21776164f, -0.08844475f, 0.02939720f, 
    0.09380623f, 0.14128146f, 0.02635989f, -0.21140730f, 0.05399017f, -0.01410430f, 0.05694529f, -0.02182821f, 
    0.00467333f, -0.00818101f, -0.09667106f, 0.11592785f, -0.68334210f, -0.38860315f, 0.34077805f, -0.03098147f, 
    -0.02184588f, -0.02266883f, -0.15363459f, -0.21600683f, -0.10361586f, -0.03345222f, -0.05009355f, 0.00336949f, 
    -0.36684620f, -0.68691987f, -0.08242989f, -0.08993616f, -0.00271765f, -0.12967552f, -0.11137901f, -0.17971900f, 
    -0.02451085f, -0.02599308f, 0.04686588f, -0.05136538f, -0.07041260f, -0.15730888f, 0.04388038f, 0.26914966f, 
    0.16235830f, -0.10413241f, 0.08961538f, -0.07028473f, -0.01495674f, -0.01758715f, 0.04087864f, 0.04863334f, 
    0.08001139f, -0.11400867f, -0.03078917f, 0.01598810f, -0.00175195f, 0.08119660f, 0.11018108f, 0.04762815f, 
    0.06336226f, 0.13136744f, 0.08074660f, 0.11517850f, 0.28773522f, -0.06939419f, 0.15289335f, -0.43627617f, 
    -0.02661405f, 0.08908056f, 0.17641476f, -0.11093485f, 0.04329199f, 0.04864695f, -0.04461016f, 0.04234946f, 
    0.03953119f, 0.25161889f, -0.07671086f, -0.00227715f, -0.04128623f, -0.15287891f, -0.11344940f, 0.03874701f, 
    0.07249471f, -0.03589784f, -0.19912748f, -0.02640564f, -0.34379730f, -0.08340335f, -0.09113669f, 0.31420586f, 
    -0.03500473f, -0.08515948f, 0.08324105f, 0.02364761f, 0.01104966f, -0.02466127f, 0.07279047f, 0.06197458f, 
    -0.46246672f, -0.47179753f, -0.32216176f, -0.27508250f, -0.12100272f, -0.44360885f, -0.28468117f, -0.19748504f, 
    -0.04305629f, -0.00509845f, -0.02444503f, -0.01620573f, -0.00260171f, -0.01374140f, -0.00863608f, -0.02585927f, 
    0.00157426f, 0.00610197f, 0.09154196f, 0.03215285f, 0.04931645f, 0.01056957f, 0.02535759f, 0.01546755f, 
    -0.25840214f, 0.02028867f, 0.19776450f, -0.04542048f, -0.01916070f, 0.04793835f, 0.06285432f, -0.17497928f, 
    -0.00422235f, -0.00764114f, -0.02985505f, 0.16888438f, 0.14961764f, 0.07804459f, 0.03986032f, -0.09857128f, 
    -0.06032512f, -0.01078399f, -0.00480064f, -0.02748110f, 0.02093811f, 0.03711612f, 0.06809012f, -0.00793037f, 
    -0.14368531f, 0.10968441f, 0.18514845f, 0.03617286f, -0.10970318f, 0.09923229f, -0.23224451f, 0.10625581f, 
    0.00578504f, 0.01342001f, 0.00946115f, -0.00962380f, 0.27845520f, 0.15966125f, -0.30734140f, -0.01071477f, 
    0.15269235f, 0.03383222f, 0.05982606f, -0.13748886f, -0.01816993f, 0.02776613f, 0.08445184f, 0.08639406f, 
    0.01824958f, -0.06131952f, 0.27512050f, 0.12810034f, 0.15194485f, -0.03058424f, 0.04334782f, 0.00672066f, 
    -0.02357775f, -0.03741162f, -0.05387438f, -0.00207772f, -0.06233032f, -0.12265415f, -0.18751277f, -0.04802780f, 
    -0.16813236f, -0.13748999f, 0.09808438f, 0.06673393f, -0.04164012f, -0.00620926f, -0.13172993f, -0.07363673f, 
    0.04278485f, 0.08611609f, 0.04070144f, 0.08308107f, -0.01245817f, 0.00743576f, -0.04405400f, 0.09408204f, 
    0.00260678f, 0.01146940f, 0.10616484f, -0.02029844f, -0.28008795f, -0.63307071f, -0.21136551f, -0.05321452f, 
    -0.19464844f, -0.03102664f, -0.24984778f, -0.41073400f, -0.03015705f, 0.00157258f, -0.00391754f, -0.02292647f, 
    -0.45400551f, 0.12051466f, 0.43458590f, -0.26025712f, -0.17145054f, -0.04988072f, -0.01939789f, 0.06453530f, 
    0.00097128f, 0.08859801f, 0.08494962f, -0.04294888f, -0.60790724f, -0.46242040f, -0.35100433f, -0.32487929f, 
    -0.05230166f, -0.15671420f, -0.03040390f, -0.34479737f, -0.02041638f, -0.01592599f, -0.02457099f, 0.01298955f, 
    -0.17674433f, 0.28867289f, 0.05867893f, -0.03285866f, 0.01140048f, 0.06530980f, -0.02042590f, -0.06975485f, 
    0.23987055f, 0.08598505f, 0.04951480f, 0.10083718f, -0.35888621f, -0.55969739f, -0.14243796f, 0.24957059f, 
    -0.05014139f, -0.11310690f, -0.11663576f, -0.26110041f, -0.06018486f, 0.01477094f, -0.06986047f, 0.02771256f, 
    -0.43267593f, -0.46565050f, -0.05069320f, 0.04707773f, 0.11175324f, -0.01494995f, 0.04598819f, -0.18092811f, 
    -0.04266106f, -0.03005528f, 0.10545026f, 0.01700681f, -0.68796706f, -0.44064590f, 0.22210914f, -0.18100592f, 
    0.05918314f, -0.03853398f, -0.02499165f, -0.03093423f, 0.04041693f, 0.08371289f, 0.03034048f, 0.23292178f, 
    -0.02148534f, 0.02107286f, 0.16103111f, -0.05642768f, -0.03548036f, -0.20774665f, 0.13389324f, 0.17019019f, 
    0.00724174f, 0.08710149f, -0.03644408f, -0.07415882f, -0.01240221f, -0.00505931f, -0.07255448f, -0.02390898f, 
    0.09721211f, -0.09240291f, 0.16069037f, 0.03537518f, 0.03498462f, -0.09042215f, -0.03040722f, -0.10282966f, 
    0.00519012f, -0.17124532f, -0.16722198f, -0.01612931f, -0.09885865f, 0.02454216f, 0.16464677f, 0.00152278f, 
    0.22325678f, -0.01789650f, 0.05702313f, 0.12905632f, -0.09482515f, -0.09235072f, 0.03020278f, 0.02699582f, 
    -0.02757818f, -0.03960450f, 0.09446423f, -0.15996765f, -0.01361696f, -0.02500749f, -0.04123449f, -0.01700820f, 
    -0.22581252f, -0.77931219f, -0.20119968f, 0.40006381f, -0.03716720f, 0.06593586f, -0.12929310f, -0.08193739f, 
    -0.02195922f, 0.03568875f, -0.01126433f, 0.03971817f, -0.01189488f, -0.07079460f, -0.01775131f, -0.03899622f, 
    0.00653423f, -0.05095376f, -0.03157590f, 0.05258127f, -0.25744143f, -0.06653500f, -0.29326934f, -0.07481573f, 
    -0.31643358f, 0.10131394f, -0.18585783f, -0.31689855f, -0.03549389f, -0.02469655f, 0.03873616f, 0.04762144f, 
    -0.03118600f, 0.02840198f, -0.03190968f, 0.07950824f, -0.18946074f, -0.03760614f, 0.11041309f, -0.17332962f, 
    -0.00801901f, 0.00639961f, 0.00996981f, 0.02619937f, 0.14991662f, 0.20734137f, 0.17537266f, 0.21372783f, 
    -0.59753019f, -0.65920246f, -0.48721668f, -0.27260789f, -0.05409590f, 0.13889296f, -0.18271628f, -0.27824867f, 
    -0.02721253f, -0.04130668f, -0.02309277f, 0.00793415f, -0.05564114f, -0.06233905f, -0.02875208f, 0.13535030f, 
    0.04313733f, 0.13013041f, -0.04038046f, 0.29207775f, 0.02165192f, 0.16462585f, 0.10045513f, -0.05010875f, 
    -0.10433315f, -0.40210614f, -0.40886334f, -0.04952491f, -0.02752869f, 0.07430946f, 0.06527086f, 0.11492281f, 
    0.02554866f, 0.06811734f, 0.07396602f, -0.04898718f, 0.03746523f, -0.06631372f, -0.09084179f, -0.11145207f, 
    0.04448757f, -0.03958746f, 0.04451457f, 0.03501965f, -0.06559973f, 0.02911286f, -0.03594783f, -0.05018398f, 
    0.11581356f, -0.02674068f, 0.01247233f, -0.47943738f, 0.01431792f, -0.04056203f, -0.02164429f, -0.04776693f, 
    0.07397863f, 0.15348512f, 0.21049403f, 0.00883205f, 0.34445685f, -0.00453975f, 0.24216634f, 0.03457412f, 
    0.09854386f, -0.15458697f, 0.17640740f, -0.02019067f, -0.01299082f, 0.06134799f, 0.07420055f, -0.01144283f, 
    -0.54731101f, 0.01250892f, 0.46173763f, 0.42262915f, -0.15622380f, -0.07117726f, 0.00084234f, 0.05129148f, 
    -0.04597026f, 0.04265328f, 0.06915312f, 0.04249017f, -0.22339419f, -0.17312473f, 0.10312799f, 0.07109451f, 
    0.01188459f, -0.13863213f, -0.07968697f, 0.09849982f, -0.05986556f, -0.02685899f, 0.07876788f, 0.00152831f, 
    0.06999191f, 0.01013185f, -0.02478281f, -0.10471236f, -0.08465809f, -0.03715234f, 0.10661463f, -0.00091932f, 
    0.11431433f, -0.10792146f, 0.00785159f, -0.03558623f, -0.26034728f, -0.23231778f, -0.43645489f, -0.07665993f, 
    -0.12366643f, 0.00006760f, 0.05066109f, -0.14267175f, 0.00068632f, 0.01134268f, 0.13987812f, -0.03462290f, 
    -0.18473068f, 0.11560734f, -0.05732764f, -0.16363557f, -0.03302965f, 0.01361288f, -0.10103510f, 0.06759163f, 
    0.09088770f, 0.02970194f, 0.09995089f, -0.21544704f, 0.01778323f, -0.05861203f, -0.28075925f, 0.03537093f, 
    -0.04267736f, 0.08031760f, 0.24059886f, 0.14994334f, -0.01183947f, 0.02261439f, 0.05041300f, 0.02037285f, 
    -0.32591003f, 0.00586113f, 0.44146687f, -0.22188315f, -0.07780535f, -0.09630397f, -0.02476567f, -0.09081032f, 
    -0.12332544f, 0.14379247f, -0.03159013f, 0.16446953f, -0.22432555f, -0.08251397f, 0.22724159f, 0.03111134f, 
    0.04273552f, 0.06350741f, -0.06731494f, -0.03665744f, 0.04301557f, 0.08384550f, 0.14122590f, -0.01288358f, 
    -0.47484201f, 0.27575481f, 0.49456504f, 0.13862367f, -0.01424336f, -0.14135195f, -0.03837830f, 0.02663847f, 
    -0.03054750f, 0.18439397f, 0.07189506f, 0.06514093f, -0.08919618f, -0.22250015f, -0.23463939f, -0.05340512f, 
    -0.08811229f, 0.13575995f, 0.16831283f, -0.01920038f, 0.01054490f, -0.01110649f, -0.03959985f, 0.05600020f, 
    0.36243108f, 0.05745450f, -0.39230365f, -0.16733165f, -0.04998633f, -0.01299477f, 0.26846743f, 0.20460498f, 
    0.03323837f, 0.10852135f, -0.16458550f, -0.10601142f, 0.23519649f, 0.10965218f, 0.05259804f, -0.20457390f, 
    0.10343876f, -0.08408962f, 0.09631280f, -0.02953414f, 0.05173123f, 0.16187024f, 0.00041774f, 0.02541822f, 
    0.10847025f, -0.21458845f, -0.02908561f, -0.23087569f, 0.06454045f, -0.20453358f, -0.04522790f, -0.02596564f, 
    0.00785875f, 0.02700683f, 0.01196216f, 0.02520612f, -0.20524697f, -0.23585361f, -0.10946002f, -0.11622440f, 
    0.07549579f, -0.04858298f, 0.07677377f, 0.05754972f, -0.02103699f, 0.00088430f, 0.01139722f, 0.04400355f, 
    -0.51488674f, 0.37458697f, -0.06933331f, 0.27672186f, -0.07281353f, 0.12904136f, 0.12529637f, -0.04646913f, 
    -0.01464057f, -0.05694600f, -0.01879841f, 0.02476645f, 0.20499614f, -0.07862161f, 0.14025742f, -0.11387935f, 
    -0.04751229f, 0.08428299f, -0.10654133f, -0.04122509f, -0.02335302f, 0.01204563f, -0.08804023f, 0.01309708f, 
    0.08662494f, -0.03005403f, -0.04040497f, -0.16128795f, 0.03924162f, 0.02112551f, -0.07130422f, -0.02010060f, 
    -0.09721704f, 0.08481189f, -0.11494418f, -0.15606304f, -0.24987037f, 0.03121449f, -0.15936373f, 0.01526619f, 
    -0.04007482f, 0.04367322f, -0.01528916f, -0.08253338f, 0.09796309f, 0.04468099f, 0.04453222f, -0.02124726f, 
    -0.10269885f, 0.09905726f, -0.06646962f, 0.03570317f, 0.00465736f, -0.01905832f, 0.03466686f, 0.03035340f, 
    0.01845393f, 0.00098978f, -0.12806924f, -0.02966478f, 0.01389380f, -0.10747658f, 0.02922971f, -0.12385385f, 
    0.02971531f, 0.07386079f, -0.01576951f, -0.00121916f, -0.06489317f, -0.16928335f, 0.09743142f, -0.07202023f, 
    0.10011016f, 0.05739980f, -0.37631360f, -0.09649408f, -0.08987031f, -0.09248253f, -0.08588871f, -0.06660946f, 
    -0.10970493f, -0.04562819f, 0.06362247f, -0.15670292f, -0.17966802f, 0.12454356f, 0.16190037f, -0.00383246f, 
    0.06375646f, 0.10400883f, 0.11880457f, 0.01044815f, 0.03693726f, -0.01565121f, 0.06384282f, 0.00402866f, 
    -0.04544996f, -0.19292706f, 0.14148901f, 0.08945926f, -0.02837919f, -0.00061555f, -0.01304026f, 0.01377372f, 
    -0.00476573f, -0.03689159f, -0.04006166f, -0.06269344f, 0.17363310f, -0.08278769f, 0.01299827f, -0.04739923f, 
    -0.06782059f, 0.08990950f, 0.07363262f, -0.01518102f, -0.05835320f, -0.01166389f, 0.03216504f, -0.09442353f, 
    0.37840164f, -0.22402258f, -0.13069412f, -0.18593827f, -0.05337403f, -0.15178443f, -0.20966181f, 0.13860446f, 
    0.02565184f, -0.02676268f, 0.02598264f, -0.06783687f, 0.15341854f, -0.23651882f, 0.40954947f, -0.35476720f, 
    -0.05322617f, 0.05060789f, 0.08650762f, -0.07333707f, -0.01177072f, -0.20499781f, 0.02334047f, 0.04225352f, 
    -0.01685673f, 0.03694304f, -0.07334411f, 0.03167346f, 0.01372016f, -0.00938797f, -0.00576679f, -0.09790526f, 
    0.00802758f, -0.04710048f, -0.03422737f, -0.06308296f, -0.29492188f, -0.39966559f, -0.06384540f, 0.04961883f, 
    0.02037779f, -0.07393865f, -0.03086813f, 0.01680548f, 0.00981353f, -0.05688489f, 0.05177931f, -0.01770283f, 
    -0.20138153f, -0.29767653f, -0.20646639f, -0.16213635f, -0.10756581f, -0.01581640f, -0.02554861f, 0.09421048f, 
    0.00100414f, -0.02214959f, -0.03149250f, -0.08099208f, -0.19150494f, 0.24167429f, 0.32815027f, 0.02918128f, 
    -0.00521912f, -0.20119342f, -0.04313653f, 0.07360421f, -0.04761565f, 0.05738059f, 0.05268214f, 0.01235167f, 
    0.08378950f, -0.02991545f, -0.06108429f, 0.08940787f, -0.09680563f, -0.01432378f, -0.10853474f, -0.02290501f, 
    0.00048318f, -0.09232559f, -0.01421906f, -0.04547530f, -0.10494241f, 0.22803558f, -0.12944379f, 0.15065104f, 
    -0.02425320f, 0.05972127f, 0.05092687f, -0.02803591f, -0.04834514f, -0.06950124f, 0.05075882f, 0.00563355f, 
    -0.11023889f, -0.34288356f, 0.12729372f, 0.15086296f, 0.03741889f, 0.00587276f, 0.02995788f, -0.07320721f, 
    -0.22105744f, 0.01962018f, 0.07143611f, 0.05105066f, -0.22633229f, -0.25626212f, -0.18657644f, -0.33737329f, 
    0.01192670f, -0.00034424f, 0.19046654f, 0.05901118f, -0.04210272f, 0.00323925f, -0.00340778f, 0.00863167f, 
    -0.33740091f, -0.39669511f, -0.28069782f, -0.01914191f, 0.04889337f, -0.11578655f, -0.06364097f, 0.00010944f, 
    0.04798635f, 0.04056344f, -0.01575798f, 0.03162483f, 0.04839215f, 0.10907235f, -0.02840458f, 0.01097799f, 
    -0.03903969f, -0.06607416f, 0.03047218f, -0.00023927f, -0.01168233f, 0.05935668f, 0.05868357f, -0.04048416f, 
    0.18231858f, 0.19313890f, 0.01948649f, 0.00382152f, -0.00818517f, 0.09262901f, 0.07898791f, -0.00322562f, 
    -0.09443701f, 0.07221804f, -0.08239110f, 0.00677256f, 0.09373111f, -0.17186798f, -0.05133025f, -0.05705463f, 
    0.11430240f, 0.02882249f, -0.03318081f, -0.07141828f, -0.01908543f, -0.07940764f, 0.07781266f, -0.02166609f, 
    0.10036416f, -0.01724618f, 0.01040066f, -0.07308217f, -0.08595099f, -0.09288870f, -0.06092552f, 0.03319389f, 
    0.13097183f, 0.02773843f, 0.07785673f, 0.02383650f, 0.00203816f, 0.13223605f, -0.03009653f, 0.07427878f, 
    -0.11377686f, -0.00694213f, -0.07428052f, -0.02888212f, -0.02381803f, 0.10200837f, -0.00148582f, 0.01698140f, 
    -0.08025113f, 0.21821597f, -0.09650843f, 0.08382199f, -0.13166253f, 0.00461246f, -0.04067450f, -0.00795039f, 
    -0.03887869f, -0.04342477f, 0.01670200f, -0.11304443f, -0.17901176f, -0.03361801f, 0.22035626f, 0.07290927f, 
    0.02228931f, -0.19428255f, -0.02351800f, -0.01111826f, 0.02512678f, 0.01276559f, 0.00412107f, -0.00367529f, 
    0.12774229f, -0.01729237f, 0.09180186f, -0.14617394f, -0.00525522f, -0.01892666f, 0.01322805f, -0.05484322f, 
    0.01033926f, -0.17454949f, -0.07987960f, -0.33177471f, -0.17592826f, -0.14530750f, -0.22940205f, 0.12907434f, 
    0.01785563f, -0.05885945f, 0.12883689f, 0.06500432f, -0.02531839f, -0.06086167f, 0.00860483f, -0.02729736f, 
    0.25424930f, -0.48861769f, -0.37572187f, -0.31642604f, -0.01159145f, -0.19637240f, -0.00729638f, 0.05139351f, 
    0.01799115f, 0.08371317f, -0.07137963f, 0.00785671f, -0.20791169f, -0.17158684f, -0.09161104f, 0.16433465f, 
    0.01837846f, -0.03694250f, 0.03221556f, -0.00891301f, 0.06302479f, 0.03654429f, 0.01330034f, -0.05051316f, 
    -0.04537999f, -0.11528902f, 0.00508522f, -0.12661196f, 0.04082042f, -0.07454653f, 0.02073319f, 0.10342568f, 
    -0.01504559f, 0.01645402f, 0.06993016f, -0.07636226f, -0.25157878f, -0.24874809f, 0.32733217f, 0.07140320f, 
    0.13746098f, 0.05701927f, 0.06537972f, 0.12155482f, 0.01255932f, -0.12511869f, -0.07763090f, -0.08620599f, 
    -0.26805952f, -0.25259048f, 0.03274508f, 0.02718465f, -0.14946264f, -0.13911293f, 0.07843134f, 0.06805225f, 
    -0.02848508f, -0.03076919f, -0.03632673f, -0.09563228f, 0.06392179f, 0.63768905f, 0.29211611f, 0.05653677f, 
    -0.02144612f, -0.16493666f, 0.02519067f, -0.01477605f, -0.08412993f, -0.11730917f, 0.07487673f, 0.04188570f, 
    -0.16620988f, -0.26835427f, 0.14394286f, -0.02590771f, -0.06499304f, 0.04369880f, -0.08306997f, -0.03925780f, 
    0.10822700f, 0.06701630f, -0.04173549f, 0.01113308f, 0.07695926f, 0.04370055f, -0.05910407f, 0.05429272f, 
    -0.08520410f, -0.13222544f, 0.06119044f, 0.00869974f, 0.00560912f, 0.04132524f, -0.00588688f, 0.01308202f, 
    -0.16184105f, -0.09618630f, -0.14257608f, 0.07590201f, -0.06515671f, -0.00573838f, 0.03690730f, -0.02717341f, 
    0.13132419f, -0.04413520f, 0.00773877f, -0.10557215f, 0.02505545f, -0.15118347f, -0.14064527f, 0.00566026f, 
    -0.08505107f, -0.13540651f, -0.04846525f, -0.00723073f, -0.02050435f, 0.00053004f, -0.00592823f, 0.01349839f, 
    0.24457483f, -0.66029620f, 0.44306129f, -0.36088085f, -0.12532692f, 0.03474502f, 0.00460065f, 0.00936572f, 
    -0.07134950f, 0.11303902f, -0.01556262f, -0.02687581f, 0.00745216f, 0.04818797f, -0.00399833f, -0.12169759f, 
    -0.00628287f, 0.04589811f, 0.02094076f, -0.04449113f, -0.04955956f, -0.07673619f, 0.01570740f, -0.01728099f, 
    -0.12112341f, -0.09570501f, 0.17216438f, -0.27754560f, -0.04194260f, 0.10936980f, -0.01586999f, 0.24765268f, 
    -0.15897900f, 0.03223779f, -0.02878799f, -0.08842275f, 0.24167782f, -0.13205032f, -0.16145778f, 0.20652612f, 
    -0.08989741f, -0.14134184f, -0.08423144f, 0.04066972f, 0.18556777f, 0.07253559f, 0.09548861f, -0.04457675f, 
    -0.32720751f, -0.29273766f, 0.03910549f, 0.48801148f, -0.07501373f, 0.05774166f, 0.01332377f, 0.01503369f, 
    0.06795738f, -0.08867273f, 0.04475561f, -0.03363946f, -0.22169204f, 0.23120633f, 0.30569056f, -0.02756612f, 
    0.09940802f, 0.08783793f, 0.06325744f, 0.05360764f, 0.04407602f, 0.00660778f, 0.10443790f, -0.01641933f, 
    0.07921375f, -0.62613374f, 0.14201076f, 0.35831293f, -0.02205192f, 0.15419796f, 0.13212493f, -0.09631988f, 
    0.02736327f, -0.01614727f, -0.02040764f, -0.09264941f, -0.01044690f, 0.11659136f, 0.08933292f, -0.01594799f, 
    0.04559368f, -0.01322354f, -0.02979239f, -0.01155280f, 0.02474654f, 0.01179982f, 0.06776256f, -0.03908598f, 
    0.11171389f, 0.22722752f, -0.03050607f, 0.21556234f, 0.01110818f, 0.00576894f, -0.02595961f, 0.03952437f, 
    -0.01836316f, 0.01141347f, 0.18799148f, -0.17314053f, -0.25775915f, -0.05695592f, 0.04961948f, -0.23100711f, 
    -0.27293825f, 0.14241731f, 0.02466140f, -0.04750128f, 0.10873254f, 0.01796645f, 0.04532243f, -0.02671428f, 
    0.10766046f, -0.35122207f, -0.36498243f, -0.20992643f, -0.03232003f, -0.07100257f, -0.07510096f, 0.10988332f, 
    0.03858366f, -0.02926543f, 0.00072472f, 0.01761169f, 0.61483645f, -0.37436399f, -0.17808211f, -0.62850302f, 
    0.10050608f, 0.02278871f, 0.00500503f, 0.14744115f, -0.01029949f, 0.05740184f, 0.04542367f, -0.18121746f, 
    -0.03476748f, 0.12043314f, 0.03226611f, -0.02704321f, -0.13833341f, -0.10709719f, -0.01401529f, -0.03765827f, 
    -0.16055821f, -0.01683824f, 0.03041129f, -0.03535067f, -0.16897887f, 0.16112471f, -0.17399842f, -0.08325523f, 
    -0.04681411f, 0.00734511f, 0.21447241f, 0.09600503f, -0.00718720f, 0.01768066f, -0.07439981f, -0.01551530f, 
    -0.05802010f, 0.17325085f, -0.03970556f, 0.00359358f, 0.01479658f, -0.07755815f, 0.11054447f, 0.05159214f, 
    0.00615765f, 0.05012794f, -0.07363664f, 0.04758874f, 0.07920961f, 0.07539996f, 0.11754722f, -0.10515331f, 
    0.01075266f, 0.09463937f, -0.22793792f, -0.17920750f, -0.07373785f, 0.09139977f, 0.01242088f, 0.02835763f, 
    0.45827961f, 0.21649177f, -0.31640345f, -0.45676729f, -0.05049542f, 0.10089090f, -0.28257975f, 0.01437888f, 
    -0.02210225f, 0.10501114f, -0.03270994f, 0.02953285f, 0.26670200f, 0.02134661f, -0.02340133f, -0.21064129f, 
    0.02084122f, 0.01273269f, -0.08856798f, 0.03177285f, 0.00228800f, -0.03629744f, 0.01718193f, -0.06037024f, 
    0.52680337f, -0.42460445f, -0.59542447f, -0.41980487f, -0.03323108f, -0.02609607f, -0.03313861f, -0.09121662f, 
    0.05622245f, -0.04653955f, 0.06575170f, 0.01721358f, -0.05714630f, 0.02508856f, -0.12876129f, 0.04188934f, 
    -0.06068745f, 0.03415459f, -0.06717710f, 0.02184699f, 0.02800767f, 0.00965129f, 0.00365749f, 0.03840480f, 
    -0.11046672f, 0.01389862f, -0.11979395f, -0.00298225f, 0.03554331f, 0.00129804f, -0.04453081f, -0.02750515f, 
    -0.03062404f, -0.02810916f, -0.03788662f, -0.00107568f, -0.17383029f, 0.21671899f, -0.06266750f, 0.18085454f, 
    0.02828833f, 0.06019543f, 0.10892636f, -0.02589927f, -0.07155492f, -0.09667198f, -0.02913512f, 0.04219838f, 
    0.30931240f, 0.27558148f, 0.11304425f, -0.21643701f, -0.10048583f, -0.12614982f, -0.13294022f, -0.19228178f, 
    -0.03829420f, 0.00454450f, -0.04775881f, -0.01638552f, 0.16866134f, -0.09228371f, -0.23838577f, 0.02252195f, 
    -0.19119909f, -0.01823913f, 0.04812679f, -0.09470028f, -0.09146315f, -0.06330903f, -0.07795916f, -0.06854135f, 
    -0.39595178f, -0.06339317f, 0.36301917f, 0.15585062f, 0.15343751f, -0.04015776f, -0.32300454f, -0.11036048f, 
    -0.00633379f, -0.02775125f, 0.00045640f, -0.05154534f, 0.19425274f, 0.11181929f, -0.16665974f, -0.16102216f, 
    0.02453520f, -0.13953537f, 0.02310739f, 0.14623797f, 0.14087591f, 0.03942185f, 0.03648512f, 0.12138403f, 
    0.17475939f, -0.00213581f, -0.12677827f, -0.01683131f, 0.08780412f, 0.01394363f, 0.02189987f, 0.00934344f, 
    0.06542192f, 0.07887211f, 0.05822365f, 0.00438857f, -0.20085980f, 0.13149758f, 0.03448133f, 0.07953885f, 
    -0.00805570f, -0.05564638f, -0.03976495f, 0.04392220f, -0.09957345f, 0.06103886f, 0.01668677f, 0.05138445f, 
    0.18610495f, 0.13979144f, -0.05367700f, -0.03343120f, 0.01878055f, 0.00525953f, -0.11525812f, -0.05917259f, 
    -0.12296608f, -0.01970528f, 0.02469184f, -0.04055691f, -0.15595862f, 0.15058602f, -0.04606690f, 0.10041738f, 
    -0.01941093f, 0.00446004f, 0.03418829f, 0.00924467f, 0.06957009f, 0.14487739f, 0.03091261f, -0.04606183f, 
    0.25177753f, 0.26860335f, -0.19375564f, -0.04789873f, 0.08837456f, -0.08154332f, 0.05193361f, 0.03187336f, 
    0.06231573f, -0.00835864f, 0.00778197f, 0.17237990f, -0.35481954f, -0.19119796f, 0.13480979f, 0.05449819f, 
    -0.01880481f, -0.01299418f, -0.07887563f, -0.03913232f, 0.06989298f, 0.13243765f, 0.12703721f, 0.12753145f, 
    0.16303512f, -0.06676409f, -0.02657691f, 0.00516972f, 0.16526403f, -0.08639939f, 0.04563908f, -0.00411821f, 
    0.00687311f, 0.07634193f, 0.12184505f, 0.13645671f, 0.11307145f, -0.06265154f, -0.09704306f, 0.03087101f, 
    0.12722839f, 0.00778235f, 0.00224927f, -0.04801377f, 0.13498068f, 0.12519433f, 0.04839664f, 0.16527896f, 
    -0.08643281f, -0.14227059f, -0.13230728f, 0.04065059f, 0.08097827f, 0.04015246f, 0.19628444f, 0.08700956f, 
    0.01286188f, -0.04088193f, -0.07075264f, -0.04812626f, -0.17844146f, -0.20996465f, 0.05242373f, 0.19398004f, 
    0.04573596f, 0.00780152f, 0.05536564f, -0.06154398f, 0.08555577f, 0.11391765f, 0.04615721f, 0.10033663f, 
    -0.18244506f, 0.10349692f, -0.00103496f, 0.00371981f, 0.04604599f, 0.01848042f, -0.02043654f, 0.04207690f, 
    -0.04016813f, -0.03731594f, -0.06504397f, 0.05212069f, -0.16980232f, -0.49975970f, -0.43759429f, -0.07817709f, 
    -0.06726424f, 0.11617588f, 0.14085211f, -0.05530413f, -0.06100528f, -0.03071864f, 0.08252384f, -0.01292200f, 
    -0.20780121f, -0.40279382f, -0.32400364f, 0.07377360f, 0.02706548f, 0.06264532f, -0.02228947f, -0.01033485f, 
    0.00295353f, 0.03302777f, 0.04580076f, 0.13592087f, 0.03009596f, -0.02397988f, 0.25489572f, 0.08367374f, 
    0.06640829f, 0.03365533f, 0.00790236f, -0.04382619f, 0.01596704f, 0.03707047f, 0.18858224f, 0.04639862f, 
    -0.03185712f, 0.03671528f, 0.04783382f, 0.03163643f, 0.03682112f, -0.00949751f, 0.03397251f, 0.06508653f, 
    -0.08763624f, 0.03206893f, -0.15126553f, -0.26116097f, -0.60737836f, -0.04356323f, 0.15039666f, 0.11291149f, 
    0.06048820f, 0.02155682f, -0.11889773f, -0.04502640f, -0.04864915f, -0.08650896f, 0.02510502f, -0.02660148f, 
    0.12400300f, -0.22440782f, -0.03511990f, -0.00303201f, 0.03566965f, -0.07622153f, -0.01819338f, 0.01686820f, 
    -0.10198781f, 0.10756603f, -0.06343378f, 0.04618293f, -0.02267645f, -0.42965928f, -0.13670176f, 0.22685088f, 
    -0.03050459f, 0.20500854f, 0.00353124f, -0.04655953f, -0.04867030f, 0.02932651f, 0.00995799f, 0.03526689f, 
    -0.06213439f, -0.28252760f, -0.17475466f, 0.04031041f, 0.05786270f, 0.06294376f, -0.05495289f, -0.07773436f, 
    0.00641075f, 0.01266396f, -0.01752965f, 0.07095872f, -0.24853791f, -0.07310700f, -0.03024696f, -0.03041509f, 
    -0.07294264f, 0.02566804f, -0.05670496f, -0.07274017f, -0.06839577f, -0.07853127f, -0.15163249f, -0.23586755f, 
    0.21381320f, -0.21406223f, -0.05358452f, -0.14005773f, -0.13936298f, -0.06565133f, 0.18044007f, 0.01156497f, 
    -0.04250909f, 0.06467082f, 0.18957420f, 0.07130671f, -0.15003055f, -0.15585551f, -0.08499430f, -0.10098808f, 
    -0.00142327f, 0.08685962f, 0.00000544f, -0.00017059f, -0.14746992f, 0.01132336f, -0.02258240f, -0.16126923f, 
    -0.19155301f, -0.20888650f, -0.15052907f, -0.08118924f, 0.01937140f, 0.05087027f, 0.06963863f, 0.14973661f, 
    -0.06051792f, -0.05209743f, -0.08930186f, -0.09102471f, 0.34580868f, 0.30057326f, 0.11724549f, 0.14104578f, 
    -0.02737508f, -0.00413267f, -0.00126148f, 0.09185746f, 0.11157348f, -0.08851720f, 0.13238193f, -0.07783760f, 
    -0.06271758f, 0.10592646f, 0.06279045f, 0.16440478f, -0.06662547f, -0.06549454f, 0.05550378f, 0.05412304f, 
    -0.06377564f, 0.07373123f, 0.03536984f, 0.05872679f, 0.15240669f, -0.14537533f, -0.05863756f, -0.00302210f, 
    0.10031765f, -0.13516921f, -0.24539098f, -0.02121342f, 0.09204134f, 0.16965231f, 0.04116009f, 0.07951415f, 
    -0.01783957f, 0.00916053f, -0.15969628f, -0.29322305f, 0.02214175f, 0.02651791f, 0.01146400f, 0.02376690f, 
    0.06082112f, 0.11190852f, 0.04827392f, 0.12538379f, -0.37903148f, -0.51462698f, -0.44606471f, -0.25694463f, 
    -0.06143967f, -0.09589460f, 0.05559387f, -0.11219318f, -0.06525315f, 0.01580982f, -0.03908805f, 0.02028650f, 
    0.01515431f, -0.28577009f, -0.29554647f, -0.33904693f, 0.04665754f, 0.18620746f, 0.21719770f, 0.12242451f, 
    -0.00747554f, -0.18210059f, -0.05844804f, 0.02794916f, -0.20815969f, -0.37227476f, -0.18340628f, -0.02127583f, 
    0.08010402f, 0.07453451f, 0.01645592f, 0.05369778f, -0.05680474f, 0.03106846f, 0.02923465f, 0.02744691f, 
    0.01289287f, -0.11531425f, -0.20111278f, 0.17484148f, -0.07293980f, -0.05381291f, 0.07116319f, -0.04383335f, 
    -0.00865035f, -0.15171517f, -0.22625361f, -0.05000551f, 0.30007157f, -0.09595491f, -0.34476119f, -0.12799333f, 
    -0.10245675f, -0.16195792f, 0.01549866f, -0.01055451f, 0.02583453f, 0.10607599f, -0.08201233f, 0.02117185f, 
    0.37655115f, 0.28408453f, -0.30396733f, -0.23795913f, 0.03794275f, -0.04941734f, -0.09699500f, -0.13319893f, 
    0.05233033f, 0.05047166f, -0.02216184f, 0.06430945f, -0.59837425f, -0.35656121f, -0.06520391f, -0.00316276f, 
    -0.02274715f, 0.03463880f, -0.00310335f, -0.06422367f, 0.00543440f, 0.02790680f, 0.14218864f, -0.00179195f, 
    -0.03603423f, -0.25153068f, -0.06850155f, 0.05990419f, -0.01714754f, 0.11112272f, 0.14256732f, 0.08092758f, 
    -0.02629653f, -0.02923129f, -0.03093840f, -0.11073913f, -0.08211392f, 0.06786509f, -0.03712073f, 0.06579407f, 
    0.04314502f, 0.04388653f, -0.00467696f, -0.02393908f, -0.02630956f, 0.03837013f, 0.13734624f, 0.17672518f, 
    -0.14709401f, 0.06904132f, 0.05359582f, 0.03524296f, 0.11570928f, 0.05445043f, -0.08081158f, 0.01533199f, 
    -0.31872332f, -0.10459200f, -0.17799190f, -0.25199574f, 0.23336764f, 0.07292918f, 0.00035480f, 0.03060660f, 
    -0.06303465f, 0.22355151f, 0.02658047f, 0.02129437f, 0.06297067f, -0.00330704f, 0.03313575f, 0.01325570f, 
    0.44441846f, 0.25058293f, -0.04425074f, -0.27860749f, -0.04506147f, -0.03484822f, 0.13861288f, -0.14644076f, 
    0.09056587f, 0.06461656f, 0.02154767f, 0.08270536f, -0.08445743f, -0.01651590f, -0.10740148f, -0.06972084f, 
    -0.04938538f, -0.07296337f, 0.03600424f, 0.00175657f, 0.10392348f, 0.09445766f, -0.01010214f, 0.09567194f, 
    0.24646637f, -0.09079514f, 0.05499124f, 0.28366852f, -0.01219455f, 0.09922369f, 0.08338978f, -0.16839743f, 
    0.04217078f, -0.00475052f, 0.03413440f, 0.10338966f, -0.02811083f, -0.03288535f, -0.03781042f, -0.02038310f, 
    0.04316936f, 0.09612609f, 0.07288757f, 0.00927073f, -0.19415018f, -0.12340424f, -0.15773776f, -0.67302108f, 
    0.20004010f, -0.04347083f, -0.45787498f, -0.12887824f, -0.09577823f, 0.03210272f, 0.08822785f, -0.10263510f, 
    -0.00971470f, 0.07492271f, 0.02315236f, 0.04526635f, -0.22328103f, -0.15274128f, 0.08912466f, 0.12770131f, 
    -0.14294954f, -0.07290313f, 0.00286505f, 0.00401260f, 0.04168878f, 0.00572121f, -0.14109555f, -0.01922349f, 
    0.63996887f, 0.15381730f, -0.25293159f, -0.27981997f, 0.21490343f, 0.02891592f, -0.00224162f, 0.01448267f, 
    0.04771893f, 0.06342490f, 0.17884158f, 0.02785387f, -0.39563072f, -0.08765395f, 0.05439065f, -0.17775613f, 
    -0.04970556f, -0.07841929f, -0.09809158f, -0.10999195f, -0.30839583f, -0.10697651f, -0.22959647f, -0.23033589f, 
    -0.11460275f, 0.02839766f, -0.25567910f, -0.13010913f, -0.04010504f, -0.05024349f, -0.04956975f, 0.08035140f, 
    -0.01340155f, 0.15181887f, -0.05393701f, -0.03328522f, -0.47276980f, -0.20708071f, 0.03658092f, 0.28556845f, 
    0.06835666f, 0.02952279f, -0.01514274f, 0.18985091f, -0.15133631f, 0.04583697f, -0.14439116f, 0.00007033f, 
    -0.14295501f, -0.43273595f, -0.26321146f, 0.09811848f, 0.06774572f, 0.18218154f, 0.14866132f, 0.08926488f, 
    0.01217329f, 0.07989669f, 0.02078616f, -0.04842914f, 0.25301123f, 0.12234990f, -0.38929841f, -0.51131254f, 
    0.00973842f, -0.11081079f, 0.08102953f, -0.14365958f, 0.03177399f, 0.14253506f, 0.09205697f, 0.12916197f, 
    -0.25810152f, 0.04824495f, 0.09723599f, 0.05980843f, 0.08117441f, -0.02335838f, 0.01504931f, 0.04290930f, 
    -0.03724870f, -0.00385518f, 0.04769057f, -0.00391831f, -0.20236216f, -0.27297029f, -0.16042513f, 0.19622581f, 
    -0.04643762f, 0.12280168f, -0.02604747f, -0.14127311f, -0.01692103f, -0.13718282f, 0.01162719f, 0.04738133f, 
    -0.11995713f, -0.07186660f, -0.03148193f, -0.05209049f, -0.09582458f, 0.07572793f, -0.23815536f, 0.15613338f, 
    -0.05706403f, 0.00899638f, -0.15272412f, 0.08925395f, -0.00493975f, 0.04754882f, 0.05400278f, -0.14647588f, 
    0.08548142f, -0.02822438f, 0.01390002f, 0.10646546f, 0.00081833f, -0.11490729f, 0.02302869f, -0.03410789f, 
    -0.03743649f, -0.27181315f, -0.26923278f, -0.10667659f, -0.11008446f, 0.00772503f, 0.09435085f, 0.14036399f, 
    0.09215970f, -0.06191374f, 0.07656750f, -0.06852026f, 0.07908098f, -0.01386623f, -0.12427644f, -0.12532945f, 
    -0.01804994f, -0.11641525f, -0.03340495f, -0.01581744f, 0.02175737f, -0.09856706f, 0.07439919f, -0.12788990f, 
    -0.33722690f, -0.39608938f, -0.27732614f, 0.11434031f, 0.02170576f, 0.11754113f, 0.07902527f, 0.02869410f, 
    0.16029730f, 0.13601062f, 0.04892093f, 0.02850343f, -0.11314848f, 0.02723315f, -0.02450527f, 0.13511947f, 
    0.13059084f, 0.13212082f, 0.15515031f, 0.00813816f, -0.02760366f, -0.00753325f, 0.00421612f, -0.00516403f, 
    0.04700293f, -0.01877220f, -0.07406327f, 0.10984153f, 0.05049999f, -0.03818863f, -0.17619993f, 0.06071318f, 
    -0.00431354f, -0.08593907f, -0.06752190f, -0.02671915f, -0.34763876f, 0.06185972f, 0.11207291f, 0.24028794f, 
    -0.13662232f, 0.05230907f, -0.01075706f, -0.00025420f, -0.12060131f, -0.02276423f, 0.03085094f, 0.06192252f, 
    -0.06849446f, -0.46644014f, 0.09612212f, -0.17007278f, 0.08760194f, 0.16219153f, 0.07260660f, 0.20164214f, 
    -0.07362534f, -0.00546387f, -0.04612395f, 0.04803602f, -0.23855169f, 0.03084400f, 0.27848577f, -0.15394035f, 
    -0.04929646f, -0.05343208f, 0.01683567f, 0.07702440f, -0.04523184f, 0.08914198f, 0.00220462f, 0.01300777f, 
    0.33129129f, -0.06735057f, -0.45561689f, -0.01887317f, 0.02241925f, 0.00875035f, 0.00661627f, 0.20930496f, 
    0.03711031f, 0.01659012f, 0.01555682f, 0.09204338f, 0.04540482f, -0.15290815f, -0.22107022f, 0.17475362f, 
    -0.01541011f, 0.11089395f, -0.03525921f, 0.19550000f, 0.06688549f, 0.05076071f, -0.05255261f, -0.16802263f, 
    -0.01213656f, -0.04614233f, 0.14255443f, 0.02514046f, 0.09049711f, 0.07726445f, -0.05119376f, -0.10240579f, 
    0.05964026f, 0.06787115f, -0.10175297f, 0.07433300f, -0.19680162f, 0.23683609f, -0.71408707f, 0.08108603f, 
    0.05124606f, -0.01266556f, 0.21355326f, -0.00364890f, 0.07116172f, -0.01505306f, -0.04721760f, -0.08594987f, 
    -0.28896064f, 0.24594271f, -0.54773378f, 0.42821234f, 0.06678273f, 0.09350782f, 0.09987924f, -0.09931695f, 
    0.12945127f, 0.04127716f, -0.05153555f, 0.05954602f, -0.01670008f, 0.10050707f, -0.02773340f, -0.37971455f, 
    -0.18685371f, -0.10863687f, 0.05489730f, -0.06830204f, -0.17530909f, 0.04101131f, -0.01788285f, -0.09768417f, 
    -0.18864372f, -0.11586401f, -0.10520674f, 0.11584162f, 0.03823057f, 0.06133592f, -0.17233753f, 0.04808690f, 
    0.01817117f, -0.10740229f, 0.07553168f, 0.01843153f, -0.06588241f, -0.10163229f, 0.12144655f, -0.16837101f, 
    0.10716864f, 0.04064156f, 0.06130577f, 0.07992862f, -0.08301857f, -0.00537756f, -0.04716716f, -0.22425728f, 
    -0.09162941f, 0.05796003f, 0.03275491f, 0.10717064f, 0.04424811f, -0.13600306f, 0.11576368f, -0.23994410f, 
    0.03806080f, -0.02921022f, -0.11688958f, -0.07686144f, -0.01485774f, 0.02064154f, 0.09624343f, -0.09638499f, 
    0.00783903f, -0.07257302f, 0.12922138f, -0.16815576f, 0.13719901f, -0.15878765f, -0.07427937f, -0.03443358f, 
    0.13097598f, -0.01690600f, 0.08789205f, 0.01444972f, -0.03894477f, -0.06833787f, -0.26445511f, -0.04701542f, 
    0.10618107f, -0.08791619f, 0.02737077f, 0.18736756f, 0.16359258f, -0.41949564f, 0.11406087f, -0.20958093f, 
    -0.08832248f, -0.02960272f, -0.41831708f, -0.03233756f, 0.00267178f, 0.02777789f, -0.07317657f, -0.04600382f, 
    -0.11505510f, -0.13229513f, -0.18095931f, 0.03522184f, 0.06925999f, -0.01587426f, -0.01897384f, -0.03048904f, 
    0.04988777f, -0.04844432f, -0.09221739f, -0.03392361f, -0.22788535f, 0.36559448f, 0.26897314f, -0.28179786f, 
    -0.08828019f, -0.13806239f, 0.07523847f, 0.07650816f, 0.00608375f, 0.08963273f, 0.07238187f, -0.01322644f, 
    -0.00657013f, -0.01483930f, 0.01802370f, -0.14937590f, -0.01750468f, -0.00466239f, -0.13457990f, 0.08824042f, 
    0.06602558f, -0.02460853f, 0.00511523f, -0.07956306f, -0.00584913f, -0.24979255f, -0.03220069f, -0.54472691f, 
    -0.08348168f, 0.09365927f, -0.00610997f, 0.03332420f, -0.02399714f, -0.04001556f, -0.06513344f, -0.09270906f, 
    0.06946953f, -0.02850695f, -0.09886791f, 0.04707918f, -0.04200625f, 0.02385669f, 0.00964656f, 0.09367113f, 
    0.06753286f, 0.04685526f, 0.05199430f, 0.07378769f, -0.42317343f, 0.09682914f, -0.55772889f, 0.11036626f, 
    0.10368445f, -0.04066124f, 0.15589018f, 0.16279192f, -0.00471375f, 0.01947935f, -0.09340373f, -0.05971001f, 
    0.09659400f, 0.10704849f, 0.48016950f, -0.17173706f, 0.07028794f, -0.37624651f, -0.01977614f, -0.06008153f, 
    0.05519614f, 0.02949259f, -0.06251635f, -0.00571498f, -0.00024910f, -0.05471626f, -0.17046629f, -0.44543520f, 
    -0.07216228f, -0.10990021f, -0.07428323f, 0.05189874f, 0.01406548f, -0.01089532f, 0.04323637f, -0.02916639f, 
    -0.31862363f, 0.05948748f, -0.08918831f, -0.20890650f, -0.16194202f, -0.07144240f, -0.05419376f, 0.16916369f, 
    0.00914767f, -0.06417073f, 0.01243012f, 0.00061382f, -0.09271452f, -0.01141967f, -0.00205339f, -0.06344428f, 
    0.06738466f, 0.08896195f, 0.10269826f, 0.06850340f, 0.09498691f, 0.03752821f, 0.06843099f, 0.22427732f, 
    -0.27929118f, -0.11488783f, 0.10896926f, -0.05018816f, 0.12768398f, -0.06689017f, -0.20958303f, 0.08014350f, 
    0.02312597f, -0.04092340f, -0.04920396f, 0.01643050f, -0.00808575f, 0.33428314f, 0.21005432f, -0.02008511f, 
    -0.01729988f, -0.05387811f, -0.12375033f, -0.17054456f, 0.17161947f, 0.06330017f, 0.12673874f, -0.04452076f, 
    0.14235151f, -0.01455357f, 0.15659334f, 0.00224378f, -0.00098854f, -0.20922557f, -0.07873457f, -0.08697976f, 
    0.10797534f, 0.04997106f, 0.15085924f, 0.13255522f, -0.30228791f, -0.21149597f, -0.32099062f, 0.04269613f, 
    -0.05776946f, 0.07251179f, 0.12912528f, 0.03590473f, -0.10169565f, 0.05437934f, 0.06457757f, -0.02361808f, 
    -0.38881323f, 0.08164459f, -0.09465019f, -0.23829962f, -0.07735774f, 0.04995488f, -0.20883535f, 0.08815179f, 
    0.13912921f, -0.10594656f, -0.06581396f, 0.01940996f, 0.16349007f, -0.23390712f, -0.09830750f, -0.00862488f, 
    0.16400300f, -0.05008438f, 0.09918091f, 0.03073395f, 0.02283728f, -0.17142473f, -0.13997039f, -0.10075949f, 
    -0.01690141f, -0.00837873f, 0.10091410f, 0.08649477f, -0.00082817f, -0.03929923f, -0.08798028f, -0.09589645f, 
    -0.00798836f, -0.02922490f, 0.03830751f, -0.06665100f, -0.29339987f, 0.02304594f, 0.17787044f, -0.15148546f, 
    0.05451131f, -0.07446788f, 0.13408640f, 0.23381026f, 0.06806432f, 0.04824218f, -0.00945650f, -0.07353030f, 
    0.09998287f, -0.20901342f, 0.10259492f, 0.55778110f, 0.09032225f, 0.03878904f, -0.20003144f, 0.08208362f, 
    0.02241932f, -0.08191834f, 0.02075670f, 0.08334051f, 0.15706365f, 0.35741997f, -0.03847645f, -0.05974536f, 
    -0.05369798f, -0.04247823f, 0.00850219f, 0.08873563f, 0.02081335f, 0.03682284f, 0.05097349f, -0.00580552f, 
    -0.05305567f, -0.00695394f, 0.07734419f, 0.26457471f, -0.02771189f, 0.05686998f, -0.24936493f, 0.09084399f, 
    0.00698774f, -0.07459660f, 0.10838019f, 0.18403761f, 0.04148511f, -0.29392943f, -0.07429924f, -0.22895665f, 
    -0.01081758f, 0.06092970f, 0.10088062f, 0.26122540f, 0.01524113f, 0.00992304f, -0.05032979f, -0.08458157f, 
    -0.57289088f, -0.02950584f, -0.12868547f, 0.06061859f, 0.03275776f, 0.00982525f, -0.09499690f, 0.19238472f, 
    0.00628824f, -0.00321942f, 0.00386737f, 0.00895593f, 0.19480206f, -0.34431651f, -0.00092930f, -0.26019666f, 
    0.03218961f, 0.04054957f, -0.02534495f, 0.06313769f, 0.12057326f, 0.03073666f, 0.09426798f, 0.07263025f, 
    0.13647507f, -0.02452237f, 0.06420122f, -0.11282540f, -0.15707967f, -0.15102258f, -0.16264908f, -0.04673649f, 
    0.07663387f, 0.09403258f, 0.09367995f, 0.02511316f, -0.08166665f, 0.01357235f, -0.15922342f, 0.00862198f, 
    -0.00277979f, -0.03389460f, 0.07139991f, 0.03959754f, 0.06268286f, -0.00874077f, -0.13798974f, -0.02032214f, 
    0.02193285f, 0.21400690f, -0.12155937f, -0.16694258f, -0.06519942f, -0.01775389f, 0.15631901f, 0.13785189f, 
    0.02432914f, 0.14412531f, 0.03749097f, 0.06819257f, -0.09216549f, 0.10626251f, -0.09976871f, -0.25855482f, 
    0.00910284f, -0.13397126f, -0.17942050f, 0.14752646f, -0.03687084f, -0.07378013f, -0.09453546f, -0.06477358f, 
    -0.15299384f, -0.51050627f, -0.07875287f, -0.14978063f, -0.00411191f, 0.01154545f, -0.12625624f, -0.05262150f, 
    -0.09211470f, -0.11173949f, -0.05066835f, -0.05783294f, 0.03674838f, -0.14064027f, 0.02175704f, 0.05863167f, 
    0.16005681f, 0.12197708f, 0.09958348f, 0.01663522f, 0.18502681f, 0.06451513f, 0.06628385f, 0.00708765f, 
    -0.19980700f, -0.07572266f, 0.06682187f, 0.04107875f, 0.04674754f, -0.09133364f, 0.05407272f, -0.00789922f, 
    -0.13578172f, 0.06338565f, -0.00386766f, 0.05572602f, -0.12490056f, 0.04291622f, 0.04678589f, 0.14513633f, 
    0.01828700f, 0.01972288f, -0.05891266f, -0.01343092f, 0.00914860f, 0.12466018f, 0.14053549f, 0.16557020f, 
    -0.13789594f, 0.06888505f, -0.13068746f, -0.01164047f, 0.03398652f, -0.16658217f, 0.19465101f, 0.12706681f, 
    -0.03823422f, 0.04162524f, -0.06352289f, -0.01249533f, 0.20561148f, -0.15126421f, 0.17356387f, -0.38155654f, 
    0.10089579f, -0.12206011f, 0.05401807f, -0.11813702f, 0.05752007f, 0.06394792f, -0.02369850f, 0.03220951f, 
    0.04612685f, -0.30941287f, -0.04946797f, 0.22180867f, 0.05826562f, 0.03643974f, -0.08080625f, -0.16349147f, 
    0.05108313f, -0.00993295f, -0.01994725f, 0.06259902f, -0.15707055f, -0.13015610f, -0.09361127f, -0.10990104f, 
    0.02238712f, 0.15754521f, 0.15447581f, 0.01876865f, 0.10555684f, 0.03602820f, -0.00707230f, 0.04039732f, 
    -0.75114495f, 0.13529603f, 0.07391877f, 0.35653758f, 0.01020747f, 0.09505814f, -0.07982069f, 0.03527404f, 
    0.12164642f, -0.10903277f, 0.04529751f, 0.02107847f, -0.09227543f, 0.18715501f, -0.31990910f, -0.56810820f, 
    -0.35674563f, -0.03381951f, -0.11355679f, 0.06787200f, 0.22654362f, 0.04147717f, 0.02275891f, -0.11201673f, 
    -0.31061238f, 0.00311867f, -0.03832005f, -0.41393760f, -0.00989293f, -0.13322884f, 0.03482247f, -0.02786187f, 
    0.07066683f, 0.01068299f, 0.07221916f, 0.10080142f, -0.44440696f, -0.05407469f, 0.27522320f, 0.48248291f, 
    0.01265903f, 0.01589578f, -0.25084627f, 0.16294074f, 0.03714405f, -0.09638022f, -0.02427348f, 0.09389041f, 
    -0.03977657f, 0.04345817f, -0.10276050f, 0.04453754f, 0.03360986f, 0.02517731f, 0.14169490f, 0.10631844f, 
    -0.06011274f, -0.01437396f, 0.02410863f, -0.10534508f, 0.00303596f, -0.00365139f, 0.33814016f, -0.22677948f, 
    0.05157262f, -0.06852890f, 0.10161277f, 0.18637480f, -0.01781970f, -0.00186996f, 0.00017857f, 0.00126867f, 
    0.17719205f, -0.10542176f, 0.06675948f, 0.02017855f, 0.19104443f, 0.11904161f, -0.16716202f, 0.23411015f, 
    0.02137247f, -0.13710830f, -0.12779549f, -0.06240554f, -0.31649211f, 0.09259474f, -0.57803875f, 0.06230699f, 
    0.11066735f, 0.03081920f, 0.17791556f, -0.24837503f, -0.02792488f, 0.00996278f, -0.06975687f, 0.00426975f, 
    -0.10667592f, 0.22289835f, -0.34646863f, 0.55173457f, -0.12812798f, 0.15175611f, -0.16778691f, 0.01171431f, 
    0.06630666f, -0.15512569f, 0.04441111f, -0.01435513f, -0.09345873f, -0.18765502f, 0.18358852f, 0.25205052f, 
    0.02090641f, 0.13185334f, -0.32149649f, -0.03389155f, 0.14471816f, -0.17356327f, -0.06085976f, 0.06756017f, 
    0.30679402f, 0.20358133f, 0.33962214f, 0.18701957f, 0.04272101f, -0.10104800f, -0.20475999f, -0.20141914f, 
    -0.09161358f, -0.03616988f, 0.02451013f, 0.11131085f, 0.02229165f, 0.42150158f, -0.23060773f, -0.06255167f, 
    0.09312154f, -0.09381720f, -0.02481864f, -0.04130539f, -0.04355618f, 0.06919249f, -0.10982451f, -0.03249019f, 
    -0.02901886f, 0.14351547f, -0.13623863f, -0.14957021f, 0.20890698f, 0.03342338f, 0.06284755f, -0.05680402f, 
    0.03034810f, -0.17162752f, 0.07751377f, -0.11571019f, -0.29527342f, 0.14647447f, -0.11118716f, -0.10667649f, 
    -0.09243791f, -0.02255738f, 0.17094849f, 0.09029534f, 0.09955263f, 0.09812447f, -0.09109396f, -0.04283492f, 
    -0.42865309f, -0.06647464f, -0.26526213f, 0.08061610f, -0.18828785f, 0.03347130f, -0.05523659f, 0.05970136f, 
    0.02190764f, -0.09811126f, -0.06418175f, 0.00639266f, -0.10215934f, -0.15144929f, -0.03905796f, 0.00179355f, 
    -0.03052579f, 0.08763479f, -0.16951258f, -0.01566105f, -0.09219724f, -0.04895493f, -0.00412261f, -0.06359561f, 
    0.00248167f, 0.00672230f, -0.00736309f, -0.06437834f, 0.02873221f, -0.08419126f, 0.03590025f, -0.14830950f, 
    0.02746935f, 0.00899469f, -0.06580647f, -0.05539910f, -0.14092642f, 0.32122943f, -0.02093428f, 0.06363541f, 
    0.02113624f, 0.09596183f, 0.18024769f, 0.19928676f, -0.12778626f, -0.06032514f, -0.11112840f, 0.05407377f, 
    -0.29086530f, 0.11793441f, 0.01824965f, 0.03667510f, -0.06659558f, -0.02742228f, -0.06590509f, -0.03924215f, 
    -0.05528226f, -0.07000869f, 0.09778894f, 0.05329761f, -0.14037454f, -0.21202949f, -0.03542557f, 0.12494799f, 
    -0.19384451f, -0.22687180f, 0.10469647f, 0.02393052f, -0.06653052f, 0.06750750f, 0.07856575f, 0.12553380f, 
    -0.22446974f, 0.01781324f, 0.16076541f, -0.19829240f, -0.06455825f, -0.10394297f, 0.13698076f, -0.03521768f, 
    -0.13464524f, -0.01355826f, -0.03876574f, 0.02616381f, 0.08762617f, 0.00590034f, 0.10673144f, 0.14285959f, 
    -0.12690546f, 0.03677943f, 0.07011899f, -0.01983559f, 0.00243143f, -0.07203531f, -0.10051206f, 0.15150853f, 
    -0.08130240f, 0.19959573f, 0.17590909f, 0.06701555f, -0.02152224f, 0.05474942f, 0.08482011f, 0.02227075f, 
    -0.00708080f, 0.02813295f, 0.04146511f, 0.08033394f, 0.00363737f, 0.15463966f, 0.10012561f, 0.07133321f, 
    -0.10740151f, -0.02882892f, 0.06450579f, 0.03052497f, -0.06221734f, 0.06246122f, 0.10193151f, 0.25753698f, 
    -0.13156702f, 0.11125810f, -0.07265046f, -0.09134503f, -0.10863803f, 0.11554123f, 0.06311116f, 0.03071965f, 
    -0.02204028f, -0.04933855f, 0.11896832f, 0.05053776f, 0.12257358f, 0.10288011f, -0.11966056f, -0.11784276f, 
    -0.06411288f, 0.01447592f, 0.19868901f, -0.08332188f, 0.07023209f, 0.07805604f, 0.02408467f, 0.07573669f, 
    -0.16946600f, 0.08192424f, -0.06293542f, -0.12019894f, 0.01151023f, -0.08559562f, -0.02623811f, -0.02340413f, 
    -0.09637756f, 0.12861486f, -0.06999569f, -0.27358922f, -0.05998204f, 0.24202274f, -0.05672428f, 0.13558425f, 
    0.00450135f, 0.20394824f, 0.08514266f, -0.17540820f, -0.09144804f, 0.13874140f, -0.04479366f, 0.27646351f, 
    -0.32620755f, 0.13720238f, -0.05428104f, -0.12887876f, -0.00839440f, -0.11304045f, -0.11442022f, 0.03442037f, 
    -0.04780499f, 0.01953366f, 0.05869262f, 0.00532095f, 0.03108579f, -0.33286369f, 0.05240586f, -0.06590170f, 
    -0.07560589f, 0.12555139f, -0.04925535f, -0.03578998f, -0.00112553f, -0.07888284f, 0.05139261f, -0.09565137f, 
    -0.01521252f, -0.22763537f, -0.09652644f, 0.01080919f, -0.03486541f, -0.01381183f, -0.05890535f, 0.00512088f, 
    -0.01461567f, 0.02682966f, -0.04069264f, -0.00549052f, 0.12726533f, -0.22611488f, 0.28438941f, 0.22158743f, 
    -0.09504821f, 0.06439809f, 0.05435659f, -0.08383232f, 0.09024651f, 0.04001321f, -0.03605641f, 0.01220005f, 
    0.01682794f, -0.03573539f, 0.10499075f, 0.10406228f, -0.00523069f, 0.09909257f, 0.00162605f, 0.01792393f, 
    -0.19274946f, -0.14602798f, -0.08394942f, -0.21885954f, -0.01247268f, 0.11674222f, -0.03395737f, -0.09036345f, 
    -0.02961324f, 0.02811358f, -0.11366269f, 0.03108708f, -0.12612887f, -0.09492306f, -0.09131800f, -0.06350728f, 
    -0.43605778f, -0.05240664f, -0.20813523f, 0.17566727f, 0.05594885f, 0.02342096f, 0.11480017f, 0.10029070f, 
    -0.07699225f, -0.10653345f, 0.03188024f, 0.20318772f, -0.14262648f, 0.02195344f, 0.05834214f, 0.01799916f, 
    0.02604491f, -0.05083415f, 0.16795044f, 0.03432546f, 0.03532647f, 0.07768262f, -0.05536643f, -0.16597027f, 
    -0.04223679f, 0.15233034f, -0.05993550f, 0.14897525f, -0.09541581f, 0.05761764f, -0.03152461f, 0.21345885f, 
    0.01693113f, 0.09901490f, 0.07211231f, 0.13087377f, 0.02695565f, -0.03256740f, 0.04258263f, -0.17703885f, 
    -0.08857472f, -0.09717132f, -0.05630073f, -0.02077511f, -0.20983727f, -0.07215214f, -0.13216981f, -0.30574074f, 
    -0.03638146f, -0.09206385f, 0.21953973f, 0.01151600f, -0.06590352f, 0.15170285f, 0.09006260f, 0.12575638f, 
    0.20790075f, -0.10785665f, 0.08159116f, -0.11892107f, 0.00826753f, -0.03462127f, -0.04397805f, 0.04271342f, 
    0.02529422f, -0.12168080f, 0.02978277f, -0.00891237f, -0.10215151f, -0.13294081f, -0.02946058f, -0.09819227f, 
    -0.03542260f, -0.19351737f, -0.07770022f, 0.05579617f, 0.05105121f, -0.22593905f, -0.02086179f, 0.14097799f, 
    -0.03156371f, 0.07440653f, -0.12411074f, -0.22501065f, -0.23150414f, -0.26138115f, 0.26472220f, -0.10198207f, 
    0.09332122f, -0.10287885f, -0.15050289f, -0.04411571f, 0.03518733f, 0.00320575f, 0.02775004f, -0.16185819f, 
    0.32944548f, -0.07722624f, 0.28169477f, -0.01820769f, 0.03953862f, -0.00843789f, 0.20275669f, 0.08398267f, 
    -0.08921613f, -0.04126316f, -0.06518568f, 0.13215579f, -0.31685713f, 0.02344383f, 0.01093668f, -0.01145108f, 
    0.06495446f, 0.09167498f, 0.03425744f, 0.07585136f, -0.03522134f, -0.01709413f, 0.11549242f, 0.16858445f, 
    -0.08231109f, 0.19721892f, -0.28223440f, 0.09628058f, -0.12082945f, 0.05080107f, 0.17754193f, -0.03893035f, 
    -0.00955875f, 0.01641105f, -0.03749061f, 0.06565018f, -0.11825613f, -0.29294911f, -0.08372939f, -0.00200120f, 
    -0.06458401f, -0.25607690f, -0.16734093f, -0.08652134f, 0.07295454f, 0.10431255f, 0.03961350f, 0.02077125f, 
    -0.24856354f, 0.33376783f, -0.16451021f, 0.04413862f, 0.00782294f, -0.03574484f, -0.09314652f, -0.05894819f, 
    0.09956713f, 0.04347283f, -0.13744146f, -0.15939122f, -0.15976578f, -0.05661098f, -0.11216830f, 0.11004494f, 
    0.07508709f, 0.00239190f, -0.13001738f, -0.09932000f, -0.07024304f, 0.06240967f, -0.00609460f, 0.12577586f, 
    -0.13491717f, 0.04902142f, 0.02326644f, -0.01022480f, 0.09506938f, -0.03698322f, -0.05859945f, -0.08323593f, 
    -0.18327433f, 0.02731524f, -0.16306230f, -0.20602158f, -0.13426337f, -0.23023920f, 0.02438316f, 0.22038333f, 
    0.02795070f, 0.06866314f, -0.03893361f, -0.03593492f, 0.07437244f, 0.04810002f, -0.01486710f, -0.00719490f, 
    -0.26165086f, 0.00128316f, -0.18874064f, 0.10966552f, -0.01949927f, 0.07894928f, -0.08871327f, 0.05961046f, 
    -0.06741001f, -0.02017015f, 0.09712137f, -0.00927397f, -0.01322702f, -0.11823773f, -0.29365769f, 0.23245184f, 
    0.09227944f, 0.08363595f, -0.00298293f, 0.12367208f, 0.06125701f, -0.01182824f, -0.12907499f, -0.03534334f, 
    -0.20437767f, 0.18789242f, 0.00461269f, 0.04695365f, -0.01966554f, 0.02145010f, 0.04408113f, -0.07668923f, 
    -0.12262973f, -0.03386670f, 0.06363426f, 0.01952361f, -0.05310407f, 0.10011144f, 0.11027258f, -0.08181248f, 
    -0.11578342f, 0.09129973f, 0.01986023f, 0.01972779f, 0.11794459f, -0.01621915f, 0.25762096f, 0.17633481f, 
    -0.03216582f, 0.08663256f, 0.14480446f, -0.20937800f, -0.00063062f, 0.03819551f, 0.10448583f, -0.05141313f, 
    -0.16843095f, -0.08399960f, -0.17144601f, -0.27366039f, -0.17940705f, 0.03092986f, 0.22038855f, -0.04405923f, 
    -0.04638351f, 0.07609323f, -0.24970034f, 0.18507920f, -0.05148005f, 0.04254751f, 0.15262394f, -0.01847934f, 
    -0.39880997f, 0.38896859f, -0.00939303f, 0.23949717f, 0.05415051f, 0.14679614f, -0.06350158f, 0.09408265f, 
    0.01668336f, 0.10329340f, 0.10589367f, 0.08477309f, -0.04350367f, -0.07059154f, -0.22217706f, -0.03928718f, 
    -0.13787831f, -0.04100047f, 0.02054399f, -0.09161571f, 0.03031748f, 0.06521300f, 0.08178463f, 0.12161774f, 
    -0.18807942f, 0.14356078f, 0.06501636f, 0.02668961f, -0.06742553f, -0.15847407f, -0.05188909f, 0.32796541f, 
    0.15623273f, 0.07381198f, 0.08588281f, -0.10108858f, 0.12761123f, -0.02451297f, -0.04119334f, -0.09967630f, 
    0.04935662f, -0.03024711f, 0.05763558f, 0.08087730f, -0.09842106f, -0.05819040f, -0.34972113f, -0.51968211f, 
    -0.19112891f, -0.25094232f, -0.02788184f, -0.09566666f, -0.10162470f, -0.07181310f, 0.06558580f, -0.06183411f, 
    -0.05153466f, 0.17341813f, 0.05770081f, 0.00457517f, -0.21128061f, 0.22323567f, 0.08649194f, 0.17392671f, 
    -0.01496782f, 0.03870004f, -0.04726174f, -0.06194995f, -0.02035396f, 0.04892144f, 0.01104722f, -0.02583044f, 
    -0.35855821f, 0.02714187f, -0.01126181f, -0.21625005f, -0.02160510f, 0.00007707f, 0.10185048f, -0.02353884f, 
    -0.13303973f, 0.03403436f, -0.03003816f, -0.01307549f, -0.12208627f, 0.03030389f, -0.12829450f, -0.18531871f, 
    -0.07614358f, -0.23426929f, -0.02176665f, 0.01199017f, -0.13804470f, -0.13612033f, -0.06948526f, -0.12338925f, 
    0.57010216f, -0.26846451f, 0.26485577f, -0.04491751f, 0.00034158f, 0.02665467f, 0.07254551f, 0.07433458f, 
    -0.02959642f, -0.20708326f, -0.20897013f, -0.02745199f, 0.27346113f, -0.03695784f, 0.22091916f, 0.33353397f, 
    -0.00931206f, 0.07865510f, 0.18311277f, -0.05494830f, -0.14959918f, 0.07895234f, 0.10676558f, 0.07786655f, 
    0.29500249f, -0.44520015f, 0.20712425f, -0.03613583f, -0.02649791f, 0.09071327f, 0.05151321f, 0.07430032f, 
    -0.09732931f, 0.03158525f, -0.06235965f, -0.14889650f, -0.50344127f, 0.00602007f, -0.24019712f, 0.01936744f, 
    -0.20309256f, 0.03151423f, -0.02665657f, -0.04210574f, -0.06728123f, -0.06588671f, 0.14495580f, 0.05426070f, 
    -0.02519394f, -0.27781910f, 0.05029792f, 0.13326307f, -0.06537221f, -0.02806303f, 0.10725971f, -0.13930073f, 
    0.01202577f, 0.05937918f, 0.11041976f, 0.04676025f, -0.13304417f, 0.05789030f, -0.12256406f, 0.14079009f, 
    0.04526393f, 0.00943542f, -0.19498217f, -0.00288781f, 0.01966663f, -0.00201635f, -0.01879139f, -0.17969449f, 
    -0.12936480f, 0.21847360f, -0.08623634f, 0.44022465f, 0.03134747f, -0.14588955f, -0.01956265f, 0.13707462f, 
    -0.05035406f, -0.06270772f, 0.01715968f, 0.26322162f, -0.06911884f, 0.14434665f, -0.28277948f, -0.09262203f, 
    -0.19292991f, -0.02773003f, 0.13088731f, -0.20354126f, -0.10966922f, 0.08658043f, -0.14168820f, -0.12555389f, 
    0.14665402f, 0.36342978f, 0.16942683f, 0.07441022f, 0.08165374f, -0.12833697f, 0.10535140f, 0.04979732f, 
    -0.02259787f, 0.10155647f, -0.02939485f, 0.09003013f, -0.35042265f, -0.10324468f, 0.16388239f, 0.13276812f, 
    0.05630678f, 0.02404658f, -0.00607622f, -0.14130306f, -0.14517322f, -0.03493569f, -0.21935037f, -0.09154563f, 
    0.11166757f, 0.14663468f, 0.08127079f, -0.11253152f, -0.00906422f, -0.06909230f, -0.00703665f, 0.00650061f, 
    -0.08114151f, 0.08143370f, 0.01908755f, -0.11127643f, -0.03911953f, -0.21747179f, 0.11975251f, 0.04796873f, 
    -0.04829979f, 0.06720226f, 0.09969279f, -0.09417836f, -0.03291780f, 0.00238382f, 0.04900482f, 0.03606983f, 
    -0.19845815f, -0.12752278f, 0.22453354f, 0.24821457f, 0.02660434f, -0.00039266f, 0.07431826f, 0.25110847f, 
    -0.19357227f, -0.07137200f, 0.05401631f, 0.00411048f, 0.19866967f, -0.22761494f, 0.23549660f, 0.12647039f, 
    -0.18597409f, -0.06621090f, 0.03362074f, 0.02139046f, -0.03009545f, -0.14334004f, 0.01970045f, 0.10126269f, 
    -0.02733980f, 0.28047585f, -0.03924919f, -0.14660357f, 0.02507171f, 0.01760169f, 0.01705124f, -0.09271802f, 
    -0.00458829f, -0.03106531f, -0.00386015f, -0.02243461f, -0.08977733f, -0.21977463f, -0.19005516f, 0.17713521f, 
    0.03786139f, -0.05005264f, 0.07711071f, -0.08470483f, -0.03210384f, 0.06439593f, -0.03268451f, -0.07337413f, 
    0.23055799f, -0.01314850f, 0.33832020f, 0.06177909f, -0.03179696f, -0.03614406f, -0.06127092f, -0.03118871f, 
    0.11689161f, 0.04072202f, 0.08470436f, 0.08548399f, 0.11320712f, -0.16232479f, 0.06824783f, 0.30070859f, 
    0.01983626f, -0.11086651f, 0.07805542f, 0.00664075f, 0.03150824f, 0.15081130f, 0.10769708f, -0.22368695f, 
    -0.05744806f, -0.04897057f, -0.10632310f, -0.03545515f, 0.10317118f, -0.09012949f, 0.03119635f, -0.01084602f, 
    0.03117078f, 0.03764551f, 0.03214872f, 0.01455468f, 0.35338965f, 0.06680747f, 0.60015184f, -0.10392215f, 
    -0.08114898f, 0.18477705f, -0.06955912f, 0.04741426f, -0.13216202f, -0.02624342f, -0.01594709f, -0.08228614f, 
    0.15409403f, 0.02313730f, 0.42248249f, -0.15782630f, 0.01136931f, 0.15815927f, 0.03014007f, 0.05412531f, 
    -0.10394058f, -0.00982898f, 0.15045798f, 0.02971349f, -0.18398221f, 0.02696833f, -0.00546241f, 0.04173368f, 
    -0.00439621f, 0.08636099f, 0.01455326f, -0.01152637f, -0.12912086f, -0.06021996f, 0.10175970f, 0.00295116f, 
    0.00970143f, 0.01248325f, 0.22686400f, -0.14559913f, 0.16356160f, 0.20483857f, 0.10205198f, -0.05163931f, 
    0.00503667f, 0.01841062f, 0.01781115f, 0.03690400f, -0.32062876f, 0.09807640f, -0.23328806f, 0.02537158f, 
    -0.13819362f, -0.00723115f, -0.08452766f, 0.14688689f, -0.30278611f, -0.10906639f, -0.08636987f, -0.24115618f, 
    0.20127030f, -0.09584758f, 0.17296882f, 0.01893227f, 0.06465917f, 0.12788239f, -0.04204395f, 0.03621836f, 
    -0.06387446f, 0.11151006f, -0.01865592f, -0.10880516f, 0.07876999f, -0.21042106f, 0.13536981f, -0.09012119f, 
    -0.00401279f, 0.02925658f, -0.06223203f, 0.04883916f, -0.19802351f, 0.05390429f, -0.13436300f, -0.27856413f, 
    -0.02708168f, 0.04579771f, -0.31128895f, -0.09219347f, 0.04080673f, -0.05511476f, 0.07970058f, 0.01708641f, 
    0.02805753f, 0.04802420f, -0.00532029f, 0.02522173f, -0.75485164f, 0.37602469f, -0.52695560f, 0.30542907f, 
    -0.04240306f, -0.14083996f, 0.25994346f, 0.03927495f, -0.03902160f, -0.11991818f, 0.02236478f, -0.10094915f, 
    0.24272372f, -0.10765637f, 0.02352206f, 0.11323512f, 0.00464686f, 0.02436948f, 0.01523987f, 0.13872322f, 
    -0.05843632f, -0.00814563f, 0.06964259f, -0.03924792f, -0.26686642f, -0.27541777f, -0.49992788f, -0.02194569f, 
    -0.05270612f, -0.27915218f, 0.10588191f, -0.10286088f, -0.00366279f, 0.14621077f, -0.09930498f, 0.00288980f, 
    -0.00887515f, 0.01258514f, -0.12500964f, -0.18037450f, -0.13222654f, -0.00770874f, 0.00166049f, -0.08077952f, 
    -0.00980235f, 0.00112924f, 0.02405685f, 0.00498026f, -0.05196649f, 0.20506267f, -0.12927683f, 0.30682200f, 
    -0.09597107f, 0.16817810f, -0.09878366f, 0.03906908f, -0.04715327f, 0.06719004f, 0.06967683f, 0.01541353f, 
    -0.12818804f, 0.21158457f, -0.27701154f, 0.19956291f, 0.02808241f, -0.05820777f, 0.05467224f, 0.01426009f, 
    0.15558098f, 0.01600227f, 0.13140725f, 0.05495279f, 0.21192247f, -0.14901984f, 0.31893152f, -0.00481741f, 
    0.00068892f, -0.12562400f, -0.00657540f, 0.09058139f, 0.05704548f, -0.01937815f, 0.04087713f, -0.03457483f, 
    -0.00063344f, -0.06795895f, -0.00028451f, 0.24676426f, -0.06671054f, 0.12666333f, -0.17073022f, 0.16634697f, 
    -0.11950171f, -0.01915786f, 0.11297439f, -0.25025252f, 0.07150078f, 0.09496423f, 0.04824669f, -0.35422775f, 
    -0.00932452f, -0.04229314f, 0.10043207f, -0.03259707f, 0.02553627f, -0.02054953f, 0.01113632f, 0.01962749f, 
    0.09648169f, -0.07243093f, 0.31942859f, -0.12431477f, -0.08959550f, -0.25166434f, -0.18905681f, -0.10057899f, 
    -0.00076795f, -0.08539389f, -0.02299831f, -0.11246350f, 0.21211316f, 0.08518558f, 0.06833915f, -0.13715078f, 
    -0.02195323f, 0.07103053f, -0.12188029f, 0.06263161f, 0.11313893f, 0.06959763f, 0.01629461f, 0.01766815f, 
    -0.02093088f, -0.04837766f, 0.08245190f, -0.24206249f, 0.02242271f, 0.02192638f, -0.14274390f, 0.09710740f, 
    0.08700797f, -0.02862889f, -0.13006499f, -0.12670067f, -0.15814421f, 0.05851468f, -0.12317308f, 0.07807004f, 
    -0.10323106f, 0.06769532f, -0.06379799f, -0.05965169f, 0.13788326f, 0.07331096f, -0.09532277f, -0.09891371f, 
    0.00496631f, 0.13565622f, -0.11794987f, -0.01428898f, -0.06624029f, 0.05921397f, 0.14657217f, -0.02030398f, 
    -0.11054262f, -0.01501263f, -0.02810217f, -0.10110921f, 0.33566782f, -0.31667486f, 0.31741542f, 0.15688102f, 
    0.04686916f, 0.02280843f, 0.11726361f, 0.07978873f, 0.03627973f, 0.02482120f, -0.04342907f, 0.17060602f, 
    -0.01184586f, -0.03521963f, 0.13762859f, -0.19722997f, 0.09910930f, 0.14964983f, -0.03317216f, -0.21683751f, 
    -0.06496838f, -0.08937362f, -0.01787473f, 0.00898603f, 0.27327767f, 0.17561339f, 0.10750068f, 0.04076761f, 
    -0.07544769f, 0.06157790f, -0.07418682f, 0.09138158f, -0.16194016f, -0.01136370f, 0.04441343f, -0.16449383f, 
    -0.06045632f, -0.19244470f, -0.00069974f, 0.13855138f, -0.04820618f, 0.04217013f, -0.10016339f, 0.03558215f, 
    0.03298365f, -0.11042412f, 0.11188136f, 0.01461864f, -0.12006394f, -0.46167257f, -0.13344948f, -0.08144312f, 
    -0.12774168f, 0.04416667f, -0.20345069f, -0.04352009f, 0.00590500f, 0.02543101f, -0.06577624f, -0.09671486f, 
    0.03044961f, -0.17193554f, -0.35790896f, 0.36959994f, -0.01393539f, -0.03474750f, -0.16998851f, 0.11274106f, 
    0.04330985f, 0.03881086f, 0.08353621f, 0.12275168f, -0.00765998f, -0.08676608f, 0.10162442f, -0.14309256f, 
    -0.09566084f, -0.08697266f, -0.09295183f, -0.11677232f, 0.10118216f, -0.02503778f, 0.02882293f, -0.02389715f, 
    -0.31661719f, -0.11498114f, 0.04152666f, 0.19676559f, 0.19067341f, 0.01807030f, 0.01420555f, 0.09651249f, 
    -0.12624826f, 0.01353550f, 0.13968503f, 0.09384491f, -0.09842283f, -0.46780884f, 0.03599527f, 0.08158354f, 
    -0.25104570f, -0.03706286f, 0.03056130f, -0.06343365f, 0.02978068f, 0.02354045f, 0.15028267f, 0.01649889f, 
    -0.26073101f, -0.21888217f, 0.24524446f, 0.30365410f, -0.22677438f, 0.15226239f, -0.11526970f, -0.11036113f, 
    0.05337414f, 0.02261920f, 0.03972843f, 0.04426651f, -0.61408144f, 0.04050769f, -0.11264007f, -0.09493242f, 
    -0.06192728f, 0.11160950f, 0.01386312f, -0.07365042f, -0.02637736f, 0.05198646f, 0.09742182f, 0.10077460f, 
    -0.39044845f, 0.59696788f, -0.27705115f, 0.22832175f, 0.09090140f, -0.15421748f, 0.08953343f, -0.10006665f, 
    0.02844277f, -0.02218609f, 0.04166659f, 0.05996193f, 0.14298283f, -0.15228435f, 0.18857983f, -0.08045240f, 
    0.10246667f, -0.04110861f, 0.03442941f, 0.10624652f, -0.07277074f, -0.00772545f, -0.06349450f, -0.18789734f, 
    0.12861048f, -0.07218359f, 0.07550164f, -0.10284947f, 0.09205003f, 0.00216468f, -0.13785289f, 0.07529921f, 
    -0.01709720f, 0.02961921f, 0.15968281f, 0.21218191f, 0.10952158f, -0.06589948f, 0.04847242f, 0.19140328f, 
    0.08050735f, 0.00500141f, 0.00405934f, 0.05947764f, 0.00979808f, 0.02529839f, -0.14122507f, -0.02215330f, 
    -0.51898301f, 0.08536429f, -0.30833304f, 0.22225720f, 0.14335479f, -0.22144319f, 0.11487683f, -0.24629284f, 
    0.05099821f, -0.08831176f, 0.05988049f, 0.08371629f, 0.01513783f, 0.01326541f, 0.00415617f, -0.06586592f, 
    -0.00366768f, 0.01613550f, 0.00555631f, 0.00833027f, -0.00855289f, 0.11222976f, -0.06078066f, -0.15713963f, 
    -0.22424366f, -0.13155361f, 0.23156121f, 0.07586586f, 0.12352947f, -0.00439715f, 0.22851926f, 0.03793065f, 
    -0.16250396f, 0.04010104f, -0.00986202f, -0.01871373f, -0.46038747f, -0.00168873f, -0.34803754f, -0.09550118f, 
    -0.05230446f, 0.04053153f, -0.05546381f, -0.09042821f, -0.06319746f, 0.09452858f, -0.01070943f, 0.02097573f, 
    -0.05581665f, -0.25391275f, 0.11418696f, 0.13751315f, -0.28208023f, 0.01511037f, -0.10619189f, -0.29700571f, 
    0.03443114f, 0.04214444f, -0.01740598f, -0.03840629f, -0.30366519f, 0.24819687f, 0.08112963f, 0.44938776f, 
    0.07524984f, -0.04104992f, -0.08630695f, 0.04919731f, -0.18660848f, 0.06319769f, 0.12384759f, 0.07210148f, 
    -0.07183670f, 0.33065522f, -0.29228231f, 0.00719523f, 0.13801171f, -0.14558323f, 0.07358001f, -0.05474365f, 
    0.05410498f, 0.08829652f, 0.02481856f, -0.01529686f, 0.07865478f, 0.08504805f, 0.03286707f, 0.11547498f, 
    -0.08857337f, 0.08629821f, -0.03894338f, 0.02317429f, -0.07611271f, 0.08341888f, 0.02387978f, 0.01276234f, 
    -0.27342996f, -0.00108865f, 0.13106953f, -0.29458842f, 0.10794786f, 0.18195474f, -0.12657739f, -0.02006767f, 
    -0.02760523f, 0.17264439f, 0.25242892f, 0.07700105f, -0.36608765f, 0.37321550f, 0.19349401f, -0.15374278f, 
    -0.23540489f, 0.02450944f, 0.18620834f, -0.07667849f, -0.01085383f, -0.11920801f, -0.10408925f, 0.03698485f, 
    0.01597253f, -0.04969637f, -0.04763749f, -0.67262042f, 0.02899745f, -0.06083336f, 0.04717615f, 0.03853877f, 
    0.03957120f, 0.00561615f, 0.08002599f, -0.06244968f, -0.47749043f, -0.18019417f, -0.42451862f, 0.19956124f, 
    0.23160772f, 0.21880567f, 0.05066026f, -0.09003003f, -0.01894830f, 0.00353210f, 0.14322366f, -0.00196573f, 
    0.07444398f, -0.01384242f, 0.14985675f, 0.04746163f, 0.04653800f, 0.03917604f, -0.07878865f, 0.06286617f, 
    -0.04260186f, 0.03840810f, -0.06043497f, -0.01284945f, -0.15968072f, -0.07473030f, -0.13722554f, 0.23681849f, 
    -0.04404673f, -0.00187364f, 0.10919350f, 0.21824300f, 0.06566488f, 0.08455251f, -0.10789163f, -0.06163634f, 
    -0.37598264f, 0.01726874f, 0.23985811f, 0.27275404f, -0.12239337f, 0.12940854f, 0.09586449f, -0.21694782f, 
    -0.28936815f, -0.10518367f, 0.15574779f, -0.10827465f, 0.48602012f, -0.31762931f, 0.27227479f, 0.02890567f, 
    0.01063365f, -0.13484411f, 0.06441662f, 0.18839598f, -0.04058750f, -0.02153705f, -0.05089601f, -0.17768605f, 
    -0.36384726f, -0.34657779f, -0.20839339f, 0.39545971f, 0.22820343f, 0.08468719f, 0.07560767f, -0.16114156f, 
    -0.10325137f, -0.12563165f, -0.01686091f, 0.17002210f, -0.46681830f, 0.01061580f, -0.51043993f, 0.33745062f, 
    -0.00418711f, 0.14494027f, 0.08492312f, -0.09033228f, -0.01189655f, 0.10620973f, 0.14916076f, 0.06487484f, 
    -0.43404144f, -0.05281493f, -0.32020706f, 0.02310389f, 0.07424274f, -0.03355194f, -0.05244270f, 0.01694284f, 
    -0.12832196f, 0.00838372f, -0.13564222f, -0.07792287f, 0.18133210f, -0.07312183f, 0.34011373f, 0.03374219f, 
    0.01316667f, -0.13915452f, -0.05761638f, -0.00488375f, 0.01293357f, -0.11809912f, -0.13177316f, -0.06592759f, 
    0.26038936f, 0.11738950f, 0.42788023f, -0.07753333f, -0.05015310f, -0.03246913f, -0.08473068f, -0.00458164f, 
    -0.13247579f, -0.08342165f, 0.20907708f, -0.00661387f, -0.15684575f, -0.08477820f, 0.22727107f, -0.36558765f, 
    -0.06673435f, 0.05669694f, -0.01559860f, 0.09273771f, -0.05100450f, 0.09652631f, 0.13542558f, -0.03894500f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.16404960f, 0.10075106f, 0.05462860f, -0.07807450f, -0.05287309f, 0.06984468f, 0.06770463f, -0.13713868f, 
    0.04319225f, 0.02845367f, 0.00500135f, -0.03842434f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
