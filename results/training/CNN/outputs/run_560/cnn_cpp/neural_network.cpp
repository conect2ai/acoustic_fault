#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.84498143f, -1.67871416f, 0.66170251f, 1.40022469f, 0.87205768f, -0.66589677f, 0.46515554f, 0.08054657f, 
    -0.25665286f, 0.50464344f, 0.40712854f, 0.00891379f, 0.11801097f, -0.03246724f, -0.05308457f, -0.49422893f, 
    0.09987558f, 0.03899771f, 0.17478766f, -0.00274052f, -0.10012163f, 0.21684080f, -0.06658414f, -0.08183458f, 
    0.32091042f, -1.61987185f, -1.04723513f, 0.50029504f, -0.28894806f, -0.67608255f, -0.11618516f, -0.99198020f, 
    0.85257310f, 0.27744192f, -0.54629779f, 0.06613852f, 0.04005704f, 0.18849573f, 0.38621867f, -0.23985220f, 
    -0.40767410f, 0.14768921f, -0.28842232f, -0.23552746f, 0.02552324f, 0.27779651f, 0.21063446f, 0.28804889f, 
    0.38462356f, 0.19928499f, -1.41942382f, 1.22641027f, 0.68166369f, -0.54247123f, 1.05451322f, 0.02771678f, 
    0.70380419f, 1.10476887f, -0.04871905f, 0.32368693f, 0.12848900f, -0.02392860f, -0.08466739f, -0.13657293f, 
    -0.18235935f, 0.32217324f, -0.22855322f, -0.27383408f, -0.03767486f, -0.03572040f, 0.46588013f, 0.38665190f, 
    0.00019111f, 0.39448038f, 0.23554455f, 1.14722300f, 0.75990349f, 1.06509566f, 1.04436052f, 0.80609453f, 
    0.74999619f, -0.84194106f, -0.80976248f, -0.38391292f, -0.37702966f, 0.45747378f, 0.53666705f, -0.27400208f, 
    0.04636999f, 0.05194578f, 0.63967884f, -0.25798956f, 0.00391585f, 0.08643228f, 0.21127543f, -0.00941447f, 
    0.22195983f, 0.52119207f, -0.38339674f, 0.11733335f, -0.78915423f, -1.51640439f, -1.37787664f, -0.79231387f, 
    -0.51915324f, -0.21841028f, 1.44904768f, 1.10702813f, 0.28411821f, 0.62483186f, 0.07833035f, -0.08131672f, 
    -0.26465699f, -0.30508557f, -0.53612059f, -0.04390128f, 0.19873169f, -0.03978447f, -0.09800489f, -0.21613045f, 
    -0.22542956f, -0.03314214f, 0.03064366f, -0.19249932f, -0.10214853f, 0.12803978f, -0.73566139f, 1.40607095f, 
    -0.11667687f, -0.97248989f, 0.21197730f, -0.57747215f, 1.46574533f, 0.06987721f, 0.33156177f, -0.37118793f, 
    -0.51227039f, -0.22011979f, -0.02246276f, 0.13118868f, 0.39152211f, 0.49516419f, -0.19388759f, -0.39388871f, 
    -0.44020319f, -0.04678847f, 0.18574178f, 0.14805882f, -0.13578805f, -0.19833054f, 0.57837850f, 0.86214030f, 
    1.10763359f, 0.52342409f, 0.04035159f, -0.16378927f, -0.18442287f, -0.43519223f, -0.19522354f, -0.19784321f, 
    -0.30828094f, -0.30552417f, -0.30173710f, -0.06458825f, 0.66865212f, 0.18577304f, -0.22034846f, 0.13302246f, 
    -0.41612798f, 0.40307021f, 0.57078916f, 0.49511096f, -0.16756392f, 0.34254932f, 0.98070496f, 1.78468513f, 
    0.03456863f, -1.23659742f, 0.88319564f, -0.40823308f, -0.87694418f, 0.58596414f, -0.25281131f, 0.31917214f, 
    0.26418975f, 0.34480524f, -0.08019430f, 0.12001453f, -0.51724565f, 0.09491511f, -0.25439644f, -0.40121984f, 
    -0.42104682f, -0.28463262f, -0.26327929f, -0.20723134f, -0.10816869f, -0.16763748f, -0.18597600f, -0.24704863f, 
    -0.77686137f, 0.02855565f, 0.58494210f, -1.05888093f, -0.15497045f, -1.04691803f, 0.26343137f, -1.37661421f, 
    -1.36782646f, -0.32730663f, 0.15595247f, 0.73726386f, -0.14149067f, -0.43309161f, -0.35943535f, 0.34276330f, 
    -0.22700907f, 0.24504584f, 0.12464119f, -0.22557962f, 0.01126071f, -0.16242468f, -0.05270736f, -0.28656143f, 
    0.08270740f, 1.55785799f, 0.54915082f, 0.66478777f, -1.38403761f, -1.07433414f, -0.04366483f, -0.44861707f, 
    0.36608952f, -0.22546066f, 0.52380794f, 0.55963731f, 0.05764586f, 0.20295687f, 0.17752039f, -0.33664006f, 
    0.01036839f, -0.24930309f, 0.22150946f, 0.20860837f, 0.01470810f, 0.31504682f, 0.38291505f, 0.06423539f, 
    0.23466788f, 0.15811029f, 0.99109823f, 0.95350754f, 0.60876948f, 1.09131145f, 0.07423485f, 0.64484036f, 
    0.38758126f, 0.17540558f, 0.08280437f, 0.50801498f, -0.30363902f, 0.13933285f, -0.27091047f, -0.33663699f, 
    -0.65749741f, -0.45172229f, 0.16783875f, 0.36002949f, -0.48515832f, -0.50951105f, 0.64520228f, 0.35833848f, 
    -0.35137954f, 0.36348891f, -0.20667568f, -1.46815991f, -1.33369625f, 0.37705967f, 0.88681626f, 0.04246769f, 
    0.74405444f, 1.06161463f, -0.63135278f, 0.45077416f, -0.54000175f, -0.38210139f, 0.39646742f, -0.26833218f, 
    0.44912857f, 0.30371779f, 0.10077120f, 0.23509116f, -0.33287609f, -0.30688182f, -0.00715293f, 0.06858512f, 
    0.29668549f, 0.59388053f, 0.27729946f, -0.11126292f, -1.30929625f, 1.10175765f, 0.75656676f, -1.47211945f, 
    -0.88385594f, 1.05069029f, -0.06211849f, -0.74910706f, 0.70747310f, -0.27755889f, -0.26733342f, -0.06068327f, 
    -0.29434153f, 0.08508799f, 0.14320071f, -0.07385631f, 0.19264683f, -0.18594389f, 0.00086972f, 0.01004314f, 
    0.20809309f, 0.22337796f, 0.23218791f, 0.21657550f, 0.14548120f, -0.35367841f, 0.68172026f, 1.26616526f, 
    1.31875694f, -1.49358499f, -0.27220270f, -0.08020987f, 0.23980094f, -0.06358238f, 0.00376607f, 0.27077731f, 
    0.27900305f, 0.08693784f, 0.39270398f, 0.16534962f, -0.02284375f, 0.10904753f, 0.02342911f, 0.06840831f, 
    -0.16374217f, -0.46804374f, -0.11695892f, -0.14301586f, 0.05599051f, -0.32417303f, 1.05765557f, 0.90082175f, 
    0.24875066f, 1.63485563f, 1.17548704f, 0.34528738f, 0.43704545f, 0.65777409f, 0.10345642f, 0.65149647f, 
    -0.86507773f, -0.21420260f, -0.18317690f, 0.47736341f, 0.22374268f, 0.03358127f, 0.12922473f, 0.39587012f, 
    0.37290278f, 0.23015028f, -0.22778046f, -0.00391898f, -0.62160695f, -0.30146262f, 0.12417302f, 0.45836404f, 
    0.64369476f, 0.33650392f, 0.26211789f, 0.41416058f, -1.50612462f, -0.72962511f, -0.36336941f, -0.72204590f, 
    -0.56488198f, 0.07509998f, 0.08539005f, -0.10564871f, 0.77024376f, -0.15410264f, -0.25161910f, 0.21734078f, 
    -0.10415561f, -0.12018538f, 0.29293233f, 0.21150096f, -0.22467525f, -0.15419374f, 0.31806475f, -0.01762409f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.04785668f, 0.49758291f, 0.18138607f, 0.15541054f, 0.22453816f, 0.20930535f, 0.34788013f, 0.27422252f, 
    0.39023569f, 0.14441815f, 0.34639293f, 0.37771425f, 0.18854983f, 0.24621019f, 0.51691788f, 0.36871469f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.56482357f, -0.11160430f, -0.46780679f, 0.58382547f, -0.35165545f, -0.03239059f, 0.00653633f, -0.00633716f, 
    -0.12974524f, 0.05614071f, -0.17366250f, 0.04187260f, -0.65065587f, -0.00051444f, -0.10586056f, 0.06565074f, 
    -0.00465605f, 0.10479323f, -0.14722008f, -0.14113933f, 0.15819797f, -0.14322934f, -0.13675116f, -0.11278414f, 
    -0.16460375f, 0.09484188f, 0.46357086f, -0.31767881f, -0.16532299f, 0.00271152f, 0.17380621f, -0.22841084f, 
    -0.11215362f, -0.17854409f, 0.16256556f, -0.21146399f, 0.27443898f, -0.40542269f, -0.00595800f, -0.08654208f, 
    -0.19820437f, -0.02267835f, -0.16532502f, 0.12816355f, 0.03590796f, 0.02245604f, -0.01015389f, -0.03443838f, 
    -0.05128187f, 0.51311833f, 0.04326501f, -0.79064357f, 0.16460930f, 0.13870302f, -0.06133872f, 0.00733831f, 
    -0.03370535f, -0.01510690f, -0.05512922f, 0.15265752f, 0.04127978f, -0.05035214f, -0.01683113f, 0.14807454f, 
    -0.23482056f, -0.00102691f, 0.12232485f, -0.01502922f, -0.14124468f, 0.09545199f, -0.08838656f, -0.05734016f, 
    0.14810213f, 0.16435154f, 0.04912172f, -0.16599545f, -0.09627880f, -0.17822386f, 0.06799169f, -0.02658508f, 
    -0.14200224f, 0.07549230f, -0.19169529f, 0.09595829f, -0.08150923f, -0.19712304f, 0.06467688f, 0.39242047f, 
    -0.16663210f, -0.23712230f, -0.23180000f, 0.10681450f, 0.01589015f, -0.08465495f, -0.02607105f, 0.18751785f, 
    -1.21534848f, -0.17341881f, 0.34463409f, 0.05034302f, 0.00190300f, 0.06084254f, 0.02281415f, 0.18265679f, 
    0.07381948f, 0.09280730f, -0.17755251f, -0.04599886f, -0.37137347f, 0.06142209f, -0.15532416f, -0.62501597f, 
    -0.02761854f, -0.07618555f, -0.13329925f, -0.07957275f, -0.01307938f, -0.00848946f, -0.24564613f, -0.04802051f, 
    0.03400736f, 0.17919253f, -0.17417717f, 0.36097014f, -0.22397721f, -0.05700012f, 0.10782470f, -0.01644430f, 
    -0.14874417f, 0.07505035f, -0.30112365f, 0.09048484f, -0.52087325f, 0.10854305f, 0.20733817f, 0.15340355f, 
    0.09696276f, 0.08277597f, -0.03581263f, 0.05571084f, 0.11883687f, 0.00336787f, 0.07366364f, -0.04451602f, 
    0.04554010f, 0.08364862f, 0.24891493f, -0.23026937f, -0.08738277f, 0.04202963f, 0.00699948f, -0.08880592f, 
    0.06387664f, -0.03992433f, -0.02448885f, 0.12885913f, -0.12918065f, 0.32478875f, -0.43710619f, 0.54132563f, 
    0.03766213f, 0.03565163f, 0.08240134f, 0.08335070f, 0.05000068f, 0.01859946f, 0.02266152f, 0.09694432f, 
    0.35139269f, -0.21920185f, -0.07605629f, 0.43419352f, -0.25652638f, -0.08315162f, 0.02202146f, 0.02885242f, 
    -0.01202904f, 0.05435362f, 0.06954365f, 0.03086830f, 0.47261381f, 0.22451290f, 0.01042917f, 0.02722517f, 
    -0.10185371f, -0.13817200f, -0.17190620f, -0.06158758f, -0.13751166f, -0.14665848f, 0.04379642f, -0.22674045f, 
    -0.09785718f, -0.31658211f, 0.11042116f, 0.28984886f, 0.00430669f, 0.08878069f, -0.05151110f, 0.16000082f, 
    0.17541468f, -0.15575227f, 0.06223384f, -0.28010073f, -0.37103704f, 0.20589393f, -0.02003461f, 0.06667215f, 
    -0.14639425f, -0.31143227f, -0.02714344f, 0.13832667f, 0.05795754f, -0.13945477f, -0.12437648f, 0.07949956f, 
    -0.08657935f, 0.16460307f, -0.09809396f, -0.25934762f, -0.05748331f, 0.21812664f, -0.01619245f, 0.18208484f, 
    0.15913059f, 0.19067778f, 0.01925960f, 0.17585902f, 0.13647662f, -0.09627482f, 0.34290364f, 0.23022595f, 
    -0.16754188f, -0.12507345f, 0.05988347f, -0.09015777f, -0.05375327f, -0.08188745f, -0.05100703f, 0.13136095f, 
    0.54011995f, -0.22021291f, -0.18739165f, -0.17151740f, -0.04682368f, -0.09969924f, -0.08718628f, -0.08766285f, 
    0.14584997f, -0.21215548f, -0.03632837f, -0.07458214f, -0.70933986f, 0.30983517f, -0.11918470f, -0.11028673f, 
    -0.15161751f, -0.16444540f, -0.10746535f, -0.18340723f, 0.10164566f, 0.00861839f, 0.08786356f, -0.42421219f, 
    -0.03264053f, 0.05713732f, 0.04023507f, 0.21378638f, -0.37186545f, 0.04868236f, 0.21403348f, 0.03098113f, 
    -0.08362411f, 0.07289530f, 0.16011734f, 0.24930708f, 0.79379237f, -0.44261158f, -0.02679972f, -0.03476863f, 
    -0.18369718f, -0.12385498f, -0.16878404f, 0.04397591f, -0.18284807f, 0.10634523f, -0.48290923f, -0.05630269f, 
    -0.12097616f, 0.08386309f, -0.39957705f, -0.11489371f, 0.04984764f, 0.07219026f, -0.01134141f, 0.05660599f, 
    0.16960491f, 0.04780610f, 0.14649758f, -0.13388069f, 0.36483774f, 0.31243253f, -0.15135151f, -0.24922259f, 
    0.10537599f, -0.09883863f, 0.12252226f, 0.07401246f, 0.10320591f, -0.07433307f, 0.18853208f, -0.08528664f, 
    0.12376110f, 0.22485264f, 0.17622136f, 0.41600195f, -0.16753118f, 0.06906947f, 0.07319662f, -0.08147477f, 
    0.10324229f, -0.14810802f, -0.04153926f, 0.01819052f, 0.07421567f, -0.02600594f, -0.66032892f, -0.08787533f, 
    -0.02959971f, 0.08968311f, 0.07705223f, -0.20916915f, -0.10206484f, 0.11291971f, -0.01329695f, 0.23238935f, 
    -1.22127008f, -0.31991738f, -0.04754907f, -0.24248704f, 0.05945533f, -0.21385328f, 0.10884900f, 0.01828336f, 
    0.03881504f, 0.07510611f, -0.05309631f, -0.15662400f, -0.23409443f, 0.06424059f, -0.09424790f, 0.08027864f, 
    -0.06679004f, -0.09539814f, -0.01932892f, -0.22678228f, -0.15084782f, -0.08798277f, -0.12145078f, 0.20717810f, 
    0.65686661f, 0.08307372f, -0.00270688f, 0.45897406f, -0.01506656f, 0.08987705f, -0.10369125f, 0.00988190f, 
    0.02575569f, -0.09775227f, -0.02147651f, -0.24967584f, -0.19658655f, -0.17522453f, -0.19199200f, -0.16691029f, 
    0.12372100f, -0.07043948f, -0.02973498f, 0.07882179f, 0.12405953f, 0.09372278f, 0.07686549f, -0.01427501f, 
    0.44428626f, 0.11396380f, -0.11273884f, 0.26135519f, 0.03608065f, 0.06196680f, 0.08650591f, 0.02917411f, 
    -0.21771669f, 0.11899385f, -0.16172792f, -0.01954450f, -0.56193382f, 0.04594778f, -0.13957463f, -0.30413595f, 
    -0.21043548f, -0.21655363f, -0.36767700f, 0.00216405f, 0.16688502f, -0.01441838f, -0.02291032f, -0.04900379f, 
    0.88430494f, -0.22885363f, -0.09805486f, 0.20410731f, 0.02141018f, 0.07265114f, 0.03209763f, -0.25977820f, 
    0.05815456f, -0.08351164f, -0.09972373f, 0.00988330f, 0.15796651f, -0.00282035f, 0.05081406f, -0.04288220f, 
    0.08246639f, 0.08104555f, -0.03873104f, -0.18066001f, 0.09977754f, -0.09951666f, 0.02862188f, -0.18362270f, 
    0.47396883f, 0.18408161f, 0.38519496f, 0.67112762f, -0.24128692f, -0.07405778f, 0.07665294f, 0.31475449f, 
    -0.09762659f, -0.00055812f, 0.08449145f, -0.02677445f, -0.29665971f, 0.31931642f, 0.05396743f, 0.06622022f, 
    -0.09623566f, -0.04132220f, -0.02610698f, 0.05057992f, -0.15076818f, -0.20938303f, -0.03440739f, -0.23687990f, 
    -0.27041826f, -0.07616404f, -0.22167489f, -0.15552233f, 0.09042364f, 0.19981918f, -0.13745125f, -0.18056750f, 
    0.02695517f, 0.03866027f, -0.12779741f, 0.07240581f, 0.20165311f, -0.08745082f, -0.12836498f, -0.21651167f, 
    0.08224640f, -0.08884279f, 0.24492128f, 0.18088716f, -0.08696599f, 0.23606962f, 0.16066176f, -0.11477784f, 
    0.46636122f, -0.20074081f, -0.70632142f, -0.38912997f, 0.02137652f, -0.08898859f, -0.19080561f, -0.08059853f, 
    -0.04799657f, -0.13206817f, -0.05107202f, -0.35026643f, -1.04682517f, 0.13414605f, 0.02647211f, -0.15141888f, 
    -0.13647471f, -0.02184429f, 0.09924650f, -0.04399553f, -0.34794319f, -0.01700579f, -0.07921226f, 0.06738668f, 
    0.07886561f, 0.04160854f, -0.09647592f, -0.14290485f, 0.07216779f, 0.00762651f, 0.03526634f, 0.05698993f, 
    -0.06463134f, 0.17955564f, 0.02217102f, 0.05491406f, 0.93157268f, -0.53587592f, -0.00037691f, -0.11264659f, 
    -0.21565300f, -0.12877506f, -0.26264542f, -0.06454971f, 0.05652502f, -0.08301996f, -0.00215141f, -0.00889711f, 
    0.34001157f, 0.13647039f, -0.44461647f, -0.24898839f, 0.09051341f, 0.09516221f, -0.03829259f, -0.00379194f, 
    -0.26677433f, -0.01015065f, 0.00925959f, 0.01545435f, 0.13286181f, -0.08467174f, -0.48114139f, -0.33801100f, 
    -0.37472495f, 0.22409396f, -0.15863286f, -0.01770311f, -0.05480990f, 0.17919062f, -0.18563196f, -0.16366270f, 
    0.07702319f, -0.17484216f, 0.13946578f, -0.21459480f, 0.20890021f, 0.13874540f, 0.11431307f, -0.02898225f, 
    0.00604505f, -0.05066878f, -0.06210166f, 0.22771421f, -0.23290482f, 0.20615157f, -0.52287495f, -0.20782922f, 
    0.09782960f, 0.15829401f, 0.03174210f, -0.27203569f, -0.18424208f, 0.07793576f, 0.02154758f, 0.01342242f, 
    -0.57764983f, 0.08821107f, 0.05124887f, 0.12939993f, -0.25299037f, 0.12727441f, 0.15713078f, -0.17502679f, 
    -0.10880602f, 0.10816604f, -0.10636519f, -0.00155075f, 0.55059665f, 0.00952760f, 0.07270548f, -0.12132188f, 
    -0.09766366f, -0.11798895f, -0.06726055f, -0.05037616f, -0.09975526f, -0.08631428f, 0.20173998f, 0.07111298f, 
    -0.40597159f, 0.41884267f, -0.00036160f, -0.00360141f, 0.19993930f, -0.07798186f, -0.21467608f, -0.07235259f, 
    0.07183978f, -0.02707294f, -0.16430955f, -0.02000135f, 0.32888916f, -0.54585218f, -0.21914019f, 0.55752861f, 
    -0.06012319f, 0.08953695f, -0.14759278f, 0.02292005f, -0.03569133f, -0.19481058f, -0.06094136f, -0.39973736f, 
    -0.07310888f, -0.35396615f, -0.06516917f, -0.18226960f, -0.25575739f, -0.08544228f, 0.10889455f, 0.02979318f, 
    -0.18969929f, 0.12865774f, 0.01618384f, 0.11161920f, 0.19688675f, -0.21674013f, 0.21365725f, -0.14518419f, 
    0.21167731f, 0.18264586f, 0.17817125f, 0.24140160f, -0.14115340f, 0.36815909f, 0.04347293f, -0.00427851f, 
    -0.50151837f, -0.31706443f, -0.32428953f, -0.07864118f, -0.03083359f, -0.25537807f, -0.12641919f, -0.04901974f, 
    0.04989084f, -0.20126131f, -0.10936297f, -0.02532711f, 0.20240268f, -0.51655877f, 0.14017144f, -0.09234063f, 
    -0.07694757f, 0.09583155f, 0.12699924f, 0.07270537f, -0.03762922f, 0.14951855f, 0.23850368f, -0.02303093f, 
    -0.18980542f, 0.71564239f, 0.26931110f, 0.36583835f, 0.11316959f, 0.02125181f, 0.04334792f, 0.06655262f, 
    0.00163030f, -0.08311218f, 0.07731952f, -0.00391805f, -0.36586481f, -0.52509558f, -0.02149763f, 0.15393472f, 
    -0.08614194f, -0.07282552f, -0.10045405f, 0.14660613f, 0.04814686f, 0.30718398f, -0.03390597f, 0.17848772f, 
    -0.51099575f, -1.02918661f, -0.47457066f, -0.09061248f, -0.21331616f, 0.03370786f, -0.09322312f, -0.06985044f, 
    -0.19215274f, 0.02297387f, -0.04099611f, 0.00346557f, -0.02048875f, 0.36454478f, -0.00464428f, 0.18682556f, 
    -0.10590364f, -0.20494810f, -0.15499803f, 0.03228422f, -0.06679881f, -0.07763986f, 0.14355150f, -0.17361502f, 
    0.68119913f, 0.16140461f, 0.37012842f, -0.27250716f, 0.15982451f, 0.00207626f, 0.09339706f, 0.17422353f, 
    -0.02120010f, -0.17052339f, -0.20866176f, 0.00769536f, -0.77308720f, 0.02314391f, 0.06779737f, 0.12014689f, 
    0.05037043f, 0.09504943f, 0.29080725f, 0.15966932f, -0.12775104f, -0.00116271f, -0.01061977f, 0.11662483f, 
    -0.67816871f, -0.70655185f, -0.27942660f, 0.11498322f, -0.22952890f, -0.08554680f, 0.05510383f, -0.18051569f, 
    0.15302855f, -0.19409385f, 0.21945044f, 0.05122400f, -0.06861401f, -0.02928316f, 0.27560583f, 0.09886757f, 
    -0.03154190f, 0.20454727f, 0.10334175f, -0.15061890f, 0.09464825f, -0.16401610f, 0.04622044f, -0.09434256f, 
    -0.71319222f, 0.16587913f, -0.00220217f, -0.25357735f, -0.09457842f, 0.00764923f, 0.04203890f, -0.04032998f, 
    0.16247195f, 0.01396514f, 0.05329961f, -0.16596927f, 0.42648548f, 0.18998723f, -0.11220262f, -0.31045449f, 
    0.09317971f, 0.09080406f, -0.16341271f, 0.17251171f, -0.01625014f, -0.19888270f, -0.11345095f, -0.01403115f, 
    0.32739618f, 0.29394931f, -0.56399053f, 0.05051751f, -0.23985450f, -0.18613592f, 0.05156376f, -0.04706297f, 
    -0.18080261f, -0.17365608f, -0.03577715f, -0.21328346f, -0.35621989f, 0.10807988f, 0.30777720f, -0.08836723f, 
    -0.05950222f, -0.02937819f, -0.13694565f, 0.13921241f, 0.25231448f, -0.31753835f, 0.08037845f, -0.06099005f, 
    -0.88865006f, 0.00043016f, 0.13991462f, 0.48133415f, 0.08300913f, 0.16775122f, 0.14986511f, 0.05916443f, 
    0.05266705f, 0.11589754f, 0.28791505f, 0.09503876f, 0.09240477f, -0.48946071f, 0.23194028f, -0.19755413f, 
    0.08828753f, 0.15481898f, -0.24064198f, 0.02047029f, 0.11075903f, 0.11657062f, -0.23375045f, 0.17935176f, 
    -0.01841574f, 0.19996431f, 0.38293791f, -0.01475394f, -0.06173766f, 0.12938721f, -0.11474964f, -0.19993393f, 
    0.27356455f, -0.14255716f, -0.05054121f, -0.08424652f, -0.03464577f, -0.04453959f, 0.03200665f, 0.01458964f, 
    -0.13470078f, 0.20139116f, 0.15979145f, -0.12793918f, -0.23163411f, -0.04803444f, 0.00024396f, 0.15240180f, 
    -0.03384269f, -0.09257738f, 0.55465031f, -0.06992191f, -0.01052148f, 0.03227416f, 0.14446896f, 0.01738678f, 
    0.04010137f, 0.09818983f, 0.01009307f, 0.15133265f, -0.04747519f, -0.41168922f, 0.32134879f, -0.34542978f, 
    -0.26884770f, 0.09686320f, -0.00070926f, -0.01959223f, 0.03844606f, -0.07880625f, -0.12573186f, -0.27135620f, 
    -0.06887928f, -0.00844985f, 0.24447450f, 0.02043142f, -0.04316869f, 0.17637268f, -0.04108467f, 0.15623760f, 
    0.00240975f, -0.10058589f, 0.16999382f, 0.05989582f, -0.55974597f, 0.28788599f, -0.12693644f, -0.54873419f, 
    0.02383360f, -0.19478096f, -0.14887546f, 0.06718190f, 0.12049456f, -0.11677541f, -0.10283623f, 0.03650051f, 
    0.65865153f, 0.42737576f, -0.09552033f, -0.16009389f, 0.06023610f, -0.03969224f, 0.08258809f, 0.03862534f, 
    -0.11126995f, -0.18932229f, -0.10808480f, 0.04099586f, -0.19471703f, -0.51144272f, -0.06764461f, -0.37857670f, 
    -0.15007189f, -0.11532641f, 0.09982818f, -0.02575498f, 0.09930354f, 0.01811364f, 0.06078156f, 0.07057625f, 
    0.20584886f, 0.13619585f, -0.25859126f, 0.02949173f, -0.05170679f, -0.04029211f, 0.24102451f, 0.29754245f, 
    -0.04168854f, 0.07383182f, -0.05266958f, 0.18499729f, -0.47705114f, -0.17756759f, 0.25244847f, 0.17013320f, 
    -0.19738936f, 0.00143405f, 0.03275819f, -0.25995043f, -0.02264079f, -0.03854852f, -0.10083568f, -0.10568068f, 
    -0.35273197f, 0.11731852f, 0.20369826f, -0.57870549f, -0.03077928f, 0.07467561f, -0.12296712f, -0.09057598f, 
    0.09875335f, -0.14558424f, 0.20743836f, 0.01611687f, -0.46106470f, -0.93266231f, -0.39710712f, 0.35595474f, 
    0.16370548f, 0.09950604f, 0.25304294f, 0.08724114f, -0.03413621f, 0.17097569f, 0.12482712f, 0.16962430f, 
    -0.36416742f, -0.02426294f, 0.20251648f, -0.00880476f, 0.00783323f, -0.04570073f, 0.00369680f, 0.06490737f, 
    0.11416896f, 0.07990178f, -0.17629531f, 0.08016016f, -0.02078681f, 0.09645517f, -0.01695728f, 0.24071099f, 
    0.01135508f, 0.08859202f, 0.15417454f, -0.04029174f, -0.09467199f, 0.21451500f, -0.05851606f, 0.22401534f, 
    -0.44800496f, -0.12433832f, -0.49328956f, -0.34912825f, 0.20520277f, -0.04074582f, -0.08523624f, -0.24447431f, 
    -0.08388323f, -0.05358813f, -0.24164334f, 0.00660817f, 0.25249150f, -0.11197156f, -0.22655690f, 0.01877445f, 
    0.03103676f, -0.43950340f, 0.02489268f, 0.01970386f, 0.12337326f, -0.16421288f, -0.17772719f, 0.10123027f, 
    0.13506544f, -0.17691138f, -0.15484631f, 0.32225847f, -0.08833695f, 0.14609167f, -0.06298266f, 0.13856101f, 
    -0.13322242f, 0.27559218f, -0.13233852f, -0.09496623f, 0.27733582f, -0.01384380f, 0.36281404f, -0.10368131f, 
    -0.18891801f, -0.22165512f, -0.20639125f, -0.16461869f, -0.03447940f, -0.27814311f, -0.19933715f, -0.32814056f, 
    0.17453676f, -0.13557862f, -0.12610963f, 0.02043637f, -0.06901875f, 0.03228668f, -0.00832124f, 0.03392280f, 
    -0.02578239f, 0.15213889f, 0.11619110f, 0.17620657f, -0.06279958f, 0.05091514f, 0.17271759f, 0.01427761f, 
    -0.03193592f, -0.04883961f, 0.14834394f, 0.16640191f, 0.19176397f, -0.06225548f, 0.23582749f, 0.00702035f, 
    0.03996791f, -0.01097144f, 0.03481505f, 0.05865401f, 0.04344130f, -0.04476316f, -0.05785437f, 0.15618506f, 
    0.25415888f, -0.07371996f, 0.04276944f, -0.16851385f, -0.80604661f, 0.29063290f, 0.21551804f, -0.11634745f, 
    -0.11477380f, 0.13544720f, 0.11221931f, 0.08362751f, -0.01175539f, 0.13716626f, -0.15473050f, -0.03559784f, 
    -0.41686615f, -0.63816923f, 0.18448335f, 0.18280016f, -0.06428050f, -0.13459855f, 0.02107364f, -0.10846649f, 
    0.04119508f, 0.08031031f, 0.11523503f, -0.13751025f, 0.27218282f, 0.03794495f, -0.01461687f, -0.20187192f, 
    -0.17407930f, 0.03863294f, -0.19846626f, 0.08687445f, -0.04198569f, -0.05188121f, 0.08302948f, -0.17655946f, 
    -0.10454655f, 0.26818684f, 0.37224644f, -0.42841953f, 0.05191452f, 0.06024203f, -0.07362603f, -0.21693745f, 
    -0.16874385f, 0.07559513f, 0.16559632f, -0.01004930f, 0.28748277f, -0.09220183f, 0.09484585f, 0.44062492f, 
    -0.19671822f, -0.08631311f, 0.19928968f, 0.30017945f, -0.16048956f, -0.04732047f, 0.18617299f, 0.30491480f, 
    1.12163401f, -0.00016312f, 0.18010557f, -0.19545999f, 0.03863622f, -0.18000840f, 0.02864894f, -0.04327364f, 
    0.17619132f, 0.14647326f, 0.07504194f, 0.13819283f, -0.20000486f, -0.26675597f, 0.13740493f, -0.42152384f, 
    -0.09936887f, 0.01693675f, 0.00410646f, -0.20919625f, -0.08523200f, 0.16414870f, 0.00367710f, -0.05871578f, 
    -0.24472667f, -0.42989594f, 0.16813937f, 0.28821918f, 0.03308879f, -0.33687624f, -0.09819305f, 0.04010255f, 
    -0.15989009f, -0.09860323f, -0.19698644f, -0.07029741f, 0.00723409f, 0.26870650f, -0.06149752f, -0.49247098f, 
    -0.25043830f, 0.14253259f, 0.00583994f, 0.11424363f, 0.16119899f, 0.07745147f, -0.08330333f, -0.12036168f, 
    -0.27686271f, -0.51563001f, -0.21126661f, -0.21630013f, 0.00417398f, -0.00174610f, 0.04911628f, 0.00420053f, 
    0.14578572f, 0.00999815f, 0.23390147f, 0.31766111f, -0.51548862f, -0.24678566f, 0.00101708f, 0.11869924f, 
    0.14723253f, 0.40026817f, 0.11138640f, 0.05271931f, -0.15424661f, -0.13565953f, -0.01023082f, 0.17710413f, 
    -0.24803333f, -0.02622448f, 0.12201476f, -0.09028912f, 0.35150874f, -0.09531920f, -0.09462216f, 0.15265657f, 
    0.13517280f, -0.31826299f, 0.24211024f, -0.27667251f, -0.53550380f, 0.10840704f, 0.03338705f, 0.13229509f, 
    0.01445816f, 0.25513142f, 0.01302509f, 0.10618031f, -0.08353226f, 0.01162294f, 0.09744357f, 0.17114685f, 
    0.07035955f, -0.30220789f, -0.31692004f, -0.04426482f, 0.11489638f, -0.08671123f, -0.00405528f, -0.03669701f, 
    -0.19843717f, -0.19855076f, -0.12898068f, -0.04552033f, -0.35053727f, -0.02252482f, -0.42251316f, 0.76621467f, 
    0.00414962f, 0.03738060f, -0.07613669f, -0.09086629f, -0.22250687f, -0.15586567f, -0.15499790f, -0.17820135f, 
    0.00404827f, 0.16364577f, 0.05149818f, -0.10769518f, -0.25539300f, -0.06032542f, -0.02412846f, 0.03555390f, 
    -0.16555053f, 0.17415868f, 0.30086151f, 0.11300230f, 0.55115193f, -0.68606317f, 0.08897904f, -0.05495815f, 
    0.25708389f, 0.17568918f, -0.01387962f, -0.10093726f, 0.06335545f, -0.19600593f, -0.01929011f, -0.15402283f, 
    0.22832884f, -0.06420886f, -0.43028948f, 0.42955762f, -0.22738260f, 0.12962954f, 0.08001746f, -0.10115059f, 
    -0.20239292f, 0.04104185f, 0.05368575f, 0.00180172f, 0.16966562f, -0.07386786f, 0.56381661f, -0.15050569f, 
    0.25201809f, -0.06642315f, 0.11902990f, 0.08338769f, 0.06558666f, -0.05075037f, -0.03652460f, -0.15269195f, 
    -0.27467665f, 0.03362599f, 0.30258030f, -0.35615647f, -0.30029929f, -0.05160324f, 0.11866222f, 0.21540856f, 
    -0.01148057f, 0.05452122f, -0.18156470f, -0.12072819f, 0.02977649f, 0.34410846f, -0.00037073f, -0.43447506f, 
    -0.05057861f, 0.10622445f, -0.04222460f, -0.04648045f, -0.05324981f, 0.06250872f, -0.08304205f, 0.03828864f, 
    0.42483622f, -0.08938896f, -0.42899671f, -0.23300105f, -0.14178005f, 0.05844788f, -0.03224720f, -0.23782806f, 
    -0.07725188f, -0.13145614f, -0.01385996f, -0.21607617f, 0.24334586f, 0.18295889f, 0.13376614f, 0.43232432f, 
    0.25794744f, 0.13871270f, 0.03388957f, 0.00594046f, -0.05981337f, 0.01846778f, -0.07569080f, -0.19672625f, 
    -0.09065910f, -0.37387377f, 0.07903915f, 0.09463768f, -0.10225119f, -0.09381141f, -0.09731852f, -0.13447845f, 
    0.12412327f, -0.12918769f, -0.10620083f, -0.05812995f, -0.72773707f, 0.14181839f, -0.29061317f, 0.10560649f, 
    -0.30458125f, -0.05542230f, -0.00858057f, -0.09854198f, -0.11239605f, 0.12325285f, -0.06526467f, 0.03494163f, 
    0.27883652f, 0.24120548f, 0.42220378f, 0.22392936f, 0.15275760f, 0.19854185f, 0.23451076f, -0.01882338f, 
    -0.01287237f, 0.20749104f, -0.08420839f, 0.05923131f, -0.06386074f, -0.05019285f, -0.16074659f, 0.08953148f, 
    0.08103402f, -0.08383872f, -0.04199512f, 0.07726922f, 0.12101872f, -0.14747149f, -0.11891335f, 0.15413207f, 
    -0.03775754f, -0.68019813f, -0.12840259f, -0.18883260f, -0.07909409f, -0.12890922f, -0.08546683f, -0.12538722f, 
    -0.11159242f, 0.03304835f, 0.03093416f, 0.01166032f, -0.21869317f, 0.55815262f, -0.40787306f, -0.25008059f, 
    -0.41918465f, 0.22298323f, -0.01540680f, -0.16282520f, -0.11583305f, -0.19897437f, 0.06279166f, -0.14160487f, 
    0.30945152f, -0.22369863f, 0.26989257f, 0.45553634f, -0.03652639f, -0.09297174f, -0.17971508f, -0.10224511f, 
    0.00850913f, -0.03009803f, -0.22321706f, -0.20524427f, -0.38214695f, -0.04625928f, 0.03113149f, 0.05925982f, 
    -0.00824999f, -0.27437362f, -0.08857808f, -0.08114152f, 0.00789612f, -0.10431672f, -0.02045929f, -0.04602780f, 
    -0.47351208f, 0.14254647f, -0.06088341f, -0.34503374f, -0.08776382f, -0.05025383f, 0.02606290f, -0.19918893f, 
    0.08302338f, 0.18206389f, -0.12109258f, -0.06094709f, -0.01253018f, -0.15104288f, 0.50758147f, -0.26258156f, 
    0.17180769f, 0.10315919f, -0.03577168f, -0.00964805f, -0.05219241f, -0.03307937f, 0.02129133f, 0.09007854f, 
    0.42411244f, 0.41153285f, -0.16839637f, 0.75265759f, 0.22607015f, -0.01929026f, 0.01525130f, -0.07865577f, 
    -0.11491790f, -0.01866399f, 0.01089286f, -0.00403465f, 0.37075090f, -0.21974312f, 0.01507293f, 0.05289432f, 
    0.06111316f, 0.16006409f, 0.01754630f, -0.17197958f, 0.07256879f, -0.02255799f, 0.02063850f, -0.22718656f, 
    -0.35044137f, 0.18463439f, 0.03285548f, -0.17475337f, -0.12924726f, 0.03306617f, 0.03952223f, -0.18066320f, 
    -0.10123321f, -0.07037071f, -0.07644912f, -0.04240973f, -0.00278279f, -0.38144782f, -0.07961249f, 0.10118569f, 
    -0.19084425f, -0.18840030f, -0.11159946f, -0.06401302f, -0.15285847f, -0.03643451f, 0.05152494f, -0.06721353f, 
    -0.11510872f, -0.16328652f, 0.13557930f, 0.22050028f, 0.18621916f, -0.20702556f, -0.10005573f, -0.22155644f, 
    0.00925270f, -0.07026976f, -0.00032832f, 0.14935344f, -0.43771687f, -0.02165839f, 0.45926601f, -0.15250225f, 
    -0.06770902f, -0.06138090f, 0.27102643f, -0.05770602f, -0.01732182f, -0.06045562f, 0.07944133f, 0.16962370f, 
    0.45129946f, 0.12031487f, -0.07951264f, 0.43265137f, -0.05877641f, 0.03671397f, -0.23671567f, -0.02993063f, 
    -0.05608611f, -0.01894038f, -0.01081629f, -0.09131560f, -0.14783981f, -0.06180661f, 0.07602166f, 0.29641306f, 
    0.14025670f, 0.09411895f, 0.06205466f, -0.10272365f, -0.04589054f, 0.17425469f, -0.23585445f, 0.05524136f, 
    -0.29761198f, -0.04532548f, 0.27489471f, 0.07849531f, -0.46448481f, -0.28859872f, -0.05295432f, -0.33297169f, 
    -0.06821224f, -0.30595949f, -0.35102898f, 0.04495673f, 0.04591551f, 0.26857373f, -0.04392689f, -0.34072116f, 
    -0.17850801f, -0.15548201f, -0.04351864f, -0.14942776f, 0.12454393f, -0.03903668f, -0.34657842f, 0.14887756f, 
    -0.10262146f, -0.48840860f, 0.01728798f, 0.07768722f, 0.12325542f, 0.18687367f, -0.04173548f, 0.14306068f, 
    0.15884189f, 0.15217628f, -0.01966672f, 0.04601473f, -0.26929188f, 0.28817037f, -0.33319569f, -0.37988311f, 
    0.06408779f, -0.26335612f, -0.31931657f, -0.06342680f, -0.01519325f, 0.10566109f, -0.10434338f, -0.34414676f, 
    -0.17088462f, -0.03909772f, -0.55467415f, -0.06211486f, 0.00294001f, -0.12786260f, 0.17058678f, -0.32311690f, 
    -0.07674765f, -0.04326623f, 0.08167926f, 0.15235814f, 0.41890725f, 0.46734262f, -0.70623434f, -0.06051053f, 
    0.08849791f, 0.00283005f, -0.15335731f, -0.14124535f, 0.17052855f, 0.09523325f, 0.15364762f, 0.20567746f, 
    0.56461442f, -0.38390309f, 0.08545164f, 0.20466851f, 0.21663646f, -0.20589921f, -0.00540194f, 0.04030469f, 
    -0.06273615f, -0.29578793f, -0.08762521f, -0.18997072f, -0.19454320f, -0.40116319f, 0.05431574f, 0.01769696f, 
    -0.06315154f, 0.00010571f, 0.03250392f, -0.16811270f, 0.20144060f, 0.10560578f, -0.18491089f, 0.10019027f, 
    0.30942109f, 0.20881329f, -0.30618152f, -0.46271539f, 0.07302450f, -0.36445144f, 0.27798480f, 0.05387341f, 
    0.23445605f, -0.09229641f, -0.18988551f, 0.00539437f, 0.48020852f, -0.53162396f, -0.02398251f, 0.20385320f, 
    0.00659086f, -0.44616225f, -0.06020209f, -0.10590166f, -0.08206314f, 0.12037569f, 0.00770173f, 0.07087928f, 
    0.55577183f, 0.04665070f, 0.01810875f, 0.22520858f, 0.22602937f, -0.14243235f, -0.15220328f, -0.05132465f, 
    -0.03572994f, 0.17539403f, 0.31148291f, -0.30430892f, -0.34219831f, -0.50417560f, -0.47613540f, -0.12628017f, 
    0.06552785f, -0.06069544f, -0.03154556f, -0.07477525f, 0.33483383f, 0.06320405f, 0.16887413f, -0.11974645f, 
    -0.20268209f, 0.01371996f, -0.01309298f, -0.69005889f, 0.03381150f, -0.14224863f, 0.09599683f, 0.04137692f, 
    0.01565560f, 0.09441709f, -0.11467870f, 0.08623851f, 0.45689577f, 0.02011495f, -0.03937244f, 0.14879148f, 
    0.06781312f, -0.28197753f, 0.02465115f, 0.00350308f, -0.12214275f, 0.17799969f, -0.00026483f, 0.15893714f, 
    0.46906602f, -0.82055664f, -0.30520451f, -0.19207384f, 0.04795015f, -0.01013031f, -0.06377171f, -0.16499043f, 
    -0.25312960f, -0.13284123f, 0.13161956f, -0.13742350f, -0.23711389f, 0.52761346f, -0.06645981f, -0.89943630f, 
    0.06623153f, -0.03007757f, 0.09666497f, 0.06385098f, -0.14501345f, 0.01664685f, 0.09489542f, -0.15733166f, 
    -0.07365129f, -0.66972166f, -0.25497696f, 0.17324406f, 0.03323262f, 0.11029620f, -0.09152269f, 0.19458425f, 
    -0.02792658f, 0.29195654f, -0.02610110f, -0.09166890f, 1.12004340f, 0.23298381f, 0.12204593f, -0.07246453f, 
    -0.00059509f, 0.15399793f, -0.05763333f, -0.11356272f, -0.10354581f, -0.01802076f, 0.18591000f, 0.09984943f, 
    0.11450332f, -0.04956331f, 0.14395401f, -0.29562771f, 0.22561502f, -0.11100587f, -0.02130612f, -0.47981140f, 
    -0.34235564f, -0.14135857f, -0.02369838f, -0.04770732f, -1.00064623f, 0.40625042f, -0.04482835f, -0.22247781f, 
    -0.13952315f, -0.15899126f, 0.00783545f, 0.11187780f, 0.05059957f, 0.08749560f, 0.15967762f, 0.33859959f, 
    -0.30308521f, -0.31878600f, 0.04523915f, -0.32782564f, 0.06883790f, 0.03175574f, -0.02611602f, 0.09510998f, 
    0.02751108f, 0.06718083f, 0.11296010f, -0.12403925f, 0.83553225f, -0.10581340f, 0.23926005f, 0.30619135f, 
    0.11140850f, 0.14989097f, 0.20494871f, -0.20913678f, -0.17553727f, 0.11962891f, -0.13123353f, 0.14219201f, 
    -0.30168283f, 0.28132668f, -0.07840678f, 0.15041010f, 0.12284631f, -0.11210716f, 0.17671141f, -0.28571787f, 
    -0.04329107f, 0.23912224f, -0.29834491f, -0.01969440f, -0.03643617f, -0.27064669f, -0.25261718f, 0.47484592f, 
    -0.06809952f, -0.01319049f, 0.02459360f, -0.07134176f, 0.17572629f, -0.06850182f, 0.03130585f, -0.20685518f, 
    -0.85837239f, -0.14343925f, 0.19339055f, -0.30124083f, -0.05365818f, -0.02704437f, -0.13300733f, -0.02551900f, 
    0.15940557f, -0.30408555f, 0.23860773f, 0.13540451f, -0.02186598f, 0.65188777f, 0.15257141f, 0.02712785f, 
    -0.01072956f, 0.14834917f, -0.03687630f, 0.03569462f, -0.06071771f, -0.06679679f, 0.08931223f, -0.05937957f, 
    -0.45683038f, 0.17710850f, -0.15003087f, 0.01500744f, 0.17758130f, -0.14183575f, 0.15215482f, -0.09107637f, 
    -0.06138087f, 0.12190306f, -0.08224170f, 0.00996392f, -0.26405698f, -0.18753630f, 0.18493688f, -0.24634719f, 
    0.05393957f, -0.03678526f, 0.03921814f, -0.15392303f, 0.11034608f, 0.10080288f, -0.05633391f, -0.25041544f, 
    0.00454359f, -0.24445972f, -0.14743161f, -0.13642235f, 0.10312469f, -0.15441768f, -0.16745977f, 0.18765225f, 
    -0.12553270f, 0.12240487f, -0.07446808f, -0.02082418f, 0.07984954f, 0.03059726f, 0.22095267f, -0.29638827f, 
    0.00425932f, 0.29555055f, 0.32951388f, 0.16926003f, -0.05023284f, 0.15281047f, 0.19665487f, 0.02202405f, 
    -0.26707131f, 0.38095868f, -0.37607226f, -0.28698269f, 0.20728725f, 0.27294257f, -0.15423700f, 0.17297485f, 
    0.06339946f, 0.26955876f, 0.16627271f, 0.36935222f, -0.57209057f, -0.20720798f, -0.18652569f, -0.49582508f, 
    0.20811021f, -0.24021251f, 0.16314662f, -0.14214268f, 0.14642066f, 0.14178735f, 0.04836694f, 0.28159997f, 
    0.65963584f, 0.20734322f, 0.03691920f, -0.26044291f, -0.28265718f, -0.15397394f, -0.02699884f, -0.11748546f, 
    -0.11256383f, -0.16138712f, -0.10375945f, -0.32593435f, -0.23155449f, -0.08813002f, 0.13280432f, 0.25620094f, 
    -0.02221478f, 0.13761964f, 0.03927556f, -0.07421673f, -0.07427189f, -0.04007439f, 0.09950294f, 0.12589495f, 
    -0.77320164f, 0.18752728f, 0.02664153f, -0.20382749f, 0.24019679f, 0.20367475f, 0.11521971f, 0.19191025f, 
    0.16145748f, 0.17714660f, -0.09789664f, 0.17776120f, -0.89536482f, -0.58029526f, 0.05505782f, 0.14065847f, 
    0.36956939f, 0.05573171f, 0.05435340f, -0.26642734f, 0.41329804f, -0.17022771f, -0.30688944f, -0.06234162f, 
    0.33243608f, 0.19050118f, -0.09715401f, -0.27188921f, 0.03335517f, 0.14536177f, -0.05492871f, -0.00581628f, 
    -0.00134098f, -0.07294292f, 0.07253411f, 0.13381553f, -0.86029696f, -0.05400348f, 0.29679593f, 0.14910986f, 
    0.03037882f, -0.01593985f, -0.08206619f, -0.00363089f, 0.25974572f, 0.00454249f, 0.00974744f, 0.13235284f, 
    -0.74629647f, -0.37961948f, -0.44533172f, -0.38900179f, 0.19717869f, 0.06623658f, -0.08311043f, -0.04603335f, 
    -0.01534208f, -0.16577947f, -0.04119080f, 0.20691991f, 0.51208270f, 0.17338194f, -0.25830990f, 0.20772640f, 
    0.00195624f, -0.13266094f, 0.20951557f, -0.00291149f, -0.00784907f, 0.16986986f, 0.08336768f, 0.11994039f, 
    -0.60173774f, 0.14256866f, -0.19591619f, -0.08928422f, -0.12605624f, -0.08797123f, -0.09880082f, 0.01875050f, 
    0.09826951f, 0.39921817f, -0.12945908f, -0.06369605f, -1.35539031f, -0.20145608f, 0.03028685f, 0.29310140f, 
    0.09033828f, -0.05271281f, -0.17286579f, -0.35888931f, -0.15123473f, 0.03206632f, -0.00533444f, -0.06516905f, 
    -0.96709931f, -0.19993387f, -0.46454826f, -0.25889185f, 0.03541252f, 0.02811928f, -0.29272377f, 0.17946588f, 
    0.04314719f, -0.03071903f, 0.01012358f, 0.03938304f, 0.24515705f, 0.03449642f, 0.11339703f, -0.18431069f, 
    0.21560764f, 0.09008084f, 0.01065786f, 0.14264794f, 0.01116555f, 0.21599968f, -0.01278595f, 0.11725217f, 
    -0.43569687f, 0.12883447f, -0.27972105f, -0.31990609f, 0.39670923f, -0.23631078f, 0.08616154f, -0.03389574f, 
    -0.08045243f, 0.11876710f, 0.08951863f, 0.17099336f, -0.13283719f, 0.44146749f, -0.02653604f, -0.35123277f, 
    -0.21579963f, 0.10717741f, -0.35654309f, -0.11883121f, 0.08679477f, -0.05499591f, -0.05916573f, -0.16594620f, 
    -1.19308484f, 0.05026047f, 0.14611767f, 0.14922805f, 0.03920344f, 0.02908217f, -0.02933986f, 0.27235195f, 
    -0.06292762f, 0.08762802f, 0.05486477f, -0.02965209f, 0.65113270f, -0.51609683f, -0.32881379f, 0.19876856f, 
    0.15904243f, -0.16645060f, 0.05406846f, 0.03702028f, 0.06110506f, -0.05990841f, 0.09673961f, -0.03975056f, 
    -0.46443233f, 0.25357416f, -0.18882753f, 0.01313078f, -0.07918523f, -0.12402747f, 0.09694299f, 0.02389073f, 
    -0.02630080f, 0.07278194f, 0.10686138f, -0.38198546f, -0.40933576f, 0.08066152f, 0.00966333f, -0.18843335f, 
    -0.01991701f, -0.10667735f, -0.03135675f, 0.32562646f, -0.19698982f, -0.22732690f, 0.22705555f, 0.00107945f, 
    0.67518699f, 0.25012079f, 0.01072675f, 0.11215142f, -0.18652986f, -0.28324294f, 0.04600692f, -0.01726663f, 
    0.06057595f, -0.26114261f, -0.10207883f, -0.07386982f, -0.28380728f, 0.21099989f, -0.00006213f, 0.07802862f, 
    0.55483341f, 0.05927147f, 0.09653249f, 0.17692044f, 0.16040947f, 0.13942870f, 0.38117465f, -0.00227380f, 
    0.23350902f, 0.03055858f, -0.41289023f, 0.42534602f, -0.16254558f, -0.12275109f, -0.09003613f, 0.06344832f, 
    -0.08219824f, -0.18403512f, -0.00084487f, -0.12060343f, 0.53365034f, -0.07501593f, -0.02562020f, -0.06772569f, 
    0.03764091f, -0.27247506f, -0.31078395f, -0.06935751f, -0.05443090f, 0.17893448f, -0.08125182f, 0.07945069f, 
    0.22157028f, -0.19793126f, -0.17513108f, -0.83583099f, 0.03988967f, 0.07182101f, -0.00728560f, -0.07121833f, 
    0.18000834f, 0.07380228f, -0.05954075f, -0.17519273f, -0.06238191f, -0.13166511f, 0.14048573f, -0.08879238f, 
    -0.01768171f, -0.14872216f, 0.11495581f, 0.19334584f, -0.10026229f, 0.02876410f, 0.08994227f, 0.09997075f, 
    -0.14779256f, -0.26919174f, -0.06866652f, 0.27831134f, -0.27140826f, 0.40186685f, -0.38446569f, -0.10001765f, 
    0.06656405f, -0.00008425f, -0.08758933f, -0.02550391f, 0.43912143f, -0.24388938f, 0.26609451f, 0.06938846f, 
    0.08983392f, 0.03625735f, -0.23782347f, 0.01270173f, 0.09252399f, 0.11543386f, 0.12259911f, 0.07499865f, 
    -0.43191239f, -0.17266424f, -0.16012111f, -0.30470183f, 0.03190348f, -0.14203750f, 0.12247951f, 0.09612051f, 
    -0.00199887f, -0.19571683f, -0.22166425f, 0.05226678f, 0.32197168f, 0.14649250f, -0.45345387f, 0.10118209f, 
    0.08177998f, -0.08559965f, -0.04343708f, 0.13921508f, 0.24370185f, -0.02030794f, -0.20797405f, -0.11731997f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.17037797f, 0.09398361f, -0.21607094f, 0.07497332f, 0.00183611f, 0.00787859f, 0.03970778f, -0.15980686f, 
    -0.01600413f, 0.08333999f, 0.19296715f, -0.00532236f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
