#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.97992432f, 0.29644665f, -0.37611437f, 0.41994292f, 0.36838663f, 0.85148215f, 0.48170653f, 0.34810472f, 
    0.61267555f, 0.31632015f, -0.32988381f, 0.11666685f, -0.08240951f, 0.06187019f, -0.05751007f, -0.26137096f, 
    -0.23015341f, -0.15764125f, 0.02434511f, 0.02505917f, -0.09455588f, -0.07004714f, 0.00077868f, 0.02318320f, 
    0.13824376f, 0.72966987f, 0.77931070f, 0.22998264f, 0.12680222f, 0.35097358f, -0.29149130f, -0.72971427f, 
    0.12592936f, 0.32315364f, -0.11616475f, 0.11888355f, 0.51385301f, 0.17261313f, 0.22028598f, 0.01871405f, 
    0.45539460f, 0.23128533f, 0.12912852f, 0.09839285f, -0.26506764f, -0.17632996f, 0.10019656f, 0.08296897f, 
    -0.09093772f, 0.43069974f, -0.37154189f, -0.97369987f, 0.11998669f, 0.65207696f, -0.34396076f, -1.19907606f, 
    -0.03760998f, 0.34778216f, -0.63631076f, -0.25931346f, 0.11817601f, 0.05620192f, -0.01271598f, 0.11132711f, 
    0.23155996f, 0.10884040f, 0.23203567f, 0.20147456f, -0.08612907f, -0.20096195f, 0.16015556f, -0.16711557f, 
    -0.01305279f, 0.07579912f, 0.15804300f, -0.54987413f, -0.47580576f, -0.65405649f, -0.68802029f, -0.36123288f, 
    0.51950067f, -0.11297823f, -0.25742322f, 0.41851974f, 0.45253792f, -0.43701065f, -0.27190247f, 0.45566103f, 
    -0.07387663f, -0.37137115f, -0.16118456f, -0.19461194f, 0.30755606f, 0.09025228f, 0.15343583f, -0.14516994f, 
    -0.16680883f, -0.37543428f, -0.17203894f, -0.24185896f, 0.70558500f, 0.60182196f, 0.28589493f, 0.68712699f, 
    1.00515664f, 0.00323075f, -0.22074959f, 0.40086204f, -0.10349744f, 0.18305986f, -0.47713235f, -0.25862086f, 
    0.11084924f, 0.25247860f, 0.21306546f, 0.20164527f, 0.09602088f, 0.15049651f, 0.22752692f, 0.39927223f, 
    0.40343544f, -0.06521402f, -0.05189135f, 0.04358383f, 0.11330151f, -0.50714999f, -1.07643044f, -0.67737430f, 
    0.08234764f, -0.21213163f, 0.22397433f, 0.67786342f, -0.25917128f, 0.46507171f, 0.63409370f, -0.28669512f, 
    -0.33212757f, -0.37881956f, 0.03925866f, 0.02565346f, -0.14648476f, 0.20327090f, 0.05154904f, -0.04966990f, 
    -0.07989227f, 0.04721334f, -0.02569627f, 0.13388310f, 0.10810166f, 0.14906189f, 0.72024453f, 0.41376483f, 
    0.94930238f, 0.19160454f, 0.16107281f, 0.50359011f, -0.03399069f, -0.07633452f, 0.42650938f, 0.38703710f, 
    -0.52314365f, 0.15498605f, 0.06162057f, 0.15841843f, -0.12594654f, -0.11040945f, 0.17101105f, 0.16265436f, 
    -0.35011014f, 0.10374588f, -0.23592570f, -0.09463644f, -0.24304400f, -0.19646199f, 0.30328208f, -0.59815371f, 
    -0.94057512f, 0.16312133f, 0.26566216f, -0.01751968f, 0.54232591f, 0.42054698f, 0.68161738f, 0.12090252f, 
    -0.63039005f, -0.16312543f, -0.18290572f, 0.19964780f, 0.18449554f, -0.48944727f, 0.00032064f, -0.13542552f, 
    -0.15380123f, 0.03847782f, -0.11962437f, -0.31966037f, -0.18307066f, -0.06231235f, -0.27513319f, -0.18766034f, 
    -0.11382844f, -0.64566416f, -0.49614179f, -0.34028760f, 0.32334024f, -0.44409728f, 0.29664901f, -0.03876491f, 
    0.11698142f, -0.39852750f, 0.05853190f, -0.29765540f, 0.16030940f, -0.16991670f, -0.05442126f, -0.35083824f, 
    0.21851949f, -0.71947753f, -0.23448409f, -0.29535130f, 0.08331332f, 0.14561997f, 0.24693915f, -0.05766138f, 
    -0.25499079f, 0.90750062f, 0.98871541f, -0.69782925f, -0.84490907f, -0.38010314f, -0.32519937f, 0.26119104f, 
    0.32866669f, -0.06679891f, 0.22475374f, 0.05709454f, 0.11896913f, 0.21530612f, -0.18608426f, -0.32399020f, 
    0.08724788f, -0.19096534f, -0.05341234f, -0.00954016f, 0.08358181f, 0.01390621f, 0.11701547f, -0.00201521f, 
    -0.05687965f, -0.12914893f, -1.41335821f, 1.10606873f, 0.22326574f, 0.04337582f, 0.00256315f, -0.23364060f, 
    0.73543042f, -0.04245906f, 0.32748908f, 0.37496805f, -0.24063057f, 0.26230219f, 0.20245683f, -0.21849042f, 
    0.06136120f, -0.04844037f, 0.00155228f, -0.06192739f, 0.07558774f, -0.12164624f, 0.04326176f, 0.13276188f, 
    -0.10182144f, 0.10112876f, -0.07297499f, 0.82439905f, 0.82016587f, 0.97075498f, 0.82475662f, -0.25918096f, 
    0.05169418f, -0.69491917f, -0.48593104f, -0.59745187f, -0.11219867f, 0.24430431f, 0.09098655f, -0.21109642f, 
    0.15366954f, -0.05787513f, 0.16589414f, -0.18646634f, -0.02895999f, -0.07827767f, 0.05003438f, 0.05003409f, 
    0.26021856f, 0.34612072f, 0.20471759f, 0.02300633f, -0.23501617f, 0.28042081f, 0.81095397f, 0.64275855f, 
    0.32666522f, 0.22918169f, 0.30619240f, 0.30784792f, 0.48199072f, 0.15988794f, 0.04465151f, 0.01417015f, 
    -0.44021255f, -0.02125903f, -0.22324346f, 0.21915419f, -0.33100656f, -0.46768630f, -0.05217109f, -0.27242595f, 
    0.48199147f, 0.38894650f, 0.11559276f, -0.05513465f, 0.06500462f, -0.29236096f, 0.82035905f, -0.33732951f, 
    -0.18668033f, 0.32799003f, 0.72487706f, -0.74363452f, -0.36576927f, -0.46877351f, -0.08417061f, -0.35471252f, 
    -0.36883149f, -0.12341068f, -0.03850343f, -0.30933183f, -0.26517972f, -0.09434715f, -0.13314126f, -0.03634923f, 
    -0.10592146f, -0.05086906f, 0.02159589f, 0.09352150f, -0.23717028f, 0.04671658f, -0.43555185f, 0.27306926f, 
    -0.65140277f, -0.43623123f, -0.55574125f, -0.17328954f, -0.55467260f, -0.03164056f, -0.23666824f, -0.29856253f, 
    -0.10170872f, 0.02692243f, -0.09526725f, 0.37016889f, -0.00076571f, 0.38163471f, 0.14239264f, 0.38737276f, 
    0.19907241f, 0.06052535f, 0.05568487f, -0.02329314f, 0.06970956f, 0.25960359f, 0.39452657f, -0.32108614f, 
    0.50975960f, -0.37825489f, -0.75110185f, -0.62588358f, 0.71743786f, 0.60752821f, 0.07287756f, 0.00527852f, 
    0.41902348f, 0.54535985f, -0.02347019f, -0.09127750f, -0.03483646f, 0.34257701f, 0.00751102f, -0.03578257f, 
    -0.02618467f, 0.04986270f, 0.28688535f, 0.09593522f, -0.12702726f, 0.12663400f, -0.04329496f, 0.21611397f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.11450019f, 0.26246446f, 0.19185494f, -0.09857375f, 0.16219655f, 0.20282665f, 0.12841569f, 0.23570806f, 
    0.13753259f, 0.12170812f, -0.07719192f, 0.27732703f, 0.17606536f, 0.18129690f, 0.07004201f, 0.24167636f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.09896966f, -0.07328357f, 0.14666358f, -0.08666475f, -0.17058076f, 0.00746710f, -0.17139074f, 0.14479204f, 
    0.09637701f, 0.03523887f, -0.06999914f, 0.00047557f, 0.00607235f, 0.13966201f, 0.03298113f, -0.03911592f, 
    0.08118128f, -0.09664233f, -0.19581158f, 0.08117802f, 0.03719264f, 0.12609437f, 0.03566757f, -0.03881319f, 
    0.19264913f, 0.08093723f, -0.09227425f, 0.21282831f, -0.16670749f, 0.13958865f, 0.00579051f, -0.04420658f, 
    0.08198053f, 0.05192492f, 0.10634564f, -0.10954683f, 0.43726751f, 0.15451224f, -0.13693760f, -0.22679386f, 
    0.07808282f, 0.01543134f, 0.12597084f, -0.10491011f, -0.09295798f, -0.02476025f, -0.06819421f, -0.00654435f, 
    -0.23625953f, 0.20430952f, 0.16211498f, -0.07676230f, -0.04908468f, -0.01339004f, -0.06767195f, 0.05809898f, 
    0.09218325f, -0.01750633f, -0.04595134f, -0.03817707f, 0.59448391f, 0.10711779f, -0.21553332f, -0.21961053f, 
    0.02913356f, 0.05139980f, 0.04206074f, 0.02822512f, 0.06205558f, -0.01904546f, 0.11811753f, 0.05552127f, 
    0.16846025f, 0.13907576f, 0.08046319f, 0.17273833f, -0.05287611f, -0.24207133f, 0.08948695f, 0.01009597f, 
    0.14212482f, 0.05080594f, -0.04423244f, -0.08230606f, 0.25099802f, -0.08417718f, 0.09982773f, 0.06093449f, 
    -0.03221859f, 0.09930228f, -0.00238888f, -0.05982530f, -0.12650092f, 0.05373830f, -0.05823508f, -0.01338457f, 
    0.23886473f, 0.02823027f, 0.07489017f, 0.01469919f, 0.03839251f, -0.00802127f, 0.03979284f, -0.04786902f, 
    -0.11215332f, 0.01947151f, -0.02689262f, -0.07777987f, -0.17301704f, 0.14798278f, 0.29087988f, -0.04937356f, 
    0.07594044f, 0.15114510f, -0.02111225f, 0.10572139f, -0.01489094f, -0.00654895f, 0.09572902f, 0.02606535f, 
    0.06493376f, -0.18544915f, -0.05438866f, -0.09057230f, 0.10278304f, 0.00309185f, -0.01334862f, -0.01062027f, 
    -0.03450667f, 0.09317897f, 0.10557693f, 0.13015674f, 0.14359599f, 0.22533812f, -0.10787392f, -0.02006650f, 
    -0.06505822f, -0.17398611f, 0.05801840f, 0.06164710f, -0.08408228f, -0.04714012f, -0.07336649f, 0.02600770f, 
    -0.09086795f, -0.11738829f, 0.12322541f, -0.01185247f, 0.02132658f, 0.02656938f, -0.05742083f, -0.20340849f, 
    0.06078369f, -0.06280551f, 0.03381310f, -0.04639304f, 0.09906338f, -0.12264401f, 0.19446598f, -0.08088008f, 
    0.01952014f, -0.01879186f, 0.10026020f, 0.03694769f, -0.06495177f, 0.02810546f, -0.11759141f, -0.05970572f, 
    0.04647740f, 0.02397785f, -0.00397490f, 0.23356022f, 0.08631283f, 0.06916989f, 0.01149925f, -0.13341257f, 
    -0.08833186f, 0.12871827f, -0.07251648f, -0.07640281f, 0.19919848f, -0.14254221f, -0.08620016f, -0.26017788f, 
    -0.05928996f, 0.09801906f, 0.23631506f, -0.05604079f, 0.12996858f, -0.11273364f, -0.07479087f, -0.03361233f, 
    -0.20906842f, 0.29363939f, 0.22097376f, -0.02834462f, 0.01714932f, 0.01341709f, 0.00620953f, -0.05288065f, 
    -0.04390988f, 0.03569442f, -0.00933437f, -0.03386349f, 0.07437866f, 0.33175787f, -0.04827627f, -0.00436221f, 
    0.11714112f, 0.05387340f, -0.07766465f, -0.02474950f, -0.11789799f, 0.03708362f, -0.14558282f, -0.06696556f, 
    0.02941947f, -0.03690073f, 0.30493784f, -0.32637027f, -0.00225391f, -0.06943665f, 0.15804081f, -0.05433608f, 
    -0.03709777f, -0.05136802f, 0.02551918f, -0.13047738f, -0.06169486f, 0.08382144f, 0.23998690f, 0.09872799f, 
    -0.05164380f, 0.04219838f, -0.08583941f, -0.04394181f, 0.13981023f, 0.15271233f, -0.01383065f, 0.14174820f, 
    -0.08666699f, 0.26758897f, 0.08866188f, 0.00196889f, 0.03699494f, 0.14701751f, -0.01122254f, -0.14641829f, 
    -0.13178088f, -0.06707925f, 0.11419539f, -0.03695453f, -0.22120693f, -0.09528302f, 0.24002737f, -0.23377441f, 
    -0.05619397f, 0.10829931f, 0.02020483f, -0.01146572f, -0.01532855f, 0.00837854f, 0.04868082f, 0.03339726f, 
    0.45731315f, 0.25376108f, 0.12221674f, 0.04334867f, -0.08369961f, -0.02637581f, 0.11657011f, 0.07642880f, 
    -0.03132658f, 0.13467740f, 0.07292657f, -0.20249203f, 0.12453326f, -0.49599692f, 0.18797304f, 0.14917831f, 
    0.14268240f, -0.04937999f, -0.05654719f, -0.06439542f, -0.02866104f, 0.07263371f, 0.21352477f, 0.08901531f, 
    -0.17965963f, 0.14128827f, 0.13338211f, 0.14123473f, -0.02691264f, -0.08899248f, 0.06200822f, -0.16116816f, 
    0.12293737f, 0.15818869f, 0.19074878f, -0.02988978f, 0.46135157f, 0.34368712f, -0.20944899f, 0.36920640f, 
    0.19413242f, -0.00381225f, -0.00150894f, 0.05401275f, -0.03626085f, 0.10340913f, 0.01346936f, -0.01493516f, 
    0.24306920f, -0.36556888f, 0.16072753f, 0.15588790f, 0.06417103f, 0.02845547f, 0.08684706f, 0.06285676f, 
    -0.00596955f, 0.01949297f, 0.05361169f, 0.13622291f, 0.43752620f, -0.19201896f, -0.24515885f, 0.02746359f, 
    0.08048124f, 0.04291156f, 0.01416471f, 0.00160334f, -0.02040400f, -0.03826248f, 0.00678767f, -0.00319860f, 
    -0.00538557f, -0.15171432f, 0.21543309f, -0.09963232f, 0.04985729f, -0.02761788f, -0.08767142f, 0.03377994f, 
    -0.02027765f, -0.12517394f, 0.09567829f, 0.06236775f, -0.03581207f, 0.07315454f, -0.29613101f, -0.03974635f, 
    -0.04790474f, -0.02644742f, -0.23348255f, -0.03920252f, 0.15580942f, 0.15339118f, 0.20376629f, 0.10168273f, 
    -0.10945436f, 0.00274292f, 0.04029496f, 0.09329040f, -0.09789336f, -0.22217616f, 0.05796691f, -0.00996044f, 
    0.04134433f, -0.32088459f, 0.03726399f, -0.07226586f, -0.19191198f, 0.24645030f, 0.03365950f, 0.27986661f, 
    0.00902687f, -0.00161815f, -0.07960714f, -0.06216282f, -0.06351393f, -0.01652271f, 0.00639640f, -0.17599897f, 
    0.31322867f, -0.25164032f, 0.39108267f, -0.02843788f, -0.03924387f, 0.05484515f, -0.07462912f, 0.15100306f, 
    0.03171464f, 0.02679765f, -0.13324814f, 0.01931175f, -0.02806254f, 0.36673677f, -0.16966674f, 0.11492740f, 
    0.15884775f, -0.07724574f, 0.00782060f, 0.03289305f, 0.09230728f, 0.04186882f, 0.01710611f, 0.00085003f, 
    0.14580673f, 0.12005375f, 0.04368718f, -0.12841272f, -0.28731701f, 0.06063081f, 0.08094624f, 0.07417537f, 
    -0.07827530f, -0.05190052f, -0.00876872f, -0.02467217f, 0.12528783f, 0.09597808f, 0.11590935f, 0.09380934f, 
    -0.02016566f, 0.02957637f, -0.04687882f, -0.09045072f, 0.00932953f, 0.09657905f, -0.04843042f, 0.00181436f, 
    -0.00417716f, 0.19898301f, 0.12435051f, -0.06963336f, 0.02575749f, 0.04127955f, 0.02355986f, 0.00723782f, 
    -0.01378985f, -0.10241254f, -0.03217613f, -0.02099247f, 0.43006697f, -0.08860674f, 0.05540819f, -0.13520785f, 
    -0.11471012f, -0.11152299f, -0.10285219f, 0.00237258f, 0.06455809f, 0.04691511f, 0.01849424f, 0.00719755f, 
    0.23705302f, 0.16140044f, 0.06773379f, 0.19119433f, -0.24083111f, 0.00297159f, 0.08885083f, -0.01402391f, 
    -0.00765138f, 0.02593167f, 0.09605006f, -0.20690104f, -0.31105760f, -0.18461078f, 0.04296844f, 0.06943025f, 
    -0.12005988f, 0.02726547f, -0.02379490f, -0.06702674f, -0.07455269f, 0.01699132f, 0.03429233f, 0.01614258f, 
    0.23996399f, -0.02813396f, 0.03105985f, -0.27879605f, 0.05907630f, -0.15880603f, 0.10697494f, -0.11285070f, 
    0.08134448f, 0.00333272f, -0.01777666f, -0.08225718f, 0.26425427f, 0.33497626f, -0.10557909f, -0.00794103f, 
    0.14065151f, -0.06080559f, 0.14551848f, -0.07881463f, -0.11430184f, -0.12138592f, -0.02641540f, 0.00874702f, 
    -0.31534868f, 0.06684888f, -0.23575497f, -0.16461800f, 0.08340918f, 0.07511584f, 0.04362355f, -0.03655216f, 
    -0.03357100f, 0.16063313f, 0.09743445f, -0.03849275f, 0.42159480f, 0.06232712f, -0.22669734f, 0.21349457f, 
    0.04955251f, -0.00625279f, 0.15600556f, 0.02971133f, -0.00257944f, 0.09703016f, -0.04853101f, 0.16935165f, 
    0.31017461f, -0.07233234f, 0.03204347f, 0.14399061f, -0.12897740f, 0.02309117f, -0.02541105f, 0.07750670f, 
    -0.04468707f, -0.00373155f, 0.06152553f, -0.11842413f, 0.20509009f, -0.06407098f, -0.20483559f, -0.10608099f, 
    0.14088100f, -0.11433990f, 0.02704176f, -0.02023602f, 0.03549243f, 0.14931817f, 0.12874809f, 0.02737903f, 
    -0.12656020f, 0.09122512f, -0.17253160f, 0.01133545f, -0.09370603f, -0.06819568f, 0.12982436f, -0.01130860f, 
    0.07506283f, 0.03850573f, 0.08704913f, -0.05043575f, 0.09233204f, -0.02005942f, -0.12841615f, 0.15635715f, 
    -0.16044945f, 0.00326012f, -0.11069797f, -0.06751711f, -0.16779408f, 0.07317353f, -0.00588240f, -0.26950887f, 
    0.01743792f, 0.03053802f, 0.02989605f, 0.00202346f, -0.00220052f, -0.04337132f, 0.00521470f, -0.02110979f, 
    -0.06979738f, -0.08200220f, -0.05203284f, -0.00604666f, -0.06140364f, 0.01744479f, -0.03673985f, -0.05446380f, 
    0.01501573f, -0.01841329f, -0.04942146f, 0.04253436f, 0.00746520f, -0.03902379f, 0.05383359f, -0.00667990f, 
    0.03176567f, -0.07572392f, 0.05868836f, -0.00990332f, 0.02364422f, -0.06217717f, 0.00901496f, 0.00349912f, 
    -0.08110251f, 0.01353461f, 0.05940623f, 0.04075880f, 0.05011619f, -0.01176299f, -0.07950999f, 0.04401053f, 
    -0.00294044f, 0.04894040f, -0.00596010f, -0.03479524f, 0.01643020f, -0.00699378f, -0.07566147f, -0.05571995f, 
    -0.01262042f, 0.03129068f, 0.04317429f, -0.01234559f, -0.00427206f, 0.03163488f, -0.03707042f, -0.01236667f, 
    -0.07533552f, -0.04307077f, -0.05791899f, -0.00864558f, 0.00834479f, -0.03430531f, -0.00267144f, -0.04525302f, 
    0.02886991f, -0.06548069f, -0.00914164f, -0.01032680f, 0.00196570f, -0.00781393f, -0.04951621f, 0.05181400f, 
    -0.02445990f, -0.01449564f, 0.02731488f, -0.05098446f, 0.04045232f, 0.06766322f, 0.04680511f, 0.01100105f, 
    -0.06197848f, 0.03233433f, -0.00595158f, -0.04812036f, -0.03356066f, 0.02446200f, 0.02514191f, 0.00097683f, 
    -0.05910431f, -0.00798951f, -0.01896417f, 0.01641026f, -0.00356280f, -0.02337450f, 0.00819553f, 0.01169393f, 
    -0.01507551f, -0.00508654f, -0.02084379f, -0.07438204f, -0.00129437f, -0.05020338f, 0.01340224f, -0.03624103f, 
    -0.01128623f, 0.00632373f, 0.04612948f, -0.05439320f, -0.06175094f, -0.02443383f, -0.05205719f, -0.04751411f, 
    -0.00167345f, -0.01252964f, -0.06334969f, 0.03459287f, 0.05532327f, 0.00894703f, 0.04967306f, -0.02603409f, 
    -0.05099745f, 0.06354055f, 0.01833415f, -0.01499523f, 0.00781948f, -0.07235131f, 0.03625784f, 0.02489224f, 
    0.05898478f, -0.07468032f, 0.03310019f, -0.07208806f, 0.02518048f, -0.06500618f, -0.00733210f, 0.02186497f, 
    -0.07011282f, -0.01346346f, -0.07416195f, -0.04802001f, 0.06015127f, -0.06697065f, -0.01518949f, -0.02772980f, 
    -0.01824330f, -0.03289489f, -0.01902849f, -0.05131655f, 0.02930191f, -0.03296839f, -0.01100813f, 0.05962113f, 
    0.03071742f, 0.00543894f, 0.01087248f, -0.01280918f, 0.02524677f, 0.02794552f, -0.01287821f, 0.02532481f, 
    0.03728471f, -0.01313100f, 0.05609526f, 0.00008731f, -0.02573545f, 0.02395950f, 0.04129524f, -0.04828724f, 
    -0.05396517f, -0.06901500f, 0.03667766f, 0.02022810f, -0.06529061f, 0.00945097f, 0.01300253f, -0.03119418f, 
    0.05750848f, -0.06969125f, -0.02865212f, -0.04718499f, 0.00768474f, -0.03112315f, -0.07054896f, -0.04754798f, 
    -0.04917915f, -0.00235450f, 0.05289876f, 0.03298453f, -0.07958401f, -0.00483645f, -0.00869455f, 0.03586870f, 
    -0.07271554f, -0.26511055f, -0.27189675f, 0.23228787f, 0.04644767f, 0.09067161f, 0.06604592f, 0.08729867f, 
    -0.11368448f, -0.10750277f, 0.16755831f, 0.01959200f, 0.05875012f, -0.11406457f, 0.09886502f, -0.01940263f, 
    -0.19491351f, -0.08854230f, -0.05564115f, 0.13131768f, 0.10518123f, 0.07736161f, 0.09463201f, 0.05675046f, 
    -0.47332489f, -0.10980748f, -0.09489075f, 0.17951673f, 0.11885706f, 0.06651605f, 0.05956521f, -0.05737952f, 
    0.10421254f, 0.06373545f, 0.06584143f, 0.18609510f, 0.09503882f, -0.14985134f, 0.00411901f, 0.09484328f, 
    0.05655501f, -0.08475792f, 0.11398046f, 0.12556612f, 0.11947611f, 0.12795018f, 0.01636291f, 0.14089736f, 
    0.26657784f, -0.02087406f, -0.17553593f, 0.17974016f, 0.03483905f, -0.06993710f, -0.08189110f, 0.04051546f, 
    0.12859318f, 0.04046371f, -0.05532794f, -0.22734776f, -0.08164807f, 0.02779353f, 0.07919952f, 0.19825479f, 
    -0.02691805f, -0.01250733f, -0.02448149f, 0.13706014f, -0.03004662f, 0.08555029f, -0.04660009f, 0.19018082f, 
    -0.27516335f, 0.00874521f, -0.23021910f, -0.06016703f, 0.10561604f, 0.06812074f, -0.08189596f, -0.03923497f, 
    0.07967305f, 0.04456586f, -0.00585137f, 0.20166472f, -0.03282167f, 0.25830090f, 0.03914388f, -0.22701268f, 
    -0.01112730f, -0.07949797f, 0.16414888f, 0.23303939f, 0.15088427f, 0.06485596f, -0.11516871f, 0.08629727f, 
    -0.14642920f, 0.06606719f, -0.01076678f, -0.06221194f, 0.02181272f, 0.01490951f, -0.04594653f, -0.07471407f, 
    -0.06218603f, -0.12460116f, -0.01886930f, 0.06354191f, -0.37351030f, -0.05382068f, -0.05026818f, -0.14812382f, 
    -0.02531334f, 0.01943861f, 0.06311370f, 0.06585069f, 0.01637051f, -0.02836217f, 0.12668179f, -0.03281590f, 
    0.21776412f, 0.36122119f, -0.05709036f, 0.23102473f, -0.13819267f, -0.02559580f, 0.02918774f, 0.04245825f, 
    0.07554965f, -0.04346059f, -0.19536592f, -0.05899714f, -0.14309639f, 0.18322465f, 0.27273551f, -0.15332057f, 
    -0.01006595f, 0.03373642f, -0.14708371f, -0.08232054f, 0.16533284f, -0.05459164f, -0.04196991f, 0.04246118f, 
    0.00328051f, 0.04456772f, -0.11526030f, 0.01452505f, -0.03054348f, 0.13366856f, 0.01272216f, -0.00209854f, 
    -0.07870424f, 0.00084051f, 0.16308281f, -0.17752153f, -0.00628693f, -0.07056651f, -0.02200472f, 0.03785896f, 
    0.04919396f, 0.09211066f, 0.08011291f, -0.01806739f, 0.03827688f, -0.05583528f, -0.00837853f, -0.05905741f, 
    0.20556141f, 0.14134111f, -0.04593470f, -0.24005169f, -0.01005031f, 0.07023852f, 0.18334860f, -0.02475398f, 
    -0.00210250f, 0.06786320f, -0.03623065f, -0.06797156f, 0.30612323f, -0.22199859f, -0.04414352f, 0.03146791f, 
    -0.02858724f, 0.06251252f, 0.04041497f, 0.13829558f, 0.03545107f, 0.01577206f, -0.03774269f, 0.26603118f, 
    -0.01824824f, -0.08788166f, -0.03685418f, -0.08091293f, 0.00823766f, 0.03507875f, -0.01011768f, 0.02072854f, 
    -0.05311859f, 0.04968538f, 0.02145633f, -0.07479323f, -0.03663680f, -0.08762033f, -0.04103122f, -0.00090334f, 
    -0.03038643f, -0.05387023f, -0.02824357f, 0.05455460f, -0.07484072f, 0.02249850f, 0.04627209f, -0.01152508f, 
    -0.04796896f, -0.05383118f, -0.08047680f, -0.08490026f, -0.08325950f, -0.06791902f, -0.03798088f, 0.04583731f, 
    -0.06821062f, -0.00652756f, -0.05985520f, 0.02958603f, -0.05210525f, -0.03470818f, -0.06592356f, -0.00302523f, 
    -0.06757593f, 0.04030273f, 0.03505657f, 0.07237498f, -0.01433786f, -0.04377674f, -0.03026688f, -0.07338430f, 
    -0.10319272f, 0.00532031f, -0.01889578f, 0.00369768f, -0.04635162f, -0.05034873f, 0.01571416f, -0.00979111f, 
    -0.08431632f, -0.00151768f, 0.00106864f, -0.01088512f, -0.02439386f, 0.01923292f, 0.04178726f, -0.09130382f, 
    0.03873738f, -0.04651611f, 0.04672507f, -0.04790496f, 0.04763709f, -0.00224513f, -0.05730784f, -0.02141904f, 
    -0.04576022f, 0.05568774f, -0.00835752f, 0.07528552f, -0.03759694f, 0.05343094f, 0.03985933f, -0.07140920f, 
    0.04503144f, -0.02676519f, 0.05604955f, 0.05420329f, -0.05501463f, -0.00686638f, 0.01964095f, 0.00717189f, 
    0.02519426f, -0.06116877f, -0.02990613f, -0.07059173f, -0.00653202f, -0.01066435f, -0.03201104f, 0.01466719f, 
    0.05872454f, -0.06649133f, -0.08647142f, -0.07227208f, -0.04559753f, 0.00882207f, 0.05245987f, -0.02681391f, 
    -0.05209376f, -0.02141251f, 0.04499744f, 0.00733964f, -0.08582430f, 0.02996660f, -0.05304619f, -0.05054437f, 
    -0.01302259f, -0.01705614f, -0.02588527f, 0.03518033f, -0.10744087f, -0.08978982f, -0.05231983f, -0.04920583f, 
    0.03114088f, -0.05174554f, -0.06444576f, -0.00074480f, 0.00458089f, 0.05137834f, -0.02641663f, -0.05911656f, 
    0.00561178f, -0.06516496f, -0.05843491f, 0.01348472f, 0.03608982f, -0.06693981f, -0.00483757f, 0.04262409f, 
    0.06061719f, -0.05022106f, -0.01283050f, -0.05621269f, -0.00305627f, -0.07575278f, 0.02385443f, 0.00195584f, 
    -0.07934784f, -0.06951392f, -0.06289113f, 0.04149919f, 0.00694340f, -0.09726183f, -0.00832069f, -0.00857577f, 
    -0.07640340f, 0.01110377f, -0.01567566f, 0.05412059f, -0.06051643f, -0.02338334f, 0.04733131f, -0.07629067f, 
    -0.02205120f, 0.02448411f, -0.02556861f, 0.03693847f, -0.01577905f, 0.04415990f, 0.05788721f, -0.02924190f, 
    0.04596934f, 0.00366526f, -0.01737074f, -0.05003215f, 0.02136543f, -0.03104750f, 0.07514711f, 0.03006163f, 
    -0.07142811f, -0.05120505f, 0.04801956f, 0.01481283f, -0.01155796f, -0.00051684f, -0.06226378f, -0.06123823f, 
    -0.08733247f, 0.02779211f, -0.05317096f, -0.03592183f, 0.03354197f, -0.04064013f, -0.04007554f, -0.01704703f, 
    -0.41887003f, -0.07764427f, -0.15560754f, 0.11836302f, 0.22953428f, 0.04572983f, -0.07250486f, 0.04314513f, 
    0.22088990f, 0.08948987f, 0.09444033f, 0.16915910f, -0.03167439f, -0.08778938f, -0.04736675f, 0.02990571f, 
    0.06142299f, 0.02167106f, -0.08051387f, 0.05324077f, 0.07324020f, 0.14684328f, -0.21436438f, -0.05734472f, 
    0.14434871f, 0.26144999f, 0.39707589f, 0.03009637f, 0.02987046f, -0.07078787f, 0.11101577f, -0.05304869f, 
    -0.07031717f, 0.03957718f, 0.17866133f, 0.08796414f, -0.04416133f, 0.20329911f, 0.21529004f, 0.12192132f, 
    -0.05312594f, 0.02058596f, 0.13300073f, 0.07029329f, 0.02357322f, 0.07776238f, -0.06280759f, 0.02486577f, 
    -0.21773157f, -0.20644517f, -0.40674353f, 0.14271757f, 0.05470152f, 0.07248850f, 0.03137994f, -0.02836204f, 
    -0.00310940f, -0.13695060f, -0.03159700f, 0.03800791f, 0.13358809f, -0.08191551f, 0.12761837f, 0.02209328f, 
    -0.10162150f, -0.16917880f, -0.10799184f, 0.12753662f, 0.07012461f, 0.05360619f, 0.23212731f, 0.13396624f, 
    -0.05293009f, -0.11102911f, -0.17409614f, -0.30326712f, 0.09285924f, 0.03499295f, -0.07342470f, 0.02839190f, 
    -0.10072675f, 0.04285813f, 0.05562022f, 0.05162800f, 0.62255323f, 0.03398832f, 0.08432979f, 0.09820858f, 
    0.04611889f, -0.05333215f, -0.05869269f, 0.12623723f, -0.13831964f, 0.06327461f, 0.02481308f, 0.13192837f, 
    0.10922809f, 0.06373397f, 0.09222538f, 0.37711373f, -0.04369359f, -0.04717917f, -0.03383067f, -0.02938466f, 
    0.06541319f, 0.03440316f, 0.22968940f, 0.15843259f, 0.31477913f, -0.06220295f, 0.16265902f, 0.16067587f, 
    0.01580916f, 0.18034768f, -0.02222967f, 0.13558866f, -0.08887246f, 0.12592623f, 0.08966784f, 0.05775123f, 
    -0.12859981f, 0.00772175f, -0.21053094f, -0.14331619f, 0.24224032f, 0.09239016f, -0.05658593f, 0.13785014f, 
    0.01701220f, 0.01014568f, 0.04403619f, 0.08605243f, -0.16172878f, -0.21781343f, -0.09843361f, -0.24390037f, 
    0.26036647f, 0.12673178f, -0.02870540f, -0.01695899f, -0.04940793f, -0.14296128f, 0.05787603f, -0.06058905f, 
    -0.10700536f, -0.15177916f, -0.05713786f, -0.44048434f, 0.10783920f, 0.16386601f, -0.01157537f, -0.36152858f, 
    -0.12661992f, -0.09115262f, 0.06050312f, -0.00491774f, 0.15930957f, 0.24236856f, -0.25152323f, -0.05926469f, 
    0.06867909f, 0.11047136f, -0.00951706f, -0.00883738f, 0.05335694f, -0.02690251f, 0.02471987f, 0.15469421f, 
    0.34182295f, -0.00729225f, 0.14585809f, -0.05645559f, 0.15259755f, -0.01886963f, 0.16362402f, -0.00421086f, 
    -0.13740146f, -0.02943867f, -0.03552245f, -0.14874110f, -0.18146048f, -0.02079674f, 0.21755844f, 0.09985064f, 
    -0.04977540f, 0.07092616f, 0.06837429f, 0.09605442f, -0.01577053f, -0.00458014f, -0.08074331f, -0.10951898f, 
    -0.03279940f, 0.01163124f, -0.00910496f, -0.06781514f, -0.00579986f, 0.02854440f, -0.01458047f, 0.00161111f, 
    0.02768402f, 0.01201460f, 0.05681898f, 0.02917322f, 0.04985916f, 0.04789800f, -0.06673669f, 0.05733388f, 
    0.06001734f, -0.05227619f, -0.01096561f, 0.05324191f, -0.00165141f, -0.05392109f, -0.05621488f, 0.03842024f, 
    -0.07154930f, 0.02268986f, -0.06781852f, -0.06963243f, -0.02040834f, 0.00256914f, 0.03317377f, -0.02594469f, 
    0.02573887f, -0.07240885f, 0.04189041f, -0.00730036f, 0.01323139f, -0.05876959f, 0.01221293f, 0.00632157f, 
    0.00277377f, 0.00846918f, -0.03662280f, 0.02308755f, -0.04719184f, 0.04802217f, -0.01340673f, 0.04829863f, 
    -0.01911603f, -0.03189522f, 0.04454328f, 0.05046814f, 0.02093440f, -0.02813413f, -0.00905183f, -0.04532777f, 
    0.03461758f, -0.04174476f, 0.01254271f, 0.02499479f, 0.02566500f, -0.04016411f, -0.05838215f, 0.03778674f, 
    -0.02426841f, 0.03272035f, 0.00849629f, 0.05630456f, -0.05942513f, -0.08072539f, 0.05156820f, -0.07707449f, 
    0.04985316f, -0.01641836f, 0.03832451f, 0.02960925f, 0.00274605f, 0.00041512f, -0.01990632f, -0.00405168f, 
    0.04162387f, -0.07551824f, -0.07430540f, -0.06504144f, -0.04541192f, -0.06408124f, 0.04718004f, 0.05734900f, 
    -0.07059699f, 0.05573423f, 0.00242890f, -0.04064709f, 0.00536639f, 0.02454644f, -0.08049203f, 0.02528152f, 
    -0.00182652f, 0.05254719f, -0.03326466f, -0.04685883f, 0.00374676f, -0.06221701f, 0.01159052f, 0.05912902f, 
    -0.03336687f, -0.04099844f, -0.00942648f, -0.06912180f, -0.07525197f, 0.01660467f, 0.00686445f, -0.08083193f, 
    -0.06357539f, -0.05064127f, -0.04987666f, -0.05772846f, 0.05966176f, 0.05910837f, -0.01930703f, 0.00734089f, 
    0.03428064f, 0.03496621f, 0.01622950f, -0.04429431f, 0.01632345f, 0.00184992f, -0.04119494f, 0.02832749f, 
    0.04712398f, 0.01436551f, -0.04889455f, 0.05345839f, -0.04856238f, 0.00321057f, -0.02910317f, 0.03398303f, 
    0.00142169f, -0.00826806f, -0.01053959f, -0.03946909f, -0.07611160f, -0.06476928f, 0.05377845f, -0.03752802f, 
    -0.02230808f, -0.06650475f, 0.02335333f, 0.05007463f, -0.02821024f, -0.02470784f, -0.03110654f, -0.05533119f, 
    -0.01771180f, -0.04155475f, 0.03099773f, -0.04502161f, -0.05372049f, -0.05660252f, 0.05596048f, 0.01571141f, 
    -0.02716931f, -0.05645411f, -0.04005744f, 0.05582917f, -0.02378109f, 0.05099830f, -0.04828602f, -0.08086530f, 
    -0.00231652f, -0.06192991f, -0.05469288f, -0.03103807f, 0.02706231f, 0.02620982f, -0.00060480f, -0.06485194f, 
    0.03544961f, 0.02060889f, -0.00969584f, 0.04987245f, 0.05565567f, -0.03018851f, -0.04365787f, 0.06075843f, 
    -0.07609636f, -0.02915060f, -0.04522493f, -0.00692935f, -0.07163157f, -0.06625037f, -0.01412751f, -0.06117636f, 
    0.37798756f, 0.06647365f, 0.06178108f, -0.05406524f, -0.18314371f, -0.00711621f, -0.10706050f, -0.16348866f, 
    -0.12725268f, -0.01716227f, -0.05193126f, -0.03462784f, -0.02380981f, 0.14145420f, -0.04500227f, -0.21985263f, 
    -0.02948522f, -0.10788500f, 0.02073925f, -0.03259232f, -0.05932095f, -0.07346026f, 0.07839140f, 0.12711766f, 
    0.23077226f, -0.14091411f, -0.06965856f, 0.03411459f, 0.21305704f, 0.03149285f, -0.07438093f, 0.06088263f, 
    0.06893766f, 0.07720185f, -0.06831658f, -0.01750734f, 0.21327282f, 0.08662249f, -0.02396311f, 0.02205305f, 
    0.18148655f, 0.07995155f, -0.10535242f, -0.13646527f, 0.03361894f, -0.02007728f, 0.12088416f, -0.05888387f, 
    0.21329346f, 0.06089955f, 0.19911420f, -0.19162889f, -0.09254448f, -0.02638938f, 0.04735521f, -0.01898628f, 
    -0.05895269f, 0.12915429f, 0.08098749f, -0.08393187f, -0.26470196f, 0.20977192f, 0.09827937f, 0.17470574f, 
    0.12709852f, 0.14865430f, 0.12446158f, -0.01142776f, -0.04034991f, 0.08886496f, -0.09208266f, -0.02773691f, 
    0.19336003f, 0.07725336f, 0.11757530f, 0.17044851f, 0.00161086f, -0.02740476f, -0.00603994f, -0.02638698f, 
    -0.07482079f, -0.09191023f, -0.08514263f, 0.06770319f, -0.36098900f, -0.14769410f, 0.08220826f, -0.09352411f, 
    0.10071747f, 0.08357024f, -0.00843123f, -0.14945421f, -0.07222191f, -0.12668316f, 0.10895065f, -0.00122276f, 
    -0.26384681f, 0.05932442f, 0.01416031f, -0.15768680f, 0.04725366f, 0.13616161f, 0.05811953f, 0.08304844f, 
    -0.17975070f, 0.02824678f, -0.06671900f, -0.02578509f, -0.19214085f, 0.07167956f, -0.11329404f, -0.05308434f, 
    -0.10227906f, -0.09407780f, -0.21188873f, -0.00190609f, 0.10714778f, 0.01250632f, -0.02145061f, 0.05861099f, 
    0.06006751f, -0.12067463f, 0.33500803f, 0.17115960f, 0.05670809f, -0.12619275f, 0.04421616f, -0.31701851f, 
    0.07743038f, 0.08299130f, -0.05376509f, 0.00698818f, -0.00519465f, 0.06383692f, -0.09256002f, 0.08524267f, 
    -0.26538828f, -0.12991278f, -0.00677453f, 0.05657148f, -0.03948147f, 0.05657761f, -0.17474927f, -0.04631868f, 
    -0.17966266f, -0.02833322f, -0.04913801f, 0.07973649f, 0.10453051f, -0.00854570f, -0.07665551f, 0.08004988f, 
    0.07475027f, 0.01729374f, -0.07682680f, 0.08660602f, -0.23084062f, -0.05445235f, 0.41845983f, 0.29733738f, 
    -0.05150183f, -0.12034751f, 0.05460127f, -0.02558065f, -0.12133648f, -0.07561753f, -0.05394789f, -0.10184429f, 
    -0.15863577f, 0.19185817f, 0.17766067f, 0.27176464f, 0.07730474f, 0.10414466f, -0.09349882f, 0.01969928f, 
    0.09990016f, -0.09835178f, 0.15819861f, 0.18419793f, 0.24899895f, 0.29854670f, -0.10475872f, 0.07745991f, 
    0.15381378f, 0.04880739f, -0.04441484f, 0.04907391f, 0.04458698f, -0.01477284f, 0.14724870f, 0.16189985f, 
    -0.23897295f, 0.18552665f, -0.22992796f, -0.36601931f, -0.07945611f, -0.04597625f, 0.04706252f, 0.06839572f, 
    0.10314043f, -0.00193652f, 0.19076546f, 0.08161097f, 0.25036961f, 0.20037216f, 0.09130142f, -0.15401840f, 
    0.05883135f, 0.04232291f, -0.09311226f, -0.12775183f, -0.07977502f, -0.20076366f, -0.07091828f, -0.31745857f, 
    -0.25783440f, 0.01900894f, -0.05819196f, -0.01909002f, 0.19039045f, -0.03122300f, 0.04843740f, 0.13970730f, 
    0.00073292f, -0.02324079f, -0.05538064f, -0.03314864f, 0.20192561f, -0.26430738f, -0.29257512f, -0.24380903f, 
    -0.10822862f, -0.07374925f, 0.00862204f, 0.09996384f, 0.10111418f, 0.10119776f, -0.06720406f, 0.33726156f, 
    0.04024261f, 0.25426143f, 0.17331798f, -0.28159645f, 0.17075218f, -0.01687796f, -0.13894564f, -0.28354129f, 
    -0.05147744f, -0.25115654f, 0.01982514f, -0.12517041f, -0.16379638f, 0.01495020f, -0.15943769f, -0.31710240f, 
    0.20912969f, 0.04644588f, 0.12525108f, 0.01110710f, -0.11165737f, -0.09006102f, 0.02905517f, 0.13175750f, 
    0.05487160f, 0.11238919f, -0.08847383f, 0.13024271f, -0.01128425f, -0.18084514f, 0.15252165f, 0.07918082f, 
    0.14893174f, 0.01315477f, -0.17067295f, -0.04967482f, -0.06639718f, -0.17544532f, 0.20660989f, 0.16304004f, 
    0.17660317f, 0.06211716f, 0.11926805f, 0.06562772f, 0.14582610f, 0.18370755f, 0.21079604f, 0.14205240f, 
    -0.27440295f, 0.16629581f, 0.06884141f, 0.28522873f, 0.01904846f, 0.04543203f, 0.08236104f, -0.01895009f, 
    -0.17415711f, 0.20769632f, 0.19492736f, 0.27966949f, -0.42035615f, 0.07373176f, -0.04693956f, 0.29619947f, 
    -0.03918910f, 0.09802429f, 0.12273882f, -0.05425605f, 0.15257747f, 0.02806995f, 0.03343955f, 0.12040033f, 
    0.36499053f, 0.05353915f, 0.23101801f, 0.17441139f, -0.00168715f, 0.09317457f, 0.01898177f, -0.04992417f, 
    0.02454103f, -0.14541554f, -0.22648375f, 0.16508864f, 0.49632126f, 0.04363985f, -0.02464355f, 0.13403922f, 
    0.10554188f, 0.07969357f, -0.19127113f, 0.02189087f, -0.20828153f, -0.27345392f, -0.03804095f, -0.12338923f, 
    -0.23305573f, 0.05068556f, 0.13746892f, -0.11446462f, 0.03337282f, -0.08486528f, 0.09997196f, 0.12238787f, 
    -0.02611675f, 0.01524550f, 0.14281629f, 0.11734962f, 0.09693591f, 0.07890119f, 0.31032693f, 0.34781510f, 
    0.08529257f, -0.04828743f, -0.01280587f, 0.18281645f, 0.02254177f, 0.04797899f, 0.16259857f, 0.24031709f, 
    0.09865221f, -0.30758449f, 0.11696469f, 0.41911498f, 0.00169100f, -0.23588136f, -0.13804621f, -0.05329696f, 
    0.10762953f, -0.20001623f, -0.17366990f, -0.10774474f, -0.08120130f, -0.16178095f, -0.00645317f, -0.23557039f, 
    0.11273231f, -0.04889939f, -0.01184570f, -0.04532359f, 0.12946707f, -0.02404166f, 0.04461955f, -0.03261719f, 
    0.05065591f, 0.01702693f, -0.06035076f, -0.03990924f, 0.01743498f, 0.03442688f, 0.06239519f, -0.03711455f, 
    -0.06209280f, -0.05341929f, 0.05018751f, -0.04812018f, -0.03636217f, 0.01022804f, -0.05712492f, -0.07065460f, 
    -0.00360115f, -0.00267300f, 0.03704572f, 0.05140910f, 0.05437542f, -0.05247789f, -0.00746058f, -0.03396536f, 
    -0.05101241f, 0.02816795f, -0.05096920f, -0.06525655f, 0.04575642f, -0.03500330f, -0.02579309f, -0.00102252f, 
    -0.03724769f, 0.01659362f, -0.05716359f, -0.02299191f, -0.04557494f, 0.02414846f, 0.04398682f, 0.02338316f, 
    0.05591032f, 0.01030562f, 0.03325981f, -0.00864844f, 0.04472270f, 0.02813538f, 0.04895436f, -0.02256272f, 
    -0.02861949f, -0.03476620f, 0.04070293f, -0.02065929f, -0.03646436f, 0.05998918f, 0.06319246f, -0.05505322f, 
    0.01503346f, -0.00753350f, 0.01309798f, 0.03274370f, 0.00915855f, -0.02546760f, -0.05721576f, 0.02924989f, 
    -0.04525770f, -0.02978718f, -0.00400634f, -0.01181614f, -0.00987056f, -0.01326793f, 0.04332179f, -0.02313106f, 
    -0.02106556f, -0.00741969f, -0.02629264f, -0.03698276f, 0.01856565f, 0.04430958f, -0.05843355f, 0.04921200f, 
    -0.02282987f, -0.06147825f, -0.05339488f, -0.05632314f, -0.03531784f, 0.05425270f, 0.06222362f, -0.00823315f, 
    0.02770050f, 0.05894833f, -0.07282463f, 0.05112780f, -0.01224968f, -0.01652307f, -0.02527703f, 0.01592663f, 
    0.02240295f, -0.03803110f, -0.04979101f, -0.02502723f, 0.02711850f, -0.01858904f, 0.03609368f, -0.01542356f, 
    -0.07038917f, -0.04581188f, -0.01615017f, -0.01068243f, -0.00432448f, -0.05668475f, -0.03047408f, 0.05156369f, 
    0.04981438f, 0.03624233f, 0.03663804f, 0.02145726f, 0.06253398f, 0.06043667f, 0.03212494f, -0.07723694f, 
    -0.01290824f, 0.06311201f, 0.03593495f, -0.01550475f, 0.01746132f, -0.02930071f, -0.05303912f, -0.00409346f, 
    -0.05673780f, -0.00343727f, 0.01137453f, -0.02731519f, -0.07708342f, 0.04425427f, -0.06271899f, -0.06641591f, 
    -0.03015909f, 0.04265106f, 0.05974258f, -0.06516001f, 0.05236172f, 0.02383909f, 0.06104529f, -0.00087494f, 
    -0.07526247f, 0.03563724f, -0.02762025f, 0.06479719f, -0.03823123f, -0.05865896f, -0.06212371f, -0.02820951f, 
    -0.04808667f, -0.00338445f, -0.00459261f, -0.01804370f, 0.03842729f, -0.00980284f, -0.05435524f, -0.06895337f, 
    -0.06416381f, 0.05133845f, -0.07288741f, 0.00002350f, -0.01993730f, -0.04592836f, -0.07379651f, -0.07661964f, 
    -0.06999999f, -0.04119102f, -0.00091286f, -0.01021844f, -0.02815792f, -0.05959985f, -0.06941996f, 0.03626033f, 
    -0.04019779f, -0.06366748f, -0.02006941f, -0.04126089f, -0.07765729f, -0.06950846f, -0.02457218f, 0.00390107f, 
    -0.07614519f, 0.03451749f, -0.07438450f, -0.01188279f, 0.05222369f, 0.00979143f, 0.04979480f, -0.04113934f, 
    -0.75576663f, -0.05541068f, -0.21187203f, -0.02342225f, 0.13343215f, 0.01813069f, 0.04654125f, 0.17103633f, 
    0.08059566f, -0.02715045f, 0.10449188f, 0.11905900f, 0.30980536f, 0.03944023f, 0.12584469f, -0.00613670f, 
    -0.07009329f, 0.07522969f, -0.03927127f, 0.06112951f, 0.02378319f, 0.06892005f, -0.19267939f, -0.04837773f, 
    -0.61356503f, 0.21998677f, 0.12618041f, -0.07663315f, 0.13302211f, -0.00712626f, 0.25278693f, 0.00814633f, 
    0.02256660f, -0.07789836f, -0.01933718f, 0.05594874f, -0.14450726f, -0.33049902f, -0.15510735f, -0.22639942f, 
    -0.18631540f, -0.00708401f, 0.09173410f, -0.04977994f, 0.18686460f, 0.06331632f, -0.01902926f, 0.35068479f, 
    -0.20622072f, 0.14633083f, 0.01199332f, 0.04205423f, 0.01993382f, 0.08199988f, -0.04832705f, 0.12086816f, 
    0.01123479f, 0.02557534f, 0.08952153f, -0.04244005f, -0.16744021f, -0.06270483f, -0.13999970f, -0.18210959f, 
    -0.16051756f, -0.08920118f, 0.02360181f, 0.05950859f, -0.06333925f, -0.02732804f, 0.04556204f, 0.15045145f, 
    -0.36158863f, 0.08207760f, -0.08436923f, -0.15392001f, -0.03409786f, -0.06805029f, 0.05701192f, 0.13337249f, 
    0.17463455f, 0.10620522f, -0.03409965f, 0.08462194f, 0.10057381f, -0.22011663f, 0.10453323f, 0.00328675f, 
    0.15044615f, -0.11689799f, 0.02204522f, 0.03854070f, 0.12264600f, 0.05663045f, 0.01920365f, 0.15261972f, 
    -0.08730266f, 0.06115047f, 0.09202576f, 0.21699482f, -0.07898624f, -0.09441133f, 0.00842724f, -0.10138851f, 
    0.15284590f, 0.25147957f, 0.23043492f, 0.20524925f, -0.25002944f, -0.19973987f, -0.03648046f, 0.33578739f, 
    0.16624336f, 0.31098640f, 0.21636353f, 0.14912805f, 0.08187771f, 0.08942505f, -0.01826729f, 0.07283366f, 
    0.01156544f, 0.06957968f, 0.05943531f, 0.15851714f, 0.11658238f, 0.06148557f, 0.12272341f, 0.25047567f, 
    -0.09178168f, 0.00388999f, -0.02618237f, 0.12833889f, 0.30521807f, -0.03154137f, 0.11237478f, 0.03663357f, 
    0.09173013f, 0.11802498f, -0.00587312f, 0.10374191f, 0.11993370f, -0.03045151f, 0.04180640f, -0.03506105f, 
    -0.04363783f, -0.02383542f, 0.08432002f, -0.15923992f, 0.02050196f, -0.13013339f, -0.00025978f, 0.20360479f, 
    -0.05461119f, 0.04601076f, 0.16765262f, -0.03962338f, 0.25866535f, 0.11125422f, -0.19113256f, 0.17885607f, 
    -0.02178467f, 0.21381433f, -0.01408530f, 0.12678419f, 0.20356081f, 0.01541132f, 0.01323388f, 0.09309713f, 
    0.12261304f, -0.08051681f, -0.07528450f, 0.07494728f, -0.06946169f, -0.20238899f, 0.13679440f, -0.09979393f, 
    0.09392903f, -0.17456737f, -0.11371303f, -0.07570761f, -0.17768551f, -0.31507045f, -0.06918082f, 0.17546453f, 
    0.04224258f, 0.09609944f, -0.04165322f, -0.05540771f, 0.08951712f, -0.05687188f, 0.08579037f, -0.05912079f, 
    0.46439540f, -0.31559023f, 0.06517828f, 0.17089079f, -0.02118417f, -0.02350572f, -0.11698580f, -0.04586356f, 
    -0.07141784f, 0.03681542f, -0.04647816f, -0.03827881f, 0.18818174f, -0.08055885f, -0.10492657f, 0.18279293f, 
    -0.12847003f, 0.01587197f, 0.15533705f, 0.13251497f, 0.05427766f, -0.05014489f, 0.01867067f, 0.02467390f, 
    -0.07719918f, -0.12888585f, 0.06214013f, 0.28283671f, -0.08577869f, -0.05102634f, -0.18054698f, -0.00285473f, 
    -0.06534484f, -0.09105694f, 0.05762067f, 0.11580780f, 0.15435104f, 0.13825780f, 0.09938593f, 0.18883260f, 
    -0.00195908f, 0.03920506f, 0.03335764f, 0.02796667f, -0.05488841f, -0.04098514f, -0.02965669f, 0.03718174f, 
    0.46890706f, -0.03954652f, 0.13993363f, 0.28105068f, -0.19937815f, 0.05796719f, 0.00807066f, -0.03260761f, 
    0.10334976f, -0.14898504f, -0.12595135f, -0.05293258f, 0.16005339f, 0.14821650f, -0.02517799f, 0.01501531f, 
    0.06309419f, -0.07548507f, 0.03821838f, -0.06289086f, 0.01869124f, -0.04305784f, 0.04825411f, 0.03148256f, 
    0.29577035f, -0.03692329f, -0.14226425f, 0.15934955f, -0.06195274f, -0.07328311f, 0.14965613f, 0.05466185f, 
    -0.05469024f, -0.06199834f, 0.04485559f, 0.01142502f, -0.46504942f, 0.14875633f, -0.11090165f, 0.06236093f, 
    -0.11582426f, 0.04708180f, -0.02574297f, 0.01502769f, 0.13338818f, -0.01836190f, 0.17233925f, 0.05378239f, 
    0.16066894f, 0.14010245f, 0.00197755f, -0.11360749f, 0.07689004f, -0.08520843f, 0.04227230f, 0.06545608f, 
    0.03181352f, -0.01119066f, -0.13118050f, -0.06212781f, 0.19234854f, -0.03093037f, -0.03312477f, -0.39209428f, 
    -0.07987116f, -0.12391971f, -0.00701107f, 0.14520191f, -0.06939492f, -0.00153459f, -0.07079733f, -0.05321218f, 
    -0.42028743f, 0.69369221f, 0.01847929f, -0.31581348f, -0.08863211f, 0.06175816f, 0.20865926f, -0.04202513f, 
    -0.00857300f, 0.05361620f, -0.04471036f, -0.01670199f, -0.01936481f, -0.17780510f, 0.09002388f, 0.49576223f, 
    -0.05619955f, -0.01285042f, 0.01035900f, 0.09064561f, -0.02499296f, 0.02633204f, -0.11183840f, 0.07777663f, 
    0.12322902f, 0.07186639f, -0.02731395f, 0.32407814f, -0.17749803f, 0.00777059f, 0.14523694f, 0.04555068f, 
    0.05394830f, -0.03437128f, 0.12476750f, -0.11592877f, 0.52905309f, 0.04210880f, 0.01814440f, 0.09971671f, 
    0.01260494f, -0.03224032f, 0.09007570f, 0.06663569f, -0.04668142f, 0.11505729f, -0.02073486f, 0.03474901f, 
    0.05080264f, 0.19633839f, -0.14983241f, -0.04516013f, -0.08111170f, -0.02898971f, 0.15187439f, 0.27780971f, 
    0.19500366f, 0.09822803f, 0.05900413f, -0.06105236f, 0.06546199f, 0.05951025f, -0.05643068f, -0.27247083f, 
    -0.02931910f, -0.06532252f, -0.01947324f, 0.04299437f, -0.00965519f, -0.03815520f, 0.02277799f, 0.07558924f, 
    0.09002151f, 0.27027115f, -0.13375857f, -0.09405646f, 0.06203531f, 0.03498393f, 0.09255894f, -0.19050585f, 
    0.19699590f, -0.00070707f, -0.04074037f, -0.06902125f, -0.11429698f, -0.35487106f, 0.00739599f, 0.06240838f, 
    0.13890292f, 0.19399229f, 0.11626197f, -0.00322242f, 0.01597968f, -0.16510937f, 0.09074043f, 0.20958842f, 
    0.27517110f, -0.12558949f, 0.21163763f, -0.20772107f, 0.23119342f, -0.06745765f, -0.07794818f, 0.08476095f, 
    0.00636010f, 0.03864891f, -0.00311883f, 0.13912350f, -0.26053506f, 0.23806877f, 0.00083781f, 0.06953984f, 
    -0.10364877f, 0.03190415f, 0.03911477f, 0.16520593f, 0.06728204f, -0.07490595f, 0.15867940f, -0.22485983f, 
    -0.12745012f, -0.23964691f, -0.22124484f, 0.19498511f, 0.09830998f, -0.02605858f, 0.03909529f, -0.14194094f, 
    -0.01982959f, 0.02762189f, 0.20251516f, 0.24026413f, -0.16538103f, 0.07829750f, 0.23420992f, 0.25456315f, 
    0.07554266f, 0.08533981f, -0.02451140f, -0.02366666f, 0.03658728f, 0.02997947f, -0.12869683f, -0.12237878f, 
    -0.09162647f, -0.33377358f, -0.01671689f, -0.07476147f, 0.19639225f, 0.14550756f, -0.09460860f, -0.13429086f, 
    -0.12001725f, -0.05068625f, -0.06263719f, 0.06805421f, 0.02364188f, 0.11679034f, 0.12698317f, -0.01872544f, 
    0.03720381f, -0.05016636f, -0.02304952f, 0.06953563f, -0.03001168f, -0.04414368f, 0.01412552f, -0.09850731f, 
    -0.16154996f, 0.03413162f, 0.16388933f, 0.03673018f, -0.00056935f, 0.00855814f, -0.00528916f, 0.19245338f, 
    -0.02806596f, -0.09011986f, 0.00095300f, 0.07065944f, -0.02583379f, 0.02673669f, -0.14702028f, 0.10959469f, 
    -0.06071665f, 0.02357338f, -0.00807734f, 0.01717968f, 0.12596342f, 0.06999731f, 0.02544930f, 0.02094126f, 
    -0.07598782f, 0.23004645f, -0.02389324f, 0.01001090f, 0.02989467f, 0.00956685f, -0.16272427f, 0.10154611f, 
    0.06709667f, -0.02245156f, 0.18860136f, 0.05166843f, -0.16349053f, -0.35210001f, -0.11437242f, 0.19471614f, 
    0.11317431f, 0.04706918f, 0.03745359f, 0.00513946f, 0.10336222f, 0.04640434f, 0.03096191f, -0.09656978f, 
    -0.11038517f, -0.02766284f, -0.05899152f, -0.02787494f, 0.02299430f, 0.09286657f, -0.08078487f, 0.05179073f, 
    0.15811847f, 0.13753293f, -0.13542327f, 0.14507827f, 0.07887710f, 0.19719347f, 0.12589538f, 0.27281791f, 
    0.12666014f, 0.11790121f, -0.13020641f, 0.09777808f, 0.11536267f, -0.03043654f, 0.01758923f, -0.06323414f, 
    0.03296264f, -0.04621816f, 0.18129867f, -0.03159487f, 0.09739629f, 0.01264853f, -0.24347134f, -0.01380650f, 
    0.09308890f, -0.02888224f, 0.07542206f, 0.15264705f, -0.10155549f, 0.43192309f, 0.19860797f, 0.12702991f, 
    0.04937232f, -0.03506977f, -0.03120689f, 0.16834098f, -0.03750195f, -0.03541185f, 0.15025173f, 0.08327349f, 
    -0.09445437f, 0.02823806f, -0.19338883f, -0.13873917f, 0.05428843f, -0.04759934f, 0.08370841f, -0.03582637f, 
    0.12871151f, 0.04705827f, 0.11616754f, -0.07184956f, 0.01528876f, -0.12824121f, -0.13606958f, -0.00588156f, 
    0.04326956f, -0.00975101f, 0.07966825f, -0.04232411f, 0.03468247f, -0.08875591f, -0.03239370f, 0.02801808f, 
    0.15591462f, 0.17327568f, 0.06429458f, 0.21662083f, 0.03139334f, 0.02399201f, -0.13888676f, -0.04102523f, 
    -0.08512959f, 0.02140473f, -0.03024652f, -0.21278274f, 0.31126469f, 0.17993498f, -0.16063337f, 0.19918695f, 
    0.20170523f, 0.06281763f, 0.11676740f, 0.04949131f, 0.05645972f, 0.01242054f, -0.16319016f, -0.10010891f, 
    0.02290729f, -0.02168817f, -0.30700272f, -0.02811453f, 0.00674235f, -0.00753709f, 0.03027108f, -0.08462502f, 
    0.02256856f, 0.04496653f, -0.02371954f, 0.18222390f, 0.02271473f, 0.33209825f, 0.15556574f, 0.24581236f, 
    0.09372994f, 0.02589415f, 0.17214000f, 0.07630204f, -0.08459670f, 0.06738090f, 0.04005238f, -0.01112994f, 
    0.01383334f, -0.21089295f, -0.16491197f, -0.21324763f, 0.15004490f, 0.13658941f, 0.05863509f, 0.02333267f, 
    -0.00135984f, 0.04545248f, -0.13721187f, 0.22704630f, 0.03652868f, 0.30813831f, 0.04593880f, -0.01100529f, 
    0.11385948f, 0.01281063f, 0.02067109f, 0.12050106f, 0.00569445f, -0.07304058f, -0.08268651f, -0.11290892f, 
    -0.06236907f, 0.12985009f, 0.12005325f, 0.13515383f, 0.06603698f, 0.21105571f, 0.08269154f, -0.01704428f, 
    -0.06792942f, 0.07300195f, 0.18325076f, -0.10567868f, -0.08193566f, -0.09528548f, 0.19758765f, 0.02097407f, 
    -0.03555639f, 0.14783162f, 0.09845143f, -0.06638762f, 0.00688997f, -0.03780375f, 0.02989936f, -0.12858859f, 
    -0.07651529f, 0.11948811f, 0.00447338f, -0.30298722f, -0.02863421f, 0.03671179f, 0.08820016f, 0.21555644f, 
    -0.02752443f, 0.10072695f, 0.15350501f, 0.02271485f, 0.42784840f, -0.10515505f, 0.00975967f, 0.02586823f, 
    -0.03983425f, -0.10025865f, -0.11041251f, -0.08321555f, 0.06567825f, -0.05589224f, 0.18700935f, -0.05022391f, 
    -0.22597639f, -0.05065115f, -0.15076877f, -0.31328607f, -0.07314155f, 0.24036443f, -0.06605172f, -0.08804360f, 
    0.08422831f, 0.05145214f, 0.04437314f, 0.09171108f, -0.08939153f, -0.07304645f, 0.17826712f, 0.24447618f, 
    0.07369009f, 0.07594457f, 0.08142101f, -0.07465575f, -0.13883841f, -0.01709524f, -0.01650052f, 0.11583462f, 
    0.13017082f, 0.01655003f, 0.02072366f, 0.19949292f, 0.13883196f, 0.04388289f, 0.00581918f, 0.07399282f, 
    0.08997048f, 0.04110049f, -0.09698614f, 0.01161396f, 0.06968702f, -0.09392814f, 0.28010613f, 0.09613483f, 
    0.09697946f, -0.05796653f, 0.03731559f, -0.00644925f, 0.04492231f, 0.01226281f, 0.10893805f, -0.05164333f, 
    0.36016622f, -0.30068573f, -0.01525755f, 0.25031909f, -0.18673515f, 0.09682972f, -0.13140891f, -0.03199400f, 
    -0.09946269f, -0.01708725f, -0.10140313f, 0.00613059f, -0.15811068f, -0.27374220f, -0.09753435f, 0.16205005f, 
    0.07257313f, -0.03723478f, 0.00403944f, 0.12161449f, 0.00668159f, 0.06299232f, 0.02464995f, 0.05902207f, 
    0.21466367f, -0.22317828f, 0.05288965f, 0.12604688f, -0.03502871f, -0.06508402f, -0.06075057f, 0.03225173f, 
    -0.00504662f, 0.14931902f, 0.00604689f, 0.19626282f, 0.16521285f, 0.30875841f, 0.06018560f, 0.02019791f, 
    -0.06009746f, -0.06821611f, 0.07984001f, 0.04547521f, -0.10789234f, -0.04738661f, 0.01385876f, 0.00144472f, 
    0.06357814f, -0.12252285f, -0.11350705f, 0.32052311f, -0.04028968f, -0.00815104f, 0.04946944f, -0.04495804f, 
    0.07318824f, -0.03332081f, 0.00717810f, -0.01543774f, 0.49659011f, 0.15031636f, 0.01937908f, 0.07956399f, 
    -0.05018521f, -0.19297075f, 0.03462926f, -0.08738563f, 0.10180362f, -0.03391642f, 0.03961195f, 0.08720478f, 
    -0.14112520f, 0.00037333f, -0.16751559f, 0.12227491f, 0.05668050f, -0.02939528f, 0.10727675f, 0.03273426f, 
    -0.03213576f, 0.11846574f, 0.10574488f, -0.00389479f, -0.00916918f, 0.23802201f, -0.00678171f, -0.05345562f, 
    -0.26207185f, 0.00776548f, -0.05359180f, 0.14625303f, 0.08143599f, 0.03856958f, 0.05015129f, 0.11559318f, 
    0.29081661f, 0.15160526f, -0.03987792f, -0.01761257f, -0.06441192f, -0.05946030f, -0.09394231f, 0.04416461f, 
    -0.07382882f, -0.11808734f, -0.10232823f, 0.07534385f, -0.05297954f, 0.02693953f, 0.03351969f, -0.26556897f, 
    -0.04431954f, 0.04628187f, -0.07880986f, 0.09115853f, 0.01121094f, 0.01425998f, -0.02852627f, 0.06386093f, 
    -0.20016488f, 0.65668619f, -0.03848357f, -0.21381779f, 0.04031555f, -0.05382116f, -0.05291031f, -0.02610742f, 
    0.12940913f, 0.10729948f, -0.01027682f, 0.11605685f, -0.55882597f, -0.28055924f, -0.02669387f, 0.19421452f, 
    0.07021537f, 0.07679941f, 0.08089881f, -0.01055082f, -0.00421939f, 0.04127734f, -0.06760324f, 0.07409352f, 
    0.02542111f, 0.03791626f, -0.18389450f, 0.20445493f, -0.10599747f, -0.02390850f, 0.13604070f, -0.10894692f, 
    -0.04608402f, -0.04107622f, 0.10170057f, -0.12464916f, 0.68837810f, 0.11419868f, 0.03133297f, 0.00257242f, 
    0.09859468f, -0.03334544f, -0.01009203f, 0.01423850f, 0.03858167f, -0.07141220f, 0.00551658f, -0.10872663f, 
    0.20204102f, 0.06087278f, -0.07944581f, -0.04816121f, -0.13148987f, 0.03730106f, -0.04258531f, 0.05412145f, 
    0.08475228f, 0.21008526f, 0.15453726f, 0.03161396f, 0.23639464f, 0.30376810f, -0.14476354f, -0.23765579f, 
    -0.11486082f, 0.06598955f, 0.07075509f, 0.10701365f, 0.05296646f, -0.06895503f, -0.02222488f, 0.13820922f, 
    -0.48191065f, 0.05211699f, 0.14644004f, 0.14728819f, -0.07518450f, 0.11934163f, 0.10535483f, 0.07718450f, 
    0.01356979f, 0.09729578f, 0.08418579f, 0.04696048f, -0.09451526f, 0.11531764f, 0.02886070f, -0.07265436f, 
    0.01615282f, 0.00860202f, -0.22986668f, 0.00754935f, 0.02377369f, 0.20215711f, 0.16470629f, -0.14979395f, 
    -0.12181522f, 0.14033328f, 0.00373658f, 0.08932548f, -0.02497681f, 0.08129335f, 0.04379559f, -0.04545124f, 
    0.02757792f, -0.01409542f, 0.05005696f, -0.06846119f, 0.20657392f, 0.07427941f, 0.06711614f, 0.11478970f, 
    0.13115446f, 0.01968631f, 0.06677321f, 0.00001595f, 0.15576050f, 0.17447472f, -0.00802082f, 0.07457070f, 
    -0.00429932f, 0.18075778f, -0.00632638f, -0.21521950f, 0.00587768f, -0.03265332f, -0.04179373f, 0.14620276f, 
    -0.04277946f, 0.14512488f, -0.02722768f, -0.14819506f, -0.18845604f, 0.11125049f, -0.00534397f, 0.02614237f, 
    0.06742635f, 0.01870316f, 0.02182434f, 0.10627492f, -0.01950108f, 0.12413515f, 0.07753353f, 0.14340803f, 
    -0.16163197f, 0.38628444f, 0.04055937f, -0.23986374f, -0.04059060f, -0.07394183f, -0.00425400f, 0.05342017f, 
    0.17682229f, 0.09839354f, 0.03556150f, 0.00546076f, 0.33176759f, 0.02199916f, -0.00211999f, -0.11696944f, 
    0.06695854f, -0.06820337f, -0.05665249f, 0.11797317f, 0.00823903f, 0.08061046f, -0.16464607f, 0.00060553f, 
    0.05426966f, -0.08132508f, 0.00387028f, 0.12084011f, 0.10686093f, -0.00954913f, -0.05166871f, -0.11499786f, 
    -0.16298237f, 0.02786788f, 0.07506566f, 0.09113208f, -0.11427470f, -0.08031158f, 0.14684787f, 0.23232426f, 
    0.12746160f, 0.15470567f, -0.05514817f, -0.08634359f, 0.05190033f, 0.01461640f, -0.00274426f, -0.09679323f, 
    0.34330410f, -0.46861497f, 0.08374985f, 0.12034553f, 0.22786829f, -0.02799267f, 0.01568878f, -0.02698632f, 
    -0.05873667f, -0.01536296f, -0.10365370f, 0.04761298f, -0.09644680f, 0.37279767f, 0.22023022f, -0.42538360f, 
    -0.03008544f, -0.07107811f, -0.18159664f, 0.01287953f, 0.06232876f, 0.02081296f, 0.02170690f, -0.02860178f, 
    0.05465325f, -0.05289898f, 0.07293805f, -0.21024457f, 0.06172848f, -0.07034822f, -0.02867864f, -0.04077485f, 
    -0.09919626f, -0.11609279f, 0.17297080f, -0.06164724f, -0.35040924f, -0.10489324f, -0.04782106f, -0.16583341f, 
    -0.01553615f, 0.01190201f, -0.06341067f, -0.02900165f, 0.00628797f, 0.01190099f, 0.05792007f, 0.00226062f, 
    0.24133459f, 0.07540733f, 0.17107961f, 0.12529418f, 0.13346480f, -0.01599391f, 0.09190106f, -0.12631986f, 
    -0.22941808f, 0.00123710f, -0.08027475f, -0.22021633f, 0.11786075f, -0.18622170f, -0.08323615f, 0.31829783f, 
    -0.03259404f, 0.11959329f, 0.07848258f, -0.10308199f, 0.02647456f, 0.03521375f, 0.00083261f, 0.00526420f, 
    0.15000063f, -0.33679187f, 0.07508749f, -0.10237011f, 0.03292594f, 0.16087656f, -0.05142292f, -0.11996920f, 
    0.07031231f, -0.09674089f, -0.08830781f, 0.02244253f, 0.03861682f, 0.00908443f, 0.12842524f, 0.13537802f, 
    0.09657754f, -0.08679411f, 0.05910746f, -0.09488704f, -0.06466138f, -0.05048804f, -0.00893377f, 0.32139337f, 
    -0.32608327f, 0.09686881f, -0.02543696f, 0.07911598f, 0.09967519f, 0.12614350f, 0.04194739f, 0.20763874f, 
    0.10328401f, 0.05006963f, 0.15544564f, 0.15792018f, 0.09513391f, -0.12101398f, -0.11260211f, -0.25783998f, 
    -0.18877713f, -0.01428104f, -0.02022420f, -0.11765808f, -0.08190265f, -0.00511142f, 0.17067656f, -0.03047346f, 
    -0.09566253f, -0.03895554f, 0.15390600f, -0.09347042f, 0.02912613f, 0.00932174f, -0.04725711f, 0.17038736f, 
    0.01747748f, 0.08000635f, -0.04017420f, -0.07774199f, 0.35946265f, 0.01337661f, -0.21633279f, -0.10716360f, 
    -0.06359061f, -0.04338206f, 0.15564801f, -0.03513661f, -0.00116510f, -0.00418429f, -0.06759251f, -0.12286299f, 
    -0.32406363f, -0.15503682f, 0.14721166f, 0.29485655f, -0.07884233f, 0.01893900f, -0.13156259f, -0.11606327f, 
    0.09093284f, -0.17585926f, 0.10664541f, -0.09662559f, -0.19982029f, 0.04369723f, 0.15815462f, -0.10075561f, 
    -0.01099963f, 0.11275083f, 0.10751040f, -0.08263601f, -0.03225249f, -0.19641273f, 0.25469303f, 0.03169013f, 
    0.17943002f, -0.12011952f, -0.05832740f, -0.24341714f, 0.01354364f, 0.00574990f, 0.05908692f, 0.14410047f, 
    0.07671018f, -0.08456428f, -0.13654549f, 0.00129901f, -0.16638622f, 0.05313117f, -0.09402721f, -0.17350805f, 
    0.01399023f, 0.14263299f, 0.03427282f, -0.01800775f, 0.03924811f, 0.04145918f, -0.11318336f, 0.19784237f, 
    -0.63161665f, 0.27333686f, -0.11154927f, 0.09740423f, -0.04701552f, -0.11934868f, -0.08374814f, -0.05502840f, 
    0.09139241f, 0.06949782f, 0.04539043f, 0.05888740f, -0.05335734f, 0.13415574f, 0.15872443f, 0.31329456f, 
    0.20347230f, -0.01541207f, 0.15751094f, 0.03478110f, 0.02990848f, 0.02407825f, -0.03090359f, 0.19204111f, 
    0.15565982f, -0.04379820f, -0.00904957f, 0.19094357f, 0.16175017f, -0.10541856f, 0.02308807f, 0.25948140f, 
    -0.02895230f, 0.07522572f, -0.08759023f, 0.06987081f, 0.09009632f, 0.03191690f, 0.15299615f, 0.07184400f, 
    0.10930921f, 0.13284630f, 0.05639096f, 0.00384203f, 0.17285652f, -0.10770183f, 0.02512966f, -0.18333162f, 
    0.08671519f, -0.00138419f, -0.04762516f, -0.01616264f, -0.08892543f, 0.22156426f, 0.11025108f, -0.09453923f, 
    0.07256665f, 0.12643890f, 0.13945539f, -0.04096894f, 0.05442998f, -0.08572148f, -0.34021953f, -0.09305207f, 
    -0.02180959f, 0.19649051f, -0.04052685f, -0.03350674f, 0.00355460f, 0.09543367f, 0.02815702f, 0.14381628f, 
    0.55432189f, -0.03576946f, 0.07909181f, -0.12136976f, 0.05744188f, -0.08569255f, 0.01370112f, -0.05797582f, 
    0.05453578f, 0.06184126f, -0.04834932f, -0.12258032f, 0.19264056f, 0.19280168f, 0.05196222f, 0.29857400f, 
    0.09206555f, 0.08379939f, 0.08292723f, -0.11285148f, -0.05485065f, -0.13824803f, -0.00953600f, 0.17987864f, 
    -0.17120606f, -0.16857007f, -0.03585189f, 0.03452815f, 0.09806469f, -0.06165943f, -0.07926598f, 0.09508018f, 
    -0.10545798f, -0.09253635f, 0.05053727f, 0.03134260f, -0.27187285f, -0.39471811f, -0.17682478f, 0.13822724f, 
    0.24487750f, 0.09560765f, 0.03290634f, 0.05055743f, 0.00509861f, -0.05686073f, 0.10496821f, -0.13611260f, 
    0.58313143f, 0.10651299f, 0.08150181f, 0.23783295f, -0.00123758f, 0.01976893f, -0.04374781f, -0.13318655f, 
    -0.03878240f, 0.06880194f, -0.02557207f, 0.00854709f, -0.46119601f, -0.13043644f, -0.21284592f, 0.02994792f, 
    0.30757862f, 0.11831947f, 0.17263128f, -0.03152091f, -0.02521628f, -0.01551080f, -0.09595331f, -0.17031497f, 
    0.71681529f, -0.00327621f, 0.17707872f, 0.07272507f, 0.13472544f, 0.08430424f, 0.02012453f, -0.29972851f, 
    -0.16163336f, -0.05752645f, 0.10212407f, -0.05731117f, -0.52997476f, 0.10097267f, -0.24477716f, -0.16366680f, 
    0.08424767f, -0.02258266f, 0.02268450f, -0.03358768f, 0.02377162f, 0.02920118f, 0.10852706f, 0.12813827f, 
    -0.17043532f, -0.28500956f, -0.17796029f, -0.37661126f, 0.19298895f, -0.00855971f, -0.06929714f, 0.12136269f, 
    0.00044953f, 0.07934339f, -0.00734144f, -0.00085102f, 0.37262401f, 0.32847351f, -0.12456002f, -0.12882204f, 
    -0.08237939f, -0.00542772f, 0.02088412f, -0.00558148f, 0.07160170f, 0.05344299f, 0.00082640f, -0.06293999f, 
    -0.22038633f, -0.12153538f, 0.01193087f, 0.00507956f, -0.00808759f, 0.04056382f, 0.03347638f, -0.11648911f, 
    0.10640489f, 0.10614578f, 0.08915813f, 0.00106390f, 0.45464158f, 0.10379342f, 0.27398887f, 0.35691229f, 
    -0.05270727f, -0.03832012f, 0.06266094f, -0.01459613f, 0.02888446f, 0.01638741f, -0.02376852f, 0.18035926f, 
    0.21015686f, -0.05470604f, -0.01943555f, 0.10702820f, 0.09937873f, 0.06152535f, 0.03073942f, 0.13611585f, 
    0.10293405f, 0.07262086f, -0.05334654f, 0.13966312f, -0.13296835f, -0.13566686f, -0.00779146f, 0.10565750f, 
    -0.08490024f, -0.07905147f, 0.02060712f, 0.04202714f, 0.00415570f, 0.18780610f, 0.08773738f, 0.05978507f, 
    -0.16010778f, 0.02035165f, -0.05954621f, -0.05964387f, 0.09341589f, 0.10035720f, -0.01174490f, 0.13874969f, 
    0.12414432f, -0.06916182f, 0.11719821f, 0.00011133f, -0.00460464f, -0.16388085f, -0.17338997f, -0.03818443f, 
    0.06626551f, 0.12042870f, -0.02678053f, 0.13989435f, -0.03376427f, 0.13529515f, 0.01852318f, 0.01335933f, 
    -0.06657858f, 0.01341623f, 0.02360471f, 0.00901260f, 0.01629467f, -0.05706639f, -0.05238952f, 0.02626211f, 
    0.04079555f, -0.01307556f, 0.00887339f, 0.01037820f, -0.02156705f, -0.03086962f, -0.04260571f, -0.05153628f, 
    0.01208896f, -0.03657985f, 0.02724374f, -0.06911245f, -0.02932445f, -0.07066628f, -0.03331663f, 0.06613019f, 
    -0.02021835f, 0.00391563f, -0.02301338f, -0.01715828f, 0.01067549f, 0.02407127f, 0.05372617f, -0.02052059f, 
    0.01202996f, -0.01568392f, -0.05212931f, 0.03062616f, -0.03697482f, -0.01389813f, 0.01510415f, -0.02677233f, 
    0.03745642f, -0.00236755f, -0.03662430f, 0.05916338f, 0.04513972f, -0.03892515f, 0.04150117f, 0.04096641f, 
    0.04717134f, 0.04951745f, 0.04941123f, -0.06024322f, 0.05639287f, 0.00450908f, -0.07647204f, 0.03245455f, 
    -0.03441784f, 0.05260236f, 0.00251646f, 0.04026709f, 0.04734633f, -0.00715692f, -0.01687736f, -0.01817550f, 
    -0.00377867f, 0.01081826f, -0.05190159f, -0.01501680f, -0.05720335f, 0.02212426f, 0.04112526f, 0.03131795f, 
    0.05695361f, -0.02059944f, -0.03990610f, -0.06085681f, -0.01675792f, 0.05394497f, 0.00969694f, -0.00667561f, 
    -0.02155855f, 0.02135466f, -0.01260877f, -0.03261913f, -0.03506449f, 0.03009360f, -0.02091664f, -0.04070417f, 
    -0.01385329f, 0.01093562f, 0.04200554f, -0.03391455f, -0.06179709f, 0.03455591f, 0.01286335f, -0.00873287f, 
    -0.07372182f, -0.03328274f, -0.02787518f, -0.03386910f, 0.03742741f, 0.04331844f, -0.00430897f, -0.04067402f, 
    0.05507109f, -0.07883053f, -0.01421683f, -0.07606776f, -0.05764649f, -0.00814181f, -0.00154017f, 0.01429569f, 
    0.03498070f, 0.05965638f, 0.03067751f, -0.07520460f, -0.06412295f, -0.04189047f, -0.05724319f, 0.04951543f, 
    -0.07468704f, 0.00204643f, -0.07509957f, -0.06365272f, -0.02438132f, -0.07915936f, -0.01315923f, -0.02785473f, 
    0.02216148f, -0.01342091f, 0.01882003f, 0.02913752f, -0.05471301f, -0.05631861f, 0.00379949f, -0.02967750f, 
    0.06127558f, -0.05049534f, 0.03445136f, 0.02146960f, 0.00707735f, -0.05123466f, 0.00705241f, 0.03345582f, 
    0.04754054f, -0.01447112f, -0.03520283f, -0.07300571f, 0.02640883f, -0.03812724f, 0.04853911f, -0.03789190f, 
    -0.04190220f, 0.02585150f, 0.00550875f, -0.07335674f, -0.04341779f, 0.03342004f, -0.04222593f, -0.02346248f, 
    0.00035319f, -0.07424173f, -0.07516298f, -0.05599273f, -0.06025341f, -0.01577249f, 0.03168824f, -0.06348774f, 
    -0.03432413f, 0.00727447f, -0.03318904f, 0.00577071f, -0.08200646f, 0.05113576f, 0.02330995f, -0.00208693f, 
    -0.01323870f, -0.07083284f, -0.02311521f, 0.05491725f, 0.04080539f, 0.03137822f, 0.03217785f, -0.01297740f, 
    -0.07222681f, -0.04904263f, 0.02609951f, -0.03334532f, 0.02732939f, -0.02722680f, 0.03568973f, -0.04396676f, 
    -0.05848834f, -0.00862524f, -0.01955765f, -0.02701040f, -0.04330860f, 0.01352285f, 0.05960611f, -0.02165756f, 
    0.04797095f, 0.04928622f, 0.02701629f, -0.02612943f, 0.04677065f, 0.02867780f, 0.02850113f, -0.04069017f, 
    0.05009200f, 0.01817828f, 0.00903313f, -0.05421407f, -0.04701544f, -0.01250195f, -0.08018632f, -0.06154545f, 
    -0.02640417f, -0.00045264f, 0.01994568f, -0.01145738f, 0.04254430f, 0.03874862f, 0.00191187f, -0.04868392f, 
    -0.01763977f, -0.03717808f, -0.05764794f, -0.00643951f, -0.02224836f, -0.00855236f, 0.02335184f, -0.05102136f, 
    -0.04886033f, 0.05648647f, -0.05922925f, -0.03901406f, 0.01153050f, -0.06245453f, -0.04012096f, 0.00422868f, 
    0.05013844f, -0.03005026f, -0.05333369f, -0.04474396f, -0.01811328f, -0.00925424f, 0.01785601f, 0.00978627f, 
    -0.07066925f, -0.00768417f, -0.02755110f, -0.06727652f, -0.02943038f, 0.01804934f, -0.05853798f, -0.04200692f, 
    -0.04788651f, -0.03138788f, -0.00368100f, 0.00205199f, 0.03399399f, 0.01964402f, 0.03057933f, 0.04907997f, 
    -0.06380995f, -0.00168287f, 0.00652745f, -0.01276264f, 0.05933371f, -0.01753956f, 0.06189492f, -0.06383349f, 
    0.00389904f, -0.01150068f, -0.03655622f, 0.00282489f, 0.02010565f, -0.06210682f, 0.01567443f, -0.05036874f, 
    -0.03353419f, -0.00626793f, -0.02619221f, -0.05808607f, -0.00439810f, -0.05546321f, -0.03324238f, -0.00332688f, 
    0.01334535f, -0.07055694f, -0.01583656f, 0.06014398f, 0.00958704f, -0.06054369f, 0.01568729f, -0.01938585f, 
    0.00703584f, -0.02850530f, 0.05148785f, 0.06221922f, 0.02166786f, 0.02970270f, -0.07048790f, -0.06258494f, 
    -0.03732112f, -0.06948198f, -0.02292502f, 0.05839552f, -0.06362660f, 0.00441643f, 0.03229912f, 0.03940317f, 
    -0.05113678f, -0.04927430f, 0.00281380f, 0.02140025f, -0.05221391f, -0.01121168f, 0.00615460f, -0.05464952f, 
    -0.02663714f, -0.05037778f, -0.03910963f, -0.04482997f, 0.03193600f, 0.00037008f, -0.00544961f, -0.04104434f, 
    -0.03008428f, -0.00291240f, -0.00662159f, 0.04218723f, 0.02582948f, 0.06559081f, 0.05145535f, -0.02305631f, 
    -0.05752503f, 0.03852880f, -0.01071251f, 0.03115007f, -0.06397495f, 0.00711551f, 0.04213068f, -0.00062404f, 
    0.04036501f, 0.02325181f, -0.07172097f, -0.07971811f, -0.00406348f, -0.07109385f, 0.03628787f, 0.01784799f, 
    0.05784352f, -0.00741859f, -0.06540404f, -0.06228186f, -0.00880028f, 0.02880587f, -0.05527957f, -0.05583001f, 
    -0.03080898f, -0.02283759f, 0.04399591f, -0.03909725f, -0.03175291f, -0.06372666f, 0.03506522f, 0.05905169f, 
    -0.00066140f, -0.04045488f, 0.04845509f, 0.05350024f, -0.02346699f, -0.00708449f, -0.03187684f, 0.00421444f, 
    -0.02554924f, 0.06353395f, -0.02554712f, 0.00193877f, 0.03591703f, 0.04627989f, -0.06572025f, -0.04577333f, 
    0.01677919f, 0.00788479f, 0.05049469f, -0.05566034f, -0.07949075f, 0.04970555f, 0.01935015f, -0.02354466f, 
    -0.03722688f, 0.00767677f, 0.02100637f, 0.04420365f, -0.07547040f, -0.03847006f, -0.06427762f, 0.02912107f, 
    -0.04928929f, -0.05401600f, -0.00704606f, -0.06181935f, -0.07110491f, -0.03586921f, 0.04377435f, -0.01033285f, 
    0.02780063f, -0.00767263f, 0.06087130f, -0.05263456f, 0.02212953f, -0.03471983f, -0.02810549f, 0.00519661f, 
    0.04012023f, -0.08157371f, -0.01665195f, 0.02484376f, 0.04177661f, -0.03582666f, -0.07800642f, -0.00061899f, 
    -0.07893837f, -0.03857149f, -0.07641499f, 0.05374788f, -0.01502228f, -0.06644779f, -0.04553799f, -0.07337226f, 
    -0.01327034f, -0.05070369f, -0.05729708f, -0.07830966f, -0.05162928f, 0.00411330f, -0.05240880f, 0.04134622f, 
    0.05048800f, -0.01682697f, 0.04409735f, 0.00523741f, -0.02966926f, -0.05937717f, 0.07102800f, -0.07858601f, 
    -0.04720131f, -0.00634191f, -0.07796782f, -0.04319583f, -0.05968981f, 0.03491715f, -0.06767790f, 0.02836950f, 
    -0.03501140f, -0.01059147f, -0.02852714f, 0.03985646f, -0.06117161f, -0.06362898f, -0.05654392f, 0.00874758f, 
    0.03362199f, 0.05527436f, 0.04870021f, 0.05344861f, -0.04871847f, 0.00728067f, 0.00981182f, -0.01404919f, 
    -0.06559714f, 0.03435590f, 0.00802854f, 0.05329562f, 0.04303213f, 0.00095032f, 0.05069504f, -0.07160045f, 
    -0.05823517f, 0.03822538f, 0.05294244f, 0.03373396f, 0.00210652f, -0.06212613f, -0.06471049f, 0.03137364f, 
    0.04156761f, 0.00149848f, -0.05403012f, 0.01200093f, -0.07645644f, 0.01944794f, 0.04270414f, 0.04117690f, 
    -0.01842086f, 0.01663487f, -0.00426249f, -0.02223265f, -0.01598055f, 0.05248110f, -0.02327413f, -0.03938665f, 
    -0.07153141f, -0.06116964f, 0.04717293f, -0.01073548f, -0.05356155f, -0.02208325f, -0.05196094f, 0.00577851f, 
    -0.06511141f, 0.02036531f, 0.05399850f, 0.01453342f, 0.05369443f, 0.05665971f, -0.06685377f, -0.03410602f, 
    0.05154770f, -0.00421322f, -0.07452400f, 0.05925197f, -0.06192626f, 0.04768433f, -0.04007348f, 0.02980102f, 
    -0.04418081f, 0.00640515f, -0.06403447f, -0.07149346f, 0.00069525f, 0.03922052f, -0.04517914f, 0.04790331f, 
    0.04676863f, 0.01169481f, 0.02341384f, 0.02827627f, 0.01477437f, 0.04780491f, 0.00466047f, 0.04902594f, 
    -0.03933511f, -0.01915355f, 0.05825455f, -0.06073387f, -0.00964154f, 0.05792631f, 0.05240485f, -0.03084070f, 
    0.03993366f, -0.00537309f, -0.01264238f, 0.01930605f, 0.06276961f, -0.01930441f, 0.00095940f, 0.02533136f, 
    -0.02143897f, -0.03613414f, 0.02647151f, -0.05264822f, 0.01261063f, -0.03215487f, 0.03763068f, -0.03045090f, 
    -0.06384830f, 0.05724027f, -0.05316816f, -0.03880014f, -0.02795457f, -0.03112328f, 0.03234954f, -0.04267239f, 
    0.03296869f, 0.02566839f, 0.01237762f, 0.05070360f, 0.05697570f, -0.07393129f, -0.03506034f, -0.07742362f, 
    0.04024897f, 0.00743132f, 0.05481626f, -0.02733339f, 0.02275319f, 0.00277492f, -0.07300550f, -0.05021637f, 
    -0.07011985f, 0.06268747f, -0.04538633f, -0.00045396f, -0.07699557f, -0.07100628f, 0.05512266f, 0.00064220f, 
    -0.00425162f, -0.05989862f, -0.04994986f, -0.05813098f, -0.06679481f, -0.00047355f, -0.05010137f, -0.02300814f, 
    -0.04599956f, -0.03048728f, 0.03876049f, 0.05036094f, -0.01119786f, -0.02448393f, 0.01575087f, 0.02027837f, 
    0.02784065f, 0.00162793f, -0.02249660f, -0.04139330f, 0.05737381f, 0.02913057f, 0.01431762f, 0.02707208f, 
    -0.01253997f, -0.01437625f, -0.05596578f, -0.06055514f, 0.02594378f, -0.03014724f, 0.00698517f, -0.06194907f, 
    0.01313007f, 0.01397138f, -0.02142579f, 0.01045570f, 0.01219940f, -0.01257483f, 0.02225407f, 0.03782650f, 
    -0.03981101f, 0.04593890f, 0.04972780f, 0.07652760f, -0.01118552f, -0.01272820f, 0.00140568f, -0.00098282f, 
    -0.03899224f, -0.00748341f, 0.04745116f, -0.02254235f, -0.02204426f, -0.00721466f, 0.04682203f, 0.01307501f, 
    -0.02368456f, -0.05223541f, -0.05839176f, 0.01542332f, -0.06966394f, -0.03210618f, -0.07902414f, 0.03873604f, 
    0.04101564f, 0.02078795f, 0.00800854f, -0.01706954f, -0.06072454f, -0.03900617f, 0.04000669f, 0.02334410f, 
    -0.01288180f, 0.03172103f, -0.01691598f, -0.00104139f, 0.00234033f, -0.07570554f, -0.02019752f, 0.06793613f, 
    -0.04793792f, -0.07120154f, -0.04761424f, -0.06249271f, -0.03736621f, 0.01875627f, 0.01922918f, -0.06844363f, 
    0.01698261f, -0.04119046f, -0.06833918f, -0.06182671f, 0.00476856f, -0.02412472f, -0.02906469f, 0.01563594f, 
    0.04790518f, -0.01414359f, -0.03852334f, 0.03971677f, -0.01308255f, 0.01961746f, 0.01210305f, 0.05892861f, 
    -0.03650101f, 0.06681284f, -0.05876375f, 0.01235282f, -0.00404491f, -0.05963975f, -0.00140276f, -0.04167807f, 
    0.06396400f, -0.00390957f, 0.03669298f, 0.07034432f, -0.00514024f, 0.01645793f, -0.06506217f, -0.03716634f, 
    0.02430611f, 0.01874937f, 0.01431590f, -0.04113692f, -0.00425193f, 0.03757836f, 0.01138218f, -0.02867017f, 
    0.04596712f, -0.02782352f, -0.05154928f, 0.04502802f, -0.02223244f, -0.03199323f, 0.03035379f, 0.02422286f, 
    0.04607733f, -0.06074683f, -0.03523016f, -0.07482905f, -0.01177883f, 0.01933760f, -0.01411413f, -0.03169163f, 
    -0.05087304f, -0.02557024f, -0.02846175f, -0.04026858f, -0.06668244f, -0.01772811f, -0.06157691f, -0.04691745f, 
    0.06058792f, -0.08137700f, 0.04635719f, -0.04218762f, 0.02998630f, -0.06312525f, -0.01946969f, -0.05980750f, 
    0.02261900f, 0.00626977f, 0.00296254f, 0.05510386f, -0.04157016f, 0.03167362f, -0.02372834f, -0.01517866f, 
    0.17280227f, 0.23863252f, -0.01776521f, -0.15538843f, -0.11042022f, 0.02096714f, -0.01053398f, -0.10735832f, 
    0.10046899f, 0.00088585f, -0.04402062f, -0.00753146f, -0.11881016f, -0.04451165f, 0.06716742f, -0.01639469f, 
    0.11484455f, 0.03049701f, -0.12495030f, -0.05163460f, -0.10282123f, -0.02984850f, 0.09293001f, 0.22512096f, 
    -0.15249392f, -0.01535827f, 0.02291986f, 0.03065040f, 0.20302808f, -0.05240929f, 0.05725608f, 0.00036872f, 
    0.05321238f, -0.02622867f, -0.01579836f, 0.13428728f, 0.26767677f, 0.08751233f, -0.00843772f, -0.09324396f, 
    0.19300257f, 0.10193230f, 0.06573518f, -0.08982415f, 0.10143199f, -0.07009980f, 0.20799479f, -0.19687916f, 
    -0.07334968f, 0.05951003f, -0.04393014f, 0.00153461f, -0.01437185f, 0.03564149f, 0.02318400f, 0.10845631f, 
    -0.09188147f, 0.16371626f, 0.21469623f, 0.06164946f, -0.28643909f, 0.18288830f, 0.12883222f, -0.02122915f, 
    0.10449822f, 0.18314141f, 0.09380078f, -0.02938795f, 0.01123936f, 0.05526006f, -0.17877524f, -0.20343024f, 
    0.21096130f, -0.14926714f, 0.20815557f, 0.05159464f, 0.12858182f, -0.07598685f, -0.14426646f, -0.07659055f, 
    -0.04604619f, -0.03560155f, 0.01432945f, 0.05863477f, -0.13858071f, -0.07123985f, 0.40239713f, -0.02774012f, 
    0.08760349f, 0.05269791f, 0.01429234f, -0.08690739f, -0.11047391f, -0.12641302f, 0.14849782f, -0.09027296f, 
    -0.40017027f, -0.04251576f, 0.10234357f, -0.09858559f, 0.14276312f, 0.09573299f, 0.08695182f, 0.05257089f, 
    -0.15072885f, 0.02839027f, 0.05621301f, -0.08656689f, -0.16931209f, 0.21176067f, 0.11904283f, 0.13373205f, 
    0.09676535f, -0.01120923f, -0.34249094f, 0.01644684f, 0.10421014f, 0.10458013f, -0.00238945f, 0.05733769f, 
    -0.01951623f, -0.23684555f, 0.22664784f, 0.17510751f, 0.07040004f, -0.01240866f, -0.07001357f, -0.19556999f, 
    0.05649560f, 0.04814435f, -0.09502071f, -0.07394756f, 0.23753475f, -0.06993582f, -0.16782293f, 0.02937182f, 
    -0.12940021f, -0.14472596f, -0.04308591f, 0.03964546f, -0.00450373f, 0.03295620f, -0.07179929f, 0.06277298f, 
    -0.25751030f, -0.12535430f, 0.09020947f, -0.13829564f, 0.16049773f, -0.03010791f, -0.10134521f, 0.10151974f, 
    0.15726359f, -0.07399852f, -0.24735238f, 0.14082120f, -0.46027482f, -0.01420030f, 0.27879560f, 0.18743248f, 
    -0.02210559f, -0.07973667f, -0.09523863f, 0.01799986f, 0.17755985f, -0.00973114f, 0.00574329f, -0.24961194f, 
    -0.04090058f, 0.07951035f, 0.13981624f, 0.03346447f, 0.18244047f, 0.09336266f, -0.17087053f, -0.16685516f, 
    0.00047012f, 0.02376927f, 0.09026638f, 0.07236875f, 0.16326806f, 0.16600752f, 0.01042385f, 0.01861292f, 
    0.07851182f, 0.07841033f, 0.03162367f, 0.05072315f, 0.07688183f, 0.12292837f, 0.00870565f, 0.17360790f, 
    0.12228240f, 0.08390666f, -0.17812151f, -0.01801718f, 0.16593982f, 0.04706385f, 0.16937302f, 0.04866197f, 
    0.01216230f, 0.00016219f, 0.07784120f, -0.00598938f, -0.13040316f, -0.14343530f, -0.09920520f, -0.00595331f, 
    0.13055986f, 0.10738094f, 0.10179096f, -0.06524729f, -0.00967884f, 0.01336768f, 0.10929934f, 0.10186272f, 
    0.45318577f, -0.18450791f, -0.20248041f, -0.03668857f, 0.07175225f, 0.03858365f, 0.02320441f, 0.06597777f, 
    -0.04858721f, 0.14425540f, -0.04507354f, -0.07798707f, -0.07259738f, 0.21994852f, 0.03138135f, 0.19728294f, 
    -0.06160247f, -0.16127352f, 0.06304384f, 0.26993799f, 0.02080926f, -0.07210056f, -0.09313028f, -0.21733072f, 
    -0.23747808f, -0.21017118f, -0.30597186f, 0.04132314f, 0.15748693f, 0.02335477f, 0.01766049f, -0.06876095f, 
    -0.10334045f, 0.16855788f, 0.06418175f, 0.17608359f, 0.12161407f, 0.03095654f, 0.42009145f, 0.40755385f, 
    -0.14676286f, -0.07450739f, -0.11956235f, 0.12511937f, -0.00379628f, 0.02749619f, -0.09968750f, 0.00266138f, 
    -0.18232030f, -0.17401271f, -0.11254575f, -0.13995500f, 0.24204782f, 0.20985548f, -0.09303325f, -0.13800627f, 
    -0.08612947f, 0.06297281f, -0.11653320f, 0.15769456f, 0.04402041f, 0.22797346f, 0.18666536f, -0.14007635f, 
    0.04994167f, -0.08452761f, 0.06327834f, 0.15445091f, -0.01636920f, 0.00690607f, -0.10099922f, -0.15840936f, 
    -0.02518836f, -0.00220242f, -0.05354266f, 0.05581785f, -0.01710653f, 0.07958270f, 0.02900101f, 0.14982995f, 
    -0.01222683f, -0.03339708f, 0.02261951f, -0.00218189f, -0.24931878f, 0.15036020f, -0.09608570f, 0.05039258f, 
    -0.04216466f, -0.11658157f, 0.04016939f, 0.00163747f, -0.00123813f, -0.07159506f, 0.05289735f, 0.16495365f, 
    0.44787049f, 0.08183905f, -0.25831479f, 0.10011639f, -0.01589208f, -0.02091430f, -0.12713194f, 0.05438244f, 
    -0.02935770f, -0.00821968f, 0.22166486f, -0.18184666f, -0.21312492f, -0.05111454f, -0.04548789f, -0.06127938f, 
    0.03193915f, -0.01745764f, -0.00437733f, -0.11504958f, 0.07282248f, -0.07546087f, -0.00813732f, -0.05009602f, 
    0.16042866f, -0.03017496f, -0.31774065f, -0.21715994f, 0.16181989f, 0.18878116f, -0.09893291f, -0.04304886f, 
    0.13003552f, 0.14692208f, -0.01480274f, 0.07523291f, -0.18282172f, 0.06338998f, 0.21148637f, -0.00420905f, 
    0.11431311f, 0.03310423f, -0.05433852f, 0.03969501f, 0.10186587f, -0.02252631f, -0.09401115f, -0.07159542f, 
    -0.11563125f, -0.04066124f, -0.01011495f, -0.18622200f, -0.00110800f, 0.10884976f, -0.07391407f, -0.00181800f, 
    -0.09576643f, 0.08175341f, 0.06122477f, 0.15717475f, 0.27981091f, 0.22719002f, 0.32244229f, 0.08564159f, 
    0.03794841f, -0.16756959f, 0.06303179f, 0.21590692f, -0.02028937f, -0.04715632f, 0.09487844f, 0.08014018f, 
    -0.38334161f, 0.09006624f, -0.09213617f, -0.03326958f, -0.10752775f, 0.06606665f, 0.15675177f, -0.00135029f, 
    -0.09816011f, 0.07521269f, 0.05282087f, -0.02767687f, -0.00912160f, -0.01635523f, -0.12383165f, 0.01071685f, 
    -0.08869179f, 0.10758825f, -0.02432400f, -0.02698966f, 0.07835966f, 0.17192702f, -0.01357264f, -0.25465453f, 
    0.20110233f, 0.06520237f, 0.16673985f, -0.07643915f, 0.09968228f, 0.06904165f, 0.06033666f, -0.01364626f, 
    -0.09674624f, 0.00754595f, -0.12850092f, -0.11525675f, 0.05331228f, 0.13333310f, -0.05385838f, 0.18681264f, 
    -0.02095651f, 0.01710721f, 0.10078552f, 0.07957435f, 0.09143926f, 0.16188467f, -0.07103202f, 0.14791293f, 
    -0.03393227f, 0.00739572f, -0.11078674f, -0.08152259f, 0.01726376f, 0.07871874f, 0.08440910f, -0.04751961f, 
    0.01283977f, -0.03948231f, 0.13328667f, -0.01528745f, -0.27482590f, 0.05957805f, 0.31967488f, 0.13862422f, 
    -0.10152683f, 0.07808967f, 0.02126594f, 0.11131785f, -0.18737879f, 0.00590516f, 0.07072318f, 0.15791368f, 
    -0.42170483f, 0.15693566f, -0.21260132f, -0.16094808f, 0.03765295f, 0.07555579f, 0.15233222f, 0.06796914f, 
    0.08658170f, 0.20442955f, -0.01893242f, 0.16913855f, 0.15784115f, -0.12829909f, 0.05359124f, -0.08954880f, 
    0.05280355f, -0.07023124f, 0.03011997f, 0.22587737f, 0.16369295f, 0.03492052f, -0.11458273f, 0.01599940f, 
    0.05902034f, 0.24556783f, 0.07856310f, 0.22945622f, -0.07885015f, -0.06165576f, 0.01853529f, -0.05717023f, 
    0.00911118f, 0.00133823f, 0.21654809f, 0.20167050f, -0.20041049f, -0.18560304f, -0.14073886f, 0.39372078f, 
    -0.04724437f, 0.09437425f, 0.18694882f, -0.05362971f, 0.05480454f, 0.10038037f, 0.02622741f, -0.09256857f, 
    0.34789601f, 0.17975658f, 0.06889220f, -0.06190038f, 0.08943383f, 0.03931531f, 0.05534814f, 0.13065745f, 
    -0.03701922f, 0.08023126f, -0.14430781f, 0.10173097f, -0.13207927f, -0.05153514f, 0.09284014f, -0.07828938f, 
    -0.00848453f, 0.00265816f, -0.12706114f, -0.05966795f, 0.06570959f, -0.00153411f, 0.09807245f, -0.11540475f, 
    -0.08394642f, 0.06542566f, -0.16426015f, -0.17554916f, -0.04129728f, 0.04604701f, -0.05875061f, -0.00864139f, 
    -0.07440704f, -0.04461637f, 0.26103547f, 0.05758054f, 0.26299146f, 0.26771197f, -0.13348541f, 0.28766727f, 
    -0.02644600f, 0.07365048f, -0.02236506f, 0.04932446f, -0.03049489f, 0.08466504f, 0.12685430f, 0.13364990f, 
    0.11909442f, 0.07894745f, -0.06353886f, 0.15926889f, 0.08474104f, -0.24657410f, 0.06530444f, 0.04214170f, 
    -0.05494418f, -0.17317463f, -0.06985410f, -0.06236757f, 0.06038501f, 0.12868032f, 0.12283747f, 0.25966373f, 
    0.08107571f, -0.06971598f, -0.00040525f, 0.03084202f, -0.04079611f, -0.09991544f, 0.00940908f, -0.04962837f, 
    -0.09846838f, 0.39406779f, -0.13532202f, 0.25863263f, 0.02032949f, -0.05967141f, -0.04068420f, 0.01302344f, 
    0.05056395f, 0.11555540f, 0.09645057f, 0.00434646f, 0.04716061f, -0.27008751f, 0.07785690f, -0.05061113f, 
    -0.24387424f, -0.09605935f, -0.16732556f, 0.20573585f, -0.01951129f, 0.11713044f, -0.02368099f, -0.14631897f, 
    -0.05832333f, -0.21466345f, 0.14764568f, 0.28600430f, 0.05042647f, -0.23806858f, 0.00292260f, -0.10393180f, 
    -0.05833166f, -0.00446107f, 0.01190944f, 0.01334385f, -0.02451057f, 0.03021226f, 0.23070154f, 0.12834978f, 
    0.10857662f, -0.01157711f, 0.21051615f, 0.10189772f, 0.05801462f, -0.09801222f, 0.03170463f, 0.11449960f, 
    0.36185148f, 0.04440482f, -0.00764975f, 0.08619237f, -0.32735327f, 0.05888324f, 0.06653163f, -0.05463111f, 
    -0.01317276f, 0.01811181f, 0.05961372f, -0.10331213f, -0.48193979f, 0.21113938f, -0.03576900f, -0.04159160f, 
    0.18328746f, 0.03104966f, 0.01698197f, -0.02241872f, 0.05998250f, 0.06515614f, 0.07016692f, 0.11725777f, 
    0.16184081f, 0.14524831f, -0.16703166f, -0.11699568f, -0.02341833f, -0.27830461f, 0.14912346f, 0.16974635f, 
    -0.02239113f, 0.01658642f, 0.07092176f, 0.10472011f, 0.44140649f, 0.20590578f, -0.22720768f, -0.00814318f, 
    0.03616557f, 0.03774223f, 0.01909130f, -0.01284195f, 0.00669608f, 0.01097468f, -0.00959432f, 0.09540186f, 
    -0.03422670f, -0.01359696f, 0.05678059f, 0.34103999f, 0.12600559f, 0.08359960f, -0.19007924f, 0.06304412f, 
    -0.24218711f, 0.05047947f, 0.03500181f, -0.04627028f, 0.29279575f, -0.15603532f, 0.20726095f, -0.17406976f, 
    0.03814316f, -0.04042460f, -0.21981262f, 0.13114561f, 0.02097301f, 0.16334178f, 0.05740066f, -0.11716831f, 
    0.40927520f, -0.09748034f, 0.30188969f, -0.03136087f, 0.02373043f, -0.01050964f, 0.14825484f, -0.09251674f, 
    0.03857395f, -0.14098753f, -0.11166093f, 0.04724868f, -0.22918439f, -0.08130483f, 0.23294125f, -0.20079410f, 
    -0.17345734f, 0.00021900f, -0.07905338f, 0.04345115f, -0.06584733f, -0.00717201f, 0.08520195f, -0.08657385f, 
    -0.18924421f, 0.26309156f, 0.25225958f, 0.10795341f, -0.03846178f, -0.06749769f, 0.04665135f, -0.17227280f, 
    -0.01890752f, -0.19650300f, 0.01403689f, -0.02468635f, 0.05826069f, 0.08926594f, 0.01740538f, -0.07083892f, 
    -0.31866285f, -0.08167774f, -0.05626757f, 0.05605840f, -0.10613402f, 0.03638670f, -0.00793936f, 0.12090991f, 
    0.07008900f, 0.02770646f, 0.20038822f, 0.06124439f, 0.09607958f, -0.12158584f, 0.14470743f, 0.14188270f, 
    0.01080859f, -0.02030803f, -0.01911351f, -0.00416865f, -0.08054079f, 0.17555854f, 0.22232616f, -0.14585523f, 
    0.09995627f, -0.00345815f, 0.10372226f, -0.03888729f, 0.06773060f, -0.05040975f, -0.06278063f, 0.20423551f, 
    0.05050164f, 0.06001030f, -0.02500959f, -0.02212396f, -0.00887631f, -0.02604700f, -0.02101245f, 0.01192906f, 
    -0.04668240f, -0.02497470f, -0.06841678f, 0.04223751f, -0.03420613f, 0.05538847f, 0.01849580f, -0.05613541f, 
    -0.02081867f, -0.03413707f, -0.00963182f, 0.01900733f, 0.01868754f, 0.05039704f, -0.03112122f, 0.00882897f, 
    -0.03301333f, 0.05588492f, 0.01008727f, 0.03055838f, 0.01990855f, 0.05458945f, -0.00404145f, -0.05318127f, 
    -0.02947780f, -0.06161334f, 0.05822662f, -0.02887655f, 0.01579773f, -0.02596586f, 0.00012952f, 0.05730341f, 
    -0.03702466f, -0.06425703f, -0.04411210f, 0.01316228f, 0.00623745f, 0.01789126f, 0.03825348f, -0.00496151f, 
    -0.02400535f, 0.01677034f, -0.00457758f, -0.00774253f, -0.07089166f, -0.02029026f, -0.01748716f, -0.04665071f, 
    0.04197500f, 0.00701711f, 0.05484174f, -0.05589393f, 0.01255397f, 0.05765962f, 0.06063897f, 0.00749412f, 
    0.03029118f, 0.00495425f, -0.00443124f, -0.04993378f, -0.04729457f, -0.00429709f, -0.04175115f, -0.07796359f, 
    -0.01303556f, -0.06147487f, 0.03172996f, 0.00838268f, -0.06154144f, -0.00333680f, -0.05926291f, -0.03448514f, 
    0.05671374f, 0.00617589f, -0.05124417f, -0.00758509f, 0.02729444f, 0.05625109f, -0.01499203f, 0.01681316f, 
    0.00202980f, -0.01270489f, -0.06623615f, -0.02705156f, 0.01117945f, -0.06027783f, -0.02293167f, -0.02705620f, 
    -0.00463867f, -0.03612253f, -0.01283027f, -0.07211225f, -0.00850205f, -0.00249413f, -0.07580545f, 0.01538893f, 
    -0.07622954f, 0.05676357f, -0.03932019f, -0.02434925f, -0.06143814f, 0.05493693f, -0.03492635f, -0.03934218f, 
    -0.06334109f, -0.04386101f, -0.00460325f, 0.04804226f, -0.05871305f, -0.01841908f, -0.02211184f, -0.06603512f, 
    0.05878474f, -0.00186929f, 0.04532650f, -0.03291097f, -0.06689085f, -0.02472573f, -0.02265138f, 0.05835853f, 
    -0.03695847f, 0.05265108f, 0.01573343f, 0.03185430f, -0.06621794f, 0.04080516f, 0.02023910f, 0.05507053f, 
    0.02299220f, 0.03436297f, -0.07583732f, 0.04859227f, -0.02899358f, -0.06889881f, -0.03475247f, 0.02264237f, 
    -0.04073121f, 0.04365521f, -0.05859386f, -0.07143672f, 0.01147681f, 0.01893124f, 0.01104692f, -0.02419748f, 
    -0.06465612f, 0.00509685f, -0.02133613f, 0.05500858f, -0.05940302f, 0.03597489f, -0.02424201f, 0.05117361f, 
    -0.06701913f, -0.01460978f, 0.00516160f, 0.01834846f, -0.02392758f, -0.02719226f, -0.03744322f, 0.05457406f, 
    -0.07419585f, 0.02343037f, -0.03211749f, -0.00357746f, -0.00095717f, -0.01939303f, -0.02825589f, 0.00848081f, 
    -0.00492382f, -0.01935818f, 0.00201818f, -0.04895202f, 0.01623737f, -0.06099826f, 0.00226141f, 0.00218049f, 
    -0.03142852f, -0.07904529f, -0.02512932f, 0.02180845f, -0.03391043f, -0.07350623f, 0.03304389f, 0.02096357f, 
    -0.23187461f, 0.00458592f, -0.02425069f, -0.07613549f, 0.10045469f, 0.07387801f, 0.13000587f, 0.05292380f, 
    0.00735195f, -0.07832511f, 0.05119854f, 0.02284133f, -0.01261170f, 0.09469088f, -0.03275109f, 0.00847815f, 
    -0.09399416f, 0.19246423f, -0.02549083f, -0.22684757f, 0.07654141f, -0.03189523f, -0.00217669f, -0.09431939f, 
    -0.39507833f, 0.08146753f, 0.12676579f, -0.08106598f, 0.06678478f, 0.18701412f, 0.11392010f, 0.03113361f, 
    -0.15045862f, 0.00531245f, -0.09278261f, -0.14065023f, -0.33355257f, 0.10810345f, 0.12360008f, 0.01567561f, 
    -0.20549576f, 0.10241842f, -0.07398716f, -0.12992205f, 0.10015035f, 0.07797383f, -0.00623263f, 0.20024747f, 
    -0.10832570f, 0.00867112f, 0.01111682f, -0.16223297f, 0.10833470f, -0.02030626f, -0.01367974f, -0.01043579f, 
    -0.01079669f, 0.11002307f, 0.02983486f, -0.04914558f, -0.13236980f, 0.02009226f, -0.01964268f, 0.00001586f, 
    0.04652548f, 0.13677219f, 0.03580187f, -0.02931133f, -0.07171652f, -0.09459197f, 0.00350086f, 0.05846122f, 
    -0.24968871f, -0.01601926f, -0.06552442f, -0.06649526f, -0.17345519f, 0.09280279f, 0.07783461f, -0.01096934f, 
    0.00277447f, 0.09388856f, -0.00424510f, 0.00061318f, 0.08178003f, -0.23338725f, -0.12428739f, 0.04011153f, 
    -0.00989440f, 0.03587357f, 0.08221018f, 0.02306354f, 0.16122073f, 0.05199732f, 0.00719768f, 0.10984941f, 
    -0.03142359f, 0.08322033f, 0.03663318f, 0.05282293f, 0.06022647f, -0.09856404f, 0.00668765f, 0.00377238f, 
    0.14500383f, 0.03162372f, 0.13467865f, 0.22817172f, 0.03329024f, -0.25748914f, -0.06580863f, 0.17237183f, 
    0.15149631f, 0.09998534f, 0.23596431f, 0.05074530f, -0.02106215f, 0.05433066f, 0.03324876f, -0.13613713f, 
    0.14806674f, -0.14786321f, -0.09577206f, 0.11547901f, 0.08961487f, -0.11170291f, 0.10864759f, -0.00961745f, 
    -0.07073338f, -0.02727834f, -0.07175666f, -0.00595520f, -0.05273566f, 0.11799914f, 0.00147601f, -0.16977799f, 
    0.11928316f, 0.11762983f, 0.03772170f, -0.13615537f, 0.13693546f, 0.12262831f, 0.04207041f, -0.15085086f, 
    0.26089478f, 0.05031773f, 0.07676627f, -0.01151073f, -0.07726579f, -0.21744935f, 0.08158714f, 0.07876927f, 
    -0.14247185f, 0.07889259f, 0.09513745f, -0.03362151f, 0.03786309f, 0.12053370f, -0.08662640f, 0.09852426f, 
    -0.01743214f, 0.05978019f, 0.08404524f, -0.08729903f, 0.16041391f, -0.08098393f, 0.07787688f, 0.00189503f, 
    -0.14492701f, 0.05520802f, 0.15474172f, 0.14112757f, 0.00374259f, -0.19608727f, 0.03977020f, 0.04361487f, 
    -0.03301778f, -0.17636608f, -0.05199624f, -0.08744091f, 0.08666562f, -0.12815915f, -0.06356878f, 0.01487834f, 
    0.03668685f, -0.04795953f, 0.03460697f, 0.03986054f, -0.03318861f, 0.01829312f, -0.02811188f, -0.07338832f, 
    -0.03829180f, 0.04053817f, 0.06635710f, -0.24499963f, -0.19178657f, 0.03501673f, -0.01444249f, 0.00340711f, 
    -0.09341321f, -0.06026714f, -0.02795855f, -0.02492508f, -0.12365349f, 0.26596463f, 0.02037149f, -0.01573549f, 
    -0.05429405f, -0.01555722f, 0.14016224f, -0.11384674f, -0.19032699f, 0.00732450f, 0.10232453f, 0.05681662f, 
    0.64447087f, -0.11296269f, -0.06482928f, -0.13346282f, 0.17397848f, 0.09449719f, 0.10904136f, 0.13745116f, 
    -0.00621313f, 0.08705249f, -0.14721093f, -0.09896708f, -0.08363576f, 0.24037410f, -0.11345434f, 0.06493444f, 
    -0.03848205f, -0.03141026f, 0.02584248f, 0.05070852f, -0.00628876f, 0.09237333f, 0.10524121f, -0.02258532f, 
    -0.20088524f, 0.01859753f, 0.29959249f, -0.32289380f, -0.01957070f, -0.08695519f, 0.06068279f, -0.05997776f, 
    0.02733847f, 0.18181798f, 0.04918697f, 0.04602363f, -0.14596188f, 0.04382117f, 0.12813075f, 0.17706408f, 
    -0.04146361f, 0.11957479f, -0.05260853f, 0.03448986f, -0.09215022f, -0.10163011f, 0.11561783f, 0.06364542f, 
    -0.35829481f, 0.11916926f, 0.12950687f, 0.07134407f, 0.07095654f, -0.01431524f, 0.00835086f, -0.03066883f, 
    -0.03231674f, 0.07795011f, -0.00118159f, 0.02913762f, -0.10857289f, -0.31943196f, -0.00623466f, -0.03919070f, 
    0.15468027f, 0.10464302f, -0.07059518f, -0.00865327f, 0.02176481f, -0.03302017f, 0.00554469f, -0.00435838f, 
    0.10877245f, 0.11001524f, 0.06714571f, -0.02397997f, 0.04750644f, -0.00951781f, 0.08891656f, 0.19519548f, 
    -0.08478937f, 0.00327697f, 0.02816988f, 0.00778748f, -0.26317224f, -0.15235549f, -0.18202120f, 0.35484791f, 
    -0.21184687f, 0.00205762f, -0.09989248f, -0.05948794f, 0.07352561f, -0.01988509f, -0.06826241f, 0.02792923f, 
    0.16937087f, -0.19096951f, 0.02787844f, 0.04880061f, 0.15032093f, -0.02071324f, 0.03049647f, -0.05125584f, 
    0.00192648f, 0.08307733f, -0.09373137f, -0.01522045f, -0.35615835f, 0.13820307f, -0.01884893f, -0.08928759f, 
    -0.10547971f, 0.01938725f, 0.06710091f, -0.02396969f, 0.00688656f, -0.04620419f, -0.04181014f, 0.00846045f, 
    -0.12941754f, 0.05180859f, -0.08030131f, -0.02552645f, 0.14794277f, -0.18579417f, -0.06787711f, -0.01534883f, 
    -0.00555083f, 0.10773741f, -0.01256782f, 0.08826243f, -0.01859391f, 0.17856409f, 0.26901358f, 0.28966230f, 
    -0.03694318f, 0.06286009f, 0.13057694f, 0.08596704f, -0.17346647f, 0.02234254f, -0.13497421f, 0.02494435f, 
    -0.05379268f, 0.04974003f, 0.13533168f, 0.23608695f, 0.09587072f, 0.00548503f, -0.06469592f, 0.04075874f, 
    -0.08237766f, 0.02159043f, 0.12277351f, 0.05584133f, 0.19690301f, 0.25304422f, -0.21516956f, 0.25623617f, 
    0.08289897f, 0.02769567f, 0.03551065f, 0.03058602f, 0.03564561f, -0.00284747f, 0.05620345f, 0.08289496f, 
    -0.01375538f, 0.02531127f, 0.00846693f, 0.03688004f, -0.06085666f, -0.00446038f, 0.02274089f, -0.05648115f, 
    -0.07798527f, 0.00514592f, -0.01820403f, 0.06001636f, 0.03422775f, 0.02283048f, 0.03181700f, -0.00392202f, 
    -0.02369444f, -0.01811912f, 0.02243714f, -0.04671225f, -0.02319245f, -0.03252505f, 0.03860555f, 0.05322494f, 
    0.01771913f, 0.02450640f, -0.07687954f, 0.05725545f, -0.00122577f, 0.01640289f, -0.05342717f, 0.05192148f, 
    -0.02418603f, 0.00508824f, 0.04089111f, -0.03402636f, -0.02349439f, -0.01445394f, 0.05714959f, -0.07154024f, 
    0.03922226f, 0.05595475f, -0.02098246f, 0.06083168f, -0.06935829f, -0.05280719f, -0.03657306f, -0.03445078f, 
    0.03272978f, -0.01362902f, -0.05223058f, 0.02882102f, 0.05880469f, 0.05151963f, 0.00915865f, 0.03974467f, 
    -0.07339155f, -0.05112317f, 0.04387852f, -0.04638113f, -0.00399041f, 0.04085951f, 0.04055035f, 0.00142972f, 
    -0.03584801f, 0.03094356f, -0.08146404f, 0.00252488f, -0.05940309f, 0.02905387f, 0.05233582f, -0.04158483f, 
    -0.00023489f, -0.01935810f, 0.05970022f, -0.05972215f, 0.02497987f, -0.02135907f, -0.03887624f, 0.04271838f, 
    -0.01401297f, -0.02234697f, -0.05604213f, -0.04636737f, -0.08325603f, -0.03412977f, 0.00933673f, -0.01375302f, 
    -0.08438464f, 0.04683232f, -0.02626979f, 0.02923001f, -0.00981132f, -0.07341270f, -0.07602450f, 0.03625867f, 
    0.04566330f, -0.03046550f, 0.05936688f, -0.08625689f, 0.00662483f, -0.05979119f, 0.04316720f, 0.01236927f, 
    -0.06707443f, -0.06928599f, -0.07895448f, -0.00367401f, -0.05107280f, -0.00050325f, 0.06053040f, -0.06635608f, 
    -0.05440728f, 0.05465342f, 0.03769066f, 0.02628941f, -0.00635541f, 0.02492364f, -0.07890932f, -0.06109549f, 
    0.00323650f, 0.02263950f, -0.03605277f, 0.01727401f, -0.00418950f, 0.03885401f, -0.02958799f, -0.00819462f, 
    -0.00294642f, -0.07209411f, -0.05734967f, -0.05747807f, -0.00728110f, 0.03867216f, -0.04380320f, -0.02586526f, 
    0.03048280f, -0.05949995f, -0.04166271f, -0.07358926f, -0.07527190f, -0.00393014f, -0.04425058f, -0.01676514f, 
    -0.04437043f, 0.00583390f, 0.01829970f, 0.00367320f, -0.02210297f, 0.03587516f, -0.02138431f, -0.00229094f, 
    0.00845224f, -0.00407308f, 0.01418459f, -0.00936999f, -0.02367965f, -0.06045935f, -0.03857495f, 0.00824597f, 
    0.05751241f, -0.04329258f, -0.07377011f, 0.06471626f, 0.02174767f, -0.02851268f, -0.05867155f, -0.05642554f, 
    -0.00299798f, 0.06179336f, -0.02968149f, -0.06795363f, 0.05947446f, -0.05345154f, -0.05567013f, -0.02439997f, 
    0.03615192f, -0.02179807f, 0.01179487f, -0.04996901f, 0.02542076f, 0.00102000f, 0.03059482f, 0.05405444f, 
    -0.06610686f, 0.02568692f, -0.01836738f, 0.04800697f, 0.05136157f, -0.00486598f, 0.01752173f, 0.01278961f, 
    -0.13759723f, 0.25456992f, -0.09888469f, -0.26203331f, -0.02835087f, -0.02873904f, -0.12201303f, -0.30418697f, 
    0.17796017f, 0.03186808f, -0.02330432f, 0.02802033f, -0.03829463f, -0.20539658f, 0.06627870f, -0.07490935f, 
    -0.14735757f, 0.15112884f, -0.00365309f, -0.16501075f, -0.10235698f, -0.07623483f, 0.02595935f, 0.07872593f, 
    0.17036030f, 0.14553908f, 0.26722324f, 0.24633788f, 0.25567198f, -0.04942378f, -0.06877162f, -0.03477553f, 
    -0.07790306f, 0.07244212f, 0.01323856f, 0.00076603f, -0.04385458f, 0.21893558f, -0.13939953f, 0.03873168f, 
    0.23819442f, 0.12296081f, 0.13246937f, 0.18862285f, 0.01911720f, 0.03937229f, 0.09654390f, -0.03940168f, 
    0.15507393f, -0.15498792f, -0.09095142f, -0.04566501f, -0.21209130f, -0.03346122f, 0.01831179f, -0.08172029f, 
    -0.03214521f, 0.07568403f, -0.00181704f, 0.06374897f, -0.41060492f, 0.40969968f, -0.06398712f, 0.13555899f, 
    0.25040552f, 0.19121702f, 0.18873817f, 0.03419089f, 0.05536121f, 0.08080106f, 0.01872787f, 0.06479378f, 
    -0.12509844f, -0.13752432f, -0.01886720f, -0.07419042f, 0.12676775f, -0.06143403f, -0.10674136f, -0.17437653f, 
    -0.05384455f, -0.20745197f, -0.12680553f, 0.12807228f, 0.24992967f, 0.32523325f, -0.04606273f, -0.08138436f, 
    0.20051259f, -0.02746061f, -0.01584377f, 0.04738929f, -0.09142057f, -0.00765919f, -0.04837532f, 0.11006236f, 
    0.19637336f, 0.04969116f, 0.18750431f, 0.29401845f, 0.11185294f, 0.28269559f, 0.03665913f, 0.24477255f, 
    -0.14634040f, 0.06331662f, 0.05138742f, -0.01542757f, 0.04692521f, -0.36456048f, 0.11364303f, -0.01683150f, 
    -0.25276896f, 0.07816461f, -0.07268231f, -0.06840554f, -0.01656305f, 0.14050591f, 0.03557743f, -0.08283331f, 
    -0.40206504f, -0.11000216f, 0.15182547f, -0.20576537f, 0.00483184f, 0.03771352f, -0.13561660f, -0.13037051f, 
    -0.08229525f, -0.10839596f, 0.05771297f, 0.00406309f, -0.35858658f, -0.10769665f, 0.20451821f, 0.04076685f, 
    -0.18301228f, 0.03030949f, -0.10243195f, -0.04374764f, 0.04790561f, -0.01011306f, 0.06627297f, -0.00926890f, 
    -0.31775558f, 0.01575310f, 0.03405580f, 0.06175324f, 0.01883779f, -0.07158937f, -0.07323159f, -0.18376420f, 
    -0.04994094f, 0.00849230f, -0.21231201f, 0.19948025f, -0.05465617f, 0.09729891f, 0.23263086f, 0.29718915f, 
    -0.14160253f, 0.03489603f, 0.03458818f, 0.06934276f, -0.05857465f, -0.05020840f, -0.06534842f, 0.02035148f, 
    0.17853937f, 0.11967096f, 0.42440495f, 0.10859441f, 0.15415783f, 0.22597264f, -0.09388481f, 0.13588783f, 
    -0.01928401f, 0.10992473f, 0.18413396f, 0.17851605f, -0.35919893f, 0.18911794f, -0.02107833f, -0.08125191f, 
    0.21694411f, 0.04509985f, 0.03349719f, -0.06552795f, 0.11181296f, 0.03876484f, 0.09556421f, 0.18254532f, 
    -0.16331792f, -0.12328355f, 0.19356872f, -0.07176822f, -0.23080947f, 0.09773006f, 0.18967494f, -0.15543278f, 
    0.00566503f, -0.10764328f, 0.09320807f, -0.10101071f, -0.08483896f, 0.23084775f, -0.10903469f, 0.09557422f, 
    0.11179937f, 0.01677244f, 0.04951198f, -0.10308439f, 0.00088289f, 0.01935616f, 0.06700008f, 0.14606763f, 
    -0.10645440f, 0.01906107f, 0.13169158f, -0.17345010f, 0.00443459f, -0.01299806f, 0.03441203f, -0.01142992f, 
    -0.02587353f, -0.00465676f, -0.12410101f, 0.13751712f, 0.05583228f, 0.16071564f, -0.17695466f, 0.28449196f, 
    -0.11387444f, 0.05659388f, 0.02239510f, -0.07676416f, 0.10754639f, 0.09710802f, 0.12715329f, -0.06868291f, 
    0.04713430f, 0.17366707f, 0.14982376f, -0.28367382f, -0.01337979f, -0.09488573f, 0.03961303f, 0.10149206f, 
    0.02682966f, -0.01699829f, -0.05314773f, -0.08855557f, -0.25687769f, 0.10638733f, 0.19523525f, 0.19844539f, 
    -0.00644566f, 0.14709255f, 0.01964216f, 0.09807285f, -0.04975531f, -0.01956171f, 0.10668702f, 0.04727070f, 
    -0.31388456f, 0.18282816f, 0.01648651f, -0.14799948f, -0.05909295f, 0.09372966f, -0.08249316f, -0.10759234f, 
    -0.12152103f, 0.01041936f, 0.07289328f, -0.11459064f, -0.07979707f, -0.01427036f, -0.02492152f, -0.21349396f, 
    -0.03827193f, -0.02781388f, 0.12856898f, 0.08031163f, 0.13714668f, -0.01160327f, -0.00286139f, 0.07703035f, 
    0.18165009f, 0.03523435f, -0.09758560f, -0.12553599f, -0.03217730f, -0.16738491f, 0.12399025f, 0.04987942f, 
    0.00570744f, -0.07631754f, 0.04908975f, 0.00846398f, -0.11678118f, -0.13798743f, -0.27156413f, 0.48164168f, 
    0.05872845f, -0.05827615f, -0.02172121f, -0.12402410f, 0.10329002f, -0.05032261f, -0.12122425f, -0.13867018f, 
    -0.20868783f, 0.08666520f, 0.09483325f, 0.10846525f, 0.10943638f, -0.16978650f, -0.00471002f, 0.01676800f, 
    0.04054297f, 0.11716966f, -0.12016461f, -0.03195971f, -0.33775711f, 0.10047811f, 0.26149452f, -0.04720046f, 
    0.03278814f, -0.08559279f, 0.00263212f, -0.09415289f, 0.16368575f, 0.11391921f, 0.02999916f, 0.05136675f, 
    0.20686841f, 0.09527822f, -0.10158063f, -0.09957889f, 0.05234737f, -0.05382562f, 0.02306978f, 0.24097471f, 
    -0.17997822f, 0.13461268f, 0.16570581f, -0.01625811f, -0.06944518f, 0.19796233f, -0.12049166f, 0.16429131f, 
    0.08266053f, -0.01093832f, -0.05925561f, 0.09939672f, 0.06924983f, 0.00780472f, 0.08481391f, -0.01902862f, 
    0.08768675f, 0.09154715f, 0.05155450f, 0.25078589f, 0.06823884f, 0.01824714f, 0.06227661f, -0.07242268f, 
    -0.02133636f, -0.06309871f, 0.07401333f, -0.09045982f, 0.00202821f, 0.11486693f, -0.24634571f, 0.51974219f, 
    0.04861562f, 0.00054577f, 0.01274790f, -0.11235746f, 0.05984802f, 0.14593613f, 0.03227644f, -0.12583497f, 
    0.30302012f, -0.01807755f, 0.18787615f, 0.09367772f, 0.14130329f, -0.02955655f, 0.16678980f, -0.05895926f, 
    0.06691241f, -0.09485021f, -0.04112659f, -0.06285913f, 0.01513719f, 0.10904768f, -0.05058851f, 0.06144327f, 
    0.25230756f, 0.08314303f, 0.06271651f, -0.12234406f, 0.09274291f, -0.15279971f, 0.03935468f, 0.23430511f, 
    -0.24086463f, 0.07999247f, -0.07072066f, -0.07377034f, -0.13376439f, 0.04985716f, -0.06846658f, 0.01953091f, 
    0.05661724f, 0.00089978f, 0.23563588f, 0.05631538f, 0.00503903f, 0.04073767f, 0.11474156f, 0.17288978f, 
    0.11495966f, -0.01351254f, -0.09479217f, 0.10747863f, -0.01126083f, 0.05662113f, 0.03566928f, -0.25041008f, 
    0.18516473f, 0.01044688f, -0.27901056f, 0.15313604f, 0.23669110f, -0.11193445f, 0.00055067f, 0.14495271f, 
    0.03835685f, 0.04777333f, -0.05210432f, -0.03204234f, 0.06598703f, -0.09059000f, 0.01461199f, 0.06083675f, 
    0.04733313f, -0.01230031f, 0.00958512f, -0.00466738f, 0.15134974f, 0.08347312f, -0.13668121f, -0.09346075f, 
    0.31512696f, -0.15444395f, 0.24929990f, -0.02551233f, 0.06432218f, 0.17740981f, -0.26500908f, -0.21726708f, 
    -0.14476909f, -0.07703195f, 0.13525872f, -0.08359172f, -0.07705152f, 0.24829432f, 0.06573480f, -0.12303808f, 
    0.02510077f, -0.01555349f, -0.03529795f, -0.01695049f, -0.03746247f, 0.11664964f, 0.03532195f, 0.01035341f, 
    -0.01163702f, -0.24907577f, -0.09175124f, -0.28290570f, 0.06197813f, 0.11422025f, 0.02960621f, 0.06470039f, 
    0.09967107f, -0.06324070f, -0.09167659f, 0.03527476f, 0.44517231f, 0.27572185f, -0.01285477f, 0.01202128f, 
    0.03456450f, -0.09818731f, 0.00044211f, -0.18092175f, -0.04234963f, -0.03537712f, 0.11334243f, -0.02992230f, 
    -0.15419370f, -0.09403777f, -0.10637388f, 0.18950686f, -0.02869327f, 0.02708003f, -0.11336070f, -0.08183023f, 
    0.09304512f, -0.01560947f, 0.14372593f, -0.09920189f, 0.16430812f, 0.07997699f, 0.18393473f, -0.12496308f, 
    0.05362683f, -0.08206439f, 0.07876361f, -0.08718630f, -0.01617676f, 0.05297004f, -0.09519634f, 0.19344890f, 
    0.38728711f, -0.18514693f, 0.08476733f, 0.06210472f, 0.18013944f, 0.21138014f, 0.03483262f, 0.08939245f, 
    -0.02430013f, 0.04307616f, -0.15627727f, 0.07128317f, -0.42266196f, -0.19385836f, -0.22999093f, -0.27256486f, 
    0.18706030f, 0.02320553f, 0.03566213f, 0.00351240f, 0.11893278f, -0.06511534f, 0.06979958f, -0.13352171f, 
    -0.00910661f, 0.01733948f, -0.13433486f, -0.29230347f, 0.00141442f, 0.29614845f, 0.01151267f, -0.07607798f, 
    0.07616575f, 0.14304529f, 0.05220267f, -0.04883700f, 0.10604803f, -0.11158215f, -0.03867416f, 0.10178877f, 
    -0.08384034f, 0.02887290f, -0.13880233f, 0.00433443f, -0.03646933f, 0.14251688f, 0.08141509f, -0.06208629f, 
    -0.06903674f, -0.20514421f, 0.19886613f, 0.03525475f, 0.11201002f, -0.02126541f, -0.03089343f, 0.19648559f, 
    0.02191043f, 0.00597403f, 0.10044280f, 0.16860265f, 0.08507285f, 0.27013767f, 0.24582681f, -0.04667660f, 
    0.21608312f, 0.00941883f, -0.01710384f, 0.01225672f, 0.09379499f, 0.09306583f, 0.04267642f, 0.02950830f, 
    0.01122447f, 0.03457856f, -0.22701168f, 0.00418497f, -0.03000418f, 0.17987120f, 0.14497878f, 0.12529896f, 
    0.13795796f, 0.12127911f, 0.19574115f, 0.03305880f, -0.00742358f, -0.19606237f, -0.01173172f, -0.24033011f, 
    -0.09920329f, 0.03368753f, 0.02869141f, 0.00693864f, 0.02158419f, 0.09942394f, -0.00867273f, 0.03931481f, 
    -0.26903033f, 0.09773912f, 0.17583576f, -0.18096362f, 0.21892433f, -0.00445575f, -0.09258429f, 0.13884498f, 
    0.05710081f, -0.01159414f, -0.03998034f, 0.10336475f, 0.58614874f, -0.24229948f, -0.31347972f, -0.28996927f, 
    -0.05725047f, -0.07597300f, -0.02323461f, 0.13909023f, 0.15634955f, 0.04660138f, 0.05633646f, 0.14485274f, 
    -0.09569652f, -0.00720142f, 0.09458665f, 0.06931118f, -0.01254760f, 0.06108177f, -0.02473025f, 0.01849626f, 
    0.24111591f, 0.01431709f, 0.07011221f, 0.02822188f, 0.20354649f, -0.04641030f, 0.13283566f, 0.11173015f, 
    -0.04065690f, 0.20106767f, 0.09734683f, 0.09313700f, 0.02694261f, 0.06063413f, -0.06845850f, 0.06743760f, 
    0.18915090f, -0.07019448f, -0.10225229f, -0.01650526f, -0.04897358f, 0.00585852f, -0.04812380f, -0.01775362f, 
    0.14057802f, 0.09297506f, -0.12073740f, 0.01976277f, -0.12166018f, 0.11117005f, 0.23827027f, -0.06842539f, 
    0.06565415f, 0.10165098f, 0.18760261f, 0.16103217f, -0.02017769f, -0.14566746f, 0.14596073f, 0.16605985f, 
    0.23843108f, -0.25020343f, -0.21971136f, 0.15815935f, -0.03761084f, -0.01938283f, -0.02548213f, 0.04551733f, 
    0.02543743f, 0.00033294f, 0.10268793f, 0.00474126f, 0.07630154f, 0.38602868f, -0.04269671f, -0.18348810f, 
    0.16084553f, 0.10060766f, 0.07049296f, -0.02586684f, -0.03618194f, 0.07465114f, -0.06375943f, 0.05635904f, 
    0.11426199f, -0.09156326f, 0.07512406f, 0.10895339f, 0.12370218f, 0.04356373f, -0.02454293f, -0.01484137f, 
    0.00724327f, 0.09918483f, 0.08113024f, -0.01143822f, -0.02078765f, -0.13125233f, 0.18200724f, -0.17713973f, 
    0.12389059f, 0.01612170f, 0.13000961f, -0.01337817f, 0.02013197f, 0.00497319f, -0.03162639f, -0.00962309f, 
    -0.23638858f, -0.05697914f, -0.21869446f, -0.10069646f, 0.00744682f, 0.08592757f, -0.04808962f, -0.03744225f, 
    -0.07937372f, 0.19461907f, -0.02228094f, -0.01797676f, 0.12546161f, -0.28217778f, -0.05987604f, -0.21364470f, 
    -0.10559063f, 0.01464701f, 0.17799172f, 0.10016149f, 0.04806591f, 0.04072915f, -0.01295692f, 0.00832678f, 
    0.07120682f, 0.28939030f, -0.01432563f, 0.32559952f, 0.20512730f, 0.01532986f, 0.05441764f, 0.12499699f, 
    0.14513554f, 0.12857614f, 0.03693585f, 0.05102503f, 0.05630232f, -0.03407767f, -0.06176198f, 0.08186431f, 
    -0.01165598f, 0.00927150f, -0.04789381f, 0.01342822f, 0.11457640f, -0.06110879f, -0.14981933f, -0.25833023f, 
    0.36740541f, -0.16352835f, 0.07949468f, -0.10769349f, -0.06967676f, -0.10019542f, -0.11262580f, -0.07134376f, 
    -0.03455365f, 0.02207715f, 0.04539093f, -0.08331227f, -0.23388453f, 0.11785991f, 0.35608739f, 0.16879636f, 
    0.07012545f, -0.00068400f, 0.05454099f, 0.21476677f, 0.03542710f, 0.05951677f, -0.20832309f, -0.02128424f, 
    0.04230663f, -0.07072338f, -0.32431549f, 0.46438187f, 0.03050414f, 0.00439608f, -0.07874902f, -0.23372087f, 
    -0.06140543f, -0.02326168f, -0.14652163f, -0.03696778f, 0.06344127f, -0.08921794f, 0.28906658f, 0.14090100f, 
    0.09059639f, -0.05487891f, -0.20087621f, -0.05611121f, 0.03311481f, 0.15480202f, 0.08917949f, 0.07255759f, 
    0.32037613f, 0.07732893f, -0.00778410f, -0.29236063f, 0.08006255f, 0.02852295f, -0.02482888f, 0.00407692f, 
    -0.05804474f, 0.05838178f, 0.04011854f, 0.08540207f, 0.36090451f, 0.14721133f, 0.02172476f, 0.09566996f, 
    0.03425545f, -0.09259049f, 0.08744991f, 0.14966920f, 0.03613810f, 0.14803080f, -0.03981534f, 0.02012461f, 
    -0.11465797f, -0.06555846f, 0.04253693f, 0.21050681f, -0.03270641f, 0.06460439f, -0.17771676f, -0.02965042f, 
    -0.07057039f, 0.00927495f, 0.03149376f, 0.03877543f, 0.35591266f, 0.10245277f, 0.01733437f, -0.05381464f, 
    -0.05501332f, -0.00986003f, 0.02982366f, -0.02110779f, -0.10636619f, 0.10426303f, 0.07840164f, -0.06843837f, 
    0.45355114f, -0.08097408f, -0.03293673f, -0.12512366f, -0.01907363f, 0.18074490f, 0.07787324f, 0.05801425f, 
    -0.02472845f, -0.15822721f, 0.01875534f, -0.13975295f, 0.09737028f, 0.01872594f, 0.05804419f, -0.24881378f, 
    -0.03505885f, 0.06584478f, -0.10370697f, -0.10302967f, -0.05037753f, -0.03394683f, 0.03925796f, -0.14531110f, 
    0.07889845f, 0.03972461f, 0.00344925f, -0.03686771f, 0.03092277f, 0.15210615f, -0.01018777f, -0.42882630f, 
    0.00363562f, -0.05801819f, 0.10837817f, 0.08415676f, -0.14863673f, 0.06641180f, -0.17441125f, -0.36526006f, 
    -0.06403092f, 0.02471007f, -0.15447292f, -0.00887378f, -0.07517099f, -0.00821179f, 0.08927319f, 0.12905030f, 
    -0.16241686f, 0.06598996f, -0.08465345f, -0.26729989f, 0.02370763f, -0.10415206f, 0.10693043f, 0.03793964f, 
    -0.15597990f, -0.05638538f, -0.04357782f, 0.06642210f, 0.06503997f, 0.10828581f, 0.31462276f, 0.07432502f, 
    0.10222659f, 0.00697905f, -0.07889009f, 0.11667583f, 0.01949589f, 0.02095616f, -0.00436335f, -0.02802169f, 
    0.03865624f, 0.16427256f, -0.09909752f, 0.12349598f, 0.12510452f, -0.06706031f, 0.09137182f, -0.02913395f, 
    -0.07882232f, -0.12352861f, 0.12106013f, -0.10642330f, -0.03003532f, -0.18725193f, 0.15680800f, 0.18273817f, 
    -0.14775895f, 0.02418164f, 0.02740943f, -0.02543678f, -0.00247618f, -0.07282195f, 0.03584539f, -0.00105941f, 
    -0.18177706f, 0.02084938f, -0.10181626f, -0.15515742f, 0.13714777f, -0.00360638f, 0.08873491f, 0.01155786f, 
    0.00755853f, 0.02273697f, -0.07673544f, 0.10169815f, -0.12667468f, -0.07500096f, -0.13997842f, 0.07618105f, 
    -0.11556397f, -0.01803776f, -0.07979517f, 0.02562797f, 0.00883345f, -0.14666659f, 0.03944409f, -0.03548275f, 
    0.12024412f, -0.10692509f, -0.04434351f, 0.17414899f, -0.05566951f, -0.07762809f, 0.11749785f, -0.00225724f, 
    -0.04733460f, 0.16699518f, 0.01260182f, 0.02230976f, -0.51090872f, 0.25986406f, 0.06248074f, 0.21922308f, 
    -0.01881271f, 0.13078856f, -0.06675314f, -0.00652002f, -0.04684338f, -0.02611020f, 0.03134605f, -0.02055073f, 
    -0.31635240f, -0.09324538f, -0.01202588f, -0.01204375f, 0.17214908f, 0.12100188f, -0.10968935f, 0.05172437f, 
    -0.12444356f, -0.04053299f, -0.09173972f, 0.13631417f, 0.05043769f, 0.27700227f, -0.26625717f, -0.10166807f, 
    -0.10832616f, -0.05146581f, 0.01679867f, -0.01429140f, 0.07767630f, 0.05184841f, -0.03190015f, -0.01511152f, 
    -0.08956513f, -0.00616997f, -0.21596898f, -0.11145408f, 0.02245426f, 0.11836855f, -0.05803774f, 0.13862310f, 
    -0.04491844f, -0.15742411f, 0.04968128f, 0.09046777f, -0.07674643f, -0.45627820f, -0.13637212f, 0.20803291f, 
    -0.20301040f, 0.04730247f, -0.09207325f, -0.03549731f, -0.02731361f, 0.03551653f, -0.02307032f, -0.09095817f, 
    0.09116967f, 0.21467531f, 0.20667817f, 0.09490490f, -0.23228909f, 0.05366691f, 0.04581500f, 0.16304156f, 
    0.03409134f, 0.08650534f, -0.18741338f, -0.10004898f, -0.28436998f, -0.03371746f, 0.37356207f, 0.15667266f, 
    0.08804908f, -0.03812670f, -0.12733313f, 0.06845073f, 0.06650064f, 0.06652039f, 0.12560190f, -0.18825898f, 
    -0.16025990f, 0.15334105f, 0.11125539f, -0.03453922f, 0.01789055f, -0.16002250f, 0.07248899f, 0.18065265f, 
    0.03890868f, 0.12111438f, 0.00484574f, -0.10896110f, 0.14524332f, 0.05852902f, 0.03626520f, 0.18111531f, 
    -0.02984544f, -0.03406686f, -0.01659997f, 0.13097873f, -0.01962304f, -0.06468333f, -0.02630911f, 0.11356371f, 
    0.18391314f, -0.19040611f, 0.07597183f, 0.08352966f, 0.12311804f, 0.00135801f, 0.03029792f, -0.00082643f, 
    0.24274431f, -0.03505398f, 0.14796712f, 0.07917411f, 0.01593312f, -0.05812300f, -0.01564675f, 0.21649231f, 
    0.10087682f, 0.01156279f, -0.09101488f, -0.07839965f, 0.02190066f, 0.00997724f, 0.06741197f, 0.05803098f, 
    0.13324197f, 0.16133796f, 0.13141397f, -0.21620616f, -0.10912704f, 0.09180931f, 0.03756078f, -0.10607201f, 
    0.06008647f, -0.03858466f, -0.01730752f, -0.02998130f, -0.02385124f, 0.16093220f, 0.02383510f, 0.13010003f, 
    -0.04636765f, 0.06106896f, 0.19310421f, -0.20590006f, -0.03897228f, 0.01800363f, -0.06208302f, 0.12230360f, 
    0.18684150f, -0.25155762f, 0.02018002f, -0.17557211f, 0.01555904f, -0.07475302f, -0.04133539f, 0.11887328f, 
    -0.06624387f, 0.09731843f, -0.05726692f, -0.01136148f, -0.49215958f, 0.03147479f, 0.06253027f, 0.29942414f, 
    0.17300023f, 0.09185283f, -0.11342687f, 0.07108493f, -0.08174268f, 0.01878317f, 0.18410477f, -0.05260879f, 
    0.37028569f, 0.08669056f, 0.11846313f, -0.01883686f, 0.13375756f, -0.13053329f, -0.01777894f, -0.15077087f, 
    -0.05522149f, 0.14061344f, -0.04207754f, 0.03586695f, -0.54183024f, -0.13439965f, -0.20486785f, 0.26298967f, 
    0.19562067f, 0.04467652f, -0.02309204f, 0.08769728f, 0.01790295f, -0.01873358f, 0.01648464f, -0.00029807f, 
    0.00368628f, 0.11113366f, 0.10812872f, 0.14970133f, 0.12085965f, 0.17869729f, -0.08091716f, -0.17530520f, 
    -0.14080766f, -0.14700556f, -0.04910125f, -0.04881993f, -0.14860773f, -0.08707646f, -0.26202211f, -0.15150554f, 
    0.00856294f, 0.04973045f, 0.08416007f, 0.06787793f, 0.07987890f, 0.00549993f, -0.02679959f, 0.16398609f, 
    0.13555908f, -0.25226569f, -0.18348698f, -0.13872510f, 0.12228607f, -0.00790479f, 0.09480073f, 0.26411828f, 
    0.09839029f, -0.09504647f, 0.01538954f, 0.13358258f, 0.16078426f, -0.10460634f, -0.20042160f, 0.13028473f, 
    -0.12733269f, -0.12276680f, 0.10795030f, 0.01609468f, 0.00657721f, 0.07591037f, -0.04355663f, -0.16089860f, 
    -0.08995860f, -0.17698507f, -0.11753917f, -0.16839759f, 0.04142961f, 0.08656053f, 0.07576862f, -0.12182104f, 
    0.06653426f, 0.00487693f, 0.00780682f, -0.08344267f, -0.38400105f, 0.12228498f, 0.30112720f, 0.04667214f, 
    0.00773754f, 0.12336642f, 0.09004308f, -0.08474718f, 0.11016517f, 0.06531532f, 0.00307861f, -0.00348752f, 
    0.30197725f, 0.17581454f, -0.10652682f, -0.03881469f, -0.04064809f, -0.13837107f, 0.09827065f, 0.06733386f, 
    -0.02200396f, 0.11179128f, -0.08086621f, 0.10466019f, -0.11211778f, 0.11396746f, -0.03971011f, 0.12784071f, 
    -0.18076973f, -0.07658099f, 0.12067935f, 0.03046503f, -0.05729488f, 0.07717172f, 0.15677689f, 0.09219450f, 
    -0.16078012f, -0.01490986f, 0.27113482f, 0.15046979f, 0.04855209f, -0.09105182f, -0.03222452f, 0.11190429f, 
    0.07732875f, -0.04775809f, 0.20731473f, -0.04108140f, -0.21057853f, 0.14681324f, -0.19548678f, 0.39231151f, 
    0.22507338f, -0.13988487f, -0.05729282f, 0.09947371f, -0.05392515f, -0.04037275f, 0.03242769f, -0.07416908f, 
    -0.07072823f, 0.02603527f, -0.05320240f, -0.10283904f, 0.02061790f, -0.03929940f, -0.14016835f, -0.08639878f, 
    -0.00443529f, 0.06695091f, 0.00953472f, -0.00095436f, 0.05427606f, -0.00484067f, -0.04494577f, -0.01058908f, 
    -0.02648609f, -0.12883629f, -0.10997426f, -0.03026810f, -0.00038466f, 0.00986225f, -0.01399828f, -0.09771340f, 
    -0.04722243f, 0.04394003f, 0.06837705f, -0.01695530f, -0.02175629f, -0.02251346f, 0.03225420f, -0.04518518f, 
    -0.02321018f, -0.06262124f, 0.03584730f, -0.01766746f, -0.10176992f, 0.00456612f, -0.00668443f, -0.05635595f, 
    -0.06057948f, -0.00140235f, -0.00979254f, 0.01327253f, -0.03199515f, -0.00734816f, 0.02982575f, 0.01283377f, 
    -0.07918675f, -0.01615576f, -0.00717516f, -0.07380240f, -0.05784831f, -0.07222369f, 0.01841430f, -0.02214258f, 
    -0.07283858f, 0.02022089f, -0.01278809f, 0.02688897f, -0.06339106f, -0.05475499f, -0.06375657f, 0.02411447f, 
    0.02315104f, -0.03683461f, 0.04387847f, 0.03206967f, -0.03751637f, 0.02154544f, -0.06430953f, -0.10956979f, 
    -0.06211779f, 0.01836003f, -0.08269296f, 0.02616246f, -0.02940864f, -0.07060850f, -0.11686923f, -0.03212756f, 
    0.04714204f, 0.04811502f, 0.08077908f, 0.06482067f, -0.02233181f, -0.06865087f, -0.07854364f, 0.01095090f, 
    0.03102487f, 0.01044174f, 0.00997127f, 0.00214494f, -0.07528798f, -0.08257341f, -0.04649175f, -0.00675116f, 
    -0.03439339f, -0.03011791f, -0.03439483f, 0.07849193f, -0.01360426f, -0.05660688f, 0.04735747f, 0.02762005f, 
    -0.05861097f, -0.04782809f, 0.03705592f, 0.06716431f, -0.05006728f, 0.03904555f, 0.00425056f, -0.09452359f, 
    -0.04077342f, -0.00701174f, -0.07489199f, -0.06132708f, -0.09583484f, 0.03987113f, -0.02416847f, 0.02892727f, 
    -0.01581725f, 0.01516147f, -0.01739343f, 0.03373843f, -0.03020261f, -0.08817935f, -0.02044500f, -0.06368804f, 
    -0.06056770f, 0.06648150f, -0.05970173f, -0.01961945f, 0.05333496f, 0.03654676f, -0.01257543f, -0.06247903f, 
    -0.10613334f, -0.11089985f, -0.12065582f, -0.00540751f, -0.01375008f, 0.05562649f, 0.00567861f, -0.01927938f, 
    -0.02029058f, 0.00363594f, -0.02674021f, -0.04705418f, 0.01326448f, -0.06014368f, -0.04830312f, -0.02256634f, 
    -0.00450137f, -0.04170413f, 0.01571362f, 0.07127000f, 0.08605694f, 0.06494838f, -0.05404782f, -0.05328913f, 
    0.03782663f, 0.00914414f, 0.00507979f, -0.02833479f, 0.01624296f, -0.05537925f, -0.06385780f, -0.04467164f, 
    -0.04344446f, -0.01667257f, -0.04109157f, 0.04751602f, 0.04521707f, 0.05134128f, 0.01017942f, 0.01298555f, 
    0.01757219f, -0.02675435f, 0.06214385f, -0.03843430f, -0.05945816f, -0.00557799f, -0.01776476f, -0.01898012f, 
    0.07042812f, -0.04698503f, -0.02637425f, -0.04648396f, -0.01662172f, -0.06065955f, -0.07646003f, -0.00125017f, 
    -0.05570717f, -0.01719959f, -0.05099350f, -0.07106227f, -0.03338479f, -0.05512974f, -0.00901877f, -0.01848605f, 
    0.00183022f, 0.00843595f, 0.02783136f, -0.06312916f, 0.00870171f, -0.05327150f, 0.00149125f, 0.05483950f, 
    -0.01679576f, 0.02460845f, 0.02018538f, -0.05967591f, -0.05484613f, -0.05754594f, -0.03826619f, -0.05794570f, 
    0.01683023f, -0.05605619f, -0.03805581f, 0.03660232f, -0.00072759f, -0.00261234f, 0.02420598f, 0.04578160f, 
    0.03507015f, -0.07591725f, -0.06719394f, 0.04322695f, 0.02961805f, 0.02391061f, -0.06724696f, -0.06359825f, 
    0.02059529f, 0.04832674f, -0.01928583f, 0.00642985f, -0.01170486f, 0.00209587f, 0.02100152f, -0.06598186f, 
    -0.03251269f, 0.05107766f, 0.04095312f, -0.02156546f, 0.00886752f, -0.02435695f, -0.07597429f, -0.05948010f, 
    -0.03236203f, -0.00260913f, 0.06729688f, -0.05783464f, -0.03911198f, 0.04054941f, 0.05736772f, -0.03248221f, 
    -0.04272235f, -0.07020888f, -0.01018635f, -0.02843246f, -0.05679595f, 0.00112734f, 0.03809448f, -0.04011783f, 
    -0.03927583f, -0.07245594f, -0.01344940f, -0.04140560f, 0.02979276f, -0.01943388f, -0.04529511f, 0.00825077f, 
    0.05436301f, -0.02067142f, 0.04325984f, -0.00587975f, -0.01733628f, 0.06232750f, -0.00480049f, -0.03355532f, 
    -0.02103107f, -0.05619621f, 0.05743003f, 0.05773543f, -0.05158744f, -0.00041688f, -0.06346709f, -0.04207242f, 
    0.04252399f, -0.06778197f, -0.01664047f, 0.04839554f, -0.03365205f, -0.02390696f, 0.02251391f, 0.04002497f, 
    0.02432265f, -0.03727825f, -0.06894091f, -0.02277843f, 0.04739594f, -0.02380706f, -0.00551312f, -0.00797321f, 
    0.01630828f, 0.01079831f, 0.01545206f, 0.05384538f, -0.07528008f, -0.04574187f, -0.07069417f, 0.03822549f, 
    -0.02600577f, -0.03348362f, 0.05369867f, 0.01760371f, -0.05597001f, -0.07157068f, -0.05648473f, -0.02009703f, 
    -0.03641562f, 0.04470653f, 0.02828453f, -0.07926267f, -0.00696909f, -0.03702623f, -0.00807087f, -0.01032212f, 
    -0.02475229f, -0.02663501f, 0.04235079f, 0.02309924f, 0.02089062f, -0.02892820f, -0.02707278f, 0.06814729f, 
    0.00574869f, -0.00790260f, 0.01422287f, -0.01270088f, -0.03661632f, 0.01409162f, -0.07843740f, -0.04059797f, 
    0.03455485f, -0.03456092f, 0.04903362f, -0.03963399f, -0.03307212f, 0.03630501f, -0.01643029f, 0.04291123f, 
    -0.00403267f, -0.05942231f, 0.03286393f, -0.07368974f, 0.04061571f, -0.04786082f, -0.01824890f, 0.05621973f, 
    0.05203045f, 0.00217899f, 0.01669314f, -0.00820466f, -0.00283925f, -0.00658834f, 0.02907957f, -0.03209645f, 
    -0.07565077f, 0.01638313f, 0.04527950f, -0.07308593f, -0.06956066f, -0.02534149f, 0.03401127f, 0.00692744f, 
    0.03603460f, -0.00374944f, 0.03793642f, -0.01294162f, -0.01606681f, -0.00100283f, 0.05105647f, -0.05233351f, 
    -0.16578989f, -0.10369559f, 0.10182144f, -0.24016440f, 0.16482678f, 0.07211077f, -0.05865794f, 0.00031704f, 
    0.21289389f, -0.00123190f, -0.01542961f, -0.01039208f, 0.10949380f, 0.16296975f, 0.01440554f, 0.01533625f, 
    0.35605818f, 0.10450741f, 0.03519319f, -0.01069436f, 0.11660397f, -0.09767883f, -0.00760923f, 0.32162473f, 
    -0.29447526f, 0.42523757f, 0.20791502f, 0.22799197f, -0.09513628f, 0.05498100f, 0.01133566f, 0.10046926f, 
    -0.04981360f, -0.10006429f, 0.20537339f, 0.03254784f, 0.18628831f, -0.09581937f, -0.25092053f, -0.17364679f, 
    -0.05510736f, -0.02450619f, -0.10718574f, -0.06261789f, 0.06048984f, -0.09724691f, 0.05279385f, -0.13035876f, 
    -0.28361821f, 0.04761080f, -0.01018766f, -0.20526768f, 0.04906670f, 0.02462324f, -0.05104118f, 0.11124977f, 
    0.05286714f, 0.09917656f, 0.00786959f, 0.23631863f, 0.37956110f, 0.02527130f, -0.33934051f, -0.17006607f, 
    -0.06104956f, -0.03130255f, 0.16556345f, -0.01636848f, 0.06477059f, 0.06576332f, -0.12808540f, -0.13998076f, 
    0.17517506f, -0.11939734f, 0.16200311f, 0.00746102f, 0.03060966f, 0.05068089f, -0.15969241f, -0.03046320f, 
    -0.00680589f, -0.07423005f, 0.15425149f, -0.09259542f, 0.24359718f, 0.03222377f, 0.17256866f, 0.08120897f, 
    -0.02353515f, 0.01923126f, -0.07441850f, -0.18886393f, -0.14458981f, -0.05627796f, 0.01755795f, -0.01264643f, 
    0.22022252f, -0.14364836f, 0.02274599f, 0.07317805f, 0.01694212f, -0.01576281f, 0.06392234f, 0.01794296f, 
    0.11575133f, 0.09385820f, -0.10920326f, -0.15102950f, 0.16818570f, 0.03503986f, 0.22646636f, 0.02800337f, 
    0.04052999f, 0.15203136f, -0.04819284f, 0.00461871f, 0.07454792f, -0.02703026f, 0.08321627f, 0.14441423f, 
    -0.57388037f, -0.09637503f, -0.16334493f, -0.10715677f, 0.09067919f, 0.03211420f, -0.15517685f, 0.10544711f, 
    0.00229564f, 0.02833665f, 0.27604517f, 0.02141024f, 0.35916981f, -0.07820157f, -0.07978193f, 0.04554309f, 
    0.17885332f, -0.03431612f, 0.13483356f, 0.06684826f, 0.05150761f, 0.13980873f, 0.08468714f, 0.16695988f, 
    0.04375020f, -0.21424228f, 0.14705423f, -0.14891575f, 0.09848653f, 0.11322787f, -0.08415116f, 0.16128060f, 
    -0.01365533f, 0.19767159f, -0.18584056f, 0.16913548f, -0.17063928f, -0.02313067f, -0.00617839f, -0.02430468f, 
    0.03405697f, 0.07550435f, 0.08183736f, 0.08247907f, 0.16058069f, -0.06883117f, -0.07944194f, -0.24476254f, 
    0.13465184f, -0.08289353f, 0.08748315f, 0.12045604f, 0.09711404f, 0.21956120f, 0.01621305f, -0.05714545f, 
    0.01938733f, 0.06269963f, 0.04615979f, -0.05455050f, -0.28038806f, -0.16922349f, -0.08657248f, -0.12295862f, 
    -0.07545607f, -0.02396134f, 0.01533178f, -0.11101463f, 0.12339170f, 0.04548980f, -0.05001999f, -0.04084432f, 
    0.24411133f, 0.36028057f, 0.20461024f, 0.01954959f, 0.00449236f, 0.00089198f, 0.00586294f, 0.13325179f, 
    0.04991421f, 0.10902379f, -0.04185872f, 0.07845958f, 0.04805933f, 0.14762998f, 0.09673730f, -0.14110075f, 
    0.11484956f, -0.12217423f, 0.08076363f, -0.05704250f, -0.04737389f, -0.10901970f, 0.13686538f, -0.07099099f, 
    0.37609178f, -0.17797740f, -0.44532967f, -0.00636080f, -0.09042553f, 0.05963148f, -0.07309448f, -0.01023724f, 
    0.10084739f, 0.15363206f, 0.10483258f, -0.07737163f, -0.08813599f, -0.04891643f, 0.27180910f, -0.13225368f, 
    0.12789541f, 0.06740843f, -0.04479361f, 0.15229599f, -0.04292833f, 0.03245546f, 0.08338788f, -0.04089575f, 
    -0.02710221f, 0.10609893f, 0.10278336f, -0.01872291f, 0.14029720f, -0.03516032f, 0.00705457f, 0.03159054f, 
    -0.10711547f, 0.03522734f, 0.06090924f, 0.06035470f, 0.17217244f, -0.20533827f, -0.12889993f, -0.10539383f, 
    0.17706124f, 0.06737525f, -0.10527426f, 0.01754072f, 0.10277237f, 0.08580529f, 0.00635386f, 0.02725683f, 
    0.30905515f, 0.08862808f, 0.16351561f, 0.23821267f, 0.07850897f, 0.09631001f, 0.03818138f, 0.02123520f, 
    0.13125670f, 0.01368624f, 0.06397533f, 0.01808099f, 0.10068612f, -0.02510240f, 0.00977158f, 0.29268202f, 
    0.09514839f, 0.06848109f, -0.03048104f, -0.09122840f, -0.05493094f, 0.12252124f, 0.06038907f, -0.07935207f, 
    -0.09053146f, -0.23372768f, -0.11822806f, 0.02360908f, 0.08324020f, 0.14961724f, -0.00141588f, 0.15610661f, 
    0.04144343f, 0.20607613f, -0.02698199f, 0.05015648f, 0.06416974f, 0.18242909f, 0.25187999f, -0.24302799f, 
    -0.07262739f, -0.17766704f, 0.08896141f, 0.02371408f, 0.02711745f, 0.02409180f, 0.15333319f, 0.11464503f, 
    0.55118376f, -0.50171220f, 0.09119454f, 0.10391989f, -0.07925825f, -0.01151474f, -0.01578146f, -0.14575040f, 
    -0.02323610f, -0.03171365f, 0.16808169f, -0.01782335f, 0.04283978f, 0.30644932f, -0.02341662f, -0.26460704f, 
    0.02961393f, 0.12297576f, 0.02500177f, 0.07231467f, -0.19729501f, 0.05454169f, -0.10158996f, -0.06633352f, 
    0.07941076f, -0.00505482f, 0.16370766f, 0.03555010f, 0.11322196f, 0.12727599f, -0.04036468f, -0.14555904f, 
    0.18355218f, -0.09904496f, -0.25485110f, 0.10051043f, -0.60490626f, -0.24438742f, 0.29453579f, -0.37735811f, 
    -0.06031286f, -0.07733005f, -0.03753912f, -0.09413412f, -0.10656057f, -0.02249438f, -0.02027193f, -0.01453481f, 
    -0.39341548f, -0.27681324f, 0.04503578f, -0.22522204f, -0.04435780f, -0.00664119f, -0.10064487f, 0.02665959f, 
    -0.13765958f, 0.00894618f, 0.08827278f, 0.17603751f, 0.07374313f, 0.01981932f, 0.29822949f, -0.31201842f, 
    0.03310428f, -0.09143557f, 0.03599516f, 0.02125357f, 0.07205083f, 0.04114979f, 0.03101484f, 0.07073499f, 
    0.02830950f, -0.38652441f, -0.14267521f, 0.10040313f, 0.05316602f, 0.02520914f, -0.03991395f, -0.08209901f, 
    0.08563663f, -0.11214503f, -0.07974258f, 0.00166474f, 0.22128673f, -0.06371031f, 0.00378346f, 0.19198601f, 
    -0.08257493f, 0.09583627f, -0.01539698f, 0.05223923f, 0.02697034f, 0.09636865f, -0.02952294f, 0.08753505f, 
    -0.78461409f, 0.18585147f, 0.08796681f, 0.16683333f, -0.09477868f, -0.01006118f, -0.07201065f, 0.02214213f, 
    -0.02521722f, -0.06616097f, 0.07052690f, 0.18483771f, 0.05769203f, -0.13601853f, -0.11946743f, 0.05260665f, 
    -0.03351276f, -0.06061732f, 0.04600123f, -0.06930406f, 0.02510652f, -0.05881062f, 0.01704070f, 0.03140462f, 
    0.42317492f, 0.01990098f, -0.12753505f, 0.15658408f, -0.05205586f, -0.04221759f, -0.03848760f, 0.08703893f, 
    0.04824326f, 0.00188017f, -0.08412968f, -0.02416452f, -0.07291830f, -0.00275691f, -0.05864773f, 0.08737497f, 
    -0.02161207f, 0.00600247f, 0.09793682f, 0.13604073f, 0.07634757f, -0.01537287f, 0.07103927f, -0.10757840f, 
    0.05405837f, 0.02730448f, -0.14728749f, -0.11922453f, -0.06121393f, -0.05195432f, -0.17492644f, -0.03727612f, 
    0.05155174f, -0.03182938f, 0.16833277f, -0.03495197f, -0.32744280f, 0.13491324f, -0.04442493f, -0.15876661f, 
    -0.01127222f, -0.00741829f, -0.01224031f, 0.11963227f, 0.00720318f, 0.05219968f, 0.02977978f, 0.15419362f, 
    0.06677721f, -0.03304689f, -0.05676179f, -0.13055123f, 0.14716145f, -0.00465077f, 0.02003917f, -0.01818064f, 
    0.04754226f, -0.06437018f, 0.03292856f, 0.11581431f, 0.22662087f, -0.15588336f, -0.07708187f, -0.14092341f, 
    0.12838995f, 0.22796001f, 0.08061671f, -0.02787816f, 0.07110111f, 0.02920608f, -0.03073727f, -0.02726263f, 
    -0.67608166f, 0.51319557f, -0.12953410f, -0.10701549f, -0.03256213f, 0.10857591f, -0.05355100f, 0.18766537f, 
    0.05462494f, 0.14457867f, 0.00839841f, 0.13770078f, 0.28117284f, 0.00882771f, 0.22149627f, 0.26750505f, 
    0.00464616f, 0.01198081f, 0.01667606f, -0.01380453f, 0.07608286f, 0.02860374f, 0.03688587f, 0.12459063f, 
    0.17647225f, 0.01164787f, 0.00232958f, 0.07553545f, -0.11659195f, 0.03595929f, 0.05103765f, 0.25033355f, 
    -0.02113785f, 0.05077354f, 0.12227590f, -0.11035255f, 0.33758935f, -0.01013122f, -0.20344728f, 0.17950171f, 
    0.04230889f, 0.07468422f, 0.16348301f, 0.04522279f, 0.10281416f, 0.06145693f, 0.09431654f, -0.01142947f, 
    0.20793949f, 0.17292875f, -0.13625687f, 0.03526348f, -0.03694943f, 0.13777690f, 0.26131520f, 0.12504442f, 
    0.07980444f, 0.14129326f, 0.05392883f, -0.19164647f, -0.24303377f, -0.29507589f, -0.24732339f, -0.12030106f, 
    -0.19465318f, 0.15156233f, -0.03580931f, 0.04490479f, -0.03458218f, 0.09564649f, -0.00592330f, 0.00411940f, 
    -0.02147646f, 0.03866851f, -0.05436952f, 0.00777590f, -0.06153456f, -0.04323686f, 0.05584186f, -0.01989160f, 
    0.06369626f, -0.02900406f, -0.02589365f, -0.04356582f, 0.03627947f, -0.02919440f, -0.01800848f, -0.06179554f, 
    0.06496450f, 0.02503411f, -0.05897411f, -0.04300424f, 0.01495013f, 0.00605143f, -0.00222811f, -0.03990151f, 
    0.00492065f, -0.05713300f, 0.04329887f, 0.05970866f, -0.07789791f, -0.04001715f, 0.05716953f, -0.03167816f, 
    -0.02530602f, 0.03813164f, -0.03225447f, 0.00678565f, -0.06572946f, -0.01574572f, -0.05287748f, -0.01437541f, 
    -0.02269332f, -0.07190768f, -0.05142758f, 0.01206470f, -0.03120716f, -0.04465944f, 0.05364758f, 0.00740860f, 
    0.04000735f, -0.03691165f, -0.04469182f, -0.00769071f, 0.02555406f, 0.04304264f, -0.07098897f, -0.00689908f, 
    -0.00606622f, -0.02307807f, 0.01125824f, -0.07097727f, -0.05850834f, -0.05354442f, 0.01575417f, 0.01539876f, 
    0.04466002f, -0.06167574f, 0.01039606f, 0.02586683f, -0.04340290f, -0.01656673f, 0.01068935f, -0.02121881f, 
    0.04397794f, -0.03779540f, -0.05281137f, -0.05910858f, 0.06580628f, 0.06072902f, -0.06143349f, 0.01697266f, 
    -0.04478526f, 0.06280962f, -0.05621326f, 0.03723848f, -0.04365733f, -0.03891959f, -0.06090030f, 0.04782713f, 
    -0.06289125f, -0.01459618f, 0.04369318f, -0.00923318f, 0.04705774f, -0.05837120f, 0.03468176f, -0.05932456f, 
    -0.00876503f, -0.03617262f, -0.02383379f, 0.02295917f, -0.01604171f, -0.02476677f, 0.02811705f, -0.04170607f, 
    -0.00122352f, -0.04941688f, 0.05459542f, 0.04677039f, 0.06038380f, -0.04975754f, -0.00775197f, -0.04982681f, 
    -0.05516420f, 0.05464454f, 0.02978573f, -0.01949400f, -0.01010491f, 0.00120307f, 0.04747276f, 0.02789100f, 
    -0.06363633f, 0.05195875f, 0.06812785f, -0.04388187f, -0.04235377f, -0.02467474f, -0.07397928f, 0.02862320f, 
    -0.07720531f, -0.05292432f, -0.02020195f, -0.01541754f, 0.00941848f, 0.02610802f, -0.07749350f, -0.03272339f, 
    0.04367641f, 0.01067350f, -0.06531681f, -0.06366877f, -0.05366043f, -0.01574555f, 0.04640456f, -0.05458588f, 
    0.05444838f, -0.04438619f, -0.02366585f, -0.06574441f, 0.03630941f, -0.01394293f, 0.00974246f, 0.02079915f, 
    -0.03517213f, 0.05393637f, 0.05094306f, -0.03683556f, 0.04786734f, -0.06591660f, -0.07033876f, 0.01970294f, 
    -0.03207154f, -0.00480380f, 0.01910793f, 0.03547845f, 0.05116555f, -0.00149234f, -0.05671361f, -0.04163767f, 
    0.01280485f, -0.05794513f, -0.06759921f, -0.03736454f, -0.06182441f, -0.03789837f, -0.01634009f, 0.04214332f, 
    0.00701217f, -0.06646398f, -0.00254012f, -0.04449980f, -0.04989729f, 0.04560236f, 0.02862277f, -0.03473799f, 
    -0.07352091f, 0.04253110f, -0.03440077f, 0.01579192f, -0.00876190f, -0.06486871f, 0.01679722f, -0.02669928f, 
    0.15625796f, 0.02253357f, 0.27482632f, 0.05724818f, 0.12216922f, 0.03046730f, -0.01329737f, -0.02002794f, 
    0.21422505f, -0.00070000f, -0.08401290f, -0.04127081f, -0.06914599f, 0.17968717f, 0.16631950f, 0.08260617f, 
    0.35533413f, 0.06648177f, -0.07655593f, -0.09321519f, -0.00853698f, -0.06797023f, 0.00530250f, 0.25309506f, 
    0.04621748f, 0.08932677f, 0.11069179f, -0.10155763f, -0.09881634f, 0.00341089f, 0.08217917f, 0.03837275f, 
    -0.00847809f, -0.04842942f, 0.20388255f, 0.12530644f, -0.13536932f, -0.05218369f, 0.17888254f, -0.16478287f, 
    -0.01227097f, 0.09362089f, -0.07815578f, 0.04004905f, -0.06490142f, -0.16606401f, 0.20379625f, -0.13228627f, 
    -0.15009159f, 0.03111588f, 0.08345003f, -0.09357366f, 0.04015881f, -0.03252668f, -0.10324204f, 0.02999975f, 
    0.03196945f, -0.01992352f, -0.07344177f, 0.16672075f, 0.33471584f, -0.13371593f, -0.18046126f, -0.15839937f, 
    0.09049005f, -0.01497340f, -0.05593755f, -0.09196042f, 0.12336947f, -0.08514415f, -0.07756568f, -0.08840743f, 
    0.29884225f, 0.02920709f, 0.33519804f, 0.07194497f, -0.02200985f, 0.05647067f, -0.19246192f, -0.11731979f, 
    -0.03006761f, -0.09178168f, 0.13027607f, -0.19357486f, 0.17772016f, 0.05915321f, 0.06442924f, 0.15807213f, 
    0.02236091f, 0.09528134f, 0.00796941f, -0.13395883f, -0.23107937f, -0.04254143f, 0.13461079f, -0.01862780f, 
    0.17230341f, -0.28621078f, -0.09037155f, -0.09889290f, 0.08750287f, -0.00884192f, 0.04423165f, 0.15661316f, 
    0.03834691f, 0.07063167f, -0.16581029f, -0.09317550f, 0.36859536f, 0.30315110f, 0.15894607f, -0.02937763f, 
    0.10737401f, -0.05178710f, -0.07519003f, 0.01634846f, 0.00497216f, -0.08700748f, 0.10493567f, 0.09682284f, 
    -0.15792853f, -0.36168382f, -0.12183799f, 0.19558375f, 0.05678136f, -0.02319681f, -0.19526704f, -0.07606189f, 
    0.00577790f, 0.01475606f, 0.15658638f, -0.03708036f, 0.06020744f, 0.13873757f, 0.01918528f, -0.07808460f, 
    0.11378368f, -0.01140401f, 0.08606917f, 0.04352244f, -0.05109746f, 0.20660232f, -0.02963812f, 0.13825394f, 
    0.18302396f, -0.02852020f, 0.09756581f, 0.04261405f, 0.24588548f, 0.08139170f, -0.08740827f, 0.05526589f, 
    0.04288037f, 0.01062124f, -0.24371353f, 0.19425833f, -0.29625827f, -0.06676985f, -0.00990177f, -0.28980190f, 
    -0.00455254f, 0.01401932f, -0.06622448f, 0.05080734f, 0.07549355f, 0.03377270f, 0.00323777f, -0.23243397f, 
    -0.09933773f, -0.03335445f, 0.14467549f, -0.09733322f, 0.04068861f, 0.27654725f, -0.13250881f, -0.05664332f, 
    -0.11588933f, 0.13847655f, 0.07477160f, 0.12387273f, -0.13273838f, -0.05618066f, -0.07816352f, -0.12964395f, 
    -0.02258063f, -0.01663873f, 0.04230604f, -0.00580005f, 0.00575416f, 0.02996656f, -0.02496788f, 0.00546303f, 
    -0.03235657f, -0.04738918f, 0.06111934f, -0.06718644f, 0.05729312f, -0.05785663f, 0.06212144f, 0.00859212f, 
    0.04057828f, -0.03565898f, -0.01037026f, 0.03770649f, 0.00754463f, 0.05158914f, -0.04638367f, 0.03665001f, 
    0.02962465f, -0.06262156f, -0.02410373f, -0.07566449f, -0.04001996f, 0.03752791f, -0.01960048f, 0.00925360f, 
    0.03596637f, -0.04457147f, 0.01781542f, 0.04975318f, -0.03801105f, -0.02628398f, -0.07310169f, -0.06101003f, 
    0.00788404f, -0.05854426f, -0.07304240f, 0.04961242f, -0.05987125f, 0.01948293f, 0.00473998f, 0.03296740f, 
    -0.01094421f, 0.00121233f, 0.01361149f, 0.03867511f, -0.03975996f, 0.06662663f, 0.00163861f, -0.01204104f, 
    -0.06306934f, -0.04581665f, 0.01128439f, 0.02370555f, -0.04967739f, 0.02808964f, -0.07204764f, 0.04506643f, 
    -0.03993379f, 0.03453843f, -0.06903404f, 0.05018751f, 0.03501027f, -0.02539578f, 0.00852144f, 0.04784779f, 
    -0.08222396f, 0.04078199f, -0.00147856f, -0.00707271f, -0.04808386f, 0.05083931f, -0.03253420f, -0.00931847f, 
    0.02144691f, -0.05631886f, 0.03921342f, 0.01242917f, -0.05950116f, 0.01953400f, -0.05191193f, 0.04319895f, 
    0.03956378f, -0.05640799f, -0.00338064f, -0.05549695f, -0.03605136f, -0.02477966f, 0.04957773f, -0.06317768f, 
    -0.00720794f, -0.01664486f, 0.06134150f, -0.05023348f, -0.02123004f, 0.01037221f, 0.02655252f, 0.02171067f, 
    -0.01961556f, -0.06116943f, -0.00432130f, -0.03284773f, 0.04953619f, -0.05197271f, -0.02194849f, 0.07111663f, 
    0.05512640f, -0.02174406f, 0.01255753f, -0.04944445f, 0.04405287f, 0.04969089f, -0.04444165f, -0.06203152f, 
    -0.03869545f, -0.04373455f, 0.03410427f, -0.02865511f, 0.01844957f, 0.04241406f, 0.05498085f, -0.07054120f, 
    -0.01994069f, 0.03124347f, 0.03790995f, -0.01511952f, 0.06136825f, -0.00532915f, -0.01572364f, 0.02602291f, 
    -0.00444972f, -0.07626151f, 0.02033958f, 0.04475448f, 0.04073864f, -0.03845243f, -0.07450491f, -0.00379204f, 
    -0.03328053f, -0.07005301f, -0.06178657f, -0.08125401f, 0.02726185f, -0.06492218f, -0.05576273f, -0.04784231f, 
    -0.03923100f, -0.00852970f, 0.05375219f, -0.04774132f, 0.02509903f, -0.08234221f, -0.03213828f, -0.04406465f, 
    -0.06845137f, 0.00169422f, -0.07493931f, -0.01568733f, 0.00891290f, 0.00344739f, -0.05774912f, -0.04733365f, 
    -0.04882535f, -0.00029144f, 0.01914817f, -0.01618811f, 0.00637429f, -0.04444024f, -0.02562326f, -0.04166213f, 
    0.03098568f, 0.03145535f, -0.05063735f, -0.02284973f, -0.06730913f, -0.03484265f, -0.05431814f, 0.02969139f, 
    0.02115995f, -0.04683878f, -0.07280888f, -0.04228405f, 0.00517470f, 0.01011605f, -0.04197425f, 0.05734913f, 
    0.05231040f, 0.00265872f, 0.06262784f, 0.02871110f, 0.01759311f, -0.03998153f, -0.07249871f, 0.05483936f, 
    -0.02625199f, -0.03852097f, 0.04756555f, 0.01060706f, -0.04296133f, -0.07554241f, -0.06242869f, -0.01851568f, 
    -0.03075627f, 0.04348629f, 0.01406683f, -0.01351762f, 0.02790484f, 0.01484377f, -0.05966772f, -0.00333725f, 
    -0.05841456f, -0.03030749f, 0.05627153f, -0.00906434f, -0.03121287f, 0.02423025f, -0.07037704f, 0.03376538f, 
    -0.04490370f, -0.00581152f, -0.00786968f, 0.02692002f, -0.07349418f, -0.01864156f, 0.04112701f, 0.04474689f, 
    -0.06210672f, 0.01037793f, 0.00320979f, -0.03258189f, -0.06300063f, 0.03379267f, -0.00512268f, 0.05492185f, 
    -0.01086310f, 0.04784764f, 0.03462014f, 0.05930420f, -0.01526131f, 0.07013650f, 0.06408837f, -0.02914385f, 
    -0.06556261f, -0.02442899f, -0.00229569f, 0.01089703f, 0.02250582f, 0.01528865f, -0.02163767f, 0.04116273f, 
    -0.03552685f, 0.00754413f, -0.02204983f, 0.05151280f, -0.00874058f, -0.06338137f, 0.03474393f, -0.02432482f, 
    -0.02938412f, -0.03074552f, -0.05397625f, 0.05392083f, -0.00512118f, -0.04504200f, -0.05862631f, -0.01270734f, 
    0.00926097f, 0.02646128f, -0.00180160f, -0.06777695f, -0.05415261f, -0.06144705f, 0.03056915f, 0.00377801f, 
    -0.06955280f, -0.00539452f, -0.05438246f, -0.01440728f, 0.00694863f, -0.06259102f, -0.03258835f, 0.00285383f, 
    -0.02915466f, 0.02921415f, 0.05080887f, -0.04281923f, 0.03919189f, 0.05545710f, -0.02727569f, 0.00305718f, 
    -0.07610855f, 0.01467670f, 0.01186092f, 0.06695449f, 0.05547549f, -0.03059143f, 0.03779016f, -0.00952078f, 
    -0.06165897f, -0.03358185f, -0.03599774f, 0.06680784f, -0.07652272f, 0.04534691f, -0.07181388f, -0.06690855f, 
    -0.03022688f, -0.07124464f, -0.04445608f, -0.00286837f, -0.05856761f, -0.02469149f, -0.06565724f, 0.01162646f, 
    -0.06627256f, 0.06693458f, -0.05969971f, -0.05894109f, -0.06313015f, 0.02138417f, -0.01912380f, 0.03585309f, 
    -0.01198103f, -0.06152508f, -0.06897455f, -0.02740358f, -0.07368897f, 0.00754761f, -0.01445895f, -0.01761521f, 
    -0.07462425f, -0.05891641f, -0.03585954f, -0.03056149f, 0.01683618f, -0.05059620f, 0.02315145f, 0.06114277f, 
    0.05663058f, -0.03541373f, 0.06329649f, 0.04966700f, 0.03080942f, -0.02429653f, -0.04075623f, 0.00015927f, 
    -0.05559748f, -0.00771075f, -0.06704610f, -0.00523433f, -0.06940071f, -0.01252204f, -0.04417396f, 0.01633994f, 
    -0.02785987f, -0.06739796f, 0.03382056f, -0.04730764f, 0.02725951f, 0.03824794f, 0.04208216f, 0.05022660f, 
    -0.02250586f, 0.05621506f, -0.06044179f, 0.04283291f, 0.00998267f, -0.03085388f, -0.04370024f, 0.02422298f, 
    -0.07664245f, -0.07801554f, -0.03005322f, 0.02182875f, 0.03566753f, -0.05424334f, 0.02790924f, -0.05691990f, 
    0.01449706f, 0.04626325f, -0.04947986f, 0.02661557f, 0.02275389f, 0.01738930f, 0.00334457f, 0.05480325f, 
    0.18461229f, 0.06258926f, 0.05447223f, -0.07605451f, 0.08293771f, 0.00899001f, -0.09406867f, -0.11295636f, 
    0.13434343f, -0.07197324f, -0.14001165f, 0.06888298f, 0.04795098f, -0.10423281f, 0.18622182f, 0.11772643f, 
    0.10768677f, 0.09440084f, 0.06060591f, 0.00230664f, -0.01013106f, -0.10473682f, -0.00210135f, 0.34165365f, 
    -0.08073227f, 0.09997648f, 0.20188190f, -0.01969070f, 0.06873231f, -0.09133593f, -0.08956451f, 0.02416961f, 
    -0.05505975f, -0.01417874f, 0.12648563f, 0.19052818f, -0.13451554f, -0.02298357f, 0.06782985f, -0.10380678f, 
    -0.02438754f, -0.08082274f, -0.07028173f, -0.01287711f, -0.04652782f, -0.15219800f, 0.27411523f, -0.09448627f, 
    0.09642110f, -0.02337352f, 0.06360985f, 0.00128952f, -0.04197022f, -0.01862419f, -0.09456202f, 0.06126124f, 
    -0.01728790f, 0.11239116f, 0.04235258f, 0.10675687f, -0.06015883f, -0.00167018f, -0.18886635f, -0.16337247f, 
    0.03951273f, -0.02870890f, -0.01408953f, -0.06666767f, 0.18201786f, -0.04791685f, -0.10896170f, -0.12138209f, 
    0.16973908f, -0.07478894f, 0.03889315f, 0.08875986f, 0.00186069f, 0.00009224f, -0.11331386f, -0.07865594f, 
    -0.07338433f, -0.14589611f, 0.13659553f, -0.10264549f, 0.15410823f, 0.17211136f, 0.00377663f, 0.10357843f, 
    0.01230275f, 0.05196416f, 0.01950167f, -0.14210349f, -0.13632222f, -0.12278087f, 0.21264642f, -0.04223573f, 
    0.22461699f, -0.13484074f, 0.04419106f, -0.05770396f, 0.04498050f, -0.03553427f, 0.00873225f, 0.28587466f, 
    0.11591721f, 0.01640696f, -0.20612793f, -0.00921874f, 0.34727642f, -0.07298516f, 0.06287710f, -0.17538066f, 
    -0.04333780f, -0.06212394f, -0.09876496f, 0.05326468f, 0.08516212f, 0.04224192f, -0.01781039f, 0.10607297f, 
    -0.63956499f, 0.00215117f, 0.03447492f, -0.09351449f, 0.08182663f, 0.06477911f, -0.10565154f, -0.04560186f, 
    0.09366430f, 0.00194881f, 0.11698771f, 0.11840064f, -0.24895529f, -0.20439447f, 0.12613760f, 0.22625801f, 
    0.18390544f, 0.04026348f, 0.15310150f, -0.02929072f, 0.04180599f, 0.08367345f, 0.05486987f, 0.07340149f, 
    0.02710818f, 0.06966560f, 0.04667229f, 0.20882989f, 0.13946114f, -0.09826582f, -0.01434369f, 0.05434585f, 
    0.10545763f, 0.02399446f, -0.29184097f, 0.05638679f, 0.03292770f, 0.10271102f, -0.00749821f, -0.16487826f, 
    -0.08639095f, -0.02910968f, 0.02811172f, 0.08926783f, 0.12153737f, -0.04395521f, -0.02903383f, -0.17366746f, 
    -0.01890000f, 0.01078791f, 0.14721392f, -0.03480692f, -0.03222484f, 0.25214842f, -0.00826430f, 0.04557427f, 
    0.12936947f, 0.13426037f, 0.08947540f, 0.01921514f, -0.22452429f, 0.12275552f, -0.11890618f, -0.16418001f, 
    0.08881395f, 0.04428353f, -0.05149353f, 0.05025591f, 0.05977337f, -0.00455521f, -0.03968012f, 0.07501553f, 
    -0.05635943f, -0.04007250f, 0.04609243f, 0.04806342f, -0.05988418f, 0.04575542f, 0.05124844f, 0.03905815f, 
    -0.05428379f, 0.01985369f, -0.04556827f, 0.01002932f, 0.05051645f, 0.00818985f, -0.04049021f, -0.03319412f, 
    -0.08892434f, -0.07218303f, 0.00416325f, -0.00766353f, -0.01485563f, 0.00483598f, -0.02911970f, -0.01360919f, 
    -0.07639989f, -0.02161684f, -0.06355027f, -0.06201795f, -0.06623953f, 0.00253930f, -0.03859151f, 0.03161927f, 
    -0.07578020f, -0.05096207f, -0.05029801f, 0.02188140f, 0.03210029f, -0.05134282f, -0.07799699f, -0.06483133f, 
    0.03273926f, -0.01541581f, -0.06514433f, -0.03317706f, -0.00128184f, 0.04500229f, -0.01640993f, -0.08794424f, 
    -0.00606928f, -0.02932784f, 0.00769552f, -0.04666002f, -0.03245036f, -0.05815079f, -0.07746487f, 0.02656071f, 
    0.00480158f, 0.02642123f, 0.04313817f, -0.00406953f, -0.07669920f, 0.01068947f, 0.00183417f, -0.03614434f, 
    -0.05516832f, -0.02000621f, 0.04860733f, -0.06770784f, 0.02604136f, 0.00534703f, 0.02542313f, -0.07705124f, 
    0.04321869f, -0.09141956f, 0.03099175f, -0.06927711f, -0.05395099f, -0.02393127f, -0.05504629f, 0.00177134f, 
    0.03306072f, 0.03651100f, -0.03755916f, -0.06798669f, 0.02803373f, -0.04856025f, -0.00945566f, 0.04375398f, 
    0.02889919f, 0.00032864f, -0.00537668f, 0.02426145f, -0.00339301f, -0.04239193f, 0.00305441f, -0.06328725f, 
    0.02389790f, -0.06099268f, 0.06349086f, -0.04748771f, 0.04871557f, -0.05244125f, 0.06239663f, -0.01546547f, 
    -0.06898786f, 0.02365622f, -0.05925852f, -0.04657194f, 0.06295553f, -0.05429455f, 0.00618171f, -0.08533458f, 
    -0.06179177f, -0.05691568f, 0.02333483f, -0.02391428f, -0.00699867f, -0.01484477f, 0.03402720f, 0.04512080f, 
    0.00435962f, -0.05640639f, -0.00497524f, -0.00001879f, -0.07623798f, -0.08652265f, -0.07198149f, 0.02337713f, 
    -0.04022519f, -0.03711714f, -0.06374042f, -0.00132979f, -0.02796315f, -0.07895494f, -0.08566306f, -0.02133228f, 
    -0.00271982f, -0.08538249f, -0.07061366f, 0.04587156f, 0.03837594f, -0.04150160f, -0.01546618f, 0.06179859f, 
    0.01727819f, -0.06636186f, 0.01813820f, -0.03237922f, -0.00096684f, -0.03458286f, -0.00958261f, 0.03280768f, 
    -0.02956569f, -0.04535077f, -0.07348258f, 0.05092435f, 0.00914347f, -0.01819295f, -0.07532451f, 0.02356299f, 
    -0.04253734f, -0.05909017f, 0.02432395f, 0.04363019f, 0.06705073f, -0.03354749f, 0.01801681f, -0.07617510f, 
    0.03097811f, -0.06309373f, -0.00855168f, 0.02770912f, -0.03516745f, -0.01760450f, -0.00424198f, 0.05296152f, 
    -0.04457645f, -0.05674992f, 0.03501254f, 0.05070876f, 0.04811420f, 0.00874002f, -0.06077634f, -0.04044435f, 
    0.04718793f, -0.06041009f, -0.03490557f, -0.06658539f, -0.04383457f, -0.03117784f, 0.01869526f, 0.01448184f, 
    0.03761374f, 0.13643129f, -0.09472769f, 0.07302563f, 0.04560341f, -0.11148679f, -0.00413162f, 0.09434657f, 
    -0.04495975f, 0.05093966f, 0.11663271f, 0.07394902f, 0.30300486f, -0.07866259f, 0.28500801f, 0.06568452f, 
    -0.22370535f, -0.06524726f, 0.04751920f, 0.05130615f, -0.04414657f, -0.07607615f, -0.02790373f, -0.09853207f, 
    0.17110933f, -0.13855717f, -0.13568924f, 0.18683542f, 0.03614808f, 0.01252617f, -0.08730148f, -0.00212395f, 
    0.07617753f, 0.00795626f, 0.00251440f, 0.01613784f, -0.14738375f, -0.17466038f, 0.10529886f, -0.13895881f, 
    -0.06832350f, 0.01428270f, 0.04939076f, 0.23949140f, -0.02281214f, 0.01954166f, 0.06770400f, 0.10999378f, 
    0.16133898f, 0.03536911f, 0.18606399f, 0.07310270f, -0.13388488f, -0.00659110f, 0.08271435f, -0.03612055f, 
    0.10756484f, -0.07114988f, -0.03626989f, 0.08683893f, 0.04547009f, -0.23326874f, -0.23059414f, -0.07291856f, 
    0.02013024f, -0.03169851f, -0.03507264f, 0.04493845f, 0.11333510f, -0.06778713f, 0.18533215f, 0.24834086f, 
    0.12435386f, 0.02292277f, -0.11573655f, 0.07594627f, -0.05447308f, -0.08228952f, 0.11241980f, 0.18290560f, 
    0.09807196f, -0.04809326f, 0.02038483f, 0.11262800f, 0.10019147f, 0.14575315f, -0.31311512f, 0.26192105f, 
    0.07055336f, -0.00097008f, 0.01215857f, 0.00692501f, 0.07863618f, 0.10001357f, -0.01056475f, 0.11984899f, 
    0.14312775f, 0.00090388f, -0.08608243f, 0.15688081f, 0.02297721f, 0.03209375f, 0.00042917f, 0.08270824f, 
    0.01604277f, 0.20210339f, -0.01193132f, 0.09565775f, 0.08431651f, -0.18700728f, 0.13881707f, -0.29141134f, 
    -0.14959590f, -0.05613452f, 0.22825119f, 0.11839585f, -0.04652151f, 0.08005153f, 0.02172694f, 0.11571269f, 
    0.25417218f, 0.01841094f, 0.07496098f, -0.09699976f, -0.04828837f, 0.06687852f, 0.15873675f, -0.01629954f, 
    -0.09794704f, -0.04479947f, 0.09010515f, 0.12992193f, -0.11657183f, 0.04140814f, 0.15849172f, 0.09418935f, 
    0.00257900f, 0.11446042f, 0.07790789f, 0.05400153f, -0.12560970f, -0.07379601f, -0.03231673f, -0.02925601f, 
    -0.09277444f, 0.27277479f, 0.11948539f, 0.26166275f, -0.10995321f, -0.06991256f, 0.13195263f, -0.12726992f, 
    0.03692650f, 0.03359130f, 0.04322398f, -0.09969514f, 0.24528445f, 0.02309111f, 0.09776419f, -0.23621944f, 
    -0.11894951f, 0.09333272f, 0.20684899f, -0.01130682f, -0.01199837f, 0.04139717f, -0.06989175f, 0.17108014f, 
    -0.10992849f, -0.15844138f, -0.06113709f, -0.11503680f, -0.04174933f, 0.00952571f, 0.09254352f, 0.21547760f, 
    0.06327417f, 0.08770961f, -0.09610508f, 0.13275698f, -0.14634034f, -0.03969260f, 0.13521306f, -0.33454534f, 
    0.10406084f, -0.03543165f, 0.09178170f, -0.02358352f, -0.01205559f, -0.11189345f, -0.04783569f, 0.09559304f, 
    -0.01795887f, -0.01000521f, -0.16120566f, -0.04469715f, 0.12085865f, -0.03870318f, 0.02741261f, -0.00787621f, 
    -0.10566247f, -0.01873396f, 0.16375914f, 0.08954416f, 0.16233547f, 0.00972075f, 0.00722405f, 0.00386995f, 
    -0.16847275f, 0.00362895f, 0.10840947f, 0.08177970f, 0.13338068f, -0.11901356f, 0.00480945f, 0.03307135f, 
    -0.38952565f, 0.14393264f, -0.17392814f, 0.37589717f, 0.05195144f, -0.00894466f, -0.19656867f, 0.06596079f, 
    -0.10634485f, -0.07982863f, -0.00058980f, -0.13872238f, 0.44661853f, -0.17234197f, -0.24093038f, 0.15163808f, 
    0.23937768f, 0.05943191f, 0.02450820f, 0.07535201f, 0.09713770f, -0.05891335f, -0.06727477f, -0.00088691f, 
    0.28466001f, 0.03920362f, -0.05025920f, -0.05639909f, 0.07246511f, -0.12123618f, 0.13768524f, -0.03619917f, 
    -0.01551560f, 0.09899271f, 0.00364415f, 0.01551606f, -0.30113459f, 0.24464753f, -0.05293639f, 0.30280745f, 
    0.05567848f, 0.06807448f, 0.15450528f, 0.02646427f, -0.14599597f, -0.01496621f, 0.03155917f, -0.07676322f, 
    -0.00262050f, -0.21315813f, -0.10498387f, -0.10164175f, 0.11458437f, 0.07608341f, 0.06673305f, 0.02625608f, 
    0.03847167f, -0.05943868f, -0.10928614f, 0.23617302f, -0.36398211f, 0.37228572f, -0.13761629f, -0.04955113f, 
    0.22982486f, 0.00012263f, -0.04009257f, -0.03397796f, 0.08610988f, -0.01069967f, -0.02428588f, 0.00409303f, 
    -0.24140598f, 0.10563558f, 0.02793669f, -0.02377870f, 0.13407582f, 0.21794723f, 0.06446208f, 0.05000208f, 
    0.03570293f, 0.21134281f, 0.09739222f, 0.02761988f, -0.13924411f, -0.14352538f, 0.17892256f, -0.16841738f, 
    -0.09076924f, 0.01875631f, 0.11429194f, -0.16407423f, 0.00716612f, 0.04172528f, -0.04463694f, -0.16162035f, 
    -0.06071096f, 0.02734781f, 0.07222133f, -0.09912913f, -0.17774607f, 0.06420612f, 0.10350605f, 0.13115588f, 
    -0.12790561f, 0.09714264f, 0.02336679f, 0.07158315f, 0.47397017f, 0.07661057f, 0.10142554f, 0.05477814f, 
    -0.05236463f, -0.04686832f, -0.09125873f, 0.02753335f, -0.00810781f, -0.13937044f, 0.10270768f, -0.02855531f, 
    -0.11600397f, 0.08082136f, -0.10016190f, -0.10670827f, -0.13959940f, 0.07675188f, 0.08760989f, 0.21367243f, 
    0.03527924f, 0.06299472f, 0.05260560f, 0.01694397f, -0.11739282f, -0.21265174f, 0.27939582f, 0.35102582f, 
    -0.03945158f, 0.02813077f, 0.27055803f, -0.06083600f, -0.20853595f, 0.09755075f, 0.06141083f, 0.08342353f, 
    0.18770820f, -0.00652089f, -0.08679748f, 0.15547179f, 0.17297044f, 0.02532040f, 0.04793540f, 0.10926670f, 
    0.09141984f, -0.03153680f, -0.17004067f, 0.08894704f, 0.00305500f, -0.29526916f, 0.17993133f, -0.03024026f, 
    0.06166279f, -0.00887939f, -0.13456741f, -0.00795179f, 0.10465998f, 0.02715743f, 0.04973166f, -0.00921280f, 
    -0.05207894f, 0.05030608f, -0.04202354f, 0.04682183f, -0.00306072f, -0.04125509f, -0.00264970f, 0.04075228f, 
    -0.04065932f, 0.03168234f, 0.03666047f, -0.00858552f, -0.01193799f, -0.02852782f, 0.02351099f, -0.01006239f, 
    0.03468055f, 0.02515880f, -0.07502227f, 0.00712335f, -0.02661957f, -0.00224301f, 0.00451349f, -0.05638963f, 
    -0.02140725f, -0.02322409f, 0.06348968f, -0.07792371f, 0.04894688f, -0.04750490f, 0.02714338f, 0.03585679f, 
    -0.07607318f, 0.04421473f, -0.04560860f, -0.03280870f, -0.00702724f, 0.02116841f, -0.04676049f, -0.07186339f, 
    -0.02196548f, -0.03158369f, -0.02784414f, -0.00588434f, -0.04316552f, 0.02267308f, -0.05286631f, 0.04102988f, 
    0.03205904f, 0.06206948f, 0.05435716f, -0.04356952f, -0.02039330f, 0.02304127f, -0.03178556f, -0.02806751f, 
    0.04480834f, -0.02907686f, -0.02593101f, 0.06316435f, -0.06050998f, 0.00602159f, -0.02398412f, 0.06031477f, 
    -0.07117980f, 0.01111986f, 0.03272341f, 0.05275070f, -0.02115357f, 0.03721900f, -0.03413016f, 0.03290465f, 
    0.02526585f, 0.05940145f, 0.03119624f, -0.00863152f, -0.01402514f, -0.04782490f, 0.00340368f, -0.05756442f, 
    -0.02614032f, 0.00827044f, 0.04797521f, -0.02970680f, 0.02331642f, -0.05503559f, -0.00103516f, -0.05233343f, 
    0.03534861f, -0.02925098f, -0.07331099f, -0.07951073f, 0.01497612f, -0.07889307f, 0.02030317f, 0.03111737f, 
    -0.02683400f, -0.07384778f, -0.06368215f, 0.00663187f, 0.06301066f, 0.03544398f, -0.03871118f, 0.01578155f, 
    0.03203553f, -0.00759451f, -0.00262310f, -0.04707565f, -0.02244897f, -0.06447296f, -0.04742787f, -0.02661348f, 
    -0.03981137f, -0.05781416f, -0.07700069f, -0.06099393f, -0.05880737f, -0.02429145f, -0.03647815f, 0.01637359f, 
    -0.02797950f, 0.02073066f, 0.05552790f, 0.05323779f, -0.06678810f, -0.06628536f, -0.05949456f, -0.01548729f, 
    0.02407923f, 0.01600434f, 0.03372150f, -0.00857870f, -0.04235410f, 0.02964091f, -0.06272630f, -0.07142482f, 
    -0.07401593f, -0.02059485f, -0.07120018f, -0.07094796f, -0.07596359f, 0.02260650f, 0.04861054f, 0.00477938f, 
    0.00511605f, 0.00980253f, -0.01028401f, -0.06956080f, -0.07423968f, -0.06337691f, -0.02146112f, -0.06975070f, 
    -0.07597595f, 0.02315478f, 0.02109703f, -0.06180904f, -0.01073147f, -0.05338156f, -0.04666355f, 0.05628781f, 
    -0.07124535f, 0.03397388f, 0.04649818f, -0.00544403f, 0.06176129f, 0.05192877f, 0.04012627f, 0.01851683f, 
    0.01871450f, 0.03312708f, -0.04306909f, -0.03694297f, -0.02061955f, -0.02577445f, -0.03382660f, 0.06344543f, 
    -0.05270159f, -0.04682019f, -0.00901073f, -0.05682924f, 0.03500472f, 0.05187516f, -0.04460644f, -0.05917444f, 
    -0.04222435f, -0.07599965f, 0.00739274f, 0.04153979f, -0.06764644f, 0.00888349f, 0.05915394f, -0.02328344f, 
    -0.41025865f, 0.09084271f, 0.10986005f, -0.14778927f, 0.09658469f, -0.04522408f, 0.13197134f, 0.24859263f, 
    0.01983992f, 0.07147770f, 0.13519482f, 0.13306548f, -0.06693712f, 0.35355923f, 0.06186787f, -0.08489071f, 
    -0.02991373f, 0.07738449f, 0.04582682f, 0.00332411f, 0.01450478f, 0.09251848f, 0.09284476f, -0.20291321f, 
    0.54272527f, 0.09531918f, -0.10630525f, -0.17920756f, -0.04739990f, 0.17966077f, 0.18107560f, -0.03164137f, 
    0.11479267f, 0.09144390f, 0.01815621f, -0.23200303f, -0.03203791f, 0.05875487f, -0.16042963f, -0.07215718f, 
    -0.08439572f, 0.04163911f, 0.01999910f, 0.01557257f, -0.02406145f, 0.13221203f, -0.14343303f, 0.19295563f, 
    -0.41896263f, 0.09115724f, 0.08869031f, -0.27797449f, 0.23181202f, -0.01460789f, 0.07050717f, 0.05039074f, 
    -0.06314371f, 0.00273269f, -0.01984157f, 0.08719510f, 0.23438153f, -0.13868707f, 0.03546708f, 0.00464523f, 
    -0.07841033f, -0.00531068f, 0.03069710f, 0.14701168f, -0.07992002f, 0.08766391f, 0.22466153f, 0.16182019f, 
    -0.44132534f, 0.09124371f, -0.06417879f, -0.10071964f, -0.01366493f, 0.08994132f, 0.21249510f, 0.12872106f, 
    0.23172539f, 0.19556725f, -0.06764319f, 0.07606658f, 0.26652607f, -0.10598538f, -0.05445351f, 0.06214476f, 
    0.20083220f, 0.01233810f, -0.03382997f, 0.10349437f, 0.16086900f, 0.13078849f, -0.09816363f, 0.08519927f, 
    0.19176544f, 0.14788632f, -0.02233618f, 0.20260006f, -0.12017490f, 0.03096950f, 0.06967440f, -0.14208522f, 
    0.07448179f, 0.09524143f, 0.30876932f, 0.11048198f, -0.33409932f, -0.12967667f, 0.15063860f, 0.39523596f, 
    -0.00257465f, 0.09944506f, 0.18438502f, 0.02086853f, 0.03003588f, -0.06956279f, 0.02922128f, -0.03306586f, 
    0.52827948f, -0.27163899f, -0.16971375f, 0.00346824f, 0.11171830f, 0.00912182f, 0.01127767f, 0.21041757f, 
    -0.14824344f, 0.10593786f, 0.07548396f, -0.03812390f, 0.03721515f, 0.23131920f, -0.04223782f, -0.32533222f, 
    0.04785101f, 0.12311360f, -0.02421011f, -0.06840266f, -0.03863209f, -0.06585881f, 0.12309809f, -0.14384188f, 
    -0.06802542f, 0.01651705f, 0.00395789f, -0.27240956f, -0.02183685f, 0.04392913f, -0.10714605f, -0.13938384f, 
    -0.13867764f, 0.10807303f, 0.27091268f, 0.14145982f, 0.08822954f, -0.04288217f, 0.11134529f, 0.15123048f, 
    0.06622270f, 0.13983563f, 0.07762097f, -0.00480048f, -0.11783053f, 0.12138179f, -0.04795349f, 0.28605059f, 
    -0.03266223f, -0.07286789f, -0.08812205f, 0.15204702f, 0.13293113f, -0.23967123f, -0.02130064f, 0.02450516f, 
    -0.20922633f, -0.04845959f, -0.20772921f, 0.07593820f, 0.16178679f, -0.01976497f, 0.18368195f, 0.26559964f, 
    0.08915867f, -0.04266527f, 0.13911027f, -0.02617698f, -0.00607965f, -0.00136773f, 0.09070244f, -0.20999119f, 
    -0.04812248f, 0.04875743f, 0.02150653f, -0.04332144f, 0.05211588f, -0.05179520f, -0.00956744f, 0.05735708f, 
    0.02259177f, -0.07907388f, 0.00109176f, -0.00725635f, 0.02339033f, -0.03795540f, -0.07225444f, -0.03931020f, 
    -0.07533502f, -0.06355296f, 0.01026728f, 0.01518665f, -0.05301763f, -0.07316383f, -0.06331767f, 0.01739678f, 
    0.00849762f, -0.06760194f, -0.07509179f, 0.03229883f, -0.03235582f, -0.06746418f, 0.06571787f, -0.06283033f, 
    -0.00262710f, -0.07161259f, 0.01066943f, -0.03801249f, -0.01299383f, -0.03290106f, -0.06011474f, -0.02256837f, 
    0.04564749f, -0.00677169f, -0.03845438f, -0.05023903f, -0.07058229f, -0.03117231f, -0.03656757f, -0.02703376f, 
    -0.04526017f, -0.05811220f, 0.04570398f, 0.01062988f, -0.03624998f, 0.00520785f, 0.01648106f, -0.06399219f, 
    -0.01295153f, -0.06449671f, -0.02115031f, 0.06227106f, -0.00630017f, 0.02071085f, 0.01761091f, -0.07087866f, 
    -0.04871636f, 0.01573135f, 0.04388705f, 0.03561152f, -0.04648530f, 0.04391465f, -0.01324324f, -0.04099324f, 
    0.05631573f, 0.05629439f, 0.02294010f, 0.06261679f, -0.00155268f, 0.03904810f, 0.05939803f, -0.01779577f, 
    0.04565797f, -0.07718084f, 0.00735874f, -0.01694928f, 0.05101851f, -0.00156126f, 0.05253239f, 0.01568174f, 
    -0.07369763f, -0.05899556f, -0.05974833f, -0.00398432f, -0.01577804f, -0.05884700f, 0.01676716f, -0.02473978f, 
    -0.05322364f, -0.02534323f, -0.02774641f, -0.00856443f, 0.01083771f, 0.04378385f, 0.03243042f, -0.05997096f, 
    0.00119999f, -0.07471056f, -0.03874014f, 0.00947945f, -0.06903744f, -0.00267769f, -0.01891402f, -0.04092178f, 
    -0.02344221f, 0.02487230f, -0.03616219f, 0.04795993f, -0.01691801f, -0.00702405f, 0.00844320f, 0.06147889f, 
    -0.05617355f, 0.00961184f, 0.05271954f, 0.04612423f, 0.05330446f, -0.04701208f, 0.01952430f, 0.01557249f, 
    0.02131366f, -0.01361177f, -0.02199737f, 0.03277918f, 0.04353853f, 0.05899323f, 0.05248520f, 0.01563528f, 
    0.01997424f, -0.05101762f, 0.06113921f, -0.05903476f, -0.07754852f, 0.02925548f, -0.02544728f, 0.03428391f, 
    -0.07806934f, 0.04038294f, -0.04254090f, -0.00554869f, -0.00576678f, -0.01270694f, -0.06302578f, 0.05232887f, 
    0.01323707f, -0.01053906f, -0.07842395f, 0.03637470f, 0.04031032f, 0.01314356f, -0.01267427f, -0.04928694f, 
    -0.00376940f, 0.02137401f, 0.02062654f, 0.05764631f, 0.05686537f, -0.06885540f, 0.04287028f, -0.03698992f, 
    0.04442310f, -0.04274567f, 0.02412057f, 0.04447500f, -0.02726809f, 0.05906933f, 0.00359531f, 0.05220266f, 
    -0.03541236f, 0.02875801f, -0.05407536f, -0.00369191f, 0.00890265f, -0.07722755f, 0.00272602f, -0.04400595f, 
    -0.02729730f, 0.05868664f, 0.02384545f, 0.01578429f, 0.04265283f, -0.02808807f, -0.05106477f, -0.02293546f, 
    -0.08032650f, 0.06155895f, -0.02419965f, 0.01791408f, 0.04328709f, 0.04460574f, -0.04706665f, -0.01344568f, 
    -0.00245252f, -0.02170036f, 0.03856960f, -0.03744169f, -0.02338383f, -0.03661191f, 0.02791557f, 0.04900394f, 
    -0.03798500f, -0.00464180f, -0.05143911f, -0.01146109f, -0.04075452f, 0.00702616f, 0.02695979f, 0.00596305f, 
    0.00726468f, 0.04856484f, 0.03258401f, -0.04131696f, 0.03959162f, -0.06242741f, 0.01900420f, 0.00673979f, 
    0.04195407f, -0.03704496f, -0.04301541f, -0.06116547f, -0.04111598f, -0.06449930f, -0.07843269f, -0.02843981f, 
    -0.07603659f, 0.03030392f, -0.06101776f, 0.03628494f, 0.04820582f, -0.08158533f, 0.02793719f, 0.00137828f, 
    0.00173187f, 0.02876172f, -0.04062610f, 0.00373468f, -0.03780602f, -0.00692921f, 0.01772022f, 0.05302260f, 
    -0.01754785f, 0.03554789f, 0.00400124f, -0.00267541f, 0.05098680f, 0.04655974f, -0.01349234f, 0.00273032f, 
    0.01829650f, 0.00044179f, -0.00545353f, 0.00575059f, -0.01970649f, -0.02208930f, -0.03820559f, 0.03717720f, 
    -0.00138412f, -0.03689720f, 0.06274529f, 0.01235937f, -0.07892683f, 0.02060084f, -0.02750191f, 0.01410009f, 
    0.02800349f, -0.07166174f, -0.05772067f, -0.00802352f, 0.00735754f, 0.02823286f, -0.00968061f, 0.03152226f, 
    -0.03948306f, 0.05412077f, -0.02882748f, 0.03681111f, 0.01156706f, 0.05464318f, -0.01247092f, -0.05121756f, 
    -0.03860250f, -0.06262232f, 0.01266846f, -0.05475163f, -0.04950411f, -0.04517569f, 0.02371859f, 0.05602835f, 
    -0.00317046f, 0.04815346f, 0.02333621f, 0.04235084f, 0.05255266f, 0.05269843f, -0.07767806f, -0.01209129f, 
    0.05507390f, -0.07875712f, 0.02307848f, 0.04239138f, -0.07582377f, 0.02976732f, -0.03433853f, 0.03649640f, 
    -0.00137503f, -0.01091103f, -0.04433302f, -0.04395749f, -0.06766053f, -0.00196124f, -0.06534615f, -0.03975726f, 
    -0.07801314f, 0.00420719f, -0.02868978f, -0.04181390f, 0.02345048f, 0.01269636f, -0.01211419f, -0.04763542f, 
    -0.02986196f, 0.01205709f, -0.06692187f, -0.03025542f, -0.07489068f, -0.05291783f, -0.01922497f, -0.04346472f, 
    0.03658701f, 0.05938980f, -0.07857909f, -0.04867779f, 0.06002421f, -0.00238738f, 0.05814501f, 0.01889411f, 
    -0.03201140f, -0.08013272f, -0.05298215f, 0.03870443f, -0.04779302f, 0.05882185f, -0.07451218f, -0.03477754f, 
    -0.00210569f, 0.02151759f, -0.07927322f, 0.05419489f, -0.05428091f, 0.01705459f, 0.01187742f, 0.01319716f, 
    -0.03548405f, -0.06839313f, -0.07333965f, -0.06024427f, -0.06221898f, 0.03890673f, -0.04744008f, -0.03578028f, 
    0.00515513f, -0.06218501f, -0.07922079f, -0.03451950f, -0.00121681f, 0.02978665f, 0.05460517f, -0.07349255f, 
    0.02087231f, -0.02718554f, -0.06959857f, 0.00681728f, -0.07358368f, -0.01049694f, 0.02467485f, -0.03760103f, 
    -0.16565438f, -0.14897400f, 0.10355467f, -0.27637583f, -0.17678063f, 0.07168793f, 0.00406151f, -0.03360157f, 
    -0.03909968f, -0.04974175f, -0.06002899f, -0.08741587f, -0.05631363f, 0.21963735f, -0.15413417f, 0.07496183f, 
    0.05242275f, 0.12241706f, 0.03514281f, -0.09319445f, 0.04058703f, 0.09827141f, 0.01300209f, 0.06975986f, 
    -0.02890501f, 0.11396046f, 0.10161325f, -0.40226030f, 0.15350062f, 0.07381009f, 0.20489740f, 0.12692253f, 
    0.05842673f, 0.04823050f, -0.15173237f, -0.02577091f, 0.03768088f, 0.07358119f, -0.21227893f, -0.00475162f, 
    -0.17443781f, 0.07534115f, -0.08474821f, -0.14060202f, 0.10586577f, 0.10704128f, -0.10182375f, 0.12069501f, 
    -0.14064918f, 0.04750790f, 0.16021760f, -0.19467221f, 0.07211681f, 0.07308555f, 0.04177969f, -0.01436907f, 
    -0.04397929f, -0.02589598f, 0.09896860f, 0.03949229f, 0.00377405f, -0.02518612f, 0.28197792f, 0.03960714f, 
    -0.11633760f, 0.00199511f, 0.09174833f, -0.07027060f, -0.08011279f, -0.05347721f, 0.06815170f, -0.01950932f, 
    -0.10267237f, 0.15272674f, 0.00980480f, 0.10449598f, -0.08185755f, 0.10573129f, 0.12475377f, 0.08129603f, 
    0.00448203f, 0.12704030f, -0.02549221f, -0.07998890f, -0.28740337f, -0.50181961f, 0.19428815f, -0.01658193f, 
    0.04737117f, 0.07117143f, 0.06082157f, -0.07278947f, 0.09342013f, 0.07563663f, 0.11545008f, 0.07242438f, 
    -0.08483463f, 0.26740193f, 0.16341296f, -0.02575574f, -0.08515298f, -0.18649270f, 0.09891564f, -0.04029202f, 
    0.17121805f, 0.02429115f, 0.09976970f, 0.09630440f, -0.29748890f, 0.14927563f, -0.29168317f, 0.34736854f, 
    0.06063671f, 0.00629310f, 0.07319349f, 0.03676408f, 0.07477163f, 0.05529120f, -0.08022238f, -0.03927673f, 
    -0.19974878f, 0.18804680f, 0.05542582f, 0.07150972f, 0.12153934f, -0.04316229f, -0.07116410f, 0.09167143f, 
    0.01295472f, 0.09841187f, -0.01927409f, 0.04523259f, 0.25419596f, -0.08227400f, -0.27113333f, 0.23876879f, 
    0.02870955f, -0.05431659f, 0.10075324f, 0.06825966f, 0.08119506f, 0.05642457f, -0.06842211f, 0.06438075f, 
    0.06951487f, -0.00702894f, -0.11354167f, -0.10795526f, -0.08414345f, -0.10419944f, -0.05566520f, 0.20184405f, 
    -0.05153718f, 0.04123316f, 0.18320069f, 0.06779173f, 0.31417686f, 0.17675287f, -0.07972521f, 0.47643048f, 
    0.10220811f, 0.03629341f, -0.02744737f, -0.03485325f, 0.06942716f, 0.01706140f, 0.08660848f, -0.04000251f, 
    0.05487498f, 0.09276371f, -0.04371670f, 0.21776219f, -0.04958093f, -0.25298181f, 0.02314073f, -0.08033353f, 
    0.11075099f, -0.17614384f, -0.02117420f, -0.01916880f, -0.01097004f, 0.16193487f, -0.20525743f, 0.25513318f, 
    0.01550845f, 0.03534506f, -0.00072067f, -0.02221103f, -0.01396763f, -0.04546580f, -0.01038543f, -0.12503915f, 
    0.25577456f, -0.27742910f, 0.15876712f, 0.04778107f, -0.03661979f, 0.00862637f, 0.03718092f, 0.01620729f, 
    -0.07730686f, 0.02578308f, -0.10847056f, 0.12720826f, -0.09583630f, 0.12344568f, 0.02668123f, 0.01876522f, 
    0.00166199f, 0.01485749f, 0.05749008f, -0.14309511f, -0.07589568f, 0.02829042f, 0.09782372f, 0.11136025f, 
    0.09256750f, -0.12154766f, -0.19939600f, 0.01639930f, -0.02644031f, 0.19049035f, 0.02183417f, 0.14452934f, 
    0.09708562f, -0.01518846f, 0.14640287f, 0.08948983f, -0.03652010f, 0.04761577f, 0.06405074f, 0.18829577f, 
    0.03044498f, -0.03814793f, -0.01392000f, 0.01880514f, -0.08528343f, 0.17353252f, 0.20178582f, -0.09129047f, 
    0.29383260f, -0.01859343f, 0.22795156f, -0.14159887f, 0.06907830f, -0.14533289f, 0.04654542f, 0.15391509f, 
    0.06988553f, 0.15381844f, -0.20771223f, -0.06774325f, 0.05081568f, -0.11749095f, -0.15970948f, 0.13994935f, 
    0.13585892f, 0.05733104f, -0.16020410f, 0.00335522f, 0.05959972f, 0.02564684f, -0.01082093f, 0.02652089f, 
    -0.17564940f, 0.17428373f, 0.22150518f, 0.13782892f, -0.06085481f, 0.01151404f, -0.05287583f, -0.12424922f, 
    -0.01299671f, -0.04051695f, 0.13000761f, -0.05600654f, -0.07788739f, 0.21129115f, -0.16327922f, -0.01757982f, 
    0.04004611f, 0.10086660f, 0.06119960f, 0.05882064f, -0.01513231f, -0.02730464f, 0.00298415f, 0.09677137f, 
    0.18373796f, -0.22668844f, -0.16242281f, -0.21339175f, 0.04231613f, -0.02851346f, -0.00880157f, 0.15244274f, 
    0.13959166f, -0.05004027f, -0.11062495f, -0.00002287f, 0.07817713f, 0.04922881f, -0.08443604f, -0.02291539f, 
    -0.12141340f, -0.10683512f, 0.03707252f, -0.12241375f, 0.07599793f, -0.07007747f, -0.01728063f, 0.01274943f, 
    0.10067811f, -0.34455079f, -0.00280874f, 0.21421349f, 0.05160564f, -0.05606969f, 0.05787998f, -0.23576166f, 
    0.03238780f, 0.03925456f, 0.04374759f, 0.02188470f, -0.44970283f, 0.47499090f, 0.33439925f, -0.23851959f, 
    -0.02561197f, 0.04061921f, -0.04806366f, 0.04189711f, 0.00472795f, 0.02003678f, -0.05193894f, 0.14571312f, 
    0.25540820f, 0.08956566f, -0.09863490f, 0.23782595f, 0.04827711f, -0.02147779f, -0.06772044f, 0.14259271f, 
    -0.10605457f, 0.04738699f, -0.05309482f, -0.07581042f, -0.35841027f, -0.00669922f, 0.13008890f, -0.17274535f, 
    0.00278293f, -0.08959322f, 0.11908364f, -0.09150629f, -0.18309455f, -0.05362093f, 0.00057294f, 0.01526133f, 
    -0.10603695f, 0.04502634f, 0.17619808f, -0.03187576f, -0.03015213f, 0.26307949f, -0.02618909f, -0.12210257f, 
    -0.09715232f, 0.15353777f, 0.16811885f, -0.01058626f, 0.11219365f, -0.09166316f, -0.21734613f, 0.12580353f, 
    0.06903080f, -0.02659512f, 0.05237723f, 0.05246801f, 0.02163599f, 0.16676329f, -0.01916216f, 0.17224672f, 
    -0.06792614f, -0.11611218f, -0.20521533f, 0.40161008f, 0.13826887f, -0.03170469f, 0.02560097f, 0.05462082f, 
    -0.04365186f, 0.01825139f, 0.09320930f, 0.02598580f, 0.11901587f, -0.25261271f, -0.04440140f, 0.11742990f, 
    -0.18431926f, 0.00988418f, -0.02836965f, 0.11452222f, 0.11804512f, 0.03139362f, -0.13137856f, -0.18694164f, 
    -0.33582303f, -0.07792948f, 0.16837043f, 0.01884390f, 0.05125695f, -0.03706333f, -0.01816821f, -0.07779737f, 
    0.05366623f, 0.02108496f, 0.00894190f, 0.03504412f, -0.28288460f, -0.14190578f, 0.35333434f, 0.05527709f, 
    -0.00381496f, -0.02702406f, 0.08138773f, 0.22245377f, 0.01713897f, 0.12565283f, -0.15438497f, 0.12217757f, 
    0.31533983f, 0.04751066f, -0.25488722f, 0.44305760f, -0.07677437f, -0.03138628f, 0.04116695f, -0.03923286f, 
    0.07265096f, 0.00380592f, -0.11841377f, -0.23139486f, -0.16549161f, -0.09957981f, 0.11284311f, 0.13179658f, 
    -0.04313830f, 0.01103176f, -0.13607627f, 0.01330412f, -0.04954205f, 0.01372920f, 0.04570249f, 0.17981979f, 
    0.05444272f, 0.02925398f, -0.16833438f, -0.27530858f, -0.07680650f, -0.05756959f, -0.02623054f, 0.14083403f, 
    -0.03718298f, 0.03213552f, 0.01755330f, 0.04719777f, 0.06561912f, 0.09621749f, -0.00574994f, -0.15286201f, 
    0.07914423f, -0.06976217f, 0.08552912f, 0.18871926f, 0.06198741f, 0.07624088f, -0.01200596f, 0.14615010f, 
    -0.12366936f, -0.01878889f, -0.03828270f, 0.03855428f, 0.06964619f, -0.05128755f, -0.07335330f, -0.12710626f, 
    -0.03021908f, -0.08423037f, 0.09264855f, 0.11626215f, 0.22328517f, 0.07533145f, -0.19506200f, -0.15330362f, 
    0.13478939f, 0.07304384f, 0.04457733f, 0.08318605f, -0.03626902f, 0.02326116f, 0.00497664f, 0.05866879f, 
    0.13808164f, 0.40219724f, -0.04364777f, 0.07443134f, 0.00456767f, 0.01865820f, 0.09384862f, 0.11560170f, 
    -0.02967522f, -0.15309007f, -0.09283298f, 0.02835491f, -0.02532580f, -0.12223201f, 0.25073701f, 0.04740319f, 
    0.03341351f, 0.14160219f, -0.12423874f, 0.00823244f, 0.15207024f, -0.02352600f, 0.02492221f, -0.12621976f, 
    0.09386428f, 0.04027801f, -0.06285278f, 0.05510893f, -0.08461098f, -0.05262420f, 0.06508926f, 0.01829521f, 
    -0.09624252f, -0.04720419f, 0.17994462f, -0.13998641f, 0.19580834f, 0.10262036f, -0.28138447f, -0.09451094f, 
    0.02448695f, 0.21302062f, -0.04925801f, 0.04601128f, 0.04438444f, 0.04741512f, 0.16726443f, 0.12298668f, 
    0.04616047f, 0.08481938f, -0.11946420f, -0.17389770f, -0.11553531f, -0.14171444f, 0.23438343f, 0.13873905f, 
    0.13174732f, -0.07085165f, -0.01210642f, -0.09619089f, -0.05132092f, 0.00705084f, 0.17276344f, 0.00660506f, 
    0.01938149f, 0.11356252f, -0.06918884f, -0.00283063f, -0.11517315f, 0.02513249f, -0.09478825f, 0.03230836f, 
    -0.02847032f, -0.12298198f, -0.01526662f, -0.12478477f, 0.08443742f, 0.07414785f, 0.04011491f, -0.02575630f, 
    0.01907674f, -0.03289177f, -0.04697322f, -0.06705635f, 0.24256448f, 0.03945161f, 0.04817392f, 0.27125147f, 
    -0.13598272f, 0.00684442f, 0.11805022f, 0.02703412f, -0.01317611f, -0.08762433f, -0.12401482f, 0.19485733f, 
    -0.46589723f, 0.30701348f, 0.08730357f, 0.15002264f, 0.01802309f, -0.00025702f, -0.04971121f, -0.01624478f, 
    -0.21642302f, -0.10199571f, -0.04573838f, 0.05386871f, 0.26446497f, -0.27475137f, -0.16931355f, 0.13391694f, 
    -0.00822689f, 0.01619653f, -0.02589764f, -0.18330939f, 0.09945010f, -0.06140517f, -0.03591571f, -0.04411832f, 
    0.37963137f, 0.10149597f, 0.11464703f, -0.06611575f, -0.05529983f, 0.03247978f, 0.08840830f, 0.04463802f, 
    0.00592105f, -0.02002812f, 0.05637634f, -0.05643994f, -0.32425150f, 0.27996176f, -0.20746699f, 0.08132901f, 
    0.05340987f, 0.10036868f, 0.08256152f, -0.03647605f, -0.11521979f, -0.08589266f, 0.02569097f, -0.07656100f, 
    0.04321196f, 0.02794633f, -0.07253832f, -0.12253194f, -0.06906167f, -0.03394844f, -0.05513893f, 0.08388027f, 
    -0.00441629f, -0.04072172f, 0.04050887f, -0.08723845f, -0.29979828f, 0.07435382f, -0.12984632f, -0.05148551f, 
    -0.01825963f, 0.02052657f, -0.08929611f, -0.07444523f, 0.06023819f, 0.02761647f, 0.10732317f, 0.07667174f, 
    0.07583277f, 0.06284107f, -0.08084409f, -0.15510979f, -0.00968335f, -0.00907067f, 0.11987428f, 0.09278574f, 
    0.00706869f, 0.12195453f, -0.01211635f, 0.00667226f, 0.07612082f, -0.19219282f, 0.08540001f, 0.06872761f, 
    0.07869156f, 0.06780948f, 0.02448703f, -0.02638601f, 0.03668591f, 0.11895000f, -0.11653864f, -0.13110135f, 
    -0.54545742f, 0.20521209f, 0.10410485f, -0.12408803f, -0.01635016f, 0.01792419f, 0.10314872f, 0.11048448f, 
    -0.01702409f, 0.03151438f, 0.03187134f, 0.03151051f, 0.33991924f, 0.00214649f, 0.26566485f, 0.29473293f, 
    -0.04060178f, -0.09833933f, -0.02509846f, 0.13195169f, 0.10149057f, -0.00783492f, 0.08704383f, 0.02794233f, 
    0.07081509f, 0.11524305f, 0.10976644f, 0.00734304f, -0.09090041f, -0.08074680f, 0.03731750f, 0.32770759f, 
    -0.05492035f, 0.11386364f, -0.01208871f, 0.00401074f, 0.09300490f, -0.11907219f, -0.08914576f, 0.34918270f, 
    -0.03419616f, 0.00564382f, 0.12652895f, -0.01201331f, -0.11946297f, 0.06421370f, 0.02204733f, -0.01703092f, 
    0.18577136f, 0.03550583f, -0.02313755f, 0.20781848f, -0.03282168f, -0.02768569f, 0.16068257f, 0.18925498f, 
    0.19297796f, 0.03180495f, -0.10441758f, -0.07545740f, -0.29291674f, -0.15126595f, -0.15541270f, 0.13611583f, 
    -0.02841993f, 0.00893103f, -0.10406867f, -0.06660105f, 0.02798615f, 0.02342198f, 0.09855810f, -0.09737415f, 
    0.25018290f, -0.07403181f, -0.06849092f, 0.24411367f, -0.00203864f, -0.12927374f, 0.12557071f, -0.06398936f, 
    -0.04866578f, 0.16413487f, 0.02783773f, -0.06055133f, 0.10087932f, 0.08593175f, 0.10853789f, 0.16450861f, 
    -0.03624208f, 0.02435300f, -0.16698860f, 0.04364118f, 0.11503315f, 0.16728905f, 0.06256779f, -0.02061648f, 
    -0.17821555f, -0.31517008f, -0.14586633f, -0.10866149f, -0.01061257f, 0.01515302f, 0.07893462f, 0.06796299f, 
    0.12667212f, 0.16083962f, -0.12047652f, 0.02368217f, -0.30073678f, -0.35723305f, 0.09185335f, -0.13039528f, 
    0.22159599f, -0.03934247f, 0.06237551f, 0.13707504f, 0.07605732f, 0.11778582f, 0.00095302f, 0.04857160f, 
    0.39092499f, 0.26018769f, 0.30858737f, 0.30394217f, -0.03184367f, 0.03771746f, -0.07416208f, -0.01082107f, 
    0.03332736f, 0.03115451f, 0.12176149f, -0.11635108f, -0.11210558f, -0.37536103f, -0.20055211f, -0.09771901f, 
    0.25596699f, -0.01440386f, 0.03935394f, 0.00463563f, 0.03549796f, -0.03880701f, 0.02922724f, 0.15538391f, 
    0.23985322f, 0.41738009f, 0.16812158f, 0.13261096f, 0.04944630f, -0.07040969f, -0.07338217f, -0.07798208f, 
    0.03172752f, 0.07165767f, 0.13151662f, 0.08049656f, -0.09046429f, 0.00627675f, -0.19214930f, -0.12974663f, 
    0.08319797f, 0.01454042f, -0.07119750f, 0.22268540f, 0.10328408f, 0.07664323f, -0.00904341f, 0.13051757f, 
    -0.33665907f, -0.18765193f, -0.08269419f, -0.11940518f, 0.21050979f, -0.06408765f, -0.14975587f, -0.06718095f, 
    -0.01405252f, -0.06895961f, -0.21222532f, 0.00765106f, -0.05846932f, 0.32855210f, -0.04455231f, -0.17570528f, 
    0.12835841f, -0.16207382f, 0.01736305f, 0.03422565f, -0.11899155f, 0.08145656f, 0.00954598f, -0.05291266f, 
    0.54123038f, -0.07979801f, -0.02707357f, 0.17744079f, 0.05627421f, 0.06806442f, 0.08357994f, -0.18765731f, 
    0.18819427f, 0.11464582f, -0.20170188f, 0.07396145f, -0.08356681f, 0.30137214f, 0.41368219f, 0.10595099f, 
    -0.14748435f, -0.07873086f, -0.10485919f, -0.08667566f, 0.11134537f, -0.03276240f, 0.02372425f, 0.02815587f, 
    0.25445664f, 0.24259895f, 0.02700831f, 0.19369090f, 0.16079666f, -0.21266185f, -0.10063617f, -0.16833310f, 
    0.06776137f, -0.05795183f, 0.15850219f, -0.05650111f, -0.06832571f, -0.14113355f, 0.02096693f, -0.13437791f, 
    -0.03601976f, -0.15434247f, -0.03487729f, -0.06220792f, 0.05224146f, 0.03493954f, 0.07053257f, 0.00836131f, 
    -0.11014603f, 0.03393294f, -0.13452698f, -0.09065494f, 0.04227053f, 0.02906073f, 0.23419692f, -0.00765991f, 
    0.06906123f, -0.07087217f, 0.07740401f, -0.23258181f, 0.14302969f, -0.09842601f, -0.11610641f, -0.09908274f, 
    0.00351735f, 0.09472111f, 0.18243688f, 0.22367904f, -0.06005229f, 0.05470042f, -0.07380574f, 0.07078770f, 
    0.27081415f, -0.09422321f, -0.26258928f, 0.05298110f, -0.05512439f, 0.12982902f, 0.08191323f, -0.14121336f, 
    0.02490343f, 0.02239431f, 0.15420391f, 0.04351528f, 0.12683919f, -0.10637047f, 0.02656107f, -0.11715610f, 
    -0.10235551f, -0.10656683f, -0.16257966f, 0.12672518f, 0.07702342f, 0.04118070f, 0.03515455f, -0.04331961f, 
    0.13253136f, -0.37510535f, -0.21517050f, -0.00245303f, -0.00825052f, 0.04514254f, 0.03702731f, 0.03643430f, 
    0.04786903f, 0.16454418f, -0.08902219f, 0.05360543f, 0.21532796f, -0.06595872f, -0.02056651f, -0.17382516f, 
    -0.03699090f, 0.11813155f, 0.02310600f, -0.03532817f, -0.17646670f, -0.08301170f, 0.00319182f, 0.10739193f, 
    0.09675415f, 0.09294678f, 0.13245840f, 0.19629115f, -0.01703653f, 0.01174031f, -0.17059551f, -0.18264906f, 
    0.08468126f, -0.11149453f, 0.13603875f, -0.06854574f, 0.10068959f, -0.01099329f, 0.27352324f, -0.06089268f, 
    -0.00643050f, 0.13174742f, 0.02703307f, -0.02191395f, 0.01842248f, 0.00423316f, -0.02478652f, 0.16718951f, 
    0.09843890f, -0.12200784f, -0.14357245f, 0.15615083f, 0.02998215f, -0.17742424f, -0.07646146f, 0.21785122f, 
    0.11621967f, 0.06864110f, -0.11443669f, 0.01269798f, -0.32061270f, -0.16177917f, 0.23067325f, -0.15135367f, 
    -0.00848333f, 0.09632283f, 0.11929056f, 0.12858492f, 0.10567683f, -0.00124871f, 0.16071203f, 0.01395427f, 
    -0.50772673f, 0.17736569f, 0.16952172f, -0.09438138f, -0.00305761f, 0.06119781f, -0.02275817f, -0.20002170f, 
    -0.10886384f, 0.07109471f, 0.05899284f, 0.11664180f, -0.47884199f, 0.34746620f, -0.27531204f, -0.06356867f, 
    0.19728935f, 0.04304361f, -0.11156958f, -0.02707531f, -0.01265170f, 0.11713970f, 0.12489266f, 0.04150720f, 
    0.69656438f, 0.19171050f, 0.13233277f, 0.26000205f, -0.04634875f, -0.10937144f, -0.08924364f, -0.20164312f, 
    0.01873099f, 0.03533963f, -0.21710329f, 0.05730559f, 0.06691208f, -0.09048782f, -0.09651321f, 0.15295462f, 
    0.10127887f, -0.03084534f, -0.20792714f, -0.12120917f, -0.10766989f, -0.08334731f, -0.06353333f, -0.03471833f, 
    0.01781488f, -0.12429699f, -0.11646031f, 0.15837237f, 0.10031551f, -0.03678230f, -0.06558283f, 0.09732512f, 
    0.02631025f, -0.05050975f, 0.09204084f, -0.05191641f, -0.00367210f, 0.03230289f, 0.19012666f, -0.08403384f, 
    -0.05894301f, -0.15435661f, -0.20502554f, -0.06058152f, 0.00728692f, 0.03138754f, 0.16909800f, 0.14847560f, 
    0.01497041f, 0.07914818f, -0.03135669f, 0.06320645f, -0.22709928f, -0.10262893f, -0.02901644f, -0.13193920f, 
    0.13059378f, 0.01062762f, -0.13392152f, -0.20366526f, 0.43078336f, 0.37625217f, -0.09462295f, -0.23844720f, 
    0.19044502f, -0.04188340f, 0.07917308f, 0.04512235f, -0.00627928f, -0.13672042f, 0.06310428f, 0.06649157f, 
    0.00596519f, 0.01876641f, -0.05111832f, -0.00122283f, -0.02465645f, -0.04697485f, 0.02490662f, -0.03625698f, 
    0.01293131f, -0.04186397f, -0.00750384f, -0.03310076f, -0.06413198f, -0.05079176f, 0.04504779f, 0.04346965f, 
    -0.00708914f, 0.04156178f, -0.06172474f, 0.05728969f, -0.01038734f, -0.06034701f, -0.00793591f, -0.02636507f, 
    0.03450594f, -0.02047420f, -0.06547311f, -0.01326237f, 0.03131751f, -0.01700765f, -0.01797101f, -0.03689494f, 
    0.01576515f, 0.00222432f, 0.02201125f, 0.03826734f, 0.05311005f, -0.00737357f, -0.02951242f, 0.01114388f, 
    0.03812958f, 0.03702779f, -0.02719358f, -0.05436400f, 0.03935436f, 0.01092582f, 0.02125654f, -0.07455611f, 
    0.06284219f, 0.01412361f, 0.01520591f, 0.05371105f, -0.04663522f, -0.01360351f, -0.03250002f, 0.05652311f, 
    -0.04055436f, 0.05026583f, -0.06373264f, 0.01097754f, -0.06566403f, 0.03339851f, -0.02205769f, 0.03749812f, 
    0.00385312f, -0.01772571f, -0.02181378f, -0.05463830f, 0.04992009f, 0.04753793f, -0.03565025f, -0.04955141f, 
    -0.00168800f, -0.04394133f, -0.06871782f, -0.05117378f, -0.01053850f, -0.03777689f, -0.00782792f, 0.03984126f, 
    -0.06733801f, -0.07334868f, 0.03567228f, -0.03981425f, 0.05183051f, -0.04944507f, 0.05423154f, -0.04573220f, 
    0.01500453f, -0.07027069f, -0.07276299f, -0.00029879f, -0.01666893f, -0.04727759f, 0.02590413f, -0.02451388f, 
    -0.01557294f, -0.00942022f, -0.00279081f, 0.03679075f, 0.03285035f, 0.01974406f, 0.05622707f, 0.04939117f, 
    0.02171723f, -0.04321282f, 0.02868380f, -0.03924309f, 0.03074363f, -0.00293610f, -0.03644324f, 0.04464182f, 
    0.01142143f, -0.07314295f, -0.01062070f, -0.05139105f, -0.06914313f, 0.02071287f, -0.06606004f, 0.01594662f, 
    -0.03407740f, 0.03938799f, -0.02184576f, -0.07726000f, -0.06193675f, 0.02993192f, 0.03231874f, -0.06186416f, 
    0.04474012f, -0.07452264f, 0.03615420f, 0.04160448f, -0.03780814f, -0.02456718f, -0.01430734f, 0.05450756f, 
    -0.04955160f, 0.03841251f, -0.01444256f, 0.04148606f, -0.00442266f, 0.00362743f, -0.04028144f, -0.06324612f, 
    0.02004070f, -0.06537329f, -0.05261313f, -0.00151311f, -0.05635210f, 0.05291607f, 0.01197685f, -0.01581498f, 
    0.06070517f, 0.03648283f, -0.07426436f, -0.02728296f, -0.01138135f, -0.07835019f, -0.06917074f, 0.04884180f, 
    -0.00387239f, -0.06363885f, 0.04671761f, -0.03561436f, -0.03277059f, -0.00087056f, -0.00284699f, 0.05669954f, 
    -0.02058194f, -0.06982981f, -0.00499821f, -0.04255768f, -0.02201701f, -0.06200708f, -0.06910529f, -0.02247099f, 
    -0.05728408f, 0.03679846f, -0.05619902f, -0.03710093f, -0.01957150f, -0.06687150f, 0.06038024f, 0.00271031f, 
    0.00109807f, 0.03106054f, -0.04986978f, -0.07138518f, -0.04859700f, -0.07794653f, 0.06650674f, -0.06522918f, 
    0.47311801f, -0.18241575f, -0.07407669f, -0.01759568f, -0.14182191f, 0.05959228f, -0.07278558f, 0.00212046f, 
    -0.00460078f, -0.00860039f, -0.09479140f, -0.11935931f, -0.20016387f, -0.11716942f, 0.00219138f, -0.02242164f, 
    0.21302064f, -0.08524127f, -0.07803541f, 0.00373343f, 0.07476619f, 0.02898502f, 0.17108090f, 0.28398168f, 
    -0.09990074f, -0.00066726f, -0.11738054f, 0.14983316f, 0.09895841f, 0.09765019f, -0.00376912f, 0.03123230f, 
    0.06289715f, 0.02547576f, -0.00185847f, 0.22209385f, 0.23427510f, 0.17837115f, -0.08430275f, -0.06027255f, 
    0.10286327f, -0.04459866f, -0.03120034f, -0.19006212f, -0.06293067f, -0.11547076f, 0.18282749f, -0.07920254f, 
    -0.08119057f, 0.02180346f, 0.08377983f, 0.02863326f, 0.07432286f, 0.00692120f, -0.10233057f, 0.09435745f, 
    0.09160856f, 0.04773759f, 0.03891921f, 0.04754671f, 0.33849180f, 0.17061035f, -0.02713661f, 0.11963324f, 
    0.06117452f, 0.12820472f, 0.09044491f, -0.04522061f, 0.18318100f, 0.04625147f, -0.06570707f, -0.20137854f, 
    -0.04614312f, -0.16636619f, 0.05258173f, 0.22493920f, 0.13855703f, -0.05592249f, 0.01256728f, -0.07888783f, 
    0.07561359f, -0.03691843f, 0.02492317f, 0.04379282f, -0.26075196f, 0.01934041f, 0.23632905f, -0.16382192f, 
    -0.07925821f, 0.13458566f, 0.09299397f, -0.10664944f, -0.02915182f, -0.13535364f, 0.04008268f, -0.10408299f, 
    -0.00836374f, -0.00321068f, 0.13230531f, -0.16828024f, -0.02669555f, 0.09163236f, 0.08955898f, 0.13120621f, 
    -0.07201703f, -0.12641448f, -0.18934363f, -0.08125500f, -0.33785120f, 0.22994718f, 0.12051193f, -0.21566670f, 
    0.11216323f, 0.02858914f, -0.15417120f, 0.05075890f, 0.07988198f, -0.02189049f, 0.05391837f, 0.18627954f, 
    -0.23004906f, 0.33763888f, -0.00655296f, -0.00537607f, 0.01551059f, -0.04290850f, -0.13628760f, -0.21088120f, 
    0.01585642f, 0.02811951f, 0.00737272f, -0.07966178f, -0.02787895f, -0.04945552f, -0.06777109f, 0.25209659f, 
    0.07129688f, -0.15840921f, 0.06720465f, -0.02566444f, 0.11505239f, 0.10385938f, -0.10411352f, 0.18973745f, 
    -0.06910767f, -0.11980897f, -0.14236113f, 0.12471272f, 0.06468630f, 0.05205857f, 0.03354744f, 0.08725960f, 
    0.09910297f, -0.02689142f, -0.17175704f, -0.13013105f, 0.07152407f, 0.03972878f, 0.24271734f, 0.11390797f, 
    0.13398404f, -0.10454361f, -0.00957814f, 0.02413839f, 0.04830269f, 0.00047592f, -0.05666770f, -0.12535258f, 
    0.10890750f, 0.13834515f, -0.03903099f, -0.02882179f, 0.10001874f, 0.19671033f, -0.06520893f, -0.14144741f, 
    0.02679068f, 0.17503233f, 0.19090727f, 0.14689615f, 0.19252741f, 0.15406194f, -0.12909552f, -0.19165973f, 
    -0.09119558f, 0.03215616f, 0.09936909f, 0.04100710f, 0.05860240f, 0.06188521f, 0.00955047f, 0.20719044f, 
    0.24043715f, -0.08199754f, 0.04391396f, 0.24058573f, 0.05926455f, -0.07273929f, -0.11724989f, 0.10990848f, 
    -0.00092821f, 0.10436154f, 0.01676452f, 0.01030635f, 0.22176404f, -0.01542777f, 0.21815021f, 0.04589708f, 
    -0.07654649f, -0.10774109f, 0.00794297f, 0.05203767f, 0.02809726f, -0.11352089f, -0.10900004f, -0.10807021f, 
    -0.27279127f, -0.06542870f, 0.00865851f, 0.05376077f, 0.00382360f, -0.04834995f, -0.08681876f, 0.01574265f, 
    0.09003431f, 0.01044893f, 0.08514340f, 0.04012697f, -0.09020916f, -0.07142049f, 0.22864567f, -0.03523525f, 
    0.11971325f, 0.04273272f, -0.04721481f, 0.22815797f, 0.01517574f, 0.00385126f, 0.08343924f, 0.06137824f, 
    0.36263949f, 0.14521943f, 0.02793528f, 0.23216566f, -0.06262927f, 0.04472776f, -0.14664812f, 0.03595911f, 
    0.09873977f, -0.11774708f, -0.09237259f, -0.14682204f, 0.05446429f, -0.16401386f, -0.09379762f, -0.18243004f, 
    0.10522886f, 0.02315759f, -0.00265406f, -0.09894279f, 0.11549533f, 0.08774298f, -0.09798920f, 0.09012284f, 
    0.42712766f, 0.01486829f, 0.04002136f, 0.11451543f, -0.14326800f, -0.07374734f, -0.06894574f, 0.08526536f, 
    0.06532477f, -0.09274378f, 0.11316279f, -0.13255690f, -0.10801303f, 0.00975544f, -0.08911401f, 0.16886394f, 
    0.03276015f, 0.02688717f, 0.07846785f, 0.00101996f, -0.11732506f, 0.09467479f, 0.18613736f, 0.14052747f, 
    -0.10474431f, 0.01694250f, -0.06661589f, 0.01796934f, 0.06221479f, 0.15412210f, -0.04033598f, 0.04168538f, 
    0.02692709f, 0.11148366f, -0.11819493f, -0.05910134f, 0.29250956f, 0.32473719f, 0.05634525f, -0.42930183f, 
    0.04101381f, -0.08831287f, -0.03725979f, 0.20206803f, -0.01448421f, 0.08021048f, 0.04338253f, 0.08485458f, 
    0.13837470f, -0.05084338f, 0.01877963f, 0.12699006f, -0.06845407f, -0.03607925f, 0.19427252f, -0.17259024f, 
    -0.06344980f, -0.05354358f, 0.11013226f, -0.04385960f, 0.11480656f, 0.07864817f, 0.13211511f, 0.14570330f, 
    -0.11275852f, 0.12630437f, 0.10491892f, 0.14988840f, -0.07516501f, -0.06132012f, -0.03239647f, -0.01531287f, 
    0.13573946f, 0.00180579f, 0.16222450f, 0.34969121f, -0.00598316f, -0.08491220f, 0.10126543f, -0.06809904f, 
    0.05020918f, -0.05319432f, -0.08182461f, -0.06852452f, -0.05638386f, -0.12964848f, -0.06604819f, -0.36211896f, 
    -0.02004032f, -0.01753845f, -0.00125155f, -0.01854536f, 0.04713356f, 0.06535323f, -0.03684388f, 0.01668519f, 
    -0.10231278f, 0.07410844f, -0.09111989f, -0.26460403f, -0.07938195f, 0.03273391f, 0.15855937f, 0.11799072f, 
    0.11981343f, 0.00803421f, 0.02303908f, 0.04206020f, -0.07258231f, -0.05679132f, 0.08255541f, -0.32894951f, 
    0.10290428f, 0.03165735f, -0.01345204f, 0.07413609f, -0.04675514f, 0.02885872f, 0.05090145f, 0.19792859f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.06529938f, -0.12998579f, 0.03186455f, -0.06419654f, 0.10022294f, -0.04672419f, 0.13233887f, 0.04384718f, 
    -0.10045939f, -0.04019458f, -0.04363957f, 0.15289018f, 0.01225338f, 0.04109173f, -0.02019410f, 0.06049161f, 
    0.05006622f, 0.13919319f, 0.03562684f, 0.00046876f, -0.01063930f, -0.01802061f, 0.01741904f, 0.00815766f, 
    0.11125675f, -0.02048177f, -0.11550329f, 0.04805243f, 0.06332539f, -0.01640377f, -0.05070335f, 0.12323079f, 
    0.09964794f, 0.15904164f, 0.03856399f, -0.13431974f, 0.04469338f, 0.08584852f, 0.01408967f, -0.05679183f, 
    0.17617354f, -0.02189577f, 0.22391702f, -0.07367597f, 0.11996358f, 0.06097888f, 0.00153749f, 0.15172866f, 
    0.01876653f, 0.05775616f, -0.02568879f, 0.03371201f, 0.05842226f, -0.06043874f, 0.02716909f, -0.05926513f, 
    0.05657138f, -0.00288332f, 0.02206611f, -0.05014930f, -0.01651228f, -0.01827878f, 0.04407594f, -0.04569381f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.30809259f, -0.33188856f, -0.22942524f, -0.00146331f, 0.30156150f, 0.01647880f, -0.51123732f, -0.05265952f, 
    0.29501256f, 0.29307809f, 0.07479119f, -0.13928485f, 0.24111240f, -0.27507365f, -0.03463597f, 0.17513280f, 
    0.01709155f, 0.00541190f, -0.03414048f, 0.08072236f, -0.10366315f, 0.07791293f, -0.12304044f, 0.14866336f, 
    -0.08760017f, -0.20284376f, 0.26150790f, -0.05277903f, -0.47954872f, -0.15976281f, -0.01394293f, -0.10298418f, 
    -0.54609841f, -0.15771669f, 0.10794125f, -0.07476849f, -0.14838660f, -0.74680066f, -0.05300104f, -0.05627781f, 
    -0.30486935f, 0.14197069f, -0.03915233f, -0.11482333f, -0.20202264f, -0.04014905f, -0.07296921f, -0.16670828f, 
    -0.03822748f, 0.17876209f, 0.21479511f, 0.04249481f, -0.14114195f, 0.03615803f, -0.06490307f, -0.26746872f, 
    0.02822811f, -0.00174581f, -0.14045966f, 0.19358805f, 0.67114049f, -0.07072520f, 0.23880169f, 0.11690047f, 
    0.17308551f, -0.05486226f, 0.28714296f, -0.05353786f, -0.12512933f, -0.04463335f, 0.09578227f, -0.00095423f, 
    -0.25351992f, -0.63685966f, 0.01264240f, -0.24999964f, 0.34014401f, -0.29339761f, -0.24430434f, 0.19813749f, 
    -0.07244839f, 0.14516431f, 0.34209558f, 0.01586416f, -0.00874003f, -0.06496771f, 0.02051290f, -0.25796747f, 
    -0.36923221f, -0.46509126f, 0.07459866f, 0.06314219f, -0.18983340f, -0.47892004f, 0.07191149f, -0.14285925f, 
    -0.24723616f, 0.14507867f, 0.08566489f, 0.02384548f, -0.39845103f, 0.13396811f, 0.00264422f, -0.09654052f, 
    0.19104786f, 0.03400841f, 0.34108579f, -0.11138186f, 0.24901655f, 0.05798371f, 0.10867497f, 0.33555609f, 
    0.11895130f, 0.14249992f, -0.16741437f, 0.07442456f, -0.35516882f, 0.10774490f, -0.05725757f, -0.37790745f, 
    0.13723183f, 0.06337477f, 0.01255295f, 0.18898606f, -0.62582678f, -0.01471175f, 0.01970791f, 0.15024920f, 
    0.00538539f, -0.09100313f, 0.26881337f, 0.07736040f, -0.04865696f, 0.00700779f, -0.06237510f, 0.11277831f, 
    -0.12621087f, -0.30885592f, -0.10975642f, -0.46186656f, 0.07450330f, -0.02006395f, 0.06226014f, 0.06224916f, 
    -0.26957750f, -0.21497634f, -0.04124599f, 0.10270826f, -0.01421062f, -0.11947889f, -0.06268401f, -0.51331609f, 
    0.38871029f, -0.01821151f, -0.40147600f, -0.00255431f, -0.22514033f, 0.33545732f, 0.10450101f, -0.51151097f, 
    -0.30220643f, 0.08661490f, 0.23761709f, 0.31992489f, -0.23031080f, 0.12482982f, 0.03031737f, -0.12282573f, 
    -0.39566436f, 0.31244782f, -0.61137187f, 0.07626270f, -0.01003539f, -0.13182417f, -0.06748948f, -0.38719127f, 
    0.10726494f, 0.21122637f, -0.04847739f, -0.10869562f, 0.38173983f, 0.09810784f, 0.07221267f, -0.14691435f, 
    0.19057488f, -0.05354330f, -0.61161929f, -0.01537925f, 0.02768780f, -0.10035788f, -0.09935935f, -0.01404887f, 
    -0.12712876f, 0.09132437f, -0.07647350f, -0.08841448f, -0.25581715f, 0.09854800f, 0.21344906f, -0.04289617f, 
    -0.38021719f, 0.30553114f, 0.11644035f, 0.26959920f, 0.35117048f, 0.32445157f, 0.06196409f, 0.28358757f, 
    -0.70362341f, -0.01323016f, -0.71648210f, 0.01422402f, 0.11374743f, 0.01127006f, -0.08698382f, -0.22468267f, 
    -0.03841693f, 0.15970823f, 0.03330221f, 0.11397175f, -0.00023596f, -0.13231091f, 0.04372460f, 0.13754995f, 
    -0.28368393f, -0.59258372f, -0.14047767f, -0.06750289f, 0.32833239f, -0.53652585f, 0.05508986f, -0.05733080f, 
    0.08372366f, -0.60329860f, 0.16746509f, 0.00168284f, -0.30172679f, 0.05753399f, -0.06930658f, 0.28453246f, 
    0.07467333f, 0.23131146f, 0.01193604f, -0.02150962f, 0.00108182f, 0.10620558f, -0.10007957f, 0.27217680f, 
    -0.78972334f, 0.10459957f, 0.05735472f, -0.93689090f, 0.03821578f, 0.03222464f, 0.00689866f, -0.16883913f, 
    -0.53878921f, -0.13908105f, -0.30630800f, 0.03573054f, 0.32870805f, -0.05299268f, -0.06506195f, -0.10785961f, 
    -0.04973128f, -0.04475960f, -0.07151046f, 0.03835073f, 0.18068857f, -0.06023733f, -0.05806873f, 0.04646847f, 
    0.13154580f, -0.11592759f, 0.14796142f, 0.02324732f, 0.10860887f, 0.01266847f, -0.10193364f, -0.27857238f, 
    -0.07957978f, 0.15035892f, 0.23233366f, -0.03788339f, 0.12374219f, 0.02433225f, 0.06451780f, 0.23353082f, 
    0.29703745f, -0.04129079f, -0.22943486f, 0.02982225f, 0.50910991f, 0.39865112f, -0.07202465f, -0.03818020f, 
    -0.52957916f, -0.28733438f, 0.25418192f, -0.05356512f, -0.35805410f, -0.12641686f, 0.10363172f, -0.02842830f, 
    -0.08497786f, 0.08269423f, 0.17443152f, -0.07231137f, -0.15039751f, 0.10396561f, -0.01907537f, -0.16539139f, 
    0.13533939f, 0.38034663f, 0.17299651f, 0.12146296f, 0.02260600f, -0.01253944f, -0.21639493f, -0.04185844f, 
    -0.09141163f, 0.05508827f, -0.02920350f, 0.07659474f, -0.33978805f, -0.01047254f, -0.71807063f, -0.02868726f, 
    0.45618200f, 0.25257573f, -0.08037151f, -0.12663066f, -0.05210322f, 0.03291431f, -0.06528137f, -0.42316759f, 
    -0.12409684f, 0.16843086f, 0.31248853f, -0.11303179f, 0.01338279f, -0.05895416f, -0.07801909f, 0.30729550f, 
    -0.00242589f, -0.31504339f, -0.17537478f, -0.01722483f, -0.06415257f, 0.25123838f, 0.10899234f, 0.31987914f, 
    0.02025643f, 0.06887297f, -0.03644614f, -0.45873806f, 0.11551033f, 0.29164457f, 0.07564186f, -0.05493122f, 
    0.24181688f, 0.13919781f, -0.05657037f, -0.01418618f, 0.15757827f, 0.02912547f, -0.12558940f, 0.29692569f, 
    0.01616969f, -0.00849636f, 0.21392791f, -0.12271180f, -0.14406841f, 0.00860833f, -0.00755237f, 0.04475740f, 
    0.15474980f, -0.59255582f, 0.20698777f, -0.13819313f, -0.40904099f, -0.09189922f, 0.05613208f, -0.05390898f, 
    0.15954477f, 0.35166809f, 0.22317378f, 0.11684955f, -0.07181076f, 0.04390770f, -0.08483081f, -0.09728982f, 
    -0.14940366f, 0.29729953f, -0.02515688f, 0.29343659f, -0.22494219f, -0.46337029f, -0.43148744f, -0.07466824f, 
    0.29131329f, 0.05966885f, -0.22245337f, -0.06483479f, 0.01255691f, 0.02172435f, -0.06180235f, -0.30958208f, 
    -0.53370506f, 0.13766715f, -0.13205589f, -0.04636436f, 0.32409659f, 0.31361055f, -0.11018337f, -0.54159462f, 
    0.24701215f, -0.24008805f, 0.19375107f, -0.26492307f, -0.33490407f, 0.07178093f, -0.14737171f, -0.06525599f, 
    -0.11576378f, -0.09328298f, -0.13717885f, 0.03867914f, -0.04377631f, -0.10993908f, 0.09582534f, -0.22379196f, 
    -0.06634048f, 0.01976301f, -0.33029187f, -0.07597066f, 0.30660862f, 0.00457223f, -0.00868501f, 0.35816285f, 
    0.13986434f, -0.04341927f, -0.12230550f, 0.15742140f, 0.11773974f, -0.08264124f, -0.25114453f, -0.09549791f, 
    0.20261046f, 0.26829132f, 0.10630365f, -0.06066460f, -0.45885214f, -0.08018591f, 0.03175154f, 0.03641678f, 
    0.22944792f, -0.07682714f, -0.09139580f, -0.48850688f, 0.04820552f, 0.12183099f, 0.18985206f, 0.13450986f, 
    0.21653028f, -0.63474268f, -0.01572059f, -0.07968567f, 0.09970399f, 0.07399184f, 0.11700850f, 0.13567050f, 
    0.07476073f, 0.27794495f, 0.23283227f, -0.05992258f, -0.26535758f, 0.28751069f, 0.06381655f, 0.24629925f, 
    0.26904446f, -0.12026557f, -0.40254787f, 0.11757384f, -0.22440621f, 0.20906705f, 0.05353760f, -0.04366115f, 
    -0.22328298f, -0.05131636f, -0.47631454f, 0.07844681f, -0.18444231f, -0.10931204f, -0.05344532f, -0.20623375f, 
    0.11218219f, -0.33463272f, -0.06537409f, 0.01040989f, 0.12128483f, -0.07705545f, 0.10771503f, 0.15070392f, 
    -0.18836384f, -0.31550315f, -0.14426683f, -0.33265311f, -0.04484508f, 0.07392871f, -0.01455400f, -0.39712396f, 
    -0.50216514f, 0.32943431f, 0.08009309f, 0.03824711f, 0.02906723f, -0.03818231f, -0.09052227f, 0.10590353f, 
    0.25293931f, -0.43633902f, 0.04816103f, -0.31558591f, -0.01185435f, 0.35105747f, -0.45553330f, 0.13541314f, 
    -0.25448334f, 0.09134875f, 0.22124995f, -0.07131785f, 0.03791272f, -0.02441086f, -0.10192062f, 0.34784579f, 
    0.16203694f, -0.25615981f, -0.19556187f, 0.10980821f, -0.17646180f, -0.16343617f, -0.00753176f, -0.38727376f, 
    0.05658448f, 0.27226546f, -0.13838232f, 0.15435234f, -0.09402499f, 0.16476317f, 0.02106487f, -0.04964954f, 
    -0.18865016f, -0.02006704f, -0.11201244f, -0.09236442f, 0.22241770f, -0.07668444f, -0.00603459f, 0.24113840f, 
    0.01854736f, -0.37471041f, -0.69662517f, -0.05387584f, -0.59755528f, 0.08810285f, 0.09433259f, 0.10879386f, 
    0.03801762f, 0.17998429f, -0.44014385f, 0.20707661f, 0.38264197f, -0.05423081f, 0.23045427f, 0.06983696f, 
    -0.05561995f, 0.30701378f, -0.59454143f, 0.09327155f, -0.07521962f, -0.10714691f, 0.29147309f, -0.02160896f, 
    -0.33084124f, 0.11110652f, 0.03456931f, 0.15170644f, -0.66510892f, -0.06588113f, -0.03113655f, -0.61312604f, 
    0.38661465f, -0.54978776f, -0.13988402f, 0.09206215f, 0.08857481f, -0.12622000f, 0.04207812f, 0.02093367f, 
    -0.03592036f, 0.00735383f, 0.44226390f, -0.10281246f, 0.12467183f, -0.13176511f, -0.07155067f, 0.22534335f, 
    -0.40179950f, 0.00909627f, 0.10266639f, 0.41383183f, 0.07343989f, -0.05876578f, -0.03930208f, -0.00493480f, 
    0.06372138f, 0.32278764f, -0.47020251f, -0.03068620f, 0.19806227f, -0.01840093f, -0.05637611f, 0.00392342f, 
    0.08560219f, 0.20375624f, -0.05120961f, -0.05265586f, 0.20614634f, -0.02210233f, -0.04728814f, -0.54010057f, 
    -0.02188219f, 0.13466513f, -0.35137221f, 0.04335293f, -0.41943306f, 0.03417060f, -0.52027321f, 0.04949214f, 
    0.14545269f, -0.71453941f, -0.28248203f, 0.04141803f, 0.26256227f, -0.05996900f, 0.18946064f, -0.01494859f, 
    -0.24423324f, -0.48001489f, 0.05920599f, 0.04080536f, -0.28795788f, 0.11782454f, 0.04049373f, 0.16566381f, 
    0.21889533f, 0.35411355f, -0.82570577f, -0.06636908f, 0.08454554f, -0.11433244f, 0.05228198f, 0.03334296f, 
    0.25397274f, -0.01260601f, -0.40331545f, 0.04391555f, 0.09184895f, 0.15734199f, -0.04834832f, 0.18812022f, 
    0.27466094f, 0.08165553f, 0.20302150f, -0.26618993f, 0.13267562f, -0.14521052f, 0.02233046f, -0.07765339f, 
    0.36010912f, -0.25298154f, 0.08886801f, -0.12986791f, 0.16994978f, 0.09337283f, -0.10237444f, 0.18140681f, 
    0.07390317f, -0.25759470f, -0.08397509f, 0.01809944f, 0.12895279f, 0.05465670f, 0.08141924f, -0.09253608f, 
    0.15168028f, -0.36262485f, -0.20037618f, -0.58625424f, -0.45897329f, -0.05816401f, 0.25361094f, -0.44808343f, 
    -0.06169486f, 0.25162131f, 0.27528414f, 0.07294816f, 0.14020121f, -0.12031133f, 0.05920849f, -0.04083764f, 
    -0.43528602f, 0.28955263f, 0.03244102f, 0.31477758f, -0.00395472f, -0.17291087f, 0.22121279f, -0.31198114f, 
    0.11537147f, -0.03255185f, 0.08998130f, 0.04676276f, 0.03551536f, -0.03371608f, 0.10375267f, 0.06273388f, 
    -0.08515885f, 0.04559506f, -0.43458235f, 0.02862565f, -0.00111223f, -0.58957791f, -0.08926495f, -0.38171428f, 
    -0.00392428f, 0.15606667f, -0.00692307f, -0.00883466f, -0.21134609f, -0.71866435f, -0.03919267f, -0.03796643f, 
    0.25645962f, -0.42211226f, 0.41514435f, -0.04922480f, -0.14216614f, -0.03405188f, 0.07083032f, -0.35167447f, 
    -0.11521584f, -0.27750891f, 0.37704301f, 0.06779616f, 0.05524096f, -0.01055853f, 0.04249870f, 0.21740966f, 
    -0.28821468f, 0.17988823f, 0.25371921f, -0.34200859f, -0.14341970f, -0.04390632f, -0.07595742f, -0.10411801f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.14497289f, -0.07648515f, 0.02686488f, 0.09799816f, 0.00306458f, -0.06346546f, 0.00643944f, -0.07497185f, 
    -0.10767680f, -0.03574450f, 0.21649672f, 0.02054962f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
