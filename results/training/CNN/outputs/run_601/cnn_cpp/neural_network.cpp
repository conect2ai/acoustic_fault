#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.55827314f, -0.11701763f, -0.19550397f, 0.71355844f, 0.01260470f, -0.40441748f, -0.35654929f, 0.43150508f, 
    -0.36670968f, -0.38199636f, -0.24756439f, -0.37774259f, -0.27893361f, -0.24088703f, 0.13345334f, 0.28472528f, 
    -0.09311790f, 0.29979181f, -0.11634853f, 0.22972983f, 0.39737257f, 0.21981338f, 0.38281947f, -0.21145986f, 
    -0.26429349f, -0.26178268f, -0.44856629f, -0.51855493f, -0.61217481f, -0.30293503f, -0.12633568f, -0.41929629f, 
    -0.22492830f, 0.09406978f, -0.00248709f, -0.44367427f, -0.18865176f, 0.36001223f, -0.10712951f, -0.29468501f, 
    0.35120952f, -0.00406633f, 0.04823928f, 0.06430437f, 0.46536967f, -0.07986816f, -0.10375434f, -0.03255005f, 
    0.22610365f, -0.12019338f, -0.92312741f, 0.27013344f, 0.53293622f, 0.76593429f, 0.07979946f, -0.48948595f, 
    0.12926173f, 0.52644610f, -0.08579858f, -0.39273280f, -0.09320355f, -0.18433809f, 0.13068809f, 0.40820640f, 
    0.21563922f, 0.13119313f, 0.29557118f, 0.07358794f, -0.15021671f, 0.34949443f, 0.14461820f, -0.07281480f, 
    -0.09393705f, -0.12418730f, -0.06083735f, -0.33919984f, -0.09410378f, 0.13334695f, 0.05596820f, -0.49460840f, 
    -0.48244026f, 0.87191504f, -0.66867536f, -0.68268150f, 0.11822219f, 0.24501872f, 0.49793643f, -0.04914423f, 
    0.20147383f, 0.10044567f, -0.09169792f, -0.37205434f, -0.02777985f, -0.03172528f, -0.36044312f, -0.10778099f, 
    0.08354142f, 0.53897482f, 0.04009469f, 0.08211140f, -0.10565699f, 0.29504234f, -0.06534782f, -0.16243851f, 
    -0.15604475f, -0.40888542f, -0.33195958f, -0.69777983f, -0.89335877f, -0.57631510f, -0.06155415f, 0.04873557f, 
    -0.07354358f, 0.33290026f, -0.54087335f, -0.15804604f, -0.30821839f, -0.21522476f, -0.14692493f, 0.12631352f, 
    -0.38349882f, 0.36710474f, 0.15851705f, 0.20873128f, -0.18882744f, 0.83441925f, 0.66373545f, -0.04910966f, 
    0.10823836f, -0.27132100f, -0.47493222f, 0.52937204f, -0.60955107f, 0.21699300f, 0.58310491f, 0.26830539f, 
    -0.30620271f, -0.18105194f, -0.18699366f, -0.22772501f, -0.12759887f, -0.20424107f, -0.08749077f, -0.14431433f, 
    -0.34974605f, -0.33808482f, 0.16143690f, -0.21136253f, -0.08908833f, 0.18888721f, -0.14637259f, -0.79901302f, 
    0.30561751f, 0.67715603f, -0.56862444f, 0.23564406f, 0.21850939f, 0.88389766f, -0.00143779f, -0.27222222f, 
    -0.12163717f, -0.58756560f, -0.50238895f, -0.28236759f, 0.04772434f, 0.07712235f, -0.00667403f, -0.29394835f, 
    -0.19137578f, 0.03710837f, -0.34212193f, 0.30904418f, 0.02239219f, 0.13477780f, -0.36290157f, -0.41260868f, 
    -0.32520640f, -0.65439582f, 0.55990601f, 0.37817580f, 0.51888490f, 0.39785501f, -0.09743102f, 0.11704445f, 
    -0.62102860f, 0.23037326f, 0.30807668f, 0.05605201f, -0.03918861f, 0.20429647f, 0.10203876f, -0.32588467f, 
    -0.14145792f, 0.46618408f, 0.16750328f, 0.24601457f, -0.05677459f, -0.05397619f, 0.38612294f, -0.06082350f, 
    0.88215554f, 0.40087661f, 0.64304250f, 0.73948658f, 0.57379210f, 0.40815613f, 0.34463441f, -0.27248815f, 
    -0.02554950f, 0.23311140f, -0.12926282f, 0.01392246f, -0.06054681f, -0.11198830f, -0.32541430f, -0.33661518f, 
    0.03304056f, 0.13087153f, 0.03635695f, -0.30007958f, 0.38261217f, 0.58011502f, 0.27685648f, -0.04796580f, 
    0.20319939f, 0.22071393f, 0.82383645f, 0.78796381f, -0.73491335f, -0.94919175f, -0.14726830f, -0.04800358f, 
    -0.11953875f, -0.52928782f, 0.11980918f, 0.40021935f, 0.43827325f, -0.26204973f, 0.13009334f, 0.10527980f, 
    0.15021886f, -0.07147071f, 0.09958209f, -0.00936719f, -0.11247916f, 0.26981294f, 0.24064590f, -0.26215786f, 
    0.10398291f, 0.30714872f, -0.53880757f, -0.79193521f, -0.83189720f, -0.59625608f, -0.25112700f, -0.41303536f, 
    0.75410175f, 0.66086125f, 0.09789146f, 0.61434186f, -0.14590149f, 0.11497488f, 0.25339463f, -0.28976402f, 
    -0.00917340f, -0.21932638f, 0.20845369f, -0.09597372f, 0.03528520f, -0.05493299f, -0.10664514f, -0.02317967f, 
    -0.08240080f, 0.03088787f, 0.25161186f, -0.62187910f, -0.48326704f, -0.39109659f, -0.23904231f, -0.14184991f, 
    -0.49596050f, -0.51298285f, -0.49109712f, -0.35622773f, 0.30583116f, 0.53467399f, 0.01512862f, 0.25315383f, 
    0.23981579f, 0.12130236f, 0.21347827f, 0.17220798f, -0.06648898f, 0.32333177f, 0.16478729f, -0.05946407f, 
    -0.04805184f, -0.06903841f, -0.25555572f, -0.02684931f, 0.53771764f, 0.23579702f, 0.76647931f, 0.83011335f, 
    -0.38509741f, 0.36931801f, -0.20768295f, -0.21369888f, 0.34427360f, 0.65587395f, 0.49498022f, -0.06243652f, 
    -0.40624413f, 0.20295042f, -0.16290396f, -0.07605965f, -0.10487548f, 0.38090628f, -0.36901897f, 0.14143521f, 
    -0.08632956f, 0.22928809f, 0.15244395f, -0.00442821f, -0.03390364f, -0.42314619f, -0.57653391f, -0.28968111f, 
    0.00353845f, -0.60983217f, -0.29780069f, -0.37334082f, -0.11218178f, -0.06352140f, -0.01623550f, 0.09109201f, 
    -0.21456528f, -0.09230196f, 0.54222727f, 0.04076267f, -0.58173436f, -0.45672956f, -0.26428711f, -0.51600266f, 
    0.25369701f, 0.09863741f, 0.07827642f, -0.38268644f, -0.30769825f, -0.20720364f, 0.71713120f, 0.34768525f, 
    0.33175635f, 0.11850711f, 0.84376979f, 0.18958130f, -0.75236535f, 0.00611895f, -0.31617942f, 0.10591786f, 
    0.21150023f, 0.25604507f, 0.10438751f, 0.16250801f, -0.00873086f, 0.29894140f, 0.07455915f, 0.05775060f, 
    0.35423672f, -0.18149066f, 0.51309890f, -0.01301575f, -0.14625745f, 0.16671433f, -0.08766445f, 0.40397546f, 
    0.59383607f, 0.47745302f, 0.40372822f, 0.28216806f, -0.52644289f, 0.17477749f, -0.23611061f, -0.29108387f, 
    -0.35531548f, -0.29893506f, -0.26940754f, 0.17452946f, 0.45300809f, -0.03911045f, -0.30119345f, 0.12212029f, 
    0.46110687f, 0.05263788f, -0.14663956f, -0.26475695f, -0.29042098f, -0.24233603f, -0.28336197f, -0.12910274f, 
    1.09704769f, 0.43888345f, -0.73107213f, -0.79342520f, -0.30823603f, -0.38433146f, -0.04605996f, 0.24869035f, 
    -0.24665466f, -0.10023757f, -0.01799659f, 0.37648624f, 0.40498045f, 0.04787926f, -0.23918234f, 0.17252195f, 
    -0.07266353f, -0.01463827f, 0.28640139f, 0.01371136f, 0.11247217f, 0.04198174f, 0.17397746f, 0.02430610f, 
    0.08105122f, -0.35972449f, -0.60680872f, 0.45874614f, 0.90180624f, 0.47926414f, -0.43155894f, -0.22156869f, 
    -0.09396326f, -0.64752507f, 0.09342179f, 0.60763979f, -0.12643497f, 0.14268182f, 0.26452807f, -0.30783412f, 
    -0.33986798f, 0.08214743f, 0.21378542f, -0.09873752f, -0.19186540f, -0.14004777f, -0.05395752f, 0.04345522f, 
    0.29220805f, -0.13452210f, 0.64108562f, -0.03013584f, -0.67721951f, -0.70581710f, -0.58499765f, 0.48576763f, 
    0.80957282f, -0.09620506f, 0.17658600f, 0.39773494f, -0.10893808f, -0.08600995f, -0.38204446f, 0.08512379f, 
    -0.19657218f, 0.01546423f, 0.13979219f, 0.17092793f, 0.10209107f, 0.04222698f, 0.16107188f, -0.06363969f, 
    -0.29905799f, -0.27404484f, 0.02378939f, 0.10139570f, -1.47999084f, -0.38014770f, 0.79312050f, 0.46451280f, 
    -0.64082932f, 0.77668744f, 0.24618083f, -0.10193285f, 0.13553509f, 0.33329514f, 0.15987612f, -0.39543566f, 
    0.11391480f, 0.20011918f, -0.12791455f, -0.06625380f, -0.07910815f, 0.14246899f, -0.20529178f, -0.00963487f, 
    0.09411054f, 0.02254619f, -0.09439293f, -0.14673880f, 0.25021580f, -0.33108237f, -0.73421043f, -0.58971804f, 
    -0.56048173f, 0.24902427f, 0.37455517f, -0.01215804f, -0.26028380f, 0.20211208f, -0.05742339f, 0.14230922f, 
    0.20247179f, 0.30796692f, -0.10756765f, -0.54287428f, -0.21079700f, -0.18858016f, 0.10663598f, -0.24995491f, 
    -0.11209840f, 0.32357413f, -0.12342930f, -0.03667646f, 0.20767477f, 0.83145148f, -0.21122266f, -0.39116579f, 
    -0.10129811f, 0.63851768f, 0.14223155f, -0.18813254f, -0.47354040f, 0.52137697f, -0.17704020f, -0.17796248f, 
    -0.08125462f, -0.01868263f, -0.08579391f, -0.04502549f, 0.12536761f, 0.15371576f, 0.25080740f, 0.39946929f, 
    0.30517459f, -0.08376815f, 0.11254527f, -0.46536246f, -0.29732797f, 0.14109682f, -0.61595249f, 0.52915990f, 
    -0.09670798f, -0.22602861f, 0.58590096f, -1.03177834f, 0.68431652f, -0.18196197f, -0.79076475f, -0.41219521f, 
    0.22503647f, 0.03596456f, 0.24972652f, -0.32337907f, 0.26468799f, 0.19210580f, 0.32749856f, 0.05863649f, 
    0.11801844f, -0.12434275f, 0.01496588f, 0.07373802f, -0.12002504f, 0.09579439f, 0.23464780f, -1.12512374f, 
    0.37765661f, -0.28687158f, -0.59906763f, -0.52182835f, 0.85226703f, 0.70127654f, 0.10651993f, 0.64379239f, 
    0.68891454f, 0.06954054f, -0.36649832f, -0.26545939f, -0.13079557f, -0.00560779f, 0.09956498f, 0.19847792f, 
    -0.13678984f, 0.00226138f, -0.17713661f, -0.15887634f, 0.00230705f, 0.19372627f, -0.11566038f, 0.03895491f, 
    1.12439167f, -0.14092898f, 0.54580855f, 0.16498147f, -0.38799259f, 0.45350012f, -0.62282610f, -0.36114091f, 
    -0.13545147f, -0.46056175f, 0.03021610f, -0.45679411f, 0.14566284f, 0.04050174f, -0.25016472f, -0.02101029f, 
    -0.04638344f, 0.01262180f, -0.23962863f, -0.01811328f, 0.18059172f, 0.12328290f, 0.34763747f, 0.16020957f, 
    0.13539328f, 0.50403023f, -0.57924974f, 0.48025087f, 0.57049912f, -0.19849084f, 0.59927976f, -0.44637913f, 
    -0.07164354f, -0.27978560f, -0.61651599f, -0.01837994f, -0.06132278f, 0.08940043f, 0.16305229f, 0.19607624f, 
    -0.38222322f, -0.02771307f, -0.30478179f, 0.21573941f, 0.24489143f, -0.00722315f, -0.03104926f, 0.01413920f, 
    -0.15960647f, 0.28028545f, -0.48091114f, -0.64102262f, -0.39832333f, -0.26650950f, 0.38945445f, -0.43073225f, 
    0.87033898f, 0.60690743f, -0.39962804f, 0.02113532f, -0.22374651f, -0.19669639f, -0.06274236f, 0.02908503f, 
    -0.27866143f, 0.05999731f, -0.11262499f, -0.15542684f, -0.09025621f, -0.11787740f, -0.06790999f, 0.02623485f, 
    0.02387127f, 0.00734424f, 0.03596967f, -0.51127011f, -0.39513767f, -0.08194822f, -0.30014011f, -0.40866038f, 
    -0.09407814f, -0.71652275f, 0.03216837f, 0.46446741f, -0.30942804f, -0.13929628f, -0.09243153f, 0.05519750f, 
    -0.20396452f, -0.47518516f, 0.17621517f, 0.24352314f, 0.05812316f, 0.06414192f, -0.52859354f, 0.14511108f, 
    0.18060863f, 0.40423557f, 0.26135513f, 0.35463059f, 0.44124976f, 0.11721618f, -0.57632571f, -0.95285672f, 
    -0.52409250f, 0.26905730f, -0.35902548f, -0.19947426f, 0.51115948f, -0.40821889f, -0.17620860f, 0.03635145f, 
    -0.51158416f, -0.19456261f, -0.06180071f, 0.20347731f, 0.41152444f, -0.29564333f, 0.03983109f, 0.14383535f, 
    0.10459262f, -0.08181115f, 0.15567270f, -0.04619730f, 0.14720447f, 0.83262986f, -0.08330888f, 0.38527840f, 
    0.96144891f, 0.77663058f, 0.67566484f, 0.35031751f, -0.03524027f, -0.34708270f, -0.23009640f, -0.09064543f, 
    0.05249353f, -0.25532961f, 0.28584245f, -0.08143535f, 0.25361803f, -0.02951357f, 0.19459446f, -0.01427682f, 
    -0.05995602f, -0.01976818f, -0.05101724f, 0.03719470f, 0.06336346f, 0.35870770f, 0.62489259f, 0.18438438f, 
    0.52067572f, 0.13200875f, 0.72227764f, -0.26456136f, -0.46279943f, -0.78414464f, -0.43918404f, 0.12677085f, 
    -0.01940870f, 0.43120825f, 0.09017266f, 0.12603913f, 0.06944577f, 0.04302955f, 0.16098520f, 0.08508888f, 
    0.01712819f, 0.48650622f, 0.11091338f, -0.09946354f, 0.00402339f, -0.03319385f, 0.10919826f, 0.44143602f, 
    0.77579260f, 0.00834772f, 0.40545169f, 0.68149078f, 0.12049409f, 0.18669605f, 0.03217177f, 0.68210012f, 
    0.28647950f, -0.06641527f, 0.24994688f, 0.19808188f, -0.59187794f, 0.06876866f, -0.40213841f, -0.11315039f, 
    -0.39612159f, -0.61530703f, 0.00333614f, -0.22201151f, 0.12147176f, 0.19875583f, 0.01202715f, -0.11159497f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.22715791f, -0.02152083f, 0.06537663f, 0.05919956f, 0.03574669f, 0.10813694f, 0.01329853f, 0.32454166f, 
    0.19930911f, 0.20463647f, 0.16320138f, 0.34386104f, 0.09074670f, 0.13894038f, 0.08333528f, -0.10259646f, 
    0.29647884f, 0.15281242f, 0.03013949f, 0.18928856f, 0.09855274f, 0.08872464f, 0.22481592f, -0.15327069f, 
    -0.02950198f, 0.11352448f, 0.09097945f, 0.13602051f, 0.29524010f, 0.28950408f, 0.14690709f, 0.10971863f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.03674811f, -0.05521265f, -0.04619533f, 0.03382072f, -0.02691049f, 0.04348164f, 0.03456527f, 0.02895076f, 
    0.03882588f, -0.02035201f, 0.01401907f, -0.02540437f, -0.05279938f, 0.00881081f, 0.03483352f, -0.00000696f, 
    -0.04882809f, -0.03553643f, -0.05159713f, 0.00104390f, -0.00579175f, 0.00652822f, -0.00590549f, -0.03681717f, 
    -0.00444906f, -0.05667689f, -0.02796346f, -0.02797809f, 0.03563355f, 0.04316446f, -0.05162303f, -0.02449693f, 
    0.01485140f, 0.01378409f, -0.04736383f, 0.02205918f, -0.02455433f, -0.05285963f, 0.00911570f, -0.00134824f, 
    0.03010541f, -0.03666760f, -0.04041563f, -0.05583886f, -0.00166409f, 0.00819615f, 0.02614628f, -0.02589756f, 
    -0.05454499f, -0.01242469f, 0.00712555f, -0.05160871f, -0.02892610f, 0.03673897f, -0.04893165f, 0.03053151f, 
    -0.02132824f, 0.01476175f, 0.03323540f, -0.03652480f, 0.01855817f, -0.04659064f, -0.00386174f, -0.05369700f, 
    0.00440771f, 0.01363026f, 0.03454151f, -0.02553716f, -0.02065049f, -0.03732894f, 0.00582877f, 0.01839010f, 
    0.01716233f, -0.02823038f, -0.01801779f, -0.00616008f, -0.01446074f, -0.03500649f, 0.03883050f, -0.00338628f, 
    0.01076354f, -0.03540527f, 0.02506118f, -0.04345519f, -0.05659125f, -0.03531132f, -0.05363622f, 0.01679046f, 
    0.02439666f, -0.02522604f, -0.01335459f, -0.00378252f, 0.00964075f, 0.03044037f, -0.02047200f, -0.01146567f, 
    0.01111911f, -0.04066877f, -0.03552810f, -0.04812000f, -0.01257018f, -0.02109360f, -0.03899918f, -0.02567946f, 
    0.02007754f, 0.01987994f, 0.02630404f, -0.03716510f, -0.03385339f, 0.02577229f, -0.01765723f, 0.01303096f, 
    0.02878313f, -0.04929395f, -0.01887907f, -0.04165800f, 0.02202968f, 0.04276391f, 0.02277322f, -0.03286458f, 
    -0.05154636f, -0.00473677f, 0.04461324f, -0.04557070f, 0.01752248f, -0.03082628f, -0.01847061f, 0.00586918f, 
    0.02722046f, -0.04072140f, 0.00264704f, 0.01096060f, -0.00955143f, -0.00597467f, 0.00184042f, -0.00566594f, 
    0.03788092f, 0.02093047f, 0.02553068f, -0.02456689f, 0.03807957f, -0.00697580f, 0.04120006f, 0.01748274f, 
    0.03933707f, -0.04755757f, -0.05145697f, 0.01092033f, 0.00344722f, -0.01063481f, -0.04845413f, -0.01372886f, 
    -0.00644702f, -0.04156933f, 0.01334053f, -0.05154042f, -0.01755781f, -0.01607293f, -0.04937302f, 0.01655705f, 
    -0.01362868f, 0.01974272f, -0.04728176f, -0.05606169f, 0.02910714f, 0.00618526f, -0.02583804f, -0.00409586f, 
    -0.04259753f, -0.04258110f, -0.02744890f, -0.01973890f, 0.00893131f, -0.01352358f, 0.01165977f, -0.04304333f, 
    -0.00734544f, -0.05154423f, 0.03180375f, 0.02738550f, -0.03302503f, 0.03698942f, 0.03594653f, -0.05539170f, 
    -0.02598761f, 0.03424808f, -0.01606826f, -0.03200547f, -0.05221567f, -0.03333480f, -0.05481591f, -0.03754769f, 
    -0.01780752f, -0.03508322f, 0.02720597f, -0.00356960f, -0.01361998f, -0.03847564f, -0.00252426f, -0.00543374f, 
    0.03467251f, -0.00414447f, -0.00138913f, -0.00409269f, -0.03000774f, 0.03980796f, 0.03695185f, 0.02043988f, 
    -0.04377124f, -0.03914788f, -0.00527200f, 0.02731410f, 0.01073557f, -0.03465503f, -0.03979909f, -0.03878299f, 
    0.01127189f, -0.02113876f, 0.00698358f, 0.04475342f, 0.04127556f, 0.01099980f, -0.05395731f, -0.02170801f, 
    -0.05610900f, -0.00529969f, -0.01971474f, 0.00384139f, 0.02113926f, -0.00792515f, 0.03459577f, -0.00926720f, 
    -0.05279684f, 0.03244766f, -0.02962948f, -0.02588827f, -0.04054524f, -0.00863271f, -0.00306880f, 0.00922762f, 
    -0.03230242f, -0.05291639f, 0.03520145f, -0.05179005f, 0.04138660f, -0.03039266f, 0.02222807f, -0.03952536f, 
    -0.03092610f, -0.05256769f, -0.05455380f, -0.01084391f, -0.00599953f, -0.05317335f, 0.00229889f, 0.01237685f, 
    -0.05524309f, -0.00832736f, 0.01811095f, 0.04317579f, -0.00808763f, 0.01153139f, 0.03440757f, -0.03436124f, 
    -0.03486517f, 0.03205616f, -0.03814457f, -0.04566858f, 0.03887301f, -0.04231512f, -0.02006630f, -0.04043403f, 
    -0.01862097f, 0.03534349f, -0.05303475f, -0.03222867f, -0.01552178f, 0.00309137f, -0.02204355f, -0.05157645f, 
    0.01839808f, 0.02676837f, -0.00728921f, 0.04446211f, 0.00187087f, 0.00236718f, -0.02773824f, -0.04972797f, 
    -0.02707416f, 0.00430598f, -0.01451491f, -0.00398387f, 0.00277690f, -0.02715076f, -0.00864393f, -0.03676739f, 
    0.01363800f, 0.00249310f, 0.03605283f, -0.03217412f, 0.03960065f, -0.02243965f, 0.00157839f, -0.00926898f, 
    0.00409434f, -0.02174691f, -0.03528036f, 0.01335572f, 0.02911193f, -0.04620417f, 0.00791385f, 0.03462989f, 
    0.02321195f, -0.04700298f, -0.03789538f, -0.02126759f, -0.04198010f, -0.05583441f, -0.00064539f, 0.01889737f, 
    -0.01244764f, -0.02767348f, 0.00821567f, -0.01360649f, -0.03098026f, 0.01791924f, -0.00868281f, 0.03014369f, 
    0.01046832f, 0.01996730f, 0.03855662f, 0.02065354f, 0.02322830f, 0.04110679f, -0.02268162f, -0.05309477f, 
    0.02894330f, -0.00533259f, -0.03044151f, 0.01655823f, -0.00844035f, 0.01940579f, -0.04913829f, 0.03344145f, 
    0.04192102f, 0.00069587f, 0.02576562f, 0.04171471f, 0.01445148f, -0.03369435f, 0.03119001f, 0.03277817f, 
    0.02287458f, -0.03954201f, 0.03513245f, -0.00505871f, 0.00584912f, -0.05218330f, 0.01360987f, 0.00731339f, 
    0.01032466f, 0.04207286f, 0.02405978f, 0.00515567f, 0.02149577f, -0.01047655f, 0.03213987f, -0.03650201f, 
    -0.02290521f, -0.01935876f, -0.02426378f, 0.01136750f, -0.01001676f, -0.05306394f, -0.03501681f, 0.01173658f, 
    0.03261648f, 0.04347706f, 0.03017436f, -0.04731201f, -0.05533710f, -0.03678530f, 0.02961743f, -0.04999941f, 
    0.30565766f, 0.18736298f, 0.03907115f, 0.22436841f, -0.11127830f, 0.19075452f, -0.09318549f, -0.08047679f, 
    -0.13439013f, -0.03930872f, 0.19487761f, 0.06970455f, 0.23633209f, 0.04457413f, -0.03598796f, -0.17958069f, 
    0.05872278f, 0.04746971f, 0.07084628f, 0.09175073f, -0.17854954f, 0.07692309f, 0.00403658f, 0.01979832f, 
    0.03821002f, 0.03268048f, 0.17401381f, 0.15304823f, 0.11664601f, -0.11502971f, 0.07901935f, 0.07961127f, 
    0.11027554f, 0.13665661f, 0.01239045f, -0.00420164f, 0.06258711f, -0.03614832f, 0.37413257f, 0.13179727f, 
    0.05497559f, 0.00353142f, 0.03871675f, 0.02821827f, 0.06612669f, 0.17197500f, 0.05601857f, -0.01688779f, 
    0.22989085f, 0.09448306f, 0.41389522f, 0.29411063f, 0.00464059f, -0.02096885f, -0.01737768f, 0.10909724f, 
    0.06288879f, -0.01732093f, -0.13963421f, 0.05044815f, -0.43557894f, -0.14710465f, -0.02616202f, 0.24016331f, 
    0.03431974f, 0.12387703f, -0.07633737f, -0.10103790f, 0.02383720f, -0.03698980f, -0.01011002f, -0.14340109f, 
    0.40639457f, 0.02371719f, 0.04264056f, 0.11661552f, -0.04855400f, 0.07010661f, 0.12230926f, -0.14220402f, 
    -0.04677531f, -0.11938034f, 0.06039332f, -0.00766400f, 0.02930886f, 0.01573198f, -0.12663788f, -0.06247538f, 
    0.03822804f, 0.02445552f, 0.18341891f, 0.05061713f, 0.12579629f, -0.00901251f, 0.08872374f, -0.01814860f, 
    -0.27576190f, -0.06831194f, -0.14824134f, -0.06287301f, -0.05418083f, -0.06690633f, -0.06329066f, -0.04936535f, 
    -0.17129710f, 0.16568662f, 0.07353410f, 0.08280738f, -0.45051312f, 0.19205239f, 0.14554408f, 0.23611379f, 
    0.14069685f, -0.01251146f, -0.01349678f, -0.04793517f, -0.15806730f, 0.01120065f, -0.10659500f, 0.08108415f, 
    0.06508368f, 0.17601630f, 0.02938175f, -0.46863312f, 0.08350815f, 0.10148951f, 0.03443890f, -0.10133824f, 
    0.07419048f, -0.00238906f, -0.03508174f, 0.07440142f, -0.09313627f, 0.12001712f, 0.03596303f, 0.13342164f, 
    0.15024307f, 0.02670583f, -0.04045809f, 0.03038185f, 0.01374517f, -0.12690146f, 0.05476733f, -0.03989193f, 
    -0.38693178f, -0.03580395f, -0.35142913f, 0.22367753f, -0.00663559f, -0.10204871f, -0.09093523f, -0.11632003f, 
    -0.02638630f, 0.10901666f, -0.00518926f, -0.00292441f, 0.03027304f, -0.02931011f, 0.09480138f, 0.27934542f, 
    -0.00190383f, -0.08740289f, -0.00411856f, -0.01468514f, -0.04455899f, -0.02083589f, 0.02168516f, 0.24436061f, 
    -0.10088949f, -0.14720498f, 0.07024038f, -0.31977427f, -0.03309827f, 0.07882867f, -0.03028590f, -0.04590736f, 
    0.00330767f, 0.01053803f, 0.17661051f, -0.03889373f, -0.05124906f, -0.04977775f, 0.13758035f, -0.09516222f, 
    -0.23688801f, -0.18796290f, 0.05802236f, 0.05324173f, -0.08513223f, 0.03073106f, 0.05471547f, -0.09160431f, 
    -0.28267449f, -0.25813413f, 0.23346707f, -0.04648431f, -0.03368136f, 0.02836397f, -0.16252507f, 0.10168860f, 
    0.00141480f, -0.01942765f, 0.05222728f, 0.02791184f, 0.23743539f, -0.04033337f, -0.05402103f, -0.02065664f, 
    -0.09214878f, -0.03590134f, 0.02324139f, -0.01365686f, 0.05028619f, -0.11004178f, -0.01411735f, 0.01172633f, 
    -0.08147405f, 0.21239071f, -0.16505574f, -0.13539118f, -0.02145959f, 0.06996806f, 0.00164399f, -0.06497423f, 
    -0.02329019f, 0.02207736f, 0.05001424f, 0.04810924f, 0.06521526f, 0.13025597f, 0.07929121f, 0.21407171f, 
    -0.08015391f, -0.02240962f, -0.04005177f, -0.03389760f, -0.09409922f, -0.00485434f, -0.08365282f, 0.00183762f, 
    0.02556842f, 0.12243079f, -0.10830075f, -0.07993472f, -0.12556003f, 0.07219508f, 0.08583658f, -0.06679464f, 
    0.03603633f, 0.05707386f, -0.07417714f, 0.02274015f, 0.02906697f, -0.03572402f, 0.14715727f, -0.13097666f, 
    0.03357962f, 0.02660706f, 0.15025963f, 0.06326949f, 0.16422579f, 0.05284556f, 0.10119268f, 0.21134496f, 
    -0.12261211f, -0.04802592f, 0.16304651f, 0.16713727f, 0.03418374f, -0.16033836f, -0.02095209f, 0.06809639f, 
    0.09047910f, 0.01500904f, -0.05997979f, 0.13879840f, 0.33003193f, 0.24680305f, 0.03614587f, -0.20287019f, 
    0.05815052f, 0.04165454f, 0.07192282f, -0.08824108f, 0.04955515f, -0.04210327f, 0.04486319f, 0.04041330f, 
    -0.02547060f, -0.19263673f, 0.07258068f, 0.02542555f, -0.01817835f, 0.06683111f, -0.01233078f, 0.00675657f, 
    -0.02888119f, 0.01725652f, -0.23849161f, 0.20949090f, 0.39268988f, 0.05693856f, -0.03496294f, 0.36524743f, 
    0.09637164f, 0.02358870f, 0.12677407f, -0.05286484f, -0.00559614f, -0.03327533f, -0.15332608f, 0.03583855f, 
    0.11752620f, 0.10638996f, 0.27611399f, 0.02526297f, 0.06478290f, 0.21538518f, -0.00653600f, 0.09833716f, 
    -0.01637043f, 0.13117804f, -0.03298586f, 0.02601393f, 0.13801479f, 0.26570749f, 0.14901471f, 0.12600999f, 
    0.16510114f, 0.12824735f, 0.09594311f, -0.02260110f, -0.03068534f, 0.05618726f, 0.04743065f, -0.11980886f, 
    0.09476275f, 0.14201137f, 0.03661147f, -0.19293302f, 0.06446870f, 0.07619878f, -0.01491276f, -0.06552113f, 
    -0.00075910f, 0.03346680f, -0.01602856f, 0.01919037f, -0.35918918f, 0.17287767f, -0.21148108f, 0.08328353f, 
    -0.18021439f, -0.13559000f, 0.08863387f, -0.02568378f, -0.02644063f, 0.08286813f, 0.04149308f, -0.08928649f, 
    0.07660668f, -0.06981182f, 0.09653472f, -0.31765196f, -0.08656809f, -0.13051432f, 0.06509706f, 0.03755170f, 
    -0.00543789f, 0.03529750f, 0.00376318f, 0.08329278f, -0.36811018f, 0.02780481f, -0.08105437f, -0.28355891f, 
    -0.04963857f, -0.10111516f, -0.11150581f, -0.00713003f, -0.02074262f, -0.02204665f, -0.04941420f, 0.10177193f, 
    -0.03465261f, -0.03354208f, -0.05162483f, -0.02408408f, 0.01879637f, 0.03338155f, 0.00645733f, 0.00028523f, 
    0.03707452f, 0.03160517f, -0.01530544f, -0.01374422f, -0.00104736f, 0.04802096f, 0.03887745f, 0.03863365f, 
    -0.03483562f, -0.00706307f, -0.00057205f, -0.02290093f, 0.01397934f, -0.00723978f, 0.03529159f, 0.03876138f, 
    -0.03499654f, -0.00884921f, 0.01506248f, 0.03011811f, 0.04133731f, 0.00230357f, 0.03793109f, -0.00832161f, 
    -0.01572992f, 0.01822571f, -0.00672158f, -0.03322649f, -0.00538414f, -0.01987945f, 0.01481062f, -0.04033612f, 
    -0.04652081f, -0.02721000f, -0.00345757f, 0.01684959f, -0.01254024f, -0.01764570f, 0.00376043f, -0.04457686f, 
    0.03715649f, 0.00963237f, -0.05432328f, -0.00220362f, -0.03200034f, 0.03231395f, -0.04113497f, -0.02930521f, 
    0.02758761f, -0.02729379f, -0.00907040f, -0.04610765f, 0.00927218f, -0.02688178f, -0.04493570f, 0.03118537f, 
    -0.02940631f, -0.00857228f, 0.01730360f, 0.00098130f, -0.05629312f, -0.00416774f, 0.02183499f, 0.01398799f, 
    0.02702138f, -0.00394607f, -0.01606968f, -0.04065485f, 0.00883998f, -0.04810752f, -0.06280715f, -0.03924918f, 
    0.02448877f, 0.01831041f, 0.02577147f, 0.01701761f, 0.01602703f, 0.02012210f, 0.04131465f, -0.00588134f, 
    -0.01780526f, -0.03443385f, 0.02698265f, -0.03293005f, -0.01043686f, -0.05919580f, 0.01099223f, -0.04940651f, 
    -0.00641293f, 0.02865789f, -0.03098626f, 0.00308907f, -0.01601341f, -0.02236644f, -0.03373171f, 0.03955157f, 
    0.01384834f, 0.02486622f, -0.02456465f, -0.01294083f, -0.01752764f, 0.00661894f, -0.01471063f, 0.01874654f, 
    -0.00448841f, 0.01171081f, -0.03937359f, 0.03590840f, -0.01239688f, 0.00400714f, -0.03295634f, -0.02612612f, 
    -0.01417788f, -0.02064736f, -0.01844088f, 0.00491303f, -0.00298110f, 0.00313418f, 0.03142587f, 0.02305165f, 
    -0.00502109f, 0.00501984f, 0.00009268f, -0.00858471f, 0.01191769f, 0.02538314f, -0.00283331f, 0.03680631f, 
    -0.02033487f, -0.01272992f, -0.04627297f, -0.04467333f, 0.01716691f, -0.05192290f, -0.00807770f, 0.02322460f, 
    0.00975572f, -0.04408808f, 0.02051813f, 0.00913307f, -0.03071264f, -0.02251780f, 0.01070645f, 0.00798958f, 
    -0.01085250f, 0.00623030f, 0.00424403f, -0.02839891f, 0.04313054f, -0.01256359f, -0.00682343f, 0.01199253f, 
    0.01998329f, 0.00004112f, -0.00623478f, -0.00593150f, 0.03424176f, 0.01433761f, 0.02478791f, 0.03961907f, 
    -0.00000235f, -0.03504684f, -0.03821801f, 0.03079903f, -0.02279244f, 0.02545228f, -0.05174293f, -0.05696016f, 
    -0.01608513f, -0.03656076f, -0.06129305f, 0.01249968f, -0.00785344f, 0.03112670f, 0.01936322f, -0.00884884f, 
    -0.02347126f, 0.03231699f, -0.03214376f, 0.00734995f, 0.03747096f, -0.01026187f, -0.00865652f, 0.03301861f, 
    0.03181343f, -0.01446974f, -0.03890131f, -0.00558506f, -0.03602824f, 0.03851314f, -0.04037159f, -0.04508916f, 
    -0.01813693f, 0.00123972f, 0.03685978f, -0.03882007f, 0.03337183f, -0.05441840f, 0.02163541f, 0.00759751f, 
    -0.03294621f, 0.00799661f, -0.04070059f, 0.03759355f, 0.01354184f, 0.00532183f, 0.03224935f, -0.02806357f, 
    0.00225318f, 0.00736930f, 0.02632556f, 0.03141163f, -0.02223194f, 0.03793474f, -0.00200674f, -0.00282362f, 
    -0.01281398f, -0.01765001f, -0.02149636f, -0.02619182f, -0.00682683f, -0.02546414f, -0.04275956f, -0.03866061f, 
    0.00865872f, -0.01396520f, 0.00556183f, -0.03730880f, -0.00037194f, -0.00490932f, 0.01556918f, -0.03103586f, 
    0.04986659f, -0.04287458f, -0.02612769f, -0.04633656f, -0.01848613f, 0.03407530f, 0.03462595f, 0.01952112f, 
    -0.01237151f, -0.01273353f, -0.04649587f, -0.04403893f, -0.03604282f, 0.02316257f, -0.00543461f, -0.05126086f, 
    -0.02955387f, 0.03974382f, 0.00202416f, 0.00239510f, 0.02233958f, -0.00382331f, -0.01565791f, 0.02061805f, 
    -0.04566320f, -0.03920409f, 0.01074600f, 0.02397619f, -0.03031836f, 0.00621264f, -0.04448557f, 0.00303219f, 
    -0.05087926f, 0.02075707f, -0.03241770f, -0.05282774f, 0.01784085f, 0.00558477f, 0.03046001f, 0.03373186f, 
    -0.00119294f, -0.00656268f, -0.00625931f, -0.02317048f, -0.04795415f, -0.02362304f, 0.00778982f, -0.00666616f, 
    0.02419789f, -0.02670909f, -0.05504423f, -0.00176755f, 0.01860380f, 0.03189895f, 0.00058280f, 0.01994943f, 
    -0.00041773f, -0.01405991f, 0.00943359f, 0.01289121f, 0.02812023f, -0.06243619f, 0.03739922f, 0.03906178f, 
    0.00542092f, 0.01048538f, 0.04162679f, -0.04119669f, 0.00614563f, -0.00209117f, -0.02191984f, 0.03737634f, 
    0.02238755f, -0.00160149f, -0.00610100f, -0.01029827f, 0.02982749f, -0.03567374f, -0.01920299f, -0.02863421f, 
    -0.01437701f, -0.03192250f, 0.02916172f, -0.04943534f, -0.02055113f, 0.02682877f, 0.00089471f, 0.02056133f, 
    0.01847505f, 0.02748039f, -0.01990493f, -0.00852934f, 0.02347055f, -0.01306666f, 0.02701479f, -0.04857434f, 
    0.04559153f, 0.04647444f, -0.00205666f, 0.02582037f, -0.05406271f, 0.00610958f, -0.04250266f, 0.02830437f, 
    -0.04366080f, -0.04832270f, 0.04289083f, -0.03393084f, -0.01678543f, 0.01618551f, -0.01133376f, 0.00496461f, 
    0.02619041f, -0.03282890f, 0.02241719f, 0.01232060f, 0.01340239f, -0.02362109f, -0.01839813f, -0.00815015f, 
    -0.01972826f, -0.05358866f, 0.00869558f, -0.00625176f, 0.00500754f, 0.00709673f, -0.02916533f, -0.03054630f, 
    0.00207687f, 0.00481825f, -0.05215512f, -0.02554257f, -0.04473199f, -0.03560448f, 0.03439209f, -0.03378212f, 
    -0.02216885f, 0.00688031f, -0.04975605f, 0.03901811f, -0.01951872f, 0.00628889f, -0.01881775f, -0.01743077f, 
    0.02301108f, -0.00346624f, 0.02827150f, 0.01472780f, 0.03287407f, -0.03030314f, -0.02461210f, -0.04986257f, 
    -0.00076286f, 0.02856012f, -0.02731249f, -0.04828498f, -0.04988199f, -0.02697548f, 0.02603062f, -0.04949475f, 
    0.03149483f, 0.01390720f, -0.03167076f, -0.02933223f, 0.01704228f, 0.02492900f, -0.05474225f, -0.04894066f, 
    -0.05562303f, 0.03554009f, 0.03855662f, 0.04423031f, -0.03242406f, -0.01874162f, -0.03186264f, -0.00993718f, 
    0.00548951f, -0.04821573f, 0.00584974f, 0.01330954f, -0.01986426f, -0.04732934f, -0.04448947f, -0.02093228f, 
    -0.04514532f, -0.01909394f, 0.03701887f, -0.03890727f, -0.02343814f, -0.00673673f, 0.02156881f, -0.04673345f, 
    -0.03057245f, -0.03481294f, -0.04500338f, 0.00348141f, 0.03920389f, -0.00396039f, -0.00015870f, 0.04317586f, 
    -0.01214359f, 0.02981638f, 0.00592668f, -0.04639488f, -0.00811461f, 0.00280243f, -0.01512639f, -0.03465444f, 
    0.02408110f, -0.03900824f, -0.01286994f, -0.02184945f, -0.00684624f, -0.00210032f, 0.02631455f, 0.04417388f, 
    -0.01079221f, -0.03868112f, -0.00106925f, 0.01753510f, 0.04043216f, -0.01218903f, -0.01767573f, 0.03400318f, 
    -0.04976910f, -0.05627855f, 0.01351922f, -0.01593636f, -0.02204959f, 0.00119101f, 0.02218748f, 0.01468941f, 
    -0.01541695f, -0.03621591f, -0.05076684f, 0.00614866f, -0.05283953f, -0.01062489f, -0.01737435f, 0.00620031f, 
    -0.00159588f, -0.04996043f, 0.00147514f, -0.03530046f, -0.04699400f, 0.02520685f, 0.02370260f, 0.00199795f, 
    0.02765046f, -0.00404747f, -0.01393391f, -0.05474605f, -0.02693403f, 0.00886404f, -0.00304917f, -0.02739009f, 
    0.01586794f, 0.04316312f, 0.01615643f, 0.01713107f, 0.02128152f, 0.01472214f, 0.01049097f, -0.03934458f, 
    -0.01193302f, -0.03904532f, -0.00167227f, -0.00517275f, 0.02913951f, -0.02517570f, 0.02477041f, -0.00897278f, 
    0.00027142f, -0.04963318f, 0.03034565f, -0.00601460f, -0.01434903f, -0.02661372f, -0.04343311f, -0.04232672f, 
    0.01264610f, 0.02617326f, 0.00847556f, -0.01517989f, 0.03798844f, 0.00307506f, 0.03444696f, -0.01030053f, 
    -0.04092409f, 0.03621539f, -0.05190205f, -0.01512728f, 0.03059467f, 0.01803747f, -0.01568084f, 0.01368627f, 
    0.01290199f, -0.01659982f, -0.00003902f, -0.01571131f, -0.04557139f, -0.04514340f, 0.03869575f, 0.03677311f, 
    0.00685255f, 0.02967566f, 0.04133485f, -0.02426150f, -0.05532553f, 0.00777058f, 0.03208760f, -0.03717115f, 
    -0.00601346f, -0.01700192f, -0.00949583f, -0.03268692f, -0.04576234f, -0.03237113f, -0.03054940f, -0.02749060f, 
    -0.03533500f, -0.03210393f, 0.03502923f, 0.02007206f, 0.00551506f, -0.02533313f, -0.03468546f, 0.02471892f, 
    0.02562164f, 0.03759626f, 0.02625011f, -0.04624949f, -0.03955330f, -0.04755424f, -0.02750439f, 0.02718413f, 
    0.01416693f, -0.00938950f, 0.03524318f, -0.03250788f, 0.01408134f, -0.05700937f, -0.05226418f, -0.01292551f, 
    -0.03206071f, -0.02045339f, -0.02160537f, 0.03475172f, -0.02015994f, 0.00249794f, -0.00926085f, 0.03179941f, 
    -0.03588574f, 0.04116159f, 0.03571286f, 0.01363345f, 0.00563561f, 0.02179457f, 0.00026764f, 0.01712895f, 
    -0.04237900f, -0.04225381f, -0.04171989f, 0.04292726f, -0.02824811f, -0.00451510f, -0.02660151f, -0.02933503f, 
    -0.04312519f, 0.02954604f, -0.01724859f, 0.00968248f, -0.04208967f, -0.05081742f, -0.02613219f, 0.03737976f, 
    -0.02095045f, -0.02123087f, -0.01535760f, 0.03112595f, -0.04346818f, 0.01346650f, 0.02626746f, -0.04197652f, 
    0.04345796f, -0.00354866f, -0.00278269f, -0.00024283f, -0.05434471f, 0.00300179f, -0.00060765f, 0.02107192f, 
    -0.02358711f, 0.02402706f, 0.00000214f, -0.02513378f, 0.03533820f, 0.01124797f, -0.01357238f, 0.03590376f, 
    -0.00919141f, -0.05363987f, 0.00547888f, 0.03061476f, -0.02020763f, -0.03048604f, 0.01809232f, 0.04006748f, 
    -0.02870195f, 0.02178260f, -0.01238142f, 0.04120796f, 0.00733717f, -0.00501649f, -0.03771224f, -0.03827341f, 
    -0.01896916f, -0.04635984f, -0.01158885f, 0.03960020f, -0.05040101f, -0.01871731f, -0.03789950f, 0.00069333f, 
    -0.02655299f, -0.03097230f, -0.04647569f, -0.00984503f, -0.02415179f, 0.00863711f, 0.03417358f, 0.03565621f, 
    -0.02821518f, 0.00315810f, -0.02071612f, 0.03637655f, -0.03570377f, 0.04049039f, -0.02587168f, 0.03333439f, 
    -0.01670191f, -0.00376724f, 0.02600773f, 0.02576674f, -0.05021977f, -0.02720206f, 0.01611910f, -0.04653534f, 
    -0.00399848f, 0.02233070f, -0.01732497f, -0.03711020f, -0.03562293f, -0.03057247f, 0.00454418f, 0.01076857f, 
    -0.01072600f, -0.04198332f, 0.04498477f, -0.03759889f, -0.00379624f, -0.05077658f, 0.03624253f, -0.04393621f, 
    0.01125861f, -0.02272176f, -0.00237175f, 0.00468200f, -0.04964549f, -0.01996587f, -0.00277366f, -0.02880556f, 
    0.03397128f, 0.03460956f, -0.01103306f, 0.02577252f, -0.00336054f, -0.03882378f, -0.01266157f, 0.03823333f, 
    0.02140688f, -0.04917713f, -0.03436888f, 0.02715915f, -0.02192975f, 0.02471429f, -0.00706512f, -0.05188544f, 
    -0.01331878f, -0.03407111f, 0.03326878f, 0.04148443f, -0.02334974f, -0.01463675f, 0.00395097f, -0.05045644f, 
    -0.02377397f, 0.03609341f, -0.04632607f, -0.05126118f, 0.01161885f, -0.01421715f, 0.02379687f, -0.03179817f, 
    -0.04091487f, 0.03947391f, -0.01947461f, 0.00730062f, 0.01180611f, -0.03865623f, -0.03456389f, 0.02410051f, 
    0.04432016f, -0.05469649f, -0.01445652f, -0.01221154f, -0.04299417f, 0.03981839f, -0.02690468f, 0.00918003f, 
    -0.01508352f, -0.04782263f, -0.02834605f, 0.00573771f, 0.04076770f, -0.01780888f, -0.05590435f, 0.00109353f, 
    -0.17495461f, -0.18956088f, -0.03505784f, -0.01763528f, 0.03490598f, -0.01891232f, 0.05699974f, 0.08231834f, 
    0.01537545f, 0.01627539f, 0.01655206f, 0.15113531f, -0.06085140f, -0.01666939f, -0.01749908f, -0.33435920f, 
    -0.06605687f, 0.03945338f, -0.01717676f, -0.17912996f, -0.07219318f, -0.10653748f, -0.01583672f, -0.01417947f, 
    -0.39065394f, 0.10015211f, 0.15636376f, 0.01826204f, 0.05240870f, -0.13630968f, -0.16301811f, 0.09651176f, 
    0.02449928f, 0.13685463f, 0.08504860f, 0.06172336f, -0.04939656f, 0.05843791f, -0.19782947f, 0.14895357f, 
    -0.07355749f, 0.03766258f, 0.01621833f, -0.02009326f, 0.06711406f, 0.04988851f, 0.10939376f, 0.03659925f, 
    0.24689621f, 0.21776816f, -0.02792808f, 0.08725989f, 0.13930254f, 0.05567206f, -0.02467406f, 0.19351618f, 
    0.02189204f, 0.04362571f, -0.05623314f, -0.03349398f, 0.19313680f, -0.16150136f, -0.31970990f, 0.16189097f, 
    0.06093541f, 0.05209845f, 0.02663378f, -0.18005767f, 0.03348390f, -0.10490303f, -0.07903219f, -0.13085707f, 
    -0.07924317f, -0.05955898f, 0.00043335f, 0.06614018f, -0.01849378f, -0.17266279f, 0.16923806f, -0.17670186f, 
    0.04073154f, 0.05670517f, -0.03367031f, -0.10960794f, 0.13085419f, 0.09635973f, 0.01700210f, 0.08529240f, 
    0.00064081f, -0.13062918f, -0.01588182f, -0.07942594f, -0.01685168f, 0.05067144f, 0.20605282f, 0.21181671f, 
    0.14959970f, -0.26748344f, -0.13762228f, 0.04747705f, 0.01041222f, -0.00769713f, 0.07111970f, -0.04661461f, 
    0.06893495f, 0.02977053f, 0.11301802f, -0.07980858f, -0.04597141f, 0.51361203f, -0.18331237f, 0.08761688f, 
    0.06205414f, 0.06651714f, -0.08394065f, 0.09811933f, 0.09737641f, 0.15353760f, 0.07374451f, 0.22081394f, 
    0.16327184f, -0.00709358f, -0.10686441f, -0.26345646f, 0.01666448f, 0.01629250f, 0.04523630f, -0.09794243f, 
    0.08977909f, 0.00297165f, -0.00729640f, -0.00827267f, -0.00872231f, 0.19427635f, -0.13982257f, -0.08327389f, 
    0.01046013f, 0.00166787f, 0.03410229f, 0.14053638f, -0.07676995f, 0.10517973f, 0.00492097f, 0.18479131f, 
    -0.02918739f, -0.20968683f, -0.17566046f, 0.25363272f, 0.25062507f, -0.17099522f, 0.00503708f, -0.11224204f, 
    0.03740041f, 0.05161688f, 0.18446419f, 0.02959882f, -0.00310149f, -0.23238619f, 0.00698120f, 0.02351004f, 
    0.04710467f, 0.04065071f, -0.04276414f, 0.14845289f, -0.04726127f, 0.08034161f, 0.25868186f, -0.06324400f, 
    0.39135301f, -0.17827602f, 0.08949645f, 0.07040217f, -0.02937830f, 0.01414612f, 0.07123996f, 0.02716995f, 
    0.11470558f, 0.06053477f, 0.08731269f, 0.26299468f, 0.05718478f, -0.10322216f, -0.15665114f, -0.00650587f, 
    -0.06167603f, -0.08687669f, -0.07786879f, -0.09055097f, -0.06321272f, -0.13613269f, 0.26112866f, -0.06128151f, 
    -0.03705656f, 0.05990885f, 0.05867399f, 0.00032622f, 0.17840968f, -0.04670033f, -0.03416349f, 0.13121812f, 
    0.09535695f, -0.00267966f, 0.11701202f, 0.22223356f, -0.06485692f, -0.04664968f, 0.11913825f, 0.03120058f, 
    0.18266968f, 0.03324645f, 0.12106390f, -0.02716267f, -0.13817902f, -0.00464426f, 0.18073812f, 0.00715513f, 
    0.44264027f, -0.03925078f, -0.29037708f, -0.27295417f, -0.03033198f, 0.00369009f, -0.09628110f, -0.02805040f, 
    0.03320071f, -0.04793116f, -0.04962885f, 0.02359727f, -0.10076643f, -0.05443446f, -0.00938097f, 0.18051374f, 
    0.03796934f, -0.12752855f, 0.05239733f, -0.01746843f, 0.01695886f, -0.06856158f, 0.05402119f, -0.05938505f, 
    0.26239327f, -0.12380328f, -0.26930958f, -0.16215166f, -0.01098962f, -0.08132818f, -0.09028818f, 0.07453796f, 
    0.13157481f, 0.02089369f, 0.08709121f, 0.03147404f, -0.11409502f, -0.28547040f, 0.39308345f, -0.01075146f, 
    0.07120807f, -0.02283742f, -0.11331192f, -0.03811984f, 0.09441540f, 0.15899493f, 0.17970721f, 0.10191531f, 
    -0.21227878f, 0.21355976f, -0.08136404f, -0.03523048f, 0.00485541f, 0.14785722f, 0.07900498f, 0.05295925f, 
    -0.04576067f, 0.03820331f, 0.04370080f, 0.18643050f, -0.15929827f, 0.04439490f, -0.08875135f, -0.27592793f, 
    -0.10325803f, -0.01234756f, 0.05583642f, -0.12163477f, 0.16849893f, -0.02918793f, -0.17633270f, -0.07055186f, 
    0.05199873f, -0.17083754f, 0.00493663f, 0.11495586f, 0.13176602f, 0.00657725f, 0.18238109f, 0.05744382f, 
    0.07498915f, -0.04739665f, -0.14665325f, 0.05080238f, 0.16000353f, -0.23814817f, 0.08255582f, 0.32940924f, 
    -0.05668629f, 0.07649004f, -0.08580647f, -0.01062025f, 0.11335507f, 0.20090669f, -0.07286165f, 0.14573136f, 
    -0.00107797f, 0.23101796f, 0.02442230f, -0.13950612f, 0.10527214f, -0.05465554f, -0.01872419f, -0.10587552f, 
    0.07908542f, 0.06422220f, -0.11693667f, -0.11931241f, -0.13440736f, -0.01987352f, 0.24764349f, -0.08991203f, 
    -0.02120833f, 0.01212618f, 0.17856906f, 0.00894344f, 0.13834667f, -0.13767651f, 0.04834775f, 0.04933632f, 
    -0.00618361f, -0.26740035f, 0.37005770f, -0.38832062f, 0.02692370f, 0.18313439f, -0.09287055f, -0.11815838f, 
    0.13979998f, 0.10387605f, -0.22027518f, -0.06345971f, -0.11473819f, -0.25248042f, 0.07289986f, 0.33613202f, 
    -0.15160657f, 0.07091780f, -0.09539746f, -0.03351289f, 0.11442359f, -0.00025613f, 0.12756540f, 0.19521584f, 
    0.35449737f, -0.10737850f, -0.11072843f, 0.02074448f, -0.01567790f, 0.06569885f, 0.12890829f, -0.01508209f, 
    -0.03567692f, 0.10716609f, 0.04091160f, 0.15158735f, 0.01622045f, -0.14546345f, -0.13355900f, -0.09301288f, 
    0.08540596f, -0.09566206f, 0.02974503f, -0.06708997f, 0.12525915f, -0.04378496f, -0.10327198f, -0.07425940f, 
    0.02640756f, -0.05199967f, -0.02634609f, -0.04138963f, -0.04119456f, 0.00247487f, 0.03214493f, 0.02548058f, 
    -0.02837054f, 0.01394759f, 0.00490854f, 0.00237214f, 0.00211916f, -0.03656370f, 0.00720045f, -0.01661417f, 
    -0.00269689f, -0.05950123f, -0.04304157f, -0.07338311f, -0.05994643f, -0.01792500f, 0.03170281f, 0.04112679f, 
    0.00652247f, -0.03380150f, 0.02495008f, -0.00075195f, -0.01958495f, -0.01446078f, -0.00557519f, -0.05393097f, 
    -0.03084639f, -0.03702587f, 0.02799107f, -0.05521243f, 0.02532974f, -0.01301155f, 0.01130978f, 0.00681989f, 
    0.01197616f, -0.02185968f, -0.06386744f, -0.01714696f, -0.03908058f, 0.01296635f, -0.06192426f, 0.02932326f, 
    0.00538618f, 0.01028975f, 0.00690383f, 0.02327109f, 0.01699792f, -0.00777727f, -0.00887338f, -0.02278857f, 
    -0.05679060f, -0.03283952f, -0.01199290f, -0.01966792f, -0.02368820f, -0.03519686f, -0.04095909f, -0.05770629f, 
    -0.01925482f, 0.01014785f, -0.02257005f, -0.03381502f, 0.02820941f, -0.03882833f, 0.00782159f, -0.05562118f, 
    0.01127626f, -0.00217778f, -0.02939161f, -0.00117481f, 0.01638472f, -0.02313052f, -0.03143610f, -0.02387148f, 
    0.02726439f, 0.01918900f, -0.04741488f, -0.01308649f, -0.03486470f, -0.04283380f, 0.03820447f, -0.03033004f, 
    -0.01171019f, -0.03214099f, -0.00211507f, -0.04253905f, 0.00853533f, -0.02730098f, -0.05126257f, -0.01395389f, 
    0.00357634f, -0.01955392f, -0.02936885f, -0.03440683f, -0.03434573f, 0.02447608f, -0.03325534f, -0.04257815f, 
    -0.00313352f, -0.02253429f, 0.03209499f, 0.02915201f, 0.01244814f, 0.00227221f, -0.03210096f, -0.06336090f, 
    -0.04637820f, -0.04178499f, 0.00799048f, -0.00120644f, -0.06327386f, 0.03768893f, -0.00395272f, -0.02164905f, 
    -0.04268480f, 0.02969693f, 0.01254757f, -0.05006163f, 0.03571699f, -0.03620955f, 0.00361613f, 0.00934147f, 
    -0.06952952f, -0.02440169f, 0.03305684f, -0.04729857f, -0.00660821f, -0.05051520f, -0.01138449f, -0.04682981f, 
    -0.01429751f, 0.01853480f, -0.03999861f, -0.04256339f, -0.03966106f, 0.03494066f, -0.05308633f, -0.00577917f, 
    -0.01219914f, -0.03866079f, -0.06718993f, -0.06508179f, -0.05991728f, -0.02823807f, -0.06492169f, -0.00422264f, 
    -0.04439874f, 0.03294732f, 0.03487991f, -0.05923935f, 0.01115387f, -0.01331200f, 0.02897801f, -0.04019431f, 
    0.01641325f, -0.03832551f, -0.00167777f, -0.03480347f, -0.03565348f, 0.03857793f, 0.00752269f, -0.02878139f, 
    0.03109788f, 0.00961566f, 0.02235719f, -0.00501986f, -0.01042002f, 0.04048578f, 0.03309534f, -0.05047938f, 
    -0.01482613f, -0.05520199f, -0.03099624f, -0.04276333f, -0.05161012f, -0.07053911f, -0.06513869f, -0.03777844f, 
    -0.00100263f, -0.05513939f, -0.00882507f, 0.01021769f, -0.03602103f, -0.02207789f, 0.03638514f, 0.01976641f, 
    0.00950655f, 0.01422117f, -0.04537753f, -0.03287534f, -0.01056415f, -0.02753950f, 0.02528534f, -0.00086223f, 
    -0.05012127f, 0.00023327f, -0.02712072f, 0.00937639f, -0.01318814f, -0.02689813f, -0.05348726f, -0.02434542f, 
    -0.07000989f, 0.00733906f, -0.04286978f, -0.03778236f, 0.02792402f, -0.00802093f, -0.00975143f, -0.02634596f, 
    -0.05107043f, -0.00755690f, -0.01973180f, -0.02773096f, -0.00986404f, 0.01637869f, 0.00527545f, 0.03685715f, 
    -0.04656474f, -0.06969787f, -0.00743453f, -0.05287534f, 0.01769706f, -0.02976412f, -0.01300561f, 0.00846584f, 
    -0.00647205f, -0.02790184f, -0.00904392f, -0.00655295f, -0.02881807f, 0.04238044f, -0.03636488f, 0.03093231f, 
    0.01225080f, -0.02823632f, -0.00807427f, -0.01920970f, 0.00647558f, 0.03346349f, -0.01914516f, 0.00434255f, 
    -0.04225913f, 0.00800270f, -0.02853053f, -0.02670628f, -0.04810749f, -0.01511738f, -0.00785881f, 0.00614977f, 
    0.00686541f, -0.04415666f, -0.04780796f, -0.05810127f, 0.03529065f, 0.00447583f, -0.02163603f, 0.00970453f, 
    -0.01407415f, 0.04067673f, -0.01737467f, -0.01595606f, 0.02672062f, -0.07110706f, -0.02621358f, 0.00136705f, 
    -0.04124863f, -0.05967676f, -0.03012587f, -0.03003197f, -0.05055147f, -0.00678421f, -0.03695228f, -0.02328151f, 
    0.00474233f, -0.05202202f, 0.00855079f, 0.03735641f, -0.02859765f, -0.00795538f, -0.05857768f, 0.00862734f, 
    -0.03966988f, -0.00888705f, -0.00494699f, 0.01828669f, -0.00295863f, 0.02514302f, 0.01039504f, -0.04011368f, 
    -0.02783005f, 0.01168247f, -0.04386742f, -0.02123869f, -0.04384039f, 0.00262010f, -0.04348975f, -0.01858753f, 
    0.02886704f, 0.01281770f, 0.03876938f, -0.00157130f, 0.02118029f, 0.02560408f, 0.02772209f, 0.02060383f, 
    -0.00243207f, -0.02508556f, -0.04187710f, -0.01514684f, -0.00797223f, -0.00334560f, 0.00366105f, -0.00855209f, 
    0.02670761f, 0.00783113f, -0.00393399f, -0.04317518f, 0.00561691f, -0.01357621f, 0.02549334f, 0.01660823f, 
    0.02917299f, 0.01940179f, 0.02097024f, 0.02701609f, 0.01455100f, -0.03972170f, 0.01323101f, -0.03357161f, 
    0.02436447f, 0.02611512f, 0.02380975f, -0.02434969f, -0.05943869f, -0.04737671f, -0.01187839f, 0.01201046f, 
    0.03190340f, -0.00688103f, -0.00408956f, -0.00852486f, -0.02094875f, 0.00939613f, -0.04521387f, -0.03589433f, 
    -0.01872657f, 0.00045626f, -0.00620707f, 0.01651482f, -0.01529793f, -0.05540421f, 0.03205087f, -0.02538585f, 
    0.00666710f, -0.00032843f, -0.02079940f, -0.03621876f, -0.00184246f, -0.01562431f, 0.02433919f, -0.03804690f, 
    -0.02291537f, -0.02393382f, -0.03983282f, 0.00078177f, 0.00626042f, -0.00311983f, -0.01618872f, -0.04850466f, 
    0.03761135f, -0.03903145f, -0.02634134f, 0.01450095f, -0.01358913f, -0.04562771f, 0.01507677f, -0.05923048f, 
    -0.16927731f, -0.24944946f, -0.05007131f, -0.17945483f, -0.00820260f, -0.12918860f, 0.12638626f, 0.24628377f, 
    0.14305168f, 0.08767588f, -0.02433337f, 0.13573714f, -0.14141621f, 0.00746238f, 0.05108628f, -0.13669530f, 
    0.00202119f, 0.15505075f, -0.01846523f, -0.23642766f, 0.03272331f, -0.05517138f, 0.05599130f, 0.01571061f, 
    -0.38526914f, -0.00308585f, -0.02882902f, -0.12361377f, -0.05463398f, 0.01337654f, -0.13169183f, 0.05939759f, 
    -0.01089065f, 0.14407533f, 0.07362591f, 0.05434321f, 0.18861561f, 0.21048647f, -0.25706849f, -0.02174155f, 
    -0.08090439f, -0.00304137f, 0.01551575f, 0.02092979f, -0.02325249f, -0.13493410f, 0.02274063f, -0.01498043f, 
    0.18806481f, 0.21862623f, -0.14137353f, 0.02816561f, 0.13867670f, 0.09008161f, 0.07319394f, 0.01579708f, 
    -0.12965287f, 0.10074725f, -0.01180945f, -0.10999110f, 0.37872469f, -0.11468296f, -0.18149820f, 0.02323088f, 
    -0.05789547f, 0.03439382f, -0.05022532f, -0.08666966f, -0.13090046f, -0.17262258f, -0.10814637f, -0.09654480f, 
    -0.30683190f, -0.03096601f, -0.04822639f, -0.00866118f, -0.04139311f, -0.16570415f, 0.02949740f, -0.18500541f, 
    0.12029648f, 0.16593471f, -0.16286086f, -0.14656785f, 0.08366365f, 0.04441105f, 0.19488358f, -0.08143573f, 
    -0.00513693f, -0.12809072f, -0.13250634f, -0.04142404f, -0.20125584f, 0.07311755f, 0.01619334f, 0.19050656f, 
    0.09200516f, -0.22826408f, 0.09062485f, 0.14057460f, -0.03392048f, 0.01643775f, 0.09354228f, 0.03246684f, 
    0.21856041f, -0.05107554f, 0.12909730f, -0.07825063f, -0.15676942f, 0.19363113f, -0.32680592f, -0.06625734f, 
    -0.00312549f, 0.01662281f, -0.00449304f, 0.17339204f, 0.12741156f, 0.05582493f, 0.13676038f, 0.15216631f, 
    0.33558458f, -0.03358863f, -0.07698914f, 0.13392575f, 0.05864447f, 0.03985357f, -0.06433538f, -0.02440467f, 
    -0.00192115f, -0.05684032f, 0.06750262f, 0.02164651f, 0.26091632f, 0.23399390f, -0.03072655f, -0.04955203f, 
    -0.00252948f, 0.01028517f, 0.04605103f, 0.11295741f, -0.14759377f, 0.15103315f, 0.05941724f, 0.22490306f, 
    -0.01255663f, -0.13225755f, 0.05677141f, 0.21851537f, 0.24461174f, -0.11364144f, -0.01840747f, 0.06916247f, 
    0.06232014f, -0.05914194f, 0.22683741f, -0.04555248f, 0.02485124f, -0.15054683f, -0.03301750f, 0.05483127f, 
    0.12805992f, 0.09769061f, -0.00872456f, 0.08175866f, -0.04563233f, 0.06410708f, 0.17284565f, -0.23592247f, 
    0.07587643f, -0.14631778f, 0.15425266f, 0.28707901f, 0.13439773f, -0.06268260f, 0.13120532f, 0.04467434f, 
    0.11410043f, 0.01359041f, 0.04028653f, 0.28624365f, -0.04003561f, -0.14335743f, -0.10409477f, 0.19534872f, 
    0.15759552f, 0.10241337f, -0.10714983f, -0.11880913f, -0.16254708f, -0.17362216f, 0.14663459f, 0.06308883f, 
    0.06120821f, 0.09131787f, 0.04003492f, -0.13483278f, 0.09803945f, -0.08285035f, 0.16117945f, 0.05152019f, 
    0.04793417f, 0.01810731f, 0.09883217f, 0.16862246f, 0.02425450f, 0.04094462f, 0.22005869f, 0.11175853f, 
    0.10421132f, 0.13616861f, -0.06158561f, -0.00095141f, -0.11367541f, -0.01831569f, 0.26486081f, -0.03276977f, 
    0.40878671f, -0.12059885f, -0.09963360f, -0.13670467f, -0.03744356f, -0.05966592f, -0.07369554f, -0.05701626f, 
    -0.02241208f, -0.09410064f, -0.04373786f, -0.03648856f, 0.00534052f, -0.21761730f, 0.02456902f, -0.05949634f, 
    0.05961558f, -0.00447979f, -0.00813685f, 0.08008767f, 0.00158055f, -0.08262499f, -0.01155238f, -0.11035895f, 
    0.16555928f, -0.08267847f, -0.13439037f, 0.08591098f, -0.00202182f, -0.19332418f, -0.01958421f, 0.17681046f, 
    0.03555874f, -0.14140883f, 0.15991050f, -0.12285963f, -0.06981677f, -0.32745034f, 0.20582993f, 0.03263445f, 
    0.13157146f, -0.00548925f, -0.13814147f, 0.01358546f, -0.06543192f, 0.01676503f, 0.20426007f, -0.04058620f, 
    0.08277117f, 0.23061433f, -0.17010093f, -0.19104962f, 0.06472915f, 0.17089340f, -0.01269622f, -0.04439773f, 
    0.04910947f, 0.13707051f, 0.04214542f, 0.02883229f, -0.31711069f, 0.21841744f, -0.02962961f, -0.02547863f, 
    -0.06881305f, -0.05454240f, 0.09115684f, -0.13494314f, 0.06349032f, -0.01957477f, -0.13366593f, -0.04652376f, 
    -0.21476346f, 0.00189439f, -0.03398517f, 0.21905585f, 0.03784011f, -0.00470151f, 0.19187233f, -0.01048301f, 
    0.14186336f, 0.00180409f, 0.03550993f, -0.09712506f, -0.25831267f, -0.19132151f, 0.08237222f, 0.27927148f, 
    -0.11295938f, 0.12720075f, -0.04654109f, 0.04778044f, 0.07041740f, 0.12275483f, 0.00407767f, 0.01508124f, 
    0.16911010f, 0.09497354f, -0.10341077f, -0.18102497f, 0.00914751f, -0.00534249f, 0.03093662f, -0.17474400f, 
    0.04323346f, 0.04771138f, -0.18864349f, -0.03988213f, -0.21543244f, -0.08030014f, 0.18929830f, -0.03304773f, 
    0.06671237f, 0.07241691f, 0.12006149f, 0.03415934f, 0.15001872f, -0.14065604f, -0.04497661f, 0.13323934f, 
    -0.07633441f, -0.34777561f, 0.13554846f, -0.07447241f, 0.05509852f, 0.05618069f, 0.01768664f, -0.05082035f, 
    0.09123908f, 0.10546377f, -0.25451893f, 0.03326914f, -0.00486828f, -0.26169586f, 0.34795791f, 0.27471074f, 
    -0.00951729f, 0.16539459f, -0.03941594f, -0.02303009f, 0.11657804f, 0.00832200f, 0.00620609f, 0.13440961f, 
    0.12391073f, -0.21973953f, -0.06404917f, 0.24882108f, 0.08149150f, 0.12546450f, 0.13415428f, -0.00107560f, 
    -0.06753902f, 0.10642666f, 0.15335780f, 0.12199714f, 0.35361820f, -0.12997693f, 0.02921173f, 0.16008000f, 
    0.07070768f, 0.00045894f, 0.13700280f, -0.14955871f, 0.07465195f, -0.09523157f, -0.11190160f, -0.16959348f, 
    -0.03831813f, -0.00709803f, 0.04216759f, -0.04268454f, 0.03937823f, -0.01962710f, 0.01246224f, 0.03649583f, 
    0.03317077f, 0.01551815f, 0.03184769f, -0.01601422f, 0.01083335f, -0.00028534f, -0.02968489f, 0.03236146f, 
    -0.03005093f, -0.02467777f, 0.04070939f, -0.02058380f, 0.03063661f, 0.02277320f, -0.01850387f, 0.00791665f, 
    0.02175160f, -0.00477519f, 0.03199092f, -0.02837862f, -0.04025317f, -0.04215745f, -0.05412771f, 0.01193235f, 
    0.02996157f, -0.03863862f, -0.04182350f, -0.03969873f, 0.01700323f, 0.00205952f, -0.04712310f, -0.04617099f, 
    -0.02663775f, 0.00960019f, 0.03785009f, 0.02204169f, -0.03392767f, 0.02283558f, -0.05693509f, -0.04067942f, 
    0.03145467f, 0.01706049f, -0.04054524f, 0.01849982f, 0.02753711f, -0.02821004f, 0.02376674f, -0.00094936f, 
    -0.05925098f, -0.02515009f, -0.05833071f, 0.02597421f, 0.01231084f, 0.01023185f, -0.01687239f, 0.03196460f, 
    -0.05834476f, 0.03321521f, -0.02127606f, -0.02674563f, -0.03872384f, -0.05640613f, 0.04445295f, -0.01539637f, 
    0.02787391f, -0.03881176f, -0.05134041f, -0.01018586f, -0.04626339f, 0.01982448f, 0.03088078f, -0.00327558f, 
    0.00071777f, 0.03322453f, -0.05458907f, 0.03605192f, 0.00669156f, -0.05754875f, 0.00755400f, 0.03256650f, 
    -0.02829606f, 0.04239688f, 0.00960065f, 0.01973195f, -0.04967936f, -0.03685091f, 0.00190444f, 0.04084701f, 
    -0.04700471f, 0.01494292f, 0.03916291f, -0.02316152f, -0.03855461f, -0.02606704f, 0.02277615f, 0.02378564f, 
    -0.02423417f, -0.03947716f, 0.00839400f, 0.01197033f, -0.01640337f, 0.04910627f, -0.03718479f, 0.01494184f, 
    -0.00227537f, -0.00096834f, 0.01283894f, -0.02113363f, 0.02775561f, 0.01510359f, -0.02971451f, -0.03718612f, 
    -0.00441182f, -0.03252744f, -0.01475592f, 0.03000877f, 0.01081503f, -0.03271689f, 0.01012727f, 0.01800402f, 
    -0.00995078f, -0.02847655f, 0.00064954f, -0.02905357f, 0.01206929f, -0.05900526f, 0.00672960f, 0.00572177f, 
    -0.01835762f, -0.00026155f, 0.02009170f, -0.03211533f, -0.01895010f, -0.02052923f, -0.04232820f, -0.03312780f, 
    -0.02669936f, 0.00001594f, 0.00656998f, -0.04980299f, 0.03655148f, 0.00296464f, 0.01554355f, -0.02759655f, 
    0.01770505f, 0.00172262f, -0.00231799f, -0.02788727f, 0.01651747f, -0.03802741f, 0.04680556f, -0.00156371f, 
    -0.05134838f, 0.00953910f, -0.03496781f, 0.00804474f, -0.03818341f, -0.06009252f, 0.01092277f, -0.04179866f, 
    -0.02491462f, -0.04026025f, -0.01920236f, 0.02012281f, 0.02198518f, -0.02676807f, 0.01036294f, 0.02294678f, 
    -0.04337583f, 0.01463517f, -0.01144777f, -0.04391563f, -0.04654011f, 0.04098875f, 0.00726071f, -0.01654434f, 
    0.02714100f, 0.04289031f, -0.04789410f, -0.03578402f, 0.02344851f, -0.01714594f, -0.01155397f, 0.03102114f, 
    -0.00811288f, 0.02776140f, -0.00106707f, -0.05821441f, -0.03741718f, 0.00237321f, 0.03127800f, 0.02059400f, 
    0.01135871f, -0.04697330f, -0.03461199f, -0.00181187f, 0.00622851f, 0.03332664f, -0.00389095f, -0.04474121f, 
    -0.00377082f, -0.00123577f, 0.01945379f, -0.01062838f, 0.03149772f, -0.03822242f, -0.01856157f, 0.00802307f, 
    0.03903349f, -0.00912189f, -0.01196705f, 0.01730973f, 0.00302306f, -0.05681600f, -0.03918453f, 0.02538433f, 
    -0.04185664f, 0.02830630f, 0.04145383f, 0.01562540f, 0.03685472f, -0.03727942f, -0.00339306f, -0.02250415f, 
    -0.05434819f, -0.04593308f, -0.03306726f, -0.00981690f, -0.03575256f, 0.00544702f, -0.01078616f, -0.00329959f, 
    -0.03465031f, -0.04711115f, -0.02977549f, 0.03176273f, 0.02241051f, 0.02571595f, 0.01645478f, 0.00224520f, 
    0.04045917f, -0.00632636f, -0.01483140f, 0.03381050f, -0.04484275f, 0.02295925f, -0.02780692f, -0.01810439f, 
    -0.02312145f, -0.03092237f, -0.05034362f, 0.04118910f, -0.01242419f, 0.04624823f, 0.02279589f, 0.01442995f, 
    0.02408575f, 0.04321079f, -0.00715220f, 0.00781936f, 0.00298642f, -0.00498712f, -0.01316235f, -0.00972002f, 
    0.01974916f, 0.00932681f, 0.01652313f, 0.01683649f, 0.01957745f, -0.01292721f, -0.00013630f, -0.01827648f, 
    -0.02851913f, 0.03535549f, -0.02651783f, 0.01953226f, -0.00362267f, 0.00403146f, -0.03144742f, -0.05101607f, 
    -0.01853714f, -0.05207249f, -0.03834030f, 0.01162468f, 0.00210718f, 0.02179314f, 0.02432517f, 0.00797333f, 
    -0.00905395f, -0.00721018f, 0.00533009f, -0.00979829f, -0.05710541f, 0.02330254f, -0.02560645f, 0.03892361f, 
    -0.01699867f, -0.03013633f, 0.02054786f, -0.03000291f, -0.04873481f, -0.05745320f, -0.01863259f, -0.02977338f, 
    -0.03870633f, -0.03042857f, 0.01917076f, -0.02101056f, -0.01523892f, -0.01368442f, 0.02972527f, -0.03194270f, 
    -0.00916632f, 0.03448711f, 0.02891481f, 0.01694277f, 0.01610973f, -0.02534084f, -0.04779419f, -0.01768486f, 
    0.03231737f, -0.02923624f, 0.01221202f, 0.05047687f, 0.00178773f, 0.00233517f, -0.06152279f, 0.02834980f, 
    0.04823213f, 0.00528165f, 0.01816291f, 0.03826688f, -0.02671216f, 0.03977170f, -0.02203670f, -0.01681075f, 
    0.02816484f, 0.03104444f, 0.02289247f, -0.04363924f, 0.02617137f, -0.00421108f, -0.02818122f, 0.02546143f, 
    -0.05165636f, -0.05273809f, -0.02535795f, 0.04098030f, 0.03400092f, 0.03180410f, -0.01574981f, -0.01374487f, 
    -0.04533873f, -0.01353405f, 0.03447981f, -0.00875700f, -0.04731419f, -0.01072566f, -0.01057413f, -0.04896329f, 
    -0.05068696f, -0.01137583f, -0.03365808f, 0.02561407f, -0.00042135f, -0.03066097f, 0.04758110f, -0.02592416f, 
    0.01066923f, -0.00381299f, 0.03821419f, -0.00969260f, 0.01725546f, 0.04312837f, 0.01772175f, 0.03076125f, 
    -0.01286821f, -0.03764261f, 0.00948205f, 0.02137340f, -0.01050145f, 0.00854236f, 0.00266609f, -0.04976858f, 
    -0.01078536f, -0.00260918f, -0.02104639f, 0.00056248f, -0.04091674f, -0.01709483f, -0.00523919f, 0.02991569f, 
    0.03711401f, 0.01972958f, 0.01825621f, 0.00292130f, 0.02313762f, -0.02452310f, -0.00914504f, -0.00302105f, 
    -0.04195395f, 0.02148395f, -0.00156698f, 0.02423539f, -0.01203199f, -0.03519493f, 0.04986618f, -0.01506635f, 
    0.03793037f, -0.00637061f, 0.03336555f, -0.04067060f, 0.05301287f, 0.03185434f, 0.02745618f, 0.00669433f, 
    0.03994087f, 0.01237220f, -0.04736980f, -0.04983442f, -0.01191067f, -0.00922698f, 0.00545874f, 0.04257024f, 
    0.03831163f, -0.01824379f, -0.04532733f, 0.05765073f, -0.05381022f, 0.01479800f, -0.03191134f, -0.04317170f, 
    -0.01671722f, 0.03338677f, -0.06546875f, 0.00076081f, 0.04716755f, -0.04092748f, -0.01979743f, -0.00677534f, 
    -0.03417603f, -0.05790359f, -0.00557260f, 0.01303308f, -0.05812904f, -0.03074451f, -0.00376254f, -0.06073566f, 
    -0.04652490f, 0.04446029f, 0.03222952f, 0.02423140f, -0.04744209f, -0.05215971f, 0.00790997f, -0.01058181f, 
    0.02684889f, 0.01488715f, -0.03629180f, -0.04650649f, -0.03135706f, -0.00983812f, -0.05673230f, -0.03074928f, 
    -0.05199189f, -0.02392386f, 0.01819782f, -0.00947670f, -0.02838152f, -0.01653960f, -0.00605971f, -0.00490064f, 
    -0.02923219f, -0.02884455f, 0.01588653f, 0.04724792f, 0.00454168f, -0.01684199f, -0.02524306f, -0.03810002f, 
    0.03818648f, 0.03981038f, 0.03752083f, -0.03543706f, -0.02260855f, 0.03670121f, 0.01468994f, -0.01372019f, 
    -0.02983490f, -0.02957490f, -0.03720673f, 0.00833293f, 0.00528056f, 0.03957607f, -0.03385851f, 0.03278504f, 
    -0.04872061f, -0.04715679f, -0.00181627f, -0.00467001f, 0.00086770f, 0.04281102f, -0.02820595f, 0.00731641f, 
    0.04866278f, 0.04235525f, 0.03465283f, -0.03734658f, 0.02035393f, 0.03457498f, -0.02997166f, 0.02851124f, 
    -0.00186991f, -0.03716451f, -0.03070727f, 0.00616670f, -0.03401564f, 0.03484387f, -0.01463648f, -0.05118712f, 
    -0.05496331f, 0.01677497f, -0.05764937f, -0.01514846f, -0.00661224f, 0.00299108f, -0.00910284f, 0.03328281f, 
    0.02963749f, -0.04684108f, 0.01350156f, 0.00014439f, 0.00178206f, -0.04147742f, -0.03719131f, 0.03767905f, 
    0.04767831f, -0.03518002f, -0.00432249f, -0.01045298f, 0.02891767f, -0.02849206f, -0.00364717f, -0.00117234f, 
    0.02698356f, 0.02130688f, -0.00330502f, -0.01542282f, 0.03658289f, 0.01653584f, 0.02690700f, 0.02355228f, 
    -0.02385318f, -0.03999573f, -0.00265516f, 0.03528203f, 0.05334361f, 0.01960486f, 0.00985797f, -0.02432024f, 
    -0.01399278f, -0.05452141f, -0.00138305f, 0.00001742f, -0.01175057f, -0.04317793f, -0.02917416f, 0.02247052f, 
    0.01214621f, -0.05464175f, 0.01788745f, -0.05877675f, -0.02440852f, -0.01198196f, -0.02077812f, -0.00319503f, 
    0.00489002f, -0.03432343f, 0.01190320f, -0.02637520f, -0.00534244f, -0.02300581f, -0.02440834f, -0.00939145f, 
    -0.02025394f, -0.03406787f, 0.00509682f, 0.01113669f, -0.00536305f, -0.00761067f, 0.01759537f, -0.03596487f, 
    -0.01165476f, 0.00926480f, 0.03514588f, 0.02799085f, -0.03788759f, 0.03555750f, -0.05209687f, -0.05188251f, 
    -0.01393593f, 0.03647381f, -0.00643180f, 0.00144168f, 0.04953042f, -0.03843439f, 0.00144895f, -0.05752502f, 
    -0.04804529f, 0.01290486f, 0.01299237f, -0.01844494f, 0.00708430f, 0.01509953f, 0.01468140f, -0.04803351f, 
    0.02475190f, -0.05932204f, -0.05560395f, -0.03759018f, 0.04083900f, 0.03328538f, 0.01538675f, -0.02734373f, 
    -0.02357938f, -0.02930042f, 0.03010186f, -0.02252577f, 0.01771546f, -0.02021094f, 0.02643032f, -0.00481549f, 
    0.00745974f, 0.00153794f, -0.00521474f, -0.03446088f, -0.03026728f, 0.03619108f, -0.03101946f, 0.03803925f, 
    -0.03132755f, -0.02782183f, -0.02969508f, 0.03436947f, -0.02572209f, -0.01404843f, 0.03314405f, -0.03277094f, 
    -0.00321756f, -0.04241852f, 0.02494372f, 0.01206394f, 0.02165000f, 0.02885161f, -0.05306813f, 0.02994874f, 
    -0.01375142f, 0.01048001f, -0.03468200f, -0.02413787f, -0.00433466f, -0.02634824f, -0.02182082f, -0.01053886f, 
    -0.01676590f, 0.03594951f, -0.04371147f, 0.00695867f, 0.03917463f, -0.04114394f, -0.01595719f, -0.01671431f, 
    -0.02474885f, -0.00835158f, -0.00892614f, 0.03598803f, 0.02156555f, -0.04412670f, -0.05076036f, -0.01145718f, 
    -0.05116175f, -0.00971832f, -0.04710778f, -0.05108416f, 0.00176510f, 0.00630691f, -0.03114041f, -0.05062341f, 
    -0.03842472f, 0.00835492f, -0.03160742f, 0.02249998f, 0.00499893f, 0.03977694f, 0.00586811f, 0.02012945f, 
    -0.02120482f, -0.04700872f, -0.05550313f, 0.03539232f, -0.01712077f, 0.03567149f, 0.00507246f, -0.01019577f, 
    -0.02886193f, -0.00166585f, -0.02011313f, -0.02841314f, 0.03665951f, -0.01284747f, -0.03747755f, 0.01478240f, 
    -0.02034645f, 0.01122690f, -0.03884956f, 0.04220157f, -0.04542800f, -0.01647074f, 0.02936227f, -0.05567107f, 
    0.01504844f, 0.01923020f, -0.04562768f, -0.05583481f, 0.02952002f, -0.00044375f, -0.02891166f, 0.03814250f, 
    0.00280798f, 0.01904303f, 0.03110185f, 0.03866171f, -0.03009140f, 0.02203653f, 0.01613277f, 0.04137122f, 
    0.02154737f, -0.02603764f, 0.03427973f, -0.01685281f, 0.04401741f, 0.01858425f, -0.05068612f, 0.00946282f, 
    -0.01645922f, 0.01312475f, -0.04095350f, 0.02823377f, -0.02958390f, 0.02876754f, -0.04917471f, 0.03115028f, 
    0.01606670f, -0.04590459f, 0.03586806f, 0.02369702f, 0.00489522f, -0.02614241f, -0.00703512f, 0.01758584f, 
    -0.03554157f, 0.02690456f, -0.01924434f, -0.03023403f, 0.04123464f, 0.03968026f, -0.05321600f, -0.03185654f, 
    -0.03788226f, -0.02864897f, -0.01432866f, 0.03432564f, 0.01912170f, -0.02075015f, 0.00446355f, 0.03946080f, 
    0.00231996f, -0.04154053f, 0.03846952f, -0.00066852f, -0.02479800f, -0.05367783f, 0.04036647f, 0.00276274f, 
    -0.03746527f, -0.03454378f, -0.02674228f, 0.04282110f, -0.03458875f, -0.02867445f, -0.02810843f, 0.01788302f, 
    0.00762595f, -0.05172835f, -0.02965264f, -0.01113839f, 0.03144337f, 0.03313327f, -0.03591620f, -0.04098259f, 
    -0.00467173f, -0.02672913f, -0.04333483f, 0.00921320f, 0.03715185f, -0.04575703f, 0.04137080f, -0.02984495f, 
    -0.02941923f, -0.01082656f, 0.02358025f, -0.04661769f, 0.00603116f, 0.02044014f, -0.02314540f, 0.01208645f, 
    -0.04628341f, 0.01747410f, -0.03181444f, -0.00079366f, -0.02242513f, 0.00679507f, 0.00571237f, -0.01127226f, 
    -0.00802322f, 0.01761096f, 0.01819256f, -0.00965594f, -0.00852730f, 0.00363763f, 0.01031456f, -0.02783718f, 
    0.02123403f, -0.00254884f, -0.02733399f, -0.03240813f, 0.03231929f, -0.03344318f, -0.04953678f, -0.03469176f, 
    0.03788025f, -0.01777115f, 0.04132374f, -0.00268458f, -0.02489165f, 0.03421025f, -0.04845008f, -0.00192282f, 
    -0.05104500f, -0.03360859f, 0.01969425f, -0.03009456f, -0.03961524f, 0.03038873f, -0.03257636f, 0.02593502f, 
    0.03092988f, 0.03728501f, 0.04068587f, -0.05095048f, 0.00518213f, 0.02228869f, 0.01977883f, -0.05369098f, 
    -0.03366809f, -0.03375632f, -0.02254287f, -0.04967787f, 0.01085863f, -0.00515194f, 0.03824508f, -0.03692142f, 
    0.03441444f, -0.02174072f, -0.01020399f, -0.03032584f, -0.00629271f, -0.05826997f, -0.04670442f, 0.02889696f, 
    -0.03450425f, -0.05286343f, 0.04054533f, -0.00306874f, -0.00271864f, 0.04088682f, -0.05278372f, -0.02997859f, 
    -0.00359553f, 0.03181965f, -0.02553922f, 0.03306632f, -0.05244857f, 0.03512922f, -0.03229379f, -0.00695121f, 
    0.01335233f, 0.01136519f, -0.03005143f, 0.00333851f, -0.00101237f, -0.03700885f, -0.00018094f, -0.03398868f, 
    -0.05580471f, -0.02441683f, 0.00170390f, -0.02417038f, 0.00026435f, -0.01043328f, -0.01898868f, 0.03527615f, 
    0.00358333f, -0.03621234f, -0.04474206f, 0.01403577f, -0.03257741f, 0.04343991f, 0.00532167f, 0.02475936f, 
    -0.03695763f, 0.02508711f, 0.01006746f, 0.00571993f, -0.00969186f, 0.01234010f, 0.01058901f, 0.02195882f, 
    -0.00000504f, 0.02202185f, -0.00597059f, 0.01053704f, 0.03849416f, -0.04797924f, -0.05545256f, -0.00723351f, 
    0.01226849f, -0.05303340f, 0.00125828f, 0.00136884f, -0.03111305f, -0.01676719f, 0.03996405f, 0.01141794f, 
    0.00395777f, -0.04111489f, 0.03104710f, -0.02545216f, 0.02869164f, 0.01547780f, -0.02829669f, 0.02936853f, 
    0.01174687f, -0.02490182f, -0.03682301f, 0.02082728f, 0.02663910f, -0.03981782f, 0.00486727f, 0.00488055f, 
    -0.00606496f, -0.03149612f, 0.02727854f, -0.05571922f, -0.02682924f, -0.03205273f, -0.01392285f, -0.03861099f, 
    0.01591490f, 0.01259762f, 0.02520462f, -0.02583164f, 0.03716173f, 0.00007427f, 0.04358712f, 0.00889169f, 
    0.00309636f, 0.02402350f, 0.00998356f, 0.01323538f, 0.00495354f, 0.00571174f, -0.04550909f, 0.01843606f, 
    -0.01206714f, 0.03101834f, -0.04756729f, -0.05930927f, -0.03637103f, -0.03446088f, 0.02549654f, -0.05483188f, 
    -0.02349969f, 0.02528390f, 0.03380164f, -0.04886016f, -0.01806380f, 0.01693252f, -0.00312496f, 0.03446985f, 
    -0.00394967f, 0.02939727f, -0.00844392f, -0.05242835f, -0.05830922f, 0.01624632f, 0.02165627f, 0.01156875f, 
    0.02684849f, -0.01804407f, 0.03783107f, -0.01164738f, -0.00096265f, 0.01837734f, -0.01590170f, 0.00451414f, 
    0.00635373f, -0.04094379f, 0.03721883f, -0.00830062f, 0.00097752f, -0.02403694f, 0.00107959f, 0.00957389f, 
    0.02878483f, -0.03773974f, -0.04308604f, 0.02971203f, 0.02302829f, -0.04417371f, 0.02173618f, -0.02588655f, 
    -0.04520592f, 0.03072083f, -0.03073738f, -0.03495177f, -0.01120886f, -0.04960069f, -0.05671112f, -0.05434735f, 
    -0.01187411f, 0.00921223f, 0.00943275f, -0.03149676f, -0.00641536f, 0.01076452f, -0.03035936f, 0.03393684f, 
    0.04140892f, -0.03290911f, -0.04006625f, -0.04420068f, -0.04596839f, 0.01301115f, -0.03983388f, -0.05466106f, 
    -0.04595042f, -0.01731203f, 0.01835064f, -0.05909585f, -0.01654255f, 0.01980925f, 0.01314713f, -0.02427655f, 
    -0.03440630f, -0.00032914f, 0.02287351f, 0.02176237f, -0.00160672f, -0.00207207f, 0.01288512f, -0.00917610f, 
    0.04127053f, -0.05710095f, -0.00847003f, -0.05364164f, -0.05360322f, -0.03635337f, 0.04061022f, -0.01860988f, 
    -0.03054477f, 0.00943725f, -0.01514083f, -0.05400475f, -0.01467234f, -0.03880491f, -0.05340992f, -0.04463345f, 
    0.01404375f, 0.03971364f, 0.02645278f, 0.02982774f, -0.01845393f, -0.01190971f, 0.02466012f, 0.01739737f, 
    0.00633235f, -0.04475275f, -0.03035742f, 0.01239652f, -0.02829945f, 0.00877771f, -0.01805512f, -0.05480696f, 
    0.00198139f, -0.05426167f, -0.01875043f, -0.03717964f, -0.02445594f, -0.04372081f, -0.05558034f, -0.01899174f, 
    0.04150422f, 0.00616954f, 0.00054539f, -0.00256371f, -0.05665055f, 0.02289193f, 0.00322831f, 0.04167407f, 
    -0.04222084f, -0.04664776f, -0.03840286f, -0.02238459f, -0.05789515f, -0.04129369f, -0.04279873f, 0.01774530f, 
    -0.01623848f, -0.04846616f, 0.03636566f, -0.00886662f, 0.03238365f, 0.03874579f, 0.00028454f, -0.02010134f, 
    -0.00712220f, 0.01890225f, -0.01310354f, 0.00125527f, 0.02371009f, -0.05788336f, -0.03269168f, 0.03260672f, 
    -0.16225675f, 0.13857961f, 0.08059753f, -0.22869909f, 0.10705035f, 0.01280670f, 0.14162360f, -0.05281997f, 
    -0.12057224f, -0.08839492f, 0.06095086f, -0.03908440f, 0.12120008f, 0.07359972f, -0.16987024f, 0.01749336f, 
    0.09678488f, 0.02561252f, -0.16184559f, 0.05720820f, 0.04290248f, 0.01087916f, -0.03397879f, -0.10744174f, 
    0.27304205f, -0.00227102f, -0.10987564f, -0.07725684f, -0.09455665f, 0.08732314f, -0.02741926f, 0.00430794f, 
    0.05125432f, -0.06292219f, 0.02041902f, 0.01334552f, 0.37824482f, 0.25250545f, 0.07641661f, 0.08689747f, 
    0.04013199f, -0.05052053f, -0.07142043f, 0.00866689f, -0.10732510f, -0.04691884f, -0.00977426f, 0.03550101f, 
    0.23504086f, 0.11007164f, 0.01211174f, 0.13460526f, -0.11457627f, 0.12425951f, -0.09050740f, -0.03295938f, 
    0.07893036f, 0.07666873f, -0.04650719f, 0.10722744f, -0.03316647f, 0.11090631f, 0.09341231f, -0.26123619f, 
    0.02170527f, -0.00006431f, -0.09626457f, 0.04834048f, 0.10266756f, 0.14480709f, 0.17928897f, 0.25489998f, 
    0.39004347f, 0.22239441f, -0.03789031f, -0.33265615f, 0.13259873f, 0.01599054f, -0.03723662f, 0.19562055f, 
    -0.04416996f, 0.01105740f, 0.11680788f, 0.06052322f, 0.22976254f, -0.10457277f, 0.29588202f, 0.15022406f, 
    0.18342602f, -0.04249340f, 0.03865863f, 0.13195506f, -0.11062007f, 0.11915624f, -0.14570004f, -0.02620616f, 
    -0.47343823f, -0.01665910f, -0.17284340f, -0.37110564f, 0.14499827f, 0.03740883f, -0.03585126f, -0.12922098f, 
    0.04217262f, 0.01265877f, 0.04227509f, -0.04162056f, 0.42367125f, -0.20132434f, 0.20028350f, 0.16869712f, 
    0.02774062f, -0.00714994f, 0.01872014f, 0.04430409f, -0.03019351f, 0.02259118f, -0.03466941f, -0.05311997f, 
    0.24973255f, -0.12495534f, -0.02442247f, 0.18267500f, -0.08935387f, -0.06442101f, 0.05800736f, 0.02119661f, 
    -0.05290920f, 0.19748130f, 0.03339830f, -0.05913515f, 0.06974400f, 0.06834021f, -0.09689499f, -0.09453247f, 
    -0.03519688f, 0.01204356f, -0.06776519f, -0.10666066f, 0.01862880f, -0.15156072f, -0.06027567f, -0.15667608f, 
    0.11840325f, 0.06587302f, 0.00360484f, -0.35612983f, 0.05752572f, 0.09004976f, 0.06544344f, -0.02352266f, 
    0.12025662f, 0.03863798f, 0.10076810f, 0.00541400f, 0.20925720f, 0.26088572f, -0.09796771f, 0.02985177f, 
    -0.08193300f, 0.07524122f, 0.16976798f, -0.20913973f, 0.20083065f, 0.17641830f, 0.03081261f, 0.08015525f, 
    -0.07142062f, 0.25945193f, -0.30445588f, 0.00179625f, 0.11430363f, 0.03494859f, 0.04649084f, -0.07921887f, 
    -0.27851167f, -0.07698706f, 0.07351048f, -0.05564954f, -0.03604741f, -0.15186408f, 0.09650735f, 0.00085181f, 
    0.00783827f, 0.06644165f, 0.04567856f, -0.04825696f, 0.02548725f, 0.13593285f, -0.07179525f, -0.08789289f, 
    -0.05215449f, -0.01818862f, -0.04590733f, 0.24783950f, 0.07089750f, 0.08473040f, 0.10181480f, 0.01910317f, 
    -0.06636571f, 0.00905590f, -0.14081477f, -0.00861265f, 0.25247186f, 0.21952029f, -0.02341461f, -0.07751422f, 
    -0.01831242f, 0.22998263f, 0.04181740f, 0.11550048f, 0.05377317f, 0.15665022f, -0.05204862f, 0.12303437f, 
    -0.09924980f, 0.00698531f, 0.00372635f, 0.23963176f, -0.11501393f, 0.09888528f, 0.09293000f, 0.12633196f, 
    -0.01576179f, -0.05755274f, 0.03417088f, -0.10176452f, 0.17759822f, -0.06803576f, 0.07776569f, -0.22948377f, 
    0.06144550f, 0.06749379f, -0.02298496f, 0.00481242f, -0.01642906f, 0.01915971f, 0.06936483f, 0.04975192f, 
    -0.05479977f, 0.06071819f, 0.21647154f, 0.18293233f, 0.01711197f, -0.00245838f, -0.02642118f, -0.00010024f, 
    0.02945723f, 0.09851247f, 0.06190126f, 0.09785258f, -0.07557972f, 0.36804184f, 0.02324640f, 0.09600998f, 
    0.05711993f, -0.01672998f, 0.09285750f, -0.03667294f, -0.07644098f, 0.05195024f, -0.07037493f, -0.10154276f, 
    0.48478705f, -0.12906048f, -0.01071788f, 0.08972825f, 0.05359729f, 0.09001121f, 0.03208698f, 0.07111127f, 
    -0.03430625f, 0.06339622f, 0.01780515f, -0.07508872f, -0.36332169f, -0.05546837f, -0.01283875f, -0.06555374f, 
    -0.00192625f, -0.10015391f, -0.11558867f, 0.12050772f, -0.01781277f, -0.11295754f, 0.16330308f, -0.05799696f, 
    0.00410555f, -0.08528041f, -0.24176683f, -0.03583473f, -0.05036590f, -0.05739012f, -0.13642858f, 0.09239350f, 
    0.10790753f, -0.01317395f, 0.14106260f, -0.07379489f, 0.16363734f, -0.07436708f, -0.03209209f, -0.07644901f, 
    0.10405819f, -0.16139539f, 0.14191921f, 0.08011527f, 0.01973908f, -0.07578631f, -0.02773014f, 0.04244943f, 
    0.40042904f, -0.14034984f, 0.00671042f, 0.35136804f, 0.11173365f, -0.02750655f, 0.00768901f, 0.17904530f, 
    -0.02797831f, 0.08211970f, 0.09004543f, -0.04046846f, 0.03371387f, 0.17341453f, -0.10440484f, 0.20528707f, 
    0.05174474f, -0.07700319f, -0.10127883f, 0.02012770f, -0.06560557f, 0.14305185f, 0.07006006f, 0.01506621f, 
    -0.02402265f, 0.11419214f, 0.00786325f, 0.39191431f, -0.00276893f, -0.05391060f, -0.06278851f, 0.10892655f, 
    0.00525592f, 0.05067157f, -0.06282206f, -0.07687180f, -0.25771981f, -0.19619972f, -0.00463207f, -0.35671011f, 
    0.28379011f, 0.09472318f, -0.03104503f, -0.06243438f, -0.04660045f, -0.11943087f, -0.07030778f, -0.03960931f, 
    -0.04184199f, 0.23016290f, -0.18629521f, 0.06670767f, 0.19817658f, -0.02571593f, -0.00282500f, -0.06868812f, 
    -0.08145117f, -0.00269994f, -0.09981696f, -0.03900681f, -0.15291171f, 0.13358594f, -0.14168993f, -0.42546466f, 
    0.11623032f, 0.12509309f, -0.11935481f, -0.05766767f, 0.20330364f, 0.00019585f, 0.11307620f, 0.05487472f, 
    -0.03198676f, 0.00527202f, 0.01986268f, 0.01070151f, 0.04433247f, -0.00476473f, -0.00474605f, 0.02092507f, 
    -0.03604074f, -0.01824386f, 0.03026106f, -0.00780810f, 0.03040911f, -0.05246901f, 0.00771020f, -0.00808577f, 
    0.03215353f, -0.01964933f, 0.04048182f, -0.03605813f, -0.01285777f, 0.02031042f, -0.04260676f, 0.00627001f, 
    -0.01363775f, -0.04100652f, -0.01191815f, 0.00580482f, 0.04973935f, 0.04209636f, 0.04775992f, -0.00059960f, 
    -0.05125777f, -0.04699241f, -0.05306995f, -0.03848622f, 0.01313520f, 0.03073928f, -0.02503255f, 0.01737270f, 
    -0.04062209f, 0.01226177f, 0.01478375f, -0.03727922f, -0.00194414f, -0.01305779f, -0.04618218f, 0.02141595f, 
    0.02210408f, 0.01745443f, -0.02625275f, 0.02416892f, -0.05166114f, 0.02126246f, -0.00679300f, 0.00353951f, 
    0.04062454f, 0.01952903f, 0.00097397f, -0.00520786f, 0.00634334f, -0.03196556f, -0.02887586f, 0.00824213f, 
    -0.03283231f, 0.00626644f, 0.03722027f, -0.01163243f, -0.00924582f, -0.04782065f, 0.03903136f, -0.02971878f, 
    0.03007825f, -0.01382275f, 0.00408399f, -0.00271501f, -0.02526177f, -0.03444031f, -0.03336733f, 0.02656149f, 
    -0.04263139f, -0.02392154f, 0.02772496f, -0.01394078f, -0.02562527f, -0.04487015f, -0.00593513f, -0.01859001f, 
    0.03349899f, 0.01934740f, -0.03499015f, -0.00419346f, -0.00504221f, -0.04408067f, -0.03856102f, 0.02945276f, 
    -0.03171809f, 0.02574911f, 0.02073008f, 0.04349295f, -0.01154339f, 0.00051278f, 0.00488150f, -0.00779772f, 
    0.03116805f, -0.03021947f, -0.02274829f, -0.03942457f, -0.02750124f, -0.04058114f, 0.02323781f, 0.03828699f, 
    0.01752612f, -0.03999195f, 0.02564433f, 0.01524459f, 0.02822088f, -0.00573731f, -0.04901752f, -0.04186493f, 
    0.01721602f, -0.05397162f, -0.00153911f, -0.02590942f, 0.00739202f, 0.01204345f, 0.01301537f, 0.01999531f, 
    -0.03904343f, 0.04731626f, -0.01154519f, -0.03093886f, 0.03596199f, 0.04478398f, -0.01829657f, -0.03751646f, 
    -0.04002260f, -0.00605107f, -0.04351095f, -0.00271785f, 0.01568096f, 0.03321105f, -0.04714333f, 0.02419223f, 
    -0.02122287f, -0.01085407f, -0.04240653f, 0.04055814f, 0.01947493f, -0.04802391f, -0.04720184f, 0.03188519f, 
    -0.01043833f, 0.03365321f, -0.02419383f, -0.00366200f, -0.05210533f, -0.04017034f, -0.04968356f, 0.00393558f, 
    -0.02587890f, 0.04270763f, 0.02713266f, 0.02659392f, -0.00618300f, -0.04650801f, -0.04221932f, -0.04881647f, 
    0.04535668f, -0.05268634f, 0.03496721f, -0.02687392f, 0.02065090f, 0.00382322f, 0.00055843f, 0.00188792f, 
    0.04061098f, 0.01277331f, -0.00479120f, -0.01858465f, 0.00977613f, -0.00445216f, -0.01911702f, -0.01524612f, 
    0.00362877f, 0.02740562f, 0.01816979f, -0.01052002f, -0.03260336f, 0.00584232f, 0.00827965f, 0.00538291f, 
    -0.01757594f, 0.00563143f, -0.04202633f, -0.00256647f, -0.01423420f, -0.04913618f, -0.05689543f, -0.00573023f, 
    -0.02342114f, 0.01509939f, -0.03808403f, 0.02251406f, -0.03166253f, 0.01854270f, 0.02876113f, 0.00376789f, 
    -0.02313409f, 0.03360790f, -0.00039924f, -0.03718846f, 0.01052585f, -0.02791838f, 0.01807210f, -0.01777963f, 
    0.01995929f, -0.03441027f, 0.01270092f, -0.01671780f, -0.00060418f, 0.04047763f, 0.01273850f, -0.01746932f, 
    0.01002586f, -0.04876572f, 0.00981397f, 0.03153244f, -0.03964093f, 0.01154063f, -0.00966041f, -0.01762892f, 
    0.00176430f, -0.04211472f, 0.01508000f, -0.02115089f, 0.02418087f, 0.03570125f, -0.04445164f, -0.00755418f, 
    -0.03760698f, 0.03901752f, -0.03334396f, 0.01972832f, 0.02294244f, -0.00826865f, 0.03947030f, 0.03287465f, 
    0.01135952f, -0.04774493f, -0.01544042f, 0.02870287f, -0.04388655f, -0.00542004f, 0.00843714f, -0.01493790f, 
    -0.02834263f, -0.03321392f, -0.00930293f, 0.02566897f, -0.00411516f, -0.00639794f, 0.02043902f, 0.00257413f, 
    0.02138440f, -0.02328799f, -0.01721874f, -0.03607523f, 0.01620992f, 0.04068773f, -0.05114828f, 0.03492668f, 
    -0.04213888f, 0.01743951f, -0.02134768f, 0.00073333f, 0.04283604f, 0.02566594f, -0.03548631f, -0.00217045f, 
    -0.03019012f, 0.02353138f, -0.02333004f, -0.03391688f, 0.01721308f, -0.02240276f, -0.00493955f, 0.00414417f, 
    0.01763138f, 0.01929515f, -0.03116412f, -0.04016789f, 0.00434006f, 0.00990781f, 0.03167726f, 0.03461711f, 
    -0.02042292f, -0.04490734f, -0.03835561f, -0.02935845f, 0.03143853f, 0.04137113f, -0.02523066f, -0.02890222f, 
    -0.04442126f, -0.03769056f, 0.03842124f, -0.00519089f, -0.02727689f, -0.00934752f, -0.04942600f, -0.00225234f, 
    -0.01998810f, 0.03822140f, -0.01280771f, 0.02505128f, -0.01730075f, 0.00824929f, 0.00765108f, -0.02657199f, 
    0.03208645f, -0.01695193f, 0.03830671f, -0.04105730f, -0.01627869f, 0.03195427f, -0.04571395f, -0.04612353f, 
    0.02421040f, 0.02133672f, -0.00540360f, -0.02368776f, 0.03484635f, 0.00577406f, 0.03104273f, -0.00629166f, 
    -0.00359783f, 0.02033281f, -0.01967801f, 0.04351158f, 0.02850736f, 0.02732680f, -0.00582926f, 0.00295948f, 
    0.02527545f, 0.01931460f, 0.02734109f, -0.03259828f, 0.02502966f, -0.00945420f, 0.01435223f, 0.01979913f, 
    -0.00194842f, 0.02015837f, -0.04907801f, 0.01175985f, 0.03889735f, 0.01747740f, -0.00155153f, -0.05232878f, 
    0.00693429f, 0.00965042f, 0.02164917f, 0.02476783f, 0.04965945f, -0.03177610f, -0.03214547f, -0.03125722f, 
    -0.05191259f, -0.03869339f, 0.01343013f, -0.04243651f, 0.02729560f, -0.03091554f, -0.03076521f, -0.02581929f, 
    -0.02218025f, 0.02464272f, -0.02022681f, -0.04610123f, -0.03100746f, 0.01877344f, 0.04538924f, -0.02764578f, 
    -0.42537719f, 0.06177064f, -0.07463855f, 0.06765780f, 0.05078235f, -0.00271446f, 0.02881982f, 0.19051741f, 
    0.01199085f, 0.03425217f, 0.02156004f, 0.08537614f, -0.14443269f, 0.27677408f, 0.02251187f, -0.22357017f, 
    -0.14758891f, -0.08267117f, 0.04982902f, -0.17674296f, 0.04770553f, 0.01306258f, -0.08767438f, -0.00919957f, 
    0.00525068f, 0.08456317f, -0.05418629f, -0.04450086f, -0.01260020f, -0.01068220f, -0.20343363f, -0.03248857f, 
    -0.07674631f, 0.00330696f, 0.06829366f, -0.03785882f, 0.31992546f, -0.09624078f, -0.30223337f, 0.00328409f, 
    -0.00943848f, 0.03781594f, 0.01274229f, -0.09521365f, 0.11397965f, -0.05258960f, 0.11862792f, -0.20019074f, 
    -0.13088124f, -0.18378371f, -0.40981922f, -0.19735914f, 0.15064420f, -0.02936052f, -0.02295891f, -0.04986705f, 
    0.01702916f, 0.09386496f, 0.04354401f, -0.17456050f, 0.44080478f, 0.26018739f, -0.08576331f, 0.04022464f, 
    0.07869182f, -0.08969565f, 0.11020504f, -0.00317276f, -0.02018354f, -0.03419345f, -0.10222422f, -0.03953960f, 
    -0.10449542f, -0.16705890f, 0.09804399f, 0.15645975f, -0.03886130f, -0.02931698f, -0.02812978f, -0.02731455f, 
    0.11799337f, 0.08212282f, 0.06997135f, 0.02945249f, 0.15392195f, -0.12306118f, 0.00675661f, 0.33071676f, 
    -0.14134942f, 0.09893325f, 0.02952351f, -0.01840646f, 0.00758822f, -0.02272334f, -0.02606460f, 0.04536241f, 
    0.44412616f, 0.11871482f, 0.04233768f, -0.00086965f, -0.02359063f, 0.03161427f, 0.13468750f, -0.04514960f, 
    -0.05967353f, 0.08365186f, 0.14905220f, -0.12171587f, -0.02013443f, 0.27682176f, -0.19855499f, -0.02228699f, 
    0.06396797f, 0.08116958f, 0.02268535f, 0.05741143f, 0.07755240f, -0.05821052f, 0.07895815f, 0.11377409f, 
    0.34635985f, 0.15752211f, 0.17905155f, -0.06903286f, 0.01033546f, -0.00027557f, 0.01861436f, -0.02722899f, 
    0.06398005f, -0.06314190f, 0.04068974f, 0.07221877f, -0.03898817f, 0.06749655f, -0.03675029f, -0.14763716f, 
    0.02184298f, -0.02531669f, -0.07887109f, 0.01782132f, -0.04866321f, 0.06587534f, -0.14229158f, 0.03048915f, 
    0.31518522f, 0.08753730f, 0.11013077f, 0.15597108f, -0.04118393f, -0.10194295f, 0.06966104f, 0.07154127f, 
    0.03021761f, -0.01524390f, -0.02200284f, 0.05974860f, -0.14079612f, 0.08669410f, 0.05059748f, -0.02222527f, 
    -0.12801588f, 0.01170820f, -0.14873104f, -0.00213336f, -0.09143496f, -0.10094023f, -0.05935423f, -0.09572059f, 
    0.21933439f, 0.22898167f, 0.13107063f, -0.11435949f, 0.11387430f, -0.01536841f, 0.06079284f, 0.08681706f, 
    0.05093918f, 0.11049858f, 0.07188439f, 0.11600579f, 0.12460427f, 0.12601836f, -0.17542776f, -0.21604542f, 
    0.00343218f, -0.13315903f, -0.10078968f, -0.05674511f, 0.07974882f, -0.07858875f, -0.09925363f, -0.00556667f, 
    0.00193398f, 0.16391277f, -0.00013541f, -0.16049957f, 0.19728969f, 0.02326059f, 0.03362918f, 0.02279791f, 
    0.04919424f, -0.00644961f, 0.11385436f, 0.02108713f, 0.17740242f, 0.00059673f, -0.20036544f, 0.00375527f, 
    0.09188390f, -0.00381694f, 0.08188352f, -0.03860995f, -0.06119997f, -0.04828889f, 0.12580967f, -0.02655353f, 
    0.44748467f, 0.13164167f, -0.14926431f, -0.29114288f, 0.14552745f, -0.11677171f, 0.13244076f, 0.05920373f, 
    -0.03896565f, -0.03292465f, 0.05264026f, -0.04965690f, 0.74914944f, -0.35197964f, 0.07146687f, 0.14459026f, 
    -0.04190425f, 0.00694578f, 0.05733419f, 0.06156068f, 0.00726028f, -0.01989388f, 0.05436210f, 0.04400831f, 
    0.20291299f, 0.03722079f, -0.03107742f, -0.17617439f, -0.01416617f, -0.00633637f, 0.11950278f, -0.06248360f, 
    0.01140082f, -0.04214201f, -0.00213319f, -0.00899567f, -0.05114753f, -0.19787128f, 0.07138190f, 0.21083373f, 
    -0.00496139f, 0.04608831f, -0.06351936f, 0.00917442f, 0.00363726f, 0.10145299f, 0.03386194f, -0.03578108f, 
    0.12808336f, -0.03925536f, -0.22614795f, -0.06844441f, -0.05040641f, 0.16429827f, -0.06741018f, 0.03119411f, 
    -0.02103643f, 0.04573174f, 0.08610155f, 0.03093008f, 0.11590179f, 0.10035602f, -0.01071257f, 0.04348370f, 
    -0.00850785f, 0.00406168f, 0.04794838f, 0.00011423f, -0.01449730f, 0.14076118f, -0.02338553f, -0.01246671f, 
    -0.12208124f, -0.07764688f, -0.11363538f, -0.00119023f, 0.06551464f, -0.00800103f, 0.12039106f, 0.05097782f, 
    -0.03174013f, 0.12231278f, -0.02901539f, -0.07618944f, -0.15963104f, -0.15263030f, -0.04725884f, 0.03220041f, 
    -0.07968142f, 0.02949687f, 0.00012041f, 0.03897231f, 0.10944986f, 0.18455906f, 0.04339259f, -0.03023060f, 
    0.25851449f, -0.07144873f, 0.10555468f, -0.10637005f, 0.04475155f, 0.07026023f, -0.05797610f, -0.07980523f, 
    0.03718213f, 0.00051495f, -0.02978498f, 0.02307326f, -0.37606758f, 0.03932599f, 0.17768861f, -0.23507676f, 
    -0.08367956f, -0.06747442f, -0.02821088f, -0.02710618f, -0.01906422f, -0.09334364f, 0.09761837f, -0.00607699f, 
    -0.04058323f, 0.00021337f, -0.16659743f, -0.05422934f, 0.02991027f, 0.04234741f, 0.00759750f, -0.12311388f, 
    0.05420027f, 0.04538247f, 0.10342855f, 0.04067949f, 0.20948033f, -0.20766471f, 0.03494427f, 0.13438144f, 
    -0.12869439f, 0.02548733f, -0.07938626f, -0.00894568f, 0.08136892f, -0.06511530f, 0.05458369f, -0.00913795f, 
    0.34395626f, 0.09648612f, -0.19851902f, -0.01151675f, -0.11757501f, 0.07341627f, 0.00947640f, 0.05534610f, 
    0.01123509f, 0.03438653f, 0.07990347f, 0.00251872f, 0.11942242f, 0.18037120f, 0.00341142f, 0.28618968f, 
    -0.00237781f, -0.00026719f, 0.04308935f, -0.04817017f, -0.05386569f, -0.01070246f, 0.09515098f, -0.02720340f, 
    0.16477828f, 0.14936292f, 0.00248794f, 0.07606416f, 0.14312184f, 0.11046863f, 0.01392704f, -0.12840526f, 
    -0.05047691f, 0.06924125f, 0.06643559f, -0.04763852f, -0.16674572f, -0.14946206f, 0.03738953f, -0.11663751f, 
    -0.08704738f, -0.07001881f, 0.09871012f, 0.22131276f, 0.10351019f, -0.03137808f, -0.12239730f, 0.10813654f, 
    0.20130430f, 0.19541545f, 0.20187025f, 0.23380470f, -0.01852171f, -0.09619079f, 0.17346895f, -0.00470618f, 
    0.05646668f, -0.05491720f, -0.05004186f, -0.06429023f, -0.26315019f, -0.09907734f, 0.08332704f, 0.00978583f, 
    -0.05508022f, 0.06457633f, -0.07642873f, -0.01177202f, -0.01136106f, 0.16233811f, 0.03934697f, 0.24990073f, 
    -0.13671640f, -0.01610769f, -0.03708593f, -0.19145279f, 0.01025865f, 0.03497936f, -0.04979809f, 0.15977950f, 
    0.14680105f, -0.03480290f, 0.11692588f, 0.10416560f, 0.11269221f, 0.29242942f, -0.02515775f, 0.05836099f, 
    0.03131781f, -0.00797578f, 0.05135025f, 0.09719463f, 0.17211401f, 0.21489176f, 0.19176009f, 0.15983073f, 
    0.16729994f, 0.01491139f, 0.11086641f, -0.04920720f, 0.00031967f, 0.07265985f, 0.03298200f, 0.08508627f, 
    -0.00313977f, -0.04684494f, 0.26640546f, 0.09058560f, -0.11703879f, 0.02872276f, -0.17416283f, 0.19720601f, 
    0.08328144f, 0.02395126f, 0.12991191f, -0.00483875f, 0.09425414f, -0.04445513f, 0.08109532f, -0.17358756f, 
    0.07802631f, 0.26656449f, -0.06824967f, 0.20674470f, 0.02414253f, 0.03832209f, -0.08162823f, -0.01962309f, 
    -0.12944873f, -0.01626220f, -0.12160958f, 0.11785918f, 0.41012263f, -0.02029006f, 0.18863025f, -0.10074671f, 
    0.02810182f, 0.02943405f, 0.07891064f, -0.11094558f, -0.08158626f, -0.03890520f, -0.00463319f, -0.02247004f, 
    -0.38927019f, -0.13916638f, -0.05401844f, -0.05375391f, -0.01866291f, -0.08708225f, -0.00891923f, 0.13927227f, 
    -0.05930014f, 0.04325970f, 0.03323552f, 0.05085538f, -0.26956096f, -0.13057742f, -0.05212271f, -0.02041203f, 
    -0.09812047f, 0.05654980f, 0.06469696f, 0.01617140f, 0.17950569f, 0.00941057f, -0.07045326f, -0.14383300f, 
    0.39490804f, 0.11804372f, 0.06641591f, -0.03802555f, -0.04164743f, 0.08889087f, 0.09122808f, 0.00088175f, 
    0.12724984f, 0.00963058f, -0.10191778f, -0.05302611f, -0.10795446f, -0.04463409f, 0.05263951f, -0.23263973f, 
    -0.05493809f, -0.03216849f, 0.05956328f, 0.10816646f, 0.05478523f, 0.00457191f, 0.00211408f, 0.11262818f, 
    0.33267513f, 0.09008799f, -0.07191581f, 0.03112020f, -0.17196226f, 0.11509713f, -0.02480276f, -0.07292639f, 
    0.03356842f, -0.04712269f, 0.02271003f, -0.19563332f, 0.10864070f, 0.09276414f, -0.02182923f, -0.03235582f, 
    -0.01942840f, -0.03187678f, 0.10023506f, 0.14003150f, 0.25935549f, 0.15279950f, 0.10868998f, 0.09765588f, 
    0.28996170f, 0.07318622f, -0.13141717f, 0.02117678f, -0.03281811f, 0.10260692f, 0.01298712f, 0.10930368f, 
    0.01883055f, 0.06197635f, -0.11025928f, 0.04766683f, -0.36473969f, -0.04089448f, 0.04564551f, 0.09390012f, 
    0.17446920f, -0.05500693f, 0.08713576f, 0.09210361f, 0.07753254f, 0.03375989f, -0.09619917f, 0.07788478f, 
    -0.20064639f, 0.00624572f, 0.15480548f, 0.09678780f, 0.07873510f, 0.13259630f, 0.02565216f, 0.03400047f, 
    0.08998168f, 0.13334472f, 0.01749605f, 0.08143204f, -0.41143039f, 0.26640400f, -0.08733119f, 0.05851443f, 
    -0.02587286f, 0.03739931f, 0.11198892f, -0.05198598f, 0.08762975f, 0.08645065f, 0.12266625f, 0.11413448f, 
    -0.11032335f, -0.08794546f, 0.14783119f, -0.06234773f, 0.16314262f, 0.11517821f, -0.15768898f, -0.03162726f, 
    -0.00968933f, 0.19833642f, -0.01163740f, 0.18483013f, 0.03532866f, 0.22653443f, 0.03408149f, 0.01963347f, 
    -0.04444501f, -0.02004152f, 0.10908610f, -0.13974102f, 0.11603536f, 0.13722318f, -0.06123617f, 0.12248413f, 
    -0.23403661f, -0.00747288f, 0.03493290f, -0.05218584f, 0.01290459f, 0.01034217f, 0.19197033f, 0.08638573f, 
    0.02936186f, -0.07390701f, 0.03397765f, -0.05352770f, -0.08420528f, -0.37517098f, -0.05745447f, -0.23639745f, 
    -0.04826179f, 0.07151652f, -0.09299137f, 0.18686362f, 0.03256975f, -0.04616581f, 0.01887947f, 0.00863774f, 
    0.67290980f, 0.08349330f, -0.15958327f, -0.12437720f, 0.14268355f, 0.09903324f, -0.10424745f, 0.09030248f, 
    -0.12627748f, -0.10913882f, 0.00668307f, 0.02788155f, 0.26674050f, -0.01638332f, -0.11681923f, -0.19916520f, 
    0.12462910f, -0.09818876f, -0.03491851f, 0.04911723f, -0.08263322f, -0.05602452f, 0.09674265f, -0.02313706f, 
    -0.38076964f, -0.04463484f, -0.12522671f, 0.15399499f, -0.05072083f, -0.11294716f, 0.06916828f, 0.06889686f, 
    0.04866012f, 0.08053975f, 0.18342987f, 0.10051066f, 0.07667629f, -0.10319418f, -0.08511526f, -0.08664865f, 
    -0.23848745f, -0.10496229f, -0.10259390f, 0.03190527f, -0.06767784f, 0.11870658f, -0.01889152f, 0.05384123f, 
    0.18294305f, 0.07227061f, 0.06519397f, -0.29906255f, -0.10614096f, 0.11607405f, -0.04881658f, 0.14532113f, 
    -0.08974163f, -0.05987235f, 0.21214943f, 0.03289818f, 0.19690064f, 0.09267430f, -0.04322736f, 0.03299962f, 
    0.12507245f, -0.02284108f, 0.04933834f, 0.03973015f, -0.02526424f, -0.08869632f, 0.09023929f, 0.00573649f, 
    0.07477441f, 0.15691523f, 0.11850686f, 0.15159242f, 0.10576826f, 0.03615623f, -0.01070053f, -0.08071792f, 
    0.04770891f, -0.08341157f, -0.14716394f, -0.04841254f, 0.08708655f, 0.08385110f, 0.07384295f, -0.00767271f, 
    0.03316535f, 0.03797826f, 0.02170322f, 0.17683071f, 0.06316832f, 0.22809827f, 0.12095304f, 0.22247136f, 
    0.00694717f, -0.00091068f, -0.05307034f, -0.04647512f, -0.02979953f, -0.00635310f, -0.01011066f, -0.01572263f, 
    0.00430753f, 0.00007070f, 0.02034438f, 0.03657416f, 0.02188371f, 0.02450757f, -0.00948912f, -0.04150362f, 
    -0.03104257f, 0.01523650f, 0.03820160f, -0.03158927f, 0.01504095f, -0.02865841f, -0.04231326f, -0.01652112f, 
    0.02889016f, 0.01916391f, 0.02257450f, -0.00228380f, -0.02526676f, -0.01662503f, -0.01361042f, -0.03609088f, 
    -0.01832448f, -0.05033645f, -0.04544106f, 0.03814112f, -0.00762810f, -0.02166845f, -0.00919904f, 0.02329714f, 
    -0.02484293f, -0.01068726f, -0.02141844f, 0.03599760f, -0.00419845f, 0.03710508f, 0.03531438f, -0.00491238f, 
    0.02487255f, 0.03026884f, -0.04635772f, -0.00371251f, 0.00255650f, 0.01838859f, 0.03557738f, -0.05031236f, 
    0.02570005f, 0.01590736f, 0.02227941f, -0.00756995f, -0.03663363f, 0.00218705f, -0.00410195f, 0.02231446f, 
    -0.04833827f, -0.01924184f, -0.01092832f, 0.01724698f, -0.04100881f, 0.03421726f, -0.03853393f, 0.03239043f, 
    -0.00065711f, -0.05144463f, -0.00536146f, -0.01765650f, 0.01941644f, -0.02925665f, 0.02521113f, -0.04560470f, 
    0.04576055f, -0.00658790f, -0.02433547f, 0.02142676f, -0.03278143f, 0.03961769f, 0.04561074f, 0.01636258f, 
    0.04354228f, -0.00974223f, -0.04157869f, -0.01354390f, 0.04305264f, -0.05452662f, 0.03294116f, -0.00899825f, 
    -0.02750264f, -0.03379566f, 0.02218659f, 0.02272582f, -0.04601413f, -0.02777082f, 0.00065379f, -0.01561366f, 
    -0.03139108f, 0.02553903f, 0.03952263f, -0.02728842f, -0.00033771f, 0.02149088f, -0.06095595f, -0.01031367f, 
    -0.03892564f, 0.03280690f, 0.01372322f, 0.02074345f, -0.01241297f, 0.02032497f, -0.03933102f, 0.02151016f, 
    -0.02200591f, -0.04418481f, -0.00063916f, -0.02113774f, 0.04595537f, -0.01783184f, -0.04868913f, -0.00036344f, 
    0.03963849f, 0.02054327f, -0.05179821f, -0.03878096f, -0.01754181f, 0.03158889f, -0.01684914f, -0.04925003f, 
    -0.01738524f, -0.00265706f, 0.00077367f, 0.01941439f, -0.01131046f, 0.02812004f, 0.03414708f, -0.03518132f, 
    -0.02946846f, -0.00750830f, -0.03880896f, -0.00360211f, 0.03067315f, 0.00174582f, -0.00267886f, -0.02840677f, 
    -0.01355918f, -0.02620709f, 0.04538308f, 0.00428362f, 0.02596024f, -0.01574499f, 0.03751514f, -0.04724580f, 
    0.00855779f, -0.02645634f, -0.03666434f, -0.03908978f, -0.01992637f, -0.02788425f, 0.02478754f, -0.01123265f, 
    0.03455986f, -0.01878711f, -0.03411770f, 0.02317482f, 0.01194039f, -0.03870500f, -0.04095724f, -0.00218734f, 
    -0.01154575f, 0.01856155f, -0.00313287f, -0.00930647f, 0.03806414f, -0.01131587f, 0.02202176f, 0.03527540f, 
    0.02872278f, -0.00266388f, -0.03088344f, -0.05169001f, -0.01914636f, -0.00803399f, -0.04343848f, -0.04997567f, 
    0.02912546f, -0.05028388f, -0.03545652f, -0.03787531f, -0.00207316f, -0.03916376f, -0.00053121f, -0.01905612f, 
    0.03654471f, 0.03348460f, 0.00453264f, 0.03029306f, 0.04055284f, -0.05188117f, -0.04033865f, 0.00424591f, 
    -0.01045490f, 0.02716807f, 0.01058337f, -0.03728358f, 0.03598297f, -0.00194064f, 0.00016547f, 0.04333377f, 
    -0.02405754f, 0.03831759f, -0.04469357f, -0.00149688f, 0.03874137f, 0.03105444f, -0.00334482f, 0.02405917f, 
    -0.05582707f, 0.04271834f, 0.02737988f, -0.03481924f, -0.00570712f, 0.03263459f, 0.03276798f, -0.00678197f, 
    -0.04924450f, -0.04937655f, 0.00535089f, 0.01421643f, -0.05429528f, 0.00673568f, 0.01534601f, -0.05065105f, 
    0.03618225f, -0.03226093f, -0.03224230f, 0.02981043f, 0.04855119f, 0.01257551f, 0.04519384f, 0.01282132f, 
    -0.01979416f, -0.04647759f, 0.01703031f, -0.02028847f, -0.01207659f, 0.01497317f, -0.01225794f, -0.04092431f, 
    -0.00944566f, 0.02262730f, -0.01993367f, -0.01576784f, -0.05429453f, -0.03076426f, -0.01189060f, 0.01332329f, 
    0.01350449f, -0.02017453f, -0.04429795f, 0.04998942f, 0.03932996f, 0.03001330f, -0.01044072f, 0.02774654f, 
    -0.05533675f, 0.03145340f, -0.03925741f, -0.04905281f, -0.03215229f, 0.01739837f, -0.02158752f, 0.01861904f, 
    -0.03408517f, -0.02094285f, -0.04623507f, 0.04229248f, -0.03421557f, 0.01908848f, 0.00095858f, -0.00039317f, 
    -0.04541137f, -0.01509736f, -0.04403602f, 0.02432347f, -0.02108848f, -0.03317298f, -0.00916905f, 0.01179306f, 
    -0.03083621f, 0.04717017f, 0.03641290f, 0.05110759f, 0.01128178f, -0.00582633f, 0.00935921f, -0.00471428f, 
    0.01728288f, -0.00431904f, -0.05075495f, 0.03896722f, 0.04242802f, 0.03065852f, 0.04722712f, -0.02353473f, 
    -0.02061093f, -0.02414555f, -0.03766204f, 0.01474679f, -0.02231516f, 0.02581347f, -0.04707765f, -0.03728316f, 
    0.03994111f, -0.02427409f, 0.04172866f, 0.00711194f, -0.04617457f, -0.00226621f, 0.05085496f, -0.03175265f, 
    -0.05686142f, -0.04917793f, 0.02791916f, 0.03708969f, -0.03742571f, 0.01374309f, -0.01247511f, 0.03745848f, 
    -0.00803296f, 0.04132803f, 0.02292250f, 0.02332130f, 0.03559386f, -0.02185288f, -0.05320406f, 0.01234503f, 
    0.00665274f, 0.00003677f, 0.03497703f, -0.00948444f, -0.00902066f, -0.00565766f, 0.02359719f, -0.00415555f, 
    -0.03853186f, -0.01855732f, 0.02282136f, -0.00488169f, -0.04786150f, 0.03614196f, 0.02367406f, -0.00844249f, 
    -0.01371103f, -0.02762271f, 0.03709436f, -0.04991263f, -0.00040346f, -0.01652378f, -0.01799071f, -0.00197693f, 
    -0.02437380f, -0.02817022f, -0.00981089f, 0.01887334f, -0.00436878f, -0.02648865f, -0.04148603f, 0.00968060f, 
    -0.01091264f, 0.03607225f, 0.00415588f, -0.01164776f, 0.02235595f, -0.02974326f, 0.00864866f, 0.03533446f, 
    0.26424330f, 0.11723379f, -0.14093105f, 0.01566784f, 0.05503124f, 0.14640163f, -0.08272632f, -0.16075844f, 
    0.00058386f, -0.03130064f, 0.00339671f, -0.04545730f, -0.13090809f, -0.31818834f, 0.15745723f, 0.20324388f, 
    0.00975975f, -0.09081835f, 0.15485692f, 0.22260411f, 0.06656767f, 0.06471498f, 0.07218467f, 0.07209059f, 
    0.32526463f, 0.02755717f, -0.02223634f, 0.30796403f, 0.06139181f, 0.10187477f, 0.19976600f, 0.07602523f, 
    -0.00773740f, -0.13455346f, -0.08915491f, -0.01928765f, -0.21796781f, -0.10272533f, 0.20228155f, -0.24801555f, 
    0.06807076f, 0.03553361f, -0.06713169f, 0.14649485f, -0.08111477f, 0.12268936f, -0.10558344f, 0.00177033f, 
    -0.36802515f, -0.00070470f, 0.22907670f, -0.25565779f, -0.04769375f, -0.01324872f, 0.14907788f, 0.01198556f, 
    0.02875722f, -0.04185989f, 0.10181975f, 0.22352336f, -0.08517351f, 0.11196852f, 0.26032099f, -0.01734155f, 
    0.02228426f, 0.08651774f, 0.11935128f, 0.12611546f, 0.06178886f, 0.24257731f, 0.17791201f, 0.05844777f, 
    0.03379213f, 0.08144615f, -0.04840069f, 0.05956567f, 0.04670905f, 0.24870601f, -0.06206935f, 0.22289646f, 
    0.00959079f, -0.08574434f, 0.23450997f, 0.11094139f, -0.08923417f, 0.09978579f, -0.14685248f, -0.03742006f, 
    0.12083045f, 0.07444306f, -0.06388658f, 0.07384894f, 0.07876512f, -0.09951779f, 0.01222222f, -0.15804154f, 
    0.08992814f, 0.24016337f, 0.06738051f, 0.08593556f, 0.09397275f, -0.01059264f, 0.01412980f, 0.07725712f, 
    -0.06853205f, 0.14625396f, -0.12356607f, 0.18553619f, -0.10658629f, -0.20772296f, 0.33073798f, -0.21649438f, 
    0.05983374f, -0.00841612f, 0.11069018f, -0.14267577f, -0.13759996f, -0.05768123f, -0.07967457f, -0.07873812f, 
    -0.27834028f, 0.10340455f, -0.03474870f, 0.16699067f, -0.00459797f, -0.05810881f, 0.06010984f, 0.19709331f, 
    -0.00575172f, 0.03352737f, 0.03497490f, 0.07423437f, -0.13710761f, -0.31774783f, 0.16238865f, 0.13856979f, 
    -0.01147193f, 0.03850653f, 0.14024748f, -0.02786932f, 0.13861293f, 0.00901929f, -0.01050105f, -0.13630076f, 
    0.00638669f, 0.10488733f, 0.00794787f, 0.02604145f, -0.18883781f, 0.19372089f, -0.06785342f, 0.08134072f, 
    -0.04960834f, 0.03736850f, -0.07170967f, 0.02049804f, -0.12836844f, 0.01709130f, -0.02345375f, -0.13212389f, 
    0.01790106f, -0.00331873f, 0.08956897f, 0.04893663f, 0.15608199f, 0.01874710f, -0.08709863f, 0.21421395f, 
    -0.01643734f, 0.14220394f, 0.08897123f, -0.00732954f, -0.03698511f, 0.13311045f, -0.07709197f, -0.05922485f, 
    -0.01044590f, -0.07851977f, -0.04146870f, -0.25327146f, 0.10658174f, 0.17290099f, 0.07910759f, 0.04818367f, 
    0.02496520f, 0.12372418f, 0.09971295f, 0.17385496f, 0.14995672f, 0.18549424f, -0.17330106f, 0.06225788f, 
    0.17383750f, 0.01088634f, -0.05668384f, 0.00167871f, -0.22720899f, 0.04810024f, 0.10595866f, -0.01730803f, 
    -0.01633302f, -0.04168503f, -0.05460996f, 0.00899072f, -0.15735723f, -0.08755242f, -0.04982553f, 0.06552012f, 
    -0.07340991f, -0.02799015f, -0.04847551f, 0.05727987f, 0.15436682f, 0.06178743f, -0.12934200f, 0.03875358f, 
    -0.31664640f, 0.06486382f, 0.28845176f, 0.16381085f, 0.00785588f, 0.03483306f, 0.05679099f, 0.09398253f, 
    0.08899981f, 0.17794360f, 0.00757338f, 0.11603897f, -0.12070766f, 0.23477247f, -0.02086520f, 0.15641454f, 
    0.07625102f, 0.13768813f, -0.00149001f, -0.03359461f, 0.12691782f, 0.07853440f, 0.04074946f, 0.16666344f, 
    -0.23790821f, 0.07035758f, 0.21287644f, -0.02184668f, 0.12640798f, 0.06636778f, 0.01625886f, -0.00387908f, 
    -0.10072499f, 0.16511127f, -0.02015411f, 0.16005057f, -0.00185217f, 0.22331811f, -0.11324765f, -0.06789958f, 
    0.04510001f, 0.04347084f, 0.15036750f, 0.03462539f, 0.06175672f, -0.10158634f, -0.09251425f, 0.05602271f, 
    0.09351353f, -0.12300912f, 0.00133396f, -0.04988620f, 0.09157836f, -0.15655036f, 0.02820606f, 0.04341805f, 
    0.03248030f, -0.06253664f, -0.06447902f, 0.00758883f, 0.60453874f, -0.09403549f, 0.17736433f, 0.14674519f, 
    0.04930901f, 0.10424954f, -0.04805202f, 0.24949993f, -0.08522535f, 0.08668381f, 0.02333805f, 0.05622952f, 
    0.17137167f, 0.14819591f, 0.12147313f, -0.04427209f, 0.17390072f, 0.08870602f, -0.15936023f, 0.04735192f, 
    -0.07868998f, -0.02281040f, 0.05824737f, 0.13818198f, 0.05990350f, 0.18687180f, -0.09520404f, -0.29314619f, 
    0.16650207f, 0.06328701f, -0.02644866f, 0.05311856f, -0.03646971f, -0.18423782f, 0.03492114f, -0.06857110f, 
    -0.29519919f, -0.02980609f, -0.21599273f, 0.09555791f, -0.13942374f, -0.01424759f, 0.07343468f, 0.19232631f, 
    0.06021820f, 0.09193890f, 0.17434643f, 0.15265028f, 0.11115612f, -0.16741261f, -0.06504502f, 0.08654347f, 
    -0.07655654f, -0.08147389f, -0.17276293f, 0.01365076f, -0.05008166f, 0.19314772f, -0.04285657f, 0.13824311f, 
    -0.05685026f, 0.10602540f, -0.00750446f, 0.04114683f, -0.00373933f, -0.09806110f, 0.12810431f, 0.11865673f, 
    -0.09049760f, -0.02351428f, 0.25310445f, 0.10138344f, 0.20080781f, 0.30539578f, -0.19551283f, -0.09824540f, 
    0.13408485f, -0.06838221f, 0.14298576f, 0.14580898f, -0.02653782f, 0.01963816f, 0.05886415f, -0.03553809f, 
    -0.14663754f, 0.17063469f, 0.35785490f, -0.05289432f, 0.09625892f, 0.04660420f, -0.02664099f, 0.03716615f, 
    0.07214630f, -0.06780155f, -0.05578551f, -0.13348296f, 0.24519661f, 0.01288547f, 0.00192345f, 0.08442507f, 
    -0.09358729f, 0.04185494f, 0.11102614f, 0.17211519f, -0.01680994f, 0.14225942f, 0.16546287f, 0.20186712f, 
    -0.04694298f, -0.00882706f, -0.03037573f, -0.00131440f, -0.02045813f, -0.01803339f, -0.01815420f, -0.05332939f, 
    -0.03486305f, 0.01896228f, 0.03143923f, -0.03286722f, 0.00730314f, -0.01045303f, 0.02663165f, -0.04287947f, 
    -0.05142401f, 0.00485016f, -0.00951103f, -0.04419162f, 0.00311388f, 0.03690109f, 0.02572751f, 0.03747447f, 
    -0.00571116f, -0.02277393f, -0.02211859f, -0.04479615f, -0.04859971f, 0.02522939f, -0.02470559f, 0.02767182f, 
    0.02013494f, -0.00929631f, -0.04446124f, -0.00951697f, 0.03758093f, -0.01391895f, 0.03657082f, -0.04989740f, 
    -0.05725916f, 0.01395559f, 0.02114060f, -0.03008218f, 0.03534308f, -0.02415968f, -0.02321223f, -0.01280812f, 
    0.03599484f, -0.00339566f, -0.00152796f, 0.00281676f, 0.00598743f, 0.03504254f, -0.00521260f, 0.03655314f, 
    -0.05669022f, 0.03030210f, -0.05422331f, 0.04328395f, 0.01021514f, -0.02740978f, -0.01560815f, -0.03573034f, 
    -0.00310000f, -0.03237832f, 0.01343056f, -0.03141993f, 0.03549652f, -0.04882731f, -0.00337590f, -0.01467857f, 
    0.01785426f, 0.03770346f, 0.01509772f, -0.02734580f, 0.03677722f, -0.02828210f, -0.04398240f, -0.02413724f, 
    -0.02737886f, -0.02909449f, 0.03319133f, -0.01992663f, -0.02906939f, -0.04918324f, 0.04652504f, -0.02844532f, 
    -0.03274921f, -0.02168456f, 0.03188040f, -0.04501463f, -0.00673538f, 0.02989637f, 0.01325328f, -0.05037423f, 
    0.00708826f, 0.00118089f, -0.02481849f, 0.03501295f, 0.02833780f, 0.03406918f, -0.01202307f, 0.02302367f, 
    0.03460978f, 0.01091907f, 0.00286150f, -0.00655628f, 0.02658164f, -0.05169980f, -0.02114058f, -0.03799955f, 
    0.03478204f, 0.03537896f, 0.01794885f, 0.00817233f, 0.04172662f, -0.01386371f, -0.03248456f, -0.00481772f, 
    0.03141646f, -0.00318917f, -0.03890425f, 0.01989059f, -0.03842359f, 0.02951366f, -0.05093782f, -0.05894083f, 
    0.03736286f, 0.02115177f, -0.00604908f, -0.04466633f, -0.04611862f, -0.03132775f, -0.02859998f, 0.03154037f, 
    0.03801143f, 0.03313713f, 0.02735872f, 0.00851609f, -0.04733803f, -0.04021582f, -0.03394441f, 0.02834310f, 
    0.04417793f, -0.04149652f, 0.02506523f, 0.01591249f, -0.02713979f, -0.04268716f, -0.04190297f, 0.01314957f, 
    0.02660972f, -0.01321288f, 0.03066685f, -0.03360806f, -0.04767919f, -0.00394072f, -0.04154184f, 0.04270165f, 
    0.02946198f, 0.01563739f, -0.00079483f, 0.00933967f, -0.04528479f, 0.00235320f, -0.04694939f, 0.01598462f, 
    0.01550100f, -0.01349706f, 0.03495536f, 0.02244706f, -0.03712008f, -0.04768582f, 0.04234852f, -0.04049124f, 
    0.03030385f, -0.02784812f, 0.04350752f, -0.02475471f, 0.01852127f, -0.01456084f, -0.05144643f, -0.04709085f, 
    -0.03495243f, -0.00669710f, -0.05113376f, -0.02296552f, -0.05373864f, 0.01659768f, -0.03601340f, -0.01310644f, 
    -0.02610100f, 0.04236711f, 0.02875119f, -0.05116602f, -0.03716034f, -0.03202868f, 0.02293772f, -0.05334195f, 
    -0.03628597f, -0.00701318f, 0.03254502f, -0.04452898f, -0.05460594f, -0.04948322f, -0.03090200f, 0.01882304f, 
    0.02482923f, 0.02630481f, -0.04892533f, -0.00551767f, -0.03070748f, -0.04627949f, 0.01649867f, -0.02899456f, 
    0.00932987f, -0.03686077f, 0.03191922f, -0.01146194f, -0.00173895f, -0.02065420f, -0.01452399f, 0.02776132f, 
    -0.01380087f, 0.01498478f, -0.04914170f, -0.02726728f, 0.00149901f, -0.04067316f, -0.04257336f, -0.03268584f, 
    0.01001893f, 0.02188737f, 0.03218165f, -0.02982297f, -0.03314019f, -0.00769996f, 0.03512865f, -0.02459860f, 
    -0.05601856f, 0.03991650f, 0.01053807f, 0.01733712f, -0.01594494f, 0.02913693f, 0.02595538f, -0.01776750f, 
    -0.01721309f, -0.04016624f, 0.03564477f, 0.03978898f, 0.03231290f, 0.03482058f, -0.03343691f, -0.05888757f, 
    -0.04908992f, 0.02933964f, -0.03290359f, -0.03680197f, -0.04045013f, 0.03742646f, -0.01732300f, -0.05197462f, 
    0.00022455f, -0.03450998f, 0.02928913f, 0.02202270f, 0.01569539f, 0.01823635f, 0.03268918f, -0.03460195f, 
    0.00199347f, 0.02209550f, 0.03161209f, 0.01679297f, -0.00082873f, 0.02663465f, -0.02845580f, 0.01933555f, 
    0.01985056f, -0.02002107f, 0.03252721f, -0.02730292f, -0.03767115f, -0.02334830f, -0.00826682f, 0.02313050f, 
    -0.03949035f, 0.03106373f, -0.05488754f, -0.05566157f, -0.02124852f, -0.03087835f, 0.00461092f, -0.03289954f, 
    0.03121646f, -0.01519752f, -0.01924049f, -0.02768338f, 0.01651224f, -0.05208144f, -0.03526034f, -0.05282722f, 
    -0.02625188f, -0.04158248f, -0.05296857f, -0.02354410f, -0.02133433f, 0.04158971f, -0.04852484f, 0.02444863f, 
    0.00268080f, -0.00660209f, 0.02057808f, -0.00330277f, 0.02502117f, -0.02977089f, -0.03477043f, -0.05507316f, 
    -0.04245274f, 0.01243692f, 0.04288658f, -0.01753391f, 0.01191267f, -0.05742305f, 0.03775181f, 0.04135567f, 
    -0.00561951f, 0.01616799f, -0.00417612f, 0.00039308f, -0.02731548f, 0.01027353f, -0.05184370f, 0.01723992f, 
    -0.04311863f, 0.00759678f, -0.00635901f, 0.01125758f, 0.02369130f, 0.03899824f, 0.03550978f, -0.02345917f, 
    0.00812565f, 0.03435844f, -0.00386512f, -0.00013227f, -0.00104720f, 0.01439746f, -0.05228312f, -0.00558522f, 
    -0.00202984f, -0.04588122f, -0.00634063f, -0.00612985f, -0.01024203f, -0.03395064f, -0.00446509f, -0.02899476f, 
    0.02760080f, -0.02806352f, 0.00381119f, 0.00008513f, 0.00561039f, 0.04767929f, -0.00467651f, 0.01083776f, 
    -0.05886990f, -0.03540556f, -0.03872277f, 0.01413799f, 0.02060259f, -0.05390094f, 0.02244775f, 0.02050722f, 
    0.00247047f, -0.04174348f, 0.01601750f, 0.02553547f, -0.04686144f, -0.02618573f, 0.01083193f, 0.01913841f, 
    -0.03984991f, -0.01591137f, -0.03589732f, 0.00905028f, -0.05919948f, 0.02168421f, -0.01030509f, 0.01377117f, 
    -0.06742375f, 0.02531712f, -0.04906364f, -0.04351734f, 0.00490298f, -0.00564746f, -0.02180909f, -0.06774745f, 
    0.00331752f, -0.00344561f, -0.03087466f, 0.01468526f, -0.05134759f, -0.03000683f, -0.06477900f, 0.02945260f, 
    -0.05009494f, -0.00707948f, -0.04298795f, -0.05853872f, -0.06728511f, -0.01410334f, 0.00722308f, 0.00419983f, 
    -0.04422664f, -0.05882524f, 0.02712594f, -0.02028193f, -0.03233723f, -0.02383745f, -0.05752651f, 0.00591874f, 
    0.02650620f, -0.04272464f, -0.01704543f, -0.00891792f, -0.02833756f, -0.06321360f, -0.01180707f, 0.00876916f, 
    -0.02900663f, -0.04799651f, -0.00274819f, -0.04626360f, -0.00926185f, 0.03193314f, -0.05000374f, -0.06264592f, 
    -0.04813834f, -0.03191606f, 0.03102040f, -0.06651421f, -0.04808117f, -0.04901326f, 0.01004421f, -0.05472538f, 
    0.01864535f, 0.02830655f, -0.04562537f, -0.05159043f, -0.04428123f, -0.06638999f, -0.05147454f, -0.00145794f, 
    -0.06767464f, 0.01043271f, 0.02105398f, -0.01710959f, -0.02216201f, -0.01750170f, -0.04989290f, -0.03018041f, 
    -0.04901683f, 0.00518166f, 0.00136652f, -0.06041299f, -0.01425792f, 0.01848887f, -0.05788996f, -0.03166901f, 
    0.00750887f, -0.04407573f, 0.02674980f, 0.02263236f, -0.02503728f, 0.01101788f, -0.05605144f, -0.06586156f, 
    -0.01795602f, -0.05008293f, -0.04587016f, 0.00066147f, -0.05546964f, -0.00689828f, -0.06024768f, -0.01365071f, 
    0.02702143f, -0.01773748f, -0.00670012f, -0.03277501f, -0.06334653f, 0.00566454f, 0.02570357f, -0.00477922f, 
    -0.05553088f, -0.04331810f, -0.02866569f, -0.03177889f, -0.06276653f, 0.00797350f, -0.03966242f, -0.01621349f, 
    -0.00165875f, -0.05151036f, 0.01905968f, -0.06546167f, -0.06406198f, 0.00799790f, 0.02396806f, -0.03448522f, 
    0.02150931f, -0.05139588f, -0.00455837f, -0.06496090f, -0.00376437f, 0.02923168f, 0.02097172f, -0.01016582f, 
    -0.01747691f, -0.03484835f, -0.04025020f, -0.00108237f, -0.06347726f, -0.00729140f, -0.03679240f, -0.06412420f, 
    -0.03479609f, -0.06698558f, -0.01724596f, 0.00024551f, 0.04225281f, -0.02310198f, -0.02854203f, -0.02277563f, 
    -0.00815749f, -0.04101706f, -0.02419793f, 0.00473825f, -0.02592090f, -0.02888593f, -0.00647403f, -0.01013729f, 
    -0.00413015f, 0.02316284f, -0.02404151f, -0.04104213f, -0.02856512f, 0.01190169f, -0.03744005f, 0.02695977f, 
    0.03809666f, 0.03056210f, 0.02477753f, 0.01027814f, -0.05674709f, -0.01140739f, -0.01600914f, -0.01180474f, 
    -0.03374910f, -0.02851236f, -0.04769731f, -0.06345681f, -0.00311920f, -0.04139040f, 0.03276484f, -0.05415463f, 
    0.00834293f, -0.02141017f, 0.00046551f, 0.00087124f, -0.04913342f, -0.01039643f, 0.01492130f, -0.00164508f, 
    0.00371286f, 0.03287584f, -0.05226491f, 0.03020388f, -0.02493703f, -0.05915516f, -0.00398603f, -0.04940856f, 
    0.02201642f, -0.03998931f, -0.04124488f, -0.05392371f, -0.04221888f, -0.02963304f, -0.00212235f, -0.05486808f, 
    -0.02828129f, -0.02952941f, 0.01174896f, 0.01665603f, 0.02760221f, -0.06185704f, -0.02608183f, -0.06101472f, 
    0.03218192f, 0.02339886f, 0.02184113f, 0.00230118f, -0.01639970f, -0.04731129f, -0.04273357f, 0.04105088f, 
    -0.00848027f, -0.02029746f, 0.01740674f, 0.02722870f, 0.00504511f, 0.00911369f, -0.03065884f, -0.02941727f, 
    0.02154714f, -0.04669186f, -0.05521235f, -0.02855312f, 0.00866437f, -0.05220501f, -0.05951385f, -0.04215468f, 
    0.02584900f, 0.02382817f, -0.04196797f, 0.03400184f, -0.02948718f, -0.04076395f, 0.00056236f, -0.04324072f, 
    0.00996231f, -0.04417330f, -0.03874034f, -0.01466895f, -0.00078569f, 0.02407317f, -0.04228560f, -0.00765441f, 
    -0.02166595f, -0.01336977f, 0.00320538f, -0.00237796f, -0.01640194f, -0.01222999f, -0.05381773f, -0.04259652f, 
    0.01734763f, -0.00995840f, -0.00067109f, -0.00286594f, -0.02486475f, -0.04980472f, -0.00057660f, 0.00633509f, 
    -0.01038489f, -0.05857843f, 0.01005471f, 0.00718252f, 0.01345527f, -0.06449523f, -0.04170401f, -0.06547000f, 
    -0.01199141f, -0.00540403f, -0.06642170f, -0.04327734f, -0.04036926f, 0.01509309f, -0.02258370f, -0.01027250f, 
    -0.05537507f, -0.06481031f, 0.01303005f, -0.02232759f, -0.03956538f, 0.02238326f, 0.02667198f, -0.02797710f, 
    -0.03242279f, 0.00863901f, -0.01205085f, -0.04665551f, -0.00109959f, 0.03655325f, -0.03793138f, -0.05508105f, 
    0.01129697f, -0.01894173f, -0.04894691f, -0.05321941f, -0.00348532f, -0.03539645f, 0.00261812f, -0.00533571f, 
    -0.03608396f, -0.05286776f, -0.04008130f, -0.06593896f, -0.01183305f, -0.01837379f, 0.02049741f, 0.03050741f, 
    0.03002285f, -0.02527196f, 0.00545788f, -0.05315140f, -0.01410375f, 0.00202507f, 0.01720176f, 0.00316761f, 
    -0.00142610f, -0.01422232f, -0.04351336f, 0.00679345f, -0.00173719f, -0.04216002f, 0.02380413f, 0.01788216f, 
    -0.04233655f, -0.03199437f, -0.04214454f, 0.01003285f, -0.03525719f, -0.02596338f, -0.04360997f, -0.06227016f, 
    -0.01970017f, -0.00522175f, -0.02488455f, -0.02361624f, -0.00813397f, -0.04906085f, -0.05040370f, -0.03966928f, 
    -0.02248132f, -0.02786412f, -0.05848337f, 0.01843397f, 0.02549190f, -0.01541313f, -0.00327590f, -0.00296727f, 
    -0.02610768f, -0.00092338f, -0.04135957f, -0.03702839f, -0.06186234f, 0.00186884f, -0.00922170f, -0.00264149f, 
    -0.01471298f, 0.02467537f, -0.03530099f, -0.00606384f, 0.00162558f, -0.05965777f, 0.02534059f, 0.02398886f, 
    -0.04590528f, -0.06337500f, -0.00346249f, -0.02084092f, 0.02681311f, -0.03428698f, -0.00887133f, -0.04579923f, 
    0.17295098f, -0.00346485f, 0.37674835f, 0.12963450f, 0.01138821f, 0.04341676f, 0.06027879f, -0.03666146f, 
    0.12721574f, -0.14305796f, 0.11543007f, -0.08974909f, 0.40207058f, 0.21827699f, 0.09149679f, 0.35283130f, 
    -0.17641127f, -0.08472604f, -0.05217730f, -0.09437201f, -0.05190304f, -0.03784103f, -0.01842327f, 0.02306855f, 
    -0.10721390f, -0.10192986f, -0.06088166f, -0.26858574f, -0.02226671f, -0.06435832f, -0.05000217f, 0.00840768f, 
    -0.06895379f, -0.11231767f, -0.12487257f, 0.07461049f, 0.07596240f, 0.35342070f, 0.14994396f, 0.06879383f, 
    0.21390848f, -0.04781613f, -0.09457755f, 0.01928997f, 0.00799687f, -0.01708231f, -0.07984247f, 0.08020537f, 
    0.11675820f, 0.08293444f, 0.16183457f, 0.22100644f, -0.04844881f, 0.06078614f, -0.09375957f, 0.15811050f, 
    0.08928584f, -0.01108222f, 0.05373576f, -0.08394921f, -0.15732361f, 0.01381114f, -0.19964927f, -0.07364731f, 
    -0.02212841f, 0.03902856f, 0.03607885f, 0.08108308f, 0.12740442f, 0.12142189f, 0.15963884f, 0.16425757f, 
    -0.09506601f, -0.43863940f, 0.19849077f, -0.05427326f, 0.01520694f, 0.06757339f, 0.10338463f, 0.12475647f, 
    0.30698302f, 0.10580776f, 0.14497152f, 0.07455695f, 0.20208457f, -0.06501485f, 0.03009618f, -0.04287956f, 
    0.06432695f, 0.05953908f, 0.14066616f, -0.03689235f, -0.05600512f, -0.00011649f, -0.01403448f, -0.14040951f, 
    -0.01334547f, -0.07571109f, -0.27687201f, -0.33474752f, -0.08152379f, -0.00893120f, -0.04951063f, -0.10562620f, 
    -0.07260891f, -0.11154500f, 0.05241051f, 0.08567935f, 0.13286202f, -0.23192354f, 0.00368662f, 0.20025265f, 
    0.06008818f, 0.10644116f, -0.03566650f, -0.03468679f, -0.03443257f, -0.00887079f, -0.00721385f, -0.11876108f, 
    0.19804023f, 0.10119273f, 0.14618614f, 0.13125166f, -0.03134535f, 0.02758927f, 0.01480788f, -0.02256621f, 
    -0.08670150f, -0.03864051f, 0.04552059f, -0.02808258f, 0.21455017f, 0.34282625f, -0.07767922f, 0.11377557f, 
    0.02016737f, 0.01016649f, 0.14898625f, -0.02212749f, 0.00452709f, -0.06132654f, -0.06386818f, -0.08127729f, 
    0.03510612f, -0.08304138f, -0.11555333f, -0.27527228f, -0.03243135f, -0.03208245f, 0.09473026f, -0.03103175f, 
    0.13568246f, -0.01428519f, 0.10632871f, 0.06197267f, 0.46779752f, 0.21712829f, 0.05224711f, 0.04324882f, 
    -0.30093539f, -0.04187738f, 0.02185978f, -0.03261268f, 0.13652056f, -0.09984069f, -0.01864670f, 0.07258239f, 
    -0.08695847f, -0.06712913f, -0.38307703f, -0.01180157f, 0.16063964f, -0.04720707f, 0.00255355f, -0.06331813f, 
    0.01717655f, -0.08898005f, 0.02239027f, -0.11672436f, -0.06541406f, 0.08971090f, 0.10830852f, -0.14802890f, 
    0.07866874f, 0.05493445f, -0.08295742f, -0.06896168f, 0.17295478f, 0.00612234f, -0.06953260f, 0.07526828f, 
    0.16720641f, -0.19716290f, -0.06149323f, 0.16524579f, 0.06694198f, 0.04821406f, -0.09971312f, 0.13391578f, 
    -0.10710146f, 0.20082884f, -0.05638791f, -0.02403593f, -0.15121801f, -0.11124515f, 0.09990086f, 0.06484146f, 
    0.06593719f, -0.05792504f, -0.04729468f, -0.02708001f, -0.07681506f, 0.02866847f, -0.05272830f, -0.09935520f, 
    -0.05953226f, -0.13439356f, -0.04183111f, 0.08493243f, 0.04979196f, -0.00025696f, 0.23968513f, 0.01316338f, 
    -0.16957748f, 0.10566675f, -0.00239719f, 0.09240925f, 0.28888327f, 0.00484308f, 0.04006099f, 0.07371226f, 
    -0.17883126f, 0.01228399f, 0.09141460f, 0.09087878f, -0.10351706f, 0.06314451f, 0.15543823f, 0.06303384f, 
    0.35637650f, -0.00430698f, 0.05379102f, 0.18429989f, -0.21076448f, 0.00585586f, 0.00416953f, -0.10084243f, 
    -0.04804171f, 0.02169361f, -0.06806768f, 0.14091945f, 0.12242536f, -0.05161382f, 0.00158390f, 0.34097019f, 
    -0.00399433f, 0.01546493f, 0.06628952f, 0.09822264f, -0.09254548f, 0.00919800f, 0.01025795f, -0.13882619f, 
    -0.43479368f, 0.07935233f, 0.38496000f, 0.13185188f, 0.08125340f, 0.10850287f, -0.03992494f, 0.27404046f, 
    -0.15483792f, 0.06127330f, -0.08437282f, -0.11251425f, -0.34965199f, 0.24303573f, -0.10926880f, -0.04174867f, 
    -0.06397993f, -0.02475382f, -0.01702656f, 0.11874809f, 0.00003278f, -0.01782644f, 0.01788005f, -0.01333086f, 
    0.02483417f, -0.01841215f, -0.21061850f, -0.04307977f, -0.02765736f, -0.05686599f, -0.08119062f, 0.04326209f, 
    -0.06490277f, 0.06551629f, 0.14496253f, 0.07623105f, 0.11410784f, -0.15761794f, 0.04925525f, 0.02136769f, 
    0.07487895f, -0.06228881f, 0.03770673f, 0.10968933f, 0.18491128f, -0.00994501f, 0.05813885f, 0.03484435f, 
    -0.12198646f, 0.02529435f, 0.27462226f, 0.20225713f, 0.02493459f, 0.00187030f, 0.01805322f, 0.13974838f, 
    -0.18191662f, -0.03112162f, -0.07153790f, 0.12402072f, 0.31977630f, 0.29724288f, 0.03854731f, 0.00154358f, 
    -0.16071996f, -0.05537941f, -0.10087079f, -0.00898844f, -0.14262059f, 0.17301610f, 0.03391076f, -0.11528187f, 
    0.18762028f, 0.08526895f, 0.02556122f, 0.30458131f, -0.04141072f, 0.02228938f, 0.10582057f, -0.11380631f, 
    -0.03867945f, 0.06243127f, 0.00367205f, -0.03733401f, -0.13883436f, -0.33092779f, -0.00644289f, -0.34186336f, 
    -0.01203630f, -0.02203256f, -0.02159154f, -0.07534980f, -0.10188533f, 0.02086975f, 0.04989120f, -0.08819522f, 
    0.00674485f, -0.09463353f, -0.12361781f, 0.22096364f, 0.12970704f, 0.02438690f, -0.09039719f, -0.07352522f, 
    -0.03045044f, -0.09472735f, -0.04744149f, -0.03685563f, -0.43351436f, 0.07563497f, -0.13990946f, -0.09957340f, 
    -0.06338345f, 0.10283790f, -0.01713504f, 0.03114785f, 0.01883743f, 0.12887515f, 0.18934233f, 0.09469742f, 
    -0.32760590f, 0.13653633f, 0.08595674f, -0.16229196f, 0.03270955f, -0.22515719f, 0.08207371f, -0.10294555f, 
    0.03271043f, 0.06303455f, -0.18497650f, 0.04529305f, 0.12833066f, 0.19506088f, -0.17703408f, 0.28332585f, 
    0.02340411f, 0.07577609f, -0.08584512f, -0.03115081f, 0.03515654f, -0.01075023f, 0.00567595f, -0.06129048f, 
    0.09219317f, -0.32241434f, 0.05767365f, -0.28314444f, -0.01651216f, -0.10149702f, -0.10972320f, 0.17046547f, 
    0.03558512f, 0.12595588f, 0.12696138f, 0.05314267f, 0.12998077f, -0.25300288f, -0.14782843f, 0.26430938f, 
    0.16006729f, 0.00711526f, 0.25024366f, -0.03822212f, -0.05505185f, -0.03098323f, 0.14490411f, 0.03191742f, 
    0.20406307f, -0.23583570f, 0.04600876f, 0.28503826f, -0.07001181f, -0.02028144f, 0.14149871f, -0.07229891f, 
    0.00340272f, -0.09260834f, -0.09180546f, 0.20100556f, -0.05200879f, -0.11496212f, 0.01671004f, -0.02409541f, 
    0.06003688f, -0.07803822f, -0.04807146f, -0.03827639f, 0.15498680f, -0.01349857f, -0.05783298f, 0.13048054f, 
    -0.11187532f, 0.11937497f, -0.01339254f, -0.31402272f, 0.23536351f, -0.08276396f, -0.02479890f, -0.05386975f, 
    -0.10960948f, 0.07007109f, -0.22609451f, 0.04011106f, -0.11835641f, 0.01246342f, 0.19209473f, 0.00344508f, 
    0.06593854f, -0.02112592f, -0.04206802f, 0.16171482f, 0.06441601f, 0.07086588f, 0.09328589f, 0.13393919f, 
    0.08910273f, 0.19182904f, 0.00401339f, -0.08937844f, 0.15110502f, 0.10426936f, 0.06164349f, 0.17382748f, 
    0.14135017f, -0.04830692f, 0.05973421f, -0.15878357f, 0.59669387f, -0.16533889f, -0.05801570f, 0.14196700f, 
    -0.09767502f, 0.03985562f, -0.03701403f, -0.00579055f, 0.16555069f, 0.19669877f, 0.05914116f, 0.17068823f, 
    -0.58669603f, -0.08758276f, 0.03751609f, 0.15446521f, 0.08488128f, 0.15910408f, 0.01556660f, -0.01354428f, 
    0.03246601f, 0.04393490f, 0.07212313f, -0.08582021f, 0.25826839f, 0.03276623f, -0.01355387f, -0.03639493f, 
    0.01897513f, -0.02267095f, 0.02609203f, 0.04199965f, 0.05118867f, 0.01853504f, 0.16095987f, 0.19479984f, 
    0.17829773f, -0.07071566f, 0.25782570f, -0.25774914f, 0.22395714f, 0.07588435f, -0.07584471f, 0.01354447f, 
    0.18722621f, -0.10479483f, 0.07082152f, 0.03440711f, -0.10023867f, -0.22108145f, 0.15098053f, -0.03556781f, 
    0.21498588f, -0.02154885f, 0.10113700f, -0.00556894f, 0.14675248f, 0.08390820f, 0.04359195f, -0.03314750f, 
    0.00557121f, 0.05844231f, -0.03660857f, -0.00544731f, 0.06188463f, -0.11895743f, -0.13500606f, 0.08333729f, 
    0.07497550f, 0.10358171f, -0.00557013f, 0.15613185f, -0.01856092f, -0.14280970f, -0.01102812f, -0.10957663f, 
    0.07380906f, -0.04598352f, -0.09420305f, 0.07412600f, -0.01011531f, 0.10543154f, 0.16942328f, -0.05034706f, 
    -0.18187633f, 0.18062010f, -0.11769755f, 0.36921090f, 0.03478227f, 0.12599175f, -0.08163000f, -0.16580075f, 
    0.12747663f, 0.00683113f, 0.03143272f, -0.04833271f, 0.04488268f, 0.15766682f, 0.00092061f, -0.41388726f, 
    0.10465402f, -0.02601720f, 0.05636907f, 0.05258651f, -0.07827844f, -0.03634368f, 0.05948370f, 0.20341717f, 
    -0.13360432f, 0.02873569f, -0.15422429f, 0.41059548f, -0.03167978f, 0.18845563f, 0.02481306f, 0.02040213f, 
    0.19220878f, -0.09371822f, -0.01184129f, -0.10039002f, -0.79420549f, 0.30607107f, -0.25809884f, -0.29203451f, 
    0.21690424f, -0.22443898f, -0.06039248f, 0.14451779f, 0.05074161f, -0.06257047f, 0.06599618f, -0.01937005f, 
    -0.19160940f, 0.04827094f, -0.03524865f, 0.27115494f, 0.12446757f, 0.09098762f, 0.00383473f, -0.00360863f, 
    0.28158882f, -0.09389914f, 0.06589273f, -0.13077274f, -0.05859938f, 0.20801321f, -0.30349267f, 0.11544113f, 
    -0.05918824f, -0.03921255f, 0.01069773f, 0.04492479f, 0.00910526f, 0.02515075f, 0.06294771f, 0.00013005f, 
    -0.02232259f, -0.09754194f, -0.07673375f, 0.21043639f, -0.16060613f, -0.02927861f, 0.02383077f, -0.06628710f, 
    -0.02468561f, 0.05884568f, 0.23325063f, 0.16021030f, -0.24944386f, -0.38121268f, 0.00432988f, 0.21567318f, 
    -0.00808005f, -0.04689793f, 0.13386559f, -0.12209813f, -0.04414116f, 0.05085694f, -0.03438067f, 0.12156618f, 
    0.04673866f, 0.32582662f, 0.26516604f, 0.10062267f, -0.10721343f, -0.07950527f, 0.03210976f, -0.11949831f, 
    0.24552649f, -0.14360720f, 0.15745968f, -0.02641127f, -0.12639041f, 0.07657414f, 0.21390046f, -0.17529213f, 
    0.02187346f, -0.07716137f, 0.04962150f, 0.00109300f, 0.05401714f, -0.04885777f, 0.04619231f, 0.09705103f, 
    -0.38102734f, -0.11004165f, -0.01595545f, -0.14443600f, 0.15466796f, 0.11420709f, 0.01970805f, -0.10530145f, 
    0.05166897f, -0.14116411f, 0.04744513f, -0.08274617f, 0.31594914f, 0.10784249f, -0.08024793f, -0.08091528f, 
    0.13553560f, 0.22384664f, 0.21937346f, 0.01411158f, -0.07181377f, -0.12126658f, 0.12832181f, 0.06171264f, 
    0.02366924f, 0.17352116f, -0.11389151f, 0.27893659f, 0.04132799f, -0.00717405f, -0.13182609f, 0.01643864f, 
    0.02636884f, -0.07666130f, -0.09976043f, 0.10177107f, 0.09880666f, 0.29164571f, 0.01528652f, -0.17084274f, 
    0.12329227f, -0.01397006f, 0.05545431f, -0.05161068f, 0.04949834f, 0.05342470f, -0.01210414f, 0.08412134f, 
    0.03253045f, 0.11715215f, -0.20086043f, -0.03783417f, -0.06973290f, -0.10056739f, 0.05310791f, 0.09515226f, 
    0.04241255f, 0.21721295f, 0.09652852f, 0.14604756f, -0.12498070f, -0.11144157f, 0.13563922f, -0.16441019f, 
    0.15322013f, 0.04092058f, -0.13902903f, 0.06409953f, 0.24498120f, -0.17672995f, -0.07757252f, -0.08709981f, 
    0.45820147f, -0.03017102f, 0.17951815f, -0.04082316f, 0.19334485f, 0.11392534f, 0.06129920f, -0.06372189f, 
    0.01175680f, 0.02109441f, 0.03060418f, -0.03904840f, 0.19117282f, 0.05019080f, 0.04931839f, 0.12772284f, 
    -0.01626986f, 0.08495296f, -0.12658229f, 0.03853875f, 0.01901343f, 0.01931264f, 0.01656224f, 0.01716123f, 
    0.00238320f, 0.02377408f, 0.31357044f, 0.04246983f, 0.05404458f, -0.00576361f, 0.07073332f, -0.06836451f, 
    -0.03763520f, -0.02559794f, 0.01370973f, -0.08346391f, -0.25829977f, 0.10676385f, 0.17736475f, 0.23930342f, 
    -0.03580960f, 0.03471401f, -0.01303170f, 0.05079649f, -0.03119648f, 0.05022749f, -0.02887415f, 0.24742228f, 
    0.14320368f, -0.08649442f, 0.10112902f, 0.38414994f, -0.06548427f, -0.08827360f, 0.00009529f, 0.25808606f, 
    0.01337615f, 0.02453178f, 0.13228218f, 0.07870187f, 0.23451205f, 0.06591079f, -0.14193331f, 0.10688211f, 
    -0.04874280f, -0.03356935f, 0.00367153f, 0.07622597f, -0.10066226f, -0.02757061f, 0.13399807f, 0.02646299f, 
    -0.09228724f, 0.01597352f, 0.10010803f, 0.01558691f, -0.02358854f, -0.00125415f, 0.18755224f, -0.13842058f, 
    0.06977435f, -0.01111895f, -0.01148236f, -0.15738268f, -0.16550131f, 0.01287691f, 0.09004429f, -0.40165991f, 
    0.13870370f, 0.00561583f, 0.07071137f, -0.04641514f, 0.06703580f, 0.09729499f, 0.05435985f, -0.12481564f, 
    0.24640347f, -0.05251275f, 0.18790300f, 0.23474802f, -0.14031951f, 0.02685354f, -0.00282077f, 0.05764196f, 
    0.07404943f, -0.11225440f, -0.05790158f, -0.02285856f, 0.16077383f, 0.05252763f, -0.07678647f, 0.21016301f, 
    -0.06056678f, -0.08461835f, 0.08896175f, 0.09050310f, 0.04567064f, 0.04017478f, 0.03486347f, -0.12112173f, 
    -0.29510155f, -0.04474694f, -0.20811658f, -0.20939739f, 0.15731010f, 0.21215752f, 0.02435351f, -0.10454679f, 
    -0.06364095f, -0.04363144f, 0.07380600f, 0.01156128f, -0.24808161f, 0.01572492f, -0.11928880f, 0.13139901f, 
    0.00161285f, -0.03911002f, -0.02853648f, 0.10033891f, 0.14259800f, 0.07951824f, 0.05404481f, 0.04947848f, 
    0.31046695f, 0.02178154f, -0.14079057f, 0.10389878f, -0.10705981f, -0.02978789f, -0.00561780f, 0.01390286f, 
    0.15158759f, -0.07309720f, 0.08101828f, -0.10534299f, -0.06061571f, -0.01739920f, -0.02712135f, 0.04688930f, 
    0.12239794f, 0.10533138f, -0.04896418f, 0.10852288f, -0.14299539f, 0.11371730f, 0.30276623f, 0.04977185f, 
    0.20726530f, -0.15467386f, -0.03402360f, 0.32580319f, -0.10120128f, 0.03068507f, -0.03004876f, -0.01549294f, 
    0.08329199f, -0.02385810f, -0.18786472f, 0.00926924f, 0.37852868f, 0.12300337f, 0.10176168f, 0.28047970f, 
    -0.01552865f, 0.14628276f, 0.10965229f, -0.00041577f, -0.03326760f, -0.08488581f, 0.24565414f, 0.15077929f, 
    0.41177827f, -0.02803059f, 0.02864042f, 0.01680053f, -0.10205241f, -0.12517178f, -0.02868520f, 0.16008280f, 
    0.01865426f, 0.11018062f, -0.02577727f, -0.10326202f, -0.23456056f, -0.20272763f, 0.18686506f, 0.12263192f, 
    0.08704265f, -0.05309407f, 0.10407395f, -0.18784142f, -0.10531770f, 0.01247688f, 0.04315079f, -0.01094483f, 
    0.06954987f, -0.27978012f, -0.05813789f, 0.00694874f, -0.04654402f, -0.04264740f, -0.06681126f, 0.00891314f, 
    0.02923418f, 0.20382199f, -0.08647331f, 0.11339542f, -0.49442631f, 0.37969518f, 0.09096368f, -0.22365224f, 
    0.06457613f, 0.06653524f, 0.02890271f, -0.03732542f, 0.07566076f, 0.04817145f, 0.01965127f, -0.04780063f, 
    0.05623652f, -0.18207724f, -0.19771105f, 0.15287989f, -0.03682633f, -0.07247411f, -0.01002115f, 0.15241535f, 
    0.07529619f, -0.00035838f, 0.01408771f, 0.02130500f, 0.43561947f, -0.06218072f, 0.01697067f, -0.05817488f, 
    -0.10751414f, -0.02365689f, 0.00550610f, 0.04869961f, -0.05727400f, 0.04605889f, -0.03723468f, -0.05520873f, 
    -0.43754098f, 0.05705854f, 0.41606304f, 0.06305801f, -0.03020395f, -0.10076826f, 0.02447112f, -0.02211903f, 
    0.06602295f, -0.02258230f, -0.10116285f, -0.03157718f, -0.43470845f, 0.04345815f, -0.16935028f, -0.21841742f, 
    0.03998255f, 0.09913721f, -0.07732098f, -0.04419460f, 0.13024247f, -0.03592722f, -0.05306587f, -0.02875075f, 
    0.49830109f, 0.07457837f, -0.17141370f, 0.28494093f, -0.18388160f, -0.08320368f, 0.09501308f, 0.11595558f, 
    -0.04814579f, -0.06370734f, 0.12264572f, 0.12123684f, 0.30856279f, 0.00830678f, 0.09168050f, 0.20506863f, 
    -0.14174409f, 0.01231920f, -0.08902211f, -0.05811500f, -0.05994686f, -0.07169689f, 0.07341562f, 0.00515373f, 
    -0.50493509f, 0.15539044f, 0.15535019f, -0.10924742f, 0.10914485f, 0.04531787f, 0.04511935f, -0.10395036f, 
    0.04236584f, -0.03981408f, 0.02572569f, 0.03414895f, 0.17285119f, -0.04566382f, -0.09781722f, 0.09022993f, 
    -0.03893892f, 0.11135229f, 0.06945165f, -0.07290231f, -0.01018666f, -0.09772788f, -0.12541957f, -0.05702823f, 
    0.33767354f, -0.11824583f, -0.06458819f, -0.05016545f, -0.07963449f, -0.02938660f, -0.01468860f, -0.05772891f, 
    -0.10301775f, 0.06563265f, -0.06587283f, -0.00625884f, 0.27037367f, -0.02167511f, 0.37384033f, 0.27078366f, 
    -0.14272350f, 0.10219119f, 0.07533095f, -0.00829825f, -0.00109945f, -0.01350910f, -0.03168483f, 0.04572144f, 
    0.20460784f, -0.09522704f, -0.03664526f, 0.41337496f, -0.00618430f, -0.01979977f, 0.07659077f, 0.04389832f, 
    -0.00293129f, 0.03592325f, -0.05921816f, 0.07683098f, -0.09077607f, 0.01557900f, 0.24574792f, 0.16017538f, 
    0.01642480f, -0.07352859f, 0.06794006f, 0.08044291f, -0.06802858f, 0.07572835f, -0.08748310f, -0.09740401f, 
    -0.01669573f, -0.01043735f, -0.03819116f, 0.01837791f, -0.04878135f, -0.01807099f, -0.03218453f, 0.01269700f, 
    -0.05688678f, -0.02417934f, -0.04967723f, 0.02780326f, 0.02345881f, 0.03036816f, 0.01967622f, -0.03149357f, 
    -0.03276261f, 0.03532675f, -0.00339677f, 0.02744634f, 0.02240195f, 0.01060248f, 0.00457958f, -0.05610896f, 
    -0.00817440f, -0.01135364f, -0.04638732f, 0.00934888f, -0.03288902f, -0.03600596f, -0.00257892f, 0.02543994f, 
    -0.02859175f, -0.03241608f, -0.03927414f, -0.00272321f, -0.04054752f, 0.01812036f, -0.04708119f, -0.05579949f, 
    0.02528896f, -0.03742272f, 0.02250275f, -0.01615282f, -0.01293199f, -0.04399051f, 0.01920045f, -0.00448609f, 
    0.00448542f, -0.05402450f, -0.04973004f, -0.00759685f, -0.01610195f, -0.02116528f, 0.04391703f, -0.02286800f, 
    0.03411978f, -0.00143553f, -0.02820487f, -0.00957361f, 0.01146253f, 0.04144404f, -0.04585393f, 0.00977310f, 
    -0.03982141f, -0.01551355f, -0.05313046f, -0.04280886f, -0.01463076f, 0.02619175f, -0.04733009f, -0.04691062f, 
    0.01825481f, -0.03476956f, -0.00345766f, 0.01589118f, -0.02436989f, -0.01259652f, 0.00766129f, -0.00601375f, 
    0.00784751f, 0.00048781f, 0.01260353f, -0.03342680f, -0.03793798f, -0.04975675f, 0.02391592f, -0.05321351f, 
    0.01527806f, -0.00804442f, 0.01662525f, -0.04604330f, 0.02322820f, -0.04529577f, -0.03740002f, 0.03280414f, 
    -0.03551529f, 0.01844758f, 0.00802547f, -0.00582674f, -0.04427483f, 0.03163077f, -0.04863857f, 0.04185870f, 
    -0.03433252f, -0.03100320f, -0.03629168f, -0.00107546f, -0.00468730f, -0.03762279f, -0.00676138f, 0.04353991f, 
    0.01501438f, 0.01540331f, -0.00640208f, -0.00150970f, -0.04770001f, -0.04874025f, -0.03484564f, -0.00753033f, 
    -0.03935259f, 0.00255023f, -0.05207984f, 0.02399093f, 0.02581300f, -0.04607479f, -0.02785432f, 0.03388545f, 
    0.02537048f, 0.01210702f, 0.00891405f, 0.02375492f, -0.03882495f, -0.01390442f, -0.05376408f, -0.02377099f, 
    0.04067609f, 0.00347156f, -0.02199629f, -0.00374452f, -0.00369968f, -0.04054184f, -0.03135200f, -0.00086872f, 
    -0.03597351f, 0.00567681f, 0.00571397f, -0.04706547f, 0.01945487f, -0.02038912f, -0.03873968f, 0.02123546f, 
    -0.02289924f, -0.04387064f, -0.02846429f, -0.04830108f, 0.02273146f, -0.03883068f, -0.00588685f, -0.03620097f, 
    -0.00772610f, -0.00327402f, 0.03840267f, 0.00848185f, 0.00651482f, 0.00397649f, -0.01800762f, 0.02906859f, 
    -0.05656882f, -0.04610599f, 0.00422417f, 0.04487624f, 0.03290083f, -0.04665432f, 0.02181093f, -0.05194369f, 
    0.02073950f, -0.01351158f, -0.01837636f, 0.02191270f, -0.01167914f, -0.04745071f, -0.00210699f, 0.04428289f, 
    -0.02881259f, -0.00118322f, 0.02477492f, -0.04045703f, -0.03755330f, -0.02823407f, 0.01064534f, 0.01801367f, 
    0.04413572f, -0.00256593f, -0.04059702f, -0.03115630f, -0.03960874f, 0.01095518f, 0.00782812f, -0.04822922f, 
    -0.00651378f, -0.03361617f, 0.01482908f, -0.05322533f, 0.03708240f, -0.01318339f, 0.03537016f, 0.03048646f, 
    -0.04941649f, -0.00023319f, 0.01363508f, 0.03854105f, -0.00721625f, -0.02409999f, 0.00658949f, 0.01061034f, 
    -0.04264245f, 0.01159873f, 0.02639923f, 0.01527057f, 0.00759687f, 0.01653517f, -0.01509100f, -0.03545589f, 
    -0.00015121f, -0.00796163f, -0.03475110f, 0.01441577f, 0.01105009f, 0.00932535f, 0.00781564f, 0.02433532f, 
    0.01843026f, -0.03285391f, 0.01746078f, 0.01809726f, -0.01019181f, -0.00405770f, -0.04652448f, -0.04444696f, 
    0.01985664f, -0.04666560f, -0.00385188f, -0.03627948f, -0.00755274f, 0.02385547f, 0.01396763f, 0.03821310f, 
    0.03516480f, -0.03675454f, -0.03998439f, -0.00656039f, 0.00257008f, 0.01165148f, -0.04850353f, -0.03471075f, 
    -0.05223246f, 0.01209660f, -0.01588149f, -0.01166391f, -0.02253785f, 0.03530356f, 0.02334014f, 0.00124956f, 
    -0.00324510f, -0.03792297f, -0.02689048f, 0.01585274f, -0.04387222f, -0.04127475f, -0.03750036f, -0.02031050f, 
    0.00808673f, 0.01185041f, 0.02490966f, 0.00712850f, 0.00127965f, 0.00469740f, 0.04071273f, -0.01148621f, 
    -0.03147366f, 0.03645622f, -0.04791737f, 0.00343152f, -0.00168255f, 0.01596936f, -0.05362178f, 0.01043400f, 
    0.01494194f, 0.01983335f, -0.01367604f, 0.00244493f, 0.01566174f, -0.01258889f, 0.01826202f, -0.03391642f, 
    -0.01433505f, -0.04322897f, -0.02070354f, 0.03963307f, -0.02956403f, 0.04438224f, 0.02511716f, -0.03772455f, 
    0.04491469f, -0.04608643f, -0.04625622f, 0.01407251f, 0.03954091f, -0.04224255f, 0.00350922f, -0.00348282f, 
    -0.02370389f, 0.01940505f, -0.04196734f, 0.01194484f, 0.02133033f, 0.00980045f, 0.03854327f, -0.04434479f, 
    -0.04813381f, -0.04593018f, -0.04711397f, 0.01377438f, 0.02861033f, -0.01818802f, 0.04065974f, 0.04368936f, 
    0.01789732f, 0.01213162f, -0.00591075f, 0.00116744f, -0.04915340f, -0.04301992f, -0.02159031f, -0.00114421f, 
    0.02986408f, -0.01412307f, -0.00652965f, -0.00514191f, 0.00920979f, 0.01694797f, 0.02489852f, -0.02185910f, 
    -0.02967090f, -0.03871335f, 0.01873055f, 0.04184638f, 0.04375347f, 0.03418318f, -0.04072804f, -0.02923895f, 
    -0.04832028f, -0.03228556f, -0.05405864f, -0.00514815f, -0.01980349f, 0.01349653f, 0.01231283f, -0.01142785f, 
    -0.01687237f, 0.00612450f, -0.04388223f, -0.00100066f, 0.02408832f, -0.00624843f, -0.02539087f, 0.03522838f, 
    0.00384162f, -0.00599482f, 0.04013289f, -0.02125474f, 0.02628150f, -0.02676743f, -0.00842850f, 0.00006087f, 
    -0.01952704f, -0.05199156f, 0.00192907f, -0.00696893f, -0.04996426f, 0.01502000f, 0.00679680f, -0.05537370f, 
    -0.17940195f, 0.08710694f, -0.05876156f, -0.11607878f, -0.00544311f, -0.11071464f, 0.08010263f, -0.04983602f, 
    0.00508464f, -0.07317387f, 0.01847457f, -0.07673716f, 0.04961356f, 0.18349542f, -0.11427399f, 0.08487741f, 
    0.06518412f, -0.02580760f, -0.21351625f, 0.05486410f, 0.00988980f, -0.06539841f, -0.08597384f, -0.10279241f, 
    0.20956688f, -0.10507296f, -0.04545263f, 0.03790678f, -0.05407796f, 0.01909748f, -0.01184823f, 0.05867549f, 
    0.10402379f, 0.13209391f, -0.01309022f, 0.11940983f, 0.50225121f, 0.10676139f, 0.12896179f, 0.08253068f, 
    0.06363810f, -0.04939450f, 0.03975645f, -0.05227653f, -0.12854347f, 0.07162925f, 0.17694198f, 0.04469297f, 
    0.09506077f, 0.00301921f, 0.06064007f, 0.09034202f, -0.11584589f, 0.01219208f, -0.13332190f, -0.07351807f, 
    0.08327380f, -0.04169669f, -0.10658409f, 0.05507121f, -0.06997354f, -0.09889059f, -0.07836163f, -0.19077490f, 
    0.14005411f, 0.06766135f, -0.05279358f, -0.09535778f, 0.09735496f, 0.10199221f, 0.06060118f, 0.10245545f, 
    0.28986719f, 0.20609882f, -0.04624069f, -0.28763029f, -0.03713222f, -0.08421019f, -0.01875771f, 0.11261189f, 
    -0.14357300f, 0.04453538f, 0.03690210f, -0.06422637f, 0.06906407f, 0.03942603f, 0.30965245f, 0.03372791f, 
    0.05200460f, -0.12870580f, 0.02348512f, 0.14351006f, 0.00747101f, 0.01372417f, 0.05646436f, 0.01361181f, 
    -0.24487042f, -0.09578625f, -0.32692733f, -0.28953937f, 0.29251850f, 0.11540874f, 0.01466818f, -0.09306509f, 
    0.02297079f, 0.01189684f, -0.07902531f, 0.02021760f, 0.52868229f, -0.06085919f, 0.31440216f, -0.07046352f, 
    0.10381266f, -0.07807944f, -0.07288494f, -0.00130526f, 0.08855714f, -0.01412714f, -0.03261405f, 0.18150809f, 
    0.09989398f, 0.18652038f, 0.17535338f, 0.27711016f, -0.18940574f, -0.01428594f, 0.04212975f, 0.11892107f, 
    -0.07364410f, 0.12129881f, -0.07817376f, -0.09974105f, 0.16883741f, -0.05633673f, 0.05151670f, -0.07780311f, 
    -0.05857050f, -0.12096798f, -0.12113217f, -0.02123917f, -0.01675986f, -0.15595734f, 0.02891557f, 0.01468825f, 
    0.27728683f, -0.14625412f, 0.02497772f, -0.27723119f, 0.20544258f, 0.07888422f, -0.00383559f, 0.01245981f, 
    0.13204212f, 0.08967777f, 0.04696987f, 0.00506106f, 0.11287644f, -0.05495572f, 0.02880840f, 0.06636818f, 
    0.04500931f, 0.06039615f, 0.09985620f, -0.10045304f, 0.22884548f, 0.18158475f, 0.02142377f, 0.00943667f, 
    -0.21444571f, 0.05414278f, -0.25596052f, -0.04923524f, 0.17433102f, 0.07656332f, 0.01328036f, -0.07212386f, 
    -0.17157076f, 0.01222397f, 0.13178004f, -0.09803233f, -0.30396149f, -0.36608943f, -0.13028912f, 0.00869754f, 
    0.12670377f, 0.04723243f, -0.02943637f, -0.04743685f, 0.01596536f, 0.14447904f, 0.19225757f, -0.14332210f, 
    -0.33403328f, 0.38412437f, -0.16941190f, 0.14788213f, 0.06326671f, 0.10987626f, 0.05375964f, -0.07064763f, 
    0.09741660f, 0.00749007f, -0.06118751f, 0.04930444f, 0.11662456f, 0.01651133f, -0.15344337f, -0.04237397f, 
    -0.05596420f, 0.12323951f, -0.06737883f, -0.04748219f, -0.02359907f, 0.07115516f, 0.02836620f, 0.15333095f, 
    -0.09925984f, 0.30472684f, -0.00740101f, 0.20172195f, -0.21690308f, 0.13679373f, 0.04968907f, 0.06495416f, 
    0.01430590f, -0.11578838f, 0.00437418f, -0.06698190f, -0.22633053f, 0.11860936f, 0.01198428f, -0.16011846f, 
    0.06586047f, -0.08640159f, 0.01668360f, -0.05094312f, -0.05784936f, -0.00638199f, 0.01630935f, 0.05117478f, 
    -0.08110216f, 0.17650943f, 0.12726676f, 0.16086876f, 0.04240454f, -0.09434541f, -0.01526618f, 0.01582662f, 
    0.03233096f, 0.05265624f, 0.09475206f, 0.04700842f, -0.25532079f, 0.33470646f, 0.04851939f, 0.19237188f, 
    0.02227748f, -0.07172419f, 0.11550893f, 0.00074214f, 0.04267924f, 0.13285835f, 0.01704573f, 0.06011819f, 
    0.40960377f, -0.12205441f, 0.04082378f, 0.18947703f, 0.04738707f, -0.08111311f, -0.03284914f, -0.03895500f, 
    0.03927407f, -0.00176414f, 0.06954857f, 0.00770799f, 0.11587010f, 0.14986573f, 0.22849883f, 0.18432610f, 
    0.03820285f, -0.08253954f, 0.02093210f, 0.14483421f, -0.05178963f, -0.14887339f, 0.01757194f, -0.04742644f, 
    -0.03150928f, 0.14396054f, 0.02995708f, -0.06816015f, -0.04984495f, 0.10540553f, -0.08916685f, 0.00629471f, 
    0.08512808f, -0.02842688f, -0.01758401f, 0.01523732f, -0.02384615f, 0.03832028f, -0.03824428f, 0.03128318f, 
    0.15310545f, -0.04565131f, 0.05850881f, -0.01317707f, 0.04041522f, 0.07297266f, -0.09314765f, 0.10969998f, 
    0.11369821f, 0.02379885f, 0.15412638f, 0.29008108f, 0.11847898f, -0.07032807f, -0.03839925f, 0.09915055f, 
    0.09794426f, 0.03491022f, 0.01700882f, -0.03757899f, 0.11835774f, 0.17163457f, 0.05206117f, 0.27312589f, 
    0.01629117f, 0.05795030f, 0.06502379f, -0.00462665f, -0.04383229f, 0.07308990f, 0.05567841f, 0.00210881f, 
    -0.04622997f, 0.24100690f, 0.09663631f, 0.24664676f, -0.03751810f, -0.04032727f, -0.11005604f, 0.19140661f, 
    -0.03854183f, -0.09735899f, -0.11369168f, 0.00092995f, -0.29377738f, -0.00098564f, -0.14536519f, -0.12409011f, 
    0.20891713f, 0.04203052f, 0.01805041f, -0.11807600f, -0.11527367f, -0.00088599f, 0.00208910f, 0.05259053f, 
    -0.16039589f, -0.05471848f, -0.38689592f, 0.09139761f, 0.13558251f, -0.07701016f, -0.00807958f, -0.06644206f, 
    -0.03166830f, 0.11760825f, -0.00339472f, -0.03819180f, 0.01092965f, -0.14528856f, -0.12219934f, -0.28828561f, 
    0.31499943f, 0.14207213f, -0.19231853f, -0.06268041f, 0.26270926f, -0.06728562f, -0.04997285f, -0.10115720f, 
    -0.28973073f, -0.00601068f, -0.06922383f, -0.07255335f, -0.06939087f, -0.13256024f, 0.13476592f, 0.07280499f, 
    -0.03998169f, 0.28508985f, -0.06990875f, 0.10196495f, -0.28127897f, -0.06505453f, 0.09176100f, -0.16615471f, 
    0.06152779f, 0.09126222f, 0.03022812f, 0.04753374f, 0.02357372f, 0.00118625f, 0.09341811f, 0.01303493f, 
    0.35184485f, -0.12306502f, 0.08758383f, -0.12505180f, 0.09455355f, -0.02702933f, -0.07340698f, 0.02382059f, 
    0.03993664f, 0.10792860f, 0.08338189f, -0.06651479f, -0.18606938f, -0.07927282f, -0.26266360f, -0.17358229f, 
    -0.05268625f, 0.04530105f, 0.07637186f, -0.08423138f, 0.06671905f, -0.03337174f, -0.01218212f, -0.08569350f, 
    -0.22442158f, -0.07754239f, -0.23822284f, -0.27677000f, 0.03213760f, 0.06682657f, 0.01770948f, -0.05191507f, 
    -0.11873263f, 0.19834130f, 0.04433309f, 0.05818046f, -0.06304906f, 0.18257871f, 0.11762466f, 0.07328928f, 
    0.09183205f, -0.02137422f, 0.01052292f, 0.01426230f, 0.06496126f, -0.00325327f, -0.03381801f, 0.15437382f, 
    0.32456410f, 0.08691153f, -0.03117301f, 0.05007383f, 0.17515215f, -0.03454672f, -0.07145521f, 0.06614122f, 
    0.06369689f, 0.06578739f, -0.03185510f, 0.24929230f, 0.18289633f, 0.05060602f, -0.10890151f, 0.30720270f, 
    -0.06018101f, 0.01506464f, 0.05800445f, -0.00136363f, -0.05788048f, 0.04217068f, -0.17278643f, 0.10857013f, 
    -0.18437088f, 0.26344681f, 0.11765169f, 0.04159762f, 0.08022541f, 0.05428806f, 0.00191284f, 0.05383675f, 
    0.01299037f, -0.01663536f, 0.14740773f, -0.08473767f, -0.10528912f, -0.04524400f, -0.21163447f, 0.13225283f, 
    0.16953741f, 0.02113441f, 0.06743114f, 0.07261220f, -0.06943054f, -0.11778979f, 0.00085018f, -0.00275428f, 
    0.16874991f, -0.43242061f, 0.07839038f, -0.03216094f, 0.06070994f, -0.05691146f, 0.06995807f, -0.01788815f, 
    0.05409278f, 0.01753199f, -0.09071584f, 0.01016752f, -0.10220563f, 0.07463384f, 0.14953689f, -0.09228335f, 
    0.01276661f, 0.06254772f, 0.06148941f, -0.09425792f, -0.12015522f, 0.10670834f, -0.05053955f, 0.01067372f, 
    -0.21753266f, 0.28368071f, 0.35304072f, 0.06051589f, 0.01094251f, -0.01986925f, 0.11713239f, -0.07462472f, 
    -0.07214139f, -0.12878712f, 0.15619290f, -0.04030079f, 0.00304945f, 0.17686240f, 0.08767298f, -0.00176709f, 
    0.03427648f, -0.06017482f, 0.02473011f, -0.13690622f, -0.11484195f, -0.03067288f, -0.10135841f, 0.04364733f, 
    -0.14472307f, 0.38044354f, 0.18846172f, -0.08339170f, 0.01052411f, 0.01237757f, -0.03899324f, 0.03837986f, 
    -0.09682964f, 0.14439507f, 0.14948703f, 0.03906511f, -0.01845504f, -0.10072015f, 0.16885397f, -0.04091448f, 
    0.02761712f, 0.02445646f, 0.03196251f, 0.10439134f, 0.02269758f, -0.00733126f, -0.07474918f, 0.01315000f, 
    0.24852824f, -0.22698843f, 0.01573912f, 0.24476838f, 0.01990191f, 0.12783718f, -0.04158797f, -0.01812141f, 
    0.00156097f, -0.03298163f, 0.11576109f, 0.01810220f, 0.12236845f, 0.13930601f, 0.18807881f, -0.23195803f, 
    0.06055374f, -0.05685001f, -0.02386055f, 0.10988779f, 0.08883911f, 0.06609057f, -0.00982046f, -0.05128564f, 
    -0.01712598f, 0.08843414f, 0.01433339f, -0.03069875f, 0.14450894f, 0.07939939f, -0.01492669f, 0.12617211f, 
    0.11995367f, -0.04953181f, 0.09273122f, -0.04450868f, 0.53227204f, -0.37288031f, 0.06127298f, -0.02697647f, 
    -0.07607502f, 0.03817795f, 0.05789580f, 0.04056731f, 0.01086275f, -0.01754343f, 0.16139020f, 0.04644744f, 
    0.04961316f, 0.19330046f, 0.14199129f, 0.06605667f, 0.02670296f, 0.09327759f, 0.00983022f, 0.04352008f, 
    -0.00322213f, 0.08853918f, 0.06520107f, 0.09247821f, 0.06733641f, 0.16975063f, -0.04899014f, -0.04497804f, 
    0.02708408f, 0.01871129f, -0.06640874f, -0.13563363f, -0.02399478f, 0.06259459f, -0.02273309f, -0.03389636f, 
    0.34263092f, -0.08878000f, -0.22854686f, -0.18409351f, 0.00291627f, 0.14298271f, -0.00811111f, 0.10697097f, 
    0.08969915f, 0.01559427f, 0.16268069f, 0.05611249f, -0.43774670f, -0.34289718f, -0.13177486f, 0.04115707f, 
    0.07765091f, -0.12891759f, 0.00587781f, -0.10229167f, 0.04618939f, -0.02505626f, 0.10466491f, 0.03609661f, 
    -0.23631947f, -0.04699425f, 0.01694288f, -0.00201966f, 0.02014859f, 0.15953803f, 0.11826804f, -0.06881243f, 
    0.20791967f, -0.00799700f, 0.25273988f, -0.22807191f, -0.08238132f, 0.17265594f, -0.02256095f, -0.27922177f, 
    0.03427327f, -0.04402123f, 0.00380223f, -0.02026945f, 0.02858464f, -0.01149980f, 0.21859755f, -0.03513759f, 
    0.59990054f, -0.42072025f, -0.22776945f, -0.05116760f, 0.05161864f, -0.00787840f, 0.02299076f, -0.02000118f, 
    -0.08077029f, 0.00651324f, 0.00181842f, 0.04860779f, -0.16675654f, -0.18422195f, 0.11655737f, -0.08101297f, 
    0.04351207f, -0.14289434f, -0.06277291f, 0.04287294f, 0.06660771f, 0.03359927f, -0.00491195f, 0.10178177f, 
    -0.08056474f, 0.04078684f, -0.05099854f, 0.15365486f, 0.02198986f, 0.05579332f, 0.02575274f, 0.15133636f, 
    0.12862325f, 0.07681312f, -0.01585652f, 0.01505573f, 0.00154756f, 0.37621582f, -0.04508488f, -0.18490569f, 
    0.12737203f, 0.12066605f, -0.03215791f, 0.05851969f, 0.13564248f, -0.06122596f, 0.09777711f, 0.10199714f, 
    -0.21480016f, 0.26772368f, 0.29026094f, -0.27701339f, 0.05798334f, 0.12253560f, -0.03656935f, 0.01836585f, 
    0.02266873f, -0.07045148f, 0.08015521f, -0.06115523f, -0.02108966f, 0.25869152f, 0.07975221f, 0.17713027f, 
    -0.05442516f, 0.05532562f, -0.02056678f, -0.08909175f, 0.01737642f, -0.11767484f, 0.06340697f, 0.13794427f, 
    -0.24665679f, 0.03933609f, 0.14461602f, 0.04758937f, 0.14135247f, 0.01892995f, 0.10181776f, 0.04659437f, 
    0.05245582f, -0.08195967f, -0.02478949f, 0.05238553f, 0.02041851f, 0.33784178f, -0.05186720f, 0.08784271f, 
    -0.20532145f, -0.16261005f, -0.04490205f, -0.10809692f, 0.18739435f, 0.04597040f, -0.11830010f, -0.01891240f, 
    -0.17003064f, 0.10748757f, -0.03974959f, -0.14999618f, -0.13408078f, 0.02744035f, -0.15402357f, -0.00581540f, 
    -0.07261853f, -0.09405525f, -0.02948563f, -0.01022193f, 0.20473464f, 0.08849749f, -0.34010834f, 0.04006520f, 
    0.06746237f, -0.03668137f, -0.00093964f, -0.12487280f, 0.07775290f, -0.01815526f, 0.02261850f, -0.02369056f, 
    0.05875010f, -0.06919876f, -0.32806158f, -0.09688124f, 0.13955578f, 0.02372314f, -0.00167582f, -0.05113941f, 
    0.08424845f, 0.03749368f, 0.13405405f, -0.13792831f, 0.23036772f, 0.32867393f, -0.03652360f, -0.00581659f, 
    0.00539809f, -0.07328892f, 0.16141289f, 0.15972850f, 0.07936419f, 0.06368761f, 0.02081219f, 0.12440478f, 
    -0.20577979f, -0.37963885f, 0.16288924f, -0.06121962f, 0.13989255f, -0.03460163f, -0.08003335f, 0.11940425f, 
    0.06080609f, 0.03178868f, 0.14920665f, 0.14835100f, 0.22603367f, -0.23073354f, 0.04048749f, 0.33795869f, 
    -0.02989697f, 0.16658856f, 0.02788739f, 0.04928896f, -0.05033871f, -0.01133582f, -0.09514175f, -0.04315018f, 
    0.33264941f, 0.05376816f, 0.03843473f, -0.19908367f, -0.08716467f, 0.01575058f, 0.00269310f, 0.02903909f, 
    -0.03783889f, -0.02203184f, 0.06797459f, -0.04477089f, 0.23733336f, -0.04435443f, -0.19756883f, 0.11534490f, 
    -0.02549092f, -0.02003293f, 0.09638416f, -0.02729388f, 0.15038384f, -0.04257790f, 0.04989905f, -0.11985401f, 
    0.05077161f, -0.00059694f, 0.09620631f, 0.11967671f, 0.06704445f, 0.04083071f, 0.06759693f, -0.06989224f, 
    -0.01561205f, -0.07094797f, 0.09686336f, 0.01162676f, 0.17165133f, 0.25343299f, -0.07932253f, -0.13134725f, 
    -0.04168930f, 0.07578729f, 0.06450731f, -0.06231288f, -0.00627132f, -0.01182421f, -0.27519059f, -0.17429571f, 
    0.33834201f, -0.01019005f, 0.19064726f, -0.13624014f, -0.07003208f, 0.01105969f, 0.03384956f, 0.12626526f, 
    -0.00456960f, -0.01118060f, -0.01540910f, 0.07927129f, 0.13087280f, 0.27580059f, -0.07187277f, -0.33824703f, 
    -0.17485859f, -0.00710955f, -0.09698698f, -0.02097279f, 0.02756472f, -0.09776398f, -0.10263007f, -0.02766178f, 
    0.23838592f, 0.10755618f, -0.07675481f, -0.09554337f, 0.00673747f, -0.14733741f, 0.09792446f, 0.11434458f, 
    0.07474266f, -0.04682052f, -0.03011493f, -0.06571765f, 0.15777092f, 0.27098328f, -0.02732977f, -0.22291093f, 
    0.03998949f, -0.09597473f, -0.12304230f, -0.10677753f, 0.15289253f, 0.00881120f, -0.17420991f, 0.01860406f, 
    0.09741898f, 0.05094897f, -0.22413178f, 0.06890135f, 0.20762296f, -0.04529163f, -0.05114579f, -0.05768818f, 
    0.00566260f, -0.00376120f, 0.06296092f, -0.01290729f, 0.12055308f, -0.01088835f, -0.08492202f, 0.06977553f, 
    -0.02242554f, 0.04493247f, 0.00228548f, 0.12774944f, 0.01614937f, 0.04364418f, -0.12985523f, -0.09275581f, 
    -0.04183595f, -0.22287492f, -0.11788786f, -0.02718651f, 0.08253356f, -0.01920176f, 0.24325192f, 0.04140592f, 
    -0.08288613f, 0.05897547f, 0.08019894f, -0.02219229f, 0.74321532f, -0.06889535f, -0.02791048f, -0.03287784f, 
    -0.07006794f, -0.00579356f, 0.04169730f, 0.04000740f, -0.03708358f, 0.11727638f, 0.11979523f, 0.01331285f, 
    0.18963332f, -0.07177488f, -0.01459417f, -0.08760784f, 0.04360540f, 0.07784344f, 0.03938136f, -0.12107394f, 
    0.04031165f, -0.02084555f, -0.02544830f, 0.00171477f, -0.11741917f, 0.00932155f, 0.00872111f, 0.23321038f, 
    -0.04744091f, 0.02221893f, -0.02069087f, 0.08240020f, -0.01354557f, -0.02519603f, -0.05823415f, -0.14186141f, 
    -0.03241225f, 0.18897682f, -0.00250508f, 0.05195815f, -0.00668224f, 0.21333438f, 0.12727748f, 0.03637772f, 
    -0.13434634f, -0.06940929f, 0.01312789f, -0.04799749f, -0.12160038f, -0.35282353f, -0.16108106f, 0.13972650f, 
    -0.15731199f, 0.06058114f, 0.01325431f, 0.17070949f, -0.14888982f, 0.18674167f, -0.01570995f, 0.03678565f, 
    -0.02020473f, 0.08903570f, -0.13333379f, -0.18862276f, 0.10621037f, -0.17450951f, -0.02028970f, 0.04748873f, 
    -0.07226475f, 0.07841472f, 0.14901271f, -0.05049914f, -0.15165676f, -0.16187006f, 0.14947948f, -0.16507332f, 
    -0.02803119f, -0.02935116f, -0.04239617f, 0.05707202f, 0.13852048f, 0.10100038f, 0.03419098f, -0.00342729f, 
    -0.04852900f, -0.03145065f, -0.03536694f, 0.06425292f, 0.08090261f, -0.03391962f, 0.04886945f, 0.00494971f, 
    0.01236361f, -0.09279487f, 0.08573081f, 0.14506133f, -0.05586326f, 0.14834201f, -0.03035080f, -0.43370566f, 
    -0.27430069f, -0.06062556f, -0.12736811f, -0.09337068f, -0.05515996f, 0.07912160f, -0.02054274f, -0.10852471f, 
    -0.08233058f, 0.00536739f, -0.21372354f, 0.16637194f, -0.01193475f, -0.03235783f, -0.03568727f, -0.06792238f, 
    0.03712462f, 0.09385075f, 0.11355720f, -0.02136561f, 0.25824881f, -0.34630141f, 0.14017977f, -0.16735967f, 
    -0.00481525f, -0.08892716f, -0.04668185f, 0.05487559f, 0.00567100f, -0.04104337f, -0.00715693f, -0.02683508f, 
    0.21354416f, 0.14593549f, -0.06371028f, 0.22319250f, -0.03090531f, 0.00043217f, -0.03693933f, -0.02637630f, 
    0.05269145f, -0.02001687f, -0.07655594f, -0.07159019f, -0.14087625f, 0.06945170f, -0.06624757f, 0.17423245f, 
    -0.03454573f, 0.11666066f, 0.00697376f, 0.08241433f, -0.09451229f, 0.15296334f, 0.15873586f, 0.03001827f, 
    0.22874163f, -0.06328420f, 0.14992802f, -0.00562805f, 0.07119289f, 0.19937742f, -0.12168504f, -0.12131991f, 
    -0.01527041f, -0.16204938f, 0.18999700f, -0.00116055f, 0.17043158f, -0.10096145f, -0.10214602f, 0.14913113f, 
    -0.19816148f, -0.09749712f, -0.05177400f, -0.14271438f, -0.01752165f, 0.04951733f, 0.08952628f, -0.05494009f, 
    -0.31235081f, 0.14115395f, 0.18144558f, -0.03649846f, -0.01439949f, -0.01668320f, 0.09212760f, 0.12514143f, 
    0.11453477f, -0.04757555f, -0.00781458f, -0.07264035f, 0.01199522f, 0.16343983f, 0.22322121f, -0.10408448f, 
    0.23847936f, -0.02001781f, -0.07490119f, 0.03626189f, -0.00668158f, 0.04670968f, -0.04177807f, -0.02564552f, 
    0.11558712f, 0.34281877f, 0.30817783f, 0.05143915f, 0.07356914f, 0.05029839f, 0.08774305f, 0.08335064f, 
    0.13837688f, -0.05014984f, 0.06836046f, 0.03360184f, -0.38341060f, -0.02430960f, 0.16328350f, 0.17651136f, 
    0.14222154f, 0.22206837f, 0.02728086f, 0.07556951f, 0.06686081f, 0.08199611f, 0.19057024f, -0.03773315f, 
    -0.28182039f, -0.46791667f, 0.13067956f, -0.08430110f, 0.08014918f, 0.15442237f, 0.03564749f, 0.06905042f, 
    0.02848930f, -0.09704396f, 0.11453305f, -0.02674433f, 0.18227603f, -0.10926901f, -0.04981483f, -0.14018078f, 
    0.07893085f, 0.07502288f, -0.06391767f, 0.13548759f, 0.15075165f, -0.14328070f, 0.07547623f, -0.01945561f, 
    0.04285267f, -0.13752261f, 0.09613965f, -0.17911889f, -0.01858504f, -0.04118650f, -0.00299983f, 0.04184796f, 
    0.12276219f, 0.17939238f, 0.04198606f, 0.20034342f, -0.52852881f, -0.08155280f, 0.10574137f, 0.25992048f, 
    0.02640118f, 0.04227610f, 0.07941495f, -0.08564771f, 0.02248984f, 0.02246386f, -0.06700824f, -0.07711688f, 
    -0.22024059f, 0.20463587f, -0.21959680f, -0.18240967f, -0.06094611f, 0.06810030f, 0.03504793f, -0.02380902f, 
    0.09735869f, -0.12071806f, 0.10333218f, 0.13297215f, 0.19244626f, 0.26475117f, 0.05863510f, 0.08347701f, 
    0.05078755f, 0.08891052f, 0.12572964f, -0.12098299f, 0.05271976f, -0.00743983f, -0.01602345f, -0.01030384f, 
    -0.15749288f, -0.17666887f, -0.21622258f, 0.07597257f, 0.02201561f, 0.15321939f, -0.10078816f, 0.10229129f, 
    0.02007607f, 0.05134098f, -0.07201551f, 0.10276544f, 0.06393011f, 0.03127354f, -0.17783076f, -0.25648949f, 
    -0.10550769f, -0.01784679f, -0.00184544f, 0.00409955f, -0.04607864f, 0.03500617f, 0.13782652f, 0.23856658f, 
    0.01928578f, -0.23890007f, 0.10993500f, -0.06179258f, 0.02368402f, 0.13801761f, 0.01054532f, -0.03529528f, 
    0.18830281f, -0.10765003f, -0.03948069f, 0.00785506f, 0.00036677f, 0.36505836f, 0.13868071f, -0.24357562f, 
    -0.04611970f, -0.03761037f, 0.04144067f, 0.01154903f, 0.09035926f, 0.08912432f, -0.08145308f, 0.03562002f, 
    -0.14421189f, -0.22271080f, -0.02434150f, 0.05620280f, -0.04601579f, 0.06589071f, -0.02080451f, -0.02084139f, 
    0.05504992f, 0.03223533f, 0.07485557f, -0.02647926f, 0.30660614f, -0.01841953f, 0.06411365f, 0.11930969f, 
    -0.13475616f, 0.08133689f, 0.11792262f, -0.03298538f, 0.14047402f, -0.05985052f, -0.07277600f, -0.00182322f, 
    -0.20762786f, -0.23366755f, -0.07018217f, 0.13937260f, -0.05968681f, -0.05681280f, 0.05412594f, -0.09185621f, 
    0.00686426f, -0.01112834f, -0.00703156f, 0.06581532f, 0.36798763f, 0.34491703f, 0.04792879f, 0.04246927f, 
    0.06849913f, -0.01409035f, 0.05049125f, 0.02226967f, 0.05859139f, 0.07790539f, 0.05022753f, 0.01912233f, 
    -0.02471839f, -0.03490115f, -0.19826511f, -0.08448453f, -0.12564956f, 0.06606563f, 0.13507757f, -0.14809264f, 
    0.04926808f, 0.06893602f, -0.03241544f, 0.05214707f, -0.15054294f, -0.03324065f, 0.07145274f, -0.11797282f, 
    -0.02328273f, 0.13662411f, 0.20164905f, 0.09643772f, 0.16742955f, -0.19600752f, 0.00373044f, 0.03638839f, 
    -0.24220426f, 0.32320431f, 0.14075574f, 0.18619056f, 0.11082265f, -0.08073251f, 0.17225617f, 0.15222688f, 
    -0.02222550f, -0.07495555f, -0.18134359f, 0.07450658f, 0.56118917f, 0.08893259f, -0.02056906f, -0.02175923f, 
    -0.23943867f, 0.12883663f, 0.05511095f, 0.07390794f, -0.11933070f, 0.03395389f, -0.02470170f, 0.02054332f, 
    -0.26518202f, 0.00596776f, 0.06225203f, -0.04744450f, 0.10324812f, -0.00460990f, 0.00221550f, 0.05340135f, 
    -0.05794652f, 0.00476938f, -0.07049001f, 0.19820915f, -0.03640225f, 0.00591333f, 0.20729430f, 0.01980256f, 
    0.08009186f, 0.09077545f, -0.08474524f, 0.00670807f, 0.22574440f, -0.04465114f, -0.00510962f, 0.01474688f, 
    -0.40852520f, 0.17915103f, -0.01912662f, -0.00002472f, -0.02097101f, 0.03130505f, 0.08682559f, 0.06390337f, 
    0.08063281f, -0.01763547f, 0.04705607f, 0.16216654f, 0.09449991f, 0.15041415f, -0.01954091f, -0.25314149f, 
    -0.19782861f, -0.00053821f, -0.09841733f, -0.14425799f, -0.16221753f, 0.15296689f, -0.07968004f, -0.03230605f, 
    -0.22229388f, -0.18970992f, -0.06964993f, 0.14172880f, 0.10899006f, 0.02575017f, 0.10091197f, -0.23939925f, 
    0.07745230f, 0.03290130f, 0.15295027f, -0.00889124f, -0.09667592f, -0.28844070f, 0.01588979f, -0.08124750f, 
    -0.04978949f, -0.02387564f, -0.04114339f, 0.10750043f, 0.03584870f, 0.07589836f, 0.01470908f, 0.01192396f, 
    0.15852420f, 0.01053688f, 0.22222711f, 0.01001824f, -0.05450005f, -0.00685817f, 0.01668085f, 0.08304185f, 
    0.10722084f, -0.05837458f, -0.00489471f, 0.09757107f, -0.19784924f, -0.08012970f, -0.13557738f, -0.20221306f, 
    -0.18463226f, -0.08640153f, -0.03514283f, 0.20193841f, -0.12647231f, 0.11718164f, 0.09253801f, 0.20763989f, 
    0.03684445f, 0.02560526f, -0.09872507f, 0.44002175f, -0.10081971f, -0.06209646f, -0.10835984f, -0.02730024f, 
    0.14602014f, -0.01721628f, -0.11594541f, -0.02055574f, 0.15505348f, -0.04484646f, 0.24329889f, 0.11768014f, 
    0.08689564f, 0.01298188f, 0.21212675f, 0.08942235f, 0.00547139f, -0.01992855f, -0.04583033f, 0.07203653f, 
    -0.29361096f, 0.26017886f, -0.47841665f, 0.21916866f, -0.02303584f, 0.07161783f, -0.06754835f, 0.04380815f, 
    -0.03459217f, -0.09171269f, -0.00579102f, 0.26707998f, -0.33637121f, -0.05616781f, -0.13112253f, -0.11080441f, 
    0.00268066f, 0.11083771f, 0.01816680f, 0.03768507f, 0.12163966f, -0.07435220f, -0.01722133f, -0.03323946f, 
    -0.14832498f, -0.06271075f, -0.00254789f, -0.19481216f, 0.09984848f, -0.01371865f, 0.05599259f, -0.07930010f, 
    -0.06322519f, 0.01285730f, 0.20540711f, -0.14687137f, 0.37258628f, -0.16454138f, 0.06641612f, -0.12352944f, 
    -0.16748121f, -0.21925415f, 0.15587814f, -0.01636960f, 0.03650070f, -0.03344515f, -0.15030226f, -0.14387780f, 
    -0.37784553f, 0.19848529f, -0.15279199f, 0.29446664f, -0.09034679f, 0.14102870f, -0.03771338f, 0.00009928f, 
    0.14166279f, 0.08065021f, 0.04458912f, 0.12755081f, 0.01753156f, 0.12780069f, -0.16798548f, 0.00950773f, 
    0.02057566f, -0.00738672f, -0.03442994f, -0.02911763f, 0.00727018f, 0.04000955f, 0.04335358f, 0.01407925f, 
    0.42938444f, 0.11060537f, -0.03505434f, 0.29427469f, -0.10419729f, 0.08650780f, 0.05455387f, -0.02421160f, 
    -0.10325345f, -0.02491486f, 0.00114393f, 0.09238228f, -0.08016170f, 0.17222044f, 0.12163373f, -0.44618037f, 
    -0.09355304f, 0.07816114f, 0.00972795f, 0.00268348f, 0.04447544f, 0.00232561f, 0.14204904f, 0.10617189f, 
    0.31139982f, 0.30100560f, 0.11269297f, 0.21158390f, 0.13121915f, -0.12383115f, -0.00242885f, 0.22506186f, 
    -0.02859863f, -0.04833718f, 0.00727900f, -0.05670440f, 0.17815347f, -0.14299831f, 0.03122671f, 0.01483690f, 
    0.06721641f, -0.01012472f, 0.12797596f, 0.15826330f, -0.03893373f, 0.13416564f, 0.04822331f, -0.05230693f, 
    0.12532118f, -0.01480878f, 0.13503845f, 0.01414150f, -0.00572681f, -0.07060549f, -0.01644720f, -0.01249806f, 
    -0.06632636f, -0.04030012f, 0.00322974f, 0.05383626f, 0.08669315f, -0.03655777f, 0.06541099f, 0.06939393f, 
    -0.02193971f, 0.00155292f, -0.05113811f, 0.17976844f, 0.07232638f, -0.18973607f, -0.11873884f, -0.09765167f, 
    0.06910370f, -0.07715602f, 0.09765681f, -0.03286420f, 0.01817446f, -0.11633576f, -0.00827756f, 0.07486527f, 
    0.19540399f, 0.03085066f, -0.09461731f, 0.06438482f, 0.02236343f, 0.00411905f, -0.25291824f, 0.01568569f, 
    -0.03481834f, 0.05373203f, -0.09512157f, -0.01735011f, 0.04425945f, -0.10234267f, -0.03289459f, 0.00436991f, 
    0.10566223f, 0.26305756f, 0.10827137f, -0.32116047f, -0.04070771f, -0.14137927f, 0.13284045f, -0.05952624f, 
    -0.15280125f, 0.11735377f, -0.03170882f, -0.02143935f, -0.41165048f, 0.07981055f, -0.20184471f, 0.28318956f, 
    0.07510635f, -0.07360397f, -0.11532187f, 0.11517395f, -0.12838864f, 0.01860802f, 0.07532910f, -0.14736292f, 
    0.12538256f, -0.06707949f, 0.39766720f, -0.21810782f, 0.16117781f, -0.05791942f, 0.16083127f, 0.07869672f, 
    -0.09711825f, 0.08126219f, -0.05455855f, 0.01404584f, -0.11274987f, -0.20475851f, -0.26393145f, 0.35261029f, 
    0.11890715f, 0.01876271f, -0.02124646f, 0.02253266f, -0.00319386f, 0.06240730f, -0.08146527f, 0.07772270f, 
    0.03319785f, -0.13100129f, 0.02354406f, -0.10219976f, 0.15143183f, -0.04208578f, 0.01393797f, 0.03002973f, 
    -0.07059270f, -0.08829422f, -0.06260704f, -0.10567800f, 0.22107783f, -0.31066290f, -0.04314208f, 0.25811154f, 
    0.23057072f, -0.10820786f, -0.05256324f, 0.12179176f, -0.11517460f, 0.06094632f, -0.02816382f, 0.00309145f, 
    -0.06884703f, 0.13251227f, -0.15687269f, -0.18143599f, -0.08118574f, 0.13739927f, -0.04954689f, -0.07413648f, 
    0.01088285f, 0.04254778f, 0.12685563f, -0.12808128f, 0.39965579f, 0.09278576f, 0.03808734f, 0.04151834f, 
    0.14589621f, 0.13455552f, 0.00356072f, 0.06983561f, 0.05895065f, 0.16623156f, 0.01350893f, 0.03904685f, 
    0.14942873f, 0.18156575f, 0.32412621f, -0.16271411f, 0.11429691f, -0.04218784f, 0.06843520f, -0.09129426f, 
    -0.04522475f, 0.02412464f, -0.03296332f, 0.12444142f, -0.18767007f, 0.06702616f, -0.09560882f, -0.01197623f, 
    0.06916814f, 0.09596851f, -0.01944511f, 0.10882089f, -0.08454157f, 0.05469566f, 0.05635048f, 0.03661939f, 
    -0.12987451f, 0.24735788f, -0.10662090f, -0.15021919f, -0.10642796f, -0.03046159f, -0.08226863f, 0.04958140f, 
    -0.02076983f, -0.02025459f, -0.00026393f, 0.00618964f, 0.09994234f, -0.15189794f, -0.02235312f, -0.01249440f, 
    0.07884421f, 0.06216870f, -0.00131132f, 0.18083589f, 0.19372319f, 0.03901272f, 0.05767711f, 0.07307997f, 
    0.07129022f, -0.04511867f, 0.20128620f, -0.44317389f, 0.04795880f, -0.02680091f, 0.12960149f, 0.12552726f, 
    -0.07810003f, -0.11484268f, 0.11753597f, 0.06174633f, 0.29737416f, 0.14020051f, -0.13596117f, 0.07769340f, 
    -0.02757580f, -0.01365438f, 0.00606878f, 0.06725112f, -0.06853344f, 0.13077007f, 0.00599610f, 0.00428148f, 
    0.08127584f, -0.25143817f, 0.01285908f, 0.05515757f, -0.03039906f, 0.01733611f, -0.00129211f, 0.03789958f, 
    0.17414778f, 0.07338341f, 0.02595783f, -0.03929762f, 0.42150396f, -0.11850870f, 0.06739888f, 0.34813681f, 
    0.00925957f, 0.16490583f, 0.16501410f, 0.09076121f, 0.04529692f, 0.17619304f, -0.01873079f, -0.06048882f, 
    -0.02365497f, 0.17053294f, -0.11726310f, -0.11743161f, -0.06627005f, 0.08884174f, -0.12701821f, 0.11681459f, 
    -0.06403900f, -0.11551246f, 0.05221947f, -0.05471437f, -0.17322873f, -0.06644759f, -0.03772752f, -0.00594024f, 
    0.14850019f, 0.11494830f, -0.06426098f, -0.04156676f, -0.08264298f, -0.02807709f, 0.04889791f, -0.18788308f, 
    0.19486876f, -0.16837718f, 0.17623200f, -0.05939333f, 0.09765057f, 0.14175023f, -0.04686971f, 0.00983708f, 
    0.05573872f, 0.04779665f, 0.13691738f, -0.05158481f, 0.21754488f, -0.27235937f, 0.07877208f, 0.20667569f, 
    -0.14326525f, 0.04281237f, 0.01757678f, 0.07811556f, -0.07133171f, -0.00677247f, 0.05716372f, -0.21324950f, 
    -0.01259368f, 0.05409864f, -0.04381708f, 0.38681081f, -0.06437454f, -0.01555916f, -0.02468229f, -0.02702863f, 
    -0.17338429f, -0.00072437f, -0.14597285f, 0.14059077f, 0.28230384f, 0.12980171f, 0.20735642f, 0.04675461f, 
    0.01681907f, -0.04732856f, 0.04163688f, 0.06863075f, -0.06412551f, -0.05668890f, 0.03986710f, -0.04434198f, 
    -0.04101552f, 0.15597492f, -0.07046340f, 0.08299331f, 0.01146302f, 0.14386234f, 0.10534833f, -0.04620565f, 
    -0.03314455f, -0.07674365f, -0.09391436f, -0.16424356f, -0.22933692f, 0.11159360f, 0.27885279f, -0.15346505f, 
    0.10198817f, 0.03273020f, -0.04474128f, 0.02334442f, 0.03394114f, 0.00142913f, -0.01018488f, 0.05414011f, 
    0.17993909f, 0.02284271f, 0.28074196f, -0.01758304f, -0.04587590f, -0.03377317f, 0.10085936f, -0.00617346f, 
    -0.00902025f, 0.25474742f, 0.09514464f, -0.10864824f, -0.31018513f, 0.15152109f, -0.02894961f, 0.30147642f, 
    -0.13266246f, 0.11866786f, -0.01714160f, 0.08086430f, -0.02391714f, -0.03872781f, -0.04047200f, -0.02130360f, 
    -0.31165278f, 0.11876249f, -0.31304219f, -0.05084629f, 0.17284492f, 0.11784440f, 0.05444104f, -0.06180435f, 
    0.08149993f, -0.00549222f, 0.00443477f, 0.14952910f, -0.26850420f, -0.20389162f, 0.03729732f, 0.15221392f, 
    0.03563442f, -0.05331569f, -0.10698044f, -0.04446496f, 0.06573087f, -0.00564226f, 0.03061339f, 0.16796692f, 
    0.27907997f, 0.16209729f, -0.22718197f, 0.22654854f, 0.00585838f, 0.04747435f, -0.00634771f, -0.02766493f, 
    0.08735756f, 0.08782989f, 0.02436417f, -0.02692991f, -0.48237905f, -0.08793645f, -0.19414569f, 0.27387837f, 
    0.19180870f, 0.01825735f, 0.02122304f, 0.03898107f, 0.09427826f, 0.08206820f, 0.09714536f, -0.02731998f, 
    0.16361530f, 0.21039902f, 0.23305866f, -0.19681738f, -0.03962848f, -0.03941565f, -0.05599882f, 0.04902713f, 
    -0.05078550f, 0.01586938f, 0.06927310f, 0.17457615f, 0.32490805f, 0.17294654f, 0.06939072f, 0.04487719f, 
    -0.08086744f, -0.05383619f, 0.05291902f, -0.00701405f, -0.13353099f, 0.00867070f, 0.00457257f, 0.14172986f, 
    -0.20457782f, 0.23849632f, 0.18608275f, 0.06859411f, 0.00261543f, -0.02378090f, 0.09240880f, 0.05957052f, 
    -0.05248239f, -0.16242412f, 0.05652650f, 0.00742151f, 0.44754580f, -0.01397270f, -0.16675775f, -0.19342537f, 
    -0.08601066f, 0.13024990f, 0.09616325f, -0.20622382f, -0.05768431f, -0.04525260f, 0.20734631f, 0.15901829f, 
    0.39977637f, -0.08352841f, -0.29829007f, -0.12309900f, -0.01868401f, -0.06484584f, -0.09697840f, 0.03372537f, 
    0.06578650f, 0.00180500f, -0.08292320f, -0.04678356f, 0.12700608f, 0.01339706f, 0.00615091f, -0.29045033f, 
    0.08833396f, 0.07902322f, -0.09342138f, -0.03631268f, 0.01182214f, -0.09470730f, -0.00478290f, -0.11959095f, 
    -0.22587900f, -0.05719441f, -0.12932718f, 0.03896938f, 0.03773952f, -0.04367687f, 0.14343256f, 0.06296423f, 
    0.06814347f, 0.01097035f, -0.09479159f, -0.13037148f, -0.04385249f, 0.02453295f, -0.13367648f, -0.28675032f, 
    -0.07691805f, 0.03536092f, 0.00731652f, 0.00428522f, 0.00420431f, -0.13248964f, 0.06276164f, 0.00972163f, 
    0.35523137f, -0.20582297f, -0.15174556f, 0.10939454f, -0.02550330f, -0.00606653f, 0.03548265f, 0.01347004f, 
    -0.08839060f, -0.06514320f, -0.03036975f, 0.10528593f, 0.39849919f, 0.01903739f, 0.03289686f, 0.03911949f, 
    0.08290412f, 0.13251114f, 0.09929536f, -0.09536512f, -0.07808770f, 0.09981793f, -0.01162764f, 0.05120487f, 
    0.01528046f, -0.16729160f, -0.06549609f, 0.25692186f, -0.04095227f, -0.08586144f, 0.07637294f, 0.02160649f, 
    0.03799652f, -0.10603970f, 0.03387409f, -0.05265321f, -0.00844680f, -0.01429780f, 0.01793551f, 0.16444711f, 
    -0.19200167f, 0.07783256f, -0.01950107f, -0.14684205f, -0.07260201f, 0.00462613f, 0.03063019f, -0.00769248f, 
    0.02676835f, 0.10002962f, -0.18432218f, -0.20561318f, 0.13681191f, 0.17198187f, -0.02985644f, 0.06269106f, 
    0.12788439f, 0.00179118f, 0.07751653f, -0.03887666f, -0.32897335f, 0.06911449f, -0.01764474f, 0.19046919f, 
    0.22079007f, 0.15130205f, 0.07079243f, -0.02490046f, 0.03608589f, -0.22357936f, 0.02723717f, 0.00386088f, 
    -0.02154338f, -0.13285917f, -0.13738619f, 0.33771321f, 0.17602114f, 0.00936422f, 0.10750777f, -0.13033816f, 
    0.07083739f, 0.08465851f, -0.05968149f, -0.04543228f, 0.10206339f, 0.08314859f, 0.10159441f, 0.08978514f, 
    0.00428581f, 0.12096030f, -0.00608919f, -0.04361768f, 0.03870508f, 0.04253933f, -0.09308438f, 0.08906895f, 
    0.30229747f, 0.20167692f, 0.09668136f, -0.20111644f, -0.13433862f, -0.03910141f, 0.10586452f, 0.07864554f, 
    -0.16832128f, -0.05518072f, 0.06024205f, 0.17300299f, 0.15760171f, 0.18281966f, -0.03665734f, -0.22671261f, 
    -0.16448423f, -0.17358042f, 0.16051728f, -0.11588231f, 0.00913885f, -0.06522206f, -0.04687839f, -0.04111425f, 
    0.00697675f, 0.00770100f, -0.03018562f, -0.03014091f, -0.01575020f, -0.02872852f, -0.03547150f, -0.02339075f, 
    0.00189128f, 0.01553613f, 0.00698743f, 0.01172363f, 0.02876285f, -0.05116692f, -0.02208140f, 0.00253455f, 
    0.00266393f, -0.00483434f, -0.03353589f, 0.01862909f, 0.03808336f, -0.05359669f, 0.00004932f, 0.04090391f, 
    -0.03185316f, -0.02288209f, 0.03997815f, 0.01565906f, -0.02616930f, 0.04630408f, 0.02415518f, 0.03317005f, 
    0.03596568f, 0.02066462f, 0.03050518f, 0.04309010f, 0.01918112f, -0.01431512f, 0.02247074f, 0.01304323f, 
    0.00548337f, 0.01591916f, 0.02348518f, 0.00277167f, -0.04235291f, 0.01284794f, 0.02447214f, 0.00632780f, 
    0.04045091f, 0.00123586f, -0.02282609f, 0.00211966f, -0.00197852f, 0.00338285f, 0.01066176f, 0.03759092f, 
    -0.00401515f, -0.01883046f, 0.04430535f, -0.01380072f, -0.03707153f, -0.01050581f, -0.02153214f, 0.01999058f, 
    -0.04480922f, 0.00201585f, -0.00742567f, 0.01321405f, -0.05248782f, -0.01435786f, -0.02933883f, -0.00743613f, 
    -0.02645470f, 0.00945362f, -0.02004891f, 0.03078583f, 0.00956370f, -0.02347259f, -0.00031952f, -0.05182550f, 
    -0.01184683f, 0.03417841f, -0.00030142f, -0.01955208f, -0.01588415f, 0.01923732f, 0.02014071f, -0.03924952f, 
    -0.05720368f, -0.02291378f, -0.05074228f, 0.03826394f, 0.01698912f, 0.00441599f, 0.00059929f, 0.03286713f, 
    -0.04326483f, 0.01140335f, -0.01004597f, 0.00837324f, -0.00508869f, 0.02721533f, 0.02497992f, -0.01175000f, 
    -0.03741858f, -0.01465873f, 0.01209846f, -0.03991800f, -0.03695880f, 0.02197999f, -0.00581843f, 0.00060276f, 
    -0.04605617f, 0.02090680f, 0.01157820f, -0.01871034f, 0.01421107f, -0.03367829f, -0.04238296f, -0.00647755f, 
    -0.01538516f, 0.02252048f, 0.02919626f, 0.00720601f, -0.00493888f, -0.04664040f, -0.02362051f, 0.04339182f, 
    -0.05483956f, -0.03516636f, 0.02010139f, 0.03634711f, 0.00829006f, -0.02127382f, 0.03812515f, -0.02155207f, 
    0.01495489f, -0.00336244f, 0.04547976f, -0.02293934f, -0.01323666f, 0.00972652f, -0.00716365f, 0.00530932f, 
    -0.04859350f, 0.01451713f, 0.02272337f, -0.03495036f, -0.01039823f, 0.00873143f, -0.04483016f, -0.01037289f, 
    -0.00205224f, -0.04487619f, 0.02416687f, -0.05415121f, -0.03660907f, -0.01616581f, 0.04109183f, 0.02320942f, 
    0.03104048f, -0.03695120f, -0.00721183f, -0.01660294f, -0.05344724f, -0.03113889f, -0.05166841f, 0.04135540f, 
    -0.02245898f, 0.02600211f, 0.00291797f, -0.03433152f, 0.03227326f, 0.00252736f, 0.03668103f, 0.03818524f, 
    -0.00889012f, 0.01899728f, 0.00013383f, -0.02866820f, 0.00383291f, -0.05464154f, 0.01159601f, -0.02701158f, 
    -0.01896519f, -0.01259581f, -0.00751096f, -0.01779068f, 0.02918482f, -0.02861793f, -0.01861960f, -0.03528245f, 
    0.03497141f, 0.02117877f, -0.01692134f, -0.02690859f, 0.00939076f, -0.01974267f, 0.04507572f, 0.03299270f, 
    -0.00175218f, 0.00754744f, -0.02938349f, -0.01623105f, 0.01794436f, 0.01565990f, 0.03072962f, -0.03912970f, 
    0.00744701f, -0.01426820f, 0.02577900f, -0.05798271f, 0.00900109f, 0.04396864f, 0.03520784f, -0.01649642f, 
    -0.03702413f, 0.02468051f, -0.03044560f, -0.02809213f, -0.01026540f, -0.02467676f, 0.02867755f, -0.01840664f, 
    -0.01962697f, -0.00848250f, 0.01307283f, -0.03939172f, 0.03351833f, 0.04348995f, 0.02522854f, -0.01364448f, 
    -0.00754961f, -0.01778371f, -0.01245156f, 0.02527476f, 0.03899805f, -0.02426690f, -0.03340384f, 0.03599687f, 
    0.01557157f, 0.03198008f, 0.00735175f, -0.00065161f, -0.00818693f, 0.00134706f, -0.02886068f, -0.02143247f, 
    -0.02713049f, 0.00651287f, -0.05483681f, 0.00464185f, 0.01694953f, -0.05167456f, -0.00855278f, -0.00723469f, 
    -0.05419266f, -0.06023375f, 0.00166186f, -0.05330150f, -0.03310405f, -0.04976572f, 0.03386332f, 0.01792760f, 
    -0.01116506f, -0.05142485f, 0.02490846f, 0.03547891f, -0.00491297f, -0.01856529f, -0.01220569f, -0.04066870f, 
    -0.04453737f, -0.01469955f, -0.00969787f, -0.04874108f, -0.04485862f, 0.03306647f, -0.00550158f, 0.03628673f, 
    -0.01746949f, -0.04345955f, 0.01363562f, 0.02835883f, 0.01914302f, -0.03775033f, -0.02317351f, 0.03162802f, 
    -0.02103287f, -0.01179510f, 0.03253569f, -0.03641675f, -0.04823188f, -0.02145392f, 0.02537501f, 0.02871008f, 
    -0.03184624f, -0.03861440f, 0.04298635f, -0.04699207f, -0.02923777f, -0.00139937f, 0.04510165f, 0.02192124f, 
    -0.02339315f, -0.01232036f, 0.00436327f, 0.03359365f, -0.01870535f, 0.03250177f, -0.03253195f, -0.03773182f, 
    0.02522666f, -0.05006064f, -0.04164500f, -0.05303225f, -0.01097532f, 0.02817278f, 0.01200762f, -0.01618991f, 
    -0.05129868f, 0.01690158f, 0.01819448f, -0.03493522f, -0.00944458f, -0.02271928f, 0.01463683f, -0.05073697f, 
    0.03952947f, 0.00807938f, -0.04081082f, -0.04431800f, -0.00213410f, -0.03161769f, -0.00252040f, -0.03363416f, 
    -0.02289807f, -0.01892580f, 0.01556352f, 0.02350335f, -0.02262806f, 0.01941599f, -0.01038094f, -0.03256197f, 
    0.02322428f, -0.00350721f, 0.02976821f, 0.00958757f, 0.01193787f, -0.00218630f, 0.03854799f, 0.03625669f, 
    -0.03787635f, 0.01120850f, -0.05749727f, 0.00377757f, -0.03677394f, 0.01271608f, -0.04500487f, 0.02498279f, 
    0.00978804f, -0.03077059f, -0.02609645f, 0.02918224f, 0.03218849f, 0.02396745f, -0.04443241f, -0.01635463f, 
    -0.04036170f, -0.01600223f, -0.01778054f, 0.00919549f, 0.01576691f, -0.03428093f, -0.04213328f, -0.03673152f, 
    -0.01452743f, -0.00141752f, 0.00271632f, -0.01894965f, 0.03158096f, 0.04016242f, -0.05256726f, -0.04541109f, 
    0.38813618f, -0.19618568f, 0.13462290f, -0.08774930f, 0.08471791f, -0.06129827f, 0.01826919f, 0.06766410f, 
    0.12553251f, -0.00593879f, 0.06990258f, -0.06696738f, 0.16951869f, 0.07885937f, 0.12629680f, 0.40654054f, 
    0.05739795f, 0.12337994f, -0.03574581f, 0.05227214f, 0.07846972f, 0.02407981f, 0.15422454f, 0.04866109f, 
    -0.10959613f, -0.17366008f, 0.00297688f, 0.02608939f, 0.09034231f, 0.06355739f, 0.06293144f, -0.07311778f, 
    -0.04370942f, 0.15176193f, -0.02867742f, 0.05525856f, 0.19940999f, 0.18411362f, 0.18798229f, -0.12055728f, 
    0.10528111f, -0.05447981f, 0.16621912f, -0.00467670f, -0.11385134f, -0.04779114f, -0.05668530f, 0.14640236f, 
    -0.05901985f, -0.06641060f, 0.18907416f, 0.08560136f, -0.03080819f, -0.14930500f, 0.17747921f, -0.07594764f, 
    0.00123140f, -0.10161973f, 0.04643502f, -0.01474895f, -0.18514350f, -0.10387691f, -0.13466582f, 0.10986418f, 
    0.02681550f, 0.11768334f, -0.03077913f, 0.02143442f, -0.06534400f, -0.01922682f, 0.07835381f, -0.08211007f, 
    -0.13193440f, -0.07836506f, 0.05133650f, -0.15453506f, -0.09442367f, -0.06246667f, -0.02420480f, -0.01126317f, 
    -0.05362301f, 0.07589334f, -0.08339681f, -0.11927694f, -0.11117648f, -0.04900790f, -0.01495166f, -0.37458006f, 
    0.04008543f, -0.05521154f, -0.07900530f, 0.15374495f, -0.05070994f, -0.02705199f, 0.09994638f, 0.01780453f, 
    0.11298141f, -0.05675188f, 0.06044037f, 0.23576242f, 0.00248291f, 0.09133065f, -0.10816959f, 0.01268563f, 
    0.12189065f, -0.15350023f, -0.05385175f, 0.08648497f, 0.03319246f, -0.20022039f, -0.08185581f, -0.11802223f, 
    0.04730487f, -0.13288188f, 0.08928977f, -0.07578824f, 0.09230906f, 0.01598827f, -0.05017676f, -0.01451158f, 
    0.04238563f, 0.24074091f, 0.22985107f, 0.24585868f, -0.08145722f, 0.11185275f, 0.00114253f, 0.02693437f, 
    -0.05571551f, 0.03187387f, 0.02020841f, -0.04243071f, 0.22418253f, 0.07126433f, 0.16518360f, 0.10823874f, 
    0.04739463f, -0.04420795f, -0.03224929f, -0.01005993f, 0.01029085f, 0.00125443f, 0.16719054f, 0.04331113f, 
    -0.21060288f, -0.13253218f, 0.06023638f, 0.05816890f, 0.07796720f, 0.03121654f, -0.13354363f, 0.05973816f, 
    -0.00425418f, -0.00536508f, 0.02824238f, 0.08955074f, 0.12714782f, -0.03882344f, 0.12919229f, -0.10056276f, 
    0.12944768f, 0.08126994f, 0.03627759f, 0.03872429f, 0.01709786f, 0.12256637f, 0.12988919f, -0.07256967f, 
    -0.44761550f, -0.21599254f, -0.10998578f, 0.34462985f, 0.04505663f, 0.03499255f, 0.00813543f, -0.06463546f, 
    0.11778668f, -0.03605282f, -0.08135983f, -0.03620789f, -0.15401843f, -0.15500677f, 0.07056776f, 0.39329359f, 
    0.12993963f, 0.30911645f, 0.00966306f, -0.01436635f, -0.07268158f, 0.00640983f, 0.11739604f, -0.05706602f, 
    -0.03073779f, 0.09102328f, -0.23338884f, -0.11312456f, -0.14592555f, -0.00657694f, 0.06232943f, -0.11708102f, 
    0.07894943f, 0.07651569f, 0.07284281f, -0.08928168f, -0.08497430f, -0.22094399f, 0.20574321f, 0.08135883f, 
    -0.09998651f, -0.02790379f, -0.09623511f, -0.18706906f, 0.01111448f, -0.00267514f, -0.03847186f, -0.03658108f, 
    -0.25821811f, 0.20676190f, 0.04811344f, 0.27146876f, -0.14861566f, -0.07521617f, -0.00937042f, -0.03851738f, 
    0.01202112f, -0.02759802f, -0.04206417f, 0.00301927f, -0.21321572f, 0.25234711f, 0.13377325f, -0.21907042f, 
    0.07419514f, 0.07469601f, 0.00664299f, 0.06757990f, -0.02286907f, 0.11310329f, -0.11284743f, -0.02969822f, 
    0.02812496f, 0.15029995f, -0.09646505f, 0.09576882f, -0.03181786f, 0.01274724f, 0.06774310f, 0.07016961f, 
    0.06992888f, -0.12277625f, 0.07683222f, -0.02811175f, -0.00496179f, 0.00152567f, -0.05284736f, 0.01938786f, 
    0.05500300f, 0.05579167f, 0.09524874f, 0.14065439f, -0.04792757f, -0.12396376f, 0.04718654f, -0.08762800f, 
    -0.11997737f, 0.07195092f, 0.41080409f, 0.07832365f, 0.05747115f, -0.17000507f, -0.11823625f, -0.12203711f, 
    0.13014390f, 0.06955048f, -0.18616089f, 0.00348117f, 0.08678887f, 0.46450385f, 0.12234388f, 0.29190588f, 
    0.03216014f, -0.00980828f, 0.15304713f, 0.12888199f, -0.02310009f, -0.01180195f, -0.01324414f, 0.10669168f, 
    -0.35566086f, 0.34899741f, 0.25282460f, 0.11738019f, -0.17213702f, 0.09872767f, -0.07011469f, -0.03748250f, 
    -0.03650331f, 0.13616031f, 0.03043365f, 0.21013100f, -0.19465362f, 0.26962748f, 0.26675522f, 0.08749850f, 
    -0.11352988f, 0.06975473f, -0.00724596f, -0.02280508f, 0.14423168f, -0.06428820f, -0.10151565f, -0.01896467f, 
    -0.20341977f, 0.13476257f, 0.23206051f, -0.02899354f, 0.03877245f, 0.04570014f, 0.07404619f, -0.10903579f, 
    0.05554894f, -0.07059041f, 0.00329662f, 0.04005738f, 0.20879498f, -0.01260067f, 0.11917653f, 0.01421665f, 
    0.09625926f, 0.19855197f, -0.03946899f, 0.03875529f, -0.05223781f, -0.07646628f, -0.06115353f, 0.01701383f, 
    -0.02004397f, 0.15574151f, -0.21092483f, 0.13309579f, -0.09656011f, 0.04274569f, 0.04131186f, 0.01792195f, 
    0.03291382f, -0.14441746f, -0.01941455f, 0.11289635f, -0.00011134f, -0.02156942f, 0.25205919f, 0.11372559f, 
    -0.10037367f, 0.02859999f, 0.01243383f, -0.04611161f, -0.01956891f, 0.06995039f, -0.00387884f, 0.04861819f, 
    -0.41264039f, -0.28677729f, -0.04213388f, 0.29585359f, -0.03278532f, 0.08110096f, -0.02837741f, -0.00034727f, 
    0.09492758f, 0.10115796f, 0.04880124f, -0.02435083f, 0.16003789f, -0.22792463f, 0.08387145f, 0.21618406f, 
    0.12437881f, 0.03376890f, -0.04941792f, 0.05788215f, -0.09893693f, 0.00423607f, -0.15584260f, -0.06294769f, 
    -0.01106560f, -0.01989692f, -0.03416899f, -0.03699298f, -0.01026163f, -0.03597938f, -0.01111682f, 0.01974348f, 
    0.04811128f, 0.03082982f, 0.04275994f, -0.00025037f, -0.03704459f, -0.04016051f, 0.00820445f, -0.00316866f, 
    -0.00013420f, -0.03082522f, 0.01656249f, -0.03864767f, 0.01530173f, -0.01259230f, -0.02151457f, -0.03050094f, 
    0.03605102f, -0.00599820f, -0.00269906f, -0.02119467f, -0.05164582f, 0.03567461f, -0.02363263f, -0.00595273f, 
    -0.01781396f, -0.03959495f, 0.00638427f, -0.02559830f, -0.02110792f, 0.01407400f, -0.05666909f, 0.00170045f, 
    -0.01011615f, 0.00209349f, -0.02660072f, 0.00599962f, 0.02096849f, 0.04278709f, -0.03412855f, 0.02013306f, 
    0.03801398f, 0.01600094f, 0.00287077f, -0.01988447f, -0.03637135f, 0.03209776f, 0.03549786f, -0.04917789f, 
    0.04124194f, 0.03769786f, 0.03121580f, -0.00567095f, 0.02808920f, -0.05032147f, -0.05431367f, -0.02006957f, 
    -0.01797072f, -0.01255782f, -0.00400634f, -0.00228147f, -0.00397640f, 0.02483853f, -0.05008322f, -0.04946127f, 
    0.03898197f, -0.01741953f, -0.02036671f, -0.01857273f, 0.01867241f, -0.00036256f, 0.03168618f, -0.01340451f, 
    0.02723832f, 0.02358681f, -0.04185756f, -0.03037472f, -0.04922504f, -0.04159520f, 0.02314521f, 0.02625355f, 
    0.00874666f, -0.00756516f, -0.00140585f, -0.05050355f, 0.04633451f, 0.02768818f, -0.03349737f, -0.01047216f, 
    -0.02636514f, -0.00479881f, -0.05390291f, 0.03467969f, -0.01334468f, -0.04839354f, -0.03090580f, 0.03942477f, 
    -0.00812419f, 0.01186655f, 0.04495842f, 0.00484693f, 0.04215946f, -0.00624278f, 0.03146891f, -0.00258467f, 
    -0.04879178f, -0.05399518f, 0.00142727f, -0.02813748f, -0.05111719f, 0.01319508f, -0.05979022f, -0.00290703f, 
    -0.02676672f, 0.01817933f, -0.00873867f, 0.00450114f, -0.04523425f, -0.04188147f, -0.05727986f, -0.05322429f, 
    0.02502893f, 0.02569656f, -0.01358160f, -0.04456809f, 0.01788268f, 0.03955336f, -0.04114990f, -0.00485910f, 
    0.00524228f, 0.03562308f, -0.02112850f, 0.04275483f, -0.04068296f, -0.04963269f, 0.03059750f, -0.01108039f, 
    0.03360637f, -0.04282823f, 0.00152757f, -0.02772973f, -0.00437524f, 0.03524278f, 0.00023697f, -0.01222402f, 
    -0.05249383f, -0.04433568f, -0.01111230f, 0.00824547f, -0.03576996f, -0.00296373f, 0.01808307f, 0.01346926f, 
    0.00657175f, -0.03538236f, -0.02427878f, -0.00085575f, 0.03995772f, -0.02651507f, 0.04136354f, -0.01846335f, 
    0.02814288f, -0.00365624f, -0.01930629f, -0.04549084f, -0.03102919f, 0.02480264f, 0.02164104f, -0.02432355f, 
    -0.05593600f, -0.02239864f, -0.01887844f, -0.04802898f, -0.03666972f, -0.02403115f, -0.03885110f, 0.01268711f, 
    -0.04321568f, -0.02934345f, 0.00232075f, -0.00838746f, -0.00195132f, -0.04243967f, 0.03943244f, -0.00246388f, 
    0.03001756f, 0.02553037f, -0.00114033f, -0.03969958f, -0.02352979f, -0.04263931f, -0.02786957f, -0.01617878f, 
    0.00162703f, -0.05171103f, -0.01171880f, -0.05103268f, 0.03252764f, -0.05180680f, 0.00495629f, -0.02652880f, 
    -0.00792200f, 0.00619623f, -0.02666892f, -0.00419229f, -0.01594551f, 0.00580727f, 0.03853863f, -0.01276303f, 
    -0.02236201f, 0.03389429f, -0.04487384f, -0.02554186f, 0.02689244f, 0.03250771f, 0.03999076f, -0.05816702f, 
    0.00608794f, -0.02223449f, -0.01193557f, 0.02046207f, 0.03155942f, -0.04959129f, 0.00967558f, -0.02499272f, 
    -0.00604642f, 0.01227183f, -0.01081706f, 0.00579031f, -0.02534024f, -0.03184441f, 0.04073596f, 0.01367972f, 
    -0.01020439f, -0.02866512f, 0.02738715f, 0.02873888f, 0.00451425f, -0.02514947f, 0.02152636f, -0.01291628f, 
    -0.02279820f, 0.01357759f, -0.00938760f, -0.03840238f, 0.04286617f, 0.00401658f, -0.01848254f, -0.04360721f, 
    0.01327060f, 0.03800496f, -0.02973380f, -0.03462260f, -0.03061258f, -0.03140775f, -0.05045238f, -0.01261915f, 
    0.05039052f, -0.02833466f, 0.00174928f, -0.04314599f, -0.05449923f, 0.00576080f, -0.03615249f, -0.00103499f, 
    0.01057047f, 0.00192516f, -0.05531276f, -0.05437884f, 0.00262785f, -0.04469802f, -0.04121043f, -0.00997122f, 
    -0.01271110f, 0.03395143f, 0.02258756f, 0.00568259f, -0.02037027f, -0.04278086f, -0.03081635f, 0.00365434f, 
    0.01317781f, -0.04567134f, -0.02881148f, -0.01383528f, 0.02544021f, -0.02178620f, -0.04243967f, 0.04912983f, 
    -0.00866485f, -0.00855925f, 0.03446095f, -0.04136795f, 0.01775605f, 0.01633346f, -0.03449159f, 0.00904261f, 
    -0.00881301f, 0.00870239f, 0.04592589f, -0.00340329f, -0.00784246f, -0.02908875f, -0.01946894f, -0.00583792f, 
    -0.02717834f, -0.03158418f, 0.00491188f, -0.02594919f, 0.03365138f, 0.00636192f, 0.00840459f, 0.03730121f, 
    0.01581479f, -0.05324680f, 0.01357451f, 0.04231165f, -0.02076511f, -0.04612970f, 0.01527411f, 0.04142506f, 
    0.04206011f, 0.03538894f, -0.04159440f, -0.00930993f, -0.03812767f, -0.00790357f, -0.01564780f, 0.01840992f, 
    -0.01936683f, 0.04595116f, -0.01464174f, -0.01251193f, -0.02609298f, -0.03292976f, -0.03202093f, -0.04367236f, 
    -0.02097030f, -0.00977765f, 0.04375662f, -0.00941434f, 0.03560988f, 0.01867679f, -0.03158731f, -0.03594389f, 
    0.01945722f, 0.02783302f, 0.01735599f, -0.01363106f, 0.00398484f, -0.01504577f, -0.04924501f, 0.00876173f, 
    0.03593098f, 0.04542580f, -0.04312328f, 0.03839346f, -0.00124844f, -0.02179869f, -0.00554202f, 0.02593183f, 
    0.00029554f, 0.02665282f, -0.03463478f, -0.00585842f, -0.04507039f, -0.05771851f, 0.04381485f, 0.00411789f, 
    0.01750408f, 0.03035186f, -0.04967376f, -0.03587892f, -0.02326931f, -0.03021091f, -0.04619358f, 0.02893887f, 
    0.04904405f, -0.12241938f, -0.03581925f, 0.02313593f, -0.20590135f, -0.09380873f, -0.00826970f, -0.05288759f, 
    0.06951130f, 0.09254039f, -0.09981483f, 0.11553074f, 0.12232443f, -0.14982127f, 0.06145434f, -0.04166913f, 
    0.06641267f, 0.14535309f, 0.04819024f, -0.04344326f, -0.06615318f, -0.03499300f, 0.12451009f, -0.00554870f, 
    -0.25713092f, 0.06978540f, -0.15712941f, -0.08673416f, -0.03201253f, 0.04914397f, -0.04364232f, 0.19230941f, 
    0.00338034f, -0.03439381f, 0.02172175f, 0.06644025f, -0.38131267f, 0.01951157f, -0.00291165f, 0.02667608f, 
    -0.04679984f, 0.07113387f, -0.01271387f, 0.15068468f, 0.12217081f, -0.05011379f, -0.08032073f, -0.03382305f, 
    0.17330189f, 0.14552768f, 0.25421730f, 0.12394541f, 0.09289573f, 0.13498081f, -0.02577122f, 0.06510012f, 
    -0.07934648f, 0.13410477f, 0.07936864f, 0.13795988f, -0.11248502f, -0.20607993f, 0.19702774f, -0.04107545f, 
    -0.14901695f, -0.06083542f, 0.04505885f, -0.11274495f, -0.03640127f, -0.04634947f, -0.25295582f, -0.02077900f, 
    -0.23980825f, 0.23891595f, -0.20158781f, 0.15815072f, 0.01151592f, 0.11482932f, 0.03983245f, 0.00804194f, 
    -0.00798007f, -0.00994248f, -0.18241516f, 0.03001620f, 0.03287232f, 0.24012141f, -0.02918614f, -0.07949549f, 
    0.12262678f, -0.04688425f, 0.00426123f, 0.02305158f, -0.07162291f, 0.05120551f, 0.01271289f, 0.16102999f, 
    -0.19095957f, -0.09100217f, 0.22174977f, -0.03113355f, -0.07714831f, 0.03533031f, 0.05214371f, 0.08098511f, 
    0.15181330f, 0.00675702f, 0.09994575f, 0.10783985f, -0.34034085f, -0.02966025f, 0.07314940f, 0.00033217f, 
    -0.06199636f, 0.09018520f, 0.01138602f, 0.08859445f, 0.07784170f, 0.06740680f, 0.07529812f, -0.00686247f, 
    0.16853778f, -0.14196430f, -0.26184905f, -0.19830137f, 0.07837686f, -0.04809089f, -0.03630659f, 0.09232704f, 
    -0.00303081f, -0.02119813f, 0.00814669f, -0.09871674f, 0.18559487f, 0.08311630f, 0.00222052f, 0.19888838f, 
    0.04254477f, 0.19908239f, 0.12250153f, 0.09336592f, -0.01844792f, 0.14284821f, 0.16314304f, 0.16437623f, 
    -0.36037391f, 0.12373827f, 0.02379289f, 0.07534140f, 0.09385557f, -0.02728801f, 0.07910907f, -0.03997920f, 
    0.00979873f, -0.10005188f, 0.10075291f, 0.07628873f, 0.07094657f, 0.06048507f, -0.06952305f, 0.21374489f, 
    0.00876296f, 0.06148546f, 0.02507112f, 0.12158268f, -0.02296775f, 0.00479735f, 0.04320863f, -0.05766176f, 
    -0.03759582f, -0.01475540f, 0.22138409f, 0.13939355f, 0.01645016f, 0.00501196f, -0.01057754f, 0.08407871f, 
    0.02298647f, 0.04449690f, 0.03029385f, 0.27893505f, 0.03251757f, 0.05396546f, 0.14408675f, -0.01032846f, 
    -0.06471208f, 0.13445483f, 0.00973604f, 0.03766419f, -0.05193648f, -0.12932260f, 0.02447915f, 0.07565408f, 
    0.12525848f, -0.32454774f, 0.38232511f, 0.01071054f, -0.08487355f, -0.02904740f, 0.17455772f, 0.10837482f, 
    -0.08433250f, 0.00445931f, 0.01771453f, 0.02997683f, -0.07528307f, 0.34169358f, 0.10159093f, -0.04718211f, 
    0.03280431f, 0.04181343f, -0.13250470f, 0.13869688f, -0.04720909f, -0.03049109f, 0.09365679f, 0.01188471f, 
    0.12579314f, -0.29367372f, 0.06389914f, -0.10115054f, 0.09542754f, -0.00963638f, 0.04599227f, 0.01064842f, 
    -0.03664184f, -0.03741396f, -0.06596610f, 0.06102274f, -0.24153428f, -0.11808181f, -0.14391220f, 0.12367518f, 
    0.02038472f, 0.03336898f, -0.06868070f, 0.04688903f, -0.01610745f, -0.01779814f, -0.03337536f, -0.07117029f, 
    0.04685255f, -0.21589337f, -0.13470982f, 0.12351940f, -0.06388321f, -0.13549170f, 0.03208076f, 0.12152022f, 
    0.04585584f, -0.10414522f, 0.03895414f, -0.15285447f, 0.22110236f, -0.19911954f, -0.00595679f, -0.01363992f, 
    0.25579920f, -0.04832402f, -0.04187435f, 0.03427647f, -0.05096469f, 0.03117249f, 0.04678895f, 0.05917405f, 
    -0.10506488f, 0.15164545f, -0.06914458f, -0.01471694f, 0.04094607f, 0.15696748f, 0.04827434f, 0.08632189f, 
    0.05492379f, 0.14484102f, 0.17082122f, 0.01673624f, -0.33812937f, -0.08826161f, -0.15610528f, -0.26051229f, 
    0.07541351f, -0.03082043f, -0.01784510f, -0.13190171f, 0.05585410f, 0.06708479f, -0.01161463f, 0.03215808f, 
    -0.06432600f, -0.14489527f, 0.14691083f, 0.11106237f, -0.04865720f, 0.01782221f, 0.16820993f, 0.00512325f, 
    0.21765743f, -0.00683018f, 0.01629923f, -0.03445520f, 0.02928545f, 0.07314290f, -0.05473465f, 0.04704181f, 
    -0.05953466f, 0.13600828f, 0.04357103f, 0.06410426f, -0.09518596f, -0.03647786f, 0.09606513f, 0.10187697f, 
    0.22016743f, 0.02791511f, -0.29447278f, -0.02731169f, -0.02802317f, 0.05291111f, -0.09183998f, 0.04878431f, 
    0.01682441f, 0.07050441f, -0.07288893f, -0.09462872f, 0.02080179f, -0.13840364f, -0.08941617f, 0.00042749f, 
    0.29124403f, -0.01307363f, 0.08989660f, 0.11672190f, 0.18498026f, -0.02513496f, 0.01898015f, 0.15171662f, 
    -0.10520256f, -0.32132378f, 0.32854083f, -0.07446742f, 0.07277954f, 0.00793042f, 0.21174286f, 0.03191183f, 
    0.05647003f, 0.09527826f, -0.13150786f, -0.06390771f, -0.02319952f, 0.22523041f, -0.01864532f, -0.00285606f, 
    0.00798817f, 0.08438299f, 0.01672845f, 0.06738822f, 0.10223585f, 0.06734815f, 0.00673418f, 0.04399406f, 
    0.05970955f, 0.00135692f, 0.32084429f, -0.12295430f, 0.03780838f, 0.00530571f, 0.07239024f, 0.06730541f, 
    0.02599610f, 0.00483326f, 0.08430754f, 0.08374735f, 0.02475179f, -0.08817205f, 0.01355346f, -0.06861459f, 
    -0.10254461f, 0.03779698f, 0.06404343f, 0.06375475f, 0.01573950f, -0.13660483f, -0.09025735f, 0.01515128f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.00706716f, -0.05521107f, -0.01435677f, -0.05284095f, 0.13104686f, -0.00341182f, 0.08014244f, 0.03443337f, 
    0.00465697f, -0.05421742f, 0.07322292f, 0.02823230f, -0.03004978f, 0.02307567f, -0.02264006f, -0.00548658f, 
    -0.03712538f, 0.02797073f, 0.08927981f, 0.06662157f, 0.01920250f, 0.01715176f, 0.01844051f, 0.00822321f, 
    -0.03119749f, 0.01014287f, 0.01865906f, -0.03162594f, -0.00314613f, -0.03126079f, -0.03558333f, 0.08388245f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.05530259f, 0.47106239f, 0.00564692f, -0.02272721f, 0.15428625f, 0.01515658f, -0.26277587f, 0.11059788f, 
    -0.02483025f, 0.00328666f, -0.65264475f, 0.02998278f, 0.10700551f, 0.15495849f, -0.17304598f, 0.10076611f, 
    0.09164060f, 0.11189149f, -0.36457315f, -0.44456956f, 0.06330125f, 0.13212512f, -0.41691121f, -0.51078141f, 
    -0.31097636f, 0.27622783f, 0.34253111f, 0.21509625f, 0.14305787f, -0.18871413f, -0.00714391f, -0.00345634f, 
    0.02975720f, -0.34249797f, 0.04821878f, 0.03433286f, 0.14837725f, 0.15289055f, 0.33073777f, 0.10344056f, 
    0.00807650f, -0.16682063f, -0.33527455f, -0.16199936f, 0.28956679f, -0.04624148f, 0.14722298f, -0.18896900f, 
    -0.14556205f, -0.05859865f, 0.20638274f, -0.28881356f, 0.09165989f, 0.04784655f, -0.65701669f, 0.29166743f, 
    0.10114168f, -0.45912585f, 0.34589544f, -0.03630985f, -0.07351361f, -0.18425027f, 0.04714612f, 0.29397631f, 
    0.07787427f, -0.51201725f, 0.03860268f, 0.03332006f, -0.40694413f, 0.17679206f, 0.20979123f, -0.02859166f, 
    -0.12730598f, -0.05964969f, 0.26548636f, 0.09042218f, 0.22624642f, -0.23743123f, 0.10264044f, 0.16007476f, 
    0.13529164f, 0.11705433f, -0.35944501f, -0.66134328f, -0.77918762f, -0.16924541f, 0.16154563f, 0.07419529f, 
    0.16471684f, 0.20109017f, 0.12146803f, 0.21179263f, -0.10723446f, 0.16579442f, -0.16645537f, -0.15084222f, 
    -0.02530845f, 0.18624803f, 0.14943819f, -0.16277562f, 0.22627768f, -0.00502736f, 0.12546602f, -0.00539860f, 
    -0.14880390f, -0.09905177f, 0.18548456f, -0.14115378f, -0.58639270f, 0.18443967f, 0.05158815f, -0.12421766f, 
    0.00948064f, 0.05217032f, 0.27353600f, -0.60674340f, 0.36101621f, 0.10938150f, -0.06697170f, -0.36590415f, 
    -0.29757223f, 0.29857814f, -0.31781638f, -0.86307788f, 0.00805503f, 0.19217424f, -0.04816461f, 0.12137914f, 
    -0.05761937f, -0.11965760f, -0.07368564f, 0.07123609f, -0.56551272f, 0.03821427f, -0.37158436f, -0.10915806f, 
    -0.13979694f, -0.01820544f, -0.20359619f, -0.05892093f, -0.60379356f, 0.14267300f, -0.04224990f, 0.19345699f, 
    -0.05250364f, 0.09718178f, -0.03590449f, 0.25435466f, 0.13056040f, -0.13138798f, -0.16222079f, -0.15132599f, 
    -0.16898985f, 0.23361996f, 0.18064354f, -0.32588679f, 0.14192598f, 0.37575114f, 0.07409504f, 0.08653504f, 
    0.08075388f, 0.06650636f, -0.16369875f, -0.13835807f, 0.16470230f, -0.16140611f, 0.19440858f, 0.13851476f, 
    0.05977414f, -0.16755562f, -0.04933189f, 0.14208797f, -0.25963953f, -0.04663359f, -0.07112030f, -0.11077592f, 
    0.10255295f, -0.08577728f, -0.88666672f, 0.28956529f, 0.22083499f, 0.02311784f, -0.04818572f, -0.06259283f, 
    -0.61630881f, -0.06596682f, -0.30829212f, 0.46166879f, -0.09819688f, -0.04922175f, -0.08384567f, 0.24005644f, 
    -0.12358003f, 0.05602142f, -0.12491414f, -0.04693903f, -0.24042536f, 0.05095493f, -0.42287010f, -0.07619052f, 
    0.11354682f, -0.07110845f, 0.04836123f, -0.02059273f, 0.18384570f, 0.14351554f, 0.02313208f, 0.01758831f, 
    -0.13314755f, -0.09322129f, 0.00424837f, -0.07655296f, -0.06522497f, -0.02876885f, -0.43147242f, 0.43141702f, 
    0.53488529f, 0.40569949f, -0.68991590f, 0.14381556f, 0.13599381f, -0.32410517f, 0.09554690f, -0.21204950f, 
    0.13716953f, 0.29354650f, 0.03744347f, -0.02012140f, -0.44392535f, -0.04303552f, -0.30905148f, 0.13106290f, 
    0.09080815f, -0.01852687f, 0.32105663f, -0.00396149f, 0.13341089f, -0.25881624f, 0.13536516f, -0.24488020f, 
    0.08077005f, 0.15536648f, 0.32094729f, -0.03113765f, 0.04111281f, 0.04678327f, 0.31175923f, -0.08143616f, 
    -0.18937622f, -0.38151452f, -0.28565541f, -0.08530837f, -0.02157187f, 0.34337041f, 0.12151272f, -0.32403609f, 
    0.15734734f, -0.21560918f, 0.02090992f, 0.01611583f, 0.33327118f, -0.05283515f, 0.33614019f, -0.16047958f, 
    -0.11171476f, -0.14950089f, -0.41196123f, -0.07904545f, 0.30266562f, 0.06426296f, 0.06755131f, -0.21809556f, 
    0.12208974f, 0.05953593f, -0.58444178f, 0.26693937f, -0.05239740f, 0.00670971f, 0.19980648f, 0.04894504f, 
    -0.10926942f, -0.57276779f, -0.00435475f, -0.32855925f, 0.14722212f, 0.32671550f, 0.06044164f, -0.60911202f, 
    0.01771483f, -0.01874655f, -0.01532028f, 0.09906526f, -0.31279278f, 0.12362758f, -0.69602537f, 0.05458682f, 
    0.09221354f, -0.00856387f, 0.44440290f, 0.01417196f, -0.31538588f, 0.35210630f, 0.15669490f, 0.13314836f, 
    0.15212412f, 0.16139059f, -0.41780454f, 0.14204508f, -0.29592279f, -0.14627664f, 0.25130072f, 0.43263128f, 
    -0.40047640f, -0.65075123f, -0.03168236f, -0.19885518f, -0.16005197f, -0.51834697f, 0.03315108f, 0.10163323f, 
    0.16967078f, 0.36350602f, 0.11501088f, -0.06965160f, 0.28050721f, -0.04377468f, 0.25276247f, 0.06790558f, 
    0.03433957f, 0.01570669f, 0.03820418f, -0.01138037f, 0.05550966f, -0.54477757f, -0.17376055f, -0.37572491f, 
    0.10818002f, 0.06071445f, 0.09689333f, 0.17242816f, -0.69050604f, 0.16331884f, 0.06056070f, 0.15720461f, 
    -0.02550197f, 0.33905599f, -0.02300896f, -0.45796609f, 0.01420412f, -0.03797697f, -0.04723136f, 0.39633104f, 
    0.15721725f, -0.40859908f, 0.06769202f, -0.00835474f, 0.05348414f, 0.02637839f, -0.01523895f, -0.16391084f, 
    -0.00452792f, -0.02138766f, 0.20854244f, 0.00452712f, 0.09258553f, 0.11485006f, 0.08360143f, -0.21713826f, 
    -0.06188522f, 0.14909665f, 0.23140451f, 0.27851340f, 0.11853614f, 0.01074852f, 0.10998299f, -0.70212066f, 
    0.58816624f, 0.04930077f, 0.05566262f, -0.16777459f, -0.13866581f, -0.16345537f, -0.02735036f, -0.24305397f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.02360471f, -0.04026511f, 0.04610378f, -0.04089837f, -0.06276669f, -0.00361218f, 0.03834639f, -0.22741082f, 
    -0.00824469f, 0.04282780f, 0.21122612f, -0.09491950f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
