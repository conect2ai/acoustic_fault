#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.28674397f, -0.13819823f, 0.57798046f, 1.06595540f, -0.24912088f, -0.84709251f, -1.29058158f, -0.55601269f, 
    0.56522250f, -0.85289997f, 0.05688686f, -0.65446913f, -0.18466672f, 0.31632441f, -0.79623872f, -0.05675020f, 
    -0.00231718f, 0.28533304f, -0.21246813f, 0.40895912f, 0.16163445f, -0.17466025f, -0.14296603f, -0.08102087f, 
    0.43985647f, 1.60171521f, -0.59834307f, -1.03041732f, -0.47559839f, -0.83479041f, 0.94866067f, 0.79406339f, 
    0.50308102f, 0.03551806f, -0.15930498f, -0.10988899f, 0.08693201f, -0.21845454f, -0.15318891f, 0.00975354f, 
    0.11266039f, -0.22448041f, 0.00098783f, -0.02910043f, 0.02659395f, 0.21077561f, -0.19931486f, 0.02090905f, 
    -0.07500432f, 0.03908788f, 1.22390914f, 0.43080521f, -0.27954337f, 0.98405367f, -0.46341956f, -0.26645258f, 
    -0.29899889f, 0.12550251f, -0.12907530f, 0.18246631f, -0.26940838f, 0.63231730f, -0.04619994f, 0.14421543f, 
    -0.40197110f, -0.29268560f, -0.18204618f, 0.06937209f, -0.22117837f, 0.29035982f, 0.10775601f, -0.13050410f, 
    0.13105297f, 0.25129166f, -0.23404841f, -1.15869069f, -0.58297092f, -0.64426154f, -0.18998751f, -0.12277028f, 
    0.50528026f, 0.30963665f, 0.42730278f, 0.21829933f, 0.24883746f, 0.54493433f, -0.05558406f, 0.37698632f, 
    -0.25029546f, 0.24273430f, -0.21605153f, -0.32317966f, -0.10967004f, -0.30598664f, -0.03206275f, 0.30149451f, 
    0.45142615f, 0.69299120f, 0.26799163f, 0.07196745f, 1.10753477f, 1.33591700f, 0.55848819f, -0.10784113f, 
    -0.46727595f, 0.04196357f, -0.21589644f, -0.21486177f, -0.21841055f, 0.15039028f, 0.10722224f, 0.26178116f, 
    0.16196638f, -0.54137081f, -0.74399543f, 0.08080351f, 0.05785573f, -0.31137395f, 0.06971311f, -0.43604800f, 
    -0.17906924f, 0.32732111f, -0.23700434f, -0.04617349f, 0.26773190f, -0.01212426f, 0.05495037f, 0.76587462f, 
    0.58753103f, 0.53241444f, -0.12849997f, 0.07092813f, 0.63488656f, 0.08439405f, -0.46544349f, -0.07528619f, 
    -0.13829887f, 0.07927085f, -0.52092832f, 0.15662371f, 0.11816301f, 0.01706107f, -0.24462555f, -0.19749489f, 
    0.01386444f, -0.07490417f, 0.66362137f, -0.25653532f, -0.53463787f, -0.46702030f, -0.33924103f, -0.50226134f, 
    0.62585956f, -0.30950207f, -0.35030591f, -0.26088294f, -0.38961816f, -1.23265576f, -0.88981682f, -0.29678890f, 
    0.38842753f, 0.31547248f, 0.00478530f, -0.28302640f, 0.14697169f, 0.13906848f, -0.05130713f, 0.34148014f, 
    0.32432568f, 0.20115563f, -0.01007512f, 0.01225210f, -0.37562570f, -0.21783800f, -0.48756748f, -1.33191311f, 
    -0.73927873f, -0.94443494f, 0.59181887f, 0.41598746f, -0.43888077f, -1.03772497f, -1.20222867f, -0.80859298f, 
    -0.50206244f, 0.31117037f, -0.71422338f, -0.30789700f, 0.11614866f, -0.38800588f, -0.17867577f, -0.06770744f, 
    -0.39847228f, -0.66010404f, -0.95653027f, -0.00114639f, -0.39221746f, -0.07664691f, 0.15860681f, 0.14358091f, 
    0.12123483f, -1.74651039f, -0.65417731f, 0.37240869f, 0.75430155f, 0.19170168f, 0.31926313f, 0.41500899f, 
    0.16346452f, 0.24426728f, -0.48843527f, -0.47207007f, -0.22184700f, 0.02503104f, 0.86442298f, -0.01276015f, 
    -0.05321507f, -0.39213869f, -0.37902611f, -0.56974310f, -0.25531298f, -0.60496718f, -0.52448881f, -0.59795082f, 
    -0.76654190f, 0.10331932f, 0.29327509f, 0.45146883f, 0.68469816f, 0.55418360f, 0.39624479f, 0.43481970f, 
    -0.47730845f, -0.22122401f, -0.27401584f, 0.06476212f, 0.39423916f, 0.21140800f, 0.24399404f, 0.35352567f, 
    -0.11128386f, 0.01821382f, -0.03136423f, 0.12065922f, 0.39531472f, 0.28699964f, -0.09590332f, 0.02230336f, 
    0.24196506f, -0.00295178f, -0.93387711f, -0.85473627f, -0.06833428f, 1.06292379f, 0.52115279f, 0.13220756f, 
    -0.50754058f, 0.33683300f, 0.87781978f, 0.59015667f, -0.05934796f, 0.48731503f, -0.31794444f, -0.08863368f, 
    -0.33175087f, -0.26459497f, -0.00194112f, 0.37035543f, -0.62133092f, -0.33092368f, -0.14511703f, 0.35202625f, 
    0.19521344f, -0.08970346f, 0.63066530f, 0.28577945f, -0.97417343f, -0.39053950f, 0.42410418f, 1.42845488f, 
    0.27984565f, 0.66525584f, -0.92848307f, -0.79007012f, -0.02750917f, 0.22168878f, 0.38665053f, -0.30658856f, 
    -0.57274860f, -0.10575593f, 0.16039103f, 0.03195480f, 0.10924462f, 0.45740950f, 0.26524413f, -0.08128148f, 
    -0.31098312f, -0.04773140f, 0.00316897f, -0.10805568f, 0.45970476f, -1.54020464f, -1.34972322f, 0.23503377f, 
    0.46819833f, 0.40155390f, 0.85141295f, 1.01881897f, -0.47005248f, -0.78236318f, 0.22170720f, 0.35028112f, 
    0.23071223f, -0.57350767f, -0.02314568f, 0.22381487f, 0.11784384f, -0.17666616f, -0.33709398f, -0.12629138f, 
    0.10426659f, -0.19262354f, -0.17883259f, 0.03176069f, -0.04155936f, -0.33042341f, -0.63290918f, -1.20208812f, 
    -0.92904949f, -0.63530397f, -0.27208212f, -0.86589205f, -0.94198424f, -1.15656972f, -0.94057840f, -0.16906446f, 
    -0.24288037f, 0.54019201f, 0.30156162f, 0.04647877f, 0.24055685f, 0.01733568f, -0.15138362f, 0.11421755f, 
    0.14338145f, 0.07463496f, 0.17116104f, 0.58765823f, 0.05078489f, 0.22280324f, -0.97067064f, -0.38167268f, 
    0.07319984f, 0.48516917f, 0.77866977f, 0.07865870f, -0.60621196f, -0.41624883f, 0.47211212f, 0.67509902f, 
    0.15010926f, 0.09143985f, 0.03049031f, 0.00753190f, -0.12705842f, 0.10186900f, -0.21145950f, -0.31154966f, 
    0.17845850f, -0.00377981f, 0.63208896f, -0.62672698f, -0.13569172f, 0.17537236f, -0.19371855f, -1.95280159f, 
    -0.61974156f, -0.70074433f, -0.72507364f, -0.27118999f, 0.39788985f, 0.31415805f, -0.26885563f, -0.03019901f, 
    0.76870757f, -0.36844790f, -0.66708803f, -0.45886430f, -0.15665081f, -0.16023773f, 0.15925319f, 0.18232815f, 
    -0.12387253f, 0.01699479f, -0.37692046f, -0.06534605f, -0.23557763f, -0.16846451f, -0.32380724f, -0.25738248f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.30877364f, 0.60265958f, 0.74272764f, 0.24404103f, 0.56502092f, 0.22254987f, 0.38257727f, 0.14417386f, 
    0.13577574f, 0.09474353f, 0.42973039f, 0.67413282f, 0.33989346f, -0.03038059f, 0.65954667f, -0.23934044f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.20782864f, 0.28692883f, 0.30461949f, -0.49985215f, 0.14551523f, -0.06553553f, -0.16541964f, -0.09267672f, 
    -0.03539753f, -0.05774568f, -0.08930939f, 0.01393951f, -0.07346465f, -0.87860805f, -1.18694460f, 0.02905680f, 
    -0.01004641f, -0.03458383f, -0.02594224f, 0.06029953f, 0.06374340f, -0.05652625f, -0.26802382f, -0.01772426f, 
    -1.00798213f, -0.78579015f, -0.39328176f, -0.44842955f, -0.00482734f, 0.11725069f, 0.01110780f, 0.07589880f, 
    -0.02984169f, -0.02879862f, -0.00259487f, -0.00955081f, 0.14691898f, -0.00101789f, -0.04058495f, -0.04860423f, 
    0.19875465f, 0.15376534f, 0.08891113f, -0.14431094f, -0.23272777f, -0.29801753f, -0.27442813f, -0.06041504f, 
    -0.61910218f, -0.50807410f, -1.16056311f, 0.55697489f, 0.10131084f, 0.08685731f, -0.02907646f, 0.04088760f, 
    -0.14429761f, 0.00173369f, 0.06534178f, -0.00207602f, -0.78808618f, -0.33683738f, 0.26074848f, 0.03133154f, 
    0.04941185f, -0.01040224f, 0.02703072f, -0.03161266f, -0.03926402f, 0.05081195f, 0.05397367f, -0.08530158f, 
    0.44834769f, 0.37800470f, -0.20652480f, -0.37350899f, -0.10750286f, -0.22930507f, 0.02395582f, 0.02190507f, 
    0.08269555f, -0.01881171f, 0.07833070f, -0.09327332f, 0.49815768f, 0.28850546f, 0.18787809f, -0.38486487f, 
    0.04541608f, 0.02514143f, 0.02520743f, -0.05889921f, -0.09783956f, -0.17239928f, -0.24976254f, -0.21381384f, 
    0.16434446f, -0.14063376f, -0.08549559f, -0.05029219f, 0.03446300f, 0.05267331f, 0.14057259f, -0.04001992f, 
    0.04580129f, 0.00997525f, 0.10234673f, 0.21646783f, 0.05680331f, 0.02451312f, 0.13697770f, 0.07586113f, 
    -0.07630400f, 0.01227553f, 0.02107569f, 0.04240506f, -0.17888829f, -0.03117587f, -0.03340454f, -0.06859326f, 
    0.08711987f, 0.36738366f, 0.44677728f, -0.25176695f, -0.03139647f, 0.07993250f, 0.01892650f, -0.01770861f, 
    -0.08971947f, -0.24648145f, 0.04926744f, -0.29620171f, 0.28590274f, 0.02577752f, -0.23258218f, 0.38852075f, 
    -0.04943876f, -0.33793452f, -0.13626741f, -0.50231326f, -0.22846760f, -0.19705923f, 0.08517838f, 0.06428765f, 
    0.58638185f, -0.57864851f, -0.93645525f, -0.02869440f, 0.09870603f, -0.17256056f, 0.11944839f, -0.07228400f, 
    -0.25813395f, -0.06030969f, -0.09847710f, -0.08127637f, 0.55999058f, 0.24706271f, -0.33041570f, -0.25470144f, 
    0.12742807f, 0.03965723f, -0.09323365f, 0.07545186f, -0.11218473f, 0.00196160f, -0.03987825f, 0.05341027f, 
    -0.15272117f, 0.22762708f, 0.37228948f, -0.32467949f, -0.10689714f, 0.02923374f, -0.04579845f, -0.00134965f, 
    -0.02947840f, -0.19237143f, -0.10081779f, -0.14045925f, 0.52507472f, 0.47363883f, 0.08774040f, -0.18224140f, 
    0.12507382f, 0.28340441f, 0.17329013f, 0.05875934f, -0.04845053f, 0.15770468f, -0.11373095f, 0.05895180f, 
    -0.59187943f, 0.10361532f, -0.44577459f, -0.59861326f, 0.05501585f, -0.18267362f, -0.21220513f, -0.31479722f, 
    0.04991137f, -0.05907128f, 0.03349575f, -0.05397289f, 1.42248595f, 0.01728362f, -0.25674728f, -0.05154813f, 
    -0.13690484f, -0.12122011f, 0.03170768f, -0.06267973f, 0.09649720f, 0.04947957f, -0.08176104f, -0.03063131f, 
    0.23187186f, 0.21593486f, 0.28091550f, -0.25627956f, 0.00300853f, -0.10316510f, -0.12923317f, -0.02285160f, 
    -0.03720502f, -0.08908307f, -0.02687915f, 0.06572915f, -0.24897017f, -0.02134464f, -0.17026041f, -0.18985632f, 
    -0.08267472f, -0.01437152f, 0.18110196f, 0.25364760f, -0.22008885f, 0.07507773f, 0.04641487f, 0.01213340f, 
    0.42778289f, 0.20700724f, 0.57806885f, -0.15382746f, -0.08200926f, 0.00068387f, -0.05767420f, 0.05583977f, 
    -0.06161945f, 0.03320697f, 0.03328727f, 0.18854465f, 0.26491204f, 0.05866722f, 0.05743478f, 0.08919440f, 
    -0.10014271f, -0.05676392f, -0.19324525f, -0.00289975f, 0.00816128f, 0.18532775f, -0.07508971f, 0.01790649f, 
    -0.01040326f, 0.04873633f, 0.05569699f, -0.27217305f, -0.11327073f, 0.04379072f, -0.32360321f, 0.21053590f, 
    -0.13791190f, -0.09392603f, 0.09531297f, 0.09565991f, -0.06773213f, -0.24281783f, 0.11839361f, -0.16080423f, 
    0.27947912f, -0.10116119f, 0.33758581f, -0.07333551f, -0.01360394f, 0.05666260f, 0.07684008f, 0.04218683f, 
    -0.29878345f, -0.09431040f, 0.02567357f, 0.08707478f, 0.06960166f, 0.06984822f, 0.00511979f, -0.15899931f, 
    -0.22646609f, -0.35649320f, -0.05807165f, -0.67896956f, 0.11677071f, 0.13491924f, -0.03312816f, 0.11690266f, 
    -0.06088892f, -0.04754187f, -0.11740674f, -0.09794839f, 0.12811407f, 0.00409735f, 0.09641654f, -0.06615742f, 
    -0.35587084f, 0.17262489f, -0.16773002f, -0.07367826f, -0.10384957f, 0.18975131f, -0.05670838f, 0.03378708f, 
    0.02184676f, -0.02380727f, -0.06559613f, 0.36000144f, 0.05167887f, -0.04228882f, -0.27282724f, -0.13240372f, 
    -0.28854841f, -0.04618258f, 0.02403576f, -0.07318041f, 0.25113288f, -0.09735107f, -0.20283310f, 0.12210223f, 
    0.49327278f, -0.72443080f, -0.27459484f, 0.12523668f, -0.13808033f, -0.00368482f, 0.16493805f, -0.14556040f, 
    0.26128736f, -0.02236027f, 0.06710663f, 0.19328384f, 0.18355307f, 0.08559160f, 0.38796851f, 0.12285478f, 
    -0.05933587f, 0.06784134f, 0.13210106f, -0.18224862f, -0.01566280f, -0.05812605f, 0.05549961f, 0.03440142f, 
    -0.32722813f, 0.18325299f, -0.04294470f, 0.24643342f, 0.00240955f, -0.02744481f, -0.05532496f, 0.06611310f, 
    0.00631788f, -0.06075877f, 0.07434525f, 0.01477161f, 0.32336524f, 0.08098769f, 0.01799226f, 0.15200871f, 
    0.16724744f, -0.05921186f, -0.22872546f, -0.34200239f, 0.13117610f, -0.05791725f, -0.30618235f, -0.42618811f, 
    -1.10352683f, 0.38140380f, 0.23607555f, -0.28154635f, -0.19777787f, 0.06550746f, 0.05666786f, 0.17540994f, 
    -0.01778686f, 0.08308084f, -0.09645221f, -0.01958922f, -0.70377195f, 0.99592441f, 0.61487639f, -0.08628470f, 
    0.02135986f, -0.01340955f, -0.05692544f, -0.12631759f, 0.07801952f, 0.09507956f, -0.04845352f, 0.14855628f, 
    -1.12783432f, 0.33499315f, 0.04578035f, -0.22779085f, -0.06869614f, -0.12814620f, -0.02190379f, 0.08860473f, 
    -0.01110986f, -0.09721100f, 0.09209895f, 0.17102677f, -0.14221172f, -0.04697248f, 0.20271297f, 0.24670553f, 
    0.04114410f, -0.12295196f, 0.22847027f, -0.10422204f, -0.01853258f, -0.08596906f, -0.03420372f, 0.02442406f, 
    -0.44198236f, -0.59545612f, 0.61021453f, -0.69929761f, -0.05740747f, 0.04430056f, -0.12420425f, 0.15776598f, 
    0.04591872f, -0.17706977f, 0.02265926f, 0.04309770f, 0.17110299f, 0.17068702f, -0.65028685f, 0.22692209f, 
    -0.02523375f, -0.07481347f, 0.00803487f, 0.15430067f, -0.01772097f, 0.07256848f, -0.17703071f, 0.08516759f, 
    -0.09602738f, -0.12116816f, 0.04357460f, -0.31890538f, 0.01053720f, 0.06320291f, -0.28854674f, 0.07108819f, 
    0.04209917f, 0.08344179f, 0.10122792f, 0.00908975f, -0.44585115f, -0.44969621f, -0.23775031f, -0.29729328f, 
    0.21797305f, -0.18633570f, -0.01133317f, -0.18848899f, -0.10592888f, -0.03448113f, -0.06213199f, -0.00170341f, 
    0.09358535f, -0.08267096f, 0.41601491f, 0.18997049f, -0.12620892f, 0.05416640f, 0.10258684f, -0.04759293f, 
    0.18210927f, 0.22370896f, 0.05222427f, 0.11525997f, -0.10492969f, 0.09531958f, -0.10165209f, -0.06645343f, 
    -0.05452427f, -0.30425814f, 0.01202668f, 0.23973809f, -0.14499032f, 0.18154556f, -0.04923349f, -0.00489959f, 
    -0.29033405f, -0.24704947f, -0.56225365f, 0.12580876f, -0.05655963f, 0.15316996f, 0.04581108f, 0.00072359f, 
    -0.05315486f, -0.14870968f, -0.21422543f, -0.00846904f, -0.00724474f, -0.08118679f, -0.18839785f, -0.19441900f, 
    0.03430377f, -0.00263522f, -0.12205014f, 0.23863293f, 0.05059292f, -0.09997481f, -0.11716820f, -0.00067121f, 
    0.44215402f, 0.23470077f, 0.89564943f, 0.07111618f, -0.11693320f, 0.01197574f, 0.19379002f, 0.33765441f, 
    0.24162629f, 0.02526428f, -0.20716044f, -0.06846623f, -0.74362582f, -0.45258757f, -0.01481825f, -0.32232839f, 
    -0.02968370f, -0.19212182f, 0.29480812f, -0.23830239f, 0.02572630f, -0.00653106f, -0.02296530f, -0.05985606f, 
    0.01388865f, -0.16873786f, -0.29959828f, 0.44987857f, -0.04177240f, 0.06912094f, 0.05084143f, 0.28560138f, 
    0.02997061f, -0.08053554f, 0.01224548f, 0.02720524f, -0.22469611f, 0.24082848f, 0.97824311f, 0.62505752f, 
    0.07969841f, -0.04594637f, -0.24839129f, -0.24507484f, -0.06280588f, -0.13676387f, -0.04995953f, 0.02780036f, 
    0.12526877f, -0.28966761f, 0.26348126f, 0.09495321f, -0.23601340f, -0.04731563f, 0.17076959f, 0.02242489f, 
    -0.00422410f, 0.10968158f, -0.05795366f, -0.16306067f, -0.57178408f, 0.46938258f, -0.19827025f, 0.43848732f, 
    0.29527062f, 0.12128392f, 0.30226901f, -0.20677631f, -0.16348378f, -0.23764424f, 0.32448110f, -0.01665832f, 
    -0.62140369f, 0.14021349f, 0.03168406f, -0.13872008f, -0.10354754f, -0.49507064f, -0.18596263f, -0.25845987f, 
    0.08897756f, 0.17630392f, -0.22522305f, 0.12854187f, 0.57415330f, -0.16444717f, 0.06800758f, 0.01782206f, 
    0.41284612f, 0.16867653f, -0.02439085f, -0.24150270f, 0.02788917f, 0.10500366f, 0.22363079f, 0.07182095f, 
    -0.69933647f, 0.07305086f, 0.35370466f, -0.01810298f, -0.20351177f, 0.07161105f, -0.51587236f, -0.01482863f, 
    -0.15422848f, 0.37306347f, -0.09873315f, -0.03146923f, -0.10612092f, 0.05108067f, 0.03518574f, -0.16452047f, 
    0.13663547f, 0.20197344f, -0.02439097f, 0.51775473f, 0.14729352f, 0.03247662f, 0.05751084f, 0.12211534f, 
    -0.12950477f, -0.10010373f, -0.03005782f, 0.48928586f, 0.09188858f, 0.12237523f, -0.07413021f, -0.05182075f, 
    0.03566295f, -0.29486632f, 0.08079668f, 0.26591998f, 0.14808899f, 0.08233225f, -0.35830799f, 0.28174999f, 
    -0.03134618f, 0.17275813f, -0.17692880f, 0.04547543f, -0.14739357f, 0.00499491f, -0.01129804f, 0.00817132f, 
    -0.05235465f, 0.50546056f, -0.50083476f, -0.01409276f, 0.15349169f, 0.11799850f, -0.01197660f, -0.10294126f, 
    -0.16800198f, 0.15929636f, -0.08099693f, 0.17827907f, -0.20896262f, -0.40974566f, -0.11755417f, 0.01971549f, 
    0.08622386f, -0.19786848f, -0.06901594f, -0.19129367f, -0.14426729f, -0.28612560f, -0.23864023f, 0.12720047f, 
    0.10332598f, 0.05151905f, -0.05597220f, -0.77281862f, 0.06625837f, -0.22392388f, -0.06600582f, 0.05388020f, 
    -0.10402475f, 0.23135936f, -0.27956891f, -0.15093493f, -0.22783698f, 0.94430834f, -0.41813123f, 0.15127958f, 
    -0.04326896f, -0.36642119f, -0.10068508f, -0.13987343f, 0.00535780f, 0.04528475f, 0.04458377f, 0.08173124f, 
    -0.18457727f, 0.99166143f, -0.40017995f, 0.10905640f, 0.30519339f, 0.05555419f, 0.02763045f, -0.04940650f, 
    -0.29117295f, -0.04617230f, -0.09294239f, -0.12405244f, -0.04351297f, -0.29412183f, -0.22778395f, 0.48945159f, 
    0.19681360f, -0.09132542f, -0.02168903f, 0.04501388f, 0.01006090f, 0.03952122f, -0.11404557f, -0.11388158f, 
    -0.31726271f, 0.06528586f, -0.41189408f, -0.98615026f, 0.14746387f, -0.08492664f, -0.28011957f, -0.21497065f, 
    -0.17150760f, -0.13016275f, -0.30502027f, -0.10445473f, 0.30274299f, -0.15910283f, -0.17635745f, 0.13374193f, 
    0.36826727f, 0.13760152f, 0.11484271f, -0.13340692f, -0.27555713f, 0.10683255f, 0.16020286f, 0.36657590f, 
    0.22490405f, -0.22336003f, 0.28916234f, 0.06886645f, -0.02870009f, 0.12350757f, -0.10915273f, 0.54974639f, 
    0.02161893f, -0.11323509f, 0.00109096f, -0.06867488f, -0.43712729f, 0.03702269f, -0.01767335f, -0.19560276f, 
    0.05857928f, -0.12823357f, -0.28534189f, -0.11680125f, -0.11000764f, -0.20088795f, -0.11106320f, 0.29620937f, 
    -0.38220084f, -0.25064382f, -0.24885201f, 0.29059535f, 0.12886885f, 0.10734710f, -0.02658619f, -0.05914554f, 
    -0.10523614f, -0.00845003f, 0.02398668f, -0.07027446f, 0.38429788f, 0.28555989f, 0.06096355f, -0.00669185f, 
    -0.07621179f, -0.02472555f, -0.09187052f, -0.22995801f, 0.15743010f, -0.10533321f, -0.12889436f, -0.08548913f, 
    0.36551842f, -0.12720241f, -0.92741758f, 0.33202374f, 0.03182255f, 0.13013732f, 0.13944308f, 0.01653098f, 
    0.05013093f, -0.08372491f, 0.00975788f, -0.24130642f, -0.15909132f, -0.42634901f, 0.28489366f, -0.05163868f, 
    0.07326932f, -0.01645026f, 0.03434331f, -0.12483943f, 0.06389835f, -0.12445933f, 0.03639676f, 0.22219960f, 
    0.06070482f, 0.27079830f, 0.18916151f, 0.33155668f, 0.03584379f, -0.09799881f, -0.20997162f, -0.15772313f, 
    0.03025019f, 0.09382184f, 0.04108145f, 0.04011116f, 0.04213737f, 0.10254564f, 0.31929979f, 0.22486386f, 
    0.04700584f, -0.04126781f, -0.24892801f, 0.02106211f, -0.19543532f, 0.04722245f, -0.00093493f, 0.09475135f, 
    0.00054037f, -0.11826508f, -0.10141810f, -0.42027876f, -0.23096521f, -0.01043706f, 0.02850017f, 0.09822809f, 
    0.29576069f, 0.14294016f, 0.11180478f, 0.47717473f, 0.23358236f, 0.02684941f, 0.07671814f, 0.12539467f, 
    0.25571203f, 0.05937697f, 0.04618054f, 0.19874007f, -0.06754366f, 0.00472781f, -0.14805779f, 0.03956837f, 
    0.24131538f, 0.03114052f, 0.00712008f, 0.12625100f, -0.08794799f, 0.05771088f, 0.15949859f, 0.00794595f, 
    -0.33540496f, -0.21390529f, -0.38002783f, -0.39305660f, -0.03334860f, -0.38229901f, 0.31899846f, 0.32812247f, 
    -0.15369990f, -0.02260057f, -0.39744803f, -0.12587683f, -0.35513559f, 0.05297950f, -0.05034342f, 0.01781698f, 
    0.13086762f, -0.97106522f, 0.17543747f, -0.19860886f, -0.20123318f, 0.05754639f, -0.21353562f, -0.27671805f, 
    0.05125745f, -0.02526067f, -0.15077896f, -0.04206965f, 0.04132397f, 0.36511457f, 0.39651150f, 0.05935710f, 
    -0.25868362f, -0.09202264f, 0.00296679f, 0.20823419f, 0.11258867f, 0.03366730f, -0.00972739f, -0.05328694f, 
    -0.01637325f, -0.19064002f, -0.30037853f, 0.00519122f, -0.31786877f, -0.06849837f, -0.06134379f, -0.14704104f, 
    -0.23585418f, 0.19808073f, -0.17654729f, 0.00626206f, -0.32282555f, -0.11538965f, 0.07054273f, 0.18319330f, 
    -0.28283870f, 0.07908244f, 0.07044806f, -0.04550485f, 0.08035544f, 0.05944747f, 0.10663778f, 0.16217127f, 
    0.44038713f, -0.15253657f, -0.16193581f, 0.45999175f, 0.04866546f, 0.07519180f, 0.16627039f, -0.03928703f, 
    -0.00339952f, 0.12424644f, -0.04596382f, 0.03435236f, -0.28911230f, -0.43706667f, -0.63083827f, -0.42994294f, 
    -0.00624817f, 0.03731827f, -0.14472738f, 0.12610371f, 0.12609190f, 0.10234868f, 0.02555271f, -0.30089700f, 
    0.28892344f, -0.56003708f, -0.45674255f, 0.37266243f, -0.04948914f, -0.00096465f, -0.00837046f, -0.00979288f, 
    0.15416853f, -0.02466999f, 0.08420050f, -0.00834883f, -0.29719135f, -0.12358723f, -0.23401965f, -0.13025174f, 
    -0.06846303f, -0.04690848f, -0.10095129f, -0.26280257f, 0.38528475f, 0.17784207f, -0.07178298f, -0.00955347f, 
    0.06220680f, -0.14128082f, -0.68921757f, 0.46370485f, 0.07128097f, -0.10010450f, -0.04792697f, 0.03412725f, 
    0.20272578f, -0.11547642f, 0.02179090f, 0.04923020f, -0.12411512f, -0.11543334f, -0.30257991f, 0.14345098f, 
    0.11178549f, -0.04834150f, 0.07897869f, -0.09735802f, -0.19416350f, -0.17450620f, -0.10064026f, -0.09887479f, 
    -0.05898131f, 0.02280097f, 0.17645510f, -0.13301371f, 0.12559006f, -0.22818854f, 0.08627015f, 0.02053694f, 
    -0.11161798f, 0.08958954f, 0.06785712f, -0.03060489f, 0.00426419f, 0.36381775f, 0.38086826f, -0.15160663f, 
    0.00051485f, 0.17186935f, 0.05778993f, 0.06964419f, 0.25586519f, 0.05383679f, -0.06730525f, 0.17756972f, 
    0.12690847f, -0.30169821f, 0.21600145f, -0.07263281f, 0.09783319f, -0.16317563f, -0.15814239f, 0.13435179f, 
    -0.12517834f, -0.20966543f, -0.36948547f, -0.48856381f, -0.13868046f, -0.14684342f, -0.09351909f, 0.01672300f, 
    -0.10809403f, -0.01233460f, 0.01517839f, -0.02597599f, 0.16171430f, 0.17598155f, -0.03320642f, -0.07387100f, 
    0.08699240f, -0.55960047f, 0.52832127f, 0.32868913f, -0.09510988f, -0.13203624f, 0.00318676f, -0.10532738f, 
    0.21934442f, -0.10693341f, 0.26576427f, 0.00099802f, 0.10997036f, 0.10512307f, 0.32226938f, -0.59477890f, 
    0.13276103f, 0.09547441f, 0.20606357f, 0.31838039f, 0.08731095f, 0.10180364f, -0.21001537f, -0.00384485f, 
    -0.14693804f, 0.18128803f, -0.21315354f, -0.42862272f, 0.27180427f, -0.11893097f, -0.14327155f, -0.09283566f, 
    -0.17538935f, -0.12390891f, 0.08859958f, 0.11702459f, -0.02275703f, 0.30075279f, 0.02670791f, -0.22974558f, 
    0.26356852f, 0.23929009f, 0.05315253f, -0.06553170f, -0.02663780f, 0.05725268f, 0.01782148f, 0.11825309f, 
    -0.15440249f, -0.29468927f, 0.38881350f, -0.11008637f, 0.13653617f, -0.11439826f, 0.06398366f, 0.18250476f, 
    0.27332211f, 0.02529154f, 0.09722071f, 0.10505328f, -0.78717732f, 0.23889786f, 0.00364242f, -0.55008733f, 
    -0.15170965f, -0.08963316f, -0.08304833f, 0.27295476f, -0.02647625f, -0.34525084f, -0.23743464f, -0.23933303f, 
    -0.63354552f, -0.06621572f, -0.86963767f, -0.24999937f, -0.12565410f, 0.23068935f, 0.28380203f, -0.27807865f, 
    0.01777917f, 0.00919266f, 0.03865470f, 0.14269146f, 0.05147811f, 0.61086357f, -0.03696157f, 0.26874134f, 
    0.17525795f, 0.14840816f, 0.10438950f, -0.08259750f, 0.17419919f, -0.14731368f, 0.18203154f, 0.32722250f, 
    -0.02017795f, -0.03476962f, -0.21933916f, -0.04271359f, 0.02345443f, 0.02638033f, 0.14138359f, -0.15518874f, 
    -0.03279888f, 0.04019567f, -0.13365917f, -0.10291308f, -0.46861848f, 0.16639385f, 0.63051337f, 0.22797601f, 
    -0.14292552f, -0.02165510f, -0.36939147f, 0.17710637f, -0.18194604f, 0.06643534f, 0.00573209f, 0.00886583f, 
    0.38403112f, -0.50027233f, -0.36659768f, -0.60206348f, 0.00480824f, 0.10438580f, 0.11056535f, -0.11933133f, 
    -0.09296715f, 0.10184124f, -0.14356567f, -0.23361601f, 0.05449517f, 0.01195846f, -0.10256865f, -0.04370497f, 
    0.10630372f, 0.07053320f, 0.01590757f, 0.00970850f, -0.03507219f, -0.06813277f, 0.09088101f, -0.26498038f, 
    -0.25710636f, -0.52729243f, -0.22419699f, 0.44455040f, -0.06967488f, 0.44005337f, -0.01571802f, -0.13066393f, 
    0.13015151f, 0.04006818f, -0.06090410f, 0.11242557f, -1.26688266f, -1.46206784f, -0.99487907f, -0.16161865f, 
    -0.38766858f, -0.19820659f, -0.24988791f, -0.15344176f, -0.04481504f, -0.03144341f, -0.02419460f, -0.08459513f, 
    -0.24009436f, 0.38340536f, -0.18216644f, 0.01693043f, -0.21145421f, 0.14085671f, 0.09160810f, 0.16333243f, 
    0.12958577f, 0.11025885f, 0.42119434f, 0.30040607f, -0.22216772f, -0.36889321f, -0.04019244f, 0.28086108f, 
    -0.01678316f, 0.05681633f, -0.01591899f, -0.18033881f, -0.06087395f, -0.30095670f, -0.14664644f, -0.05149432f, 
    -0.15221713f, -0.04662670f, -0.15758470f, 0.23264800f, -0.07083229f, -0.23338905f, -0.16491625f, 0.14664690f, 
    0.03842599f, 0.14358361f, 0.06943726f, -0.07229339f, -0.39934042f, -0.37728709f, -0.02885232f, 0.54098207f, 
    0.40766329f, -0.06947447f, 0.19378076f, 0.17158124f, -0.01321437f, 0.01095240f, 0.28516564f, -0.06108795f, 
    -1.08150434f, 0.87990695f, 0.45871544f, -0.15556867f, -0.09282935f, 0.14261614f, 0.00559153f, -0.06845298f, 
    0.06229191f, 0.20741636f, 0.02467356f, -0.24941331f, -1.21068823f, -1.09960008f, -0.58895457f, -0.27720064f, 
    0.01255084f, -0.45735046f, -0.31645015f, -0.21698956f, 0.03145930f, -0.07439431f, -0.05012016f, -0.03428651f, 
    0.50941628f, -0.18014635f, 0.07494750f, 0.23875828f, 0.03519799f, 0.13483940f, 0.11024267f, 0.13931631f, 
    0.33686268f, 0.12134120f, 0.30553085f, -0.16748177f, -0.46626076f, -0.78032416f, 0.27458984f, -0.01916472f, 
    -0.17934062f, -0.19582580f, 0.22584072f, 0.10975722f, -0.01078865f, 0.19667229f, 0.11330330f, -0.02714396f, 
    -0.26294854f, 0.07398038f, 0.07455026f, 0.05234675f, -0.05605204f, -0.14875984f, -0.11021607f, -0.10292700f, 
    0.04263714f, 0.14254744f, 0.02466818f, 0.05255288f, -0.38728216f, 0.03862973f, 0.02108212f, 0.20992944f, 
    0.06876437f, -0.22005507f, 0.28204101f, -0.00443454f, -0.26251638f, -0.17013729f, -0.06373764f, -0.04541798f, 
    0.09011150f, -0.11752257f, -0.05851497f, -0.12068773f, -0.12860218f, -0.05473395f, -0.09996615f, -0.03895681f, 
    0.06804056f, 0.02698988f, 0.02087816f, -0.17015263f, 0.60701400f, -0.15997668f, -0.40742862f, -0.25973541f, 
    -0.04358458f, -0.24666908f, 0.03398853f, -0.04833637f, 0.02633947f, 0.05561023f, 0.17727162f, 0.12202966f, 
    -0.08975014f, 0.04817530f, -0.00332938f, -0.07225249f, 0.09041274f, -0.00240595f, -0.06358235f, -0.04401631f, 
    0.05445190f, -0.00053178f, -0.04154770f, -0.07696092f, 0.23851077f, 0.00273241f, -0.06707538f, 0.11999353f, 
    -0.08894408f, -0.17580877f, 0.09951158f, -0.10142414f, 0.07396662f, 0.08642998f, -0.11534458f, -0.03105878f, 
    -0.65052730f, -0.50156820f, -0.33132634f, -0.37902471f, 0.13185240f, 0.02576461f, 0.17667165f, 0.13396937f, 
    0.09520926f, -0.07245115f, -0.10544692f, -0.10050950f, -0.20115431f, -1.03578269f, 0.96773225f, 0.54523987f, 
    -0.37087950f, 0.04264551f, 0.04651430f, 0.08940798f, -0.09810127f, 0.08266501f, -0.03164498f, -0.05918912f, 
    0.49835241f, -1.07553709f, -0.44959620f, -0.19867907f, 0.08886690f, -0.07933575f, 0.10148445f, -0.17600413f, 
    0.05877733f, 0.17408328f, 0.17331423f, -0.01584004f, -0.01067235f, 0.13476007f, 0.03262182f, -0.20357591f, 
    -0.07800574f, -0.02010919f, -0.01845608f, 0.04348655f, -0.08233093f, 0.08322097f, -0.01416712f, -0.08333642f, 
    0.59120184f, -0.26393598f, -0.08026439f, -0.57693678f, 0.08526875f, 0.13125269f, -0.03610808f, 0.02240695f, 
    0.01084116f, -0.05752441f, -0.02729511f, -0.32630086f, -0.19465159f, 0.03475313f, 0.46260238f, -0.40320802f, 
    0.01382415f, 0.00139439f, 0.18402031f, -0.04367531f, -0.06417982f, 0.01069225f, 0.12634499f, -0.13907525f, 
    -0.17552130f, 0.13318643f, -0.28886577f, 0.16223419f, -0.06151782f, -0.19451067f, 0.35149303f, 0.09191344f, 
    0.20626697f, 0.10589694f, 0.00782211f, 0.04750641f, -0.76781005f, -0.70182043f, -0.31778634f, -0.58388811f, 
    0.16136573f, 0.02332384f, -0.00416776f, 0.32040036f, -0.00030785f, 0.03976350f, 0.03831241f, -0.01954615f, 
    0.58941388f, -0.06148648f, 0.06889851f, -0.60415256f, 0.01452862f, 0.11724927f, -0.11714675f, -0.20125410f, 
    -0.33416006f, 0.06240843f, -0.49146044f, -0.13328148f, 0.80677372f, -1.32169664f, -1.15313995f, -1.23868811f, 
    0.10665760f, 0.08770674f, 0.02005165f, 0.51461726f, 0.18168408f, 0.03059306f, 0.09300234f, 0.20575371f, 
    0.38101822f, 0.61712360f, 0.38512132f, 0.15881342f, 0.35936859f, -0.06981699f, -0.17751190f, -0.19941868f, 
    -0.09594299f, 0.06324988f, 0.07788135f, -0.02001969f, -0.46054119f, -0.40063518f, 0.80914927f, 0.25277206f, 
    -0.21604750f, 0.14509588f, -0.02642263f, -0.14513874f, -0.09437285f, 0.27708429f, 0.08098579f, 0.07356196f, 
    -0.32414046f, 0.35909304f, 0.07790347f, -0.22984104f, 0.07652883f, -0.04768628f, 0.03185690f, -0.10473798f, 
    -0.02758183f, 0.07842412f, 0.01162521f, 0.16070329f, -0.17714396f, -0.47956803f, -0.27993149f, -0.27201205f, 
    -0.20420338f, 0.23225240f, 0.09308428f, 0.21998498f, 0.10095967f, -0.01845014f, 0.08388229f, 0.02115625f, 
    -0.64019871f, 0.32585022f, 0.01699772f, 0.33434975f, 0.07284218f, -0.15052298f, -0.21219051f, 0.04366692f, 
    -0.07810590f, 0.10585232f, 0.08519331f, -0.02145959f, -0.15550120f, 0.13024548f, 0.25054932f, -0.28070083f, 
    -0.08615932f, -0.00163251f, 0.05973586f, -0.17065029f, -0.31321830f, 0.09453908f, -0.22221981f, -0.08524948f, 
    0.11543278f, -0.02353075f, 0.00511351f, 0.20293987f, 0.15639061f, 0.21240410f, 0.11462803f, 0.04412698f, 
    -0.24277344f, 0.00486234f, -0.17070296f, -0.27008304f, 0.09563175f, -0.51085198f, -0.69048202f, -0.81106210f, 
    0.04404047f, -0.34028283f, 0.17690693f, 0.08389835f, 0.22860013f, 0.11646140f, 0.02294323f, 0.05702521f, 
    0.25175348f, -0.35606462f, -0.13867578f, -0.08091068f, 0.00760730f, 0.12502521f, 0.00258457f, 0.10030559f, 
    -0.19024225f, -0.33287570f, 0.00789319f, -0.50942624f, -0.15347254f, -0.07120050f, 0.06354178f, -0.17075524f, 
    -0.23410316f, -0.09720547f, 0.04642850f, -0.16649470f, 0.03991315f, 0.07613598f, 0.11717003f, 0.08900964f, 
    0.10709964f, -0.02628894f, -0.35196096f, -0.15920457f, 0.11653633f, -0.29158089f, 0.09833880f, -0.08253942f, 
    0.19728689f, 0.22884637f, 0.17476206f, 0.38086519f, 0.30698523f, 0.12523431f, -0.13017656f, 0.00204423f, 
    -0.26725167f, 0.07067332f, 0.26067123f, -0.10841119f, 0.10509416f, 0.09377825f, -0.03704744f, -0.07908793f, 
    -0.10361023f, -0.65935308f, -0.68254042f, -0.09891863f, -0.28074440f, 0.28851154f, 0.24008462f, 0.16610681f, 
    0.07197554f, -0.16224948f, -0.21455775f, 0.11564322f, -0.28084624f, -1.12412333f, -0.50779110f, 0.14979628f, 
    -0.22281305f, -0.13066702f, 0.02771589f, -0.04830134f, -0.11155315f, 0.03436022f, 0.13566758f, 0.19069888f, 
    0.62352312f, 0.01672257f, -0.50823843f, -0.30096138f, 0.20103669f, -0.13580933f, 0.26020706f, -0.12166018f, 
    -0.06586693f, 0.00480956f, 0.33866546f, 0.23082437f, -0.04354220f, 0.03730622f, -0.65529752f, 0.12543225f, 
    -0.02614219f, 0.27363604f, 0.28269890f, -0.03754923f, -0.18268219f, -0.03757144f, -0.33868620f, -0.50163853f, 
    -0.28635779f, -0.66293031f, -1.28959429f, 0.27754250f, -0.01624782f, 0.06402160f, 0.19919494f, -0.19882834f, 
    -0.12846366f, -0.07232013f, -0.01866190f, 0.05343099f, 0.27347314f, -0.36994883f, 0.54824036f, -0.97717524f, 
    -0.04576322f, -0.18519497f, -0.08294136f, -0.01725087f, -0.21982531f, 0.15624318f, 0.03463429f, -0.09268658f, 
    0.30194047f, -0.47672635f, -0.34447312f, 0.08828165f, 0.24779680f, 0.24115779f, -0.09956086f, -0.00216976f, 
    0.13970035f, -0.22866172f, -0.18827860f, -0.05277333f, 0.30715328f, 0.24925725f, 0.36932614f, 0.17078181f, 
    0.26205108f, -0.18100730f, -0.54880875f, -0.20488891f, -0.10628282f, -0.35597226f, 0.01255506f, -0.04651385f, 
    -0.34666795f, -0.01823183f, -0.40243819f, 0.24325792f, 0.02300372f, 0.17418119f, 0.12989022f, 0.04339623f, 
    0.02194852f, 0.14283189f, -0.25206050f, 0.00142804f, -0.46666265f, -0.10432390f, -0.02316413f, 0.24604049f, 
    0.19012354f, 0.25466242f, -0.02106350f, 0.14058834f, 0.09703358f, -0.02998357f, 0.10882793f, 0.19092423f, 
    0.15523767f, -0.14458616f, 0.17721561f, -0.25066331f, -0.39598423f, 0.02956977f, 0.24772252f, -0.06969062f, 
    0.10773611f, 0.02849530f, -0.09511609f, -0.04040355f, -0.61983836f, -0.52525908f, 0.28383482f, 0.00688132f, 
    -0.00276197f, 0.13870834f, -0.01931058f, 0.31446576f, -0.11737437f, 0.15043300f, 0.07247432f, -0.20696940f, 
    0.27984825f, -0.03525066f, 0.47883293f, 0.53819960f, 0.01003612f, -0.21616484f, 0.00079913f, -0.08260117f, 
    0.00294783f, -0.01351872f, 0.16636071f, 0.15108842f, 0.39784363f, -0.44983661f, 0.14710790f, -0.36848551f, 
    0.07549625f, 0.29509205f, 0.11320139f, 0.01530158f, -0.02036481f, -0.19131817f, 0.10800716f, -0.09505588f, 
    0.27329594f, 0.08711480f, 0.35046178f, 0.36450163f, 0.07235748f, -0.16944551f, -0.18047512f, 0.07679714f, 
    0.17768779f, 0.16815323f, -0.26499757f, -0.13066329f, 0.15317176f, -1.27003562f, 0.32972714f, -0.88724118f, 
    -0.00563425f, 0.24620141f, -0.15288028f, 0.10429498f, -0.14625420f, 0.09213194f, 0.27270722f, -0.07796131f, 
    -0.24817693f, -0.19290058f, 0.16708434f, 0.13849308f, 0.38732687f, -0.27680519f, -0.29641411f, 0.14495510f, 
    -0.01927635f, 0.22225070f, -0.12799165f, 0.05731297f, -0.44230726f, 0.26386496f, 0.00045674f, -0.58456165f, 
    -0.47104198f, 0.26947293f, -0.10477515f, 0.16888998f, 0.00554635f, -0.05992236f, 0.04775960f, -0.00672729f, 
    -0.66397107f, -0.29453301f, 0.36666781f, 0.49292573f, 0.03211084f, 0.20278727f, -0.14846666f, -0.45972112f, 
    0.03988079f, -0.08643777f, -0.06483375f, -0.05148279f, -0.05527535f, -0.13392213f, 0.04314377f, 0.37546965f, 
    -0.15326376f, 0.01844832f, -0.10931997f, -0.01230658f, 0.24175134f, -0.01301673f, 0.11349742f, -0.02371558f, 
    -0.49640340f, 0.79501927f, -0.47461075f, -0.03389683f, 0.11748336f, 0.27005902f, -0.07456717f, -0.10922378f, 
    0.02732451f, 0.15127005f, -0.04482508f, -0.15520738f, 0.07885949f, 0.20277885f, 0.18887512f, 0.26426670f, 
    -0.02211831f, -0.29385620f, 0.00389264f, -0.04535667f, 0.00462243f, 0.05486533f, -0.19149369f, -0.26850438f, 
    -0.26230237f, 0.20860989f, 0.63647521f, -0.18702364f, -0.11032905f, 0.53686482f, 0.14617427f, 0.14928110f, 
    -0.11840146f, 0.15597171f, 0.35335740f, -0.04209723f, 0.09165773f, 0.11641093f, 0.07793189f, 0.22295426f, 
    -0.26193583f, -0.14024642f, 0.03136199f, 0.12810777f, -0.04040745f, 0.16234308f, 0.15604265f, 0.30086425f, 
    0.07199669f, -0.10668899f, -0.36524442f, -0.27206206f, -0.42747104f, -0.11553972f, 0.14621504f, -0.07170674f, 
    -0.19471416f, 0.05491776f, 0.15517376f, 0.17532113f, 0.02407245f, -0.27986985f, 0.60291034f, -0.51896298f, 
    -0.46076429f, -0.02313124f, 0.40140271f, -0.01974575f, -0.18071578f, -0.09117286f, -0.11760379f, 0.03927162f, 
    -0.07026765f, -0.22557072f, -0.00512586f, -0.10287121f, 0.13354063f, -0.38827381f, 0.39397374f, -0.17541629f, 
    0.00100653f, -0.09339970f, -0.19157542f, -0.03112724f, -0.42662010f, 0.33727252f, -0.96753079f, 0.40240327f, 
    0.13171984f, 0.25019419f, 0.16385043f, 0.12437481f, 0.06353821f, 0.37540045f, -0.09058565f, -0.06575887f, 
    -0.90760189f, 0.88710737f, 0.00833792f, -0.20214371f, 0.02696976f, 0.05057650f, -0.26716626f, 0.12402503f, 
    0.05817013f, -0.45366907f, -0.56527746f, -0.74770159f, -0.58162761f, -0.37315357f, 0.12849742f, -0.76622188f, 
    -0.29626858f, -0.12179264f, -0.35577488f, -0.00125418f, 0.29666197f, 0.20307268f, 0.19852081f, 0.02933968f, 
    -0.60467905f, 0.64105904f, -0.28047588f, 0.06352233f, -0.10005802f, 0.10942398f, 0.00664675f, -0.10461173f, 
    0.09032995f, -0.08518539f, 0.21112309f, 0.31103328f, -0.67484486f, 0.21667083f, 0.39907011f, 0.14385827f, 
    0.35448080f, 0.26144007f, -0.07519764f, 0.03172941f, -0.15334238f, -0.32030681f, 0.02118098f, -0.12563597f, 
    -0.20270604f, 0.41234782f, 0.07621282f, 0.39143121f, -0.14338458f, -0.00970231f, -0.43023562f, 0.15215388f, 
    0.16683477f, -0.20432161f, 0.09590679f, 0.12220653f, -0.36900455f, -0.46130398f, -0.15310019f, 0.50315559f, 
    -0.00664545f, -0.20033818f, -0.12776819f, 0.06023858f, 0.07352576f, 0.06778078f, 0.13922763f, 0.16113794f, 
    -1.03061461f, 0.25539988f, -0.04519077f, -0.59948003f, 0.07026143f, 0.24792810f, -0.31054267f, 0.24642864f, 
    0.00491568f, -0.12825681f, 0.18982226f, 0.04771071f, -0.10843919f, -0.12191300f, -0.24618362f, -0.23161808f, 
    0.00793290f, -0.28013331f, 0.04032736f, 0.24602553f, -0.35767758f, 0.05801148f, -0.06683901f, -0.86109382f, 
    0.63568640f, -0.59804189f, 0.82023007f, 0.03921270f, 0.04737503f, -0.43493575f, -0.18869814f, 0.14432299f, 
    0.01476427f, -0.13739295f, -0.02190885f, 0.02899110f, -0.61344045f, -0.40854287f, -0.23400497f, 0.11260828f, 
    -0.14247774f, 0.26325014f, -0.01367543f, 0.22518714f, -0.20881809f, -0.04845554f, 0.11279646f, 0.11164969f, 
    0.62645370f, 0.14522864f, 0.30598792f, 0.53007579f, -0.16084246f, -0.21698765f, 0.20445690f, 0.45887622f, 
    -0.19401261f, 0.13974537f, -0.12514471f, 0.00867974f, -0.20902455f, -0.07984997f, -0.26497629f, 0.13937764f, 
    0.19131966f, -0.08839313f, 0.05882305f, 0.03673789f, -0.22326365f, -0.05620646f, -0.01081361f, -0.40336579f, 
    0.26528311f, 0.20288663f, 0.68040377f, -0.25687665f, -0.13676657f, 0.00342313f, -0.16241832f, 0.02659162f, 
    -0.29177901f, -0.08313648f, 0.10722727f, -0.23793784f, 0.08166052f, 0.32699856f, 0.02406907f, -0.46241596f, 
    -0.14334099f, 0.17406218f, 0.04192169f, 0.22489543f, 0.04199026f, -0.10559383f, 0.17851573f, -0.04852948f, 
    -0.10943261f, -0.24889649f, -0.43886015f, 0.02622529f, -0.30207452f, -0.25722459f, 0.38768294f, -0.20603491f, 
    0.03188328f, 0.03720538f, -0.11670895f, 0.07411747f, -0.46772859f, -0.79403615f, -0.20347121f, 0.36260244f, 
    -0.28553939f, -0.01014405f, -0.24328299f, -0.29739660f, 0.07282523f, 0.05760348f, 0.11105551f, -0.12836404f, 
    -0.53338814f, 0.05961506f, -0.32269779f, 0.32172588f, 0.29393634f, -0.02269733f, 0.03978291f, 0.07620044f, 
    0.04022588f, 0.07242160f, 0.06138780f, 0.25644535f, 0.14274156f, 0.27718833f, -0.19266291f, -0.20770666f, 
    0.02608768f, 0.04524464f, 0.07234191f, -0.08942643f, -0.06791770f, -0.09024353f, -0.11790586f, -0.00038562f, 
    -0.42716333f, -0.22541119f, -0.16329218f, 0.36794928f, 0.28580752f, -0.06848450f, -0.02467440f, -0.04167952f, 
    -0.11658844f, 0.02495171f, 0.04845452f, -0.26981235f, -0.55089217f, 0.47653881f, -1.04274106f, 0.54681170f, 
    0.02638363f, 0.48785862f, 0.05552543f, -0.02728104f, -0.07367783f, 0.13959976f, 0.04271221f, -0.08296579f, 
    -0.84517616f, 0.12439916f, 0.05200671f, 0.20095830f, 0.05782437f, 0.20099816f, -0.03198994f, 0.39829966f, 
    -0.14418541f, 0.06234794f, 0.20189819f, 0.10371365f, 0.00207390f, -0.18738054f, 0.14051627f, -0.21230793f, 
    -0.16479978f, 0.06643237f, -0.16908608f, -0.12959805f, 0.11138538f, -0.04014403f, -0.15537840f, -0.12956920f, 
    -0.19246839f, -0.15559280f, -0.30333170f, -0.11653718f, 0.17161554f, -0.23693797f, 0.05703711f, -0.07329839f, 
    0.10496907f, -0.14648935f, 0.05842742f, 0.13615112f, -0.20398565f, 0.52176207f, -0.52441365f, -0.02187989f, 
    0.05876926f, -0.11903350f, -0.12508051f, -0.15874018f, -0.02366435f, 0.12094136f, 0.36460891f, 0.12529778f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.28124890f, 0.06551936f, 0.19540206f, -0.19705938f, -0.16132405f, 0.22383747f, 0.08339325f, -0.30637515f, 
    0.15884607f, -0.07164751f, 0.16427910f, -0.11190294f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
