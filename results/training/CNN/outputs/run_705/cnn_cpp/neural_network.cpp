#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.58251715f, -1.04303098f, -0.95688254f, -0.61979842f, 0.13720883f, -0.31640965f, 0.63910311f, -0.09458847f, 
    0.00049750f, -0.21503490f, 0.49180523f, -0.33977035f, 0.33467802f, 0.42905712f, 0.41180587f, -0.19426006f, 
    -0.08366716f, -0.22919717f, -0.30043918f, 0.15289904f, -0.11411247f, 0.03481229f, -0.16965978f, -0.15954365f, 
    -0.41595861f, 0.55393094f, 0.49298939f, 0.47609663f, -0.56535274f, -0.22171332f, 0.32472581f, 0.23435101f, 
    0.69034302f, 0.80768085f, 0.73328125f, -0.41425091f, 0.53178257f, -0.24886885f, -0.63384813f, -0.78683966f, 
    -0.01301951f, 0.36748019f, -0.30809799f, 0.04360305f, -0.69530034f, -0.16039799f, -0.07546621f, -0.09803424f, 
    -0.02084967f, -0.50746018f, 0.92179435f, 1.17504883f, 0.85756874f, 0.93072015f, 0.07532794f, -0.09815509f, 
    0.08369417f, -0.53618509f, 0.29991525f, 0.22834718f, 0.47992620f, 0.35827267f, 0.17020622f, -0.18459699f, 
    -0.10382987f, 0.40151626f, 0.01643622f, 0.59284711f, 0.21582949f, 0.15825389f, -0.23589656f, 0.14711004f, 
    0.07290348f, -0.15210912f, 0.38502938f, -0.67619491f, 0.58337843f, 0.90641594f, -0.49908984f, 0.17821869f, 
    0.31617391f, 0.52224547f, 0.54954720f, 0.10222977f, 0.58041513f, -0.96518970f, 0.25542447f, 0.33237797f, 
    -0.18376936f, -0.05620622f, -0.09708305f, -0.06726114f, 0.04890666f, -0.02059118f, 0.23245046f, -0.19290458f, 
    -0.02805504f, -0.35376513f, 0.03897143f, -0.21513888f, -0.62492681f, -0.48971212f, -0.93204677f, -0.39467287f, 
    -0.59785837f, 0.03951565f, -0.19184637f, -0.05949641f, 0.77422065f, 0.25565436f, -0.49089888f, 0.08122072f, 
    -0.08197234f, -0.00375216f, -0.31795797f, -0.18417011f, -0.06309714f, -0.15718709f, -0.08733635f, -0.24102017f, 
    0.27567661f, -0.06987278f, 0.02910596f, 0.03054384f, 0.24572621f, -1.80449748f, 0.89444959f, 0.93909490f, 
    -0.36605209f, -0.53427708f, 0.06947008f, 1.15968287f, -0.30054253f, 0.13593526f, 0.01352732f, -0.19976068f, 
    0.09871765f, 0.17707565f, -0.28259560f, 0.21191654f, -0.18392816f, -0.32706600f, -0.05342687f, -0.45806816f, 
    -0.34569031f, 0.17516474f, 0.11362138f, 0.19945103f, 0.07088038f, 0.00053622f, 1.35171187f, 0.48657557f, 
    0.55126035f, 1.12391663f, 1.30845273f, 1.00663006f, 0.29754457f, 0.08014502f, -0.29402709f, -0.27259803f, 
    0.20095168f, 0.35559723f, -0.23125108f, -0.00133221f, 0.08620222f, 0.17316921f, 0.06233484f, 0.28208116f, 
    0.09165184f, 0.24222948f, 0.09628442f, 0.19428560f, 0.25296929f, 0.27648890f, 0.29150403f, -0.16491081f, 
    0.90188611f, 0.64381671f, -0.53981084f, 0.77129430f, 1.11681104f, -0.51978385f, -1.15266061f, -0.56616390f, 
    -0.56217706f, 0.09608532f, 0.33925423f, 0.25385809f, 0.51791090f, -0.54510885f, -0.01289193f, 0.06160066f, 
    0.32961833f, -0.26960930f, -0.17418438f, 0.07993990f, -0.08104748f, 0.03810254f, 0.06678627f, -0.13359758f, 
    -1.13489020f, -0.50241733f, 0.75329053f, -0.38567367f, -1.12479568f, 0.13945581f, -0.78784245f, 0.12844595f, 
    0.20249087f, -0.04012852f, 0.09766475f, 0.60274315f, -0.18753764f, 0.46998391f, -0.00960319f, -0.29930788f, 
    0.20399863f, 0.03886881f, -0.20366053f, -0.00051171f, 0.33533609f, 0.11759394f, -0.06231325f, 0.25192729f, 
    0.06009542f, 0.96663910f, 0.65626800f, 0.73276037f, 0.20303774f, 0.68910211f, -0.77990776f, -0.61482418f, 
    -0.23330742f, 0.22359063f, -0.40014488f, 0.12174539f, -0.25520724f, 0.22045019f, -0.15600710f, -0.15095617f, 
    -0.34965909f, 0.24346861f, -0.24451479f, -0.33736405f, -0.11167859f, 0.07818583f, -0.06448049f, 0.36590299f, 
    -0.02293875f, 0.16471900f, 0.99774402f, 0.97102493f, -0.92956531f, -0.18393764f, -0.83284408f, 0.89296883f, 
    0.56004465f, -0.03971227f, 0.45886445f, 0.13916005f, 0.24390619f, -0.31575537f, -0.50633168f, -0.08458387f, 
    -0.08525422f, 0.03065129f, -0.17292623f, -0.15660147f, 0.17292519f, 0.25462988f, -0.22319262f, -0.11966209f, 
    -0.10656258f, -0.29746547f, 0.04906012f, -0.34839046f, -1.05272591f, -0.70920056f, -0.56972677f, 0.00024928f, 
    -0.10001182f, 0.21680278f, 0.63490683f, -0.13644840f, -0.01136712f, -0.50578916f, 0.00427768f, -0.01081522f, 
    -0.10960401f, -0.42242026f, -0.02015017f, 0.49560499f, 0.24563709f, 0.18510151f, 0.23319526f, 0.33162451f, 
    0.38102731f, -0.08117553f, 0.29837883f, 0.41417754f, -0.80342519f, 0.13041037f, -1.11889911f, -0.40122271f, 
    0.21669845f, -0.45594865f, 1.10054159f, 0.67043245f, 0.15609552f, 0.68769020f, 0.19906417f, -0.14690599f, 
    0.16708881f, -0.29250851f, 0.30935797f, -0.04096174f, -0.07949554f, -0.28689644f, -0.23810124f, -0.17515457f, 
    0.21951550f, 0.12727508f, 0.12338548f, 0.11097964f, 0.13013409f, -0.38261378f, -0.30441082f, 0.05474457f, 
    -0.19659697f, 0.52385712f, 1.09041512f, 0.01999635f, -0.59027100f, -0.94739699f, -0.78033978f, -0.12521666f, 
    -0.34020504f, 0.44247127f, -0.27559391f, 0.03519305f, -0.41374394f, 0.37592715f, -0.41687348f, 0.22355774f, 
    -0.41917124f, -0.03199418f, 0.31715691f, -0.01120553f, -0.20304632f, -0.41260815f, -0.39943531f, -0.31602609f, 
    -0.70453668f, -0.81004554f, -0.29050741f, 0.22296792f, 0.46694043f, -0.49078962f, -0.69984353f, 0.46438956f, 
    0.10786261f, 0.20983143f, 0.57857656f, -0.12883310f, -0.42022383f, 0.20109989f, -0.01137500f, 0.36745372f, 
    -0.06616699f, -0.11969200f, -0.25415996f, -0.09924142f, -0.39629424f, -0.17635269f, 0.31203449f, 0.34634262f, 
    -0.28278998f, -0.87304986f, 0.21158817f, -0.08431291f, -0.46706817f, -0.66006410f, -0.07867282f, -0.39311957f, 
    0.09487590f, -0.62503600f, -0.08738717f, -0.11414466f, 0.24543273f, 0.30980095f, 0.34710109f, 0.16220573f, 
    0.03851877f, -0.28205284f, -0.30635655f, -0.00472897f, -0.06487622f, 0.28029564f, 0.30567241f, 0.50315440f, 
    -1.67920816f, 1.17957723f, -0.25213856f, -0.60514593f, -0.02630235f, 0.92398953f, -0.24990045f, -0.23272432f, 
    0.60427338f, -0.40120861f, 0.15751696f, -0.24628244f, -0.69706941f, 0.25870633f, -0.22470552f, -0.08324219f, 
    0.19132817f, -0.37356380f, -0.21497625f, -0.13940459f, 0.07608403f, 0.31485733f, 0.32859552f, 0.29183653f, 
    0.16970612f, -0.05650275f, -1.00769126f, -0.72599185f, 0.52888912f, 0.07372230f, -1.09874475f, -0.19919504f, 
    0.31860682f, 0.13735931f, -0.59269679f, 0.62426788f, 0.52993035f, 0.11543314f, -0.15830545f, 0.07854763f, 
    0.23836181f, 0.34539333f, -0.43872762f, 0.07049803f, 0.08968340f, -0.21178778f, 0.05217290f, 0.38357708f, 
    0.07390318f, 0.49644369f, 0.69892913f, 0.65462577f, -0.83168405f, -0.46128660f, -0.56842935f, -0.53188038f, 
    -0.46552622f, -0.45071542f, -0.17801932f, -0.13072000f, -0.25135231f, 0.18605542f, 0.64746284f, 0.17299953f, 
    0.09279624f, -0.17459603f, -0.06270485f, -0.02947183f, 0.33115762f, 0.45440722f, 0.67493182f, -0.03078318f, 
    0.17401527f, -0.16051555f, 0.27569756f, -0.49489394f, -0.28996283f, -0.59062529f, -0.74004304f, -0.70226550f, 
    0.27997124f, 0.63293904f, -0.29521021f, 0.70433068f, 0.89436162f, 0.16129573f, -0.43959114f, -0.23680356f, 
    -0.44680357f, 0.10918734f, -0.06272046f, 0.05248822f, 0.19964744f, 0.45958504f, 0.02628785f, 0.02585143f, 
    -0.24832772f, 0.25847057f, -0.08558021f, -0.06155149f, -0.17179406f, -0.11767559f, 0.67707783f, 0.27597764f, 
    0.30426371f, -0.60070634f, -0.67236167f, -0.81942552f, -0.81738472f, -0.65337509f, 0.48785257f, 0.64898342f, 
    0.49850702f, 0.15810902f, 0.00015095f, 0.33135313f, 0.12667091f, 0.32620516f, 0.40474415f, -0.04062404f, 
    0.04284946f, -0.13026987f, -0.00780363f, 0.04519224f, -0.35025719f, -0.42643845f, 1.25711441f, -0.05824833f, 
    -1.11022305f, -0.46165806f, -0.52775192f, 0.07631831f, 0.30378324f, -0.41064984f, -0.76712996f, 0.17541723f, 
    0.11495418f, -0.28836411f, 0.00602099f, 0.12114546f, 0.26142988f, -0.09261400f, 0.37537009f, 0.12672801f, 
    0.06154073f, 0.29662040f, -0.23888847f, 0.14138411f, -0.12452221f, 0.05674028f, 0.63124895f, 0.10234921f, 
    0.79384303f, -0.59615493f, 0.20705999f, -0.63103008f, 1.01183164f, 0.59900910f, -0.13304016f, 0.30078146f, 
    -0.32454219f, -0.20537709f, -0.32333580f, -0.17923929f, -0.41459826f, 0.26571867f, -0.29154378f, -0.18029299f, 
    0.26927459f, -0.00748038f, 0.03712312f, 0.19576113f, -0.06785464f, -0.33706677f, 0.30408522f, 0.05621949f, 
    -0.51073408f, -0.01681303f, 0.94731921f, 0.82636517f, -1.33721793f, 0.55772632f, -0.28654265f, -0.71760309f, 
    -0.02023268f, 0.28279269f, -0.15438545f, 0.07751035f, 0.10660531f, 0.26125616f, -0.37872124f, 0.27623028f, 
    0.03271902f, 0.08281107f, -0.12689273f, 0.02762672f, 0.09966750f, -0.11981156f, -0.09518664f, -0.04389836f, 
    -0.76002741f, -1.30987501f, -0.46770948f, 0.20831516f, 0.18154256f, 0.25550520f, 1.11454546f, 0.42895085f, 
    0.25086337f, 0.44912127f, 0.48098698f, 0.12962084f, -0.03687884f, -0.28306979f, -0.04890737f, 0.11188438f, 
    0.09527788f, 0.18357837f, -0.06076589f, -0.00164984f, 0.11278165f, -0.00342083f, 0.03487923f, 0.50685412f, 
    -0.11003317f, 0.56909925f, -0.98058611f, 0.46434802f, 0.54693592f, 0.09535093f, -0.52643251f, -0.22700885f, 
    -0.68686634f, -0.48238221f, -0.04432167f, 0.34265232f, 0.23645096f, -0.37146911f, 0.56067961f, -0.46495339f, 
    -0.39155540f, -0.67629224f, -0.51924706f, -0.11156675f, -0.52607048f, -0.42610461f, 0.02322728f, 0.20065580f, 
    0.02634749f, -0.03334092f, 0.93994820f, -0.02905702f, 0.91783965f, 0.61383134f, -0.72786939f, 0.10368873f, 
    -1.43772960f, 0.41788086f, 0.37707371f, 0.29851681f, 0.21330822f, -0.32837841f, -0.46813256f, -0.02641497f, 
    0.10535230f, -0.22016606f, -0.16795023f, 0.00784461f, -0.34067407f, 0.16855046f, 0.33256787f, 0.14148523f, 
    -0.03331533f, 0.15365282f, -0.00185822f, 1.25407946f, 0.83478695f, 0.90238875f, -0.66163450f, -1.06764102f, 
    0.04202062f, -0.57886654f, -0.09468082f, -0.45816207f, 0.60654837f, 0.25963432f, 0.03100098f, -0.16699383f, 
    0.03822010f, 0.04950553f, -0.12107412f, -0.03015392f, -0.05288184f, -0.08504298f, 0.01368813f, -0.16642171f, 
    0.02631201f, -0.00779361f, -0.10325402f, 0.08157252f, 0.78059864f, -0.96318173f, 0.42428562f, 0.42188039f, 
    0.34909180f, -0.92106783f, 0.71689957f, 0.00008768f, 0.40666214f, 0.54813212f, -0.37935564f, 0.16510034f, 
    -0.30712226f, 0.10162456f, 0.23999661f, -0.33219200f, -0.20614374f, -0.37764567f, 0.43212825f, 0.18972152f, 
    -0.24152309f, -0.33733147f, -0.24359483f, 0.15013017f, 0.15543883f, 0.76894438f, 0.30776533f, -0.14364468f, 
    0.94673926f, 0.49466923f, -0.32126510f, 0.58388197f, 0.22207345f, -0.45558861f, 0.67553169f, 0.32399425f, 
    -0.30885789f, -0.10089035f, 0.14729999f, -0.61667794f, -0.23039654f, 0.23008573f, 0.28743413f, 0.37213701f, 
    -0.46548527f, -0.13286899f, 0.52760905f, -0.19914773f, 0.16016787f, -0.49927250f, 1.06627703f, -0.24198066f, 
    -0.61260885f, -1.32014620f, -0.54129845f, 0.56650579f, 0.27499014f, 0.17176372f, 0.70188773f, 0.25352120f, 
    0.19619985f, 0.03093262f, -0.63555807f, -0.10500404f, -0.15748751f, 0.17421581f, -0.06206733f, -0.26798043f, 
    0.22165710f, 0.14125735f, 0.40499023f, -0.15612130f, -0.38541463f, -0.16103107f, 0.07011014f, 1.25306523f, 
    1.05546188f, -0.06800798f, -0.10917488f, 1.03923774f, -0.08333437f, 0.26229092f, 0.58509493f, 0.25324488f, 
    0.25105339f, -0.74694437f, 0.44071853f, 0.16125891f, -0.35698786f, 0.15921643f, 0.26761967f, -0.18696733f, 
    -0.05809213f, -0.16455200f, 0.35544309f, 0.11527449f, -0.12064318f, -0.14119478f, -0.10951138f, 0.15532640f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.18555181f, 0.18665701f, 0.42377529f, 0.06235670f, 0.10636809f, 0.08698516f, 0.19830357f, 0.05234561f, 
    0.39488682f, 0.18177888f, 0.18880391f, -0.07948486f, 0.17601846f, 0.26187727f, 0.41690415f, 0.00090428f, 
    0.06272921f, 0.21428315f, 0.51042789f, 0.15653485f, 0.39493361f, 0.23916920f, 0.21615759f, 0.07274431f, 
    0.19296631f, 0.28858843f, 0.19684206f, 0.23347364f, 0.23687272f, 0.29172891f, 0.09152143f, 0.24973230f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.46999517f, -0.01178661f, 0.05310737f, -0.13143158f, -0.10941086f, 0.13498642f, -0.02618163f, 0.00287370f, 
    0.03866439f, -0.05095962f, -0.05242281f, 0.06114564f, 0.11115970f, 0.14920177f, 0.03869194f, 0.00351340f, 
    -0.10876255f, -0.01146977f, -0.06999297f, -0.12459613f, -0.01868065f, 0.09711966f, -0.14409463f, 0.02269548f, 
    0.12279072f, 0.06616677f, -0.07758421f, 0.16691875f, -0.17173970f, -0.03232605f, -0.04251194f, 0.05098389f, 
    0.03367807f, 0.00911630f, -0.18211690f, -0.10363337f, -0.06882928f, 0.04651763f, 0.11914294f, 0.20140140f, 
    -0.03683515f, -0.05634679f, 0.05531223f, -0.06147845f, 0.02241779f, -0.24750675f, -0.14682688f, 0.07397377f, 
    0.14668910f, 0.20175320f, -0.44103363f, -0.34491852f, 0.10064232f, -0.05888454f, 0.07320917f, 0.11877953f, 
    0.05433572f, -0.20932995f, -0.05350715f, -0.04937654f, 0.48864624f, -0.04119065f, 0.38395280f, 0.15623568f, 
    0.01564934f, 0.04945602f, 0.02588292f, 0.03843705f, 0.13462858f, 0.12423377f, 0.17219485f, -0.01867320f, 
    0.28144777f, -0.25312921f, -0.06879975f, 0.16724564f, -0.18775886f, -0.01179776f, 0.01760975f, 0.14675651f, 
    -0.11009037f, -0.03339647f, 0.00885460f, -0.04167158f, -0.38911310f, 0.17740810f, 0.21545914f, -0.42875072f, 
    -0.12121304f, -0.09913431f, 0.11255518f, -0.18439972f, 0.04550811f, 0.04055887f, -0.04180478f, 0.01708594f, 
    -0.63374686f, -0.04485226f, -0.12038124f, 0.16309689f, -0.06876307f, -0.01461762f, -0.04817557f, -0.07309488f, 
    0.05426688f, -0.06660625f, 0.04324392f, -0.06131732f, 0.32781252f, 0.13088176f, 0.05582469f, -0.02537361f, 
    -0.20166279f, -0.25090170f, -0.07831879f, -0.01554647f, -0.13762294f, -0.10066532f, -0.06443550f, -0.21441148f, 
    0.21726045f, -0.22614482f, 0.01765751f, -0.29326212f, -0.19891399f, 0.10898224f, 0.06057518f, 0.16488153f, 
    -0.02099252f, 0.02729846f, -0.01732744f, 0.01845094f, -0.11530678f, 0.14153391f, -0.19489944f, -0.31903428f, 
    0.14670491f, 0.08424009f, 0.08299140f, 0.18527390f, 0.00896410f, 0.05946786f, 0.06629665f, 0.06273171f, 
    -0.01052819f, 0.35066402f, 0.08951776f, -0.30694908f, 0.10248303f, -0.15690300f, -0.09274857f, -0.06481139f, 
    -0.09440290f, 0.15748262f, -0.05619494f, 0.05744927f, -0.39679042f, -0.07169779f, 0.14020169f, -0.08418638f, 
    -0.09249291f, 0.01316342f, -0.15001325f, -0.17382742f, -0.21812974f, 0.01143009f, 0.02188509f, -0.09111189f, 
    0.05075225f, -0.24190196f, 0.03670223f, -0.36503714f, 0.00815313f, -0.14263020f, 0.02277468f, 0.14693825f, 
    -0.02896152f, -0.09166269f, -0.11151493f, -0.01967041f, 0.11687547f, -0.26181456f, -0.09009350f, 0.21764433f, 
    -0.02579175f, -0.10484337f, 0.02403658f, -0.05137810f, -0.23598032f, 0.21872851f, -0.04412278f, 0.00359385f, 
    0.40686896f, -0.03184806f, -0.09704649f, -0.01160150f, 0.07909778f, -0.00376260f, -0.03041902f, -0.01131771f, 
    0.10692513f, 0.02870427f, 0.08970365f, -0.06620154f, -0.16416480f, -0.15548567f, -0.10348551f, 0.28778219f, 
    0.01871975f, -0.11603534f, 0.10353129f, 0.02584067f, 0.04538205f, -0.04773855f, 0.07553777f, -0.24925803f, 
    -0.18507552f, -0.03475581f, 0.09517954f, -0.29877260f, -0.02864279f, 0.09848012f, 0.14676407f, 0.01390676f, 
    -0.00001085f, -0.09770111f, 0.00885323f, 0.09506517f, 0.47588882f, 0.09449995f, 0.01107439f, -0.47786209f, 
    0.13323884f, 0.14090659f, 0.08187462f, -0.05909854f, 0.03059286f, -0.01093688f, 0.11596449f, 0.05762357f, 
    -0.21506260f, -0.01627767f, -0.00140395f, 0.13683526f, 0.03589219f, -0.07742635f, 0.09454805f, 0.04992739f, 
    0.09960060f, 0.05627782f, -0.05862939f, -0.08302277f, -0.56500936f, 0.36075735f, 0.05951352f, -0.36454460f, 
    -0.09487648f, -0.10241470f, 0.00990587f, 0.00028444f, -0.08603269f, -0.10794805f, 0.12698498f, -0.08901414f, 
    -0.07781618f, 0.02990727f, 0.09966502f, -0.08140738f, -0.13306251f, -0.09184348f, 0.05125823f, 0.03597677f, 
    0.04441988f, -0.09821067f, -0.05671274f, -0.00640478f, 0.23892359f, -0.04284790f, -0.02317609f, 0.34149185f, 
    -0.23406596f, -0.01896940f, 0.00696202f, -0.16209607f, -0.02660505f, -0.10930525f, -0.10825718f, -0.00920007f, 
    -0.12372998f, 0.32482380f, -0.01735066f, -0.11476194f, 0.14902633f, 0.13833587f, -0.10193772f, 0.12665839f, 
    -0.02440936f, 0.07941516f, 0.03547326f, -0.06917696f, 0.32683921f, -0.12183260f, -0.03412083f, 0.41265753f, 
    -0.19469930f, -0.17413551f, 0.03593549f, 0.13561384f, -0.09160212f, 0.16212901f, -0.05118623f, 0.04733182f, 
    0.25735006f, -0.28481534f, -0.14817664f, 0.53502965f, -0.02798779f, 0.01267229f, -0.16024917f, -0.16078494f, 
    -0.03389496f, -0.10938717f, -0.04085306f, -0.00808365f, -0.22076382f, 0.15925325f, -0.00954358f, -0.35056335f, 
    -0.08906875f, -0.26094821f, -0.05526720f, -0.02689140f, -0.11910521f, -0.00483726f, 0.02006864f, 0.12130529f, 
    0.23254427f, -0.37887603f, -0.01929418f, 0.07679677f, -0.12660353f, -0.12192500f, 0.04899100f, 0.07324376f, 
    0.03635343f, -0.03062247f, 0.09407893f, -0.05395782f, 0.17572719f, 0.27403536f, -0.03388853f, 0.13534825f, 
    -0.07877304f, 0.07307862f, -0.02903105f, -0.04758688f, -0.01413631f, 0.08538009f, 0.01449591f, -0.05484740f, 
    0.08376426f, -0.05528982f, -0.07813019f, -0.49357557f, 0.19558324f, -0.03668765f, 0.01245713f, -0.07696733f, 
    -0.05885177f, 0.00287118f, 0.08156539f, 0.15860049f, 0.27009869f, -0.19321769f, -0.05463749f, -0.23899831f, 
    -0.17186262f, 0.02321330f, 0.02703014f, 0.20901300f, 0.00576331f, -0.00437459f, 0.07521613f, 0.04621770f, 
    0.43813017f, 0.01468810f, -0.12051360f, 0.11524487f, 0.09986009f, -0.03600160f, 0.04838201f, 0.02748344f, 
    -0.05558624f, 0.01901666f, -0.07332634f, -0.18483047f, -0.00456932f, 0.25201070f, 0.25319028f, 0.02927703f, 
    0.12738280f, -0.11347303f, -0.00100883f, 0.01006668f, 0.17050299f, -0.17570823f, -0.03152689f, -0.15501256f, 
    0.26215521f, -0.11978620f, 0.11732697f, 0.27432367f, -0.12227631f, -0.04782594f, 0.11267012f, 0.00454602f, 
    -0.03280265f, -0.09020377f, 0.11638662f, 0.01029316f, -0.02475850f, 0.34415483f, -0.12917814f, 0.01288685f, 
    0.12753576f, 0.02516555f, 0.07708053f, -0.07371696f, 0.01504541f, 0.18691385f, 0.05157310f, -0.15065537f, 
    -0.07026110f, -0.12832588f, 0.06654801f, -0.06450993f, 0.00876948f, -0.01877722f, 0.03033825f, 0.14823733f, 
    0.12618081f, -0.24861926f, 0.00147013f, -0.04100467f, -0.88597220f, 0.08141373f, -0.33345541f, -0.26174182f, 
    -0.13912521f, 0.05632799f, 0.06604867f, -0.08684580f, -0.07506299f, -0.20049916f, 0.06701602f, 0.01376645f, 
    0.16116175f, 0.05904992f, 0.29090682f, 0.17774877f, -0.21209782f, 0.05407452f, -0.03334775f, 0.03490515f, 
    -0.04703116f, 0.02312331f, -0.04387059f, 0.07625949f, 0.14132425f, -0.08290219f, -0.00894688f, -0.17396349f, 
    -0.04206998f, 0.04444339f, -0.05128812f, -0.09323189f, -0.01794986f, -0.01185991f, -0.01495232f, -0.01938180f, 
    -0.41477099f, 0.08946408f, -0.04741009f, 0.15650018f, 0.06064610f, -0.09753761f, 0.06446965f, 0.18671043f, 
    0.07743578f, -0.04058603f, -0.09876037f, 0.00078481f, 0.08329201f, -0.12582147f, 0.04348095f, 0.17672083f, 
    0.11772517f, 0.02351404f, 0.09700616f, 0.06820563f, -0.04359080f, 0.04244979f, -0.08254448f, 0.12825856f, 
    0.27710429f, -0.41951048f, 0.03260894f, -0.13732336f, -0.12636271f, -0.18087177f, -0.12810802f, 0.01909891f, 
    -0.19310832f, -0.03735951f, -0.17923316f, 0.04021206f, 0.13356963f, -0.09476253f, -0.02609531f, -0.21399122f, 
    0.13448918f, 0.01322773f, -0.09237612f, 0.01575243f, 0.31999198f, -0.00129563f, 0.00630236f, 0.07220829f, 
    0.43184957f, -0.20602387f, -0.06940965f, -0.17707606f, 0.17979228f, 0.17360900f, -0.05977623f, 0.02475502f, 
    0.14541280f, -0.07186285f, 0.07638755f, 0.03552480f, 0.11009955f, -0.01999615f, -0.21173759f, -0.19926167f, 
    0.08437006f, -0.14823088f, -0.02129352f, -0.01692014f, -0.02982565f, -0.01020990f, -0.11210689f, -0.03123557f, 
    0.05164503f, 0.04602185f, 0.04061563f, -0.13464938f, -0.12321095f, -0.07570024f, 0.21532078f, -0.08961064f, 
    -0.17156051f, -0.02268382f, 0.17836057f, -0.13701089f, -0.05930137f, -0.01835135f, -0.12353368f, -0.06766173f, 
    -0.18426770f, 0.08451549f, -0.09158672f, 0.09088723f, -0.07836587f, -0.07274491f, 0.04350130f, 0.06378577f, 
    -0.71723723f, -0.15382122f, -0.26673034f, -0.27098429f, -0.06374416f, 0.07579770f, -0.07880665f, -0.12591308f, 
    0.08682869f, 0.18863234f, -0.17471774f, -0.23001660f, -0.06321084f, -0.09022983f, -0.03156205f, 0.06810283f, 
    0.00616902f, 0.10115841f, -0.08546726f, 0.13470092f, -0.21156381f, 0.13586508f, 0.12332500f, 0.05666658f, 
    0.24096182f, -0.34191915f, -0.00713011f, -0.33269280f, 0.01898433f, -0.00017875f, -0.01051710f, 0.11826912f, 
    -0.13635273f, 0.15440600f, 0.06926105f, 0.10370385f, -0.08479735f, -0.08482416f, -0.05437811f, -0.23494387f, 
    0.00228616f, -0.16451019f, -0.02454334f, 0.13771971f, 0.06040935f, 0.08235081f, -0.07650536f, 0.09117296f, 
    -0.33691645f, -0.07997868f, -0.13983634f, -0.01567736f, 0.02769667f, -0.04984829f, 0.03183163f, -0.00738013f, 
    -0.03144296f, 0.11854300f, 0.04720238f, 0.14448032f, -0.05902729f, 0.10130301f, -0.13695970f, -0.42437369f, 
    0.02717422f, 0.16282943f, 0.06194138f, 0.03041983f, 0.16858985f, -0.02878254f, 0.00611557f, 0.14937769f, 
    0.15004790f, 0.28191894f, 0.04250695f, -0.01304409f, 0.10506728f, -0.20855834f, -0.05063327f, 0.08137608f, 
    0.05328765f, 0.07997537f, -0.11783869f, 0.01364772f, -0.07290296f, -0.35368261f, -0.02364175f, 0.10086704f, 
    -0.12976675f, 0.12106652f, -0.14812769f, 0.12988204f, 0.08006908f, 0.12999582f, 0.01015094f, -0.07600614f, 
    0.38339546f, -0.17781302f, -0.17173572f, 0.02825877f, -0.06556600f, 0.00652049f, -0.06116806f, -0.11368198f, 
    0.22426528f, 0.00418696f, 0.03347761f, 0.19531807f, -0.35353777f, -0.08773528f, -0.13064000f, 0.04934887f, 
    0.11381982f, 0.09244780f, 0.05046590f, 0.05369296f, 0.01680349f, -0.19888379f, -0.23653337f, -0.22874095f, 
    -0.23033921f, 0.30777138f, 0.10862132f, 0.17899106f, -0.21681890f, -0.20587601f, 0.12771927f, 0.05229819f, 
    0.10421860f, -0.05282161f, 0.08861873f, 0.12858523f, 0.14277963f, 0.09387798f, -0.22052422f, -0.16763014f, 
    -0.16577527f, -0.04775935f, 0.11995093f, -0.04461057f, -0.10958432f, -0.08670942f, 0.08741616f, -0.01305451f, 
    0.29592726f, -0.02664544f, 0.05607483f, 0.19350642f, -0.06250883f, -0.10744069f, -0.06108427f, -0.11512308f, 
    -0.03137894f, 0.06941179f, -0.22636855f, -0.01684537f, 0.26377085f, -0.06352434f, 0.03287531f, 0.29890779f, 
    -0.19564888f, -0.08458621f, -0.00157927f, 0.11258692f, 0.15864754f, -0.09820430f, -0.07021847f, 0.10428410f, 
    0.29076239f, -0.35106325f, 0.15346918f, -0.33111623f, 0.05599182f, 0.10098995f, -0.18858163f, 0.01608387f, 
    -0.08468166f, 0.05837742f, -0.04488953f, 0.01677223f, 0.33487934f, 0.17752451f, 0.04314467f, 0.18443310f, 
    0.06064491f, -0.01557312f, 0.04874505f, -0.05612048f, -0.01657319f, -0.07409365f, -0.15175553f, 0.10266711f, 
    0.20292203f, -0.11596636f, 0.14873236f, -0.05363493f, -0.34328461f, -0.00478829f, -0.07511477f, 0.05226515f, 
    0.07142986f, -0.06340302f, -0.05377559f, 0.04845424f, 0.09373640f, 0.15682127f, -0.07497953f, -0.03886689f, 
    -0.13572623f, 0.03713547f, 0.18991120f, 0.09046882f, 0.01566587f, 0.00964337f, 0.01546112f, -0.14029393f, 
    0.25313011f, 0.01045275f, 0.01847782f, -0.07571507f, -0.07053936f, 0.04654307f, -0.02072885f, -0.05677735f, 
    -0.07117573f, 0.03219188f, -0.01178577f, -0.04978378f, 0.42332515f, -0.06247496f, -0.22449188f, -0.05450971f, 
    -0.14716934f, -0.08509799f, 0.02274304f, 0.17434025f, -0.15820226f, 0.01958141f, 0.08159478f, 0.00892229f, 
    0.05934640f, -0.08898841f, 0.00571638f, 0.26289031f, -0.12153199f, -0.12959763f, -0.12067758f, -0.01370740f, 
    0.13542821f, 0.17349251f, -0.06095770f, 0.01493787f, 0.65341449f, 0.01011420f, -0.50609171f, -0.29353014f, 
    0.03857511f, -0.02034808f, -0.00062822f, 0.09079656f, -0.01319438f, 0.02487414f, 0.01717837f, -0.15692157f, 
    0.13021757f, -0.00161009f, 0.09124980f, -0.04045879f, 0.05597398f, -0.04545012f, -0.03806435f, -0.05067271f, 
    0.04261621f, 0.00605987f, 0.01427206f, -0.01846116f, -0.04534739f, 0.02070793f, -0.12386818f, -0.09320792f, 
    0.11588667f, -0.03644197f, -0.00445583f, -0.07054774f, -0.17793502f, 0.10492414f, -0.18400259f, -0.05009999f, 
    0.03488724f, 0.03381499f, 0.11930604f, -0.42372742f, -0.20808722f, -0.04679607f, -0.08255941f, 0.06695981f, 
    -0.00062022f, -0.04804894f, 0.02205227f, -0.03990216f, -0.14612138f, 0.28238809f, -0.33924055f, 0.03453737f, 
    0.11769377f, 0.03551506f, 0.10068820f, -0.12782432f, 0.02729642f, 0.08352151f, -0.03986430f, -0.20896335f, 
    0.40118125f, -0.10638592f, -0.07813596f, -0.14669353f, 0.00200420f, -0.18425305f, 0.14175652f, 0.06446743f, 
    -0.05011378f, -0.07740565f, 0.16361165f, -0.03577494f, 0.23126678f, -0.10089041f, -0.01647674f, 0.25193670f, 
    -0.09605797f, -0.19481288f, 0.05195200f, -0.14869626f, -0.06843609f, -0.05685590f, -0.05176464f, 0.10796409f, 
    0.24739185f, -0.01584057f, 0.19140337f, 0.22427219f, -0.16006356f, -0.05954976f, -0.11291153f, -0.02759421f, 
    0.01691657f, 0.06633738f, 0.04870103f, -0.01371432f, -0.40043932f, -0.37430882f, 0.26385900f, -0.30855668f, 
    -0.05760550f, 0.01508008f, -0.04329832f, -0.15219946f, 0.00057905f, -0.02462578f, -0.00039974f, 0.04854138f, 
    0.06861433f, -0.05619314f, 0.22591878f, -0.15276815f, 0.10775986f, -0.24215411f, -0.02923342f, -0.03456751f, 
    0.01426109f, 0.01533725f, -0.00408330f, -0.04400216f, 0.26643080f, -0.20817418f, -0.23834845f, -0.17781159f, 
    0.00361102f, -0.07377560f, -0.09407401f, -0.01410910f, 0.02369446f, 0.12374835f, -0.01969823f, 0.02071130f, 
    0.17286839f, 0.15932353f, -0.05597200f, 0.08212838f, 0.00989056f, 0.12844808f, -0.09557572f, -0.19407165f, 
    -0.05918905f, 0.07436007f, 0.11607047f, 0.12875597f, 0.59814644f, -0.29884845f, -0.10925739f, -0.25867125f, 
    -0.08692004f, -0.01048580f, -0.00512784f, -0.19097933f, -0.07794209f, -0.12551846f, 0.20992391f, -0.25187775f, 
    -0.31239685f, 0.05035752f, -0.01523643f, -0.33682892f, 0.05000984f, -0.02627660f, 0.07668954f, -0.13123189f, 
    0.06390496f, -0.05866545f, -0.04720924f, 0.00153311f, 0.31800029f, -0.13579892f, 0.35010949f, 0.20689191f, 
    -0.04126994f, 0.05509494f, 0.12265507f, 0.08712970f, -0.04069864f, 0.06344844f, -0.02622145f, -0.08201293f, 
    0.22976710f, 0.02436895f, -0.21407932f, -0.02914518f, 0.05912885f, 0.04722149f, 0.03110442f, 0.05055055f, 
    -0.07579864f, -0.17814377f, -0.07213935f, -0.21792305f, -0.28587863f, -0.06728721f, -0.50795859f, -0.29836693f, 
    0.03707119f, -0.09657974f, 0.05380181f, -0.13139257f, -0.18977977f, -0.00832411f, 0.05574188f, -0.03533627f, 
    -0.13629772f, 0.18661992f, -0.14892349f, 0.02398042f, -0.03392279f, -0.13894881f, 0.07146735f, -0.00185519f, 
    -0.12754801f, -0.01233288f, -0.01284042f, 0.09300337f, 0.51998872f, -0.06345288f, -0.05651317f, -0.15233681f, 
    0.20048648f, 0.04699850f, -0.15207003f, -0.08403900f, -0.10257833f, 0.01990584f, -0.04217092f, 0.09128468f, 
    0.35868356f, -0.21986741f, 0.40336916f, 0.00885733f, -0.18784910f, 0.01961593f, -0.04318607f, 0.11570542f, 
    0.08628752f, 0.00402126f, 0.02828223f, -0.02910614f, -0.29418686f, 0.02182973f, -0.31413466f, -0.18106578f, 
    0.03390979f, 0.23474583f, -0.09786886f, 0.15856405f, 0.04300733f, 0.07465111f, 0.06947540f, -0.14165410f, 
    -0.45878592f, 0.17773053f, -0.00807878f, -0.21191864f, -0.09635458f, 0.05748384f, -0.11600246f, -0.02301823f, 
    0.03080294f, 0.07100014f, 0.05273741f, -0.01591457f, -0.41279787f, 0.03403335f, 0.07118642f, -0.36979392f, 
    0.01610509f, 0.14731261f, 0.01598261f, 0.06673380f, -0.20318219f, -0.03107934f, -0.08255620f, -0.09060743f, 
    0.15679266f, 0.07273868f, 0.04958387f, -0.12352130f, -0.09113880f, 0.00791871f, -0.07102087f, 0.13611571f, 
    -0.01201878f, -0.03986790f, 0.08978391f, -0.14195020f, 0.03858703f, 0.07215023f, 0.14210030f, -0.13036129f, 
    0.08598533f, -0.00102221f, -0.02747931f, 0.01070151f, -0.09195737f, 0.00811996f, -0.15070911f, 0.03232042f, 
    -0.25403279f, 0.16713800f, 0.13163050f, 0.22929251f, -0.04094923f, -0.16403161f, 0.04115496f, 0.05352733f, 
    0.01154728f, -0.09581927f, 0.06708647f, -0.01471467f, 0.09731115f, -0.03892252f, -0.01079269f, -0.12804414f, 
    0.11406985f, 0.03876501f, 0.17169979f, -0.07870677f, -0.01637406f, -0.07255710f, 0.10963961f, 0.06396193f, 
    0.07872321f, 0.02676947f, -0.25394848f, 0.12029064f, -0.20737930f, -0.06895889f, 0.00870837f, 0.05051406f, 
    -0.00545506f, -0.09414572f, 0.07549746f, 0.11514468f, -0.53631651f, -0.22506452f, -0.25252509f, -0.20450582f, 
    -0.14030160f, 0.04776480f, -0.09574495f, -0.02520045f, -0.20324248f, 0.26773944f, -0.22866866f, 0.12071571f, 
    -0.44615912f, -0.26155260f, -0.33963051f, 0.13524297f, -0.05662829f, -0.02159609f, -0.01078778f, 0.04617349f, 
    -0.01236689f, -0.14700344f, -0.04549965f, -0.09673503f, -0.22709759f, -0.20475574f, 0.14160268f, -0.13625833f, 
    0.03081946f, -0.09856998f, 0.07861143f, 0.00634429f, 0.04412625f, 0.02393996f, -0.03236639f, 0.10720566f, 
    0.15971033f, 0.14808464f, 0.09977643f, -0.09545323f, -0.23840404f, -0.01459604f, 0.04538228f, -0.10852456f, 
    -0.08642045f, 0.05872048f, 0.12045078f, -0.06643676f, -0.18068305f, 0.45675537f, 0.13836442f, -0.04155699f, 
    -0.01676290f, 0.02529310f, -0.13087745f, 0.16497083f, 0.09809149f, 0.00415154f, -0.02978501f, 0.00634237f, 
    -0.93404353f, -0.46320179f, -0.12236775f, 0.16239828f, -0.17185399f, -0.02846786f, 0.00828130f, 0.03200110f, 
    -0.00640471f, -0.23175226f, 0.05273347f, -0.03001056f, 0.80274802f, -0.15242700f, 0.06193808f, 0.29065701f, 
    0.04209376f, -0.02306747f, -0.03377477f, 0.08208823f, -0.05114632f, -0.00555825f, -0.18575077f, 0.02775987f, 
    0.15608190f, -0.03026257f, 0.22276150f, -0.28974026f, -0.10768673f, -0.05482285f, 0.10577303f, 0.12246354f, 
    0.02639547f, -0.07325836f, 0.07679550f, 0.20108466f, -0.01276535f, -0.19568375f, -0.12078030f, 0.13424614f, 
    0.02912024f, -0.02493183f, 0.00795954f, -0.14739838f, -0.03395393f, 0.03297449f, -0.02823492f, -0.05808033f, 
    0.09481158f, -0.02098793f, -0.05192092f, -0.04927961f, -0.07989948f, 0.07671882f, -0.04652353f, 0.02459953f, 
    0.00295170f, 0.02987643f, 0.04272592f, 0.06493159f, 0.16823228f, -0.11224742f, -0.10397093f, -0.03164081f, 
    -0.22413257f, -0.19853145f, 0.18595290f, 0.02282227f, -0.21491587f, -0.01838668f, -0.22635476f, 0.09870892f, 
    -0.16025960f, 0.10579699f, -0.05727454f, -0.04537870f, -0.04145349f, -0.06523868f, -0.02602711f, -0.16280364f, 
    -0.03781091f, 0.01647842f, -0.05866261f, 0.06679063f, 0.40610895f, -0.08158908f, 0.14654852f, 0.31784728f, 
    -0.12693925f, -0.03425985f, -0.01917897f, 0.17472315f, 0.01558240f, -0.08844411f, -0.08766482f, 0.02551227f, 
    -0.21168087f, 0.13473685f, -0.00554457f, -0.09648269f, -0.06642772f, -0.05708448f, -0.02369997f, 0.07375138f, 
    0.00019134f, 0.01232329f, -0.10473502f, 0.18067883f, 0.40891081f, -0.00162444f, 0.14338635f, 0.13238895f, 
    -0.03278255f, -0.04752497f, -0.07513593f, -0.11894491f, 0.11497226f, -0.02857463f, 0.04050959f, -0.11689182f, 
    0.51042914f, 0.37233350f, -0.00720919f, -0.05116175f, 0.13634434f, 0.04317282f, 0.09787943f, 0.18710086f, 
    -0.07507451f, -0.08443601f, -0.02258250f, -0.18128970f, 0.19465533f, -0.01748781f, 0.35356301f, -0.01369145f, 
    -0.14825875f, -0.19613725f, 0.02535609f, -0.05100096f, -0.03488414f, -0.10386951f, -0.06635213f, -0.03990647f, 
    0.19488609f, -0.07305947f, 0.07552785f, -0.02777718f, -0.02942427f, 0.12193499f, -0.02036573f, 0.03703147f, 
    0.04313929f, 0.00176489f, 0.02849245f, 0.11134689f, -0.21883370f, 0.07441398f, -0.10209589f, -0.25174087f, 
    -0.09113038f, 0.06702179f, 0.02773796f, -0.04358932f, 0.13278341f, -0.17044155f, 0.11074900f, 0.07468652f, 
    -0.17549221f, 0.06978343f, 0.25386661f, 0.19624731f, 0.14914994f, 0.17974514f, 0.01940715f, -0.14598550f, 
    -0.16680577f, 0.09100103f, -0.11136571f, -0.14334844f, -0.19030912f, 0.18009949f, 0.14022154f, -0.22021545f, 
    -0.00338879f, 0.17898558f, 0.01422598f, 0.05016219f, 0.14940079f, -0.01837244f, 0.03729241f, -0.01665892f, 
    -0.53786284f, 0.33490381f, -0.02535999f, 0.01211949f, 0.08408389f, 0.08517976f, -0.09310050f, 0.02424690f, 
    -0.15199833f, 0.00544681f, 0.21150555f, -0.08747011f, -0.59957963f, 0.12327980f, 0.43705514f, 0.12946361f, 
    0.12808633f, 0.16039251f, 0.11716276f, 0.01186558f, -0.17071077f, 0.00433751f, -0.18493161f, -0.14541581f, 
    -0.04238926f, -0.05567801f, -0.05377258f, 0.00262457f, -0.09644271f, -0.22913449f, -0.01206169f, -0.08371532f, 
    -0.05185442f, 0.07862835f, 0.04353840f, -0.05651237f, 0.05806173f, 0.07678504f, 0.13345911f, 0.08454568f, 
    0.10026332f, 0.16121913f, -0.06005561f, 0.11518353f, 0.13675949f, 0.08759938f, 0.13024001f, 0.03539039f, 
    0.16662620f, -0.45502982f, -0.39231765f, 0.12447393f, -0.05919332f, 0.13922687f, 0.13287275f, -0.04030282f, 
    -0.02444364f, 0.10147924f, 0.09981352f, 0.01709221f, -0.09306649f, -0.27384496f, -0.22920471f, 0.24033850f, 
    -0.15945797f, 0.02337262f, -0.05191280f, 0.07508268f, 0.01164218f, -0.03387846f, 0.02107919f, -0.08850047f, 
    -0.34305564f, 0.22712322f, -0.03115315f, -0.03835559f, -0.09483192f, 0.09142878f, 0.02059697f, -0.04956261f, 
    -0.08431982f, -0.08953410f, 0.08970507f, 0.11746191f, -0.48726577f, -0.37982014f, -0.06901417f, 0.14931951f, 
    -0.09097661f, 0.08729272f, 0.08245694f, 0.00115782f, -0.10601930f, 0.08087383f, -0.00873740f, 0.02555838f, 
    -0.07680178f, -0.16669546f, 0.07730471f, -0.08860602f, -0.11793528f, 0.15359606f, 0.08573057f, 0.05508865f, 
    0.00094109f, 0.09490608f, 0.01328600f, 0.00759737f, -0.31880569f, -0.56902504f, -0.37759194f, -0.08519039f, 
    -0.06777287f, -0.16841380f, 0.03672648f, -0.00766845f, 0.08712387f, 0.01381500f, -0.08407292f, -0.01308667f, 
    -0.13697848f, 0.15106136f, -0.04116286f, 0.08781362f, 0.11904439f, -0.07903995f, 0.19155341f, 0.18862960f, 
    0.04506163f, -0.19648923f, 0.03934511f, 0.12265256f, 0.09044945f, -0.26349348f, 0.23288126f, -0.01854940f, 
    -0.03044474f, 0.08090228f, -0.09573880f, 0.18914983f, 0.04248258f, 0.12181959f, 0.25947642f, 0.08867993f, 
    -0.26407549f, -0.02036396f, 0.08862176f, -0.09446119f, -0.11307503f, -0.04517347f, 0.10779681f, 0.11889140f, 
    0.07183436f, 0.02903406f, -0.05091789f, -0.21115524f, -0.07470594f, 0.10490694f, 0.01007552f, -0.01713360f, 
    -0.08773674f, -0.08682783f, 0.13165474f, 0.15425523f, -0.01369309f, 0.06808221f, 0.01703296f, 0.02507165f, 
    -0.01280338f, -0.01791431f, -0.05412517f, 0.24225181f, 0.16767946f, 0.10475755f, 0.01562151f, 0.15607406f, 
    -0.05147151f, 0.00558226f, 0.08886939f, 0.07182452f, -0.13871309f, 0.15443875f, -0.07961010f, -0.19993038f, 
    0.01764711f, -0.04036951f, 0.04713252f, -0.07479405f, -0.03492116f, 0.06725688f, -0.21695964f, -0.05129492f, 
    0.20116377f, 0.07608809f, 0.04084496f, -0.04234460f, 0.07412984f, -0.06953872f, -0.05519934f, 0.10810034f, 
    0.05807994f, -0.05179972f, 0.06538952f, -0.12445275f, -0.26314506f, 0.16542116f, 0.04259050f, -0.17687766f, 
    -0.09453515f, 0.00419636f, -0.07878011f, 0.16751094f, -0.14256689f, -0.01214639f, 0.03309167f, 0.09307127f, 
    0.61287230f, 0.06591297f, -0.05302551f, -0.33455223f, 0.03486050f, 0.13233492f, -0.16041742f, 0.15406314f, 
    -0.03283102f, -0.05684653f, 0.00123045f, -0.02184748f, 0.02530597f, -0.02472235f, 0.21199626f, 0.21448947f, 
    -0.13585782f, -0.13502246f, -0.08326112f, -0.08967759f, 0.06263592f, 0.06253736f, -0.09377988f, 0.05257799f, 
    -0.41297352f, 0.14494754f, -0.01594773f, 0.06025605f, 0.05981694f, -0.01233033f, 0.00048209f, -0.03451174f, 
    -0.03290993f, -0.20558186f, 0.01304490f, 0.01862919f, -0.56741619f, 0.00966657f, -0.07052024f, 0.15252431f, 
    0.05312881f, -0.10382409f, 0.01733773f, 0.06806202f, -0.06147427f, 0.07414378f, 0.12685785f, -0.04511775f, 
    -0.37368724f, -0.01212609f, -0.04900755f, 0.01905716f, -0.00811572f, 0.08909019f, 0.00849900f, 0.02763878f, 
    -0.12877247f, -0.14032097f, -0.08093003f, -0.06179918f, -0.15616503f, 0.24528658f, -0.16939074f, -0.25908282f, 
    0.02849953f, 0.09101095f, 0.03715152f, -0.07597987f, -0.02145111f, 0.06637792f, -0.04709819f, 0.22563328f, 
    -0.08405153f, 0.02153738f, 0.22661820f, 0.35913259f, 0.17461619f, 0.13532917f, 0.09138288f, 0.02604706f, 
    0.06145567f, 0.02731678f, -0.05885323f, 0.05155742f, -0.02283393f, -0.02697700f, -0.10915580f, 0.27227226f, 
    -0.04899145f, -0.09604955f, 0.09669894f, 0.01874361f, -0.00016858f, -0.04308571f, -0.01441166f, 0.05808541f, 
    0.81937379f, 0.24037565f, -0.19569623f, -0.24633633f, 0.03093395f, -0.04338967f, 0.01167776f, 0.00491608f, 
    0.11934274f, -0.16331716f, 0.08578103f, 0.12371786f, -0.19472067f, 0.14464025f, -0.28940782f, 0.17462716f, 
    0.06908801f, 0.02355910f, 0.00452011f, 0.16330522f, 0.03393886f, -0.00459427f, -0.16362855f, -0.06280600f, 
    0.10560410f, -0.23112448f, 0.00617827f, 0.11521692f, -0.18737765f, -0.03992708f, 0.00432667f, -0.11425908f, 
    0.07013036f, -0.03855195f, -0.05421968f, -0.04721893f, -0.27462903f, -0.07126394f, 0.06082816f, 0.30937338f, 
    -0.09771082f, 0.03290140f, 0.01974933f, -0.01020330f, -0.08993664f, 0.12803924f, 0.07446386f, 0.03848369f, 
    -0.15741006f, -0.18015108f, 0.32957542f, 0.13349330f, -0.06467514f, 0.07309658f, -0.13293597f, 0.00252908f, 
    0.18406673f, -0.11079832f, -0.14313270f, -0.04123622f, 0.25308457f, 0.02692715f, 0.03966836f, -0.01389679f, 
    -0.06316047f, -0.12422222f, 0.24566343f, -0.03106207f, -0.06804883f, -0.10388279f, -0.17988741f, 0.09245829f, 
    -0.33693227f, -0.03491853f, 0.18717389f, -0.08629493f, -0.05393738f, -0.02335872f, 0.07269000f, -0.04890084f, 
    -0.00957562f, -0.12560932f, -0.00384886f, -0.24492939f, -0.47826371f, -0.01727375f, 0.17893508f, 0.08946545f, 
    0.02903964f, 0.00547187f, -0.04797639f, -0.20995489f, 0.08373216f, -0.00185015f, 0.05718007f, 0.08660834f, 
    -0.63869470f, 0.20839229f, -0.12663269f, 0.09752424f, 0.01247071f, 0.06379047f, -0.06225611f, -0.04155540f, 
    -0.03497925f, 0.01065684f, 0.21684614f, -0.14193001f, -0.32073754f, 0.08720479f, 0.24787752f, -0.10321189f, 
    0.07934693f, -0.04856673f, -0.03619457f, -0.06904929f, 0.01421979f, 0.07568160f, 0.02704758f, 0.05796894f, 
    -0.20427814f, -0.20354775f, 0.27813172f, -0.11198539f, 0.00541776f, 0.00751005f, -0.15760380f, -0.07555539f, 
    0.06057954f, -0.06424591f, -0.07093776f, -0.01685605f, -0.28839141f, -0.47680041f, 0.08430678f, -0.17007717f, 
    -0.12421843f, 0.11994620f, -0.07029043f, -0.13365360f, 0.11215658f, 0.01032455f, 0.09679070f, 0.08649823f, 
    -0.50192314f, 0.26661348f, -0.12762105f, 0.03792819f, 0.01433244f, -0.12557214f, -0.05091917f, 0.00113960f, 
    -0.09274957f, -0.01557707f, 0.09157085f, -0.07553207f, -0.05351710f, -0.12940854f, -0.01667773f, 0.00458932f, 
    -0.07961833f, 0.10335307f, 0.08369926f, -0.05246077f, -0.01785977f, 0.00501050f, -0.14940020f, 0.00760813f, 
    -0.31542271f, 0.09279247f, 0.17160085f, 0.13348065f, -0.10215849f, 0.04428178f, 0.11418152f, -0.06368859f, 
    0.04179468f, -0.11676814f, 0.06624319f, -0.15197711f, 0.29002514f, -0.24417724f, 0.05440174f, 0.04858682f, 
    -0.31927311f, -0.09005104f, 0.18074995f, 0.05414455f, -0.04227265f, 0.01462978f, -0.07525929f, -0.14570077f, 
    -0.74039203f, -0.44185099f, -0.18873972f, -0.06204617f, 0.21117076f, 0.06683165f, 0.03784742f, -0.14593039f, 
    -0.08787721f, 0.24503480f, -0.04132927f, 0.09827610f, 0.33564302f, -0.10488987f, -0.02454993f, 0.03666305f, 
    0.01961735f, -0.09952393f, -0.13886282f, -0.15196228f, -0.01101556f, -0.23950236f, -0.21661396f, 0.12204919f, 
    -0.02953074f, -0.01745130f, 0.10952273f, -0.01848335f, 0.07920854f, 0.18812947f, 0.05565315f, -0.06652693f, 
    0.09610557f, -0.03320403f, 0.20314831f, 0.17002116f, -0.07908436f, -0.06863061f, 0.07069205f, 0.00527666f, 
    0.08416274f, -0.21189918f, -0.19921368f, -0.20067063f, -0.16613804f, -0.20390993f, 0.22995386f, -0.13469778f, 
    0.15230529f, -0.38544881f, -0.48511079f, -0.03313760f, 0.20834585f, 0.28408918f, -0.05313867f, -0.17075942f, 
    -0.07064831f, 0.10654958f, 0.07200094f, -0.07430490f, -0.61221284f, -0.35276863f, 0.08530511f, 0.27100599f, 
    0.03378918f, -0.18947960f, -0.03665616f, 0.04524150f, -0.00062628f, 0.01990033f, -0.12760861f, -0.09959867f, 
    -0.21745667f, 0.01940713f, 0.23937906f, 0.05793842f, -0.05141326f, 0.19066471f, 0.17850229f, -0.12312456f, 
    0.12870316f, 0.15734629f, -0.02308847f, 0.30622482f, -0.12969229f, -0.27559721f, 0.22561964f, 0.39514345f, 
    -0.12270045f, 0.04342787f, 0.07719089f, -0.03028652f, -0.00478816f, -0.03261027f, 0.10910200f, 0.05880228f, 
    -0.58239043f, -0.30618763f, -0.39258060f, 0.26326200f, 0.09944242f, -0.12821725f, -0.09048206f, -0.07410978f, 
    0.11510862f, 0.07760341f, 0.06183064f, 0.13133809f, 0.04740066f, 0.09742600f, -0.01895430f, 0.14306813f, 
    -0.03980371f, -0.06579357f, 0.14748175f, -0.04016020f, -0.05481372f, -0.26641417f, 0.05590148f, 0.04935558f, 
    0.32455939f, 0.34888804f, -0.19187284f, -0.06490623f, 0.02996762f, 0.00649421f, -0.14490151f, -0.24309421f, 
    -0.23711362f, 0.07717243f, 0.07253312f, -0.10273603f, 0.06675070f, 0.02084040f, -0.23148678f, -0.06259282f, 
    0.16503842f, 0.19514811f, 0.06340311f, 0.11262526f, 0.11511286f, -0.07847989f, -0.00105022f, -0.06390661f, 
    -0.60644305f, -0.04483656f, -0.10503940f, -0.12758280f, -0.12236702f, -0.09054107f, 0.07249455f, -0.02442303f, 
    0.05939260f, 0.00508466f, -0.15694661f, 0.06733704f, -0.04046227f, 0.17392860f, 0.18106560f, 0.16772930f, 
    0.03637472f, 0.17153989f, 0.00398535f, 0.05974920f, 0.02196772f, 0.07422276f, 0.24256745f, -0.20739655f, 
    -0.23929211f, -0.29440367f, -0.24207708f, 0.21485716f, 0.02146155f, 0.15811959f, -0.09863967f, 0.15724722f, 
    0.12177447f, 0.00864737f, 0.15271369f, -0.05296272f, -0.08494000f, 0.09948641f, 0.24137917f, -0.15516968f, 
    0.09413783f, 0.01059492f, 0.09501050f, 0.12425334f, 0.14596292f, -0.04058594f, -0.01307655f, 0.07921048f, 
    -0.17825931f, -0.19872625f, 0.56115746f, 0.37442121f, -0.04993334f, 0.01043372f, 0.24747546f, 0.01353502f, 
    0.03694247f, 0.03486848f, -0.18601398f, 0.06805334f, -0.18166249f, -0.20135014f, 0.00138489f, -0.14480674f, 
    0.08462894f, -0.01934169f, 0.02607739f, -0.09959608f, 0.12462921f, -0.00127509f, -0.22372134f, 0.30687881f, 
    0.12971245f, 0.02910700f, 0.21868776f, 0.19244868f, -0.07374079f, -0.27285677f, 0.03941076f, -0.12861422f, 
    -0.08281617f, -0.04661932f, 0.01874049f, -0.05173393f, -0.04317074f, -0.14690995f, -0.26808602f, 0.05047682f, 
    0.11851524f, 0.04664578f, -0.00793356f, -0.02821761f, -0.02202897f, -0.15822950f, -0.06880777f, -0.01618960f, 
    0.12734456f, 0.06374632f, -0.07637323f, -0.03216903f, -0.00777344f, -0.04618622f, -0.05266408f, -0.06516957f, 
    -0.07457315f, -0.00506369f, 0.23240967f, 0.35227752f, -0.15397076f, -0.14623652f, -0.00402985f, 0.38324323f, 
    -0.09360153f, -0.03068529f, -0.08959199f, 0.11798044f, 0.21714827f, 0.26970384f, 0.06236143f, -0.01626091f, 
    0.12439025f, -0.05259243f, 0.06914330f, -0.01900109f, -0.32941648f, 0.16791049f, 0.02066835f, 0.06745218f, 
    0.12017751f, 0.14840192f, 0.01870235f, 0.02030395f, -0.00480460f, 0.04555620f, -0.04896647f, -0.37927157f, 
    0.12996173f, -0.11782119f, 0.07090537f, 0.05946743f, -0.02170182f, -0.02686257f, 0.18155228f, 0.06651568f, 
    -0.63885367f, 0.14261143f, -0.05161430f, -0.15385582f, 0.22055908f, -0.03156342f, -0.09441702f, -0.00846312f, 
    -0.09521262f, -0.15164492f, -0.13937037f, -0.05862752f, -0.11837386f, -0.14596629f, 0.06798710f, 0.15932898f, 
    -0.15944014f, 0.10138839f, 0.04621495f, -0.10696642f, 0.00927645f, -0.26801649f, 0.02738046f, -0.00564880f, 
    0.27931377f, -0.10526251f, -0.15964489f, 0.04723779f, 0.02501074f, 0.05683843f, -0.11842488f, 0.06876764f, 
    -0.01520456f, 0.07847422f, 0.05137521f, -0.10345752f, -0.08772458f, 0.10259285f, -0.06428879f, 0.01733293f, 
    0.00601272f, -0.06359424f, 0.03034231f, 0.05655513f, 0.01281782f, -0.10490415f, -0.00123547f, -0.12549844f, 
    -0.08835522f, 0.14469244f, 0.03318853f, -0.24224845f, 0.08121737f, 0.18538547f, 0.06536092f, 0.01216822f, 
    -0.07178739f, 0.00137619f, 0.07051145f, -0.28090256f, -0.10015982f, 0.17448606f, 0.16135502f, -0.23107103f, 
    -0.01718293f, -0.21692170f, -0.08260704f, -0.05274396f, 0.06081600f, -0.18714266f, 0.08212568f, -0.00093710f, 
    0.27395180f, -0.46108904f, -0.39469269f, 0.06846656f, 0.00746040f, -0.14588530f, -0.06112668f, -0.09078547f, 
    0.21232396f, 0.05137391f, -0.24314769f, 0.11551668f, 0.12905362f, 0.04486034f, 0.32449368f, -0.23121244f, 
    0.00139462f, 0.13091962f, -0.08590436f, -0.09602272f, -0.22887494f, 0.05384597f, -0.03119756f, 0.02391027f, 
    -0.23365714f, 0.27341253f, -0.10807396f, -0.22865328f, -0.14665678f, -0.00837826f, -0.02122448f, 0.05644187f, 
    0.05006549f, -0.09967750f, 0.05851124f, 0.01231329f, -0.29876333f, 0.21081431f, -0.04089021f, 0.29714027f, 
    -0.02527512f, -0.15445183f, 0.12417485f, 0.01935467f, 0.08711067f, 0.20164248f, 0.18404430f, 0.11531430f, 
    -0.06848073f, 0.36595112f, 0.11661262f, -0.20343493f, -0.15903392f, 0.05803877f, 0.05970407f, -0.09238987f, 
    0.14175229f, 0.10037782f, -0.17810872f, -0.20019034f, -0.02476940f, -0.18850788f, -0.09856655f, 0.26503679f, 
    -0.11548594f, -0.01596452f, -0.06412736f, 0.12803288f, 0.11613733f, 0.03202752f, -0.12551703f, 0.13598210f, 
    -0.41990489f, 0.05883504f, -0.01706295f, -0.33341077f, -0.23573548f, -0.15268067f, -0.10536224f, -0.20306921f, 
    -0.19304220f, 0.17534494f, 0.07685415f, 0.08396498f, 0.52524996f, -0.22487326f, 0.05993669f, 0.05463840f, 
    0.06363850f, -0.00672824f, -0.01990717f, -0.00324452f, -0.24368931f, 0.03563734f, 0.02312007f, 0.01185301f, 
    0.12345559f, 0.06406327f, 0.04949577f, -0.42556870f, -0.16841817f, -0.13750288f, -0.11858063f, 0.11954506f, 
    -0.01679683f, -0.07157966f, -0.07009513f, -0.14652994f, 0.16592860f, -0.05200879f, -0.06844325f, 0.02082462f, 
    0.01939793f, 0.08713219f, 0.07427704f, 0.16676226f, -0.01237769f, 0.04628264f, -0.12552281f, 0.08417410f, 
    -0.25203988f, -0.13963078f, -0.09073009f, -0.13675301f, 0.07931791f, 0.05895696f, 0.07296266f, -0.19583035f, 
    -0.13579179f, 0.13750625f, 0.06532168f, -0.06188989f, -0.08151876f, 0.32435966f, 0.20302369f, -0.39348045f, 
    -0.08027011f, 0.07352832f, -0.01252612f, -0.05466188f, -0.00217110f, 0.15999080f, 0.11590374f, 0.15720156f, 
    -0.28834885f, 0.01106287f, -0.17346191f, 0.52548099f, 0.13947150f, 0.05333572f, 0.03058022f, 0.11620630f, 
    0.16090484f, 0.02294236f, 0.04264573f, 0.06464610f, -0.07594570f, -0.11828931f, -0.00566533f, -0.07754251f, 
    -0.12037691f, -0.11055982f, 0.01989279f, -0.16696952f, -0.12248176f, 0.04107043f, -0.16291812f, -0.07073497f, 
    -0.51822585f, -0.12290853f, 0.01690760f, 0.04608051f, 0.11760345f, -0.10643677f, 0.06299721f, -0.06101233f, 
    0.13527866f, -0.16671976f, 0.15216094f, -0.03050966f, 0.22884406f, -0.30244404f, -0.16964452f, -0.21374552f, 
    -0.05513448f, -0.02752238f, -0.07591873f, 0.04013309f, -0.08321124f, 0.00640916f, 0.09979344f, -0.02775449f, 
    0.09611779f, -0.02911708f, -0.57591832f, 0.03038039f, -0.02469974f, -0.10965051f, -0.00549077f, -0.15318049f, 
    -0.10905616f, 0.05743037f, -0.13699491f, 0.12881382f, 0.01341425f, 0.02178615f, -0.21930583f, -0.17348221f, 
    -0.00979019f, -0.19409120f, -0.12554161f, -0.15117007f, 0.00927931f, -0.05435150f, -0.00195255f, -0.31893492f, 
    0.08423551f, -0.12907697f, 0.16973996f, 0.13312159f, -0.01120836f, -0.08196565f, -0.14052817f, -0.01226483f, 
    -0.19589433f, 0.06374726f, 0.19389865f, -0.01715594f, 0.05178592f, -0.02222610f, -0.06079105f, 0.02673207f, 
    -0.01886911f, -0.01462488f, 0.12933084f, -0.15486728f, 0.11154996f, -0.14135478f, 0.22896099f, -0.27777463f, 
    -0.17276905f, -0.11184630f, -0.12600100f, 0.16346423f, 0.04513510f, 0.03303887f, -0.12040666f, 0.10196614f, 
    0.04364577f, -0.11267613f, 0.10854326f, -0.05191535f, -0.34345272f, 0.02790462f, -0.18696445f, 0.02964403f, 
    -0.08788122f, 0.15093230f, -0.11368154f, -0.07235979f, 0.01810587f, 0.08410463f, 0.07699694f, -0.05054970f, 
    0.08765671f, 0.04044754f, 0.14715512f, -0.11483728f, 0.03428354f, 0.15804517f, 0.01246051f, 0.07480490f, 
    0.04638160f, -0.16216117f, -0.23881760f, -0.13671973f, -0.12320086f, -0.22231814f, -0.24798420f, 0.33582509f, 
    0.17724809f, -0.14739484f, 0.06529361f, -0.21577348f, -0.01070470f, -0.11175726f, -0.03919645f, 0.05371056f, 
    0.17948501f, -0.10327577f, -0.02438739f, 0.22114116f, 0.05881803f, 0.01682889f, 0.05645034f, 0.02240706f, 
    -0.08963756f, -0.30585244f, 0.11265507f, 0.06977116f, 0.31526452f, 0.20686030f, -0.00265847f, -0.09702729f, 
    -0.01644873f, 0.11727475f, 0.20282054f, 0.07652463f, 0.07828695f, 0.09689260f, -0.03229138f, -0.01389215f, 
    0.26626348f, -0.51413172f, -0.09455106f, -0.21691094f, -0.04418739f, 0.07902250f, 0.11300884f, 0.07165805f, 
    -0.04628066f, 0.09136000f, -0.05819149f, 0.06124496f, 0.35103679f, 0.19897784f, -0.11128356f, -0.41607741f, 
    -0.05798513f, -0.24520919f, 0.08738819f, -0.04839893f, 0.08776704f, 0.06737687f, 0.05953720f, 0.10830441f, 
    -0.54942864f, 0.04919013f, 0.09652559f, -0.13269463f, 0.01276161f, -0.00576468f, 0.17737399f, 0.09266115f, 
    -0.11573631f, -0.08467911f, -0.10405172f, 0.00855086f, -0.22547291f, 0.29147932f, -0.04282868f, 0.47000298f, 
    0.12035161f, 0.16803482f, -0.07444541f, 0.14354154f, -0.04027018f, 0.01638002f, -0.21238965f, -0.08777799f, 
    0.47062817f, 0.02235171f, 0.29339692f, 0.05494571f, -0.14480858f, -0.05368911f, 0.01583610f, -0.03538997f, 
    0.07107145f, -0.17074840f, 0.05899800f, 0.20177478f, 0.24903651f, 0.01288044f, 0.03412259f, -0.15907073f, 
    -0.01995098f, 0.15725227f, 0.13721476f, 0.06387859f, -0.11151993f, 0.22301377f, -0.04003876f, 0.11539798f, 
    -0.46644512f, 0.21652307f, -0.55625933f, 0.13340324f, 0.15296523f, -0.07522103f, 0.08969664f, -0.03525949f, 
    -0.08387767f, -0.04393119f, 0.16312061f, -0.19727886f, -0.70768315f, 0.20928057f, 0.12608518f, 0.00793406f, 
    -0.16858400f, 0.02603308f, 0.05458905f, 0.09753194f, -0.02098493f, -0.18387581f, 0.08988460f, -0.04301684f, 
    -0.01646830f, 0.18499799f, 0.16257004f, -0.00898815f, 0.05602916f, 0.18504170f, -0.02434878f, 0.00099532f, 
    -0.01100414f, -0.05531414f, -0.06163937f, 0.00586057f, 0.08555434f, -0.06385420f, -0.05578989f, -0.14513162f, 
    -0.02322121f, -0.10969863f, 0.06168153f, -0.01232619f, 0.12374146f, 0.06216871f, -0.10830767f, 0.01682024f, 
    -0.34971446f, 0.01979912f, -0.15960313f, -0.30663687f, -0.03864353f, -0.04037770f, -0.05303948f, -0.08506468f, 
    -0.08746080f, -0.06952339f, -0.03363743f, -0.05332011f, 0.02523487f, -0.16871101f, -0.02390525f, -0.00665765f, 
    -0.00511605f, -0.00607330f, -0.03252511f, -0.06234022f, 0.01688685f, -0.06622211f, -0.07869074f, -0.05745221f, 
    0.02482425f, 0.27528834f, 0.18331249f, 0.24764015f, 0.20287906f, 0.03762347f, 0.19443421f, -0.00803648f, 
    -0.04949572f, 0.05843094f, -0.02402095f, -0.12494513f, 0.44770190f, 0.04833445f, 0.19645280f, 0.14560860f, 
    0.27106223f, 0.03478014f, 0.00002681f, -0.12442201f, -0.09140120f, -0.00182677f, -0.04069243f, -0.04108724f, 
    -0.43622783f, 0.20961384f, -0.10674258f, -0.00312885f, -0.15863016f, -0.08828759f, 0.02259989f, -0.13908535f, 
    -0.04807944f, 0.03170536f, -0.07939278f, -0.08313316f, -0.20669790f, 0.09181082f, -0.03697996f, 0.19872165f, 
    0.05738322f, -0.07063945f, -0.05389891f, -0.01367507f, -0.02808801f, 0.18503873f, 0.08209667f, -0.16021316f, 
    0.23489718f, 0.09883872f, 0.01565662f, 0.32519040f, 0.21374974f, 0.05564450f, 0.09218467f, -0.09894467f, 
    0.02971540f, -0.00959956f, -0.06861470f, -0.12793335f, -0.16081995f, -0.26368812f, -0.15197629f, -0.04515307f, 
    0.06550867f, 0.01895300f, -0.08605632f, -0.01312977f, -0.15812081f, 0.00225495f, 0.09636760f, -0.06270132f, 
    -0.28415009f, 0.11766452f, 0.02510480f, -0.04003842f, -0.15895738f, 0.06755922f, 0.11631386f, 0.00928597f, 
    0.02708896f, -0.00416337f, -0.03955718f, 0.00975767f, 0.07558221f, 0.14758073f, 0.31152511f, 0.12445015f, 
    0.17636706f, 0.06830535f, 0.10343045f, 0.14375296f, -0.04388248f, 0.13060001f, -0.00372101f, 0.02504980f, 
    -0.07734811f, -0.07395740f, 0.10550065f, 0.04039944f, -0.10842577f, -0.00526120f, -0.02523361f, 0.11753771f, 
    0.00910099f, -0.06416268f, 0.00791581f, -0.00004300f, -0.18145123f, 0.09361950f, 0.01997138f, 0.16551621f, 
    -0.09328225f, -0.10750833f, 0.02926678f, -0.00616400f, -0.09170832f, 0.01689673f, -0.02660904f, -0.15379526f, 
    0.01853037f, 0.22455767f, 0.10782695f, 0.12063839f, 0.06218745f, -0.02040922f, 0.09137996f, 0.02561397f, 
    0.05234511f, -0.03267726f, -0.16063862f, -0.17728616f, -0.07489441f, 0.19336291f, 0.15371031f, -0.08800954f, 
    -0.06174998f, 0.04172852f, 0.01055898f, -0.04292646f, 0.01490050f, 0.03423323f, 0.05379872f, 0.00192575f, 
    -0.29666886f, 0.31385204f, 0.12402923f, 0.16566862f, 0.04438519f, -0.04028867f, -0.01456952f, 0.09762846f, 
    -0.07852283f, 0.03010166f, 0.08085071f, -0.05900656f, 0.27855900f, 0.15712059f, 0.20163253f, -0.03745534f, 
    -0.03917104f, -0.04136179f, -0.01946803f, -0.01386977f, -0.02863633f, 0.02394636f, -0.01721768f, 0.00959432f, 
    -0.13923281f, 0.10664591f, -0.15713964f, 0.00160660f, -0.19149217f, -0.17307389f, -0.14547125f, -0.11502245f, 
    -0.13049445f, 0.00573259f, -0.03837225f, -0.09380149f, -0.15288769f, 0.30105329f, 0.09441816f, 0.11233447f, 
    0.10912889f, -0.03158867f, 0.11008120f, 0.05109703f, 0.07167039f, 0.00477549f, 0.06877071f, -0.02230128f, 
    0.03144061f, -0.23054969f, 0.01967264f, 0.06953464f, -0.13103427f, -0.18270837f, -0.01555038f, -0.01888214f, 
    0.04278330f, 0.02160444f, -0.03067119f, -0.17656955f, 0.32621238f, -0.01368052f, 0.01005225f, 0.28130198f, 
    0.08093655f, -0.11801286f, -0.05178813f, -0.06228767f, -0.15329435f, -0.19676897f, -0.05909241f, -0.09319448f, 
    0.16526744f, -0.47042099f, -0.05127196f, -0.02185093f, -0.09958418f, -0.07159003f, -0.05229320f, -0.04130511f, 
    0.09015977f, -0.09051187f, -0.04441316f, -0.08985757f, 0.36899692f, -0.25407550f, 0.06126654f, -0.10875896f, 
    -0.14115407f, -0.01264452f, -0.03822910f, -0.14846413f, -0.01380167f, -0.06131835f, -0.16260281f, -0.11089301f, 
    -0.13807416f, 0.17726474f, 0.17484513f, 0.02406508f, 0.10560837f, 0.07017757f, 0.05186582f, 0.02755564f, 
    -0.02752315f, 0.12283457f, 0.09884874f, -0.03367007f, 0.14695965f, -0.03479072f, -0.07208702f, 0.10734867f, 
    -0.17359902f, -0.02236887f, -0.17350711f, -0.15073887f, -0.12769324f, 0.08249359f, -0.09272918f, -0.02109080f, 
    -0.05319407f, 0.19958727f, -0.21697386f, -0.40390107f, -0.08508901f, 0.02463226f, -0.08316535f, -0.09723270f, 
    -0.03651961f, -0.00372467f, 0.01923358f, -0.06379182f, -0.29672262f, -0.28946260f, -0.22492349f, -0.15811507f, 
    0.04021890f, -0.08855468f, -0.00097913f, 0.05420239f, -0.10236708f, 0.01290661f, -0.05472758f, -0.07734684f, 
    0.09197422f, 0.10224164f, -0.25641274f, -0.23227710f, -0.10228021f, -0.01891989f, 0.01286444f, 0.06765462f, 
    -0.10637039f, -0.09680388f, -0.22897829f, -0.09114210f, 0.04721523f, 0.04624688f, 0.03117303f, -0.19694108f, 
    -0.09923017f, -0.04876783f, -0.08104187f, -0.08537368f, -0.02769265f, -0.09427887f, -0.04162834f, -0.11077336f, 
    -0.03782646f, 0.24263661f, -0.26969376f, 0.18503816f, -0.02576112f, -0.00448661f, 0.01085128f, -0.07874591f, 
    0.07214358f, 0.00467125f, 0.04316741f, -0.00402439f, -0.16858302f, 0.08000784f, -0.00118412f, 0.06415447f, 
    -0.06853811f, -0.02700539f, -0.07425635f, -0.09190893f, -0.08260469f, 0.02201614f, 0.05973032f, -0.11605374f, 
    -0.34241357f, 0.00407668f, 0.24329714f, -0.25351626f, 0.10943169f, -0.15249567f, -0.03143099f, -0.18251710f, 
    0.00090142f, 0.03532850f, 0.09710322f, -0.13195811f, 0.39397240f, 0.03649216f, -0.13099030f, 0.13765788f, 
    -0.03476240f, 0.03520644f, 0.04936886f, 0.00037291f, -0.07600953f, -0.03313524f, -0.05533912f, 0.08163163f, 
    0.08404267f, -0.17163484f, -0.09010371f, 0.19918714f, 0.21941429f, 0.05493302f, -0.06430464f, -0.04617789f, 
    -0.04136661f, -0.01029371f, 0.17752780f, 0.03671698f, 0.33599600f, 0.06582166f, 0.04133328f, 0.08050238f, 
    -0.05258873f, -0.10146999f, -0.11331591f, -0.21194920f, -0.04942597f, -0.04322216f, -0.06502421f, 0.02269112f, 
    -0.12490053f, -0.12960209f, 0.32125992f, 0.01701195f, 0.00082173f, 0.07731137f, -0.05198858f, 0.13500328f, 
    0.05262005f, -0.22626023f, -0.09630617f, -0.01280626f, 0.08710962f, -0.10529293f, -0.12384573f, -0.03759743f, 
    -0.03432229f, 0.13273951f, 0.03336704f, -0.03932566f, 0.08700871f, -0.00023129f, -0.05774319f, -0.11060377f, 
    0.09268722f, 0.04742378f, 0.05115001f, 0.23830585f, 0.08516467f, 0.13577893f, 0.03518251f, -0.17803159f, 
    0.05893942f, -0.03831579f, -0.02801549f, 0.14840870f, 0.00434190f, -0.18074158f, -0.22143395f, 0.10071816f, 
    0.09198834f, -0.03999166f, -0.00492746f, 0.02478461f, 0.13342862f, 0.00435927f, 0.16695675f, -0.10112751f, 
    0.18667074f, -0.26610392f, 0.22913034f, -0.22826819f, -0.08923772f, -0.02148588f, 0.14305653f, -0.00088530f, 
    -0.03814933f, 0.01762443f, 0.12722456f, 0.11175305f, -0.44475374f, -0.38837227f, 0.07848802f, -0.07073903f, 
    0.16106053f, 0.07550319f, -0.06235425f, -0.02563276f, 0.09296455f, 0.01201889f, 0.02583301f, -0.08567452f, 
    0.20050520f, 0.27814075f, -0.22606717f, 0.05202957f, -0.01362908f, -0.00625530f, -0.32946146f, -0.11414360f, 
    -0.07265922f, 0.08458450f, -0.10415417f, 0.01498868f, -0.47938758f, 0.07522403f, 0.18114564f, -0.17396790f, 
    -0.13995507f, 0.12849545f, -0.04674362f, 0.04223209f, 0.11133681f, -0.14824732f, 0.01548402f, -0.02756446f, 
    0.06373350f, 0.18572991f, 0.03816039f, 0.17917611f, -0.12452199f, 0.07740285f, -0.01606897f, 0.03915514f, 
    0.03358480f, 0.18085703f, -0.06957558f, 0.00271018f, -0.18079066f, -0.20884857f, -0.06551236f, -0.20288563f, 
    -0.06580144f, -0.19604473f, -0.09564055f, 0.13667388f, 0.19062665f, -0.11163557f, -0.13800116f, -0.05643217f, 
    -0.21109539f, 0.16245432f, 0.07709406f, -0.13479908f, -0.00344683f, 0.01425811f, -0.15436041f, -0.20600644f, 
    0.01038684f, -0.14395192f, 0.17432751f, 0.10079132f, -0.21759096f, 0.04748617f, 0.05062308f, -0.44855458f, 
    0.01882995f, 0.02190721f, -0.01097561f, 0.04759762f, 0.13117114f, 0.10107584f, -0.12505022f, -0.03560608f, 
    -0.21205910f, 0.15558553f, -0.20387410f, -0.28001302f, -0.01034738f, 0.01711569f, -0.01886787f, -0.04562714f, 
    0.12322638f, -0.08654258f, -0.07382563f, 0.08600333f, -0.32745656f, -0.01265512f, 0.17926112f, -0.33330405f, 
    -0.08234082f, 0.01989698f, 0.06492096f, 0.10257951f, -0.08654086f, 0.01648552f, -0.02435880f, 0.31190965f, 
    -0.20207635f, 0.12660809f, -0.43080717f, -0.36688304f, -0.03883207f, -0.08676352f, -0.21646446f, -0.02874444f, 
    0.11783955f, 0.12038241f, 0.10413545f, -0.04204667f, -0.01799791f, 0.13907115f, 0.04879234f, 0.14499728f, 
    -0.16633709f, -0.02668939f, 0.02869924f, -0.06149688f, 0.02995165f, 0.03499341f, -0.08067426f, -0.01804380f, 
    -0.09039053f, -0.30552876f, -0.23266836f, -0.30186933f, -0.08119384f, -0.00430371f, 0.03218439f, -0.15283819f, 
    -0.04165878f, 0.13425881f, 0.13112943f, 0.09636923f, 0.15082429f, 0.32585388f, -0.17780921f, -0.24157363f, 
    -0.01592701f, -0.03171156f, -0.29641768f, -0.04551918f, -0.23060130f, -0.08115572f, 0.07355372f, 0.15338334f, 
    0.27486148f, -0.01467926f, -0.17820346f, 0.07278469f, 0.02596806f, 0.10004476f, -0.00957796f, -0.07369526f, 
    0.08184443f, 0.12345176f, 0.07491466f, 0.10679276f, -0.28274566f, 0.17797142f, -0.22631326f, 0.06816331f, 
    0.14012998f, -0.09086677f, -0.00181001f, 0.08456930f, 0.07291371f, 0.00190328f, -0.04276580f, 0.05051024f, 
    -0.15663020f, -0.09808952f, 0.17365229f, 0.19883256f, -0.19839998f, -0.13222438f, 0.02687198f, -0.15558924f, 
    0.04183982f, -0.05794289f, -0.08614115f, 0.04605752f, -0.15642300f, -0.26776841f, -0.14113696f, -0.20598286f, 
    0.06823167f, -0.07158597f, 0.04358958f, -0.08418389f, -0.12354966f, -0.12899433f, 0.13775998f, -0.07228249f, 
    -0.19581762f, -0.07521635f, 0.02688352f, 0.02655879f, 0.05058546f, -0.01513194f, -0.06994674f, 0.07829936f, 
    -0.00453649f, 0.14691964f, -0.19045879f, -0.22212830f, 0.20135050f, 0.22296831f, -0.60796446f, -0.07473015f, 
    0.04346412f, 0.00888999f, -0.11588098f, -0.07438935f, 0.04128284f, -0.02494306f, -0.04329348f, 0.03265492f, 
    0.02491671f, 0.09262345f, -0.07038579f, 0.04550194f, 0.17167835f, 0.01609899f, -0.08202030f, 0.01190143f, 
    -0.03579839f, -0.02125375f, 0.08240026f, 0.10510974f, 0.19809228f, -0.10252414f, -0.13787678f, 0.23473470f, 
    0.15047169f, -0.05792040f, -0.09058646f, 0.05284702f, 0.05966148f, -0.14947110f, 0.00122365f, -0.04132995f, 
    0.10273775f, 0.29725945f, -0.02313311f, 0.17451464f, -0.24988030f, 0.10394760f, -0.15190700f, -0.04321042f, 
    -0.00325606f, -0.11387014f, 0.09508660f, 0.01629137f, 0.19828813f, -0.07649418f, 0.04303437f, 0.09872166f, 
    0.08567743f, -0.05705810f, -0.15459426f, -0.09193929f, -0.02104893f, 0.09553433f, -0.10569119f, 0.06071379f, 
    0.07648998f, -0.44945842f, -0.02226555f, 0.33328983f, -0.07636900f, -0.04950088f, -0.16733222f, 0.02832094f, 
    0.06126342f, 0.00965592f, -0.08652373f, -0.20706649f, 0.16163386f, -0.03765075f, 0.03309654f, -0.00408688f, 
    0.07596396f, 0.03539793f, 0.08526841f, 0.18120395f, -0.06990806f, -0.00790640f, 0.07058589f, -0.05860987f, 
    -0.18156523f, 0.15699039f, 0.18506408f, -0.21949823f, 0.06605059f, -0.08116618f, -0.14742121f, -0.03716405f, 
    -0.15216672f, 0.13194846f, -0.05669276f, -0.07170718f, 0.25159895f, -0.31501621f, 0.29291674f, -0.19752310f, 
    -0.03842776f, 0.24288587f, 0.14722618f, 0.00868478f, 0.04867984f, 0.09205971f, 0.03229896f, 0.15330574f, 
    -0.39823663f, -0.28102925f, 0.12409285f, 0.02852835f, -0.01645917f, -0.20350237f, -0.06306101f, 0.05125786f, 
    0.13264868f, 0.04338602f, -0.09591527f, 0.10357825f, 0.37844211f, -0.41821352f, 0.36680666f, 0.07612914f, 
    0.14232452f, 0.03404954f, -0.06008906f, -0.10476297f, 0.14226097f, -0.01957044f, 0.07022505f, 0.13209888f, 
    -0.28102636f, 0.48917791f, -0.60893965f, -0.26189786f, 0.30359524f, -0.14363201f, 0.03132686f, 0.01746448f, 
    -0.18027040f, -0.18885106f, -0.05033553f, -0.28344715f, -0.24633409f, 0.41133153f, -0.18907879f, -0.51800144f, 
    0.01533578f, -0.06676853f, -0.17871121f, -0.08261849f, -0.04685352f, -0.01392691f, 0.02677300f, -0.01519718f, 
    0.32785675f, 0.03493776f, -0.11112624f, -0.01080548f, 0.11553683f, -0.11047607f, 0.17271549f, -0.06576909f, 
    -0.07163631f, 0.07420932f, 0.09074278f, -0.07955929f, -0.13060980f, -0.20728533f, -0.06782990f, -0.30662224f, 
    -0.04523545f, 0.14904812f, -0.05806172f, 0.01603022f, 0.00450971f, -0.05542185f, 0.05933298f, -0.03854884f, 
    -0.57656699f, 0.23740998f, 0.55965775f, -0.10599056f, -0.01124903f, 0.01157568f, 0.02499094f, 0.07768295f, 
    0.14972815f, 0.02258550f, 0.07229593f, -0.06751849f, 0.23991218f, -0.20346485f, -0.14054061f, 0.13302879f, 
    0.08243148f, -0.06823815f, -0.13451231f, 0.04518704f, -0.26645219f, -0.05336047f, -0.16692679f, -0.08293770f, 
    0.34420088f, -0.56305218f, -0.04629153f, 0.06070175f, 0.02148291f, -0.10697993f, -0.17518894f, 0.09550855f, 
    -0.02331449f, 0.03923429f, 0.12262608f, -0.06823160f, 0.10366478f, 0.26553157f, -0.12627567f, 0.10876321f, 
    0.05635209f, 0.15271358f, -0.04474802f, 0.08306796f, -0.03821427f, -0.02111159f, -0.10611183f, 0.03148055f, 
    -0.22680230f, -0.31582031f, 0.12158584f, -0.09411374f, -0.00637218f, 0.07507616f, -0.06894424f, 0.06042988f, 
    0.05015583f, 0.18206938f, -0.05585510f, 0.01080825f, -0.46109676f, 0.02682108f, 0.21995541f, -0.02089188f, 
    -0.05966645f, 0.02719346f, 0.06520528f, -0.14457890f, -0.10053318f, -0.22690462f, 0.05950834f, 0.19363834f, 
    -0.50664377f, -0.50796968f, -0.15742713f, 0.02399424f, -0.14777277f, -0.02306135f, -0.07772677f, 0.09262843f, 
    -0.19203064f, -0.15252005f, 0.20193972f, -0.02202351f, -0.20554855f, 0.06126218f, -0.14863098f, 0.27391973f, 
    -0.03775396f, 0.10090184f, 0.05131497f, -0.02384196f, -0.04415165f, -0.07136039f, 0.01952077f, -0.08651078f, 
    -0.34641701f, 0.01803243f, 0.20950155f, 0.02612561f, 0.06093993f, 0.01152009f, 0.05148579f, -0.05579062f, 
    0.02247630f, -0.10210969f, -0.14083691f, 0.06559261f, -0.30077302f, -0.32659847f, -0.00510257f, -0.22022612f, 
    0.10315235f, -0.02991413f, 0.10805751f, 0.08110971f, -0.03448359f, -0.16221079f, 0.02558545f, 0.03723141f, 
    0.05406530f, 0.13785869f, -0.23387668f, -0.27845386f, 0.08059163f, 0.05396570f, -0.08033916f, 0.06982881f, 
    0.00192649f, 0.08400007f, -0.03838591f, -0.13249862f, 0.19795009f, -0.53409958f, 0.24308962f, -0.14735943f, 
    -0.02906129f, 0.11704106f, -0.10610456f, 0.22437234f, -0.05853934f, -0.07515033f, 0.12381367f, -0.16525576f, 
    0.07360391f, -0.24020679f, -0.01262432f, 0.10287402f, 0.11020388f, 0.10328854f, -0.03741872f, -0.02869047f, 
    -0.07743804f, 0.08796893f, 0.01874628f, 0.08544618f, -0.10269750f, -0.06052741f, -0.17195530f, -0.24119143f, 
    -0.01098353f, -0.14045112f, 0.02336634f, 0.02912487f, 0.05859576f, -0.00977413f, 0.07048640f, -0.08201094f, 
    0.15798485f, -0.27518597f, -0.06244543f, 0.11680797f, 0.04718750f, -0.00726434f, -0.00726001f, -0.07893904f, 
    0.05506656f, 0.04920095f, 0.00726012f, -0.09964669f, 0.09781682f, 0.11722877f, -0.11490121f, -0.26179841f, 
    -0.23267637f, 0.05711371f, -0.04706272f, 0.04819008f, 0.00281055f, 0.11683989f, 0.01727556f, 0.16262494f, 
    0.55007672f, 0.14268745f, 0.18294349f, -0.29408646f, -0.07091391f, -0.04204877f, 0.13874243f, -0.22530235f, 
    0.00776618f, 0.01667012f, -0.04177700f, -0.15111706f, 0.42162704f, -0.05885286f, 0.36341661f, 0.06229554f, 
    0.02784161f, 0.03065416f, 0.14502974f, 0.00616101f, -0.00004783f, -0.00435572f, 0.00821132f, 0.19415560f, 
    -0.37483248f, -0.30548939f, 0.07085552f, 0.01606201f, 0.14680290f, 0.03713275f, 0.15429033f, -0.04888495f, 
    0.13574103f, 0.05075572f, -0.06074908f, 0.23712946f, -0.36487511f, 0.10862629f, -0.04544828f, -0.04808905f, 
    0.08190972f, -0.04980665f, -0.00360566f, 0.02989582f, 0.00006159f, 0.20664105f, 0.00170004f, 0.05152736f, 
    0.04613095f, 0.34593681f, 0.14355624f, 0.15966760f, 0.00207871f, 0.08332069f, 0.05239264f, 0.23002347f, 
    -0.07619236f, -0.01576982f, 0.06330457f, -0.00477078f, -0.30073577f, 0.15034731f, -0.18146299f, 0.06384695f, 
    0.14231151f, 0.01765741f, -0.02933396f, -0.10156971f, 0.06855531f, 0.04661696f, 0.15732314f, -0.06808367f, 
    0.31872317f, -0.08680990f, 0.03239848f, -0.09771653f, -0.10755063f, -0.08961809f, 0.04601968f, -0.13142206f, 
    0.07288050f, 0.03252188f, -0.14235532f, -0.04897570f, -0.49648479f, -0.10900563f, -0.02714691f, 0.00899421f, 
    0.01877558f, 0.06924711f, 0.00002244f, -0.19910645f, -0.00192089f, -0.37796587f, -0.03050265f, 0.07895288f, 
    -0.68445194f, -0.40342620f, -0.14244489f, -0.13131391f, 0.17010288f, -0.00431983f, -0.18086691f, -0.00404784f, 
    0.08399537f, 0.17655900f, 0.15733153f, 0.25168100f, -0.28066587f, 0.34345540f, 0.00787874f, -0.08683309f, 
    -0.03608404f, 0.05678666f, -0.09971236f, -0.02180867f, 0.22369577f, 0.03537987f, 0.05486823f, -0.12483066f, 
    0.10725387f, 0.02033328f, 0.00334557f, -0.08232234f, -0.02059167f, -0.02410031f, 0.05549867f, 0.04008636f, 
    0.10322051f, -0.16158058f, -0.04207144f, -0.14775109f, -0.51482767f, 0.16815519f, -0.35958895f, -0.00976611f, 
    -0.04925515f, 0.04477040f, 0.05406964f, 0.01258777f, 0.06472205f, 0.00012839f, 0.03688855f, -0.18363860f, 
    -0.62989330f, -0.40408579f, -0.21648903f, -0.44820753f, 0.02924364f, 0.08250044f, 0.01693358f, -0.03918492f, 
    0.01884713f, 0.20020497f, -0.02760751f, 0.20852019f, -0.23160601f, -0.15763515f, -0.10303117f, -0.35298193f, 
    0.17388068f, -0.08485307f, -0.04446831f, -0.02452979f, 0.02821643f, -0.10002889f, 0.18614514f, -0.03799760f, 
    0.08837979f, 0.09579035f, -0.12699357f, 0.05087409f, 0.04894927f, 0.14544496f, 0.09563974f, -0.04628916f, 
    -0.01300533f, 0.11383052f, 0.13126568f, -0.08635998f, -0.20851833f, -0.07003338f, 0.02885207f, -0.43957004f, 
    0.08308905f, 0.03609813f, -0.01064471f, 0.08969148f, 0.04850193f, 0.02409923f, -0.03518446f, 0.07174157f, 
    -0.46098965f, -0.25996560f, -0.15567014f, -0.17883237f, -0.03842331f, 0.00740053f, 0.05950846f, -0.25182262f, 
    0.12607870f, 0.01479409f, -0.15856755f, -0.06929732f, 0.22955593f, 0.06683501f, 0.09355438f, -0.01062691f, 
    -0.22137769f, 0.07219590f, -0.01444207f, -0.07804871f, -0.01816188f, 0.06369614f, 0.28719571f, -0.18603508f, 
    0.36173546f, 0.03839321f, -0.11999866f, 0.02567331f, -0.09599134f, 0.06704703f, 0.05517073f, 0.17449379f, 
    0.09112695f, 0.11368445f, -0.04552110f, 0.07704560f, 0.18625855f, 0.28466538f, -0.06900364f, 0.27396724f, 
    0.11129426f, -0.13075592f, 0.09759432f, 0.01367148f, 0.07345718f, -0.05095609f, -0.03471906f, -0.04485241f, 
    0.25851926f, 0.16920191f, -0.27291054f, 0.09110127f, -0.09797508f, -0.05624996f, -0.05061807f, -0.09856826f, 
    0.06572340f, -0.05846931f, 0.17365843f, -0.10489115f, -0.12731132f, -0.31797063f, -0.01822793f, -0.03127132f, 
    0.11095416f, 0.09171512f, -0.07017483f, -0.09434707f, 0.10551754f, 0.06077721f, 0.05500188f, -0.00862833f, 
    -0.40253529f, 0.02222158f, -0.02077145f, -0.03957802f, 0.13587321f, 0.07935244f, -0.06154796f, 0.06430967f, 
    0.11186428f, 0.29716003f, -0.08414473f, -0.00611225f, 0.24528946f, 0.06588734f, -0.06072913f, -0.04546922f, 
    0.30030668f, 0.07421847f, 0.04168759f, 0.06907780f, -0.00708457f, 0.14791298f, -0.07647613f, 0.25695369f, 
    -0.00577018f, 0.02358465f, 0.07610369f, 0.16315636f, 0.10853406f, 0.11840010f, -0.04923084f, 0.09382328f, 
    0.05009270f, 0.32221645f, 0.11953070f, 0.09542267f, 0.17554885f, 0.00204131f, -0.04627765f, 0.03177654f, 
    -0.01839063f, -0.01084612f, 0.03450218f, -0.09394970f, 0.04554883f, 0.01976645f, -0.14896120f, -0.01449122f, 
    0.31204337f, 0.29277456f, -0.04652916f, -0.07277577f, 0.06997702f, -0.06263647f, 0.09508141f, 0.11174105f, 
    -0.07789429f, 0.04633405f, 0.27405486f, 0.07138978f, -0.03833853f, -0.09115932f, 0.07337518f, -0.09675168f, 
    0.06744004f, -0.00288001f, -0.13140941f, -0.00910373f, -0.09990504f, 0.13387367f, -0.00667165f, 0.09737794f, 
    -0.01140725f, -0.18105221f, -0.03425473f, -0.27992275f, 0.03105164f, 0.07461322f, -0.04635530f, 0.01666213f, 
    0.00880006f, 0.02832985f, -0.12127674f, 0.03086514f, -0.02903034f, 0.07260687f, -0.18680185f, 0.25111869f, 
    -0.14414619f, 0.03643715f, -0.10291395f, 0.10280106f, -0.17324324f, -0.05874060f, -0.09205709f, -0.00396099f, 
    0.31999475f, 0.01634246f, -0.17389819f, 0.01686157f, -0.10668689f, -0.15013008f, -0.04834364f, 0.02540581f, 
    -0.17230570f, -0.08910181f, 0.01948539f, 0.19196953f, 0.41836372f, 0.08021756f, 0.28468806f, 0.03467672f, 
    0.22384663f, -0.04237599f, -0.00156882f, 0.10841729f, 0.08554985f, 0.00522354f, -0.29642278f, -0.15957302f, 
    -0.71096933f, -0.05992635f, 0.18124814f, 0.14484026f, 0.15181074f, -0.10459635f, 0.05091591f, 0.01773095f, 
    -0.06446149f, 0.18344814f, -0.15175545f, 0.03162825f, -0.87977338f, -0.02305729f, 0.28647369f, 0.32896465f, 
    0.27176592f, -0.03962606f, 0.05631927f, -0.13167034f, -0.05903706f, 0.01041364f, -0.09141190f, 0.14243087f, 
    -0.07692597f, -0.25993848f, -0.11704595f, 0.04266658f, 0.06512383f, 0.14970499f, -0.08029501f, -0.09646196f, 
    0.09141140f, 0.06132782f, -0.15578729f, -0.13147472f, -0.19751345f, -0.32996160f, -0.24614117f, -0.15700951f, 
    0.11778222f, -0.04791484f, 0.00930898f, -0.06086066f, 0.02326119f, 0.00569142f, 0.05858861f, -0.03454327f, 
    -0.13154143f, -0.35621762f, 0.15698124f, -0.00009481f, -0.08459602f, 0.09215915f, 0.10234157f, -0.09556533f, 
    0.08205021f, -0.17893063f, -0.10237624f, -0.00053119f, -0.63854569f, -0.38922569f, 0.02476978f, -0.19530465f, 
    0.04533435f, 0.14856990f, -0.10418466f, -0.04529089f, 0.07256480f, -0.01812154f, -0.02104652f, 0.24420258f, 
    0.23284657f, -0.03713579f, 0.14770220f, -0.12753671f, 0.03285006f, 0.03770090f, -0.03417373f, -0.15021612f, 
    -0.03450437f, -0.01561660f, 0.12882191f, 0.09617894f, -0.38065684f, -0.00254174f, -0.28676483f, -0.33911780f, 
    0.01262349f, 0.16611771f, -0.14708963f, 0.09284323f, -0.01630945f, -0.01847185f, 0.07136479f, -0.27194557f, 
    0.42638436f, -0.01385964f, -0.14414513f, -0.08193652f, 0.09103384f, -0.14005703f, 0.00854732f, 0.01561490f, 
    -0.01828510f, -0.09896737f, -0.00206484f, 0.17614846f, -0.65546787f, -0.05067936f, -0.07760417f, -0.14613961f, 
    -0.05742493f, 0.11943500f, -0.08084340f, 0.21085881f, -0.02326250f, -0.14178093f, -0.09438159f, -0.07205459f, 
    0.09532968f, 0.13550873f, -0.18451929f, -0.20528978f, -0.30396053f, -0.01820799f, -0.00336664f, -0.15308967f, 
    0.07292504f, 0.08212152f, 0.02748467f, 0.03799957f, -0.19371349f, 0.04299847f, -0.03246754f, 0.19504005f, 
    -0.11533290f, 0.09071056f, -0.20688720f, 0.11364799f, -0.03788844f, 0.12915009f, 0.18167475f, 0.15624526f, 
    0.31683341f, -0.60543364f, -0.10365392f, -0.02744581f, 0.15463090f, -0.00247790f, 0.00787189f, -0.04175206f, 
    -0.08436243f, 0.00239343f, -0.09662186f, -0.01504400f, 0.05556280f, -0.23452544f, -0.15439938f, 0.57369226f, 
    -0.10052545f, -0.01427062f, 0.06320819f, 0.03882141f, 0.09213959f, -0.01402006f, 0.02007956f, 0.04943096f, 
    -0.15403540f, 0.04541118f, -0.02670291f, -0.11725893f, -0.10200547f, 0.15323953f, -0.11267276f, -0.12972131f, 
    0.00844447f, 0.01402942f, -0.01538159f, -0.14900357f, 0.38805258f, 0.20560659f, -0.35909179f, -0.00537678f, 
    -0.01469074f, 0.02250366f, -0.01140094f, 0.09036441f, 0.09257752f, 0.06877802f, 0.03537129f, -0.00857770f, 
    -0.17533045f, -0.51786208f, -0.09453248f, 0.01913977f, 0.19348374f, -0.03597253f, -0.01586651f, 0.01081387f, 
    0.07165899f, 0.15185836f, -0.03814066f, 0.02018817f, -0.10445219f, 0.18662913f, -0.01442106f, 0.14125229f, 
    -0.21736160f, -0.06396881f, -0.07934745f, -0.27818972f, -0.04891084f, -0.07196659f, 0.05537647f, 0.00599258f, 
    -0.27348143f, 0.10470039f, 0.00915742f, 0.07438053f, 0.07424235f, 0.07949256f, 0.04034013f, 0.02358408f, 
    -0.09929348f, 0.00997599f, 0.15123436f, -0.14752851f, 0.00996477f, -0.28104177f, 0.07270050f, 0.13865288f, 
    -0.17105396f, 0.07293376f, 0.10989911f, -0.16647466f, 0.00062671f, 0.05977848f, 0.12975956f, 0.07949116f, 
    0.26898372f, -0.05538706f, -0.24138148f, -0.02162402f, -0.02482891f, 0.06491623f, -0.01341050f, -0.02195356f, 
    -0.03103492f, -0.02235257f, -0.09668237f, -0.00039691f, 0.23161213f, 0.18339537f, -0.20032518f, 0.14228518f, 
    0.10931180f, 0.02687016f, 0.15126593f, 0.16071907f, -0.05760277f, 0.02785518f, -0.00406657f, 0.02311103f, 
    -0.19838275f, -0.23277393f, 0.00889135f, 0.13781805f, -0.11504400f, 0.13851306f, -0.03088747f, 0.01229156f, 
    -0.19628677f, -0.06730092f, -0.03837921f, 0.11860851f, -0.30495828f, 0.24792811f, -0.02980039f, -0.27631611f, 
    0.08878776f, -0.08712821f, -0.15773150f, -0.05982188f, 0.03256250f, 0.04000213f, 0.01716986f, -0.09129830f, 
    0.14935663f, 0.40732902f, -0.19379719f, 0.10320275f, 0.14155264f, 0.08079157f, -0.02115071f, 0.02165492f, 
    -0.00851927f, -0.05635963f, -0.17862067f, -0.10501538f, 0.24015115f, -0.05657583f, 0.03733629f, 0.15562727f, 
    -0.13905613f, -0.07458387f, -0.02099740f, 0.03239142f, -0.09209669f, 0.02498447f, -0.06204727f, -0.16019258f, 
    0.06640147f, -0.04660957f, -0.07524651f, 0.17442831f, -0.05557153f, -0.07208058f, 0.07166255f, 0.05135073f, 
    0.01998197f, -0.14439453f, -0.11366048f, -0.18898290f, 0.15573601f, -0.05125586f, -0.04681832f, 0.20760638f, 
    -0.02958086f, 0.14764260f, 0.11297482f, -0.08877307f, 0.05256174f, -0.11238599f, -0.03314961f, -0.20841381f, 
    -0.07782882f, 0.19263507f, -0.38893652f, -0.06394513f, 0.03665470f, -0.07805727f, 0.01741825f, 0.11228233f, 
    0.04672137f, 0.02100901f, 0.04003683f, -0.03951389f, -0.21478815f, 0.22340867f, -0.22420633f, -0.10578733f, 
    0.15077268f, -0.01259430f, 0.05268737f, 0.05111411f, -0.05399783f, -0.08990413f, -0.02169833f, 0.01730344f, 
    -0.26841855f, 0.10245319f, 0.00408871f, -0.07513312f, -0.06938948f, -0.08259023f, 0.13281295f, 0.15388626f, 
    -0.08976124f, -0.00479056f, -0.06655227f, -0.12340704f, 0.08125606f, 0.02844552f, -0.32754484f, -0.02202820f, 
    0.24428558f, -0.01464043f, 0.06019720f, -0.05506562f, -0.00658674f, 0.04034646f, 0.11267916f, 0.08942426f, 
    0.31084123f, -0.09252480f, -0.07833716f, -0.44200864f, 0.17358120f, -0.06829815f, -0.07309121f, 0.12838149f, 
    -0.00756292f, -0.11145523f, 0.05989342f, 0.10308567f, 0.69708133f, 0.04007528f, 0.05468491f, -0.11850067f, 
    -0.05197986f, -0.13157029f, -0.15211087f, 0.02236239f, 0.16291426f, 0.16965614f, 0.04897970f, 0.15053719f, 
    -0.38344738f, 0.22943828f, -0.15916640f, -0.04896028f, 0.03641514f, -0.15218824f, 0.00825401f, 0.25583696f, 
    0.04946348f, 0.07817236f, -0.00219809f, 0.12800942f, 0.00046975f, 0.00882743f, -0.21270722f, -0.18821780f, 
    0.14697626f, 0.09886038f, 0.05053198f, -0.05495300f, 0.08951904f, 0.01318925f, -0.01639688f, -0.07187094f, 
    -0.14775211f, -0.11388384f, 0.02783555f, 0.03596659f, 0.06593687f, 0.00239183f, -0.03211915f, -0.05383405f, 
    -0.07003218f, 0.05225835f, -0.08183967f, 0.01156814f, -0.32112893f, 0.22128624f, -0.41406780f, 0.16551343f, 
    0.16934773f, 0.05683803f, -0.01454969f, 0.05585276f, 0.14546569f, -0.05632920f, 0.01143746f, -0.13536862f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.10356171f, 0.03517248f, -0.09461752f, 0.00779532f, -0.03905999f, -0.03654407f, 0.03432683f, -0.12810555f, 
    0.00628587f, -0.00625382f, 0.09105977f, 0.04141149f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
