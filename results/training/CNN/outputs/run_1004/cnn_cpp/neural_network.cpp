#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.27180883f, 0.04833700f, 0.05712131f, -0.22888403f, -0.07049555f, 0.30634671f, -0.02012311f, 0.10023921f, 
    0.22353274f, 0.54312676f, -0.09269679f, 0.09305223f, -0.04740763f, 0.01989555f, -0.16358364f, -0.02932905f, 
    -0.25489128f, 0.03638038f, 0.11459228f, -0.41044462f, 0.07579331f, 0.24622050f, 0.28050399f, 0.33030730f, 
    0.35459948f, -0.78632164f, 0.31922939f, -0.47547710f, -0.69882172f, -0.25874242f, 0.01035735f, 0.05713198f, 
    0.35775203f, 0.47818321f, 0.21577039f, 0.21254668f, -0.00603081f, 0.10147031f, -0.06942472f, -0.18040141f, 
    -0.26773280f, 0.05456737f, -0.13545933f, 0.30547714f, 0.23049814f, 0.04396283f, 0.09840312f, 0.22559330f, 
    -0.07765951f, -0.15956487f, 0.16650958f, -0.34887430f, -0.44061264f, -0.34343085f, 0.02504197f, 0.06447955f, 
    -0.30682474f, -0.31812501f, -0.41189837f, -0.44277447f, 0.37688708f, 0.50935942f, 0.28816122f, 0.27945626f, 
    -0.29538423f, 0.03052324f, 0.34374434f, 0.01418068f, -0.02283762f, 0.04981139f, -0.11497144f, -0.07589790f, 
    -0.13371383f, -0.11015303f, -0.21519384f, -0.97569096f, -0.15913299f, -0.01053617f, -0.18175118f, 0.26594073f, 
    0.42187938f, -0.09451738f, -0.53414178f, -0.30839670f, -0.36974937f, -0.48104021f, -0.28117511f, 0.09216458f, 
    -0.58287936f, -0.03925826f, -0.19533660f, -0.37727800f, 0.00925114f, 0.13035052f, 0.04186180f, 0.14776392f, 
    -0.04288653f, -0.23179582f, -0.31866008f, -0.19617368f, 0.20016666f, 0.58757037f, 0.51670980f, 0.34709558f, 
    0.19448915f, 0.09225289f, -0.30951521f, -0.20048423f, 0.06257265f, -0.09326968f, 0.22166686f, 0.13136190f, 
    -0.08377188f, -0.21229927f, 0.11752421f, 0.10875359f, 0.35127535f, -0.06842840f, 0.11184886f, 0.08566022f, 
    0.19767402f, -0.15083975f, -0.29030243f, -0.02785844f, -0.07579917f, -0.00810953f, -0.70442909f, -0.45090470f, 
    -0.21783996f, 0.87061459f, -0.62495649f, -0.53475285f, 0.03404593f, 0.12575567f, 0.10965982f, 0.20754898f, 
    -0.00118114f, 0.27220979f, 0.19079660f, -0.00276175f, 0.05442213f, 0.12751268f, -0.52539933f, 0.09129870f, 
    -0.13809957f, 0.38702548f, -0.21388519f, -0.03393403f, -0.15189140f, 0.13006864f, 0.01975582f, 0.00115941f, 
    -0.28020599f, 0.55025595f, -0.06846742f, -0.10857195f, 0.18452074f, -0.29077363f, 0.06172635f, -0.23426181f, 
    0.03236230f, 0.00455678f, -0.01514709f, 0.30390605f, -0.21243827f, -0.16904087f, -0.09012160f, 0.47427335f, 
    0.14161089f, 0.03580562f, -0.19081245f, 0.28263965f, 0.27388591f, 0.30435395f, 0.13911910f, -0.20913248f, 
    -0.64451408f, -0.67438334f, -0.30524471f, -0.39946166f, 0.39025062f, -0.12445478f, -0.01204721f, 0.18069229f, 
    -0.14414442f, -0.36721534f, -0.20011854f, -0.14803436f, -0.01911301f, 0.35916251f, -0.05599508f, 0.04709289f, 
    0.22829691f, -0.07121688f, -0.11538351f, 0.10696378f, 0.21893300f, 0.38142973f, 0.25496539f, -0.02139480f, 
    0.67342985f, -0.46318877f, 0.22951408f, -0.18532571f, 0.09658306f, 0.23553778f, -0.08732433f, 0.16818096f, 
    0.19756120f, 0.28247100f, 0.18448344f, -0.04481585f, -0.20183757f, 0.31659365f, -0.04547745f, -0.24550952f, 
    -0.07014294f, 0.10417662f, 0.14328976f, -0.43179917f, -0.06248096f, -0.13226362f, 0.18163344f, -0.31719232f, 
    0.33831975f, -0.43614307f, 0.46566254f, 0.65562451f, -0.77620810f, -0.84516495f, -0.23867381f, 0.25831696f, 
    0.35325047f, 0.42905489f, -0.09936422f, -0.23115249f, 0.04766757f, 0.08595031f, 0.46926340f, -0.08253513f, 
    0.08867762f, -0.10874783f, 0.12635745f, -0.36325631f, -0.15651396f, 0.14260969f, 0.03003052f, 0.08383927f, 
    -0.11730067f, 0.09290884f, 0.49555531f, -0.22563262f, 0.27408201f, 0.63013428f, 0.01425640f, 0.16348182f, 
    -0.00854081f, 0.04319899f, -0.24778165f, -0.36386618f, -0.03958317f, -0.23748314f, 0.09645859f, -0.15591840f, 
    0.07767765f, -0.36728564f, 0.36244509f, 0.16010125f, 0.02668981f, -0.24933349f, 0.25501716f, -0.28852049f, 
    -0.00116639f, 0.24543042f, -0.22113635f, 0.55025870f, -0.33508751f, -0.17024976f, -0.05747588f, 0.23570514f, 
    0.14877953f, -0.11587284f, -0.07854354f, 0.23889819f, 0.10197496f, 0.17889735f, 0.15532100f, 0.26830480f, 
    -0.02905628f, 0.33133066f, 0.03806682f, -0.25748828f, 0.18173315f, -0.00069119f, 0.11856934f, 0.07864559f, 
    0.35300833f, 0.20706807f, -0.27939063f, 0.28709570f, 0.69515651f, 0.96653849f, -0.31024909f, 0.27748695f, 
    -0.23335777f, -0.41584477f, -0.48540500f, 0.01529719f, 0.35393548f, 0.03360773f, -0.10169459f, 0.15378827f, 
    0.03755224f, 0.14377454f, -0.23613788f, -0.00723720f, -0.00011370f, -0.18198504f, -0.01083689f, -0.19725230f, 
    -0.05470999f, -0.02481650f, -0.01338809f, -0.13771138f, 0.07152941f, 0.35915741f, 0.67930132f, -0.00392595f, 
    0.03017729f, -0.15210813f, 0.32398003f, -0.29114419f, -0.00810685f, -0.56629062f, -0.61657703f, -0.24073535f, 
    0.39488435f, 0.04800034f, -0.22366473f, 0.14534406f, -0.05591240f, -0.11041226f, 0.00446259f, 0.00018382f, 
    -0.12052976f, 0.11134126f, 0.14072031f, -0.17426854f, 0.15457316f, 0.31026122f, -0.83899629f, -0.69792587f, 
    -0.69172716f, -0.34861761f, -0.09314746f, 0.65612286f, 0.15308762f, 0.10072807f, -0.16746020f, 0.90044421f, 
    0.22361253f, -0.12559675f, -0.06935987f, -0.08909742f, 0.38783586f, -0.10981087f, 0.10046878f, -0.11456858f, 
    -0.01344992f, -0.16688587f, -0.12541158f, -0.14339912f, 0.06015238f, 0.01012496f, 0.00747754f, 0.31373149f, 
    -0.18939891f, -0.66654187f, -0.47975099f, -0.17986089f, 0.24622692f, 0.03590333f, 0.06067840f, -0.49582416f, 
    -0.73611748f, 0.42806149f, -0.04633291f, 0.39936608f, -0.17579874f, -0.48058951f, -0.02857439f, -0.22215521f, 
    -0.10358291f, -0.52436882f, -0.12187703f, -0.01456578f, -0.03152158f, -0.05305655f, 0.17747301f, 0.27007329f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.16783710f, 0.31030923f, 0.16670924f, -0.10659505f, -0.19272414f, 0.26064128f, 0.34682584f, -0.06018972f, 
    0.36652076f, 0.29264921f, 0.27222770f, -0.08454494f, 0.30772808f, 0.08535144f, 0.35940340f, 0.14577033f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.06828664f, 0.08832790f, -0.15404949f, -0.08475999f, 0.00751245f, 0.01977812f, -0.05497587f, 0.02255203f, 
    -0.06035316f, -0.19554113f, 0.14414677f, 0.06053742f, -0.01572525f, 0.25818551f, 0.01759272f, 0.06168231f, 
    -0.10933740f, -0.03219157f, 0.21038330f, -0.07250571f, -0.06014757f, 0.01049917f, -0.13420714f, 0.14037719f, 
    0.22218779f, 0.19590452f, 0.07074436f, 0.01737579f, 0.18649130f, 0.07940453f, -0.00951280f, 0.16053668f, 
    -0.06156714f, 0.00793733f, 0.03065061f, 0.07760219f, -0.21463977f, -0.13606453f, 0.19946833f, 0.07116359f, 
    -0.05617660f, -0.00844141f, -0.11238107f, 0.11877076f, 0.06376595f, 0.08524214f, -0.00359109f, 0.01707458f, 
    -0.35741195f, -0.24807082f, 0.04081834f, -0.08676154f, -0.00922478f, -0.01016489f, -0.14754105f, -0.06246646f, 
    0.07295110f, -0.02248406f, -0.06298690f, 0.02393840f, 0.06134799f, -0.03984375f, 0.19919465f, 0.21742880f, 
    -0.05683428f, -0.01372697f, -0.07653054f, 0.04003771f, -0.01158718f, 0.07781203f, -0.10293645f, 0.01883405f, 
    0.08374194f, -0.02643361f, 0.02248935f, -0.10460570f, 0.08725839f, 0.16170065f, 0.13072863f, 0.07070198f, 
    0.10339098f, 0.00296120f, 0.04098941f, -0.31531224f, -0.05980201f, 0.15702979f, 0.27774915f, 0.30166802f, 
    -0.12066506f, 0.00049213f, 0.14675799f, 0.10253975f, 0.11405966f, 0.08965494f, 0.06275594f, -0.07166164f, 
    -0.09010422f, -0.02743223f, -0.03349572f, -0.20621344f, -0.32684684f, 0.03877447f, -0.09614868f, 0.00840532f, 
    0.00715447f, -0.05575901f, 0.00392841f, -0.11621377f, 0.00663986f, 0.15348785f, -0.30396464f, -0.00516607f, 
    -0.10273355f, -0.03584313f, 0.09054790f, 0.05771166f, -0.04669279f, -0.22896272f, -0.00138582f, 0.05736421f, 
    -0.09443041f, 0.04355986f, -0.06406499f, -0.04645333f, -0.13378543f, -0.16491337f, -0.06124278f, 0.09750243f, 
    -0.03504193f, -0.01787598f, -0.01058591f, -0.03036525f, -0.17494458f, -0.18814494f, 0.02978564f, -0.24964447f, 
    -0.10224220f, -0.01706751f, 0.14584018f, -0.06063949f, 0.17842150f, 0.11251624f, -0.11617374f, -0.08250327f, 
    -0.38720518f, -0.21919017f, 0.00231969f, 0.22275071f, -0.17334276f, 0.03478650f, -0.00107589f, -0.21716425f, 
    0.14992182f, -0.00623437f, 0.02810704f, -0.13592678f, -0.00763290f, 0.33260050f, -0.03852394f, 0.05822791f, 
    0.02913821f, 0.08674762f, 0.00621317f, 0.18148249f, 0.03900203f, 0.15134673f, -0.14863752f, -0.09988883f, 
    0.04363922f, -0.04741585f, 0.35601276f, 0.30766624f, 0.03594388f, 0.01864057f, 0.02667625f, 0.00584218f, 
    -0.01000540f, 0.07417312f, 0.08280798f, 0.12543672f, 0.24836664f, 0.27665156f, 0.25528294f, 0.12345441f, 
    0.00437996f, 0.09561674f, -0.00491030f, 0.05129135f, 0.04754476f, -0.13436542f, 0.08023767f, -0.04825287f, 
    -0.07434347f, 0.02098923f, 0.06241919f, 0.00505738f, -0.09833570f, -0.05522593f, 0.00298675f, -0.07927784f, 
    0.06023202f, -0.01698045f, -0.05057474f, 0.15657502f, -0.36876410f, -0.02307188f, -0.07316126f, -0.26185721f, 
    -0.20075716f, -0.19438668f, 0.06912663f, 0.12085971f, 0.02053826f, -0.09915673f, -0.10106725f, -0.04469853f, 
    0.10435115f, 0.13325410f, -0.03825308f, -0.23378237f, -0.04180882f, -0.03303435f, -0.02840857f, 0.11059210f, 
    -0.08832926f, -0.01061253f, 0.03706330f, 0.00418104f, -0.02142870f, 0.26090646f, 0.22281004f, -0.00775414f, 
    0.03834222f, 0.07805569f, 0.03317409f, 0.13525896f, 0.13120678f, -0.03942085f, -0.05667690f, 0.02214374f, 
    -0.20240965f, -0.32145852f, -0.05342521f, 0.10346748f, 0.05577291f, -0.00453145f, -0.00610691f, 0.00479804f, 
    -0.18065500f, -0.12037221f, 0.02321986f, -0.14683627f, -0.15810649f, 0.12045103f, 0.21216826f, 0.03188292f, 
    0.02381206f, 0.11565559f, -0.07190467f, 0.10365644f, -0.06092635f, -0.00186183f, -0.02269273f, 0.06531462f, 
    0.14112882f, 0.03188031f, 0.06390274f, -0.03740136f, 0.13226086f, 0.24976751f, 0.16179235f, 0.09051039f, 
    0.22246450f, 0.18771380f, -0.04668206f, 0.00777836f, 0.03333710f, 0.12056224f, -0.03484454f, 0.00174056f, 
    0.07444318f, 0.13028917f, 0.11291221f, 0.18158334f, -0.05116326f, 0.07409772f, 0.02034399f, -0.03248109f, 
    0.20973982f, -0.15551640f, 0.08665631f, 0.01680133f, -0.17480512f, -0.11910592f, -0.01614671f, 0.09688932f, 
    0.10561777f, -0.03342302f, -0.08468375f, -0.06688637f, -0.17917073f, 0.13799633f, -0.15216295f, -0.10708667f, 
    -0.02624636f, -0.00292766f, 0.06064329f, 0.14917769f, 0.00056368f, -0.10475874f, -0.02615905f, -0.05289806f, 
    0.07476983f, -0.25470099f, -0.11254319f, -0.16995238f, -0.03013879f, 0.05635446f, -0.16621183f, 0.10773612f, 
    -0.08583477f, -0.11348182f, 0.05457881f, -0.07910804f, 0.01641783f, 0.01663717f, -0.06678951f, -0.03850691f, 
    -0.11022217f, -0.05592209f, 0.17468245f, -0.07305004f, 0.12618060f, -0.01416893f, 0.08591754f, 0.00075797f, 
    0.08783365f, -0.11303638f, -0.41080379f, 0.16045669f, -0.01145559f, -0.07127479f, 0.14961825f, -0.08446293f, 
    0.03064225f, 0.03313330f, -0.10736869f, -0.02726403f, 0.06742112f, 0.03042393f, -0.24299984f, 0.07752382f, 
    -0.07302468f, 0.18869340f, 0.17915350f, 0.04840145f, 0.05154205f, 0.01319839f, 0.08320427f, -0.05644668f, 
    0.14473143f, 0.27484760f, 0.11717208f, -0.13737302f, -0.07046673f, -0.08351342f, -0.07865477f, -0.00846369f, 
    -0.02921700f, 0.04889488f, -0.08862976f, 0.04694450f, 0.17270841f, 0.10190877f, -0.05246456f, 0.08153913f, 
    0.01842304f, 0.01245974f, 0.02124261f, 0.11380361f, 0.03708836f, -0.13720092f, 0.07958624f, -0.05588676f, 
    0.13082603f, 0.06518988f, -0.28252062f, -0.22026752f, 0.13475600f, -0.02258600f, -0.03328655f, -0.09707308f, 
    -0.16422544f, -0.03816609f, -0.00123515f, -0.08270078f, 0.25808665f, 0.09918374f, 0.12729751f, -0.04138585f, 
    0.07697365f, 0.05652151f, -0.03970305f, 0.05835439f, 0.02116170f, 0.01102574f, 0.08618273f, 0.11519596f, 
    -0.19644433f, -0.00084876f, 0.41307908f, 0.13107894f, 0.15477718f, 0.10331342f, -0.00144951f, -0.01828246f, 
    0.11934924f, -0.02211349f, -0.00326636f, 0.02936338f, -0.30832952f, -0.23001263f, 0.27079713f, 0.09019744f, 
    -0.03514300f, 0.09987707f, 0.02166075f, 0.10608952f, 0.06979105f, 0.00043498f, 0.08439329f, 0.10256194f, 
    0.10831580f, 0.00173650f, 0.01587366f, -0.15246916f, 0.06364140f, 0.17643872f, 0.09754116f, 0.06783202f, 
    -0.11376097f, 0.04154485f, 0.00088917f, 0.15065934f, -0.11542314f, -0.32419983f, 0.20613728f, 0.18103692f, 
    0.08242586f, -0.01583013f, -0.08824445f, 0.04843991f, 0.09902484f, -0.01355172f, -0.15705198f, 0.06881583f, 
    -0.07322998f, -0.07693340f, 0.01722856f, 0.13250971f, -0.04263294f, -0.03269226f, -0.11579159f, 0.12166204f, 
    -0.26373953f, -0.16592236f, -0.05992890f, -0.30837852f, -0.08111952f, -0.06251095f, 0.11607075f, 0.19424494f, 
    0.03044897f, -0.10691956f, 0.08847505f, 0.08215808f, 0.00592731f, -0.16610835f, -0.08183657f, 0.02390293f, 
    0.01259136f, -0.17468032f, 0.06894740f, -0.10754374f, 0.04736970f, -0.09810864f, -0.06387446f, -0.20444649f, 
    0.00255157f, 0.11927139f, 0.15702102f, 0.04315175f, -0.05345341f, 0.28030142f, 0.00676069f, 0.13322216f, 
    0.03334620f, -0.00904579f, 0.12869896f, -0.13407499f, -0.06404948f, 0.16862836f, 0.06346153f, 0.02420652f, 
    0.36123419f, 0.07250280f, 0.01669963f, -0.01180716f, 0.03658881f, -0.09965193f, 0.06160419f, -0.10716104f, 
    -0.05967639f, 0.07246240f, 0.05971833f, 0.02602000f, -0.16504283f, -0.24836098f, 0.07217268f, -0.31055182f, 
    0.01028810f, 0.06366900f, -0.02652288f, -0.11311400f, 0.06764238f, -0.06262602f, -0.11231663f, -0.40380332f, 
    0.31857365f, -0.11549341f, -0.01127306f, 0.09616784f, 0.03465629f, -0.00642043f, -0.04425375f, -0.08047736f, 
    0.07435068f, -0.04195311f, 0.08008900f, -0.07463006f, 0.00325103f, 0.41192621f, 0.24509585f, -0.12416644f, 
    0.08624349f, -0.10939632f, 0.04284546f, 0.12064878f, -0.21075201f, -0.26604408f, -0.17325053f, -0.01072264f, 
    0.01078790f, -0.07962549f, -0.02480184f, 0.03799984f, 0.07337832f, -0.07186253f, 0.14962773f, 0.17286886f, 
    0.00373432f, -0.07532669f, -0.00829157f, 0.07961442f, -0.12683436f, 0.20531067f, 0.49356836f, 0.12133560f, 
    -0.03170870f, -0.02588085f, 0.06755871f, 0.12490549f, 0.06824332f, 0.09805703f, 0.07313325f, -0.12414181f, 
    0.15955819f, 0.08684020f, -0.08606398f, 0.04740968f, 0.11165591f, 0.09499507f, 0.12426972f, 0.02168213f, 
    -0.06385364f, -0.11057344f, 0.03241364f, -0.10114707f, 0.37122798f, 0.28192809f, 0.09504861f, 0.20567203f, 
    -0.01623076f, -0.10926358f, -0.03089124f, -0.05280544f, -0.02672709f, 0.05236236f, -0.11039380f, 0.04791465f, 
    -0.37729493f, -0.26152685f, 0.03067597f, 0.20505117f, -0.00251534f, 0.07548457f, 0.02174656f, -0.25112367f, 
    0.04078577f, -0.00868588f, 0.04094167f, 0.00292264f, -0.12503712f, -0.36136323f, 0.16990057f, 0.05694818f, 
    0.03412722f, -0.05871727f, 0.02775982f, 0.06867113f, 0.00194733f, -0.00471276f, 0.09541123f, -0.11209402f, 
    0.05308086f, 0.11337688f, 0.06277677f, -0.25473621f, -0.03597315f, -0.13548879f, -0.03372810f, 0.02654372f, 
    0.06521911f, -0.01691740f, -0.11044409f, -0.02840470f, -0.18825966f, -0.27024060f, -0.26716101f, 0.36170185f, 
    -0.06985049f, 0.05113105f, -0.06059271f, 0.13891838f, -0.05987718f, 0.11596065f, -0.00780265f, 0.09223069f, 
    -0.12298637f, 0.04046770f, 0.06362913f, 0.01459852f, -0.02512882f, 0.01121184f, 0.13552845f, -0.10142662f, 
    -0.05535968f, -0.02803200f, 0.12746646f, 0.03743878f, -0.36868468f, 0.17584532f, 0.13331135f, 0.19758192f, 
    -0.10772334f, 0.01237359f, 0.20224431f, 0.06107935f, -0.10342371f, 0.10353887f, 0.01600732f, -0.14597650f, 
    -0.08102083f, 0.38005438f, -0.11215245f, -0.15242760f, -0.08886508f, 0.11113147f, 0.03509959f, -0.02692833f, 
    -0.02117911f, 0.05907699f, 0.07922351f, 0.06005803f, 0.37797067f, 0.05433596f, -0.06921801f, -0.01871154f, 
    -0.06580257f, 0.15163708f, 0.15383679f, -0.02578469f, -0.02208241f, 0.02855151f, 0.06986985f, 0.07845978f, 
    -0.05167894f, 0.71770710f, 0.05107822f, 0.03978798f, -0.13726656f, 0.01045784f, 0.07626993f, -0.17025688f, 
    0.10767119f, 0.04542978f, 0.00042272f, -0.10103805f, 0.04437616f, 0.10815908f, -0.01725828f, -0.01372124f, 
    0.03925559f, 0.04782739f, -0.01908750f, 0.10179007f, -0.05831054f, 0.17720705f, 0.15467186f, 0.00482315f, 
    -0.27040079f, 0.23284988f, 0.18417858f, -0.31631178f, -0.21217151f, 0.02785418f, 0.00342918f, -0.09207267f, 
    0.06594054f, 0.01013933f, 0.03258319f, 0.09200893f, 0.01893832f, -0.17327227f, 0.21948706f, -0.23294309f, 
    0.07768952f, -0.10081737f, -0.09653616f, 0.10469666f, -0.09881993f, -0.01435333f, -0.07187252f, 0.04256779f, 
    -0.07314289f, 0.09566071f, 0.11745936f, 0.17298020f, -0.04564613f, -0.03744793f, 0.03159725f, 0.04688806f, 
    -0.09574264f, 0.01848210f, 0.01723291f, -0.06324866f, -0.12442572f, -0.06499498f, 0.25496712f, 0.20494692f, 
    -0.00413894f, -0.03519606f, 0.08688728f, 0.05262692f, 0.10197527f, 0.03117958f, 0.16679181f, 0.12979950f, 
    -0.17637168f, -0.00151776f, 0.08204160f, -0.01366208f, -0.16417444f, -0.00508118f, -0.13390101f, -0.03421127f, 
    -0.05979868f, 0.09477945f, 0.01807832f, 0.04891568f, -0.17568694f, 0.10021065f, -0.00499226f, 0.08035760f, 
    -0.01724400f, -0.02048923f, 0.04559549f, 0.23529811f, 0.08137919f, 0.15284650f, 0.17913345f, 0.00768494f, 
    -0.27135620f, -0.14554739f, 0.06543595f, -0.08811067f, 0.01804851f, -0.01923857f, -0.05269917f, -0.10619064f, 
    -0.14237437f, -0.00961932f, -0.00791310f, -0.00316256f, -0.06846427f, 0.18737307f, 0.04965813f, 0.08586173f, 
    0.09234893f, -0.05030020f, 0.00646687f, -0.01507616f, 0.01648259f, 0.11672675f, 0.12702735f, -0.09349003f, 
    -0.00138325f, 0.10345121f, 0.01831405f, -0.12393305f, -0.13443400f, -0.21204177f, -0.24062207f, 0.05725750f, 
    -0.18687472f, -0.05756092f, -0.17618808f, -0.16536954f, -0.02328917f, -0.14688332f, 0.07063230f, -0.04156113f, 
    0.13016208f, 0.18551542f, 0.01781126f, 0.19655380f, 0.00546778f, 0.00147618f, 0.14375482f, 0.03868015f, 
    0.07847133f, 0.03969999f, -0.03967998f, 0.08585995f, 0.04297587f, 0.16837017f, 0.25689426f, -0.03507482f, 
    0.03619819f, -0.00322199f, -0.02818073f, -0.05010207f, -0.11484627f, 0.19145525f, 0.02481035f, -0.15104942f, 
    0.02289095f, -0.03656630f, 0.13156460f, -0.09978856f, -0.02856970f, 0.07069583f, -0.12758479f, -0.19005726f, 
    -0.03342063f, 0.18412825f, 0.17273982f, 0.23852538f, -0.07464791f, -0.10099894f, 0.17423835f, 0.13159660f, 
    0.03192270f, 0.07142196f, 0.27330378f, 0.21722719f, 0.11666975f, -0.01963477f, 0.20796256f, -0.06368542f, 
    0.09194660f, 0.05307815f, 0.28988689f, 0.17571571f, 0.08406229f, 0.03439270f, -0.10951462f, 0.09512253f, 
    -0.00599906f, 0.22882557f, -0.03378368f, -0.03499573f, 0.00242710f, 0.04681044f, -0.08077561f, -0.01730979f, 
    0.01767939f, 0.02499866f, 0.12916589f, -0.08751597f, -0.10662995f, 0.02758245f, -0.13735496f, 0.03319455f, 
    -0.22273882f, 0.02899837f, -0.08627425f, -0.06761730f, -0.00338009f, 0.02972932f, 0.04843600f, -0.04426507f, 
    0.66046357f, -0.03218238f, 0.33317879f, 0.23860420f, 0.01311119f, -0.08230239f, 0.04888396f, 0.04499367f, 
    0.02642279f, 0.03431708f, 0.09721054f, 0.08574905f, -0.09385230f, -0.18414435f, 0.01898771f, -0.13436350f, 
    0.00885511f, 0.10223635f, -0.13182566f, 0.02164784f, -0.05411369f, -0.01744887f, 0.17468779f, 0.10692980f, 
    -0.44148058f, 0.35446820f, -0.04821634f, -0.15617952f, -0.13024835f, -0.11052207f, -0.02625963f, 0.15628141f, 
    0.08271503f, 0.03315581f, -0.05911568f, -0.01159073f, -0.13869734f, -0.03029367f, -0.05414847f, 0.00066572f, 
    -0.05246986f, 0.10491257f, 0.00906967f, -0.09670242f, 0.13127172f, -0.02474658f, -0.00520123f, 0.02768728f, 
    0.03818443f, 0.00414544f, 0.08743206f, 0.09153140f, -0.07711609f, 0.06846946f, 0.12842403f, 0.02354598f, 
    -0.10528610f, -0.19760613f, -0.04689100f, -0.15810281f, -0.07901155f, 0.30876246f, 0.03341368f, -0.05749977f, 
    -0.01025276f, 0.09805378f, -0.13406891f, -0.01037081f, -0.02972320f, -0.18013673f, -0.01972044f, 0.01456437f, 
    0.27230781f, 0.18830274f, 0.01570216f, 0.02372335f, -0.06197078f, -0.00901635f, -0.02638196f, 0.09182597f, 
    0.18338159f, -0.02212551f, 0.03496400f, 0.04259389f, -0.01507861f, 0.11962293f, 0.03983454f, 0.09752111f, 
    0.02870451f, -0.04178807f, 0.01725435f, 0.01435033f, 0.10529448f, -0.13301966f, -0.20171790f, -0.04122985f, 
    -0.11817593f, -0.25252625f, 0.00405644f, -0.04393233f, 0.12421656f, 0.09060280f, 0.03871971f, -0.02232375f, 
    0.04035643f, -0.03316422f, 0.13646756f, 0.16494447f, 0.07583966f, -0.01627626f, 0.04157744f, 0.14342564f, 
    -0.14982302f, 0.17938274f, -0.01065977f, 0.07309065f, -0.06442217f, 0.00442695f, -0.05023636f, -0.10457724f, 
    0.02204837f, 0.04271554f, 0.04892799f, -0.00318826f, 0.08936703f, -0.02102443f, 0.07266801f, 0.05953769f, 
    -0.07126722f, -0.02651242f, -0.10340914f, -0.00993108f, 0.20223583f, 0.29256493f, 0.28889233f, 0.02886516f, 
    -0.00393128f, 0.17436782f, 0.11186621f, 0.14352588f, 0.02573736f, -0.13668722f, -0.04982850f, 0.02563968f, 
    -0.01779799f, -0.37516442f, -0.21379061f, -0.10313668f, -0.06402866f, 0.02492398f, 0.06771401f, 0.05356096f, 
    -0.07589094f, 0.03821107f, -0.08662076f, -0.17022946f, -0.40282166f, -0.11214948f, 0.10025103f, -0.19587645f, 
    -0.11294081f, 0.07612009f, -0.10541333f, 0.16795072f, 0.02443409f, -0.04629590f, 0.04458920f, 0.00295220f, 
    -0.09382512f, -0.20511580f, -0.37605548f, -0.44717333f, 0.01964260f, -0.18625316f, -0.00048111f, 0.12676051f, 
    0.04547898f, -0.02435183f, -0.07081745f, 0.06962357f, 0.08323383f, -0.01674609f, 0.05243323f, 0.06950253f, 
    -0.04150573f, 0.06467585f, 0.15220560f, 0.19670257f, -0.03848040f, 0.03510819f, 0.02736447f, -0.02033347f, 
    -0.61830908f, -0.57190853f, -0.40742639f, -0.42453757f, 0.06967234f, 0.06811598f, 0.02924394f, -0.10744812f, 
    0.00349983f, 0.00142295f, -0.02920604f, 0.04190464f, 0.06741621f, 0.20840244f, -0.31711626f, -0.03116839f, 
    0.00940740f, -0.11864902f, -0.06290881f, -0.01821093f, -0.00191537f, 0.04975851f, 0.08439465f, -0.01623778f, 
    0.40487945f, 0.29973930f, 0.06578010f, 0.08500982f, 0.00195844f, 0.13868627f, 0.06148351f, 0.03531379f, 
    0.14938341f, -0.06508832f, 0.04775880f, 0.07855126f, 0.32334271f, 0.17413612f, 0.16977815f, -0.06322313f, 
    -0.02800084f, 0.07121448f, 0.07596661f, 0.09993196f, -0.08796471f, -0.16515483f, -0.08633318f, -0.15797696f, 
    0.04837222f, -0.04112364f, -0.02303509f, -0.07926587f, -0.05791016f, 0.04418376f, 0.00954696f, -0.04847318f, 
    -0.02725487f, -0.02847055f, 0.05600388f, 0.04564965f, -0.04448013f, 0.03710648f, 0.03794914f, -0.00105680f, 
    0.00676136f, 0.03016878f, -0.05828348f, 0.02622733f, -0.04550428f, -0.00958710f, 0.00502047f, 0.03034760f, 
    -0.05126313f, 0.04807164f, -0.02287167f, 0.04207278f, -0.01011597f, -0.07175774f, -0.08048765f, -0.05448991f, 
    -0.05951122f, 0.01064941f, -0.05244414f, -0.05003031f, 0.03820449f, -0.02779451f, -0.04352975f, 0.05488151f, 
    0.03696433f, -0.01563177f, 0.04400297f, 0.05690590f, -0.01961186f, -0.00679306f, -0.02532381f, -0.00084759f, 
    0.04897338f, 0.02376818f, -0.06875195f, -0.00814826f, -0.00824740f, -0.04589750f, -0.03355861f, -0.02534798f, 
    -0.06951934f, -0.07774446f, -0.03836200f, -0.05554585f, 0.05409110f, 0.03899564f, -0.06364993f, -0.05750833f, 
    0.02274217f, -0.06412198f, -0.08286006f, -0.06306998f, 0.02809037f, 0.04850487f, -0.03115507f, 0.02553553f, 
    -0.06066164f, 0.07049681f, -0.03004564f, 0.04007679f, 0.03448611f, -0.05005202f, 0.00429617f, -0.00412524f, 
    -0.04084292f, -0.06393597f, -0.02996366f, -0.04755282f, -0.01746432f, -0.06107900f, 0.01041893f, 0.01577223f, 
    0.05287363f, 0.00653048f, -0.02197926f, -0.06298553f, -0.07393271f, -0.02353792f, 0.02359775f, -0.06654509f, 
    -0.06368729f, -0.06635929f, -0.03347442f, -0.01324289f, 0.03968244f, 0.02069054f, -0.07596160f, -0.06089408f, 
    0.04130380f, -0.07002675f, 0.03247404f, 0.05142504f, 0.00886545f, -0.04091953f, 0.02229998f, -0.00347054f, 
    0.04091787f, -0.04276241f, -0.04741872f, -0.06696229f, 0.00563761f, -0.03810608f, 0.02231453f, -0.01053835f, 
    -0.05403710f, -0.01329333f, -0.02299483f, 0.04690883f, -0.06344680f, 0.03113393f, -0.02304121f, -0.06261767f, 
    0.02898400f, -0.02684591f, -0.05851541f, -0.00066507f, -0.05157222f, 0.04008972f, -0.03268937f, -0.03636932f, 
    -0.02444495f, -0.00614870f, -0.06235705f, 0.01773790f, -0.00916024f, -0.00628534f, -0.04226732f, 0.02956474f, 
    0.03146238f, 0.01114589f, 0.00259698f, 0.02270811f, -0.05213786f, -0.00392121f, -0.05222297f, -0.01988791f, 
    0.05824446f, -0.07051298f, -0.05514399f, 0.01889539f, -0.04914559f, 0.04885885f, -0.00970766f, 0.04401538f, 
    -0.03403112f, -0.03770126f, -0.02718869f, -0.07282930f, 0.02949552f, -0.07613648f, 0.04387232f, -0.00233207f, 
    0.02655038f, -0.06883937f, -0.06154165f, 0.01764315f, -0.06629288f, 0.01625551f, 0.05391435f, -0.00987734f, 
    0.00785181f, 0.01798723f, 0.01040659f, -0.07446679f, -0.01071346f, -0.00087467f, 0.06502504f, 0.06131312f, 
    0.01638323f, -0.00202885f, 0.06448421f, 0.02534128f, -0.04908724f, -0.04141354f, -0.04900661f, -0.06884295f, 
    -0.09959187f, 0.01624847f, 0.08354882f, 0.12797530f, 0.02103278f, -0.13083930f, -0.12138453f, 0.05905043f, 
    -0.00329317f, -0.04881583f, -0.04707533f, -0.03568259f, -0.46141407f, 0.19239457f, 0.23778725f, 0.09127571f, 
    0.02809166f, -0.01166201f, -0.07545310f, -0.04296705f, 0.16348195f, 0.11603353f, 0.20147392f, 0.05434938f, 
    0.30131209f, 0.25433838f, 0.14241454f, -0.38161325f, 0.08951509f, 0.04258062f, -0.01534931f, -0.01391640f, 
    0.11107290f, 0.11004574f, 0.03787480f, -0.06893530f, -0.16903478f, 0.01706197f, -0.00117579f, 0.06956761f, 
    -0.10797358f, 0.07803325f, -0.02140765f, -0.04972068f, -0.05590582f, 0.12852857f, 0.06303091f, 0.13459326f, 
    -0.06620288f, -0.13961993f, -0.13284720f, 0.19975691f, 0.20551349f, 0.08031023f, 0.09992786f, 0.15585774f, 
    0.07544213f, -0.03139374f, -0.00699967f, 0.07017847f, 0.17078061f, 0.23091738f, 0.27328795f, -0.22052145f, 
    -0.01655019f, -0.15563661f, 0.01057350f, 0.05782217f, 0.08639162f, 0.02366206f, -0.06199856f, -0.05822619f, 
    0.06529163f, -0.16998836f, -0.00070382f, 0.00972844f, 0.12471081f, 0.02743416f, -0.09288003f, 0.26026088f, 
    0.10854771f, -0.13120922f, -0.19291882f, -0.13071840f, -0.07543086f, -0.08729543f, -0.08416725f, -0.13991740f, 
    -0.07207061f, 0.00559499f, -0.21365827f, -0.14418304f, 0.01551952f, -0.02105840f, -0.01802414f, 0.04094948f, 
    0.02264179f, -0.22389567f, 0.04837836f, 0.20004660f, 0.04606958f, -0.01659375f, 0.00840835f, 0.12046371f, 
    0.00172838f, -0.00232694f, 0.03517032f, -0.02036511f, -0.12397111f, 0.22218214f, -0.14341657f, -0.01595520f, 
    -0.03095922f, -0.16091096f, -0.13132702f, -0.16964638f, 0.07081478f, -0.05103841f, -0.08481921f, -0.07422336f, 
    0.13700759f, -0.37766218f, -0.04510705f, 0.01880915f, 0.19352922f, 0.08057706f, 0.04430109f, 0.16675088f, 
    -0.00936661f, 0.01478550f, -0.01989731f, 0.12181614f, -0.02225129f, 0.10641299f, 0.11921239f, 0.17360258f, 
    0.09665629f, -0.07304633f, 0.10006990f, -0.08023033f, 0.10308742f, -0.10916890f, -0.09180892f, -0.00622412f, 
    0.33434886f, 0.00028626f, -0.20916639f, 0.29225823f, -0.06045984f, 0.00372593f, 0.16251144f, 0.08128134f, 
    -0.00871820f, 0.04183565f, -0.01700274f, -0.04026572f, 0.04908084f, 0.04776841f, -0.24551970f, -0.07949017f, 
    0.22441910f, -0.09809858f, 0.17409641f, -0.05528064f, 0.00008688f, 0.00328702f, 0.00805595f, -0.07272267f, 
    -0.19791532f, 0.15599500f, 0.47707418f, 0.10121532f, -0.06885722f, 0.03150941f, 0.07040517f, 0.15058637f, 
    0.03105025f, -0.05398696f, 0.03949892f, 0.20963076f, 0.07180914f, 0.20411429f, -0.01991642f, -0.36807159f, 
    0.08159657f, 0.01706268f, -0.12331471f, 0.02261299f, -0.06325975f, 0.18618688f, -0.00847824f, -0.22918296f, 
    -0.07888831f, 0.02134146f, -0.01120102f, 0.00944043f, -0.03400804f, -0.07618100f, -0.00310877f, -0.04592125f, 
    0.03751880f, 0.03439748f, 0.03454999f, 0.03454421f, 0.01660750f, 0.00902326f, -0.03281430f, -0.01458057f, 
    -0.00883392f, -0.05029537f, 0.05132892f, 0.00811629f, -0.04332833f, -0.06902627f, 0.03740162f, -0.07767956f, 
    0.02753486f, 0.01100571f, 0.04757438f, 0.02152629f, -0.04037763f, 0.01359499f, 0.00657916f, -0.01722324f, 
    0.03236265f, 0.02234446f, -0.04241361f, -0.06226544f, -0.02954629f, -0.06838102f, 0.01954742f, 0.06235253f, 
    -0.05148481f, -0.04572436f, 0.02157728f, 0.04513768f, 0.00490231f, -0.06398222f, -0.03815587f, 0.00117338f, 
    -0.04576621f, -0.02476302f, -0.04341191f, -0.01492196f, -0.01954056f, -0.07231773f, -0.03210213f, -0.04247214f, 
    0.02576492f, -0.07499755f, 0.03668395f, 0.05201048f, 0.00489265f, -0.01872186f, -0.01697036f, -0.08125979f, 
    -0.06229632f, 0.03504275f, -0.06711273f, 0.04460326f, 0.02026805f, 0.02714186f, -0.07860432f, -0.05654505f, 
    0.02090948f, 0.05080283f, -0.04186625f, -0.04141213f, -0.05211523f, -0.06281433f, -0.01502795f, 0.04917972f, 
    -0.03437034f, 0.05579804f, -0.04032341f, 0.02280756f, -0.06008566f, -0.03866649f, 0.04817640f, -0.04463690f, 
    -0.06325465f, 0.01561598f, -0.04198246f, -0.06043248f, -0.02061944f, -0.04147205f, -0.01819194f, -0.00386768f, 
    -0.06130963f, 0.01488783f, -0.03702003f, 0.02836351f, -0.06286802f, -0.07706328f, -0.06919530f, 0.06130756f, 
    -0.02634350f, 0.05219927f, -0.05410898f, -0.04167361f, 0.02966519f, 0.00623164f, 0.05974164f, 0.02085035f, 
    0.05204111f, -0.01763670f, -0.05448613f, -0.00902772f, -0.05554425f, -0.07171833f, -0.04777450f, 0.05224087f, 
    0.02653584f, -0.05839125f, 0.00388754f, -0.04773461f, -0.06303640f, 0.03444559f, -0.06293099f, -0.06784029f, 
    0.04165805f, -0.02717133f, -0.03448313f, -0.05166182f, -0.00084011f, -0.03383657f, 0.05251259f, 0.05494886f, 
    -0.04171060f, -0.00674858f, -0.07958462f, -0.05602781f, 0.00528698f, 0.00951591f, 0.02485844f, -0.03472369f, 
    0.06341826f, -0.04427245f, -0.04766437f, -0.04285820f, -0.01717293f, -0.01272300f, -0.08095778f, -0.00755830f, 
    -0.01223622f, 0.05497530f, -0.02168614f, -0.03992982f, -0.04270290f, -0.00930370f, -0.07342642f, -0.03025985f, 
    0.03240080f, 0.00736359f, -0.06129280f, -0.04703877f, -0.07607578f, -0.02773445f, 0.03526895f, -0.05543332f, 
    -0.07204560f, 0.03724469f, 0.03261383f, -0.06270010f, -0.04112006f, -0.06095121f, 0.04823449f, -0.04273926f, 
    -0.07416169f, -0.06919471f, -0.02484246f, -0.06899841f, 0.06267141f, -0.04950860f, -0.01292506f, 0.02978641f, 
    -0.00340432f, -0.00353590f, -0.02543505f, 0.04955283f, -0.03316430f, -0.06740252f, -0.03927841f, 0.05996726f, 
    -0.21193029f, -0.03490067f, -0.00526698f, 0.05092917f, 0.10147206f, 0.08130644f, -0.05492169f, 0.05964417f, 
    -0.01787758f, 0.00264896f, 0.19100179f, 0.11650953f, 0.09859990f, 0.01854493f, -0.17211777f, 0.12838759f, 
    0.03150238f, 0.11520816f, 0.05848820f, 0.12096608f, -0.05371797f, 0.01084430f, -0.10720729f, -0.02090541f, 
    -0.09946129f, -0.16362260f, -0.05641473f, 0.14569111f, -0.19627126f, 0.05451648f, 0.15048325f, -0.00360146f, 
    0.00553699f, -0.05214943f, -0.16280249f, -0.01975132f, -0.08294877f, -0.11816379f, -0.02446044f, 0.06122223f, 
    0.08126613f, -0.06408620f, 0.05048112f, -0.10404714f, 0.19424994f, 0.16924152f, 0.13398345f, -0.12091203f, 
    -0.11847167f, 0.09943893f, 0.04898331f, -0.21127039f, -0.02199119f, 0.01379750f, -0.06417876f, -0.07466957f, 
    -0.08090060f, -0.07242890f, -0.14480484f, -0.03631439f, 0.33281472f, -0.24152265f, -0.16833289f, 0.25454175f, 
    -0.07680853f, -0.06482963f, 0.07688909f, 0.05381606f, 0.00240485f, 0.10846130f, 0.13319220f, 0.02024999f, 
    0.11974997f, 0.02212846f, -0.05952000f, 0.05573294f, 0.29972073f, -0.00551233f, 0.13346814f, 0.03263557f, 
    0.12696645f, -0.02371286f, 0.14466165f, 0.15576370f, -0.07072853f, -0.03467448f, 0.29617161f, 0.20505393f, 
    0.06628038f, -0.00361014f, 0.21405812f, 0.09768637f, 0.04841924f, -0.00278501f, 0.00426811f, -0.10683149f, 
    0.02887267f, 0.05308864f, -0.03154263f, -0.23653047f, -0.03350892f, -0.03234420f, -0.13148722f, -0.03336242f, 
    0.03836355f, 0.07391515f, 0.34721300f, 0.20680808f, -0.20175250f, -0.06372259f, -0.01305932f, -0.03224190f, 
    0.11648384f, 0.24148415f, 0.11323495f, 0.13806912f, 0.01179871f, -0.08611732f, 0.10267625f, 0.03769442f, 
    -0.17764698f, 0.25141090f, 0.01401130f, 0.00469895f, 0.02359869f, -0.21541864f, 0.04367322f, -0.08263381f, 
    0.01412622f, -0.11745353f, -0.07070323f, -0.14238834f, -0.12697688f, -0.18223992f, -0.09873332f, -0.16220142f, 
    -0.00408404f, 0.04092548f, 0.02436813f, 0.05306219f, 0.08233568f, 0.30182937f, 0.07162236f, 0.05278184f, 
    -0.22740977f, -0.01617996f, 0.38366511f, 0.10204697f, 0.11397581f, -0.00723475f, -0.20734632f, -0.01922365f, 
    -0.02991618f, -0.04450452f, -0.02866551f, 0.07442411f, -0.12476745f, 0.03863781f, 0.00875676f, -0.20077965f, 
    -0.05441562f, 0.12250018f, -0.21196970f, 0.18615824f, 0.00546733f, -0.05691922f, 0.05863389f, 0.06062237f, 
    -0.09907833f, -0.18255734f, -0.07209228f, 0.17889266f, -0.01094936f, 0.08987477f, 0.00217345f, -0.07544485f, 
    0.04580718f, -0.14778411f, -0.07062766f, 0.02895680f, -0.09044734f, -0.11717217f, 0.18939079f, -0.05577043f, 
    -0.10357943f, 0.21522371f, 0.13270186f, 0.02601769f, 0.01555268f, 0.02950919f, 0.06656279f, 0.06385770f, 
    -0.01480987f, 0.04520638f, 0.03269388f, 0.05260849f, -0.05249533f, -0.06755003f, 0.03056495f, 0.03949896f, 
    -0.01365868f, 0.03276297f, 0.02510018f, -0.05427088f, -0.06859015f, -0.05517128f, -0.04179281f, -0.00995593f, 
    0.02123623f, 0.00746572f, -0.02867359f, -0.07477379f, 0.01824275f, -0.02950276f, 0.06374507f, 0.04490336f, 
    0.01520852f, 0.00144248f, 0.05516599f, 0.05511295f, 0.03819109f, 0.05848831f, -0.01794153f, -0.03931735f, 
    -0.01031974f, -0.02934744f, 0.01079919f, -0.00023446f, -0.02022920f, -0.06495319f, -0.03914796f, 0.01963724f, 
    -0.05307463f, 0.00964809f, 0.00874404f, -0.01302346f, 0.03935645f, 0.05208640f, -0.06715199f, -0.01132542f, 
    -0.01840475f, -0.01374560f, -0.04921612f, 0.03087511f, -0.03185093f, 0.01081655f, -0.06191834f, -0.03782298f, 
    -0.04984020f, 0.01260334f, -0.04284342f, -0.04826247f, -0.02333075f, 0.01066239f, 0.05842622f, 0.02352621f, 
    -0.07596343f, -0.04135207f, -0.02045264f, 0.03980934f, -0.01817780f, -0.06930765f, 0.00889070f, 0.01686278f, 
    -0.04459999f, -0.03527240f, -0.04040836f, 0.01533333f, -0.01450134f, 0.06232381f, -0.06137201f, 0.05649947f, 
    -0.06020784f, 0.01355371f, -0.04556587f, -0.00044604f, 0.00696808f, -0.03699469f, -0.01965322f, 0.04683927f, 
    0.00910603f, 0.02634203f, -0.08304350f, -0.06287287f, -0.00621919f, 0.04177141f, -0.04527634f, -0.04915445f, 
    -0.04887600f, 0.05307408f, -0.01311647f, -0.00010018f, 0.05829778f, -0.03863962f, -0.02057547f, 0.06132296f, 
    -0.05031135f, 0.04765471f, -0.04123101f, 0.05375307f, -0.05041109f, -0.05331537f, -0.07418624f, 0.03431252f, 
    -0.06316114f, -0.01385228f, 0.06661148f, 0.05797785f, 0.04124097f, -0.06893602f, -0.05759657f, -0.00244926f, 
    -0.01457355f, 0.00532398f, 0.03375701f, 0.02230463f, 0.03747170f, -0.00968892f, -0.05489485f, 0.00131540f, 
    -0.04267054f, -0.02456930f, -0.04024527f, 0.01841598f, -0.06468290f, -0.02471185f, 0.06643499f, -0.01215975f, 
    0.00834048f, 0.03273894f, -0.02206535f, -0.07759102f, 0.00244779f, 0.02359811f, -0.06250464f, -0.08111659f, 
    -0.06764673f, -0.06695688f, 0.07108287f, 0.02844001f, 0.05846108f, 0.01782773f, -0.06425843f, -0.05117222f, 
    0.01661785f, -0.01875952f, 0.02241926f, 0.01561327f, 0.02211200f, -0.06130874f, 0.04898966f, 0.02573569f, 
    -0.05318700f, -0.08444384f, -0.06473531f, -0.03029741f, 0.05719572f, -0.04622597f, -0.03733727f, -0.00824210f, 
    0.02817265f, 0.01357301f, 0.02767304f, 0.03259046f, -0.01862587f, -0.00622330f, 0.00629846f, -0.02304542f, 
    -0.06349135f, -0.01466609f, -0.04687694f, -0.01707273f, -0.01536014f, 0.03051775f, -0.08503401f, -0.04743462f, 
    -0.06945416f, 0.00417574f, -0.06599161f, -0.05010203f, -0.00504921f, 0.05693578f, -0.04085760f, -0.01540030f, 
    -0.01298324f, 0.06301793f, -0.21764950f, 0.15954730f, 0.16717508f, -0.02475710f, -0.04170035f, -0.08237104f, 
    -0.03360967f, -0.09267946f, 0.05187265f, -0.04665862f, 0.46899399f, 0.15961057f, 0.27017248f, 0.39515525f, 
    0.12178496f, -0.05561818f, 0.02823571f, 0.08125120f, -0.11613116f, -0.01816208f, 0.03463062f, 0.09740604f, 
    -0.08101489f, -0.14578789f, 0.16976179f, 0.17866391f, 0.10499684f, 0.00285531f, -0.04791485f, -0.08207649f, 
    -0.02674963f, 0.04722625f, -0.01372516f, 0.02013348f, -0.03164004f, -0.24737735f, -0.03359218f, 0.18103528f, 
    -0.08368507f, 0.16992146f, 0.05535043f, -0.15610927f, -0.08762517f, 0.07522038f, 0.06250121f, 0.18913347f, 
    0.15191866f, 0.00440643f, -0.05689709f, -0.13917835f, 0.03306498f, 0.08092931f, 0.01194779f, -0.10838220f, 
    0.11304958f, 0.03176882f, -0.07125256f, -0.00646871f, 0.06932570f, -0.07465801f, -0.03249703f, -0.00420320f, 
    0.04934986f, 0.10766511f, -0.07516111f, 0.12346434f, -0.03397245f, 0.15649763f, 0.05746465f, -0.06883009f, 
    -0.00828784f, 0.01583105f, 0.08887278f, 0.20557711f, -0.12674168f, -0.05101882f, -0.01564768f, -0.00980943f, 
    0.00493371f, -0.18564582f, 0.04040973f, -0.13933598f, -0.15375656f, 0.06689835f, -0.07852805f, 0.29842314f, 
    -0.02439826f, -0.17891957f, 0.07854219f, -0.21366033f, 0.00132521f, 0.02598689f, -0.08737086f, 0.03015554f, 
    -0.23113325f, 0.10129962f, -0.21304230f, 0.18000837f, 0.04697060f, -0.03977099f, 0.10306828f, 0.05652733f, 
    -0.06416020f, 0.09404626f, 0.01618758f, 0.21976267f, 0.65599799f, 0.13725717f, 0.19844946f, 0.19479640f, 
    -0.08954249f, -0.18885247f, 0.08435723f, -0.08205310f, -0.06473535f, 0.07053893f, 0.00837933f, 0.03702123f, 
    -0.24040654f, 0.35196939f, -0.06098315f, 0.14912441f, -0.02030429f, -0.02442346f, 0.12615210f, 0.01262327f, 
    -0.07143973f, 0.10279319f, -0.12706311f, 0.10617293f, -0.14189406f, 0.09263949f, -0.05130879f, 0.01575521f, 
    -0.10989636f, 0.10632326f, 0.01909988f, 0.03229995f, 0.01131728f, -0.08311018f, -0.05796230f, -0.17630556f, 
    0.09694222f, 0.03043576f, 0.10105871f, 0.14187755f, -0.12263986f, 0.08271471f, -0.04621904f, -0.06621566f, 
    -0.04428586f, 0.05117757f, 0.07258608f, 0.02912258f, -0.25930625f, -0.16016769f, 0.35771897f, 0.01939463f, 
    0.29380843f, 0.15320247f, -0.03586340f, 0.04862623f, 0.03400893f, -0.10322252f, -0.03042140f, -0.09777181f, 
    -0.40320745f, 0.06796645f, 0.30268961f, 0.30889162f, 0.16477120f, -0.03061043f, 0.05709600f, 0.01928812f, 
    -0.11838196f, 0.03049074f, 0.07945616f, 0.16221109f, -0.21249565f, -0.00728960f, 0.07325830f, 0.21639204f, 
    0.07236449f, 0.00389018f, -0.21260314f, 0.08028106f, -0.06267354f, 0.12914784f, 0.13795426f, -0.06353088f, 
    -0.06035832f, -0.05236263f, -0.05326838f, 0.01198626f, -0.04908398f, 0.00997433f, -0.04649355f, 0.05120005f, 
    0.05372627f, -0.01852429f, -0.04773505f, 0.05799653f, -0.00170737f, 0.04342015f, 0.06504745f, 0.00750902f, 
    -0.00615735f, 0.06552346f, -0.07214876f, 0.03222016f, -0.00373825f, -0.00637365f, -0.02513739f, -0.05191995f, 
    -0.06721552f, -0.06514340f, 0.02938904f, 0.00574870f, -0.06679943f, -0.06503950f, 0.02878472f, -0.01394737f, 
    -0.04768023f, -0.02823319f, -0.00256449f, 0.02375083f, -0.04828426f, 0.05800382f, 0.02536252f, -0.03694864f, 
    0.00390881f, 0.04905257f, -0.01926287f, -0.06256908f, -0.05727437f, -0.03453744f, 0.01789479f, -0.02401111f, 
    -0.06048313f, -0.00044319f, -0.03963882f, 0.06001606f, 0.02926284f, -0.06645460f, 0.03968985f, -0.03277161f, 
    0.06801976f, -0.06384924f, 0.00922491f, 0.06048923f, -0.05120198f, 0.03498913f, 0.06649986f, -0.05469075f, 
    -0.07277166f, 0.06524887f, 0.03485323f, -0.00488086f, -0.02354241f, 0.02053007f, -0.00380223f, 0.02947088f, 
    -0.06015282f, 0.04020010f, -0.04723426f, -0.06420947f, 0.01950493f, 0.05614517f, 0.00664205f, -0.04497591f, 
    0.03250670f, -0.00850475f, 0.03353694f, -0.01684501f, -0.05247755f, 0.05873131f, -0.06007200f, -0.02597564f, 
    -0.00828269f, -0.01832417f, -0.05665866f, 0.00912731f, -0.00793386f, -0.00575091f, -0.07260759f, -0.00064210f, 
    -0.07090937f, -0.04629760f, -0.04724005f, 0.06564356f, 0.03062524f, 0.00758864f, -0.05381649f, -0.02219953f, 
    -0.01230445f, -0.05673419f, -0.04260359f, 0.00625414f, 0.03181401f, 0.00145729f, 0.00998979f, -0.03828366f, 
    -0.00061809f, 0.06007365f, 0.06212471f, 0.00859063f, -0.05446220f, 0.01452073f, -0.02194646f, -0.03983715f, 
    -0.04481050f, -0.04661186f, 0.05121617f, -0.03233686f, -0.04753221f, -0.03095553f, -0.00076816f, -0.02923214f, 
    0.03268880f, 0.00078499f, -0.02013610f, -0.07297380f, -0.04452308f, -0.02947744f, -0.03156232f, -0.03508817f, 
    0.03734345f, 0.00728211f, -0.06864598f, 0.01267798f, -0.01482463f, 0.06249686f, -0.06794731f, -0.01450847f, 
    0.06413391f, -0.07480639f, 0.02833713f, -0.02518555f, -0.00459205f, 0.00686226f, -0.03563792f, -0.06938688f, 
    0.05282624f, 0.06328905f, -0.02871875f, -0.06583211f, -0.06749269f, 0.01532052f, -0.07671334f, 0.02284338f, 
    0.01686133f, -0.03760365f, -0.00368437f, 0.06635008f, -0.02292889f, 0.01814882f, -0.00189048f, -0.00407331f, 
    0.00445480f, -0.06371708f, -0.07336903f, -0.07604648f, -0.02000801f, -0.07036222f, 0.03785583f, 0.02983563f, 
    -0.06090552f, 0.00337761f, 0.00422549f, -0.06729848f, 0.02741616f, -0.03779949f, -0.06734672f, 0.01053450f, 
    -0.01707591f, 0.02518386f, 0.02317561f, -0.04592964f, -0.04176623f, 0.06221458f, -0.06865049f, 0.00748488f, 
    0.00975991f, -0.04014361f, -0.06273799f, 0.05889787f, -0.02664428f, -0.00191822f, 0.00535318f, 0.04408980f, 
    -0.05187077f, 0.03830177f, -0.05939549f, -0.04871741f, 0.03704216f, 0.01578647f, 0.05821199f, -0.00863755f, 
    0.04550401f, -0.05148371f, -0.03513386f, -0.05279644f, -0.07851736f, -0.04259847f, -0.00136181f, -0.01216143f, 
    -0.00251578f, -0.00518426f, -0.01558454f, -0.05005845f, 0.04146406f, -0.00967909f, -0.01265163f, 0.01378419f, 
    -0.06631184f, 0.05377309f, -0.06765512f, -0.05255270f, -0.01375910f, -0.00597254f, -0.05432372f, -0.06486387f, 
    -0.04525757f, 0.01550338f, 0.03990659f, 0.04311218f, -0.06812812f, 0.04774361f, -0.02568859f, 0.03741171f, 
    -0.01422416f, 0.02495592f, 0.02958753f, -0.06513117f, 0.01021162f, 0.00264081f, 0.03746967f, -0.02585118f, 
    -0.01863630f, -0.06901602f, -0.06653406f, 0.04792713f, -0.00904091f, 0.00108924f, 0.05243220f, -0.00162880f, 
    0.05458318f, -0.06617113f, 0.05563561f, -0.08084889f, 0.05283467f, -0.07307062f, 0.01510784f, 0.00729429f, 
    0.01048088f, 0.03960478f, 0.02730859f, -0.04389461f, 0.05891846f, 0.05229855f, -0.02345872f, -0.04477318f, 
    -0.02818301f, 0.02174597f, -0.07493277f, -0.00175388f, 0.05908122f, -0.05537216f, 0.06745441f, -0.04677650f, 
    -0.04308384f, 0.05780986f, 0.00369120f, -0.02771224f, 0.03677795f, 0.01597663f, 0.00352365f, 0.00318256f, 
    -0.06720528f, -0.02798483f, -0.04424363f, -0.00356890f, -0.04524878f, -0.03377268f, -0.00723006f, -0.07351590f, 
    -0.04472766f, 0.06261353f, 0.03842154f, 0.00990041f, -0.01402351f, -0.04914511f, 0.02081770f, 0.02390837f, 
    -0.00829046f, 0.01398616f, -0.06342234f, -0.02581491f, -0.05503021f, 0.04435239f, -0.01889932f, 0.03780046f, 
    0.01157599f, 0.00004822f, -0.01055474f, -0.05875098f, -0.01517663f, 0.00713593f, -0.00427364f, -0.06577758f, 
    -0.06601978f, -0.04913330f, 0.01484604f, -0.06596663f, 0.00132554f, 0.04925267f, -0.05112075f, 0.01663611f, 
    0.04651369f, 0.04605381f, 0.04442820f, 0.06731607f, 0.02425390f, -0.06570545f, -0.04190714f, -0.01495230f, 
    -0.07522337f, -0.05942841f, 0.03042305f, -0.00741574f, 0.05015180f, 0.04085521f, -0.06612968f, -0.01540776f, 
    -0.04393475f, -0.01563095f, 0.04653050f, -0.03228893f, 0.04018335f, -0.08341829f, 0.05617462f, -0.01873348f, 
    -0.00472688f, -0.06871027f, -0.04277166f, -0.01733235f, -0.00948582f, 0.02812148f, -0.07396661f, -0.08109722f, 
    0.04147000f, -0.03254151f, -0.01743846f, 0.05876328f, 0.02467439f, -0.01830630f, -0.03910097f, -0.01877911f, 
    -0.03299198f, -0.01911761f, 0.05479348f, -0.05098680f, 0.06563347f, 0.03466059f, 0.05854297f, -0.05541555f, 
    -0.01965373f, 0.04265746f, 0.01799313f, -0.05577930f, -0.01072238f, 0.01106183f, -0.02106312f, 0.00360222f, 
    -0.03736442f, 0.13538367f, -0.02932628f, 0.07867207f, 0.19348215f, 0.01912163f, 0.07769624f, 0.02770531f, 
    0.02600945f, 0.16402289f, 0.08879825f, -0.13901529f, 0.04406391f, 0.08141593f, 0.03638021f, -0.01416971f, 
    -0.06153236f, 0.21104568f, 0.07998336f, 0.05070323f, -0.08374292f, 0.14812905f, -0.10929887f, -0.04760530f, 
    -0.32784364f, -0.15957548f, -0.02412780f, 0.11412697f, -0.24405423f, 0.05435282f, -0.00411547f, -0.20895737f, 
    -0.00873416f, -0.12063868f, -0.14049992f, -0.11530048f, 0.15127499f, -0.29499674f, -0.23273569f, 0.15887317f, 
    0.12340623f, -0.00534268f, 0.14405423f, -0.26068366f, -0.09165193f, 0.05479278f, 0.08385983f, 0.00004412f, 
    0.29244572f, 0.05316389f, -0.10036924f, -0.13945051f, -0.21713375f, -0.06225098f, 0.04736684f, -0.19233619f, 
    -0.01413011f, -0.07419105f, 0.00878329f, -0.07310094f, -0.25548333f, 0.00778480f, -0.35076144f, 0.08005920f, 
    0.02087058f, 0.13339894f, -0.01078681f, 0.04260605f, 0.17692079f, -0.01389573f, 0.25765345f, -0.02791503f, 
    0.12572657f, 0.15181184f, -0.01929488f, -0.05399629f, 0.09562527f, 0.10979373f, 0.05173943f, 0.08103539f, 
    -0.12775041f, 0.02297818f, -0.00957907f, 0.15485650f, -0.13222933f, 0.13333473f, 0.03596380f, -0.04195273f, 
    -0.05711343f, -0.06278168f, -0.01550041f, -0.00381468f, -0.08473569f, -0.01712809f, -0.12523267f, -0.22599296f, 
    -0.03891131f, 0.30808908f, -0.16654967f, 0.10979086f, 0.08490196f, 0.03047731f, 0.04440136f, 0.16403279f, 
    -0.00797994f, 0.09898601f, 0.06273759f, 0.16807593f, 0.30339959f, -0.28639820f, 0.53450727f, -0.26612720f, 
    -0.00233880f, 0.04598663f, 0.19444072f, 0.05803329f, -0.00078971f, 0.08994264f, 0.13392159f, 0.09756543f, 
    0.06517634f, 0.45033336f, 0.17561622f, -0.06600334f, 0.00534701f, -0.04230031f, -0.04302316f, -0.12464100f, 
    0.05650986f, -0.06961117f, 0.07566690f, 0.00935346f, 0.10666021f, 0.21295890f, -0.13507079f, 0.02568424f, 
    0.03398626f, -0.00180971f, -0.00214151f, 0.01190003f, -0.04896194f, -0.00350300f, 0.18454342f, -0.03449590f, 
    0.11826769f, 0.18032651f, 0.11006654f, -0.19518523f, -0.01557431f, -0.16757028f, 0.00419784f, 0.06224940f, 
    -0.17849652f, 0.01705004f, 0.00921703f, 0.15457265f, 0.25836104f, -0.36354098f, 0.15597510f, 0.01072898f, 
    -0.02384602f, -0.04193220f, 0.09566032f, -0.06660786f, -0.05868558f, 0.13137357f, 0.04946305f, 0.07175632f, 
    -0.19307880f, 0.45811781f, -0.12931615f, -0.04804467f, -0.06610210f, -0.09816314f, 0.11146750f, 0.04770130f, 
    -0.11738160f, 0.16111666f, 0.19181798f, -0.08650190f, 0.02766046f, -0.37981558f, 0.05269124f, 0.09361691f, 
    -0.05688317f, -0.10421582f, 0.08495805f, -0.03038877f, 0.08197504f, 0.07660466f, 0.14469133f, 0.15537849f, 
    -0.01392465f, 0.00806118f, 0.14666760f, 0.10935932f, 0.00668836f, -0.05091827f, 0.03367312f, -0.01416676f, 
    -0.03897557f, -0.10766963f, -0.18906666f, -0.17707169f, -0.49042445f, 0.67041814f, 0.07707389f, 0.17227995f, 
    0.17105822f, 0.13588637f, -0.00104443f, 0.00719211f, -0.15038717f, 0.01468712f, 0.09379559f, 0.03879317f, 
    -0.03805363f, -0.15108435f, -0.19534528f, -0.22156391f, 0.05380321f, 0.17838357f, 0.03531395f, -0.04343475f, 
    0.21374476f, -0.04398670f, -0.09515271f, -0.02573592f, -0.02485367f, -0.15206072f, -0.02037596f, -0.03886130f, 
    0.06818780f, -0.17099097f, 0.08731595f, -0.00251459f, -0.04040642f, 0.11455455f, 0.03955629f, -0.14743921f, 
    -0.05005463f, -0.05458613f, 0.09665354f, 0.05509953f, -0.08445820f, 0.01190684f, 0.06068301f, 0.11313406f, 
    -0.05755223f, -0.06161151f, -0.03235298f, -0.00207164f, -0.23271061f, 0.03090806f, -0.28001684f, 0.12260827f, 
    -0.01061026f, -0.02768556f, 0.03776811f, 0.10186077f, 0.08540259f, 0.03158417f, 0.10748991f, 0.05049520f, 
    -0.12957779f, -0.02371396f, 0.15437178f, -0.00270949f, 0.07008817f, 0.06064580f, 0.01615617f, 0.11313526f, 
    -0.19990294f, -0.13445431f, 0.02475099f, 0.01354832f, -0.15031762f, 0.04478842f, 0.12032446f, -0.28272268f, 
    -0.13084495f, 0.06335869f, -0.08783383f, -0.04341444f, -0.23628461f, -0.25994205f, -0.12347381f, -0.27732691f, 
    0.35128909f, 0.37257269f, 0.25455114f, 0.15989898f, 0.06358804f, 0.01149694f, 0.02378704f, 0.10036310f, 
    0.18912756f, 0.32655001f, 0.14040586f, 0.05500260f, -0.10712826f, 0.02073856f, -0.30057791f, -0.08258078f, 
    -0.13419412f, 0.03548716f, 0.01825006f, 0.09141998f, 0.18012378f, -0.00449352f, 0.04478011f, 0.19855274f, 
    0.33393136f, 0.17648461f, 0.23520157f, 0.07682835f, 0.02588258f, -0.00405238f, 0.06863983f, -0.07160071f, 
    0.08632910f, -0.10405724f, 0.03194708f, 0.11043177f, 0.11860529f, 0.00882692f, -0.03798697f, -0.01076453f, 
    0.08421072f, -0.06472442f, -0.00317820f, 0.07056024f, -0.11564413f, -0.08617915f, -0.07872156f, -0.06322432f, 
    0.15151122f, 0.25466752f, 0.33888429f, -0.01428739f, 0.09649753f, -0.03316965f, -0.01765631f, 0.10983932f, 
    0.02337058f, -0.02898769f, 0.05977586f, 0.19010317f, 0.19320223f, -0.25635982f, -0.32195103f, -0.12198281f, 
    0.01099067f, -0.23016480f, 0.08661339f, 0.02443783f, -0.08631744f, -0.04708765f, -0.02948946f, 0.03706471f, 
    0.05391216f, 0.22628662f, 0.40433991f, 0.21045032f, -0.20616214f, 0.06199644f, -0.03957283f, 0.07631719f, 
    -0.01267145f, 0.09840885f, 0.11499725f, -0.03145534f, 0.04571182f, -0.17564178f, 0.05799188f, -0.28109169f, 
    0.11100999f, 0.00997000f, 0.18807760f, -0.04357857f, 0.12599884f, -0.00191510f, -0.25103977f, -0.01236606f, 
    0.07314967f, 0.02804956f, 0.14616017f, 0.00456015f, 0.00452549f, 0.05871703f, -0.01977945f, -0.10689037f, 
    0.13893047f, -0.05610984f, -0.09701560f, 0.01491379f, -0.47622034f, 0.15895765f, -0.02851677f, -0.20120952f, 
    0.16566387f, 0.03412158f, 0.18916081f, -0.16764767f, -0.17415142f, 0.04357805f, 0.07976300f, 0.06542017f, 
    0.15332124f, 0.08370078f, -0.06061972f, -0.04516914f, 0.21523650f, -0.01221421f, -0.00478104f, 0.14377056f, 
    -0.07715260f, -0.04368132f, 0.06365351f, 0.14171451f, -0.30024388f, -0.22595882f, -0.14844161f, -0.49239820f, 
    0.00397512f, -0.04598543f, 0.07209529f, 0.33961323f, -0.04317989f, -0.08162513f, 0.04778503f, -0.09726073f, 
    0.06490780f, -0.02682927f, 0.01815414f, 0.20495982f, -0.10693748f, -0.07263812f, -0.03406189f, 0.01028063f, 
    0.04528220f, 0.10154819f, 0.04106447f, 0.06965737f, -0.78737652f, 0.08750545f, -0.10141861f, -0.03032329f, 
    -0.09310425f, 0.32800332f, 0.00952602f, 0.03626435f, 0.00036782f, -0.24321181f, -0.06190992f, 0.08314537f, 
    -0.03577922f, -0.11962283f, 0.07986506f, -0.04698944f, -0.07333501f, 0.06381941f, -0.04952456f, -0.09268754f, 
    -0.10177957f, 0.08876379f, -0.00015830f, 0.03219033f, -0.05013097f, -0.00471830f, -0.45828560f, -0.57954800f, 
    0.05360009f, -0.10512681f, -0.09470855f, 0.15531586f, -0.11296387f, -0.08264388f, 0.00320862f, -0.12547097f, 
    0.16773674f, 0.21454284f, 0.23261158f, 0.13277024f, -0.10326067f, 0.12846740f, 0.01899407f, -0.03534261f, 
    0.13321446f, 0.17770077f, -0.09025422f, -0.17025551f, -0.20004317f, 0.10944782f, -0.56508422f, -0.22283427f, 
    0.04957740f, -0.06727653f, -0.11150715f, 0.12479712f, 0.35535353f, -0.01054450f, 0.00161617f, -0.16234352f, 
    0.40327835f, 0.01346037f, 0.27068669f, 0.24644350f, -0.11254467f, 0.10431580f, 0.07651684f, 0.07548689f, 
    0.17025633f, 0.07088359f, 0.04319097f, 0.03157499f, 0.08006981f, 0.01345393f, 0.10156965f, -0.00117303f, 
    0.00239129f, 0.02939750f, -0.03299991f, 0.06338455f, -0.00253223f, -0.05757880f, 0.06608152f, 0.01638543f, 
    0.11068353f, 0.29796991f, 0.03007794f, 0.13050814f, -0.06057788f, -0.02520910f, 0.00627262f, 0.14357764f, 
    0.04414609f, 0.00572953f, 0.08259846f, -0.02487596f, 0.44433364f, -0.10122673f, -0.07476863f, 0.36759317f, 
    0.01575585f, -0.05978149f, 0.05866716f, 0.08356270f, -0.02127010f, -0.11334144f, -0.04643603f, -0.06909682f, 
    0.18248866f, -0.11298212f, -0.10622302f, -0.08462536f, 0.01052178f, 0.06768920f, -0.08717182f, 0.01883738f, 
    0.03496438f, 0.05651939f, -0.21085967f, -0.19223240f, 0.25480846f, -0.64236200f, -0.31521332f, -0.10098070f, 
    0.05976674f, 0.15145446f, 0.05913110f, -0.01026861f, 0.04886557f, -0.10831627f, -0.00436868f, -0.00168301f, 
    0.01265690f, 0.01888360f, -0.07793029f, -0.07479984f, 0.00874602f, 0.04103215f, -0.08648656f, -0.04364149f, 
    -0.01666796f, -0.03045616f, -0.06515055f, 0.00050240f, -0.09247855f, -0.06076620f, -0.05464714f, -0.07223374f, 
    -0.09037355f, -0.04338830f, 0.02160558f, 0.01893996f, -0.02831073f, -0.08411016f, 0.04067348f, -0.05549298f, 
    -0.06234385f, 0.04384164f, -0.06748869f, -0.00164554f, -0.02640774f, -0.03950904f, 0.02473534f, -0.01642325f, 
    -0.03671623f, 0.01362399f, -0.02164479f, -0.05670279f, 0.00826699f, 0.03975019f, 0.02878981f, 0.00851841f, 
    0.00967932f, -0.02619184f, 0.00960915f, -0.06384403f, -0.02776026f, -0.06654214f, -0.05155696f, 0.00771578f, 
    -0.08752013f, 0.00846818f, 0.03994668f, -0.04514139f, 0.01329287f, 0.01468412f, -0.07389247f, -0.01542015f, 
    -0.03811457f, -0.04084115f, -0.04709817f, -0.01323796f, -0.07456759f, 0.01206429f, -0.09163687f, -0.05328228f, 
    -0.00672740f, -0.06576022f, 0.03536635f, -0.07282577f, -0.03100454f, -0.00473562f, -0.09310422f, -0.07817469f, 
    -0.00646455f, -0.01995420f, -0.00266946f, -0.01931388f, 0.04110548f, -0.05735214f, -0.07847659f, -0.05065533f, 
    0.03244654f, -0.07490400f, -0.05377896f, 0.02486403f, -0.06955735f, -0.01597276f, -0.00272780f, 0.02726042f, 
    -0.03874642f, -0.09351083f, -0.03279412f, -0.00210368f, -0.02605124f, -0.00110532f, -0.01752329f, 0.02345062f, 
    -0.03335565f, -0.09018472f, 0.02168968f, -0.03892535f, 0.04810555f, -0.07592415f, -0.00987476f, -0.07580230f, 
    0.02878375f, -0.08189607f, 0.03617803f, 0.01626532f, -0.02244485f, -0.05260370f, -0.04982822f, 0.02641837f, 
    -0.02183115f, -0.08371549f, 0.01260291f, -0.06249768f, 0.03730279f, 0.00777010f, -0.02449893f, -0.03604489f, 
    0.04657007f, -0.02742738f, -0.05646456f, -0.09269407f, -0.09235419f, -0.08013093f, -0.02994229f, -0.00507463f, 
    -0.08085191f, -0.08746273f, 0.00299079f, 0.01104539f, -0.05415082f, -0.04450455f, -0.01076724f, -0.06726977f, 
    -0.05546402f, -0.07923590f, -0.04840980f, -0.04523699f, -0.01245833f, -0.03816875f, -0.02389090f, -0.06906983f, 
    -0.06435689f, -0.09341241f, -0.05471077f, 0.03297444f, 0.03611040f, -0.02166949f, 0.02404038f, 0.00928880f, 
    0.03786084f, 0.00316594f, -0.06219946f, 0.02203912f, -0.06610456f, -0.06769458f, -0.01304227f, -0.05289853f, 
    -0.02202277f, -0.02352315f, -0.03002500f, 0.00573025f, -0.03917760f, 0.03371016f, -0.08672369f, -0.00651816f, 
    -0.06200090f, -0.03281772f, 0.01178446f, -0.00448771f, -0.02005618f, -0.00570004f, -0.07796179f, -0.06879476f, 
    -0.08585297f, -0.00722241f, -0.08976106f, -0.01394134f, -0.01540915f, -0.04093850f, -0.01292093f, 0.06981239f, 
    -0.00795362f, 0.00271480f, 0.04551775f, -0.05392783f, -0.02176721f, -0.08450653f, -0.04003664f, 0.03768440f, 
    0.02029215f, -0.26406965f, 0.03827168f, -0.06457609f, 0.06155754f, 0.00061341f, -0.07657405f, 0.17700104f, 
    -0.03918622f, -0.00396184f, -0.00134128f, -0.09893315f, 0.10821845f, 0.09674817f, 0.04081709f, 0.17349686f, 
    0.04486369f, 0.30541122f, 0.00457473f, 0.01130987f, 0.08181851f, -0.04168610f, 0.02340610f, 0.11254238f, 
    0.22320738f, 0.07325166f, -0.25150535f, 0.07811516f, -0.07757295f, -0.04413250f, 0.16692784f, 0.03974919f, 
    0.00907527f, 0.09049098f, 0.05192528f, 0.10147954f, 0.14702272f, 0.08032338f, -0.07447470f, 0.05671915f, 
    0.13177650f, 0.06610445f, 0.06954554f, 0.03506998f, 0.04955600f, 0.02146089f, 0.07465268f, -0.00260015f, 
    -0.36725375f, -0.23969306f, -0.13132845f, -0.20452203f, -0.00463554f, -0.03584939f, -0.03534043f, -0.17349009f, 
    -0.02228254f, -0.14775221f, 0.00332755f, 0.18057467f, -0.00135721f, 0.10613085f, 0.01867018f, 0.20900452f, 
    -0.03524650f, -0.07255492f, 0.03494685f, 0.04663381f, 0.00195414f, -0.02294887f, 0.18343136f, 0.04564846f, 
    -0.15825999f, 0.05102147f, -0.02024759f, -0.04418792f, 0.06396349f, -0.00330374f, -0.01351156f, 0.08724966f, 
    -0.09522568f, -0.20022500f, -0.03848176f, 0.03867606f, 0.14207736f, 0.19519882f, 0.36016396f, 0.08775891f, 
    -0.05164856f, 0.16152461f, 0.07950623f, -0.00315751f, -0.06122170f, -0.14135472f, 0.04218821f, -0.11140416f, 
    -0.15780258f, -0.14741890f, -0.09048678f, -0.32399833f, -0.06556597f, 0.23394807f, 0.01338401f, -0.20447683f, 
    -0.09045282f, 0.08653625f, 0.09671259f, -0.14808013f, 0.06657629f, -0.28661069f, 0.06360271f, 0.19615829f, 
    -0.07779141f, 0.19112407f, -0.23135671f, 0.10327432f, 0.06410028f, 0.01690868f, 0.13435498f, 0.01173044f, 
    -0.19450995f, 0.15013318f, -0.23297758f, -0.33666649f, -0.10030495f, -0.31244844f, 0.01363758f, -0.17116356f, 
    0.00924826f, 0.00390846f, -0.04915933f, 0.22328843f, 0.17481196f, -0.14570941f, 0.04759424f, -0.14974359f, 
    -0.06418894f, -0.02890925f, -0.02998103f, -0.05405378f, -0.07993000f, 0.02508633f, -0.13441072f, -0.18206489f, 
    -0.62664962f, -0.49793965f, 0.17456429f, -0.28327730f, 0.00616747f, 0.11764671f, -0.18520762f, -0.05591759f, 
    -0.03872028f, -0.10847048f, -0.03750890f, -0.02241832f, 0.10172814f, 0.22726908f, -0.24709725f, -0.09987678f, 
    0.17976165f, 0.16391873f, 0.04779710f, 0.09163766f, -0.23303610f, 0.02950273f, -0.22672084f, 0.11710361f, 
    0.34791195f, -0.14325541f, 0.14002311f, 0.05077489f, 0.12148709f, 0.17365147f, -0.04753874f, -0.19510759f, 
    0.08986032f, 0.08264414f, 0.13336580f, -0.00565033f, 0.17913713f, 0.29667184f, 0.03135955f, -0.11065088f, 
    0.01701326f, 0.08167796f, 0.19397758f, 0.01108697f, -0.02284068f, 0.04720896f, -0.13080290f, 0.06559756f, 
    0.18697493f, -0.01848638f, 0.08617025f, -0.01006826f, -0.03572409f, 0.15335508f, -0.06383639f, -0.15930612f, 
    -0.14486189f, -0.08286893f, -0.00376197f, -0.02824634f, 0.32992467f, -0.46305877f, -0.21146645f, -0.29014617f, 
    0.16517411f, -0.13135354f, 0.17623919f, -0.18752284f, -0.03276574f, 0.14137201f, 0.06759974f, 0.13914223f, 
    -0.12099984f, -0.04143754f, -0.14123340f, 0.29857281f, 0.14756517f, -0.02638087f, 0.09518830f, 0.22717115f, 
    0.02934740f, 0.22391333f, -0.00405890f, 0.08785740f, 0.21137342f, 0.02935266f, -0.10125328f, -0.07403834f, 
    -0.00319020f, 0.10793719f, 0.00861839f, 0.20381282f, -0.13948295f, -0.01699246f, 0.13457499f, 0.03610429f, 
    0.14802124f, 0.18627009f, 0.06603058f, 0.10859147f, -0.18251890f, -0.12647514f, 0.01796999f, -0.07165574f, 
    0.00712192f, 0.00239158f, -0.02960787f, 0.09629574f, -0.23754391f, 0.06614882f, -0.13495442f, 0.16866054f, 
    0.03260094f, 0.13103098f, 0.01151286f, -0.08700895f, -0.07715654f, 0.02964322f, 0.06176591f, 0.01461153f, 
    -0.04311552f, -0.05569143f, -0.11623862f, -0.10235537f, -0.00127174f, -0.02825951f, -0.17823134f, 0.20019458f, 
    -0.08757306f, -0.02150906f, 0.09130866f, -0.00619117f, 0.06769701f, -0.11145362f, -0.06958874f, 0.11951650f, 
    -0.01443467f, 0.03556345f, 0.03849752f, 0.11748120f, -0.08675566f, 0.07077423f, 0.00355893f, -0.04161010f, 
    0.19661666f, 0.13225757f, 0.16385750f, 0.09173415f, -0.10860086f, 0.02376219f, -0.08699983f, -0.15018751f, 
    -0.01615293f, 0.11708944f, -0.12025071f, -0.03823777f, -0.04644290f, 0.02881424f, 0.03114393f, 0.10715432f, 
    -0.02200992f, 0.05033222f, 0.10367066f, -0.02950334f, 0.04830887f, 0.00268687f, 0.04086038f, 0.08231413f, 
    0.36400375f, 0.20435770f, 0.23082402f, 0.16013929f, -0.19939387f, -0.11385295f, 0.08555037f, 0.03963298f, 
    0.09479071f, -0.00362241f, 0.04913507f, 0.06960866f, 0.09019241f, -0.05184871f, 0.00407576f, -0.04884030f, 
    -0.00075238f, -0.01122057f, -0.07198931f, 0.07413456f, 0.02178808f, -0.04407653f, 0.02242401f, -0.10774540f, 
    0.03744575f, 0.19071104f, 0.17570807f, 0.01145654f, -0.13618666f, -0.10810030f, -0.15492822f, 0.01914651f, 
    0.06381662f, -0.02547865f, 0.02158160f, -0.04583059f, 0.34378567f, 0.07413039f, 0.11723065f, 0.26800439f, 
    -0.17198324f, 0.07973865f, 0.06419043f, 0.13637182f, -0.00402648f, -0.11330267f, -0.21209045f, -0.11225313f, 
    0.45011738f, -0.32084635f, -0.34487954f, -0.01803381f, 0.08903341f, -0.02051693f, -0.17787780f, -0.25466517f, 
    -0.04632000f, 0.07801420f, 0.07786905f, -0.08723341f, -0.05952359f, -0.20380893f, -0.01091160f, 0.21882074f, 
    0.07808650f, 0.07150198f, 0.19380897f, 0.13823742f, -0.01121224f, -0.03275957f, 0.04750321f, -0.02369125f, 
    -0.08016089f, 0.11229701f, -0.07474876f, 0.05127247f, -0.02301800f, 0.06744594f, -0.16655336f, -0.17334443f, 
    -0.01752839f, 0.20868751f, 0.14563227f, 0.10231702f, 0.21284206f, -0.33696792f, -0.04982888f, -0.16383028f, 
    -0.04508980f, 0.00701324f, 0.11516385f, 0.03633200f, -0.06669440f, 0.06043981f, -0.00551378f, -0.03933248f, 
    -0.02363794f, 0.04857874f, -0.27771863f, 0.01849119f, 0.00908931f, -0.11101516f, 0.07231236f, 0.09146485f, 
    -0.11588467f, 0.07210774f, -0.06391271f, -0.10807937f, 0.38525295f, 0.24803954f, -0.15880033f, 0.01190113f, 
    0.11180454f, 0.02590874f, 0.03796836f, 0.04353353f, -0.00678166f, -0.01605448f, 0.01440971f, 0.04716321f, 
    0.09686296f, -0.02889709f, 0.04457511f, 0.10132533f, -0.24636795f, -0.16050915f, 0.03191506f, -0.25584781f, 
    -0.05109046f, -0.01265030f, -0.02196554f, -0.20758009f, 0.10169617f, 0.34382677f, -0.00483509f, -0.04234615f, 
    0.09907126f, 0.25691247f, 0.14638563f, -0.01329464f, 0.05790608f, -0.08788758f, 0.04793730f, -0.09729807f, 
    0.13209032f, 0.10924994f, -0.07448950f, -0.00797951f, -0.05069620f, 0.03764091f, -0.01539932f, -0.17229244f, 
    -0.01255100f, 0.20414537f, -0.02729378f, 0.01824110f, 0.27071166f, 0.18036972f, -0.18256393f, -0.01468611f, 
    0.06824459f, 0.06070198f, 0.04545226f, 0.05984930f, -0.02718293f, 0.14110307f, -0.00546387f, 0.12798125f, 
    -0.15290065f, 0.06764467f, -0.28562626f, 0.29440767f, -0.06642944f, -0.04989316f, 0.08969668f, -0.02410107f, 
    -0.00710007f, 0.12753500f, -0.01917741f, 0.00021464f, 0.44917542f, -0.32403627f, 0.51273191f, -0.00132362f, 
    -0.08291298f, 0.01248993f, 0.05238623f, 0.20179789f, -0.00267185f, 0.07035340f, -0.14369190f, 0.08170407f, 
    -0.24886096f, 0.09914053f, 0.10392953f, 0.10318200f, -0.11049591f, 0.02285264f, -0.20985197f, 0.00756641f, 
    -0.09521549f, 0.03334818f, 0.00615228f, 0.08265512f, -0.05911150f, 0.10341982f, -0.19078334f, 0.01813040f, 
    -0.22094293f, 0.00693200f, -0.09981971f, -0.02589508f, 0.01692954f, -0.07980438f, 0.09531411f, -0.19061603f, 
    0.05322196f, -0.12211640f, 0.18293625f, 0.08213301f, -0.03034651f, 0.01907242f, 0.14660558f, 0.05543333f, 
    -0.13186198f, 0.02970095f, -0.06550191f, 0.08645406f, 0.17327820f, -0.25191951f, 0.26569128f, 0.45705524f, 
    0.05851119f, 0.27190563f, -0.03267255f, -0.02644403f, 0.06247405f, 0.13698658f, 0.06102257f, -0.02286834f, 
    -0.03109230f, 0.17476915f, -0.29578319f, -0.16445868f, 0.10757649f, 0.03209784f, 0.00052205f, -0.03180705f, 
    -0.09320614f, 0.12115771f, 0.01879814f, -0.03236175f, 0.11565345f, -0.01471929f, -0.21102397f, 0.30332091f, 
    0.01961610f, 0.01266337f, 0.00725562f, 0.09587384f, 0.00249107f, -0.06771132f, 0.10086838f, 0.10532806f, 
    -0.04597545f, -0.13091375f, 0.06993096f, 0.04894722f, -0.06440574f, -0.24197254f, -0.12328584f, -0.07532501f, 
    0.09929615f, 0.14799701f, -0.02716659f, 0.11492204f, 0.05107468f, 0.23691182f, 0.15446192f, 0.31397891f, 
    -0.02283523f, -0.13793446f, -0.04341999f, 0.00905926f, -0.04102047f, 0.15051708f, 0.08291986f, 0.02487882f, 
    -0.24371794f, -0.16186637f, -0.02630531f, -0.11928702f, 0.06554290f, 0.18626040f, 0.03874103f, -0.00134992f, 
    -0.00315047f, -0.08135994f, -0.09906270f, -0.09221208f, -0.06819867f, -0.03620059f, 0.03114449f, -0.13882953f, 
    0.01317100f, 0.08837201f, -0.01018872f, 0.02683783f, 0.01972943f, 0.02690932f, 0.03380808f, 0.18439779f, 
    -0.15055396f, -0.15220192f, -0.09170236f, -0.00606510f, -0.04737107f, 0.00257054f, 0.00197981f, 0.01173793f, 
    0.13463786f, -0.01219158f, -0.02887045f, -0.12809484f, 0.00397772f, 0.15637845f, -0.21671888f, -0.05288976f, 
    0.19394545f, 0.09331189f, 0.11781407f, 0.08704891f, -0.08236235f, 0.04089924f, -0.09481896f, 0.06217291f, 
    -0.18010561f, 0.04341865f, 0.09753823f, 0.05063945f, 0.04814246f, 0.05598187f, 0.04434595f, -0.12965992f, 
    0.04313520f, -0.12845090f, -0.04290856f, 0.09550177f, -0.15739506f, -0.04030332f, -0.25224790f, -0.08751224f, 
    0.03407784f, -0.08344034f, -0.21616201f, -0.02760972f, -0.14034738f, -0.09407479f, -0.01220224f, 0.00070458f, 
    0.16536739f, 0.39500287f, -0.07571805f, 0.06792878f, -0.01833905f, -0.03744946f, -0.03347167f, 0.03535349f, 
    0.29960620f, 0.17765868f, 0.10944391f, 0.14141120f, 0.58724320f, 0.39656901f, -0.15485652f, 0.20489475f, 
    -0.11632941f, -0.17812009f, -0.02983813f, -0.09123681f, 0.09245258f, 0.14890034f, 0.00451320f, 0.06268404f, 
    -0.24279305f, -0.00937497f, 0.08830965f, 0.25173220f, -0.02519003f, 0.20046751f, -0.02660831f, -0.22063534f, 
    -0.00111996f, -0.04350370f, 0.03836080f, 0.01799278f, -0.19064049f, 0.15995218f, -0.11650527f, -0.07880826f, 
    0.02577459f, -0.06199853f, -0.07241288f, -0.02297680f, 0.09447227f, -0.11904374f, -0.06016896f, 0.04464391f, 
    0.35266390f, 0.51484972f, -0.00850076f, -0.00423462f, -0.09564558f, -0.09056051f, 0.09002205f, 0.00314761f, 
    0.04831549f, 0.10909533f, 0.02523693f, 0.06900270f, -0.25405592f, -0.40425798f, 0.20983230f, -0.08852214f, 
    0.24325632f, 0.03831188f, -0.01262120f, -0.13188267f, 0.02094842f, -0.18018107f, -0.09652464f, -0.01114740f, 
    -0.31215668f, -0.04515881f, 0.27471095f, 0.14605695f, -0.06937490f, -0.05094019f, -0.00155712f, 0.26980144f, 
    -0.02430317f, 0.10923073f, 0.10402417f, 0.02067897f, -0.29336008f, -0.00742142f, -0.19942656f, -0.00229407f, 
    0.15452524f, 0.03053106f, 0.02637753f, -0.04652320f, -0.00965943f, 0.07322031f, 0.11826943f, 0.08567601f, 
    -0.05828566f, 0.03462155f, -0.00479390f, -0.03348687f, -0.02255432f, 0.00870220f, 0.05266655f, -0.06615397f, 
    0.03508637f, 0.05278609f, 0.00475726f, -0.07772375f, -0.00814383f, 0.05220008f, 0.05577902f, -0.04824696f, 
    -0.03659207f, 0.03993278f, 0.01551264f, 0.03095149f, 0.03849528f, -0.07775051f, -0.05304050f, 0.04245279f, 
    0.02658675f, -0.06270901f, -0.07559669f, -0.01619698f, 0.02634234f, 0.02637350f, -0.03646689f, 0.05478612f, 
    0.01088270f, 0.00477840f, 0.05727372f, -0.02803865f, -0.00087928f, -0.03979633f, 0.05165911f, -0.01880548f, 
    -0.00519277f, -0.01350566f, -0.00796828f, 0.06584463f, 0.00909032f, -0.04784095f, -0.01954346f, 0.00766027f, 
    0.03248802f, -0.02946524f, -0.04407796f, 0.05084415f, -0.01466443f, -0.04001587f, -0.06253649f, -0.04226948f, 
    0.03914955f, -0.07152552f, 0.04621325f, -0.01886105f, -0.01733889f, -0.08273701f, -0.00689355f, 0.04856431f, 
    -0.04852867f, 0.03363654f, -0.05579294f, 0.01556724f, -0.00424508f, 0.04225544f, 0.01334275f, -0.02885734f, 
    0.03546584f, -0.00457039f, 0.01775207f, 0.03289086f, 0.04029511f, 0.02750975f, 0.02130550f, -0.06146749f, 
    -0.01974767f, -0.05995625f, -0.01194356f, 0.03957790f, 0.00879762f, -0.06077914f, 0.00575756f, 0.05592639f, 
    0.04380418f, 0.02986307f, -0.00202373f, -0.04014682f, -0.07257202f, -0.04422692f, 0.04962602f, -0.07103559f, 
    0.01190971f, 0.02239513f, 0.02047047f, 0.01523990f, 0.01267430f, 0.04697880f, 0.05768830f, -0.03987009f, 
    0.01718380f, -0.03889191f, -0.02952085f, -0.01577489f, -0.07594831f, 0.02530949f, 0.05572537f, 0.03032462f, 
    -0.07788796f, -0.04347768f, -0.03354598f, -0.00002477f, -0.07732198f, -0.01148540f, -0.06983598f, -0.02935130f, 
    -0.00124354f, -0.06788394f, -0.02926394f, 0.00884069f, -0.05623417f, 0.00073872f, 0.02243469f, -0.02900984f, 
    0.03662325f, -0.01376182f, 0.01777318f, -0.03926184f, -0.05582169f, 0.00397624f, 0.03330594f, 0.04907885f, 
    0.00594059f, -0.04088400f, -0.01708129f, 0.05077259f, -0.01814550f, -0.06642507f, -0.06823128f, -0.04403905f, 
    0.04729288f, -0.05276705f, 0.04989144f, 0.04314775f, 0.05913435f, -0.06322035f, -0.05318797f, -0.03920407f, 
    0.03315222f, -0.00831552f, -0.08058752f, -0.00705964f, -0.07528821f, 0.05095313f, 0.01225005f, -0.03585710f, 
    0.00315348f, 0.04311153f, -0.02514790f, 0.05829589f, -0.01803151f, -0.01889703f, 0.05870649f, -0.03233894f, 
    0.02494325f, 0.00389637f, -0.05525716f, -0.00868792f, -0.04848500f, -0.00626369f, -0.05457210f, -0.04043389f, 
    -0.03827703f, -0.07640955f, -0.00300110f, -0.05582128f, -0.04071831f, 0.05270687f, 0.03485577f, -0.02233606f, 
    -0.01972158f, 0.02526377f, -0.02049086f, -0.05103946f, -0.02051502f, 0.01146959f, -0.04119547f, 0.01248357f, 
    0.21069425f, 0.11396706f, 0.08072150f, -0.00936975f, -0.05270323f, -0.01616257f, 0.00942641f, -0.12925942f, 
    0.08035127f, 0.07696899f, 0.08687878f, 0.16649266f, -0.14964803f, 0.06344318f, 0.05529282f, -0.28323755f, 
    0.15221940f, -0.08608341f, 0.06497798f, -0.10703162f, 0.05505728f, 0.07081626f, 0.11727972f, 0.04904825f, 
    0.15594013f, 0.22803685f, 0.04450489f, -0.04197376f, 0.21314336f, 0.05812532f, -0.06954376f, 0.09726725f, 
    0.03185359f, 0.12099855f, 0.10908295f, -0.01195299f, -0.01516372f, -0.09734741f, -0.02014536f, -0.01223931f, 
    0.07844387f, 0.14550811f, -0.00518032f, 0.14923048f, 0.15003739f, -0.00199718f, -0.04497681f, 0.13496721f, 
    -0.13689736f, -0.35001227f, -0.26461032f, 0.23562768f, -0.02653598f, 0.03583336f, 0.12334536f, -0.05426475f, 
    0.06505214f, 0.11948837f, 0.09753323f, 0.02781904f, -0.20621710f, 0.21260892f, 0.21029849f, 0.10300602f, 
    0.07648851f, 0.02679701f, -0.02130232f, 0.09582701f, -0.00238440f, -0.01947618f, -0.09284253f, -0.09482828f, 
    0.05154319f, -0.10619678f, 0.00255309f, -0.13667230f, 0.12811953f, 0.06814305f, -0.12231229f, 0.20424670f, 
    0.05886787f, 0.03494987f, -0.20764460f, -0.05244985f, 0.13902628f, 0.12898487f, -0.08598134f, -0.04574350f, 
    0.00811868f, -0.04192347f, 0.00613095f, 0.18690753f, 0.02337778f, -0.09648196f, 0.01832647f, 0.14402983f, 
    0.07040501f, -0.18243718f, 0.05140043f, 0.03683635f, -0.19293980f, -0.09004481f, -0.01018960f, -0.02312452f, 
    0.06872478f, 0.13218717f, -0.13085927f, -0.22927417f, -0.16011454f, 0.32084692f, -0.09836079f, -0.16347300f, 
    -0.15302099f, -0.17048031f, -0.08216710f, 0.12520425f, 0.14469041f, 0.01985997f, 0.00104406f, 0.04672805f, 
    0.13219358f, -0.42092234f, 0.01839468f, -0.07732271f, -0.06597389f, 0.12716486f, -0.11287525f, 0.15268937f, 
    0.01999921f, 0.02299375f, 0.01187361f, 0.02469925f, 0.10854489f, 0.03751655f, 0.12637039f, -0.09450995f, 
    -0.03535911f, -0.02400577f, 0.01176569f, -0.06048185f, 0.13710643f, -0.02929877f, 0.05927433f, -0.06520797f, 
    -0.16732977f, 0.11510729f, -0.44563314f, 0.12893678f, -0.20779699f, 0.06143529f, 0.12470965f, -0.08544504f, 
    0.06493977f, 0.01578794f, -0.08799252f, -0.05338532f, 0.27908006f, -0.06812713f, 0.00308819f, 0.29912695f, 
    0.09092632f, 0.14120565f, 0.33392489f, 0.08367367f, 0.11560524f, -0.08076114f, -0.09785910f, -0.11646698f, 
    0.37471232f, 0.06200380f, 0.06217773f, 0.11751499f, -0.01447201f, 0.06262712f, -0.08265588f, 0.08013573f, 
    0.09810644f, 0.07277563f, 0.05447286f, -0.01214465f, 0.29625016f, 0.02516178f, 0.02194203f, -0.01748078f, 
    0.04351709f, -0.02758090f, -0.02794837f, 0.11270007f, -0.02796091f, -0.11344668f, 0.04648099f, -0.02538792f, 
    -0.10033618f, -0.11603227f, -0.02582982f, -0.03784216f, -0.01134910f, 0.00052293f, 0.00706698f, 0.00095044f, 
    0.08395446f, 0.21093208f, 0.20276706f, 0.18316300f, 0.31575701f, -0.10650279f, -0.08479921f, 0.30696946f, 
    -0.05871648f, 0.07181634f, 0.05832017f, 0.18233426f, 0.10437423f, 0.07501788f, 0.01592810f, -0.01187546f, 
    -0.25436810f, -0.11257594f, -0.05478727f, -0.00011861f, 0.03928632f, 0.10679597f, -0.02375334f, -0.04684428f, 
    -0.00075444f, -0.02121731f, 0.00665922f, 0.06088931f, 0.06342792f, 0.02232730f, 0.03418295f, -0.08436842f, 
    0.06717426f, -0.01776952f, -0.02098991f, -0.03186827f, -0.01451017f, 0.00881824f, -0.03989632f, -0.01757152f, 
    -0.00889558f, 0.01711824f, 0.04653192f, -0.10345805f, -0.01634206f, -0.00660861f, -0.06113189f, -0.05403246f, 
    -0.01060041f, -0.02309686f, 0.05559997f, -0.06635083f, 0.22434184f, -0.07596415f, -0.25642449f, -0.01215583f, 
    0.11199567f, 0.04273121f, 0.19071621f, -0.09703360f, -0.09714079f, 0.10269970f, 0.03641481f, 0.03752892f, 
    -0.16562071f, 0.12514594f, 0.10189475f, 0.04977088f, -0.04430529f, -0.10585282f, 0.10056290f, -0.10249431f, 
    0.09027955f, 0.15946189f, 0.08739211f, 0.14994827f, -0.25632933f, -0.17808899f, -0.21544513f, -0.07068853f, 
    0.11534181f, 0.13799639f, 0.00613969f, -0.09805070f, 0.06864679f, 0.12803423f, 0.00394397f, -0.02440485f, 
    -0.09265238f, 0.15261282f, -0.02138019f, -0.26744989f, 0.06750484f, 0.13011613f, -0.03909062f, -0.02391917f, 
    0.14483836f, -0.00761252f, 0.20143320f, 0.15655573f, 0.27619156f, 0.08950752f, 0.00024927f, 0.23713055f, 
    0.00049106f, 0.21016380f, 0.00819580f, -0.02629874f, -0.06779042f, 0.07561131f, 0.00645346f, 0.07956199f, 
    -0.27174354f, 0.03359610f, 0.03493197f, -0.02591418f, 0.02744912f, 0.16056350f, -0.07789992f, -0.17128262f, 
    0.01313493f, -0.05096560f, -0.01618714f, -0.03436638f, -0.14675523f, -0.09264645f, -0.08700158f, -0.11952800f, 
    -0.10537718f, 0.00820583f, -0.04364979f, -0.01688603f, 0.07262471f, 0.05527939f, 0.11315846f, 0.12150384f, 
    -0.08743613f, 0.12279792f, -0.04725449f, -0.14384963f, -0.08236345f, 0.05972505f, 0.15086028f, 0.03489843f, 
    -0.09278557f, 0.01588788f, -0.02685401f, -0.01534141f, -0.31709695f, -0.22881857f, 0.19859868f, -0.12478801f, 
    -0.03208482f, -0.15028825f, 0.07607770f, -0.02504959f, 0.05201593f, 0.02481458f, 0.00829223f, 0.10950664f, 
    -0.24925525f, -0.32918102f, -0.04510339f, -0.12010231f, 0.03985409f, 0.09522809f, 0.18169066f, 0.21928219f, 
    0.04375523f, -0.00997302f, -0.00336174f, -0.07802489f, -0.19955544f, -0.06446119f, -0.01908598f, 0.06230671f, 
    0.08492230f, -0.03174131f, 0.01124670f, -0.20792918f, 0.06251734f, 0.10745928f, -0.08193197f, 0.15959869f, 
    -0.06746934f, 0.01775772f, 0.05017815f, -0.08367608f, -0.06394935f, -0.07630680f, 0.04852327f, -0.05602886f, 
    -0.08149756f, 0.00109655f, -0.06977533f, -0.05651743f, -0.01122652f, -0.01788050f, -0.02979229f, 0.04924997f, 
    -0.00381644f, -0.01061119f, -0.05046339f, -0.07339496f, -0.07655684f, 0.00539749f, -0.07767381f, 0.02978481f, 
    0.00166342f, -0.06256843f, 0.04260082f, -0.08757150f, 0.04118780f, 0.05387088f, 0.03270049f, -0.07658216f, 
    0.06124862f, -0.03993802f, 0.05071869f, -0.09220803f, 0.02597973f, -0.04924682f, -0.05304148f, -0.04739766f, 
    -0.04916622f, 0.01352839f, -0.04753714f, -0.01158184f, -0.01114567f, -0.02907013f, 0.05775359f, -0.04016878f, 
    0.01086111f, -0.03315495f, -0.03217860f, -0.01977161f, 0.02493013f, -0.04310055f, -0.03720438f, 0.05690429f, 
    -0.04120135f, 0.03888889f, 0.03994823f, 0.01355723f, 0.01777569f, 0.03599276f, 0.02473149f, -0.07033949f, 
    0.02567092f, -0.01652581f, 0.06019247f, 0.04333696f, 0.03423369f, -0.05793976f, -0.00543359f, -0.05895855f, 
    0.00619905f, -0.06202424f, -0.04288082f, -0.00748071f, -0.02521896f, -0.01952433f, 0.03524148f, -0.04514519f, 
    -0.07627747f, -0.04843712f, 0.05477136f, 0.06547420f, 0.05550490f, -0.04834718f, 0.05211594f, -0.05552480f, 
    -0.05096376f, -0.07409621f, -0.04341413f, -0.04500183f, 0.01558065f, -0.03760446f, -0.07146033f, -0.01256950f, 
    -0.06815824f, -0.07600782f, -0.02923026f, -0.05770581f, -0.02440833f, -0.00413207f, 0.03641207f, 0.04731631f, 
    0.03752909f, 0.03751713f, -0.04438603f, -0.05448893f, 0.03619197f, 0.06079362f, 0.02075537f, -0.04320534f, 
    -0.03443772f, -0.00407273f, -0.04264668f, 0.03353935f, -0.04225267f, -0.05679863f, -0.04780969f, -0.01082562f, 
    -0.06810421f, -0.01641790f, -0.00602274f, -0.01945063f, -0.04337012f, -0.01978604f, -0.00961846f, -0.03420066f, 
    -0.05036818f, -0.04289835f, -0.08768553f, 0.05694793f, -0.04350567f, -0.04392730f, -0.01487912f, -0.00452102f, 
    -0.04331939f, -0.01248116f, -0.03818333f, -0.00922954f, 0.01500549f, -0.00446756f, -0.00496776f, -0.03504858f, 
    -0.00456669f, -0.05037399f, 0.06525182f, 0.01220516f, 0.06396194f, 0.04862731f, -0.06376653f, -0.06950684f, 
    0.02661014f, 0.00072933f, -0.03851072f, 0.03743151f, -0.07670806f, -0.01488839f, 0.02634515f, 0.00585277f, 
    -0.06504960f, -0.07207423f, -0.02817849f, -0.06330163f, -0.07095838f, 0.03304286f, -0.02455313f, -0.06891889f, 
    -0.03652894f, -0.06694089f, 0.01008892f, 0.00270151f, -0.05601791f, -0.01231405f, -0.07380963f, -0.00467682f, 
    -0.07001476f, 0.02597254f, 0.04144599f, 0.04639279f, 0.02859264f, -0.05986579f, -0.02462624f, -0.02172131f, 
    0.04819175f, 0.01692194f, -0.02518739f, -0.02971867f, -0.02835074f, 0.02635630f, 0.06574982f, -0.03586100f, 
    -0.03912154f, 0.04400608f, -0.03695350f, 0.04330351f, -0.04995805f, -0.05501049f, -0.03818932f, 0.06089740f, 
    -0.02878175f, -0.07244547f, -0.01553207f, 0.03092705f, 0.00922218f, 0.03151260f, 0.02095002f, -0.00691829f, 
    0.03813986f, -0.03601467f, -0.02824970f, -0.07875650f, -0.00227884f, 0.04117662f, -0.06373873f, -0.06598680f, 
    -0.02962280f, 0.02300063f, 0.03701391f, -0.00010121f, 0.05195632f, -0.00876003f, -0.00050361f, -0.03981623f, 
    -0.04249857f, -0.03702068f, -0.05390434f, 0.04820972f, -0.02143586f, 0.04074570f, -0.08061236f, -0.01280415f, 
    0.01321831f, -0.02706424f, -0.07308134f, 0.03316035f, -0.04496798f, 0.04829942f, 0.04032231f, -0.00056472f, 
    -0.01603336f, 0.04886350f, -0.02371972f, 0.06145215f, 0.04758427f, -0.02922921f, 0.01614149f, 0.06935116f, 
    0.01204038f, -0.00539126f, 0.05962894f, -0.01658082f, -0.01118468f, -0.04909617f, -0.00988629f, -0.00320527f, 
    0.00090127f, 0.00110191f, 0.03621825f, 0.03168364f, 0.00933926f, -0.03698105f, -0.05895027f, 0.05949827f, 
    -0.00936680f, 0.02569408f, 0.02959345f, 0.05652214f, -0.03508810f, -0.04939148f, -0.06374552f, 0.02476765f, 
    -0.05137107f, 0.00631250f, -0.05931476f, -0.04790238f, -0.00206313f, -0.04831199f, -0.03393479f, -0.04337858f, 
    0.03986085f, 0.02557871f, -0.00656234f, -0.00393839f, -0.07041716f, -0.05737831f, 0.06555772f, 0.04714102f, 
    0.02455409f, 0.02594137f, 0.05675595f, 0.01852047f, 0.04037189f, 0.03206814f, -0.03206098f, -0.07314533f, 
    -0.07747978f, -0.03817419f, -0.06077537f, -0.03041545f, -0.00669809f, -0.01824173f, -0.03442751f, 0.00722574f, 
    0.02022776f, -0.02015876f, 0.05167441f, 0.01152359f, -0.04218929f, 0.04065870f, 0.03281033f, 0.02969086f, 
    -0.05212441f, 0.05532184f, -0.07549313f, -0.02098446f, 0.03259398f, -0.07611655f, -0.04624275f, -0.07839071f, 
    -0.05565254f, -0.04485711f, 0.02317321f, -0.02244141f, 0.00948936f, 0.05192262f, -0.01217967f, -0.00852816f, 
    -0.06792450f, 0.03567823f, -0.05356585f, -0.00590650f, -0.07149957f, 0.02244690f, -0.03917048f, -0.00677180f, 
    -0.02401646f, -0.02894500f, -0.07244502f, 0.01727672f, -0.05094553f, -0.04172823f, -0.01776822f, -0.06302895f, 
    0.01352119f, 0.05184715f, 0.02073605f, -0.01877044f, 0.04090048f, 0.04012801f, -0.05210074f, 0.03971657f, 
    -0.02400065f, -0.02195654f, -0.06916192f, -0.06397119f, 0.02522166f, 0.06802050f, -0.01940482f, -0.03697299f, 
    -0.00396828f, -0.07357182f, -0.02869914f, -0.06847671f, 0.04890969f, 0.03374674f, -0.05770909f, -0.06632554f, 
    -0.04640516f, -0.00486038f, 0.02364590f, -0.00013019f, 0.04550068f, -0.02886272f, -0.01870585f, -0.05374769f, 
    -0.01915483f, 0.05732461f, -0.01610962f, -0.00801067f, 0.01579366f, 0.03599930f, -0.05738423f, -0.02523151f, 
    -0.05303787f, 0.01713679f, -0.00318773f, -0.06391717f, -0.05310133f, -0.02883679f, 0.04097434f, 0.02394625f, 
    -0.03917873f, 0.05604042f, -0.00888799f, 0.01370918f, 0.04769466f, 0.04287075f, -0.04172851f, -0.05300228f, 
    -0.06476754f, 0.02673394f, 0.00104243f, -0.05467116f, 0.01271454f, -0.04872290f, -0.00188280f, -0.07183930f, 
    0.00255905f, -0.02370232f, 0.00565412f, -0.06342557f, 0.06246467f, -0.06116755f, 0.05455582f, -0.03494190f, 
    0.01250172f, -0.05852435f, -0.08009652f, 0.00144782f, -0.04388572f, 0.03268374f, 0.01220658f, -0.04539959f, 
    -0.03758872f, 0.00394286f, 0.01025363f, -0.00764083f, -0.01768426f, 0.04391304f, 0.04494611f, -0.00144360f, 
    0.04713181f, -0.01182084f, -0.00000927f, -0.02084713f, 0.01348023f, 0.02114848f, -0.03186204f, 0.06298880f, 
    0.04646965f, 0.01587020f, -0.01304697f, -0.05775770f, -0.07219041f, 0.00401735f, 0.00479118f, -0.08383271f, 
    0.02660522f, 0.00709511f, 0.03510855f, 0.03210154f, 0.00581377f, 0.02342082f, 0.05171748f, -0.03190905f, 
    0.02960156f, -0.07631895f, -0.05090441f, -0.03302187f, 0.04028655f, -0.07364451f, -0.08244198f, 0.05185352f, 
    -0.03023364f, 0.02101876f, 0.04342648f, 0.01792373f, -0.01865260f, -0.02315475f, -0.01202488f, -0.06812084f, 
    0.03491099f, 0.02243894f, 0.04397867f, 0.00083004f, 0.00397202f, -0.01369230f, -0.07716772f, -0.01002748f, 
    -0.04685734f, 0.06506919f, 0.06684420f, -0.06386384f, 0.04288071f, 0.03837688f, 0.05815659f, -0.02398166f, 
    -0.08282442f, -0.06557257f, -0.06032647f, 0.01920424f, 0.03645458f, -0.00029184f, -0.03509816f, -0.03146708f, 
    -0.02392648f, -0.05879989f, -0.01918866f, 0.04467179f, -0.04817078f, -0.00576301f, -0.07762025f, -0.00098443f, 
    -0.04133998f, 0.02307649f, -0.06112941f, -0.01749067f, 0.02662978f, 0.05660329f, -0.00169384f, 0.00748919f, 
    0.04106968f, 0.00697960f, 0.05576655f, 0.02411306f, -0.02421086f, 0.01326586f, 0.05149896f, -0.01406566f, 
    -0.03988992f, -0.00179980f, 0.04183953f, -0.03032876f, 0.00183936f, -0.07265202f, -0.07457601f, -0.01457869f, 
    0.07168153f, 0.01422403f, 0.05304436f, -0.06031289f, -0.05882179f, -0.05721654f, 0.02632391f, 0.02150755f, 
    -0.04016772f, 0.00432403f, -0.08468238f, 0.01987550f, 0.00895291f, -0.04621900f, -0.04320065f, -0.07594765f, 
    -0.01337369f, -0.00534571f, -0.02122463f, -0.04985622f, -0.07100391f, 0.02006718f, -0.00606957f, -0.02593810f, 
    -0.06431795f, -0.01015771f, 0.06392328f, 0.01366594f, 0.03376081f, -0.01009558f, -0.00460071f, -0.00236973f, 
    -0.05303123f, 0.02703906f, 0.01458346f, -0.08309671f, 0.02206726f, -0.07594706f, -0.06873024f, 0.04632045f, 
    -0.05247513f, -0.00172412f, 0.04959403f, -0.05472222f, -0.01128638f, -0.04137680f, -0.00519130f, -0.00221737f, 
    0.19154441f, 0.16667253f, -0.10658735f, 0.12925711f, 0.02673451f, -0.05267704f, 0.07873337f, -0.08604881f, 
    -0.15685844f, -0.20096418f, -0.05163182f, -0.07432473f, -0.06278447f, 0.45566645f, 0.22120537f, -0.04874715f, 
    0.05666518f, -0.11366202f, 0.00060027f, 0.00972932f, 0.14420030f, -0.01200519f, 0.02576121f, 0.04380514f, 
    0.15211634f, 0.23215030f, 0.24934003f, 0.01970396f, 0.08743218f, -0.00980335f, 0.04181939f, 0.15050463f, 
    0.09719233f, 0.02983882f, 0.07443859f, -0.01999732f, -0.13919051f, -0.24038921f, 0.12682788f, 0.08288045f, 
    -0.01699087f, 0.10548342f, -0.01412390f, 0.03851891f, 0.17753047f, 0.06941348f, -0.06611454f, 0.10224389f, 
    -0.08911919f, -0.13653360f, -0.34084943f, 0.08335950f, 0.15303177f, 0.12643509f, 0.05682709f, -0.04270572f, 
    0.02951913f, 0.06364807f, 0.01327336f, 0.16772760f, -0.07370515f, 0.07729536f, 0.07594445f, 0.02843072f, 
    0.02738589f, -0.05813541f, -0.16262843f, 0.00785980f, 0.11198512f, 0.17916274f, -0.00983233f, -0.07963464f, 
    0.03222998f, -0.17624404f, -0.00209925f, -0.09800435f, 0.10563804f, 0.16851299f, 0.00817809f, 0.13137755f, 
    -0.00357999f, -0.10860878f, -0.09845768f, -0.25988400f, 0.00507308f, 0.08182577f, 0.18898638f, 0.03756594f, 
    -0.18405685f, -0.03611808f, 0.05930978f, 0.11096758f, 0.01113250f, -0.13965109f, -0.04451568f, -0.01151339f, 
    0.02010643f, -0.13031200f, -0.06954268f, -0.06285742f, -0.01813073f, 0.01114768f, -0.04970898f, -0.01402837f, 
    -0.08557197f, 0.05510174f, -0.11500669f, -0.12499825f, -0.08088658f, 0.34631473f, -0.14292070f, -0.30786288f, 
    -0.01703365f, -0.18900687f, 0.08260448f, 0.11542563f, -0.01491777f, -0.01895058f, 0.11970679f, 0.03575462f, 
    0.19579773f, -0.24246991f, 0.00089906f, 0.01108285f, -0.01761084f, -0.03012560f, 0.10879193f, 0.12438661f, 
    0.04500086f, -0.08701748f, -0.04946368f, -0.01521700f, 0.05288425f, -0.04464123f, 0.17258531f, -0.08343857f, 
    0.12608300f, -0.00667017f, 0.08319190f, 0.08951136f, 0.14450723f, 0.01168658f, -0.05046317f, -0.11843594f, 
    -0.16310857f, 0.10473876f, -0.27313742f, -0.04667025f, -0.03980043f, 0.05941180f, -0.08315185f, -0.19532976f, 
    0.03244776f, -0.08917795f, -0.03323112f, 0.00496668f, 0.16672876f, 0.11829806f, -0.10292599f, -0.02092383f, 
    0.06042500f, -0.07469068f, 0.06297427f, 0.01790123f, 0.02960186f, -0.08569983f, -0.13975514f, -0.20229331f, 
    0.10021257f, 0.23600677f, 0.36508214f, 0.24339405f, -0.11925796f, -0.03708322f, 0.05500417f, 0.04005826f, 
    0.03517739f, 0.03948573f, 0.09933836f, 0.10692918f, 0.14904431f, -0.03737174f, 0.19672677f, -0.07030704f, 
    -0.01023989f, -0.04182479f, -0.01088217f, 0.14585690f, 0.08345198f, -0.13982458f, 0.05550154f, -0.00474253f, 
    -0.05106493f, 0.16597512f, -0.09537949f, -0.00877942f, -0.09934339f, -0.04683758f, 0.14401458f, -0.08811663f, 
    -0.21167371f, 0.00856979f, -0.01976759f, -0.13308550f, -0.47412831f, 0.20721501f, 0.16983835f, -0.21931639f, 
    0.05042933f, -0.08557700f, 0.00682176f, 0.05393958f, -0.04996909f, 0.05317652f, 0.03925774f, 0.02401615f, 
    -0.02776329f, 0.16495956f, 0.27851403f, -0.11171315f, -0.09100343f, -0.01163911f, -0.08138157f, -0.03597931f, 
    0.03317454f, 0.11569098f, 0.05807158f, -0.13260497f, -0.20240544f, -0.22891785f, 0.11502726f, 0.06769234f, 
    -0.13302031f, -0.02265991f, 0.04600077f, -0.10261849f, 0.07189334f, 0.12127126f, 0.08512773f, 0.02994713f, 
    0.06696310f, -0.06061991f, -0.30854163f, 0.00268565f, 0.04193955f, -0.09767811f, 0.05964417f, -0.01452103f, 
    -0.17176911f, -0.08164787f, -0.04413524f, -0.16134703f, -0.26612809f, -0.13833512f, 0.23185349f, 0.17735623f, 
    -0.12458550f, 0.10166399f, -0.01420646f, 0.15400724f, 0.23160644f, 0.03936357f, 0.17455524f, -0.01656501f, 
    0.26526621f, -0.02434092f, 0.07252022f, -0.02567308f, 0.10080522f, 0.18057032f, 0.11680634f, 0.26078784f, 
    0.03827820f, -0.00721764f, -0.16355650f, 0.02377900f, -0.00730409f, 0.18760525f, 0.06354927f, -0.12602732f, 
    -0.10970689f, -0.09633321f, 0.16315509f, 0.22111891f, 0.02901711f, 0.07234099f, 0.05629872f, -0.09092823f, 
    -0.00886110f, -0.12231945f, -0.00975582f, 0.28257501f, 0.01261193f, -0.11139619f, 0.00735196f, 0.06911036f, 
    -0.06449085f, 0.01378652f, -0.02518017f, -0.05723578f, -0.31199425f, 0.02377155f, 0.16490529f, -0.45133632f, 
    0.04223375f, -0.08337564f, 0.19470246f, 0.14358866f, 0.01864908f, 0.00327080f, 0.10274633f, 0.10947812f, 
    0.35596719f, 0.06669679f, -0.04848508f, -0.15564141f, 0.07465254f, -0.07728137f, -0.07634097f, 0.20136631f, 
    0.04209698f, -0.02176498f, 0.07187369f, -0.07620738f, 0.09761024f, 0.04102661f, -0.09299721f, -0.00709224f, 
    -0.02822185f, -0.16736069f, 0.03740663f, -0.01767446f, -0.04853515f, -0.04523039f, 0.00541767f, 0.01169928f, 
    0.39639217f, 0.03163655f, -0.11942592f, 0.18212681f, 0.02950031f, -0.10773529f, 0.13005815f, 0.01216123f, 
    0.03587392f, 0.03137910f, -0.03898653f, 0.03515627f, 0.27650762f, -0.07036901f, -0.10187172f, 0.06440699f, 
    -0.16731668f, 0.06383961f, 0.21491975f, 0.10872928f, 0.03986431f, 0.08310673f, 0.06480643f, 0.06240476f, 
    -0.11134796f, 0.50561285f, 0.09676043f, 0.06469337f, -0.09935607f, -0.17933325f, -0.09565967f, -0.08462578f, 
    -0.09394190f, 0.01148405f, 0.10623146f, 0.01125193f, 0.15031525f, -0.13781615f, 0.14360362f, -0.02712727f, 
    -0.23263881f, -0.06711229f, -0.20338193f, 0.12269446f, 0.16301069f, -0.06581049f, 0.04486187f, -0.05172781f, 
    -0.06332553f, -0.06189614f, 0.05833342f, 0.02866211f, 0.03348860f, 0.07567590f, 0.07297742f, 0.00718595f, 
    -0.13306309f, -0.06148379f, -0.08133738f, -0.13821495f, -0.03846334f, 0.06198585f, 0.05144113f, 0.01732086f, 
    0.09148718f, -0.10880619f, -0.07756496f, -0.12840384f, 0.03807808f, 0.00212916f, 0.10769202f, 0.09822805f, 
    -0.07359052f, -0.12949663f, 0.19425678f, 0.05307467f, -0.23722528f, 0.14495042f, 0.05545555f, -0.03359945f, 
    -0.03487557f, 0.09314804f, -0.03505135f, -0.04243916f, -0.10098315f, -0.20173918f, 0.02023467f, 0.03199377f, 
    -0.06271166f, -0.10113828f, -0.08218207f, 0.04006689f, 0.10227066f, 0.12216066f, 0.11418190f, -0.21640392f, 
    0.08237215f, 0.13956730f, -0.05504562f, -0.12429844f, 0.03105690f, 0.10048912f, 0.06305089f, 0.11703445f, 
    -0.15795322f, 0.00677291f, -0.03663747f, 0.07718798f, 0.10836215f, -0.30258757f, 0.33951613f, 0.15875795f, 
    0.06561603f, -0.18633851f, -0.04644103f, 0.12675662f, 0.03871130f, 0.00123271f, 0.13092740f, 0.10577130f, 
    0.15633301f, -0.06288257f, -0.03000844f, -0.03781424f, 0.18857412f, -0.05462820f, 0.03225395f, 0.12772758f, 
    -0.03702524f, -0.00648293f, 0.01996049f, -0.05686372f, -0.07395725f, -0.16216671f, 0.16853578f, -0.01077755f, 
    0.02914495f, -0.09980764f, 0.12331811f, 0.08159585f, 0.07425388f, -0.03948423f, 0.04800424f, -0.10639496f, 
    0.17341708f, -0.04076711f, 0.29233465f, 0.04156949f, 0.13710587f, -0.02771793f, 0.03641536f, -0.16600217f, 
    -0.06455338f, -0.01771513f, 0.15212123f, 0.09235598f, -0.56047219f, 0.15508427f, -0.19319651f, -0.02219116f, 
    0.21200748f, 0.03810405f, 0.24894996f, -0.02005787f, 0.06861271f, 0.10781094f, 0.08399390f, 0.13922450f, 
    0.39380726f, -0.03130065f, 0.11680069f, -0.02887132f, 0.15036829f, -0.10855088f, 0.23321837f, 0.03529619f, 
    -0.06139291f, -0.10595912f, 0.10274184f, -0.02033881f, -0.03536528f, -0.00302064f, 0.04781779f, -0.01899991f, 
    0.10545053f, -0.03244070f, -0.04687986f, -0.06060698f, 0.01815040f, 0.04314810f, 0.02122563f, 0.04758597f, 
    0.37806177f, -0.01973877f, 0.40878215f, 0.14941114f, 0.10019937f, -0.06961758f, 0.02118569f, 0.11056430f, 
    0.08984951f, -0.01765147f, 0.08523428f, 0.05347816f, -0.13451852f, 0.12105969f, -0.10701396f, -0.21056744f, 
    -0.24852979f, 0.18116209f, -0.04252762f, 0.20297889f, 0.00573642f, -0.02286157f, -0.00959309f, -0.00004377f, 
    0.17451562f, -0.17824380f, 0.01585093f, 0.02783937f, -0.00766368f, -0.06661134f, 0.01736346f, -0.13847324f, 
    -0.00515503f, -0.06598203f, -0.00146276f, -0.00188269f, -0.14071554f, -0.13902996f, 0.23787871f, -0.05778471f, 
    -0.15664701f, 0.13166785f, 0.00781780f, 0.25888115f, 0.02729511f, 0.15829381f, -0.02753687f, -0.05350362f, 
    -0.04317764f, -0.04808547f, 0.04900102f, 0.00842140f, -0.00717357f, -0.01731901f, -0.05298459f, -0.01246334f, 
    0.05670376f, -0.00176832f, -0.03484343f, -0.04685654f, -0.05888052f, -0.01106270f, -0.05114925f, -0.07824837f, 
    0.06121136f, 0.02613156f, 0.03052336f, 0.04052488f, 0.00898365f, -0.03055256f, -0.02646943f, -0.03853213f, 
    0.04541165f, -0.01120383f, -0.06036424f, 0.03629580f, -0.01244007f, -0.00799625f, -0.02955093f, 0.01474431f, 
    -0.02732449f, 0.01123673f, 0.01056091f, 0.03680340f, 0.05249008f, 0.04086527f, -0.01979401f, 0.01219519f, 
    -0.01595333f, 0.00851518f, -0.02796947f, -0.03118822f, -0.04085103f, -0.03368711f, -0.01444648f, -0.04284330f, 
    0.07175130f, 0.00657376f, -0.06338508f, 0.00948222f, -0.01694944f, -0.01684689f, -0.07290948f, 0.01995436f, 
    0.01722660f, 0.02782056f, -0.00995576f, 0.01348467f, -0.08036866f, -0.04314120f, -0.01833948f, 0.00833862f, 
    0.05632363f, -0.02229371f, -0.04097906f, -0.02644556f, -0.01682907f, -0.03740024f, 0.04808535f, 0.04353371f, 
    0.03906560f, 0.02739542f, -0.08064905f, -0.01291615f, 0.00939234f, 0.02113654f, 0.02937954f, -0.04434162f, 
    -0.03937839f, -0.06244846f, -0.00073079f, 0.05511805f, 0.01287998f, 0.03406832f, 0.02519876f, -0.03495901f, 
    0.03164288f, 0.01690340f, -0.00975989f, 0.05390780f, 0.03177305f, 0.02372618f, 0.02773933f, 0.04129886f, 
    -0.02882213f, -0.06095892f, -0.05530800f, 0.00710296f, -0.04040071f, 0.00092971f, -0.00063964f, -0.02584756f, 
    0.04810914f, 0.01131840f, -0.03207316f, -0.01310827f, 0.00156408f, 0.01556486f, -0.03510139f, 0.03583670f, 
    0.00838757f, -0.01162229f, 0.01921131f, 0.04189694f, 0.02335351f, -0.06242454f, -0.01641082f, 0.01705197f, 
    0.05968643f, -0.02613892f, 0.04350552f, -0.01855476f, -0.07929627f, 0.00023899f, -0.02038622f, -0.03563796f, 
    0.05137045f, -0.05940503f, 0.04561143f, -0.02597173f, -0.04073763f, -0.06164620f, -0.07714254f, 0.03806769f, 
    -0.05788907f, -0.07549611f, 0.05424038f, -0.03210575f, 0.03174445f, -0.01379994f, -0.07880910f, -0.02386330f, 
    0.01392812f, -0.02189578f, -0.03790128f, -0.04427507f, -0.00387022f, 0.00037871f, -0.02716930f, 0.00014129f, 
    -0.01010367f, 0.02079789f, -0.08049981f, -0.05796880f, -0.05902389f, -0.04445793f, 0.00186669f, -0.02173208f, 
    0.06034923f, -0.01377961f, -0.06447493f, 0.00018867f, -0.00218193f, 0.03360875f, -0.06933422f, -0.07592987f, 
    -0.03230130f, -0.04710495f, 0.02943392f, -0.05609506f, -0.02424309f, 0.05102692f, 0.03584396f, 0.04067317f, 
    0.01840789f, 0.05952317f, -0.05133241f, -0.03305798f, -0.00648452f, -0.06253735f, 0.00835694f, 0.01400190f, 
    -0.02076742f, -0.06847280f, 0.02885628f, -0.07609206f, -0.03677432f, 0.00418678f, 0.02815713f, -0.06257247f, 
    -0.04333020f, 0.11170369f, -0.10927664f, -0.05672523f, -0.03552174f, -0.04294631f, 0.05392198f, -0.02188019f, 
    -0.09981070f, -0.03632314f, 0.00357174f, -0.04924547f, -0.46235445f, 0.22186680f, 0.09264166f, -0.21788831f, 
    -0.00459318f, -0.01005101f, 0.04267430f, 0.10239363f, 0.03368737f, -0.03760392f, -0.01156831f, 0.05960260f, 
    0.20053621f, 0.24871075f, 0.09837658f, -0.07555595f, 0.01015892f, -0.00774802f, -0.11012506f, 0.00543634f, 
    0.04239592f, 0.08990748f, 0.03911421f, -0.02630285f, 0.04860204f, 0.00400617f, 0.00115062f, 0.09352346f, 
    0.02792147f, 0.03294793f, 0.04996703f, 0.05540893f, 0.13207154f, 0.02103769f, -0.01837513f, 0.06926405f, 
    0.06675221f, -0.07803772f, -0.22229399f, 0.11890474f, 0.05790194f, -0.05177196f, -0.02877627f, -0.02900244f, 
    -0.04828207f, -0.01776858f, 0.01727538f, -0.11038840f, -0.09931912f, 0.01776461f, 0.19238918f, 0.00452624f, 
    -0.19293928f, 0.10538981f, -0.00061220f, 0.04159991f, 0.07306368f, 0.03994558f, -0.02271037f, -0.12510927f, 
    0.13137214f, -0.03033515f, 0.11416902f, -0.09768221f, -0.02892685f, 0.23444821f, 0.08321188f, 0.18014328f, 
    -0.03344480f, 0.07985114f, -0.19135760f, -0.02957205f, 0.03375149f, 0.23631057f, 0.09060222f, 0.01736404f, 
    -0.07919227f, 0.13526174f, 0.12416893f, 0.04478135f, -0.02524396f, -0.05687393f, 0.03226149f, 0.00648024f, 
    0.00986289f, -0.01490903f, -0.03021893f, 0.21191649f, -0.04029480f, -0.06637052f, 0.09472950f, 0.19022571f, 
    -0.02586365f, -0.06342279f, -0.22357510f, -0.16773093f, -0.13113597f, -0.19845018f, 0.13940200f, -0.31981522f, 
    -0.06143489f, -0.00471207f, 0.03252244f, 0.14619924f, -0.01937153f, -0.09110378f, -0.06088176f, 0.13224642f, 
    0.23526494f, -0.01532296f, -0.06533618f, -0.19048819f, 0.00165825f, -0.10846527f, -0.11630764f, 0.11838012f, 
    0.05976082f, -0.11603262f, -0.05733569f, 0.03729662f, 0.08628386f, 0.08698244f, -0.01582808f, 0.05860746f, 
    0.00032355f, -0.09749445f, 0.06241539f, -0.00410798f, -0.02819595f, -0.11848855f, -0.04454400f, -0.06371818f, 
    0.06794026f, 0.05756985f, -0.23720416f, 0.01611940f, -0.11842949f, 0.04791602f, 0.08786222f, -0.06763982f, 
    -0.04548050f, 0.04781787f, -0.05909172f, -0.07565782f, 0.28642571f, 0.18734372f, -0.19167191f, 0.09964410f, 
    0.05098533f, 0.02226366f, 0.12105106f, -0.06928209f, 0.09312755f, 0.02688295f, 0.09716178f, -0.02018815f, 
    -0.06096296f, 0.39993078f, 0.16306265f, 0.02037189f, -0.02428311f, -0.04540460f, 0.03687000f, 0.07298995f, 
    0.05396586f, 0.09465300f, -0.00379291f, 0.02387290f, 0.16710174f, -0.08739900f, 0.10736760f, 0.05251943f, 
    0.07646684f, 0.06795104f, -0.09866580f, 0.00172860f, 0.00588699f, -0.10621758f, 0.04924160f, 0.00060895f, 
    -0.04273272f, 0.03407953f, -0.04572091f, -0.00942146f, -0.04933059f, 0.05924648f, 0.02078846f, -0.05382425f, 
    -0.05809139f, -0.03114367f, 0.03885790f, -0.00888834f, 0.02283196f, -0.00242459f, -0.04616487f, -0.07973261f, 
    0.00258261f, 0.01961544f, -0.05489432f, -0.02308459f, 0.03691715f, -0.03764683f, 0.00093768f, -0.05522846f, 
    0.03284552f, -0.08194701f, -0.02048890f, 0.04451249f, -0.05780316f, -0.02697545f, -0.01787221f, -0.00721831f, 
    -0.02085691f, -0.01608254f, -0.03698570f, 0.04434048f, -0.05300688f, -0.08086695f, -0.00647004f, -0.06563913f, 
    -0.00550697f, -0.07349213f, -0.06916569f, -0.01668358f, -0.00173572f, 0.03108201f, 0.04056575f, 0.04965173f, 
    -0.05010378f, 0.01260343f, -0.01365131f, 0.03258369f, -0.01203553f, 0.01547438f, -0.07334701f, -0.01062172f, 
    -0.01509364f, 0.03972706f, -0.00850840f, -0.03419339f, 0.04612458f, -0.00678683f, 0.05626176f, -0.05888443f, 
    -0.01633160f, 0.00650953f, 0.03453893f, -0.02411238f, 0.00622020f, -0.02964977f, 0.04821252f, -0.04862962f, 
    -0.03454818f, 0.00381447f, 0.01624756f, -0.04588322f, 0.00875755f, -0.04290186f, -0.02984951f, 0.00648906f, 
    0.02489526f, -0.07356840f, 0.02601472f, -0.05955841f, 0.05874539f, 0.00310212f, -0.02246257f, 0.06121903f, 
    0.05651950f, 0.02549550f, -0.02841227f, -0.00594129f, -0.07832646f, 0.05802863f, -0.07200061f, 0.03908169f, 
    0.05553811f, -0.02529849f, 0.02050727f, 0.01191428f, -0.04111181f, -0.03852333f, -0.00874284f, 0.03838674f, 
    0.03842782f, -0.05204758f, 0.00362419f, 0.02678449f, -0.05682714f, 0.01806688f, 0.06250937f, -0.06302860f, 
    -0.06798749f, -0.06780256f, 0.00704929f, -0.00330282f, 0.02932433f, 0.01230630f, -0.07966893f, -0.04708588f, 
    -0.00252021f, 0.04977159f, -0.07316907f, -0.06476253f, -0.04625335f, 0.06054440f, -0.04356483f, 0.03574475f, 
    -0.06880166f, -0.07574075f, 0.02991810f, -0.05384416f, -0.00001947f, -0.04951473f, 0.03423323f, -0.02502960f, 
    -0.04649931f, -0.07381389f, -0.00924998f, -0.06707000f, -0.02491678f, 0.00089541f, -0.06321789f, 0.02860837f, 
    0.01847358f, -0.00001911f, -0.06556148f, 0.04192908f, -0.01693531f, 0.02192655f, 0.01537789f, -0.04064726f, 
    0.05589532f, -0.00440288f, -0.07084078f, 0.02586784f, 0.04876214f, 0.05694133f, -0.03688386f, -0.04767635f, 
    -0.04644601f, 0.03713010f, -0.03776090f, 0.03991425f, -0.07755528f, 0.01992299f, -0.00480507f, 0.01471684f, 
    0.06160964f, -0.03024711f, -0.00934192f, -0.06526048f, -0.06459240f, 0.05227244f, 0.04572354f, -0.00868475f, 
    -0.02355921f, 0.01925574f, -0.04943133f, -0.05176575f, 0.01205373f, -0.07599992f, -0.03652048f, -0.05369212f, 
    -0.02113601f, 0.03069571f, -0.07036647f, -0.02214722f, -0.00856816f, 0.06040130f, -0.04877187f, 0.05938634f, 
    -0.23888154f, -0.23340252f, 0.14504363f, -0.12017614f, -0.09890881f, -0.00632293f, -0.09783304f, 0.00409356f, 
    0.24669740f, 0.25713450f, 0.13059947f, 0.18329409f, -0.18435329f, -0.00543764f, -0.16364585f, -0.05268924f, 
    -0.04880068f, -0.01725412f, -0.03407170f, -0.11321095f, -0.00986134f, 0.09154651f, 0.04297687f, 0.09164783f, 
    -0.17164436f, -0.04497276f, 0.09907705f, -0.04838482f, 0.08610176f, -0.01931856f, 0.02543793f, -0.01851603f, 
    -0.14724429f, -0.15285350f, -0.04779079f, -0.00504754f, -0.10060521f, 0.26893100f, 0.24155767f, 0.02687358f, 
    0.05851459f, 0.01827377f, -0.06759520f, 0.18532237f, -0.13870884f, 0.02109874f, -0.02525834f, -0.13989720f, 
    -0.20590347f, -0.19917066f, -0.03424007f, -0.14632428f, -0.15529479f, -0.05066110f, -0.19694437f, -0.00604534f, 
    -0.05392816f, -0.09993859f, 0.13930537f, -0.09766687f, -0.01969927f, -0.05176456f, 0.08534262f, 0.14721359f, 
    0.00188795f, 0.12251524f, -0.03355534f, 0.05227492f, -0.06439058f, -0.04812072f, 0.00603349f, 0.15352246f, 
    0.04474504f, 0.09302382f, -0.13435613f, 0.02397852f, 0.02590463f, 0.08291958f, 0.08093005f, 0.10365012f, 
    0.08334326f, 0.13423191f, 0.18052131f, 0.21824862f, -0.03513539f, 0.10446843f, 0.02093422f, 0.00871384f, 
    0.09688906f, 0.11657257f, 0.16887791f, 0.03129273f, 0.05437209f, 0.17952287f, 0.18422478f, -0.12200185f, 
    0.18501139f, -0.00400941f, 0.18785639f, -0.29869372f, -0.18168645f, 0.04062800f, -0.07587802f, 0.10073251f, 
    0.12965547f, 0.05121174f, 0.16269423f, -0.01526756f, -0.21736471f, 0.03776385f, -0.18788663f, 0.06255991f, 
    0.03317020f, 0.12064994f, 0.07481231f, 0.12644717f, 0.22072786f, 0.17522988f, -0.06307607f, 0.08539920f, 
    0.00785700f, -0.15311815f, -0.21901992f, -0.11445265f, -0.05176751f, 0.22815393f, -0.12314179f, -0.06553930f, 
    -0.05598852f, -0.08417169f, 0.14016186f, -0.13406475f, -0.21052675f, -0.24103165f, -0.22702739f, -0.19401301f, 
    0.04894790f, 0.05686251f, 0.00175836f, -0.11153308f, 0.21529709f, 0.14674710f, 0.12490679f, 0.12038555f, 
    0.29032207f, -0.05671105f, -0.01414917f, 0.09709067f, -0.13545531f, -0.19640601f, -0.01445603f, -0.03070500f, 
    0.10196871f, -0.00389018f, -0.14520587f, -0.04278032f, 0.13260269f, -0.04500447f, 0.10138202f, -0.08686684f, 
    -0.09874006f, 0.11960705f, -0.10042459f, 0.01311569f, 0.01942099f, 0.07911868f, 0.05461231f, 0.25362352f, 
    -0.18128218f, -0.03976526f, -0.07837240f, -0.18857662f, -0.03509707f, 0.03786420f, -0.03872725f, 0.04623424f, 
    -0.04572874f, -0.06803143f, -0.04946683f, -0.05030093f, -0.08032316f, 0.15253174f, 0.09245628f, 0.13564254f, 
    -0.06627300f, 0.19162232f, 0.14375354f, -0.12490675f, 0.05703083f, -0.04067136f, -0.14304295f, -0.01895730f, 
    0.13690142f, -0.06900091f, -0.03835222f, -0.15418316f, -0.11806264f, -0.01600691f, -0.14418927f, -0.11615790f, 
    0.02334887f, -0.16456357f, -0.18538930f, -0.13150142f, 0.32275611f, -0.01144381f, 0.12426824f, 0.00790793f, 
    0.04172100f, -0.17675346f, 0.12962887f, -0.02185969f, 0.14032075f, 0.04113907f, 0.10277495f, -0.01188495f, 
    0.09768087f, 0.05514738f, 0.20753588f, -0.04479842f, 0.07534028f, 0.00665715f, 0.12692018f, 0.27675807f, 
    0.02583755f, 0.04339579f, 0.06380002f, 0.01736344f, 0.04856160f, 0.07962757f, 0.11522608f, -0.10835063f, 
    -0.01344182f, 0.11972462f, -0.05948696f, 0.15650977f, 0.13886349f, 0.06431025f, -0.00170318f, 0.18374881f, 
    -0.14255427f, 0.16708529f, 0.16913344f, -0.06142303f, 0.05340063f, 0.21313013f, 0.07015137f, 0.21204887f, 
    -0.03691620f, 0.11883571f, -0.00016877f, 0.09536391f, 0.27562639f, 0.06771022f, 0.36675665f, -0.16064551f, 
    0.13868906f, -0.16130643f, 0.06697633f, 0.00195060f, 0.04282165f, 0.03628781f, -0.09343849f, -0.11595852f, 
    0.02610714f, -0.19773038f, -0.10133971f, -0.07693385f, 0.02954472f, 0.02146070f, -0.23707801f, 0.07738988f, 
    -0.12263144f, -0.10594692f, -0.08421263f, -0.36076584f, 0.25889316f, -0.12813860f, 0.01273543f, 0.11463120f, 
    0.02111227f, -0.08466137f, 0.00390891f, -0.00475287f, -0.05292312f, -0.15195346f, -0.16080600f, -0.01199785f, 
    0.12586854f, -0.18673937f, 0.14194652f, -0.04989810f, -0.12878644f, -0.09543724f, -0.18049830f, -0.31653744f, 
    0.01836553f, 0.03828121f, 0.16638650f, 0.10606547f, -0.08507694f, 0.41802618f, -0.18350229f, 0.29061225f, 
    0.11279453f, -0.07248707f, 0.11668084f, -0.11252359f, 0.00784163f, -0.01590460f, -0.10144576f, 0.13363859f, 
    0.12656151f, -0.16348979f, 0.08851334f, 0.17030637f, 0.09039569f, -0.11129472f, 0.07507712f, -0.04985467f, 
    -0.12165119f, 0.21095462f, -0.14010550f, 0.03916451f, -0.18807106f, -0.18565288f, 0.21049336f, -0.31941995f, 
    -0.07455891f, -0.03851419f, -0.07287524f, -0.04313502f, -0.02659217f, -0.00804200f, -0.15317474f, -0.25304514f, 
    0.16322739f, 0.02973634f, 0.01127580f, 0.32570615f, 0.10791615f, 0.01441203f, -0.05202023f, -0.01077499f, 
    -0.05553792f, -0.01148672f, 0.16837834f, -0.00023914f, -0.30775604f, 0.44081956f, 0.06074398f, 0.00364927f, 
    0.07839401f, 0.02343020f, -0.06139831f, 0.03343609f, -0.09293901f, -0.26065090f, -0.19693592f, -0.20772436f, 
    0.44253978f, -0.25835386f, 0.15730694f, 0.01099776f, -0.05732926f, -0.10122750f, 0.04226997f, -0.05100552f, 
    0.19252348f, 0.00831827f, 0.01664289f, 0.20590299f, -0.05121006f, 0.33097187f, 0.11785746f, -0.03422910f, 
    0.08191228f, 0.09251804f, 0.07941168f, 0.22531569f, -0.01256478f, -0.00094326f, 0.10151368f, -0.07142272f, 
    -0.07459290f, -0.13176279f, 0.06015277f, 0.02322251f, -0.11721996f, 0.01265256f, -0.07973799f, -0.01705711f, 
    0.18046390f, 0.11840133f, 0.16493072f, 0.16488662f, -0.07369088f, -0.33597112f, -0.18824974f, -0.05846179f, 
    -0.00300740f, 0.33864406f, 0.23720762f, 0.19951345f, -0.09729861f, -0.05594175f, -0.07699089f, -0.04162748f, 
    0.25420472f, 0.18164413f, -0.22326557f, 0.13606761f, -0.08105142f, 0.00813023f, 0.05118007f, -0.03385206f, 
    -0.13622719f, 0.02662038f, -0.07679195f, -0.04899540f, 0.19019821f, 0.30898914f, -0.06133277f, 0.03629919f, 
    0.16318361f, -0.16375916f, 0.09873098f, 0.12770613f, 0.04890538f, 0.13115436f, 0.05508148f, -0.00254810f, 
    -0.17235672f, 0.00978125f, 0.09365625f, -0.00075231f, -0.08080309f, -0.05274441f, -0.12673360f, -0.01987788f, 
    0.03846052f, 0.03089642f, 0.04216512f, -0.09311894f, 0.22400050f, 0.16958793f, -0.03530115f, 0.09650315f, 
    0.03171771f, 0.19580795f, 0.29815352f, -0.01041468f, 0.14741766f, -0.14215726f, 0.05938023f, 0.08073533f, 
    0.12217288f, 0.05834855f, 0.07530675f, 0.08135964f, 0.16983615f, 0.06747874f, -0.18418136f, -0.08334543f, 
    0.10223620f, 0.15322918f, 0.05079032f, 0.14915346f, 0.25844190f, 0.21943401f, 0.14373346f, 0.07329454f, 
    0.15136649f, 0.17284824f, -0.01174499f, 0.07815671f, -0.06786050f, 0.08458465f, -0.01168581f, 0.09987693f, 
    -0.14138788f, -0.22124247f, -0.26266724f, 0.00050184f, -0.01316423f, 0.09605084f, -0.06249213f, 0.03535473f, 
    -0.01466355f, 0.12103037f, 0.13617295f, 0.01832751f, 0.04669528f, -0.37560654f, 0.17301583f, -0.01663291f, 
    0.19014762f, 0.14736535f, -0.11681911f, 0.15294750f, 0.06917184f, 0.00275037f, -0.10291323f, -0.09943002f, 
    -0.24897212f, -0.08493631f, 0.02737830f, 0.08068547f, -0.12168317f, -0.01919895f, -0.09209541f, -0.09401923f, 
    -0.00292040f, 0.06330401f, 0.00001900f, -0.00795853f, -0.03849339f, -0.03066320f, -0.17670067f, -0.07997148f, 
    -0.06856448f, 0.09043063f, 0.04667697f, 0.05213610f, 0.03169296f, 0.14294726f, 0.01070774f, -0.03708895f, 
    -0.10131107f, -0.17937790f, 0.21397866f, 0.08174800f, -0.01553855f, -0.05105059f, -0.07116348f, 0.01342080f, 
    -0.02995351f, 0.10411135f, 0.06841221f, 0.09293627f, 0.15603812f, 0.08306314f, 0.09776761f, 0.30087686f, 
    -0.07128818f, -0.08935408f, -0.31225163f, -0.07453109f, -0.02888939f, 0.06490817f, 0.05691395f, 0.19771995f, 
    -0.02827676f, 0.00777859f, -0.32243976f, -0.15243353f, 0.14662300f, 0.16408092f, 0.15431128f, 0.02859681f, 
    0.07736642f, -0.15500891f, -0.14922294f, -0.13945813f, 0.20029429f, -0.01495893f, -0.23374780f, 0.04975501f, 
    0.01998114f, 0.17205447f, 0.18248576f, -0.05010778f, 0.07176986f, -0.03751095f, 0.03193677f, 0.01163823f, 
    -0.02056209f, -0.01660999f, 0.02509778f, -0.02435069f, 0.02371190f, -0.01604469f, -0.05592034f, -0.00465622f, 
    -0.07580787f, -0.00231020f, -0.07547185f, -0.01116761f, 0.00664474f, -0.06788393f, -0.03839757f, -0.06486122f, 
    0.00626584f, -0.03508511f, 0.03699674f, -0.04606115f, -0.05533583f, 0.05347098f, 0.03585276f, 0.03597840f, 
    0.05671551f, -0.00216224f, -0.03103217f, -0.07572527f, -0.04310963f, -0.01459445f, 0.04583225f, -0.05176021f, 
    -0.01039923f, -0.05826329f, -0.05619675f, -0.04289240f, -0.04940598f, -0.07105376f, -0.01002553f, -0.02517610f, 
    -0.01147776f, 0.02002609f, -0.02750400f, 0.05114097f, 0.05663992f, 0.05218862f, -0.01115956f, -0.03892089f, 
    0.02644410f, -0.04199923f, -0.04844568f, -0.06297645f, -0.05988146f, -0.04874970f, 0.05044666f, 0.01987200f, 
    -0.02646159f, 0.06784403f, 0.07937951f, -0.06630899f, -0.03062646f, 0.02512945f, 0.06138294f, 0.05303103f, 
    -0.00438124f, 0.05009239f, 0.05425524f, 0.05650519f, 0.02496071f, 0.01555308f, -0.01592975f, -0.01050724f, 
    -0.05285897f, -0.05514797f, -0.05352708f, 0.05806616f, 0.04213417f, 0.03535793f, 0.00816036f, 0.02972596f, 
    -0.05403990f, -0.04394867f, 0.00941261f, 0.01977640f, -0.01748988f, -0.05488203f, -0.02698804f, -0.00890516f, 
    0.05512996f, -0.07176916f, -0.06529462f, -0.00457605f, -0.00991546f, -0.04432731f, -0.03436554f, 0.01733304f, 
    0.02441408f, -0.04167345f, 0.06243497f, 0.06406790f, -0.02247521f, -0.01101590f, -0.07318381f, 0.02161714f, 
    0.06764324f, -0.04499402f, -0.00518003f, -0.02607602f, -0.00349425f, -0.08096734f, 0.02299126f, -0.00970054f, 
    0.01041458f, 0.04469895f, 0.03997665f, -0.06325336f, -0.00071117f, 0.05506922f, -0.05063124f, 0.01254040f, 
    0.00679853f, 0.02034464f, -0.04258242f, -0.00993603f, -0.02564581f, -0.00715482f, -0.03755902f, 0.04048134f, 
    0.00621220f, -0.06979642f, 0.02762142f, 0.06423601f, -0.04912291f, -0.07466301f, -0.03107456f, -0.03374832f, 
    -0.01242066f, -0.05620708f, -0.04033909f, 0.03234921f, -0.02798554f, 0.03466611f, -0.04052339f, -0.03362850f, 
    -0.06750298f, -0.00570503f, -0.06609474f, -0.04250051f, -0.02721985f, -0.06320982f, -0.06746385f, -0.02475948f, 
    -0.06649949f, 0.01614597f, -0.07218046f, -0.01870414f, -0.07833274f, -0.05026827f, 0.01235885f, 0.04664605f, 
    0.01363789f, 0.06352571f, 0.07224948f, 0.00463279f, -0.02683278f, -0.00429447f, -0.05365819f, -0.07485650f, 
    0.03643629f, -0.01545402f, 0.05087010f, 0.03899017f, 0.01653043f, -0.00759342f, 0.04839305f, -0.07719878f, 
    -0.02720802f, 0.01434625f, 0.00166499f, -0.01332539f, -0.02186201f, 0.04854937f, -0.07088445f, 0.04546921f, 
    0.04217837f, 0.03910839f, -0.07967550f, 0.00117596f, -0.05960444f, 0.02647498f, 0.01993610f, -0.03199959f, 
    -0.14757952f, 0.02243223f, 0.15740825f, 0.06488278f, -0.11208260f, 0.04093869f, -0.00418641f, -0.15096766f, 
    0.11972371f, 0.29441708f, 0.09708554f, 0.21187910f, -0.01395404f, -0.25016052f, -0.02590518f, -0.24738631f, 
    0.02728359f, -0.11914124f, 0.11324764f, -0.03466329f, 0.07009766f, 0.11274875f, 0.10009843f, -0.02160581f, 
    -0.09818287f, 0.02765384f, 0.29522014f, -0.04527759f, -0.04873082f, 0.07741172f, -0.01281061f, 0.32631278f, 
    -0.07265493f, -0.02315594f, -0.06686278f, -0.13085352f, -0.05324456f, 0.05888885f, 0.21876623f, -0.16060850f, 
    0.00534508f, 0.20154162f, -0.04835428f, -0.00130197f, 0.15538399f, 0.09086289f, 0.07108346f, 0.16772932f, 
    -0.21605361f, -0.02409866f, -0.09097236f, -0.12720670f, 0.12575400f, 0.28786999f, 0.29030603f, 0.01502631f, 
    -0.16519329f, 0.06241588f, 0.11553168f, -0.16960460f, 0.23924311f, -0.04915830f, 0.45923594f, 0.08724789f, 
    0.15118766f, -0.19307050f, 0.02168489f, -0.04476788f, 0.06280140f, 0.09594478f, -0.08568045f, -0.10470707f, 
    0.26861513f, -0.14469874f, -0.04867907f, -0.04938749f, 0.20920083f, 0.05322940f, -0.01865504f, 0.11545934f, 
    0.20566447f, 0.05294909f, -0.11962771f, -0.01053255f, 0.24221036f, -0.13558963f, -0.21520863f, -0.00415258f, 
    0.12709700f, -0.14182587f, 0.02571137f, 0.14835574f, -0.14451200f, -0.10118226f, -0.08998083f, 0.03950723f, 
    0.17838368f, -0.29837263f, 0.21985784f, 0.07145551f, -0.06911530f, -0.12029380f, -0.17835836f, -0.08280395f, 
    0.14704536f, 0.11975590f, 0.10815582f, 0.18565953f, -0.45072964f, 0.54196703f, -0.20008190f, 0.14523511f, 
    0.16164319f, -0.06034647f, 0.29505697f, -0.00562146f, 0.15064801f, 0.05164072f, -0.15235911f, 0.04652184f, 
    0.01814268f, -0.48688579f, 0.12715559f, -0.03539199f, -0.00847157f, 0.12829039f, 0.02007754f, 0.13039562f, 
    -0.06653760f, -0.06354581f, -0.07987472f, -0.07367770f, -0.06148284f, -0.17699261f, 0.09621469f, -0.14894038f, 
    0.08179343f, 0.00971713f, 0.03197968f, 0.02816923f, 0.22650848f, 0.27120817f, 0.11796221f, 0.08183905f, 
    0.32911074f, 0.16371509f, -0.19531795f, 0.20464006f, 0.08755971f, -0.02196942f, 0.00502117f, 0.06388644f, 
    -0.01510133f, -0.04954637f, 0.06789471f, -0.05598937f, -0.21383537f, 0.08572800f, 0.21038127f, 0.06464813f, 
    -0.05876945f, 0.23058885f, 0.13000138f, 0.15436804f, 0.07310209f, -0.04855700f, 0.03153956f, 0.07435849f, 
    0.06632648f, -0.27786121f, -0.12322875f, -0.08063228f, -0.08942021f, -0.16694671f, -0.03654496f, 0.02139210f, 
    0.05098507f, -0.15099645f, -0.04525521f, 0.09544025f, -0.09364827f, 0.05969416f, 0.23520312f, 0.02501983f, 
    -0.05479222f, 0.09476661f, -0.07321871f, 0.30942655f, 0.06485425f, 0.03830703f, 0.23829600f, 0.07759301f, 
    -0.10418110f, -0.06048731f, -0.17044245f, -0.01552423f, 0.00598513f, -0.12965998f, 0.03605867f, 0.04860903f, 
    -0.03076956f, 0.16093269f, -0.03024063f, 0.09771664f, 0.35349926f, -0.07031550f, 0.01207803f, 0.22898445f, 
    0.13495842f, 0.01127009f, -0.12430033f, 0.01434759f, 0.01467795f, 0.02642550f, 0.18424432f, 0.02461801f, 
    -0.37825134f, -0.20947427f, 0.21262065f, 0.11465313f, 0.04671902f, 0.11241227f, 0.01509830f, -0.15063877f, 
    0.05749593f, -0.00147139f, -0.04501234f, -0.04986526f, -0.06666891f, -0.11896557f, 0.15160589f, 0.01875465f, 
    0.02384302f, 0.19097824f, -0.02455806f, -0.03069278f, -0.02774633f, 0.00113422f, -0.00038519f, 0.07232736f, 
    0.07367927f, -0.01091235f, 0.07154608f, -0.22584604f, -0.09342761f, 0.06813602f, 0.00996047f, -0.05290604f, 
    -0.08148498f, 0.07669996f, 0.00609853f, -0.05388305f, 0.10044764f, -0.14527699f, 0.03037111f, -0.00325091f, 
    0.17946923f, 0.10867097f, 0.06125115f, 0.10897492f, 0.02285402f, 0.07972553f, -0.01425608f, 0.01370161f, 
    -0.15835175f, 0.07700436f, -0.00885835f, 0.10670255f, -0.03573814f, -0.04931136f, -0.14903846f, -0.04080532f, 
    -0.16850743f, -0.13231783f, -0.07933143f, -0.01662896f, -0.19441001f, -0.11995741f, -0.13430431f, -0.08208336f, 
    0.16763654f, -0.04193740f, -0.07940778f, 0.00791815f, 0.01200475f, -0.01461979f, -0.03620554f, 0.10764013f, 
    -0.03765028f, -0.05733962f, -0.04923275f, -0.05826299f, 0.04882489f, -0.07428791f, 0.09159230f, -0.09786154f, 
    -0.05374344f, 0.18179236f, 0.07166072f, 0.17280450f, 0.22325532f, 0.25933141f, 0.12964791f, 0.36348367f, 
    -0.01101304f, -0.02302702f, 0.10283041f, -0.07272055f, 0.11533839f, 0.17985962f, -0.02652796f, -0.02491463f, 
    -0.09077392f, 0.07909996f, 0.04222620f, 0.10890707f, 0.15357031f, 0.15108506f, 0.05013047f, -0.22160758f, 
    -0.08661059f, 0.09503832f, -0.12079111f, 0.09302217f, -0.08000463f, 0.04654019f, -0.12758672f, -0.09414015f, 
    -0.10171843f, -0.04509168f, -0.08455325f, -0.03563009f, -0.11705799f, -0.12351970f, -0.02162759f, -0.16212647f, 
    0.36417156f, -0.04515376f, -0.00937991f, 0.02738653f, 0.00890164f, -0.02453019f, 0.00209364f, 0.06829972f, 
    -0.02612037f, 0.05107888f, 0.07770855f, -0.07041728f, -0.17373161f, -0.02429738f, 0.29744750f, 0.00366087f, 
    0.15286620f, -0.09606582f, 0.16407104f, -0.08963201f, -0.15219820f, -0.16742583f, -0.06061690f, 0.02353663f, 
    -0.03384488f, -0.21076310f, -0.07143379f, -0.16161683f, 0.12515512f, -0.07837211f, 0.09396777f, 0.24779436f, 
    -0.01966341f, -0.00369601f, 0.11847448f, 0.03617552f, -0.33203411f, 0.09777854f, 0.07882118f, 0.14074539f, 
    0.02003662f, 0.00089119f, 0.03666752f, 0.09995720f, -0.01836811f, 0.29673064f, 0.04816094f, -0.05952106f, 
    0.05212514f, 0.03807690f, -0.03467723f, 0.01730874f, 0.03534868f, 0.02474171f, 0.04227265f, 0.00305186f, 
    -0.05501674f, -0.06055210f, -0.02489147f, 0.06484509f, 0.03844133f, -0.04195503f, -0.03205954f, 0.00700558f, 
    0.05174138f, 0.01498570f, -0.03321748f, 0.01660207f, -0.05732779f, -0.07074258f, 0.01852419f, 0.02938229f, 
    -0.01616410f, -0.06095329f, -0.07767420f, -0.05813134f, 0.02459071f, 0.02080015f, 0.01315288f, -0.01252590f, 
    -0.07373857f, -0.07555301f, 0.00974932f, 0.04972435f, -0.01544808f, -0.03006081f, 0.03960928f, -0.05212984f, 
    -0.03559474f, -0.04999711f, -0.06246708f, 0.02417861f, 0.03932288f, 0.06662732f, 0.01633206f, -0.07295306f, 
    -0.01010516f, -0.05714386f, -0.03152683f, -0.02708938f, -0.05651070f, 0.00028967f, 0.02778546f, 0.01650537f, 
    0.00659443f, 0.00088035f, 0.01018645f, -0.07073484f, -0.07137494f, -0.03756280f, -0.01277940f, -0.07672322f, 
    0.01315279f, -0.02092195f, 0.03891435f, -0.01085715f, 0.00779922f, 0.05544887f, -0.07376184f, -0.00416819f, 
    -0.06692619f, 0.02795753f, -0.06758174f, 0.01959099f, -0.07093874f, -0.04938640f, -0.05802845f, 0.05644365f, 
    0.04266791f, 0.04779892f, 0.01269492f, 0.05876997f, -0.06698502f, -0.01977724f, 0.04098200f, -0.05189433f, 
    -0.06100777f, 0.05334300f, -0.01863773f, -0.03501568f, -0.05195980f, -0.04297372f, -0.06246072f, 0.01920609f, 
    -0.00660340f, -0.07088477f, 0.05481576f, 0.04595613f, 0.02987469f, -0.05176705f, -0.05490065f, -0.06041773f, 
    0.03189123f, 0.00282900f, -0.05589213f, -0.00813872f, -0.06547859f, 0.05733358f, 0.06244662f, -0.02737833f, 
    0.00650245f, -0.04129581f, -0.00070344f, -0.01449533f, -0.02661848f, -0.05747902f, 0.05409024f, -0.03122890f, 
    0.01500018f, 0.06590117f, -0.07146074f, -0.04209233f, -0.04676449f, -0.04749407f, -0.05430485f, -0.00768994f, 
    0.01545129f, 0.01472703f, 0.00402255f, -0.06477927f, -0.04129069f, 0.03888904f, -0.07183307f, 0.03341908f, 
    -0.06609322f, -0.02372144f, -0.05347753f, 0.02744969f, -0.01111208f, 0.01866311f, 0.03554372f, 0.01330021f, 
    0.01408518f, 0.00822635f, 0.05356212f, 0.00002069f, -0.02495081f, -0.05886043f, -0.02458030f, 0.00707807f, 
    -0.02550194f, -0.04875325f, 0.01224477f, -0.07304287f, -0.03952228f, 0.01358900f, -0.02354388f, -0.02354463f, 
    0.01585979f, 0.03876446f, -0.07315656f, -0.05597115f, -0.03567243f, 0.01033600f, -0.05746208f, 0.03998349f, 
    0.05222988f, -0.06775043f, 0.02496888f, -0.03988405f, -0.05547687f, 0.06260925f, 0.02057381f, -0.06487531f, 
    0.04680092f, 0.03967365f, 0.04273646f, 0.05260010f, 0.04889156f, 0.00380383f, -0.05082454f, -0.05263413f, 
    -0.01911899f, -0.07387292f, 0.05820213f, -0.06298166f, 0.01244890f, 0.04761841f, -0.06248609f, 0.01450072f, 
    -0.28208905f, -0.08700381f, 0.12342092f, 0.18508515f, -0.19304079f, -0.15472430f, -0.05405507f, -0.08849590f, 
    0.16556032f, 0.23694348f, -0.05344821f, 0.10089525f, -0.34771001f, -0.01782577f, 0.05072669f, 0.01520415f, 
    -0.10586147f, 0.06687293f, 0.02375419f, 0.09569663f, -0.16465372f, 0.01211692f, 0.03064794f, 0.00580122f, 
    -0.07350368f, 0.00603684f, -0.10578614f, -0.11267498f, -0.18208362f, 0.05840319f, 0.03769558f, 0.09389181f, 
    -0.12067463f, 0.00217566f, -0.10162492f, -0.10154664f, 0.10911458f, 0.14578891f, -0.00643754f, -0.08189553f, 
    0.04861009f, -0.12314717f, 0.05378890f, -0.04358025f, 0.10683205f, 0.10247336f, 0.05004584f, 0.21298692f, 
    -0.17534709f, -0.16410607f, -0.07786339f, 0.01592437f, -0.01301306f, -0.02722700f, -0.07530274f, -0.15430984f, 
    -0.12502098f, -0.13269015f, -0.01582191f, -0.30830371f, 0.21380758f, 0.06405866f, -0.09701879f, 0.07682410f, 
    0.05827957f, -0.05026769f, 0.20980909f, 0.07325552f, -0.04075108f, -0.00081022f, 0.07710579f, 0.09643874f, 
    0.02176280f, 0.02770777f, 0.06134759f, 0.00117020f, 0.10262109f, 0.01526413f, 0.13040699f, -0.01083975f, 
    0.20321415f, 0.12823306f, 0.08665152f, 0.29606193f, 0.04981872f, -0.06037477f, -0.30737415f, -0.16458602f, 
    0.13697290f, 0.04300156f, -0.03896604f, 0.06983660f, -0.01529578f, -0.03314244f, -0.05136239f, -0.00890055f, 
    0.10988571f, 0.24845032f, 0.02652335f, 0.01787056f, 0.03687983f, 0.00138764f, -0.02114270f, 0.08314653f, 
    0.31430501f, 0.14917856f, 0.11619893f, 0.16979258f, 0.06138916f, 0.14765693f, 0.05101717f, 0.04078611f, 
    0.13685666f, -0.05541399f, 0.03387229f, 0.29252127f, 0.00787909f, 0.11348239f, 0.07615069f, 0.03973758f, 
    -0.19242184f, -0.06724751f, 0.05599031f, -0.01440699f, 0.10265503f, 0.23308378f, -0.10005294f, -0.09694681f, 
    0.01559461f, -0.17088421f, 0.07713579f, 0.03397244f, -0.13772435f, 0.02261391f, -0.22217390f, -0.00300403f, 
    0.04948848f, -0.09839886f, -0.19224378f, -0.20435204f, 0.02888369f, -0.00396372f, 0.01517817f, 0.20495555f, 
    0.28248891f, 0.54093236f, 0.01290179f, 0.04738681f, 0.16745725f, 0.03180796f, 0.20138128f, 0.01316932f, 
    0.03578122f, 0.01815686f, -0.08227561f, 0.17149292f, -0.23833701f, -0.50248808f, 0.06894813f, -0.03258617f, 
    -0.08919512f, 0.19818573f, -0.00552054f, -0.09632836f, 0.10268131f, 0.07925890f, 0.14832862f, 0.12276772f, 
    -0.34640065f, 0.21990384f, 0.02539602f, 0.03945863f, 0.01682845f, 0.06473082f, -0.07157300f, 0.17667729f, 
    -0.02417867f, 0.06522965f, 0.10800730f, 0.10446691f, -0.04947866f, -0.28192556f, -0.20303841f, 0.00836047f, 
    -0.00379031f, 0.03789319f, 0.00998415f, -0.00496009f, -0.05921754f, 0.05909185f, 0.15799479f, 0.19006139f, 
    0.01970503f, -0.14622526f, 0.08059115f, -0.03331184f, 0.01514348f, -0.03449427f, 0.14378124f, 0.05216692f, 
    0.08352743f, 0.09930649f, -0.07108690f, 0.02337222f, 0.37198111f, 0.12546824f, 0.09646183f, 0.21839462f, 
    0.05756910f, -0.08361603f, 0.01869732f, -0.11268938f, 0.00313299f, 0.04981852f, 0.02596798f, 0.15649630f, 
    -0.27295023f, -0.16511209f, -0.04197602f, 0.06332374f, 0.02092129f, 0.06756649f, 0.10808467f, 0.00015199f, 
    -0.01121239f, 0.01912228f, 0.01134539f, 0.17355925f, -0.07096314f, -0.11509019f, -0.04656250f, -0.05155357f, 
    0.04037965f, 0.15731728f, 0.08888221f, 0.11017929f, -0.02193938f, 0.06166105f, 0.01480695f, 0.04999969f, 
    -0.00769710f, -0.02212347f, 0.08705191f, -0.11754715f, -0.07134093f, -0.01491340f, 0.07721636f, -0.01400916f, 
    0.03180008f, -0.08616931f, -0.07947437f, 0.06844771f, -0.13541153f, -0.11838692f, -0.19123071f, 0.12226941f, 
    0.05251861f, 0.04412913f, 0.05134861f, 0.06821940f, -0.04413570f, 0.07565749f, 0.01234166f, 0.07724995f, 
    -0.10795718f, 0.03787416f, -0.06771639f, -0.02202860f, 0.00696307f, -0.21283638f, 0.09408902f, 0.00025958f, 
    -0.07166559f, -0.05654813f, 0.22373897f, 0.06292210f, -0.18472978f, -0.13241062f, -0.11018945f, -0.04365743f, 
    -0.03932562f, -0.05773715f, -0.04868760f, 0.01793582f, -0.03615474f, 0.10132846f, 0.09829926f, -0.00046200f, 
    0.16062367f, 0.42937484f, 0.10730830f, -0.12823212f, 0.11456691f, 0.02177806f, -0.01698628f, -0.08491319f, 
    0.13405029f, 0.15641320f, 0.20111369f, 0.09093891f, 0.18560295f, 0.30524820f, -0.17463647f, 0.24602678f, 
    0.03652815f, 0.00369393f, 0.04848253f, -0.06694563f, 0.09681632f, 0.16384508f, 0.17137139f, 0.05454057f, 
    -0.08993664f, 0.16733573f, 0.00588696f, 0.08431937f, 0.09908225f, 0.06109974f, 0.20802072f, -0.11179896f, 
    0.06695238f, 0.02624765f, 0.04619499f, 0.08209023f, -0.05414375f, -0.08110052f, 0.02140374f, -0.12940694f, 
    -0.00060197f, 0.03774232f, -0.13944440f, 0.00405867f, -0.07341435f, 0.01133077f, 0.03238967f, 0.03590432f, 
    0.05699782f, 0.39269263f, 0.32414106f, -0.09278765f, 0.09835389f, -0.03044625f, -0.05031815f, -0.04162479f, 
    0.10045844f, -0.06371857f, 0.01808373f, -0.02507168f, -0.10373583f, -0.17599040f, 0.20344298f, -0.09153938f, 
    0.08546440f, 0.08056492f, 0.02223785f, 0.08869562f, -0.01334831f, -0.17595977f, -0.06636031f, 0.10250666f, 
    0.07251468f, -0.30389011f, 0.11054373f, 0.14559081f, 0.06190829f, -0.05269645f, 0.02232601f, 0.04883528f, 
    -0.08098564f, 0.06673354f, 0.16954561f, 0.10518932f, -0.23829627f, -0.05563852f, 0.02587584f, -0.00920925f, 
    0.06123146f, 0.03284289f, 0.05637887f, 0.10439035f, -0.08238959f, 0.12409499f, 0.05916383f, 0.05057039f, 
    -0.01155733f, 0.03001751f, -0.19723207f, 0.09621018f, -0.00041079f, -0.23759520f, 0.00660300f, -0.00469430f, 
    -0.12828003f, -0.13680145f, -0.00170440f, -0.15517457f, 0.29249632f, 0.08031043f, 0.20361264f, 0.22219884f, 
    0.07229946f, -0.09751171f, -0.10653254f, -0.04420025f, -0.04471092f, 0.03049216f, -0.01135981f, 0.07762906f, 
    -0.16546209f, 0.00107181f, 0.28340158f, 0.17771164f, 0.00341651f, 0.00669648f, 0.00930450f, -0.04623039f, 
    0.20732690f, -0.02691589f, -0.04253753f, 0.10996166f, -0.04674590f, -0.18292436f, 0.13902956f, 0.17620254f, 
    -0.07872545f, 0.02670416f, 0.02455030f, 0.02971711f, 0.16797525f, 0.06952593f, 0.06672978f, 0.22327206f, 
    0.10170379f, -0.14210273f, -0.04222946f, -0.05652205f, 0.19875361f, 0.21093811f, 0.13441803f, -0.19866881f, 
    0.04679148f, 0.09250896f, -0.04590541f, 0.03941902f, 0.12251827f, -0.03852346f, -0.02770057f, -0.06584627f, 
    -0.00782514f, -0.05774884f, 0.05526384f, 0.08177406f, -0.10818420f, 0.13910013f, -0.07355931f, -0.17445678f, 
    -0.27095392f, -0.16292688f, 0.01247474f, 0.11066142f, -0.15720622f, -0.02680122f, -0.08118476f, 0.06720518f, 
    -0.16788147f, -0.39341047f, -0.23907277f, -0.28889349f, -0.17451833f, -0.08505962f, -0.04081569f, 0.18982987f, 
    0.10984752f, -0.04452998f, -0.02427975f, 0.06628867f, -0.02533785f, -0.12757243f, -0.05418327f, 0.16374700f, 
    -0.15233544f, 0.01328689f, -0.08145007f, -0.17025791f, 0.02461783f, -0.03734785f, -0.14489448f, -0.18726720f, 
    -0.04003346f, 0.01720198f, -0.07986306f, 0.13230363f, 0.37126708f, 0.27533743f, 0.02972381f, 0.27373365f, 
    0.06088506f, -0.01763990f, -0.09473319f, -0.15628429f, -0.02134996f, 0.06105704f, 0.03847238f, 0.00282667f, 
    -0.06358907f, 0.07553201f, 0.09889714f, 0.35965306f, 0.19464248f, 0.06179167f, -0.00457696f, -0.18404421f, 
    -0.05763479f, 0.17983802f, -0.25746673f, 0.02495823f, -0.13073510f, -0.06299452f, 0.00196344f, -0.19374928f, 
    0.10124707f, 0.07744025f, -0.10044483f, 0.02907523f, -0.05044756f, -0.22764418f, -0.23547280f, -0.41026023f, 
    0.13533306f, 0.14918974f, -0.02792603f, -0.00781165f, 0.06566560f, 0.02898805f, 0.02420762f, -0.24032328f, 
    -0.03261052f, 0.04501250f, 0.04335010f, -0.09653372f, -0.15467058f, 0.01709625f, 0.22056758f, 0.21234477f, 
    0.32721397f, -0.21463777f, 0.23431186f, -0.15657701f, -0.10136399f, -0.25750229f, -0.25800619f, -0.30511355f, 
    -0.11531763f, -0.07679792f, 0.12884806f, 0.15030134f, -0.02469132f, -0.01108074f, 0.10747758f, 0.15903735f, 
    -0.02732889f, 0.04244621f, 0.17650841f, 0.09863185f, -0.14235993f, 0.03594028f, 0.15575536f, 0.26855913f, 
    0.13927941f, -0.10878993f, 0.02940940f, 0.06189252f, -0.01227370f, 0.11715997f, 0.17630489f, -0.05113034f, 
    0.14233777f, 0.08689056f, 0.06193969f, -0.14860764f, -0.02046889f, 0.13265868f, 0.03002871f, -0.06461351f, 
    -0.13989370f, -0.09105899f, -0.07782856f, -0.11680787f, 0.40573180f, -0.50563228f, -0.22869176f, -0.19414833f, 
    0.07042746f, -0.05184706f, 0.10033740f, 0.20702304f, 0.07095065f, -0.08921435f, 0.04678497f, 0.03219426f, 
    0.06167381f, -0.02174008f, 0.03543182f, 0.16626117f, -0.00567630f, -0.14944689f, -0.06417664f, 0.04859975f, 
    -0.13363613f, 0.15718526f, -0.00661249f, -0.08526877f, 0.25915030f, 0.29791105f, -0.28165174f, -0.07530704f, 
    0.01808783f, -0.06433616f, 0.03004834f, 0.01266172f, -0.07511033f, -0.15125366f, -0.00539773f, -0.07942756f, 
    0.18531108f, 0.28004953f, -0.00238476f, 0.06164207f, -0.14964336f, -0.05241980f, 0.01163016f, 0.06077670f, 
    0.01235983f, 0.21446194f, 0.00107864f, 0.10256572f, -0.06288502f, -0.05117146f, 0.18021579f, -0.11005363f, 
    0.20906177f, 0.09865593f, 0.06263871f, -0.04342828f, 0.02720542f, -0.06785641f, -0.05498821f, 0.00949741f, 
    0.17219660f, 0.13437690f, -0.00172927f, 0.07686112f, -0.10208002f, -0.01283954f, -0.07260904f, -0.07683109f, 
    0.00592728f, -0.01713483f, -0.08215638f, -0.12625724f, 0.28334579f, 0.04624482f, 0.09760217f, -0.05599535f, 
    -0.02061052f, -0.05791745f, 0.09508487f, 0.05957290f, 0.07628107f, 0.03127074f, -0.08758882f, -0.01237000f, 
    -0.23634093f, -0.15810634f, -0.03550075f, 0.08917476f, 0.04607495f, 0.03725008f, 0.07901996f, -0.02826316f, 
    -0.17613488f, -0.20326501f, -0.02032326f, -0.06542591f, -0.08056214f, -0.40995339f, 0.38777992f, -0.00121763f, 
    0.18070765f, 0.05553652f, 0.24855414f, -0.02014049f, -0.21272950f, 0.13034706f, 0.01410599f, -0.03744688f, 
    0.01571838f, 0.11055876f, 0.11548653f, 0.01555148f, -0.01037327f, -0.03100357f, 0.06301880f, 0.16966279f, 
    0.10361035f, 0.14076011f, 0.11189155f, -0.08117431f, -0.01256606f, 0.01614323f, 0.10642856f, 0.04654045f, 
    0.03648335f, 0.18256293f, 0.05626442f, 0.06879707f, -0.17596832f, -0.08085790f, 0.04362981f, -0.06966787f, 
    0.18346609f, -0.17679118f, 0.21176080f, 0.11186653f, 0.05540357f, -0.02928459f, -0.05973789f, 0.11488159f, 
    -0.02432133f, 0.14270493f, 0.07451139f, 0.02295051f, 0.02114136f, 0.16516462f, 0.20754443f, 0.17767186f, 
    -0.13523220f, 0.06995187f, -0.05013001f, 0.08163814f, -0.02533232f, 0.08450013f, 0.00798373f, -0.13671468f, 
    0.18965326f, -0.00894749f, -0.50118428f, -0.12570538f, 0.06035342f, -0.03880442f, 0.07557838f, -0.08916581f, 
    0.13028426f, 0.02938432f, -0.02258912f, -0.00054971f, -0.10302754f, -0.14663377f, -0.05966539f, 0.16658324f, 
    -0.08658340f, 0.01685477f, -0.07163339f, 0.11395455f, -0.09433291f, -0.23650965f, 0.04419818f, -0.02106113f, 
    -0.00804802f, 0.03061014f, -0.01180308f, 0.09104898f, 0.02579208f, 0.12339453f, -0.11062167f, 0.03436403f, 
    -0.03775172f, -0.02880549f, 0.05996789f, 0.08794069f, 0.23486263f, 0.10668921f, 0.11766396f, 0.25999585f, 
    -0.02827265f, 0.00876175f, 0.15789106f, -0.01937139f, 0.00278988f, -0.05725383f, -0.08313735f, 0.02113027f, 
    0.23922169f, -0.00032806f, -0.43291938f, 0.14587021f, -0.11808600f, -0.06650809f, 0.09463958f, 0.05472005f, 
    0.19342484f, -0.07769420f, 0.06804371f, 0.05729115f, 0.15756179f, -0.00009195f, -0.27574655f, -0.02474866f, 
    -0.05109172f, -0.12465916f, 0.07872675f, 0.10677618f, 0.19644319f, -0.00622402f, 0.09630001f, -0.20339355f, 
    -0.19878490f, -0.07764126f, -0.04195129f, -0.08825272f, -0.02198143f, -0.03769280f, -0.14589478f, -0.13217817f, 
    -0.05338473f, -0.05223100f, -0.05152132f, 0.07287814f, 0.05276415f, 0.09339617f, -0.36273059f, 0.22371180f, 
    -0.18634495f, 0.12582929f, -0.09840927f, 0.01701695f, -0.08376821f, 0.03714251f, 0.08023921f, 0.00986694f, 
    -0.00889808f, 0.01543114f, 0.03024984f, -0.01238848f, 0.06766499f, 0.00992132f, -0.00743567f, -0.11626648f, 
    -0.00653550f, -0.04362965f, 0.14385211f, -0.01428350f, 0.14941981f, 0.15304658f, 0.23998812f, 0.28558090f, 
    -0.09606752f, 0.10366218f, 0.16381267f, 0.09200478f, -0.02726232f, 0.01216229f, -0.02767007f, 0.05496121f, 
    0.02147730f, 0.18180145f, -0.10012899f, -0.03109728f, -0.09112054f, 0.03263860f, -0.07211828f, -0.01735985f, 
    -0.05971171f, -0.04203333f, 0.00946507f, 0.01852055f, 0.21590464f, -0.01390112f, -0.09862395f, 0.09589609f, 
    -0.01610355f, 0.12290278f, -0.01329377f, 0.14987329f, 0.01455602f, -0.08258995f, -0.00107215f, 0.02777151f, 
    -0.42206642f, 0.10686255f, -0.17445309f, -0.10235267f, -0.06558443f, -0.04489252f, -0.02279283f, 0.03472509f, 
    -0.03971107f, -0.01935399f, 0.06834952f, 0.05822183f, -0.12989885f, -0.09675729f, -0.02833641f, -0.03136080f, 
    -0.08583836f, 0.00864555f, -0.04209742f, 0.07139544f, -0.08854404f, 0.01420269f, -0.04119335f, -0.01514509f, 
    -0.69739211f, -0.12936132f, 0.28651014f, -0.03385558f, 0.03290163f, 0.08507217f, -0.03593882f, -0.11056787f, 
    0.02319394f, -0.02079918f, -0.05140997f, 0.01690901f, -0.29965028f, -0.38178891f, -0.01087532f, -0.00668232f, 
    0.00668553f, 0.30953193f, -0.23708965f, 0.15485403f, 0.00871292f, 0.00549220f, 0.06412315f, -0.05844580f, 
    0.24063517f, 0.01144076f, 0.20262365f, 0.28137684f, 0.12799312f, 0.16422209f, 0.07453349f, 0.01736240f, 
    0.02008000f, 0.05115626f, 0.05790910f, 0.07928804f, 0.20849279f, -0.04047775f, -0.04373582f, 0.03398653f, 
    0.03658229f, 0.05749741f, 0.20316933f, 0.09531389f, 0.00811510f, -0.16355319f, 0.08213817f, 0.01053563f, 
    -0.02576562f, 0.02294145f, -0.00052348f, 0.00092169f, -0.02356531f, 0.02808379f, -0.07685738f, 0.00891394f, 
    0.06564671f, -0.03868358f, -0.07539849f, -0.01624679f, 0.04399912f, -0.02044845f, -0.01305275f, -0.05333005f, 
    -0.02973551f, 0.05168240f, -0.05514561f, -0.03271407f, -0.01156895f, 0.01065441f, 0.02269245f, -0.00133096f, 
    0.01911778f, -0.04622927f, 0.00162552f, -0.07293779f, -0.01696650f, 0.01540672f, 0.04763430f, -0.04076198f, 
    -0.05441812f, -0.06210112f, -0.07730644f, 0.01465568f, -0.07709115f, -0.05360654f, -0.07560785f, 0.01688622f, 
    -0.06303458f, -0.06023324f, 0.03466132f, 0.03455176f, -0.06259863f, -0.06755587f, 0.00909004f, 0.00226853f, 
    0.05635704f, -0.06198158f, -0.04209954f, -0.06380404f, -0.05221730f, -0.03842068f, 0.03886241f, 0.00656097f, 
    0.00527605f, 0.03467796f, 0.02901499f, -0.03973454f, 0.00874438f, -0.06570937f, 0.04118813f, -0.04971176f, 
    0.03899699f, -0.04908811f, -0.02352411f, -0.00510247f, -0.05078728f, -0.03456392f, 0.01230892f, -0.00688384f, 
    0.04258817f, -0.06331346f, 0.04928137f, -0.06705263f, -0.00598293f, -0.06118086f, 0.04145255f, -0.03086837f, 
    -0.03897452f, -0.04374741f, 0.01721429f, 0.00129916f, -0.03015694f, 0.03592106f, 0.06563605f, 0.06143732f, 
    -0.02567528f, 0.03448559f, -0.01411300f, -0.06293022f, -0.07373436f, -0.03602453f, 0.04399686f, -0.01636503f, 
    -0.03814591f, -0.03389437f, -0.03912269f, -0.03794001f, 0.05262282f, 0.04897909f, -0.06982574f, -0.02118438f, 
    -0.06050007f, 0.06305751f, -0.06240168f, -0.07465261f, 0.01184294f, -0.03759618f, -0.02423766f, 0.00460840f, 
    -0.03582257f, -0.03142887f, 0.06321016f, 0.04994231f, 0.06473400f, -0.02907641f, 0.01917245f, -0.02100087f, 
    0.01769307f, -0.00007519f, 0.05202949f, -0.06905726f, -0.01899847f, -0.02931879f, -0.01944668f, 0.01431187f, 
    0.02223380f, 0.01270577f, -0.05579452f, -0.00527904f, -0.06371006f, -0.00525913f, 0.03023152f, -0.05542307f, 
    0.00778142f, 0.05747322f, -0.02328536f, -0.01547559f, 0.02574017f, 0.04817703f, 0.03208306f, 0.03797607f, 
    -0.07549708f, 0.04153663f, 0.06479482f, -0.05286244f, -0.02736204f, -0.00102767f, -0.04668326f, -0.02160469f, 
    -0.02970210f, 0.00257652f, -0.06587304f, 0.02213146f, -0.07206721f, -0.02659356f, -0.06479839f, -0.00206950f, 
    -0.04384473f, -0.02635327f, -0.07347274f, -0.06304099f, -0.00543115f, -0.00461868f, -0.00485874f, 0.00974778f, 
    -0.04880979f, -0.03361647f, 0.05881981f, 0.02367365f, -0.06463005f, 0.03328839f, -0.01818297f, 0.04477027f, 
    -0.01414985f, -0.03297692f, -0.06802803f, -0.07580663f, 0.04396180f, 0.04850822f, 0.02507117f, -0.00924708f, 
    -0.03328259f, -0.03448674f, -0.01377078f, 0.04895213f, 0.05661166f, -0.01168035f, 0.01092851f, 0.04131049f, 
    -0.11089638f, -0.04811489f, 0.18024869f, 0.00921935f, -0.09672110f, -0.09252670f, 0.02522768f, -0.09390673f, 
    0.01213896f, 0.08691107f, -0.08895009f, 0.06465875f, -0.52074564f, 0.24923284f, -0.03775994f, -0.12952687f, 
    -0.13860480f, 0.06085734f, 0.09707308f, 0.05098448f, -0.02234985f, 0.02844326f, 0.11981682f, 0.03375252f, 
    0.15828663f, 0.11035149f, -0.26037008f, -0.26595417f, 0.07383849f, 0.00493659f, 0.08687043f, 0.09558337f, 
    0.03931043f, 0.14547682f, 0.05829711f, 0.08029780f, 0.06401752f, 0.30719513f, -0.08788995f, -0.05740293f, 
    0.06703664f, -0.09372644f, -0.09378343f, 0.11985330f, 0.05207937f, 0.08601510f, 0.08089744f, -0.01341390f, 
    -0.12512003f, -0.20017862f, -0.03540681f, 0.31201208f, -0.09252612f, -0.07933389f, 0.00090438f, 0.04686375f, 
    0.05168029f, -0.16350687f, -0.02279672f, -0.20110039f, -0.14462551f, 0.22874561f, 0.08662917f, -0.11640294f, 
    0.10771801f, 0.03936162f, 0.11994459f, 0.17632876f, 0.03967963f, -0.04589892f, 0.09596969f, 0.12052481f, 
    0.05902027f, 0.05126516f, -0.06963200f, -0.14864431f, 0.08343618f, 0.21786897f, 0.07096810f, 0.09786719f, 
    0.06884889f, -0.01119600f, -0.08288648f, 0.08010452f, 0.09700989f, 0.03478701f, -0.03923936f, -0.20795114f, 
    -0.04152275f, 0.13457397f, -0.09980750f, -0.06023419f, 0.03268898f, -0.16327600f, -0.12122931f, -0.04546524f, 
    0.25303322f, 0.15648608f, 0.09006239f, -0.04518056f, -0.11600249f, -0.04901531f, 0.02481626f, -0.04120884f, 
    0.18288405f, -0.01631565f, 0.01671356f, -0.01736382f, -0.15065590f, 0.01851835f, -0.15901150f, -0.02244398f, 
    -0.08807158f, 0.01612649f, -0.01020753f, 0.03734292f, 0.07826102f, -0.02129375f, -0.00382790f, -0.07495848f, 
    0.00539817f, -0.15513617f, -0.04055740f, -0.03796850f, -0.10994213f, 0.14370635f, 0.00949861f, 0.05153147f, 
    0.02758877f, -0.17965607f, 0.05843744f, 0.00875584f, 0.07020057f, -0.04654917f, -0.09050605f, -0.11499399f, 
    -0.02905251f, -0.14968392f, -0.03926113f, -0.09442606f, 0.04820392f, -0.01995325f, -0.01263584f, 0.10948510f, 
    -0.07074466f, 0.15946853f, -0.12929615f, 0.06265765f, -0.10947435f, -0.03512847f, -0.01273539f, -0.02289131f, 
    0.11424796f, -0.04145782f, -0.03379290f, 0.04818574f, 0.16240619f, -0.18175372f, -0.38688695f, -0.06594087f, 
    0.04216823f, 0.12430523f, 0.01588773f, -0.02517305f, 0.08125105f, -0.00147443f, 0.01557000f, -0.00273482f, 
    0.19060232f, 0.20860834f, 0.25458938f, -0.02051020f, -0.12567350f, 0.05935513f, -0.13452280f, 0.05867656f, 
    0.14323099f, 0.02720441f, 0.03088173f, 0.08756054f, 0.23535016f, -0.07144018f, -0.25996059f, -0.21146636f, 
    0.12526695f, 0.13522750f, 0.13428490f, -0.09826786f, 0.02323566f, -0.09685945f, -0.00376459f, 0.14976859f, 
    -0.01319644f, -0.04480540f, 0.03078766f, -0.02004417f, 0.02073791f, -0.06988908f, 0.00288626f, -0.07183415f, 
    0.02283813f, 0.01102653f, 0.01271080f, -0.04822367f, -0.05577128f, 0.00567454f, -0.04196413f, 0.01564586f, 
    -0.06861596f, 0.01895948f, -0.06256872f, 0.05527375f, -0.01246299f, 0.00045749f, 0.04702076f, -0.05234249f, 
    -0.06583375f, -0.00129864f, -0.00766844f, -0.00410888f, 0.04611808f, 0.01870698f, -0.02266793f, 0.02604080f, 
    0.03893321f, 0.06894865f, 0.01822951f, 0.02979004f, 0.04074376f, 0.02142651f, -0.01805938f, -0.06753687f, 
    -0.04438802f, -0.07177515f, -0.01833174f, 0.04169860f, -0.06355951f, -0.05848447f, -0.01699722f, -0.00839356f, 
    -0.05559821f, -0.01463521f, 0.03994677f, -0.01274184f, 0.01842590f, -0.00171671f, -0.05236640f, -0.03355770f, 
    0.05179699f, 0.01354432f, 0.05459106f, -0.02898928f, 0.02363409f, -0.01559079f, -0.04251422f, -0.00817473f, 
    -0.02707709f, 0.01643318f, -0.01988454f, -0.02467179f, -0.06384087f, 0.04213186f, -0.03422190f, -0.03964745f, 
    0.03201076f, 0.00080244f, -0.06306247f, 0.03720433f, -0.00039841f, -0.04026861f, -0.00687334f, -0.05970915f, 
    -0.03798297f, -0.04048381f, -0.00218096f, -0.00111749f, 0.04632591f, -0.01673012f, 0.02135680f, 0.01498623f, 
    -0.00956543f, -0.03350352f, -0.03616195f, -0.06886465f, -0.00560573f, 0.06677809f, -0.01693738f, 0.06352729f, 
    -0.03104926f, 0.02514741f, -0.02191304f, -0.06445458f, -0.06476614f, -0.00924578f, 0.01958275f, 0.05941013f, 
    0.06720287f, 0.05084859f, -0.05041102f, 0.07042185f, -0.05284135f, -0.05106661f, -0.04762645f, -0.01971759f, 
    0.02416145f, -0.02834355f, 0.00827640f, -0.04561852f, -0.01702484f, -0.06251379f, -0.03021702f, -0.04292351f, 
    -0.00165049f, -0.00106279f, -0.01721354f, 0.01436041f, -0.03723392f, 0.07168931f, -0.01921861f, 0.01723008f, 
    0.04585787f, -0.04938079f, 0.06619985f, -0.06636020f, 0.03838144f, 0.04265451f, -0.03142498f, 0.03753686f, 
    0.05572335f, -0.04225312f, -0.03888753f, 0.03238117f, -0.03835860f, 0.02981326f, -0.04248927f, -0.02435339f, 
    -0.01894481f, -0.03585279f, 0.02458535f, 0.00812925f, -0.02591201f, 0.02437487f, -0.01298534f, -0.02590647f, 
    -0.06366556f, -0.07166909f, 0.01995620f, -0.01650951f, -0.04342369f, -0.04726437f, -0.00343865f, -0.05190656f, 
    0.06501530f, -0.00605441f, -0.05606671f, 0.03441276f, 0.04278858f, -0.05209303f, 0.04927789f, -0.07168439f, 
    0.01955272f, -0.02889348f, 0.03417882f, 0.01826669f, 0.05666529f, 0.04936492f, 0.03315754f, -0.05707490f, 
    0.00056068f, -0.05589294f, 0.00886855f, 0.02063067f, -0.02284213f, -0.04093001f, 0.02259253f, 0.05212517f, 
    -0.03957072f, -0.00641469f, 0.06646129f, 0.03012196f, -0.03179635f, -0.01001508f, 0.05663772f, -0.06673787f, 
    0.40090939f, 0.19622940f, 0.02127020f, 0.06644963f, 0.07081506f, 0.16111818f, 0.08799972f, -0.13239223f, 
    0.03237880f, -0.09972895f, 0.15739423f, 0.10944179f, 0.64529705f, -0.05070604f, 0.21030252f, 0.14522281f, 
    0.04943665f, -0.09876958f, -0.05773428f, -0.00448639f, 0.05941689f, 0.02125135f, -0.10927298f, 0.15113610f, 
    -0.01956407f, -0.01414094f, -0.13329399f, 0.22759135f, 0.02322834f, 0.00906737f, 0.15965022f, 0.07926696f, 
    0.05124945f, -0.00359517f, 0.01914580f, 0.13449875f, 0.14673564f, -0.25305963f, -0.13922979f, 0.06670779f, 
    -0.06497279f, 0.27536544f, 0.07002011f, -0.04454490f, 0.05145494f, -0.13191307f, -0.06286728f, 0.09972077f, 
    -0.04095881f, -0.04659509f, -0.06303862f, -0.11456549f, -0.11013932f, 0.11003931f, 0.14796987f, -0.16791631f, 
    0.06600346f, 0.03176330f, -0.00826443f, -0.00080065f, -0.13965023f, 0.19349812f, -0.34459403f, 0.11401358f, 
    -0.09026852f, -0.02166014f, -0.10005084f, -0.07906546f, -0.07452802f, 0.11579235f, 0.02673437f, -0.15053667f, 
    -0.08082646f, -0.02591588f, 0.04006158f, 0.06655935f, -0.02967785f, -0.14329718f, -0.11597001f, -0.03145257f, 
    0.04126310f, -0.04235127f, 0.17476986f, 0.00801591f, 0.03376459f, 0.07953127f, -0.09224761f, 0.22607367f, 
    -0.08015895f, -0.11031660f, -0.00916466f, 0.11981237f, 0.02525574f, 0.02364911f, 0.03567461f, 0.18484825f, 
    -0.00864534f, 0.12880719f, -0.15060037f, -0.10157306f, 0.09030095f, 0.13814871f, -0.08106807f, -0.10886033f, 
    -0.27183852f, -0.00261694f, -0.17035010f, -0.10925717f, 0.38154498f, 0.16072166f, 0.09226710f, 0.08845204f, 
    -0.12944016f, -0.11527987f, -0.06253947f, 0.04417539f, -0.06152638f, -0.01115754f, 0.08270217f, 0.00322097f, 
    -0.29352272f, 0.07767030f, 0.01602735f, 0.06136738f, -0.04560099f, -0.11202237f, 0.14411947f, -0.03115634f, 
    -0.03631902f, -0.02023493f, -0.13376760f, 0.11913016f, 0.10073930f, 0.04643574f, 0.07708168f, -0.14230865f, 
    0.04217993f, -0.03042533f, 0.01966955f, 0.01639247f, 0.03208595f, -0.00573662f, 0.16299863f, 0.08967516f, 
    -0.71820509f, 0.25682864f, 0.01645792f, -0.10225318f, -0.02610734f, 0.01977441f, -0.13548139f, -0.32478985f, 
    -0.04219488f, -0.07023426f, 0.00250551f, 0.04641306f, -0.03167260f, -0.32108498f, 0.28863305f, 0.21832289f, 
    0.11667662f, 0.15085775f, 0.01800099f, 0.09714620f, 0.12590277f, -0.06986469f, -0.06964779f, -0.16366337f, 
    0.28689331f, -0.06716380f, 0.11173915f, 0.29511195f, 0.13534462f, -0.06691986f, 0.02049762f, -0.16817880f, 
    -0.04935954f, 0.03456575f, 0.09827968f, 0.06031490f, 0.06749127f, -0.00908340f, -0.03879374f, 0.28939995f, 
    0.09627724f, -0.11500175f, 0.07257079f, 0.18105192f, -0.11534774f, 0.03024224f, 0.14770149f, 0.01429052f, 
    -0.04727693f, 0.00177272f, -0.24406491f, 0.06100734f, 0.09311417f, -0.03243257f, -0.05224150f, 0.03338276f, 
    0.13991402f, 0.03346680f, 0.16215636f, -0.01739338f, -0.13133907f, 0.11052409f, 0.05626639f, 0.17709908f, 
    0.05182326f, 0.12611490f, 0.00421345f, 0.21104948f, 0.06630051f, 0.09625240f, -0.04998165f, -0.10663438f, 
    -0.00488566f, -0.06679670f, 0.00401786f, 0.03055339f, 0.08336379f, -0.05444735f, -0.06812297f, -0.14471529f, 
    -0.05480566f, 0.04434512f, -0.09657765f, -0.08024651f, -0.15498871f, -0.22870676f, -0.10581461f, 0.13679722f, 
    0.09158494f, -0.07184874f, 0.14185156f, -0.11216476f, -0.06343845f, 0.02655273f, 0.04058856f, -0.09165527f, 
    0.11132244f, 0.02515441f, 0.00880264f, 0.06637595f, -0.06861809f, -0.10011842f, -0.15867212f, 0.03002300f, 
    -0.04187565f, -0.08155680f, -0.16999547f, -0.05453778f, 0.20060934f, -0.08841583f, -0.00923247f, -0.01373106f, 
    -0.07403824f, 0.24199331f, -0.09197889f, 0.22775820f, 0.08433669f, -0.08933066f, -0.08629276f, -0.03669951f, 
    0.07987947f, 0.12458114f, -0.08555102f, 0.12990734f, -0.06030612f, 0.25272727f, 0.18240283f, -0.07067286f, 
    0.05561142f, 0.01798905f, -0.06308939f, -0.07579553f, -0.15497716f, 0.28211063f, 0.18176872f, 0.14095157f, 
    -0.08972659f, -0.00395393f, 0.27652949f, -0.17268336f, -0.09782641f, -0.01774705f, -0.03900930f, -0.13555960f, 
    -0.22944862f, 0.12277078f, -0.18529636f, 0.13283801f, -0.01684559f, -0.09894842f, 0.15097891f, 0.21517724f, 
    0.02923522f, 0.01799436f, 0.09433629f, 0.16461667f, 0.50602639f, -0.43448952f, 0.57088870f, -0.10558096f, 
    0.03654787f, -0.01206766f, 0.07330726f, 0.09443600f, -0.09300362f, -0.03575179f, 0.08915589f, -0.03216569f, 
    -0.10177489f, 0.32792091f, 0.01705495f, 0.00565860f, 0.00580663f, -0.02775239f, 0.01792628f, -0.01709049f, 
    0.00281326f, 0.06464557f, -0.04816923f, -0.03288418f, -0.04780268f, 0.09107620f, -0.23625669f, 0.03046623f, 
    -0.05264344f, 0.11048879f, -0.00858178f, 0.05792315f, 0.04486543f, 0.03732386f, 0.01542699f, -0.09486211f, 
    0.32184914f, -0.15410306f, 0.12657148f, 0.01289977f, -0.12132444f, -0.03447251f, 0.04522390f, 0.00592859f, 
    -0.07586601f, 0.09889698f, -0.06807838f, -0.02758181f, 0.14293657f, -0.07716643f, 0.05022607f, -0.00835121f, 
    0.09941061f, 0.13949575f, -0.01890744f, -0.00664177f, -0.12867999f, -0.00383899f, 0.16870105f, -0.00696140f, 
    -0.59717947f, 0.53840208f, 0.01925491f, 0.01910698f, -0.01191622f, -0.05906145f, 0.13212788f, 0.14089265f, 
    0.03353436f, 0.00424954f, -0.07594482f, 0.02129646f, -0.08235847f, -0.13832559f, -0.01584556f, 0.18916161f, 
    0.00550379f, 0.14509521f, -0.10980515f, -0.10290774f, 0.05655468f, 0.02480788f, 0.08299057f, -0.04435729f, 
    0.06605389f, -0.02730322f, -0.09662997f, 0.05423439f, 0.11996493f, 0.07260725f, -0.00117375f, -0.01269743f, 
    -0.22884487f, -0.01365376f, -0.00769369f, -0.09073491f, 0.34723261f, 0.09980401f, 0.13455057f, 0.19753869f, 
    0.13733000f, -0.14449120f, -0.01610704f, -0.00283596f, 0.11918800f, -0.02062800f, 0.07133169f, 0.04701552f, 
    -0.30707127f, -0.09713428f, 0.31457362f, 0.03796683f, 0.10637157f, 0.13395599f, -0.05111471f, -0.13519858f, 
    -0.03689728f, 0.05450225f, -0.07610386f, -0.07061507f, -0.24922991f, -0.30132428f, 0.23834565f, 0.04783061f, 
    -0.01151610f, 0.05743945f, 0.00241521f, -0.01207922f, -0.12900235f, -0.00120708f, 0.04561242f, -0.01335716f, 
    0.14362420f, 0.13174745f, 0.01205315f, -0.05973214f, 0.09451860f, 0.03147238f, 0.11113654f, 0.00378625f, 
    0.02662466f, 0.13208574f, 0.07056414f, 0.06574181f, 0.13587078f, -0.20302454f, 0.09031892f, 0.04785363f, 
    0.11152221f, -0.08137720f, -0.02363687f, 0.11930241f, 0.07168812f, 0.13446316f, -0.04495233f, -0.00605786f, 
    -0.00517757f, 0.04599773f, -0.05492665f, 0.01584780f, 0.01073722f, -0.06049368f, 0.14601351f, 0.05556006f, 
    -0.15002151f, -0.10299406f, -0.02780182f, -0.09095871f, -0.24695836f, -0.14855558f, 0.06779095f, 0.01445288f, 
    0.00285048f, -0.12832314f, 0.18053375f, -0.04414590f, 0.01417142f, -0.04769446f, -0.14490828f, -0.05997657f, 
    -0.10077316f, 0.03981346f, 0.10682859f, -0.08451917f, 0.16992062f, 0.02589745f, 0.04599472f, -0.05831875f, 
    0.06741817f, 0.00842307f, 0.09546541f, 0.15700218f, -0.06517818f, 0.15441355f, 0.09780909f, 0.13355255f, 
    0.02982227f, 0.03713059f, 0.32419550f, -0.04438345f, -0.04631836f, 0.16515407f, 0.12502977f, 0.14629377f, 
    0.16165505f, 0.22971791f, 0.05557865f, -0.03258115f, 0.02678003f, -0.05151646f, 0.10535375f, -0.09637865f, 
    0.09142340f, 0.02679922f, -0.05674100f, -0.05743342f, 0.05532073f, -0.02040557f, 0.03175359f, 0.03222558f, 
    0.09799499f, 0.05039376f, -0.03997270f, 0.05790076f, -0.03876891f, -0.00738922f, -0.06499266f, -0.08010569f, 
    0.33883908f, 0.00329832f, 0.04948616f, 0.07814831f, -0.01776312f, -0.02758789f, -0.10009052f, -0.01915807f, 
    0.01255043f, -0.04808831f, 0.14288794f, 0.10380198f, -0.13311498f, 0.15088239f, 0.16746330f, -0.18647176f, 
    0.07510342f, -0.06250128f, 0.00256880f, 0.04367148f, 0.00158268f, -0.05866403f, -0.03724074f, -0.09250935f, 
    -0.01594066f, -0.04492534f, -0.02007906f, 0.05583658f, 0.00844866f, -0.21229948f, 0.07431187f, 0.03856141f, 
    0.06867999f, 0.05634931f, 0.13659182f, 0.06334618f, -0.23848063f, 0.02811234f, 0.37254244f, -0.05720542f, 
    -0.01796512f, 0.06353847f, -0.07238214f, 0.17581823f, -0.09083880f, 0.13280480f, 0.07630312f, 0.07323099f, 
    0.00265479f, 0.04492065f, -0.00048195f, -0.02237395f, -0.01952613f, -0.07140831f, 0.06183223f, 0.05908288f, 
    -0.02999834f, 0.02778275f, -0.03915316f, 0.05541388f, 0.02313836f, 0.00461046f, -0.06611842f, -0.02135633f, 
    -0.02634354f, -0.05013518f, 0.05445507f, -0.00554148f, 0.03491475f, 0.00240450f, -0.06483059f, 0.05396973f, 
    -0.04378290f, -0.02145211f, -0.03400400f, 0.04320735f, -0.01118921f, -0.00408527f, 0.02827167f, 0.05521599f, 
    0.06789871f, 0.05618185f, 0.00131537f, -0.06590706f, 0.00780503f, -0.02665288f, -0.00389484f, -0.06454034f, 
    0.00844772f, -0.01143468f, 0.01639343f, 0.01509437f, 0.03226779f, 0.04444651f, 0.04304640f, -0.03155459f, 
    -0.04381689f, -0.02857727f, 0.00442950f, -0.03106982f, -0.06858185f, 0.06493351f, -0.06426025f, 0.03157803f, 
    0.01469884f, 0.01986758f, 0.04361684f, -0.04046089f, 0.06687524f, 0.03726791f, -0.02519219f, 0.00574974f, 
    0.05091615f, 0.06330469f, 0.00557785f, -0.04584660f, -0.00013097f, 0.05770171f, -0.05109039f, -0.05658136f, 
    -0.06942763f, -0.03210626f, -0.02218990f, -0.05381577f, 0.00107610f, 0.05978434f, 0.00621034f, -0.04768591f, 
    -0.04567550f, -0.03508743f, -0.06955272f, -0.02454323f, -0.00136337f, -0.03182287f, -0.01452902f, 0.00360162f, 
    -0.04179632f, -0.06586913f, -0.03933264f, -0.02167516f, 0.01999076f, -0.03610302f, -0.05322834f, -0.02268984f, 
    0.01260589f, 0.01439978f, -0.06785735f, 0.04000302f, -0.05422951f, 0.06471527f, -0.02798289f, 0.00319365f, 
    -0.05355376f, 0.00766358f, 0.01054093f, 0.00239609f, -0.03017908f, -0.00745397f, -0.06803544f, -0.06307334f, 
    0.06100672f, 0.03713097f, -0.01799889f, 0.01800169f, -0.04779656f, 0.01978558f, 0.00921913f, 0.00078289f, 
    -0.01097467f, -0.04874941f, -0.04856395f, -0.07056161f, -0.02278773f, -0.04546088f, 0.06129368f, 0.06233237f, 
    -0.03767383f, -0.02246731f, -0.03502915f, 0.06055082f, 0.03753735f, 0.02898017f, -0.04251251f, 0.06881903f, 
    -0.02017281f, -0.06884657f, -0.04443818f, -0.01566064f, 0.07023764f, 0.03035266f, 0.03306166f, -0.03662216f, 
    -0.04957549f, 0.07145309f, -0.04459013f, 0.04983943f, 0.04136027f, -0.01142045f, -0.04213404f, 0.03936435f, 
    -0.04484779f, -0.03896200f, 0.06340475f, -0.01728871f, -0.03730591f, -0.01028828f, 0.04798284f, -0.00250146f, 
    -0.05352731f, -0.00929556f, -0.06145804f, -0.05068525f, 0.00922392f, -0.00672752f, -0.05876902f, -0.05113003f, 
    -0.06383367f, 0.01658875f, -0.04432870f, 0.05529398f, -0.02195582f, -0.06682654f, 0.05852119f, 0.00672284f, 
    -0.00082956f, -0.03386030f, 0.04677065f, -0.06622013f, -0.04461454f, -0.04386359f, 0.07012946f, 0.05009667f, 
    0.03865413f, -0.01323150f, 0.03114032f, 0.03698763f, -0.01838592f, -0.05785316f, -0.00465395f, -0.04316880f, 
    -0.25574943f, -0.01211325f, 0.02190858f, -0.04022039f, -0.08547138f, -0.12588793f, -0.07356184f, -0.09938578f, 
    0.05439012f, 0.15000351f, 0.06061503f, 0.08533360f, -0.45134875f, -0.00765436f, -0.02112442f, -0.07720736f, 
    -0.12175684f, -0.08429784f, 0.03735748f, 0.16839321f, 0.00181646f, -0.06310088f, 0.05064366f, -0.08819536f, 
    0.02420132f, 0.14308757f, 0.19129063f, -0.15866040f, 0.16138639f, 0.07736429f, -0.07411265f, 0.12108595f, 
    -0.06518341f, -0.12981611f, 0.03052637f, -0.02908486f, -0.18197714f, 0.08973150f, 0.35264912f, 0.11546003f, 
    -0.05163236f, -0.09726608f, 0.02990841f, 0.11241355f, 0.12531044f, 0.06412911f, 0.04101888f, 0.01174691f, 
    -0.19315572f, -0.20590575f, -0.09027663f, 0.12818907f, 0.16942564f, -0.02951691f, -0.21259625f, 0.13654858f, 
    -0.06832080f, 0.06875493f, 0.04273471f, -0.07304715f, 0.05845807f, -0.06031461f, 0.35517824f, -0.07634959f, 
    0.12830350f, 0.08823003f, -0.08194158f, 0.16194712f, -0.00873799f, -0.00897350f, -0.13043515f, 0.13050507f, 
    0.15253466f, -0.11347868f, 0.10919127f, 0.10993337f, 0.04462958f, 0.21536677f, 0.17864820f, -0.07777312f, 
    0.15684037f, 0.14631778f, -0.08724342f, -0.27089742f, -0.07838237f, 0.15205699f, 0.00124160f, 0.10058919f, 
    0.08008324f, 0.01613147f, 0.20608170f, 0.00583444f, 0.03089426f, 0.14495368f, 0.01567983f, -0.06886297f, 
    -0.09871647f, -0.16641362f, 0.06000681f, 0.19246158f, -0.18632549f, -0.19110738f, 0.00121838f, 0.19132164f, 
    0.19162123f, -0.09103538f, 0.03356788f, 0.01546307f, -0.03173563f, 0.12301854f, -0.18256462f, -0.10154220f, 
    0.11072428f, -0.07855448f, 0.11789249f, 0.07848088f, 0.10426641f, -0.06007842f, -0.02982677f, 0.02995905f, 
    0.06483012f, -0.26500264f, -0.14343573f, -0.03272495f, -0.01926416f, 0.06835340f, -0.11941412f, 0.11793023f, 
    -0.10376409f, -0.07709799f, 0.08333320f, -0.14809775f, -0.22534111f, -0.06437954f, -0.06092633f, -0.09503845f, 
    -0.02907048f, -0.01048351f, 0.14921002f, -0.01994989f, 0.08331977f, 0.10565821f, 0.06622730f, 0.06082362f, 
    0.55645102f, -0.02311393f, -0.27786881f, 0.21839862f, -0.14257461f, 0.05316813f, 0.06154128f, -0.07367685f, 
    -0.00418061f, 0.04831466f, -0.11611651f, 0.00172205f, -0.00588458f, 0.06784515f, -0.10041718f, -0.09428174f, 
    0.00686670f, 0.05618050f, -0.00827986f, -0.02788061f, 0.08757292f, 0.00154500f, 0.20812435f, -0.07754301f, 
    -0.40767354f, 0.27883881f, 0.09085511f, -0.01515080f, -0.11701766f, -0.07729712f, -0.09536529f, 0.20522088f, 
    -0.01725906f, -0.04479761f, -0.11419926f, 0.08446766f, 0.02542635f, 0.12500130f, 0.15547134f, 0.06352649f, 
    0.05675488f, 0.15321423f, -0.12881936f, 0.06167369f, 0.12523949f, -0.17358623f, 0.05489632f, 0.11104444f, 
    0.02605174f, -0.15524484f, 0.14545572f, -0.00451935f, -0.10840389f, 0.15029252f, -0.12277131f, 0.00573909f, 
    0.20897906f, 0.19312857f, 0.06525099f, 0.20727655f, 0.07707664f, 0.02579872f, -0.03349808f, 0.20160459f, 
    -0.06579474f, -0.08852756f, 0.11353327f, 0.03108615f, -0.01928551f, 0.05111958f, 0.05233244f, 0.09868461f, 
    0.00922556f, -0.19854657f, -0.29597020f, -0.07522456f, 0.03410865f, 0.00782007f, 0.02834302f, 0.10418355f, 
    -0.07764303f, -0.06369505f, 0.04043706f, 0.02988875f, 0.07751258f, 0.30349782f, 0.20416363f, -0.01915933f, 
    0.19917598f, -0.15012053f, 0.04689809f, 0.09995853f, -0.13748844f, -0.02396817f, 0.01208111f, -0.20823760f, 
    -0.38338047f, -0.14667240f, -0.03948633f, -0.18849103f, -0.19470476f, -0.25480732f, -0.24605440f, -0.04613468f, 
    -0.03028456f, -0.16757208f, -0.12479818f, -0.21200846f, 0.10527135f, -0.01534991f, -0.09457664f, 0.19845420f, 
    0.06315135f, 0.24666922f, 0.00032353f, 0.15413141f, -0.11773489f, 0.07531600f, -0.02364523f, 0.16180386f, 
    -0.03324004f, 0.08363077f, -0.03599601f, -0.07103589f, 0.04598006f, 0.17308784f, 0.20943439f, -0.12588191f, 
    0.14198133f, 0.21074022f, 0.24372385f, 0.16049558f, 0.05096497f, 0.23343576f, 0.06401332f, 0.09630011f, 
    0.15756360f, 0.16881394f, 0.15357675f, 0.06874935f, 0.03128019f, 0.24112318f, 0.03866812f, -0.17447428f, 
    0.00604519f, 0.16911981f, -0.01335510f, -0.05063459f, -0.23340867f, -0.09549528f, -0.01896811f, 0.08551808f, 
    0.06525937f, 0.00767560f, 0.23326156f, -0.01055547f, 0.32700658f, 0.10791788f, -0.13676526f, 0.27553385f, 
    0.02664290f, 0.17541607f, 0.06006496f, 0.14844774f, 0.01671973f, 0.09701984f, -0.05080940f, 0.13170543f, 
    -0.33524707f, 0.06881926f, -0.25798753f, -0.04022405f, -0.16947684f, 0.10834004f, -0.18231103f, -0.09326884f, 
    -0.09822503f, -0.03703202f, 0.04412265f, -0.12456825f, -0.35017484f, -0.09277762f, -0.29336554f, -0.15753028f, 
    -0.12239191f, 0.02745713f, -0.01052724f, -0.04470840f, 0.06262485f, 0.15131374f, 0.15073772f, 0.20884426f, 
    -0.14899161f, -0.00606350f, 0.23971075f, -0.00914337f, -0.14986275f, -0.02256389f, -0.10643028f, -0.15155488f, 
    0.06865764f, 0.00640053f, 0.02689377f, -0.20306285f, -0.18851946f, -0.32809374f, 0.10167302f, 0.03627658f, 
    0.01184625f, 0.24647385f, -0.14859958f, -0.00006617f, 0.13921782f, 0.06645112f, 0.05287167f, 0.20566157f, 
    -0.06633815f, 0.04098952f, 0.09378843f, 0.01364890f, 0.07999216f, 0.01296983f, -0.09201551f, -0.00495887f, 
    -0.02211524f, 0.13346964f, -0.00255455f, -0.04452408f, 0.11044389f, 0.07794949f, -0.01701342f, 0.17232104f, 
    0.01046718f, 0.19461183f, 0.04609379f, -0.09673367f, 0.00348670f, -0.09110607f, -0.01212489f, 0.08209421f, 
    -0.13567981f, -0.28882530f, 0.11986230f, -0.19154528f, -0.07584029f, 0.05036847f, 0.03037080f, -0.03083379f, 
    0.07645848f, 0.02825399f, 0.11300972f, 0.13209619f, 0.16413547f, -0.11896850f, -0.12291343f, 0.05421723f, 
    0.01156148f, 0.17145206f, 0.13249794f, -0.02865612f, -0.05058063f, 0.00667673f, -0.12170099f, 0.06694311f, 
    0.02597102f, -0.07362458f, -0.23064452f, 0.08357463f, -0.17277443f, -0.05555482f, 0.08635607f, -0.08065304f, 
    0.04509867f, -0.06280420f, -0.00883840f, 0.09850337f, 0.14988090f, 0.17622578f, -0.13818407f, -0.16428465f, 
    0.10225254f, 0.00909907f, 0.06666582f, 0.13644090f, 0.00553561f, -0.00255869f, 0.06978547f, -0.19927406f, 
    -0.13083099f, 0.14973982f, 0.09295019f, -0.17945874f, -0.20838659f, -0.06613072f, -0.09190404f, -0.04900773f, 
    -0.11409290f, -0.09719428f, -0.06092972f, 0.06210581f, 0.05009991f, -0.00159616f, -0.11874860f, 0.22273141f, 
    0.09313747f, -0.07155029f, 0.16300873f, 0.00177145f, -0.01969478f, -0.05689748f, 0.05533986f, 0.05513214f, 
    -0.04281427f, 0.00713488f, -0.09122609f, -0.11292487f, 0.03967830f, -0.12572844f, -0.01249423f, -0.02622377f, 
    0.07415877f, -0.01158178f, 0.19494697f, 0.21369760f, 0.01328726f, -0.10761604f, 0.11020715f, -0.05961917f, 
    0.02218020f, 0.07969378f, 0.09081186f, -0.00369910f, 0.03403492f, 0.01129275f, 0.01109991f, -0.18648829f, 
    0.16378531f, 0.09355927f, 0.13402048f, -0.17140335f, -0.06936501f, 0.17315085f, -0.08403598f, -0.13060044f, 
    0.12705819f, -0.01808607f, 0.09332415f, 0.08018410f, -0.20148344f, -0.14936469f, -0.00584201f, 0.12861799f, 
    0.00948208f, 0.27450752f, -0.04538615f, 0.03276980f, 0.09737404f, 0.10524495f, 0.09977943f, 0.05494533f, 
    0.04111283f, 0.25694558f, 0.12925684f, 0.00128226f, -0.07721917f, -0.06924728f, 0.15216790f, -0.13268875f, 
    0.07157272f, -0.08855909f, 0.03021148f, 0.01262440f, -0.01090748f, -0.22891141f, -0.06945615f, -0.12500936f, 
    -0.10993436f, 0.08121183f, -0.16373716f, -0.03390582f, 0.03824928f, 0.13749331f, 0.01930520f, 0.06421490f, 
    -0.25405645f, 0.03559326f, 0.35224071f, -0.12276956f, 0.03727490f, -0.05074448f, -0.23226191f, 0.00470670f, 
    0.04254180f, -0.12911853f, -0.07738117f, 0.05230184f, -0.01312697f, 0.07570495f, -0.09460858f, 0.03624742f, 
    -0.09089834f, 0.04611189f, -0.10719267f, 0.20713671f, -0.14429149f, 0.02898107f, -0.00053001f, 0.13322350f, 
    0.44627127f, -0.33865359f, -0.31147406f, -0.09456406f, 0.08820520f, 0.10723544f, 0.02913353f, -0.13132001f, 
    0.16553737f, 0.04432048f, -0.11666084f, 0.02838711f, -0.00059476f, -0.00732465f, -0.07981151f, -0.04441964f, 
    0.04516821f, 0.11448814f, 0.23635365f, -0.08925192f, -0.02835847f, 0.05295933f, -0.07656785f, 0.11349013f, 
    -0.17867859f, -0.17693211f, -0.03061697f, -0.08275376f, 0.04719504f, 0.06817661f, -0.11592898f, -0.00931636f, 
    0.00360918f, -0.00896256f, -0.09207641f, -0.02530035f, 0.11684103f, -0.07395649f, -0.08158148f, -0.08304290f, 
    0.15663166f, 0.10177375f, 0.03038595f, -0.01675756f, 0.02588691f, 0.02969925f, 0.10594992f, 0.15023054f, 
    0.16415322f, -0.00883760f, -0.17302074f, 0.06402702f, -0.15775675f, 0.07215434f, 0.13651389f, 0.05004123f, 
    -0.13066214f, -0.09292657f, 0.05458518f, 0.06894091f, 0.13659516f, 0.26803580f, -0.08490353f, -0.06699421f, 
    0.15304804f, -0.02537310f, -0.01137475f, 0.16457893f, -0.03370324f, 0.05642649f, 0.07217535f, -0.01815491f, 
    -0.02022960f, 0.26845565f, 0.12892589f, 0.00933370f, -0.13791470f, -0.07763225f, -0.06756961f, -0.02686063f, 
    -0.00606219f, -0.05611960f, -0.11630907f, 0.09795630f, 0.21704069f, -0.02599282f, 0.23726887f, 0.13161436f, 
    0.15590142f, -0.04909717f, 0.14292009f, 0.00561603f, 0.02347839f, -0.17878564f, 0.09643613f, 0.08396107f, 
    0.19996558f, -0.02246071f, -0.15588896f, 0.00708528f, 0.07352123f, -0.17224796f, -0.12105154f, 0.04470835f, 
    0.00473010f, -0.09653397f, 0.14728200f, -0.07204313f, 0.19848543f, -0.08277500f, 0.23574279f, 0.14141479f, 
    0.06858309f, 0.03480884f, 0.10494555f, -0.06952938f, -0.00342269f, -0.00754082f, 0.04721157f, -0.13081965f, 
    0.10174230f, -0.04079237f, 0.17152825f, 0.07130731f, -0.02308623f, 0.11090807f, -0.17067765f, -0.21197128f, 
    0.01501409f, 0.02316640f, 0.24495101f, 0.06282340f, -0.23492619f, -0.18313299f, 0.04991317f, 0.10115731f, 
    0.11350086f, 0.14289586f, 0.07635479f, 0.05896189f, 0.05276832f, 0.06273821f, 0.04183465f, 0.09707765f, 
    0.12031598f, 0.14806837f, 0.07417438f, 0.09749068f, -0.09318365f, -0.08702183f, 0.12896995f, -0.11894898f, 
    0.05073266f, -0.03307793f, 0.09858365f, 0.05351564f, 0.00886440f, -0.17561245f, -0.03492744f, -0.13012104f, 
    -0.11406533f, 0.06976549f, -0.18184234f, -0.02713669f, 0.02240951f, 0.06111982f, -0.12246098f, -0.12103463f, 
    0.20406567f, -0.03487382f, 0.55982149f, 0.16150275f, 0.08510504f, 0.02848487f, -0.16332065f, 0.13672718f, 
    -0.02332676f, 0.00318437f, -0.02129549f, 0.06345951f, 0.02716565f, 0.19658221f, -0.03643894f, -0.03021224f, 
    -0.16547854f, 0.10407093f, -0.28087735f, 0.20485587f, -0.14201367f, 0.03436012f, 0.03497425f, 0.02476287f, 
    0.13612008f, -0.25676522f, -0.13406771f, 0.00242464f, 0.12925448f, 0.09637503f, -0.08512475f, -0.22389272f, 
    0.06867864f, -0.15666075f, -0.02851479f, 0.03236371f, -0.00721528f, 0.09999458f, -0.01047471f, -0.06386428f, 
    -0.02511634f, 0.27785718f, 0.10991866f, 0.12786111f, -0.05002525f, 0.00278789f, -0.02108328f, 0.08093525f, 
    -0.39453086f, -0.21410821f, -0.04943465f, -0.10434423f, 0.03312876f, -0.03907508f, -0.17061836f, 0.01071406f, 
    0.12710461f, 0.04798185f, -0.05725874f, 0.05214043f, -0.06148849f, -0.23997201f, -0.06865489f, 0.05946624f, 
    0.06220371f, -0.03850476f, -0.03699822f, 0.15610649f, 0.02347239f, 0.02735490f, 0.29305780f, -0.08355313f, 
    0.18515313f, -0.02002874f, 0.25673264f, -0.05394619f, 0.08721302f, 0.04404737f, -0.06493983f, 0.05965247f, 
    -0.06328123f, 0.04854171f, 0.07417145f, -0.05180347f, 0.03659338f, 0.30009872f, 0.06583411f, -0.11645501f, 
    0.09834613f, -0.06317362f, -0.02896823f, 0.06437040f, -0.01823676f, 0.12204601f, -0.01287528f, 0.10766021f, 
    -0.23764761f, 0.09145679f, 0.14711906f, 0.04108770f, 0.08794603f, 0.04296334f, -0.17693409f, 0.19823866f, 
    0.03135807f, 0.05464809f, -0.03613710f, 0.02605905f, 0.51103538f, -0.04604279f, 0.45570117f, -0.26959774f, 
    0.24137887f, 0.03670724f, -0.04487234f, 0.10839964f, -0.05014965f, 0.00055876f, -0.07656082f, 0.10950673f, 
    0.13170968f, 0.06379307f, 0.02513767f, 0.05915936f, -0.00010194f, 0.07354956f, 0.18365769f, -0.14103730f, 
    -0.02224248f, -0.03084410f, -0.08784927f, -0.21051289f, 0.16454883f, -0.18406220f, -0.07085173f, 0.05601595f, 
    0.13948436f, 0.06188834f, -0.05931703f, -0.33996153f, -0.02803778f, -0.06836309f, -0.12128833f, -0.01060492f, 
    -0.08746390f, -0.11725777f, 0.08765897f, 0.14047453f, -0.03013434f, -0.14098479f, -0.01918360f, -0.00891840f, 
    0.19689031f, -0.03633310f, 0.24554521f, 0.18192478f, -0.08486324f, -0.05735807f, 0.15864046f, 0.28524333f, 
    0.12955494f, 0.03455895f, 0.13437663f, 0.01803024f, -0.00906881f, 0.08545065f, -0.07091429f, 0.00156874f, 
    -0.08893894f, -0.24449661f, 0.03736218f, 0.14279665f, 0.15140153f, 0.15544733f, -0.01526383f, 0.17176767f, 
    -0.06774577f, 0.08353858f, -0.04323634f, -0.08931219f, -0.36539462f, -0.02201764f, -0.12296006f, 0.00460286f, 
    -0.11474710f, 0.13245696f, -0.09179637f, 0.06230034f, 0.09493110f, -0.05111349f, -0.00447056f, -0.09030961f, 
    0.61935663f, -0.24464585f, 0.27334067f, 0.26466104f, 0.09385447f, 0.04330477f, -0.07346918f, 0.30713534f, 
    0.00284445f, -0.02329198f, 0.04558950f, -0.04507632f, -0.24708882f, 0.22234099f, 0.00414078f, -0.10901675f, 
    0.07638198f, 0.11380950f, -0.03280665f, -0.02269164f, -0.04196372f, -0.05762372f, 0.07844132f, 0.00902798f, 
    -0.41653809f, -0.03040414f, -0.12248521f, -0.14626588f, -0.01705172f, -0.04497629f, -0.02973686f, 0.11049555f, 
    0.09982697f, -0.04217932f, -0.03222516f, 0.10145549f, -0.17123251f, 0.22894934f, -0.06113332f, -0.08123168f, 
    -0.02255709f, 0.08208621f, -0.14368154f, -0.09504528f, 0.03026599f, 0.08063214f, 0.05343821f, -0.01954486f, 
    0.06685744f, -0.04355974f, 0.04501683f, 0.01300853f, 0.03636760f, 0.05021399f, 0.03687115f, -0.00695479f, 
    -0.07939997f, 0.01556507f, -0.07348763f, 0.00295419f, -0.03177167f, 0.04854984f, 0.02238947f, 0.03031990f, 
    -0.00003180f, -0.00878466f, -0.04093734f, -0.06021950f, -0.06954435f, -0.09171580f, -0.07551827f, -0.09170356f, 
    -0.01129770f, 0.05345573f, 0.01206522f, -0.07767583f, -0.10172089f, 0.04840936f, -0.07190919f, -0.01567873f, 
    0.01899353f, -0.01765529f, 0.03973827f, -0.05398888f, 0.01014731f, -0.05594414f, -0.02061643f, -0.03612535f, 
    -0.06517256f, -0.07002627f, -0.08002768f, -0.02599488f, 0.04024457f, -0.07202513f, -0.08230291f, -0.03656906f, 
    -0.04657510f, -0.00385654f, 0.07128462f, -0.02493621f, 0.05188843f, 0.00312251f, -0.05808668f, 0.05812401f, 
    -0.07211218f, 0.04722522f, -0.03853165f, -0.01517704f, -0.02989016f, 0.01059843f, -0.03936915f, -0.08570371f, 
    -0.08555594f, -0.04274688f, 0.05353985f, 0.03469409f, -0.03020758f, -0.02402918f, -0.02004712f, 0.03779312f, 
    -0.01292485f, 0.03823911f, -0.07497985f, 0.01923866f, -0.04777718f, -0.04598813f, -0.01807766f, -0.06157826f, 
    0.02162941f, 0.02025576f, -0.01198429f, 0.05797170f, -0.07274608f, -0.06071772f, 0.01084563f, 0.00225630f, 
    0.02001433f, 0.04216982f, -0.02809681f, -0.03940237f, 0.02562533f, -0.06985825f, 0.01714630f, 0.02980745f, 
    -0.05235643f, -0.09270656f, 0.04205873f, -0.07572799f, 0.01897665f, -0.02649524f, 0.02745922f, 0.03722279f, 
    -0.07819903f, 0.00926669f, -0.07231541f, 0.00348272f, 0.03905123f, -0.06305327f, -0.04171879f, -0.07349554f, 
    -0.06898048f, 0.00288404f, -0.09041128f, 0.01134743f, 0.00443652f, -0.06447130f, 0.02016291f, -0.00941065f, 
    -0.01746555f, 0.03727058f, -0.07173868f, -0.05791603f, -0.06292940f, -0.03052879f, 0.06832176f, -0.02164053f, 
    -0.06644519f, -0.07253607f, 0.06443409f, -0.02219661f, -0.02815059f, 0.03763074f, 0.00341787f, -0.06003562f, 
    -0.01005008f, -0.04024165f, 0.00022561f, -0.03154495f, -0.06800374f, -0.07579895f, 0.04223134f, -0.05397835f, 
    -0.05663641f, -0.06461290f, -0.01323294f, 0.02863572f, 0.01341483f, -0.01503226f, -0.00011591f, -0.02091490f, 
    0.00219310f, -0.01379287f, -0.06125067f, -0.02293489f, -0.05033898f, 0.08541610f, 0.03828040f, 0.01705213f, 
    0.04715597f, -0.09431400f, -0.04484171f, -0.05718920f, -0.06077616f, 0.05733429f, -0.00581019f, -0.00507216f, 
    -0.05847598f, -0.01884007f, -0.07652378f, 0.00811754f, -0.04482837f, 0.05693204f, 0.02276970f, -0.01692173f, 
    -0.08512519f, -0.02491126f, -0.01336706f, 0.00588460f, -0.08671781f, -0.03117535f, 0.02524080f, 0.00970586f, 
    0.03760430f, -0.00388388f, -0.05972477f, 0.02645802f, 0.05670210f, -0.07814278f, 0.04225374f, 0.03330145f, 
    0.08981771f, 0.13014039f, -0.17628776f, 0.10457595f, 0.05738942f, -0.10151719f, 0.07615708f, 0.08290922f, 
    -0.02764317f, -0.14591661f, -0.06500854f, -0.17435059f, -0.22179027f, 0.29800045f, 0.22855265f, 0.01982436f, 
    -0.02361911f, -0.14723691f, -0.07102993f, 0.02102320f, 0.04901224f, 0.05742703f, -0.03511259f, 0.10938232f, 
    0.01699247f, 0.06998787f, 0.22123958f, -0.07406345f, 0.12635556f, 0.10848723f, -0.02997300f, 0.01305707f, 
    0.12362333f, 0.04722140f, 0.10162859f, -0.05596624f, -0.14263093f, -0.24415253f, 0.07483412f, 0.06359237f, 
    -0.08815759f, 0.14753950f, -0.04951668f, -0.13147435f, 0.07980506f, 0.10583429f, 0.07064700f, 0.21959500f, 
    0.02751881f, -0.03336876f, -0.16417608f, -0.00120630f, 0.10169017f, 0.10007843f, 0.02094685f, 0.02296167f, 
    -0.09248781f, 0.02468378f, 0.08084537f, -0.02281913f, -0.00929352f, -0.00689842f, 0.17543143f, -0.07101362f, 
    -0.12603424f, -0.05080786f, -0.21297993f, 0.13320842f, 0.08276116f, -0.00640968f, 0.13660423f, -0.08887579f, 
    -0.00208445f, -0.12205045f, -0.02192961f, -0.03904152f, 0.05961246f, 0.16584733f, 0.02264962f, 0.12697114f, 
    0.02967356f, -0.13263594f, -0.17170632f, -0.08230342f, -0.19457479f, 0.07252890f, -0.03215790f, 0.11022200f, 
    -0.16863434f, -0.06342780f, -0.11136714f, -0.08644921f, 0.01829109f, -0.02699747f, 0.01802665f, 0.03110738f, 
    0.04250437f, 0.06588855f, -0.06521735f, 0.11590980f, 0.02185981f, -0.09007430f, 0.01449023f, 0.11457681f, 
    -0.05382060f, 0.01413609f, -0.02421862f, -0.02711941f, 0.10836238f, 0.13243717f, 0.18386522f, -0.18617825f, 
    -0.15112653f, -0.11886010f, 0.10191653f, -0.00984428f, 0.04030784f, -0.00362566f, 0.05385458f, 0.07687149f, 
    0.18957420f, -0.02513477f, 0.03910918f, -0.07312700f, 0.07740014f, 0.02631136f, -0.04772277f, 0.01154109f, 
    -0.01234145f, 0.02457461f, -0.11135761f, 0.08702429f, 0.07657646f, 0.13979471f, 0.02166173f, 0.10608886f, 
    0.07702462f, -0.09493534f, 0.07437136f, -0.02003975f, 0.09924464f, -0.08637626f, -0.03298893f, -0.00388264f, 
    0.25314704f, 0.14201926f, -0.29092041f, 0.03007980f, -0.13463061f, 0.05649625f, 0.03959478f, 0.04110782f, 
    -0.10282873f, -0.08520742f, 0.07067321f, 0.01116848f, 0.11840921f, 0.01471955f, 0.03883593f, -0.08537186f, 
    0.21274294f, -0.06152984f, 0.20204857f, -0.03373365f, 0.01026010f, -0.04668467f, -0.10708002f, -0.18362656f, 
    -0.11515313f, 0.33685693f, 0.30289164f, 0.18521436f, -0.12560914f, -0.19051361f, 0.01105793f, 0.08351997f, 
    0.00881201f, -0.04154776f, 0.10969841f, 0.12391182f, 0.07825685f, -0.09965099f, 0.10421386f, 0.07948569f, 
    0.03842863f, -0.02893629f, -0.16870591f, 0.15277207f, 0.00628554f, 0.10944296f, 0.11185800f, -0.12963444f, 
    0.00665935f, 0.03953814f, -0.17924806f, -0.04316393f, 0.34267578f, 0.11297284f, -0.11800580f, -0.06526349f, 
    -0.08604158f, -0.19544984f, -0.02748631f, -0.17517176f, 0.30100122f, 0.04827451f, 0.14423004f, 0.16887777f, 
    0.08537738f, 0.12113635f, 0.08644371f, 0.20481712f, 0.15374079f, -0.04642113f, 0.07092848f, -0.01272980f, 
    0.06900854f, -0.03496416f, -0.27126402f, 0.06846517f, 0.21868855f, -0.10210015f, 0.06702454f, -0.03368404f, 
    0.04315535f, 0.07465822f, 0.06462267f, -0.07699823f, 0.20228581f, 0.08839593f, -0.27465466f, 0.10452452f, 
    0.07974464f, -0.03982694f, 0.03129472f, 0.09064930f, -0.27400321f, -0.10872325f, -0.01631212f, 0.06042193f, 
    0.11600501f, 0.26209360f, 0.15996209f, 0.12250716f, -0.03905714f, -0.12769994f, -0.06254889f, -0.04547663f, 
    0.13458960f, 0.10559062f, -0.08221526f, 0.13826123f, 0.01454612f, 0.08852856f, -0.03026078f, -0.16273892f, 
    0.04591158f, 0.07301387f, -0.06407700f, 0.03537485f, 0.07109693f, -0.16394316f, 0.02658116f, -0.05170855f, 
    -0.06153645f, 0.08503136f, -0.01822988f, 0.11875596f, -0.15107125f, -0.09234313f, 0.00127021f, -0.01033513f, 
    -0.13851665f, -0.17304389f, 0.01460279f, -0.30667555f, 0.03315256f, 0.05869759f, 0.12747057f, 0.09436715f, 
    -0.10801538f, -0.04554629f, 0.01124419f, -0.18823345f, -0.15365511f, -0.09382770f, -0.08104236f, -0.04010519f, 
    -0.33622324f, 0.14154308f, -0.20593311f, 0.15210429f, 0.01923705f, 0.06530154f, 0.01520595f, -0.03650874f, 
    -0.17254177f, -0.03560644f, -0.02315924f, 0.00489478f, 0.44539934f, -0.38884392f, 0.44724450f, 0.08614234f, 
    -0.04113419f, 0.06823311f, 0.08328947f, -0.01265820f, -0.03391370f, -0.07734670f, -0.03662395f, -0.09295881f, 
    -0.01427947f, 0.47122699f, -0.04017414f, 0.14978440f, -0.12378938f, -0.21131401f, 0.17484626f, -0.01126597f, 
    0.03479811f, 0.10921006f, -0.01606205f, 0.13908949f, -0.13331473f, 0.08051921f, -0.06872756f, 0.00376106f, 
    -0.00293992f, 0.19995086f, -0.11327242f, 0.12608688f, -0.05747611f, -0.09538329f, -0.12929957f, -0.40709597f, 
    -0.12252545f, -0.31106099f, 0.60765165f, 0.05645910f, -0.09687544f, 0.03820439f, -0.24721329f, 0.02679082f, 
    -0.05188027f, -0.06017545f, -0.04756653f, 0.12277944f, 0.18858317f, 0.25796938f, 0.06481670f, 0.14485931f, 
    0.08839355f, 0.07814618f, -0.13766406f, 0.12056553f, -0.10248087f, 0.00681550f, -0.04585448f, -0.23056786f, 
    0.12275197f, 0.18351042f, 0.00855864f, 0.10448982f, 0.17221650f, 0.01211831f, 0.01831882f, -0.21989581f, 
    0.04034118f, -0.08902614f, 0.06422947f, 0.06212485f, 0.06851922f, 0.13064761f, -0.04144595f, 0.00300854f, 
    0.16622357f, 0.11912516f, 0.15984400f, 0.03747205f, -0.13696323f, -0.02151910f, 0.11879081f, -0.08797652f, 
    -0.29488915f, 0.06586638f, -0.22858344f, 0.05011780f, 0.11487092f, 0.09283620f, -0.01427356f, -0.15342981f, 
    -0.15774411f, -0.41540620f, -0.21181111f, -0.24763875f, 0.11465745f, -0.23638803f, 0.00653206f, 0.07381983f, 
    0.06438047f, 0.00485820f, -0.00310913f, 0.12287391f, 0.11766457f, 0.09659962f, 0.00143525f, 0.03148885f, 
    0.16577543f, -0.01234648f, -0.01461062f, 0.06873339f, -0.04314563f, 0.02037178f, 0.04410151f, 0.18796512f, 
    0.25719374f, 0.13781665f, 0.12469976f, 0.04557405f, 0.24210909f, 0.11271753f, -0.14583543f, 0.08646100f, 
    -0.01107101f, 0.19720168f, 0.21795563f, 0.05699653f, -0.07168175f, 0.06217273f, 0.09100405f, 0.37281218f, 
    0.19837978f, 0.13465261f, 0.05517280f, 0.39732972f, 0.03625969f, -0.12987556f, 0.07923320f, 0.14307600f, 
    -0.01737560f, 0.04592797f, -0.05482179f, -0.02160864f, 0.22762328f, 0.11604736f, 0.09655214f, -0.12438656f, 
    -0.10515239f, 0.06126507f, -0.01226538f, -0.09323211f, -0.06447750f, 0.01958244f, 0.12467850f, -0.08961456f, 
    -0.11373127f, -0.04029446f, -0.06114950f, -0.19912037f, 0.18764485f, -0.04345918f, -0.10653469f, 0.17777582f, 
    -0.10849822f, -0.17451243f, -0.50218374f, -0.55165732f, 0.18008600f, 0.01323653f, 0.05466411f, 0.04877260f, 
    0.11724158f, 0.04536884f, 0.04389173f, 0.13241634f, -0.07037309f, -0.17348538f, -0.25457880f, 0.13627630f, 
    -0.56295639f, -0.39359769f, 0.01948918f, 0.21725737f, 0.03908618f, -0.32591876f, -0.30569151f, -0.44138104f, 
    -0.05719069f, 0.05089443f, -0.01793970f, 0.10541616f, -0.03011354f, -0.21836062f, 0.36388698f, -0.02460622f, 
    0.01196738f, -0.06938996f, -0.06108865f, -0.17664948f, -0.03807422f, 0.01731270f, 0.18360731f, 0.08799605f, 
    0.14319456f, -0.01112897f, 0.24387774f, 0.15237054f, 0.08007832f, -0.42106843f, -0.02349853f, 0.01286045f, 
    -0.08498519f, 0.08409298f, -0.22697458f, 0.03803172f, -0.05356478f, -0.20237206f, -0.23187611f, -0.23467158f, 
    0.10782779f, 0.04967364f, -0.19801526f, -0.06398609f, 0.10627478f, -0.08986399f, -0.30405986f, -0.31389803f, 
    -0.22053495f, 0.07660464f, 0.08381153f, 0.12588423f, -0.27818301f, 0.07870451f, -0.29815710f, -0.03416777f, 
    -0.20705542f, -0.04385483f, 0.00886313f, 0.10477455f, 0.16171962f, 0.30480450f, -0.17662497f, 0.12566103f, 
    0.23197858f, -0.11518229f, 0.08348020f, -0.01183646f, -0.15753864f, -0.03184816f, -0.07237887f, -0.42409939f, 
    0.14237605f, 0.09364242f, 0.09716013f, 0.05148936f, 0.03072140f, -0.00933117f, -0.01863965f, -0.16609594f, 
    0.03215308f, 0.00899762f, 0.01210322f, 0.24888194f, 0.15689936f, 0.01390134f, -0.06404991f, 0.07564943f, 
    0.05559923f, 0.03852185f, 0.15038350f, 0.18018442f, -0.12390561f, -0.00669577f, 0.23113458f, -0.03189115f, 
    -0.07413769f, 0.03675734f, -0.03596660f, 0.04953745f, -0.05209458f, -0.07621855f, 0.00312124f, 0.03547914f, 
    0.01942710f, 0.05230353f, -0.01786693f, 0.04949984f, 0.04895743f, -0.07334443f, -0.02494682f, -0.03158486f, 
    -0.02509064f, -0.02039506f, -0.02374938f, 0.00376259f, -0.04617848f, 0.00479313f, 0.03342583f, -0.07198579f, 
    0.00657109f, 0.05608464f, 0.05175968f, 0.02852928f, -0.06361178f, 0.03754082f, -0.06184175f, -0.05551223f, 
    -0.02983701f, -0.04248702f, -0.03732653f, -0.06697992f, 0.05426149f, 0.04734120f, -0.04080976f, -0.07672853f, 
    -0.03471977f, -0.00438296f, 0.06119603f, -0.02072025f, -0.04222067f, 0.01918247f, -0.02137278f, -0.07038076f, 
    0.06336528f, 0.00927165f, -0.00817335f, -0.03610757f, -0.01054988f, 0.02585409f, -0.06510837f, 0.04805279f, 
    -0.01912615f, 0.01144662f, -0.07626871f, -0.06314667f, 0.04696717f, -0.02103985f, -0.00125195f, -0.02893264f, 
    -0.05266793f, 0.04718418f, -0.07739744f, -0.02544257f, -0.07886640f, 0.03987760f, 0.02875674f, -0.07637099f, 
    0.00418792f, -0.05223034f, -0.03997624f, 0.02809755f, 0.01573093f, -0.06261539f, -0.07752606f, 0.04253383f, 
    0.01040734f, -0.03283497f, -0.06340984f, 0.00198329f, 0.00196900f, -0.05221698f, -0.04055770f, 0.00486657f, 
    -0.00204781f, -0.04549952f, -0.06722972f, -0.02416635f, 0.00075182f, 0.06180912f, 0.02592793f, -0.01342857f, 
    -0.04761759f, -0.05266993f, 0.05768289f, 0.05891678f, -0.00440911f, 0.02294699f, -0.06761830f, -0.01925354f, 
    0.02799169f, -0.03636293f, 0.03032922f, 0.02624327f, -0.06884209f, -0.01200605f, -0.01166434f, 0.04157935f, 
    0.05776180f, -0.07233106f, 0.01460242f, 0.00101211f, -0.01898079f, 0.05958687f, 0.03101054f, -0.02804301f, 
    -0.07694779f, -0.05547883f, -0.06493811f, 0.06301748f, 0.04122469f, 0.02956624f, 0.02229952f, 0.00559733f, 
    0.02261470f, -0.06592243f, -0.01304988f, -0.02565491f, -0.01528588f, -0.02848167f, 0.05555486f, -0.05660075f, 
    -0.03248864f, -0.01499633f, -0.07576190f, -0.00677370f, -0.03621492f, -0.00553940f, 0.01484812f, 0.05970765f, 
    0.00718029f, -0.04789728f, -0.02003601f, -0.05203480f, 0.05789413f, 0.03833795f, -0.07392504f, -0.03615139f, 
    -0.00492976f, -0.02681259f, -0.03057451f, 0.04731661f, 0.06498903f, -0.03078357f, 0.05764285f, -0.02997538f, 
    -0.01731497f, -0.07350699f, 0.03853762f, 0.04691821f, 0.00871863f, -0.06677143f, 0.04454393f, 0.01534061f, 
    -0.06015309f, -0.05524100f, -0.00068655f, -0.06018635f, 0.02977377f, 0.02552115f, -0.01498824f, 0.03218901f, 
    -0.03700768f, 0.02060277f, -0.07631109f, -0.06054587f, 0.02444439f, -0.02425148f, 0.04487994f, 0.00306901f, 
    0.04376166f, -0.04160951f, -0.03075936f, -0.04842221f, -0.02741198f, -0.06917141f, -0.00943592f, 0.05559781f, 
    -0.08872113f, -0.10024508f, -0.02894084f, -0.16577522f, -0.04315120f, 0.01284331f, -0.03284644f, 0.02872132f, 
    0.00114044f, -0.05357901f, 0.04624949f, 0.14536843f, 0.01111528f, 0.13707544f, -0.04084407f, 0.01782169f, 
    -0.03035228f, -0.11400002f, 0.24678908f, -0.08348001f, -0.08054561f, -0.02703330f, 0.11268680f, 0.14695355f, 
    0.27949208f, 0.24387869f, 0.00906689f, 0.05775432f, 0.15782554f, -0.03527400f, 0.07547090f, 0.13387257f, 
    0.04331856f, -0.05178755f, 0.02408210f, 0.12139093f, -0.02096976f, 0.26093957f, 0.10918387f, 0.02820092f, 
    0.04480409f, 0.04365034f, -0.01970999f, 0.08436719f, 0.03579633f, 0.15010974f, -0.04596000f, -0.20025072f, 
    -0.31037143f, -0.35068497f, -0.04333190f, -0.04737961f, -0.07129042f, -0.08893374f, -0.13932262f, 0.11435886f, 
    0.00291274f, -0.03144855f, -0.03993995f, 0.04065375f, 0.07408156f, 0.16001229f, 0.24022481f, 0.27689880f, 
    -0.02981907f, 0.08902667f, -0.15148650f, -0.00877979f, 0.08391939f, 0.02975171f, 0.02976945f, 0.06946581f, 
    0.08690438f, 0.10557934f, -0.11920080f, -0.11026075f, 0.05231256f, 0.08869500f, 0.00681251f, 0.00875250f, 
    0.07032704f, 0.13309903f, 0.14757408f, -0.13696228f, 0.09744455f, 0.22653532f, 0.39696583f, 0.21312651f, 
    -0.14501826f, -0.01935798f, 0.09699564f, 0.05626261f, 0.03644666f, 0.03582037f, -0.03452299f, -0.04010660f, 
    -0.15721481f, -0.18806815f, -0.10701416f, -0.21060804f, -0.14358282f, -0.06836648f, 0.01685507f, -0.04287903f, 
    -0.04136608f, -0.04872389f, 0.11677957f, -0.06577350f, -0.04655828f, 0.00086474f, -0.11504011f, 0.12180299f, 
    0.04976708f, 0.01605150f, 0.06059603f, 0.01889065f, 0.00651052f, -0.08319443f, -0.02531752f, 0.04161773f, 
    -0.05391031f, -0.17688891f, -0.24559756f, -0.05815668f, -0.03732692f, -0.10028027f, 0.07532077f, 0.15934810f, 
    0.03555885f, -0.03142613f, 0.06211461f, -0.06948308f, -0.15532774f, -0.09431970f, -0.15406685f, -0.13892689f, 
    -0.06219150f, -0.06711552f, -0.02612176f, 0.02708631f, 0.01129737f, -0.05557594f, -0.06979739f, -0.02366072f, 
    -0.35879558f, -0.20258194f, -0.01019616f, 0.02840601f, 0.00528172f, 0.07588699f, -0.02816495f, -0.09809060f, 
    0.15199010f, -0.02409338f, 0.03605381f, -0.03312588f, 0.08549214f, 0.19796726f, -0.17521730f, -0.12127146f, 
    0.01803390f, 0.17183658f, 0.01944866f, 0.18688001f, -0.04596159f, 0.04829415f, 0.02419257f, 0.02427106f, 
    0.23880211f, 0.13586468f, 0.21771061f, 0.19572538f, 0.07718302f, -0.01898003f, -0.07136247f, 0.01868583f, 
    0.07793988f, 0.04145620f, 0.02073399f, 0.07037189f, 0.19220524f, 0.13279825f, 0.05838687f, -0.10939615f, 
    -0.05620514f, 0.06638867f, 0.18081249f, -0.04219079f, -0.04104137f, -0.05964736f, -0.05152297f, 0.00708824f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.03916185f, 0.09773097f, -0.02891572f, 0.05878538f, 0.22844283f, -0.05424115f, 0.04414356f, 0.11598238f, 
    -0.02161804f, 0.07765319f, -0.05025594f, -0.01766174f, -0.03748628f, 0.02278426f, 0.11113571f, 0.46454811f, 
    0.25406078f, 0.00184218f, -0.00400606f, -0.08156932f, -0.05608281f, 0.16653670f, 0.02750919f, 0.00743534f, 
    0.06278218f, -0.05238165f, -0.03603392f, -0.04324761f, 0.12366716f, 0.11866735f, 0.14616729f, -0.02262842f, 
    0.11615161f, -0.02499717f, 0.20865761f, -0.02756063f, -0.06014518f, 0.01600423f, 0.10734699f, -0.02509744f, 
    -0.03331285f, 0.27534574f, 0.06113484f, -0.05114910f, -0.19569780f, -0.00070620f, 0.04958628f, 0.07857226f, 
    0.05462963f, -0.22282107f, 0.06334465f, 0.07639859f, -0.06379547f, 0.09446073f, 0.04506055f, 0.09106287f, 
    -0.00204253f, 0.06251821f, -0.07764272f, 0.04210034f, -0.03538759f, -0.14369090f, 0.03385184f, 0.02440166f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.04847707f, 0.04118344f, -0.13455069f, 0.04397371f, 0.21977407f, -0.03742974f, 0.03322721f, -0.16883898f, 
    0.02806256f, 0.01496405f, -0.07426597f, -0.10663437f, -0.02111064f, -0.05700070f, 0.00014306f, 0.17167315f, 
    0.02340155f, -0.10275840f, 0.00441521f, 0.03203014f, 0.07025617f, 0.23934858f, 0.07848571f, -0.08800215f, 
    0.16262111f, -0.09893380f, -0.09849259f, 0.09038524f, -0.11025055f, -0.03801050f, -0.08647822f, 0.04708068f, 
    -0.04406354f, 0.00684457f, 0.49366605f, -0.11183728f, 0.09559074f, 0.09865072f, 0.03188463f, -0.17744675f, 
    -0.10042237f, 0.28947052f, 0.11850943f, -0.19869910f, -0.25279132f, 0.10323444f, -0.06583243f, 0.05607346f, 
    0.03522715f, -0.38508707f, 0.13865501f, 0.11820656f, 0.07583082f, 0.18057239f, 0.29620242f, 0.14913349f, 
    0.14853591f, 0.21864322f, 0.04153491f, -0.19446981f, -0.16302368f, -0.70312643f, 0.05791052f, 0.05205071f, 
    0.10595247f, 0.10362691f, 0.17596531f, 0.36158994f, 0.11425137f, -0.05001535f, 0.06750377f, -0.08940008f, 
    -0.00593668f, -0.02774132f, -0.07792941f, 0.02894126f, -0.07664160f, 0.03987149f, 0.15828082f, 0.19147213f, 
    0.05740937f, 0.08989494f, 0.16888793f, 0.01117448f, -0.06177643f, 0.11118726f, -0.02843201f, 0.09402210f, 
    -0.11284555f, -0.11484031f, 0.12363086f, -0.12336901f, 0.12773651f, 0.08928868f, -0.00313270f, -0.08303748f, 
    -0.07567704f, -0.09464477f, 0.10495737f, -0.22567740f, -0.14843778f, 0.07144804f, -0.22440132f, 0.16608536f, 
    -0.03992187f, -0.00716846f, 0.14224279f, 0.04502602f, -0.18790223f, -0.06940322f, -0.06567818f, 0.08826436f, 
    0.08207068f, -0.10238141f, 0.14904208f, 0.00490760f, -0.04183768f, 0.00309294f, 0.07102582f, -0.03217890f, 
    0.05831468f, -0.33693016f, -0.00759735f, 0.16283457f, 0.08905757f, -0.28918198f, -0.07262841f, 0.06302327f, 
    -0.41831148f, -0.15383352f, 0.02078655f, 0.10906392f, 0.02317867f, -0.28383452f, -0.04122050f, -0.14633180f, 
    -0.08350436f, -0.04962539f, 0.11948484f, -0.23265706f, 0.08374421f, -0.05201521f, 0.21377553f, 0.16982558f, 
    0.30340126f, 0.05292079f, 0.02092467f, 0.34790024f, 0.19829842f, 0.03877684f, -0.02055196f, 0.15474376f, 
    -0.02440108f, -0.10863975f, -0.01627304f, 0.06662763f, -0.04390384f, 0.01498302f, 0.11186212f, -0.09643198f, 
    -0.15512635f, 0.01337811f, 0.15340535f, 0.18524048f, 0.04871217f, 0.11439962f, 0.27903646f, 0.11586610f, 
    0.04700808f, -0.03269203f, -0.00178454f, -0.03683719f, 0.18381989f, -0.28823814f, -0.08924689f, -0.03827492f, 
    0.02113135f, -0.09813836f, -0.22476116f, 0.14638326f, 0.06975494f, -0.31787288f, -0.25640422f, 0.15811700f, 
    0.03572977f, 0.16496360f, -0.11846782f, -0.17881869f, 0.05048495f, 0.27411300f, 0.07320034f, -0.12143631f, 
    -0.31228149f, -0.05070088f, 0.17371333f, -0.06253867f, 0.08106592f, -0.22213186f, 0.01025668f, 0.18264963f, 
    0.09583455f, 0.22018598f, -0.01489786f, 0.03178177f, 0.09213097f, -0.07583817f, 0.01263086f, 0.16781938f, 
    -0.27316022f, -0.08371938f, -0.17386200f, -0.13215499f, -0.17759831f, 0.16873278f, -0.01184934f, -0.01951787f, 
    0.05127821f, -0.12216114f, -0.12348581f, -0.07318542f, -0.02427914f, 0.06696914f, 0.20493373f, -0.07403713f, 
    -0.15302323f, -0.04439018f, -0.28907925f, 0.31405309f, -0.16886474f, 0.04932707f, 0.34411991f, 0.29919550f, 
    0.03079316f, 0.30941281f, 0.21388640f, 0.07775467f, -0.16202998f, -0.05454496f, -0.06285803f, -0.08031289f, 
    -0.10713631f, 0.03521885f, -0.31181350f, 0.16587800f, -0.09822391f, -0.24823725f, -0.23124638f, 0.10785194f, 
    0.07549366f, 0.09361284f, -0.03667409f, 0.13609664f, -0.00193897f, 0.04365266f, 0.11722847f, -0.20333543f, 
    -0.10249348f, -0.07304217f, -0.16069067f, -0.50062132f, -0.00246453f, -0.05700297f, -0.12135165f, 0.07395881f, 
    -0.06945337f, -0.10099094f, -0.12205207f, 0.03943441f, -0.11128804f, -0.00192113f, -0.20299143f, -0.19288641f, 
    -0.14707525f, -0.00827406f, 0.19277954f, 0.21164297f, 0.32916850f, 0.12091957f, -0.08408160f, 0.05069542f, 
    0.04265602f, 0.09833534f, -0.06224942f, 0.08736331f, -0.19506514f, -0.44624069f, -0.07425758f, 0.10705105f, 
    -0.05129946f, -0.11908007f, -0.03529103f, 0.12317314f, 0.28661996f, -0.08840457f, 0.00864767f, 0.16523015f, 
    0.06454740f, 0.16858128f, 0.00839020f, 0.13626711f, 0.08102165f, -0.09394249f, 0.03201403f, 0.21875247f, 
    -0.00270163f, 0.03106575f, -0.12987162f, -0.26625279f, 0.05101867f, -0.06014810f, 0.13151027f, 0.21320863f, 
    0.05162557f, 0.33787817f, -0.00588201f, -0.17794758f, 0.13127947f, 0.26053327f, -0.08962877f, 0.16200961f, 
    0.01143228f, -0.04124016f, 0.20075855f, 0.25901005f, 0.09866063f, -0.20911169f, 0.00111922f, -0.19903216f, 
    -0.08367548f, -0.03887419f, 0.00683837f, 0.23138323f, 0.06783102f, -0.07260181f, 0.22229996f, -0.10094446f, 
    -0.38351879f, 0.04818713f, -0.14452079f, 0.04010310f, 0.17081174f, 0.16339006f, -0.09351409f, -0.14664795f, 
    -0.01342429f, 0.04680942f, -0.08853514f, 0.04655921f, 0.03192160f, 0.07678120f, 0.04424974f, -0.02074781f, 
    -0.15578908f, -0.01219398f, 0.11139810f, 0.02363409f, 0.04474144f, -0.04427084f, 0.09068512f, 0.21626782f, 
    0.12605409f, -0.01154816f, 0.25333849f, 0.14337350f, -0.05627481f, -0.08787211f, -0.06362916f, -0.28071383f, 
    0.09641063f, 0.20248994f, 0.02393444f, 0.18164298f, -0.12407992f, 0.02467031f, 0.08938078f, -0.06934623f, 
    0.05537545f, -0.19801801f, 0.07736603f, 0.03743587f, 0.04224513f, -0.07421899f, 0.09808411f, -0.14752574f, 
    0.20470779f, 0.03944363f, 0.17090508f, 0.03969977f, 0.10734358f, 0.26772660f, 0.04096591f, -0.05383454f, 
    -0.08384407f, 0.19695498f, 0.01068082f, -0.15246011f, 0.11096574f, -0.06197015f, -0.06833470f, 0.23726600f, 
    0.16364425f, 0.00039556f, 0.42547455f, 0.31018808f, -0.08100194f, -0.15264657f, 0.12026551f, 0.01094277f, 
    -0.01740711f, 0.08139813f, 0.09687193f, -0.11800586f, 0.12841748f, -0.14361359f, 0.13801651f, -0.05434137f, 
    -0.08457951f, -0.04535954f, 0.23907724f, 0.20492744f, 0.12075245f, 0.04532557f, -0.08821149f, -0.09234526f, 
    -0.04851011f, -0.16122304f, 0.00754894f, -0.19356769f, 0.11541337f, 0.03193411f, 0.10082647f, 0.13417940f, 
    0.10227042f, 0.05822468f, -0.11139343f, 0.00453473f, 0.00873053f, -0.08649003f, 0.19027765f, 0.31305379f, 
    0.26141784f, -0.11799278f, -0.01666347f, -0.12985511f, 0.21923102f, -0.24806252f, -0.07608855f, 0.16482016f, 
    -0.15823096f, -0.21123894f, 0.18209180f, 0.09280047f, 0.13803723f, 0.19067264f, -0.01328097f, 0.14469121f, 
    -0.05205166f, -0.11847584f, 0.09164687f, 0.07963786f, 0.08793727f, 0.02719244f, 0.10476030f, 0.33511898f, 
    -0.06892426f, 0.03415471f, -0.10167212f, -0.08234642f, -0.07780713f, 0.05346557f, 0.11334234f, -0.09519678f, 
    -0.05519566f, -0.00807790f, 0.07816387f, -0.08611555f, 0.09920411f, 0.09475148f, 0.07872276f, -0.11599713f, 
    0.16976005f, -0.13102371f, -0.08581418f, -0.10691883f, -0.09313742f, 0.05408675f, -0.22559951f, 0.15823080f, 
    -0.03283439f, -0.01462533f, 0.13496220f, -0.03882166f, 0.05220780f, -0.14854223f, -0.09980642f, 0.06972775f, 
    -0.03669761f, -0.31363130f, 0.14252312f, 0.05697322f, -0.01320463f, 0.04327312f, -0.21215868f, -0.18321662f, 
    0.05884441f, 0.16276693f, 0.09947257f, 0.22513722f, 0.23071317f, -0.27954379f, 0.05990955f, -0.17293510f, 
    -0.08695935f, 0.10871729f, -0.23953129f, 0.15722030f, 0.07011912f, 0.14706825f, 0.02145526f, -0.02059483f, 
    -0.04011391f, -0.07063842f, 0.12498625f, 0.02695530f, 0.07393508f, 0.06567705f, 0.06495962f, 0.40613091f, 
    0.05924439f, -0.11428092f, -0.03886119f, 0.03388199f, -0.16063118f, 0.06446807f, 0.11183143f, 0.04450436f, 
    -0.08197840f, 0.00223291f, 0.00655328f, -0.03767944f, -0.20758782f, -0.27984461f, -0.15267558f, 0.09324835f, 
    -0.23930825f, -0.09288564f, -0.09682146f, -0.22054115f, -0.07991619f, -0.01671565f, 0.11442047f, -0.36605716f, 
    0.02527277f, -0.05025639f, -0.03376292f, -0.11061486f, 0.04566174f, -0.26707539f, 0.09926248f, 0.02139545f, 
    0.02486408f, -0.17454657f, 0.10628871f, 0.20676705f, 0.10326169f, -0.18984269f, -0.01793914f, -0.05870553f, 
    -0.15555932f, -0.02587896f, 0.01339627f, 0.05974987f, 0.33063602f, -0.02992004f, 0.02745570f, -0.11532598f, 
    -0.02435434f, -0.11085127f, 0.04659883f, 0.03923253f, 0.05172350f, -0.06967597f, -0.08575308f, -0.04117571f, 
    0.08580731f, -0.01399731f, -0.04128373f, -0.10771455f, 0.02282383f, 0.07725152f, -0.15423915f, -0.05150069f, 
    -0.14756633f, 0.03835133f, 0.02211903f, -0.07238657f, -0.00790900f, 0.03822798f, -0.05172855f, 0.09230115f, 
    -0.04286135f, 0.03595273f, -0.03109154f, 0.06633504f, -0.05940210f, 0.04332677f, -0.11653404f, -0.11801732f, 
    -0.03478333f, -0.10274865f, 0.02039717f, -0.08185990f, -0.07540580f, 0.02284120f, -0.07881267f, 0.04566814f, 
    0.08366978f, -0.07653806f, 0.02686706f, -0.05732876f, 0.04108891f, -0.09336427f, -0.04952408f, 0.01690417f, 
    -0.00561316f, 0.00073688f, -0.06175323f, -0.00782677f, 0.07671429f, -0.06876354f, -0.07818601f, -0.00747236f, 
    0.06645603f, -0.07151622f, -0.11313158f, -0.11716888f, -0.03272745f, 0.01225322f, -0.08286066f, 0.00915018f, 
    -0.42446589f, -0.13763592f, -0.17539510f, 0.00189828f, -0.04054612f, -0.06994142f, 0.03026418f, -0.06388491f, 
    -0.03830932f, -0.26443657f, -0.03066078f, -0.20345044f, -0.05706184f, -0.00154099f, 0.17498794f, 0.32234791f, 
    0.16903968f, 0.00013387f, -0.11841040f, 0.33061567f, -0.00287790f, 0.18123826f, 0.02599154f, 0.30620405f, 
    -0.11470447f, -0.01686633f, 0.03910455f, 0.05766272f, 0.07143815f, 0.01111907f, 0.00471847f, 0.00132331f, 
    -0.12211626f, -0.04298651f, 0.10771184f, -0.13882776f, -0.03365666f, -0.00513586f, 0.11355208f, -0.02678725f, 
    0.07181305f, 0.19573329f, 0.16867031f, -0.12159568f, -0.15285917f, -0.21623012f, -0.07996912f, 0.15610982f, 
    -0.10233378f, -0.13714945f, -0.14932391f, 0.07623562f, -0.01253054f, -0.21888316f, -0.09713433f, 0.00889958f, 
    0.05495861f, -0.02914212f, -0.12984757f, 0.08460414f, 0.05259215f, -0.06923839f, -0.00766829f, -0.13225378f, 
    0.03540754f, -0.05955557f, 0.15676969f, -0.09496525f, -0.27308065f, 0.09922367f, 0.11601871f, -0.01469250f, 
    0.03519952f, 0.07006555f, -0.05612268f, 0.12844320f, 0.01722482f, 0.13037203f, 0.00489827f, -0.29841027f, 
    -0.17564258f, -0.00936332f, 0.20674552f, 0.47222438f, 0.21377257f, -0.21067148f, -0.08039616f, 0.22202954f, 
    -0.13062277f, 0.00190840f, 0.05033794f, 0.00645844f, 0.01617602f, -0.27663517f, -0.04332246f, 0.04524844f, 
    0.12212197f, 0.06504770f, -0.17794774f, 0.02553385f, 0.12075463f, -0.09589378f, 0.03599568f, -0.00165397f, 
    -0.04060636f, -0.13394664f, -0.11110399f, 0.28945017f, -0.07810155f, 0.11343944f, -0.11037208f, -0.12909786f, 
    0.00822185f, 0.22546755f, 0.08422913f, 0.00234742f, 0.11579791f, -0.17035218f, -0.08507764f, 0.15537094f, 
    0.20298289f, -0.12542191f, 0.01035001f, 0.09108977f, 0.08757993f, 0.49876034f, 0.10399394f, 0.10865144f, 
    0.39343315f, 0.32512373f, 0.12027378f, 0.04945236f, 0.09615967f, 0.16457361f, -0.11577637f, -0.07217980f, 
    -0.12777570f, 0.11565910f, -0.02104143f, -0.16149496f, 0.05679581f, 0.02575068f, -0.26245478f, 0.16720772f, 
    0.34789491f, -0.09788024f, 0.37479860f, 0.35341978f, -0.22641380f, 0.02025043f, 0.01268864f, 0.27262455f, 
    -0.20793909f, -0.01690085f, 0.08010035f, 0.03453730f, 0.13291653f, 0.12721016f, -0.07948770f, -0.03335304f, 
    0.06483312f, -0.07617472f, 0.37696236f, 0.03137764f, 0.00157245f, 0.03714490f, 0.15572755f, -0.28483063f, 
    0.05670537f, -0.04606874f, 0.07685975f, -0.20800416f, -0.30599216f, 0.00009762f, 0.00111413f, 0.29055637f, 
    0.11023870f, -0.05228884f, -0.20474383f, -0.14438473f, 0.00579716f, 0.05055699f, 0.11190175f, 0.25765651f, 
    0.11089138f, -0.09470331f, -0.00104444f, -0.08451857f, -0.31872508f, -0.49447307f, -0.10248758f, 0.28423384f, 
    0.15269759f, 0.18991071f, -0.12180094f, 0.14820056f, -0.07674929f, -0.05000595f, 0.03627411f, 0.12486187f, 
    0.03625394f, 0.12767355f, -0.10551375f, 0.17899784f, -0.01441479f, -0.01485927f, -0.10151893f, 0.03662935f, 
    0.06796330f, -0.10031006f, -0.23285596f, -0.15398619f, -0.18260264f, 0.27481046f, -0.06958456f, 0.16077040f, 
    -0.03973252f, -0.02804386f, 0.08960637f, 0.07306648f, 0.17477193f, 0.12547217f, -0.05378515f, 0.10415158f, 
    0.01057099f, -0.05622661f, 0.13726375f, -0.05073909f, 0.00987552f, -0.03520469f, 0.16626626f, 0.02726650f, 
    -0.02900837f, 0.33849317f, 0.16336879f, 0.04559344f, -0.37560081f, 0.20503573f, 0.10231049f, 0.12864625f, 
    -0.01805195f, 0.19585177f, 0.00296957f, -0.11153928f, -0.02452267f, 0.26830569f, 0.23661914f, -0.14079006f, 
    -0.21781729f, -0.27738491f, 0.03318562f, 0.14454439f, -0.27688277f, -0.39253104f, -0.03257419f, 0.09844051f, 
    -0.07513399f, -0.02661285f, -0.07363161f, -0.08055598f, -0.07035129f, -0.01524259f, -0.07227926f, -0.10916775f, 
    -0.10586093f, -0.08007228f, 0.07649726f, 0.02904722f, -0.03636868f, -0.00810444f, -0.05930501f, 0.07885799f, 
    -0.09163712f, 0.02275696f, -0.04753929f, -0.01085271f, 0.12227803f, -0.06289694f, -0.11942084f, 0.04497083f, 
    0.02407604f, 0.05838557f, -0.03816704f, 0.11335295f, 0.07170644f, -0.02420208f, -0.06358349f, 0.04903863f, 
    0.09822202f, 0.09459786f, -0.06705359f, -0.11713234f, -0.11681238f, -0.11692823f, 0.04862389f, -0.10038017f, 
    -0.03924999f, -0.05614951f, -0.06796612f, 0.11615787f, -0.11344281f, -0.12156622f, -0.09170295f, -0.01192209f, 
    -0.11052862f, -0.12350926f, -0.06008068f, 0.06520402f, 0.04709089f, 0.09003387f, 0.03422043f, 0.10445586f, 
    0.05666547f, 0.02923563f, 0.01419476f, 0.08674653f, 0.01236574f, -0.02391788f, -0.08016013f, -0.10543461f, 
    0.00110088f, -0.12872720f, -0.01499956f, 0.06286655f, -0.14135399f, 0.06847346f, -0.04081443f, -0.02493236f, 
    -0.09776922f, 0.00397415f, 0.02253173f, 0.04408674f, -0.07444976f, -0.10039867f, 0.04768118f, 0.04667166f, 
    -0.15889277f, -0.00815123f, -0.10580093f, -0.13925910f, 0.03417799f, -0.03153553f, 0.10004325f, 0.03443881f, 
    -0.17188205f, 0.12467903f, 0.06599229f, -0.00268580f, -0.06540511f, 0.00946040f, -0.15888421f, -0.00179383f, 
    -0.04368182f, -0.08800737f, -0.10521315f, -0.11189070f, -0.11119847f, -0.04371753f, -0.02517025f, -0.08912327f, 
    -0.04734080f, 0.05054331f, 0.07378979f, -0.09477200f, 0.05758785f, -0.12007019f, -0.03914057f, -0.14859986f, 
    -0.04522103f, -0.10687827f, -0.13618620f, -0.03753338f, 0.02587935f, 0.05862203f, -0.03752830f, -0.03321081f, 
    -0.08164755f, 0.11906136f, -0.12115844f, 0.05048016f, -0.07147945f, 0.05692090f, 0.07026561f, -0.13671292f, 
    0.01142252f, 0.11242355f, -0.04287527f, 0.11577274f, 0.16195750f, 0.08899847f, 0.02130795f, 0.00158692f, 
    -0.06455012f, 0.15266830f, -0.03418795f, -0.06194565f, -0.05303979f, -0.03229034f, 0.23517646f, 0.26995090f, 
    -0.06449079f, 0.02631577f, -0.11900297f, 0.16833955f, 0.00148152f, 0.07438032f, 0.01185836f, 0.13096361f, 
    -0.11467194f, -0.03586917f, 0.02410806f, 0.03731531f, 0.25164527f, 0.27715048f, 0.11157708f, 0.02159193f, 
    0.20237106f, -0.09382112f, 0.16242011f, -0.16415507f, -0.09559849f, 0.01045947f, 0.21870179f, -0.00735871f, 
    -0.09888314f, 0.20696600f, 0.12251429f, -0.14914431f, -0.20633197f, -0.02919810f, 0.11667163f, -0.02408110f, 
    -0.11405583f, 0.09579894f, -0.15645978f, -0.08265410f, 0.02944414f, 0.09584801f, 0.10561443f, 0.06942429f, 
    0.04205684f, -0.41891092f, -0.09019384f, 0.10907906f, -0.28220469f, -0.44927850f, 0.00470361f, 0.11116522f, 
    -0.06441498f, 0.22639206f, 0.01826607f, -0.23503394f, 0.10047724f, 0.17126437f, 0.11474982f, 0.09811199f, 
    -0.05266401f, -0.03870480f, 0.06538029f, -0.16031058f, -0.01036234f, -0.06668686f, -0.16068994f, 0.25648847f, 
    0.13491268f, -0.08914288f, -0.00091898f, -0.10709141f, -0.08611644f, -0.07119759f, 0.10367195f, 0.18064147f, 
    -0.22646323f, 0.06467943f, -0.09771877f, 0.00345812f, 0.18087591f, 0.18694411f, -0.00173151f, -0.08162759f, 
    0.23932853f, -0.09186677f, 0.09231294f, 0.08238709f, -0.01085709f, 0.02610854f, 0.21835443f, -0.03057171f, 
    0.09128506f, 0.06964596f, -0.11182741f, -0.03464999f, -0.12668958f, 0.01396362f, 0.06709993f, 0.34889475f, 
    -0.05882722f, -0.17053217f, 0.01962041f, -0.10858142f, 0.05523828f, 0.26606560f, 0.05216767f, -0.06357280f, 
    -0.00220794f, 0.05720804f, 0.08116520f, 0.18035629f, -0.16871780f, -0.00251272f, -0.03683307f, -0.00918317f, 
    0.08222692f, 0.31079292f, 0.05438609f, -0.16191262f, 0.24420632f, 0.11882136f, -0.06699550f, -0.09794088f, 
    0.10292611f, -0.10173517f, -0.05579501f, -0.04198810f, 0.01205033f, 0.03668747f, 0.06785631f, -0.06951728f, 
    0.02294761f, -0.02456231f, -0.19939071f, 0.21484320f, 0.16846922f, -0.07518739f, 0.04787342f, 0.29009756f, 
    -0.09670828f, 0.10589742f, -0.08860449f, 0.05618470f, -0.02008291f, 0.36316091f, -0.07760025f, 0.04942128f, 
    0.23166491f, -0.00885235f, 0.03053443f, 0.03764468f, 0.09657536f, 0.04672588f, 0.13838930f, -0.11578692f, 
    0.01012737f, -0.00553490f, -0.15752691f, -0.01547670f, 0.03125792f, -0.02247060f, 0.09988520f, 0.09116564f, 
    0.00581518f, -0.13566954f, 0.13421457f, -0.16010265f, 0.06980594f, 0.20727308f, 0.04382286f, -0.07971086f, 
    -0.08743367f, 0.07340372f, 0.05838330f, 0.07148255f, 0.04551354f, 0.14829296f, 0.08113129f, 0.13440751f, 
    0.11543550f, 0.15557475f, -0.19147369f, -0.06285215f, 0.19562460f, -0.17848845f, -0.05881900f, -0.09411612f, 
    -0.00925698f, -0.08554394f, -0.10270479f, 0.22366922f, 0.01963121f, 0.02344293f, 0.04333340f, -0.12867501f, 
    0.01697240f, 0.06192916f, -0.12968081f, 0.29525942f, 0.39450419f, 0.10856848f, -0.02445565f, 0.06888030f, 
    0.02557943f, -0.12189963f, 0.07967295f, -0.10883971f, -0.14941046f, -0.14554612f, -0.01906072f, -0.04533101f, 
    0.03087616f, 0.02949029f, 0.34164733f, -0.27386427f, 0.12438169f, -0.04505439f, -0.13604501f, -0.09756176f, 
    -0.09298022f, 0.18034574f, 0.13113867f, -0.12303531f, 0.02411470f, 0.04810210f, -0.04606203f, -0.12377881f, 
    0.04961212f, 0.09281798f, 0.31222558f, -0.21587889f, -0.01759871f, 0.13677460f, 0.25064504f, -0.05299709f, 
    0.06644660f, 0.23686770f, -0.09437665f, -0.13714722f, 0.07858750f, -0.23392043f, 0.01559335f, 0.06477255f, 
    -0.36368194f, -0.07646408f, 0.12759192f, 0.05992254f, 0.30098507f, -0.34022480f, 0.07378114f, -0.04445821f, 
    -0.00349231f, 0.15019591f, 0.11766690f, -0.02306519f, -0.03700265f, 0.12209228f, 0.06627039f, -0.24273121f, 
    -0.03093769f, -0.09470201f, -0.33462653f, 0.00478264f, 0.30703357f, -0.17904510f, 0.04991053f, -0.29594478f, 
    0.05315418f, 0.04854877f, 0.10086582f, 0.10441145f, -0.29379705f, 0.18990561f, 0.06951483f, -0.02078894f, 
    0.11813332f, -0.05614290f, 0.16620712f, 0.01244123f, 0.15189445f, 0.03087505f, 0.16296516f, 0.31014547f, 
    -0.05922432f, 0.11017323f, 0.13641965f, -0.20607238f, 0.19944118f, -0.28254294f, -0.06262183f, -0.24869689f, 
    -0.10347809f, -0.30173647f, 0.33768889f, 0.15616636f, 0.05416574f, 0.23633698f, 0.02530366f, 0.15454291f, 
    0.28869879f, 0.52030319f, -0.02989976f, -0.03614389f, 0.04707896f, -0.08342677f, 0.01712810f, -0.17775147f, 
    -0.01738753f, 0.12093156f, -0.12115481f, 0.03050943f, -0.10062772f, 0.01198533f, -0.11240433f, -0.02598059f, 
    -0.10614640f, -0.00820494f, 0.01894664f, -0.13460566f, 0.11615916f, 0.03450241f, 0.07556422f, -0.07082362f, 
    -0.11197975f, -0.07387786f, -0.09239052f, -0.08268899f, -0.09252598f, 0.00959134f, 0.12018634f, -0.01078302f, 
    -0.05766488f, -0.11400153f, 0.01970267f, -0.10824125f, 0.04797882f, -0.11466788f, -0.03073307f, 0.08626059f, 
    -0.01500569f, -0.02889479f, -0.08898451f, 0.06648397f, -0.09503894f, 0.05878522f, 0.09787481f, 0.02937546f, 
    0.02113465f, -0.08215018f, 0.04873031f, -0.09221642f, 0.01206824f, -0.02039638f, -0.01436900f, -0.09757728f, 
    0.07245064f, -0.01321721f, 0.00997819f, -0.11384195f, 0.02603120f, 0.05227733f, 0.02539847f, 0.00931059f, 
    -0.10260273f, 0.11639504f, -0.03799586f, -0.07218882f, -0.10327117f, 0.06978581f, 0.04272537f, -0.06876127f, 
    0.12215447f, 0.37913224f, 0.04314471f, -0.01037064f, -0.00378538f, 0.26633847f, 0.00743319f, -0.07114853f, 
    0.06807118f, 0.14101368f, -0.08986326f, -0.07437228f, -0.00376469f, -0.07489613f, -0.12767206f, -0.15603355f, 
    0.13534293f, -0.04783538f, 0.12477954f, -0.03719887f, 0.18754701f, -0.09857131f, -0.00196420f, 0.16742617f, 
    -0.01592018f, 0.03384705f, 0.02749863f, -0.03339052f, 0.09585954f, 0.32409558f, -0.16275562f, -0.10582817f, 
    0.30068102f, -0.02092190f, 0.51621056f, -0.01197489f, 0.20582557f, -0.06506135f, 0.18826017f, -0.06427216f, 
    0.02578256f, 0.06435803f, -0.17011325f, -0.18492943f, -0.20883159f, 0.08819218f, -0.05023143f, 0.31234902f, 
    -0.10415691f, -0.08996230f, 0.03917464f, -0.23116510f, 0.05055234f, 0.26233473f, 0.19323955f, 0.16401458f, 
    -0.05957018f, -0.02895654f, -0.03747091f, 0.02568464f, -0.20163387f, -0.07299545f, 0.08070324f, 0.16840316f, 
    -0.09312965f, -0.15966280f, -0.09001183f, -0.09030415f, -0.13594452f, 0.04183898f, -0.12223986f, -0.06973516f, 
    0.05251266f, -0.10843659f, -0.03013933f, -0.11138649f, -0.00395593f, 0.01600210f, 0.03734856f, -0.05587009f, 
    -0.08088179f, -0.05825822f, -0.12869613f, 0.05887813f, 0.04809241f, -0.05102985f, 0.02511618f, 0.03132202f, 
    0.02990388f, -0.10866632f, -0.04193555f, -0.11829658f, -0.09941076f, -0.01271574f, -0.14967452f, -0.05928648f, 
    -0.03846516f, -0.03003721f, 0.01543049f, -0.11103944f, -0.12344015f, -0.02662075f, 0.02816491f, -0.12678102f, 
    0.11338097f, 0.01048874f, -0.07239506f, 0.06145499f, -0.08414721f, 0.03501819f, 0.10740414f, -0.00393877f, 
    0.04327855f, -0.09495157f, -0.01117168f, -0.13213287f, 0.07872394f, 0.03175513f, 0.00081836f, -0.18326686f, 
    -0.00866284f, -0.09279782f, 0.10990493f, -0.05778099f, 0.02088808f, -0.00325042f, 0.08990058f, -0.00722693f, 
    0.24411479f, 0.11786583f, 0.11483107f, -0.04935323f, 0.00730717f, 0.13908054f, 0.00723119f, 0.37318036f, 
    -0.13092273f, -0.07098538f, 0.01249412f, 0.11411918f, -0.04236968f, -0.07063092f, -0.12034238f, 0.17962553f, 
    0.12422303f, 0.06282611f, 0.06806470f, -0.27118278f, -0.17726150f, 0.08972321f, 0.08889067f, 0.12714510f, 
    -0.25046808f, 0.00695588f, 0.03586420f, -0.00886763f, 0.32990080f, 0.19571282f, 0.17366022f, 0.02626315f, 
    0.19393227f, 0.09073904f, -0.23368697f, 0.19197726f, -0.11356619f, 0.03758070f, 0.12245152f, -0.06329285f, 
    -0.05610018f, -0.06252711f, 0.16836008f, 0.05954330f, -0.10734808f, -0.16373232f, 0.07873933f, 0.04411712f, 
    -0.01674995f, -0.01353235f, 0.04314935f, -0.02614095f, 0.04545081f, 0.17559747f, -0.05399283f, -0.29340747f, 
    0.08586888f, 0.21293098f, 0.07406548f, 0.28568998f, 0.03183137f, 0.31979135f, -0.04784289f, 0.13863310f, 
    0.20330027f, 0.01530812f, 0.24430712f, 0.15742795f, 0.07381310f, 0.11157893f, -0.01720849f, -0.05990600f, 
    -0.00858694f, 0.03970522f, -0.12478120f, 0.21405181f, 0.10500772f, -0.09400184f, 0.04676375f, -0.14088687f, 
    -0.32812428f, 0.09018856f, 0.07435562f, 0.27319312f, 0.24494056f, -0.20425376f, -0.12269289f, 0.09872252f, 
    -0.29668725f, 0.02597988f, 0.08944533f, 0.01411711f, 0.10247158f, 0.26747489f, 0.06446961f, -0.10732874f, 
    -0.01885071f, 0.00410335f, 0.05532113f, 0.01747577f, 0.04728801f, -0.01292010f, -0.02267263f, -0.09869043f, 
    -0.01428150f, -0.17927471f, -0.15849923f, -0.00621415f, 0.07225510f, 0.17933871f, -0.09210973f, -0.27428570f, 
    0.12479925f, 0.20333360f, 0.21565729f, 0.07342604f, -0.02394542f, 0.15479648f, -0.01102194f, -0.13169886f, 
    0.17416197f, 0.03970431f, -0.13107304f, 0.16804940f, 0.38732201f, 0.19364519f, -0.06386920f, 0.17630751f, 
    0.04367729f, 0.00554821f, -0.06003599f, -0.08796728f, -0.05233405f, -0.10402711f, -0.02732852f, -0.11506613f, 
    0.11859939f, -0.05013439f, 0.05280513f, -0.13436690f, -0.06148317f, 0.04049757f, 0.07295338f, -0.06585633f, 
    -0.03935288f, -0.05872229f, -0.01115467f, 0.08836187f, -0.11974354f, 0.02647114f, -0.04286222f, 0.06663527f, 
    0.01281994f, -0.11660784f, 0.11279130f, -0.02682030f, -0.05498348f, -0.08134665f, 0.04516954f, 0.05259840f, 
    -0.03232760f, 0.05344331f, -0.06252323f, -0.04512279f, -0.10303627f, 0.03341271f, -0.12601499f, 0.05469578f, 
    0.04779774f, 0.02612618f, -0.13514692f, -0.06046259f, -0.04637152f, 0.09455830f, 0.07497686f, -0.04345683f, 
    -0.07949916f, 0.01896288f, -0.07978995f, -0.02828229f, -0.07827823f, 0.04486400f, -0.06343971f, -0.12162291f, 
    -0.06403681f, -0.05282212f, -0.04796281f, -0.07323872f, 0.09787390f, -0.07697435f, 0.06692475f, -0.11141765f, 
    0.20998424f, 0.08104394f, -0.03684824f, -0.02104094f, -0.14837261f, 0.16086006f, 0.01410049f, 0.00735995f, 
    0.00766157f, 0.31656522f, -0.10513580f, -0.02199231f, -0.06649953f, -0.01604235f, -0.12619837f, -0.07493164f, 
    -0.07933207f, 0.06782284f, 0.25444907f, -0.03270465f, 0.00273919f, -0.10144757f, 0.02751209f, 0.06570523f, 
    0.12985577f, 0.07775959f, 0.05016334f, 0.08111615f, 0.06580556f, -0.17125976f, 0.00777191f, -0.07314857f, 
    -0.13808021f, -0.06127424f, 0.11194558f, -0.17097388f, 0.38590568f, 0.05751722f, 0.27687991f, -0.24843761f, 
    -0.11444238f, 0.25083032f, 0.02401785f, -0.06602647f, -0.02650598f, 0.25545967f, -0.08693958f, 0.05341176f, 
    -0.02788122f, 0.15936792f, 0.00443490f, -0.10745049f, 0.00036167f, 0.08093702f, 0.23206389f, 0.11404318f, 
    0.16134410f, 0.05315422f, 0.02677036f, -0.11215708f, -0.19079995f, -0.31831029f, -0.00546411f, 0.11238157f, 
    -0.01310824f, -0.17403343f, -0.16402490f, 0.07861618f, 0.22644229f, -0.07837445f, -0.12530483f, -0.18716055f, 
    0.03708197f, 0.22962554f, -0.11413176f, 0.03484938f, 0.04773107f, -0.03243448f, -0.01117986f, 0.14116499f, 
    -0.29003555f, -0.04805085f, 0.22070211f, -0.01218696f, 0.04769789f, 0.19131327f, -0.10945968f, -0.26813492f, 
    0.01668637f, -0.11006416f, 0.01692051f, 0.04297794f, -0.19671790f, -0.26204693f, -0.00144974f, -0.01245496f, 
    -0.20956972f, 0.01579104f, -0.03303811f, 0.09985252f, 0.13034309f, -0.07670575f, -0.09018737f, -0.00967835f, 
    -0.09560812f, 0.16903196f, 0.12503684f, -0.15108053f, -0.03095505f, 0.23838840f, -0.11784104f, 0.01544029f, 
    0.02893877f, -0.14273575f, 0.25486127f, 0.00080945f, -0.07015351f, -0.12556374f, 0.31028944f, 0.23918511f, 
    0.35646790f, 0.36903581f, 0.08563347f, -0.17697738f, 0.34974897f, -0.00455189f, -0.11446968f, 0.12317640f, 
    -0.00022289f, -0.08236977f, -0.11845868f, -0.13192128f, -0.11618222f, -0.02037510f, 0.03452744f, -0.00387377f, 
    0.12353969f, 0.04511935f, -0.04334531f, 0.03908898f, -0.04925194f, -0.00883321f, -0.04044910f, -0.06466378f, 
    -0.01190788f, 0.11571537f, -0.02965297f, -0.10889680f, 0.03551735f, -0.03036030f, -0.07365268f, -0.10151689f, 
    -0.12158711f, 0.06188600f, 0.02109870f, -0.09561630f, -0.05725856f, 0.07177615f, 0.07611281f, -0.06878570f, 
    -0.06432276f, 0.11696385f, 0.11273120f, -0.01554558f, -0.06415693f, -0.06606851f, -0.05415979f, 0.00194191f, 
    -0.09630257f, -0.05670269f, 0.00501144f, 0.10093267f, -0.12430947f, -0.02415282f, -0.02469099f, 0.07462204f, 
    0.09561153f, -0.12650943f, -0.10056561f, -0.13478619f, -0.00568826f, -0.05732362f, 0.00581212f, -0.02265721f, 
    0.04362037f, 0.02058779f, 0.04276474f, 0.01494782f, -0.08145505f, 0.10426554f, 0.07651064f, -0.03154657f, 
    0.00603614f, 0.12116230f, -0.07994638f, 0.04822324f, 0.19996813f, 0.03607710f, 0.02541893f, 0.20839664f, 
    -0.02492122f, 0.18968713f, 0.03182779f, -0.00976152f, 0.11337597f, -0.02606766f, 0.11120098f, 0.31195909f, 
    -0.01754927f, -0.03812398f, -0.09072228f, -0.31994224f, -0.16230872f, 0.11956245f, 0.07578882f, -0.03261556f, 
    -0.07322982f, 0.09170741f, -0.07454113f, 0.12163319f, 0.14855282f, 0.25723934f, 0.11030166f, -0.10122675f, 
    0.11878569f, 0.10821056f, 0.04094594f, -0.12119699f, 0.03023789f, 0.02316426f, 0.00226371f, -0.13898483f, 
    -0.03244547f, 0.19361977f, -0.14551771f, -0.01792075f, -0.09886930f, -0.01200730f, 0.12394144f, 0.17436935f, 
    -0.00351071f, -0.36871114f, 0.19483835f, 0.18780957f, -0.03890331f, 0.24862817f, 0.11728114f, -0.09304082f, 
    -0.06457263f, 0.01867583f, -0.12988101f, 0.19404070f, 0.02679581f, -0.05513962f, 0.00798026f, -0.03037551f, 
    0.00628889f, 0.00258227f, 0.07435448f, 0.03520287f, 0.23468712f, -0.01615979f, 0.07722510f, 0.18062378f, 
    -0.10478859f, -0.10648991f, 0.04989595f, 0.20686023f, -0.00247554f, 0.09412568f, 0.36111131f, 0.23344952f, 
    -0.14562884f, 0.04016702f, 0.09244960f, -0.29897323f, 0.08693689f, 0.11114459f, -0.11359227f, -0.03459435f, 
    -0.36344966f, -0.10833326f, 0.11071936f, -0.04461629f, 0.14610466f, 0.16852692f, -0.03683216f, -0.11905973f, 
    0.17088465f, -0.10920187f, -0.32038537f, 0.06458262f, -0.12078350f, -0.02338862f, -0.11824723f, -0.08390516f, 
    0.03142692f, 0.04772855f, -0.13037613f, -0.00090896f, -0.11972337f, -0.02783062f, 0.03199057f, 0.08086202f, 
    -0.03796527f, -0.21831858f, 0.31681275f, 0.16658060f, -0.06371027f, 0.02883231f, -0.19062564f, -0.06540803f, 
    0.01781851f, 0.13085902f, 0.12200297f, 0.35959393f, 0.28994295f, 0.25916281f, -0.06201851f, 0.10891339f, 
    -0.20438305f, -0.06841838f, 0.08622031f, 0.04053234f, 0.01033759f, -0.08863204f, -0.05119780f, -0.21982652f, 
    -0.07364716f, 0.03975658f, 0.12544812f, 0.20589094f, -0.09056471f, 0.06322105f, 0.25386336f, -0.23068754f, 
    -0.32892433f, -0.00681382f, -0.15370591f, 0.13715884f, 0.34336841f, 0.13317177f, -0.00795290f, 0.07214750f, 
    0.04827297f, 0.03475720f, -0.06319874f, 0.08053015f, -0.10926132f, 0.05241656f, -0.13441730f, -0.05588010f, 
    -0.13320740f, 0.00069814f, -0.18418753f, 0.17638978f, 0.21427479f, -0.08070231f, 0.29840526f, 0.21852303f, 
    0.00696676f, 0.20947121f, -0.01673187f, 0.17000115f, 0.03127723f, 0.08606257f, 0.00295377f, -0.35704845f, 
    0.06423993f, 0.31525436f, 0.04493805f, 0.09995857f, -0.11858152f, -0.20326541f, -0.17732714f, -0.11010844f, 
    0.09994704f, -0.03303934f, 0.03760590f, -0.00296936f, 0.04615441f, 0.39676470f, -0.05424600f, -0.11008375f, 
    0.09135637f, -0.20037478f, 0.20907816f, 0.30398107f, 0.11260495f, -0.18530712f, -0.04304121f, -0.20300706f, 
    -0.07235099f, 0.28615341f, -0.05717985f, 0.15621014f, -0.09831709f, 0.05458865f, 0.00036135f, -0.03910277f, 
    -0.17624784f, -0.09188597f, 0.11217710f, 0.14945604f, -0.10027492f, -0.03665335f, -0.04364203f, -0.22099836f, 
    0.06208899f, -0.04366411f, 0.03042950f, -0.06062599f, -0.05155374f, -0.19085719f, 0.15947436f, 0.00700896f, 
    -0.24382405f, -0.05336646f, 0.23347749f, -0.03435839f, -0.01086903f, -0.12816040f, 0.02349154f, 0.08167768f, 
    -0.08797449f, 0.07063612f, 0.23992933f, 0.05006004f, -0.10689328f, 0.07733989f, -0.07569523f, -0.03120231f, 
    -0.04644063f, -0.02292554f, 0.07006340f, 0.27912080f, 0.03744479f, -0.05272949f, 0.23163807f, 0.26131222f, 
    0.22386545f, 0.17047279f, 0.08309402f, -0.11675485f, 0.01451788f, -0.18296486f, -0.10734263f, -0.06358787f, 
    0.05471755f, 0.17387976f, 0.05908961f, -0.42523435f, 0.05162955f, -0.07005151f, -0.00892572f, -0.00900859f, 
    -0.13203454f, -0.03422765f, 0.02898636f, -0.05471912f, -0.03451764f, 0.03173829f, -0.43846506f, -0.11634294f, 
    -0.17779031f, 0.06525868f, -0.14203174f, -0.12170405f, 0.04200974f, -0.00003717f, 0.06487931f, 0.14387082f, 
    0.03030318f, 0.10521668f, -0.03369552f, 0.00302699f, -0.14580537f, -0.08987579f, 0.10062959f, 0.01686793f, 
    -0.05854844f, 0.11226813f, 0.24583185f, 0.29251063f, 0.14110410f, -0.00331059f, 0.17418617f, 0.20630139f, 
    -0.08105075f, 0.07837933f, 0.03386235f, -0.15539984f, -0.12426559f, -0.19414511f, -0.05529802f, -0.10918667f, 
    -0.09544894f, -0.31370097f, -0.12486573f, 0.04867692f, -0.08007837f, 0.12228414f, 0.15649788f, 0.09139057f, 
    0.22887731f, 0.48018533f, 0.10962708f, -0.18324146f, -0.16610730f, -0.12606727f, 0.00861331f, 0.02040870f, 
    0.12898125f, 0.09791045f, -0.21457908f, 0.11913262f, 0.02934553f, 0.21106927f, -0.06832289f, -0.22145453f, 
    -0.07363002f, 0.03456960f, 0.11713607f, -0.05608333f, -0.07882872f, 0.08342467f, 0.20254587f, 0.12292312f, 
    0.18423007f, 0.07362112f, 0.29900700f, 0.41292128f, 0.23289257f, -0.24784535f, -0.10465302f, 0.10190104f, 
    -0.23276721f, -0.01374493f, -0.09684926f, -0.07606171f, 0.11451855f, 0.05939605f, -0.15161744f, -0.08256495f, 
    0.20617680f, 0.09342877f, -0.10052576f, 0.01365546f, 0.19305719f, 0.01558210f, -0.12226866f, -0.22775459f, 
    -0.01413261f, -0.13758960f, -0.12680465f, 0.02312276f, -0.03298554f, 0.20728293f, 0.11200790f, -0.06503835f, 
    0.05957983f, 0.36636758f, 0.00265407f, -0.05984447f, -0.06750523f, -0.09426399f, 0.09433855f, -0.02771043f, 
    -0.00067040f, -0.38267824f, -0.00904699f, 0.17732975f, 0.12070768f, 0.25459880f, -0.01640500f, 0.08181266f, 
    -0.11951962f, 0.10186078f, -0.12041461f, -0.00179410f, 0.09371736f, -0.11356205f, -0.06459154f, -0.13301528f, 
    -0.00174169f, -0.10138757f, -0.03678490f, -0.08040349f, 0.11362351f, 0.10830043f, -0.09598143f, 0.05640928f, 
    0.01556736f, -0.06201558f, -0.09605639f, -0.06511729f, 0.03796595f, -0.03239985f, 0.01078136f, -0.06079595f, 
    -0.01279781f, -0.11373049f, -0.12272961f, -0.08647885f, -0.03831282f, -0.00769988f, -0.05241904f, -0.12341374f, 
    -0.01460147f, 0.04872313f, -0.05720836f, 0.02786592f, 0.01880708f, 0.03095180f, -0.14348453f, -0.12228204f, 
    0.09844640f, -0.05827118f, -0.03271371f, 0.09120600f, 0.02014931f, 0.00306655f, -0.06567106f, 0.01792417f, 
    0.07467945f, 0.02352558f, -0.05308567f, -0.12898815f, 0.11537854f, -0.12432255f, -0.06559950f, -0.00103434f, 
    -0.08718237f, -0.04155663f, -0.08072506f, -0.07193293f, -0.11330646f, -0.09629956f, 0.01792799f, 0.07996956f, 
    -0.63130152f, -0.07781952f, 0.13553801f, -0.04149996f, 0.06595621f, -0.13827124f, -0.02075963f, -0.05711583f, 
    0.06592974f, -0.27258736f, 0.04383522f, -0.15879425f, 0.02548418f, -0.03874187f, 0.37796491f, 0.23928280f, 
    0.28361255f, -0.12913586f, -0.33060747f, 0.22914998f, 0.14600490f, 0.18353289f, 0.11552280f, 0.25121391f, 
    0.16550584f, -0.11981309f, -0.06211808f, 0.12062053f, -0.02360106f, -0.08059422f, 0.06281512f, 0.10630319f, 
    -0.11329908f, -0.06059734f, 0.04371527f, -0.18725896f, 0.07092658f, -0.03590545f, 0.02737777f, 0.30273691f, 
    0.02886789f, 0.16444272f, 0.07150279f, 0.03620864f, 0.03851735f, -0.46487623f, 0.06524400f, 0.05364311f, 
    0.10848139f, -0.11085133f, 0.14916724f, 0.12009738f, 0.02086557f, -0.03133879f, -0.38290638f, 0.06144916f, 
    -0.08134088f, 0.23316358f, 0.04025520f, 0.05132867f, -0.22635531f, -0.01918674f, -0.02766935f, -0.38985652f, 
    0.17736968f, 0.01165924f, 0.04404608f, 0.31752732f, -0.02681261f, -0.03430352f, 0.02676616f, 0.08621608f, 
    -0.10251360f, -0.14129123f, 0.05527196f, 0.32046437f, 0.10437340f, 0.11195678f, -0.10998710f, 0.04642639f, 
    -0.18559228f, -0.06918529f, -0.23034027f, -0.28955904f, 0.09358247f, 0.30438370f, 0.04108489f, 0.18327871f, 
    0.06829262f, 0.08197128f, -0.10309969f, 0.00905003f, 0.23675451f, -0.15583558f, -0.27824521f, 0.07237054f, 
    0.06034449f, -0.07212166f, -0.31877533f, 0.02896378f, -0.12598844f, -0.07779075f, -0.10968443f, 0.11373831f, 
    -0.00570423f, -0.02330228f, 0.08383440f, 0.33155534f, -0.40485692f, 0.13973548f, 0.00020847f, -0.07449710f, 
    -0.06982394f, 0.28593260f, 0.15293275f, 0.06983905f, 0.00925748f, 0.06542255f, -0.07354545f, -0.32305789f, 
    -0.29871291f, -0.00877690f, -0.04848319f, 0.34479144f, 0.19183692f, 0.20632136f, -0.07686241f, 0.00523213f, 
    -0.01606453f, -0.08913294f, 0.40929785f, -0.20937988f, 0.10524605f, -0.11103126f, -0.10363860f, 0.26214993f, 
    -0.03015521f, 0.02477571f, 0.01867678f, 0.11988115f, -0.06500740f, -0.10577933f, -0.17326863f, -0.02643639f, 
    -0.06651839f, -0.07780460f, -0.18796566f, -0.28972414f, -0.30890870f, -0.02984335f, -0.06589292f, 0.20953546f, 
    -0.04990599f, 0.09906103f, -0.04852795f, -0.12618691f, 0.20123760f, 0.28553718f, 0.21153398f, 0.03787048f, 
    0.09663781f, -0.03949890f, 0.13593142f, 0.27094853f, -0.11354625f, -0.09096980f, 0.06681419f, 0.35608020f, 
    0.07009108f, -0.10382959f, 0.04349269f, 0.23701079f, 0.04705070f, -0.25034776f, 0.08141391f, -0.06783138f, 
    -0.10843346f, -0.24769706f, -0.09305508f, 0.24133028f, 0.00003467f, 0.32071078f, -0.26107332f, -0.02408904f, 
    0.08539535f, 0.18694727f, -0.01094684f, 0.18658829f, -0.10812619f, -0.07806524f, 0.00977723f, 0.08195669f, 
    0.17290287f, -0.13783218f, -0.07697084f, 0.27935922f, -0.07225027f, -0.01786704f, -0.06903726f, -0.12255184f, 
    0.05069001f, 0.16159846f, 0.01259671f, 0.24718660f, -0.03896120f, -0.07571015f, 0.09999361f, 0.11078024f, 
    -0.02951168f, -0.02244424f, -0.19527368f, -0.09475879f, -0.04786808f, 0.06690651f, 0.07636613f, 0.12565313f, 
    0.10272118f, -0.08819636f, 0.00605142f, -0.02514485f, 0.06183553f, -0.15066497f, 0.03030558f, 0.05942471f, 
    0.14189012f, -0.06693041f, -0.38162833f, -0.15941830f, 0.07595111f, 0.00778391f, -0.11277115f, -0.07891809f, 
    0.03078611f, 0.16146068f, -0.10144933f, 0.30036306f, -0.06953566f, 0.02585544f, 0.04013569f, 0.01409208f, 
    -0.03132921f, 0.17368068f, 0.33563325f, -0.06473915f, 0.09418168f, -0.02764458f, 0.01456599f, -0.01128384f, 
    -0.06783129f, -0.08852494f, -0.08570947f, 0.04854351f, 0.28356427f, 0.21520649f, -0.01468110f, -0.03139504f, 
    0.02540961f, -0.08265827f, -0.18716794f, 0.35242403f, 0.10836515f, -0.31786710f, 0.07456808f, -0.19705236f, 
    -0.09994283f, 0.09875251f, 0.05703293f, 0.16496789f, 0.12925664f, 0.04513269f, 0.22037719f, 0.03093073f, 
    -0.32965988f, -0.01226573f, -0.00664319f, -0.08211740f, 0.17654388f, 0.20158702f, 0.04801412f, -0.10787997f, 
    0.36622733f, 0.08688927f, -0.12090828f, -0.11900421f, -0.16295321f, -0.15628818f, -0.12073945f, 0.04685698f, 
    -0.07703695f, 0.07364419f, 0.06653880f, -0.03708361f, -0.04870532f, -0.11521066f, -0.07141121f, 0.18246667f, 
    -0.01542193f, -0.03552720f, 0.23144378f, 0.26325053f, 0.04202648f, 0.15306890f, 0.07498889f, -0.12734514f, 
    0.07385038f, 0.32433665f, 0.04952531f, 0.06742129f, 0.11138271f, -0.16681415f, 0.31314021f, 0.10329956f, 
    -0.07494683f, -0.28889191f, -0.11375563f, -0.19611447f, 0.04344558f, -0.03137975f, -0.01407241f, 0.03635751f, 
    -0.04205991f, 0.00533862f, 0.41291803f, 0.24264820f, -0.00411814f, 0.02115862f, 0.10657725f, 0.21102735f, 
    -0.06219420f, -0.00051566f, 0.08830735f, 0.28140917f, 0.07058544f, -0.08215646f, -0.36466238f, -0.00306160f, 
    -0.31379285f, -0.01571208f, -0.08261638f, -0.28651497f, -0.31414056f, 0.22883454f, 0.07650968f, -0.01095412f, 
    0.24849543f, -0.11634791f, -0.00718399f, 0.01381117f, 0.20382877f, -0.29109016f, -0.09713205f, -0.00695168f, 
    -0.11740283f, -0.01710970f, 0.10251746f, 0.20234671f, -0.01135227f, -0.01965852f, 0.18614754f, 0.45479995f, 
    -0.09061331f, -0.02340704f, 0.19431065f, 0.44525132f, -0.46664390f, -0.10272731f, 0.06863025f, -0.13839377f, 
    0.00185235f, -0.08595920f, -0.01439373f, 0.27874461f, 0.02310412f, 0.19860928f, -0.03545011f, -0.15870127f, 
    0.00071290f, 0.24904555f, -0.15860823f, 0.20987980f, -0.09069400f, -0.11639334f, 0.06904361f, -0.08120067f, 
    -0.14861940f, 0.29302022f, -0.17360388f, -0.14460889f, 0.04210302f, -0.08940745f, -0.09493048f, 0.20961425f, 
    -0.10045315f, -0.10554753f, -0.03432218f, 0.07561702f, 0.00510800f, -0.06596281f, -0.06815092f, 0.00407199f, 
    -0.07128297f, -0.06043090f, -0.30952218f, -0.14894500f, 0.20108387f, 0.34357020f, -0.03158512f, 0.16879237f, 
    0.09099746f, 0.00751853f, -0.10718916f, -0.08439907f, -0.09963374f, 0.12271927f, 0.10005437f, 0.07853866f, 
    0.06106379f, 0.01412769f, 0.17034298f, -0.14764683f, 0.01226657f, -0.02379484f, 0.23528612f, 0.10576180f, 
    0.04840787f, 0.39952171f, 0.04791258f, 0.03384499f, -0.20107853f, -0.03209327f, -0.09189488f, 0.18729326f, 
    -0.12121625f, 0.01583809f, -0.18097845f, -0.04297907f, -0.06498510f, 0.18609996f, 0.18533321f, -0.16181722f, 
    -0.04968839f, 0.03058067f, -0.12929966f, 0.02576766f, -0.48665878f, -0.40856561f, -0.06063763f, -0.11810687f, 
    -0.13007963f, -0.10390229f, 0.01416477f, -0.04252275f, -0.06730396f, -0.07045806f, -0.03046602f, -0.09674165f, 
    0.10776509f, -0.06465103f, 0.00968378f, 0.07346053f, 0.01651482f, 0.04281204f, -0.04197616f, 0.00100355f, 
    -0.06683019f, -0.11016403f, -0.00698645f, 0.01109328f, 0.04269268f, -0.10787570f, -0.12290353f, -0.09639511f, 
    -0.11156427f, -0.11970764f, 0.10482087f, 0.01634597f, 0.09823305f, 0.01404943f, 0.01434529f, 0.07473409f, 
    -0.11048567f, -0.05692543f, 0.08354183f, 0.05601254f, 0.03359748f, 0.08922227f, -0.08242644f, -0.13222124f, 
    0.09065633f, -0.12472104f, -0.04319691f, 0.05835717f, 0.02541512f, -0.11741032f, -0.10752025f, 0.06234773f, 
    -0.03961068f, -0.04051457f, -0.05823939f, -0.02629318f, -0.01918192f, -0.01825545f, 0.07879886f, -0.07451904f, 
    -0.07515802f, 0.12615220f, 0.06133945f, 0.08338530f, 0.00759910f, -0.04222119f, 0.02014703f, 0.07120343f, 
    -0.12830167f, -0.01563847f, 0.03484270f, 0.35413915f, 0.10729182f, -0.10722724f, -0.00338309f, -0.24767832f, 
    -0.03428102f, 0.01898687f, 0.00571681f, 0.16103956f, -0.10556528f, -0.00857262f, 0.25306326f, 0.14098014f, 
    0.11215508f, -0.02754067f, 0.01132695f, 0.33734152f, 0.14332733f, 0.22288768f, 0.06219506f, 0.06553537f, 
    0.18875189f, 0.08052930f, -0.08765594f, 0.04862380f, -0.13130873f, -0.28912759f, -0.13117896f, 0.05802643f, 
    -0.09449665f, -0.05632433f, -0.00358342f, 0.04739675f, 0.13482724f, -0.02682074f, -0.03485936f, 0.27929667f, 
    -0.02314210f, -0.02133350f, 0.31015715f, 0.05985785f, -0.16229792f, 0.02469518f, 0.06298403f, 0.07947758f, 
    0.09303825f, 0.30908430f, -0.05919258f, -0.08368275f, -0.12064470f, -0.15377970f, 0.13267393f, 0.23665665f, 
    0.04823538f, -0.25644660f, -0.01858992f, -0.21477614f, 0.12985605f, -0.17748173f, -0.10431076f, 0.02384538f, 
    -0.13630372f, -0.24943456f, 0.12827775f, 0.04732688f, 0.07103616f, -0.06909673f, -0.09592891f, 0.21833114f, 
    -0.09579995f, 0.06296312f, -0.03868379f, 0.09174601f, -0.02540377f, -0.04081670f, 0.09289427f, 0.05371780f, 
    -0.19273107f, 0.09011239f, 0.06020512f, -0.51276362f, -0.15648429f, 0.10964999f, 0.06146751f, -0.22052334f, 
    0.24372979f, -0.09459272f, -0.00559320f, 0.01197669f, -0.01701497f, -0.25938141f, -0.03713566f, 0.10959272f, 
    -0.17720032f, -0.07146346f, -0.23551418f, 0.01222534f, 0.00614403f, 0.04753234f, -0.29881173f, 0.13118865f, 
    0.00068904f, 0.06263690f, 0.13853092f, 0.26009902f, -0.25996715f, 0.10047460f, -0.02276343f, 0.20545863f, 
    -0.07515715f, 0.17791945f, 0.05489432f, 0.03519222f, 0.01002389f, -0.07882992f, 0.16747259f, 0.08632381f, 
    0.06345956f, -0.04531363f, -0.04943962f, 0.03090399f, 0.20906535f, -0.01324666f, -0.05807247f, -0.07602135f, 
    -0.03724594f, -0.07470647f, -0.12222958f, 0.06562893f, 0.19426952f, -0.23420835f, 0.08373717f, 0.07764524f, 
    0.01116350f, 0.04371314f, -0.10422532f, 0.09555594f, -0.06763358f, -0.00326820f, -0.10718714f, 0.13839215f, 
    0.06938767f, -0.13924168f, -0.20104706f, 0.02920102f, -0.10955811f, 0.07927093f, 0.12903748f, -0.27023637f, 
    0.14548230f, 0.08249541f, 0.08047881f, -0.05321361f, -0.18097280f, -0.03785441f, 0.11155295f, 0.11397254f, 
    0.12645207f, 0.00719687f, 0.10386796f, -0.01713579f, 0.13103782f, 0.08361286f, -0.03012173f, -0.08677842f, 
    -0.04469055f, 0.03702258f, 0.09252929f, -0.05407040f, -0.00321806f, 0.07827222f, 0.01644080f, 0.00499269f, 
    0.06115782f, -0.13105425f, -0.02609368f, 0.10789288f, -0.03481396f, 0.19628254f, 0.13035527f, 0.21667695f, 
    0.21779989f, 0.21624582f, 0.05846640f, -0.12827978f, -0.05437851f, -0.47072119f, 0.11476138f, 0.07897951f, 
    -0.05367694f, 0.01707539f, -0.44817236f, -0.09520682f, -0.02441659f, 0.23823598f, -0.04069223f, 0.06109788f, 
    0.01813795f, 0.01197885f, -0.07905073f, -0.04398054f, -0.05338344f, 0.05760060f, -0.12482312f, 0.30480585f, 
    0.03184382f, 0.08207771f, 0.17540382f, 0.10345048f, -0.02569402f, 0.22520326f, -0.06702176f, 0.03767742f, 
    0.05744295f, 0.03460305f, 0.10512182f, -0.00894656f, -0.07109545f, -0.18941166f, -0.02885070f, -0.11378941f, 
    -0.02353859f, 0.05332521f, 0.04087804f, -0.05256839f, 0.09290082f, -0.04721167f, -0.08284580f, -0.26953167f, 
    -0.07624875f, 0.35375407f, 0.11799585f, -0.14967707f, -0.00323301f, 0.29916516f, -0.07673016f, 0.50436449f, 
    0.04774372f, -0.08683410f, -0.09299471f, -0.18160036f, 0.10743337f, -0.02627738f, 0.07744603f, 0.31753364f, 
    0.19126281f, -0.02948067f, 0.05914559f, -0.08440199f, -0.00311415f, -0.05285750f, -0.06455906f, 0.01461706f, 
    -0.05466983f, 0.03362221f, -0.24039142f, -0.17508103f, 0.26281720f, 0.18957701f, 0.08326060f, 0.15559320f, 
    0.06463406f, 0.22788620f, -0.00965119f, 0.05334367f, -0.06530592f, 0.12370558f, 0.00213004f, 0.04817975f, 
    0.00145492f, -0.07924595f, 0.05726997f, -0.03565127f, 0.08892440f, -0.06228553f, 0.03208314f, -0.32613921f, 
    -0.09723365f, 0.01943909f, 0.00221280f, -0.09776206f, -0.22573866f, 0.17315470f, 0.05943295f, 0.01847205f, 
    0.04820029f, 0.11193696f, 0.12168998f, -0.27794912f, 0.37171119f, 0.07305855f, 0.23771386f, -0.15102617f, 
    0.03116792f, 0.05094581f, -0.17506923f, -0.28738904f, 0.04669493f, -0.08600999f, 0.06180242f, 0.03076497f, 
    0.12091087f, -0.48622552f, 0.25708464f, 0.06324084f, 0.06992479f, 0.22056347f, -0.08937427f, 0.10770106f, 
    0.29159236f, 0.40546572f, -0.08910941f, 0.00343017f, 0.19813478f, 0.06401903f, 0.01109371f, 0.15927319f, 
    0.29197338f, -0.00984234f, 0.37395447f, -0.03579655f, -0.03776878f, 0.29471275f, -0.01945038f, -0.03698514f, 
    0.05332564f, -0.02004555f, 0.04138898f, 0.03329320f, -0.02880118f, -0.05890909f, -0.44751421f, -0.11377215f, 
    0.00168541f, -0.01655271f, 0.41066360f, 0.41179588f, -0.08982634f, 0.03590937f, 0.09816739f, 0.18906043f, 
    -0.01524747f, 0.10863215f, 0.03374163f, -0.02646488f, 0.13595130f, -0.07033501f, 0.00375122f, -0.10098508f, 
    -0.11960152f, -0.11335516f, 0.18519194f, 0.43865174f, 0.00219113f, 0.03943144f, -0.01747449f, 0.14605194f, 
    0.13017052f, -0.28960690f, -0.00870298f, 0.17261320f, 0.00604154f, 0.16785672f, -0.04604075f, 0.00597127f, 
    0.12225243f, 0.18565750f, -0.12460960f, 0.11347038f, -0.02533578f, -0.02714194f, -0.03387439f, 0.24147236f, 
    0.19741961f, -0.11360285f, 0.10604832f, -0.09020355f, 0.23034397f, 0.24441138f, -0.00425311f, 0.17917176f, 
    -0.01052920f, 0.12964211f, -0.06528845f, -0.04697365f, 0.12848644f, -0.10095543f, 0.00994901f, 0.20271830f, 
    -0.00996103f, 0.10104324f, 0.02418877f, 0.20265694f, 0.10156094f, 0.05165837f, 0.16618291f, 0.13264495f, 
    -0.18407175f, -0.00642002f, -0.23173198f, -0.17701070f, 0.02849578f, 0.19804351f, 0.01496737f, 0.10936305f, 
    -0.16965924f, -0.02992762f, -0.06246540f, -0.10589020f, 0.32717195f, 0.25364181f, -0.13338377f, 0.04753603f, 
    0.14049137f, -0.03585314f, -0.40560973f, 0.11090831f, -0.18686359f, -0.00516852f, -0.03068383f, -0.06064264f, 
    -0.01914001f, 0.00592563f, 0.04867265f, 0.06367283f, -0.23705542f, -0.02997017f, 0.02962057f, 0.14925249f, 
    0.01537196f, 0.19036706f, 0.00881270f, 0.09589066f, -0.11435603f, 0.04323479f, -0.01855728f, -0.30515778f, 
    -0.00782345f, -0.07699111f, -0.05819225f, 0.33992609f, 0.09102557f, 0.28535289f, 0.02182205f, -0.08059967f, 
    0.10700566f, 0.04403025f, -0.32487905f, -0.32380995f, -0.15865617f, 0.07662315f, -0.08713429f, 0.17772239f, 
    0.03989844f, -0.18970174f, -0.04448242f, -0.04887085f, 0.05423360f, -0.12624492f, -0.06448036f, -0.00892670f, 
    0.26278642f, 0.06861237f, 0.22338310f, 0.20616332f, 0.20892298f, -0.09286547f, -0.05979017f, 0.15328161f, 
    0.02057669f, -0.02715027f, 0.06900542f, -0.03207247f, -0.11980237f, -0.24075279f, 0.05598943f, 0.08114244f, 
    0.04174734f, -0.02837937f, -0.21428053f, 0.04032506f, 0.11121023f, 0.08762436f, 0.02450971f, -0.07078237f, 
    -0.09389548f, -0.18739063f, -0.01826954f, 0.06438999f, 0.31188765f, 0.07223497f, -0.03836235f, 0.19272324f, 
    -0.04282057f, 0.19790146f, -0.00002874f, -0.16494995f, 0.09753040f, -0.22540444f, -0.03956829f, 0.20014554f, 
    0.00812776f, 0.11020554f, 0.12843740f, -0.21551344f, 0.25113833f, 0.09966909f, -0.05510968f, -0.01055139f, 
    0.06179164f, 0.04903464f, 0.14171287f, 0.00300147f, 0.06136012f, -0.21381605f, -0.07283472f, 0.15620904f, 
    0.02718242f, 0.01839072f, 0.04412610f, 0.09512985f, -0.08160560f, -0.08706301f, -0.63968492f, -0.03738214f, 
    -0.04347837f, 0.02374203f, -0.17751408f, 0.00337188f, -0.21780169f, 0.16713415f, 0.10730872f, 0.15812431f, 
    -0.04570829f, -0.07308509f, -0.00498811f, 0.07056217f, 0.05187238f, -0.25952831f, 0.08729781f, 0.11253323f, 
    -0.20032200f, -0.01193015f, 0.11831841f, 0.42964795f, -0.20450535f, 0.01971134f, 0.28866705f, 0.09243497f, 
    0.00844230f, -0.02836017f, 0.07673439f, 0.31136289f, -0.09404023f, -0.04886217f, -0.04248800f, 0.07598069f, 
    0.00757875f, 0.19269237f, -0.31563905f, 0.17032981f, 0.09512500f, 0.15123874f, 0.04113371f, 0.03003817f, 
    0.03460101f, 0.30076221f, 0.12207827f, 0.02816900f, -0.13581245f, -0.08167035f, -0.05172989f, 0.11285774f, 
    -0.04832521f, 0.14060959f, -0.23563322f, -0.05329910f, 0.14836630f, -0.25787315f, 0.01649039f, 0.02516584f, 
    0.06030777f, -0.09305082f, 0.05836655f, 0.14938270f, -0.09898776f, 0.03049006f, 0.19245486f, -0.05282247f, 
    -0.06531132f, 0.13503852f, -0.13701360f, -0.10599377f, 0.36210808f, 0.05887504f, 0.10842781f, -0.06966937f, 
    -0.02701405f, -0.01526254f, -0.04847151f, 0.00458781f, -0.02785244f, -0.01471261f, -0.12250979f, -0.02299656f, 
    -0.04237266f, -0.01281355f, 0.15536381f, -0.02201157f, 0.14666058f, 0.04433800f, 0.07097558f, 0.02855423f, 
    -0.01964510f, 0.12730686f, -0.11961675f, -0.08632603f, -0.04184137f, 0.14853552f, -0.04144797f, 0.11767250f, 
    -0.10828412f, -0.18612671f, 0.28222671f, -0.09060925f, 0.03191743f, 0.17994413f, 0.25970462f, -0.18650828f, 
    0.15862444f, 0.13890317f, 0.02628118f, -0.17907649f, 0.25778854f, -0.04079181f, -0.04404971f, 0.15342903f, 
    0.12091712f, -0.20157504f, 0.39873540f, 0.29306850f, 0.02166927f, -0.20068394f, 0.08402139f, -0.03050370f, 
    0.05476897f, 0.10903562f, 0.05362466f, 0.18003802f, 0.00518703f, -0.05349085f, 0.20229255f, -0.02018174f, 
    -0.14838457f, 0.14537993f, -0.27175504f, 0.01844342f, -0.09593336f, -0.13594609f, 0.00646212f, -0.02671951f, 
    -0.02906573f, 0.01064222f, 0.03265143f, 0.08140141f, 0.02345693f, 0.15372910f, 0.04456531f, -0.04332662f, 
    -0.09831504f, -0.05031351f, -0.23411800f, 0.10909566f, -0.12998119f, -0.06285430f, 0.09038194f, 0.19196953f, 
    0.06132971f, -0.15853031f, 0.15518163f, 0.15191674f, 0.10608958f, 0.02401421f, -0.05670108f, -0.29253137f, 
    0.02454157f, 0.14146034f, 0.18409853f, 0.27401292f, 0.03377534f, 0.01750892f, -0.14549775f, -0.04279651f, 
    -0.02789709f, 0.07930542f, -0.10977407f, 0.14794302f, 0.01921354f, -0.04691376f, 0.00431886f, 0.02202507f, 
    0.25536537f, 0.27899715f, 0.02917658f, -0.21711119f, 0.00473642f, 0.11930691f, -0.09930351f, 0.08749152f, 
    0.08455218f, -0.11532941f, 0.12272159f, -0.09051748f, -0.07464400f, -0.08869229f, -0.17347319f, 0.06168310f, 
    0.18043168f, 0.04240546f, 0.20533979f, 0.19440651f, -0.06507287f, -0.15148525f, 0.02868796f, 0.19202580f, 
    -0.35163999f, -0.10821348f, 0.02667047f, -0.09471188f, 0.18723528f, 0.01777903f, -0.06830303f, 0.08342304f, 
    0.06790500f, -0.08057341f, 0.03024224f, 0.28066856f, 0.01387964f, -0.11837292f, 0.04457630f, -0.15584590f, 
    0.01397317f, 0.08253939f, 0.04413258f, -0.13604884f, 0.02631094f, 0.02563731f, -0.01994744f, 0.26463848f, 
    -0.03695859f, -0.02501550f, -0.31660694f, -0.01917966f, 0.06931312f, 0.10090102f, -0.05543582f, -0.06563674f, 
    0.20400077f, -0.04772760f, -0.01314927f, -0.01309646f, 0.13549227f, 0.19144809f, -0.07472788f, 0.08852939f, 
    0.30586904f, -0.05268088f, 0.02470102f, -0.26623851f, -0.11233595f, 0.08601283f, 0.09812878f, 0.01153134f, 
    -0.09326255f, -0.21434256f, 0.08630329f, 0.08273380f, -0.09655161f, -0.01702278f, -0.44652861f, -0.32276264f, 
    0.06899683f, 0.09002635f, 0.08239711f, 0.20658571f, 0.30554110f, 0.04539993f, 0.06358471f, 0.08170511f, 
    -0.30121249f, -0.05553940f, -0.03475150f, -0.04619136f, 0.21554238f, -0.29340070f, -0.36688587f, -0.04175087f, 
    0.02212922f, 0.01368964f, -0.21552940f, 0.31076592f, -0.01514345f, -0.02910166f, -0.00284979f, -0.02301954f, 
    0.10298285f, -0.21556818f, -0.16254450f, 0.29365608f, 0.03310049f, 0.03722984f, -0.08007545f, -0.05702261f, 
    -0.05012065f, 0.20587926f, 0.00094738f, -0.23683262f, 0.03206429f, 0.18852887f, 0.05403671f, -0.47697276f, 
    0.06278514f, 0.35593626f, 0.08737309f, 0.25053287f, 0.23547371f, 0.62143761f, -0.11428517f, 0.15996489f, 
    -0.07646039f, -0.17228340f, 0.35323766f, 0.19005936f, -0.09748001f, 0.08284916f, 0.01449417f, -0.11454128f, 
    -0.05592255f, -0.06286117f, 0.08149649f, 0.04942539f, -0.04228301f, -0.02101713f, 0.06719868f, 0.22562446f, 
    0.10664151f, -0.11659222f, 0.19449817f, 0.31177509f, -0.13709614f, 0.03158420f, -0.01529981f, -0.13314906f, 
    -0.11808795f, -0.06828982f, -0.03614242f, 0.07457051f, 0.08015724f, 0.02853269f, 0.12089010f, -0.07778451f, 
    0.00725687f, -0.00234658f, -0.11570487f, 0.27621147f, -0.20942999f, 0.00509614f, -0.02963158f, 0.16624360f, 
    -0.05767062f, 0.03003807f, 0.24503900f, 0.14206144f, -0.01492746f, 0.04275647f, -0.01128908f, -0.14650452f, 
    0.07770908f, 0.18445162f, -0.21249093f, 0.27073705f, 0.06730750f, -0.28822258f, -0.15707895f, 0.20155014f, 
    0.20318216f, -0.19818680f, -0.11260001f, 0.07374778f, 0.01015189f, 0.02126899f, 0.09051730f, 0.08919834f, 
    0.12344043f, -0.08121197f, -0.15158379f, -0.25678295f, 0.02658135f, 0.07879753f, -0.03119552f, 0.11901376f, 
    0.11659129f, 0.02427243f, 0.09391792f, -0.12989984f, -0.10599200f, -0.01970997f, -0.11950169f, 0.05914155f, 
    -0.04077874f, 0.10678376f, 0.11929812f, -0.06938673f, 0.05197845f, -0.03097050f, 0.08163784f, 0.10256145f, 
    -0.20334141f, 0.00605886f, -0.06402419f, -0.03439997f, -0.01771872f, -0.21267876f, -0.19819251f, 0.03138228f, 
    0.00749659f, -0.11079418f, -0.09666044f, 0.02539909f, -0.05281050f, 0.10925958f, -0.02423402f, -0.10348017f, 
    -0.09687878f, 0.03548034f, 0.02968051f, -0.03426132f, 0.01269188f, 0.08067799f, 0.10137778f, 0.01297650f, 
    -0.00813515f, -0.03288996f, -0.24566562f, -0.05149981f, 0.00375852f, -0.01627599f, 0.08278508f, 0.06394476f, 
    0.05588752f, -0.07339668f, -0.08690807f, -0.09242797f, -0.05659463f, 0.02479242f, 0.08134524f, 0.08394650f, 
    -0.32684603f, 0.01291168f, -0.17390999f, -0.08116681f, 0.01496212f, 0.16857725f, -0.08992916f, 0.03188955f, 
    0.04859255f, -0.01648786f, -0.08156174f, -0.25402296f, 0.12211286f, -0.04368018f, -0.29154685f, 0.00009486f, 
    -0.08861609f, 0.11218071f, -0.19486919f, -0.32033062f, -0.18941425f, -0.08879107f, -0.07830094f, -0.15636581f, 
    0.16975451f, 0.02908985f, -0.03110829f, -0.06667305f, -0.03140574f, 0.02550255f, -0.04467762f, 0.03450328f, 
    -0.11174720f, 0.06469078f, -0.16465306f, -0.10353172f, 0.07840117f, -0.10617384f, -0.12604684f, 0.03220188f, 
    0.12144120f, -0.42625400f, 0.05394210f, 0.02078624f, 0.11218090f, 0.11933336f, -0.04140922f, -0.13411309f, 
    -0.03119124f, 0.16049874f, -0.21483649f, -0.23424169f, 0.00006178f, -0.03434895f, 0.00756835f, 0.06226072f, 
    -0.11525800f, -0.07607888f, 0.07863694f, -0.06984252f, -0.13872817f, -0.01605448f, 0.07862062f, -0.17922767f, 
    0.32345873f, 0.14584050f, 0.16758247f, -0.18538931f, -0.07251962f, 0.03381586f, -0.02498786f, 0.30491185f, 
    0.09374218f, -0.21156061f, 0.05402830f, 0.00998982f, -0.09492993f, -0.11151984f, -0.19495243f, 0.18053336f, 
    0.26469764f, 0.02909204f, 0.10900723f, -0.03319553f, -0.16923270f, 0.11439319f, 0.01075317f, 0.37132263f, 
    -0.12461802f, -0.00941472f, 0.06457262f, 0.11047393f, 0.35095677f, 0.22682360f, 0.11504808f, 0.01846115f, 
    0.07275279f, 0.05227737f, -0.10579205f, 0.02450454f, 0.15197617f, 0.08788567f, -0.04315998f, -0.11396531f, 
    -0.06894775f, -0.03289166f, 0.10374330f, 0.08450101f, -0.02531549f, -0.04756614f, -0.11614578f, 0.38977382f, 
    -0.10269231f, 0.00851300f, 0.07928244f, -0.14571616f, -0.05314354f, 0.12738740f, -0.04450271f, -0.15708138f, 
    0.03719998f, -0.01281245f, -0.08590078f, 0.25351429f, -0.07890267f, 0.31303579f, 0.11664718f, 0.06581603f, 
    0.12306343f, 0.08903661f, 0.35032198f, 0.22955343f, 0.14997225f, -0.13649988f, 0.09973752f, 0.03177175f, 
    0.04940988f, -0.14599438f, -0.09289964f, 0.01803846f, -0.12350269f, 0.01601342f, -0.05442741f, -0.07331928f, 
    -0.20970960f, 0.02711608f, -0.03422642f, -0.18952836f, 0.09197374f, 0.13660440f, -0.03822311f, -0.10231408f, 
    0.05068911f, -0.02968199f, 0.06801042f, 0.10375193f, -0.10267066f, 0.05889564f, -0.15398613f, 0.04463354f, 
    0.10168742f, -0.06933537f, 0.23964453f, -0.14390483f, -0.05098685f, 0.10189096f, 0.01066120f, 0.27467164f, 
    0.03597222f, 0.04452828f, 0.11109836f, 0.03769885f, -0.08443400f, -0.16345847f, 0.08673224f, -0.07730949f, 
    0.09028064f, -0.10881736f, 0.25568733f, 0.13858028f, -0.01156342f, 0.36807504f, 0.20460162f, -0.27001214f, 
    -0.15961456f, 0.25786334f, 0.11696288f, 0.07901333f, 0.03251740f, -0.26041797f, 0.10255366f, 0.05213482f, 
    0.24268442f, -0.06843202f, 0.25712514f, -0.01040459f, -0.25686315f, 0.09862318f, 0.06136645f, -0.08878771f, 
    0.08213396f, 0.27188960f, 0.01589637f, -0.02447431f, -0.07149412f, 0.01729826f, 0.01379698f, -0.27383152f, 
    -0.10761196f, 0.07083611f, 0.25915599f, 0.01312081f, -0.12871519f, -0.19872265f, 0.09151930f, 0.09477007f, 
    -0.03515015f, 0.00482789f, -0.09087215f, -0.02550955f, 0.13200960f, -0.05010575f, -0.13162039f, 0.03522879f, 
    0.19301380f, 0.00521040f, 0.26340351f, -0.00854991f, 0.16350944f, -0.01825552f, 0.01231962f, -0.20416734f, 
    0.05315226f, -0.13598557f, -0.19851439f, 0.15129416f, -0.06139104f, -0.07329416f, 0.07133114f, -0.23012447f, 
    0.04973470f, 0.13449976f, 0.04070456f, 0.16316554f, 0.10324641f, 0.00994775f, 0.06386057f, 0.15867256f, 
    0.07542495f, -0.14908387f, 0.01316610f, -0.01759437f, 0.06282126f, 0.18547526f, -0.05603965f, 0.07288150f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.21985795f, 0.25301790f, 0.19428203f, 0.18867105f, -0.00646673f, -0.04640123f, 0.14061971f, 0.01554184f, 
    0.08453342f, -0.07333165f, 0.13202554f, -0.02808548f, 0.03358762f, 0.12525684f, -0.01909691f, -0.01728186f, 
    0.13376755f, 0.07272433f, -0.00123260f, -0.09198614f, 0.00820568f, 0.11857551f, 0.05499647f, -0.19462827f, 
    0.10781459f, -0.13294272f, -0.13598730f, 0.11256790f, 0.16754135f, 0.03242271f, 0.20871349f, 0.00259394f, 
    -0.01484329f, 0.14873721f, -0.01299082f, -0.02126544f, -0.06915231f, 0.21592556f, 0.02126988f, 0.12252881f, 
    -0.09504960f, -0.04318380f, 0.04722704f, 0.24178363f, 0.03261584f, 0.04946463f, 0.07395482f, 0.15695031f, 
    0.11309956f, 0.04643388f, -0.08014500f, 0.10124308f, -0.10800511f, -0.00599351f, 0.03652909f, -0.10350791f, 
    -0.04570260f, -0.08381428f, 0.10603654f, 0.10812356f, -0.07301448f, 0.09342822f, 0.09755205f, 0.01889239f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.29022175f, -0.24722163f, -0.47692659f, -0.16670488f, 0.31762084f, -0.47903609f, 0.09841041f, 0.06830509f, 
    -0.16142626f, 0.08397115f, -0.24555872f, 0.16734016f, 0.03430720f, -0.25241727f, -0.05855413f, -0.04613180f, 
    -0.26158768f, 0.10555870f, 0.18371648f, -0.03223367f, -0.06933276f, 0.10509659f, 0.08988030f, -0.03433882f, 
    0.00336272f, 0.04200996f, 0.03594937f, -0.00579569f, 0.09440168f, -0.04198876f, -0.04367458f, 0.13218287f, 
    0.00246723f, -0.52065021f, -0.18521829f, 0.26837572f, -0.01976843f, -0.40166721f, 0.03234041f, -0.43077442f, 
    0.01580023f, -0.22967863f, -0.66800648f, -0.23163152f, 0.07075813f, -0.11572838f, -0.21022747f, -0.20396769f, 
    0.20909701f, 0.08458489f, 0.11128634f, 0.02761698f, 0.34142745f, -0.17555289f, 0.10328497f, -0.47805807f, 
    0.19077557f, 0.21561810f, -0.24515870f, 0.16375156f, 0.17299728f, 0.13321114f, -0.45366213f, 0.00991254f, 
    0.20000471f, 0.18676659f, 0.18002015f, -0.19160561f, -0.26841339f, -0.08755758f, 0.21762572f, 0.14057760f, 
    0.26330420f, 0.07783467f, 0.35385907f, 0.03269966f, 0.29545307f, 0.01465269f, -0.08346121f, -0.08905134f, 
    0.12401042f, 0.13707204f, 0.01280424f, 0.00591388f, -0.19494255f, 0.12878746f, 0.22580308f, -0.02734507f, 
    -0.07524799f, 0.05695316f, 0.09057086f, 0.20131034f, 0.03517753f, 0.03649740f, 0.10966659f, -0.06135126f, 
    -0.38422471f, 0.07225376f, -0.23164529f, 0.32134762f, 0.03389067f, 0.27317035f, -0.31083509f, -0.25893721f, 
    -0.09820845f, -0.12746549f, -0.54309100f, -0.10492450f, 0.03064536f, 0.12413156f, -0.23684345f, 0.03696636f, 
    0.13970391f, 0.07752505f, 0.09120940f, -0.24645068f, -0.13075113f, -0.51731962f, -0.08383042f, -0.25897235f, 
    0.05265978f, -0.76219678f, 0.08751895f, 0.01997391f, 0.13516198f, 0.05297619f, -0.07499743f, 0.22830290f, 
    0.12921293f, 0.18753977f, -0.39023623f, -0.04275749f, -0.51759112f, -0.04820580f, 0.17909540f, 0.10724659f, 
    -0.23353621f, 0.07228619f, -0.40408680f, -0.47417369f, 0.08481383f, 0.02175985f, 0.09641610f, -0.00273594f, 
    -0.10134001f, -0.18295579f, -0.38731536f, -0.05837959f, -0.38839477f, -0.12341342f, -0.63773495f, -0.01923892f, 
    0.09757593f, 0.02785552f, 0.00728536f, -0.05271146f, 0.38760644f, -0.06194304f, 0.18063754f, 0.14216869f, 
    -0.50556219f, 0.16216509f, -0.49921945f, -0.29272848f, 0.05352505f, -0.54813492f, 0.20434564f, -0.03883930f, 
    0.11054690f, 0.22962600f, 0.19398011f, -0.18207595f, 0.01456269f, 0.12671083f, 0.25359520f, 0.11622892f, 
    0.09740855f, -0.04188753f, 0.10713919f, 0.02215961f, 0.11560585f, 0.17176162f, 0.00482153f, 0.01569270f, 
    -0.04164855f, -0.42191857f, 0.10210013f, -0.11474550f, -0.01725257f, 0.08426286f, 0.02487091f, -0.49098030f, 
    -0.13711388f, -0.05306402f, -0.05570564f, -0.07442877f, 0.15194517f, 0.18211435f, 0.05409396f, -0.47931024f, 
    -0.51438159f, 0.08796148f, -0.27071565f, 0.21390866f, -0.01417858f, -0.10387874f, 0.11653998f, 0.04691564f, 
    -0.32798499f, -0.47122100f, -0.14367758f, 0.10133126f, -0.05837630f, -0.13245976f, -0.18244314f, 0.02224831f, 
    -0.04737985f, 0.12134115f, -0.00029354f, 0.11632896f, 0.12637739f, -0.03063751f, -0.41110551f, -0.14766786f, 
    0.26505753f, 0.15449910f, -0.18657447f, 0.04456326f, 0.03805319f, -0.22367768f, 0.06483208f, -0.11784513f, 
    0.01888011f, 0.29374251f, 0.01684977f, -0.24066117f, -0.11949463f, 0.34408456f, -0.01291704f, -0.26938143f, 
    -0.16338868f, -0.11501706f, 0.16021655f, -0.16770022f, 0.07463804f, 0.08920443f, 0.06567439f, -0.00351444f, 
    -0.03104640f, 0.18126135f, 0.05307703f, -0.28817761f, -0.77941692f, 0.04460059f, -0.01135250f, 0.04413174f, 
    -0.35842204f, -0.06031430f, 0.19256829f, -0.58162701f, -0.20004672f, -0.11608791f, 0.00200901f, -0.09050609f, 
    -0.54104978f, -0.11688477f, -0.16942121f, 0.19157335f, 0.07012498f, 0.03971687f, 0.09143995f, 0.01826380f, 
    -0.15108816f, 0.08917367f, 0.12965161f, -0.06829430f, 0.12576739f, -0.10739414f, -0.01691735f, 0.00318111f, 
    0.14770961f, 0.14148425f, -0.10081130f, 0.02632615f, -0.21386544f, -0.10321810f, 0.07200728f, 0.03551044f, 
    0.00252407f, -0.21321933f, -0.11267695f, 0.09616352f, -0.10501595f, 0.19319521f, 0.17584157f, 0.10796142f, 
    0.11724423f, -0.34547809f, 0.00411967f, -0.32154027f, -0.03380661f, -0.45377669f, -0.26172981f, 0.00023190f, 
    -0.24444713f, 0.04435880f, 0.10785658f, 0.06368206f, -0.02997779f, 0.09561274f, -0.08049203f, 0.06383703f, 
    0.05635677f, 0.18033686f, -0.08888222f, -0.28382385f, -0.12827623f, 0.18989658f, -0.04142293f, 0.18303798f, 
    0.23099671f, -0.11679245f, -0.09955902f, -0.20769496f, 0.16188642f, -0.11917900f, 0.04702198f, -0.11253791f, 
    -0.26191419f, 0.05878073f, -0.23372231f, -0.22576392f, 0.17694473f, 0.04814531f, 0.09799525f, 0.04069990f, 
    -0.09891769f, 0.16790628f, 0.12061614f, 0.09227399f, 0.18161163f, 0.08401609f, 0.17261975f, -0.02630087f, 
    -0.00672821f, -0.04218933f, 0.01433006f, 0.07587007f, 0.08076376f, -0.01147090f, 0.12449995f, -0.12287474f, 
    -0.27736035f, -0.01308535f, 0.42961690f, -0.34517881f, 0.05685089f, -0.10379357f, -0.10018530f, 0.12887421f, 
    -0.25887257f, -0.18995228f, -0.01228323f, 0.16244540f, -0.05293849f, -0.25952566f, -0.14136295f, 0.14957236f, 
    0.00348983f, 0.18666427f, -0.00411542f, -0.19574890f, 0.02672176f, 0.20211644f, 0.14373682f, -0.22660981f, 
    0.05207950f, 0.09332495f, -0.45526764f, -0.02199184f, 0.05718333f, 0.09925620f, 0.20369549f, -0.05041740f, 
    0.02918028f, 0.18315065f, -0.19273682f, 0.22710226f, -0.27352059f, 0.05295939f, -0.56764072f, 0.17692015f, 
    -0.27951223f, -0.14229366f, -0.15200283f, -0.11641339f, -0.39566731f, 0.10093332f, 0.12102985f, 0.02160939f, 
    0.03351578f, 0.06069079f, -0.21447343f, -0.27192405f, -0.06036915f, -0.10989556f, -0.65356261f, -0.14338577f, 
    0.05309125f, -0.45945174f, -0.00183553f, -0.48910868f, -0.33948767f, -0.10398706f, 0.18645686f, 0.12577835f, 
    0.05549074f, -0.03681201f, -0.25968665f, -0.25227794f, -0.08724513f, 0.20718010f, 0.19888280f, 0.14844826f, 
    0.00995760f, 0.13214089f, 0.24225587f, 0.23223379f, -0.06321830f, 0.07931557f, 0.31690860f, 0.01319197f, 
    -0.03030455f, -0.24985395f, -0.61415082f, 0.14662801f, 0.07749035f, -0.02277590f, -0.12437779f, -0.07694324f, 
    -0.42827901f, -0.12290578f, -0.06429260f, -0.10757850f, 0.09789103f, 0.07536516f, 0.16372390f, -0.30532032f, 
    -0.07831925f, -0.03460391f, 0.19385441f, 0.10597415f, 0.01019397f, 0.12272406f, 0.17282011f, -0.00527889f, 
    -0.23150997f, -0.07987049f, -0.14916119f, 0.09035597f, 0.11024430f, -0.32412553f, 0.02638857f, -0.10188150f, 
    -0.06242367f, 0.10145251f, 0.16409002f, -0.18870288f, 0.08939799f, 0.09119667f, -0.21069989f, -0.11540049f, 
    -0.34341764f, -0.19142215f, 0.05552417f, -0.43055204f, -0.19751266f, -0.08783592f, -0.20651188f, -0.57076138f, 
    0.07232396f, 0.15851820f, 0.30207211f, 0.10767709f, 0.08130569f, 0.13624658f, -0.51233929f, 0.13013370f, 
    -0.13631511f, 0.20927572f, 0.15813048f, -0.23800080f, 0.00493670f, 0.23290031f, -0.13103537f, 0.09484809f, 
    -0.35976824f, -0.42435053f, 0.46558639f, -0.38571805f, -0.00050601f, 0.44231233f, -0.46352836f, 0.17414656f, 
    -0.07214788f, -0.23157202f, 0.22222432f, -0.00119472f, -0.18330145f, -0.25944358f, -0.02108486f, -0.32136905f, 
    0.24634299f, -0.33928424f, 0.10649706f, 0.24261758f, 0.15704077f, 0.02073726f, -0.11136505f, -0.25881043f, 
    0.09541202f, 0.08868554f, -0.05387940f, -0.29131418f, -0.12451493f, 0.07202967f, -0.01024814f, 0.00240233f, 
    0.01330107f, -0.46489149f, -0.31497413f, -0.04074760f, 0.05053096f, -0.04161331f, -0.32153800f, -0.02974094f, 
    -0.50441873f, -0.33647925f, 0.05542020f, 0.23827934f, 0.43309480f, -0.14587149f, 0.05481825f, -0.47030994f, 
    0.25503454f, 0.24647588f, 0.12606344f, -0.28934118f, -0.11391813f, -0.01497578f, -0.12545231f, -0.37097216f, 
    0.04838179f, 0.17051575f, -0.11714529f, 0.15839146f, 0.06641162f, 0.12844941f, 0.12937362f, 0.18523405f, 
    0.34662005f, 0.20791635f, -0.41526368f, -0.16167620f, -0.02536801f, 0.05022394f, -0.01147323f, -0.02600660f, 
    -0.52549922f, -0.06643568f, 0.03798563f, -0.08840621f, -0.36195612f, -0.53414971f, -0.24681205f, -0.62791324f, 
    -0.27989054f, -0.03296442f, 0.00139596f, 0.27405113f, -0.26018777f, 0.00466923f, -0.06641277f, -0.18938291f, 
    -0.08662242f, 0.06820262f, -0.01180066f, -0.13044782f, 0.19537976f, 0.15318759f, -0.00063115f, 0.00289150f, 
    0.15712738f, 0.28591317f, -0.08777363f, -0.49707010f, -0.44794923f, 0.10965386f, -0.07693151f, 0.06569914f, 
    0.20730117f, -0.08643348f, 0.03313249f, 0.02896885f, -0.56737727f, -0.02703374f, -0.04648865f, -0.02664370f, 
    0.05118401f, -0.10993601f, -0.05873576f, -0.30339253f, 0.02194897f, -0.06259363f, -0.02714269f, 0.14079711f, 
    -0.20395465f, -0.30932611f, 0.03672769f, 0.14063914f, -0.06278001f, -0.07358053f, -0.31053922f, -0.18030265f, 
    -0.10264397f, -0.33299264f, 0.03307052f, 0.16663614f, -0.57182497f, 0.35137281f, -0.30687705f, -0.08308031f, 
    0.22739781f, -0.19057280f, 0.17950578f, -0.14717171f, -0.14273539f, 0.21009502f, -0.24934019f, -0.24041939f, 
    0.07957513f, 0.11605738f, -0.33728313f, -0.29362160f, -0.37210295f, 0.21773981f, -0.29667604f, -0.28841904f, 
    0.14643459f, -0.07554923f, -0.60833883f, -0.17681280f, -0.00561395f, 0.28801566f, -0.02061540f, -0.12801160f, 
    0.15546696f, -0.18370251f, 0.28535995f, 0.29256511f, -0.06170012f, 0.11565959f, 0.12915833f, 0.04478641f, 
    -0.15972398f, 0.20597348f, -0.02282071f, -0.11336810f, -0.23000202f, -0.10013635f, 0.02035187f, -0.02449755f, 
    0.15374297f, -0.17228815f, -0.24100140f, 0.33265465f, -0.11565334f, -0.17005476f, 0.20598310f, -0.41544312f, 
    0.15627144f, 0.29204610f, -0.33327886f, 0.30876735f, 0.05573992f, 0.21748237f, -0.29867709f, -0.00680880f, 
    -0.12696236f, -0.15723948f, -0.33518660f, 0.10551935f, -0.34236112f, -0.22277267f, 0.19113833f, 0.01712225f, 
    -0.16809146f, -0.14580077f, -0.29887885f, -0.07347389f, -0.26600409f, 0.01258652f, 0.20747152f, -0.37242010f, 
    0.01124725f, -0.07710133f, 0.01411839f, 0.16644703f, -0.24609189f, 0.22549589f, -0.17783494f, 0.19422807f, 
    -0.37753919f, -0.02706609f, -0.26495260f, -0.13869265f, -0.45909977f, -0.39474392f, -0.12241057f, 0.04309706f, 
    -0.01261829f, -0.18151991f, 0.07134461f, -0.05372583f, 0.28731969f, 0.05652454f, -0.53039956f, -0.06588275f, 
    -0.00792090f, 0.34629554f, 0.09221493f, -0.30229217f, 0.22371601f, 0.08608177f, 0.16758050f, 0.33328748f, 
    0.14445159f, 0.15021434f, -0.00200653f, 0.00660473f, -0.12168779f, 0.02678697f, -0.41842073f, 0.14766642f, 
    -0.11963183f, -0.11194400f, -0.19323575f, -0.17560685f, 0.09501864f, -0.16294456f, -0.20903099f, 0.00068328f, 
    -0.56517279f, 0.32688349f, -0.11373032f, 0.03823533f, -0.70793754f, -0.28290257f, 0.06956182f, 0.24338181f, 
    -0.07552968f, -0.18902306f, -0.00579020f, 0.05245929f, -0.60519558f, -0.18442473f, 0.11798881f, -0.22329976f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.13522953f, 0.18530150f, 0.13176188f, -0.10271826f, 0.04478998f, 0.09482884f, 0.12763749f, -0.10349022f, 
    -0.00884675f, 0.03409253f, -0.07023741f, -0.00314855f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
