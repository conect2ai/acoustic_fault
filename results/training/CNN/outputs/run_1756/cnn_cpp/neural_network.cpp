#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.38098952f, -0.92102587f, -0.96537822f, -0.52342254f, -0.71209371f, 0.67605108f, 0.23030950f, 0.26419479f, 
    0.01832739f, 0.41397193f, 0.09286469f, 0.00976867f, 0.16820391f, -0.19661719f, 0.15621744f, -0.09690551f, 
    0.15729007f, 0.02028503f, 0.03571784f, -0.08561464f, 0.00044930f, -0.23968947f, -0.07610188f, -0.01073213f, 
    0.00577233f, -0.87633765f, -0.69934404f, -0.72492987f, -0.01939649f, 0.36820769f, 0.15782252f, 0.01348280f, 
    0.09359458f, -0.25550556f, -0.23502658f, -0.37175909f, -0.55580252f, -0.21186382f, 0.31040597f, -0.25145903f, 
    0.21222050f, 0.11827506f, -0.16511783f, -0.39956045f, -0.11786429f, 0.20282598f, -0.24163592f, 0.09311874f, 
    -0.04971806f, -0.23937152f, 0.63882941f, -0.03780737f, -0.17907980f, -0.43134594f, 0.40663579f, -0.26942816f, 
    0.10314151f, -0.15364647f, -0.18246722f, 0.35710078f, -0.18765983f, 0.50747693f, -0.28126830f, -0.39580759f, 
    0.48428795f, -0.05521650f, 0.07475802f, -0.11770401f, 0.06544894f, -0.24691021f, 0.20910130f, -0.10648455f, 
    0.01414228f, -0.02954065f, -0.16680248f, -0.28299740f, 0.17095837f, -0.52034199f, -0.40508196f, -0.17046291f, 
    -0.12241085f, -0.02577720f, 0.37057525f, -0.30564156f, -0.10394407f, -0.05387313f, 0.10875858f, 0.12826876f, 
    -0.16944855f, -0.08247237f, -0.24978988f, -0.21816708f, -0.04303453f, -0.22641829f, 0.07743760f, 0.19500650f, 
    0.35114279f, 0.07523447f, 0.31692824f, 0.39506611f, -0.14267237f, -0.57409143f, -0.19156428f, -0.27961466f, 
    -0.20421657f, -0.12601224f, -0.32802090f, -0.40014312f, -0.18380721f, -0.43340057f, 0.65397042f, 0.43976927f, 
    0.14940797f, 0.44571665f, -0.25428557f, 0.04989079f, 0.04572079f, -0.31774959f, -0.16564909f, -0.28926545f, 
    0.07607639f, -0.03228385f, 0.07241446f, -0.28906929f, -0.38868731f, 0.28030837f, -0.08907323f, -0.25872675f, 
    0.11215620f, 0.15416190f, 0.17474745f, 0.24038075f, 0.04218798f, -0.36626077f, -0.05704507f, -0.00582479f, 
    0.48220992f, -0.40251017f, -0.07586399f, 0.11941142f, 0.28135431f, -0.24657978f, 0.26046789f, 0.00449376f, 
    -0.05822805f, 0.10105228f, 0.07458268f, -0.21715459f, 0.15593676f, -0.04656727f, -0.04383510f, 0.18522634f, 
    -0.10757874f, -0.30125448f, -0.58854049f, -0.44220155f, -0.34165436f, -0.53667337f, -0.50251585f, -0.64094597f, 
    0.06867768f, -0.17443818f, -0.24140859f, -0.41825488f, 0.30179459f, -0.25008702f, 0.19431259f, -0.18375519f, 
    -0.30211300f, -0.32564875f, -0.37589175f, 0.14056259f, 0.01833803f, -0.00855764f, -0.04238460f, -0.18440786f, 
    0.62481606f, 0.37216172f, -0.02951063f, -0.29816636f, -0.21402267f, -0.28249800f, -0.05987491f, 0.30327946f, 
    -0.16263781f, 0.34606138f, -0.25303099f, -0.10658469f, -0.06662277f, -0.11740583f, -0.07372064f, -0.18284228f, 
    0.04054065f, -0.09806467f, -0.12799938f, -0.14027180f, 0.26177078f, 0.24525994f, -0.02615177f, 0.16706499f, 
    -0.22230625f, -0.59299910f, 0.22563469f, 0.74980062f, 0.53060502f, -0.70666456f, -0.76308060f, -0.30028456f, 
    0.51278466f, 0.12073349f, 0.06699058f, -0.19764982f, 0.06413136f, 0.35537255f, 0.05628173f, -0.19601095f, 
    0.10332188f, -0.03649084f, -0.05218650f, 0.00554659f, -0.06772597f, -0.08482680f, -0.14382759f, 0.17310624f, 
    -0.14703454f, -0.33049959f, 0.10984358f, -0.14518225f, -0.14196007f, 0.31571433f, -0.07665257f, 0.21553142f, 
    0.02445578f, -0.25962785f, 0.20865817f, 0.11596020f, 0.07166587f, -0.14120573f, 0.41896239f, -0.16060512f, 
    -0.29171029f, 0.13024506f, -0.28456107f, -0.15861538f, -0.20288451f, 0.22563933f, 0.28838113f, 0.34096324f, 
    0.27908200f, -0.15300523f, 0.13190815f, 0.06531724f, -0.91341686f, -0.15384743f, 0.76231974f, 0.14411551f, 
    -0.16137195f, 0.38919032f, -0.64763945f, -0.60738403f, -0.15412775f, 0.01376514f, -0.14036891f, 0.01467728f, 
    -0.22723296f, 0.10039532f, 0.13378684f, 0.09108389f, 0.25242102f, 0.20653023f, -0.12338658f, -0.14598127f, 
    -0.02147427f, -0.04622337f, 0.00856502f, 0.69660133f, -0.14085358f, -0.00854364f, -0.17397946f, 0.00149420f, 
    0.18758032f, 0.41985223f, -0.09611679f, -0.44698653f, -0.20353727f, 0.05095039f, -0.09747163f, 0.05352169f, 
    -0.34672311f, -0.19091412f, -0.04180344f, 0.25155050f, 0.19714440f, -0.23153628f, -0.09591151f, 0.10415735f, 
    -0.44659036f, -0.38438138f, -0.16568910f, -0.42065853f, 0.31352597f, 0.46916041f, 0.36888868f, 0.20800769f, 
    -0.01396529f, 0.05745672f, -0.02600359f, -0.14215054f, -0.21884769f, 0.09053811f, 0.13337451f, -0.14125028f, 
    0.15350328f, 0.22811183f, -0.12570265f, 0.02690923f, -0.01208513f, -0.00222666f, -0.09467743f, -0.19224332f, 
    0.14347495f, 0.29885444f, -0.09217091f, -0.18758224f, -0.15983559f, 0.91892028f, -0.31176990f, -0.35915664f, 
    -0.11992279f, -0.07570850f, 0.45687816f, 0.22210006f, -0.09182528f, 0.24811627f, 0.06286455f, 0.03750545f, 
    0.10339791f, -0.24164042f, 0.02392181f, -0.27227160f, 0.01441400f, -0.16152705f, 0.07686897f, -0.05660190f, 
    -0.19358669f, -0.16451026f, 0.09285400f, 0.10158283f, -0.20856783f, -0.15355054f, -0.13047740f, -0.48432851f, 
    -0.06278174f, 0.80859834f, 0.38732511f, 0.55135947f, 0.19001894f, -0.54225844f, -0.58157927f, -0.41165972f, 
    -0.13123538f, -0.17601576f, -0.10575666f, 0.07932794f, -0.00865820f, -0.29736850f, -0.30080870f, -0.00755601f, 
    0.20106632f, 0.19931678f, 0.25569144f, -0.14489979f, 0.11198762f, -0.06299847f, -0.32286370f, -1.07921660f, 
    -0.58563644f, -0.20964898f, 0.49718919f, 0.80062288f, 0.09481948f, 0.17728242f, -0.31238961f, 0.32771969f, 
    0.56875205f, 0.17897832f, 0.24561933f, -0.06170021f, 0.22659145f, -0.21277499f, -0.36163089f, -0.14012823f, 
    0.38544503f, -0.21885179f, -0.22573075f, -0.20243672f, 0.29609087f, 0.01008824f, 0.11277355f, 0.17694396f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.16732781f, 0.06251231f, 0.24115819f, 0.02801080f, 0.18313904f, 0.13547364f, -0.02402565f, 0.09615891f, 
    0.17843622f, 0.04779178f, -0.13422003f, -0.09773415f, -0.13563877f, 0.11474308f, 0.09260435f, 0.27901942f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.43157777f, 0.19250014f, 0.03611245f, -0.04344025f, -0.16399595f, 0.01159699f, 0.13913879f, 0.24701606f, 
    0.01711333f, -0.05367514f, -0.01857694f, 0.09535372f, -0.21394260f, -0.05881058f, -0.14799017f, -0.12489925f, 
    -0.04847772f, -0.00566894f, 0.04615362f, 0.06492665f, 0.02058586f, 0.02638716f, -0.04335524f, 0.12913047f, 
    0.16686520f, 0.01413211f, 0.06938745f, 0.12186693f, 0.01411744f, 0.08645788f, -0.00550538f, 0.06908471f, 
    -0.06375683f, 0.09529142f, 0.16582982f, 0.04622317f, -0.17610548f, -0.05629092f, 0.10083821f, -0.14598003f, 
    -0.12049112f, -0.04596977f, -0.19041122f, -0.01874202f, 0.04438468f, -0.05650224f, -0.06915159f, -0.24196720f, 
    -0.09437702f, -0.21493146f, 0.12463812f, 0.02520795f, 0.05819963f, 0.05631125f, 0.10999937f, -0.02632502f, 
    0.03663066f, 0.07678863f, -0.07111456f, 0.00616262f, -0.10809006f, -0.01100728f, -0.10421878f, -0.01327034f, 
    0.06011825f, 0.18103163f, 0.09921943f, 0.02579220f, 0.03617948f, 0.09074854f, 0.07441633f, 0.06214476f, 
    -0.15729889f, 0.07868365f, 0.02581405f, 0.08330467f, 0.05770531f, -0.08069611f, 0.02008679f, -0.17276849f, 
    0.25591490f, 0.00376205f, 0.00938688f, 0.03657418f, 0.00521579f, 0.09635585f, -0.09702946f, 0.10030795f, 
    0.00867080f, -0.03438209f, 0.00237052f, -0.07796892f, 0.01404032f, -0.07451675f, -0.04276984f, 0.06722009f, 
    0.56945056f, -0.21548595f, -0.11523174f, 0.12837902f, 0.22855563f, 0.09601376f, 0.00213184f, -0.12587637f, 
    0.07788796f, 0.03280806f, -0.02199771f, -0.00137084f, 0.00758945f, 0.09646559f, -0.13040891f, -0.04143847f, 
    -0.00708968f, -0.05807027f, -0.00204344f, 0.06772204f, -0.07367490f, 0.04728642f, 0.00149915f, -0.02243828f, 
    -0.31410307f, -0.03347506f, 0.22544847f, -0.26136494f, 0.04043769f, 0.15089907f, 0.10340698f, 0.10695396f, 
    -0.03317769f, -0.11146332f, 0.04441953f, 0.02806020f, -0.30817452f, -0.02878604f, -0.02611853f, -0.02856292f, 
    0.01886570f, 0.13111360f, 0.13158511f, 0.10753586f, 0.02223138f, 0.18625765f, 0.12834145f, 0.01637788f, 
    -0.13292505f, 0.04604251f, 0.05824013f, -0.29888058f, 0.02473263f, -0.04645739f, 0.04854989f, 0.10613513f, 
    -0.07472514f, -0.06358627f, -0.03954101f, 0.03889334f, -0.28086546f, -0.09638770f, 0.02048689f, 0.03012889f, 
    0.00564019f, -0.04572010f, -0.15203811f, -0.03840962f, 0.12616462f, 0.14270194f, 0.14975657f, 0.13755536f, 
    -0.13101467f, 0.05058770f, -0.06294666f, 0.08757943f, -0.02363446f, 0.08874755f, 0.11075656f, -0.02842414f, 
    -0.02254993f, 0.03233160f, 0.07424580f, 0.00346391f, 0.06037828f, -0.08420332f, -0.08544774f, 0.07847231f, 
    0.02860833f, -0.08425383f, 0.01001481f, 0.03671789f, 0.26938200f, 0.03697755f, 0.24714710f, -0.09692680f, 
    -0.30153924f, 0.09233435f, 0.03163055f, 0.17271931f, -0.10509633f, -0.04417398f, 0.10628802f, 0.19051227f, 
    0.09661350f, 0.10395223f, -0.06957918f, -0.06359908f, -0.28408313f, -0.17264384f, 0.02542377f, -0.18274567f, 
    -0.05266472f, -0.02466611f, 0.03159514f, 0.05133379f, 0.00098177f, 0.08968846f, -0.07545844f, 0.13383533f, 
    0.39207360f, -0.05460864f, 0.04058207f, 0.14517416f, 0.07879091f, -0.00109680f, 0.07438482f, 0.12088030f, 
    -0.07320912f, 0.11227329f, -0.02288834f, 0.13508195f, -0.05929631f, -0.02733393f, 0.05523954f, 0.12930770f, 
    0.06242177f, -0.00749836f, -0.07528108f, 0.06191391f, 0.03431287f, 0.05218321f, -0.02489077f, -0.08189368f, 
    -0.07262723f, -0.08955209f, 0.23125777f, 0.16240056f, 0.10071879f, -0.01707616f, 0.08366994f, -0.01923545f, 
    0.13112140f, -0.05621192f, 0.05302100f, 0.08171089f, -0.14954075f, -0.02251482f, -0.16332103f, -0.10469230f, 
    0.10008477f, -0.03125622f, 0.11647530f, -0.05936217f, 0.00475050f, -0.04323906f, -0.04031605f, -0.03290283f, 
    -0.30186173f, -0.06297868f, 0.04127906f, 0.19046073f, 0.01490862f, -0.04508740f, 0.08176481f, -0.05210576f, 
    0.10159262f, -0.00032159f, 0.05262660f, 0.08337291f, 0.20455174f, 0.29969710f, 0.05286328f, 0.00619399f, 
    0.05762468f, -0.01498054f, -0.01930069f, -0.08904272f, 0.00645633f, -0.08386560f, -0.01613913f, -0.01584080f, 
    0.36041066f, -0.01199531f, -0.10575717f, 0.23861904f, -0.01486712f, -0.02536979f, 0.04735354f, 0.03796918f, 
    -0.04903557f, 0.04458871f, 0.01403053f, 0.13527937f, 0.18151368f, -0.03864286f, -0.11408984f, -0.14015265f, 
    -0.18039969f, -0.13422889f, 0.08129354f, 0.04938089f, -0.01909807f, 0.03701597f, 0.10991667f, 0.00044982f, 
    -0.20444082f, 0.12579963f, 0.22782968f, 0.01830076f, 0.08895731f, 0.19416751f, -0.02451748f, 0.00982407f, 
    0.04392793f, -0.03787814f, 0.01906442f, -0.00194611f, 0.01421718f, 0.18339835f, 0.04963187f, 0.03500533f, 
    -0.01014486f, 0.03735165f, 0.06179009f, 0.08348659f, 0.03038575f, -0.04209737f, 0.07338180f, -0.10752395f, 
    -0.06083193f, -0.04691894f, 0.03142849f, -0.12868795f, -0.02013981f, -0.18052430f, -0.20910488f, 0.01737064f, 
    -0.16152734f, -0.13127239f, -0.06298108f, -0.10701137f, -0.25268197f, 0.21824335f, 0.03774474f, -0.08110793f, 
    -0.06400613f, 0.04543727f, -0.03234243f, -0.04734496f, 0.12634364f, 0.01691514f, 0.15509637f, 0.14259616f, 
    -0.16647664f, 0.23797303f, -0.05788008f, 0.27089998f, 0.05687407f, 0.18134616f, 0.04252876f, 0.01125869f, 
    -0.00485680f, 0.12320119f, -0.00749158f, 0.00747988f, -0.01610313f, -0.22757582f, -0.14572993f, -0.30773208f, 
    -0.09213009f, -0.03616220f, -0.06258927f, 0.09872600f, 0.20135179f, 0.08857930f, 0.26911184f, -0.06963485f, 
    -0.07413418f, 0.32845724f, 0.16645287f, 0.04794351f, 0.07550897f, -0.10664049f, -0.08350967f, 0.06793377f, 
    -0.07538655f, -0.04859950f, 0.06849343f, -0.03769406f, -0.05339005f, 0.08802104f, 0.22934386f, 0.08208348f, 
    -0.07786601f, 0.10867310f, -0.14985543f, 0.12595028f, -0.06347597f, -0.07623072f, -0.02311264f, -0.04973940f, 
    -0.08203915f, 0.15590376f, -0.10529159f, 0.18661924f, -0.15000330f, 0.02606721f, 0.06211754f, -0.00344162f, 
    -0.07704185f, 0.12928927f, 0.07004154f, 0.00365020f, 0.23417099f, 0.24664192f, 0.20984979f, 0.13514818f, 
    -0.07933217f, 0.11228682f, 0.04038454f, -0.13730288f, 0.11383227f, 0.03965573f, -0.04376864f, 0.01289448f, 
    0.07321205f, 0.17509957f, 0.10136812f, 0.29003474f, 0.08711791f, -0.00504200f, 0.10371181f, -0.02677946f, 
    0.10400949f, 0.03169168f, -0.00343276f, 0.00973879f, -0.05282440f, -0.00476916f, -0.08916482f, 0.10374582f, 
    0.10843164f, 0.13903648f, 0.00166769f, 0.06943867f, -0.07052342f, -0.03061847f, 0.03223303f, 0.00617550f, 
    0.19594733f, 0.15512285f, 0.18893360f, 0.24510629f, 0.05779183f, -0.02597543f, 0.17610712f, 0.05313930f, 
    -0.08403642f, -0.03398778f, -0.02561889f, 0.00995477f, 0.19962861f, -0.22921947f, 0.12259617f, 0.10313767f, 
    -0.11159030f, -0.07352615f, 0.00650888f, -0.07435585f, -0.02715547f, -0.04767117f, -0.05904550f, 0.03307237f, 
    -0.45847762f, 0.10195173f, 0.15599167f, -0.01471453f, -0.25467935f, 0.05251689f, -0.05455649f, 0.07301364f, 
    -0.07762675f, -0.10407531f, -0.07014021f, 0.13013184f, 0.10512771f, 0.23109402f, 0.05154828f, 0.11317930f, 
    0.03946067f, 0.02181080f, 0.06468419f, -0.06511628f, 0.04456930f, -0.16599554f, -0.05032539f, -0.17071746f, 
    0.09753034f, 0.08812238f, 0.28359446f, 0.16576944f, -0.08668400f, 0.15726806f, -0.15802215f, 0.02023754f, 
    -0.07439841f, -0.06846169f, 0.00710367f, -0.05842463f, 0.09484809f, 0.03948744f, -0.16549386f, -0.02214327f, 
    -0.02675332f, -0.07859335f, 0.05641973f, 0.04077309f, 0.10674442f, -0.13069636f, 0.04483024f, 0.08850703f, 
    -0.17403646f, -0.15143676f, -0.08621818f, 0.08126618f, -0.00016652f, -0.03437624f, -0.01298407f, -0.03276138f, 
    0.03973725f, -0.01671692f, 0.05566512f, 0.13148361f, -0.20635098f, -0.10831273f, -0.30697876f, -0.01301912f, 
    0.04168422f, 0.06607670f, -0.00539638f, 0.14479530f, -0.09722848f, -0.08619832f, -0.03436756f, 0.06949838f, 
    -0.06163699f, 0.23904508f, -0.04479503f, 0.04521456f, -0.14116393f, -0.06185724f, 0.02728384f, 0.18749547f, 
    -0.06865199f, -0.03410324f, -0.05237200f, 0.05732867f, -0.19069949f, 0.07257681f, -0.19400731f, 0.15106903f, 
    0.04516786f, 0.11974163f, 0.02719595f, -0.10850121f, -0.05040731f, 0.00111525f, 0.04583561f, -0.03613743f, 
    0.31598803f, 0.01356594f, 0.25707191f, 0.07026886f, -0.00501561f, 0.06796177f, 0.09727591f, -0.03296027f, 
    0.00381100f, -0.02695651f, 0.01764252f, 0.06013004f, 0.03136083f, 0.23649544f, 0.48568812f, 0.48116827f, 
    0.15887094f, -0.00870656f, -0.05475737f, 0.13102283f, 0.06987012f, -0.04955121f, 0.00815998f, -0.10657094f, 
    -0.08277117f, -0.20736273f, -0.09690531f, -0.16179639f, -0.07342116f, -0.18892159f, -0.29228318f, 0.04647948f, 
    0.15183115f, 0.03584065f, -0.21013573f, -0.22902532f, 0.23408644f, 0.25633425f, 0.10792951f, 0.29528853f, 
    0.24784547f, 0.17547938f, 0.19291747f, 0.05297809f, 0.07950068f, 0.13038917f, -0.03191426f, -0.05395041f, 
    0.09454238f, 0.20163931f, -0.03770089f, 0.24275467f, -0.11083061f, 0.01156642f, 0.14430511f, 0.06066113f, 
    0.16074407f, -0.11326912f, -0.00860856f, 0.13684945f, 0.05351559f, -0.11459234f, -0.10384033f, -0.13054529f, 
    0.05534191f, -0.04091550f, 0.05018596f, 0.11407211f, 0.13944380f, 0.02508974f, -0.05161152f, 0.08458936f, 
    0.18321256f, 0.23937510f, 0.11333352f, 0.25805128f, 0.04491979f, -0.15960635f, 0.10760289f, 0.15822430f, 
    -0.00413547f, 0.15310167f, -0.08441062f, 0.06599889f, -0.37471336f, -0.22692777f, -0.02641296f, 0.02649044f, 
    -0.00541570f, -0.04678217f, 0.02283335f, 0.02666849f, 0.02938547f, -0.06090794f, -0.01872868f, -0.07005353f, 
    -0.35234347f, -0.43198535f, 0.08986034f, -0.00329264f, -0.01299249f, -0.05860745f, 0.10760253f, 0.00303481f, 
    0.09104248f, -0.02778753f, -0.00510701f, -0.12921360f, 0.03534466f, -0.09094015f, -0.01561847f, 0.02587935f, 
    -0.12530157f, -0.17750601f, 0.10604796f, 0.06157611f, 0.09073120f, 0.04092271f, 0.04475205f, -0.11201999f, 
    0.13479084f, 0.31517506f, -0.01128876f, 0.01891315f, 0.00962747f, -0.16482289f, 0.14054482f, 0.06294960f, 
    0.09640095f, 0.03417102f, -0.01903711f, 0.05695956f, 0.11520855f, -0.01872447f, -0.10712779f, -0.19394363f, 
    -0.07119296f, 0.08977656f, -0.22548938f, 0.11072844f, -0.06771410f, -0.06049454f, 0.12771922f, -0.00789838f, 
    -0.24546847f, -0.17430912f, -0.27790198f, -0.19928488f, 0.00572211f, -0.06294228f, -0.08822944f, 0.08215662f, 
    0.06001304f, -0.00857529f, 0.04478030f, -0.04995743f, 0.19623159f, -0.36423722f, -0.22949828f, -0.19147319f, 
    -0.09597722f, 0.01351439f, -0.07765862f, -0.03440199f, 0.07195763f, 0.01098839f, 0.16716875f, -0.08281122f, 
    0.01826784f, 0.13591066f, 0.24578594f, -0.01784352f, -0.00079805f, -0.15869516f, -0.23639582f, 0.03167360f, 
    0.01631092f, 0.02551354f, 0.00527307f, -0.15228482f, -0.12409318f, -0.29812321f, 0.16313586f, 0.15655188f, 
    -0.05414668f, -0.07461735f, 0.00598908f, 0.01513406f, 0.09224597f, -0.02317768f, -0.00437889f, 0.16864194f, 
    0.18422337f, 0.00901288f, 0.09901371f, -0.27049741f, -0.01133233f, -0.18347593f, -0.13498186f, -0.09122342f, 
    0.01177002f, -0.00669243f, 0.11428530f, 0.01577431f, -0.19815259f, -0.01774221f, -0.13335887f, 0.08950879f, 
    0.00210782f, 0.10165639f, -0.21260442f, 0.06579664f, -0.04752187f, -0.01070240f, 0.02635744f, 0.07734968f, 
    0.12767939f, -0.10267776f, -0.05596650f, -0.29247802f, 0.10465800f, -0.04081671f, 0.13208525f, -0.00254677f, 
    0.12129972f, -0.03763600f, 0.18558058f, -0.01147825f, -0.03918418f, 0.01654316f, 0.13547988f, -0.01070604f, 
    -0.02800540f, -0.18040238f, 0.05288940f, 0.20954707f, 0.00097286f, -0.09350570f, -0.05203028f, 0.13459158f, 
    -0.15154468f, 0.28533086f, 0.28991601f, 0.15344317f, -0.10086402f, -0.07142872f, -0.01999667f, 0.12705959f, 
    0.10723227f, 0.14569223f, -0.03664647f, -0.04220226f, 0.07573241f, -0.07556107f, 0.10291103f, -0.09622135f, 
    0.08545876f, 0.06957198f, -0.02381115f, -0.18687302f, -0.04191457f, -0.08285847f, -0.06804498f, -0.06541467f, 
    0.11564951f, 0.20471153f, -0.02527998f, 0.11803859f, 0.00298425f, -0.05915030f, 0.21453938f, 0.00037680f, 
    -0.01662051f, 0.04022060f, 0.02134540f, -0.07006252f, 0.19995788f, -0.08976442f, -0.11854026f, 0.32119590f, 
    -0.06714271f, 0.05449109f, -0.08607338f, -0.24239987f, 0.00740201f, -0.00964449f, -0.01264566f, -0.10250730f, 
    -0.19937451f, -0.17929004f, -0.27303740f, 0.07447458f, -0.00965761f, 0.08967315f, 0.00614434f, 0.06039888f, 
    0.02295347f, -0.12387202f, 0.11077862f, -0.09381043f, -0.01584570f, 0.08441787f, 0.17590988f, 0.16503318f, 
    -0.04475365f, 0.07527956f, -0.20075063f, -0.02940178f, -0.10231295f, -0.06996533f, 0.14177689f, -0.13240890f, 
    -0.31792080f, -0.09843206f, -0.09735525f, -0.07459267f, -0.00682470f, 0.01463835f, -0.14837269f, 0.12498394f, 
    -0.10316395f, -0.08863533f, 0.00844608f, -0.14278148f, 0.22733496f, -0.03501831f, 0.25675115f, -0.07136578f, 
    0.01802736f, 0.10416069f, 0.12852807f, 0.07955140f, 0.06434706f, 0.07785421f, 0.03753138f, 0.21757755f, 
    0.21565795f, -0.01494533f, -0.23090620f, 0.06108600f, -0.01264021f, 0.12855330f, -0.02156059f, -0.07584007f, 
    -0.05147291f, 0.06017316f, -0.03436362f, 0.02329760f, 0.40111133f, 0.00479617f, 0.15142602f, -0.10266995f, 
    0.05907923f, -0.08975095f, -0.11514585f, -0.02860923f, 0.02614208f, 0.11399724f, 0.03867911f, 0.00517325f, 
    -0.06604954f, -0.51763594f, 0.38775957f, 0.14742227f, 0.16890211f, 0.08756341f, -0.17096026f, -0.03210279f, 
    0.04926731f, 0.06663650f, -0.09886259f, -0.07429362f, 0.08777079f, 0.11476887f, 0.19557941f, 0.14114602f, 
    -0.10930860f, -0.02310411f, -0.14932999f, -0.10792467f, 0.02774359f, -0.02478146f, -0.01503840f, -0.00467364f, 
    -0.16851810f, 0.34208158f, 0.27899507f, 0.36192042f, -0.05456927f, -0.11047792f, 0.01161510f, -0.11072167f, 
    0.18684424f, 0.09809354f, 0.04296589f, 0.06308348f, -0.27297255f, -0.16516989f, 0.03311415f, -0.00886195f, 
    -0.07772420f, 0.04824867f, 0.06511624f, -0.06380367f, 0.02917938f, 0.00980417f, -0.03156960f, 0.02269995f, 
    0.31740481f, 0.13578553f, -0.27506715f, 0.20882298f, 0.04510985f, 0.19674022f, 0.05222625f, 0.15767303f, 
    -0.05598427f, 0.04443531f, -0.04697520f, 0.16715862f, -0.15224651f, 0.02347265f, 0.11533372f, 0.07382281f, 
    0.02735937f, -0.07134517f, -0.09517216f, -0.09009955f, -0.05808969f, -0.03950818f, -0.18250127f, -0.15065096f, 
    -0.16103137f, -0.10706751f, 0.22528550f, 0.15759371f, 0.03326948f, -0.02612038f, -0.02680969f, -0.09724016f, 
    0.14035408f, 0.15903433f, -0.05123477f, -0.05840709f, -0.01061618f, 0.14962755f, -0.25714734f, 0.18606022f, 
    0.02166874f, -0.15758820f, 0.00979406f, 0.00879943f, -0.08417224f, -0.11196575f, -0.08916231f, -0.01286512f, 
    -0.16002461f, -0.08675916f, 0.01197057f, 0.18629795f, -0.00034051f, 0.08389591f, -0.00453850f, 0.06536936f, 
    -0.08809551f, -0.07593343f, -0.06738723f, -0.02595109f, 0.35783094f, 0.12421519f, 0.06100428f, -0.16126043f, 
    0.11023457f, 0.02865283f, -0.08883861f, -0.15476379f, -0.23006265f, -0.13931490f, 0.00880125f, -0.07699017f, 
    -0.13319857f, 0.10418127f, -0.23153621f, 0.13873661f, -0.09932037f, -0.01117337f, 0.15135625f, 0.02656014f, 
    -0.04068490f, -0.04142277f, 0.16784658f, 0.11672561f, 0.00667082f, -0.10662322f, -0.03393219f, -0.06372988f, 
    -0.16399688f, -0.13757256f, 0.02677617f, 0.05212504f, -0.02253854f, -0.20913097f, -0.03235499f, -0.05024920f, 
    0.01856870f, -0.05484203f, 0.17200696f, 0.29634291f, 0.02086297f, 0.22685923f, -0.14793430f, 0.00997273f, 
    -0.00730537f, -0.03993052f, 0.07848444f, -0.02275349f, 0.11256566f, 0.27263299f, -0.04110273f, 0.16008842f, 
    0.15878192f, 0.05995796f, 0.16528773f, -0.06082589f, 0.06950838f, 0.06536977f, -0.00028291f, 0.07657933f, 
    0.09544226f, -0.02671546f, -0.00248868f, -0.16363133f, 0.14049873f, -0.09073164f, -0.20419784f, 0.04361849f, 
    -0.27088115f, -0.16925852f, 0.03080169f, 0.09598455f, -0.10363717f, 0.26868516f, -0.16162914f, 0.05446901f, 
    -0.03035878f, 0.02018179f, -0.04903633f, 0.04118561f, -0.08316926f, 0.04300458f, 0.09699389f, 0.18179514f, 
    -0.27356887f, 0.33847269f, -0.12275068f, 0.30953243f, 0.14507949f, 0.15740928f, 0.02116138f, -0.07293954f, 
    0.02031168f, 0.07189755f, 0.09981962f, -0.03992296f, -0.37065306f, -0.03642682f, -0.16628225f, 0.03615599f, 
    -0.07008442f, 0.03025857f, 0.04756080f, -0.04563678f, -0.02507173f, -0.03151431f, -0.05666340f, 0.06760787f, 
    -0.08541814f, 0.53874600f, 0.27998039f, 0.20021799f, -0.01596329f, -0.05850990f, 0.10462312f, 0.18238799f, 
    -0.19479084f, -0.00625800f, 0.06091934f, 0.07320974f, -0.14466561f, -0.28595835f, 0.46591607f, 0.04351117f, 
    -0.03436496f, 0.05114829f, 0.02846170f, -0.11159134f, -0.04292393f, -0.10455970f, 0.05102103f, -0.14964728f, 
    0.30577222f, 0.05302986f, 0.05741281f, 0.16354717f, 0.00826094f, 0.19754004f, 0.05132805f, 0.13747609f, 
    0.02441741f, 0.19001782f, 0.03821131f, 0.12021272f, 0.01464756f, -0.01422503f, 0.18067427f, -0.19346362f, 
    -0.03305007f, -0.08962502f, -0.10776062f, 0.10139322f, -0.15892699f, -0.09287196f, -0.13238141f, -0.08272126f, 
    -0.18442471f, -0.20497943f, 0.13808437f, 0.02399329f, -0.05406154f, -0.09971769f, -0.14711422f, -0.15240465f, 
    0.02959263f, 0.06331094f, -0.09472187f, 0.04303019f, 0.04766168f, -0.01772252f, 0.00738328f, 0.13355045f, 
    0.01643556f, 0.03639326f, 0.07093529f, 0.15400249f, 0.18925501f, -0.05662970f, -0.02106610f, 0.03252706f, 
    -0.18592693f, -0.07535537f, -0.14072824f, -0.18581674f, -0.11418942f, -0.19367087f, -0.31462926f, -0.29930753f, 
    -0.08242083f, -0.06731730f, -0.03056312f, 0.02619840f, -0.00034881f, -0.00627929f, 0.01240834f, -0.20102736f, 
    -0.01913773f, 0.03016902f, 0.12281439f, 0.09187690f, 0.05851790f, -0.02589031f, -0.02459730f, -0.03811701f, 
    0.05139372f, 0.33954340f, -0.17660439f, 0.28129002f, -0.02321000f, 0.07785892f, -0.04875009f, 0.08569835f, 
    -0.09761577f, -0.01213902f, 0.07022101f, 0.14397101f, -0.10573900f, -0.15150654f, -0.08197281f, -0.04880903f, 
    0.08271682f, 0.02821242f, 0.10417123f, -0.01311992f, 0.03978220f, 0.03123624f, -0.04356445f, -0.07597846f, 
    -0.33544126f, -0.26597849f, 0.30890226f, 0.08180760f, -0.01376140f, 0.14872791f, -0.07898962f, 0.03128557f, 
    -0.03366705f, 0.01954326f, -0.04848089f, -0.01598078f, -0.11579311f, -0.19408922f, -0.00554903f, -0.12494081f, 
    0.14727944f, 0.03945231f, 0.09629417f, 0.06303041f, 0.16759339f, 0.20706572f, 0.07686450f, 0.14320154f, 
    0.07182081f, 0.24518743f, 0.14076285f, -0.07387959f, 0.01832238f, 0.06069745f, 0.05765831f, 0.02820679f, 
    0.07290310f, -0.05714887f, 0.01651688f, 0.06493840f, -0.19305648f, 0.07105825f, -0.00793472f, 0.05506807f, 
    0.05802486f, 0.00389892f, -0.08043008f, 0.16348539f, 0.02212611f, -0.00025394f, 0.08150265f, 0.15026113f, 
    -0.07666028f, 0.15908213f, -0.15447982f, 0.20993218f, 0.03201010f, 0.01080441f, 0.22368346f, -0.06779227f, 
    0.03238883f, 0.07419322f, 0.15812194f, 0.07422121f, -0.28670329f, -0.02633917f, -0.29063442f, 0.25028959f, 
    0.11159845f, 0.10588161f, 0.04662490f, 0.14806956f, 0.15833704f, 0.03118674f, 0.06792584f, -0.11850403f, 
    0.08996646f, 0.11329138f, 0.14583379f, 0.24597785f, 0.13451654f, 0.11879360f, 0.03790959f, -0.27757877f, 
    0.08506250f, -0.07442114f, 0.00789682f, 0.04351159f, -0.08172745f, 0.04486864f, 0.04120633f, 0.11709262f, 
    0.08339114f, -0.00316549f, 0.16671260f, -0.05466810f, 0.06193956f, -0.04749518f, 0.02841091f, -0.01217656f, 
    0.15753081f, -0.06857444f, -0.01160617f, 0.21750978f, -0.10530583f, 0.21243401f, -0.19921502f, -0.06828848f, 
    0.08620610f, 0.22456366f, -0.18331482f, 0.09228579f, -0.04126653f, -0.05604224f, -0.05280057f, 0.11052111f, 
    0.09240362f, 0.01874958f, 0.07080867f, 0.11632971f, -0.11626361f, 0.04680061f, -0.07296782f, -0.09041626f, 
    -0.21037818f, -0.08420034f, -0.04979963f, 0.06898241f, 0.01626991f, 0.08851568f, 0.06410442f, 0.15470481f, 
    0.09647571f, 0.05219167f, 0.01168910f, -0.02256546f, 0.15732005f, -0.02579601f, -0.21773149f, 0.03384877f, 
    -0.02153160f, -0.07376876f, -0.07721102f, 0.01205474f, 0.04708905f, 0.04381556f, -0.02967630f, 0.01263617f, 
    -0.12030928f, -0.29297534f, 0.06750157f, -0.06964003f, -0.05470730f, 0.01175506f, 0.01602240f, 0.08870438f, 
    -0.07174124f, 0.09766649f, -0.21384332f, -0.06090657f, 0.25461859f, 0.22741453f, 0.15685061f, -0.26208556f, 
    0.04393785f, -0.08031335f, -0.12653865f, -0.06152692f, -0.25307912f, -0.06649035f, -0.03430862f, -0.16206574f, 
    0.00426121f, 0.25594521f, -0.26240617f, 0.11946543f, -0.02137013f, -0.23735766f, 0.19688137f, 0.00615177f, 
    -0.10120796f, 0.03040135f, 0.04576343f, -0.08034257f, 0.04622172f, -0.39803132f, -0.12827587f, -0.05315224f, 
    -0.14657363f, -0.24662460f, 0.03286928f, 0.11834180f, 0.13035670f, -0.22893891f, 0.04902568f, 0.11483162f, 
    0.26893979f, -0.03997346f, -0.07433718f, 0.26794177f, 0.02968811f, 0.06724133f, -0.06676854f, -0.13114899f, 
    0.10423234f, -0.06206536f, -0.06776594f, -0.08951442f, -0.04158243f, 0.31147653f, -0.09767675f, 0.00675505f, 
    0.08920872f, -0.03730553f, 0.04695275f, -0.33438638f, 0.12580767f, 0.12520014f, -0.07091897f, 0.25179017f, 
    0.01223257f, 0.00735809f, -0.18067338f, -0.14380035f, 0.00790109f, -0.17274661f, -0.27524039f, 0.02433625f, 
    -0.14010446f, -0.10761096f, 0.05352671f, -0.05322894f, 0.07740130f, 0.36371580f, 0.00187304f, 0.01249102f, 
    0.09233485f, 0.07401702f, -0.05565166f, -0.08227640f, 0.02318948f, 0.20302136f, 0.08104244f, 0.16329135f, 
    -0.19780888f, 0.43989316f, -0.18797897f, 0.17989491f, 0.15038149f, 0.02960853f, -0.05276301f, -0.11012606f, 
    0.01110396f, -0.00383186f, 0.15386252f, 0.01176028f, -0.23044617f, -0.14020526f, -0.09773030f, -0.00215780f, 
    -0.00345034f, -0.05403377f, -0.05310526f, 0.08650456f, -0.10246722f, 0.07645051f, -0.08499885f, 0.11679906f, 
    -0.26296279f, 0.03836965f, 0.37235793f, 0.17309786f, -0.02681179f, 0.06454337f, -0.00314332f, -0.13013938f, 
    -0.07640569f, -0.05350121f, -0.13711797f, 0.08196568f, -0.11422715f, 0.03306395f, -0.17158763f, -0.09109364f, 
    -0.03333231f, 0.00564481f, -0.22372036f, 0.11354823f, -0.03148197f, 0.04640914f, -0.04661417f, 0.17150202f, 
    -0.23030485f, -0.11377450f, 0.12343030f, -0.06706635f, -0.03462544f, -0.14127658f, -0.10667102f, -0.20374580f, 
    0.03790426f, 0.16928400f, -0.04267112f, 0.17261878f, 0.12955180f, 0.10039753f, -0.08867132f, 0.17335066f, 
    -0.07345347f, -0.14429563f, 0.02853410f, 0.02933389f, 0.13002609f, 0.02639523f, 0.03263962f, -0.14921042f, 
    -0.01808045f, 0.00205650f, 0.10808717f, 0.32689789f, 0.20170386f, 0.04957270f, 0.14500460f, -0.08140299f, 
    0.09179085f, 0.05594964f, 0.05303559f, 0.04382959f, -0.01856560f, 0.05693211f, -0.03124794f, -0.14156778f, 
    0.03636663f, -0.17571475f, 0.06234882f, -0.13844708f, 0.05972447f, -0.02210481f, 0.03395776f, -0.05459521f, 
    -0.12884563f, -0.12695114f, 0.14594468f, 0.28398287f, 0.07050145f, 0.03831368f, 0.12248458f, 0.08404303f, 
    0.06192451f, -0.01816754f, -0.12287957f, -0.04277547f, 0.22294401f, 0.14811076f, 0.19690835f, 0.06088281f, 
    -0.13532314f, -0.02625588f, -0.06674050f, -0.00789999f, -0.01737295f, -0.12079661f, -0.05949517f, -0.09532538f, 
    0.00140987f, -0.34729984f, -0.05604973f, 0.19149709f, -0.15138097f, 0.17876045f, -0.04458589f, -0.19688277f, 
    0.01020514f, -0.02158089f, -0.05206104f, 0.02214757f, 0.47922125f, 0.09002803f, -0.04808124f, 0.13917193f, 
    -0.02688163f, -0.13124000f, -0.01871958f, -0.06366285f, -0.07519304f, -0.24544720f, 0.03207538f, -0.06540601f, 
    0.04653019f, 0.19915657f, 0.14163157f, 0.28406474f, 0.11289232f, -0.02876059f, -0.07768057f, 0.07175134f, 
    0.03965012f, -0.11787127f, 0.08940025f, -0.07361931f, 0.00803015f, 0.35322878f, 0.16097999f, 0.11603432f, 
    0.09391914f, -0.04358011f, 0.14535949f, 0.14181863f, 0.11268972f, 0.15481399f, -0.07095341f, -0.07120972f, 
    -0.09539180f, -0.12951234f, 0.04696115f, -0.18062463f, -0.02964362f, -0.02333331f, -0.15050885f, -0.03846144f, 
    0.06239131f, -0.09544161f, -0.02877345f, 0.06548584f, -0.13358271f, -0.06113019f, 0.03959872f, -0.03922229f, 
    0.00614964f, 0.01484042f, 0.00024067f, -0.08328196f, 0.07841378f, 0.07179964f, 0.17232761f, 0.00245815f, 
    -0.16491696f, 0.23868316f, 0.01393835f, 0.11215045f, 0.06520086f, 0.12416026f, -0.08657987f, 0.20792127f, 
    -0.11601038f, -0.03649826f, 0.02324396f, -0.16023853f, 0.26308939f, -0.00872604f, -0.09932782f, -0.41901067f, 
    0.08681010f, 0.07843698f, -0.15483345f, 0.04128156f, -0.06747118f, 0.11155641f, 0.08458695f, -0.10899831f, 
    0.10565094f, 0.17809853f, 0.41422671f, -0.04951563f, -0.14018673f, -0.10577521f, -0.07971466f, -0.22944394f, 
    0.04595073f, 0.06933843f, 0.01434721f, 0.15285480f, 0.05819509f, -0.06287109f, -0.00743528f, 0.07237767f, 
    -0.02087042f, 0.12189539f, -0.11397966f, 0.04248977f, 0.12906753f, 0.02239680f, 0.02980066f, 0.11119651f, 
    -0.18802750f, -0.02507798f, 0.00054716f, -0.17399655f, -0.01823669f, -0.04940311f, 0.05363913f, -0.24296169f, 
    -0.04633030f, 0.07612945f, 0.03832422f, 0.08204065f, 0.02953883f, 0.14252624f, 0.12632780f, -0.00023505f, 
    -0.07986432f, -0.16593003f, -0.00991889f, 0.10438672f, -0.04661430f, -0.21595545f, -0.24349017f, -0.23494935f, 
    0.22355273f, 0.10485689f, -0.01201212f, 0.11535452f, -0.07833210f, -0.06108836f, 0.08982975f, 0.07032187f, 
    0.17006345f, 0.10130221f, 0.03310065f, 0.05430448f, 0.08603957f, -0.12575224f, 0.04432543f, -0.09298722f, 
    -0.19782421f, -0.15476534f, -0.20336202f, -0.03941978f, -0.09507062f, -0.20193091f, -0.16100402f, -0.02480737f, 
    0.11248326f, 0.26617721f, -0.06809369f, 0.14482842f, 0.05658558f, -0.04857918f, 0.18385434f, 0.12184823f, 
    -0.01241258f, 0.07424819f, 0.00841311f, -0.00959428f, -0.01777233f, -0.08897476f, -0.03031221f, 0.28213751f, 
    -0.00135273f, 0.21385075f, -0.22689508f, -0.15012364f, -0.06336384f, -0.08707725f, -0.06994600f, -0.19406734f, 
    0.06288491f, 0.01160364f, 0.03377529f, 0.10641337f, -0.03069644f, 0.07641067f, -0.04192166f, 0.02734275f, 
    -0.03829587f, -0.07157759f, -0.10025289f, -0.00773019f, 0.08702499f, 0.11581227f, -0.10718749f, 0.16322660f, 
    0.00393483f, 0.15370552f, -0.13466431f, -0.27166885f, -0.18419458f, -0.41404340f, -0.29807326f, -0.25468317f, 
    -0.06296095f, -0.03813403f, -0.09727148f, -0.12191771f, 0.08907475f, 0.08711126f, -0.04414384f, 0.17044798f, 
    -0.03252311f, -0.03156930f, 0.06163708f, -0.12610309f, 0.18609905f, -0.09268355f, 0.03682692f, -0.03841789f, 
    0.07193206f, -0.00140463f, 0.07272424f, -0.01898425f, 0.25659326f, 0.31871465f, 0.09033200f, 0.21822518f, 
    -0.14458957f, 0.12807883f, 0.09281100f, 0.22680201f, 0.11601768f, 0.10174149f, -0.10745147f, -0.22120574f, 
    -0.00758077f, -0.18559289f, 0.04484064f, 0.10445965f, -0.03347321f, -0.19501898f, 0.12437137f, 0.13197365f, 
    -0.04102554f, -0.17860593f, -0.10567435f, -0.12932163f, 0.09299870f, 0.01516514f, 0.02290748f, 0.11825152f, 
    0.26149800f, -0.17469333f, 0.25984418f, 0.03307072f, 0.13822892f, 0.01693765f, 0.02783916f, 0.12693119f, 
    0.01774460f, -0.06032537f, -0.21928215f, 0.04519888f, 0.07115705f, 0.25056824f, 0.02517401f, 0.44044170f, 
    0.11519083f, -0.06616663f, -0.33317223f, -0.20000319f, -0.20209108f, -0.18142711f, -0.03305279f, -0.05615228f, 
    -0.09197938f, -0.41131389f, -0.25703925f, -0.14417189f, 0.04046319f, 0.07087421f, 0.12401973f, 0.02510035f, 
    0.00303162f, -0.16621710f, -0.03039807f, -0.05375238f, 0.18797240f, 0.12453584f, -0.05038409f, -0.22239527f, 
    0.00493091f, -0.06749360f, 0.11056723f, -0.02337340f, -0.02973562f, 0.01622626f, -0.01506120f, 0.08544562f, 
    -0.02397213f, -0.02778318f, -0.06013814f, 0.12440334f, -0.01309411f, -0.03142139f, -0.13803875f, 0.02908157f, 
    0.02072864f, 0.03894414f, 0.03906277f, -0.04024521f, 0.04051715f, 0.06961694f, -0.12058133f, 0.05128053f, 
    0.12173354f, 0.04152521f, -0.00418722f, -0.15451913f, 0.05777647f, -0.02691623f, -0.06249226f, -0.07945755f, 
    0.17096300f, -0.13593073f, -0.10410638f, 0.01435521f, 0.00662455f, 0.12393217f, 0.04670630f, 0.02177361f, 
    0.07496040f, -0.05974111f, 0.05319637f, -0.09770662f, -0.11764998f, 0.12661330f, -0.25160390f, -0.03445406f, 
    0.05955476f, 0.06490421f, 0.12842305f, 0.00058444f, 0.11482737f, 0.16917422f, 0.14026123f, 0.01275516f, 
    0.19385834f, 0.02102885f, 0.14944501f, 0.12367313f, 0.02913123f, 0.00077192f, 0.10458153f, 0.17490019f, 
    0.10804237f, 0.02955359f, 0.04169738f, 0.03186462f, 0.13300687f, 0.09805346f, 0.20423457f, 0.21174896f, 
    0.12466288f, -0.15272169f, -0.06743895f, 0.00037429f, -0.03378487f, 0.00678698f, 0.07510255f, 0.00555906f, 
    0.65388280f, -0.26628140f, 0.41998002f, 0.08483052f, 0.09318215f, -0.05250598f, -0.02995038f, -0.04568283f, 
    0.00521582f, 0.05449355f, 0.05689248f, -0.04611939f, 0.10222036f, 0.07650379f, -0.08373417f, -0.13162081f, 
    0.15768830f, 0.02058830f, -0.03402591f, 0.01983339f, -0.03799304f, 0.04538918f, -0.03566876f, 0.08116081f, 
    0.37179649f, 0.40991700f, 0.08635117f, 0.06669087f, 0.09043048f, 0.03911039f, 0.10685227f, -0.04839629f, 
    -0.00535791f, -0.07409537f, 0.01171762f, 0.02722065f, -0.01566184f, 0.14936528f, -0.10923767f, 0.11444967f, 
    -0.11294149f, 0.11536242f, 0.03225034f, -0.00094642f, 0.00768966f, -0.02043606f, 0.06828646f, -0.26901296f, 
    -0.12726116f, 0.09799134f, 0.24340159f, 0.10432932f, -0.03682672f, -0.01203098f, -0.06348815f, 0.01991796f, 
    -0.06819358f, 0.01184789f, 0.09996305f, -0.03849212f, -0.05976070f, -0.13782240f, -0.16762222f, 0.10618807f, 
    -0.07632574f, 0.08540373f, -0.04910911f, -0.07547873f, 0.11014056f, -0.07750624f, -0.02317538f, 0.02508152f, 
    0.21964198f, 0.24057181f, -0.04148138f, 0.07481706f, -0.14107741f, -0.08845283f, 0.11274028f, 0.09400899f, 
    -0.07249225f, -0.10625211f, -0.10524027f, -0.06160069f, 0.24664962f, -0.21662222f, -0.16895010f, -0.18056473f, 
    -0.06991136f, -0.04292987f, -0.01532846f, -0.02985430f, 0.19098374f, -0.01259516f, 0.10403536f, 0.08652342f, 
    0.06087192f, -0.12110270f, 0.02409046f, 0.13259153f, 0.08304099f, 0.11626191f, 0.05093348f, -0.01289587f, 
    0.10807709f, 0.00946829f, -0.01932307f, 0.02709510f, -0.12308679f, -0.04523688f, 0.40938780f, 0.11270473f, 
    0.06702492f, -0.00136957f, 0.26333439f, -0.08414256f, 0.03892181f, -0.00719583f, -0.00622424f, -0.14667580f, 
    0.31224790f, -0.10733189f, 0.00868621f, 0.25109407f, 0.00391021f, 0.09142686f, -0.23399559f, 0.09942657f, 
    0.05792670f, 0.07666277f, -0.11664362f, 0.08244871f, -0.02655458f, -0.04575103f, -0.03385229f, 0.13923597f, 
    0.14943163f, 0.27541342f, 0.05378146f, -0.02021305f, -0.10570415f, 0.09896859f, 0.06586666f, 0.00334234f, 
    -0.05620902f, -0.12152826f, -0.01314390f, -0.13507158f, 0.03718852f, 0.09789423f, 0.13344890f, 0.11771726f, 
    0.04858527f, -0.12532079f, 0.05403677f, 0.03957774f, 0.00289216f, -0.06466426f, -0.12007213f, -0.00664951f, 
    -0.02753955f, -0.14685209f, -0.04709667f, 0.07727489f, 0.12907918f, -0.00942728f, -0.01695895f, -0.01603827f, 
    -0.27323639f, -0.22335561f, 0.04529568f, -0.21909174f, -0.00435260f, 0.05052168f, -0.09627225f, -0.00090865f, 
    -0.02195363f, 0.04726697f, 0.02587447f, 0.16705021f, -0.05216853f, 0.26861566f, 0.13505609f, -0.23383458f, 
    0.19222018f, -0.18706733f, -0.03294438f, 0.09340356f, 0.01068353f, -0.02361288f, -0.01605660f, 0.08153807f, 
    0.04812721f, 0.30198228f, -0.21565685f, 0.13008460f, -0.00733634f, -0.28330564f, 0.05137521f, 0.03190717f, 
    -0.02075798f, 0.01460697f, 0.00511713f, 0.04488923f, -0.09339114f, -0.23444691f, -0.03788909f, -0.18306658f, 
    -0.05520253f, -0.12665145f, 0.17992873f, 0.06064910f, 0.02165264f, 0.09004435f, 0.03320325f, 0.06760382f, 
    0.04709619f, -0.03072011f, -0.03115332f, 0.06834152f, -0.05920893f, 0.00455661f, 0.04742611f, -0.01537870f, 
    -0.05359283f, 0.00274616f, -0.08083230f, 0.00335428f, 0.09672546f, -0.08022995f, -0.00706420f, -0.10102392f, 
    0.02535250f, -0.07122608f, -0.03162717f, -0.12609036f, 0.01540125f, -0.07147870f, 0.21032178f, 0.00375318f, 
    -0.10059881f, 0.05662198f, 0.01869071f, -0.08997131f, -0.09444355f, -0.09885057f, -0.21853749f, -0.06676952f, 
    -0.09226258f, -0.08944792f, -0.00828479f, -0.02491289f, 0.02022799f, 0.24883491f, 0.08310483f, -0.01547941f, 
    -0.08449589f, -0.07797173f, -0.08212136f, -0.05386932f, 0.05982006f, 0.05728361f, 0.04463731f, 0.03146369f, 
    0.10361733f, 0.42303529f, -0.12410092f, 0.06801260f, -0.02727455f, -0.17188515f, 0.11685420f, 0.06930377f, 
    -0.00428407f, -0.04614987f, -0.00485563f, 0.05605038f, -0.09604922f, -0.25008357f, -0.18950132f, -0.01799153f, 
    -0.05807496f, -0.08924045f, -0.01435314f, 0.08178274f, 0.08953346f, 0.04754105f, 0.05103809f, 0.11415441f, 
    -0.40537986f, 0.16478854f, 0.25676602f, 0.04056712f, -0.12039599f, -0.10144895f, 0.02259428f, 0.18652244f, 
    0.14154315f, 0.24588728f, 0.00421636f, 0.15805104f, -0.26201391f, -0.19995460f, -0.18011059f, -0.06611160f, 
    -0.10086770f, -0.06672589f, -0.05706111f, 0.06092067f, -0.03012330f, -0.02066171f, -0.07434966f, 0.11472070f, 
    0.37543237f, -0.10864753f, 0.04209906f, -0.07513904f, 0.07290383f, -0.01566393f, 0.16531020f, 0.01427206f, 
    -0.00971844f, 0.05169547f, 0.09199622f, 0.02854476f, -0.20302677f, -0.09780260f, -0.01245859f, -0.15611666f, 
    -0.03655973f, -0.08045144f, -0.14252241f, -0.02940113f, 0.13486509f, 0.04387718f, -0.06170907f, -0.06323605f, 
    -0.07061812f, -0.05620645f, 0.27255338f, -0.03698792f, 0.03236225f, 0.05527823f, 0.08458165f, -0.16164033f, 
    -0.03837544f, 0.10961442f, 0.16433764f, -0.01638331f, -0.02483799f, 0.01793584f, 0.06648224f, 0.02668059f, 
    0.24069987f, 0.11179953f, 0.14975163f, 0.14484043f, 0.10488115f, 0.12938106f, 0.08794009f, 0.02029082f, 
    -0.15106684f, -0.00194775f, 0.02296990f, 0.13155468f, -0.04142712f, 0.02907165f, 0.17505534f, -0.08193985f, 
    0.08428583f, -0.12182043f, 0.05174735f, 0.00231263f, 0.15258814f, 0.02917173f, -0.19722798f, 0.04079706f, 
    0.06519809f, 0.03739856f, -0.01522001f, 0.02747599f, -0.00858638f, -0.12602036f, 0.03313524f, -0.02364656f, 
    0.39046085f, -0.32061616f, -0.24959250f, 0.45554090f, 0.00760735f, -0.02885185f, 0.00576331f, 0.18099461f, 
    -0.02032300f, -0.05385870f, 0.07436444f, -0.03878605f, 0.10515366f, -0.04400455f, -0.17232774f, 0.02386327f, 
    0.05682455f, -0.11366259f, -0.03456952f, -0.02000848f, 0.05418660f, -0.03142476f, 0.02082881f, -0.00217805f, 
    -0.28983268f, 0.04207564f, 0.21297662f, 0.12111753f, 0.11349822f, 0.04496847f, 0.02260018f, 0.14763092f, 
    0.01378352f, -0.01383943f, -0.03522038f, -0.02244142f, -0.05315471f, 0.13152747f, 0.08931533f, 0.02667352f, 
    0.07087713f, 0.02004363f, 0.06250849f, -0.05007460f, 0.01434482f, 0.21100517f, 0.17925687f, -0.13965878f, 
    0.10490379f, -0.04868331f, 0.05595705f, 0.00205190f, 0.04145941f, -0.01494557f, 0.06009000f, -0.02408609f, 
    0.03911474f, -0.03427583f, -0.10606198f, 0.04404990f, -0.12089930f, 0.07836929f, 0.08987133f, -0.12602770f, 
    0.01799466f, 0.02797543f, -0.04726997f, -0.06846205f, 0.01417891f, 0.01520149f, 0.23430642f, 0.08417414f, 
    -0.26388061f, 0.00507745f, -0.04411740f, 0.32427412f, 0.18341702f, 0.26217932f, 0.12102176f, 0.03667141f, 
    0.01771132f, 0.02618474f, -0.09516238f, 0.03321643f, 0.10309337f, -0.19136742f, 0.04315471f, 0.18322244f, 
    0.04409198f, -0.01585494f, 0.00228062f, 0.07211252f, 0.21913657f, 0.15850739f, 0.14812143f, 0.17922051f, 
    0.02408288f, 0.27860063f, -0.24443778f, 0.05139385f, 0.11393847f, 0.00226493f, -0.00645940f, 0.08895355f, 
    -0.18061070f, -0.10238851f, 0.06468747f, -0.07452479f, 0.11949137f, 0.12853345f, 0.03572830f, -0.02046108f, 
    -0.07552283f, 0.02255943f, -0.04470715f, 0.03378367f, -0.01743794f, 0.00709221f, -0.04492230f, -0.04571122f, 
    -0.22419474f, 0.33662537f, -0.19902390f, 0.34016770f, -0.04724126f, 0.21791138f, -0.03711541f, -0.01942862f, 
    -0.14393319f, 0.09860342f, 0.15622441f, 0.13124216f, 0.29597649f, 0.22326924f, 0.38336799f, 0.12592801f, 
    -0.11372988f, 0.10487482f, -0.07577927f, -0.26859015f, 0.00804900f, 0.03239057f, 0.05318168f, -0.00462489f, 
    0.12796040f, 0.00096200f, -0.06675536f, 0.24531078f, -0.01985407f, 0.01171616f, -0.08989116f, 0.11708262f, 
    0.17304139f, 0.14256199f, 0.01422519f, 0.02732402f, -0.07509857f, 0.02849379f, -0.09207097f, 0.14324549f, 
    -0.12652345f, 0.24667703f, 0.04348285f, 0.03720036f, -0.09554718f, 0.05418137f, 0.06157980f, -0.05772870f, 
    0.12848933f, 0.17330231f, 0.15777592f, 0.03548312f, -0.08006527f, 0.00953996f, -0.05129752f, 0.09545475f, 
    -0.04689563f, 0.02809682f, 0.04631079f, 0.09467629f, 0.24489363f, -0.09477543f, 0.25434589f, 0.00341019f, 
    -0.06793732f, -0.11935152f, 0.05187171f, 0.00453503f, -0.07211950f, 0.01855599f, -0.11537368f, 0.00433877f, 
    -0.19604516f, 0.40239105f, 0.10959236f, -0.14878379f, -0.21678095f, 0.10241643f, -0.14871432f, -0.06920329f, 
    -0.00026021f, -0.08488323f, -0.00261037f, 0.08613500f, 0.04756648f, 0.32897928f, -0.04517129f, -0.10376050f, 
    0.01876575f, 0.17321296f, 0.10047384f, -0.07478350f, 0.00424057f, -0.13949475f, -0.04397029f, -0.06666004f, 
    0.15397027f, 0.01590056f, 0.27625719f, 0.37312409f, -0.07233361f, 0.13692309f, -0.16552892f, -0.10868467f, 
    -0.08717840f, 0.04044005f, -0.03835442f, -0.03083558f, -0.12152189f, -0.05631353f, -0.30157992f, 0.00193732f, 
    0.00045374f, 0.06007573f, 0.11006895f, 0.13823882f, 0.08295628f, 0.05594639f, -0.00166845f, 0.10428544f, 
    -0.05142754f, 0.01463974f, -0.04569303f, 0.08104554f, 0.02411324f, -0.00519733f, 0.08439846f, -0.12082520f, 
    0.01636343f, -0.01839039f, 0.08790981f, 0.09397300f, -0.32442972f, -0.20641524f, -0.44253826f, 0.04559098f, 
    0.04292237f, 0.05243522f, 0.02848157f, 0.11324371f, -0.06250541f, 0.00358579f, -0.07093124f, 0.01978255f, 
    -0.15075320f, 0.32698956f, -0.19169095f, 0.03092842f, -0.24761628f, -0.01687367f, -0.06077063f, -0.11195972f, 
    0.05217643f, 0.05707731f, 0.01455366f, 0.07754698f, -0.23040511f, 0.14474618f, -0.56456006f, -0.06026079f, 
    0.03326140f, 0.08546231f, 0.09903519f, 0.03107977f, 0.07722894f, -0.00247641f, 0.07321196f, -0.07142718f, 
    -0.00075694f, 0.01485197f, -0.05468186f, -0.02416059f, -0.03521293f, -0.00908014f, -0.02422293f, -0.04802665f, 
    -0.03645152f, -0.07830770f, -0.06254812f, 0.04379519f, 0.05267871f, 0.01735792f, -0.07395422f, 0.04498025f, 
    -0.01717835f, 0.01165019f, -0.07679465f, 0.05832506f, -0.01172606f, 0.03280063f, -0.08166875f, -0.00316426f, 
    -0.06727533f, -0.00695915f, 0.04152684f, -0.07195772f, -0.06046649f, 0.01966168f, -0.02773705f, 0.04987319f, 
    0.00135737f, -0.04383588f, 0.00164451f, -0.05337509f, -0.03079565f, -0.01021031f, 0.02498639f, 0.00576253f, 
    -0.04995038f, -0.05181701f, 0.04084197f, -0.04423255f, -0.05116696f, -0.06007015f, 0.05268735f, -0.07084689f, 
    -0.04492259f, 0.03172042f, -0.06670740f, 0.00012160f, -0.03720683f, -0.00249226f, 0.06091370f, -0.06806707f, 
    0.01110708f, 0.05182723f, -0.02117226f, 0.01689391f, -0.07058756f, -0.02389430f, -0.00688819f, 0.03739342f, 
    0.05704087f, 0.00812749f, -0.03647972f, -0.07375394f, -0.02221322f, 0.06218587f, 0.03225552f, 0.01450314f, 
    -0.03772987f, -0.03404824f, -0.01183499f, 0.04296727f, 0.01436404f, -0.03610579f, -0.02390633f, -0.03349034f, 
    0.03975897f, -0.04630545f, -0.03595165f, -0.03946371f, 0.01893695f, -0.04927418f, -0.07387245f, -0.05270749f, 
    -0.07801839f, 0.05069995f, 0.00159422f, -0.06500298f, 0.00846331f, -0.03960626f, -0.01159874f, 0.03101943f, 
    -0.02987356f, -0.05918701f, -0.05808513f, 0.05498431f, -0.06222788f, -0.03571124f, 0.00811962f, -0.02167217f, 
    0.05131042f, -0.04530610f, -0.04227088f, -0.07843336f, 0.02536546f, 0.02394914f, 0.02853072f, -0.01838385f, 
    0.02586714f, -0.06925923f, 0.02516411f, 0.04767220f, -0.07006865f, -0.01619795f, 0.04391367f, 0.05830211f, 
    -0.07448959f, -0.04024824f, -0.03507565f, -0.04423635f, -0.04212265f, 0.01877258f, -0.07128727f, -0.02913146f, 
    0.00146097f, -0.06700241f, 0.00536836f, 0.01110823f, 0.06949669f, -0.01175159f, 0.01108116f, -0.05301924f, 
    0.05701974f, -0.03424324f, -0.05000454f, 0.01145922f, -0.02650189f, 0.02353127f, 0.04528679f, -0.05433815f, 
    0.05397536f, -0.03973182f, -0.02282883f, 0.05036487f, -0.06156791f, -0.06140808f, 0.00127637f, -0.00825077f, 
    0.03250435f, -0.04303798f, 0.05640868f, -0.06562218f, 0.00201202f, 0.06460319f, 0.02720536f, -0.02612528f, 
    -0.03614312f, 0.04567135f, 0.06761384f, -0.00518770f, -0.06643027f, 0.04896535f, -0.06488787f, -0.02486194f, 
    0.05062154f, -0.02589003f, 0.00951358f, -0.02913969f, 0.02706242f, 0.04703417f, -0.07608355f, -0.00706197f, 
    0.02965658f, -0.03015651f, 0.00045404f, -0.04755019f, -0.04347733f, -0.08668926f, -0.01934859f, -0.03723451f, 
    0.06062511f, 0.00593997f, -0.04321553f, -0.07770510f, 0.01125607f, -0.01562054f, -0.07660320f, -0.01490816f, 
    -0.41956031f, 0.11202028f, -0.22083202f, -0.04487681f, 0.01058341f, -0.08814179f, -0.01327059f, 0.30458030f, 
    0.14344844f, 0.11009480f, 0.02620286f, -0.13577567f, -0.22129777f, 0.07386322f, 0.02945436f, -0.08035230f, 
    -0.05196930f, -0.01988501f, -0.13434087f, 0.08989806f, -0.02045737f, 0.09623075f, -0.00693463f, 0.18104205f, 
    0.42439550f, 0.22173393f, 0.07225768f, 0.37575558f, 0.11094594f, 0.10506182f, 0.20845327f, 0.21900599f, 
    -0.06782044f, 0.14209197f, 0.21106161f, 0.09685776f, -0.05682136f, -0.08027374f, 0.12256051f, 0.00832309f, 
    -0.06012790f, 0.14146803f, -0.15683243f, 0.04298174f, 0.16784373f, 0.09353685f, -0.06884044f, -0.13098678f, 
    -0.08234277f, -0.15875615f, 0.18376188f, -0.03372724f, 0.06570151f, 0.08389201f, 0.04032209f, -0.06144491f, 
    0.02609821f, -0.02343806f, 0.04073110f, 0.07993206f, -0.14298381f, 0.10873086f, -0.17054009f, 0.08258497f, 
    0.16099691f, 0.12908863f, 0.11679609f, 0.01185101f, 0.00160903f, -0.00620600f, 0.11266001f, 0.02080437f, 
    -0.17912710f, 0.12193869f, 0.03733772f, 0.18529028f, 0.01025833f, -0.05971447f, -0.00975985f, -0.12312338f, 
    0.20183198f, -0.04714661f, 0.16602901f, 0.02350836f, 0.30386704f, -0.00949363f, 0.01795623f, 0.14228687f, 
    0.13255809f, -0.13100833f, -0.01741063f, -0.00978767f, 0.03746211f, -0.00000908f, -0.05782891f, 0.07414371f, 
    0.27947727f, -0.09733135f, 0.05550337f, 0.29136568f, 0.03011305f, -0.03204117f, -0.03024972f, 0.13751425f, 
    -0.01784398f, 0.16155070f, 0.01339802f, 0.05142144f, 0.02651224f, 0.19807166f, 0.04600246f, -0.16176182f, 
    -0.24696514f, -0.01054975f, -0.10094643f, 0.02168080f, -0.04393962f, -0.01711275f, 0.08249155f, -0.04788418f, 
    -0.22401601f, 0.08380162f, 0.17072816f, -0.19096743f, -0.07735341f, 0.32875732f, -0.06172837f, -0.08882468f, 
    -0.05341179f, -0.03360367f, -0.04721502f, 0.04610753f, -0.03620043f, 0.28222951f, -0.02589740f, 0.13927948f, 
    -0.01180441f, 0.01287782f, 0.02316524f, 0.08684907f, -0.00503694f, -0.14333707f, 0.08558847f, -0.18954547f, 
    0.09992467f, -0.10137803f, 0.07870563f, -0.03467719f, -0.13313048f, -0.16345955f, -0.09076892f, -0.01508316f, 
    -0.09126098f, -0.05703796f, -0.06908362f, -0.04722138f, -0.19237322f, 0.14853282f, -0.09035607f, 0.15253773f, 
    -0.03023984f, 0.11378025f, -0.03848788f, 0.06940250f, 0.05132906f, -0.02707512f, -0.03240582f, 0.04666328f, 
    -0.25231615f, 0.20037107f, -0.11277103f, 0.19587994f, 0.02572337f, 0.02492326f, 0.08110361f, 0.03750588f, 
    0.06833026f, -0.06796806f, -0.15040399f, 0.02589814f, -0.33374554f, -0.10196985f, -0.20919870f, -0.13652965f, 
    -0.05326898f, -0.11171202f, 0.07665105f, -0.03716123f, 0.15614334f, -0.01275930f, 0.30168167f, -0.06145853f, 
    -0.40577337f, -0.06081516f, -0.30628905f, -0.09138191f, -0.06729984f, -0.04227985f, 0.12362983f, -0.01022945f, 
    -0.01098100f, 0.14804699f, 0.12429069f, -0.00900674f, -0.09480106f, -0.53598082f, -0.15142252f, -0.44659880f, 
    0.25391939f, -0.06276520f, 0.00372996f, -0.03704635f, -0.11734231f, 0.04147392f, -0.07503801f, 0.09148671f, 
    0.42945266f, 0.05958672f, -0.04314867f, 0.21433260f, 0.04292843f, 0.11499668f, 0.06451628f, 0.07353764f, 
    -0.02646367f, 0.14292769f, 0.18891312f, 0.19180991f, -0.32028821f, -0.05811431f, -0.18119855f, -0.11237534f, 
    -0.04006188f, -0.09986050f, -0.07045426f, -0.14213188f, -0.05454815f, 0.02838049f, -0.03517081f, -0.07075611f, 
    -0.12123804f, -0.20242108f, 0.05095648f, -0.13097751f, 0.11672161f, 0.09845917f, -0.09812534f, 0.04350075f, 
    0.01211387f, 0.15824145f, 0.01767086f, 0.07031728f, -0.03632478f, 0.11435292f, -0.05833680f, 0.06583610f, 
    0.09078731f, 0.00190076f, -0.00700578f, -0.07032165f, 0.03281262f, -0.06184797f, -0.02699706f, -0.16278195f, 
    -0.32184365f, -0.40821975f, -0.12314925f, -0.10096505f, 0.15949398f, 0.10718843f, -0.08976229f, -0.08896045f, 
    -0.05741069f, -0.08372506f, 0.15782158f, -0.10038558f, 0.08693799f, 0.18642524f, 0.07512923f, 0.04247390f, 
    0.12915239f, 0.03127827f, -0.04042115f, 0.01150000f, -0.03616909f, -0.05240196f, -0.02507959f, -0.06592045f, 
    0.02507896f, 0.26481214f, 0.08466761f, 0.04514596f, 0.18347804f, 0.03227188f, 0.05700187f, 0.12497775f, 
    -0.03030994f, -0.00099392f, 0.08891982f, 0.03225043f, 0.01914821f, -0.08629985f, 0.10620492f, 0.03915633f, 
    -0.08476056f, -0.09663211f, -0.01482161f, 0.04506680f, -0.07428943f, 0.10122375f, -0.03425162f, -0.00384298f, 
    -0.08500557f, 0.13744706f, -0.04524617f, -0.00090664f, -0.01844550f, -0.00704501f, 0.20796572f, -0.04688569f, 
    -0.01933760f, -0.10260183f, -0.03992673f, -0.04210812f, -0.07252037f, -0.00526000f, 0.05064799f, 0.18450214f, 
    -0.07608904f, 0.01088923f, -0.00732635f, -0.02147393f, 0.19531462f, 0.14277737f, 0.14945279f, 0.21664302f, 
    0.21748935f, 0.11740427f, 0.12949371f, 0.01144300f, -0.09345791f, -0.03378509f, 0.00566469f, 0.02489284f, 
    -0.17072943f, -0.07770181f, 0.00804046f, 0.05405362f, 0.05537711f, 0.16362824f, 0.05424643f, 0.08485284f, 
    -0.05062316f, 0.05081068f, 0.06032334f, -0.05319452f, -0.01786629f, 0.06465644f, -0.00172470f, 0.08718970f, 
    -0.07110185f, 0.11339870f, -0.00695998f, 0.07977197f, 0.11409677f, 0.04286980f, 0.11071786f, -0.05612719f, 
    0.01687365f, -0.02972264f, -0.00806429f, 0.04391995f, 0.07788798f, -0.04288672f, 0.02987956f, -0.14939749f, 
    -0.17750032f, 0.04127612f, -0.01328249f, 0.08118372f, 0.07164356f, 0.14323294f, 0.13803057f, -0.03261823f, 
    -0.02085024f, 0.02404653f, 0.05169981f, -0.07064137f, -0.01467100f, 0.04504453f, -0.04218879f, 0.05631621f, 
    -0.00270258f, -0.06709861f, -0.07031471f, -0.00698676f, -0.03079106f, 0.00286455f, -0.05812174f, 0.04972383f, 
    0.05825533f, -0.00494575f, -0.04691795f, -0.06122784f, 0.04451527f, 0.05270613f, -0.05902036f, -0.03132915f, 
    -0.02166983f, -0.06134822f, -0.03844452f, -0.03504192f, -0.03541593f, 0.00335000f, -0.04499104f, -0.01749376f, 
    0.05524315f, 0.00620861f, -0.06367649f, -0.02880186f, -0.03805485f, -0.04873206f, 0.03408014f, -0.06521521f, 
    -0.00272522f, -0.02316358f, -0.06417519f, 0.06438831f, 0.00131484f, 0.02342489f, -0.00428248f, -0.07154532f, 
    -0.06473760f, 0.02772968f, -0.03429681f, -0.07188404f, -0.02224377f, 0.00734565f, -0.02347071f, -0.03308254f, 
    -0.05165830f, -0.04071364f, -0.03536027f, -0.06365918f, 0.02396081f, -0.05912990f, 0.03242825f, -0.04773771f, 
    -0.07407498f, -0.05583560f, 0.03972390f, -0.04107316f, -0.07399138f, 0.03274422f, -0.06214378f, -0.06536296f, 
    0.00674891f, -0.02305065f, 0.04729638f, -0.01578478f, -0.00437454f, -0.03923304f, 0.05715003f, 0.03564979f, 
    -0.01689646f, 0.01985900f, -0.04175789f, 0.05427586f, -0.06615902f, 0.01783909f, -0.00639138f, -0.04525768f, 
    -0.00773818f, 0.05637769f, -0.00665161f, 0.01983246f, -0.04107840f, -0.00676730f, 0.02991480f, 0.05211670f, 
    -0.00314056f, 0.00302517f, -0.00815809f, 0.05553316f, 0.00097826f, 0.03224429f, 0.02516304f, -0.01135060f, 
    -0.00833199f, -0.05038431f, -0.00531428f, 0.03962670f, 0.01855976f, 0.06512658f, -0.02286429f, -0.07443935f, 
    0.05820424f, 0.00095689f, -0.06133338f, -0.01712554f, 0.04664498f, -0.06248305f, -0.07432398f, -0.04835109f, 
    0.06173546f, 0.02332615f, -0.01061656f, -0.06847300f, 0.05064039f, 0.00216274f, -0.02283560f, -0.00068524f, 
    -0.04075295f, -0.01478862f, 0.02277806f, -0.05279309f, -0.02707300f, -0.05662998f, -0.00760656f, -0.01888543f, 
    -0.01290457f, -0.00845062f, -0.00262691f, -0.03321584f, -0.01954771f, -0.01741740f, -0.00481848f, 0.05476236f, 
    0.05839803f, -0.00328684f, -0.06086630f, -0.06090848f, 0.01715355f, 0.01380851f, -0.06849613f, -0.02283539f, 
    0.00503487f, 0.05663900f, -0.00885958f, 0.04817668f, 0.00028579f, 0.00687893f, -0.05077578f, 0.01714683f, 
    -0.06125426f, 0.04620283f, 0.01466334f, 0.03915497f, -0.05648157f, -0.00005834f, -0.06789489f, -0.01727066f, 
    0.02279187f, 0.01572577f, 0.01574368f, -0.02760796f, -0.01507862f, -0.06671816f, -0.07551004f, 0.02435362f, 
    0.00100786f, 0.06372166f, 0.02147272f, 0.00297867f, 0.03491482f, -0.02204619f, -0.01959947f, 0.02975608f, 
    -0.03046946f, 0.01207049f, -0.05799833f, 0.01822897f, -0.05277133f, 0.03096679f, -0.06895518f, -0.06938957f, 
    -0.29359680f, 0.01314071f, -0.09537212f, 0.24403501f, 0.04875351f, -0.00416126f, 0.22791809f, 0.02861721f, 
    -0.00156840f, 0.09396540f, -0.09086440f, 0.05093136f, 0.03852477f, 0.04830252f, -0.31662917f, -0.23338561f, 
    0.00101067f, 0.01898373f, 0.11018342f, -0.05405694f, -0.04562891f, -0.02590196f, -0.03554572f, 0.10516028f, 
    0.05597337f, 0.17660135f, 0.14278814f, 0.22812773f, -0.02783185f, 0.10789865f, 0.03062530f, 0.01085248f, 
    -0.04534804f, 0.14562726f, -0.06571451f, 0.17130502f, -0.06159917f, -0.10882834f, -0.06138157f, 0.04873226f, 
    0.14443542f, -0.00108614f, -0.03220401f, 0.02815712f, -0.06645616f, 0.04966014f, 0.04488331f, -0.13753594f, 
    -0.08891876f, -0.27568048f, -0.19330548f, -0.02223102f, 0.07335243f, 0.07975177f, 0.01304424f, 0.02602584f, 
    -0.03711154f, 0.07190577f, 0.07115750f, -0.08171135f, -0.24975221f, 0.00774743f, -0.14827856f, -0.03056548f, 
    -0.11744564f, -0.01721047f, 0.00649029f, 0.01602193f, -0.08171248f, -0.00841627f, 0.04989564f, -0.03797921f, 
    -0.26942462f, -0.27961978f, 0.00291623f, -0.09372026f, 0.00115912f, 0.06800159f, 0.00570661f, -0.02478025f, 
    0.08688945f, -0.09088913f, -0.04846106f, 0.04879590f, 0.23067671f, 0.34499475f, 0.16827224f, 0.01682033f, 
    0.18767165f, -0.14278714f, 0.03967524f, -0.02375374f, -0.14816180f, -0.07126479f, 0.04449350f, 0.10862484f, 
    0.61559027f, 0.08349068f, 0.05856719f, -0.11696780f, 0.13535419f, -0.02089363f, 0.12337720f, -0.09270433f, 
    0.10099144f, -0.02062874f, 0.03417358f, 0.03014721f, 0.09220709f, -0.05063088f, -0.07509660f, -0.19805437f, 
    -0.05061387f, -0.04066421f, 0.06886322f, 0.10736523f, -0.04077985f, 0.08477814f, -0.03370134f, 0.06305902f, 
    0.18498123f, 0.04084040f, 0.10905062f, 0.12761761f, 0.08178289f, 0.09904249f, 0.01340571f, -0.05359320f, 
    0.11413042f, -0.10886223f, 0.01208424f, -0.03226949f, -0.25387704f, 0.19333121f, 0.05179441f, 0.26991868f, 
    -0.02114146f, -0.01336913f, 0.10604621f, 0.00020945f, -0.05035919f, 0.25894484f, 0.03527413f, 0.01162092f, 
    -0.22274527f, -0.03726406f, 0.07188606f, -0.27534747f, 0.00543180f, -0.15289350f, -0.20944943f, -0.11106633f, 
    -0.08607947f, -0.05018452f, 0.04917948f, -0.03819861f, -0.23009217f, 0.06370472f, -0.02674019f, 0.05459757f, 
    0.00097994f, 0.02261263f, -0.04974707f, -0.12264413f, 0.11778323f, 0.11481674f, 0.16236205f, 0.10079189f, 
    -0.11626861f, 0.46707705f, -0.21286809f, 0.26950094f, 0.03371768f, 0.10491546f, 0.11749799f, -0.08549177f, 
    -0.09402980f, -0.03488204f, 0.12347297f, 0.07315828f, 0.18042089f, -0.01686338f, -0.09442775f, -0.25740162f, 
    -0.08285738f, 0.01906188f, 0.02823730f, 0.01838716f, 0.10858068f, 0.02185437f, 0.22905271f, 0.03140600f, 
    0.01027116f, 0.09788470f, -0.05535349f, 0.10356305f, 0.12430354f, 0.15199144f, -0.00161715f, 0.06244094f, 
    0.00154059f, 0.06476770f, -0.05262321f, 0.05386386f, 0.03757266f, 0.25303686f, -0.23782147f, -0.05359579f, 
    -0.00894077f, 0.07460806f, 0.11038364f, 0.01404237f, 0.04946971f, -0.05244955f, -0.12124599f, 0.14425819f, 
    0.03496276f, 0.08827198f, 0.01150640f, 0.07629150f, 0.04039660f, 0.02814236f, 0.06314284f, -0.01357358f, 
    -0.03181760f, -0.12430937f, 0.18010378f, 0.05006282f, -0.09557512f, -0.22466864f, -0.16433460f, -0.18545373f, 
    0.05936594f, 0.13054894f, -0.02204404f, 0.03310582f, 0.04239223f, 0.03040446f, -0.03876344f, 0.02105505f, 
    0.08782159f, -0.00258726f, -0.28550589f, -0.38383263f, -0.06439864f, 0.04164948f, -0.01273891f, -0.02970722f, 
    -0.18778075f, -0.00787457f, -0.04189966f, -0.13922691f, -0.09298138f, -0.13820429f, -0.11027764f, -0.14735770f, 
    -0.05887555f, 0.02737297f, -0.13777183f, -0.14624095f, 0.02786721f, 0.00236433f, 0.02885105f, -0.04829557f, 
    0.02202823f, -0.06311290f, -0.09823597f, -0.31374720f, -0.02430353f, 0.13016956f, -0.02502078f, -0.07697438f, 
    0.12296642f, 0.01953997f, 0.13082065f, 0.13154685f, 0.00901972f, -0.03025122f, -0.00777382f, -0.01568634f, 
    0.05423684f, -0.06317186f, 0.02467214f, -0.03206805f, 0.00160225f, -0.02711484f, 0.06921940f, 0.18668905f, 
    0.04512477f, 0.18337867f, 0.12636395f, 0.08224228f, -0.01539660f, -0.04925833f, 0.14012995f, 0.21303512f, 
    -0.07497469f, 0.02573322f, -0.03813604f, -0.07666669f, -0.12957968f, -0.05431301f, -0.04536301f, -0.01179786f, 
    0.17484097f, -0.04238813f, -0.19773698f, -0.09782934f, -0.02866521f, 0.13052000f, 0.13763094f, -0.06778222f, 
    0.04343177f, -0.27340016f, -0.17101765f, -0.05986117f, -0.09736664f, 0.05680446f, 0.02567277f, -0.16392779f, 
    0.05400913f, 0.03446476f, 0.01217930f, 0.03962480f, -0.11202811f, -0.16364142f, -0.03074790f, 0.08029271f, 
    0.10101592f, 0.04312649f, 0.01088050f, -0.04824791f, 0.08195166f, 0.13880396f, -0.05029808f, -0.16278026f, 
    -0.07686150f, -0.15586627f, -0.04413651f, 0.11404240f, 0.07295562f, -0.00084192f, -0.05533836f, -0.14234731f, 
    -0.05310179f, -0.02689164f, -0.04319286f, -0.07485120f, 0.05423825f, 0.12738346f, 0.02561383f, 0.07677517f, 
    -0.03007091f, -0.01325316f, 0.01213692f, -0.01063126f, 0.05148649f, 0.04947253f, -0.00568560f, -0.09207626f, 
    0.18547198f, 0.19505590f, -0.02927919f, 0.29286662f, 0.01604024f, -0.04895941f, 0.12113577f, -0.07596307f, 
    -0.04073988f, -0.05899015f, 0.02315397f, 0.14798547f, -0.32634208f, 0.05854247f, 0.33301020f, 0.26686224f, 
    -0.04652110f, -0.10738666f, 0.05657267f, 0.01866555f, 0.08517433f, -0.00519922f, 0.13220938f, 0.14308731f, 
    0.01859843f, -0.00823476f, 0.02323455f, 0.06035552f, -0.03367838f, -0.03085455f, 0.02296212f, -0.00786627f, 
    0.01627390f, 0.05933131f, 0.02165160f, -0.06560913f, 0.04990080f, 0.04833319f, -0.01601831f, -0.00436177f, 
    -0.07485823f, 0.03205997f, -0.04757953f, -0.07955511f, 0.05541534f, -0.02351522f, -0.05730905f, -0.06344538f, 
    -0.06551004f, -0.07258437f, -0.00019347f, -0.05372102f, -0.07606716f, 0.03795040f, -0.03393967f, -0.01903041f, 
    -0.06533129f, 0.04314226f, -0.02778493f, -0.07554520f, -0.05700025f, -0.07872593f, 0.05814536f, -0.00629543f, 
    -0.03900634f, -0.07293189f, -0.04921160f, -0.08278539f, -0.02289405f, -0.07810118f, 0.04294854f, -0.04079404f, 
    0.03726297f, -0.06653685f, 0.00890626f, 0.03209308f, -0.01108166f, 0.02026912f, 0.02700284f, -0.03947129f, 
    -0.01769938f, -0.07219094f, -0.01912267f, -0.05045448f, 0.04211615f, -0.01860853f, 0.02063430f, -0.04589717f, 
    -0.05280804f, 0.06264666f, 0.02328259f, -0.04338460f, 0.04064749f, -0.03261881f, 0.06463970f, 0.00388503f, 
    -0.05891933f, 0.04609060f, -0.07036465f, 0.03069515f, -0.03934539f, -0.05488002f, 0.03212149f, 0.00936522f, 
    0.05613902f, 0.04248618f, 0.01159174f, -0.04267437f, -0.00418099f, -0.07214214f, -0.05334650f, -0.03473404f, 
    0.00243073f, 0.02357870f, 0.02099657f, 0.04652921f, 0.03765106f, -0.04629462f, 0.04746017f, -0.01227281f, 
    0.02927118f, -0.05084879f, -0.02781357f, 0.03565077f, -0.03301011f, 0.02001880f, -0.07193526f, 0.05988702f, 
    0.02837127f, 0.01937890f, 0.00232574f, -0.06134223f, 0.02696189f, 0.02489060f, -0.01922821f, -0.06430278f, 
    -0.01306337f, 0.02978867f, -0.02769065f, -0.05540212f, -0.05861272f, -0.00779932f, -0.00845206f, -0.00844799f, 
    -0.04698753f, -0.01260438f, -0.03939988f, -0.03439114f, 0.01320061f, -0.05479819f, -0.01583344f, -0.02697593f, 
    -0.03646421f, 0.02430759f, -0.01570728f, 0.00283245f, 0.01105081f, 0.05534657f, 0.02757927f, 0.05928294f, 
    -0.01640106f, -0.02146428f, -0.06456549f, -0.03383606f, 0.03168165f, -0.02785243f, 0.05846897f, 0.04388145f, 
    -0.03765237f, 0.02131554f, -0.01783885f, -0.06574714f, -0.02606193f, -0.06366119f, -0.05785020f, -0.07457413f, 
    0.00891311f, -0.02540619f, -0.00455172f, -0.05645667f, 0.05749719f, -0.04723831f, -0.02528330f, 0.01564708f, 
    -0.03885485f, 0.00041130f, 0.03972903f, -0.00798015f, 0.03505892f, 0.02992818f, 0.02616482f, 0.01531394f, 
    0.03035633f, -0.00184418f, -0.01611314f, 0.04186605f, -0.06089309f, -0.01660429f, -0.00598400f, 0.05297844f, 
    -0.07083905f, -0.00611314f, 0.00228405f, 0.04930355f, 0.00557207f, 0.01350493f, 0.02879074f, -0.05521408f, 
    -0.05760009f, -0.06546383f, 0.02023371f, -0.07324778f, -0.01151175f, -0.02641490f, 0.02478591f, 0.00529035f, 
    -0.19040112f, -0.26333755f, -0.05571802f, -0.24118179f, 0.03038614f, 0.07691815f, 0.03599001f, 0.22725323f, 
    -0.03460880f, 0.11708763f, -0.01551360f, 0.09225302f, -0.00173834f, 0.13505025f, -0.31925252f, -0.16064003f, 
    0.08163576f, 0.06132906f, -0.10822482f, 0.10926184f, -0.12091904f, -0.05854392f, -0.12264767f, 0.12947218f, 
    -0.11956882f, 0.00393070f, 0.08896983f, -0.21423048f, 0.06618311f, -0.23332237f, 0.29079852f, 0.00450043f, 
    -0.00812146f, -0.17263936f, 0.17640828f, -0.03904104f, -0.15480900f, 0.07717674f, -0.11421433f, -0.04590235f, 
    -0.01260107f, -0.09127750f, 0.04442509f, -0.09582704f, 0.01929583f, -0.00463881f, 0.15667017f, 0.15616877f, 
    0.24841295f, 0.37560859f, 0.13678658f, -0.16520378f, 0.10349439f, 0.04221427f, -0.08497801f, -0.07320383f, 
    -0.00989487f, 0.05977430f, 0.05477522f, -0.11010072f, -0.25995681f, -0.09264392f, 0.00710892f, -0.41984019f, 
    0.16698876f, 0.02353980f, -0.04312071f, -0.18856415f, 0.05240967f, 0.06768011f, 0.02310725f, 0.04419337f, 
    0.18804798f, 0.20952947f, 0.05536190f, -0.00078232f, 0.01169955f, 0.02820640f, 0.09708799f, 0.05103004f, 
    0.06535123f, -0.07950749f, 0.05166951f, 0.03811982f, -0.03317434f, -0.07624127f, -0.15679097f, 0.20387420f, 
    0.04236127f, 0.09805552f, 0.03867392f, 0.02375455f, 0.09151954f, -0.05339483f, 0.12275472f, 0.05815359f, 
    0.18792035f, -0.40459174f, 0.23107034f, -0.01102032f, 0.09412917f, 0.26208964f, 0.05216842f, -0.00636464f, 
    -0.04040471f, 0.02187358f, -0.01875121f, -0.10837651f, -0.09214761f, 0.07952151f, 0.03027094f, 0.11961228f, 
    0.17496547f, 0.01042287f, -0.13423476f, -0.09258222f, -0.17620407f, 0.19218102f, -0.10276613f, 0.04011287f, 
    -0.09426123f, 0.26895720f, -0.02462706f, -0.22326283f, 0.06317090f, -0.00452213f, 0.09659460f, 0.04834419f, 
    -0.02382190f, -0.01311859f, 0.09412630f, 0.05600765f, -0.10259344f, -0.21641575f, -0.05866930f, 0.05187153f, 
    0.05576713f, -0.00674977f, -0.00647676f, 0.29727268f, -0.05597012f, -0.03902637f, 0.01703670f, -0.19659074f, 
    0.01677449f, -0.12597394f, -0.01699529f, 0.01615487f, -0.07166920f, -0.07544190f, 0.13160312f, -0.00669198f, 
    0.00591667f, 0.10558652f, -0.25853121f, -0.02891654f, -0.07990121f, -0.09676561f, 0.06470802f, -0.08494830f, 
    -0.02831092f, -0.04335857f, 0.02829823f, -0.05340344f, 0.15120804f, -0.00350012f, -0.01875127f, -0.06783366f, 
    0.14154285f, -0.36523038f, 0.22715250f, 0.11189963f, 0.03730823f, 0.11769021f, -0.00143583f, 0.07142298f, 
    -0.00480998f, -0.08607115f, -0.17017329f, -0.07576010f, 0.29120880f, -0.04354857f, 0.41738877f, -0.06062173f, 
    -0.04673387f, -0.08595796f, -0.02300024f, -0.03673144f, 0.20437744f, 0.06923838f, 0.12581290f, 0.08081602f, 
    -0.23505811f, 0.25094327f, 0.05052328f, 0.24410205f, -0.02376027f, 0.02694609f, 0.00055348f, 0.13632199f, 
    0.17900375f, 0.11075849f, -0.01185029f, -0.17937145f, -0.21619183f, 0.02591572f, -0.17593662f, -0.03664382f, 
    0.00605654f, -0.01582244f, 0.06370530f, -0.04108984f, -0.05952293f, -0.03067180f, 0.02942373f, -0.01678188f, 
    0.11494235f, 0.18828739f, 0.11754059f, 0.18927547f, -0.05470403f, 0.09263753f, -0.00589690f, -0.02967835f, 
    0.00000473f, 0.09393895f, -0.06822393f, 0.15490669f, -0.04858129f, -0.19203198f, 0.13167343f, 0.04271173f, 
    -0.05715993f, 0.01390271f, 0.10078657f, 0.25736415f, 0.01738699f, 0.03916286f, 0.03566983f, -0.04187047f, 
    -0.32818076f, -0.17976888f, -0.12051495f, 0.18404649f, 0.03793187f, 0.02143989f, 0.12347954f, 0.05805094f, 
    -0.04935399f, 0.12402131f, -0.04954694f, 0.02912800f, 0.05388730f, -0.02250226f, -0.02218487f, -0.03610443f, 
    0.03390417f, 0.00041986f, 0.06488030f, -0.00308468f, 0.09126934f, 0.03360257f, 0.16854392f, 0.16786186f, 
    -0.21079706f, -0.39706799f, -0.05966954f, 0.05322968f, -0.06431030f, 0.12648484f, -0.05680206f, 0.01392950f, 
    0.02051925f, -0.02164011f, 0.01859237f, 0.04311896f, 0.37422729f, 0.28058940f, 0.11904004f, -0.23729518f, 
    -0.01552990f, -0.00882252f, -0.07504802f, -0.05523490f, -0.03286714f, 0.03271218f, 0.05764832f, 0.01925879f, 
    0.22897148f, 0.37587133f, -0.45973954f, 0.06303473f, -0.00541181f, 0.09578628f, -0.03517089f, -0.03599789f, 
    -0.01104317f, 0.06641986f, 0.06357678f, 0.01518596f, 0.08279287f, -0.04290910f, -0.04327937f, -0.04888604f, 
    -0.05021567f, -0.04153543f, 0.12859145f, 0.10483367f, -0.00908938f, -0.02081004f, 0.14063960f, 0.20855725f, 
    -0.02049996f, -0.09099287f, 0.07488894f, 0.30077592f, -0.04179326f, 0.07771222f, -0.04744560f, -0.10412014f, 
    0.07518622f, -0.07922088f, -0.04609974f, -0.00113230f, -0.04438182f, 0.14503342f, 0.14172964f, 0.17632334f, 
    0.04527375f, -0.04313865f, 0.10452195f, 0.07119846f, -0.04240791f, -0.03498377f, 0.01912158f, 0.09187758f, 
    0.05876354f, 0.04808643f, 0.11336462f, -0.05252226f, -0.08066837f, -0.06551068f, -0.03959262f, -0.04383977f, 
    -0.10853492f, -0.08899125f, -0.01993376f, 0.06651183f, -0.17611687f, 0.32120332f, 0.00527067f, 0.11570936f, 
    -0.09734532f, -0.05753525f, -0.12908706f, -0.03226648f, -0.01422822f, 0.14121564f, 0.11804173f, 0.14781088f, 
    -0.28775078f, 0.38470608f, -0.25485715f, 0.27313620f, 0.11915410f, 0.21960789f, 0.04111890f, -0.09431726f, 
    0.04804688f, -0.00256812f, -0.05620721f, 0.09321223f, -0.24695165f, 0.18379122f, -0.06938826f, 0.06203368f, 
    0.05930546f, 0.02677341f, 0.03404709f, 0.03166395f, 0.03427026f, 0.03709647f, 0.15970911f, 0.15010633f, 
    -0.04229622f, -0.11763362f, -0.43032670f, 0.01288703f, 0.16291001f, 0.00913151f, 0.08145003f, 0.16506515f, 
    -0.00599991f, 0.01972896f, 0.01191135f, -0.30461657f, 0.14439225f, 0.30721232f, -0.02298116f, 0.00749242f, 
    0.20028247f, 0.11449820f, 0.01824124f, 0.10346574f, -0.17296241f, -0.04083919f, -0.08840613f, -0.04040205f, 
    -0.25341064f, 0.38897115f, 0.11741126f, 0.33820099f, -0.04252567f, -0.00170695f, 0.04262453f, 0.03628192f, 
    -0.17067358f, -0.07090688f, 0.07106653f, 0.00335214f, 0.15710634f, 0.00487712f, 0.15262853f, 0.13761957f, 
    -0.01450946f, 0.21386832f, 0.17904821f, 0.04728899f, 0.02940192f, 0.03948867f, 0.06303518f, 0.11114843f, 
    -0.02646419f, 0.04492045f, -0.15431900f, -0.07912340f, 0.04846543f, 0.01837758f, 0.16824037f, 0.23298794f, 
    -0.04369683f, -0.01831180f, -0.17863381f, 0.01428838f, -0.07741031f, 0.04266181f, 0.12490049f, -0.04552954f, 
    -0.09654430f, 0.09930564f, 0.02478942f, -0.02049216f, 0.02035418f, -0.01961748f, 0.04314532f, 0.00771926f, 
    0.11917317f, 0.05430878f, 0.11192955f, -0.07824186f, 0.06555068f, 0.07711156f, -0.08278920f, 0.01753577f, 
    -0.05287853f, 0.00325047f, 0.02606650f, 0.01046727f, 0.03024927f, 0.12958768f, 0.19639669f, 0.02189660f, 
    -0.05812996f, -0.01506165f, 0.01472137f, -0.00311470f, -0.04536702f, -0.00903123f, 0.09837138f, 0.09064237f, 
    -0.29857069f, 0.33067062f, 0.18517166f, -0.14331315f, 0.09897532f, 0.12425464f, -0.08778783f, 0.07234707f, 
    0.01659100f, 0.10553113f, -0.01663096f, -0.03966740f, -0.06688468f, 0.14566717f, 0.23929119f, -0.11045787f, 
    -0.10856473f, 0.04968162f, 0.09897819f, 0.06213007f, -0.02824885f, 0.13630715f, 0.08934371f, 0.12871291f, 
    0.16422334f, 0.08276514f, -0.08597460f, 0.08670651f, 0.04822371f, 0.11777622f, 0.20268176f, -0.05514181f, 
    -0.02254225f, 0.03338539f, 0.06312706f, 0.05966817f, -0.10550042f, -0.07347807f, -0.04962253f, 0.21090543f, 
    0.01822222f, -0.02702016f, -0.10815562f, 0.06121227f, -0.00885981f, -0.37123349f, -0.03825473f, -0.16675989f, 
    0.09388930f, -0.11744758f, 0.04369032f, 0.03271220f, -0.10831556f, -0.13485894f, -0.01802010f, -0.10447252f, 
    -0.13838153f, 0.03535816f, -0.00554568f, 0.07270747f, 0.05221937f, 0.26335618f, -0.02540368f, 0.10488311f, 
    -0.02183210f, -0.02238233f, -0.02246820f, -0.01491257f, 0.06139369f, 0.04044003f, -0.24327958f, -0.00973672f, 
    0.17279974f, 0.42531294f, -0.11237341f, -0.10025071f, -0.14485317f, -0.08789849f, 0.13225229f, 0.10373771f, 
    0.05930312f, -0.02726271f, -0.07597381f, -0.03252164f, -0.12568931f, 0.31825364f, 0.07821392f, -0.34326854f, 
    -0.22086652f, 0.10125858f, 0.13570766f, -0.03303001f, 0.05797169f, -0.07742731f, 0.01087216f, -0.03103029f, 
    0.12366100f, -0.50883901f, -0.31942877f, -0.11405319f, 0.06937879f, 0.13345543f, 0.14491871f, 0.09174886f, 
    -0.02691371f, -0.04356394f, 0.02949329f, -0.02054900f, 0.34008405f, -0.05329242f, 0.11357191f, -0.16359906f, 
    0.13224469f, 0.01030309f, 0.19440603f, -0.09162965f, 0.01051289f, 0.02601062f, -0.02755003f, -0.09255332f, 
    -0.26249450f, 0.04081339f, -0.01962910f, 0.25506976f, -0.04296175f, -0.06495640f, -0.24066323f, -0.09769262f, 
    0.04772262f, 0.05032776f, -0.02156975f, 0.01491137f, 0.14794052f, 0.00556256f, -0.04060891f, 0.18018696f, 
    0.03218709f, -0.07702135f, 0.09476792f, -0.12666915f, 0.00543691f, -0.01110520f, 0.06701091f, 0.04763606f, 
    0.07978034f, -0.33908236f, -0.24288848f, 0.08304898f, 0.04762601f, -0.04770561f, 0.00744186f, 0.14193681f, 
    0.11939719f, -0.02792713f, -0.11160701f, 0.02841045f, -0.01919111f, 0.02570738f, -0.02058022f, -0.02331916f, 
    -0.04607600f, 0.13653739f, 0.11157811f, 0.17293066f, -0.00710170f, -0.04058794f, 0.00755082f, 0.11577714f, 
    0.00190921f, -0.01368299f, 0.05938089f, -0.07004340f, 0.02675704f, -0.02603022f, -0.08002970f, 0.04424931f, 
    0.02933311f, -0.03602986f, -0.16072959f, -0.04625266f, 0.00633908f, 0.14415705f, 0.20236994f, 0.08849204f, 
    0.04250895f, -0.02324285f, 0.00265115f, -0.04953209f, -0.07263283f, 0.07942829f, 0.00342714f, 0.01469065f, 
    0.52986854f, 0.03850409f, 0.29049644f, -0.02198110f, 0.16571473f, 0.00682764f, -0.03594380f, -0.16762359f, 
    0.14019716f, 0.09609508f, -0.00985298f, 0.03568733f, 0.00127102f, 0.09856606f, -0.01651624f, -0.03005022f, 
    0.00269773f, -0.01374903f, 0.07578473f, 0.07011393f, 0.01067743f, 0.01074779f, -0.16342375f, 0.11552144f, 
    0.37093541f, 0.23429404f, -0.02526188f, 0.00712160f, 0.05669466f, 0.04798282f, 0.24532008f, 0.07243003f, 
    0.05015421f, -0.01461857f, -0.00135900f, -0.04438242f, -0.09637056f, 0.02253713f, -0.02335105f, 0.09959894f, 
    -0.07018911f, 0.01824925f, -0.14525223f, -0.12042192f, 0.04579738f, -0.00335732f, 0.09625822f, -0.04859158f, 
    -0.05884473f, 0.11790755f, 0.14456294f, -0.09632882f, -0.03946181f, -0.00767135f, 0.06845375f, -0.01469615f, 
    0.02369769f, -0.00690880f, 0.16501029f, 0.09127849f, -0.04998359f, -0.00580318f, 0.02014444f, 0.02412064f, 
    -0.07748514f, 0.00219757f, 0.08928792f, -0.05652917f, 0.23761421f, -0.01849270f, -0.08711847f, 0.12379768f, 
    0.26942340f, 0.23625135f, -0.06997120f, -0.27788493f, -0.07591138f, -0.05321729f, 0.19263460f, 0.04800019f, 
    -0.00348209f, 0.02636514f, -0.02880172f, -0.03115741f, 0.37980884f, 0.09798829f, -0.31921631f, -0.25463676f, 
    0.08753890f, 0.09420310f, 0.02621078f, -0.07777256f, -0.05971838f, 0.00986626f, 0.11555280f, -0.07618109f, 
    0.17313224f, -0.19003412f, -0.05284272f, 0.02888602f, -0.03802541f, -0.01139656f, -0.05266543f, -0.14583410f, 
    0.12316896f, -0.13682069f, -0.00961771f, -0.02225943f, 0.04646923f, 0.00632864f, 0.04222108f, 0.18395238f, 
    -0.05881703f, 0.00662763f, -0.02712440f, 0.04080003f, 0.05497938f, 0.00440247f, 0.07882596f, 0.05061866f, 
    0.21734983f, -0.24512044f, -0.17462164f, -0.13459659f, 0.00620196f, -0.02630242f, -0.06428304f, 0.01635650f, 
    0.04605420f, 0.01999808f, 0.12606546f, -0.08375757f, 0.03607265f, 0.05016502f, 0.10468890f, 0.26797897f, 
    0.10575169f, 0.01251395f, -0.07185068f, 0.16217472f, 0.00756383f, 0.08867254f, 0.01293961f, 0.01079488f, 
    0.05005548f, 0.13790585f, 0.24752532f, 0.28764114f, 0.01470169f, -0.04127280f, 0.07814206f, 0.16144744f, 
    0.08383464f, -0.01713327f, 0.04242337f, 0.07370533f, 0.00242111f, -0.10525858f, -0.17196731f, -0.07801554f, 
    0.06289636f, 0.08760278f, 0.02199061f, -0.02872048f, 0.05322870f, 0.04395604f, 0.03991091f, -0.05450745f, 
    0.12696379f, 0.16379540f, 0.13084023f, 0.21040410f, 0.02629161f, -0.08627620f, 0.09013281f, 0.08812107f, 
    -0.06757813f, -0.02635232f, 0.00894274f, 0.11699816f, 0.16347621f, -0.09790652f, -0.04995738f, 0.09590210f, 
    -0.00061123f, -0.06472975f, -0.04783858f, -0.07089895f, 0.01529837f, -0.00220635f, -0.08599449f, -0.03850516f, 
    0.17436442f, -0.09531974f, -0.26836526f, -0.07770783f, -0.07795539f, -0.06537817f, -0.03710777f, -0.11190085f, 
    -0.03912428f, 0.03217296f, -0.01126978f, -0.08613066f, 0.03520629f, -0.03724308f, -0.09776227f, -0.05072746f, 
    -0.05348960f, 0.02065833f, -0.11696507f, -0.00527023f, 0.07227505f, -0.06192134f, 0.19931231f, 0.02126872f, 
    0.07803016f, 0.07797474f, 0.12960511f, 0.06961367f, -0.07569453f, 0.01996177f, -0.19584088f, -0.00370059f, 
    0.01704103f, -0.01609468f, -0.03119237f, -0.01764914f, 0.08710717f, 0.10123970f, -0.00663185f, 0.00898366f, 
    -0.02784842f, 0.07699046f, -0.06100529f, 0.14266583f, -0.02711803f, -0.04215987f, -0.03421958f, 0.07976223f, 
    -0.23068294f, -0.19191124f, -0.51912731f, -0.14990768f, -0.13377379f, -0.00504713f, -0.15181439f, -0.05728626f, 
    -0.08138704f, 0.07880519f, 0.13839966f, 0.03289628f, 0.14358316f, -0.29309565f, -0.11107446f, -0.15587173f, 
    -0.07327769f, -0.00252710f, -0.08809986f, 0.03938352f, 0.05244384f, 0.00459687f, -0.03141096f, 0.09737781f, 
    -0.04487249f, -0.12908149f, 0.11573511f, -0.04886497f, 0.00930627f, 0.03415934f, -0.12590763f, -0.03100188f, 
    -0.00534023f, 0.02746465f, -0.08306433f, 0.02658763f, -0.09330195f, -0.04154825f, -0.25750226f, 0.02188404f, 
    -0.01179090f, 0.05050809f, -0.08137391f, -0.11874491f, -0.01013168f, 0.12089834f, 0.07205915f, 0.04011736f, 
    0.41699272f, -0.30459309f, 0.00271473f, -0.18874784f, -0.03900944f, 0.00341594f, 0.00988615f, -0.12798378f, 
    0.00364485f, 0.01241265f, 0.02854324f, -0.01465075f, 0.31666091f, -0.01409244f, 0.39330938f, 0.16248143f, 
    0.14596136f, -0.00286455f, 0.07533681f, -0.02566090f, -0.01744046f, -0.07946063f, 0.02715204f, -0.01961282f, 
    -0.04678224f, -0.09442125f, 0.04389245f, 0.04858155f, -0.03274755f, -0.01279639f, -0.24108833f, -0.17705013f, 
    0.17169818f, 0.03506865f, -0.09712991f, 0.01501077f, 0.12585293f, 0.10758987f, -0.10023916f, 0.09809045f, 
    0.23754311f, 0.18224888f, 0.13265505f, -0.06445974f, 0.05330999f, 0.02890910f, -0.11247246f, -0.02828551f, 
    0.12990007f, -0.15379047f, -0.08828390f, 0.20099901f, 0.03945624f, -0.05645860f, 0.08522470f, 0.08221693f, 
    0.13648413f, -0.03429684f, 0.04619182f, 0.00897898f, 0.14925297f, 0.08899185f, -0.13085096f, 0.08115812f, 
    -0.06422582f, -0.02029243f, -0.03144090f, 0.15704069f, -0.02013957f, 0.00472410f, -0.04283373f, -0.02543084f, 
    0.37820148f, 0.19347620f, 0.04124349f, 0.07463986f, 0.01948690f, 0.00671178f, -0.03231050f, 0.16457358f, 
    -0.14227954f, -0.03285573f, -0.07547238f, 0.04072782f, -0.06370644f, -0.05677349f, 0.28387645f, 0.20287065f, 
    0.00811868f, 0.07831903f, -0.14766547f, 0.13234012f, -0.07276019f, -0.03426760f, -0.14602394f, -0.13360181f, 
    -0.05763436f, -0.16121706f, 0.43580797f, 0.02004238f, 0.02180159f, -0.03775381f, -0.12324510f, -0.00667352f, 
    0.01709643f, -0.05577055f, -0.05852129f, 0.17743465f, 0.13304755f, -0.05962018f, -0.08242203f, 0.12804565f, 
    0.10013382f, 0.11044256f, 0.15111516f, -0.14166774f, 0.02648765f, -0.28326684f, -0.14700581f, -0.11444066f, 
    0.30215052f, 0.31015679f, -0.07576927f, -0.00534703f, -0.03984817f, -0.13796042f, -0.02472402f, 0.12220030f, 
    -0.00264348f, -0.04362030f, 0.00290777f, 0.01720225f, 0.14176762f, 0.07672099f, -0.03776614f, -0.07973310f, 
    -0.01862415f, 0.06570800f, 0.02761016f, -0.04003327f, 0.01936468f, 0.03800644f, 0.12071408f, 0.06519590f, 
    0.06580505f, 0.20990971f, 0.23271067f, 0.06245034f, 0.04616209f, 0.06598942f, -0.11813813f, 0.08935426f, 
    0.14516410f, -0.03420236f, 0.14886969f, 0.11377504f, 0.14941841f, -0.23215008f, -0.03691085f, 0.06341029f, 
    0.01707421f, 0.04957446f, 0.02864175f, -0.02658315f, 0.00044475f, -0.20123687f, -0.06489841f, -0.07369334f, 
    0.31696814f, 0.34684235f, 0.04164749f, -0.28712747f, -0.14800408f, -0.22523864f, 0.00316535f, 0.24212663f, 
    -0.03418235f, 0.05842302f, 0.03981930f, -0.05794972f, 0.23808628f, -0.01058569f, -0.10700750f, 0.19077213f, 
    0.11463965f, 0.10971584f, -0.00251502f, -0.03837034f, -0.13228661f, -0.03783748f, -0.03510810f, 0.02309239f, 
    0.08496233f, 0.42264584f, 0.21101603f, -0.02393763f, -0.05450967f, -0.12862034f, -0.06421019f, 0.19952698f, 
    0.02654147f, 0.14301008f, 0.08148055f, 0.03362286f, -0.21788628f, -0.18365614f, 0.13776606f, 0.03691487f, 
    -0.19507401f, -0.04523135f, -0.03034021f, -0.06161961f, 0.02679604f, -0.00111337f, 0.08091438f, -0.03309344f, 
    0.47578713f, -0.04380604f, -0.12467124f, -0.22210285f, 0.04650836f, 0.02471646f, 0.18271808f, 0.17037591f, 
    -0.06463433f, 0.01716853f, 0.07793178f, -0.01960194f, 0.00122394f, 0.16517974f, 0.28258765f, -0.09800360f, 
    -0.05276119f, -0.03357172f, -0.13660860f, 0.07082971f, 0.00619879f, -0.10030569f, -0.03440444f, -0.02200101f, 
    0.00477198f, 0.21237762f, 0.28797099f, 0.02405495f, 0.00181026f, 0.00337663f, 0.00026791f, -0.04970977f, 
    0.15034088f, 0.15031336f, -0.00237667f, 0.11577134f, 0.08678440f, -0.00309133f, 0.03200110f, 0.08376335f, 
    0.15689780f, 0.03627306f, 0.05156951f, -0.01678532f, 0.13604222f, -0.03511322f, -0.16304964f, -0.10120264f, 
    -0.01644187f, 0.17796606f, -0.08402731f, -0.08637082f, -0.05325368f, -0.12330376f, 0.01708094f, -0.01380939f, 
    0.00204340f, -0.02302308f, 0.13004692f, 0.00213450f, 0.10601742f, -0.12645137f, -0.26265410f, 0.15519966f, 
    0.03916720f, -0.00275020f, 0.00947171f, -0.03854017f, -0.03362448f, -0.03050847f, -0.11688046f, -0.03372620f, 
    -0.26697084f, -0.07227375f, -0.25667617f, 0.16653194f, -0.02117184f, 0.08768616f, 0.05972220f, 0.21173705f, 
    -0.16681501f, -0.15278682f, 0.01484323f, -0.03034906f, -0.04738527f, 0.11501713f, 0.04685214f, 0.03052552f, 
    -0.01543601f, 0.07217380f, -0.09309359f, -0.08111773f, 0.07844602f, -0.02249852f, 0.14740953f, -0.10835726f, 
    -0.41115847f, -0.18205515f, 0.12099942f, -0.03344053f, -0.03538999f, 0.10228762f, -0.10902401f, 0.06817020f, 
    -0.08592476f, 0.00640194f, -0.00340841f, -0.07138214f, 0.19408433f, -0.17682099f, 0.02648752f, -0.27810022f, 
    -0.01278071f, -0.02398962f, 0.10927147f, 0.11129797f, -0.01038976f, 0.07422868f, 0.07035848f, 0.14700350f, 
    0.13744150f, -0.04847666f, -0.21972723f, 0.02141455f, -0.01560206f, 0.02886891f, 0.08612629f, -0.04899662f, 
    -0.01156238f, 0.07783718f, -0.11294307f, -0.07088642f, 0.12149057f, 0.10530136f, 0.11648356f, -0.10270202f, 
    -0.03555783f, -0.08975908f, -0.07905627f, 0.00740468f, -0.03653511f, 0.10100412f, 0.13579799f, 0.18780880f, 
    -0.12794496f, -0.48086935f, 0.13454804f, 0.10273711f, 0.17710440f, 0.02727455f, 0.00732251f, -0.07529702f, 
    -0.00328685f, 0.05869671f, -0.05345017f, 0.00946901f, -0.13594900f, 0.02318815f, 0.19180728f, 0.45358917f, 
    0.01276525f, 0.04476164f, -0.11335824f, -0.06549238f, 0.13368040f, 0.08227268f, 0.08019409f, 0.08988882f, 
    0.19556531f, -0.03167744f, 0.13557237f, -0.35644007f, 0.04074883f, -0.17119186f, -0.10387973f, -0.07736699f, 
    -0.00684698f, 0.06642235f, 0.20539950f, 0.04027721f, -0.09783178f, -0.00504873f, 0.09383661f, 0.27066886f, 
    -0.17266369f, -0.07374997f, -0.08575518f, 0.09934150f, 0.00408614f, -0.18770625f, 0.08623917f, -0.14376098f, 
    0.12231255f, -0.01493824f, 0.08326219f, -0.21639824f, -0.09308999f, -0.00133740f, 0.05074099f, 0.05898070f, 
    -0.00387067f, 0.01720302f, 0.03286116f, -0.02251556f, 0.05130259f, 0.06840152f, 0.11860709f, 0.00513087f, 
    -0.03221193f, 0.04411019f, 0.03377213f, 0.11712485f, -0.06282773f, -0.04975772f, -0.05236183f, 0.04569595f, 
    0.11761234f, 0.20652743f, 0.12669162f, 0.22473738f, -0.10483861f, -0.08753467f, 0.02857452f, 0.00561880f, 
    -0.00861760f, -0.07135341f, -0.10178678f, -0.13064818f, 0.10505610f, 0.04780845f, 0.10604558f, 0.01008797f, 
    0.04754734f, 0.15295890f, 0.03214961f, -0.01224067f, -0.02435611f, -0.03163067f, -0.02437093f, -0.01853041f, 
    0.08403526f, 0.34830704f, 0.00575957f, 0.14057370f, 0.00487684f, -0.12259593f, 0.04177421f, 0.12721074f, 
    0.04664300f, -0.00855153f, 0.08240256f, -0.12619925f, 0.09887478f, -0.06144674f, -0.03692920f, 0.20060076f, 
    -0.19695279f, -0.03464394f, -0.10364546f, 0.04831671f, 0.08759177f, 0.02022694f, -0.12331839f, 0.08760270f, 
    -0.26552391f, -0.03020588f, -0.06807833f, 0.13827559f, 0.02178073f, -0.05287726f, 0.10885960f, 0.08234288f, 
    -0.00861717f, -0.01232665f, -0.05827477f, 0.11077179f, 0.13967009f, 0.17300752f, 0.03255074f, 0.10832111f, 
    0.07008913f, 0.15074711f, -0.05048910f, -0.24538727f, -0.10145248f, -0.18866700f, 0.16785763f, -0.13504939f, 
    -0.17696628f, 0.03208705f, 0.03788449f, -0.19188604f, -0.00068795f, 0.06968489f, -0.12359409f, 0.14657807f, 
    -0.20409353f, 0.01699829f, -0.16307859f, -0.01711889f, 0.19820422f, -0.11720187f, 0.08758260f, -0.20920002f, 
    -0.20852427f, 0.04381050f, -0.06513143f, -0.05664406f, 0.09511496f, -0.12291364f, -0.13652502f, 0.03810727f, 
    0.00953784f, 0.18586238f, 0.02648995f, 0.13470115f, 0.08273788f, 0.09530026f, 0.04700952f, 0.02911385f, 
    0.05567094f, 0.17252639f, 0.10668923f, 0.12524188f, 0.35159975f, -0.02528422f, 0.17119505f, -0.06623950f, 
    -0.07318386f, -0.05739185f, 0.05191860f, 0.02241506f, -0.02166743f, 0.07773834f, -0.07978408f, 0.08920694f, 
    0.04213933f, -0.40254942f, 0.26945940f, -0.14422913f, -0.15532239f, 0.01621635f, -0.14143828f, 0.12709785f, 
    -0.09246387f, -0.05243443f, -0.09015072f, 0.02022764f, 0.09724631f, 0.14244770f, -0.03104400f, 0.41400677f, 
    0.05684030f, -0.01435130f, -0.00274475f, -0.06575089f, -0.01775206f, 0.04368461f, -0.09400031f, 0.02807354f, 
    -0.00241201f, -0.06956408f, -0.05838495f, -0.06070551f, -0.02734187f, 0.00403652f, -0.00392986f, 0.01530951f, 
    0.03201745f, -0.07390536f, 0.05507510f, 0.00478524f, -0.03667824f, -0.01449427f, -0.06232300f, 0.02280217f, 
    0.01718146f, -0.02457530f, 0.04226471f, -0.03010829f, -0.06602895f, -0.01759342f, -0.03039732f, 0.05289759f, 
    -0.06171829f, 0.05413712f, 0.00013874f, -0.07793608f, -0.04299467f, 0.02279055f, 0.03799027f, -0.07990105f, 
    -0.04215447f, -0.01120229f, -0.08524524f, -0.04933542f, 0.04654917f, -0.02333568f, -0.03413747f, -0.05060288f, 
    -0.04086451f, 0.02552008f, -0.03727935f, -0.04712679f, 0.03554700f, -0.00912642f, 0.02223615f, 0.00779386f, 
    -0.02963529f, -0.06793081f, 0.03673337f, 0.04243737f, 0.05023000f, -0.02762070f, -0.04789714f, -0.07068069f, 
    0.06241407f, -0.02714095f, -0.03908498f, -0.04881531f, 0.03971304f, -0.00579680f, -0.02728168f, 0.05170532f, 
    0.05911831f, -0.01671972f, 0.04496878f, -0.04556741f, -0.03009129f, -0.04627070f, 0.03982707f, 0.05513326f, 
    -0.03477222f, -0.04197927f, 0.01019463f, -0.04336520f, -0.04446914f, -0.06031059f, -0.04809390f, 0.04776258f, 
    0.00414604f, 0.01699166f, 0.06200307f, -0.06283344f, 0.00068525f, -0.03019536f, -0.02882004f, 0.01079437f, 
    0.01983032f, -0.06177358f, -0.06355317f, -0.06115008f, -0.01805450f, -0.00908541f, -0.04727734f, -0.05036948f, 
    -0.04715764f, -0.06101435f, -0.04288967f, -0.06285863f, -0.03980013f, -0.01401929f, -0.06592838f, -0.00075250f, 
    0.03089392f, -0.08251650f, -0.02094184f, -0.02238275f, 0.01129876f, 0.04975625f, -0.07625884f, 0.04543331f, 
    -0.08253492f, 0.03958011f, -0.06150871f, -0.08117653f, 0.01284550f, -0.06656025f, 0.04017387f, 0.03393649f, 
    -0.09024592f, 0.00979513f, 0.02590743f, 0.02213496f, 0.01268225f, -0.05251117f, -0.04700426f, 0.03757278f, 
    -0.07088067f, 0.00073793f, 0.00040294f, 0.00963956f, -0.00897762f, 0.05650600f, -0.07857349f, -0.03787646f, 
    -0.04757666f, 0.03373059f, 0.03235898f, -0.06082252f, 0.05373409f, 0.01484135f, 0.03018492f, -0.04670063f, 
    -0.07618216f, -0.07893306f, -0.05701648f, 0.03043760f, -0.00578482f, 0.02251227f, 0.04699500f, -0.01874537f, 
    -0.08129337f, -0.04291965f, -0.02815042f, 0.02095852f, -0.07356159f, 0.06201807f, -0.06016639f, 0.00235137f, 
    0.01518996f, 0.00252264f, -0.00072929f, -0.02486053f, -0.03751596f, -0.03041139f, -0.02288608f, -0.08027794f, 
    0.04959587f, 0.01087957f, 0.00717719f, -0.01782717f, 0.00190150f, -0.07063701f, 0.01381883f, -0.00020422f, 
    0.01613710f, 0.03515935f, -0.01350904f, -0.00836242f, 0.04161321f, -0.02576579f, 0.01744442f, -0.04700642f, 
    0.04199857f, 0.00257629f, -0.01809874f, 0.01243986f, 0.01756405f, 0.04700900f, -0.03503705f, -0.03757598f, 
    0.15331973f, -0.13317129f, 0.21647221f, -0.09048034f, -0.08995678f, -0.14403872f, -0.19901732f, 0.00904052f, 
    0.07442632f, -0.06156944f, -0.04992015f, 0.02423402f, -0.19384074f, 0.07769321f, 0.02270703f, 0.29802695f, 
    -0.01872531f, 0.09495852f, -0.14481860f, 0.11124017f, 0.09227473f, -0.06417026f, 0.00513475f, -0.11291839f, 
    0.12177517f, -0.14048651f, 0.37891531f, -0.20768832f, 0.03404389f, -0.03398627f, -0.10769276f, 0.03876127f, 
    0.01972187f, 0.00186759f, -0.20073056f, 0.02038054f, -0.14831997f, -0.11118978f, -0.01988325f, -0.05777140f, 
    -0.09018052f, 0.08380792f, 0.16602768f, 0.20712401f, 0.05621525f, 0.08699496f, 0.00003724f, 0.04156671f, 
    -0.10782763f, -0.00928478f, -0.01663745f, 0.19509616f, 0.04386054f, 0.04390306f, 0.17761706f, 0.09995983f, 
    -0.00179979f, -0.00263563f, -0.06994250f, -0.00572987f, 0.01166493f, -0.17233346f, 0.07047042f, -0.18155538f, 
    0.00110161f, 0.09690502f, 0.04590555f, 0.09287125f, -0.02321006f, 0.08740539f, 0.07810564f, 0.22515719f, 
    -0.19795924f, -0.06449597f, 0.01902163f, 0.21609144f, 0.14038756f, 0.04690645f, 0.09664142f, 0.10926290f, 
    0.10661541f, 0.09768326f, -0.02076921f, 0.00361544f, 0.08003693f, 0.08964717f, -0.12546873f, 0.15066124f, 
    -0.06434981f, 0.08624005f, -0.03933551f, -0.02578541f, 0.00960636f, 0.00536555f, -0.04425333f, 0.04503445f, 
    -0.06306481f, 0.02354147f, -0.37769118f, 0.16832048f, 0.09909874f, 0.19183257f, 0.04786558f, -0.13110773f, 
    0.01063356f, 0.05604335f, 0.01370843f, -0.02683287f, 0.09014902f, -0.12697138f, 0.02191699f, 0.10132124f, 
    -0.04996571f, 0.02577718f, 0.01035881f, 0.01595499f, 0.00710786f, 0.04262440f, 0.12441555f, 0.08528262f, 
    -0.28979516f, 0.00758507f, -0.13475214f, -0.19816811f, 0.01589967f, -0.05879632f, 0.10110234f, 0.11744867f, 
    0.02441938f, 0.00444834f, 0.03801225f, -0.09529062f, 0.09406427f, 0.02166128f, 0.33509111f, -0.09526762f, 
    -0.04151072f, -0.00396881f, 0.00703693f, 0.14752246f, 0.12526134f, -0.05061997f, -0.03129758f, 0.09612645f, 
    -0.03160913f, -0.01331052f, -0.15247831f, -0.04688064f, -0.08282131f, -0.08119339f, 0.01800448f, -0.01703720f, 
    0.02700715f, -0.01770431f, 0.02721428f, -0.07532367f, 0.16025034f, 0.16831134f, 0.35629660f, -0.05168559f, 
    0.00026615f, -0.13705592f, 0.00036393f, -0.02876213f, 0.07522175f, 0.12961879f, -0.00880174f, 0.05955617f, 
    0.01582792f, -0.16906942f, 0.16908807f, -0.19825910f, -0.00648230f, 0.14209062f, -0.08936159f, 0.11517604f, 
    -0.00237563f, 0.00238285f, -0.04457889f, -0.15792321f, 0.16963273f, -0.06806669f, 0.09223379f, 0.14007521f, 
    0.03732291f, -0.05208432f, -0.04931207f, -0.09417444f, 0.01176403f, 0.09138679f, 0.06795478f, 0.21490589f, 
    -0.04941069f, 0.16750775f, 0.26721421f, -0.12803453f, -0.18904838f, -0.07471900f, -0.06725313f, -0.03858814f, 
    -0.06149437f, -0.04928539f, 0.05712718f, 0.13931587f, -0.04906357f, -0.15345785f, 0.15208347f, 0.08163903f, 
    -0.09779622f, 0.03148431f, -0.09111626f, 0.04575434f, 0.12293123f, -0.07240822f, 0.07044397f, 0.06969956f, 
    0.01851746f, 0.06673530f, -0.09455913f, -0.06516141f, -0.11454152f, 0.15781803f, -0.05451232f, -0.11564336f, 
    0.02511907f, 0.13861455f, -0.07441453f, 0.14891084f, 0.01236627f, 0.09921806f, 0.19187061f, -0.00168169f, 
    -0.04016077f, -0.09139790f, -0.09964448f, 0.10065929f, 0.01631432f, -0.11222471f, -0.15429778f, -0.27009469f, 
    0.10137542f, -0.03753806f, 0.15597190f, 0.12593122f, 0.00578047f, -0.08274531f, 0.07893395f, 0.01218710f, 
    0.14814577f, 0.04062050f, 0.06966730f, 0.10556604f, -0.04418780f, 0.11021776f, -0.28673300f, 0.15687254f, 
    -0.09609015f, -0.05451110f, -0.09958156f, 0.02309135f, -0.04793086f, -0.06946883f, -0.18535365f, -0.00990002f, 
    0.10562198f, 0.21064882f, 0.08183850f, 0.20676066f, 0.02174219f, -0.04865879f, 0.11796343f, 0.04004420f, 
    0.14295878f, -0.06313556f, -0.05478498f, -0.04500332f, 0.17202283f, 0.01220362f, 0.06215316f, 0.42785728f, 
    0.00413657f, -0.02672580f, -0.04914034f, -0.13090044f, -0.06245898f, -0.18774147f, -0.13951853f, -0.16004948f, 
    0.28397831f, -0.22057503f, 0.17605446f, 0.20428456f, 0.07379659f, 0.08461658f, -0.07121149f, 0.04270461f, 
    0.04532997f, -0.04385534f, 0.02190864f, 0.07295654f, 0.00042526f, 0.08162936f, -0.01957275f, 0.12874593f, 
    -0.11256704f, 0.15165673f, -0.11523837f, -0.17040129f, -0.20974343f, -0.46327761f, -0.20314662f, -0.22495264f, 
    -0.28989449f, -0.04140019f, 0.09441856f, -0.09450325f, -0.01206045f, 0.17446330f, -0.16785438f, 0.17683476f, 
    0.06013272f, 0.08362856f, 0.05665644f, -0.07116032f, 0.15248255f, 0.12233651f, 0.03678475f, -0.08382180f, 
    0.03185274f, 0.18350759f, 0.09840814f, 0.08844120f, 0.16430052f, 0.28982940f, 0.12573181f, 0.16388446f, 
    0.05034549f, 0.24840051f, 0.22921969f, 0.01754298f, 0.14475876f, 0.11014747f, -0.07109226f, -0.03005900f, 
    -0.03256207f, -0.19063917f, 0.13660429f, 0.04194994f, -0.13033432f, -0.23583639f, 0.04330146f, 0.07801468f, 
    -0.08827411f, 0.08733431f, -0.12911537f, 0.07048941f, -0.08714937f, 0.02315424f, 0.07647174f, 0.13897023f, 
    0.15939614f, -0.09530650f, 0.16470444f, -0.05769964f, 0.03512433f, 0.04507975f, -0.00957063f, 0.12038947f, 
    -0.05852386f, 0.06085184f, -0.02515880f, 0.10597394f, 0.01366893f, 0.07192782f, -0.17824192f, 0.37377638f, 
    0.00141738f, -0.09307314f, -0.25352752f, -0.22720514f, 0.02485900f, -0.05317014f, 0.08022739f, -0.16038311f, 
    0.29929754f, 0.18649273f, 0.23344316f, 0.16223539f, -0.01607995f, 0.00931355f, -0.11915781f, -0.09467502f, 
    0.21588184f, 0.04516285f, 0.14838751f, 0.17378338f, 0.07698370f, -0.21477057f, 0.47344598f, 0.16542150f, 
    0.12208471f, -0.04037085f, 0.08260634f, 0.02522161f, 0.14193134f, 0.10790170f, 0.06293576f, -0.02867796f, 
    0.20012239f, -0.04684305f, -0.15333082f, -0.02429649f, -0.00276588f, -0.03055432f, -0.21654427f, 0.03219017f, 
    -0.04716601f, 0.09592166f, 0.03184694f, 0.04388841f, -0.00442016f, 0.12971048f, 0.18907969f, 0.05433444f, 
    0.14867699f, 0.09263301f, 0.07434919f, 0.03603975f, -0.21502803f, -0.16148451f, -0.13456719f, -0.16901821f, 
    0.15572232f, 0.11494302f, 0.09528546f, -0.05045250f, -0.05265832f, -0.02427168f, 0.05211097f, 0.07765482f, 
    0.25394145f, 0.09761135f, 0.15162559f, 0.25167605f, 0.21110538f, -0.23708564f, -0.15250656f, 0.08855730f, 
    -0.11825173f, -0.30227098f, -0.18141566f, 0.10568538f, 0.11167674f, -0.07619174f, -0.15384737f, -0.05295673f, 
    -0.01679829f, 0.09183742f, -0.04443839f, -0.01908919f, 0.10064222f, 0.04137197f, 0.01878367f, 0.14602958f, 
    -0.01902506f, 0.03265958f, 0.09870304f, 0.02804317f, -0.07103707f, 0.03354780f, -0.02791317f, -0.17822893f, 
    0.06928412f, -0.13026929f, 0.04976824f, 0.02726245f, 0.00837076f, -0.01138410f, -0.06365280f, -0.11781559f, 
    -0.44535080f, 0.09460223f, 0.00834352f, -0.02769024f, -0.11094026f, -0.09611002f, 0.09092924f, 0.01587156f, 
    -0.02579374f, 0.01570221f, -0.03253356f, 0.00375981f, -0.18774056f, -0.24559478f, -0.03075048f, -0.05449593f, 
    -0.05311198f, -0.04891805f, 0.10572119f, -0.04927688f, 0.01061484f, -0.19852558f, -0.03723900f, -0.16668515f, 
    -0.08047688f, -0.09345827f, 0.01969828f, -0.02305803f, 0.03243140f, 0.03587821f, 0.01982223f, 0.07540138f, 
    -0.00903661f, 0.08053081f, 0.06050200f, 0.03920393f, 0.27182165f, -0.25966430f, 0.03745176f, -0.14775424f, 
    0.00501222f, -0.12827544f, -0.08508530f, -0.03605089f, 0.23663320f, -0.00404192f, 0.13591067f, 0.23110391f, 
    0.06636414f, 0.01958907f, -0.23546296f, 0.17437238f, -0.12719946f, -0.29495052f, -0.23408808f, -0.10529877f, 
    -0.13837349f, -0.07872248f, -0.01118340f, -0.00855931f, 0.14890261f, 0.19974005f, -0.06824528f, -0.06849119f, 
    -0.24102657f, -0.12548272f, -0.09265273f, 0.04105313f, 0.13594003f, 0.04011301f, -0.00909777f, 0.14417636f, 
    0.14806812f, -0.11164273f, 0.03633697f, -0.08488394f, 0.17040342f, -0.16445357f, 0.13621520f, 0.05031580f, 
    0.10356625f, 0.03779438f, 0.02149950f, 0.14363056f, 0.03448445f, 0.02425379f, 0.04448164f, 0.21102804f, 
    -0.14312625f, 0.04871661f, -0.02438323f, -0.11503434f, -0.03287308f, -0.05951037f, -0.12157743f, -0.12917307f, 
    0.01747471f, -0.21435986f, -0.24800831f, -0.36319810f, -0.11233769f, -0.05627894f, -0.06515259f, -0.08113145f, 
    -0.00338861f, -0.01160728f, -0.01258899f, -0.21177880f, -0.01246466f, -0.23544291f, -0.56367624f, -0.43402120f, 
    0.07234374f, 0.07737534f, -0.20302972f, 0.07789769f, -0.08981556f, 0.05644684f, -0.00435082f, -0.10919694f, 
    -0.07204419f, 0.13082531f, 0.11201242f, -0.10721096f, 0.03212528f, -0.03160564f, 0.02777032f, 0.10320213f, 
    0.16279885f, -0.12534130f, -0.01350940f, 0.14547218f, 0.07482398f, -0.05401484f, -0.48674250f, -0.24137069f, 
    0.17687358f, -0.14878826f, 0.18989427f, 0.13676257f, 0.05040086f, 0.13356863f, -0.02061024f, 0.08938882f, 
    -0.47331160f, 0.00274978f, 0.17105646f, -0.01580486f, 0.11926772f, -0.12159857f, 0.03744277f, 0.10875962f, 
    0.02938862f, -0.04043791f, -0.02336910f, 0.07271104f, 0.12290098f, 0.04669219f, 0.13760909f, -0.01233520f, 
    0.03241776f, -0.01417382f, 0.01367899f, -0.12953342f, -0.04737684f, 0.01936195f, -0.12413576f, 0.02581921f, 
    0.15822831f, -0.11968906f, -0.42131364f, 0.24404676f, 0.20649734f, 0.10348604f, 0.11647671f, 0.05301675f, 
    -0.14782529f, -0.01796428f, -0.06259978f, -0.18706080f, 0.33287907f, 0.38649684f, 0.21819919f, 0.37208700f, 
    -0.18845810f, 0.02969369f, 0.04178284f, -0.04869943f, 0.01325072f, -0.02402697f, -0.01328858f, -0.11093761f, 
    -0.26061198f, -0.07570104f, 0.05318628f, -0.11737997f, -0.06354874f, 0.06110087f, -0.04599946f, -0.06124358f, 
    -0.02276465f, -0.09222367f, -0.04456006f, 0.04823998f, 0.11701000f, 0.13124815f, 0.25082850f, 0.17814402f, 
    -0.10741124f, -0.06668817f, 0.06502338f, 0.12737770f, 0.08081733f, -0.05096849f, 0.10783979f, 0.02565561f, 
    -0.21324167f, 0.26158103f, -0.41461125f, 0.00589999f, 0.09870728f, -0.26082745f, -0.03097987f, 0.14292143f, 
    -0.10181680f, -0.00569555f, 0.01945190f, 0.04095687f, 0.12294428f, -0.11618652f, 0.18688732f, 0.06314114f, 
    0.06816129f, -0.01918179f, 0.02938108f, 0.13641150f, 0.03980102f, -0.10216917f, 0.30394274f, 0.12364051f, 
    0.25914750f, 0.20184189f, 0.12556192f, 0.19256586f, -0.09521244f, 0.03620960f, -0.00231602f, 0.03263638f, 
    0.02800546f, 0.06010474f, 0.05543634f, 0.03755065f, 0.37731174f, 0.11641447f, 0.13100143f, -0.10172237f, 
    0.09245316f, -0.01873021f, -0.02531598f, 0.00731011f, 0.10569414f, 0.18807489f, 0.21079795f, -0.06881989f, 
    0.01008473f, -0.13675852f, 0.15781021f, -0.10266891f, 0.08336236f, 0.22388218f, -0.02011824f, 0.10142994f, 
    0.04287165f, 0.01580526f, 0.07149030f, -0.11627202f, 0.33597603f, 0.15854546f, 0.39279327f, -0.21472402f, 
    -0.03551925f, -0.01455806f, -0.10911789f, -0.07115970f, -0.09404322f, 0.09969588f, -0.07739069f, -0.03818372f, 
    -0.21019399f, -0.69435269f, -0.24107413f, -0.39049378f, -0.06989776f, -0.11769333f, -0.03394366f, 0.01813561f, 
    -0.13195224f, -0.05636008f, -0.11092731f, -0.19877462f, -0.21045013f, -0.06588898f, -0.43573207f, -0.16660891f, 
    0.01468671f, 0.03708773f, -0.11038415f, 0.05477303f, -0.07215483f, 0.05452902f, 0.05532296f, -0.15476577f, 
    -0.13555875f, 0.08498687f, 0.23207837f, 0.05675296f, -0.01086252f, 0.05343179f, 0.05164358f, 0.03307683f, 
    0.02773259f, -0.00491553f, -0.05546637f, 0.05304486f, -0.12473790f, -0.30696255f, -0.29747587f, -0.01244682f, 
    -0.00564605f, -0.00054656f, 0.27842939f, -0.04878757f, 0.04622758f, 0.08750126f, -0.00847436f, 0.03027564f, 
    -0.38292331f, -0.15064350f, -0.15919310f, 0.26871368f, -0.01490963f, -0.01945832f, -0.03223222f, 0.11650334f, 
    0.02193496f, 0.05108156f, -0.04721294f, 0.02943303f, 0.11327753f, 0.06081140f, 0.10320847f, 0.04752019f, 
    -0.03367954f, 0.13815543f, 0.17937994f, -0.06299113f, 0.03215576f, 0.15264890f, 0.03893255f, 0.09235901f, 
    0.03659458f, -0.03756144f, -0.13349544f, 0.23872800f, 0.11328309f, -0.05233116f, 0.12482393f, 0.19600654f, 
    -0.00902200f, 0.06338319f, -0.04769135f, -0.02258656f, 0.34867713f, 0.23936392f, 0.15519668f, 0.26940808f, 
    -0.06971461f, 0.03040230f, 0.00923318f, -0.08406787f, 0.09413415f, 0.01661249f, -0.01227213f, -0.01024436f, 
    0.15068305f, -0.04794011f, 0.14943816f, 0.09423552f, 0.10588787f, -0.00231374f, -0.05829638f, -0.00310882f, 
    -0.11165161f, -0.09539354f, 0.02600814f, -0.04573403f, 0.14434810f, 0.21922424f, 0.06833036f, 0.09377465f, 
    -0.00292473f, 0.02011626f, 0.14814296f, -0.01235847f, -0.05678955f, 0.01792464f, -0.05054406f, 0.05860259f, 
    -0.17919193f, 0.17763487f, -0.33383080f, -0.14167690f, 0.03681112f, 0.02855879f, 0.18879192f, 0.08949613f, 
    -0.09037653f, 0.04313590f, -0.07213002f, 0.04937841f, -0.06828961f, 0.01786533f, 0.07741673f, -0.00837546f, 
    -0.08643309f, 0.00023131f, -0.02187169f, 0.20717539f, 0.12070968f, -0.06907694f, 0.10009866f, -0.01860414f, 
    0.19254909f, 0.22019574f, 0.29884958f, 0.23012468f, 0.03425267f, 0.07802885f, 0.02738588f, 0.04016321f, 
    0.15311968f, 0.10483781f, 0.05443521f, 0.01513880f, 0.29027951f, 0.02173452f, 0.10976324f, 0.06438217f, 
    0.00917236f, 0.02726980f, 0.09241667f, 0.01810094f, 0.12647940f, 0.11321249f, -0.13485292f, -0.02713127f, 
    0.23287855f, 0.01233417f, 0.13359156f, -0.18274382f, -0.13256003f, -0.01238182f, 0.17165709f, 0.24194963f, 
    -0.00195336f, -0.00735672f, -0.05038958f, -0.02341375f, 0.44313517f, 0.01584278f, -0.22084567f, -0.10070890f, 
    -0.00368743f, -0.02078768f, -0.00393741f, -0.05215929f, -0.04980684f, 0.08886579f, 0.02204730f, -0.07953520f, 
    0.11842272f, 0.19375762f, 0.29214019f, 0.05987563f, 0.05148757f, 0.11192199f, -0.07390580f, 0.06690101f, 
    -0.01717060f, 0.13664721f, 0.05499578f, -0.03971579f, 0.02826097f, 0.14936037f, 0.06757019f, 0.11231257f, 
    -0.09644315f, 0.20030846f, -0.21191110f, 0.12169491f, -0.11134132f, -0.02027106f, -0.04873936f, -0.02500361f, 
    -0.47200873f, 0.18548393f, -0.07397517f, -0.12802836f, -0.10871734f, -0.17972068f, 0.06541575f, -0.02144942f, 
    -0.06721251f, -0.09424648f, -0.01449970f, -0.14042680f, 0.32617506f, 0.28386301f, 0.11906353f, 0.19555818f, 
    0.02370845f, 0.16393980f, 0.15741929f, 0.09418590f, 0.10709081f, -0.00219960f, -0.01846947f, 0.09834816f, 
    0.25842801f, 0.46571121f, 0.18124616f, 0.19600624f, 0.02874772f, -0.08953404f, 0.13936888f, 0.01418827f, 
    0.03112109f, 0.02729605f, -0.02485377f, 0.12540652f, -0.11684387f, -0.00139202f, 0.07397580f, -0.13557144f, 
    -0.04072220f, -0.05379502f, -0.01965985f, 0.04172393f, 0.06540912f, 0.05492334f, 0.22194418f, 0.12114517f, 
    0.19978173f, 0.25318429f, 0.12853312f, 0.21096222f, 0.04098176f, -0.10232680f, 0.18401831f, 0.08269059f, 
    -0.18525648f, -0.04884464f, -0.08356126f, -0.11676562f, -0.09755597f, -0.22331688f, 0.00310184f, 0.09003728f, 
    -0.20591217f, -0.01909266f, 0.01367837f, -0.04532098f, 0.05711370f, 0.00599511f, -0.18211778f, 0.07475229f, 
    -0.56176358f, 0.00572213f, 0.18905628f, -0.15141962f, -0.13658935f, 0.15949298f, -0.11802130f, 0.14329202f, 
    -0.00573473f, -0.04383274f, -0.24048921f, 0.02222138f, 0.13506967f, 0.17301761f, 0.07234451f, 0.09475362f, 
    0.02869582f, 0.08767244f, 0.05907280f, -0.05404712f, 0.15528448f, -0.02323731f, 0.05761101f, 0.02870276f, 
    0.17559798f, 0.11353478f, 0.01799892f, 0.15305610f, -0.00982088f, -0.03473791f, -0.10770231f, 0.11808030f, 
    -0.13239041f, 0.07732870f, 0.00090424f, -0.03128565f, -0.02660535f, -0.13812606f, -0.14637421f, -0.09040455f, 
    0.05081233f, -0.07024487f, -0.15081847f, 0.01915438f, 0.12347067f, -0.20178440f, 0.06783290f, -0.06680884f, 
    -0.17700519f, -0.34131616f, -0.30269578f, 0.04318673f, -0.02626882f, -0.05436768f, 0.04820848f, -0.05614541f, 
    0.07266798f, -0.02443174f, 0.06981062f, 0.10225959f, 0.04033075f, -0.04713619f, -0.08974976f, -0.25754881f, 
    -0.10238727f, -0.10669467f, 0.04525470f, -0.01486640f, 0.03518135f, -0.12188753f, -0.09779920f, -0.07684882f, 
    0.19210915f, 0.09071157f, 0.12928171f, -0.06225653f, -0.02938135f, -0.08978971f, 0.04959094f, 0.32054144f, 
    0.04066135f, 0.00513766f, -0.06025143f, 0.02813198f, -0.11597288f, 0.23006883f, 0.07778443f, -0.01400607f, 
    0.04974278f, 0.06887817f, 0.06014894f, -0.02644199f, -0.04556638f, 0.09036640f, -0.03913472f, 0.06376243f, 
    -0.06867318f, -0.06615167f, -0.05854401f, -0.02465949f, 0.02218432f, -0.04344171f, -0.03665049f, 0.02956771f, 
    -0.03294261f, -0.03473595f, 0.01367149f, -0.05889087f, 0.05993961f, -0.02893561f, -0.04751930f, 0.01926133f, 
    -0.01521363f, 0.01562698f, 0.00736439f, -0.03747657f, -0.00044165f, 0.02788875f, -0.02532934f, 0.05618852f, 
    0.00904075f, 0.06245519f, 0.04614896f, 0.04112372f, -0.06217119f, -0.06417488f, 0.00331084f, 0.00063166f, 
    0.03791929f, -0.06764576f, 0.06320554f, -0.05828452f, 0.05560055f, -0.03873572f, 0.01040171f, -0.02862304f, 
    -0.03696050f, -0.02295677f, -0.05617983f, -0.06650274f, -0.04267742f, 0.03360122f, -0.05511759f, -0.06526563f, 
    -0.06702678f, -0.03588714f, 0.02882963f, -0.05335327f, -0.04878147f, 0.03357815f, 0.02718620f, -0.01747471f, 
    -0.01365201f, 0.01079237f, 0.03215471f, -0.01222583f, -0.05967158f, 0.01294158f, -0.05089384f, 0.04743391f, 
    0.00583672f, 0.05530765f, -0.04478384f, -0.00223104f, 0.02389907f, 0.04287359f, -0.04528682f, -0.04684461f, 
    0.05573417f, -0.03242358f, 0.01218699f, -0.06884725f, -0.06182249f, 0.05855850f, 0.01080248f, 0.00263879f, 
    -0.06182377f, 0.04280469f, 0.00863583f, -0.03994474f, 0.04687787f, -0.04198854f, -0.00649031f, 0.01739880f, 
    -0.00460119f, -0.03217600f, 0.00303354f, 0.03103241f, -0.02601288f, -0.05720154f, -0.03607456f, -0.07854132f, 
    -0.02142620f, 0.02627159f, -0.01828777f, -0.01244317f, -0.06880277f, -0.04903962f, -0.02438353f, -0.06321321f, 
    0.00402552f, -0.04800809f, 0.02306126f, -0.03762446f, 0.01156140f, -0.02823909f, -0.07762214f, 0.00335863f, 
    0.02124096f, 0.06288423f, -0.03965319f, 0.02028990f, 0.06108681f, 0.05591641f, 0.00422258f, 0.00336510f, 
    0.04110200f, -0.06858353f, -0.01995798f, -0.02441135f, -0.02295779f, -0.01581165f, -0.02209608f, -0.03477090f, 
    0.05046721f, -0.03526810f, -0.03415333f, -0.02912308f, -0.04481945f, -0.00560209f, 0.06181513f, 0.04110890f, 
    -0.02503998f, -0.01084898f, 0.00999016f, -0.05185168f, 0.02402317f, 0.03795536f, -0.02301764f, 0.01352711f, 
    -0.04888874f, -0.06841495f, -0.03707942f, -0.03293369f, -0.06416098f, -0.07564804f, 0.00487082f, -0.05880839f, 
    0.04602619f, -0.01996404f, -0.00633029f, 0.03233789f, 0.04758436f, -0.05053627f, -0.01851371f, -0.00222820f, 
    -0.06302498f, -0.04502111f, 0.05951843f, -0.00442620f, 0.03132112f, -0.01291207f, 0.05882283f, -0.01236084f, 
    -0.02664024f, -0.04756081f, 0.03012300f, 0.01907023f, -0.05269017f, 0.01933629f, -0.01406043f, -0.03970116f, 
    -0.06962544f, -0.03808222f, 0.00312315f, 0.03258011f, -0.04057467f, -0.04283031f, -0.03938447f, -0.06344137f, 
    -0.02726013f, 0.02714755f, -0.02849268f, -0.03974015f, -0.05735592f, -0.02136819f, 0.03529026f, -0.02137941f, 
    -0.22473350f, -0.08855841f, 0.05378076f, -0.27343008f, 0.04450475f, -0.05542198f, -0.07046439f, 0.01975084f, 
    -0.10431148f, 0.08883721f, 0.08506408f, 0.25016823f, 0.06745256f, 0.14456125f, -0.24724558f, -0.05264519f, 
    0.06525436f, 0.02428866f, -0.13906899f, -0.00378778f, 0.06168003f, -0.02458674f, -0.02741843f, 0.24205923f, 
    -0.16287933f, 0.08927428f, -0.07641850f, -0.17676169f, -0.02434769f, -0.18949293f, -0.01717543f, 0.04607598f, 
    0.16806978f, -0.06234016f, 0.03494390f, 0.14844066f, 0.06970480f, 0.17400703f, -0.06180358f, -0.07552212f, 
    0.04363132f, -0.10017062f, -0.08911245f, -0.09766564f, -0.03369971f, -0.09845666f, -0.20450088f, -0.12003887f, 
    0.43012032f, 0.20857498f, 0.22108008f, -0.03653130f, 0.12835056f, -0.04981345f, 0.11018479f, -0.13301365f, 
    0.03021893f, 0.11579946f, 0.14432192f, 0.12419488f, -0.20641805f, 0.04900891f, -0.38045985f, -0.30942643f, 
    0.05990790f, 0.07130892f, -0.06203828f, -0.16184467f, 0.02473248f, 0.03614936f, 0.00190355f, 0.00397838f, 
    0.43091321f, 0.32353994f, 0.10316889f, 0.21682565f, -0.06677875f, -0.02817826f, 0.11718485f, 0.14317998f, 
    0.15792884f, -0.05987201f, 0.04019335f, -0.00728558f, -0.01813447f, -0.13714230f, -0.00421567f, 0.33344194f, 
    -0.00418052f, 0.07527801f, -0.08206788f, -0.05779938f, -0.00625465f, -0.10498976f, -0.07658079f, -0.15073642f, 
    0.23232119f, -0.50972545f, 0.55068600f, 0.10828051f, 0.02520761f, 0.09688571f, 0.07323591f, -0.01858088f, 
    -0.00720820f, -0.20893735f, -0.01374573f, -0.16836545f, -0.06558538f, -0.03836451f, -0.09850075f, 0.20046037f, 
    0.11236009f, 0.07370385f, -0.24419460f, -0.06646503f, -0.34483656f, -0.11820236f, -0.23968543f, -0.19017339f, 
    0.06611349f, 0.29968515f, 0.05009040f, -0.11122120f, 0.07945697f, -0.02473860f, 0.00172565f, 0.10807823f, 
    0.05693410f, 0.09572451f, -0.02716455f, 0.08588489f, -0.15253513f, -0.08444732f, -0.13500270f, -0.02214057f, 
    0.03782417f, 0.14127524f, 0.16474260f, 0.17719153f, 0.03153208f, 0.29668212f, 0.11218070f, -0.05370615f, 
    -0.05139265f, -0.07583711f, 0.08951981f, 0.01296428f, 0.11250150f, 0.09305272f, 0.00435939f, -0.02416489f, 
    0.10703471f, -0.12043193f, 0.01857954f, -0.07285532f, -0.09098566f, -0.35382318f, -0.08266607f, -0.00242768f, 
    -0.05785047f, 0.16160013f, -0.13975553f, 0.05598935f, 0.13539459f, -0.06437971f, 0.19445480f, 0.03797204f, 
    0.13788866f, -0.12658840f, 0.17947675f, 0.17568436f, 0.03976209f, 0.15701221f, -0.01405512f, 0.08509278f, 
    -0.08707697f, -0.10312164f, -0.11139889f, 0.03467019f, 0.00907450f, -0.07527750f, 0.34371346f, 0.18242013f, 
    -0.02118366f, -0.10600197f, -0.11043843f, -0.10976017f, 0.11518929f, 0.01525812f, -0.00754796f, -0.05295366f, 
    0.23329967f, -0.19088040f, -0.24188446f, -0.08825932f, 0.12555970f, 0.13819273f, 0.20380484f, 0.20302509f, 
    0.05852005f, -0.17462611f, -0.13202010f, -0.24308373f, 0.19423819f, 0.14364998f, 0.14261080f, 0.00883211f, 
    0.07410835f, 0.12491312f, 0.16348131f, 0.14590494f, 0.00748234f, -0.05226542f, -0.11168467f, -0.06282968f, 
    -0.15633343f, 0.13469261f, 0.00341273f, 0.14194141f, 0.04568207f, -0.07299544f, -0.06495020f, 0.04241388f, 
    -0.06397276f, -0.14935544f, 0.17587107f, -0.08930095f, -0.00104365f, 0.12004916f, 0.07184038f, 0.15533523f, 
    0.06428599f, 0.10841978f, 0.09798244f, -0.04615935f, 0.04613063f, 0.10049325f, 0.13563839f, 0.13518548f, 
    0.16181089f, 0.14286137f, -0.09782375f, -0.14848466f, -0.00780395f, 0.03432472f, 0.06898710f, 0.10216033f, 
    -0.00738594f, -0.09024560f, -0.10634203f, -0.11940241f, 0.03230922f, -0.08201812f, 0.03532384f, -0.03265870f, 
    -0.09552500f, 0.01166919f, -0.03096548f, 0.00090082f, -0.05582813f, 0.03509843f, -0.01509690f, 0.04055471f, 
    0.09659760f, 0.14294411f, 0.13438542f, -0.10843196f, 0.17517486f, 0.16584156f, -0.02329308f, 0.13335501f, 
    0.06455299f, 0.07822882f, 0.14460693f, 0.05252571f, -0.07849157f, 0.11877002f, 0.03986464f, 0.12640779f, 
    0.02062753f, -0.09305564f, 0.00708674f, 0.10035013f, -0.04074910f, 0.03543425f, 0.14871299f, 0.23892495f, 
    -0.02500684f, 0.23752183f, 0.34478259f, -0.18393347f, -0.04843518f, -0.02548296f, 0.10034561f, 0.00854294f, 
    0.04078903f, 0.02237239f, -0.03002875f, 0.08541579f, -0.14181177f, 0.07242132f, 0.14672630f, 0.02654782f, 
    -0.11981865f, 0.04149409f, 0.04865034f, -0.04961269f, 0.00258757f, 0.19393262f, 0.13044922f, 0.06088119f, 
    0.01046965f, 0.05022940f, -0.12895893f, -0.06899032f, 0.11507007f, -0.02536357f, 0.15372561f, -0.03039207f, 
    0.00371261f, -0.01225854f, 0.02293881f, 0.06078975f, 0.05634059f, -0.27971494f, -0.20287104f, -0.13820727f, 
    -0.02909199f, -0.01340853f, -0.10948882f, 0.01047419f, -0.05030418f, -0.33234012f, -0.08929209f, -0.20617808f, 
    -0.04724477f, -0.06376634f, 0.00564482f, 0.00140386f, -0.01743666f, -0.11588690f, -0.05903009f, -0.03657345f, 
    -0.01058132f, 0.10352518f, -0.03513356f, 0.01441645f, 0.11790393f, 0.00822371f, -0.15492944f, -0.10027960f, 
    -0.01764090f, 0.00480275f, 0.00843708f, -0.06134098f, 0.06275792f, -0.08641784f, -0.34759060f, -0.12375536f, 
    0.32918629f, 0.09549588f, 0.08949552f, -0.12381581f, -0.04859801f, -0.40131703f, 0.11476957f, 0.20221220f, 
    0.01270296f, -0.04608151f, 0.00516303f, -0.00512867f, 0.02534104f, 0.15598594f, 0.04398182f, -0.22288442f, 
    -0.17162853f, -0.02254248f, 0.16162705f, 0.06044535f, 0.11384024f, 0.06809779f, 0.03002240f, -0.04276303f, 
    0.05075971f, -0.16438179f, 0.00398983f, -0.04908441f, -0.06496105f, -0.01104814f, 0.12864801f, 0.09010136f, 
    -0.01177246f, -0.04752525f, 0.06457675f, 0.06398392f, 0.07984846f, -0.08536150f, -0.10941678f, 0.08130555f, 
    -0.00542186f, -0.07703430f, 0.22617295f, -0.08751690f, 0.19911146f, -0.14544958f, -0.01164426f, 0.07026689f, 
    0.24316365f, -0.18584692f, -0.00935901f, 0.02060622f, -0.01844929f, 0.08512620f, -0.14167558f, -0.07696211f, 
    -0.06904760f, 0.09015624f, 0.04012227f, 0.07568190f, -0.27691558f, -0.17906940f, -0.16617170f, -0.13379611f, 
    0.02200390f, -0.16286363f, 0.00195504f, 0.04241484f, -0.05028188f, -0.03109276f, -0.00678513f, -0.04936706f, 
    -0.09691556f, -0.34656066f, -0.08274075f, -0.17426324f, -0.15290685f, 0.01590904f, -0.03474940f, 0.14667541f, 
    -0.02313541f, 0.04980111f, 0.00658461f, -0.06463901f, -0.10490017f, -0.02766209f, -0.10775718f, -0.06281430f, 
    0.08130918f, 0.13491695f, 0.09822311f, 0.08152389f, 0.10338421f, 0.11274834f, 0.06652979f, 0.02135871f, 
    -0.13020842f, -0.16511989f, -0.18837622f, -0.15427671f, 0.07327631f, 0.05737361f, 0.02907885f, 0.11025933f, 
    0.15461056f, 0.10681619f, 0.01442654f, 0.11825316f, 0.10447772f, 0.18826900f, -0.12571400f, 0.09946595f, 
    0.03618060f, -0.13063061f, 0.00416147f, 0.04546228f, -0.10559215f, -0.03008742f, 0.01468797f, -0.01982118f, 
    0.73006493f, -0.04993300f, -0.11980963f, 0.05007516f, 0.28090256f, 0.02808279f, 0.05189618f, -0.15871617f, 
    0.19608366f, 0.04216931f, 0.07395339f, -0.12464331f, -0.02166163f, -0.14503776f, -0.17763777f, -0.22012855f, 
    0.06332774f, 0.05389316f, -0.10090207f, 0.05937116f, -0.02626007f, 0.07919911f, 0.01546102f, 0.05255767f, 
    -0.06503563f, -0.02369329f, -0.05345372f, -0.15533668f, 0.00669214f, 0.03663902f, 0.16632944f, 0.05141319f, 
    0.09912392f, -0.13027866f, -0.03096121f, 0.09706153f, -0.19023621f, 0.06989394f, 0.12353440f, 0.04769383f, 
    -0.03763476f, 0.09558127f, 0.08553357f, 0.15447840f, 0.01533257f, 0.41996816f, 0.08190083f, 0.08571998f, 
    -0.06357529f, 0.12213905f, 0.04883903f, -0.18599582f, -0.01529780f, -0.01534703f, 0.04174319f, -0.03304614f, 
    -0.10047136f, 0.04729209f, 0.00807198f, 0.07293979f, -0.22490244f, -0.04884181f, 0.06538912f, 0.05060652f, 
    -0.09721337f, 0.00759819f, -0.12776977f, -0.09648225f, 0.04072518f, 0.32154503f, 0.15528180f, 0.17837244f, 
    -0.03922795f, -0.14398721f, 0.11800552f, 0.07077929f, 0.08017921f, 0.15141743f, -0.00895443f, -0.21690854f, 
    -0.03384791f, -0.07399774f, 0.04786735f, 0.04253287f, 0.07859477f, -0.23310791f, 0.04949429f, 0.21473373f, 
    0.02076802f, -0.12918554f, -0.07277964f, 0.10369339f, 0.22430699f, 0.16869056f, 0.23393095f, 0.07114992f, 
    -0.09945784f, -0.45991042f, -0.53050774f, -0.38242823f, -0.03553157f, -0.05856225f, 0.04141994f, 0.15654987f, 
    -0.02624026f, 0.03721005f, -0.04689988f, -0.11770570f, 0.23002826f, 0.36367923f, -0.07383435f, -0.01378901f, 
    0.19396524f, 0.00944229f, 0.01965448f, 0.04427581f, -0.02635598f, 0.08358020f, 0.03386083f, 0.02414370f, 
    -0.06079154f, 0.18209700f, 0.12513529f, 0.19066569f, 0.04597799f, -0.06050421f, -0.00648144f, 0.03210316f, 
    -0.03361149f, -0.02878764f, 0.11594189f, -0.00853269f, 0.02259816f, -0.01491838f, -0.07636546f, 0.07471778f, 
    0.02474589f, 0.10674831f, 0.09100316f, -0.03761031f, 0.00341191f, 0.05102509f, 0.08321285f, 0.02677557f, 
    -0.13629551f, -0.01240531f, -0.09283481f, 0.03857109f, 0.10871276f, -0.05503626f, 0.02027793f, 0.15626034f, 
    -0.00200430f, 0.05354148f, 0.04328777f, -0.05368063f, -0.10175455f, 0.06374604f, -0.04054524f, -0.07621615f, 
    0.00433704f, 0.18954526f, 0.07942797f, -0.12385548f, -0.16405714f, 0.10289183f, 0.12386821f, 0.14682232f, 
    0.17797226f, 0.13027172f, 0.13757990f, 0.17020448f, -0.05284222f, -0.02089693f, -0.03703187f, 0.09200555f, 
    0.04027290f, 0.11249965f, 0.03113053f, -0.02209330f, 0.10339702f, 0.00917111f, 0.24832256f, 0.30671573f, 
    -0.07179649f, 0.07764843f, -0.09932947f, -0.01024303f, -0.08327755f, -0.02013617f, -0.01396923f, 0.02216327f, 
    0.27777854f, -0.19265029f, 0.25674957f, -0.07336132f, 0.28158775f, 0.12536351f, 0.01762995f, -0.09327998f, 
    -0.01109683f, 0.08858037f, 0.01671146f, -0.01608359f, -0.13687812f, 0.18535587f, 0.08740851f, -0.00388342f, 
    0.02237846f, 0.09214298f, -0.04686113f, 0.05023384f, -0.12567939f, 0.03816640f, 0.05121209f, -0.07403517f, 
    0.28744149f, 0.30692035f, 0.02230561f, -0.13188632f, 0.01455278f, 0.06865418f, 0.04135679f, 0.00260072f, 
    -0.04336221f, -0.02634912f, -0.10167903f, 0.10195923f, -0.00682254f, 0.21801367f, 0.04813080f, 0.20624706f, 
    -0.05083559f, 0.02241122f, -0.05188622f, 0.13755961f, 0.06648158f, -0.16296124f, -0.00829950f, -0.08533457f, 
    0.18267670f, -0.03221056f, 0.17437093f, -0.01906397f, -0.10862613f, 0.00518389f, -0.04556701f, -0.06714999f, 
    -0.02839610f, -0.06676625f, 0.05039766f, -0.02618326f, 0.17253268f, 0.03673611f, 0.02563094f, 0.14884499f, 
    -0.01893468f, 0.04383968f, -0.01001738f, -0.05899515f, 0.08816356f, -0.03611612f, -0.09013154f, -0.14297234f, 
    -0.00721165f, 0.13734907f, -0.16224204f, -0.02541645f, -0.03745832f, 0.05706838f, 0.00326215f, -0.01344527f, 
    -0.03414626f, -0.03014233f, 0.03011637f, 0.04670153f, 0.05765076f, 0.05157635f, -0.12149364f, -0.12936372f, 
    -0.09140573f, -0.07688446f, 0.04614586f, -0.03849100f, 0.03735627f, -0.09961125f, 0.06548005f, 0.05376013f, 
    -0.03730391f, 0.18845826f, 0.12016869f, 0.16475223f, 0.24807025f, 0.07897341f, -0.08161236f, -0.28145462f, 
    -0.08495726f, 0.09302676f, -0.04947021f, 0.03419043f, -0.05451680f, 0.16235864f, -0.13104676f, -0.06767054f, 
    -0.00786340f, 0.07377388f, -0.12071560f, 0.04312751f, -0.05728167f, -0.03357715f, -0.00602426f, 0.08879589f, 
    -0.10256094f, 0.09224658f, -0.06706126f, -0.10386758f, 0.02191735f, 0.03134324f, 0.18242140f, -0.07037842f, 
    -0.00163201f, 0.07320919f, 0.00794591f, -0.08135267f, 0.13456602f, 0.11145838f, 0.03496710f, 0.05468135f, 
    0.07059383f, 0.06974899f, -0.03390433f, -0.17261213f, 0.05452281f, -0.03005995f, 0.03782972f, 0.07556956f, 
    0.14574386f, 0.18769732f, -0.11622763f, -0.04777553f, 0.08464513f, 0.12455833f, 0.00388305f, -0.02511974f, 
    -0.08555084f, 0.07870333f, 0.09597897f, 0.01115311f, 0.00836855f, 0.00620955f, 0.04061079f, -0.04234982f, 
    0.10139714f, -0.05436403f, -0.00138082f, -0.07551114f, 0.07329820f, 0.11418249f, 0.08215140f, -0.12132213f, 
    0.13202672f, -0.02543896f, 0.05057920f, -0.01794501f, 0.10047688f, 0.11998436f, 0.09792556f, 0.03932914f, 
    -0.08618084f, -0.09993897f, 0.07182933f, 0.11084920f, 0.18416107f, 0.06653570f, -0.06277353f, -0.04306814f, 
    0.02813568f, -0.15127434f, 0.10066944f, 0.00342354f, 0.02898713f, -0.00897281f, 0.01256922f, 0.05107927f, 
    -0.48356211f, 0.06027778f, 0.01059899f, -0.06201175f, -0.33006501f, -0.12901354f, -0.00801588f, 0.28836057f, 
    -0.05621638f, -0.15528251f, -0.01770739f, 0.11149912f, 0.16646133f, 0.12731425f, -0.09813026f, 0.09622864f, 
    0.08725204f, 0.01128718f, 0.01943711f, -0.05017756f, 0.01996001f, -0.02461960f, -0.02301740f, -0.14916351f, 
    0.13970818f, -0.18790860f, -0.03556659f, 0.17954844f, 0.11124782f, -0.13183683f, -0.13545036f, 0.06152817f, 
    -0.05111174f, 0.05067812f, 0.02675745f, -0.05839369f, 0.08088011f, -0.18533260f, -0.23649292f, -0.12207896f, 
    0.06043572f, 0.01595519f, 0.09688341f, -0.05067496f, -0.00112814f, 0.15898433f, 0.00015983f, -0.12302963f, 
    -0.12444494f, -0.16731767f, -0.20434129f, 0.06594463f, 0.02411313f, 0.05271388f, -0.01847340f, -0.05692536f, 
    0.04141039f, 0.11729509f, 0.04948095f, 0.08489607f, 0.06096316f, 0.04385768f, -0.25508496f, 0.05735513f, 
    0.02966720f, 0.02756688f, 0.02260047f, -0.01267075f, -0.09318005f, -0.06494807f, -0.02023383f, -0.07863299f, 
    -0.02002066f, 0.11791318f, -0.01663187f, 0.25716740f, -0.18736359f, -0.12983240f, -0.04350614f, 0.10365444f, 
    -0.10313085f, -0.04777509f, -0.07687340f, 0.11234202f, -0.17132585f, 0.05624409f, 0.06649251f, -0.02128339f, 
    -0.01049566f, -0.03527200f, -0.02189380f, -0.00339299f, 0.04195010f, 0.00900129f, -0.13363311f, -0.04273596f, 
    -0.02191528f, -0.32035664f, -0.48458716f, -0.03451028f, 0.09795976f, -0.04497305f, 0.05596073f, 0.17025082f, 
    0.03951273f, 0.04369402f, 0.02321743f, -0.01823683f, 0.31739217f, 0.23276365f, -0.16278656f, -0.11438629f, 
    0.19305265f, 0.05985830f, 0.12890786f, -0.00000206f, 0.01578785f, -0.07943179f, -0.01894532f, 0.02833017f, 
    -0.14517875f, 0.29689845f, 0.13030252f, 0.26916397f, 0.02911744f, -0.04249328f, -0.07910111f, -0.04156571f, 
    -0.12905677f, -0.03475000f, 0.12344278f, -0.08568985f, 0.06025086f, -0.16609930f, -0.04600247f, 0.07780416f, 
    -0.00186890f, 0.09750592f, 0.06359742f, 0.01249039f, 0.00090104f, 0.01194214f, 0.11876634f, 0.10750698f, 
    0.06783308f, 0.05801329f, -0.22364423f, -0.09937682f, 0.11722340f, 0.17530893f, 0.03752032f, 0.14076987f, 
    -0.13296328f, 0.04939326f, 0.07129142f, -0.10001315f, -0.16360898f, -0.01755811f, -0.03355627f, -0.08730726f, 
    -0.04212562f, 0.05357423f, -0.03929193f, -0.00013646f, -0.08344764f, 0.11563246f, 0.08592675f, 0.09035812f, 
    0.15416084f, -0.03532077f, 0.09321735f, -0.08331764f, 0.09139565f, 0.07389410f, -0.05562869f, 0.06468567f, 
    0.04006009f, 0.08823434f, 0.05773979f, 0.10634777f, 0.02524466f, 0.08553994f, 0.13918239f, 0.15365465f, 
    -0.00353791f, -0.03401279f, -0.00775480f, -0.02053574f, -0.06395296f, 0.06695259f, 0.02514588f, 0.21763961f, 
    0.36818528f, 0.23816669f, 0.36494613f, -0.29265654f, 0.18641089f, 0.06494169f, -0.08590963f, -0.07052164f, 
    0.04758757f, 0.07136380f, -0.09735623f, -0.01292596f, -0.13304092f, -0.01914086f, -0.01907103f, -0.12868918f, 
    0.12469583f, 0.12164751f, 0.00214085f, -0.04415161f, -0.06342784f, 0.27149421f, 0.07678825f, 0.24985726f, 
    0.32220960f, 0.09245250f, 0.01553298f, 0.10265822f, 0.03743307f, 0.10433748f, 0.13721003f, -0.10751610f, 
    -0.02565752f, 0.05826567f, -0.00491351f, 0.09981036f, -0.21839170f, -0.01623104f, -0.11978360f, 0.32513919f, 
    0.01024026f, 0.07301748f, 0.00977582f, 0.16829918f, -0.01749808f, -0.09858593f, -0.02679635f, -0.25899115f, 
    -0.13528639f, -0.00455208f, 0.09492609f, 0.03062632f, -0.17811225f, -0.10768489f, -0.00755149f, -0.08432875f, 
    -0.11744410f, -0.08438113f, -0.07295551f, 0.02508690f, -0.13664351f, -0.01355792f, 0.05536901f, 0.18693627f, 
    -0.02453016f, -0.07578509f, -0.05221820f, -0.08465067f, 0.07670221f, 0.01457789f, -0.10311321f, -0.09395215f, 
    0.24923392f, 0.28460622f, -0.18060775f, -0.08481056f, -0.07881822f, -0.03564251f, 0.13431714f, -0.00295847f, 
    0.01655116f, -0.15792474f, -0.07379659f, 0.02200365f, 0.09543712f, 0.22377345f, -0.16705155f, -0.20274377f, 
    -0.11879498f, -0.10727575f, 0.08721035f, -0.10131025f, 0.12071185f, 0.01187497f, 0.06964727f, 0.17663379f, 
    0.03328289f, 0.50350046f, 0.23960808f, 0.33359528f, -0.16266322f, -0.01160059f, 0.18083781f, -0.13661788f, 
    0.03260627f, 0.05798502f, 0.07107884f, 0.10824244f, 0.12118413f, -0.25174266f, -0.01647615f, -0.15162523f, 
    0.13027744f, 0.10336178f, -0.03509125f, 0.11015593f, 0.11079098f, 0.21924013f, 0.00558443f, 0.04228887f, 
    -0.19090557f, 0.07467049f, 0.08319669f, 0.12751149f, 0.02044290f, 0.00743675f, 0.08989717f, -0.12272707f, 
    -0.12831815f, 0.11760809f, 0.02456242f, 0.24612932f, -0.08252138f, 0.05189292f, -0.10333616f, -0.00064182f, 
    -0.01576794f, -0.11122829f, 0.02906042f, -0.14042270f, -0.22120352f, -0.15912214f, -0.14037935f, -0.18548164f, 
    0.01881854f, 0.19884260f, -0.00113753f, -0.07904155f, -0.10766626f, -0.08153300f, -0.11498530f, 0.08919965f, 
    0.10755097f, 0.13556215f, 0.01979697f, 0.05802014f, -0.08328059f, -0.06668865f, 0.29521900f, -0.12622108f, 
    -0.08093872f, -0.40323839f, -0.21344136f, 0.02529526f, -0.08212345f, -0.29318872f, -0.05006224f, -0.16128992f, 
    -0.00661061f, -0.22015662f, -0.05933905f, -0.02250170f, 0.04785104f, 0.20806633f, -0.04154655f, 0.03593103f, 
    -0.00802549f, 0.01279818f, -0.07385369f, 0.02635767f, -0.13014729f, 0.04983922f, 0.14777510f, -0.20844351f, 
    -0.16493590f, 0.18227144f, -0.18163635f, -0.08035556f, -0.12661028f, -0.23539542f, -0.08133567f, -0.08231734f, 
    -0.30754867f, 0.17674842f, 0.08310546f, -0.06458326f, -0.09763772f, 0.04536622f, -0.04494864f, 0.07244123f, 
    -0.01087305f, -0.21475026f, 0.06342758f, -0.06870105f, 0.10970456f, -0.08197600f, 0.04957555f, 0.14764096f, 
    0.01944259f, -0.16236362f, -0.10503784f, -0.17577052f, 0.04249490f, -0.20104124f, -0.17641348f, -0.02495380f, 
    0.06128627f, -0.21364048f, -0.07176188f, 0.21618755f, 0.31056231f, 0.05834216f, 0.13235058f, 0.20651436f, 
    0.04685891f, -0.09381957f, 0.16001436f, 0.00627112f, -0.04507404f, 0.10741019f, 0.20709111f, 0.19493678f, 
    0.20421632f, -0.14055115f, 0.13628483f, -0.10207219f, 0.11116641f, 0.27813557f, 0.13145612f, 0.23544019f, 
    0.09346958f, -0.04355572f, -0.05624244f, -0.03674876f, -0.09835908f, -0.12408287f, -0.30203381f, -0.25136697f, 
    -0.23434260f, -0.33152914f, -0.09906195f, 0.24291779f, -0.06378137f, 0.20561218f, 0.08888245f, -0.01168225f, 
    -0.10441508f, -0.19102764f, 0.08591063f, -0.22171144f, 0.14228134f, 0.08983286f, 0.18859451f, 0.11640634f, 
    0.11867936f, 0.21016443f, -0.09927603f, 0.14431989f, 0.22835416f, 0.03926324f, 0.09286333f, -0.02046883f, 
    -0.04331340f, -0.06220150f, 0.17860186f, 0.01574761f, 0.31017464f, 0.36012527f, 0.19825475f, -0.08786694f, 
    -0.15251610f, 0.02419797f, -0.24025548f, 0.18459304f, 0.06357720f, 0.07285435f, 0.03851535f, -0.16167937f, 
    -0.02842692f, 0.23710975f, 0.44799119f, 0.14269671f, -0.03404521f, 0.03142942f, -0.02079789f, -0.12844639f, 
    -0.04423963f, 0.06059759f, 0.16712008f, 0.36172912f, -0.06732361f, -0.27344713f, 0.00170711f, 0.01439932f, 
    -0.07944342f, 0.03328507f, 0.02590349f, -0.03902334f, -0.01642683f, -0.01781169f, 0.09632183f, 0.01096377f, 
    0.15895250f, -0.23952326f, -0.04867622f, -0.25486627f, -0.04136260f, 0.03461999f, 0.08363829f, -0.02714849f, 
    0.08864871f, 0.11759873f, -0.13759789f, 0.09087974f, -0.03837942f, -0.07590585f, -0.06563605f, -0.18019846f, 
    0.05319109f, -0.08482191f, -0.08215068f, 0.15284234f, -0.05364243f, -0.06075611f, 0.01151403f, -0.05369388f, 
    0.14810543f, -0.04714769f, 0.16190737f, -0.00295182f, 0.03886883f, 0.00047798f, -0.07132877f, -0.15867949f, 
    -0.03613472f, -0.05875789f, 0.04922421f, -0.05374536f, 0.09521279f, -0.07285696f, -0.05754818f, 0.05667099f, 
    0.15013549f, -0.01135827f, 0.12268275f, 0.14260058f, 0.20930901f, 0.06095471f, -0.07609403f, -0.14407970f, 
    -0.05615824f, -0.20093255f, -0.17912188f, -0.09287633f, 0.07932805f, -0.02790955f, -0.06240532f, -0.05855117f, 
    -0.03317783f, -0.08037643f, -0.05649365f, 0.00505282f, 0.11516491f, 0.02283723f, -0.05455477f, -0.16845614f, 
    0.03557080f, 0.06489222f, 0.04280584f, -0.00900760f, -0.05311281f, -0.04567623f, 0.01608450f, -0.01660969f, 
    0.19056071f, 0.00811037f, -0.25793642f, 0.08080687f, -0.22085106f, -0.04766400f, -0.07036104f, 0.05870231f, 
    -0.09373414f, -0.13456406f, 0.01049940f, 0.10734245f, 0.26529658f, -0.14648701f, -0.26361793f, 0.09389779f, 
    0.11854907f, -0.08213526f, 0.02398883f, -0.05923486f, 0.10459125f, -0.11154081f, -0.07604955f, 0.06948229f, 
    -0.13178621f, -0.09502614f, 0.16150162f, 0.32038373f, 0.01829120f, -0.00501997f, -0.09398136f, 0.04472334f, 
    -0.03238801f, -0.06016243f, -0.03079459f, -0.07332885f, -0.08499168f, -0.08941846f, 0.05809587f, -0.04929034f, 
    0.12224949f, -0.02564157f, 0.11049859f, -0.02631226f, 0.07447636f, 0.38684040f, 0.04611963f, 0.18689963f, 
    -0.05605632f, 0.04721998f, 0.04714506f, 0.03582254f, 0.02548948f, 0.13030249f, 0.05587151f, -0.01444795f, 
    0.11126123f, 0.05864897f, -0.04030047f, -0.07028208f, -0.14427194f, -0.03785544f, 0.08098183f, 0.06580271f, 
    0.06265230f, -0.05649173f, -0.05118432f, -0.00619145f, -0.00028752f, 0.07714596f, 0.25341666f, 0.14964530f, 
    -0.12871857f, 0.02382268f, 0.14671935f, 0.28798899f, 0.18858625f, 0.23616284f, 0.00584870f, -0.03284158f, 
    -0.13343780f, 0.04267165f, 0.05817545f, 0.09659428f, 0.07996515f, -0.11166723f, 0.06943578f, 0.26170540f, 
    0.14509965f, 0.03258946f, -0.04881593f, 0.02810391f, -0.02041871f, 0.08809564f, -0.06584065f, 0.06865837f, 
    0.20494267f, -0.44759873f, 0.02965161f, 0.00649032f, 0.02551442f, 0.10831536f, 0.15009807f, 0.01468087f, 
    0.13930273f, -0.09642164f, -0.04660538f, -0.07446354f, 0.26950723f, 0.09535585f, 0.16747509f, 0.01426377f, 
    0.09854544f, -0.01627939f, 0.16776979f, -0.05851828f, 0.07573020f, 0.01162650f, 0.00655115f, -0.12964815f, 
    -0.05736371f, -0.10395745f, 0.22124103f, 0.01033013f, -0.02911953f, -0.06843036f, -0.31429696f, -0.16641037f, 
    0.02582167f, -0.08477159f, -0.21723545f, 0.00125632f, -0.01423094f, -0.04196354f, -0.19339177f, 0.11417358f, 
    0.04603437f, 0.11024389f, 0.19128111f, 0.09139836f, -0.07639028f, 0.09071617f, 0.04221726f, 0.09686807f, 
    0.04307860f, -0.13321443f, -0.07610671f, 0.03579311f, -0.04825969f, 0.07258166f, 0.13584530f, 0.15488507f, 
    -0.04968000f, -0.08639897f, 0.02031444f, -0.02309804f, 0.07572667f, -0.07934095f, -0.03964294f, -0.13793541f, 
    -0.13283394f, -0.09174205f, -0.09824909f, -0.02406929f, 0.05495631f, 0.04500945f, -0.03675149f, -0.03834023f, 
    -0.04495245f, -0.19434609f, 0.05719325f, -0.11871704f, -0.00004401f, -0.00277821f, -0.03540473f, 0.07789706f, 
    -0.04099189f, 0.05565546f, -0.08755071f, 0.03223087f, -0.12870450f, 0.21272328f, 0.11157668f, -0.13778374f, 
    0.02898896f, 0.02264254f, -0.09557444f, 0.03105924f, 0.02870482f, 0.05838409f, 0.00155042f, 0.05320319f, 
    0.21765050f, 0.08699954f, 0.01055836f, 0.01433198f, 0.16022347f, 0.01917380f, 0.10616568f, -0.20366836f, 
    0.04055926f, 0.06302262f, -0.11420812f, -0.01398353f, -0.04571015f, -0.19688113f, -0.15775697f, -0.09814949f, 
    0.11622484f, -0.11443060f, 0.19721931f, -0.01038984f, 0.06220796f, 0.10654945f, -0.06712566f, 0.21661158f, 
    0.21052979f, 0.11629016f, -0.17747976f, 0.11745195f, 0.07102504f, -0.13636269f, 0.20816326f, -0.03601073f, 
    0.04269703f, -0.04526100f, -0.05256834f, 0.10973521f, 0.01419712f, 0.07860564f, 0.18799295f, 0.05155247f, 
    -0.12592191f, -0.02613869f, -0.06110806f, -0.00815502f, 0.06171238f, 0.01998029f, 0.06471227f, -0.06261329f, 
    -0.15344809f, 0.04182019f, 0.09996172f, -0.09088782f, -0.09433926f, -0.06824628f, -0.13688006f, 0.03050813f, 
    -0.04404278f, -0.07783130f, 0.05075204f, -0.12703793f, 0.14078990f, 0.07289902f, 0.21495691f, 0.05119386f, 
    -0.04674806f, -0.14273563f, -0.04910171f, -0.10317953f, 0.11770333f, 0.14808504f, 0.07024948f, 0.09211722f, 
    0.23112036f, 0.18891016f, 0.04607368f, -0.25015089f, 0.03970017f, -0.07112343f, 0.05641637f, 0.11680972f, 
    -0.03554158f, 0.02667182f, 0.13788418f, -0.01796657f, 0.29199985f, -0.03866887f, -0.12434740f, -0.17483369f, 
    -0.04136392f, -0.00032686f, -0.04025289f, 0.04692885f, 0.01380349f, 0.04948919f, 0.02910488f, 0.00050962f, 
    0.15670045f, -0.21199779f, 0.10222369f, -0.16613245f, 0.04583617f, 0.03099669f, -0.10317807f, 0.04535845f, 
    0.09073550f, -0.06820036f, -0.03554616f, 0.10572967f, -0.15612255f, -0.03422153f, -0.23099191f, 0.09708224f, 
    -0.12141497f, 0.02094840f, -0.11017077f, 0.01419727f, 0.07529452f, -0.06564305f, -0.04036212f, 0.07202715f, 
    0.00267782f, -0.09592656f, 0.11561956f, -0.31008273f, 0.12275907f, -0.03404478f, 0.19067194f, 0.04746191f, 
    -0.06766081f, -0.10615620f, 0.09118124f, -0.11116520f, -0.02815874f, -0.13894542f, -0.04851707f, -0.04490259f, 
    -0.00714888f, 0.04989070f, 0.01344529f, -0.00338619f, 0.14215961f, 0.02629140f, 0.17140752f, 0.07951889f, 
    0.22932854f, 0.28764114f, 0.15634295f, -0.14307739f, -0.09721606f, 0.09939243f, 0.06141973f, 0.07200066f, 
    0.00093897f, -0.03208682f, 0.10581549f, -0.14381737f, -0.03568770f, -0.15690207f, 0.01171461f, -0.16899608f, 
    0.01474347f, 0.03043396f, 0.00981343f, -0.05930682f, 0.07450921f, 0.15785909f, 0.05573590f, -0.02461388f, 
    0.06326479f, 0.31284183f, -0.10753557f, -0.08613361f, 0.00587238f, 0.03503736f, 0.15803827f, -0.01073882f, 
    0.09234338f, -0.01232739f, 0.19463253f, 0.01642154f, -0.06865498f, 0.00223384f, -0.33023247f, 0.24779183f, 
    0.07140137f, -0.10792593f, 0.06922432f, 0.07046109f, 0.09553844f, 0.00492809f, 0.04099376f, 0.13123032f, 
    0.11822688f, -0.19179016f, 0.13130601f, 0.07464379f, 0.07463593f, 0.06123483f, -0.02441490f, 0.01337271f, 
    -0.00385135f, -0.08976085f, 0.02607274f, 0.06859683f, 0.00444500f, -0.00732813f, -0.03778355f, 0.00869729f, 
    0.22013550f, -0.02247255f, -0.03917987f, -0.16502304f, 0.00696691f, 0.07645983f, 0.05484038f, 0.03262151f, 
    -0.17237332f, -0.11059622f, -0.17912968f, -0.07017206f, -0.03299601f, 0.01218897f, -0.00196952f, 0.00465298f, 
    -0.09275557f, 0.09766572f, 0.00046115f, -0.06033117f, 0.04244005f, -0.23776473f, -0.04128206f, -0.11402544f, 
    0.05944968f, 0.10838437f, -0.02614946f, 0.11946136f, -0.04414552f, 0.02932236f, 0.00416869f, -0.06003490f, 
    -0.11788876f, -0.06265626f, -0.15192951f, 0.09537829f, 0.00291070f, -0.08655318f, 0.08702192f, -0.10028981f, 
    0.04837743f, 0.12060320f, -0.19370526f, 0.05227362f, 0.18465674f, 0.00419339f, 0.13091895f, -0.11582490f, 
    -0.09124392f, 0.01207118f, 0.05854004f, -0.01501450f, 0.06203067f, -0.04910887f, -0.02323535f, -0.06225933f, 
    0.29796723f, -0.33600089f, 0.35616502f, 0.04490102f, -0.00885125f, -0.08616876f, 0.01315173f, 0.06847996f, 
    -0.07893033f, -0.02618817f, -0.10656583f, 0.04262395f, 0.17042029f, -0.14955559f, 0.23175380f, 0.20998324f, 
    -0.00635929f, -0.08540177f, 0.03974467f, -0.14956173f, 0.21418893f, 0.04617451f, 0.07297672f, 0.23880394f, 
    0.07689786f, -0.15822309f, 0.23274978f, -0.20936781f, -0.19819835f, -0.03462516f, -0.09301565f, -0.06144628f, 
    -0.01159938f, 0.02379179f, 0.05082260f, -0.09647397f, -0.12301962f, -0.19673622f, 0.44177777f, 0.24028881f, 
    0.11761077f, -0.04392713f, -0.07761949f, 0.04153483f, 0.01752265f, -0.07440189f, -0.01278565f, -0.21285762f, 
    0.38297334f, -0.18423158f, 0.12637447f, -0.05595351f, 0.01008068f, -0.06301925f, -0.19313598f, 0.12105326f, 
    0.27082068f, 0.00866275f, -0.02768113f, 0.05709226f, -0.03161381f, 0.05287789f, 0.00689069f, -0.11451611f, 
    0.10915373f, 0.09790179f, 0.03304059f, 0.11322092f, 0.02818132f, 0.07808830f, -0.04399241f, 0.02767973f, 
    -0.20680472f, -0.13188669f, 0.11468697f, 0.12679057f, 0.01342217f, -0.24808221f, 0.08421919f, -0.05005013f, 
    -0.01620934f, -0.09053794f, 0.02294585f, 0.09469443f, 0.16477394f, -0.04150893f, -0.01298233f, 0.04294030f, 
    -0.02735920f, 0.00415249f, -0.00431482f, 0.10284698f, 0.03727876f, -0.07210979f, -0.06124742f, 0.07287911f, 
    -0.06355660f, 0.15109409f, 0.07547842f, 0.14081973f, -0.04028344f, -0.03287452f, 0.01110938f, 0.08120921f, 
    -0.08811789f, 0.04375141f, -0.20099422f, -0.02770807f, -0.05206569f, -0.03599490f, 0.15343530f, 0.10305276f, 
    -0.00981501f, 0.12944216f, 0.08531988f, 0.03632462f, 0.03442294f, -0.10296448f, -0.02644136f, -0.04485285f, 
    -0.27336586f, -0.29817098f, 0.00278027f, 0.35788360f, 0.05228504f, 0.18517521f, 0.01346182f, -0.03057062f, 
    -0.00150257f, 0.08649522f, 0.02190187f, -0.05495932f, 0.03560821f, -0.05075217f, -0.00345786f, 0.17183805f, 
    -0.03572999f, 0.03389456f, 0.14832830f, -0.00633480f, 0.05091918f, -0.13706432f, -0.03448467f, -0.05829903f, 
    -0.31013107f, 0.16600728f, -0.01111242f, -0.19445430f, -0.04984564f, -0.05479447f, 0.03188132f, 0.21911088f, 
    -0.01660141f, 0.02828267f, -0.02764264f, -0.01772637f, 0.13652068f, 0.05167385f, 0.15624873f, -0.26633844f, 
    0.04185659f, -0.03671888f, -0.03237287f, 0.06624008f, 0.10848465f, 0.00888306f, 0.27148423f, 0.20024595f, 
    0.03868832f, 0.19698645f, 0.15210940f, 0.01966794f, 0.01944583f, -0.04491438f, 0.01883202f, 0.08181510f, 
    0.01025412f, -0.03606382f, 0.03262608f, -0.04994521f, 0.29709014f, -0.03293877f, 0.02170247f, -0.05353360f, 
    0.07287701f, 0.01608136f, 0.03718112f, 0.10207407f, -0.03371713f, -0.03070527f, 0.13872279f, 0.06914627f, 
    0.14688461f, -0.09556441f, 0.17747352f, -0.25540578f, 0.10455956f, -0.11495460f, -0.03998582f, 0.19746964f, 
    0.04007084f, 0.14142442f, 0.04342027f, -0.16200639f, 0.03856974f, -0.09173725f, 0.07586763f, 0.34840435f, 
    0.13532546f, 0.05713255f, -0.04975991f, -0.04997442f, -0.02310753f, -0.04415902f, -0.00042871f, -0.07896980f, 
    0.23054174f, -0.39212736f, -0.14379315f, -0.18170360f, 0.00817880f, 0.03352080f, -0.06380936f, -0.25909385f, 
    0.16898476f, 0.07796431f, 0.03368666f, 0.01999301f, 0.27968779f, -0.01362766f, -0.02683594f, 0.01836505f, 
    0.24904542f, 0.01774967f, 0.12025268f, 0.04048405f, 0.13529235f, 0.11139314f, 0.07545784f, 0.07805203f, 
    -0.11040904f, -0.11366349f, 0.13581476f, 0.04851887f, -0.21408328f, -0.09112548f, -0.31489384f, -0.25354549f, 
    0.05520740f, 0.03356741f, -0.06778876f, -0.11645335f, 0.11585869f, 0.03097907f, -0.26018840f, 0.15333770f, 
    0.02996812f, -0.09021877f, 0.18722688f, 0.07150863f, 0.02094389f, -0.02166491f, -0.03669940f, -0.08685941f, 
    -0.00653141f, -0.03640763f, -0.05036135f, 0.15190014f, 0.06501605f, -0.03702394f, 0.04764971f, 0.04208979f, 
    0.17552857f, 0.08090940f, 0.04494913f, -0.01914124f, 0.09012736f, 0.06685954f, -0.04967882f, -0.11523113f, 
    -0.12688582f, -0.12348972f, -0.06804440f, -0.18208744f, -0.12622586f, 0.03001313f, -0.04033792f, -0.16930862f, 
    0.15278032f, 0.03953509f, 0.04172463f, 0.19310673f, 0.02510021f, 0.18236980f, 0.04530012f, 0.21792343f, 
    0.03762583f, 0.02120525f, -0.10151539f, -0.06161884f, 0.01579455f, 0.05350539f, 0.23712949f, 0.18013047f, 
    -0.06190423f, 0.12728783f, -0.29543185f, 0.03840082f, -0.11640073f, -0.08351128f, -0.06426127f, -0.25971162f, 
    -0.08489694f, -0.21788354f, 0.35429698f, 0.00402682f, -0.06260590f, -0.01774574f, 0.00814239f, -0.13966709f, 
    0.02090447f, -0.19803451f, -0.08225118f, -0.13955033f, 0.07047637f, 0.00312944f, -0.09825605f, 0.05065742f, 
    0.09757449f, 0.03931283f, -0.02477459f, -0.17847575f, 0.07713089f, -0.32749626f, -0.04962479f, -0.09060312f, 
    0.27583709f, 0.22285427f, -0.12282246f, -0.03311453f, 0.19594947f, 0.00522215f, 0.07138620f, 0.07516453f, 
    0.11427069f, 0.05046064f, -0.01278160f, 0.03978318f, 0.25903329f, 0.18570803f, 0.06608738f, 0.24435923f, 
    0.03757903f, 0.07568531f, 0.11005409f, 0.22119997f, -0.05565631f, 0.22264287f, -0.00296445f, 0.15660964f, 
    0.09332273f, 0.19573402f, 0.10562454f, 0.07707578f, -0.08906131f, 0.10682122f, -0.06712601f, -0.19148466f, 
    0.10011449f, -0.19449516f, 0.05888372f, 0.07071890f, 0.18241291f, -0.10823683f, 0.04560209f, 0.26033407f, 
    -0.15803111f, -0.08073494f, 0.10011521f, -0.12262505f, -0.01555938f, -0.01117508f, 0.10524593f, 0.05837933f, 
    0.20966230f, 0.08733641f, 0.04715089f, -0.24758326f, 0.08570865f, 0.08029076f, 0.12963930f, 0.09960087f, 
    -0.17548239f, -0.09921502f, 0.06011893f, -0.00051919f, 0.30955541f, 0.13158439f, -0.09956928f, -0.10961992f, 
    -0.12010472f, -0.01688130f, -0.24550550f, -0.10833718f, 0.06533866f, -0.05498948f, 0.02681473f, -0.14711520f, 
    -0.40070683f, 0.46918559f, -0.14056697f, 0.12910174f, 0.07671607f, -0.12109884f, 0.01774892f, 0.11991917f, 
    0.01899807f, 0.04786375f, -0.08674737f, -0.01972640f, -0.15351799f, 0.18859085f, -0.34580582f, -0.07872202f, 
    0.03564892f, 0.07168389f, -0.03687390f, 0.03638649f, -0.10063031f, 0.14376630f, -0.01345520f, 0.15213840f, 
    -0.05730650f, 0.30206832f, -0.08918370f, 0.27631900f, -0.10614537f, 0.13357429f, 0.19095095f, 0.01351516f, 
    -0.10955008f, 0.02199242f, 0.13907708f, 0.07671670f, 0.14107959f, 0.02858962f, 0.19143145f, -0.03734066f, 
    -0.14418079f, -0.07117558f, -0.04026504f, 0.06438496f, -0.05201692f, 0.01859413f, -0.06591284f, -0.15293156f, 
    -0.31072342f, -0.12414690f, -0.02655704f, 0.14812325f, 0.12283421f, -0.05800310f, -0.02631874f, -0.06007030f, 
    -0.04688969f, 0.22409475f, -0.09533250f, -0.05650173f, -0.22306766f, 0.13547495f, -0.05714956f, 0.01569962f, 
    0.08179195f, 0.11343675f, 0.12169848f, -0.08040361f, -0.03234649f, -0.04503192f, 0.10306507f, 0.05317745f, 
    -0.06849054f, -0.19145876f, 0.06439967f, 0.10039388f, -0.05099334f, 0.00636994f, 0.08646477f, -0.03535577f, 
    0.04954899f, 0.00374934f, -0.06484655f, 0.05970417f, 0.26765057f, -0.06771295f, 0.04593867f, -0.10115676f, 
    -0.16320415f, 0.10629682f, 0.04969696f, -0.10430312f, -0.03924874f, -0.08335395f, -0.12475362f, -0.06010743f, 
    0.23386088f, 0.07486512f, -0.20537610f, -0.02061868f, -0.01617636f, 0.19959576f, 0.02984070f, 0.18452135f, 
    -0.03592606f, -0.02414195f, -0.03670190f, -0.11361136f, 0.00965878f, 0.10773387f, 0.04533152f, -0.13713048f, 
    -0.11470860f, 0.09960879f, -0.09572318f, 0.04001511f, -0.01061370f, -0.08347022f, 0.06508397f, -0.08043689f, 
    0.03603091f, -0.07704681f, 0.35936129f, 0.26439899f, 0.00706013f, 0.23064640f, -0.19122235f, 0.00752173f, 
    -0.03398651f, 0.02888577f, 0.01853029f, 0.04803019f, -0.14218925f, 0.35375932f, -0.01393170f, 0.19233480f, 
    -0.01183603f, 0.06863613f, 0.21625438f, 0.14952672f, 0.07705348f, 0.17655575f, -0.14578640f, 0.05621845f, 
    0.05726133f, -0.20410329f, 0.00701546f, -0.10261131f, -0.12655738f, -0.01751565f, -0.02626370f, -0.00048791f, 
    0.01812136f, -0.04498668f, -0.03200047f, 0.07772454f, -0.22823855f, 0.07194069f, -0.00672786f, 0.08556845f, 
    0.00488488f, -0.08115058f, -0.17888938f, 0.00779302f, -0.05669592f, 0.07773540f, 0.25529063f, 0.13928761f, 
    -0.47678310f, 0.24239662f, -0.30044019f, 0.32807633f, 0.06813145f, 0.33152848f, 0.01263317f, -0.11478735f, 
    0.02599842f, -0.08010477f, -0.08152952f, 0.05634708f, -0.18655401f, 0.14750178f, -0.08206360f, -0.02307844f, 
    0.08869749f, -0.07052596f, 0.06084150f, 0.00359096f, 0.07166951f, 0.13322915f, 0.07756206f, 0.01481062f, 
    -0.31424460f, -0.01354296f, -0.05082171f, -0.17412668f, -0.13462223f, -0.09647802f, 0.00898341f, 0.07030268f, 
    0.20842026f, 0.19697686f, 0.07690775f, 0.10818959f, -0.20366445f, 0.00146937f, -0.20068990f, -0.09869105f, 
    0.07806332f, 0.03468430f, 0.04332120f, -0.04572453f, 0.12949182f, 0.07037987f, -0.00270109f, 0.14003868f, 
    0.17073703f, -0.01340414f, 0.02709414f, 0.12652749f, 0.02678933f, -0.03981539f, 0.09483994f, 0.06490537f, 
    0.04055725f, -0.07442537f, 0.20669851f, 0.08270254f, -0.11136778f, -0.22495368f, -0.19643345f, -0.23411272f, 
    -0.11087765f, -0.02307945f, -0.16191939f, 0.11591744f, 0.03697883f, 0.04324050f, -0.09152059f, -0.00964141f, 
    -0.02609672f, -0.19661769f, -0.13248649f, -0.24781774f, 0.01110590f, -0.05512703f, 0.07146280f, 0.03474012f, 
    -0.07087658f, 0.06206669f, 0.03777776f, -0.14700782f, -0.09680365f, -0.02832764f, -0.09202269f, -0.06297906f, 
    0.02530172f, 0.10615650f, -0.02321659f, 0.08415355f, -0.04167201f, 0.15864626f, 0.13313431f, 0.01938704f, 
    -0.04835201f, -0.02790260f, -0.11517442f, -0.23141754f, 0.06579879f, 0.10903819f, -0.00676081f, -0.00377910f, 
    0.19038786f, -0.09917071f, 0.14842735f, 0.12350686f, -0.01821163f, -0.03999764f, 0.00270432f, 0.19163051f, 
    0.17157775f, -0.02028975f, -0.06357572f, -0.04070836f, -0.04161721f, 0.06085106f, -0.01545807f, 0.08084979f, 
    0.56489766f, -0.27022222f, 0.01770637f, 0.17979063f, 0.24257825f, 0.14919385f, 0.22947776f, 0.15804309f, 
    0.12124254f, 0.13122340f, -0.06458462f, -0.09823810f, -0.18034191f, -0.05190110f, 0.05910147f, -0.01915692f, 
    0.13375169f, 0.12969805f, -0.11067380f, 0.03610264f, -0.03527594f, 0.14520276f, 0.07119849f, 0.00298381f, 
    -0.19187067f, -0.15568654f, -0.21024501f, -0.31914395f, 0.05899461f, 0.11566212f, 0.01239580f, -0.06582617f, 
    0.00650550f, 0.08229762f, -0.00357820f, 0.09062901f, -0.08470989f, 0.07319596f, 0.08004838f, 0.10269687f, 
    -0.08143935f, 0.07218177f, 0.09486955f, -0.02657718f, 0.05641828f, 0.19398201f, 0.13255298f, -0.19116129f, 
    -0.07029995f, -0.13278605f, 0.02527013f, -0.12053062f, -0.02724366f, -0.06418110f, -0.02829940f, 0.01197953f, 
    -0.02886853f, -0.06096988f, -0.01977020f, -0.06126557f, -0.03627557f, 0.03142766f, 0.27068925f, 0.07012060f, 
    -0.13443980f, 0.03586973f, -0.05966618f, -0.00125664f, 0.07432032f, 0.15794612f, 0.25755897f, 0.10327540f, 
    -0.06259432f, -0.10173643f, -0.08029845f, 0.10940810f, 0.17795815f, 0.17527224f, 0.13418618f, -0.08415833f, 
    -0.01873603f, -0.07967097f, -0.01096161f, 0.04699007f, -0.19694148f, -0.23919798f, 0.27383748f, 0.22892587f, 
    0.00246169f, -0.08453783f, -0.02102624f, 0.03126971f, 0.22426839f, 0.06473423f, 0.22442040f, 0.13817185f, 
    0.17531002f, 0.09905499f, 0.35002926f, 0.08076993f, -0.07194414f, -0.17225893f, -0.05454586f, 0.07439319f, 
    0.18679458f, 0.12934132f, 0.04281210f, 0.08255643f, -0.22403067f, -0.03438331f, -0.12808892f, 0.33936837f, 
    -0.13040985f, -0.05097461f, -0.08107883f, 0.13376917f, 0.19990359f, -0.01696859f, 0.09460019f, -0.05104533f, 
    0.28471532f, -0.06000765f, 0.27572149f, -0.17884856f, 0.02821231f, 0.07368744f, -0.03664664f, -0.05423652f, 
    0.06736018f, -0.03626082f, -0.12585111f, 0.02196966f, -0.07368895f, -0.17177378f, 0.08418842f, -0.13037041f, 
    -0.03611616f, -0.01088875f, 0.08796643f, 0.29576495f, -0.03678089f, -0.04632394f, 0.11951823f, 0.11722319f, 
    0.04771120f, 0.08590152f, 0.04897992f, -0.05122894f, -0.00923540f, 0.01819358f, 0.13673611f, -0.00243643f, 
    -0.09040516f, -0.05053332f, 0.01534064f, 0.06829827f, 0.03722880f, -0.12147778f, 0.07546148f, -0.11926652f, 
    -0.08304893f, 0.05359660f, 0.00855163f, 0.01440698f, 0.20202526f, 0.17601615f, -0.10243908f, 0.07917018f, 
    -0.27497804f, -0.01710102f, -0.16275974f, -0.18215342f, -0.00741310f, -0.06248720f, 0.07363778f, 0.01744114f, 
    0.23225343f, 0.17338701f, 0.13094629f, 0.07410060f, 0.02730139f, -0.00846088f, -0.20304579f, 0.04109050f, 
    0.08029216f, -0.07988296f, -0.02723477f, 0.00110355f, 0.05814081f, 0.03543141f, -0.05901766f, 0.06140890f, 
    0.11765365f, 0.13692260f, -0.36281961f, 0.20812753f, 0.11111503f, 0.10974222f, 0.07173467f, -0.06770864f, 
    -0.02395646f, -0.04834904f, 0.08013255f, -0.02679650f, 0.02284344f, -0.12766021f, -0.02238443f, 0.06038960f, 
    -0.00081838f, 0.03974049f, -0.01981364f, 0.01313986f, -0.07770809f, 0.15808709f, 0.15442123f, 0.16005345f, 
    -0.32880619f, -0.25391927f, -0.09444248f, -0.17565548f, -0.08793107f, 0.07658248f, 0.01014782f, 0.07257229f, 
    0.00318165f, 0.04382291f, 0.08438393f, 0.08405423f, 0.07713635f, -0.06323175f, 0.14689197f, -0.13558976f, 
    0.03035849f, 0.07830920f, 0.04551336f, 0.18231110f, -0.02591988f, 0.02661338f, -0.02446048f, 0.05339015f, 
    -0.22197352f, 0.02215798f, -0.10052497f, -0.08937536f, -0.05155232f, -0.01235001f, -0.00858817f, -0.04630091f, 
    -0.10693804f, -0.02881577f, -0.14247285f, -0.06197594f, 0.04796341f, 0.10622831f, 0.26109928f, -0.13997604f, 
    -0.09641331f, -0.14680682f, -0.14647973f, -0.08641213f, -0.02713681f, 0.18245131f, 0.01875245f, 0.07114433f, 
    0.02059326f, -0.33913288f, 0.19007602f, -0.08092531f, 0.04192837f, 0.23334156f, -0.13572747f, -0.00973087f, 
    0.00945821f, 0.02314092f, -0.06937666f, 0.05160100f, -0.00602793f, -0.09499791f, 0.18474831f, 0.42071980f, 
    0.07458553f, -0.04695414f, -0.11559798f, -0.03008066f, 0.12019012f, 0.14635578f, 0.25728941f, 0.35328931f, 
    0.06785222f, -0.30127305f, 0.16576448f, -0.16161707f, 0.03325775f, 0.07821330f, 0.02533786f, -0.15763886f, 
    0.02706231f, -0.06001600f, 0.07774783f, 0.12096018f, 0.11021776f, 0.04143880f, 0.10954210f, 0.00239658f, 
    0.18765993f, -0.00809414f, 0.00442213f, 0.01211977f, -0.02435220f, -0.00627284f, 0.03706668f, -0.01572583f, 
    -0.00705374f, -0.22338432f, 0.00646709f, -0.21007249f, -0.05010845f, -0.12452901f, -0.13957569f, 0.02294010f, 
    0.25070387f, -0.04509000f, -0.12216559f, -0.03439486f, -0.00038135f, 0.06885031f, -0.23445323f, 0.02448173f, 
    0.13891760f, -0.03744756f, 0.01810852f, -0.00617665f, 0.00281456f, 0.11258788f, 0.06693682f, -0.00463938f, 
    0.05841932f, -0.07295677f, 0.03532946f, 0.10570969f, -0.00486134f, 0.06381071f, 0.13419729f, 0.01809850f, 
    -0.04225617f, -0.11263616f, -0.03244226f, -0.03289493f, 0.14181381f, 0.03978182f, -0.04352884f, -0.12791494f, 
    0.00113291f, -0.12141572f, -0.01262528f, -0.01522389f, 0.12863569f, 0.06473579f, -0.02642466f, 0.10045495f, 
    0.11728729f, -0.05641916f, -0.02205774f, 0.11743423f, -0.04937832f, -0.02459295f, -0.01283541f, 0.12001209f, 
    -0.11686061f, -0.05627983f, -0.09802311f, -0.03015352f, -0.11659408f, 0.05091643f, 0.10658882f, -0.01730062f, 
    0.12866390f, 0.02591318f, -0.03576760f, 0.06254350f, -0.02148974f, -0.03767300f, 0.02331537f, -0.06017582f, 
    0.10791301f, -0.38962209f, 0.27745187f, 0.14309272f, 0.09947437f, -0.02706618f, 0.20046207f, 0.06927795f, 
    0.01119755f, -0.02784221f, 0.03107061f, -0.07432926f, 0.07414188f, -0.17505096f, 0.04406096f, 0.17867705f, 
    0.05790167f, -0.16079478f, -0.00782149f, 0.06491260f, 0.10149319f, -0.06464808f, -0.02827653f, 0.07633980f, 
    0.24160023f, 0.30409160f, -0.20157948f, -0.02199512f, 0.13062799f, -0.15430596f, 0.11875948f, 0.07845303f, 
    0.05197518f, -0.08394612f, -0.02813188f, 0.08753499f, 0.01767606f, 0.08426850f, 0.15681142f, -0.06640113f, 
    -0.02413921f, -0.05101164f, -0.04966028f, -0.08367445f, -0.00422116f, 0.12222886f, 0.06044576f, -0.05067763f, 
    0.06588966f, 0.07703908f, -0.00351915f, -0.10264067f, 0.01363547f, -0.06029350f, -0.00399570f, 0.12892084f, 
    0.00782424f, -0.03664703f, 0.00715779f, -0.08804329f, 0.26894629f, -0.07818467f, -0.01649850f, -0.06744455f, 
    0.03254307f, 0.03528542f, 0.07479591f, 0.02266856f, 0.06513247f, -0.05541465f, 0.06559470f, -0.11444262f, 
    0.12912095f, 0.02631261f, 0.03828668f, -0.03372240f, 0.03034600f, 0.00144022f, -0.14262365f, 0.05936321f, 
    0.05763886f, 0.01612375f, 0.03683826f, -0.11599629f, 0.18856785f, -0.13612370f, 0.20856483f, -0.17669512f, 
    0.03702754f, -0.06986994f, -0.02717698f, 0.07310696f, -0.05128582f, 0.01728062f, -0.01648345f, 0.03890554f, 
    -0.00080965f, -0.08294562f, 0.04110390f, -0.29472613f, -0.13478251f, -0.09383632f, -0.19581176f, -0.03639305f, 
    0.00195274f, 0.17253695f, -0.00360239f, 0.02812642f, 0.12808034f, 0.09409112f, -0.23624972f, -0.08987878f, 
    0.05928832f, 0.10145086f, -0.02512115f, 0.20403905f, 0.08368466f, 0.01246761f, -0.06035640f, 0.04873668f, 
    -0.37190637f, 0.12757108f, 0.26614910f, -0.24100301f, -0.08270799f, -0.18664478f, 0.03853650f, -0.14006294f, 
    0.10030827f, -0.04042363f, 0.06201514f, 0.08219893f, 0.08800609f, 0.01042221f, -0.01314676f, -0.03331866f, 
    -0.04075973f, 0.09123684f, 0.03792178f, 0.15041611f, -0.01926812f, -0.12055415f, -0.13193886f, -0.12346439f, 
    0.14450140f, 0.32575071f, -0.06448776f, -0.11828833f, 0.07770871f, -0.06151109f, 0.09899934f, -0.05203695f, 
    0.10830447f, -0.04519252f, 0.07255924f, 0.04769680f, -0.24018244f, -0.16049698f, 0.11336728f, -0.26123860f, 
    -0.06154451f, 0.03376372f, -0.10380263f, -0.18108073f, -0.03589175f, -0.02942527f, -0.03313346f, 0.14427246f, 
    0.06274172f, 0.22020628f, -0.11061577f, 0.06596421f, 0.13374422f, 0.19632289f, 0.22932695f, 0.06898411f, 
    0.12769493f, 0.07541689f, -0.00785989f, -0.01723751f, -0.12494917f, 0.01698264f, 0.07513734f, 0.25757948f, 
    -0.15646118f, 0.05317850f, -0.04280599f, -0.13115670f, -0.00030143f, -0.29600286f, -0.04996018f, -0.05417858f, 
    0.03644659f, -0.09835663f, 0.37285444f, -0.08134134f, 0.04204489f, 0.19997062f, 0.05434458f, -0.09792831f, 
    0.00116146f, -0.02647122f, -0.01181127f, -0.10913946f, -0.00448071f, 0.26487499f, 0.11050896f, 0.12086149f, 
    0.09139913f, 0.18010299f, -0.08123247f, -0.21613403f, -0.01960423f, 0.00186960f, -0.38090652f, -0.16008411f, 
    -0.02868859f, 0.08984692f, -0.18300863f, -0.22105941f, 0.13978678f, -0.03725689f, 0.09416109f, 0.17055945f, 
    -0.10512119f, 0.01599264f, 0.10702697f, -0.00986671f, -0.04812031f, -0.13484329f, -0.11020475f, 0.05997385f, 
    -0.07538945f, -0.02641480f, 0.02804792f, 0.16885643f, 0.12067031f, 0.12979834f, -0.06421190f, -0.01711210f, 
    -0.09171904f, -0.09164769f, 0.03305144f, -0.01463932f, -0.03661546f, 0.02677365f, -0.02458962f, -0.12485584f, 
    0.15555830f, -0.01999800f, -0.19530106f, 0.06444877f, 0.06401932f, -0.14062205f, 0.06581566f, 0.07052472f, 
    -0.16021124f, -0.31061530f, -0.03092017f, -0.17535678f, 0.14467102f, 0.01298955f, 0.11397324f, 0.01898052f, 
    0.39911464f, -0.10530419f, 0.26108563f, -0.01634243f, 0.00363572f, -0.04251204f, 0.05377989f, 0.12539458f, 
    -0.07155671f, 0.01252270f, -0.24184854f, -0.09534841f, 0.22863130f, 0.28604263f, 0.28480563f, 0.08445784f, 
    -0.02707149f, 0.02701952f, -0.05642736f, -0.28708959f, 0.26925939f, 0.03558402f, 0.11988410f, -0.08365678f, 
    -0.19607078f, 0.27967060f, -0.08784220f, 0.18746680f, -0.00070768f, -0.05286694f, -0.03271243f, 0.03762761f, 
    -0.03457761f, 0.16542637f, 0.03415047f, -0.07538599f, 0.11758842f, 0.16754901f, -0.29537845f, -0.04188488f, 
    0.08656883f, 0.12242060f, 0.02211703f, 0.00533672f, -0.12461966f, 0.16127509f, -0.03530546f, -0.07876859f, 
    -0.23550108f, 0.24258530f, 0.08615993f, 0.24817856f, -0.07022712f, 0.11553764f, -0.03497905f, -0.00534827f, 
    0.02845572f, 0.13018031f, 0.07824765f, 0.05289434f, 0.17721936f, 0.01558352f, 0.02063407f, 0.01752115f, 
    -0.12187012f, -0.10528829f, 0.17131902f, 0.03679839f, -0.11387685f, -0.05515130f, -0.01660695f, 0.05456315f, 
    -0.33144715f, -0.05925099f, -0.19994697f, 0.17841271f, 0.19926794f, 0.04328696f, -0.01147913f, 0.15339564f, 
    -0.00668463f, 0.18043301f, -0.05863768f, 0.01533374f, -0.07378828f, 0.14604895f, 0.10173140f, 0.05796732f, 
    -0.10132079f, 0.07189029f, -0.06700915f, -0.11920130f, -0.21291366f, -0.00324210f, 0.00001255f, -0.02735877f, 
    -0.13448827f, -0.25934649f, -0.04081458f, 0.05169123f, -0.08914652f, 0.09816203f, 0.04696012f, -0.03164817f, 
    -0.04282534f, 0.08992879f, -0.12268022f, -0.08311187f, 0.19184032f, 0.09082156f, 0.16938190f, -0.23952325f, 
    -0.19652237f, 0.13160221f, 0.00669547f, -0.17754135f, -0.13620153f, -0.03506673f, -0.03834693f, -0.04961480f, 
    -0.18600741f, 0.31985885f, -0.37588567f, -0.10205410f, -0.00201019f, 0.05360473f, -0.00538767f, 0.04621137f, 
    0.01406740f, -0.06503267f, 0.00053088f, -0.10535275f, 0.02163688f, 0.05309394f, 0.10734985f, 0.00061142f, 
    -0.01087911f, 0.07625777f, -0.03346597f, 0.10025956f, 0.08356890f, -0.08944025f, -0.01348474f, 0.00949245f, 
    0.25102988f, -0.15052295f, 0.17563830f, 0.26858205f, -0.01445995f, 0.06193083f, 0.00579275f, 0.01493028f, 
    0.01206770f, 0.02579234f, -0.06095050f, -0.04910483f, -0.13808680f, 0.30203500f, 0.03838935f, 0.20755012f, 
    0.02470331f, -0.09982155f, 0.10172591f, 0.07456673f, 0.01215164f, 0.09568794f, -0.03065516f, 0.19302757f, 
    0.14008929f, 0.01309639f, 0.01741438f, -0.09184971f, -0.18259512f, 0.08558470f, 0.03491728f, 0.01620914f, 
    0.02857017f, -0.06386515f, -0.01996416f, 0.06280564f, -0.21992834f, 0.15267801f, -0.04089070f, 0.01442207f, 
    0.03216778f, -0.05740912f, -0.07031792f, 0.00957103f, -0.01080596f, 0.15948693f, 0.18473428f, -0.01412655f, 
    -0.26392996f, 0.17201789f, -0.23545510f, 0.12743711f, 0.05956414f, 0.32894468f, 0.05590652f, 0.00508918f, 
    0.01691082f, -0.01594554f, 0.13554072f, 0.06040769f, -0.02221082f, 0.38451126f, -0.02650576f, -0.17357053f, 
    0.12309942f, 0.09378062f, 0.01524295f, -0.01446146f, -0.14797553f, -0.03013118f, -0.00638245f, 0.03374499f, 
    -0.27609232f, 0.02709098f, 0.10344462f, 0.10390963f, 0.04020382f, -0.06351029f, 0.06467505f, -0.10459095f, 
    0.01295803f, -0.05171656f, 0.01517925f, 0.04075677f, -0.18484910f, 0.08121372f, -0.10758290f, -0.08896510f, 
    -0.01537076f, -0.03268493f, -0.05789111f, -0.00577351f, -0.01339834f, 0.02106356f, -0.03602414f, 0.15224245f, 
    0.03795543f, 0.03249564f, 0.02565018f, 0.02553333f, -0.13907926f, 0.08762635f, 0.06276230f, -0.06433498f, 
    0.00878343f, 0.07340784f, 0.02578546f, 0.03708022f, 0.10184013f, -0.03547767f, 0.10460297f, 0.07276309f, 
    -0.07314652f, -0.16034682f, -0.12938407f, 0.08675017f, 0.00504909f, -0.03465643f, 0.03297113f, -0.11884047f, 
    -0.04113164f, -0.08674373f, 0.05065607f, 0.23453546f, 0.04819132f, -0.00626941f, 0.03915287f, 0.03164836f, 
    0.14487624f, 0.07227448f, 0.05165498f, 0.01654566f, -0.01296624f, 0.07020113f, -0.12076689f, 0.10817845f, 
    -0.03528385f, 0.01834215f, 0.07309057f, -0.02874618f, 0.01472237f, 0.05869204f, 0.01351250f, -0.01944687f, 
    -0.09378269f, -0.04980918f, 0.05378841f, 0.26378730f, 0.01315103f, -0.07878809f, 0.15679094f, 0.10896984f, 
    0.03397701f, 0.03346432f, -0.10018192f, 0.04042054f, 0.29354325f, -0.09799005f, 0.08478807f, 0.22494017f, 
    -0.02372554f, -0.00127147f, -0.04191447f, -0.07964130f, -0.03824507f, -0.06744626f, -0.05755903f, -0.10937140f, 
    0.50228888f, -0.17101517f, -0.26734507f, 0.18837251f, -0.04753949f, -0.09719836f, -0.04605464f, -0.10517164f, 
    0.01634322f, -0.03446763f, 0.00645875f, 0.03949793f, 0.06701013f, 0.13062638f, -0.06223298f, -0.00518593f, 
    -0.10394552f, -0.01755205f, -0.05721787f, -0.10882787f, -0.08667969f, -0.14494313f, -0.14166546f, -0.03901893f, 
    0.12735562f, 0.08260372f, 0.26540560f, 0.23931158f, 0.01041440f, 0.12747259f, -0.16213652f, 0.02349890f, 
    0.07566026f, -0.07807487f, 0.02963422f, -0.06174071f, -0.11857425f, 0.29355541f, -0.05879913f, 0.21091652f, 
    -0.10899304f, 0.00127331f, 0.11460453f, 0.06572956f, 0.01826502f, 0.11623699f, -0.10274208f, 0.03185074f, 
    -0.11337557f, 0.11241096f, 0.13433920f, -0.03302598f, -0.03726522f, 0.00976612f, -0.05824161f, -0.12880562f, 
    0.03329832f, 0.03408694f, 0.05390894f, -0.01492718f, -0.29727179f, -0.07247693f, 0.02425447f, 0.03736884f, 
    0.00829817f, 0.07076360f, -0.10165991f, 0.03032170f, -0.00612799f, 0.00175727f, 0.16171271f, 0.00204055f, 
    -0.15546677f, 0.12850045f, 0.09920951f, 0.21828564f, -0.04746767f, 0.23050717f, -0.02448522f, 0.00676601f, 
    -0.02517432f, -0.01671726f, 0.02401788f, 0.06101224f, -0.04023445f, -0.02665712f, -0.39452934f, 0.11638418f, 
    0.08531895f, -0.04096939f, -0.13955255f, -0.15479170f, -0.03456403f, 0.04805208f, 0.02570424f, 0.03482276f, 
    0.45026720f, -0.00180597f, -0.17207871f, 0.14030455f, 0.16043422f, 0.15511134f, 0.06016742f, -0.11468265f, 
    -0.01051619f, -0.08320861f, 0.12666722f, -0.06434000f, 0.32394403f, 0.21597713f, 0.16203482f, 0.11102594f, 
    0.09527778f, 0.06979432f, 0.26564011f, 0.04706690f, 0.05361792f, -0.06910709f, 0.03955127f, -0.12258015f, 
    -0.31344721f, 0.17185767f, -0.16812597f, 0.08243302f, -0.06247336f, -0.03769227f, -0.18587877f, -0.06045536f, 
    -0.04041737f, -0.08795179f, -0.00404705f, -0.07774046f, 0.27984113f, 0.25985348f, 0.12882473f, 0.32737043f, 
    0.11283026f, 0.13645642f, 0.23157457f, 0.06257373f, -0.00994070f, 0.07138622f, 0.11014522f, 0.11624555f, 
    0.07461756f, 0.07037428f, -0.12885450f, 0.09776223f, -0.00348301f, 0.12527482f, 0.08828305f, 0.33811465f, 
    0.09510188f, 0.16664673f, 0.02828321f, 0.04233800f, -0.05883118f, -0.09287179f, -0.01510966f, 0.03658937f, 
    -0.12194847f, 0.01412857f, -0.14015248f, -0.03924148f, -0.10625341f, -0.04395070f, 0.02748130f, 0.02633713f, 
    0.10239875f, 0.02224270f, 0.05115214f, -0.11002826f, 0.13575861f, 0.06188196f, 0.07809574f, 0.20048316f, 
    -0.02308976f, 0.10817570f, -0.03598357f, 0.08425589f, 0.03810560f, 0.08203685f, 0.24061006f, -0.10663113f, 
    -0.12551565f, 0.02958267f, 0.07172631f, 0.01828585f, -0.04383746f, 0.08784102f, 0.00105712f, 0.05820768f, 
    -0.26961219f, 0.51274443f, 0.13859525f, -0.34131494f, -0.02831774f, -0.02050357f, -0.06693425f, -0.00217450f, 
    0.15035111f, 0.00093510f, -0.06229474f, 0.04363092f, -0.13636889f, -0.01508485f, 0.07002187f, -0.06737862f, 
    -0.03824943f, 0.14588243f, 0.17545024f, 0.07969099f, 0.01402500f, 0.04485236f, -0.03028420f, 0.04078776f, 
    0.40678722f, 0.03868048f, 0.00768773f, 0.21567659f, 0.09285355f, 0.08359753f, 0.05566104f, -0.05803445f, 
    -0.01618643f, 0.01204851f, 0.00452571f, -0.00673653f, 0.00955691f, -0.16848236f, -0.13543594f, -0.05778822f, 
    -0.01463254f, -0.06404536f, -0.03064515f, -0.03868604f, -0.04077221f, -0.03445878f, 0.10899109f, 0.06318203f, 
    -0.22537191f, -0.06456231f, -0.25466245f, -0.20159592f, -0.02375020f, -0.08641534f, -0.08909584f, 0.01983449f, 
    0.01161010f, -0.01198889f, 0.12940744f, -0.01978562f, -0.06881033f, -0.05885958f, -0.39175904f, -0.02432730f, 
    -0.01391907f, 0.04408547f, 0.03745484f, -0.04873145f, -0.03305954f, 0.04297851f, -0.16333014f, -0.08150873f, 
    0.24922080f, 0.21775344f, -0.02713842f, -0.14599231f, -0.15945888f, -0.13036279f, -0.03843229f, 0.06424966f, 
    0.01997218f, 0.09317014f, -0.00048972f, -0.03399030f, -0.14344402f, 0.33041289f, -0.20884195f, -0.08894993f, 
    -0.02652678f, 0.02650291f, 0.08150176f, 0.06723275f, -0.08949874f, -0.08262074f, -0.06270523f, -0.05168151f, 
    -0.09178678f, -0.03964632f, 0.12588246f, -0.27398625f, -0.19274774f, -0.08263224f, -0.05524379f, 0.06511635f, 
    0.01988558f, 0.08937144f, -0.09527510f, 0.13776302f, -0.11257625f, -0.14651836f, -0.12947893f, -0.06987697f, 
    0.08659689f, 0.01796285f, -0.16060540f, 0.03479129f, 0.06130213f, -0.01302856f, -0.03756542f, 0.15826148f, 
    -0.06603342f, -0.25852570f, -0.06082474f, -0.37821907f, 0.09758700f, -0.28113377f, 0.23005451f, -0.02280932f, 
    0.06756686f, 0.00047711f, 0.24907179f, -0.07021878f, -0.20559980f, 0.11815462f, -0.07530937f, 0.09178632f, 
    -0.00124398f, -0.13810366f, -0.08251758f, -0.06530996f, 0.01098347f, -0.14916293f, -0.02186299f, -0.09762559f, 
    0.16730815f, 0.16715935f, 0.27942571f, 0.04816885f, -0.01970667f, -0.04261201f, 0.06285314f, -0.07438625f, 
    0.16863503f, 0.16626072f, 0.00484105f, -0.05115198f, -0.07246602f, 0.05646301f, -0.03230672f, -0.27714694f, 
    0.21997812f, 0.09485300f, 0.13343263f, -0.27036142f, 0.04485945f, -0.07511572f, -0.09295052f, -0.13633060f, 
    0.12036557f, 0.41674775f, 0.05212606f, 0.29276729f, 0.06672598f, 0.04729858f, 0.14390305f, 0.10428464f, 
    0.15439560f, -0.07849623f, 0.06839743f, 0.04375064f, 0.04754487f, 0.05078310f, -0.10350123f, 0.40609002f, 
    -0.03207032f, 0.00309430f, -0.08516644f, -0.13269080f, 0.03475797f, -0.14960495f, 0.13823779f, -0.19594732f, 
    0.24816427f, -0.54609770f, 0.20196533f, 0.04193668f, 0.18115623f, 0.20959030f, -0.08939961f, -0.04190988f, 
    -0.04716610f, -0.06275717f, 0.09160747f, 0.06611814f, 0.08099476f, 0.06581209f, 0.10385550f, 0.20455313f, 
    0.07217763f, 0.04152254f, -0.22014295f, 0.00092422f, -0.19095209f, 0.08674365f, 0.12169748f, -0.12658650f, 
    -0.35769415f, 0.17045373f, 0.08480457f, -0.13952942f, 0.15559779f, -0.01325181f, 0.02258404f, -0.01716329f, 
    -0.08481354f, -0.00426169f, -0.03847760f, 0.01337403f, 0.09787126f, -0.11421184f, -0.03732648f, -0.06014780f, 
    0.03710195f, 0.01088374f, 0.17788783f, 0.20470496f, 0.03011659f, 0.07822976f, 0.01623709f, 0.11142989f, 
    -0.00721063f, -0.13613096f, -0.09298284f, 0.07393435f, -0.07107038f, 0.05563189f, 0.02811451f, -0.01924369f, 
    0.03480444f, -0.01380601f, -0.03134548f, 0.13816182f, -0.02651761f, -0.20340931f, 0.08856548f, -0.14559436f, 
    -0.18990859f, -0.06676357f, -0.09949236f, -0.04777417f, 0.14013386f, 0.02410031f, 0.12629950f, -0.02145423f, 
    -0.00756658f, -0.44181663f, 0.39375642f, 0.20851360f, 0.08243060f, 0.05274554f, -0.07549511f, 0.03333418f, 
    -0.04423300f, 0.12380579f, -0.15704216f, 0.07607480f, 0.25284922f, -0.07043691f, 0.19590949f, -0.15110818f, 
    -0.15741056f, -0.10846508f, -0.01363873f, -0.09481266f, 0.14653350f, 0.18155101f, 0.01766427f, -0.00849770f, 
    -0.01649336f, 0.01546213f, -0.02576604f, 0.05478626f, 0.03489360f, 0.01085137f, -0.00693620f, -0.06253336f, 
    0.04439636f, -0.06655970f, 0.05283904f, -0.07581699f, 0.05994308f, 0.05535308f, 0.02702061f, -0.04947093f, 
    0.03682561f, -0.03947536f, 0.06039960f, -0.02123256f, -0.06400923f, -0.05409883f, -0.00459753f, -0.02579442f, 
    0.03155427f, -0.07804789f, 0.00063172f, -0.05279750f, -0.02062169f, -0.03486136f, -0.05405920f, -0.06751307f, 
    0.01904088f, 0.00625863f, 0.01911136f, 0.02287052f, 0.03374905f, -0.05922297f, -0.02467266f, 0.03842617f, 
    -0.03556564f, -0.00946870f, 0.01967147f, 0.02684908f, -0.06272022f, -0.01926125f, 0.04315956f, -0.07422265f, 
    0.00405656f, -0.01948321f, 0.01671572f, 0.00829072f, -0.06527527f, -0.02704437f, -0.00426573f, -0.00145607f, 
    0.05824891f, -0.05684419f, -0.03377103f, -0.02117725f, 0.02956421f, 0.00192818f, 0.02395789f, -0.05223494f, 
    0.03451182f, -0.05216361f, -0.04589120f, 0.05593508f, -0.02616180f, -0.07484395f, -0.01684088f, -0.05765818f, 
    0.01329004f, 0.00573399f, 0.02562253f, -0.03270872f, 0.01751824f, 0.03653559f, -0.05509959f, 0.04552026f, 
    -0.02500671f, -0.03144744f, -0.06173516f, -0.06283229f, -0.04067390f, -0.06396525f, -0.07451642f, 0.04746418f, 
    0.02030045f, -0.01652646f, 0.03772059f, -0.05988528f, 0.03053476f, -0.04257049f, -0.04313017f, -0.05259397f, 
    0.05339263f, 0.00671325f, -0.06409777f, -0.02966742f, 0.03321667f, 0.02057212f, -0.05470403f, -0.00093419f, 
    -0.07542802f, -0.01376222f, 0.03324055f, 0.05321570f, 0.05183204f, -0.05492044f, -0.02135840f, 0.00076484f, 
    0.03131744f, -0.02799591f, -0.08006379f, 0.02105162f, 0.03383300f, -0.03043045f, 0.06037262f, 0.00831844f, 
    -0.00624240f, 0.03103657f, -0.03529799f, -0.02615615f, -0.05552389f, -0.05300048f, -0.00951468f, -0.07118616f, 
    -0.05675820f, -0.05620263f, 0.01140170f, 0.01368563f, -0.07528164f, 0.01521955f, 0.03839377f, 0.06542041f, 
    0.00987979f, -0.05335848f, 0.05491924f, -0.01630114f, 0.05787960f, 0.01753041f, -0.02780988f, 0.02911296f, 
    0.01828740f, 0.03839824f, 0.03235301f, -0.01673432f, 0.01872152f, -0.00394921f, -0.02830745f, 0.03413064f, 
    0.00391757f, -0.00962625f, -0.04274456f, 0.02790385f, -0.04075787f, 0.00501343f, -0.06108920f, 0.01893781f, 
    -0.03722286f, -0.07212220f, -0.02142083f, -0.01761021f, -0.05451688f, -0.01422856f, -0.04612073f, -0.04547128f, 
    -0.02357790f, -0.05095051f, 0.04222121f, -0.05196700f, 0.01810019f, -0.05667728f, -0.01086027f, -0.00552547f, 
    -0.05533696f, -0.06336077f, 0.05895391f, 0.04332868f, 0.03124880f, 0.03302798f, 0.00682760f, 0.06118167f, 
    -0.02246337f, -0.00024790f, -0.07365961f, -0.02381545f, -0.07106180f, -0.06436023f, 0.04670617f, 0.02513826f, 
    0.35992453f, 0.09478856f, 0.01146144f, -0.02246127f, -0.00315214f, 0.06604737f, 0.11989339f, -0.02604493f, 
    0.01959984f, -0.01702735f, 0.10340053f, -0.17984496f, 0.10834903f, -0.10147727f, 0.48724991f, 0.29924986f, 
    0.12817648f, 0.01559221f, 0.33050781f, -0.00634723f, 0.04797618f, -0.14953481f, -0.02353203f, -0.14455824f, 
    0.33916211f, 0.04508141f, -0.07040844f, 0.15793863f, 0.01705234f, 0.09997120f, -0.14054276f, 0.00352643f, 
    0.01698544f, 0.04062897f, 0.13236028f, 0.18515927f, 0.05454407f, 0.01110559f, 0.03417864f, -0.26502955f, 
    0.08233726f, 0.12186965f, -0.00393770f, 0.04188023f, -0.20730695f, 0.03849293f, -0.12413523f, -0.15778273f, 
    -0.23549177f, -0.27204183f, -0.21214145f, -0.03348675f, -0.15226722f, 0.03779066f, 0.01658899f, 0.04415106f, 
    0.10149577f, 0.04252216f, -0.06233629f, 0.01793017f, 0.11982750f, 0.03017454f, 0.06044013f, 0.18115281f, 
    -0.04906171f, -0.01232511f, 0.00480771f, 0.16837436f, 0.03928832f, -0.08839833f, 0.02954706f, 0.03037501f, 
    0.01415507f, -0.10358784f, -0.10195234f, -0.37799978f, -0.02391528f, -0.00227168f, -0.29685301f, -0.07977707f, 
    0.04504564f, 0.10657472f, -0.00336816f, 0.10130122f, -0.06339740f, 0.10283516f, 0.14128135f, -0.06740190f, 
    -0.12747930f, 0.03258421f, -0.01460618f, -0.01092111f, -0.17401670f, -0.03631509f, -0.02500603f, -0.02938298f, 
    -0.16018787f, 0.37112486f, 0.07396336f, 0.03922431f, 0.12609884f, -0.15875994f, 0.01184720f, -0.06578735f, 
    0.15999606f, 0.04989945f, 0.04029236f, 0.09698830f, -0.04130688f, -0.15732358f, 0.01582756f, 0.04015059f, 
    0.09041803f, 0.06851791f, 0.12045234f, -0.03969621f, -0.06210547f, -0.20866674f, 0.09182944f, -0.03090293f, 
    -0.04593083f, -0.30624989f, -0.04361647f, -0.11858127f, -0.08285686f, -0.01172026f, 0.05582181f, -0.07837833f, 
    -0.01863365f, -0.01154882f, -0.04611598f, -0.07692333f, 0.21014401f, -0.19430853f, -0.07449164f, -0.13235612f, 
    -0.02789487f, -0.11846632f, -0.12200617f, -0.16646472f, 0.10821210f, 0.10926287f, 0.09031332f, 0.24472387f, 
    0.05542037f, 0.20429017f, 0.16960818f, 0.05569332f, -0.05294002f, -0.03586688f, 0.05535345f, -0.00187480f, 
    -0.06654218f, 0.01215413f, 0.16569348f, 0.06284323f, 0.14550044f, 0.06562921f, -0.01005144f, 0.26766407f, 
    -0.12912965f, -0.08181459f, 0.03995853f, -0.00676258f, -0.18812291f, 0.21848065f, 0.03494097f, 0.11162648f, 
    0.16836236f, 0.11046443f, -0.12445775f, -0.20776871f, -0.13141201f, -0.11490995f, 0.15104632f, 0.00268816f, 
    -0.01808748f, 0.03991594f, 0.09346455f, 0.03127472f, -0.32069528f, 0.11403515f, 0.06957950f, 0.47679460f, 
    0.07945947f, 0.05485670f, 0.06183420f, 0.05604907f, 0.02153897f, -0.01392857f, 0.09694959f, 0.02018833f, 
    0.35580894f, -0.06858388f, 0.30781752f, -0.21778010f, -0.08992338f, -0.07471044f, -0.20033698f, 0.16309434f, 
    0.14425665f, 0.05991967f, 0.12188330f, -0.01253952f, -0.03367324f, 0.03604725f, 0.50432765f, 0.39105481f, 
    0.10573599f, 0.04564630f, -0.01680912f, 0.02117331f, 0.04702806f, -0.03299008f, 0.01337350f, -0.14895682f, 
    0.24486832f, -0.00705430f, 0.27741846f, -0.00370243f, -0.08958577f, -0.18522479f, -0.10701159f, 0.17200728f, 
    0.10400762f, 0.02719514f, 0.09617354f, 0.10096993f, 0.10995157f, -0.02209149f, 0.19807801f, 0.04667122f, 
    0.10480687f, 0.18487789f, 0.08961668f, 0.24562685f, 0.00792652f, -0.06740864f, -0.13247386f, 0.03062011f, 
    -0.19507767f, 0.02901652f, 0.13415539f, 0.00263114f, 0.01439863f, -0.00405972f, 0.00771014f, 0.02029479f, 
    -0.13636889f, -0.20033282f, 0.00877228f, 0.17582507f, 0.14703569f, -0.06756918f, 0.13013619f, 0.01570718f, 
    -0.06238529f, -0.06019679f, -0.06697668f, 0.05415857f, 0.03058171f, -0.02880436f, -0.12548107f, 0.01764734f, 
    -0.10028669f, 0.11359191f, 0.02346732f, 0.05828898f, 0.02490238f, -0.10679550f, -0.06871796f, 0.06414947f, 
    -0.11466034f, -0.09671042f, -0.01441221f, 0.00959868f, -0.21864234f, 0.00090780f, 0.07367034f, 0.06308985f, 
    -0.11918128f, -0.13496603f, 0.07100955f, 0.02221256f, 0.13352363f, 0.10345403f, -0.21226540f, 0.05577879f, 
    -0.66183019f, 0.07555860f, -0.16002117f, 0.12211809f, 0.00990508f, -0.01678729f, 0.16708414f, -0.05800380f, 
    -0.05882686f, -0.07374781f, -0.16353409f, 0.03819864f, 0.12746002f, -0.02503824f, 0.01488199f, -0.03690430f, 
    -0.02280022f, -0.00663653f, -0.04228510f, -0.01952048f, 0.01933093f, -0.13256678f, 0.12006349f, -0.01101262f, 
    -0.25993580f, -0.12853049f, -0.20381305f, -0.07068146f, 0.08183773f, -0.07928730f, 0.22958751f, 0.20332073f, 
    -0.18291509f, 0.09770050f, -0.06673415f, 0.10171711f, 0.47894132f, -0.21920392f, 0.17493601f, -0.30377823f, 
    -0.00099792f, 0.00995920f, -0.24436201f, 0.04770177f, 0.03517990f, -0.16632302f, 0.00878650f, -0.00707184f, 
    0.09551927f, 0.10380610f, 0.07403247f, 0.06767989f, -0.09581219f, 0.00605369f, -0.08388720f, -0.11026047f, 
    0.03485657f, 0.02700973f, -0.06807837f, -0.07243588f, 0.34865627f, 0.15406762f, 0.13931209f, 0.06741663f, 
    -0.14719266f, -0.06453565f, -0.04001350f, 0.08689583f, 0.08041826f, 0.04081802f, 0.02202740f, -0.02050912f, 
    0.16346915f, 0.05070308f, 0.10712179f, -0.08218736f, -0.02717775f, -0.14163241f, 0.00886630f, 0.18423249f, 
    0.08386683f, 0.11647300f, 0.02933148f, -0.11787935f, 0.01423898f, -0.00418651f, 0.30297202f, 0.26685449f, 
    -0.07989162f, 0.10178971f, -0.13517635f, -0.04708405f, 0.01552444f, -0.04066222f, 0.06858154f, 0.01796897f, 
    -0.06560533f, 0.53586495f, 0.21185023f, 0.14056832f, 0.09899304f, -0.05513581f, -0.04557725f, 0.02482012f, 
    -0.03259098f, 0.11758376f, 0.02560363f, 0.01985075f, -0.32637095f, -0.04611083f, 0.10324388f, 0.06111422f, 
    -0.06146514f, -0.06217680f, -0.05442199f, -0.04323051f, -0.04415989f, 0.10050974f, 0.09943756f, -0.02375549f, 
    0.46620825f, 0.13758960f, -0.17418240f, 0.12905210f, -0.09093537f, 0.08056886f, 0.00305536f, 0.03761219f, 
    -0.04610440f, 0.21250123f, -0.09751505f, 0.14607002f, 0.15513784f, 0.10293134f, 0.18937595f, -0.03470221f, 
    0.00348324f, 0.07557358f, -0.15549935f, 0.08893810f, -0.02202042f, 0.07708541f, -0.09916349f, -0.06299337f, 
    -0.23237233f, -0.06544530f, 0.12375633f, 0.19160779f, 0.09204566f, 0.02351994f, -0.07191296f, -0.01575300f, 
    0.08118019f, 0.22992808f, 0.08075529f, 0.11541404f, 0.04537207f, -0.01709690f, -0.10178921f, 0.20114388f, 
    0.15016191f, 0.04265724f, 0.17466171f, 0.08887276f, 0.04341384f, -0.04854186f, 0.02701425f, -0.00868632f, 
    -0.07741112f, -0.03710642f, 0.00237669f, 0.09022090f, 0.00758417f, -0.02955719f, -0.00832368f, 0.01862981f, 
    0.03858747f, 0.09335675f, -0.03203021f, 0.00662231f, 0.26490748f, -0.09026948f, 0.05889363f, -0.14774977f, 
    0.04561792f, -0.02544731f, 0.03295732f, -0.03880975f, -0.05608816f, -0.08941898f, -0.08629213f, -0.12668179f, 
    -0.23518178f, 0.12110490f, -0.41856301f, 0.31241605f, -0.08294630f, -0.11599903f, -0.04244697f, 0.17258206f, 
    -0.10248394f, -0.12414991f, -0.01511772f, 0.01823292f, -0.04973244f, -0.02341781f, -0.07611393f, -0.09009673f, 
    -0.12721442f, 0.03763321f, 0.03415733f, 0.06174276f, 0.08270089f, -0.13781531f, 0.02300978f, -0.14742666f, 
    -0.05517256f, -0.13860768f, 0.25309697f, 0.27179304f, -0.05363750f, 0.19660953f, -0.18328112f, -0.02827870f, 
    0.06057999f, -0.03030364f, 0.01114617f, -0.01884886f, 0.13342622f, 0.24801904f, -0.00486765f, -0.03750674f, 
    0.00971557f, 0.10097007f, 0.11292273f, -0.02162164f, 0.00700026f, 0.11389288f, 0.11752594f, 0.25561896f, 
    0.21710314f, 0.01118502f, -0.09145336f, 0.10917218f, -0.05570753f, -0.01207672f, -0.04022719f, 0.02132602f, 
    0.08668146f, 0.02889658f, 0.07569456f, -0.07047757f, 0.02138686f, 0.11460731f, -0.10922725f, 0.06070557f, 
    0.01295450f, -0.02917990f, -0.17647646f, 0.09050155f, -0.18416616f, -0.00047020f, 0.16589630f, 0.07883292f, 
    -0.34345022f, 0.05314783f, -0.11896502f, 0.26422155f, 0.20374556f, 0.22043972f, -0.06410533f, -0.14745313f, 
    0.03631441f, -0.06029630f, 0.03089982f, 0.04423514f, -0.39131477f, -0.04050916f, -0.07317431f, 0.36593828f, 
    0.09374543f, -0.09494430f, -0.09277637f, 0.00029006f, 0.04288151f, 0.13997510f, -0.07430252f, -0.00585227f, 
    -0.00788351f, 0.03623789f, 0.03931532f, 0.03640273f, 0.00138295f, -0.01709580f, 0.03011760f, -0.04947448f, 
    0.05453320f, 0.03166773f, -0.02411639f, 0.04215945f, -0.06788905f, -0.03514116f, -0.01143823f, -0.02738502f, 
    0.01712749f, 0.01754117f, -0.01568778f, -0.04134554f, -0.04965958f, -0.01649708f, -0.02520637f, -0.01696826f, 
    0.03087685f, -0.01839718f, 0.02361529f, 0.00637859f, -0.03013290f, 0.04040774f, 0.00594026f, 0.02958559f, 
    -0.04841934f, -0.04265336f, 0.01177501f, 0.04251896f, -0.05380324f, -0.05443823f, 0.07002401f, -0.02837737f, 
    -0.03819565f, -0.02516213f, -0.03554214f, -0.04233359f, 0.00596662f, -0.07208073f, 0.00751318f, -0.05955896f, 
    -0.04655917f, 0.06992775f, 0.04027488f, -0.03534065f, 0.05486493f, -0.01679619f, 0.01290098f, -0.00755825f, 
    0.03204821f, 0.04901376f, -0.07471979f, -0.01468181f, -0.01351497f, -0.01889386f, -0.03240598f, 0.04192215f, 
    -0.02857790f, -0.06672290f, -0.04928385f, -0.01322784f, -0.03637262f, 0.04929488f, 0.02586174f, 0.00994992f, 
    0.00173082f, -0.01420396f, 0.01381946f, 0.00000682f, 0.02551897f, -0.01279305f, -0.03824196f, 0.05471761f, 
    0.03807104f, 0.04440475f, 0.06601269f, -0.04607166f, 0.01918660f, 0.04874000f, 0.06116385f, 0.01471841f, 
    -0.02861359f, -0.04746463f, 0.00421750f, -0.07306305f, 0.01060133f, -0.01264488f, -0.04314091f, 0.02003462f, 
    -0.02166866f, -0.04962401f, -0.04195172f, 0.01123381f, -0.04162293f, 0.04785352f, 0.03028988f, -0.00712508f, 
    -0.02332663f, -0.01129336f, -0.04718527f, -0.05884307f, -0.07074592f, 0.05892714f, 0.03592835f, -0.02024828f, 
    0.04777918f, -0.00499053f, 0.05858596f, 0.04556146f, 0.00748818f, 0.02727752f, -0.05456752f, -0.02353779f, 
    -0.05591781f, -0.01943314f, -0.06139155f, 0.00457983f, -0.03127303f, -0.07609511f, 0.01220565f, -0.03654226f, 
    -0.05239945f, -0.04571914f, 0.00911652f, -0.04048764f, -0.06604304f, -0.05753758f, 0.06092778f, -0.02378041f, 
    0.05742190f, -0.02620048f, -0.05367212f, -0.01388073f, -0.05085705f, 0.00733311f, 0.03917739f, -0.06902395f, 
    -0.00884476f, -0.07517555f, -0.03000887f, -0.03334874f, -0.04430867f, -0.01343270f, 0.00011565f, -0.06012922f, 
    0.02926467f, -0.04515887f, -0.02877727f, 0.01042947f, 0.06355148f, 0.02323703f, 0.05992534f, 0.01440669f, 
    0.06474642f, -0.05026282f, 0.01644849f, -0.03370193f, -0.03663781f, 0.03259372f, -0.06179276f, -0.03887660f, 
    0.05417406f, -0.07243083f, -0.03490689f, 0.05482177f, 0.06078608f, -0.03019425f, -0.00707752f, 0.06256403f, 
    0.00543120f, -0.03033826f, -0.03894898f, 0.00296942f, -0.02159721f, 0.01062152f, -0.05427941f, 0.05220673f, 
    0.02318382f, -0.04159750f, -0.07405280f, -0.04296670f, 0.01447136f, 0.00740824f, -0.03866938f, -0.05444475f, 
    0.35636929f, -0.17936222f, -0.08160390f, -0.46962106f, -0.03762543f, -0.05986236f, 0.02763144f, 0.02568473f, 
    -0.03295136f, 0.00088658f, 0.05103272f, 0.13340452f, 0.17555878f, 0.01219717f, 0.27562147f, 0.17010790f, 
    -0.02092937f, -0.04360897f, 0.13318799f, -0.08209290f, 0.16142669f, -0.15329303f, -0.01590503f, 0.03070031f, 
    0.24917935f, -0.06492113f, -0.14500506f, -0.07185283f, 0.08485837f, 0.06102065f, -0.02010133f, -0.05369720f, 
    -0.08785771f, -0.03489333f, 0.13422155f, -0.08761337f, -0.05877738f, -0.03091384f, 0.09195548f, -0.07662608f, 
    0.10005902f, 0.08562241f, -0.00173026f, 0.09119176f, -0.05471558f, 0.04037938f, -0.06189989f, 0.00709857f, 
    0.20306483f, 0.09495675f, 0.09519598f, -0.01534165f, -0.18534580f, 0.00800830f, 0.00196093f, 0.04797858f, 
    0.07027014f, 0.01071140f, 0.03414151f, 0.02513169f, 0.06714065f, -0.10926258f, -0.06396082f, 0.06441534f, 
    -0.00350749f, 0.14789489f, 0.00339801f, 0.04711455f, -0.01087755f, 0.04299665f, -0.05160656f, -0.09027316f, 
    0.14173350f, 0.31550160f, -0.00161253f, -0.16410199f, 0.01106367f, -0.10418814f, -0.03033112f, 0.02022639f, 
    0.18002361f, 0.04614241f, 0.13195527f, 0.03398150f, -0.05764378f, -0.23053268f, -0.07804241f, 0.35955659f, 
    -0.05083136f, -0.15889104f, -0.08929496f, 0.00520783f, 0.00395871f, 0.03030529f, -0.03879114f, -0.04883273f, 
    0.36083192f, -0.24774024f, 0.29909757f, 0.05702481f, 0.24608603f, -0.01462295f, 0.03632982f, -0.00933836f, 
    0.09390035f, -0.06929754f, -0.02930930f, -0.09304216f, -0.13952684f, 0.04266246f, 0.03126922f, -0.00557395f, 
    0.15715526f, 0.14146601f, -0.07919005f, -0.01534469f, -0.02058812f, -0.08701357f, -0.03622578f, -0.06837175f, 
    -0.11107921f, 0.07924628f, -0.02525033f, -0.38652375f, -0.16339909f, -0.00752515f, -0.06811982f, 0.05288489f, 
    -0.13518846f, 0.03439952f, -0.03706464f, 0.07192736f, 0.08290628f, -0.18064399f, -0.00360966f, -0.15099162f, 
    -0.08100323f, 0.09559771f, -0.05655803f, 0.03783454f, 0.09528442f, -0.00770798f, 0.09805046f, 0.08727404f, 
    -0.06222846f, 0.19293095f, 0.14365289f, 0.20573853f, 0.08109701f, 0.04532567f, 0.04589735f, 0.02015784f, 
    0.08177377f, 0.08535295f, -0.01363348f, -0.02590167f, 0.12796442f, -0.30128291f, 0.00021642f, 0.00843412f, 
    -0.07820492f, -0.00353571f, -0.05198487f, -0.04479664f, -0.10224546f, 0.00259901f, -0.05792597f, 0.00896999f, 
    0.29647654f, -0.50503534f, 0.25146511f, -0.11332528f, -0.09947889f, -0.04454276f, -0.04806768f, 0.06571055f, 
    0.01306842f, -0.04769811f, -0.02655984f, 0.03099730f, 0.06356086f, -0.14293306f, 0.08795337f, 0.43852755f, 
    0.02244399f, -0.03064741f, -0.10600805f, -0.13065825f, 0.09072296f, -0.04017077f, 0.08187314f, 0.07367651f, 
    0.05563025f, -0.08057725f, -0.24936481f, -0.19789726f, -0.04831770f, -0.16578540f, 0.03850090f, 0.04265342f, 
    0.07391463f, 0.12629484f, 0.06943735f, -0.08916481f, -0.01039875f, 0.04232532f, -0.15809622f, 0.00268057f, 
    0.02227157f, 0.06526355f, 0.03764331f, 0.10842773f, -0.08740602f, 0.04273342f, 0.09901433f, 0.00808494f, 
    0.00489518f, 0.15112095f, 0.05160313f, 0.28930059f, -0.08773459f, 0.02181958f, -0.07656293f, 0.00225037f, 
    0.14957945f, 0.08641321f, 0.13653444f, 0.03873286f, -0.11611067f, -0.10036936f, -0.20830984f, -0.22408882f, 
    0.00334612f, -0.10506597f, 0.08547749f, 0.05832371f, -0.00882612f, -0.04242627f, -0.11969659f, -0.04942346f, 
    -0.26648140f, -0.19146049f, -0.00543777f, 0.10217050f, -0.12377758f, -0.01055804f, -0.05660510f, 0.04476865f, 
    -0.15994915f, 0.14712243f, 0.19202606f, 0.00424175f, 0.04118773f, 0.08207634f, 0.05468291f, 0.00870139f, 
    -0.02940265f, 0.00951363f, -0.00358559f, -0.06719305f, -0.17034638f, 0.11518046f, -0.06693488f, -0.12566848f, 
    0.00769493f, -0.17923057f, -0.11864884f, 0.10553396f, 0.01333246f, -0.06118386f, -0.07658662f, 0.08892160f, 
    -0.03015157f, 0.01928212f, 0.01599925f, 0.03852046f, 0.48409188f, 0.17884840f, 0.27517673f, 0.27138218f, 
    -0.16104504f, 0.09751172f, -0.04743752f, -0.05306009f, -0.12833767f, -0.01188220f, -0.02358809f, -0.21519604f, 
    0.22261487f, -0.00182814f, -0.08747210f, -0.04480118f, 0.15944600f, 0.00889316f, -0.11528545f, 0.04537899f, 
    0.07316323f, -0.08950436f, -0.11951071f, -0.09525211f, -0.01786810f, -0.00711797f, 0.11163025f, -0.17003970f, 
    0.02278352f, 0.02453507f, -0.19736300f, -0.08374713f, -0.07300010f, -0.12847933f, 0.05726986f, -0.05091148f, 
    0.14291286f, -0.07874584f, 0.01145691f, 0.05669662f, 0.16513914f, 0.02409186f, 0.11796159f, 0.08100239f, 
    -0.02684023f, -0.02617959f, -0.25916973f, -0.05948120f, -0.06148122f, 0.26065063f, 0.30879855f, 0.26256585f, 
    -0.09007760f, 0.12589365f, 0.25432470f, -0.01339699f, -0.06074242f, 0.06128481f, 0.20326537f, 0.13384499f, 
    0.31685421f, 0.26511559f, 0.10861722f, 0.04470121f, -0.06925876f, 0.07062998f, 0.08514488f, -0.06699652f, 
    -0.03279814f, -0.04905975f, 0.04103341f, -0.06872135f, 0.37760368f, 0.10205562f, 0.01589676f, 0.20606051f, 
    0.08534547f, 0.13901901f, -0.05294517f, 0.00050143f, -0.13836743f, 0.22560106f, 0.33959866f, 0.03497553f, 
    -0.13153014f, 0.04994504f, -0.01238366f, 0.04421723f, 0.01176846f, 0.31465590f, -0.19824126f, 0.11979285f, 
    -0.06069625f, -0.08679133f, 0.13021363f, 0.09400642f, 0.00846597f, 0.13480926f, -0.04122213f, -0.08693790f, 
    -0.03211343f, -0.16603792f, -0.11609425f, 0.00106686f, -0.12673311f, 0.15357880f, 0.03413317f, -0.06649490f, 
    0.00068157f, -0.05904299f, -0.02981511f, 0.04946600f, 0.04531178f, 0.06612957f, -0.05325830f, 0.01379614f, 
    0.02873929f, -0.00818520f, -0.04701382f, -0.03483794f, -0.03481289f, -0.02510644f, -0.06396220f, -0.01343196f, 
    0.05187823f, -0.00109624f, -0.01751996f, -0.07681009f, 0.03300946f, -0.03670312f, -0.03249095f, 0.03217359f, 
    -0.04373023f, 0.00815891f, -0.05905331f, 0.00072740f, -0.02486167f, -0.03657052f, -0.05920659f, -0.04273322f, 
    -0.01650431f, -0.03374358f, 0.05862862f, -0.05588054f, -0.03439193f, 0.03455786f, 0.06763324f, 0.00955399f, 
    0.04372836f, 0.01005727f, 0.04661585f, 0.01855494f, 0.07264543f, -0.02354592f, -0.01046183f, -0.06079878f, 
    -0.06688311f, -0.04874285f, -0.00008058f, 0.02670375f, -0.01442095f, -0.03249965f, 0.00939732f, 0.06426869f, 
    -0.02738781f, -0.00758767f, -0.04110121f, 0.01440949f, 0.06431581f, -0.04393645f, 0.01107079f, 0.01614384f, 
    -0.05163310f, -0.06300101f, -0.05536662f, 0.06710473f, 0.03886172f, 0.03646976f, 0.05736519f, 0.02149649f, 
    0.02212156f, -0.02018008f, -0.01601552f, 0.00512863f, -0.03348840f, 0.00737134f, 0.04575998f, -0.05978992f, 
    -0.06129660f, -0.04103856f, 0.02994132f, -0.02432650f, -0.02303199f, -0.05925504f, 0.00037797f, -0.05385352f, 
    -0.07636517f, -0.03071027f, 0.04683137f, 0.01431222f, -0.01028268f, -0.04789861f, -0.06664985f, -0.05703474f, 
    -0.04375172f, 0.03662878f, -0.05650677f, -0.06119461f, -0.05339950f, 0.02058649f, -0.01835642f, -0.07005636f, 
    -0.07222037f, -0.03276734f, 0.05830373f, -0.07345425f, 0.03488132f, -0.00754551f, -0.00790150f, 0.06419902f, 
    0.02153137f, -0.02648415f, -0.04209719f, -0.02331205f, -0.03513733f, 0.06573226f, -0.02638344f, 0.01590505f, 
    -0.02466940f, -0.00114362f, -0.05444011f, 0.02041972f, 0.00734020f, -0.06464392f, -0.06128030f, -0.06818946f, 
    -0.07864476f, -0.03657611f, -0.04587122f, -0.03954688f, -0.03437328f, -0.02491455f, -0.06363202f, 0.02950970f, 
    0.05169709f, -0.01534291f, 0.00993668f, 0.04597465f, 0.01868713f, 0.06481003f, 0.01738220f, 0.03485040f, 
    -0.02109712f, 0.01721027f, -0.02277230f, 0.03863878f, 0.05813176f, -0.06261436f, -0.01401156f, -0.07487824f, 
    -0.01962903f, 0.06106269f, -0.03012788f, -0.01185156f, 0.02111731f, -0.00467839f, -0.06676009f, 0.05366324f, 
    0.04756995f, -0.00009748f, -0.02725273f, -0.03646135f, 0.01319386f, -0.01823779f, 0.02240093f, -0.04363682f, 
    0.02992730f, 0.05278032f, 0.05136032f, -0.01910524f, 0.05587067f, 0.04356860f, 0.04388794f, 0.04733486f, 
    -0.01002756f, 0.03833807f, 0.00579605f, -0.03230781f, -0.04244226f, -0.05290532f, -0.01820401f, 0.03240095f, 
    0.06657986f, 0.05922071f, -0.02664163f, -0.06352821f, -0.06894263f, -0.04427855f, -0.04154362f, 0.05943266f, 
    -0.30507654f, -0.03946374f, -0.22171463f, -0.06594083f, 0.12981212f, 0.10156883f, 0.13687861f, -0.00092694f, 
    0.14076538f, 0.11994102f, -0.04829451f, 0.04712720f, -0.05753292f, 0.12757772f, -0.21029264f, -0.23257802f, 
    0.14807984f, -0.00470023f, -0.07116716f, -0.00014664f, -0.05961706f, 0.10208243f, -0.06568622f, 0.26514015f, 
    0.14253585f, -0.04073127f, -0.16633752f, 0.05779887f, -0.02291465f, -0.04480029f, 0.10086268f, 0.06306601f, 
    0.10055863f, 0.09618229f, 0.13734581f, -0.02452234f, -0.03470012f, -0.11535457f, -0.18019444f, 0.00737456f, 
    0.04889857f, -0.13575958f, -0.09263991f, 0.03678026f, 0.10139039f, 0.11490045f, -0.04479975f, -0.07847501f, 
    -0.10800622f, -0.02909583f, 0.02507404f, -0.07159238f, 0.16650453f, 0.12109257f, -0.01850762f, -0.13786699f, 
    -0.10378439f, 0.04047254f, 0.03745829f, -0.06777649f, -0.03238973f, 0.08969236f, -0.06509256f, -0.13033092f, 
    0.23043582f, 0.07320422f, 0.12289315f, -0.17737889f, -0.05362447f, 0.10505389f, 0.16457568f, -0.06604532f, 
    0.01163313f, -0.10119590f, 0.08943160f, 0.12275340f, -0.04230552f, 0.06882332f, 0.08496035f, -0.00999579f, 
    -0.02297390f, -0.05708441f, 0.07428487f, -0.00196046f, 0.10353175f, 0.07689925f, 0.00420756f, -0.02273433f, 
    0.10755313f, -0.00234183f, -0.00164775f, -0.00329364f, -0.07142421f, -0.04543777f, 0.05005036f, -0.08231179f, 
    0.27620739f, -0.36649448f, 0.12245262f, -0.01557605f, 0.07367995f, -0.09595869f, 0.11562127f, 0.14997771f, 
    0.07239338f, 0.10246620f, -0.03102076f, -0.10754707f, 0.02097664f, 0.02477449f, 0.07604648f, -0.00628487f, 
    0.07869580f, -0.08850861f, -0.20565702f, 0.08897136f, -0.04652964f, 0.02354586f, 0.04371392f, 0.05291522f, 
    0.26537803f, 0.17896464f, 0.00607011f, 0.06818059f, 0.02698905f, 0.00246249f, 0.08837536f, -0.06477208f, 
    0.01920419f, -0.00010151f, -0.07195830f, 0.00927596f, -0.08529435f, 0.25991508f, 0.01888902f, 0.26658958f, 
    -0.00099724f, 0.05361208f, 0.08981887f, -0.01347004f, 0.05605305f, 0.07357401f, -0.03479444f, -0.08633313f, 
    0.17432195f, -0.15407902f, -0.02155943f, -0.06812033f, -0.10820268f, 0.03368877f, -0.04703003f, -0.06623600f, 
    0.03042330f, -0.00045797f, -0.06457681f, -0.05637316f, -0.08008266f, 0.01701435f, 0.00667158f, -0.04346742f, 
    0.04814815f, -0.02658915f, 0.01125976f, -0.06388472f, 0.14244542f, -0.01057738f, 0.16516268f, 0.00281866f, 
    -0.28910881f, 0.15707311f, -0.16129275f, 0.26553530f, 0.09458345f, 0.12650737f, 0.06412973f, -0.00438685f, 
    0.11178511f, -0.10265756f, 0.01027616f, 0.07891168f, 0.01004665f, -0.15810980f, 0.29781193f, -0.29195365f, 
    0.04426380f, -0.05612724f, -0.00971403f, 0.03847649f, 0.17740946f, 0.08388688f, 0.12127626f, 0.04302020f, 
    0.23581994f, 0.11262268f, -0.25434431f, -0.03854933f, 0.04074050f, -0.04551080f, -0.00105575f, 0.05043035f, 
    -0.00905058f, -0.07030120f, 0.00992691f, -0.17677708f, 0.06167092f, 0.02890511f, 0.38403130f, 0.06002213f, 
    0.01188167f, 0.06385005f, 0.12173640f, -0.05569153f, -0.08067439f, -0.15111487f, -0.02926803f, -0.07721631f, 
    0.06798872f, 0.19292456f, -0.18715584f, 0.24811144f, -0.04744842f, 0.17070317f, 0.01993447f, 0.08918668f, 
    -0.16847911f, 0.04476885f, 0.15183786f, -0.03231974f, 0.21513987f, 0.10039778f, 0.26251227f, 0.13086425f, 
    0.02771286f, 0.17143784f, 0.00823626f, -0.02504755f, 0.01243749f, -0.01308318f, -0.05327394f, 0.07438175f, 
    0.13073631f, 0.10913570f, 0.05774147f, 0.00359993f, 0.04599217f, 0.02986831f, -0.06066255f, -0.03957449f, 
    0.16683929f, 0.07662543f, -0.02324828f, -0.06738534f, -0.02775037f, 0.04386621f, -0.01587708f, 0.19347379f, 
    0.04803856f, 0.06602245f, 0.09730570f, 0.02571235f, -0.02552106f, -0.03371465f, 0.02481491f, 0.01212922f, 
    0.10780130f, 0.22798574f, 0.07143139f, -0.04426603f, 0.08846187f, -0.13950579f, -0.07845532f, 0.03265754f, 
    -0.07591697f, 0.01101487f, -0.05776180f, -0.02337852f, 0.13180113f, 0.02655538f, 0.18276992f, 0.11267333f, 
    -0.17868879f, -0.16607539f, 0.02629130f, 0.02114076f, -0.05932441f, 0.03472369f, -0.03698576f, 0.06821147f, 
    -0.31703597f, 0.44106793f, 0.26936129f, -0.04179510f, -0.17437634f, -0.08338242f, -0.13261925f, -0.06548367f, 
    -0.02133993f, -0.10448987f, -0.02659360f, 0.17394014f, 0.04265109f, 0.14361969f, 0.11666119f, -0.06676212f, 
    -0.01989518f, 0.19057581f, 0.00799368f, -0.09134233f, -0.04593317f, 0.02703273f, 0.12174817f, -0.00553842f, 
    0.03675457f, -0.14324586f, 0.20903039f, 0.06376145f, -0.04014233f, 0.17845635f, -0.11375597f, -0.10522273f, 
    -0.12125472f, -0.07048722f, -0.02689478f, -0.00524168f, 0.08440297f, -0.24736595f, -0.14154778f, -0.08329868f, 
    -0.06918336f, -0.00084981f, -0.04310238f, -0.03119236f, -0.02284168f, -0.20967667f, -0.00969004f, -0.03252297f, 
    -0.00443526f, 0.06835449f, 0.08107144f, 0.10333433f, 0.03301777f, -0.00417069f, 0.00825516f, -0.01821338f, 
    0.00356858f, 0.07877374f, 0.03531035f, 0.01518920f, 0.00052208f, -0.00228134f, -0.10557541f, 0.00565423f, 
    0.01831468f, -0.04123800f, -0.05134761f, 0.13658589f, -0.09449009f, -0.02933200f, -0.14900199f, -0.01788835f, 
    0.09855919f, 0.07428720f, 0.01453681f, -0.03121188f, -0.11225083f, -0.03681987f, 0.12232127f, 0.01491883f, 
    -0.10994770f, 0.05982752f, 0.00024503f, -0.00595032f, -0.13373537f, 0.18272778f, -0.22352229f, 0.03500002f, 
    -0.15091206f, 0.11314420f, 0.10770227f, 0.02499170f, 0.08064467f, 0.04158582f, -0.01389197f, -0.02951161f, 
    0.17804709f, -0.16083026f, 0.06650185f, 0.22750260f, 0.04175268f, 0.06497952f, 0.08847468f, -0.12112024f, 
    0.08702675f, 0.00227474f, 0.02616923f, 0.14246756f, 0.13449532f, 0.08498014f, -0.06818083f, 0.10451315f, 
    0.08170374f, -0.04495152f, 0.15928285f, -0.06969678f, 0.13194846f, -0.11816330f, 0.09790738f, 0.00799168f, 
    -0.05368323f, -0.09486465f, 0.20339720f, 0.10396704f, -0.09437234f, 0.06377709f, -0.22057885f, -0.15782775f, 
    0.10720409f, 0.10937743f, -0.18452568f, 0.05802119f, -0.12105091f, -0.10708793f, -0.20851092f, 0.06093008f, 
    -0.00948447f, 0.00253934f, 0.11560906f, 0.17450432f, -0.08576994f, -0.00336592f, -0.04803622f, -0.06265473f, 
    -0.09215063f, -0.25555500f, -0.26851517f, 0.00928381f, 0.01188739f, 0.07972154f, 0.12081107f, 0.21995026f, 
    -0.09199411f, -0.05399369f, -0.08541134f, -0.04610742f, 0.04327099f, -0.06058849f, -0.06668228f, -0.08107188f, 
    -0.04085751f, 0.00159453f, -0.01109154f, 0.14434005f, 0.14737014f, 0.16462590f, 0.05256145f, 0.02395649f, 
    -0.13060945f, -0.29993001f, -0.01583514f, -0.10286424f, 0.06611405f, -0.00602674f, 0.04475580f, 0.02207617f, 
    0.01451111f, 0.05666143f, -0.01838568f, 0.08337756f, 0.04441437f, 0.20772302f, 0.14461140f, -0.18995315f, 
    -0.05977244f, 0.00178598f, -0.02721952f, -0.03196004f, -0.14298132f, 0.08310136f, -0.02204121f, -0.01826858f, 
    0.53152263f, 0.16698028f, -0.07482470f, 0.01504764f, 0.14833063f, -0.02561127f, 0.09081896f, -0.13945591f, 
    0.00204394f, 0.03442859f, -0.01149046f, -0.06652619f, -0.06803107f, -0.34587163f, -0.19723292f, -0.09626527f, 
    0.10157855f, -0.00634865f, 0.02923884f, 0.03829659f, -0.02785814f, 0.08770834f, 0.09139322f, 0.26064375f, 
    0.25488767f, -0.03852177f, -0.10923909f, 0.06169815f, 0.01395514f, -0.00496960f, -0.01238447f, -0.01091961f, 
    0.14078218f, -0.09405388f, -0.08650427f, 0.06391826f, -0.17535815f, 0.16778703f, 0.11790939f, 0.12272394f, 
    -0.09227841f, 0.05826159f, 0.07070985f, -0.01662778f, 0.00585316f, 0.22894001f, -0.03633383f, 0.10029801f, 
    -0.22363575f, 0.10150146f, 0.10673983f, -0.16138953f, -0.03098154f, 0.00078721f, -0.03032900f, 0.07355330f, 
    -0.20359427f, 0.00816217f, 0.09475388f, 0.05853244f, -0.16949540f, 0.04884866f, 0.14961688f, 0.08828035f, 
    -0.11682846f, -0.03935482f, -0.07530636f, -0.15301298f, -0.05350980f, 0.19204627f, 0.08990104f, 0.05419694f, 
    -0.06654897f, 0.38428757f, -0.10847460f, 0.09254801f, 0.11384474f, 0.11570442f, -0.02741065f, -0.14105816f, 
    -0.13572326f, 0.01210230f, 0.10138226f, 0.00567795f, -0.04893053f, 0.01866080f, -0.06423774f, -0.02964326f, 
    0.12159021f, -0.02870168f, -0.00734395f, 0.01469718f, 0.11576336f, 0.10060953f, 0.07195605f, 0.23444943f, 
    -0.13841918f, 0.32565603f, 0.08347839f, 0.21549995f, -0.09604643f, -0.14266436f, -0.08661261f, 0.07716262f, 
    0.09723087f, 0.22066091f, -0.05188359f, 0.10521093f, 0.15513727f, 0.03873662f, -0.14570430f, -0.01197102f, 
    -0.05128264f, 0.16689803f, -0.01563585f, 0.16524960f, -0.18107219f, -0.00590132f, 0.02619515f, 0.09156113f, 
    -0.23436362f, 0.15623793f, 0.06191267f, -0.23518370f, -0.13115115f, -0.01538105f, 0.20827450f, -0.32709557f, 
    -0.21952562f, 0.12223592f, 0.00890630f, 0.09988053f, 0.01577958f, 0.12255445f, 0.10237177f, 0.05736856f, 
    0.00498703f, 0.02203706f, 0.02351691f, -0.01444873f, -0.08259812f, -0.19271260f, -0.10396177f, -0.25075990f, 
    0.28653157f, 0.16631123f, 0.07479186f, 0.02245081f, -0.10243634f, -0.14689432f, -0.08387869f, -0.04390229f, 
    0.24531853f, 0.17898619f, 0.14784463f, -0.03100384f, -0.18307839f, -0.08228481f, 0.22280954f, -0.23025128f, 
    0.01591286f, -0.09874916f, -0.15501671f, -0.06944765f, 0.06543999f, -0.04803165f, -0.11145972f, -0.03927001f, 
    0.14172380f, 0.24166469f, 0.05392927f, 0.06511124f, -0.05515301f, 0.15356541f, 0.05488687f, -0.00304416f, 
    0.07719915f, -0.10044905f, 0.00567167f, -0.01888903f, 0.03656241f, 0.04401783f, -0.06659020f, 0.20089802f, 
    0.09955098f, 0.15836380f, -0.13346595f, -0.15479273f, -0.25916353f, -0.49925828f, 0.01901439f, -0.06954248f, 
    0.04299197f, 0.07133412f, 0.33595511f, -0.01504750f, -0.05806927f, 0.11268602f, -0.24561802f, 0.00533418f, 
    -0.13079423f, -0.02593326f, -0.05114885f, 0.02069676f, -0.03327023f, 0.18284787f, 0.07508538f, 0.15339445f, 
    -0.09404146f, 0.09406162f, -0.00790546f, -0.12840526f, -0.08994006f, -0.16092992f, -0.40172255f, -0.09895925f, 
    -0.13982818f, -0.08433493f, 0.01951309f, -0.05021276f, 0.25389761f, 0.10445397f, -0.05278455f, 0.15968652f, 
    -0.16909631f, 0.05234219f, 0.05996801f, -0.12712714f, -0.09766781f, -0.00354366f, -0.13794385f, 0.12207937f, 
    -0.11236875f, -0.13294663f, 0.15658216f, 0.14681710f, 0.08199501f, 0.23948620f, 0.12561598f, 0.24606290f, 
    -0.07292551f, -0.04135838f, -0.03410042f, 0.06052825f, 0.26644084f, -0.02720356f, -0.14587095f, -0.18940981f, 
    -0.10277497f, -0.15930091f, 0.02431944f, 0.23055813f, -0.21717010f, -0.21503279f, 0.01949491f, 0.04377948f, 
    -0.19639325f, -0.19462593f, -0.05994807f, -0.12799367f, 0.05402764f, -0.02685739f, 0.05739000f, 0.08316324f, 
    0.30059555f, -0.10852229f, 0.21393751f, 0.12085332f, 0.05531418f, 0.08674516f, 0.04741073f, 0.11696758f, 
    -0.04404241f, -0.03796740f, -0.32675081f, 0.06594218f, 0.15527892f, 0.45161590f, 0.15902117f, 0.01219917f, 
    -0.22144660f, -0.00542953f, -0.18811226f, -0.20646515f, 0.13376024f, 0.00308180f, 0.05924981f, -0.05646202f, 
    -0.17350236f, -0.01307139f, -0.08161576f, -0.32488504f, -0.03742957f, -0.16375615f, -0.20288138f, 0.01901895f, 
    -0.08224660f, 0.02694573f, 0.07076368f, -0.06476272f, -0.35368511f, -0.00822278f, 0.03778910f, 0.03267346f, 
    0.01557568f, -0.00645398f, -0.23439920f, 0.04292338f, 0.04647664f, 0.12812959f, 0.01130800f, 0.06227316f, 
    0.31576756f, -0.03598139f, -0.04919160f, -0.12291418f, 0.11042150f, -0.08525728f, 0.08030188f, 0.20354313f, 
    0.00102509f, -0.01039212f, 0.14937112f, -0.12276482f, -0.11507116f, -0.00882467f, 0.11541039f, -0.06417422f, 
    0.03204884f, 0.01911823f, -0.00799743f, 0.05342611f, 0.17611074f, 0.20423369f, 0.05568879f, 0.04474511f, 
    -0.07476932f, 0.09533571f, 0.33210573f, 0.06382492f, -0.00497377f, 0.04390730f, 0.13881375f, -0.07781307f, 
    0.00350905f, 0.04810252f, 0.17237112f, 0.05308709f, 0.12528729f, -0.04570305f, -0.02241766f, 0.06474049f, 
    0.16043569f, 0.09636335f, 0.04570919f, -0.02220321f, -0.15127930f, 0.05691804f, 0.06125141f, 0.02528886f, 
    -0.01080965f, 0.32099479f, 0.13716175f, 0.32286209f, -0.06110295f, -0.02885429f, 0.13208921f, 0.00943681f, 
    0.08124723f, 0.01289947f, 0.11403973f, -0.05212142f, 0.14207271f, -0.01251330f, -0.16732691f, 0.34356898f, 
    0.05995193f, -0.01366469f, 0.06817910f, -0.03821131f, 0.09759744f, -0.04791235f, 0.00675175f, -0.04903599f, 
    -0.29685757f, -0.49423423f, 0.03547111f, 0.08882610f, -0.10346684f, -0.06334117f, 0.13606800f, 0.03749626f, 
    -0.02515381f, 0.07398504f, 0.11997451f, -0.02158414f, 0.18330112f, 0.31368315f, 0.23907484f, 0.14403853f, 
    -0.01630981f, -0.05604917f, -0.12173641f, 0.03359009f, 0.02339957f, -0.14837211f, 0.05568476f, -0.06016447f, 
    -0.21857826f, 0.17536567f, 0.06742184f, -0.08941673f, -0.04991016f, -0.03014081f, -0.07800605f, -0.00130689f, 
    -0.00987287f, -0.00868329f, 0.01002451f, -0.06801386f, 0.14802153f, 0.15624423f, 0.00638750f, -0.06644220f, 
    0.04493931f, 0.03625081f, -0.07445670f, 0.07562322f, -0.02466258f, -0.21653107f, 0.11189315f, -0.12953581f, 
    0.20951466f, -0.06370375f, -0.07690386f, 0.31471059f, -0.03631313f, -0.01064499f, -0.03843616f, -0.01266104f, 
    0.08243627f, -0.04707499f, -0.08158749f, -0.06366430f, 0.42918885f, -0.00917856f, 0.07060798f, -0.13387115f, 
    0.07264017f, 0.06960344f, -0.00558955f, -0.03382420f, 0.14392667f, -0.16303813f, 0.05410416f, -0.05394644f, 
    -0.12777491f, -0.35865170f, 0.24742216f, 0.10816898f, -0.14027514f, -0.00741262f, -0.05082053f, 0.10678378f, 
    0.01361752f, 0.04241197f, -0.12128153f, -0.04479188f, 0.12067796f, -0.32805970f, 0.21673100f, 0.10309294f, 
    -0.11202753f, -0.12159912f, -0.09801813f, -0.08467095f, 0.09116696f, 0.04351247f, 0.03911619f, 0.09141125f, 
    0.01768149f, 0.04980301f, -0.06599135f, 0.05341907f, -0.05039609f, -0.02417020f, -0.01130624f, -0.01920675f, 
    -0.05169234f, -0.02062546f, -0.03961869f, -0.00622301f, -0.03653147f, -0.01588254f, 0.04052861f, -0.00059261f, 
    -0.04086389f, -0.01245657f, -0.04111491f, 0.00737356f, -0.02604433f, -0.03442487f, -0.03777141f, -0.00862748f, 
    0.01058287f, -0.07011972f, -0.02957551f, -0.05301772f, -0.02817682f, -0.00201508f, -0.03946785f, -0.04058845f, 
    0.00240136f, -0.05987783f, -0.04900002f, -0.05051073f, -0.01022033f, 0.02028973f, -0.03785571f, -0.01683372f, 
    -0.01823471f, -0.05461064f, -0.04767438f, -0.00056650f, -0.06355052f, 0.03370179f, -0.02573578f, 0.04327036f, 
    -0.01729643f, 0.05775137f, 0.03790736f, 0.05515136f, 0.00359180f, -0.05559840f, -0.07636780f, -0.05403162f, 
    0.04607629f, -0.06600258f, 0.00192444f, 0.03258629f, -0.00509821f, 0.03897064f, 0.02436629f, -0.06764338f, 
    0.02428594f, 0.05217754f, 0.03829094f, 0.00266079f, -0.01060567f, -0.04627477f, 0.01075459f, 0.05836705f, 
    -0.03934637f, -0.05016870f, 0.00009269f, 0.03702525f, 0.02064415f, 0.02453070f, -0.02362052f, 0.05696703f, 
    0.04750199f, 0.05102267f, -0.05875498f, -0.04358099f, 0.02530341f, -0.04912542f, -0.01895927f, 0.03622071f, 
    -0.01047980f, 0.01073228f, 0.02795606f, -0.02436490f, 0.03371442f, 0.04578553f, -0.07031649f, -0.00008600f, 
    0.03558967f, -0.04830778f, 0.03201225f, -0.03452004f, 0.02833988f, 0.05159118f, -0.07961123f, -0.00081489f, 
    0.01352695f, 0.00586327f, 0.06155287f, -0.00008102f, -0.07739343f, -0.01414639f, -0.06500147f, 0.02780662f, 
    0.00575137f, -0.01792492f, 0.03084101f, -0.02471746f, -0.07591508f, 0.04797725f, -0.04213825f, -0.03112031f, 
    -0.02554923f, 0.04141285f, 0.05685785f, -0.03578585f, -0.05647310f, 0.00747496f, 0.02350990f, 0.03940736f, 
    -0.07426342f, -0.07944363f, 0.05443944f, 0.01092757f, -0.05962403f, 0.00075900f, 0.04050728f, 0.02830440f, 
    -0.06434545f, -0.07781341f, -0.01692955f, 0.05337234f, 0.01008941f, 0.02157953f, -0.03161917f, -0.01610341f, 
    -0.01111572f, 0.02860938f, -0.01648233f, 0.02900941f, 0.02558823f, -0.07507687f, 0.00861638f, -0.01071105f, 
    -0.04155240f, 0.01581720f, 0.01969849f, -0.03926280f, -0.06804211f, -0.03243527f, 0.00296291f, 0.02045907f, 
    -0.07275952f, -0.03044551f, -0.03120575f, -0.05892684f, -0.02884214f, 0.01210324f, -0.04237278f, 0.03346155f, 
    -0.00618986f, 0.03830456f, -0.01759523f, -0.04994747f, 0.01369202f, -0.00332934f, 0.04796512f, 0.00536466f, 
    -0.06106937f, 0.02971612f, -0.07251081f, -0.05642329f, -0.07139301f, 0.00780737f, 0.00014786f, 0.02071266f, 
    -0.03095884f, 0.05849931f, 0.05588094f, 0.01465617f, -0.04563113f, -0.01972302f, -0.07381457f, 0.00138937f, 
    0.13523304f, 0.32144952f, -0.02789040f, 0.00948454f, -0.02848449f, -0.04193864f, -0.16680604f, 0.12049585f, 
    0.07881448f, 0.04531615f, 0.07671461f, -0.27153525f, 0.00130066f, 0.03529517f, 0.24913426f, 0.03687799f, 
    0.11164904f, 0.05070547f, 0.10371809f, 0.07312384f, -0.05861599f, -0.00829643f, 0.00676583f, -0.13579053f, 
    0.14062174f, 0.26872957f, 0.04342774f, -0.04032666f, 0.05351668f, -0.04185342f, 0.09667309f, 0.15786868f, 
    -0.10942204f, 0.03777824f, 0.08485015f, 0.05419894f, -0.03366183f, 0.02100925f, 0.19865187f, 0.02931911f, 
    -0.08004501f, 0.05488140f, 0.18732099f, 0.10260699f, -0.05965298f, 0.04710143f, -0.07806273f, 0.00511213f, 
    -0.16598628f, 0.19321032f, 0.02310469f, 0.01027357f, 0.04358344f, -0.05283312f, -0.06581821f, 0.10110372f, 
    0.05707797f, 0.11915909f, -0.04135029f, 0.05651778f, 0.12673745f, -0.00610030f, 0.13983463f, 0.10945301f, 
    0.05088655f, -0.06775650f, -0.01098010f, 0.00783828f, -0.06745777f, -0.09570585f, -0.01124226f, -0.02021542f, 
    -0.12489942f, 0.08268308f, 0.09080041f, -0.07477114f, 0.09299651f, 0.05181709f, 0.05583717f, -0.05824808f, 
    -0.04793638f, -0.01237020f, -0.01923814f, -0.03149113f, -0.07799000f, 0.01578310f, -0.07009359f, -0.12264053f, 
    -0.18668671f, -0.00359471f, -0.01343560f, 0.03313759f, -0.01411851f, -0.04044354f, -0.01105098f, 0.05661103f, 
    -0.71787357f, 0.20179386f, -0.22572425f, -0.16111140f, -0.04468354f, 0.08530605f, 0.02853243f, 0.06831335f, 
    -0.05813600f, 0.03235008f, -0.01994308f, 0.03700190f, -0.01506907f, 0.12746078f, 0.30889654f, 0.03706004f, 
    -0.17040625f, 0.08581942f, 0.07892047f, 0.09729190f, -0.04031465f, -0.02648998f, 0.10280278f, -0.03290861f, 
    -0.12037019f, -0.23363511f, -0.00581150f, -0.07083412f, -0.04122067f, 0.00954654f, 0.05182342f, -0.10149040f, 
    -0.09190401f, 0.05647086f, 0.06903562f, -0.06890608f, 0.15801066f, -0.18416809f, 0.06002352f, 0.00719156f, 
    0.01571064f, -0.09345878f, -0.05345705f, 0.06744289f, -0.04319346f, -0.18100713f, -0.06335697f, 0.11144713f, 
    0.20288591f, 0.02242770f, -0.19544517f, 0.09529102f, -0.07969995f, 0.03179190f, 0.02859602f, -0.06807486f, 
    -0.03447012f, 0.01926314f, -0.04575143f, 0.04268264f, 0.22409429f, 0.19801860f, 0.06776295f, 0.06492096f, 
    0.02474897f, -0.01261267f, -0.02611813f, -0.02240303f, -0.05621209f, 0.11115507f, -0.08532126f, 0.01428562f, 
    -0.06593461f, -0.17704658f, -0.01380751f, -0.08437291f, 0.08096391f, 0.00733313f, -0.01026767f, 0.01788888f, 
    0.03199920f, 0.02329919f, 0.00368219f, -0.06043855f, -0.18337646f, 0.29456207f, 0.22775328f, -0.01039762f, 
    -0.08444159f, -0.00973861f, -0.01243232f, 0.04148831f, 0.05862409f, 0.05353418f, 0.02919147f, 0.03094907f, 
    -0.04360018f, 0.05877784f, -0.04928246f, 0.01840629f, 0.01218503f, 0.05641511f, -0.01804818f, -0.00916283f, 
    0.06108015f, -0.00679425f, 0.03326359f, -0.05414166f, 0.03465872f, -0.03742510f, 0.02298519f, 0.02775392f, 
    0.01420933f, 0.01419909f, -0.04094711f, 0.05687260f, 0.03731475f, -0.00447727f, 0.03216396f, -0.01278579f, 
    0.00877825f, 0.05179000f, -0.01599962f, 0.01006952f, 0.03170653f, 0.00623490f, -0.06153081f, -0.04976672f, 
    -0.01562347f, 0.05709055f, 0.01281099f, 0.05047680f, -0.01911374f, 0.00684955f, -0.04859135f, 0.00950023f, 
    -0.05123453f, -0.01979816f, 0.03206414f, -0.06818217f, -0.00036012f, -0.07443591f, -0.04588852f, -0.02052243f, 
    -0.01598478f, -0.03382654f, -0.03846517f, 0.05588763f, -0.06898791f, -0.01597164f, 0.05891042f, 0.04205507f, 
    0.03287120f, -0.06618687f, -0.03543600f, -0.07253534f, -0.01752073f, 0.05439600f, -0.07176229f, -0.04442626f, 
    -0.07342908f, -0.05150332f, -0.03677944f, 0.01103102f, -0.04075276f, 0.02850451f, -0.03528096f, -0.05476462f, 
    -0.03223750f, -0.01244310f, -0.01031664f, 0.02312735f, -0.04548132f, -0.04803765f, 0.01250811f, -0.07671518f, 
    -0.02018969f, -0.04580323f, 0.00480044f, 0.04692983f, -0.01380734f, 0.00543031f, -0.06990502f, -0.01269266f, 
    0.02392036f, -0.00815257f, 0.03189924f, 0.03366909f, -0.00855939f, -0.03468082f, -0.03089001f, 0.02218790f, 
    -0.02893837f, -0.02355322f, -0.04692648f, -0.02352032f, -0.06267850f, -0.07450409f, -0.01116525f, 0.05399932f, 
    0.01485985f, -0.04009123f, -0.00128952f, -0.05590282f, -0.00926800f, 0.02810537f, -0.07541189f, -0.00371000f, 
    0.05229572f, 0.00037443f, 0.06029328f, 0.03446308f, -0.02683478f, -0.06588569f, -0.06022930f, -0.00717637f, 
    0.00539167f, -0.05870057f, -0.00599792f, -0.03012979f, 0.00296108f, 0.00150549f, 0.05728235f, -0.04882496f, 
    0.01546830f, -0.02850406f, -0.05210607f, 0.05667731f, 0.06185747f, -0.02722995f, -0.05778822f, 0.03230070f, 
    -0.06587661f, 0.02697933f, -0.03387367f, 0.02715963f, 0.06018593f, -0.04033221f, -0.03378577f, -0.01624909f, 
    0.06120793f, 0.01345588f, 0.01464728f, -0.04058457f, -0.04873676f, -0.00997868f, -0.04076390f, -0.01231148f, 
    0.01678394f, -0.01231014f, 0.03258427f, -0.07209973f, -0.05477998f, 0.04230855f, -0.03601243f, -0.07097497f, 
    0.03787687f, -0.04790549f, -0.02670192f, 0.05006684f, 0.06598835f, 0.02701329f, -0.00012516f, -0.01809120f, 
    -0.02394513f, -0.02515694f, -0.01455151f, 0.03008362f, -0.03738151f, 0.01718044f, -0.05983987f, 0.02961876f, 
    0.04662151f, 0.00683312f, -0.06951796f, 0.00967261f, 0.04355511f, -0.05796678f, -0.07227132f, 0.00047572f, 
    -0.06067306f, -0.05162984f, 0.02547368f, -0.02406834f, -0.01452714f, 0.01093173f, -0.07623582f, 0.01031828f, 
    -0.02714613f, -0.01790331f, -0.06599452f, 0.00203143f, 0.04870078f, -0.03802272f, 0.01127300f, -0.02048727f, 
    0.01581876f, -0.00080092f, 0.03131767f, 0.06271111f, 0.04299504f, -0.05467809f, 0.00846216f, -0.06755944f, 
    -0.01430392f, -0.04637718f, 0.01502145f, -0.01223333f, -0.02191835f, -0.01430505f, 0.00715969f, 0.03062517f, 
    0.03941109f, -0.04154691f, 0.02290017f, 0.00031776f, -0.03012244f, 0.02288590f, -0.06909310f, -0.00073840f, 
    -0.02587285f, -0.04189366f, 0.02464171f, 0.03048033f, 0.02879306f, -0.06332316f, -0.05117165f, 0.06388635f, 
    -0.06986296f, -0.01194998f, 0.01580339f, 0.00356469f, -0.00888655f, -0.05980641f, -0.04411088f, -0.04295951f, 
    -0.06280524f, -0.07591952f, 0.05201427f, 0.00470740f, -0.06793772f, 0.01516104f, -0.04211200f, -0.03797308f, 
    -0.06762329f, 0.03790960f, -0.03025223f, 0.01922691f, 0.05339803f, -0.02489557f, 0.01655718f, -0.05411417f, 
    -0.06239939f, -0.04969729f, -0.05324443f, -0.01266303f, 0.01488049f, -0.01217381f, -0.06957392f, -0.02804396f, 
    -0.00558645f, 0.00715473f, -0.02694472f, -0.03919590f, -0.06985753f, -0.03994851f, -0.01935783f, 0.03578796f, 
    -0.01775141f, 0.00091633f, 0.01150934f, 0.05940906f, -0.00980585f, 0.03436321f, -0.04725608f, 0.04317519f, 
    0.01053210f, -0.05910500f, 0.07030643f, -0.06030986f, 0.04185267f, 0.04245660f, -0.04929325f, 0.04096224f, 
    -0.05469712f, 0.02825782f, 0.00218297f, -0.06234901f, -0.05219062f, -0.02925400f, -0.06932291f, -0.01118198f, 
    -0.01777832f, -0.02642624f, 0.01210015f, 0.05446649f, -0.00131236f, 0.01312079f, -0.05311946f, 0.02275069f, 
    -0.00570658f, 0.02113295f, 0.02862534f, -0.06246072f, 0.06662176f, -0.01413388f, 0.02708632f, -0.01560555f, 
    -0.00034305f, 0.06521715f, -0.03218831f, -0.05587820f, 0.03609789f, 0.05214584f, -0.06743217f, -0.02430360f, 
    0.03542139f, 0.06233392f, -0.06634466f, -0.06696648f, -0.03787335f, 0.06663577f, -0.06703804f, 0.00803270f, 
    -0.00028602f, -0.03200953f, -0.02312329f, -0.06457984f, 0.04982558f, 0.03404950f, -0.01876725f, -0.00350449f, 
    -0.05302797f, 0.03153868f, -0.02272832f, 0.03298810f, -0.01864752f, 0.06529445f, 0.03075596f, 0.02572384f, 
    -0.01585949f, 0.03858692f, -0.01274696f, -0.06219370f, -0.05311335f, -0.05102478f, -0.05485477f, -0.02720249f, 
    -0.06109966f, 0.07083928f, -0.05094311f, -0.02399212f, -0.00988129f, 0.02025241f, 0.03156682f, -0.02265150f, 
    0.04918855f, -0.00115204f, -0.06360374f, 0.04632400f, 0.06718133f, 0.01354657f, -0.04830666f, 0.06012058f, 
    0.07019171f, -0.02556724f, -0.00416921f, 0.02619725f, 0.02170071f, -0.06189192f, -0.07414715f, 0.00067377f, 
    -0.05401214f, -0.02459604f, -0.03442949f, -0.05543983f, 0.03038560f, 0.00635556f, -0.04747850f, -0.00088353f, 
    -0.27316299f, 0.15407906f, 0.19631311f, 0.24860270f, 0.02611745f, 0.13939455f, 0.25576305f, 0.04026046f, 
    0.07845350f, 0.01377019f, -0.01988889f, 0.07472590f, -0.03983779f, -0.06247081f, -0.23654933f, -0.14141971f, 
    -0.02211065f, 0.01514720f, 0.07175554f, 0.06231209f, 0.07159273f, 0.00264653f, 0.01772304f, 0.06834530f, 
    -0.11449227f, -0.01625372f, 0.08513953f, 0.07130896f, -0.11631458f, 0.13516589f, 0.04648985f, -0.15784860f, 
    -0.04021972f, 0.21219374f, 0.19355738f, 0.18671288f, -0.11354434f, -0.06291506f, -0.00696168f, 0.04802676f, 
    -0.04777588f, -0.21575785f, -0.04935653f, -0.05166327f, -0.06416240f, -0.06436477f, -0.12452359f, -0.09972845f, 
    -0.32698932f, -0.19593811f, -0.04255190f, 0.10370232f, -0.01792402f, 0.06935320f, 0.01486480f, 0.05638086f, 
    0.07088610f, 0.07619338f, 0.06382858f, -0.12966061f, -0.14457236f, 0.12577784f, -0.05691405f, -0.03458070f, 
    0.05324923f, -0.14964329f, 0.03590553f, 0.01790648f, -0.07667531f, -0.07538292f, 0.03430647f, -0.16088475f, 
    -0.14411873f, -0.35552970f, -0.05331250f, 0.13552690f, -0.01546247f, 0.05622292f, 0.09566972f, 0.02953490f, 
    -0.04607217f, -0.14019504f, -0.14223750f, -0.05159277f, 0.29319835f, 0.14987311f, 0.22601311f, -0.21210968f, 
    -0.08314680f, 0.04001949f, -0.07812390f, -0.15850525f, -0.32992068f, -0.08883256f, 0.05262454f, 0.01825516f, 
    0.34936705f, 0.00284002f, -0.27825934f, 0.05813165f, 0.00266367f, 0.05272956f, 0.11224982f, 0.15589374f, 
    0.07786254f, 0.00198358f, 0.02825822f, 0.11777083f, 0.16090012f, -0.03266404f, -0.10408513f, -0.00123104f, 
    -0.06968524f, -0.08646529f, -0.16752315f, -0.07603388f, -0.00516420f, -0.27010840f, 0.03590037f, 0.06233840f, 
    0.02269349f, 0.09105216f, 0.16244528f, 0.27604780f, 0.15257125f, 0.08588782f, 0.03315060f, 0.17361534f, 
    0.12999207f, -0.13612534f, -0.01328636f, -0.15941414f, -0.09767748f, 0.30669138f, 0.20269163f, 0.28507510f, 
    0.02136456f, 0.03993247f, 0.29816148f, 0.02834895f, 0.00812771f, 0.26745799f, 0.06321052f, 0.22677960f, 
    0.04507959f, 0.01415341f, -0.01868772f, -0.29835397f, -0.14931540f, 0.06024887f, -0.03544618f, -0.09906787f, 
    -0.15084340f, -0.10235847f, 0.13785863f, -0.05582535f, -0.14052409f, 0.08661065f, -0.04081439f, -0.15285338f, 
    0.15126169f, -0.00356148f, 0.04841663f, -0.05048421f, 0.06636070f, 0.07255482f, 0.35657841f, 0.17308673f, 
    -0.18878044f, 0.21851648f, -0.00728546f, 0.11949261f, 0.03701366f, 0.27464369f, 0.02134991f, -0.00646215f, 
    -0.00634165f, -0.18302475f, 0.16911048f, -0.01513094f, 0.19134386f, -0.04396719f, -0.02329380f, -0.29730737f, 
    -0.00169042f, 0.05528905f, -0.13292967f, 0.29090846f, -0.12649870f, 0.07981455f, 0.05950021f, 0.08862779f, 
    -0.20969634f, -0.23362620f, -0.23960769f, 0.10661572f, 0.04031911f, 0.12378883f, 0.18503252f, -0.03068484f, 
    0.09963849f, 0.04256433f, -0.00020536f, -0.03679183f, 0.04356133f, 0.13872200f, -0.08661028f, -0.11533398f, 
    0.13973892f, 0.02176001f, 0.14037438f, 0.01117965f, -0.01078465f, -0.02338496f, 0.00992654f, 0.01939371f, 
    -0.01498973f, 0.04301831f, 0.15244833f, 0.23086883f, -0.08935614f, -0.08414198f, -0.01383409f, -0.07020431f, 
    0.00026989f, 0.04643071f, -0.04824118f, 0.04574600f, -0.05495990f, -0.01826071f, -0.03317162f, 0.25029266f, 
    0.11189592f, 0.12544614f, 0.17345330f, -0.02201183f, 0.02737261f, 0.15246034f, 0.12466948f, 0.02581250f, 
    -0.08088794f, -0.13528632f, -0.13909459f, -0.00255753f, 0.20653960f, 0.11359002f, 0.07131024f, 0.18565202f, 
    -0.11268470f, 0.00306617f, -0.02723718f, 0.01091607f, -0.06358071f, -0.10664017f, -0.00568196f, -0.13084440f, 
    0.05421610f, -0.14406565f, -0.05073873f, -0.05982205f, 0.03982381f, 0.06601395f, 0.14270011f, 0.06334424f, 
    -0.03648866f, -0.17862634f, 0.12651028f, 0.02632945f, 0.03710349f, 0.13158345f, 0.10341482f, 0.11558176f, 
    -0.00185474f, -0.07752413f, -0.01067546f, 0.18356381f, 0.11446083f, 0.20729782f, 0.21686861f, -0.15556614f, 
    0.06449777f, -0.03363443f, 0.02635789f, 0.06855708f, -0.12557635f, -0.02205207f, 0.05629534f, 0.12159240f, 
    0.14810899f, 0.18405879f, 0.11287038f, -0.14290667f, 0.01669913f, 0.02758547f, -0.07553815f, -0.10659633f, 
    -0.10930610f, 0.04617715f, -0.06808557f, 0.06651215f, 0.10760266f, -0.00539135f, -0.07576524f, -0.14070499f, 
    -0.03382723f, -0.11673466f, 0.11868385f, -0.03668612f, -0.05527019f, 0.16189152f, 0.02517929f, 0.21654804f, 
    0.27058434f, 0.13253047f, 0.02103528f, 0.25367466f, 0.10285224f, -0.02435958f, 0.12633319f, -0.04029133f, 
    0.08683917f, -0.09810145f, 0.03375077f, 0.03347627f, -0.00986996f, 0.13283989f, 0.08477788f, 0.32489631f, 
    -0.08843483f, -0.06996813f, 0.11378066f, 0.02520218f, -0.04896979f, -0.13650867f, 0.03073323f, -0.16891429f, 
    -0.14354402f, -0.05346099f, 0.07908872f, -0.02468891f, -0.17902318f, -0.11574680f, -0.19407837f, -0.10237628f, 
    -0.18973994f, -0.14232172f, -0.10144228f, -0.01457673f, -0.00832363f, 0.20938437f, 0.08694340f, 0.05395795f, 
    -0.03929315f, 0.01780577f, 0.04299173f, -0.09606884f, 0.13144651f, 0.03915080f, -0.08298336f, 0.02548945f, 
    0.09496486f, 0.56843871f, -0.14115006f, 0.03503874f, -0.03191802f, -0.04801820f, 0.10111009f, 0.06943646f, 
    -0.06156157f, 0.01877444f, 0.08396273f, -0.06796943f, 0.10777016f, 0.05361525f, -0.22816803f, -0.40588284f, 
    -0.16726708f, 0.02632875f, 0.05049153f, 0.08868960f, 0.12390643f, 0.03197273f, -0.01106908f, 0.13663442f, 
    -0.03570198f, 0.00068129f, 0.03720869f, 0.06304722f, -0.01229886f, 0.04869578f, -0.02044346f, -0.04135195f, 
    0.03767651f, 0.00771125f, -0.07030866f, -0.06206597f, 0.05897128f, 0.00108260f, -0.01888123f, 0.04178995f, 
    -0.01060981f, -0.04979958f, -0.05753493f, 0.00679399f, -0.05445592f, -0.04311449f, -0.05783584f, 0.06175051f, 
    0.01269778f, 0.02876166f, -0.07769677f, 0.00840786f, -0.04731522f, 0.01029291f, -0.01084865f, -0.03775144f, 
    0.04119812f, 0.01176032f, -0.00356636f, 0.00145065f, -0.06068023f, -0.00670347f, -0.07235888f, -0.00396851f, 
    0.03176256f, -0.00877446f, 0.02080791f, 0.02719261f, 0.05871840f, 0.04540749f, -0.06225012f, -0.01497898f, 
    -0.04266846f, 0.04380709f, -0.05159442f, 0.06312334f, 0.04165266f, 0.05547514f, -0.08009588f, 0.06532006f, 
    -0.01264931f, 0.05840954f, -0.06940655f, 0.05081743f, -0.07365840f, -0.04851342f, 0.03150263f, 0.03335794f, 
    -0.07619444f, -0.00404045f, -0.05459639f, 0.02586779f, 0.05777332f, 0.04008870f, -0.06438718f, 0.03448489f, 
    0.03412190f, -0.06253266f, 0.03287072f, 0.04952999f, 0.01977653f, -0.04059108f, 0.02809281f, 0.04904883f, 
    -0.07532381f, -0.00531034f, -0.05705571f, -0.08126931f, 0.05425305f, -0.04327562f, 0.00808948f, -0.01359310f, 
    -0.01887876f, -0.06361952f, -0.06001040f, -0.00138268f, -0.01630485f, 0.04121143f, 0.02173969f, -0.06686030f, 
    0.04207812f, 0.01627318f, -0.01304251f, 0.04445177f, 0.05785910f, -0.06478533f, 0.03633200f, -0.05036748f, 
    -0.06796119f, 0.00081474f, -0.01962894f, -0.01720156f, 0.00538042f, -0.06637014f, -0.05512968f, 0.02032343f, 
    0.00330468f, 0.04854816f, -0.08028689f, -0.06313942f, 0.03162388f, -0.04238484f, 0.05131678f, 0.06025649f, 
    -0.02671987f, -0.06756533f, -0.00858662f, -0.02004725f, 0.06018345f, -0.07443906f, 0.03518864f, -0.05502165f, 
    0.00750605f, -0.05800375f, -0.06405167f, -0.02328618f, -0.06635772f, 0.01151880f, 0.06200705f, -0.02378611f, 
    0.01474521f, -0.03462196f, -0.02325814f, 0.01950155f, -0.00504996f, -0.05642866f, -0.04859279f, 0.01261955f, 
    -0.04893868f, 0.05056318f, -0.06309111f, 0.00536749f, 0.02365067f, 0.05265023f, -0.00363376f, 0.05562847f, 
    -0.01954520f, -0.04155867f, 0.05209543f, -0.00425234f, -0.01366391f, -0.03240837f, 0.06098614f, -0.03910840f, 
    0.03574643f, -0.04473568f, 0.04776793f, -0.01346656f, -0.02905786f, -0.02058483f, -0.05334619f, -0.01878925f, 
    0.05227038f, 0.03646323f, -0.04126065f, 0.01320793f, 0.06184768f, 0.02202758f, 0.04845845f, 0.03054906f, 
    0.05447947f, 0.04723579f, -0.05757779f, 0.01451042f, -0.05280080f, -0.06780333f, -0.05963615f, -0.02844117f, 
    -0.05948548f, -0.03625975f, -0.02181767f, -0.07465466f, -0.02701091f, 0.01617084f, -0.04847183f, -0.00081054f, 
    0.01113790f, 0.02162044f, 0.40407598f, 0.07691703f, -0.11168916f, 0.02032300f, 0.01322905f, 0.27772829f, 
    0.00840684f, 0.05890810f, 0.15615641f, 0.30834690f, 0.15981238f, -0.26842526f, -0.12181992f, 0.01918921f, 
    -0.15630864f, -0.09414698f, -0.04118461f, -0.07323547f, 0.01630094f, -0.07741170f, -0.13114803f, 0.08247220f, 
    -0.00676720f, -0.20918408f, 0.32764581f, -0.17290583f, 0.09017321f, -0.06247118f, 0.02009331f, -0.13620384f, 
    0.04455556f, -0.03253547f, 0.04813746f, -0.14185449f, -0.13918152f, -0.16445835f, -0.25316995f, -0.07975216f, 
    -0.08630278f, -0.26761761f, 0.06896602f, 0.19698440f, 0.00266854f, -0.10663926f, 0.09180275f, 0.03804139f, 
    0.22549033f, 0.12539758f, 0.22186682f, -0.06977931f, -0.02735260f, 0.09445220f, -0.17641960f, 0.00190942f, 
    -0.07745041f, -0.12215409f, -0.06629530f, -0.00821800f, 0.04431146f, 0.00341796f, 0.10042352f, -0.05469904f, 
    0.01170786f, 0.05769682f, -0.00233567f, 0.11039031f, 0.05652435f, 0.05705005f, 0.10056295f, -0.01087852f, 
    -0.26429173f, -0.02964241f, -0.17657253f, -0.28691763f, -0.05957429f, 0.03215504f, 0.04551465f, -0.01503443f, 
    0.02551981f, -0.10564654f, -0.02954316f, -0.03925692f, -0.20938112f, 0.07964776f, -0.33452404f, -0.05198640f, 
    0.09169198f, 0.07078183f, 0.08523795f, 0.02591945f, 0.06659555f, -0.02823935f, 0.06093737f, -0.00263499f, 
    0.46299845f, 0.02946434f, -0.16414095f, 0.06959709f, 0.09200084f, 0.06075977f, 0.06486646f, -0.13429525f, 
    -0.01725862f, -0.08731823f, 0.04473396f, 0.04323103f, 0.09399494f, -0.11728267f, -0.11911105f, 0.03084040f, 
    0.26822808f, 0.00169937f, 0.05810548f, -0.01558459f, 0.11565081f, 0.12060568f, -0.05310701f, 0.24903178f, 
    -0.33254892f, -0.13715005f, -0.09737892f, 0.06667566f, 0.11668067f, -0.00748126f, 0.07405889f, -0.05223478f, 
    -0.05409606f, 0.01120026f, 0.06876153f, -0.00860496f, -0.23130485f, -0.01889901f, 0.10588557f, 0.01693955f, 
    0.07888488f, -0.07225838f, 0.00326208f, -0.10073403f, 0.15628806f, 0.22619294f, -0.01871586f, -0.00211886f, 
    -0.11658706f, -0.04209536f, -0.03453579f, -0.03504405f, 0.05431359f, 0.06135280f, 0.13125741f, -0.03549397f, 
    0.04372431f, 0.01202944f, -0.01665155f, -0.06747472f, -0.21849933f, -0.00739694f, 0.29434422f, -0.08357748f, 
    0.03330991f, -0.17770502f, 0.01995577f, -0.12522410f, 0.24081837f, 0.27830788f, 0.05421102f, 0.05309736f, 
    0.22765878f, -0.32464954f, 0.19367713f, 0.00975214f, 0.09894144f, 0.08903013f, 0.19597329f, 0.02660353f, 
    -0.05615810f, -0.02399558f, 0.03968782f, 0.07757070f, 0.46023241f, -0.05296651f, 0.07020023f, -0.01105521f, 
    0.15198162f, 0.02989232f, -0.04853766f, -0.03553613f, 0.16844574f, 0.16485876f, -0.02030228f, 0.18568206f, 
    -0.15943336f, -0.16273610f, -0.56871521f, -0.19731458f, 0.01571576f, 0.01920926f, 0.04158145f, 0.02199009f, 
    0.24055134f, 0.00103698f, 0.01133427f, -0.09944596f, -0.54387641f, -0.45610568f, -0.68382871f, -0.49083140f, 
    0.08803865f, -0.00538259f, -0.03857504f, 0.00686961f, -0.03182878f, -0.01987878f, 0.03526026f, -0.00033621f, 
    0.26588932f, 0.32222074f, 0.00523895f, 0.15170924f, 0.01071889f, -0.00761855f, 0.03651666f, 0.09170444f, 
    0.01748463f, 0.08706148f, 0.22142714f, 0.34401575f, -0.33100107f, -0.51145697f, -0.25158837f, -0.24433930f, 
    0.04298388f, -0.25086331f, -0.06114202f, 0.06716290f, -0.08569439f, 0.07707848f, -0.18143432f, -0.06086313f, 
    -0.46156123f, -0.01475016f, 0.09448906f, -0.18754193f, 0.11350333f, 0.06623777f, -0.00646788f, 0.13312984f, 
    0.14735289f, 0.04868491f, 0.07937922f, -0.00592936f, 0.06454539f, 0.14642049f, 0.00564033f, 0.04932969f, 
    0.06829296f, 0.04970177f, 0.06666902f, 0.02880137f, 0.02972645f, 0.00792402f, -0.10912002f, -0.10345996f, 
    0.05645643f, -0.56137508f, -0.42105907f, -0.21414052f, 0.07487410f, -0.06797058f, -0.02949315f, 0.09658064f, 
    -0.05517871f, 0.03110038f, 0.11518972f, 0.01634430f, 0.52750534f, 0.45282504f, 0.09767161f, 0.29214820f, 
    -0.00804635f, 0.03034481f, -0.02302108f, 0.01410942f, -0.07340605f, -0.13912056f, -0.04132317f, -0.09613806f, 
    -0.07264459f, 0.25426129f, 0.14590041f, 0.07320376f, 0.03604094f, 0.01711425f, -0.06467682f, 0.11934076f, 
    -0.04482061f, -0.00586254f, -0.06266963f, 0.09459379f, -0.00608043f, -0.02913717f, 0.12685646f, 0.12801710f, 
    0.00233150f, 0.04278898f, -0.12095848f, -0.03703319f, -0.00611008f, -0.09546235f, 0.13019948f, -0.06107464f, 
    -0.08675658f, 0.01229185f, -0.12036529f, -0.18776497f, -0.14049831f, 0.02609652f, -0.09415086f, -0.18895739f, 
    -0.11610005f, -0.06585068f, -0.07680623f, -0.07326429f, 0.16604427f, -0.02079663f, 0.09865420f, 0.25067195f, 
    -0.15010105f, 0.00186880f, 0.13949995f, 0.00540641f, 0.18351665f, -0.01860439f, 0.07835392f, 0.25555351f, 
    0.16682798f, 0.17148572f, 0.12045322f, 0.25412714f, -0.02935519f, 0.05118097f, -0.08542070f, -0.02820181f, 
    -0.08744249f, -0.05862696f, -0.03570532f, 0.06933002f, 0.33944681f, 0.18655245f, 0.10022230f, 0.04790867f, 
    -0.01394941f, 0.03241932f, -0.02070505f, -0.02338855f, 0.14040169f, 0.15473607f, 0.00234402f, -0.03952094f, 
    -0.21881440f, -0.00147710f, 0.09199043f, 0.15135980f, 0.27984342f, 0.35714325f, -0.04635022f, 0.05849448f, 
    -0.10894722f, -0.05524970f, -0.05990723f, 0.12475251f, 0.02529923f, 0.21135662f, 0.24572140f, 0.02527714f, 
    -0.22248381f, 0.01963061f, 0.06241672f, -0.01166756f, -0.03867169f, 0.23184702f, 0.08220197f, 0.21680489f, 
    -0.40679610f, 0.25231680f, -0.38420931f, -0.06174065f, -0.09891966f, -0.04081570f, 0.03847349f, 0.12060593f, 
    -0.03065232f, 0.09533974f, 0.10207523f, -0.01958107f, -0.23008586f, -0.46714076f, 0.01675631f, -0.33816063f, 
    0.11899763f, -0.15007019f, 0.06680535f, -0.08006114f, -0.13268673f, -0.10119795f, 0.03335379f, 0.07330138f, 
    0.50780880f, 0.27561164f, -0.08384521f, 0.22627109f, -0.07415049f, 0.12350473f, 0.06650534f, 0.08273237f, 
    0.12293499f, 0.22186859f, 0.12448791f, 0.35432246f, -0.18336099f, -0.18490005f, -0.02103993f, -0.32013509f, 
    -0.03053174f, 0.00793980f, -0.20327298f, -0.07558570f, -0.04492394f, -0.04252766f, -0.14726052f, -0.18437985f, 
    -0.41729638f, -0.14071411f, 0.17407258f, 0.04456833f, 0.07252871f, -0.07222543f, -0.16304481f, 0.02580699f, 
    0.13076533f, 0.02876443f, -0.01118589f, 0.07461973f, -0.02704950f, 0.13371703f, -0.05211628f, 0.13120376f, 
    0.06115881f, -0.00761094f, 0.13939586f, 0.00046890f, 0.00520225f, -0.12503737f, -0.05890104f, -0.09904598f, 
    0.08205620f, -0.44171095f, -0.14624219f, -0.14448288f, -0.01903902f, 0.03106432f, -0.14722598f, -0.16277280f, 
    0.06824603f, -0.11159795f, 0.11036826f, -0.02231486f, 0.21101028f, 0.14010447f, 0.26913029f, 0.04389459f, 
    0.00971731f, -0.03599256f, -0.01018211f, -0.05043850f, -0.05521262f, -0.10367998f, -0.11271533f, -0.17652684f, 
    -0.04948345f, 0.24807808f, 0.02788606f, 0.20115440f, 0.10437912f, 0.11365452f, -0.04915723f, 0.13323203f, 
    0.03125751f, -0.11820286f, -0.10534293f, 0.11011990f, -0.07718535f, -0.01824535f, -0.00305846f, 0.01591812f, 
    -0.06308775f, -0.16585520f, -0.08933298f, 0.06002565f, -0.13157976f, -0.08215082f, 0.05482996f, -0.03334869f, 
    -0.13382235f, -0.25439176f, 0.11592320f, -0.04023304f, -0.16558018f, 0.12117755f, -0.10259894f, -0.04894010f, 
    -0.07239247f, 0.01624454f, -0.04547148f, -0.03847344f, -0.00873628f, -0.06436218f, -0.07680760f, 0.19853228f, 
    0.01659046f, -0.00625581f, 0.14319083f, -0.05467710f, 0.21797432f, 0.14922048f, 0.24440822f, 0.32411435f, 
    0.28629956f, 0.10206392f, 0.14979227f, 0.03652677f, 0.02679638f, 0.02157637f, 0.02993766f, -0.00495127f, 
    -0.13919985f, -0.08469228f, -0.02652606f, -0.01392366f, 0.19173530f, 0.20422369f, -0.03285366f, 0.21068327f, 
    -0.08800443f, 0.15776715f, -0.02811328f, 0.01409976f, -0.06589554f, 0.09093405f, 0.16702169f, 0.05712726f, 
    -0.10003193f, 0.28022438f, -0.22931273f, 0.28586292f, 0.10708628f, 0.16191252f, 0.05013384f, -0.12536800f, 
    0.03323834f, -0.05097145f, -0.02545220f, 0.07964735f, -0.22378393f, 0.14076655f, 0.12264524f, 0.19271444f, 
    -0.10953107f, 0.00095532f, -0.02228152f, 0.06096399f, -0.04346624f, -0.08468056f, 0.04548289f, 0.04202848f, 
    -0.08325870f, 0.03677839f, 0.26708359f, -0.05461119f, -0.01087117f, -0.14024359f, -0.15913850f, 0.29764119f, 
    -0.10983764f, -0.04980870f, -0.07828356f, -0.10137560f, -0.23965152f, 0.33452430f, -0.01138135f, 0.22754213f, 
    -0.00545987f, 0.06848054f, -0.08572215f, 0.21869583f, -0.04645717f, -0.07147472f, -0.05703267f, -0.03939132f, 
    0.09932052f, 0.17712975f, 0.31583682f, -0.02076976f, -0.03355006f, -0.10124851f, -0.15995757f, 0.18517393f, 
    0.08064229f, 0.07429584f, -0.08540320f, 0.04780194f, 0.01029626f, -0.07986039f, 0.12527658f, 0.04325977f, 
    -0.01964144f, 0.30816263f, 0.01823857f, 0.10307989f, 0.06668975f, 0.04829026f, 0.12771641f, 0.01470194f, 
    -0.22520079f, 0.05364635f, -0.06581476f, -0.06409665f, -0.00006529f, 0.04413754f, 0.19282824f, 0.00489250f, 
    -0.10067415f, -0.20343877f, -0.01929741f, 0.07310347f, -0.02781135f, -0.06992022f, 0.11678086f, -0.15173215f, 
    0.11339080f, 0.23281759f, 0.12840001f, 0.17205939f, 0.08696273f, 0.26586324f, 0.02399369f, 0.28820306f, 
    -0.07749419f, -0.11376341f, 0.10708445f, -0.02433681f, -0.02662612f, 0.15744236f, 0.11656912f, 0.07739112f, 
    0.09832366f, 0.12095691f, 0.07782289f, 0.05740862f, -0.00747316f, 0.04308483f, -0.00559629f, 0.10029031f, 
    -0.02897341f, -0.08745735f, 0.06469728f, -0.02652194f, 0.06777934f, -0.03089240f, -0.03928426f, 0.19708686f, 
    -0.34119681f, -0.04992282f, -0.21320625f, 0.21756001f, 0.08535716f, 0.05360541f, 0.06058115f, -0.08502118f, 
    -0.03471559f, 0.04263265f, 0.00754818f, -0.09381793f, 0.16216496f, -0.05396169f, 0.03377326f, 0.13747227f, 
    -0.02130856f, -0.00614480f, 0.03563778f, -0.09297784f, -0.05918300f, 0.15485439f, 0.17253642f, -0.03477380f, 
    -0.16276929f, -0.00486136f, -0.13866524f, -0.02542166f, -0.06389154f, 0.00091894f, -0.00572164f, 0.03231721f, 
    0.02062934f, 0.03012914f, -0.07439484f, 0.02830732f, -0.04084937f, -0.04087963f, 0.04910436f, -0.23891917f, 
    -0.02200977f, -0.00595818f, -0.04815805f, 0.14329065f, -0.00134463f, -0.20480171f, 0.00619101f, -0.22533469f, 
    -0.02619793f, -0.09508006f, -0.11386428f, 0.08339351f, -0.13552402f, -0.04583165f, -0.07731914f, 0.02468793f, 
    -0.06036983f, -0.06568570f, -0.14017393f, -0.05377572f, 0.18440716f, 0.29338646f, 0.21677680f, -0.10537749f, 
    -0.17799543f, -0.10003535f, -0.02360762f, -0.00211946f, 0.16077673f, 0.00773690f, 0.00840601f, -0.14873073f, 
    0.08805700f, 0.33753550f, 0.00274363f, 0.09014305f, 0.00943073f, 0.02618478f, -0.06551554f, 0.15942155f, 
    0.00656933f, 0.01912392f, -0.02048355f, -0.26340318f, -0.20117714f, -0.04730088f, 0.24306655f, 0.24125807f, 
    -0.04549956f, -0.17253785f, -0.12651959f, -0.06278345f, 0.12375139f, -0.09844711f, 0.19511342f, 0.15176217f, 
    0.02859283f, -0.07439219f, 0.01777850f, 0.04949893f, -0.00519727f, 0.00921106f, 0.02623818f, 0.05247724f, 
    -0.05014104f, 0.00359624f, 0.05232184f, -0.06771349f, -0.06866199f, 0.01975896f, -0.03864954f, -0.00384377f, 
    -0.04125075f, 0.04280998f, -0.02972165f, 0.02115005f, 0.03577793f, 0.06075948f, -0.05983384f, -0.04951534f, 
    0.05926893f, 0.05599305f, -0.03833698f, 0.04946513f, -0.02077558f, 0.03707371f, 0.05717612f, -0.05373345f, 
    0.04737271f, 0.05635944f, 0.04135090f, -0.06573541f, -0.05314393f, 0.01895732f, 0.04697686f, 0.06163163f, 
    -0.05667746f, -0.07022746f, 0.04226574f, 0.03179161f, 0.00301631f, -0.00336561f, 0.00247626f, -0.03878649f, 
    -0.01405640f, 0.05641069f, -0.02870961f, 0.05665554f, -0.06697445f, 0.04542775f, -0.05735952f, -0.03301056f, 
    0.04793030f, 0.04363819f, -0.01996494f, 0.02081806f, -0.01223136f, -0.04788033f, -0.06890476f, 0.02976426f, 
    0.04999678f, 0.02738674f, -0.06736641f, -0.06512760f, -0.06927246f, -0.02174007f, 0.00889370f, 0.01588362f, 
    -0.00071060f, -0.03721515f, -0.00300867f, -0.03847811f, -0.02494390f, -0.06084497f, -0.01862469f, -0.02997926f, 
    -0.00729553f, 0.03738776f, 0.05212013f, 0.03722722f, -0.01161705f, -0.07034285f, -0.07605622f, -0.04343009f, 
    -0.05758485f, -0.07122138f, 0.05327842f, 0.01049117f, -0.01799693f, -0.02093907f, 0.05284599f, -0.04102799f, 
    0.05231188f, 0.00993996f, -0.00705215f, -0.04746739f, 0.02500459f, 0.02838370f, 0.05228971f, 0.00671338f, 
    0.01929821f, -0.06089529f, -0.03938348f, 0.01428202f, -0.05558894f, 0.01878218f, -0.00646549f, 0.03142115f, 
    -0.01176114f, -0.03476376f, 0.03031355f, -0.05408148f, -0.05519833f, 0.05649275f, -0.03884555f, 0.04385800f, 
    -0.05287842f, 0.05438583f, -0.05658962f, -0.07454638f, 0.01149343f, -0.01376425f, -0.03146064f, 0.05095713f, 
    0.06641315f, -0.03346631f, -0.07130012f, 0.04808895f, -0.07261455f, -0.04591105f, 0.02444805f, -0.04214650f, 
    -0.01499932f, -0.01294385f, -0.06676163f, -0.03328057f, 0.00209052f, -0.01132299f, -0.02995237f, 0.00482733f, 
    0.04382459f, 0.05056223f, -0.03745681f, -0.01159678f, -0.03458208f, 0.04321912f, -0.03449860f, -0.03165141f, 
    0.00655166f, -0.05568929f, -0.04981358f, 0.04577646f, -0.00179290f, -0.04621865f, 0.00838111f, -0.01228304f, 
    -0.06709663f, -0.02526989f, -0.05998695f, 0.00495809f, -0.06697123f, -0.06727114f, -0.06638341f, -0.02298531f, 
    -0.05820135f, 0.01232596f, 0.03949669f, -0.04744833f, -0.01841027f, -0.05801323f, -0.01835544f, 0.05774304f, 
    -0.07036150f, 0.04682698f, 0.02263747f, -0.02955456f, -0.04975080f, -0.07378373f, 0.02801402f, 0.01269159f, 
    -0.07120768f, 0.02252864f, 0.02028400f, 0.00755393f, -0.03966749f, 0.01978248f, 0.02888444f, 0.03891305f, 
    0.05220245f, 0.13237128f, -0.22747701f, -0.10353180f, 0.00538498f, 0.04636574f, 0.08072805f, 0.00191503f, 
    0.07403719f, 0.12589318f, 0.01234965f, -0.05701234f, -0.19084075f, -0.57029635f, -0.51137722f, -0.42421699f, 
    0.06864840f, 0.02977971f, -0.00274184f, -0.06756593f, -0.11448914f, -0.07719485f, -0.02168795f, 0.12768307f, 
    0.32021785f, 0.06049063f, -0.11348157f, 0.01620036f, -0.00261264f, -0.01680715f, 0.17395286f, 0.07684458f, 
    0.03386760f, 0.11147074f, 0.31000790f, 0.32582876f, -0.16066560f, -0.03794882f, -0.06778613f, -0.11383970f, 
    -0.07495823f, -0.32908598f, -0.07700339f, 0.01757739f, -0.16433202f, -0.12815362f, -0.09847080f, -0.01307493f, 
    -0.47375271f, 0.14173962f, 0.25983337f, -0.40036896f, 0.08065151f, 0.08749717f, -0.09761749f, 0.15476425f, 
    -0.00285027f, 0.07449959f, 0.01209992f, 0.03740784f, 0.14625314f, 0.03536338f, 0.01387468f, -0.01550357f, 
    0.18924195f, 0.09901109f, 0.05590319f, -0.06235069f, 0.12762333f, -0.07888082f, -0.03640005f, -0.17817517f, 
    -0.06178543f, -0.84947848f, -0.24921864f, -0.31325188f, 0.10677896f, 0.09797226f, 0.06186701f, -0.06038288f, 
    0.00767337f, -0.00659632f, 0.13429327f, -0.07386700f, 0.34245235f, 0.40321735f, 0.18815918f, 0.18728927f, 
    -0.21592452f, -0.01552102f, -0.05279161f, -0.10147943f, -0.09406473f, -0.09727143f, -0.03361817f, -0.16051051f, 
    -0.19857866f, 0.09415459f, -0.06619532f, -0.05188139f, 0.08087465f, 0.08892119f, -0.00728249f, 0.04947104f, 
    -0.10266362f, -0.09861947f, -0.05726465f, 0.12099078f, 0.06848121f, -0.00286004f, 0.20171425f, 0.13536438f, 
    -0.01069143f, -0.10376016f, -0.26676434f, -0.03899690f, -0.00759293f, 0.05806965f, 0.08657369f, 0.01971734f, 
    -0.13422328f, -0.03536448f, -0.27218232f, -0.10796276f, 0.02728663f, -0.19284108f, 0.00102146f, -0.12819102f, 
    -0.14882663f, -0.21116506f, 0.02139460f, -0.04380912f, 0.06409014f, -0.07963932f, 0.14949344f, 0.13104296f, 
    -0.06776480f, -0.05764720f, 0.08662591f, 0.05481058f, 0.16673072f, 0.06748547f, 0.20577487f, 0.33044237f, 
    0.28581917f, 0.21496472f, 0.06457308f, 0.08710198f, -0.03978911f, 0.04007549f, 0.00771677f, -0.01736644f, 
    -0.11655772f, 0.08193012f, 0.00361170f, -0.00981992f, 0.17006715f, 0.12342580f, 0.12222580f, -0.03937385f, 
    -0.00883213f, 0.08321635f, -0.07345360f, -0.03776492f, 0.11200745f, 0.36426997f, 0.24047169f, 0.00899459f, 
    -0.49199077f, -0.22549534f, 0.07288517f, 0.25234962f, 0.24471012f, 0.20202783f, -0.12814620f, -0.14139195f, 
    -0.14904799f, 0.04666426f, -0.03453101f, -0.00393586f, -0.04445902f, 0.10959496f, 0.33204651f, -0.03803699f, 
    -0.11535229f, 0.05222055f, -0.03214923f, 0.00944786f, 0.04905538f, 0.17667159f, -0.06726741f, 0.19469628f, 
    0.01368900f, -0.03378346f, 0.04024449f, -0.06479779f, -0.06286930f, -0.06147939f, -0.06847543f, 0.01439212f, 
    0.00410263f, -0.02246651f, 0.00969369f, -0.07471041f, 0.03385897f, 0.04974430f, -0.03945834f, 0.06027066f, 
    -0.07154701f, -0.06797396f, 0.05992133f, -0.02017123f, -0.00449734f, -0.01804520f, -0.05249849f, 0.02552068f, 
    -0.06168927f, 0.03147212f, 0.04081412f, 0.02305730f, -0.01138593f, -0.06933458f, 0.05854121f, -0.04475899f, 
    0.00363629f, -0.07137977f, 0.04406976f, 0.04263061f, 0.01442188f, 0.04485663f, -0.03308593f, 0.00130689f, 
    -0.04754094f, 0.02152916f, -0.02920442f, -0.07844886f, -0.06171612f, -0.04442165f, -0.05898552f, 0.00400867f, 
    0.01396065f, 0.04436345f, 0.03113787f, -0.07255648f, -0.03357276f, -0.04917882f, -0.08526610f, 0.01475985f, 
    -0.04831613f, -0.05172162f, -0.07644438f, 0.01072612f, -0.07077805f, -0.03506384f, 0.04027061f, -0.05512829f, 
    -0.02322961f, -0.05878486f, 0.01755069f, -0.00299005f, -0.02870199f, 0.02628489f, 0.05184794f, -0.04552710f, 
    -0.01540036f, 0.02536657f, 0.05110682f, 0.02694461f, 0.02168008f, -0.01651546f, 0.02830552f, -0.02980412f, 
    -0.03220854f, 0.00393338f, 0.00487280f, -0.01939058f, -0.02261196f, 0.03341486f, -0.06001952f, -0.00682016f, 
    -0.07193222f, 0.04427967f, 0.03503732f, -0.02469636f, -0.05168376f, -0.05041440f, -0.01577117f, -0.01257495f, 
    0.07363503f, 0.03375909f, -0.06190263f, 0.01382172f, 0.05016293f, 0.00305406f, -0.05334074f, -0.07632949f, 
    -0.01395483f, 0.01154789f, -0.00755140f, 0.06534083f, -0.03347262f, 0.06669524f, 0.00000569f, 0.02124557f, 
    0.03116955f, -0.00767006f, 0.00825363f, -0.01153969f, -0.01904975f, -0.04926004f, -0.05886617f, -0.05754886f, 
    0.02449422f, -0.01446200f, 0.05077225f, 0.05127150f, -0.07930113f, 0.04235658f, 0.03304162f, -0.00043665f, 
    -0.02169777f, -0.04650860f, -0.01999379f, -0.02770439f, -0.04544314f, -0.02975302f, 0.00010073f, -0.04090625f, 
    0.02828604f, -0.04346518f, 0.02387895f, 0.00690856f, -0.07660568f, 0.04590062f, 0.04057103f, -0.02893578f, 
    -0.02710452f, 0.01547004f, -0.06768352f, 0.05374282f, -0.03899698f, -0.01794680f, -0.03402741f, -0.03609874f, 
    -0.00671778f, -0.06711207f, 0.02760687f, -0.00907903f, -0.05031564f, -0.01003919f, 0.05821642f, 0.05199418f, 
    -0.07325149f, 0.03772652f, -0.02234773f, -0.00182260f, -0.03678371f, -0.06239296f, -0.02269230f, -0.05700608f, 
    -0.01376545f, -0.01912596f, -0.00491335f, -0.00970540f, -0.04805190f, -0.03847223f, 0.01670711f, 0.01528114f, 
    0.00480727f, -0.04132205f, -0.02914909f, -0.00047795f, -0.05587227f, -0.00390513f, 0.03091917f, 0.02167309f, 
    0.05425545f, -0.03411037f, -0.04756757f, -0.02276543f, -0.05774607f, 0.01014520f, 0.01491358f, 0.02512729f, 
    0.00213418f, -0.06563088f, -0.35816297f, -0.16062987f, 0.16461466f, -0.04083195f, -0.20080194f, 0.20474109f, 
    -0.10938405f, 0.00934614f, 0.10875205f, 0.00561424f, 0.04544470f, 0.32469425f, 0.04292006f, 0.00705903f, 
    0.21630670f, 0.12089991f, 0.08434936f, 0.13337336f, -0.08039959f, -0.08788422f, -0.17865112f, -0.02850050f, 
    0.16089445f, 0.38236412f, -0.02333787f, 0.24442738f, 0.04308016f, -0.02740901f, -0.04124491f, 0.24740258f, 
    -0.06657980f, -0.01933507f, 0.04151209f, 0.04067512f, 0.05620484f, -0.11463901f, 0.10784344f, 0.12719567f, 
    0.13739753f, 0.29121163f, 0.03596321f, 0.10004422f, 0.13857411f, -0.00074580f, 0.02023738f, 0.11693211f, 
    0.01719241f, 0.01937010f, -0.08006028f, -0.13035165f, 0.12218896f, 0.06646279f, 0.03086405f, 0.10059745f, 
    -0.15649502f, -0.08702537f, 0.01241966f, 0.18963590f, -0.06403241f, 0.02329826f, -0.10493303f, 0.06257954f, 
    0.02101531f, 0.09246431f, 0.04394157f, 0.06829286f, 0.11259905f, 0.13011153f, 0.14801633f, 0.08542151f, 
    0.27217081f, 0.03735410f, 0.18165115f, -0.08471142f, -0.05059493f, -0.02663003f, 0.04573499f, 0.02071072f, 
    -0.06755840f, 0.08442488f, -0.00152389f, 0.05327725f, -0.00974665f, -0.03424140f, 0.09633468f, 0.00868359f, 
    0.06354783f, -0.09408841f, 0.12786876f, 0.05500765f, 0.05190107f, -0.00383916f, -0.15502703f, 0.12297384f, 
    -0.23543067f, 0.29125780f, 0.23561868f, -0.02193574f, 0.01862989f, 0.02064507f, -0.07052379f, -0.01667968f, 
    -0.06386228f, -0.08228318f, -0.13810587f, -0.07986230f, -0.14259794f, 0.00071210f, 0.01388355f, -0.14501221f, 
    -0.00852772f, -0.00955675f, 0.09580730f, 0.08544495f, 0.08611682f, 0.23499449f, 0.03762306f, 0.08992170f, 
    0.30560756f, 0.02467210f, 0.00508725f, -0.07303469f, -0.04503852f, 0.17162341f, 0.09664292f, -0.02557112f, 
    0.03139950f, 0.08681751f, -0.02025019f, 0.09089394f, -0.09927617f, -0.20522602f, -0.23373052f, 0.13645798f, 
    -0.09579131f, 0.02700369f, -0.09609565f, -0.06027043f, -0.11275112f, -0.30573210f, -0.02636112f, -0.25855628f, 
    -0.00452957f, -0.09875686f, 0.09950083f, 0.17579357f, -0.09692529f, -0.13515082f, -0.02155088f, -0.11418316f, 
    -0.02547682f, -0.04186584f, -0.13564578f, -0.01583045f, 0.15559286f, 0.10016128f, -0.05813855f, 0.18509783f, 
    -0.11152321f, 0.08392317f, -0.14526379f, 0.02399534f, 0.00652115f, -0.08285433f, -0.12982155f, -0.14738311f, 
    0.03983165f, 0.44059423f, -0.16652122f, 0.23538382f, -0.03711118f, 0.04839453f, 0.08423284f, -0.05285539f, 
    -0.08578577f, -0.06781808f, 0.00354937f, -0.16286573f, -0.46902555f, 0.12147568f, 0.18278214f, 0.01726162f, 
    -0.05513670f, -0.12719516f, 0.03624637f, -0.12330039f, 0.08295892f, -0.09046504f, 0.10541903f, 0.19669715f, 
    -0.04745082f, -0.04669151f, 0.17395036f, -0.17167801f, -0.13221841f, -0.08549830f, -0.06475537f, 0.26127043f, 
    -0.03140669f, 0.05003603f, 0.02378802f, -0.01248195f, 0.08032294f, 0.23981684f, -0.06154913f, 0.05788479f, 
    0.11516288f, -0.00748272f, 0.01366171f, -0.00172097f, -0.07478384f, -0.05664457f, -0.12248923f, 0.10539526f, 
    -0.18307686f, 0.16618477f, 0.22519115f, -0.04520458f, 0.00144975f, -0.23982605f, -0.09113914f, 0.05794413f, 
    0.14888644f, -0.00376936f, 0.04399439f, 0.27135879f, -0.04007420f, -0.03804646f, -0.12543024f, -0.05335025f, 
    0.03611375f, 0.20075540f, 0.07292882f, -0.07404492f, 0.01461532f, -0.07246871f, -0.03025678f, -0.10476764f, 
    0.12154541f, 0.08356470f, -0.14568432f, -0.29194102f, 0.12050485f, 0.07440475f, 0.09362642f, -0.07654977f, 
    -0.07347106f, -0.10542771f, -0.01880619f, 0.06563538f, -0.32543999f, -0.32294926f, 0.19048640f, -0.56838042f, 
    0.15465321f, 0.00943435f, -0.05864555f, 0.11116435f, 0.19469482f, 0.20816496f, 0.09483267f, 0.15711020f, 
    -0.01902968f, -0.04073612f, -0.08020357f, -0.14290115f, 0.06023043f, 0.19666176f, 0.00426812f, 0.00681812f, 
    0.05449031f, 0.02645333f, 0.02516207f, 0.03616790f, -0.22408082f, 0.01780361f, -0.06633918f, -0.16757713f, 
    -0.04286819f, -0.12015975f, 0.07797767f, -0.06433968f, -0.04733875f, -0.04020183f, -0.03357316f, 0.03719951f, 
    -0.01817642f, -0.21505006f, 0.19792493f, 0.00425737f, 0.11365062f, 0.08822616f, 0.06036063f, -0.06629938f, 
    -0.03005549f, 0.04217897f, 0.03622552f, -0.11471718f, 0.16516842f, -0.06500168f, 0.00952590f, 0.09714659f, 
    0.20799328f, 0.04908333f, -0.03210418f, 0.03035774f, -0.08632222f, 0.26131439f, -0.13355020f, -0.02527855f, 
    -0.09229099f, 0.10487549f, -0.02137094f, -0.10095827f, 0.09196086f, -0.21981320f, 0.24356502f, 0.23222780f, 
    -0.02173721f, 0.06873798f, 0.01204826f, 0.15113153f, -0.23212104f, -0.27286896f, -0.07544621f, -0.12117545f, 
    -0.02900489f, 0.03572926f, -0.05152928f, 0.12521139f, 0.10623547f, -0.02464109f, 0.02931217f, -0.16209659f, 
    -0.22061005f, -0.26355672f, -0.00634475f, -0.16445611f, -0.16093236f, -0.26803768f, -0.12400394f, -0.16877730f, 
    0.11319038f, 0.05863328f, -0.16476789f, -0.10585879f, 0.07180432f, 0.03414596f, 0.14551629f, -0.09386039f, 
    -0.16902898f, -0.14682870f, 0.01613677f, -0.09499041f, 0.22847933f, -0.07170905f, 0.08265647f, -0.01698384f, 
    0.24995399f, 0.11445433f, 0.02583832f, 0.22677267f, -0.05394596f, -0.06564511f, 0.05365827f, 0.12304915f, 
    0.00728667f, 0.01282954f, -0.12615882f, -0.18346170f, 0.25192091f, -0.06629276f, 0.60356635f, 0.07662435f, 
    -0.09884784f, -0.20762874f, 0.00065726f, 0.05972806f, 0.15197833f, 0.06263622f, 0.11510245f, -0.01969888f, 
    -0.03527854f, 0.03419325f, 0.02557651f, 0.05750343f, 0.02083866f, -0.02474904f, -0.06076723f, -0.03614951f, 
    -0.05252566f, -0.05816920f, 0.04567039f, -0.03787602f, -0.01856578f, -0.04174543f, -0.07173749f, 0.01250189f, 
    -0.06050779f, -0.07571621f, -0.00890811f, -0.03291625f, 0.03587281f, -0.07122020f, 0.04311001f, 0.00144981f, 
    -0.06956339f, -0.03034577f, -0.06171310f, -0.02710941f, 0.00324610f, 0.00121365f, -0.01039683f, 0.01487181f, 
    -0.04590289f, -0.03036605f, 0.05449510f, -0.05403655f, 0.01851280f, -0.00738081f, -0.05916741f, 0.02766630f, 
    -0.01103630f, -0.08137254f, -0.02108120f, 0.02322171f, 0.00090683f, -0.05655396f, -0.03813665f, 0.00878661f, 
    0.04571116f, -0.07150176f, -0.00160766f, -0.06007868f, 0.01424354f, 0.00680533f, 0.02101030f, 0.05762216f, 
    -0.03668066f, 0.04985005f, 0.02621510f, -0.00193769f, -0.05409092f, -0.01603985f, 0.02600993f, -0.04351923f, 
    0.01285079f, 0.06829645f, -0.06081002f, -0.00756346f, -0.00839366f, -0.04680873f, -0.00445860f, -0.00562432f, 
    0.05011812f, 0.01031633f, 0.03040564f, 0.04957569f, 0.02808389f, -0.07642102f, -0.07530894f, -0.00078607f, 
    -0.03132413f, 0.02883789f, -0.02484120f, -0.01415196f, -0.01782431f, -0.03126903f, -0.06811307f, 0.02842690f, 
    0.06109659f, -0.04900056f, -0.05988828f, -0.03073925f, -0.03053915f, -0.02296342f, 0.02465085f, -0.05571163f, 
    -0.07190226f, -0.00259119f, 0.04885653f, 0.00457224f, -0.00159425f, 0.02499699f, 0.01810185f, -0.07876107f, 
    0.04659953f, -0.01799959f, -0.00444638f, 0.02382243f, 0.03459816f, 0.04686308f, -0.00043594f, -0.03466943f, 
    -0.05734242f, -0.00979152f, 0.02291875f, -0.08143694f, 0.01688391f, 0.01625338f, 0.06206867f, 0.06142499f, 
    0.00709126f, -0.00620020f, 0.05506264f, 0.00066075f, 0.03128361f, 0.01347065f, 0.01817701f, 0.00957654f, 
    -0.05067511f, -0.01722876f, -0.06654277f, 0.01432789f, -0.02391995f, -0.07194622f, 0.02118797f, -0.07972197f, 
    -0.00318922f, 0.00029937f, -0.06043392f, 0.05937170f, -0.08034286f, -0.07253459f, 0.02656506f, -0.06718679f, 
    -0.03219649f, -0.01071094f, -0.05216413f, 0.01032766f, -0.05661593f, -0.02962004f, 0.04911728f, -0.03663374f, 
    0.06027429f, 0.06949444f, -0.00106140f, -0.07009389f, 0.02185008f, -0.06398459f, -0.04128292f, -0.00650891f, 
    -0.02095076f, -0.07868905f, -0.07091824f, -0.04597136f, -0.04813975f, 0.06217362f, -0.06762940f, -0.04764584f, 
    0.04951800f, -0.07816622f, -0.04546220f, 0.06631426f, -0.03594336f, -0.01675839f, 0.04612911f, 0.04602349f, 
    -0.00857678f, 0.04691780f, 0.05012923f, 0.00825240f, -0.03530131f, -0.03348488f, -0.04685894f, -0.01003071f, 
    -0.03507206f, 0.05315013f, 0.03464257f, 0.04841420f, 0.04278946f, -0.06727191f, -0.07339296f, -0.02814084f, 
    -0.12076135f, -0.22947036f, -0.01119658f, -0.00682712f, -0.09839945f, -0.06958631f, 0.10308883f, 0.20548676f, 
    0.14101237f, -0.09208478f, -0.13681865f, -0.21177939f, -0.19553508f, -0.08066608f, 0.15517904f, 0.06919129f, 
    0.05220421f, -0.02751151f, -0.04980310f, 0.16001827f, -0.04257619f, -0.04543621f, -0.11088771f, -0.05656551f, 
    0.11149030f, 0.05018564f, 0.29891852f, 0.06396126f, 0.04220549f, -0.04341321f, -0.05757190f, 0.10157275f, 
    -0.00300913f, 0.12091225f, 0.02517581f, -0.02592686f, -0.05441896f, -0.05130706f, 0.11234786f, 0.13018309f, 
    -0.00313794f, 0.12997574f, 0.14667951f, 0.10124661f, 0.01077160f, 0.06849675f, 0.08051541f, 0.09400938f, 
    -0.15483956f, -0.08360559f, -0.02419548f, 0.05640761f, 0.10363127f, 0.03565573f, 0.18080574f, 0.09232711f, 
    -0.03665590f, -0.07537734f, -0.03101151f, -0.02802773f, -0.03698116f, -0.05024093f, 0.15847808f, -0.12251523f, 
    0.01720169f, 0.06897996f, 0.01721886f, 0.09570733f, -0.07776140f, -0.00771944f, 0.01117354f, 0.09787895f, 
    -0.36261651f, -0.10489958f, 0.02546910f, 0.04421151f, 0.11315278f, 0.10781581f, 0.04122186f, -0.01713909f, 
    -0.00943590f, 0.01232175f, 0.00037951f, 0.03661456f, 0.04538719f, 0.33671647f, 0.05145168f, 0.00782980f, 
    -0.05504212f, 0.00099793f, -0.04309859f, 0.05530205f, 0.01431994f, -0.04145948f, 0.05378677f, 0.16922587f, 
    0.02070102f, 0.19633129f, -0.11220339f, 0.08322483f, 0.06222700f, 0.02167995f, 0.04864844f, -0.15977642f, 
    -0.10693659f, 0.05565417f, -0.02305510f, -0.07302369f, 0.11224423f, -0.00404777f, 0.00175621f, -0.12501501f, 
    -0.10641994f, -0.08916806f, 0.12107816f, -0.05885907f, -0.00648846f, 0.12805797f, 0.08637703f, 0.11854874f, 
    -0.21736041f, 0.13609628f, -0.08271228f, -0.04242824f, 0.08555771f, 0.09508865f, 0.19991870f, 0.07169980f, 
    -0.00674461f, -0.05970817f, 0.02664895f, -0.02243671f, 0.05915337f, 0.07676648f, 0.10827140f, -0.06335761f, 
    0.01812782f, -0.00178997f, -0.08214007f, 0.10837722f, 0.05797042f, -0.24583733f, -0.01715521f, -0.14578226f, 
    -0.08988183f, 0.10081551f, 0.06123560f, -0.12575033f, -0.18350920f, -0.10438031f, -0.07666504f, -0.04046851f, 
    -0.20608330f, -0.01514619f, -0.12193421f, 0.02830873f, -0.09273286f, 0.17073768f, 0.15109767f, -0.11435979f, 
    -0.07136068f, -0.14592007f, -0.07198098f, -0.08787388f, 0.14471996f, 0.17709213f, -0.04684164f, 0.14627707f, 
    0.05427662f, 0.29489413f, -0.11260123f, -0.22857192f, -0.05635146f, -0.02036923f, 0.04275343f, 0.11381114f, 
    0.07849960f, 0.05207876f, -0.08789027f, -0.12672931f, 0.17545013f, -0.12352310f, -0.18798076f, -0.27211028f, 
    -0.12477628f, -0.00514894f, 0.04264334f, 0.10188559f, 0.13947958f, -0.00873823f, 0.18322326f, 0.05287869f, 
    0.19246812f, -0.22881646f, -0.22706372f, -0.29187748f, -0.05116285f, -0.10026795f, -0.00119989f, 0.19047202f, 
    -0.03867130f, 0.03053954f, 0.06838505f, -0.11198951f, 0.01765258f, 0.19872303f, 0.06183515f, 0.31247467f, 
    0.03083746f, -0.03084249f, 0.04219766f, 0.02960393f, 0.13545969f, -0.01897753f, -0.01094629f, -0.13226917f, 
    0.30250990f, 0.20821597f, 0.13047601f, 0.18190552f, 0.06169716f, 0.07128695f, -0.04985464f, 0.10207268f, 
    0.00185374f, -0.12062586f, -0.01802080f, -0.03119482f, -0.11761142f, -0.11287551f, 0.13457164f, -0.04470133f, 
    0.05734836f, 0.15806909f, 0.07924633f, 0.13103758f, 0.02924261f, 0.02500896f, 0.00033115f, 0.13660191f, 
    -0.16633314f, 0.02615378f, -0.00098881f, -0.08474194f, -0.04628953f, -0.06119272f, 0.09101360f, 0.20536692f, 
    -0.09300242f, -0.13007012f, -0.11121590f, -0.03445987f, 0.01583152f, -0.10349113f, 0.00755392f, -0.08546031f, 
    -0.12382338f, 0.33541837f, 0.02541585f, 0.01041649f, -0.04276548f, 0.15319751f, -0.01780917f, 0.05416514f, 
    -0.00555878f, 0.17891960f, 0.05208750f, -0.03218681f, 0.03987426f, -0.07618093f, -0.01598420f, 0.06519578f, 
    0.10442021f, 0.12745398f, 0.12920551f, 0.08256457f, 0.10583878f, -0.04541006f, -0.14719561f, 0.19475627f, 
    -0.11744525f, -0.18381870f, 0.02775964f, -0.09361566f, 0.06813334f, 0.08168523f, -0.09978223f, 0.06329846f, 
    0.10532331f, 0.14089738f, -0.13619675f, -0.03127608f, 0.26942119f, 0.14547765f, 0.09366109f, -0.20697622f, 
    0.07488541f, 0.01715771f, -0.05534321f, -0.18073179f, -0.20729364f, 0.08836643f, 0.13721080f, -0.03590385f, 
    0.05218892f, 0.10630411f, -0.04108172f, 0.05538409f, 0.03489992f, 0.11241622f, 0.16617544f, 0.04859352f, 
    -0.11230505f, -0.11249079f, -0.01699237f, -0.34150398f, -0.12676124f, 0.09153458f, 0.16953225f, -0.01105508f, 
    -0.03439030f, 0.01081522f, -0.03357598f, -0.03329453f, 0.10076623f, -0.01388341f, 0.13667229f, 0.02904820f, 
    -0.13022222f, 0.05363825f, -0.03678172f, 0.18405673f, -0.08168054f, -0.11899953f, -0.08414073f, -0.05268831f, 
    0.13541679f, 0.15461977f, 0.05888864f, 0.06624714f, -0.09209754f, -0.07038277f, 0.03874017f, -0.05831730f, 
    -0.14058004f, 0.03103998f, -0.09443863f, -0.10485888f, 0.33979493f, -0.00784534f, 0.28758445f, 0.01133354f, 
    -0.11588112f, -0.00607217f, -0.13950594f, -0.08933978f, 0.00936887f, 0.19421770f, -0.16745587f, 0.04843649f, 
    0.07452667f, -0.13543499f, 0.11965840f, -0.12814036f, -0.10931872f, -0.05327402f, -0.14078434f, 0.02134473f, 
    -0.08776356f, -0.06714981f, -0.04378042f, 0.02704907f, -0.08042745f, -0.05169211f, -0.00803759f, 0.30977845f, 
    -0.07817081f, -0.04305868f, -0.02960539f, -0.19341408f, 0.16959026f, -0.01553865f, 0.25496334f, 0.22120588f, 
    0.03291898f, 0.05544914f, 0.35462853f, 0.15062810f, 0.02284184f, -0.02155426f, -0.00882780f, -0.20597820f, 
    -0.00025169f, -0.02277059f, 0.04751182f, 0.12889722f, -0.16597669f, -0.01989941f, 0.33623007f, 0.14099790f, 
    0.03218573f, -0.04889053f, -0.05355892f, -0.06219389f, 0.13364583f, -0.06627302f, 0.19452368f, 0.01512631f, 
    0.31254306f, -0.11964052f, -0.00277398f, 0.03813343f, -0.03313330f, 0.11291570f, -0.29796797f, -0.13245942f, 
    0.08757909f, 0.13247581f, -0.24805260f, 0.10538296f, 0.11657738f, 0.01647172f, 0.02737775f, 0.06313511f, 
    -0.03189936f, 0.09671143f, -0.07327100f, 0.03930794f, -0.01589807f, 0.03064840f, -0.15376034f, -0.22673500f, 
    0.06696478f, -0.15371506f, 0.07608909f, 0.21847211f, 0.02786155f, -0.08731214f, 0.16639915f, 0.07001053f, 
    0.11881509f, -0.02394503f, 0.06206521f, 0.04344377f, 0.14395969f, -0.00402092f, -0.15000068f, 0.13232325f, 
    -0.10010982f, -0.19464026f, 0.03553119f, 0.05264907f, 0.04458926f, 0.04926551f, -0.12539050f, -0.00225626f, 
    -0.02383943f, -0.04784344f, 0.02015937f, 0.06786472f, -0.01396385f, -0.07564893f, -0.08611998f, 0.15420237f, 
    -0.06031814f, 0.10971283f, -0.07243847f, 0.08951085f, 0.22029002f, -0.08020645f, 0.21688184f, -0.01495691f, 
    0.12664336f, 0.09538790f, -0.07371520f, 0.07010123f, -0.08787201f, -0.04273859f, -0.10832318f, -0.10787927f, 
    0.03643659f, 0.01941334f, -0.12656336f, 0.32308918f, -0.09609719f, -0.09751505f, -0.01053120f, -0.00774642f, 
    0.00209742f, -0.01209888f, -0.01851953f, 0.11480585f, 0.13833079f, -0.26702264f, -0.31434387f, -0.02763068f, 
    -0.03286913f, -0.05273605f, 0.06970388f, -0.07462851f, -0.00737126f, -0.24094377f, -0.07092053f, -0.09983902f, 
    0.12763958f, 0.12751547f, 0.12922603f, 0.15081193f, -0.01789963f, 0.08262940f, -0.22172837f, -0.00203694f, 
    0.05307424f, -0.01680879f, -0.06413076f, 0.02124380f, 0.11678586f, 0.22647488f, 0.11773142f, -0.10203236f, 
    -0.07713975f, 0.09196133f, -0.01579766f, -0.00189030f, 0.02114791f, 0.19766001f, 0.15179077f, 0.21419585f, 
    0.04181823f, 0.29435712f, 0.19849077f, -0.06755762f, 0.03677866f, 0.04317436f, -0.17236315f, 0.00327772f, 
    -0.02604984f, -0.09118532f, 0.14120108f, -0.01905400f, 0.14716381f, 0.04707006f, -0.14570504f, 0.15299201f, 
    -0.02787940f, -0.01409753f, -0.06156739f, 0.07331726f, -0.10963420f, -0.02001374f, 0.13178407f, 0.07195967f, 
    -0.06896477f, 0.34223840f, 0.06572536f, 0.04555883f, 0.10892288f, 0.02458892f, -0.08213291f, -0.00460597f, 
    -0.10218430f, 0.11657493f, 0.00475409f, -0.01469699f, -0.18401422f, -0.06982496f, -0.27797276f, 0.25686428f, 
    0.16720189f, -0.07171585f, -0.08419636f, -0.01583515f, -0.04624539f, -0.05197407f, -0.03121172f, -0.09675468f, 
    0.34406769f, -0.17698367f, -0.20565432f, 0.13158138f, 0.13413125f, 0.03563769f, -0.04722095f, -0.12684651f, 
    0.19150069f, -0.00355182f, 0.04115223f, -0.06058851f, 0.07556728f, 0.24837977f, 0.26545593f, 0.22235127f, 
    0.21227817f, -0.04508359f, 0.26990789f, 0.06780651f, -0.00353641f, -0.01365998f, 0.06567048f, -0.15697291f, 
    0.13639913f, 0.29745331f, 0.15501574f, 0.29902834f, 0.02084808f, 0.15748841f, -0.26037776f, -0.03566833f, 
    -0.05498878f, -0.00991027f, -0.15324917f, -0.00778242f, 0.06778888f, -0.18342002f, -0.02206120f, 0.06560366f, 
    0.07510848f, 0.27086726f, 0.19321333f, 0.17592160f, -0.02987192f, 0.06125772f, 0.11875412f, 0.09334913f, 
    -0.14207289f, -0.19202468f, -0.27114114f, 0.17067473f, -0.03252477f, 0.14630896f, 0.17559868f, 0.30982149f, 
    -0.10952159f, -0.05107530f, -0.06136550f, 0.01303107f, 0.16668473f, -0.11088126f, -0.04737858f, 0.09850936f, 
    -0.16510308f, 0.03278657f, -0.07331493f, 0.07331529f, -0.03056702f, 0.15412103f, 0.09394358f, 0.07868907f, 
    -0.07068083f, -0.19859010f, 0.03366669f, -0.02083688f, 0.03879778f, -0.03753651f, -0.05832183f, 0.16958721f, 
    -0.00939586f, 0.07186763f, -0.01812595f, 0.11364656f, 0.22111741f, 0.25215307f, 0.24201494f, -0.04654196f, 
    0.04212344f, -0.10673136f, -0.05702823f, 0.06006424f, -0.11401718f, 0.07442459f, -0.02820421f, 0.02736278f, 
    -0.00919505f, 0.53511047f, -0.09829392f, -0.01178131f, -0.00479365f, -0.29644194f, -0.01476019f, -0.10192169f, 
    -0.08082063f, 0.03849341f, -0.05738056f, -0.06824595f, -0.11022349f, -0.13019352f, -0.10598958f, -0.11058456f, 
    -0.06139381f, 0.01662805f, 0.19204083f, 0.05681475f, 0.14647390f, -0.00630844f, 0.07507090f, 0.15893693f, 
    0.39780951f, -0.11166470f, -0.06564739f, 0.09812257f, -0.09511293f, 0.06704646f, 0.09085346f, -0.10876334f, 
    0.00823229f, -0.08401790f, -0.03976992f, 0.07296824f, 0.16326737f, 0.21857920f, 0.08862140f, 0.17831382f, 
    -0.03572823f, -0.00694024f, -0.03264406f, -0.12220883f, -0.04224966f, -0.22500278f, -0.07971068f, -0.10441720f, 
    0.03271990f, 0.15374491f, 0.02218325f, 0.10523620f, -0.06784415f, -0.03033460f, -0.17190528f, -0.17183459f, 
    -0.19775796f, 0.02035849f, 0.04237828f, -0.08210953f, 0.16170095f, 0.27733594f, 0.02731347f, 0.22987325f, 
    -0.10592611f, -0.08681366f, -0.05884072f, -0.12171138f, -0.06056465f, -0.00560625f, -0.23184364f, -0.08742388f, 
    0.17455356f, 0.33379787f, -0.24616569f, -0.23848566f, -0.06215861f, -0.11887114f, 0.11816595f, 0.13663149f, 
    -0.08141747f, -0.18451822f, 0.01123766f, 0.13230769f, -0.09718671f, 0.07834738f, -0.44994643f, 0.02830714f, 
    0.01988015f, 0.01446335f, 0.07028839f, -0.09052205f, 0.03279658f, -0.06132456f, 0.03721168f, 0.19716196f, 
    0.00227415f, -0.31273040f, -0.00517347f, 0.17285161f, -0.01164030f, -0.04152154f, 0.15118615f, -0.07738498f, 
    0.11881187f, 0.00714486f, -0.06317972f, -0.10614900f, 0.26629144f, 0.03712085f, -0.04475478f, 0.02041239f, 
    0.11750282f, -0.06151662f, 0.04513249f, 0.10095128f, -0.02308473f, 0.08353423f, -0.08197189f, -0.11567836f, 
    -0.28185543f, -0.06173609f, 0.21156223f, 0.03361366f, 0.09347390f, -0.09837046f, -0.17614900f, -0.08215748f, 
    0.08135697f, -0.04289629f, -0.05378130f, 0.04595912f, 0.04118022f, -0.08548199f, -0.17720653f, 0.15137166f, 
    0.06257703f, 0.02439486f, 0.20482473f, 0.11758983f, 0.01677094f, 0.05045337f, 0.07912259f, 0.12855409f, 
    -0.11805273f, -0.19164139f, -0.12610997f, 0.06915654f, 0.10694740f, 0.06171655f, 0.15227394f, 0.27442214f, 
    0.01015567f, -0.02484156f, -0.12666214f, 0.01028150f, 0.03388875f, 0.04356150f, 0.15078050f, -0.08124056f, 
    -0.02449258f, -0.07186776f, 0.03658690f, 0.00280483f, 0.05134834f, 0.00759952f, 0.06041189f, 0.05201366f, 
    -0.17141089f, -0.27179745f, 0.04233648f, 0.07678985f, 0.04291904f, 0.15296425f, 0.03208437f, 0.16019908f, 
    -0.09952093f, -0.00517251f, -0.04261925f, 0.00508781f, 0.03446321f, 0.31651923f, 0.18503416f, -0.09418540f, 
    -0.05830207f, 0.05876029f, -0.07850729f, 0.00455578f, 0.01434890f, -0.01328843f, 0.05022185f, 0.00769118f, 
    -0.03047134f, 0.14926979f, -0.14040522f, -0.08162392f, -0.15776950f, -0.06521557f, -0.07958639f, -0.21472555f, 
    -0.10413595f, 0.10925716f, 0.01912680f, -0.04920235f, 0.11985830f, -0.02884301f, -0.03804378f, -0.00457129f, 
    0.02961465f, -0.02692497f, 0.16142592f, 0.11153939f, 0.10947071f, 0.04817672f, 0.06413814f, 0.18503331f, 
    0.19660449f, 0.15996976f, -0.19204883f, 0.23498955f, 0.15609047f, -0.13537182f, 0.22721983f, -0.06060365f, 
    0.00839458f, -0.11965999f, 0.10013840f, 0.00579259f, -0.11192634f, 0.14467831f, 0.19514157f, 0.15749297f, 
    -0.01894975f, -0.16727182f, -0.00245716f, -0.09522075f, 0.00846709f, -0.16309582f, -0.12912707f, -0.08630040f, 
    -0.02926794f, -0.04779898f, 0.00743248f, -0.14052726f, -0.14209870f, -0.15441251f, -0.09781468f, -0.04222399f, 
    -0.09252454f, -0.04401054f, 0.04645694f, 0.06270184f, -0.02795961f, 0.24772663f, 0.11457808f, -0.01285519f, 
    -0.05966643f, -0.16640897f, -0.01774236f, -0.17283942f, 0.19709371f, 0.14842965f, -0.02795085f, -0.06518081f, 
    0.14106347f, 0.38669857f, -0.07207613f, -0.11805693f, 0.05871147f, 0.01453622f, 0.03792562f, 0.10431720f, 
    0.08806258f, -0.02189092f, 0.03078194f, -0.08921617f, 0.30999571f, 0.09332392f, -0.13267098f, -0.37182170f, 
    -0.06366812f, 0.02356138f, 0.02871817f, 0.11895850f, 0.01955148f, 0.08738321f, -0.00240601f, 0.04623831f, 
    0.11394694f, -0.18542433f, -0.17858471f, -0.34727535f, 0.03597557f, 0.07484105f, 0.03761803f, -0.00405705f, 
    0.02024653f, -0.10354659f, 0.00514399f, 0.12424290f, 0.16728057f, -0.08788411f, 0.22164555f, -0.07134414f, 
    0.00690618f, -0.01631440f, 0.06788202f, 0.02116652f, 0.04748596f, -0.03113716f, 0.00352443f, 0.00604983f, 
    0.15094040f, -0.13437918f, -0.21676347f, 0.06696759f, 0.15368016f, -0.06990735f, 0.06896869f, 0.15978889f, 
    -0.00178180f, -0.03040803f, 0.26233736f, -0.08032519f, -0.03730646f, 0.13108537f, 0.01399317f, -0.03630770f, 
    0.18556392f, 0.03374971f, -0.00397233f, -0.14375088f, 0.05431001f, 0.05475172f, -0.04246044f, 0.08249106f, 
    0.17834841f, 0.15755516f, 0.18070108f, -0.16939500f, -0.06163033f, 0.10826911f, -0.06005754f, -0.06448504f, 
    0.06363273f, -0.10037011f, 0.10493617f, -0.07917716f, 0.02514765f, 0.01389188f, -0.05376891f, 0.05712183f, 
    -0.00422808f, -0.05793976f, -0.08381116f, -0.09630196f, -0.01086740f, -0.05026490f, -0.07432785f, -0.17115673f, 
    0.15823871f, 0.30504066f, 0.08381218f, 0.05691147f, 0.02153428f, -0.06414199f, -0.00610197f, -0.04118419f, 
    0.06854866f, 0.04040229f, 0.09209126f, 0.02298493f, -0.26601735f, -0.10816605f, -0.18023652f, 0.16291647f, 
    0.10123835f, -0.06795978f, 0.03390728f, 0.01353983f, 0.09085411f, 0.03300546f, -0.00182028f, 0.07510319f, 
    0.05385005f, -0.34347790f, 0.45333433f, -0.06428864f, -0.03739640f, -0.12489717f, 0.10342167f, 0.11598909f, 
    0.12178272f, -0.08258899f, -0.05130245f, 0.10152380f, -0.13567807f, 0.17006946f, 0.05629521f, 0.03180365f, 
    0.12569840f, 0.02050360f, -0.11326368f, 0.02521176f, -0.02067466f, -0.02915395f, -0.03131052f, -0.09662198f, 
    -0.11349270f, 0.12219352f, -0.01239443f, -0.20010373f, 0.05724958f, -0.02045773f, 0.19338194f, 0.02131076f, 
    -0.11919261f, -0.01770206f, -0.03351776f, 0.00898686f, 0.22115962f, -0.17342608f, -0.09980592f, -0.11969708f, 
    -0.05490451f, 0.10621948f, -0.09138285f, -0.08505906f, -0.04274741f, -0.08710379f, 0.06114722f, -0.06152835f, 
    0.13375172f, -0.02423467f, 0.12360883f, 0.08727648f, 0.13406034f, 0.00067034f, 0.06635556f, -0.00664073f, 
    0.02522020f, 0.09542227f, -0.03577264f, -0.04549520f, 0.16155466f, -0.25004932f, -0.01446625f, -0.02543992f, 
    -0.01376604f, 0.08454909f, 0.00834579f, 0.09236613f, -0.01396682f, -0.09413523f, -0.01761221f, -0.02940407f, 
    0.27009103f, -0.26957804f, 0.15988149f, -0.08844054f, -0.13970324f, -0.29026636f, -0.00213190f, 0.08051433f, 
    0.10846930f, 0.03540684f, 0.01150994f, 0.00318940f, 0.18383665f, -0.27329630f, 0.15752766f, -0.00540192f, 
    -0.13357453f, 0.04570435f, -0.02038309f, -0.01578479f, 0.10172954f, 0.11910769f, -0.06516811f, -0.01927642f, 
    -0.01692903f, -0.11158450f, -0.24210066f, -0.06221310f, 0.07044895f, 0.14076152f, 0.10155165f, 0.25065294f, 
    0.01868668f, 0.00588210f, -0.04510368f, -0.06692259f, 0.20487343f, 0.27010840f, -0.02591382f, -0.08723693f, 
    0.11386314f, 0.09655696f, 0.11921189f, 0.13439342f, -0.01710460f, -0.05061326f, -0.20405681f, 0.07617291f, 
    -0.16480611f, 0.19368243f, -0.09788701f, 0.14491563f, 0.08985057f, -0.09393269f, 0.12607512f, 0.02699198f, 
    -0.07604972f, -0.16399498f, 0.19743103f, -0.06154007f, -0.01010943f, 0.00825913f, -0.09757844f, -0.01581759f, 
    0.02961990f, 0.09982307f, 0.02400361f, -0.26366434f, 0.14777327f, 0.03538686f, 0.10309014f, -0.01007968f, 
    0.19278133f, 0.01279335f, -0.14396152f, -0.23244068f, -0.00246133f, 0.11601450f, -0.01381578f, 0.00365930f, 
    -0.18912715f, -0.09829856f, -0.06114237f, -0.17147192f, -0.13798645f, -0.09879291f, -0.04630764f, -0.06859032f, 
    -0.03323285f, 0.06633464f, -0.06204773f, -0.12065694f, -0.07095315f, -0.02064569f, 0.00751482f, -0.07381766f, 
    0.22994532f, 0.09719703f, -0.01176944f, -0.04273697f, 0.03199929f, 0.07907808f, 0.02238564f, 0.05437823f, 
    -0.03345066f, -0.03023398f, 0.01911552f, 0.03566605f, -0.04288959f, 0.06286125f, 0.01528154f, 0.14925891f, 
    0.05531303f, -0.14736654f, -0.04212255f, 0.03705350f, 0.02959264f, 0.03520523f, 0.08134028f, 0.08094034f, 
    0.18690254f, -0.03868268f, 0.37829262f, -0.24253875f, 0.10922030f, 0.04534751f, 0.04776703f, 0.10955304f, 
    0.06803097f, 0.02178027f, -0.09389617f, -0.01671536f, -0.14007205f, -0.01298162f, 0.06037932f, -0.06021511f, 
    0.12489769f, -0.03351576f, -0.19949056f, 0.02051415f, 0.01028157f, 0.13285121f, 0.02877119f, -0.05110976f, 
    0.11823493f, 0.15225977f, -0.08813234f, -0.07063720f, 0.11182491f, 0.03070939f, 0.16753234f, 0.02937279f, 
    -0.08929936f, 0.07330590f, -0.01035008f, 0.05952090f, -0.12763657f, -0.17679499f, -0.31034324f, -0.09931590f, 
    -0.03348789f, 0.06697814f, -0.09044472f, -0.11936955f, 0.05773010f, -0.03021265f, 0.02032577f, -0.27884981f, 
    -0.19227165f, -0.26921123f, -0.03716511f, -0.01313950f, 0.03132818f, -0.05016402f, -0.09855887f, -0.09067468f, 
    0.02148606f, -0.04990708f, -0.12614751f, 0.00539158f, -0.08217318f, -0.09245692f, -0.19422497f, -0.15000404f, 
    -0.05620800f, -0.01677925f, 0.01540349f, -0.02884666f, 0.28772828f, 0.00318246f, -0.04748489f, -0.21506025f, 
    0.34087437f, 0.16726390f, -0.06834698f, 0.05649176f, -0.16480269f, -0.21616554f, 0.09694584f, -0.01529144f, 
    0.06073153f, 0.01302988f, -0.03723315f, 0.00812026f, -0.17116676f, -0.06123292f, 0.20173968f, -0.23726588f, 
    -0.16774850f, 0.01974056f, 0.06679703f, 0.02682660f, 0.14570154f, -0.07095148f, 0.10832766f, -0.02963162f, 
    0.05042004f, 0.00904520f, 0.10868873f, -0.04375525f, -0.10598864f, 0.15090995f, 0.06843704f, 0.05931154f, 
    0.17671761f, 0.19669989f, 0.03485762f, -0.05044769f, 0.07594384f, -0.09577031f, 0.37440380f, 0.04564468f, 
    0.15427461f, -0.06218711f, 0.11445275f, 0.00983331f, 0.03490284f, 0.04304656f, -0.01987910f, -0.00892167f, 
    0.19502975f, -0.06541775f, 0.10554072f, -0.07920111f, -0.02661113f, -0.16052030f, 0.00354567f, 0.03246089f, 
    0.15471333f, -0.06076208f, -0.02701462f, 0.06076714f, -0.13505276f, 0.00140398f, -0.11212140f, -0.13951349f, 
    0.05341409f, -0.02169493f, 0.10381490f, 0.14105338f, -0.09240883f, -0.01334826f, 0.00500867f, 0.08786750f, 
    -0.15137368f, -0.01576717f, 0.05281791f, -0.23737483f, -0.02802211f, 0.08182926f, -0.00756102f, -0.10939015f, 
    -0.07139736f, -0.10941476f, 0.01643325f, 0.04606558f, 0.05412639f, -0.00668625f, 0.01761211f, -0.07980967f, 
    -0.00653214f, -0.16577642f, -0.01270903f, -0.07811234f, 0.10975357f, -0.09464879f, -0.13540617f, 0.02429023f, 
    -0.09242120f, -0.10926797f, -0.03574365f, -0.08389654f, 0.06494538f, 0.11597745f, -0.08641733f, -0.01757604f, 
    -0.06143369f, -0.13463525f, 0.04268245f, -0.02292047f, -0.25332144f, 0.09812944f, -0.13479885f, -0.27207989f, 
    -0.09183370f, 0.12249865f, -0.03807313f, 0.10472732f, 0.05593275f, 0.06128523f, -0.05061823f, -0.00481315f, 
    -0.40094253f, -0.04672460f, 0.06174485f, 0.10301577f, -0.05018761f, -0.03904079f, 0.07056995f, 0.10737140f, 
    -0.02375106f, 0.05428052f, -0.04140649f, -0.05292665f, -0.10317884f, -0.17088148f, 0.21504569f, 0.09953562f, 
    0.00565475f, -0.09450334f, 0.03886038f, 0.09845711f, 0.00733190f, 0.12386785f, 0.15642752f, 0.05581710f, 
    -0.11981518f, 0.06403796f, -0.18669453f, -0.24688928f, 0.02174166f, -0.19509314f, 0.31266245f, 0.03642581f, 
    0.02240727f, -0.01077503f, 0.03505764f, 0.09858517f, 0.12802768f, -0.14150944f, 0.17521100f, -0.19452649f, 
    0.12989594f, -0.04379818f, -0.01419684f, -0.00243595f, -0.05517804f, -0.03046264f, 0.06626130f, 0.11050694f, 
    0.09031171f, 0.02811371f, -0.10375632f, -0.05678742f, -0.12311891f, 0.00943481f, -0.09402195f, 0.08608036f, 
    0.02309377f, -0.01259457f, 0.00157000f, -0.04874497f, 0.25187176f, 0.10893418f, 0.17897463f, -0.11624165f, 
    0.02859772f, -0.02647037f, 0.06805207f, -0.07628344f, -0.01484985f, 0.06107626f, 0.05855116f, -0.07517100f, 
    0.14920191f, -0.09050278f, -0.03363563f, -0.07023189f, 0.13694009f, -0.13231014f, 0.10038088f, -0.05143329f, 
    0.08607606f, 0.08239085f, 0.00772130f, -0.14349163f, 0.02727787f, -0.08756646f, 0.47904959f, -0.02383423f, 
    -0.04691682f, 0.00483587f, 0.01859598f, 0.11547953f, -0.03093461f, 0.04793975f, -0.06196363f, -0.07985170f, 
    0.13303298f, 0.29985815f, -0.14715669f, 0.24744451f, -0.13585910f, 0.00639782f, 0.03103110f, 0.05164367f, 
    0.13215728f, 0.05509210f, 0.00265143f, -0.11307555f, -0.02890496f, -0.27186593f, 0.44979736f, 0.03032375f, 
    -0.00702163f, 0.07703698f, 0.24851847f, 0.03410629f, -0.08661868f, 0.08111830f, 0.05901765f, -0.10510989f, 
    0.22752444f, 0.13096738f, -0.05882725f, 0.27726084f, 0.09879089f, 0.15504436f, 0.07938594f, 0.12178180f, 
    -0.17816755f, -0.04598648f, 0.12387259f, 0.08698170f, -0.05211158f, -0.03671495f, 0.23649548f, 0.10717998f, 
    0.02240228f, 0.17259656f, 0.04843429f, 0.10050540f, -0.04718216f, 0.00742635f, -0.01004041f, -0.05783664f, 
    -0.06066338f, -0.09743623f, 0.12938109f, -0.03229099f, 0.01824057f, 0.08587521f, 0.01405722f, 0.03299377f, 
    0.05249838f, 0.01445127f, 0.00755096f, 0.00210309f, 0.10676040f, 0.02741490f, 0.07993379f, 0.14634137f, 
    -0.04518145f, -0.11537558f, -0.02892007f, 0.07906465f, -0.01158150f, -0.07404085f, -0.06003648f, -0.05937661f, 
    -0.20497163f, -0.10272643f, 0.07060732f, -0.11253773f, 0.09231029f, 0.05901371f, -0.12694380f, -0.10236536f, 
    -0.10510429f, -0.05525362f, 0.09123265f, 0.13109055f, 0.09156268f, 0.22255839f, 0.01174938f, -0.16516113f, 
    0.00930833f, -0.12866853f, -0.05315471f, -0.00991227f, 0.03896157f, -0.01915728f, -0.02831730f, 0.04092307f, 
    -0.33407831f, 0.56079727f, -0.25848800f, 0.01255781f, -0.13663691f, -0.04653965f, -0.01996709f, -0.07527608f, 
    -0.13713370f, 0.07907607f, -0.04507400f, 0.11218917f, -0.03822713f, 0.01680425f, -0.02344241f, -0.08886262f, 
    -0.08982626f, 0.03650736f, 0.06401292f, -0.02228859f, 0.04488996f, -0.01356190f, 0.18481877f, 0.10986570f, 
    -0.18837671f, -0.29535857f, 0.06376923f, -0.00169518f, -0.09309123f, 0.20875742f, 0.03445178f, -0.12991247f, 
    0.00777966f, 0.04732664f, -0.03488223f, -0.04000250f, 0.13605902f, -0.11822671f, 0.07038570f, -0.00383786f, 
    0.00116686f, -0.15035591f, -0.01099572f, -0.04407248f, 0.01742163f, -0.11564573f, 0.09286282f, 0.10937598f, 
    0.05044492f, 0.01337457f, -0.16254823f, -0.08839759f, -0.16948669f, -0.12307983f, -0.18987273f, -0.11381914f, 
    -0.20083605f, -0.00382592f, -0.07950278f, -0.05437543f, 0.08552051f, 0.33233127f, 0.00778752f, -0.02929085f, 
    -0.13550320f, -0.03605548f, 0.09113742f, -0.04229215f, 0.09647588f, 0.04533868f, -0.09797473f, 0.04764860f, 
    0.04090200f, 0.03055796f, -0.14438125f, -0.00921922f, 0.06317554f, -0.12101972f, 0.15583879f, 0.02269636f, 
    0.14425260f, -0.03454575f, -0.02844475f, 0.08185243f, -0.12867963f, 0.09223514f, -0.17182902f, -0.15312129f, 
    -0.22976276f, -0.01404646f, 0.08974300f, 0.04960722f, 0.00379661f, 0.00826660f, 0.01670440f, 0.15205549f, 
    -0.06218692f, -0.88307124f, -0.29577252f, -0.35832375f, 0.06672727f, -0.03815677f, 0.06783486f, -0.05441244f, 
    -0.06210986f, -0.04112173f, 0.03445702f, -0.00555855f, -0.21001722f, -0.09534933f, -0.44751677f, -0.22118534f, 
    0.03191155f, -0.09485867f, -0.04194812f, 0.10046718f, 0.04533699f, -0.01394134f, 0.03002324f, -0.10152218f, 
    0.22213770f, 0.21373224f, 0.21175468f, 0.14872494f, -0.07557397f, 0.10289540f, -0.08905468f, -0.07361183f, 
    0.10304561f, 0.02590447f, -0.08814176f, 0.15446514f, -0.19991371f, -0.33114377f, -0.30487725f, -0.00359956f, 
    0.17402628f, 0.26285976f, 0.01031909f, -0.01670620f, -0.02913294f, 0.05034482f, 0.03397217f, -0.00863699f, 
    0.22406796f, -0.26870129f, -0.50939751f, -0.14560920f, 0.05329725f, 0.05709792f, 0.22326733f, 0.31168580f, 
    0.07953591f, 0.00889818f, -0.08812952f, -0.08098289f, 0.12142537f, 0.08631919f, 0.01767858f, 0.09789072f, 
    -0.00907946f, 0.15474772f, 0.03980792f, 0.02062732f, 0.01161440f, 0.10054417f, 0.03625665f, 0.03026439f, 
    0.11382723f, 0.12019241f, -0.45958328f, -0.06956394f, -0.00789304f, -0.09684654f, 0.10751932f, 0.18892731f, 
    -0.01377145f, 0.10295834f, 0.06667312f, -0.03016034f, 0.25092360f, 0.28702816f, 0.29698893f, 0.36415648f, 
    0.12291071f, -0.05483965f, -0.01077662f, -0.01272461f, -0.10060030f, -0.02990935f, 0.01813907f, 0.08284575f, 
    0.27656662f, 0.21030031f, 0.27110776f, 0.04243633f, 0.20416237f, 0.01543735f, 0.05174058f, -0.09775008f, 
    0.06218318f, -0.02849658f, 0.01551334f, 0.04053288f, 0.07226787f, 0.02551728f, -0.00492590f, 0.03644471f, 
    0.00897028f, 0.01398066f, 0.09987087f, -0.07138512f, -0.15404382f, -0.12806971f, -0.04158980f, -0.09386486f, 
    -0.08214013f, -0.00389333f, -0.46328795f, -0.36059403f, 0.05089075f, 0.14002988f, 0.10004949f, 0.10077247f, 
    -0.02117658f, -0.09368007f, 0.01954292f, -0.06134695f, 0.10967317f, -0.08031465f, 0.08207532f, 0.11975846f, 
    -0.03452056f, 0.08812457f, -0.05486697f, 0.03833022f, 0.20053871f, -0.18836947f, 0.10810368f, 0.03485471f, 
    0.12156701f, 0.27011660f, 0.26564324f, 0.30456302f, -0.03010776f, 0.01769609f, -0.02574348f, -0.02330600f, 
    -0.09589058f, -0.07975487f, 0.00709977f, 0.12240003f, 0.35073897f, 0.01491287f, 0.24617851f, 0.18136577f, 
    -0.07591555f, -0.01018125f, -0.00645630f, 0.02888095f, 0.01787354f, -0.06934728f, -0.30553463f, 0.15185575f, 
    0.51947427f, 0.28486010f, 0.03917760f, -0.09276307f, 0.03292302f, -0.11657929f, 0.07680587f, 0.16529500f, 
    -0.06366576f, -0.02836085f, -0.05234303f, -0.01366026f, 0.19260745f, -0.06860641f, -0.12522499f, 0.20693837f, 
    -0.08235848f, -0.05456646f, -0.02506764f, -0.14376278f, 0.07937855f, -0.20710184f, 0.13114671f, 0.00989533f, 
    0.21416487f, -0.02468769f, 0.22381723f, -0.19253619f, 0.02023767f, -0.04518790f, -0.15207534f, -0.20040539f, 
    0.00394938f, 0.09744070f, 0.04731773f, 0.11188424f, 0.26290366f, 0.24893515f, -0.18706343f, 0.08770328f, 
    0.16536944f, 0.18273039f, 0.00462815f, 0.10684001f, 0.16571032f, -0.10941605f, 0.11896996f, 0.07590764f, 
    -0.28180295f, -0.01315456f, 0.02863420f, -0.24100471f, -0.10706488f, -0.16845673f, 0.03381365f, -0.38205659f, 
    0.22126149f, -0.04044727f, -0.02667228f, -0.01588677f, 0.15632962f, -0.07047120f, -0.23902990f, -0.19352759f, 
    0.04840579f, -0.10022421f, 0.06521106f, 0.11242513f, -0.07784649f, -0.15055859f, -0.18614677f, -0.13335761f, 
    0.22206414f, 0.25407428f, -0.12672669f, 0.05988385f, 0.00618259f, -0.02244774f, 0.01796441f, 0.04196166f, 
    -0.01088969f, 0.05247100f, 0.06197677f, 0.01051420f, 0.03918553f, -0.17641050f, -0.01173572f, -0.32149792f, 
    -0.07336508f, 0.04563537f, -0.05848285f, -0.26757124f, 0.03203668f, -0.10225007f, -0.15743111f, -0.08861195f, 
    0.41007328f, 0.23503298f, -0.10426670f, -0.03631023f, 0.06189571f, 0.07071157f, 0.16811886f, 0.03592523f, 
    0.12324658f, 0.04639298f, 0.01021721f, -0.00449383f, -0.05517579f, -0.09112208f, -0.09257099f, 0.13715920f, 
    -0.12007461f, 0.08886926f, -0.11591318f, -0.13709188f, -0.06083801f, -0.10365175f, -0.00588896f, -0.17341588f, 
    0.10868139f, -0.10504299f, 0.31063709f, -0.00111415f, 0.08944732f, 0.10190462f, -0.04431461f, 0.08346368f, 
    0.05797547f, -0.21960168f, -0.02307746f, -0.25392741f, -0.16245508f, 0.04889348f, -0.00959064f, 0.22780092f, 
    0.18025227f, 0.22199319f, -0.25745136f, -0.21875706f, -0.08820304f, -0.21700920f, -0.31795350f, -0.19672258f, 
    0.11731500f, -0.06604860f, -0.25265792f, -0.21770823f, 0.13344993f, 0.07376914f, 0.06130878f, 0.07810304f, 
    -0.04543892f, 0.08239947f, -0.00956884f, -0.02517861f, -0.01035716f, -0.07684035f, -0.01546080f, 0.01938279f, 
    -0.03953083f, -0.02033724f, 0.11506207f, 0.13158077f, 0.21548179f, 0.30337161f, 0.04179604f, 0.23030114f, 
    -0.04145315f, -0.07124080f, -0.06673532f, 0.17352466f, -0.01183796f, 0.26930910f, 0.18690062f, 0.00387741f, 
    0.06480283f, -0.04419351f, -0.12407223f, -0.12255912f, 0.15863869f, -0.23888920f, 0.06059139f, 0.05489708f, 
    -0.08556347f, -0.20189124f, -0.05772958f, -0.16186281f, -0.00417527f, -0.03977466f, 0.16843605f, 0.04284507f, 
    0.29931483f, -0.25816685f, 0.19309276f, 0.06421304f, -0.00979824f, 0.10682098f, 0.03719788f, -0.08322060f, 
    -0.11324696f, -0.14731820f, -0.06441396f, -0.01306522f, 0.19084032f, 0.22456029f, 0.36848086f, 0.25841656f, 
    0.03916209f, -0.11577003f, -0.17706153f, -0.22768691f, -0.01823989f, -0.03892500f, -0.06812909f, -0.02119208f, 
    0.16239609f, -0.03340656f, 0.02574030f, 0.14000438f, 0.12199856f, 0.16871664f, 0.06497741f, -0.23168166f, 
    -0.11014998f, 0.06257101f, 0.11950412f, -0.00518504f, 0.12629810f, 0.03755800f, 0.08490718f, -0.00688222f, 
    0.14961001f, -0.05511489f, 0.13393320f, -0.15387727f, -0.00423138f, 0.03390825f, -0.02059836f, -0.19999094f, 
    -0.27637666f, 0.05088393f, -0.21199094f, -0.05182565f, -0.16575935f, -0.06851116f, -0.17685062f, -0.05732501f, 
    -0.08050165f, 0.03133954f, -0.07061152f, -0.08676953f, 0.28883681f, 0.28897253f, 0.06792043f, 0.15785363f, 
    0.22721529f, 0.15312546f, 0.08628993f, -0.04387708f, -0.03385226f, 0.10978293f, -0.00657200f, -0.02988820f, 
    -0.12223358f, 0.08018771f, -0.15661322f, 0.20296714f, -0.03408315f, 0.07261907f, 0.01911435f, 0.15037116f, 
    0.18924060f, 0.11342316f, -0.08381321f, 0.08103237f, -0.08332208f, -0.04932005f, -0.10518923f, 0.01749451f, 
    -0.15925752f, -0.05314573f, -0.09153607f, -0.06996702f, -0.00993130f, -0.04085095f, 0.01576561f, -0.04431785f, 
    0.02857137f, -0.17518380f, 0.02747741f, -0.06942280f, 0.19428763f, -0.01800143f, -0.06732462f, -0.10641618f, 
    -0.06033420f, 0.03583643f, -0.12173459f, -0.12528585f, -0.06707682f, -0.11447246f, 0.21404852f, -0.33529836f, 
    -0.05374395f, 0.01688265f, -0.04835597f, -0.05346806f, -0.00691638f, 0.06954077f, 0.00716914f, -0.09145486f, 
    -0.41326749f, 0.31229788f, -0.00029839f, -0.28205591f, 0.18430606f, -0.19601607f, 0.08201926f, -0.02173512f, 
    0.07522263f, -0.03311719f, -0.02244220f, 0.04962986f, -0.05273341f, -0.03632954f, 0.06555028f, 0.07799378f, 
    0.05324651f, 0.22721474f, 0.22834560f, 0.14193690f, 0.16921303f, 0.06335545f, -0.00799134f, 0.00350265f, 
    0.40825650f, 0.06313618f, -0.00744035f, 0.24342653f, -0.17377026f, 0.04253216f, -0.01566529f, -0.24490154f, 
    0.01976464f, -0.10739216f, -0.04689502f, 0.10629059f, -0.04219181f, 0.02952739f, -0.11143769f, -0.10339909f, 
    -0.06407675f, -0.13293245f, -0.05614975f, -0.05714367f, -0.19176912f, -0.15343794f, -0.09636708f, 0.03957054f, 
    -0.22390559f, -0.11107922f, -0.16602382f, -0.20906514f, -0.07673031f, -0.09731508f, -0.02923318f, 0.03507831f, 
    0.04566358f, 0.06647111f, 0.04943376f, -0.02660636f, -0.04741764f, 0.00829339f, -0.28894618f, -0.06388935f, 
    0.06199270f, 0.07233443f, -0.07131485f, 0.05688868f, -0.46265149f, 0.10256179f, 0.09317798f, 0.15511848f, 
    -0.07407362f, 0.08456257f, -0.18067214f, 0.00748780f, -0.13264549f, -0.06940059f, -0.04274746f, -0.19844320f, 
    0.07401235f, -0.06286085f, 0.10786941f, 0.11238077f, -0.03502639f, 0.26832393f, -0.20197310f, -0.19980158f, 
    0.13067529f, 0.09716586f, 0.00216614f, 0.00415434f, -0.13413571f, 0.28053322f, 0.04948341f, -0.03426357f, 
    0.03955280f, -0.27850282f, -0.08116192f, -0.22136407f, -0.15642828f, -0.12355308f, -0.10608414f, 0.27633354f, 
    -0.03367945f, 0.04483949f, -0.00707320f, -0.05179080f, -0.10825295f, 0.16619770f, 0.20617150f, 0.23773500f, 
    0.20006768f, -0.01806455f, -0.00954009f, 0.15716287f, 0.09757984f, -0.06821374f, -0.06421730f, -0.08077236f, 
    0.25895452f, 0.05352289f, 0.30925184f, 0.19074127f, 0.07581817f, -0.02301784f, -0.26417208f, 0.27091041f, 
    0.04329926f, 0.02896319f, -0.02587664f, -0.05251198f, -0.04109769f, -0.12257189f, 0.16887261f, 0.10005088f, 
    -0.00883475f, 0.30590385f, 0.16909970f, 0.18661608f, 0.11528412f, 0.07629490f, 0.11903596f, 0.17339464f, 
    -0.16080786f, -0.11735766f, -0.03929372f, -0.05164563f, 0.13297933f, -0.01786817f, 0.16919270f, 0.02534976f, 
    -0.23043889f, -0.16015750f, 0.00842925f, -0.00559451f, 0.01934179f, -0.20368543f, 0.06652822f, -0.19209163f, 
    0.06154565f, 0.22379905f, 0.04987133f, 0.15281232f, 0.00787905f, 0.33514044f, 0.11523155f, 0.18885411f, 
    -0.08741993f, 0.18036422f, 0.15511943f, 0.01669069f, 0.04787701f, 0.00002252f, -0.03790325f, 0.06846499f, 
    -0.00440854f, 0.06685689f, -0.05256619f, 0.07068692f, -0.06598806f, 0.11201733f, 0.02862511f, 0.09121481f, 
    -0.09169831f, -0.15971452f, 0.01814848f, 0.07170885f, 0.10486615f, 0.05787440f, -0.11615122f, 0.04615720f, 
    0.13894606f, -0.01393697f, -0.01309472f, 0.16506837f, 0.18754849f, 0.04417569f, 0.09087469f, -0.18464309f, 
    0.01394505f, 0.06424569f, -0.08176799f, 0.00807120f, 0.02874759f, -0.02139907f, 0.00555261f, -0.01734516f, 
    0.09234928f, 0.01851415f, 0.04543776f, 0.00417611f, -0.02659059f, 0.11419341f, 0.13260999f, 0.05564606f, 
    -0.19424725f, 0.08006241f, -0.03882279f, -0.20578355f, -0.04409273f, -0.04370430f, 0.23851718f, -0.01309858f, 
    -0.03367127f, 0.07114842f, -0.15198518f, 0.11361975f, 0.01805094f, -0.05593433f, 0.05762071f, -0.08459174f, 
    -0.13122261f, 0.10400414f, -0.18254928f, 0.15159665f, 0.02011540f, -0.28468254f, 0.04786665f, -0.20398401f, 
    -0.02954155f, 0.09040637f, 0.16966480f, -0.19496004f, -0.18612581f, -0.17846625f, -0.02757185f, -0.06507754f, 
    -0.02624707f, -0.08258480f, -0.08001156f, -0.12631884f, 0.24793798f, 0.10902753f, 0.33831543f, -0.02406587f, 
    -0.09562349f, -0.13462792f, -0.05129296f, -0.10484584f, 0.13274899f, -0.02139159f, -0.12529412f, -0.08648958f, 
    0.08414897f, 0.17386900f, -0.03797243f, -0.25772059f, -0.13513297f, -0.12275530f, 0.04205849f, 0.20366421f, 
    -0.01090097f, 0.05127898f, -0.05371854f, -0.25349712f, -0.16062137f, -0.31886551f, -0.10037111f, 0.08331148f, 
    0.00752475f, -0.10167862f, -0.01941372f, -0.09125189f, 0.18808480f, 0.04141436f, 0.22068332f, 0.17594621f, 
    0.26212934f, -0.36110160f, -0.13295630f, -0.14636286f, 0.09533773f, 0.10671133f, 0.09331326f, -0.06082016f, 
    -0.13879965f, 0.02708942f, 0.14825554f, 0.01357122f, 0.18808009f, 0.24507207f, 0.27478391f, 0.22690715f, 
    0.15729730f, 0.06410768f, 0.19635603f, 0.10634468f, -0.09939249f, -0.04199016f, -0.04848558f, 0.01835384f, 
    0.07837105f, -0.23216340f, -0.18140113f, -0.10558751f, -0.09632581f, -0.23590998f, -0.16681103f, 0.10246590f, 
    -0.00189655f, -0.06350429f, -0.03509878f, -0.09295207f, 0.18350574f, 0.13115904f, 0.08044263f, 0.26922795f, 
    0.19987971f, 0.02778344f, 0.12983428f, -0.00508405f, -0.02714737f, 0.06485024f, 0.01286974f, 0.15641980f, 
    0.11232997f, 0.06124273f, 0.00005017f, 0.13349505f, 0.07702214f, 0.19200435f, 0.08531342f, 0.10082424f, 
    -0.05435491f, 0.01920204f, 0.06956615f, -0.06807508f, -0.02570178f, -0.05530604f, -0.23338324f, -0.16967709f, 
    0.16099717f, 0.02084881f, 0.06066633f, -0.01650069f, 0.18435498f, 0.19392961f, 0.15505339f, 0.01410474f, 
    0.31982803f, 0.07279432f, 0.12435061f, 0.03683732f, -0.12123958f, -0.02327029f, 0.04847665f, 0.15080404f, 
    -0.08283486f, -0.00271758f, -0.14644217f, 0.03979768f, -0.27530694f, -0.07074092f, -0.05695716f, -0.13995951f, 
    -0.12240370f, -0.11620471f, 0.00051988f, -0.00239647f, -0.04594248f, -0.03855872f, 0.07505514f, -0.03311659f, 
    0.06406800f, -0.30950573f, 0.22819979f, -0.22486661f, 0.03633792f, -0.02213163f, 0.06905317f, -0.10768033f, 
    0.06675766f, -0.01955961f, -0.06070106f, 0.00742732f, -0.04426815f, -0.13459992f, -0.04299889f, 0.00753327f, 
    0.20083086f, 0.00721056f, 0.04281840f, 0.11984533f, 0.12581483f, 0.08549798f, 0.15167932f, 0.03198236f, 
    0.44211107f, 0.34226772f, 0.11713640f, 0.09271600f, 0.00855381f, -0.14682747f, 0.13333797f, 0.02121236f, 
    -0.01822280f, 0.01233585f, -0.09418328f, 0.16648237f, 0.00748103f, 0.02492941f, -0.07159920f, -0.02686662f, 
    -0.07232648f, 0.05091175f, 0.00867178f, -0.04187042f, -0.08515601f, 0.13993219f, 0.10696333f, 0.01568745f, 
    -0.16138975f, -0.25456914f, -0.23207673f, -0.26204482f, -0.12536849f, -0.08723045f, -0.10263589f, 0.01049152f, 
    0.12377483f, 0.05386084f, 0.05376321f, -0.04789570f, 0.11337841f, -0.69744688f, -0.30762973f, -0.13220704f, 
    0.02625053f, 0.07613938f, -0.02941496f, -0.07860560f, -0.00787194f, 0.08680727f, 0.21611501f, -0.11141062f, 
    0.01876125f, -0.00243610f, 0.05474025f, -0.00959136f, -0.17940167f, -0.02606245f, -0.06125484f, -0.07238801f, 
    -0.02712636f, -0.04417661f, 0.13207325f, 0.02755380f, -0.33810407f, -0.35617003f, 0.08225193f, -0.10358228f, 
    -0.04593197f, 0.03512743f, 0.07022651f, 0.15712725f, 0.11432794f, 0.09871875f, -0.04629618f, 0.11706644f, 
    0.01698545f, 0.00187824f, -0.02693154f, 0.03134825f, 0.00346151f, -0.03884824f, -0.06963221f, -0.00324244f, 
    0.02735566f, -0.06199013f, -0.02035284f, 0.01808048f, -0.05995645f, 0.00474857f, 0.00647958f, 0.03515078f, 
    -0.05569022f, 0.03452335f, -0.08056430f, -0.03574235f, 0.03440332f, -0.03550678f, -0.05443995f, -0.05925367f, 
    0.00633727f, -0.00407446f, -0.01053218f, 0.03715502f, 0.01571182f, -0.02274664f, 0.02572890f, 0.06980979f, 
    -0.07648668f, -0.00239699f, -0.01005552f, -0.05052685f, 0.01198067f, -0.02140065f, -0.02729002f, 0.04907349f, 
    -0.03223968f, 0.05630129f, -0.02409157f, 0.04365235f, -0.01217420f, -0.07786345f, 0.05810349f, -0.03287321f, 
    -0.08073293f, -0.00157964f, 0.04549607f, -0.03954357f, 0.01490277f, -0.00234475f, 0.05419030f, -0.04280202f, 
    -0.04371184f, 0.02161884f, -0.05961630f, 0.03418374f, 0.02815120f, 0.02427882f, -0.02837276f, -0.00980508f, 
    -0.05790851f, -0.01639730f, -0.03199047f, 0.03221025f, 0.04095258f, -0.02496816f, -0.04992455f, 0.02230050f, 
    0.04409008f, -0.00690719f, -0.05604113f, -0.02705805f, 0.00104568f, 0.03135839f, -0.04029926f, -0.03180147f, 
    0.03645085f, 0.03283001f, 0.01049391f, -0.04199040f, -0.05713156f, 0.03086649f, -0.03924386f, -0.03956657f, 
    0.01963676f, -0.00803642f, 0.01486408f, 0.04451068f, 0.05353942f, -0.02146747f, 0.00162213f, -0.04694687f, 
    -0.01958342f, -0.06463298f, 0.04374621f, 0.03705994f, 0.01561096f, 0.05830708f, -0.02424610f, 0.01061529f, 
    0.01264678f, -0.05032644f, -0.03759181f, 0.01765333f, 0.00184166f, 0.02178955f, 0.04897620f, -0.00763985f, 
    0.00464909f, -0.04266942f, -0.01044888f, -0.07488132f, -0.00448786f, 0.03048300f, -0.05410814f, -0.03337211f, 
    -0.08347878f, 0.03379965f, -0.07176310f, 0.02309242f, 0.06970625f, 0.01016481f, -0.05828878f, -0.01109109f, 
    -0.01672155f, -0.02747901f, 0.03538892f, -0.06377471f, 0.02569495f, 0.00259883f, -0.05499146f, 0.01760224f, 
    0.06188969f, 0.03719814f, -0.02635137f, -0.01193119f, 0.06988282f, -0.05553238f, -0.03815710f, -0.03023666f, 
    -0.00906217f, -0.04989705f, -0.05318123f, 0.03566658f, -0.00805951f, -0.05578775f, 0.04687493f, 0.05882545f, 
    0.04212421f, -0.01552987f, 0.00414628f, 0.00660699f, -0.07028653f, -0.02190275f, -0.04279792f, 0.06019693f, 
    -0.06651144f, -0.03590468f, -0.03882943f, -0.02162908f, 0.03145623f, -0.01472083f, 0.00978085f, 0.04220001f, 
    0.04829891f, -0.03703182f, 0.00900259f, 0.01612497f, -0.06493963f, 0.04416152f, 0.04541923f, -0.04316511f, 
    -0.06337004f, 0.06084055f, -0.05086611f, -0.02804906f, 0.02162060f, -0.07866268f, -0.04367581f, 0.01733913f, 
    -0.01331323f, -0.03959953f, 0.04189451f, -0.05897412f, -0.04082930f, -0.08154778f, 0.03756337f, -0.00721382f, 
    -0.19477578f, -0.06228592f, 0.07280511f, -0.33051836f, -0.04675635f, -0.02297451f, -0.03342374f, 0.21528813f, 
    -0.03793081f, 0.07981289f, 0.06573810f, 0.17229708f, -0.30770239f, -0.04312115f, -0.10134470f, 0.01952191f, 
    -0.05284375f, 0.03275262f, -0.03300340f, 0.08003277f, 0.05761361f, -0.10328764f, -0.00939521f, 0.16446514f, 
    0.27687603f, -0.08435858f, -0.07283472f, -0.17217341f, 0.02100169f, 0.00387369f, 0.17163326f, 0.11198438f, 
    -0.00733226f, -0.09211376f, 0.16752642f, 0.03330515f, -0.06218859f, 0.03438647f, 0.07979102f, 0.00231003f, 
    -0.00007385f, -0.11868315f, -0.22168550f, -0.02759905f, 0.08619705f, -0.01292372f, -0.01714443f, -0.03100108f, 
    0.14317559f, 0.03766206f, 0.19985305f, -0.05583944f, -0.06488747f, 0.03291314f, 0.11507417f, -0.20776305f, 
    0.05515341f, 0.04110704f, 0.04254522f, -0.04023354f, -0.13554087f, -0.04375361f, -0.20041694f, -0.21068312f, 
    0.11617117f, 0.16838868f, 0.13361651f, -0.01021801f, 0.13894309f, 0.17202428f, -0.03528583f, 0.06518570f, 
    0.06435964f, 0.31238782f, 0.10463309f, 0.12685844f, 0.00243315f, -0.11913420f, 0.21238524f, -0.04416389f, 
    0.15504681f, -0.05632045f, 0.11021335f, 0.02676740f, 0.20283687f, -0.16891395f, -0.19876404f, 0.36962432f, 
    0.16145489f, -0.06365428f, -0.06892020f, -0.05256724f, 0.08779953f, -0.04658391f, -0.01276626f, -0.06821595f, 
    0.48948437f, -0.58106291f, 0.20164686f, 0.29311445f, 0.15480806f, 0.14550054f, 0.01034042f, 0.14722066f, 
    -0.02923404f, -0.06305435f, 0.05644565f, 0.02761325f, -0.08569657f, 0.03580931f, 0.05747204f, 0.06657752f, 
    0.07168961f, -0.06513195f, -0.18747659f, -0.01776293f, -0.18904004f, -0.01918278f, 0.08934783f, -0.09739578f, 
    -0.30613679f, 0.15386026f, 0.14324000f, -0.21000287f, -0.07460628f, 0.09902595f, -0.02477833f, 0.06567055f, 
    -0.01984844f, -0.02922914f, 0.00458661f, 0.02231063f, -0.06600311f, -0.03872056f, 0.00411409f, -0.30023769f, 
    -0.07889341f, 0.03634125f, -0.00037552f, 0.11354112f, -0.04461148f, 0.09651691f, 0.03848559f, -0.17213283f, 
    -0.02353699f, -0.03845885f, 0.07623021f, -0.10055830f, 0.02977718f, -0.03324382f, 0.05113894f, 0.03184415f, 
    0.03133749f, -0.04011467f, -0.12902428f, -0.01983471f, -0.07808536f, -0.26857612f, -0.01361672f, -0.14135750f, 
    -0.04441076f, 0.06910387f, -0.13434252f, 0.04915220f, 0.03421998f, -0.05628012f, 0.12975475f, 0.02013432f, 
    -0.18534583f, -0.29977912f, 0.23234539f, 0.17974125f, 0.07290491f, 0.16476937f, 0.00257673f, -0.01109845f, 
    0.02542876f, 0.07531705f, 0.01833747f, -0.03628353f, -0.32607624f, -0.46793497f, 0.17116256f, 0.33422354f, 
    0.00659687f, -0.16472532f, -0.04172857f, -0.06393506f, 0.13450785f, 0.06364084f, 0.12473662f, 0.12656142f, 
    -0.35565120f, 0.18798985f, -0.19937538f, 0.05116855f, 0.14480194f, 0.05648746f, -0.06062049f, 0.11762409f, 
    -0.10646627f, 0.00575395f, -0.01514965f, 0.00914713f, -0.26479244f, 0.15121399f, -0.08159836f, -0.13799599f, 
    -0.04329786f, 0.10790839f, -0.08990132f, 0.07708318f, -0.12967275f, -0.14168175f, -0.19136804f, 0.17005467f, 
    0.06254505f, 0.32842061f, -0.08083276f, 0.37768030f, -0.02218223f, 0.08870987f, 0.05622181f, 0.17843150f, 
    -0.08842991f, 0.09407268f, 0.00063469f, 0.13518809f, 0.27055135f, 0.09991750f, 0.18193734f, 0.00938081f, 
    -0.04007819f, 0.06676397f, -0.08022923f, -0.00738146f, 0.18517251f, 0.03053115f, -0.06010963f, -0.08233501f, 
    0.30070281f, -0.06780650f, 0.16364247f, 0.21491927f, 0.15477608f, -0.06835919f, 0.03297585f, -0.21555062f, 
    0.09532288f, -0.06026910f, -0.02253420f, -0.00909325f, -0.20771128f, 0.12632713f, -0.28120521f, 0.12125682f, 
    0.11350395f, 0.14593978f, 0.19688019f, 0.09598841f, 0.04501351f, 0.00818144f, 0.03901834f, 0.12094268f, 
    0.06767284f, 0.23896867f, 0.15349638f, 0.21838117f, -0.05683471f, -0.04649397f, 0.06403680f, -0.00835554f, 
    0.06070855f, -0.15235531f, -0.02518982f, -0.14794448f, 0.32605258f, -0.00838210f, 0.23775797f, 0.21095072f, 
    0.12063751f, -0.02597570f, -0.01956876f, -0.06175942f, -0.04032606f, -0.07046753f, -0.09203409f, -0.10955763f, 
    0.33626664f, -0.00406288f, 0.24947232f, 0.05549982f, -0.03345170f, 0.18441758f, -0.15062611f, 0.22202203f, 
    -0.06403233f, 0.07484444f, -0.15039319f, -0.04247676f, -0.09479894f, 0.23419926f, -0.15390724f, -0.04263777f, 
    -0.00871088f, 0.02925136f, -0.00616252f, 0.00144261f, -0.07408855f, 0.01689666f, -0.08922186f, 0.03458648f, 
    0.07490722f, 0.29005742f, 0.46288013f, 0.09864942f, 0.03361011f, 0.35095316f, -0.15767176f, 0.02989616f, 
    -0.06724330f, -0.04531002f, -0.04733920f, 0.05303060f, -0.07916975f, 0.19133921f, -0.27385601f, 0.21998154f, 
    -0.08274369f, 0.09709209f, 0.04107591f, 0.04370237f, 0.04610506f, -0.13047095f, 0.00902763f, -0.20490639f, 
    -0.01829442f, -0.02859053f, 0.12345426f, -0.06100705f, 0.10386535f, -0.00991900f, -0.04257460f, 0.03460884f, 
    -0.08715203f, -0.17424524f, -0.01850670f, 0.00205340f, -0.14766409f, -0.03836216f, -0.09608117f, 0.22570071f, 
    -0.01639403f, 0.12988992f, -0.16239591f, 0.05631089f, 0.07366479f, -0.25464672f, -0.02377320f, -0.00640054f, 
    -0.27103704f, 0.41084209f, -0.23111008f, 0.20331132f, -0.07031062f, 0.21290982f, 0.07185621f, -0.00029664f, 
    0.01953143f, -0.09257814f, -0.16202271f, -0.13417447f, -0.23474312f, 0.04205483f, -0.19279273f, 0.10090829f, 
    0.11109904f, -0.06516968f, 0.06047497f, -0.12766570f, 0.23017868f, -0.03225186f, 0.12209400f, 0.01280369f, 
    0.22320534f, 0.01990013f, 0.17303047f, -0.25165346f, -0.11926843f, -0.04849804f, -0.01732020f, 0.13807899f, 
    0.03284246f, 0.11238772f, 0.04331336f, 0.00173113f, 0.11161618f, -0.17081007f, -0.15622437f, 0.23224358f, 
    0.20492463f, -0.07497792f, -0.07698482f, 0.19789891f, 0.01040990f, 0.04996568f, -0.07115468f, 0.06082141f, 
    0.12917373f, -0.20125788f, 0.05725246f, -0.11487149f, 0.03292288f, -0.10444217f, 0.01130782f, 0.03278654f, 
    0.12755400f, 0.06926861f, 0.06534006f, -0.04553051f, -0.20194271f, -0.12650360f, -0.16329430f, -0.16802332f, 
    0.05625603f, -0.17082484f, 0.05116517f, 0.09216082f, -0.15986508f, -0.10905118f, -0.07895426f, -0.02844121f, 
    -0.36029693f, 0.07566395f, 0.10802776f, -0.01323573f, -0.03895142f, 0.04027363f, 0.06960801f, 0.11750025f, 
    -0.10463035f, 0.17813386f, 0.11282239f, 0.05947247f, 0.11285003f, -0.04692349f, 0.14261989f, -0.16031237f, 
    0.20859264f, 0.01109556f, 0.05808704f, -0.04239791f, -0.01501085f, 0.07951296f, -0.01562233f, -0.12167533f, 
    -0.16989146f, -0.26825947f, -0.20848532f, -0.08929271f, 0.07669555f, 0.22481303f, 0.14491732f, 0.03610697f, 
    -0.01784470f, -0.03263488f, 0.14662926f, 0.03967883f, 0.02974673f, 0.09962413f, -0.07726157f, 0.05772604f, 
    -0.15770426f, -0.03844317f, -0.07096333f, -0.01007646f, -0.04722159f, -0.08835353f, -0.08170077f, -0.06549960f, 
    -0.34899983f, -0.22365555f, -0.28144708f, 0.06582442f, -0.05822051f, 0.10238824f, 0.17281219f, -0.02531835f, 
    0.01412102f, -0.15476084f, -0.09745231f, -0.12297023f, 0.13725306f, -0.14817797f, 0.19214091f, 0.09972268f, 
    0.03599463f, -0.08013284f, -0.13137652f, -0.03327646f, -0.00082256f, -0.01092191f, 0.04890693f, -0.07780217f, 
    -0.11481796f, -0.04408333f, -0.07763837f, -0.09493919f, 0.21074799f, -0.23383760f, 0.20502608f, 0.23150438f, 
    -0.12795746f, -0.02346542f, -0.05718845f, 0.07458824f, 0.11850812f, -0.07458921f, 0.17852071f, -0.07557256f, 
    0.03601793f, -0.02081591f, 0.20097865f, 0.20619828f, 0.03835738f, 0.19300340f, 0.30541879f, 0.28889009f, 
    0.25122702f, -0.04784385f, -0.15271723f, -0.00567527f, -0.11326940f, -0.03268185f, -0.05590848f, -0.11358579f, 
    -0.00477487f, 0.07610688f, -0.11605217f, -0.12273280f, 0.24228989f, 0.18823746f, 0.05801324f, -0.11931687f, 
    -0.06940173f, 0.02068510f, -0.01945960f, -0.16145311f, 0.11915723f, 0.36697659f, 0.31588790f, -0.01357019f, 
    0.05184736f, -0.36354649f, 0.27113959f, 0.08584841f, 0.16655394f, 0.10730266f, -0.17170936f, 0.09356125f, 
    0.06347147f, -0.01347480f, 0.08264105f, -0.10845124f, 0.11188304f, -0.10617980f, 0.41131532f, -0.04750185f, 
    -0.04019098f, -0.05269376f, -0.19715951f, 0.08638100f, 0.06814943f, 0.12175759f, -0.07363697f, 0.01491553f, 
    -0.07808134f, 0.00697441f, 0.00698608f, -0.06072515f, -0.01409739f, -0.03537901f, -0.05302531f, 0.00756529f, 
    -0.01438875f, -0.01482882f, -0.00589954f, -0.04821004f, -0.05279959f, 0.06289998f, -0.02324219f, -0.04273808f, 
    0.01835192f, -0.01383717f, 0.04986416f, 0.02178137f, 0.03331063f, 0.03463350f, -0.07295616f, -0.07867201f, 
    0.06144090f, 0.06421895f, -0.00120846f, 0.01851421f, -0.06742883f, -0.06002612f, -0.02856229f, -0.04973556f, 
    0.01389339f, 0.03734942f, -0.04600986f, 0.02899785f, -0.05632254f, -0.04457513f, 0.03663239f, -0.02278469f, 
    -0.00245730f, -0.03084000f, -0.03792903f, 0.02724050f, 0.03664712f, -0.07062951f, -0.07069817f, 0.05865779f, 
    -0.02726504f, -0.04249661f, 0.06040437f, -0.05484046f, -0.04594676f, 0.00780352f, -0.01315901f, -0.05600720f, 
    -0.02545722f, 0.03152012f, 0.01594972f, -0.06200263f, 0.05106709f, -0.01639166f, -0.00398150f, -0.02702981f, 
    0.02626649f, 0.04721915f, 0.00554345f, -0.07990845f, -0.00340788f, 0.05399201f, 0.00317691f, -0.01753360f, 
    -0.02414762f, -0.05234881f, 0.05490807f, 0.04915885f, -0.05186724f, 0.04798483f, -0.01150768f, 0.02810941f, 
    -0.05838919f, 0.02650673f, 0.02695847f, -0.07448303f, 0.06868056f, -0.05652742f, -0.00516795f, 0.05577627f, 
    0.01981960f, -0.05204020f, -0.05150552f, -0.00786372f, -0.06919812f, -0.07546090f, -0.07768656f, 0.03511721f, 
    -0.05182486f, -0.02510035f, -0.04229626f, -0.07302722f, 0.01104767f, -0.00731720f, -0.06953295f, -0.02563847f, 
    -0.06195017f, 0.00901983f, 0.05470585f, -0.07182936f, -0.06297681f, 0.01065736f, -0.04165788f, -0.02105834f, 
    0.04949388f, 0.04434479f, -0.06450142f, -0.06476240f, -0.01497835f, -0.06212880f, -0.01621028f, 0.01996541f, 
    0.00132107f, -0.02443718f, 0.03790968f, -0.07347469f, -0.05088432f, 0.01924948f, -0.05976528f, -0.07221919f, 
    0.00242681f, 0.03486460f, -0.05757008f, -0.01463513f, 0.02165113f, 0.04444828f, -0.04869851f, -0.02836911f, 
    -0.07220036f, 0.01007836f, -0.06030281f, 0.01331676f, 0.05801532f, -0.07362330f, -0.03079785f, -0.02122440f, 
    -0.01576089f, -0.05333816f, -0.00906771f, -0.04485963f, 0.02964946f, -0.05094261f, 0.05412084f, -0.03619628f, 
    -0.04459447f, -0.01843192f, 0.04381417f, -0.06635246f, -0.03631116f, 0.07160653f, 0.02082130f, -0.01100049f, 
    0.03566070f, -0.05302304f, 0.00460955f, 0.05797705f, 0.00819949f, -0.02494379f, -0.00025076f, -0.00127931f, 
    0.01609193f, -0.01930423f, 0.01722053f, 0.01097487f, -0.00423396f, 0.02680400f, 0.04322182f, 0.01454557f, 
    0.01730401f, -0.00853509f, -0.05464732f, 0.02591299f, 0.06679484f, -0.03662811f, -0.00645135f, 0.04170695f, 
    0.02757910f, 0.04906127f, -0.04692988f, -0.04588804f, -0.07497332f, 0.00990307f, -0.01106777f, -0.07465468f, 
    -0.40016758f, -0.32672822f, 0.23315433f, -0.01962995f, 0.01904376f, -0.07164989f, -0.11730300f, 0.00284386f, 
    -0.02109004f, 0.11230218f, 0.00001191f, 0.06918768f, -0.15364447f, 0.04994446f, -0.31045294f, -0.13681690f, 
    -0.01691475f, -0.06092537f, -0.19507128f, 0.11267985f, 0.04609571f, -0.00581944f, -0.09045440f, 0.20298345f, 
    -0.25579774f, 0.02226894f, 0.32085767f, -0.05824055f, -0.06698944f, -0.20360476f, -0.03822584f, -0.06664959f, 
    0.20513541f, -0.05560236f, -0.08022211f, 0.10215534f, 0.09862555f, 0.08229975f, -0.05604431f, 0.10840525f, 
    0.12899455f, 0.06945949f, 0.01452765f, -0.11815783f, 0.06351712f, -0.00250881f, 0.04977530f, -0.04729939f, 
    0.25779295f, 0.04150464f, 0.01655261f, -0.02530787f, 0.08187652f, 0.05215913f, 0.11107647f, -0.04769639f, 
    0.05456106f, 0.01299427f, 0.14967190f, 0.11145341f, -0.13944916f, -0.06365071f, 0.05960108f, -0.40629661f, 
    0.13251489f, -0.12370121f, 0.08603334f, -0.02786206f, 0.13719773f, -0.02348191f, -0.04731717f, 0.11697652f, 
    0.02420042f, 0.05170145f, 0.05303619f, 0.20350714f, 0.08006649f, 0.02564228f, 0.21699190f, 0.10640862f, 
    0.09245156f, -0.04257676f, 0.03601874f, 0.06100066f, -0.03795660f, 0.20740646f, 0.16868223f, 0.13999097f, 
    0.01010081f, -0.07464581f, 0.06301006f, -0.02218045f, -0.06178563f, -0.13977972f, -0.07418434f, 0.12123328f, 
    0.15834194f, -0.35789719f, 0.41814101f, 0.13650167f, -0.11141376f, 0.04409085f, -0.03114486f, -0.11177438f, 
    0.03068257f, 0.11354414f, -0.10367677f, 0.09357724f, 0.38123196f, 0.14095147f, -0.04748713f, 0.08209992f, 
    0.09589079f, -0.11550256f, 0.14830680f, -0.01686001f, -0.06639059f, 0.12609424f, -0.16911902f, -0.19803523f, 
    -0.08287740f, 0.33998346f, -0.15743965f, 0.01702757f, 0.15324071f, -0.05895619f, 0.13643353f, 0.04505071f, 
    -0.09317466f, -0.09663048f, 0.12267543f, 0.16417439f, -0.07678859f, 0.01819968f, 0.05857399f, 0.03165464f, 
    0.08122672f, 0.02160471f, 0.03767481f, 0.06740466f, 0.00801405f, -0.02189361f, -0.03810537f, -0.29371554f, 
    -0.21151973f, -0.19623333f, 0.01885414f, -0.03872701f, 0.09088170f, -0.12641843f, -0.23767801f, -0.00501347f, 
    0.21341093f, -0.09744942f, -0.04778190f, 0.04763005f, -0.08192636f, 0.00873176f, 0.12088995f, -0.05129649f, 
    -0.01415711f, -0.10698926f, 0.08911050f, -0.04853425f, 0.18702880f, -0.05656755f, 0.08776088f, -0.02244572f, 
    0.12058347f, 0.43079299f, 0.00897486f, 0.08458359f, -0.03799365f, -0.16141735f, 0.05668505f, 0.27720609f, 
    -0.08514655f, 0.07809027f, -0.04784984f, -0.22737765f, 0.26524156f, -0.07380394f, 0.11484943f, -0.30679813f, 
    -0.10598078f, -0.08300244f, -0.02929490f, 0.02240063f, 0.11187626f, -0.02854311f, 0.14722325f, 0.01061394f, 
    0.41130590f, 0.13909929f, 0.04943774f, -0.06358910f, 0.10737670f, 0.09321400f, -0.19476867f, 0.00734208f, 
    0.00355066f, 0.05712005f, -0.01441501f, 0.00873455f, 0.08828108f, 0.17536837f, 0.18406019f, 0.30943552f, 
    0.18943845f, 0.09694602f, 0.04808823f, 0.06295950f, -0.00065789f, 0.05307785f, 0.10210032f, -0.10023905f, 
    0.04940414f, 0.28121281f, -0.06063930f, -0.04254054f, 0.09686209f, -0.04039548f, 0.05740188f, 0.13076529f, 
    0.01150458f, -0.09402134f, 0.01633910f, -0.10169736f, 0.01892678f, 0.05497476f, 0.08958210f, 0.02337275f, 
    -0.03221237f, 0.09160997f, 0.16490178f, 0.07634056f, -0.04589130f, -0.04860071f, -0.02935009f, 0.10509047f, 
    -0.13009331f, 0.14102386f, -0.20224743f, -0.11440916f, 0.02396431f, 0.02299609f, 0.01676298f, 0.11905064f, 
    -0.00323329f, 0.01150608f, -0.01508299f, 0.08118024f, 0.01132470f, -0.12918094f, 0.07625757f, -0.01018246f, 
    -0.02807168f, -0.06083869f, -0.14025939f, -0.10344820f, 0.03255039f, -0.07590029f, -0.06701064f, -0.02179292f, 
    0.19550344f, 0.05901315f, -0.04090360f, -0.23824039f, 0.01761224f, 0.11951517f, 0.04643124f, -0.07945406f, 
    0.01822171f, 0.07421464f, 0.12852782f, 0.04191166f, -0.18387091f, -0.13146180f, -0.14343543f, -0.02895857f, 
    -0.14080715f, -0.05697671f, 0.02859527f, 0.09109111f, -0.03886249f, -0.00830012f, -0.05798344f, -0.00866647f, 
    -0.59109730f, 0.20865855f, -0.06799179f, -0.14885278f, 0.06023624f, -0.02575053f, 0.17213131f, 0.11315509f, 
    0.00008936f, -0.01405553f, -0.08856962f, 0.00718407f, -0.17411731f, -0.14625345f, 0.17727472f, 0.14029631f, 
    0.00757211f, 0.09700054f, -0.06064769f, 0.11500440f, 0.06000833f, 0.08615946f, 0.05484344f, -0.10390191f, 
    -0.04379108f, -0.23468679f, -0.25491622f, -0.18539080f, 0.02085099f, -0.06559652f, 0.02542482f, 0.13740653f, 
    -0.00572748f, 0.12023495f, 0.07565376f, 0.06609570f, 0.28304610f, -0.20659471f, -0.06608790f, -0.14614575f, 
    0.07780765f, 0.11606507f, -0.03177556f, 0.03341850f, -0.04074131f, 0.04011849f, 0.08280572f, 0.06850607f, 
    0.09086096f, -0.08020680f, -0.17784736f, -0.00869347f, -0.02125852f, 0.02004875f, 0.09803180f, 0.05440821f, 
    -0.04794345f, -0.01456601f, -0.11032508f, -0.07531492f, 0.33929393f, 0.17692214f, 0.01732671f, -0.00877993f, 
    -0.06717572f, 0.05458183f, -0.07161914f, 0.03639272f, -0.13145177f, 0.07309430f, -0.00655031f, -0.05157924f, 
    0.11084369f, -0.18166369f, 0.15337615f, 0.01705762f, -0.01255089f, -0.06359143f, 0.04287573f, -0.01374404f, 
    -0.00379503f, -0.01812511f, 0.06186555f, -0.03102536f, -0.34631756f, 0.18617742f, 0.48350397f, 0.15950394f, 
    -0.16416575f, -0.05352860f, -0.01180734f, 0.02022927f, 0.01028506f, -0.04383954f, -0.00985140f, 0.07714128f, 
    -0.01617894f, -0.02764608f, -0.02321264f, -0.04622733f, 0.01635274f, -0.06307659f, 0.00431446f, 0.04916122f, 
    -0.00584900f, -0.03853324f, 0.03725299f, -0.05082299f, 0.02667253f, -0.06442584f, -0.05534223f, -0.04605571f, 
    -0.06136622f, -0.07551181f, -0.01019932f, 0.06366564f, -0.05601345f, -0.01261330f, -0.06436101f, -0.00121612f, 
    0.00886053f, -0.07869969f, -0.07267660f, -0.04661903f, -0.01076157f, 0.04376132f, -0.06460236f, 0.05526994f, 
    -0.06947765f, -0.06796671f, -0.05405179f, -0.04886463f, 0.01477964f, -0.05803686f, 0.02484354f, -0.03948265f, 
    0.03412662f, 0.03093587f, 0.06110593f, -0.02772894f, -0.02389201f, -0.03248166f, 0.03734612f, -0.03246866f, 
    0.04865627f, -0.07690593f, -0.07625253f, 0.05145397f, -0.01020852f, -0.06052350f, -0.02129786f, -0.02394054f, 
    0.01040529f, 0.00043516f, 0.03982359f, 0.03362904f, -0.02108747f, 0.00390769f, 0.02045035f, -0.04546789f, 
    -0.00124801f, 0.05529849f, 0.02910469f, 0.00345460f, 0.00887791f, 0.00464911f, -0.04918729f, 0.00128940f, 
    0.06598432f, -0.07218559f, -0.05050295f, 0.04865055f, 0.00512113f, -0.06586109f, -0.04279186f, 0.03160065f, 
    0.01902704f, 0.06129168f, 0.06126350f, 0.03584415f, -0.07594878f, 0.04393204f, 0.00076687f, -0.05002210f, 
    -0.04255124f, -0.04326867f, -0.03563628f, -0.05776517f, 0.04612410f, -0.03464779f, 0.03970727f, 0.03243042f, 
    0.01950620f, -0.00446041f, -0.07076903f, 0.01325185f, -0.07365915f, 0.02609150f, -0.01669116f, -0.05521334f, 
    0.02044214f, -0.02149586f, 0.02299925f, 0.02346393f, -0.07570951f, -0.06614161f, 0.04316816f, 0.04409104f, 
    -0.03550355f, 0.02126870f, -0.01433171f, 0.03247282f, -0.03687310f, 0.01887530f, -0.04858961f, 0.01673415f, 
    0.00168396f, -0.01605799f, 0.02976856f, -0.02937341f, 0.04360751f, -0.07749421f, 0.00207521f, 0.03422071f, 
    -0.06654616f, 0.02765881f, 0.01602165f, 0.00687766f, -0.01920360f, -0.00541353f, -0.02763627f, 0.00876972f, 
    -0.00730482f, -0.05449060f, 0.01614731f, -0.05482228f, -0.02006670f, -0.04900949f, 0.00385087f, -0.03798960f, 
    0.00348070f, 0.00137300f, 0.06309030f, 0.04720745f, -0.05449933f, -0.00872588f, -0.07659326f, 0.05351351f, 
    -0.05449617f, -0.02744368f, -0.07295258f, 0.00428583f, -0.06617163f, 0.03311081f, 0.04934110f, -0.03742939f, 
    -0.00560722f, 0.05298595f, 0.05721632f, -0.07518870f, -0.00016597f, 0.05612339f, 0.06020263f, -0.06284518f, 
    -0.07232506f, 0.05376419f, 0.06019748f, -0.01385454f, 0.02142429f, -0.06877208f, 0.03370848f, -0.00073795f, 
    0.04126049f, 0.04889486f, -0.02882868f, -0.02600380f, 0.01551323f, 0.03799362f, 0.00466207f, -0.00526341f, 
    -0.04338151f, 0.04267051f, -0.03410542f, -0.03490613f, 0.01178959f, -0.01208453f, -0.00861193f, -0.00384633f, 
    0.11518878f, -0.31427437f, -0.23390347f, 0.08038461f, 0.12385551f, 0.19185726f, 0.17293353f, -0.15400025f, 
    0.03794589f, -0.11974625f, -0.05544429f, -0.17927657f, 0.25462189f, 0.18083338f, 0.06464563f, -0.24212031f, 
    0.11898515f, -0.00076752f, 0.13517404f, -0.02218748f, -0.00618902f, -0.02670852f, 0.02054990f, 0.03964419f, 
    -0.34326047f, 0.04300512f, -0.06120653f, 0.15552773f, -0.08990782f, -0.00056578f, -0.07745489f, -0.12424014f, 
    -0.08188878f, -0.00487560f, -0.12797253f, 0.02185131f, 0.20512612f, 0.15749618f, 0.07778497f, 0.43362957f, 
    0.05226810f, 0.04883525f, 0.12388502f, -0.20797923f, -0.04616214f, 0.07455516f, -0.00898531f, 0.07237873f, 
    0.12426943f, 0.03993912f, -0.12213754f, 0.10554801f, 0.03707691f, 0.07992405f, 0.15029344f, 0.14526215f, 
    0.11869679f, -0.04861758f, -0.01120374f, 0.08311529f, 0.06688015f, 0.10630775f, -0.00389320f, -0.01140184f, 
    -0.10519022f, -0.10195310f, 0.02327907f, -0.13808106f, -0.13145033f, -0.12175515f, -0.01408948f, 0.01581688f, 
    0.04951930f, -0.09955605f, 0.17066212f, 0.07722889f, 0.08955100f, -0.00742503f, 0.01602496f, 0.08877459f, 
    -0.06422633f, 0.03465103f, -0.03979374f, 0.05896885f, 0.21783067f, 0.23892109f, 0.38752583f, 0.10506312f, 
    0.04378750f, -0.05879633f, -0.13586617f, 0.01027357f, -0.05348821f, 0.02244789f, 0.10623345f, -0.04128743f, 
    0.19297872f, 0.11653393f, 0.31688899f, -0.24247584f, 0.04258426f, -0.05417341f, -0.12427410f, -0.15911421f, 
    0.00006513f, 0.02864983f, -0.05610450f, -0.05822046f, 0.10599582f, 0.18898347f, -0.01320410f, -0.03707612f, 
    -0.10722243f, -0.07941407f, 0.10534659f, 0.04580774f, 0.05063361f, -0.03613061f, -0.08402422f, 0.10744324f, 
    0.48792022f, 0.24144745f, 0.03646979f, 0.29454863f, 0.09096680f, -0.06415807f, 0.04567894f, -0.11281557f, 
    0.05292446f, -0.05129009f, -0.06291284f, -0.07131439f, -0.13548414f, 0.08225221f, -0.03376915f, 0.07929339f, 
    -0.15472429f, -0.00179745f, -0.04840725f, -0.00773914f, -0.05339185f, -0.09584625f, 0.04647056f, 0.01648393f, 
    -0.05840357f, -0.04153945f, 0.09773481f, -0.04805279f, -0.04713902f, 0.01437976f, -0.16222681f, -0.03229053f, 
    0.03058895f, 0.04697336f, 0.08665827f, 0.10290056f, -0.09121656f, 0.00953140f, -0.10847240f, 0.03094336f, 
    0.03368687f, -0.04566184f, -0.04510975f, -0.11003421f, 0.19279538f, -0.04306210f, -0.22367421f, -0.04187439f, 
    0.15897985f, 0.44330764f, 0.00859788f, -0.04178425f, -0.06950932f, -0.07586125f, 0.03251902f, 0.01346717f, 
    -0.06124735f, -0.04375563f, -0.06624397f, -0.00818174f, 0.33281884f, 0.14953242f, -0.33025956f, -0.41803765f, 
    -0.12439448f, 0.08133260f, 0.05922621f, -0.07417896f, -0.07561357f, -0.03658269f, -0.05103706f, -0.08657621f, 
    0.05530499f, -0.05677553f, 0.02946394f, -0.01865837f, 0.02205151f, 0.06257846f, -0.07056611f, -0.00440219f, 
    0.04083695f, -0.02657248f, -0.02276998f, 0.00147844f, 0.04338805f, 0.01509908f, 0.03457478f, 0.04487053f, 
    0.03647551f, 0.03498722f, 0.03827416f, -0.01924642f, -0.05188330f, -0.07769089f, 0.00671620f, 0.00336394f, 
    -0.04194773f, 0.04478396f, -0.00353572f, -0.02481358f, -0.03217109f, -0.05708565f, -0.04059935f, -0.09277043f, 
    0.02662257f, 0.01737539f, -0.07192431f, -0.08426530f, -0.04785234f, 0.00456981f, 0.05315197f, -0.05862383f, 
    -0.00254468f, -0.04758713f, -0.01314066f, 0.04972941f, -0.08289402f, 0.00106165f, 0.01176473f, 0.06090467f, 
    0.05089663f, -0.01662314f, 0.05272099f, -0.07338452f, 0.02082197f, -0.03873486f, 0.03217544f, 0.05612936f, 
    -0.08467926f, 0.01714078f, -0.02354928f, -0.06920151f, 0.05132940f, -0.05269022f, 0.02753717f, -0.01746590f, 
    -0.04276578f, 0.02359740f, -0.02452799f, -0.06378912f, -0.01083154f, -0.05241591f, -0.00851551f, 0.02087529f, 
    0.00507772f, -0.02008251f, 0.01107352f, 0.03362121f, 0.02170233f, -0.06076526f, 0.02476893f, -0.05119532f, 
    -0.02439153f, -0.06641152f, 0.02130706f, -0.04242607f, -0.06770804f, 0.01819277f, -0.02200750f, -0.01272537f, 
    -0.00450521f, -0.09114152f, -0.07141894f, 0.01463140f, 0.01031793f, -0.00231740f, -0.04331331f, -0.05906049f, 
    -0.05723894f, -0.08274089f, -0.03790870f, -0.06253655f, 0.00613753f, -0.03881828f, -0.01311511f, -0.04283198f, 
    -0.09671434f, 0.02804215f, 0.00595626f, 0.03149521f, -0.06463922f, -0.08276697f, -0.05403278f, -0.05402476f, 
    -0.08411846f, 0.04552345f, -0.08364588f, 0.02564036f, -0.02679154f, -0.02403404f, 0.02273288f, -0.05714977f, 
    -0.02152700f, 0.05530727f, 0.01007969f, -0.01701136f, -0.04774296f, -0.05987440f, -0.00561482f, 0.01288260f, 
    0.01810875f, 0.03404953f, -0.07971609f, 0.00441029f, -0.00978395f, -0.01704080f, -0.02072232f, -0.00607716f, 
    0.05806982f, -0.00303041f, 0.02590948f, -0.02026787f, -0.01821418f, -0.01456302f, -0.00000057f, 0.02492884f, 
    -0.00464675f, -0.00903045f, -0.05744372f, -0.01258920f, 0.02470962f, 0.02025408f, 0.02486793f, -0.03107400f, 
    -0.08821765f, 0.04083415f, -0.04752422f, -0.02612387f, -0.08009248f, -0.00955055f, -0.05538687f, -0.07472752f, 
    0.02388880f, 0.04670529f, 0.03989846f, 0.02495243f, 0.03818658f, -0.05251930f, -0.03263614f, -0.03095914f, 
    0.04405507f, -0.05274389f, -0.07264151f, -0.04136645f, -0.00598350f, 0.03261409f, -0.07942687f, 0.02976352f, 
    -0.05493779f, -0.06764358f, 0.05014234f, -0.03296101f, -0.07746255f, 0.04373470f, 0.00203600f, 0.03716645f, 
    -0.04364846f, -0.06718592f, 0.03987697f, 0.05561125f, 0.00088093f, 0.02891063f, -0.07008860f, -0.07312072f, 
    0.05830189f, -0.10051693f, 0.24806423f, 0.00157628f, 0.02545855f, -0.02136644f, -0.14410660f, 0.04846434f, 
    0.06345934f, -0.00040865f, 0.04261016f, 0.05571807f, -0.11384168f, 0.24524128f, -0.30861735f, 0.18512355f, 
    0.04181755f, 0.10489788f, -0.09863492f, 0.06563982f, 0.02015023f, -0.10463345f, -0.06418888f, 0.10353071f, 
    -0.28365579f, 0.19569989f, 0.23254260f, -0.08217515f, -0.03628557f, -0.10586436f, -0.03098262f, 0.00187584f, 
    0.15053578f, 0.00927402f, -0.16653402f, 0.12518384f, 0.12053658f, -0.07567477f, -0.01949526f, 0.01187249f, 
    -0.00932168f, 0.23917960f, 0.15216325f, 0.09336720f, 0.15448537f, 0.04964525f, 0.13040438f, 0.13496771f, 
    0.08360812f, 0.07207779f, -0.20054066f, -0.16863406f, 0.09255190f, 0.02407128f, 0.10317165f, 0.06098810f, 
    -0.07732194f, 0.03820411f, 0.03365563f, 0.05587349f, -0.08117642f, -0.16392846f, 0.02772859f, -0.33257532f, 
    -0.07549358f, 0.13284276f, 0.03221600f, 0.01144560f, 0.15814757f, 0.22169495f, 0.00730250f, 0.14662424f, 
    -0.02746249f, -0.19463874f, -0.10426121f, -0.06218670f, 0.03706848f, 0.07622541f, 0.18505348f, 0.13386698f, 
    0.10530344f, 0.09491380f, -0.01406453f, 0.03857842f, 0.09568883f, 0.05073094f, -0.00015982f, 0.01248642f, 
    0.08933893f, -0.05072002f, 0.00409345f, -0.08973150f, -0.03203675f, -0.03451731f, -0.03442399f, 0.13058911f, 
    0.09535290f, 0.04773066f, -0.20644505f, 0.00266287f, 0.06522936f, -0.06905655f, 0.12041715f, 0.09112658f, 
    -0.03804406f, 0.10045245f, -0.00956474f, -0.05139462f, -0.02651301f, -0.03410952f, -0.06026394f, 0.11407644f, 
    0.09467915f, 0.07971042f, 0.03452935f, -0.03510473f, -0.07481970f, 0.03893899f, 0.01694432f, 0.08007142f, 
    0.15714383f, -0.09032746f, -0.20419808f, 0.16374737f, 0.07223532f, -0.09993576f, -0.01549791f, 0.00695052f, 
    0.09989680f, -0.03409450f, -0.01885628f, 0.04932830f, -0.12030733f, -0.15697391f, 0.01369905f, -0.10811330f, 
    0.03817692f, 0.04833386f, -0.06570908f, -0.08140934f, 0.07517172f, -0.01321912f, -0.11834302f, -0.10388274f, 
    -0.28332663f, -0.23838957f, -0.19236982f, 0.15589772f, -0.07582115f, -0.07559928f, -0.13033089f, -0.10434320f, 
    0.01491169f, -0.05663490f, -0.10679369f, -0.01812744f, 0.13082233f, 0.15951519f, 0.14688063f, -0.10688419f, 
    -0.02142570f, -0.11997461f, -0.04692795f, -0.08685709f, 0.16003381f, -0.02446334f, -0.03233883f, -0.10454140f, 
    0.06604900f, 0.32432824f, -0.05454271f, 0.20310281f, -0.01556152f, 0.06319766f, -0.06723140f, 0.01921276f, 
    -0.08005239f, -0.10559817f, -0.04954010f, -0.16251419f, -0.12178639f, 0.11177213f, 0.27552822f, 0.19083278f, 
    0.01308383f, -0.17479858f, -0.06909457f, -0.14454150f, -0.01781315f, -0.06874730f, 0.01984599f, 0.24190958f, 
    -0.11487165f, 0.42806298f, 0.41539121f, 0.09969933f, -0.12269121f, 0.07600076f, 0.11369544f, -0.02086700f, 
    -0.02759063f, 0.08901568f, -0.07525002f, 0.21955633f, 0.02480720f, -0.14996938f, -0.13286598f, -0.15302508f, 
    0.00480060f, 0.13569227f, -0.01375016f, 0.10228711f, -0.01931043f, 0.08662616f, 0.07324095f, 0.16842072f, 
    -0.08411365f, 0.05675315f, -0.06271878f, 0.09689801f, -0.09434886f, 0.13734548f, 0.13566177f, -0.21036258f, 
    -0.04026127f, 0.13946135f, 0.15228611f, 0.30871928f, -0.09652107f, 0.15490404f, 0.04957206f, 0.03294278f, 
    0.08204196f, -0.18477519f, -0.11583943f, 0.00809429f, -0.18279991f, -0.22367892f, -0.20843747f, -0.49711633f, 
    0.19503011f, 0.11436354f, 0.10364386f, 0.01485072f, -0.11366905f, -0.01474074f, -0.02969900f, -0.07408300f, 
    0.31924289f, 0.19085170f, 0.02434695f, 0.04411028f, -0.20800181f, 0.14524421f, -0.25845647f, 0.06154818f, 
    -0.01654053f, -0.30968770f, -0.12594011f, 0.00801214f, 0.02269043f, -0.23364072f, -0.14839013f, -0.28583184f, 
    0.07519773f, -0.02796129f, -0.04177241f, 0.17796233f, 0.04237973f, -0.02385343f, 0.04702396f, 0.02206111f, 
    0.10986447f, -0.09352786f, -0.10979795f, -0.03564670f, 0.16168237f, -0.06918525f, 0.03377637f, 0.24289463f, 
    0.12499371f, 0.16893892f, -0.17867552f, -0.13848183f, -0.21282391f, -0.29344776f, 0.04980881f, -0.26286298f, 
    0.42068720f, -0.15919328f, 0.12814277f, 0.11891051f, -0.00889982f, 0.10114470f, -0.12342299f, 0.10994754f, 
    0.02689567f, -0.06233416f, -0.08907373f, 0.04777465f, -0.05107228f, 0.06754626f, -0.04744046f, 0.02765553f, 
    -0.05502173f, -0.00683785f, -0.17890361f, -0.15539229f, -0.29261637f, -0.37159982f, -0.28932086f, -0.23964348f, 
    -0.14351174f, -0.00564136f, 0.25309688f, 0.07516769f, 0.20848545f, 0.06926937f, 0.00580959f, 0.33178699f, 
    0.02796282f, -0.10792105f, 0.14301009f, -0.06559420f, -0.07976085f, 0.15378568f, -0.06274928f, 0.08131012f, 
    -0.02102162f, 0.00290596f, 0.16018672f, 0.10372669f, 0.21003518f, 0.54672742f, 0.25488085f, 0.32258227f, 
    -0.00085047f, 0.02654179f, 0.18910152f, -0.10459384f, 0.25441101f, -0.01517561f, -0.16920014f, -0.06917481f, 
    -0.14782365f, -0.27467340f, 0.07050709f, 0.03029061f, -0.28643164f, -0.18121253f, -0.08361106f, 0.05202075f, 
    -0.05985985f, 0.00646866f, -0.05489118f, 0.00841226f, 0.06569068f, 0.02635667f, 0.24284783f, 0.29243228f, 
    0.07814883f, 0.05757308f, 0.17019615f, 0.21971290f, 0.15753633f, 0.13991602f, 0.16132203f, 0.09651553f, 
    -0.08110920f, -0.01561258f, -0.05609285f, 0.06781827f, 0.06258579f, 0.04476532f, 0.18036319f, 0.18591268f, 
    -0.09345518f, -0.05919867f, -0.17219931f, -0.15245558f, 0.07253100f, 0.01240608f, 0.11997560f, -0.20927610f, 
    -0.03291355f, 0.06057855f, 0.00082439f, 0.00645890f, -0.02956327f, -0.02344180f, -0.01010389f, -0.07735444f, 
    -0.02735377f, -0.05955799f, -0.06267797f, 0.04742669f, 0.01587062f, 0.02486614f, -0.02626780f, -0.04160539f, 
    -0.06051952f, 0.02597164f, 0.02333730f, 0.04693404f, -0.04469967f, -0.03978947f, -0.01963808f, -0.06970458f, 
    -0.05358790f, -0.05310256f, -0.04390121f, -0.02544100f, -0.05065300f, -0.03842875f, -0.01111015f, 0.02448220f, 
    -0.00330142f, -0.05785569f, -0.02641623f, -0.03594566f, -0.06623854f, 0.05653479f, 0.00394277f, -0.05248034f, 
    0.05669139f, -0.05797403f, 0.05525596f, -0.04172758f, 0.01111097f, 0.03581865f, -0.02774338f, -0.03430980f, 
    0.01652485f, -0.04242204f, 0.05480738f, -0.05151237f, 0.03566400f, -0.06791879f, 0.05794187f, -0.05514559f, 
    0.02776639f, 0.03218510f, 0.05297948f, -0.02665657f, -0.01322260f, -0.00583616f, 0.05776925f, -0.00429865f, 
    -0.05500724f, 0.00629321f, 0.03155168f, -0.06516864f, 0.02809783f, 0.01290203f, -0.02834897f, 0.05536114f, 
    0.01369531f, -0.07445060f, -0.00719936f, 0.04462333f, 0.02079481f, 0.05237812f, -0.06852026f, 0.05665058f, 
    0.03734882f, 0.03384023f, -0.00287330f, 0.03634318f, -0.07026328f, 0.06276125f, -0.00486779f, 0.05120922f, 
    0.04123688f, 0.06552830f, 0.03376570f, 0.02386338f, 0.03500044f, -0.04164815f, 0.04496772f, 0.06369967f, 
    -0.07092140f, -0.00644757f, -0.05208700f, -0.05361681f, 0.06267338f, -0.02735473f, 0.03651835f, -0.01252387f, 
    -0.07014992f, 0.05354854f, -0.07250006f, -0.07171641f, 0.01388199f, -0.00694830f, -0.04666200f, 0.00118661f, 
    -0.05522824f, -0.00455216f, -0.06231039f, 0.02171053f, 0.00917304f, -0.02393608f, -0.04745973f, -0.07772229f, 
    0.03219313f, -0.07739026f, -0.02798936f, -0.02302868f, 0.04344727f, -0.01189825f, 0.04762316f, -0.05192031f, 
    0.00931294f, -0.02180680f, 0.03277040f, 0.00092719f, -0.02405704f, -0.04359823f, 0.01432545f, 0.03957394f, 
    0.04824343f, 0.01017406f, 0.06049102f, -0.04232363f, -0.04377464f, -0.05478223f, 0.02666220f, -0.03783799f, 
    -0.03646461f, 0.01180885f, 0.05287646f, -0.07571366f, 0.04458407f, -0.06833385f, 0.05273861f, -0.01331713f, 
    0.00857939f, 0.04686826f, 0.02123317f, -0.03185524f, -0.06630414f, -0.05111550f, 0.05946549f, -0.03368049f, 
    -0.05364155f, 0.03229757f, -0.04990887f, -0.05528804f, 0.03909040f, -0.05908271f, -0.02190677f, -0.03960449f, 
    -0.06395608f, 0.05840968f, 0.01026753f, -0.03747148f, -0.07479569f, 0.03160990f, -0.00912391f, 0.01394576f, 
    -0.02803790f, 0.00284415f, -0.07200051f, -0.06997912f, 0.03417119f, 0.03662364f, -0.07254349f, 0.06438589f, 
    -0.01352288f, -0.07354902f, -0.04097872f, -0.07223565f, -0.05526311f, -0.03954270f, 0.04356566f, -0.05291975f, 
    -0.07671227f, 0.04659519f, -0.05840495f, 0.00662207f, 0.02677246f, 0.01083913f, -0.02840303f, -0.02835673f, 
    0.04698048f, -0.05214418f, -0.04164312f, -0.08057690f, 0.00888038f, 0.04197042f, 0.04120025f, -0.02538402f, 
    0.04677561f, -0.06978926f, -0.06555861f, 0.00127215f, -0.06105265f, -0.07424670f, 0.05777397f, 0.01358297f, 
    -0.07629062f, 0.00566978f, -0.07484316f, 0.03953347f, 0.05648027f, -0.07816377f, -0.07638486f, -0.06554766f, 
    -0.02113518f, -0.07079136f, 0.00335888f, -0.02483247f, -0.04401303f, 0.02753626f, -0.02774504f, 0.02368094f, 
    0.02811951f, -0.08330454f, -0.00159662f, 0.00207337f, -0.03360268f, -0.06051112f, -0.01103018f, 0.01448698f, 
    0.01872991f, -0.07260600f, -0.08219413f, -0.06462120f, -0.01094767f, -0.04702011f, 0.03561967f, 0.05423917f, 
    -0.02237731f, 0.04711916f, -0.05932001f, -0.04422082f, 0.00389377f, -0.06159494f, 0.01093153f, 0.04117192f, 
    0.02997217f, -0.04485504f, -0.08477930f, -0.05265748f, -0.00407681f, 0.03332848f, -0.07830384f, 0.01940378f, 
    -0.02326348f, 0.02130362f, -0.02244651f, -0.05651595f, 0.00074764f, -0.02563525f, 0.04666155f, 0.03813282f, 
    -0.01720169f, -0.03733154f, -0.03664371f, 0.03162155f, -0.07019360f, -0.00916058f, -0.00660645f, 0.02758529f, 
    -0.01433443f, -0.00062781f, -0.05903101f, 0.03322675f, -0.04113377f, -0.00571313f, -0.02051078f, 0.01507431f, 
    -0.03530029f, 0.02889322f, -0.02840264f, -0.02258880f, -0.01549154f, 0.02836453f, -0.04819443f, -0.06650124f, 
    0.02535959f, -0.02821224f, -0.04992170f, 0.06390327f, -0.01698861f, 0.00634977f, -0.01113342f, -0.05625503f, 
    0.04796470f, 0.00849039f, -0.07139999f, 0.05830209f, -0.02125463f, 0.04098428f, 0.02933841f, -0.02093979f, 
    -0.05165491f, -0.07457390f, 0.01810233f, 0.01713775f, -0.04781819f, -0.05395618f, 0.03305879f, -0.02748464f, 
    -0.00290436f, -0.03028842f, 0.02481425f, -0.00357141f, -0.00154484f, 0.05180014f, -0.07194008f, 0.01026997f, 
    0.00764323f, -0.04473996f, 0.03490808f, -0.06771897f, -0.08006588f, 0.00987831f, -0.07381333f, 0.01477494f, 
    0.04574909f, -0.04704595f, -0.00155710f, 0.02068485f, 0.04499076f, 0.01086144f, 0.02735012f, -0.03669536f, 
    0.02418422f, 0.01225454f, 0.00453577f, -0.03111524f, 0.01324348f, -0.07049831f, -0.07184073f, 0.00303229f, 
    0.02459519f, -0.03131894f, -0.06261542f, 0.05236480f, -0.06971976f, 0.05417389f, 0.04134072f, 0.01671662f, 
    -0.01982079f, -0.00679270f, -0.06737225f, -0.00803809f, 0.06080533f, -0.02960300f, 0.02455456f, -0.05076738f, 
    0.04066236f, -0.00659447f, 0.00022948f, 0.00050574f, 0.05128380f, -0.08213633f, 0.03298126f, -0.03867295f, 
    0.05687106f, -0.00046007f, -0.05007832f, 0.05956253f, -0.02363361f, 0.03982918f, -0.07411172f, 0.06014571f, 
    0.13401145f, 0.13023742f, -0.20151246f, 0.00106312f, -0.06831428f, 0.03186233f, 0.12722148f, 0.13399024f, 
    -0.09145498f, -0.12100102f, 0.01617801f, -0.07451989f, 0.14991462f, -0.13655336f, 0.35840178f, 0.09411095f, 
    -0.04846269f, 0.01749268f, 0.33811903f, -0.15003869f, 0.13423274f, -0.02677842f, 0.11838554f, -0.18453875f, 
    0.26049447f, -0.01394653f, -0.12342738f, 0.15812996f, -0.00265476f, 0.17293653f, -0.07047823f, 0.06275234f, 
    -0.12418746f, 0.04744972f, -0.11948495f, 0.05590669f, 0.00875210f, -0.00054335f, 0.26324978f, 0.03320065f, 
    0.10959148f, 0.20663913f, -0.01706160f, 0.14169000f, -0.08406946f, -0.04558206f, -0.13279577f, -0.00037851f, 
    -0.05666092f, -0.30208442f, 0.00243805f, 0.04737215f, -0.08409481f, -0.07616666f, -0.05009776f, 0.15635467f, 
    0.09338433f, 0.08032621f, -0.05436832f, -0.00766718f, 0.00846435f, -0.06000395f, -0.13493398f, 0.14796165f, 
    -0.22452471f, 0.11253220f, 0.05374756f, 0.10732682f, 0.12558259f, 0.03495031f, -0.13759224f, 0.04299232f, 
    -0.08243331f, -0.01613283f, 0.01918235f, -0.15150754f, -0.04613750f, -0.16549218f, -0.22574386f, 0.01869880f, 
    0.02310572f, 0.10629185f, 0.07493780f, 0.15043764f, 0.20161547f, 0.13521476f, 0.13363950f, 0.02273302f, 
    -0.06089519f, -0.11519386f, -0.06480725f, -0.00893056f, 0.02740236f, 0.05670228f, -0.03468439f, -0.10650944f, 
    0.45057875f, 0.46118400f, 0.00963413f, 0.08877195f, 0.18386871f, -0.05290138f, -0.06911834f, 0.00575846f, 
    0.03280161f, 0.03042391f, -0.03112723f, -0.00625041f, -0.21619558f, -0.08035623f, 0.01514473f, -0.14171873f, 
    -0.08156896f, -0.00745550f, 0.10778834f, -0.02466886f, 0.00141923f, 0.00479718f, -0.00217059f, 0.08091938f, 
    0.07459863f, -0.18384695f, 0.25440553f, -0.03931974f, -0.12925874f, 0.24945799f, 0.10802591f, -0.13226037f, 
    0.08369966f, 0.04738028f, -0.02996979f, 0.05114613f, 0.00669319f, -0.06311490f, 0.04666398f, 0.04967823f, 
    -0.04182271f, 0.09182990f, 0.00956713f, -0.00589550f, 0.02129868f, -0.03740198f, 0.09427185f, 0.18486546f, 
    -0.00954092f, 0.13392617f, 0.11948225f, -0.08294168f, -0.11039863f, -0.00257003f, -0.11825114f, -0.12806059f, 
    -0.13287455f, -0.02859605f, 0.06149133f, -0.02160479f, -0.02378334f, 0.05550616f, -0.12824559f, 0.13919820f, 
    -0.04796059f, 0.03359023f, -0.15797326f, 0.01533744f, -0.04380133f, 0.08621737f, 0.05630568f, 0.16279931f, 
    -0.05733348f, -0.01462805f, -0.19760822f, -0.02577344f, 0.00127296f, 0.01541821f, 0.06524090f, -0.14854476f, 
    -0.01409414f, 0.03888438f, 0.01168564f, 0.08260188f, -0.27655560f, -0.06242977f, -0.48631942f, 0.22570343f, 
    -0.04714962f, -0.06768631f, -0.02916405f, 0.01947451f, 0.06292842f, 0.00249475f, 0.05295452f, 0.05932140f, 
    0.36558542f, 0.22466408f, 0.20984967f, 0.12478577f, -0.06678319f, -0.01827277f, -0.20151332f, -0.07114169f, 
    0.05055377f, 0.00155397f, 0.09236903f, -0.11332886f, 0.12226273f, -0.00557183f, 0.33144397f, 0.20941545f, 
    0.10320988f, 0.13807824f, 0.05232511f, 0.21826355f, -0.00787887f, 0.07348950f, 0.06368951f, -0.17610729f, 
    -0.09428115f, -0.00491779f, -0.01306409f, -0.14605486f, -0.01950111f, 0.06024261f, -0.15357541f, 0.00041658f, 
    -0.12891884f, -0.07842340f, -0.00692695f, -0.06345012f, 0.18883528f, 0.21662366f, 0.25670248f, 0.11746140f, 
    0.01207491f, 0.10749232f, 0.09704189f, 0.01871017f, -0.16649263f, 0.00708918f, -0.07019839f, -0.04003191f, 
    0.17730263f, 0.27515891f, -0.01324664f, 0.04729743f, -0.12505594f, -0.09789360f, 0.08789154f, 0.19706829f, 
    0.14111073f, 0.09368839f, 0.02331137f, 0.12039784f, 0.08513423f, -0.16667461f, 0.10609807f, -0.04225596f, 
    -0.24918920f, -0.12623748f, -0.11669438f, 0.03092437f, -0.08032878f, -0.08333528f, -0.12244645f, -0.06357364f, 
    -0.01156053f, 0.17583482f, 0.11526656f, 0.07233611f, 0.14368841f, -0.02749715f, 0.05707579f, 0.08848624f, 
    -0.11500587f, 0.13904154f, 0.06959161f, -0.02208358f, -0.21229811f, -0.13683835f, -0.13167556f, 0.03471758f, 
    -0.08238724f, 0.08851264f, -0.02996982f, -0.06729534f, -0.02770048f, 0.01057513f, -0.10086667f, 0.04472538f, 
    -0.49312672f, 0.20124288f, -0.09716998f, -0.05844287f, -0.05945750f, 0.06377076f, -0.05747161f, -0.12856716f, 
    0.04859455f, 0.01802595f, 0.02328506f, 0.06065198f, -0.19262794f, -0.04192529f, -0.01523808f, 0.06945212f, 
    -0.19877940f, 0.11384629f, 0.11176447f, -0.00566713f, -0.03070183f, -0.14438681f, 0.02722262f, -0.19429158f, 
    -0.14208086f, -0.13152005f, -0.06217715f, 0.01437476f, 0.00905258f, 0.08674059f, -0.01355030f, 0.02727875f, 
    0.03663244f, 0.07044832f, 0.06515145f, -0.11253358f, 0.20968781f, -0.20906928f, -0.01715961f, -0.15332603f, 
    -0.01240011f, -0.09783195f, -0.13576120f, -0.02744733f, -0.07353915f, -0.12600437f, 0.04998863f, 0.20581552f, 
    -0.08934574f, -0.07288968f, -0.33134401f, 0.00998127f, -0.05948766f, -0.02001180f, -0.00838102f, 0.00253700f, 
    -0.05216286f, -0.05796456f, 0.04203674f, -0.02117223f, 0.06997183f, -0.08247615f, -0.01406464f, -0.07934403f, 
    -0.03731655f, -0.11782999f, -0.02800785f, 0.01649798f, -0.08645238f, -0.04844348f, -0.15874404f, 0.10085672f, 
    0.12051809f, -0.16453962f, 0.13571647f, -0.22485733f, 0.06982936f, -0.19834103f, -0.07797938f, -0.00224735f, 
    0.09255511f, -0.00752681f, -0.09347528f, 0.04456359f, -0.17001538f, 0.26560146f, -0.13813472f, 0.15134092f, 
    -0.01783982f, 0.06092287f, -0.05116764f, -0.00457010f, -0.07640837f, -0.00829086f, -0.04647212f, -0.13319366f, 
    -0.32942706f, 0.29503164f, 0.40221107f, 0.27946064f, -0.04930926f, 0.06383070f, 0.08722612f, -0.01224650f, 
    0.02572447f, -0.04179713f, -0.14637975f, 0.12431644f, -0.22843263f, -0.11033478f, -0.18560015f, -0.13961153f, 
    -0.00765577f, 0.09624171f, -0.07201537f, 0.05878789f, -0.05290637f, 0.06956901f, -0.12745784f, 0.23105760f, 
    0.02283891f, -0.19851868f, -0.03596304f, -0.07616990f, -0.01290806f, -0.04696000f, 0.24888600f, 0.09350693f, 
    0.09780328f, 0.15474409f, 0.14084624f, 0.20128800f, -0.20545755f, 0.00885785f, -0.12353766f, 0.01045535f, 
    0.11745031f, -0.16986376f, -0.15368700f, -0.11797942f, -0.18768439f, -0.19442853f, -0.19339232f, -0.24231911f, 
    -0.14517595f, 0.04642762f, 0.34941268f, 0.16660000f, -0.01556114f, -0.04666669f, 0.00659163f, -0.15324010f, 
    0.21128184f, 0.15524448f, 0.14473569f, -0.03494773f, -0.12916869f, 0.00011828f, 0.01647077f, -0.16008247f, 
    0.31378171f, -0.31149840f, 0.05258247f, -0.07460689f, 0.06844401f, -0.13320355f, 0.01749405f, 0.00692474f, 
    -0.25335354f, -0.14012623f, 0.01147743f, 0.26091570f, 0.04361196f, 0.10972863f, 0.11110997f, -0.01020208f, 
    0.09526790f, -0.04564084f, -0.04391161f, 0.00126194f, -0.02560367f, 0.06911593f, -0.12675427f, -0.01299203f, 
    0.03377997f, 0.00409320f, -0.11728349f, -0.03406547f, -0.07409238f, -0.22482027f, -0.03287124f, -0.14231883f, 
    0.02098810f, -0.35629067f, -0.05691132f, 0.25885147f, -0.09889577f, 0.10938071f, 0.08934377f, 0.09329166f, 
    0.05193519f, -0.05944007f, -0.02843213f, 0.09996292f, 0.27976179f, -0.00919125f, 0.02792438f, -0.09131407f, 
    -0.10871115f, -0.02143244f, -0.01571240f, -0.02280901f, -0.28004178f, -0.06245472f, -0.08341107f, -0.21455950f, 
    -0.24180518f, 0.19195472f, 0.12055224f, 0.13105294f, 0.24890424f, 0.01704479f, 0.01116612f, 0.11316720f, 
    -0.06032117f, -0.16053750f, 0.08055695f, -0.04185993f, -0.09155823f, 0.11111623f, -0.03126332f, -0.06006671f, 
    0.07937191f, 0.07773992f, 0.30095157f, 0.11428920f, 0.11778934f, 0.31458464f, 0.10115749f, 0.11967447f, 
    -0.00289312f, -0.13089408f, -0.04424123f, -0.08207259f, -0.04401550f, -0.15043400f, -0.18636402f, -0.00521556f, 
    -0.21811524f, -0.15728852f, -0.12723663f, -0.11330251f, -0.02969969f, 0.03198507f, 0.02790354f, -0.25926664f, 
    -0.04433522f, -0.05581032f, -0.02293184f, -0.01648250f, 0.09362779f, 0.08773384f, 0.35499859f, 0.07146309f, 
    -0.13586333f, 0.17962268f, 0.24282245f, 0.38158095f, 0.18662716f, 0.13162662f, 0.07510344f, 0.14682484f, 
    -0.03244969f, -0.04691922f, -0.01137847f, -0.06450802f, 0.16318564f, 0.02637369f, 0.33563629f, -0.13076603f, 
    -0.04125011f, -0.07043330f, -0.07492335f, 0.25875670f, 0.12738210f, 0.17020431f, 0.08851979f, -0.08076177f, 
    0.07469270f, -0.14969423f, -0.13696496f, -0.22981158f, -0.05305235f, 0.16910203f, 0.18057741f, 0.02293597f, 
    0.12834859f, 0.11933994f, -0.02308152f, -0.07002813f, 0.00138788f, -0.02791251f, 0.38478610f, 0.03442138f, 
    0.16486007f, -0.06580251f, 0.12944743f, 0.03841941f, 0.14061305f, -0.00689687f, -0.03025079f, 0.00280697f, 
    0.47320041f, -0.09963911f, -0.05652199f, 0.10335726f, 0.05148133f, -0.03405422f, -0.02308943f, 0.12587456f, 
    0.10831313f, -0.11143693f, 0.07621129f, 0.00179165f, -0.07929639f, -0.07446598f, -0.09622707f, -0.08239666f, 
    0.10382725f, 0.10348531f, -0.01323602f, 0.03014036f, -0.03982557f, 0.08803818f, -0.11714265f, -0.04160415f, 
    -0.00791213f, -0.00229170f, -0.03958175f, -0.27986342f, 0.04084752f, -0.01856537f, 0.14888681f, -0.12729767f, 
    -0.03463487f, -0.09356615f, -0.06885661f, 0.06670304f, -0.03517357f, 0.01181159f, -0.03351960f, -0.04592552f, 
    -0.00840706f, -0.08525766f, -0.00164631f, 0.10165463f, 0.05814766f, 0.01573926f, -0.06909923f, -0.02768216f, 
    0.03718442f, 0.05093475f, -0.03550827f, -0.14459127f, -0.00747235f, 0.01759378f, -0.11156863f, -0.07957863f, 
    -0.03119130f, -0.08400287f, 0.02514104f, 0.00930227f, -0.29618701f, 0.11193984f, 0.02361691f, -0.03885090f, 
    0.16626853f, 0.01126442f, -0.03769098f, 0.08405880f, -0.05719477f, -0.04310894f, 0.04433303f, -0.02694766f, 
    0.06865696f, -0.00740934f, 0.28478771f, 0.24349041f, 0.10144739f, -0.06872784f, 0.07248912f, 0.24714769f, 
    0.04417231f, 0.07080531f, 0.04102552f, 0.09490836f, -0.22334130f, -0.23249537f, 0.17135745f, 0.02405896f, 
    0.03146802f, -0.05016722f, -0.07177919f, 0.01550710f, 0.02082258f, 0.11855783f, 0.19732472f, -0.05035427f, 
    -0.20559683f, 0.15452945f, -0.15097983f, -0.27244240f, -0.05267848f, 0.01915628f, 0.28583944f, 0.02703649f, 
    0.02086518f, 0.09986679f, 0.09963705f, 0.16321748f, 0.16590868f, -0.15909879f, 0.04600728f, -0.18121350f, 
    0.03151137f, -0.05110848f, -0.09992466f, -0.04201327f, 0.03970589f, -0.11013737f, 0.09000956f, -0.12950581f, 
    0.10420325f, 0.04935799f, 0.02481321f, -0.02660736f, -0.07916806f, -0.04574154f, -0.12403100f, 0.09484446f, 
    -0.18007235f, -0.10488497f, 0.04372203f, -0.01590346f, 0.05806860f, 0.06721373f, -0.00350042f, 0.04544603f, 
    -0.06677082f, -0.00935625f, 0.04392108f, 0.00091039f, -0.04927330f, 0.03134912f, 0.03340927f, 0.03126096f, 
    0.21834888f, 0.03094116f, -0.12158543f, -0.06866616f, 0.10743832f, -0.13373290f, 0.20823760f, -0.03597356f, 
    0.08774804f, 0.04103537f, -0.03017525f, -0.00467736f, -0.26033533f, -0.17599085f, 0.39675277f, 0.10074219f, 
    -0.16474226f, -0.04177811f, 0.12249928f, 0.19013144f, 0.11973231f, 0.02150754f, 0.12653744f, -0.00354915f, 
    0.14134051f, -0.27144483f, 0.23535268f, -0.02597941f, -0.03835031f, -0.04836575f, -0.02361621f, -0.16544655f, 
    0.06811690f, -0.07876544f, -0.04719679f, 0.02564562f, -0.11881141f, -0.02644204f, -0.17400049f, 0.06385091f, 
    0.00545103f, -0.03929022f, -0.18645364f, 0.13677199f, 0.02625218f, 0.02551974f, 0.08806988f, -0.09019199f, 
    -0.11518770f, -0.14892760f, 0.23860139f, -0.33265617f, 0.07906885f, -0.09606227f, -0.12552625f, -0.24983226f, 
    0.08181482f, 0.02897720f, -0.15726480f, -0.02125456f, -0.03930993f, -0.00567923f, -0.08074856f, 0.09631668f, 
    0.01081361f, -0.14221694f, 0.15965889f, 0.07570503f, 0.03829990f, 0.02414527f, 0.09856941f, 0.17024991f, 
    -0.16793469f, 0.04026938f, -0.07103116f, 0.25615129f, 0.02200157f, 0.00070104f, 0.11339521f, 0.12656219f, 
    0.03813021f, 0.08050296f, -0.05501844f, 0.05233448f, 0.16280803f, -0.03094283f, 0.08306843f, -0.11918601f, 
    0.03568665f, 0.09116738f, 0.06931939f, -0.05961009f, -0.01503911f, 0.19333218f, 0.02725301f, 0.17597945f, 
    0.02112975f, -0.15624495f, -0.00814109f, 0.13700981f, -0.01490123f, 0.00009510f, 0.25828665f, 0.16957703f, 
    -0.08928234f, 0.08459195f, -0.14698862f, -0.12429018f, 0.17890987f, 0.05744503f, 0.07146936f, 0.13922043f, 
    -0.18396536f, 0.14676094f, 0.01162630f, -0.00265815f, 0.05067325f, -0.00397540f, 0.01121651f, 0.01059176f, 
    0.01941937f, -0.17908905f, -0.28933403f, 0.12935799f, 0.00666636f, 0.04198888f, 0.00387471f, -0.22200046f, 
    -0.02686242f, 0.00927939f, 0.02279384f, -0.06872831f, 0.19222158f, 0.14518127f, -0.01348454f, 0.17474419f, 
    0.08828155f, -0.01190812f, 0.10931607f, 0.03921047f, -0.02208787f, -0.07824911f, 0.11630057f, 0.18040454f, 
    0.12071402f, 0.19925232f, -0.03374472f, 0.09605064f, 0.08854494f, -0.13272637f, -0.06278139f, 0.00936026f, 
    0.04505512f, -0.02228750f, -0.01797398f, -0.08950607f, 0.00019162f, 0.22243457f, 0.27058786f, 0.10198040f, 
    -0.09475835f, 0.06374722f, 0.08042376f, -0.02984975f, 0.09047858f, 0.03676043f, -0.06811007f, -0.01453548f, 
    -0.02210383f, 0.02290108f, -0.02506920f, 0.00685772f, -0.07184227f, 0.14941096f, 0.01381528f, 0.06729373f, 
    0.03467518f, 0.06561112f, 0.10834578f, 0.01897649f, 0.25621438f, 0.05976286f, 0.21726738f, -0.10543551f, 
    0.03820069f, -0.08016565f, -0.00444058f, -0.11305873f, 0.13799277f, 0.04979833f, 0.02879337f, -0.03964635f, 
    -0.04546008f, -0.10685083f, 0.20751433f, -0.08446773f, -0.03273591f, 0.11834537f, -0.23505516f, 0.13042967f, 
    -0.05046186f, -0.04192366f, 0.00551542f, -0.05657661f, 0.38019073f, 0.05166463f, -0.03734883f, -0.09888326f, 
    0.07774815f, -0.00701785f, -0.11199093f, -0.13218507f, -0.05388915f, 0.06946243f, -0.07260715f, 0.16371575f, 
    -0.10863042f, 0.06070291f, 0.11469045f, 0.03246049f, 0.15646294f, 0.12562433f, 0.09047432f, -0.14795296f, 
    -0.09537110f, 0.13908678f, -0.02641794f, -0.01357208f, 0.20524062f, 0.04350284f, -0.10035220f, 0.00662266f, 
    -0.02985733f, 0.08392835f, 0.04950685f, -0.01502143f, -0.00800352f, 0.01004273f, 0.00852632f, 0.17558374f, 
    -0.23404224f, 0.20444769f, 0.11153619f, 0.23754981f, -0.18987894f, -0.00715835f, -0.11059701f, -0.34732583f, 
    0.06787936f, 0.13477400f, -0.13603000f, 0.18948174f, 0.19584119f, 0.09488264f, -0.23137431f, -0.12047955f, 
    0.11223222f, -0.07532760f, -0.00925882f, -0.01212279f, 0.06197015f, -0.00943936f, -0.20273004f, -0.38283116f, 
    0.14297515f, -0.08888785f, -0.17384210f, 0.08775810f, 0.03684995f, 0.11027288f, 0.09578145f, 0.04762478f, 
    0.05463446f, 0.06662734f, 0.10924683f, -0.00673383f, -0.24270315f, 0.09570700f, -0.17704631f, -0.05501148f, 
    -0.14897256f, -0.16011199f, 0.07272825f, -0.01152263f, -0.10523380f, -0.05827354f, -0.04703948f, -0.10246741f, 
    0.16449481f, -0.04630738f, -0.03691811f, 0.12957664f, 0.01038375f, 0.08558530f, 0.08383788f, 0.08046104f, 
    0.01074414f, -0.05469905f, -0.12355426f, -0.02200362f, 0.05355954f, 0.00839448f, 0.21945554f, 0.18034658f, 
    -0.00085574f, 0.05895384f, -0.29190782f, -0.05405654f, -0.27802578f, -0.18233716f, 0.04160627f, -0.12913051f, 
    0.57966393f, -0.00552421f, 0.31083131f, -0.02155042f, -0.00315923f, -0.03764375f, -0.12951574f, 0.03127769f, 
    0.09546050f, -0.07665705f, -0.22464357f, -0.00557144f, 0.06051284f, 0.14033547f, -0.10579047f, -0.04862419f, 
    0.01506357f, 0.10798757f, 0.09892792f, -0.15355638f, -0.07702205f, -0.25674301f, -0.36610025f, -0.15507829f, 
    0.26535964f, 0.13988157f, 0.09575085f, 0.13510741f, 0.04394027f, -0.01108774f, 0.00133748f, 0.16209877f, 
    0.02492685f, -0.13159013f, 0.02774008f, -0.03044930f, -0.23840164f, 0.36628857f, -0.06518897f, 0.28013861f, 
    -0.08972627f, 0.11586846f, 0.24411435f, 0.08880274f, 0.14646579f, 0.39523694f, 0.08808123f, 0.16707234f, 
    0.00687980f, 0.13510670f, 0.37170932f, -0.14365889f, 0.10020183f, 0.14082828f, -0.24161234f, -0.14374438f, 
    0.14118755f, -0.13600785f, 0.15433142f, 0.01381693f, -0.24777581f, -0.24648534f, -0.01548887f, 0.25113696f, 
    0.00265747f, 0.19604404f, 0.00078251f, -0.11665482f, -0.06548350f, -0.01454421f, 0.27712214f, 0.15633745f, 
    0.15287267f, 0.24389894f, 0.03584293f, -0.00596981f, -0.08320885f, 0.05850698f, 0.14331691f, 0.05267109f, 
    -0.14649108f, -0.08778089f, 0.06648343f, 0.02577371f, 0.09801564f, 0.12445182f, 0.01775321f, 0.02236833f, 
    0.06903229f, -0.11983667f, -0.16310199f, -0.14872590f, -0.06630687f, -0.09959030f, 0.00226538f, -0.08819875f, 
    -0.24145560f, -0.14038038f, -0.06102914f, 0.01324922f, 0.09367766f, 0.10997726f, 0.16050963f, 0.21806774f, 
    -0.02904783f, -0.06136170f, -0.05770262f, -0.00987674f, -0.22727773f, 0.07543630f, -0.11093280f, -0.14328682f, 
    -0.08553385f, 0.03918370f, -0.00327918f, -0.01639965f, -0.08267789f, 0.01314680f, -0.18087858f, 0.11652934f, 
    0.13710256f, 0.09922746f, 0.04196071f, 0.13636652f, -0.01192295f, -0.02250314f, 0.13307108f, 0.00921128f, 
    -0.13519332f, 0.05977655f, 0.03197778f, 0.08579088f, 0.00202229f, -0.03337168f, 0.09046607f, 0.10503997f, 
    0.07177827f, 0.16490555f, -0.09835398f, -0.19330132f, 0.19336058f, 0.01185805f, 0.03988494f, 0.00955119f, 
    0.36106917f, 0.09555459f, 0.08715253f, -0.23563030f, 0.05823739f, 0.17076853f, 0.08162326f, -0.14264975f, 
    0.09638138f, -0.04434141f, 0.04702858f, -0.08587444f, -0.07187060f, -0.01865585f, -0.09769406f, -0.03940479f, 
    0.20430598f, 0.12129442f, 0.14541423f, 0.14040753f, 0.06263598f, 0.19987476f, 0.12046722f, 0.10522395f, 
    0.03739509f, 0.12923139f, 0.05311865f, 0.01491685f, 0.06349102f, 0.03802978f, 0.08543941f, 0.12013587f, 
    0.06698369f, -0.06538639f, 0.11917073f, 0.02957569f, 0.27045166f, 0.13984245f, 0.01337612f, 0.23367728f, 
    0.17795962f, -0.19814807f, -0.05300562f, -0.00656854f, -0.04308373f, 0.04562846f, -0.04375768f, 0.15016474f, 
    0.37996870f, -0.03036102f, 0.34791738f, 0.12649000f, -0.01919868f, -0.03539783f, -0.10004600f, 0.00382221f, 
    -0.04382508f, 0.09591312f, -0.01080672f, 0.08539014f, 0.08043468f, 0.06656056f, -0.07436456f, -0.08610185f, 
    0.13744161f, -0.13521303f, 0.01900089f, -0.05857885f, -0.02708476f, 0.15389934f, 0.08914073f, 0.09318341f, 
    0.01059105f, 0.23903352f, 0.07924010f, 0.14002471f, 0.09677628f, 0.19175397f, -0.01091076f, -0.01128478f, 
    -0.07912070f, -0.08233994f, -0.09203059f, -0.05878275f, -0.01660791f, -0.02581983f, -0.26549250f, -0.07189345f, 
    0.04688125f, -0.01462850f, -0.10733946f, -0.01695064f, 0.01362392f, -0.11780292f, -0.08682140f, -0.46441773f, 
    -0.17760088f, 0.00434767f, 0.14569858f, 0.15190609f, 0.07534509f, -0.11595852f, -0.04981070f, -0.02713848f, 
    -0.04493270f, -0.01273160f, -0.07183504f, 0.12257490f, -0.19615012f, 0.02207832f, -0.17414765f, -0.00108334f, 
    0.01345558f, 0.02148328f, -0.03614251f, -0.00595145f, 0.25274169f, -0.13622139f, -0.21758500f, 0.02454246f, 
    0.13822427f, 0.32526481f, -0.00217559f, 0.18965733f, -0.10142324f, -0.09114707f, 0.16063212f, 0.12322023f, 
    -0.01635953f, -0.12619264f, -0.07151686f, 0.04917477f, -0.05940739f, -0.18875833f, -0.09280489f, -0.03527882f, 
    -0.05794844f, -0.03116936f, 0.11126859f, 0.06186830f, 0.33792159f, 0.02102152f, 0.20749173f, 0.10351036f, 
    -0.13811570f, 0.13741979f, 0.08802339f, 0.18309098f, 0.02288830f, -0.11139113f, -0.00871460f, 0.15192367f, 
    0.02978539f, 0.02220316f, 0.08495066f, 0.21972065f, -0.16226192f, -0.06949183f, -0.45390871f, -0.10085423f, 
    -0.10174824f, 0.03117107f, 0.01443875f, -0.08333097f, 0.01976964f, -0.05536250f, 0.04728949f, 0.11349265f, 
    -0.05734913f, -0.05896689f, 0.06011131f, -0.08345594f, -0.07684022f, 0.11418698f, 0.08877682f, -0.15592276f, 
    -0.00014325f, 0.09350644f, 0.07492526f, 0.01172055f, 0.04216433f, -0.11167828f, -0.09103466f, -0.00768946f, 
    -0.14311206f, -0.15225025f, 0.06191698f, 0.15182500f, 0.00841204f, -0.04417517f, 0.01803389f, -0.01233520f, 
    -0.09361104f, -0.07294222f, 0.05453676f, 0.17230746f, 0.12261182f, 0.10124600f, -0.11841124f, -0.00366405f, 
    0.04610222f, 0.13334884f, 0.14152202f, 0.02289395f, -0.03820055f, 0.06882947f, -0.02443885f, 0.04275119f, 
    0.13170949f, 0.11065209f, 0.05346609f, -0.03696922f, 0.09027593f, 0.10205051f, 0.11372921f, -0.01439975f, 
    -0.09203263f, -0.14887759f, -0.12611887f, -0.01641982f, 0.00156079f, -0.04188447f, 0.04848634f, 0.03452679f, 
    0.06469970f, 0.00047255f, 0.05970154f, 0.04771708f, 0.30870277f, -0.00358340f, -0.12080695f, -0.02133905f, 
    -0.08191614f, -0.05684624f, -0.01943605f, -0.05034876f, -0.05828181f, -0.00592394f, 0.02113050f, -0.08839959f, 
    0.54552513f, 0.10297157f, -0.35054725f, -0.06024015f, 0.04185030f, 0.04862649f, -0.07842536f, -0.11079111f, 
    -0.08042105f, -0.01199049f, 0.11791632f, -0.01114275f, 0.10760925f, 0.05688082f, -0.17588897f, -0.05334026f, 
    0.14374794f, 0.07771879f, -0.05895147f, -0.01304376f, 0.00816515f, -0.07816166f, -0.03411558f, 0.22314626f, 
    0.04043059f, -0.13187608f, 0.26664832f, 0.36281008f, -0.05489561f, 0.08800873f, -0.21579306f, -0.00374210f, 
    -0.03463827f, -0.03769186f, -0.07636207f, -0.06637474f, -0.12642218f, 0.16626272f, -0.01819231f, 0.22816290f, 
    -0.00180374f, 0.09965491f, 0.14653817f, 0.05904735f, 0.09333462f, 0.32950187f, -0.06574344f, 0.09500173f, 
    -0.16458362f, -0.06264827f, -0.05738055f, 0.00700845f, -0.04437219f, 0.01164267f, 0.03875296f, -0.04439967f, 
    -0.05711892f, 0.05653527f, 0.02666099f, -0.03654406f, -0.27720511f, -0.00656194f, 0.12303166f, 0.03643389f, 
    -0.01255217f, -0.04985351f, -0.13481687f, -0.07156777f, 0.08698060f, 0.20144515f, 0.20804609f, 0.08817954f, 
    -0.20307761f, -0.05118245f, 0.04679026f, 0.24448265f, 0.10686528f, 0.38365474f, -0.07007886f, -0.06421264f, 
    -0.03894415f, -0.07742100f, -0.00802006f, 0.12628038f, 0.12563217f, 0.03316771f, -0.16650435f, 0.02352821f, 
    0.17732374f, -0.00724415f, -0.06039881f, -0.04859479f, 0.14503787f, 0.21774861f, 0.00043956f, 0.11346954f, 
    0.05361139f, 0.00668942f, 0.19109665f, 0.28226385f, 0.03165989f, -0.10304019f, -0.07877703f, 0.05442794f, 
    0.00160613f, -0.10143017f, 0.01017758f, 0.00142880f, 0.00627678f, -0.05372142f, -0.21794789f, -0.00433426f, 
    -0.06385484f, 0.04299877f, -0.21270941f, 0.08116893f, -0.06579969f, -0.00957890f, -0.04490563f, -0.06054024f, 
    -0.35283172f, 0.12202316f, 0.40187204f, -0.19482854f, -0.08053178f, 0.07157628f, 0.03998873f, -0.13332461f, 
    -0.04262426f, 0.00155264f, -0.12197819f, 0.08562959f, 0.05367760f, -0.03474968f, 0.00498836f, 0.10397397f, 
    -0.08851866f, -0.11342069f, 0.21862763f, 0.03446790f, 0.06986430f, -0.02000244f, 0.18554723f, 0.09699775f, 
    0.12266605f, 0.10730062f, -0.02697364f, 0.29219809f, 0.07790580f, -0.01628491f, 0.03983206f, 0.21605659f, 
    0.06771953f, 0.11009818f, -0.00218741f, -0.01665224f, 0.11322156f, -0.00278337f, 0.28989378f, -0.10479425f, 
    -0.06881168f, 0.19130024f, 0.07182085f, 0.11286391f, -0.04877099f, 0.10983624f, 0.10464776f, 0.14217719f, 
    -0.09148879f, -0.14968735f, -0.07162678f, 0.18088166f, 0.00626246f, 0.06780383f, 0.19162504f, 0.09279996f, 
    -0.07059305f, 0.04696625f, -0.04124554f, 0.02111325f, 0.22163326f, 0.17455310f, -0.06411163f, 0.07383210f, 
    -0.10344223f, -0.04279049f, 0.11031082f, -0.01628520f, -0.01519870f, 0.04403844f, -0.02968147f, 0.09914874f, 
    0.09829954f, 0.24389641f, -0.32382995f, -0.14853719f, -0.06439456f, 0.04788771f, -0.09156673f, -0.28809616f, 
    -0.01027660f, -0.06713083f, 0.05063334f, -0.00238481f, 0.25424913f, 0.20190492f, -0.07989042f, 0.03401074f, 
    0.11976637f, 0.09975384f, 0.19511452f, -0.08339500f, 0.10039685f, 0.06148425f, -0.15169838f, 0.30044824f, 
    0.02710896f, -0.15974034f, 0.07075644f, 0.29072446f, 0.00476046f, 0.01443144f, -0.09875836f, 0.02364375f, 
    0.00432437f, -0.00677617f, 0.05209246f, -0.16894339f, -0.09509974f, 0.03813639f, 0.18542750f, 0.06223901f, 
    -0.01006287f, -0.16712259f, 0.00922006f, 0.11319932f, 0.02499053f, -0.08551281f, -0.05587912f, 0.02050934f, 
    -0.16653101f, 0.08174653f, 0.02130338f, 0.11521276f, -0.00513951f, -0.00266792f, 0.02464397f, -0.01452002f, 
    -0.00836763f, 0.13854659f, 0.06520355f, 0.12976862f, -0.19973500f, 0.00455577f, 0.25861341f, -0.02444580f, 
    0.06956206f, -0.04794750f, 0.02407969f, -0.03454744f, 0.13905215f, 0.08120334f, -0.07421493f, 0.09670870f, 
    0.14530331f, -0.03287505f, 0.12467226f, -0.22596404f, -0.05826692f, 0.11928602f, -0.08016060f, 0.20633893f, 
    -0.00081691f, 0.03141927f, -0.12416547f, -0.04907343f, 0.51850426f, 0.21354246f, -0.49981731f, -0.13803250f, 
    0.13239954f, 0.14139967f, -0.02646537f, -0.10081141f, -0.08154503f, 0.10965347f, -0.04554424f, 0.08089906f, 
    0.01866321f, -0.00921288f, 0.06396475f, -0.05339184f, -0.05130220f, -0.03149594f, 0.05921081f, 0.01429888f, 
    -0.07115150f, -0.02509365f, -0.04093323f, -0.02901692f, -0.03191305f, -0.07345453f, 0.00112470f, 0.04017539f, 
    -0.02517290f, -0.05065852f, 0.00786488f, 0.01656783f, -0.06260390f, 0.02485774f, 0.02062617f, -0.03797961f, 
    0.01138276f, -0.05310258f, 0.02838607f, 0.04484040f, -0.08287232f, -0.02518366f, 0.02904540f, -0.01623906f, 
    -0.07125738f, -0.05100569f, -0.02155328f, 0.06238646f, -0.05055463f, 0.03822292f, -0.00360102f, -0.06605305f, 
    -0.01631688f, 0.04677904f, 0.05343765f, -0.01474325f, 0.02034163f, -0.07048029f, 0.01487610f, 0.04167901f, 
    0.06982508f, 0.01103177f, -0.05240508f, -0.06792579f, -0.07884651f, -0.00400890f, -0.01365582f, 0.04479306f, 
    0.02057371f, -0.02316345f, 0.00319714f, -0.01438117f, 0.04889013f, 0.03361680f, 0.00275958f, 0.00473834f, 
    -0.06876613f, -0.06459107f, -0.01355613f, 0.01423711f, 0.05554657f, -0.06982717f, 0.02675599f, 0.00023209f, 
    0.05939486f, -0.06941506f, -0.00290571f, -0.03274324f, -0.07263812f, 0.04198215f, -0.04065111f, 0.00252195f, 
    -0.02884503f, -0.05006050f, 0.00904718f, 0.06798482f, -0.06985603f, -0.01173740f, 0.03017039f, -0.00321878f, 
    0.00375771f, -0.00176201f, -0.02730619f, -0.05320192f, 0.00507035f, -0.00648214f, -0.04456176f, -0.01739079f, 
    0.00299486f, 0.03088050f, -0.05307400f, -0.06530587f, -0.00234918f, -0.02239447f, 0.00698686f, -0.03540423f, 
    -0.04531461f, 0.02035860f, 0.07008652f, -0.06825238f, 0.00617210f, -0.04994018f, -0.08063202f, 0.02792835f, 
    0.05206004f, -0.01865724f, 0.04666979f, 0.00101219f, -0.06216436f, -0.05761008f, 0.05479053f, -0.02209175f, 
    0.03530864f, -0.06914978f, -0.02119228f, -0.07683034f, -0.03506319f, 0.04197390f, -0.01568079f, -0.00044997f, 
    0.06647619f, -0.04057425f, 0.03799218f, -0.00248976f, 0.03260821f, -0.00841679f, -0.07538978f, -0.01899668f, 
    -0.01838604f, 0.00436946f, -0.03895510f, -0.05088494f, 0.01515017f, -0.01799486f, 0.01395286f, 0.05373140f, 
    0.00996174f, 0.05781589f, 0.01846055f, 0.01779717f, 0.01613624f, -0.04433238f, -0.05885130f, 0.00642790f, 
    0.02932606f, -0.04247695f, 0.00198741f, -0.04253535f, -0.06201153f, -0.05007456f, -0.06653712f, -0.00903345f, 
    -0.05474899f, 0.01654089f, -0.03667453f, -0.04207634f, 0.02179806f, 0.06940423f, 0.00340039f, 0.06182596f, 
    0.02878158f, -0.02661377f, 0.04345264f, -0.01729117f, -0.05022450f, -0.02117991f, 0.05899043f, -0.03265300f, 
    0.00613672f, 0.02753089f, -0.05183116f, -0.02183525f, 0.01508899f, 0.05181435f, -0.06340895f, -0.05945281f, 
    0.03691915f, -0.01687938f, 0.00198823f, 0.04806367f, 0.03284045f, -0.03825538f, 0.00739916f, -0.03108730f, 
    -0.02111372f, 0.16824375f, 0.00728967f, -0.26617086f, -0.09245086f, -0.03389478f, -0.07237532f, 0.11207478f, 
    0.00210204f, 0.09925379f, 0.06662834f, -0.04771519f, -0.04315610f, -0.23558307f, 0.56630152f, 0.23424675f, 
    0.15332343f, -0.03644090f, 0.04419527f, 0.02706515f, 0.12744364f, 0.02995002f, 0.08148132f, -0.10351388f, 
    0.46310037f, -0.05660935f, -0.00032057f, 0.15652655f, -0.01786434f, -0.00871417f, -0.11927997f, 0.23023167f, 
    0.20387301f, 0.02521107f, -0.03955130f, 0.04761730f, -0.08397131f, 0.12403540f, 0.12114431f, -0.27744693f, 
    -0.03093667f, 0.10200198f, -0.13461745f, 0.15643620f, -0.13289815f, 0.01407961f, -0.18450670f, -0.12238317f, 
    -0.20404609f, -0.19699796f, 0.08102722f, 0.03914480f, 0.06282877f, -0.21809599f, 0.06012831f, -0.02836258f, 
    0.04180885f, 0.04027993f, 0.06244139f, 0.15122551f, 0.02145980f, 0.09520766f, -0.10913636f, 0.04467984f, 
    0.02450852f, -0.07159153f, -0.00135611f, 0.13307370f, 0.05301130f, -0.15696409f, -0.13916729f, 0.13054200f, 
    -0.07879189f, 0.09431825f, -0.11032317f, -0.08146708f, -0.02311859f, -0.08677510f, -0.15031441f, -0.08901362f, 
    0.01722540f, -0.00147867f, -0.11991090f, -0.06645220f, -0.15466459f, 0.00379384f, 0.04813292f, -0.00625349f, 
    -0.00822230f, 0.08592492f, -0.00961079f, 0.05461938f, 0.02555604f, -0.03292918f, -0.01139206f, -0.04502359f, 
    -0.12215724f, -0.10536674f, 0.01087075f, 0.25466046f, 0.23259215f, 0.21152221f, 0.11935966f, 0.04022428f, 
    0.04735464f, 0.01154892f, -0.03020027f, 0.04644708f, -0.13823681f, -0.19627164f, 0.09726550f, 0.03354146f, 
    -0.10752767f, 0.01238021f, 0.07580275f, 0.14381367f, 0.00651406f, -0.12068787f, -0.00731164f, -0.20029519f, 
    -0.29067466f, 0.01109564f, 0.12672102f, -0.24777356f, -0.14554709f, -0.00851385f, 0.18594235f, 0.04435690f, 
    0.06003316f, 0.03206233f, 0.03537979f, 0.07802589f, 0.18648069f, 0.04826698f, 0.11109837f, -0.15184943f, 
    -0.05091268f, 0.01589671f, -0.08704010f, 0.02635433f, 0.09210762f, 0.12154081f, 0.23491092f, 0.25242889f, 
    0.15010536f, 0.12942590f, 0.15666333f, -0.13881923f, -0.07407875f, 0.00739339f, 0.04030556f, 0.13242325f, 
    0.00130591f, -0.15811369f, -0.00677760f, -0.00309429f, 0.15966135f, -0.10393650f, 0.00465503f, 0.05417199f, 
    -0.00930498f, 0.01729109f, -0.00646923f, 0.05181647f, -0.07707175f, 0.03452526f, 0.13007206f, 0.15583019f, 
    -0.05952163f, -0.07744767f, -0.15990101f, -0.11498131f, 0.15183626f, 0.01688222f, 0.04729851f, 0.00706585f, 
    0.10599808f, 0.13384306f, 0.08835935f, -0.02666304f, -0.23562036f, -0.02634867f, 0.14532407f, 0.39528221f, 
    0.01769084f, 0.07853372f, -0.05707287f, 0.07889210f, -0.03916371f, -0.12465253f, 0.03362176f, -0.09690014f, 
    0.16442209f, 0.11195196f, -0.03349994f, 0.09525128f, -0.01400666f, 0.02041312f, -0.05364004f, -0.18350542f, 
    0.12068644f, 0.02271517f, 0.17674413f, 0.17313430f, 0.24147843f, -0.13241206f, 0.13859788f, -0.06267520f, 
    0.00379014f, 0.07424268f, 0.10832510f, 0.11472793f, 0.03271475f, 0.03541883f, 0.08252057f, 0.11930318f, 
    -0.05728312f, 0.03796883f, -0.30818939f, 0.00410417f, -0.07040401f, -0.01775077f, 0.11645485f, -0.20857769f, 
    -0.17006940f, -0.11558208f, 0.10208566f, 0.01999059f, 0.14157152f, 0.12119015f, 0.04870534f, -0.11107446f, 
    0.05211691f, 0.07609931f, 0.02465859f, 0.11607703f, -0.03321028f, -0.04458816f, -0.09918278f, -0.19521652f, 
    0.31359699f, 0.10861676f, 0.09054513f, -0.03436722f, -0.09689095f, -0.05241136f, 0.02624570f, 0.01815276f, 
    0.19839115f, 0.13493328f, 0.10254634f, 0.16857480f, -0.10235781f, -0.18420427f, -0.24107933f, 0.09795523f, 
    -0.12939383f, -0.25065127f, -0.27061626f, -0.07758807f, -0.16560324f, -0.30518192f, -0.13016853f, -0.34495431f, 
    0.23006372f, 0.27721450f, -0.02721145f, -0.07105504f, 0.14470321f, 0.03320690f, 0.10496151f, 0.08387747f, 
    0.01364796f, 0.00832152f, 0.03756982f, 0.00257732f, -0.23695235f, -0.05952725f, -0.01890280f, 0.00973261f, 
    0.09435911f, 0.04075251f, -0.10013113f, 0.06593049f, -0.18400745f, -0.21625246f, -0.07106666f, -0.22013277f, 
    -0.03849963f, 0.17469434f, 0.46656179f, -0.17011715f, -0.19522633f, -0.01115553f, -0.03344761f, -0.03603153f, 
    -0.12479651f, -0.21586120f, -0.13567269f, -0.10595152f, -0.28894877f, 0.13348866f, -0.01842294f, 0.00410509f, 
    -0.07979480f, 0.17038891f, 0.04694866f, -0.15629973f, -0.16250068f, -0.13713920f, -0.24060044f, -0.14716659f, 
    0.09654613f, 0.00040874f, -0.01230106f, -0.09192875f, 0.15102282f, 0.22018965f, 0.02852039f, 0.16353965f, 
    0.02599888f, -0.06427624f, 0.04073233f, -0.01109647f, 0.30120921f, -0.10701323f, -0.10966570f, 0.08514535f, 
    -0.11457123f, -0.21661307f, -0.06797975f, 0.00788123f, 0.00179365f, 0.15224706f, 0.11480635f, 0.23544240f, 
    -0.29694843f, -0.11541091f, 0.02443529f, 0.37723866f, -0.10574163f, -0.31155479f, -0.12278676f, -0.42268026f, 
    -0.18723388f, -0.31030676f, -0.06639498f, 0.10374735f, -0.36987910f, -0.42162752f, -0.29750094f, 0.17919379f, 
    -0.21875022f, -0.17300312f, -0.06929603f, 0.01106012f, 0.04152313f, -0.06176519f, -0.03683542f, 0.23240624f, 
    0.23732586f, -0.20370467f, 0.23014368f, -0.17254993f, 0.15771225f, -0.02427859f, 0.13892829f, -0.07041415f, 
    -0.00154764f, -0.10171945f, -0.06279884f, 0.20435049f, 0.18710352f, 0.31035671f, -0.01977177f, 0.14593175f, 
    -0.14377829f, -0.07876889f, -0.16836815f, -0.26452550f, 0.02483261f, 0.00512938f, -0.06989311f, -0.20662631f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.12379059f, 0.13678281f, -0.01877925f, -0.00650913f, -0.06530301f, 0.02041559f, 0.10803421f, 0.11380298f, 
    -0.12094520f, -0.11864049f, -0.02098046f, 0.20749699f, 0.14047496f, -0.01475305f, 0.04025065f, 0.17585954f, 
    0.18385851f, 0.02808326f, 0.10109429f, 0.12714046f, -0.02326339f, -0.07847833f, 0.17423220f, 0.10671412f, 
    0.00445924f, 0.01310570f, -0.06989983f, 0.07122130f, 0.12322905f, -0.02898225f, 0.09752734f, -0.09475950f, 
    0.06082230f, 0.13517718f, 0.05978976f, 0.03375390f, -0.07648236f, -0.05697417f, 0.13969713f, 0.16695960f, 
    -0.00550442f, -0.07494514f, -0.00793379f, -0.02340857f, 0.03350170f, 0.06948499f, 0.09504050f, 0.04282742f, 
    -0.13502526f, -0.03922866f, 0.19757465f, 0.18462987f, -0.06505628f, -0.05376649f, -0.08341875f, 0.02597148f, 
    -0.00582926f, -0.02266095f, -0.04873651f, 0.24370404f, 0.18942119f, 0.02090128f, -0.05548614f, 0.04771707f, 
    -0.00224063f, -0.02733913f, -0.07186453f, 0.12757970f, 0.03628699f, -0.06837126f, 0.04309221f, 0.03623750f, 
    0.04604710f, -0.00848489f, 0.01825960f, 0.01977239f, 0.02201333f, 0.05081472f, -0.02561844f, 0.17506272f, 
    0.17922370f, 0.21285519f, -0.07349276f, 0.18242647f, -0.02208396f, 0.07597353f, 0.20067126f, 0.03158649f, 
    0.12273380f, 0.23225607f, -0.06370036f, 0.17601256f, 0.00112345f, -0.07102069f, 0.09166580f, 0.07549170f, 
    0.20002739f, 0.10340676f, -0.10189575f, -0.11001804f, 0.28365985f, -0.04292707f, -0.05460211f, 0.11737316f, 
    0.03258080f, 0.11926039f, 0.05855213f, -0.03323535f, 0.00090986f, -0.01043576f, -0.07581484f, -0.03424778f, 
    0.20028268f, -0.02615401f, 0.05983341f, -0.06442735f, 0.12042549f, 0.02788495f, 0.04766627f, 0.21430342f, 
    -0.00839719f, -0.13999829f, 0.10688934f, -0.01096766f, -0.01506828f, 0.00347281f, 0.11292405f, -0.12945774f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.37367418f, -0.50103009f, 0.03008706f, -0.03290003f, -0.25556573f, -0.37342504f, 0.09860114f, -0.30358008f, 
    -0.24738519f, 0.10707193f, 0.00628074f, -0.11876173f, -0.39903709f, 0.13186379f, -0.05764125f, -0.43517917f, 
    -0.02181640f, 0.01446352f, -0.15231787f, 0.10233369f, -0.03281888f, 0.13898689f, -0.25390890f, 0.06257426f, 
    0.12807775f, -0.08380459f, 0.13456590f, -0.17865574f, -0.20022243f, -0.03911221f, -0.36126813f, -0.03637368f, 
    0.08209177f, -0.42660782f, -0.38063112f, 0.10865186f, -0.08388040f, 0.18453135f, 0.14954907f, -0.07447336f, 
    -0.00111072f, 0.13761041f, 0.20955157f, 0.23430257f, -0.03420525f, 0.05229139f, -0.00175199f, -0.20742530f, 
    0.13830975f, -0.18705204f, -0.08782967f, -0.26663175f, 0.01069078f, 0.31114227f, -0.02792344f, -0.26734090f, 
    0.21613888f, -0.12391095f, 0.01951236f, 0.06128529f, -0.07372490f, -0.21131738f, -0.02969591f, 0.09895640f, 
    -0.57707828f, 0.02358459f, -0.17762318f, 0.07976660f, -0.05966940f, 0.19753568f, -0.37909639f, 0.04852629f, 
    -0.05312597f, -0.02089336f, 0.02712557f, -0.46808746f, -0.03041794f, -0.03858649f, 0.06361335f, -0.26715991f, 
    -0.11715989f, -0.32073784f, -0.04862978f, -0.09421465f, 0.08428203f, 0.09562942f, 0.20205864f, -0.07382693f, 
    -0.29442748f, -0.16432887f, -0.15186605f, -0.07109256f, -0.04788475f, 0.11647531f, 0.19633253f, 0.02458936f, 
    -0.07105509f, -0.24031958f, 0.31275088f, 0.15965454f, -0.34270856f, 0.09892512f, 0.06098250f, -0.44832152f, 
    -0.12748399f, -0.01386699f, 0.00103505f, -0.05395555f, 0.11317041f, -0.01962550f, 0.09943653f, -0.04676882f, 
    -0.01483785f, 0.13583690f, -0.02031612f, 0.00829754f, -0.00548669f, 0.09073516f, -0.32168061f, -0.04375916f, 
    -0.38138619f, 0.25044078f, -0.05580308f, -0.18759950f, -0.00662838f, -0.03219125f, -0.15971871f, 0.33454153f, 
    -0.26517197f, -0.08942575f, 0.00691251f, 0.24536690f, 0.05693014f, 0.05109765f, -0.04004234f, 0.20598072f, 
    -0.36806470f, -0.23355307f, -0.04629410f, 0.20243916f, -0.17822950f, 0.01665714f, 0.01059553f, -0.07081242f, 
    0.15431122f, -0.05987497f, -0.38990101f, -0.02856483f, -0.01868358f, -0.38311419f, -0.05339207f, 0.02173818f, 
    0.03612204f, 0.15425883f, 0.09812873f, -0.00073460f, 0.15831263f, -0.06865299f, 0.03707947f, -0.17088950f, 
    0.26335138f, 0.22357130f, 0.11561516f, 0.02329803f, -0.01190619f, -0.35625437f, 0.07986772f, -0.07545447f, 
    0.01695717f, 0.02552578f, -0.03728407f, -0.11522049f, -0.10685284f, 0.10520254f, -0.03312156f, 0.09364138f, 
    -0.01677885f, -0.30331174f, -0.14450400f, 0.01000222f, 0.03620970f, -0.53749156f, -0.12149999f, -0.21433288f, 
    0.17575844f, -0.46109655f, -0.04066353f, 0.21345064f, 0.30240706f, 0.04215114f, 0.04213959f, 0.09630106f, 
    0.21848239f, 0.05242796f, -0.10469404f, 0.12282668f, -0.03914876f, -0.76789904f, 0.01987582f, -0.02509427f, 
    0.03456757f, -0.02141647f, -0.00577879f, -0.19868134f, 0.06309994f, -0.07242301f, -0.15314940f, 0.44477326f, 
    0.22438091f, 0.01530466f, -0.01441294f, 0.34713849f, -0.00992078f, 0.13362384f, -0.26699194f, -0.07839077f, 
    0.06488327f, 0.15424182f, 0.16591242f, 0.28091201f, 0.07784180f, 0.06275444f, -0.06287928f, 0.07257329f, 
    0.30976313f, 0.20283221f, -0.38517764f, 0.10372835f, 0.14269941f, 0.15737917f, -0.05826814f, -0.28359267f, 
    -0.25788924f, 0.10039261f, -0.06226540f, -0.35183269f, 0.11073521f, -0.07017758f, 0.05085183f, 0.00943980f, 
    -0.05894645f, -0.62773919f, -0.02324188f, -0.00527650f, 0.09915842f, 0.20156500f, -0.63341981f, 0.11767270f, 
    -0.00266484f, -0.55512816f, -0.13715780f, -0.22384495f, -0.11741426f, -0.01461126f, 0.04929965f, -0.03778212f, 
    0.07743055f, 0.04287844f, -0.02152722f, -0.00692910f, -0.30439192f, 0.31688547f, 0.15203430f, 0.26575094f, 
    0.08848633f, 0.07489733f, -0.24532373f, 0.25875622f, 0.08276048f, -0.08876338f, -0.05740125f, -0.05628004f, 
    -0.02611095f, 0.06444812f, 0.08143359f, 0.05279398f, 0.01899081f, -0.39882699f, 0.02135242f, -0.22014163f, 
    -0.06569420f, -0.31177145f, 0.08672974f, 0.01483556f, -0.12609021f, 0.00998549f, 0.08728123f, 0.11914992f, 
    0.18196259f, -0.46876645f, -0.30623442f, -0.04241392f, 0.00417236f, -0.26475140f, 0.00096937f, -0.01401607f, 
    -0.41690740f, 0.06425192f, -0.37615001f, 0.33406577f, 0.13013294f, 0.04445958f, 0.05126153f, 0.17003292f, 
    -0.24837382f, -0.16084433f, 0.02645989f, 0.12336203f, 0.04115155f, -0.06938820f, -0.09738646f, -0.10425027f, 
    -0.09572758f, -0.44100308f, -0.04848847f, 0.31481689f, 0.24866904f, 0.01183971f, 0.07757372f, -0.14608961f, 
    -0.32170081f, 0.05159042f, -0.16358849f, -0.01784720f, 0.05306189f, 0.09570948f, -0.16798551f, -0.08537003f, 
    -0.01418320f, -0.01336916f, 0.00818931f, 0.13776043f, -0.02104405f, -0.06778222f, 0.08870664f, -0.67993939f, 
    -0.09641095f, 0.25508368f, 0.02219008f, -0.51572233f, 0.04598518f, -0.23043221f, 0.34731898f, -0.02071682f, 
    0.10036009f, -0.15459287f, 0.15368514f, -0.02054225f, 0.05945061f, -0.06213263f, -0.15462714f, 0.10859051f, 
    0.23657304f, -0.09693421f, -0.32020998f, -0.05143935f, 0.12245544f, -0.57608020f, 0.04690633f, -0.10686059f, 
    -0.29922831f, 0.01191151f, -0.03243006f, 0.19697060f, 0.02040418f, 0.05899566f, -0.14901070f, 0.07653139f, 
    0.18029578f, 0.17247260f, 0.04567062f, 0.03909172f, 0.01810351f, 0.00868671f, 0.20690644f, 0.14531106f, 
    -0.04717280f, 0.10343677f, -0.05279860f, -0.10795091f, 0.01737520f, 0.01082028f, 0.04569398f, -0.62206900f, 
    -0.14644936f, -0.03396380f, 0.05948798f, 0.05921179f, -0.16515484f, 0.26684287f, -0.62714756f, 0.39448017f, 
    0.32362255f, 0.01210594f, 0.11950598f, -0.05502288f, -0.02607774f, 0.09020703f, 0.02284180f, -0.12504409f, 
    -0.52545547f, -0.00402543f, 0.23107906f, 0.01899714f, 0.01508337f, -0.17275263f, 0.14529973f, -0.03258205f, 
    0.05659706f, 0.06568795f, 0.08068062f, -0.51698446f, -0.23315626f, 0.02349042f, -0.16848764f, -0.03674934f, 
    -0.09118193f, 0.03511436f, -0.13493051f, 0.03614147f, 0.02742714f, 0.11114027f, -0.09499896f, -0.03435243f, 
    0.01746071f, 0.14396457f, 0.01491690f, 0.12354390f, 0.05224623f, -0.01248617f, -0.25610885f, -0.20670778f, 
    0.09159201f, 0.18723901f, -0.10573560f, -0.20979606f, 0.08995575f, -0.11304244f, 0.24294981f, 0.27638456f, 
    0.09382249f, -0.11033911f, -0.03637773f, -0.19615561f, -0.29918078f, 0.11094598f, 0.03711041f, -0.40790433f, 
    0.34815854f, 0.00395768f, 0.17975080f, -0.03813565f, 0.20675893f, -0.02800454f, -0.13146438f, 0.07225294f, 
    -0.18454221f, 0.06355900f, -0.05924875f, 0.37128085f, 0.19680539f, -0.04359031f, -0.41600448f, -0.09781118f, 
    -0.40502954f, -0.10448826f, -0.02540613f, -0.34755966f, -0.02828580f, 0.04399258f, -0.14310613f, -0.06553281f, 
    -0.12951270f, -0.32154068f, 0.18895073f, 0.03498028f, 0.13644169f, -0.36326081f, -0.05293416f, -0.21373084f, 
    -0.17454742f, -0.30731571f, 0.00172733f, 0.25949714f, -0.30266872f, 0.09181657f, 0.05223671f, -0.19629245f, 
    0.08033781f, -0.04347463f, -0.02360588f, 0.15219581f, -0.10758569f, 0.04907871f, 0.17604914f, 0.04929758f, 
    0.16947205f, 0.10812601f, -0.02067030f, -0.00755004f, -0.10934664f, -0.09106931f, 0.11848180f, -0.31533647f, 
    0.24667346f, 0.19868971f, 0.02688467f, 0.18785954f, 0.09351504f, -0.04695532f, -0.31157273f, -0.09401703f, 
    -0.05186566f, 0.03042043f, 0.11828693f, -0.01063249f, 0.22375105f, 0.14314571f, 0.04340058f, -0.28465635f, 
    0.14459853f, 0.23700756f, 0.01715056f, -0.15925197f, 0.11384043f, 0.08848018f, 0.00096088f, 0.08487292f, 
    -0.17478634f, -0.00504037f, -0.37818468f, -0.09663732f, -0.04508465f, 0.01735990f, -0.13421132f, -0.16496009f, 
    -0.03226852f, 0.09998322f, 0.05348862f, 0.14965516f, 0.18088301f, -0.00315949f, -0.10564349f, 0.28697944f, 
    0.13801372f, 0.04748461f, 0.19187926f, 0.09786621f, 0.03656295f, 0.16081904f, -0.02690166f, -0.30222756f, 
    -0.12635289f, 0.10257664f, -0.23243392f, 0.03843345f, 0.07482148f, -0.28933781f, 0.10875491f, 0.04538804f, 
    0.01512229f, -0.03783184f, -0.28070304f, -0.03844395f, 0.00934409f, 0.11631693f, -0.23103014f, 0.13781418f, 
    -0.10479540f, 0.32915220f, 0.00040207f, -0.27440631f, -0.08263628f, 0.13773027f, 0.02373808f, 0.09741132f, 
    -0.63000458f, -0.05775721f, -0.02453619f, 0.08990563f, -0.34830248f, 0.24543227f, 0.24495362f, -0.02255891f, 
    -0.05386858f, -0.04008448f, 0.02736144f, -0.16746335f, -0.17800663f, 0.07275821f, 0.03084020f, -0.23829892f, 
    -0.21185131f, -0.20144804f, 0.04599440f, -0.44451520f, -0.05982930f, -0.11737002f, -0.33801278f, -0.07454630f, 
    -0.15799186f, -0.19360164f, 0.12547328f, -0.28017354f, -0.17512210f, 0.13577273f, -0.12066789f, -0.14439784f, 
    0.02338355f, 0.13007432f, 0.00044098f, -0.09117133f, -0.29216552f, -0.13468258f, 0.02280027f, 0.16325924f, 
    0.16154602f, -0.67078197f, -0.06805093f, 0.07922692f, -0.10238101f, 0.04353635f, -0.00234890f, 0.03260391f, 
    -0.13823895f, 0.24291015f, -0.08334485f, -0.00953465f, -0.04049675f, 0.09054989f, 0.10742429f, -0.19980164f, 
    0.04543316f, -0.01211762f, 0.10538151f, 0.05546015f, 0.10559282f, -0.02969139f, -0.12675457f, 0.26857942f, 
    0.04855238f, 0.01195784f, -0.03282465f, 0.12402265f, -0.00402953f, -0.35872328f, -0.18480416f, -0.37234414f, 
    -0.07692457f, -0.25345889f, 0.16702366f, 0.03146955f, 0.04459741f, -0.04401483f, -0.06060919f, 0.12682046f, 
    0.07432752f, -0.06393662f, 0.04991604f, 0.11664725f, -0.04117287f, 0.32457665f, -0.14675368f, 0.02876393f, 
    0.00922348f, 0.03027897f, 0.03468782f, -0.06866638f, -0.04404905f, 0.03921154f, -0.02734610f, -0.09985878f, 
    -0.10167130f, -0.10957792f, -0.00733661f, 0.03428518f, 0.06560556f, 0.23683892f, 0.11033596f, 0.03298387f, 
    0.11405153f, 0.05510137f, 0.11057088f, -0.40635210f, -0.17758906f, -0.02101250f, 0.14140382f, -0.01468973f, 
    -0.08966437f, -0.20654003f, 0.20409603f, -0.03805919f, 0.04805358f, 0.16494864f, -0.30703378f, -0.17710507f, 
    -0.09479883f, 0.21545036f, 0.07433218f, -0.24391732f, 0.10510015f, -0.10744272f, 0.00615957f, 0.12796460f, 
    -0.30937871f, 0.00468535f, 0.12711634f, 0.00496304f, -0.17157578f, -0.14049216f, 0.18940140f, 0.03398751f, 
    -0.09300194f, 0.05481621f, 0.01440383f, -0.56207800f, 0.04668980f, -0.04413706f, -0.08376719f, -0.12802579f, 
    -0.04789159f, 0.17196119f, 0.00030907f, -0.29854438f, -0.01578434f, 0.25368193f, 0.36543828f, -0.01085057f, 
    0.01789374f, 0.08317898f, -0.11379194f, -0.11157835f, -0.06589089f, 0.18025625f, 0.22289914f, 0.03772636f, 
    -0.12669834f, 0.25452065f, -0.09997739f, -0.16536267f, 0.19171225f, 0.19973724f, -0.03455922f, 0.37380472f, 
    0.13044231f, -0.13001451f, 0.05574636f, 0.32719657f, 0.01525478f, 0.02266891f, -0.01659619f, 0.07641067f, 
    0.13433723f, -0.28859553f, 0.03462131f, -0.06440517f, -0.09771375f, -0.12154024f, -0.08374151f, 0.19641683f, 
    -0.12357581f, -0.21673641f, 0.20736465f, -0.22919194f, -0.28485680f, 0.05259844f, -0.05549647f, -0.34058869f, 
    0.10423776f, 0.15283093f, -0.32523665f, -0.53882754f, 0.16561432f, 0.25529841f, 0.15735035f, 0.13290961f, 
    -0.05311570f, -0.25484803f, -0.36571276f, -0.06281513f, 0.24822758f, -0.30209908f, -0.00101437f, 0.07959875f, 
    0.17068841f, -0.05060344f, 0.16922808f, 0.08997612f, -0.04515717f, 0.11467434f, 0.15174724f, -0.17940961f, 
    -0.32472244f, -0.16814637f, -0.62851566f, 0.20837168f, -0.29531455f, 0.03393650f, -0.03000240f, -0.17608564f, 
    0.02574158f, -0.02659593f, -0.35070559f, -0.39034033f, 0.00173146f, -0.09134047f, -0.26671788f, 0.11595927f, 
    -0.27330214f, 0.07412855f, -0.34026995f, 0.15840575f, 0.18944804f, -0.31999126f, -0.01452347f, -0.05753107f, 
    -0.56992042f, 0.16769503f, 0.14825512f, 0.06090346f, -0.01502874f, -0.27821556f, 0.05366790f, -0.06406648f, 
    -0.45255247f, 0.10743759f, -0.05517992f, 0.00066185f, -0.14656378f, 0.20122880f, 0.04691468f, -0.12173492f, 
    0.00297788f, 0.00486145f, 0.16304751f, -0.21602707f, -0.04053669f, -0.10816929f, 0.08049358f, 0.03616768f, 
    0.13779438f, -0.00440387f, 0.05739031f, 0.27753371f, -0.13849077f, -0.01022143f, 0.14676459f, 0.05588779f, 
    0.15773803f, -0.10675480f, -0.00860194f, 0.36248043f, 0.03643868f, -0.20561334f, -0.02191386f, 0.02415637f, 
    -0.09396361f, -0.05102546f, -0.21321547f, -0.64513886f, -0.14949563f, -0.01437076f, -0.14195396f, 0.18413071f, 
    0.20152460f, -0.52533704f, -0.26176721f, 0.00169016f, -0.27366933f, -0.27167282f, 0.02479532f, 0.07761753f, 
    -0.36312565f, 0.25001860f, 0.06584029f, -0.35962778f, 0.13029324f, -0.07544760f, -0.30168229f, -0.06632531f, 
    -0.16919161f, 0.12664512f, 0.04912239f, -0.01079790f, 0.02033547f, -0.19001460f, 0.32071987f, 0.12919544f, 
    -0.22995539f, -0.32433045f, -0.24158286f, 0.17145817f, -0.31450528f, 0.02481909f, 0.05603636f, 0.00731968f, 
    0.00610444f, 0.07786611f, -0.20567761f, -0.26368186f, -0.00813642f, -0.19080178f, -0.07153212f, -0.24980471f, 
    0.42458221f, -0.11988769f, 0.04501538f, -0.23644474f, 0.00228118f, -0.18106186f, 0.01541141f, -0.09882166f, 
    0.09357905f, 0.04374654f, 0.06810830f, -0.42033795f, -0.03793665f, 0.21106346f, -0.07110814f, -0.03656645f, 
    0.18601815f, -0.29583234f, 0.07839990f, -0.26752734f, -0.19671495f, 0.00130762f, 0.08328637f, -0.06951443f, 
    -0.30693364f, 0.23843111f, 0.18946049f, -0.16499612f, -0.02922892f, 0.04250241f, -0.09567136f, -0.03083955f, 
    0.10364485f, -0.12641212f, 0.03741579f, 0.11983477f, -0.05840530f, 0.18302819f, -0.17284891f, 0.18414687f, 
    0.34704429f, -0.10173592f, -0.04543912f, -0.17714173f, 0.15320949f, 0.22474808f, 0.04085856f, 0.01039624f, 
    -0.32219344f, 0.33789444f, -0.06092142f, -0.34105453f, -0.07620384f, -0.38089654f, 0.08108590f, -0.15664473f, 
    0.03343023f, -0.07838135f, 0.05733018f, -0.29340309f, -0.07302935f, 0.06548165f, 0.08683572f, -0.08198123f, 
    -0.06316141f, 0.06577752f, -0.08592930f, 0.16879541f, 0.17407240f, -0.05405501f, 0.17167580f, -0.11223982f, 
    -0.21549869f, -0.20865120f, -0.06574627f, -0.06662153f, -0.07917111f, -0.38902307f, -0.04818174f, -0.07273114f, 
    0.18020947f, -0.08602430f, -0.14274408f, -0.23611003f, 0.24283479f, 0.05580447f, -0.22905388f, 0.11002088f, 
    -0.15784620f, -0.00164304f, -0.10926100f, 0.00944398f, 0.05973238f, -0.21831492f, -0.01398150f, -0.08515113f, 
    -0.23132040f, 0.12984546f, 0.05866530f, 0.29733557f, -0.28541514f, -0.07052892f, 0.09576613f, 0.06875402f, 
    -0.41158375f, -0.00903605f, -0.02904573f, 0.02847346f, -0.25526902f, -0.21966310f, 0.11264079f, -0.05948786f, 
    0.21834350f, 0.10569265f, -0.26736960f, -0.05087477f, 0.20006952f, -0.05847407f, 0.03467226f, -0.07777989f, 
    0.06600430f, 0.10186645f, -0.42353958f, -0.29006532f, -0.32441148f, -0.27222130f, -0.18953532f, 0.01474676f, 
    -0.29459915f, -0.39532903f, 0.29757243f, 0.21503669f, -0.04763243f, -0.02314643f, 0.05425741f, 0.01186583f, 
    0.03768973f, -0.05887958f, 0.37224904f, 0.09368401f, -0.09623434f, 0.10148780f, 0.06827417f, 0.00170388f, 
    0.16595522f, 0.00153523f, -0.17012702f, -0.29593292f, -0.05356632f, 0.01289534f, 0.03949035f, -0.52448177f, 
    -0.56397247f, -0.23876621f, 0.07531852f, -0.54847169f, -0.09006691f, -0.56459069f, 0.13925785f, 0.21070686f, 
    0.03584654f, -0.11926236f, 0.25990394f, -0.38468039f, -0.10135598f, 0.23073491f, 0.19044578f, -0.31763309f, 
    -0.25469667f, -0.16621231f, 0.10802701f, 0.12922339f, -0.05426069f, -0.41015837f, -0.20225841f, 0.06014499f, 
    0.10518075f, -0.29751515f, 0.00180155f, 0.05025958f, -0.41055381f, -0.40849477f, -0.03426294f, 0.13471954f, 
    -0.07369830f, 0.09360988f, 0.00683323f, -0.00348788f, 0.29946420f, -0.42537087f, -0.27122560f, 0.07518220f, 
    -0.30909783f, 0.03519866f, 0.03748757f, 0.09698223f, 0.25962672f, -0.04832854f, 0.17329183f, 0.01205788f, 
    -0.43248999f, -0.12398440f, -0.05211311f, -0.00636782f, 0.05558620f, -0.17586032f, -0.14277738f, -0.03810211f, 
    0.18456291f, 0.16565959f, -0.20734313f, 0.22305034f, 0.21910621f, -0.04278706f, 0.17034578f, -0.14038521f, 
    0.06573787f, 0.15014419f, -0.34703448f, -0.16584429f, 0.05902215f, -0.24829195f, -0.04055408f, -0.01143907f, 
    -0.14032042f, -0.34409446f, 0.00318994f, 0.08073003f, -0.20164452f, -0.08240340f, 0.12935144f, -0.03056965f, 
    0.10625048f, -0.34905896f, -0.08408903f, -0.09083187f, 0.14496844f, -0.19073062f, -0.31563833f, -0.03068873f, 
    0.06813955f, -0.05083941f, 0.28503066f, 0.17760459f, 0.13705787f, -0.03235427f, -0.31504565f, -0.36082307f, 
    0.01537299f, -0.20984983f, -0.20443499f, 0.12984879f, 0.33934852f, -0.27489376f, -0.20980515f, -0.13914335f, 
    -0.03245740f, 0.24630074f, -0.27822024f, -0.20715278f, 0.00827808f, -0.21667193f, -0.04531654f, -0.28385708f, 
    -0.16189875f, -0.08756597f, -0.33603084f, 0.02119084f, 0.04740358f, 0.16396704f, -0.11099120f, -0.48400202f, 
    -0.34182960f, 0.07513841f, -0.03427684f, 0.14234444f, 0.33622834f, 0.01704328f, 0.22619168f, 0.18690023f, 
    -0.03848280f, 0.04554485f, -0.03129354f, -0.07163323f, 0.00253179f, 0.24694924f, -0.19139314f, 0.11838480f, 
    -0.13889730f, 0.01452712f, -0.39288047f, -0.09755743f, 0.09618673f, -0.04878072f, 0.30386242f, 0.16812885f, 
    -0.02908538f, -0.14716779f, 0.13141149f, 0.26066715f, 0.04835522f, 0.26364070f, -0.11439025f, -0.01421540f, 
    -0.17195553f, 0.14503165f, -0.01391834f, 0.01716000f, 0.13577639f, 0.00930297f, -0.06369478f, 0.32539383f, 
    0.01836022f, -0.05973616f, -0.12262411f, -0.34371650f, 0.01296633f, 0.00665116f, 0.17758788f, 0.06853847f, 
    -0.04403155f, -0.09347786f, -0.08652122f, -0.02034393f, -0.49052784f, 0.08011285f, 0.15623268f, -0.12765282f, 
    -0.23140517f, 0.09664451f, -0.01982579f, -0.01620406f, -0.00882336f, -0.33564591f, 0.09302869f, -0.05799511f, 
    -0.18885043f, 0.16907024f, 0.02929088f, -0.32468823f, -0.26960948f, 0.02694836f, -0.26029408f, 0.05209458f, 
    -0.42953494f, -0.01539521f, 0.44177845f, 0.06357995f, -0.01241944f, 0.18571138f, 0.06803781f, 0.18945886f, 
    -0.49894086f, 0.20469394f, -0.00160895f, -0.09982772f, 0.22231096f, -0.04753550f, -0.39229071f, 0.07917657f, 
    0.10684776f, 0.07952785f, -0.08077704f, -0.05968535f, -0.14105025f, 0.00981735f, -0.00728891f, -0.11182858f, 
    0.27946377f, 0.04456971f, -0.36956102f, 0.11133686f, 0.03847240f, -0.00047148f, 0.00804629f, -0.30963862f, 
    -0.00503813f, 0.01803291f, 0.10431168f, -0.27809870f, 0.16862738f, 0.02489872f, -0.13219874f, -0.13057199f, 
    -0.07655505f, -0.21403857f, -0.46394756f, -0.07166601f, -0.08079442f, 0.17133263f, -0.00087495f, 0.23230352f, 
    -0.14770710f, 0.02517925f, -0.06677973f, 0.07887115f, 0.05416305f, 0.02451019f, 0.26977968f, 0.34175077f, 
    -0.23169313f, -0.06617163f, -0.33739215f, 0.04550523f, 0.14127064f, -0.06742899f, 0.14097232f, -0.36828789f, 
    -0.18923891f, -0.38861865f, -0.07045868f, 0.13644147f, 0.06330008f, -0.38416472f, 0.12680826f, -0.21215987f, 
    0.08220097f, 0.08839765f, 0.18622534f, -0.06638598f, -0.37130499f, -0.24406658f, -0.01653459f, -0.25293788f, 
    -0.42754328f, 0.34241700f, -0.00621140f, 0.12957720f, -0.47580439f, 0.14596048f, 0.39469799f, -0.05032795f, 
    0.11961710f, -0.35038704f, 0.00405136f, -0.15634792f, 0.11349868f, 0.10356543f, 0.02739119f, -0.45484817f, 
    -0.12239286f, 0.04675419f, -0.07592873f, 0.14024056f, -0.20409575f, 0.11205332f, 0.04145459f, -0.04390965f, 
    0.34634456f, -0.02752807f, -0.09485827f, -0.11537287f, 0.12288145f, -0.00979679f, -0.24227795f, -0.14192671f, 
    -0.36953625f, 0.27248490f, -0.03219761f, 0.10362958f, -0.00741458f, 0.22148003f, 0.00185238f, -0.04088844f, 
    0.20953655f, 0.17878941f, -0.37405863f, 0.19119534f, 0.15565977f, -0.55946606f, 0.01060268f, -0.07965204f, 
    0.31614339f, -0.79224843f, -0.32145482f, -0.11984667f, 0.12235225f, -0.56014043f, 0.04649276f, -0.26656535f, 
    0.16754656f, 0.02295576f, -0.06850380f, -0.02952333f, 0.16444993f, 0.02136153f, -0.04284179f, 0.06045868f, 
    0.21898746f, -0.48977029f, -0.00036043f, 0.02670020f, -0.09145299f, 0.17029989f, -0.27910423f, -0.24716291f, 
    0.00587924f, -0.46914944f, 0.00997198f, 0.03147583f, 0.30258983f, -0.04212212f, -0.20315091f, -0.35531020f, 
    0.20740665f, 0.07326168f, 0.11207663f, -0.31397396f, -0.21569560f, 0.19977804f, 0.23588017f, 0.04415678f, 
    -0.17543924f, -0.01518374f, 0.08183000f, 0.00202697f, 0.06282331f, 0.26662356f, 0.03672552f, 0.26421905f, 
    0.09511739f, -0.06975510f, 0.18384205f, -0.05838350f, -0.03396802f, -0.41736621f, 0.14040543f, -0.11050013f, 
    0.05537983f, -0.13866785f, -0.00902667f, -0.04746999f, -0.13728461f, -0.03762212f, -0.10453876f, 0.24541664f, 
    -0.34729832f, -0.26359144f, -0.02657615f, -0.30171531f, 0.04090483f, -0.02389796f, -0.35600802f, 0.12250106f, 
    0.14211957f, -0.20509173f, 0.04148695f, -0.37605926f, -0.09318233f, -0.15156858f, -0.39535898f, 0.07802293f, 
    -0.01072509f, 0.30717966f, 0.18426275f, -0.04385711f, -0.22209908f, -0.35943788f, 0.16828583f, 0.27428544f, 
    -0.21882318f, -0.31113389f, 0.02568094f, 0.27772510f, -0.19550467f, 0.23079760f, 0.03753716f, 0.11975436f, 
    0.19395612f, -0.04543121f, 0.03134805f, 0.15130600f, 0.09762135f, -0.07249252f, -0.10421360f, 0.02443627f, 
    -0.12606055f, -0.01780453f, 0.01471235f, 0.09110026f, -0.11865979f, -0.08637758f, -0.23782505f, 0.01043670f, 
    0.20301847f, -0.15108727f, 0.05892131f, -0.08528692f, 0.04580298f, 0.19422895f, -0.58565301f, -0.04806553f, 
    -0.07489273f, 0.13739286f, 0.21723267f, 0.06754003f, -0.30072093f, -0.11785247f, -0.17155132f, -0.27564725f, 
    0.02674746f, -0.05930136f, -0.27796447f, -0.20270015f, 0.06826261f, 0.00606071f, 0.02477473f, 0.16021669f, 
    0.46169028f, -0.26456505f, -0.03115438f, -0.40876368f, -0.18191908f, -0.03754256f, -0.18447594f, 0.04437618f, 
    -0.31792247f, 0.18617995f, -0.06441674f, -0.03145120f, 0.31802541f, -0.27216354f, -0.28891936f, -0.01772552f, 
    -0.28211835f, 0.37946445f, -0.05669956f, 0.11372150f, -0.32397351f, 0.06117832f, 0.21446335f, -0.51049513f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.13117106f, 0.12481275f, 0.10372601f, -0.06433915f, -0.07569160f, 0.04419016f, -0.01182358f, -0.08857813f, 
    -0.00428230f, 0.09530381f, 0.01156574f, 0.05222636f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
