#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.06602068f, -0.15441132f, -0.40664241f, -0.59722292f, 0.05453847f, 0.10296257f, 0.37590495f, -0.05301069f, 
    0.20822501f, -0.36103553f, -0.25771591f, -0.13746101f, -0.23396465f, -0.15303938f, 0.02174993f, -0.08726436f, 
    -0.04384023f, -0.25503898f, -0.03337220f, 0.20531476f, 0.13298991f, -0.24339275f, 0.41328490f, 0.12922275f, 
    0.29144275f, -0.55561793f, -0.12133374f, 0.39387873f, 0.58260155f, 0.17862928f, -0.04479593f, 0.43143702f, 
    -0.28968233f, -0.06895402f, -0.39120111f, -0.22128436f, -0.16922808f, 0.34391919f, -0.07030881f, 0.10859711f, 
    0.08660351f, -0.00041923f, 0.30577123f, -0.09729341f, -0.26596996f, -0.35985354f, -0.18118547f, -0.60508102f, 
    -0.17012461f, -0.17737366f, -0.08354127f, -0.31119794f, 0.34832162f, -0.18236350f, -0.29788586f, -0.50943530f, 
    -0.40295491f, -0.15726675f, 0.20865907f, -0.34305617f, -0.00616200f, -0.14243418f, -0.09789828f, -0.14672463f, 
    0.16757625f, 0.18903963f, 0.29590425f, 0.14201073f, 0.10983463f, -0.15731998f, 0.08071062f, 0.10667633f, 
    -0.31346282f, -0.13034618f, -0.13375686f, 0.04919810f, 0.36054704f, 0.09184770f, 0.25022051f, 0.60455137f, 
    -0.18818177f, -0.44259530f, -0.48403245f, -0.34478599f, -0.33416796f, -0.28420416f, 0.02225236f, 0.24927734f, 
    0.53478968f, -0.10163737f, 0.29214239f, -0.01851162f, 0.22209519f, -0.00266809f, -0.18020971f, -0.35193345f, 
    -0.07372758f, -0.07936008f, 0.13081630f, 0.13904575f, -0.21251598f, -0.40124723f, -0.60187125f, -0.61597443f, 
    -0.34584782f, -0.15084165f, 0.40117732f, 0.55782193f, -0.12399406f, 0.46238017f, 0.19737564f, 0.01328645f, 
    -0.23659167f, -0.29397506f, 0.27274841f, 0.12774692f, -0.16170980f, -0.06381003f, 0.11122210f, 0.07327576f, 
    -0.01017040f, -0.03990501f, 0.13155521f, 0.07855397f, 0.16917764f, -0.62801504f, -0.32366034f, 0.19281356f, 
    -0.09391989f, 0.15057905f, -0.25907525f, 0.10766296f, -0.32969046f, 0.21220167f, 0.02220754f, 0.61725706f, 
    -0.04286489f, -0.38302961f, 0.14199844f, -0.11638477f, -0.20794165f, 0.38489982f, 0.30331826f, -0.32946444f, 
    -0.39238891f, -0.20244190f, -0.12067758f, 0.06142095f, 0.27372515f, 0.14333108f, -0.69341367f, -0.06386115f, 
    0.51183945f, -0.04780231f, -0.22727989f, 0.64899063f, 0.58791161f, 0.22979277f, -0.44505316f, -0.21050294f, 
    -0.19454180f, -0.17392266f, -0.17226301f, -0.04575528f, -0.08402295f, 0.30177191f, 0.00522435f, 0.14780892f, 
    -0.22525635f, -0.00466620f, -0.26467994f, 0.08401763f, 0.17848815f, 0.08754132f, -0.06053523f, -0.13102163f, 
    -0.69685161f, -0.46915811f, 0.23380220f, -0.07483052f, -0.11258925f, -0.26289696f, -0.08078045f, 0.50309134f, 
    -0.03464220f, 0.03931253f, 0.21266545f, 0.30676213f, 0.23333471f, -0.23424608f, 0.09479040f, -0.21396621f, 
    0.06105220f, -0.07320439f, -0.07396059f, 0.06510645f, -0.03274742f, -0.02342771f, 0.24732731f, 0.12536868f, 
    0.66973060f, -0.08715124f, -0.06681490f, 0.35636169f, 0.27230233f, 0.02951429f, 0.22137991f, -0.61108208f, 
    -0.07110576f, 0.22755553f, -0.07788697f, -0.06267946f, 0.27086031f, -0.20062546f, -0.01069148f, 0.04933902f, 
    0.31412190f, 0.26106638f, 0.09832772f, 0.29184255f, -0.12630619f, -0.24438424f, -0.06528243f, 0.10224558f, 
    0.22392926f, -0.52829492f, -0.50165319f, -0.05161890f, 0.43978834f, 0.29540193f, 0.59527242f, 0.36449581f, 
    -0.16014723f, 0.30634961f, -0.12789854f, 0.29084069f, 0.24261993f, -0.19314915f, 0.57696354f, 0.16162963f, 
    0.11472844f, 0.13527367f, 0.07766251f, -0.05560257f, 0.30223081f, -0.09722079f, -0.00973743f, -0.33887899f, 
    -0.19245629f, 0.19948454f, 0.59699470f, 0.61077505f, 0.54354233f, -0.40575340f, -0.36261639f, -0.30799943f, 
    -0.47288021f, 0.14000919f, 0.31163362f, -0.03277158f, -0.10557296f, 0.21033983f, 0.01396341f, -0.08956589f, 
    0.16993731f, -0.05016570f, -0.04416784f, 0.10489827f, -0.10228020f, 0.32484648f, 0.06219259f, -0.07222618f, 
    0.27199897f, 0.04912754f, 0.17631613f, -0.13207079f, -0.23459429f, 0.44293654f, -0.40096036f, -0.52861649f, 
    -0.26718724f, -0.24827741f, 0.34839121f, 0.17666791f, 0.03287353f, 0.38973066f, 0.30427194f, -0.27542984f, 
    0.22974560f, 0.34006432f, 0.27067980f, -0.24798100f, -0.11889367f, -0.20862487f, -0.43198076f, 0.20545487f, 
    -0.06358707f, -0.05477580f, -0.05214469f, 0.27397645f, 0.93206722f, 0.28487831f, -0.24992770f, 0.64972633f, 
    0.30560338f, -0.17986172f, -0.25078946f, 0.14540724f, 0.13711196f, 0.22296005f, 0.03257411f, 0.11775135f, 
    -0.16741237f, -0.07757419f, -0.27305889f, -0.09575273f, 0.07295061f, -0.16879070f, 0.23158897f, 0.20397371f, 
    0.09611102f, -0.15727048f, 0.05272989f, -0.55850810f, 0.30534574f, -0.36914271f, -0.53203475f, 0.00670099f, 
    -0.28545040f, -0.38246015f, 0.29481521f, -0.57812649f, -0.01574501f, 0.08925086f, -0.21638055f, -0.29665390f, 
    -0.06340770f, -0.20143777f, -0.00116357f, 0.15146424f, 0.24750590f, 0.17952316f, 0.01091880f, -0.17688741f, 
    0.30596152f, -0.18837218f, 0.13002051f, 0.41225109f, 0.26372913f, -0.04553727f, 0.41296303f, -0.18600497f, 
    -0.41936201f, -0.09941529f, -0.16369426f, -0.73842341f, -0.89187503f, -0.50925004f, 0.24483635f, -0.27350163f, 
    0.00407905f, -0.25717759f, -0.05214835f, -0.13914990f, -0.38177380f, 0.06839273f, -0.02140374f, 0.04303043f, 
    -0.10939890f, 0.05371871f, 0.14493923f, 0.15198614f, 0.23833235f, 0.20808601f, 0.16261613f, 0.38737920f, 
    -0.30774733f, 0.05090705f, 0.10891192f, 0.46188059f, 0.04156166f, 0.05541203f, 0.12852155f, 0.29721147f, 
    0.51070333f, -0.14593089f, -0.21893242f, 0.09025235f, -0.38114357f, 0.05304027f, -0.06061252f, -0.18711527f, 
    -0.14497188f, 0.37260947f, 0.11413088f, 0.29486525f, 0.51332414f, 0.29568356f, 0.15331474f, -0.16227360f, 
    0.87278557f, -0.58608639f, -0.49360546f, 0.07790204f, 0.42634615f, 0.66595829f, 0.11232284f, -0.18904707f, 
    -0.10166966f, -0.08956345f, 0.11067217f, -0.07298786f, -0.32976097f, 0.09323376f, 0.00338799f, 0.11009136f, 
    0.23029229f, -0.08604521f, -0.10078902f, 0.05594647f, -0.00040478f, -0.07786781f, 0.00234928f, 0.06444786f, 
    -0.03409445f, 0.19140580f, -0.28458402f, -0.05315972f, 0.12163866f, 0.20602472f, -0.23948093f, -0.33775362f, 
    0.02656479f, 0.16014083f, -0.46954441f, 0.03445499f, -0.20300074f, 0.24953569f, -0.13164644f, -0.44526330f, 
    0.22961093f, 0.12117440f, 0.11560253f, 0.11514711f, -0.34586352f, -0.34386334f, -0.19846457f, -0.30467135f, 
    0.16115370f, -0.13429755f, 0.21454890f, 0.24891007f, -0.35268402f, -0.77880967f, 0.33133498f, -0.33104026f, 
    0.03403624f, 0.56779158f, -0.07535343f, -0.07419544f, -0.11559305f, -0.18140791f, 0.06025508f, -0.21258418f, 
    -0.19435263f, 0.24606617f, 0.13045967f, 0.10743331f, 0.11197985f, 0.21072987f, -0.23635474f, -0.01381872f, 
    -0.09216695f, -0.29904997f, 0.19213587f, 0.17184976f, 0.45891413f, 0.43704364f, 0.58010316f, -0.08624018f, 
    -0.23527576f, 0.25798547f, -0.03584402f, 0.24520126f, 0.02905034f, -0.21717399f, -0.04287360f, 0.30651549f, 
    0.09337863f, 0.09078156f, 0.00362673f, -0.17147413f, 0.19554141f, 0.03710958f, -0.28983727f, 0.21246514f, 
    -0.25952309f, -0.33599353f, -0.20325978f, -0.25988999f, -0.82191300f, 0.83339220f, 0.11007376f, -0.62312168f, 
    0.39850858f, 0.11733267f, 0.30506635f, -0.12308137f, -0.48409563f, -0.05927772f, 0.12954099f, -0.12689662f, 
    0.03584236f, 0.11662949f, 0.23247138f, 0.04593141f, 0.09809335f, -0.01218286f, 0.13311459f, 0.13531932f, 
    0.16980584f, 0.14521395f, 0.08953287f, 0.19487970f, 0.26700592f, -0.11162165f, -0.45103627f, 0.11951321f, 
    -0.15456884f, -0.38881928f, -0.01343536f, -0.19071338f, 0.20752898f, 0.08710561f, -0.02257420f, -0.04219723f, 
    0.05308734f, -0.14809456f, -0.18494721f, -0.15838385f, -0.33864948f, 0.26792982f, 0.11503144f, -0.20296362f, 
    -0.11352356f, 0.33920485f, 0.60832590f, -0.44733265f, -0.01794913f, -0.22117886f, 0.40520573f, 0.41213757f, 
    0.36300406f, 0.53194195f, 0.13420545f, -0.59072214f, 0.25815731f, -0.16839257f, 0.32546163f, 0.29791155f, 
    0.21256034f, 0.07505892f, -0.12775569f, 0.10471524f, -0.37972325f, -0.16272816f, 0.06879289f, 0.17673331f, 
    0.15012962f, -0.14684506f, -0.26285103f, 0.22425456f, 0.18124260f, 0.04804740f, -0.14925832f, -0.36344659f, 
    -0.55901641f, -0.54486388f, -0.34075844f, -0.08320832f, -0.22742100f, 0.46306664f, -0.32746395f, -0.32354838f, 
    0.37136546f, 0.24944748f, 0.09124248f, 0.12521355f, 0.05193592f, 0.21182936f, 0.03445512f, 0.19654937f, 
    0.21481599f, 0.26110345f, -0.18022904f, 0.28867525f, -0.13969624f, 0.26714954f, -0.11548499f, -0.11163183f, 
    -0.05708984f, 0.35080147f, -0.34880674f, -0.65167224f, -0.48965365f, 0.28858808f, -0.42388168f, -0.06335816f, 
    0.60020626f, -0.03156629f, -0.38694805f, 0.00942456f, -0.13224021f, 0.08449004f, 0.02926332f, 0.24131121f, 
    0.20680271f, -0.24719593f, -0.10375109f, 0.13476905f, -0.20612158f, 0.00283129f, 0.20540999f, -0.08343396f, 
    0.07366992f, -0.03068440f, 0.53556979f, 0.26565647f, 0.08718156f, 0.12866376f, -0.84134519f, -0.02575387f, 
    -0.55562919f, -0.29194456f, -0.20676361f, 0.32690671f, -0.15542264f, 0.16411856f, 0.19750646f, -0.18226629f, 
    0.03515757f, 0.07647039f, -0.03733700f, 0.06365366f, -0.38518566f, 0.30858782f, -0.12488347f, 0.16337979f, 
    0.05565019f, 0.06053560f, 0.11279062f, 0.27855137f, 0.54170299f, 0.48735085f, 0.23827124f, 0.53829825f, 
    0.30637217f, -0.37276611f, 0.01230211f, -0.48433587f, 0.18660823f, 0.13095938f, -0.11993672f, -0.03550284f, 
    -0.08091793f, 0.47339967f, 0.05350070f, -0.31465259f, -0.04663283f, -0.22663097f, -0.02852306f, -0.08768485f, 
    -0.23717788f, -0.01639076f, 0.23703890f, 0.86627179f, -0.27899945f, -0.18307169f, 0.13067983f, 0.41976443f, 
    0.28611222f, 0.23684897f, -0.15486167f, -0.08760847f, -0.41928977f, 0.05512509f, 0.06567077f, -0.18909957f, 
    0.10038321f, 0.37095949f, -0.17368281f, -0.13970597f, -0.30728710f, 0.21351908f, 0.01331888f, -0.03129424f, 
    0.39500985f, 0.07555305f, -0.18743721f, -0.20615247f, -0.09787351f, -0.45586562f, -0.47280788f, -0.26577291f, 
    0.00108629f, -0.52580988f, 0.60791445f, -0.20330229f, -0.46416035f, 0.34186265f, -0.20352280f, 0.21726318f, 
    0.10228482f, -0.02029478f, 0.26118016f, -0.21952309f, 0.39828745f, 0.48448670f, -0.07245660f, 0.08610287f, 
    0.28759196f, -0.00492296f, -0.29926857f, 0.01997572f, -0.25455114f, -0.13087364f, 0.65569472f, 0.57841033f, 
    -0.47577876f, -0.15796769f, 0.31656563f, -0.22623184f, -0.32754391f, -0.57958841f, -0.02607365f, 0.04286003f, 
    0.38057706f, 0.07193234f, 0.13741083f, -0.01015089f, -0.02184157f, 0.18818504f, 0.12247021f, 0.18033269f, 
    0.40577042f, 0.09758062f, 0.12450967f, -0.10765398f, -0.22504748f, 0.25208497f, -0.37218300f, -0.28291345f, 
    -0.29930544f, -0.52633876f, -0.22531410f, 0.35438576f, -0.35238898f, 0.06856285f, -0.08645874f, 0.41392902f, 
    0.14100423f, -0.16300488f, 0.10894633f, -0.20525719f, -0.01624091f, 0.22310174f, 0.22119197f, -0.00934711f, 
    0.15818852f, 0.39646387f, 0.17429784f, -0.26496798f, -0.31916323f, -0.35262185f, 0.19781293f, -0.45843503f, 
    -0.77743936f, -0.60598511f, -0.17453752f, -0.17042284f, 0.07318155f, -0.03954342f, -0.00709964f, 0.53016567f, 
    0.37225759f, 0.35745806f, -0.09021756f, -0.08834926f, 0.11386491f, 0.26317903f, -0.03983510f, 0.15995748f, 
    -0.19527179f, 0.17027971f, -0.13180941f, 0.05523583f, -0.42061713f, -0.01136611f, 0.08656697f, 0.03569251f, 
    0.70422798f, -0.00685024f, 0.17235239f, 0.74000967f, 0.32268229f, -0.30854809f, -0.25004947f, 0.28950760f, 
    -0.52352428f, -0.42226788f, -0.15370527f, -0.15600348f, -0.49166778f, -0.16529173f, -0.08237858f, 0.03374512f, 
    -0.01216587f, 0.23147251f, -0.02069882f, -0.17157033f, 0.08230826f, 0.14088678f, 0.15710995f, 0.11150719f, 
    0.17164308f, 0.13482998f, -0.87314755f, -0.76650107f, 0.39706489f, 0.18618293f, -0.76895291f, 0.38910189f, 
    -0.13497226f, 0.19592483f, -0.20097071f, 0.10672726f, -0.11043769f, 0.17276396f, 0.14207737f, 0.16160803f, 
    -0.12108265f, -0.05319837f, -0.18669769f, -0.10356708f, 0.01521279f, 0.01071324f, 0.02060991f, 0.08301564f, 
    0.09012806f, 0.21073227f, -0.56121010f, -0.77406865f, -0.16414925f, -0.01283617f, 0.56956917f, 0.31261471f, 
    0.51053357f, -0.26738498f, -0.09910137f, -0.34263879f, -0.06440932f, -0.04421666f, 0.10976372f, 0.26439393f, 
    0.03886117f, -0.09097937f, 0.05093913f, -0.36973608f, -0.06903240f, 0.26376778f, 0.05150139f, 0.21449372f, 
    0.02166142f, 0.35508901f, -0.19955742f, -1.12273836f, 0.25201741f, 0.30587155f, 0.08192343f, -0.09091224f, 
    0.17973241f, 0.91080630f, 0.13819739f, 0.40137383f, 0.51944041f, -0.28874752f, -0.07331840f, 0.25597832f, 
    -0.28477281f, -0.19805440f, 0.16413833f, -0.06816384f, -0.01364769f, -0.12328524f, -0.09393606f, -0.06578286f, 
    0.05936708f, -0.21955597f, -0.19270107f, -0.03311691f, -0.47904277f, 0.25035176f, 0.84972364f, 0.47129244f, 
    -0.24737595f, -0.18045449f, -0.51861817f, -0.19820882f, -0.45089039f, -0.39824662f, 0.49510419f, -0.13400199f, 
    0.14244331f, 0.16980366f, -0.16540322f, -0.41208267f, -0.00337759f, -0.32444122f, 0.03566055f, 0.09457163f, 
    -0.09244083f, 0.11528282f, -0.01181985f, 0.00137574f, 0.07630616f, 0.41536495f, 0.28191566f, 0.40157229f, 
    0.66266704f, 0.22776711f, -0.16427550f, 0.45527241f, 0.23314607f, 0.31872731f, 0.04981310f, -0.47092679f, 
    -0.33716089f, -0.02406010f, 0.05478756f, -0.14063768f, -0.11903080f, -0.24530765f, -0.21176988f, -0.15059732f, 
    0.09614048f, -0.32579610f, 0.21333249f, -0.06939616f, 0.23423195f, 0.01806270f, -0.04264573f, 0.08286821f, 
    -0.15161887f, 0.30657876f, -0.04884920f, -0.09412464f, -0.40216494f, -0.22760938f, -0.07652284f, -0.19963184f, 
    -0.53052658f, 0.39200225f, 0.23349118f, -0.29241154f, -0.32749298f, -0.00485419f, -0.20552687f, -0.09654831f, 
    0.29871723f, -0.00447210f, 0.14783515f, -0.07357808f, -0.06643888f, -0.12940530f, -0.30077824f, -0.61819345f, 
    -0.37165847f, -0.40990952f, 0.33460891f, 0.39564621f, -0.49237955f, 0.60619771f, 0.47990817f, -0.52327394f, 
    0.31271717f, 0.33830878f, 0.02711384f, 0.19498061f, -0.02571446f, 0.28010169f, -0.28952235f, 0.00672534f, 
    -0.04649070f, -0.17250349f, 0.11211050f, 0.02911810f, 0.26557499f, -0.10621942f, 0.03488277f, -0.10755610f, 
    0.76877767f, 0.05648281f, -0.46645516f, -0.66037613f, -0.13857372f, 0.35725874f, -0.28856564f, -0.32490298f, 
    -0.03821551f, 0.00935256f, -0.45557433f, -0.15389651f, 0.31552109f, -0.14361882f, -0.25683525f, -0.22320704f, 
    0.11883953f, 0.02185929f, 0.20864506f, -0.29268393f, 0.06574193f, 0.19627675f, -0.03723437f, -0.16604745f, 
    0.26593900f, 0.16415675f, 0.15086173f, -0.07108234f, -0.05454088f, 0.62054342f, -0.57278734f, -0.73476881f, 
    -0.46965593f, -0.58535588f, 0.26349226f, 0.18515871f, 0.47616008f, -0.31727126f, -0.06115614f, 0.12115089f, 
    0.12992622f, -0.33334634f, 0.08868195f, 0.15699774f, 0.20868342f, 0.24572778f, -0.03447210f, -0.10710192f, 
    -0.12619814f, 0.07979687f, -0.18325080f, 0.46435431f, -0.04104312f, -0.65447849f, 0.33584476f, 0.10929542f, 
    0.38811716f, 0.28010565f, -0.03769714f, 0.43928441f, -0.12402854f, 0.11296086f, 0.35635230f, 0.22501101f, 
    0.32082331f, -0.33845830f, -0.35729539f, -0.06366639f, -0.12361860f, 0.15358050f, 0.15937801f, -0.35061991f, 
    0.12242811f, 0.01859331f, -0.12773570f, 0.67602980f, 0.27894518f, 0.55214691f, 0.12922715f, -0.26921737f, 
    -0.28697863f, 0.33217037f, -0.46170375f, 0.00112641f, 0.04109473f, -0.05412729f, 0.06165906f, 0.15637514f, 
    0.12949452f, 0.16226296f, 0.19674444f, -0.00221876f, -0.09185893f, 0.25689793f, -0.03291052f, 0.04494958f, 
    0.01452166f, 0.21678606f, -0.26934651f, 0.13653079f, -0.33900586f, -0.25847319f, -0.40726778f, -0.07806676f, 
    0.28680068f, 0.57296121f, 0.41592121f, 0.25568068f, -0.29439080f, 0.44771352f, -0.06617531f, -0.42183125f, 
    0.20598604f, 0.13131526f, -0.24158357f, -0.39072382f, 0.03520456f, -0.40879002f, -0.06979938f, -0.34871238f, 
    0.09870323f, -0.29348132f, 0.01846967f, -0.01799879f, -0.32988486f, -0.20492266f, 0.17162317f, 0.31699339f, 
    -0.57413530f, -0.22128800f, 0.43959242f, -0.19542255f, -0.47852552f, -0.06921425f, 0.23683128f, -0.02413839f, 
    -0.32196593f, -0.29112896f, 0.12937696f, 0.03378458f, -0.23743723f, -0.32947946f, -0.06153969f, -0.20557706f, 
    0.27397195f, -0.35141912f, 0.11460831f, -0.26162988f, -0.24886924f, -0.40239289f, 0.68140399f, 0.44566533f, 
    -0.54590780f, 0.55805898f, -0.31957105f, -0.27978051f, 0.31470791f, 0.26428035f, 0.27962124f, -0.21664420f, 
    0.28994265f, -0.23999199f, -0.21345241f, 0.01962984f, -0.07729945f, 0.06205131f, -0.04361209f, 0.19464627f, 
    -0.06897427f, 0.13183412f, -0.06646556f, -0.23053266f, -0.01387840f, -0.18627605f, -0.17243046f, 0.70066798f, 
    0.00899555f, -0.10137133f, 0.23785023f, 0.18304726f, 0.18710546f, 0.18284330f, 0.17577882f, 0.10443228f, 
    0.49297571f, -0.52571952f, 0.02201753f, 0.15299122f, -0.24302250f, 0.30923533f, -0.27938482f, -0.28066358f, 
    0.04455078f, -0.05243557f, -0.23679557f, 0.17813842f, 0.14215676f, 0.00987383f, 0.20166098f, -0.11261490f, 
    -0.37654632f, -0.49727252f, -0.48012936f, -0.36747244f, -0.27846840f, 0.30546710f, 0.47560853f, 0.25076067f, 
    0.06454010f, 0.43405554f, -0.24192099f, 0.14358920f, -0.05583703f, 0.04989677f, -0.13010740f, -0.27754658f, 
    0.06253115f, 0.05429481f, 0.19004206f, -0.43454638f, -0.10351752f, -0.07196604f, 0.07215001f, -0.05838577f, 
    0.28683022f, 0.44929671f, 0.57946140f, 0.45757756f, 0.10718413f, -0.11333447f, -0.42305651f, 0.49217197f, 
    -0.19813429f, -0.56984568f, -0.04483905f, 0.37427375f, 0.21454944f, -0.12935030f, 0.03109251f, 0.03688369f, 
    -0.16678856f, 0.05199762f, 0.06371867f, 0.09185001f, -0.37405479f, 0.31313211f, -0.04749243f, 0.04455261f, 
    0.14884275f, 0.15440165f, -0.32555416f, -0.20830230f, -0.48202261f, -0.25185779f, 0.25982997f, 0.41718307f, 
    0.59135115f, 0.45193645f, 0.32756937f, 0.09714767f, 0.20096689f, -0.39820713f, 0.16886815f, -0.00586341f, 
    0.46052194f, 0.10006924f, -0.16815495f, -0.25826365f, 0.25970450f, -0.02038124f, -0.08821212f, -0.22935203f, 
    -0.30621272f, -0.05126277f, -0.07324364f, 0.38638702f, 0.37268996f, -0.04673372f, -0.14244384f, -0.58726501f, 
    0.40798596f, 0.51444507f, -0.13242100f, 0.42920521f, 0.69705629f, -0.10929228f, -0.54415184f, -0.16018112f, 
    -0.35698241f, -0.03261348f, -0.03020746f, 0.47688916f, 0.13156208f, 0.17632428f, -0.12727161f, -0.00831162f, 
    -0.07057521f, -0.06260575f, 0.06201740f, 0.34207064f, 0.70289528f, 0.67004979f, -0.38360104f, -0.50906360f, 
    -0.88243496f, 0.22889316f, 0.09747370f, 0.07924307f, -0.14744322f, 0.13020191f, 0.26278988f, 0.37984270f, 
    -0.01550944f, -0.04357557f, -0.04881025f, 0.13242169f, -0.29267907f, 0.19361436f, 0.09512080f, 0.08205292f, 
    0.18689512f, -0.05006081f, -0.17550486f, 0.09452614f, 0.18115112f, 0.25232303f, 0.18314591f, -0.44451529f, 
    -0.40338153f, -0.20842175f, 0.02535233f, -0.14939828f, -0.77067912f, -0.31475028f, -0.19056275f, 0.33875510f, 
    0.55720770f, 0.32778084f, 0.16786204f, 0.28736877f, -0.10068232f, -0.12316609f, 0.13948475f, -0.14482121f, 
    -0.06850539f, 0.26045710f, 0.30479601f, 0.26975554f, 0.03544287f, -0.03868902f, 0.57558131f, 0.12167256f, 
    -0.52441788f, -0.40061322f, -0.45061871f, 0.37104774f, 0.45514962f, 0.01085855f, -0.25587937f, 0.02316293f, 
    0.09295692f, -0.27556396f, -0.08396292f, -0.18294880f, -0.14014338f, -0.30912033f, 0.08968744f, -0.35543612f, 
    -0.06006777f, 0.06347367f, -0.01275602f, -0.34246504f, -0.19838212f, -0.22698648f, -0.06673269f, 0.60268378f, 
    0.01387034f, 0.29908657f, 0.72232616f, -0.17067835f, 0.11816148f, -0.08269597f, 0.01694572f, 0.07692070f, 
    0.45613545f, -0.11613216f, 0.15187325f, 0.09078098f, 0.13002792f, -0.27937174f, -0.27725166f, 0.22707932f, 
    0.12492108f, -0.23049952f, 0.08070158f, 0.31808177f, -0.35505340f, -0.13663326f, -0.17982565f, -0.10398354f, 
    0.16843042f, 0.23564892f, -0.13988434f, -0.04935575f, 0.33503211f, -0.39635220f, -0.01935839f, -0.02022338f, 
    0.38126147f, 0.05177281f, 0.40473849f, 0.16516800f, -0.42701244f, -0.02566800f, -0.06107469f, 0.09427685f, 
    0.09060328f, 0.11052330f, -0.06375295f, 0.43700817f, 0.36372617f, 0.25520474f, -0.14100383f, -0.12733349f, 
    0.48267391f, -0.77735811f, 0.15746716f, 0.57104123f, 0.78169507f, -0.36625874f, -0.10533381f, 0.15346089f, 
    0.27844414f, 0.39322209f, -0.33657250f, -0.12461262f, -0.09348717f, 0.06147979f, 0.20060283f, -0.01823069f, 
    -0.15644175f, 0.11197752f, -0.17824300f, -0.40809044f, -0.04193866f, 0.34403771f, 0.30777746f, 0.25687730f, 
    -0.12631564f, -0.20779790f, 0.03124619f, 0.54133391f, -0.42911798f, -0.44873178f, -0.19561784f, 0.06492264f, 
    -0.58112752f, -0.32376423f, 0.02388664f, -0.34289122f, -0.21891314f, -0.41979110f, 0.28371352f, 0.28112751f, 
    0.19705680f, -0.02785442f, -0.31654155f, 0.25742501f, -0.13128358f, 0.09378570f, 0.12061162f, 0.03181081f, 
    -0.21348616f, 0.10832508f, -0.24350743f, 0.44844243f, 0.10383042f, 0.47113848f, 0.77819675f, 0.17275955f, 
    0.42821109f, 0.41792861f, -0.12882850f, 0.18366298f, 0.15544865f, -0.16171522f, 0.15435065f, -0.18382186f, 
    -0.04544111f, -0.28216946f, 0.24597155f, -0.00426594f, 0.28262246f, -0.12181026f, -0.06760681f, 0.12089313f, 
    0.38168368f, 0.20269121f, 0.11061456f, 0.07016963f, 0.35760140f, 0.18381095f, 0.60623163f, 0.31781259f, 
    0.45820624f, 0.28589147f, -0.28240812f, -0.28429568f, -0.37110147f, -0.13511263f, 0.28957042f, -0.07443137f, 
    -0.06967203f, 0.09728815f, -0.07309388f, 0.32199273f, 0.41515574f, -0.10381185f, 0.07758772f, 0.20673861f, 
    0.17832610f, 0.09860306f, 0.18143478f, 0.31369761f, 0.34033999f, -0.57687920f, 0.50057852f, -0.50364321f, 
    -0.28876469f, 0.19189543f, 0.16447335f, 0.76628304f, 0.07133243f, 0.44551513f, 0.40957558f, 0.26701009f, 
    -0.22430095f, 0.14697613f, -0.43200088f, -0.29819259f, 0.15492135f, -0.07497618f, 0.08611758f, 0.08041359f, 
    -0.27839789f, -0.06785212f, -0.02529346f, -0.17128409f, -0.03804534f, 0.12906761f, -0.30328575f, 0.66265947f, 
    0.44439945f, 0.31427890f, -0.31203249f, 0.25019562f, -0.20150934f, 0.24673016f, 0.12641160f, 0.17373955f, 
    0.18386790f, -0.52327079f, 0.21316436f, -0.19921562f, -0.01414313f, -0.41892818f, -0.41456488f, -0.15573563f, 
    -0.27840897f, -0.22815001f, -0.14604497f, 0.02015071f, 0.17696650f, 0.10504408f, -0.02955157f, 0.43909767f, 
    0.18446778f, 0.68577743f, 0.30395925f, 0.39550334f, 0.13717180f, 0.16760111f, 0.21450093f, -0.26007465f, 
    0.34666628f, -0.13510430f, -0.01853361f, -0.03991066f, 0.24448317f, 0.32795262f, -0.32580176f, -0.28792775f, 
    0.04187022f, 0.03511908f, -0.16251515f, -0.34161565f, 0.07436007f, -0.36453724f, -0.04202330f, 0.10752934f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.02334647f, -0.05143377f, 0.25061348f, 0.15805550f, -0.01710213f, 0.07160916f, -0.11539821f, 0.31414816f, 
    0.01881126f, -0.03619357f, 0.08120257f, 0.18372656f, 0.07129227f, -0.06720427f, 0.06269376f, 0.08687111f, 
    0.11956494f, -0.04317431f, 0.13348441f, -0.03016353f, 0.29654890f, 0.19003765f, -0.12908958f, 0.27863517f, 
    0.10451737f, 0.18860823f, 0.08341620f, 0.11350412f, 0.10343990f, 0.14539118f, 0.04137475f, 0.15380247f, 
    -0.04802109f, 0.15114081f, 0.28110844f, 0.06386846f, 0.02359368f, 0.20763049f, -0.11475989f, -0.03335015f, 
    0.13729376f, 0.30233943f, 0.06572812f, 0.12255365f, 0.22815098f, -0.09562160f, -0.04546767f, -0.07698584f, 
    0.09330796f, 0.11376455f, 0.02186278f, 0.09149658f, 0.02164492f, 0.05067548f, 0.05268468f, 0.18539403f, 
    0.09484775f, 0.22690329f, 0.22571489f, 0.10708287f, 0.11877152f, 0.13191281f, 0.28294554f, -0.00004134f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.01867660f, -0.00607912f, -0.03427599f, -0.02498073f, -0.00404794f, -0.03614652f, -0.03275418f, 0.01501318f, 
    0.02898405f, 0.02834406f, -0.03432718f, -0.01968454f, -0.00725993f, 0.02101506f, -0.00835805f, -0.03142339f, 
    -0.04080977f, -0.02397064f, 0.02083748f, 0.00799197f, 0.00210758f, -0.03180074f, -0.02672162f, 0.02801995f, 
    -0.03499614f, 0.02313383f, 0.00625243f, -0.01924421f, -0.02079696f, 0.00181946f, -0.00252936f, -0.00234699f, 
    0.02261050f, -0.03783164f, 0.02796690f, -0.03208082f, -0.02153472f, -0.03791077f, -0.03475857f, -0.02257631f, 
    -0.03044430f, -0.01635109f, -0.03589609f, 0.02293837f, -0.00937321f, -0.02580951f, -0.03897157f, -0.04349601f, 
    -0.02003368f, 0.01640134f, -0.03116051f, 0.01263485f, 0.02547773f, -0.01069437f, 0.00372695f, -0.01937396f, 
    -0.02572498f, 0.00939118f, -0.00637513f, -0.03582470f, -0.01499343f, -0.02104986f, 0.01110381f, 0.02918879f, 
    0.01354863f, 0.02230056f, -0.01942229f, -0.01620420f, 0.00014810f, 0.01056022f, 0.00888274f, 0.02432226f, 
    0.01119014f, 0.02402312f, 0.02096603f, -0.02438438f, 0.01015656f, 0.00023368f, 0.02939029f, -0.00091983f, 
    -0.04104042f, -0.02243206f, 0.00882324f, -0.02877779f, 0.01893630f, -0.02733524f, -0.00205192f, -0.03285536f, 
    0.02358765f, -0.00297210f, -0.00251830f, -0.00806827f, 0.00921222f, 0.01452528f, -0.02958906f, 0.01009609f, 
    0.00658718f, -0.03293966f, -0.01403645f, 0.01968887f, -0.00805855f, -0.03725494f, 0.01469701f, -0.02799862f, 
    -0.01431902f, 0.03005253f, -0.00800404f, -0.03922374f, -0.02405383f, 0.00610136f, -0.02820310f, -0.02011151f, 
    -0.00924596f, 0.02588507f, -0.02290300f, -0.02283876f, -0.03031676f, -0.00695628f, 0.02685932f, -0.00937718f, 
    -0.02433751f, 0.02329102f, 0.00812298f, -0.00023245f, -0.03582233f, -0.02211514f, 0.00490224f, 0.02984848f, 
    -0.02127403f, 0.00426772f, 0.00596607f, -0.00301716f, -0.03360768f, -0.02935184f, -0.01042407f, -0.00518275f, 
    0.01671833f, -0.00995556f, -0.04082809f, -0.03127012f, 0.00896278f, -0.00403965f, 0.01072335f, -0.02093774f, 
    0.01256780f, -0.00961293f, 0.01141581f, -0.01043267f, -0.03711545f, -0.01445965f, 0.02578801f, -0.03457358f, 
    -0.00840134f, -0.03921691f, -0.02629582f, -0.03719525f, 0.02988776f, 0.02335540f, -0.01547690f, -0.00854351f, 
    0.01688317f, -0.03308558f, 0.00341238f, 0.00386004f, -0.03618794f, -0.02837075f, 0.00414251f, 0.02236452f, 
    -0.02606620f, 0.01270633f, 0.02011935f, 0.01331111f, -0.00351713f, 0.00014260f, 0.00705570f, 0.01565828f, 
    0.00471088f, 0.00724535f, -0.03961527f, 0.00689012f, 0.02855997f, -0.02152299f, 0.01895200f, -0.03298974f, 
    -0.01797249f, 0.01577154f, 0.02696262f, -0.01736054f, -0.03441489f, -0.01624330f, 0.01183509f, 0.02367575f, 
    -0.00263500f, 0.00597123f, 0.00736467f, -0.03489797f, 0.00748253f, -0.00341372f, -0.00622666f, -0.00529280f, 
    -0.03748758f, 0.02138080f, -0.01380327f, 0.00667902f, -0.00171684f, -0.03448932f, -0.00208581f, 0.03031882f, 
    0.00945592f, 0.00801497f, 0.01004550f, -0.02753783f, -0.01439272f, -0.00614778f, 0.00903539f, 0.01912110f, 
    -0.04277587f, -0.02390744f, 0.00709514f, 0.01296195f, 0.00189777f, 0.00245758f, -0.04245833f, 0.01671638f, 
    -0.01146856f, 0.00605182f, 0.01764968f, -0.03576195f, 0.00903339f, -0.03932542f, -0.00922159f, -0.03929317f, 
    -0.00667068f, -0.03875053f, -0.01640084f, -0.02183475f, 0.01299638f, -0.03076237f, -0.00814732f, -0.00352864f, 
    0.01878073f, -0.01490142f, 0.01461816f, 0.00601130f, -0.03921697f, 0.00870051f, 0.01410793f, -0.00516901f, 
    0.02844745f, 0.00019729f, -0.03871895f, -0.03394727f, -0.03410912f, -0.03246572f, 0.01647526f, 0.01669293f, 
    -0.02532574f, 0.01715632f, 0.02396006f, 0.02120037f, -0.03001164f, -0.03362145f, -0.01076119f, 0.02107080f, 
    -0.00308941f, -0.01794421f, 0.01925234f, -0.00307430f, 0.00137061f, 0.02274377f, -0.01895227f, -0.01567045f, 
    0.03466474f, -0.02107996f, -0.02262437f, -0.03093643f, 0.01792286f, -0.01154085f, -0.03648569f, -0.03030766f, 
    -0.01135016f, 0.02644549f, 0.01747042f, -0.00098800f, 0.02390282f, -0.00469415f, -0.00126194f, 0.01388698f, 
    -0.00518109f, -0.02597780f, 0.02351398f, 0.01774792f, 0.01992259f, 0.02570090f, -0.03881710f, 0.01282734f, 
    -0.02312074f, -0.02819506f, -0.00763440f, -0.04217764f, 0.00378384f, -0.00088221f, 0.02437671f, -0.01173527f, 
    -0.02092685f, -0.02480854f, -0.03422884f, 0.00812090f, -0.03687624f, 0.01961539f, -0.02883572f, -0.03064645f, 
    -0.03148863f, 0.01128308f, 0.01685766f, 0.02777328f, -0.00411185f, -0.02791486f, 0.00734695f, 0.01195072f, 
    0.00046912f, -0.01872973f, -0.03520594f, 0.01489994f, -0.02922273f, -0.00696370f, 0.00628332f, 0.02404370f, 
    0.02897490f, 0.02928110f, 0.00770427f, -0.01510490f, -0.02499183f, 0.00275300f, -0.03730527f, -0.02673680f, 
    -0.02834362f, 0.00015834f, -0.01580275f, -0.01537132f, -0.04050119f, 0.01915544f, 0.00350195f, 0.00234359f, 
    -0.03045718f, 0.01739028f, 0.00765363f, -0.01434551f, 0.01246254f, 0.00050787f, -0.00329822f, -0.01684851f, 
    0.00484180f, 0.02478997f, -0.01855024f, -0.00738692f, 0.01721221f, -0.01779790f, -0.03768127f, -0.02943930f, 
    0.00755669f, -0.02884323f, 0.01601345f, 0.01473134f, 0.02550407f, 0.00993740f, 0.01089472f, -0.00633816f, 
    0.02269573f, 0.01195978f, -0.03594637f, -0.00790676f, 0.00980400f, -0.02918909f, 0.00018115f, -0.03111119f, 
    -0.03306275f, -0.03460740f, -0.02654948f, 0.00822317f, 0.01232962f, -0.02078113f, 0.01748625f, 0.00885659f, 
    0.02354597f, -0.02805508f, 0.02354714f, -0.00958517f, 0.02183763f, 0.00491368f, 0.01899972f, -0.04330968f, 
    -0.01031490f, -0.02193591f, -0.03463919f, 0.00841314f, 0.02694653f, -0.03230023f, -0.00849997f, -0.02391022f, 
    -0.02361105f, 0.01899265f, -0.00948857f, 0.02687252f, -0.02703519f, 0.02652380f, -0.00619354f, 0.00666871f, 
    0.01223161f, 0.02946107f, -0.03267392f, -0.01515021f, -0.02641582f, 0.01102786f, -0.00187708f, 0.01426970f, 
    0.00819027f, -0.00860728f, -0.02897282f, 0.00072874f, 0.00389980f, -0.04071273f, 0.02808799f, 0.02811614f, 
    0.01964740f, 0.00116649f, 0.01730985f, -0.02375566f, -0.00703836f, -0.01545060f, -0.00819624f, 0.00118870f, 
    -0.00678586f, 0.00246446f, 0.02667951f, 0.00466817f, -0.01352851f, -0.00696478f, -0.01591274f, -0.04030081f, 
    -0.03550948f, -0.03450586f, -0.00952796f, 0.02166249f, 0.01127145f, -0.03587341f, -0.03583072f, -0.02005848f, 
    -0.03286477f, 0.01526503f, 0.02445682f, -0.00091296f, 0.02497972f, -0.02183627f, -0.03195214f, 0.00550692f, 
    0.00109675f, -0.00694022f, -0.00750913f, -0.01246894f, 0.01368863f, 0.02215461f, -0.02930788f, -0.02901265f, 
    -0.01874153f, 0.00589500f, 0.02435980f, -0.02620908f, -0.00635686f, -0.00147584f, 0.01559562f, -0.00550473f, 
    -0.04071655f, -0.01348812f, -0.01971657f, 0.01439259f, -0.01570822f, 0.01431431f, -0.02556196f, 0.02497578f, 
    -0.02141045f, -0.00219615f, 0.01869114f, 0.00251228f, -0.04125454f, -0.00342368f, 0.02063357f, 0.00939857f, 
    0.02130491f, 0.00419385f, -0.02317123f, 0.02407943f, -0.00027422f, -0.03431625f, -0.00723433f, -0.04323049f, 
    -0.03358376f, -0.03871302f, 0.01784296f, 0.00462464f, 0.02194799f, -0.03671464f, -0.00356683f, -0.00829466f, 
    -0.01359650f, 0.02927481f, -0.03898822f, 0.00147453f, 0.02033414f, -0.03496004f, -0.00132468f, -0.00026086f, 
    0.01703651f, -0.00930784f, -0.01241112f, -0.02426015f, 0.02678390f, -0.01139408f, 0.00743609f, 0.02744516f, 
    0.00596994f, -0.01031262f, -0.00612500f, -0.03114421f, -0.01548303f, -0.02046096f, -0.04227760f, -0.03817403f, 
    0.02858765f, 0.01786105f, -0.00137934f, 0.00635516f, -0.00075279f, -0.03781946f, -0.02271472f, -0.01730021f, 
    -0.00851445f, -0.03670597f, 0.01718099f, -0.02619142f, -0.04126713f, -0.01603295f, 0.02702568f, -0.02939318f, 
    0.01654321f, 0.02541769f, 0.00430993f, 0.01365746f, 0.00811358f, -0.03043169f, -0.02279451f, -0.01013996f, 
    -0.03810352f, -0.02531115f, -0.03341879f, -0.01866090f, -0.02994922f, 0.00146892f, -0.01262503f, -0.03938325f, 
    -0.00399375f, -0.01610860f, 0.02777772f, 0.03333303f, 0.02445305f, 0.00918144f, -0.01410293f, -0.03471928f, 
    -0.01010078f, -0.01075239f, -0.00728428f, -0.01646848f, 0.00405902f, -0.00638345f, 0.02510730f, -0.02650981f, 
    -0.00264640f, 0.02357959f, 0.01219655f, 0.00369979f, -0.01911709f, -0.03872633f, -0.01652247f, -0.01545114f, 
    -0.01887948f, -0.00404221f, -0.02362382f, -0.04203487f, 0.01876525f, -0.01189358f, 0.00782333f, -0.02180128f, 
    -0.01839978f, -0.03570303f, -0.04075790f, -0.01987568f, 0.00552060f, -0.02642269f, 0.01687277f, 0.00201108f, 
    -0.00851989f, 0.01043679f, 0.02305161f, -0.02672191f, -0.01153301f, 0.02738797f, -0.04165163f, 0.00026704f, 
    0.02087159f, -0.00626978f, -0.03158562f, 0.02694957f, -0.01542118f, -0.00747322f, 0.00454614f, 0.02319272f, 
    0.02531768f, -0.02045614f, -0.00923587f, 0.00174933f, 0.01286073f, -0.01144311f, -0.02401728f, -0.03535309f, 
    0.02863399f, -0.00032398f, -0.03712601f, 0.01757582f, 0.01754607f, -0.01822728f, -0.00413264f, -0.03629730f, 
    0.00464194f, -0.03657506f, -0.02937230f, -0.01403973f, -0.03961650f, -0.02687812f, 0.01294096f, -0.01736606f, 
    -0.03047009f, -0.00221213f, 0.00029242f, -0.01263268f, -0.01280687f, -0.03434813f, -0.01577474f, -0.00331035f, 
    0.01010927f, 0.00940777f, -0.02450628f, -0.00148118f, -0.04217674f, -0.03741141f, -0.00701950f, -0.01921384f, 
    -0.03388261f, -0.02577874f, 0.02614140f, 0.01686499f, -0.02642383f, -0.02977138f, 0.02753769f, 0.00979396f, 
    -0.01238709f, 0.00357843f, 0.01226094f, 0.01568503f, -0.02766864f, 0.01165935f, 0.00140695f, -0.01329610f, 
    -0.03851532f, 0.00345373f, -0.03881662f, 0.02681934f, 0.03837651f, 0.01191849f, -0.01472588f, -0.03068674f, 
    0.02352156f, -0.01571710f, -0.02786811f, 0.01093366f, -0.01525622f, -0.04088478f, -0.04157260f, 0.00883607f, 
    0.00686812f, 0.01971848f, 0.00787897f, -0.02490148f, -0.02801785f, -0.00501840f, -0.01992596f, -0.03286895f, 
    -0.03620054f, -0.02815771f, 0.02377785f, 0.01325947f, -0.02490017f, 0.00239288f, 0.01910442f, -0.02638091f, 
    0.02513666f, 0.01379581f, 0.00615536f, 0.00879447f, 0.00897461f, -0.00649889f, -0.02056052f, -0.02923089f, 
    -0.03013636f, 0.01132186f, 0.00323925f, 0.02591121f, -0.02918583f, -0.03020206f, 0.01227327f, 0.02415895f, 
    0.02678869f, 0.01170423f, 0.01575639f, -0.00531570f, 0.02123500f, -0.03882331f, 0.01181346f, 0.03138172f, 
    -0.02267817f, 0.02217722f, -0.00834321f, 0.01067086f, 0.02381733f, -0.02105894f, -0.01454541f, -0.02462471f, 
    0.02238376f, -0.00590470f, -0.00909229f, -0.02976151f, 0.00223524f, -0.01007620f, -0.01803293f, 0.00567996f, 
    -0.00508175f, -0.02294997f, -0.01579813f, -0.01714449f, -0.04102896f, -0.02965624f, 0.00018645f, 0.02860114f, 
    -0.00973063f, -0.03794562f, -0.01279086f, -0.00343118f, 0.02226526f, -0.02540074f, 0.01088568f, 0.01952458f, 
    -0.02498718f, 0.02495941f, -0.03872155f, -0.00144090f, 0.00995533f, 0.01588190f, -0.01976958f, -0.00277139f, 
    -0.03812633f, 0.01595802f, 0.02633000f, -0.00389689f, 0.01395938f, -0.00786182f, -0.01179738f, -0.01863090f, 
    -0.00903224f, 0.01691466f, -0.01608656f, -0.02916014f, -0.03682208f, 0.01409457f, -0.02509153f, -0.01299307f, 
    0.01026818f, 0.02126345f, 0.00234749f, 0.02419132f, -0.01800800f, 0.01523903f, -0.03060197f, -0.01574021f, 
    -0.02237679f, -0.00599904f, 0.00979664f, 0.00509003f, 0.00696057f, -0.01527918f, -0.04141602f, -0.02564419f, 
    -0.01176722f, -0.02664932f, -0.03467991f, 0.02881103f, -0.01200504f, -0.04108725f, -0.02831364f, -0.01486894f, 
    0.00957723f, -0.01447756f, -0.00462491f, -0.03376240f, -0.00375724f, 0.00485926f, -0.03860834f, -0.00438848f, 
    0.01764721f, -0.02778960f, 0.00113124f, 0.01176812f, -0.02228628f, 0.01124688f, 0.02957044f, 0.01419902f, 
    0.02910806f, 0.01222379f, 0.00392646f, 0.01135219f, 0.00002314f, 0.02642835f, -0.00798392f, -0.02879919f, 
    -0.00522705f, -0.01888065f, 0.00292486f, 0.00791045f, 0.00021643f, 0.01746468f, -0.02250642f, 0.00863393f, 
    -0.03986889f, 0.01558302f, -0.01698325f, -0.02507655f, -0.02523112f, -0.02018903f, 0.01681023f, -0.03215098f, 
    -0.02492692f, -0.02797959f, -0.01268565f, -0.03756498f, -0.00824256f, -0.00260572f, -0.00882953f, -0.00968040f, 
    -0.02360447f, -0.04052277f, -0.00344567f, 0.00340198f, -0.00774358f, -0.03970620f, -0.02724166f, 0.02243402f, 
    0.00116216f, 0.00388136f, -0.00604966f, 0.01591104f, -0.00000457f, -0.00267607f, 0.02423390f, -0.02057818f, 
    -0.03702072f, 0.02233341f, 0.02072168f, -0.00604607f, 0.00529901f, -0.03506166f, 0.02566229f, 0.01849974f, 
    0.02590211f, 0.01963794f, 0.01898936f, 0.00868772f, 0.00927958f, -0.03196924f, -0.00185754f, -0.04087926f, 
    -0.03205429f, 0.01863058f, -0.02424983f, -0.03505183f, -0.00750916f, -0.03323122f, -0.00611682f, -0.00244707f, 
    -0.01313962f, -0.00932245f, -0.02928708f, 0.01324385f, 0.02042968f, 0.02551410f, -0.02054695f, 0.01587713f, 
    0.02292241f, 0.00465455f, 0.00502615f, -0.00564257f, -0.01626912f, -0.03633131f, 0.00429498f, -0.04130715f, 
    -0.01675342f, -0.04201289f, 0.02947772f, -0.00882543f, 0.02533560f, -0.01136081f, -0.02773707f, -0.01202442f, 
    -0.04025010f, -0.02334037f, 0.00823200f, 0.02834742f, -0.03294336f, -0.02330373f, 0.00911175f, 0.02137365f, 
    -0.00566821f, 0.02839946f, 0.02249074f, -0.03936077f, -0.02464787f, 0.02453897f, 0.02795220f, -0.00382703f, 
    0.02958283f, -0.02862312f, -0.02694165f, -0.00468409f, 0.01764371f, 0.01328141f, -0.03133578f, -0.00697057f, 
    -0.01390866f, -0.01404946f, -0.01384623f, -0.02671442f, -0.00728147f, -0.02269586f, -0.03757428f, 0.02510203f, 
    0.01517620f, -0.02545765f, 0.02126636f, 0.00905587f, 0.00882132f, -0.01221583f, 0.00642605f, -0.02796939f, 
    -0.02945698f, -0.02027628f, 0.02601297f, 0.02530007f, 0.00397851f, -0.03055971f, -0.00576089f, -0.00762970f, 
    0.02068844f, -0.02553070f, -0.01897651f, 0.02144275f, 0.02400106f, 0.01226692f, -0.00049708f, -0.02663670f, 
    -0.00643454f, 0.02406739f, 0.02534669f, 0.01176391f, -0.03899120f, -0.02047755f, -0.01654008f, 0.01514558f, 
    0.02715027f, 0.02650407f, 0.00189167f, -0.03299824f, 0.02820930f, -0.03618247f, -0.03552013f, 0.00258250f, 
    0.01140515f, 0.00440565f, -0.02214206f, -0.03667582f, -0.00207453f, -0.02868825f, -0.03598208f, 0.02834413f, 
    -0.00496222f, -0.00049242f, 0.02603434f, -0.01483887f, 0.02332344f, -0.00001722f, -0.03924116f, 0.01950558f, 
    -0.03754479f, -0.03132808f, -0.02993675f, -0.00166960f, -0.03415417f, -0.00199031f, -0.03117477f, 0.00449669f, 
    0.01332792f, 0.00949176f, -0.01596578f, 0.00411535f, 0.01487224f, -0.01562108f, -0.03525821f, 0.01569728f, 
    -0.01245356f, 0.02908934f, 0.00047537f, 0.02558965f, 0.00565042f, -0.00549353f, 0.01533535f, -0.02153241f, 
    -0.03844070f, 0.01781854f, -0.03826658f, 0.01518220f, -0.03477544f, 0.02905626f, 0.00564186f, 0.02393458f, 
    0.00576100f, 0.00730282f, -0.00002353f, 0.02719214f, 0.02754833f, -0.00728783f, 0.02535384f, -0.01062020f, 
    -0.00619271f, 0.01938359f, -0.04131129f, 0.00841909f, -0.03477608f, 0.02125875f, -0.03994252f, 0.02926030f, 
    -0.00645304f, 0.02956632f, 0.02363595f, -0.01169327f, -0.01423013f, 0.00271564f, -0.01340903f, 0.02721134f, 
    -0.00621179f, -0.00609888f, -0.03714345f, -0.01251272f, 0.01124402f, -0.01888143f, -0.03918441f, 0.02541129f, 
    -0.02686116f, 0.01684249f, -0.02084502f, -0.01683615f, 0.02572133f, -0.03451231f, -0.00750222f, -0.00229282f, 
    -0.03928084f, 0.00125485f, -0.01258690f, 0.00266808f, 0.01454416f, 0.02218458f, -0.01476455f, 0.02769956f, 
    0.02091828f, -0.04177267f, -0.03881386f, 0.01775371f, -0.02064621f, 0.01635147f, 0.00193548f, 0.01009661f, 
    0.00393378f, -0.01647957f, 0.01974810f, -0.02374262f, 0.00415648f, 0.02085303f, 0.00891253f, 0.00309927f, 
    0.01898267f, -0.03308599f, -0.00480008f, -0.00275399f, -0.03329685f, 0.01067848f, -0.01630231f, -0.02296909f, 
    -0.01107627f, 0.02382221f, -0.01306965f, -0.03754119f, 0.01464758f, 0.02871004f, -0.02677655f, -0.01219771f, 
    0.02996990f, -0.01163287f, -0.02709983f, -0.01748423f, -0.02502364f, -0.02007150f, 0.01999313f, -0.01384106f, 
    0.00885532f, -0.03182349f, 0.00572748f, -0.01633281f, -0.03507144f, 0.00249522f, -0.02961543f, 0.02581515f, 
    -0.02446920f, -0.03311961f, -0.01188044f, -0.02657173f, 0.02112361f, -0.00627112f, 0.01539091f, -0.01461403f, 
    -0.01522343f, 0.02755799f, -0.03221407f, 0.01423783f, 0.01343041f, -0.01837626f, -0.03510149f, -0.00574415f, 
    0.00454302f, 0.02950454f, 0.00561097f, 0.01576235f, -0.02649788f, 0.02424422f, -0.01990147f, -0.04107135f, 
    0.02065161f, -0.03950396f, 0.00305633f, -0.01792137f, -0.00738789f, -0.03192516f, -0.04009172f, -0.00850452f, 
    -0.03345575f, -0.02242334f, 0.01454918f, 0.02188118f, -0.02709932f, 0.01721632f, -0.02974188f, -0.02048472f, 
    0.00865344f, -0.03357983f, -0.03403740f, 0.01824618f, 0.01146879f, 0.01680969f, -0.04015126f, -0.02390525f, 
    -0.02230398f, 0.02595514f, -0.00922074f, -0.02574289f, -0.03159566f, -0.02310271f, -0.03951328f, -0.04102590f, 
    -0.03741761f, -0.00151685f, 0.01117863f, 0.02392776f, -0.02269929f, -0.00711787f, 0.02201542f, -0.00759587f, 
    0.00028508f, -0.02014510f, -0.00836180f, -0.01995840f, -0.01120777f, 0.01732521f, 0.02497907f, 0.01246642f, 
    -0.02521960f, 0.01029420f, -0.03899030f, 0.02602099f, 0.02258490f, 0.00452296f, 0.03812169f, 0.00129733f, 
    0.01052597f, -0.01627450f, -0.03350987f, 0.02691368f, -0.00355154f, -0.03671693f, -0.01804328f, -0.00080249f, 
    -0.00149051f, -0.03226317f, -0.00046567f, -0.00257032f, -0.03405564f, 0.02856107f, -0.01597657f, -0.01676039f, 
    0.02279554f, -0.01342402f, 0.03039799f, -0.03079046f, 0.01350137f, -0.03679830f, -0.02274104f, -0.01614128f, 
    -0.01647155f, 0.00927663f, 0.01095440f, -0.00280919f, -0.01482103f, -0.00129067f, 0.02714857f, -0.02189284f, 
    0.01251386f, -0.00273080f, -0.00959208f, -0.03481210f, -0.03121811f, 0.02677934f, -0.03794843f, 0.01728819f, 
    0.00182102f, -0.00927669f, -0.02519472f, -0.00741760f, -0.01848768f, -0.03176720f, -0.03785001f, 0.00044320f, 
    -0.00225829f, -0.04034471f, -0.03801824f, -0.01788404f, 0.02517732f, -0.00238299f, -0.00830570f, 0.02056712f, 
    0.01857210f, -0.03253777f, 0.02004753f, -0.00356336f, -0.03355734f, 0.01911479f, 0.02066316f, 0.02996528f, 
    -0.01065711f, -0.00586743f, -0.02263610f, -0.02199152f, -0.02608087f, 0.01281522f, -0.00816794f, -0.03276922f, 
    0.01382050f, -0.01751944f, -0.00762045f, 0.01626085f, 0.00918227f, 0.02713681f, 0.01432262f, -0.01373622f, 
    -0.00569881f, -0.00756475f, -0.03726492f, -0.03286084f, -0.00842873f, -0.02330312f, -0.00936258f, -0.01825285f, 
    -0.00218775f, -0.03824605f, -0.04170358f, 0.00949987f, -0.03375446f, 0.02773223f, 0.01858346f, -0.00694079f, 
    -0.01420409f, -0.02009800f, -0.01442856f, -0.03939685f, -0.02140064f, 0.02007595f, 0.02178588f, -0.01386440f, 
    -0.00695726f, 0.01183636f, 0.00104862f, -0.00729939f, 0.01843156f, -0.00469773f, 0.00394532f, -0.00189405f, 
    -0.02687330f, 0.00279521f, -0.03156726f, -0.00615717f, -0.02735094f, -0.01080637f, -0.02606261f, 0.00130830f, 
    -0.03807953f, 0.00457024f, 0.01714681f, -0.01136498f, -0.03293008f, 0.00413623f, 0.00490902f, 0.02145605f, 
    0.01861113f, -0.04008826f, -0.00286356f, -0.03539474f, -0.01999740f, -0.01317650f, 0.01403330f, -0.00143812f, 
    -0.00521102f, 0.02559676f, -0.00315166f, -0.03807902f, 0.00746786f, -0.00156102f, -0.02077917f, -0.01940757f, 
    -0.00513481f, -0.02345184f, -0.04060059f, -0.01128853f, 0.02683925f, 0.00662722f, 0.01887661f, -0.01044508f, 
    -0.01309488f, -0.00115297f, -0.01811023f, 0.02382725f, -0.02850018f, -0.03829991f, 0.00337744f, 0.02643602f, 
    0.02805583f, -0.00702283f, -0.01126065f, -0.03815158f, -0.00068495f, -0.02317056f, -0.03171651f, -0.00185956f, 
    0.01440794f, 0.01432716f, 0.00381165f, 0.00766034f, 0.02114723f, -0.03351429f, -0.03265974f, -0.01046082f, 
    -0.03559852f, -0.01453603f, 0.01867783f, -0.02770660f, -0.02512056f, 0.01589923f, -0.02508004f, 0.01321945f, 
    -0.03107729f, -0.01495386f, -0.03460840f, -0.01078415f, 0.00278936f, -0.04027630f, -0.01089198f, 0.00061803f, 
    0.00454056f, 0.00993101f, -0.02079166f, -0.02486053f, -0.02786457f, 0.02234962f, -0.03370957f, 0.02686996f, 
    -0.03450696f, 0.02382489f, 0.01941749f, -0.00770269f, 0.01587196f, -0.02596657f, 0.00439648f, -0.00524965f, 
    0.02949770f, -0.00620297f, -0.02113030f, -0.01523766f, -0.02298569f, -0.01136327f, -0.01025072f, -0.00580825f, 
    -0.02784426f, 0.01805452f, -0.03060855f, 0.02222870f, 0.01620561f, -0.03296030f, 0.02222927f, -0.01739811f, 
    0.00552794f, -0.01267657f, 0.00433736f, -0.02556007f, -0.01658608f, 0.02261768f, -0.03572897f, -0.01265498f, 
    -0.00289051f, -0.02247568f, -0.03288100f, 0.02454907f, 0.02995344f, -0.03462310f, -0.03424987f, -0.03742505f, 
    0.02031654f, 0.01118915f, 0.01769041f, -0.00343770f, -0.02102812f, -0.00754066f, -0.01485762f, -0.00585691f, 
    -0.02264251f, 0.01636343f, -0.03793893f, 0.00376067f, -0.01646127f, 0.02066589f, 0.02799045f, -0.02184655f, 
    -0.03349021f, -0.00305896f, -0.00773057f, -0.03542848f, -0.01443960f, -0.00042272f, 0.01585715f, -0.03551755f, 
    0.01587438f, -0.00121139f, 0.00555765f, -0.01049506f, 0.00540684f, -0.00968128f, -0.02340670f, 0.01754576f, 
    -0.03167602f, 0.02548347f, -0.00186710f, -0.01616420f, -0.01533328f, -0.02405785f, 0.02345446f, 0.02839472f, 
    -0.03995242f, -0.04063655f, -0.03406718f, 0.02463133f, 0.00909015f, -0.01994047f, -0.03797185f, 0.02104910f, 
    -0.03780627f, -0.03003867f, -0.01068108f, 0.00463309f, 0.01401673f, -0.00787841f, -0.01073637f, -0.00413997f, 
    0.02621282f, 0.00905911f, -0.02228247f, 0.00288681f, -0.03615087f, 0.00536680f, -0.02639778f, -0.03133504f, 
    -0.00536997f, -0.02252615f, -0.03884355f, 0.00400775f, 0.01195597f, -0.01093214f, 0.02205899f, -0.03607958f, 
    0.01750745f, -0.00293990f, 0.01829918f, -0.01484310f, 0.00624552f, -0.00384835f, -0.00465614f, -0.00399448f, 
    0.00540981f, -0.00471807f, -0.04151168f, 0.01291673f, 0.00151910f, 0.02450130f, 0.00209905f, -0.03439946f, 
    0.00897342f, -0.01809156f, 0.00490983f, 0.00303677f, 0.03372192f, 0.01452148f, -0.01875974f, -0.04029242f, 
    0.01800160f, 0.03001843f, -0.02276774f, 0.00669455f, 0.01416304f, 0.00510831f, 0.00400152f, 0.00174698f, 
    -0.01104122f, 0.02543093f, -0.02946069f, 0.02025161f, -0.01881591f, -0.02900269f, 0.02828269f, 0.02897739f, 
    -0.03585560f, 0.02335692f, -0.02893741f, 0.00809553f, -0.02268867f, -0.00260786f, 0.00104561f, -0.02137681f, 
    0.02390635f, 0.00948011f, 0.02565633f, -0.04178054f, 0.01580792f, -0.01599439f, 0.02566048f, 0.01349666f, 
    0.03019284f, -0.00622962f, -0.03694815f, 0.03943740f, 0.02398764f, 0.01663226f, -0.00649436f, 0.02025710f, 
    0.02357058f, -0.03265111f, 0.02473591f, 0.01425314f, 0.02730695f, -0.02781670f, -0.03784463f, 0.01405148f, 
    -0.02615297f, 0.02646101f, -0.00233445f, 0.01282349f, 0.02059655f, 0.00537384f, -0.04139947f, -0.00326982f, 
    0.00088542f, -0.00504993f, -0.02213094f, -0.00786240f, -0.03315473f, -0.02262881f, 0.01872765f, -0.04093683f, 
    0.02458805f, -0.03427522f, -0.03806080f, -0.02854623f, -0.00193252f, 0.02155876f, -0.01932103f, 0.02957535f, 
    0.02737438f, 0.00353056f, 0.02950756f, -0.02764200f, -0.04061874f, -0.01232722f, 0.01402588f, 0.02182078f, 
    -0.01743563f, -0.01814588f, 0.02513791f, -0.03540747f, -0.02675461f, 0.00205920f, 0.01919222f, 0.01686562f, 
    -0.00600134f, 0.00819244f, -0.02931517f, 0.01239579f, -0.01539195f, -0.02556379f, 0.00971085f, -0.01850012f, 
    0.02485337f, 0.02280868f, -0.04138601f, 0.02287069f, 0.01244952f, 0.02459371f, -0.03490852f, 0.01316201f, 
    0.00056162f, -0.02208063f, -0.02310599f, 0.02222366f, 0.02435362f, -0.01454583f, 0.00196088f, -0.02961737f, 
    -0.00887618f, 0.00870583f, -0.01445230f, 0.00748423f, -0.02030502f, -0.00954603f, -0.04025083f, -0.00829762f, 
    -0.01080774f, 0.02376182f, -0.03526056f, -0.00505930f, -0.03051600f, 0.00819625f, 0.00109252f, -0.03817012f, 
    0.00764566f, 0.01543286f, -0.02926692f, 0.01753384f, 0.02165329f, 0.00542667f, 0.01410651f, 0.00757896f, 
    0.00662023f, 0.01398561f, -0.00048412f, -0.01099490f, -0.01381509f, -0.04008105f, -0.03614575f, 0.00098283f, 
    -0.03277674f, -0.00436899f, -0.02627170f, -0.01375619f, -0.00990760f, 0.01875790f, 0.01306538f, 0.01397735f, 
    0.00472840f, 0.00775150f, -0.02681171f, -0.01582702f, -0.02836676f, 0.02199330f, -0.01638190f, -0.04559413f, 
    -0.02556083f, -0.00316031f, 0.01663044f, -0.00624875f, 0.02172012f, 0.00314545f, 0.00491608f, -0.03336333f, 
    -0.03449427f, -0.00268109f, -0.00594843f, 0.02484718f, 0.02808410f, 0.01648222f, -0.00378566f, -0.01188781f, 
    -0.01599636f, -0.03654885f, -0.02249319f, 0.03513111f, -0.00088843f, -0.02165107f, -0.00179438f, -0.01578519f, 
    0.01437585f, 0.02810474f, -0.00306013f, -0.01358909f, -0.01197313f, 0.03251180f, -0.02835326f, -0.00263612f, 
    0.01991275f, 0.02579064f, -0.01436928f, 0.02792263f, 0.01454466f, -0.01384226f, 0.03750193f, 0.02700705f, 
    0.02755865f, -0.03203623f, -0.00264278f, 0.01153062f, 0.02487911f, -0.01920905f, -0.00261073f, -0.03626524f, 
    -0.01037472f, -0.00559725f, -0.02510538f, 0.01225549f, -0.04121802f, -0.04045939f, 0.02632946f, 0.02727886f, 
    -0.02761605f, 0.03527410f, -0.01416383f, -0.00079257f, 0.04065327f, 0.02098437f, -0.03388940f, -0.02081906f, 
    0.01750101f, -0.01664235f, -0.00018663f, 0.02991252f, 0.00738507f, -0.00253979f, 0.01212699f, -0.03842106f, 
    -0.01106329f, 0.01655003f, -0.03627248f, -0.04081753f, -0.04224220f, -0.03334948f, 0.00318113f, 0.02850126f, 
    -0.00159550f, -0.02391556f, 0.00878917f, 0.04385163f, -0.02768476f, -0.02888649f, -0.02190934f, 0.03697112f, 
    0.00416227f, 0.00474279f, -0.02880291f, 0.04266537f, -0.00725585f, -0.03304622f, -0.00436389f, -0.03420237f, 
    0.01519369f, -0.00719889f, 0.00046319f, 0.00802140f, -0.02244502f, -0.00831599f, 0.01398511f, 0.02640478f, 
    -0.00819184f, 0.01264326f, 0.00352474f, 0.01943226f, -0.00119549f, 0.02167531f, 0.00207459f, -0.01542459f, 
    0.00849804f, -0.01473271f, -0.01733582f, -0.04024118f, -0.01322302f, -0.00135397f, -0.03797283f, 0.00807871f, 
    -0.01117977f, -0.04158369f, 0.02667337f, 0.00637147f, -0.00548933f, -0.01974454f, -0.03882606f, 0.02315976f, 
    0.00451368f, -0.03078791f, -0.02347586f, 0.02349320f, -0.01688988f, -0.01523226f, -0.01399846f, 0.00686951f, 
    0.02578526f, 0.00094708f, 0.02669650f, -0.01307950f, -0.00613677f, 0.00552497f, -0.02082017f, -0.00257325f, 
    -0.02363653f, -0.00782415f, -0.01447979f, -0.01050258f, -0.00694436f, 0.00966061f, -0.03348578f, 0.00374295f, 
    -0.01065254f, -0.02790964f, -0.02578426f, -0.00086596f, -0.02904366f, -0.03324694f, -0.03293272f, 0.03976854f, 
    0.02642711f, -0.02566541f, 0.02839204f, 0.02358709f, -0.02946367f, 0.00362038f, -0.01634528f, -0.03084054f, 
    0.00192780f, 0.01025469f, 0.02408770f, -0.03644558f, -0.00052082f, 0.01318752f, -0.01883795f, 0.01556940f, 
    -0.00969934f, -0.02337392f, 0.02816403f, -0.04380687f, 0.00356230f, 0.02982530f, -0.03890932f, -0.01091106f, 
    -0.01721603f, -0.01559590f, 0.00404411f, 0.00720815f, 0.00063988f, -0.03786215f, -0.03345452f, 0.03345977f, 
    -0.03113244f, 0.02290226f, -0.00382729f, -0.00430041f, 0.03411593f, -0.01053301f, -0.02215863f, -0.00408925f, 
    0.01586954f, 0.01207324f, 0.02447163f, 0.01233073f, -0.01728145f, 0.00081600f, 0.00548348f, 0.00843002f, 
    0.02147257f, 0.01555779f, -0.02724282f, 0.00018648f, -0.00006228f, -0.00629951f, 0.00935956f, -0.04058975f, 
    0.00978244f, 0.01334738f, 0.01361502f, -0.02939175f, 0.00672861f, 0.00976435f, 0.02557386f, -0.03123162f, 
    -0.04257934f, 0.01107332f, -0.00826160f, -0.02274698f, -0.00587321f, 0.01772128f, 0.00614671f, 0.00417104f, 
    -0.01956303f, -0.04328348f, 0.00712148f, -0.03695708f, 0.00037083f, 0.02642591f, -0.03299884f, -0.02183547f, 
    -0.02500526f, -0.00068514f, 0.01638673f, -0.00316988f, 0.00427287f, -0.00879088f, -0.03972635f, 0.02148331f, 
    0.00081017f, 0.02502799f, -0.03166516f, -0.00179031f, -0.02740130f, 0.03785244f, -0.01590888f, -0.00564956f, 
    -0.01582493f, 0.01373076f, -0.00973128f, -0.03200814f, 0.00422691f, 0.02012470f, -0.03782368f, 0.00256067f, 
    -0.02486673f, -0.03714664f, -0.00980084f, 0.01697863f, -0.00036961f, 0.04179408f, 0.01676946f, 0.03125392f, 
    0.02311594f, -0.03363137f, -0.01074020f, -0.00861411f, -0.00550925f, 0.01266558f, 0.00871364f, -0.01544720f, 
    -0.02474556f, 0.02402849f, 0.00525466f, 0.02448485f, -0.01591088f, 0.01130197f, 0.03320184f, -0.00977090f, 
    -0.02430744f, 0.01814956f, -0.01327144f, 0.04086534f, -0.00887969f, 0.00316673f, 0.01720839f, 0.00546729f, 
    0.02096207f, -0.03754523f, 0.02684741f, -0.02544483f, -0.02808257f, 0.02495071f, 0.02710029f, -0.02427112f, 
    -0.03268343f, 0.02004767f, 0.01146590f, -0.00427326f, 0.01520902f, -0.02560991f, -0.01258907f, 0.01323438f, 
    -0.01801201f, 0.02373073f, -0.00243813f, -0.02113667f, -0.02842476f, -0.04167335f, -0.02405295f, -0.03367637f, 
    -0.00289977f, -0.02367790f, 0.02758633f, -0.02033767f, 0.01440038f, -0.03396143f, -0.01251192f, 0.01439032f, 
    -0.03637910f, -0.02705298f, 0.02673664f, -0.02146692f, 0.00513060f, -0.03810306f, -0.03265194f, -0.00380255f, 
    -0.00929118f, 0.02702392f, -0.04170315f, -0.03116481f, -0.01888230f, 0.00978146f, -0.02247054f, 0.02792247f, 
    0.01814392f, -0.00337710f, 0.00937018f, -0.00457662f, 0.01910805f, 0.00191213f, 0.00373400f, 0.03078521f, 
    -0.01192540f, 0.00502059f, -0.03486548f, 0.00156514f, -0.02564668f, -0.02017970f, 0.01610412f, 0.02214153f, 
    0.03300010f, 0.04028768f, 0.03348073f, -0.00892851f, 0.00695914f, 0.01418430f, 0.02326592f, -0.00702085f, 
    -0.02757443f, 0.00437369f, 0.01190361f, 0.01706196f, 0.01183833f, 0.00004973f, 0.02302233f, 0.02260084f, 
    0.02759309f, 0.01872260f, 0.01818641f, -0.01384405f, -0.00028454f, 0.01895434f, -0.02194691f, -0.03277746f, 
    -0.04109694f, -0.00771221f, -0.02225855f, 0.03142730f, -0.00363946f, 0.01169794f, 0.01972895f, -0.03430033f, 
    -0.03674458f, 0.00182719f, -0.00330744f, -0.03651407f, -0.01020078f, -0.03250871f, -0.03902560f, -0.00996138f, 
    -0.03082500f, 0.03406396f, 0.01504481f, 0.00683436f, -0.00466213f, 0.00705253f, -0.01758115f, 0.01029468f, 
    0.02484519f, -0.00676024f, -0.00005327f, 0.00883387f, -0.00478478f, 0.03339412f, 0.00167490f, -0.00685130f, 
    0.01275178f, 0.02872909f, 0.00106393f, 0.01792934f, -0.01332225f, 0.00137092f, 0.03166876f, 0.03263363f, 
    0.00643341f, -0.01784137f, 0.00971500f, -0.00332819f, -0.03868650f, -0.00696425f, -0.04184504f, -0.03530148f, 
    -0.02050807f, 0.01331190f, -0.01614423f, 0.01898550f, -0.00080964f, 0.02606952f, -0.02038004f, -0.01156060f, 
    -0.03974476f, -0.03667815f, -0.01814532f, -0.00708967f, -0.01124403f, -0.03946997f, -0.00789420f, -0.02497679f, 
    -0.03766478f, 0.01270865f, 0.02791824f, 0.02690507f, -0.02629824f, -0.01899548f, -0.00214100f, -0.03540646f, 
    0.01897537f, 0.02198776f, -0.03624757f, -0.03759012f, -0.04096260f, -0.00350902f, 0.02391166f, -0.01439092f, 
    0.01724617f, 0.01005445f, -0.03426836f, 0.00854116f, -0.00680171f, -0.02540335f, -0.02136128f, 0.02160567f, 
    -0.04015923f, -0.01579392f, -0.01606372f, -0.02311404f, -0.02208843f, 0.01993559f, 0.02899430f, -0.03302818f, 
    0.01507543f, -0.00321829f, -0.01969116f, -0.02259662f, 0.02773764f, 0.01169067f, -0.03787451f, -0.00637320f, 
    -0.04451008f, -0.01536519f, -0.03884545f, -0.00734866f, -0.02917702f, -0.03351124f, 0.01066391f, -0.00304849f, 
    0.02722437f, -0.02320826f, -0.01709171f, 0.01166720f, 0.03227064f, -0.01390892f, -0.00426926f, -0.01580331f, 
    0.01819647f, -0.01899438f, 0.00217716f, -0.02959659f, 0.02653955f, 0.01945049f, -0.00462139f, 0.00330627f, 
    -0.03029229f, 0.01207759f, -0.03973732f, -0.00630704f, 0.00978485f, 0.01239990f, -0.03066014f, 0.02913904f, 
    -0.01798471f, 0.01343630f, -0.00394172f, -0.00630093f, -0.03442838f, 0.01457271f, -0.02771977f, -0.03553029f, 
    0.02325985f, 0.00517645f, -0.01564321f, 0.00282098f, -0.02288356f, 0.00664222f, 0.02924193f, 0.02837260f, 
    0.00796905f, -0.03519577f, -0.00360112f, -0.00827109f, -0.00301328f, 0.02417989f, -0.02267053f, -0.00670952f, 
    -0.02171103f, 0.02502696f, -0.02974116f, 0.02702034f, 0.02095033f, -0.00038223f, -0.01337121f, 0.00199428f, 
    -0.01353015f, -0.01388426f, 0.01029856f, -0.04106331f, 0.01881734f, 0.00439794f, -0.00773094f, 0.00774420f, 
    -0.02717257f, 0.00164863f, 0.02292285f, -0.01535601f, 0.00212769f, 0.02185515f, -0.03250778f, -0.02031225f, 
    0.02663148f, 0.02925291f, -0.01421206f, -0.01744983f, 0.02998375f, -0.03961635f, -0.03131707f, -0.01803825f, 
    0.01877546f, 0.00957907f, 0.02076918f, -0.01502933f, -0.03188677f, -0.02758010f, 0.01888841f, -0.01551106f, 
    0.01816471f, -0.03626047f, 0.01191264f, -0.03410902f, -0.01799728f, 0.02616663f, -0.01066652f, -0.03784275f, 
    0.03154736f, 0.00110488f, 0.02526334f, -0.01527470f, 0.01749102f, 0.02464399f, -0.02530953f, -0.02535379f, 
    0.02798974f, -0.04306348f, -0.02829288f, 0.01792299f, -0.00790719f, -0.01805512f, -0.00365479f, 0.01656071f, 
    -0.01406400f, 0.01931812f, -0.03373063f, 0.02933756f, -0.01223281f, -0.02301157f, 0.00489248f, 0.01914707f, 
    0.02325839f, 0.00806610f, 0.03210180f, -0.03541858f, -0.01520224f, 0.00768540f, -0.01997151f, 0.02138231f, 
    -0.02903720f, 0.02042705f, -0.02592477f, -0.01304257f, 0.02507657f, -0.02599054f, -0.03342848f, -0.01517459f, 
    -0.01167951f, -0.00908992f, 0.02126358f, -0.02784938f, -0.03517319f, -0.00545524f, -0.03795654f, -0.01648062f, 
    -0.03625104f, 0.03619215f, -0.02661946f, 0.01285948f, -0.00982333f, -0.02118734f, 0.01894977f, -0.01863143f, 
    0.01676696f, 0.02253603f, 0.00106660f, -0.00259212f, -0.00870446f, -0.02838473f, -0.02108138f, 0.01525502f, 
    -0.01339517f, 0.01575019f, -0.01383388f, 0.01374717f, -0.02968347f, -0.00887417f, 0.02439108f, -0.03828637f, 
    0.01815496f, -0.01249482f, -0.02984222f, 0.00843843f, -0.04012666f, 0.01572012f, -0.00079551f, 0.03440041f, 
    -0.00948891f, 0.02912544f, -0.02687366f, -0.02180646f, -0.03261290f, -0.00833511f, 0.00014426f, 0.02289625f, 
    0.01050747f, 0.00554798f, -0.03778283f, -0.00299779f, -0.02984654f, -0.02513887f, -0.01059855f, -0.03001761f, 
    -0.00656443f, -0.00563997f, -0.03558846f, -0.02128987f, -0.00473038f, -0.02181116f, -0.02018077f, 0.02101793f, 
    -0.00335778f, -0.02218921f, 0.00763624f, -0.03417746f, 0.04405822f, -0.01170323f, -0.03898266f, -0.02032980f, 
    -0.00690925f, 0.01462908f, -0.02338844f, 0.01743534f, -0.01896434f, -0.03004902f, 0.01001229f, -0.00475265f, 
    -0.02204544f, -0.04429291f, -0.01357240f, -0.01812558f, -0.02091453f, 0.02125681f, 0.02596251f, 0.01134865f, 
    -0.03004536f, -0.00805504f, 0.00802631f, -0.03704391f, -0.03776645f, -0.01920069f, -0.01678581f, -0.01096902f, 
    0.02551761f, -0.00345030f, -0.02778731f, 0.02423448f, 0.00271248f, 0.03268215f, -0.02663306f, 0.00834092f, 
    -0.03107437f, -0.01245470f, 0.00398468f, 0.02327922f, -0.01481742f, 0.02220780f, -0.02509812f, 0.01570355f, 
    0.01998210f, -0.01354631f, -0.00594118f, -0.01253035f, 0.02199409f, 0.02150644f, 0.03742630f, 0.03016957f, 
    -0.03879010f, 0.01923968f, -0.04076351f, 0.03340260f, 0.01576699f, -0.01257606f, 0.01433232f, -0.03420965f, 
    0.00080480f, -0.01361723f, -0.03707084f, -0.00569163f, -0.02170987f, 0.01331785f, 0.01432593f, -0.03802860f, 
    -0.03025373f, 0.02084118f, -0.03664332f, 0.00517958f, 0.02103190f, -0.02256859f, 0.00902538f, -0.01638751f, 
    -0.03882350f, 0.01086845f, 0.00505360f, -0.01778599f, 0.02109663f, -0.02743363f, -0.02003499f, 0.00109429f, 
    -0.01640755f, 0.01842366f, 0.01177727f, 0.01472003f, -0.00790783f, 0.02131809f, -0.01584066f, -0.03092238f, 
    0.00262586f, -0.01091849f, -0.02446507f, -0.02769978f, 0.00979992f, -0.00613009f, -0.02662639f, -0.01890225f, 
    -0.03907117f, 0.03191397f, 0.02799368f, 0.00619772f, -0.01068995f, -0.01526815f, -0.00281179f, -0.02240414f, 
    -0.03117355f, 0.00307074f, -0.02892045f, -0.00219156f, 0.02121802f, -0.01241031f, 0.02890966f, 0.02053446f, 
    -0.03746397f, 0.00076764f, -0.01314010f, -0.03475718f, 0.01423342f, -0.02815292f, -0.02757888f, -0.02189009f, 
    -0.04186149f, 0.03934446f, -0.04026723f, -0.00392958f, -0.00340837f, -0.01113690f, -0.00454668f, -0.01889436f, 
    -0.02562672f, -0.01652660f, -0.02495254f, -0.01685137f, 0.00960269f, -0.02070739f, 0.00436235f, 0.01830024f, 
    0.02792815f, 0.00531649f, -0.02821835f, -0.00903520f, -0.01832707f, -0.02996126f, -0.00503578f, -0.01500082f, 
    -0.02245633f, 0.01768051f, 0.02527102f, -0.02784544f, -0.02602779f, -0.03329394f, -0.02931003f, 0.02243872f, 
    -0.00009869f, -0.00614455f, -0.03963751f, 0.01222296f, 0.01090393f, 0.01673094f, -0.03082581f, -0.01407947f, 
    -0.01713962f, -0.01647618f, -0.02384931f, 0.00667227f, 0.00993003f, -0.01949238f, 0.00454794f, -0.03232976f, 
    0.01969927f, -0.01159136f, 0.02304805f, -0.01724133f, -0.01490606f, -0.00694002f, -0.03836348f, -0.03009892f, 
    -0.02654714f, -0.00520242f, -0.01939235f, -0.03283017f, -0.03884436f, 0.03223176f, -0.02027665f, -0.02867957f, 
    -0.01456792f, 0.01260319f, 0.00025966f, 0.01373614f, -0.01193938f, -0.01797983f, 0.01392786f, -0.01350799f, 
    0.00245753f, 0.02855249f, 0.01761003f, 0.02271561f, -0.01407800f, -0.00741805f, -0.00348471f, 0.02765192f, 
    -0.01702271f, -0.01147470f, 0.02441745f, -0.01747968f, 0.03222836f, 0.01758610f, 0.00496789f, -0.02122772f, 
    -0.03524406f, 0.02002910f, 0.00273469f, 0.01347534f, 0.00697052f, -0.01842124f, 0.00232543f, -0.00309610f, 
    -0.00907656f, -0.03794760f, -0.02050431f, -0.03044986f, 0.02296280f, -0.03013100f, -0.01558981f, 0.01799331f, 
    0.00212046f, 0.01593082f, 0.00388247f, 0.01112992f, -0.01018521f, 0.02620575f, 0.01035346f, 0.00828517f, 
    0.00878994f, 0.02453564f, -0.02999843f, -0.00800939f, 0.02269596f, -0.02650248f, -0.01666967f, -0.00293994f, 
    -0.02841379f, -0.02317192f, -0.03977929f, 0.02650704f, 0.01419143f, 0.02877494f, 0.01816403f, -0.03789531f, 
    -0.02233941f, -0.03131591f, 0.02588361f, 0.01339675f, -0.03611881f, -0.02472794f, 0.01272810f, 0.02764639f, 
    0.01978743f, 0.01831764f, 0.01857127f, -0.00540969f, -0.02767926f, 0.03016976f, 0.00130704f, 0.02567367f, 
    0.00829418f, -0.04207150f, 0.00815892f, -0.01585750f, 0.01905714f, 0.01132710f, -0.00290332f, 0.00656422f, 
    -0.02819560f, -0.02154621f, 0.01409886f, 0.02375780f, -0.00954127f, -0.02438329f, -0.00751471f, -0.01807862f, 
    0.01595310f, -0.00588207f, -0.02730323f, -0.00135762f, 0.02005097f, -0.02344618f, 0.02534926f, 0.00033080f, 
    -0.00069174f, -0.01297101f, 0.01156776f, -0.01961526f, -0.01592320f, -0.00116957f, 0.01342220f, -0.00501267f, 
    0.03287969f, -0.02843615f, -0.02593522f, -0.03047404f, 0.00546458f, 0.01296459f, -0.02271097f, -0.02918691f, 
    -0.03848031f, 0.02819564f, -0.02704754f, 0.03088890f, -0.00254375f, -0.03163266f, -0.03291056f, 0.02983473f, 
    0.01059953f, 0.02391536f, 0.01871236f, 0.02621903f, -0.02144350f, 0.02500769f, -0.02194737f, -0.02970746f, 
    0.01576287f, -0.02137168f, -0.01425531f, -0.00282308f, 0.00685048f, -0.02612299f, -0.03020294f, -0.03634552f, 
    -0.02256330f, -0.01668946f, -0.03361038f, 0.00841521f, 0.01791907f, 0.02238964f, 0.00338673f, -0.02570927f, 
    -0.01850319f, 0.03335816f, -0.03566613f, 0.00018888f, 0.00966301f, -0.01402718f, 0.02600389f, 0.01906143f, 
    -0.02294044f, -0.01403111f, -0.00749137f, 0.01041093f, -0.02032130f, -0.02293351f, -0.01086744f, 0.02159568f, 
    0.00103289f, -0.01990538f, -0.00855905f, 0.01935492f, 0.01097163f, 0.03445325f, -0.03332249f, -0.02662548f, 
    -0.00218959f, -0.00369357f, -0.00107830f, -0.03890305f, -0.00775735f, -0.01006704f, -0.00727576f, -0.00014715f, 
    -0.02691855f, 0.00523497f, -0.00064336f, 0.00959040f, 0.01315636f, -0.02852542f, 0.00436285f, -0.04346417f, 
    -0.02731359f, -0.01211652f, -0.03720472f, -0.03787077f, 0.01825068f, -0.02965180f, 0.02294035f, -0.00724033f, 
    -0.03853922f, 0.01230146f, -0.03796613f, 0.01063311f, -0.01368658f, 0.02130884f, -0.02589125f, 0.01439356f, 
    -0.02041172f, -0.02862228f, -0.00128505f, 0.02553723f, -0.00393005f, 0.02852188f, -0.01115191f, 0.01866378f, 
    0.01716574f, 0.01236895f, -0.02853955f, 0.01868941f, -0.00782441f, -0.01301035f, 0.00947187f, 0.01338821f, 
    -0.00373421f, -0.01021325f, -0.03402892f, 0.00728452f, 0.00596447f, -0.01610430f, 0.02479237f, 0.01653405f, 
    0.00216200f, -0.01552743f, 0.01144395f, -0.00935134f, 0.00361054f, -0.02339144f, 0.00941415f, -0.01057083f, 
    -0.03754552f, 0.03238971f, -0.01235677f, -0.02890218f, 0.00267773f, -0.03828527f, -0.00935484f, -0.00383808f, 
    0.02342728f, 0.01975422f, 0.00476938f, 0.02636429f, 0.00963291f, 0.00421392f, 0.02693738f, -0.02421307f, 
    0.02029712f, -0.02703772f, -0.02022370f, 0.00742171f, -0.04044022f, -0.00487957f, -0.00124758f, 0.00012091f, 
    0.01902480f, -0.00636066f, -0.01592095f, 0.02952242f, 0.00519146f, -0.04527048f, -0.01031441f, 0.00562028f, 
    0.00486154f, -0.01882892f, 0.00015508f, 0.01567728f, -0.02853180f, -0.00225150f, 0.00608910f, 0.01667005f, 
    0.00466717f, -0.03360380f, 0.00294483f, -0.00154393f, 0.02258706f, 0.01144533f, -0.03518440f, 0.00563459f, 
    -0.01559263f, 0.02800863f, 0.02990074f, -0.00210300f, -0.02958516f, -0.01731204f, -0.02300474f, 0.00910118f, 
    0.02518644f, -0.03096753f, 0.00958227f, -0.02104105f, 0.01290104f, -0.03657177f, 0.02469203f, 0.02379059f, 
    -0.02519489f, -0.01819894f, 0.01593716f, 0.02131409f, -0.03189107f, -0.01565245f, -0.02092413f, 0.00856696f, 
    -0.03174864f, -0.03923771f, 0.02844231f, -0.02779327f, -0.03431615f, -0.00630647f, -0.00015101f, -0.00168015f, 
    -0.00777605f, -0.00324288f, -0.00042401f, -0.01340279f, -0.00863714f, 0.02247213f, 0.00722787f, -0.00177826f, 
    -0.02482276f, -0.01960865f, 0.02177529f, -0.02412639f, -0.00988943f, -0.00302086f, 0.01369033f, -0.02135661f, 
    0.02947064f, 0.00813330f, 0.00463568f, 0.00443648f, 0.01686708f, 0.01939237f, 0.02542543f, 0.02120095f, 
    -0.01048568f, -0.03277519f, -0.04021648f, 0.01481802f, 0.01194938f, 0.02235302f, -0.02494305f, 0.01333612f, 
    0.03426036f, 0.01660533f, -0.01413701f, 0.00778733f, 0.01593569f, 0.01036486f, -0.02514530f, 0.00288751f, 
    -0.04308463f, -0.02658091f, -0.03529846f, 0.00752790f, -0.04248827f, 0.00446942f, 0.00338249f, -0.03120880f, 
    0.02383468f, -0.02968423f, -0.01214054f, 0.01620080f, 0.00832524f, -0.01115714f, -0.03093620f, -0.03456357f, 
    0.03856745f, -0.02048567f, 0.01184579f, 0.01877191f, -0.04340201f, -0.04088720f, -0.02229823f, 0.00391205f, 
    -0.01374842f, -0.00486229f, 0.02492653f, -0.02460155f, -0.00038865f, -0.03337530f, -0.01862766f, 0.00520651f, 
    0.02403086f, -0.00807603f, -0.00765561f, -0.03624047f, -0.03340418f, -0.01192552f, -0.02428668f, -0.03002189f, 
    0.01827330f, -0.02811667f, -0.00674221f, -0.00152715f, -0.04009559f, 0.03291216f, 0.02808416f, -0.02570768f, 
    0.01607415f, 0.01366657f, -0.00558469f, -0.00359406f, -0.02627338f, -0.03193459f, -0.02144988f, 0.01048257f, 
    0.03180013f, -0.03097902f, 0.02607847f, -0.00295633f, -0.00788969f, -0.04000018f, 0.01892737f, -0.03270916f, 
    0.02698339f, 0.02610755f, -0.03713555f, -0.03742635f, 0.01180904f, 0.01270777f, -0.02393204f, 0.03182404f, 
    -0.03313803f, -0.01747913f, 0.02326748f, 0.01250965f, 0.00876686f, -0.01152464f, 0.02047115f, -0.02751406f, 
    -0.02732494f, 0.01284663f, -0.02871180f, 0.00715455f, -0.01902982f, -0.01946471f, -0.00792734f, -0.03221657f, 
    -0.02478305f, 0.01700962f, -0.02313101f, -0.04298282f, -0.01826359f, -0.03352569f, 0.02544539f, -0.00014535f, 
    -0.01291643f, 0.00605054f, 0.01351968f, 0.02375821f, -0.04531948f, -0.01221054f, -0.01199582f, -0.00654850f, 
    0.00917316f, 0.02883193f, 0.00429822f, -0.01697504f, 0.01120888f, 0.01741363f, 0.01097212f, 0.01155096f, 
    -0.08376234f, -0.07129461f, -0.06927285f, 0.01276547f, 0.04412138f, -0.20036754f, -0.07960250f, -0.09889779f, 
    -0.02092510f, -0.02205950f, 0.06846208f, -0.01476523f, 0.43788901f, 0.03874693f, 0.01727350f, -0.22785866f, 
    -0.05091301f, 0.18330808f, -0.06826967f, -0.03997294f, 0.07621809f, 0.03252758f, 0.07156609f, 0.05474724f, 
    -0.10753576f, -0.15659401f, -0.14798321f, -0.00379213f, 0.02344171f, -0.06322324f, 0.01605837f, -0.03046601f, 
    0.16346277f, -0.01891245f, 0.01847942f, -0.04687798f, -0.02907507f, 0.27294829f, -0.01663670f, -0.09088831f, 
    0.05848867f, 0.01295549f, 0.01410165f, 0.01872131f, -0.06366137f, -0.02759814f, -0.04048722f, 0.10495812f, 
    -0.29264855f, -0.00940852f, -0.17375018f, -0.06468280f, 0.12034842f, 0.01201321f, -0.01017321f, 0.06578590f, 
    -0.00434124f, -0.03840455f, 0.11030315f, -0.05457325f, 0.18789989f, -0.08338957f, -0.17792460f, -0.00055321f, 
    0.00272390f, 0.05218534f, -0.04991836f, 0.12931858f, 0.04225169f, 0.05150363f, -0.01578366f, 0.04014763f, 
    0.05171842f, -0.20288417f, -0.12540671f, -0.07231957f, -0.13458014f, 0.13479760f, -0.03198127f, -0.02151240f, 
    -0.02046457f, 0.07303328f, 0.00532048f, 0.05166020f, -0.21624482f, -0.12756133f, -0.09462111f, -0.18586807f, 
    -0.03572146f, -0.00560860f, 0.03301989f, -0.00864181f, -0.01573370f, 0.11895366f, -0.06793091f, 0.08155324f, 
    0.22374605f, 0.28665236f, 0.21272705f, -0.16040449f, 0.04294126f, -0.07621604f, -0.08513016f, 0.07120841f, 
    0.05985678f, -0.03400322f, 0.00622187f, -0.14381161f, 0.08957609f, -0.18566574f, 0.00803107f, -0.00794688f, 
    -0.01221542f, 0.04819652f, -0.06019782f, 0.04599028f, -0.03297558f, -0.09246520f, 0.02370557f, -0.14919439f, 
    0.04690972f, 0.34585008f, 0.07801162f, 0.24914381f, -0.13647571f, 0.07467151f, 0.20222223f, 0.05531587f, 
    0.06338666f, -0.00876298f, 0.05529105f, -0.14112410f, -0.29004756f, 0.08147942f, -0.15086006f, -0.00060405f, 
    0.08259539f, 0.05629531f, -0.05730225f, 0.08045135f, 0.01946989f, -0.07042853f, 0.03754368f, -0.11996937f, 
    0.00035909f, 0.40157750f, 0.26868957f, -0.08852374f, 0.02620047f, 0.01105031f, 0.08900586f, 0.00104840f, 
    0.03411482f, -0.05025939f, 0.04630833f, -0.02596812f, -0.29218733f, -0.03957802f, 0.03461555f, -0.14426111f, 
    -0.06567349f, -0.01784072f, -0.07673200f, 0.05412679f, 0.12496830f, -0.05531146f, -0.01932595f, 0.00734125f, 
    -0.26426622f, 0.06821869f, -0.20549011f, -0.10605567f, 0.04086224f, -0.03627459f, -0.01286778f, 0.01597726f, 
    -0.03150065f, -0.04097869f, 0.03962140f, 0.06511783f, 0.18536814f, 0.07074572f, 0.16242483f, -0.07436031f, 
    -0.00543214f, 0.01680112f, -0.00739583f, 0.09781516f, -0.06754713f, -0.18369401f, 0.03351606f, 0.12230095f, 
    0.13636339f, -0.20207061f, 0.11032387f, -0.39376956f, 0.14181679f, 0.00423218f, 0.07497112f, 0.05345507f, 
    0.07433654f, 0.10410761f, -0.08023181f, -0.00092995f, -0.08067424f, 0.03461606f, -0.11026786f, -0.08879100f, 
    0.00916154f, -0.02945240f, -0.10035924f, 0.03699772f, 0.00622019f, 0.07401035f, 0.02892428f, 0.03783942f, 
    -0.12714209f, -0.02909779f, -0.19456369f, 0.12106772f, 0.08549646f, 0.04611562f, 0.10134386f, -0.01437314f, 
    -0.09140092f, -0.02828923f, -0.04426918f, 0.12599128f, 0.24062072f, 0.33717278f, 0.27045882f, -0.09133806f, 
    -0.02235444f, 0.05298579f, 0.03276096f, 0.12742269f, 0.15440100f, 0.02904170f, -0.00601121f, 0.04710231f, 
    -0.01399197f, -0.17707971f, 0.11742277f, 0.15049925f, -0.06014715f, 0.02633217f, 0.01117562f, 0.04233940f, 
    -0.11358099f, -0.03500421f, -0.02982521f, -0.10826395f, -0.23472288f, -0.03263726f, -0.08317203f, -0.06722598f, 
    0.05416474f, -0.10830522f, 0.07511814f, -0.14450148f, 0.07219038f, -0.06685468f, 0.08473743f, 0.07916442f, 
    0.27894065f, 0.46113986f, 0.19236469f, -0.07700132f, -0.04248799f, 0.02740721f, 0.04651459f, 0.00825396f, 
    0.02205381f, 0.04116000f, 0.03832549f, 0.03654402f, -0.10922457f, -0.10366724f, -0.11581949f, -0.08410721f, 
    0.03601161f, 0.01922025f, 0.02470975f, 0.03882057f, -0.00573070f, -0.08825279f, -0.00132368f, -0.03644515f, 
    -0.02681364f, 0.02003589f, -0.06660866f, 0.15307651f, -0.03202371f, 0.05776693f, 0.06695735f, -0.12407324f, 
    -0.06471460f, -0.05053364f, -0.02778785f, 0.03183736f, 0.20931284f, 0.13126411f, -0.00000963f, 0.11375938f, 
    0.03418449f, -0.00582382f, -0.01622005f, -0.02199613f, 0.03258869f, -0.00240936f, -0.06666362f, 0.13058706f, 
    0.34477162f, 0.04971259f, 0.15385573f, 0.01010949f, 0.04455999f, 0.04125342f, 0.06982960f, -0.00220223f, 
    -0.02223918f, -0.00989158f, 0.03645575f, 0.03862964f, 0.13628435f, -0.04059428f, 0.12204809f, -0.10400189f, 
    0.22649929f, -0.04264418f, 0.03777295f, 0.05100312f, 0.02350601f, 0.00190327f, -0.01491490f, 0.09585693f, 
    0.02743075f, -0.08170195f, -0.01540019f, -0.04374955f, 0.16609330f, -0.11431023f, 0.13441886f, 0.05835255f, 
    -0.13740391f, -0.14837825f, -0.01788857f, 0.00229699f, 0.17182468f, 0.00696272f, 0.08638950f, 0.05908622f, 
    -0.01450913f, 0.06883970f, 0.05463251f, 0.06946731f, 0.00388905f, 0.03736896f, -0.01402747f, -0.05935553f, 
    -0.11909848f, -0.22903153f, -0.10546472f, 0.07657436f, -0.02555670f, 0.00298019f, -0.02163382f, -0.10254130f, 
    -0.00218538f, -0.03748948f, -0.00065756f, -0.12643179f, -0.10609078f, -0.10275978f, -0.16508152f, -0.03569334f, 
    -0.00364148f, -0.02433128f, 0.05379060f, 0.05582346f, -0.02460147f, 0.10006527f, -0.09918121f, -0.00345953f, 
    0.06971461f, 0.18463452f, -0.04828143f, -0.14098038f, 0.18806535f, 0.03757850f, 0.00230039f, 0.02317410f, 
    -0.02981552f, 0.07121864f, -0.13366267f, -0.01078391f, -0.03131429f, -0.04245334f, -0.05705589f, -0.14844072f, 
    0.16729046f, 0.01021861f, 0.01048135f, 0.03134953f, 0.02409589f, 0.02368569f, 0.07807761f, -0.00557679f, 
    0.08044579f, -0.14664480f, 0.04046662f, -0.03282022f, 0.05577162f, 0.14821164f, -0.03640427f, 0.01288140f, 
    -0.06548463f, 0.06175589f, 0.03215956f, -0.01922214f, -0.11583911f, -0.35816866f, -0.19725585f, 0.01759474f, 
    -0.12551239f, 0.06631676f, 0.12835352f, -0.01234388f, -0.03988072f, 0.13448741f, 0.01957564f, 0.06460353f, 
    0.21906929f, 0.00554548f, 0.05940752f, -0.21863587f, -0.14744492f, 0.03818525f, 0.06955328f, 0.08486437f, 
    0.06909547f, 0.03642718f, 0.06001063f, 0.08374609f, 0.12581722f, 0.30444393f, 0.20200263f, -0.04957494f, 
    0.07010926f, 0.01319210f, 0.18902403f, 0.08835601f, 0.05894766f, 0.05807675f, -0.01985597f, 0.08610384f, 
    -0.34493828f, 0.01807711f, -0.00715902f, -0.15431847f, 0.00494522f, 0.01421221f, -0.01626482f, -0.01109655f, 
    0.03964406f, -0.02250813f, 0.08504636f, -0.06386426f, -0.03486659f, -0.05039088f, -0.06018383f, 0.00478933f, 
    0.11227898f, -0.03006662f, 0.07796898f, 0.11064959f, -0.05796600f, -0.14813955f, 0.10028516f, -0.11441146f, 
    0.19212128f, -0.01486036f, -0.16317408f, -0.01465639f, -0.00831703f, 0.11173947f, 0.06256321f, -0.04501363f, 
    -0.01477952f, -0.00192502f, 0.05814325f, -0.04394891f, -0.02317351f, 0.04577418f, 0.02545691f, -0.07409007f, 
    0.03694599f, 0.09188858f, -0.02588663f, 0.04603322f, -0.00496425f, 0.01017321f, -0.07652720f, 0.09178597f, 
    -0.07044175f, 0.07064160f, 0.10474525f, -0.01324237f, -0.05080267f, -0.02128394f, -0.01370205f, -0.00201620f, 
    -0.13756092f, -0.04227434f, 0.00149893f, 0.07565998f, 0.35070968f, 0.36471245f, 0.19547187f, 0.04173453f, 
    -0.02029913f, 0.00653356f, -0.01346288f, 0.01723739f, -0.01604901f, 0.04557647f, 0.01822933f, -0.13168643f, 
    -0.06325006f, -0.32803378f, 0.13369146f, -0.12259814f, 0.03036820f, 0.00189316f, 0.08321176f, -0.04632162f, 
    0.05865445f, -0.00999046f, 0.06401674f, 0.19217959f, 0.04027416f, -0.17221643f, -0.05606971f, 0.06211958f, 
    -0.15798271f, 0.05395203f, 0.06429102f, 0.00472764f, 0.03653146f, 0.01925629f, -0.00507530f, -0.02069727f, 
    0.00163033f, 0.32835686f, 0.15870522f, 0.20361213f, 0.05064575f, 0.05215795f, 0.08418322f, 0.09367871f, 
    -0.02236350f, 0.12841612f, -0.01175501f, 0.11359221f, -0.11387600f, 0.08891913f, 0.29321101f, -0.18821970f, 
    0.01302862f, 0.02388510f, -0.03028979f, 0.05924396f, 0.02259407f, -0.04266771f, -0.05615287f, 0.08655286f, 
    -0.20511112f, -0.16722374f, -0.24314281f, -0.05158256f, -0.00024421f, -0.07515524f, 0.01153480f, -0.05519913f, 
    -0.00531864f, 0.08928292f, 0.02725069f, 0.10422837f, 0.48343161f, 0.22882770f, 0.11559820f, 0.08090936f, 
    0.06072855f, 0.01905847f, 0.04638947f, 0.11662655f, 0.01068596f, 0.05459453f, -0.02321094f, 0.03696593f, 
    -0.24934177f, -0.22895002f, -0.01610583f, -0.02316341f, 0.05336907f, 0.04517641f, -0.06405925f, 0.07974916f, 
    0.02223298f, 0.14681631f, 0.02321962f, 0.03893886f, 0.29391679f, 0.06197903f, 0.17085682f, 0.19345818f, 
    -0.02796226f, -0.05498663f, 0.20402342f, 0.06857745f, -0.02133240f, 0.00670837f, 0.13645776f, -0.10637975f, 
    0.25168201f, 0.11104289f, -0.07242575f, 0.11711461f, 0.02088929f, 0.05818195f, 0.16318668f, 0.02758887f, 
    0.01306720f, 0.01048902f, 0.03110844f, -0.15109932f, -0.10384940f, -0.15417218f, -0.05794771f, -0.01928839f, 
    0.05811600f, -0.02005815f, -0.01973091f, -0.00149332f, -0.07000674f, -0.10500067f, -0.12595172f, -0.02617896f, 
    0.02452282f, -0.15732296f, 0.02479047f, -0.01465470f, 0.08633173f, 0.00326646f, 0.03485075f, 0.04301571f, 
    0.10348699f, 0.01848119f, 0.06911332f, 0.08620784f, 0.23443668f, 0.23954926f, 0.22311124f, -0.02635692f, 
    0.04073272f, 0.08658034f, -0.09667041f, 0.02852459f, -0.04771443f, -0.06443692f, 0.04189144f, -0.13996285f, 
    0.15141843f, 0.11467507f, 0.16559048f, 0.03147945f, -0.06359955f, 0.02882782f, 0.01758068f, -0.02001237f, 
    0.05625596f, -0.16758727f, -0.09680772f, -0.04379631f, 0.15461752f, -0.01248384f, 0.05090193f, -0.10075311f, 
    0.00638673f, 0.02530027f, -0.03678761f, -0.11247426f, -0.09316038f, 0.00737520f, 0.01656262f, 0.11120071f, 
    -0.01385135f, -0.07282203f, 0.04607819f, 0.12406643f, 0.07019667f, -0.11013508f, 0.05186381f, 0.00478770f, 
    0.04329276f, -0.01561490f, 0.01276225f, -0.00708497f, 0.14119151f, 0.07951195f, 0.23960471f, 0.03545412f, 
    0.00886772f, 0.11863923f, 0.07745928f, 0.05229912f, -0.03061185f, 0.03447779f, 0.01226614f, -0.10991739f, 
    0.41984496f, 0.27509758f, 0.23428895f, 0.09710207f, -0.00012112f, 0.02338534f, 0.14916925f, -0.09796161f, 
    -0.00469007f, -0.01710409f, -0.00339724f, -0.19226043f, -0.17234658f, -0.30114692f, -0.01325187f, 0.05684178f, 
    -0.02144129f, -0.02183436f, 0.06021566f, -0.03154700f, -0.05611428f, 0.11563412f, 0.07534416f, 0.06983433f, 
    0.32390517f, 0.03834749f, 0.04772632f, 0.14124347f, -0.11162057f, -0.01043724f, 0.08381831f, 0.06160102f, 
    -0.03309028f, -0.05837786f, 0.03156694f, 0.03721986f, 0.36211210f, 0.38177493f, 0.21981563f, 0.09549032f, 
    0.03429708f, -0.02173860f, 0.04534329f, 0.09373220f, 0.04918963f, 0.00623493f, -0.11645719f, 0.11756131f, 
    -0.00992953f, 0.01828854f, -0.01953053f, 0.02922005f, -0.02035666f, 0.02531020f, -0.01691147f, 0.02340259f, 
    -0.00240699f, 0.02786937f, 0.01644552f, -0.00670082f, -0.03974950f, -0.03411274f, -0.00229716f, -0.01813912f, 
    -0.02165100f, 0.02990694f, -0.02185286f, 0.00704171f, -0.02713791f, -0.01995404f, 0.02231026f, 0.00412666f, 
    0.02825410f, -0.01074052f, 0.00895600f, 0.01476082f, -0.01279892f, -0.02545269f, -0.01149472f, -0.00481958f, 
    -0.02342966f, -0.02615783f, 0.01163454f, 0.02168619f, -0.00638477f, -0.01881381f, -0.02813080f, -0.00763958f, 
    -0.01665704f, -0.03908148f, -0.02139946f, -0.02222375f, -0.01499743f, -0.02953833f, 0.02266711f, -0.03474681f, 
    0.01599643f, -0.01457564f, 0.00360359f, -0.00447336f, 0.01101572f, -0.04078973f, -0.00252611f, -0.03827813f, 
    0.02578451f, -0.03296069f, -0.01106837f, 0.00310356f, -0.01465097f, -0.02610598f, 0.01955676f, 0.01708192f, 
    -0.02980330f, -0.00575634f, -0.00878035f, -0.03102069f, -0.03754358f, -0.02259467f, -0.04021420f, 0.02620020f, 
    -0.02747464f, -0.00227071f, -0.03393266f, -0.03975615f, 0.02506274f, 0.01767841f, -0.04141543f, -0.01394054f, 
    -0.01301152f, -0.01841212f, -0.02081591f, -0.01737724f, -0.03447048f, 0.01404882f, 0.02852831f, 0.00096396f, 
    0.00112198f, 0.01966609f, -0.00231572f, -0.03430628f, -0.03650432f, 0.01419833f, -0.02672681f, 0.01701684f, 
    -0.03423714f, -0.03817676f, -0.01229362f, -0.00293361f, -0.02570371f, -0.00645833f, -0.01083519f, -0.01011667f, 
    0.02309250f, 0.01415261f, -0.03992448f, -0.01825744f, 0.02514764f, -0.01532575f, -0.02401906f, 0.01839977f, 
    -0.00405987f, 0.02167637f, 0.01152030f, -0.02938374f, -0.04062213f, -0.01832684f, -0.00875581f, -0.03653577f, 
    0.02287989f, -0.03976669f, 0.01016845f, -0.02784583f, -0.03600725f, -0.01357967f, -0.02848413f, -0.03644927f, 
    -0.01107968f, -0.01005723f, -0.00410186f, 0.02019212f, -0.03363299f, -0.01044283f, -0.02260782f, -0.02723859f, 
    -0.00471018f, 0.01858045f, -0.01616835f, 0.01570861f, -0.02979091f, -0.00064971f, -0.01807463f, -0.02249193f, 
    0.02925902f, 0.00255922f, -0.03260345f, 0.01822631f, 0.01455666f, -0.00793558f, 0.01612174f, -0.03846386f, 
    0.01276619f, -0.00542994f, -0.04152965f, -0.01859774f, -0.01113724f, 0.00875403f, 0.01323659f, -0.00780596f, 
    -0.01794355f, -0.00800366f, -0.02802585f, -0.03345558f, -0.00754602f, -0.03965775f, 0.01452511f, -0.00318706f, 
    -0.03656135f, 0.00503646f, -0.02519049f, -0.03300290f, 0.01562073f, 0.01094868f, 0.01401497f, 0.01336904f, 
    0.00690070f, -0.03037424f, -0.01110498f, 0.01786793f, 0.01688218f, -0.02141752f, 0.01613835f, 0.01190758f, 
    0.01007027f, -0.04028705f, -0.02271021f, -0.01767567f, 0.00219525f, -0.03030261f, 0.02686610f, -0.00043551f, 
    0.02913796f, -0.00861168f, 0.02099987f, -0.02447028f, 0.00723223f, 0.02761274f, -0.02615850f, -0.03031018f, 
    0.02735474f, 0.00770607f, -0.03179224f, -0.02475471f, -0.01196851f, -0.03973608f, -0.02413209f, -0.03492488f, 
    0.00482312f, -0.03620920f, 0.00160279f, -0.03785795f, -0.00651616f, 0.01581122f, 0.02780743f, -0.03191237f, 
    0.00047316f, -0.03780097f, -0.00381219f, -0.01403722f, -0.03957893f, -0.03379695f, 0.01805982f, 0.02512706f, 
    0.02363157f, -0.04176787f, 0.02272111f, 0.02151314f, 0.01749327f, 0.01170313f, 0.02679898f, -0.02091006f, 
    -0.03146450f, 0.00565687f, -0.01298663f, -0.02950327f, 0.00776371f, -0.02579707f, -0.02194577f, -0.03786937f, 
    0.01329610f, 0.00096973f, 0.02187909f, -0.03325663f, 0.00642916f, 0.02191947f, 0.02934438f, 0.00601389f, 
    0.01420513f, -0.01400225f, -0.02710375f, 0.02522080f, 0.02515886f, 0.02401140f, 0.00717077f, 0.01808423f, 
    0.02641663f, 0.02030670f, -0.03966338f, 0.01406916f, -0.04005359f, -0.01344945f, 0.00714762f, -0.01120277f, 
    0.02176575f, -0.01823019f, 0.01606985f, -0.03099031f, -0.02062288f, -0.01068045f, -0.02455947f, -0.00496101f, 
    0.01180500f, -0.01049238f, -0.03668687f, -0.00568417f, 0.01509202f, 0.02254398f, 0.02233324f, 0.01041141f, 
    0.01454161f, -0.04133089f, -0.03957349f, -0.03543296f, -0.03825723f, 0.01913495f, -0.03461649f, -0.02999243f, 
    -0.01578378f, 0.02032553f, -0.00182944f, -0.02432426f, -0.02301652f, -0.00424914f, 0.01768250f, -0.01119546f, 
    -0.01621377f, 0.02201574f, -0.00722129f, 0.01999896f, 0.00500922f, 0.01994489f, -0.00929360f, -0.03883874f, 
    -0.00181220f, -0.01958110f, -0.03684268f, 0.02615451f, -0.03407052f, -0.03368104f, 0.02311254f, 0.02138020f, 
    0.01663862f, -0.00025320f, -0.03469045f, -0.00126423f, -0.03857167f, -0.00372439f, 0.01418961f, 0.02490025f, 
    0.01467479f, -0.03257137f, 0.00522258f, 0.02734448f, -0.01557615f, -0.04176740f, 0.01057778f, 0.01835154f, 
    -0.04177596f, 0.02932709f, -0.02875608f, 0.01320723f, -0.00597101f, -0.03881030f, -0.02745041f, -0.01205826f, 
    -0.01309157f, 0.00941726f, -0.02810171f, 0.01386731f, -0.00978495f, -0.00876436f, -0.03004023f, -0.03670742f, 
    -0.00218548f, 0.01917495f, 0.03003151f, -0.04034081f, -0.04070776f, -0.03579248f, 0.01835459f, -0.02126317f, 
    0.01320859f, 0.01289993f, -0.00405902f, 0.01182615f, 0.01491459f, 0.01178206f, 0.00558361f, 0.00756044f, 
    -0.03861088f, -0.02775692f, -0.01363902f, -0.00252091f, -0.02263503f, -0.04122853f, -0.00569630f, -0.01651284f, 
    0.01285868f, 0.02478187f, 0.01426694f, -0.03384432f, 0.02396208f, -0.02113113f, -0.00650385f, -0.00644733f, 
    0.01388993f, -0.03936556f, -0.02108630f, 0.01429914f, 0.02462385f, -0.03761008f, -0.03799668f, -0.00183173f, 
    -0.02640825f, -0.01899074f, 0.00657244f, -0.02156036f, -0.01465918f, -0.03000833f, -0.02538718f, -0.03198945f, 
    -0.00836406f, 0.02240761f, -0.03833739f, 0.01855639f, -0.00512264f, -0.00572572f, -0.00752352f, -0.01738199f, 
    -0.02395072f, -0.04206131f, -0.02265595f, -0.03847658f, -0.02552203f, 0.01007010f, -0.03492038f, 0.01867862f, 
    -0.03615118f, -0.00744038f, 0.01617584f, 0.02126376f, -0.03571390f, -0.02021654f, -0.01072929f, -0.03723560f, 
    -0.01830339f, -0.03226973f, 0.02672318f, -0.00558124f, 0.01163676f, 0.00985415f, 0.01182017f, -0.01782819f, 
    -0.02201615f, -0.01987081f, -0.02244756f, -0.03847905f, -0.02517862f, -0.03238339f, -0.02141440f, 0.00845476f, 
    0.00151416f, -0.03120230f, -0.00439170f, 0.01016247f, 0.02582731f, -0.03342127f, -0.04129408f, 0.02650521f, 
    -0.04141893f, 0.02153668f, -0.01625716f, -0.01791427f, -0.02795313f, -0.02644306f, -0.02740863f, -0.03100878f, 
    -0.02801135f, 0.01094276f, 0.02023030f, 0.01885023f, -0.01206266f, 0.02913584f, -0.03334703f, -0.00551801f, 
    0.01848176f, -0.00085143f, 0.01075438f, -0.00604121f, -0.02158013f, 0.02981805f, 0.01864163f, -0.01951159f, 
    0.01684744f, 0.00676546f, -0.01004264f, -0.03274926f, -0.02957538f, -0.02186851f, 0.00676860f, -0.03631458f, 
    -0.02660422f, 0.00745038f, -0.02532216f, -0.03483217f, 0.01577491f, -0.03372677f, -0.03654704f, -0.00459233f, 
    -0.01028633f, 0.02888265f, -0.02685379f, 0.00693558f, 0.01593626f, 0.02000688f, -0.02058985f, -0.01376303f, 
    0.02407482f, 0.00672126f, 0.00323838f, 0.01698889f, 0.00291049f, -0.01569069f, -0.00184366f, -0.01792725f, 
    0.00679361f, -0.01452042f, 0.01287968f, -0.00117480f, -0.02988412f, 0.01291925f, -0.00378713f, -0.01152264f, 
    -0.00199471f, -0.01460040f, -0.03744230f, -0.00896836f, 0.01932996f, -0.03381203f, -0.02136863f, 0.00266121f, 
    -0.03367604f, 0.02897139f, -0.02107872f, -0.02580835f, 0.00385270f, -0.01232897f, 0.00668556f, -0.02693820f, 
    0.01253104f, -0.04086309f, -0.01438678f, -0.01899104f, 0.00849456f, 0.00570690f, -0.00383417f, 0.01131181f, 
    -0.00904069f, -0.02811494f, -0.01503884f, 0.01725532f, -0.01475304f, -0.02770323f, -0.01863529f, -0.01726053f, 
    -0.03029472f, -0.02739770f, -0.00806300f, -0.00827974f, -0.01097058f, -0.00915835f, 0.01161045f, -0.02818066f, 
    -0.02799890f, 0.02131092f, -0.03608506f, -0.01786259f, 0.02343395f, -0.02825006f, -0.03368088f, 0.02091317f, 
    -0.03070403f, 0.02010124f, -0.01666318f, -0.03026902f, 0.00409577f, 0.00968627f, -0.02205863f, -0.00950404f, 
    -0.03004291f, -0.01003960f, 0.00903190f, 0.00920889f, -0.01603307f, 0.00968429f, -0.02726411f, -0.00871551f, 
    0.01799734f, 0.01730290f, 0.01182759f, 0.02117710f, -0.02689990f, 0.01062022f, -0.01257060f, -0.00851883f, 
    -0.01585807f, 0.01601518f, 0.00611175f, -0.00107244f, -0.01670782f, 0.02838458f, -0.00191375f, -0.03873893f, 
    -0.01879140f, -0.04091980f, -0.03565269f, 0.01307069f, -0.03946154f, 0.02155218f, -0.01334371f, 0.02598665f, 
    0.01191344f, -0.00927659f, -0.04051267f, 0.01566257f, 0.00615441f, 0.00416339f, -0.02508830f, -0.00766749f, 
    -0.02049653f, -0.00516610f, 0.00946776f, 0.01369070f, 0.00199151f, -0.00372690f, -0.01632286f, 0.02832108f, 
    -0.02655245f, -0.01304595f, -0.04196230f, -0.00038027f, 0.02296790f, 0.02589116f, -0.01273884f, -0.02812882f, 
    0.00955385f, 0.02443852f, 0.01586323f, -0.01688493f, 0.01834552f, 0.00955328f, -0.01596635f, 0.01732834f, 
    0.00737500f, -0.03619018f, -0.00971211f, -0.01657857f, -0.00404039f, 0.02946193f, -0.02424659f, 0.01493872f, 
    0.01365309f, -0.03485778f, 0.02261798f, -0.02836959f, -0.01727337f, 0.00162128f, -0.03005435f, 0.02444712f, 
    0.02986224f, 0.01338978f, 0.02835337f, 0.01237901f, 0.02806803f, 0.00081153f, -0.03049020f, -0.03836319f, 
    -0.00862674f, -0.01039890f, -0.01423899f, 0.01428213f, -0.02402719f, -0.02656084f, 0.00485876f, -0.03227912f, 
    -0.03949874f, -0.03351564f, 0.02217769f, 0.01572565f, 0.01300542f, -0.00247717f, -0.02826954f, -0.00210295f, 
    -0.02670256f, 0.02743474f, -0.00244856f, -0.00029383f, 0.00194803f, -0.04152087f, 0.01550352f, -0.02064733f, 
    0.01513350f, 0.01307486f, 0.02302057f, -0.01455724f, 0.00817978f, -0.00943255f, 0.01988738f, 0.01402418f, 
    -0.04092631f, 0.02784486f, -0.01737959f, -0.01515188f, -0.02438652f, -0.00940459f, -0.01087499f, -0.01260212f, 
    -0.01532255f, -0.01973940f, -0.02382391f, -0.03340070f, 0.02772527f, 0.02461557f, 0.01615296f, 0.00389884f, 
    0.01922707f, -0.00380453f, 0.01708394f, -0.02543700f, 0.02052284f, -0.00784158f, 0.01319001f, 0.00232229f, 
    -0.02022882f, -0.03515058f, 0.02892777f, -0.02310483f, 0.01186920f, -0.02246435f, -0.03751970f, 0.02542664f, 
    0.02388388f, -0.01821650f, 0.01664475f, -0.00337267f, -0.03683956f, -0.02064906f, 0.01245178f, -0.00119860f, 
    0.00043950f, -0.03960502f, -0.02110473f, -0.03426781f, -0.01143481f, 0.02686164f, -0.01695667f, 0.02752016f, 
    0.02209955f, 0.00492680f, 0.00024971f, 0.02019987f, -0.01771187f, -0.01131588f, 0.01630640f, -0.03357505f, 
    -0.02049331f, -0.03782171f, -0.02832039f, -0.00090771f, 0.00419711f, -0.02118522f, -0.03419700f, 0.00598055f, 
    0.01588092f, 0.01251529f, -0.03106120f, -0.00823178f, 0.01390755f, 0.00146882f, 0.02891920f, -0.00077213f, 
    0.01418803f, -0.03874426f, 0.02941328f, -0.02393621f, -0.02878837f, 0.00124859f, -0.01038716f, 0.01926630f, 
    -0.02631501f, -0.03921754f, -0.02185793f, -0.02275726f, -0.03944403f, 0.01561186f, -0.00803675f, 0.00466110f, 
    -0.09486806f, -0.19169644f, 0.01608371f, -0.13842340f, -0.08625124f, -0.05465179f, -0.12964174f, 0.01235449f, 
    0.06388294f, 0.06249243f, 0.12260713f, 0.07664377f, 0.24910827f, 0.11165742f, -0.18050890f, 0.19324060f, 
    -0.06524198f, 0.04467113f, -0.05536758f, 0.12613645f, 0.06318920f, -0.03216996f, -0.05785906f, 0.01596450f, 
    0.02705475f, 0.06058064f, 0.04950019f, 0.04022370f, 0.03958785f, 0.01473446f, 0.08068177f, 0.03357672f, 
    0.01009320f, 0.14080447f, -0.01523979f, 0.07956780f, 0.28942937f, 0.05449629f, -0.10487960f, -0.24813618f, 
    0.08218624f, 0.03561898f, 0.05553490f, 0.09238125f, 0.02144813f, 0.03199359f, -0.04976452f, -0.02777359f, 
    -0.03850386f, -0.24618267f, -0.16228393f, -0.22159646f, -0.05012328f, -0.14413421f, -0.10916120f, 0.11759704f, 
    0.06234219f, -0.01598856f, 0.02618495f, -0.02099094f, -0.06624138f, -0.05009384f, -0.17578845f, 0.06639599f, 
    0.12489650f, 0.09291406f, 0.02262397f, 0.06644914f, 0.07845481f, -0.02923924f, 0.04710399f, -0.01335602f, 
    -0.00421230f, -0.20191537f, -0.20896229f, 0.07165256f, -0.04254724f, -0.01398090f, -0.05808346f, -0.02991864f, 
    0.16453461f, -0.04216901f, -0.18133521f, -0.09081843f, 0.06336405f, -0.09573592f, -0.03028478f, 0.00272982f, 
    0.09056903f, -0.06380761f, 0.05037622f, 0.17012042f, 0.06548307f, 0.00100943f, 0.00191597f, 0.06591587f, 
    -0.04336387f, -0.19874075f, -0.01609651f, -0.10075944f, -0.02184383f, 0.05852049f, 0.00386809f, 0.03939023f, 
    -0.01198708f, 0.04104732f, 0.15160280f, 0.00273554f, 0.34281138f, 0.12312797f, -0.33821169f, 0.10464640f, 
    0.01776390f, 0.00609207f, 0.00454576f, 0.12682079f, 0.01277727f, 0.08437898f, -0.08572844f, 0.08754755f, 
    -0.00679816f, 0.02132976f, 0.37949446f, 0.13248940f, 0.03916499f, -0.02869992f, 0.09791826f, 0.04228035f, 
    0.02229802f, 0.09671445f, -0.02922980f, 0.08594843f, -0.07020541f, -0.10960782f, 0.15693580f, 0.01096593f, 
    0.04425209f, 0.12173852f, -0.06208102f, 0.01534555f, 0.00136721f, 0.16414301f, -0.07381044f, -0.08238739f, 
    -0.27604377f, -0.15787268f, -0.06735153f, 0.02743118f, 0.02313135f, -0.04087682f, 0.04786602f, 0.04047722f, 
    0.11791354f, 0.07697537f, -0.16565071f, 0.07381403f, 0.11874470f, -0.16598596f, -0.08428972f, -0.31920901f, 
    -0.05024786f, -0.11426936f, 0.03922441f, -0.08133833f, 0.11594316f, 0.13764527f, 0.12007736f, 0.03204898f, 
    -0.09059825f, -0.12902622f, 0.44090843f, -0.06099062f, 0.02164059f, 0.00220782f, 0.03580284f, 0.08403113f, 
    0.05900356f, -0.03925855f, 0.04121540f, 0.05580629f, -0.20653857f, -0.01225233f, 0.12360553f, 0.18006670f, 
    0.04406511f, 0.08279216f, 0.04213350f, -0.07280899f, 0.06503110f, 0.11725155f, 0.01191395f, 0.21380264f, 
    0.15173219f, 0.11604790f, -0.11155812f, 0.06144626f, 0.17283866f, 0.10880034f, 0.04701187f, 0.11931146f, 
    0.07546070f, 0.09588814f, -0.00874962f, 0.00359529f, -0.10023371f, -0.05385964f, 0.11496045f, -0.07816188f, 
    0.11938222f, 0.00850508f, 0.08484979f, 0.22060487f, 0.09988134f, 0.04168834f, -0.04360013f, 0.18432450f, 
    -0.01896319f, -0.20467936f, 0.04248094f, -0.21177164f, -0.00751830f, 0.01801583f, 0.07325067f, 0.20055261f, 
    -0.01708601f, 0.01372495f, 0.00960273f, 0.05022826f, 0.07536910f, -0.22030297f, 0.25996444f, 0.06808493f, 
    -0.13610001f, 0.09048145f, -0.09861900f, 0.06715407f, 0.05263713f, 0.02779164f, -0.02718913f, 0.03773671f, 
    -0.10857785f, -0.02293637f, -0.13029268f, -0.32249922f, 0.06065768f, 0.08467605f, 0.11965469f, 0.02290880f, 
    0.14477140f, 0.11382907f, 0.00718280f, 0.07291774f, 0.05719158f, 0.01721544f, 0.00053220f, -0.05453019f, 
    0.09815089f, -0.04462158f, 0.10610795f, -0.11395732f, 0.02565325f, 0.07568608f, -0.05264676f, 0.13746025f, 
    -0.03932115f, -0.09934752f, 0.14735743f, -0.04574499f, -0.12658931f, -0.10890756f, 0.06671488f, -0.03251632f, 
    0.00862544f, 0.00464208f, 0.00700963f, 0.10060802f, 0.11043201f, -0.14667678f, -0.27177146f, -0.09185538f, 
    -0.03192652f, -0.01581625f, 0.04149258f, 0.03714340f, 0.05968559f, -0.02080663f, 0.01911001f, 0.10714806f, 
    -0.34667292f, -0.21961962f, 0.30085224f, -0.27990055f, -0.02772779f, 0.02531703f, 0.15274440f, 0.02627685f, 
    0.00559054f, 0.01331507f, -0.01529823f, -0.06688859f, 0.14590091f, 0.22019380f, 0.11153085f, -0.23642462f, 
    0.05573218f, 0.15072125f, 0.00495955f, 0.05804720f, 0.05803580f, 0.01292123f, 0.00936196f, 0.00981697f, 
    0.14475664f, -0.13410597f, -0.09678658f, -0.09349697f, 0.13344157f, 0.10904966f, -0.01697936f, 0.00211444f, 
    0.06922115f, -0.05138075f, -0.01058979f, 0.02597723f, 0.02684164f, 0.13585159f, -0.07721963f, 0.03067877f, 
    0.06208453f, -0.04541268f, 0.05029529f, 0.12500507f, -0.00023751f, 0.09720640f, 0.05428813f, 0.04919009f, 
    0.11842260f, -0.05095728f, -0.25432974f, -0.00758470f, 0.07920542f, 0.01830106f, 0.10639603f, 0.02862804f, 
    -0.01961835f, 0.00651112f, 0.03937661f, -0.03269091f, -0.20319349f, 0.11835261f, 0.15168756f, -0.06000856f, 
    -0.12833208f, -0.02915107f, -0.06741695f, 0.04334046f, 0.00006931f, 0.06404680f, 0.07572065f, 0.11267766f, 
    -0.08312266f, -0.08556796f, 0.01373590f, -0.35150337f, 0.03914882f, -0.01833019f, 0.09745399f, -0.03035236f, 
    -0.10267249f, -0.01376052f, -0.06893174f, 0.11913490f, 0.16353123f, -0.12016746f, -0.12505443f, -0.18754321f, 
    0.02198090f, -0.03990617f, 0.05883639f, 0.08950134f, 0.06974593f, 0.02973363f, -0.02916483f, 0.14767754f, 
    -0.25223476f, 0.05938226f, -0.16438153f, -0.12107369f, -0.07496513f, -0.06931424f, -0.01420521f, 0.12741338f, 
    0.03185466f, 0.09727547f, -0.05893892f, 0.00477014f, 0.04236601f, -0.15543903f, -0.13354374f, 0.30886644f, 
    -0.03185111f, 0.07091226f, 0.09217112f, -0.03874409f, 0.01641511f, 0.04897515f, 0.03771630f, 0.20564258f, 
    0.53032005f, 0.07476504f, -0.07370918f, 0.27951357f, 0.00264882f, -0.00517909f, 0.00519125f, 0.01033155f, 
    0.07336019f, 0.05093432f, -0.00198382f, 0.05138976f, 0.29968777f, -0.19089293f, -0.21167436f, 0.00108574f, 
    -0.06527417f, 0.02895760f, 0.01180362f, 0.08696970f, 0.00956001f, 0.03131201f, 0.03575845f, -0.00057581f, 
    -0.10873653f, 0.46280080f, 0.02888027f, -0.21205099f, 0.11423248f, 0.06319119f, 0.07949204f, 0.06996187f, 
    0.01988865f, 0.10277063f, 0.02106234f, 0.03568539f, -0.13982217f, -0.23992096f, 0.03492314f, -0.00820338f, 
    0.00914297f, 0.13993789f, 0.10614441f, -0.00156108f, 0.01632699f, 0.09683668f, 0.03671220f, 0.07745706f, 
    0.11084584f, -0.06186706f, 0.00410210f, -0.02148682f, -0.18653639f, -0.06754749f, 0.08342269f, -0.02611501f, 
    -0.00692059f, 0.05029016f, -0.10442273f, 0.03681737f, 0.26569501f, 0.21344410f, -0.08361028f, 0.02061344f, 
    0.06370596f, -0.08506864f, -0.03348512f, 0.06870014f, -0.06214995f, -0.05299944f, 0.13460974f, -0.06270557f, 
    -0.22595209f, 0.05212919f, 0.25660923f, 0.04398241f, 0.17596436f, 0.00737396f, -0.01264716f, -0.01464950f, 
    0.09707460f, -0.07692301f, -0.05917097f, 0.02710423f, 0.22450604f, 0.13196793f, 0.28496408f, -0.22935459f, 
    0.06087495f, 0.16874874f, 0.06780525f, 0.04221794f, -0.04188119f, 0.09125412f, 0.05827864f, 0.07127019f, 
    0.10573256f, 0.00377365f, 0.09850328f, -0.18926565f, 0.00547086f, -0.04117311f, -0.01609018f, 0.04314419f, 
    0.08998144f, 0.04400981f, 0.06684452f, -0.09007432f, -0.26985255f, 0.02911008f, 0.40738019f, 0.01884404f, 
    -0.00422443f, 0.04178923f, -0.04768074f, 0.03098998f, 0.02813291f, 0.08682405f, 0.02488150f, 0.09738817f, 
    0.16554539f, 0.13637161f, -0.05291536f, -0.01356998f, 0.05146129f, -0.02357661f, -0.06325519f, -0.00481118f, 
    0.17548932f, 0.08978196f, -0.02087638f, 0.05001126f, -0.30753005f, -0.21849023f, 0.17077297f, -0.20829794f, 
    -0.07737716f, -0.06257124f, -0.05181223f, 0.05267596f, -0.02662033f, -0.06781337f, -0.02781649f, 0.01034835f, 
    -0.16638340f, -0.04743730f, 0.13993283f, 0.19212498f, 0.00034141f, -0.07490570f, -0.01102179f, 0.01522190f, 
    0.04168207f, -0.06953695f, -0.12869975f, 0.19192536f, -0.15993816f, 0.08728053f, 0.01431072f, 0.06091500f, 
    -0.01673053f, 0.06793994f, 0.08955371f, 0.01891079f, 0.16101649f, 0.00494091f, 0.06700677f, 0.13000180f, 
    0.07927254f, -0.08528067f, -0.18600073f, -0.19592227f, -0.09370510f, -0.08796863f, -0.08365416f, 0.15626718f, 
    0.14490163f, 0.00342737f, 0.09679433f, -0.00441579f, -0.19968137f, 0.24991889f, 0.07157134f, 0.08047638f, 
    -0.02526143f, 0.09267822f, -0.05652550f, 0.08856431f, -0.08328684f, 0.04615036f, 0.07279515f, 0.04011833f, 
    0.34640375f, -0.08880634f, -0.13123582f, -0.01811702f, 0.09545174f, -0.03963684f, -0.02651082f, 0.10130081f, 
    0.03854228f, 0.06796357f, -0.04055927f, -0.02625388f, 0.01471470f, -0.24236888f, 0.13009432f, 0.09106144f, 
    -0.00563052f, 0.06122866f, 0.04373433f, -0.04678635f, 0.13310970f, -0.09038398f, 0.01314866f, 0.05348905f, 
    0.00732826f, -0.15390812f, 0.35425520f, 0.13644303f, -0.04589231f, 0.05987845f, 0.05050202f, 0.04345278f, 
    -0.04433505f, 0.09036142f, 0.06178954f, 0.07846387f, 0.09797677f, 0.01720987f, 0.02340525f, -0.11676946f, 
    0.17722484f, 0.11304656f, 0.09197246f, 0.00435287f, 0.06717335f, 0.02478345f, -0.04589788f, -0.03506021f, 
    -0.02020750f, -0.08003064f, 0.06053656f, -0.10270255f, 0.13635881f, -0.02249361f, 0.01156049f, -0.04860223f, 
    0.07255495f, 0.04079392f, 0.02772591f, -0.03487046f, -0.08373778f, -0.11688041f, -0.00938128f, 0.10994088f, 
    0.10281716f, -0.02598808f, 0.03820260f, 0.02763325f, 0.11733103f, 0.10043888f, 0.14619912f, 0.02322641f, 
    0.05472922f, 0.03684718f, 0.27324229f, 0.06401034f, -0.02773968f, 0.04481431f, 0.10206292f, 0.05715869f, 
    0.01113319f, 0.06346029f, 0.00460852f, 0.03243265f, -0.06552816f, 0.24458539f, -0.03443026f, 0.14801051f, 
    0.00072203f, -0.02039633f, -0.01720544f, 0.05539906f, 0.07537684f, 0.05779129f, 0.08772083f, 0.03987740f, 
    -0.04640002f, -0.19662309f, 0.22694138f, 0.02100569f, 0.02623873f, 0.11382935f, 0.07021566f, 0.03937547f, 
    0.06106626f, 0.04777227f, -0.00633653f, 0.01564102f, -0.12895902f, -0.08044323f, -0.09698460f, -0.10641190f, 
    0.07840548f, 0.14848840f, 0.04790964f, -0.04350335f, -0.03066372f, 0.04389723f, 0.09327979f, 0.00215875f, 
    0.09766755f, 0.16172960f, -0.00084065f, -0.18658185f, 0.15115066f, 0.02300182f, 0.10080677f, 0.02361912f, 
    -0.00617227f, -0.06080158f, 0.02896052f, 0.05281765f, 0.20518282f, -0.24416375f, -0.03833881f, -0.07319045f, 
    0.02461230f, 0.09837677f, 0.07744890f, 0.08717381f, -0.02242876f, -0.02175029f, -0.01594873f, 0.04986239f, 
    -0.07589144f, 0.21075363f, -0.04038186f, 0.08655760f, -0.09077897f, 0.06258596f, 0.14546445f, 0.01039860f, 
    0.05342806f, -0.03200837f, 0.05315089f, 0.05254394f, -0.23185223f, -0.00990444f, -0.03424386f, -0.08149434f, 
    0.05198134f, 0.18595761f, 0.00857648f, -0.05781094f, 0.05520837f, -0.01375907f, -0.07403400f, -0.00037752f, 
    -0.02484004f, 0.02755711f, -0.00465861f, -0.02719681f, -0.03526793f, 0.00803692f, 0.00257016f, -0.00163032f, 
    -0.01533069f, -0.02991786f, -0.02685531f, 0.02980763f, 0.02950701f, -0.01251985f, 0.01958716f, -0.00857400f, 
    0.02505525f, -0.00879205f, 0.00320782f, -0.03398037f, -0.00271659f, -0.01599449f, 0.00872783f, 0.00748040f, 
    -0.03461576f, 0.01781893f, 0.02077422f, -0.01389037f, 0.01145244f, 0.02686634f, -0.03361034f, -0.02335577f, 
    -0.03480234f, 0.01953539f, -0.04033133f, -0.01206877f, -0.03105679f, -0.01181924f, 0.02727603f, -0.02085424f, 
    -0.00964527f, -0.03006275f, 0.00799145f, 0.02343865f, 0.01465783f, 0.00264926f, 0.00609106f, 0.02530739f, 
    0.02351694f, 0.01898808f, 0.00975809f, 0.01535968f, -0.00202049f, -0.02717696f, -0.00468762f, -0.00376977f, 
    -0.02436887f, -0.02052483f, 0.01653374f, -0.01794722f, -0.00429530f, -0.01665011f, -0.01993714f, -0.02070609f, 
    -0.04117826f, 0.01366012f, -0.03265112f, -0.02489691f, -0.00129464f, 0.00317618f, -0.03496212f, -0.03378533f, 
    -0.02748810f, -0.01083880f, -0.01352461f, -0.01005643f, 0.00415662f, 0.00456363f, -0.02798088f, 0.01660650f, 
    -0.01829694f, -0.02296037f, -0.02710622f, -0.02424355f, -0.02749241f, -0.02568554f, 0.02963284f, -0.03392514f, 
    0.01688655f, -0.00391124f, 0.02142793f, -0.02558899f, -0.01464333f, -0.03484876f, -0.02683340f, -0.01049030f, 
    0.02328940f, 0.03446615f, -0.01240556f, -0.03752228f, 0.02001960f, -0.02750926f, -0.00342026f, 0.02763190f, 
    -0.00748185f, -0.01967283f, 0.02574143f, -0.00110509f, -0.00022901f, -0.00822859f, -0.01942139f, 0.00641343f, 
    0.00104195f, -0.03211127f, -0.02798374f, 0.01903761f, -0.02576096f, -0.02066456f, -0.03582961f, 0.02353149f, 
    0.02876513f, 0.02946325f, 0.01195052f, 0.01723746f, -0.02731668f, 0.02212578f, -0.03319270f, 0.00389853f, 
    0.01975608f, -0.01431187f, -0.00173608f, 0.00576130f, 0.03762361f, -0.00870119f, -0.02184175f, -0.02274806f, 
    0.00866398f, 0.01254950f, 0.01674532f, -0.03480946f, 0.02442957f, -0.01846710f, 0.01331728f, 0.00562823f, 
    0.01137338f, -0.03411806f, 0.00408010f, -0.02941961f, -0.00086700f, -0.02588229f, 0.01993594f, 0.00834309f, 
    -0.00599974f, -0.02506263f, 0.01475445f, -0.00319806f, -0.03778812f, -0.02655171f, 0.03957366f, 0.01831210f, 
    -0.02577255f, -0.00767821f, 0.01826103f, -0.04050072f, -0.00035030f, -0.03919930f, -0.02434557f, 0.02015768f, 
    0.01168188f, -0.00053426f, 0.00819004f, 0.00769846f, 0.02405760f, -0.01747453f, -0.00533801f, -0.01233208f, 
    -0.03643803f, 0.00883381f, -0.01054910f, 0.01247887f, -0.02022298f, -0.02978163f, 0.02551145f, 0.00983180f, 
    -0.01326693f, 0.00813660f, -0.00170636f, -0.03754468f, 0.02475210f, 0.02626271f, 0.01880310f, -0.04094382f, 
    -0.01454734f, 0.02502519f, 0.01969190f, -0.01022395f, 0.00009403f, 0.00765142f, -0.03273463f, 0.02068013f, 
    -0.02481820f, 0.01386752f, -0.01786637f, -0.01249361f, 0.02871639f, 0.02910006f, -0.03202159f, 0.01885217f, 
    0.02129270f, -0.00228524f, 0.00090243f, -0.02459793f, -0.00520063f, 0.00069834f, -0.02302265f, 0.02054509f, 
    0.02086883f, 0.00436767f, 0.00664034f, 0.01183817f, -0.02391814f, -0.03130845f, 0.02709750f, 0.02492671f, 
    0.02342628f, -0.02987622f, -0.01999411f, 0.01061652f, 0.00513405f, 0.01017782f, 0.03223149f, -0.00368670f, 
    0.01024853f, -0.00475607f, 0.02953731f, 0.00652102f, 0.02541414f, -0.02838999f, 0.02716777f, 0.00320666f, 
    -0.02094644f, 0.02590187f, 0.01139944f, 0.02237668f, 0.00907551f, -0.00241403f, -0.01153601f, -0.02959167f, 
    0.00829867f, 0.00779325f, 0.01163803f, -0.03936387f, -0.03167052f, -0.03252145f, 0.02328986f, -0.03540267f, 
    0.02825783f, -0.01675070f, 0.02666974f, 0.01056174f, 0.02056443f, -0.04165778f, -0.02204338f, 0.00971828f, 
    -0.00161793f, 0.02915661f, -0.03860408f, -0.03650477f, -0.02161881f, 0.02936008f, 0.02925192f, -0.02843003f, 
    0.00994668f, -0.01100611f, -0.02767740f, -0.01338369f, 0.01621145f, -0.02785608f, 0.03319385f, 0.02315119f, 
    0.01583780f, -0.02599098f, 0.00131852f, -0.01084365f, -0.00424356f, -0.03141829f, -0.00294406f, -0.03908526f, 
    0.01715320f, -0.01842228f, -0.00686221f, -0.02407823f, -0.00801490f, 0.01285462f, 0.01323866f, 0.00833112f, 
    0.02994433f, -0.04122800f, 0.00593724f, 0.02717612f, 0.00074806f, -0.02615882f, -0.00004994f, -0.02393978f, 
    0.00640936f, -0.03318332f, 0.00477458f, -0.02936775f, 0.01092814f, -0.00691447f, 0.00558970f, -0.03119340f, 
    0.01582388f, 0.01099855f, -0.02322160f, -0.01475259f, 0.02817860f, -0.01054631f, -0.01945591f, -0.01086175f, 
    -0.00620014f, -0.00394414f, 0.02382324f, 0.00658480f, 0.01185423f, 0.02698589f, 0.00954124f, 0.00250049f, 
    -0.01811847f, -0.03554784f, 0.02578115f, -0.01790957f, -0.01737079f, 0.00847654f, -0.03123091f, -0.00757646f, 
    -0.01229460f, -0.02517441f, 0.04001000f, 0.00403675f, -0.02175133f, -0.01424552f, -0.03255521f, 0.01032500f, 
    -0.01621412f, -0.03598085f, 0.02071793f, -0.02107636f, -0.01473364f, 0.02243878f, 0.01177250f, -0.01201187f, 
    -0.01585780f, -0.02740056f, 0.01780815f, -0.00307658f, -0.01221285f, 0.00032823f, -0.02547484f, 0.02893597f, 
    0.00415045f, 0.00703125f, 0.00085148f, 0.00780820f, -0.03865460f, -0.00498899f, -0.03640796f, -0.03977935f, 
    -0.02861239f, -0.03690787f, 0.01058477f, 0.00068980f, 0.01942863f, 0.01829591f, 0.02462427f, 0.01011751f, 
    0.02571350f, -0.02577416f, -0.03767162f, -0.01222980f, -0.03770912f, 0.01102366f, 0.01020989f, 0.00381994f, 
    -0.01657248f, -0.03747128f, -0.01481282f, -0.02812592f, -0.00519601f, -0.01140544f, 0.02103944f, -0.01786271f, 
    0.00234163f, -0.01670127f, -0.02950693f, -0.01606675f, -0.00885155f, -0.00375600f, -0.00958563f, -0.02783488f, 
    -0.01258578f, -0.03360720f, -0.03092257f, -0.02191637f, -0.00139537f, -0.01643920f, -0.02755457f, 0.03251966f, 
    0.00271940f, -0.01532901f, -0.00811671f, 0.01165806f, 0.02756933f, -0.01928545f, -0.03147267f, -0.03094164f, 
    0.02510007f, 0.02376365f, 0.02732208f, -0.00829205f, 0.00803974f, -0.02477056f, -0.02326770f, 0.02063102f, 
    -0.02447194f, -0.00608787f, 0.01595412f, -0.01693136f, 0.01305528f, -0.00834218f, -0.03958103f, -0.01797119f, 
    -0.01337977f, 0.00428763f, 0.01424927f, -0.00738171f, 0.02997898f, 0.02245049f, -0.00879422f, -0.01003638f, 
    -0.00944025f, -0.03374444f, 0.02155835f, 0.02271783f, -0.02111100f, -0.00469466f, 0.00646289f, -0.04128591f, 
    0.02432572f, -0.03245595f, 0.02260799f, 0.02414008f, -0.02803042f, 0.00202303f, 0.00635681f, 0.01211516f, 
    -0.03751694f, 0.02754936f, 0.00447708f, 0.01638059f, -0.02076618f, 0.00494281f, -0.03146100f, 0.00020076f, 
    -0.02881645f, 0.02864783f, -0.03205750f, 0.00183342f, -0.00869185f, 0.02905206f, 0.00875983f, 0.00853659f, 
    -0.00071400f, 0.01843745f, 0.02113587f, -0.00866068f, -0.00100474f, -0.03438309f, -0.03436127f, -0.03825984f, 
    0.02404629f, -0.00415296f, -0.00588414f, 0.00935942f, 0.02691763f, -0.04204157f, 0.00338347f, 0.00918797f, 
    0.01014908f, -0.01511004f, 0.00440177f, -0.01001438f, -0.00108218f, 0.00571069f, -0.01210944f, 0.02119007f, 
    0.02885354f, -0.01345494f, -0.01054672f, -0.01194512f, 0.00341947f, -0.01911500f, 0.00411921f, -0.04037846f, 
    -0.01798489f, -0.03249918f, 0.02082133f, -0.02769820f, -0.02170816f, -0.02429826f, -0.03847029f, -0.00427049f, 
    -0.02352460f, 0.00525958f, 0.01882674f, -0.03156630f, 0.01553753f, -0.02355316f, -0.02706567f, 0.01552959f, 
    0.00539548f, -0.00471416f, 0.00378018f, 0.00917289f, -0.01693177f, 0.01073518f, 0.00236324f, 0.01217913f, 
    0.01082604f, 0.01129822f, 0.01285840f, 0.01423030f, 0.00174476f, -0.03930613f, -0.03014547f, -0.01058964f, 
    0.01015165f, -0.01789027f, 0.00392523f, 0.01397692f, 0.01534868f, -0.00919010f, -0.02738430f, -0.02917420f, 
    0.00869229f, 0.00832261f, -0.01706798f, 0.00713592f, 0.01823200f, 0.01345085f, -0.04177070f, 0.02042853f, 
    -0.00612320f, -0.02926154f, -0.01638729f, -0.03391748f, -0.04201496f, 0.00388520f, -0.03587164f, 0.01964030f, 
    0.02927893f, 0.00922107f, -0.02395403f, -0.04008353f, -0.03355239f, -0.02902759f, -0.03045078f, 0.00256955f, 
    -0.02422372f, 0.00579005f, 0.00526409f, 0.02377336f, -0.03906006f, 0.00943264f, 0.00819098f, -0.02585609f, 
    -0.02344145f, 0.00628879f, -0.01690695f, -0.03722684f, -0.03651483f, -0.03827504f, -0.01111450f, -0.00161560f, 
    -0.02821346f, -0.01807206f, -0.02935679f, 0.01093210f, 0.00589121f, -0.03324919f, -0.02626514f, 0.00559490f, 
    -0.04166291f, 0.02165201f, 0.00198731f, -0.04028430f, 0.01164106f, 0.00233484f, 0.00494110f, -0.00635163f, 
    0.02254146f, -0.02997688f, -0.00957711f, 0.02740944f, 0.02155449f, 0.00155895f, -0.03453370f, 0.02251074f, 
    -0.00076315f, -0.03840101f, -0.03142209f, 0.01283899f, -0.02715933f, -0.01314367f, -0.04142303f, -0.00085149f, 
    -0.02527676f, -0.02193473f, -0.02063035f, -0.02646984f, -0.00132350f, -0.02088405f, -0.01797824f, -0.03013016f, 
    -0.03033494f, -0.03574876f, -0.03950477f, 0.02499025f, -0.00147659f, 0.01117353f, -0.00186178f, 0.01427483f, 
    0.02937143f, 0.02175765f, -0.03420280f, -0.02420102f, 0.01822365f, -0.00497069f, 0.00064273f, -0.00426002f, 
    -0.01881951f, 0.02441926f, 0.01461338f, 0.00167432f, 0.02196180f, -0.01729206f, 0.00357602f, 0.01002242f, 
    -0.01876394f, 0.02393846f, 0.01366671f, -0.01904438f, 0.00567943f, 0.00519867f, -0.02756182f, -0.04023369f, 
    0.02473107f, -0.02217177f, -0.00018205f, 0.00276216f, -0.00199840f, -0.02996490f, -0.00323760f, 0.00814245f, 
    0.00520871f, -0.01700195f, -0.01844542f, -0.02888457f, 0.00345808f, -0.03851660f, 0.02359205f, -0.01261650f, 
    0.02406628f, 0.01097969f, -0.03177692f, -0.03957165f, -0.01818677f, 0.02196814f, 0.02080230f, -0.01025747f, 
    0.01117307f, -0.01006130f, 0.02818897f, -0.01308067f, 0.02102850f, 0.00235449f, -0.03227240f, -0.02365828f, 
    -0.00807768f, 0.00997002f, 0.00760699f, -0.02083945f, 0.02577303f, 0.02143979f, -0.00798130f, -0.00717579f, 
    0.01195390f, -0.01631807f, 0.01238650f, -0.01710090f, -0.00443674f, -0.00630368f, -0.00696090f, 0.00299661f, 
    -0.02815092f, -0.03786057f, -0.01094113f, 0.00289902f, 0.01424451f, -0.00660467f, 0.02923584f, -0.01668260f, 
    0.03764409f, -0.00361673f, 0.01266108f, 0.01648878f, 0.01969570f, -0.02237116f, 0.01670635f, -0.01494594f, 
    0.00364221f, 0.02202065f, -0.04100569f, 0.02478108f, 0.00850417f, -0.00439438f, -0.00544647f, -0.04111456f, 
    -0.02607295f, -0.01588984f, -0.00837370f, -0.04201037f, -0.02498134f, 0.00560111f, -0.01570465f, 0.00657642f, 
    0.01804006f, -0.02218715f, -0.02046782f, -0.00158199f, -0.01637629f, -0.01153474f, -0.02000790f, 0.02422005f, 
    0.00749216f, 0.01107154f, -0.00124850f, -0.01188210f, -0.02011937f, 0.00648592f, -0.00184086f, 0.00145938f, 
    -0.02070565f, -0.02423595f, -0.00970048f, -0.01188591f, 0.00113039f, -0.03083308f, -0.04018906f, -0.00803902f, 
    -0.01517573f, 0.02847608f, -0.03471329f, -0.01758150f, -0.02138494f, -0.04185724f, 0.00900581f, -0.03025988f, 
    0.03447021f, -0.01783342f, -0.06809013f, -0.25531286f, -0.11266728f, 0.01998585f, 0.00486548f, 0.01931795f, 
    -0.02336391f, 0.08595708f, -0.05074453f, 0.11774202f, 0.07414898f, -0.24770314f, -0.03619736f, 0.11785441f, 
    -0.05428002f, -0.00144005f, -0.08400372f, -0.09947266f, -0.00220505f, -0.09381878f, 0.04265269f, -0.01034745f, 
    -0.23739922f, -0.04280916f, -0.04043082f, -0.09382290f, 0.05135350f, 0.03389161f, -0.09786388f, 0.02653305f, 
    0.02195286f, 0.08345318f, -0.04613379f, 0.04471572f, -0.12373284f, -0.05072596f, -0.17721765f, 0.02175237f, 
    0.08566092f, 0.09843064f, 0.02776265f, -0.03642443f, -0.00294796f, 0.01806579f, 0.00666035f, -0.06415616f, 
    0.18172759f, 0.13908479f, 0.12759352f, 0.09596093f, -0.05114188f, -0.07355372f, 0.01227258f, -0.05116929f, 
    -0.02095872f, 0.01014064f, -0.01724787f, 0.04807313f, -0.14667171f, -0.16754256f, 0.02034976f, -0.07046850f, 
    0.08183268f, 0.03650609f, -0.01283097f, -0.04684426f, -0.06037127f, -0.04045503f, 0.07925572f, 0.04643517f, 
    -0.04804484f, -0.11294395f, 0.04146644f, -0.08914672f, -0.07327219f, 0.03993548f, 0.06011747f, -0.03001400f, 
    0.01526992f, 0.02207341f, -0.08159745f, -0.12806511f, -0.02296421f, -0.10650625f, 0.19680575f, 0.00809256f, 
    -0.05964003f, 0.02571021f, 0.02271884f, 0.09747308f, -0.04424124f, -0.02590632f, 0.05490969f, 0.08912238f, 
    0.20567179f, -0.10878466f, 0.08746974f, 0.14366706f, 0.02256134f, 0.08457525f, 0.04911486f, -0.06394503f, 
    -0.05475389f, 0.02139693f, 0.05634204f, 0.08510777f, 0.21327437f, -0.08874138f, 0.11097989f, 0.11305214f, 
    -0.14315705f, 0.07641006f, -0.00169132f, 0.11617119f, -0.06820139f, 0.04835070f, -0.01882798f, 0.13579182f, 
    -0.07986378f, 0.11183101f, -0.15666912f, -0.07642432f, 0.12242071f, -0.02302392f, 0.02560265f, 0.08784090f, 
    0.06118040f, 0.01478252f, 0.02707256f, 0.12616782f, -0.24845402f, 0.05639119f, 0.00132939f, 0.00306720f, 
    0.07816945f, 0.10190448f, -0.01766955f, 0.08163277f, 0.01144089f, -0.02291221f, 0.00809948f, 0.02966367f, 
    0.03047400f, -0.06847470f, -0.01586741f, 0.19932352f, 0.13246998f, -0.09376585f, -0.06529925f, 0.05634013f, 
    -0.06312040f, 0.06211463f, -0.04956835f, 0.04513061f, -0.09605584f, 0.06837822f, 0.20600702f, -0.15973364f, 
    0.01258525f, -0.04065340f, 0.06468409f, -0.07714799f, -0.00032710f, 0.11387743f, -0.02834865f, 0.12438814f, 
    -0.12321981f, -0.11710780f, 0.01166818f, -0.19498388f, 0.06730412f, 0.05963443f, 0.02015742f, 0.05254678f, 
    0.03052826f, -0.02514813f, 0.05829558f, 0.08482665f, -0.01707185f, -0.01650091f, 0.16719788f, 0.32534805f, 
    -0.00407107f, 0.03901353f, -0.02270086f, 0.01334449f, 0.07870112f, 0.05157739f, -0.01452294f, 0.02304079f, 
    -0.07634845f, -0.16828939f, 0.05850640f, -0.00433276f, -0.09109185f, 0.11047625f, -0.03526712f, 0.04413042f, 
    -0.02107442f, 0.00752088f, -0.05095674f, 0.07189044f, -0.17306751f, -0.16222127f, -0.14481349f, -0.13592985f, 
    -0.00289172f, 0.07395020f, 0.11201833f, -0.04234944f, 0.06009630f, -0.01144198f, -0.05308363f, 0.06894234f, 
    -0.08844849f, 0.21026723f, -0.00231364f, -0.16601814f, 0.16293147f, -0.02025166f, -0.04021006f, 0.10797365f, 
    0.03443444f, 0.08142748f, 0.08350077f, 0.01409165f, 0.10401081f, -0.05363738f, -0.07915830f, 0.06262617f, 
    0.00265983f, 0.07028185f, -0.14108430f, -0.03457553f, 0.00767618f, -0.00756744f, 0.08232093f, -0.02937296f, 
    -0.06610280f, 0.24092573f, -0.12010990f, -0.06164966f, 0.03028539f, 0.06313440f, 0.00986776f, -0.00504333f, 
    0.02180172f, 0.14573379f, 0.00408025f, 0.07038888f, -0.15969744f, 0.01850025f, 0.11106493f, -0.00956834f, 
    0.00912134f, -0.02553029f, -0.04169905f, 0.04440673f, 0.17021504f, 0.01880317f, -0.09791751f, -0.02912922f, 
    0.16276154f, -0.07428715f, -0.09495413f, 0.18434791f, 0.12447786f, -0.15868789f, 0.00479161f, 0.00124699f, 
    -0.09322110f, -0.10272285f, 0.01541509f, -0.02373664f, 0.21379344f, 0.14012174f, 0.04169815f, -0.02820942f, 
    -0.13169505f, 0.08695628f, 0.02817710f, 0.03187899f, -0.00079539f, 0.01635949f, 0.04395667f, 0.06484194f, 
    -0.22866479f, 0.06807709f, -0.05304449f, -0.00572092f, 0.07295531f, -0.00865896f, 0.00955171f, 0.00773784f, 
    0.06701327f, -0.03033323f, 0.03482914f, 0.06012324f, 0.18714586f, 0.11147114f, -0.14348651f, -0.11611241f, 
    0.11091460f, -0.02690721f, 0.02537364f, 0.04513006f, 0.05535586f, 0.03760739f, 0.05404009f, 0.05407635f, 
    0.09038352f, -0.21101746f, 0.13472077f, 0.16538152f, 0.04235183f, 0.02260987f, -0.02537713f, -0.05813371f, 
    0.07547482f, -0.05795199f, -0.06902386f, -0.01853816f, 0.04894407f, -0.01697040f, 0.05821028f, 0.04928902f, 
    -0.08803935f, -0.05061521f, 0.00395932f, 0.08645222f, -0.05877241f, 0.05735914f, 0.01525266f, -0.11289225f, 
    0.27679107f, 0.13377491f, -0.14386122f, 0.00274080f, 0.01526157f, 0.06726445f, 0.01925731f, 0.06478145f, 
    0.07187635f, 0.06006908f, 0.08428551f, 0.00571571f, -0.00085411f, 0.14033365f, 0.04662118f, -0.03988042f, 
    -0.01946928f, 0.02247216f, 0.01681837f, -0.01814320f, 0.06492027f, -0.01997886f, 0.09316296f, 0.04647519f, 
    -0.06377891f, 0.09976107f, 0.09261841f, -0.09566133f, 0.00332529f, -0.04386250f, 0.01986570f, 0.04189908f, 
    0.05098247f, 0.04218079f, -0.01916955f, 0.04629890f, 0.11140712f, 0.03725807f, 0.29504502f, 0.06899654f, 
    -0.06856163f, 0.01025714f, -0.04569017f, 0.01797481f, -0.00826031f, 0.09956262f, 0.01559609f, 0.10861099f, 
    -0.24090706f, 0.03854895f, -0.04308673f, 0.15758359f, -0.03432450f, 0.00567791f, 0.00456392f, 0.05139468f, 
    0.00495139f, 0.09263986f, 0.03431910f, 0.07527881f, 0.42610261f, -0.12962878f, 0.03447817f, -0.00994950f, 
    -0.09463771f, 0.12029177f, 0.06405786f, 0.09044118f, -0.05277305f, 0.07554062f, 0.01607476f, 0.03933208f, 
    0.05263912f, -0.04210044f, 0.10921680f, -0.12590210f, -0.07170212f, -0.05160783f, 0.06939384f, -0.12641177f, 
    0.06616400f, -0.01484547f, -0.09259374f, -0.05611625f, 0.25916770f, -0.08065819f, 0.10370132f, 0.07054331f, 
    -0.00321371f, -0.05324166f, 0.02304544f, -0.08053982f, -0.01736952f, 0.02331542f, 0.04205890f, -0.09481207f, 
    -0.11743259f, 0.10137872f, -0.08387655f, 0.02944569f, 0.00573727f, -0.02157572f, 0.00505787f, 0.04818878f, 
    -0.01220556f, 0.07093736f, -0.01692104f, -0.06250788f, 0.13806465f, -0.09583972f, -0.00609128f, 0.20315158f, 
    0.06742347f, -0.01598898f, 0.04041478f, -0.01942397f, -0.03219609f, 0.12704840f, 0.04195920f, -0.09415238f, 
    -0.09073321f, -0.08977336f, -0.08061704f, -0.06471662f, -0.07531288f, -0.04267775f, -0.04350833f, -0.09270727f, 
    -0.02747556f, 0.01323073f, 0.02206636f, -0.08632845f, 0.44473010f, 0.13657127f, 0.17471501f, 0.12432507f, 
    -0.08107238f, 0.06921355f, -0.00701686f, 0.04679738f, 0.12437895f, 0.06254508f, 0.01894900f, -0.04729975f, 
    0.01193137f, 0.13223141f, -0.03320142f, -0.14338382f, 0.06264141f, 0.00593058f, -0.10825934f, -0.01738377f, 
    -0.00420080f, -0.00927639f, 0.10479580f, 0.03594639f, 0.07281379f, 0.09998925f, 0.04340259f, -0.23863402f, 
    0.08270953f, 0.03624383f, -0.02647354f, 0.03429385f, 0.02805519f, 0.00316096f, -0.01244312f, 0.04595672f, 
    0.20089364f, 0.10998596f, 0.02352908f, -0.03802500f, 0.03627922f, -0.04779966f, 0.05595692f, -0.00394749f, 
    -0.00050291f, -0.01201303f, -0.01282623f, -0.08704250f, 0.04284027f, -0.08626059f, -0.10059676f, -0.03754399f, 
    0.01161067f, -0.01578826f, 0.00464302f, 0.05685275f, -0.04046862f, 0.01919387f, 0.02846926f, 0.07422894f, 
    0.22199851f, 0.06461276f, 0.09463015f, 0.09618556f, -0.03000090f, -0.04098576f, -0.02101036f, 0.00863802f, 
    0.02688896f, 0.00061874f, -0.02413210f, 0.03133647f, -0.18459384f, -0.10851384f, -0.01395532f, -0.12363076f, 
    0.20877612f, -0.02838256f, -0.06815065f, -0.01035715f, -0.11797185f, 0.05229684f, 0.06786942f, -0.08837626f, 
    0.15771054f, -0.10970987f, -0.14736903f, 0.19963531f, 0.02657929f, -0.06679869f, -0.04967578f, 0.04557221f, 
    -0.09817882f, 0.02479672f, 0.00691973f, 0.14991748f, 0.18957311f, 0.06766231f, 0.14309038f, 0.16968611f, 
    -0.00401044f, -0.01375230f, 0.04330166f, 0.05840409f, 0.11016878f, -0.00297301f, 0.01522265f, 0.13364656f, 
    0.20510745f, 0.00061084f, 0.08036627f, 0.04285477f, -0.04700761f, 0.00650527f, -0.03631965f, 0.08861046f, 
    -0.01085495f, -0.14272496f, 0.09135941f, -0.02389795f, 0.11077407f, 0.15123066f, -0.16578542f, -0.02444149f, 
    0.03633187f, 0.05274677f, 0.04630122f, 0.05648917f, -0.03826446f, 0.08625365f, 0.07410445f, 0.10516458f, 
    0.16876188f, 0.19405161f, 0.09233519f, 0.09606464f, -0.10458599f, 0.02543272f, 0.04892157f, -0.05130975f, 
    -0.04060104f, 0.04569754f, -0.03829845f, -0.03537600f, 0.23766845f, 0.04923129f, -0.02272766f, 0.05701502f, 
    0.06274127f, 0.07889502f, 0.00028652f, -0.02005733f, -0.05690548f, -0.10050576f, -0.10066996f, 0.01975694f, 
    0.21931772f, 0.16968352f, -0.05829986f, -0.08260944f, -0.02096102f, -0.07319078f, -0.03835460f, -0.00268243f, 
    -0.01337623f, 0.05763710f, 0.06707852f, 0.18277796f, 0.21018824f, 0.07271954f, -0.15002398f, -0.25209850f, 
    0.04609947f, 0.08076474f, 0.01027817f, -0.05174319f, 0.19764462f, 0.05225334f, 0.08512995f, -0.08836179f, 
    0.16527861f, 0.10297670f, -0.12657049f, -0.32999992f, 0.00751796f, -0.06842916f, -0.09245332f, -0.00631926f, 
    -0.07723358f, 0.10518235f, -0.06054930f, 0.00754908f, 0.08098333f, -0.14626077f, 0.09129873f, 0.11939079f, 
    -0.05947919f, 0.05592949f, 0.01865281f, 0.06754534f, 0.09134368f, -0.06557229f, 0.12562226f, -0.06473278f, 
    -0.05105553f, -0.10168280f, -0.03941827f, 0.08941655f, 0.01194126f, 0.09702408f, 0.02399667f, 0.05227401f, 
    0.08472644f, -0.09895152f, 0.08039399f, 0.13600762f, -0.01396628f, -0.03323623f, -0.06188589f, 0.04231314f, 
    -0.01701701f, -0.06410421f, -0.01498935f, -0.09431969f, 0.03721651f, 0.05493334f, 0.03741836f, -0.00302710f, 
    -0.23632053f, -0.08859614f, -0.12971875f, -0.18898514f, 0.01666968f, 0.02318121f, 0.01944997f, 0.11911618f, 
    0.01496766f, 0.04844777f, 0.02127951f, 0.00016411f, 0.21302697f, -0.10788251f, 0.12696774f, 0.11310987f, 
    0.01915934f, -0.01215347f, 0.04817713f, -0.02674405f, 0.03406280f, -0.03387313f, 0.01399140f, -0.06824055f, 
    -0.08542006f, 0.08225258f, 0.08659894f, 0.10813911f, 0.02570817f, -0.05917636f, 0.06663992f, -0.05617807f, 
    0.04882126f, 0.01674763f, -0.03440398f, 0.06603097f, 0.25535262f, 0.08102532f, 0.08238721f, 0.10186634f, 
    -0.00738281f, -0.00006248f, -0.08994064f, 0.05712339f, 0.10046168f, -0.02276185f, 0.04481265f, 0.02751103f, 
    0.00011217f, 0.05549250f, -0.02252499f, 0.09234882f, 0.02551096f, -0.01032006f, -0.00628689f, -0.04520306f, 
    0.00290315f, -0.00089727f, 0.03255059f, 0.03433357f, 0.06824446f, 0.06190683f, -0.02633576f, 0.14355104f, 
    0.08977059f, 0.01475555f, -0.03847110f, -0.05360277f, 0.04751495f, 0.03922672f, 0.02080638f, -0.06120085f, 
    -0.00181467f, -0.01111234f, -0.00854513f, -0.00033770f, -0.01895001f, 0.01433356f, -0.00373965f, -0.03324357f, 
    0.00177150f, 0.00404863f, -0.01898388f, -0.03080886f, -0.02076326f, -0.03581141f, -0.03779827f, -0.01994138f, 
    -0.01604107f, -0.03335316f, 0.02857933f, -0.01015686f, 0.02487326f, 0.01733642f, 0.02234274f, -0.01038497f, 
    0.00134229f, 0.01795912f, -0.01175156f, 0.00249400f, -0.01367603f, -0.01048758f, -0.04021116f, 0.00051690f, 
    -0.01129280f, 0.03485560f, -0.00069459f, 0.01562292f, 0.00871047f, -0.02760230f, -0.02870466f, -0.03252525f, 
    0.01239789f, -0.01227376f, 0.01232619f, 0.01893463f, 0.02367256f, 0.01838254f, -0.02831582f, 0.00274897f, 
    0.00970710f, -0.03968300f, -0.01664707f, -0.02003646f, 0.03536025f, -0.02259791f, -0.00073687f, 0.03043591f, 
    -0.03486639f, -0.02227014f, -0.01877365f, 0.00643382f, -0.02110955f, -0.02890274f, 0.00377619f, -0.01226580f, 
    -0.01855923f, -0.03505607f, 0.00242046f, -0.02849565f, -0.00185913f, -0.00733926f, 0.00772448f, -0.01929956f, 
    -0.04098431f, 0.01457849f, -0.04761862f, -0.00852651f, 0.00290025f, 0.02418532f, 0.01086201f, 0.00971256f, 
    0.03054138f, -0.01198047f, 0.01857999f, -0.02706550f, -0.02043314f, 0.02201612f, -0.00641152f, -0.01986529f, 
    0.00382173f, 0.02147811f, -0.02116789f, 0.01221941f, -0.01197555f, 0.01069764f, -0.02480984f, 0.00076213f, 
    0.03846901f, 0.01667199f, 0.02751560f, -0.03029761f, -0.02727150f, 0.02470193f, 0.01157465f, 0.01846746f, 
    0.02474936f, -0.01625274f, 0.01133831f, 0.04127948f, 0.04140309f, 0.01427239f, -0.00321902f, -0.01479658f, 
    0.01482486f, -0.00721871f, -0.00206323f, -0.00647132f, 0.01144285f, 0.01554977f, 0.01628063f, 0.02024867f, 
    -0.01556050f, -0.03119688f, -0.02336575f, -0.02296606f, -0.01778469f, -0.01747099f, -0.00235165f, 0.00299620f, 
    -0.02350774f, 0.02941555f, -0.02668504f, -0.01980708f, 0.02485804f, -0.01094781f, 0.03119250f, -0.01814135f, 
    0.01105981f, 0.02615177f, 0.02467120f, 0.02162437f, 0.02034603f, 0.02007468f, 0.01839373f, -0.02679113f, 
    0.01837375f, -0.03037648f, 0.02162614f, 0.01869923f, 0.00979324f, -0.01457731f, 0.03153155f, -0.02283714f, 
    0.00869842f, -0.00129686f, 0.02208368f, -0.01546383f, -0.01567417f, -0.03737640f, -0.03971235f, -0.04049987f, 
    -0.00101959f, -0.02606964f, 0.00885913f, 0.02373862f, -0.02508401f, -0.00277789f, -0.03335220f, -0.01458753f, 
    -0.00515354f, 0.00166336f, 0.01404741f, 0.02164869f, -0.00451600f, 0.02051008f, 0.01795821f, -0.01979143f, 
    -0.01831160f, -0.01404864f, 0.00966512f, -0.00862646f, 0.01895599f, 0.00359767f, 0.02520089f, -0.01027086f, 
    -0.01638100f, 0.03032489f, -0.01928803f, 0.00980476f, -0.03278479f, 0.01798134f, -0.02657754f, 0.00958618f, 
    0.01206306f, -0.01044480f, 0.01132182f, -0.00245222f, 0.01930789f, -0.02774757f, -0.00096047f, 0.00004526f, 
    0.03683751f, 0.00124140f, -0.02854356f, 0.00850043f, -0.00898066f, -0.02486462f, 0.01283753f, -0.00586997f, 
    0.01538695f, -0.00660670f, -0.01639855f, -0.01345477f, -0.01984885f, -0.00196441f, -0.01380152f, -0.02152258f, 
    0.02458617f, 0.01460441f, -0.00414259f, -0.03198281f, 0.00210007f, -0.03842138f, 0.02775302f, -0.02698555f, 
    0.03077958f, -0.01467673f, -0.02901972f, 0.02263240f, -0.03015900f, 0.00780071f, -0.02498537f, -0.02846542f, 
    -0.04074459f, -0.03372733f, 0.02138938f, 0.00094344f, -0.03663473f, 0.03144192f, -0.00694935f, -0.03721625f, 
    -0.00791850f, -0.01085039f, -0.00661393f, 0.01206790f, -0.01792837f, -0.01708918f, -0.02987709f, -0.00127165f, 
    -0.02731685f, -0.03181277f, 0.03258225f, 0.00335816f, -0.01626948f, 0.01278813f, 0.00458470f, -0.02945304f, 
    -0.02295898f, -0.02952146f, -0.02656276f, -0.02701161f, -0.00331475f, 0.01012374f, 0.02437962f, 0.01832669f, 
    0.01345645f, -0.00518964f, 0.01160565f, 0.01418724f, -0.00079398f, 0.03211830f, 0.00508239f, -0.02671690f, 
    0.01975332f, 0.01452368f, 0.00453213f, 0.02993208f, -0.01689446f, -0.01327693f, 0.01836562f, -0.00121634f, 
    -0.00987193f, 0.00249377f, 0.01604999f, -0.04055777f, -0.02569428f, 0.02149454f, 0.00433763f, 0.01373974f, 
    -0.03163252f, 0.02221087f, -0.00835576f, -0.04661561f, 0.00730517f, -0.00069291f, -0.02253634f, -0.03268370f, 
    -0.03416752f, 0.00351630f, -0.02373751f, 0.00732557f, 0.01884135f, -0.00506848f, -0.00493584f, -0.02588397f, 
    -0.00811531f, -0.00575536f, 0.01295568f, 0.00670520f, 0.02929556f, -0.00450452f, -0.00146875f, 0.02883854f, 
    0.03609784f, -0.02398727f, -0.03238430f, 0.00935090f, 0.01018594f, -0.02387622f, 0.01415610f, -0.01428748f, 
    0.00810055f, -0.01463583f, 0.02234271f, -0.02149396f, -0.02639172f, 0.00864460f, 0.00865548f, 0.02498125f, 
    -0.02398912f, -0.02398238f, 0.02358618f, -0.02183808f, 0.01486615f, -0.01253672f, 0.03007493f, -0.01603511f, 
    0.02764296f, -0.01037679f, 0.02992585f, -0.01771343f, -0.00284863f, -0.01281347f, 0.02545334f, 0.01075944f, 
    0.03540179f, -0.00980174f, -0.00391983f, -0.02439163f, 0.03577799f, -0.03176121f, -0.00723199f, -0.01958079f, 
    0.01188975f, 0.02203486f, 0.01035242f, -0.01156739f, 0.03769511f, 0.03771554f, 0.01453938f, -0.00371965f, 
    0.04191306f, -0.02918042f, -0.00479923f, 0.00821709f, -0.02927635f, -0.02865387f, -0.04011392f, -0.01788270f, 
    0.01705180f, 0.01978317f, -0.02045968f, -0.00186146f, 0.04196197f, -0.03930030f, 0.02254260f, 0.00364074f, 
    0.01358310f, -0.02775217f, 0.01575986f, 0.02784342f, 0.01319223f, -0.01886678f, 0.01229067f, -0.02767717f, 
    -0.02906407f, -0.00539975f, -0.02351438f, -0.03687774f, -0.00392567f, 0.03648153f, 0.03041228f, 0.02668565f, 
    0.02834496f, -0.00459652f, 0.00330642f, 0.01241742f, 0.02428293f, -0.00309045f, -0.01803827f, -0.01846322f, 
    0.01687316f, 0.00152458f, -0.02951804f, 0.00826958f, 0.00344225f, -0.01879175f, -0.02820420f, -0.01571852f, 
    0.02183143f, 0.01516625f, 0.01289964f, -0.02772904f, -0.02586598f, -0.03566168f, 0.01305453f, -0.00903996f, 
    -0.00349049f, 0.02458219f, -0.00065842f, 0.02105631f, 0.01524715f, 0.02852940f, 0.00380433f, -0.00545414f, 
    -0.02106626f, -0.00326301f, 0.02120575f, 0.01370615f, 0.01564634f, 0.00375304f, -0.04591924f, -0.02392874f, 
    0.00195089f, 0.00300228f, 0.00523251f, -0.03507495f, -0.04553276f, 0.02634461f, 0.01679524f, 0.01363624f, 
    0.02636663f, -0.00291846f, -0.02730479f, 0.01867055f, -0.03654841f, -0.03754459f, -0.03242470f, -0.01890179f, 
    0.02680123f, 0.02007377f, 0.00967275f, -0.03425905f, -0.04269563f, 0.02549197f, 0.02612337f, -0.03662777f, 
    -0.04507477f, -0.00808842f, -0.03414923f, -0.02741799f, -0.04058082f, 0.01953351f, -0.00218553f, -0.02324542f, 
    -0.01724124f, 0.04184139f, -0.01986998f, -0.00776973f, 0.01104777f, -0.01312969f, -0.03290030f, 0.00844410f, 
    0.01444618f, -0.00318707f, -0.04109427f, -0.01302446f, 0.00678318f, -0.01310424f, 0.01079711f, -0.01252959f, 
    0.01460371f, -0.02027575f, -0.02960128f, -0.01031443f, -0.00654060f, 0.01891829f, -0.02354334f, -0.00639949f, 
    -0.02464947f, -0.03636959f, -0.00482707f, -0.02635357f, -0.00693116f, -0.02119217f, 0.01891037f, -0.00611451f, 
    -0.01808366f, -0.01511417f, -0.03487774f, 0.00253190f, 0.01854243f, -0.01845939f, 0.00118213f, -0.01004907f, 
    0.02840107f, -0.02044331f, 0.03016885f, 0.01608698f, -0.00827548f, -0.02913824f, -0.01341916f, -0.02985897f, 
    -0.00258382f, -0.03869716f, 0.01242668f, -0.00896605f, -0.00831066f, -0.02948713f, -0.02466940f, 0.01331108f, 
    0.03126055f, -0.02893765f, -0.01322448f, 0.00479907f, 0.02126830f, 0.00149577f, 0.03235062f, -0.03473762f, 
    -0.03525749f, 0.01978839f, 0.02175002f, 0.00439111f, -0.04017675f, 0.01731015f, -0.02975827f, 0.01940205f, 
    -0.04318850f, -0.01350150f, -0.02939059f, 0.02284512f, -0.00837155f, 0.00580783f, 0.03248063f, 0.02316536f, 
    -0.03900124f, -0.02502733f, -0.03015784f, -0.01628289f, -0.01370771f, -0.00654546f, 0.01257570f, 0.02382209f, 
    0.02107748f, -0.02119759f, -0.02875730f, 0.01428912f, 0.03351462f, -0.02935799f, 0.04148284f, 0.02545113f, 
    -0.01965047f, 0.01288060f, -0.03811745f, 0.01856210f, 0.02794706f, 0.01614183f, -0.00928343f, 0.02669732f, 
    0.03046228f, -0.02387053f, -0.02585582f, -0.03191957f, 0.01768296f, 0.01863337f, -0.00706237f, -0.02795199f, 
    -0.00043561f, 0.02479202f, 0.00728321f, -0.02798155f, -0.02076296f, -0.00314933f, -0.00205015f, -0.04427341f, 
    0.02222806f, -0.03002500f, 0.02845759f, -0.03457465f, 0.04044986f, -0.00579211f, -0.02238627f, 0.00027499f, 
    0.04147860f, -0.00956717f, -0.01922197f, 0.02518906f, -0.02795817f, 0.01638422f, -0.02444710f, 0.00012426f, 
    0.02220381f, -0.01204805f, -0.00009586f, 0.00119454f, -0.02112113f, -0.03472284f, -0.01824199f, -0.01364577f, 
    -0.01575601f, 0.01008931f, -0.03324845f, -0.00731039f, -0.03088180f, 0.01672532f, 0.00694334f, 0.02744417f, 
    -0.03236742f, -0.03095299f, 0.00107808f, -0.02566095f, -0.00493714f, -0.03725258f, 0.02475197f, -0.02090560f, 
    -0.01606482f, -0.03433223f, -0.00684886f, -0.00740761f, 0.04016104f, 0.00206629f, -0.03994041f, -0.02045519f, 
    -0.00043842f, 0.00545426f, 0.01286954f, 0.01272967f, 0.03135065f, -0.01710362f, -0.01324712f, 0.00583590f, 
    -0.01038123f, 0.00102441f, -0.00418889f, -0.00727309f, 0.04306641f, 0.01362661f, 0.00731871f, -0.00768537f, 
    -0.01148737f, 0.00582611f, -0.04157178f, -0.02927583f, -0.01732031f, -0.03283869f, -0.02000125f, -0.00858349f, 
    0.02303175f, 0.02041918f, 0.01957965f, 0.01921119f, 0.00236355f, -0.01338647f, -0.04183939f, 0.02844161f, 
    0.00246979f, 0.01180173f, -0.01281030f, -0.01719199f, -0.00548424f, -0.00659707f, -0.00663855f, 0.01375566f, 
    0.02171084f, -0.02768867f, 0.00277178f, 0.02150667f, 0.01630107f, -0.02290603f, 0.00935206f, 0.00807365f, 
    0.02860943f, -0.01786329f, -0.01633207f, -0.02659884f, -0.02353937f, 0.01428478f, 0.00637390f, 0.02696379f, 
    0.02222966f, 0.00383180f, 0.01398893f, 0.01745596f, 0.01982041f, 0.04200889f, -0.02685822f, 0.02292963f, 
    0.01759011f, -0.03923133f, 0.00044126f, -0.02684995f, -0.01976307f, 0.02259265f, -0.01614936f, -0.02585971f, 
    0.01182002f, -0.00965467f, -0.01344962f, -0.00624741f, -0.00074539f, -0.00168190f, -0.01081986f, -0.03726214f, 
    0.02364489f, -0.03628952f, 0.01155677f, 0.00950463f, -0.01081660f, -0.00484476f, 0.04343091f, -0.01834619f, 
    -0.02353531f, 0.02169272f, -0.00188493f, -0.02311552f, 0.04025925f, 0.02309709f, -0.00637750f, -0.00818392f, 
    0.02450843f, 0.01698379f, -0.01740211f, -0.01931398f, -0.02126687f, -0.04111289f, -0.01995156f, -0.02022957f, 
    -0.00898764f, -0.01081493f, -0.01489144f, -0.02878502f, -0.01718190f, -0.04285870f, -0.02022515f, -0.01241541f, 
    0.01960808f, -0.01390525f, -0.04650627f, 0.01595627f, 0.01685375f, 0.01223036f, 0.01580414f, -0.04985456f, 
    -0.02958842f, -0.02721228f, -0.01251687f, -0.01422359f, 0.00396838f, 0.01470700f, -0.02333370f, 0.02702278f, 
    -0.01095022f, -0.01880833f, 0.02770530f, 0.03324413f, -0.03705187f, 0.01116307f, -0.00819643f, 0.00960382f, 
    0.02932333f, 0.07278439f, 0.11829790f, 0.38553199f, 0.02494531f, -0.09582952f, -0.08414531f, -0.05243281f, 
    0.01391161f, -0.13654687f, 0.18361667f, 0.00923483f, -0.00013877f, 0.10090022f, -0.00811730f, -0.19964348f, 
    0.13527955f, -0.04961815f, 0.02946284f, 0.16968660f, 0.01904671f, 0.09284537f, -0.02337059f, 0.03977142f, 
    0.20187920f, 0.05212478f, 0.02159261f, -0.00622890f, 0.01487591f, 0.07172328f, 0.09771097f, -0.01556276f, 
    -0.04501493f, -0.10906818f, 0.05393654f, -0.02506762f, -0.09015467f, 0.05749309f, 0.08093718f, 0.08544417f, 
    0.04229018f, 0.00272432f, -0.04130524f, 0.13539995f, 0.11345415f, 0.07415829f, 0.00347025f, -0.00152361f, 
    0.01670864f, 0.15129070f, 0.12323800f, 0.13863054f, -0.00364452f, 0.15592602f, 0.05201003f, -0.00708287f, 
    0.03774489f, -0.02870072f, 0.17492835f, -0.04831630f, 0.29649338f, 0.21205062f, 0.14587402f, -0.00850656f, 
    -0.08214490f, -0.02324163f, 0.05675434f, 0.06680106f, 0.08937384f, 0.19788146f, -0.03096286f, 0.07119716f, 
    0.38235241f, -0.01737699f, -0.08979151f, 0.07631481f, 0.06666649f, 0.01252681f, -0.01294098f, 0.15014809f, 
    -0.01492514f, 0.01837254f, 0.08362311f, 0.23753773f, 0.19864382f, 0.17008029f, 0.12248443f, -0.01463161f, 
    0.02770556f, 0.03614628f, 0.00637902f, -0.00533304f, -0.00822150f, 0.08940858f, -0.00473996f, 0.00189495f, 
    -0.23477453f, 0.24774300f, -0.15361246f, 0.02244794f, 0.13541125f, 0.03456951f, 0.02605284f, 0.04728602f, 
    -0.00083116f, -0.04194970f, -0.12375927f, -0.02451879f, 0.12397728f, -0.03327518f, 0.07924944f, -0.02568239f, 
    0.04293167f, -0.08072928f, 0.06261007f, 0.09020097f, 0.08563244f, -0.03570655f, -0.03067538f, -0.11272635f, 
    -0.04574348f, -0.09003544f, 0.09151942f, 0.08551764f, 0.04034964f, 0.15530846f, -0.04262969f, -0.06963889f, 
    0.10809650f, 0.10262776f, 0.01194340f, 0.01017159f, 0.23982506f, 0.12435974f, 0.08078685f, -0.04042463f, 
    -0.04150352f, -0.04341057f, 0.08475015f, -0.02489819f, -0.04579507f, 0.02626869f, 0.12055229f, -0.02897201f, 
    -0.21786961f, 0.19282627f, -0.17650181f, -0.23602904f, 0.14607090f, 0.14506677f, 0.17173527f, -0.02494908f, 
    0.14481761f, 0.06739932f, 0.24841596f, -0.03130021f, 0.19439426f, 0.14679737f, -0.03730499f, 0.13149470f, 
    -0.00181138f, 0.11876892f, -0.08319876f, 0.12262408f, -0.07958961f, -0.09115902f, 0.07822736f, 0.10761576f, 
    0.10614800f, 0.18191524f, -0.20277713f, 0.13565226f, -0.04394476f, 0.04887087f, -0.02291933f, -0.07010827f, 
    0.02767329f, 0.21374208f, 0.06320611f, -0.04465384f, 0.05392314f, -0.02847295f, -0.07881122f, -0.15933894f, 
    -0.01999568f, 0.02278808f, 0.03085126f, 0.10031935f, -0.02016900f, -0.05940320f, 0.10137865f, -0.00761554f, 
    -0.07440627f, 0.21132518f, -0.02449679f, -0.09089990f, 0.08185095f, -0.09467802f, 0.09919534f, -0.03721347f, 
    -0.06026621f, -0.08426780f, 0.13499080f, -0.01244057f, 0.19050299f, 0.19388013f, 0.07201696f, 0.15451682f, 
    -0.05557452f, 0.00155705f, 0.02926697f, 0.14843079f, -0.05713996f, 0.11002599f, 0.07491375f, -0.07851892f, 
    0.07628610f, 0.01942593f, -0.06538429f, 0.46095723f, -0.05416438f, 0.05440885f, 0.15713902f, -0.06523939f, 
    0.03706935f, -0.03170389f, 0.00689785f, -0.09221221f, -0.18323320f, 0.02339596f, 0.03277553f, -0.17499913f, 
    0.11293408f, 0.00635048f, 0.11490054f, 0.02948176f, 0.07877227f, 0.04384698f, -0.01607932f, 0.06247688f, 
    0.35739297f, -0.05499761f, -0.01008115f, 0.28957978f, 0.09416186f, -0.05923255f, -0.02664029f, 0.10050711f, 
    -0.07133907f, -0.12294225f, -0.01542985f, -0.03090016f, 0.30883616f, 0.11548438f, 0.09084087f, -0.05755489f, 
    -0.06826060f, 0.03208878f, 0.11288694f, -0.06510149f, -0.13126652f, 0.05826544f, 0.24680434f, 0.11401294f, 
    -0.20713592f, 0.09372836f, 0.11017133f, -0.12484717f, 0.03429695f, 0.28224483f, -0.01497630f, -0.00134002f, 
    -0.02306867f, 0.19134504f, 0.04980206f, -0.00537412f, 0.06608634f, 0.14185730f, 0.09437937f, 0.09102617f, 
    0.04112016f, 0.04261768f, 0.03462225f, -0.07491498f, -0.01742560f, 0.06544133f, -0.00845000f, -0.04342763f, 
    0.22078754f, 0.13692826f, 0.02719406f, 0.35339716f, -0.00744276f, 0.09469092f, -0.08928746f, 0.13378119f, 
    -0.02346202f, 0.05819889f, 0.03632483f, 0.06068175f, -0.01489897f, -0.16033976f, 0.05571097f, 0.06383027f, 
    0.08931173f, 0.02554722f, 0.03013789f, 0.03527446f, 0.02582041f, 0.09336871f, -0.01187356f, 0.00152113f, 
    -0.04587266f, 0.32892549f, -0.13976401f, -0.27265537f, 0.05915871f, -0.04029715f, 0.01361239f, 0.08304042f, 
    -0.01889073f, 0.11230971f, 0.15444516f, 0.05036546f, -0.18270431f, -0.03005629f, -0.07201929f, -0.01905945f, 
    0.21040286f, 0.08814397f, 0.15133314f, -0.07182135f, 0.11327764f, -0.05812819f, 0.10532232f, 0.20349051f, 
    -0.01247235f, 0.07427748f, 0.22373740f, 0.15836196f, 0.00864622f, 0.00277132f, 0.04475689f, -0.08547377f, 
    -0.05856362f, -0.00910491f, 0.02074763f, 0.09007925f, 0.32720962f, -0.16446674f, -0.06087561f, 0.13936861f, 
    0.09057238f, -0.00305192f, 0.00632640f, 0.05885701f, 0.01039457f, -0.03633476f, -0.09810779f, -0.05262544f, 
    0.06581288f, 0.13169818f, 0.04781562f, 0.15442047f, -0.12791152f, 0.09021064f, 0.13851371f, -0.02405273f, 
    -0.10936540f, 0.01233867f, 0.03786265f, -0.10240815f, -0.02054688f, 0.09764697f, 0.05452172f, 0.02316995f, 
    -0.00275669f, 0.00285555f, 0.07580864f, 0.10657414f, -0.00674286f, -0.01358849f, 0.13192710f, -0.09824041f, 
    0.13904817f, 0.07361782f, 0.24780385f, -0.10189783f, 0.21524142f, -0.10267266f, 0.08885048f, -0.00815007f, 
    0.08270831f, -0.01025206f, 0.09375664f, 0.02330754f, 0.01715928f, 0.18997857f, 0.09266013f, -0.12414157f, 
    0.04563422f, -0.01939615f, -0.01469248f, 0.01721222f, 0.06054307f, -0.04600307f, 0.00977019f, 0.03762469f, 
    0.21139868f, 0.07387540f, 0.04992818f, 0.10736017f, -0.00363094f, 0.00897937f, 0.05284096f, 0.09965068f, 
    0.04573182f, -0.04639733f, 0.07781370f, 0.07864576f, -0.10209598f, 0.00327891f, -0.07987321f, -0.00452226f, 
    0.01044676f, 0.01801576f, 0.09199939f, 0.16849448f, -0.01117105f, 0.06712838f, -0.05410449f, 0.16356401f, 
    0.21809146f, -0.12282146f, 0.04288367f, -0.06278584f, 0.12669274f, -0.03430091f, -0.01704112f, -0.05512950f, 
    0.14792961f, 0.07838888f, 0.02277720f, 0.07482203f, -0.09713309f, 0.09149508f, -0.02599199f, -0.26290494f, 
    0.09969262f, -0.01122676f, -0.00457752f, 0.05429480f, 0.16421875f, -0.06798268f, 0.07078927f, 0.21660292f, 
    0.18647772f, 0.17711458f, 0.19706982f, 0.05884680f, 0.11065715f, 0.16213225f, 0.05366500f, 0.17132913f, 
    0.15952955f, 0.00001241f, 0.03036999f, 0.02188821f, -0.03380661f, -0.11999160f, -0.01619864f, -0.00750396f, 
    0.00737293f, 0.03161914f, 0.19544776f, -0.02690596f, -0.02332837f, -0.02884508f, -0.01258465f, -0.04291659f, 
    0.02461252f, 0.10569199f, -0.22857529f, 0.26873374f, -0.08618870f, 0.15117985f, 0.02437462f, -0.00643771f, 
    0.00762992f, 0.18721849f, -0.04223616f, 0.04520956f, -0.03368986f, 0.04644113f, -0.11563804f, 0.26720524f, 
    0.13760033f, 0.04380704f, 0.06890415f, -0.06155446f, 0.19941343f, 0.04732051f, 0.03396016f, -0.09397502f, 
    0.01342667f, -0.01583918f, -0.07722282f, 0.38928485f, 0.06586246f, 0.18385974f, -0.06011264f, -0.01881927f, 
    0.00145706f, -0.06850202f, 0.04007357f, 0.16406803f, -0.10349396f, -0.02871312f, 0.00043991f, 0.08578350f, 
    0.13076219f, 0.11392594f, 0.04727495f, -0.06879663f, 0.13831632f, 0.05423866f, 0.06399425f, -0.03917041f, 
    -0.07491738f, -0.11184008f, -0.09893389f, 0.07405579f, -0.03251277f, -0.01018989f, 0.20524991f, 0.02661236f, 
    -0.05113013f, 0.01482887f, 0.06072682f, 0.14659037f, 0.25457487f, 0.19072229f, -0.08956167f, 0.36517960f, 
    -0.07490496f, 0.12577964f, 0.11074781f, 0.09316683f, 0.10429749f, 0.00258044f, -0.01457664f, 0.28914556f, 
    -0.27966300f, -0.04870147f, 0.06737676f, -0.06874160f, 0.16227233f, 0.16002576f, 0.12748554f, 0.00690809f, 
    0.14582023f, 0.08194070f, 0.04272659f, -0.06677035f, -0.29412803f, -0.05942422f, -0.08194743f, -0.05946692f, 
    0.14424995f, 0.06678252f, 0.01662209f, -0.01222280f, -0.04057138f, 0.05129569f, 0.02376701f, 0.03990125f, 
    0.00753046f, 0.08655336f, 0.10642610f, 0.21471688f, -0.00993920f, -0.05499827f, 0.14227302f, -0.05048084f, 
    0.01552213f, 0.13235591f, -0.02478096f, 0.09217517f, 0.00492053f, -0.26540676f, 0.07859095f, -0.07657460f, 
    0.19146727f, -0.00924982f, 0.04552488f, -0.00888661f, 0.15766692f, 0.05893299f, -0.01913321f, 0.04244036f, 
    -0.08021657f, -0.27378398f, 0.05162475f, 0.16723078f, 0.04354445f, -0.01690528f, 0.07870640f, 0.16211286f, 
    -0.07541347f, -0.09003993f, 0.13752598f, 0.05910140f, -0.38289931f, 0.02179891f, 0.02546430f, 0.08647960f, 
    -0.01905460f, -0.00550194f, 0.07328445f, 0.10907931f, 0.01334586f, 0.12962861f, 0.09079605f, 0.04513685f, 
    -0.18605189f, -0.01301150f, -0.06343023f, 0.20531227f, 0.03206761f, 0.06252139f, 0.01737390f, -0.04636635f, 
    0.10183325f, 0.06033919f, -0.05263611f, -0.09924853f, 0.04054707f, 0.03806932f, -0.02191228f, 0.07220184f, 
    0.13349685f, -0.06380714f, -0.10039372f, -0.03291108f, -0.05422482f, -0.01638673f, -0.01570491f, 0.12912637f, 
    -0.17693144f, 0.02142296f, 0.05645547f, 0.35003763f, -0.03479047f, 0.15693796f, 0.17861572f, -0.06583866f, 
    0.06412150f, -0.03892321f, 0.14430439f, 0.12579343f, -0.08409476f, 0.11618947f, 0.07044970f, -0.23797785f, 
    0.11579249f, 0.08367840f, 0.03395806f, -0.00218269f, -0.00408168f, 0.01136082f, 0.03838358f, 0.07805999f, 
    0.02994736f, 0.13417375f, -0.02995828f, 0.08520187f, 0.21656838f, 0.04493155f, -0.00097783f, -0.05863474f, 
    0.02576998f, 0.04014558f, -0.00418745f, -0.12409321f, 0.35234797f, -0.06761730f, 0.15606140f, -0.19743621f, 
    0.11449829f, -0.01116647f, -0.00573183f, 0.05628385f, -0.04176546f, 0.02811515f, 0.12659426f, 0.08749131f, 
    0.25242999f, 0.11755248f, -0.05536518f, 0.21260346f, 0.11376837f, -0.00812207f, -0.08205459f, -0.02598102f, 
    0.06844512f, -0.04010858f, 0.01393054f, 0.14895844f, -0.11589715f, -0.01788720f, -0.07442443f, -0.19941626f, 
    0.06752865f, 0.04850436f, -0.01911783f, 0.08241322f, 0.00319177f, -0.01049662f, 0.06832747f, 0.05755072f, 
    0.04807312f, -0.03350725f, -0.03086192f, -0.07883908f, 0.08920622f, 0.04580253f, -0.11245001f, 0.04558995f, 
    0.07720654f, 0.07011151f, 0.12253483f, -0.10093115f, -0.25595278f, -0.09637660f, 0.01145427f, 0.21446548f, 
    -0.02584313f, 0.03038499f, 0.20529497f, 0.08433078f, -0.03241777f, 0.12803134f, 0.04993277f, 0.00701801f, 
    -0.02342016f, -0.03061270f, 0.07424688f, -0.07906865f, 0.21778841f, 0.09128661f, -0.12734547f, 0.04906031f, 
    0.16966286f, 0.15189615f, 0.08488715f, 0.10794231f, -0.18514664f, -0.07069424f, -0.05423283f, -0.03590982f, 
    0.05336071f, -0.01039855f, -0.02148991f, 0.06287164f, 0.12785068f, 0.03402295f, 0.02171553f, 0.17744978f, 
    -0.03664572f, 0.02728158f, -0.03193535f, 0.01426175f, -0.00195007f, -0.02091969f, 0.02599364f, 0.00034784f, 
    -0.02202875f, -0.03048669f, 0.01319501f, 0.01885531f, 0.00197666f, 0.00727729f, 0.01757901f, 0.00626669f, 
    0.01791100f, 0.03663284f, -0.01577409f, 0.01661035f, -0.02528305f, 0.01468878f, 0.01873014f, 0.00908875f, 
    -0.02824039f, 0.01160442f, 0.01496232f, 0.00180983f, 0.00083820f, -0.00098720f, 0.02787016f, 0.02856203f, 
    -0.02904031f, 0.00689430f, -0.03250854f, -0.01009747f, 0.01693522f, 0.01046346f, -0.02556454f, -0.00952643f, 
    -0.00275025f, 0.01747110f, 0.02322174f, 0.03091959f, -0.00637045f, -0.01057799f, 0.00437701f, 0.01560712f, 
    -0.02391166f, -0.00602231f, 0.00014412f, -0.01267814f, 0.02946609f, -0.03766458f, -0.01428494f, 0.00219316f, 
    -0.02794353f, 0.02380882f, -0.03490733f, 0.00778261f, -0.00530558f, 0.01610517f, -0.01140118f, 0.00466438f, 
    -0.02841454f, -0.01034291f, 0.00493988f, 0.03641284f, 0.00645373f, 0.00730864f, 0.01876882f, 0.02114883f, 
    0.02922444f, -0.02797788f, 0.01081056f, -0.02775052f, 0.01939374f, 0.02132642f, 0.01639286f, 0.00030033f, 
    -0.03968653f, -0.03775087f, -0.02080491f, 0.01037715f, -0.03666049f, -0.00809711f, -0.03635772f, 0.01907680f, 
    -0.01852574f, -0.03290945f, 0.02335189f, 0.03028782f, 0.01330153f, 0.01701990f, 0.03048227f, -0.01528199f, 
    -0.04542162f, -0.00682954f, 0.00613349f, 0.00086328f, 0.00748260f, 0.01955286f, 0.01744033f, -0.02067188f, 
    0.02637040f, 0.02158373f, 0.01890340f, -0.02170618f, -0.01162033f, 0.00006389f, 0.00280719f, -0.03356570f, 
    0.01066782f, -0.00446735f, -0.01863091f, -0.01776474f, 0.00836499f, 0.01525404f, -0.02983883f, 0.02915443f, 
    0.00446456f, -0.02471396f, 0.00701728f, -0.01945090f, -0.00961379f, 0.01072325f, -0.01606009f, -0.03641662f, 
    -0.02744351f, -0.03428143f, 0.00413287f, -0.01944977f, -0.03118321f, -0.03421070f, -0.04225287f, 0.01921577f, 
    0.00801482f, -0.00808377f, -0.00042468f, 0.01348813f, -0.01948149f, -0.00207884f, -0.01913829f, -0.00469146f, 
    0.01400707f, 0.03326908f, -0.01946775f, 0.03319566f, -0.01140380f, -0.03888154f, -0.00657092f, -0.02710403f, 
    -0.02613464f, -0.03361288f, 0.02105815f, -0.02658023f, 0.00770600f, -0.02351121f, 0.01908783f, -0.01621249f, 
    -0.02215116f, 0.03721546f, 0.00720555f, 0.00873079f, 0.03325007f, -0.03803859f, -0.00142729f, -0.03339617f, 
    0.02502262f, -0.01917434f, -0.02559770f, -0.01440206f, -0.00669181f, 0.00527985f, 0.03425362f, 0.00258504f, 
    -0.04184326f, -0.02325597f, -0.04617781f, 0.01034515f, 0.03050875f, 0.02244220f, -0.02547811f, -0.00388966f, 
    0.02767762f, 0.01860476f, -0.02703378f, 0.02317536f, -0.00439685f, -0.02099253f, -0.04312443f, -0.01550700f, 
    0.00048470f, -0.02295302f, -0.03319581f, 0.03007632f, 0.02350129f, -0.00120301f, -0.00800350f, -0.01259373f, 
    -0.02888398f, 0.00415214f, -0.01053630f, -0.01479862f, -0.01243215f, 0.00087222f, 0.01622786f, -0.00892287f, 
    -0.00818896f, -0.00461704f, 0.02247898f, 0.02444394f, -0.00044699f, 0.02753174f, -0.00595609f, -0.00039212f, 
    0.02333899f, 0.00702809f, -0.01251350f, 0.02044621f, -0.00122297f, -0.04226670f, 0.00890774f, 0.00197932f, 
    0.00786061f, -0.02152239f, -0.04816670f, -0.01860613f, 0.02096386f, -0.03087480f, -0.02288164f, -0.01405822f, 
    0.02220931f, -0.04335986f, -0.00900115f, -0.00247002f, 0.01149685f, 0.02184765f, -0.01786907f, 0.02263412f, 
    0.00042681f, -0.03639025f, -0.04387883f, -0.04108798f, 0.01530076f, -0.01830754f, -0.00423724f, -0.02948533f, 
    -0.03224744f, -0.03652590f, 0.00684319f, -0.01749226f, -0.02276592f, -0.01279522f, -0.01808572f, -0.00031405f, 
    0.00148825f, -0.01773880f, 0.03476978f, 0.02581935f, 0.00503072f, 0.00606960f, -0.01925974f, -0.00301787f, 
    -0.00385928f, -0.02071687f, -0.00614670f, 0.00756035f, -0.03433710f, -0.03522085f, -0.00841112f, -0.03177864f, 
    -0.02106728f, -0.03154271f, 0.03053950f, 0.01311987f, -0.03426876f, 0.01060221f, 0.00124013f, 0.02778881f, 
    0.03024188f, -0.00138810f, 0.01607457f, 0.01591295f, 0.02202796f, -0.00739179f, -0.01464169f, 0.01095660f, 
    0.00485624f, 0.03710346f, -0.00070079f, -0.02405506f, 0.01823238f, 0.03018062f, -0.01805775f, -0.00389619f, 
    0.01742888f, -0.02046138f, -0.04382408f, -0.02966982f, 0.02154073f, -0.00125764f, -0.03768563f, 0.00072082f, 
    0.01717280f, -0.02065823f, -0.03938250f, 0.00725680f, 0.01047352f, 0.00457589f, -0.02114129f, -0.03842242f, 
    0.00636423f, 0.03083718f, -0.00887211f, 0.01462386f, -0.03615985f, 0.03245734f, 0.01450704f, -0.02574905f, 
    -0.00385294f, 0.01318831f, -0.03623004f, 0.02360356f, -0.03373196f, 0.01534994f, 0.00045864f, -0.02293991f, 
    0.00803936f, -0.02261147f, -0.00102541f, -0.04153178f, 0.02399562f, 0.02014854f, 0.02089346f, -0.01310337f, 
    0.01193338f, 0.01936727f, -0.02208246f, -0.02654914f, 0.02604118f, -0.02052594f, -0.02495954f, -0.02403058f, 
    0.01202628f, 0.01729162f, 0.00353665f, -0.01267003f, -0.04427192f, -0.03089902f, -0.01736061f, 0.01626287f, 
    -0.01581281f, 0.02014242f, 0.02507939f, 0.00930277f, 0.01222333f, -0.00494856f, 0.01304044f, -0.01448738f, 
    -0.03278962f, -0.01654228f, 0.01618870f, 0.02500477f, 0.03221586f, 0.00625722f, 0.02950735f, -0.01389872f, 
    0.02612911f, -0.02451310f, -0.03489121f, -0.03744939f, -0.03010509f, -0.00063230f, -0.00865923f, -0.00769950f, 
    0.01715444f, -0.03194577f, -0.02815566f, 0.03706352f, -0.00257284f, -0.00198192f, 0.03701639f, -0.02672339f, 
    -0.03283717f, -0.02837751f, -0.01290572f, -0.02423689f, 0.02845997f, -0.03036890f, 0.00781973f, -0.03623791f, 
    0.01217257f, -0.01430989f, -0.02688126f, -0.00122566f, 0.01640741f, -0.00966124f, 0.00708909f, -0.00480077f, 
    0.00161300f, 0.02232389f, -0.02067498f, 0.00954603f, -0.00122451f, -0.02422333f, -0.03222490f, -0.02676217f, 
    0.01178438f, -0.03899273f, -0.01448778f, -0.01616199f, 0.01018955f, 0.01057273f, -0.00279709f, -0.02073927f, 
    0.00171635f, 0.03043220f, -0.03706547f, -0.01188966f, -0.01086645f, -0.00805718f, -0.01856429f, -0.03697971f, 
    0.01546360f, 0.02634536f, 0.02441058f, -0.00121971f, 0.00625699f, -0.01017507f, -0.00419767f, 0.00448989f, 
    -0.01954927f, -0.00295922f, -0.03053857f, -0.00687175f, -0.02140802f, 0.02439021f, -0.00780613f, 0.00822095f, 
    -0.01178638f, -0.03534508f, -0.01568758f, -0.01022397f, 0.04674577f, 0.03817547f, -0.01756910f, -0.00278796f, 
    -0.00877156f, -0.04605402f, -0.02289780f, 0.02105005f, 0.01724782f, -0.02161887f, 0.00519394f, -0.01883652f, 
    -0.00274592f, -0.03556637f, 0.02394835f, 0.02138403f, -0.00285457f, -0.00044403f, 0.03096380f, -0.02550825f, 
    -0.03256790f, 0.00898115f, 0.03691001f, -0.02146515f, -0.02541150f, 0.01071833f, -0.01607247f, -0.00759371f, 
    0.02788018f, 0.02216149f, 0.00074435f, -0.01985442f, -0.01608757f, -0.01124032f, -0.04014745f, -0.02256055f, 
    -0.01225535f, -0.01674255f, 0.02860181f, 0.02060344f, -0.00081266f, -0.02131809f, -0.00706784f, -0.00232333f, 
    -0.02999601f, 0.00092809f, -0.03069804f, -0.01295060f, -0.03316959f, 0.01670813f, -0.01325920f, 0.02855480f, 
    -0.01596541f, -0.04041005f, 0.02099873f, -0.03825008f, 0.00712432f, -0.00426311f, -0.00145334f, 0.02491524f, 
    -0.03026224f, -0.01054492f, -0.02085368f, -0.03838779f, -0.00340246f, 0.00588333f, -0.00275691f, 0.01045212f, 
    -0.00396080f, 0.01033921f, -0.00181105f, 0.01427708f, -0.03349268f, -0.02546503f, 0.04164563f, 0.02413967f, 
    0.01814949f, 0.01541096f, -0.00981674f, -0.00503375f, 0.01035616f, 0.00453286f, -0.00785942f, 0.02690269f, 
    -0.01285938f, 0.01905867f, 0.01644543f, -0.01964964f, -0.03805041f, -0.03585790f, 0.00422137f, 0.02703523f, 
    -0.03299116f, -0.01516330f, -0.01261609f, -0.01149907f, 0.03568330f, 0.01896436f, 0.03303365f, 0.01615329f, 
    -0.01433993f, 0.02210411f, 0.02944577f, 0.01419214f, 0.00613064f, -0.00536063f, -0.02560085f, 0.00635062f, 
    0.02548202f, 0.02514347f, 0.00368597f, 0.01636520f, -0.02940931f, -0.04223298f, -0.01305620f, 0.02927015f, 
    0.04080416f, -0.04236949f, 0.02569574f, 0.00209153f, 0.01884905f, -0.01560722f, -0.01988856f, 0.01475489f, 
    -0.01979557f, -0.03479771f, -0.04434278f, -0.04761627f, -0.01135765f, -0.00252827f, -0.01494540f, -0.00330872f, 
    -0.02504427f, -0.00084305f, -0.01027851f, -0.00310659f, 0.02149235f, 0.01923958f, -0.02308856f, -0.01749870f, 
    0.00508926f, -0.00123261f, -0.01240029f, -0.00580070f, -0.01684121f, 0.02254816f, 0.03828483f, 0.00016786f, 
    -0.03244900f, -0.03673715f, -0.02534570f, -0.02821877f, 0.01527892f, -0.00980136f, -0.02438000f, 0.02686861f, 
    -0.03499344f, 0.01897608f, -0.04134633f, -0.04376007f, -0.02633866f, -0.01898044f, 0.02559452f, 0.02011522f, 
    0.02276533f, 0.02396925f, 0.00064844f, 0.03566055f, 0.00610622f, 0.01831828f, -0.01880617f, 0.02520357f, 
    -0.03369239f, 0.01398786f, -0.03399654f, -0.04264729f, 0.00314591f, -0.02842290f, -0.00092358f, 0.02679549f, 
    0.00874507f, -0.00047968f, 0.00373031f, -0.01740298f, -0.02005356f, -0.00859879f, 0.02254806f, -0.00875061f, 
    0.01259924f, -0.03265502f, 0.01828927f, 0.00835876f, 0.00853740f, -0.03631938f, 0.00208985f, -0.00509702f, 
    -0.03386647f, 0.00514050f, 0.00803722f, -0.04024531f, -0.00831334f, 0.00166852f, -0.03615881f, -0.02650524f, 
    0.00105286f, -0.03518971f, 0.00798685f, -0.02258190f, 0.02167304f, 0.01610227f, -0.01375982f, 0.01229164f, 
    -0.01270288f, 0.03720932f, -0.03704844f, -0.00518659f, -0.02625196f, -0.01389229f, 0.00810391f, 0.02643857f, 
    0.01136889f, -0.01907543f, -0.03853912f, 0.00615666f, -0.04025149f, -0.00922795f, 0.01241021f, 0.02531910f, 
    0.00655816f, 0.01868762f, -0.02911712f, -0.00300916f, -0.00802478f, -0.04109261f, -0.01679658f, -0.01529588f, 
    -0.04359736f, -0.04197878f, -0.01418935f, 0.00164080f, -0.01770831f, -0.01061636f, -0.03220315f, -0.03499900f, 
    0.02596443f, 0.01526149f, -0.03044428f, 0.01322592f, -0.01325706f, -0.02431506f, -0.02372001f, -0.03952627f, 
    -0.00354558f, -0.00834037f, -0.03606471f, -0.01169075f, 0.02661884f, -0.02409973f, -0.02161893f, -0.02137919f, 
    0.00282787f, 0.03026917f, -0.02485430f, 0.02072400f, -0.00201297f, -0.03549021f, -0.02833567f, 0.01183580f, 
    0.00704629f, -0.01919368f, -0.00183567f, 0.00867187f, -0.03528019f, 0.01812660f, -0.01261957f, -0.01604958f, 
    -0.02069612f, -0.04158989f, -0.00370264f, 0.00205206f, -0.00818387f, 0.00419359f, -0.03844004f, -0.02054585f, 
    -0.03174230f, 0.00337542f, -0.00488262f, -0.01387979f, -0.04519668f, -0.00186833f, 0.00849232f, 0.00386466f, 
    -0.02109267f, -0.02666926f, 0.00917301f, -0.00973909f, 0.00507481f, 0.00226545f, 0.02483298f, 0.00828258f, 
    0.00998961f, -0.00353834f, 0.02167842f, -0.02459218f, -0.00419380f, 0.01160203f, 0.02072105f, 0.01858127f, 
    -0.02173268f, -0.01021214f, -0.00667512f, 0.00176684f, 0.01241285f, -0.02257871f, 0.02834247f, 0.00398791f, 
    -0.03284724f, 0.00148802f, -0.02985457f, -0.00451029f, -0.01615357f, 0.01326438f, 0.01542506f, 0.02032508f, 
    -0.03702305f, -0.08651506f, 0.02225209f, -0.07756457f, -0.04738937f, 0.07017350f, -0.02777511f, 0.00925712f, 
    -0.07692355f, 0.05133840f, -0.07854410f, 0.06935438f, -0.04937205f, -0.06636256f, -0.11460525f, -0.00838347f, 
    -0.15258172f, -0.02077586f, -0.18997729f, -0.16407028f, -0.05482572f, -0.07006445f, 0.10383448f, 0.00837986f, 
    -0.20665203f, -0.01143894f, -0.02775139f, -0.08751010f, 0.01016200f, -0.01214687f, -0.08051963f, 0.05008999f, 
    -0.01730509f, 0.10858999f, -0.00071981f, -0.01058865f, -0.11227898f, -0.11442537f, -0.27532312f, 0.07795272f, 
    -0.00060663f, 0.03060423f, -0.01059267f, -0.02430599f, -0.09380206f, -0.00767402f, 0.08604652f, 0.01036948f, 
    0.01145507f, 0.13221930f, 0.07330431f, 0.28742492f, 0.02103931f, -0.07693728f, 0.03083217f, 0.09020266f, 
    -0.07581937f, 0.04450877f, -0.14627652f, 0.00526769f, -0.10471684f, -0.15944515f, -0.07417406f, -0.01572663f, 
    0.17705412f, 0.07761460f, 0.02881179f, 0.00237332f, -0.06917651f, -0.06149570f, 0.12014294f, 0.02075257f, 
    -0.17363665f, -0.18781021f, 0.09009165f, -0.04685515f, -0.10770001f, 0.09500948f, 0.06394749f, -0.01467564f, 
    -0.06898151f, 0.04292011f, -0.13574025f, -0.08004575f, -0.08882328f, -0.06546859f, 0.07838188f, -0.00693722f, 
    0.11521951f, 0.00944482f, 0.03660732f, 0.19748838f, 0.03200427f, 0.00103232f, 0.04218780f, 0.09301121f, 
    0.15272091f, -0.26027304f, -0.00517046f, 0.17318094f, 0.04663797f, 0.12438568f, 0.09876076f, -0.09157872f, 
    0.02992594f, 0.06843670f, 0.07226323f, 0.06212644f, 0.21901126f, 0.00441915f, 0.08665767f, 0.06482465f, 
    -0.00220408f, 0.03551637f, -0.01469520f, 0.11364231f, -0.12184355f, 0.06478376f, -0.05688540f, 0.17823946f, 
    0.16835979f, 0.23417687f, 0.04017904f, -0.15859911f, 0.07595077f, -0.01598381f, 0.00317021f, 0.02300695f, 
    0.02050693f, -0.00514772f, -0.04306461f, 0.16546865f, -0.13179617f, 0.04307839f, 0.11805286f, -0.05916764f, 
    0.08753487f, 0.13252617f, 0.00560837f, 0.09859353f, -0.04459597f, -0.00475201f, -0.00151840f, 0.06936742f, 
    -0.18604763f, -0.09180795f, -0.12251037f, 0.05510344f, 0.21691950f, -0.13805366f, -0.13256960f, -0.02062899f, 
    0.00261683f, 0.09248066f, -0.08063958f, 0.17671241f, 0.01318820f, -0.08768083f, 0.18968186f, -0.02748588f, 
    0.05099899f, -0.10788728f, 0.07566508f, -0.07128007f, -0.02513325f, 0.06616393f, 0.06862472f, 0.09267011f, 
    -0.07552975f, -0.04437916f, 0.15716252f, -0.08812167f, 0.04212777f, 0.03876776f, -0.04005699f, 0.07635012f, 
    0.10169529f, 0.04089510f, 0.05688229f, 0.05504509f, -0.02090351f, 0.00689483f, 0.04496435f, 0.28365260f, 
    0.00290912f, -0.07266621f, 0.03109730f, 0.03512101f, 0.11451029f, 0.04287650f, -0.06074113f, 0.14914562f, 
    -0.06592951f, -0.17947237f, 0.06851367f, 0.15361640f, 0.06673594f, 0.03822701f, -0.00087202f, 0.02190804f, 
    -0.02325101f, 0.04803190f, -0.04516836f, 0.03474604f, -0.22851975f, -0.02334584f, -0.17177956f, -0.15135804f, 
    0.00213103f, -0.00344891f, 0.01993304f, -0.04251109f, 0.07054906f, -0.07662437f, 0.09411813f, -0.00488869f, 
    -0.02546394f, 0.21716850f, 0.02775415f, 0.03681707f, 0.07393214f, -0.02710706f, -0.05211009f, 0.10776500f, 
    -0.04454960f, 0.02634440f, 0.08980198f, -0.04712292f, 0.09475828f, -0.07755810f, -0.06114245f, -0.10861296f, 
    -0.09512918f, 0.08777482f, -0.27404925f, 0.00609641f, -0.07716659f, 0.03944436f, 0.14182547f, -0.08110686f, 
    -0.13579072f, 0.02122839f, -0.14074802f, 0.00947780f, -0.06891910f, 0.13881975f, 0.02513941f, -0.06018019f, 
    0.01684259f, 0.18906960f, 0.08474074f, 0.09382463f, -0.20368557f, -0.04644177f, 0.09280510f, -0.03452494f, 
    0.01704346f, -0.03417990f, -0.06822064f, 0.01559359f, 0.18025517f, -0.09745879f, -0.15204300f, -0.13441332f, 
    0.27455032f, -0.08182236f, -0.13307220f, -0.03349341f, 0.15044460f, -0.19784321f, -0.05065351f, -0.02077878f, 
    -0.05831543f, -0.06917866f, -0.03753608f, 0.01595036f, 0.24845035f, 0.02098632f, -0.01163606f, 0.07759034f, 
    -0.04356476f, 0.06881826f, 0.04896848f, 0.03716436f, -0.02169930f, -0.02035769f, 0.03739310f, 0.02444790f, 
    -0.13039102f, 0.00505311f, 0.09600605f, -0.10073575f, 0.00350134f, -0.06648092f, 0.01310164f, -0.03004304f, 
    0.00372718f, -0.06214096f, -0.02575178f, -0.06378848f, 0.32627439f, 0.07347707f, -0.16670260f, -0.11517639f, 
    -0.07389041f, 0.10733680f, 0.00147016f, -0.04681287f, 0.08312992f, 0.04830034f, 0.08613955f, 0.07591899f, 
    0.08101593f, -0.25266010f, 0.10106707f, 0.04865992f, 0.14464658f, 0.07581493f, -0.13328665f, -0.06546953f, 
    0.14980119f, -0.09087576f, -0.00273280f, 0.07489396f, -0.04844304f, -0.06059890f, -0.05259533f, 0.10971448f, 
    0.03539310f, -0.09010296f, 0.01056188f, -0.02640200f, 0.04605648f, 0.10976252f, -0.05911250f, -0.10218325f, 
    0.32348540f, 0.15758023f, -0.23484838f, 0.07578372f, 0.02181417f, 0.03311580f, 0.05515965f, 0.03800635f, 
    0.03792869f, 0.01993665f, 0.03690539f, -0.16459918f, -0.01056772f, 0.02387646f, 0.09754731f, -0.06392407f, 
    -0.12612441f, -0.01607664f, -0.08565326f, -0.11311089f, 0.07409905f, 0.04005036f, 0.10315575f, 0.02424123f, 
    0.01809900f, 0.04566156f, 0.15144034f, -0.01098076f, -0.03020797f, 0.02955469f, 0.00050046f, -0.03126564f, 
    0.10832885f, -0.01547255f, -0.07803769f, 0.06364501f, 0.10421254f, -0.05235280f, 0.22222067f, 0.14013648f, 
    0.06627779f, 0.04472116f, 0.07653338f, 0.10640973f, -0.03522179f, 0.02975180f, -0.06494106f, 0.11107619f, 
    -0.41014978f, 0.21394241f, -0.15592372f, 0.10385180f, -0.03116860f, -0.06347322f, -0.03208725f, 0.01765940f, 
    0.05202647f, 0.07714248f, 0.01831407f, 0.08772825f, 0.10873768f, -0.08882504f, -0.08918019f, 0.04459941f, 
    0.10423297f, 0.14493249f, -0.00319587f, 0.17444946f, -0.02651587f, 0.14116864f, -0.02892405f, 0.03907211f, 
    0.10705162f, -0.01489446f, 0.04638634f, -0.01690914f, 0.02307921f, -0.02774990f, 0.08670236f, -0.06598415f, 
    0.09472704f, 0.01796984f, -0.05370793f, 0.00380054f, 0.12975079f, -0.08691419f, 0.02287166f, -0.06751990f, 
    0.01172013f, 0.04514306f, -0.07438810f, 0.01425724f, -0.02987610f, -0.02745976f, 0.02065792f, -0.05334249f, 
    -0.05410558f, 0.17878993f, -0.05542400f, -0.01135225f, -0.04481983f, 0.01176905f, -0.00266388f, 0.02355471f, 
    0.01498186f, 0.02515373f, 0.05266801f, -0.01774794f, 0.07903421f, -0.15841863f, -0.08897671f, 0.02635030f, 
    0.06145693f, 0.02909049f, -0.04720385f, -0.02520904f, 0.00604670f, 0.06716821f, 0.00117769f, -0.08590809f, 
    -0.18109903f, 0.01199964f, -0.12985313f, -0.12217489f, -0.08598149f, -0.10745657f, -0.05315677f, -0.12300511f, 
    -0.01456069f, -0.01871927f, 0.01657337f, -0.02016998f, 0.32598427f, 0.20630388f, -0.03193215f, 0.00391737f, 
    0.04966411f, 0.09580286f, -0.03423240f, -0.01753580f, 0.02873385f, 0.04404617f, 0.06436895f, -0.09272936f, 
    -0.06448457f, 0.15152158f, 0.06358063f, -0.05320904f, 0.09499855f, 0.01022896f, -0.13620315f, -0.06962477f, 
    0.09255456f, -0.07797299f, 0.11810757f, 0.00955113f, 0.17573056f, 0.02572222f, -0.01368020f, -0.17527901f, 
    0.05492437f, -0.06082974f, 0.05504208f, 0.07983811f, 0.03931532f, 0.07789736f, -0.01033467f, 0.07112896f, 
    0.18144163f, -0.03678722f, -0.00745072f, -0.01237036f, 0.00620593f, -0.01564519f, 0.11221777f, 0.07107958f, 
    -0.09256165f, 0.07692524f, 0.07549468f, -0.18472916f, 0.23784231f, -0.06732757f, -0.02056475f, -0.12041933f, 
    0.00421889f, 0.02958393f, 0.03274100f, 0.04462204f, 0.06509787f, 0.09356895f, 0.02467974f, 0.08821405f, 
    0.13839512f, 0.02893060f, 0.04184330f, 0.06111695f, 0.08073996f, 0.01005980f, 0.00439619f, 0.02578060f, 
    -0.02364536f, -0.01096994f, -0.03067928f, -0.07293835f, -0.24047309f, -0.27616397f, 0.04891222f, -0.09121963f, 
    0.07705233f, -0.01490029f, -0.04802314f, -0.02777315f, -0.01935879f, 0.04323609f, -0.06155708f, -0.13349476f, 
    -0.10765764f, -0.09183830f, -0.05009856f, 0.09990244f, -0.03840543f, -0.10372621f, -0.06781214f, -0.06929766f, 
    -0.09415748f, 0.08475501f, -0.05033879f, 0.05695060f, 0.20329419f, 0.15304057f, -0.01682435f, 0.09678707f, 
    0.11421105f, -0.04616075f, 0.10292692f, 0.05704062f, 0.22293383f, -0.10092264f, -0.07687748f, 0.09180038f, 
    0.03080229f, -0.00813118f, 0.03848243f, 0.14347921f, -0.00964990f, 0.00766748f, -0.10465115f, 0.15831567f, 
    -0.01615153f, -0.13987117f, 0.09343455f, -0.17924209f, 0.36253986f, 0.10684776f, -0.13028395f, -0.08601426f, 
    -0.07106999f, 0.05098973f, 0.01658002f, -0.05477731f, -0.01300105f, 0.03627536f, 0.07286536f, 0.09672521f, 
    0.22104411f, 0.11892930f, 0.09719820f, 0.11506478f, -0.03248807f, 0.02487155f, 0.07746754f, 0.05887213f, 
    -0.04428700f, 0.02040932f, -0.09879630f, -0.10744119f, 0.33637390f, -0.02396954f, 0.01295371f, 0.00535719f, 
    0.02652734f, 0.08973311f, 0.05580640f, -0.02525272f, -0.03036618f, -0.07995097f, -0.04286664f, 0.01782146f, 
    0.10370513f, 0.13545802f, 0.17476170f, -0.13102189f, -0.01255798f, -0.05792436f, 0.01364053f, -0.05968701f, 
    0.09795815f, 0.00796705f, 0.06577652f, 0.15448324f, 0.19161488f, 0.03149252f, -0.18506441f, -0.21924475f, 
    0.10745769f, 0.09835203f, 0.06313497f, -0.03722008f, 0.20541950f, 0.04923711f, 0.05680874f, -0.14452612f, 
    0.09159806f, 0.04127742f, 0.03710298f, -0.31201187f, 0.04406352f, -0.07867009f, 0.00537990f, -0.09554264f, 
    -0.06153721f, 0.00183405f, -0.05554952f, -0.03194884f, -0.01542417f, -0.10443596f, 0.04432448f, -0.06636990f, 
    0.05406160f, 0.03857419f, -0.02686254f, 0.07477673f, 0.11904109f, -0.04367463f, 0.06053203f, -0.03617658f, 
    0.08525901f, -0.12858830f, 0.06501637f, 0.02653317f, 0.00066368f, 0.06092571f, 0.07000819f, 0.11683153f, 
    0.04381946f, 0.04261684f, 0.07696410f, 0.11468737f, -0.13222168f, 0.05305850f, -0.08501852f, -0.07358668f, 
    -0.01761630f, -0.01456821f, -0.01915690f, -0.10708757f, 0.08802968f, 0.01943605f, -0.01836995f, 0.00892171f, 
    -0.11932977f, -0.21196516f, -0.06322623f, -0.05750538f, -0.00803449f, 0.08004094f, 0.03195462f, 0.12247031f, 
    0.01731993f, 0.09553524f, 0.03633444f, -0.10675757f, 0.27752632f, -0.11290648f, 0.04426453f, -0.07846484f, 
    0.12559333f, 0.04432293f, 0.03157657f, -0.12648900f, 0.02867665f, 0.03204082f, -0.01605961f, -0.02783681f, 
    0.05329165f, 0.09062917f, 0.02758100f, 0.11219856f, 0.08444110f, 0.02667707f, -0.01599241f, -0.05066624f, 
    0.04995609f, 0.03736226f, 0.07220035f, 0.18590795f, 0.32111320f, -0.08260999f, 0.02038013f, 0.06482913f, 
    0.02672349f, 0.03719081f, -0.08448850f, 0.04852134f, 0.05141929f, -0.06808265f, 0.07276851f, 0.00531416f, 
    -0.01730781f, -0.05244425f, 0.00146249f, -0.09029154f, -0.07962413f, 0.09498613f, -0.02215140f, -0.07937556f, 
    -0.02215200f, 0.05986940f, -0.01198112f, -0.09631713f, 0.14695644f, 0.03886968f, -0.13602319f, 0.01884363f, 
    0.07856435f, 0.02447332f, -0.02939192f, -0.08611870f, 0.09629626f, 0.11637736f, 0.06476538f, -0.04322558f, 
    0.16822344f, 0.01144818f, 0.02683573f, 0.09615902f, -0.03368617f, -0.06861287f, -0.02991108f, -0.05920245f, 
    -0.11366908f, 0.00387686f, 0.02866965f, 0.03938005f, -0.20313972f, -0.01120838f, 0.04967828f, 0.21105151f, 
    0.11449338f, 0.01882799f, 0.00065650f, 0.06620598f, -0.02053556f, 0.03276603f, 0.00354639f, 0.12050521f, 
    0.00305069f, 0.17830779f, 0.11817329f, -0.06483681f, -0.08951741f, 0.04842196f, -0.00525955f, -0.05162273f, 
    -0.03046990f, -0.11727164f, -0.00880686f, 0.09434555f, -0.04254670f, -0.10115123f, -0.07024556f, 0.08544766f, 
    0.13649869f, 0.04941551f, 0.09533293f, 0.03474483f, 0.10488729f, -0.01242483f, -0.08341058f, -0.05889869f, 
    0.26368335f, 0.02678977f, 0.00402499f, -0.05489790f, 0.00622701f, 0.05398767f, 0.00755936f, -0.12575689f, 
    -0.07074549f, 0.05441044f, 0.04653059f, -0.05783623f, 0.14457430f, 0.12644380f, 0.15298013f, 0.10999203f, 
    -0.06607860f, -0.08493411f, 0.01074960f, 0.12373457f, -0.00262205f, 0.04606582f, -0.07264979f, 0.03760495f, 
    -0.32466877f, -0.17800713f, 0.13994054f, 0.18801351f, -0.06848180f, -0.01418994f, -0.03160449f, 0.19361936f, 
    0.02863835f, -0.03005142f, 0.11882533f, 0.00562352f, 0.35782129f, 0.04435405f, -0.02687195f, -0.16819820f, 
    -0.01736699f, -0.09835254f, 0.07829718f, 0.02913191f, 0.05388080f, 0.05838339f, -0.08018752f, -0.11288324f, 
    -0.09379429f, -0.12942871f, -0.05638176f, 0.19799803f, 0.12899053f, -0.01162353f, 0.08982775f, -0.06867880f, 
    -0.21090762f, -0.06431816f, -0.10091311f, 0.03418471f, 0.24050911f, 0.08904146f, 0.10382207f, 0.07686767f, 
    -0.00100445f, -0.01283193f, 0.01382951f, 0.02294502f, -0.18408962f, -0.04709622f, 0.04343149f, -0.07577727f, 
    0.05505407f, 0.03791577f, -0.11832549f, -0.11803138f, 0.08928370f, 0.02350219f, -0.06790525f, 0.08256689f, 
    0.05544034f, 0.00006808f, -0.04440349f, -0.02866257f, 0.04023611f, 0.22668955f, 0.13681372f, -0.09788215f, 
    -0.08019943f, -0.03832025f, -0.07316371f, -0.11804017f, 0.02325469f, -0.03300912f, -0.00229443f, -0.02944140f, 
    0.02884839f, -0.05763714f, -0.22937967f, -0.01365052f, 0.10267790f, 0.00049906f, -0.03174752f, -0.00645211f, 
    0.11414372f, -0.02519998f, -0.03496372f, -0.06729883f, 0.23145556f, 0.13197829f, -0.06312936f, -0.00294125f, 
    -0.15682203f, -0.02619653f, -0.01721083f, 0.14663187f, -0.06030478f, -0.06170469f, 0.12545110f, 0.05346071f, 
    0.38242006f, 0.21126492f, -0.08771016f, -0.14425159f, 0.06500673f, -0.00986760f, -0.05172861f, -0.09381600f, 
    -0.01722598f, 0.09625694f, -0.06963049f, -0.02600117f, -0.19426148f, 0.12786674f, -0.09001736f, -0.04001584f, 
    -0.00986184f, -0.03115033f, 0.01199650f, 0.01843748f, 0.03992836f, -0.13768534f, 0.14124088f, 0.15111662f, 
    -0.01298252f, -0.36190683f, 0.07105491f, 0.17844570f, -0.07074669f, -0.00649272f, -0.09128521f, -0.02953868f, 
    -0.18394220f, -0.06139166f, 0.04602799f, -0.04842652f, 0.07471100f, 0.10896110f, 0.10966148f, 0.14930387f, 
    0.01233684f, 0.06338095f, 0.10066018f, 0.06159182f, 0.00924137f, 0.05593246f, 0.03755073f, -0.12716480f, 
    0.01981696f, 0.11210087f, 0.02133870f, 0.28579089f, 0.00401602f, -0.06555650f, 0.12642246f, -0.09385803f, 
    -0.00913846f, 0.02867459f, 0.01504431f, -0.02723502f, -0.09733203f, 0.09311274f, -0.22703311f, -0.13260226f, 
    -0.03753112f, 0.01960529f, 0.01153812f, 0.01431109f, 0.04208712f, 0.00103038f, 0.01934159f, 0.09584586f, 
    0.10762455f, 0.02931100f, 0.09853262f, 0.17925020f, -0.00415135f, 0.15206392f, -0.06258521f, 0.12211323f, 
    0.03214363f, -0.01315203f, -0.00560071f, 0.03066903f, 0.01176507f, 0.06800270f, 0.03381125f, 0.02645665f, 
    -0.05353309f, 0.06358621f, -0.08047358f, -0.06391726f, -0.10176570f, 0.14725521f, -0.00036183f, 0.10104888f, 
    0.12259926f, 0.00160059f, -0.28444672f, -0.19599961f, 0.07485571f, 0.18865629f, -0.01325877f, 0.05676604f, 
    -0.05388042f, -0.06035373f, 0.00227979f, -0.02057695f, 0.29927212f, 0.14316300f, -0.02724124f, 0.01555494f, 
    -0.01796117f, 0.02596132f, 0.00750797f, -0.05408303f, -0.04690343f, -0.02631077f, 0.01154946f, -0.02610000f, 
    -0.04647401f, -0.04951483f, -0.00676013f, 0.05433687f, -0.08338025f, 0.08489891f, -0.04167895f, 0.08336759f, 
    0.00734122f, 0.04926718f, -0.00897297f, 0.02432983f, 0.17494071f, -0.02215393f, -0.04880811f, 0.01878132f, 
    0.15219282f, 0.10587941f, 0.06754407f, 0.05479576f, -0.10565302f, 0.08138780f, -0.04410576f, 0.04442748f, 
    0.18980283f, -0.27504987f, -0.09706095f, 0.00676390f, 0.05877674f, -0.03110538f, 0.04034393f, 0.01941455f, 
    -0.06586239f, 0.07195891f, 0.03565419f, 0.03975036f, -0.10278416f, -0.36234194f, 0.22132002f, 0.09783259f, 
    0.01682900f, 0.04315861f, 0.07872126f, -0.01281573f, 0.09823258f, -0.00273698f, 0.02515695f, 0.01700522f, 
    0.20745067f, 0.07177959f, -0.07039056f, 0.12097088f, 0.02340125f, 0.16085893f, 0.01630061f, 0.01016263f, 
    -0.05336466f, 0.03910666f, 0.04815598f, 0.07105029f, 0.40581957f, -0.09870251f, -0.07970295f, 0.23453915f, 
    -0.05570318f, 0.02562313f, 0.04653308f, 0.00409198f, -0.01117214f, -0.02629218f, -0.03109450f, -0.12553552f, 
    -0.01245035f, 0.14880866f, 0.05685036f, -0.09433464f, -0.20542218f, 0.08473915f, 0.09587348f, -0.01373748f, 
    0.09052169f, -0.03778093f, -0.15236774f, -0.11522807f, 0.27288887f, 0.04891057f, 0.02225827f, -0.19289988f, 
    -0.06703135f, -0.05390849f, 0.04621949f, -0.07383988f, 0.04081159f, -0.04470976f, 0.05161702f, -0.06975674f, 
    -0.04799497f, -0.23504256f, 0.16411538f, -0.13139071f, 0.12950942f, 0.04292728f, -0.05321768f, -0.00030314f, 
    0.03297701f, -0.14515074f, 0.02898698f, 0.00166206f, 0.29112521f, -0.02716545f, 0.13937689f, -0.10989749f, 
    0.00523759f, -0.08154459f, 0.07703546f, 0.10001118f, 0.05486846f, 0.05433447f, 0.03804965f, -0.12889810f, 
    0.31978366f, 0.06938497f, 0.16775256f, 0.10659891f, -0.00596859f, -0.05079288f, 0.08676745f, -0.01956426f, 
    0.01657961f, -0.15990326f, 0.08090936f, -0.01622215f, -0.58561271f, 0.24662700f, -0.07917293f, -0.17057040f, 
    0.01949641f, -0.01726313f, -0.02874799f, 0.00601421f, -0.05154177f, 0.09470191f, -0.03808254f, 0.07582322f, 
    0.25307149f, -0.16050126f, -0.06437019f, 0.14455526f, 0.05500940f, 0.03217101f, -0.01663073f, 0.03505852f, 
    0.06073908f, 0.01017673f, 0.00736840f, -0.07768399f, -0.19381462f, -0.18870133f, -0.12247854f, -0.29926750f, 
    0.07349679f, -0.10708597f, -0.02692699f, 0.09608221f, 0.08069229f, -0.05449190f, 0.05459415f, -0.09168797f, 
    0.14542019f, 0.23347589f, 0.06117912f, 0.18171838f, 0.12095009f, 0.08715537f, -0.08734497f, 0.01725902f, 
    0.14928736f, 0.02515190f, 0.04942125f, 0.12610976f, 0.08115740f, 0.18113181f, 0.17574878f, 0.04284806f, 
    -0.00143914f, 0.07204720f, -0.00596285f, 0.01509167f, -0.00821053f, 0.09901468f, -0.02585187f, -0.13853440f, 
    0.10879740f, 0.04950817f, -0.08797666f, 0.12206633f, 0.00911488f, -0.04256343f, -0.04860266f, -0.05582058f, 
    -0.02866494f, 0.14531867f, -0.00155836f, 0.03186851f, 0.20434409f, 0.13509913f, -0.07439890f, 0.19147180f, 
    0.18604702f, 0.01334527f, -0.05083166f, 0.00249538f, 0.01785257f, 0.02622381f, -0.11806786f, -0.10743275f, 
    -0.02582398f, 0.03163643f, 0.03394959f, -0.01454082f, 0.13764362f, -0.04714676f, -0.01197545f, 0.03473989f, 
    0.05267869f, -0.04507743f, -0.03604337f, 0.05112234f, 0.20220917f, -0.05179850f, -0.21381289f, -0.01080179f, 
    0.12033735f, 0.01461874f, 0.04490404f, -0.00090003f, 0.02952619f, -0.00910974f, -0.01226300f, 0.05672580f, 
    0.01930231f, -0.06542911f, -0.06828094f, 0.06011138f, 0.05790221f, -0.00240113f, 0.13911833f, -0.07053600f, 
    0.06577461f, 0.03665562f, 0.00365696f, 0.17061941f, 0.25591880f, 0.15942007f, -0.04854506f, 0.26875269f, 
    -0.07151585f, 0.19392589f, -0.17635287f, 0.01844201f, 0.22855578f, 0.00223934f, 0.03200432f, 0.18619671f, 
    0.20352070f, -0.43277788f, -0.12097041f, -0.22213314f, -0.02714807f, -0.00997177f, 0.04760851f, 0.08545658f, 
    0.07944254f, 0.09359470f, 0.03567417f, 0.01424282f, -0.19040106f, -0.07572979f, -0.07557167f, 0.02854285f, 
    0.20332842f, -0.04190668f, 0.00409053f, -0.04435546f, 0.15568919f, -0.08747301f, 0.03226812f, 0.13090047f, 
    0.17843062f, 0.05954977f, -0.04814763f, -0.04783828f, -0.11459740f, -0.10488136f, 0.07033028f, -0.03035439f, 
    -0.04664511f, 0.02266841f, -0.01403705f, -0.02680954f, 0.21443222f, -0.08491961f, -0.05987868f, -0.09282379f, 
    -0.05536081f, -0.00266148f, 0.00649241f, -0.05137968f, 0.07434060f, 0.03192316f, 0.09995478f, -0.00709132f, 
    -0.03617302f, -0.06453545f, 0.10542668f, -0.02783272f, 0.03166097f, -0.06129455f, 0.03800343f, 0.02761534f, 
    -0.17788538f, -0.05476077f, -0.02520061f, -0.01791104f, -0.11529123f, 0.08049694f, 0.01056723f, -0.17696856f, 
    -0.10260313f, -0.01409026f, 0.04055468f, 0.12240676f, -0.11837954f, 0.04433650f, -0.00694798f, -0.06188496f, 
    0.04670039f, -0.14007394f, -0.01060240f, 0.03703607f, 0.01308195f, -0.03552183f, -0.08046811f, 0.16685311f, 
    0.01369417f, 0.14303505f, -0.04305984f, 0.06939077f, 0.39175791f, -0.08080576f, 0.04200711f, 0.02549357f, 
    0.12585171f, -0.12477756f, -0.16385579f, -0.10479086f, -0.03616284f, -0.05380474f, 0.00362223f, -0.04211450f, 
    0.05904772f, -0.24214105f, -0.07478410f, 0.08394441f, -0.02861220f, -0.00424741f, 0.03438488f, -0.10328545f, 
    -0.03370745f, -0.00175446f, -0.00048802f, 0.15213759f, -0.08236476f, -0.02545359f, -0.21806251f, -0.13332665f, 
    0.07593083f, 0.01980158f, -0.07462943f, 0.08130164f, 0.12482298f, 0.03157453f, -0.03010682f, -0.00799176f, 
    0.19205545f, 0.00085790f, -0.02016261f, 0.13580106f, 0.06139344f, 0.15626039f, 0.10791995f, -0.05003834f, 
    -0.12421542f, -0.03058663f, -0.02780229f, -0.00484799f, -0.19640665f, 0.00895096f, 0.06676154f, -0.23987147f, 
    -0.11631440f, -0.01082715f, 0.07034993f, -0.00736388f, -0.10629909f, 0.05727059f, 0.14268881f, 0.02152914f, 
    0.28183201f, 0.15903951f, -0.09692147f, 0.05771640f, 0.06886346f, 0.13582592f, -0.11917783f, 0.03379911f, 
    0.01114663f, 0.05781488f, 0.00558313f, 0.16014965f, -0.06657866f, -0.33864892f, -0.05461902f, -0.23312001f, 
    -0.02119473f, 0.03206716f, -0.03664250f, -0.07582150f, -0.13817440f, -0.08725775f, 0.05600088f, -0.08521065f, 
    0.00098677f, -0.40846324f, -0.19061193f, 0.10239279f, -0.07188579f, -0.04981153f, -0.04711886f, 0.00980983f, 
    -0.08807851f, -0.03477700f, -0.01336673f, -0.11026361f, -0.03734461f, 0.19726408f, -0.10214810f, -0.07407060f, 
    -0.11561710f, 0.02511412f, 0.06005822f, 0.12102419f, 0.05317289f, 0.08967715f, -0.03958449f, -0.07132570f, 
    -0.08340935f, -0.14420596f, -0.05444646f, -0.10154847f, 0.10296296f, 0.09112491f, -0.12788728f, 0.03383460f, 
    0.09809541f, 0.07177684f, 0.01255043f, 0.09964382f, -0.17665897f, -0.31679681f, -0.22090656f, -0.15985864f, 
    -0.07036678f, -0.03663581f, 0.07090915f, 0.01419068f, 0.16229403f, -0.06009365f, 0.08489145f, 0.10655169f, 
    -0.02695129f, -0.03320055f, 0.01341129f, 0.01211326f, -0.01329686f, -0.00643294f, 0.01366563f, -0.02757833f, 
    0.01159673f, -0.02921113f, 0.00617919f, -0.02187850f, -0.03623832f, -0.03674341f, -0.02662229f, -0.02894012f, 
    0.00653058f, -0.02810686f, 0.01248092f, -0.00891575f, 0.01448790f, -0.01644914f, -0.03189737f, -0.03268453f, 
    -0.00017733f, -0.00250118f, -0.02616898f, -0.00625974f, 0.01565444f, 0.01214615f, 0.02201617f, 0.00780667f, 
    0.02708558f, -0.01364352f, -0.04133692f, -0.01152644f, -0.03475548f, 0.01767477f, -0.03309159f, 0.00896276f, 
    0.02350547f, 0.01283636f, 0.00012137f, 0.00378924f, -0.03292062f, -0.01275849f, -0.03401820f, -0.02833366f, 
    -0.00877334f, -0.02231897f, -0.03724198f, -0.03529404f, -0.00649278f, 0.02475478f, 0.02359493f, 0.02559864f, 
    0.00277033f, -0.03774686f, -0.02657197f, -0.04112065f, -0.02744649f, -0.02590953f, -0.03254982f, 0.02458800f, 
    0.01283617f, 0.02324590f, 0.01183139f, 0.00194102f, -0.03123942f, -0.03603578f, 0.00805002f, -0.00855617f, 
    0.00112943f, 0.01575208f, 0.00293900f, 0.01180604f, 0.02071078f, -0.00417631f, -0.00637912f, 0.01710073f, 
    0.00173234f, -0.04018233f, 0.00539700f, 0.01677181f, -0.02305230f, -0.00197899f, -0.00772174f, -0.00522649f, 
    0.01231859f, -0.03861516f, -0.01614839f, -0.01011616f, 0.01336762f, -0.03543720f, -0.02117482f, -0.01900750f, 
    -0.01230071f, 0.02016070f, 0.00241175f, 0.01808541f, -0.00774776f, -0.02046778f, 0.01047002f, 0.02554954f, 
    0.02190217f, 0.02485143f, -0.01958407f, -0.02751232f, -0.04344928f, -0.02344533f, -0.02258837f, -0.03619375f, 
    0.01316387f, 0.01955894f, 0.00514590f, -0.02053758f, 0.01966020f, -0.02774674f, -0.00399958f, -0.02794299f, 
    0.00851052f, -0.04050714f, -0.02250379f, -0.01510102f, -0.03873158f, -0.00407257f, 0.02686239f, -0.02813518f, 
    0.02866544f, -0.02301607f, -0.00051535f, -0.02709408f, -0.00342234f, 0.02922057f, -0.00351369f, 0.00161000f, 
    0.02079809f, -0.00291034f, 0.01658168f, -0.02213897f, 0.01896727f, 0.02909548f, -0.00331684f, 0.01329181f, 
    0.01909779f, -0.03233453f, -0.02403211f, 0.03712780f, 0.02883549f, -0.02679025f, -0.00958117f, 0.01905880f, 
    -0.03469384f, 0.00362643f, 0.00856365f, 0.02590984f, 0.01571823f, -0.04079037f, 0.01667243f, 0.01851983f, 
    -0.00380135f, 0.02837308f, -0.03972235f, -0.00590487f, -0.01988921f, -0.01176380f, 0.01762201f, 0.01392506f, 
    -0.00729781f, -0.03391984f, 0.01098754f, -0.02203245f, 0.00469952f, 0.01844013f, -0.02014813f, -0.02405913f, 
    -0.01989411f, 0.02197727f, -0.00482838f, -0.00413378f, 0.00423166f, -0.04041468f, -0.02520077f, 0.00921215f, 
    0.01026885f, -0.01607821f, 0.00515246f, -0.02390156f, 0.00605841f, -0.00820963f, 0.01862469f, 0.01315165f, 
    -0.00240857f, -0.02503050f, -0.00859184f, -0.01709213f, -0.02793515f, -0.02160152f, -0.04109835f, -0.02795321f, 
    -0.01415880f, -0.02017154f, -0.03245723f, -0.02780658f, 0.01774952f, -0.01204101f, 0.00953566f, -0.00168628f, 
    -0.04095370f, -0.02845291f, 0.00263715f, -0.01796660f, -0.00044182f, -0.01582269f, -0.03670278f, -0.02976122f, 
    -0.03532383f, -0.03886383f, -0.00761882f, 0.02372217f, -0.01972690f, 0.02525228f, 0.02506127f, 0.01714813f, 
    -0.00758271f, -0.02320194f, -0.02947967f, 0.02827984f, 0.00566331f, -0.00271003f, 0.01705842f, 0.00776638f, 
    0.01669081f, -0.02375346f, -0.01609934f, -0.01596337f, 0.01837439f, 0.01161985f, 0.00293728f, 0.01661499f, 
    0.01413805f, 0.00973942f, -0.03078882f, 0.00741386f, 0.01473203f, -0.00543038f, -0.03421879f, -0.04186068f, 
    0.02834659f, 0.02014978f, -0.01155261f, -0.00660916f, 0.02352529f, -0.01421253f, -0.01342432f, -0.03812805f, 
    0.01843103f, 0.00928073f, 0.01986511f, -0.04035693f, -0.03798964f, 0.02226458f, -0.00810738f, 0.01694552f, 
    -0.02221772f, 0.00855307f, 0.02678691f, 0.00455037f, 0.01465222f, -0.01695654f, -0.00773479f, -0.03971525f, 
    -0.00749570f, -0.02889441f, 0.02603573f, -0.02126878f, -0.02092889f, 0.00936652f, 0.00679607f, -0.03145232f, 
    -0.00022622f, -0.00376018f, -0.03734718f, -0.00837825f, 0.02107149f, -0.03999374f, -0.02341646f, -0.00930134f, 
    -0.00439081f, -0.03536059f, 0.00489679f, -0.02184894f, 0.02117471f, -0.02260086f, -0.00331318f, -0.02380704f, 
    -0.03823836f, 0.01045055f, -0.01348335f, 0.02246689f, -0.02788527f, -0.01640402f, -0.02614415f, -0.00453821f, 
    -0.01938604f, -0.00162227f, 0.00973758f, 0.02107961f, -0.04166418f, -0.03930877f, -0.00512925f, 0.00986143f, 
    -0.00350680f, -0.02358543f, 0.01826649f, -0.02347572f, -0.01579715f, -0.01502948f, 0.00435016f, -0.02645732f, 
    -0.01382617f, 0.02054779f, -0.01645491f, 0.02260390f, -0.04080278f, -0.02146788f, -0.01458036f, 0.01082525f, 
    -0.03524744f, -0.02913919f, 0.01357026f, 0.00436023f, -0.03321461f, -0.04119329f, 0.01870625f, 0.02668039f, 
    0.01674108f, 0.00514666f, -0.02725722f, 0.01675074f, -0.02662908f, -0.00003174f, -0.03396482f, -0.03558826f, 
    0.02212125f, -0.01997144f, -0.01577749f, 0.02683981f, 0.02064086f, -0.02376309f, -0.03940012f, -0.02897918f, 
    0.02186786f, 0.01505161f, -0.04146283f, -0.00612475f, 0.01413355f, -0.00133178f, 0.01443974f, 0.01522102f, 
    -0.00990752f, 0.00381110f, -0.01691373f, 0.02140370f, -0.03345775f, 0.01900492f, -0.00478474f, 0.01085301f, 
    0.01078872f, 0.00491034f, 0.01660061f, -0.00100198f, -0.00247588f, -0.03897921f, 0.00611595f, 0.01530033f, 
    -0.02713272f, -0.01998039f, 0.01186059f, -0.02257449f, 0.01902054f, -0.03176121f, -0.02498952f, -0.01016391f, 
    0.01141061f, -0.02870102f, -0.01720851f, 0.01083258f, -0.00061070f, 0.01217503f, 0.02851024f, -0.00395196f, 
    -0.02406993f, -0.01361271f, 0.00653695f, 0.02256482f, -0.01763331f, -0.03747403f, -0.01384488f, -0.01140105f, 
    0.01404740f, -0.00642603f, 0.02336805f, -0.03424851f, -0.03000697f, 0.02736634f, -0.03040417f, -0.00981475f, 
    0.00361155f, 0.00091399f, 0.00121587f, 0.02750813f, -0.01276941f, -0.01622658f, -0.03612849f, -0.00709160f, 
    -0.01149482f, -0.00950985f, -0.01928096f, -0.03133076f, -0.03169570f, -0.02083971f, -0.01048115f, -0.03518816f, 
    0.02135748f, 0.02907287f, 0.02227907f, 0.00911485f, -0.03670902f, 0.02104583f, -0.02715865f, 0.02341101f, 
    -0.03150679f, -0.02399540f, 0.00545819f, -0.00333984f, -0.00303078f, 0.02416450f, -0.04091236f, -0.03333493f, 
    0.00122221f, -0.00778808f, -0.01540921f, -0.03510807f, -0.01338422f, -0.01226958f, 0.02235759f, -0.01658853f, 
    -0.00436677f, -0.03677622f, -0.00975135f, 0.00115826f, 0.01270240f, 0.01927236f, -0.00124458f, -0.03536936f, 
    0.01805441f, -0.00140862f, -0.03831194f, 0.01179759f, 0.01870955f, -0.02347678f, 0.02640608f, 0.02823487f, 
    0.02473313f, -0.02585741f, -0.01650064f, 0.02212862f, -0.02517612f, -0.03323243f, 0.01341078f, 0.00146241f, 
    -0.00742484f, 0.02855950f, -0.00818610f, -0.01552910f, -0.04001601f, -0.00433944f, -0.00260811f, 0.01490708f, 
    0.00021668f, -0.00459623f, -0.01078964f, 0.01490675f, 0.00771758f, -0.02399736f, -0.00727256f, -0.00055941f, 
    0.01348028f, -0.04158457f, 0.01935654f, 0.00636885f, -0.03318436f, -0.00082349f, -0.01369002f, -0.04181777f, 
    0.01204824f, -0.00304658f, 0.01837514f, -0.03254586f, -0.03574130f, -0.04051114f, 0.00004859f, -0.02900864f, 
    -0.02748794f, -0.03811471f, -0.03998899f, 0.02212614f, -0.03049724f, 0.00966349f, -0.01632247f, -0.03125276f, 
    0.01365494f, -0.02490192f, -0.01883410f, 0.01771455f, -0.01166554f, 0.02695970f, -0.03503656f, -0.02324104f, 
    -0.01484285f, -0.03119811f, 0.01483501f, 0.01470831f, -0.00442014f, 0.02757193f, -0.01687236f, -0.03779979f, 
    -0.00640099f, -0.00551042f, 0.02270717f, 0.02303339f, -0.03095033f, -0.04281569f, 0.00166028f, -0.00821100f, 
    -0.02849444f, -0.00453202f, 0.02672496f, -0.01427280f, -0.03004754f, 0.01658976f, 0.01281518f, -0.03080113f, 
    -0.03285429f, -0.03044143f, -0.03020841f, 0.00529970f, 0.01186454f, 0.01968319f, -0.03867913f, -0.02927498f, 
    0.02370456f, 0.01789467f, 0.02997560f, -0.01448432f, -0.01022306f, 0.00201828f, 0.00560945f, -0.04150066f, 
    -0.02296615f, -0.02716959f, -0.02381002f, -0.01126415f, -0.02333049f, -0.04102096f, -0.01936968f, -0.02909592f, 
    -0.00792503f, 0.00991304f, -0.03057619f, -0.00710961f, -0.00639107f, -0.03490542f, 0.00232738f, -0.01494706f, 
    -0.03755220f, 0.02314316f, 0.00127484f, 0.00759624f, -0.02747121f, -0.01098178f, 0.00677443f, 0.00511002f, 
    0.02427237f, 0.02852439f, 0.02942559f, -0.01830905f, -0.00280121f, 0.00092737f, 0.01328244f, 0.00589619f, 
    0.02907738f, 0.01533112f, 0.02044717f, -0.00996347f, 0.00449754f, -0.01693550f, -0.01114627f, 0.02741916f, 
    -0.01241644f, -0.01001391f, 0.01209877f, 0.02660821f, 0.00268353f, -0.01945776f, -0.03264344f, 0.02739766f, 
    0.02411741f, 0.01092044f, 0.01169130f, -0.02759408f, -0.02534999f, -0.02215839f, -0.00888055f, -0.03741527f, 
    0.02309152f, 0.02580708f, -0.01994214f, 0.00127827f, -0.02559343f, -0.03091022f, -0.03799212f, -0.03161053f, 
    0.01593239f, -0.03805721f, 0.00474737f, 0.01260566f, -0.00700434f, -0.00458338f, -0.01914715f, -0.01923699f, 
    -0.00470735f, -0.03313392f, -0.04102166f, -0.00871332f, -0.00397159f, -0.01933786f, 0.01485348f, -0.03027925f, 
    -0.04202681f, -0.01740381f, 0.00298247f, 0.02314234f, -0.00510420f, 0.02097468f, -0.03623915f, -0.02003074f, 
    -0.01041678f, 0.00182060f, 0.01880579f, 0.00115469f, 0.01286451f, -0.01479653f, -0.00776528f, -0.02589107f, 
    -0.00711357f, -0.03932406f, 0.00826110f, 0.02594457f, -0.03893909f, -0.02214022f, -0.01271194f, -0.01562985f, 
    -0.02006605f, 0.00446858f, 0.00174507f, 0.00120987f, -0.00222081f, -0.04249172f, -0.00413035f, -0.03089196f, 
    -0.02316977f, -0.02759936f, -0.02573858f, -0.02720253f, -0.03178417f, -0.00772983f, 0.00851666f, 0.01119073f, 
    -0.03921847f, 0.00964626f, -0.03962777f, -0.00351553f, -0.00619993f, 0.00815705f, -0.02049831f, -0.02624591f, 
    0.00511598f, -0.00883771f, -0.03888182f, 0.02834120f, -0.02001845f, -0.03216029f, 0.00606739f, 0.00270253f, 
    0.02109865f, 0.01557719f, -0.01343918f, 0.01222626f, -0.00896553f, 0.02394182f, -0.01179864f, 0.01048837f, 
    0.01345241f, -0.02888906f, -0.01368620f, -0.03604352f, -0.02595112f, 0.00097708f, 0.00497948f, -0.03579017f, 
    -0.03918403f, -0.00711083f, 0.02877774f, 0.00616284f, -0.01688891f, 0.00028670f, 0.01085176f, 0.02282491f, 
    0.01366332f, -0.04113693f, 0.01888435f, -0.03208786f, -0.02276482f, -0.02873632f, -0.02828729f, -0.04057841f, 
    0.01165755f, 0.00005591f, -0.01001845f, -0.03418786f, -0.00375878f, -0.03402983f, 0.02524506f, 0.02507605f, 
    -0.02366097f, -0.03067413f, -0.03773302f, -0.00274475f, -0.00293646f, 0.02246138f, -0.01492356f, -0.00210206f, 
    0.02780716f, 0.01091586f, -0.01373022f, -0.00940194f, 0.00079463f, 0.00107393f, -0.02884057f, -0.00501202f, 
    -0.02461045f, 0.01795182f, 0.00062236f, 0.00799871f, -0.04052062f, -0.02405662f, -0.02639842f, -0.01055602f, 
    -0.02649505f, -0.04025149f, 0.00661267f, -0.03995172f, -0.00224887f, -0.02532747f, -0.00443597f, -0.00788491f, 
    0.00629458f, -0.02140632f, -0.00189503f, -0.03140768f, -0.03035564f, -0.02044288f, -0.03458729f, -0.01311518f, 
    -0.03661394f, -0.03159362f, 0.02293402f, 0.02109943f, 0.01108282f, 0.01978863f, 0.02351580f, -0.02904841f, 
    -0.03308979f, 0.00694019f, -0.02682314f, 0.00226539f, 0.01002548f, 0.00595755f, -0.01410025f, 0.01201984f, 
    -0.01120840f, 0.01232084f, 0.00692721f, 0.01343571f, -0.01702146f, 0.00771191f, -0.03551796f, -0.03746775f, 
    0.01510728f, -0.00642813f, 0.01141430f, -0.01369205f, -0.01626315f, -0.02463640f, 0.02196493f, -0.04506999f, 
    0.01708076f, -0.01951734f, -0.00714244f, -0.02262643f, -0.02190266f, -0.01603302f, -0.03169580f, -0.00059657f, 
    0.01588260f, 0.00638497f, -0.00460812f, -0.01952180f, 0.00664310f, -0.02343215f, 0.02442791f, 0.02801201f, 
    -0.03462406f, 0.03157413f, -0.02568113f, 0.03248921f, 0.02282961f, -0.02969307f, -0.02769586f, 0.03223025f, 
    -0.03002142f, 0.00670770f, -0.03452228f, 0.02582685f, -0.01481334f, 0.01472495f, 0.00138807f, -0.02350385f, 
    -0.01796809f, -0.03535614f, -0.02951531f, -0.02993735f, 0.00846505f, 0.01391870f, 0.00068852f, -0.02288144f, 
    0.00301011f, -0.00621831f, -0.04239822f, -0.00844042f, 0.01740827f, 0.01844235f, -0.00363144f, -0.01744268f, 
    0.00259570f, -0.00021436f, -0.03698015f, 0.02595734f, -0.00708642f, 0.01967219f, 0.00295408f, -0.03666317f, 
    -0.03848398f, -0.02911529f, -0.01220356f, -0.03854308f, 0.02339262f, -0.00251633f, 0.01424529f, -0.01786723f, 
    0.00158664f, -0.03614831f, -0.02220169f, -0.01820325f, -0.01866483f, -0.03243814f, 0.00834044f, -0.01018283f, 
    -0.00765761f, -0.02407649f, -0.01124116f, 0.01647728f, 0.01756393f, 0.01798746f, 0.02200183f, -0.03079668f, 
    0.00337350f, -0.00553883f, -0.00681207f, 0.01810786f, -0.02868245f, 0.01944597f, 0.02157977f, -0.00258671f, 
    -0.00768560f, -0.02377367f, 0.01646785f, 0.00786238f, -0.02350927f, -0.02720396f, -0.02829711f, 0.02725543f, 
    -0.00382144f, -0.00588758f, 0.01108894f, 0.03031442f, -0.02001386f, -0.00694710f, -0.03579656f, -0.00262758f, 
    0.00933787f, 0.04081372f, -0.03831995f, -0.02787864f, -0.03017596f, -0.01509212f, -0.03709960f, 0.01971996f, 
    -0.01034986f, 0.01851911f, 0.00632639f, 0.00026693f, 0.01987645f, -0.03711313f, 0.02485893f, -0.04097598f, 
    -0.02072919f, -0.00316923f, -0.04143434f, -0.02209790f, -0.00429069f, -0.01400402f, -0.02045644f, -0.00212158f, 
    0.01851897f, 0.00382606f, 0.00258020f, 0.00284743f, 0.00297860f, -0.02202803f, -0.03591446f, 0.00753838f, 
    -0.03474150f, 0.01333454f, -0.01779296f, -0.03194346f, 0.03556424f, -0.01347790f, -0.01769661f, -0.00194579f, 
    -0.03814283f, 0.01600144f, -0.00899396f, 0.00881932f, 0.00862303f, -0.00444757f, -0.02470089f, -0.00052066f, 
    -0.00503377f, 0.03595958f, -0.03180524f, -0.01249448f, 0.03467182f, -0.02609044f, -0.03205991f, -0.03399830f, 
    0.01884002f, -0.01068034f, 0.02383578f, -0.03989186f, 0.00112267f, -0.01154709f, -0.04063897f, 0.00811266f, 
    0.02281340f, -0.01437370f, -0.01757761f, -0.00478654f, 0.03021258f, -0.02855997f, -0.03697614f, -0.02760978f, 
    0.02491112f, 0.01504375f, -0.02081341f, -0.01204378f, 0.01240116f, -0.04195762f, -0.03260204f, -0.00248128f, 
    0.01618838f, 0.01914581f, -0.02090995f, -0.00146480f, -0.03319464f, 0.00076006f, -0.03038003f, -0.01704126f, 
    0.01434564f, -0.01314365f, -0.01858932f, -0.02259193f, -0.02716251f, -0.01875036f, -0.01246275f, 0.00911590f, 
    -0.00280430f, 0.02338804f, -0.01927819f, -0.03392615f, -0.00788597f, 0.02772374f, -0.00997501f, 0.01863545f, 
    0.01600895f, -0.00597654f, 0.00260112f, -0.01457324f, -0.01672967f, 0.02500277f, -0.01527498f, 0.00057727f, 
    -0.00091316f, 0.02300928f, -0.00931950f, -0.00052606f, -0.02080997f, 0.00076424f, -0.01510570f, -0.00694725f, 
    -0.01327224f, -0.02224101f, 0.03322492f, -0.02860297f, -0.01313711f, -0.01581364f, -0.03142745f, -0.01517696f, 
    -0.02432460f, -0.01178287f, -0.00034429f, -0.00819916f, 0.00868228f, -0.02750134f, -0.03948625f, -0.02646302f, 
    -0.00685872f, -0.01573816f, 0.00414484f, 0.00017947f, -0.01065763f, -0.03279239f, 0.02971232f, 0.00750211f, 
    0.00715923f, 0.01447640f, -0.01407059f, 0.00708152f, -0.00589823f, -0.00658805f, -0.02680169f, 0.00597537f, 
    -0.03227502f, 0.00469710f, -0.01760584f, 0.00987029f, 0.02291227f, -0.03504499f, 0.02241628f, -0.03404128f, 
    -0.03639012f, -0.03800163f, 0.02139428f, -0.03189524f, 0.01460952f, -0.02270952f, 0.01646770f, 0.01459763f, 
    -0.03416162f, -0.00961528f, 0.00140810f, -0.00040723f, -0.01595021f, -0.03814739f, -0.02126427f, 0.02150083f, 
    0.00994524f, -0.00379682f, -0.01551089f, -0.02420805f, 0.01122820f, -0.02713525f, 0.01936628f, 0.01807491f, 
    -0.02238417f, -0.02166728f, -0.02847283f, -0.03475253f, 0.00453601f, 0.01701813f, -0.01471326f, -0.03146010f, 
    0.00388502f, -0.02796271f, -0.02152315f, -0.00511930f, 0.02344863f, 0.02080644f, -0.00889981f, 0.00573138f, 
    -0.03707105f, -0.00145114f, 0.00622782f, 0.02106833f, -0.01325621f, 0.03208738f, -0.01380787f, 0.02290021f, 
    0.02490308f, -0.02584510f, -0.01670409f, 0.02571908f, -0.01118093f, 0.01449345f, -0.03139039f, 0.03316693f, 
    -0.00337044f, -0.03758681f, -0.01375944f, 0.02153600f, 0.02729118f, -0.01493872f, 0.02279464f, 0.00084227f, 
    -0.00284848f, 0.01752437f, 0.00379980f, -0.01615387f, -0.01326851f, -0.02986682f, -0.00099754f, -0.03610192f, 
    -0.02059325f, -0.02355542f, 0.01161091f, 0.02363320f, -0.01510692f, -0.00811693f, -0.03155418f, 0.00394756f, 
    -0.00242745f, 0.00535469f, -0.01677139f, 0.00138609f, -0.00646922f, 0.02944170f, 0.01738655f, 0.00540990f, 
    -0.00397824f, -0.00951470f, 0.03109401f, -0.03525379f, 0.01220642f, -0.00473799f, 0.00160081f, 0.01546893f, 
    -0.00409716f, -0.00873276f, -0.03196093f, 0.03271879f, -0.01151207f, -0.03834431f, -0.01515155f, 0.01347783f, 
    0.01761389f, 0.02048112f, -0.03657785f, 0.02071906f, 0.02190698f, -0.01815024f, 0.03219611f, -0.01318553f, 
    -0.02439095f, 0.02683852f, 0.02413204f, 0.03856569f, 0.00192436f, -0.01474539f, -0.00138202f, -0.02840810f, 
    -0.00696297f, 0.00067301f, -0.01586434f, -0.01226549f, -0.03890716f, -0.03019646f, -0.03651799f, -0.01197398f, 
    0.02599768f, -0.02707135f, -0.01666012f, -0.03671695f, -0.00332379f, -0.00252086f, -0.01499519f, 0.03130186f, 
    -0.01466496f, -0.01911855f, 0.00854376f, 0.01501977f, -0.00678371f, -0.01742668f, 0.01402903f, 0.02459846f, 
    -0.01455584f, 0.01013266f, 0.03515379f, -0.03382357f, -0.01327379f, 0.02523053f, 0.00231342f, 0.02613069f, 
    -0.00756740f, 0.00119383f, -0.03801217f, -0.00388731f, -0.01217996f, 0.00875063f, 0.02709263f, 0.00621311f, 
    0.02989791f, -0.03140474f, 0.01188408f, 0.01210015f, -0.00536988f, 0.01082686f, -0.02415254f, -0.01727163f, 
    0.02946929f, -0.01169065f, 0.00429354f, -0.01664955f, 0.01211825f, 0.02139837f, 0.02199941f, -0.00015006f, 
    0.01661021f, -0.03593907f, -0.02797792f, 0.02200582f, -0.03562846f, 0.00998242f, 0.03396057f, 0.00961475f, 
    0.02941791f, -0.00150058f, -0.01747897f, 0.02133395f, -0.01848532f, -0.02399427f, 0.01635599f, 0.01114740f, 
    -0.00041973f, 0.01558809f, 0.00945748f, -0.03025970f, -0.03666386f, -0.03699755f, -0.04117689f, 0.02545819f, 
    0.00898285f, -0.02320045f, 0.00900717f, 0.00262736f, 0.00191648f, -0.02434579f, -0.03733938f, -0.02041557f, 
    -0.03611194f, -0.00937480f, -0.02444229f, -0.02338882f, -0.01923414f, -0.03599697f, 0.02362392f, 0.00032617f, 
    -0.04563734f, 0.02091045f, 0.01342357f, -0.00771506f, -0.01650001f, -0.02816959f, 0.00348483f, -0.01656559f, 
    -0.01184417f, 0.02253197f, -0.01894500f, 0.00526399f, 0.01638905f, 0.00323118f, 0.00360955f, -0.01181875f, 
    0.00477572f, 0.00762775f, -0.03931373f, 0.02300187f, -0.01178733f, -0.00961000f, 0.01273352f, 0.01489987f, 
    -0.00135168f, 0.02480578f, -0.03575451f, 0.02409684f, -0.00605672f, -0.04280822f, 0.01871099f, -0.01397748f, 
    0.00477214f, -0.03785123f, 0.03544191f, -0.00021704f, -0.01467450f, 0.01799779f, 0.01898421f, 0.02358666f, 
    -0.03823373f, -0.00679433f, -0.02135438f, 0.01473741f, -0.02671446f, 0.00830053f, -0.00889141f, -0.00044131f, 
    0.02599343f, 0.03438888f, -0.02822342f, -0.04071398f, -0.00115271f, -0.00174352f, 0.00351982f, 0.00041620f, 
    -0.03535037f, -0.01413294f, -0.00902242f, -0.00717328f, -0.03015906f, -0.04031030f, 0.01682997f, -0.02383770f, 
    -0.01180603f, 0.01409120f, -0.02568296f, 0.00578577f, -0.01186718f, -0.00445571f, 0.02204489f, -0.02814694f, 
    -0.01160407f, 0.00903298f, 0.02031913f, 0.03209555f, -0.00819626f, 0.03181430f, 0.00590502f, -0.02780553f, 
    0.00584848f, -0.01568247f, 0.00992349f, 0.02375850f, 0.02317180f, -0.01391930f, 0.02314091f, -0.03269450f, 
    0.01359404f, -0.02497203f, 0.00795895f, 0.01179824f, -0.03733777f, -0.01831461f, 0.02661434f, 0.02613459f, 
    -0.00935449f, -0.01341061f, -0.01113572f, 0.00995389f, 0.02599724f, -0.02407084f, -0.01550795f, 0.00687810f, 
    -0.00732874f, 0.02025577f, 0.02860555f, 0.00575898f, 0.00102462f, -0.01316078f, -0.03623536f, 0.01149809f, 
    -0.03796918f, -0.03648723f, -0.00516872f, 0.03113684f, -0.02703515f, 0.00890976f, -0.01930090f, -0.00078456f, 
    -0.01251226f, -0.03747635f, -0.02704768f, 0.00550847f, -0.03217359f, -0.02228777f, -0.04169512f, 0.01055956f, 
    -0.03032035f, -0.01266613f, -0.01386808f, -0.02924916f, -0.01562338f, -0.01826399f, -0.01453821f, -0.02423118f, 
    -0.00408492f, -0.00007051f, 0.00668099f, 0.01618646f, 0.00284750f, -0.02551045f, 0.00426844f, 0.01480471f, 
    -0.01598976f, -0.02097825f, 0.03087195f, 0.01354557f, 0.02044498f, -0.00022686f, 0.03009661f, -0.00560917f, 
    -0.00817824f, -0.02843323f, -0.03696757f, -0.00738026f, -0.03779709f, 0.00149089f, -0.00348014f, 0.01843120f, 
    -0.00676889f, -0.02203579f, -0.04152963f, 0.00623364f, 0.02611732f, -0.03400468f, -0.01829274f, 0.01928228f, 
    -0.01617330f, -0.02016486f, 0.03307978f, -0.02397623f, -0.04109586f, -0.04449501f, 0.01305343f, -0.03050106f, 
    -0.02911103f, -0.01544077f, -0.02829217f, -0.02766784f, -0.01203961f, 0.01145664f, 0.02927897f, -0.01433159f, 
    0.02408725f, -0.03600178f, -0.01884340f, 0.00879833f, 0.02176143f, -0.02925085f, 0.02426278f, -0.00169605f, 
    -0.03140549f, -0.01040671f, 0.01870684f, -0.00014912f, -0.02473143f, -0.04127816f, 0.01819811f, -0.04388646f, 
    0.02501635f, -0.01130623f, 0.00643563f, -0.02914652f, -0.00624430f, -0.00180938f, 0.02603635f, 0.01662452f, 
    0.03251281f, -0.03450240f, 0.02221167f, -0.01411335f, 0.01815582f, -0.01369548f, -0.00045770f, -0.03302415f, 
    -0.02494141f, 0.01454973f, 0.00417505f, 0.00354934f, 0.03138575f, 0.00214241f, 0.00385333f, 0.00417119f, 
    -0.02598375f, -0.03700221f, -0.04139936f, -0.00611950f, 0.02278862f, -0.03815752f, -0.00641361f, -0.00961856f, 
    0.01789239f, -0.02107519f, -0.00151331f, -0.01183920f, -0.01273038f, -0.02915082f, -0.04028329f, -0.03390396f, 
    -0.01821926f, 0.00857685f, 0.00240860f, 0.00270244f, 0.01063851f, -0.00297966f, -0.01513692f, 0.00665908f, 
    -0.00442431f, 0.00077024f, -0.01522311f, 0.01432805f, -0.01847431f, -0.03576297f, 0.02125498f, 0.02020884f, 
    -0.02610384f, 0.00198101f, -0.00950153f, -0.00754916f, 0.01869362f, 0.01890488f, 0.01932320f, 0.02185790f, 
    0.01254140f, -0.01032316f, 0.01865416f, -0.03572313f, -0.04187943f, -0.01373156f, -0.01661066f, 0.02385170f, 
    0.00754596f, -0.03699743f, -0.03131389f, -0.00642637f, -0.01205951f, -0.00022136f, 0.02353806f, -0.01350338f, 
    0.00837332f, -0.02210550f, -0.03811768f, 0.02120440f, 0.02283765f, -0.04158258f, -0.03674360f, -0.02430246f, 
    0.01639047f, 0.02926057f, -0.02364265f, 0.01169588f, 0.01580502f, -0.00799086f, -0.00145589f, -0.03161235f, 
    0.01647042f, 0.00257248f, 0.02919012f, 0.01884531f, -0.01486122f, 0.02754762f, -0.03930751f, 0.02169564f, 
    -0.00756475f, -0.02224976f, -0.02281598f, -0.02119526f, -0.03622684f, -0.00132046f, -0.02037889f, -0.01163734f, 
    0.02802734f, 0.00747614f, -0.00870616f, 0.02712052f, -0.01208581f, -0.00659233f, -0.00193696f, 0.01071586f, 
    -0.02581374f, 0.00018330f, -0.03027381f, -0.00566823f, 0.02793055f, -0.02968753f, -0.02040783f, -0.01838181f, 
    -0.03714117f, -0.02920215f, -0.02534932f, -0.02417838f, -0.03975936f, 0.01766869f, 0.01934271f, 0.02862224f, 
    -0.02845118f, -0.03367386f, 0.01771700f, 0.00382865f, -0.01345368f, -0.02064476f, -0.01857691f, -0.03950023f, 
    -0.03106389f, -0.00493357f, -0.04066414f, -0.02361403f, 0.02480225f, -0.01986855f, 0.02753734f, -0.03031599f, 
    -0.01002455f, 0.01613276f, -0.02394605f, 0.02875962f, -0.01287519f, 0.02586270f, 0.00615440f, -0.03500905f, 
    0.00018457f, -0.02590062f, 0.00119529f, -0.02545123f, -0.01602867f, 0.00115472f, 0.00342096f, -0.00023901f, 
    0.00449629f, 0.00117435f, -0.03204126f, 0.02024000f, -0.02704646f, -0.00806484f, -0.00226599f, -0.01169799f, 
    -0.00080340f, -0.02482909f, 0.00896807f, 0.00554968f, -0.03570592f, -0.03609137f, -0.02546417f, -0.03198065f, 
    -0.02720101f, -0.00790170f, -0.01872084f, 0.01373260f, -0.01365793f, 0.00350425f, -0.00852142f, 0.02708707f, 
    0.02578132f, -0.00621585f, -0.01393329f, 0.00576963f, 0.00059607f, -0.00639902f, 0.02249819f, -0.00197220f, 
    0.01956979f, 0.02426818f, 0.01038924f, -0.00913456f, 0.01185567f, 0.00251072f, 0.00423133f, 0.01040628f, 
    0.02852471f, 0.01732648f, 0.02608507f, -0.01761338f, -0.03786085f, -0.00920236f, 0.02307225f, -0.01788630f, 
    0.01656313f, -0.01802759f, -0.01634073f, -0.00666179f, 0.02951681f, 0.01373396f, -0.00147144f, 0.00967686f, 
    -0.00354667f, 0.02616603f, -0.00631800f, -0.01214726f, -0.00846749f, -0.03143166f, -0.01933848f, 0.00829415f, 
    0.00377974f, 0.02770413f, -0.02955868f, 0.00767753f, 0.00710522f, 0.02991706f, 0.01209790f, 0.00370574f, 
    -0.02339801f, -0.00202909f, -0.00574389f, 0.01409278f, 0.01453168f, 0.00175557f, -0.03663757f, -0.01530079f, 
    -0.01735601f, -0.02083845f, -0.03740851f, -0.02550451f, -0.01978898f, -0.02255506f, 0.01549675f, -0.02334408f, 
    -0.01849348f, -0.01585040f, -0.00603321f, -0.01895847f, -0.01270313f, -0.00887153f, 0.02158282f, 0.01411873f, 
    -0.02196706f, 0.02314514f, -0.02441015f, 0.01324721f, -0.02194222f, -0.00406728f, 0.01684894f, 0.01740004f, 
    0.01499463f, -0.02677271f, -0.03143055f, -0.01010839f, 0.01656466f, 0.02366659f, -0.02171671f, 0.00812614f, 
    -0.03238657f, -0.00633226f, -0.01411009f, -0.02522533f, 0.01896094f, 0.02622933f, 0.00882283f, 0.01397319f, 
    0.00410677f, -0.03247679f, 0.00291865f, -0.03923246f, -0.02505230f, 0.01289293f, -0.00017374f, 0.00694880f, 
    -0.01879525f, 0.02806010f, 0.01990661f, -0.02829405f, -0.01904890f, 0.00324973f, -0.00448627f, -0.04113277f, 
    0.00974059f, 0.01910069f, 0.02073923f, -0.02284253f, -0.02810862f, -0.02512977f, -0.00139414f, -0.02395219f, 
    0.01295271f, 0.02255425f, -0.01591660f, -0.01052374f, -0.03682481f, 0.01475375f, 0.01625212f, -0.00467824f, 
    -0.00725555f, -0.03608774f, 0.00147637f, -0.01579704f, -0.03649738f, -0.04064266f, 0.00903204f, 0.01584288f, 
    -0.01598941f, 0.00813752f, -0.00070751f, 0.00482990f, -0.02824746f, 0.02852211f, -0.01171264f, 0.01854542f, 
    0.01154900f, -0.01231356f, 0.01631777f, 0.01867775f, -0.01701739f, -0.00536380f, 0.02786787f, -0.03696275f, 
    0.01832921f, -0.03238762f, -0.00171652f, 0.01348354f, 0.00981538f, -0.01808136f, -0.03077653f, -0.03558755f, 
    -0.00588030f, -0.02035834f, -0.01851766f, -0.00897398f, 0.00146665f, -0.03850836f, -0.01720532f, 0.00672352f, 
    0.02099128f, 0.01395586f, -0.01807646f, 0.01556259f, -0.02594621f, 0.00349446f, 0.02845599f, 0.01551915f, 
    0.00981717f, -0.00784351f, 0.02869229f, -0.00332091f, -0.03203470f, 0.02313456f, 0.02443648f, -0.00547957f, 
    0.01087897f, -0.03785979f, -0.03749855f, -0.02247050f, -0.00815999f, -0.03704058f, -0.00220180f, -0.02145361f, 
    -0.00312048f, 0.02965612f, 0.00140994f, 0.00357995f, -0.03306589f, 0.02622197f, 0.00897425f, 0.01771227f, 
    0.01417080f, 0.01029510f, -0.01743476f, -0.02768799f, 0.02192454f, -0.01945724f, -0.02243187f, -0.00182215f, 
    -0.00797334f, -0.01611326f, 0.01327397f, 0.00091483f, 0.02175964f, 0.02194212f, -0.00531177f, -0.00682742f, 
    -0.00966771f, -0.01466228f, -0.03580249f, 0.00708878f, 0.02410092f, -0.01520987f, -0.00534008f, -0.04006179f, 
    -0.01927290f, 0.02184426f, 0.02279927f, -0.02295302f, -0.00270933f, -0.02142232f, 0.00276508f, -0.00510851f, 
    -0.03454113f, 0.00569706f, -0.02343516f, -0.01863720f, -0.00410767f, 0.02296677f, -0.01004871f, -0.02122451f, 
    0.00658721f, 0.00232450f, -0.00592285f, -0.02792269f, -0.03221250f, -0.00961248f, 0.02167295f, 0.02095195f, 
    -0.01013926f, -0.00064489f, -0.03055778f, -0.01021709f, 0.01745379f, 0.00477687f, -0.01756549f, 0.02696569f, 
    0.00866393f, -0.02556320f, 0.01946227f, 0.02381210f, -0.02038531f, 0.00477245f, -0.01673696f, -0.00508158f, 
    -0.04158764f, 0.01326493f, -0.03026252f, -0.00106639f, -0.01796890f, 0.02590727f, -0.03228566f, -0.01579047f, 
    0.02091211f, -0.04180031f, 0.02450508f, -0.03806945f, -0.03433052f, 0.02788855f, -0.02588243f, -0.01996766f, 
    0.00575298f, 0.01468975f, 0.01688448f, 0.01246414f, -0.03868169f, -0.00468146f, -0.02686331f, 0.02450132f, 
    0.01061580f, -0.01796876f, 0.02554668f, -0.00055260f, 0.00552793f, -0.01329244f, 0.02550936f, -0.01323562f, 
    -0.02496087f, 0.00695268f, -0.02610972f, 0.00544366f, -0.00944573f, -0.03299481f, -0.01743525f, -0.01973553f, 
    -0.00537681f, -0.04115352f, 0.00595781f, 0.02846926f, 0.00148160f, -0.03499041f, -0.00741465f, -0.03331167f, 
    0.00502116f, -0.03467721f, 0.02205827f, 0.03545298f, -0.03292157f, -0.03900546f, -0.00078418f, -0.00826712f, 
    -0.03601393f, -0.00642453f, -0.03445611f, -0.00855764f, -0.01130619f, 0.02596807f, -0.04139265f, 0.01790482f, 
    0.00728638f, 0.00736360f, -0.00589396f, 0.02352469f, -0.01051955f, -0.00157762f, -0.01617458f, 0.01987934f, 
    -0.03028336f, -0.02732176f, -0.00826101f, 0.02118185f, -0.00303268f, -0.01373355f, -0.01479194f, 0.00033561f, 
    0.01952674f, -0.01980746f, -0.00598412f, -0.01958817f, -0.02820262f, 0.01525960f, -0.01854596f, -0.04097918f, 
    -0.02956793f, -0.00261586f, 0.02692085f, -0.02298926f, -0.03385396f, -0.02779690f, -0.02871978f, -0.00446496f, 
    -0.00870755f, 0.02278526f, 0.01507181f, -0.03815648f, 0.00505592f, 0.00656213f, 0.02628385f, -0.02435177f, 
    -0.04151580f, 0.01629228f, -0.02148521f, 0.00329605f, -0.03123335f, -0.02339736f, 0.01867797f, 0.02029112f, 
    0.02991561f, -0.02913145f, 0.01002034f, 0.00644011f, 0.00745743f, 0.00505027f, 0.02937801f, -0.01209736f, 
    -0.03242204f, -0.03864721f, 0.01211081f, 0.02705342f, 0.00706860f, -0.02008084f, -0.03392941f, 0.01440757f, 
    -0.00816209f, 0.00286848f, -0.01293144f, -0.03033749f, 0.02072558f, 0.02182633f, 0.01811811f, 0.00994454f, 
    -0.01775431f, 0.01151512f, 0.01482850f, -0.01880392f, -0.02657002f, 0.02623075f, -0.02408968f, 0.01558816f, 
    -0.00058347f, 0.01240896f, -0.00311507f, -0.03362107f, 0.02979034f, 0.02066532f, -0.01485468f, 0.01355904f, 
    -0.01779799f, 0.00937014f, 0.01398704f, -0.00060935f, -0.00120318f, -0.03556972f, -0.00214223f, -0.02316065f, 
    -0.00830134f, -0.01529341f, -0.03614294f, -0.03722026f, -0.02384686f, 0.01739964f, -0.01103650f, -0.02903653f, 
    -0.04044716f, -0.02143339f, -0.00976358f, -0.03470274f, -0.03899859f, -0.01791177f, -0.01250854f, -0.00647433f, 
    -0.01380812f, -0.00925035f, 0.00368578f, 0.00285658f, 0.02969641f, -0.01372675f, -0.03264208f, 0.00310876f, 
    -0.03937736f, 0.01592519f, -0.02967650f, 0.02286329f, 0.00786752f, -0.01671392f, -0.01126665f, -0.00199962f, 
    0.01462009f, -0.00124073f, -0.02834088f, 0.01864577f, -0.00625211f, 0.02560506f, 0.00842264f, 0.02332038f, 
    -0.02964919f, 0.02446429f, 0.02642352f, -0.01638910f, -0.02231310f, 0.02682097f, -0.01419540f, -0.02931514f, 
    -0.03034209f, 0.00634213f, -0.03955914f, 0.01312026f, -0.03747116f, -0.03624753f, -0.02899211f, -0.02693200f, 
    0.00826305f, 0.01764893f, -0.02627324f, -0.02371644f, -0.00789151f, -0.01900866f, 0.01380474f, -0.03951756f, 
    0.02935036f, -0.00235331f, 0.00832600f, -0.02467554f, 0.02319473f, -0.00668489f, 0.00086735f, 0.02266878f, 
    -0.00554539f, 0.01226598f, -0.01357797f, 0.01034661f, -0.01207851f, -0.00274975f, 0.00654506f, -0.03469666f, 
    0.00085641f, -0.01324027f, -0.03204763f, 0.03733799f, -0.01190612f, -0.00966468f, -0.00388160f, -0.03690493f, 
    0.00061802f, 0.02308030f, -0.00233368f, 0.03228204f, -0.01929100f, -0.01226609f, 0.02647468f, -0.03026928f, 
    -0.03389134f, -0.03177378f, 0.01277311f, -0.00953538f, -0.03734812f, 0.00560063f, 0.01647412f, -0.03324547f, 
    0.02371460f, 0.00024886f, -0.03515073f, -0.03927561f, -0.00942603f, -0.02268492f, -0.02521673f, 0.02042543f, 
    0.00092456f, 0.01334555f, 0.01377335f, 0.02628539f, 0.00529460f, 0.01374113f, 0.00045784f, -0.02237844f, 
    -0.02695354f, -0.01734170f, -0.02513695f, -0.00038595f, 0.01460142f, -0.00993788f, -0.03129819f, -0.02648753f, 
    0.00738460f, 0.02730866f, -0.01973485f, -0.00565378f, -0.02840546f, -0.02041928f, -0.03611378f, -0.00829323f, 
    -0.02272324f, -0.03231302f, 0.02579653f, -0.04174414f, 0.00724232f, -0.03710090f, 0.02506789f, -0.01659917f, 
    0.01237826f, 0.02630598f, -0.00250243f, 0.01846492f, 0.02905854f, -0.02547322f, 0.02284219f, -0.03600345f, 
    -0.02775719f, 0.00085205f, 0.00094399f, -0.00140486f, 0.01077292f, -0.00846671f, -0.00715335f, -0.00093705f, 
    0.00621960f, -0.03919240f, -0.03556809f, -0.01701901f, -0.04125510f, -0.00250241f, -0.03771536f, 0.01216360f, 
    0.00381841f, -0.03997235f, -0.03337854f, 0.01698500f, -0.01583832f, -0.04008030f, -0.02983601f, -0.01791139f, 
    0.00187582f, 0.01404885f, 0.02227831f, 0.01142114f, -0.00314685f, -0.03017499f, -0.02064898f, -0.03038861f, 
    -0.02615913f, 0.01566564f, -0.00722445f, -0.00300517f, 0.02419390f, 0.02179959f, 0.02448323f, -0.00333236f, 
    -0.00634083f, -0.00628320f, 0.02543213f, 0.02666415f, 0.02176283f, 0.02568896f, -0.02300013f, 0.02336480f, 
    0.13476366f, 0.05551196f, -0.00177566f, -0.05713418f, 0.04171798f, 0.20252998f, 0.12241697f, 0.01796573f, 
    0.07198749f, 0.08437191f, -0.16965003f, -0.10135018f, -0.04524332f, 0.12622254f, 0.27562726f, 0.16298407f, 
    0.00476773f, -0.05889037f, -0.04154193f, 0.03738414f, 0.11604849f, 0.08578726f, 0.10315353f, -0.05828640f, 
    0.11608608f, 0.00737191f, 0.10962814f, 0.11223412f, -0.00386750f, 0.03915440f, -0.02954619f, 0.17107823f, 
    0.07607559f, 0.02578012f, 0.12993355f, -0.02789427f, 0.16666305f, -0.07064240f, 0.08030974f, 0.06607506f, 
    -0.02194868f, -0.04213697f, 0.01891238f, -0.00178332f, -0.04328889f, -0.05349821f, 0.22673193f, 0.22561251f, 
    -0.36611074f, -0.08794915f, -0.17372553f, -0.25881338f, 0.13321550f, -0.01014671f, 0.07809808f, 0.02899220f, 
    0.00455170f, 0.08600641f, -0.12104472f, 0.06913602f, -0.28507119f, 0.13831025f, 0.15117101f, -0.03928563f, 
    0.01744040f, -0.03960444f, 0.06701252f, -0.03014681f, -0.00752752f, 0.09455717f, -0.07509368f, 0.03824648f, 
    -0.13008644f, 0.17307849f, 0.18453489f, 0.09877709f, 0.01934585f, -0.01637276f, 0.09284472f, -0.15607037f, 
    0.11791600f, 0.03032195f, 0.11887456f, -0.12979113f, -0.03849354f, -0.00889840f, -0.13931334f, 0.07533062f, 
    0.06628300f, 0.00745865f, 0.07666823f, -0.02142629f, 0.03440067f, -0.01885322f, 0.14712253f, 0.03881364f, 
    0.01087887f, 0.07622242f, 0.00531240f, -0.06532501f, -0.01543548f, -0.08661101f, 0.09362189f, -0.01783781f, 
    0.13240157f, 0.10402551f, 0.08357754f, 0.18312478f, -0.37188661f, -0.07085545f, -0.00471987f, -0.04159079f, 
    0.17338306f, 0.01978726f, 0.04387267f, -0.27011400f, 0.09449238f, -0.02222420f, 0.08451649f, 0.10985994f, 
    0.40968844f, 0.11414897f, -0.01309208f, 0.08999921f, -0.00520121f, 0.01391742f, 0.00605688f, -0.06746968f, 
    -0.08439007f, -0.03552277f, -0.01387949f, 0.05774290f, 0.08534802f, 0.00996362f, 0.05280159f, 0.18423542f, 
    -0.00638874f, -0.03002085f, -0.04839593f, 0.07961835f, 0.09473756f, 0.06679130f, -0.04167810f, 0.17337663f, 
    0.13982800f, 0.05194834f, 0.17239030f, 0.15000845f, -0.09470901f, 0.02455115f, 0.01849928f, -0.04449525f, 
    0.02240009f, -0.00238003f, -0.05033131f, 0.06046249f, -0.11758171f, -0.20974560f, -0.06254824f, 0.04620896f, 
    -0.01387173f, -0.06347625f, 0.04464856f, -0.00828249f, 0.10553093f, 0.07865617f, -0.17822912f, -0.14278822f, 
    0.00864829f, 0.00874910f, 0.14306700f, 0.09685558f, 0.01771985f, 0.06655332f, 0.01588620f, -0.01710214f, 
    0.10117725f, -0.20605038f, 0.01801633f, 0.08332431f, 0.03766964f, -0.01371509f, 0.03897302f, -0.12192926f, 
    0.09506782f, -0.08819254f, -0.05441350f, 0.09413744f, -0.02469597f, 0.06889624f, 0.04621674f, -0.09524338f, 
    0.20351887f, 0.24899994f, 0.12918261f, 0.20046313f, 0.02669434f, -0.07233100f, 0.18116710f, -0.05658468f, 
    0.13812943f, 0.10887288f, 0.03564234f, 0.13045309f, -0.05748706f, -0.00166802f, 0.10653205f, 0.01335326f, 
    0.13998508f, -0.08705343f, 0.02708681f, -0.15115213f, 0.09202942f, -0.05064785f, 0.10005820f, 0.11984186f, 
    -0.10258128f, 0.06326866f, 0.21312986f, -0.05918593f, -0.13297352f, 0.07640447f, -0.06584622f, -0.07111959f, 
    0.05212978f, 0.14271013f, 0.05026690f, 0.13513857f, 0.18014967f, 0.07744430f, 0.10943939f, 0.18047410f, 
    0.12125089f, 0.03795719f, 0.08311325f, 0.09318215f, -0.06203200f, 0.07106321f, -0.02841503f, 0.04194201f, 
    -0.13629681f, -0.11140174f, 0.36638635f, 0.09681796f, -0.01054038f, -0.11383675f, 0.00586693f, 0.00376920f, 
    0.08053743f, 0.00357893f, 0.09304518f, -0.04188269f, -0.02304722f, -0.10559133f, -0.15690677f, 0.08630759f, 
    0.12630749f, 0.10257288f, -0.09692360f, 0.13519318f, 0.05293911f, 0.02124195f, -0.07588848f, -0.06269313f, 
    -0.09961124f, -0.07683824f, -0.09367603f, 0.01270201f, 0.10488117f, -0.03951252f, -0.03346057f, 0.00413892f, 
    0.18483296f, 0.02897269f, 0.14009775f, 0.14968912f, -0.45586315f, -0.21432900f, -0.06081262f, -0.00773273f, 
    0.14427401f, -0.01104792f, -0.06079064f, -0.08255828f, 0.10725299f, -0.07248852f, -0.03512806f, 0.08700538f, 
    0.22790608f, -0.00030136f, 0.10490485f, -0.17267585f, -0.09301548f, -0.02435785f, -0.02928193f, -0.16166736f, 
    -0.01751005f, -0.05960087f, -0.17837170f, 0.11587238f, -0.01816959f, 0.15121545f, 0.08505287f, 0.13598403f, 
    -0.05472657f, -0.08945476f, -0.02270087f, -0.06176695f, -0.02021776f, -0.08507127f, 0.09791326f, 0.10430801f, 
    -0.19919910f, 0.08887257f, 0.09789603f, 0.14179233f, 0.06958739f, 0.02079682f, 0.01837865f, -0.01445830f, 
    0.03749895f, 0.10271686f, -0.08745778f, 0.06263418f, 0.15915224f, 0.14780466f, 0.00088843f, 0.04247198f, 
    0.01915177f, 0.11321573f, -0.01922364f, -0.00205950f, 0.08057120f, -0.07250336f, 0.08931365f, 0.01541203f, 
    -0.47228673f, 0.00295920f, -0.08147086f, -0.04802231f, -0.03367466f, -0.05167241f, -0.03239093f, 0.02874867f, 
    0.09582960f, 0.01432939f, -0.02264425f, 0.08863441f, -0.09666505f, 0.18403782f, 0.15846089f, 0.21261157f, 
    0.11948191f, -0.00874833f, -0.00963982f, 0.05527864f, -0.09115359f, 0.02412046f, 0.00670111f, 0.16042773f, 
    0.08263783f, -0.15738276f, -0.17040692f, -0.17424037f, 0.01759955f, 0.12602630f, -0.17393586f, 0.02103023f, 
    0.13839565f, 0.05056995f, 0.07211701f, 0.01763062f, -0.20016582f, -0.17458650f, -0.22693686f, -0.13302803f, 
    0.05753569f, 0.07929757f, 0.09390298f, -0.13840699f, 0.10136992f, 0.02632717f, -0.02535461f, -0.02986396f, 
    0.04732265f, -0.16777515f, -0.04293329f, -0.01288861f, -0.06773373f, 0.13926542f, 0.00530134f, 0.03103316f, 
    0.05307472f, -0.04908196f, 0.05335012f, 0.02136963f, -0.64895439f, 0.34577483f, 0.11895437f, 0.15628687f, 
    0.09687723f, -0.16608490f, 0.09511971f, -0.09574597f, 0.06849776f, -0.02635872f, 0.00784231f, -0.04450499f, 
    -0.44666544f, 0.07770332f, -0.05630997f, 0.21330766f, 0.05318044f, 0.00830574f, 0.00158445f, 0.14177154f, 
    -0.09255448f, 0.17587413f, 0.03507925f, 0.06727243f, -0.06009540f, -0.05459015f, 0.14867371f, -0.01121275f, 
    -0.04310920f, -0.02526097f, -0.02313497f, -0.06839871f, 0.13680188f, -0.09831348f, -0.02142522f, 0.03059405f, 
    0.12186623f, -0.13160574f, 0.14283699f, 0.04326128f, -0.05970987f, -0.06982809f, 0.01667485f, 0.17149991f, 
    -0.09321180f, -0.06826486f, 0.02573961f, 0.19331102f, 0.00238742f, -0.06819964f, -0.02835123f, 0.01504367f, 
    0.02046308f, 0.00077734f, -0.04100367f, -0.08693751f, 0.02755884f, 0.00590594f, 0.00115732f, -0.03565187f, 
    0.01238409f, -0.02036974f, -0.10240322f, 0.05325522f, 0.12826055f, -0.12350891f, 0.19109698f, 0.10268221f, 
    -0.04009915f, 0.09813640f, -0.04254197f, 0.09284716f, -0.59350771f, -0.01316433f, 0.01417515f, -0.13198182f, 
    0.09926594f, -0.05955995f, -0.03235187f, 0.12876396f, 0.01463354f, 0.04216728f, 0.09642032f, 0.12371100f, 
    0.06232892f, 0.09140565f, 0.09742244f, -0.01027192f, 0.00121092f, -0.02464041f, 0.01740782f, 0.14998432f, 
    0.15436897f, -0.01825862f, 0.03333952f, -0.05145032f, 0.07770643f, 0.11083943f, -0.02624852f, 0.07870766f, 
    -0.12770179f, 0.02036204f, 0.04779852f, 0.08306494f, -0.14826095f, -0.01270528f, -0.04338736f, 0.08900385f, 
    -0.11892695f, -0.08763633f, 0.00473740f, -0.08488952f, 0.09030873f, -0.06844682f, 0.13096987f, 0.09716953f, 
    0.13778313f, 0.15624221f, 0.02946504f, -0.02538682f, 0.20936134f, 0.09003277f, 0.00331577f, 0.15433125f, 
    0.01163400f, 0.04411243f, 0.10192225f, 0.02771555f, -0.18191305f, 0.09567090f, 0.04649402f, 0.11162647f, 
    -0.08439914f, 0.09614112f, 0.11414824f, -0.25353104f, 0.01541914f, 0.08984156f, 0.05804356f, -0.03441635f, 
    -0.01130024f, -0.03434166f, 0.02323856f, -0.17217486f, 0.08755548f, -0.26109710f, 0.17143679f, -0.06108256f, 
    0.09269192f, -0.07536962f, 0.02975516f, 0.04315574f, 0.20453282f, -0.06483319f, 0.11492081f, -0.07532255f, 
    0.02284236f, 0.35046604f, 0.03430837f, 0.05410176f, 0.04792994f, 0.00190026f, -0.09124807f, -0.19560659f, 
    -0.15227941f, -0.04525571f, 0.04131630f, -0.17417327f, 0.05944255f, -0.03693075f, -0.13559677f, -0.26419872f, 
    -0.05327846f, 0.04973549f, -0.01580394f, 0.00188869f, -0.07874443f, 0.09421192f, 0.03099767f, -0.21105260f, 
    -0.18465136f, -0.00928490f, -0.24961248f, -0.23773202f, 0.05306799f, 0.17887132f, 0.01474045f, -0.01469886f, 
    0.02602953f, -0.11912789f, 0.01856075f, 0.07017866f, 0.19125199f, 0.01314367f, 0.05117755f, 0.22486265f, 
    0.08601509f, 0.01218377f, 0.03623582f, -0.06356154f, -0.14370057f, -0.04830163f, -0.02099816f, -0.02384073f, 
    -0.18417440f, 0.06915275f, -0.10226189f, -0.19390446f, 0.07592068f, 0.06307175f, 0.07137115f, -0.15126801f, 
    0.14189789f, 0.09799454f, 0.00941032f, -0.00328908f, 0.31832424f, 0.04630356f, -0.13395242f, -0.13588545f, 
    -0.02122542f, 0.13607192f, -0.12770399f, -0.09975468f, 0.09135941f, -0.04930478f, 0.01607116f, 0.06716968f, 
    0.23755047f, 0.15823545f, -0.04768955f, 0.07935746f, 0.14097379f, 0.06313345f, -0.06633622f, -0.00572722f, 
    -0.02260082f, -0.05238752f, 0.00056550f, 0.05804511f, 0.07886752f, 0.25373107f, 0.09605502f, 0.28630435f, 
    -0.15199824f, -0.03920761f, 0.07990183f, 0.02691572f, 0.00343926f, 0.05279454f, 0.12394407f, 0.05286934f, 
    0.20925190f, 0.21602772f, -0.11249933f, -0.01407119f, -0.01860220f, 0.08105420f, -0.15661566f, 0.14985816f, 
    0.08734931f, 0.05419295f, -0.03269145f, -0.03970928f, 0.19196624f, -0.02266228f, -0.03108103f, 0.11293717f, 
    0.09299030f, -0.03491497f, -0.04327976f, 0.11358129f, 0.03387177f, 0.10729510f, 0.07768103f, 0.04804014f, 
    0.05252482f, 0.11518615f, 0.04484366f, -0.14056176f, -0.02205754f, 0.09587462f, 0.00718238f, 0.07977924f, 
    -0.01903622f, 0.12562852f, -0.09639742f, 0.03606049f, -0.17094821f, 0.05390638f, 0.16172527f, 0.14251968f, 
    0.04938035f, 0.00562530f, -0.03285632f, 0.22775103f, 0.06747747f, 0.16102622f, -0.06055396f, -0.00999613f, 
    0.07444327f, 0.02631896f, 0.24806163f, 0.07569697f, -0.01525985f, -0.09534184f, 0.09012039f, 0.08227444f, 
    0.02085377f, 0.06720319f, 0.10458168f, -0.00932778f, -0.02384416f, 0.15405674f, 0.01352452f, 0.14500868f, 
    0.14277788f, -0.07471350f, 0.05509935f, 0.01499774f, 0.17280488f, 0.10590225f, -0.08147387f, -0.00176301f, 
    0.11191348f, -0.01284157f, -0.02629565f, 0.21107367f, -0.00842079f, -0.05421911f, 0.12975071f, -0.01000426f, 
    -0.03835185f, 0.04255562f, -0.06942364f, 0.15134589f, -0.03166185f, 0.06668642f, 0.00101241f, -0.16708027f, 
    0.02327175f, 0.02081089f, 0.00214111f, -0.11233635f, -0.08690344f, -0.01947648f, -0.09973580f, 0.06619781f, 
    -0.00158127f, -0.16030841f, -0.07143636f, 0.11452887f, -0.01895178f, -0.13387963f, 0.01216503f, 0.13538429f, 
    0.02663981f, -0.08343438f, 0.01505800f, -0.09365246f, 0.11774903f, 0.00823803f, 0.07153364f, 0.05166250f, 
    -0.01737925f, 0.15260182f, -0.01555828f, -0.00237589f, -0.20519729f, -0.03448085f, 0.08834966f, -0.02499123f, 
    -0.08735015f, 0.12081871f, 0.11516390f, -0.09202564f, -0.00530900f, 0.00019543f, 0.15527478f, 0.06076102f, 
    -0.02544452f, -0.05594460f, 0.09478232f, 0.08245970f, -0.26557761f, 0.10633932f, -0.07894753f, 0.28799281f, 
    0.06589796f, 0.07663987f, 0.19948097f, 0.11722707f, -0.00544059f, 0.08425981f, -0.13356744f, 0.08931766f, 
    0.19616021f, 0.13586800f, 0.07803929f, 0.16674249f, -0.05612385f, 0.03919126f, 0.10159481f, -0.01659418f, 
    0.01406119f, -0.03660288f, -0.09627809f, 0.01593028f, 0.21207151f, 0.07900034f, 0.24545237f, 0.16500972f, 
    -0.11375704f, -0.08186639f, 0.04611638f, 0.01285040f, 0.01413208f, 0.07801411f, -0.10391263f, -0.05257065f, 
    0.12906125f, -0.08801108f, -0.02082151f, -0.04686979f, -0.03345089f, -0.01592620f, 0.03923380f, 0.09422249f, 
    0.02782446f, -0.03618819f, -0.05603132f, 0.03932950f, -0.10542232f, -0.06192665f, -0.05111727f, 0.09269933f, 
    -0.05350143f, -0.06588551f, 0.01496370f, 0.10708027f, 0.02831336f, 0.04414162f, -0.00674978f, -0.01301598f, 
    0.00618130f, 0.33233699f, 0.18592955f, -0.03181579f, 0.12266194f, -0.08640398f, -0.07233762f, 0.10712814f, 
    0.00681590f, -0.09930151f, 0.04235376f, 0.04794990f, 0.02457852f, 0.16791108f, -0.10963371f, 0.25340098f, 
    0.06516303f, -0.02436261f, -0.07038278f, 0.06555750f, 0.03599409f, -0.02509624f, 0.00997846f, -0.07336319f, 
    0.07110823f, -0.17318822f, 0.02184715f, 0.13482307f, 0.00849067f, -0.00444811f, 0.03373906f, 0.07148886f, 
    0.05289363f, 0.06101531f, -0.05209173f, 0.11375654f, 0.00756452f, 0.17505862f, -0.00904305f, -0.02686768f, 
    0.16194494f, -0.05606109f, 0.10602970f, 0.01790595f, 0.04925481f, -0.00231302f, -0.04250525f, 0.06788822f, 
    -0.12987593f, -0.15270087f, 0.01961995f, -0.14039122f, 0.00168560f, -0.01800920f, -0.01586450f, -0.03658396f, 
    0.01932008f, 0.03356249f, 0.02311803f, -0.00826514f, 0.27144620f, -0.23949091f, -0.02196162f, 0.06670205f, 
    -0.08558605f, -0.00059065f, 0.03605332f, -0.05500240f, 0.06368545f, 0.01447998f, 0.04763642f, -0.04099297f, 
    0.26802483f, -0.25577760f, 0.00256220f, 0.19710891f, -0.06280516f, -0.05382987f, 0.07308743f, 0.07747278f, 
    0.07038297f, -0.01338250f, -0.04301067f, 0.07278325f, 0.23287767f, -0.10401473f, -0.22069980f, -0.00108237f, 
    0.12927900f, 0.06334814f, -0.09656674f, 0.00041947f, -0.14389466f, -0.12437436f, 0.08459701f, -0.06708371f, 
    0.05322268f, -0.10613247f, 0.35657021f, 0.16651121f, -0.03272860f, -0.06922434f, 0.10696898f, -0.02328243f, 
    0.04065881f, 0.10549097f, 0.09426700f, -0.04527593f, -0.03320630f, 0.12478379f, -0.11386836f, 0.15296911f, 
    0.07953115f, 0.08421404f, 0.04531272f, -0.13873184f, -0.00811334f, 0.13181646f, -0.04047467f, 0.01487330f, 
    0.06740677f, 0.20776187f, 0.07144652f, 0.33698410f, 0.07696771f, 0.02713872f, -0.08388464f, -0.00929930f, 
    -0.02898910f, -0.03792150f, 0.11817729f, -0.04097098f, 0.03633749f, 0.05366465f, 0.19937769f, 0.03438638f, 
    0.04974795f, -0.05236860f, 0.11488807f, 0.09336413f, 0.05868303f, 0.04033460f, 0.00004606f, 0.01366346f, 
    -0.01235874f, -0.08655267f, 0.07127570f, -0.17944093f, 0.00475119f, -0.11476899f, 0.05590231f, 0.00635610f, 
    0.03078934f, -0.03138394f, -0.02040788f, -0.05860669f, -0.07625357f, -0.04962883f, -0.18440516f, 0.23857799f, 
    -0.01635381f, 0.05609307f, 0.13027425f, -0.08823241f, -0.00642893f, 0.07169603f, -0.02684323f, 0.03607572f, 
    0.19117677f, 0.15802044f, -0.11917032f, -0.23779795f, 0.03254628f, 0.04023242f, 0.04900016f, 0.01698850f, 
    0.11040910f, -0.05791979f, 0.00173757f, 0.08133273f, 0.13135789f, 0.04924812f, 0.10303940f, 0.00054728f, 
    -0.01944094f, 0.09230231f, 0.10919540f, 0.06516987f, -0.07953578f, 0.03392827f, -0.06525002f, 0.07631535f, 
    -0.05711125f, -0.16238932f, -0.04063531f, 0.12517636f, -0.12633128f, 0.02563272f, -0.00251578f, 0.01676223f, 
    0.00518068f, 0.09364313f, -0.09147619f, -0.01629205f, -0.00346548f, -0.06785951f, 0.10602586f, -0.03971476f, 
    0.06670276f, -0.07215574f, -0.03856994f, 0.05844734f, -0.01358546f, 0.06601810f, -0.07367653f, -0.04529489f, 
    0.08080906f, -0.09578319f, 0.05480847f, -0.24960692f, 0.02462195f, -0.03676812f, 0.05017803f, 0.09670094f, 
    0.03173647f, 0.02710224f, 0.13320683f, -0.06421607f, -0.19366851f, 0.02107410f, 0.12707445f, -0.05881222f, 
    -0.11235867f, 0.03786571f, -0.03990506f, -0.05378620f, 0.05298990f, -0.03379986f, -0.00727418f, -0.17928639f, 
    -0.02896512f, -0.09493537f, -0.00718678f, 0.04123363f, -0.02550896f, 0.01784609f, 0.09122604f, 0.08811924f, 
    0.02157366f, 0.06080127f, 0.06610103f, -0.10422674f, 0.05808427f, 0.20111576f, 0.02827850f, 0.00318548f, 
    -0.03902268f, 0.04990159f, -0.03155073f, 0.03139560f, 0.05788358f, -0.02179528f, 0.05989131f, -0.02887930f, 
    -0.06112953f, -0.07140978f, 0.20090601f, 0.03131031f, -0.05566873f, 0.05588218f, -0.05982287f, -0.00504746f, 
    0.06931313f, 0.01278942f, -0.06362639f, -0.05694709f, -0.18736173f, 0.11339427f, 0.13794556f, -0.18644084f, 
    0.05477871f, 0.09651028f, 0.06060089f, 0.01084969f, 0.06227724f, -0.00912839f, 0.00371505f, 0.03556237f, 
    0.18741877f, 0.06829392f, 0.06947611f, -0.03434224f, 0.13261180f, -0.05767591f, 0.08308689f, 0.16138324f, 
    -0.03332526f, 0.02312942f, 0.03044555f, 0.02842736f, 0.19548945f, 0.15227956f, -0.17154473f, 0.11951280f, 
    0.12187091f, -0.04432452f, -0.01467929f, 0.14829853f, 0.01307266f, -0.05288171f, 0.06525134f, 0.04191873f, 
    0.22629014f, 0.06604986f, 0.02089075f, 0.25352067f, -0.15782388f, -0.04281221f, -0.06826571f, -0.04076282f, 
    -0.05796439f, -0.00195847f, 0.13205124f, -0.03995029f, -0.08465949f, 0.06197734f, -0.11385523f, 0.16826938f, 
    0.01120169f, -0.01122274f, -0.06760088f, -0.03180065f, -0.01216644f, 0.02102938f, -0.12526852f, 0.03626117f, 
    -0.12046624f, 0.15496781f, -0.04827943f, -0.02736807f, 0.07280400f, 0.06608777f, -0.01822441f, 0.14088194f, 
    -0.02307651f, -0.10716407f, -0.03415059f, -0.00635587f, 0.25977033f, 0.44835725f, 0.10411052f, 0.04251714f, 
    0.07518161f, 0.15391611f, 0.03422863f, 0.16908082f, 0.08478843f, -0.02276506f, 0.03372445f, -0.05368146f, 
    -0.29915485f, 0.25625852f, -0.09115398f, 0.20824917f, 0.01596296f, 0.08363057f, -0.11793637f, -0.13866153f, 
    0.05350438f, -0.00833753f, 0.00152040f, -0.01528386f, 0.10013159f, -0.03375640f, -0.10479092f, 0.22129294f, 
    -0.07088687f, 0.09304781f, -0.07685841f, 0.02343336f, -0.09186127f, 0.01827670f, 0.12128880f, 0.09257808f, 
    0.12863082f, 0.13735157f, -0.00402080f, 0.16108286f, -0.03275813f, 0.08924216f, -0.05567148f, 0.00301109f, 
    0.00705371f, 0.05406261f, -0.08156154f, 0.09437460f, -0.12629491f, 0.21417744f, 0.01863023f, 0.02510502f, 
    0.06293419f, 0.07166100f, -0.05739500f, -0.01297351f, -0.01330662f, -0.01577710f, -0.06275527f, 0.10446912f, 
    -0.27157339f, -0.10484263f, 0.31310678f, -0.10400519f, 0.13375053f, -0.20199764f, 0.16146378f, -0.00755581f, 
    -0.03526430f, 0.05308802f, 0.03083395f, 0.16779700f, 0.03156602f, -0.12468881f, 0.29664522f, 0.16177930f, 
    -0.09283333f, -0.04781395f, 0.10567739f, -0.09520870f, 0.03641044f, -0.01206708f, 0.10452810f, -0.05745514f, 
    0.15967391f, 0.00248531f, -0.07342125f, -0.14443013f, 0.06921667f, 0.11619093f, 0.03420003f, 0.04440998f, 
    0.17901349f, -0.06667645f, -0.06197958f, 0.10478582f, -0.28642935f, 0.01715952f, -0.01778381f, -0.07437152f, 
    -0.03557328f, -0.03258283f, -0.01745311f, 0.01728492f, 0.06717977f, -0.09688685f, -0.07712883f, -0.01617991f, 
    0.02998941f, 0.31149587f, -0.03655955f, 0.01009631f, 0.19986440f, 0.01429560f, -0.08641741f, 0.22733799f, 
    0.02610182f, 0.09786845f, -0.00082124f, 0.01633533f, 0.00405114f, 0.05144757f, 0.10218148f, -0.30483881f, 
    -0.08934577f, 0.11423298f, 0.11172552f, 0.15111750f, -0.03548472f, 0.03240204f, 0.12385486f, 0.12031794f, 
    0.24441087f, -0.04667138f, -0.01731401f, -0.19613531f, -0.06936762f, 0.03527743f, 0.07017270f, 0.03488380f, 
    0.12772501f, 0.01611286f, 0.05662702f, -0.02435916f, 0.20063971f, -0.06539758f, -0.13030007f, 0.16750826f, 
    0.11835474f, -0.00783663f, 0.14581859f, 0.00867137f, -0.09896209f, 0.12346649f, 0.12669231f, 0.13362801f, 
    0.19855502f, 0.26271996f, 0.17097951f, 0.04083045f, 0.07668739f, -0.08365130f, 0.07235626f, 0.13204975f, 
    -0.02331012f, 0.08837729f, -0.02644946f, 0.06589509f, -0.42408451f, 0.04169993f, 0.15201771f, -0.06782091f, 
    -0.09955863f, -0.01682659f, -0.00311006f, -0.10405965f, 0.04530930f, -0.06680351f, 0.02338553f, -0.16174345f, 
    0.26065165f, 0.27345058f, -0.03563819f, -0.00426504f, 0.03221225f, -0.03463397f, 0.04559857f, 0.17064671f, 
    0.08731961f, -0.07274195f, 0.03533102f, 0.12076315f, 0.03439693f, -0.12724188f, 0.14108725f, -0.02587736f, 
    -0.01715432f, -0.05014596f, -0.01382796f, 0.00240408f, 0.09110868f, 0.18079610f, 0.01682228f, 0.11921080f, 
    -0.25116521f, -0.20932856f, 0.39294916f, -0.21718173f, -0.05845547f, 0.09226332f, 0.04962409f, -0.06957094f, 
    -0.01869198f, -0.02655921f, 0.02749033f, -0.05992121f, -0.20029089f, 0.00900256f, 0.17240596f, -0.04692341f, 
    -0.04814326f, 0.09353278f, 0.01761035f, -0.02067368f, -0.05368378f, 0.00820488f, 0.00981935f, 0.02913052f, 
    -0.06187775f, 0.04873129f, 0.23052076f, -0.03329422f, 0.01356330f, 0.00727328f, 0.18052982f, 0.05181616f, 
    -0.02162724f, 0.09701644f, 0.12104279f, -0.00395219f, -0.15164532f, 0.01409663f, -0.17837077f, 0.24017988f, 
    0.00972321f, -0.00410046f, 0.16270669f, -0.00513456f, 0.01858572f, 0.17621166f, -0.19580933f, 0.08416070f, 
    -0.00688444f, -0.05870788f, 0.10248446f, -0.02984511f, 0.00006870f, -0.12490675f, 0.11905663f, -0.08982309f, 
    -0.01866348f, 0.07517310f, 0.07027198f, -0.01982612f, -0.07874274f, 0.19500300f, -0.16324882f, 0.32083866f, 
    -0.03394461f, 0.26177803f, -0.00291948f, 0.03173545f, 0.13840856f, -0.01756280f, 0.05224342f, 0.00961460f, 
    -0.05718334f, 0.10632919f, 0.05534271f, -0.14817162f, -0.08330467f, 0.17344636f, 0.10617191f, -0.08527349f, 
    -0.00463402f, -0.00308533f, -0.03198142f, 0.03357795f, -0.01401019f, 0.15835671f, -0.16582358f, 0.18493278f, 
    0.02123758f, -0.00456146f, -0.01350577f, 0.02877883f, 0.05170164f, -0.01981598f, -0.07415761f, 0.07027205f, 
    -0.04607064f, -0.02156221f, -0.10143411f, -0.06455473f, 0.04544680f, 0.02635216f, -0.09555255f, 0.06226411f, 
    0.00204759f, -0.08493316f, 0.00363477f, -0.03577820f, 0.36315706f, 0.24454033f, 0.09021387f, -0.06915583f, 
    0.06218562f, 0.07501373f, 0.05206424f, 0.07590843f, -0.00132728f, 0.00922846f, 0.01403121f, -0.05807002f, 
    -0.02341069f, 0.15072988f, -0.07636295f, -0.03013911f, 0.01003006f, 0.11921711f, -0.01538801f, -0.04097716f, 
    0.01148935f, 0.11842189f, 0.14659503f, 0.05983884f, -0.11657994f, -0.18015212f, -0.06145069f, -0.01803127f, 
    0.03586025f, -0.02338455f, 0.09965528f, 0.00536275f, 0.03770447f, -0.00049993f, 0.04197486f, 0.06127423f, 
    -0.02894857f, 0.00977893f, 0.02510198f, -0.03149590f, -0.00433939f, 0.00461869f, -0.02400354f, -0.02363951f, 
    -0.02909970f, -0.01685712f, -0.02657968f, -0.01528920f, 0.01614590f, 0.01518646f, -0.03109828f, 0.02555726f, 
    -0.03377356f, 0.00659626f, 0.01880387f, -0.00029422f, -0.02326204f, -0.01987593f, 0.00101452f, -0.02490164f, 
    0.02520716f, 0.00104311f, 0.00647694f, -0.02565943f, 0.01413870f, 0.01899187f, -0.00747131f, -0.01314189f, 
    -0.03738206f, -0.01256529f, -0.03890863f, 0.01549702f, -0.03038946f, -0.01919233f, -0.00640682f, 0.02919605f, 
    0.00999315f, -0.02431457f, 0.01612892f, 0.01890346f, 0.02968289f, -0.00881627f, -0.03209804f, -0.02189780f, 
    -0.03194842f, -0.00324925f, 0.01473446f, 0.00441666f, -0.00988476f, -0.01140225f, -0.02469768f, -0.02480151f, 
    0.01989310f, -0.04115425f, -0.02528969f, -0.03585814f, 0.01871574f, -0.00001844f, -0.00462345f, 0.02850229f, 
    0.00332821f, -0.01076052f, 0.01325913f, -0.00392590f, 0.00879521f, 0.01570247f, -0.00151738f, 0.00964453f, 
    -0.01167201f, 0.02103458f, -0.00027128f, -0.02025234f, -0.01867631f, 0.02768375f, -0.01086017f, -0.00664096f, 
    0.02974393f, -0.01809067f, 0.00388785f, -0.01951184f, 0.02701165f, -0.01716362f, -0.03818992f, 0.02687219f, 
    0.02263608f, 0.02646394f, -0.02233795f, -0.01113786f, -0.02117483f, 0.00901272f, -0.01728460f, -0.00701487f, 
    -0.00858741f, 0.00380425f, 0.01865653f, 0.01553104f, -0.01127203f, 0.00950009f, 0.00733855f, 0.02766609f, 
    0.01475957f, 0.02765562f, 0.02994630f, -0.00222858f, -0.03084307f, -0.00120064f, -0.01953301f, 0.02231282f, 
    0.00836296f, -0.03750069f, -0.03875744f, -0.01783441f, 0.01182719f, -0.03564907f, 0.02045999f, 0.00337181f, 
    -0.02617490f, 0.02926752f, -0.00864057f, -0.03382469f, -0.00393994f, 0.01805578f, -0.00486907f, -0.02231202f, 
    0.00925160f, 0.01132781f, 0.01210990f, -0.01693072f, -0.03174480f, 0.00251039f, 0.01049708f, 0.00323064f, 
    -0.02401135f, 0.01166490f, -0.03423912f, 0.01168592f, -0.00868325f, -0.03279429f, -0.02939432f, -0.01002099f, 
    0.01102927f, 0.02043059f, -0.01876038f, -0.00022860f, 0.02013708f, -0.03498657f, -0.00025703f, -0.00672044f, 
    -0.03969176f, -0.02554942f, -0.02235297f, -0.03438536f, -0.02491736f, -0.00443529f, -0.03122442f, 0.01304238f, 
    -0.00219453f, 0.01030438f, -0.00311213f, 0.00530362f, -0.03331981f, -0.03183863f, 0.00418487f, 0.01778079f, 
    -0.00110402f, 0.02401785f, -0.01159887f, -0.00143249f, 0.02797967f, -0.02703953f, -0.01343848f, 0.00642111f, 
    -0.00829745f, 0.03002614f, 0.00186357f, -0.01881946f, -0.04116341f, 0.02751792f, 0.00184451f, 0.00155348f, 
    -0.02055366f, -0.00227489f, -0.03435959f, 0.01462035f, -0.02956118f, 0.01596012f, 0.00812786f, 0.00412277f, 
    -0.01037889f, 0.02864603f, -0.02316318f, 0.00310364f, 0.00418904f, -0.00263512f, -0.01679317f, -0.01817874f, 
    0.02769445f, 0.02470664f, -0.03376479f, 0.00069181f, 0.01242466f, 0.02380715f, -0.02845685f, -0.00556935f, 
    0.00943603f, 0.02975882f, 0.02398964f, 0.02057858f, 0.00244028f, -0.03496395f, 0.00146236f, -0.03412048f, 
    0.00937951f, 0.00943379f, -0.03486172f, 0.02486866f, -0.01330736f, -0.03203449f, 0.00037034f, -0.01440843f, 
    -0.03561721f, -0.02670355f, -0.00721985f, -0.02393827f, -0.02462828f, 0.01726626f, -0.02531988f, -0.03278253f, 
    -0.02708741f, 0.01258520f, -0.03607232f, -0.00548330f, -0.02577161f, 0.00681137f, 0.01788474f, -0.02224584f, 
    -0.00553116f, 0.02509088f, -0.04073973f, -0.02737620f, -0.01227276f, -0.03028868f, -0.04111005f, -0.02963427f, 
    0.00119593f, -0.02643201f, -0.02101201f, -0.00575024f, -0.02798536f, -0.03469860f, 0.01049682f, -0.01775896f, 
    -0.01314549f, -0.01164043f, 0.02180127f, -0.00347747f, -0.03585691f, -0.01251144f, -0.03483572f, -0.01343110f, 
    -0.02781499f, 0.02586661f, -0.02514378f, 0.02220467f, -0.03718797f, -0.02531010f, 0.02141333f, -0.00591148f, 
    -0.03542342f, -0.00501915f, -0.00997228f, -0.03008034f, -0.03541083f, -0.00191293f, -0.00452399f, 0.02511723f, 
    -0.00141669f, -0.01819954f, -0.02142910f, 0.00457944f, -0.01309890f, 0.01204978f, -0.02306359f, 0.01218194f, 
    0.00370438f, -0.02955271f, -0.01462980f, 0.02590466f, 0.01031246f, -0.00271054f, -0.02909838f, -0.00478263f, 
    0.00896414f, 0.02122243f, 0.02322433f, 0.02144761f, -0.03703082f, -0.03153122f, 0.02179817f, -0.02389417f, 
    -0.03241456f, -0.03493288f, 0.02257312f, -0.04080348f, -0.02941827f, 0.02547800f, -0.02381933f, -0.02566613f, 
    -0.03359407f, -0.03582643f, -0.01431174f, -0.00880948f, -0.03980645f, -0.02480443f, 0.02025364f, 0.00038918f, 
    0.02627243f, -0.03262648f, -0.02103908f, 0.01150484f, -0.03347984f, -0.03536911f, -0.00884570f, 0.02269085f, 
    -0.00406570f, -0.00892335f, 0.03062162f, -0.03015578f, -0.03160412f, -0.03349165f, -0.00431416f, -0.02888871f, 
    -0.00185859f, -0.00746291f, 0.02337330f, -0.01906248f, 0.00790646f, -0.02922857f, 0.00528632f, -0.02054395f, 
    -0.02132066f, -0.01214322f, -0.00749036f, -0.03644795f, 0.02534646f, -0.00210308f, -0.00694941f, -0.02688145f, 
    -0.03804988f, -0.01392224f, 0.00829113f, 0.02101582f, -0.00306182f, 0.01592188f, -0.00734514f, 0.01034626f, 
    -0.04067483f, -0.02684699f, 0.01942930f, -0.03056556f, -0.00006327f, -0.02407831f, 0.01754577f, 0.03052541f, 
    0.01798964f, -0.01839952f, -0.01331952f, -0.01800796f, -0.00859124f, -0.00635188f, 0.01859560f, -0.00097227f, 
    -0.00019206f, -0.02490319f, -0.01414193f, -0.01423332f, -0.00957631f, 0.00021861f, 0.02649116f, -0.00586476f, 
    -0.03158545f, -0.02517638f, 0.00815667f, 0.00143907f, -0.00668262f, 0.02504384f, 0.02911279f, -0.00044554f, 
    0.02704806f, 0.02968330f, -0.02036425f, 0.01539598f, 0.02795998f, 0.00105072f, 0.00549550f, 0.00125702f, 
    -0.01250748f, -0.03365084f, -0.00249065f, 0.02234400f, -0.04044008f, 0.02278607f, -0.00081306f, 0.00696369f, 
    0.00595354f, -0.00004000f, 0.02628713f, -0.01396836f, -0.00548885f, -0.00502833f, 0.00701615f, 0.02356539f, 
    -0.00289046f, 0.01786295f, 0.02308029f, -0.01386305f, -0.02748340f, -0.01504873f, -0.00309931f, -0.00994895f, 
    0.03051580f, -0.00961781f, -0.03625372f, 0.01638359f, -0.00113161f, -0.02221115f, 0.00346445f, 0.00664464f, 
    -0.01355875f, -0.03768329f, -0.03695945f, -0.03973395f, -0.02943727f, -0.01035761f, -0.02342317f, -0.02540183f, 
    -0.02292859f, 0.01183836f, -0.02002924f, -0.04083506f, -0.02943717f, 0.00335610f, -0.02899792f, -0.01292786f, 
    -0.01970083f, 0.00406193f, 0.01184871f, -0.00079682f, -0.01707684f, -0.01912507f, -0.03231060f, 0.01914660f, 
    -0.01468226f, 0.01774731f, -0.02458725f, -0.01675296f, 0.02693355f, 0.01764658f, -0.03857019f, 0.00891944f, 
    -0.01336612f, -0.00659335f, 0.01991420f, 0.01717903f, 0.01917243f, -0.01657851f, -0.02609956f, 0.02397112f, 
    -0.01493070f, -0.03390459f, 0.02168115f, -0.01765328f, 0.00642939f, 0.01121340f, 0.02483989f, 0.01962312f, 
    0.00575980f, -0.02314714f, -0.01594461f, -0.00585099f, -0.02368015f, -0.00472484f, -0.02546660f, 0.02852900f, 
    0.02468051f, 0.01649363f, -0.02160283f, -0.02439811f, 0.01110260f, -0.03338213f, -0.01922901f, 0.01182923f, 
    0.02875415f, -0.03548175f, 0.02387278f, -0.03567681f, 0.03055714f, -0.02675713f, -0.01038540f, 0.01034950f, 
    0.01009837f, -0.00219109f, -0.00552103f, -0.03069782f, 0.00030309f, -0.01236872f, -0.00535703f, 0.02289596f, 
    -0.02139525f, 0.00097571f, -0.01709978f, -0.03136741f, -0.03656147f, -0.01857344f, -0.03496366f, -0.00050715f, 
    -0.03831433f, -0.01814943f, 0.01338538f, 0.03017240f, -0.00391215f, -0.01497390f, 0.02778886f, -0.00116450f, 
    -0.02671343f, -0.03277175f, -0.02966676f, 0.02805409f, -0.04096778f, -0.02184075f, 0.02774832f, 0.01285316f, 
    -0.01247338f, -0.02475848f, -0.01125669f, 0.00192970f, 0.00936509f, -0.02116667f, -0.04071436f, -0.00044450f, 
    0.01243376f, -0.02556781f, -0.00546011f, 0.02570792f, 0.01291679f, 0.01551178f, 0.01352524f, -0.00852703f, 
    -0.01831075f, 0.01955849f, -0.02387915f, -0.02692001f, -0.03008124f, -0.03676943f, 0.00823280f, 0.01388213f, 
    -0.00244325f, 0.02835052f, 0.00377487f, -0.03673267f, -0.01954688f, 0.02783713f, 0.00832034f, -0.04000633f, 
    -0.01692671f, -0.00212420f, 0.01841812f, -0.03659115f, 0.00658605f, -0.03482005f, -0.01742770f, 0.02779445f, 
    -0.01500969f, -0.03840536f, -0.03268105f, -0.02591904f, -0.03817958f, -0.01660885f, -0.00938238f, -0.03060565f, 
    -0.01185841f, -0.02085573f, -0.02721803f, -0.02538950f, -0.02590969f, -0.00421250f, 0.01097056f, -0.02152182f, 
    0.02230804f, 0.01068682f, 0.00874219f, 0.02863836f, -0.03911361f, -0.00797765f, 0.01878601f, 0.01695313f, 
    -0.03466158f, -0.00706940f, -0.01564940f, -0.03873249f, -0.03785810f, 0.00689272f, -0.02161466f, 0.00452433f, 
    0.01213952f, -0.00648742f, -0.01927106f, -0.01159883f, 0.01020263f, 0.00189547f, -0.02678729f, 0.00066643f, 
    -0.02583943f, -0.03616565f, 0.02028823f, -0.03174997f, -0.00177255f, -0.03125387f, -0.03666895f, 0.01345994f, 
    -0.02959268f, -0.00569866f, 0.00087301f, -0.00307774f, -0.03187852f, -0.00625926f, 0.02356050f, -0.03191765f, 
    -0.02806668f, 0.01635351f, 0.02114804f, -0.04107442f, -0.04022398f, -0.03664583f, -0.01266382f, -0.01055121f, 
    -0.03764090f, -0.01905771f, -0.03894895f, -0.02129252f, -0.01474227f, 0.02424897f, -0.02153416f, -0.01966358f, 
    -0.03287084f, -0.00078793f, 0.02483893f, -0.00630251f, -0.00435500f, 0.02880231f, 0.03080137f, -0.03564917f, 
    -0.03346273f, -0.02443696f, 0.00368398f, 0.00117474f, 0.01010441f, -0.02867595f, -0.02626489f, 0.01770086f, 
    0.02883461f, -0.02510889f, -0.03125731f, 0.00101296f, -0.04128868f, 0.01747366f, 0.01386055f, 0.01772457f, 
    -0.01670158f, 0.00340342f, -0.03875189f, -0.03361719f, 0.03071594f, -0.03193179f, -0.03970685f, 0.02678390f, 
    0.01788542f, -0.02703206f, -0.02893653f, 0.00433700f, -0.00230502f, 0.00126935f, 0.01824092f, 0.01189258f, 
    -0.01434888f, 0.01456963f, 0.01986388f, 0.00008139f, 0.00947402f, -0.01139959f, -0.02809204f, 0.02523480f, 
    0.02448440f, -0.03029761f, 0.03075048f, 0.00023311f, 0.01842779f, 0.01953417f, -0.02319893f, -0.03351612f, 
    -0.01883691f, -0.01390184f, -0.01269197f, -0.03061637f, -0.03065255f, 0.00696866f, 0.01077592f, 0.00359670f, 
    0.00181297f, -0.03015018f, -0.00587063f, 0.01968526f, -0.02976620f, -0.00619808f, 0.00923040f, -0.00474904f, 
    -0.01986157f, 0.00808459f, 0.02307098f, -0.00104454f, 0.02661838f, 0.00648473f, 0.02694055f, 0.02602288f, 
    -0.03199949f, -0.02435566f, 0.00104158f, 0.01053705f, -0.04057251f, -0.02051989f, 0.00788714f, -0.01271330f, 
    0.00178555f, 0.00680497f, 0.00263006f, 0.00022357f, 0.02865159f, -0.00651809f, 0.00574535f, -0.00758554f, 
    0.02708028f, -0.01359194f, -0.01915425f, 0.02077686f, -0.02652809f, -0.03136605f, -0.02841303f, 0.00888661f, 
    -0.02893593f, 0.02733154f, -0.01391050f, -0.02578554f, 0.01210974f, -0.03691657f, 0.00773935f, 0.00747811f, 
    0.02468815f, 0.02572036f, -0.02173393f, -0.02878217f, -0.02890392f, 0.01215624f, -0.01647144f, 0.02393896f, 
    -0.02932439f, 0.03507296f, 0.01019891f, 0.02524202f, 0.00235796f, 0.02491651f, 0.03338131f, 0.03571673f, 
    -0.01190226f, -0.00106031f, -0.02540193f, -0.00061072f, 0.01644244f, -0.01398106f, 0.04198514f, -0.01507382f, 
    0.00716211f, 0.01416209f, -0.02478827f, -0.03323211f, -0.00003309f, 0.00880209f, 0.00102627f, 0.00208882f, 
    0.00859040f, 0.00782402f, -0.00969723f, 0.02163614f, 0.00927269f, -0.02718624f, 0.02010250f, -0.02447397f, 
    -0.02980714f, 0.01119301f, -0.00251735f, -0.01668571f, -0.00145787f, 0.01178087f, 0.01529811f, 0.01245931f, 
    -0.00753505f, 0.02713098f, 0.00921174f, 0.02408872f, -0.00020760f, -0.02624392f, -0.01519012f, -0.01811307f, 
    0.02225552f, -0.03937376f, -0.03458205f, 0.01159665f, -0.02301841f, -0.01804649f, 0.02021613f, -0.01396994f, 
    -0.03952418f, 0.02916136f, -0.02934751f, -0.00155579f, -0.03469930f, 0.01809307f, 0.01245370f, -0.00715241f, 
    0.00537549f, 0.01308832f, 0.01687985f, -0.00588944f, 0.01566233f, -0.00200134f, -0.00465681f, -0.03412415f, 
    0.00709409f, 0.01690357f, 0.00602551f, -0.00672840f, -0.00012097f, -0.02736725f, 0.02237091f, 0.02850926f, 
    -0.01602356f, 0.00441154f, 0.00141687f, -0.02328201f, -0.02206684f, -0.02656312f, -0.00325167f, 0.00703390f, 
    0.00259700f, -0.01420370f, -0.01109012f, 0.00328703f, -0.03297555f, -0.02664145f, -0.00077563f, 0.02182769f, 
    0.00254810f, -0.01001029f, -0.01393634f, -0.00373040f, -0.01799646f, -0.02427521f, 0.01917514f, -0.01283090f, 
    -0.04400741f, 0.01001000f, -0.01618499f, -0.02490067f, 0.01101404f, 0.01519682f, -0.00151464f, 0.01530544f, 
    0.01522560f, 0.01500581f, 0.02431418f, 0.00174912f, 0.00165896f, -0.02763308f, 0.00505974f, -0.00474109f, 
    -0.01325700f, 0.01044302f, -0.02366278f, -0.00346419f, -0.02179920f, 0.02787994f, 0.01668777f, -0.01010580f, 
    -0.04128607f, -0.03765718f, -0.03656171f, -0.00531454f, 0.00058889f, -0.01386724f, -0.04564504f, -0.03503301f, 
    -0.02701627f, -0.03035736f, 0.00402864f, -0.02663187f, 0.02931110f, 0.02277475f, -0.00153787f, -0.01747019f, 
    0.00905313f, -0.01174123f, 0.03413045f, -0.02033163f, -0.02716613f, -0.01045062f, -0.02822035f, 0.02333490f, 
    -0.00215645f, -0.00345351f, -0.02040981f, -0.03818075f, -0.00381249f, 0.02095480f, -0.01842017f, -0.03110898f, 
    -0.01954599f, -0.02603387f, 0.03665492f, -0.02330782f, -0.03205292f, 0.04063407f, 0.01051389f, 0.00272316f, 
    0.01026079f, 0.00931557f, 0.00953052f, 0.01934607f, 0.01390040f, 0.00732550f, -0.01014799f, -0.01406007f, 
    0.00587251f, -0.03318563f, -0.00843074f, -0.00669629f, -0.00937492f, -0.01605928f, 0.00969103f, -0.02778836f, 
    -0.01023553f, -0.02663041f, -0.03536537f, -0.03138579f, -0.03359247f, -0.00852695f, 0.03119382f, -0.01368892f, 
    0.02073712f, 0.00241483f, 0.01478198f, -0.03912015f, -0.03008391f, -0.01309813f, -0.00001155f, -0.00002923f, 
    -0.02422646f, 0.01515446f, 0.01685735f, 0.00278164f, -0.01528495f, -0.01479919f, 0.03694753f, -0.00533162f, 
    -0.02277846f, 0.01527545f, 0.00901774f, 0.02346626f, -0.00039019f, 0.00253763f, -0.01701171f, -0.02821264f, 
    0.01590930f, 0.02666050f, -0.00816739f, 0.01880850f, 0.00468500f, -0.01106412f, -0.00692212f, -0.01516272f, 
    0.02313006f, -0.01102220f, -0.00818710f, -0.01930370f, 0.01403180f, 0.01881488f, -0.03421899f, 0.03849892f, 
    -0.00962364f, -0.00373727f, 0.00041938f, 0.01411443f, 0.01473544f, -0.00810400f, -0.00445566f, 0.03100995f, 
    0.02001758f, -0.00400638f, -0.02179194f, -0.02545303f, -0.03997730f, 0.02494825f, 0.02930391f, -0.02983208f, 
    -0.01459868f, -0.03162886f, -0.00949576f, 0.02429629f, 0.00511363f, 0.02574329f, -0.02632100f, 0.00860733f, 
    0.01796762f, -0.01212141f, -0.00531554f, -0.01076957f, -0.00003062f, 0.00992529f, -0.00741725f, -0.00480788f, 
    0.02961431f, -0.01585493f, -0.01736415f, -0.03013337f, 0.02861257f, -0.03756548f, -0.02455516f, 0.02089865f, 
    0.02700325f, -0.03070899f, -0.03438137f, -0.03998115f, -0.04475942f, 0.01818620f, 0.01700608f, 0.02682616f, 
    0.00501417f, -0.00474955f, -0.02804477f, 0.02661878f, -0.02788727f, 0.01672358f, -0.00353833f, -0.03315998f, 
    -0.01652435f, 0.01534382f, -0.04166453f, -0.00441860f, 0.02646120f, 0.01224434f, 0.03619487f, 0.00613976f, 
    -0.01049928f, 0.00045957f, -0.02498650f, -0.00863447f, -0.01413803f, -0.01684553f, -0.01023525f, 0.01299748f, 
    0.00805677f, 0.00137995f, 0.00587275f, 0.02112745f, 0.02404347f, 0.00463041f, -0.00371873f, -0.00965563f, 
    -0.01998002f, 0.01248174f, 0.02563768f, 0.03525160f, 0.00829258f, -0.02391408f, -0.02019307f, -0.03424577f, 
    0.01259688f, 0.00888229f, -0.04187630f, -0.00666750f, -0.02692461f, 0.02615332f, -0.02148887f, 0.00993323f, 
    -0.04100113f, 0.01306207f, -0.00222771f, 0.02727211f, 0.02630723f, 0.02026411f, -0.02989345f, 0.02975985f, 
    -0.02933116f, -0.01698591f, -0.03474061f, 0.02481918f, 0.01735113f, 0.00997492f, -0.01473311f, 0.03262153f, 
    0.01901246f, -0.00524396f, 0.02693809f, -0.02733560f, -0.00140357f, -0.02936298f, -0.00214756f, 0.00812383f, 
    0.02333033f, -0.03974829f, 0.02608757f, -0.00687112f, -0.02524985f, 0.01633763f, 0.00981958f, -0.00851605f, 
    -0.03174994f, -0.01343108f, 0.00686600f, -0.03246520f, -0.01191817f, 0.01513412f, -0.02443549f, 0.00173459f, 
    0.00835872f, -0.03649553f, -0.02571411f, -0.03508754f, 0.00616080f, -0.01188056f, -0.01809620f, 0.02181041f, 
    -0.03450313f, 0.02925226f, -0.01101606f, -0.03346707f, -0.01252563f, 0.00210819f, -0.00974210f, 0.00126014f, 
    0.01861457f, 0.02302805f, -0.01094672f, 0.02210703f, 0.02216727f, 0.01696704f, 0.00889857f, 0.02277301f, 
    -0.03937692f, -0.00566936f, -0.02585875f, -0.02326726f, -0.00881622f, -0.01703233f, -0.03126950f, -0.02817616f, 
    0.00278064f, -0.03527281f, -0.00650612f, 0.01067817f, -0.03022573f, 0.02577966f, -0.00710012f, -0.01328015f, 
    -0.02309724f, -0.03240089f, -0.02310239f, -0.02196126f, -0.02380830f, 0.02544292f, -0.02634767f, 0.01499324f, 
    0.02803475f, -0.01018531f, -0.03566708f, -0.01226146f, -0.03023449f, -0.01431565f, -0.01567950f, 0.00612173f, 
    0.00456527f, -0.00389891f, 0.03560953f, -0.01216861f, -0.02820395f, 0.03447368f, -0.02063598f, -0.02783771f, 
    -0.03543674f, -0.03776256f, -0.02941727f, -0.01896695f, 0.00254602f, -0.00409043f, 0.03439920f, 0.01770738f, 
    -0.02776713f, 0.02897736f, 0.00065198f, 0.00297933f, -0.01915735f, 0.00671761f, 0.02436467f, -0.03426672f, 
    -0.00179315f, -0.01812398f, 0.01666152f, -0.01900648f, 0.02444227f, -0.01792441f, -0.00033559f, 0.02156166f, 
    0.01448368f, -0.02418507f, 0.00174640f, -0.00383197f, -0.01444123f, 0.02971007f, -0.02866813f, -0.03285764f, 
    0.02190021f, -0.01679091f, 0.02883172f, 0.00645467f, 0.00376415f, 0.00208528f, 0.01293111f, 0.02528528f, 
    0.02129556f, -0.02388416f, 0.02198856f, -0.00111051f, 0.00777932f, 0.01108947f, -0.03691506f, -0.03312884f, 
    -0.02416451f, -0.00305771f, 0.02337256f, -0.00284878f, -0.02913307f, -0.00477911f, 0.00706471f, -0.03094061f, 
    -0.02034677f, 0.00527606f, 0.00054095f, 0.02357600f, -0.03102212f, -0.04214429f, -0.00223639f, 0.01707332f, 
    0.01221952f, 0.02134939f, 0.00650731f, 0.02815204f, 0.01921307f, -0.01083279f, -0.01448860f, -0.00719922f, 
    0.02900063f, -0.02121786f, -0.01001808f, -0.00518364f, 0.02277311f, 0.00764383f, -0.02056192f, -0.03356978f, 
    -0.04054608f, -0.00530046f, 0.02642975f, 0.00632871f, 0.00695441f, 0.02763284f, 0.02285993f, 0.01507432f, 
    -0.00591339f, -0.03398160f, -0.03421536f, -0.02392624f, -0.03388050f, 0.02150585f, -0.01674677f, 0.01403592f, 
    0.02999622f, -0.03023493f, 0.03153768f, -0.03615171f, -0.00779880f, 0.01393907f, 0.02403728f, -0.03271040f, 
    0.02275860f, -0.01955548f, -0.02720020f, -0.03543496f, 0.03258976f, -0.00101107f, 0.00430883f, -0.00567328f, 
    -0.00658992f, -0.01123872f, 0.01278797f, 0.02295009f, 0.02816910f, 0.02174152f, -0.02957121f, 0.03242972f, 
    -0.01427324f, 0.01240473f, 0.02548992f, -0.03699048f, -0.00324258f, -0.00149263f, -0.03897917f, -0.00361878f, 
    -0.02383403f, 0.03135150f, -0.02882318f, -0.02531146f, -0.00002653f, 0.00667143f, -0.00771994f, -0.02329345f, 
    0.00863698f, -0.00922610f, -0.01653526f, -0.02800994f, -0.00492364f, 0.00765033f, -0.01692247f, -0.04401522f, 
    -0.00416814f, -0.00312923f, 0.03087693f, -0.02671723f, 0.00246283f, -0.01731705f, -0.00942431f, 0.02578476f, 
    -0.02548408f, 0.01326334f, 0.02672079f, -0.01781622f, -0.00291075f, -0.00818540f, 0.00564390f, 0.01200189f, 
    0.01442866f, -0.04819347f, 0.00291936f, -0.03210290f, 0.01096292f, -0.02576418f, -0.02999257f, 0.02085657f, 
    -0.00245865f, 0.02985157f, -0.01822887f, -0.04126128f, -0.01706824f, -0.01734692f, 0.01456918f, -0.00402503f, 
    -0.00108847f, 0.03800892f, -0.01326134f, 0.02468800f, -0.00982879f, 0.02479947f, 0.00501005f, -0.01944016f, 
    -0.03003883f, 0.00471412f, -0.04149421f, -0.01238835f, 0.01864445f, -0.00825135f, -0.04094895f, 0.02076080f, 
    0.00692108f, -0.02910161f, -0.01728430f, -0.01528436f, 0.01699082f, -0.03012902f, -0.02867945f, 0.01660802f, 
    0.01727635f, 0.00133719f, 0.01785064f, 0.00250808f, -0.02320190f, 0.01239719f, 0.01701234f, -0.03830662f, 
    -0.02485275f, -0.02929113f, -0.03779155f, -0.00663984f, 0.01670467f, -0.02605994f, -0.00201939f, 0.00133846f, 
    -0.02203876f, -0.01787359f, -0.00830269f, 0.01495981f, -0.03064376f, -0.00867030f, 0.00367474f, -0.01638459f, 
    -0.01225612f, 0.02164826f, 0.00641797f, -0.00291360f, 0.02309867f, -0.01897446f, 0.01025655f, -0.02225758f, 
    -0.00607891f, -0.03261045f, -0.03466606f, 0.00738415f, -0.01063374f, 0.00494864f, -0.02019930f, -0.01074537f, 
    -0.00178675f, 0.00216290f, -0.02558878f, 0.02772328f, -0.02070948f, -0.02886993f, 0.03189564f, 0.02418477f, 
    0.01158547f, 0.01502958f, 0.02274970f, -0.01558014f, 0.01339399f, -0.01831237f, 0.01296457f, 0.01193877f, 
    -0.00136133f, -0.03422302f, -0.00738663f, 0.01419257f, -0.01750633f, -0.01840994f, -0.03406075f, -0.01960889f, 
    0.02515434f, -0.03383803f, 0.00912983f, 0.01058969f, 0.00257513f, -0.03967671f, 0.00690161f, 0.00051192f, 
    0.01072808f, -0.01862796f, 0.02573933f, -0.02624440f, -0.04889381f, 0.02554169f, -0.02547397f, 0.02581486f, 
    -0.02094397f, 0.02255587f, -0.02797371f, 0.02892669f, -0.03851570f, -0.02251062f, -0.03519503f, -0.01065530f, 
    -0.01986187f, -0.00408988f, 0.01055234f, 0.01291644f, -0.02159242f, 0.01024007f, -0.02180282f, -0.01742784f, 
    -0.04670751f, -0.02957654f, 0.02207782f, 0.00473240f, -0.01135234f, 0.02345363f, 0.01386594f, 0.02296479f, 
    -0.02150225f, 0.02936283f, -0.01598273f, 0.02670472f, 0.00200304f, 0.02862736f, 0.01013731f, 0.00392628f, 
    0.01141673f, -0.02787104f, -0.01915277f, 0.01090442f, -0.02796410f, -0.01456095f, -0.02893312f, -0.01456748f, 
    0.03081196f, -0.00290037f, -0.02943253f, -0.01515953f, -0.03191665f, 0.02809808f, 0.01700037f, -0.01281924f, 
    -0.02603940f, 0.00969695f, -0.00238835f, -0.01918451f, 0.02021794f, 0.02722075f, 0.01575423f, 0.02406552f, 
    -0.00287552f, -0.02739357f, -0.00150331f, 0.02086531f, 0.01958887f, -0.00148666f, 0.01964444f, 0.01379360f, 
    0.01637019f, -0.01990594f, 0.00382425f, 0.01869808f, 0.01552848f, 0.00787702f, -0.03725350f, 0.00987526f, 
    -0.03661391f, -0.01677287f, 0.00519435f, -0.01568407f, -0.00170015f, -0.00429497f, -0.03893536f, -0.00212703f, 
    -0.03945084f, 0.01728993f, -0.00389646f, -0.02042472f, 0.02637426f, -0.02873958f, 0.02099475f, 0.02666396f, 
    -0.00840415f, -0.00375749f, -0.01886211f, 0.02946013f, 0.00975899f, -0.00790564f, 0.00783091f, 0.02025623f, 
    -0.03633023f, -0.01467224f, 0.00196076f, -0.00599798f, -0.03482250f, -0.00380293f, -0.02718469f, -0.02516271f, 
    -0.03367166f, 0.03300419f, -0.00601690f, -0.01139941f, -0.03633998f, -0.03160149f, -0.00063289f, -0.01548460f, 
    0.00048690f, -0.03986095f, -0.00717800f, -0.02595698f, -0.02539357f, 0.01774315f, 0.00156937f, -0.02849028f, 
    -0.02629172f, -0.02270528f, 0.02675948f, 0.03394348f, 0.00914125f, -0.03537410f, 0.00667583f, -0.00284164f, 
    0.02802106f, -0.04073565f, -0.00320637f, 0.02305759f, 0.00516103f, 0.02044191f, -0.04332843f, -0.01531968f, 
    -0.01569244f, -0.01872316f, 0.00860080f, 0.02759868f, -0.02983375f, -0.04271458f, -0.03562462f, -0.01390018f, 
    -0.03841584f, 0.01976789f, 0.01303674f, 0.02019852f, -0.01002585f, -0.02323604f, -0.03069012f, 0.01290203f, 
    -0.00598242f, 0.00798542f, -0.00355917f, -0.01997525f, -0.01466229f, 0.00612140f, -0.04187535f, 0.00970727f, 
    0.03869662f, -0.03990353f, 0.02801796f, 0.02129981f, 0.00449783f, 0.02741893f, 0.02150806f, 0.01668931f, 
    0.00822692f, 0.02852728f, 0.03315091f, 0.00862036f, -0.00988416f, -0.04045868f, -0.00217542f, 0.00425464f, 
    0.01943307f, -0.00620305f, -0.00389834f, -0.00325566f, -0.01325341f, 0.02059177f, 0.01045198f, -0.01688632f, 
    -0.00810554f, -0.04007055f, 0.00588388f, 0.00992843f, 0.02220762f, -0.02571743f, -0.02199379f, 0.00688457f, 
    -0.02538950f, 0.00172415f, -0.00829224f, -0.00544846f, 0.01512117f, -0.00406770f, -0.03473267f, -0.01154900f, 
    -0.03411820f, 0.02183127f, 0.02608806f, -0.00996564f, 0.02947932f, 0.01588244f, -0.02851916f, 0.00446320f, 
    -0.01470770f, 0.01747506f, -0.02620214f, 0.00513046f, 0.00690850f, 0.01561311f, -0.02429985f, 0.00189312f, 
    -0.00143961f, -0.04091548f, -0.01174178f, 0.02124726f, -0.00079774f, 0.02873280f, -0.00153417f, -0.00971892f, 
    -0.03528620f, -0.02866381f, 0.00430804f, -0.00075486f, -0.00817854f, 0.01284465f, 0.02320670f, -0.03828197f, 
    0.01315729f, 0.02072880f, 0.02037243f, -0.01981852f, 0.00817727f, -0.00293918f, 0.03380621f, -0.03066450f, 
    0.00263723f, -0.01376141f, -0.00192370f, 0.02017426f, -0.03542863f, 0.02443317f, -0.03162984f, 0.00701474f, 
    0.00269881f, -0.02475040f, -0.02076824f, -0.01876646f, -0.00279293f, 0.00419568f, -0.01261299f, -0.02119066f, 
    0.01320716f, -0.03000092f, 0.02525283f, 0.01478880f, -0.01503744f, 0.01325840f, 0.00658451f, 0.01465444f, 
    0.01059443f, 0.00745200f, 0.03609191f, -0.00764677f, 0.01644211f, -0.02076417f, -0.00295667f, -0.01670406f, 
    0.01738149f, -0.03920123f, -0.00778729f, 0.02564258f, -0.01150604f, -0.02419717f, 0.01048695f, -0.03592712f, 
    -0.02552754f, 0.02175148f, 0.00042156f, 0.02905148f, -0.03453126f, -0.03779769f, -0.00263615f, 0.02236525f, 
    0.01139413f, 0.02651570f, 0.01769982f, 0.01784329f, -0.00661281f, -0.01916063f, 0.00482324f, 0.03013066f, 
    -0.00045296f, -0.02376324f, 0.00722842f, -0.03386504f, 0.00057726f, 0.02340438f, -0.00728516f, 0.02104883f, 
    0.01421419f, -0.01859185f, -0.03617865f, 0.01607288f, 0.00924554f, -0.02513543f, 0.01547452f, 0.01785471f, 
    0.01858917f, 0.00918654f, 0.03122848f, -0.00224823f, -0.00032457f, 0.01863232f, 0.03212367f, -0.03493118f, 
    0.01711274f, -0.03223833f, 0.00135040f, -0.02484572f, -0.02604734f, 0.01554391f, 0.02624915f, 0.00896822f, 
    -0.01922169f, 0.03549999f, 0.02400947f, 0.01085084f, 0.00410986f, -0.00369530f, -0.00851679f, 0.00030018f, 
    -0.04024094f, -0.03996968f, 0.01208803f, 0.02713099f, 0.02675443f, 0.00520568f, 0.00803840f, -0.01352343f, 
    0.01922233f, -0.03536150f, -0.02538780f, 0.01091265f, -0.00464679f, -0.04217124f, 0.02318823f, 0.02692406f, 
    0.01614840f, 0.02096758f, -0.02989591f, -0.00110875f, 0.02439319f, 0.02317112f, -0.02082970f, 0.01929090f, 
    -0.03160154f, -0.03415640f, -0.01988544f, -0.02051991f, -0.02912133f, -0.01480262f, 0.00978980f, -0.00173368f, 
    0.01665062f, -0.00185682f, 0.02258338f, 0.01061910f, 0.02868771f, 0.02525015f, 0.02547922f, -0.02815571f, 
    -0.03142383f, 0.01569917f, 0.03141016f, 0.00277233f, 0.02933075f, 0.00408710f, 0.03147056f, -0.01303845f, 
    0.00507526f, 0.01240866f, 0.00157768f, 0.03038333f, -0.03448548f, -0.00943690f, -0.02191018f, -0.03133121f, 
    -0.03777608f, 0.00470173f, -0.00595719f, 0.00690238f, -0.01615722f, -0.01459427f, 0.02834893f, -0.02597932f, 
    -0.00577565f, -0.03737455f, 0.02080505f, 0.02934131f, -0.01605957f, 0.01798151f, 0.03023487f, -0.02253523f, 
    -0.00337776f, 0.01604140f, -0.03014035f, -0.00157543f, 0.02042194f, -0.00705127f, -0.03390215f, -0.00022404f, 
    -0.02487608f, -0.03134048f, 0.00705490f, -0.00100291f, -0.03482001f, -0.02227306f, 0.02128751f, 0.01547744f, 
    0.01720447f, 0.03038293f, -0.01798181f, 0.02354211f, 0.02251138f, 0.02505238f, -0.00190767f, 0.00273693f, 
    -0.02008471f, -0.02197947f, -0.01644803f, -0.01459312f, -0.01091307f, 0.01314713f, -0.03682299f, -0.03042610f, 
    -0.00500407f, 0.00271444f, 0.01936328f, -0.00554250f, -0.04376158f, -0.03177027f, 0.02281825f, -0.00533641f, 
    -0.02363157f, 0.03546189f, -0.01917164f, -0.01815077f, 0.02514591f, -0.01927287f, -0.03327122f, -0.00059063f, 
    0.00875703f, 0.02438146f, 0.01345604f, 0.01451353f, -0.04103724f, -0.00423877f, -0.03460369f, -0.02991155f, 
    0.01901674f, 0.01535665f, -0.03666685f, 0.01185276f, -0.00068526f, -0.03854848f, 0.00671932f, -0.02371774f, 
    0.00861876f, 0.01492137f, -0.01751154f, 0.00958302f, -0.03361072f, -0.03834904f, -0.00245716f, 0.03103994f, 
    -0.03532237f, 0.03164790f, -0.00716468f, -0.02255226f, -0.04168700f, -0.03386860f, -0.03199348f, 0.01538283f, 
    -0.01307459f, 0.01808639f, 0.01446419f, -0.02360700f, 0.03047869f, -0.00858876f, -0.00727475f, 0.02213203f, 
    -0.02127354f, 0.01956870f, 0.03122515f, -0.01116277f, -0.03009621f, -0.02702018f, -0.01332343f, -0.03063890f, 
    -0.02754341f, -0.01703964f, -0.00325544f, -0.00722237f, 0.01199661f, -0.02140287f, -0.01350498f, 0.02283944f, 
    0.02248628f, -0.01508009f, 0.01971414f, -0.03462472f, -0.02081904f, 0.01071123f, -0.02987628f, 0.02934060f, 
    0.00421587f, 0.00071971f, -0.02896303f, 0.00444906f, 0.01820692f, -0.01601558f, -0.03247544f, 0.00958973f, 
    0.00456836f, 0.01894209f, -0.01533896f, -0.01583501f, -0.02560664f, -0.03236989f, 0.03175812f, 0.02268269f, 
    0.01900534f, 0.02051388f, -0.04177749f, 0.02388996f, 0.02837661f, -0.00782165f, 0.00281343f, -0.02333552f, 
    -0.00029725f, -0.03253460f, -0.01020535f, 0.01450972f, 0.03031638f, -0.00580893f, 0.00295675f, 0.01440718f, 
    -0.04072931f, -0.00750595f, 0.01485477f, 0.02417617f, -0.03566674f, -0.04058120f, 0.02392010f, -0.01604989f, 
    -0.02450465f, 0.00426406f, -0.02056513f, -0.01746192f, -0.03759407f, -0.02947829f, -0.00822240f, -0.00836825f, 
    0.02803885f, 0.00741907f, 0.02295220f, 0.00173658f, 0.00539834f, -0.00592444f, -0.02001801f, -0.03363595f, 
    0.00953603f, 0.01704448f, -0.01647728f, -0.02536883f, -0.03046379f, 0.01547338f, 0.00443834f, 0.01692780f, 
    0.00468239f, -0.03373501f, 0.01971940f, -0.00226137f, -0.02996454f, 0.01600246f, -0.01231449f, 0.01859074f, 
    -0.01436872f, -0.00535223f, 0.02401808f, -0.03001653f, 0.00456152f, -0.00411855f, -0.03742927f, -0.01398415f, 
    0.01533144f, -0.02296057f, -0.01241583f, -0.01979969f, -0.01907978f, -0.03257800f, 0.00409980f, -0.03288961f, 
    0.01645811f, -0.02839780f, 0.00254266f, -0.03087347f, 0.01704720f, -0.00423869f, 0.03465477f, 0.03156691f, 
    -0.04371273f, 0.01673179f, 0.03350587f, -0.03263743f, -0.01223815f, 0.01578750f, -0.01590834f, 0.01246812f, 
    0.00913168f, -0.01508281f, -0.03584821f, -0.00502345f, -0.01693216f, -0.02145772f, -0.02519059f, -0.01409809f, 
    0.03085607f, 0.00631207f, -0.02413959f, -0.01941757f, -0.04042002f, -0.01511306f, -0.02576023f, -0.03666860f, 
    -0.03989353f, -0.03689177f, -0.04087917f, 0.00003192f, 0.00206802f, -0.02464787f, 0.03808197f, 0.02581667f, 
    0.01500694f, -0.02370151f, -0.00184093f, 0.01657251f, 0.00916986f, -0.00583382f, -0.00665595f, 0.01691390f, 
    -0.02400339f, -0.03490271f, 0.01011629f, -0.00077332f, 0.02891007f, -0.03084213f, 0.02215492f, 0.00152898f, 
    -0.00545011f, 0.02064171f, 0.00368511f, 0.01595270f, 0.01684145f, -0.01490800f, -0.00364075f, -0.03900270f, 
    -0.00375338f, 0.01707571f, -0.01182092f, 0.02362205f, 0.00256825f, 0.01762771f, 0.01621029f, -0.01313773f, 
    -0.00047867f, -0.03291843f, 0.02906855f, -0.02379883f, -0.02092832f, 0.02252793f, -0.02538790f, 0.01901704f, 
    -0.03638768f, -0.01377991f, -0.02222729f, 0.01791610f, 0.01556253f, 0.01275387f, 0.01995201f, 0.01533155f, 
    0.01110690f, -0.02615999f, 0.00189021f, -0.01361763f, -0.00399199f, -0.02981896f, 0.00445780f, 0.02357576f, 
    0.00451350f, 0.02626482f, -0.00353572f, 0.02266794f, 0.02707700f, 0.01904651f, 0.03210877f, -0.00278655f, 
    -0.01483754f, 0.00151657f, -0.02874406f, -0.03176871f, -0.00049171f, 0.00024579f, 0.01674127f, 0.00521045f, 
    0.02380390f, -0.02857424f, -0.01308915f, -0.01466412f, 0.01878853f, -0.00608271f, -0.01099435f, -0.00472511f, 
    -0.00031631f, 0.00527161f, -0.00061988f, 0.02903741f, -0.01731448f, 0.00727770f, -0.02393189f, -0.03658709f, 
    0.01644011f, 0.00507719f, 0.01746537f, 0.01880082f, 0.02031839f, -0.03230042f, 0.01259544f, -0.00347303f, 
    -0.01518740f, -0.04318605f, -0.02366867f, -0.02224577f, -0.00640341f, -0.03160568f, -0.01277057f, -0.01933087f, 
    0.00464301f, 0.01920022f, 0.02270365f, -0.01985810f, 0.00248958f, -0.01465488f, 0.01446124f, 0.01166738f, 
    -0.01937825f, -0.01618137f, 0.02095698f, -0.02503241f, -0.01084923f, 0.01656048f, 0.01796823f, 0.02975002f, 
    0.00269484f, -0.01076040f, 0.00676852f, -0.00982611f, -0.00808266f, 0.02917967f, 0.02424951f, -0.02960737f, 
    0.02958830f, 0.02296422f, -0.00485785f, -0.01202344f, 0.02150791f, -0.01660511f, 0.00199636f, -0.03828084f, 
    0.00780814f, 0.01944950f, 0.01041359f, 0.02908268f, 0.01937233f, -0.03022630f, 0.01907665f, 0.00908875f, 
    0.01756221f, -0.02884826f, -0.03717317f, -0.00744449f, -0.00832356f, -0.02753627f, 0.01014288f, 0.02364349f, 
    0.01748898f, 0.02573725f, -0.00267620f, -0.00230921f, -0.01671628f, 0.00149664f, -0.03243698f, 0.03333391f, 
    -0.03971703f, -0.01918147f, -0.01641027f, -0.01875760f, 0.02137262f, 0.01517886f, -0.03386158f, 0.02440952f, 
    -0.02111263f, -0.01150733f, -0.02946166f, 0.00773097f, -0.01569982f, 0.00592751f, -0.01017522f, -0.01045025f, 
    0.25275147f, -0.21796741f, 0.00326836f, -0.22522631f, 0.07949142f, 0.08466693f, 0.10825123f, 0.04650047f, 
    0.05870043f, 0.03985134f, -0.12912980f, 0.10054728f, -0.20540261f, 0.02065419f, -0.05415301f, -0.16926916f, 
    0.26747036f, 0.13435072f, -0.07468077f, -0.09524433f, -0.06149646f, -0.06027758f, 0.17765404f, -0.06894677f, 
    -0.16438586f, 0.05932340f, 0.07571682f, 0.06686676f, 0.05232804f, -0.01037749f, -0.06966321f, 0.11244921f, 
    -0.00635478f, 0.09783240f, 0.08522709f, 0.15730831f, 0.03192617f, 0.03086641f, 0.04916504f, 0.25916418f, 
    -0.00066541f, 0.09828507f, 0.07902116f, 0.06791250f, 0.08263810f, -0.19369426f, 0.11993872f, 0.09162439f, 
    0.03863988f, -0.08078426f, -0.09794620f, -0.01398203f, 0.08931824f, 0.15265946f, 0.01277242f, 0.01521707f, 
    -0.07736979f, 0.04148441f, -0.12461187f, 0.10304686f, 0.01536864f, 0.27193236f, -0.14215367f, -0.05782315f, 
    0.06535757f, 0.03759527f, -0.01211926f, 0.06867829f, 0.02695306f, -0.11110966f, -0.04016178f, -0.02469905f, 
    -0.54302132f, 0.13452940f, 0.05171920f, -0.05005418f, -0.04856643f, 0.09045164f, 0.04433940f, -0.15581818f, 
    -0.11111560f, 0.11508325f, -0.03936825f, -0.04278637f, -0.00128945f, -0.20793392f, -0.15194185f, 0.07724025f, 
    0.01730197f, 0.12310331f, 0.12635654f, 0.08574980f, 0.08684294f, -0.02291481f, 0.10663022f, 0.13667935f, 
    0.27027377f, -0.12064776f, 0.01074935f, 0.12682012f, -0.07785103f, 0.02473998f, 0.07058249f, -0.16648965f, 
    0.08374015f, -0.03684242f, 0.09435707f, 0.04351985f, -0.19878647f, 0.11220475f, -0.06296333f, -0.15264915f, 
    -0.00423585f, 0.06777189f, -0.08237508f, 0.07006077f, -0.06036201f, -0.00264811f, 0.14565727f, -0.04622019f, 
    -0.18774076f, -0.05944057f, -0.17458400f, -0.07579730f, -0.06438389f, -0.05906320f, 0.03265873f, 0.02662167f, 
    0.02648494f, 0.01158210f, -0.06288201f, 0.08537146f, -0.13423494f, 0.13053231f, -0.22831394f, -0.04998072f, 
    0.08897045f, -0.01833436f, 0.03681042f, 0.22866373f, -0.08376517f, -0.08842082f, -0.13640149f, 0.08518647f, 
    0.36659935f, -0.18169473f, 0.14781529f, 0.36492696f, 0.00736508f, -0.00947495f, -0.11246785f, 0.03400234f, 
    0.11221054f, -0.04962235f, -0.14401993f, 0.06500709f, -0.16809283f, 0.15463106f, 0.29633793f, 0.14134680f, 
    -0.13220881f, 0.14682230f, 0.07599188f, -0.10432170f, 0.22505303f, 0.11438011f, -0.06713676f, 0.11265574f, 
    0.26057890f, -0.04929553f, -0.12750973f, 0.09016462f, 0.05529113f, 0.03363160f, 0.14772634f, 0.12105502f, 
    -0.03686934f, -0.10817792f, -0.11887464f, 0.06460120f, 0.07431595f, -0.04267767f, -0.02449622f, 0.04124222f, 
    -0.02517941f, -0.04219419f, 0.10390963f, 0.10862297f, 0.17264031f, 0.01372140f, 0.01506841f, 0.16742019f, 
    0.20570505f, -0.36792007f, 0.22469571f, -0.06362483f, -0.05368029f, -0.05715224f, -0.02581578f, -0.02757102f, 
    0.20397973f, 0.09274702f, -0.14636031f, 0.13862531f, 0.06426845f, -0.14090553f, -0.14294422f, -0.06995978f, 
    -0.05322530f, 0.14580645f, -0.07974483f, -0.11998679f, 0.02375426f, -0.12837751f, -0.11669721f, -0.01515364f, 
    0.19681484f, 0.01463418f, 0.17995870f, -0.15367892f, 0.03362501f, -0.03868458f, -0.09007400f, -0.06309992f, 
    0.02708510f, -0.01956442f, 0.07822419f, 0.07708720f, 0.06819351f, 0.08616927f, -0.06353026f, 0.08522257f, 
    0.03816932f, -0.03944523f, -0.03267352f, 0.10817062f, 0.07644413f, -0.09623307f, 0.06055042f, 0.11497199f, 
    -0.33581501f, 0.15199372f, 0.06669007f, 0.07904094f, -0.07164121f, 0.03696796f, 0.04622573f, -0.02554687f, 
    0.12412833f, 0.24340315f, 0.09216989f, -0.00926682f, -0.19886541f, 0.01519715f, -0.03276890f, 0.09277015f, 
    -0.00623225f, 0.11183385f, -0.20529647f, 0.07373092f, 0.09698914f, -0.04666704f, 0.13062091f, -0.12731659f, 
    0.16119562f, 0.02102890f, -0.14656624f, 0.19610459f, -0.04214937f, -0.05356822f, 0.03123726f, 0.07520632f, 
    0.10808212f, -0.09957746f, 0.07778322f, -0.03260041f, 0.13469638f, 0.20957977f, -0.04054659f, 0.05637411f, 
    0.00288166f, 0.02497410f, 0.13848269f, 0.04945282f, 0.08314377f, 0.07125825f, 0.08129171f, 0.05492686f, 
    0.06294440f, -0.27739412f, -0.05942696f, -0.07777775f, -0.09040005f, 0.07177602f, 0.13092278f, -0.15638891f, 
    0.08741432f, 0.04826145f, -0.03891250f, 0.00760380f, -0.05370774f, 0.08613060f, 0.13776393f, 0.28328934f, 
    0.01644624f, 0.02120299f, 0.09299450f, 0.05097903f, 0.09821007f, 0.05739453f, 0.01711164f, 0.20113026f, 
    0.09905702f, -0.05783703f, 0.23449576f, 0.17802599f, -0.14311065f, 0.11467751f, 0.05949032f, 0.09143271f, 
    0.01700697f, -0.05579170f, -0.00851344f, 0.00024717f, 0.24356063f, -0.20966314f, 0.33213302f, 0.05414614f, 
    -0.12539926f, -0.05119510f, -0.10623430f, 0.00102278f, -0.07553622f, 0.13324031f, -0.12898679f, -0.00333944f, 
    -0.01059135f, 0.15678124f, 0.01538516f, 0.01355928f, -0.01617282f, -0.00578487f, 0.03682030f, 0.07430574f, 
    0.13656628f, 0.09884849f, 0.13590196f, 0.02609603f, -0.09085628f, 0.01014495f, -0.04273770f, 0.11354736f, 
    -0.07950900f, 0.17866942f, 0.06301142f, -0.08226492f, 0.03637412f, 0.17529695f, 0.21139809f, 0.04119501f, 
    -0.01943874f, 0.13974553f, 0.02088919f, 0.27995235f, 0.01917149f, -0.01362427f, -0.02420969f, -0.03350542f, 
    0.13255690f, 0.06446705f, 0.09367260f, 0.00428925f, 0.14186797f, 0.07063215f, -0.06831422f, 0.19468111f, 
    0.08314740f, 0.10663727f, -0.05550361f, -0.03686747f, -0.04829190f, 0.05050360f, -0.09708710f, 0.10473952f, 
    0.16023052f, 0.03308275f, 0.20138739f, 0.33754066f, -0.10628536f, 0.14661859f, 0.01564313f, 0.00349952f, 
    0.07472394f, 0.02995571f, -0.01909337f, 0.13605599f, 0.08399373f, -0.19090462f, 0.01761711f, 0.06389960f, 
    0.13194805f, -0.00207466f, -0.01619049f, 0.25327143f, -0.03166784f, 0.00196048f, -0.01206096f, -0.05518889f, 
    -0.13724016f, 0.09049223f, -0.08092327f, -0.15067002f, 0.13870563f, -0.05961275f, 0.12554292f, -0.04344297f, 
    0.00908978f, 0.02488491f, 0.06796771f, 0.07976107f, -0.61465824f, 0.23346002f, -0.23091015f, -0.08013232f, 
    0.05097592f, -0.08916926f, -0.13255914f, -0.09079045f, -0.01809851f, 0.01855333f, 0.02876292f, -0.10871196f, 
    -0.08594771f, -0.21293856f, 0.28119868f, 0.05278228f, -0.09223004f, 0.07065371f, 0.01392856f, 0.10240618f, 
    -0.08084165f, -0.00345709f, 0.01237283f, -0.04607630f, 0.14906780f, 0.14342828f, 0.07673711f, 0.20667565f, 
    -0.10552666f, -0.03378610f, 0.14901493f, 0.13581431f, 0.00264707f, 0.13449882f, -0.04000703f, -0.12152793f, 
    -0.05583633f, -0.12273248f, -0.06608506f, -0.00782568f, 0.14486036f, 0.00350659f, -0.20979898f, 0.01483834f, 
    -0.04925698f, -0.08946264f, 0.19158481f, 0.01532681f, -0.25910038f, 0.17188586f, -0.09668294f, 0.01265127f, 
    0.11229684f, -0.02432749f, 0.00610510f, 0.07096987f, -0.04787622f, 0.02848974f, -0.01390918f, -0.00733187f, 
    0.34562707f, -0.39912444f, 0.00007901f, -0.13425191f, -0.09916434f, 0.02649068f, 0.11882280f, 0.10694102f, 
    0.05701402f, -0.18269278f, 0.17821981f, -0.15147455f, -0.02468174f, -0.20598327f, -0.00801949f, 0.14021076f, 
    0.03637030f, -0.07313786f, -0.17409050f, 0.09646387f, 0.03425922f, 0.01085260f, -0.06945612f, 0.20303404f, 
    -0.09703550f, 0.12177520f, 0.02129304f, -0.10577384f, 0.01509761f, -0.02018838f, 0.00806499f, 0.01469168f, 
    -0.13045384f, -0.07451797f, -0.13958892f, 0.05480248f, 0.23310684f, 0.01808255f, -0.00794427f, 0.11828914f, 
    0.02012373f, -0.21309854f, -0.04808776f, 0.04360932f, 0.17331642f, 0.01963601f, 0.05409557f, 0.06320718f, 
    -0.07910292f, -0.04657185f, -0.08489378f, 0.02552310f, 0.02527342f, -0.10384900f, 0.07989851f, 0.01443374f, 
    0.01851220f, -0.09350166f, 0.01167780f, -0.07771354f, -0.02035600f, 0.08925080f, 0.06881545f, 0.27696994f, 
    0.10469621f, -0.13791183f, -0.05353372f, -0.20348847f, -0.05612102f, 0.16718076f, 0.05391032f, -0.09819186f, 
    0.25151089f, -0.19548956f, -0.04431909f, 0.11162180f, -0.00284644f, -0.09579641f, -0.10625883f, 0.00502504f, 
    0.08442360f, 0.00429698f, -0.13530397f, 0.17597882f, 0.27029738f, -0.22242227f, 0.16714245f, 0.11232114f, 
    -0.12091060f, 0.02586912f, -0.03983756f, 0.03420853f, 0.12171761f, -0.00465260f, 0.02668702f, 0.00868115f, 
    0.00074965f, 0.00243612f, -0.26147571f, -0.10495552f, 0.01499025f, 0.09385542f, 0.06167144f, -0.03721245f, 
    -0.00818059f, -0.10969383f, 0.02963024f, -0.11302774f, -0.17460944f, 0.09689648f, -0.03283843f, 0.03918610f, 
    -0.08310580f, 0.10770969f, -0.04754173f, 0.11209924f, 0.15838622f, 0.00443753f, 0.02045890f, 0.03410815f, 
    -0.04236134f, 0.05083221f, -0.10579972f, -0.09082805f, 0.03138560f, 0.01204745f, -0.05742140f, -0.19223680f, 
    0.07018075f, 0.14420286f, -0.09080770f, 0.05217898f, -0.03432421f, 0.03135123f, -0.07884522f, -0.02408438f, 
    -0.00693062f, 0.02290866f, -0.04910962f, -0.02748453f, -0.05542662f, -0.01489190f, 0.07284212f, -0.19135529f, 
    0.21917464f, -0.18416159f, -0.28500050f, -0.14649370f, 0.09679323f, -0.00114337f, -0.00081121f, 0.12406384f, 
    0.04482565f, 0.04501756f, 0.00244528f, 0.06772161f, 0.23468472f, -0.29088843f, -0.01007601f, 0.06780861f, 
    0.00357117f, 0.00136389f, -0.06404202f, 0.11963102f, 0.06444246f, 0.05512667f, 0.08761015f, -0.05639350f, 
    0.38635573f, -0.23624581f, -0.01375110f, -0.02443872f, 0.01818384f, -0.01686579f, -0.09093614f, 0.06251781f, 
    -0.05986661f, -0.01872509f, -0.08154133f, 0.04753184f, 0.16794750f, -0.03151621f, 0.09346393f, 0.14608735f, 
    -0.04969645f, -0.05733691f, -0.11275554f, 0.03752838f, -0.03272320f, -0.14428236f, 0.15982790f, 0.00535884f, 
    0.18035287f, -0.10162311f, -0.07221775f, 0.00716327f, -0.07752789f, -0.08738579f, -0.05416863f, 0.05084353f, 
    0.06040478f, 0.00588786f, 0.07368799f, -0.00426516f, -0.30522850f, -0.13224384f, -0.16237220f, -0.08395384f, 
    0.08005585f, 0.01823821f, 0.15222728f, 0.12067585f, -0.05023349f, -0.08246400f, -0.08629828f, 0.00986591f, 
    0.18604352f, -0.03974763f, -0.03128067f, 0.18245935f, -0.07473252f, -0.00167487f, 0.06552553f, 0.05785552f, 
    -0.09348909f, 0.06515565f, 0.01063513f, -0.00732712f, 0.22972915f, -0.01314773f, 0.22218269f, 0.12738347f, 
    -0.11446081f, -0.04755947f, 0.05538030f, 0.12577410f, 0.03211485f, 0.00569341f, 0.05126428f, 0.15386437f, 
    0.00800638f, 0.02133525f, 0.32396552f, 0.31237933f, -0.10897358f, -0.03778353f, 0.08443265f, -0.02351010f, 
    0.04079796f, 0.12873794f, 0.04977725f, 0.16124192f, -0.07826626f, 0.09808502f, -0.20325786f, -0.13149831f, 
    -0.03652984f, 0.04741420f, -0.07693035f, -0.11371808f, 0.18735516f, -0.04402716f, 0.01305185f, 0.04659098f, 
    -0.06325707f, -0.11342023f, 0.06665043f, 0.09659778f, 0.07565733f, -0.01334763f, 0.05431996f, 0.02917652f, 
    -0.07675485f, -0.06077668f, -0.16525060f, -0.05874844f, 0.14918908f, 0.03154047f, 0.12700963f, 0.16140199f, 
    -0.08818196f, -0.09714246f, 0.00692015f, 0.10171666f, 0.02755372f, -0.03062232f, 0.03700782f, -0.09509955f, 
    -0.03561356f, 0.02611862f, 0.00378997f, -0.01473814f, 0.00266284f, 0.01014914f, -0.03056516f, -0.01061029f, 
    0.00265229f, 0.00102644f, -0.03452859f, -0.01644021f, -0.03181075f, 0.00807760f, 0.03334590f, -0.00688432f, 
    -0.02723004f, 0.01581488f, -0.00074081f, 0.02594077f, 0.01552750f, -0.01302129f, -0.00040600f, -0.01542279f, 
    -0.00152117f, 0.00380154f, -0.03827149f, -0.02042816f, 0.01409589f, 0.01704965f, -0.02723422f, 0.01457071f, 
    -0.00995761f, 0.01627636f, 0.02899232f, 0.00458950f, -0.02165064f, -0.00807219f, -0.04075469f, -0.02570345f, 
    -0.02686931f, -0.02508493f, -0.02835499f, -0.03056785f, -0.03526028f, -0.00217941f, -0.00748674f, -0.00460054f, 
    -0.02157045f, 0.02830187f, -0.02816044f, 0.02651115f, -0.00772548f, -0.03328899f, -0.03684121f, 0.02098059f, 
    0.01360264f, -0.00561887f, -0.02967026f, -0.01290107f, -0.03028946f, 0.01877985f, -0.01039823f, -0.02936812f, 
    0.02875890f, 0.00065195f, -0.02443307f, -0.00112356f, 0.00032038f, -0.03705237f, -0.01221757f, 0.01429195f, 
    0.02296375f, -0.03184142f, 0.02037145f, 0.00536142f, 0.00273929f, -0.00552424f, 0.01085680f, -0.02949696f, 
    0.00956305f, -0.02249650f, 0.02389616f, 0.01586936f, 0.02044235f, 0.01548283f, -0.03835554f, 0.02735895f, 
    -0.01230519f, -0.03670070f, 0.01280271f, -0.03507541f, -0.00099459f, -0.03044099f, -0.03353242f, -0.01275492f, 
    -0.03795537f, -0.02549052f, -0.01754276f, -0.01247833f, -0.03788317f, -0.04207388f, -0.02272932f, -0.00014355f, 
    0.01291243f, 0.02123871f, -0.02581158f, 0.01804395f, -0.01912994f, -0.00208007f, -0.01350304f, 0.02196224f, 
    0.01774940f, -0.01842467f, 0.00840218f, 0.00660960f, 0.02871087f, -0.00957229f, 0.01645784f, -0.03561481f, 
    0.02772938f, 0.02179326f, -0.00796308f, 0.01383723f, -0.01412958f, 0.02917266f, 0.01664034f, -0.03652648f, 
    -0.03728160f, -0.02992868f, -0.01810734f, -0.00586230f, -0.00579113f, -0.01641639f, -0.00849761f, 0.01565806f, 
    0.00948827f, -0.02150589f, 0.02991699f, -0.02111897f, -0.03905074f, -0.02838702f, 0.00188484f, 0.01682338f, 
    0.02198429f, -0.01335130f, -0.04071492f, 0.02163846f, 0.02423461f, -0.01499121f, 0.00851237f, -0.01432575f, 
    0.00231121f, -0.04092943f, -0.04176592f, 0.01752437f, -0.01315549f, 0.02497717f, 0.00626495f, -0.00187762f, 
    -0.03002090f, -0.03007446f, -0.02962290f, 0.00527880f, 0.02490790f, 0.02750022f, 0.01185705f, 0.02689935f, 
    0.01951621f, -0.01575900f, 0.00865107f, -0.03723019f, -0.01308143f, 0.00086695f, 0.01610309f, -0.00752054f, 
    0.00729425f, -0.02811594f, -0.02323007f, -0.01052476f, 0.00171638f, 0.02016574f, -0.02946864f, -0.00981417f, 
    0.02397902f, -0.04094898f, 0.01457202f, -0.00148341f, -0.00997320f, 0.02254162f, -0.02383500f, 0.01487179f, 
    0.01966809f, 0.04141315f, -0.01351778f, 0.01484513f, 0.01184744f, -0.01122272f, -0.00053965f, 0.01714913f, 
    -0.00148801f, -0.03970250f, -0.02194769f, 0.01183671f, -0.02408025f, -0.03614542f, 0.00490135f, 0.01155632f, 
    -0.01268965f, -0.02483396f, -0.01332886f, -0.00212080f, -0.00475002f, 0.00520302f, -0.03756927f, -0.00193784f, 
    0.00187892f, -0.02580042f, 0.00005170f, 0.01487990f, -0.01678094f, 0.00990022f, 0.00145011f, -0.02281646f, 
    0.01268952f, 0.02820655f, 0.02025291f, 0.02342291f, -0.00037693f, 0.00769003f, 0.04128454f, 0.02066435f, 
    -0.00219061f, -0.04196283f, -0.01124851f, -0.03709026f, -0.01815780f, -0.01778560f, -0.03559351f, 0.01140553f, 
    -0.01386741f, 0.02444424f, 0.02692365f, 0.01045526f, -0.03341873f, 0.00092542f, 0.01812721f, -0.02962857f, 
    -0.02449482f, -0.02648245f, -0.00253488f, 0.00305471f, 0.00073492f, -0.01542825f, -0.02982244f, 0.02818109f, 
    -0.04085276f, -0.03706061f, -0.00608543f, -0.00099365f, 0.01679040f, -0.01654609f, 0.02676553f, 0.02886069f, 
    -0.00337460f, 0.01779170f, -0.01023600f, -0.03872948f, -0.00340855f, -0.00951850f, 0.00447601f, 0.02011544f, 
    -0.03700825f, 0.01113068f, -0.04131144f, -0.03342346f, -0.00488890f, -0.01387878f, 0.01494458f, -0.00537537f, 
    0.02732302f, 0.00839873f, 0.02007457f, -0.00648240f, -0.04195540f, -0.02133140f, 0.01076707f, 0.01960095f, 
    -0.02621015f, -0.03091777f, 0.00098523f, -0.03235244f, -0.01818532f, -0.02806495f, 0.00536026f, 0.02768566f, 
    -0.02189627f, -0.03923431f, 0.00722201f, 0.02863973f, -0.00437493f, 0.00490637f, -0.03111764f, -0.02768802f, 
    -0.02403452f, 0.01604652f, -0.03648769f, 0.02086987f, -0.00485735f, -0.03334748f, -0.03111441f, -0.01400296f, 
    -0.02904651f, -0.03712160f, 0.01562604f, -0.00278301f, -0.01208627f, -0.01075214f, 0.02765923f, 0.00601507f, 
    0.02553886f, -0.02260048f, 0.01950016f, 0.02587676f, 0.01107303f, 0.01650556f, -0.01351737f, -0.02568949f, 
    0.02835100f, -0.01430307f, -0.00531000f, -0.03602693f, -0.00092838f, -0.03084612f, 0.03831553f, -0.02883245f, 
    -0.02977063f, -0.03252924f, 0.00976143f, 0.02875233f, 0.02166701f, 0.01683760f, 0.00196833f, -0.03024409f, 
    0.00257168f, -0.03259948f, 0.00999615f, 0.02862664f, -0.03903336f, 0.02895244f, -0.03252945f, 0.01694454f, 
    -0.03669557f, -0.01829402f, -0.02377939f, -0.00407030f, 0.02695584f, 0.01011357f, -0.02524569f, -0.01992141f, 
    -0.00826584f, 0.00401815f, -0.00076058f, -0.02212627f, 0.00456277f, -0.03309343f, 0.01830528f, -0.03457813f, 
    -0.02894860f, -0.04079134f, -0.04201688f, -0.01641992f, -0.02421004f, 0.00161272f, -0.03334898f, -0.03415255f, 
    0.02007434f, -0.03279822f, -0.01830287f, -0.01639435f, 0.01541714f, -0.02571409f, -0.01510212f, -0.01969792f, 
    -0.01420610f, 0.02064365f, 0.00000058f, 0.02559891f, -0.01247832f, 0.00700949f, 0.01047661f, 0.00034418f, 
    -0.03725855f, -0.01640490f, -0.01078722f, 0.00438505f, -0.02433749f, -0.01538518f, -0.00709101f, -0.03908661f, 
    0.00649816f, -0.00133454f, -0.01773704f, -0.01587175f, -0.00502434f, -0.00746911f, -0.01896420f, 0.01848718f, 
    -0.04177413f, 0.02578748f, 0.02702276f, -0.03523275f, 0.01074855f, -0.00515211f, -0.01068167f, -0.04172107f, 
    0.00407562f, -0.02217728f, -0.01651235f, -0.02819570f, -0.01954331f, 0.02966960f, -0.00127309f, 0.00931670f, 
    0.00032946f, 0.02384357f, 0.00218470f, -0.01235547f, -0.03243474f, 0.01085636f, -0.00512678f, -0.03263419f, 
    0.02024584f, 0.02950410f, -0.00813123f, -0.03940650f, 0.01988740f, -0.01003948f, -0.00108041f, 0.00443394f, 
    0.01949234f, 0.01513018f, 0.01696190f, -0.01213458f, -0.00688690f, -0.01438257f, 0.02758454f, 0.01506369f, 
    -0.01144280f, -0.01730320f, -0.01752368f, -0.02148133f, 0.00810049f, 0.02078346f, 0.00664199f, -0.03360512f, 
    0.02525744f, -0.03806475f, -0.03162946f, -0.01323362f, -0.01424885f, -0.02786957f, 0.00388618f, -0.01787506f, 
    0.01244173f, 0.00971884f, 0.01185064f, -0.01235990f, -0.00752842f, -0.02290234f, -0.03582718f, -0.03271585f, 
    -0.03881874f, 0.00589455f, 0.00896785f, -0.00862128f, 0.00158192f, -0.02041101f, 0.00394620f, -0.03167466f, 
    0.02070735f, -0.03977043f, -0.00339858f, -0.02950690f, -0.00403065f, -0.03272008f, 0.00897569f, 0.01477461f, 
    -0.02941928f, -0.01446810f, 0.01750571f, -0.01459821f, 0.01816259f, -0.02860532f, -0.03408475f, -0.01446228f, 
    0.01897995f, -0.00407472f, 0.02067190f, -0.00771885f, -0.02923953f, 0.00277748f, -0.00782228f, -0.02820185f, 
    0.02868452f, 0.02370466f, -0.01334423f, -0.02083120f, -0.03086831f, -0.04141747f, -0.00872984f, 0.02932141f, 
    0.01159687f, 0.02401944f, -0.01846363f, 0.02379880f, -0.03139420f, -0.03212508f, -0.03779805f, -0.00402152f, 
    -0.00337773f, -0.02805738f, 0.00273245f, -0.00890953f, 0.01473329f, 0.00765340f, 0.02063731f, -0.03054799f, 
    -0.03420949f, 0.02688932f, 0.01523276f, 0.02226818f, -0.04181350f, -0.01890941f, -0.01891255f, 0.00972434f, 
    -0.03443262f, 0.01401120f, 0.00099615f, -0.03006494f, -0.00366528f, 0.02648465f, -0.02587060f, 0.02386009f, 
    -0.03819394f, -0.02239051f, -0.00195106f, -0.02762374f, -0.00236251f, 0.02177142f, 0.01826202f, -0.03310378f, 
    -0.03383250f, -0.00926878f, -0.02009752f, 0.00064553f, 0.01426540f, -0.02215433f, -0.03692435f, 0.02636635f, 
    -0.02674405f, 0.01661998f, -0.01823935f, 0.00656328f, 0.02259394f, -0.00388342f, -0.00020143f, 0.01011312f, 
    0.01454646f, 0.02827788f, 0.01952025f, 0.01784705f, -0.01460900f, 0.02486747f, 0.00432549f, -0.04042485f, 
    0.03004788f, 0.02792519f, -0.04155961f, -0.03199998f, -0.00158138f, 0.01089877f, -0.03719119f, -0.01925822f, 
    -0.03487122f, -0.02530770f, 0.00239163f, 0.01495420f, -0.03786740f, -0.00973807f, -0.04062809f, -0.01103602f, 
    -0.01034789f, 0.00750859f, -0.01018084f, -0.03152798f, -0.01297631f, 0.01130321f, -0.03862945f, -0.02392275f, 
    0.00669819f, -0.00181454f, 0.01898084f, 0.01466590f, 0.02280816f, 0.00729416f, 0.02732811f, 0.00462158f, 
    0.02581913f, -0.00451843f, -0.04059833f, 0.00699668f, -0.03312754f, 0.00680770f, 0.01940033f, -0.00283607f, 
    -0.01617135f, -0.03566439f, 0.00121711f, 0.00859653f, 0.00602995f, 0.01855185f, -0.00046668f, 0.02748748f, 
    0.02937145f, 0.02079675f, -0.01741514f, -0.03317537f, -0.00950388f, -0.00592182f, -0.01791888f, -0.01678384f, 
    -0.03698659f, 0.01059989f, -0.03139239f, -0.04160671f, 0.02028962f, -0.03276591f, -0.01917954f, 0.02729203f, 
    -0.00941215f, -0.00328493f, 0.01718170f, 0.02098119f, 0.01900281f, 0.00034219f, -0.02046115f, 0.00573774f, 
    0.00273043f, -0.03793196f, 0.00038038f, 0.00410229f, 0.02333843f, 0.00554331f, 0.00052397f, -0.02347228f, 
    -0.01546483f, 0.02114156f, 0.00405034f, -0.02764542f, -0.03362055f, 0.02942238f, 0.01067960f, 0.01291638f, 
    -0.01211295f, 0.02554890f, -0.00336423f, -0.00727661f, -0.03701729f, -0.00950385f, 0.00434312f, 0.00846868f, 
    -0.01153184f, 0.03586386f, 0.00426655f, -0.03728498f, -0.01218762f, -0.03598294f, -0.03286385f, 0.02152008f, 
    0.01743336f, -0.02527806f, -0.03548272f, -0.03451018f, -0.03969293f, 0.00577724f, -0.01058835f, -0.01865892f, 
    0.02992984f, 0.00432747f, -0.02469645f, -0.03161341f, -0.03253841f, 0.02577904f, 0.02252129f, -0.01335367f, 
    0.01375450f, -0.01382448f, 0.01179617f, -0.01032407f, -0.01859211f, -0.00618322f, 0.01369431f, 0.01157582f, 
    -0.03711745f, -0.03216059f, 0.01423854f, -0.00632557f, -0.02180651f, 0.01854626f, 0.01170580f, 0.00810326f, 
    -0.02842976f, -0.01002882f, -0.02799134f, 0.00071176f, -0.03393431f, -0.01152002f, 0.02743918f, 0.00988988f, 
    -0.01336597f, -0.02056416f, -0.02885029f, -0.01313189f, -0.00476106f, -0.03684995f, -0.00520672f, 0.00866506f, 
    0.00926908f, 0.01500079f, 0.02305320f, 0.02196253f, 0.00511546f, -0.02698491f, 0.01724204f, -0.02756521f, 
    0.01644898f, 0.00673798f, -0.03636847f, 0.02465676f, 0.00527466f, -0.03979709f, -0.03379301f, 0.00809572f, 
    -0.02266643f, 0.01439325f, -0.04167181f, -0.03927440f, -0.00874788f, -0.02240770f, -0.03641176f, -0.03185490f, 
    -0.03657352f, -0.01386394f, -0.01872264f, -0.03905185f, 0.00132730f, 0.01017323f, 0.01988540f, 0.02445793f, 
    -0.03199918f, -0.01538792f, 0.01271642f, -0.02123517f, -0.01391044f, -0.00778919f, 0.01924841f, 0.01440156f, 
    0.00249465f, 0.01693068f, -0.00108998f, -0.02695003f, -0.03124882f, -0.01113968f, -0.01660696f, 0.01032372f, 
    -0.03053346f, -0.02772929f, 0.00008331f, 0.02900249f, -0.02699114f, -0.03845799f, 0.00492942f, -0.01946981f, 
    -0.00677301f, 0.00123922f, -0.01304422f, -0.03892466f, -0.00607054f, -0.04504503f, -0.02531394f, -0.00488326f, 
    0.00056170f, 0.01886760f, -0.04387776f, -0.04371050f, -0.03046149f, 0.00903617f, 0.02281513f, -0.01078911f, 
    -0.04259738f, -0.00118511f, -0.00384698f, -0.03113370f, -0.04005739f, -0.01554622f, 0.00317240f, 0.01554089f, 
    0.01522107f, -0.03857142f, -0.01991659f, -0.03960202f, -0.01838283f, 0.01774959f, -0.00096482f, 0.00907562f, 
    -0.00546662f, 0.01134544f, -0.02748338f, 0.02070747f, -0.04159988f, -0.00765022f, -0.02639566f, -0.01961608f, 
    0.01987547f, -0.03433862f, 0.01118195f, -0.03947195f, -0.02033231f, -0.00295610f, -0.03221981f, -0.03722036f, 
    0.01269854f, -0.01767592f, -0.04192341f, 0.00656273f, 0.01069366f, -0.00886645f, -0.01951020f, -0.02461518f, 
    -0.01619017f, -0.04133712f, 0.01988437f, 0.01355724f, -0.03593554f, -0.04592181f, -0.04037997f, -0.04112641f, 
    -0.03494291f, -0.00305428f, 0.00758740f, 0.01109322f, -0.00740558f, 0.03887277f, -0.01549303f, -0.02950719f, 
    -0.01331550f, 0.00304110f, -0.02472795f, 0.00691826f, 0.00415255f, -0.02982157f, -0.01891086f, 0.02029402f, 
    0.00854254f, 0.00506411f, -0.02545819f, -0.04139803f, -0.01832027f, -0.01414019f, 0.01534009f, -0.03548266f, 
    -0.04349373f, -0.01479032f, 0.01172255f, -0.00160541f, -0.02779873f, 0.03616248f, 0.01301757f, -0.04357115f, 
    -0.00165144f, -0.00869474f, -0.02561663f, -0.01603319f, -0.00889431f, 0.03543771f, 0.01336264f, -0.02580342f, 
    -0.00225273f, -0.00330431f, -0.00253200f, -0.01045753f, -0.03326800f, -0.00758560f, 0.03338822f, -0.03979193f, 
    -0.02627885f, -0.02194973f, 0.02142317f, -0.01409092f, -0.02968681f, 0.01190751f, -0.00031358f, 0.02299376f, 
    -0.01832217f, 0.01583221f, -0.01011825f, -0.01537133f, -0.04294353f, -0.03251254f, -0.04080976f, 0.02257095f, 
    -0.04253716f, 0.01292266f, -0.00132645f, 0.02313247f, -0.00769341f, 0.02241949f, -0.03763298f, 0.02473755f, 
    -0.03111135f, 0.00095447f, -0.00024116f, -0.03253813f, 0.01307830f, -0.03409189f, -0.00782420f, 0.00256556f, 
    -0.02191273f, 0.00276899f, -0.03155715f, -0.02590572f, 0.01899923f, 0.02184539f, 0.02240893f, -0.02998934f, 
    0.02260228f, -0.01390697f, 0.02573166f, 0.02205175f, 0.01642612f, -0.01456619f, -0.01367414f, 0.01305657f, 
    0.00762184f, -0.02527426f, -0.00035341f, -0.04668392f, -0.01689966f, 0.00875730f, 0.00386430f, -0.03717260f, 
    -0.02898605f, -0.01074164f, -0.02433390f, -0.02936597f, -0.01980169f, 0.01728482f, 0.00184377f, -0.02266688f, 
    -0.03090588f, 0.00349347f, -0.04485211f, -0.01363622f, -0.00242064f, -0.02662479f, -0.00923846f, -0.00915646f, 
    0.01733842f, 0.02065523f, -0.03807084f, 0.00574123f, -0.02726980f, 0.01583971f, 0.02171567f, -0.02118313f, 
    -0.00496838f, -0.01524003f, -0.01594129f, 0.00484262f, -0.02459263f, -0.01594754f, -0.03648640f, -0.03885218f, 
    0.01919976f, -0.03236235f, -0.00424903f, 0.02389329f, 0.01936699f, -0.01733526f, 0.00999392f, -0.00558714f, 
    0.04490550f, -0.04283866f, -0.01681571f, -0.02195053f, 0.03787180f, -0.04700470f, -0.04675969f, 0.01451894f, 
    0.00302696f, 0.00256846f, -0.00286256f, -0.03955428f, -0.01327907f, 0.01521318f, -0.02783273f, -0.02543879f, 
    0.01060028f, -0.00653753f, -0.01290066f, -0.03393100f, -0.02118713f, 0.01837805f, -0.03169405f, -0.04297048f, 
    -0.03033938f, -0.03532716f, -0.04322678f, 0.00685562f, -0.01471590f, -0.00315670f, -0.03815633f, -0.02235109f, 
    0.00540033f, -0.00144767f, -0.02759927f, -0.00152664f, 0.02673591f, -0.00400474f, 0.01558482f, -0.01121750f, 
    -0.02632874f, -0.04123114f, -0.04132208f, -0.01945684f, -0.01202624f, -0.02212858f, 0.01547367f, -0.02636225f, 
    0.02418083f, 0.01694508f, -0.00004742f, 0.01548793f, -0.01495932f, -0.00538699f, -0.03659116f, -0.03010636f, 
    0.01755642f, -0.01470762f, -0.00226949f, 0.01630688f, -0.01401661f, -0.04377339f, -0.04053466f, -0.04141280f, 
    0.01873250f, -0.03172310f, -0.01656954f, -0.02989117f, -0.01303180f, 0.02186793f, -0.01368767f, -0.02739849f, 
    -0.00024786f, -0.02941738f, -0.02947096f, 0.02873436f, -0.03830657f, -0.00527270f, -0.04088700f, 0.02225786f, 
    -0.01975857f, 0.02369354f, -0.01869662f, 0.00676794f, -0.01822748f, 0.01243265f, -0.01361424f, -0.02818473f, 
    -0.01387633f, -0.01235646f, -0.03522525f, 0.01952937f, -0.00929410f, -0.02638823f, 0.00765499f, -0.01627233f, 
    0.01844333f, 0.01879255f, -0.04190083f, -0.02658753f, 0.03752026f, -0.01627791f, 0.00605054f, -0.03502593f, 
    -0.04515608f, -0.00468942f, 0.00877623f, -0.00587237f, -0.02915296f, 0.01609660f, -0.02973430f, 0.00259717f, 
    -0.00011489f, 0.00615238f, 0.00717292f, -0.01290714f, -0.02096386f, 0.01691555f, 0.02103512f, -0.01852173f, 
    -0.02057335f, -0.02803784f, -0.00055581f, 0.00522552f, -0.02810362f, -0.00031813f, -0.01811957f, -0.01509139f, 
    -0.01208362f, -0.03502207f, 0.02088354f, 0.00529509f, -0.03157904f, -0.01184030f, 0.00571738f, 0.01039796f, 
    0.02123749f, -0.04337421f, -0.04506414f, 0.02281591f, -0.00165766f, 0.00211983f, -0.02920238f, 0.01164977f, 
    0.03485720f, -0.02747884f, -0.03130574f, 0.01547417f, -0.04271041f, -0.03513413f, -0.00339946f, 0.00224056f, 
    0.01497884f, -0.01703255f, -0.00842522f, 0.00073300f, -0.01507290f, 0.01489533f, -0.03369367f, -0.01534350f, 
    -0.02940425f, -0.02324741f, -0.01239600f, 0.01043644f, -0.02854227f, -0.01545465f, -0.01961828f, -0.02510578f, 
    0.01559804f, -0.02357528f, -0.00122269f, -0.01102908f, -0.01908956f, -0.01937620f, 0.00122441f, 0.01102638f, 
    0.01332371f, 0.02218981f, -0.04560486f, -0.00184097f, -0.02674343f, 0.01604036f, -0.02752876f, -0.04325105f, 
    -0.02779339f, -0.01859078f, -0.03178113f, -0.00824926f, 0.00980202f, -0.00134466f, -0.00059639f, -0.01961944f, 
    -0.03186884f, 0.01141518f, 0.00813467f, -0.01858559f, 0.00623687f, -0.04456529f, -0.03521220f, 0.01231777f, 
    -0.03941249f, -0.02936106f, -0.01205109f, -0.03080207f, 0.01839008f, -0.03420874f, -0.02531778f, -0.03095984f, 
    -0.02696103f, -0.03760065f, 0.01161883f, 0.01925335f, -0.01314925f, -0.04192504f, -0.00416962f, -0.03763052f, 
    -0.00066807f, -0.02227519f, 0.02155383f, 0.02823808f, -0.03409908f, -0.00406790f, 0.01123699f, -0.01085672f, 
    -0.00360035f, -0.03019856f, -0.00101732f, -0.03791860f, 0.01560856f, -0.03099350f, -0.00965010f, -0.04117821f, 
    0.01640261f, -0.03479039f, -0.01186988f, -0.00682741f, 0.00272026f, 0.00293065f, 0.04175958f, 0.01750675f, 
    -0.03823353f, -0.01971504f, 0.01608219f, -0.00753882f, -0.03222627f, -0.00611555f, -0.02557198f, 0.00713775f, 
    -0.02438242f, -0.01001959f, -0.03792396f, -0.00578115f, -0.04573575f, -0.01592262f, -0.00892836f, 0.01597615f, 
    0.01048862f, -0.02705912f, -0.00483035f, -0.00728827f, -0.00264079f, 0.01468161f, -0.02405172f, -0.01084060f, 
    0.00783021f, 0.00756639f, -0.02317276f, -0.03614571f, -0.01005658f, -0.02466781f, -0.01282197f, 0.02179523f, 
    0.00141456f, 0.02102273f, -0.02013694f, -0.04470694f, 0.01723201f, -0.00418604f, -0.01798556f, -0.02830887f, 
    0.00446356f, -0.00583663f, -0.04384389f, -0.02155813f, 0.00039140f, -0.04197767f, 0.00236675f, 0.02642466f, 
    -0.04387226f, -0.00664051f, -0.04587418f, -0.01680455f, -0.01318470f, -0.02206824f, 0.02113762f, -0.02239237f, 
    0.02371025f, -0.01356181f, 0.03070793f, -0.01211987f, -0.00342652f, -0.01508563f, -0.03997332f, -0.01007910f, 
    0.01891412f, 0.00656233f, -0.00682930f, -0.00568280f, -0.03331594f, 0.01793547f, -0.01685019f, -0.02571587f, 
    0.02348034f, -0.03428845f, -0.04235560f, -0.01132127f, -0.03085408f, -0.03494148f, 0.01572445f, -0.00812427f, 
    0.00756591f, -0.01032586f, -0.02653564f, -0.03046719f, -0.04051711f, -0.03360252f, -0.02535050f, -0.03479837f, 
    0.00359845f, 0.02216261f, -0.00404187f, -0.01465852f, -0.04282033f, -0.00291408f, 0.01866554f, -0.02133037f, 
    -0.02403205f, 0.01944946f, -0.02243034f, -0.01903201f, -0.03636245f, -0.00562241f, 0.00616170f, 0.01770193f, 
    -0.03859165f, -0.03939939f, -0.03191886f, 0.01635836f, -0.00482514f, -0.02011099f, 0.01212950f, -0.00589125f, 
    0.00445365f, 0.02896777f, -0.04431572f, -0.04663050f, -0.04062000f, -0.00954620f, -0.04346348f, -0.00441578f, 
    -0.03244556f, -0.02282156f, -0.02781158f, -0.00125492f, 0.00811623f, 0.01971802f, 0.02293911f, 0.00725141f, 
    -0.02726614f, 0.04116826f, -0.01824133f, -0.02582710f, -0.00710706f, -0.02996591f, 0.00497022f, -0.04811816f, 
    0.00918030f, 0.04080489f, 0.00468828f, 0.00958102f, -0.03331151f, -0.03269732f, -0.02955928f, 0.01550681f, 
    0.01010017f, 0.00763706f, -0.00322936f, -0.02202933f, -0.03574908f, 0.00147797f, -0.03534666f, -0.01303844f, 
    -0.01549064f, -0.04149971f, -0.02257675f, -0.00147035f, -0.00971999f, -0.03061472f, 0.02314094f, -0.01761958f, 
    -0.00279172f, -0.01963291f, -0.04311343f, -0.03598180f, -0.00944622f, -0.01107549f, -0.00956453f, -0.00797371f, 
    -0.00438341f, -0.02006098f, -0.03145858f, -0.03990472f, -0.02233653f, 0.00557264f, -0.00763073f, 0.00385215f, 
    -0.00980340f, -0.03543163f, -0.02122006f, -0.00459866f, -0.04019272f, 0.02107132f, -0.02233628f, 0.01338766f, 
    0.01325924f, -0.01270392f, 0.00317510f, -0.03376156f, -0.04760839f, -0.02820173f, -0.03215388f, 0.00501924f, 
    -0.01145591f, -0.02110651f, -0.01301867f, 0.03031957f, 0.02533484f, -0.03712401f, 0.00175882f, -0.02871716f, 
    -0.03985409f, -0.03535535f, -0.03985561f, -0.00536827f, 0.01682220f, 0.01462980f, 0.01017085f, -0.03530492f, 
    -0.01786018f, -0.04748325f, -0.01312423f, -0.04406863f, 0.01266946f, 0.00739739f, -0.00158698f, 0.00963526f, 
    0.03246981f, 0.00524346f, -0.00729189f, 0.02143003f, -0.03610860f, 0.01462390f, -0.01515043f, 0.00604784f, 
    -0.00835692f, 0.00170274f, 0.01699947f, -0.00328990f, -0.00914315f, 0.01081942f, -0.04002687f, 0.01672053f, 
    -0.00012879f, -0.03243298f, -0.01141736f, 0.00214340f, -0.01014674f, -0.04664856f, -0.02430613f, -0.02948410f, 
    -0.04287181f, -0.04342594f, 0.02019876f, 0.01074863f, -0.00462690f, -0.02981185f, -0.03673166f, -0.01856008f, 
    -0.00762014f, 0.01945256f, -0.01346655f, -0.02331911f, 0.01847585f, -0.00482901f, 0.00534415f, -0.04629795f, 
    0.00732161f, -0.02743926f, 0.01200089f, 0.01295571f, 0.02920046f, -0.03787040f, -0.01323300f, -0.03655285f, 
    0.01738637f, 0.03982306f, -0.04014796f, 0.01672263f, 0.01295347f, 0.04421170f, -0.01033660f, 0.02222216f, 
    0.00812960f, -0.02078052f, 0.01341298f, -0.04314694f, -0.03527150f, -0.04325586f, -0.00982389f, -0.01850752f, 
    0.00694788f, -0.04655640f, -0.03891285f, -0.01237956f, 0.01909554f, 0.02494517f, -0.00694869f, -0.03751427f, 
    -0.01882573f, -0.04386612f, -0.02147293f, 0.00581220f, -0.02170704f, -0.04863557f, 0.00606063f, 0.00736560f, 
    -0.01069013f, 0.01954548f, -0.03317314f, -0.00414640f, -0.04636085f, 0.00720800f, 0.01045422f, -0.02410806f, 
    -0.03878607f, -0.01321635f, -0.00169806f, -0.01221437f, 0.01143911f, -0.00947539f, 0.02452377f, 0.01366000f, 
    0.00066432f, -0.01800969f, 0.01431825f, 0.00151332f, -0.02017565f, -0.01616294f, -0.01165859f, -0.01087032f, 
    -0.01197966f, 0.00480567f, -0.01974022f, -0.00019875f, 0.02831098f, 0.00731343f, -0.00653272f, -0.01975726f, 
    0.00562194f, 0.01338424f, 0.00655976f, -0.02637987f, -0.01273685f, -0.00121160f, -0.01748717f, -0.03142443f, 
    0.01273704f, 0.01424314f, 0.01213921f, -0.02028495f, -0.00194574f, 0.02104595f, -0.00677366f, -0.02579941f, 
    -0.03941160f, -0.01529079f, 0.01151813f, -0.01486820f, 0.01867345f, -0.03407153f, -0.00837921f, 0.00071654f, 
    0.02514775f, 0.02873159f, 0.01710912f, -0.03805045f, -0.02617031f, -0.01578289f, 0.02646537f, 0.00639978f, 
    0.00334384f, -0.02372491f, -0.02903451f, -0.03166265f, -0.00690493f, 0.00117078f, -0.03496529f, -0.03829264f, 
    -0.04041700f, -0.02770001f, -0.01671065f, -0.02493734f, -0.00942879f, 0.02100513f, -0.02527690f, 0.01190943f, 
    0.00702420f, 0.02855287f, -0.02233128f, -0.03706223f, 0.01534309f, 0.01046539f, -0.01170543f, -0.00214948f, 
    0.00524383f, -0.00278473f, -0.01165794f, -0.03570258f, 0.01064429f, 0.02331182f, 0.00886937f, 0.01477220f, 
    0.02670682f, -0.02194343f, 0.01092873f, 0.02733656f, -0.03877498f, 0.01905643f, -0.03157436f, -0.03981102f, 
    -0.00914990f, 0.02047641f, -0.01212385f, -0.03525161f, -0.03670768f, 0.01003904f, 0.02082343f, 0.00261091f, 
    -0.04098934f, -0.01890812f, -0.01535947f, -0.01752861f, -0.02175214f, 0.01260767f, -0.03426214f, 0.02066867f, 
    0.02906199f, -0.02234428f, -0.02888266f, 0.00181491f, -0.01893753f, -0.00765064f, -0.01166634f, -0.02434732f, 
    0.00671898f, -0.03660820f, -0.02976833f, -0.02668408f, -0.00602957f, 0.01470493f, -0.02153060f, -0.02844022f, 
    -0.00420132f, 0.00842999f, 0.00403055f, 0.00971069f, 0.00742760f, -0.02085768f, 0.00136696f, -0.02323849f, 
    0.00318147f, -0.01497158f, -0.00057654f, 0.02067785f, 0.00756598f, -0.01267009f, 0.02335767f, -0.01351969f, 
    -0.00563702f, 0.02969808f, 0.02027278f, -0.02428191f, 0.02765105f, 0.00006287f, 0.00489992f, 0.00944726f, 
    0.01346753f, -0.01914524f, 0.01397486f, 0.02484568f, 0.01384337f, -0.03568286f, 0.01797006f, -0.04097550f, 
    -0.03459382f, -0.03677960f, -0.01005343f, -0.01068953f, 0.02897200f, 0.00642306f, -0.02658052f, -0.03169549f, 
    0.00357217f, -0.02154638f, 0.01148089f, -0.01561455f, -0.02889794f, 0.00958396f, -0.02886484f, 0.01671322f, 
    -0.01374750f, 0.00163326f, 0.00581633f, -0.00120989f, 0.00204214f, -0.00416564f, -0.03775223f, -0.03020775f, 
    -0.02901744f, 0.01845804f, -0.00433945f, 0.02337202f, -0.03536642f, 0.00923536f, -0.02804259f, -0.02317720f, 
    0.01541172f, -0.00854814f, -0.03076607f, 0.01460011f, -0.00365373f, 0.01924006f, -0.02455761f, 0.02996621f, 
    -0.02687086f, -0.03699885f, 0.00500266f, -0.02965517f, 0.02795171f, -0.00203415f, 0.00884036f, 0.02875257f, 
    -0.03181540f, -0.01984448f, -0.04119539f, -0.03750714f, -0.03837927f, -0.03473553f, 0.02872369f, -0.02685525f, 
    -0.01456031f, 0.02641165f, -0.02652161f, -0.00646793f, 0.00764923f, 0.01112952f, 0.01904495f, -0.03500783f, 
    0.01463016f, 0.01959055f, -0.03892161f, -0.03391055f, 0.00527360f, 0.01712372f, -0.01049442f, 0.00051694f, 
    0.00781367f, 0.00218132f, -0.01430520f, -0.01424135f, -0.03834935f, 0.00994226f, -0.03184767f, -0.02799301f, 
    -0.01912156f, -0.03351818f, -0.02516235f, -0.02580750f, -0.03951725f, -0.02829217f, -0.00622866f, -0.02011801f, 
    0.01493997f, -0.02387967f, -0.02654439f, 0.00152013f, 0.01433082f, -0.02161591f, -0.01219706f, -0.00767772f, 
    0.02608958f, 0.01611127f, 0.00900617f, -0.00227044f, -0.02775846f, -0.02695793f, 0.02785491f, -0.00443137f, 
    -0.02479632f, -0.01328137f, -0.00974657f, -0.02612771f, 0.02989336f, -0.03969195f, -0.02274254f, -0.03664504f, 
    0.01591260f, 0.00935659f, -0.00846028f, -0.03251119f, -0.00705915f, -0.00752812f, -0.04035177f, 0.00767419f, 
    -0.03493808f, -0.00302768f, 0.01072004f, 0.02562582f, -0.03296312f, -0.01388358f, -0.03693778f, -0.03672177f, 
    0.00164346f, -0.01575722f, 0.02114414f, -0.01077620f, -0.03814090f, -0.02965481f, -0.01857274f, -0.00580515f, 
    0.01192265f, -0.00235846f, -0.00802175f, 0.02122592f, -0.03238460f, -0.01035224f, 0.00252157f, -0.02075930f, 
    0.01034113f, -0.01281558f, 0.01717476f, -0.01047727f, -0.00038559f, -0.03211913f, 0.00348121f, -0.02258562f, 
    0.00701593f, 0.00678103f, -0.00461522f, 0.00360522f, 0.00156691f, 0.01542058f, -0.02387398f, 0.00198287f, 
    0.02003609f, -0.02119080f, -0.01048241f, -0.01838541f, 0.01868543f, -0.00965816f, 0.00989915f, 0.02693910f, 
    -0.03920034f, 0.00749942f, -0.00585826f, -0.02896177f, -0.00422199f, 0.00560960f, 0.00118648f, 0.00525514f, 
    -0.00271912f, -0.03969797f, -0.00871551f, -0.00254911f, -0.03142831f, -0.02794190f, -0.02168630f, -0.02122919f, 
    0.02279386f, 0.00277220f, -0.00195289f, 0.00355001f, -0.00225533f, 0.01674818f, -0.03794320f, -0.00977719f, 
    -0.00678331f, -0.00674460f, 0.02982398f, 0.02690233f, -0.00213038f, 0.01123354f, -0.01545307f, -0.00557956f, 
    -0.00506219f, 0.02806590f, 0.01672349f, -0.01606929f, -0.04135081f, 0.01451773f, -0.00191750f, 0.01025725f, 
    0.02810009f, 0.02191960f, -0.01797210f, -0.01700549f, -0.02896067f, 0.02534262f, -0.02279191f, -0.02960589f, 
    -0.02075720f, -0.01459473f, 0.00190962f, -0.02595366f, -0.02869572f, 0.01657426f, 0.02771273f, 0.00175428f, 
    -0.02296625f, 0.02775545f, 0.01371785f, -0.03181186f, 0.00022491f, -0.03037465f, -0.00583959f, -0.00288915f, 
    -0.01278477f, -0.01970458f, -0.01978321f, -0.00947156f, -0.00354709f, -0.00047398f, -0.00337240f, -0.00276239f, 
    -0.02069976f, 0.00422961f, -0.02885122f, 0.02484890f, -0.02875202f, -0.03325747f, -0.01390420f, -0.00756669f, 
    0.02135745f, -0.01793589f, 0.01332141f, -0.00815872f, -0.03351869f, 0.00879145f, 0.02250610f, -0.00296892f, 
    -0.03409477f, -0.02601822f, -0.03014542f, 0.02535183f, -0.01310689f, -0.04155710f, 0.00781489f, 0.01493536f, 
    0.00111760f, -0.02586265f, 0.01461894f, -0.01225516f, -0.02809033f, -0.02343371f, 0.00355012f, 0.02406369f, 
    0.02359322f, 0.00492076f, -0.00866011f, -0.02987023f, -0.01352311f, -0.00815916f, 0.01563704f, 0.02932340f, 
    0.00485094f, -0.02856292f, -0.00746579f, 0.00233945f, -0.01995308f, -0.01464211f, -0.02853111f, -0.01013487f, 
    -0.00407332f, -0.02033030f, 0.00318560f, -0.02094262f, -0.01467082f, 0.01420424f, -0.03585499f, -0.01966758f, 
    -0.01685338f, 0.01101115f, -0.00881876f, 0.00254872f, 0.01783239f, 0.00293300f, -0.01610848f, -0.01750646f, 
    -0.03989073f, 0.01976963f, 0.02912757f, 0.02500101f, 0.01082335f, 0.01176518f, -0.03950888f, -0.03378123f, 
    0.00052049f, -0.00029359f, 0.01070466f, -0.03620948f, -0.01700547f, 0.02048251f, 0.00593155f, 0.01170805f, 
    -0.02985141f, -0.03507282f, -0.03091514f, -0.01365234f, 0.02962229f, 0.01755513f, -0.01533024f, 0.00684062f, 
    -0.00082954f, 0.01544308f, -0.04207411f, 0.02510635f, -0.04146478f, -0.01909762f, -0.01450210f, -0.02799824f, 
    -0.02161914f, -0.03842613f, -0.04153168f, -0.03131622f, 0.02235648f, -0.03060663f, 0.02113193f, -0.01497669f, 
    -0.02621322f, 0.02510209f, 0.01599994f, -0.02726355f, 0.01415962f, -0.02762915f, -0.02084405f, -0.00086379f, 
    -0.01716866f, -0.03288512f, 0.00140014f, -0.01925593f, 0.00090737f, -0.00462225f, 0.01384015f, 0.02714619f, 
    -0.02006512f, -0.00267730f, -0.02437865f, -0.00765472f, 0.01384102f, 0.02754811f, -0.03408539f, 0.02770314f, 
    0.00409654f, -0.03728084f, 0.02057338f, 0.01242884f, 0.02082167f, -0.01141394f, -0.01631978f, -0.02469760f, 
    0.01388640f, 0.00302950f, -0.02385502f, -0.04070890f, -0.03230257f, 0.00952273f, -0.02296554f, 0.02175214f, 
    0.00646595f, 0.02445634f, -0.01664368f, -0.00350768f, 0.01144097f, -0.01641435f, -0.00785221f, 0.02228403f, 
    -0.02373734f, -0.03722776f, 0.02172709f, -0.03196988f, 0.01529397f, 0.02273557f, 0.00960558f, -0.01046295f, 
    0.00881885f, 0.01405475f, -0.00535637f, -0.01462535f, -0.01431078f, 0.01724402f, -0.01717770f, 0.02159142f, 
    -0.03049107f, -0.00906752f, 0.00850477f, -0.02734932f, -0.02602607f, -0.01795638f, -0.00593717f, 0.00929904f, 
    -0.02983582f, -0.00649867f, -0.00220573f, -0.02335309f, 0.00839823f, -0.01631160f, -0.01373577f, -0.00552535f, 
    -0.01573611f, -0.00726771f, -0.01830028f, 0.00221676f, 0.01437013f, -0.03991506f, -0.00639718f, 0.02547908f, 
    0.02265933f, -0.04175029f, 0.00411559f, -0.00253747f, -0.01322442f, 0.00316066f, 0.01250003f, -0.02141188f, 
    0.01746732f, -0.00512284f, -0.01992845f, -0.02396876f, -0.00427444f, -0.03547796f, -0.00038224f, -0.02843321f, 
    0.02433686f, -0.00853829f, 0.01910822f, -0.01861953f, 0.01083416f, 0.02636949f, -0.02928092f, -0.03119890f, 
    -0.01935427f, 0.02013401f, -0.00180565f, -0.04153824f, -0.01289854f, 0.01468752f, 0.02038525f, -0.02100204f, 
    -0.00606825f, -0.01648402f, 0.01573431f, -0.00289276f, -0.03962290f, 0.00522872f, -0.00458450f, -0.02270699f, 
    -0.00966414f, 0.02324093f, -0.03326735f, 0.01339842f, 0.00855670f, 0.02461082f, -0.01598912f, 0.02632691f, 
    0.02443151f, 0.00383354f, 0.01298943f, 0.00408606f, 0.02954590f, 0.02016647f, -0.03246363f, -0.01419071f, 
    -0.04135823f, -0.02434229f, -0.02259138f, 0.00075109f, -0.00545461f, -0.00846049f, 0.00654672f, -0.02832485f, 
    -0.02444449f, 0.01266943f, -0.00914347f, -0.03318688f, 0.00099195f, -0.00128889f, -0.01544932f, 0.00494885f, 
    0.00237992f, 0.00089162f, -0.03171600f, -0.02415541f, 0.02343918f, -0.02312804f, -0.01185711f, 0.01562198f, 
    0.02699387f, -0.01939555f, 0.00936974f, 0.01643987f, -0.00180414f, 0.00539928f, 0.01162658f, 0.00098080f, 
    -0.03592516f, -0.02277396f, -0.01833807f, 0.02851605f, -0.02349493f, 0.00410873f, 0.01378103f, -0.03497160f, 
    0.00704955f, -0.01937197f, -0.01913304f, -0.00373287f, 0.02959193f, -0.00870698f, 0.01117242f, 0.00192872f, 
    -0.02586129f, -0.03693636f, 0.00980669f, -0.01091320f, -0.02022346f, -0.02076275f, -0.02176231f, -0.00295932f, 
    -0.03196305f, -0.02847393f, -0.03884282f, -0.00967649f, 0.01092988f, 0.00082725f, 0.01077636f, -0.01697405f, 
    0.01980099f, -0.03684881f, -0.03938451f, 0.01973522f, -0.02077039f, 0.00245741f, 0.01477586f, 0.02163962f, 
    -0.00181299f, -0.00740631f, -0.00556139f, -0.02492681f, -0.01117541f, -0.04196561f, 0.02522836f, -0.03342734f, 
    -0.00688513f, -0.01477676f, -0.01094584f, 0.02299437f, -0.02615938f, 0.00184919f, -0.03161016f, -0.00478032f, 
    0.00402433f, 0.01750411f, 0.00200318f, -0.00337396f, -0.00823413f, -0.01051988f, 0.00156194f, 0.00763813f, 
    -0.01827038f, -0.02241005f, 0.00597692f, 0.01965968f, -0.00639866f, 0.01407267f, -0.00081523f, -0.01228818f, 
    -0.01431265f, 0.00148653f, -0.02726554f, -0.04077360f, -0.00628312f, -0.02645596f, 0.00771404f, -0.02910102f, 
    -0.00029460f, -0.01939036f, -0.02067295f, 0.02266192f, 0.00346112f, 0.02197204f, -0.00523927f, -0.01389587f, 
    -0.00300569f, -0.02200188f, 0.02998826f, 0.02977563f, -0.02535247f, 0.01858354f, -0.03908141f, -0.02088127f, 
    -0.01669885f, -0.01193916f, -0.01326659f, -0.00697345f, 0.02955719f, -0.03219945f, -0.03398640f, 0.00889668f, 
    -0.01862310f, -0.01174605f, -0.01197800f, 0.00739204f, -0.03707529f, -0.01485694f, -0.00632033f, 0.01247358f, 
    -0.00843483f, -0.00068453f, 0.01022587f, -0.03386811f, 0.00305629f, -0.00773449f, 0.01279671f, -0.01287791f, 
    -0.02657390f, -0.00638104f, -0.04078407f, 0.00962460f, 0.00900346f, 0.00369164f, -0.03537363f, -0.02159057f, 
    -0.01651688f, -0.00342482f, 0.03011971f, -0.00643759f, -0.02435881f, -0.01637063f, 0.00337833f, -0.02685964f, 
    -0.04088947f, 0.01981595f, 0.00722590f, 0.00848815f, -0.03854654f, -0.00571093f, 0.00784862f, 0.01800054f, 
    -0.02392442f, -0.04134866f, -0.01982298f, 0.00749057f, 0.02966665f, -0.01736913f, 0.00610845f, -0.03222794f, 
    0.00474005f, 0.00137550f, -0.03322802f, -0.02104714f, 0.02590321f, -0.00984191f, 0.00695805f, -0.03251974f, 
    -0.02788089f, -0.01055784f, -0.00648745f, -0.03646233f, -0.02400547f, -0.03655345f, 0.01552732f, 0.01198294f, 
    -0.01916199f, 0.00440351f, 0.01085877f, 0.02251795f, -0.02256035f, 0.01876326f, -0.03264358f, 0.00527206f, 
    0.02152207f, 0.02387613f, -0.00086260f, 0.02463308f, -0.00533900f, 0.01737402f, 0.01620304f, 0.02777886f, 
    0.00405537f, 0.00464142f, 0.01330744f, -0.01391382f, -0.01640061f, -0.00195150f, -0.00952176f, -0.02752772f, 
    -0.04002955f, 0.01164789f, -0.00915985f, 0.00085864f, -0.03360469f, -0.02921398f, -0.02069174f, -0.02690252f, 
    -0.02180723f, -0.02250229f, 0.02781121f, -0.00935240f, 0.00862396f, 0.00684662f, 0.02120085f, 0.02013770f, 
    -0.01258117f, 0.01187520f, -0.02853884f, 0.00628635f, -0.03104985f, -0.01205369f, -0.01854624f, 0.00639878f, 
    0.00072216f, -0.04051344f, 0.01599888f, -0.01800284f, 0.02453589f, -0.02131626f, -0.00929039f, 0.00488659f, 
    -0.00016424f, 0.02183569f, 0.01864030f, 0.00793151f, 0.02267920f, -0.01635499f, 0.02277892f, 0.01693488f, 
    0.01002089f, 0.01617048f, -0.00130248f, -0.02282718f, -0.01038692f, 0.00379963f, -0.01333414f, -0.01612855f, 
    -0.00765114f, -0.02828343f, -0.03592721f, -0.03222577f, 0.00295778f, -0.02288948f, 0.02572240f, 0.01667499f, 
    0.02632933f, 0.01172453f, -0.02144013f, -0.02847796f, -0.00403245f, -0.01865037f, -0.03755405f, -0.03557865f, 
    0.00128272f, -0.00597698f, 0.00845656f, -0.00720366f, 0.01494235f, -0.03418434f, -0.03395401f, 0.00345067f, 
    0.00769961f, 0.02041434f, 0.02681820f, -0.00392979f, 0.01648773f, 0.02282417f, 0.01289047f, -0.04068319f, 
    -0.03298512f, 0.01738841f, 0.00709231f, 0.01321233f, 0.00021794f, -0.03531349f, 0.01075272f, -0.02341723f, 
    0.02128609f, -0.00980952f, -0.02329494f, 0.01050699f, 0.02425595f, 0.00938892f, 0.01527585f, 0.02921159f, 
    0.02152745f, 0.03038933f, -0.03314817f, -0.00401209f, -0.01707404f, 0.02238264f, -0.00482883f, 0.01772109f, 
    0.02918567f, -0.03899287f, 0.02411443f, -0.02381897f, -0.02677967f, -0.00588284f, -0.02821223f, -0.00521622f, 
    -0.01896148f, 0.00204331f, 0.00215477f, -0.00748419f, 0.00034783f, 0.01730870f, 0.00153466f, -0.03978596f, 
    -0.03221660f, -0.03996170f, 0.01439556f, -0.03863002f, -0.01875285f, -0.01247267f, -0.03901375f, -0.03908826f, 
    -0.00823494f, -0.03242164f, 0.00624629f, 0.02107511f, -0.04072155f, 0.01296071f, -0.03162211f, -0.03333909f, 
    0.01428352f, 0.00463154f, 0.02700728f, -0.03916291f, -0.02441701f, -0.02356498f, -0.02932399f, -0.02956652f, 
    -0.01155243f, 0.00683522f, 0.02687733f, -0.02673587f, -0.01814130f, -0.01719045f, -0.00433869f, -0.03001556f, 
    -0.02525544f, -0.01365682f, -0.02319883f, -0.01608342f, -0.03555148f, -0.02369384f, -0.02315796f, 0.01037014f, 
    -0.00513613f, -0.04021006f, -0.03697560f, -0.03020383f, -0.02858378f, -0.00680171f, 0.02355960f, -0.03407558f, 
    -0.03141365f, -0.03458654f, -0.02036814f, 0.02012730f, -0.02824248f, -0.01984544f, 0.00064183f, 0.00028530f, 
    -0.02816298f, -0.00188330f, -0.01053050f, -0.00278711f, -0.01715410f, -0.00661621f, -0.03302770f, -0.02511875f, 
    0.00825891f, 0.00011400f, -0.00817572f, 0.00096598f, 0.00524456f, 0.00413342f, -0.00559737f, -0.03714621f, 
    -0.03689808f, 0.02709411f, 0.01477663f, -0.00339627f, -0.00189846f, -0.02397792f, 0.01584272f, -0.03709067f, 
    -0.00848212f, -0.01412287f, 0.02190076f, 0.01905055f, -0.01337831f, -0.02777538f, -0.03239428f, 0.02275733f, 
    0.00108345f, -0.02353161f, -0.02906627f, -0.00111724f, -0.00344044f, 0.00034702f, 0.01156565f, -0.00365529f, 
    -0.02205207f, -0.00002255f, 0.01173342f, -0.01575479f, -0.02901409f, -0.00930102f, 0.00326790f, 0.00458507f, 
    0.01569718f, -0.03571275f, 0.02530444f, -0.00966886f, -0.00465975f, -0.02169184f, -0.01708949f, -0.00263989f, 
    -0.03303533f, -0.03625001f, -0.02552847f, 0.01782945f, 0.01725687f, -0.00310884f, -0.02382064f, 0.00118997f, 
    -0.00107684f, -0.00378019f, -0.01474049f, -0.00351374f, 0.01479744f, 0.01561271f, -0.00551392f, 0.00842551f, 
    0.00557571f, -0.02558300f, 0.02287271f, -0.01030679f, -0.01494747f, -0.00168093f, 0.01171111f, -0.00712690f, 
    0.00191281f, -0.01205088f, 0.00974764f, 0.00048362f, -0.02584685f, -0.02475636f, 0.02999737f, 0.00249461f, 
    -0.04005150f, -0.03136124f, 0.00930599f, 0.02516969f, 0.02846987f, 0.01544889f, -0.04053838f, -0.00849206f, 
    0.01230639f, 0.02840685f, -0.02860468f, 0.01841688f, 0.01378421f, -0.02273619f, -0.01238038f, -0.02201513f, 
    0.02711044f, 0.01558517f, 0.00117642f, -0.03145620f, -0.00124327f, -0.03912304f, -0.00504244f, -0.01623746f, 
    0.02067815f, 0.02672215f, -0.01965821f, -0.00725796f, -0.04055817f, -0.02774438f, -0.02740257f, -0.01255425f, 
    0.02037775f, 0.02619775f, 0.02019943f, -0.01292896f, -0.01101629f, -0.03527394f, -0.03761429f, -0.01300444f, 
    -0.01775093f, 0.00004428f, -0.03005870f, -0.03795292f, -0.03801385f, -0.03566518f, 0.00209329f, -0.01718801f, 
    0.02024579f, -0.03338447f, 0.01798421f, -0.03714338f, -0.02890141f, 0.01584549f, -0.03470203f, -0.00326423f, 
    -0.02582474f, 0.01048273f, 0.02971545f, -0.00758993f, -0.01617818f, 0.01978189f, -0.02000487f, 0.01410987f, 
    0.00266771f, 0.01915398f, 0.00754737f, -0.01455102f, 0.00669501f, 0.00415833f, 0.01104025f, -0.02130757f, 
    -0.01017664f, 0.01134597f, 0.01195943f, -0.01024627f, -0.00704605f, -0.01142156f, -0.00348459f, -0.04162743f, 
    0.01874517f, 0.00607021f, -0.00544090f, 0.02334642f, -0.01658196f, -0.00717371f, 0.00005409f, 0.01617059f, 
    -0.03970691f, -0.01201316f, 0.01873920f, -0.01159428f, 0.00882735f, 0.02050762f, -0.01941239f, -0.02135335f, 
    -0.01642816f, 0.02252819f, -0.00133858f, -0.02467754f, -0.01217550f, -0.00501238f, -0.01673068f, -0.02821660f, 
    -0.02348684f, 0.02233953f, -0.04013833f, -0.00611143f, -0.00425231f, -0.01000925f, -0.04060191f, 0.00552014f, 
    0.02166415f, -0.00100841f, 0.00394516f, -0.00767325f, -0.01183908f, -0.03138161f, -0.03788413f, -0.02502032f, 
    -0.01670729f, -0.02924089f, -0.01793919f, 0.02346209f, -0.03701875f, 0.01721107f, 0.00271762f, 0.02827014f, 
    0.02607199f, 0.02383659f, -0.03441408f, 0.01739370f, -0.02050363f, 0.01937609f, 0.01847601f, 0.00859978f, 
    -0.01688433f, 0.00082685f, 0.01525954f, 0.01261991f, -0.01388639f, 0.00902998f, 0.00512547f, -0.00782017f, 
    0.02152730f, 0.00408592f, -0.03056889f, 0.02335919f, -0.03910625f, 0.00889833f, -0.00152153f, 0.01682419f, 
    0.00931642f, -0.02424913f, 0.01407880f, -0.02901268f, -0.02955309f, -0.04068600f, -0.02487914f, -0.03640372f, 
    0.01727528f, -0.02791113f, 0.01687732f, -0.00466287f, -0.02806474f, -0.01706409f, -0.02090370f, 0.00404180f, 
    0.00597725f, 0.02251923f, 0.00120140f, -0.02022997f, -0.03778939f, -0.00925384f, 0.02904152f, 0.02350305f, 
    -0.00000529f, 0.02544655f, 0.02912092f, -0.02683669f, 0.02941311f, -0.03283298f, 0.01856059f, 0.02289294f, 
    0.02874558f, -0.04149940f, -0.02690047f, -0.03688363f, -0.01803481f, 0.00521917f, 0.02878956f, 0.02652857f, 
    -0.03258607f, 0.02046344f, -0.03970679f, -0.02617157f, -0.03948052f, -0.01188154f, -0.01825300f, -0.00942588f, 
    0.02754184f, -0.02085276f, 0.02789495f, -0.01345143f, -0.00667518f, -0.00908810f, -0.00458796f, 0.02961045f, 
    -0.03350130f, -0.01870166f, 0.00872021f, -0.03271981f, 0.01268799f, 0.02051292f, -0.02055141f, -0.01142368f, 
    0.00676055f, 0.01544098f, -0.01382497f, 0.00091571f, 0.01572181f, -0.01278142f, -0.00025789f, -0.03265129f, 
    -0.00908705f, -0.02447838f, -0.02846009f, -0.02189604f, -0.03089544f, 0.02328739f, -0.03466311f, -0.00558267f, 
    0.01721066f, -0.00628324f, -0.01375929f, -0.01605297f, 0.00759739f, -0.02814082f, 0.02384745f, 0.02838059f, 
    -0.03271755f, -0.03794203f, -0.03786827f, 0.02441709f, -0.00419012f, -0.03817958f, -0.01417135f, 0.00902997f, 
    -0.01190634f, -0.00928451f, -0.00760313f, -0.01670346f, 0.02483518f, -0.04136137f, -0.00392459f, 0.01920036f, 
    0.02062228f, -0.00692110f, 0.00575003f, -0.03626110f, -0.03095632f, -0.02857115f, -0.04148690f, 0.01305125f, 
    -0.02583501f, -0.00719057f, -0.03785961f, 0.01657015f, -0.03836107f, 0.02934406f, -0.00171504f, -0.02615857f, 
    -0.01765445f, 0.00517485f, 0.01798364f, -0.02947631f, -0.03160079f, 0.02758129f, -0.03534165f, -0.03458510f, 
    0.00542235f, -0.00582030f, 0.02019842f, 0.02664499f, 0.00502107f, -0.01489600f, -0.02990230f, -0.00447057f, 
    0.02180828f, 0.02842074f, 0.01542540f, 0.01541282f, -0.02873744f, 0.00691057f, -0.00929231f, 0.02513404f, 
    -0.03446159f, 0.01578989f, -0.03065203f, 0.02295890f, -0.01557726f, -0.00878194f, 0.00422989f, -0.02514838f, 
    -0.03663579f, 0.01734319f, -0.03991004f, -0.03567331f, 0.01822740f, -0.04069991f, -0.03716037f, -0.03246011f, 
    -0.02080038f, 0.00021731f, 0.01264483f, -0.02787012f, -0.01921226f, -0.03871069f, 0.01458067f, -0.02676294f, 
    0.02673545f, -0.01876966f, -0.01128039f, -0.00104765f, -0.02200863f, 0.01812739f, 0.02575797f, 0.00588329f, 
    -0.03482418f, -0.02034898f, -0.01318253f, -0.00078484f, -0.03322722f, 0.01750172f, 0.02160837f, -0.01522834f, 
    -0.02428347f, 0.02715907f, -0.03396419f, 0.01813827f, -0.01010045f, -0.03813068f, 0.02151929f, -0.00070584f, 
    -0.01445552f, -0.01152525f, 0.00938873f, 0.01551924f, 0.00237845f, -0.02169423f, 0.01553098f, 0.00052271f, 
    -0.03514656f, 0.01635999f, -0.04059622f, 0.02721241f, 0.02568003f, -0.02866179f, 0.00145945f, -0.03276680f, 
    0.00357749f, 0.00980093f, 0.02698911f, -0.01987835f, 0.00224587f, 0.00235566f, -0.03871612f, -0.02567021f, 
    -0.04038758f, -0.01791203f, 0.00707032f, -0.04060392f, -0.00237194f, 0.02765155f, -0.00954560f, -0.00171812f, 
    -0.02172592f, 0.00376184f, -0.02683270f, 0.02317169f, 0.01819999f, 0.00175036f, -0.01064669f, -0.03504094f, 
    0.00852400f, 0.00522895f, 0.00816808f, -0.02977384f, -0.03851625f, 0.00544926f, -0.03042644f, 0.01855619f, 
    0.02948329f, -0.02474512f, 0.00598758f, -0.02542572f, -0.01526683f, -0.02566447f, 0.01836791f, 0.03019818f, 
    -0.02082677f, -0.01732526f, 0.02865945f, -0.03115023f, -0.00859150f, 0.02895093f, 0.02452254f, -0.00709154f, 
    -0.01588851f, -0.02763708f, 0.00098164f, 0.00022878f, 0.02594437f, 0.01840495f, -0.00243915f, 0.00455549f, 
    -0.02699042f, -0.02154600f, 0.01189108f, 0.02591544f, -0.02932623f, -0.02124491f, -0.03670739f, 0.01991500f, 
    0.00839071f, 0.00459381f, -0.02308133f, 0.02267044f, -0.03003686f, 0.02381088f, 0.01846583f, -0.03761547f, 
    0.01592127f, 0.02736995f, 0.00528241f, -0.01144041f, -0.00398095f, 0.03507869f, -0.03811161f, 0.01604397f, 
    -0.04157666f, 0.02737026f, 0.02160929f, -0.03587170f, 0.02372514f, -0.03495078f, -0.02674605f, -0.03573414f, 
    0.01637333f, -0.03885239f, -0.00289856f, 0.01066227f, 0.00294211f, -0.03367160f, 0.01924718f, -0.02454246f, 
    0.00897893f, -0.01375330f, 0.00573507f, -0.01975189f, -0.00692039f, -0.00780529f, -0.03714459f, -0.03638202f, 
    0.00753273f, -0.00247897f, -0.02848519f, -0.01643515f, -0.03607831f, -0.01377107f, -0.02289546f, -0.00420129f, 
    0.00838049f, -0.03875352f, -0.01648806f, -0.00681294f, -0.01450662f, 0.01977625f, 0.01317405f, -0.02796945f, 
    -0.02710501f, -0.00948749f, 0.00486902f, -0.01372685f, -0.03764535f, 0.00432182f, -0.02798426f, -0.02199675f, 
    0.02659359f, -0.01080729f, -0.02694941f, -0.02380841f, -0.02951615f, 0.00177602f, -0.02493821f, -0.02366004f, 
    0.02685257f, -0.01207855f, -0.03823964f, 0.00109879f, -0.02318802f, -0.03356625f, 0.00991482f, -0.02067390f, 
    0.00038944f, 0.02452535f, -0.00020439f, -0.02936219f, 0.04161878f, 0.01145222f, -0.00273081f, 0.00444625f, 
    -0.01146563f, -0.01839547f, -0.02037817f, -0.01282588f, -0.00722309f, -0.01320803f, -0.00624892f, -0.00315807f, 
    -0.00838222f, 0.02930834f, 0.02848696f, -0.01429511f, -0.01094839f, -0.02300199f, -0.00906085f, -0.01105698f, 
    0.02223199f, 0.01403050f, 0.01589489f, 0.02667773f, -0.03891615f, -0.00713731f, -0.01201131f, -0.03093131f, 
    -0.03694043f, -0.02031045f, -0.00516901f, -0.00513010f, -0.04243969f, -0.02307655f, -0.01012265f, -0.02810895f, 
    -0.02442699f, -0.01601434f, 0.01677898f, 0.01693928f, 0.00440015f, -0.01551436f, -0.01492673f, -0.00768604f, 
    0.02730579f, -0.03238019f, -0.02373204f, -0.00492168f, 0.01676947f, -0.04536010f, 0.01534905f, -0.02365904f, 
    -0.02750921f, 0.00788572f, -0.02098895f, 0.01579332f, -0.01734975f, 0.00132110f, -0.02097682f, 0.00135024f, 
    0.01808208f, 0.00522529f, 0.02293101f, -0.02456471f, 0.00718137f, -0.03824719f, 0.01575271f, 0.02119914f, 
    -0.03174758f, 0.01814611f, 0.02258404f, -0.00353419f, 0.00698719f, 0.01006672f, 0.00598237f, -0.01587326f, 
    -0.01272729f, 0.01275263f, -0.03400716f, -0.02596315f, -0.03376796f, -0.02977717f, -0.02130419f, -0.01126350f, 
    0.01517507f, -0.00328398f, -0.03181665f, -0.03047908f, 0.01415457f, -0.03941406f, 0.00837791f, 0.00575766f, 
    0.02741835f, 0.02622735f, 0.01244150f, 0.01613678f, 0.02429392f, -0.00109608f, -0.02692157f, 0.02190800f, 
    0.01799072f, 0.01183281f, -0.03629728f, -0.01035242f, 0.00283989f, -0.03772235f, -0.01968095f, 0.00853930f, 
    -0.02972206f, 0.01442393f, -0.03266566f, -0.01023065f, -0.03547951f, 0.02760996f, -0.01046037f, 0.01581260f, 
    0.02200293f, -0.00200662f, -0.02981896f, 0.02757186f, -0.00476781f, -0.00870396f, -0.02712783f, 0.02326169f, 
    0.02020408f, 0.00298862f, 0.01693184f, 0.01877935f, -0.02340717f, -0.03227102f, -0.00349166f, 0.01305942f, 
    0.02997285f, -0.03554798f, -0.01717380f, -0.00025741f, 0.01248082f, -0.00347242f, -0.01986668f, 0.02094010f, 
    0.02269158f, 0.00165915f, 0.00699202f, 0.03040675f, -0.01064904f, 0.01473720f, -0.00597802f, 0.00175235f, 
    0.01425373f, -0.02719686f, -0.02665579f, -0.02285103f, -0.03874276f, -0.00365905f, 0.00236018f, -0.01468274f, 
    -0.04047600f, -0.02969821f, -0.02135532f, -0.03797427f, -0.02315087f, -0.01285614f, -0.01580138f, -0.02435310f, 
    -0.04254290f, -0.01488558f, 0.00944853f, -0.02240113f, -0.02308337f, 0.00428302f, -0.02153570f, 0.01895167f, 
    0.02382898f, -0.01090469f, -0.02522352f, -0.01580122f, 0.02087450f, 0.01302411f, 0.01747463f, -0.02640289f, 
    -0.01090919f, 0.02765233f, -0.02726566f, -0.02057100f, -0.00079965f, -0.00507725f, -0.02997382f, 0.02075500f, 
    -0.00936674f, -0.01264574f, -0.01243241f, 0.02413616f, 0.02870611f, -0.00763007f, 0.00664863f, 0.02023707f, 
    0.01989168f, -0.01807716f, -0.01423535f, -0.02151382f, -0.01605754f, -0.00496700f, -0.03630917f, 0.02353778f, 
    0.03594221f, -0.04492049f, 0.01929743f, 0.01687733f, -0.01838258f, -0.01923279f, 0.01175466f, 0.02891655f, 
    -0.00169209f, 0.00151542f, -0.01488749f, 0.00997909f, 0.01710254f, 0.02337987f, 0.00515734f, -0.03285948f, 
    -0.01959679f, 0.02889562f, 0.03197687f, 0.01951399f, -0.00605931f, -0.03692399f, -0.01781459f, -0.01911825f, 
    -0.02211416f, 0.02808548f, -0.02956630f, 0.00043672f, 0.01112110f, -0.00197312f, -0.02616884f, 0.03208543f, 
    -0.00912222f, -0.02414343f, 0.00020391f, 0.01743300f, -0.02113093f, 0.01590275f, 0.02750803f, 0.01534689f, 
    -0.00829063f, 0.00258774f, 0.00617193f, -0.01383854f, -0.01476342f, 0.02841445f, 0.00890362f, -0.01267558f, 
    -0.03014025f, 0.01943510f, 0.03167563f, 0.00099065f, 0.02477205f, -0.00457879f, -0.01765288f, 0.00277476f, 
    -0.00496770f, -0.04165667f, 0.02091974f, 0.00827980f, 0.02994513f, -0.00813456f, -0.02118271f, 0.00833359f, 
    0.02786054f, 0.02547123f, -0.00871901f, -0.01727783f, -0.00833194f, 0.00100927f, -0.02965454f, -0.00255005f, 
    -0.00457563f, -0.00307264f, -0.00615814f, -0.00821121f, -0.02267173f, 0.02896333f, -0.00132339f, 0.00330240f, 
    0.00619004f, 0.01459082f, 0.01689482f, -0.02301355f, 0.00932185f, -0.00377009f, -0.01217162f, 0.00416538f, 
    0.00442667f, 0.01639024f, 0.01946009f, -0.04238327f, -0.04095052f, -0.01960314f, -0.03060682f, -0.04440585f, 
    -0.01557328f, 0.01403750f, -0.01540101f, 0.01665642f, -0.01215008f, -0.02176929f, 0.01385470f, -0.01764902f, 
    0.01803012f, 0.00781059f, -0.00534788f, 0.03105236f, 0.02670821f, -0.03751198f, -0.02873190f, -0.00176190f, 
    0.00344388f, 0.01600355f, -0.01223513f, -0.01545375f, -0.03542455f, 0.02904022f, 0.02708603f, 0.02047639f, 
    -0.00844127f, 0.00129861f, -0.02604881f, 0.02569158f, -0.00957615f, -0.02141581f, -0.04066019f, -0.00173092f, 
    0.01088041f, -0.00748443f, -0.01600022f, -0.01663602f, -0.00360516f, -0.00599305f, 0.02199965f, -0.00815818f, 
    0.01536681f, -0.03096597f, 0.01739425f, -0.03934979f, 0.02490696f, -0.02366434f, -0.01048014f, -0.00511799f, 
    -0.00634751f, 0.02070807f, 0.01729570f, -0.04018573f, -0.02803117f, -0.02354211f, 0.01122880f, 0.00439876f, 
    0.01258984f, -0.00560854f, 0.01857620f, 0.01121704f, -0.00927136f, -0.03030174f, -0.00742547f, 0.02957025f, 
    0.02561255f, 0.01667278f, 0.02883078f, -0.02468479f, -0.03741848f, -0.03125133f, -0.03204258f, -0.03135566f, 
    -0.02556309f, -0.02953059f, 0.03238446f, -0.02954505f, 0.00526946f, -0.03351124f, 0.01215589f, 0.01558622f, 
    0.01690879f, -0.01048112f, -0.00856598f, 0.00156634f, -0.00037085f, 0.01562260f, -0.02371736f, -0.02660193f, 
    0.02908928f, 0.02818566f, -0.02116547f, -0.01784253f, 0.01903963f, 0.01173340f, -0.00820126f, -0.00535934f, 
    -0.02399316f, -0.02536425f, -0.03724688f, -0.01004972f, -0.00017477f, -0.00368512f, 0.00396074f, -0.00578653f, 
    -0.02133096f, -0.01821656f, 0.00551349f, 0.02587095f, 0.02476575f, 0.01648086f, 0.01885365f, -0.01846308f, 
    -0.00325203f, 0.00031545f, -0.00761281f, 0.01948972f, -0.03191695f, 0.02790838f, -0.01377700f, -0.00147427f, 
    0.01145300f, -0.03763806f, -0.03520589f, -0.03992265f, 0.02860315f, -0.03778849f, 0.02346928f, -0.03859192f, 
    -0.02602995f, 0.01305705f, -0.04012085f, 0.00764238f, -0.00341727f, -0.02873189f, 0.00156215f, -0.03616362f, 
    0.01861119f, 0.02334304f, -0.03051826f, -0.01921415f, 0.02241839f, 0.00998858f, 0.00830954f, -0.02171387f, 
    -0.01946511f, 0.01456168f, 0.01561983f, 0.02469463f, 0.02430857f, 0.00948148f, 0.02824511f, 0.02623198f, 
    -0.02154331f, 0.00255276f, -0.02545434f, -0.02571382f, -0.03286766f, -0.02472517f, -0.01178142f, 0.00077611f, 
    -0.01034689f, 0.03631746f, -0.00271981f, -0.01633549f, 0.01968665f, -0.01045497f, -0.00900509f, 0.02164433f, 
    -0.00414005f, 0.01965816f, 0.00995454f, -0.02991676f, -0.00054171f, 0.00690592f, 0.00993717f, -0.00958535f, 
    -0.01490143f, -0.02325955f, -0.01971143f, -0.02732818f, -0.00034752f, 0.00137101f, 0.00788321f, -0.02454952f, 
    -0.03701341f, 0.02604525f, -0.03500103f, -0.00536298f, -0.02776253f, -0.03433797f, 0.01551040f, -0.01041581f, 
    0.02647092f, -0.02597364f, -0.00285062f, 0.01120578f, -0.00260291f, 0.01454839f, -0.00175998f, -0.02472736f, 
    -0.03867776f, 0.00366773f, -0.02485267f, -0.00174116f, 0.02938388f, -0.01450620f, -0.00762768f, 0.02045332f, 
    0.00107688f, -0.00764789f, -0.01947026f, -0.04352821f, 0.03328516f, -0.03090614f, -0.00641342f, -0.00276386f, 
    -0.03855702f, 0.02906704f, 0.03487950f, -0.00801505f, -0.01958451f, -0.00591383f, -0.01618245f, 0.01156197f, 
    0.00149284f, -0.00562591f, -0.02464763f, -0.00121941f, -0.01356695f, -0.01621239f, 0.00901602f, -0.03970055f, 
    -0.00806851f, -0.02660394f, 0.01755718f, -0.01687972f, 0.02590544f, -0.04136281f, -0.00992941f, -0.01739438f, 
    -0.04175260f, -0.03665942f, 0.02375884f, -0.04040624f, 0.01759537f, 0.01894311f, -0.00385377f, -0.00214502f, 
    0.01280368f, -0.03701600f, -0.04342464f, -0.01774739f, -0.01357907f, 0.01646486f, 0.00825480f, 0.01974544f, 
    0.00964253f, 0.03089257f, -0.00719221f, -0.00708006f, 0.03071843f, 0.01782720f, 0.01536877f, -0.02448023f, 
    -0.02937227f, 0.00735458f, -0.02188611f, 0.01282218f, 0.00694043f, 0.01487962f, -0.02860275f, -0.00827545f, 
    0.00345999f, 0.00739289f, 0.00771428f, 0.02484354f, 0.01294485f, 0.00626840f, 0.00365784f, -0.01825574f, 
    -0.01373184f, -0.03134386f, -0.01608955f, 0.02076433f, -0.02629886f, -0.00803611f, 0.02512006f, -0.03299676f, 
    -0.01329780f, 0.00737543f, -0.04166811f, 0.00747125f, -0.00714135f, -0.03843083f, -0.01628288f, 0.01709142f, 
    -0.02068438f, -0.03038857f, -0.02494791f, 0.01520901f, -0.02143750f, 0.00610030f, -0.01836555f, -0.00784976f, 
    -0.00392941f, -0.02471518f, -0.01043557f, -0.02615519f, -0.03199022f, -0.01952916f, -0.01136985f, 0.02377620f, 
    -0.01773473f, 0.00604453f, -0.02428584f, -0.00827187f, -0.01258493f, 0.00965283f, -0.02120078f, 0.02396964f, 
    -0.00253890f, 0.00531195f, 0.01069714f, -0.02964875f, 0.00880964f, -0.01072510f, -0.01189945f, -0.01395849f, 
    -0.01750396f, 0.00887524f, -0.02400507f, 0.02306676f, 0.02503289f, -0.04232716f, -0.01070739f, -0.03737089f, 
    -0.00728772f, -0.03447674f, -0.03162657f, -0.02293797f, -0.03763894f, 0.01159458f, 0.00458140f, 0.01759326f, 
    0.01867792f, -0.01063989f, 0.00867047f, 0.02356407f, -0.01035381f, 0.00402658f, 0.03123819f, 0.00678462f, 
    0.00438952f, 0.02330860f, 0.02082171f, -0.01030982f, -0.00115774f, 0.02266822f, 0.01899827f, -0.02629533f, 
    0.01167017f, 0.01330169f, -0.02367886f, 0.02644459f, -0.01675785f, -0.02301534f, -0.03852873f, -0.02337673f, 
    -0.03509621f, -0.02058256f, 0.01227156f, -0.01846897f, -0.02288624f, -0.00690081f, -0.03403227f, 0.03946675f, 
    -0.03209225f, -0.02143457f, 0.01118925f, -0.01218435f, 0.01630142f, 0.01331938f, 0.00804812f, -0.04033371f, 
    -0.01940266f, -0.03468091f, 0.00571509f, -0.03151781f, 0.01689380f, -0.03587654f, -0.02396902f, 0.01366013f, 
    -0.00681960f, -0.03180669f, -0.02327441f, -0.01437083f, 0.01492316f, 0.02583558f, 0.01478967f, -0.02913041f, 
    -0.03090592f, 0.01053540f, 0.01512086f, -0.00072741f, 0.02291384f, -0.03981861f, 0.02459380f, -0.02199035f, 
    0.01966269f, -0.02531587f, -0.01552399f, -0.01138716f, -0.00398365f, 0.02494319f, -0.02662976f, -0.03427430f, 
    0.01665340f, 0.00940206f, 0.00319495f, 0.01248155f, -0.02100737f, -0.03984693f, -0.03840061f, 0.02734628f, 
    -0.01546708f, -0.04176166f, -0.02110750f, -0.03989032f, -0.01292495f, -0.01265642f, -0.02012766f, -0.01920652f, 
    0.00070609f, -0.01567184f, -0.03200420f, 0.00091958f, -0.02030701f, -0.00858438f, 0.02890692f, -0.02324127f, 
    0.00661715f, -0.02701680f, -0.03835659f, -0.01655182f, -0.02998959f, 0.02520315f, -0.00722374f, -0.01551799f, 
    -0.03384379f, -0.03991306f, 0.00650120f, 0.01715915f, -0.01775070f, -0.02611753f, -0.02755953f, -0.02647837f, 
    -0.03859504f, 0.01830876f, -0.03249883f, -0.03170082f, 0.00585965f, -0.03953437f, 0.01112128f, 0.00667560f, 
    -0.02906363f, -0.01681708f, -0.01221324f, -0.01427900f, 0.01605672f, -0.00698376f, -0.03976737f, -0.03257973f, 
    0.01075127f, -0.02942567f, -0.03281150f, -0.04162070f, -0.00658287f, 0.00913781f, -0.02843666f, -0.01580255f, 
    0.00446876f, 0.01216198f, -0.02838336f, -0.03590871f, -0.03582495f, 0.02027352f, 0.01535307f, 0.01716587f, 
    0.03860047f, 0.01400834f, 0.01510551f, -0.01405179f, 0.02400591f, 0.00434382f, -0.01325921f, -0.00751915f, 
    0.00200962f, 0.02786728f, -0.00580480f, 0.02349510f, 0.01353322f, 0.02051692f, 0.00957851f, 0.02331738f, 
    0.02115885f, -0.00849435f, -0.03599694f, 0.01507619f, 0.01681839f, -0.01255255f, 0.01837936f, -0.00414280f, 
    -0.03670582f, -0.00733247f, -0.01812581f, -0.02826218f, -0.01841515f, 0.00120268f, 0.00500103f, 0.01248669f, 
    0.01048758f, 0.01620591f, 0.01339835f, -0.01420981f, -0.00358492f, -0.03970215f, -0.03813905f, -0.01647600f, 
    -0.01386701f, 0.00786267f, -0.01789262f, 0.01437011f, -0.00608178f, -0.02868186f, -0.00080695f, 0.01946297f, 
    -0.03276356f, 0.01930180f, -0.03496732f, 0.00039418f, 0.00689771f, 0.02880828f, 0.02493984f, 0.00704749f, 
    0.01289447f, -0.01252666f, 0.02739439f, 0.01942215f, -0.02413415f, -0.02310330f, -0.02588382f, -0.03406433f, 
    -0.01805044f, -0.03847058f, -0.02983573f, -0.00475509f, -0.03145721f, 0.01038393f, 0.01374094f, -0.00142443f, 
    -0.03399448f, 0.02413678f, -0.04206695f, 0.02122460f, -0.01644543f, -0.03251632f, 0.01773930f, -0.01543479f, 
    -0.00404515f, 0.01586956f, -0.03617956f, -0.03081898f, -0.00354199f, 0.00728145f, -0.00604495f, -0.03654180f, 
    0.01902335f, 0.02086331f, -0.03041465f, 0.02248453f, -0.02936709f, 0.01820883f, 0.02527248f, -0.04169227f, 
    -0.00190288f, -0.01785703f, -0.02836440f, 0.00958221f, 0.02756031f, -0.03706384f, -0.02422193f, 0.02005514f, 
    0.00198707f, -0.01013773f, 0.02114660f, -0.03956108f, 0.00846657f, -0.00126340f, 0.00811930f, -0.00709323f, 
    0.01195828f, -0.03268543f, -0.00578339f, 0.01054461f, 0.01755630f, -0.00111155f, -0.03119124f, -0.01678921f, 
    0.01862010f, 0.02075675f, -0.01378492f, 0.02233989f, -0.01422187f, -0.02292379f, -0.02269789f, -0.02592430f, 
    0.00388848f, 0.00331193f, -0.02216911f, -0.00386610f, -0.02399077f, -0.02585026f, -0.04092055f, -0.02810317f, 
    -0.02843085f, -0.02635669f, 0.02035662f, -0.00184789f, -0.00008354f, 0.01253532f, 0.00744087f, 0.01714702f, 
    -0.03250453f, 0.02019732f, 0.01176942f, 0.02804456f, -0.02145805f, 0.02360614f, 0.02256045f, -0.00629854f, 
    -0.01731279f, -0.01617154f, -0.04159613f, -0.00404711f, -0.03476342f, -0.02712022f, 0.01023183f, 0.01738853f, 
    -0.02008516f, -0.01340173f, -0.03954253f, 0.02030453f, -0.01193268f, -0.00172782f, -0.03214924f, 0.00131073f, 
    -0.00866466f, 0.00080990f, -0.01740230f, -0.03614673f, -0.03621560f, 0.00394431f, -0.02768699f, 0.01399912f, 
    -0.03262854f, 0.02038429f, -0.01359107f, -0.03008194f, 0.02881038f, 0.02988289f, -0.01957085f, 0.02259647f, 
    -0.03491613f, -0.01267420f, -0.01677428f, 0.02623989f, 0.01312430f, -0.03891525f, 0.00029832f, 0.01177121f, 
    -0.01170471f, -0.01530845f, -0.03282523f, -0.02520595f, 0.00964683f, -0.00963086f, -0.02087323f, 0.00527690f, 
    -0.03368025f, 0.00314160f, -0.01511255f, 0.02339343f, 0.01978304f, 0.02971287f, -0.00575283f, 0.01554052f, 
    -0.01486680f, 0.02467849f, -0.00361569f, -0.02767383f, 0.00622103f, 0.02264692f, 0.02351615f, 0.01201801f, 
    -0.02819065f, -0.01437695f, -0.00874848f, 0.01139766f, -0.01655863f, -0.03340073f, 0.00987003f, -0.00395371f, 
    0.02081971f, 0.00040049f, -0.04009520f, -0.00985897f, 0.00164177f, -0.01847674f, 0.02150864f, 0.01983965f, 
    -0.03596949f, 0.02093245f, -0.02196609f, 0.02453036f, 0.00333505f, -0.00147668f, -0.02236842f, 0.00667070f, 
    -0.00266777f, -0.01380721f, -0.02527692f, 0.00070235f, -0.02011068f, 0.00798234f, 0.04192194f, 0.01267770f, 
    -0.02151952f, 0.00561394f, -0.03665686f, 0.00019357f, -0.02621047f, -0.01821479f, 0.02411912f, 0.01642257f, 
    -0.00996243f, -0.03582640f, 0.02734357f, -0.03590229f, 0.02897877f, 0.00069847f, -0.02050409f, 0.00177563f, 
    0.02919526f, 0.00991320f, 0.00649301f, 0.01129170f, 0.01371940f, 0.02067764f, -0.02970986f, -0.02820121f, 
    -0.01462096f, -0.02987626f, -0.01369161f, -0.01465347f, 0.02342717f, -0.03315297f, -0.00938508f, 0.01017143f, 
    0.02838278f, -0.03234353f, -0.01012154f, 0.01002206f, 0.01490521f, -0.02657274f, -0.03045946f, 0.02057169f, 
    0.02770158f, -0.00797280f, 0.02858026f, 0.00410726f, -0.02924724f, 0.01074730f, 0.02642292f, 0.00102243f, 
    0.00063674f, 0.02782320f, 0.03261059f, -0.01088280f, -0.02326942f, -0.00960972f, -0.01224380f, 0.02806167f, 
    -0.01001799f, -0.02524245f, -0.02616369f, -0.00732900f, 0.03005657f, -0.01115194f, -0.03328070f, 0.00527813f, 
    -0.02071763f, 0.01983279f, -0.00664431f, 0.02663134f, -0.03240521f, -0.00000076f, -0.00715297f, -0.02400060f, 
    -0.02747549f, -0.02661593f, 0.01434863f, -0.00633773f, 0.00248398f, -0.00731576f, -0.00753999f, -0.02328941f, 
    0.00468536f, -0.03769192f, -0.03693530f, -0.01032163f, -0.02578163f, -0.02632599f, 0.02251651f, -0.03051332f, 
    -0.01452929f, -0.03215217f, 0.03918138f, 0.00677294f, 0.02079604f, 0.02811778f, 0.01829144f, -0.02750455f, 
    -0.03199567f, -0.00442912f, -0.03155456f, 0.03537231f, -0.04164134f, -0.02503608f, -0.03896836f, 0.02012989f, 
    -0.02347442f, 0.02921042f, -0.00546569f, -0.01599356f, -0.03604638f, 0.02405057f, -0.03822228f, -0.04056969f, 
    -0.00029813f, -0.03531406f, -0.01867111f, -0.01501116f, -0.00897070f, 0.01115844f, 0.02312961f, 0.00229475f, 
    -0.03171220f, -0.02691461f, 0.00385817f, -0.02683939f, -0.00416903f, 0.01748909f, 0.00643200f, -0.02511689f, 
    0.00361499f, -0.03778959f, 0.02413486f, -0.03068405f, -0.01034900f, 0.00525270f, 0.00608848f, 0.00513341f, 
    -0.00986560f, -0.02907193f, -0.02478900f, -0.01008862f, -0.01482014f, -0.03512041f, 0.01935763f, 0.02572065f, 
    -0.02685665f, 0.00978556f, 0.02407308f, -0.01929878f, -0.01149111f, 0.01660416f, 0.00008591f, -0.02674158f, 
    -0.00426472f, -0.01482980f, -0.01072887f, -0.03163131f, 0.02693226f, -0.00752811f, 0.00321693f, 0.02735293f, 
    0.01803939f, 0.02931323f, -0.03705277f, -0.03681006f, 0.02502755f, 0.00187674f, -0.03155517f, 0.02441640f, 
    0.01356108f, 0.00882806f, -0.00200496f, 0.00351036f, -0.01833065f, -0.02120478f, -0.00413712f, -0.02747175f, 
    -0.04159511f, -0.01858350f, -0.03411224f, -0.00019318f, -0.02283249f, -0.02085958f, -0.01074546f, -0.02442070f, 
    -0.02876017f, 0.03298993f, -0.03291509f, 0.00778447f, -0.02197770f, -0.00384596f, 0.00772856f, 0.03555402f, 
    -0.00227268f, 0.02119321f, -0.02271377f, -0.02142156f, 0.03684331f, -0.03075870f, -0.01310819f, -0.02163431f, 
    -0.03066030f, 0.00724469f, -0.03243521f, -0.01994179f, 0.01118353f, -0.03263003f, 0.01324584f, -0.00126807f, 
    -0.00099500f, -0.02175247f, -0.02772368f, 0.01674836f, 0.00464600f, 0.02577645f, 0.02963397f, -0.00241700f, 
    -0.00321026f, 0.01176424f, -0.02327159f, -0.02881234f, -0.01343993f, 0.02388280f, 0.02685842f, 0.00008502f, 
    0.01335042f, -0.00386975f, 0.01977636f, -0.03000784f, 0.01379903f, -0.01525217f, 0.01788516f, 0.01024526f, 
    -0.01419568f, 0.01409132f, -0.01328504f, -0.03829319f, 0.02737886f, -0.02177112f, 0.02058611f, -0.03772717f, 
    -0.02113363f, -0.02492049f, -0.04013281f, 0.02528231f, -0.03547659f, -0.00909027f, -0.00796170f, -0.04183729f, 
    0.01174635f, 0.01056911f, 0.02047157f, 0.02969933f, 0.02868177f, 0.00922013f, -0.01708189f, 0.02899060f, 
    -0.01270640f, 0.01777843f, -0.00452165f, 0.02345496f, 0.02178023f, 0.00348675f, 0.02667675f, -0.01857413f, 
    -0.02040140f, 0.02350674f, -0.03947681f, -0.03995048f, 0.01705242f, -0.01103823f, 0.00077941f, -0.01148775f, 
    0.01889216f, 0.00717056f, -0.00679758f, 0.01163430f, -0.02399856f, -0.01026633f, 0.02257565f, 0.00541592f, 
    -0.01872156f, -0.02796382f, -0.02946466f, 0.00346079f, -0.01884956f, -0.03229337f, -0.01660498f, 0.00449029f, 
    -0.02141554f, 0.02546432f, -0.04084031f, -0.00358089f, -0.03287929f, -0.03097967f, -0.00170827f, -0.01103181f, 
    0.02276308f, 0.02932473f, -0.01245658f, -0.04005935f, 0.00887950f, -0.02713973f, 0.00600611f, -0.00212051f, 
    0.01460072f, 0.02992302f, -0.00850089f, -0.01974345f, 0.00698765f, -0.02073914f, 0.03639246f, -0.00840443f, 
    0.01465927f, 0.01852828f, -0.00910072f, 0.02564203f, 0.00382706f, -0.01430863f, -0.02210688f, 0.01347389f, 
    0.01654324f, -0.03402635f, 0.00900593f, 0.01072185f, 0.02567013f, 0.01795254f, 0.02978506f, 0.00383303f, 
    -0.03057499f, 0.00086312f, -0.02771380f, -0.01654552f, 0.00968652f, -0.02493591f, 0.00551810f, 0.02804083f, 
    -0.02286955f, -0.00020324f, -0.00031152f, 0.00584931f, 0.02349077f, 0.00561575f, -0.02977150f, 0.00039164f, 
    0.04073077f, -0.00082088f, -0.03869943f, -0.01708361f, 0.02419034f, -0.03745153f, -0.01503513f, -0.02535376f, 
    0.00029035f, -0.03549136f, 0.00975180f, 0.02839800f, 0.02336806f, 0.01538382f, -0.02579357f, -0.00072212f, 
    -0.00814910f, -0.00921403f, -0.00544024f, -0.02018617f, 0.00602468f, -0.01534692f, -0.01645639f, -0.00252371f, 
    0.01147248f, 0.01584353f, -0.02239646f, 0.01779254f, -0.03555121f, -0.01696204f, 0.00180974f, -0.01555716f, 
    0.01783058f, -0.02288051f, -0.03864602f, 0.00389130f, 0.00180299f, -0.03320682f, 0.00855525f, -0.01493374f, 
    0.00105021f, -0.03461235f, -0.03294993f, -0.02275938f, 0.00266382f, 0.03802283f, 0.00624261f, -0.04128575f, 
    -0.01677758f, 0.03363261f, 0.03926048f, -0.02161473f, 0.02486218f, -0.00953757f, 0.02548446f, 0.03077769f, 
    -0.03453177f, 0.02967224f, 0.01829027f, -0.02828183f, -0.01704741f, 0.00331888f, -0.02967293f, -0.01145503f, 
    0.01472657f, 0.00257224f, 0.01887258f, -0.03195512f, 0.02036581f, 0.00110954f, 0.01781737f, -0.03570829f, 
    -0.02580851f, 0.00728998f, -0.01811734f, -0.01157209f, -0.02099392f, -0.00499215f, 0.02167437f, 0.00304009f, 
    0.02322180f, 0.00196283f, -0.00949317f, -0.02869908f, -0.01226218f, 0.00517505f, -0.03638813f, -0.03087973f, 
    0.00275461f, -0.02807035f, 0.01267164f, 0.00189320f, -0.02945141f, 0.01939191f, 0.03120713f, 0.00373174f, 
    -0.02900316f, 0.02032605f, -0.00351502f, 0.01021262f, -0.00218388f, 0.00388866f, 0.00303626f, -0.01100660f, 
    0.00126296f, -0.03702860f, 0.01269600f, -0.01260164f, -0.00002168f, 0.00965760f, -0.02408158f, 0.00100287f, 
    -0.04041490f, -0.01510407f, -0.01180942f, -0.01426484f, -0.03730631f, -0.00583909f, 0.02880574f, 0.03086800f, 
    -0.02449788f, 0.03607804f, 0.00874194f, -0.02526731f, -0.00872518f, 0.00759290f, 0.03162932f, -0.03100833f, 
    -0.01310623f, -0.03926383f, -0.01108663f, 0.00170110f, 0.01274955f, -0.01871921f, -0.03919587f, 0.01345560f, 
    -0.01563250f, 0.00307879f, -0.01532078f, -0.04511790f, -0.02343536f, -0.02396613f, -0.02861509f, -0.00655265f, 
    -0.02578670f, 0.01782033f, -0.02042167f, 0.00090050f, -0.02614259f, -0.00669039f, -0.02155126f, -0.01737739f, 
    0.01589554f, 0.02776678f, 0.01604870f, -0.00292280f, -0.01976799f, 0.01835664f, -0.03373991f, -0.02624845f, 
    -0.01330391f, 0.01439091f, 0.00015948f, -0.01201072f, 0.01115789f, 0.01418143f, 0.01757868f, 0.00275088f, 
    -0.02966745f, 0.02567128f, 0.01687003f, 0.01912367f, -0.01970206f, -0.01749517f, -0.02358814f, 0.01129420f, 
    -0.02872028f, -0.00231113f, 0.01739006f, 0.01927447f, -0.03107601f, 0.01275111f, 0.01131402f, 0.03386177f, 
    -0.03620198f, 0.01781375f, 0.02994419f, -0.04022902f, 0.00184462f, 0.00495623f, -0.03446501f, -0.01809982f, 
    0.01344050f, 0.01358089f, -0.00999910f, -0.03293810f, 0.01478045f, 0.00533645f, -0.01703516f, 0.00512809f, 
    -0.02759601f, 0.02220677f, -0.02220142f, -0.00120261f, -0.01279171f, -0.04001857f, -0.00841615f, 0.02766181f, 
    0.00039061f, -0.02349462f, -0.02860049f, -0.01786032f, -0.00841085f, 0.03066638f, -0.03575219f, -0.01173957f, 
    -0.03635191f, -0.02375691f, 0.03050077f, 0.01899900f, 0.00990313f, 0.02530267f, 0.00988595f, 0.01488261f, 
    -0.00384833f, 0.03041847f, 0.03843357f, -0.02716911f, 0.02151057f, 0.00181628f, -0.03334557f, -0.00755199f, 
    0.02519100f, 0.01579631f, -0.00443619f, -0.03230264f, 0.00963838f, -0.01661518f, 0.02528187f, -0.01550700f, 
    0.03668854f, 0.02246210f, -0.03671517f, 0.01704890f, -0.01237240f, 0.02725687f, 0.03069672f, -0.03549669f, 
    0.00720846f, 0.01999700f, 0.02240579f, -0.03727356f, -0.02350521f, -0.00167736f, 0.02878457f, 0.02626212f, 
    0.01307531f, 0.01537805f, 0.01385556f, -0.03978982f, -0.02992300f, -0.01520826f, -0.01659476f, -0.01347843f, 
    -0.02277767f, -0.04378101f, -0.00804823f, -0.00591481f, -0.01624507f, -0.02414571f, -0.03500869f, 0.01521713f, 
    -0.02470626f, 0.01299895f, 0.00013182f, 0.01911143f, 0.02240154f, 0.01284252f, 0.01220732f, -0.00075500f, 
    -0.03920914f, -0.01674652f, -0.01530939f, 0.01378053f, -0.04031529f, 0.00421888f, -0.03422709f, 0.03304439f, 
    -0.02934999f, -0.01007330f, 0.01969829f, 0.01002748f, -0.03641742f, 0.01049977f, 0.02705111f, -0.02208413f, 
    -0.01033240f, 0.01653366f, 0.02663622f, -0.01424251f, 0.03242643f, 0.00847574f, 0.03102228f, 0.01656791f, 
    -0.03443545f, 0.00468922f, -0.01286974f, -0.02480313f, 0.02503303f, 0.01669987f, -0.00512442f, 0.01631658f, 
    -0.01502447f, -0.00193984f, 0.01209954f, -0.03233688f, 0.01352622f, 0.01712320f, -0.02706774f, -0.00497109f, 
    0.02772729f, -0.00716942f, -0.04010029f, -0.01036007f, 0.01753542f, -0.04544713f, -0.00870460f, 0.02415287f, 
    -0.02657618f, 0.03443104f, -0.02456594f, 0.02375542f, 0.02188863f, 0.02044684f, 0.01693538f, -0.03428715f, 
    -0.00884250f, -0.01322359f, 0.02295942f, 0.01122840f, 0.01900600f, -0.00298612f, 0.00526833f, 0.01157599f, 
    -0.00764712f, -0.02553209f, -0.01290120f, -0.02290206f, 0.02173081f, 0.02303377f, -0.01281284f, -0.01993088f, 
    0.00755764f, -0.02362340f, -0.01299173f, 0.01919933f, 0.01923407f, 0.00204989f, -0.03799107f, 0.01533404f, 
    -0.00806161f, -0.00643423f, 0.01462100f, -0.02973162f, -0.00926239f, -0.00511645f, -0.02988620f, -0.00188751f, 
    0.00742418f, 0.00291637f, -0.03030095f, -0.00404634f, -0.01669098f, -0.03341114f, -0.02194268f, -0.02239377f, 
    -0.01149228f, -0.00496296f, -0.03048188f, -0.03294967f, 0.02069794f, -0.00580639f, -0.02136228f, -0.03167402f, 
    -0.03901267f, -0.02575888f, 0.02119700f, 0.00888708f, -0.02202820f, -0.02077284f, -0.02124897f, -0.00931836f, 
    -0.01735752f, 0.01840861f, -0.01025555f, -0.01223223f, 0.00895025f, -0.03415637f, -0.03568604f, 0.01101002f, 
    0.01004249f, 0.01541579f, -0.00903902f, -0.02028711f, -0.00003483f, 0.00597060f, -0.01034688f, 0.01751840f, 
    -0.00926795f, 0.01064312f, -0.01705738f, 0.02847823f, 0.01014136f, 0.02554026f, -0.02668905f, -0.01651187f, 
    -0.03532996f, 0.00310615f, -0.03236136f, 0.00515440f, -0.00267301f, -0.04309274f, 0.01021149f, 0.01092555f, 
    0.01940002f, -0.02847052f, 0.03364641f, -0.01942694f, -0.02410989f, 0.01519015f, 0.02398408f, -0.03056908f, 
    0.03573898f, 0.00242770f, 0.00069432f, 0.01938405f, 0.01896213f, -0.02191704f, 0.01177809f, -0.03292312f, 
    0.00832869f, -0.00412926f, -0.00307463f, -0.02203661f, -0.03359007f, 0.02071746f, 0.02587559f, 0.01725426f, 
    0.00445008f, -0.01529521f, 0.02741029f, 0.01276150f, 0.03176304f, 0.02450619f, -0.02690307f, 0.00698366f, 
    -0.03584211f, 0.00173445f, -0.00371305f, 0.01034894f, -0.00592216f, -0.00341016f, -0.01631585f, -0.00055627f, 
    -0.02904314f, -0.03116453f, -0.03521091f, -0.02781361f, 0.00293293f, 0.01459909f, -0.00914242f, -0.02807102f, 
    -0.02621019f, 0.01009488f, -0.00761080f, -0.00094161f, -0.03320558f, -0.02954777f, 0.00232757f, -0.02713581f, 
    0.01997441f, -0.02529791f, 0.00795727f, -0.01978255f, 0.01311859f, -0.02175705f, -0.01661409f, -0.00786762f, 
    0.02337990f, 0.00042987f, -0.01684293f, -0.01089653f, -0.01619689f, 0.03962024f, -0.01311078f, 0.02310484f, 
    -0.03820482f, 0.01552811f, -0.00618389f, 0.00205412f, -0.01683119f, 0.01110005f, 0.03501788f, 0.02276126f, 
    -0.01067822f, -0.01326649f, -0.02249118f, 0.00073597f, 0.01711293f, -0.02303943f, -0.02543202f, 0.00440667f, 
    0.01475544f, 0.03612335f, -0.02126743f, -0.03444894f, -0.01750342f, 0.02567496f, -0.02078136f, 0.00077457f, 
    -0.01048858f, 0.02584232f, 0.01136674f, -0.01151304f, 0.01449691f, -0.02686532f, 0.01793998f, -0.02910106f, 
    -0.00621054f, 0.01933300f, 0.03888132f, 0.01938521f, -0.00883742f, -0.00384328f, -0.01252694f, -0.01743689f, 
    0.01315153f, -0.02156134f, -0.02103003f, 0.03884705f, -0.02912974f, 0.00912645f, -0.02216826f, -0.00924153f, 
    -0.01763799f, -0.01799354f, 0.03422075f, -0.01704401f, 0.00384895f, 0.02726453f, 0.03512654f, 0.03374245f, 
    -0.02721628f, -0.02974261f, 0.02664127f, 0.00626656f, 0.00697191f, -0.01527210f, -0.00535330f, -0.02321239f, 
    0.03890724f, 0.02515112f, -0.01140361f, -0.02151113f, 0.03531398f, 0.00625297f, -0.00804829f, -0.00726106f, 
    -0.04241864f, -0.01365147f, -0.01416005f, -0.01455155f, 0.00937307f, -0.03166264f, -0.04199310f, -0.00442539f, 
    -0.00155203f, -0.01214763f, 0.02659274f, -0.03137097f, -0.04015483f, -0.02198259f, 0.00923202f, -0.01633245f, 
    0.00720368f, -0.03215800f, 0.00662786f, 0.02644044f, -0.01322486f, 0.00291203f, -0.02490572f, 0.00271427f, 
    0.00005381f, -0.00160473f, -0.02571053f, -0.02504216f, -0.01137291f, -0.01328657f, 0.01732897f, -0.03510303f, 
    -0.02229117f, 0.01565592f, 0.02268330f, 0.01222296f, -0.02030189f, 0.00602005f, -0.01029975f, 0.01841682f, 
    0.00034234f, -0.04197541f, -0.00632302f, 0.02177455f, -0.03186980f, -0.04196573f, -0.01093175f, 0.01907771f, 
    -0.00563964f, -0.03367251f, -0.02155184f, -0.02398431f, -0.03376317f, -0.03747230f, 0.01086509f, -0.00752305f, 
    -0.02517501f, -0.02285206f, 0.00068905f, -0.03243092f, -0.02398911f, 0.00740321f, 0.01124142f, -0.00154577f, 
    -0.01873884f, 0.02499780f, 0.02777523f, 0.01532481f, 0.01626704f, 0.00956152f, -0.01313549f, 0.00748126f, 
    0.01216202f, 0.01618907f, 0.02838577f, -0.01807876f, -0.03871509f, 0.00995010f, -0.03863763f, 0.00769280f, 
    0.02137746f, 0.02897862f, -0.00669224f, 0.02035293f, -0.02541469f, -0.01122178f, -0.00617812f, -0.00239558f, 
    0.01614068f, -0.00311370f, 0.00274168f, -0.02780919f, -0.01614730f, 0.02422787f, -0.01259220f, 0.02140644f, 
    0.01299272f, -0.00631695f, 0.02571181f, -0.02371880f, -0.00797814f, 0.02103679f, -0.02983646f, -0.04291341f, 
    -0.02592360f, 0.00039335f, -0.00775818f, -0.04020266f, -0.03690997f, -0.02801232f, -0.00510545f, -0.03653663f, 
    0.01197994f, 0.00364518f, -0.03616881f, 0.01812736f, -0.00015376f, -0.01118614f, -0.03104739f, -0.01996784f, 
    -0.02628552f, -0.00857433f, 0.01115857f, -0.03115566f, 0.00163756f, -0.03520485f, 0.02301788f, 0.01880298f, 
    -0.01533153f, -0.01624543f, 0.02616583f, -0.00532329f, 0.00292190f, 0.02119115f, 0.01148531f, -0.01151975f, 
    0.01526803f, 0.03322963f, -0.02147629f, 0.00977117f, 0.01090696f, -0.01110949f, -0.00117046f, -0.04649572f, 
    0.00098939f, -0.00900705f, -0.01039180f, -0.03722573f, -0.02425042f, -0.00934788f, -0.02490468f, -0.01114765f, 
    -0.01059394f, 0.02507129f, 0.00462407f, -0.01127421f, 0.03362530f, -0.01650458f, -0.03054606f, -0.04069021f, 
    -0.01872065f, -0.02343420f, -0.01047289f, 0.00242850f, 0.01771102f, 0.02881381f, -0.03940814f, -0.01385953f, 
    -0.01772344f, 0.03125738f, -0.00374344f, 0.01477534f, -0.02948585f, 0.00355885f, -0.03825071f, 0.02700431f, 
    -0.00824459f, 0.02905582f, -0.01621628f, 0.03379739f, 0.00287984f, -0.01838820f, -0.03437167f, 0.01694811f, 
    -0.00371423f, 0.02646412f, -0.01256845f, -0.00897600f, 0.02872429f, -0.01360118f, -0.01092056f, -0.00370882f, 
    0.00941996f, -0.01872331f, -0.04456927f, -0.02654420f, -0.00112675f, -0.04305534f, -0.04400194f, 0.00646969f, 
    -0.00250996f, 0.01470336f, -0.02646209f, -0.00243877f, -0.01144101f, -0.01565809f, 0.00325189f, -0.04021186f, 
    -0.01030217f, 0.01599950f, -0.03183120f, 0.02547615f, 0.00916928f, -0.04256375f, 0.02658493f, -0.03398358f, 
    -0.01883895f, -0.00225667f, -0.03609660f, 0.02596546f, 0.01084596f, -0.02443478f, 0.01324871f, 0.00291154f, 
    0.01005807f, -0.00071054f, -0.00831046f, 0.02305791f, -0.03288680f, 0.02306523f, 0.00007980f, -0.02786118f, 
    0.01246033f, -0.00211575f, 0.01487833f, -0.01792825f, -0.00448593f, 0.00167407f, 0.01401027f, 0.00630930f, 
    -0.02980966f, 0.02120024f, -0.02278199f, 0.02604623f, 0.01529929f, -0.01162450f, 0.02397736f, 0.02598269f, 
    0.00200708f, 0.01692199f, -0.03032885f, -0.03609936f, 0.00888687f, 0.00777733f, -0.04117530f, -0.04095749f, 
    0.00941931f, -0.02092074f, -0.01842849f, -0.03103380f, -0.02190530f, -0.01915121f, -0.02818509f, -0.00629089f, 
    -0.04016256f, -0.03204578f, 0.02495133f, 0.00346042f, 0.02381318f, 0.00295220f, -0.01839930f, 0.00845836f, 
    -0.02778558f, -0.00585727f, 0.02464033f, -0.03891561f, 0.01112670f, 0.02743431f, -0.03618605f, 0.01386057f, 
    0.02448531f, -0.01758585f, -0.03528770f, 0.00987582f, -0.02726920f, -0.03487236f, -0.00010936f, 0.02118519f, 
    0.01571528f, -0.02903927f, -0.01755877f, 0.01877856f, -0.01905430f, 0.01287059f, -0.00750103f, -0.02607169f, 
    -0.04139025f, 0.03989353f, -0.03815969f, -0.01025630f, 0.03166620f, -0.00982807f, 0.00304866f, 0.02744192f, 
    -0.02954968f, 0.01534902f, -0.01859877f, 0.02515986f, 0.00237517f, -0.03035713f, -0.00985417f, -0.03758057f, 
    0.00265590f, 0.00219851f, -0.01854694f, 0.01142618f, -0.00936854f, -0.03706715f, 0.02625049f, 0.01035565f, 
    -0.02168861f, 0.01072760f, 0.01412172f, 0.00849298f, 0.02476546f, -0.01891499f, -0.03481674f, 0.01152047f, 
    -0.03970173f, -0.00010593f, -0.02680098f, -0.03176583f, -0.00439542f, 0.00029271f, -0.03205730f, 0.02087173f, 
    0.02981102f, -0.02302835f, -0.01141086f, -0.02528149f, -0.01589475f, 0.02565009f, -0.03542070f, 0.01788384f, 
    0.01306015f, 0.01925977f, 0.00053740f, 0.02594103f, -0.00483506f, 0.02000541f, -0.02443654f, 0.02283905f, 
    -0.01589122f, -0.00889689f, -0.01758259f, -0.04020856f, 0.01985541f, 0.00514324f, -0.02415539f, -0.00144601f, 
    -0.02251415f, -0.01397352f, 0.00779942f, 0.02405221f, -0.01565550f, 0.02503208f, 0.00304542f, -0.02577063f, 
    -0.02999594f, -0.01247498f, 0.02666259f, 0.01654034f, 0.02461385f, -0.02891079f, -0.02333597f, 0.02850703f, 
    -0.02882390f, -0.01904980f, -0.02688287f, -0.03489027f, 0.02373732f, -0.00714439f, -0.03244584f, 0.00194463f, 
    -0.03455717f, -0.02108016f, -0.01674457f, -0.01931993f, 0.00665710f, 0.00773356f, 0.00126008f, 0.02820132f, 
    -0.02756542f, -0.01755768f, 0.00884805f, -0.00438947f, 0.02158045f, -0.01001678f, -0.03390276f, 0.02994663f, 
    0.01345472f, 0.02067080f, -0.02915974f, 0.01236487f, -0.03055461f, -0.01609445f, 0.00318382f, 0.02838919f, 
    0.00842954f, -0.03715752f, 0.02407014f, -0.03548748f, -0.00100147f, 0.01174715f, -0.03801464f, 0.02671434f, 
    -0.02294298f, -0.03101442f, 0.01501520f, 0.01611514f, -0.00644662f, -0.00630350f, -0.02854533f, -0.00615637f, 
    -0.01885452f, 0.01393296f, -0.04046526f, 0.00180899f, -0.00043297f, -0.00294214f, -0.02941049f, -0.00710798f, 
    -0.00052417f, 0.02635356f, 0.01955146f, 0.01532679f, -0.02268891f, 0.04057071f, 0.00067640f, 0.00432830f, 
    0.00523285f, -0.03913162f, -0.03628189f, -0.03658361f, 0.02840236f, -0.01512286f, 0.01868644f, 0.00980330f, 
    -0.02698560f, 0.02043711f, -0.03672180f, 0.01335171f, -0.03642071f, -0.00642288f, -0.02949072f, 0.01824970f, 
    -0.00252710f, 0.02678503f, -0.01330047f, -0.03533330f, 0.00471523f, -0.01421631f, -0.00566979f, -0.00137393f, 
    -0.01672152f, -0.03248901f, -0.00540581f, 0.00828044f, -0.00771568f, -0.02725946f, -0.01638937f, -0.02694668f, 
    0.00860772f, 0.00966506f, -0.02961160f, 0.01699026f, -0.02788311f, 0.00119142f, 0.00570220f, 0.01764471f, 
    0.00463170f, -0.01287279f, -0.02930835f, 0.00371868f, 0.00696847f, -0.02958969f, -0.03963571f, 0.00846143f, 
    -0.02057674f, 0.01286990f, -0.03526403f, -0.04188238f, 0.02901245f, 0.00260717f, -0.01073745f, -0.03378152f, 
    0.00824407f, -0.02162401f, 0.02661550f, -0.01336897f, -0.02851517f, 0.00680440f, 0.00650653f, -0.02391468f, 
    0.02048820f, -0.04053072f, -0.00715436f, -0.00834644f, -0.01570898f, 0.00407535f, -0.02452086f, -0.01992035f, 
    0.01556818f, -0.01255698f, -0.02852060f, 0.02045548f, -0.03478516f, 0.02595362f, 0.02097418f, -0.02464239f, 
    -0.00844398f, -0.00086841f, 0.01134936f, 0.02930750f, -0.00102383f, 0.01843200f, -0.00110984f, -0.03546695f, 
    -0.00672721f, -0.00973788f, -0.01281015f, 0.02488243f, -0.03381709f, -0.02896940f, -0.01670505f, -0.00982721f, 
    -0.01184611f, -0.01826237f, 0.02739586f, -0.00138957f, -0.01109406f, -0.01500721f, -0.03047321f, -0.03406265f, 
    0.00229986f, -0.02274758f, -0.00278054f, 0.02361174f, -0.00640228f, -0.00252220f, 0.02748134f, 0.01220000f, 
    0.02474097f, 0.01826146f, -0.00899726f, -0.00972433f, -0.00744488f, 0.02883587f, -0.00695920f, 0.00769688f, 
    0.00765663f, -0.03516137f, -0.03839691f, -0.03822343f, 0.01019167f, 0.01598297f, -0.00630600f, -0.03042170f, 
    -0.01647620f, 0.01465437f, 0.02481188f, 0.00409587f, -0.00292432f, 0.00004754f, -0.02612294f, 0.02425810f, 
    -0.01374097f, -0.00817140f, -0.03740798f, -0.02731119f, 0.02540937f, -0.02277759f, 0.01948816f, -0.03483394f, 
    0.01533006f, -0.00011447f, -0.02959886f, -0.02368552f, -0.03135619f, -0.01753903f, 0.02294149f, 0.01720317f, 
    -0.03049470f, 0.02984630f, -0.02325092f, 0.01933128f, -0.00330566f, -0.01820412f, -0.00523233f, 0.00575746f, 
    -0.00030327f, 0.00543549f, -0.03108730f, 0.02507188f, -0.03554102f, 0.02597291f, 0.02451226f, 0.01654027f, 
    0.02488244f, -0.02532367f, 0.00028304f, -0.01145724f, 0.01353830f, 0.00582223f, 0.02898734f, 0.00228787f, 
    -0.03780242f, 0.02269459f, 0.02609710f, -0.02091564f, -0.01974672f, 0.00175271f, -0.02208411f, 0.00318842f, 
    -0.00803753f, -0.00707238f, -0.00817338f, -0.03552406f, -0.03087796f, -0.01405324f, -0.01678867f, -0.02594787f, 
    -0.01138464f, 0.02383172f, 0.02470123f, 0.02173976f, -0.01452584f, 0.00955739f, 0.01999697f, -0.01166062f, 
    0.01532444f, 0.01881261f, 0.02691657f, -0.00955223f, -0.04133085f, 0.02015155f, 0.01696089f, -0.02669127f, 
    -0.02046987f, -0.00277004f, -0.00160716f, -0.00038740f, -0.01995564f, -0.00153966f, -0.01327418f, -0.03396439f, 
    -0.03328896f, -0.03622813f, -0.03035405f, -0.04079849f, -0.00855920f, -0.01427602f, -0.00262004f, 0.01310105f, 
    -0.03253746f, 0.00042958f, -0.03259710f, -0.04183334f, -0.02976470f, 0.02624049f, -0.01652787f, -0.01909857f, 
    -0.02300106f, 0.01598236f, -0.03688703f, -0.02273368f, 0.02896018f, 0.02879835f, 0.00946712f, 0.00932430f, 
    -0.01230970f, -0.03164596f, 0.01841877f, -0.01231778f, -0.02594649f, 0.02142994f, -0.00625861f, -0.01307292f, 
    0.01967365f, 0.00976826f, -0.02926309f, 0.02940890f, 0.02194044f, -0.03602146f, 0.00822139f, 0.01855187f, 
    0.01273133f, 0.00720568f, -0.00955774f, 0.01848115f, -0.00521628f, -0.02907624f, 0.00885155f, -0.02498607f, 
    -0.00279594f, -0.03063212f, -0.03451576f, -0.00579073f, 0.02240956f, 0.01885762f, 0.00857910f, -0.01871477f, 
    -0.00713640f, 0.04079896f, -0.00570984f, -0.01172494f, -0.00326963f, -0.00975522f, 0.00036590f, -0.01331214f, 
    -0.00638167f, -0.02482383f, -0.02620833f, -0.03222654f, -0.00794009f, -0.00346847f, -0.03450538f, 0.00346827f, 
    -0.03457423f, 0.01200935f, -0.00934306f, -0.02331685f, -0.02857624f, 0.01615828f, 0.02577621f, -0.03650622f, 
    0.00260987f, 0.01193615f, -0.02885773f, -0.01436988f, -0.00628879f, -0.00870499f, -0.03028307f, -0.02878160f, 
    -0.01851992f, -0.04032468f, -0.00189320f, -0.02459325f, 0.00951808f, 0.00653072f, -0.01667692f, -0.03339957f, 
    0.01594556f, 0.03834682f, 0.00508560f, -0.00505227f, -0.02241588f, 0.00968918f, -0.00616154f, -0.02408487f, 
    0.01583939f, -0.03801329f, -0.00064904f, 0.02417913f, -0.02840870f, 0.01789540f, -0.02448961f, 0.02905640f, 
    -0.02250851f, -0.01251391f, -0.02575548f, 0.01860845f, 0.02690523f, 0.00949171f, 0.00258593f, 0.00921135f, 
    0.01463897f, 0.00288605f, 0.01745759f, 0.02979085f, -0.04133961f, 0.01555729f, -0.00412794f, 0.02225512f, 
    0.00907597f, -0.00737987f, 0.02072421f, 0.02034570f, -0.03383020f, -0.00739169f, 0.03041770f, 0.00710878f, 
    -0.01587760f, 0.00400548f, -0.02658758f, -0.00800029f, -0.00741221f, -0.01233114f, -0.04175922f, 0.02609722f, 
    -0.03930126f, 0.02360520f, -0.03814999f, -0.03742914f, 0.02260766f, 0.00148347f, -0.04111331f, 0.01969875f, 
    0.02072582f, -0.01235368f, 0.02241238f, 0.01042837f, -0.02098852f, 0.02988477f, -0.00144793f, -0.03657507f, 
    0.01035517f, 0.00367407f, 0.02645149f, 0.02521056f, 0.01757788f, -0.02006654f, -0.00558241f, 0.02648899f, 
    -0.00689761f, -0.02458375f, -0.03270584f, -0.00804104f, -0.02166107f, 0.01378353f, -0.03599880f, 0.01555504f, 
    -0.01731271f, -0.03009609f, 0.00108735f, -0.00460470f, 0.01086796f, 0.00517379f, 0.02964260f, -0.03222772f, 
    0.01536409f, -0.02605125f, -0.01935112f, -0.01860014f, -0.01865588f, 0.02398387f, -0.03713300f, -0.00595631f, 
    0.01978531f, -0.00386816f, -0.00206684f, -0.02451955f, 0.02741770f, -0.00963340f, 0.02366762f, -0.00625094f, 
    -0.00594872f, -0.02920070f, -0.00130012f, -0.04015954f, 0.01923873f, -0.03216241f, -0.00533143f, 0.02963673f, 
    0.02010054f, -0.01866917f, 0.02624385f, -0.01564452f, 0.01414083f, -0.03171358f, -0.03109162f, -0.01900224f, 
    -0.00242652f, -0.01396717f, -0.01206749f, 0.00745256f, 0.01246427f, 0.03630007f, -0.01779548f, -0.00223090f, 
    -0.00101559f, 0.01074515f, -0.01626632f, 0.00592168f, 0.00157758f, 0.01255851f, 0.03594073f, -0.00427368f, 
    -0.01024784f, 0.00116753f, 0.01972255f, -0.02765062f, 0.02958635f, -0.02783315f, 0.01350837f, 0.00657565f, 
    0.00779263f, -0.01937370f, 0.02137791f, -0.00245020f, -0.00756378f, 0.01433226f, -0.02709986f, -0.00993627f, 
    -0.00951262f, 0.02464187f, -0.02612458f, 0.01993170f, -0.00741684f, 0.02286123f, -0.02176840f, 0.02313614f, 
    -0.03608544f, 0.01963796f, -0.04092808f, -0.00740356f, -0.01216443f, -0.03580449f, -0.00649280f, -0.03595171f, 
    -0.03878728f, -0.01812007f, -0.02343366f, -0.01227103f, -0.01484263f, -0.01046216f, -0.03228316f, -0.04040191f, 
    0.02903313f, 0.02121381f, -0.01013873f, 0.01755970f, -0.04155221f, 0.01320525f, 0.01108840f, -0.03300032f, 
    -0.02265605f, -0.00423641f, 0.01295828f, -0.02282191f, 0.01457764f, 0.02677468f, 0.00861635f, 0.02310069f, 
    0.01425721f, -0.03930816f, 0.00447902f, 0.02421957f, -0.00920275f, -0.01738091f, 0.02039595f, 0.00842037f, 
    -0.01998521f, -0.01890718f, 0.01223554f, -0.03936401f, 0.00966706f, 0.00295832f, -0.01681282f, -0.01378263f, 
    -0.02216052f, 0.00535005f, -0.00056351f, 0.00120241f, 0.00531804f, 0.00045423f, 0.02212503f, 0.03312822f, 
    0.01282146f, 0.02727775f, -0.02513449f, 0.02955918f, 0.01598335f, -0.00730950f, -0.01671176f, -0.01136554f, 
    -0.00182469f, 0.00487842f, -0.01518548f, -0.02774371f, 0.02437871f, 0.00194782f, -0.00867358f, 0.01508035f, 
    0.04165036f, -0.01386459f, -0.01442707f, 0.00752521f, -0.01995846f, 0.02461998f, 0.02703294f, 0.02852552f, 
    -0.02309025f, 0.01548980f, -0.02668196f, -0.01243106f, 0.01774844f, -0.02090471f, -0.03172587f, -0.03500798f, 
    -0.02046927f, -0.03154329f, 0.01522332f, -0.00794008f, -0.00318799f, 0.00979635f, -0.04125720f, -0.00448148f, 
    -0.02829348f, -0.00069654f, -0.00595533f, -0.03303231f, -0.00391306f, 0.02776165f, -0.02526273f, -0.00440746f, 
    -0.02828428f, 0.01097206f, 0.00104698f, -0.00582597f, -0.02613886f, -0.02724988f, -0.03323511f, -0.03636970f, 
    -0.02100744f, -0.01580622f, -0.03842625f, 0.01019571f, -0.02363456f, -0.02314372f, 0.01093742f, 0.01671275f, 
    -0.03670473f, 0.00327884f, -0.00891159f, -0.00692766f, -0.03055751f, -0.03401951f, 0.02194689f, -0.02235413f, 
    0.02184677f, -0.00056645f, -0.01408942f, 0.03111331f, -0.03387867f, 0.02618674f, 0.02719082f, -0.03721138f, 
    0.01941951f, 0.01831963f, 0.02638019f, -0.01955075f, 0.01869570f, 0.02296610f, -0.01206672f, -0.02241891f, 
    -0.00692314f, -0.02029836f, 0.02102155f, 0.00758266f, -0.00562659f, 0.02358724f, -0.00711887f, -0.01483685f, 
    -0.00123344f, -0.03684967f, -0.02728412f, -0.00082904f, 0.02228060f, -0.00072734f, -0.00268009f, 0.01276923f, 
    0.00460731f, -0.03607039f, 0.00205773f, 0.02796453f, -0.01753620f, -0.00843093f, -0.03247298f, 0.00436221f, 
    -0.01077483f, -0.00660613f, -0.00985372f, 0.00388792f, -0.03175456f, 0.01358422f, -0.03661147f, -0.02773037f, 
    0.02003371f, -0.03535549f, 0.02199588f, -0.01668889f, -0.04596294f, 0.01851111f, 0.01319055f, -0.00510084f, 
    -0.00396676f, -0.03900709f, 0.00623510f, -0.03975918f, -0.01283497f, 0.00793805f, 0.00582743f, -0.00691209f, 
    0.02364340f, -0.00119522f, -0.02943193f, 0.01900449f, -0.01482007f, 0.02826162f, 0.02484257f, 0.01030490f, 
    -0.02625190f, -0.03155599f, 0.02893442f, 0.01233276f, -0.00507315f, -0.01028022f, -0.02095571f, 0.00702816f, 
    -0.00995000f, 0.02753805f, 0.00318312f, -0.00369351f, -0.02980451f, -0.02842134f, -0.02880697f, 0.01330002f, 
    0.02377328f, -0.02692292f, -0.00479894f, -0.01211641f, 0.02733824f, 0.01869017f, -0.04140898f, -0.01269779f, 
    0.00743121f, 0.03383979f, -0.01796906f, -0.01184900f, 0.00276610f, -0.03490125f, -0.01620215f, -0.02218738f, 
    -0.00928479f, -0.00198525f, -0.03559029f, 0.02152232f, 0.02553229f, -0.00821698f, -0.03203311f, -0.02723434f, 
    -0.00080826f, 0.00119843f, -0.02434297f, -0.00030973f, -0.03013510f, -0.03795964f, 0.01443572f, 0.01916002f, 
    0.01237803f, 0.00787241f, -0.01981353f, 0.00479044f, 0.02217023f, -0.01664704f, -0.00676483f, -0.01891187f, 
    -0.00461127f, -0.00606435f, -0.03281974f, -0.00987909f, 0.00987410f, -0.01107450f, -0.00431351f, -0.03371521f, 
    0.02605588f, -0.01194218f, 0.01640545f, -0.02713550f, 0.00186077f, 0.02774671f, -0.00730850f, -0.00630348f, 
    0.03530884f, 0.03271288f, -0.03351742f, 0.00943489f, 0.01348548f, -0.00346964f, -0.01330861f, 0.00937711f, 
    0.01180286f, -0.02977974f, 0.00496017f, -0.02937709f, 0.03742608f, -0.01374480f, 0.00436867f, -0.01965384f, 
    -0.00404089f, 0.01729041f, -0.04187227f, 0.00217987f, -0.03117843f, -0.03754688f, -0.00771569f, -0.02412064f, 
    0.00129606f, -0.03112448f, 0.02141926f, 0.01009800f, 0.02647390f, 0.01488524f, -0.04260819f, -0.00885737f, 
    0.00755073f, 0.00571523f, -0.01520192f, -0.01058173f, 0.00510541f, -0.02964848f, 0.01655405f, 0.00553753f, 
    0.00210624f, -0.02222024f, -0.04007379f, -0.03426486f, -0.01419750f, 0.02600139f, 0.00272673f, -0.00515628f, 
    -0.01227912f, -0.03625019f, -0.01143328f, 0.01279217f, -0.02890398f, 0.00160237f, 0.02636447f, 0.03184323f, 
    -0.00094926f, 0.01810332f, -0.03655022f, -0.00249581f, 0.00347365f, 0.02095587f, 0.02666640f, -0.01081701f, 
    -0.01511750f, -0.03636273f, -0.01413448f, -0.00898078f, 0.02308928f, 0.02713822f, 0.00794843f, 0.01933790f, 
    0.01553659f, -0.02022718f, 0.00467436f, -0.00890200f, -0.00381102f, -0.03062273f, -0.00809770f, -0.00611445f, 
    -0.04011119f, -0.00635905f, -0.00673619f, -0.01231853f, -0.03186654f, -0.02463403f, 0.01710409f, 0.00545052f, 
    -0.00530173f, -0.03099974f, 0.02310270f, -0.02623786f, -0.01410753f, -0.02016165f, 0.03036164f, -0.00081182f, 
    0.00838718f, 0.02529141f, -0.02652317f, -0.01844827f, -0.00924135f, 0.00554053f, 0.00292219f, -0.00238044f, 
    0.02276761f, -0.03692712f, -0.03374841f, 0.00005917f, -0.01769197f, 0.01247949f, -0.03535447f, 0.02788911f, 
    0.01379841f, 0.02289953f, -0.03053665f, -0.03234915f, 0.01218353f, -0.02104624f, -0.00079988f, -0.00822808f, 
    0.01925152f, 0.02671806f, -0.00253887f, 0.01195969f, -0.01732337f, 0.02802653f, -0.02806943f, -0.02282695f, 
    -0.01698542f, -0.00295534f, -0.00784962f, 0.01770794f, 0.02192855f, 0.00995164f, -0.00781173f, 0.00877085f, 
    -0.02530131f, -0.00407191f, 0.01623783f, -0.00605003f, -0.01430050f, -0.01874452f, -0.00773037f, 0.00124598f, 
    0.02944244f, 0.00313795f, -0.01757709f, -0.04189890f, 0.01727669f, 0.03830710f, 0.02828966f, -0.00242545f, 
    0.01027155f, 0.02181369f, -0.01060552f, -0.00637847f, -0.04074659f, 0.00260565f, 0.01212783f, 0.02773086f, 
    0.00431352f, 0.01778171f, -0.02072883f, -0.02228365f, -0.03983196f, -0.00357504f, 0.00566680f, -0.03145320f, 
    0.02541540f, 0.01975219f, 0.01213419f, -0.03151622f, -0.02199649f, 0.02808690f, 0.02259482f, -0.02848276f, 
    -0.00783089f, -0.03084124f, 0.02200016f, -0.03461888f, 0.02771374f, -0.01873594f, -0.02017451f, -0.02500664f, 
    0.00978141f, 0.01780180f, 0.01565534f, -0.00376367f, -0.03589504f, -0.03201746f, 0.01220479f, -0.02570334f, 
    0.01021684f, 0.00134839f, -0.02138944f, 0.00656074f, 0.01471884f, -0.01108546f, -0.02293209f, 0.02441461f, 
    -0.00351971f, 0.01046512f, -0.02816083f, -0.03853628f, -0.03111024f, -0.03235615f, -0.00904399f, -0.01030867f, 
    0.03001990f, -0.02405828f, 0.03131120f, 0.01932954f, 0.01032999f, 0.00970343f, 0.02151924f, -0.01091481f, 
    0.00655253f, 0.02213995f, -0.02903875f, -0.03213654f, -0.03494208f, -0.03979822f, -0.03096519f, 0.02913673f, 
    -0.03618868f, -0.00670632f, 0.00329904f, -0.01966850f, 0.02816614f, 0.02382617f, -0.01502202f, 0.01838970f, 
    0.00340209f, 0.01017147f, -0.01372873f, 0.01077020f, -0.00645449f, 0.01670218f, -0.04516377f, 0.02822093f, 
    0.00496745f, -0.01913237f, -0.00431644f, -0.03622834f, 0.01233482f, -0.03844786f, 0.02060856f, -0.00407521f, 
    -0.02722678f, 0.00465938f, -0.03741699f, 0.00573918f, 0.03388570f, 0.01876412f, 0.02095416f, -0.03516468f, 
    0.00819838f, 0.02900720f, 0.00428246f, 0.00136619f, -0.01377708f, -0.02965829f, -0.02910379f, 0.01294229f, 
    -0.04208218f, -0.03006927f, 0.00918718f, -0.01703206f, -0.02760183f, 0.01423455f, 0.01442747f, -0.01228892f, 
    -0.01725679f, 0.00886082f, -0.01154331f, -0.02921540f, -0.02519313f, -0.03333048f, -0.00498049f, 0.01549323f, 
    -0.01013443f, -0.03051914f, -0.00839578f, -0.03380745f, 0.00504913f, -0.00959907f, -0.04294578f, -0.02880063f, 
    0.00329826f, 0.01067410f, -0.01909953f, -0.01790039f, 0.01719791f, 0.01998995f, -0.00082913f, 0.00408053f, 
    -0.00166936f, 0.03167761f, 0.02145943f, -0.03415938f, -0.01007978f, -0.04321502f, 0.02925977f, -0.00643669f, 
    0.02002913f, 0.00146608f, -0.02066854f, -0.00082240f, 0.01051252f, 0.00285090f, 0.00247777f, 0.02409974f, 
    -0.01211330f, -0.00612752f, 0.00530791f, -0.00647414f, 0.01068862f, 0.02324241f, 0.02825652f, 0.03343481f, 
    0.01479989f, -0.03175954f, -0.01274786f, -0.01007732f, -0.02337321f, -0.02746951f, -0.03796935f, 0.01399853f, 
    0.02262202f, -0.04175707f, 0.02939142f, -0.02216621f, -0.02869566f, 0.00653246f, -0.02143897f, -0.01394028f, 
    -0.03248718f, -0.03385828f, -0.02589245f, -0.00919725f, 0.02477926f, 0.02697431f, -0.01478908f, -0.01375511f, 
    -0.03108511f, -0.01485390f, -0.03106415f, -0.03450745f, 0.02092376f, -0.02224686f, 0.02842491f, 0.02558225f, 
    -0.01818273f, -0.02181589f, -0.02869028f, -0.01249802f, -0.02171603f, 0.02806067f, 0.01870724f, 0.01041910f, 
    0.00742456f, -0.01083533f, -0.01666255f, -0.00609652f, -0.04430366f, 0.03198064f, -0.03104412f, -0.02258924f, 
    -0.03414232f, 0.02471977f, -0.00650742f, -0.00154608f, 0.01659577f, 0.01194682f, 0.00246921f, 0.02710052f, 
    -0.01566492f, 0.03110994f, 0.01302470f, -0.03075203f, -0.01406080f, -0.01943669f, -0.03286517f, -0.02319341f, 
    0.02118982f, -0.01324496f, 0.03013268f, -0.01773008f, 0.00924265f, -0.00685263f, -0.02330834f, 0.02837223f, 
    -0.01651045f, 0.03399077f, -0.03821717f, -0.00358025f, -0.01398970f, -0.00224220f, 0.02680176f, 0.02374822f, 
    -0.01440415f, -0.00365957f, 0.00475400f, -0.00293225f, -0.01832965f, -0.01484537f, -0.01321594f, 0.00481766f, 
    0.01096989f, 0.02900768f, -0.02258369f, -0.01599006f, -0.01762824f, 0.01180252f, -0.02835028f, -0.02053051f, 
    0.01794228f, -0.02560178f, 0.00940411f, 0.02656061f, -0.03070364f, 0.03612487f, 0.02982435f, -0.01952357f, 
    0.00423873f, 0.02662382f, -0.00268873f, -0.04256752f, 0.03035433f, -0.02582671f, -0.00050985f, -0.02405752f, 
    -0.04555146f, -0.02908638f, -0.00964992f, 0.00074664f, -0.00914283f, 0.03256194f, 0.02566806f, 0.01127716f, 
    0.02299458f, 0.02128007f, -0.01087676f, -0.01672590f, 0.03652570f, 0.03186440f, -0.00547606f, 0.01996005f, 
    0.01206407f, -0.04079332f, 0.00816596f, -0.00297145f, 0.02142856f, -0.03609778f, 0.01643552f, -0.01031467f, 
    -0.03585454f, 0.04006818f, -0.01845388f, -0.01627271f, 0.01386737f, -0.02530549f, -0.02640670f, -0.02860062f, 
    -0.03248503f, -0.01774944f, 0.00730472f, 0.00442663f, -0.02143697f, 0.02750195f, -0.01935882f, 0.02061239f, 
    0.00304781f, 0.01468031f, 0.00863949f, 0.02909479f, 0.02518868f, -0.01950035f, 0.01204740f, -0.00892291f, 
    -0.03998627f, 0.00633596f, -0.00830700f, -0.01288366f, 0.02378840f, -0.00750649f, -0.02223425f, -0.01452234f, 
    -0.02787230f, -0.00532941f, -0.00760565f, -0.00981544f, -0.00736980f, -0.02983934f, -0.00167422f, -0.03775427f, 
    0.02935782f, -0.01016759f, 0.01666983f, -0.02951411f, 0.00621283f, 0.02425802f, 0.02370840f, 0.01016717f, 
    0.03451124f, -0.01636812f, 0.01879882f, 0.00928810f, 0.00349472f, -0.01861773f, 0.00891695f, 0.02948831f, 
    -0.02144162f, 0.00570832f, -0.00424717f, -0.00169634f, -0.00502829f, 0.03004696f, -0.00906645f, 0.03288152f, 
    -0.03673103f, -0.02328631f, 0.02141014f, -0.01712414f, -0.02564140f, -0.01315482f, 0.01829982f, -0.00614406f, 
    0.01211647f, -0.00103597f, 0.01784673f, -0.01081627f, -0.01985041f, -0.02670478f, 0.00900298f, -0.01947611f, 
    -0.03180536f, -0.03157736f, -0.03629703f, 0.02292040f, 0.03589256f, 0.00246466f, 0.01812742f, 0.00652555f, 
    0.01173483f, -0.00687127f, -0.00497688f, -0.00772315f, -0.01843533f, 0.00137067f, -0.01407433f, 0.01269689f, 
    0.03514156f, -0.01140567f, -0.00440158f, 0.02007254f, -0.03140637f, -0.01645037f, 0.00959086f, 0.00065811f, 
    0.02501267f, 0.00180801f, -0.03615623f, 0.00186283f, -0.03722561f, -0.02499349f, 0.02290261f, 0.00491914f, 
    0.02063888f, 0.00491067f, -0.03349015f, 0.00784663f, -0.02887610f, 0.01068145f, 0.02037800f, -0.03241321f, 
    0.01019226f, -0.03908193f, -0.01829803f, -0.00640799f, 0.02541307f, 0.01614164f, -0.03262137f, 0.00937466f, 
    0.02212286f, 0.01124065f, -0.03329511f, -0.01307963f, 0.00560493f, 0.02532993f, -0.00660215f, -0.03437247f, 
    0.00321537f, 0.00045200f, 0.02635200f, -0.03662906f, 0.00951970f, -0.00317285f, 0.00443864f, -0.02895423f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.01152412f, -0.02849438f, 0.01663474f, 0.00855921f, 0.04547304f, 0.02655318f, 0.13623367f, 0.00822065f, 
    0.00634824f, 0.02550334f, 0.01044394f, -0.01826964f, 0.05256736f, 0.06121879f, -0.01527524f, 0.02638215f, 
    0.01179765f, -0.00654363f, 0.01586518f, 0.01119479f, -0.00644035f, -0.00213438f, 0.04611562f, 0.02218159f, 
    -0.03850961f, 0.02175225f, -0.03641656f, -0.02520065f, 0.02835621f, -0.03464242f, 0.02209418f, -0.02449690f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.02288580f, 0.04291148f, 0.09074669f, -0.08830272f, 0.08616138f, 0.09040274f, -0.12840077f, -0.06508571f, 
    0.30662113f, -0.07307635f, -0.25098893f, 0.11908049f, 0.02657834f, 0.30090994f, -0.07553621f, -0.05389132f, 
    0.09548096f, 0.40880278f, 0.00303545f, 0.09118509f, 0.09383880f, 0.01371831f, 0.37210247f, -0.11766947f, 
    0.00214699f, -0.07056101f, 0.01540537f, -0.03651540f, -0.17238270f, 0.16023724f, 0.07260283f, 0.04662926f, 
    -0.16585489f, -0.12788770f, -0.09776451f, -0.01981430f, -0.20589910f, -0.13806775f, -0.22168887f, 0.14039624f, 
    -0.19658926f, -0.13891874f, 0.04899777f, 0.06929082f, -0.21124998f, 0.11227445f, 0.04419822f, -0.12084445f, 
    0.15518595f, 0.22999372f, 0.31068289f, 0.13256866f, 0.17160077f, 0.04471542f, 0.52958804f, 0.01690910f, 
    -0.03919446f, 0.01166287f, 0.09374943f, -0.16618976f, 0.15284312f, -0.15233560f, -0.11522885f, -0.01275765f, 
    0.07266622f, 0.04497278f, -0.11131407f, -0.02170141f, 0.15866701f, -0.01292021f, -0.01472281f, 0.15067157f, 
    0.12026899f, -0.05880786f, 0.29821128f, -0.04198246f, 0.32639459f, -0.01327399f, 0.03208468f, 0.14835115f, 
    -0.13829304f, 0.05504088f, -0.24432577f, -0.12339012f, -0.16375953f, 0.01824975f, -0.06292294f, 0.10492203f, 
    -0.16162015f, 0.15849537f, -0.02984647f, 0.16116323f, 0.12929220f, -0.12280364f, -0.14207290f, 0.03806913f, 
    -0.16802251f, 0.09342609f, 0.05953716f, -0.09520716f, 0.27194092f, 0.03268335f, 0.34042555f, -0.12892610f, 
    -0.37308848f, 0.07343582f, 0.14110138f, 0.06929975f, 0.00368332f, -0.27625296f, 0.00894807f, 0.12728891f, 
    0.06329221f, 0.28843427f, 0.04983888f, 0.02530256f, -0.01410622f, -0.04770437f, 0.00460943f, 0.07949772f, 
    0.06623026f, 0.10050390f, 0.11502574f, 0.05393215f, 0.14616053f, 0.11487121f, -0.10035314f, -0.16743767f, 
    -0.07035252f, 0.03595646f, -0.01784027f, -0.07008123f, 0.13015187f, -0.08226696f, 0.04947234f, -0.17199782f, 
    -0.22159076f, 0.09593896f, 0.34229732f, -0.13665563f, -0.15895353f, 0.37287173f, 0.00967920f, 0.10047935f, 
    0.12445566f, 0.01749769f, -0.29739273f, 0.14062935f, -0.01145415f, 0.10196455f, 0.26489484f, -0.00060996f, 
    0.03526329f, -0.13453689f, 0.04337394f, 0.09281410f, -0.13526092f, -0.08901367f, 0.14751145f, 0.09760645f, 
    -0.02820130f, 0.06938893f, 0.09518319f, 0.13312279f, -0.60934186f, 0.06040186f, -0.07337659f, 0.01488381f, 
    0.33999908f, -0.09564300f, 0.11465342f, 0.08804536f, -0.08266281f, 0.36353788f, -0.01698920f, -0.11123922f, 
    0.13633673f, 0.01926548f, 0.06214537f, -0.15355523f, -0.11788725f, 0.00031713f, -0.04714545f, -0.10902984f, 
    0.14895727f, 0.12487321f, -0.06774455f, 0.16069579f, 0.16309984f, 0.02759681f, 0.14179148f, 0.00179173f, 
    0.02189344f, -0.13997953f, -0.11804301f, 0.07692624f, 0.00017502f, -0.00086975f, 0.29149806f, 0.10620733f, 
    -0.07779375f, 0.17111661f, 0.31716093f, -0.06148403f, -0.21614707f, 0.36441004f, 0.12761678f, 0.05986096f, 
    -0.02634595f, -0.01594087f, 0.31625533f, -0.07757193f, -0.00336368f, 0.14984739f, -0.52170068f, -0.00665072f, 
    0.02896708f, 0.07521586f, 0.11740692f, -0.05592227f, -0.15918082f, 0.05742099f, 0.13036534f, -0.10017547f, 
    0.00947970f, 0.10285940f, -0.00872021f, 0.00834133f, 0.18603556f, 0.12493820f, 0.18561892f, 0.11137431f, 
    -0.14830659f, -0.11594985f, -0.11101307f, -0.07219177f, -0.28090125f, -0.18466027f, -0.16655883f, 0.02238600f, 
    -0.08734249f, 0.31984001f, 0.24379610f, 0.16277774f, -0.08063994f, -0.16507149f, 0.00976858f, 0.01905343f, 
    0.06181149f, 0.03224463f, -0.00732715f, 0.01369348f, 0.03821097f, 0.14352328f, -0.02877456f, -0.03605075f, 
    0.08900586f, -0.04388149f, -0.09082395f, -0.12150595f, 0.35275441f, -0.14191702f, -0.03210388f, 0.14421803f, 
    -0.07980616f, -0.11016756f, 0.15476769f, -0.10509574f, -0.19545560f, 0.30623952f, -0.14015713f, -0.16928171f, 
    -0.14378539f, -0.16386352f, -0.28398103f, -0.01820638f, 0.05787955f, -0.06693557f, 0.45970476f, 0.13135767f, 
    0.09810157f, -0.03984173f, 0.00261605f, 0.06607749f, -0.12714745f, -0.11941756f, 0.00785310f, -0.13632762f, 
    0.15165570f, -0.06721845f, -0.00143723f, 0.10890321f, 0.00839671f, -0.08790287f, 0.59199810f, 0.00297978f, 
    0.20130643f, 0.00380592f, 0.03676641f, 0.09693225f, 0.08277564f, -0.22367209f, 0.01677777f, 0.00888157f, 
    0.03687560f, 0.27699777f, 0.01490116f, 0.10778505f, 0.06294886f, 0.07594111f, -0.28896362f, -0.15593845f, 
    0.11308329f, 0.12669960f, -0.17085579f, 0.13460034f, -0.12293437f, -0.13398804f, 0.00822715f, 0.08354445f, 
    0.11900473f, 0.03916342f, 0.06456749f, -0.05174345f, -0.13654931f, 0.12060738f, -0.02920911f, 0.08350204f, 
    0.05343404f, 0.01540292f, -0.08978974f, 0.14646356f, -0.16831936f, -0.07925724f, 0.16740832f, 0.11790774f, 
    0.11468125f, -0.11471790f, -0.07866053f, -0.07013307f, -0.11743796f, 0.16340196f, -0.09121024f, -0.15923738f, 
    -0.00096124f, -0.12187344f, -0.03478809f, -0.10640101f, 0.15055487f, 0.00988142f, 0.05005539f, -0.16739972f, 
    0.03285486f, 0.00260783f, -0.16535370f, -0.02788318f, -0.15798834f, -0.16360947f, 0.30107549f, -0.07253823f, 
    -0.16505341f, 0.14826509f, -0.26875761f, 0.02935965f, 0.17036261f, 0.17336391f, -0.08461602f, -0.16231404f, 
    0.00788401f, 0.32202795f, 0.17122604f, -0.09487655f, -0.00880046f, -0.08052561f, 0.36162522f, -0.04832353f, 
    0.12324935f, -0.06686432f, 0.02984521f, -0.05322332f, -0.05805722f, 0.18115385f, 0.10070511f, -0.11934552f, 
    -0.12317607f, -0.15209086f, -0.00232939f, -0.04323080f, 0.59222907f, -0.12654574f, -0.07704940f, -0.02416991f, 
    0.08380195f, 0.11697998f, -0.07758671f, 0.02493951f, 0.28293061f, 0.26716393f, 0.02587541f, 0.07446724f, 
    0.11712835f, -0.16939797f, 0.11140259f, 0.15652891f, 0.14552979f, 0.07241481f, -0.27892005f, -0.13437656f, 
    -0.03688584f, 0.05450409f, 0.14431132f, 0.05708220f, -0.13326693f, 0.00498236f, 0.13180707f, 0.14244875f, 
    0.04270502f, -0.16125780f, -0.02947068f, -0.03258585f, 0.18878172f, 0.06468618f, -0.21170677f, -0.05064692f, 
    -0.14164929f, -0.14588965f, 0.29133877f, 0.10575226f, 0.10238031f, -0.01469992f, -0.05718836f, -0.08805210f, 
    -0.11212996f, 0.25470945f, -0.26579756f, 0.16559462f, -0.16220456f, 0.01580279f, -0.04527519f, -0.10850225f, 
    -0.16482756f, 0.15536772f, 0.00540306f, 0.07323462f, -0.06608442f, -0.00644857f, -0.04228625f, 0.07531503f, 
    0.11318157f, 0.12628804f, 0.11749780f, 0.03493064f, -0.05625818f, -0.10277905f, 0.16570061f, -0.16993712f, 
    0.43942946f, -0.11801901f, -0.19439626f, 0.11948571f, 0.44800833f, -0.28983739f, 0.03171955f, 0.05333521f, 
    -0.05748958f, -0.34633705f, 0.12486858f, 0.03718309f, 0.16307232f, -0.01188872f, 0.30973357f, -0.09398223f, 
    -0.17440228f, 0.08070405f, -0.00810047f, -0.04669000f, 0.14193374f, -0.11316551f, 0.05499049f, -0.06685494f, 
    -0.12731206f, -0.06263048f, -0.07642718f, 0.14427832f, 0.37818134f, 0.07722003f, 0.18899882f, 0.06796174f, 
    0.19481653f, -0.11013439f, 0.00944838f, 0.14700943f, -0.34064969f, -0.20122926f, 0.12226059f, 0.02059097f, 
    0.14415148f, -0.24552770f, 0.24242574f, 0.04576951f, 0.01894451f, 0.09081654f, -0.00275478f, 0.15542617f, 
    -0.03605252f, 0.08350770f, 0.09434989f, -0.03699598f, -0.14972661f, -0.06527226f, 0.13851535f, -0.02453006f, 
    -0.02409641f, 0.14955795f, 0.14868432f, -0.02805357f, 0.23396847f, 0.11407837f, -0.30031332f, -0.14367855f, 
    -0.14146587f, 0.02001046f, 0.32065943f, -0.13929021f, -0.30510360f, -0.25261509f, -0.08069517f, -0.13402326f, 
    -0.12015681f, 0.04981066f, 0.05599108f, 0.16257869f, -0.16474666f, -0.14023128f, 0.13288629f, 0.07555419f, 
    0.14533220f, 0.11825552f, 0.05895782f, 0.00609648f, 0.11566155f, 0.01179391f, -0.03759524f, 0.01480501f, 
    0.00457430f, -0.13240331f, -0.11538466f, 0.13007687f, -0.02239180f, -0.02722455f, -0.17661087f, -0.00315290f, 
    0.06282064f, 0.15825687f, 0.14561002f, -0.04727700f, -0.05806445f, -0.17686908f, 0.04801469f, 0.02297237f, 
    0.11684590f, -0.01501383f, -0.03466314f, 0.06578693f, 0.11381906f, 0.00343958f, 0.17876710f, 0.11757843f, 
    0.17383267f, 0.14754966f, 0.05820549f, 0.03442996f, 0.03982534f, 0.01201651f, -0.09861194f, -0.12389824f, 
    -0.16596660f, -0.08300760f, 0.13015686f, 0.16425036f, -0.03013185f, -0.15067533f, 0.05978303f, -0.07846366f, 
    0.10673792f, -0.02118279f, 0.27617922f, 0.16271928f, 0.19913274f, 0.47988644f, 0.02445449f, -0.13523717f, 
    0.15977123f, -0.43558961f, 0.29133642f, -0.13436890f, -0.05494832f, 0.06288207f, -0.15749840f, -0.07260158f, 
    -0.06069800f, -0.15111358f, -0.01527088f, 0.12615573f, -0.13356376f, -0.06757127f, 0.05632643f, -0.08443138f, 
    -0.11403789f, -0.16401492f, 0.01656215f, 0.11120521f, -0.17415190f, -0.03082251f, -0.28083658f, 0.08963311f, 
    -0.02017306f, -0.15058069f, 0.19052882f, 0.13038731f, -0.37521815f, -0.09215559f, -0.04446018f, 0.17202735f, 
    -0.04642418f, -0.11922996f, 0.40767559f, 0.13506067f, 0.17440957f, 0.04977776f, 0.13193570f, -0.02933579f, 
    0.02758461f, 0.04213410f, 0.16206235f, -0.14042865f, -0.08981507f, -0.05436166f, 0.09278537f, 0.06620795f, 
    -0.02544963f, -0.14964791f, -0.01691508f, -0.11698104f, 0.34145713f, 0.04786593f, 0.21816178f, 0.11301076f, 
    0.21881714f, -0.04391208f, -0.00430355f, -0.06234870f, 0.24592243f, 0.03556643f, -0.15726300f, 0.13785374f, 
    0.01521320f, -0.14903823f, -0.38544682f, 0.03097632f, 0.06590045f, 0.04266022f, 0.28976303f, -0.10069703f, 
    -0.03824087f, 0.00126305f, -0.11125872f, -0.00973772f, 0.04369145f, -0.02362063f, 0.10073155f, -0.08420600f, 
    -0.00036958f, -0.12713553f, 0.04413843f, -0.09384945f, -0.17022030f, -0.00903845f, -0.23871249f, 0.10427166f, 
    -0.30915749f, 0.14526139f, 0.19391587f, -0.08631021f, -0.24398233f, 0.00314491f, -0.04941748f, -0.13487425f, 
    -0.07342474f, 0.05439248f, 0.27764288f, 0.06167985f, 0.13866955f, 0.13511392f, 0.13484967f, 0.03533856f, 
    0.11703088f, -0.04187729f, 0.13096964f, -0.13414861f, -0.08210997f, 0.06907744f, -0.06935632f, 0.08926709f, 
    0.02204931f, -0.03177613f, 0.11742150f, -0.10553508f, 0.16593279f, 0.08419472f, 0.17845687f, -0.07794522f, 
    -0.09299923f, -0.14674632f, -0.06486878f, 0.14655481f, -0.18120749f, -0.44490963f, 0.06864095f, 0.14825457f, 
    -0.17141400f, 0.51703936f, 0.10353597f, -0.08446991f, 0.08719169f, 0.12795776f, -0.11395783f, -0.11171889f, 
    0.04141155f, -0.09595479f, 0.01896231f, 0.16126335f, 0.11189061f, 0.17879146f, 0.14569612f, -0.00046202f, 
    -0.10646241f, -0.15884365f, 0.16765216f, -0.11952761f, -0.21716088f, 0.12503244f, -0.23966235f, -0.01798247f, 
    0.27105141f, -0.05916281f, 0.17846209f, 0.13028736f, 0.21229205f, 0.30723771f, 0.18162104f, -0.00163959f, 
    0.14621085f, 0.10844801f, -0.18499812f, 0.03254666f, 0.05849266f, 0.07774763f, -0.06222751f, 0.03430072f, 
    0.15635422f, -0.16901107f, 0.10626038f, 0.14856848f, 0.14913622f, -0.02187703f, 0.01949558f, -0.10218960f, 
    0.03937740f, 0.09693139f, 0.14491907f, -0.14252096f, 0.12935679f, -0.09777601f, 0.41245207f, 0.11916336f, 
    0.04639751f, -0.03218906f, -0.14167462f, -0.15477499f, 0.28794995f, -0.36605501f, 0.06815129f, -0.14115940f, 
    0.06484412f, 0.02611140f, 0.10725746f, -0.12087727f, -0.12555704f, 0.05418091f, 0.10305439f, -0.01569879f, 
    0.14569485f, 0.04953171f, 0.03031654f, 0.14824431f, 0.02129501f, 0.15967582f, -0.06501254f, -0.06565938f, 
    0.15262824f, 0.02496720f, 0.13029109f, -0.16746449f, 0.13739021f, 0.14386517f, -0.07719759f, 0.01072023f, 
    -0.21474330f, -0.17199232f, 0.04743859f, 0.16416492f, -0.18130925f, 0.32298985f, -0.12038435f, 0.17212364f, 
    -0.14241078f, -0.06282399f, 0.07657255f, -0.09380452f, 0.15991411f, 0.01331834f, 0.45021561f, 0.13188578f, 
    0.00840992f, -0.05157702f, -0.08275243f, 0.16869192f, 0.07512607f, -0.02252248f, 0.08870225f, 0.13278067f, 
    -0.00948460f, -0.14054663f, -0.05176535f, -0.11859126f, 0.01087596f, 0.11270558f, -0.25006902f, -0.15350130f, 
    0.35253990f, 0.09957185f, -0.22913410f, -0.13819079f, 0.36007291f, -0.24216054f, 0.06445024f, 0.17467506f, 
    0.16384734f, 0.30175015f, 0.17853072f, 0.12225921f, -0.12413598f, -0.10612130f, 0.12066270f, -0.03282989f, 
    0.16963296f, -0.17595479f, -0.11040266f, -0.00610567f, 0.15622503f, 0.12541854f, 0.04074241f, -0.10510136f, 
    -0.00719453f, -0.14643477f, 0.10513163f, -0.12210539f, -0.23421726f, 0.08308448f, 0.06372557f, -0.01009354f, 
    -0.19597667f, -0.12276636f, 0.27582607f, 0.18203752f, 0.04735537f, -0.00275388f, -0.01455856f, 0.11967120f, 
    0.03709733f, -0.04559290f, 0.40320349f, -0.13071199f, -0.02260821f, -0.15882494f, -0.21030921f, 0.09648640f, 
    0.10569108f, -0.08805627f, 0.05463642f, 0.10446806f, -0.11880393f, 0.17086922f, 0.03139169f, 0.01791779f, 
    0.00562297f, -0.01341347f, -0.09514092f, -0.18251692f, 0.06848086f, -0.10358433f, -0.06168843f, 0.12979898f, 
    0.06996639f, -0.12399270f, -0.13737956f, -0.06298030f, -0.12881829f, 0.10218670f, 0.05710729f, -0.01943131f, 
    -0.11499797f, -0.13323677f, -0.12416461f, -0.08191341f, 0.01318146f, -0.02951092f, 0.11620840f, -0.08681415f, 
    0.14657614f, 0.00841831f, 0.05945038f, -0.08284428f, 0.11297945f, 0.08027069f, -0.09478158f, -0.12686303f, 
    -0.15862070f, -0.16603473f, -0.05150371f, -0.06983602f, -0.25521317f, -0.01792905f, 0.32792810f, 0.12697721f, 
    0.37987116f, 0.09894647f, -0.18760066f, -0.13971266f, 0.28831851f, 0.16565964f, 0.13642691f, 0.13941683f, 
    -0.02652292f, -0.17349307f, 0.27120599f, -0.08697464f, -0.04048849f, -0.02699426f, 0.12173487f, -0.06073773f, 
    0.16647926f, -0.09420376f, 0.12441944f, 0.15533708f, 0.05633795f, -0.17020290f, 0.01928819f, 0.00006550f, 
    0.16587685f, -0.03269213f, -0.01130610f, 0.08876934f, 0.33906242f, -0.12536313f, -0.07966210f, 0.08216276f, 
    0.26512936f, -0.00255945f, -0.04073039f, 0.10625926f, 0.08528239f, -0.00369882f, 0.12327458f, -0.17587720f, 
    0.11646819f, 0.24945793f, -0.30793357f, 0.10649343f, 0.06190103f, -0.11483363f, 0.20842305f, -0.14107925f, 
    -0.02275105f, 0.04523267f, -0.13434464f, -0.06197970f, -0.10043104f, -0.10037731f, 0.15519929f, 0.16329481f, 
    -0.12259448f, -0.10776229f, -0.13512237f, 0.07829886f, 0.04268748f, -0.13574964f, 0.13420711f, 0.02960767f, 
    0.02605481f, 0.14413570f, -0.11058649f, -0.05841456f, 0.28462481f, 0.27953440f, -0.11337457f, 0.04329227f, 
    0.14282908f, -0.29078540f, 0.09503459f, 0.07359054f, -0.09584827f, 0.06921885f, 0.30471739f, -0.13837649f, 
    -0.01026647f, -0.03803224f, -0.03132796f, 0.12030735f, -0.10141729f, 0.11963861f, -0.13926448f, 0.15510832f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.10510371f, 0.09802216f, 0.21761376f, -0.00427605f, 0.00905887f, 0.21507253f, -0.06927516f, 0.04645599f, 
    -0.07061464f, 0.09583883f, -0.06600002f, 0.16191646f, -0.01064034f, -0.10822675f, 0.08797203f, -0.12804632f, 
    -0.10391738f, 0.01381723f, -0.03838475f, 0.14341129f, 0.19687875f, -0.15267013f, 0.02343747f, -0.05944802f, 
    -0.12652205f, 0.04484091f, -0.07943160f, 0.03390788f, -0.06506488f, 0.01487757f, -0.07037684f, -0.17573121f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.26012191f, 0.37802738f, -0.28272268f, 0.02272014f, -0.54020947f, -0.57649630f, 0.00904170f, 0.13708928f, 
    -0.71924806f, 0.00457546f, 0.17054085f, 0.28684008f, -0.07067116f, -0.34931535f, 0.09483889f, -0.00900631f, 
    -0.16913158f, -0.23566417f, -0.19515510f, 0.03592168f, -0.36790720f, -0.22563922f, 0.27800635f, -0.67812347f, 
    0.13952114f, 0.01224585f, 0.41417456f, 0.13073486f, 0.06692702f, 0.13763654f, 0.01940924f, -0.00976315f, 
    0.16024250f, 0.00224872f, -0.02518625f, -0.12279167f, -0.12562913f, -0.01910342f, -0.46912131f, -0.01672636f, 
    0.29807368f, -0.06979602f, -0.06408741f, 0.25645310f, 0.07404291f, -0.61870670f, 0.41870281f, 0.12166849f, 
    -0.46955019f, -0.10784268f, -0.05705421f, -0.05341504f, 0.33381331f, -0.27503383f, -0.06598673f, -0.04983689f, 
    0.15379648f, 0.11399119f, -0.02616200f, -0.45616886f, -0.08193683f, 0.14277814f, 0.12762155f, 0.24219796f, 
    -0.23478255f, -0.62841028f, -0.05815161f, -0.23120621f, -0.44616100f, -0.42188466f, 0.23467590f, -0.22266144f, 
    -0.29329935f, 0.14580432f, 0.13228928f, -0.46558511f, 0.43956846f, -0.40175116f, 0.34578240f, 0.21563360f, 
    -0.24325244f, -0.39703086f, 0.30848572f, -0.25407362f, 0.03962734f, -0.23184435f, -0.43882588f, -0.19890201f, 
    0.13140494f, -0.17434381f, 0.10605323f, 0.11339841f, 0.10864184f, 0.16865395f, -0.04688670f, 0.18947135f, 
    0.19040710f, 0.29301944f, -0.08336037f, -0.17372935f, 0.05179424f, 0.18529554f, 0.20397221f, 0.06574444f, 
    0.04291174f, 0.08728890f, -0.15730317f, 0.23534948f, -0.38452831f, -0.34381434f, -0.61625093f, -0.09405300f, 
    -0.27239305f, -0.26951331f, 0.09020545f, 0.11560958f, -0.44842640f, 0.23852842f, -0.28913003f, 0.01309520f, 
    -0.84298360f, 0.10439491f, -0.22646947f, 0.10044194f, -0.00513418f, -0.04896102f, -0.29515070f, -0.05569679f, 
    -0.38080251f, 0.29889196f, 0.12450889f, 0.11920396f, -0.01096031f, -0.71019882f, -0.13754556f, -0.04623427f, 
    0.05463887f, 0.00520602f, 0.05927467f, -0.12212826f, -0.22977786f, 0.13483642f, 0.28699720f, 0.16125697f, 
    0.22563834f, 0.40041631f, 0.11994586f, 0.36191201f, -0.22310171f, 0.36220860f, -0.03705743f, -0.39858603f, 
    -0.05980169f, 0.17310727f, -0.22348770f, 0.11449809f, 0.04811822f, -0.31372133f, -0.21155772f, -0.10632501f, 
    0.19265017f, 0.09923130f, -0.08302287f, 0.08140441f, 0.00979407f, 0.10919724f, -0.29452184f, 0.28817147f, 
    0.10832203f, 0.14121930f, 0.08822080f, 0.32310444f, -0.16360256f, 0.26784155f, -0.16976278f, -0.19307196f, 
    0.08197827f, -0.12400609f, -0.68948072f, -0.54148507f, 0.07522428f, -0.05277477f, 0.33104640f, 0.04881757f, 
    0.18323971f, 0.07944420f, 0.15991923f, -0.17010811f, -0.18214303f, -0.41548994f, 0.22189504f, -0.17671478f, 
    -0.18908559f, -0.15823554f, 0.04241398f, 0.03249705f, 0.23502363f, 0.23494969f, 0.07843433f, 0.01862229f, 
    0.31754079f, 0.16492935f, 0.00122661f, -0.41533154f, 0.04045402f, 0.28094241f, -0.44349101f, 0.25720528f, 
    0.27457470f, -0.07977857f, -0.10798784f, -0.49124506f, 0.26927269f, -0.83118498f, 0.12443089f, -0.26159367f, 
    -0.07388035f, 0.02841696f, -0.65651429f, -0.26215491f, -0.07035620f, -0.47431171f, 0.20171657f, -0.22596192f, 
    -0.23461828f, 0.20607172f, -0.00590176f, -0.41783440f, 0.14066146f, 0.29488766f, -0.01124774f, -0.40787572f, 
    0.12924667f, -0.57710010f, -0.16874380f, -0.57848305f, 0.16388178f, 0.26056832f, 0.05148344f, -0.47354221f, 
    0.38243267f, 0.26477733f, 0.12394833f, 0.39372528f, -0.22977765f, 0.27959928f, -0.20537449f, 0.30748287f, 
    -0.16440238f, 0.10373512f, 0.25719205f, 0.19462435f, 0.03240447f, -0.38156098f, -0.21870819f, -0.26878649f, 
    0.27969676f, -0.32214096f, 0.33803096f, -0.19042961f, -0.28805536f, 0.14113680f, -0.44614229f, -0.54704142f, 
    -0.27343652f, 0.17970175f, -0.08020900f, -0.02219000f, -0.12127757f, 0.19415219f, 0.30183318f, -0.22307733f, 
    -0.29002035f, 0.06788900f, -0.14339054f, -0.16916062f, 0.25578541f, -0.75405014f, 0.00673585f, 0.59908617f, 
    -0.07868305f, -0.59795576f, 0.50541353f, -0.36710531f, -0.00843926f, 0.11904544f, 0.26924247f, -0.22801180f, 
    -0.60592830f, -0.39564556f, 0.20777170f, 0.17823997f, -0.17911299f, -0.31150299f, 0.38836530f, 0.07517439f, 
    -0.53276646f, 0.38018090f, -0.05741986f, 0.07383233f, 0.10956938f, -0.01682426f, -0.43161237f, -0.03284268f, 
    -0.19650543f, -0.81730247f, 0.01295751f, -0.25331530f, -0.20004317f, -0.26807541f, 0.32729360f, -0.28789008f, 
    0.16368976f, -0.30563602f, -0.47125950f, 0.27045816f, -0.05119652f, -0.14932673f, -0.24429706f, -0.27013603f, 
    -0.29815108f, -0.02651864f, -0.06704587f, -0.05628923f, 0.07677719f, 0.11812950f, 0.15184243f, -0.67641759f, 
    -0.19422325f, 0.23181477f, 0.14907311f, 0.19882730f, -0.59869510f, -0.17692629f, 0.34647229f, -0.22126146f, 
    -0.46364343f, -0.24587099f, 0.18440318f, -0.28282514f, 0.07320401f, -0.17125647f, -0.53945273f, -0.04197517f, 
    0.14470984f, -0.09113087f, -0.44988549f, 0.03793041f, -0.11602040f, 0.29035485f, -0.26118466f, 0.20200200f, 
    0.11012504f, -0.05504825f, 0.21590528f, 0.01575388f, 0.22190148f, -0.31791106f, 0.02870051f, -0.53367728f, 
    0.28126985f, -0.24960265f, 0.09333672f, 0.00846768f, 0.43671730f, 0.41135350f, -0.41930753f, -0.22247471f, 
    -0.12530220f, -0.17390820f, 0.23334110f, -0.62588060f, 0.11404095f, -0.33765841f, -0.49916324f, 0.20805454f, 
    -0.40622368f, 0.19550526f, -0.17417225f, -0.12955318f, 0.01197499f, -0.23222162f, 0.19324635f, 0.25858539f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.02084834f, -0.06362339f, -0.11041617f, -0.13832846f, 0.07603501f, 0.04855938f, 0.06855386f, 0.09301111f, 
    -0.13193563f, -0.04077166f, -0.04375090f, 0.06762885f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
