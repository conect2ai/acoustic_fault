#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.37493324f, 0.46336672f, -0.03118061f, -0.43391347f, 0.08450143f, 0.26324123f, -0.31089476f, -0.06277706f, 
    -0.17401588f, 0.15769827f, 0.12327430f, 0.06105851f, 0.16534394f, 0.02963624f, -0.33073646f, -0.38975170f, 
    -0.11353088f, 0.47834662f, 0.12859994f, -0.15439896f, 0.19654946f, -0.17358601f, -0.53947198f, 0.53698868f, 
    0.03961693f, -0.07499544f, -1.06034315f, -0.32592592f, 0.68170941f, 0.54609525f, -0.27759990f, -0.25803044f, 
    -0.01420408f, 0.37542889f, 0.09333243f, 0.02093151f, -0.45944536f, -0.47738957f, -0.13740249f, 0.11760312f, 
    0.38686603f, 0.12846072f, -0.23249047f, 0.06913455f, -0.54396200f, -0.21343771f, -0.12297701f, -0.72132373f, 
    -0.62798035f, -0.60844314f, 0.50815725f, 0.84449977f, 0.23138051f, -0.79535371f, 0.14007449f, 0.22904338f, 
    -0.06807696f, 0.02102891f, -0.26919189f, -0.63947701f, -0.32367784f, -0.12589929f, -0.11107294f, 0.35140055f, 
    -0.36709020f, 0.34250543f, -0.28794467f, 0.12933978f, 0.12859699f, -0.01896929f, 0.06732965f, 0.07535651f, 
    -0.28996632f, -0.20632866f, -0.11861113f, -0.32320505f, -0.45795837f, -0.92761081f, -0.51137549f, -0.80286545f, 
    0.00910291f, 0.30445835f, 0.33865568f, -0.38962761f, -0.20388316f, -0.47066557f, -0.57268059f, -0.13207996f, 
    0.54944587f, -0.30865321f, -0.15789811f, 0.20842800f, 0.13024619f, -0.26170456f, 0.09146222f, -0.19943273f, 
    -0.23863427f, 0.00933035f, 0.05105246f, -0.41581675f, 0.51957446f, 0.41028303f, -0.49809957f, -0.25015429f, 
    -0.42429963f, -0.19673972f, 0.06062328f, 0.21821645f, -0.00774581f, -0.39620253f, 0.40008560f, -0.68287963f, 
    0.71809256f, -0.13978803f, -0.29314816f, -0.13935335f, 0.19295685f, -0.15061621f, -0.38372490f, 0.04162169f, 
    -0.08915976f, 0.28226313f, 0.01691526f, 0.17212170f, 0.56761527f, -0.21265028f, -0.21197978f, -0.28632495f, 
    -0.06774729f, -0.73678446f, -0.62517303f, -0.50407082f, -0.36018953f, -0.52410990f, -0.52996355f, -0.13793883f, 
    0.04492408f, -0.16063222f, -0.11905329f, 0.16826761f, 0.26760778f, -0.08209217f, 0.07119930f, 0.01719175f, 
    -0.24312951f, 0.16716896f, 0.13860609f, 0.11142025f, 0.22703080f, 0.50026995f, -1.46277964f, 0.29776004f, 
    0.01303363f, 0.26507413f, 0.76843625f, -0.12722124f, -0.14809920f, 0.54872584f, -0.12752263f, -0.20727672f, 
    -0.01231832f, -0.09814357f, -0.22320589f, 0.09875023f, 0.12501451f, -0.04554667f, -0.11123458f, -0.00829109f, 
    -0.00670717f, 0.30166337f, -0.01228942f, -0.32027215f, -0.06686907f, 0.35741246f, 0.01430690f, -0.75162375f, 
    0.80283225f, 0.21843463f, -0.43555272f, -0.75992352f, -0.15865916f, 0.53332353f, 0.29165107f, 0.54421645f, 
    0.22623509f, -0.11651316f, -0.42257643f, -0.32716352f, 0.25934210f, -0.14645666f, 0.19979316f, -0.47707352f, 
    -0.21408197f, 0.10746540f, 0.05790083f, -0.32607797f, 0.08179449f, 0.18903422f, -0.04831190f, 0.17278302f, 
    -1.37529683f, -0.44401467f, 0.11446029f, -0.81290197f, -0.91104788f, 0.52439213f, 0.12292285f, -0.19413021f, 
    0.22738308f, 0.65373999f, 0.04038084f, 0.08251953f, 0.06288344f, 0.26207757f, -0.02113257f, -0.22608183f, 
    -0.24964786f, -0.40345830f, -0.30739594f, 0.02102427f, -0.07655399f, 0.13145246f, 0.00104394f, 0.00938610f, 
    -0.29837716f, -0.45578930f, -0.62455982f, -0.83692610f, -0.64225382f, -0.66372281f, 0.52420980f, 0.01263303f, 
    0.01778783f, -0.30466944f, -0.34628919f, 0.42532808f, 0.13078120f, 0.28648895f, 0.29496256f, 0.44184265f, 
    -0.08794101f, 0.06050841f, 0.13016760f, 0.05914519f, -0.08358680f, -0.46992436f, -0.32339886f, 0.09016013f, 
    0.19090647f, -0.09667592f, -1.33610678f, -0.32477391f, -0.43668595f, -1.11864865f, -0.78899109f, 0.96526289f, 
    0.13442306f, -0.64114475f, -0.29056740f, 0.46637568f, -0.26658261f, -0.31544286f, -0.16895756f, -0.51445717f, 
    -0.16109781f, 0.29236469f, 0.42440438f, 0.11691397f, 0.02518194f, -0.10272384f, 0.04052740f, -0.00885417f, 
    -0.01370701f, -0.17477985f, 0.13044311f, -0.69350469f, -0.77663213f, -0.45765570f, -0.20268627f, 0.14418736f, 
    0.05201577f, 0.60371774f, 0.29907519f, 0.57051688f, 0.23484291f, 0.12831405f, 0.13162594f, 0.05055055f, 
    0.04067603f, -0.36790735f, 0.10238000f, 0.15573426f, 0.23860237f, 0.03556818f, 0.12601544f, -0.12311526f, 
    0.04610359f, -0.05314499f, -0.07340896f, -0.10023551f, 0.26213518f, 0.25167486f, -0.12216748f, 0.14020734f, 
    -0.93693560f, 0.37889269f, 0.16333987f, -0.20438582f, 0.37469968f, 0.24762468f, -0.29798827f, -0.39788499f, 
    -0.05188784f, -0.27597460f, -0.08920560f, 0.15554237f, -0.09925038f, -0.18793875f, -0.03963019f, -0.20406495f, 
    -0.63441288f, -0.37044281f, -0.21310355f, -0.53681964f, -0.75624108f, -0.29415759f, 0.24776344f, 0.35861000f, 
    -0.25671977f, 0.34107530f, -0.71922892f, -0.65663689f, 0.47830334f, -0.10806759f, 0.14714487f, 0.08264650f, 
    -0.17545709f, 0.38653326f, -0.02663066f, -0.18988685f, 0.25298831f, 0.31486481f, 0.08355995f, -0.03693623f, 
    0.01602253f, 0.24114971f, -0.13905643f, -0.39590904f, 0.40202060f, -0.12828465f, 0.14942661f, -0.78777999f, 
    -0.30288509f, 0.96984708f, -0.30224839f, -0.45778036f, -0.23905189f, -0.52835745f, -0.68279499f, -0.34599218f, 
    0.67663157f, -0.31126869f, 0.31562063f, -0.19558842f, 0.27950734f, -0.20611386f, -0.04243451f, 0.06462884f, 
    0.05281505f, 0.12313216f, 0.19355796f, -0.08201402f, 0.19446945f, 0.15720221f, -0.22878312f, 0.38585523f, 
    0.58909869f, -0.40962607f, 0.30924952f, -0.57168168f, -0.23229319f, -0.03048921f, 0.20409480f, 0.30126262f, 
    0.02908285f, -0.20446381f, -0.01129973f, 0.56252676f, -0.08574281f, -0.36323136f, -0.20513737f, 0.03441777f, 
    0.02031522f, 0.12113737f, -0.23466411f, -0.17577197f, 0.17705083f, 0.09328375f, -0.16852333f, -0.02564644f, 
    0.60534501f, -0.54137754f, -0.90851450f, -1.40000677f, -0.75711536f, -0.19563368f, -0.07911359f, 0.55887067f, 
    0.53039008f, 0.31279176f, 0.39233747f, -0.02309448f, 0.23563056f, -0.58897161f, 0.05417318f, -0.15726574f, 
    0.03069193f, -0.27528283f, -0.02715598f, -0.07238439f, -0.17352167f, 0.15447915f, -0.31927708f, -0.24942151f, 
    -0.06288940f, -0.38262486f, -0.44433889f, -0.30990005f, -0.35783678f, -0.46709698f, -0.84428436f, -0.90570885f, 
    -0.77515167f, -0.69006538f, -1.04705000f, 0.31824017f, 0.60908198f, 0.42722782f, 0.36964682f, 0.24716452f, 
    -0.03164534f, -0.50871027f, -0.23677695f, -0.14619376f, -0.44345668f, -0.32508534f, 0.23221500f, 0.21732651f, 
    0.03908471f, -0.30532575f, 0.79876280f, 0.56959313f, 0.50742078f, -0.89615566f, -0.92637068f, 0.28555632f, 
    -0.43644774f, -0.33920318f, 0.09913228f, -0.45850605f, 0.31453642f, -0.04530820f, 0.39252549f, 0.37724587f, 
    0.11096265f, 0.03136875f, 0.03866282f, -0.15696147f, 0.17341736f, -0.29744235f, -0.16902757f, 0.21200277f, 
    -0.03494220f, -0.09383360f, -0.27880740f, 0.21667346f, 0.43696961f, 0.51877195f, 0.54982740f, -0.39795914f, 
    -1.16989720f, -0.90781975f, -0.79628235f, -0.45392385f, -0.40291741f, -0.14713693f, -0.48458964f, -0.40135586f, 
    0.10871529f, -0.29209030f, -0.22285266f, 0.05612289f, -0.17372411f, -0.19730589f, 0.06521951f, -0.16004777f, 
    0.00693726f, -0.18249722f, -0.04072359f, -0.26651984f, -0.14288296f, -0.28547993f, -0.30554280f, -0.09595218f, 
    -0.44596246f, -0.84900624f, -0.60524064f, -0.70329767f, -0.71915114f, -0.57838273f, 0.56169945f, 0.36970249f, 
    0.39414874f, -0.46425590f, -0.35360494f, -0.03332256f, 0.16794793f, 0.11769695f, -0.08432432f, -0.31395790f, 
    -0.07180940f, -0.41572550f, -0.13275512f, -0.18886043f, -0.11022940f, 0.99243426f, 1.07343447f, -0.50831962f, 
    -0.08645266f, -0.20799790f, -0.63085103f, -0.36953640f, 0.23609011f, 0.03111831f, -0.30495191f, 0.00758927f, 
    0.11652609f, 0.17921355f, -0.05734703f, -0.07566907f, 0.01698145f, 0.11325914f, 0.25396246f, -0.17491925f, 
    -0.32708129f, -0.04815777f, 0.09068947f, -0.01177395f, 0.01527029f, -0.20331980f, -0.55361164f, -1.09646046f, 
    0.06802945f, 0.42525938f, 0.61397690f, 1.03107393f, -0.29295146f, -0.07482374f, 0.28301877f, 0.75263566f, 
    0.18218777f, 0.08533445f, -0.36455229f, -0.15551974f, 0.11127321f, -0.11948917f, -0.19067140f, 0.18243636f, 
    0.11662130f, -0.38217673f, -0.14798242f, 0.13973726f, -0.15861881f, 0.12938046f, -0.04804445f, -0.46525866f, 
    -0.83325589f, -0.23580210f, -0.38275042f, 0.06151873f, -0.08458602f, -0.43656260f, -0.50460678f, -0.35975355f, 
    -0.22449408f, -0.30240715f, -0.52322960f, -0.27025598f, 0.70860451f, -0.45286432f, 0.26345855f, -0.43956256f, 
    -0.57042378f, -0.29774943f, -0.46813273f, -0.07812907f, 0.00186907f, -0.17303507f, 0.10414752f, 0.07256675f, 
    -0.17964616f, -0.32084990f, 0.44140455f, -0.32542515f, -0.82266533f, 0.63634676f, 0.14141913f, -0.14743184f, 
    0.01139297f, 0.42424890f, 0.29504567f, -0.07092017f, 0.18644878f, -0.26584637f, -0.24733487f, 0.31346372f, 
    -0.28137860f, -0.26834750f, -0.09677891f, -0.25309029f, -0.07066227f, -0.01466572f, 0.27309066f, 0.25220805f, 
    0.11033358f, -0.91435003f, -0.04097886f, -0.16624087f, 0.27273333f, 0.69284165f, -0.54615724f, -0.55578935f, 
    -0.09544949f, 0.64546716f, 0.52005631f, 0.03509845f, -0.19265750f, -0.03026197f, -0.11091287f, -0.22955725f, 
    -0.03298629f, 0.25587386f, 0.25176898f, -0.27041793f, -0.16123274f, 0.19925632f, 0.08430403f, 0.34903255f, 
    -0.06109720f, -0.06068650f, 1.12885737f, -0.65655041f, -0.83196110f, -0.38021019f, -0.67712742f, 0.25964698f, 
    0.41479957f, 0.14453241f, 0.26782456f, 0.20555411f, 0.06670427f, 0.51141238f, -0.01543264f, 0.00027359f, 
    0.02094567f, -0.07115954f, -0.30183730f, -0.18159518f, -0.03477514f, 0.07211744f, 0.17367703f, -0.20719403f, 
    -0.08863898f, 0.28318101f, 0.17280419f, -1.47635770f, 0.44075695f, -0.17360348f, -0.34753403f, 0.35561556f, 
    -0.15541841f, 0.55336350f, 0.42198107f, 0.30886912f, -0.15502240f, -0.21493641f, 0.00482159f, -0.11221542f, 
    0.12631382f, 0.21686596f, 0.00904530f, -0.20064120f, -0.29734740f, 0.14965333f, 0.44790345f, -0.04615997f, 
    -0.01735842f, 0.26186168f, -0.01309966f, -0.34934223f, -0.84356838f, -1.22636712f, -0.30798420f, 0.86058176f, 
    0.40432233f, -0.03579544f, -0.35474664f, -0.17835851f, 0.02739918f, -0.86441314f, 0.42249075f, -0.69440562f, 
    -0.57415164f, 0.20506319f, 0.15249562f, -0.15227148f, -0.32615840f, 0.23840223f, -0.02306612f, -0.21274453f, 
    -0.25742674f, 0.15545693f, 0.43417636f, -0.40030161f, -0.26181835f, 0.75248855f, 0.46869618f, 0.62126940f, 
    0.45495531f, 0.09388821f, -0.03543258f, 0.14130554f, 0.13119198f, -0.36340055f, -0.17036510f, -0.18116653f, 
    0.35290942f, 0.32403326f, -0.40249804f, -0.04682710f, -0.28115705f, 0.03920869f, -0.27541727f, -0.16027972f, 
    0.18427682f, 0.28858787f, -0.14519070f, -0.10149969f, -0.07253489f, 0.05307863f, 0.47313315f, 0.23080835f, 
    0.21750435f, 0.01752636f, -0.12223234f, -0.31170726f, 0.42329979f, 0.54480594f, 0.28870520f, 0.20778218f, 
    0.15386766f, 0.21261139f, 0.31050658f, 0.00632708f, -0.09281802f, 0.37161472f, 0.03424980f, -0.05817191f, 
    -0.14566663f, -0.20478453f, 0.22157621f, 0.16795331f, 0.12562083f, -0.12633945f, -0.05377022f, -0.55936944f, 
    0.02087683f, 0.22316718f, -0.78517520f, -0.48235857f, -0.00275463f, -0.39187965f, -0.30913806f, 0.28290254f, 
    0.15067820f, -0.18259734f, -0.23840116f, -0.40865409f, -0.03762323f, -0.09365826f, -0.02037387f, 0.13181034f, 
    -0.16704373f, -0.09006301f, -0.24444947f, 0.24995445f, 0.61084640f, 0.42979854f, 0.29847574f, 0.03564567f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.29557264f, 0.10594855f, 0.18382706f, -0.01865833f, 0.16597620f, -0.03644661f, 0.43482882f, 0.14673957f, 
    0.05599333f, -0.08133587f, -0.37293419f, -0.03083912f, 0.08503711f, 0.47218063f, 0.44730639f, 0.67014050f, 
    0.35151562f, -0.19366935f, 0.17363077f, 0.23566538f, -0.22534135f, 0.38223356f, 0.53202641f, 0.35006258f, 
    0.30370361f, 0.37712920f, 0.42390841f, 0.27061763f, 0.51923382f, -0.00566405f, 0.02199419f, -0.16699006f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.17596644f, -0.41400340f, -0.62319821f, 0.08084611f, -0.02494589f, 0.10432507f, -0.13912651f, 0.00367400f, 
    -0.09981417f, 0.03369696f, -0.08632457f, 0.05754554f, -0.01437171f, -0.01257449f, 0.27441385f, -0.16721968f, 
    -0.01019844f, -0.02392578f, 0.07311599f, -0.03608483f, -0.08204444f, -0.04967422f, 0.05429601f, 0.10221241f, 
    -0.53072065f, -0.58105242f, -0.76428175f, 0.37899619f, -0.06060312f, 0.13858183f, -0.10453667f, 0.01313828f, 
    -0.06300076f, 0.01848100f, -0.01931242f, 0.00664473f, 0.38250190f, 0.05924009f, -0.03665713f, 0.06047563f, 
    0.08832520f, 0.22600083f, 0.02982976f, -0.08727228f, 0.02061472f, 0.01042458f, 0.10820598f, 0.05285694f, 
    0.09078722f, -0.14688534f, -0.14859731f, -0.11643133f, 0.06334230f, 0.11093538f, -0.05410337f, -0.16182631f, 
    -0.14182495f, -0.07276116f, -0.22456893f, -0.16070607f, 0.26462913f, 0.21978067f, -0.02856463f, -0.25634786f, 
    0.04367651f, 0.02325991f, 0.03518780f, -0.04220420f, 0.02161384f, 0.01938468f, -0.05207844f, -0.02912266f, 
    0.16313246f, 0.03201045f, 0.22929034f, -0.40984729f, -0.13135394f, 0.00809573f, 0.18982613f, -0.03018225f, 
    -0.13533531f, -0.11874130f, 0.02675273f, -0.05459104f, -0.94698578f, -0.45011577f, 0.19472615f, -0.07612602f, 
    0.02306490f, -0.02419463f, -0.03641695f, 0.01641019f, 0.16983011f, 0.02177992f, -0.18522291f, 0.02931456f, 
    0.21008152f, -0.03568273f, 0.02154317f, -0.17431994f, 0.04627534f, 0.08588132f, -0.05426994f, 0.01350720f, 
    0.03942363f, -0.05221971f, -0.12549362f, 0.06606501f, 0.38758183f, 0.09319717f, -0.18195651f, -0.02894991f, 
    0.16887034f, 0.11267767f, -0.18847087f, -0.04062490f, -0.07163805f, 0.02418244f, 0.09793240f, 0.04425043f, 
    0.31979817f, 0.21921980f, -0.18184699f, -0.19171087f, 0.07270272f, 0.26720703f, -0.07862828f, 0.15617862f, 
    0.02715004f, 0.08282855f, 0.05148112f, 0.05042786f, 0.12296046f, 0.14442529f, 0.01415140f, -0.00739983f, 
    0.10338679f, 0.11777430f, 0.19868281f, 0.07240380f, -0.09163366f, 0.19447121f, 0.06133914f, 0.10781409f, 
    -0.47032100f, -0.21962576f, -0.02404034f, 0.03474765f, 0.08811083f, 0.00087823f, -0.10507353f, -0.02949996f, 
    -0.16146207f, 0.02163938f, 0.10305011f, 0.17181706f, -0.01051922f, 0.03297931f, 0.11514913f, -0.04520191f, 
    -0.18779632f, 0.05244079f, -0.26000065f, 0.07801700f, 0.14549172f, -0.17406756f, -0.06169064f, -0.01930587f, 
    0.20400810f, 0.11597883f, -0.01835808f, -0.22939481f, -0.15943077f, -0.06599997f, -0.03349890f, -0.02520866f, 
    0.00281271f, 0.07791266f, -0.06797393f, -0.02468502f, -0.84984392f, -0.87931466f, -0.19926389f, -0.02345298f, 
    0.02882596f, -0.01012279f, -0.02037371f, 0.02312904f, -0.18867941f, -0.22355403f, -0.13883817f, 0.08968066f, 
    0.25146917f, -0.08172892f, -0.17941545f, -0.13622646f, 0.15765220f, -0.01708498f, -0.13872537f, 0.05786863f, 
    -0.09216663f, -0.03910675f, -0.00246747f, 0.08469716f, 0.41209108f, 0.33182332f, -0.21280620f, -0.19080128f, 
    0.04496083f, -0.02155100f, -0.08340888f, 0.06948999f, 0.03156631f, -0.02259696f, 0.01491827f, -0.05902849f, 
    0.31084397f, -0.42744678f, -0.21892661f, 0.09959468f, -0.20699576f, 0.03000676f, -0.09139389f, -0.13463810f, 
    0.03118624f, -0.04708581f, 0.02274670f, 0.07287122f, 0.12631647f, 0.25228700f, 0.14236355f, -0.28786120f, 
    -0.04574093f, -0.03794027f, -0.11668427f, 0.01460470f, -0.04136424f, -0.02361282f, -0.02324584f, 0.06485115f, 
    0.36939234f, 0.27378446f, -0.13075855f, -0.11006963f, 0.18026078f, -0.04659043f, 0.01683543f, 0.19524111f, 
    -0.01047119f, -0.06871713f, -0.00606487f, 0.03627506f, -0.30204740f, -0.44543812f, -0.39526322f, -0.22148399f, 
    -0.21870035f, -0.14050858f, 0.05544750f, -0.11563102f, 0.03616645f, 0.01461263f, -0.05995420f, 0.00390414f, 
    0.24998607f, 0.07139344f, 0.11989734f, 0.00907416f, 0.02547972f, -0.01807530f, 0.06485072f, -0.07984503f, 
    -0.02835977f, 0.04978022f, -0.11273444f, -0.09672826f, 0.27256003f, 0.08620897f, -0.10804915f, -0.15679814f, 
    0.13840653f, 0.06284843f, 0.17978568f, -0.02724356f, -0.20523416f, -0.19021665f, -0.12475480f, -0.21638495f, 
    -0.18408722f, -0.50585186f, -0.22169521f, -0.17967151f, -0.00752716f, -0.05511735f, 0.04956272f, -0.06161516f, 
    -0.19343039f, -0.07907438f, -0.16738206f, -0.05010101f, 0.14178154f, 0.45512998f, 0.35751814f, -0.45848212f, 
    -0.10280357f, 0.10594980f, 0.01036174f, 0.06486920f, -0.03966947f, -0.12420744f, -0.01693641f, -0.04263806f, 
    -0.20054938f, -0.18629058f, -0.23906484f, 0.10304014f, 0.12648344f, -0.02498101f, -0.01325367f, -0.06383853f, 
    -0.12553577f, -0.12740564f, -0.11282953f, 0.01871660f, -0.06043788f, -0.39521852f, 0.08743026f, -0.14456807f, 
    -0.03112858f, 0.03304019f, 0.07487646f, -0.00582734f, -0.22251064f, -0.05254885f, 0.02005898f, 0.04174098f, 
    0.61253375f, 0.01563513f, 0.01852040f, -0.47464395f, 0.00207619f, 0.09380956f, 0.02713394f, 0.00831437f, 
    -0.02382886f, -0.06780415f, -0.16961804f, 0.06956992f, -0.42690346f, -0.23461023f, -0.40016508f, 0.26777810f, 
    0.00415496f, 0.05929708f, 0.08794154f, 0.00916348f, 0.04801917f, 0.02765644f, 0.07852951f, 0.02692699f, 
    0.07735949f, -0.02877186f, 0.00205665f, 0.07262502f, -0.02557321f, 0.06968059f, 0.04354192f, 0.06782975f, 
    -0.32540944f, -0.24123818f, -0.45998964f, -0.23821877f, 0.13097294f, 0.06988237f, 0.21041180f, -0.25058186f, 
    0.11961840f, 0.40309307f, -0.27997759f, -0.17310895f, -0.04183616f, -0.02422357f, -0.02838301f, -0.07185548f, 
    0.15473413f, 0.15024611f, 0.25484717f, 0.05429534f, 0.00754320f, -0.05739159f, 0.05442791f, -0.05391276f, 
    0.20370290f, -0.26344264f, 0.16708981f, 0.12001496f, -0.25248459f, 0.10191073f, -0.10969042f, 0.08050826f, 
    0.08282741f, -0.02059512f, -0.10861987f, -0.05233225f, -0.30640608f, -0.27493188f, -0.34856606f, -0.22778003f, 
    0.40469608f, -0.03168468f, -0.11930153f, 0.30314994f, 0.03577634f, -0.26493359f, 0.03366205f, 0.07605246f, 
    -0.05187779f, -0.13823199f, -0.00641234f, -0.07860720f, 0.25606701f, 0.01614477f, 0.32770979f, -0.02777659f, 
    0.26550978f, 0.01527996f, 0.11547949f, -0.18840653f, 0.00479870f, -0.02539603f, 0.02728093f, -0.16284290f, 
    0.05594045f, -0.13903832f, 0.03064398f, -0.26854041f, -0.07085402f, 0.16218203f, 0.09970605f, -0.11306249f, 
    -0.10123885f, -0.07445038f, 0.01474780f, -0.06269006f, -0.06599960f, 0.21674657f, 0.21194650f, 0.01801564f, 
    -0.16376153f, 0.08956389f, -0.14579330f, -0.03248084f, -0.03059684f, -0.01662448f, -0.00372230f, -0.03062469f, 
    -0.47853306f, -0.22579232f, -0.01583397f, 0.13053702f, 0.13537902f, 0.07466956f, 0.04863578f, -0.03563546f, 
    0.15525736f, 0.13444784f, 0.11739702f, 0.03314287f, -0.43955767f, 0.10927061f, 0.02699964f, -0.21610963f, 
    -0.04081088f, 0.02148248f, 0.09195308f, -0.06801604f, 0.20138246f, 0.07285499f, -0.16175322f, -0.12150920f, 
    -0.03703252f, -0.02767286f, -0.26758927f, -0.20303692f, 0.04092656f, 0.00293376f, -0.04256118f, 0.06145024f, 
    -0.22508499f, -0.14825764f, 0.11749814f, -0.13009575f, -0.07046445f, -0.05674848f, 0.20599473f, -0.07631131f, 
    0.07854410f, 0.09457052f, 0.20144150f, -0.12390624f, 0.06671967f, 0.05932603f, 0.01513924f, -0.00673925f, 
    0.60287350f, 0.35900170f, 0.25216883f, -0.09692523f, 0.16812830f, -0.02230951f, -0.31058061f, -0.10085821f, 
    0.01214050f, 0.02235693f, -0.09999215f, -0.09983341f, 0.03239581f, -0.14872065f, -0.09323088f, -0.00158929f, 
    -0.20989534f, -0.06393331f, 0.02809584f, -0.05060484f, -0.03596715f, -0.21727167f, -0.06747568f, -0.12128345f, 
    0.06311338f, 0.16176642f, 0.06218831f, -0.00163987f, -0.01549602f, -0.01143204f, -0.15107973f, -0.02466133f, 
    -0.46920377f, -0.05672906f, -0.13935323f, -0.40941411f, -0.16177146f, 0.08689146f, 0.10900944f, 0.06630268f, 
    0.10686854f, 0.01640415f, 0.02038882f, -0.11064465f, -0.03286065f, 0.08923952f, 0.04917882f, 0.03977422f, 
    -0.39844954f, 0.15630001f, -0.11190050f, -0.20508316f, -0.14067829f, -0.20192951f, -0.00084314f, 0.00078858f, 
    -0.09274503f, -0.03255736f, 0.19415109f, 0.05455304f, -0.05750044f, 0.28535983f, 0.16607377f, -0.13586539f, 
    0.01058498f, 0.05873336f, -0.08537094f, 0.05229060f, -0.10330277f, 0.12630014f, 0.11657266f, 0.12363645f, 
    -0.04834238f, -0.30171150f, -0.05430277f, -0.08698182f, 0.03063066f, 0.13177460f, -0.29334667f, -0.22849989f, 
    0.06693836f, -0.00586040f, -0.21309999f, -0.05058055f, -0.17713006f, -0.11277942f, 0.06161177f, 0.14212424f, 
    -0.15108445f, 0.18502146f, -0.13922243f, 0.32354409f, -0.05721319f, 0.00742352f, 0.03494438f, 0.07676014f, 
    0.00268648f, -0.37174031f, -0.00419752f, -0.25830498f, -0.01708803f, -0.00535655f, -0.12188055f, 0.20985353f, 
    -0.07817302f, 0.28090447f, -0.01264931f, 0.15452412f, -0.03184085f, -0.07663535f, -0.33794805f, -0.63866198f, 
    -0.06064311f, -0.33117321f, -0.18132310f, -0.01328393f, -0.04023330f, -0.06198936f, 0.02380489f, 0.08017755f, 
    -0.23932451f, -0.01102601f, -0.08282439f, -0.03299504f, -0.04391343f, 0.07361192f, -0.30142686f, -0.01065904f, 
    0.06655031f, -0.08040625f, -0.10702065f, 0.16639151f, 0.01783345f, -0.10271209f, 0.37258673f, -0.09345993f, 
    -0.04437016f, -0.18678188f, -0.04121736f, -0.03410053f, -0.02452499f, 0.05935578f, -0.07814256f, 0.20776354f, 
    0.26183510f, 0.27004880f, -0.14918622f, 0.13776501f, -0.15042248f, -0.01286300f, -0.00288920f, 0.00685597f, 
    -0.09596251f, -0.13734122f, -0.11988133f, 0.14368397f, 0.09333231f, -0.14986801f, 0.14870615f, 0.32356110f, 
    0.29334942f, 0.12170197f, 0.13950317f, 0.17534861f, 0.16219185f, -0.05231304f, 0.12956598f, -0.24116543f, 
    0.28375441f, 0.04020745f, -0.03922449f, -0.54424858f, -0.01627501f, -0.01383264f, 0.09574579f, 0.09495393f, 
    -0.15008323f, 0.04860377f, -0.00063054f, 0.17047982f, -0.74691474f, 0.21790560f, -0.02132877f, 0.03192614f, 
    0.29523879f, 0.02089335f, 0.09260136f, -0.00005110f, -0.05584919f, -0.04349296f, -0.10319719f, 0.12048090f, 
    0.79825187f, -0.35344097f, -0.20246157f, -0.23596959f, 0.01239129f, 0.00374836f, 0.09813444f, -0.03222660f, 
    0.28162897f, 0.10155784f, -0.09312371f, -0.03721962f, -0.46419790f, -0.12485850f, 0.05922976f, -0.04229939f, 
    0.08817720f, 0.02831464f, 0.07482576f, 0.02942911f, -0.00307266f, 0.17360887f, 0.08782697f, -0.05631975f, 
    -0.42927122f, 0.09859292f, -0.03360074f, -0.33086792f, 0.11311231f, -0.05068861f, 0.24940278f, 0.42251912f, 
    0.09622595f, 0.00824569f, 0.14109966f, -0.10915827f, 0.46303862f, 0.23976655f, 0.24554968f, 0.20966668f, 
    -0.09878645f, -0.03930845f, -0.04798222f, -0.05322562f, 0.05772658f, -0.08044314f, 0.00413368f, 0.10912136f, 
    0.18480086f, 0.07709256f, 0.18629096f, 0.07352628f, -0.06066963f, 0.01570397f, -0.03719437f, 0.03374607f, 
    0.03746751f, -0.04001477f, -0.05624886f, 0.06996726f, 0.03803439f, 0.20440213f, 0.20501010f, 0.13505112f, 
    0.13262624f, -0.05491520f, 0.00115475f, 0.38747627f, -0.11352951f, -0.05313605f, -0.01868921f, -0.02097870f, 
    -0.06149144f, -0.12224448f, 0.19180457f, -0.16572690f, 0.03220997f, 0.05602731f, 0.13137478f, 0.04826285f, 
    -0.01542523f, -0.10419108f, 0.15299234f, -0.09679938f, -0.10981801f, -0.03073035f, -0.19194350f, 0.16892102f, 
    0.00474608f, -0.01168796f, -0.16719410f, 0.04788115f, 0.21238495f, 0.09430049f, -0.02221872f, 0.32694939f, 
    -0.06154126f, -0.31727096f, -0.07469124f, -0.64366847f, 0.02288055f, -0.04697827f, -0.17319159f, 0.15773924f, 
    0.02528501f, 0.00148403f, 0.07575796f, 0.03192173f, -0.21227314f, 0.08967105f, 0.49933949f, 0.14844012f, 
    -0.12432145f, -0.07628257f, 0.25774255f, -0.01876051f, 0.01967917f, 0.01025568f, 0.10890986f, -0.06750622f, 
    -0.27624771f, -0.04247688f, -0.29454470f, -0.31823438f, -0.05779129f, 0.18085645f, 0.04991658f, -0.08068649f, 
    0.02829795f, -0.06068766f, -0.06453837f, -0.10303602f, -0.56065077f, -0.43100539f, -0.21538875f, -0.16915189f, 
    -0.12581782f, 0.13835822f, -0.03299618f, -0.19968529f, -0.02908749f, -0.05105888f, 0.00128420f, 0.03941418f, 
    0.07225707f, -0.09408679f, -0.28501162f, 0.19692199f, 0.09627498f, -0.08446284f, 0.08073320f, 0.02472041f, 
    -0.17450698f, 0.09973300f, -0.08375479f, 0.06808342f, 0.11021709f, -0.04389082f, -0.02823672f, 0.00385499f, 
    -0.03544714f, -0.00043504f, -0.05135494f, 0.05449518f, -0.06125724f, -0.13497350f, -0.02803005f, -0.07876611f, 
    0.53202027f, 0.34222311f, 0.37805864f, 0.61812192f, -0.02706850f, -0.04049579f, 0.06725141f, -0.03541110f, 
    -0.02905189f, -0.08769511f, -0.04615514f, 0.07708322f, -0.16216935f, 0.03629622f, 0.37171796f, -0.07463931f, 
    -0.14896391f, -0.09922103f, 0.17216662f, 0.07352343f, 0.02048934f, 0.05640398f, 0.03412240f, 0.00120447f, 
    -0.24552496f, -0.12714636f, 0.57617497f, 0.62360483f, -0.10651360f, 0.00721877f, -0.05056199f, 0.03446845f, 
    0.05790936f, 0.00380609f, -0.01006099f, 0.07488381f, -0.02029708f, 0.16551580f, 0.08058277f, 0.11284966f, 
    0.04234137f, 0.03360393f, 0.07130993f, 0.10710442f, 0.08530589f, -0.10135928f, 0.26351756f, 0.14537185f, 
    -0.01821857f, 0.02698302f, 0.02178520f, 0.08183543f, -0.00376579f, 0.00271532f, 0.04919346f, -0.15818198f, 
    0.17435168f, 0.16571081f, 0.03821201f, 0.10275912f, 0.02435165f, -0.02891788f, -0.04731977f, 0.10948207f, 
    -0.03316110f, -0.18351315f, 0.09490044f, 0.12748052f, -0.13077831f, 0.03767870f, 0.05593382f, 0.00028173f, 
    -0.20634468f, -0.08908248f, -0.02928228f, 0.03046557f, 0.09743025f, 0.03247893f, 0.15227135f, 0.00713676f, 
    0.02529208f, 0.03933186f, -0.04214427f, -0.00072701f, -0.16565423f, -0.02605378f, -0.01197320f, 0.19318691f, 
    -0.02230151f, -0.02311545f, -0.03406610f, -0.01995102f, 0.11835909f, -0.20808208f, 0.15272497f, -0.04336484f, 
    -0.26107255f, 0.63835186f, 0.05205087f, 0.22225425f, -0.03818959f, 0.09681640f, 0.19007370f, -0.02895817f, 
    0.07300950f, 0.14948112f, -0.11475462f, 0.11349580f, -0.77368462f, -0.62327898f, -0.32458019f, -0.41909319f, 
    0.08842862f, -0.03680102f, 0.02583607f, -0.14237030f, 0.00296248f, -0.03035337f, -0.05964058f, -0.07235570f, 
    -0.20493013f, 0.15687469f, 0.17562044f, -0.24989837f, 0.07482952f, -0.35307258f, -0.29786047f, -0.41458002f, 
    0.17806485f, -0.02438580f, -0.03601623f, 0.14428854f, -0.85376644f, 0.08987009f, 0.28423333f, -0.09889725f, 
    -0.15716057f, -0.14961331f, -0.27931479f, -0.08518410f, -0.00739331f, -0.01370889f, -0.01445107f, -0.02580809f, 
    -0.76164842f, -0.53651571f, -0.36614141f, -0.33250239f, 0.09874342f, 0.15277109f, -0.29226783f, -0.31447780f, 
    -0.04050140f, 0.03427541f, 0.02251115f, 0.03855130f, -0.42584893f, -0.20855519f, 0.36997238f, 0.12839068f, 
    0.04807687f, 0.01106645f, -0.01448710f, -0.17761190f, 0.06692295f, 0.00898844f, 0.06873967f, 0.10512475f, 
    -0.36831054f, -0.06994857f, 0.09805658f, 0.07967561f, 0.05859433f, 0.01807547f, 0.00488287f, 0.15241100f, 
    -0.16159621f, -0.13843431f, 0.02094116f, -0.16528422f, -0.07174069f, -0.11268982f, 0.28001437f, 0.12644447f, 
    0.04035440f, -0.01947825f, -0.06517400f, -0.05422495f, 0.01680890f, -0.05967671f, 0.05570683f, -0.13620536f, 
    0.06860052f, 0.30876383f, 0.26835912f, 0.08288638f, 0.02473458f, 0.01166868f, -0.18963178f, 0.08505627f, 
    0.03659089f, -0.17048608f, 0.09784099f, 0.16692017f, -0.18352087f, -0.29919639f, -0.12858112f, 0.14036678f, 
    -0.01444068f, 0.13126020f, 0.11551684f, 0.00427027f, -0.05216186f, -0.05692882f, 0.01892115f, 0.01321953f, 
    -0.43958622f, 0.43120590f, 0.13993789f, 0.08446081f, -0.06846976f, 0.05313573f, -0.01848673f, -0.13591026f, 
    -0.14044252f, 0.01151267f, -0.12069504f, 0.05603677f, 0.11139553f, -0.04452413f, -0.04472401f, 0.28271446f, 
    0.08765712f, -0.07481252f, 0.17944738f, 0.04771358f, 0.00735325f, 0.13652304f, -0.06417403f, -0.16975302f, 
    -0.25370619f, 0.33430019f, 0.20285439f, 0.11034803f, -0.06510898f, -0.16416761f, 0.08970394f, 0.06302033f, 
    0.02500064f, 0.03135403f, -0.02953942f, -0.01493460f, -0.27602911f, 0.00819892f, -0.24769144f, -0.52232945f, 
    -0.01427684f, -0.02209746f, -0.01569775f, 0.11805891f, 0.07553217f, -0.02935121f, -0.02704482f, 0.00439254f, 
    -0.11468717f, -0.12531881f, -0.03752751f, 0.10041671f, 0.00857535f, 0.01214625f, 0.10417227f, -0.03297697f, 
    0.01639801f, -0.25455618f, -0.06349168f, 0.06330388f, -0.10297954f, -0.17613582f, 0.06140883f, 0.11602549f, 
    -0.06768091f, 0.15399317f, -0.03935613f, 0.12097601f, -0.00563269f, -0.09952525f, -0.05482497f, -0.05881874f, 
    -0.43294993f, 0.08294750f, -0.11577714f, 0.01117538f, -0.07559108f, -0.20413913f, 0.01546641f, -0.46030128f, 
    -0.14728938f, -0.05384183f, -0.04522427f, -0.19330066f, -0.03810531f, 0.42718208f, -0.41136160f, 0.10786798f, 
    -0.19153920f, -0.11064506f, -0.00017157f, 0.09500909f, -0.08063597f, 0.22302321f, 0.01169954f, 0.05141328f, 
    0.39946195f, -0.28547409f, 0.72277176f, 0.00459111f, -0.22853477f, 0.22950253f, -0.28336877f, 0.02992900f, 
    0.11033047f, -0.02471687f, 0.42961890f, -0.12652299f, -0.00503745f, -0.27499467f, -0.09023509f, 0.27445361f, 
    -0.01531646f, -0.00174763f, 0.05212549f, -0.12018944f, 0.08376914f, 0.11847205f, -0.11269245f, 0.03066632f, 
    -0.21011983f, 0.12069253f, -0.02638013f, 0.39624178f, 0.03821401f, -0.06702868f, -0.10020301f, -0.01805699f, 
    -0.02537123f, 0.13290127f, 0.21408337f, -0.24147879f, 0.04617509f, -0.18742053f, 0.11511551f, 0.14935441f, 
    -0.01524441f, 0.05280122f, -0.04411568f, -0.07532272f, 0.13212512f, 0.06280939f, -0.05639561f, -0.26254383f, 
    -0.00074554f, 0.50018054f, -0.51104200f, -0.97338045f, -0.00022818f, 0.05457006f, -0.10727651f, -0.14909925f, 
    -0.12333505f, -0.15995198f, -0.13940813f, 0.02001485f, 1.05092812f, -0.04818055f, -0.07056308f, 0.24279755f, 
    0.05538065f, 0.30281779f, -0.03233946f, -0.03532298f, -0.17679539f, -0.07767837f, 0.28256571f, -0.18441747f, 
    0.29644531f, -0.10064302f, 0.25497538f, 0.26532927f, 0.07197903f, 0.07540921f, 0.01952956f, 0.03395966f, 
    -0.00199053f, 0.00622561f, -0.03660359f, 0.02425317f, -0.18008296f, -0.28711668f, -0.15525913f, 0.22680043f, 
    0.15697686f, 0.06555659f, 0.05418513f, -0.05655689f, 0.03020743f, 0.01367091f, 0.05523116f, 0.05240097f, 
    0.24473935f, -0.30341679f, -0.00941223f, 0.17357379f, 0.13793920f, -0.04857025f, 0.02709040f, -0.07533078f, 
    -0.06407224f, 0.12999272f, -0.04711692f, 0.15384623f, 0.13192016f, 0.06661216f, -0.02029924f, -0.03205325f, 
    0.46435601f, 0.19468674f, 0.11687154f, 0.03147473f, 0.04333088f, 0.05364518f, -0.18864793f, -0.01311177f, 
    0.01683456f, -0.08764293f, 0.14261980f, 0.05928610f, -0.15446958f, 0.07547011f, -0.00842608f, 0.05594763f, 
    0.11811137f, 0.10149991f, 0.10184573f, -0.15704331f, 0.32894903f, 0.00347553f, -0.00485832f, -0.16599609f, 
    -0.32386142f, 0.02859951f, -0.09893891f, -0.24241574f, 0.17739597f, 0.21598129f, -0.12673602f, -0.10422805f, 
    0.02104277f, -0.05964238f, -0.17324516f, 0.25682893f, -0.07255177f, -0.12208568f, 0.09204499f, -0.07678197f, 
    0.10971019f, -0.13391614f, 0.03028425f, 0.06421465f, -0.50936455f, -0.16119061f, -0.29044628f, -0.16867474f, 
    -0.11350270f, -0.07529711f, -0.39525777f, -0.04767419f, -0.05400086f, 0.12910514f, -0.13891272f, -0.16155380f, 
    -0.12086579f, -0.04369866f, -0.05075294f, 0.38089755f, -0.06262033f, 0.00465333f, -0.02060373f, -0.08160944f, 
    -0.03795484f, 0.10034430f, -0.18674248f, 0.23990463f, 0.08551821f, -0.16075830f, -0.11080693f, 0.16431527f, 
    0.02921043f, 0.15969022f, 0.17690168f, 0.09342539f, 0.03938236f, -0.09223771f, 0.05851546f, -0.07230925f, 
    -0.22024980f, 0.09399723f, 0.34018621f, 0.10618237f, -0.20265786f, 0.00997249f, -0.26520205f, 0.05466994f, 
    0.06762847f, -0.11386853f, -0.05017702f, 0.03755352f, -0.11431975f, -0.18844776f, 0.10683149f, 0.16635805f, 
    -0.06599315f, 0.03056205f, 0.20282258f, -0.10721298f, -0.10663731f, -0.06042967f, -0.08100075f, 0.08779359f, 
    -0.04649878f, -0.17526644f, -0.08352979f, 0.11987168f, 0.01458077f, 0.09190194f, 0.14644213f, 0.01765116f, 
    0.04468958f, 0.13002655f, 0.02533444f, -0.05659269f, -0.37508917f, 0.34313935f, 0.57072067f, 0.31675655f, 
    -0.02007849f, -0.01286358f, -0.23439361f, -0.07968230f, -0.17972857f, 0.01559028f, -0.10871002f, -0.12665780f, 
    -0.52826738f, 0.47002852f, 0.00476670f, -0.97793740f, 0.38798472f, -0.01485234f, 0.15108247f, 0.01415140f, 
    -0.24186414f, -0.13697459f, 0.10540069f, -0.08067737f, -0.17232053f, -0.12962650f, -0.14124356f, 0.04849162f, 
    -0.03986457f, -0.00510903f, -0.13867480f, 0.03245363f, -0.09301827f, 0.03111988f, 0.03451332f, 0.08122415f, 
    -0.14381075f, -0.11296371f, 0.19727141f, -0.10798532f, -0.00140986f, 0.17562105f, -0.14729725f, 0.00805683f, 
    0.05544689f, 0.02216000f, 0.10506381f, 0.04372690f, 0.34948444f, -0.12929918f, -0.05927251f, -0.36727682f, 
    -0.15720277f, -0.05769263f, 0.00526591f, 0.01326339f, 0.02552000f, -0.05193723f, -0.09378940f, -0.10312176f, 
    -0.70028681f, 0.23519787f, -0.06557073f, 0.33329201f, 0.03375337f, -0.03038879f, 0.10453582f, -0.17607096f, 
    -0.07001976f, 0.01137061f, 0.13880345f, -0.05087971f, 1.03858531f, 0.24043798f, -0.17895231f, -0.39146465f, 
    0.11873493f, 0.01901987f, 0.09445819f, -0.24745344f, -0.29999253f, -0.08905993f, 0.10498061f, -0.10127278f, 
    -0.18966691f, 0.22464253f, -0.30194387f, -0.00289585f, 0.06682788f, 0.03142007f, -0.22498690f, -0.01079515f, 
    -0.03587927f, -0.10612630f, 0.15073326f, 0.02038167f, -0.14044420f, -0.23837218f, -0.15801467f, -0.04657694f, 
    -0.03488253f, -0.13573533f, 0.02421640f, -0.26905924f, 0.00279238f, -0.02449297f, -0.10966187f, 0.15279089f, 
    -0.37050843f, -0.80359834f, 0.03392058f, -0.13097343f, 0.10177044f, -0.11574702f, -0.11914534f, -0.19961931f, 
    -0.06545719f, 0.10736150f, -0.06948348f, -0.14557220f, 0.46671081f, -0.03686765f, 0.19421847f, 0.23129348f, 
    -0.10672633f, 0.08793435f, -0.01515509f, -0.03396526f, 0.21906629f, -0.05574148f, -0.19553730f, 0.22465329f, 
    0.00758214f, 0.06941143f, -0.17892227f, 0.08856861f, 0.06547413f, 0.02283120f, -0.05330765f, -0.01316030f, 
    -0.03328193f, 0.02430497f, -0.21552445f, -0.14953960f, 0.17072833f, -0.18587089f, -0.10186700f, -0.18952338f, 
    -0.13302858f, 0.10113981f, -0.07393948f, -0.06149198f, 0.14569640f, 0.19784777f, -0.03186561f, 0.37729162f, 
    0.10489676f, 0.52309674f, -0.33904302f, 0.41638103f, 0.14401415f, 0.00659781f, -0.14093438f, -0.12445613f, 
    0.22257461f, 0.02983424f, -0.14406694f, 0.01022997f, -0.24112271f, 0.07531456f, 0.08107187f, -0.13879263f, 
    -0.10525183f, -0.24184015f, -0.06064865f, -0.01079236f, -0.06334119f, -0.01509873f, 0.01112201f, 0.11391218f, 
    0.00590941f, -0.26973197f, 0.17643481f, -0.09416134f, -0.07941103f, -0.10486362f, -0.16556764f, 0.13810244f, 
    -0.13772069f, -0.17404251f, 0.01069625f, -0.34070179f, 0.10932500f, 0.18761067f, 0.08606422f, 0.17729846f, 
    -0.11835614f, -0.00663581f, 0.16937403f, 0.18049352f, -0.04350942f, 0.01242030f, -0.01137916f, -0.05682818f, 
    -0.10157694f, -0.81472421f, 0.02484830f, 0.33036602f, -0.16454886f, -0.00757210f, -0.29699948f, -0.03189588f, 
    -0.28225926f, -0.11652637f, -0.03484061f, 0.00244498f, -0.00445172f, -0.10504885f, -0.20045377f, -0.35190010f, 
    0.16641244f, -0.07222447f, -0.01246297f, 0.06255944f, -0.23133175f, -0.30008543f, -0.05028674f, -0.11510419f, 
    0.05437563f, 0.36183059f, -0.00502234f, 0.24146874f, -0.15561217f, -0.10768183f, -0.00385421f, -0.11149985f, 
    0.08511616f, -0.00729820f, 0.00240382f, 0.19505593f, 0.12700275f, 0.17442626f, 0.12276756f, 0.19264574f, 
    -0.12244429f, -0.18089676f, -0.04974430f, 0.03854719f, -0.10084993f, 0.04581833f, 0.01182344f, 0.06630390f, 
    -0.16803704f, -0.06937903f, 0.02646869f, 0.10704507f, -0.12105735f, -0.16565949f, -0.00935638f, -0.12390855f, 
    0.03298333f, 0.00295851f, 0.12326279f, 0.05004067f, 0.11390962f, -0.03036478f, 0.11747618f, 0.06300852f, 
    -0.12564777f, -0.03921359f, 0.01480876f, 0.08496793f, 0.02984961f, 0.05455221f, -0.10178573f, -0.04427465f, 
    -0.13065875f, 0.09274664f, -0.20483190f, -0.12530108f, 0.03504709f, -0.07054599f, 0.12593371f, -0.10922235f, 
    0.13499251f, 0.05028316f, 0.06055548f, 0.35621589f, 0.07679829f, 0.03597615f, -0.00270262f, 0.06967398f, 
    -0.26866463f, -0.06850649f, -0.00594798f, -0.08856692f, 0.11020905f, -0.14741787f, -0.07349612f, -0.00698785f, 
    0.03120582f, 0.04177954f, 0.29401127f, 0.05713075f, 0.05341195f, -0.08607077f, -0.16103676f, 0.16208352f, 
    -0.02556016f, -0.02371715f, -0.05242914f, -0.00217279f, 0.00956197f, -0.48894414f, -0.04452153f, -0.06068836f, 
    -0.00623814f, 0.03363170f, 0.07159728f, -0.04347361f, 0.02807093f, -0.15764068f, 0.03041724f, -0.25970867f, 
    -0.13895684f, 0.02190964f, 0.14568959f, -0.10268614f, -0.05509517f, 0.03816633f, 0.00065907f, -0.10867597f, 
    0.11093480f, -0.07765361f, 0.07086242f, -0.06078734f, 0.15723842f, 0.17593466f, 0.36388427f, 0.18799187f, 
    -0.04549808f, -0.00828426f, 0.01094098f, 0.25316319f, 0.07334575f, 0.04530815f, 0.02605236f, 0.00580330f, 
    -0.06009613f, 0.21365063f, 0.04586905f, 0.31194693f, 0.31919301f, 0.10305434f, -0.09557082f, -0.23627907f, 
    0.03311695f, 0.09655163f, 0.00778225f, 0.01212819f, 0.12516548f, 0.20009090f, 0.01663852f, 0.25571933f, 
    0.00367730f, 0.26266733f, -0.04918354f, 0.12230555f, 0.00192323f, 0.00497393f, -0.02104926f, -0.05744692f, 
    0.17416979f, 0.25442958f, 0.28351182f, 0.10108089f, 0.03443666f, -0.00751188f, 0.00988002f, 0.10483630f, 
    0.01805575f, 0.02450839f, 0.13072102f, 0.01250476f, -0.03230428f, 0.05394108f, -0.20032495f, 0.01429786f, 
    -0.17625725f, -0.12085640f, -0.01976881f, 0.03261437f, 0.13622023f, -0.01177810f, 0.03349172f, -0.08488142f, 
    0.20396358f, -0.10366827f, -0.18341357f, 0.08007417f, -0.10193320f, 0.04593716f, -0.02695571f, -0.05243326f, 
    -0.09955766f, -0.00720451f, -0.22070554f, -0.14299856f, 0.06414010f, 0.06255795f, 0.09493016f, -0.02055950f, 
    -0.13508688f, -0.04128155f, -0.19984505f, -0.19914673f, 0.01346899f, 0.04699723f, -0.03662981f, 0.10624500f, 
    0.04107036f, 0.13041590f, -0.27010533f, 0.27956033f, 0.07808607f, -0.00891578f, 0.07594279f, -0.10228557f, 
    -0.19708502f, -0.39302021f, 0.03740469f, -0.31415144f, -0.08938180f, -0.23013225f, -0.06888467f, -0.10027596f, 
    0.05566178f, 0.02701592f, 0.01751956f, 0.03287778f, 0.08279841f, -0.00207869f, -0.02662137f, -0.18666191f, 
    0.07035998f, -0.16033193f, 0.01035718f, 0.03280105f, 0.01155299f, 0.01514748f, -0.06212233f, 0.16143943f, 
    -0.13602236f, -0.14025687f, 0.01302655f, 0.13875334f, -0.50855869f, -0.56154674f, -0.00899130f, -0.09147789f, 
    -0.09206446f, -0.06285476f, -0.09871261f, 0.02813855f, 0.13299212f, -0.11278615f, -0.19485672f, 0.16370146f, 
    -0.08972809f, -0.25214869f, 0.07862036f, -0.10594009f, -0.22385006f, -0.03304034f, -0.23576826f, -0.19428696f, 
    -0.15697077f, 0.09048815f, -0.13448028f, -0.04046459f, -0.05689998f, -0.01470794f, 0.09301172f, 0.16811776f, 
    0.07947980f, 0.04191820f, 0.05398590f, 0.05131106f, 0.11617615f, 0.05705519f, -0.00915239f, -0.05519702f, 
    0.00548821f, 0.08235288f, -0.04206795f, -0.01767049f, 0.12220702f, 0.07900158f, 0.08632561f, 0.09716267f, 
    0.21227010f, 0.06002670f, -0.05714858f, -0.04774789f, -0.12653932f, 0.04279473f, -0.19125926f, 0.02782889f, 
    0.00006261f, -0.11477408f, 0.08932565f, -0.35006535f, 0.05609466f, -0.01098717f, 0.00108854f, 0.04678556f, 
    -0.12618192f, 0.02230001f, -0.43974990f, -0.34404904f, -0.12039506f, 0.15411192f, -0.21200208f, 0.18424550f, 
    -0.09803793f, -0.03584623f, -0.02843823f, 0.02199302f, 0.00840404f, -0.31178424f, 0.21933074f, -0.01397790f, 
    0.00534844f, -0.09586925f, 0.02213208f, -0.00993616f, -0.23166984f, -0.50063694f, -0.12300906f, -0.32735959f, 
    -0.35945055f, 0.29143742f, -0.42473370f, -0.22294196f, 0.00744900f, 0.17686863f, 0.06972237f, 0.02625710f, 
    -0.01856781f, 0.06412591f, -0.08602497f, -0.11370440f, -0.03428283f, 0.16498402f, -0.22051084f, -0.09341134f, 
    0.01790711f, 0.09301379f, -0.24220558f, 0.07983907f, -0.00748917f, 0.03507268f, -0.04114002f, -0.09946896f, 
    0.15891115f, 0.09063109f, -0.27570504f, -0.01024874f, -0.01301837f, 0.01484178f, -0.16958597f, 0.02928070f, 
    0.21574146f, 0.01515760f, 0.13775423f, 0.45989087f, 0.09840542f, 0.11927111f, 0.14592269f, -0.07874092f, 
    0.35414720f, 0.13627657f, 0.13239160f, 0.13015297f, 0.03526628f, -0.00603404f, 0.04206914f, 0.19462089f, 
    -0.03100335f, 0.36768493f, 0.15190145f, 0.22371209f, -0.11860247f, -0.13902912f, -0.13127939f, 0.15775354f, 
    0.12525748f, -0.09163013f, -0.02240678f, -0.03093480f, -0.09184802f, -0.20978473f, -0.33315378f, 0.28567985f, 
    0.13235223f, -0.06164809f, -0.10345480f, 0.07330380f, 0.04681609f, 0.00127195f, -0.11343912f, 0.22544666f, 
    -0.66747862f, -0.35850558f, -0.10429635f, -0.23070754f, 0.00646376f, 0.00168589f, 0.00573617f, 0.02499929f, 
    0.04149380f, 0.12312540f, -0.01942609f, -0.27527881f, -0.11338468f, 0.20635174f, -0.13392425f, -0.34276098f, 
    -0.04065802f, 0.10515220f, -0.03299730f, -0.06507038f, 0.02366572f, -0.04246675f, -0.03095919f, -0.02636651f, 
    -0.59977663f, 0.17119122f, -0.04992600f, -0.34356171f, 0.12821066f, -0.15016884f, 0.13194561f, 0.20721404f, 
    -0.02149228f, -0.11852808f, 0.07797591f, 0.13546585f, -0.23501508f, -0.23935451f, -0.12698524f, -0.07809146f, 
    0.08653460f, -0.07642181f, -0.06611365f, -0.02383882f, -0.17211363f, -0.17369619f, 0.05262474f, 0.21257058f, 
    0.20046256f, -0.28478271f, -0.12799968f, -0.15543181f, -0.03135808f, 0.06018099f, 0.08416083f, 0.15736267f, 
    -0.12263189f, -0.37878761f, -0.41731250f, -0.51777732f, 0.00064177f, -0.00345076f, -0.02378766f, -0.00234799f, 
    0.20520934f, 0.01716317f, -0.12884186f, 0.25881213f, -0.13913202f, 0.03611538f, 0.06216928f, 0.07085234f, 
    0.29109243f, -0.07477532f, -0.01684832f, -0.24835847f, 0.24511661f, 0.26120418f, 0.03766725f, 0.06574607f, 
    0.10202801f, 0.05678556f, 0.01922078f, -0.01646340f, 0.76197660f, -0.12073869f, -0.24940096f, 0.34700301f, 
    -0.00076496f, 0.02663988f, 0.02390248f, 0.05985514f, 0.19698484f, -0.01493127f, 0.13238382f, 0.08980086f, 
    0.24257843f, -0.11118111f, -0.12427772f, -0.13620563f, -0.04208609f, -0.05765194f, -0.11990666f, 0.25900221f, 
    -0.10748076f, -0.27073747f, 0.22121513f, -0.03031183f, -0.00977209f, 0.24261080f, 0.08649372f, -0.14101744f, 
    0.24959907f, -0.17207120f, 0.05104023f, -0.46371648f, 0.06109732f, 0.06471810f, -0.04861565f, -0.01570744f, 
    -0.06056426f, 0.17852762f, -0.40983537f, -0.22221336f, -0.13557848f, 0.05665155f, 0.27521509f, -0.06823136f, 
    -0.09503899f, -0.11690981f, -0.00978148f, -0.29180846f, 0.06624176f, -0.02800128f, 0.26149672f, 0.24092312f, 
    0.02624905f, 0.20550376f, 0.11788875f, 0.10622772f, 0.08794533f, 0.03448091f, -0.02433734f, -0.04839861f, 
    0.25519890f, 0.15031511f, 0.23326294f, -0.05570001f, 0.15520923f, -0.05467977f, -0.05307469f, -0.19191012f, 
    -0.05309813f, -0.07705480f, 0.03795139f, -0.02254399f, 0.51968056f, -0.10753504f, -0.52624470f, -0.05974735f, 
    0.04318286f, 0.30995396f, -0.11099301f, 0.05270231f, 0.06681406f, 0.00029931f, 0.05061998f, -0.16488692f, 
    -0.18321304f, -0.42236707f, 0.35417444f, -0.12933908f, -0.01650999f, -0.00911701f, 0.03935321f, -0.08124213f, 
    0.14292304f, -0.02040196f, 0.06851437f, 0.07217181f, 0.09072901f, 0.14933062f, 0.16650786f, -0.17352962f, 
    -0.03496547f, -0.04325728f, 0.03119862f, -0.05103179f, 0.06105788f, 0.10699709f, -0.16402926f, 0.23153700f, 
    -0.19514784f, -0.21028189f, -0.28487307f, 0.06198366f, 0.01166155f, -0.04316471f, -0.18540862f, -0.02365796f, 
    0.28895721f, 0.15479797f, 0.03733515f, 0.15756644f, -0.00816958f, 0.01418556f, 0.28827429f, 0.21119811f, 
    -0.29345843f, -0.17568691f, -0.07378287f, 0.11462191f, 0.00865945f, 0.02806006f, 0.08816253f, -0.01139234f, 
    -0.24342094f, -0.21280970f, -0.17724904f, -0.09508942f, -0.05663915f, 0.12308895f, -0.09012845f, -0.01000480f, 
    0.12424821f, 0.07931180f, -0.02074748f, -0.09602794f, -0.57888812f, 0.42553097f, -0.40690979f, 0.19979663f, 
    -0.03905602f, -0.11098392f, -0.08113135f, 0.10953291f, 0.05084103f, 0.09560798f, -0.19149864f, -0.15073419f, 
    0.28426841f, 0.14892635f, 0.12506349f, 0.16236386f, -0.03087105f, -0.06146653f, 0.18768357f, -0.12732685f, 
    0.11613210f, 0.05674879f, -0.08342518f, 0.06400564f, -0.13186145f, -0.33599943f, -0.28877896f, 0.25124103f, 
    0.06201722f, -0.04148467f, -0.05460860f, 0.06127086f, -0.03021628f, -0.02444035f, 0.11930235f, -0.07655811f, 
    -0.05730103f, -0.08998079f, -0.05687362f, 0.11263010f, 0.13772348f, -0.14690509f, -0.11222398f, -0.04784081f, 
    0.02488841f, 0.05267916f, 0.13827346f, -0.00579386f, -0.18451184f, 0.02039530f, 0.02376135f, -0.09610227f, 
    0.01559784f, -0.10668600f, 0.17303921f, -0.11957410f, 0.02646027f, 0.09851370f, 0.12116932f, 0.02588134f, 
    0.02578022f, -0.03543817f, -0.08234560f, -0.29036200f, 0.13485552f, -0.04850542f, 0.03278713f, 0.05587815f, 
    0.03636999f, 0.17352808f, -0.23252624f, 0.09820247f, 0.00964817f, 0.18250489f, -0.12161993f, -0.04873931f, 
    -0.00466131f, 0.06291738f, 0.08928833f, 0.10966142f, 0.15308265f, 0.04442080f, 0.23786141f, -0.03941695f, 
    -0.13570778f, -0.18445075f, 0.17877676f, -0.28413880f, 0.09110983f, 0.17861897f, 0.11113966f, -0.23392478f, 
    -0.01757793f, 0.07938772f, 0.09851320f, 0.03051291f, -0.77669263f, -0.20336156f, 0.17034979f, -0.25274944f, 
    -0.14980219f, 0.17023140f, -0.01215985f, -0.04766723f, 0.01228051f, 0.06276806f, -0.00380529f, 0.08957631f, 
    0.14720009f, 0.19888242f, 0.04983162f, -0.35788843f, -0.01396984f, -0.43375731f, 0.19335702f, 0.09701678f, 
    0.06318048f, 0.07744949f, -0.01818211f, -0.11984636f, -0.59796596f, -0.58470678f, -0.62954605f, -0.41083655f, 
    -0.01989175f, -0.56067282f, -0.06828948f, -0.47214773f, -0.02627501f, 0.00297833f, -0.03604421f, -0.05267819f, 
    -0.29430094f, -0.12496303f, -0.06830896f, 0.18675016f, -0.04821300f, -0.18927132f, 0.04544842f, 0.14489301f, 
    -0.03308269f, 0.04814882f, 0.22772290f, 0.07823634f, 0.09849887f, 0.00813159f, 0.08071883f, 0.09869151f, 
    -0.11761081f, -0.06394224f, 0.00465719f, 0.07454915f, -0.00558651f, 0.02821465f, 0.26079497f, 0.11737785f, 
    -0.13431895f, 0.01005858f, 0.48682860f, 0.09903583f, -0.01657811f, 0.03434042f, -0.14602357f, 0.07841373f, 
    -0.02024182f, 0.05088112f, 0.19924529f, 0.20614588f, -0.67756134f, 0.31270078f, 0.03086270f, -0.36563537f, 
    -0.15492825f, -0.08941994f, -0.07185604f, -0.04591401f, -0.01606445f, 0.06200558f, 0.04447650f, -0.01333672f, 
    -0.99209070f, -0.36681488f, 0.26472902f, -0.31539816f, 0.10239104f, -0.17976904f, 0.08253416f, -0.00672500f, 
    0.00651785f, 0.00423219f, 0.07455906f, -0.04025242f, -0.21358046f, 0.16334194f, 0.24750002f, -0.04131063f, 
    -0.03247694f, -0.02889278f, -0.15012947f, -0.03037799f, -0.02112976f, 0.16667315f, -0.11004625f, -0.06191659f, 
    0.13244946f, 0.04860163f, 0.02038652f, 0.08588417f, -0.07403059f, 0.05526537f, 0.06941704f, 0.07160753f, 
    0.19012083f, 0.20738284f, 0.20783487f, 0.15636535f, 0.09735209f, -0.11428876f, -0.25576457f, -0.01611105f, 
    -0.12225784f, 0.23970254f, 0.08814117f, 0.21937431f, 0.12340707f, -0.00893029f, 0.00387084f, -0.00509328f, 
    -0.51060754f, -0.35385892f, 0.02725129f, 0.25889012f, 0.07067674f, 0.26003546f, -0.04687383f, -0.30307409f, 
    0.08551212f, -0.13575336f, -0.02951897f, -0.01512297f, 0.05611842f, 0.15214393f, -0.06395349f, -0.23274812f, 
    -0.10084924f, -0.04697776f, 0.16774109f, 0.05378902f, -0.07403702f, 0.10793533f, -0.21581732f, 0.10342127f, 
    0.45871335f, 0.57506579f, -0.06727218f, 0.44643611f, -0.03157122f, -0.01450188f, 0.11619569f, 0.32306993f, 
    0.09258722f, 0.08092341f, 0.05029996f, -0.09068871f, -0.96485776f, -0.55798668f, -0.29010904f, -0.04747273f, 
    -0.20346743f, -0.20145389f, -0.22529000f, -0.44445455f, -0.10352670f, -0.04446579f, 0.03639315f, 0.00842078f, 
    0.52655542f, 0.23009320f, -0.16796604f, -0.44139153f, 0.17995286f, -0.10635085f, 0.23203939f, 0.00801491f, 
    0.09752481f, -0.09358745f, 0.11786270f, 0.03306794f, -0.72166437f, -1.12764883f, -0.62506247f, -0.10541613f, 
    -0.11601959f, 0.28086227f, 0.25949460f, -0.25939417f, -0.03374803f, -0.02828578f, 0.09883097f, 0.13485751f, 
    -0.75598574f, -0.89332217f, -0.22322632f, -0.17925739f, -0.20968907f, 0.11743735f, 0.08709056f, -0.25354412f, 
    -0.03945626f, -0.00625628f, -0.10240905f, -0.09963846f, 0.44172704f, -0.05488031f, -0.26050302f, -0.61650968f, 
    -0.07214221f, 0.06532300f, 0.24215971f, 0.16683878f, 0.04569679f, 0.04422046f, -0.12893096f, -0.09336399f, 
    -0.13114370f, -0.06681276f, 0.04601534f, 0.10030439f, 0.05390329f, -0.00519689f, 0.04202370f, 0.16218172f, 
    0.24597050f, 0.08193109f, 0.16901897f, 0.04253541f, -0.14568578f, -0.33418363f, 0.03838300f, -0.16386491f, 
    -0.01484212f, -0.04345187f, 0.01516880f, -0.10714452f, -0.08214764f, 0.04551687f, 0.03695691f, 0.07540984f, 
    0.31488100f, 0.06430835f, 0.40805283f, 0.45120823f, 0.06214267f, -0.14198793f, 0.05716665f, -0.01684115f, 
    -0.11059893f, 0.21013467f, 0.10527720f, -0.17226695f, -0.00114585f, -0.21323067f, -0.53239036f, 0.11964699f, 
    -0.01940678f, -0.19043252f, -0.16000143f, 0.26213846f, 0.07315703f, 0.05233093f, 0.02632613f, -0.03583581f, 
    0.31634557f, 0.58195859f, -0.04325400f, 0.18784302f, -0.02925876f, -0.05277635f, -0.11853219f, -0.08634653f, 
    0.04827869f, -0.07971828f, 0.05041718f, 0.02842868f, -0.36896321f, -0.06661195f, 0.21375585f, -0.04129158f, 
    -0.12849480f, 0.07676770f, 0.02837087f, 0.06570026f, 0.08621415f, -0.06535005f, 0.24616179f, 0.13107723f, 
    -0.68088305f, -0.62328339f, -0.16128418f, 0.15575455f, -0.14212140f, 0.06225383f, -0.20702264f, -0.39522514f, 
    -0.08875210f, -0.03649873f, 0.02536560f, -0.15796044f, -0.12533748f, -0.14060922f, -0.00950771f, -0.09996024f, 
    -0.03706251f, 0.01050114f, 0.11978409f, -0.09657399f, -0.05603411f, -0.00051300f, -0.10266421f, 0.04290166f, 
    0.13039449f, -0.05501638f, -0.18292430f, -0.20363036f, -0.08628311f, -0.08026142f, 0.05180106f, 0.00142718f, 
    -0.14148690f, 0.01391604f, -0.22538230f, -0.39552617f, -0.38372776f, -0.26355758f, -0.43619326f, -0.26151007f, 
    -0.07749379f, -0.30461508f, -0.21042040f, 0.03187340f, -0.02053039f, -0.00757565f, -0.05056590f, -0.14816236f, 
    0.04365065f, 0.09060585f, 0.09169325f, -0.10111105f, -0.13186790f, -0.03959363f, -0.07087366f, -0.02741210f, 
    -0.01997264f, 0.14903811f, 0.12015126f, -0.08108171f, 0.24947219f, -0.40562910f, 0.14453901f, -0.14129078f, 
    0.02023655f, -0.09784598f, 0.04443793f, -0.22217292f, 0.09560981f, 0.05722601f, 0.01049170f, 0.02783919f, 
    -0.08323023f, 0.27217391f, -0.18524778f, 0.00946878f, -0.07732757f, -0.13574727f, 0.07047330f, -0.02598786f, 
    -0.03532772f, 0.11200708f, 0.06432290f, 0.07711845f, -0.42047977f, -0.12344524f, -0.29064795f, -0.67465544f, 
    0.21134761f, -0.01546130f, 0.12396019f, 0.00400313f, -0.07146614f, -0.02419008f, -0.04170914f, -0.01956284f, 
    -0.33468926f, 0.35955873f, -0.02471513f, 0.21857958f, 0.10192186f, 0.07999118f, 0.18366764f, -0.13238284f, 
    0.02937332f, -0.04277365f, 0.04057733f, -0.00982640f, -0.33362937f, -0.49002928f, -0.22328810f, 0.52269828f, 
    0.06133447f, -0.10513303f, -0.10971408f, -0.13209116f, 0.00066967f, 0.04361301f, -0.01518926f, -0.03527827f, 
    0.61614412f, 0.23738314f, -0.42347258f, -0.20908271f, -0.11113237f, -0.01644213f, 0.08456329f, -0.19995922f, 
    -0.16255628f, 0.18652473f, -0.18736297f, -0.26310369f, -0.03691872f, 0.23615552f, -0.08543640f, 0.16452275f, 
    0.00872294f, 0.14284527f, 0.02857235f, -0.02216064f, -0.11635616f, 0.09454493f, 0.02142188f, 0.07691665f, 
    0.72351277f, -1.01222670f, -0.52228051f, -0.68505800f, -0.08557085f, 0.06640313f, -0.22982877f, 0.10908848f, 
    0.23678787f, 0.09220979f, 0.02671027f, 0.09772772f, -0.15597890f, -0.32594624f, -0.29493713f, 0.02571123f, 
    0.07733568f, -0.10140704f, -0.10040120f, -0.01983974f, 0.13449712f, 0.06437957f, 0.01078389f, -0.01850754f, 
    -0.22761732f, -0.53847325f, -0.07293615f, -0.49922442f, -0.13083185f, 0.20970197f, 0.04425349f, 0.06885430f, 
    0.09809191f, 0.00563830f, -0.04455897f, -0.05369264f, 0.24235712f, 0.20536323f, -0.00262950f, -0.11189171f, 
    -0.05520275f, -0.14053294f, -0.02164309f, -0.06062726f, 0.13411666f, 0.06148560f, -0.08014336f, -0.10581520f, 
    -0.04353175f, -0.01561744f, 0.02026963f, 0.01050122f, 0.00171997f, -0.04292100f, -0.06993741f, -0.06070300f, 
    0.23126160f, 0.17067572f, 0.10275211f, 0.05453550f, 0.05599234f, 0.04933782f, -0.04840791f, 0.00276954f, 
    -0.13276251f, -0.21513569f, -0.11973328f, -0.27024516f, -0.04652985f, 0.00295590f, 0.00711833f, 0.06237142f, 
    -0.53415751f, -0.29558527f, 0.36554956f, 0.12902424f, -0.06630870f, 0.10378404f, -0.08788553f, -0.01756214f, 
    0.01137402f, 0.01403484f, 0.01433005f, 0.03802425f, -0.07988971f, 0.09147236f, -0.22963081f, 0.02732093f, 
    0.01733039f, 0.01986337f, 0.02745074f, -0.14055683f, -0.03959468f, -0.12836742f, 0.02926726f, -0.29881328f, 
    -0.56380802f, -0.73076427f, -0.59547800f, -0.00826319f, -0.27836442f, -0.10671529f, 0.15315232f, -0.35563689f, 
    0.01823710f, 0.07480547f, -0.01309040f, -0.14621060f, -0.43025956f, -0.30528080f, 0.09011737f, 0.70873851f, 
    0.17367326f, -0.06626576f, 0.14378639f, 0.04974876f, -0.05724106f, -0.04913292f, -0.01367945f, 0.00098239f, 
    -0.27451566f, 0.23362079f, -0.06728594f, 0.08583537f, -0.08072866f, 0.04400355f, 0.05718969f, 0.09639243f, 
    0.01043935f, 0.00977358f, 0.17244394f, 0.07332456f, -0.50499135f, 0.03044747f, -0.07299660f, 0.27114639f, 
    -0.01791325f, -0.02949031f, -0.06925824f, 0.04076525f, 0.00738989f, 0.04777013f, -0.03281690f, -0.00440152f, 
    -0.46209112f, -0.23937002f, 0.19885103f, 0.44986349f, 0.04334325f, 0.16889399f, 0.09242646f, 0.14291310f, 
    -0.03235803f, -0.11537382f, -0.08005553f, -0.02728898f, -0.36553669f, 0.21688998f, -0.22431369f, 0.03162464f, 
    0.02141873f, 0.01224683f, 0.04262109f, -0.02605863f, 0.09235677f, -0.06497722f, 0.12075179f, -0.09230115f, 
    0.20879197f, -0.15290593f, 0.25150612f, -0.39891061f, 0.06076729f, 0.05787863f, -0.05025905f, -0.00749956f, 
    -0.01671180f, -0.03072466f, -0.12520234f, -0.43439347f, -0.16411620f, -0.30664408f, 0.14268194f, -0.09111478f, 
    -0.10086658f, 0.10473413f, 0.00307538f, 0.05833220f, -0.15816276f, 0.05158627f, -0.10418700f, 0.04748064f, 
    0.06524059f, 0.03447671f, 0.07834904f, -0.21901396f, -0.19173446f, 0.21592276f, -0.03798572f, 0.15927620f, 
    0.18009205f, 0.05609500f, -0.06147907f, -0.08442399f, 0.54090685f, -0.40557849f, 0.21186695f, 0.10289952f, 
    -0.02051822f, -0.12499970f, -0.23568080f, 0.06299052f, -0.02625489f, -0.03636625f, -0.01561699f, -0.12480236f, 
    -0.16716953f, -0.29192233f, -0.18418764f, 0.01993749f, -0.01813427f, -0.08637454f, 0.08191247f, -0.08781124f, 
    -0.35781488f, 0.00151765f, 0.05128406f, 0.08124676f, 0.71370590f, 0.28385964f, -0.29017559f, 0.06020801f, 
    0.06474761f, -0.12289931f, -0.14079654f, -0.24447456f, 0.01392065f, -0.05194183f, 0.04384911f, 0.02436931f, 
    0.47078761f, -0.35159296f, 0.12738702f, 0.12910640f, -0.14395943f, 0.19624990f, 0.02527740f, 0.12148262f, 
    -0.04272893f, 0.02382279f, -0.06615264f, -0.03139067f, 0.03162592f, 0.17266676f, -0.04748302f, -0.09997076f, 
    0.05118296f, -0.11081283f, 0.00815949f, 0.04548243f, 0.06154324f, 0.15057933f, 0.03706241f, -0.02809783f, 
    -0.00338861f, -0.02207709f, 0.01450429f, 0.09997209f, 0.01966575f, 0.06606637f, 0.02035631f, -0.02548018f, 
    -0.02797739f, -0.14792782f, -0.08301795f, 0.00567465f, -0.13117841f, -0.35068020f, -0.18633230f, 0.11739399f, 
    -0.18856233f, 0.43584195f, -0.01193242f, 0.03133991f, 0.06017563f, 0.00280102f, -0.02260740f, -0.00304788f, 
    -0.25154907f, -0.04775996f, 0.05023098f, 0.06538647f, -0.09555103f, -0.02226960f, 0.16764846f, 0.09718785f, 
    0.13959281f, -0.01864658f, 0.16838548f, 0.18457344f, 0.28880319f, -0.07345851f, -0.06356266f, -0.05128687f, 
    -0.00908216f, -0.06702213f, 0.17877115f, -0.07423114f, -0.00320660f, -0.10882536f, -0.02779366f, -0.71998513f, 
    -0.49964795f, -0.17026924f, 0.14366865f, -0.08444157f, -0.10406671f, -0.08542070f, -0.10988923f, -0.04115285f, 
    -0.21794333f, -0.22566433f, -0.13855682f, -0.17950724f, 0.30334488f, -0.36783972f, -0.31821862f, 0.23645177f, 
    0.04944012f, 0.17523469f, 0.02965155f, -0.04027796f, -0.04685413f, -0.15717851f, -0.06958975f, 0.07443275f, 
    -0.53219086f, 0.14539590f, -0.15960874f, 0.13347656f, 0.16543667f, 0.07757148f, -0.01806814f, 0.03978033f, 
    0.14815693f, 0.21965677f, 0.07938842f, 0.25555304f, -0.31662360f, -0.54354453f, -0.13088435f, -0.00933467f, 
    0.07036320f, -0.13718396f, -0.17249866f, -0.01619692f, 0.03066883f, 0.08859687f, 0.06823487f, 0.02488494f, 
    0.60185057f, 0.21465300f, -0.21715279f, -0.27658573f, -0.00674162f, -0.14868978f, 0.02307086f, 0.00375688f, 
    0.27942950f, -0.04540322f, 0.05321718f, 0.18542168f, -0.13085449f, 0.23722547f, 0.02418861f, -0.02467347f, 
    -0.05236859f, -0.00943145f, -0.16861446f, -0.04654573f, 0.06894051f, 0.19517899f, 0.12674721f, 0.05364043f, 
    -0.65373755f, -0.70154023f, -0.61201388f, 0.22622691f, 0.06192985f, 0.25596476f, 0.18474685f, 0.12128175f, 
    -0.11784863f, 0.04747555f, -0.00038558f, -0.25784042f, -0.23099038f, -0.39207518f, -0.16319825f, 0.01433970f, 
    0.03177771f, 0.05633359f, 0.07633691f, 0.10154659f, -0.09464183f, -0.15827255f, -0.10397428f, -0.05494492f, 
    -0.03537400f, -0.38866526f, -0.58334291f, 0.33684531f, -0.01289457f, 0.17571774f, 0.17927107f, -0.01677972f, 
    -0.10401750f, -0.05919644f, -0.10312125f, 0.04476766f, -0.18958029f, -0.16834310f, -0.24857505f, -0.10255304f, 
    -0.06363174f, 0.06454841f, 0.14165401f, 0.10302179f, 0.10846230f, 0.05269519f, -0.01046930f, -0.12623531f, 
    -0.14111879f, 0.00673755f, 0.05277189f, 0.22209531f, 0.05217151f, -0.03588742f, -0.02941645f, 0.07610343f, 
    -0.00493949f, -0.01518713f, -0.18999816f, -0.61106735f, 0.11026354f, -0.02811684f, -0.01496815f, 0.11402512f, 
    0.09410550f, -0.04448897f, 0.09215876f, 0.01272101f, 0.09665006f, -0.01995948f, 0.03774638f, 0.04083667f, 
    0.52362555f, 0.08154340f, -0.18886784f, 0.01581086f, -0.08133717f, -0.11872670f, -0.09263141f, -0.15910268f, 
    -0.02738177f, 0.09080482f, 0.01969068f, 0.07717967f, -0.25220194f, 0.30929181f, -0.05460778f, 0.11492665f, 
    -0.03030010f, 0.07446404f, -0.06911007f, 0.05480769f, -0.01934903f, 0.10108799f, -0.18670037f, 0.17186798f, 
    -0.00677558f, -0.12115458f, -0.16594404f, 0.40223420f, 0.26147979f, 0.29640099f, 0.17696609f, 0.05654629f, 
    -0.04404154f, -0.17157793f, -0.14760633f, -0.06950887f, -0.21427281f, -0.81504792f, -0.46171093f, -0.23239271f, 
    -0.05916413f, 0.21030526f, -0.05578530f, 0.06681240f, -0.04742897f, 0.11235266f, -0.03343773f, 0.03972071f, 
    -0.45120865f, -0.10894822f, 0.08424030f, 0.17580226f, 0.12662259f, -0.00653015f, -0.39203012f, 0.16258325f, 
    -0.17509440f, -0.01296139f, -0.15154344f, -0.12482507f, 0.21138202f, 0.14920999f, 0.17695887f, 0.10238846f, 
    0.28866979f, -0.19389708f, -0.23209667f, -0.25470459f, -0.08675169f, 0.00745238f, 0.06503476f, 0.00855711f, 
    0.04135619f, -0.06753564f, -0.20328742f, -0.13109334f, -0.29900271f, -0.10111587f, 0.08237112f, -0.25689605f, 
    -0.04686317f, -0.00721109f, -0.03777608f, -0.04379871f, -0.58908176f, 0.19115181f, -0.04087653f, 0.19375110f, 
    0.03338025f, 0.05467268f, -0.09959885f, 0.02256789f, -0.01323590f, -0.05106757f, 0.00891814f, 0.02353742f, 
    0.01409954f, -0.15095495f, -0.23706412f, -0.20442316f, -0.00830358f, -0.06014128f, 0.00418648f, 0.01798227f, 
    0.16664959f, 0.11039350f, 0.12668766f, 0.06659769f, 0.14240535f, -0.59151745f, -0.43389171f, -0.27160841f, 
    -0.08197021f, -0.01227839f, 0.02446741f, 0.09255330f, 0.11899804f, -0.05679185f, 0.07654807f, -0.00822234f, 
    -0.43809700f, 0.06737357f, 0.10376699f, 0.40467620f, -0.16883002f, 0.10487888f, -0.05881885f, 0.04753724f, 
    0.19751348f, 0.08611961f, 0.02098856f, -0.13684957f, 0.42889702f, 0.19970299f, -0.21694729f, -0.18893009f, 
    0.33336467f, -0.16398557f, -0.02483922f, -0.15425482f, 0.07615675f, 0.14787306f, 0.02933704f, 0.26176465f, 
    -0.22624922f, -0.08439498f, 0.07101201f, 0.00633007f, -0.11025644f, 0.15671909f, 0.17748590f, 0.00011614f, 
    0.15744697f, 0.07024644f, 0.07571020f, 0.12212511f, 0.30584478f, -0.24130128f, -0.07678373f, -0.28279376f, 
    -0.14486705f, 0.01746649f, 0.10503509f, 0.13044669f, 0.08202546f, -0.04306636f, 0.08853038f, -0.20481634f, 
    0.46115896f, 0.29474673f, -0.40375483f, -0.28837141f, 0.12381371f, -0.15253605f, 0.06576652f, 0.00674999f, 
    0.01080050f, 0.03517317f, 0.02506126f, 0.22701207f, -0.24712162f, 0.07691329f, 0.19622114f, -0.08358979f, 
    -0.13675211f, 0.05593381f, -0.07100712f, -0.10788975f, -0.12627293f, 0.08603848f, -0.05965984f, 0.04664558f, 
    -0.27081060f, 0.15727635f, -0.12645015f, -0.07643893f, -0.02125324f, 0.00096030f, -0.09639671f, -0.05960828f, 
    0.03145885f, 0.11873521f, 0.02805970f, 0.21663335f, -0.55283076f, -0.40413326f, -0.18100515f, 0.06628805f, 
    0.17729095f, 0.03693912f, -0.20452413f, 0.09379639f, -0.08897481f, 0.13546650f, 0.11431379f, 0.22473526f, 
    -0.09520426f, 0.05469806f, 0.12815934f, -0.01824815f, 0.03444264f, -0.04872392f, 0.07800667f, -0.14387324f, 
    -0.02324622f, 0.15297520f, -0.23705050f, 0.00188500f, 0.02371393f, 0.01141960f, 0.17997053f, 0.32754689f, 
    0.07679444f, 0.10718929f, 0.05209638f, -0.04484455f, 0.18252599f, 0.09734806f, 0.15356791f, 0.13271978f, 
    -0.33881602f, 0.10763301f, -0.31510788f, -0.31446955f, 0.19660757f, -0.17473349f, 0.19706018f, 0.02100747f, 
    0.10448892f, 0.12871221f, -0.18856461f, 0.02658952f, -0.06891878f, -0.13970129f, -0.45461908f, 0.14537464f, 
    -0.17189160f, -0.12690797f, -0.15074739f, 0.02138384f, 0.11296816f, 0.00943107f, 0.04760466f, 0.09970558f, 
    0.10430346f, 0.09888282f, -0.38420540f, -0.37733820f, 0.01010495f, -0.27976379f, -0.07951389f, 0.09545993f, 
    -0.09499929f, 0.02775602f, -0.29708189f, -0.41747043f, -0.24003890f, -0.04392797f, -0.23955134f, -0.22488335f, 
    -0.17585190f, -0.17064716f, 0.09302468f, 0.17212828f, 0.00067153f, -0.03187016f, 0.05417633f, -0.09218353f, 
    -0.68186957f, 0.02338818f, 0.15293545f, 0.35869238f, 0.18180178f, 0.05714188f, -0.13868728f, -0.30256185f, 
    0.05122465f, -0.07260661f, 0.07555003f, -0.11648034f, -0.28375304f, 0.13371468f, -0.54586273f, -0.07522787f, 
    -0.00190533f, -0.19422890f, 0.04335010f, -0.14273326f, -0.01269786f, -0.14736083f, -0.04202566f, -0.01818187f, 
    -0.16216820f, 0.44881648f, -0.09379937f, -0.26794490f, -0.20585217f, -0.06862810f, -0.10356514f, -0.22323316f, 
    -0.02678822f, -0.13505194f, 0.05767281f, 0.16306289f, -0.02099390f, -0.16410217f, 0.32437757f, 0.11927624f, 
    -0.11034797f, -0.20315801f, -0.07500258f, 0.18000658f, -0.07068180f, 0.00486559f, 0.09403367f, 0.01487795f, 
    -0.21989271f, -0.31080538f, -0.33758530f, -0.44819602f, -0.33139506f, 0.20337100f, 0.15026483f, 0.04020042f, 
    0.12267625f, 0.02498698f, 0.05076117f, 0.02227230f, 0.24980395f, 0.08737544f, 0.21610089f, 0.39484000f, 
    0.20133401f, -0.09812333f, -0.08972452f, -0.18674426f, 0.16543518f, -0.04369785f, 0.05850985f, 0.27931908f, 
    0.14981315f, 0.06587916f, -0.05213461f, -0.02801284f, 0.01724786f, -0.07647363f, 0.03210237f, 0.11025569f, 
    -0.00772430f, 0.04058407f, 0.23191799f, 0.33228183f, -0.44471881f, 0.04031530f, -0.46797302f, 0.13794488f, 
    0.26339340f, -0.12962274f, 0.11747660f, -0.23172738f, -0.01974349f, 0.02575373f, -0.14030865f, -0.12838964f, 
    0.49817184f, -0.39421120f, 0.00553459f, -0.42627409f, 0.13114935f, -0.06707152f, -0.13238782f, 0.12982717f, 
    -0.07602188f, -0.05817570f, -0.18697332f, -0.17255974f, -0.13654324f, 0.08454074f, -0.02441130f, -0.02758657f, 
    0.14966039f, -0.08409666f, -0.07067476f, -0.05815144f, 0.13322924f, 0.05283602f, -0.13372900f, 0.06304388f, 
    0.02369614f, 0.14698282f, 0.81937540f, -0.64877379f, 0.07115255f, -0.29892793f, 0.04691613f, -0.11526325f, 
    -0.16731098f, -0.00230128f, 0.02093627f, -0.02597842f, 0.04996268f, 0.30572021f, 0.11817143f, -0.18483259f, 
    -0.09692091f, -0.08540727f, 0.21654089f, 0.07665238f, 0.08760438f, 0.05804842f, -0.02708052f, -0.00356483f, 
    0.05966547f, 0.49095190f, -0.25022033f, -0.24383797f, -0.25798342f, 0.02118759f, 0.15563406f, 0.16279906f, 
    0.02586838f, 0.05250077f, -0.06987879f, -0.07554704f, 0.37655041f, -0.03723755f, -0.99754637f, -0.05056779f, 
    0.19140065f, -0.00478612f, 0.21727851f, 0.11263116f, 0.04356381f, 0.08112913f, 0.04171036f, -0.05690387f, 
    -0.15449239f, 0.28407419f, 0.12462874f, 0.02300273f, 0.07640146f, -0.09867734f, 0.26305366f, 0.32353219f, 
    0.05401244f, 0.09857068f, -0.03392176f, -0.02599527f, -0.36646032f, 0.35227859f, -0.48255894f, 0.08383687f, 
    0.12608799f, -0.13366570f, 0.10228641f, -0.11725251f, 0.11649756f, -0.10257831f, -0.14294341f, -0.12137475f, 
    0.30592954f, -0.22204594f, 0.32980472f, 0.21631204f, -0.04388252f, -0.02107444f, -0.23933437f, -0.16276835f, 
    0.00025782f, 0.01545580f, 0.00207444f, -0.08471266f, -0.37382507f, 0.02397430f, -0.13520098f, 0.30992240f, 
    -0.22083397f, 0.03395310f, 0.06087258f, -0.06812803f, 0.01085192f, -0.01320177f, 0.07268435f, -0.14861549f, 
    -0.00395208f, -0.00810042f, -0.02668905f, -0.52154505f, -0.37228158f, 0.01929281f, 0.03381995f, 0.00612202f, 
    0.10319694f, 0.04689063f, -0.25655079f, -0.31466824f, -0.08203942f, -0.07559870f, -0.05474210f, 0.37154633f, 
    0.03754388f, -0.08173227f, 0.19065315f, -0.21807010f, 0.13310316f, -0.07122283f, -0.12395266f, -0.06572662f, 
    0.20228164f, 0.20964281f, 0.81648469f, -0.58125079f, 0.08799911f, -0.27061570f, -0.08678220f, -0.01387644f, 
    -0.18219653f, 0.05505595f, 0.00738951f, 0.01531284f, -0.56410503f, 0.30087283f, 0.33321744f, 0.45675245f, 
    0.15684322f, -0.07956961f, -0.27107847f, -0.19840759f, -0.02512490f, -0.34437227f, 0.15974484f, 0.22034648f, 
    -0.35638982f, -0.18027106f, 0.08396237f, 0.29060555f, 0.19023891f, -0.05620220f, -0.21555416f, 0.11567493f, 
    0.01876915f, -0.08382342f, -0.00097995f, -0.07359663f, -0.34884065f, -0.25088489f, -0.22125030f, -0.16122030f, 
    0.23340538f, 0.24504174f, 0.19195598f, 0.10553490f, 0.11719362f, 0.00091571f, -0.10266920f, 0.03833525f, 
    -0.26497975f, 0.21637538f, 0.09171678f, 0.09713718f, 0.05233774f, 0.04368666f, 0.06867439f, -0.03275194f, 
    0.23024221f, 0.22969915f, 0.06524692f, -0.07525340f, -0.03578104f, 0.11836395f, -0.36102983f, -0.10181900f, 
    -0.20393705f, -0.05219398f, 0.06030085f, -0.01735645f, 0.03127528f, -0.14762795f, 0.06665320f, -0.00017506f, 
    0.04994941f, -0.02807503f, -0.10447531f, 0.54041851f, -0.15887883f, -0.05387197f, 0.16746472f, 0.16616966f, 
    0.31425163f, 0.10992853f, -0.01427003f, -0.05181599f, -0.33429384f, 0.21491934f, -0.15225706f, -0.26170540f, 
    -0.12467133f, 0.06661134f, -0.09797213f, -0.03588554f, -0.29341412f, -0.37840226f, -0.36199987f, -0.54098761f, 
    0.43166438f, 0.18837886f, 0.14733300f, 0.23477662f, -0.43966907f, -0.00330109f, 0.16319755f, -0.17046212f, 
    -0.05172807f, 0.08974381f, -0.43319142f, -0.00158256f, -0.14029880f, 0.09692694f, -0.20639087f, 0.04669952f, 
    0.02658040f, -0.03921803f, 0.00906497f, -0.04146263f, 0.07829957f, 0.12470756f, -0.18592077f, -0.29922301f, 
    0.19388032f, -0.07410660f, 0.30110273f, 0.48826161f, -0.34115723f, 0.13019224f, 0.20769291f, -0.06745435f, 
    0.16276656f, -0.21877584f, 0.18566188f, 0.42765257f, -0.09259254f, -0.07559846f, -0.14168365f, 0.09690461f, 
    -0.11312823f, 0.12268139f, 0.27830461f, 0.04829312f, -0.00797695f, 0.07728921f, 0.02780794f, 0.17095535f, 
    -0.02517879f, -0.15278919f, 0.47505778f, -0.26836452f, -0.12398165f, 0.18851475f, -0.02492085f, 0.18601353f, 
    -0.00645243f, 0.05239965f, 0.09896283f, 0.03476666f, 0.44039118f, 0.18069912f, 0.44129577f, -0.46881497f, 
    -0.31131995f, 0.05770370f, 0.18203090f, 0.18800622f, 0.09676771f, 0.09390271f, -0.36277789f, -0.06841462f, 
    0.34866944f, 0.09238091f, -0.05825026f, -0.52219498f, 0.04411477f, -0.22207822f, -0.06301971f, -0.03423369f, 
    -0.27547494f, 0.04711423f, -0.04981430f, -0.43181854f, -0.21251653f, 0.17153892f, -0.36856598f, 0.20791459f, 
    0.07467896f, -0.10933681f, -0.14544843f, 0.04279284f, -0.14082612f, 0.16313307f, 0.03615081f, 0.07953382f, 
    0.15527529f, -0.33384725f, -0.13390486f, 0.30954322f, 0.14015679f, -0.15358731f, 0.06809634f, 0.06208063f, 
    -0.10924213f, 0.02449687f, 0.14430410f, -0.11899022f, -0.29877490f, 0.21214321f, 0.18580057f, -0.17511316f, 
    0.03722365f, -0.10647763f, -0.26217657f, -0.09762363f, -0.07159583f, 0.09348995f, -0.01935439f, -0.15722020f, 
    -0.16135310f, 0.08218461f, 0.28821391f, -0.02016324f, 0.08253922f, 0.07361269f, -0.13376196f, -0.08862739f, 
    -0.09070544f, -0.12549646f, -0.32809970f, -0.28448758f, -0.24417037f, -0.25688413f, 0.26681665f, -0.04719906f, 
    -0.11609770f, 0.13543682f, 0.10299375f, -0.08873838f, 0.06523497f, 0.13839245f, -0.08007064f, 0.15835615f, 
    -0.37437490f, 0.17774612f, 0.21140088f, 0.51799756f, -0.00901361f, 0.24558675f, -0.13214681f, -0.00651088f, 
    -0.04256450f, -0.06512069f, 0.11586181f, 0.22839189f, -0.10249326f, 0.11801594f, 0.26559284f, 0.04497938f, 
    -0.14791566f, 0.09414557f, 0.28254676f, -0.14148550f, -0.05809709f, 0.03741572f, 0.06169426f, 0.21134657f, 
    -0.28905505f, 0.05792487f, 0.02851888f, 0.13254958f, -0.14775562f, -0.08087233f, 0.11366957f, 0.20026873f, 
    0.06508419f, -0.10545976f, -0.05028786f, -0.26948875f, -0.25462657f, -0.32706586f, -0.01430257f, -0.04774161f, 
    0.02112775f, 0.03694291f, 0.01390492f, -0.14101517f, 0.01323998f, 0.21140888f, -0.00664768f, 0.02521843f, 
    0.20261040f, -0.32535082f, -0.03702243f, 0.29636392f, 0.10089438f, -0.29376453f, 0.13682401f, 0.12897815f, 
    -0.40846229f, -0.14851573f, -0.29652211f, -0.06585717f, -0.09922083f, -0.20149760f, -0.22426614f, -0.06380714f, 
    -0.12569541f, -0.00162418f, 0.16472669f, -0.15374133f, 0.05736158f, 0.19787815f, -0.02049866f, -0.12359783f, 
    -0.12693132f, -0.45410421f, -0.17024985f, 0.16912292f, -0.15717895f, -0.04031570f, -0.10178391f, -0.09675401f, 
    -0.02627483f, 0.07160869f, -0.12061179f, -0.01300186f, -0.26699409f, -0.32569468f, -0.27932450f, 0.04083335f, 
    0.17027010f, -0.14752510f, 0.24950480f, -0.06834638f, -0.26940063f, 0.00143861f, 0.06048026f, 0.10119942f, 
    -0.52492607f, 0.29892784f, -0.49344131f, 0.24716391f, 0.19602002f, 0.02336101f, 0.06813658f, -0.22985721f, 
    -0.10758125f, 0.11667831f, 0.08918545f, 0.04050098f, -0.24441250f, 0.52620703f, -0.25024474f, 0.00893516f, 
    -0.09111444f, -0.01480932f, -0.00847573f, 0.14989647f, 0.06568986f, 0.24671663f, -0.17950614f, -0.00577493f, 
    0.14674740f, -0.07948780f, 0.18308175f, 0.21105731f, 0.13617061f, -0.02320640f, 0.01197920f, -0.00565241f, 
    -0.05331024f, 0.03258927f, -0.09927190f, 0.11048324f, -0.42441413f, 0.15175650f, -0.26468408f, 0.03753006f, 
    -0.08923719f, 0.19250531f, 0.04532143f, 0.05443874f, -0.09159886f, -0.03678970f, 0.10193238f, -0.04861608f, 
    -0.16578619f, 0.14721316f, 0.16410854f, 0.04380596f, -0.11023948f, 0.07629337f, -0.13636139f, 0.02709791f, 
    -0.02051698f, -0.14506494f, 0.18291087f, -0.07851098f, 0.42974147f, -0.21469702f, 0.42494199f, -0.27016106f, 
    -0.11957222f, 0.14777790f, -0.00002154f, 0.09478981f, -0.08347084f, 0.08028247f, -0.24717781f, -0.10251865f, 
    -0.55960250f, 0.16460006f, -0.32949340f, 0.39959592f, 0.02838058f, 0.22554307f, 0.10737772f, 0.03525443f, 
    -0.07598792f, 0.06052233f, -0.02512770f, 0.06162348f, -0.20291200f, -0.40302175f, 0.05239259f, -0.32619205f, 
    -0.22075118f, -0.14820762f, -0.11573331f, 0.16217415f, 0.04652085f, -0.04762044f, 0.14838627f, -0.04358852f, 
    -0.17418954f, -0.39592817f, -0.11723474f, -0.56439734f, -0.16828775f, -0.14478479f, -0.13221583f, 0.02114690f, 
    -0.18364389f, 0.04158827f, 0.04271751f, 0.18331033f, 0.22971527f, 0.09968673f, -0.00676954f, -0.08912661f, 
    -0.05310292f, -0.18686330f, 0.12071119f, -0.08104213f, 0.06203538f, 0.03410958f, -0.02034607f, 0.15193334f, 
    0.18104549f, -0.22866747f, 0.34274828f, 0.02723519f, 0.02812854f, 0.04300904f, 0.00374646f, 0.04976835f, 
    -0.38849023f, 0.13661128f, -0.09954777f, -0.10070492f, 0.16127130f, 0.08131684f, -0.03400992f, 0.21538995f, 
    0.11628587f, -0.06461498f, 0.16000284f, 0.10046256f, 0.12060957f, 0.26190004f, 0.17984925f, 0.22773103f, 
    0.36221689f, -0.18901461f, 0.51266265f, -0.32473129f, -0.09519240f, 0.28303611f, -0.07088017f, 0.04704922f, 
    -0.04111231f, -0.04818271f, 0.18388408f, 0.20144561f, 0.24312811f, 0.17321728f, 0.08316310f, -0.17619592f, 
    -0.13089535f, -0.09371142f, -0.00411119f, 0.17974409f, -0.03803114f, -0.00267253f, 0.09534784f, 0.07497897f, 
    0.23591211f, -0.30480307f, 0.46723929f, 0.09307092f, 0.02403004f, 0.03719731f, -0.24423793f, 0.25719017f, 
    -0.10320961f, 0.07762608f, -0.14579488f, -0.23573424f, 0.15021151f, -0.06754307f, -0.15959443f, -0.16682795f, 
    -0.12122847f, -0.24423800f, -0.12699056f, -0.14134097f, 0.00596952f, -0.14681609f, -0.06055334f, -0.18018658f, 
    -0.25329724f, -0.20272937f, 0.26182830f, -0.40325758f, 0.18686455f, 0.26597726f, 0.19224131f, 0.06133529f, 
    -0.00437919f, -0.02115842f, -0.06081964f, 0.10371549f, 0.13835990f, -0.40362877f, 0.24927936f, -0.02137993f, 
    0.01105489f, -0.04373933f, -0.07125632f, -0.00624979f, -0.00181499f, -0.04463356f, -0.01115555f, 0.00829409f, 
    -0.34973937f, -0.16564296f, -0.24841161f, -0.29906636f, 0.11350749f, -0.18928331f, 0.17019507f, -0.12195564f, 
    0.10975341f, -0.04524355f, -0.15520246f, 0.01956290f, 0.01404284f, -0.02892017f, 0.27179495f, 0.18379864f, 
    -0.07603952f, -0.28550914f, -0.12993318f, 0.00097658f, -0.04828954f, -0.04173311f, -0.11873131f, -0.05225424f, 
    -0.27768329f, 0.33313951f, -0.05356693f, 0.15352163f, -0.34972706f, 0.17429259f, 0.13034739f, -0.10580841f, 
    0.02278565f, 0.05408591f, -0.04949000f, -0.13060082f, -0.35430482f, -0.19891801f, -0.23702887f, 0.03907535f, 
    0.17858446f, 0.11483847f, 0.03064248f, -0.04297527f, -0.05244325f, 0.08420876f, -0.03197788f, -0.09145773f, 
    0.01523125f, 0.04231552f, 0.03193295f, -0.01026390f, 0.06237416f, -0.10318884f, 0.07288045f, 0.14555901f, 
    0.02552812f, -0.04544407f, 0.08723979f, 0.18179542f, 0.37858844f, -0.15009719f, 0.29902467f, -0.25072175f, 
    0.02888710f, 0.07687930f, -0.03209678f, 0.17423204f, -0.02111369f, -0.05708266f, -0.02462582f, -0.16320582f, 
    -0.21870667f, 0.10462746f, -0.10349692f, 0.37600330f, -0.39687008f, -0.24838971f, 0.24782898f, 0.05954890f, 
    0.04852613f, -0.07455817f, 0.00191105f, -0.10604353f, 0.23253557f, -0.18988448f, 0.38514671f, -0.09974118f, 
    0.02239042f, 0.00945450f, 0.10231889f, 0.06166793f, -0.08363974f, -0.00221354f, 0.04497666f, -0.18623577f, 
    0.12911992f, -0.20701927f, 0.21593480f, -0.48430461f, 0.08287600f, 0.01112749f, 0.01230342f, 0.01269004f, 
    -0.08865759f, 0.20734517f, 0.12745368f, -0.01344508f, -0.38293439f, -0.61053741f, -0.10766470f, -0.30632329f, 
    -0.10589365f, -0.04643843f, -0.19238746f, -0.08250293f, -0.04928708f, 0.00387843f, -0.03630508f, 0.00009428f, 
    -0.12640204f, -0.50477928f, 0.62506443f, 0.35473228f, -0.05725960f, 0.12030129f, -0.06449553f, -0.10148514f, 
    -0.01050172f, -0.07516819f, 0.20672393f, 0.19462518f, 0.49538410f, -0.23422374f, 0.46074626f, -0.11245354f, 
    -0.08580200f, -0.19660276f, -0.08517291f, -0.05253089f, 0.02472535f, 0.02134209f, -0.01082899f, 0.06207890f, 
    -0.29060838f, -0.47927323f, -0.03386294f, 0.02876763f, -0.27731219f, -0.15907438f, 0.00852674f, -0.28909409f, 
    -0.05920071f, 0.15705828f, -0.00325682f, -0.11283311f, 0.66090536f, -0.10650315f, 0.46041143f, 0.07816273f, 
    0.01954013f, 0.13499692f, -0.11274846f, 0.28035024f, -0.24970803f, 0.10078894f, 0.04353601f, -0.07643037f, 
    -0.63891000f, 0.14660928f, -0.62689346f, 0.31847212f, 0.12933706f, -0.10010207f, 0.16525099f, -0.07963608f, 
    0.04980247f, -0.05272054f, 0.11991236f, 0.08407881f, -0.28034145f, -0.48068053f, -0.06411560f, -0.06266598f, 
    -0.04611186f, -0.24724801f, 0.01336695f, -0.14017539f, 0.04324205f, -0.03310094f, 0.07970342f, 0.13255952f, 
    -0.49512437f, 0.24027494f, 0.03282432f, 0.01476743f, 0.11114818f, 0.01825641f, 0.14570777f, -0.18961027f, 
    -0.12583907f, 0.04804162f, -0.06928407f, -0.03833886f, -0.02239032f, -0.20312504f, -0.02898235f, 0.01663979f, 
    -0.07439607f, 0.33113667f, -0.11963276f, -0.02755312f, -0.11427004f, 0.01559361f, 0.15558447f, -0.27262342f, 
    -0.38274211f, -0.42455667f, -0.10372569f, 0.42422682f, -0.04215242f, 0.03702671f, 0.12492864f, 0.24059226f, 
    -0.17268568f, 0.00816157f, -0.11914057f, -0.04525432f, -0.16826870f, -0.10301421f, -0.23439254f, 0.00264426f, 
    0.16206050f, 0.22114193f, 0.03789808f, -0.03636762f, 0.02862012f, 0.00660109f, -0.05625062f, -0.01465109f, 
    -0.05560850f, -0.33537954f, 0.37012658f, 0.49090686f, -0.07090648f, 0.03721498f, -0.07313513f, -0.22886631f, 
    0.05935057f, 0.02486728f, 0.29246020f, 0.13069902f, 0.42839164f, 0.30811054f, 0.15480952f, -0.23482366f, 
    -0.20586669f, -0.03813559f, 0.00483370f, 0.08221488f, -0.21753949f, 0.10238494f, -0.12386571f, -0.01716700f, 
    0.08886505f, -0.02069705f, -0.00519476f, -0.11255252f, -0.02576738f, 0.16219623f, 0.07262447f, 0.10947701f, 
    -0.14354157f, 0.03928102f, 0.20196299f, -0.15936649f, 0.13623364f, -0.13303058f, 0.09768078f, -0.18466383f, 
    -0.14670700f, -0.15095338f, 0.07325359f, -0.30668169f, 0.04439552f, -0.06215747f, -0.25167307f, -0.28724113f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.22869325f, 0.16866200f, 0.07811334f, -0.17928235f, -0.05079092f, 0.10704743f, -0.00241479f, -0.22401196f, 
    0.07402769f, 0.01711523f, 0.07508828f, -0.06142393f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
