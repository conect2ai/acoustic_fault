#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.24066600f, 0.57696843f, -0.96007931f, -0.29885542f, -0.60062391f, -0.36284563f, 0.04049606f, 0.00789962f, 
    0.30658224f, 0.60882574f, -1.18548942f, -0.73508859f, 0.40192726f, 0.79415506f, 0.43850797f, -0.11932848f, 
    0.18056524f, -0.08181570f, -0.48561454f, -0.06876408f, 0.64161336f, -0.86181068f, -0.45535269f, 1.39142036f, 
    0.16831459f, -0.10148859f, 0.05149151f, -0.84906459f, -0.83553880f, -0.73961484f, -0.12854449f, 0.90391570f, 
    0.24574396f, 0.27677602f, -0.22961655f, -0.41179687f, 0.17177881f, -0.79503429f, -0.75189197f, -0.29152054f, 
    -0.39285833f, 0.26330701f, -0.91054845f, -0.48286363f, -0.01960527f, 0.49045837f, 0.23033398f, 0.95576966f, 
    0.02817170f, 0.35438314f, 0.66759753f, -0.11409564f, -0.49122924f, -0.26285660f, 0.82159221f, 0.40204525f, 
    0.74018681f, -0.65011144f, 0.06604483f, -0.35902816f, 0.56760913f, 0.10712329f, 0.65426493f, -0.30293709f, 
    -0.73671669f, -0.66202289f, 0.19947484f, -0.06650259f, -0.37717187f, 0.29060003f, 0.95769244f, -0.53936899f, 
    -0.85656661f, 0.58451504f, -0.97967792f, 0.42055455f, -0.07165924f, 0.48418614f, -0.47493869f, -0.46906197f, 
    -0.53562421f, -0.45071298f, 0.26425883f, 0.69129050f, -0.20935799f, 0.29468352f, -0.98958975f, -0.51047641f, 
    0.31208435f, -0.34126288f, -0.67571962f, -0.59546816f, 0.97752273f, -0.53746754f, -0.84065711f, -0.32584083f, 
    0.54850727f, 0.41130406f, 0.35051084f, 0.27243406f, 0.81425446f, -0.83814275f, -1.02993977f, -0.58296627f, 
    -0.39102301f, -0.39360359f, -0.46632674f, -0.08658427f, -0.51602954f, -0.36416292f, -0.06813440f, 0.54903609f, 
    -1.30223560f, -0.62787580f, -0.09380865f, 0.56755352f, -0.23221411f, -0.71041560f, -0.59131587f, -0.34799203f, 
    -0.11885041f, 0.24513510f, -0.97992349f, 0.06351877f, -0.30385369f, 0.27748272f, 0.48196664f, 0.26419157f, 
    -0.56903046f, -0.63007557f, -0.15034904f, -0.03750161f, 0.18711805f, 0.78933245f, 0.32500231f, 0.36105803f, 
    0.65721869f, -1.18725872f, 0.19576617f, -0.32485062f, -0.59768277f, 0.09264322f, -0.00947539f, -0.05792147f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.56705743f, -0.06846102f, 0.11001409f, -0.25262851f, 0.53810591f, 0.19586289f, 0.31445652f, 0.88446891f, 
    -0.24914801f, 0.65209794f, -0.02374921f, -0.23654671f, -0.26913372f, -0.51452845f, 0.69910932f, 0.58582067f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.03849854f, -0.03851749f, 0.06599321f, 0.05053336f, -0.05421579f, -0.06896649f, 0.05098412f, -0.00796765f, 
    -0.03560322f, -0.02572497f, -0.05605976f, 0.00889015f, 0.00796088f, -0.03100606f, 0.02857620f, -0.00361689f, 
    0.05492394f, -0.05214159f, -0.05708937f, 0.04304235f, 0.01507010f, -0.06182143f, 0.05071634f, 0.03664108f, 
    -0.04816984f, -0.02214861f, 0.06664722f, 0.01137106f, -0.08111871f, 0.06213640f, -0.03643178f, 0.06461872f, 
    0.07747409f, 0.00826891f, -0.06193787f, -0.06048241f, -0.02563752f, -0.07829980f, -0.06899759f, 0.05596201f, 
    -0.08081645f, -0.06760307f, -0.03350093f, 0.04708302f, 0.01300090f, -0.01499630f, 0.06500384f, 0.02479173f, 
    -0.08744351f, -0.05137489f, -0.00467051f, -0.06131406f, 0.04727810f, 0.04753851f, 0.01904962f, 0.02190696f, 
    -0.06574281f, 0.03300379f, -0.04532869f, 0.05707784f, 0.02954301f, -0.07023746f, 0.03888215f, 0.01733404f, 
    -0.00127305f, -0.01664020f, 0.01465918f, -0.03740023f, -0.02070327f, -0.01844072f, -0.06396125f, -0.02525292f, 
    -0.07689919f, -0.05193222f, -0.01045811f, 0.01177887f, -0.07004755f, 0.07439256f, -0.03048636f, 0.05292156f, 
    0.01401641f, 0.04959172f, -0.02689662f, -0.02124657f, -0.00658116f, 0.03706842f, 0.01917024f, -0.03225970f, 
    -0.07052462f, -0.04359310f, 0.03881583f, -0.00196906f, 0.03774377f, 0.03080568f, -0.05929791f, 0.03029529f, 
    -0.00403110f, -0.01595250f, -0.08366535f, -0.05235876f, -0.02450275f, -0.01615397f, -0.08474600f, 0.01515282f, 
    -0.00808120f, 0.01499035f, -0.00858153f, -0.07903431f, -0.00348918f, 0.01567434f, -0.06745842f, -0.00529970f, 
    -0.04077750f, 0.07025996f, 0.03698115f, 0.07274431f, 0.06949876f, -0.09095821f, -0.08048344f, 0.06601146f, 
    -0.04539317f, 0.00317311f, 0.07015751f, -0.04543271f, 0.06004084f, 0.05331557f, -0.09403746f, -0.01126371f, 
    -0.08448693f, -0.08619221f, -0.05188784f, -0.08407293f, 0.06630020f, 0.03831350f, 0.00532001f, 0.00273341f, 
    0.04816928f, -0.05048826f, -0.04563917f, -0.07105909f, 0.05237161f, 0.02441191f, -0.08527897f, -0.02498112f, 
    -0.04151074f, 0.04677135f, 0.05809415f, -0.06508835f, -0.06492820f, -0.08218174f, 0.05866374f, -0.08531553f, 
    -0.04838626f, -0.02230120f, -0.03959934f, 0.01334319f, -0.06532122f, 0.04294652f, 0.03971305f, -0.06104076f, 
    0.07330565f, -0.02516600f, -0.02841286f, -0.08220537f, 0.05618603f, 0.01525489f, -0.02382693f, -0.05015976f, 
    -0.07172085f, -0.04302708f, 0.06610233f, 0.04748679f, 0.02912171f, -0.01810070f, -0.07519235f, -0.03422210f, 
    -0.02810004f, 0.04984532f, -0.01853677f, 0.07649707f, 0.06293214f, 0.02169170f, 0.04591291f, -0.01933462f, 
    -0.04581875f, 0.04411242f, -0.06110254f, -0.01819346f, 0.05625306f, -0.06319591f, -0.00579018f, 0.03389351f, 
    0.04934848f, 0.00016095f, 0.04565314f, 0.01442651f, -0.00160471f, -0.09206048f, 0.04042194f, 0.05987380f, 
    -0.08643077f, -0.01704622f, -0.01499845f, -0.06313680f, -0.00552375f, -0.07941379f, -0.01780903f, 0.04249994f, 
    0.02054604f, -0.09147695f, -0.06530749f, 0.06520433f, -0.05772065f, -0.00583363f, -0.08398166f, -0.07109512f, 
    -0.06046648f, -0.06624917f, -0.03322016f, 0.04305347f, -0.03584001f, -0.07887229f, -0.02995821f, -0.00669054f, 
    0.04217064f, 0.04038564f, -0.08657973f, -0.04584398f, 0.03971218f, 0.05720030f, 0.04963531f, 0.06051363f, 
    -0.01879893f, 0.00528461f, -0.08358259f, 0.01830193f, -0.03766127f, -0.01231677f, -0.01615581f, -0.05720101f, 
    0.03954525f, -0.00093195f, 0.04616079f, 0.05203820f, -0.02377223f, 0.02533929f, -0.05148029f, -0.00169843f, 
    -0.05884748f, -0.08891199f, -0.05374610f, 0.06016551f, 0.04644011f, -0.08297810f, -0.06870376f, -0.03779114f, 
    -0.00737572f, -0.00829703f, -0.00700999f, -0.07982535f, -0.07193330f, -0.02450251f, -0.03651167f, 0.00256771f, 
    0.00828600f, -0.09400970f, 0.07125719f, 0.07335205f, 0.00176798f, 0.02111687f, -0.04012941f, 0.04017995f, 
    -0.03687594f, -0.03531075f, -0.01248947f, -0.08896261f, -0.00100019f, 0.07264563f, 0.05487261f, 0.03087711f, 
    0.04514052f, 0.01198925f, -0.06808034f, 0.06235559f, -0.09233413f, -0.09412937f, -0.02422396f, -0.00089663f, 
    -0.11536037f, -0.38597411f, -0.45006755f, -0.06121251f, -0.15134731f, -0.01846522f, 0.19613411f, 0.00905413f, 
    -0.13724992f, -0.59735823f, -0.95356655f, -0.52859741f, -0.19991964f, 0.01063333f, -0.07256179f, -0.22017509f, 
    -0.08617572f, -0.01097635f, 0.15277247f, 0.56887203f, -0.07852352f, 0.38073835f, 0.02581401f, -0.24228090f, 
    0.15252255f, -0.20196941f, -0.22322710f, 0.69692963f, 0.04911977f, -0.30750680f, -0.08684469f, -0.06453418f, 
    0.01173433f, -0.08853585f, 0.05553382f, -0.00245969f, 0.16518773f, -0.00020565f, 0.01654045f, -0.10548202f, 
    -0.00897728f, 0.18341409f, 0.10825262f, 0.01296813f, -0.01875553f, 0.19639215f, 0.23277929f, 0.22290966f, 
    -0.08487953f, -0.12567519f, -0.17301394f, -0.10805345f, 0.01934537f, 0.04536822f, 0.49024659f, 0.30587932f, 
    -0.01845848f, -0.02106133f, -0.05462662f, -0.02717309f, -0.13794512f, 0.00524836f, 0.02652444f, 0.41125855f, 
    -0.54935986f, -0.38981929f, 0.14362872f, 0.24700162f, 0.43321058f, 0.12047104f, 0.11982569f, -0.01566492f, 
    -0.29173586f, -0.39275780f, -0.53887653f, 0.13766463f, -0.12171789f, -0.06445362f, -0.03712198f, 0.13095376f, 
    0.02432043f, 0.10266465f, 0.02121321f, 0.38560876f, 0.08666005f, 0.36337590f, 0.04832992f, 0.05521693f, 
    0.09320825f, 0.29616016f, -0.36638567f, -0.83264214f, 0.25859749f, 0.11767287f, 0.15859576f, -0.16563097f, 
    0.03284967f, -0.12735072f, 0.09695391f, -0.29515046f, -0.12447622f, -0.27420470f, -0.32141539f, -0.25243622f, 
    0.04524161f, -0.05231342f, -0.17353374f, -0.07017466f, -0.14742787f, -0.22876942f, 0.96853679f, -0.24274868f, 
    -0.24146125f, -0.38003358f, -0.17542246f, 0.04472625f, -0.15387453f, 0.29664224f, 0.20368427f, 0.54108471f, 
    -0.35882106f, 0.09400800f, -0.10447764f, -0.07877192f, 0.26226670f, -0.01020173f, -0.19030894f, -0.06151281f, 
    0.11806187f, -0.04527261f, 0.09415443f, 0.08367501f, 0.09254901f, -0.03330544f, 0.14738254f, -0.32100016f, 
    -0.39656803f, 0.06501811f, -0.11902208f, -0.01582873f, 0.28026098f, 0.26120245f, 0.12923370f, 0.07542887f, 
    -0.00885555f, 0.17293040f, 0.17218827f, 0.40918458f, 0.05225451f, 0.10293543f, -0.03089892f, 0.01500584f, 
    -0.00321651f, -0.27904487f, 0.02360624f, 0.90939885f, -0.06062936f, -0.12094372f, 0.01378938f, -0.17265998f, 
    -0.05144894f, -0.15917014f, -0.24803485f, 0.49953502f, -0.38776454f, -0.14805943f, 0.12135354f, 0.27273059f, 
    0.13459757f, 0.07671457f, -0.15689351f, 0.04077636f, 0.22095166f, -0.02285976f, 0.10735018f, -0.01106799f, 
    -0.17349145f, -0.06675516f, 0.22305427f, 0.17297563f, -0.05079258f, -0.03722402f, 0.12358035f, -0.02172483f, 
    -0.12922357f, -0.19068444f, -0.00255258f, 0.14340712f, 0.24387525f, -0.15195815f, -0.09242006f, 0.05444646f, 
    -0.05842515f, -0.06288311f, 0.08577485f, 0.20288475f, 0.15935853f, -0.09372904f, 0.05791463f, 0.24821018f, 
    0.05009358f, -0.07210153f, 0.09875273f, -0.11785305f, 0.05173162f, -0.19856578f, -0.31946206f, 0.01458560f, 
    -0.14569348f, 0.39604300f, 0.13833919f, 0.12629580f, 0.06578610f, -0.04710751f, -0.03369050f, 0.18189853f, 
    0.09577327f, -0.47474775f, -0.03376438f, -0.02562818f, 0.23838699f, 0.24752103f, 0.09721047f, 0.19141598f, 
    0.50875407f, 0.63560569f, 0.37564385f, 0.09735180f, 0.00481296f, -0.00797542f, -0.06168864f, 0.33338571f, 
    0.39748442f, 0.50978667f, 0.24228713f, 0.05006441f, -0.02115296f, 0.22318511f, 0.15231033f, 0.36549032f, 
    -0.04101477f, -0.16729350f, -0.38369897f, 0.00650286f, 0.04851195f, 0.68381268f, -0.11765632f, 0.09582298f, 
    -0.09797199f, 0.01231682f, -0.00743492f, 0.14318214f, 0.10993763f, -0.29039130f, 0.14267096f, 0.19674048f, 
    -0.03742747f, 0.19668628f, 0.03470819f, 0.14471915f, 0.15033497f, -0.11494809f, -0.06774469f, 0.11010002f, 
    0.16087748f, -0.14364985f, -0.40015998f, 0.06252439f, -0.07896926f, -0.10693534f, -0.03848808f, 0.24653605f, 
    0.26382464f, 0.14453578f, 0.21523954f, -0.06577533f, -0.04557754f, -0.09762446f, -0.26308668f, 0.23856445f, 
    0.19560003f, 0.51714349f, 0.05872733f, 0.12832259f, 0.04162126f, 0.10747039f, 0.18616648f, -0.09612506f, 
    0.05506944f, 0.07287893f, -0.04075773f, -0.02869183f, -0.21295202f, 0.12239473f, 0.05218901f, -0.02312727f, 
    -0.07579809f, 0.74877238f, -0.69595277f, -0.55083495f, -0.01359040f, -0.27360129f, 0.10169484f, 0.06371909f, 
    -0.02234337f, -0.11743637f, -1.53507543f, -0.90894985f, 0.44177499f, -0.39748576f, 0.06575917f, -0.09987885f, 
    0.14427330f, 0.17583685f, 0.11099016f, 0.36867207f, -0.17273574f, 0.11114559f, 0.31916735f, 0.07668567f, 
    0.15756142f, 0.02239168f, 0.03018345f, 0.16687854f, 0.16493493f, 0.14834188f, 0.39026630f, 0.10949840f, 
    0.17185615f, 0.15068348f, 0.10493873f, -0.20640312f, 0.00615538f, -0.13059929f, -0.10468840f, -0.51293552f, 
    -0.05294811f, -0.30618361f, -0.21608034f, 0.18910629f, 0.05764747f, -0.05794051f, -0.12432484f, 0.00246891f, 
    -0.02638133f, -0.14428589f, 0.17602949f, -0.02784516f, 0.01223951f, 0.10306146f, 0.21181764f, 0.25301078f, 
    0.03423158f, 0.03858590f, 0.06636158f, -0.10775771f, -0.09344251f, 0.10098632f, -0.12995909f, -0.12055114f, 
    -0.36811000f, 0.08584569f, 0.44231793f, -0.19420928f, 0.08737113f, 0.05213364f, 0.12311262f, 0.07449207f, 
    -0.22976315f, -0.43488860f, -0.33689240f, -0.14533094f, -0.00522811f, 0.04017489f, -0.06497094f, 0.10687827f, 
    0.04074112f, -0.13545233f, 0.14027052f, 0.56786996f, 0.24315339f, -0.20274025f, -0.02204115f, -0.02147339f, 
    -0.09387702f, 0.19945289f, -0.06828512f, -0.25281331f, 0.11731040f, 0.06727864f, 0.09009568f, -0.12208395f, 
    -0.07538615f, -0.09979671f, -0.07841045f, -0.06903474f, 0.12297282f, 0.08636359f, 0.07039016f, -0.28745848f, 
    0.27172542f, -0.19589986f, 0.00145468f, 0.12724930f, 0.09395345f, 0.71214676f, 0.22423384f, 0.21253827f, 
    -0.16754028f, 0.05389196f, 0.05284880f, 0.14305818f, -0.02911092f, 0.16018422f, 0.03407517f, -0.03223006f, 
    -0.17993832f, -0.10317919f, 0.12798217f, -0.03043719f, 0.03314592f, 0.14443098f, 0.02550335f, -0.10955289f, 
    -0.09389197f, -0.52420622f, -0.02081579f, -0.25535128f, -0.03612867f, -0.11262415f, 0.06473878f, -0.10175570f, 
    -0.28333166f, 0.35496899f, -0.24344778f, 0.01260959f, -0.15500408f, 0.08422428f, 0.17427629f, 0.13178247f, 
    -0.05847357f, -0.15594730f, -0.44003907f, -0.04227530f, -0.05034131f, -0.10932241f, 0.14051613f, -0.08275814f, 
    -0.00422796f, 0.14175056f, -0.34004304f, -0.18036079f, -0.19379658f, 0.30061498f, -0.03074868f, 0.07220532f, 
    0.26174787f, 0.02807042f, 0.10879974f, -0.31499407f, -0.30674717f, 0.30804983f, 0.30245584f, -0.01467124f, 
    -0.05862005f, -0.09500004f, 0.08640486f, 0.03879956f, 0.15914617f, 0.12114251f, 0.15522662f, 0.26552522f, 
    0.08377924f, 0.17923987f, 0.05417486f, -0.01068584f, 0.08158243f, -0.10315292f, -0.02612217f, -0.17349134f, 
    -0.49126562f, -0.21322459f, -0.14783292f, -0.00592182f, 0.14819780f, 0.03594117f, 0.42062107f, -0.05716311f, 
    -0.30532598f, 0.09381837f, -0.02279582f, -0.18284723f, -0.06776624f, 0.10187161f, 0.21500085f, -0.02670858f, 
    0.23571171f, 0.30958846f, 0.27714983f, 0.03578438f, -0.03208095f, -0.09997807f, 0.09880592f, 0.10417150f, 
    -0.09740733f, 0.29017317f, -0.14919230f, -0.09189673f, -0.38592163f, -0.16147159f, -0.05465166f, -0.12274112f, 
    -0.09922432f, -0.26529858f, -0.36208051f, 0.38224950f, 0.12670387f, 0.14991513f, 0.15504126f, 0.05309428f, 
    0.12376969f, 0.02259968f, -0.60315841f, -0.08350068f, 0.25105014f, -0.33598581f, 0.05213000f, 0.07239868f, 
    -0.06894758f, -0.09790208f, 0.14212397f, -0.40979898f, -0.56977361f, -1.03547716f, -0.02977738f, -0.11733467f, 
    -0.01747544f, -0.01297136f, 0.05358052f, -0.01351563f, -0.58941275f, -0.17170854f, -0.17593914f, -0.18823324f, 
    -0.02884580f, -0.28829023f, 0.32805735f, 0.13251063f, 0.26374710f, -0.46602020f, -0.31735018f, 0.06407036f, 
    -0.04172104f, 0.19466823f, -0.10125451f, 0.15090728f, -0.05685228f, -0.00313950f, 0.44895557f, 0.01116013f, 
    0.20729607f, 0.02746499f, 0.28651628f, 0.08499806f, 0.23791085f, 0.29767594f, -0.00145252f, 0.17653018f, 
    0.18799087f, -0.29388767f, 0.12087302f, 0.19986942f, 0.08585539f, -0.01744795f, 0.11204924f, -0.08414453f, 
    0.02410768f, -0.04095148f, -0.09210286f, -0.00769879f, -0.08971532f, -0.02866762f, -0.04631530f, -0.09114578f, 
    0.05646837f, -0.08015519f, 0.05548376f, -0.06665534f, -0.06470808f, -0.04772010f, -0.04251144f, -0.04881710f, 
    0.05713443f, 0.01803489f, 0.01012805f, -0.02552392f, 0.04865279f, -0.08131397f, -0.08782101f, -0.05098261f, 
    -0.01031243f, 0.01997170f, 0.02360443f, 0.05117001f, -0.08688521f, -0.08650745f, -0.03149389f, -0.06288374f, 
    0.03237613f, 0.00479295f, 0.05836365f, 0.04096539f, -0.07887968f, 0.05636828f, 0.01978306f, -0.07307821f, 
    -0.07604027f, -0.08770718f, 0.02871656f, -0.04313016f, -0.02235523f, -0.05730469f, -0.02958690f, 0.05014578f, 
    0.01256406f, 0.04605833f, -0.02877583f, 0.04960239f, 0.04292645f, 0.00169538f, -0.02261988f, 0.02539583f, 
    -0.03268673f, -0.03727042f, -0.07670692f, 0.00972885f, -0.09129323f, 0.05901740f, 0.04637062f, -0.04854952f, 
    0.00800097f, 0.04010013f, -0.03890141f, -0.08486264f, -0.01454417f, 0.01880254f, 0.03197091f, -0.00312551f, 
    0.03348494f, -0.08749519f, 0.05040473f, 0.02639825f, 0.01838701f, -0.05548592f, -0.00949781f, 0.05067329f, 
    -0.01674473f, 0.02978108f, -0.07893937f, 0.05234351f, -0.00728664f, -0.07663174f, 0.04174926f, -0.07736336f, 
    0.05545740f, 0.06648194f, -0.03099427f, -0.04252707f, 0.02425239f, -0.01208626f, -0.06603356f, -0.08841943f, 
    -0.02523298f, 0.05243756f, 0.03105614f, 0.00086740f, -0.01918317f, -0.05299588f, 0.05603866f, 0.05068314f, 
    -0.02163672f, 0.04721617f, -0.10628422f, -0.04470089f, -0.07348800f, 0.02797833f, 0.05589831f, -0.10389800f, 
    0.03216183f, 0.01359602f, -0.08857165f, 0.03784594f, -0.01392408f, 0.02208847f, 0.05942650f, -0.01888352f, 
    0.00828469f, -0.06602391f, -0.05440287f, -0.01143677f, -0.05626537f, -0.08499153f, -0.03978636f, -0.09286140f, 
    -0.07555237f, -0.08881688f, -0.01492977f, -0.06483259f, -0.07885863f, 0.05516365f, -0.01294896f, 0.06304135f, 
    0.04728423f, -0.04746183f, -0.00343853f, 0.02639692f, 0.00045127f, -0.07112489f, 0.03222954f, -0.09120413f, 
    -0.22970851f, -0.14412029f, 0.11215618f, 0.10972341f, -0.04002040f, 0.06850625f, 0.10007622f, 0.11875653f, 
    0.06729849f, 0.29327080f, 0.38796839f, -0.09002692f, 0.38473585f, 0.09691095f, -0.04596259f, -0.11832462f, 
    -0.15446518f, 0.05699173f, 0.12117794f, -0.03242191f, -0.09911995f, -0.05475666f, -0.06650650f, -0.14157747f, 
    0.00084052f, 0.00890815f, 0.24872349f, -0.15655868f, 0.34263682f, -0.31554261f, -0.08888430f, -0.03146132f, 
    0.05975084f, 0.02013519f, -0.15381245f, -0.02663698f, 0.30116770f, -0.05398736f, 0.14468984f, 0.05168035f, 
    0.12927072f, 0.00092762f, 0.05088049f, -0.11124698f, 0.06723690f, -0.23509324f, -0.13806722f, -0.17968284f, 
    -0.13069758f, 0.02757142f, -0.01659490f, -0.05664835f, -0.04030213f, -0.11170767f, -0.51643252f, -0.06821160f, 
    -0.09992395f, -0.19254956f, -0.16615108f, 0.08166435f, -0.00729547f, 0.12907185f, 0.33105797f, 0.22272374f, 
    0.19595121f, 0.18827440f, -0.27721593f, 0.17010497f, -0.02055303f, 0.11115223f, 0.08370288f, 0.08894767f, 
    -0.11279969f, 0.11914093f, -0.07705834f, -0.26416895f, -0.03107583f, -0.06308757f, -0.22505762f, -0.35722730f, 
    -0.29306936f, 0.20909882f, 0.21546808f, -0.04054626f, 0.05704856f, 0.02254736f, 0.15276746f, 0.10704621f, 
    0.04574689f, 0.06010210f, -0.13885112f, -0.62933731f, -0.25715905f, 0.15125029f, -0.00737839f, -0.20579404f, 
    0.07252814f, 0.06456284f, 0.09090313f, -0.64145350f, -0.04329196f, -0.10070606f, 0.11345728f, 0.28644991f, 
    -0.01542024f, -0.07967658f, 0.12192696f, -0.18973853f, -0.14901407f, -0.19235159f, -0.08913486f, -0.02101190f, 
    -0.28399470f, -0.08955844f, -0.05227167f, 0.11090883f, 0.09026395f, -0.11215086f, 0.09797214f, 0.35835508f, 
    -0.17258683f, -0.07371762f, 0.15232649f, -0.09619969f, 0.09360061f, -0.00576333f, 0.04921240f, -0.70640099f, 
    0.20948911f, 0.09630333f, 0.06821046f, -0.09209637f, 0.04524446f, 0.11904121f, 0.11740635f, -0.22196661f, 
    0.11879247f, 0.05567782f, 0.10013146f, 0.11276910f, 0.10851872f, 0.15049595f, -0.09182115f, 0.00203420f, 
    0.39650646f, 0.41952050f, 0.15056014f, -0.13499455f, 0.19036870f, 0.05698052f, 0.07183434f, 0.04185795f, 
    -0.22041842f, -0.24136344f, -0.05770222f, -0.60751337f, -0.10591168f, -0.12852833f, -0.11046621f, 0.09264934f, 
    0.20346418f, -0.02430969f, 0.01284006f, -0.54764640f, -0.67565763f, 0.12938003f, -0.23785828f, -0.18341851f, 
    -0.17938440f, 0.09299400f, -0.04445004f, -0.15162590f, -0.27086958f, 0.08951583f, -0.03634934f, -0.05124124f, 
    0.13071743f, 0.18743925f, -0.00769658f, 0.08771819f, 0.20167509f, 0.08001449f, 0.24243292f, 0.28266296f, 
    -0.00259783f, 0.01599166f, -0.00983232f, 0.17162651f, -0.02653578f, 0.09525176f, 0.02364547f, -0.53218597f, 
    0.25629058f, 0.05037689f, -0.07154197f, -0.02676229f, -0.05716445f, 0.26531792f, 0.00664489f, -0.12873906f, 
    -0.25971335f, 0.09434454f, -0.10754935f, -0.10563412f, -0.07584298f, -0.23050211f, 0.08788278f, 0.11293246f, 
    0.08934505f, 0.39438164f, 0.24338526f, 0.16341069f, 0.20287649f, 0.10890181f, -0.01532820f, 0.19109091f, 
    -0.01815078f, 0.34175888f, -0.21744603f, -0.48151687f, -0.17787516f, 0.17060025f, 0.14098088f, 0.00214837f, 
    -0.12335113f, -0.49317020f, -0.59782356f, 0.40463829f, -0.14589074f, 0.02208640f, 0.21980488f, -0.10577776f, 
    -0.10182773f, -0.14861195f, 0.18000183f, 0.06100008f, 0.23690365f, 0.08403361f, -0.11522231f, -0.15725389f, 
    0.02275935f, 0.15053995f, -0.09685732f, 0.25523791f, 0.38900471f, -0.28418612f, 0.23157977f, -0.26018497f, 
    0.06164094f, 0.17096083f, -0.01224593f, -0.06182003f, 0.21596892f, 0.11033553f, 0.49927646f, -0.10259373f, 
    0.09043791f, -0.13950886f, 0.00381033f, -0.19382708f, 0.16178896f, -0.06300942f, -0.31583753f, 0.34506500f, 
    -0.11236083f, -0.19422457f, -0.10268934f, -0.05844896f, -0.28729650f, 0.03517794f, 0.09793766f, 0.30894548f, 
    -0.20573890f, 0.05716161f, 0.24304850f, 0.06664274f, -0.12826543f, -0.13146938f, -0.17534347f, 0.40029109f, 
    0.21935573f, -0.13503025f, 0.12869334f, -0.05913461f, -0.19056842f, 0.09078138f, 0.14666137f, 0.00582955f, 
    -0.06622253f, 0.02020139f, 0.21419302f, 0.12566574f, -0.08224957f, -0.17861481f, 0.08613000f, 0.16105042f, 
    0.00575965f, -0.03399766f, 0.36386389f, -0.18534993f, 0.34427381f, 0.24226199f, 0.24486539f, -0.04725792f, 
    -0.06358196f, 0.07656441f, 0.58356971f, 0.12990278f, -0.02858722f, 0.05889612f, -0.41694760f, 0.06567211f, 
    -0.02004953f, -0.21276557f, 0.13797747f, 0.58704138f, 0.12156004f, 0.32317331f, 0.29171830f, -0.02801987f, 
    -0.18211219f, 0.02173619f, -0.01978602f, 0.15211543f, 0.28643733f, 0.16429664f, -0.20951670f, -0.00684320f, 
    -0.10157516f, -0.18618186f, 0.05449193f, -0.17891198f, 0.05405010f, -0.00074272f, -0.11561380f, -0.32492670f, 
    0.09001438f, 0.03570845f, -0.08738153f, -0.11147329f, -0.15353416f, -0.44638586f, -0.09721462f, 0.20884205f, 
    -0.11772446f, 0.07537614f, 0.24021883f, -0.04932518f, -0.01638681f, -0.07799442f, 0.15199675f, 0.02171905f, 
    0.20043196f, -0.16181079f, -0.36266324f, -0.11193787f, 0.01109626f, 0.01247071f, -0.00319465f, -0.12097206f, 
    0.23456457f, 0.45829189f, 0.19498838f, 0.10371638f, 0.22337912f, 0.06621290f, -0.35113144f, -0.35319397f, 
    0.00732563f, 0.01032694f, -0.52752161f, -0.00116237f, -0.07181139f, 0.06361849f, 0.21398970f, 0.06637559f, 
    -0.08197995f, -0.31444684f, 0.05398890f, 0.23452477f, 0.03979863f, 0.31919435f, -0.04659135f, -0.05377477f, 
    0.08752221f, -0.01998840f, 0.24891850f, -0.13992700f, 0.25322253f, -0.18696414f, 0.07240357f, 0.03443791f, 
    0.11235982f, -0.02162140f, 0.08941603f, 0.03780791f, 0.15514797f, 0.28051242f, 0.26096740f, -0.04417930f, 
    -0.08850559f, 0.13238835f, -0.02812409f, 0.07669955f, -0.02366371f, 0.41707408f, 0.53521466f, 0.14198802f, 
    -0.14054659f, -0.07920148f, -0.05652917f, 0.11283040f, 0.10229626f, 0.13764904f, -0.30069789f, -0.30630356f, 
    -0.06104919f, 0.00496873f, -0.04610172f, 0.09847534f, 0.05570434f, 0.22377053f, 0.02781473f, -0.25108343f, 
    0.10031241f, -0.04108859f, 0.10449714f, 0.02520727f, -0.00015377f, -0.08469021f, -0.01415529f, -0.05607578f, 
    -0.11112620f, 0.21820430f, 0.40011063f, -0.06399995f, 0.03608507f, 0.08435255f, 0.16415812f, 0.06051407f, 
    0.40449220f, -0.36495966f, -0.35516647f, -0.38275146f, 0.16176590f, 0.22145543f, 0.01687988f, -0.19264682f, 
    -0.05755060f, 0.10561705f, -0.17439187f, -0.37512401f, -0.09030957f, -0.09965876f, 0.22315852f, 0.14471404f, 
    0.02065928f, -0.10117652f, 0.36858705f, -0.13083787f, -0.19709979f, -0.25563964f, -0.11843856f, -0.27478388f, 
    -0.15220982f, 0.02505517f, -0.27029592f, -0.18177608f, -0.13340795f, -0.09892701f, 0.09247884f, 0.10259364f, 
    -0.12201884f, -0.00718159f, -0.09672924f, -0.27408126f, -0.29849732f, -0.33467522f, -0.31707880f, 0.15859172f, 
    -0.39728370f, -0.00066241f, -0.34299472f, 0.00478998f, -0.10864619f, -0.09141352f, -0.29456797f, 0.39775565f, 
    0.10399745f, 0.04724589f, -0.05898327f, -0.08414570f, 0.13542953f, 0.39118025f, 0.27481398f, 0.04993533f, 
    0.08555559f, -0.18705484f, -0.02974484f, -0.15589102f, -0.04840718f, 0.13970405f, 0.01489118f, -0.04407682f, 
    -0.21237195f, 0.15182859f, -0.07104993f, 0.02774270f, -0.02434796f, -0.34451449f, -0.27779844f, -0.35488477f, 
    -0.11786129f, -0.00473655f, 0.13466422f, 0.40436822f, 0.43510783f, -0.03068961f, -0.05478848f, 0.06999073f, 
    -0.10708088f, -0.02077701f, -0.19304970f, -0.09543004f, 0.47377652f, -0.00249125f, 0.01952045f, 0.13715713f, 
    -0.05397378f, 0.19856749f, 0.36548948f, 0.30223542f, 0.15706164f, -0.13477102f, 0.22432908f, 0.33371961f, 
    0.19545655f, 0.14711477f, -0.06614374f, -0.20793703f, 0.08222030f, 0.02190957f, 0.21141995f, -0.30337980f, 
    -0.18572947f, -0.07038403f, 0.12499228f, 0.03428901f, -0.44795945f, -0.41735971f, -0.05925424f, 0.03969415f, 
    -0.35868862f, -0.27219799f, 0.07247664f, 0.10740174f, 0.07030053f, 0.22141515f, -0.06620356f, -0.14595069f, 
    0.07418840f, 0.07246734f, 0.00133514f, 0.01909163f, 0.02579435f, 0.20703211f, 0.36474103f, -0.02725933f, 
    0.17983627f, 0.09737048f, 0.08234974f, 0.10730535f, 0.22367747f, 0.11756683f, -0.18678451f, 0.10383411f, 
    -0.38433945f, 0.18399802f, -0.01688584f, 0.12033824f, 0.10247684f, 0.14308268f, -0.02815410f, 0.14483054f, 
    -0.06355972f, -0.09869982f, -0.08350074f, -0.12932803f, -0.06084372f, -0.42843640f, 0.08067688f, -0.03040873f, 
    -0.09128354f, 0.01561065f, -1.42238700f, 0.56830966f, -0.44917113f, -0.00278116f, -0.25775203f, -0.03627792f, 
    -0.13172053f, 0.01359525f, 0.02585791f, -0.40744644f, 0.04883434f, 0.44526905f, -0.06445099f, -0.31056613f, 
    -0.01007826f, 0.00653778f, -0.11379290f, -0.05473850f, -0.13938388f, 0.30983979f, 0.19265422f, 0.05397013f, 
    -0.06157048f, -0.04893036f, 0.08088872f, -0.13058551f, 0.19710249f, -0.29623550f, 0.29893789f, -0.36567450f, 
    -0.12857221f, -0.01549376f, 0.02181510f, 0.14835350f, 0.02318813f, -0.01633395f, -0.16699918f, 0.37627381f, 
    -0.07638213f, 0.00732680f, 0.06018233f, 0.09013655f, -0.04842992f, -0.00614592f, -0.05949354f, 0.33279926f, 
    0.11932068f, -0.09382312f, 0.10268280f, -0.03257291f, 0.02614984f, 0.22147113f, 0.02002342f, -0.07797980f, 
    -0.46489707f, 0.15676738f, -0.18930703f, 0.11340207f, 0.08259991f, 0.26671821f, 0.22380416f, -0.06631479f, 
    -0.07998656f, -0.35769776f, 0.45792535f, 0.36823583f, -0.06903616f, 0.20551947f, -0.17798936f, -0.02967009f, 
    0.07741392f, -0.09028888f, -0.06878579f, 0.06882349f, 0.01159190f, -0.14144774f, 0.32564682f, -0.10315461f, 
    -0.09030487f, 0.00956570f, 0.02592666f, 0.03884621f, -0.36299822f, 0.01633721f, -0.01738413f, 0.07255704f, 
    -0.16357665f, 0.13259718f, -0.22250903f, 0.05880943f, 0.10096502f, 0.14680536f, 0.40550283f, -0.18991175f, 
    -0.16835967f, -0.03065165f, 0.06970178f, 0.06898890f, -0.13197470f, 0.12598105f, 0.26472288f, 0.29102120f, 
    0.03956695f, -0.50196248f, -0.29854456f, 0.03037286f, 0.22094040f, -0.04370733f, -0.39838308f, 0.15805863f, 
    0.05096971f, 0.31344208f, -0.02671599f, 0.17387395f, -0.02646404f, 0.10600214f, 0.04979757f, -0.39558023f, 
    -0.12606089f, 0.02250300f, -0.28574142f, 0.30753258f, 0.25186765f, -0.00783985f, 0.03664527f, 0.13132630f, 
    0.22530058f, 0.02872211f, 0.28433371f, 0.24042350f, 0.21213974f, 0.08463589f, -0.12245658f, -0.05371938f, 
    0.10294574f, -0.05762076f, -0.58970475f, -0.33597726f, -0.21379746f, -0.14596637f, -0.03978246f, -0.19020568f, 
    0.08717267f, 0.16046102f, -0.04807574f, -0.25295377f, -0.46949616f, -0.10606823f, 0.02476479f, -0.32838169f, 
    -0.01627561f, 0.29528669f, -0.08177577f, -0.20408650f, 0.07385517f, 0.10688385f, 0.02066235f, -0.19902936f, 
    0.14605348f, -0.11170869f, 0.10515198f, -0.17389022f, 0.20483504f, 0.06211441f, 0.15671168f, 0.02419741f, 
    0.06632651f, -0.05686386f, 0.35481471f, 0.21869317f, -0.34882766f, -0.39970332f, -0.26982394f, -0.10879761f, 
    -0.06379414f, -0.16678983f, -0.27136508f, 0.02645888f, -0.04960189f, 0.12102603f, -0.54215962f, -0.36672369f, 
    -0.12746541f, 0.13074122f, 0.03511525f, 0.13315944f, 0.25878817f, 0.30097508f, 0.14568439f, -0.22535613f, 
    -0.19956140f, 0.46018484f, 0.10075862f, -0.03367547f, 0.23040843f, 0.05257434f, -0.02889532f, 0.07460624f, 
    0.10988160f, 0.04005652f, -0.06894216f, 0.00550597f, -0.08738030f, 0.29695728f, -0.13771389f, 0.07405740f, 
    -0.14051077f, 0.51195419f, 0.26457840f, 0.57469195f, -0.00816052f, 0.14748713f, 0.16997816f, 0.10338712f, 
    0.15298748f, 0.35230523f, 0.57186913f, -0.51334602f, -0.18024309f, 0.06334009f, 0.12962353f, -0.14012730f, 
    -0.11555137f, 0.05104246f, -0.17092767f, 0.05161724f, -0.31783465f, 0.15245976f, -0.14345637f, -0.19223018f, 
    0.10291989f, 0.21515897f, 0.07863218f, -0.42389882f, -0.38576630f, -0.04642694f, 0.05115998f, -0.03419609f, 
    -0.08966933f, 0.27611578f, 0.14415653f, -0.05030525f, -0.05939332f, -0.39021116f, -0.09664688f, -0.00809393f, 
    -0.16214250f, -0.09737443f, -0.09116495f, 0.17316076f, -0.28794006f, -0.19597866f, -0.00121071f, 0.29266867f, 
    0.22972716f, 0.20214574f, 0.20126623f, 0.16513713f, 0.23933482f, -0.06961089f, 0.15475336f, 0.28438666f, 
    0.27993566f, 0.36676621f, 0.18660934f, 0.31326944f, 0.29960468f, 0.16657993f, 0.01326155f, -0.15304860f, 
    -0.06087929f, -0.37487906f, 0.17143090f, 0.00882702f, -0.21245641f, -0.16147913f, 0.07063781f, 0.01221947f, 
    0.19042586f, -0.04409006f, -0.30498350f, 0.24740504f, -0.12938122f, -0.18224576f, -0.11876089f, -0.01326497f, 
    -0.17125292f, 0.05756409f, 0.06344812f, 0.14564329f, 0.03059424f, -0.00084635f, -0.02046780f, -0.14230546f, 
    0.12228987f, -0.01939091f, 0.02889783f, -0.55403090f, 0.33665937f, 0.10277121f, -0.29071984f, 0.09898548f, 
    0.00615912f, -0.05811528f, -0.07006619f, -0.22632129f, 0.35926959f, 0.22501583f, -0.19749951f, 0.10120758f, 
    0.05846852f, -0.11251958f, 0.07503869f, 0.11676254f, -0.09939792f, -0.04765259f, -0.20687425f, 0.06609851f, 
    0.01201998f, -0.15270017f, -0.17836520f, -0.02242094f, 0.04545804f, 0.08929741f, 0.01475441f, -0.10608383f, 
    0.05479915f, -0.09888414f, -0.40156117f, 0.08042564f, 0.02235041f, 0.05279721f, 0.18692774f, -0.05898694f, 
    -0.22050554f, -0.01110968f, -0.02780783f, 0.15345022f, 0.22216083f, 0.12715527f, 0.06369255f, 0.08562008f, 
    0.41718909f, 0.24134620f, -0.24914235f, 0.11016593f, -0.06609771f, 0.11106993f, 0.03323588f, -0.05850295f, 
    -0.33847582f, 0.21574435f, 0.50604284f, 0.02057232f, 0.13905802f, -0.03332343f, 0.31809518f, 0.07828821f, 
    0.17266156f, 0.09854750f, 0.46687457f, -0.12982367f, -0.53117651f, -0.04535067f, 0.23692082f, 0.07446206f, 
    -0.05849770f, -0.14359668f, 0.19937076f, -0.36408424f, -0.23112564f, -0.42366254f, -0.40733427f, -0.13472022f, 
    -0.22631925f, 0.02492477f, 0.03387506f, 0.05036704f, 0.21918146f, -0.06956244f, 0.21450499f, -0.01186030f, 
    -0.21451171f, 0.18265007f, -0.04148939f, -0.08794609f, -0.07577477f, 0.19848506f, 0.47745541f, 0.12228885f, 
    -0.08537917f, 0.00287284f, -0.19641173f, -0.13802660f, -0.00774601f, -0.01988472f, -0.02356572f, -0.36114222f, 
    -0.01213698f, 0.34313169f, 0.07284452f, 0.01373512f, -0.00344393f, -0.09351660f, 0.29613352f, -0.24623610f, 
    -0.35336617f, -0.23101558f, -0.01331876f, 0.02205917f, -0.01346285f, 0.13519153f, 0.08026181f, -0.05031445f, 
    0.21198651f, -0.02821862f, -0.06553055f, 0.09084380f, 0.10429758f, 0.05661111f, 0.15988274f, -0.12001760f, 
    0.06597571f, -0.61468428f, 0.31158516f, 0.27348128f, -0.07387213f, -0.13794805f, 0.24848793f, 0.02333714f, 
    -0.07230863f, 0.13670570f, 0.47094145f, -0.03982922f, -0.05479138f, -0.02138602f, 0.07997990f, 0.04818916f, 
    -0.10958885f, 0.08578168f, -0.01099696f, -0.60475868f, -0.42142758f, -0.22840649f, -0.22786751f, 0.27396357f, 
    -0.13948245f, 0.05863069f, 0.10407959f, 0.01813801f, 0.13214773f, 0.05819005f, 0.15997018f, 0.03656798f, 
    0.17266680f, 0.07106465f, -0.09739701f, 0.07408434f, 0.07898663f, 0.05144092f, 0.25784418f, -0.07380135f, 
    -0.04274778f, -0.07109685f, -0.09136651f, 0.14260323f, 0.01005914f, 0.24710280f, 0.60979706f, -0.23418422f, 
    -0.30211359f, 0.02250886f, -0.11199814f, -0.01710694f, -0.04125801f, 0.05267268f, -0.16829470f, -0.22245009f, 
    -0.05425128f, 0.56308156f, -0.01402444f, 0.08694956f, 0.15363422f, -0.16686749f, -0.13696124f, 0.07044514f, 
    -0.21523204f, -0.04468568f, 0.10411561f, -0.03857841f, -0.19164521f, 0.10856476f, -0.01903357f, 0.09590837f, 
    0.23319072f, 0.08903761f, 0.10540172f, 0.32115898f, 0.16777338f, -0.08140104f, -0.25819182f, 0.20742609f, 
    0.08358264f, 0.16369538f, -0.57307625f, -0.58793628f, -0.50958914f, -0.30866709f, -0.04929290f, -0.18181172f, 
    0.24549444f, -0.04911914f, -0.07572862f, -0.87875348f, -0.59991467f, -0.60969681f, -0.15244193f, 0.06902222f, 
    0.02113519f, -0.00743854f, 0.08197528f, -0.11561554f, 0.29245302f, -0.79775959f, -0.07947707f, -0.08411329f, 
    -0.06965035f, -0.56175870f, 0.15563978f, 0.04638691f, 0.10188307f, -0.47294101f, -0.56808686f, -0.12641016f, 
    0.17770280f, 0.25874612f, -0.12340569f, -0.33557665f, -0.16057627f, -0.06862867f, 0.49915743f, -0.13143530f, 
    -0.03405121f, 0.17571816f, 0.13192333f, -0.12381957f, 0.02159651f, 0.01252011f, 0.00260401f, 0.28591400f, 
    0.17286299f, -0.02604227f, -0.04929246f, 0.26561728f, -0.03812278f, 0.11931816f, -0.03608761f, 0.02291554f, 
    -0.41099903f, 0.04854339f, -0.28570074f, 0.09670418f, 0.21395671f, 0.08782573f, -0.10790866f, 0.04725026f, 
    0.18173552f, 0.06255934f, -0.99792171f, -0.11987013f, -0.28923628f, 0.11642337f, -0.03674904f, 0.13614289f, 
    -0.20551653f, -0.14157830f, 0.05042890f, 0.37778756f, 0.31622583f, 0.02566854f, -0.01718652f, -0.10885289f, 
    -0.01559266f, -0.17293653f, -0.00843331f, 0.40206254f, -0.31926477f, -0.00306187f, -0.08713564f, -0.33811659f, 
    -0.16705850f, -0.03147013f, -0.16842251f, -0.09705254f, 0.06663554f, -0.23183931f, -0.38412732f, -0.12836161f, 
    -0.01071466f, -0.18005800f, -0.01110108f, 0.07840678f, -0.00612742f, 0.29230112f, 0.11720308f, 0.26043603f, 
    -0.13222943f, 0.10928276f, -0.04971056f, -0.07798157f, -0.26923454f, -0.08288937f, -0.00214479f, -0.06078148f, 
    0.09037009f, 0.00300239f, 0.05903886f, 0.02602789f, 0.01350210f, -0.00849526f, 0.27155465f, 0.12959892f, 
    -0.28952909f, -0.34925085f, 0.10719107f, 0.01000276f, 0.04565076f, 0.08124023f, 0.07752708f, 0.22961682f, 
    -0.07659388f, -0.20906097f, -0.38351107f, 0.06167269f, -0.20695797f, -0.07797883f, -0.02476331f, -0.04066077f, 
    -0.21324107f, 0.00228636f, 0.24250059f, 0.29420504f, 0.15576230f, -0.01862110f, 0.04162113f, 0.16707407f, 
    0.07114407f, 0.01279618f, 0.05909469f, 0.44120362f, 0.30869633f, 0.00404746f, 0.04624239f, 0.08141419f, 
    0.04065018f, 0.03611280f, 0.16407804f, 0.03570796f, -0.26254642f, -0.04857581f, 0.06412837f, 0.23924395f, 
    0.02936793f, 0.03773101f, 0.02769772f, -0.11711865f, -0.19630872f, 0.66467929f, 0.30329823f, -0.07468892f, 
    0.15760231f, 0.14221744f, 0.01533363f, -0.04990449f, 0.17782575f, 0.06968174f, 0.54109037f, -0.19977838f, 
    -0.13340694f, 0.00837504f, 0.15672973f, 0.03990120f, 0.04863209f, 0.19716758f, -0.31097072f, -0.06261300f, 
    0.09227750f, -0.20313407f, 0.00571845f, 0.06104327f, 0.30056033f, 0.00544561f, 0.36859313f, -0.50811499f, 
    0.25238276f, -0.30588365f, -0.02651835f, 0.27606246f, 0.22544596f, -0.11012325f, -0.10660429f, -0.10667295f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.04482321f, -0.07190493f, 0.15115309f, 0.20174095f, -0.07486154f, 0.27771577f, -0.05832623f, 0.14856218f, 
    0.00350997f, -0.15283149f, 0.11665525f, 0.13619061f, 0.42657545f, 0.30828595f, 0.23790085f, 0.11172348f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.21166196f, 0.16512376f, -0.13324216f, -0.37325770f, 0.50099385f, -0.03506152f, 0.21581858f, 0.59912288f, 
    0.37105134f, -0.11618253f, 0.31067699f, 0.24603306f, 0.36482304f, 0.55271822f, -0.03561759f, 0.15913269f, 
    0.08997215f, 0.20686744f, 0.30768672f, -0.21182384f, 0.03746739f, -0.13624017f, -0.03050618f, 0.02515656f, 
    -0.15146793f, -0.11292988f, 0.33161557f, -0.13740571f, -0.25610802f, 0.12011912f, 0.04595779f, 0.22531071f, 
    0.18218909f, 0.11663761f, 0.22031677f, 0.24250342f, -0.36232218f, 0.18196562f, 0.09409995f, 0.14200209f, 
    -0.35069698f, -0.39235598f, 0.16737115f, -0.17565459f, -0.18122299f, 0.44599730f, 0.32188490f, 0.02531073f, 
    0.04428513f, 0.13004649f, -0.63772655f, -0.00952467f, 0.45541006f, 0.23967901f, -0.04168114f, 0.30123362f, 
    0.04064068f, -0.05409061f, -0.13545272f, 0.14320743f, -0.05922925f, 0.27739185f, 0.34579903f, -0.27179497f, 
    -0.11456108f, 0.02992547f, -0.72868276f, -0.11671568f, -0.06430842f, -0.02454670f, -0.13663316f, 0.46075353f, 
    0.20945147f, 0.30854496f, -0.04388206f, 0.09749819f, 0.42374983f, 0.64220333f, -0.55648381f, -0.26412538f, 
    0.20151339f, -0.25075966f, -0.11428076f, 0.23848467f, -0.15349452f, -0.54543126f, 0.09856760f, 0.62515581f, 
    0.10149341f, -0.14436500f, 0.19080442f, 0.16819245f, 0.34582123f, 0.52995449f, -0.47691035f, -0.95705986f, 
    0.14693397f, -0.01580150f, -0.15064472f, 0.07330728f, -0.36698344f, 0.13942976f, 0.09506627f, 0.71020877f, 
    -0.43854252f, 0.14765623f, 0.07693290f, 0.19736709f, 0.20882681f, -0.00022754f, 0.82994854f, -0.94191897f, 
    0.14234103f, -0.00853841f, 0.16785491f, -0.38981077f, -0.25513300f, 0.65358710f, -0.16995561f, 0.74102074f, 
    0.11330518f, 0.07536471f, 0.00919368f, -0.48745403f, 0.51353127f, 0.39842308f, 0.54476839f, -0.03597027f, 
    -0.11703141f, 0.07918983f, 0.11772146f, -0.10898250f, -0.00118928f, -0.21877724f, 0.13758923f, -0.15342347f, 
    -0.12506232f, -0.22152634f, -0.23708577f, 0.07486169f, -0.19727111f, -0.19536699f, 0.01019487f, 0.09897543f, 
    -0.05987017f, 0.23749918f, -0.06095481f, -0.24241699f, 0.08802329f, 0.13104308f, 0.08335204f, 0.11094568f, 
    -0.24725339f, 0.12470220f, 0.16078785f, 0.09300117f, -0.24365732f, 0.20868599f, -0.06140646f, -0.18513855f, 
    0.24187338f, -0.12893619f, -0.14201227f, -0.05508684f, 0.87048227f, -0.04417767f, -0.07166716f, -0.40400645f, 
    0.25020128f, 0.02858095f, 0.37956953f, 0.39249411f, 0.48733410f, 0.23091146f, -0.76647735f, 0.28605461f, 
    -0.17398337f, 0.14114472f, -0.16975874f, -0.23477575f, -0.14716414f, 0.14721158f, -0.14691618f, 0.19902427f, 
    -0.17989635f, 0.02469350f, -0.22513333f, 0.07389984f, 0.09874497f, -0.07210284f, -0.00592781f, 0.02350582f, 
    0.17824715f, -0.01798864f, 0.33102506f, -0.08838335f, -0.53588885f, 0.55440265f, -0.16880485f, -0.30443999f, 
    0.62495697f, -0.06074942f, 0.54341114f, 0.71111524f, 0.06780331f, -1.24732769f, -0.31935877f, 0.02843568f, 
    -0.20877363f, -0.08936982f, -1.14841866f, 0.53511697f, 0.30649370f, -0.19622381f, 0.14766620f, -0.19482161f, 
    0.39810091f, -0.49526021f, -0.51309335f, -0.52029157f, 0.27614880f, -0.56197816f, 0.62287474f, -0.63337314f, 
    0.06587610f, 0.10583936f, 0.39013734f, 0.24231714f, -0.30871034f, 0.12847121f, 0.01583698f, -0.08390877f, 
    -0.03354229f, -0.03565976f, -0.38393149f, -0.28719383f, -0.96505624f, -0.03494171f, -0.00807515f, -0.08501036f, 
    0.14792745f, 0.00278479f, -0.71591729f, 0.26755536f, -1.03925681f, 0.59112155f, -0.07669594f, -0.34802842f, 
    -0.41605154f, -0.17448577f, 0.29206496f, 0.48281348f, 0.03963405f, -0.44235164f, 0.38125336f, -0.10105619f, 
    0.12430121f, 0.01385869f, -0.48327932f, 0.13591486f, -0.37991294f, -0.49774298f, 0.18283813f, 0.44942775f, 
    -0.17491393f, -0.10245125f, 0.40171650f, 0.12014255f, 0.34103039f, 0.15443119f, 0.22065139f, 0.23630658f, 
    0.20671690f, -0.16320957f, 0.24369955f, 0.36697251f, -0.16389190f, 0.48020208f, 0.19493957f, -0.15761845f, 
    -0.04517505f, -0.51373661f, -0.79782075f, -0.48448640f, 0.38152617f, 0.31285101f, 0.21902350f, -0.20477676f, 
    -0.14362490f, 0.05210751f, -0.13992456f, -0.16745201f, 0.19893995f, 0.02444997f, 0.10783178f, -0.24450898f, 
    -0.09407741f, -0.17901546f, -0.03488061f, -0.10523304f, -0.05953428f, -0.00682768f, -0.02527991f, -0.15496656f, 
    0.15717117f, -0.03226379f, 1.06603539f, -0.17687842f, 0.24578223f, -0.25850546f, -0.23135522f, -0.15590480f, 
    0.65587586f, 0.64978200f, 0.57700539f, -0.23198287f, 0.16824177f, -0.17231506f, -0.48058087f, 0.35386550f, 
    0.16027528f, 0.21830244f, -0.80438071f, 0.27480528f, -0.13770919f, 0.09475363f, -0.21308362f, 0.03686383f, 
    0.28211889f, -0.65884316f, 0.20990886f, 0.18281831f, 0.29545975f, -0.46594688f, -0.33862844f, -0.20499982f, 
    0.17433119f, 0.21571583f, 0.54760599f, -0.00594802f, -0.43990788f, -0.26584300f, -0.17487824f, 0.60903847f, 
    0.37199482f, 0.37132463f, 0.42508918f, 0.10803334f, -0.20288859f, 0.04615938f, 0.71106535f, -0.04451417f, 
    0.22741708f, -0.08968579f, 0.20616475f, 0.24494499f, -0.67196357f, 0.09388197f, -0.02661929f, 0.16585647f, 
    -0.31348008f, -0.06249692f, 0.77052355f, 0.98503739f, 0.22979780f, 0.09501827f, -0.14353460f, -0.24975093f, 
    -0.23522978f, -0.08923810f, 0.33904403f, 0.21477708f, 0.48718861f, 0.25412986f, -0.00470533f, -1.00280690f, 
    0.42277455f, -0.12414343f, 0.21977007f, 0.47837585f, -0.35368657f, -0.71718961f, -0.12762579f, 0.06991208f, 
    0.01543389f, -0.24155001f, 0.77269250f, 0.17682473f, -0.76163894f, 0.10609204f, -0.19069538f, -0.53684139f, 
    -0.10367237f, -0.73425788f, 0.06469496f, 0.39428532f, -0.04898993f, 0.03804202f, 0.45130372f, -0.32711765f, 
    0.13965109f, -0.04580343f, -0.11960062f, -0.19095215f, 0.20871449f, 0.16099855f, -0.08613479f, 0.23628157f, 
    -0.15328592f, -0.20198026f, -0.22580299f, 0.07907286f, -0.02945927f, 0.03435639f, 0.05998817f, -0.07438612f, 
    0.08862139f, 0.12055666f, 0.07225484f, 0.48296171f, -0.47407919f, 0.25365028f, -0.21268019f, -0.15340225f, 
    -0.04765765f, -0.07252251f, -0.17988886f, -0.52765179f, 0.29321647f, -0.42186424f, 0.15570614f, -0.73971224f, 
    0.21333662f, 0.13595991f, 0.11569669f, -0.30128184f, 0.14932683f, 0.48082498f, 0.10935096f, 0.19769749f, 
    0.56904650f, -0.01036652f, 0.36504564f, -0.72233766f, 0.09538074f, 0.19127029f, -0.14745794f, 0.37189975f, 
    0.20215495f, -0.03724787f, -0.69013548f, 0.46569654f, -0.02643622f, -0.52500767f, 0.15710856f, 0.12591055f, 
    0.27413827f, 0.15118071f, -0.65064389f, -0.41582042f, 0.26671606f, -0.23426124f, -0.47219604f, -0.22176071f, 
    0.06005889f, 0.23133394f, 0.35827935f, -0.15840283f, 0.73557764f, -0.20208424f, 0.19495383f, 0.60845244f, 
    0.00368126f, 0.41461393f, 0.51808769f, 0.48642299f, -0.08506197f, 0.61979765f, 0.25069061f, 0.21437223f, 
    -0.10225496f, 0.06258945f, 0.19649890f, -0.15737824f, 0.42865470f, 0.75583333f, 0.15969630f, -0.30886015f, 
    0.06932823f, 0.09220026f, 0.44097248f, 0.74898493f, -0.12511265f, -0.44289744f, 0.03527096f, -0.27622920f, 
    -0.11021632f, -0.07247948f, -0.01732345f, -0.18019553f, -0.19729821f, -0.00207827f, -0.12077586f, -0.09868482f, 
    0.11885617f, -0.15386455f, -0.09106980f, -0.00150362f, 0.09313820f, 0.04970526f, 0.10047983f, -0.12600490f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.14786859f, 0.74704194f, -0.08322485f, 0.17769065f, 0.04227844f, 0.10803522f, 0.12809798f, 0.46933925f, 
    0.12719743f, -0.18784481f, 0.36088058f, -0.15855671f, -0.24504295f, 0.26443312f, 0.87270665f, 0.33789310f, 
    -0.20321453f, 0.39196077f, -0.17577454f, -0.15390658f, 0.49280059f, -0.21699023f, 0.09905756f, -0.11512565f, 
    0.44139129f, -0.13768303f, 0.42893690f, 0.30472180f, 0.16386588f, 0.11520110f, -0.07391296f, -0.22467762f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.20888889f, -0.33850276f, 0.09241888f, 0.21829757f, -0.04634243f, -0.10329365f, -0.21040289f, -0.53779680f, 
    -0.05603386f, -0.12283885f, 0.33913240f, 0.11773048f, -1.43503320f, 0.27126300f, -0.51881653f, -0.08398336f, 
    -0.28442866f, -0.46751159f, 0.04463050f, 0.27722245f, -0.00847084f, -0.34580654f, -0.86951876f, 0.28250837f, 
    -0.85358328f, -0.04720582f, -0.73294359f, -0.03197132f, 0.27052617f, 0.42832926f, 0.00263146f, 0.10663602f, 
    0.45509395f, 0.39731437f, 0.02671471f, 0.24313028f, 0.30735680f, -0.04968918f, -0.36892405f, 0.33890349f, 
    0.16555855f, -0.14060278f, 0.35312131f, -0.16600960f, -0.31742269f, -0.62516320f, 0.69646198f, -0.61487484f, 
    -0.15554506f, 0.14266011f, -0.14859048f, -0.01491062f, -0.31919149f, -0.39287746f, -0.10196190f, -0.20350854f, 
    0.76649016f, 0.07019459f, -0.43289471f, 0.25906760f, -0.27281874f, 0.21047592f, 0.16480297f, -0.06311993f, 
    0.17320837f, -0.07554916f, 0.07330338f, 0.20092109f, -0.01853747f, 0.40038854f, 0.48922005f, -0.01231182f, 
    0.09596466f, -0.14935406f, -0.59741998f, -0.08281132f, -0.44852170f, 0.45173776f, 0.56612420f, 0.21066067f, 
    0.31790268f, 0.10310520f, -0.03212525f, -0.88091254f, 0.27773589f, 0.13017479f, -0.07464100f, -0.63430047f, 
    -0.85187805f, 0.16460726f, 0.07069393f, -0.23585221f, 0.23602246f, -0.21019825f, -0.63861006f, -0.17132345f, 
    -0.14795686f, -0.32990161f, -0.46832970f, -0.50582802f, 0.25872749f, 0.34389850f, -0.16281095f, -0.31709561f, 
    -0.01289894f, -0.15598908f, 0.13988794f, -0.02554859f, -0.50267541f, 0.16088513f, -1.31667447f, -0.33311036f, 
    0.36617610f, 0.16514885f, 0.05248288f, 0.13782364f, 0.03823216f, -0.21714172f, 0.17275527f, -0.25636870f, 
    -0.75528908f, 0.06774358f, 0.17000796f, -0.18669897f, 0.49404433f, -0.22118875f, -1.16721201f, -0.16310452f, 
    -0.07120714f, 0.19038744f, 0.16871215f, -0.06406909f, 0.02295629f, 0.28820288f, -0.27919593f, -1.10088623f, 
    0.13310614f, 0.15662535f, 0.02583908f, 0.11622133f, 0.36521325f, 0.15790725f, 0.01690221f, -0.66973931f, 
    -0.19360621f, -0.38823530f, -0.15398315f, 0.19411391f, 0.06667606f, 0.31790096f, 0.05009041f, 0.58970928f, 
    -1.22781193f, 0.11940899f, -0.34051150f, -0.07309043f, 0.00001597f, -0.01324309f, 0.36395940f, 0.02781498f, 
    0.23897342f, -0.94577718f, 0.06761178f, -0.15126809f, 0.19447680f, 0.00419144f, -0.48367590f, 0.14564019f, 
    0.13817681f, 0.04195016f, 0.05707514f, -0.14390238f, 0.60064501f, -0.23859271f, -0.14444408f, -0.14603999f, 
    -0.08690176f, -0.27154723f, 0.15452543f, 0.34672746f, 0.08608217f, -0.02792649f, -0.20312202f, -0.10193564f, 
    -1.32100117f, 0.06645790f, -0.29410473f, 0.60637379f, 0.05091466f, -0.13882308f, -0.12456801f, 0.02066653f, 
    -1.16704297f, -0.69817698f, 0.19861405f, 0.23089565f, -2.00250697f, -1.07225049f, 0.76829588f, 0.19608489f, 
    -0.17434600f, 0.12761077f, -1.38180423f, -0.07598610f, -0.19120209f, 0.67229646f, 0.22686099f, 0.24740328f, 
    -0.03152574f, 0.22292492f, 0.04127318f, -0.76779944f, -0.24631394f, 0.22903031f, -0.01462956f, -0.23532577f, 
    -0.21253370f, 0.16028889f, 0.41603771f, -0.15703437f, -0.17736205f, -0.38627690f, -0.18635818f, -0.15482378f, 
    -0.87585032f, -0.04476267f, -0.23463985f, -0.75037879f, -1.41309357f, -0.96453792f, -1.05130398f, 0.14684647f, 
    -0.02275259f, -0.06662361f, -0.57558858f, -0.19815861f, 0.35027578f, -0.39380628f, -0.77607775f, -0.57525307f, 
    -0.05148366f, -0.06869777f, 0.03880616f, 0.63304019f, -0.09504385f, 0.55845487f, -0.18218546f, 0.16090448f, 
    -0.47660264f, -0.05802947f, -0.01014140f, -0.07254265f, 0.02227836f, 0.24674441f, 0.13179533f, -0.05268228f, 
    0.09932334f, -0.27119100f, -0.02090823f, -0.25819820f, -0.22838886f, -0.46745014f, 0.52484810f, 0.43114746f, 
    -0.02056759f, 0.10076017f, -0.10964384f, 0.06806373f, -0.43597519f, -1.50803626f, -0.53050834f, -0.10895841f, 
    0.20983358f, -0.22530678f, -0.13470523f, 0.13093340f, -1.58250523f, 0.34352422f, 0.27272245f, -1.01675677f, 
    -0.15921900f, -0.02845458f, 0.04112934f, 0.13439240f, -1.03459466f, 0.44989571f, -0.27558157f, -0.01496753f, 
    -0.56586432f, -0.12268929f, -0.27020150f, -0.21063410f, -0.19847344f, -0.55435151f, -0.29290235f, 0.08703013f, 
    -0.00476667f, -0.07924561f, -0.10711358f, -0.09631488f, 0.25785208f, 0.29902604f, -0.80591053f, 0.41627368f, 
    -0.26652631f, 0.37988690f, 0.10386705f, -0.47186616f, 0.36296746f, -0.47681496f, -0.18676069f, 0.26929298f, 
    -0.17449464f, 0.14002211f, 0.44507024f, 0.14707127f, 0.13698483f, -1.11987317f, 0.08789981f, -0.06762589f, 
    0.06717219f, -0.65607679f, -0.93418521f, -0.23157771f, -0.12955067f, -0.17713606f, 0.17067164f, -0.20354314f, 
    0.08310333f, -0.04996969f, 0.21416177f, -0.20961295f, 0.36846280f, -0.74723214f, -0.90054744f, 0.48805955f, 
    0.30480483f, -0.68089497f, -0.08664583f, -0.38814521f, 0.24783911f, -0.19825909f, 0.41757533f, 0.32390288f, 
    -1.00813723f, 0.16676113f, -0.36379907f, -0.84320182f, -0.86000764f, 0.22712584f, 0.38377112f, -0.02512143f, 
    -0.70093381f, -0.22979872f, 0.12128554f, -0.65703553f, -0.19504626f, 0.54711813f, 0.43795201f, -0.13844143f, 
    -0.08065934f, -0.10571773f, -0.54075420f, -0.05587675f, 0.35699639f, -0.74685377f, -0.49008217f, 0.22689019f, 
    -0.43578750f, 0.08256057f, -0.07382674f, -0.22798130f, -0.34294716f, -0.09321973f, 0.35083422f, -0.04249862f, 
    0.48364222f, 0.16309825f, 0.21178229f, -0.55668825f, -0.19338913f, -0.28255656f, 0.53889740f, 0.00134768f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.08963466f, 0.33312902f, -0.21101010f, -0.07828122f, -0.17261432f, -0.20736384f, -0.07714306f, -0.28563663f, 
    0.04894335f, 0.39496112f, -0.16475752f, -0.23400190f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
