#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -1.37546933f, -1.18724537f, -0.36852291f, -0.80065048f, -0.68748385f, -0.27678460f, -0.81203353f, 0.05027654f, 
    0.32493165f, -0.35505536f, 0.76757282f, -0.19958234f, -0.36187267f, 0.10946934f, 0.22645465f, 0.00594685f, 
    -0.15758289f, -0.15526122f, -0.38797262f, 0.00631397f, 0.33387911f, 0.55026054f, -0.05195565f, 0.47263455f, 
    -0.14503928f, -1.18471837f, 1.02166772f, 0.54155433f, -1.26362705f, 0.88165641f, -0.28951126f, -0.38754249f, 
    -1.03142357f, -0.58134007f, -0.88263661f, 0.27518696f, 0.14931741f, 0.15673058f, 0.16599500f, -0.48033658f, 
    -0.16732527f, 0.06539425f, -0.06821369f, -0.45270759f, -0.56203371f, -0.11116248f, -0.00371768f, 0.10046834f, 
    0.24313264f, -0.17827593f, 0.87611717f, 1.40554118f, -1.00278807f, 0.34651342f, -1.20119345f, 1.09372604f, 
    0.28475761f, -0.00222877f, 0.58776098f, 0.67558122f, 0.12692109f, -0.17737162f, -0.36333269f, -0.39218307f, 
    -0.18198980f, 0.00238360f, -0.34768760f, -0.25371775f, 0.01123100f, 0.11286784f, -0.00596429f, -0.24313517f, 
    -0.19594768f, -0.06730621f, -0.03448516f, 1.07657492f, 0.34337595f, 0.48276681f, 1.77950644f, 1.17283070f, 
    0.82142252f, 0.30246034f, 0.02960939f, 0.01900580f, -0.01272248f, 0.15977827f, 0.15251942f, 0.22105029f, 
    0.42788559f, -0.31604970f, 0.03955036f, 0.11600277f, 0.48704252f, 0.13679223f, 0.58382511f, 0.15982023f, 
    0.47938073f, 0.48664224f, -0.14191845f, 0.13655224f, -0.67313886f, -1.32205796f, -0.84607166f, -0.55423957f, 
    -0.12523198f, -0.03569023f, 1.66621459f, -0.07213079f, -0.22724120f, 0.41287494f, 0.00017282f, -0.22159867f, 
    -0.28917256f, -0.35236394f, 0.22838169f, 0.24490584f, 0.51813489f, -0.02994889f, 0.19797875f, 0.18768248f, 
    -0.03227634f, -0.18770047f, 0.07203763f, 0.02248230f, 0.17090957f, 0.13038768f, -0.10196710f, -0.71783108f, 
    -0.96393728f, -0.35071447f, 1.05298257f, 1.13174462f, 0.37442127f, 0.80300438f, 1.14875960f, -0.35731575f, 
    -0.05089254f, -0.04848137f, -0.34194884f, -0.16645662f, -0.25552243f, -0.06496125f, 0.00448240f, 0.01362052f, 
    -0.16775285f, -0.32556286f, -0.21460725f, 0.11811368f, -0.26180428f, 0.16699956f, 1.75703478f, 0.70587748f, 
    -1.64754307f, -1.00487268f, -0.80419022f, -0.21042980f, 0.18695126f, -0.46528444f, -0.00469608f, -0.26934657f, 
    -0.19967711f, 0.10589272f, 0.17546579f, 0.20301384f, 0.18682377f, 0.00728935f, 0.06836733f, -0.06802320f, 
    0.01013997f, 0.32267055f, 0.39305720f, 0.09684503f, 0.00784755f, -0.19840056f, -0.02786865f, 1.46742237f, 
    -0.13892582f, -0.09883894f, 1.28106475f, 1.14923811f, -0.06102317f, 0.51459289f, -0.49055469f, 0.52370870f, 
    0.53168064f, -0.48511291f, -0.25679073f, -0.78041869f, -0.22351205f, -0.23181929f, -0.49523607f, -0.39277595f, 
    -0.45821029f, -0.19833626f, -0.40712631f, 0.15383932f, 0.17965925f, -0.07818713f, -0.01905236f, -0.03738264f, 
    -0.56747389f, -0.62509954f, -0.47816446f, -0.67058921f, -0.71748185f, -1.16018093f, 0.22098045f, 0.72105396f, 
    0.41276753f, 0.13369627f, -0.83319134f, -0.14631628f, -0.81917334f, -0.40400794f, -0.10062728f, -0.11564573f, 
    0.15536948f, -0.51946414f, 0.01215525f, -0.54607207f, 0.00947468f, -0.40093985f, 0.24395724f, -0.19303247f, 
    -0.33183393f, -0.77498513f, -1.54663253f, -1.04065263f, 0.49986210f, 1.02440929f, 0.91193157f, 0.46119183f, 
    -0.78301817f, 0.95709622f, -0.29615831f, 0.19380969f, 0.16264018f, -0.08011065f, 0.70447606f, 0.25456646f, 
    -0.32094193f, -0.37179276f, -0.23662183f, -0.64624172f, -0.19092160f, 0.06559359f, 0.23808020f, 0.04867111f, 
    -0.05251697f, -0.16434613f, -0.93072385f, -0.57658350f, -0.27960211f, 1.18247616f, 0.00712114f, -1.03338671f, 
    1.01871622f, 0.46205917f, 0.35006911f, -0.59114438f, 0.65013325f, 0.22075558f, 0.16690147f, -0.25033677f, 
    0.10740532f, -0.17150153f, 0.29892713f, -0.26565933f, 0.40016159f, -0.60393870f, -0.34858561f, -0.24550198f, 
    -0.45506886f, -0.00311127f, -0.37866810f, -0.30935287f, -0.73982257f, 0.27399313f, 1.16102266f, -0.02327922f, 
    -1.41140163f, -0.79485726f, -0.68197882f, -0.50930637f, 0.11827321f, 0.47273099f, 0.68920493f, 0.18744703f, 
    0.39609542f, -0.42908594f, -0.25189254f, 0.28901356f, 0.35208839f, 0.04597424f, 0.11832579f, 0.22614948f, 
    -0.09351404f, 0.11153346f, 0.19402361f, -0.06396424f, 1.91531754f, 0.56288046f, 1.62520516f, -0.03257956f, 
    -0.35442498f, 0.43324399f, -1.25776684f, 0.27421364f, -0.19440667f, 0.40012437f, 0.18922085f, -0.07253353f, 
    -0.25789899f, 0.06774575f, -0.35134396f, -0.11151551f, 0.17439248f, 0.25172889f, -0.36370808f, -0.15128411f, 
    -0.07671095f, 0.53355259f, 0.16152826f, 0.06239126f, 0.03943954f, -0.61215961f, 0.49904233f, 1.32119036f, 
    -0.23316224f, 0.52793419f, 1.00105083f, 0.65072995f, 0.81595683f, 0.14148004f, 0.20232487f, 0.61289620f, 
    0.27134529f, 0.80993187f, 0.73592883f, 0.28391275f, 0.49975672f, -0.02233728f, -0.30713642f, -0.32540196f, 
    0.32408488f, 0.11823597f, 0.49952564f, -0.11261336f, 0.11491100f, 0.33415419f, -1.34730852f, -0.09001557f, 
    0.17073190f, -0.07209682f, -1.26549411f, 0.32243791f, 0.69868386f, -1.04167747f, 0.05249344f, 0.72246557f, 
    0.56003457f, -0.10118745f, -0.55277568f, -0.42411527f, 0.55251193f, 0.28700572f, 0.30039227f, 0.00704417f, 
    -0.05628960f, 0.10670672f, 0.02926236f, 0.16285692f, 0.21874879f, 0.46303016f, -0.02535015f, 0.99355954f, 
    1.36046231f, 0.64947373f, 1.19880509f, 1.00579166f, -0.16699819f, -0.26914230f, 0.75957286f, 0.22761351f, 
    0.34054217f, -0.07833636f, 0.45360944f, -0.01956839f, 0.71083677f, -0.32225087f, 0.52344221f, -0.39603177f, 
    -0.30095008f, 0.33135840f, -0.25108388f, 0.07182133f, -0.46680945f, -0.37974173f, 0.01164797f, -0.18752590f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.48256120f, 0.41954371f, 0.09484171f, 0.34544057f, 0.44396472f, 0.36005333f, 0.33750695f, 0.07718059f, 
    0.00383599f, 0.49452615f, 0.14028291f, 0.39064869f, 0.42950895f, -0.04210985f, -0.05774364f, 0.39484611f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.32786396f, -0.53090936f, -0.42942363f, 0.26494801f, -0.13173953f, 0.09303568f, 0.05818782f, 0.00782876f, 
    -0.01116824f, -0.09198103f, -0.03852862f, 0.12181216f, -0.77244526f, -0.05810383f, 0.12141053f, -0.21828535f, 
    0.03129020f, -0.24286002f, -0.01350004f, 0.00514188f, 0.04106550f, 0.03702881f, 0.00464136f, -0.21636270f, 
    0.44417357f, -0.03496946f, -0.12111493f, -0.26855731f, -0.08463877f, -0.17661168f, 0.14852317f, 0.02315929f, 
    0.02911708f, 0.00299597f, 0.07201780f, 0.06611512f, 0.26401144f, 0.08494900f, -0.38443404f, 0.32979631f, 
    -0.37124652f, 0.07161446f, -0.18452622f, 0.15184787f, -0.19584893f, 0.10709631f, -0.35186046f, -0.04847366f, 
    0.02471458f, 0.27206841f, 0.40011451f, -0.73493212f, 0.14052723f, 0.14389403f, -0.10690719f, -0.13617158f, 
    0.01746483f, -0.09251640f, -0.04703645f, 0.15543228f, 0.47263870f, 0.12848395f, 0.02572920f, -0.31959707f, 
    0.20961167f, 0.06463874f, 0.17770661f, -0.02324851f, 0.08517417f, -0.02969315f, 0.00039934f, 0.22307274f, 
    -0.64018631f, -0.17565371f, 0.14606433f, -0.65416276f, -0.28530410f, 0.08221835f, -0.04828198f, 0.05101952f, 
    -0.15264867f, -0.11299444f, -0.06780957f, 0.14564143f, 0.40544829f, 0.04121742f, 0.25764698f, 0.66089255f, 
    -0.12836872f, -0.04500613f, -0.00824692f, 0.08199976f, -0.35313311f, 0.03347286f, 0.06433721f, -0.09331705f, 
    -0.33888030f, -0.06952766f, -0.22433625f, -0.12350821f, -0.00109487f, 0.19294426f, 0.07176859f, -0.05943326f, 
    0.04611418f, 0.06401493f, 0.01884047f, -0.03896318f, -0.50277835f, 0.16523479f, 0.02681925f, 0.03753321f, 
    0.08454853f, 0.00920002f, 0.02237350f, 0.08310610f, 0.16923720f, -0.07970973f, 0.09558541f, -0.12384097f, 
    -0.32344007f, 0.42658713f, -0.11657049f, 0.09162029f, 0.01121470f, 0.06949702f, -0.04202297f, 0.01691455f, 
    -0.00703752f, -0.17523569f, -0.14666744f, 0.22070196f, 0.18858233f, -0.28842950f, -0.32966301f, 0.45904371f, 
    -0.06700635f, -0.26350603f, 0.20264345f, -0.07292600f, -0.21800387f, 0.04152898f, -0.16718976f, -0.00871781f, 
    0.39089024f, -0.27124012f, 0.11564933f, -0.15922777f, -0.38801703f, -0.14095192f, -0.08043416f, -0.06401996f, 
    -0.24641864f, 0.08146784f, -0.24054480f, -0.04883416f, -0.42786643f, -0.38674924f, 0.04899054f, -0.00909484f, 
    0.10613164f, 0.13288341f, 0.17425233f, -0.22972843f, 0.21409169f, 0.02017868f, 0.10065655f, 0.09070083f, 
    0.88920575f, -0.01288592f, 0.11073199f, 0.03771700f, -0.02599701f, 0.12239666f, 0.04553005f, -0.03231759f, 
    0.18936862f, 0.15587622f, 0.14553218f, 0.12819533f, 0.30147314f, -0.05845284f, 0.13677156f, 0.05858431f, 
    -0.25358802f, -0.05165267f, -0.10582227f, 0.17513661f, 0.08985388f, 0.16174260f, 0.07084299f, -0.26657808f, 
    -0.04829940f, 0.03798140f, 0.32669213f, 0.09273797f, -0.11218851f, -0.09127799f, -0.06889615f, 0.19617797f, 
    0.00218430f, 0.03413288f, -0.17826231f, 0.11860123f, -0.06739186f, 0.16272637f, -0.15542366f, -0.33715698f, 
    -0.00144198f, 0.10010240f, -0.00590685f, -0.10412269f, 0.12615824f, 0.00886776f, -0.02452812f, -0.08234905f, 
    0.05379121f, -0.14082691f, 0.06202992f, -0.07399146f, -0.11766194f, -0.02973426f, -0.10964540f, 0.01550060f, 
    0.05449842f, 0.24087614f, -0.09643927f, 0.10746834f, 0.17967741f, -0.12198415f, 0.31157273f, 0.36656857f, 
    -0.09391315f, -0.05563559f, -0.02930544f, 0.10294982f, 0.10949945f, 0.04066664f, 0.18614998f, 0.02048258f, 
    0.50695038f, -0.13824388f, -0.39415264f, -0.10075939f, 0.12495758f, 0.11720179f, 0.11612689f, 0.08616854f, 
    0.26895034f, 0.13600770f, -0.18285984f, -0.06083489f, 0.03877192f, -0.11708498f, 0.23331486f, -0.29029638f, 
    0.15301828f, -0.12557478f, -0.18392044f, 0.07273126f, 0.14384033f, -0.06440421f, 0.24587660f, -0.14935012f, 
    0.70857942f, -0.47252613f, 0.09079499f, -0.67189139f, -0.08170737f, -0.18594007f, 0.07872657f, 0.19167607f, 
    -0.24440117f, 0.20250180f, 0.07913654f, 0.02789802f, 0.53102070f, -0.17434880f, 0.21798299f, 0.24209872f, 
    -0.28196800f, 0.19438094f, 0.08988142f, 0.16678396f, 0.11411963f, 0.02667614f, -0.10021271f, -0.21511026f, 
    -0.18225612f, -0.08460546f, 0.17232986f, -0.16699615f, -0.04734593f, -0.32416156f, -0.20226148f, -0.11903181f, 
    0.01802986f, 0.06142795f, -0.32015014f, -0.13512558f, 0.46843967f, -0.11773406f, -0.38528764f, -0.11410598f, 
    0.19294566f, 0.20011461f, -0.19976614f, 0.05320294f, -0.33462343f, 0.02686424f, -0.13300624f, -0.20699564f, 
    0.08451480f, -0.26177537f, -0.25972143f, 0.23378240f, -0.04411976f, 0.03112935f, -0.37210533f, -0.08719866f, 
    -0.26194319f, -0.09647365f, 0.02347885f, 0.10408244f, -0.38328061f, -0.27611634f, -0.28905141f, 0.07947223f, 
    0.04856812f, -0.23934804f, -0.19978945f, 0.13695720f, 0.17502871f, -0.04810135f, 0.24461821f, -0.00312708f, 
    0.10702217f, 0.26033348f, 0.05975861f, -0.04544685f, 0.00193469f, -0.03487103f, 0.19300558f, -0.06629470f, 
    0.17585582f, -0.16239557f, 0.20149088f, -0.00099229f, -0.40486637f, 0.21972674f, 0.12970127f, -0.02866189f, 
    -0.30919552f, 0.00501609f, -0.02274544f, -0.10926712f, -0.08797798f, -0.07381189f, -0.07059515f, -0.22336376f, 
    -0.69916618f, -0.24180815f, -0.58518004f, 0.22751947f, -0.18474919f, -0.29471704f, -0.05420390f, -0.00331357f, 
    -0.05857243f, 0.09217966f, -0.21268302f, 0.06926258f, 0.50158864f, -0.06454407f, 0.19410187f, 0.29772413f, 
    0.13873929f, -0.10788874f, -0.05347382f, 0.03242811f, 0.13920648f, -0.16476969f, -0.28011742f, 0.11075927f, 
    -0.09272636f, -0.24839714f, 0.03339763f, 0.09127650f, -0.24695528f, 0.16369626f, -0.34433058f, -0.32602143f, 
    0.14344114f, -0.10018019f, -0.00643918f, -0.06765348f, 0.24800764f, -0.20873807f, -0.81792700f, -0.29661176f, 
    0.22460763f, 0.10417284f, 0.00234757f, -0.33038378f, -0.02133025f, -0.00666592f, -0.23594506f, -0.32615516f, 
    0.54529268f, -0.31242046f, -0.08396002f, -0.12956759f, 0.04893129f, 0.00739747f, 0.11552466f, 0.05573146f, 
    -0.17010914f, 0.06098616f, 0.15660471f, -0.03525157f, 0.14303735f, -0.00799593f, -0.06773273f, 0.22596262f, 
    0.09175266f, 0.05156545f, -0.16919646f, -0.00598849f, -0.11555770f, 0.04014924f, -0.02164094f, -0.04898172f, 
    0.34639114f, -0.22772591f, 0.40689331f, 0.17986403f, -0.10442418f, -0.26185831f, -0.19555187f, 0.20815639f, 
    0.09305444f, 0.06791189f, 0.12673196f, 0.04796059f, 0.49441633f, 0.31482306f, 0.20268667f, 0.47396943f, 
    -0.10384153f, -0.07954980f, 0.05382688f, 0.26410809f, -0.25579801f, 0.10123941f, -0.05354473f, -0.00262779f, 
    -0.03937239f, 0.08868733f, -0.27370271f, -0.33675277f, -0.11183222f, -0.16822091f, 0.21228676f, -0.08163527f, 
    -0.19901995f, 0.14518434f, 0.02928013f, -0.15801285f, -0.05097641f, -0.13029653f, -0.06000109f, -0.39520049f, 
    0.12940088f, 0.10181370f, -0.22432758f, 0.00799132f, 0.01160137f, 0.09437224f, 0.09626399f, -0.01510802f, 
    0.38576144f, 0.15275288f, -0.21669330f, 0.46934262f, -0.15816925f, -0.18808208f, -0.00309804f, 0.22651969f, 
    0.07200689f, 0.12634930f, 0.10298552f, -0.05804317f, 0.41946208f, -0.62131441f, -0.01818269f, -0.04014985f, 
    -0.37554047f, -0.00271173f, -0.20573938f, 0.08029693f, -0.03350021f, -0.06857030f, -0.27817443f, -0.13778618f, 
    0.90899438f, -0.20600346f, -0.39030895f, -0.22201395f, 0.04581278f, 0.21249609f, -0.06306856f, -0.25934404f, 
    -0.22344901f, 0.03539656f, 0.20439345f, -0.17691703f, 0.22064571f, -0.27716705f, -0.36853209f, 0.08767387f, 
    -0.12761863f, 0.25959018f, -0.06415761f, -0.06521178f, -0.14130083f, -0.05851900f, -0.06379885f, -0.15111208f, 
    -0.76525855f, 0.28580135f, -0.07564164f, -0.21739291f, -0.07237069f, -0.01233620f, 0.06789824f, 0.06523311f, 
    0.08740015f, 0.12523110f, -0.20560119f, -0.05738110f, 0.52158380f, 0.23674917f, -0.09945277f, -0.02581684f, 
    -0.15090443f, -0.06868028f, 0.01154450f, -0.24042735f, 0.09600469f, 0.09864110f, -0.02847007f, -0.09760190f, 
    0.64580452f, -0.40717164f, 0.46158984f, -0.44097546f, 0.19321613f, -0.04497341f, 0.01287176f, 0.17783992f, 
    -0.10932484f, -0.02198172f, -0.00015040f, -0.00620190f, -0.02878611f, -0.00797115f, -0.33576694f, 0.13635097f, 
    0.05342714f, 0.08854391f, 0.11728506f, -0.05520795f, 0.00007710f, 0.06324291f, 0.00390096f, -0.24420154f, 
    0.35761154f, 0.14075594f, 0.09194637f, -0.02459488f, -0.36376947f, -0.04033019f, -0.05009597f, -0.06810980f, 
    0.09561696f, -0.01714011f, 0.15514457f, -0.01863527f, 0.75581235f, 0.43709999f, 0.36753914f, 0.19672619f, 
    0.29593426f, 0.09779325f, -0.04681486f, 0.09550186f, -0.14451744f, 0.03057073f, -0.02001331f, -0.16865765f, 
    0.02188376f, 0.10992894f, -0.06334857f, 0.18084736f, -0.12402346f, 0.22262610f, -0.05738253f, 0.02736405f, 
    -0.14839612f, 0.03958233f, 0.01715562f, -0.04134110f, -0.56627959f, -0.22538675f, 0.03958108f, 0.15477568f, 
    -0.04972858f, 0.14709145f, 0.04248827f, -0.19393659f, 0.12006179f, -0.29582131f, -0.11435961f, 0.25387231f, 
    -0.31029612f, 0.00559763f, -0.17557843f, 0.23128185f, -0.29251048f, -0.29096985f, 0.08120452f, 0.07185010f, 
    0.01594456f, -0.01629040f, 0.07472008f, 0.03491189f, -0.80912268f, 0.07493126f, -0.28172207f, -0.28495887f, 
    -0.06989140f, 0.11380106f, -0.16931583f, -0.20375386f, -0.04228627f, -0.08445266f, 0.07650896f, 0.01814880f, 
    0.18552932f, -0.32213476f, 0.20189981f, 0.06781325f, -0.08095042f, 0.04555493f, 0.02279137f, 0.29004559f, 
    -0.01149686f, 0.11464403f, 0.04917750f, 0.15970525f, -0.03601519f, -0.78225845f, -0.31887504f, -0.16149513f, 
    0.01990188f, -0.01204969f, -0.11039600f, -0.39090189f, 0.18968010f, 0.20968539f, 0.22414935f, 0.01833221f, 
    -0.08044638f, 0.00158714f, 0.26166740f, -0.03491096f, -0.28782541f, -0.06675360f, 0.14688568f, 0.03127904f, 
    -0.27091259f, 0.07733847f, 0.05262479f, -0.09759147f, 0.66506064f, 0.21718597f, -0.24757211f, 0.09314491f, 
    0.00271923f, 0.03882049f, 0.02448171f, -0.02876417f, -0.17114925f, -0.00238951f, 0.16429357f, -0.11020194f, 
    -0.36441901f, 0.26751798f, 0.06966306f, -0.15954052f, 0.16046758f, 0.10988992f, 0.41445076f, 0.04324823f, 
    -0.00547138f, 0.21134242f, -0.03065914f, -0.05347700f, -0.29036921f, 0.29371536f, 0.23702697f, 0.22756235f, 
    0.02329659f, 0.07302941f, -0.05338351f, 0.00559753f, -0.02615811f, 0.19251771f, -0.18146652f, -0.18576603f, 
    -0.21075006f, -0.90915829f, -0.63556939f, 0.28155312f, -0.10539934f, 0.11811597f, 0.11842283f, 0.15707706f, 
    -0.13678090f, -0.01920787f, -0.17014505f, -0.11315001f, -0.58991367f, 0.06446353f, 0.15350921f, -0.23941028f, 
    0.02935178f, -0.24559329f, 0.01240871f, -0.04353867f, 0.22234717f, 0.21507680f, -0.00573978f, -0.01381385f, 
    -0.10370982f, 0.28277984f, -0.03790369f, -0.34822711f, -0.01347778f, 0.01735792f, -0.18717839f, 0.09150804f, 
    0.11054458f, -0.25023398f, -0.01426868f, 0.07792317f, -0.22391216f, -0.67265081f, -0.35681468f, 0.15734041f, 
    -0.28320774f, -0.12255254f, 0.31469274f, -0.25736210f, 0.09970445f, -0.16238979f, 0.10704716f, 0.05331863f, 
    0.46868151f, 0.06751002f, -0.23627077f, -0.05683992f, 0.26475474f, 0.07222190f, -0.05986497f, 0.17853719f, 
    0.06879035f, -0.04797754f, 0.11194258f, -0.18331528f, 0.00390217f, 0.34259474f, 0.18284746f, -0.08239751f, 
    -0.16924024f, 0.04034459f, -0.05956130f, -0.04227277f, 0.17744413f, 0.04634514f, -0.06037036f, 0.11529974f, 
    -0.46565878f, -0.48618987f, -0.11700325f, 0.11258736f, 0.14349297f, 0.07897298f, 0.10309711f, -0.11902747f, 
    -0.22629783f, -0.02646003f, -0.00501594f, -0.08537208f, 0.08834115f, 0.09672744f, -0.07692210f, 0.01940709f, 
    -0.03511281f, 0.03341220f, 0.14322747f, 0.09256086f, -0.02299346f, -0.05006518f, 0.01734583f, -0.00407550f, 
    -1.19570982f, 0.10512955f, 0.40395948f, 0.19630101f, -0.14260387f, -0.32710451f, 0.20465545f, 0.08190206f, 
    -0.21518843f, -0.03467812f, 0.17797598f, -0.03638665f, -0.57129151f, -0.16819508f, 0.20766331f, 0.31857508f, 
    0.12529922f, -0.04172634f, 0.10902307f, 0.12422697f, 0.00126916f, 0.09794310f, -0.03035170f, 0.26064447f, 
    0.28810155f, -0.17153667f, 0.10858405f, 0.14224721f, -0.13613974f, -0.14345437f, 0.16382180f, -0.08221366f, 
    -0.01448662f, -0.11363123f, 0.00442667f, -0.08678392f, 0.43733239f, 0.28648013f, -0.00136348f, 0.03881859f, 
    0.13023323f, -0.00619603f, 0.02153401f, 0.08919634f, -0.19374649f, 0.01308326f, -0.02297651f, 0.13528922f, 
    0.06691377f, -0.25067315f, 0.09391654f, 0.31757721f, -0.05061916f, -0.06479526f, 0.09284337f, 0.02610193f, 
    -0.11796242f, -0.08769739f, 0.23635499f, 0.24342905f, -0.66537166f, 0.20866956f, -0.26650560f, -0.26598173f, 
    0.05881593f, -0.05897893f, -0.12504493f, -0.01688368f, 0.14705011f, -0.23128898f, 0.11587916f, 0.08002079f, 
    -0.46593454f, 0.10365197f, -0.32844755f, 0.06768446f, 0.11415587f, -0.01497979f, 0.30602884f, 0.03463408f, 
    0.10532273f, 0.23209947f, -0.22757335f, 0.11193958f, -0.46569818f, -0.33512974f, 0.07663435f, 0.29347134f, 
    0.01404996f, 0.23141688f, -0.09905749f, -0.25481057f, -0.04576561f, 0.00624745f, -0.20919755f, -0.18552835f, 
    -0.25914210f, -0.27306968f, 0.32072261f, 0.03785086f, 0.05490245f, 0.14929050f, -0.12664433f, -0.14644302f, 
    0.20470139f, 0.20622884f, 0.04075252f, 0.09044032f, 0.17500639f, 0.38579106f, -0.52352893f, -0.18359153f, 
    0.22928616f, -0.37494054f, -0.17740065f, 0.15356502f, -0.17964712f, 0.04723588f, 0.16697276f, 0.08592362f, 
    0.04006189f, -0.27179804f, -0.02746224f, -0.05372945f, -0.11434692f, 0.05797262f, -0.15062431f, 0.02148665f, 
    0.02876647f, -0.18236290f, 0.00572856f, 0.05294749f, -0.03841066f, -0.23907536f, -0.09062150f, 0.28385949f, 
    -0.29115972f, -0.12449322f, 0.01497207f, 0.08781665f, -0.11430714f, 0.15472370f, -0.03905875f, -0.28261876f, 
    -0.34453073f, -0.41841793f, -0.39072984f, 0.20601058f, 0.15855132f, -0.05375111f, 0.09652280f, 0.29253983f, 
    0.06695762f, 0.34576821f, -0.21846429f, 0.26271766f, -0.07938276f, -0.10864029f, 0.29918095f, 0.49305108f, 
    -0.12155946f, 0.01030853f, 0.20935480f, 0.02061391f, -0.03208862f, -0.04435517f, 0.18071187f, 0.29191837f, 
    0.59514987f, 0.27267006f, -0.15043519f, -0.18373565f, 0.17326257f, 0.01627359f, -0.35805577f, -0.14757174f, 
    -0.09429503f, -0.22303043f, 0.03358797f, -0.16374700f, -0.24684256f, 0.05081108f, 0.35300276f, -0.27778712f, 
    0.10182595f, -0.00987228f, 0.03280035f, -0.07013538f, 0.16620183f, 0.02205240f, -0.03537466f, 0.40219903f, 
    -0.48790407f, -0.04584472f, -0.40390512f, -0.18122961f, 0.16480356f, 0.22755626f, -0.32420227f, -0.11790247f, 
    0.08002332f, -0.05254728f, -0.16402210f, 0.10254095f, 0.23208039f, -0.08754993f, -0.28595862f, -0.17729206f, 
    -0.08692842f, -0.09572506f, -0.07969689f, -0.33786675f, -0.09093489f, 0.10208026f, -0.04296885f, -0.08126328f, 
    -0.09249744f, -0.30632499f, -0.08432610f, 0.00338331f, -0.02252003f, -0.11080561f, 0.06304810f, -0.00138461f, 
    -0.09888809f, -0.02748497f, -0.00600463f, 0.00682300f, -0.28008774f, 0.01710928f, 0.11014288f, -0.32969666f, 
    0.00749372f, -0.24028271f, -0.10732170f, 0.13721481f, 0.33043981f, -0.01223195f, -0.32029650f, -0.40863663f, 
    0.20708355f, -0.01120126f, -0.36895007f, -0.05619876f, 0.13933773f, 0.06079885f, 0.27855375f, -0.00880649f, 
    0.09002942f, 0.01575293f, -0.26430172f, -0.10675165f, -0.85439348f, -0.22009110f, -0.04171890f, -0.33731982f, 
    -0.04751689f, 0.19470285f, 0.15435840f, 0.07164041f, -0.11005197f, 0.00554193f, -0.03934736f, 0.20124830f, 
    -0.53756654f, 0.21502413f, 0.22640091f, -0.13849679f, 0.01400483f, 0.06748346f, -0.17012468f, 0.11865100f, 
    0.08820546f, -0.21116421f, -0.01959907f, -0.26076770f, 0.20013186f, 0.04503319f, 0.00788666f, 0.07403540f, 
    -0.01502493f, -0.12088367f, 0.05535022f, 0.21211138f, -0.05680742f, -0.15148307f, 0.26807866f, 0.31067812f, 
    0.20995931f, -0.02799589f, 0.06954312f, 0.38609403f, -0.02197713f, -0.08718155f, -0.10685521f, 0.03605421f, 
    0.09728161f, -0.21962115f, 0.05459720f, -0.11718002f, -0.21922524f, 0.09929590f, 0.27352536f, 0.21869038f, 
    -0.05773852f, 0.31443623f, 0.17289259f, 0.10133430f, 0.06317832f, 0.04079841f, -0.07084164f, 0.23576580f, 
    -0.70600528f, -0.01230711f, -0.07676271f, 0.19056775f, 0.35706758f, -0.00693569f, 0.06287467f, 0.04820483f, 
    -0.02769995f, -0.01353575f, -0.03246576f, -0.08038721f, 0.05176755f, 0.25235221f, 0.26994199f, -0.19664480f, 
    -0.04935985f, 0.22832580f, 0.12314609f, -0.17116576f, -0.14640404f, -0.19273034f, -0.05805875f, 0.31757468f, 
    -0.65092254f, 0.11278781f, -0.19541842f, -0.50940102f, -0.04797984f, -0.19555886f, -0.08462613f, -0.29944170f, 
    -0.29988369f, -0.09680179f, 0.10090942f, -0.24690649f, 0.03128242f, -0.33856463f, 0.02532305f, -0.18879449f, 
    -0.16093108f, -0.12469746f, -0.12676342f, 0.04713757f, -0.19950585f, 0.11068635f, -0.02440597f, 0.12406677f, 
    -0.32196862f, 0.44933254f, -0.06730063f, 0.73588270f, 0.03558403f, 0.15231934f, 0.15928245f, 0.15463522f, 
    0.20254087f, 0.04949586f, 0.00013875f, -0.03750672f, 0.16189709f, -0.00242138f, -0.03090329f, -0.58758378f, 
    -0.17081089f, 0.04465414f, -0.06827717f, 0.12953967f, 0.02926390f, -0.07395811f, 0.02583782f, -0.37745211f, 
    0.30081880f, -0.39460966f, -0.32405025f, -0.13570419f, -0.00214145f, 0.08979557f, 0.11278321f, 0.03652913f, 
    0.08204235f, 0.07287547f, 0.03480470f, 0.15098952f, -0.42190334f, -0.18995602f, -0.19625396f, 0.25931430f, 
    -0.12438319f, 0.10725754f, 0.06467706f, -0.10062550f, -0.03113672f, -0.00365563f, 0.05765491f, 0.25413963f, 
    -0.13739486f, -0.42931792f, -0.22155322f, 0.50778770f, 0.21194263f, 0.24634472f, 0.02498044f, -0.01989674f, 
    0.07692889f, -0.22342306f, 0.07157817f, -0.04744960f, 0.01247213f, 0.06730078f, 0.23434107f, -0.45631754f, 
    -0.26658484f, -0.00446927f, -0.01978435f, 0.03928352f, -0.15742661f, 0.03666720f, 0.12437970f, 0.42915645f, 
    -0.26734251f, -0.35369387f, -0.21709545f, -0.39765382f, 0.00232925f, -0.02748309f, -0.04791029f, -0.17954051f, 
    0.11543587f, -0.07059759f, 0.37181628f, 0.12306219f, -0.02856310f, -0.29955283f, 0.32684487f, -0.09298880f, 
    -0.04815801f, -0.02459396f, 0.11119596f, -0.05432256f, 0.17010841f, 0.05869075f, 0.08092035f, 0.02422020f, 
    0.60813695f, -0.37395552f, 0.31465894f, 0.15156692f, 0.10558178f, 0.23767684f, 0.13520819f, -0.02947690f, 
    0.20386736f, -0.05017956f, 0.27067566f, 0.00343359f, 0.48860809f, 0.25218561f, -0.02495629f, -0.27481201f, 
    0.12668443f, 0.09034895f, -0.06614173f, -0.18553632f, -0.04944668f, 0.02082252f, -0.30358365f, -0.19634378f, 
    -0.44780722f, 0.37357169f, 0.03820988f, 0.14061390f, -0.18056138f, 0.00008704f, 0.08186082f, 0.12770005f, 
    -0.08183944f, -0.03788124f, -0.18651521f, 0.06054385f, -0.01979861f, -0.68523711f, -0.04122427f, 0.38928536f, 
    -0.21449891f, -0.17087767f, 0.03250527f, 0.11986142f, 0.02215582f, -0.11691023f, -0.11026981f, -0.34069169f, 
    0.40577278f, 0.15382968f, -0.00253833f, -0.03843135f, -0.24287800f, 0.02142285f, 0.17663059f, -0.06857871f, 
    -0.13629182f, 0.05703963f, 0.19807379f, -0.37514549f, -0.12453651f, 0.42984024f, 0.25300077f, -0.45602700f, 
    -0.08918181f, -0.07792497f, -0.01351739f, 0.12945600f, 0.02813852f, 0.13497928f, 0.18168418f, -0.05060377f, 
    0.08269936f, 0.29809326f, 0.09322832f, 0.39420074f, 0.30261037f, 0.10539989f, 0.03882539f, -0.04125679f, 
    -0.19092177f, 0.00224627f, -0.13676137f, -0.27101114f, 0.11174426f, -0.29631349f, 0.19262511f, 0.47966295f, 
    0.09272725f, -0.25467342f, -0.11802272f, -0.11228444f, -0.06422362f, 0.00198717f, -0.17318469f, -0.28337118f, 
    -0.38780233f, 0.09066031f, -0.00610860f, -0.03074821f, -0.17886989f, -0.03162600f, -0.01345632f, 0.11640756f, 
    0.14580896f, -0.03562837f, -0.14228974f, 0.02641971f, -0.47365075f, 0.22145577f, -0.14693904f, -0.13500649f, 
    -0.07062390f, 0.04597523f, -0.06374031f, -0.12289666f, -0.34725973f, -0.07072531f, 0.06949537f, -0.17707567f, 
    0.15062271f, 0.37318030f, 0.35958904f, 0.09270307f, 0.23872766f, 0.21770483f, 0.07850171f, 0.06760527f, 
    -0.00675792f, 0.08812740f, 0.06033328f, -0.14474721f, -0.21658641f, 0.19075869f, -0.02288947f, 0.00411079f, 
    0.03037684f, 0.03380811f, 0.03786363f, -0.12680157f, 0.23870987f, 0.16737297f, -0.03205853f, -0.06695430f, 
    -0.18114994f, 0.21538125f, -0.49145043f, 0.25983042f, -0.05590060f, 0.01045409f, -0.16388310f, -0.01771124f, 
    -0.14641266f, 0.04642410f, 0.03428418f, -0.15783094f, -0.46327233f, 0.09843704f, -0.44614163f, -0.17745090f, 
    -0.09065340f, -0.12029729f, -0.08045201f, -0.27915695f, -0.15902255f, -0.10489086f, -0.15575309f, -0.06365249f, 
    0.38576713f, -0.00285855f, 0.28018695f, 0.16791679f, 0.33421877f, 0.18351671f, 0.06130675f, 0.02427773f, 
    -0.10982449f, -0.07774339f, -0.14909823f, -0.17150007f, -0.62581611f, 0.14869297f, 0.27840143f, -0.22246508f, 
    -0.06481007f, 0.05048513f, 0.08528276f, -0.15626624f, -0.01704345f, -0.05004468f, -0.11500934f, -0.23033142f, 
    0.48818138f, -0.41394138f, 0.24397558f, -0.47247136f, 0.00564737f, 0.10231617f, -0.01717423f, -0.16620678f, 
    0.03618430f, -0.00922384f, -0.07644523f, -0.18598028f, 0.40948677f, 0.00436292f, -0.14575602f, -0.09364294f, 
    -0.17529213f, -0.00131357f, -0.11841903f, -0.14372829f, -0.10713427f, -0.15714443f, -0.07081070f, -0.07038695f, 
    -0.37760660f, -0.19901462f, -0.43207881f, -0.51457697f, -0.01769666f, -0.10574549f, -0.05852915f, -0.09851518f, 
    -0.37274477f, 0.18572335f, 0.02874468f, -0.06265177f, 0.33417559f, 0.10139125f, 0.15716423f, 0.03585122f, 
    -0.13206331f, 0.15466559f, -0.07044375f, -0.11397577f, -0.05088686f, -0.08115877f, -0.01100772f, -0.01680673f, 
    0.27728924f, 0.61504370f, 0.30709907f, 0.50147015f, 0.30073264f, 0.08985036f, 0.16575001f, 0.25938746f, 
    0.04131449f, -0.07259998f, 0.23720711f, 0.15995082f, -0.46976048f, 0.15411974f, -0.35093486f, -0.28205094f, 
    -0.02804353f, 0.15763864f, 0.05361290f, -0.05905889f, -0.17045937f, -0.09135821f, 0.00117564f, -0.14927390f, 
    -0.39717278f, -0.03915235f, 0.62905562f, -0.28730327f, 0.16155021f, -0.13903140f, 0.04172792f, 0.22279872f, 
    0.01075307f, 0.04497397f, -0.11480803f, 0.28350583f, -0.24465971f, -0.32358778f, -0.50605392f, -0.28415015f, 
    0.23924434f, -0.11365200f, -0.24337740f, -0.08833742f, 0.05043600f, 0.01152270f, -0.07416640f, 0.17637631f, 
    0.28751040f, 0.42840010f, -0.37716624f, -0.08061504f, 0.14444126f, -0.08463568f, -0.52172095f, -0.00628472f, 
    -0.24055192f, 0.00353879f, -0.20104222f, 0.00233193f, 0.21009573f, 0.01313546f, 0.16164628f, 0.42290130f, 
    0.08152577f, 0.00893545f, 0.01270384f, -0.08592948f, 0.03267442f, 0.09309710f, 0.17823146f, 0.03570298f, 
    -0.32776040f, -0.08026978f, 0.15937252f, 0.12496295f, -0.35599971f, -0.19619550f, -0.17179136f, -0.41782963f, 
    -0.05986518f, 0.00731155f, -0.11207553f, 0.07061110f, 0.26514310f, 0.31161985f, -0.10690770f, 0.29055601f, 
    -0.21130273f, 0.07996884f, 0.05897354f, 0.00968348f, -0.22525021f, 0.07095877f, -0.21733406f, -0.10983744f, 
    -0.00728864f, 0.53348756f, -0.59129149f, -0.34667471f, 0.04070273f, -0.09302088f, -0.57019544f, -0.02302022f, 
    0.30944788f, 0.00358214f, -0.13398835f, -0.08170528f, 0.23015396f, -0.01579804f, 0.09680428f, 0.33111653f, 
    0.10960159f, -0.13350616f, -0.01423822f, 0.04282830f, -0.02668755f, -0.03127277f, -0.29822925f, -0.21158677f, 
    -0.32427710f, -0.04334312f, -0.01236376f, 0.01415979f, 0.27071947f, 0.00378702f, 0.03377393f, 0.01701974f, 
    -0.11148955f, 0.07387235f, -0.34918818f, 0.11766814f, -0.11405892f, -0.18630487f, 0.51890635f, 0.19962507f, 
    -0.00352807f, 0.08310727f, -0.09535221f, -0.09547444f, -0.08892344f, 0.09388188f, -0.03548984f, 0.04456620f, 
    -0.17388901f, -0.51420987f, 0.14529870f, -0.29570541f, -0.15621822f, -0.29359287f, -0.03003664f, -0.22656678f, 
    0.14970134f, -0.16738984f, 0.00330621f, -0.06869339f, 0.08680281f, -0.49710357f, 0.04649050f, -0.29285836f, 
    0.01762680f, -0.16963179f, 0.08023306f, -0.15796004f, 0.12154026f, 0.01208519f, 0.21093629f, 0.20665410f, 
    0.07646771f, 0.18485488f, -0.09657378f, -0.03244170f, 0.05323906f, -0.00885137f, -0.10966193f, -0.12944235f, 
    0.29217941f, -0.02481000f, 0.21812283f, -0.07151038f, 0.39499882f, 0.03402689f, 0.00514103f, 0.03225706f, 
    -0.03369475f, 0.07213017f, -0.10482321f, -0.27533975f, 0.03811657f, 0.19092056f, 0.14302817f, -0.02735393f, 
    0.08045319f, -0.33581251f, 0.03328982f, -0.14254753f, 0.10973829f, -0.23641454f, 0.24481346f, -0.09965040f, 
    0.12397359f, -0.00241299f, -0.46155873f, 0.26378125f, -0.11809812f, -0.17372322f, -0.01903061f, 0.32227853f, 
    0.31644580f, -0.01676735f, -0.19131081f, -0.09183216f, -0.20621006f, 0.08822578f, 0.14594048f, -0.12424516f, 
    0.15336001f, -0.23843767f, -0.17024124f, 0.24006523f, 0.06208435f, -0.12633194f, 0.15826382f, -0.01650667f, 
    0.07950056f, -0.08623097f, 0.11086141f, -0.16457854f, -0.11296807f, -0.46541527f, -0.40781519f, -0.43360716f, 
    0.01001942f, -0.00716876f, -0.06491306f, 0.09338633f, -0.19753110f, -0.14721957f, 0.33592537f, -0.11329049f, 
    -0.42479363f, 0.22874326f, 0.65301234f, -0.19417985f, -0.06697327f, 0.02346035f, 0.13779843f, -0.07239280f, 
    0.28075290f, 0.06406123f, 0.23937139f, 0.24844186f, -0.54727918f, 0.72169179f, -0.49068397f, -0.50805748f, 
    0.10469180f, -0.21976268f, 0.13607402f, -0.01589543f, -0.09791166f, -0.18894517f, -0.21085103f, -0.19277163f, 
    0.10962006f, -0.49499455f, -0.24023044f, -0.16476277f, 0.07395229f, -0.02812954f, -0.04253416f, -0.00304417f, 
    -0.21464436f, -0.12229604f, 0.01679866f, -0.28706187f, -0.08945647f, 0.08457886f, 0.18366905f, -0.16044563f, 
    0.10551991f, 0.04380220f, -0.13252480f, 0.22836281f, 0.17365150f, 0.10750078f, -0.09282859f, 0.18563502f, 
    -0.54924494f, 0.73768640f, 0.46596351f, 0.19280510f, 0.14162004f, 0.15831812f, -0.11312967f, -0.04697746f, 
    -0.04077175f, -0.02689031f, -0.11632158f, 0.01299930f, -1.16253579f, 0.58789539f, 0.00643513f, -0.54229319f, 
    0.16483136f, 0.12331403f, -0.07327636f, -0.21176632f, -0.04122509f, -0.06810354f, 0.14818932f, 0.18926561f, 
    0.32839125f, -0.13785429f, -0.28366190f, 0.21836592f, 0.03219376f, 0.02890807f, -0.17778365f, 0.21761137f, 
    -0.34006158f, -0.08626307f, 0.11256906f, -0.05263255f, -0.41732356f, 0.28620258f, -0.25442722f, 0.47453237f, 
    0.05365500f, -0.08797928f, -0.05657462f, -0.12049267f, 0.02479849f, 0.21684369f, -0.05376085f, 0.12984847f, 
    -0.01347943f, -0.24284872f, -0.34452286f, 0.52586263f, -0.08936050f, -0.11364473f, 0.14668055f, 0.08797239f, 
    0.09959333f, 0.07233854f, 0.10127297f, 0.04296292f, -0.45276240f, 0.25184417f, 0.44615573f, -0.20595571f, 
    -0.07642316f, -0.00625285f, 0.04692668f, -0.08997193f, 0.13600595f, 0.05966952f, -0.12932758f, -0.13896351f, 
    0.78607285f, 0.13136728f, 0.16992466f, -0.54672730f, -0.06722283f, 0.22244927f, 0.13332304f, -0.13700114f, 
    -0.30468833f, -0.02897745f, 0.01914875f, -0.03082801f, 0.39438513f, -0.07813977f, -0.21081598f, -0.28623453f, 
    0.12940684f, -0.12690513f, -0.02498771f, -0.21210977f, 0.00141687f, -0.15050660f, -0.01688263f, 0.21213715f, 
    -0.42033440f, 0.01784711f, -0.14059326f, -0.17765725f, 0.12856026f, 0.05103422f, 0.06577096f, -0.09346611f, 
    0.18715648f, -0.02139247f, 0.07016554f, -0.05856270f, -0.27175891f, 0.03345977f, 0.09583701f, -0.02879745f, 
    0.10526000f, -0.02969984f, 0.15097593f, -0.04472968f, 0.16053821f, 0.02783450f, 0.09542484f, 0.23626746f, 
    0.28411105f, 0.17897791f, 0.07406574f, -0.17223743f, 0.08022090f, 0.03456216f, 0.23103406f, 0.03897623f, 
    0.03427643f, 0.24654673f, 0.28987744f, 0.08606881f, 0.04605816f, 0.12192422f, -0.20337380f, -0.39981261f, 
    0.08476771f, 0.08640999f, 0.11930221f, 0.09131033f, 0.09721361f, -0.01867595f, -0.00224978f, 0.06877077f, 
    -0.89601755f, -0.34184095f, -0.18646878f, -0.10105413f, 0.03147937f, 0.02091330f, -0.02699991f, -0.17146620f, 
    0.28805292f, -0.07865413f, -0.03433974f, 0.00559637f, -0.58167893f, -0.39376676f, -0.36829627f, -0.55330342f, 
    -0.04197776f, -0.28120086f, 0.02980475f, 0.19785805f, 0.14253664f, 0.31984544f, 0.30432668f, 0.12941957f, 
    0.50549650f, 0.09148964f, -0.01408616f, -0.00477342f, -0.20798445f, -0.00533437f, 0.00397753f, 0.08282907f, 
    0.07078485f, 0.07441195f, -0.07039537f, -0.11137508f, 0.31841353f, 0.03911602f, -0.05391400f, -0.07799078f, 
    -0.35674059f, 0.04910093f, 0.08068101f, -0.04763662f, 0.03972551f, -0.08606444f, -0.02201749f, -0.17551619f, 
    -0.75103819f, -0.38114122f, 0.28590173f, -0.09254650f, 0.16188405f, 0.10486513f, -0.18050763f, 0.07957450f, 
    0.18595265f, -0.14577381f, 0.04113739f, 0.09015332f, -0.39121556f, -0.51480383f, -0.32156163f, -0.18872645f, 
    0.00473767f, -0.10383141f, 0.08335385f, -0.05966911f, -0.09578513f, 0.07104130f, -0.20948865f, -0.09510864f, 
    0.13615631f, -0.04915459f, 0.26542667f, -0.37964171f, -0.09378883f, 0.28661773f, 0.03796036f, -0.28254876f, 
    -0.00655839f, -0.29062334f, -0.24463542f, -0.23027135f, 0.51513976f, 0.07571359f, 0.03280739f, 0.37296015f, 
    0.03992147f, -0.31894523f, 0.04585789f, 0.11322146f, 0.08205458f, -0.08866125f, -0.15007351f, 0.02148138f, 
    -0.07441062f, 0.00514346f, 0.17659213f, 0.24184671f, -0.16525485f, 0.02024894f, -0.41180128f, 0.21226852f, 
    -0.23663737f, -0.05831750f, -0.19868252f, 0.01124677f, 0.51890582f, 0.19325595f, 0.26036093f, -0.04843820f, 
    0.17697760f, 0.15062274f, 0.11236670f, 0.05693417f, 0.00026950f, 0.21170813f, 0.26369661f, 0.15500720f, 
    -1.60370302f, -0.32534602f, 0.26563758f, 0.13047941f, 0.29189232f, -0.05713109f, 0.21651520f, -0.05873455f, 
    0.02291334f, 0.11445162f, 0.00886208f, 0.26453987f, -0.35613856f, 0.30363443f, -0.05217327f, -0.13733841f, 
    0.04244783f, 0.13308530f, 0.09256170f, 0.13170668f, 0.02528937f, -0.06158053f, 0.23221074f, 0.04643996f, 
    -0.13603014f, 0.06638660f, -0.19676580f, 0.39156830f, -0.00939672f, -0.09121042f, 0.06247403f, -0.10519681f, 
    -0.01441504f, 0.20203832f, -0.13019948f, 0.43843827f, -1.32063115f, -0.34757864f, -0.48582718f, -0.48550004f, 
    0.28768769f, -0.03370712f, -0.34870142f, -0.13764875f, -0.08939439f, -0.00476391f, -0.04523971f, 0.01775972f, 
    -0.18643373f, 0.12641355f, -0.15037836f, -0.41230300f, 0.07785062f, 0.11735259f, -0.23257107f, -0.28724942f, 
    -0.02876645f, -0.02363123f, 0.01445292f, -0.11811412f, -0.10140759f, -0.23193341f, 0.05271019f, 0.86151081f, 
    -0.27926597f, 0.11794384f, 0.20828195f, 0.00129568f, 0.22649433f, -0.12690660f, 0.02295431f, -0.06116736f, 
    -0.47998399f, -0.67234164f, 0.00482583f, 0.06032111f, -0.02219523f, -0.02859422f, -0.01703994f, -0.02804255f, 
    -0.10637368f, 0.14944547f, -0.04711672f, 0.17992190f, 0.12531509f, -0.59479666f, 0.12101350f, -0.10616711f, 
    0.17487787f, 0.04925193f, 0.04823723f, -0.03248133f, -0.13170935f, 0.01071772f, -0.07668278f, -0.14001413f, 
    0.25066048f, 0.20776276f, 0.03402703f, 0.18913521f, 0.04351410f, -0.04827559f, 0.03617316f, -0.19174120f, 
    -0.17611343f, -0.11014447f, 0.14437707f, -0.15566173f, -0.22582473f, -0.37918279f, -0.08001195f, -0.03730845f, 
    0.14537531f, -0.00854998f, 0.16544911f, 0.09873875f, -0.23703504f, -0.15816747f, -0.10897291f, -0.17752966f, 
    0.12574469f, 0.58735865f, -0.42375311f, 0.07582685f, 0.16605255f, 0.24266720f, -0.03985242f, -0.29779774f, 
    0.16734029f, 0.01057374f, -0.00791515f, 0.08494599f, -0.01070601f, -0.09433748f, -0.43571767f, -0.28105369f, 
    0.26787490f, 0.10878661f, 0.20037748f, 0.04020628f, 0.17087810f, 0.01443779f, 0.07837926f, 0.08902516f, 
    -0.35287765f, 0.68529713f, 0.08616488f, -0.27548030f, -0.17524959f, -0.12478942f, -0.27339622f, -0.13023034f, 
    0.18754736f, 0.20361190f, 0.00834898f, 0.10629516f, 0.33217931f, -0.18900076f, 0.15434715f, 0.20488569f, 
    0.06752435f, -0.18789543f, 0.24371284f, 0.03712295f, 0.08495976f, -0.06132974f, 0.02153752f, 0.24526991f, 
    -0.60192454f, 0.21739508f, -0.04309132f, -0.56361800f, -0.04452810f, -0.26551753f, -0.00927183f, -0.25083774f, 
    -0.13159211f, 0.31651139f, 0.09814776f, 0.02192969f, -0.16270614f, 0.39163873f, -0.27500567f, -0.40570235f, 
    0.20305003f, 0.05615038f, -0.00090778f, 0.16646156f, -0.00778842f, -0.12751758f, 0.02164858f, -0.07309614f, 
    0.67767000f, 0.25038019f, -0.23007877f, -0.32779977f, 0.16284724f, -0.24663995f, -0.08099036f, 0.14543748f, 
    -0.02465619f, 0.00800563f, 0.14581190f, 0.15826310f, -0.54799891f, -0.44426331f, 0.17446689f, -0.04303630f, 
    0.14381540f, 0.06009024f, -0.14387034f, 0.32942215f, -0.16436139f, 0.00179791f, 0.23343121f, 0.00623179f, 
    0.27693710f, -0.14741255f, 0.06410985f, 0.05660515f, -0.28028858f, 0.22065698f, -0.07528708f, 0.02817212f, 
    -0.21939781f, 0.20490128f, 0.01370549f, -0.22051467f, 0.07703638f, 0.09087829f, -0.22385135f, -0.26840594f, 
    0.02848856f, 0.00635124f, -0.10804323f, 0.14296323f, 0.19623703f, 0.03808473f, -0.13485061f, 0.04371266f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.16995288f, 0.07378565f, -0.11785697f, -0.01510934f, -0.01975572f, -0.00649291f, -0.08195801f, -0.16553864f, 
    -0.02815619f, 0.00795848f, 0.26436195f, 0.01356881f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
