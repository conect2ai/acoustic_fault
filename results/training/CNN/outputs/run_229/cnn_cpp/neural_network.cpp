#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.60171366f, -0.44414887f, -0.69756413f, 0.38766930f, -0.28384706f, 0.47732455f, -0.20230617f, -0.29747865f, 
    -0.27518845f, -0.80153692f, 0.57584780f, -0.11653104f, 0.11591307f, 0.40805992f, -0.69931692f, -0.18507087f, 
    0.05989354f, -0.26317438f, -0.90692538f, 0.72305906f, -0.14995350f, -0.03415809f, 0.51782531f, 0.52302647f, 
    -0.13317421f, 0.19871131f, 0.08289766f, 0.29975301f, -0.04388591f, -0.44121179f, -0.13446675f, 0.27896011f, 
    -0.83113092f, 0.14767048f, 0.30521175f, 0.27680191f, 0.22296520f, 0.68217558f, -0.14043474f, 0.49069130f, 
    0.73263204f, 0.59605187f, -0.30454418f, -0.39068422f, -0.12275677f, -0.61694634f, -0.76456815f, -0.35323569f, 
    -0.26402423f, -0.33664662f, -0.02617587f, -0.32531086f, 0.30753896f, 0.08512811f, 0.61150146f, 0.60744220f, 
    0.32606393f, -0.51471651f, -0.88900912f, 0.05426515f, 0.14543255f, -0.02852984f, -0.12114540f, 0.48509085f, 
    -0.80664611f, -0.21919836f, -0.43297407f, -0.39819118f, -0.23535451f, 0.08806327f, 0.22008866f, 0.45057341f, 
    0.24618985f, 0.34827429f, 0.41701731f, 0.18428704f, -0.36540771f, 0.21203819f, -0.74377888f, -0.38051358f, 
    -0.43618163f, 1.02957797f, 0.94466799f, 0.40566686f, -0.29644445f, 0.33066556f, -0.20562442f, -0.10898842f, 
    0.44555065f, 0.11435708f, -0.01889775f, -0.21155894f, -0.58798754f, -0.26749411f, 0.33080921f, 0.25569826f, 
    -0.50340945f, 0.14429760f, -0.40348208f, -0.19049940f, -0.64769763f, 0.11041476f, -0.58736885f, 0.22018148f, 
    0.90652376f, 0.00742183f, -0.12388103f, 0.18755296f, 0.71554244f, -0.07052360f, 0.74669254f, 0.56636089f, 
    -0.11588096f, 0.28152037f, 0.32475403f, 0.05734047f, -0.08131876f, -0.42671457f, 0.00072392f, 0.26095504f, 
    -0.65066373f, 0.05766520f, -0.73065752f, 0.37655789f, -0.29622108f, -0.34959689f, -0.40434331f, -0.60604829f, 
    -0.52618706f, 0.42668223f, 0.93718678f, 0.07166789f, 0.15500891f, -0.07355140f, -0.22326297f, -0.15645885f, 
    -0.35405400f, -0.67263049f, -0.10522325f, -0.25788754f, -0.31743333f, 0.00569393f, 0.03803849f, 0.20359519f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.05906761f, -0.01838732f, -0.13353559f, 0.35712975f, -0.18378605f, -0.21193714f, -0.13063328f, -0.13616371f, 
    -0.20276988f, -0.03873887f, -0.03013801f, -0.49003410f, 0.13527232f, 0.09973156f, -0.03188173f, 0.19731800f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.23325031f, 0.12237743f, 0.26670074f, -0.04377384f, 0.05266307f, 0.06736287f, -0.06900553f, -0.09605970f, 
    -0.00020688f, 0.59673780f, 0.13527519f, 0.09597483f, -0.01140861f, -0.02148701f, -0.23099628f, -0.03179431f, 
    -0.00883745f, -0.03223454f, -0.51098043f, 0.22475146f, -0.16525309f, -0.02804319f, -0.12481671f, -0.16587983f, 
    -0.10438863f, -0.02085093f, 0.14618373f, -0.11283252f, -0.01447774f, -0.22102788f, -0.17871508f, 0.08071421f, 
    -0.25625771f, -0.02378088f, -0.13282260f, -0.04902796f, -0.13063404f, 0.05602123f, 0.03766748f, 0.06846873f, 
    -0.09716379f, 0.22340351f, 0.00659536f, 0.01763033f, -0.00501486f, 0.00547750f, 0.06935254f, 0.17471968f, 
    -0.14417644f, -0.02547699f, 0.15440099f, -0.10723347f, 0.00210160f, -0.19456026f, -0.15820487f, -0.05704335f, 
    -0.54191220f, -0.10663506f, 0.02613345f, -0.09699434f, -0.04160397f, 0.03619225f, 0.12304281f, 0.33119926f, 
    0.13647027f, -0.05309563f, -0.23577571f, -0.14451236f, -0.22929396f, 0.01265849f, -0.08190341f, 0.15528390f, 
    0.10681557f, 0.04695034f, -0.15763243f, -0.06866657f, 0.14199513f, 0.03250642f, 0.06972668f, -0.18966463f, 
    0.05446796f, 0.05713797f, -0.09891793f, 0.13906538f, 0.00170385f, -0.07575069f, 0.06809645f, 0.00295669f, 
    -0.03963987f, 0.11687439f, -0.17834437f, 0.18355386f, 0.06427704f, 0.18298759f, 0.06266483f, -0.05566643f, 
    -0.19205409f, -0.05500397f, 0.11617661f, 0.26447079f, -0.05174893f, 0.01812943f, 0.00844776f, 0.20378770f, 
    0.04014200f, -0.15179473f, -0.12863468f, -0.19055198f, 0.00827956f, 0.09906735f, -0.13745442f, -0.02886206f, 
    -0.10818002f, -0.02800087f, -0.10295691f, -0.11633142f, -0.00143255f, -0.27634090f, 0.30322358f, 0.06849548f, 
    0.01724776f, 0.09349683f, 0.02361399f, -0.16246705f, -0.16310911f, 0.10126217f, 0.13651912f, 0.25924665f, 
    0.24469392f, -0.01459465f, -0.13847268f, -0.06915620f, -0.04101521f, 0.03827418f, 0.13547470f, 0.17905927f, 
    0.21312518f, -0.03532787f, -0.12655939f, -0.02100872f, 0.12177604f, -0.16815326f, 0.07303943f, 0.03119961f, 
    0.22224744f, 0.12351741f, 0.01100656f, -0.00979690f, -0.02327540f, 0.04868920f, -0.00010718f, 0.14730942f, 
    0.05735562f, 0.04439900f, -0.13386448f, -0.00827711f, 0.10856912f, 0.03438327f, 0.01081989f, -0.06755245f, 
    0.05620895f, -0.16053624f, -0.04893382f, -0.20492002f, -0.10508002f, 0.04827839f, -0.07401118f, -0.13438907f, 
    -0.02900147f, 0.16163865f, 0.07641884f, -0.11429208f, -0.18892224f, 0.14030024f, 0.06208947f, 0.06414860f, 
    0.09259045f, -0.01368493f, -0.08237522f, -0.10775661f, -0.20240535f, 0.04735455f, -0.06634149f, 0.05519129f, 
    -0.12974586f, 0.09665619f, 0.03339788f, -0.19024919f, 0.00897724f, 0.00581514f, -0.31052756f, 0.07846549f, 
    0.05614287f, -0.06525285f, 0.10340592f, -0.04901215f, 0.06242260f, -0.06139445f, 0.05791534f, -0.05825804f, 
    -0.25988740f, 0.01750146f, -0.05608075f, -0.09336512f, -0.02085552f, 0.11935639f, 0.02813541f, 0.46779943f, 
    0.03744627f, 0.01120630f, -0.28989273f, -0.01461711f, 0.02769290f, 0.00506506f, -0.08170258f, -0.09687849f, 
    0.49071565f, 0.15177624f, -0.29981571f, 0.10509418f, -0.03170584f, 0.30608097f, -0.16177373f, -0.16544846f, 
    0.02545800f, -0.08703022f, -0.04914459f, 0.12045491f, -0.16814792f, 0.03372212f, 0.03958817f, -0.05571538f, 
    -0.02604412f, 0.13636146f, 0.26874062f, -0.22791971f, 0.17821768f, 0.01295249f, 0.16985779f, 0.03378820f, 
    -0.00064842f, 0.14487453f, -0.13726860f, 0.45005774f, -0.19919187f, 0.00085921f, -0.12968037f, 0.11052546f, 
    0.02689365f, -0.05454354f, 0.10067443f, 0.04474531f, -0.28548217f, 0.21368116f, -0.38085550f, 0.10141489f, 
    0.04062455f, 0.04426599f, 0.07106641f, -0.14518586f, -0.18850410f, 0.03555393f, 0.01240111f, 0.07207522f, 
    -0.15591364f, -0.00053533f, -0.08882593f, 0.02020479f, 0.01946978f, 0.06766941f, 0.00133691f, 0.12781030f, 
    0.39853311f, -0.01324179f, 0.02776206f, -0.11608052f, 0.03878613f, 0.11351948f, -0.18480532f, -0.15204829f, 
    -0.00082474f, 0.25893787f, 0.23789527f, -0.02767956f, -0.12064931f, -0.19947118f, 0.10643947f, -0.01020444f, 
    -0.12263226f, -0.27828020f, -0.16637127f, -0.05327423f, 0.29790229f, 0.10622638f, 0.13715814f, -0.22752547f, 
    0.13100438f, 0.20181088f, -0.25116757f, -0.14764255f, 0.06711852f, 0.00975532f, 0.05569397f, 0.08783637f, 
    -0.00619819f, 0.14744553f, 0.38666630f, -0.44970113f, 0.14241396f, -0.15401395f, 0.04161759f, 0.17480426f, 
    -0.26975930f, -0.00256552f, 0.17817950f, -0.01440546f, 0.24099340f, -0.33370250f, 0.26001343f, 0.04611515f, 
    -0.05096592f, 0.02877389f, 0.21638553f, 0.15663867f, -0.05231755f, -0.31552374f, -0.06630969f, -0.10749444f, 
    0.01633305f, 0.01812154f, 0.20510900f, -0.01568477f, -0.00712245f, -0.17258011f, 0.10586257f, -0.20182557f, 
    0.20519936f, 0.11179776f, 0.05631613f, 0.13175914f, -0.09227338f, 0.00265954f, -0.26513141f, 0.30504462f, 
    0.30500215f, -0.02931719f, -0.13790429f, -0.10465723f, 0.10618605f, 0.16177543f, 0.06364051f, 0.31657913f, 
    -0.23911345f, -0.20951696f, 0.04661573f, 0.07239338f, -0.15665346f, 0.01766556f, -0.05005138f, -0.06490556f, 
    -0.18269448f, 0.18951103f, -0.06371657f, 0.17935328f, 0.19577357f, -0.12752061f, 0.01641830f, -0.18109533f, 
    0.03587389f, -0.42164400f, 0.72317350f, 0.13970931f, 0.30490342f, -0.07130052f, -0.15599920f, -0.15031554f, 
    -0.10594378f, -0.11006432f, -0.33793572f, -0.29261991f, 0.20171423f, -0.09522343f, -0.09109809f, 0.10880724f, 
    -0.06226488f, -0.17660370f, 0.18627566f, 0.08857529f, -0.43206540f, 0.03332610f, 0.07886429f, -0.21488817f, 
    0.00783747f, -0.13187729f, -0.07679581f, 0.07694156f, -0.09603592f, 0.12781063f, 0.12763089f, 0.22664069f, 
    0.24534258f, 0.28758556f, 0.11428744f, 0.08711566f, 0.09796324f, 0.35578406f, 0.01823553f, 0.11307017f, 
    0.01472162f, 0.00953128f, -0.04928272f, -0.05893219f, 0.11891572f, 0.25766239f, 0.14277956f, -0.44767994f, 
    0.00930113f, 0.07227736f, -0.02776781f, 0.01200196f, -0.04957487f, -0.01503318f, 0.09229700f, -0.00468697f, 
    -0.02329290f, 0.13576677f, 0.14734055f, 0.15114234f, -0.07655345f, 0.14869471f, -0.07525020f, 0.02249547f, 
    0.14545785f, 0.47558939f, 0.04685906f, 0.11274300f, -0.11605498f, -0.10735137f, 0.00380587f, -0.11465716f, 
    0.01647181f, -0.34339494f, -0.42634106f, -0.20405582f, -0.05654030f, 0.15451588f, 0.04430094f, -0.13608927f, 
    0.06374227f, -0.18859918f, -0.14678790f, -0.21277612f, -0.48332256f, -0.09580521f, 0.00757862f, -0.00459045f, 
    0.12318662f, -0.01394203f, -0.07370625f, 0.11882209f, -0.11215505f, -0.04440828f, 0.14711626f, 0.17557026f, 
    0.25179914f, 0.05588564f, 0.03252384f, 0.09307884f, 0.06581894f, 0.10532730f, 0.26354817f, -0.02394359f, 
    0.09873640f, -0.03588303f, 0.00115045f, 0.04191545f, -0.13518262f, -0.26354945f, -0.10495252f, -0.14293043f, 
    0.09971590f, -0.11275469f, -0.10515843f, -0.15321285f, 0.19021150f, 0.06395671f, 0.04551194f, 0.34011409f, 
    0.14984553f, -0.10001641f, 0.06165367f, 0.15663692f, 0.13508846f, 0.12853938f, 0.03558151f, -0.15339765f, 
    0.10366189f, -0.05292716f, 0.19273105f, 0.09086338f, 0.02165026f, -0.07896429f, 0.02718377f, -0.15629496f, 
    -0.03138427f, 0.19217119f, 0.07153631f, 0.18475266f, 0.03380849f, -0.15019786f, -0.03746753f, 0.09799618f, 
    0.03443104f, 0.11433363f, 0.12447805f, -0.02051812f, -0.18836468f, -0.08869602f, 0.10754652f, -0.14238401f, 
    0.13661060f, -0.02193327f, 0.08999525f, -0.11050255f, -0.06688453f, 0.12050948f, 0.04847933f, 0.14783800f, 
    0.08540954f, 0.09860363f, -0.04464690f, 0.18174848f, 0.09389748f, -0.25193390f, -0.01698293f, -0.23243092f, 
    -0.08854334f, -0.03055348f, 0.03250885f, 0.06431255f, 0.26120704f, 0.00261678f, 0.27298525f, -0.09005057f, 
    -0.14977361f, 0.19610684f, 0.06354774f, 0.01635141f, -0.14293942f, 0.03785469f, -0.24600278f, -0.32306984f, 
    -0.01612591f, 0.19916975f, 0.23732777f, -0.03184079f, 0.05467392f, 0.18477538f, -0.10689556f, -0.73249209f, 
    -0.37296897f, -0.01584814f, -0.00632406f, 0.04125504f, -0.10735727f, -0.18652406f, -0.10689573f, -0.02147699f, 
    0.02490798f, -0.30019152f, -0.08822776f, -0.04539236f, -0.00709319f, 0.01401436f, -0.03670923f, -0.27046505f, 
    0.11385047f, 0.25611520f, -0.27470997f, 0.18000072f, 0.03411730f, 0.09210955f, 0.17627548f, 0.03418432f, 
    0.04395873f, 0.10192013f, -0.17263395f, 0.16723351f, 0.15036692f, -0.00137094f, 0.10836407f, -0.08124081f, 
    0.12104537f, -0.09511454f, 0.27385920f, 0.21134153f, -0.47349975f, -0.01393671f, 0.15799576f, 0.04160034f, 
    0.03328846f, -0.02379577f, -0.04942772f, -0.15743396f, -0.58398628f, -0.09830374f, -0.10045145f, 0.09369931f, 
    -0.00140499f, 0.07237495f, 0.13923566f, -0.01035997f, 0.01313969f, 0.04335081f, -0.07436353f, -0.21542518f, 
    -0.14270763f, -0.21170859f, 0.25980392f, 0.02676934f, 0.11933956f, -0.40835279f, -0.26442310f, -0.09591728f, 
    -0.09416467f, -0.16165268f, -0.07226620f, 0.05186795f, 0.06983861f, 0.22344974f, -0.17344512f, -0.06774954f, 
    0.21698692f, -0.02424010f, -0.35883194f, -0.01419605f, -0.06069685f, 0.05091656f, 0.22087462f, -0.10638294f, 
    -0.56375110f, 0.10619880f, 0.02230645f, 0.14492613f, 0.11180362f, -0.09981064f, 0.07071494f, -0.12792145f, 
    0.23765588f, 0.16243905f, 0.13652816f, 0.08081809f, -0.01420882f, -0.30222911f, 0.21594284f, 0.09722173f, 
    0.05231276f, 0.28018749f, 0.19702767f, 0.06083396f, -0.09496382f, -0.00654347f, -0.03082353f, -0.09355278f, 
    -0.03929814f, 0.11348515f, -0.01442900f, 0.11317566f, -0.03719345f, 0.02134859f, -0.09725838f, -0.00144088f, 
    -0.15938404f, 0.07075959f, 0.03932395f, -0.47232485f, 0.24860741f, -0.24938753f, 0.01003994f, 0.07378267f, 
    -0.24777366f, -0.01768412f, -0.19658278f, 0.02747863f, -0.15577690f, -0.05389203f, 0.07634851f, 0.09270258f, 
    -0.06260880f, -0.15502645f, -0.02375267f, 0.06098293f, 0.09475020f, -0.30836758f, -0.11249597f, -0.05360606f, 
    0.00251455f, 0.13663594f, 0.05033664f, 0.09425651f, 0.01730519f, 0.12968704f, 0.27414367f, 0.12198801f, 
    -0.32406074f, 0.05156197f, 0.13644853f, 0.14556211f, 0.07498579f, -0.08416846f, -0.02040217f, -0.05479779f, 
    0.40332991f, 0.08500534f, 0.12320794f, 0.04632020f, -0.01158597f, -0.13486831f, 0.03934968f, -0.06459466f, 
    -0.09454232f, 0.11132170f, 0.10326855f, -0.04299056f, 0.05344960f, -0.12014397f, 0.06750336f, -0.15930429f, 
    -0.06742767f, 0.21521428f, -0.15618528f, -0.03540145f, -0.04008988f, -0.06254470f, 0.03170640f, 0.01670214f, 
    0.02508750f, -0.01002821f, 0.12385979f, -0.02244303f, -0.11491822f, -0.34365147f, -0.01460124f, 0.14814167f, 
    -0.02428563f, 0.02363276f, -0.10031308f, 0.04695790f, 0.16433524f, -0.08346194f, -0.01909439f, -0.01943932f, 
    0.00634879f, -0.03861381f, -0.13838367f, -0.06056939f, -0.12993212f, -0.37966186f, 0.04595553f, -0.07536391f, 
    -0.38600501f, 0.01164467f, -0.01734448f, 0.19171986f, 0.14668328f, 0.10155690f, -0.21338058f, -0.05251989f, 
    -0.16838285f, 0.00774962f, -0.03481999f, 0.00555531f, -0.30502057f, 0.25075889f, 0.08040157f, 0.38838953f, 
    -0.25017962f, -0.04761938f, 0.08069318f, 0.14830896f, -0.16103205f, 0.12526964f, 0.12864710f, 0.20506807f, 
    -0.08354704f, -0.08161171f, -0.01463880f, 0.05346160f, 0.01371466f, -0.12978570f, -0.00412328f, -0.11429384f, 
    -0.10370599f, -0.19625422f, 0.31796393f, 0.38642660f, 0.14983539f, 0.09657107f, -0.12404165f, -0.24390520f, 
    -0.04765172f, 0.04491188f, 0.14867613f, -0.15897274f, 0.27942124f, 0.06277722f, 0.09661025f, -0.15721694f, 
    -0.12061133f, -0.00125861f, 0.19813155f, 0.22300670f, -0.12227647f, 0.03496953f, -0.06610546f, -0.02174976f, 
    0.04782667f, -0.02647012f, -0.03610864f, 0.50920212f, 0.02252120f, -0.17627054f, -0.25533047f, 0.00193957f, 
    0.00648697f, -0.04979796f, 0.10027696f, -0.07089338f, -0.70723671f, 0.06414109f, 0.11249305f, 0.15162092f, 
    0.15341011f, 0.06216330f, -0.12171047f, -0.05840820f, -0.06384758f, 0.24824993f, -0.02075843f, -0.03065495f, 
    0.04170129f, 0.06328479f, 0.01817296f, -0.21162614f, -0.00401997f, 0.11682021f, 0.11243650f, -0.02761816f, 
    0.22290973f, -0.11502145f, -0.22904105f, -0.07006694f, 0.03367456f, -0.01376403f, -0.03489371f, -0.02832706f, 
    -0.41786703f, 0.11227319f, -0.05998427f, -0.03547992f, -0.05939858f, -0.14754391f, 0.12045748f, -0.05622157f, 
    -0.07040867f, 0.11019258f, -0.19690283f, -0.08163758f, 0.14450829f, 0.04293305f, -0.05839335f, -0.08584105f, 
    -0.22888896f, -0.43576843f, -0.30299607f, -0.07868256f, -0.02294715f, -0.06315291f, -0.04378165f, 0.10656340f, 
    -0.04413797f, 0.14580674f, -0.10167334f, 0.18922639f, 0.26296461f, -0.05456256f, -0.11090108f, -0.19152839f, 
    0.01655466f, 0.14596695f, -0.13198994f, 0.11363915f, -0.17138971f, -0.01163489f, 0.04533103f, 0.10993572f, 
    0.08218464f, 0.03114478f, 0.12828606f, 0.26798627f, 0.03842405f, -0.11488914f, -0.02093719f, -0.01780639f, 
    0.07103147f, -0.01234595f, 0.09948893f, 0.01302920f, -0.26996526f, -0.00833797f, 0.21805272f, -0.18208489f, 
    0.12836359f, -0.13421029f, 0.05553611f, 0.30313203f, 0.06670808f, 0.02166722f, 0.01378165f, -0.05879781f, 
    0.02274092f, 0.12680976f, -0.04714433f, 0.06383577f, 0.09021290f, -0.08291251f, 0.20850123f, 0.11873725f, 
    0.17840508f, -0.21366127f, -0.09992080f, -0.04035166f, 0.15412425f, 0.01294531f, -0.03921594f, 0.19838221f, 
    0.00083429f, 0.27147684f, -0.16727327f, 0.07017098f, -0.07453713f, -0.00857943f, -0.02196776f, -0.24819976f, 
    -0.11788066f, -0.28630981f, -0.37948778f, 0.12150956f, 0.11370668f, 0.06638595f, -0.07779422f, -0.10287629f, 
    0.00891292f, -0.01960943f, 0.29378042f, -0.22488098f, 0.31003115f, 0.03328567f, -0.16377051f, -0.13817152f, 
    -0.16186723f, -0.12752900f, -0.04923929f, -0.31007594f, 0.14774197f, -0.33393720f, -0.04107700f, 0.11276728f, 
    -0.10609946f, 0.01307196f, 0.09712750f, 0.16812037f, 0.10480002f, -0.02904915f, 0.24868721f, 0.25089625f, 
    0.02881398f, -0.09818209f, 0.08458586f, 0.20407102f, 0.05722804f, 0.01896922f, -0.25451398f, -0.20247315f, 
    -0.16244479f, 0.06940845f, -0.02743481f, 0.05760135f, 0.04496791f, 0.00498305f, 0.19136710f, 0.23473929f, 
    0.23097499f, -0.42541671f, 0.20087335f, -0.04554844f, -0.00365612f, 0.14802933f, -0.12274798f, 0.11234593f, 
    0.08264713f, -0.05292691f, -0.01700541f, 0.04748182f, -0.06363975f, 0.06975385f, 0.10646116f, -0.23980042f, 
    0.00946225f, 0.02917283f, -0.09282533f, -0.07574242f, -0.02936713f, 0.07100531f, -0.08157450f, -0.08029844f, 
    -0.00599608f, -0.06958903f, -0.00717323f, 0.03810617f, 0.05624036f, -0.02664478f, 0.08655925f, -0.01177523f, 
    -0.00375541f, -0.07983488f, -0.07799989f, 0.00439602f, -0.03733855f, -0.01358275f, -0.03684266f, 0.05810502f, 
    0.03347927f, -0.00029049f, -0.05990809f, -0.06284180f, 0.01873380f, -0.02700608f, -0.01368484f, 0.05921744f, 
    0.01341489f, -0.08718386f, 0.02547189f, -0.05532255f, -0.05007964f, 0.00132378f, -0.02388889f, -0.06774686f, 
    -0.00569257f, -0.05337089f, -0.05717680f, 0.00887923f, -0.03696796f, -0.00410001f, 0.05423437f, -0.01611075f, 
    -0.02405265f, 0.00125383f, -0.01314656f, -0.08186634f, -0.06390907f, -0.03025806f, 0.06770336f, 0.06827942f, 
    -0.09536093f, -0.03150332f, -0.02462673f, 0.02556011f, 0.02640888f, -0.04582925f, -0.01847339f, 0.01441334f, 
    -0.07893811f, -0.05981536f, -0.06149025f, -0.07979240f, -0.06936026f, -0.07383262f, -0.02201865f, 0.02640274f, 
    -0.09104497f, -0.00469088f, 0.01499407f, -0.10186917f, -0.00779183f, -0.04877840f, -0.05539065f, -0.02634237f, 
    -0.00301089f, 0.02241532f, 0.04771582f, -0.01378106f, -0.07669471f, 0.07585682f, -0.00742396f, 0.05410847f, 
    -0.07233489f, -0.03479910f, -0.06799337f, -0.01206120f, -0.00522076f, -0.06380051f, 0.05827941f, -0.06014664f, 
    0.02914431f, -0.06743640f, -0.07365199f, -0.03310627f, 0.02618938f, 0.04727947f, -0.00064554f, 0.01678160f, 
    -0.04628400f, -0.04390813f, 0.05067924f, 0.04297834f, 0.01605281f, -0.06076813f, -0.07624958f, -0.02593529f, 
    -0.05114667f, 0.03012790f, -0.04047827f, 0.05543287f, 0.03450561f, 0.07219533f, 0.00033675f, -0.09790905f, 
    -0.05445058f, 0.04229734f, -0.01408216f, -0.03330236f, -0.01703662f, 0.07093421f, 0.03077218f, -0.09487962f, 
    0.05437048f, -0.01941255f, 0.04206377f, -0.00474135f, 0.00087178f, 0.04459525f, -0.04546389f, 0.06434464f, 
    -0.06936829f, -0.06545564f, 0.04035698f, 0.00813439f, -0.02672695f, -0.01161269f, 0.06150877f, 0.06534740f, 
    0.10357279f, -0.04782391f, -0.16711749f, 0.08024477f, 0.15727134f, 0.08593036f, -0.11469895f, -0.08636180f, 
    0.03221146f, -0.02156276f, 0.17729846f, 0.04237144f, -0.12967452f, -0.15001489f, -0.00671596f, 0.03801026f, 
    -0.08473973f, 0.23249432f, 0.00806740f, -0.27516368f, 0.04008268f, 0.06595279f, 0.26800856f, 0.04835016f, 
    -0.03041779f, -0.01250297f, 0.03421381f, -0.13840531f, 0.01990852f, 0.00658586f, -0.09599370f, -0.06682632f, 
    0.15360609f, 0.14087187f, 0.01224770f, 0.08865745f, 0.12455156f, 0.10472061f, 0.02692295f, 0.17269200f, 
    -0.07327162f, 0.06344549f, 0.22600500f, 0.06919519f, -0.06945467f, -0.22169937f, -0.02152066f, 0.29519343f, 
    0.32129586f, -0.04634174f, 0.17429090f, 0.06122800f, 0.03074574f, 0.14715154f, -0.01447959f, -0.29583907f, 
    0.07979108f, -0.54757720f, 0.07073326f, -0.07718642f, 0.09027141f, 0.06773152f, -0.03501829f, 0.16586897f, 
    -0.17883635f, -0.04334438f, 0.01893892f, -0.04307507f, -0.33553007f, -0.09216218f, 0.25625062f, -0.08032376f, 
    -0.01919568f, 0.05023709f, 0.21334949f, 0.03015715f, -0.04556757f, 0.05245198f, 0.41812462f, 0.14004807f, 
    0.13074875f, -0.38666555f, 0.36423811f, 0.32325566f, 0.05326276f, 0.06404287f, 0.06566045f, -0.00008052f, 
    0.02929907f, -0.11437804f, 0.09241576f, -0.07242451f, 0.04983764f, 0.03171875f, -0.09796436f, -0.13446259f, 
    -0.04752288f, -0.04810778f, 0.09606806f, -0.09382197f, -0.08891207f, -0.29894736f, -0.21872549f, -0.01312601f, 
    0.07914122f, -0.02215160f, -0.14629553f, -0.01731987f, -0.25928536f, 0.31841362f, -0.15478718f, 0.06550615f, 
    0.15572920f, 0.02778096f, 0.08050454f, -0.14407355f, 0.05925154f, -0.12667856f, -0.07244418f, 0.09214544f, 
    -0.00415357f, -0.03386812f, -0.11682360f, -0.07698356f, -0.04058449f, -0.01634277f, -0.26165414f, -0.12054855f, 
    0.11317279f, 0.25387925f, 0.09260788f, 0.02115974f, 0.07613035f, 0.00552709f, -0.14174935f, -0.07066464f, 
    -0.07874416f, 0.10984600f, 0.37840316f, 0.05009484f, 0.09297268f, 0.21058637f, 0.02230421f, 0.20778616f, 
    -0.04082754f, 0.12842529f, -0.27034083f, 0.03410856f, 0.15625224f, -0.11718186f, 0.01430144f, 0.14681919f, 
    -0.18985732f, 0.08140477f, 0.00107965f, -0.11049106f, 0.18525434f, 0.00250450f, 0.31036037f, -0.28077662f, 
    -0.08064093f, -0.13775678f, 0.07388448f, 0.09962879f, -0.19722709f, 0.07222310f, -0.00915006f, -0.06804872f, 
    0.12703280f, -0.00676951f, 0.21512282f, -0.02186733f, -0.00681765f, -0.00024184f, 0.15364315f, -0.02264443f, 
    0.26627582f, 0.19942273f, -0.07830263f, -0.15044950f, -0.26525369f, -0.17578427f, 0.02951354f, 0.16498335f, 
    -0.13600771f, -0.09206265f, -0.15067051f, 0.10556908f, 0.21131326f, 0.36933368f, 0.08225579f, 0.06668468f, 
    -0.10578732f, -0.26440763f, 0.19325042f, 0.11648571f, 0.15772326f, 0.19093454f, 0.38687778f, -0.40284476f, 
    0.11345049f, 0.08358989f, -0.07756916f, 0.09124598f, 0.06021961f, -0.31911644f, 0.03857750f, 0.49320835f, 
    -0.09925249f, 0.11172354f, 0.10398044f, 0.04668020f, 0.11857454f, 0.03726297f, -0.08869531f, 0.03670467f, 
    -0.51754349f, -0.10575801f, -0.01028386f, -0.02150468f, 0.04396902f, 0.11521033f, -0.55583656f, 0.02670261f, 
    -0.34790552f, -0.04830361f, -0.15455434f, -0.06485645f, -0.16565207f, 0.17861451f, 0.04017201f, -0.00191243f, 
    0.03399593f, 0.19082558f, 0.11415850f, 0.07559467f, 0.21931434f, 0.21220359f, -0.23027039f, 0.19632974f, 
    0.12131094f, -0.01952590f, -0.01559801f, -0.14361058f, 0.03636365f, -0.12958571f, -0.01930232f, -0.12762447f, 
    -0.11379430f, -0.02357386f, 0.00703777f, -0.13158868f, -0.36534941f, -0.11950538f, 0.15671481f, -0.00060615f, 
    0.05950910f, -0.24615216f, 0.02452715f, -0.12601973f, 0.19353232f, 0.23027107f, -0.03870438f, -0.00981295f, 
    0.14955927f, 0.25428474f, 0.21185382f, -0.26386443f, -0.01028930f, -0.16286081f, -0.04532689f, -0.05441221f, 
    -0.25782338f, -0.18124051f, 0.02864199f, -0.18629895f, 0.26524448f, 0.10790938f, 0.07048404f, 0.20404817f, 
    0.15782885f, -0.11183598f, 0.04732583f, 0.00983435f, 0.12267537f, -0.17657498f, -0.03989299f, -0.32610488f, 
    -0.00642119f, -0.08203663f, 0.02854921f, 0.02700174f, -0.01292078f, 0.06981245f, 0.02110375f, 0.05647590f, 
    -0.03636007f, -0.08064115f, 0.00162532f, -0.04823956f, 0.06017218f, -0.01498722f, 0.01391666f, -0.05034010f, 
    -0.06238232f, 0.01419044f, -0.00722326f, -0.07361673f, 0.00535477f, -0.00958232f, -0.07830083f, -0.08654379f, 
    0.05369408f, -0.06502843f, 0.01038074f, 0.06278442f, 0.03580656f, 0.04409028f, 0.04256413f, -0.04195493f, 
    0.00059247f, -0.04469213f, -0.07870246f, -0.02152461f, -0.04959022f, 0.00625081f, -0.04121071f, 0.01974224f, 
    -0.04536844f, 0.01978117f, -0.06742564f, -0.02138559f, 0.00043201f, 0.03699135f, -0.08655194f, -0.06504925f, 
    0.04615590f, 0.02659127f, 0.03441372f, 0.03144559f, 0.01706500f, -0.08031741f, -0.01631324f, -0.04319805f, 
    -0.07797438f, -0.08857526f, 0.04581596f, -0.06813664f, -0.02452679f, 0.01112109f, -0.01630954f, -0.08277407f, 
    0.01919057f, -0.01379438f, -0.00969764f, -0.00520002f, -0.03136623f, 0.05787655f, -0.01890927f, -0.08511082f, 
    0.05341189f, 0.04016163f, -0.06759630f, -0.00624998f, -0.05561698f, 0.06730624f, 0.00917245f, 0.00206084f, 
    -0.02399615f, -0.01389267f, -0.03709074f, -0.01394613f, -0.01963750f, -0.01071695f, -0.03680274f, -0.00103715f, 
    -0.06841723f, 0.06734442f, 0.03377532f, -0.05648848f, 0.04693438f, -0.08137929f, -0.07979762f, -0.02743780f, 
    -0.08489846f, -0.07050794f, 0.01911694f, -0.03333287f, 0.03619067f, -0.02427822f, 0.04242589f, -0.01661131f, 
    -0.02644745f, 0.00904501f, 0.03350922f, -0.03073107f, 0.03715394f, 0.05039283f, -0.00738273f, 0.02443763f, 
    -0.01947079f, -0.02047463f, 0.03971039f, 0.00223035f, -0.00704031f, -0.00224798f, -0.03486673f, -0.02166732f, 
    -0.08745533f, 0.01446612f, -0.05821342f, -0.05004168f, 0.04571745f, -0.00810715f, 0.03460795f, -0.06470397f, 
    0.01292763f, -0.06046281f, 0.03647149f, 0.01453243f, -0.03143213f, -0.08001769f, 0.01835402f, 0.01679266f, 
    -0.02694027f, 0.05327761f, 0.05550844f, -0.03839635f, 0.02089561f, -0.00005213f, 0.04772123f, -0.00988348f, 
    0.05931356f, -0.07778869f, 0.00529699f, -0.10623013f, 0.07833626f, 0.01624511f, -0.01703586f, 0.02073394f, 
    0.05292610f, 0.13306813f, 0.04123412f, 0.05171122f, -0.09897252f, -0.05725920f, 0.03139544f, 0.01910998f, 
    -0.05682055f, 0.14730258f, -0.17299020f, 0.29751652f, 0.00789146f, -0.05993192f, 0.09313714f, -0.09365370f, 
    -0.08160720f, -0.16060902f, -0.01626822f, 0.07865620f, -0.10668421f, -0.12569483f, -0.05400875f, 0.02404855f, 
    -0.03929357f, 0.00373862f, 0.10577301f, -0.01658160f, -0.65492743f, -0.14601851f, -0.04417614f, 0.26709649f, 
    0.16967995f, 0.12195991f, 0.05795528f, 0.00435444f, -0.10379283f, -0.08606877f, -0.15072095f, 0.18628776f, 
    -0.37653092f, 0.09109776f, -0.08362640f, 0.06018177f, -0.07775964f, -0.03768303f, 0.50390130f, 0.09084225f, 
    -0.15388067f, -0.03661385f, 0.08709845f, 0.03368573f, 0.02476867f, 0.02498398f, -0.06670923f, -0.02362715f, 
    -0.00402384f, -0.08466078f, 0.24456018f, -0.01576284f, -0.07523945f, 0.27904081f, 0.08185326f, -0.07779495f, 
    0.02184049f, -0.12031204f, -0.23044227f, 0.03530668f, 0.20088145f, 0.03784057f, -0.09237155f, -0.03051770f, 
    -0.00257643f, 0.31111109f, -0.05042652f, -0.17780925f, 0.12153223f, 0.01243114f, 0.02675552f, 0.03886030f, 
    -0.09539937f, -0.01147964f, -0.02358370f, 0.21715084f, 0.14502111f, -0.18695332f, -0.06383779f, 0.02547490f, 
    -0.04159246f, -0.10670999f, 0.09706678f, -0.09400133f, 0.12123469f, -0.02255130f, -0.04671701f, -0.01766495f, 
    -0.06109726f, 0.07140602f, -0.05545193f, -0.04127210f, -0.17164625f, -0.29978436f, -0.35358819f, 0.08820091f, 
    0.06817605f, 0.05807143f, -0.11760286f, -0.03125133f, -0.07942301f, 0.04654374f, 0.14246169f, -0.08540663f, 
    0.10592493f, 0.21630329f, 0.11646514f, -0.07756657f, 0.00958242f, -0.04276452f, -0.24910386f, -0.14041479f, 
    0.09838738f, -0.03616527f, 0.09382278f, 0.00986561f, -0.15522660f, 0.09813099f, 0.05003832f, -0.02015749f, 
    0.10781174f, 0.20860131f, -0.01313923f, -0.10641439f, -0.08974241f, 0.07516671f, 0.17831591f, 0.03268103f, 
    0.11185723f, -0.14392595f, 0.31373036f, -0.01327909f, 0.10695602f, 0.08079002f, 0.02134101f, 0.01934074f, 
    -0.00373589f, 0.06079138f, -0.45989478f, -0.67433143f, 0.03986919f, -0.05625913f, 0.13008098f, 0.01290755f, 
    0.02340450f, -0.13488764f, 0.26639181f, 0.10053130f, 0.12682389f, -0.08869492f, -0.04421839f, -0.15516272f, 
    -0.10803520f, -0.00522687f, 0.07916366f, 0.09815645f, 0.01121898f, -0.36468047f, -0.02663457f, 0.04859885f, 
    -0.13812827f, 0.11552265f, 0.11428738f, 0.07021344f, 0.22888842f, 0.25008622f, 0.06085901f, -0.06350938f, 
    -0.08702565f, 0.03714370f, -0.07304171f, 0.23486122f, 0.04163031f, -0.49167731f, -0.13143359f, 0.31965801f, 
    -0.14476280f, -0.13320167f, -0.05244147f, 0.06532891f, -0.11475430f, 0.14062662f, -0.02422034f, -0.18044998f, 
    -0.14981529f, 0.12991147f, 0.14420652f, -0.12393012f, 0.16189511f, 0.07125357f, 0.00793708f, -0.11754700f, 
    0.22669132f, -0.31090423f, 0.00484768f, 0.05230424f, -0.07767903f, 0.03247188f, 0.01741779f, -0.17848048f, 
    -0.01323375f, -0.10755729f, 0.08545044f, 0.11120417f, 0.06444106f, 0.10256127f, 0.06005558f, 0.06786960f, 
    0.26567844f, 0.01672985f, -0.09204623f, -0.00693238f, 0.14431004f, 0.08147401f, 0.00312836f, 0.04536766f, 
    -0.15048636f, -0.04788199f, 0.02312717f, -0.06283443f, 0.10602110f, -0.23784587f, 0.02626336f, -0.00833281f, 
    0.12334774f, 0.14739214f, -0.18992347f, -0.16826873f, 0.18340702f, 0.22333333f, -0.21457577f, -0.09212863f, 
    -0.11202510f, -0.05455681f, 0.24349162f, -0.01414036f, 0.16678785f, 0.16970430f, 0.12656409f, 0.04522377f, 
    0.16298872f, -0.07214257f, 0.03283259f, -0.02585488f, 0.08682839f, -0.17030688f, -0.26069173f, -0.13097467f, 
    0.10782255f, 0.12763880f, 0.16640764f, 0.12447865f, -0.14174576f, 0.02536307f, -0.10747594f, 0.12962362f, 
    0.15917648f, -0.34910786f, -0.00485765f, -0.00568229f, -0.03452669f, -0.06086006f, -0.05020801f, -0.49390006f, 
    -0.00861244f, 0.16043067f, 0.12327604f, -0.06081971f, -0.00815675f, 0.10746103f, 0.03104021f, -0.05966755f, 
    0.18525054f, 0.22038616f, 0.19650508f, -0.04377779f, 0.14332190f, -0.02096790f, -0.23829073f, 0.03640861f, 
    -0.09991600f, -0.40384993f, 0.22865927f, -0.10204621f, -0.05522452f, -0.07777786f, -0.00209486f, -0.07527123f, 
    -0.23472787f, 0.08237937f, -0.51745170f, -0.10247853f, 0.03338099f, 0.16256855f, -0.01722433f, -0.10431910f, 
    -0.08030242f, 0.17484701f, 0.06646438f, 0.07522243f, -0.26862395f, -0.05954748f, 0.14653723f, -0.10669191f, 
    0.09788375f, 0.10820128f, -0.29132408f, 0.15273985f, 0.16475970f, -0.29445049f, -0.11056201f, 0.08915985f, 
    0.27021271f, 0.06079737f, 0.07005008f, 0.17724591f, 0.06220409f, 0.33570427f, 0.06925768f, -0.13719586f, 
    -0.16314091f, -0.05460268f, 0.07842967f, 0.15602075f, 0.09005498f, 0.04988280f, 0.33591759f, -0.11072353f, 
    -0.10877938f, 0.04000241f, -0.17674319f, 0.22714183f, -0.12268133f, -0.02527957f, -0.15987824f, -0.24512079f, 
    -0.16101003f, -0.08315331f, 0.08948895f, -0.18544342f, 0.12631676f, 0.04056444f, -0.00656968f, -0.01502953f, 
    0.27149129f, 0.15369020f, -0.01200765f, 0.14190179f, -0.02217781f, 0.04911907f, -0.24263687f, 0.01683632f, 
    0.09329073f, 0.29423779f, -0.05775696f, -0.02498548f, 0.03995783f, -0.06799199f, 0.07624201f, 0.16919781f, 
    -0.04717226f, 0.23255707f, 0.11867438f, 0.27300388f, 0.14279422f, 0.02644441f, -0.09039345f, -0.16069557f, 
    -0.10927116f, -0.07893896f, 0.11612906f, -0.28934070f, 0.24417587f, 0.04003737f, 0.09062117f, -0.19418015f, 
    -0.07890243f, 0.02458387f, 0.05647312f, 0.04963362f, 0.00308906f, -0.26076981f, -0.09063095f, -0.13304727f, 
    0.01596158f, -0.10740530f, 0.16847219f, 0.08907440f, 0.14615077f, 0.02211247f, -0.00921055f, -0.25587815f, 
    -0.26290417f, 0.16616628f, 0.08583678f, -0.16957219f, 0.22956638f, -0.04260102f, 0.22597329f, 0.15717907f, 
    -0.11576054f, 0.18403274f, 0.00058894f, -0.18671186f, 0.02589429f, 0.08848614f, -0.24012066f, 0.26804671f, 
    0.29699147f, 0.10893752f, -0.17657159f, -0.09844802f, 0.01506435f, 0.00502008f, -0.01626921f, -0.22228348f, 
    0.24457170f, 0.13695371f, 0.20332539f, 0.07346625f, 0.15205835f, 0.12330612f, -0.08203151f, -0.00594170f, 
    -0.00921955f, 0.17374106f, 0.11561891f, -0.05761749f, -0.02086809f, -0.14661099f, -0.12902999f, -0.09151153f, 
    0.14797559f, 0.01483786f, -0.21511431f, 0.09568526f, 0.04909666f, -0.02873672f, 0.17978093f, -0.25063610f, 
    0.28388569f, 0.00062286f, -0.05486787f, 0.18254256f, 0.01332088f, 0.10438942f, -0.07123155f, 0.02276444f, 
    0.02441259f, -0.03622104f, 0.06661266f, 0.12572402f, -0.00238064f, -0.01182792f, -0.06152689f, -0.02971542f, 
    -0.03698166f, 0.02804736f, 0.04935144f, 0.15590815f, -0.19500987f, -0.03406458f, 0.03653356f, -0.16083577f, 
    0.08734999f, -0.10602904f, -0.15848267f, 0.00889378f, -0.01823953f, -0.03612598f, 0.04959122f, -0.05314847f, 
    -0.10399214f, 0.17724939f, 0.20626527f, -0.11867271f, -0.00359069f, -0.07167684f, -0.07359853f, 0.24637644f, 
    -0.10226854f, -0.07875357f, -0.19340262f, -0.01531862f, -0.18689859f, 0.10855500f, 0.08111581f, 0.00619904f, 
    -0.19734730f, -0.18456298f, -0.01087702f, 0.08353582f, -0.06848148f, 0.13787340f, 0.15958810f, 0.01052635f, 
    -0.03183812f, -0.75560051f, -0.47903600f, 0.08755746f, 0.02451563f, 0.32352930f, 0.00508123f, -0.04806677f, 
    -0.06981431f, 0.18507795f, 0.06260498f, -0.07647116f, 0.00028967f, -0.10162896f, -0.09752629f, 0.02510075f, 
    0.19032750f, -0.00979879f, -0.06265224f, -0.05764731f, -0.20965600f, -0.07717663f, -0.21803080f, -0.10212693f, 
    0.00604661f, 0.05983357f, -0.11237206f, 0.08126652f, -0.52693814f, -0.38371694f, -0.05896968f, 0.11809079f, 
    -0.13607179f, 0.11554313f, 0.07133033f, 0.14508955f, 0.04784964f, 0.09898005f, 0.39721733f, 0.20124434f, 
    0.09752163f, 0.13139848f, -0.11987250f, -0.02386100f, -0.04736930f, -0.03581524f, 0.21641880f, 0.23865765f, 
    -0.11152912f, -0.02279143f, -0.10712873f, -0.02648276f, -0.02500021f, 0.14067714f, 0.10243636f, -0.15148576f, 
    -0.09557107f, -0.06532283f, -0.08772051f, -0.00734807f, -0.04395898f, 0.06726316f, -0.02107251f, 0.02814302f, 
    0.00515083f, -0.00234836f, 0.01193360f, -0.08531183f, -0.03550817f, -0.04777771f, -0.02439470f, 0.00624534f, 
    -0.00597006f, 0.02028442f, 0.07611302f, -0.01916248f, -0.08737993f, -0.06716852f, -0.03638455f, 0.05463779f, 
    -0.06516277f, -0.03473068f, 0.07460371f, 0.07114688f, -0.04025701f, 0.02552536f, -0.08253630f, -0.08371675f, 
    -0.04432007f, -0.04013371f, -0.06129235f, 0.00279288f, 0.06704115f, -0.05690194f, 0.01657835f, -0.07058999f, 
    0.03552262f, -0.06165399f, 0.02701081f, 0.00039094f, 0.06331507f, -0.03941128f, 0.01215053f, -0.07418706f, 
    0.01812630f, -0.07178722f, -0.03358691f, -0.00898109f, -0.01262086f, 0.02700925f, -0.03696391f, 0.04960961f, 
    -0.06302761f, -0.06707090f, -0.03250112f, -0.07599204f, -0.00060722f, -0.08316906f, -0.04111247f, 0.07076570f, 
    -0.08830255f, 0.05142307f, -0.02157650f, 0.05998795f, 0.06584801f, 0.05631311f, -0.06709921f, -0.04234415f, 
    -0.08398961f, 0.01026997f, 0.06489930f, 0.02732680f, -0.07712995f, -0.01731039f, 0.01089448f, -0.01131573f, 
    0.00948414f, -0.07394260f, 0.07264382f, 0.02424330f, 0.03127929f, -0.04875461f, 0.04621760f, -0.07797194f, 
    0.01374458f, 0.02710944f, 0.00701611f, -0.07464281f, 0.04133508f, -0.06315207f, 0.00290816f, -0.05425124f, 
    -0.03344025f, -0.04940249f, 0.00104055f, 0.03325786f, -0.07444775f, 0.07374713f, -0.02551933f, 0.05317289f, 
    -0.08701398f, -0.00139714f, -0.00794983f, 0.05950467f, -0.02256692f, 0.02234132f, -0.08915258f, 0.01098883f, 
    -0.06902204f, -0.01381807f, 0.04835925f, 0.05753702f, 0.02444610f, -0.01556061f, -0.00166790f, 0.04647753f, 
    -0.06076305f, -0.07615998f, 0.02083118f, -0.07282916f, 0.02582273f, 0.04629076f, 0.05486677f, -0.03787039f, 
    -0.08795562f, -0.01784739f, -0.01420669f, -0.05552457f, -0.03962532f, -0.07816125f, -0.05750603f, -0.07341358f, 
    -0.02646759f, 0.03150638f, -0.04597235f, -0.01792506f, -0.07617503f, 0.06664588f, -0.08077482f, -0.01546736f, 
    -0.02036255f, 0.06410772f, -0.01058956f, -0.04041566f, 0.06358673f, -0.00641675f, -0.02334689f, -0.06224789f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.17715459f, -0.21621035f, 0.39458138f, 0.25081092f, 0.14151326f, -0.03330775f, 0.16328219f, -0.03351608f, 
    0.11955219f, 0.05597087f, -0.05766943f, -0.02692855f, 0.10203125f, -0.09301499f, 0.10760710f, 0.06298640f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.38702491f, -0.16699263f, 0.22927050f, -0.13011146f, 0.40825245f, 0.52375513f, 0.34795216f, -0.15750378f, 
    -0.30248746f, 0.47565240f, -0.18191168f, -0.14784400f, -0.04959345f, -0.22753303f, 0.29332757f, -0.15846443f, 
    0.86187774f, -0.12072235f, -0.01789280f, -0.15882786f, 0.38862008f, -0.53353745f, 0.01952430f, 0.15237267f, 
    0.47402179f, 0.14290266f, 0.22538710f, -0.21103473f, -0.07713494f, -0.20411272f, 0.11707421f, 0.02052164f, 
    0.01064575f, -0.15789944f, 0.34301713f, 0.12805365f, 0.18755969f, -0.28030619f, -0.37404624f, 0.04738003f, 
    0.41073477f, -0.53649294f, 0.05887927f, 0.28852209f, -0.40309742f, 0.14315568f, 0.08458965f, -0.21843857f, 
    0.54369336f, -0.23257057f, 0.18165040f, 0.21834683f, -0.22906531f, -0.25481728f, -0.03741281f, -0.12706576f, 
    -0.22624025f, 0.57759064f, -0.04002351f, 0.46088558f, 0.03902121f, 0.02644257f, 0.23039338f, -0.10206333f, 
    0.30578941f, 0.38409644f, 0.12606704f, -0.39826810f, -0.48302308f, -0.24752268f, 0.38804048f, -0.21686195f, 
    0.13030227f, 0.20658824f, -0.07898515f, 0.29411089f, 0.13781479f, 0.30524021f, 0.24287760f, 0.17813475f, 
    -0.24137267f, -0.16934735f, -0.27111802f, 0.21292600f, 0.54563558f, 0.06832854f, -0.43784168f, 0.05989056f, 
    -0.24668749f, 0.11550488f, -0.06815678f, 0.07627507f, -0.02745209f, 0.06782591f, 0.25132862f, -0.19010699f, 
    -0.32647181f, -0.55263704f, 0.44621259f, 0.09158874f, 0.04922807f, 0.03923004f, 0.01558326f, -0.20645633f, 
    0.23359574f, 0.13661022f, 0.08948243f, -0.17523268f, -0.18788122f, -0.09686725f, 0.26052594f, 0.09884875f, 
    0.25495377f, 0.52722389f, -0.15471348f, 0.42266527f, -0.16676208f, 0.47864306f, 0.31245297f, 0.06812764f, 
    -0.14233162f, 0.25022349f, -0.25206953f, -0.32283875f, 0.36198887f, 0.20671576f, 0.10851189f, -0.18242964f, 
    -0.21768112f, -0.10111757f, 0.17690806f, -0.35029638f, -0.60185975f, 0.04689563f, 0.02872591f, -0.04105572f, 
    0.15869156f, 0.42486238f, 0.24678442f, 0.56473577f, 0.03379478f, -0.04202386f, 0.07443027f, -0.05273092f, 
    -0.19870140f, -0.20582300f, -0.28994319f, 0.10782060f, 0.02709483f, 0.15552989f, -0.04242290f, -0.08019310f, 
    0.04658961f, -0.28456795f, 0.13839436f, 0.12604521f, -0.15098161f, 0.02357388f, 0.14918503f, 0.01666546f, 
    0.35079899f, -0.00522319f, 0.34009063f, -0.03349398f, -0.05704271f, -0.20069641f, 0.43077970f, -0.13925223f, 
    0.24352896f, 0.26578167f, 0.03751859f, -0.47871971f, -0.57071418f, 0.29464310f, 0.25148574f, 0.06359810f, 
    -0.23352972f, 0.00122530f, 0.00165325f, 0.39963630f, -0.14149082f, 0.09151564f, 0.52404165f, 0.04094772f, 
    -0.40557322f, -0.16982274f, -0.22564921f, 0.12416869f, 0.24377769f, 0.04544880f, 0.42583075f, -0.12313086f, 
    -0.03300992f, -0.19201618f, -0.17898515f, 0.04477817f, 0.07579756f, 0.11156031f, -0.11426795f, -0.16172829f, 
    0.02726677f, -0.23965752f, -0.06602505f, -0.13273093f, 0.02050492f, -0.21910614f, -0.07761955f, -0.06591290f, 
    -0.09787011f, 0.44201422f, -0.26364347f, 0.54573202f, -0.11746529f, 0.15265304f, -0.13331249f, 0.14094417f, 
    0.21033493f, -0.00398267f, -0.15385997f, -0.12631457f, -0.52704722f, 0.49726009f, 0.08781868f, -0.19915131f, 
    -0.42217267f, 0.01411666f, 0.10106190f, 0.20289491f, -0.18458951f, 0.67282194f, 0.10508116f, -0.05054012f, 
    -0.00034357f, 0.19845425f, 0.02685444f, 0.10464937f, 0.29308364f, 0.28640327f, -0.83863729f, -0.23017648f, 
    0.30376884f, 0.44774181f, 0.19165987f, -0.47540277f, -0.45193326f, -0.60698122f, 0.27267498f, -0.00717674f, 
    0.37805501f, 0.37264845f, -0.15862799f, 0.15997130f, -0.24272519f, 0.45301679f, 0.17389591f, -0.05217538f, 
    0.09458353f, -0.01354078f, 0.48227057f, 0.09785399f, -0.22422491f, 0.63410908f, -0.52818900f, -0.11286941f, 
    0.37237656f, -0.44981408f, -0.03725079f, 0.08681004f, -0.10957356f, -0.23543587f, 0.30162504f, 0.19847375f, 
    0.05516942f, 0.42660284f, -0.12976357f, -0.54922861f, 0.60140884f, 0.38145855f, -0.34173486f, -0.24440417f, 
    0.31807652f, -0.27651021f, 0.19381031f, -0.14143257f, 0.33875546f, -0.23749039f, 0.00579324f, 0.21210718f, 
    -0.15977696f, -0.23718634f, 0.14924787f, 0.38865113f, 0.54213291f, -0.69539398f, 0.18794478f, 0.06305412f, 
    0.38499120f, -0.13751929f, -0.02126310f, -0.34708652f, 0.16645212f, -0.00884900f, -0.29944763f, -0.13117389f, 
    0.54538506f, 0.45876086f, -0.03092286f, -0.44017553f, -0.09366831f, -0.37227744f, -0.20739730f, -0.14131585f, 
    0.26809710f, 0.16043068f, 0.07181006f, 0.13250208f, 0.31819603f, -0.16780606f, 0.48241940f, -0.22755057f, 
    0.06618164f, 0.43319407f, 0.18535274f, -0.08214383f, -0.28985196f, 0.74884945f, -0.06965681f, -0.17807551f, 
    0.02230002f, -0.05481919f, -0.06387430f, 0.28430474f, -0.53637892f, 0.47188571f, 0.42871952f, 0.12237284f, 
    -0.71082872f, -0.13641487f, 0.36250222f, 0.22766462f, -0.11089437f, 0.39832011f, 0.44333664f, -0.08888185f, 
    -0.45249021f, 0.09157105f, -0.19011709f, 0.49881160f, 0.54352254f, 0.21735038f, -0.05441011f, 0.03456384f, 
    -0.15511321f, -0.10974845f, 0.04568772f, 0.52328181f, 0.17377391f, 0.09268296f, -0.62325722f, 0.05747035f, 
    0.36423731f, -0.05586749f, -0.18528584f, -0.31234309f, 0.28940094f, -0.20866878f, -0.19250683f, -0.17337027f, 
    -0.00446560f, 0.34415567f, 0.28442082f, -0.32622981f, 0.11942025f, -0.21586159f, 0.00401474f, -0.19978836f, 
    0.39012942f, -0.19704583f, 0.19638219f, -0.40965170f, -0.59368283f, 0.07185445f, 0.43223360f, 0.21579868f, 
    0.13695718f, -0.52560759f, 0.19999513f, 0.70708883f, 0.08888965f, -0.24396847f, -0.15432541f, -0.18814033f, 
    0.13658668f, 0.30850098f, 0.01059687f, -0.30931967f, -0.51585221f, 0.07781235f, -0.29857346f, -0.12970340f, 
    0.19249369f, -0.15241554f, -0.00165094f, -0.42305744f, 0.00726167f, -0.09435929f, -0.04400917f, -0.23878020f, 
    -0.20224427f, 0.10694306f, -0.22759792f, 0.20497766f, 0.30248499f, 0.03343252f, -0.23508036f, -0.00679111f, 
    -0.25855288f, -0.26859868f, -0.15895627f, -0.23460709f, 0.04873652f, -0.11503062f, -0.19221342f, 0.18972224f, 
    0.18773666f, -0.22138375f, -0.05632851f, -0.21646938f, -0.25081569f, -0.01714259f, 0.12319804f, -0.20105216f, 
    -0.18934733f, 0.34018293f, 0.11513808f, -0.35001421f, -0.18172361f, -0.18968317f, 0.28872165f, -0.19995347f, 
    0.05365637f, -0.29223359f, 0.11812560f, 0.27117845f, 0.81155390f, 0.17434335f, -0.21880279f, 0.22797050f, 
    -0.11664023f, -0.64637578f, 0.06402296f, -0.22747655f, -0.33503613f, -0.11974787f, 0.57405782f, -0.02736333f, 
    0.02723794f, 0.22802104f, -0.06497553f, -0.13094136f, 0.26745844f, 0.24443358f, -0.13250254f, -0.10651788f, 
    0.20654514f, -0.09167274f, -0.32429850f, 0.15006877f, 0.53616655f, -0.14228721f, 0.25305149f, 0.01943465f, 
    0.03249668f, 0.63796550f, -0.05044760f, -0.43928134f, 0.00441390f, 0.32605070f, -0.22750552f, 0.05027064f, 
    0.23076066f, -0.27063525f, 0.30815855f, 0.07182177f, -0.15295509f, 0.96181697f, 0.00029569f, -0.19796427f, 
    0.12325435f, -0.02224523f, 0.01744816f, 0.24320385f, -0.14978547f, -0.36846533f, 0.06443781f, -0.20297346f, 
    -0.03856425f, 0.25198716f, 0.01660615f, 0.40612367f, 0.21758956f, -0.06129826f, -0.11294037f, -0.06927829f, 
    -0.09331657f, -0.14302813f, 0.13259637f, 0.27464756f, -0.13328204f, 0.55174899f, -0.43874136f, 0.06597286f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.57410038f, -0.12277031f, 0.36679569f, -0.44156370f, -0.39860684f, 0.24825853f, 0.62092185f, -0.11896323f, 
    0.23407958f, 0.01477686f, -0.14639220f, -0.42513031f, 0.12052295f, -0.11236349f, -0.13443780f, 0.11965027f, 
    0.03902751f, 0.25082326f, 0.31113604f, -0.03456194f, 0.07367294f, 0.09351388f, 0.39062965f, 0.40949464f, 
    0.06505831f, 0.22011785f, -0.29827133f, -0.00478824f, 0.10173631f, 0.27327469f, -0.02051381f, 0.20553607f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.11233441f, -0.09541053f, -0.13254787f, 0.15718535f, 0.28676936f, -0.34420002f, 0.03352008f, 0.46408185f, 
    0.44923022f, 0.00469197f, 0.19323899f, 0.87464482f, -0.13879652f, 0.22580570f, -0.02828435f, 0.22319093f, 
    0.06037967f, -0.32458287f, -0.26723087f, 0.06981785f, 0.30479947f, 0.17904121f, -0.23895933f, -0.18065804f, 
    -0.20530578f, -0.08769438f, -0.02914314f, 0.04124021f, -0.70465559f, -0.07355154f, -0.01820002f, 0.01358667f, 
    0.16527125f, 0.01893937f, 0.29736832f, -0.17262326f, -0.21755943f, 0.55150425f, 0.38517043f, -0.28382719f, 
    0.03713702f, 0.15693626f, 0.20276394f, -1.12373054f, 0.13587488f, -0.17275141f, 0.50211966f, -0.08092093f, 
    0.26373130f, 0.39960685f, 0.36457980f, -0.20074159f, -0.01376271f, -0.04143609f, 0.37766138f, 0.01247898f, 
    0.51181120f, 0.01268372f, -0.03113597f, -0.03014328f, 0.37667993f, 0.31014353f, 0.30838129f, 0.32879233f, 
    0.28079408f, -0.07960781f, -0.04091966f, 0.06661236f, -0.05205049f, 0.06798686f, 0.35771486f, -0.33463836f, 
    0.42245227f, -0.02567790f, 0.15259387f, -0.21179545f, 0.04800094f, -0.33350059f, 0.08246260f, 0.00180356f, 
    0.10422949f, -0.27607921f, 0.24502255f, -0.10699635f, -0.11797892f, 0.51056790f, -0.03913933f, 0.15354888f, 
    0.17381866f, 0.05528903f, 0.17013119f, 0.11500727f, 0.16219799f, 0.14277978f, -0.15426578f, 0.11937152f, 
    0.03333085f, -0.12672481f, 0.26589155f, 0.19529459f, 0.10616782f, 1.02732050f, 0.07463216f, -0.23074497f, 
    -0.09642155f, 0.05379136f, 0.02248767f, 0.22550507f, -0.04484819f, 0.70842820f, 0.36015189f, 0.21202308f, 
    -0.37846372f, -0.19659881f, 0.41772133f, -0.29344586f, -0.13796864f, 0.37075940f, -0.01145574f, -0.16660821f, 
    0.65950280f, -0.17088589f, 0.12298602f, 0.05823852f, 0.60667855f, 0.51929981f, -0.59696823f, 0.71170020f, 
    -0.49734554f, 0.05711280f, 0.40497759f, -0.20251845f, 0.08791923f, -0.45505959f, 0.09776104f, 0.02560581f, 
    -0.28220394f, 0.03132116f, 0.15472925f, -0.57206261f, -0.12622491f, 0.40974924f, 0.48168859f, 0.28049350f, 
    0.30745560f, -0.03078515f, 0.30742484f, 0.04227464f, 0.10991406f, -0.17448926f, 0.57652670f, 0.42098781f, 
    -0.05603197f, -0.00494271f, -0.07048104f, 0.46375322f, 0.06842853f, -0.34617212f, 0.11985067f, 0.24738522f, 
    0.04363883f, -0.44391948f, 0.04637402f, -0.14103584f, 0.00690235f, -0.11165913f, 0.31239581f, 0.18880954f, 
    0.00026362f, 0.04031717f, -0.04339438f, -0.08428512f, -0.02854905f, 0.07828145f, 0.63658690f, -0.21778853f, 
    0.24479584f, 0.05142006f, 0.29367301f, -0.47573942f, 0.05151504f, 0.52528751f, 0.12612119f, -0.01411027f, 
    0.44133231f, -0.06048574f, 0.01302839f, 0.24836044f, 0.34746930f, -0.29874277f, 0.35095465f, 0.13001482f, 
    0.01077819f, 0.26388738f, -0.04616198f, -0.12092637f, 0.01718062f, 0.85618889f, -0.14894933f, 0.31366017f, 
    -0.67972916f, 0.05203577f, 0.11935072f, -0.54352450f, 0.14528301f, 0.42632717f, 0.27969301f, 0.00027594f, 
    -0.15199344f, 0.27159631f, 0.16638218f, -0.00923331f, -0.00551265f, -0.30697662f, 0.26543045f, 0.24368824f, 
    0.23828730f, 0.14867333f, 0.04034656f, -0.26891446f, -0.00408938f, 0.89878559f, -0.35544211f, 0.21413973f, 
    0.07800932f, -0.22034618f, -0.09405056f, 0.24149606f, 0.42094511f, 0.07281493f, -0.21956724f, 0.08993058f, 
    0.64117354f, -0.01938480f, -0.04102793f, 0.29515418f, 0.10207311f, -0.06593218f, 0.24824210f, 0.20300739f, 
    0.24058624f, 0.35776645f, -0.22282271f, 0.34012264f, 0.29222548f, 0.12245169f, -0.38121703f, 0.04729254f, 
    -0.54128158f, -0.04274239f, -0.05503893f, 0.19321015f, -1.19194746f, -0.40313089f, 0.24814545f, -0.07022203f, 
    0.40902880f, -0.27281791f, -0.29298645f, 0.29552794f, 0.25550333f, -0.42529872f, -0.06653469f, 0.59384698f, 
    0.13081205f, -0.17934956f, 0.21243627f, 0.77485740f, 0.14869893f, -0.16134575f, -0.18329024f, 0.05634529f, 
    -0.44120729f, -0.49688250f, -0.08389460f, 0.13729435f, 0.06431268f, 0.47800192f, -0.43803218f, -0.02679620f, 
    -0.10187245f, 0.14568309f, 0.13828385f, 0.11340073f, 0.13970080f, 0.02283772f, -0.53839135f, -0.06184890f, 
    0.01723784f, 0.10688766f, -0.19781770f, -0.11063501f, 0.06831559f, -0.08769809f, -0.11501635f, -0.08775643f, 
    -0.17345546f, -0.02906166f, -0.02930539f, 0.10399657f, -0.07068452f, 0.14015408f, 0.06390899f, -0.00185669f, 
    0.07301664f, -0.01577459f, -0.15936290f, 0.05748320f, 0.06088305f, -0.02470535f, -0.07195375f, -0.18205379f, 
    -0.06555232f, 0.02408238f, -0.01216655f, -0.16151211f, -0.15193836f, -0.04652365f, -0.18694130f, -0.03973031f, 
    -0.20376919f, -0.27048051f, 0.07519684f, -0.21351266f, -0.04781201f, 0.20367354f, -0.00898706f, -0.32708636f, 
    0.61123812f, 0.14950791f, -0.22714509f, -0.04985641f, 0.14969109f, -0.42715117f, 0.46591467f, 0.04569004f, 
    0.24282372f, 0.31380564f, 0.09136517f, 0.17832460f, 0.00923680f, 0.30368441f, 0.31517243f, -0.39046812f, 
    -0.48550931f, -0.00937994f, -0.07349539f, 0.41056132f, 0.06547491f, -0.45921901f, 0.01912335f, 0.32488936f, 
    0.05307604f, -0.24367464f, 0.23657162f, -0.01276819f, 0.39268371f, 0.44704193f, -0.12704140f, 0.20028955f, 
    0.10055950f, 0.04437494f, 0.06272297f, 0.33154750f, 0.16883378f, 0.46177122f, -0.06974795f, 0.22061309f, 
    0.16016109f, 0.18029740f, -0.23986810f, 0.35532361f, 0.53147823f, -0.09991630f, -0.42708066f, 0.14973873f, 
    -0.44707170f, -0.22845145f, 0.15764891f, 0.07323208f, -0.66738272f, -0.03501500f, -0.37322488f, 0.20064093f, 
    0.06103597f, 0.12222031f, 0.21591629f, 0.24278776f, 0.06921693f, -0.68103254f, 0.36575079f, -0.33031258f, 
    0.40930256f, -0.00443242f, 0.35110235f, 0.19498491f, 0.08860926f, -0.07640283f, -0.25053439f, 0.06281035f, 
    0.12301432f, -0.12732016f, -0.24876110f, 0.01427000f, 0.33950102f, -0.23882528f, -0.30924511f, 0.23041232f, 
    0.19791371f, 0.08197539f, -0.11915501f, -0.29509398f, 0.44153187f, -0.11149469f, 0.53617382f, -0.05276420f, 
    0.12524983f, 0.07699303f, -0.36422732f, 0.01871077f, 0.16624509f, -0.12951580f, 0.12469441f, 0.24791160f, 
    0.40940812f, -0.15801883f, -0.04413958f, 0.24222562f, 0.07820658f, 0.09818814f, 0.15342465f, 0.18615372f, 
    -0.22205715f, -0.32579789f, 0.06270670f, -0.14548913f, -0.16599719f, 0.40035185f, 0.02474469f, -0.32676807f, 
    -0.17200518f, 0.07275028f, 0.08422213f, 0.16732486f, 0.40113324f, 0.42276245f, -0.14788660f, -0.23327030f, 
    0.35011050f, -0.27364299f, -0.33833021f, -0.19593537f, -0.04535697f, -0.19084200f, 0.17722954f, 0.25751814f, 
    -0.14535522f, 0.08304151f, 0.07766471f, 0.27547055f, -0.02640574f, -0.16003054f, 0.26621136f, -0.23282970f, 
    0.17226592f, 0.09718116f, 0.03703387f, 0.13250884f, -0.21506657f, 0.25175571f, 0.44009414f, -0.20509596f, 
    0.04012765f, 0.15656582f, 0.09990826f, 0.20922789f, -0.17045601f, -0.05068139f, -0.03414975f, -0.35403803f, 
    -0.25018102f, 0.52633739f, 0.06311314f, 0.32680357f, 0.38394314f, -0.31573203f, 0.17610106f, -0.03898638f, 
    0.18001834f, -0.16794322f, 0.26123554f, -0.04836836f, 0.02343495f, -0.46006754f, -0.31312129f, 0.23758622f, 
    0.10693455f, -0.32856554f, 0.30045301f, 0.27585250f, -0.00168143f, -0.11383646f, 0.17613828f, 0.16147350f, 
    0.51866037f, -0.24726236f, 0.03570019f, -0.05088102f, -0.20369755f, -0.16122693f, 0.07017362f, -0.10760860f, 
    -0.21281303f, 0.34760174f, -0.19529866f, 0.08879223f, 0.24691090f, -0.35984319f, -0.53981823f, 0.11801873f, 
    -0.01647068f, 0.13922831f, 0.00368120f, 0.50491005f, 0.16386677f, 0.28855222f, 0.10064728f, 0.16926718f, 
    -0.55264539f, 0.02809132f, 0.27474663f, 0.11691432f, -0.30923626f, 0.12602447f, -0.74416816f, -0.35556093f, 
    -0.02721639f, 0.64458215f, 0.08074809f, 0.48821917f, 0.46940148f, 0.10253463f, -0.42034885f, 0.15579534f, 
    0.07457298f, 0.29222390f, 0.40394565f, 0.06298731f, 0.18114662f, 0.32108590f, 0.11873775f, -0.41278508f, 
    0.11640973f, 0.16221398f, 0.00672310f, -0.13900888f, 0.09053324f, -0.65759897f, -0.38734972f, 0.11834676f, 
    0.19363967f, 0.52591246f, 0.00723511f, 0.45799652f, 0.05855910f, -0.12570405f, -0.03486537f, 0.42931923f, 
    -0.46390045f, 0.01598753f, -0.07933564f, 0.13695753f, -0.41424927f, -0.30566826f, 0.04574009f, -0.45637295f, 
    -0.34266809f, 0.19641359f, -0.22413492f, 0.34200454f, 0.62204361f, -0.41055575f, -0.43685627f, 0.35856232f, 
    0.09535272f, 0.07296281f, 0.34584725f, -0.28769800f, 0.08036797f, -0.28906304f, -0.27833495f, 0.42659169f, 
    0.24218172f, -0.03796111f, -0.44370639f, 0.45558783f, 0.37341502f, -0.11918985f, -0.39645478f, -0.04982335f, 
    -0.39955047f, -0.03577019f, -0.03593215f, -0.01363774f, -0.72597545f, 0.08842863f, 0.19476765f, -0.27393851f, 
    0.70847011f, -0.41988578f, -0.05692206f, 0.23461261f, -0.07323273f, -0.25878027f, 0.30991697f, -0.10789472f, 
    0.31186122f, 0.06865864f, 0.17284825f, 0.40890869f, 0.11783751f, -0.28243536f, -0.04323081f, 0.01687128f, 
    0.06991637f, -0.61605948f, -0.26662248f, -0.27329180f, 0.32489115f, 0.32367313f, -0.39342132f, -0.07303078f, 
    0.12046362f, -0.37157100f, 0.10629375f, -0.32311484f, 0.11630297f, -0.29144990f, 0.49788743f, 0.05600824f, 
    0.08678094f, -0.35273463f, 0.33749032f, 0.11903034f, 0.17702578f, -0.50936532f, 0.26660278f, -0.30508018f, 
    0.65939111f, 0.01036361f, 0.01619764f, 0.64255446f, -0.14728712f, -0.09495813f, -0.01465693f, 0.14563286f, 
    0.58604848f, -0.13615339f, -0.24976927f, 0.07423124f, 0.22710940f, 0.38796601f, -0.59320849f, 0.28101280f, 
    -0.31940922f, 0.13441825f, 0.02359806f, -0.08128452f, -0.53836501f, -0.64947563f, 0.42005214f, 0.00120464f, 
    -0.25503445f, -0.19526209f, -0.17365184f, 0.01192864f, 0.42822438f, 0.04336985f, -0.49746451f, -0.00585460f, 
    0.34434316f, 0.01848613f, 0.13820294f, -0.16675459f, -0.17127526f, 0.29826555f, 0.33250400f, 0.40285948f, 
    -0.31517544f, -0.32632631f, -0.25978354f, -0.05496696f, 0.31969249f, -0.00483660f, -0.92560971f, 0.08438959f, 
    -0.00511055f, -0.16677657f, -0.04333777f, 0.30496585f, -0.09086977f, -0.12678528f, -0.65846062f, 0.18763514f, 
    0.13835365f, -0.11124111f, -0.12636596f, 0.13603148f, -0.16425769f, -0.10753614f, 0.00172279f, -0.19878075f, 
    0.13496459f, -0.09342436f, -0.05490208f, 0.01063338f, 0.01822727f, -0.06898891f, -0.14197820f, 0.01522489f, 
    -0.16444059f, -0.05024648f, -0.18678764f, 0.10832347f, 0.07441697f, -0.17979589f, 0.02677782f, -0.08744323f, 
    0.12529917f, -0.05500423f, -0.16114445f, -0.03714749f, -0.11387821f, -0.06803001f, -0.17193168f, -0.12515253f, 
    0.50710696f, -0.02711863f, -0.29789656f, 0.07731153f, 0.19146049f, 0.37658110f, 0.05975914f, -0.06079650f, 
    0.52435327f, 0.05844620f, 0.01106709f, 0.39393389f, 0.00996478f, -0.08480123f, 0.07841163f, 0.11238539f, 
    -0.11278682f, 0.36865139f, -0.09531194f, 0.20973499f, 0.00252593f, 0.26785365f, -0.09723206f, -0.12144289f, 
    -0.19254182f, 0.36601517f, -0.12678140f, 0.11028357f, 0.42084342f, 0.03451603f, 0.47927001f, -0.54664880f, 
    0.23905332f, 0.47726491f, 0.29684746f, -0.10836913f, -0.16968900f, 0.08070662f, 0.14103524f, -0.47832605f, 
    -0.35343182f, 0.12221954f, 0.27600366f, -0.28609478f, 0.14995214f, -0.35709158f, -0.24556059f, -0.05588982f, 
    0.22925995f, 0.37423006f, 0.13384987f, 0.22347468f, -0.14935865f, -0.18590774f, -0.18839647f, 0.26000220f, 
    0.12969212f, 0.44079077f, -0.08268111f, -0.22934765f, 0.61872405f, 0.11395794f, -0.02406874f, 0.16196756f, 
    0.10367405f, -0.10066039f, 0.23551774f, 0.16549653f, -0.26749253f, -0.21709846f, 0.41826412f, 0.02580757f, 
    -0.02337585f, -0.01125293f, 0.08734752f, -0.24935085f, -0.07933320f, 0.05011147f, 0.09747771f, -0.01296458f, 
    0.29062709f, -0.48388931f, -0.12575635f, -0.18603837f, 0.33779529f, 0.23219714f, 0.59886551f, 0.12711689f, 
    0.47582021f, -0.43874043f, 0.08835243f, -0.22815906f, -0.10980563f, -0.15896446f, 0.29371488f, 0.03425651f, 
    -0.36220679f, 0.80456978f, 0.15529431f, 0.02888167f, -0.01698424f, -0.18024725f, -0.06353402f, -0.26501223f, 
    -0.20009956f, -0.07028736f, 0.36332884f, -0.33171636f, -0.05138139f, -0.30523697f, -0.24560085f, 0.38031697f, 
    0.33499625f, -0.12672636f, 0.27723107f, 0.50085443f, 0.11887032f, -0.39182785f, 0.38046715f, 0.30249646f, 
    0.46601126f, 0.03769502f, -0.08333054f, -0.07126853f, 0.02724971f, 0.06468140f, -0.14521873f, -0.10441481f, 
    -0.08200575f, -0.08101526f, -0.12876694f, 0.04798311f, 0.15171969f, -0.12639804f, -0.10533715f, -0.16726109f, 
    -0.07220349f, 0.16463479f, -0.14795104f, 0.13723928f, 0.02883093f, 0.17060059f, -0.07521923f, -0.04880084f, 
    -0.13872266f, -0.05671065f, -0.13645139f, 0.02514510f, -0.16517484f, -0.13370004f, -0.03255490f, 0.15325512f, 
    0.16905384f, -0.04016986f, -0.01642155f, -0.04314607f, -0.02979738f, -0.14858808f, -0.01816217f, -0.04832876f, 
    0.53440171f, 0.11715369f, -0.18958893f, -0.11689069f, -0.14954545f, 0.06369907f, 0.10285597f, 0.11692355f, 
    -0.10874239f, 0.05121341f, 0.11076633f, 0.16897228f, -0.08083580f, -0.41593659f, -0.44246697f, 0.05371904f, 
    -0.06659986f, 0.65102893f, 0.22337170f, 0.20492153f, 0.04385675f, 0.01661224f, -0.24861571f, 0.28297764f, 
    -0.77408266f, 0.43665072f, 0.01402097f, 0.24805528f, 0.13766865f, 0.28758445f, -0.26583081f, -0.33348066f, 
    -0.02443188f, -0.31213009f, 0.25250012f, -0.28827894f, -0.04712005f, -0.17627813f, 0.09129411f, 0.03737685f, 
    -0.35084540f, 0.00224631f, 0.27597106f, -0.00554187f, -0.10650683f, 0.80130595f, 0.37810597f, 0.20839478f, 
    0.15219125f, 0.11598822f, 0.17686093f, -0.29896688f, 0.35393584f, 0.31806326f, 0.07200968f, 0.36560464f, 
    0.15889080f, -0.26874670f, 0.08890382f, 0.06317812f, -0.01096831f, -0.13591212f, -0.08865386f, 0.62138587f, 
    0.24033155f, 0.27449700f, 0.30701196f, 0.36099985f, -0.03561689f, 0.35142308f, 0.41446736f, -0.16336516f, 
    -0.02308335f, 0.19639482f, 0.11520354f, -0.51319808f, 0.12259155f, -0.40906349f, 0.19976084f, 0.12236949f, 
    -0.04751153f, -0.41062060f, 0.38007984f, -0.06720378f, -0.20184048f, -0.08570733f, 0.55510688f, -0.15503810f, 
    0.89026374f, 0.13225682f, -0.10030413f, -0.09898899f, 0.84379381f, 0.38808256f, -0.02170743f, 0.11308851f, 
    0.17890894f, 0.08011833f, -0.01270002f, -0.15455495f, 0.18781962f, -0.22402082f, 0.34410909f, -0.38491485f, 
    0.42120272f, 0.04128557f, 0.24934858f, -0.07077558f, 0.05887030f, 0.17865737f, 0.00264773f, 0.39382988f, 
    -0.21845454f, -0.00660946f, 0.09089444f, -0.01019073f, -0.00370302f, -0.24317892f, -0.16562144f, 0.23305722f, 
    0.00869949f, -0.13745233f, 0.06376817f, 0.13896567f, 0.46405098f, 0.24090996f, -0.00215510f, -0.32067320f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.22689241f, 0.17924844f, 0.56511801f, 0.37593463f, 0.05911328f, -0.02464581f, -0.11821305f, -0.27527291f, 
    0.27062735f, -0.19092357f, 0.37729707f, 0.48676577f, 0.36804670f, 0.15240531f, -0.19618259f, -0.33664316f, 
    -0.28391230f, 0.43705058f, -0.64199203f, 0.14637537f, 0.14769888f, -0.00823785f, -0.09048314f, 0.18870410f, 
    0.17244942f, 0.50334811f, 0.17389575f, -0.14933152f, 0.42062297f, 0.40800339f, 0.25242093f, 0.32766870f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.46016222f, 0.06813590f, -0.02965767f, 0.01999111f, -0.02146481f, -0.59327221f, 0.40909618f, -0.35985065f, 
    -0.20532885f, -0.09544724f, -0.26214755f, -0.10119309f, 0.07193360f, -0.38989392f, -0.38631135f, -0.16869041f, 
    0.20145179f, 0.35176879f, -0.81478858f, -0.48376024f, -0.28174061f, -0.80590737f, 0.13738911f, -0.03663933f, 
    0.54303163f, -0.25498527f, 0.17449076f, 0.01926250f, 0.51701510f, 0.00237832f, 0.04721351f, -0.00225200f, 
    -0.44971797f, 0.25741771f, 0.20590200f, 0.23653498f, -0.06853549f, 0.07825965f, 0.41071653f, 0.16695346f, 
    -0.17910874f, -0.11624546f, -0.81301957f, -0.43604016f, -0.46807775f, 0.09363316f, 0.28069133f, 0.02928696f, 
    0.08472292f, -0.62170708f, 0.53716725f, 0.03332186f, -0.66322714f, 0.64083159f, -0.08863666f, -0.23643395f, 
    -0.04514860f, 0.18531799f, 0.06048301f, -0.00549675f, -0.23901224f, -0.02706989f, 0.35824877f, -0.27980301f, 
    -0.06489004f, 0.13839090f, 0.07170507f, -0.40497473f, 0.19702007f, 0.42849267f, -0.23655990f, 0.59394252f, 
    -0.44997492f, -0.01721730f, 0.36363792f, -0.21936058f, -0.13766938f, 0.01054965f, 0.27977201f, -0.84996331f, 
    -0.41644859f, -0.36085978f, -1.12466550f, 0.43813682f, 0.32764372f, -0.60144132f, -0.21550414f, 0.10318305f, 
    -0.74281728f, 0.24807532f, -0.53470999f, -0.01376518f, -0.01903841f, 0.25848496f, -0.30017799f, -0.65181863f, 
    0.24478433f, -0.35980758f, -0.18766430f, -0.54308194f, -0.57250315f, -1.14242005f, -0.46469837f, 0.21681911f, 
    0.01736763f, -0.00584230f, -0.31520790f, -0.04389740f, 0.17543474f, 0.05922924f, -0.60900170f, 0.27723381f, 
    -0.26234582f, 0.26012215f, 0.25200486f, 0.15837856f, 0.29374802f, -0.52203250f, -0.14874829f, 0.33696899f, 
    -0.26240331f, -0.07034823f, 0.06321827f, 0.16319765f, -0.02334503f, -1.14570951f, -0.06150445f, -0.15394713f, 
    -0.16426979f, -0.00572437f, 0.06664926f, -0.16041565f, 0.28066149f, -0.29240519f, -0.17302461f, -0.09494762f, 
    -0.69602901f, -0.09450405f, 0.21596907f, -0.05960067f, 0.02915690f, 0.01925397f, 0.42770287f, 0.11572506f, 
    -0.34937447f, 0.32874593f, -0.16278599f, -0.28474596f, 0.10484661f, -0.23010641f, -0.16416821f, -0.00929008f, 
    0.02879133f, -0.09366892f, 0.15424940f, 0.16248655f, 0.03633392f, -0.21858208f, -0.02881328f, 0.40179688f, 
    -0.12032926f, -0.02689949f, -0.01305505f, 0.06265690f, 0.16724969f, 0.09419975f, 0.30216643f, -1.16723764f, 
    -0.18873616f, -0.08301672f, -0.04663247f, -0.00482532f, 0.25916496f, 0.12696950f, 0.08360925f, 0.02476284f, 
    -0.59234428f, -0.48684520f, 0.14903507f, -0.55018151f, -1.31793225f, -0.16280314f, -0.09467912f, -0.13105251f, 
    -0.17927697f, 0.30625632f, 0.22836401f, -0.03289372f, -0.39369273f, 0.13172355f, 0.14908960f, 0.33642688f, 
    -0.20279455f, -0.03271395f, 0.01191253f, -0.10661986f, 0.14859298f, 0.38637039f, -0.25947589f, -0.43152782f, 
    -0.32612494f, 0.15651245f, -0.46480978f, -0.48235884f, 0.40827656f, -0.31794146f, -0.10716083f, 0.12928326f, 
    -0.34746072f, -0.25342780f, -1.23301959f, 0.53110099f, 0.19623058f, -0.44695130f, -0.09912357f, -0.33887476f, 
    0.17073019f, 0.32969525f, 0.12190636f, -0.13281618f, -0.12576190f, 0.36781859f, 0.05769607f, -0.13784078f, 
    0.08153898f, -0.71476728f, -0.87963259f, -0.47334448f, 0.31023976f, 0.50489861f, 0.37597758f, 0.27083069f, 
    0.00528002f, 0.04255132f, -0.29856437f, 0.11541522f, -0.20673047f, -0.37131637f, 0.11870118f, 0.24503751f, 
    0.24550614f, 0.06214335f, 0.39361510f, -0.86941814f, -0.25469080f, 0.09377611f, -0.01793155f, -0.29750100f, 
    -0.46447271f, -0.79083014f, 0.19429474f, -0.01710151f, -0.09276868f, -0.05184641f, -0.71268564f, -0.30348974f, 
    0.03195328f, -0.22344172f, 0.19163874f, 0.27571684f, -0.49205849f, 0.15191026f, -0.09934615f, -0.11106969f, 
    0.42326635f, -0.15736969f, 0.04122135f, -0.53047371f, -0.65356785f, 0.47280499f, 0.18406576f, -0.34830168f, 
    0.58825296f, -1.35518146f, 0.08247047f, -0.13026893f, -0.62829691f, -0.20174368f, -0.00680094f, 0.24735889f, 
    -0.11386313f, -0.59531206f, -0.46036765f, 0.01134359f, 0.20950529f, -0.23186068f, 0.11563371f, -0.06383289f, 
    -0.00804642f, 0.00081576f, 0.24097799f, -0.02521749f, 0.25176036f, -0.05919232f, -0.54020190f, -0.24621011f, 
    0.05371922f, -0.12492818f, 0.51249969f, -0.03973928f, 0.05506232f, -0.02943051f, -0.32178408f, -0.00365404f, 
    -0.97826844f, 0.11281544f, 0.14105301f, -0.31754276f, 0.11480018f, -0.43177420f, -0.05758077f, -0.51882094f, 
    0.01310261f, 0.32762653f, 0.14264575f, 0.03822401f, -0.25201494f, 0.02571840f, 0.17900488f, -0.25775126f, 
    0.20207027f, -0.72639912f, 0.18795225f, -0.31504625f, -0.73084176f, -0.42331162f, -0.35373276f, 0.14317663f, 
    0.33732074f, -0.21806614f, -0.40221757f, 0.12174658f, 0.04402572f, 0.08005474f, 0.44609171f, -0.20658661f, 
    -0.42116076f, -0.01087927f, -0.06806853f, 0.36743635f, 0.18047655f, -0.07287655f, -0.14182138f, 0.20234914f, 
    -0.63827270f, 0.08524289f, -0.31753328f, -0.07672852f, 0.54864568f, -0.16173755f, -0.35952118f, 0.22740641f, 
    0.16230141f, -0.08968427f, 0.05646074f, 0.37605968f, -0.10684935f, 0.05985175f, -0.22676648f, 0.14386171f, 
    0.16839112f, -0.18673944f, 0.27184033f, 0.20416583f, -0.04291048f, -0.06670388f, -0.49445611f, -0.27970010f, 
    0.30867812f, -0.18865150f, -0.45322600f, -0.01605787f, 0.32670671f, 0.67294109f, -0.16350754f, -0.05007998f, 
    -0.21344191f, 0.09042633f, -0.41574419f, 0.11660239f, -0.41704643f, 0.34508458f, -0.28098905f, -0.20444776f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    0.40075645f, -0.07208025f, 0.03949429f, -0.00396573f, -0.14770615f, 0.36876133f, -0.26505405f, -0.41476482f, 
    -0.24375148f, 0.31997898f, 0.09640314f, 0.29908922f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
