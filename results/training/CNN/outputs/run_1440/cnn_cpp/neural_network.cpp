#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.53506362f, 0.42483449f, 0.91918695f, -0.76076257f, -0.46278217f, -0.30382702f, -0.03219907f, 0.45813179f, 
    -0.08856142f, 0.52153265f, -0.14300615f, -0.07067182f, -0.86253232f, -0.63118082f, -1.21013045f, 0.04288435f, 
    -0.78094101f, -0.21423788f, -1.28726137f, -0.88367909f, -0.43869063f, 1.04712903f, -0.27247381f, -0.34054750f, 
    -0.28615609f, -0.62752700f, -0.74037617f, -1.09115922f, -0.35269409f, 0.81119233f, -0.64712286f, -0.25283152f, 
    -0.44832897f, -0.54731637f, -0.49611801f, -0.72495222f, -0.62188286f, -0.16129284f, -1.21247756f, 0.84040320f, 
    0.65837598f, 0.73339111f, -0.43462762f, -0.38333276f, -0.33974949f, -0.38756436f, -0.25332454f, -0.27235141f, 
    0.58390385f, 1.12316966f, 0.63308811f, 0.21820146f, 0.49945775f, -0.16908802f, 0.50367701f, -1.15201592f, 
    0.87415153f, -0.00674171f, -0.27954268f, 0.35616645f, 0.34459758f, -0.29991153f, 0.44614699f, 0.33238649f, 
    0.47606835f, 0.34969503f, -0.16715613f, 0.92970544f, -0.94343632f, 0.43420631f, -0.25056502f, -0.08524528f, 
    0.95635480f, -0.71104753f, -1.31262577f, 0.03137553f, 0.28636393f, 0.45585352f, -0.00593023f, 0.50863421f, 
    0.24003123f, -0.80923754f, 0.11062422f, 0.78778833f, 0.74656808f, 0.50095487f, -0.82167381f, -0.17890175f, 
    0.24219038f, -0.27298456f, -0.50454372f, 0.30014530f, 0.58914977f, -1.02759004f, -0.05778468f, 1.28153265f, 
    0.03239599f, 0.29154465f, -0.03216847f, -0.32639927f, 0.01806031f, 0.18117160f, -0.56236130f, -0.87426066f, 
    -0.99762136f, 0.55615258f, 0.56928742f, 0.06322800f, -1.35278416f, -0.58924848f, 1.24188089f, 0.36951953f, 
    0.09021673f, -0.80036634f, 0.25588572f, 0.40623084f, -0.39609143f, -0.81291008f, -0.81180543f, -0.75028211f, 
    0.39528659f, 0.17170694f, -0.09354353f, 0.46639934f, 0.76103199f, 0.41426826f, 0.70254815f, 1.14291441f, 
    -1.06289947f, -0.32482302f, -0.30627057f, 0.42800349f, -0.09809844f, -0.08991485f, -0.07402317f, -0.20651454f, 
    -0.34265599f, 0.28783262f, -0.76581645f, -0.44904324f, -0.98685950f, 0.73927671f, 0.62726653f, 0.47137958f, 
    -0.33112130f, -0.10806528f, -0.31229755f, 0.38897270f, 0.09921445f, 0.54836899f, 0.63151145f, 0.10609630f, 
    0.27916571f, -0.38780579f, -0.03372201f, -0.25113508f, -0.19174267f, -0.93659014f, -1.08803344f, 0.07616211f, 
    -0.85044426f, 1.19486892f, 0.40874699f, -1.09671056f, 0.56703794f, -0.56999648f, -0.17074735f, 0.15596020f, 
    -0.45313963f, -0.41982773f, -0.34135288f, 0.05677169f, 0.31905735f, 0.86880231f, -0.25331178f, -0.91797245f, 
    0.84005445f, -0.22066277f, -0.10885920f, -0.11516833f, 0.77636898f, 0.87891632f, -0.39184061f, 0.37940019f, 
    0.40897751f, 0.06721670f, -0.60218477f, -0.23712571f, 0.04484800f, -0.38231936f, 1.04904330f, -0.06960639f, 
    -0.35652044f, 0.42225239f, 0.44134951f, -0.05949557f, 0.27414179f, 0.95846844f, -0.91044956f, 0.16584128f, 
    -1.11034322f, 0.01424325f, -0.58820361f, -0.85507053f, -0.16257787f, -0.41705957f, -0.26672456f, -0.76628846f, 
    -0.96664292f, -0.29078269f, -0.14737481f, -0.38796967f, -0.35210815f, -0.38635486f, -0.44568473f, 0.58718878f, 
    -0.57090753f, -0.15730107f, -0.14263569f, -0.09598401f, 0.81594396f, -0.81982917f, 0.69800115f, -0.09942182f, 
    0.62340844f, -0.01266384f, -0.84258842f, 0.49777123f, 0.63604659f, -0.81695271f, 0.96756750f, -0.42986920f, 
    -0.62562931f, -0.27273169f, 0.93845934f, 0.90176386f, -0.13874298f, 0.08077814f, -0.66234100f, -0.71191126f, 
    0.08327217f, 0.20003170f, 0.01663430f, -0.51945931f, -0.76768905f, -0.10726681f, -0.77606207f, 0.07890347f, 
    1.36674345f, -0.21681795f, -0.05864436f, -0.29349694f, 0.28567517f, 0.78088027f, 0.59318054f, 0.19079520f, 
    -0.46451116f, 0.65782255f, 0.31967154f, -0.45962277f, -0.60669261f, 0.32212386f, 0.69366330f, 0.59881335f, 
    -0.39105949f, 0.24828959f, -0.07389743f, -0.14510264f, 0.92009330f, -0.75696659f, 0.84812415f, 0.15812704f, 
    -0.36636695f, 0.85821509f, 0.26451579f, 0.17690097f, -0.01038595f, 0.98665202f, -0.68756473f, 0.67903948f, 
    0.45831239f, 0.51464689f, -0.30148426f, -0.55805951f, 0.28531027f, -0.27207261f, -0.54758793f, 0.69326687f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.17330089f, -0.18265519f, -0.24031779f, -0.39088506f, 0.09940581f, -0.03828315f, 0.35728899f, 0.53000343f, 
    0.24254493f, 0.27633089f, 0.29511318f, 0.43458754f, 0.13334413f, 0.28284830f, 0.15208280f, 0.01535978f, 
    0.54455465f, -0.12166503f, 0.49209371f, 0.09090707f, -0.36673293f, 0.12182477f, 0.26717359f, 0.02447597f, 
    -0.03456384f, 0.17080042f, 0.21779691f, 0.63470703f, -0.09151689f, -0.05055784f, 0.43002254f, 0.00396688f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.34220788f, 0.22833344f, 0.27498460f, -0.14309177f, 0.15365675f, -0.12720750f, -0.12474532f, 0.06623480f, 
    -0.02075230f, 0.08225130f, 0.14666471f, 0.55264843f, 0.12304713f, -0.05496801f, 0.17903976f, -0.03783051f, 
    0.00588893f, 0.09811388f, -0.58072996f, -0.22783306f, 0.43661594f, 0.03495940f, -0.01805986f, 0.03737170f, 
    -0.11050316f, -0.13014209f, -0.14393988f, -0.05584568f, -0.11849912f, 0.10538208f, 0.03598294f, 0.18216987f, 
    -0.00738092f, -0.05534656f, 0.06575679f, 0.07287502f, -0.29526785f, 0.20229097f, -0.02970596f, 0.03721669f, 
    -0.05710588f, -0.26440141f, -0.16637109f, -0.22770143f, -0.18720762f, 0.01479441f, 0.09006898f, 0.04625184f, 
    0.11074707f, 0.16223928f, 0.11158408f, -0.03769149f, -0.01062064f, 0.13645683f, 0.07366490f, 0.10603324f, 
    0.05243118f, 0.03482711f, -0.06367695f, 0.12400172f, 0.03010196f, -0.03810195f, 0.17206621f, -0.03603437f, 
    0.16579558f, -0.16033472f, -0.04207906f, 0.01283265f, -0.12895820f, -0.02553204f, -0.00110169f, -0.17222783f, 
    -0.22083059f, 0.06363101f, 0.02529988f, 0.01089206f, -0.10026688f, 0.04073193f, -0.08516862f, -0.06279185f, 
    0.12795538f, -0.37733209f, -0.01848460f, 0.07678925f, -0.06742045f, 0.13284606f, -0.18328553f, 0.06911731f, 
    -0.03148628f, -0.20430951f, -0.02041548f, 0.18736431f, -0.25033772f, -0.15927365f, -0.02424255f, 0.09832998f, 
    -0.03367586f, 0.06278976f, -0.03878630f, 0.06146225f, 0.10013603f, 0.04437339f, 0.02044774f, 0.07392282f, 
    -0.05052626f, -0.03475704f, 0.19783103f, 0.01850643f, 0.04231085f, 0.13165374f, 0.11969773f, -0.27353665f, 
    0.34479105f, 0.07528277f, 0.11256935f, 0.17667538f, -0.01511653f, 0.04475816f, -0.06547803f, -0.11399709f, 
    -0.06094666f, -0.35391477f, -0.22339486f, 0.21762158f, 0.08205806f, -0.00077214f, 0.07032540f, -0.18033478f, 
    -0.06926382f, 0.12787147f, 0.21524858f, 0.06473516f, -0.08403171f, -0.11334106f, 0.04079111f, 0.19082901f, 
    0.11158810f, 0.02980326f, -0.20317362f, -0.07880757f, -0.15144362f, 0.07368323f, 0.19126472f, 0.10477345f, 
    -0.02553641f, 0.12679547f, -0.01349066f, 0.05145597f, 0.02396339f, 0.02532307f, 0.05470597f, 0.09498634f, 
    0.05699076f, 0.02787453f, 0.54147851f, 0.37983978f, 0.18363579f, -0.01323396f, 0.10024883f, 0.09188994f, 
    -0.08098008f, 0.09109014f, 0.13300774f, -0.09869269f, 0.04603160f, 0.13593382f, -0.02727624f, 0.22064321f, 
    -0.17399971f, -0.04125567f, -0.01171004f, -0.15419334f, -0.23894809f, -0.04822605f, 0.02699390f, -0.04800424f, 
    -0.00876942f, -0.11171855f, -0.14130251f, -0.08406925f, 0.00080570f, -0.08867487f, -0.02370076f, 0.31857270f, 
    0.01277837f, -0.00534169f, 0.01819397f, -0.01325199f, 0.00572690f, 0.03364252f, 0.18844096f, -0.02606063f, 
    -0.00676616f, 0.18979715f, -0.06624416f, -0.17962860f, 0.15782650f, 0.20819373f, 0.01710651f, 0.08792809f, 
    0.28235897f, 0.04411842f, 0.03638277f, 0.15311012f, -0.01467501f, 0.00548404f, 0.04910764f, 0.09543018f, 
    0.17498603f, -0.00768928f, -0.04598629f, -0.07970475f, 0.09325381f, 0.06444414f, -0.09685649f, 0.04088114f, 
    0.08342407f, 0.23894876f, 0.29216197f, 0.17090973f, -0.09658856f, -0.10441517f, 0.13281949f, 0.26399136f, 
    0.19839129f, -0.23028848f, 0.17321593f, 0.14930782f, 0.10798166f, -0.01314557f, -0.07590073f, -0.44853356f, 
    -0.21732409f, -0.02289014f, -0.33610758f, -0.06594700f, -0.02206878f, 0.02823516f, 0.06590791f, 0.07018045f, 
    0.01549910f, 0.29014602f, 0.08068386f, 0.24147916f, 0.47313294f, -0.22561711f, 0.04179648f, -0.09697151f, 
    -0.02348771f, -0.04874104f, -0.11741292f, -0.14918587f, -0.25610217f, -0.16084832f, -0.06305618f, 0.02509640f, 
    -0.06191117f, -0.04372681f, 0.08267318f, -0.14511043f, -0.15141736f, -0.09559631f, 0.22010477f, 0.21163863f, 
    -0.01306787f, 0.23846509f, -0.01401596f, 0.03261318f, 0.26333785f, -0.33007458f, -0.13051200f, 0.01575115f, 
    0.02619117f, 0.10845474f, 0.02200584f, 0.13877825f, -0.19292694f, 0.13617451f, -0.08959419f, -0.16296197f, 
    0.02340469f, 0.08393436f, 0.03267594f, 0.00995807f, 0.05549018f, -0.01526608f, -0.16556014f, 0.02751140f, 
    -0.04022645f, -0.07501150f, 0.16660714f, 0.02360316f, -0.06025407f, -0.01747964f, 0.18841775f, 0.09301140f, 
    0.10375939f, -0.12851986f, 0.07650066f, 0.19917347f, -0.31948358f, 0.05333843f, 0.11867875f, -0.15703867f, 
    0.15684496f, 0.05380366f, 0.36518419f, 0.02690843f, -0.35036865f, 0.13369960f, 0.00034905f, 0.05228608f, 
    -0.04312505f, 0.00447140f, -0.00691346f, 0.55957782f, 0.26133218f, -0.03087126f, 0.14035244f, 0.26040125f, 
    0.28362316f, -0.06875713f, -0.05681888f, -0.10032254f, 0.37164626f, -0.39656663f, -0.56071991f, -0.04245701f, 
    -0.02061698f, -0.07301859f, 0.04397667f, 0.00866976f, -0.29179096f, 0.11777490f, -0.38096681f, -0.44396180f, 
    0.09317945f, 0.12156614f, 0.09662195f, 0.10721841f, 0.01488654f, 0.15299597f, -0.01378244f, 0.04173584f, 
    -0.29320356f, 0.15938906f, 0.09361368f, -0.14132001f, 0.26977935f, -0.11264723f, -0.14145076f, -0.67663842f, 
    -0.33631039f, -0.14683822f, -0.04972168f, -0.08772826f, -0.25032127f, 0.07669140f, 0.02687014f, 0.17816219f, 
    -0.25776276f, -0.36020088f, -0.34372914f, -0.06683717f, -0.21275397f, 0.13699351f, 0.23522073f, 0.09579516f, 
    0.04694010f, -0.14223593f, 0.34638768f, -0.12266252f, -0.09098878f, -0.02255349f, 0.03430000f, 0.10654780f, 
    -0.01952558f, 0.12416545f, 0.05819157f, -0.06409583f, -0.14573149f, -0.16384482f, -0.28305808f, -0.39918259f, 
    -0.04086978f, 0.04825658f, -0.01146511f, 0.33246902f, 0.17622390f, 0.18752515f, -0.09978919f, -0.07571511f, 
    0.06847204f, 0.06713273f, 0.06298849f, 0.03603428f, 0.20570095f, 0.31047332f, -0.26860842f, 0.17003369f, 
    -0.06248192f, 0.03101636f, 0.04758231f, -0.09404247f, 0.07470846f, -0.01421922f, 0.00771803f, -0.30153421f, 
    0.14847200f, 0.11543772f, 0.11991873f, 0.03463967f, 0.11631350f, 0.22276512f, 0.03422173f, -0.45362878f, 
    -0.05025259f, -0.35210505f, -0.02427011f, 0.05706726f, 0.03367135f, 0.04940086f, -0.04838547f, 0.44422847f, 
    0.31112382f, -0.01479246f, -0.01247832f, -0.17223765f, 0.07477754f, 0.15046924f, 0.02499899f, 0.08268521f, 
    -0.09686929f, -0.15065983f, -0.28467560f, 0.23321237f, 0.06810343f, 0.02037927f, 0.03127242f, 0.05343437f, 
    0.05896603f, 0.47340253f, 0.31909856f, 0.13960451f, -0.16941637f, -0.38648397f, 0.24404119f, 0.06469193f, 
    0.16219495f, 0.14615421f, -0.08145494f, 0.14392437f, -0.00742465f, 0.19175260f, 0.00682851f, -0.03131703f, 
    -0.12827152f, -0.11137071f, -0.03729333f, -0.27443662f, -0.17114370f, 0.25559399f, -0.01999553f, -0.18799999f, 
    -0.18420358f, 0.04335042f, -0.01299496f, 0.16506714f, -0.33851260f, -0.16100605f, 0.17897853f, -0.06457637f, 
    0.12156176f, -0.05459786f, 0.23639023f, -0.19388241f, -0.03440645f, 0.17614421f, -0.24703828f, -0.34389976f, 
    0.05587275f, -0.11195666f, -0.11923285f, 0.07493978f, 0.28462693f, 0.03531339f, 0.30694607f, 0.08583857f, 
    -0.18693417f, 0.21087413f, -0.01944729f, 0.14903677f, -0.04876558f, 0.04918604f, -0.10651472f, 0.28898224f, 
    0.00537158f, -0.17776242f, 0.20926920f, -0.06466980f, 0.07709330f, -0.10446480f, 0.01985762f, 0.04822113f, 
    0.36676368f, 0.06424928f, -0.22705415f, 0.14718227f, -0.13081700f, -0.00598850f, 0.07271074f, 0.21233396f, 
    0.11585413f, 0.03076946f, -0.02199446f, -0.17484392f, 0.07666274f, 0.01335282f, 0.09933627f, 0.22615683f, 
    -0.08529171f, -0.27693790f, -0.73189276f, -0.40990952f, 0.30671439f, -0.18543474f, 0.12435914f, 0.00194021f, 
    0.20162220f, 0.09508539f, 0.06210929f, 0.10765331f, -0.23913942f, -0.12557636f, 0.15809405f, -0.04843500f, 
    -0.14454681f, -0.07195506f, -0.12894091f, -0.13906692f, -0.59866357f, -0.16223046f, 0.23902473f, -0.00777675f, 
    -0.00004204f, 0.01778209f, -0.05428531f, 0.01229266f, -0.00355515f, -0.46482185f, -0.12391771f, 0.14900562f, 
    0.06670758f, -0.03911052f, -0.11860962f, -0.01813380f, 0.07990788f, 0.14507525f, -0.30173650f, -0.15192722f, 
    0.23007801f, -0.04067363f, -0.04930165f, -0.08793463f, 0.14346080f, 0.11476568f, 0.01906285f, -0.45666099f, 
    -0.30876678f, 0.22466734f, 0.17304370f, -0.04652599f, -0.21391593f, 0.16995928f, 0.01949979f, 0.01019086f, 
    0.12013813f, -0.41012150f, 0.01493539f, 0.08383908f, 0.05019473f, 0.03237490f, 0.15067820f, 0.01201875f, 
    0.10716693f, -0.36955103f, -0.31197381f, -0.33717936f, -0.18311086f, -0.00274911f, 0.07981355f, 0.06160371f, 
    -0.00688950f, -0.01644857f, 0.25705433f, 0.24724330f, -0.02038513f, 0.00096348f, -0.13366213f, 0.25176805f, 
    -0.08906405f, -0.13189223f, -0.11536587f, 0.23202074f, -0.00912692f, 0.11068778f, 0.14545214f, 0.05168066f, 
    0.36947298f, 0.16484639f, 0.10936740f, -0.02869213f, 0.32077196f, -0.05498571f, -0.27932537f, -0.11754198f, 
    -0.18685517f, -0.04614149f, -0.13583837f, -0.13939683f, -0.21292447f, 0.07710239f, -0.08708312f, -0.07281335f, 
    0.13612795f, -0.00173824f, 0.01443268f, 0.07682636f, 0.06775393f, 0.07909876f, -0.08719299f, -0.06547742f, 
    -0.00237691f, -0.03141107f, 0.19590266f, 0.04627325f, -0.10033310f, 0.12587872f, 0.01503140f, -0.35015401f, 
    -0.13656260f, -0.14735548f, 0.14187191f, 0.07042391f, 0.06198235f, 0.10537326f, 0.03779549f, -0.00989945f, 
    -0.00392816f, 0.10528893f, -0.21074818f, 0.02088167f, 0.12802871f, 0.19709614f, 0.13495013f, 0.14322850f, 
    0.11306982f, -0.29442814f, 0.37682059f, -0.11449698f, -0.02160944f, -0.07887411f, -0.03562039f, 0.09274802f, 
    0.08627063f, 0.05697631f, 0.13964511f, -0.14608069f, 0.38036931f, -0.02493322f, 0.06701501f, -0.17780060f, 
    0.13854128f, 0.10182676f, -0.06814587f, 0.42554641f, -0.06632037f, 0.07542217f, 0.00480881f, -0.07445450f, 
    -0.02896237f, 0.11607712f, 0.04838419f, 0.07703787f, 0.04188887f, 0.30090359f, -0.02342131f, 0.24554709f, 
    -0.33326155f, 0.12500374f, 0.18192293f, -0.14248520f, -0.04458254f, -0.03357245f, 0.05751633f, -0.17136262f, 
    0.12149600f, -0.00345941f, 0.02006792f, -0.00052478f, -0.03453140f, 0.06275006f, -0.11446550f, -0.42352247f, 
    -0.21780777f, 0.04148602f, -0.05631544f, -0.01362310f, 0.13730830f, -0.04451183f, -0.07714979f, 0.25137547f, 
    -0.04584504f, 0.12129972f, -0.09805454f, -0.01017358f, -0.08930124f, 0.06499029f, 0.07318178f, 0.01457936f, 
    0.06639162f, 0.03711897f, -0.01873678f, 0.09788518f, 0.03799000f, -0.01510843f, 0.05232845f, 0.17154524f, 
    0.11222362f, 0.11430210f, -0.03057703f, -0.23450094f, 0.03189730f, -0.03360695f, -0.09898771f, 0.10047571f, 
    0.03568428f, 0.16076557f, 0.00627576f, -0.05202782f, 0.18636629f, 0.08519121f, 0.05492836f, 0.13793232f, 
    0.03427291f, 0.09728910f, -0.02415764f, -0.17778422f, -0.36429036f, 0.56393927f, 0.08360039f, 0.06965863f, 
    -0.05583638f, -0.00501744f, -0.09164920f, -0.06804433f, -0.25150469f, -0.32500082f, -0.22041330f, -0.03434686f, 
    -0.02048352f, 0.07485106f, 0.10360888f, -0.07108869f, -0.11446130f, 0.04505067f, 0.01423233f, 0.22030286f, 
    0.09128573f, -0.20055388f, 0.04149379f, 0.00334322f, 0.29677257f, 0.10821911f, 0.11566652f, 0.15062548f, 
    -0.07463402f, 0.16418521f, 0.16797239f, 0.26539069f, -0.00007841f, -0.03118176f, -0.08704869f, 0.17792012f, 
    0.10901842f, -0.07718800f, 0.10001872f, -0.09317531f, 0.09726846f, 0.19277674f, -0.07189284f, 0.02731366f, 
    -0.04453940f, -0.08337023f, -0.20307590f, 0.20269644f, -0.13158159f, 0.10068896f, -0.04882094f, 0.13819346f, 
    0.03743728f, -0.03595276f, -0.14784470f, 0.18734820f, 0.00217351f, -0.05836787f, 0.13231468f, -0.14092983f, 
    -0.09505134f, -0.46151295f, -0.39019790f, -0.43493780f, -0.00501905f, 0.02124921f, 0.01493441f, -0.00959743f, 
    0.08656204f, -0.09626688f, -0.04342110f, 0.19634171f, -0.07140678f, 0.11104293f, -0.22626570f, -0.08097048f, 
    0.02717315f, 0.06293537f, 0.00406890f, -0.04959138f, -0.36459398f, -0.32818198f, 0.15277305f, -0.01225484f, 
    0.09091289f, 0.09944707f, -0.05311045f, -0.03234493f, -0.06376487f, -0.22659773f, -0.35519919f, -0.05106037f, 
    -0.00363120f, 0.01773683f, 0.02728657f, 0.11878359f, 0.05338340f, -0.09142821f, -0.13107337f, -0.05187763f, 
    -0.05065480f, 0.08479897f, 0.01475520f, -0.01259145f, 0.00280981f, -0.15017428f, 0.02953615f, -0.51703525f, 
    -0.41986862f, 0.12682636f, 0.16349795f, -0.01561063f, 0.06549464f, -0.01287387f, 0.04247548f, 0.11187864f, 
    -0.08908734f, -0.49322233f, -0.15566269f, -0.09762496f, -0.24392219f, -0.03598047f, 0.06654642f, 0.02895457f, 
    0.00522901f, 0.09284505f, 0.48101622f, 0.17770767f, -0.01717251f, -0.13371873f, -0.08984825f, -0.05671451f, 
    -0.13771206f, 0.03751611f, 0.67023158f, 0.22836044f, 0.31650755f, 0.01998121f, 0.07503653f, 0.04346894f, 
    0.25859368f, -0.04793051f, -0.23141371f, 0.15324524f, 0.15152052f, 0.18719484f, -0.04895732f, 0.04047617f, 
    -0.01937574f, 0.31822810f, -0.00717552f, -0.06397114f, -0.11287544f, -0.06860834f, -0.03283694f, 0.10846009f, 
    0.04553712f, 0.01805976f, 0.18683195f, 0.01748384f, -0.02850290f, -0.11423551f, -0.48627359f, -0.52326894f, 
    -0.31863743f, -0.06425422f, 0.29505134f, 0.23446377f, 0.02704730f, 0.34335592f, -0.34451446f, -0.17189424f, 
    -0.42707080f, -0.30648154f, 0.39649081f, -0.12401474f, 0.04347540f, 0.07925751f, 0.07388049f, -0.24457866f, 
    -0.45095256f, -0.05157809f, -0.07315066f, -0.36213183f, -0.12415644f, 0.04741569f, -0.00850767f, -0.13570440f, 
    0.39589268f, -0.26825842f, -0.67309165f, 0.12328142f, 0.07872459f, -0.10344671f, 0.09694967f, 0.06874768f, 
    0.07412995f, -0.27011055f, -0.47145382f, -0.00895314f, -0.11884186f, -0.37543809f, 0.09112138f, 0.13020770f, 
    0.14250325f, -0.15184170f, -0.19661309f, -0.58289129f, -0.07928818f, 0.10603093f, -0.09646617f, -0.06988113f, 
    0.13636836f, 0.17908128f, 0.31381539f, 0.05718248f, 0.15359497f, 0.44555730f, -0.19897453f, -0.04132211f, 
    0.01401126f, -0.09129881f, 0.11721233f, 0.16194212f, 0.50136334f, -0.14192796f, 0.22143722f, -0.19646652f, 
    -0.06287892f, 0.02657006f, -0.12617393f, 0.22485138f, 0.10381373f, 0.24262881f, 0.07314257f, 0.25925431f, 
    -0.07295906f, 0.09153026f, 0.24297705f, -0.04665877f, -0.19050474f, 0.06933677f, -0.23195003f, 0.08305247f, 
    -0.87710136f, -0.41324967f, -0.26430890f, 0.11616016f, 0.08422917f, 0.19961858f, -0.20208724f, 0.11935364f, 
    0.24449870f, 0.58487034f, -0.13485697f, -0.06146134f, -0.18609793f, -0.14794366f, 0.15773280f, 0.11563434f, 
    -0.02190112f, -0.40081042f, -0.37199330f, 0.00818401f, 0.00575465f, 0.08588657f, 0.07678504f, 0.00669758f, 
    -0.02274891f, 0.34779656f, 0.47290596f, 0.11799780f, -0.25820178f, -0.01683500f, -0.10558743f, 0.01036427f, 
    0.06595369f, 0.14295089f, 0.28272921f, 0.07632636f, 0.03851866f, 0.12171954f, 0.01459040f, -0.14902222f, 
    0.05198065f, -0.08702280f, -0.00670214f, -0.52424109f, -0.00383453f, -0.30496305f, -0.20315045f, -0.42825174f, 
    -0.01803746f, 0.02305035f, -0.05144874f, 0.17244320f, 0.48695123f, 0.24526431f, 0.10256276f, 0.19570486f, 
    0.09410453f, -0.30133215f, 0.00876855f, -0.06334877f, -0.08600816f, 0.12975852f, -0.44368520f, -0.78534359f, 
    -0.06215006f, -0.13811471f, 0.31325006f, 0.20904078f, -0.22171806f, 0.12939118f, 0.20566645f, 0.46744761f, 
    0.38600034f, -0.14949584f, 0.27492225f, 0.17910677f, 0.13863692f, 0.06385291f, -0.07326557f, 0.65533477f, 
    0.34191537f, 0.20969927f, -0.09632080f, 0.30042791f, 0.20561668f, 0.18747544f, 0.06994896f, 0.08819191f, 
    -0.17149782f, 0.30630007f, 0.04920035f, -0.15892933f, -0.21696806f, 0.31750047f, -0.21998268f, -0.03300203f, 
    -0.05933024f, 0.30900821f, -0.05241519f, -0.18008226f, -0.18424428f, 0.13367075f, -0.29286799f, 0.31529716f, 
    0.17542931f, -0.09419233f, 0.09856717f, -0.73060292f, -0.64215058f, -0.07393511f, -0.08036065f, -0.18595000f, 
    0.06638493f, 0.06948122f, 0.10689571f, 0.11188862f, -0.16087013f, 0.19659910f, 0.03618516f, 0.03224653f, 
    0.05820930f, 0.25330284f, 0.13498774f, 0.07133459f, -0.12581283f, 0.11670379f, 0.07610553f, 0.08673938f, 
    -0.26698637f, 0.13819103f, -0.13446967f, -0.19135961f, 0.07816589f, -0.08566006f, -0.47463021f, 0.01939099f, 
    0.29633343f, 0.11799300f, 0.14660022f, -0.12270445f, 0.09157550f, -0.13338275f, -0.00870384f, -0.11484732f, 
    -0.20285107f, -0.04239808f, -0.13317361f, 0.05844179f, -0.12461083f, 0.10272958f, -0.09739991f, 0.08057614f, 
    -0.33465254f, -0.00082739f, -0.17449753f, -0.06026667f, 0.32163474f, -0.05885223f, -0.06674252f, -0.25626063f, 
    -0.15212083f, -0.00955337f, -0.00245348f, -0.05581597f, -0.18794437f, 0.00277146f, 0.13860041f, 0.16133031f, 
    0.07371144f, -0.52970755f, -0.28225222f, -0.14362885f, 0.00403514f, -0.01476517f, -0.00654221f, 0.10254706f, 
    0.15329461f, 0.14906965f, -0.59839892f, 0.00052377f, 0.15900396f, -0.11765891f, 0.00176042f, -0.00479928f, 
    -0.10215795f, 0.06224266f, -0.19547117f, -0.57956678f, -0.38865322f, -0.09826868f, -0.05016513f, 0.16571508f, 
    -0.01688538f, -0.22607815f, 0.08703642f, 0.17983618f, -0.21953964f, 0.16431673f, 0.34581161f, -0.14678308f, 
    -0.14177196f, 0.03167175f, -0.01857398f, -0.04459101f, -0.00876214f, -0.23463906f, -0.17143181f, -0.08873422f, 
    -0.15624046f, 0.03182084f, 0.12739633f, 0.03457483f, 0.11593054f, -0.03799032f, 0.20255364f, -0.08551437f, 
    -0.04130379f, -0.02228271f, -0.16549288f, 0.09880777f, 0.10015931f, 0.18915816f, 0.21392044f, -0.01505694f, 
    -0.15569109f, 0.21739072f, 0.03585503f, -0.06502214f, -0.13192333f, 0.24428613f, 0.28476751f, 0.13991575f, 
    0.13764437f, -0.17399284f, 0.04014898f, 0.06106136f, 0.17458379f, -0.15184011f, 0.01786826f, -0.00925113f, 
    -0.01881573f, 0.21093582f, -0.00673330f, 0.28951800f, -0.00661708f, -0.05667651f, 0.08203499f, 0.38258019f, 
    0.04357956f, 0.07331669f, 0.13144815f, -0.18161817f, -0.13033076f, -0.05009673f, -0.28528762f, 0.02314955f, 
    0.09290392f, 0.14280924f, 0.14270884f, -0.22527482f, 0.10258642f, 0.02330730f, 0.09766983f, 0.02424159f, 
    0.04834218f, 0.20832102f, 0.21989527f, 0.26822549f, 0.14572515f, -0.09757256f, 0.19964603f, -0.01250640f, 
    0.02382768f, 0.46443450f, -0.08947915f, 0.11634086f, 0.15705501f, -0.27024630f, -0.09449290f, -0.21768667f, 
    -0.10036570f, 0.33020335f, -0.04410666f, 0.16147731f, 0.07253993f, 0.05220576f, 0.34102964f, -0.18437901f, 
    0.24090432f, 0.05919975f, -0.08203595f, -0.11155163f, -0.04755754f, 0.05435566f, 0.23600192f, -0.38847759f, 
    -0.06658030f, -0.34812403f, 0.01583899f, 0.00819931f, -0.00112808f, 0.08514249f, 0.17324755f, 0.29423270f, 
    -0.18888207f, -0.09194805f, -0.03676421f, 0.08750873f, 0.19798103f, 0.27398452f, 0.11592270f, 0.09024072f, 
    0.19460741f, -0.52348042f, -0.31957817f, 0.30824259f, 0.11025868f, -0.15816723f, 0.03404624f, 0.03805067f, 
    0.07031061f, 0.42117053f, 0.26513404f, 0.08825320f, 0.23414648f, 0.14280775f, 0.18974900f, 0.15794852f, 
    0.00184169f, 0.11144675f, 0.27733016f, -0.07888970f, -0.16850081f, 0.10226472f, -0.12925602f, 0.06540297f, 
    -0.11113348f, 0.03687923f, -0.02136591f, 0.07158189f, -0.12532552f, -0.14900562f, -0.17957987f, -0.24945082f, 
    -0.19397874f, -0.30483747f, -0.19005749f, -0.23636174f, -0.21237363f, -0.08720224f, -0.09168846f, -0.16681182f, 
    -0.19279034f, -0.10916657f, -0.18666629f, -0.00937003f, 0.08479361f, 0.01262493f, -0.31108281f, -0.21299405f, 
    0.06354730f, 0.02884891f, -0.03993988f, 0.23197664f, 0.15073358f, 0.08020663f, 0.40761882f, -0.30602410f, 
    -0.15343985f, -0.01450878f, -0.08471463f, 0.05986562f, 0.01722102f, 0.11641218f, 0.11700680f, 0.17771088f, 
    -0.21861941f, -0.30399475f, 0.02401233f, -0.15016684f, 0.13416328f, -0.14913756f, 0.03078032f, 0.25463474f, 
    0.21736678f, -0.03294185f, 0.02904733f, 0.19317268f, -0.06000143f, 0.07498182f, 0.07056747f, -0.13455026f, 
    -0.15310596f, 0.03202081f, 0.03438403f, 0.13015458f, 0.12767510f, -0.10293528f, -0.06562365f, -0.09799376f, 
    0.25102478f, 0.09212289f, 0.01911461f, 0.22758377f, 0.26800075f, 0.21763499f, -0.00262368f, 0.12275014f, 
    0.28853795f, 0.14983365f, 0.09608996f, 0.19157304f, -0.18049619f, -0.22714333f, -0.13545956f, -0.18237069f, 
    -0.11814892f, -0.23637909f, -0.18898189f, -0.12671350f, -0.18078746f, -0.07983029f, -0.30736074f, -0.03820198f, 
    -0.08510835f, -0.22282337f, 0.00003533f, 0.03013680f, 0.12984869f, -0.08584984f, 0.09309050f, -0.13861257f, 
    -0.00072601f, -0.14911911f, -0.03654941f, 0.06725051f, 0.00553473f, -0.03468452f, 0.18674316f, -0.18040371f, 
    -0.09785296f, -0.09605110f, -0.07971878f, -0.04471857f, -0.09469311f, -0.16823958f, 0.11437625f, -0.06313699f, 
    0.31654400f, 0.19434951f, -0.18211395f, -0.09335425f, -0.02908579f, 0.04641106f, 0.10373197f, -0.03261751f, 
    -0.01149020f, 0.11054678f, 0.66264749f, 0.33055788f, 0.55491608f, 0.00894530f, 0.00246970f, 0.06581371f, 
    0.01336869f, 0.10886655f, -0.10634980f, -0.15236175f, 0.18310323f, 0.05533423f, 0.04998179f, 0.19260532f, 
    0.15515321f, 0.08263969f, 0.16233659f, 0.16330850f, 0.29314682f, 0.39808458f, -0.00034251f, 0.05526108f, 
    0.21822874f, -0.09723824f, -0.00383485f, 0.12843348f, -0.20404729f, -0.06526315f, 0.20776431f, 0.26816025f, 
    0.24900487f, 0.11951554f, 0.17836261f, 0.37203068f, 0.13094713f, 0.03908933f, 0.01915084f, 0.08126792f, 
    0.11828635f, 0.14267081f, 0.12314805f, -0.33106816f, -0.49126661f, -0.12377926f, -0.00987895f, 0.04740005f, 
    0.10878709f, 0.05159957f, 0.03383815f, 0.00005309f, 0.07311141f, -0.28406221f, -0.31445900f, 0.18579221f, 
    0.13549130f, 0.07160034f, -0.01709079f, -0.10110809f, 0.12983668f, 0.02558701f, 0.02371565f, -0.14561106f, 
    -0.22783835f, -0.08169010f, 0.25799960f, 0.01264219f, -0.03220540f, -0.08158750f, -0.18265209f, -0.18246971f, 
    -0.05849051f, 0.26371911f, -0.32379436f, 0.03560711f, -0.07470680f, 0.21922676f, 0.10152067f, 0.06488591f, 
    -0.08635075f, -0.17997392f, 0.01233043f, 0.36304435f, -0.00244782f, 0.04525212f, 0.20447366f, -0.01773917f, 
    -0.11832620f, -0.21536016f, -0.10421940f, -0.03623487f, -0.11817051f, -0.33981693f, 0.04026861f, 0.05013683f, 
    -0.00595363f, -0.11948437f, -0.23169518f, -0.18547337f, 0.35120776f, -0.24155299f, 0.08799703f, -0.04567310f, 
    0.04477601f, 0.03159698f, 0.00769952f, -0.05087883f, 0.18728164f, 0.01059671f, -0.47974595f, 0.02953658f, 
    0.02290983f, 0.01142181f, -0.06830457f, 0.32476822f, 0.00769246f, 0.13427325f, -0.33262315f, 0.75835377f, 
    -0.10594197f, -0.07194153f, 0.11960118f, 0.03228211f, 0.30745295f, 0.04973038f, 0.10272375f, -0.04463973f, 
    -0.14362219f, -0.10943591f, 0.17719796f, -0.08025439f, -0.20352381f, -0.11511365f, -0.30516219f, -0.27644396f, 
    0.01228887f, -0.06939888f, -0.02044429f, 0.06097613f, 0.08066932f, -0.00541069f, -0.29287961f, -0.53443772f, 
    -0.41260502f, -0.03368755f, 0.08319074f, -0.27832785f, 0.27113685f, -0.04300668f, 0.23477210f, -0.09346696f, 
    -0.12076507f, -0.09002613f, 0.15908778f, 0.31966138f, 0.13252845f, 0.04854449f, -0.10073610f, 0.21345624f, 
    0.04577934f, 0.01770500f, 0.13129893f, 0.24076021f, 0.12517893f, -0.36708274f, -0.00041530f, 0.03320301f, 
    0.08639452f, 0.06766509f, 0.01226032f, 0.07117730f, -0.31592816f, 0.22283459f, -0.06786905f, 0.13574463f, 
    0.17552765f, 0.16601421f, 0.05475675f, 0.08634897f, -0.02821080f, 0.02487699f, 0.07287563f, -0.01821194f, 
    0.08262618f, 0.09399550f, 0.06523106f, -0.28116596f, -0.30065936f, -0.12767659f, 0.05856971f, -0.09244995f, 
    0.38554648f, 0.02748318f, 0.05887914f, 0.13198973f, -0.01579723f, 0.02213892f, 0.10357525f, 0.10673744f, 
    -0.02399892f, 0.20009626f, 0.13597573f, 0.00380523f, 0.19068269f, -0.06776354f, 0.03241808f, 0.12246922f, 
    0.14201228f, -0.20146440f, -0.04602524f, -0.03857518f, -0.08772720f, 0.02428889f, -0.05558092f, -0.26927376f, 
    -0.22818702f, 0.14662899f, 0.25634354f, 0.07466494f, 0.19163820f, 0.04561494f, 0.15456083f, -0.02810238f, 
    0.01487234f, 0.12278900f, 0.36151135f, 0.28908789f, -0.07230412f, -0.02152123f, -0.08154129f, 0.26594871f, 
    -0.01641656f, 0.07237930f, -0.00646360f, -0.20024487f, -0.09216422f, 0.13519467f, 0.21377756f, 0.13244872f, 
    0.25648442f, 0.20731460f, 0.00344070f, 0.11035155f, 0.15210451f, 0.17834541f, -0.18536466f, 0.11381052f, 
    0.13289990f, 0.06734826f, 0.05459542f, 0.02014543f, 0.13179117f, 0.12627310f, 0.09673811f, -0.29373151f, 
    -0.08606563f, 0.00202426f, 0.13923120f, 0.06657304f, 0.03309344f, -0.02307789f, -0.01849702f, 0.09359438f, 
    -0.04400397f, 0.06949466f, 0.06799065f, 0.12827037f, -0.12630725f, -0.24628055f, 0.02602891f, 0.05416507f, 
    0.22617787f, -0.05030778f, -0.01838451f, -0.09013455f, 0.09008828f, 0.03808123f, 0.07873631f, -0.02434225f, 
    -0.48615795f, 0.07616135f, 0.13137248f, -0.14997561f, -0.20375991f, -0.04511539f, -0.05074595f, -0.08607275f, 
    0.09171629f, -0.12583300f, -0.01444523f, 0.22338630f, -0.10264105f, -0.11044998f, 0.03666784f, -0.14181347f, 
    -0.02024241f, 0.20319077f, -0.34816015f, 0.24326903f, 0.27535459f, 0.24612334f, 0.09677417f, 0.05120760f, 
    0.02050870f, 0.02869652f, 0.20458084f, -0.08912931f, -0.02410662f, -0.09070344f, 0.07241527f, 0.04412628f, 
    0.09871422f, 0.14068277f, -0.12619805f, -0.33611426f, -0.15456063f, 0.36618948f, 0.22934332f, 0.23735845f, 
    0.21746776f, 0.02083858f, 0.03576484f, 0.09644131f, 0.07226508f, -0.15451385f, 0.04577453f, 0.16558985f, 
    0.14899199f, -0.03972162f, -0.04621734f, -0.16225459f, 0.11454338f, -0.00762629f, -0.21023346f, 0.04297146f, 
    -0.40642214f, -0.00469333f, 0.16811870f, -0.05733136f, 0.17327164f, 0.10758244f, 0.26784825f, -0.35739028f, 
    0.01559897f, -0.20038939f, -0.13216671f, -0.14610966f, -0.08758246f, 0.07162892f, -0.18637714f, 0.15963662f, 
    0.42740750f, 0.22667041f, 0.19963484f, -0.32042676f, -0.12720802f, 0.02580384f, 0.18121469f, 0.18428425f, 
    0.03677967f, 0.11594688f, 0.22365947f, -0.03582434f, 0.08908272f, 0.16278997f, -0.02000381f, 0.00973106f, 
    0.05975128f, 0.01261800f, -0.17987075f, -0.33459768f, -0.06585670f, 0.20971164f, -0.02799214f, -0.15473635f, 
    0.05809810f, -0.03757335f, 0.02116314f, -0.05335695f, -0.02583723f, -0.02048723f, 0.02362278f, -0.09691953f, 
    -0.09657539f, -0.20707215f, -0.40163526f, -0.14165683f, 0.40242803f, 0.14045462f, -0.15404876f, -0.11736771f, 
    -0.09638865f, 0.01432707f, -0.08028485f, 0.19770892f, 0.05484346f, -0.20987993f, 0.11047041f, 0.33743927f, 
    0.08536878f, 0.02268650f, 0.17525634f, -0.00719497f, 0.10083783f, 0.13906977f, 0.22618055f, 0.01375576f, 
    0.14610013f, 0.05564902f, -0.16717567f, -0.07991979f, 0.04203717f, 0.07265011f, -0.06997743f, 0.04769574f, 
    -0.24601363f, -0.04178602f, 0.01644498f, -0.11738580f, 0.01806024f, -0.23337625f, -0.42048606f, -0.13085672f, 
    -0.14212209f, 0.02242843f, 0.29334897f, 0.11234233f, 0.06059550f, 0.21804257f, 0.14900206f, 0.20965342f, 
    0.11197913f, -0.39342499f, 0.10634135f, 0.24191396f, 0.02114206f, -0.04370540f, -0.13799646f, -0.20520577f, 
    -0.02997201f, -0.00680091f, -0.13454606f, 0.06691526f, -0.12844354f, -0.06159689f, 0.17361562f, 0.09679020f, 
    0.12795809f, 0.06827680f, -0.17326173f, -0.24853230f, -0.11811725f, -0.06981198f, -0.17481609f, -0.32997787f, 
    0.04510634f, 0.10612199f, 0.17073750f, 0.10326652f, 0.11104132f, -0.88093483f, -0.42315185f, -0.06267099f, 
    -0.01239202f, 0.10005161f, 0.05863228f, -0.00370175f, -0.25671566f, -0.63404441f, -0.38062239f, -0.27531609f, 
    0.03886582f, 0.04868362f, -0.13849962f, 0.09380434f, -0.03968275f, 0.16899909f, -0.29778218f, -0.01108749f, 
    0.28943580f, 0.11748323f, 0.20372579f, -0.12910837f, 0.16389760f, -0.14903851f, 0.05623085f, -0.16493368f, 
    -0.12815848f, 0.31792507f, 0.09340355f, 0.16881397f, -0.08760871f, 0.00824533f, -0.01598742f, -0.14102590f, 
    -0.42831850f, -0.28016609f, 0.05195969f, 0.04242101f, -0.05913540f, 0.08944514f, -0.35288629f, 0.28764293f, 
    -0.06035826f, -0.05019790f, 0.15119316f, -0.34606719f, 0.18983489f, 0.18850234f, -0.07406936f, 0.21299592f, 
    0.19618724f, -0.08097451f, -0.43229386f, 0.08447965f, 0.31595868f, -0.19627303f, -0.30264896f, -0.15041588f, 
    -0.02047090f, 0.03667214f, 0.05429894f, 0.16517568f, 0.32078588f, 0.05962291f, 0.17144556f, 0.10592016f, 
    -0.09091357f, 0.16115618f, 0.38958666f, 0.00962366f, -0.31608593f, -0.30848303f, 0.18726052f, 0.11632381f, 
    -0.19643795f, 0.15118131f, 0.12204196f, -0.28151432f, 0.20258391f, -0.21468768f, 0.00740657f, 0.13364241f, 
    -0.07024248f, -0.07895625f, -0.04133750f, -0.08416978f, -0.13248438f, 0.10636933f, 0.46828252f, -0.44009408f, 
    -0.22295073f, -0.00263541f, -0.01968769f, -0.01239852f, 0.00438714f, 0.23665164f, 0.28331026f, -0.22497503f, 
    -0.06256773f, -0.04446926f, -0.14850116f, -0.13761239f, -0.17617385f, 0.04260464f, 0.12892087f, 0.06620279f, 
    -0.03014853f, 0.03461445f, -0.04091324f, 0.04248274f, -0.06274855f, 0.00233967f, -0.01206266f, -0.01061634f, 
    -0.00187485f, -0.02960708f, 0.05741021f, 0.04381080f, -0.00754670f, 0.00434602f, -0.02730521f, -0.05922804f, 
    -0.01001008f, -0.06193901f, 0.00393507f, -0.03069438f, 0.00096201f, -0.02990635f, -0.01488769f, 0.01683135f, 
    -0.00677285f, -0.03562715f, -0.02935924f, -0.02233487f, 0.02655683f, -0.04280103f, -0.01248534f, -0.01101417f, 
    0.04963193f, 0.03370798f, 0.02925926f, -0.04903273f, 0.02812145f, 0.02955094f, 0.00628379f, -0.04884513f, 
    0.03398320f, 0.00108000f, 0.03755309f, -0.04875347f, -0.00083952f, -0.00252830f, -0.00368429f, -0.03088956f, 
    -0.06609490f, -0.05727212f, -0.00019504f, -0.00341187f, -0.06529558f, -0.01848274f, -0.01546760f, -0.04521709f, 
    -0.06264538f, 0.03828504f, -0.03050335f, 0.04971699f, 0.00047258f, -0.06711052f, -0.04535300f, 0.03446716f, 
    -0.01880427f, 0.02200132f, 0.00935976f, -0.05536824f, 0.00042637f, -0.06955388f, -0.02603570f, -0.03250962f, 
    0.04026039f, 0.04458931f, -0.05762902f, -0.02690925f, 0.01040157f, -0.04764976f, 0.04101836f, 0.04440698f, 
    -0.04968570f, 0.01405927f, 0.01692652f, -0.04507428f, -0.02021254f, 0.02376124f, 0.04276425f, -0.00215345f, 
    0.00228995f, 0.01727912f, 0.04283906f, -0.02050783f, 0.02645203f, 0.02602335f, -0.04254430f, -0.05117490f, 
    -0.04299324f, -0.04457982f, 0.00822644f, 0.01733185f, 0.05794143f, 0.02844550f, 0.01003742f, 0.00159558f, 
    0.02701638f, 0.00144764f, -0.03284898f, -0.02853105f, -0.03571597f, -0.00691638f, -0.05138336f, 0.01114671f, 
    -0.03386034f, 0.02861176f, 0.00510338f, -0.00681514f, 0.00042144f, -0.03218811f, 0.02172502f, 0.05381942f, 
    0.06025564f, 0.02726050f, -0.03743417f, 0.03728937f, 0.02438780f, -0.04342454f, -0.01357751f, 0.04730474f, 
    0.04534873f, 0.00121438f, 0.03003877f, -0.02096581f, 0.02088342f, -0.00616416f, -0.04775455f, -0.01269475f, 
    -0.05336550f, -0.02244405f, -0.03698515f, -0.05700159f, -0.06299832f, 0.04011315f, -0.04155551f, -0.03780544f, 
    -0.04913481f, 0.03393360f, -0.03014906f, -0.05386994f, 0.01673727f, -0.02480221f, -0.05142045f, -0.01889813f, 
    -0.02679233f, -0.05523844f, -0.03354101f, -0.01792608f, -0.01106520f, 0.00707372f, -0.02087861f, 0.03852929f, 
    -0.04621330f, -0.03510767f, -0.03793953f, 0.00214572f, 0.05708069f, -0.05967914f, 0.00374734f, -0.00154578f, 
    -0.05135487f, -0.06139612f, 0.01987476f, -0.05575234f, -0.02121068f, 0.03696448f, 0.00805161f, 0.00561809f, 
    0.01110116f, 0.03884574f, 0.01763039f, -0.02510689f, -0.02006608f, -0.00379712f, 0.04440570f, -0.00007232f, 
    0.00460391f, -0.00947604f, 0.03693580f, -0.07132585f, 0.00200123f, 0.04617273f, 0.02915457f, 0.03758160f, 
    -0.07122093f, 0.03777834f, 0.04284715f, 0.04435932f, -0.05720034f, -0.02430099f, -0.01656523f, 0.03599364f, 
    0.01618481f, 0.04079702f, 0.02949418f, -0.00327201f, 0.02748179f, 0.02110262f, 0.01405545f, -0.03559129f, 
    0.03511956f, 0.00868132f, 0.03612597f, -0.00781948f, 0.00111962f, -0.01748729f, -0.04401721f, -0.02474699f, 
    0.02873533f, -0.03373813f, -0.04000337f, 0.01089482f, -0.04972574f, -0.06560270f, -0.06587531f, 0.00398204f, 
    -0.01477225f, 0.02077131f, 0.01102989f, -0.00117476f, -0.00386079f, -0.05297394f, 0.00812542f, -0.00101827f, 
    -0.03608757f, -0.02875024f, -0.05612295f, 0.01489218f, -0.02899877f, -0.06920708f, 0.00739215f, 0.00426911f, 
    0.05055319f, -0.04110098f, -0.04688473f, 0.01620434f, 0.00516155f, -0.01574248f, -0.05209215f, 0.04721162f, 
    0.04078614f, -0.02832232f, -0.00897224f, 0.00372368f, 0.02167291f, 0.00145354f, -0.05324483f, 0.00261427f, 
    -0.01334431f, 0.01521519f, -0.05187950f, 0.02676722f, -0.04055734f, 0.01484966f, 0.02693206f, 0.04524379f, 
    -0.02262412f, 0.03442346f, -0.03143365f, -0.00050143f, -0.00373773f, -0.02695679f, 0.04289164f, 0.01316711f, 
    -0.01006111f, 0.03281227f, -0.07050156f, -0.02538867f, -0.02784115f, -0.03133780f, 0.03017793f, -0.06866599f, 
    0.00014901f, 0.00117849f, -0.05170043f, -0.04729991f, -0.00104448f, -0.01342441f, -0.02724210f, -0.00993913f, 
    0.03574539f, -0.19024608f, 0.22959073f, 0.17410654f, 0.12787393f, -0.04022894f, -0.03158195f, 0.08904022f, 
    0.17891413f, -0.13039742f, -0.22188006f, -0.81179923f, 0.05711396f, 0.06012442f, 0.10664468f, 0.05190006f, 
    0.08443099f, -0.60240889f, -0.52263016f, 0.17927033f, 0.14048038f, 0.02441227f, -0.19132116f, -0.22657673f, 
    -0.15964366f, -0.34326953f, -0.33863348f, -0.57281971f, -0.24433619f, -0.12043279f, 0.14416276f, -0.00674563f, 
    0.14701012f, -0.24891469f, -0.15049309f, -0.44578072f, -0.40802297f, -0.03463401f, -0.29031003f, -0.09869535f, 
    -0.01723593f, -0.30779263f, -0.17537124f, -0.26762938f, -0.07739325f, -0.05394022f, -0.05092861f, -0.02636140f, 
    0.18290313f, 0.23927736f, 0.07442709f, -0.03604196f, -0.14381079f, -0.09244794f, 0.06162887f, 0.19878696f, 
    0.02332639f, 0.15172638f, 0.16579147f, 0.19139893f, -0.01844884f, 0.34710681f, 0.16454758f, 0.14559059f, 
    -0.13673887f, 0.06577346f, 0.03159789f, 0.23633547f, 0.07855377f, 0.00519652f, 0.07628053f, 0.06580588f, 
    0.23236452f, 0.14641005f, -0.24704750f, 0.13547273f, -0.10820450f, 0.06722652f, 0.04354918f, -0.20432395f, 
    0.08948384f, 0.12198047f, -0.06361663f, 0.18114863f, 0.20046683f, 0.19825149f, 0.28478843f, -0.01805553f, 
    0.26354900f, -0.23015070f, -0.08669214f, 0.01082806f, 0.13265955f, 0.22450951f, 0.19341965f, 0.14785311f, 
    -0.04127580f, -0.05724385f, 0.36680606f, 0.08420312f, 0.07501566f, -0.22092210f, 0.20222905f, -0.00679716f, 
    0.15509149f, 0.12587760f, 0.33109513f, 0.03038109f, 0.18887809f, 0.46628317f, 0.32492691f, 0.09117174f, 
    -0.07064110f, 0.32783973f, -0.26801866f, 0.12718692f, -0.27124658f, -0.11179832f, 0.19738615f, 0.10315861f, 
    -0.10526417f, -0.13783126f, -0.06327448f, -0.01602682f, 0.08469113f, 0.02213971f, 0.13130522f, 0.07191063f, 
    -0.15441099f, -0.06430988f, 0.02687681f, 0.22639965f, -0.22876477f, 0.06901062f, 0.13089892f, 0.16413157f, 
    0.07996141f, -0.17833807f, 0.11915079f, 0.06869172f, 0.18841559f, 0.07580912f, 0.23214810f, 0.04865990f, 
    0.06744669f, 0.14025526f, 0.09600918f, 0.10381731f, 0.14567001f, 0.10155747f, 0.06731477f, 0.10668107f, 
    0.03947299f, 0.08187358f, 0.06123533f, -0.19149587f, -0.05548574f, 0.10992764f, -0.01554268f, 0.16798462f, 
    0.28202781f, -0.04377103f, 0.20230843f, 0.19836275f, -0.03615544f, 0.03562321f, -0.13390106f, 0.11068664f, 
    -0.18313284f, 0.17399780f, -0.36445627f, 0.07684872f, -0.03738436f, 0.15126066f, 0.00912011f, 0.09195727f, 
    0.03297342f, -0.01472240f, -0.09094822f, 0.14064594f, 0.05118934f, -0.04505476f, -0.03919974f, -0.12363606f, 
    -0.01838497f, -0.02404906f, 0.17328921f, -0.08000620f, -0.03353142f, -0.11355391f, 0.01753047f, 0.06673614f, 
    0.16292617f, 0.05009645f, 0.20118713f, 0.09240764f, -0.15660575f, 0.20426770f, 0.12102029f, 0.28301248f, 
    -0.13236427f, 0.00368294f, 0.02354417f, -0.07064409f, 0.00034083f, 0.05925350f, -0.03024372f, -0.04575979f, 
    0.13030626f, 0.15958433f, -0.01628006f, -0.04524156f, -0.03766826f, 0.02217221f, 0.05571676f, 0.20952277f, 
    -0.03907580f, 0.03219906f, 0.18439664f, -0.12343384f, 0.07786585f, 0.02287146f, 0.00237253f, 0.23318681f, 
    0.15936704f, -0.09762539f, -0.11365357f, -0.13591529f, 0.03338153f, -0.01752428f, 0.21949652f, 0.12151736f, 
    -0.02952140f, -0.49486327f, 0.02378507f, -0.22501338f, 0.13897029f, -0.02407496f, 0.10163303f, -0.02376629f, 
    0.06358841f, 0.08770623f, -0.08030035f, -0.28307211f, -0.10265465f, -0.19774039f, -0.05577974f, 0.12291721f, 
    0.03483053f, -0.13309082f, 0.09969745f, -0.00483007f, -0.04352505f, -0.10956989f, 0.03747553f, -0.10098415f, 
    0.00538832f, -0.00800963f, 0.09266913f, -0.09917285f, -0.05676177f, -0.01429499f, -0.10876668f, 0.13304673f, 
    -0.01902456f, 0.08832985f, 0.03913049f, 0.03306405f, 0.00193437f, 0.03896086f, 0.06206197f, 0.03802527f, 
    0.05284213f, 0.12189759f, 0.04507455f, 0.10462509f, 0.01528295f, -0.05489193f, 0.06238743f, 0.04160997f, 
    -0.01261420f, -0.02140665f, -0.03651857f, 0.05454296f, 0.05515882f, 0.04861068f, -0.05218149f, 0.03816639f, 
    0.03714803f, -0.02792800f, -0.04987743f, -0.01268410f, 0.01506244f, 0.04693641f, -0.04058668f, -0.06464513f, 
    -0.00464877f, -0.04028340f, 0.04897794f, 0.00857529f, -0.04922203f, 0.00896411f, 0.02863391f, 0.00154751f, 
    -0.05143890f, -0.02247275f, -0.00026407f, -0.03253726f, 0.01797035f, -0.06095747f, -0.02698974f, 0.04415119f, 
    -0.01220989f, -0.01656308f, -0.02142980f, -0.06293345f, -0.04734582f, -0.01650766f, 0.01483890f, -0.03622368f, 
    0.03563698f, -0.01641436f, -0.01750490f, -0.03483657f, 0.00121093f, -0.03068807f, 0.01147868f, -0.05356879f, 
    -0.05572491f, -0.01683053f, 0.04019398f, -0.03306362f, 0.01095808f, -0.00485426f, 0.02020390f, -0.04068028f, 
    -0.02927109f, 0.02848675f, -0.05397930f, 0.01725970f, 0.02407390f, 0.01974334f, -0.01620466f, 0.00329103f, 
    -0.03925395f, -0.02475300f, 0.02863356f, -0.05205923f, -0.04318108f, 0.04468907f, -0.05260281f, -0.00977425f, 
    -0.05668586f, -0.00473223f, -0.04704997f, -0.01464842f, -0.01532495f, -0.00385172f, -0.04050354f, -0.05450258f, 
    -0.02562086f, 0.03171783f, -0.01408377f, -0.04537838f, -0.01977115f, 0.02926232f, -0.05975769f, 0.00736305f, 
    -0.03842017f, 0.01298078f, 0.00890755f, 0.03060381f, 0.03727600f, -0.03418984f, -0.04586060f, 0.04295065f, 
    0.03338287f, -0.02425305f, -0.01104846f, 0.02648199f, -0.03803441f, -0.01081307f, 0.03914763f, -0.03943735f, 
    -0.04056131f, 0.00042660f, 0.03359721f, 0.01676549f, 0.01924529f, 0.03313567f, 0.04815315f, -0.01553598f, 
    0.01359463f, -0.00605519f, 0.02437755f, 0.05139015f, -0.02390310f, 0.03149670f, 0.00619414f, -0.01670347f, 
    0.00819548f, -0.02221435f, 0.04435421f, -0.02971531f, -0.03852838f, 0.02314906f, 0.01180550f, -0.00868931f, 
    -0.02005333f, -0.02322975f, -0.06030324f, 0.00423467f, 0.00943009f, -0.04084786f, 0.00237679f, -0.03969658f, 
    -0.02720545f, -0.03128826f, 0.02115588f, -0.03734615f, 0.05174118f, -0.02185680f, 0.00032804f, -0.03779355f, 
    -0.04368036f, -0.04706205f, 0.04539767f, -0.03921279f, -0.05778468f, 0.02743821f, 0.04181335f, -0.01911621f, 
    -0.05888440f, -0.01097049f, -0.03144180f, -0.05638657f, -0.05409323f, -0.01150618f, 0.04481697f, 0.03896554f, 
    0.01040585f, -0.02323528f, 0.05083643f, -0.00036119f, -0.00992933f, 0.01292152f, -0.00739319f, -0.02484270f, 
    -0.01706971f, 0.01424250f, 0.04105869f, -0.03170935f, 0.01226585f, 0.01857490f, -0.05050040f, -0.00847365f, 
    0.03275627f, -0.05481195f, 0.03562810f, -0.05860893f, 0.04802077f, 0.03642936f, -0.02155757f, 0.01293645f, 
    0.01317078f, 0.01978482f, -0.01902219f, 0.02466551f, 0.02246529f, -0.01841192f, -0.04105899f, -0.00092794f, 
    0.02162831f, -0.01691503f, 0.00620491f, -0.03094076f, -0.02131057f, -0.01274960f, 0.02304454f, 0.01000907f, 
    0.03396984f, -0.02946848f, -0.00431013f, 0.02431058f, -0.05433753f, -0.05397457f, -0.00833766f, -0.05654204f, 
    0.00164601f, -0.03246063f, 0.04644535f, -0.00208547f, -0.05967371f, -0.03448093f, 0.02199917f, 0.03533354f, 
    -0.01556767f, 0.02165631f, -0.02944366f, -0.02405637f, 0.03495598f, -0.02486694f, -0.01794544f, 0.00574602f, 
    0.02806048f, -0.04120760f, -0.03655449f, 0.03920286f, -0.03169966f, 0.00118229f, 0.03586828f, -0.03417105f, 
    -0.00329352f, 0.05348449f, -0.02365810f, -0.02965970f, -0.05450904f, 0.00124264f, -0.02771481f, -0.02870572f, 
    0.00795945f, 0.00593489f, -0.02346553f, -0.04575354f, -0.06602994f, -0.04419003f, 0.04930624f, -0.03694488f, 
    -0.05010181f, -0.01340088f, -0.00877652f, -0.06497189f, 0.01225526f, 0.04144534f, -0.04272740f, 0.03628580f, 
    0.01374513f, 0.04570895f, -0.03970217f, 0.01638268f, -0.01371440f, -0.02394168f, -0.00954956f, -0.05239299f, 
    -0.03191266f, -0.04121737f, -0.04165515f, -0.04827494f, -0.05014108f, 0.02704967f, 0.00089511f, -0.06136754f, 
    -0.00129165f, 0.05381453f, 0.00266194f, 0.05558684f, -0.05788580f, 0.00163456f, 0.02720026f, 0.04327939f, 
    -0.05994998f, -0.00592830f, -0.06097349f, -0.04579152f, -0.03925413f, -0.04691907f, 0.05245322f, -0.03163785f, 
    0.05971190f, -0.01763458f, 0.03087835f, 0.02534588f, -0.01199132f, 0.01842509f, -0.00566981f, -0.00618220f, 
    0.10056394f, 0.28695109f, 0.40439987f, -0.20958197f, -0.18070790f, -0.20717628f, -0.04761805f, -0.12065987f, 
    -0.00854203f, 0.02817149f, -0.15663491f, 0.35782298f, 0.02807545f, -0.02240941f, 0.01149489f, 0.05027369f, 
    0.12617628f, -0.07229681f, -0.23269990f, -0.23256440f, 0.05841303f, -0.10943605f, 0.01767780f, -0.07145461f, 
    0.02853176f, -0.03873227f, -0.12255324f, 0.19568586f, -0.03626112f, 0.33859202f, -0.07166199f, 0.01414027f, 
    -0.16388324f, 0.06493229f, 0.12665989f, 0.16987602f, 0.06082385f, 0.01157522f, -0.30239406f, 0.05383745f, 
    -0.09715379f, 0.01288334f, 0.03808974f, 0.05392454f, -0.07597246f, 0.40348583f, -0.07266843f, 0.09861332f, 
    0.06345676f, -0.03154248f, -0.09652819f, 0.08865644f, 0.05347975f, 0.09727728f, 0.25607976f, -0.47613418f, 
    0.17115662f, 0.05674827f, -0.19900581f, 0.14088060f, 0.13842730f, 0.04693622f, -0.07117086f, -0.15270557f, 
    -0.13540377f, -0.18276881f, -0.03618485f, 0.07815403f, -0.13989295f, 0.09181082f, 0.00535447f, -0.00069749f, 
    -0.18389536f, -0.16518258f, 0.49930215f, -0.28744900f, 0.20167203f, 0.08515461f, -0.05080928f, 0.05641684f, 
    0.12706308f, 0.05225343f, -0.26403412f, -0.04837414f, 0.06503689f, 0.15156893f, -0.28963929f, 0.13943952f, 
    -0.06620394f, -0.03032398f, -0.28798595f, -0.15531009f, -0.49177977f, 0.01924551f, -0.27203146f, -0.27407372f, 
    0.08916553f, -0.08348756f, 0.07411271f, 0.11757378f, -0.01298154f, 0.36082420f, -0.01857844f, -0.08113663f, 
    0.10505335f, 0.12245388f, -0.04671233f, -0.09929138f, 0.07286792f, -0.13508427f, 0.37587833f, 0.05130726f, 
    -0.08444517f, -0.05026149f, 0.04617659f, 0.02175138f, 0.04115827f, -0.18097539f, -0.32405764f, 0.18230693f, 
    0.01813038f, 0.08503950f, -0.06387715f, 0.03215821f, 0.07554100f, -0.03124663f, 1.06735933f, 0.26745954f, 
    -0.42850047f, -0.20973276f, -0.16194826f, 0.23425984f, 0.05277881f, -0.04416246f, 0.20900427f, 0.01347576f, 
    -0.31762055f, 0.22822957f, -0.07958977f, -0.04362476f, 0.24107106f, -0.00568155f, -0.10251707f, -0.01057058f, 
    0.05766692f, 0.13670021f, 0.05493649f, 0.10629764f, 0.06506510f, -0.08614974f, -0.01672501f, 0.11795516f, 
    0.17027341f, 0.05118685f, -0.00177473f, 0.60922438f, -0.16777983f, 0.02644598f, -0.12200394f, -0.14946125f, 
    -0.01040352f, 0.20983724f, 0.36677045f, 0.00059030f, 0.21385585f, 0.03313085f, 0.09863350f, 0.06114391f, 
    -0.07395209f, 0.17637037f, -0.05256142f, -0.07268517f, -0.10700601f, -0.19895296f, 0.04748970f, -0.08139203f, 
    -0.28541762f, 0.04787960f, -0.04663597f, -0.02278512f, 0.15272245f, -0.01843965f, -0.09236799f, 0.09388075f, 
    -0.09518667f, -0.10642783f, 0.16271862f, -0.21435167f, -0.04339021f, -0.29326218f, 0.00079447f, -0.60458887f, 
    -0.08180300f, -0.27420244f, -0.06033492f, -0.07241309f, 0.10670982f, -0.07119826f, -0.09556246f, -0.06465248f, 
    0.24319679f, 0.00596173f, -0.14246790f, -0.07592379f, 0.19191802f, 0.01286627f, -0.07945783f, -0.05574155f, 
    -0.19943137f, 0.29119265f, -0.02513137f, -0.11187665f, -0.22762908f, 0.12372333f, 0.06489930f, -0.11008216f, 
    0.13342658f, -0.43803543f, 0.39156428f, 0.21561788f, -0.08837354f, -0.28007531f, -0.00148931f, -0.12811024f, 
    -0.09768010f, 0.06129732f, -0.15820290f, 0.11670638f, 0.01672563f, 0.16066793f, -0.01126682f, 0.03863117f, 
    0.10730925f, -0.05741113f, 0.35634032f, 0.55832970f, 0.21671747f, -0.05439021f, 0.16174936f, -0.11967670f, 
    -0.05729662f, -0.19867505f, 0.07022630f, 0.22422203f, 0.03855603f, -0.01184662f, 0.29723400f, 0.05165160f, 
    -0.25713402f, -0.33780137f, -0.05211824f, 0.16802646f, -0.17856437f, 0.34936982f, 0.17428266f, -0.19548118f, 
    -0.04572228f, -0.31560045f, -0.21174589f, 0.14678308f, 0.12575844f, -0.29901397f, 0.04805634f, 0.17207839f, 
    0.01592816f, 0.07380091f, -0.29672843f, -0.21140683f, 0.11681622f, 0.20675750f, -0.43061420f, -0.22327641f, 
    0.16234040f, -0.01304223f, -0.01173132f, -0.04453978f, 0.30463073f, 0.09933463f, 0.31902292f, 0.13078557f, 
    0.08760653f, -0.65709531f, -0.18861631f, 0.00363135f, -0.04830403f, 0.08648365f, 0.09014241f, 0.03551062f, 
    0.00394899f, 0.03638943f, -0.05193310f, -0.04821267f, 0.03683339f, 0.01062041f, -0.03886047f, -0.06319407f, 
    -0.04777554f, -0.03013956f, -0.02113295f, 0.05127925f, 0.01175512f, 0.00127721f, -0.02153449f, 0.03862819f, 
    -0.00644617f, 0.04360821f, -0.04581659f, 0.06317656f, 0.00182306f, -0.05190160f, -0.02931923f, -0.06034391f, 
    -0.03549740f, -0.00292910f, 0.04380703f, -0.03056789f, -0.01382351f, -0.04191426f, -0.00841975f, -0.04911482f, 
    -0.00758614f, -0.06449315f, -0.01615856f, -0.02378611f, -0.04129453f, 0.04337217f, -0.03765479f, -0.01730167f, 
    -0.04163752f, -0.02200276f, -0.04157000f, 0.01479018f, -0.04888309f, -0.01400094f, -0.00630038f, -0.00064213f, 
    0.00811711f, -0.04314977f, 0.04790615f, 0.00389638f, -0.05010117f, -0.04556107f, 0.02957893f, -0.04124668f, 
    -0.05333110f, -0.06055740f, -0.05895796f, 0.02571493f, -0.00891132f, -0.06178343f, -0.02337715f, -0.06318054f, 
    0.00867501f, 0.05152396f, 0.03527680f, -0.05839478f, 0.03514423f, 0.01299076f, -0.05700005f, -0.04653750f, 
    -0.04347890f, -0.06703999f, -0.05940272f, 0.04789364f, -0.02238653f, 0.00066639f, 0.00155844f, -0.04086435f, 
    -0.04622131f, 0.05256478f, 0.00886737f, 0.00908523f, 0.00683375f, -0.05838114f, 0.01059478f, -0.05402631f, 
    -0.05127516f, -0.04378466f, 0.04901353f, 0.03869274f, -0.05638650f, -0.04916768f, -0.02292001f, 0.03314933f, 
    0.01339594f, -0.04321073f, 0.01918127f, 0.02907269f, -0.04091756f, -0.03992696f, 0.01282615f, -0.04149093f, 
    -0.04854119f, -0.01301622f, 0.04205491f, 0.01484050f, 0.00917911f, 0.00209251f, -0.05484074f, 0.01956987f, 
    -0.03299318f, 0.01901780f, -0.03167449f, -0.00473479f, 0.03293759f, -0.00775666f, -0.03355075f, -0.01245903f, 
    -0.05773620f, -0.00513629f, -0.05246565f, -0.03403320f, 0.01168132f, -0.00452905f, -0.05110938f, -0.06670322f, 
    -0.00666747f, 0.03153271f, 0.02325389f, -0.06250921f, 0.00421370f, -0.02666243f, 0.01150641f, -0.02647761f, 
    -0.01151418f, 0.01872004f, -0.00851176f, 0.03020795f, -0.05963491f, 0.01225239f, -0.00660150f, -0.05101917f, 
    0.02387999f, -0.02739734f, 0.05061662f, -0.04233172f, -0.03694829f, -0.04030168f, 0.02335194f, -0.04342024f, 
    -0.03145625f, -0.01445023f, 0.00114923f, -0.03696446f, -0.01910326f, -0.03318939f, 0.01097139f, 0.01909677f, 
    0.04138452f, -0.01071557f, -0.02655816f, -0.06137681f, 0.04161964f, -0.02511222f, -0.01180980f, -0.05059590f, 
    0.03857435f, 0.00142137f, -0.03351400f, -0.00482709f, -0.04616942f, -0.06385765f, -0.01473822f, -0.00890670f, 
    0.04457441f, 0.02738978f, 0.00408291f, 0.03182830f, -0.01594734f, 0.02086456f, -0.01765759f, 0.00664244f, 
    -0.02564823f, -0.00034894f, -0.03150683f, -0.01444407f, -0.00045534f, 0.04532931f, -0.03673560f, -0.05186220f, 
    0.01408320f, -0.04312354f, -0.05947528f, 0.04198699f, -0.01995325f, -0.04264957f, -0.03398522f, 0.00919444f, 
    0.00230012f, -0.01993421f, -0.03304277f, 0.00239161f, 0.01123777f, 0.00750916f, 0.01165995f, 0.02562175f, 
    0.04008906f, 0.03358601f, 0.00264639f, -0.03044035f, -0.03933819f, 0.05030338f, 0.03134323f, 0.04323496f, 
    0.05971769f, 0.04230849f, -0.05338824f, 0.00612417f, -0.05136895f, 0.01028424f, -0.05456391f, -0.02291323f, 
    0.01380258f, -0.00061188f, -0.00549787f, 0.01112395f, 0.00133891f, -0.04218880f, -0.00178714f, 0.00802432f, 
    0.02997576f, 0.02737011f, 0.01553075f, -0.04614337f, -0.00500920f, 0.02196366f, -0.06583370f, 0.05021926f, 
    -0.01973510f, -0.02868283f, -0.06658204f, -0.01530345f, 0.00942002f, -0.00103180f, 0.02496491f, 0.03053737f, 
    -0.00491242f, -0.00727543f, -0.03153628f, -0.00221645f, 0.02055290f, -0.00724620f, 0.04271817f, 0.01825698f, 
    -0.02205310f, -0.00467825f, 0.02529344f, 0.02196280f, -0.00000476f, 0.05210247f, 0.02499907f, 0.06167145f, 
    -0.02505221f, 0.03962770f, 0.03636449f, 0.00304482f, -0.02531954f, -0.06338364f, -0.05972654f, -0.05688844f, 
    -0.01561125f, 0.00219761f, -0.01743051f, 0.02980939f, -0.00396944f, 0.04735786f, 0.04370597f, 0.00441853f, 
    -0.04885649f, 0.00572182f, 0.04674835f, -0.01408091f, -0.04828662f, 0.04970061f, 0.03167539f, -0.04360042f, 
    0.01351136f, -0.14346698f, -0.00203768f, -0.03687303f, 0.11424120f, 0.20255034f, -0.05003473f, -0.01134561f, 
    -0.05046675f, -0.27496201f, 0.04696679f, -0.18769723f, -0.05202270f, 0.05419731f, -0.01414614f, -0.10050922f, 
    -0.19887888f, 0.17220855f, 0.62262088f, 0.47149202f, 0.07460702f, 0.06834786f, 0.07178504f, -0.06146353f, 
    -0.11108035f, -0.09223406f, 0.10826683f, 0.27951509f, 0.28100726f, 0.01864454f, 0.17403512f, 0.04341016f, 
    0.11473560f, -0.17467692f, -0.18146110f, -0.15601079f, 0.21340433f, 0.13430488f, -0.26569632f, -0.11613100f, 
    0.16702747f, -0.18606602f, -0.12936740f, -0.08854271f, -0.02380913f, 0.03057314f, 0.01724973f, 0.03067975f, 
    0.03896100f, -0.30008104f, -0.40081847f, -0.19541022f, -0.08471942f, -0.10005773f, 0.03059786f, 0.15066694f, 
    0.07544349f, -0.17339814f, 0.11511312f, 0.27544814f, -0.18978159f, 0.03194908f, 0.02271961f, -0.12228004f, 
    0.00787498f, 0.05596747f, 0.02383170f, 0.15871732f, -0.05870520f, 0.05574041f, 0.03075513f, 0.10260274f, 
    0.17210695f, 0.16289923f, -0.26972118f, 0.00868361f, -0.26778406f, -0.15972631f, -0.01552209f, -0.01382877f, 
    0.07415105f, 0.02070569f, 0.25254643f, 0.09667965f, -0.00730807f, 0.18040930f, 0.10573483f, 0.03545569f, 
    0.06769820f, 0.10010257f, -0.17793092f, 0.06902268f, 0.35156217f, -0.00992077f, -0.14525928f, -0.07338220f, 
    -0.18303077f, 0.21424867f, 0.02151093f, 0.05871167f, -0.03781440f, -0.36349827f, -0.04407473f, -0.02762065f, 
    0.00458813f, 0.02462204f, 0.00174936f, 0.02842839f, 0.22427616f, 0.41899478f, -0.08563779f, 0.16525304f, 
    -0.33281386f, 0.23435804f, -0.11003075f, -0.09969915f, -0.07902515f, -0.20074652f, 0.10823319f, -0.17230816f, 
    -0.08750483f, -0.04720096f, 0.02361330f, -0.05672793f, 0.02994905f, -0.10122252f, 0.29495049f, -0.34272352f, 
    -0.11142449f, -0.13852789f, -0.00637615f, -0.01139482f, 0.27020893f, -0.09837920f, -0.13906351f, 0.07268434f, 
    0.19899166f, -0.05807102f, -0.13709421f, -0.00590200f, -0.00077425f, -0.06634296f, 0.02127019f, 0.05956440f, 
    -0.06885799f, 0.06153560f, 0.10037471f, 0.13849297f, 0.11994042f, -0.11482747f, -0.10340185f, -0.01022787f, 
    -0.11999878f, 0.21871884f, -0.13692012f, -0.22441426f, 0.02966568f, 0.02905073f, 0.06685939f, 0.13589825f, 
    0.19194837f, 0.19451337f, 0.14124140f, -0.04259845f, 0.02162242f, 0.03321573f, -0.10959747f, 0.14191158f, 
    -0.23786363f, -0.13131768f, -0.33979487f, -0.20230107f, -0.12093238f, 0.18300095f, 0.04590788f, 0.10201117f, 
    0.08053558f, 0.15368196f, 0.18375526f, -0.09420283f, 0.08186060f, -0.00124793f, 0.05110607f, -0.07108244f, 
    0.10156859f, -0.04434892f, -0.14385377f, -0.15874325f, -0.12085387f, -0.07902264f, 0.11195170f, 0.28929663f, 
    -0.01567653f, -0.00607634f, 0.05986062f, -0.20195377f, -0.03318967f, -0.01171643f, 0.25326851f, 0.35866117f, 
    0.04067116f, 0.13542305f, 0.10625037f, -0.05807526f, 0.11752544f, -0.00789040f, -0.03783476f, 0.32853681f, 
    0.07126360f, 0.16246401f, 0.16135751f, 0.04555875f, 0.13704954f, 0.13089442f, 0.00597656f, -0.01536039f, 
    -0.21641594f, 0.06323946f, -0.11021962f, -0.16275187f, -0.45932826f, -0.06249768f, -0.08634606f, 0.00758288f, 
    -0.06577616f, 0.19092727f, 0.04480521f, 0.12250887f, 0.01127798f, 0.04792267f, -0.01598186f, -0.03079742f, 
    -0.03161827f, -0.16801545f, 0.04375762f, -0.48952669f, -0.12330325f, 0.00202507f, 0.07471296f, 0.10179046f, 
    -0.02813875f, 0.12063455f, -0.18059386f, -0.02341010f, -0.28218704f, 0.00023836f, 0.05886816f, -0.06442642f, 
    -0.12194193f, 0.03790702f, 0.27310729f, -0.08971481f, 0.03725509f, -0.02617452f, 0.12692481f, 0.02989586f, 
    0.12211491f, 0.05022189f, 0.00378960f, 0.08362629f, -0.07419603f, 0.02914842f, 0.02485224f, 0.21491152f, 
    -0.01854957f, 0.07548444f, 0.01112221f, 0.06608898f, 0.06285273f, 0.08598042f, 0.17394441f, 0.10323467f, 
    0.15597872f, -0.01784373f, -0.21853636f, -0.12799439f, -0.19780309f, -0.01265959f, -0.00416636f, 0.16995786f, 
    -0.21414670f, 0.18421999f, 0.03253969f, 0.11822464f, 0.04167430f, 0.04875253f, 0.34878534f, 0.08132368f, 
    -0.00497366f, 0.00984329f, -0.02143197f, 0.01374718f, -0.03969723f, -0.04242640f, 0.04093108f, 0.02498718f, 
    -0.01482858f, 0.00240611f, 0.04501041f, -0.02043631f, 0.04861924f, -0.04132733f, 0.04126574f, -0.01650320f, 
    -0.00813442f, -0.04191042f, 0.01635432f, -0.00408365f, -0.05960681f, 0.01168147f, -0.03681843f, -0.04088034f, 
    0.01900774f, -0.02335063f, -0.06995293f, -0.02526460f, -0.03415143f, -0.06360452f, 0.00681407f, -0.05327613f, 
    0.04675077f, 0.03747511f, 0.00069000f, -0.00321561f, 0.03324213f, -0.07248793f, 0.03859451f, 0.02057195f, 
    0.01523413f, -0.01350082f, 0.02065407f, 0.02495071f, 0.03846070f, 0.02258190f, 0.03030850f, -0.00488962f, 
    -0.04777709f, -0.02408287f, -0.03029978f, -0.01748641f, -0.04924959f, 0.05946523f, -0.05441896f, -0.02773013f, 
    -0.01194447f, 0.04333900f, -0.00227789f, 0.03965203f, 0.03484133f, 0.00759301f, -0.01417272f, -0.02710473f, 
    0.02747281f, -0.05198196f, -0.00264274f, 0.03821093f, -0.00654454f, 0.02879267f, -0.02844949f, -0.00492585f, 
    -0.03632132f, 0.00728511f, -0.02468317f, -0.04635675f, -0.06410984f, -0.00136475f, 0.00102934f, 0.01681347f, 
    -0.01294040f, 0.04241395f, -0.01425979f, 0.01676260f, 0.04329640f, 0.01115686f, 0.05119511f, -0.06658260f, 
    -0.05436213f, 0.04709128f, -0.04862373f, -0.00868228f, -0.04770249f, 0.03098211f, -0.02831679f, -0.03982855f, 
    -0.02259716f, -0.05329688f, -0.00914429f, 0.01654000f, -0.05802308f, -0.06782363f, -0.06764272f, -0.04175582f, 
    -0.02643422f, 0.03622216f, 0.01225402f, -0.07088697f, 0.04126558f, -0.00086621f, -0.06352020f, 0.04078607f, 
    -0.06601763f, 0.03139603f, -0.01850727f, 0.00893142f, 0.02398371f, -0.00500575f, 0.03662295f, 0.02020574f, 
    -0.05397224f, 0.01191789f, -0.00622284f, -0.06440203f, -0.03372550f, -0.01321033f, -0.05621307f, 0.03571938f, 
    0.06183101f, 0.02550650f, -0.06643630f, 0.04594317f, 0.00903504f, 0.04641703f, -0.01011327f, -0.03770263f, 
    -0.01199625f, -0.02471728f, 0.03825886f, -0.02880198f, -0.01646057f, -0.04264070f, -0.00932573f, 0.03709601f, 
    0.04149142f, -0.00048994f, 0.01123922f, -0.01149515f, -0.05101693f, -0.04566732f, -0.02384122f, -0.01060488f, 
    -0.00807816f, 0.00595444f, -0.02547592f, -0.01259062f, 0.03545653f, 0.03542034f, 0.04633835f, -0.00925180f, 
    -0.01891458f, -0.04681358f, -0.00520823f, -0.04900466f, -0.00731565f, 0.00478582f, -0.05410748f, -0.04397905f, 
    0.01136395f, -0.06345341f, -0.05106142f, 0.00100457f, -0.02735229f, 0.04523995f, -0.03543132f, -0.06822213f, 
    -0.01617312f, 0.01830539f, 0.03636209f, -0.00502787f, 0.01547959f, 0.02169041f, -0.03594716f, 0.04503448f, 
    0.03148899f, 0.00375634f, -0.01598308f, -0.04426927f, -0.03361337f, -0.04638382f, 0.03474213f, 0.02049853f, 
    -0.01839469f, -0.04792133f, 0.04437922f, 0.02846354f, 0.03714282f, 0.02339138f, -0.00274170f, 0.01443118f, 
    -0.03603990f, 0.01746974f, -0.03926820f, 0.02581159f, 0.02163221f, 0.02566402f, 0.01887942f, -0.00740286f, 
    0.01086041f, -0.04842003f, -0.01832697f, -0.04751547f, -0.05351583f, -0.01880723f, -0.05461989f, -0.01821323f, 
    -0.05072892f, -0.03955535f, 0.05159872f, -0.05330747f, 0.04375242f, -0.03745524f, -0.00824284f, -0.03142370f, 
    0.03598603f, -0.05666497f, 0.04263649f, -0.02986016f, 0.01202696f, -0.01571201f, -0.01063802f, -0.06295846f, 
    -0.05548549f, -0.04252477f, 0.01118687f, 0.00153116f, -0.03619931f, -0.05944513f, -0.04150501f, -0.02011268f, 
    0.02458823f, -0.02174999f, -0.03675878f, 0.00564645f, 0.02238017f, -0.03403803f, 0.04568240f, 0.03917291f, 
    -0.00406147f, 0.03521866f, 0.05025980f, 0.02488661f, -0.07130025f, 0.02024303f, -0.03506807f, -0.01152892f, 
    -0.03116629f, 0.03716463f, -0.06541400f, 0.01516742f, -0.03687808f, -0.00058533f, 0.00270620f, 0.00864547f, 
    -0.03192942f, 0.01087095f, 0.03860834f, -0.03849488f, 0.05008058f, -0.01828788f, 0.03332537f, -0.04920264f, 
    0.02339922f, 0.01231213f, 0.00406121f, 0.02474381f, 0.00252589f, -0.06430159f, -0.02024406f, 0.03057891f, 
    -0.00591937f, 0.03070803f, 0.01749828f, -0.00384323f, -0.03928015f, -0.00455304f, 0.02602278f, -0.03725684f, 
    0.01363205f, 0.40528914f, -0.23141089f, 0.06579877f, 0.14643018f, 0.04902620f, 0.03427358f, 0.06144911f, 
    0.03311025f, 0.39153433f, -0.03893458f, 0.16121966f, 0.06054671f, -0.12842236f, 0.01543388f, -0.03937095f, 
    0.00874512f, 0.19590224f, 0.02840028f, -0.02111715f, 0.10139945f, -0.28015852f, 0.12705299f, 0.07191128f, 
    0.06103476f, -0.07732687f, 0.03193359f, -0.00931178f, -0.14761649f, -0.27162689f, 0.05126438f, -0.24910611f, 
    -0.08424934f, 0.07751775f, 0.07491283f, 0.09473167f, 0.29063308f, 0.17829175f, 0.41036856f, -0.18489169f, 
    -0.08719622f, 0.03886110f, 0.07108261f, 0.02620623f, 0.01976814f, 0.28858724f, 0.24515565f, 0.21579947f, 
    -0.22713272f, -0.17610723f, -0.27501655f, 0.13136804f, 0.02327522f, 0.00431444f, -0.15157342f, -0.27800250f, 
    -0.45046753f, 0.20125186f, 0.06701571f, 0.13067791f, 0.02231517f, 0.08198451f, -0.02978966f, 0.03499329f, 
    -0.37554717f, 0.31544852f, 0.03290379f, 0.16567649f, 0.07484733f, 0.33398390f, 0.19664656f, 0.02219699f, 
    -0.34835050f, -0.07582864f, 0.43706593f, 0.11327570f, -0.19924226f, 0.07663569f, -0.00312006f, 0.14809701f, 
    0.16673288f, -0.33000678f, -0.39356637f, 0.09813440f, -0.49539483f, 0.13145672f, -0.39405784f, 0.05654426f, 
    -0.03381434f, -0.15718792f, -0.47443998f, 0.03962268f, -0.21360335f, -0.07606793f, -0.15807386f, -0.25186336f, 
    0.08928781f, 0.30985799f, 0.07907896f, 0.34101981f, 0.27057737f, 0.33035424f, -0.01576406f, -0.20657156f, 
    0.13891923f, 0.01761976f, 0.00373652f, 0.04152904f, 0.03793557f, -0.48297450f, -0.14027716f, -0.32229599f, 
    0.09821860f, -0.30102804f, -0.05077142f, -0.02963103f, -0.05830456f, 0.15629061f, -0.18380448f, 0.43186718f, 
    0.05240176f, -0.12454045f, -0.11062567f, 0.01071136f, 0.11281519f, 0.14554103f, -0.84365565f, -0.24898952f, 
    -0.80800581f, -0.24571013f, -0.19729435f, 0.32909900f, -0.06967348f, 0.00653369f, -0.10210683f, 0.26285812f, 
    0.09737991f, 0.35465032f, -0.00248255f, -0.11588123f, 0.14141701f, 0.10326748f, 0.09493846f, 0.09347839f, 
    0.14532472f, -0.05422830f, 0.14918789f, 0.06628420f, -0.15177979f, -0.07035520f, 0.11346958f, 0.08429317f, 
    0.15529124f, 0.13123898f, 0.07064686f, 0.46835032f, -0.20891874f, 0.05082643f, -0.12572734f, 0.13887784f, 
    -0.04659374f, 0.00410579f, -0.27755994f, -0.21838787f, -0.31079927f, 0.23494017f, -0.02611790f, 0.13906415f, 
    0.18081252f, 0.09315620f, 0.06411008f, -0.42368367f, -0.43605226f, -0.55022269f, -0.10695778f, -0.10994039f, 
    0.08693404f, -0.04595081f, 0.06355776f, 0.25475770f, 0.01771883f, -0.49331808f, -0.02126745f, -0.08847296f, 
    -0.26545078f, 0.06857821f, 0.01378602f, 0.17845103f, 0.22937812f, -0.27259073f, 0.02393374f, -0.08250592f, 
    -0.09642781f, -0.07328391f, -0.16219564f, 0.27929255f, -0.10865136f, 0.01998361f, -0.08727728f, -0.07489292f, 
    0.19333529f, -0.19601209f, 0.19199106f, 0.15385281f, 0.06118471f, 0.02224523f, -0.01344218f, -0.10780107f, 
    0.05931257f, 0.31875020f, -0.18332900f, 0.22033593f, 0.09235318f, 0.06724006f, -0.04086477f, -0.11970840f, 
    0.41582328f, -0.42801899f, 0.17892651f, -0.14973110f, 0.38739845f, -0.19707668f, -0.02121181f, -0.01993614f, 
    0.00742360f, -0.21244758f, -0.07853377f, 0.00146959f, -0.14561523f, -0.10672706f, 0.01292231f, 0.32522207f, 
    0.10640705f, -0.06147733f, -0.12709633f, -0.32402197f, -0.19388857f, 0.12000664f, 0.09509222f, 0.20007098f, 
    -0.08587465f, -0.03624109f, 0.04299631f, -0.08101297f, 0.03926928f, 0.39325696f, 0.20231818f, -0.13995099f, 
    -0.20164636f, 0.02863006f, 0.13624565f, -0.03641441f, -0.21649395f, -0.16142847f, -0.44444248f, -0.25950915f, 
    -0.00868871f, 0.15022379f, -0.04032657f, 0.15617597f, -0.09836765f, -0.28347889f, -0.05999165f, 0.07979733f, 
    -0.09319449f, 0.06228041f, -0.07649442f, 0.22652735f, 0.02192040f, 0.01950012f, 0.11333062f, 0.01413117f, 
    0.31783640f, -0.23902358f, -0.06242780f, -0.06893560f, 0.18958391f, -0.05516911f, 0.07408228f, -0.47434723f, 
    -0.30536550f, -0.63350523f, 0.19986312f, -0.15714496f, 0.09098148f, -0.02150331f, -0.12576039f, 0.20085552f, 
    0.06395733f, -0.15183420f, -0.06614045f, 0.05110390f, 0.06738591f, 0.06521481f, 0.08511686f, -0.11033811f, 
    -0.03285940f, -0.22659524f, -0.29113728f, 0.09715553f, -0.26014227f, 0.02463107f, -0.07397272f, 0.03009851f, 
    0.22029303f, -0.10677954f, -0.00690186f, 0.21446216f, 0.01646705f, -0.03574335f, 0.10341412f, 0.18330219f, 
    -0.06025450f, -0.06904920f, -0.05951454f, 0.13462389f, -0.03808609f, -0.09378426f, 0.05555075f, -0.22185290f, 
    0.16692917f, -0.07080594f, 0.24583302f, 0.05862245f, 0.18354869f, -0.24550049f, 0.16698715f, 0.09560478f, 
    0.18068458f, 0.12176727f, -0.08343939f, -0.25051245f, -0.26219741f, -0.06507531f, 0.01173473f, -0.14878847f, 
    -0.05628484f, -0.01561244f, 0.00975141f, -0.06621560f, -0.42858455f, -0.19745383f, 0.33201829f, -0.34816760f, 
    -0.48585135f, 0.10634924f, -0.06031640f, -0.14299236f, 0.32896569f, 0.27642554f, 0.00436469f, -0.28708455f, 
    -0.02068824f, -0.17963102f, -0.06604342f, -0.01230584f, 0.15812169f, 0.11663590f, -0.00768880f, 0.16552278f, 
    -0.44275346f, 0.01079093f, 0.16009375f, 0.04218622f, 0.02616765f, 0.01673581f, -0.27643356f, 0.07231464f, 
    0.13887636f, 0.09783871f, 0.05602773f, -0.36872420f, 0.02373991f, 0.24042453f, 0.15491085f, 0.24283773f, 
    -0.01416691f, 0.00249082f, 0.69519556f, 0.19376977f, -0.12812042f, 0.05188736f, -0.00066412f, -0.07778205f, 
    0.01743245f, 0.02452391f, 0.06556554f, -0.06927032f, 0.05857693f, 0.10113846f, 0.12209764f, -0.01653158f, 
    0.07407661f, -0.02933705f, 0.05997494f, -0.12691079f, 0.01646005f, -0.30477983f, -0.49200290f, 0.34148857f, 
    0.30133632f, 0.20678656f, 0.28625682f, 0.03544093f, -0.43010852f, -0.26257423f, -0.36000142f, 0.08116816f, 
    0.14474642f, -0.00685165f, 0.09709371f, -0.18206064f, 0.04489081f, 0.11726180f, -0.13416320f, -0.10818021f, 
    -0.16321360f, 0.00826377f, 0.24234290f, -0.26110455f, -0.06691283f, 0.21089540f, -0.07747886f, -0.13554993f, 
    -0.28201669f, -0.13255575f, 0.16841663f, -0.03911823f, 0.06192217f, -0.05386029f, 0.08916567f, -0.22246130f, 
    -0.04440382f, -0.21085142f, -0.17842348f, 0.08170091f, 0.01639592f, 0.17293496f, 0.09783923f, 0.03345404f, 
    -0.08597740f, -0.29431662f, 0.00355551f, 0.01882226f, 0.33255652f, -0.06472284f, -0.01140372f, -0.10717330f, 
    0.01771827f, 0.16562061f, 0.18704550f, 0.02227465f, -0.09306861f, -0.07297108f, 0.09662276f, -0.03966710f, 
    0.01188570f, 0.37311649f, 0.12220410f, 0.27709654f, -0.18046592f, -0.01770435f, 0.11481395f, -0.08287439f, 
    0.05857714f, -0.04725396f, 0.15109658f, 0.12306274f, -0.57195246f, -0.12245508f, 0.17502925f, -0.17748353f, 
    0.03567235f, 0.00890194f, -0.17080185f, -0.01719130f, 0.00975737f, 0.21350731f, -0.09041645f, -0.24919437f, 
    -0.12765072f, 0.10636224f, -0.05095599f, 0.18736286f, -0.41910964f, 0.20661163f, 0.00845063f, -0.11662209f, 
    0.03744214f, 0.01760859f, -0.02140472f, -0.06650336f, -0.04112366f, 0.13805190f, 0.02785037f, -0.09450778f, 
    -0.12939671f, -0.01248661f, 0.20630227f, 0.04007300f, 0.20933288f, -0.16357656f, 0.19462097f, 0.06279129f, 
    -0.03193811f, -0.50822842f, -0.18183842f, 0.16009340f, 0.05607442f, 0.17281209f, 0.29355651f, -0.21931575f, 
    -0.11795793f, 0.27153853f, -0.19087392f, -0.09145357f, 0.17688271f, 0.24681182f, 0.02371563f, 0.15514423f, 
    0.30021453f, -0.01568307f, -0.45837781f, 0.09175674f, -0.03806678f, -0.16676325f, -0.18559042f, 0.04132301f, 
    0.07892744f, 0.09324078f, -0.05824884f, 0.32780048f, -0.04120842f, -0.02876773f, 0.08694171f, 0.12770700f, 
    0.11153901f, -0.13751522f, 0.12242765f, 0.07869451f, -0.16902810f, 0.22815403f, 0.04503724f, -0.04818025f, 
    -0.02087929f, -0.03542762f, -0.14336076f, 0.09735310f, -0.03116136f, -0.30091792f, 0.08226673f, -0.09330544f, 
    -0.08837708f, -0.04447993f, -0.14264071f, 0.11881357f, -0.23209931f, 0.02309103f, -0.27255997f, 0.39248693f, 
    0.19825681f, 0.07202698f, 0.00156809f, -0.03821661f, 0.21708904f, 0.08022909f, 0.09887949f, -0.29593262f, 
    -0.17508659f, -0.14426522f, 0.07959769f, 0.08116120f, -0.16406472f, 0.05545287f, 0.07977095f, 0.15390700f, 
    0.24821834f, 0.28339833f, -0.20655181f, 0.09369162f, 0.02288374f, 0.09343442f, -0.11275857f, -0.06599640f, 
    -0.11138172f, 0.30845791f, -0.06294582f, 0.54247832f, -0.03677071f, -0.08742598f, -0.20886047f, 0.04922538f, 
    -0.05884875f, 0.16781640f, -0.05282021f, -0.10331599f, -0.19799998f, 0.06649315f, -0.06159554f, 0.22678192f, 
    0.08900756f, 0.18661806f, 0.32764694f, 0.25397417f, 0.22807169f, 0.14177966f, 0.02235153f, 0.01503788f, 
    0.04415495f, 0.10775653f, 0.05022575f, 0.21521850f, 0.08600078f, -0.52763498f, 0.19631256f, 0.15023315f, 
    0.28908938f, 0.41592082f, 0.01761472f, 0.07326853f, 0.13975066f, -0.00188982f, -0.07478215f, -0.15632948f, 
    -0.11000040f, 0.19578849f, 0.01161542f, -0.13802223f, -0.11903574f, 0.04900584f, 0.19408646f, -0.07088730f, 
    -0.05786825f, 0.02767343f, 0.00182643f, -0.10581908f, 0.09180287f, 0.28757632f, -0.06132799f, -0.02468865f, 
    0.23684108f, 0.13580662f, -0.19706662f, 0.11637081f, -0.09163855f, 0.20697026f, 0.12656511f, 0.04046296f, 
    -0.13961017f, 0.03383581f, 0.30842468f, 0.07599557f, 0.10752270f, -0.06666040f, -0.12993656f, 0.05797112f, 
    0.04888941f, -0.09981819f, 0.34288189f, -0.45772451f, -0.02798072f, 0.18072189f, -0.20502363f, 0.18317682f, 
    0.07879174f, -0.06928874f, 0.02522697f, 0.13384339f, -0.20399702f, 0.02572344f, 0.27581173f, -0.03833273f, 
    0.21181512f, -0.25570992f, -0.36051139f, -0.00624153f, -0.11178537f, -0.03940929f, 0.03857781f, -0.20325120f, 
    -0.07782164f, -0.15613025f, 0.04109643f, 0.06358770f, 0.28234401f, 0.02975789f, -0.29179338f, 0.18832974f, 
    -0.03145137f, -0.16373856f, 0.10359265f, -0.02652231f, -0.03834249f, 0.00061016f, -0.17646159f, -0.09594966f, 
    -0.04118049f, 0.16620842f, -0.01270488f, -0.28695977f, -0.16839989f, -0.12353317f, -0.26948211f, 0.22443084f, 
    0.47251353f, 0.03200409f, 0.07676189f, 0.03400184f, -0.02887310f, 0.06807857f, -0.08311262f, -0.25422341f, 
    -0.34319717f, -0.03225392f, 0.11608534f, -0.13497996f, -0.07515271f, -0.30914855f, -0.04040010f, 0.00651534f, 
    -0.06137400f, -0.06943794f, -0.03848176f, -0.01317456f, 0.11721184f, -0.04891801f, 0.02596795f, -0.06988678f, 
    -0.24200116f, -0.03600730f, -0.01828062f, 0.18879035f, 0.13275287f, -0.12830904f, -0.04247797f, -0.06047990f, 
    0.07850929f, 0.05247688f, 0.36253729f, 0.24001445f, 0.21267824f, 0.21170397f, -0.04872916f, 0.27092913f, 
    0.28979406f, 0.29319778f, 0.01139281f, 0.28069022f, 0.26499271f, -0.21587135f, 0.01122525f, 0.11739440f, 
    0.08492782f, -0.03724534f, -0.07243370f, -0.23770042f, -0.36230794f, 0.04878593f, 0.20780478f, -0.14496213f, 
    0.02450800f, 0.05186803f, 0.02892515f, -0.06602494f, -0.13622800f, -0.02868081f, 0.01236246f, -0.16230960f, 
    -0.00357416f, 0.03540036f, -0.04715014f, 0.28080788f, 0.06494708f, 0.10034254f, 0.11152758f, -0.18882605f, 
    0.09047005f, 0.12459818f, -0.04268235f, -0.01132936f, -0.01026927f, 0.05811576f, 0.23587893f, 0.12732318f, 
    -0.10408415f, 0.05236627f, 0.21220222f, 0.01183441f, 0.10148186f, 0.02035357f, 0.05219315f, 0.11698584f, 
    0.06556578f, -0.13758868f, -0.09124081f, -0.08807938f, -0.04176462f, -0.23388287f, 0.15145230f, -0.10064775f, 
    -0.09587508f, -0.06957236f, -0.04879709f, 0.07624447f, 0.01689668f, 0.04936370f, 0.19022867f, 0.07977502f, 
    0.45452136f, -0.18132523f, -0.15896256f, 0.22732194f, 0.23348494f, 0.00878299f, -0.13881926f, 0.01705135f, 
    -0.09156209f, 0.04529786f, -0.12611333f, 0.14336458f, -0.16287693f, 0.04781681f, 0.06846204f, 0.04998626f, 
    0.30528787f, 0.03263479f, 0.15844864f, -0.00892683f, -0.02873534f, 0.24605612f, -0.02089296f, -0.11300172f, 
    0.04323786f, -0.01696476f, -0.04585792f, -0.02617652f, -0.28840190f, -0.04694289f, 0.32544142f, -0.25151393f, 
    -0.16033925f, -0.00248118f, 0.03149180f, 0.04194183f, 0.00703934f, -0.11638798f, -0.21382797f, 0.19037046f, 
    0.06908011f, 0.04162525f, 0.08681321f, 0.05283321f, 0.22242963f, 0.10311958f, 0.11674222f, 0.19708523f, 
    0.06700727f, 0.09810119f, -0.06650992f, 0.08683306f, -0.04426602f, -0.13519031f, -0.00713142f, -0.19105569f, 
    0.02762830f, -0.06364824f, 0.03234641f, 0.01916826f, -0.03032765f, 0.01972847f, 0.02384187f, 0.00400167f, 
    -0.05946391f, -0.01672581f, -0.01532131f, -0.00641718f, 0.05010438f, 0.03032124f, 0.03284747f, 0.02024631f, 
    0.00033155f, -0.03710114f, 0.04771285f, -0.05928339f, -0.03146977f, -0.00489414f, -0.03935609f, -0.05100206f, 
    -0.01480150f, -0.01180119f, -0.01446339f, -0.02523126f, 0.03543908f, -0.02279611f, -0.05648925f, -0.04468593f, 
    0.04094988f, -0.01982309f, 0.01809368f, 0.00224706f, 0.03425582f, -0.05605567f, 0.02024978f, 0.03319401f, 
    0.00558254f, 0.00298008f, -0.00971719f, -0.06260832f, -0.04775053f, -0.01306707f, 0.04604828f, -0.05252027f, 
    0.04219389f, -0.02352128f, -0.01681139f, 0.03801928f, 0.01543076f, -0.03992308f, -0.00366945f, -0.03058885f, 
    0.01138034f, -0.02074226f, -0.03931101f, 0.01291068f, 0.04703541f, 0.01427894f, -0.01876338f, -0.06002758f, 
    -0.04606688f, 0.03389550f, -0.05405670f, -0.02701170f, 0.01245923f, -0.06331904f, 0.03989835f, -0.01060194f, 
    0.01143281f, -0.03861598f, 0.00928500f, 0.00537159f, 0.01003598f, -0.05259424f, -0.03725896f, -0.04086765f, 
    0.00742556f, 0.04410740f, 0.02614798f, -0.00116881f, 0.03673190f, -0.03904711f, -0.04700914f, -0.01920702f, 
    0.04427346f, -0.05956858f, -0.04067357f, 0.05024054f, -0.06192161f, -0.06198496f, -0.04184936f, 0.02147280f, 
    -0.06481703f, 0.00289118f, 0.03529052f, -0.05571448f, 0.03505057f, -0.03978760f, -0.04683035f, 0.02916673f, 
    0.01621687f, -0.06538701f, -0.04456808f, 0.03728817f, -0.03865007f, 0.00390701f, 0.04154118f, 0.00528857f, 
    -0.02265836f, -0.01212248f, -0.05805781f, 0.05394608f, 0.03094930f, -0.02595077f, 0.00857703f, 0.01402928f, 
    0.04030898f, 0.04407521f, -0.02429312f, -0.03460734f, -0.01054190f, -0.05116817f, -0.03593463f, 0.04751781f, 
    -0.03261990f, -0.01603649f, 0.04955249f, 0.01097322f, -0.02513051f, -0.04807260f, -0.02824866f, 0.04295022f, 
    -0.01384822f, 0.00052185f, 0.03023670f, 0.00636990f, -0.06251599f, -0.03766504f, 0.04097664f, 0.03633219f, 
    0.03432022f, 0.02063267f, -0.01150655f, -0.00107094f, 0.00208144f, -0.00188783f, -0.02676735f, 0.02306389f, 
    0.02357972f, -0.00211060f, -0.04269035f, 0.04106657f, -0.06303076f, 0.00699540f, 0.01287686f, 0.00617238f, 
    -0.01203523f, -0.01701670f, -0.04002742f, 0.02035693f, -0.05410787f, -0.02904767f, -0.02143057f, -0.00952329f, 
    -0.05736008f, 0.04510622f, -0.00281237f, -0.05609757f, -0.04757501f, 0.02340969f, 0.02224778f, -0.06407011f, 
    -0.02775118f, 0.00238155f, 0.01873973f, -0.00295900f, -0.00659765f, 0.01302928f, -0.04328030f, -0.03339667f, 
    0.00444727f, 0.01829433f, 0.00698216f, -0.02330934f, 0.01007900f, -0.03512219f, -0.05319512f, -0.00206947f, 
    0.03911777f, -0.02330674f, 0.03068755f, 0.01092850f, 0.04761762f, 0.04487396f, 0.05151857f, -0.04193769f, 
    0.04313742f, 0.03040704f, 0.00828414f, -0.06288341f, -0.03235938f, 0.03555012f, 0.04897957f, -0.06051312f, 
    -0.00413305f, 0.02149173f, -0.05882537f, -0.03426766f, -0.01804988f, -0.01536475f, -0.00429014f, -0.05473845f, 
    0.00564795f, -0.06594893f, 0.04735438f, 0.02607162f, 0.02403616f, -0.04515470f, 0.01426340f, -0.04778008f, 
    -0.04357793f, 0.02286609f, -0.06198945f, 0.02816783f, -0.01672361f, -0.02177971f, 0.03266366f, -0.00397716f, 
    0.01471187f, -0.04175103f, 0.01851972f, 0.02593127f, 0.01466843f, 0.01677680f, 0.03394364f, -0.05408114f, 
    0.05044350f, -0.04249500f, 0.02598052f, 0.00719334f, 0.01917116f, 0.01561622f, -0.03643742f, 0.01323245f, 
    -0.01163382f, -0.01847767f, -0.00707429f, -0.00593419f, 0.02113075f, -0.00710973f, 0.04009156f, -0.02793086f, 
    0.01380021f, 0.00121646f, 0.01131725f, -0.00702024f, -0.00492399f, -0.03505965f, 0.02425570f, -0.04140509f, 
    -0.01492005f, 0.00278635f, -0.04809300f, -0.02455164f, -0.06391381f, -0.04783339f, -0.01271204f, -0.01467102f, 
    -0.05618230f, -0.03520333f, -0.00910849f, -0.02449975f, 0.04107862f, -0.00561511f, -0.03448659f, 0.02695707f, 
    -0.01475514f, 0.03714125f, 0.00237571f, -0.03453483f, -0.01912479f, -0.02155434f, -0.01684789f, -0.06628395f, 
    -0.28533617f, -0.07778081f, 0.01531442f, -0.23805103f, 0.16613418f, -0.04714359f, 0.03518650f, 0.05469769f, 
    -0.06104134f, 0.18433370f, 0.06850728f, 0.14636207f, 0.01987981f, 0.02840188f, -0.18512610f, 0.08073998f, 
    -0.10171212f, -0.07581912f, 0.02224533f, -0.35973939f, 0.17017996f, -0.11116739f, -0.08533059f, -0.37307164f, 
    0.05449943f, 0.00084548f, 0.13543101f, -0.16783066f, -0.15261513f, 0.00794015f, 0.07881681f, 0.04702989f, 
    -0.02463640f, 0.14394900f, -0.10481840f, -0.02569924f, -0.21385489f, 0.06208177f, -0.28118694f, -0.14993046f, 
    -0.06115429f, 0.13582876f, 0.08438396f, 0.13123421f, 0.10057524f, -0.07826535f, 0.05283892f, -0.15928306f, 
    -0.17165831f, -0.29460329f, -0.16683057f, -0.06010367f, 0.08907418f, 0.04865545f, -0.29329872f, 0.27089599f, 
    0.14376429f, -0.11970767f, 0.30786437f, 0.42930156f, -0.15724207f, 0.02213771f, -0.05264852f, -0.12742014f, 
    0.50325757f, -0.02545661f, 0.02515072f, -0.05282395f, -0.08399612f, 0.07938883f, -0.09864565f, 0.17286706f, 
    -0.18856637f, -0.19669041f, -0.23075950f, 0.02833826f, -0.36625519f, 0.00472747f, 0.01237382f, 0.04308716f, 
    0.02078680f, -0.61744022f, -0.00180598f, 0.14109556f, -0.26279122f, -0.10099204f, -0.40150928f, 0.08698157f, 
    0.10424069f, 0.01454988f, -0.54117113f, 0.36697504f, -0.18202341f, -0.19975226f, -0.01765055f, -0.03009243f, 
    0.06946393f, 0.18247040f, 0.06381888f, -0.05785708f, 0.11620052f, 0.20637782f, -0.07507939f, 0.03255944f, 
    0.09286726f, 0.00210262f, 0.00936180f, -0.01128252f, -0.24549295f, 0.01076824f, -0.08507310f, -0.09795582f, 
    0.11228763f, -0.05715710f, -0.01777320f, 0.07498040f, 0.15615484f, 0.33564979f, -0.10572725f, -0.17979464f, 
    0.05671925f, -0.08915082f, -0.02703895f, 0.09197485f, 0.01378065f, 0.02646990f, -0.00926295f, -0.42231211f, 
    -0.36839589f, 0.17045830f, 0.26979941f, 0.06327231f, 0.11973403f, -0.05049650f, 0.03019555f, -0.02692768f, 
    0.37922245f, 0.23828670f, -0.02543425f, -0.08860763f, 0.01900254f, 0.01668180f, -0.17382579f, 0.03145369f, 
    -0.05777059f, 0.16725776f, 0.06182927f, -0.09047782f, 0.01047320f, -0.14664207f, -0.02069715f, 0.05265137f, 
    -0.02716582f, -0.05714665f, 0.60236561f, 0.34754089f, -0.04120519f, 0.07692911f, -0.02837222f, -0.05937642f, 
    0.01294829f, -0.02594850f, 0.06998215f, -0.20016608f, -0.08026221f, 0.07016516f, 0.26892850f, 0.26479724f, 
    0.01790332f, -0.23530532f, 0.03237472f, -0.19566907f, -0.06725195f, 0.12955585f, -0.06412705f, 0.01842785f, 
    -0.16892904f, -0.09341937f, 0.15331922f, -0.05284063f, 0.08166765f, -0.08869808f, -0.00300817f, 0.00751166f, 
    -0.02962180f, -0.04748550f, 0.12360690f, -0.16456376f, 0.20698275f, -0.21152276f, 0.08179443f, -0.11348537f, 
    0.27000332f, 0.00486423f, 0.15282725f, -0.20412582f, -0.07989651f, 0.03568990f, -0.00831383f, 0.17559242f, 
    0.01754308f, 0.06327660f, 0.14166182f, 0.07147696f, -0.04003296f, -0.02584910f, 0.08006096f, 0.15318403f, 
    0.16134253f, -0.05447705f, -0.05578560f, -0.03777458f, 0.08169940f, 0.10751884f, 0.04229608f, 0.03444368f, 
    -0.00675921f, 0.44967490f, 0.47230002f, -0.21336475f, -0.17230977f, -0.18282348f, -0.04203732f, 0.01563823f, 
    0.10683101f, -0.25075147f, 0.20906267f, 0.42960301f, -0.16541532f, -0.00482987f, 0.12562248f, -0.04809644f, 
    -0.10546087f, 0.07998281f, 0.03286405f, -0.65086985f, -0.05708236f, -0.04805830f, -0.05650444f, -0.00384667f, 
    0.01350975f, 0.11602138f, -0.04635048f, -0.20149806f, 0.32404482f, -0.25035167f, -0.10386378f, -0.19140078f, 
    0.07938285f, 0.06290746f, 0.03718124f, 0.06062599f, -0.18440126f, -0.06013097f, 0.17136607f, -0.01851002f, 
    -0.06368093f, -0.17501192f, 0.11717634f, 0.10459638f, -0.02519960f, -0.15022552f, 0.30610478f, 0.18054603f, 
    -0.14957783f, 0.14063945f, -0.08702992f, 0.26884446f, 0.30061555f, -0.00239648f, -0.10162567f, 0.09028983f, 
    0.08361392f, 0.00152007f, -0.17977022f, -0.05513042f, 0.00303860f, 0.32854483f, -0.09675525f, -0.17416143f, 
    -0.05334477f, -0.02794690f, -0.06875981f, -0.08101355f, 0.03805586f, -0.14488450f, -0.00784775f, 0.03170576f, 
    -0.10515586f, -0.91426194f, -0.28269464f, 0.05438707f, 0.00314324f, -0.17197916f, -0.02769458f, -0.17066973f, 
    0.10192045f, 0.18591499f, 0.12216398f, 0.02717477f, 0.04281615f, -0.03193033f, 0.02772053f, -0.04999522f, 
    -0.05507270f, -0.18638711f, -0.54271358f, -0.27592212f, -0.35199305f, -0.19520980f, -0.03116625f, -0.02394697f, 
    0.15776838f, 0.03057154f, 0.06528756f, -0.21375968f, 0.04683359f, 0.18370233f, -0.16252936f, -0.09703254f, 
    0.02547062f, 0.10410418f, 0.00316469f, -0.05617944f, -0.27953219f, 0.13417198f, -0.35658285f, -0.05177850f, 
    -0.20038278f, -0.03908710f, 0.01740726f, 0.07569823f, 0.29605591f, 0.05038107f, 0.11850707f, 0.31835207f, 
    -0.17920725f, -0.13255443f, -0.16680908f, 0.07619929f, 0.20723581f, 0.13728490f, 0.41264361f, -0.30421078f, 
    0.04230506f, 0.22867361f, -0.03457370f, 0.06121180f, 0.04730175f, -0.04392767f, 0.04850622f, -0.12405822f, 
    -0.14926165f, 0.05822475f, 0.37307012f, -0.04918111f, 0.21191870f, 0.12174676f, -0.04781514f, -0.16906077f, 
    0.11328549f, 0.04680069f, 0.04850777f, 0.00804970f, 0.14145063f, -0.04452588f, -0.14013983f, 0.00445317f, 
    0.02928347f, -0.86180246f, -0.31005427f, 0.12128992f, -0.04495763f, -0.06793716f, -0.09536985f, 0.29713207f, 
    0.16991350f, 0.17481311f, -0.26471347f, -0.27782738f, -0.15542735f, -0.23814431f, -0.09080596f, -0.12943497f, 
    0.35047328f, 0.11654973f, 0.13512586f, -0.00807200f, 0.00621059f, 0.06269461f, -0.03214858f, 0.03821280f, 
    -0.01988216f, 0.17494854f, -0.06698360f, -0.04906679f, -0.52610105f, -0.25593787f, -0.06718748f, 0.06274445f, 
    -0.02792310f, 0.10061244f, 0.24050722f, -0.11356652f, 0.06183553f, -0.04686804f, 0.30235448f, 0.26114383f, 
    0.06361987f, 0.15392713f, -0.11654545f, 0.07014878f, -0.06478688f, 0.09586343f, 1.14942527f, -0.23573270f, 
    -0.94793653f, 0.14401156f, -0.04979435f, 0.15646894f, 0.12495506f, 0.13667952f, 0.08674242f, 0.07394368f, 
    -0.17984295f, -0.06536366f, -0.06505325f, -0.21230116f, -0.02732281f, -0.02459039f, -0.21327740f, -0.16415627f, 
    0.11356848f, 0.34098288f, 0.20275824f, -0.09743002f, -0.03686463f, 0.05156975f, 0.14977895f, 0.04304260f, 
    0.02431682f, -0.00968631f, 0.12219074f, 0.22850934f, -0.32331559f, -0.09308279f, -0.23708983f, -0.00330899f, 
    -0.01878313f, 0.00601960f, 0.52998841f, -0.07309651f, -0.04433292f, 0.15929708f, 0.13739730f, 0.26700971f, 
    0.25485122f, 0.00475047f, 0.08859370f, -0.19625413f, -0.22607653f, -0.13258989f, -0.06764551f, 0.03908282f, 
    -0.24626099f, -0.13252939f, 0.01317623f, -0.22399853f, -0.01238760f, -0.03333019f, -0.18801373f, -0.03665337f, 
    -0.13650681f, -0.05237487f, 0.08844952f, -0.26673537f, -0.10082005f, -0.13269438f, -0.30284563f, -0.40168872f, 
    -0.11583754f, -0.07986166f, -0.09127411f, 0.14737886f, 0.07557924f, 0.10353677f, -0.19766390f, -0.00826705f, 
    -0.05029287f, -0.04386742f, -0.09934182f, 0.10907976f, 0.10108268f, 0.02649571f, 0.11628379f, 0.03809053f, 
    -0.17569096f, -0.01245180f, 0.13532040f, -0.10002320f, -0.11418762f, 0.14492725f, -0.06847752f, -0.01273110f, 
    -0.46432975f, -0.23550750f, 0.07616895f, 0.03356344f, -0.33314341f, -0.20441504f, 0.19817874f, -0.03602354f, 
    -0.23527701f, 0.35541648f, 0.17651837f, -0.09770356f, -0.04962106f, 0.05860647f, 0.04153183f, 0.02039864f, 
    0.14484240f, 0.11091808f, 0.66139364f, -0.10035164f, -0.15479825f, -0.05520791f, 0.11733947f, -0.00668467f, 
    0.08601457f, 0.06106346f, 0.08037406f, 0.42845824f, -0.02871732f, 0.01544780f, -0.09551357f, 0.26372826f, 
    0.14774549f, 0.17592013f, 0.04235139f, 0.17647658f, -0.17096268f, 0.06434624f, -0.02067770f, -0.07195820f, 
    0.01206020f, -0.16361727f, -0.05251382f, 0.08345994f, 0.01731683f, -0.29658124f, -0.47700718f, -0.30992413f, 
    0.15584207f, -0.04866975f, -0.19819294f, -0.15484366f, 0.08233747f, 0.19419110f, -0.15999427f, -0.01373065f, 
    -0.22481109f, 0.23510529f, 0.21465102f, -0.11086470f, 0.24528575f, 0.12170172f, 0.34238425f, 0.02857687f, 
    -0.41548586f, -0.16156453f, 0.00060406f, 0.12867850f, 0.04331736f, -0.07244138f, -0.16987219f, 0.03700311f, 
    -0.20467414f, -0.47225153f, 0.13486944f, -0.02925623f, -0.08459372f, 0.02890950f, 0.04695064f, 0.08005282f, 
    0.11408909f, -0.54142553f, -0.44075119f, -0.00451690f, -0.05874428f, 0.04592853f, -0.08024509f, -0.09252526f, 
    -0.00071747f, 0.00100065f, 0.17322977f, -0.06964218f, 0.37289912f, -0.10863043f, -0.22846378f, -0.36917800f, 
    -0.03520315f, -0.15911594f, 0.05733083f, -0.44568083f, -0.19679230f, -0.28752699f, 0.05529824f, -0.12651370f, 
    -0.37982821f, 0.03362344f, -0.12028089f, -0.11789537f, 0.28735530f, 0.16112113f, -0.07834985f, -0.39971650f, 
    -0.34576455f, -0.12517674f, 0.09474291f, -0.00268503f, 0.24056296f, 0.15362448f, 0.19102298f, 0.04226671f, 
    -0.48871100f, -0.27728215f, -0.32824197f, 0.10681198f, -0.10034467f, -0.11215588f, 0.18888995f, 0.02732644f, 
    -0.24156086f, 0.06142047f, -0.13811655f, -0.21549252f, -0.12460370f, 0.16713277f, 0.11741768f, 0.00646465f, 
    -0.10960600f, 0.19732867f, -0.02054318f, 0.12500407f, -0.04787904f, 0.11672724f, -0.22440490f, 0.18893930f, 
    0.08936464f, -0.08222391f, -0.47230518f, 0.18812284f, -0.03476148f, 0.01152315f, 0.04454179f, -0.02457856f, 
    0.15498225f, 0.30052379f, 0.15273452f, 0.14818965f, -0.04227999f, 0.08056530f, -0.15789984f, 0.15146385f, 
    0.13388285f, 0.08472328f, 0.12624262f, -0.05310883f, 0.00905449f, 0.13889860f, 0.07980043f, -0.00326233f, 
    -0.00062305f, 0.22101606f, -0.01653923f, -0.60576743f, -0.49250162f, 0.10790012f, 0.04039137f, 0.04697977f, 
    0.20822658f, 0.00006689f, -0.01001608f, 0.28923410f, 0.52038884f, 0.12807277f, 0.24292064f, 0.10922551f, 
    0.10891787f, 0.15268442f, 0.25275975f, 0.10681339f, -0.17803375f, 0.48769027f, -0.01460335f, -0.04539652f, 
    -0.08362273f, 0.23463440f, 0.12301555f, 0.07631071f, -0.00264084f, 0.04185627f, 0.00551760f, 0.28781119f, 
    -0.23163293f, 0.02030996f, -0.03691646f, 0.33288726f, 0.25822055f, 0.34370476f, 0.05787936f, -0.52764690f, 
    -0.08913465f, -0.09777899f, 0.15386255f, 0.05384163f, 0.27482283f, -0.02322889f, -0.02978837f, 0.10515037f, 
    0.25821882f, 0.15241545f, -0.22801286f, -0.10369855f, 0.04810377f, 0.16279012f, 0.02978666f, 0.04972157f, 
    -0.00808314f, -0.52330786f, -0.59409517f, -0.14440596f, -0.06296465f, 0.08646718f, -0.08042973f, 0.07512657f, 
    -0.16725461f, -0.10868965f, -0.29211932f, 0.05768540f, -0.22129525f, -0.01902230f, 0.07094912f, -0.03955037f, 
    -0.29578045f, 0.05663469f, -0.30510765f, -0.02730319f, -0.03258975f, -0.02175683f, -0.03171011f, 0.13499962f, 
    0.02976174f, -0.03202782f, 0.04832670f, -0.04930363f, 0.03195063f, 0.01561193f, 0.01886886f, -0.05464995f, 
    -0.11691375f, 0.13226652f, 0.14014734f, -0.10476480f, -0.05808297f, 0.10726246f, 0.08508339f, -0.12212510f, 
    -0.22050583f, -0.24604341f, -0.10541808f, 0.08329938f, -0.06519707f, -0.05144141f, -0.11765067f, 0.02034624f, 
    -0.04111979f, 0.03325769f, -0.02437680f, -0.24787341f, 0.00313690f, 0.07513431f, 0.06231782f, 0.23918325f, 
    0.13117985f, 0.34452108f, -0.10212374f, 0.12763642f, -0.07317115f, 0.02707835f, 0.02314662f, -0.13779503f, 
    0.35638717f, 0.10132258f, -0.09522391f, -0.18530674f, 0.25690943f, 0.29127094f, 0.30799338f, 0.13682824f, 
    -0.06035114f, -0.03159356f, -0.05951656f, -0.18187156f, -0.04369389f, 0.18215099f, -0.23252164f, 0.07823935f, 
    -0.18091954f, 0.22936533f, -0.05425015f, -0.22042850f, 0.20697029f, -0.04747348f, -0.02931437f, 0.07120090f, 
    0.06507975f, -0.12104009f, 0.35255712f, 0.33657888f, -0.12529036f, -0.30709943f, -0.11764954f, 0.14321882f, 
    -0.01245348f, 0.13993286f, 0.26141581f, -0.01376737f, -0.12271641f, 0.03886253f, 0.09944356f, 0.00991632f, 
    0.13872412f, -0.04136785f, 0.01590144f, -0.18447429f, 0.05364479f, -0.05906326f, -0.13893194f, 0.22186458f, 
    0.00085154f, -0.02166629f, -0.11493267f, 0.13634478f, 0.01153829f, 0.03364328f, 0.06017494f, 0.00083846f, 
    0.05728154f, -0.00265666f, -0.11597311f, -0.07083437f, 0.07795766f, -0.12771772f, 0.11563865f, -0.09299897f, 
    -0.10487015f, -0.04537497f, -0.04164670f, 0.05890088f, -0.06815133f, -0.01175984f, -0.35469401f, 0.15302745f, 
    -0.58976841f, -0.15099955f, -0.08344152f, -0.08201569f, -0.29126090f, 0.24235556f, -0.14552973f, 0.01756880f, 
    0.21193831f, -0.11371430f, 0.03745549f, -0.19630049f, -0.09686365f, -0.18003578f, 0.03991698f, -0.06342673f, 
    0.27286816f, 0.05598965f, 0.27034214f, 0.19715813f, -0.02896210f, -0.02881026f, 0.23993127f, -0.23089488f, 
    -0.06006358f, 0.27055266f, -0.33224127f, 0.44174120f, 0.26574302f, -0.38477120f, 0.11634336f, -0.19945197f, 
    -0.17712046f, 0.01679167f, 0.04320411f, -0.23787665f, 0.09308630f, 0.26554358f, 0.21178246f, 0.23692060f, 
    0.14383806f, 0.28347149f, 0.10312603f, 0.09666774f, -0.17826232f, 0.08473931f, -0.09089112f, -0.06781758f, 
    -0.12292436f, 0.00794085f, -0.28348708f, 0.02470422f, 0.13420932f, -0.34225932f, -0.13946496f, -0.11968878f, 
    -0.06210837f, 0.16483198f, 0.12343738f, 0.13289544f, 0.01611556f, 0.06849943f, 0.26138219f, -0.21939825f, 
    -0.12154529f, 0.57133996f, -0.03289631f, 0.03996832f, 0.00312350f, -0.00963381f, 0.07199050f, 0.11524730f, 
    0.55845237f, 0.06237935f, -0.06896640f, -0.00754494f, -0.06741023f, -0.34068790f, 0.12490788f, -0.13781935f, 
    0.10592225f, 0.62942582f, 0.49482745f, 0.17163661f, 0.02325532f, -0.00710873f, 0.04712202f, 0.00257279f, 
    0.13705811f, 0.13975634f, -0.05095594f, -0.08554013f, -0.14908057f, 0.06287463f, -0.10058917f, -0.03367803f, 
    0.08122977f, 0.14451431f, -0.08592448f, -0.05051880f, -0.13379407f, -0.15151659f, -0.09821803f, -0.09920518f, 
    0.12717204f, -0.02834685f, 0.06544051f, 0.02360461f, 0.63383573f, 0.33270308f, -0.25458890f, -0.04401699f, 
    -0.01632659f, 0.13467842f, -0.02887092f, -0.04444413f, -0.01181549f, 0.08783281f, 0.19494306f, 0.13235253f, 
    0.22939491f, 0.16068281f, 0.08430753f, 0.00192254f, -0.01796629f, 0.00857877f, -0.10958640f, 0.00488875f, 
    0.11013028f, 0.00218967f, 0.17572045f, 0.28711185f, -0.02543260f, -0.19097097f, 0.11010160f, -0.19352262f, 
    -0.01857493f, -0.13556749f, -0.05977436f, -0.01785464f, 0.07783572f, 0.07208069f, -0.01698516f, 0.06213974f, 
    -0.19671486f, -0.04967794f, 0.20481831f, 0.04794655f, 0.25002551f, -0.00049717f, 0.07907689f, 0.11261509f, 
    -0.02781124f, 0.03215698f, -0.35807252f, 0.09983212f, -0.03723697f, -0.11654470f, -0.06676452f, 0.10495485f, 
    0.00577955f, 0.14391387f, -0.10816383f, 0.13391079f, -0.04326123f, -0.07521308f, 0.07467842f, 0.14393190f, 
    0.15320925f, 0.04911773f, -0.23521045f, -0.13056941f, 0.12037364f, -0.02505987f, 0.00782174f, -0.08350944f, 
    0.06863184f, 0.02021459f, -0.02481247f, 0.09077086f, -0.18141474f, -0.20275843f, -0.41349828f, -0.49894267f, 
    0.19279893f, -0.24750356f, 0.11628867f, 0.00220517f, -0.08401466f, -0.40079939f, -0.60719287f, -0.09803904f, 
    -0.01333276f, 0.00270116f, 0.10103393f, 0.07597795f, -0.00355756f, -0.13485003f, 0.15953954f, -0.12853512f, 
    -0.03662113f, 0.15073258f, -0.01093353f, 0.01905805f, 0.27056673f, 0.06625479f, -0.20955633f, 0.04984304f, 
    0.06456554f, 0.07270702f, 0.12782532f, 0.18521608f, -0.14849660f, -0.00973626f, -0.13483834f, -0.07044203f, 
    -0.03896633f, 0.04400231f, 0.36117497f, 0.07268588f, -0.00225692f, 0.00900590f, -0.06332938f, 0.13346380f, 
    -0.05583138f, -0.09275825f, 0.04715410f, 0.07378834f, -0.02462037f, 0.16073686f, -0.11731034f, 0.12750554f, 
    0.04277123f, -0.28752109f, -0.72228861f, -0.38559476f, 0.07741717f, -0.41357666f, -0.16006228f, -0.04556505f, 
    -0.17277910f, -0.04163040f, 0.02522505f, 0.06411698f, 0.26280248f, -0.13318156f, 0.16387704f, 0.09901089f, 
    0.15050657f, 0.36512750f, 0.16239536f, -0.00837509f, 0.08429379f, -0.47580665f, -0.03237225f, 0.02622363f, 
    -0.24265119f, -0.06616923f, -0.02554966f, -0.19370690f, -0.05112891f, -0.09963512f, 0.11506394f, 0.35509261f, 
    -0.12291480f, -0.40739551f, -0.08158454f, -0.32825944f, -0.05418083f, 0.02853567f, 0.41237724f, -0.05076474f, 
    0.29230487f, -0.12313624f, -0.17059858f, 0.02508624f, 0.13889173f, 0.11994597f, 0.19593187f, -0.28197187f, 
    -0.01051565f, -0.29597560f, -0.27340001f, -0.12228266f, -0.06064368f, 0.06672993f, 0.31730258f, 0.00472281f, 
    -0.07284140f, -0.19978711f, -0.09985784f, -0.01314502f, 0.02724726f, 0.00486540f, -0.05653706f, 0.22562872f, 
    0.27494815f, 0.49658334f, 0.81449068f, -0.13678971f, 0.07085742f, 0.01136305f, 0.01317831f, -0.04504278f, 
    0.03817692f, -0.36733216f, 0.00732745f, -0.03069593f, -0.35152543f, 0.07030800f, -0.02506391f, -0.01688398f, 
    -0.10664085f, -0.22700983f, -0.51117015f, 0.22566684f, 0.02485334f, -0.20660888f, 0.07831444f, -0.01035549f, 
    0.08672858f, 0.23814727f, 0.12127875f, -0.06754473f, -0.18595476f, -0.25998774f, -0.17800125f, -0.18030119f, 
    -0.03424053f, -0.07824829f, -0.13665855f, -0.16213475f, -0.21886392f, 0.10853996f, 0.01568263f, 0.09172517f, 
    0.05895574f, -0.01717335f, -0.01286714f, -0.02711306f, 0.13560095f, 0.17340864f, 0.11220732f, 0.14341336f, 
    0.01100282f, 0.08239008f, 0.00219018f, -0.08079091f, -0.00915263f, 0.04983995f, 0.18036780f, -0.04690745f, 
    0.05710354f, -0.00562316f, 0.08871034f, -0.05159356f, 0.12074849f, 0.11227585f, 0.19002934f, -0.17216137f, 
    0.02515283f, -0.27312809f, -0.21633069f, 0.02940041f, 0.26098451f, -0.17790614f, 0.00593718f, 0.10616091f, 
    0.08399453f, -0.02477953f, -0.25550124f, 0.01045638f, 0.12445735f, -0.16899475f, 0.15254398f, -0.30046099f, 
    -0.17575318f, -0.13737793f, 0.09546365f, -0.10505447f, 0.37776357f, -0.01173692f, -0.21393363f, 0.04487551f, 
    -0.02104892f, -0.06320231f, 0.00199943f, 0.10274576f, 0.22856116f, -0.08500797f, 0.09667516f, 0.08882665f, 
    0.11099277f, 0.01004481f, 0.15353973f, 0.04346999f, 0.11774080f, 0.30726343f, -0.00409756f, 0.09778398f, 
    -0.15899114f, 0.17053331f, -0.06525337f, 0.10340859f, -0.04051664f, 0.14564440f, 0.10292731f, -0.13454823f, 
    -0.21477093f, -0.17702250f, -0.38290223f, 0.06645295f, 0.18608113f, 0.19696049f, -0.37244654f, 0.23453556f, 
    -0.19145527f, 0.04640142f, 0.12758601f, 0.02247624f, -0.26539147f, -0.07067593f, 0.14146762f, 0.00103463f, 
    0.27788326f, -0.10233492f, 0.01579947f, 0.15950684f, 0.11695790f, 0.09837333f, 0.20076261f, 0.06024168f, 
    0.07944419f, -0.02215571f, -0.05228223f, -0.01501291f, -0.11290315f, -0.18414935f, 0.03741489f, 0.06157379f, 
    0.10100050f, 0.22311203f, 0.29521155f, -0.05395367f, 0.05643247f, 0.10110434f, 0.06540804f, 0.18489151f, 
    0.07781292f, 0.02130016f, 0.08003847f, 0.08807772f, -0.21937066f, 0.07760917f, 0.07388921f, 0.04136752f, 
    -0.01203846f, 0.30561510f, -0.16481940f, -0.04865991f, -0.07618953f, -0.04332303f, -0.05115901f, 0.04510254f, 
    -0.07212070f, -0.31384495f, -0.35799921f, 0.07563864f, -0.05803060f, 0.06877459f, 0.08213796f, 0.04412514f, 
    -0.02421705f, 0.11061607f, 0.03595818f, -0.21114539f, -0.20742255f, 0.07523717f, 0.06645142f, 0.12121720f, 
    -0.38442218f, -0.08046895f, 0.06054583f, 0.20475315f, -0.02091412f, 0.19271004f, 0.30305877f, 0.60310405f, 
    -0.02656248f, 0.01876441f, 0.01830775f, 0.00715046f, 0.17168817f, -0.04629109f, -0.04134967f, 0.22538219f, 
    0.18466617f, -0.21475379f, -0.12646961f, -0.05703370f, -0.06634261f, 0.17850707f, 0.03175218f, 0.11216144f, 
    0.10041140f, 0.13613924f, 0.04195649f, 0.08017686f, -0.20865543f, -0.27345964f, 0.13400574f, 0.23593861f, 
    0.16488114f, -0.16238852f, -0.10562968f, -0.06945962f, 0.20480046f, 0.20706226f, 0.10975926f, -0.21619479f, 
    -0.37707296f, -0.22028175f, -0.00892251f, 0.04197356f, -0.20604761f, 0.00360241f, 0.01669003f, 0.08144280f, 
    -0.06611445f, 0.10473361f, -0.05676839f, -0.15939218f, -0.00353578f, 0.07097095f, -0.03595618f, 0.00629171f, 
    -0.09839290f, -0.12825519f, -0.04562859f, -0.00898696f, -0.10384221f, -0.02793678f, -0.04040761f, 0.02791366f, 
    -0.00554065f, 0.11963604f, -0.10359393f, -0.34403342f, -0.29483077f, 0.07302425f, 0.05634282f, 0.11796204f, 
    0.05609909f, 0.01503405f, 0.16641064f, 0.04602365f, -0.05134927f, -0.05414144f, -0.05954533f, 0.07554342f, 
    0.09007458f, 0.16154742f, -0.13795683f, 0.10776703f, -0.13382708f, -0.05386741f, -0.05537860f, 0.03028973f, 
    0.12433701f, -0.03752995f, -0.01855344f, 0.07448831f, 0.04428053f, -0.25466466f, -0.13185453f, 0.24142689f, 
    0.19954255f, 0.08137520f, 0.15933460f, -0.01086608f, 0.09496004f, 0.39958778f, -0.26266435f, 0.10683354f, 
    0.09963212f, 0.03850377f, -0.00827536f, -0.29171312f, -0.00209487f, -0.10226335f, -0.12834021f, -0.06543731f, 
    -0.12146956f, 0.10284355f, -0.18423502f, 0.06125388f, -0.44822031f, -0.01508438f, 0.15968095f, 0.10964192f, 
    -0.18266276f, 0.16819441f, 0.18536648f, 0.14758481f, 0.04505983f, -0.00697521f, -0.35141322f, 0.03030900f, 
    -0.06657034f, 0.03272779f, 0.12846696f, -0.03491995f, -0.27892268f, 0.22865111f, -0.13890563f, 0.18090175f, 
    0.09718752f, 0.05865632f, -0.16546388f, -0.23280156f, 0.19837856f, -0.30113319f, -0.05869349f, -0.36062130f, 
    0.09157481f, 0.07146710f, 0.23240276f, -0.00336309f, 0.09284003f, -0.00147857f, -0.45862663f, 0.21349663f, 
    0.10144203f, 0.03920109f, 0.01937526f, 0.16865414f, 0.10528747f, -0.04519653f, 0.21424392f, -0.08481997f, 
    -0.12558630f, 0.07470005f, -0.13388383f, 0.08130000f, -0.07527020f, 0.05823381f, -0.00472886f, 0.10059322f, 
    -0.25257391f, -0.11359465f, 0.04780883f, 0.03334063f, 0.08324384f, -0.00474802f, -0.17107685f, 0.11625357f, 
    -0.05174414f, -0.55587047f, -0.23632506f, 0.02789837f, 0.26801410f, 0.19730498f, 0.24857824f, 0.09400973f, 
    0.13153635f, 0.01727262f, 0.16951579f, -0.15215302f, 0.17083167f, -0.10399692f, 0.18789758f, 0.08266067f, 
    -0.04707996f, 0.03879408f, 0.24691765f, -0.17481776f, -0.39127609f, -0.32382545f, -0.10930367f, -0.04226902f, 
    -0.09704914f, 0.21781121f, 0.10927711f, 0.13853090f, -0.22648843f, -0.30678570f, -0.14171839f, 0.02644989f, 
    -0.15493704f, 0.33308572f, -0.19670740f, 0.06168883f, 0.09449162f, 0.11660041f, -0.10857309f, -0.27825215f, 
    -0.11431365f, -0.05041344f, -0.00321912f, -0.19306600f, -0.14120458f, -0.14431714f, 0.54233122f, -0.80466586f, 
    0.07806560f, 0.03091166f, 0.01955991f, -0.14131618f, -0.23868369f, 0.10620903f, -0.10865730f, -0.43005976f, 
    -0.38801113f, -0.29587477f, -0.05038294f, -0.10312902f, -0.00479534f, 0.07049912f, 0.07112020f, 0.11481134f, 
    -0.21162033f, 0.05368294f, 0.04964494f, 0.06797735f, 0.07559879f, 0.08263774f, 0.07711080f, 0.21951549f, 
    0.15812260f, -0.06058137f, -0.27341309f, 0.20562547f, -0.02085811f, -0.23923539f, 0.13523294f, 0.07765774f, 
    -0.03211375f, 0.35210437f, -0.27089125f, -0.12272464f, 0.09420195f, 0.05887023f, 0.01751214f, 0.14960547f, 
    -0.05777595f, -0.03424035f, -0.11715446f, 0.37081134f, -0.37199169f, 0.08133733f, -0.18289936f, 0.07052629f, 
    -0.03398784f, -0.00272260f, 0.11430451f, -0.05818825f, 0.13613091f, -0.17216849f, 0.01815171f, -0.47074080f, 
    -0.04222012f, -0.24935824f, -0.07780164f, 0.00984187f, 0.03543970f, 0.06433354f, -0.05106727f, 0.32506409f, 
    -0.02748860f, 0.14526947f, -0.03328830f, 0.06564968f, 0.24883161f, 0.08684968f, 0.06153600f, -0.09260439f, 
    -0.02003201f, -0.11128399f, 0.08429071f, -0.24180719f, 0.13767429f, 0.00916302f, 0.07685295f, 0.13680001f, 
    0.30543920f, -0.17390463f, 0.09783489f, -0.00703077f, -0.14999588f, -0.05872918f, -0.04158541f, 0.18406083f, 
    -0.12313130f, -0.42902964f, 0.00108351f, -0.23290588f, -0.14895342f, -0.06998947f, -0.00267836f, -0.14373043f, 
    0.02749560f, -0.23474559f, -0.53961307f, 0.44159210f, -0.03944073f, 0.01341012f, -0.04541923f, 0.15392506f, 
    -0.19009994f, 0.01132916f, 0.23386319f, -0.21134101f, 0.10928348f, -0.09142189f, 0.01690396f, -0.01525321f, 
    -0.22852698f, 0.06623192f, -0.01833421f, 0.59261411f, -0.00068295f, 0.50268215f, 0.27605003f, 0.08124220f, 
    -0.05243964f, 0.08196376f, 0.07217147f, 0.20937088f, 0.16648167f, -0.38391685f, -0.00168691f, -0.32130697f, 
    -0.01752776f, -0.13498369f, 0.04771788f, -0.04066111f, 0.12341014f, 0.02374468f, -0.19612879f, 0.23365422f, 
    -0.28613356f, 0.04404704f, 0.05761749f, -0.00997275f, 0.09313122f, 0.00667041f, -0.23318872f, -0.11952471f, 
    -0.03216871f, -0.20293790f, 0.03735953f, 0.09968091f, 0.02658316f, 0.09406170f, 0.19797432f, 0.52298599f, 
    -0.13986519f, 0.21709456f, 0.02457883f, 0.00973010f, -0.03325813f, 0.01140788f, 0.17084844f, 0.05145514f, 
    -0.00525821f, -0.01191049f, -0.04509603f, -0.04398689f, -0.01290205f, -0.00523600f, -0.03616263f, -0.04543984f, 
    -0.02953957f, -0.04827168f, -0.03695013f, -0.06259955f, -0.05507165f, 0.00723713f, -0.04639765f, 0.01888988f, 
    -0.01898296f, 0.01351285f, -0.07084921f, 0.02177132f, 0.00158714f, -0.03659650f, -0.03989518f, -0.04800798f, 
    0.04196756f, -0.04834112f, 0.01440271f, 0.03705845f, -0.04767497f, 0.00542573f, 0.01564516f, -0.03129889f, 
    -0.03549601f, 0.01483162f, 0.03740766f, -0.03049123f, -0.07180987f, 0.00681814f, -0.01204705f, -0.01254331f, 
    0.05258544f, -0.05897088f, 0.01638873f, -0.04235749f, 0.01276813f, -0.06808000f, 0.00971873f, 0.04427776f, 
    0.00104172f, -0.00161566f, -0.00465399f, 0.01764112f, 0.04040481f, 0.02917699f, 0.05119395f, -0.03874641f, 
    0.01943164f, -0.02286018f, -0.05410510f, 0.02757621f, -0.02575420f, 0.03935011f, -0.03172302f, -0.06568147f, 
    0.00046648f, -0.02095477f, -0.00721334f, -0.03063932f, 0.01900429f, -0.04373420f, 0.04269319f, -0.03722410f, 
    0.04057611f, -0.03840297f, -0.06472743f, -0.02104059f, -0.01614471f, 0.04449231f, -0.01484534f, -0.04475202f, 
    -0.04337676f, 0.00040078f, 0.01815029f, -0.02607817f, 0.02040326f, 0.03074249f, -0.04986798f, 0.05156608f, 
    0.02699527f, -0.04828673f, -0.03923387f, -0.06030452f, 0.00476079f, 0.00248674f, -0.00921527f, 0.02317706f, 
    0.01090102f, 0.03083365f, 0.03357682f, -0.01887042f, 0.00821500f, 0.01312604f, 0.04456146f, -0.00260592f, 
    0.02293350f, 0.01442238f, -0.01244383f, 0.03344284f, 0.00026255f, -0.04411984f, 0.02450060f, 0.02156708f, 
    -0.07219503f, 0.05740189f, -0.02300913f, -0.05470678f, -0.02229542f, 0.04085104f, 0.01219878f, -0.01591579f, 
    -0.02346890f, 0.04833780f, -0.02546469f, -0.04995392f, -0.01610570f, -0.01355449f, -0.05299097f, -0.02954852f, 
    -0.06094049f, -0.01032012f, -0.00084351f, 0.01384358f, 0.04593047f, -0.03710806f, -0.02703231f, -0.05265873f, 
    -0.04569288f, -0.00317929f, 0.02629457f, -0.03722976f, 0.00456255f, -0.01166530f, 0.04855241f, -0.02110727f, 
    0.01207179f, -0.06511078f, -0.03230136f, 0.00142161f, 0.02616868f, -0.00495187f, -0.03133774f, 0.00785278f, 
    0.03233604f, 0.04778408f, 0.00475372f, -0.04363931f, 0.00451930f, -0.05080568f, 0.00313801f, -0.01685670f, 
    -0.03970147f, -0.02536144f, -0.06375653f, -0.00217200f, -0.01685551f, 0.02857754f, 0.02192557f, 0.03187560f, 
    0.04970500f, 0.01498565f, -0.03819359f, -0.02966471f, -0.02986257f, -0.06154776f, -0.04517374f, -0.00675582f, 
    -0.06123482f, -0.03271417f, -0.04125522f, 0.04722523f, 0.02458302f, 0.01512490f, -0.06325474f, -0.01040169f, 
    -0.04473070f, 0.03351385f, 0.01848990f, -0.01027898f, 0.00904674f, -0.01218234f, 0.03638729f, -0.01693177f, 
    0.05560278f, -0.01240463f, -0.05058217f, -0.00927749f, -0.02188087f, -0.03144435f, -0.04888590f, -0.01455719f, 
    0.02692022f, -0.05204458f, -0.01872443f, -0.04309957f, -0.06303398f, 0.01493914f, -0.05527927f, 0.01336046f, 
    -0.05005949f, -0.03690813f, 0.01174189f, -0.01740306f, 0.00355726f, -0.03849111f, -0.04024103f, -0.01619723f, 
    0.03768562f, -0.01346529f, -0.05096812f, 0.03528619f, 0.04036644f, -0.03745397f, 0.04461370f, -0.04605570f, 
    -0.03789200f, -0.00167913f, -0.03619368f, 0.01068263f, 0.01797516f, -0.06450025f, -0.01941879f, 0.02360459f, 
    0.01032014f, -0.01026134f, 0.02779431f, 0.01673699f, 0.03970850f, 0.02590206f, 0.01401369f, 0.02832486f, 
    -0.01804131f, 0.03486479f, 0.04127159f, 0.04072515f, 0.02555725f, -0.02851103f, 0.00421935f, 0.00765884f, 
    -0.02709263f, -0.00538164f, -0.04510597f, 0.02650923f, -0.01934867f, 0.02328148f, -0.03081938f, -0.03789070f, 
    -0.04872745f, 0.00838938f, 0.04055425f, 0.01351378f, 0.01436107f, -0.04484617f, 0.03277925f, -0.04669018f, 
    0.02129215f, -0.00972689f, -0.03012425f, -0.00103674f, 0.00913479f, 0.02580185f, -0.02314953f, -0.00695002f, 
    0.01796073f, 0.05216854f, 0.01512973f, -0.05887613f, -0.02730982f, -0.02566165f, -0.02671147f, 0.02381663f, 
    0.02990395f, -0.04168827f, -0.01655574f, 0.04041380f, -0.05612908f, 0.05544540f, 0.04592492f, -0.01905833f, 
    0.19364285f, 0.00516932f, 0.36975911f, 0.09530903f, 0.08663285f, -0.19208317f, -0.02974148f, -0.06503464f, 
    -0.04850940f, -0.11174984f, -0.76365119f, -0.69590312f, 0.04413515f, -0.07029986f, -0.01726899f, 0.04944658f, 
    0.09137936f, 0.09145301f, -0.13534306f, 0.21777302f, 0.45349148f, 0.01898982f, -0.24502438f, -0.15238981f, 
    0.11484641f, -0.03482383f, 0.07024113f, 0.01152496f, 0.07257678f, -0.21316826f, -0.11433910f, 0.19994313f, 
    0.21019216f, -0.08126289f, 0.04114097f, 0.03474603f, -0.19756594f, -0.00940264f, -0.21707043f, 0.16713330f, 
    0.04031406f, -0.37840798f, 0.04136985f, -0.20021178f, 0.06512593f, -0.00246881f, -0.01880799f, -0.08315273f, 
    -0.01431176f, -0.00803661f, -0.07217961f, -0.11095417f, -0.14968719f, -0.04684861f, -0.02954625f, 0.22985438f, 
    0.17743982f, -0.09147304f, -0.00126449f, 0.14808866f, -0.15168227f, 0.15512335f, -0.00219683f, 0.24886695f, 
    -0.03393976f, -0.02250920f, -0.06658012f, 0.05673363f, -0.15120173f, 0.14995173f, 0.07401596f, 0.00660612f, 
    0.40213457f, -0.07553547f, -0.22148502f, 0.02758498f, -0.04702463f, 0.03336553f, 0.02450995f, -0.06885865f, 
    -0.08486763f, -0.24034709f, 0.12789372f, 0.00256796f, 0.03657106f, 0.28616688f, 0.08626500f, 0.10075103f, 
    0.01794208f, 0.04414767f, -0.09780320f, 0.09019820f, 0.30692324f, -0.11155095f, 0.13684885f, 0.05739140f, 
    -0.07584323f, -0.03426928f, -0.10578520f, -0.14517890f, -0.12874423f, -0.41082636f, -0.08750206f, -0.22196274f, 
    -0.04066291f, 0.06027095f, -0.02627827f, -0.00139103f, -0.11722238f, 0.07055181f, 0.03983307f, -0.12886357f, 
    0.32214460f, 0.10081556f, 0.04532237f, -0.00352586f, -0.04964254f, -0.09501331f, -0.06296998f, -0.34435949f, 
    0.14365754f, 0.03944596f, 0.14157145f, 0.19051205f, -0.08470330f, -0.02225631f, 0.61622167f, -0.52805698f, 
    0.03709428f, -0.01024171f, -0.06673421f, -0.17745163f, -0.02499459f, -0.01807658f, 0.11345972f, -0.00454846f, 
    -0.06589592f, -0.35393009f, 0.05871976f, -0.11061019f, 0.12581053f, 0.02911545f, -0.13869064f, -0.11675499f, 
    0.03403881f, -0.02030273f, 0.07362731f, 0.07766691f, 0.05432873f, 0.05532509f, -0.04636111f, 0.08821076f, 
    -0.02227400f, -0.02973332f, -0.15338545f, -0.07231160f, -0.16724817f, -0.41695642f, 0.02584714f, -0.01435479f, 
    -0.11777460f, 0.03964714f, -0.18757319f, -0.01302938f, -0.14612658f, 0.19521719f, 0.05988503f, 0.36274236f, 
    -0.03986038f, 0.04206083f, 0.00495873f, 0.19471399f, -0.19394404f, 0.42899543f, -0.02449254f, 0.00720910f, 
    0.05540292f, 0.06087064f, 0.12150461f, 0.00408619f, 0.51527786f, -0.13263017f, -0.12974207f, 0.01077237f, 
    -0.05228667f, -0.11648490f, 0.04758578f, 0.09808989f, 0.04211000f, -0.09572799f, 0.06040729f, 0.25458983f, 
    -0.07617705f, 0.11902561f, -0.16788760f, -0.13226645f, -0.00640939f, -0.12474492f, 0.09689900f, 0.04940383f, 
    -0.04596970f, 0.01961934f, -0.26402479f, -0.05933648f, 0.08480934f, 0.11272685f, 0.12989956f, 0.09181134f, 
    0.22316137f, 0.13638766f, 0.08904263f, -0.47081473f, -0.11709996f, 0.09262269f, 0.00454099f, 0.05731249f, 
    -0.03405899f, -0.15550144f, -0.14325437f, 0.06641290f, 0.00854508f, 0.10778587f, -0.27823493f, -0.08219878f, 
    -0.05317409f, -0.28111327f, -0.08062169f, 0.14197646f, 0.10936830f, -0.00809375f, 0.11745750f, 0.15498640f, 
    -0.06248079f, -0.04150004f, 0.48181412f, -0.09200192f, 0.13249132f, 0.08312730f, -0.06574746f, -0.14435580f, 
    -0.03470098f, 0.01857759f, 0.06015604f, 0.08334142f, 0.29729694f, 0.19049142f, 0.19431484f, -0.17137241f, 
    -0.24784862f, -0.10227005f, -0.06915144f, -0.17356895f, 0.31133696f, -0.11452460f, 0.23126295f, -0.00845261f, 
    -0.00208021f, -0.04545767f, 0.14523874f, 0.01198977f, 0.04188991f, 0.17114273f, -0.10775753f, 0.30685663f, 
    0.04098229f, 0.11452655f, -0.08472568f, 0.01138022f, -0.07130389f, -0.08217626f, 0.18551935f, -0.06560788f, 
    -0.07614446f, -0.05326510f, -0.01527230f, 0.02436148f, 0.00886948f, -0.07589247f, 0.01887931f, 0.36356664f, 
    0.06372043f, 0.33254859f, -0.05138640f, -0.04605057f, -0.12723289f, 0.03465832f, 0.15946855f, 0.03238459f, 
    0.02685325f, 0.03812343f, -0.04976501f, -0.04882543f, -0.04328717f, 0.02102196f, -0.02219925f, -0.00962493f, 
    0.01346739f, 0.05603319f, 0.02550750f, 0.05396178f, 0.03117136f, 0.03339911f, 0.04307596f, 0.01094612f, 
    0.01703177f, -0.03746682f, -0.01052476f, 0.03443805f, 0.00729546f, -0.00825803f, -0.01207781f, 0.01054274f, 
    0.03763039f, -0.02280897f, 0.00698606f, 0.03636802f, 0.03151806f, 0.02103298f, -0.00080539f, -0.01726679f, 
    -0.00184598f, -0.04801511f, 0.01478279f, -0.01616656f, 0.01665060f, -0.04466426f, -0.04692683f, -0.01970923f, 
    -0.05185306f, 0.00773813f, 0.03600659f, -0.01974095f, 0.04282486f, -0.04509297f, -0.05444877f, 0.04072306f, 
    0.02440581f, 0.02658765f, 0.02283668f, -0.02235377f, -0.05397438f, 0.02336633f, 0.01651386f, -0.00336649f, 
    0.02693172f, -0.02141910f, -0.05801631f, -0.00929621f, 0.00687372f, -0.01595877f, 0.03875266f, 0.01019792f, 
    0.03445044f, -0.04410831f, 0.00855999f, 0.02483468f, -0.04800994f, 0.04049464f, 0.02177948f, 0.03113685f, 
    0.03619377f, -0.01588330f, 0.02150959f, 0.04311510f, 0.04174075f, -0.02626106f, 0.00478593f, 0.00304133f, 
    -0.04637928f, 0.02648763f, -0.00349422f, -0.01952359f, 0.04771651f, 0.00089598f, -0.06291157f, -0.05604012f, 
    -0.05305774f, 0.03980653f, -0.00044600f, -0.05310633f, 0.04331878f, -0.00256603f, 0.02423896f, 0.00748064f, 
    -0.03190166f, -0.05339209f, -0.03319799f, -0.02295283f, 0.00760601f, -0.04942046f, 0.01165973f, -0.01658373f, 
    -0.00729705f, -0.02025215f, -0.02370479f, -0.01788822f, -0.05054948f, -0.02777727f, -0.04504367f, -0.00240483f, 
    -0.02137044f, 0.02657724f, 0.02312016f, 0.02994926f, 0.01271344f, -0.02892284f, 0.00703299f, -0.02640324f, 
    -0.03105504f, 0.03099698f, -0.04183813f, 0.05088210f, -0.01014674f, -0.05985776f, -0.01383717f, 0.03451248f, 
    0.05170595f, -0.03794614f, 0.03574311f, -0.02540836f, 0.00735426f, 0.04805014f, 0.02921011f, -0.06051133f, 
    -0.03852557f, 0.01309077f, 0.00405226f, -0.00576261f, 0.03347697f, -0.06262317f, -0.06608560f, -0.00127004f, 
    0.03499316f, 0.01565457f, 0.04483795f, 0.03244568f, 0.01730047f, -0.01187331f, -0.02050927f, 0.04289118f, 
    -0.05129067f, 0.00263267f, -0.03758338f, 0.02819026f, 0.02469559f, -0.00037952f, 0.02853910f, 0.01709584f, 
    0.04469893f, -0.02768383f, -0.01460657f, 0.01176032f, 0.00118538f, 0.03531227f, -0.04551480f, 0.01759701f, 
    -0.03233609f, 0.03766894f, -0.03356083f, -0.04600933f, -0.04496396f, -0.01963435f, -0.03937926f, 0.00988292f, 
    0.04602463f, 0.03184906f, -0.02356527f, -0.02940332f, -0.01447623f, -0.01536866f, -0.05546339f, 0.02849457f, 
    -0.01714151f, 0.01502978f, -0.05239374f, 0.04557831f, -0.05788504f, -0.04374815f, -0.03417724f, 0.02571339f, 
    0.00090332f, 0.04352362f, 0.04732731f, 0.01777475f, 0.01245407f, 0.02899876f, 0.01432061f, 0.03214100f, 
    -0.01763333f, 0.00751628f, -0.01363164f, -0.03554782f, 0.02412152f, 0.04739799f, -0.05131379f, 0.04330050f, 
    0.01818967f, -0.02824555f, -0.05543630f, 0.01223276f, -0.03795539f, -0.03202915f, -0.06074138f, -0.02281308f, 
    -0.06050428f, -0.03516897f, 0.02746910f, -0.04385693f, -0.01983145f, -0.03932041f, 0.02327939f, 0.02815162f, 
    0.01451042f, 0.01475355f, -0.05381377f, -0.04637719f, -0.05613482f, -0.05179403f, -0.06439259f, -0.00722597f, 
    -0.01615262f, 0.02798804f, 0.04885069f, 0.00800095f, -0.04173728f, -0.00674864f, -0.04925132f, -0.00709686f, 
    -0.03458015f, -0.04920040f, 0.04410177f, -0.02750346f, 0.02116419f, -0.01358650f, -0.06217529f, -0.00265189f, 
    -0.02332663f, -0.02452401f, 0.02482139f, -0.05940927f, 0.01845899f, -0.04550264f, -0.04492268f, 0.02755896f, 
    0.05736006f, -0.04123488f, 0.04437755f, 0.02704227f, -0.06302486f, -0.03671349f, -0.03459424f, -0.05284109f, 
    0.01064805f, 0.02905979f, -0.04861938f, -0.00260477f, -0.01469942f, -0.05273011f, 0.04378726f, 0.00807044f, 
    -0.04094153f, 0.00090849f, 0.00036821f, -0.02745223f, -0.00610361f, -0.04441752f, -0.00601047f, -0.02536251f, 
    -0.03596506f, -0.01946806f, -0.02354983f, -0.04296917f, 0.00409289f, 0.01339398f, 0.00309479f, -0.00955225f, 
    -0.19162618f, -0.01432353f, 0.17765222f, 0.10259178f, 0.06249205f, 0.03053477f, 0.08775381f, 0.11029259f, 
    -0.11125712f, -0.15816160f, 0.31535619f, 0.71666050f, 0.10638241f, 0.10308456f, -0.02286513f, -0.00467738f, 
    -0.09053602f, 0.12781134f, 0.19574302f, -0.17180669f, -0.25907362f, 0.03817235f, -0.01987533f, 0.03585286f, 
    -0.02691569f, -0.11860430f, 0.36245561f, 0.07905972f, 0.08244194f, 0.26771498f, 0.00452741f, 0.06152713f, 
    0.05377770f, 0.25598013f, 0.28144142f, 0.24135740f, 0.35136697f, 0.00819879f, -0.17521232f, -0.11585575f, 
    -0.02182594f, 0.10345329f, -0.09788933f, 0.04029267f, 0.03339288f, 0.22947979f, 0.09465196f, 0.06984538f, 
    -0.21127452f, -0.05819988f, -0.10789055f, 0.03836141f, 0.06922156f, 0.08709217f, -0.07193024f, -0.00559396f, 
    -0.02146443f, -0.10890889f, -0.08197937f, -0.12633716f, -0.01302030f, -0.03163745f, -0.13980380f, -0.05452169f, 
    -0.22455867f, -0.13655962f, -0.10818870f, 0.04406278f, 0.06567855f, -0.20426691f, -0.08858740f, -0.10418561f, 
    -0.27642485f, -0.05025892f, 0.06140141f, -0.17758855f, 0.13141224f, -0.12132490f, -0.00633830f, 0.00965373f, 
    0.07127926f, 0.16039988f, -0.06985389f, -0.24234445f, -0.09365779f, -0.43867227f, -0.19005188f, -0.05418962f, 
    -0.10809524f, -0.25963300f, 0.03149918f, 0.00033232f, -0.09085605f, -0.20794207f, -0.26721227f, -0.16289155f, 
    0.01142200f, -0.10416667f, -0.12283737f, 0.27354625f, 0.42039987f, 0.27426118f, 0.05352861f, 0.12114588f, 
    -0.12133061f, 0.03209077f, -0.16032469f, -0.16063838f, 0.59378767f, 0.08270794f, -0.41308603f, 0.04972083f, 
    0.03608100f, -0.09955902f, 0.08084780f, -0.00985646f, -0.29535380f, 0.30808294f, 0.17408288f, 0.16451500f, 
    0.43761769f, 0.12217952f, -0.01670941f, 0.04815670f, -0.08420197f, 0.06920941f, -0.12829542f, 0.15257260f, 
    -0.40097883f, 0.19630310f, -0.01649639f, -0.04649922f, -0.20807859f, 0.08883922f, -0.07788823f, 0.34363538f, 
    0.46558970f, 0.47287250f, 0.09633549f, 0.11929290f, -0.07672695f, 0.11456388f, -0.01872926f, -0.10569988f, 
    0.14826874f, 0.03580926f, 0.02772481f, 0.01129610f, -0.07131238f, -0.24611463f, 0.08763450f, 0.01763409f, 
    0.05124331f, 0.30787179f, 0.62914300f, 0.39667276f, 0.04915790f, 0.00569390f, -0.06111795f, -0.03310007f, 
    -0.21076320f, -0.02261611f, -0.31961513f, -0.13838376f, -0.09659115f, -0.05503746f, 0.01729081f, 0.07742155f, 
    0.06744138f, 0.11444392f, 0.07287285f, -0.07983740f, -0.18272990f, -0.13301460f, 0.11338853f, -0.02000846f, 
    0.00913790f, -0.21620052f, 0.16358806f, -0.29785803f, 0.05208816f, 0.08483476f, 0.05386426f, 0.27169579f, 
    0.06489641f, 0.04359556f, -0.09908821f, -0.16480075f, -0.08773707f, 0.11670709f, -0.00061313f, 0.01379524f, 
    -0.28855306f, 0.20482692f, -0.20296134f, -0.01771331f, 0.16696663f, 0.08047957f, -0.33183789f, 0.03411439f, 
    0.03252044f, -0.03060468f, -0.00144505f, 0.11264995f, -0.05247216f, -0.09858881f, 0.10049784f, 0.09776863f, 
    0.01505532f, -0.10851311f, 0.12675165f, -0.01580784f, -0.09718960f, -0.03471615f, -0.10096312f, 0.02253400f, 
    0.25340238f, 0.24178153f, 0.26115456f, 0.22235507f, -0.11030895f, -0.08986390f, 0.13862371f, -0.07202049f, 
    -0.09056194f, -0.07709779f, 0.04457093f, -0.06124798f, -0.06471562f, -0.02782938f, -0.25392216f, -0.05139381f, 
    0.13752285f, -0.05118413f, -0.09907980f, 0.00768726f, -0.17790580f, 0.10753986f, 0.08149571f, 0.01707210f, 
    0.03689755f, 0.11961471f, -0.10313636f, 0.08634452f, -0.06889547f, -0.27741387f, -0.16127333f, -0.20639844f, 
    0.07946015f, -0.06005566f, -0.15919138f, -0.17599981f, 0.04231245f, 0.03544695f, 0.07928757f, 0.14710401f, 
    -0.04653432f, 0.05616055f, -0.14573240f, 0.07094073f, -0.00463520f, -0.04014016f, 0.00439999f, -0.01059079f, 
    0.12819883f, 0.13398124f, 0.11666720f, 0.09787214f, 0.03866139f, 0.02365420f, 0.01103206f, 0.10226307f, 
    -0.02762661f, -0.18210785f, -0.19862120f, -0.21913688f, 0.11787791f, -0.01294879f, -0.08291544f, 0.00733242f, 
    -0.04352439f, -0.02303135f, 0.22722998f, 0.15774426f, -0.01770234f, -0.02416883f, 0.28489715f, -0.18854991f, 
    0.46846280f, 0.45014605f, 0.40945256f, -0.13888516f, -0.03033125f, -0.23424236f, 0.04806476f, 0.10758924f, 
    0.03621008f, -0.39532125f, 0.01709372f, 0.15179200f, -0.20798922f, -0.02816088f, -0.11940229f, -0.06845003f, 
    -0.05577740f, -0.02053386f, -0.26592055f, -0.40190482f, -1.30023122f, -0.24695773f, -0.33817929f, 0.36001062f, 
    0.13864575f, 0.04659108f, 0.06399111f, 0.06754749f, 0.02073222f, -0.21705255f, -0.04780956f, -0.23804611f, 
    0.17016990f, 0.10634519f, 0.10625906f, 0.04485166f, -0.35327134f, -1.13420224f, -0.86247581f, -0.25304285f, 
    -0.03224485f, 0.06528242f, -0.16510190f, -0.11556824f, 0.00373370f, 0.16927363f, -0.16871406f, -0.21735208f, 
    -0.15953226f, 0.06253440f, -0.07064966f, -0.10748062f, -0.03417705f, -0.01743232f, 0.09711174f, -0.05325024f, 
    -0.15195645f, -0.02823973f, 0.11937446f, 0.01919427f, 0.14524102f, 0.10557497f, -0.00233307f, 0.21471691f, 
    0.33897236f, 0.05677603f, 0.05374669f, -0.11513507f, -0.17262957f, 0.12033407f, 0.13487060f, 0.10428063f, 
    -0.18438691f, -0.37087604f, -0.12595782f, -0.08877605f, 0.33418456f, 0.00143295f, 0.08187532f, 0.06574669f, 
    -0.12729175f, 0.02752356f, 0.27798250f, -0.24464244f, 0.13178438f, -0.06987570f, 0.27076757f, 0.02401898f, 
    -0.11760752f, -0.02091443f, 0.24770473f, -0.03791806f, 0.13407655f, 0.08884805f, 0.06373162f, -0.00282738f, 
    0.15710674f, 0.04418686f, -0.02606992f, -0.49841055f, 0.07114486f, 0.32113636f, -0.03130282f, -0.00260852f, 
    -0.19648203f, 0.03777020f, 0.03717796f, 0.19295797f, -0.09513119f, -0.48110232f, -0.18675676f, 0.10324193f, 
    0.30628270f, 0.51563144f, 0.32338956f, -0.15182501f, 0.04242316f, -0.39658216f, -0.63483465f, -0.35203850f, 
    -0.09401467f, 0.14084879f, 0.10034663f, -0.01029749f, -0.12290353f, -0.08790666f, 0.05635764f, -0.26522845f, 
    0.18198174f, -0.14209670f, 0.39713818f, -0.19164886f, -0.10526691f, 0.10703541f, 0.03353336f, -0.35462895f, 
    -0.01781111f, 0.23782699f, -0.20943879f, -0.10768098f, -0.16957915f, 0.13407610f, 0.09165527f, 0.14882863f, 
    0.01424812f, -0.19888444f, -0.25896293f, 0.02744979f, 0.06454379f, 0.03528487f, 0.00881195f, 0.00969429f, 
    -0.06198036f, -0.58963484f, 0.46404886f, -0.11464822f, 0.00983614f, 0.13720945f, -0.02491256f, 0.03926224f, 
    0.11161259f, 0.04737096f, 0.37448841f, 0.03992401f, 0.02345908f, 0.08341298f, 0.21167129f, -0.04529120f, 
    0.14894594f, 0.01645148f, -0.05280653f, 0.26942384f, 0.13567951f, 0.41969171f, 0.05011937f, -0.06980948f, 
    -0.14216398f, 0.07811993f, 0.04958881f, 0.12039327f, -0.02107458f, 0.10703510f, 0.17794028f, -0.18739322f, 
    0.03064724f, -0.12837194f, -0.13205171f, 0.10577395f, 0.07155222f, 0.26857874f, -0.13816933f, -0.00145842f, 
    -0.03899291f, 0.04686283f, -0.07771299f, -0.07134355f, 0.16170928f, -0.15359966f, -0.33163881f, 0.07056734f, 
    -1.02423358f, -0.03650029f, -0.18487522f, 0.34329551f, 0.08341155f, -0.05598118f, -0.06960450f, 0.05969520f, 
    -0.13741827f, -0.77892792f, -0.12462878f, -0.09940825f, 0.17523108f, 0.09709921f, 0.02184144f, -0.00724054f, 
    -0.20456235f, -0.20518333f, -0.24582942f, -0.14537370f, -0.06312500f, 0.05092336f, 0.28112456f, 0.02224672f, 
    -0.21418700f, -0.27645242f, -0.30699903f, 0.06946875f, 0.08686218f, 0.01081559f, -0.10554687f, 0.23931234f, 
    0.06116936f, 0.18169463f, 0.27789170f, 0.46810746f, 0.10294400f, -0.09103252f, -0.09132186f, -0.22787987f, 
    0.00257157f, 0.18952650f, 0.06323336f, 0.07578179f, -0.94335049f, -0.07833730f, -0.20151581f, 0.15843414f, 
    0.13909234f, 0.27631998f, -0.06000518f, -0.01973662f, 0.07235982f, 0.28237295f, 0.26230156f, -0.03396479f, 
    -0.14440699f, -0.13129559f, -0.05285696f, 0.03219390f, 0.08428605f, 0.13195185f, 0.46657267f, 0.29347351f, 
    -0.00784788f, -0.08360520f, -0.17163625f, -0.00271790f, 0.04919224f, -0.00044472f, 0.16822097f, 0.34525168f, 
    0.03470844f, -0.06086620f, 0.12335782f, -0.11718630f, -0.18030483f, 0.07840728f, -0.09315314f, 0.39037219f, 
    0.12099906f, 0.35405773f, 0.01844976f, -0.07306552f, -0.10888146f, 0.06486575f, 0.06300321f, 0.09433202f, 
    0.05917584f, -0.04367434f, -0.10623199f, -0.14407420f, -0.00789619f, -0.07558216f, 0.00918720f, -0.08782777f, 
    -0.03526117f, -0.20432231f, 0.26723862f, 0.11409240f, 0.29450923f, 0.07121674f, -0.02033974f, 0.05766806f, 
    0.08670304f, 0.04804652f, -0.11099992f, -0.01813538f, -0.05707158f, -0.23320812f, 0.01662604f, 0.19538453f, 
    0.01795050f, 0.15317442f, 0.33513933f, 0.20817763f, 0.17815049f, -0.29791212f, -0.12037889f, 0.04679273f, 
    0.17725879f, -0.11110745f, 0.02007885f, 0.19061503f, -0.17162883f, 0.25767455f, 0.45840365f, -0.17868733f, 
    0.04793145f, -0.17791685f, 0.21288672f, 0.37414384f, 0.47108474f, -0.00332240f, 0.05276991f, 0.24878612f, 
    0.03459554f, 0.07280220f, 0.09807052f, -0.15230063f, -0.32048959f, -0.26816413f, -0.07646735f, 0.08725713f, 
    0.09052242f, 0.14810675f, 0.14295086f, 0.00708515f, 0.16819510f, -0.12867843f, -0.46534249f, -0.02201801f, 
    0.05538611f, -0.00169400f, 0.16093504f, 0.10803749f, 0.20289814f, 0.08221330f, 0.13893850f, 0.04210927f, 
    0.05147179f, 0.27246705f, 0.21481872f, 0.07921644f, 0.08554617f, 0.01682030f, 0.12379835f, -0.22062832f, 
    0.01558840f, 0.05962995f, -0.03642378f, -0.13845193f, -0.06066683f, 0.20930347f, 0.06119597f, -0.25775510f, 
    0.14701262f, 0.02528437f, -0.07281046f, 0.11977032f, 0.00342279f, -0.00113322f, 0.22006619f, -0.07592499f, 
    -0.06813990f, -0.14061412f, -0.19174254f, -0.00248167f, -0.21755816f, -0.26227349f, 0.10064861f, -0.03089941f, 
    -0.29302937f, -0.17690779f, -0.22118463f, -0.36195779f, -0.37306115f, -0.25455266f, -0.12787871f, -0.02948992f, 
    -0.02697376f, 0.04645356f, -0.18325748f, 0.11966644f, 0.24915598f, -0.20803438f, 0.32525691f, 0.23950827f, 
    0.11522960f, -0.00123820f, -0.16226451f, 0.46864390f, 0.01623428f, -0.17741984f, -0.13124579f, -0.07583264f, 
    -0.04934344f, 0.06758033f, -0.15657794f, 0.11199641f, 0.06610841f, 0.35945433f, 0.22445075f, 0.06680835f, 
    0.02173106f, -0.14618836f, -0.03944996f, -0.00768920f, -0.40066940f, -0.23559180f, -0.47001424f, -0.55184209f, 
    0.03985579f, 0.19186951f, 0.20855582f, 0.03029928f, 0.05526560f, 0.01554351f, 0.29389456f, -0.39989915f, 
    -0.52020311f, -0.13828798f, -0.15873452f, -0.36912870f, -0.01599788f, 0.01070275f, -0.05756476f, -0.18819103f, 
    -0.25184169f, -0.19344980f, -0.28868338f, -0.12916495f, -0.08708403f, -0.11396649f, -0.00734701f, 0.34192625f, 
    0.11043574f, 0.15017188f, 0.29562807f, 0.14042902f, 0.21802902f, -0.21366273f, 0.00911494f, 0.03648195f, 
    0.05830913f, 0.14526336f, 0.07729384f, 0.02270955f, -0.17219742f, -0.00935758f, -0.08676584f, 0.09025228f, 
    0.05691629f, 0.08394129f, 0.07288083f, 0.23719573f, -0.02207882f, -0.09713782f, -0.03260895f, 0.01124420f, 
    0.19138701f, 0.05849312f, -0.04619489f, -0.08816008f, -0.23837928f, -0.23575953f, -0.11071611f, -0.31520450f, 
    -0.10981619f, -0.05606197f, -0.01638914f, -0.07586449f, -0.08052125f, 0.08669335f, 0.21448079f, -0.17187762f, 
    -0.14224780f, -0.17445661f, -0.15005350f, 0.25660798f, -0.12987907f, -0.13374849f, 0.03663862f, 0.02029448f, 
    -0.14315262f, 0.19017094f, -0.01815865f, 0.04225490f, -0.12884152f, -0.04456151f, -0.04738186f, -0.45163488f, 
    -0.40716058f, 0.06146791f, 0.44727603f, -0.01919574f, -0.07482956f, 0.10205844f, 0.05019488f, 0.17862312f, 
    0.27960211f, 0.26291889f, 0.11135389f, 0.14136660f, 0.00366867f, 0.10414762f, -0.00830298f, 0.23533230f, 
    0.04659376f, 0.06997178f, -0.07989470f, -0.03569575f, 0.12022458f, 0.22735569f, 0.07647655f, -0.03464081f, 
    -0.01631045f, 0.08990402f, 0.08544953f, 0.31449223f, 0.11791327f, 0.14370520f, -0.23886542f, 0.04911448f, 
    0.20238410f, 0.10324010f, 0.23285754f, 0.14353046f, -0.09910070f, 0.02394187f, -0.01530540f, -0.05738197f, 
    0.01270126f, 0.06921742f, 0.10762341f, 0.09938417f, 0.02753424f, -0.08140056f, 0.14792028f, -0.08542786f, 
    0.03123691f, 0.12389628f, 0.05741711f, 0.10950171f, 0.18966292f, 0.07655609f, -0.09464521f, -0.18741591f, 
    0.09029076f, -0.00326000f, 0.11053636f, 0.04026345f, 0.14430816f, 0.03203716f, 0.01311215f, -0.00521088f, 
    0.01620763f, 0.18065718f, 0.09789968f, -0.05269112f, 0.14422348f, -0.09887633f, -0.10366475f, -0.09361719f, 
    -0.08860323f, 0.24654058f, 0.18325990f, 0.23083831f, -0.04387089f, 0.04778385f, 0.09336340f, -0.13925971f, 
    -0.01721139f, -0.00173691f, 0.35345960f, -0.01998483f, -0.13994022f, 0.16095024f, 0.03116521f, -0.05625257f, 
    -0.10090894f, 0.11915105f, 0.12067369f, 0.63085032f, 0.07101491f, 0.08127663f, 0.11757024f, 0.19135489f, 
    -0.11559415f, -0.20150799f, 0.03944525f, -0.21287403f, -0.09581110f, -0.37773910f, 0.14592703f, 0.07150024f, 
    0.00284595f, 0.03197779f, 0.01673146f, 0.18937789f, 0.12564754f, 0.27554533f, 0.14409310f, 0.00194670f, 
    -0.20153219f, -0.57332915f, -0.19430645f, -0.16025826f, 0.11561853f, -0.02330196f, -0.23699193f, 0.22299936f, 
    -0.57804424f, 0.16233660f, 0.34994847f, -0.02784487f, 0.01143833f, 0.18638369f, -0.09879769f, -0.26834309f, 
    0.21696414f, 0.39923972f, -0.13850066f, -0.15193272f, 0.01319868f, -0.05486798f, 0.05616767f, 0.00820830f, 
    -0.30116549f, -0.17215240f, 0.14243191f, -0.11459044f, -0.28776985f, 0.03804314f, -0.05529377f, -0.02703002f, 
    0.10632118f, 0.46127066f, 0.33426788f, -0.36533898f, -0.00876914f, -0.05525030f, -0.08068534f, -0.00444888f, 
    0.14125295f, -0.04170970f, 0.12878938f, 0.31039858f, -0.22016695f, -0.47193933f, -0.18965249f, -0.03358448f, 
    0.05046428f, -0.00406085f, 0.17698267f, 0.22658539f, -0.16485560f, -0.00213396f, -0.15283942f, -0.01263924f, 
    -0.12860434f, -0.01527619f, -0.08320548f, 0.02766550f, 0.77036858f, 0.12955542f, -0.11560558f, 0.08839136f, 
    0.03624126f, -0.12854624f, 0.16336390f, -0.10970053f, -0.04559670f, 0.44270000f, -0.11239932f, -0.11781850f, 
    0.11716913f, -0.07527789f, -0.08429548f, -0.21209887f, -0.02302125f, 0.03238269f, -0.08975633f, -0.35565162f, 
    -0.01525831f, 0.02866150f, -0.08827011f, 0.39687261f, 0.05657773f, 0.05861424f, 0.07802051f, 0.19360945f, 
    -0.23661205f, -0.07544405f, -0.17495245f, -0.10504663f, -0.11743739f, 0.06394621f, -0.03708889f, -0.07733949f, 
    0.29603860f, 0.07224516f, -0.19136293f, -0.05043117f, -0.15344638f, -0.05845630f, -0.23315787f, 0.04772836f, 
    -0.06862036f, 0.21284018f, 0.09013713f, 0.15567464f, -0.07769992f, -0.20275198f, -0.23583817f, -0.14849097f, 
    0.01622005f, 0.23015678f, -0.03364561f, 0.05279959f, -0.03454727f, -0.14467351f, 0.02490315f, 0.16911910f, 
    -0.10782821f, 0.10056614f, -0.15784054f, -0.06283967f, 0.04834320f, -0.11824451f, -0.03421814f, -0.04086924f, 
    -0.22735013f, -0.12147080f, 0.13220325f, -0.16568270f, -0.26740602f, -0.25280228f, -0.24629451f, -0.20984565f, 
    -0.45823336f, 0.16972359f, 0.04901628f, 0.02264361f, 0.12614258f, 0.07844269f, 0.06393351f, -0.22806010f, 
    -0.38924265f, -0.10827441f, -0.01457752f, 0.24281475f, -0.00778973f, 0.08495726f, 0.11199814f, -0.15273640f, 
    0.01557314f, 0.01578102f, 0.03328693f, 0.01419466f, 0.09642164f, 0.01541512f, -0.09216636f, 0.37305218f, 
    0.03957070f, -0.00351208f, 0.10848797f, 0.01917445f, -0.13509813f, -0.08386629f, -0.06462441f, 0.15399003f, 
    0.63979596f, -0.14231217f, 0.10190803f, 0.24235424f, -0.04374954f, -0.23296629f, -0.14290057f, -0.12485578f, 
    -0.14091039f, -0.16847900f, -0.10320333f, -0.04143672f, -0.06437785f, 0.04746947f, 0.05850279f, 0.08952574f, 
    0.19092184f, 0.08082306f, -0.02759129f, 0.02809843f, 0.31301096f, -0.10928184f, -0.03067283f, -0.04794005f, 
    -0.21909775f, -0.03166365f, -0.05829518f, 0.22538191f, -0.01893016f, -0.15196483f, 0.00897564f, -0.07869671f, 
    0.23645459f, 0.02724318f, 0.09633458f, -0.12096541f, -0.10407609f, -0.29016772f, 0.31614417f, 0.14488843f, 
    -0.29574269f, -0.13891704f, 0.04762428f, -0.15620425f, 0.26063848f, -0.22451848f, 0.42546049f, 0.22060445f, 
    -0.06943538f, -0.20220433f, -0.04527527f, -0.15693009f, -0.07352705f, 0.35641062f, -0.39094123f, -0.00017174f, 
    0.55940622f, -0.34274763f, -0.22831579f, -0.00787692f, -0.02496700f, 0.01502811f, 0.22026113f, -0.25836387f, 
    0.11209655f, 0.27770376f, -0.02044654f, -0.12089898f, -0.15625694f, -0.14788666f, 0.16846256f, -0.18747650f, 
    0.00674303f, -0.02141323f, -0.03927710f, -0.04613919f, 0.02992127f, -0.02230094f, -0.06505513f, 0.01329498f, 
    0.04304078f, 0.03327107f, 0.03867425f, -0.04211282f, 0.03153306f, -0.01777958f, -0.00916159f, -0.04483091f, 
    -0.04074557f, 0.00793682f, 0.00913183f, -0.01810803f, -0.02925875f, -0.00732073f, -0.04845091f, 0.02638219f, 
    0.04531218f, 0.02018202f, -0.04191778f, -0.04649095f, 0.01285491f, -0.00245483f, 0.03378160f, -0.01754932f, 
    -0.05933807f, 0.04439247f, -0.03799068f, 0.04358781f, -0.01981981f, -0.00879049f, 0.01545089f, 0.03948765f, 
    0.02813310f, 0.03208056f, -0.04225163f, 0.01658091f, 0.01475892f, 0.04318648f, -0.03142085f, 0.04693768f, 
    -0.04257644f, 0.04038730f, -0.02650804f, 0.00166550f, -0.03204235f, 0.03422575f, -0.03506441f, 0.05810932f, 
    -0.04672943f, 0.00895060f, -0.06625043f, 0.03207966f, 0.00339697f, 0.02666649f, -0.04312271f, -0.02222364f, 
    0.03216175f, 0.05230460f, 0.03427938f, -0.06878056f, 0.02245149f, 0.01798759f, -0.03692647f, 0.03115771f, 
    -0.00357780f, 0.00844263f, 0.04016771f, 0.04541699f, -0.03978230f, -0.03901480f, -0.03235193f, 0.00809639f, 
    -0.05781146f, -0.00192750f, -0.03863411f, -0.00717996f, -0.05818992f, -0.01051487f, -0.03362246f, 0.00997183f, 
    -0.02583074f, 0.03443306f, -0.04796777f, -0.04592658f, -0.03806734f, 0.03289562f, -0.04654182f, 0.02786542f, 
    -0.02963672f, -0.06927427f, 0.04249589f, -0.05538673f, -0.01424834f, 0.02276442f, 0.00228227f, -0.00407913f, 
    0.02290269f, -0.00940365f, 0.00201541f, -0.05920392f, -0.05241072f, 0.02190100f, -0.00906516f, -0.04264560f, 
    -0.01436036f, 0.02890424f, -0.05590360f, -0.00779587f, 0.03463206f, 0.02417326f, -0.03217955f, 0.01576609f, 
    0.03610691f, -0.05479983f, -0.02087527f, -0.03009334f, -0.05506234f, 0.04223624f, -0.00875940f, -0.04085285f, 
    0.06178601f, -0.00342346f, -0.03780445f, -0.00522769f, -0.06744780f, 0.02409970f, 0.01060333f, 0.03725358f, 
    -0.04452686f, -0.00096967f, -0.02818630f, -0.04948151f, 0.04976513f, -0.00848998f, -0.00142707f, -0.05717358f, 
    -0.05901682f, 0.00871945f, -0.02708304f, -0.05082062f, -0.00593126f, -0.04548901f, 0.01992684f, 0.00748923f, 
    0.00975356f, 0.02000412f, 0.00896684f, -0.02936882f, -0.01914191f, 0.01579308f, -0.02809273f, 0.00141224f, 
    -0.00115683f, 0.02250565f, -0.06543659f, -0.04599498f, -0.00097112f, 0.01254548f, -0.06526068f, -0.04656794f, 
    -0.02609428f, -0.00642676f, -0.00507366f, -0.04148667f, -0.03922097f, -0.03628716f, 0.02101175f, -0.03004840f, 
    0.04227032f, -0.00810540f, -0.02350810f, 0.02744245f, 0.03713359f, 0.06079747f, 0.06898287f, -0.05042216f, 
    -0.00039959f, -0.00287926f, 0.00579111f, -0.03469336f, -0.02166455f, -0.01709824f, -0.04400671f, 0.01955222f, 
    0.02411819f, 0.02011223f, -0.04268146f, 0.00555658f, -0.05994251f, -0.02871384f, -0.05159238f, -0.01635047f, 
    0.02233180f, -0.01021882f, 0.02352202f, -0.04136870f, -0.00411050f, 0.03081799f, 0.04020511f, 0.03579754f, 
    0.00829116f, 0.00317967f, 0.05080567f, -0.04276094f, 0.02527163f, 0.03718349f, 0.02734129f, -0.04359301f, 
    -0.02700030f, -0.01254022f, 0.01659098f, 0.02159538f, 0.01588628f, 0.01685861f, -0.01636897f, -0.05734799f, 
    -0.03232483f, 0.03889700f, 0.00042953f, -0.04257105f, 0.01799596f, -0.04407362f, 0.01163805f, -0.04664692f, 
    -0.06731193f, -0.03852181f, 0.03756339f, -0.02599888f, 0.01262297f, 0.03808635f, -0.04149325f, -0.03424872f, 
    -0.00516510f, 0.01228985f, -0.03847331f, -0.02363114f, 0.01666200f, -0.02798303f, -0.05417287f, -0.05559231f, 
    0.02612943f, 0.01660194f, -0.05673058f, 0.03454538f, 0.02368942f, -0.01930762f, -0.00591452f, -0.05825623f, 
    -0.04729978f, 0.01579299f, -0.03773440f, 0.01906472f, 0.00615385f, 0.04569414f, -0.01826663f, 0.00612092f, 
    -0.03427103f, -0.04455533f, -0.06499217f, -0.01134819f, 0.01653872f, -0.04870630f, 0.04043960f, 0.01256000f, 
    -0.01249309f, -0.06316010f, -0.02681057f, 0.04210995f, 0.03853589f, -0.01962614f, 0.02802601f, -0.00005104f, 
    -0.00462890f, -0.03356142f, -0.00612192f, -0.02570668f, 0.00569879f, -0.00917758f, -0.01342616f, -0.05918738f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.08375429f, -0.12088159f, 0.05600162f, 0.02581825f, 0.54190183f, -0.10298613f, 0.19558465f, 0.01678322f, 
    0.31925681f, -0.03599598f, 0.14841135f, -0.04843631f, 0.12685306f, -0.00980894f, 0.17584820f, 0.23768662f, 
    0.13710961f, 0.00239160f, 0.11542705f, 0.41602701f, 0.23514785f, 0.14348225f, -0.06913541f, 0.06128332f, 
    -0.00290852f, 0.21615145f, -0.00455957f, -0.35003138f, 0.31500083f, 0.06484276f, -0.07368480f, -0.02719335f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.29087037f, 0.30316743f, 0.13821039f, 0.47933012f, -0.59304792f, -0.05735097f, -0.20978031f, 0.01421371f, 
    -0.17404850f, -0.07743927f, -1.00421178f, 0.11535468f, 0.33802301f, -0.17740494f, 0.07092191f, -0.41615912f, 
    -0.45094934f, 0.00466778f, 0.14808519f, -0.69663835f, -0.09589946f, 0.10508189f, 0.22728319f, -0.02629342f, 
    -0.10614333f, -0.08166444f, -0.07685269f, 0.19070382f, -0.29322013f, 0.01681847f, 0.41805881f, 0.11967090f, 
    -0.20334063f, -0.03969936f, -0.08602645f, 0.45215327f, -0.03197809f, -0.24444252f, 0.44199693f, -0.13590732f, 
    0.19956885f, 0.15628597f, -0.30424654f, -0.12791017f, 0.31665051f, -0.07793795f, 0.05900861f, -0.08750088f, 
    -0.20715067f, -0.14178218f, -0.06720109f, -0.54473579f, 0.18593188f, 0.25665805f, -0.08712398f, -0.23551543f, 
    0.03412867f, 0.30384734f, -0.12464499f, -0.31283450f, 0.32331038f, -0.23682900f, -1.00854218f, -0.13613991f, 
    -0.07602046f, -1.09591508f, -0.14429452f, -0.38422769f, 0.28251356f, 0.19859177f, 0.83684003f, 0.13585916f, 
    -0.01348108f, -0.11531373f, -0.15130442f, 0.10022393f, 0.00510883f, -0.15749319f, -0.17827676f, 0.29286376f, 
    -0.20148493f, -0.06718753f, -0.54062629f, -0.29246885f, 0.15519135f, 0.53272891f, -0.26482558f, -0.52544242f, 
    0.11731496f, -0.13557759f, -0.02737899f, -0.28680590f, -0.84941357f, 0.19681163f, -0.03401379f, -0.12368122f, 
    -0.25068462f, 0.37331691f, 0.02684966f, -0.36520690f, -0.38910317f, -0.05205235f, 0.35041481f, 0.10353995f, 
    -0.37468764f, -0.12472935f, 0.24860510f, 0.03381469f, -0.13208079f, 0.07331911f, 0.21014662f, 0.30455995f, 
    0.12296753f, 0.14867200f, -0.47059754f, -0.54432052f, -0.08745221f, 0.34234726f, -0.20286821f, -0.04148281f, 
    0.04129878f, -0.44977707f, -0.10285378f, 0.47730961f, -0.29518458f, 0.09638350f, 0.52470994f, -0.10972045f, 
    0.31382030f, -0.05630111f, -0.50107288f, 0.32478875f, -0.23967363f, 0.11464932f, -0.01742360f, -0.02071531f, 
    -0.25995380f, 0.08845814f, -0.12600985f, -0.03352787f, -0.30854243f, -0.12839924f, 0.41392696f, -0.34738380f, 
    -0.15337902f, -0.10025021f, 0.38951704f, 0.22235136f, -0.10595643f, -0.41053855f, -0.00370367f, -0.70997357f, 
    0.02332574f, 0.24905722f, -0.05194381f, 0.29053345f, -0.10730461f, 0.07700601f, 0.14074826f, -0.03087695f, 
    0.06611372f, 0.14611486f, 0.18326573f, 0.09703270f, 0.08279691f, -0.12685956f, 0.03874505f, 0.12261427f, 
    0.00354253f, 0.06897620f, 0.61667883f, -0.09715018f, 0.23524329f, 0.10559814f, -0.53020215f, -0.30065760f, 
    -0.24173783f, -0.07154737f, 0.16906065f, 0.70654976f, -0.14011201f, -0.42000800f, 0.12732857f, 0.02632162f, 
    -0.12567478f, -0.08221862f, 0.03699732f, 0.21826591f, 0.08830104f, -0.22835146f, -0.59972686f, 0.09316247f, 
    -0.17581144f, -0.87138331f, -0.40853819f, -0.89644551f, 0.18840221f, 0.36095256f, -0.57280487f, -0.14406829f, 
    -0.12036391f, 0.01772903f, -0.66662842f, -0.18283509f, -0.13017868f, -0.13121769f, -1.18606949f, 0.03328645f, 
    0.44521850f, 0.03488017f, -0.09867092f, 1.11958730f, 0.06647510f, -0.14445905f, -0.26541555f, -0.14159694f, 
    -0.09798305f, -0.26029769f, 0.01036586f, -0.59751964f, -0.51135099f, 0.36319855f, -0.44550216f, 0.13899717f, 
    0.00234169f, -0.06903730f, -0.29633054f, 0.08658487f, -0.35531452f, 0.13832474f, -0.17502242f, 0.17045736f, 
    -0.29812393f, -0.00441615f, -0.10038700f, 0.04326601f, -0.18092348f, -0.08227094f, -0.07815112f, 0.50778484f, 
    -0.08602067f, -0.09697421f, -0.17500091f, -0.41092607f, 0.42748839f, -0.42938048f, -0.01549831f, -0.15544283f, 
    -0.11885305f, -0.32521626f, 0.10278752f, 0.21876374f, 0.51066178f, -0.31462497f, 0.30826142f, 0.16554551f, 
    0.21916400f, 0.20773761f, 0.32226670f, -0.49259406f, 0.22264083f, -0.42387912f, -0.68759143f, 0.11679194f, 
    0.27475771f, -0.00111704f, -0.10195485f, -0.14311627f, -0.34909981f, -0.04007459f, -0.10195845f, 0.54902291f, 
    0.29012495f, 0.02088775f, -0.52919155f, -0.31375250f, -0.26817042f, -0.10047488f, 0.26241881f, -0.12921894f, 
    0.09024800f, -0.62566149f, -0.10740863f, -0.36956742f, 0.38785523f, -0.26543301f, -0.19480915f, 0.07220786f, 
    -0.59549826f, -0.38898408f, 0.31405097f, -0.20471649f, -0.23530987f, 0.36620072f, -0.30892345f, 0.12315451f, 
    -0.13107328f, 0.07918455f, 0.19026242f, 0.11916318f, 0.06973686f, -0.17343463f, 0.87004954f, 0.06003069f, 
    0.27330321f, 0.11280566f, -0.29424441f, 0.35876015f, -0.09927574f, -0.78598100f, -0.56805986f, -0.35239545f, 
    0.14007202f, 0.00110210f, 0.13613479f, -0.28577065f, -0.20181860f, 0.17955928f, 0.19155559f, -0.04863438f, 
    0.34928864f, -0.53016633f, -0.14008251f, -0.61175454f, 0.26398399f, -0.29335180f, -0.15600954f, 0.14469512f, 
    0.12668757f, -0.05271076f, -0.27045405f, 0.11174656f, 0.25122046f, 0.07952224f, 0.03425437f, -0.58251214f, 
    -0.07009106f, -0.00355213f, 0.92664510f, -0.22903670f, -0.13763198f, 0.65269649f, 0.02330340f, 0.40361562f, 
    -0.15868732f, -0.32925940f, 0.00132329f, -0.09494582f, -0.44831991f, -0.36500779f, -0.12185180f, 0.05043729f, 
    0.05635593f, -0.59865600f, 0.08056740f, -0.57634181f, 0.06336038f, -0.16769120f, -0.02922380f, 0.00331005f, 
    -0.13825810f, 0.07483578f, 0.68474603f, -0.04449857f, 0.30782655f, -0.09596572f, -0.27972865f, -0.18797304f, 
    0.07214145f, -0.02004432f, 0.03967927f, -0.02246205f, -0.53663558f, -0.20672238f, -0.69645017f, 1.20220220f, 
    0.14199391f, 0.46929792f, 0.13617061f, 0.04000195f, -0.02364764f, 0.12682353f, -0.12522838f, 0.16407186f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.47242531f, 0.21599813f, 0.31585655f, -0.17960174f, -0.08002515f, -0.09363918f, 0.21044081f, -0.24167988f, 
    0.23731053f, 0.24526218f, 0.00989597f, -0.15214150f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
