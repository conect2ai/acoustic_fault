#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    1.16655517f, 1.07180381f, 0.81454498f, -0.24568836f, 0.56804621f, -0.64847082f, 0.04725706f, 0.25781333f, 
    -0.18955742f, -0.84406227f, -0.92751247f, -1.13879788f, -0.03712052f, -0.46137542f, 0.27880695f, -0.31532916f, 
    -0.14466111f, -0.69680876f, 0.57159197f, 0.60402322f, 0.92472768f, 0.34553337f, -0.45506486f, 0.81099641f, 
    -0.43990919f, -0.11931504f, -0.39185119f, 1.20135951f, -0.77246118f, -0.86246097f, -0.31520796f, -1.03892565f, 
    -0.32046753f, -0.19397894f, -0.21662569f, 0.16971540f, -0.92405313f, 0.92150104f, -0.34140268f, 0.62522542f, 
    0.10412839f, -1.07526124f, -0.10085134f, -0.03325867f, 0.36674199f, 1.35937703f, 1.10758913f, 0.11083498f, 
    -0.53271288f, -0.90567988f, 0.25522408f, -0.11247281f, 0.34020740f, 0.10641630f, -0.14906240f, 0.37175363f, 
    0.60825211f, -1.05717146f, 0.15064023f, -0.18572566f, -0.54579210f, -0.89953667f, -0.97852772f, 0.30672398f, 
    1.00965703f, 0.74411792f, 0.73094326f, 0.41023543f, 0.87266958f, 0.12060237f, 0.14094815f, 0.49336070f, 
    0.60227716f, 0.81031466f, -0.00826423f, 1.15349901f, -0.12774542f, -0.93427169f, 0.46995598f, 0.56431174f, 
    0.32671589f, -0.78209633f, -1.15020573f, -0.86944056f, -0.21590501f, 0.67043900f, 1.38927019f, 0.13027740f, 
    0.10740940f, 0.82519096f, -1.62478137f, -0.91298240f, 1.11411822f, -0.09937070f, -0.11282831f, -0.25031814f, 
    -0.04841669f, -0.23064536f, 0.21248454f, -0.04568587f, 0.04373601f, 0.72923291f, -1.09287381f, -1.05991900f, 
    0.27060306f, 0.24824248f, -0.14493759f, 0.27474049f, -0.19519264f, -0.90698510f, -0.89119470f, -0.68041927f, 
    -0.60730159f, -0.73561853f, 0.10941117f, 0.38439959f, 0.50956929f, 0.08818644f, -0.92424595f, 1.05432749f, 
    0.14404526f, 0.02280593f, 1.50273526f, 0.14566118f, -0.35834259f, -0.38694254f, -1.07382798f, 0.18990467f, 
    0.15587111f, 0.92065972f, 1.15651441f, 0.01809350f, 0.25566146f, -0.35111076f, -0.28211069f, -0.68779290f, 
    -1.01860762f, -0.56167293f, 0.01123364f, 1.00816131f, -0.85671747f, -0.11678243f, 0.11520516f, -0.28553262f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.39759934f, -0.59968543f, 0.68477196f, 0.28244153f, 0.22050466f, 0.39258510f, 0.44364706f, 0.24304403f, 
    -0.07546393f, 0.30263108f, -0.00914338f, 0.63749480f, 0.02059355f, 0.01884153f, -0.18821970f, 0.55523938f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.04459998f, 0.34176031f, 0.54054159f, -0.03228705f, -0.01299477f, 0.15762088f, -0.19226305f, 0.13821691f, 
    0.13984257f, -0.39701062f, 0.32676950f, -0.30149376f, 0.16895731f, -0.00575231f, -0.11601319f, 0.03372378f, 
    -0.10047922f, 0.20016240f, -0.04335569f, 0.32625586f, 0.49504527f, 0.01086391f, 0.15996148f, 0.19604422f, 
    0.37731728f, 0.08393256f, 0.07693817f, -0.32424247f, -0.12954970f, -0.20952038f, -0.17624542f, 0.15966891f, 
    -0.06412977f, 0.36423346f, 0.09064743f, -0.10856265f, -0.36528677f, -0.22714320f, 0.00319858f, 0.23600383f, 
    0.26047224f, -0.27266827f, -0.07316928f, -0.02678311f, 0.40548131f, 0.14619513f, 0.29457101f, 0.33632725f, 
    -0.31166613f, -0.34666750f, 0.03280212f, -0.34648427f, 0.17968106f, 0.00244784f, 0.04650254f, -0.13627340f, 
    0.51950580f, -0.01408288f, 0.35077325f, -0.28058890f, 0.20332298f, 0.52454460f, 0.31177932f, 0.16425827f, 
    0.09380951f, 0.08373936f, 0.12838094f, -0.14772137f, 0.34954801f, 0.20235020f, 0.02901251f, -0.26833901f, 
    -0.00369986f, 0.04843769f, 0.06765106f, -0.18169850f, -0.16256866f, -0.19394489f, -0.02812826f, -0.01517623f, 
    0.00646085f, -0.31902200f, -0.32292983f, -0.44545984f, 0.29518786f, 0.15832438f, 0.16115995f, 0.13156873f, 
    -0.16176929f, -0.13676368f, -0.34397182f, -0.52466857f, -0.44965738f, 0.25426269f, -0.19450395f, -0.10958437f, 
    -0.08551157f, 0.24813308f, -0.05237015f, 0.02902928f, 0.52949440f, -0.14734736f, 0.03063572f, 0.11339751f, 
    0.47654933f, 0.01390771f, 0.31800926f, 0.36729884f, -0.14656809f, 0.22890912f, -0.24368498f, 0.20189545f, 
    0.33599165f, -0.05417563f, -0.03127491f, -0.36930841f, -0.04088691f, 0.81054246f, 0.01518175f, -0.21675670f, 
    -0.06613710f, 0.20176470f, 0.04981158f, -0.04472158f, -0.14546117f, 0.04425967f, -0.07600296f, -0.78799790f, 
    -0.27640960f, 0.37988868f, 0.35161981f, -0.14673306f, 0.27012989f, -0.14086944f, -0.18531013f, -0.39685625f, 
    -0.53150409f, -0.89515144f, 0.21614434f, 0.16508545f, 0.27941403f, -0.09681877f, -0.02493983f, -0.13884504f, 
    -0.11745977f, -0.07899807f, 0.13085632f, 0.13162637f, 0.24629764f, -0.11449461f, 0.07254060f, -0.05210250f, 
    -0.17284986f, -0.50310838f, -0.21063143f, 0.41904393f, 0.17584811f, -0.13289627f, 0.06635618f, -0.28847709f, 
    -0.00651016f, 0.05258314f, 0.35772786f, 0.58795917f, -0.06383863f, 0.20153654f, 0.05084469f, 0.03384250f, 
    -0.22028959f, -0.00799353f, -0.31008649f, -0.23115322f, 0.28575429f, -0.26361722f, -0.09407737f, 0.09944575f, 
    -0.01790161f, 0.09011509f, 0.21504374f, 0.05434692f, -0.04094175f, -0.08132838f, -0.54556793f, 0.33455476f, 
    0.01757433f, 0.00354110f, 0.10458102f, -0.20677800f, 0.17624950f, -0.50772035f, -0.18652679f, 0.15711980f, 
    0.19210495f, 0.06933738f, 0.05728000f, 0.02732037f, -0.03646277f, -0.23214509f, -0.08025496f, 0.30825931f, 
    0.07815935f, -0.03341125f, -0.23418652f, -0.16073330f, 0.12657185f, 0.02491269f, 0.14459045f, 0.21371159f, 
    0.16348043f, 0.18699393f, 0.13785727f, 0.11410103f, -0.20474522f, -0.11803731f, 0.07592570f, 0.08419479f, 
    0.05570220f, -0.17170104f, -0.42863134f, -0.02401997f, -0.13101742f, -0.00772319f, -0.40120092f, 0.19091453f, 
    0.08425468f, -0.10595857f, 0.24133267f, 0.76140952f, -0.18087468f, 0.08375260f, 0.02386486f, -0.11478368f, 
    -0.02169035f, 0.02249240f, -0.09403978f, -0.20888640f, -0.13391764f, -0.16467810f, -0.01176185f, -0.22923164f, 
    -0.17397653f, 0.08105879f, 0.16276689f, -0.41694167f, -0.15486394f, 0.04427825f, -0.12841463f, -0.14077131f, 
    -0.21626073f, 0.11349241f, -0.19684865f, -0.07782564f, 0.17632614f, 0.62937421f, 0.00976857f, 0.31545612f, 
    0.08331306f, -0.30423042f, 0.41727990f, -0.10573310f, 0.06104418f, 0.11501044f, -0.10572091f, 0.16422962f, 
    -0.05549996f, -0.17778985f, -0.21254754f, -0.04945242f, -0.03425734f, -0.05949944f, 0.10883350f, -0.26768425f, 
    -0.07861432f, 0.04884325f, 0.04002371f, 0.14792164f, 0.14721593f, -0.13574663f, 0.06756761f, -0.11754160f, 
    -0.00774974f, 0.12009984f, 0.06603761f, 0.16687094f, 0.15828049f, -0.11931029f, 0.03860058f, 0.13437948f, 
    0.04772206f, -0.04305874f, -0.03198506f, -0.04242515f, -0.02494024f, -0.00866725f, -0.00622360f, 0.03537221f, 
    -0.05875061f, -0.08840848f, -0.05718007f, -0.05515119f, 0.01651455f, -0.06827909f, -0.00143394f, 0.03153666f, 
    0.01476410f, 0.01338675f, -0.04803840f, 0.00153823f, 0.04454893f, 0.01608180f, 0.04419951f, -0.00002099f, 
    -0.03447631f, -0.04467115f, 0.04249372f, 0.00251469f, -0.00773809f, -0.09117366f, 0.05729597f, -0.03482923f, 
    0.03928858f, -0.03710429f, 0.01894522f, 0.02507333f, 0.03359970f, 0.06358923f, -0.01456424f, 0.06903775f, 
    -0.04829990f, -0.03150701f, -0.02266491f, 0.04258163f, 0.00155590f, 0.01728395f, 0.05610207f, -0.01257315f, 
    -0.00944488f, -0.02151749f, -0.00718362f, 0.00311288f, -0.04777743f, -0.00860672f, 0.00806611f, -0.06391278f, 
    -0.01687896f, -0.03238840f, -0.01258862f, -0.01646748f, -0.07108705f, -0.05014034f, 0.01401566f, 0.03894994f, 
    0.04196927f, -0.01895974f, 0.03524708f, 0.00552297f, 0.06756589f, 0.02743891f, 0.06873305f, -0.08499011f, 
    -0.00297936f, -0.03007868f, -0.06827904f, -0.06783751f, -0.05107010f, 0.05308893f, 0.05803985f, -0.05038318f, 
    -0.08195215f, -0.02475572f, -0.04512994f, 0.05526969f, -0.08432878f, 0.00980212f, -0.06071406f, 0.02424868f, 
    0.01893108f, -0.06379097f, -0.03208513f, -0.01703468f, 0.01384974f, 0.04300490f, -0.07643136f, -0.08158278f, 
    -0.02234571f, -0.09769692f, 0.00309452f, 0.05019385f, -0.09005152f, 0.04221789f, -0.00185249f, -0.05005450f, 
    0.02202076f, 0.07468266f, 0.06147384f, 0.01209669f, 0.07251051f, -0.02504500f, -0.00404918f, -0.08288139f, 
    0.00243773f, -0.06178852f, -0.05487956f, -0.05638363f, 0.01704282f, 0.01936707f, -0.02219649f, 0.07005112f, 
    -0.04929603f, -0.08427984f, -0.07601164f, 0.06090736f, -0.02736837f, -0.03533649f, -0.01119872f, -0.05152062f, 
    0.02362381f, 0.05437036f, -0.09015671f, 0.03498251f, -0.03939539f, 0.01347848f, 0.00553421f, 0.00990428f, 
    -0.08156515f, -0.08566980f, 0.02336703f, 0.00392001f, 0.06760991f, -0.07272940f, 0.02082233f, -0.01447152f, 
    0.00579898f, -0.08447699f, 0.04048106f, -0.00536617f, -0.08820081f, -0.04180977f, 0.04621089f, 0.06077861f, 
    0.06053527f, 0.05518320f, -0.01772945f, -0.01180414f, 0.03767925f, 0.03805624f, -0.00841093f, -0.04756549f, 
    0.01642031f, 0.06438444f, 0.04806955f, -0.01034777f, -0.04981833f, 0.05958284f, -0.06844730f, -0.03661876f, 
    0.03714148f, -0.07831945f, -0.01079980f, 0.04687621f, 0.04828066f, 0.01533042f, 0.01882588f, -0.04151724f, 
    -0.04259318f, -0.05080485f, -0.03877297f, -0.07049398f, 0.00844628f, -0.06133848f, 0.02056580f, 0.01894092f, 
    0.04213497f, -0.01688390f, -0.09578327f, 0.05223621f, -0.09163304f, 0.06840873f, -0.05731336f, -0.02409645f, 
    0.04669164f, 0.00789366f, -0.04700070f, -0.02995080f, -0.00235916f, 0.05187998f, -0.02957561f, -0.06047478f, 
    0.04889770f, -0.08265864f, -0.03190416f, 0.05030745f, 0.06291042f, -0.03569033f, -0.03901635f, 0.03720565f, 
    0.05412119f, 0.01486186f, -0.02291058f, 0.04748644f, -0.05070683f, -0.02313307f, -0.01800386f, -0.06751975f, 
    -0.04859301f, -0.05282895f, -0.07095633f, -0.02128499f, -0.07509350f, 0.05239394f, -0.05956468f, 0.04210965f, 
    0.02918620f, -0.00737584f, 0.00748997f, -0.01535031f, 0.03426965f, -0.04992128f, -0.06705623f, 0.00707357f, 
    -0.00573495f, -0.07615996f, -0.09336420f, 0.04464260f, 0.00838395f, 0.05455001f, -0.00948438f, -0.07305331f, 
    0.01774462f, 0.00187271f, 0.01239584f, -0.06526423f, -0.09617450f, 0.04166825f, 0.06516369f, 0.05954392f, 
    -0.01763915f, -0.03945257f, 0.00913901f, -0.01939832f, 0.05396484f, 0.03060971f, -0.00962449f, -0.00378257f, 
    -0.04619606f, -0.02940848f, 0.06165709f, 0.03620826f, -0.02342900f, -0.03600486f, -0.03747952f, -0.06843500f, 
    -0.02865634f, -0.08870722f, 0.01706727f, -0.03955736f, 0.00581364f, -0.00771554f, -0.02535643f, -0.05794251f, 
    -0.03331723f, -0.06044722f, -0.04205715f, -0.03430039f, 0.03871561f, 0.02275711f, -0.08820707f, -0.00111068f, 
    0.00676503f, 0.03531615f, -0.09520074f, -0.07315024f, 0.03287914f, -0.05036923f, -0.09657640f, -0.01111174f, 
    0.25270891f, -0.30233979f, -0.10458135f, -0.15452486f, -0.14774719f, 0.24579999f, 0.04460511f, 0.11321190f, 
    0.17947668f, -0.04193835f, 0.06647474f, 0.66237909f, -0.22127059f, 0.02178591f, 0.14773075f, -0.14287600f, 
    0.10801405f, 0.50403714f, 0.05812496f, -0.12055583f, -0.24323595f, -0.01509281f, 0.00366398f, 0.23868981f, 
    0.12838343f, -0.13527279f, -0.13393518f, 0.59538811f, 0.08834852f, 0.00070952f, -0.22453919f, -0.08212750f, 
    -0.24094073f, -0.07913982f, 0.11592021f, -0.10532510f, 0.26132458f, 0.28052565f, 0.21276636f, 0.16433938f, 
    -0.17838027f, 0.18370047f, -0.24187738f, -0.01560639f, 0.04832211f, -0.03699898f, -0.19290490f, -0.21253680f, 
    -0.20035671f, 0.34747106f, -0.33687255f, -0.01992415f, -0.06567319f, -0.02839290f, 0.16119957f, 0.03646920f, 
    -0.24535942f, 0.02237038f, 0.00858997f, 0.29911649f, -0.16787705f, 0.24834727f, 0.13674133f, -0.24992831f, 
    0.06436131f, 0.29098821f, 0.11929201f, -0.11985243f, 0.14314139f, -0.03883623f, -0.10248108f, -0.29950383f, 
    -0.16653581f, 0.04064061f, 0.28054261f, -0.07191483f, 0.04267953f, -0.22162241f, -0.35966644f, 0.03860063f, 
    -0.22473225f, 0.15726414f, -0.36237273f, 0.12446108f, 0.18164517f, 0.03928411f, 0.09993336f, 0.00820137f, 
    -0.04194441f, -0.18306527f, 0.27744228f, -0.14212868f, -0.02176875f, -0.01096731f, -0.13199174f, -0.09775189f, 
    0.14487541f, -0.10762031f, -0.16753930f, -0.26991269f, -0.17802821f, -0.29776433f, -0.09189938f, -0.05434502f, 
    -0.12560885f, 0.19537938f, -0.04535038f, -0.10211973f, 0.29937470f, 0.01235343f, 0.24595642f, 0.06905540f, 
    0.11957057f, -0.01583077f, 0.33295375f, 0.06266341f, -0.11001061f, 0.26984730f, -0.28782412f, -0.18664910f, 
    0.03599045f, 0.02902528f, 0.19563320f, -0.11497895f, -0.15210965f, -0.04452044f, -0.08706388f, 0.24554929f, 
    0.53151250f, 0.30156863f, 0.18048234f, 0.07177376f, 0.01824241f, 0.20842366f, 0.11934735f, -0.03320421f, 
    0.02426714f, 0.38671982f, 0.22018649f, 0.02169798f, -0.14976685f, -0.17052883f, 0.02786019f, 0.17130338f, 
    -0.02794774f, 0.05533585f, -0.04692322f, 0.05710174f, -0.00645405f, 0.03520143f, 0.03530863f, -0.01155366f, 
    0.04314255f, 0.04648281f, -0.01504155f, 0.01600975f, -0.00561469f, 0.04153844f, -0.04505671f, 0.02063186f, 
    0.00297234f, -0.06632735f, -0.06161236f, 0.02393045f, 0.00159531f, -0.03588647f, 0.01999004f, 0.01943655f, 
    -0.06237742f, -0.05797925f, -0.01583973f, -0.02812747f, -0.00604468f, 0.06618271f, -0.04453826f, -0.02999725f, 
    0.03252826f, -0.00982348f, -0.04518233f, 0.03811148f, 0.01414266f, -0.01276797f, 0.04778141f, -0.02009340f, 
    -0.08781796f, -0.03369352f, 0.05342577f, -0.08582684f, 0.02008638f, -0.03342545f, -0.09258551f, -0.07512711f, 
    -0.08691300f, 0.02611125f, -0.01505372f, 0.02739009f, -0.00500592f, -0.08673568f, -0.00885292f, 0.01444756f, 
    -0.06661028f, 0.02146302f, -0.00779166f, 0.03833489f, -0.06142932f, -0.07569471f, 0.02258124f, -0.01560677f, 
    -0.02386033f, -0.07897164f, -0.03404934f, -0.04928447f, -0.02307714f, 0.05515424f, -0.02911288f, 0.05427947f, 
    -0.05053325f, -0.04982657f, -0.07928719f, -0.06351230f, 0.02553392f, -0.03323403f, 0.04593785f, -0.04319675f, 
    -0.02348538f, -0.02564828f, 0.03918771f, 0.02339617f, -0.01138911f, -0.01384589f, 0.00746838f, -0.03443926f, 
    -0.04272734f, -0.02137563f, 0.04109823f, -0.09785755f, 0.03805429f, -0.03363499f, 0.04979248f, -0.03142504f, 
    0.06219943f, -0.07527450f, -0.01189824f, -0.03699139f, -0.03691301f, -0.03672152f, -0.07848442f, -0.09428409f, 
    -0.01812637f, 0.03643326f, 0.06060136f, 0.02169988f, -0.03070979f, -0.01011646f, 0.00314822f, 0.06749484f, 
    0.02264484f, -0.06817563f, -0.02428353f, -0.05219576f, -0.07695883f, -0.07275853f, -0.06681118f, 0.07298245f, 
    0.02020763f, -0.09060183f, 0.06222630f, -0.06547829f, -0.02858538f, -0.03227507f, 0.00149880f, 0.04333076f, 
    -0.04933581f, -0.01626041f, 0.06046525f, -0.01677846f, 0.04741464f, 0.08159705f, 0.03470805f, -0.06601147f, 
    0.01600290f, 0.00116116f, -0.01314979f, -0.08055355f, -0.00564831f, -0.03887967f, -0.09045020f, -0.05368397f, 
    0.00753833f, 0.05795059f, -0.03613235f, 0.00210911f, 0.02448536f, -0.09231734f, 0.03918295f, -0.08368973f, 
    -0.06821208f, 0.05210963f, -0.04971362f, -0.01842371f, -0.01641296f, 0.05972398f, -0.04965842f, 0.04621449f, 
    0.01319272f, 0.03920567f, 0.06406412f, -0.05043453f, -0.04141156f, -0.02608220f, -0.05277996f, 0.03264087f, 
    0.06882476f, -0.08057656f, -0.08793578f, 0.00059369f, 0.00058201f, 0.00730550f, -0.04543890f, -0.03373982f, 
    -0.06292738f, 0.06048838f, -0.08995657f, -0.06079088f, -0.01408382f, -0.03939592f, -0.07118383f, -0.06083471f, 
    0.02065984f, -0.03340598f, -0.03527994f, -0.06019155f, -0.05814015f, 0.00177111f, -0.02406720f, 0.05465534f, 
    0.00239379f, -0.08934786f, -0.05193666f, -0.04172695f, 0.05095743f, -0.01592595f, -0.07068305f, -0.05745682f, 
    -0.02187835f, -0.02260081f, -0.08253018f, 0.02189874f, -0.01467900f, -0.00066343f, 0.05879878f, 0.00923562f, 
    -0.06669711f, -0.00960564f, 0.01642125f, -0.03319587f, -0.00985750f, 0.01237719f, 0.02231548f, 0.03530855f, 
    -0.04601156f, 0.00640581f, 0.05840523f, -0.06467676f, -0.07573161f, -0.05241203f, -0.07934890f, 0.04465296f, 
    0.03296423f, 0.04026894f, -0.04214598f, -0.03319279f, -0.03863827f, -0.01235156f, 0.03289086f, 0.01481349f, 
    0.03289014f, -0.03975994f, 0.01278992f, -0.06531629f, -0.05160229f, -0.07797372f, -0.01338342f, -0.08036418f, 
    -0.03370134f, -0.01714840f, -0.01230276f, 0.03657485f, 0.06889517f, 0.00072668f, -0.02291805f, -0.06782601f, 
    -0.03231815f, 0.01031307f, -0.03761098f, -0.00012471f, 0.01775979f, 0.04623321f, -0.08381908f, 0.05090776f, 
    0.05081508f, 0.04506790f, 0.01539459f, 0.02377616f, 0.03920672f, -0.09466196f, 0.02370580f, -0.09939963f, 
    0.04521014f, 0.00692766f, -0.02964685f, -0.08101068f, -0.01070775f, -0.02171514f, -0.03198450f, -0.07324937f, 
    -0.00868550f, -0.06222425f, -0.04399617f, -0.06575434f, 0.01651447f, 0.02869184f, 0.04258500f, 0.06594470f, 
    -0.05570688f, 0.01853264f, 0.06777127f, -0.05093511f, -0.02052007f, -0.05092912f, 0.06505701f, -0.04743248f, 
    0.02269099f, 0.05800043f, -0.05951171f, -0.09125789f, 0.06643772f, 0.06064816f, 0.03470626f, -0.07688223f, 
    -0.05820167f, 0.00670694f, -0.06574837f, -0.02927653f, 0.00642716f, -0.07850055f, 0.02499710f, -0.00169346f, 
    -0.03660849f, -0.09312336f, -0.06809834f, -0.09881068f, -0.09028750f, -0.08647769f, -0.09143318f, 0.00705860f, 
    0.06617633f, -0.04479539f, 0.00959312f, 0.01529141f, 0.06149495f, 0.05636993f, -0.05466539f, -0.06333482f, 
    0.02165546f, 0.06114418f, -0.08990345f, -0.05676019f, -0.00751807f, 0.00395475f, -0.09250873f, -0.03896767f, 
    -0.00988265f, -0.00457702f, -0.03603120f, 0.01649923f, 0.03125808f, -0.02143198f, 0.00146904f, -0.07724763f, 
    -0.00747118f, 0.06258878f, -0.04467000f, -0.00114247f, -0.00675733f, -0.01202475f, -0.01739124f, 0.03011400f, 
    0.05455834f, 0.04515277f, -0.02959225f, 0.05356439f, -0.06399906f, -0.02495317f, 0.03950520f, -0.08402736f, 
    0.05386421f, 0.02761695f, 0.03853177f, 0.04378141f, 0.02250066f, 0.06575541f, -0.03488812f, -0.02162365f, 
    0.00967507f, 0.05429490f, 0.06170604f, -0.09675533f, -0.07740913f, -0.07658391f, -0.04135339f, -0.06276833f, 
    0.00696746f, -0.07151300f, 0.01523378f, -0.07622533f, -0.03953106f, -0.00761313f, -0.00403861f, 0.05924176f, 
    -0.02807504f, 0.00020165f, 0.04724719f, -0.00191017f, -0.04117104f, -0.05173446f, 0.04615703f, -0.00643701f, 
    0.03526310f, -0.07340891f, 0.03573033f, -0.01399370f, 0.03927274f, 0.04750551f, -0.01377975f, 0.05336758f, 
    0.01515086f, -0.07405320f, -0.01862927f, 0.02480494f, -0.09630746f, -0.06275335f, -0.07618736f, -0.07464815f, 
    -0.04908350f, -0.00929823f, -0.05682957f, 0.04278077f, -0.08933490f, 0.01504397f, 0.04493604f, 0.06170857f, 
    -0.09566187f, 0.01942201f, 0.05661990f, -0.08691837f, -0.06783095f, 0.04288703f, -0.02908633f, -0.06850854f, 
    -0.04479673f, 0.03176700f, -0.05652525f, 0.02173750f, -0.05087781f, 0.00245223f, -0.06098789f, 0.06464374f, 
    -0.00269454f, -0.00091912f, -0.00058168f, 0.01629060f, 0.02161033f, -0.03658068f, 0.02462407f, -0.05785372f, 
    -0.03784581f, -0.07206856f, -0.08382582f, -0.02806749f, -0.09404112f, -0.02149913f, 0.05094440f, 0.04737368f, 
    0.02648349f, 0.07479669f, -0.03982753f, -0.06797735f, 0.00589012f, -0.00719045f, 0.05234907f, -0.05435860f, 
    0.04582767f, 0.01478267f, -0.02065689f, -0.02746339f, -0.09660316f, 0.03939256f, 0.04415520f, 0.02701252f, 
    0.05563713f, -0.00052396f, 0.06013283f, -0.01659704f, -0.01644221f, -0.08030945f, 0.03133829f, 0.01331861f, 
    -0.03299104f, -0.06761688f, 0.01051391f, -0.01554477f, -0.00254592f, 0.06523630f, 0.05150791f, 0.03190398f, 
    0.00678667f, 0.01723906f, -0.06077744f, 0.02543007f, 0.00563762f, 0.02235373f, 0.04565179f, 0.05566486f, 
    0.01160281f, -0.07541975f, -0.05363269f, -0.08765849f, -0.00240692f, 0.04509262f, -0.02515323f, -0.02858846f, 
    -0.00094184f, 0.02661921f, -0.06774312f, -0.02076509f, 0.06626195f, 0.03619175f, -0.07480414f, 0.05283924f, 
    0.01946492f, -0.06391075f, -0.00757658f, 0.06330368f, -0.05296448f, 0.06305517f, -0.03408743f, -0.00766997f, 
    -0.02633304f, -0.08618367f, -0.05260652f, -0.09134679f, 0.00425942f, 0.02312902f, -0.09872422f, 0.06328227f, 
    -0.02866250f, 0.05090371f, -0.02675267f, -0.00717846f, -0.00225638f, -0.04018912f, -0.01459180f, -0.07934825f, 
    0.04685259f, 0.05711708f, -0.00413900f, -0.09294273f, -0.06771367f, -0.05173659f, 0.05298681f, -0.08510541f, 
    -0.01072722f, 0.03833901f, 0.06077274f, -0.03920120f, -0.03258016f, -0.07366848f, 0.01555726f, 0.01805590f, 
    -0.03374731f, 0.01219466f, -0.08849030f, 0.06367300f, -0.01130745f, -0.05058994f, 0.01162612f, -0.03928389f, 
    0.05703617f, -0.08287621f, 0.05959737f, -0.08085593f, 0.00062876f, 0.01682946f, 0.05824596f, -0.04909885f, 
    0.02693574f, -0.07662890f, -0.06201917f, 0.02553215f, -0.06284232f, -0.00704624f, -0.00343163f, -0.02621526f, 
    -0.00311724f, 0.00878164f, 0.05329990f, -0.02095267f, 0.06497432f, -0.07206125f, -0.03781189f, -0.05124053f, 
    -0.06046809f, -0.02509874f, 0.06050307f, 0.02171682f, 0.06887975f, -0.06861544f, -0.07290573f, -0.06263836f, 
    0.06817795f, 0.02395773f, -0.49096441f, 0.36900869f, -0.07293513f, -0.04421186f, 0.00999827f, -0.05849762f, 
    0.28879246f, 0.09856857f, -0.49525586f, 0.05838675f, 0.06112738f, 0.13007240f, -0.03056309f, -0.25917023f, 
    0.15704031f, -0.01398400f, -0.23968334f, -0.30313754f, -0.08283065f, 0.15659299f, 0.31414074f, 0.10909038f, 
    0.01316179f, 0.07837725f, -0.04436154f, 0.03658364f, 0.23766351f, 0.53017622f, -0.09912189f, -0.21694089f, 
    0.00906256f, 0.32220784f, 0.08236261f, -0.21893658f, -0.07830041f, -0.59783238f, -0.30547890f, 0.20448986f, 
    -0.02237744f, 0.19228213f, -0.05642012f, -0.26918450f, -0.09618419f, 0.24894582f, 0.01335087f, -0.00117152f, 
    0.06803534f, 0.01131084f, -0.03091874f, 0.26494026f, 0.00792861f, -0.23817584f, -0.06489944f, -0.19730595f, 
    -0.32810849f, 0.13081086f, 0.03137087f, 0.14972691f, -0.02533873f, 0.05747500f, 0.06380296f, -0.34777671f, 
    -0.06851634f, -0.11716190f, 0.10378965f, -0.02616420f, -0.01267895f, -0.21024789f, -0.11450347f, 0.15195438f, 
    0.42983904f, -0.24596377f, -0.53163809f, -0.14898431f, -0.05263525f, 0.02467225f, 0.20707960f, 0.26071939f, 
    0.09216038f, 0.30525979f, -0.00450504f, 0.32326064f, -0.27878767f, 0.01705459f, -0.06242265f, 0.08207037f, 
    -0.02073915f, 0.13217171f, -0.49359608f, 0.03642068f, 0.33128497f, -0.05593197f, -0.18358456f, 0.07924602f, 
    -0.01563249f, -0.20974813f, 0.31034532f, 0.33507106f, 0.31555891f, -0.19423202f, 0.13595517f, -0.10468560f, 
    0.06992865f, 0.23024818f, 0.13436979f, -0.06385157f, 0.24939995f, -0.23200291f, 0.05796591f, 0.22545514f, 
    -0.19075234f, -0.14323722f, -0.11627828f, 0.14089295f, -0.04589519f, 0.04284808f, 0.35766837f, -0.10119406f, 
    0.25281385f, 0.16167633f, -0.08338708f, 0.03206819f, 0.33066559f, 0.03899168f, -0.21783285f, 0.02601833f, 
    -0.14675331f, -0.21886595f, -0.34418166f, -0.07672172f, 0.05991432f, 0.14052138f, 0.05787578f, -0.21072379f, 
    -0.19001368f, 0.00461524f, -0.10936231f, -0.18331496f, 0.15494466f, -0.22619411f, 0.19477153f, -0.10726314f, 
    0.20041448f, 0.36761457f, 0.13817175f, -0.15715882f, -0.02732302f, -0.03893256f, -0.03856045f, 0.05246192f, 
    0.11735421f, 0.05642388f, -0.02976936f, -0.42829111f, 0.21081284f, -0.01203272f, 0.17654479f, 0.15036701f, 
    -0.12161414f, -0.03794926f, 0.04952025f, 0.03549854f, 0.17156835f, 0.11289098f, -0.03698131f, -0.10276654f, 
    -0.13155368f, 0.07955597f, -0.15311001f, -0.14135878f, -0.46930319f, -0.05737329f, -0.17694853f, 0.17997162f, 
    0.00945718f, 0.08057659f, 0.03184336f, 0.04660063f, 0.52175504f, -0.11343492f, -0.30223584f, 0.13106370f, 
    -0.04236684f, -0.04756498f, -0.04887718f, 0.00139510f, 0.05908491f, 0.21852094f, 0.11428077f, 0.26171219f, 
    -0.14393041f, -0.30893463f, 0.08249117f, -0.02844421f, -0.04277854f, 0.19047743f, -0.15138094f, 0.13081048f, 
    -0.12284778f, -0.06997344f, 0.15000354f, -0.02797506f, 0.37238514f, 0.29254249f, -0.10943549f, -0.57053226f, 
    0.17026894f, -0.00989549f, 0.03809090f, 0.20513794f, 0.02445137f, 0.25410596f, -0.29416531f, -0.12169176f, 
    -0.28298864f, -0.44841179f, 0.16031398f, -0.24005005f, -0.14348519f, 0.00843620f, -0.23463368f, 0.14752248f, 
    0.03295915f, 0.13775000f, 0.64603275f, -0.58453846f, 0.15013438f, 0.00625131f, -0.03493680f, 0.24243994f, 
    -0.02769728f, -0.02596577f, -0.91052657f, -0.12618871f, 0.45356846f, -0.11580397f, -0.01203898f, -0.10070478f, 
    -0.17879908f, 0.08593417f, -0.01692374f, -0.24657099f, -0.20433217f, -0.22875144f, 0.02884497f, -0.25696620f, 
    -0.11409371f, 0.01529984f, -0.05562789f, 0.27579463f, -0.51830453f, -0.40470415f, 0.24539700f, -0.02521262f, 
    0.16467045f, -0.07383087f, 0.16177596f, -0.02269609f, -0.10598652f, -0.47096381f, 0.05697283f, -0.42088625f, 
    0.06796324f, -0.00201361f, 0.05455753f, 0.12391685f, 0.02731826f, -0.01638089f, 0.91276312f, 0.35904682f, 
    0.04051151f, 0.10960181f, 0.10053277f, -0.08482239f, 0.07502476f, -0.05076515f, 0.07277594f, 0.11767983f, 
    -0.13049886f, -0.19703911f, 0.01534873f, 0.32966617f, 0.24815781f, -0.04884851f, 0.01779290f, -0.22359063f, 
    -0.49658826f, -0.22719288f, -0.12031130f, 0.12229519f, -0.11108978f, 0.05902702f, -0.08173893f, 0.05531204f, 
    0.17126919f, 0.42754704f, 0.35592166f, 0.67255056f, 0.26818094f, -0.00728115f, 0.04529652f, -0.06689171f, 
    0.03206537f, -0.06273929f, 0.41590437f, 0.01707620f, 0.03439016f, -0.24388847f, -0.15519439f, -0.09625640f, 
    0.01000435f, -0.01383889f, 0.29556596f, 0.20765828f, -0.02823539f, -0.18582340f, -0.15499173f, 0.00474801f, 
    -0.08757861f, -0.29671004f, -0.02490569f, -0.13570365f, -0.42488879f, -0.05591393f, -0.14968787f, 0.20007087f, 
    0.02268713f, -0.09984379f, -0.27808338f, 0.00676539f, -0.28417134f, -0.38394415f, -0.01225335f, 0.02185484f, 
    0.11489999f, -0.33514196f, 0.05758127f, -0.17743844f, 0.17382069f, -0.19319849f, -0.05285355f, -0.19426797f, 
    0.14582245f, 0.10996108f, 0.13920777f, 0.20956881f, 0.06842347f, -0.06444131f, -0.10374802f, 0.17407927f, 
    -0.16437945f, 0.04390631f, 0.12032626f, 0.03339776f, -0.37449509f, -0.11610758f, -0.05264920f, 0.35729629f, 
    -0.18610699f, 0.34819844f, -0.08796994f, -0.22534110f, -0.26366910f, -0.32235652f, 0.26010996f, 0.28368226f, 
    -0.17981340f, 0.14839225f, -0.00305484f, 0.23615983f, 0.10616135f, 0.29998663f, 0.07969206f, 0.02356114f, 
    0.19514817f, 0.14287668f, 0.30489972f, 0.04185129f, -0.07356257f, 0.21701336f, -0.31869552f, 0.06513412f, 
    0.06546967f, 0.11486100f, -0.09881318f, -0.04899843f, -0.24750149f, -0.59301496f, -0.10991741f, -0.31666720f, 
    -0.21219474f, -0.05033484f, 0.08741748f, 0.18105336f, -0.19137248f, 0.30813554f, 0.37545145f, -0.04415491f, 
    0.07118606f, 0.20351250f, 0.04804337f, 0.10406162f, -0.20514527f, -0.11026356f, -0.23278837f, -0.26393637f, 
    -0.06251556f, 0.17361225f, -0.42716315f, 0.20941401f, -0.07285792f, 0.18850371f, 0.19432850f, 0.36687371f, 
    0.44356996f, 0.21609807f, 0.15704276f, 0.32666090f, 0.08074554f, 0.02339037f, -0.04143052f, 0.03409313f, 
    0.06453790f, 0.43952128f, 0.03010669f, -0.12975444f, -0.05446398f, -0.08071209f, 0.08280505f, -0.24934457f, 
    0.46712935f, 0.10649859f, -0.08285686f, 0.07699466f, -0.15914461f, 0.16594952f, -0.04987770f, 0.00953264f, 
    0.04334975f, 0.47394946f, 0.17275742f, -0.25323913f, -0.30387980f, 0.03607779f, 0.22300501f, -0.09983221f, 
    0.24369085f, 0.00807545f, 0.36547774f, 0.03271981f, 0.06750628f, 0.12456328f, -0.04330564f, 0.12899904f, 
    0.07650851f, 0.13422638f, -0.04722104f, 0.21257009f, 0.04424293f, -0.18566011f, 0.27687347f, 0.01029945f, 
    0.04020134f, 0.04871110f, 0.11139660f, -0.03422334f, -0.72300196f, -0.24539025f, -0.31291971f, -0.04414712f, 
    0.05768827f, 0.16515222f, 0.00761551f, -0.01138491f, 0.09992624f, 0.77141523f, 0.29174793f, 0.01459838f, 
    0.24447615f, -0.26621523f, 0.15263817f, 0.08598915f, -0.14054942f, 0.20463707f, -0.21912733f, 0.14020391f, 
    -0.60421562f, 0.07922242f, 0.02514052f, -0.05378753f, -0.03158342f, -0.19372161f, -0.14918928f, 0.25361872f, 
    0.14417627f, 0.01745209f, -0.15508811f, -0.17238311f, -0.09670690f, 0.05309591f, 0.21039693f, -0.15197632f, 
    0.00250420f, -0.28048578f, 0.13581060f, 0.09289970f, -0.07509904f, -0.13114919f, 0.13314371f, -0.15567681f, 
    0.13168874f, 0.33911592f, 0.47411659f, -0.03321584f, 0.21640350f, 0.08689829f, -0.00891360f, 0.11347929f, 
    -0.08781339f, 0.18486694f, -0.25946417f, 0.07720943f, 0.07553560f, -0.14317238f, -0.00356985f, 0.02655495f, 
    -0.03007568f, -0.06751748f, -0.23783796f, -0.13398968f, -0.13869558f, 0.01330437f, 0.00595642f, -0.07341390f, 
    0.03472134f, 0.07885797f, -0.22267894f, 0.08177214f, -0.03975756f, 0.18285438f, -0.37434751f, 0.09347052f, 
    -0.24412164f, 0.30710012f, -0.01942761f, -0.14592054f, -0.05498905f, -0.69056273f, -0.04496255f, -0.08821905f, 
    0.19067635f, -0.00454614f, 0.06667092f, -0.00427950f, 0.09325869f, -0.15912536f, -0.99487436f, -0.27432054f, 
    -0.25333911f, -0.13647409f, 0.26238185f, -0.21390210f, -0.10485265f, 0.03568283f, -0.06991684f, 0.16113745f, 
    -0.40074274f, -0.56128258f, 0.03170909f, 0.16787222f, 0.07950640f, 0.14280547f, 0.13015684f, -0.24289457f, 
    -0.55876344f, -0.55449241f, -0.05012832f, 0.05409751f, 0.04160112f, 0.23961607f, -0.11209485f, 0.03708022f, 
    -0.09096851f, -0.02501245f, 0.20802473f, 0.18958190f, 0.34854966f, 0.02198434f, 0.11468015f, -0.14565305f, 
    0.29533938f, -0.08903374f, -0.57871300f, -0.26726919f, 0.27115896f, 0.05346796f, 0.00140809f, 0.08364415f, 
    -0.07096742f, 0.04374431f, 0.19487253f, 0.51142389f, 0.48055434f, -0.40269181f, 0.00455789f, 0.08749877f, 
    -0.03793713f, -0.09647737f, -0.24944322f, -0.11998042f, 0.35279381f, -0.43655470f, 0.04501460f, -0.06696194f, 
    -0.10894807f, -0.02140551f, -0.17864172f, -0.06949869f, -0.15855861f, -0.14171182f, -0.98918509f, -0.04579186f, 
    0.10617856f, -0.00601558f, -0.17184804f, 0.15453726f, -0.12227892f, -0.05498343f, 0.12350880f, 0.31297886f, 
    0.26764670f, 0.08436912f, 0.24201082f, 0.21016164f, -0.07377923f, 0.15655521f, 0.09750467f, -0.36505833f, 
    0.29842040f, -0.02430313f, -0.02043948f, -0.21475625f, 0.19769306f, 0.15913449f, 0.07412291f, -0.11575133f, 
    0.25500134f, -0.07320832f, 0.01662148f, -0.26186407f, -0.19256325f, 0.07383619f, -0.04908042f, 0.11152387f, 
    0.06210661f, 0.30535772f, 0.46077746f, 0.10484762f, -0.08439280f, -0.06662045f, -0.31527060f, 0.12877339f, 
    0.36703983f, 0.06535711f, -0.46664226f, 0.16729075f, -0.09104487f, 0.00153080f, -0.19948605f, -0.13309026f, 
    -0.15027781f, 0.01977156f, 0.14594281f, -0.18265140f, 0.03334364f, -0.08011389f, -0.09234057f, 0.22641760f, 
    0.25502744f, 0.03154365f, 0.07827429f, 0.01733507f, 0.20257175f, 0.10943445f, 0.22308053f, -0.15379702f, 
    -0.13671899f, 0.05696200f, -0.08644290f, 0.01612826f, -0.01112258f, 0.51009011f, -0.10673556f, 0.04552049f, 
    0.03826619f, -0.03219364f, -0.10468229f, 0.02014514f, 0.15813076f, 0.18753952f, -0.08930522f, 0.13281548f, 
    0.11951658f, 0.09286225f, 0.10981272f, 0.01824575f, 0.18197322f, 0.11780541f, 0.21271008f, -0.04648818f, 
    0.24716069f, 0.17377011f, -0.22657847f, 0.18117528f, 0.02720604f, -0.12333669f, -0.12747031f, -0.32294258f, 
    -0.20738794f, 0.14765741f, -0.25451550f, 0.07546941f, 0.15708487f, 0.14000949f, -0.09641287f, 0.12214430f, 
    -0.07118820f, 0.02353373f, 0.21700926f, 0.36528519f, 0.07261749f, -0.14549530f, 0.03728192f, -0.02717708f, 
    0.21969904f, 0.03319168f, -0.09063555f, -0.23917608f, -0.50194818f, 0.17138085f, 0.11904386f, 0.01967688f, 
    0.12618637f, -0.03332517f, 0.27041444f, -0.38855886f, 0.01490418f, -0.41249534f, 0.06701411f, 0.09478433f, 
    0.30006304f, -0.20966589f, 0.09558721f, 0.03147852f, 0.06754882f, -0.09398862f, -0.63199955f, 0.06418207f, 
    0.11721282f, -0.24086426f, -0.01927524f, 0.23344055f, 0.17102896f, -0.30164310f, 0.29425114f, 0.30811721f, 
    -0.02614547f, 0.01855792f, 0.11018690f, -0.25261146f, 0.07558019f, 0.09991432f, -0.07606243f, 0.16913570f, 
    -0.34050870f, 0.08966482f, 0.19477721f, 0.26714158f, -0.20308006f, 0.03024764f, -0.13151018f, 0.05611689f, 
    -0.12017692f, -0.21294813f, 0.01995461f, 0.02389527f, 0.13627881f, -0.21708983f, -0.02343471f, 0.41150716f, 
    -0.16795138f, -0.23979682f, 0.12434894f, -0.17239890f, -0.14436935f, 0.03778045f, -0.08033071f, 0.00549925f, 
    0.07771858f, 0.80031884f, 0.38772991f, 0.23986895f, -0.04580577f, -0.24454395f, -0.08815458f, 0.00467676f, 
    -0.08336715f, 0.06489374f, 0.33857313f, -0.49287716f, -0.46693891f, -0.17819464f, -0.04343531f, 0.04503216f, 
    0.13792171f, 0.00904444f, 0.06377843f, 0.11478186f, 0.23801965f, -0.20321064f, 0.11700642f, 0.13666521f, 
    -0.00742207f, -0.10447481f, -0.03881368f, 0.16776243f, 0.33604345f, -0.24858777f, -0.23270586f, 0.28643054f, 
    -0.12057877f, -0.00194810f, -0.11095522f, 0.02167958f, -0.12806040f, -0.49752277f, 0.54357684f, -0.07311643f, 
    -0.08174093f, -0.05059395f, 0.00523449f, -0.08161794f, 0.13025959f, 0.02205042f, 0.73684967f, 0.35382771f, 
    -0.07778284f, 0.06681831f, -0.11853333f, -0.07842273f, 0.16951196f, 0.06666539f, -0.17937540f, -0.05144630f, 
    -0.33871979f, 0.08464812f, 0.07813480f, 0.28932151f, 0.00949629f, -0.00836990f, -0.13591178f, -0.30416679f, 
    -0.84436136f, 0.31529775f, -0.01179624f, 0.22085245f, 0.09144609f, -0.08028260f, -0.05753069f, -0.13477314f, 
    0.35597408f, -0.10288190f, -0.12643395f, 0.18538985f, -0.42621395f, -0.01538895f, -0.04958225f, -0.47017625f, 
    -0.12689170f, 0.18987092f, -0.80263090f, -0.00217856f, 0.07852477f, 0.17028743f, 0.09828851f, 0.23068851f, 
    0.08250128f, -0.15365279f, -0.03360360f, -0.03151399f, -0.24961671f, 0.14625560f, 0.05603927f, 0.07470572f, 
    -0.19607778f, 0.03533450f, 0.14219390f, 0.03666122f, 0.57464910f, 0.03996387f, -0.03134915f, -0.12291985f, 
    -0.06524667f, -0.10357340f, 0.10210096f, 0.04904670f, 0.14763275f, -0.36426976f, 0.22633661f, -0.27219284f, 
    0.16141313f, 0.05732050f, -0.12684955f, -0.02681197f, 0.09112826f, 0.24138327f, 0.11360352f, 0.27570057f, 
    0.50707066f, 0.00667520f, 0.08784158f, -0.03610467f, -0.02687190f, -0.12258393f, -0.18189524f, -0.88609594f, 
    -0.30022573f, -0.05076405f, -0.02191481f, 0.15431057f, 0.33268616f, -0.00347036f, -0.05241001f, -0.26923695f, 
    -0.43193814f, -0.10899859f, -0.51273406f, 0.04919618f, -0.24961613f, -0.02407790f, -0.01358609f, -0.00464064f, 
    0.08172714f, 0.23799628f, 0.22460222f, -0.30031693f, 0.25287855f, -0.14829592f, 0.08195033f, 0.16749160f, 
    0.26725987f, -0.09664007f, -0.11785565f, -0.07133528f, 0.07895231f, -0.32516870f, -0.23788324f, -0.15030269f, 
    0.16749358f, -0.16813953f, 0.11284308f, 0.50703192f, 0.20364976f, 0.31496748f, -0.25267220f, -0.14968373f, 
    0.12004577f, 0.09774312f, 0.17008470f, 0.09469135f, 0.22267015f, 0.12254825f, -0.13561872f, 0.28279087f, 
    -0.33607218f, -0.08443716f, 0.04397425f, 0.15659432f, 0.18617110f, 0.22953743f, -0.41770908f, 0.14897227f, 
    0.04350258f, 0.23826559f, -0.02104301f, -0.18820940f, 0.02212443f, -0.23457868f, 0.42090386f, 0.03874613f, 
    -0.27859014f, -0.06059634f, -0.13104828f, 0.28177267f, 0.09815129f, 0.38749573f, -0.12099573f, 0.02961409f, 
    -0.06107172f, -0.03106009f, -0.06216400f, -0.03898267f, 0.10045214f, 0.10688080f, 0.12307380f, -0.21379884f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.32403389f, -0.09769612f, -0.08351293f, -0.02258871f, -0.04972206f, -0.06263664f, -0.06207042f, 0.03338349f, 
    -0.07532130f, 0.09787431f, 0.20074025f, -0.12193491f, 0.06388267f, -0.00634319f, 0.08220012f, 0.38606730f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.26824951f, -0.47967175f, 0.10236824f, -0.01849513f, 0.17077579f, 0.16144805f, 0.19091342f, 0.18440613f, 
    -0.12730512f, -0.05054859f, 1.28731298f, -0.07324936f, -0.86253530f, -0.10047882f, -0.18115991f, 0.12061248f, 
    0.21220304f, -0.26484755f, 0.20344134f, 0.16660565f, -0.27106535f, 0.19507404f, -0.15527570f, -0.14002720f, 
    -0.22980995f, -0.49192673f, 0.36002097f, 0.29909754f, 0.57134062f, -0.03218622f, -0.09033880f, -0.36540782f, 
    -0.27123120f, 0.21318144f, 0.21880016f, 0.17564154f, -0.00636835f, -0.23705754f, 0.05310115f, 0.22226191f, 
    0.01540372f, 0.02372535f, 0.01328341f, -0.91822660f, -0.18404092f, -0.86343700f, 1.18170118f, -0.15320382f, 
    -0.54125541f, -0.40635180f, 0.15397307f, 0.02912106f, 0.15738691f, -0.25290251f, -0.10666043f, -0.06878317f, 
    0.21957879f, 0.36312798f, -0.15977919f, -0.69266635f, -0.66972560f, 0.86270547f, -0.25446355f, 0.37346077f, 
    0.08446939f, 0.41930243f, -0.01616397f, -0.04287169f, 0.37212855f, -0.18164228f, -0.07734491f, -0.08812989f, 
    -0.03531863f, -0.22182783f, -0.30262998f, -0.02110800f, -0.64502120f, -0.31113294f, -0.05028863f, 0.23386398f, 
    0.46287140f, -0.47273821f, -0.09106942f, 0.03644069f, -0.37893325f, 0.05899017f, -0.04207728f, -0.11551898f, 
    -0.23759009f, -0.39798471f, -0.01232891f, 0.67325503f, -0.13184385f, -0.20121171f, -0.17547591f, -0.18742765f, 
    0.43042636f, 0.09172557f, 0.23416716f, -0.06134003f, 0.03927901f, -0.20265980f, 0.07408873f, -0.13919087f, 
    0.01998463f, -0.69075239f, -0.21206138f, -0.41357335f, 0.49978372f, -0.22792664f, -0.62354952f, 0.28765276f, 
    -0.42416871f, -0.35017398f, 0.03881081f, -0.19618298f, 0.51427966f, 0.21388599f, -0.24204500f, -0.11302001f, 
    0.02650957f, -0.64110219f, 0.24253747f, 0.85945797f, -0.93996823f, 0.13825858f, 0.01818378f, -0.33883685f, 
    0.06854088f, 0.91448236f, 0.04119706f, -0.00541351f, -0.78361058f, 0.14835240f, -0.07787032f, -0.10160933f, 
    -0.22755741f, 0.42835015f, -0.43154782f, 0.04836688f, 0.53004956f, 0.41120341f, -0.45727941f, -1.26448810f, 
    0.47729763f, 0.02483699f, -0.11546273f, 0.09033881f, 0.27898452f, -0.08680326f, -0.22349855f, 0.06115856f, 
    -0.08492567f, 0.39255235f, -0.69981617f, 0.11113427f, -0.62761301f, -0.54255855f, -0.47248325f, -0.16503485f, 
    -0.42133451f, -0.19698402f, 0.18074679f, 0.06966163f, -0.65436482f, -0.04377314f, 0.03636764f, 0.10757172f, 
    -0.07354821f, 0.39250556f, -0.66750300f, -0.08357770f, -0.25824231f, 0.11952571f, 0.49167386f, 0.85935020f, 
    -0.48186848f, 0.02891112f, 0.07721677f, 0.11264080f, 0.53849828f, -0.02500094f, -0.09808211f, 0.11761858f, 
    -0.04930098f, 0.50217146f, -0.10511793f, -0.79023939f, 0.74997860f, -0.08501514f, -0.09296583f, 0.02090340f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.26512402f, -0.05287012f, -0.04675991f, -0.41169903f, 0.66827047f, 0.59951133f, -0.45773411f, -1.00834405f, 
    -0.70598572f, 0.37239963f, -0.00542047f, 0.00462691f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
